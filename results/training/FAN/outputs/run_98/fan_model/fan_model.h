/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.64546955e-01f, 9.60738510e-02f, 2.21401751e-01f, -2.01321632e-01f, -3.03220540e-01f, -2.62104303e-01f, -5.74502870e-02f, -1.69767171e-01f, -3.63534293e-03f, 1.09334830e-02f,
  -1.14644445e-01f, 1.35951772e-01f, 2.01329157e-01f, -1.27636790e-01f, 2.86164135e-02f, 3.29032600e-01f, -2.29160711e-01f, -4.91041876e-02f, 8.23370814e-02f, -1.97482333e-01f,
  1.71546843e-02f, -2.36849099e-01f, 1.25502586e-01f, -1.53356150e-01f, -1.97581753e-01f, -6.02604880e-04f, -4.05984856e-02f, 8.07653591e-02f, -1.85826033e-01f, -2.87627112e-02f,
  -3.22449300e-03f, 2.30864678e-02f, 3.54442075e-02f, 1.72617554e-03f, -1.10112756e-01f, -6.18700422e-02f, -3.32932249e-02f, 5.78674562e-02f, 6.12017093e-03f, 3.05977464e-03f,
  -3.98866832e-02f, -3.05305682e-02f, 1.27200438e-02f, 3.92188057e-02f, -1.13132872e-01f, 1.30143790e-02f, -2.19733380e-02f, 5.60507365e-03f, -3.26177962e-02f, 4.50237244e-02f,
  2.92154197e-02f, 5.81129156e-02f, -2.20849384e-02f, 1.93957072e-02f, 8.47661942e-02f, 2.91298181e-02f, 7.19695017e-02f, 5.88243008e-02f, 6.83158776e-03f, -8.70235264e-03f,
  -7.44006857e-02f, 8.16999450e-02f, 7.39945620e-02f, -2.96794884e-02f, -2.38012541e-02f, -3.42978537e-02f, 6.29354864e-02f, -1.73401795e-02f, 3.79387140e-02f, -1.05393240e-02f,
  -4.97873276e-02f, 3.11312079e-02f, -9.66712907e-02f, -2.02648044e-02f, 1.29652126e-02f, 1.34961754e-02f, 3.58591527e-02f, -2.79483497e-02f, -2.41169296e-02f, 3.85001826e-04f,
  3.48010613e-03f, -4.28574272e-02f, 2.19233148e-02f, -2.15877008e-04f, 3.86713967e-02f, 1.01349503e-01f, -9.64917243e-03f, 6.09863475e-02f, 5.54881897e-03f, -1.07014822e-02f,
  -1.72476724e-01f, -8.07393417e-02f, -1.39996717e-02f, -6.15165979e-02f, 9.24939811e-02f, -2.53610928e-02f, 3.71481702e-02f, -1.38628604e-02f, -1.64489187e-02f, -7.45932013e-02f,
  -6.96334094e-02f, 5.66331577e-03f, -3.96470651e-02f, -2.89685205e-02f, 9.88948252e-03f, 5.93973286e-02f, -6.54949173e-02f, -1.25272861e-02f, -7.21470639e-02f, -1.56611428e-02f,
  -4.72138710e-02f, -6.30012900e-02f, 1.23473275e-02f, -2.71227751e-02f, -9.75886881e-02f, -3.05638239e-02f, -1.19322032e-01f, 5.54736927e-02f, -4.47018854e-02f, 5.65170906e-02f,
  -5.15050888e-01f, 3.27009320e-01f, -2.46891528e-02f, 1.04411657e-03f, -5.69752343e-02f, 1.72763597e-02f, -7.66410306e-02f, -8.20731223e-02f, -2.90119916e-01f, 7.77844042e-02f,
  1.52441278e-01f, -1.55590490e-01f, 7.23779425e-02f, 2.61106580e-01f, 9.51103643e-02f, 1.07190073e-01f, 1.46099865e-01f, -1.07067458e-01f, 2.30846405e-02f, -3.63407061e-02f,
  -5.49381487e-02f, 2.26143748e-01f, 8.82438421e-02f, 1.54521853e-01f, -6.73742592e-02f, -7.46649429e-02f, 4.71546203e-02f, 1.99308004e-02f, 1.45871922e-01f, -7.10805180e-03f,
  -7.69799501e-02f, -1.29044384e-01f, -1.60934791e-01f, -8.25053155e-02f, -2.69951448e-02f, -9.68973786e-02f, -1.19084306e-01f, 2.80831419e-02f, 1.66327618e-02f, -2.95756161e-02f,
  -3.64690907e-02f, -2.11094152e-02f, 8.30471516e-02f, 2.30079778e-02f, -8.68185610e-02f, -9.76203755e-02f, 2.99151596e-02f, 6.53181598e-02f, -5.45930490e-02f, -1.68837197e-02f,
  1.49226775e-02f, 2.74414849e-02f, -7.77301863e-02f, 2.55305693e-02f, -2.29554009e-02f, 8.55245441e-03f, 3.96884121e-02f, -4.96844277e-02f, -3.51430736e-02f, -9.34591666e-02f,
  6.05175421e-02f, -8.78793895e-02f, -2.19777767e-02f, -3.24834958e-02f, 5.30385002e-02f, 3.95888872e-02f, -3.22371572e-02f, 3.59191410e-02f, -3.74648422e-02f, 5.97356558e-02f,
  7.27488548e-02f, -2.23631300e-02f, -5.98384142e-02f, -5.02553070e-03f, -2.99135260e-02f, -3.55979800e-02f, 3.26783322e-02f, -1.37150791e-02f, 5.33721074e-02f, -1.68490428e-02f,
  -6.32340983e-02f, 3.50710154e-02f, -2.22965647e-02f, -6.01825342e-02f, 2.22376585e-02f, 2.44900901e-02f, 5.04674092e-02f, -4.99955099e-03f, -4.00226675e-02f, 2.90636737e-02f,
  -4.58707213e-02f, -2.29385905e-02f, -6.66085333e-02f, -6.92024156e-02f, 3.60122137e-02f, -5.65411709e-02f, 1.52513031e-02f, 9.49695986e-03f, 3.22520621e-02f, -3.54995988e-02f,
  -9.30407569e-02f, -7.88504109e-02f, 2.37256065e-02f, -2.69351024e-02f, 4.82099205e-02f, 2.96326168e-02f, 4.43129763e-02f, -6.22351132e-02f, -6.39987290e-02f, -2.34049913e-02f,
  1.96952745e-02f, -4.56788205e-03f, 1.33795813e-02f, -6.65120706e-02f, 8.29630625e-03f, 4.24398743e-02f, -2.55335607e-02f, 3.78548019e-02f, 2.53491551e-02f, 5.07279225e-02f,
  1.61699131e-01f, -3.16891551e-01f, 3.43680292e-01f, 2.96162695e-01f, -4.50174622e-02f, 3.16786463e-03f, 1.45734474e-01f, -1.30140400e-02f, 8.84044841e-02f, -1.99390516e-01f,
  -8.24441854e-03f, -1.22397346e-02f, -1.45946980e-01f, 1.07488051e-01f, -6.78213015e-02f, -7.57428184e-02f, 1.23860002e-01f, -4.35764641e-02f, -1.83203444e-02f, 3.19216177e-02f,
  1.53457910e-01f, -1.76942945e-01f, 1.77326813e-01f, -1.39302313e-01f, 1.21039636e-01f, 1.74378350e-01f, -1.47878915e-01f, 3.77393924e-02f, 2.87089292e-02f, -3.24851163e-02f,
  -9.76812560e-03f, 1.18435055e-01f, 7.12855235e-02f, -7.88795575e-03f, 6.28800988e-02f, 9.06164665e-03f, 2.13511977e-02f, 1.99247394e-02f, 3.66304666e-02f, 6.20138757e-02f,
  -2.28973804e-03f, 9.69332643e-03f, 2.10917778e-02f, -1.21690938e-02f, -1.59276146e-02f, 2.27621831e-02f, 3.40373963e-02f, 1.11983843e-01f, 2.67050583e-02f, 8.26124027e-02f,
  7.12541342e-02f, 5.06809391e-02f, 9.21764746e-02f, 2.10355278e-02f, 2.19405871e-02f, 6.28990456e-02f, 9.92695093e-02f, 1.59405097e-02f, -3.73105295e-02f, -4.58909534e-02f,
  2.94612590e-02f, -1.08208917e-01f, -1.64331589e-02f, -8.97650234e-03f, 2.87324172e-02f, 7.12016746e-02f, -1.77165587e-02f, -3.01982854e-02f, 3.75249535e-02f, -1.86790768e-02f,
  2.79874802e-02f, -5.11979626e-04f, -5.50330579e-02f, 4.97126728e-02f, 2.01482046e-02f, 7.60205388e-02f, 5.26302494e-02f, -3.51418518e-02f, 4.95225675e-02f, -1.98194245e-03f,
  -5.77398948e-02f, 3.25926356e-02f, -2.89394427e-02f, 8.77309311e-03f, 2.67652189e-03f, -3.81825236e-03f, 6.76291585e-02f, 1.24349058e-01f, 2.59164982e-02f, 7.16824271e-03f,
  -3.40055436e-01f, -3.16727161e-01f, -1.02330469e-01f, -4.78868783e-02f, -5.58843054e-02f, -8.46472010e-02f, 1.78278387e-02f, -2.31012963e-02f, -7.94376433e-02f, -5.43464012e-02f,
  2.08830591e-02f, 4.70767133e-02f, 8.17866158e-03f, 3.66323814e-02f, -7.76414573e-02f, -3.49442139e-02f, -5.52867539e-04f, -9.50574875e-02f, -1.02561347e-01f, -5.78826554e-02f,
  -7.28308707e-02f, 3.47816665e-03f, 4.90782708e-02f, -4.63864356e-02f, -2.78263651e-02f, -2.64777485e-02f, -2.29336601e-02f, 3.99983674e-02f, 1.54377436e-02f, -2.48073917e-02f,
  -2.75775790e-01f, 9.45967734e-02f, 5.48540242e-02f, 2.38940865e-03f, 1.90681055e-01f, 1.09125078e-02f, -6.58124406e-03f, 1.72287285e-01f, 1.74235031e-01f, -1.29048526e-03f,
  7.79653043e-02f, -4.34170961e-02f, 2.67330674e-03f, 2.07701087e-01f, -3.01100165e-01f, 3.11669614e-02f, -1.09838936e-02f, -5.47669316e-03f, 9.97076705e-02f, 1.33568302e-01f,
  -3.56758051e-02f, 8.83114412e-02f, -2.59540100e-02f, 1.49955243e-01f, 2.19514966e-02f, -9.16666631e-03f, -2.03100085e-01f, -4.29925770e-02f, -5.59978187e-02f, -2.42258180e-02f,
  3.42098385e-04f, -1.13485657e-01f, 1.14998579e-01f, -7.22215772e-02f, -1.84602961e-02f, -6.12856727e-03f, -9.52560827e-02f, 2.00817734e-02f, 2.60356162e-02f, -1.52826933e-02f,
  1.93908662e-02f, -1.77035779e-02f, 4.56811562e-02f, 4.60436009e-02f, 9.68906935e-03f, 3.13845165e-02f, 2.31205598e-02f, 7.48265088e-02f, 7.43603632e-02f, -5.81022426e-02f,
  -5.79394680e-03f, -1.49668958e-02f, -2.86867246e-02f, 9.47727915e-03f, -8.45342651e-02f, -3.09332237e-02f, 7.41181821e-02f, -9.10984799e-02f, -1.53318420e-01f, -7.89542794e-02f,
  -7.77317733e-02f, 1.01555176e-02f, -2.83777025e-02f, 2.13139579e-02f, -8.31583291e-02f, 1.91973913e-02f, 1.04195261e-02f, -3.79148754e-03f, -3.17907805e-04f, -3.40461023e-02f,
  3.15991566e-02f, -2.82914061e-02f, -5.00462502e-02f, -4.34095487e-02f, -1.92321558e-03f, 2.78154444e-02f, -3.65879983e-02f, -3.18240258e-03f, 3.66648361e-02f, -6.78858720e-03f,
  -5.50565720e-02f, -3.34190540e-02f, 1.94046758e-02f, 4.04120944e-02f, -2.86476444e-02f, -6.05236553e-02f, 3.26818042e-02f, 4.26468849e-02f, 4.34243615e-04f, -4.77183312e-02f,
  -2.48248637e-01f, -3.85031879e-01f, 4.57783751e-02f, -6.29762858e-02f, -6.14315048e-02f, 4.37771939e-02f, 8.65140483e-02f, 5.33799827e-02f, -1.79983154e-01f, -9.74133238e-03f,
  -2.46624667e-02f, 4.02695350e-02f, -3.65366861e-02f, 3.75669748e-02f, -1.35652637e-02f, -2.33856142e-02f, 2.76682787e-02f, -8.29252899e-02f, -1.37277424e-01f, -1.50313042e-02f,
  -6.48925602e-02f, -3.32072861e-02f, 6.47475827e-04f, -1.36417029e-02f, 1.63779836e-02f, -5.67510724e-02f, -4.36436124e-02f, 5.81635088e-02f, -5.37964515e-02f, 6.46520630e-02f,
  1.04450837e-01f, -1.52901918e-01f, 6.73412010e-02f, 2.28422806e-01f, 1.08687624e-01f, -2.43797556e-01f, -8.32077637e-02f, 4.66123689e-03f, -1.32891357e-01f, -2.62211949e-01f,
  5.45636460e-04f, 1.94677189e-01f, -2.03319579e-01f, 5.81510775e-02f, 3.98615152e-01f, -1.49573073e-01f, 4.07903604e-02f, 1.33927800e-02f, 4.30798829e-02f, 1.22369811e-01f,
  1.79664403e-01f, 1.40277743e-01f, 1.72883555e-01f, 1.42893903e-02f, 5.37977256e-02f, -4.51758206e-02f, 1.94956020e-01f, 5.48711009e-02f, 4.43756906e-03f, 1.44522965e-01f,
  -1.59425065e-01f, -4.82953116e-02f, -2.92466599e-02f, 5.12488466e-03f, -2.90208776e-02f, -2.48240624e-02f, 3.03581823e-02f, 1.28130130e-02f, 1.41092297e-02f, -9.85046625e-02f,
  -2.30472628e-02f, 5.79901524e-02f, 4.07228135e-02f, 6.79307058e-02f, 1.62685942e-02f, -9.60735977e-03f, -6.27270490e-02f, -3.04577369e-02f, -2.40717288e-02f, 4.68670055e-02f,
  -6.00166731e-02f, -8.18953365e-02f, -5.44278882e-03f, -1.56392977e-02f, 6.14232086e-02f, -4.53661680e-02f, 1.80726722e-02f, 4.76344526e-02f, -7.52138495e-02f, 3.75416502e-02f,
  -5.66998795e-02f, 3.10440063e-02f, 2.69852392e-02f, -4.75063175e-03f, -3.75728644e-02f, 1.19744614e-02f, -1.32913105e-02f, 2.71976292e-02f, 2.33414397e-02f, -4.22857180e-02f,
  -2.95009650e-03f, 4.37362790e-02f, 1.83169525e-02f, 1.87511705e-02f, 2.24605668e-02f, -2.86103282e-02f, 3.79617848e-02f, -4.99201491e-02f, -5.94977755e-03f, 5.08499295e-02f,
  7.82071706e-03f, -4.40080538e-02f, -1.87247880e-02f, -4.02349867e-02f, -4.66024056e-02f, 2.93543115e-02f, 9.46670771e-04f, -1.53858745e-02f, -2.29757298e-02f, 9.12473351e-02f,
  -3.65241840e-02f, 1.28356397e-01f, -7.26662949e-02f, -7.11814826e-03f, -1.92104671e-02f, 5.11357598e-02f, 1.68023594e-02f, 2.41691284e-02f, -1.94102563e-02f, 2.80024167e-02f,
  6.21437915e-02f, -1.16248056e-02f, 2.11785063e-02f, -1.83398202e-02f, -2.14548167e-02f, -2.57493742e-02f, -4.33002738e-03f, 3.78252789e-02f, 3.97185162e-02f, 1.04297069e-03f,
  3.55588794e-02f, -4.15394194e-02f, -1.33770583e-02f, -5.50717786e-02f, -3.03886272e-02f, -1.52607355e-02f, 9.03168544e-02f, -3.59848887e-02f, 5.53283021e-02f, 1.77648570e-03f,
  3.09530854e-01f, 1.76853016e-01f, -7.73144215e-02f, -4.55358289e-02f, -5.61943324e-03f, 6.29227832e-02f, 2.12265268e-01f, -1.40779316e-01f, 9.23287943e-02f, 9.81442556e-02f,
  2.25146651e-01f, 1.10402972e-01f, 1.56439394e-01f, 2.41526157e-01f, -8.25847387e-02f, 2.31567279e-01f, -6.73652068e-02f, 1.39779136e-01f, -7.62334000e-03f, -4.62400317e-02f,
  -3.29022221e-02f, -1.21381529e-01f, -1.04071699e-01f, -3.27484369e-01f, 9.54151452e-02f, -2.06920847e-01f, -2.28186458e-01f, -1.72730505e-01f, -1.28785819e-01f, -2.05154363e-02f,
  9.29965749e-02f, 1.90907538e-01f, -2.17267200e-02f, -5.44655323e-02f, 3.38487476e-02f, 4.27687727e-02f, -5.78556992e-02f, -1.61638986e-02f, 2.67642848e-02f, -1.17506348e-02f,
  6.35076920e-03f, 2.89863162e-03f, 1.54417837e-02f, -2.95925811e-02f, 3.34767587e-02f, 2.66608819e-02f, 2.99048424e-02f, -4.22415994e-02f, -4.16935310e-02f, 1.39886275e-01f,
  5.34122959e-02f, 1.34293959e-01f, 7.78271332e-02f, -2.06252020e-02f, 5.40496409e-03f, 4.78644073e-02f, -7.81086367e-03f, 8.25849473e-02f, 6.90210685e-02f, 6.27025813e-02f,
  -5.62000833e-02f, -2.68805623e-02f, -2.94930371e-03f, 4.12176251e-02f, 1.07926406e-01f, 7.68698454e-02f, -6.94781356e-03f, 3.24068479e-02f, -4.47978899e-02f, 4.42132540e-02f,
  3.68970307e-03f, 5.70627712e-02f, 6.41479194e-02f, 4.19856086e-02f, 1.02458633e-02f, 1.98546946e-02f, -4.03654315e-02f, 4.37033772e-02f, 1.31025538e-02f, 2.32087970e-02f,
  2.51326673e-02f, -3.80419977e-02f, 7.16452450e-02f, -4.15116474e-02f, -3.11257765e-02f, 3.40934657e-02f, -1.32553903e-02f, 2.50604879e-02f, -3.75066027e-02f, -6.81766570e-02f,
  -8.11311454e-02f, -2.35601977e-01f, -1.00342266e-01f, 6.18679798e-04f, -8.14304203e-02f, 1.35558629e-02f, -1.27676837e-02f, 5.62428962e-04f, -7.57557824e-02f, -2.78902962e-03f,
  -9.44610164e-02f, -2.44575907e-02f, -3.82620059e-02f, 3.98038179e-02f, -6.70099035e-02f, 2.27294397e-02f, -1.62998643e-02f, -7.48688728e-02f, -1.59885019e-01f, -8.32701251e-02f,
  -1.96910240e-02f, -2.53706742e-02f, -7.00585619e-02f, -3.33841257e-02f, -1.36959739e-02f, 3.07664778e-02f, -3.26078455e-03f, 1.89717840e-02f, -8.05908293e-02f, -8.56530666e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.73414809e-01f, -6.25771165e-01f, 1.80929810e-01f, 4.77791160e-01f, 2.47284770e-01f, 1.87652744e-02f, 2.49367237e-01f, 1.86816964e-03f, 2.18683407e-01f, -4.75726694e-01f,
  -5.39517924e-02f, -4.20281813e-02f, -3.14789504e-01f, 3.93208005e-02f, 1.90657303e-01f, -2.60751575e-01f, 3.93984281e-02f, -9.36933160e-02f, 4.43722643e-02f, 1.62090901e-02f,
  1.64555207e-01f, -7.99179450e-03f, 8.05079713e-02f, -1.85351595e-01f, 2.00302005e-01f, 8.96191448e-02f, -1.24578528e-01f, -4.60356250e-02f, 5.70499524e-02f, 6.58052787e-02f,
  -8.47368017e-02f, 5.57269640e-02f, 6.51451200e-02f, -9.11901593e-02f, -3.11767180e-02f, 4.19215485e-02f, -6.65002782e-03f, 4.10795473e-02f, 1.28727525e-01f, 3.19092721e-02f,
  -6.24296851e-02f, 5.56609146e-02f, 4.32040580e-02f, 4.84333150e-02f, 5.61154224e-02f, 6.02409430e-02f, 8.23581517e-02f, -3.74877788e-02f, 2.83994135e-02f, 1.03876546e-01f,
  4.75635529e-02f, 1.14846358e-03f, 3.36878411e-02f, -3.67171466e-02f, 1.63935986e-03f, 5.42039275e-02f, 7.95253813e-02f, -2.84504835e-02f, -9.29478556e-03f, 7.51558319e-02f,
  -5.19696735e-02f, -5.82885519e-02f, 4.87661734e-03f, 2.67064106e-02f, 4.16899957e-02f, 1.09350167e-01f, 4.51918505e-02f, -2.36650053e-02f, 2.38092635e-02f, -7.99472034e-02f,
  7.73300901e-02f, -4.89041582e-03f, 1.22466413e-02f, 5.06679900e-02f, 4.81781065e-02f, 8.76345411e-02f, 1.13181742e-02f, 6.27883768e-04f, -5.44590950e-02f, 7.27273077e-02f,
  -5.67612574e-02f, 1.15870778e-02f, -5.31981587e-02f, 6.53521270e-02f, -7.51838461e-02f, -1.71500184e-02f, -3.44898328e-02f, 4.42707203e-02f, -5.81488013e-03f, 1.14944009e-02f,
  -4.76726979e-01f, -4.25611913e-01f, -1.36200294e-01f, -3.45168635e-02f, -7.64672384e-02f, -1.30268827e-01f, 4.21664529e-02f, -4.72262595e-03f, -1.07415967e-01f, 3.47135141e-02f,
  -1.03916246e-02f, 5.66485897e-02f, -1.48413489e-02f, 3.57968658e-02f, -1.11809187e-01f, -1.13960141e-02f, 1.53972423e-02f, -1.10475399e-01f, -5.50137348e-02f, -6.01212531e-02f,
  -4.28941473e-03f, -6.43604062e-03f, 2.96488758e-02f, 5.30404970e-02f, -4.58572134e-02f, -2.46907938e-02f, 5.64965792e-03f, -1.51138064e-02f, -7.30010914e-03f, -5.58011010e-02f,
  4.59340304e-01f, -3.98639411e-01f, -4.23945367e-01f, -1.21854298e-01f, 3.86645764e-01f, 5.07012963e-01f, 2.35643223e-01f, -6.17130287e-02f, -3.75490844e-01f, -1.94361463e-01f,
  1.41184762e-01f, -2.99681693e-01f, -2.18920350e-01f, -7.92818591e-02f, 2.85873473e-01f, -2.91258812e-01f, 2.41080560e-02f, 2.94074714e-02f, -1.54935330e-01f, 1.54349133e-01f,
  7.21335635e-02f, 3.02302361e-01f, -3.93562540e-02f, 1.75690055e-01f, 2.37448514e-01f, 8.97438452e-03f, 1.85757741e-01f, 1.17689595e-01f, 2.90121809e-02f, 1.85606226e-01f,
  -3.49778607e-02f, -1.54446647e-01f, 4.23620716e-02f, -9.86741483e-02f, 1.56786993e-01f, 2.39190757e-01f, 1.39484972e-01f, 3.10404524e-02f, -3.13656628e-02f, -7.60970414e-02f,
  -1.15943961e-02f, -9.37452614e-02f, -1.71003580e-01f, 7.61746913e-02f, 4.72523533e-02f, -2.17492338e-02f, -8.85631610e-03f, 1.19116716e-02f, -9.31743681e-02f, -6.83222115e-02f,
  -2.16039475e-02f, -2.04164326e-01f, -8.29713717e-02f, -1.39351726e-01f, -1.07430682e-01f, -4.21283804e-02f, -5.31659182e-03f, -3.82665806e-02f, -2.17696264e-01f, 6.20713457e-02f,
  1.25411181e-02f, 1.00886874e-01f, -4.47873808e-02f, -1.88439131e-01f, -2.31250878e-02f, 3.02419830e-02f, -3.28883380e-02f, -1.38228253e-01f, -3.24756242e-02f, 9.76895615e-02f,
  -1.08658792e-02f, -4.85368958e-03f, -7.61499256e-02f, -1.02137048e-02f, 4.47090417e-02f, 8.30930658e-03f, 6.76644370e-02f, 6.28387406e-02f, 2.15425417e-02f, 6.82969624e-03f,
  2.23414344e-03f, 3.00124828e-02f, 1.51389122e-01f, -7.67640322e-02f, -7.97818005e-02f, 4.80217487e-02f, 8.42796639e-03f, -3.60855572e-02f, 2.75110025e-02f, 6.79053878e-03f,
  -1.03731178e-01f, -1.59486189e-01f, -3.42663005e-02f, -3.17363814e-03f, -3.42680961e-02f, 8.44813660e-02f, -9.73685365e-03f, -1.05432741e-01f, 2.24293061e-02f, -2.53916532e-02f,
  9.71968248e-02f, 8.44392255e-02f, -1.01726457e-01f, -2.61661634e-02f, -1.58171710e-02f, 3.30996402e-02f, 2.16798130e-02f, -5.11535536e-03f, 4.46162112e-02f, -5.83148152e-02f,
  -7.76372999e-02f, 7.92525616e-03f, -8.00778791e-02f, 2.74391398e-02f, -1.02095447e-01f, 4.06674035e-02f, -4.04914748e-03f, -8.93842895e-03f, -8.22503120e-03f, -1.87357545e-01f,
  1.90452170e-02f, -1.53884038e-01f, -1.37359574e-01f, -3.46235573e-01f, -4.18075807e-02f, -8.73971730e-02f, -3.45150292e-01f, -1.41369790e-01f, -1.56970739e-01f, 3.88759025e-03f,
  -1.64974913e-01f, -1.39765114e-01f, -5.22812754e-02f, -3.06954086e-01f, -3.90333845e-03f, -1.24019878e-02f, -1.92964613e-01f, -2.24997550e-01f, -1.13325585e-02f, -2.34017506e-01f,
  -8.74904618e-02f, -3.12891483e-01f, -1.00917131e-01f, -1.17406674e-01f, -1.90386817e-01f, -3.05016562e-02f, 2.01274022e-01f, -1.84114367e-01f, -9.31232721e-02f, -1.60016030e-01f,
  -1.55365631e-01f, -9.17228013e-02f, -1.30945712e-01f, 2.05473136e-02f, 3.31776701e-02f, 1.22854579e-02f, 9.79630798e-02f, -7.84428865e-02f, -9.25216824e-02f, -2.08447147e-02f,
  3.91629003e-02f, -4.74658748e-03f, -7.73880780e-02f, -1.59145687e-02f, -7.34687001e-02f, -1.55063309e-02f, 6.96938392e-03f, 1.38528243e-01f, -9.79009941e-02f, -3.19614224e-02f,
  -1.60095409e-01f, 1.01575881e-01f, 6.76760674e-02f, -3.17231156e-02f, -6.61195721e-03f, -5.17525002e-02f, 3.49743217e-02f, -5.35690933e-02f, 5.12334928e-02f, 2.12786421e-02f,
  1.55299352e-02f, 7.75069743e-02f, 1.56532712e-02f, 3.70344184e-02f, -5.66363595e-02f, -1.44135533e-02f, 7.91452453e-03f, -1.94454882e-02f, 1.75510976e-03f, 1.88751295e-02f,
  2.09147334e-02f, 5.57827810e-03f, -3.14776897e-02f, -2.31409632e-02f, 2.91366712e-03f, 9.50111896e-02f, -3.84724475e-02f, 1.79192964e-02f, -8.84293020e-02f, 9.89135355e-02f,
  -2.98134554e-02f, -8.90973490e-03f, -1.05685666e-01f, 5.47726415e-02f, 5.48294820e-02f, 3.99718340e-03f, -1.89910866e-02f, -1.39417779e-02f, 1.46401301e-01f, 5.67544177e-02f,
  4.40852344e-02f, 4.76729125e-02f, -1.50998840e-02f, -5.07019535e-02f, -3.03037092e-02f, 6.31416440e-02f, 3.67548354e-02f, -8.23246539e-02f, -4.18050364e-02f, -8.92024022e-03f,
  5.97660430e-02f, -2.79439855e-02f, 2.29713619e-01f, -6.67323843e-02f, -5.53426221e-02f, -9.28624533e-03f, -6.05293736e-02f, 6.68481141e-02f, 5.22866957e-02f, 4.64110747e-02f,
  -3.21624763e-02f, 4.74234298e-02f, 9.04439250e-04f, -4.25775610e-02f, 8.29605572e-03f, 4.56391312e-02f, 9.24359933e-02f, -6.32640868e-02f, 3.20388228e-02f, -3.82951996e-03f,
  -6.21326342e-02f, -1.61223598e-02f, 3.51045489e-01f, 3.34740698e-01f, -4.74536002e-01f, 1.87200204e-01f, 5.28562427e-01f, -3.56893986e-01f, 1.26793399e-01f, 9.04480517e-02f,
  -1.56106815e-01f, 3.30167860e-01f, 2.12642685e-01f, 1.91074327e-01f, -2.29819678e-02f, 3.03056866e-01f, 3.04819494e-01f, 2.36599684e-01f, -9.89148393e-02f, 3.16619896e-03f,
  -7.37265423e-02f, -1.98645145e-01f, 1.70092389e-01f, -3.67182434e-01f, -3.89566422e-02f, -1.16198614e-01f, -1.70889109e-01f, 2.35968805e-03f, -6.95816725e-02f, -1.81500480e-01f,
  -1.77168757e-01f, -1.55097589e-01f, 6.52127638e-02f, -7.97633082e-03f, -5.91844469e-02f, 5.94952218e-02f, 9.24454033e-02f, 1.30842909e-01f, -3.04199923e-02f, -5.99666778e-03f,
  1.10024303e-01f, -1.20886683e-01f, -1.10577323e-01f, 8.77847895e-03f, -6.03627600e-02f, -7.64020681e-02f, -8.13607872e-02f, -2.42545493e-02f, -2.02596351e-03f, -1.36817200e-02f,
  1.10589273e-01f, -2.54450142e-02f, 1.88108552e-02f, 2.34672576e-02f, 3.86010669e-02f, 2.04051994e-02f, 1.76172063e-01f, 8.93514231e-02f, 4.85793278e-02f, -9.30990428e-02f,
  6.55703545e-02f, 6.53080363e-03f, -2.50161849e-02f, -4.39350270e-02f, -9.52561293e-03f, -9.74905640e-02f, 5.17480895e-02f, -1.23577245e-01f, 3.23883095e-03f, -7.53044058e-03f,
  -5.05043268e-02f, -1.66009851e-02f, -8.58290792e-02f, -2.15815660e-02f, -3.40035595e-02f, 7.70401210e-02f, 1.29931375e-01f, -8.26873928e-02f, -3.90499793e-02f, -7.97000974e-02f,
  3.20652388e-02f, 7.06326365e-02f, -1.05979573e-02f, -3.90078463e-02f, 5.36958054e-02f, -6.11578263e-02f, -8.91573429e-02f, 2.89749764e-02f, 3.75738069e-02f, -6.76153824e-02f,
  -1.99388146e-01f, -1.29573897e-01f, -3.70708443e-02f, -6.78201690e-02f, 6.60516694e-02f, -5.95897771e-02f, 1.99802946e-02f, -6.29675314e-02f, 3.64361294e-02f, 4.56833616e-02f,
  -4.12142947e-02f, 1.01252645e-02f, -5.58524244e-02f, 8.10958259e-03f, 1.67860668e-02f, -7.55572245e-02f, 9.61011425e-02f, 2.07096781e-03f, -3.69886085e-02f, -1.16527528e-01f,
  3.07315640e-04f, 7.70842284e-02f, -5.27817309e-02f, -1.03933886e-02f, 6.90222578e-03f, -3.01560182e-02f, -1.15185939e-01f, -6.33427268e-03f, -1.25402197e-01f, 8.46922770e-02f,
  1.66975245e-01f, 4.84657437e-01f, -5.07952878e-03f, -3.48456688e-02f, -3.61952838e-03f, 6.01304412e-01f, 2.62960315e-01f, -6.04799890e-04f, 4.83737998e-02f, 2.91595846e-01f,
  -1.84780017e-01f, 1.57383189e-01f, -9.31008980e-02f, 5.64468764e-02f, 1.48861438e-01f, 1.49582475e-01f, 2.83923686e-01f, 1.64027870e-01f, -2.05938127e-02f, 2.02144325e-01f,
  -3.99051532e-02f, 1.63146272e-01f, -3.11500847e-01f, -1.61258392e-02f, 4.64014448e-02f, -1.67011455e-01f, -2.65654445e-01f, -2.01985717e-01f, -2.87056938e-02f, -3.00039798e-02f,
  -1.10334955e-01f, -8.08703899e-02f, 2.98185274e-02f, 8.90258253e-02f, 5.06477244e-02f, 3.07576247e-02f, 4.68532834e-03f, 5.87989241e-02f, -1.69600546e-01f, -6.29704818e-02f,
  1.86470225e-01f, -8.00872445e-02f, 1.45059168e-01f, -1.21175209e-02f, 5.20545766e-02f, 3.50611210e-02f, 3.05708013e-02f, 1.18554372e-03f, 2.46441942e-02f, 2.35047899e-02f,
  6.40800148e-02f, 2.08157357e-02f, -3.63391563e-02f, 4.59211459e-03f, -7.39674047e-02f, -1.67812817e-02f, 5.16058169e-02f, 9.12419334e-02f, 1.54906377e-01f, 1.05618194e-01f,
  3.37674879e-02f, 2.91574914e-02f, 1.38466001e-01f, 5.06293811e-02f, -2.45692208e-02f, -7.97710866e-02f, 3.02498210e-02f, -1.55328557e-01f, 1.46228094e-02f, 6.70112371e-02f,
  -4.85532135e-02f, -2.58002672e-02f, -4.24706563e-02f, 7.44671449e-02f, -2.20067203e-02f, 1.04753241e-01f, 1.33637199e-03f, 9.85609461e-03f, -1.25183165e-02f, 2.20183749e-02f,
  -1.20284051e-01f, 2.73635332e-02f, 1.91138145e-02f, -9.65741798e-02f, 7.56973727e-03f, -9.91282836e-02f, -4.58487198e-02f, -4.67320979e-02f, -1.24365352e-01f, 7.96925724e-02f,
  1.55825108e-01f, 4.06940043e-01f, -3.79118249e-02f, 5.99833056e-02f, 5.94067089e-02f, 5.97715713e-02f, 1.06125966e-01f, 8.74988586e-02f, 6.73969239e-02f, 9.31692719e-02f,
  1.20314263e-01f, 2.86953393e-02f, 1.01837657e-01f, -1.48462892e-01f, -2.74780877e-02f, 2.41069332e-01f, 2.58828346e-02f, 1.29931960e-02f, -8.64428096e-03f, -6.75403699e-02f,
  1.93842668e-02f, 6.82825297e-02f, 1.03102632e-01f, 5.44895343e-02f, 8.93066227e-02f, -6.22576009e-03f, 1.74994797e-01f, -4.69741784e-02f, 1.08696230e-01f, -6.78608716e-02f,
  -7.30774403e-01f, 3.97085845e-01f, 8.82779583e-02f, -3.06553185e-01f, -3.19079943e-02f, 1.20189130e-01f, 1.21525535e-02f, 3.65896188e-02f, -1.82443753e-01f, 2.80335337e-01f,
  3.52553092e-02f, -2.64437377e-01f, 2.38280460e-01f, 1.01162843e-01f, -2.77442604e-01f, 3.53540987e-01f, 4.28910777e-02f, -1.22000784e-01f, -1.92612186e-02f, -1.43360198e-01f,
  -1.61257327e-01f, -6.62879422e-02f, 1.30073428e-01f, 8.03116113e-02f, -7.07592294e-02f, -1.15953162e-01f, -4.75657396e-02f, 8.03208444e-03f, -3.84755023e-02f, -6.89594522e-02f,
  -1.34409383e-01f, -2.48354644e-01f, 1.17951278e-02f, -6.40635658e-03f, -9.45047289e-02f, -2.21075956e-02f, -1.03444988e-02f, -7.01414868e-02f, -8.53514448e-02f, -1.92982238e-02f,
  -6.52917549e-02f, -3.47026624e-02f, -5.74706681e-02f, 8.87469214e-04f, -7.22266585e-02f, 9.30427201e-03f, 1.37733981e-01f, 1.34567559e-01f, 3.20050213e-03f, 8.73328075e-02f,
  9.12892744e-02f, 8.69848728e-02f, 6.72136322e-02f, 3.38526219e-02f, 5.91703504e-03f, 3.68184634e-02f, 7.51911998e-02f, 2.87292134e-02f, -3.88822593e-02f, -8.48036185e-02f,
  -1.76909287e-02f, -1.07839145e-02f, 1.16435535e-01f, -5.51824085e-02f, -2.13201046e-02f, 1.07114632e-02f, -4.20615934e-02f, -5.48748821e-02f, -3.25782900e-03f, 1.25175687e-02f,
  -6.19113818e-02f, 1.59257278e-02f, -3.06206290e-02f, 2.47193803e-03f, 7.33122043e-03f, -2.34601889e-02f, 7.34850243e-02f, -6.32113218e-02f, -7.42407367e-02f, 5.05133756e-02f,
  -2.50420421e-02f, 1.34216985e-02f, -1.10686095e-02f, 6.37910664e-02f, -3.42351221e-03f, 8.76262411e-03f, 2.70224009e-02f, 1.11757211e-01f, 4.69611026e-02f, -1.00074209e-01f,
  -3.15952867e-01f, -3.49042982e-01f, -2.67109703e-02f, -1.19106680e-01f, -4.91407402e-02f, 4.20770682e-02f, 5.97675666e-02f, 2.93400791e-02f, -5.07811271e-02f, -5.24266623e-02f,
  -2.71278545e-02f, 1.05594089e-02f, -6.34714812e-02f, -5.84499352e-02f, -1.71816461e-02f, 3.81435156e-02f, -2.73601823e-02f, -4.97988686e-02f, -1.35109887e-01f, -7.72144124e-02f,
  -1.45825064e-02f, -6.21023476e-02f, 2.20459308e-02f, 1.57672334e-02f, -2.79786214e-02f, -5.91552705e-02f, -1.21584140e-01f, 3.50737944e-02f, -2.32055634e-02f, 3.73839922e-02f,
  1.43462732e-01f, 1.88442208e-02f, -4.04830426e-01f, -1.25990599e-01f, -7.46002197e-02f, -5.64286351e-01f, -3.15765440e-01f, -1.61310777e-01f, 1.79778233e-01f, 1.99983090e-01f,
  2.77964056e-01f, 9.71029922e-02f, 3.12059909e-01f, 9.10844281e-02f, -2.38335699e-01f, 2.19525680e-01f, -4.18065786e-01f, -1.73096061e-01f, 1.07253604e-01f, -1.48152784e-01f,
  -8.43223184e-02f, 2.31649294e-01f, -1.34152129e-01f, -2.90426920e-04f, -5.18245734e-02f, -7.42634311e-02f, -1.32701034e-02f, 1.02597840e-01f, -1.55897751e-01f, 3.77371199e-02f,
  -5.07148020e-02f, 3.24571013e-01f, -7.78197274e-02f, 3.69860120e-02f, -1.14392079e-01f, -1.79031715e-01f, -1.03306554e-01f, 1.26581797e-02f, 1.05250984e-01f, 2.98450212e-03f,
  1.62168629e-02f, 1.21755719e-01f, -2.25268677e-02f, 2.09635094e-01f, -3.47558148e-02f, 7.99670257e-03f, -8.62743147e-03f, -5.52522242e-02f, -2.25446392e-02f, -1.61651205e-02f,
  -1.12756602e-02f, -1.03012487e-01f, -9.17270705e-02f, 2.06120461e-02f, -8.29716120e-03f, 1.21078558e-01f, -1.69011027e-01f, -1.81854218e-02f, -5.15952744e-02f, 2.42497306e-02f,
  1.02974959e-01f, 7.87754953e-02f, -4.04243544e-02f, 9.81054753e-02f, -2.43244600e-02f, -6.23131320e-02f, -4.24388684e-02f, -1.46579415e-01f, 4.50714901e-02f, -2.54615545e-02f,
  -2.06996322e-01f, -3.34467329e-02f, 1.31737679e-01f, -2.92933043e-02f, -1.70970187e-02f, 5.31428214e-03f, -3.86452377e-02f, 6.27688393e-02f, -1.01546131e-01f, -2.39212513e-02f,
  1.63168743e-01f, 3.82932499e-02f, -1.07462448e-03f, -7.56614655e-02f, -3.38882692e-02f, 2.03649566e-01f, 4.41675745e-02f, 3.54520455e-02f, -1.08976588e-01f, -1.67727202e-01f,
  -1.54384404e-01f, 2.20756102e-02f, 4.83558401e-02f, -4.95515838e-02f, -4.56933631e-03f, -1.18197680e-01f, 2.31572222e-02f, -9.78051797e-02f, 2.92283460e-03f, 1.25757651e-03f,
  -5.20973615e-02f, -1.62630796e-01f, -1.35258287e-01f, 1.41169280e-01f, -8.21324214e-02f, -3.45634446e-02f, 9.04868841e-02f, 1.62613932e-02f, -1.28149111e-02f, -8.93193856e-02f,
  -2.63346825e-02f, 4.76446897e-02f, 1.20231556e-03f, -5.55677377e-02f, -1.35092661e-01f, 5.78976236e-02f, -1.89473629e-02f, 2.98975799e-02f, 5.51079810e-02f, -7.06338137e-02f,
  -5.14646351e-01f, 4.43464994e-01f, -3.92434448e-01f, 2.10696738e-02f, -4.55939844e-02f, 2.07711965e-01f, 4.72674638e-01f, 1.31159574e-01f, 3.34012747e-01f, 3.02970678e-01f,
  1.23200901e-01f, 9.89035517e-02f, 2.46511817e-01f, 2.82396138e-01f, -4.29232508e-01f, 2.39841044e-01f, 1.70148939e-01f, 2.32852325e-01f, 1.97260290e-01f, 2.27573421e-02f,
  -1.42093450e-01f, 2.58309335e-01f, -3.48659396e-01f, 9.13591161e-02f, -8.55439454e-02f, -1.08436890e-01f, -1.65822685e-01f, 3.09465602e-02f, -1.05920941e-01f, 1.68721229e-01f,
  -2.96039619e-02f, 1.47106573e-01f, -1.21563151e-01f, -5.78355379e-02f, -1.24820538e-01f, -7.03628734e-02f, -7.29068741e-02f, -8.20726231e-02f, -4.96670157e-02f, 5.80581604e-03f,
  -2.64670793e-02f, -8.09542090e-02f, 8.97961855e-02f, 1.57828014e-02f, -8.96401238e-03f, -8.46737158e-03f, -1.26040161e-01f, -1.52620330e-01f, 1.04349025e-01f, -7.65278786e-02f,
  -1.07584983e-01f, -1.42245367e-01f, -4.80818301e-02f, 1.12345196e-01f, -2.69863941e-02f, 1.36225954e-01f, 3.21302116e-02f, -8.25375021e-02f, -4.93693352e-02f, -6.25738204e-02f,
  -6.38895333e-02f, 1.48883417e-01f, 6.63490221e-03f, -4.10173647e-02f, -6.85042934e-03f, 3.65325995e-02f, -1.38254538e-02f, 2.44892854e-02f, -9.47261043e-03f, 3.28643620e-02f,
  8.38063192e-03f, 4.78031635e-02f, 8.00197870e-02f, -1.43771768e-02f, 7.74665028e-02f, -1.95271838e-02f, -6.46663830e-02f, 6.01048246e-02f, -3.04098781e-02f, -1.66855201e-01f,
  7.49137178e-02f, -2.97151087e-03f, 7.26989955e-02f, 4.14674990e-02f, 4.20037769e-02f, -3.94615531e-02f, 1.00391001e-01f, -9.03460532e-02f, 1.93441492e-02f, 4.93965037e-02f,
  3.19936961e-01f, 4.19787616e-01f, 1.02967359e-01f, 9.04890969e-02f, 2.53185555e-02f, -5.85605837e-02f, 8.12527090e-02f, -6.80744871e-02f, 6.62072971e-02f, 1.27559155e-01f,
  -5.73624112e-02f, 1.13781720e-01f, -6.59254789e-02f, -5.54721244e-02f, -3.94439101e-02f, -9.50995646e-03f, 1.62514955e-01f, 7.67889693e-02f, 7.38816112e-02f, 3.24110244e-03f,
  -9.31584910e-02f, 1.15465850e-01f, -1.85280405e-02f, 5.63027672e-02f, 2.87610088e-02f, 8.59118160e-03f, 6.83141649e-02f, -5.76212443e-02f, -3.29191126e-02f, 7.64879733e-02f,
  -5.15430450e-01f, 1.56184107e-01f, -3.01970273e-01f, -8.72206017e-02f, -2.74166137e-01f, -3.92874718e-01f, 1.99723034e-03f, -1.91747144e-01f, -1.34291083e-01f, 4.25670922e-01f,
  2.15393692e-01f, -4.52775717e-01f, 1.99950248e-01f, -1.20204398e-02f, -5.56011558e-01f, 1.42100304e-01f, 3.82005349e-02f, 1.63627684e-01f, -1.79388270e-01f, -1.65074974e-01f,
  -2.50866979e-01f, -1.64454579e-01f, -3.88794765e-02f, -1.08738087e-01f, -1.58047229e-01f, -2.55462397e-02f, 3.88998538e-01f, -3.37732136e-02f, 5.83350919e-02f, -1.77420974e-01f,
  -1.44817367e-01f, -1.61910459e-01f, 8.58015567e-02f, -1.15925968e-01f, -2.63017062e-02f, 1.12128504e-01f, 7.74483085e-02f, -5.10281464e-03f, -1.10530011e-01f, -1.19837597e-01f,
  -1.63594689e-02f, -8.93609896e-02f, -1.41167343e-01f, -7.20995292e-02f, -2.55005062e-02f, -8.11754242e-02f, -1.24656759e-01f, 5.28221428e-02f, -1.14964500e-01f, -4.41587083e-02f,
  -3.61127667e-02f, -1.01221865e-02f, 5.58644719e-02f, 6.48218691e-02f, -1.12024951e-04f, -6.13820218e-02f, 6.38897866e-02f, 1.19174877e-02f, -6.83138371e-02f, -9.17355046e-02f,
  -6.96911057e-03f, -8.38751905e-03f, -4.18331735e-02f, -6.40416145e-02f, -6.11698776e-02f, 7.23005980e-02f, 1.25004584e-02f, 5.30414470e-02f, 4.47884277e-02f, 1.42490929e-02f,
  -6.36767894e-02f, -3.20774466e-02f, -1.63642149e-02f, 8.03339332e-02f, 2.42191423e-02f, 4.57745716e-02f, -5.45376819e-03f, -8.97736177e-02f, -2.10656207e-02f, 3.68890464e-02f,
  5.01637198e-02f, -1.01046763e-01f, 4.49456051e-02f, 7.68431723e-02f, -1.03372913e-02f, -2.31176522e-03f, 7.20594153e-02f, 4.54695597e-02f, -1.02442468e-03f, -1.47416126e-02f,
  -1.87040478e-01f, -1.06291480e-01f, -4.93400507e-02f, -8.87610316e-02f, 3.97027880e-02f, 5.94759658e-02f, 2.98181456e-02f, -3.33596468e-02f, -3.96121107e-02f, -8.04684758e-02f,
  2.54621562e-02f, 8.21897611e-02f, -2.45674513e-02f, 1.96126997e-02f, -3.23919952e-02f, 3.18346657e-02f, 4.73430268e-02f, 4.61324006e-02f, -4.07595597e-02f, 1.44639425e-02f,
  4.15219069e-02f, -2.21531615e-02f, 1.94080651e-03f, -8.13906197e-04f, 1.22818179e-01f, 3.88067402e-02f, -8.11341479e-02f, 4.63650189e-02f, -1.09460698e-02f, 7.18461424e-02f,
  -6.00546539e-01f, 3.45684946e-01f, 2.44790345e-01f, -1.87547863e-01f, -6.20912313e-02f, 6.69899583e-01f, 3.66826534e-01f, 1.37922600e-01f, -1.01471201e-01f, 2.55329251e-01f,
  1.52117252e-01f, -1.02724716e-01f, 2.66921520e-01f, 2.97087759e-01f, 3.80004048e-01f, 3.84150207e-01f, 2.01938465e-01f, 1.82529137e-01f, -9.98996720e-02f, -1.34093612e-01f,
  -5.03624342e-02f, 1.04032665e-01f, 2.26158470e-01f, -1.37601644e-01f, 3.92548963e-02f, -3.13781232e-01f, -1.25072375e-01f, 1.06594870e-02f, 1.07421562e-01f, 1.93624675e-01f,
  -7.35142305e-02f, -3.70395869e-01f, -1.55935168e-01f, -1.47516169e-02f, -1.42862657e-02f, -1.23076461e-01f, -3.95018549e-04f, 1.45935109e-02f, -4.00389768e-02f, 1.51750604e-02f,
  -5.60343303e-02f, 4.56702448e-02f, -6.85221180e-02f, -2.98244017e-03f, -1.14728875e-01f, -4.83605340e-02f, 1.27644867e-01f, 1.14317909e-01f, 8.73338580e-02f, 1.19177409e-01f,
  1.23866245e-01f, 9.78856161e-02f, 5.65112829e-02f, 3.81214246e-02f, 4.61321101e-02f, 7.52211809e-02f, 4.60048504e-02f, 2.20290162e-02f, 1.49842203e-02f, 4.64901477e-02f,
  -7.20943809e-02f, -1.57060735e-02f, -6.71914313e-03f, -7.01431977e-03f, 6.49319515e-02f, -1.32074403e-02f, 3.83705460e-02f, 8.48251283e-02f, -4.20374190e-03f, 6.05634041e-02f,
  -3.02661564e-02f, -1.21105956e-02f, -1.24803364e-01f, 5.22670373e-02f, -3.83394100e-02f, -9.95787680e-02f, -3.60787772e-02f, -7.23795295e-02f, 5.23931198e-02f, 7.03762025e-02f,
  -2.62801573e-02f, 3.61548029e-02f, 2.88969763e-02f, -8.16845670e-02f, 2.59430949e-02f, 2.31443346e-02f, -3.83913592e-02f, 7.60890990e-02f, 1.57523472e-02f, -3.73251811e-02f,
  4.55413125e-02f, -1.39884457e-01f, -6.05282709e-02f, -6.12637512e-02f, -6.13087676e-02f, 3.89142632e-02f, -1.00607365e-01f, -2.38065645e-02f, 8.48901272e-02f, -1.26308845e-02f,
  -2.46548597e-02f, -2.78168786e-02f, -1.28578693e-01f, -4.58362177e-02f, 7.49044418e-02f, 1.41721278e-01f, 1.67879090e-02f, -6.82253093e-02f, 4.12576906e-02f, 5.47438534e-03f,
  -9.61623993e-03f, -7.66577497e-02f, 7.42784664e-02f, -4.36714515e-02f, -7.79585317e-02f, 8.35566521e-02f, -1.75889298e-01f, -9.49002281e-02f, 1.62259191e-02f, 8.56952071e-02f,
  -2.54865587e-01f, 2.86416441e-01f, -2.04813495e-01f, -1.55284077e-01f, -5.59903145e-01f, -1.04755789e-01f, 2.09036507e-02f, 5.93451224e-02f, 2.47340575e-01f, 3.73702705e-01f,
  -2.54575640e-01f, 3.44430506e-01f, 2.89367825e-01f, -2.39532471e-01f, -8.45514014e-02f, 3.82789463e-01f, -8.98670182e-02f, 1.48997843e-01f, 1.43732028e-02f, 4.87842113e-02f,
  -1.02738619e-01f, -1.38545573e-01f, -2.17745766e-01f, 8.00419226e-03f, -3.89720500e-01f, -1.32730022e-01f, -2.75635153e-01f, -1.98853374e-01f, -3.44712734e-01f, -2.72977859e-01f,
  -2.65559703e-01f, -1.32102534e-01f, -2.14446023e-01f, -1.00256160e-01f, -3.96158025e-02f, 1.03304919e-03f, -2.39240732e-02f, -3.57341431e-02f, -1.25843152e-01f, -1.13965869e-02f,
  2.11230695e-01f, 2.07923818e-02f, 3.37196141e-02f, 9.77263302e-02f, -1.21980980e-02f, -1.71294317e-01f, -1.09356530e-01f, -1.70646608e-01f, -1.92211151e-01f, -9.05349925e-02f,
  3.35008800e-02f, -5.99740036e-02f, -1.29823476e-01f, -1.76911131e-02f, -2.45656341e-01f, -1.90274060e-01f, 5.63201010e-02f, -8.88293535e-02f, -1.94001153e-01f, -5.61756454e-02f,
  -8.54985937e-02f, -6.46838024e-02f, 2.03761049e-02f, 3.40262055e-02f, 1.11631043e-01f, -8.48059580e-02f, 1.18224978e-01f, 8.27684253e-03f, 1.09420950e-02f, -3.52006145e-02f,
  -3.15652154e-02f, -5.52659892e-02f, 7.86249638e-02f, 6.64580194e-03f, 8.41172133e-03f, 1.87631249e-01f, -1.35207148e-02f, 3.44230980e-02f, 1.62986070e-01f, -1.49521036e-02f,
  -1.74071137e-02f, -1.04162015e-01f, -8.15266743e-03f, -7.62989148e-02f, 5.63489944e-02f, 6.22442663e-02f, 3.41266803e-02f, -4.36208919e-02f, -1.53595805e-02f, -1.23718619e-01f,
  -1.65896088e-01f, -9.10428166e-02f, -1.15697861e-01f, -1.13913774e-01f, 1.51629582e-01f, -3.47259752e-02f, 5.62128313e-02f, -2.49900147e-02f, -5.36142513e-02f, 3.57037634e-02f,
  6.07897937e-02f, 1.36490181e-01f, -7.65818497e-03f, -4.59898189e-02f, 1.86244622e-01f, 2.57268585e-02f, 4.09462005e-02f, 1.06776943e-02f, -1.26828209e-01f, -8.30600187e-02f,
  -1.41329085e-02f, 1.12390310e-01f, 7.55594075e-02f, 1.50534417e-03f, -7.74290934e-02f, -4.01331335e-02f, 2.26487163e-02f, -4.83694896e-02f, -2.12382436e-01f, 1.19064208e-02f,
  -4.38236713e-01f, -1.14290984e-02f, -2.14123473e-01f, -3.15676361e-01f, 3.36194128e-01f, 3.32005024e-02f, 1.02426969e-01f, 2.33055890e-01f, -1.14907452e-03f, 1.41354412e-01f,
  9.76148173e-02f, -4.13090676e-01f, 1.46944180e-01f, -4.11196083e-01f, -3.94807488e-01f, -2.59863019e-01f, -3.70076150e-01f, -3.20858389e-01f, -2.38440442e-03f, -3.52984183e-02f,
  -1.39716238e-01f, -9.47914366e-03f, -1.52819216e-01f, 3.57656300e-01f, 2.68484056e-02f, 1.41356975e-01f, 1.27041847e-01f, 2.72400439e-01f, -1.62086084e-01f, -8.37765783e-02f,
  9.75981429e-02f, 1.35944486e-01f, 1.19454660e-01f, 1.16204349e-02f, 2.31724251e-02f, 7.13037550e-02f, -6.53027371e-02f, 3.35758887e-02f, 5.59182912e-02f, -9.77266487e-03f,
  -9.76288877e-03f, -3.59746926e-02f, -1.01149797e-01f, 2.25088932e-02f, 1.09991588e-01f, 3.72088440e-02f, -8.26761127e-02f, -2.72889505e-03f, 2.80043930e-02f, -1.63673252e-01f,
  -1.82500686e-02f, -9.16197225e-02f, -8.29878971e-02f, -1.09141439e-01f, -5.69212884e-02f, 6.41295314e-02f, -2.50096638e-02f, -6.97925761e-02f, -5.83287422e-03f, -1.10920176e-01f,
  -4.96957861e-02f, 8.37692842e-02f, 2.72399504e-02f, 9.38616022e-02f, 2.19806619e-02f, 7.43984878e-02f, -3.25288922e-02f, -2.95745656e-02f, 4.56006005e-02f, -1.81004833e-02f,
  7.95741007e-02f, -2.25154590e-02f, 6.36731237e-02f, 3.73956934e-02f, -7.98708424e-02f, -7.35766068e-02f, -1.21915918e-02f, -7.87654966e-02f, -3.39127705e-02f, -2.57876962e-02f,
  4.89247069e-02f, -5.43658901e-03f, -4.44887672e-03f, 4.02114466e-02f, 8.05918723e-02f, -3.54426913e-02f, 1.33181233e-02f, -4.76829559e-02f, 7.47340173e-03f, -2.25218870e-02f,
  1.25174960e-02f, -1.18651530e-02f, 1.79830864e-01f, 2.40216795e-02f, 1.84209626e-02f, 1.86812542e-02f, -2.63794214e-02f, -1.28262326e-01f, 8.24623853e-02f, 2.38083918e-02f,
  -1.26504935e-02f, 5.80508560e-02f, 4.27699126e-02f, -7.87281692e-02f, -2.57491786e-02f, 9.07482877e-02f, 2.51005660e-03f, 1.06684510e-02f, 3.85389589e-02f, -3.36786546e-02f,
  1.17632441e-01f, 7.62105435e-02f, 4.04278561e-02f, 1.34907499e-01f, 7.83174019e-03f, 2.41501499e-02f, 1.50470091e-02f, 4.15338092e-02f, 1.84111912e-02f, -3.72604690e-02f,
  5.60006686e-02f, -2.00312566e-02f, 3.27339083e-01f, -8.22600424e-02f, 3.38353693e-01f, 4.50312257e-01f, 3.26859862e-01f, 3.44934434e-01f, 5.42251229e-01f, -3.78144473e-01f,
  -2.30427235e-01f, -4.43596154e-01f, -2.17542890e-02f, -2.29840323e-01f, 4.17863905e-01f, 2.72364795e-01f, 1.62029788e-01f, -4.09176759e-02f, 2.66675353e-01f, -5.17001860e-02f,
  -4.50671557e-03f, -3.12065661e-01f, -2.11074471e-01f, -2.54065871e-01f, -2.15385005e-01f, -2.37895232e-02f, -3.38731885e-01f, 1.39277145e-01f, -4.12438661e-01f, 2.16184035e-01f,
  1.36345830e-02f, -1.87221151e-02f, -1.19664846e-02f, 1.12302578e-03f, 8.18364099e-02f, 4.23844345e-03f, -8.00448954e-02f, 7.51723722e-02f, 1.12787664e-01f, -4.33568060e-02f,
  -1.82364181e-01f, -1.20307788e-01f, -6.14167303e-02f, 6.40266314e-02f, 9.21901911e-02f, -1.00131959e-01f, 1.59982983e-02f, 4.08004038e-02f, -1.06681287e-02f, 5.23691922e-02f,
  -6.66645914e-02f, -7.63805807e-02f, -3.21217105e-02f, 1.34592485e-02f, 7.13900756e-03f, 7.65788630e-02f, 4.34108190e-02f, 3.63162197e-02f, 4.70846472e-03f, 8.36843550e-02f,
  5.59458174e-02f, 2.38294780e-01f, -6.17646016e-02f, -5.04915193e-02f, 1.40161375e-02f, 7.03071654e-02f, -7.86363930e-02f, -9.67373550e-02f, 8.19559693e-02f, -8.32814127e-02f,
  -2.74498528e-03f, -8.49599764e-03f, 3.18082981e-02f, 2.52550524e-02f, -3.06350533e-02f, -1.03077991e-02f, 9.74486815e-04f, -2.49276478e-02f, -1.63518358e-02f, 6.54607192e-02f,
  4.15870138e-02f, 4.72611934e-02f, -4.01499607e-02f, -6.21064380e-02f, 5.13460115e-02f, 1.89717915e-02f, -3.24958153e-02f, -1.71331074e-02f, 8.11369717e-03f, -1.89070199e-02f,
  2.40972310e-01f, 1.16618812e-01f, -3.79512459e-02f, -1.82052165e-01f, 2.27336138e-02f, -4.46299054e-02f, 6.52481616e-02f, 4.23122868e-02f, 9.41397548e-02f, -8.91834381e-04f,
  -1.62547871e-01f, -1.33692056e-01f, -1.48038156e-02f, 4.70988937e-02f, -2.57147923e-02f, 6.25854805e-02f, -8.99284631e-02f, -5.46076298e-02f, 7.88923651e-02f, -2.80705164e-03f,
  -1.96217537e-01f, -7.32175559e-02f, -5.00978380e-02f, -7.41769224e-02f, -1.57217339e-01f, -6.17263429e-02f, 2.77538871e-04f, 1.04392767e-02f, -9.30047221e-03f, 8.26658458e-02f,
  3.41437496e-02f, -8.04132521e-02f, -2.50355273e-01f, 5.01284488e-02f, -4.33277905e-01f, 5.71210422e-02f, 4.43727486e-02f, -1.89933568e-01f, 3.19149971e-01f, 2.31140435e-01f,
  3.36865224e-02f, 2.51492679e-01f, 4.12338935e-02f, 1.77351952e-01f, 2.46832386e-01f, 4.44463819e-01f, 2.57080257e-01f, 3.34267318e-01f, 1.61956266e-01f, -5.62487282e-02f,
  1.06346205e-01f, 5.38109578e-02f, -2.35007867e-01f, -1.54558465e-01f, -3.37351680e-01f, -2.76436716e-01f, -1.87911242e-01f, -2.29096457e-01f, -4.58891205e-02f, -7.94485658e-02f,
  8.27027634e-02f, -6.95950314e-02f, -1.20240256e-01f, 1.09903581e-01f, -7.91392550e-02f, -9.85551327e-02f, 9.03871953e-02f, -5.46333492e-02f, -1.80391707e-02f, 1.55984117e-02f,
  8.75929371e-02f, 8.75616595e-02f, 1.12275243e-01f, -3.99748310e-02f, -2.00836733e-02f, -3.98427658e-02f, 3.13457362e-02f, -3.31762619e-02f, -1.21126510e-02f, -1.15223609e-01f,
  -8.22717026e-02f, 2.20302236e-03f, -9.05465428e-03f, 8.59273672e-02f, -5.72351962e-02f, 6.04888387e-02f, 5.40272109e-02f, -6.80936351e-02f, 6.62813634e-02f, 2.49059573e-02f,
  -5.27619906e-02f, 1.35419235e-01f, 3.54646929e-02f, -6.70083845e-03f, -8.97574704e-03f, -1.09663077e-01f, 3.00553143e-02f, 1.69917569e-02f, 9.30275172e-02f, 9.49574355e-03f,
  7.70620480e-02f, -1.36884719e-01f, 4.83186729e-03f, 9.48239118e-02f, 5.28946240e-03f, -1.37254559e-02f, -1.75117869e-02f, 4.26955298e-02f, -2.34320592e-02f, 3.84630216e-03f,
  -9.91116744e-03f, 1.29058227e-01f, -5.40208109e-02f, -5.66237271e-02f, 3.24985087e-02f, -8.84971768e-02f, -9.49037075e-03f, -1.23080099e-02f, -8.75459239e-03f, -5.44664860e-02f,
  8.50329399e-02f, 1.58998683e-01f, -5.35410503e-03f, 8.28832537e-02f, 3.71085033e-02f, -7.92692155e-02f, 9.63369291e-03f, -1.72364041e-02f, 6.26925826e-02f, 1.62926409e-03f,
  2.11245082e-02f, 9.53731090e-02f, -1.12760148e-03f, -7.03550735e-03f, 5.08609153e-02f, -6.02003075e-02f, 1.39031291e-01f, 6.86499402e-02f, -2.02892181e-02f, -2.20321938e-02f,
  -8.75481963e-02f, 7.70898461e-02f, 3.45460288e-02f, -6.73044324e-02f, 5.01346327e-02f, -1.36775589e-02f, 5.76921478e-02f, -8.28345865e-02f, -3.83972796e-03f, 9.47486982e-02f,
  1.74718663e-01f, 8.67506713e-02f, -2.96694517e-01f, 8.64182264e-02f, 2.37201108e-03f, -1.42146833e-02f, 2.32114509e-01f, 9.78407450e-03f, -1.65246233e-01f, 2.26675510e-01f,
  3.64271164e-01f, -1.24207482e-01f, 2.78700024e-01f, 3.48273516e-01f, 1.98750347e-01f, 1.54652521e-01f, 2.13107407e-01f, 1.01404220e-01f, -2.40746841e-01f, 1.01566739e-01f,
  -4.24600951e-02f, 2.56965518e-01f, 1.87194362e-01f, -5.86280935e-02f, 2.71629333e-01f, -1.60545230e-01f, 2.73799598e-01f, -4.68029305e-02f, 4.71714735e-02f, 1.18842229e-01f,
  -1.39429020e-02f, 6.12796992e-02f, 7.04749301e-03f, -1.05634183e-01f, 1.04703277e-01f, 3.90303358e-02f, -2.83915307e-02f, 1.17243268e-01f, -2.08564922e-02f, 5.02012856e-03f,
  4.50294763e-02f, -8.12765956e-02f, -1.57661978e-02f, 1.14738778e-03f, -1.05744004e-01f, -4.65282947e-02f, -3.98348160e-02f, -1.29905564e-03f, -1.25010371e-01f, 1.00261047e-01f,
  2.33892184e-02f, -4.42879088e-02f, 9.37910527e-02f, 2.89578084e-02f, -3.36971246e-02f, -1.80407669e-02f, -2.32975166e-02f, -2.35825218e-02f, -2.00017728e-02f, -6.03205059e-03f,
  1.01840399e-01f, 1.00095849e-02f, -2.39592735e-02f, 5.94473630e-03f, 2.52985172e-02f, 5.61242225e-03f, 2.67910911e-03f, 3.03417481e-02f, -1.65933333e-02f, 7.82252029e-02f,
  -5.99735267e-02f, -4.88332473e-02f, 5.79846390e-02f, 2.84682214e-02f, 5.47341406e-02f, -3.61397304e-02f, 4.86158840e-02f, 9.19629447e-03f, -4.77562696e-02f, -9.99517739e-02f,
  -2.07870770e-02f, -4.14548814e-02f, -1.27162039e-03f, 6.08375892e-02f, -1.86955649e-02f, 4.48055519e-03f, 5.51513098e-02f, 5.87955974e-02f, 7.39919320e-02f, 4.69238199e-02f,
  1.17578842e-01f, 1.52718335e-01f, -6.36401772e-02f, -3.59871201e-02f, -5.90783916e-02f, 3.71186174e-02f, -3.22057046e-02f, -6.98407972e-03f, 4.34614383e-02f, 4.79940558e-04f,
  5.86001314e-02f, -6.82944506e-02f, -3.47596221e-02f, 3.92741002e-02f, -8.07137787e-02f, 6.36562854e-02f, 4.61063460e-02f, -2.28847358e-02f, 8.33934471e-02f, 1.15912408e-02f,
  9.69650224e-03f, 3.91492732e-02f, -4.04695608e-02f, -2.66883727e-02f, -8.96839872e-02f, 1.16819657e-01f, -7.96325058e-02f, -3.68092395e-02f, 2.37465743e-02f, 2.32621152e-02f,
  -4.96131182e-01f, 7.77142541e-03f, -1.24713965e-01f, -1.27783209e-01f, 3.07649106e-01f, 1.97282791e-01f, -3.71647418e-01f, 2.03585234e-02f, -2.62011021e-01f, -1.81250662e-01f,
  -4.08564657e-02f, -9.09141228e-02f, -3.39922279e-01f, 1.62338853e-01f, 2.07114905e-01f, 3.93625237e-02f, 1.95729420e-01f, -4.03710827e-02f, 8.95545632e-02f, -1.01300262e-01f,
  1.82754248e-01f, 2.32422024e-01f, 3.47607657e-02f, 2.57248312e-01f, -3.84178832e-02f, -1.50254443e-02f, -5.94647564e-02f, -1.29432097e-01f, 1.78979531e-01f, 1.62699834e-01f,
  -1.19758889e-01f, -2.55652428e-01f, -2.37452775e-01f, -1.37878031e-01f, -8.59526172e-02f, -1.58444762e-01f, -1.48547575e-01f, -1.61134321e-02f, -1.00279637e-01f, -4.07644594e-03f,
  -1.23610839e-01f, 9.80071276e-02f, 1.29530594e-01f, -6.43704608e-02f, 4.58071046e-02f, 8.19602385e-02f, 5.46254776e-02f, -4.66663167e-02f, 4.61925194e-03f, 1.68453641e-02f,
  -8.32436606e-03f, 1.17446713e-01f, 3.09411604e-02f, 7.72048756e-02f, 5.43881319e-02f, 1.47744596e-01f, 8.02828372e-02f, -3.56427841e-02f, 8.79463404e-02f, 5.38049340e-02f,
  3.44965644e-02f, -4.29333821e-02f, -2.51949187e-02f, -1.10918991e-02f, -5.59073016e-02f, 4.45218310e-02f, -1.88170914e-02f, 3.17267291e-02f, -4.03550192e-04f, 4.33058217e-02f,
  1.09073125e-01f, -2.27130502e-02f, 5.56032732e-02f, -5.13826460e-02f, 8.32837541e-03f, 7.21381754e-02f, 2.34111454e-02f, -3.00577935e-02f, 6.01958856e-02f, 5.23560960e-03f,
  -4.46977317e-02f, -1.89152975e-02f, -4.35151579e-03f, 2.75493227e-02f, 1.97800752e-02f, -1.21700212e-01f, -5.87167740e-02f, 3.26415226e-02f, -2.40942626e-03f, 2.95831612e-03f,
  -3.98953110e-01f, -3.63594562e-01f, -1.14256784e-01f, 1.81110464e-02f, -6.01938292e-02f, 2.87170224e-02f, -3.49019393e-02f, 1.35972485e-01f, -5.95558546e-02f, -1.43294320e-01f,
  4.42324812e-03f, -7.76576474e-02f, 5.16465418e-02f, 1.77129544e-03f, 1.01964913e-01f, -2.88796867e-03f, -1.37981787e-01f, -6.66691810e-02f, -9.72276255e-02f, 4.25587781e-02f,
  -6.99584782e-02f, 5.92036322e-02f, 3.12639109e-04f, 8.85358974e-02f, 4.13789265e-02f, -8.28301534e-03f, -1.11402823e-02f, 5.45211993e-02f, 9.03231651e-02f, 1.06327526e-01f,
  -1.36839092e-01f, 4.37879749e-03f, 3.58159363e-01f, 5.71967438e-02f, 1.07982054e-01f, 4.28120285e-01f, 3.51860613e-01f, 1.04350038e-01f, 3.98890674e-01f, -1.72509775e-01f,
  -2.21195370e-01f, -1.45909548e-01f, 1.45536020e-01f, -1.35642126e-01f, 4.13362712e-01f, 3.19122642e-01f, 1.49289727e-01f, 7.36239851e-02f, 6.41757473e-02f, -1.78422615e-01f,
  5.23294434e-02f, -2.63164878e-01f, -4.72902842e-02f, -3.05609465e-01f, -1.92579612e-01f, -1.29813626e-01f, -2.97474980e-01f, 1.53230548e-01f, -2.44396016e-01f, 1.31043166e-01f,
  -8.00989270e-02f, -1.35362491e-01f, -2.31878713e-01f, -4.65242900e-02f, -8.58237892e-02f, 4.58090156e-02f, 1.30521670e-01f, 9.15635154e-02f, 7.20780715e-02f, 3.10984831e-02f,
  -5.54407239e-02f, -2.81621255e-02f, -5.61921224e-02f, 6.15539365e-02f, 6.28993809e-02f, -7.02733397e-02f, -3.46027948e-02f, -5.70028760e-02f, -4.76714522e-02f, 5.30041791e-02f,
  -2.48250999e-02f, 1.16829844e-02f, 1.57307703e-02f, -3.31905037e-02f, -3.03649660e-02f, -6.40216544e-02f, 1.31994262e-01f, 6.12130761e-02f, -2.90773474e-02f, 4.78298180e-02f,
  4.04166244e-02f, 8.24886486e-02f, -9.80581790e-02f, -8.71632155e-03f, -8.36982392e-04f, -1.54336803e-02f, 4.41154093e-02f, -4.01686840e-02f, 4.02809456e-02f, -8.04705173e-02f,
  -7.51524493e-02f, -9.95822474e-02f, -1.96785573e-02f, 1.06955310e-02f, -8.62549543e-02f, -4.44606766e-02f, -5.63878827e-02f, -2.59655192e-02f, -1.56248556e-02f, -4.50037867e-02f,
  7.40036741e-02f, 1.24026716e-01f, -1.33111134e-01f, 1.79327093e-02f, -2.05526426e-02f, 2.90666036e-02f, -6.13390915e-02f, 4.33629826e-02f, -1.57655925e-02f, 3.77692678e-03f,
  1.00844942e-01f, 9.43810791e-02f, -1.40234113e-01f, -1.60103932e-01f, -2.14130543e-02f, -1.13534279e-01f, 7.38185644e-02f, -6.37919456e-02f, 7.08483234e-02f, -3.52595933e-02f,
  -1.35592399e-02f, -4.07992117e-02f, -4.44315299e-02f, -5.01275109e-03f, -3.32720354e-02f, -3.64476405e-02f, 4.39897329e-02f, -7.05100521e-02f, 1.47553172e-03f, -8.52700993e-02f,
  -1.56783253e-01f, -3.64525653e-02f, -2.31416542e-02f, -1.43530607e-01f, -1.41018778e-01f, -1.04207993e-01f, -8.93414766e-02f, -4.85845143e-03f, 1.21781798e-02f, 9.08030570e-03f,
  3.60949375e-02f, 4.20774668e-01f, 4.60219830e-01f, 1.76243424e-01f, -2.88051933e-01f, -3.00040483e-01f, -1.92529783e-01f, 2.40735337e-01f, 1.46388307e-01f, 1.13108270e-01f,
  -1.71400100e-01f, 2.99559832e-01f, -8.92638508e-03f, 1.91820890e-01f, -6.30602092e-02f, -5.07783182e-02f, -9.95231885e-03f, 2.61088237e-02f, 3.28686647e-02f, 1.76377028e-01f,
  -3.98882180e-02f, -3.35170656e-01f, 1.27363473e-01f, -7.99085349e-02f, 1.10855088e-01f, 3.04374218e-01f, -1.10539667e-01f, 2.92309443e-03f, 8.94992501e-02f, -1.39364265e-02f,
  3.81524190e-02f, 3.11447978e-01f, 2.52487808e-01f, 7.86571279e-02f, 4.75224666e-02f, -1.28559083e-01f, -2.55429670e-02f, 8.16117506e-03f, -1.10346274e-02f, -5.84812544e-04f,
  -6.23366646e-02f, -7.56469071e-02f, 4.68200110e-02f, -6.92565814e-02f, 2.15450563e-02f, 7.89308250e-02f, 1.10638561e-02f, 4.08346578e-03f, 1.31222099e-01f, 1.70775782e-02f,
  1.17087901e-01f, 7.21617937e-02f, -1.08649656e-02f, 5.76984063e-02f, 8.28497559e-02f, 9.50495433e-03f, 5.34910895e-03f, 4.02525663e-02f, 1.03290908e-01f, 6.94971755e-02f,
  -5.24032749e-02f, -9.57471430e-02f, 1.72908488e-03f, 7.17416313e-03f, 3.45274732e-02f, -2.90502943e-02f, -3.50906849e-02f, -6.59339651e-02f, 2.55547557e-02f, -1.33087337e-01f,
  -5.45209423e-02f, 1.06240250e-01f, -1.09513685e-01f, -9.81406495e-02f, -4.22617123e-02f, 9.02153924e-02f, -5.57978377e-02f, 5.79781607e-02f, -4.61708717e-02f, 6.75567538e-02f,
  2.21328847e-02f, -1.56375229e-01f, 1.18900472e-02f, -4.47522439e-02f, -1.09334603e-01f, -4.09652740e-02f, 4.01327424e-02f, 8.35769102e-02f, -8.92643817e-03f, -5.34795411e-02f,
  5.72612733e-02f, 3.47074240e-01f, 1.57850459e-01f, 7.94667564e-03f, 1.32276565e-01f, 2.22536791e-02f, -3.07101719e-02f, 1.12300567e-01f, 9.51877087e-02f, -1.69124827e-02f,
  -5.69592901e-02f, -1.78192668e-02f, -1.26049355e-01f, -2.31356900e-02f, -5.13589457e-02f, 6.88613132e-02f, -2.43434887e-02f, -4.30479795e-02f, 8.24611410e-02f, 5.87632060e-02f,
  1.94849949e-02f, -1.10546499e-01f, 7.96913132e-02f, -1.01230957e-01f, -3.04565970e-02f, 2.35350560e-02f, -1.84089374e-02f, 1.17464043e-01f, -1.62893608e-02f, -5.92427813e-02f,
  -4.97671425e-01f, -2.46284261e-01f, -2.77009960e-02f, 1.23084970e-01f, -1.78993121e-01f, -7.13510290e-02f, 2.26220086e-01f, -2.41286740e-01f, -8.01326782e-02f, 1.66926667e-01f,
  1.47882223e-01f, -1.87717184e-01f, 8.86402577e-02f, 3.11930001e-01f, -9.99385491e-02f, 2.11951524e-01f, 1.47459075e-01f, 1.68007806e-01f, -8.95640478e-02f, -1.46799177e-01f,
  -6.89394325e-02f, 1.71182960e-01f, 1.74823746e-01f, -1.14200622e-01f, -7.36161396e-02f, -1.31323636e-01f, 6.57849014e-02f, -7.06740245e-02f, 1.10841654e-01f, 2.68991422e-02f,
  -1.34666517e-01f, -1.26995280e-01f, -4.90425527e-03f, -2.23404244e-02f, -1.31328329e-02f, 4.60437611e-02f, 1.75441224e-02f, 4.22135033e-02f, 2.85060201e-02f, -4.63041626e-02f,
  -7.68266909e-04f, -5.07457815e-02f, -1.29414431e-03f, 2.99353544e-02f, -8.69036764e-02f, -5.12045808e-02f, -5.99000864e-02f, -1.16868019e-02f, -1.89095046e-02f, -5.16146496e-02f,
  3.10093332e-02f, -5.09630516e-02f, 1.36402017e-02f, 5.45900539e-02f, -5.61932474e-02f, 1.95032544e-02f, 9.62350667e-02f, -1.05659999e-01f, -1.05508573e-01f, -7.02177137e-02f,
  4.43358794e-02f, 6.10947199e-02f, 2.16043480e-02f, 2.96808360e-03f, 9.09040496e-03f, 7.59400204e-02f, 5.93636185e-02f, 9.61101241e-03f, -5.19168051e-03f, -3.86559851e-02f,
  2.30392553e-02f, -7.97362998e-02f, -7.43077025e-02f, 2.37032399e-02f, 1.81080420e-02f, -6.57034060e-03f, 7.56181031e-02f, -4.83049126e-03f, -1.22363456e-02f, -4.13681790e-02f,
  3.33718956e-03f, -2.87169740e-02f, -4.03199047e-02f, 5.93233667e-02f, 1.28012495e-02f, -4.11568210e-02f, 3.63118597e-03f, -4.54247035e-02f, 3.67767029e-02f, -1.18411392e-01f,
  -3.61142129e-01f, -3.34770471e-01f, 2.49095410e-02f, -6.30577803e-02f, 1.33567322e-02f, -8.58281031e-02f, -1.45400036e-02f, -1.05145276e-01f, -1.18736878e-01f, -4.49524552e-04f,
  -1.87248997e-02f, 5.32078035e-02f, -8.80100280e-02f, 6.82954341e-02f, -4.75684414e-03f, 3.20301168e-02f, 8.22630003e-02f, -4.06276882e-02f, 2.23043319e-02f, -3.99967767e-02f,
  7.35780597e-03f, 2.26710904e-02f, 7.97986686e-02f, 2.41740863e-03f, 2.31153034e-02f, -1.81710273e-02f, -1.47121981e-01f, 5.03293518e-03f, 3.13511142e-03f, 5.85598871e-02f,
  8.74623582e-02f, 6.76728413e-02f, -8.38570595e-02f, -1.04415536e-01f, -1.92044050e-01f, -3.25040579e-01f, -2.95270205e-01f, 1.67304147e-02f, -3.01510751e-01f, -8.04651063e-03f,
  9.69103910e-03f, -2.94987351e-01f, 1.99552357e-01f, -2.17995033e-01f, -2.96258498e-02f, 4.47684862e-02f, -1.61305610e-02f, -1.63808435e-01f, 1.23651326e-01f, 2.12197691e-01f,
  1.68634921e-01f, 8.44268724e-02f, 2.02025354e-01f, 2.44281441e-01f, 1.59751121e-02f, 1.69179589e-01f, 2.96170980e-01f, 6.77742213e-02f, 5.04537337e-02f, -1.57330036e-01f,
  -1.44295171e-01f, 5.67787103e-02f, -4.62132879e-02f, -8.09784085e-02f, 1.80732101e-01f, 2.87790224e-02f, 3.91778499e-02f, -7.30992779e-02f, -5.57189099e-02f, -7.51539739e-03f,
  1.50450934e-02f, 1.65672861e-02f, -3.96781676e-02f, -9.29170847e-02f, -4.50395085e-02f, 9.33523104e-03f, 4.77279387e-02f, -5.24093509e-02f, -7.25305378e-02f, 1.24257781e-01f,
  -1.52618187e-02f, -3.26180714e-03f, -8.15107021e-03f, 7.25686550e-02f, 1.33008519e-02f, -1.80433709e-02f, -3.56830768e-02f, 5.92654012e-02f, -8.33481252e-02f, -6.32680021e-03f,
  1.26126319e-01f, 1.02139674e-02f, 5.99365197e-02f, -8.85171071e-03f, 1.78212319e-02f, 8.52995887e-02f, -1.27764493e-01f, -8.45084488e-02f, -7.17409002e-03f, 7.61169717e-02f,
  1.58620626e-02f, -1.52812302e-02f, -6.22785976e-03f, -1.42222932e-02f, 6.55397698e-02f, -4.07427736e-02f, -9.76261050e-02f, -4.87980852e-03f, 4.27235365e-02f, -1.69999357e-02f,
  -9.11421850e-02f, 2.78839208e-02f, -2.00847033e-02f, -1.88265033e-02f, -1.20376907e-01f, 4.81151566e-02f, 8.29750821e-02f, 6.34683529e-03f, 1.11754574e-01f, -5.78554114e-03f,
  1.29756555e-01f, 3.53822261e-01f, -9.17453691e-03f, -1.23538993e-01f, 1.23241758e-02f, 9.29699019e-02f, -1.07549027e-01f, -3.94858532e-02f, 3.28105763e-02f, 3.67171355e-02f,
  1.43919706e-01f, -1.16118444e-02f, 2.10837033e-02f, 4.81721461e-02f, -1.01250075e-01f, 1.34132355e-01f, 4.46821265e-02f, -5.10205701e-02f, 3.64606362e-03f, 1.92970321e-01f,
  1.08907022e-01f, 7.91811198e-02f, 2.08746805e-03f, -6.23442754e-02f, 8.74135084e-03f, -3.82177606e-02f, 3.95406522e-02f, -1.73422229e-02f, 3.42750475e-02f, -1.03186898e-01f,
  -5.41714430e-01f, -2.89393634e-01f, -4.53187555e-01f, -2.32386105e-02f, 6.65199906e-02f, 2.87964463e-01f, 1.96906716e-01f, -3.69277932e-02f, -2.90650010e-01f, 3.32328856e-01f,
  3.40313554e-01f, -3.03706050e-01f, -1.52049720e-01f, 4.62993324e-01f, 2.73237820e-03f, 7.32645812e-03f, 3.87579978e-01f, 2.38096163e-01f, -2.23408639e-01f, -1.77889988e-01f,
  -7.84875527e-02f, 3.77515376e-01f, 4.53917086e-02f, 1.98582202e-01f, 1.04625918e-01f, -1.36395976e-01f, 2.75068104e-01f, -1.27075329e-01f, 4.78573769e-01f, 2.04870075e-01f,
  1.82692766e-01f, -1.84427455e-01f, -9.35612172e-02f, -5.25618084e-02f, 1.26646027e-01f, 8.32133964e-02f, 2.06442103e-02f, 4.04555649e-02f, -9.59289595e-02f, 1.55941967e-03f,
  -5.30752614e-02f, -9.13407803e-02f, -4.86574173e-02f, -6.76928014e-02f, -3.80504951e-02f, -7.69955590e-02f, -7.00112954e-02f, 5.56186251e-02f, 1.02133723e-02f, -1.41146123e-01f,
  -2.29229212e-01f, 8.16103630e-03f, -3.40033621e-02f, 7.32298419e-02f, -4.84780483e-02f, -9.18275341e-02f, -5.07404990e-02f, -8.31448212e-02f, 6.62762672e-02f, -9.93783120e-03f,
  -5.24054328e-03f, -6.36808500e-02f, -4.30058613e-02f, -4.27083904e-03f, 2.81677134e-02f, 8.44732150e-02f, 7.52098411e-02f, 1.24726512e-01f, -4.13172580e-02f, 2.76538124e-03f,
  -4.40547206e-02f, -4.64216694e-02f, 6.93975538e-02f, 2.04009991e-02f, 1.67563763e-02f, 3.26130241e-02f, -9.30827335e-02f, 1.53696006e-02f, -8.52142796e-02f, 1.52581260e-01f,
  5.67066344e-03f, -1.95851866e-02f, 6.24753758e-02f, 6.22397177e-02f, 2.01505274e-02f, -4.01828215e-02f, 7.65801743e-02f, -8.77371877e-02f, -1.33551722e-02f, 4.66746241e-02f,
  1.04418829e-01f, -1.51949331e-01f, 9.89962928e-03f, 7.43712112e-02f, 8.33253637e-02f, -1.68201514e-02f, 5.57461753e-02f, 3.56758796e-02f, -4.86002900e-02f, -1.03018600e-02f,
  -8.49029329e-03f, 4.90815565e-02f, 4.04474735e-02f, -7.31911603e-03f, 1.28806055e-01f, 4.15746644e-02f, 1.53726069e-04f, 2.17142627e-02f, 7.55395442e-02f, 1.15945283e-02f,
  -2.72640157e-02f, 9.06017423e-03f, -1.09835260e-03f, 4.48491909e-02f, 1.20232835e-01f, 4.80583273e-02f, -4.84641967e-03f, -6.94021881e-02f, 1.58209741e-01f, -1.23967873e-02f,
  3.29694659e-01f, 3.88638109e-01f, 3.57732534e-01f, 2.81978816e-01f, -7.21816421e-02f, -9.58045423e-02f, 1.45423142e-02f, 1.31747335e-01f, 3.38980138e-01f, -1.24845341e-01f,
  -2.86682755e-01f, 1.96544290e-01f, -2.76301742e-01f, 1.60713091e-01f, -1.51898369e-01f, -1.68581963e-01f, 2.46199578e-01f, 1.36681544e-02f, 4.25041020e-02f, 3.09065934e-02f,
  9.34990495e-02f, -3.30938458e-01f, 4.52766232e-02f, -2.58739948e-01f, 1.36234462e-01f, 2.83933520e-01f, -3.15322131e-01f, 2.53445543e-02f, 1.31144449e-01f, -1.29170320e-03f,
  1.39955506e-01f, 4.76481728e-02f, 1.41671985e-01f, 1.93570748e-01f, 8.43296945e-02f, 2.38626190e-02f, 1.17138267e-01f, -6.42233714e-02f, 7.61303753e-02f, 3.25699039e-02f,
  -7.35045818e-04f, -1.16339885e-02f, 2.78580561e-02f, -6.28358647e-02f, 1.22829035e-01f, 8.96347314e-02f, 1.14713728e-01f, 1.60042077e-01f, 1.01426393e-01f, 3.70329060e-02f,
  9.58522260e-02f, 1.73766345e-01f, 1.17599495e-01f, 4.31958027e-02f, 1.48215815e-01f, 1.01299487e-01f, -3.02138360e-04f, 2.92769987e-02f, 9.58013684e-02f, 8.35938156e-02f,
  -3.99883948e-02f, -3.35575119e-02f, -6.67983294e-02f, 2.85939388e-02f, -7.54763931e-02f, -1.11845769e-02f, 1.86014653e-03f, -7.48674423e-02f, 7.78239891e-02f, -3.69387306e-02f,
  -1.00749936e-02f, 2.24060297e-01f, 2.93170698e-02f, 9.25086066e-02f, -6.21519387e-02f, 7.33193383e-03f, -2.03193370e-02f, -5.06668352e-02f, 6.30392134e-02f, 3.26492600e-02f,
  -1.27970189e-01f, 2.71871556e-02f, -8.19859877e-02f, -3.40768248e-02f, 4.93018255e-02f, 2.43164375e-02f, -3.26325861e-03f, 2.33229771e-02f, -2.05919240e-02f, -1.34172857e-01f,
  4.33626734e-02f, -5.23087271e-02f, 7.65308738e-02f, -2.55217627e-02f, 5.57943583e-02f, -8.20560157e-02f, 3.02985590e-02f, 7.91001320e-02f, 1.97107755e-02f, -1.27555266e-01f,
  3.05287279e-02f, -2.39339210e-02f, -2.71103606e-02f, 1.96776958e-03f, -3.91333215e-02f, -2.53049452e-02f, 8.18820670e-03f, 3.87888104e-02f, 2.98866574e-02f, -2.81574894e-02f,
  -3.35792005e-02f, -1.01768412e-01f, -5.13230264e-02f, 3.18047218e-02f, 1.33071244e-02f, -2.89180893e-02f, -1.04242340e-02f, 9.93194953e-02f, -5.15282452e-02f, 5.85099272e-02f,
  3.44947875e-01f, 3.14426601e-01f, 4.81362566e-02f, 3.11197303e-02f, -1.30248889e-01f, -2.68631905e-01f, -2.02790767e-01f, -1.66456085e-02f, -1.83426321e-01f, 2.45882198e-01f,
  -2.08369344e-01f, 1.89013511e-01f, -1.34006724e-01f, 3.49548273e-02f, -2.44554535e-01f, -3.11699867e-01f, 1.61476612e-01f, 2.05019135e-02f, -6.93769231e-02f, 3.10999006e-01f,
  -5.67174563e-03f, -9.72877443e-03f, 6.08881339e-02f, 6.51250081e-03f, 2.98504323e-01f, 1.98851898e-01f, 2.38632351e-01f, -8.44446719e-02f, 1.61374107e-01f, -1.72246709e-01f,
  -1.08203694e-01f, 4.21014912e-02f, 1.99055187e-02f, 1.52899427e-02f, 5.87003343e-02f, 8.16044137e-02f, 1.20111912e-01f, -1.21754020e-01f, -1.19841866e-01f, -4.23121527e-02f,
  9.60405841e-02f, -9.86567582e-04f, -2.84715686e-02f, -2.19003391e-02f, 7.99354240e-02f, 3.21557000e-02f, -3.75291263e-03f, 5.22453412e-02f, 6.79787919e-02f, 1.25470608e-01f,
  -4.61203866e-02f, 7.92328343e-02f, 1.07762121e-01f, -2.62417123e-02f, -8.82580951e-02f, -4.58222777e-02f, 4.50604782e-02f, 7.97253028e-02f, 1.14745915e-01f, 6.50773197e-03f,
  3.89592685e-02f, 7.10268617e-02f, 1.64432116e-02f, -5.00874035e-02f, -2.49486249e-02f, 2.47548753e-03f, 2.03590794e-03f, -2.90304571e-02f, -7.58856088e-02f, 5.63993938e-02f,
  -5.52142262e-02f, 3.30114067e-02f, 6.61070284e-04f, -2.51566246e-02f, 1.63734723e-02f, 8.09329823e-02f, -3.64325643e-02f, 3.19148004e-02f, -2.21526604e-02f, -5.28420955e-02f,
  -2.39461064e-02f, -1.24642840e-02f, -4.44130935e-02f, 9.87082049e-02f, -3.61965820e-02f, -4.94218990e-02f, 2.44490914e-02f, 5.92746735e-02f, -3.65284421e-02f, 1.83375832e-02f,
  3.65093462e-02f, 1.64468244e-01f, -6.84998333e-02f, -1.06834747e-01f, -4.43816967e-02f, 5.47250696e-02f, 2.23633945e-02f, -3.81781645e-02f, 2.37824172e-02f, -3.30368690e-02f,
  1.31902128e-01f, -3.37920450e-02f, 9.84905735e-02f, 3.17560658e-02f, -3.43272798e-02f, -5.68636954e-02f, 2.68062465e-02f, -2.89481208e-02f, 6.39078170e-02f, 1.25250772e-01f,
  9.41760987e-02f, 1.98313799e-02f, 4.10011522e-02f, -1.13668278e-01f, -2.90208496e-02f, 1.16723357e-02f, 2.26349812e-02f, 4.68092971e-03f, 8.08788761e-02f, -3.88312191e-02f,
  1.62425846e-01f, -4.27215755e-01f, -1.78779677e-01f, -9.19771418e-02f, 1.09170571e-01f, -1.50337085e-01f, -1.39412522e-01f, -1.32242620e-01f, -5.97132072e-02f, -1.85379252e-01f,
  -2.03798175e-01f, -9.49466154e-02f, 4.94358456e-03f, -4.54779744e-01f, 1.57117754e-01f, -1.26011312e-01f, -1.77293018e-01f, -1.17622308e-01f, -3.22426409e-02f, -1.09782889e-01f,
  -4.89841886e-02f, -2.77906954e-01f, -7.76135400e-02f, -2.36130267e-01f, -2.44302213e-01f, 7.65598342e-02f, 1.82519883e-01f, -2.41095554e-02f, -1.80125847e-01f, -4.10618186e-02f,
  -1.64196178e-01f, -1.14811599e-01f, -4.07040194e-02f, -3.96290906e-02f, 1.27562255e-01f, 3.83132398e-02f, 4.70831804e-02f, -3.46274190e-02f, 4.81618568e-02f, 8.50541517e-02f,
  3.52570489e-02f, 1.33551499e-02f, -6.34044334e-02f, -4.88032438e-02f, -7.80492872e-02f, -2.37556230e-02f, -2.31163967e-02f, 5.48022613e-03f, -1.03326738e-01f, 4.08280361e-03f,
  3.22838575e-02f, 1.12544052e-01f, -1.86739415e-02f, 9.01175812e-02f, 1.02700263e-01f, -4.24806681e-03f, -4.61065285e-02f, 1.46473974e-01f, -1.95519384e-02f, 1.22087680e-01f,
  -3.23792659e-02f, 1.41780913e-01f, 2.82749981e-02f, -9.73534808e-02f, -5.57545386e-02f, -4.75019850e-02f, -8.46619308e-02f, -1.02911294e-01f, 2.06299592e-03f, -8.59526992e-02f,
  1.65645629e-02f, -6.61437539e-03f, -1.80273443e-01f, -5.63348271e-03f, 1.11311331e-01f, 3.21823359e-02f, 6.25713635e-03f, 1.10670112e-01f, 1.26669452e-01f, 2.28069723e-02f,
  -1.55468747e-01f, 2.58194357e-02f, 8.65846202e-02f, 7.01740608e-02f, -5.63305914e-02f, 1.64747685e-01f, -8.53690058e-02f, 2.93550119e-02f, 5.38560748e-02f, 1.83364912e-03f,
  1.40959352e-01f, 3.25503736e-03f, -7.31115863e-02f, -5.30026257e-02f, -6.66676983e-02f, -3.94558795e-02f, -1.55665502e-01f, -7.49170333e-02f, -7.47903949e-03f, -5.31216152e-02f,
  1.08720429e-01f, -2.86952704e-02f, 1.15433939e-01f, 3.65938656e-02f, -1.50490412e-02f, 3.81455980e-02f, 4.99556996e-02f, 3.03356368e-02f, 6.50062189e-02f, 3.45527045e-02f,
  8.42435807e-02f, 1.44614741e-01f, -5.66362264e-03f, 1.30363405e-01f, 2.17211172e-02f, 1.27002954e-01f, 6.17042109e-02f, 7.91808441e-02f, -4.18261588e-02f, 8.17124639e-03f,
  1.77175738e-02f, 2.41756797e-01f, 2.10635159e-02f, -4.35212702e-02f, 4.49750526e-03f, -3.11214998e-02f, -3.69108655e-02f, -8.72292221e-02f, -1.15437977e-01f, 2.46649936e-01f,
  -1.12081990e-01f, 3.16723734e-01f, -1.15290642e-01f, -1.99931815e-01f, -5.20413697e-01f, -3.31899881e-01f, -1.47769377e-01f, 6.62327185e-02f, -1.99807547e-02f, 1.33285940e-01f,
  -1.57707244e-01f, -3.01197529e-01f, -2.84782350e-01f, -5.56318797e-02f, 1.45384401e-01f, 2.14551300e-01f, -4.20810953e-02f, 1.22087508e-01f, 1.34558737e-01f, -8.87601897e-02f,
  -5.93239106e-02f, -1.20327743e-02f, 8.63276199e-02f, 3.24201435e-02f, -1.17571596e-02f, 6.66974410e-02f, 9.93870124e-02f, -8.90259519e-02f, -1.15932934e-01f, 2.13776622e-02f,
  1.05024099e-01f, -4.04307619e-02f, -1.42638879e-02f, -6.47294521e-02f, 1.19880848e-01f, 9.70428661e-02f, -1.58962968e-03f, 8.57516006e-02f, 5.62700704e-02f, -4.28374186e-02f,
  5.08880131e-02f, 2.89883614e-02f, 3.11180968e-02f, 5.10202013e-02f, 3.27756815e-02f, -1.79941077e-02f, 5.32268248e-02f, 1.46946326e-01f, 1.26912132e-01f, -1.19429920e-02f,
  -3.41935828e-02f, 4.28648889e-02f, 2.65514590e-02f, -3.59948091e-02f, -4.11763079e-02f, -5.01895584e-02f, 1.99737828e-02f, -2.34658830e-02f, -2.70172097e-02f, 1.67895164e-02f,
  4.08499315e-02f, 1.06516026e-01f, -3.82069275e-02f, 3.92716974e-02f, 2.00355984e-03f, 1.82773545e-02f, -4.41577025e-02f, 4.75389659e-02f, 4.61850176e-03f, -1.72995739e-02f,
  1.27830850e-02f, -4.87545021e-02f, 3.95788737e-02f, 3.43048759e-02f, -4.59857136e-02f, -3.18337791e-02f, 5.16400151e-02f, -2.23293230e-02f, -3.16146910e-02f, -4.97994982e-02f,
  1.92996599e-02f, 6.40337318e-02f, 2.69758496e-02f, 2.25301851e-02f, 3.32088359e-02f, 1.73741970e-02f, -4.69393618e-02f, 2.32481235e-03f, -1.09748300e-02f, -3.74998488e-02f,
  1.56343784e-02f, 5.58668226e-02f, 8.76244009e-02f, -1.07849017e-02f, -3.78130488e-02f, -5.52028418e-02f, 3.98636274e-02f, 5.66338859e-02f, 4.36218418e-02f, 3.95315140e-02f,
  7.51527175e-02f, 6.75611869e-02f, -1.03346169e-01f, 4.14613113e-02f, 6.08502254e-02f, 4.45847809e-02f, 1.17851727e-01f, 4.54184674e-02f, 1.83855053e-02f, 5.85683323e-02f,
  5.19210935e-01f, -1.49464354e-01f, -2.16121048e-01f, 2.47996479e-01f, 3.34458202e-01f, 3.06962967e-01f, 2.13462710e-01f, 1.94186077e-01f, 2.25775108e-01f, -2.22764567e-01f,
  9.65861753e-02f, -1.53242663e-01f, -3.52971524e-01f, 2.87280828e-01f, 4.39355969e-01f, -2.23386928e-01f, 3.40359241e-01f, 1.26638666e-01f, 2.90950313e-02f, 1.58715665e-01f,
  2.12936088e-01f, 4.29498851e-01f, -1.91704825e-01f, -1.33172963e-02f, 2.40549937e-01f, -1.58157676e-01f, -9.66971219e-02f, -2.67854452e-01f, -4.75603454e-02f, 1.16429158e-01f,
  3.88919935e-02f, 1.22546248e-01f, 7.56644979e-02f, -1.07394576e-01f, 9.64927003e-02f, -7.51763768e-03f, -8.17103013e-02f, -5.76239116e-02f, -5.37390262e-02f, -5.12405261e-02f,
  -6.13608137e-02f, -3.26330122e-03f, 1.19129114e-01f, -8.93485472e-02f, 1.06295668e-01f, 3.79213132e-02f, -1.95976067e-02f, -3.54359262e-02f, -9.58232954e-02f, 4.13166313e-03f,
  -8.13770574e-03f, 1.06172767e-02f, 9.17918757e-02f, -9.02225450e-02f, -3.83660547e-03f, 3.06429919e-02f, -1.18333101e-01f, -5.72092570e-02f, -4.57768589e-02f, 1.17057562e-01f,
  2.88049914e-02f, -3.67075950e-02f, 1.90812908e-02f, -5.33367954e-02f, 9.39263105e-02f, -4.81759058e-03f, -1.90148875e-03f, 1.14385188e-02f, 1.39731951e-02f, 1.41655281e-02f,
  9.74653661e-03f, 6.87284097e-02f, 7.77346864e-02f, -4.08018269e-02f, 9.08103958e-02f, 4.45520580e-02f, -7.41063710e-03f, -4.15726490e-02f, 5.16506694e-02f, -1.26330471e-02f,
  -3.74856703e-02f, 8.17046091e-02f, -2.85486095e-02f, -9.64918435e-02f, 1.33626675e-02f, -3.21596600e-02f, 9.00590122e-02f, 7.03272969e-02f, -1.09725259e-01f, 2.17407532e-02f,
  3.09882369e-02f, 4.70641330e-02f, -3.12815383e-02f, -5.43016680e-02f, -3.48953232e-02f, 8.57710540e-02f, 3.70922647e-02f, 1.23003446e-01f, 2.66199396e-03f, 1.01550549e-01f,
  1.18264347e-01f, -6.02907352e-02f, -9.19289887e-03f, -6.30261302e-02f, -4.68284450e-02f, 9.44427326e-02f, -8.95806178e-02f, -4.32871766e-02f, 5.60876727e-02f, 2.02565882e-02f,
  -4.50992584e-02f, -4.75523211e-02f, 2.72685252e-02f, 1.16268277e-01f, 6.89400584e-02f, -3.52537408e-02f, -3.47196171e-03f, -3.24132703e-02f, -1.36981783e-02f, -5.61502650e-02f,
  2.70332307e-01f, -1.13624550e-01f, -4.45914716e-01f, -1.22943304e-01f, 3.73644769e-01f, 2.24962667e-01f, -1.75386220e-01f, 2.52120733e-01f, -2.96890974e-01f, 7.34095722e-02f,
  2.44018540e-01f, -1.15909584e-01f, -2.85581678e-01f, 1.32960632e-01f, 2.19346151e-01f, -4.16971028e-01f, 2.38860995e-01f, 1.10892378e-01f, -1.14115879e-01f, 2.39063412e-01f,
  2.93469783e-02f, 4.84914213e-01f, -5.21316640e-02f, 3.87582898e-01f, 2.73219019e-01f, 3.64462882e-02f, 2.51229078e-01f, -1.57778159e-01f, 2.86106169e-01f, 1.16482712e-01f,
  -8.47100094e-03f, -1.56443622e-02f, -5.24158254e-02f, -1.10801615e-01f, 4.02107723e-02f, -9.87558439e-03f, -1.02165546e-02f, 1.98553652e-02f, -3.96313779e-02f, -2.75249202e-02f,
  1.61918253e-02f, 4.73306440e-02f, 1.09295689e-01f, -3.79536711e-02f, 4.61469181e-02f, -1.84982289e-02f, 1.28893449e-03f, -1.41183078e-01f, -5.86772412e-02f, -5.17568216e-02f,
  -9.83279720e-02f, 1.80918407e-02f, 4.39057313e-02f, 3.36396843e-02f, 3.96804251e-02f, 6.98876977e-02f, -7.11182877e-02f, -6.08272515e-02f, 4.32211384e-02f, 4.37197499e-02f,
  1.43535122e-01f, -1.17008962e-01f, 1.53948432e-02f, -9.45638940e-02f, -3.30210440e-02f, 7.20076077e-03f, 9.77551827e-05f, 2.94288136e-02f, -1.16669238e-01f, -4.00494374e-02f,
  3.72885913e-02f, -3.30083929e-02f, -7.32575133e-02f, 1.81269515e-02f, 5.57839610e-02f, -5.08703142e-02f, -2.12376900e-02f, 1.79564394e-02f, -6.01925626e-02f, -2.76182555e-02f,
  -8.59281868e-02f, 6.41597286e-02f, -3.56641784e-02f, 5.68547919e-02f, 1.78006403e-02f, 4.59857434e-02f, 5.17244749e-02f, -1.36308791e-02f, -1.33638189e-03f, 4.81307656e-02f,
  2.54154932e-02f, 2.34159976e-01f, -2.95767896e-02f, -1.01095857e-02f, -1.40869066e-01f, 1.09674506e-01f, -1.18503995e-01f, 1.23517260e-01f, 5.80419451e-02f, 6.20233081e-02f,
  9.70675796e-02f, 1.32716075e-02f, 2.93390360e-04f, 4.48315628e-02f, -1.04976550e-03f, 1.13716967e-01f, 5.75376712e-02f, -3.67295817e-02f, 7.41050690e-02f, 1.21909901e-01f,
  7.23305941e-02f, 1.52351767e-01f, -9.17232260e-02f, 1.08140305e-01f, 1.24750033e-01f, 5.43035287e-03f, 1.66842982e-01f, -7.99869150e-02f, 1.49015384e-02f, -1.10077992e-01f,
  -7.03099519e-02f, 5.36063492e-01f, 1.40501454e-01f, -1.32877780e-02f, -8.38791113e-03f, -4.04162735e-01f, -1.71639532e-01f, 1.69896439e-01f, 9.74929929e-02f, 1.38625875e-01f,
  -8.52354765e-02f, 3.06616843e-01f, 1.62147269e-01f, -1.81454234e-02f, -4.38696653e-01f, -1.90857083e-01f, -3.27269733e-01f, -1.07219137e-01f, 5.63366944e-03f, -1.10584283e-02f,
  -7.83012658e-02f, -5.66261075e-02f, 2.47027408e-02f, 1.26945958e-01f, 4.62596603e-02f, 2.42878199e-01f, 2.45199726e-06f, 2.24623665e-01f, -5.91079369e-02f, 3.85586638e-03f,
  -1.35284930e-01f, 3.10266107e-01f, 1.08425096e-01f, -7.45558888e-02f, -1.81290731e-01f, -5.31851649e-02f, -5.38221858e-02f, 8.56584460e-02f, 4.67920266e-02f, -3.70017551e-02f,
  6.80231228e-02f, 6.24597035e-02f, 7.54869953e-02f, 7.69089529e-05f, 3.07967924e-02f, 9.70512107e-02f, 5.30067496e-02f, -9.26314890e-02f, 8.42664763e-02f, -5.48581034e-02f,
  6.89027384e-02f, -9.27385408e-03f, -8.43068510e-02f, -2.55674869e-02f, 8.11698735e-02f, -2.04685181e-02f, -7.81772435e-02f, 2.30265297e-02f, 3.36251780e-02f, -1.99806374e-02f,
  3.36678363e-02f, -8.89146030e-02f, -1.54036433e-02f, 3.20518389e-02f, 4.83624171e-03f, 8.90589580e-02f, 4.29115072e-02f, 9.27682593e-02f, 4.65982445e-02f, 5.13048023e-02f,
  -3.47649418e-02f, 4.35719313e-03f, -4.42882255e-03f, -8.86716619e-02f, 2.11154632e-02f, 2.42989380e-02f, -2.05201786e-02f, 5.29095046e-02f, -5.22296280e-02f, 2.55507417e-02f,
  3.98739018e-02f, -5.48699722e-02f, 6.87675625e-02f, -2.14327388e-02f, -8.11228976e-02f, 2.76350155e-02f, 5.69007620e-02f, 2.46550310e-02f, 1.14799952e-02f, -4.99024894e-03f,
  -2.41915345e-01f, 8.01913515e-02f, 4.90782559e-02f, 1.77345257e-02f, 3.21240537e-02f, -1.56796649e-02f, 8.18155613e-03f, -4.82027382e-02f, 4.29062657e-02f, -5.21272197e-02f,
  -1.09272404e-02f, -4.52508293e-02f, -1.03500009e-01f, -3.24586667e-02f, 2.22177114e-02f, -1.51812375e-01f, -1.10921497e-02f, -8.20756704e-03f, -3.80864888e-02f, 6.73596263e-02f,
  1.00196324e-01f, 8.47882479e-02f, 5.95959462e-02f, 9.34269652e-03f, 2.18416918e-02f, -2.27418523e-02f, 3.60878441e-03f, 1.21613424e-02f, 4.31710221e-02f, 3.19925882e-02f,
  -8.65473673e-02f, 7.61888251e-02f, -2.80872226e-01f, 2.21623182e-01f, 1.07380584e-01f, 8.48188400e-02f, 1.43727858e-03f, 1.32076606e-01f, 5.41446768e-02f, 2.59542763e-01f,
  3.39847416e-01f, -1.42906941e-02f, -1.45574184e-02f, 4.95275497e-01f, 2.64574736e-01f, 1.44464627e-01f, 4.16050225e-01f, 2.40711927e-01f, 1.35997515e-02f, 2.19602898e-01f,
  9.63329747e-02f, 4.20927733e-01f, 1.28583610e-01f, 6.33651391e-02f, 1.96129844e-01f, -2.59128600e-01f, 1.79391578e-01f, -2.80015260e-01f, 2.33214989e-01f, 3.77232619e-02f,
  9.50119719e-02f, 6.96631372e-02f, -6.14793459e-03f, -2.05141425e-01f, 3.37204561e-02f, -7.82279298e-02f, -3.05025186e-02f, -2.17203513e-01f, -1.22404873e-01f, -6.62767664e-02f,
  -1.05156176e-01f, -2.61216834e-02f, 2.37937476e-02f, -2.98280083e-02f, 1.87448282e-02f, -3.37794386e-02f, 6.35340661e-02f, 5.65690808e-02f, 5.31127043e-02f, -9.04611312e-03f,
  5.38052507e-02f, 5.37807606e-02f, 6.31555915e-02f, 3.87716852e-02f, -4.05454524e-02f, 9.10024252e-03f, 2.53074355e-02f, -2.61330884e-02f, 2.54017357e-02f, 8.94091502e-02f,
  -6.61245435e-02f, 6.74708001e-03f, 2.78349370e-02f, -8.15802813e-03f, -7.10449647e-03f, 5.15994653e-02f, 3.54578309e-02f, 3.76064591e-02f, -8.85755569e-02f, 1.25493854e-01f,
  -3.13087221e-04f, -4.14230339e-02f, 5.31030372e-02f, -2.69485582e-02f, 9.40517858e-02f, 4.16367315e-02f, -1.05082154e-01f, -8.70851055e-03f, 8.33371133e-02f, 4.28631715e-02f,
  -8.60841796e-02f, 4.04256098e-02f, -1.44305769e-02f, -7.48212263e-02f, 1.22824451e-02f, -9.35637280e-02f, 9.82374791e-03f, 7.31442571e-02f, 2.06271168e-02f, -7.52717927e-02f,
  2.11602822e-01f, 7.64804035e-02f, 3.94041128e-02f, -5.76917976e-02f, -5.27947880e-02f, 6.27727136e-02f, 3.40084406e-03f, -3.36554796e-02f, -8.62841904e-02f, -2.96899322e-02f,
  -4.13629115e-02f, 2.18713135e-02f, -5.15440330e-02f, 7.30041787e-02f, 3.39356251e-02f, 9.84160677e-02f, 6.21565711e-03f, -6.98814318e-02f, 2.02924293e-02f, 4.23695557e-02f,
  4.11181636e-02f, -3.36979539e-03f, -4.38500643e-02f, -2.26228349e-02f, 2.65516099e-02f, -5.66720497e-04f, 5.89682758e-02f, -4.66003967e-03f, -2.34610885e-02f, 6.64279088e-02f,
  -4.67514485e-01f, -2.04082996e-01f, 1.75936878e-01f, 2.09076867e-01f, -7.61901140e-02f, -3.32263678e-01f, -3.37079197e-01f, -3.10514390e-01f, -6.14594296e-02f, -4.27493900e-01f,
  -3.60997647e-01f, 9.86868739e-02f, -4.02986169e-01f, 2.32257947e-01f, 4.08970177e-01f, 6.28823414e-02f, 2.14569569e-01f, 1.33656397e-01f, 3.75223905e-01f, 4.46248390e-02f,
  3.40264887e-01f, 2.42575154e-01f, 4.40833002e-01f, 4.02486414e-01f, 1.55139446e-01f, 2.66267598e-01f, 4.49817121e-01f, 3.16588104e-01f, 4.07075822e-01f, 2.05736950e-01f,
  -1.59379482e-01f, -1.67464897e-01f, 1.39193813e-04f, 4.39625531e-02f, -4.69012149e-02f, -1.22405261e-01f, 9.25361644e-03f, -4.10753302e-02f, 8.50908384e-02f, 6.47196500e-03f,
  -1.05755448e-01f, 7.19746873e-02f, 1.19116887e-01f, 9.01748016e-02f, -1.13913879e-01f, 1.77186280e-01f, 1.41094550e-01f, -1.09858923e-01f, -5.92005551e-02f, -5.74787287e-03f,
  9.82971210e-03f, -5.97227998e-02f, -4.38005812e-02f, 9.51058939e-02f, 1.73062131e-01f, -9.43457615e-03f, 9.42078531e-02f, 2.68199518e-02f, 6.79200292e-02f, 6.29659593e-02f,
  -7.68529102e-02f, 1.49555102e-01f, 3.16815041e-02f, 3.30568925e-02f, -2.31493767e-02f, -7.72153437e-02f, 5.85961640e-02f, -3.95353884e-02f, 3.26556042e-02f, -5.49463034e-02f,
  8.79506208e-03f, 3.07479464e-02f, 3.62421013e-02f, -2.26553231e-02f, -6.25628605e-02f, -7.08281100e-02f, -5.93018718e-02f, 7.75924399e-02f, -3.99849676e-02f, -2.21378971e-02f,
  -6.59932196e-02f, 2.18660962e-02f, 8.12676325e-02f, -3.30747962e-02f, -1.44402876e-01f, -4.60825898e-02f, 4.52573523e-02f, -2.94640008e-02f, 6.90101041e-03f, 7.90281519e-02f,
  -6.70159161e-02f, 2.29297429e-01f, 8.28174427e-02f, -2.99317110e-02f, 8.50032419e-02f, 4.32316177e-02f, 1.45887360e-01f, 6.50988966e-02f, -5.25069200e-02f, 7.09548965e-02f,
  -7.18514770e-02f, 2.65089199e-02f, -5.58915287e-02f, -3.75972949e-02f, 7.01347589e-02f, -6.84338063e-02f, -1.04131280e-02f, -1.15263900e-02f, -2.52135545e-02f, 7.77471289e-02f,
  3.25554051e-02f, -6.18238188e-02f, 9.82908681e-02f, 1.75189033e-01f, -5.71114123e-02f, -1.03072889e-01f, -7.85671845e-02f, -3.13675329e-02f, 1.06154397e-01f, 6.47092760e-02f,
  2.64270872e-01f, 1.94740206e-01f, 3.12058747e-01f, 3.49576861e-01f, 1.68718621e-01f, 1.71927363e-01f, 5.15279807e-02f, 1.07925206e-01f, 4.95067507e-01f, 1.16632562e-02f,
  -2.54606724e-01f, 1.13430038e-01f, -2.58419365e-01f, 1.05075672e-01f, -3.66899192e-01f, -1.21116348e-01f, 2.04770163e-01f, 7.64403418e-02f, 1.81382626e-01f, 4.66693603e-02f,
  3.21445242e-02f, -3.14978242e-01f, -2.60461986e-01f, -2.21142039e-01f, 1.47826895e-01f, 2.24540234e-01f, -3.20208102e-01f, -9.41704065e-02f, -4.95961867e-02f, -1.09245360e-01f,
  3.23967449e-02f, 3.73502448e-02f, 1.09216243e-01f, 2.29102317e-02f, 4.14367542e-02f, 1.43121276e-02f, 3.66430208e-02f, -1.60126507e-01f, -7.16243386e-02f, 4.99512069e-02f,
  6.16487898e-02f, -3.08477283e-02f, 2.22575106e-02f, -1.27761170e-01f, 9.16531011e-02f, 2.38454202e-03f, 1.25176087e-01f, 1.47776470e-01f, -5.90798818e-02f, -1.75518710e-02f,
  4.47052009e-02f, 1.18031427e-01f, 1.75771326e-01f, -6.81836682e-05f, 8.42913240e-02f, 1.02158889e-01f, 9.15456638e-02f, -1.10766247e-01f, 5.74404784e-02f, 1.02403574e-01f,
  -6.53608143e-02f, 8.63137692e-02f, -3.33670639e-02f, 9.86674335e-04f, -6.17950894e-02f, 2.70963833e-03f, 1.42458854e-02f, -2.87072938e-02f, 3.79401669e-02f, 2.11734995e-02f,
  3.16253453e-02f, 1.83073226e-02f, 5.48728257e-02f, 1.23909414e-01f, -2.21005119e-02f, 9.76093411e-02f, -9.54523310e-02f, 4.50120531e-02f, 4.42202538e-02f, 5.85413771e-03f,
  -1.25549182e-01f, -2.59715877e-03f, -1.05342984e-01f, -1.49372881e-02f, -5.35534136e-02f, -1.36574442e-02f, 5.33252656e-02f, -2.94497889e-03f, -1.79246888e-02f, -1.07020892e-01f,
  7.48058930e-02f, 1.34678558e-01f, 2.86875702e-02f, -7.51585588e-02f, -5.84135689e-02f, -7.08855968e-03f, 3.26951519e-02f, 6.52621016e-02f, -3.52647603e-02f, -1.39140198e-02f,
  6.39950186e-02f, 1.51029043e-02f, 6.50293753e-02f, -2.59464961e-02f, -4.38126139e-02f, -8.19193497e-02f, 2.61645950e-02f, 1.00278787e-01f, 9.13172141e-02f, 1.46457395e-02f,
  7.48348683e-02f, 1.10703357e-01f, -7.42931757e-03f, 1.22330599e-01f, 1.20580971e-01f, -6.69657215e-02f, 1.08773574e-01f, -1.71860047e-02f, -7.61449412e-02f, 3.80934402e-02f,
  -3.08471262e-01f, 3.87392759e-01f, 4.56192970e-01f, -2.89633840e-01f, 2.26000205e-01f, 2.90648550e-01f, -3.17287177e-01f, 2.78611630e-01f, 5.93732148e-02f, -1.49542853e-01f,
  -2.78375566e-01f, -8.71517435e-02f, -6.46150336e-02f, -2.56117806e-02f, -2.87403554e-01f, -1.12118438e-01f, -1.55426130e-01f, -2.69749016e-01f, 4.85045873e-02f, -1.56008258e-01f,
  -5.96420141e-03f, -2.91648388e-01f, 1.86722800e-02f, 3.01665574e-01f, 2.74543434e-01f, 1.79940835e-01f, -2.52173930e-01f, 7.56556764e-02f, -1.24228885e-02f, -3.71069671e-03f,
  -5.50971813e-02f, -9.83703583e-02f, 8.49521011e-02f, 1.70527995e-01f, 3.73863094e-02f, -4.72710356e-02f, -8.66325013e-03f, -6.82818517e-02f, -1.29938098e-02f, 1.13347813e-01f,
  2.07616482e-02f, 1.03691757e-01f, -7.15692937e-02f, 6.90210238e-02f, 9.27619934e-02f, 9.75002199e-02f, 1.46917179e-01f, 8.73566866e-02f, 7.20804930e-02f, 1.71542853e-01f,
  7.64880255e-02f, 1.68392986e-01f, 6.14692457e-02f, -8.24785754e-02f, 4.21114676e-02f, 8.46568123e-03f, -1.23434095e-02f, 5.07300049e-02f, 9.29812118e-02f, 5.23412153e-02f,
  1.37705266e-01f, -8.36486667e-02f, -5.08015305e-02f, -6.01339936e-02f, -6.86489716e-02f, 1.06889516e-01f, -1.07193649e-01f, -3.95894833e-02f, 3.14211212e-02f, 5.56723550e-02f,
  3.58901322e-02f, -1.39610237e-02f, 5.82174622e-02f, 4.58541550e-02f, -1.00087047e-01f, 1.02033848e-02f, 1.46997655e-02f, 2.88596135e-02f, -1.57687217e-02f, 4.82962318e-02f,
  -1.15221865e-01f, -1.10115230e-01f, -3.34150940e-02f, 3.72720994e-02f, -6.69450983e-02f, 3.67622972e-02f, 8.69462937e-02f, 1.09628439e-01f, -3.47533822e-02f, -1.29649505e-01f,
  -4.56241757e-01f, -3.81100625e-01f, -6.32293895e-02f, -2.42735539e-02f, -7.69028440e-02f, -8.01131725e-02f, 2.11189762e-02f, 6.46958277e-02f, -3.13007347e-02f, 2.40730513e-02f,
  1.45526960e-01f, 5.40913269e-02f, -6.38960451e-02f, -3.75276394e-02f, -6.78576156e-02f, -1.00702094e-02f, -2.00871661e-01f, -1.53422654e-01f, -1.18225448e-01f, 6.26420453e-02f,
  -3.09674023e-03f, -1.45149939e-02f, -7.65748620e-02f, 5.08973114e-02f, -5.00460900e-02f, -8.23006704e-02f, -7.53440708e-02f, 9.71769691e-02f, -6.12675287e-02f, -1.73438024e-02f,
  -4.66213733e-01f, 1.48236647e-01f, 5.20547211e-01f, -3.80050182e-01f, 1.51653634e-02f, 3.24846298e-01f, 2.56726779e-02f, -2.66157798e-02f, -4.02462095e-01f, -1.15250272e-03f,
  -3.03873569e-02f, 2.22915366e-01f, -6.32563792e-03f, -1.45822361e-01f, -1.96624473e-01f, -2.43686154e-01f, -3.18575591e-01f, -1.08728297e-01f, -1.12914927e-01f, -6.48381263e-02f,
  -9.84217972e-02f, -2.74872988e-01f, -1.62324030e-02f, 2.48198621e-02f, 1.81519538e-01f, 1.01853229e-01f, -1.64096370e-01f, 2.28739873e-01f, 3.88644561e-02f, 1.98733568e-01f,
  -8.80061612e-02f, -1.56833589e-01f, -5.30689545e-02f, 5.69156520e-02f, 8.78959373e-02f, 6.54418394e-02f, 9.24249887e-02f, 8.35352764e-02f, -1.23468801e-01f, 4.35504876e-02f,
  -1.37222568e-02f, 1.39033301e-02f, 1.99528523e-02f, -1.78768616e-02f, -6.64459988e-02f, 2.54019070e-02f, 5.14727347e-02f, 3.42795695e-03f, -4.22695056e-02f, -8.09200760e-03f,
  8.70628729e-02f, 8.97271410e-02f, 8.09090883e-02f, 3.20183635e-02f, 6.30409047e-02f, 4.23021764e-02f, -1.26687273e-01f, 8.76398757e-02f, -1.81641355e-02f, 7.98331201e-03f,
  -4.63608615e-02f, -1.72351189e-02f, -7.29803229e-03f, 1.62507147e-02f, -2.20339186e-02f, 7.99020939e-03f, -6.13092296e-02f, -8.08248892e-02f, 1.02305666e-01f, -3.70818451e-02f,
  -1.00817978e-01f, -1.56961922e-02f, -9.31948051e-02f, -1.54297268e-02f, -6.34486079e-02f, -1.40394166e-01f, 1.28402695e-01f, 1.23590983e-01f, -6.68966398e-03f, 8.08467120e-02f,
  -6.03935644e-02f, 6.87521175e-02f, -7.84641430e-02f, -6.17544465e-02f, -1.13849854e-02f, -5.32525741e-02f, 1.03694923e-01f, 3.03578060e-02f, -2.53753997e-02f, 6.80033490e-02f,
  -1.06240571e-01f, -1.79853007e-01f, -1.36660948e-01f, -2.71374434e-02f, -7.15441704e-02f, 2.97130644e-02f, -2.57775635e-02f, 3.89901251e-02f, -5.66943623e-02f, -8.06980506e-02f,
  7.02890307e-02f, -4.76558208e-02f, 7.71223679e-02f, -5.63251488e-02f, 1.81312747e-02f, -3.54256257e-02f, -7.23450035e-02f, -5.43971285e-02f, -3.00557353e-02f, 6.26419410e-02f,
  3.29110250e-02f, -5.08813225e-02f, 1.28700376e-01f, -1.67301688e-02f, -1.53849185e-01f, 6.43721372e-02f, -1.62959158e-01f, -2.62840446e-02f, -2.36743987e-02f, 8.78721476e-02f,
  -3.36368233e-01f, -4.05057594e-02f, -4.34393197e-01f, -3.72900724e-01f, 3.02343190e-01f, -4.69985545e-01f, -2.35247746e-01f, -4.03063260e-02f, -7.05644637e-02f, 2.27689296e-01f,
  3.57839651e-02f, -1.86810523e-01f, 1.55230716e-01f, -4.55023140e-01f, -6.34754658e-01f, -3.19503963e-01f, -5.12869298e-01f, -3.16994965e-01f, -6.46990538e-02f, -4.74618487e-02f,
  -2.12674260e-01f, 4.50075120e-02f, -4.17911321e-01f, 3.76650482e-01f, -3.42780165e-02f, 1.78430066e-01f, 2.40738377e-01f, 2.55306721e-01f, -1.05908714e-01f, -2.66692601e-02f,
  -2.48651057e-01f, 4.00220379e-02f, -3.50614302e-02f, -9.32601169e-02f, -6.12347089e-02f, 1.18874453e-01f, -4.88941185e-02f, -7.73504889e-03f, -3.09547577e-02f, -5.14817573e-02f,
  7.50251636e-02f, 3.34509686e-02f, 1.25251627e-02f, 4.24145199e-02f, 7.97607899e-02f, -1.13240350e-03f, -1.42464444e-01f, -1.06316335e-01f, 1.88436788e-02f, -1.64631516e-01f,
  -1.65096566e-01f, -1.31737605e-01f, 9.42605827e-03f, -1.33874752e-02f, 4.14374797e-03f, 2.67974213e-02f, -1.13109887e-01f, -3.13145220e-02f, -3.02883750e-03f, -4.08423580e-02f,
  6.03056028e-02f, 7.67797455e-02f, -4.87114079e-02f, -4.39741425e-02f, 2.01027561e-02f, 1.85348075e-02f, 3.16291675e-02f, 4.91585024e-02f, 4.55713011e-02f, 3.62266153e-02f,
  5.63020967e-02f, -2.60748640e-02f, 2.68178377e-02f, -3.22575271e-02f, -7.97247961e-02f, 4.66726115e-03f, 1.04853194e-02f, 4.74656150e-02f, -2.02983450e-02f, -1.27582282e-01f,
  9.13149491e-02f, -2.60702204e-02f, 1.18703721e-02f, 6.24688230e-02f, -1.11691371e-01f, -1.13524236e-02f, 6.72935098e-02f, -7.79973045e-02f, -9.98835359e-03f, 1.08947225e-01f,
  -1.97849479e-02f, 1.23947665e-01f, 3.55258286e-02f, 5.23280650e-02f, -4.08396497e-03f, -1.81424478e-03f, -6.41418472e-02f, -3.19527015e-02f, -3.90228778e-02f, 6.73403591e-02f,
  -5.05547179e-03f, 8.14007446e-02f, 1.41163930e-01f, -2.88377460e-02f, -4.33004536e-02f, -3.24202850e-02f, 8.82606059e-02f, 9.60403830e-02f, 7.72198737e-02f, -6.31397183e-04f,
  1.22524753e-01f, 9.70577821e-02f, 7.14452043e-02f, 4.88624051e-02f, 8.40025097e-02f, 4.10686918e-02f, 7.28837550e-02f, 2.35671978e-02f, 7.45157748e-02f, -4.82306518e-02f,
  -1.56591207e-01f, -4.68565635e-02f, 5.98775968e-02f, -4.11729634e-01f, 2.81578936e-02f, -3.29789482e-02f, -9.33536962e-02f, -2.47791648e-01f, -1.98495641e-01f, -1.77036971e-01f,
  -1.87875703e-01f, -9.38054733e-03f, 2.40368962e-01f, -2.08748788e-01f, 2.09519148e-01f, 3.29464555e-01f, -2.88615972e-01f, -2.34922394e-01f, 6.31566942e-02f, -2.05236956e-01f,
  -1.26904950e-01f, -1.40378356e-01f, 1.20494537e-01f, -1.58838823e-01f, -1.39376253e-01f, -1.90469041e-01f, -1.10615067e-01f, 1.12890430e-01f, -2.67209888e-01f, 4.50239144e-02f,
  1.06452316e-01f, 1.52042657e-01f, 1.36887908e-01f, 5.25107495e-02f, 5.18693179e-02f, 4.31637391e-02f, -3.27619351e-02f, 4.91852984e-02f, 3.79576460e-02f, -1.09136991e-01f,
  -1.04140438e-01f, 7.51591101e-02f, -1.52604759e-01f, 8.16354454e-02f, -1.31792113e-01f, -4.26374525e-02f, 9.90299284e-02f, -5.37464321e-02f, 2.74286196e-02f, 8.98904726e-02f,
  1.52154379e-02f, -8.24077614e-03f, -4.39869575e-02f, -3.19611318e-02f, 4.22758656e-03f, -5.54655641e-02f, 7.49768689e-02f, 5.26008271e-02f, -7.14756250e-02f, -1.21363431e-01f,
  -5.86656295e-02f, -3.78463045e-02f, 9.92454886e-02f, 1.00900838e-02f, 2.46938542e-02f, 5.73834926e-02f, -4.34420109e-02f, 1.03498466e-01f, -2.73928861e-03f, 1.87401958e-02f,
  1.08118635e-02f, 1.90170743e-02f, 5.73808998e-02f, -1.33858979e-01f, -5.37104122e-02f, 6.42203493e-03f, 3.47121172e-02f, -7.17003550e-03f, -9.37614515e-02f, -9.11318418e-03f,
  -3.51204872e-02f, -6.21733628e-02f, 4.35092896e-02f, -6.76892996e-02f, -1.06991790e-02f, 1.61850732e-02f, -9.27328765e-02f, 6.16236292e-02f, 6.92850957e-03f, 1.26921237e-02f,
  4.15752307e-02f, -8.98787007e-02f, 1.35120794e-01f, -1.44878896e-02f, 1.35088086e-01f, 1.04985878e-01f, -3.78638245e-02f, -1.60543099e-01f, -9.29826945e-02f, -3.41648869e-02f,
  -2.55760401e-01f, -1.32238884e-02f, -1.31663084e-01f, -3.46392840e-02f, -9.91346389e-02f, -5.70924245e-02f, -5.73373027e-02f, -1.10914156e-01f, -2.54774373e-02f, -1.21913023e-01f,
  -3.55190597e-02f, -1.90966371e-02f, 2.82585230e-02f, -2.93376576e-02f, -5.30162938e-02f, -1.02328241e-01f, 4.32401411e-02f, -3.32531519e-02f, -4.05050628e-02f, -8.14870223e-02f,
  8.25583756e-01f, -2.16279432e-01f, 5.79325184e-02f, 3.65800202e-01f, 2.66429484e-01f, -2.92886123e-02f, 1.35978863e-01f, 1.52822897e-01f, 2.77312398e-01f, -2.47117788e-01f,
  -6.17760979e-02f, -5.09954132e-02f, -2.63695508e-01f, 1.43287599e-01f, -1.46156177e-01f, -1.92337230e-01f, 1.21944830e-01f, -1.40469912e-02f, 1.35927126e-01f, 1.57358348e-01f,
  1.58385754e-01f, -2.24250779e-02f, -7.72629827e-02f, -1.38906643e-01f, 2.35678345e-01f, 6.15689941e-02f, -2.60673821e-01f, -2.07448736e-01f, -8.31618160e-02f, -9.24722180e-02f,
  1.12983502e-01f, 2.06063196e-01f, 8.29783902e-02f, -1.20111797e-02f, 7.86080658e-02f, 9.41842869e-02f, -6.96642697e-02f, -1.17864527e-01f, 6.28462285e-02f, 2.58272160e-02f,
  -9.83607098e-02f, 2.64740549e-02f, -2.33740918e-02f, -9.58018750e-02f, 2.25230008e-01f, 4.71560247e-02f, 1.09753445e-01f, 1.03322510e-02f, -4.04754132e-02f, 9.34841111e-02f,
  1.34127781e-01f, 6.50037304e-02f, 7.54967034e-02f, -8.23748559e-02f, 9.96672828e-03f, 9.93434638e-02f, -9.06446651e-02f, -1.29172921e-01f, -6.68635368e-02f, 8.16440880e-02f,
  -1.25807710e-02f, -5.68410903e-02f, 5.44751137e-02f, 8.45048055e-02f, 6.39858469e-02f, 6.59784954e-03f, 5.77509850e-02f, -7.58155137e-02f, -2.64434088e-02f, -5.40037155e-02f,
  3.61469784e-03f, 6.08255528e-02f, 1.50603000e-02f, 1.64475851e-02f, 3.25985625e-02f, 7.07412735e-02f, -3.91726233e-02f, -6.82312921e-02f, 4.43373248e-02f, 5.75358048e-02f,
  1.90340523e-02f, 2.63835900e-02f, 2.78191902e-02f, -9.11000837e-03f, -5.55764697e-02f, -3.31453569e-02f, -6.43460304e-02f, 1.07241370e-01f, -6.16831705e-03f, -5.20608835e-02f,
  -2.04715922e-01f, -4.40229893e-01f, -4.63471934e-02f, -1.17569678e-02f, -9.33690295e-02f, 5.46120107e-02f, -3.83848115e-03f, 7.52106011e-02f, -1.18514411e-01f, -1.25087528e-02f,
  -2.66407225e-02f, 4.84991260e-02f, -2.24242806e-02f, 3.59586477e-02f, -7.66992941e-02f, 3.77385467e-02f, -1.51494235e-01f, -3.48501392e-02f, -8.31826925e-02f, -9.16122943e-02f,
  7.12230522e-03f, 5.40640065e-03f, 1.74618792e-02f, 5.72526176e-03f, -1.11645162e-01f, -1.13363206e-01f, 2.04584599e-02f, -1.10053392e-02f, -7.37507418e-02f, -1.23910308e-01f,
  -5.10586262e-01f, -1.11970954e-01f, 3.59405071e-01f, -4.17856693e-01f, -9.14400630e-03f, 3.55978340e-01f, 3.11566412e-01f, -1.22861579e-01f, -3.47681165e-01f, -1.84113249e-01f,
  4.95999539e-03f, -4.70237359e-02f, 2.98258722e-01f, -1.46506250e-01f, 4.59433526e-01f, 2.35772997e-01f, -1.16002567e-01f, -3.59030552e-02f, -5.78713194e-02f, -2.22393304e-01f,
  -1.40195370e-01f, -2.44787872e-01f, 2.71348387e-01f, -2.64408767e-01f, -6.94061890e-02f, -1.62759408e-01f, -1.27076656e-01f, 1.99069485e-01f, -2.17444897e-01f, 1.26237929e-01f,
  -5.00855185e-02f, -3.08699846e-01f, 8.05816352e-02f, 7.85003155e-02f, 8.96359421e-03f, -2.95415614e-02f, 5.76427020e-02f, 1.51038319e-01f, -5.26593626e-02f, -1.82652697e-02f,
  3.30294706e-02f, 5.05822487e-02f, -1.68291077e-01f, 4.82837297e-02f, -8.89511555e-02f, -1.03774825e-02f, 1.07832260e-01f, 4.54265848e-02f, 1.71704181e-02f, 1.54370353e-01f,
  1.12048969e-01f, 4.30314578e-02f, 2.17597112e-02f, -3.45186144e-02f, 7.01827332e-02f, -4.12475690e-02f, 3.72986961e-03f, 5.51254861e-02f, -5.26772812e-02f, -8.78946036e-02f,
  -5.82817383e-02f, -4.31447476e-02f, 6.41022995e-02f, -6.73903823e-02f, -6.39450699e-02f, -7.55141377e-02f, -1.89323502e-03f, 9.76394862e-03f, -1.44010764e-02f, 4.74255253e-03f,
  -8.30871835e-02f, -5.22420257e-02f, -3.87287810e-02f, 1.56251844e-02f, -6.87893853e-02f, -7.17452690e-02f, 9.66664404e-02f, -3.72811668e-02f, -4.11646701e-02f, -2.49584503e-02f,
  1.41288824e-02f, 3.61521216e-03f, -2.15572994e-02f, 4.15307432e-02f, 6.12387955e-02f, 1.03761956e-01f, -2.42677089e-02f, 6.41892478e-02f, -2.21420433e-02f, 7.23133460e-02f,
  -7.12647140e-02f, -2.90498525e-01f, 5.09477369e-02f, -1.71805266e-02f, 3.35785262e-02f, 2.72957478e-02f, -1.26687046e-02f, -6.58420101e-02f, -5.82810007e-02f, -2.55925059e-02f,
  -6.33748919e-02f, 1.44960694e-02f, -8.49992856e-02f, 5.54137444e-03f, -4.84525040e-02f, 5.76391183e-02f, -1.00976983e-02f, -3.43306288e-02f, 7.39322975e-03f, -1.16399020e-01f,
  -1.34906713e-02f, -4.98084761e-02f, 3.14206034e-02f, -8.32894444e-02f, -1.26872882e-01f, 6.52350858e-03f, -8.18846077e-02f, -4.90451269e-02f, -3.33541818e-02f, 4.40894859e-03f,
  -3.07310896e-04f, -1.58684496e-02f, -1.31642535e-01f, 1.32650539e-01f, 1.97084472e-02f, -1.44738689e-01f, -2.64370739e-01f, 1.83109775e-01f, -1.81535691e-01f, 3.37437391e-02f,
  2.12344557e-01f, -1.70821384e-01f, -7.78381228e-02f, 2.87098914e-01f, 1.31463945e-01f, -5.56112416e-02f, 1.99283615e-01f, 2.74238326e-02f, -1.03593998e-01f, 1.07869700e-01f,
  1.46161631e-01f, 2.76240826e-01f, 1.60166413e-01f, 2.05102786e-01f, 1.17880143e-01f, 1.57065511e-01f, 2.64056295e-01f, -3.38604413e-02f, 2.72561282e-01f, 4.57502156e-02f,
  -1.24945052e-01f, 6.74912930e-02f, -1.28115611e-02f, -7.61846751e-02f, 6.30621985e-02f, -2.02326849e-02f, -7.98415095e-02f, -1.62522716e-03f, -6.13798872e-02f, 3.21530290e-02f,
  3.26127396e-03f, 9.90589987e-03f, 8.87076035e-02f, -3.03809606e-02f, 3.34722623e-02f, -2.85427906e-02f, -6.60817921e-02f, -5.88882342e-02f, -3.89292277e-02f, 2.96199066e-03f,
  -5.67566007e-02f, -1.25981169e-02f, 5.25309294e-02f, 7.39374058e-03f, -3.49441692e-02f, -8.20710137e-03f, -2.05337610e-02f, -1.95834562e-02f, 1.52014429e-02f, 2.97348183e-02f,
  5.20914160e-02f, -1.38859330e-02f, -6.53746650e-02f, -8.15500468e-02f, 3.16656940e-02f, -1.30466968e-02f, -4.52247187e-02f, 1.93131100e-02f, -6.93288743e-02f, -5.40346233e-03f,
  3.82748954e-02f, 3.62108499e-02f, -2.05784179e-02f, 2.81278491e-02f, 5.30600213e-02f, -2.96916775e-02f, -2.21807491e-02f, 6.00649118e-02f, -1.93119105e-02f, -5.80696331e-04f,
  -5.79692386e-02f, 2.32475437e-02f, -7.02238381e-02f, 2.37481445e-02f, 2.21249163e-02f, 3.70351598e-02f, 6.07500859e-02f, 3.89025244e-03f, -2.53499812e-03f, 5.97098493e-04f,
  1.26753896e-01f, 2.81253576e-01f, -3.54492441e-02f, -1.51276831e-02f, 3.41912471e-02f, 1.17925536e-02f, -5.44855669e-02f, 5.79724051e-02f, 8.49146247e-02f, 8.00036415e-02f,
  7.63387084e-02f, -1.77103933e-02f, 3.81559245e-02f, 1.90315787e-02f, 6.09566458e-02f, 5.28245196e-02f, 4.55730818e-02f, -4.42479625e-02f, 5.49088828e-02f, 1.29390866e-01f,
  9.73613411e-02f, 6.27005547e-02f, 6.17563399e-03f, -8.99458379e-02f, 1.48514053e-02f, 1.73498914e-02f, -1.62918642e-02f, -4.02825773e-02f, 3.75527553e-02f, 3.95704135e-02f,
  1.67163715e-01f, -4.59167153e-01f, -3.39052826e-01f, -3.67285579e-01f, 6.39077872e-02f, 1.40634522e-01f, -4.47444655e-02f, -2.62522399e-01f, -3.89229864e-01f, -1.24633491e-01f,
  -1.77815720e-01f, -4.66375537e-02f, -6.48789704e-02f, -2.93612301e-01f, 3.89927775e-01f, 7.62398215e-03f, -9.23911184e-02f, 7.08673298e-02f, -2.33421624e-01f, 1.27895121e-02f,
  -7.52191097e-02f, 2.89268699e-02f, -1.44640654e-01f, 4.51533832e-02f, -1.91002369e-01f, -4.08360586e-02f, 1.68979689e-01f, 2.29976866e-02f, -1.51930936e-03f, -5.57987094e-02f,
  -8.21299776e-02f, -2.18576133e-01f, -7.34168217e-02f, 8.39020386e-02f, -6.74043521e-02f, 7.67667368e-02f, 6.88400492e-02f, 1.48402870e-01f, 3.67272422e-02f, -4.91848998e-02f,
  9.47410613e-02f, 1.29838198e-01f, -7.98423663e-02f, 1.31596163e-01f, -5.51350005e-02f, -2.12298129e-02f, 1.87453032e-02f, -1.86229736e-01f, 3.63023058e-02f, -9.62099899e-03f,
  -1.06215067e-01f, -1.37146488e-01f, -1.14568532e-01f, -6.63371608e-02f, -1.98516827e-02f, 5.42353094e-02f, 1.16138101e-01f, 1.61561951e-01f, -6.30953610e-02f, 3.55232228e-03f,
  3.80379818e-02f, 1.48621991e-01f, -2.39346232e-02f, -1.07296154e-01f, -6.38722330e-02f, -2.36279406e-02f, -1.52167697e-02f, -6.32834211e-02f, 2.18822475e-04f, 4.20997404e-02f,
  -9.80451256e-02f, -7.06783496e-04f, -4.84649949e-02f, -8.40567984e-03f, 2.26931111e-03f, -9.99780223e-02f, 9.31446180e-02f, 1.82893313e-02f, -1.23439655e-01f, -3.81496251e-02f,
  -1.07323311e-01f, -1.06503544e-02f, 5.33862859e-02f, 1.93395149e-02f, -2.41246298e-02f, 1.24233335e-01f, -9.00694430e-02f, 5.92494570e-02f, -2.21662134e-01f, -7.69444481e-02f,
  4.91215847e-02f, -3.09103001e-02f, -3.07548512e-02f, 6.78613177e-03f, 1.87400950e-03f, -1.62197892e-02f, -7.51025230e-02f, -1.67102013e-02f, 5.57937026e-02f, -3.57608758e-02f,
  -2.40558740e-02f, 1.01005420e-01f, -3.04045733e-02f, 5.28810285e-02f, 8.81309509e-02f, -3.96079868e-02f, 1.47078618e-01f, -6.15877956e-02f, 9.59609821e-02f, 7.63809159e-02f,
  9.87750739e-02f, -3.91927548e-03f, 3.60500701e-02f, -1.29640147e-01f, -6.99080452e-02f, 9.25165340e-02f, 1.71517819e-01f, 7.32460544e-02f, -3.72413658e-02f, -3.57557945e-02f,
  -3.75927985e-01f, -1.05418423e-02f, 3.60354215e-01f, -4.77070183e-01f, 2.69273818e-01f, 3.47865641e-01f, 2.41696432e-01f, -1.58219680e-01f, -2.07348481e-01f, -2.76164949e-01f,
  -1.83454037e-01f, 6.99438751e-02f, 3.03471088e-01f, -3.29861373e-01f, 3.16280812e-01f, 2.11541101e-01f, -2.24832639e-01f, -1.46874934e-01f, 1.40323117e-01f, 2.39531565e-02f,
  2.98314337e-02f, -1.42105371e-01f, 7.23796189e-02f, -1.50523670e-02f, -4.11076769e-02f, -1.78496435e-01f, -2.30769023e-01f, 3.88023049e-01f, -2.55647004e-01f, 5.91432676e-02f,
  -7.98242688e-02f, -2.96850413e-01f, 6.51519746e-02f, 1.47056608e-02f, -9.26299170e-02f, 6.01516813e-02f, 2.79667322e-02f, 1.40205830e-01f, 1.72301754e-02f, -1.23226102e-02f,
  2.16790400e-02f, -3.23533975e-02f, -6.16199113e-02f, 4.18958515e-02f, 8.58514979e-02f, -6.10364005e-02f, 7.72279277e-02f, 5.82642592e-02f, 2.77968291e-02f, 4.10277173e-02f,
  4.16343808e-02f, 1.18288875e-01f, -4.30046432e-02f, -7.42755160e-02f, 1.62832007e-01f, -9.39137638e-02f, 1.31960250e-02f, 1.12332016e-01f, 3.99214253e-02f, -6.93567991e-02f,
  2.45972555e-02f, 1.77208136e-03f, 1.40372172e-01f, -2.08322164e-02f, 3.41972597e-02f, -1.49913654e-01f, -3.21730296e-03f, -1.52114849e-03f, -4.22808528e-02f, -3.28856409e-02f,
  -4.21376713e-02f, 2.31406279e-02f, 9.88917798e-03f, 1.29317306e-02f, -4.16060649e-02f, -8.67791921e-02f, 4.48483080e-02f, -1.86473187e-02f, -5.96005656e-02f, -7.13976473e-02f,
  -1.00727096e-01f, 5.89516107e-03f, 3.15509476e-02f, -5.11106364e-02f, 1.67378392e-02f, 8.29026923e-02f, -7.91948065e-02f, 2.07779035e-02f, -8.35082009e-02f, 1.52130812e-01f,
  -9.34582353e-02f, -2.36844584e-01f, 5.09767160e-02f, -6.91085607e-02f, -1.94132756e-02f, -1.56510398e-02f, 5.92642948e-02f, -3.37695191e-03f, 5.62124653e-03f, 1.86895579e-02f,
  -4.63103168e-02f, -9.83124599e-02f, 1.03592975e-02f, 3.44673102e-03f, 7.79926926e-02f, -5.55880964e-02f, 3.86663750e-02f, 5.82925901e-02f, -3.18850912e-02f, -3.71349491e-02f,
  -8.51858184e-02f, -3.73574048e-02f, -4.53257486e-02f, -1.13261580e-01f, -1.40212607e-04f, -4.25981283e-02f, -4.60316688e-02f, -3.43718752e-02f, 1.33922249e-01f, -3.42153981e-02f,
  -4.10115391e-01f, 2.45596096e-01f, 5.30599020e-02f, -3.03283006e-01f, 1.79477543e-01f, -1.04976073e-01f, -2.30836980e-02f, 4.03064370e-01f, -6.59837574e-03f, 1.70897394e-01f,
  3.41616012e-02f, -3.46607149e-01f, 2.53397614e-01f, -3.16475868e-01f, -3.67624134e-01f, -2.09300533e-01f, -2.84880549e-01f, -1.94242001e-01f, -1.70738325e-01f, -1.40489137e-03f,
  -4.94756103e-02f, -6.84789419e-02f, 1.93028495e-01f, 2.81627148e-01f, 9.42503139e-02f, 1.15230083e-01f, 1.85204476e-01f, 2.96945840e-01f, -1.44028561e-02f, -1.69304591e-02f,
  9.44635272e-02f, 7.62142912e-02f, 2.11909860e-01f, 7.86599889e-02f, 1.57490090e-01f, -4.13727351e-02f, 1.16581060e-02f, 4.14744169e-02f, 1.14439778e-01f, -2.40435563e-02f,
  -3.42731513e-02f, -5.62873967e-02f, -1.44658282e-01f, 9.29796323e-03f, 2.26850025e-02f, 7.55057484e-03f, 2.06881687e-02f, 7.22796544e-02f, 4.69593778e-02f, -1.96587503e-01f,
  -1.81353148e-02f, -3.74059603e-02f, -1.65739164e-01f, -1.17524631e-01f, -5.76368123e-02f, 1.74145978e-02f, -9.68795344e-02f, -5.03472611e-02f, -4.47892621e-02f, -8.98790956e-02f,
  -1.23160906e-01f, -6.00892417e-02f, 3.31747644e-02f, 1.20113842e-01f, -2.24886159e-03f, 6.60915161e-03f, -2.27692514e-03f, -5.10819182e-02f, -7.63414800e-02f, -6.76858798e-02f,
  5.73854335e-02f, -2.03712992e-02f, -1.14560435e-02f, -8.09758455e-02f, -1.07401051e-01f, -1.02054872e-01f, -7.18621463e-02f, -6.05300851e-02f, -9.30027978e-04f, 3.30764428e-02f,
  8.83989707e-02f, 5.73890237e-03f, 2.20744759e-02f, 9.90286693e-02f, 1.04111418e-01f, -6.05869945e-03f, -1.38411790e-01f, -7.23749623e-02f, 1.30664632e-02f, -3.67869847e-02f,
  2.00664118e-01f, 8.14876109e-02f, 1.94399819e-01f, 1.31048650e-01f, 7.04068989e-02f, -2.94829998e-02f, -9.80324894e-02f, -6.11405745e-02f, 5.46786673e-02f, -1.00556642e-01f,
  -3.08073778e-03f, 6.04578517e-02f, 6.54939041e-02f, -6.30928800e-02f, 7.99957514e-02f, 3.19372937e-02f, 4.44123987e-03f, 1.66364536e-02f, 1.52295277e-01f, -2.40784660e-02f,
  6.92396984e-02f, -6.08728826e-02f, -6.21762387e-02f, 7.24804029e-02f, -4.67597358e-02f, 4.68997210e-02f, -6.13416247e-02f, 2.78411657e-02f, -4.33451012e-02f, 4.27229144e-02f,
  2.97432035e-01f, -6.22586727e-01f, 7.82499388e-02f, 2.57457793e-01f, 9.93993804e-02f, -1.82811067e-01f, 2.09006488e-01f, -1.85315073e-01f, -7.61736184e-02f, -4.78403598e-01f,
  5.62686548e-02f, 1.28344297e-01f, -7.70071074e-02f, -6.08480116e-03f, 4.05678332e-01f, 2.57526673e-02f, -7.14357048e-02f, 1.39435098e-01f, -2.04473566e-02f, -2.15148687e-01f,
  1.45123690e-01f, -1.30319715e-01f, 9.40266550e-02f, -4.31795061e-01f, -9.97159630e-02f, -6.38908297e-02f, 6.36658892e-02f, -7.67526701e-02f, -2.81637497e-02f, 2.51676261e-01f,
  -1.96489885e-01f, -7.78638721e-02f, 1.09146750e-02f, -7.42080510e-02f, -8.82371515e-02f, 5.60153183e-03f, 9.25311670e-02f, 1.18798263e-01f, 9.84392241e-02f, 1.06411222e-02f,
  7.30815232e-02f, -3.52546200e-02f, -3.52088548e-02f, -8.56189895e-03f, -5.81907853e-02f, -5.52120171e-02f, 1.12453401e-02f, -2.07112897e-02f, -1.14916579e-03f, 3.07989735e-02f,
  -3.57907382e-03f, 7.21912161e-02f, 7.80298188e-02f, -1.80909131e-02f, 1.18782796e-01f, 3.04366387e-02f, 9.13622081e-02f, 6.39547631e-02f, 2.42268890e-02f, -1.03156324e-02f,
  3.67586799e-02f, 1.68217602e-03f, -1.00458711e-02f, -2.29615271e-02f, 1.11384261e-02f, 3.56377363e-02f, -8.18295553e-02f, 4.48150821e-02f, 3.17756459e-02f, -8.73253718e-02f,
  3.14220041e-02f, 7.64942765e-02f, 4.66806255e-03f, -5.60891703e-02f, 2.49629095e-02f, 4.43596840e-02f, 6.87090084e-02f, 5.24753181e-04f, -3.91531661e-02f, 7.51908720e-02f,
  -2.43358482e-02f, -2.59683356e-02f, -1.08316146e-01f, 4.03321497e-02f, -3.31956521e-02f, -2.23588739e-02f, -9.70266387e-02f, -8.05604234e-02f, -6.42926246e-03f, 9.22366828e-02f,
  -5.34428775e-01f, -5.36995173e-01f, -5.29192053e-02f, -4.29655751e-03f, 4.65152640e-04f, -3.26260813e-02f, 1.57908313e-02f, -4.25888114e-02f, -1.62605122e-01f, -7.43084922e-02f,
  -7.69554153e-02f, -1.20960623e-02f, -8.31326321e-02f, -2.52976269e-02f, 6.28605187e-02f, -7.17252344e-02f, -2.39648037e-02f, 2.83032618e-02f, 5.80544397e-02f, -9.41419452e-02f,
  -4.47184481e-02f, -5.40185347e-02f, 4.94972654e-02f, -1.29138259e-02f, 4.52707708e-02f, 1.83000788e-02f, -7.06599206e-02f, 1.74948648e-02f, 2.26044562e-03f, -2.08363067e-02f,
  -6.81122661e-01f, 6.40531778e-01f, 4.54176702e-02f, -3.04052055e-01f, 3.24480385e-02f, 4.18176968e-03f, -2.16407016e-01f, 2.08678484e-01f, 1.67619362e-01f, 1.16610073e-01f,
  -5.47612668e-04f, 9.48382616e-02f, 2.81162262e-01f, -3.93381864e-02f, -2.03394741e-01f, 1.55624092e-01f, -2.42533922e-01f, -1.26008064e-01f, 2.19472989e-01f, -9.67045501e-02f,
  -1.04308657e-01f, -2.49478862e-01f, -1.24030799e-01f, 1.17591202e-01f, -1.20038539e-01f, -1.27093047e-01f, -2.99972594e-01f, 1.16586916e-01f, -2.63370544e-01f, 8.51929560e-02f,
  -2.79670000e-01f, -7.42638037e-02f, -2.78199434e-01f, -1.75688684e-01f, -2.22901285e-01f, -2.34655086e-02f, -1.55685395e-01f, -3.20620313e-02f, 1.40611492e-02f, 7.09479600e-02f,
  5.64872799e-03f, 2.73435116e-02f, 7.91337527e-03f, 1.46295384e-01f, -3.52526642e-02f, -1.07671146e-03f, 8.29220563e-02f, -1.11498177e-01f, 3.69350575e-02f, 1.13379769e-01f,
  1.64549932e-01f, 1.44195911e-02f, -1.13232270e-01f, -2.42347401e-02f, -2.77741868e-02f, -5.21285310e-02f, 2.30522789e-02f, -6.78411424e-02f, -9.37158391e-02f, 1.93359368e-02f,
  1.57681629e-02f, -5.63845932e-02f, -5.67487441e-02f, -8.82127658e-02f, 8.08368325e-02f, 5.54733314e-02f, 6.65978268e-02f, -1.88531857e-02f, -7.71386027e-02f, -1.36619404e-01f,
  -8.81264657e-02f, -8.51287693e-02f, -3.32084633e-02f, -6.02802448e-02f, 2.31024846e-02f, -8.26628208e-02f, -1.32480130e-01f, -3.07951327e-02f, 4.04396318e-02f, -7.32269064e-02f,
  1.97803397e-02f, 5.19653931e-02f, 2.31952947e-02f, 3.14971618e-02f, -7.46557564e-02f, -3.97593854e-03f, 2.93822885e-02f, -7.11986981e-03f, -2.16017272e-02f, -3.79567361e-03f,
  -3.68864506e-01f, -2.94599384e-01f, -1.21211961e-01f, -6.68251812e-02f, -1.20915256e-01f, -2.13173255e-02f, -7.69178048e-02f, -1.17235053e-02f, -1.68353140e-01f, -5.91339264e-03f,
  2.63616797e-02f, -7.68977497e-03f, -4.19235788e-02f, 6.46428540e-02f, 1.17861452e-02f, -1.00689381e-01f, -1.44205153e-01f, -6.17981255e-02f, -1.93077892e-01f, -1.23648178e-02f,
  -2.45054234e-02f, -5.08789457e-02f, -3.59990932e-02f, -8.92323032e-02f, -4.90383580e-02f, -1.57743305e-01f, -8.97431523e-02f, 2.88421568e-02f, -1.36731401e-01f, 1.07523091e-01f,
  3.57860237e-01f, -4.09111053e-01f, 1.57397255e-01f, 2.39077747e-01f, 3.03479761e-01f, 1.60188928e-01f, 2.43954986e-01f, 1.76807091e-01f, 5.21325827e-01f, -3.72842312e-01f,
  -1.47228897e-01f, -2.86145002e-01f, 6.46586046e-02f, -3.01219881e-01f, 2.36348882e-01f, 4.97897640e-02f, -1.30231548e-02f, -1.14940763e-01f, 1.92826852e-01f, 3.59079801e-02f,
  4.72838096e-02f, -2.88903773e-01f, -5.07044084e-02f, -2.14333981e-01f, -1.29626825e-01f, -1.29879728e-01f, -2.48089388e-01f, -9.58525017e-02f, -4.16649848e-01f, -1.70960709e-01f,
  6.16345275e-03f, 9.65185165e-02f, -1.36355877e-01f, -8.50002766e-02f, 4.98111062e-02f, -1.15307674e-01f, -1.12629727e-01f, -6.98463619e-02f, 1.58889338e-01f, 3.07370722e-02f,
  -4.96390611e-02f, 5.95447719e-02f, -9.50413570e-02f, -2.55656671e-02f, 5.67793772e-02f, 1.58585166e-03f, 5.63652217e-02f, 7.80415609e-02f, -8.38554129e-02f, -1.38210570e-02f,
  7.22120330e-02f, 5.75560257e-02f, 8.81749839e-02f, -1.41725820e-02f, 4.32569124e-02f, -6.39181063e-02f, 2.55406685e-02f, -5.16435057e-02f, -7.44830910e-03f, -1.81356017e-02f,
  -1.22450039e-01f, 1.13263531e-02f, -9.37038139e-02f, -2.60626823e-02f, 1.55288624e-02f, 3.63979451e-02f, -2.17902251e-02f, -4.30034101e-02f, 1.15611218e-01f, 4.63749692e-02f,
  7.07068071e-02f, -4.76289168e-02f, 8.17149505e-02f, 9.95486453e-02f, 1.62620621e-04f, 8.13738108e-02f, -4.79899943e-02f, 7.62044638e-02f, 1.18033262e-02f, 3.03694569e-02f,
  -1.49834491e-02f, -2.97715086e-02f, 7.01019391e-02f, 1.92338414e-02f, 2.66145519e-03f, 2.89187226e-02f, -5.80935888e-02f, 1.42352432e-02f, 7.46829882e-02f, -2.30806507e-03f,
  3.89898978e-02f, -2.47919187e-01f, -4.53438088e-02f, -3.64485085e-02f, 8.81622918e-03f, -1.06612124e-01f, -1.36278039e-02f, -2.60209311e-02f, -4.83071133e-02f, 1.01463431e-02f,
  -6.86635226e-02f, 7.03503704e-03f, -9.93522163e-03f, 1.22615555e-02f, -1.25563383e-01f, -1.90234021e-03f, -7.52793550e-02f, -4.46311152e-03f, -8.40073153e-02f, -8.88227820e-02f,
  -1.60184037e-02f, 8.10737759e-02f, 4.81369086e-02f, 2.14575231e-02f, 4.98929352e-04f, -3.51473950e-02f, 1.88951194e-02f, -1.81467179e-03f, 9.56677198e-02f, -5.80477342e-02f,
  -4.84141521e-02f, -1.00777447e-01f, 2.95223445e-01f, 2.71258473e-01f, -6.27808794e-02f, -4.94173579e-02f, 4.01105359e-02f, -1.85264766e-01f, -3.50755632e-01f, -2.41883043e-02f,
  -4.68727667e-03f, 2.28846267e-01f, -1.65462345e-02f, -1.78972661e-01f, -1.46115392e-01f, -3.44340503e-01f, -8.63580778e-02f, 9.42546427e-02f, -1.72478020e-01f, 2.59237200e-01f,
  -7.43537676e-03f, -3.06478441e-01f, 9.43628848e-02f, -8.50401744e-02f, 1.82534292e-01f, 3.25623721e-01f, 3.00197721e-01f, 1.82619676e-01f, 3.18202466e-01f, -3.87224406e-02f,
  -8.41580927e-02f, -1.43805340e-01f, 3.05388831e-02f, -4.96812016e-02f, 1.28045797e-01f, 8.53937864e-02f, 9.32618529e-02f, 6.43616170e-02f, 6.22686371e-02f, -2.15751734e-02f,
  6.59324974e-02f, 5.87484613e-02f, 1.54568693e-02f, -7.47877210e-02f, -4.29789163e-02f, -5.00138178e-02f, -3.74315232e-02f, -3.28592733e-02f, -6.23553060e-02f, 7.18764812e-02f,
  1.09638795e-01f, 6.78715413e-04f, 4.15330045e-02f, 5.41084073e-02f, 4.14006300e-02f, 5.71413606e-04f, 1.28276139e-01f, 2.26706043e-01f, -5.62496334e-02f, 4.10967506e-02f,
  -8.26924965e-02f, -1.11570597e-01f, -1.31816894e-01f, -6.03178628e-02f, -8.36201757e-02f, 3.81324515e-02f, -1.16455413e-01f, -1.06035516e-01f, 6.43897802e-02f, -2.30809804e-02f,
  2.62284856e-02f, -2.29322445e-03f, -1.56299204e-01f, 5.16551174e-02f, 5.58413798e-03f, -1.69254452e-01f, 3.13714109e-02f, 9.13329646e-02f, 1.55916139e-01f, -2.18057986e-02f,
  -9.99179035e-02f, 6.15811422e-02f, 1.42974988e-01f, 2.68357862e-02f, -1.87975287e-01f, 4.29072864e-02f, -1.77011900e-02f, 2.62165368e-02f, -1.19413689e-01f, -2.13593058e-02f,
  2.41130084e-01f, 2.37210721e-01f, 1.00697421e-01f, -6.75533619e-03f, -8.13375935e-02f, -3.34184431e-02f, -1.31873339e-01f, 2.71691047e-02f, 2.39982739e-01f, -1.32125020e-01f,
  8.81312937e-02f, 9.30624977e-02f, 6.16631396e-02f, -1.57131925e-02f, 7.03925937e-02f, 4.78165150e-02f, 1.01061121e-01f, 6.08332865e-02f, 1.92693453e-02f, 1.23957410e-01f,
  7.73922727e-02f, 3.99760231e-02f, -6.71801120e-02f, -7.91735761e-03f, 4.32014540e-02f, 1.03578947e-01f, 3.47690582e-02f, 7.10068122e-02f, 6.65480569e-02f, 1.87671468e-01f,
  1.53996482e-01f, 2.62495905e-01f, -3.84787507e-02f, 9.32489112e-02f, -3.81325483e-01f, -1.44429371e-01f, -1.99323431e-01f, 1.75612494e-02f, 2.54957199e-01f, 3.53936739e-02f,
  -3.01872492e-01f, 3.40521157e-01f, 9.65122208e-02f, -2.49757558e-01f, 4.18377638e-01f, 2.47667015e-01f, 2.35441588e-02f, -2.81217676e-02f, 9.72870067e-02f, 1.46410232e-02f,
  1.48168370e-01f, -1.97113886e-01f, -6.89691156e-02f, -3.82055752e-02f, -2.90006548e-01f, -3.51740606e-02f, -5.86226285e-02f, -1.78215906e-01f, -2.53520399e-01f, -6.06366470e-02f,
  -1.41298518e-01f, 1.51020572e-01f, -7.84155205e-02f, 5.87107092e-02f, 1.79274392e-03f, -7.30605572e-02f, -1.34259969e-01f, -1.75773874e-02f, 5.56223020e-02f, 3.47727090e-02f,
  1.10560238e-01f, 4.75763381e-02f, -2.57040951e-02f, 5.19857742e-03f, -6.78298175e-02f, -5.57256117e-02f, -4.31592092e-02f, -1.39225975e-01f, -3.26268412e-02f, -1.79853905e-02f,
  2.00740770e-02f, -5.87584963e-03f, -6.04611710e-02f, 9.18047279e-02f, 2.30181869e-03f, -1.17547680e-02f, 8.41597542e-02f, -6.91301972e-02f, -4.30719666e-02f, 1.00236163e-01f,
  1.22199483e-01f, -6.62362725e-02f, -6.97008595e-02f, -1.37341797e-01f, 2.53353715e-02f, 2.47047544e-02f, 1.03327468e-01f, -1.02697834e-01f, 9.93288383e-02f, -3.63253467e-02f,
  -3.96093763e-02f, -1.18046068e-02f, -7.67389014e-02f, 1.99595187e-02f, 4.98768799e-02f, 6.00300059e-02f, 2.69814264e-02f, 1.10515850e-02f, 5.88553697e-02f, 1.89867392e-02f,
  -1.08480686e-02f, -7.49046952e-02f, 6.19422868e-02f, -8.65010843e-02f, -1.22992314e-01f, -7.99517557e-02f, -9.04321447e-02f, 2.27032322e-02f, -3.32747288e-02f, 4.24707774e-03f,
  1.52114376e-01f, 4.28853691e-01f, 1.62537023e-01f, 5.70527278e-02f, 8.88847858e-02f, -1.50081702e-02f, 5.07356673e-02f, 1.14843167e-01f, 1.54349595e-01f, 1.02493353e-01f,
  -4.65642735e-02f, -2.78200931e-03f, -5.87300248e-02f, -1.37276873e-01f, 9.16868970e-02f, 1.10835232e-01f, 4.90601286e-02f, 8.33248943e-02f, 8.05820376e-02f, 3.61767076e-02f,
  -4.90470184e-03f, 4.72040810e-02f, 1.58143625e-01f, 1.06631815e-02f, 5.09025790e-02f, 3.51802655e-03f, 2.05088640e-03f, 7.75858061e-03f, 1.35573009e-02f, 1.01137951e-01f,
  2.31936619e-01f, -1.41616777e-01f, 9.05722156e-02f, 5.09898901e-01f, 1.84428424e-01f, -1.57309011e-01f, -5.53909689e-02f, 1.42674759e-01f, 3.22105795e-01f, -3.96050394e-01f,
  -4.11080159e-02f, -2.88675666e-01f, -5.12424648e-01f, 2.03767642e-01f, 2.56988585e-01f, -1.98758110e-01f, 4.25714552e-01f, 2.40643471e-02f, 1.94263458e-01f, -6.60788454e-03f,
  2.91237921e-01f, 1.19301558e-01f, 5.30530885e-02f, 1.56804562e-01f, 2.19447836e-02f, 2.61657238e-01f, 1.11221865e-01f, 6.42914698e-02f, 1.39672190e-01f, 1.20337397e-01f,
  1.50778377e-02f, 1.18313156e-01f, 3.03558372e-02f, 8.57507512e-02f, 4.34275195e-02f, -2.59007141e-02f, -1.12919156e-02f, -1.17570885e-01f, 7.30175674e-02f, -8.75008255e-02f,
  -1.53081283e-01f, 6.25934824e-02f, -7.09979679e-04f, -6.62341341e-02f, 1.32102206e-01f, 1.47716716e-01f, 1.42448200e-02f, -1.09568203e-03f, 1.71728060e-02f, -7.98473209e-02f,
  -6.21060766e-02f, -5.27865663e-02f, 9.02922750e-02f, 3.62004749e-02f, 1.15237489e-01f, 1.96741313e-01f, 3.78158987e-02f, -5.44881448e-03f, -2.72553023e-02f, 1.27266929e-01f,
  -3.17489095e-02f, -5.04412912e-02f, -2.81560123e-02f, -1.04821928e-01f, 8.29048082e-02f, 8.63433778e-02f, -2.68577766e-02f, -9.12815854e-02f, 5.35469800e-02f, -6.84923027e-03f,
  1.21469103e-01f, 1.14333533e-01f, 6.35069534e-02f, -2.18187850e-02f, 7.74395466e-02f, 7.19943270e-02f, -7.87955821e-02f, -6.98706880e-02f, 1.09013677e-01f, -5.08391894e-02f,
  1.08800597e-01f, 9.74417403e-02f, -1.41147107e-01f, -5.89432120e-02f, 8.56619030e-02f, -9.19209495e-02f, -8.50877240e-02f, 1.51829440e-02f, -6.57112524e-02f, -7.29796104e-03f,
  3.38386111e-02f, 2.29664639e-01f, -4.11167927e-02f, 1.08246349e-01f, 3.65066156e-02f, -4.32857834e-02f, 1.02952376e-01f, 7.79319108e-02f, 2.08517507e-01f, -1.72122568e-02f,
  3.25975455e-02f, -6.98155584e-03f, -1.10031314e-01f, 1.62402652e-02f, 9.33581218e-03f, 1.17864553e-02f, -2.17107125e-02f, 1.92301407e-01f, 1.74235389e-01f, -2.16055773e-02f,
  -8.14280212e-02f, -1.51496738e-01f, 7.10079819e-02f, 1.17043234e-01f, -1.53589789e-02f, 1.18827773e-03f, -9.94539559e-02f, 6.53086454e-02f, -5.91492578e-02f, 5.34974784e-02f,
  3.77931505e-01f, 3.07277203e-01f, 1.50884718e-01f, 2.20507145e-01f, -1.77686382e-02f, -4.56910193e-01f, -2.04107389e-01f, 4.27282900e-02f, 3.15278083e-01f, -3.44863459e-02f,
  -1.55865893e-01f, 2.87788004e-01f, -7.66206952e-03f, -1.66577965e-01f, -4.79932666e-01f, -1.32958174e-01f, -3.53553891e-01f, -9.76607278e-02f, 1.69890478e-01f, -1.72215372e-01f,
  1.25608351e-02f, -4.19573992e-01f, -2.22497553e-01f, -9.27779675e-02f, -1.23520708e-02f, 2.56707430e-01f, -2.49062642e-01f, 7.92270377e-02f, -1.77005038e-01f, -6.43321201e-02f,
  -9.12962481e-02f, 2.22273678e-01f, 5.23640849e-02f, 4.68393154e-02f, -1.45160124e-01f, -8.16293284e-02f, -9.52209979e-02f, 1.22277634e-02f, -1.19897276e-02f, 3.91438864e-02f,
  2.58351248e-02f, -3.24464925e-02f, 1.74645707e-02f, 7.90250897e-02f, 1.30869016e-01f, 7.22562149e-02f, 6.51513487e-02f, -1.75852012e-02f, 1.23677127e-01f, 4.37952168e-02f,
  6.59337640e-02f, -2.51335208e-03f, -1.18087105e-01f, 2.23028287e-02f, 2.07728688e-02f, 4.95701320e-02f, -6.66414350e-02f, -2.12039482e-02f, -1.52293658e-02f, 5.67328334e-02f,
  2.61814017e-02f, -9.59312096e-02f, -6.72686985e-03f, 1.02001205e-01f, -4.12530303e-02f, 2.33534724e-02f, -2.21693125e-02f, -4.10457663e-02f, 5.99327944e-02f, -2.06404030e-02f,
  -7.52609149e-02f, 1.62165567e-01f, 1.10543277e-02f, 1.50480922e-02f, -3.49793583e-02f, -6.97052805e-04f, -4.57920097e-02f, -5.77718159e-03f, -3.29393297e-02f, 3.87114584e-02f,
  -5.72684687e-03f, -1.07673451e-01f, 4.45265733e-02f, -3.46114673e-02f, -9.10993367e-02f, 4.41272967e-02f, -1.23512764e-02f, 2.61374805e-02f, 4.06610072e-02f, -1.21727161e-01f,
  -4.88845646e-01f, -3.76873523e-01f, -5.69185428e-02f, 4.30073030e-02f, -2.14767139e-02f, -6.57387525e-02f, -1.15779908e-02f, 9.76893306e-02f, -1.18446179e-01f, -1.42156752e-02f,
  -7.15994611e-02f, -3.29426229e-02f, -8.18804130e-02f, 1.56310163e-02f, -1.27875566e-01f, -4.39095497e-02f, -4.31605503e-02f, -5.71780428e-02f, -1.93704784e-01f, -4.56835376e-03f,
  -2.91532390e-02f, -1.96439940e-02f, -8.70494917e-02f, -3.53651978e-02f, 8.24456569e-03f, 2.51811072e-02f, 1.50327021e-02f, 7.92312771e-02f, -6.17747717e-02f, -1.52827045e-02f,
  1.65566429e-01f, -3.36883456e-01f, 3.86979997e-01f, 3.74266982e-01f, 1.12594008e-01f, -4.39394206e-01f, 1.07638717e-01f, -1.74710818e-03f, -8.14986080e-02f, -4.83021051e-01f,
  9.84981433e-02f, 1.30266339e-01f, 2.56588310e-01f, -1.36886910e-01f, 5.42953670e-01f, 1.89507723e-01f, -4.13351841e-02f, -1.60232559e-01f, 2.99458265e-01f, 1.94212794e-01f,
  2.94815153e-01f, -3.17359567e-02f, 4.77230608e-01f, -1.84243202e-01f, 6.71631321e-02f, 4.69416082e-02f, 2.22048804e-01f, 1.65134296e-01f, -2.72753805e-01f, -1.53276429e-01f,
  -2.25289091e-01f, 1.68774083e-01f, 2.50555221e-02f, -1.67190209e-01f, -2.99239792e-02f, -9.33404043e-02f, 1.25546511e-02f, 1.42404124e-01f, 1.00156873e-01f, -1.99303143e-02f,
  -2.26661190e-02f, 8.14206619e-03f, -7.80246258e-02f, -5.99236786e-02f, -6.73575997e-02f, -7.00992569e-02f, 5.39185386e-03f, -3.21473740e-02f, 6.16489463e-02f, 6.23969547e-02f,
  9.99012664e-02f, -6.30997270e-02f, 5.28019145e-02f, -6.59584403e-02f, 2.31989741e-01f, -9.78768244e-02f, 1.22554814e-02f, 6.69147149e-02f, -9.20985639e-02f, -3.05697266e-02f,
  2.57907230e-02f, 9.64230970e-02f, -2.06384491e-02f, -1.00341076e-02f, -1.59840677e-02f, 1.10247917e-02f, 7.66636292e-03f, -6.17565075e-03f, 5.29822335e-03f, 2.46971063e-02f,
  -7.56020397e-02f, 5.85116893e-02f, -3.96301039e-02f, -4.94288094e-02f, 1.21863894e-02f, -2.21576896e-02f, 3.53326462e-02f, -9.10247862e-02f, 1.85806130e-03f, 4.12194431e-02f,
  6.93523362e-02f, -3.34322751e-02f, 1.11262500e-02f, 1.08565227e-03f, -1.06155552e-01f, 1.36879787e-01f, 1.45790484e-02f, -6.78423196e-02f, 1.03495367e-01f, 1.61357909e-01f,
  -2.28820249e-01f, 2.36757509e-02f, -1.14953332e-02f, -1.58698812e-01f, -9.12855491e-02f, -5.71744777e-02f, 5.00622801e-02f, -8.49709660e-02f, -5.08218482e-02f, 2.59728860e-02f,
  -6.66158944e-02f, 1.35208750e-02f, -5.82111403e-02f, -1.58040866e-01f, -1.02329485e-01f, -1.01245306e-02f, 5.58786690e-02f, -5.37060089e-02f, 1.27679557e-02f, -8.30871537e-02f,
  2.95956694e-02f, -1.14374142e-03f, -3.86320264e-03f, 4.42491733e-02f, 3.36078228e-03f, 1.72413979e-02f, 1.49256475e-02f, -7.07744807e-02f, 3.24662938e-03f, -4.59462143e-02f,
  2.77225137e-01f, 7.83192292e-02f, -2.98763394e-01f, 3.63981992e-01f, -1.15279168e-01f, 3.36953014e-01f, 4.25581634e-01f, 1.99472867e-02f, 3.03622097e-01f, 2.93923408e-01f,
  3.67688835e-01f, -1.66640565e-01f, 8.53910744e-02f, 5.60461283e-01f, 1.13738179e-02f, 2.91449636e-01f, 4.30283904e-01f, 3.22197199e-01f, -5.73194325e-02f, 1.77443981e-01f,
  6.09086603e-02f, 3.21021527e-01f, -9.44761187e-02f, -2.21537501e-01f, 9.91446674e-02f, -2.94755876e-01f, -1.37038112e-01f, -3.84671688e-01f, -5.64071462e-02f, -8.23941156e-02f,
  1.02130249e-01f, 1.33742899e-01f, 4.22088392e-02f, -2.63366662e-02f, 5.08855209e-02f, -2.56590918e-02f, -1.28932446e-01f, -1.27968729e-01f, -1.20384023e-01f, 3.51140127e-02f,
  4.74422872e-02f, -2.25281082e-02f, 4.26707044e-02f, -5.32554165e-02f, -2.59991381e-02f, -9.59968269e-02f, 9.48651358e-02f, 2.20819656e-02f, -6.47720695e-02f, 6.19900301e-02f,
  9.31412727e-02f, -1.19291404e-02f, 1.07625641e-01f, 8.27319734e-03f, 6.21015579e-03f, 5.42595657e-03f, -5.37243597e-02f, -1.17668532e-01f, -2.44147312e-02f, -6.13623392e-03f,
  -5.63692190e-02f, 1.02101609e-01f, 2.01845750e-01f, 2.92098317e-02f, -1.52563397e-02f, -5.66741489e-02f, 4.77532484e-02f, -9.91576836e-02f, -7.85790160e-02f, 1.57909766e-02f,
  -5.04912250e-02f, 2.84196790e-02f, 4.69142161e-02f, -3.53255570e-02f, 1.02325089e-01f, -8.56527593e-03f, -1.15891919e-01f, -1.62062645e-02f, 1.37349039e-01f, -2.15959661e-02f,
  -1.57396346e-02f, 4.55255695e-02f, 8.63117278e-02f, -1.26424767e-02f, 5.12041301e-02f, -6.37620464e-02f, 1.35956839e-01f, 4.14547063e-02f, 4.83903810e-02f, -6.00022897e-02f,
  5.38442917e-02f, 1.89578217e-02f, 1.16068929e-01f, -1.42353317e-02f, -1.52009249e-01f, 9.89929289e-02f, 3.38438600e-02f, 2.90707666e-02f, -6.50921687e-02f, 1.14883810e-01f,
  -9.10608470e-03f, 1.82672031e-02f, -5.34581318e-02f, -9.39119831e-02f, -1.02298833e-01f, 1.93394139e-01f, 7.68583491e-02f, -1.08611241e-01f, -3.72121595e-02f, -6.55639246e-02f,
  1.46775525e-02f, 5.72634414e-02f, 1.15237096e-02f, -1.03528732e-02f, -3.00051030e-02f, 2.50807181e-02f, -9.62318704e-02f, -6.71809167e-02f, -5.86106330e-02f, 1.64708421e-02f,
  1.79002941e-01f, -5.96318319e-02f, -3.73931468e-01f, -1.99739620e-01f, 4.29647863e-02f, 2.42663458e-01f, 6.74012750e-02f, -1.66758671e-01f, -4.12456721e-01f, 8.65456238e-02f,
  1.53416201e-01f, -1.34139866e-01f, 2.75702849e-02f, 4.36301470e-01f, 2.25345701e-01f, 1.86755732e-01f, 3.26475888e-01f, 2.83120036e-01f, 6.48532510e-02f, 9.02849287e-02f,
  5.25772944e-02f, 4.03929263e-01f, 1.39038846e-01f, 1.40634328e-01f, 2.90381521e-01f, -1.55358136e-01f, 3.81966680e-02f, -1.21352300e-01f, 1.79364622e-01f, 1.10996529e-01f,
  2.67811745e-01f, 1.51718585e-02f, 3.06235049e-02f, 1.46774221e-02f, 8.18285272e-02f, 6.79128692e-02f, 2.10957173e-02f, 5.67681640e-02f, -1.31646693e-01f, 3.57229915e-03f,
  -3.58260097e-03f, -2.70141903e-02f, 2.22793538e-02f, -8.03535134e-02f, -6.27303571e-02f, -5.74729703e-02f, -1.24328092e-01f, 1.81200111e-03f, -7.47603327e-02f, 3.27245742e-02f,
  -1.24539331e-01f, 8.43577087e-02f, -6.51820377e-02f, -5.74118597e-03f, -1.20551266e-01f, -1.22560173e-01f, -1.67523529e-02f, 4.18311451e-03f, 2.72368789e-02f, -6.83050230e-02f,
  5.54067176e-03f, 6.70529306e-02f, 5.67654446e-02f, 1.48402333e-01f, 1.84274968e-02f, -1.74662974e-02f, 5.15042283e-02f, 4.37616967e-02f, -7.76817948e-02f, 6.76387176e-02f,
  -2.58091539e-02f, -3.45130637e-02f, -4.87103872e-02f, 3.61021273e-02f, 4.71208282e-02f, 8.63988884e-03f, 9.09007713e-02f, -1.76447667e-02f, -1.03878766e-01f, 1.68847516e-02f,
  -2.08140779e-02f, -6.18917160e-02f, -4.96381074e-02f, 1.18189789e-01f, 8.30018818e-02f, -1.20710999e-01f, -6.28518537e-02f, -2.16876660e-02f, -9.44124311e-02f, -2.54993271e-02f,
  1.53298065e-01f, -3.89002301e-02f, -4.99224775e-02f, 8.99250805e-02f, 9.53416452e-02f, 1.43303603e-01f, 7.32187256e-02f, 5.10703810e-02f, -1.11828092e-02f, 3.01216487e-02f,
  1.07688839e-02f, -4.67462391e-02f, 1.07615748e-02f, 4.07663500e-03f, -2.36215293e-02f, -2.05005761e-02f, 1.15415861e-03f, -8.36378932e-02f, -6.37907088e-02f, -5.49643300e-02f,
  -2.59116199e-02f, -4.56820540e-02f, -1.14365898e-01f, 2.21135467e-02f, -4.71737497e-02f, -6.11119457e-02f, 1.57459937e-02f, -7.87930414e-02f, 9.42158625e-02f, -5.04394434e-02f,
  3.24270874e-01f, -4.66860265e-01f, -2.48077229e-01f, -5.29701523e-02f, 1.42979622e-01f, 2.47911997e-02f, 6.60249684e-03f, -2.55555362e-01f, -1.88506231e-01f, -2.30867922e-01f,
  -2.69918479e-02f, 2.09028319e-01f, -8.49645212e-02f, -4.95659299e-02f, 6.22152627e-01f, 2.69574411e-02f, -2.63550840e-02f, 2.57657934e-02f, -1.48619652e-01f, -1.88637108e-01f,
  -4.10761721e-02f, 8.78337473e-02f, -5.03282584e-02f, -2.71298528e-01f, -3.16149642e-04f, -2.04823837e-01f, 7.85616636e-02f, 7.83255473e-02f, -2.25095614e-03f, 3.41941267e-01f,
  -9.23972856e-03f, -1.17873281e-01f, -5.45192659e-02f, 6.48244768e-02f, -9.72167999e-02f, 3.72186378e-02f, 1.37749910e-01f, 2.17881337e-01f, 2.11642087e-01f, -6.02013506e-02f,
  9.25029293e-02f, 1.82224512e-01f, 2.52004005e-02f, 1.44746080e-01f, 1.41882366e-02f, -6.56061396e-02f, -8.49181190e-02f, -2.93440223e-02f, -1.01761192e-01f, 4.37901169e-02f,
  -8.21389556e-02f, -1.72012933e-02f, -1.01844594e-02f, 2.83908695e-02f, -8.87757167e-03f, -5.45466170e-02f, -3.60913351e-02f, 2.85951290e-02f, -6.65466907e-03f, -7.95046166e-02f,
  -6.94286525e-02f, 7.06495047e-02f, 2.23006122e-02f, -2.30055535e-03f, -6.40210742e-03f, 1.71609726e-02f, 7.24974275e-02f, 4.29323539e-02f, 1.34248314e-02f, -3.31317224e-02f,
  -1.39949936e-02f, -2.05409955e-02f, 3.67990695e-02f, -3.54010202e-02f, -7.18950927e-02f, -2.47338247e-02f, 5.99163957e-02f, -4.53701876e-02f, -9.14194137e-02f, -4.87370789e-02f,
  1.07924558e-01f, -5.38714975e-02f, -1.10833906e-02f, -2.04249602e-02f, -8.84575956e-03f, 2.98997257e-02f, -2.69039888e-02f, -4.71379012e-02f, -6.40225187e-02f, 1.31261528e-01f,
  6.41663978e-03f, -3.92675310e-01f, -7.00927079e-02f, -2.49757059e-02f, -7.19357282e-03f, 6.75264895e-02f, 1.09777497e-02f, -9.07322988e-02f, 1.91680435e-02f, -8.43706876e-02f,
  -2.11681109e-02f, 2.92240619e-03f, -5.64763062e-02f, 1.23160042e-01f, 5.75092509e-02f, -1.99266568e-01f, 3.82294576e-03f, 9.20028687e-02f, 9.63296182e-03f, -5.19342124e-02f,
  -6.47851676e-02f, -3.86270694e-02f, 1.51989043e-01f, -6.29420951e-02f, -6.55572861e-02f, 4.10803631e-02f, 1.09576900e-02f, 4.28509489e-02f, 8.02638307e-02f, 2.93295477e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.74536937e-01f, 5.83069623e-01f, 1.83327407e-01f, 4.82324004e-01f, 5.31771839e-01f, 2.73446828e-01f, 1.49504364e-01f, 5.10868073e-01f, 3.24988455e-01f, 4.46488500e-01f,
  3.87041420e-01f, 4.35124636e-01f, 5.26379943e-01f, 2.37792447e-01f, 2.37958863e-01f, 2.65740514e-01f, 4.33979243e-01f, 3.95318031e-01f, 1.44398183e-01f, 2.82145977e-01f,
  2.23686665e-01f, 4.13459361e-01f, 3.91815156e-01f, 3.27142417e-01f, 3.53895754e-01f, 3.97791833e-01f, 3.94974083e-01f, 2.12093219e-01f, 2.17053309e-01f, 3.03082019e-01f,
  4.69192415e-01f, 4.82203454e-01f, 5.55231392e-01f, 2.21527755e-01f, 2.76238352e-01f, 3.85785103e-01f, 3.26587796e-01f, 1.58520460e-01f, 4.91926968e-01f, 3.32133949e-01f,
  4.04748827e-01f, 2.80876428e-01f, 3.85450155e-01f, 3.00747663e-01f, 5.04553139e-01f, 3.69072407e-01f, 2.97783464e-01f, 3.84062260e-01f, 4.21929628e-01f, 2.97864109e-01f,
  2.67436832e-01f, 2.93792486e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.31521877e-02f, -3.38452309e-01f, -3.67752351e-02f, -8.28176290e-02f, -1.98160291e-01f, -5.67135261e-03f, 3.43237489e-01f, 1.65574700e-01f, 1.85615256e-01f, 2.33543530e-01f,
  -2.94550300e-01f, 1.87489599e-01f, -1.39989063e-01f, -5.37829995e-01f, -2.34726548e-01f, 4.93642300e-01f, -2.18261153e-01f, 5.02591610e-01f, 2.74656508e-02f, 3.83899689e-01f,
  6.93482280e-01f, 4.38437045e-01f, 1.77166909e-01f, -4.15194519e-02f, -7.00572431e-01f, 2.52912372e-01f, 2.36439422e-01f, -1.63214002e-02f, -1.14135101e-01f, -1.85013637e-01f,
  6.33706391e-01f, -7.59908333e-02f, 5.35790384e-01f, -1.60070434e-01f, -2.17204690e-01f, -1.69546679e-01f, -1.34921521e-01f, -4.55953807e-01f, -5.36924958e-01f, -2.65097260e-01f,
  2.88113743e-01f, -2.77089268e-01f, -2.62502313e-01f, -4.23495919e-01f, -3.20166200e-01f, -3.77940178e-01f, 4.98785302e-02f, -3.40306729e-01f, 1.34710342e-01f, -4.67983298e-02f,
  -5.29371142e-01f, -5.10894895e-01f, 1.86021969e-01f, 9.41364616e-02f, -7.33064488e-02f, -3.81368011e-01f, -1.79436252e-01f, -3.74207079e-01f, -2.83513039e-01f, -2.69037277e-01f,
  -2.50017017e-01f, 3.84151667e-01f, 3.30810547e-01f, -4.30748641e-01f, -2.59846389e-01f, 1.13052472e-01f, -2.48128045e-02f, 6.18923083e-02f, 4.50534731e-01f, 1.61834881e-01f,
  -4.94512051e-01f, 1.82266071e-01f, -6.24501050e-01f, -5.95162325e-02f, 9.44560245e-02f, 4.03505713e-01f, -5.94539702e-01f, 4.17014837e-01f, 1.51135419e-02f, -4.95012432e-01f,
  3.62413943e-01f, -5.24151981e-01f, 2.92121530e-01f, 2.83903778e-01f, -5.56860566e-01f, 3.66186619e-01f, -7.30132639e-01f, -4.00901437e-01f, -1.76911026e-01f, 6.10199198e-02f,
  4.03591245e-01f, -1.82762183e-02f, -2.49059767e-01f, -4.37408209e-01f, -2.91847914e-01f, 1.71167627e-01f, 2.81836122e-01f, -4.42910701e-01f, 2.80864686e-01f, -1.20428942e-01f,
  -1.81351066e-01f, 5.03568351e-01f, 5.81497848e-01f, -2.00438395e-01f, 5.19089520e-01f, -7.58729756e-01f, -1.82475254e-01f, -2.84640700e-01f, -1.46466479e-01f, -2.36461371e-01f,
  2.55120452e-02f, 1.50959551e-01f, -1.89068034e-01f, 1.96533397e-01f, 1.51085228e-01f, -3.26413542e-01f, -7.34280229e-01f, -4.39918578e-01f, -5.69500983e-01f, -3.98022443e-01f,
  -5.10654271e-01f, -2.22161844e-01f, -1.68202773e-01f, -2.15080887e-01f, -6.11408234e-01f, 4.46775109e-01f, 5.02997518e-01f, 1.39178365e-01f, -2.87567705e-01f, 1.85704846e-02f,
  -7.03859031e-02f, -5.50782215e-03f, -1.85637653e-01f, -2.51040906e-01f, -1.12177372e-01f, 1.98301122e-01f, 2.72452414e-01f, 1.28403291e-01f, 2.04075292e-01f, -2.91230232e-01f,
  3.70393842e-01f, 3.18129599e-01f, -1.64853364e-01f, -2.48476982e-01f, -4.79204983e-01f, -2.58828729e-01f, -3.09707731e-01f, -4.28421140e-01f, -1.70262143e-01f, -2.42056638e-01f,
  -1.55913487e-01f, -1.33072957e-01f, -4.05349255e-01f, 2.05876857e-01f, -3.07137609e-01f, 4.72875565e-01f, -3.67546409e-01f, -3.79513770e-01f, 1.89763501e-01f, -5.61847925e-01f,
  4.07617450e-01f, 1.75746728e-03f, -1.96779400e-01f, -2.03877181e-01f, -1.81782663e-01f, 2.59908766e-01f, 4.07250762e-01f, -1.58613339e-01f, 7.14614913e-02f, 5.20744443e-01f,
  -1.77125737e-01f, 5.72413057e-02f, 8.26844200e-02f, -4.43562381e-02f, -3.52333814e-01f, 2.38672085e-03f, -2.99795210e-01f, 1.87082350e-01f, 2.67921031e-01f, -4.14273947e-01f,
  -1.07349262e-01f, 3.87002856e-01f, -6.80176914e-02f, -5.06810427e-01f, -1.90335780e-03f, -2.12788910e-01f, 4.52158988e-01f, -1.69601977e-01f, -3.95921886e-01f, -3.94876957e-01f,
  1.33378446e-01f, 4.61496919e-01f, 1.01304702e-01f, -1.95988178e-01f, -1.43805623e-01f, -4.57101166e-01f, -1.19092494e-01f, 1.61303014e-01f, 2.93677270e-01f, 1.72937810e-01f,
  -1.61112532e-01f, 3.46638411e-01f, -1.05367765e-01f, 9.46004223e-03f, -1.36125952e-01f, -5.34757018e-01f, -3.26017678e-01f, -4.34483826e-01f, -4.47113693e-01f, 2.20313609e-01f,
  7.20723927e-01f, 4.84753400e-01f, 2.50535101e-01f, -5.87618589e-01f, 2.62265712e-01f, 4.25993115e-01f, -4.73881930e-01f, -3.28653663e-01f, -3.63145731e-02f, 7.50136897e-02f,
  -5.81674337e-01f, 1.12728998e-01f, 9.61643606e-02f, -1.47055835e-01f, -3.51959854e-01f, -4.63841110e-01f, -3.23651671e-01f, -6.18248343e-01f, 1.32320210e-01f, -1.50215402e-01f,
  -3.40512574e-01f, 6.07210934e-01f, -2.81638891e-01f, -3.59959751e-01f, -3.20245534e-01f, 2.61056125e-01f, 1.52837634e-01f, 5.14661014e-01f, 2.04390705e-01f, -1.92074418e-01f,
  -2.93433815e-01f, -9.42834914e-02f, -2.84377605e-01f, 1.24868840e-01f, 3.58149350e-01f, -1.79198176e-01f, 4.72304523e-01f, -3.76052529e-01f, -5.69935620e-01f, -1.13216124e-01f,
  -1.13026291e-01f, 4.96552229e-01f, -1.31830007e-01f, -2.52041429e-01f, -3.27780873e-01f, -7.73769319e-02f, 1.83507744e-02f, -2.05469280e-01f, 2.62399226e-01f, 9.58453268e-02f,
  7.26054236e-03f, 4.47869003e-02f, 4.02364463e-01f, 4.83729750e-01f, 1.12704977e-01f, 2.96817482e-01f, -1.68803543e-01f, -1.31422818e-01f, -3.82482469e-01f, 7.79186487e-02f,
  1.44269034e-01f, -2.66688406e-01f, -7.63968006e-02f, 4.87893641e-01f, -5.39283156e-01f, -3.34792167e-01f, -2.56268919e-01f, 5.60928762e-01f, -1.50855090e-02f, 7.61838406e-02f,
  3.51008028e-01f, -5.69620609e-01f, -2.76469082e-01f, 5.05414665e-01f, 2.25699469e-01f, 2.70502120e-01f, -8.45844150e-02f, 7.49037564e-02f, -1.02824405e-01f, 1.03660235e-02f,
  -3.08395058e-01f, -2.32130736e-01f, -2.53405064e-01f, -4.45415318e-01f, -6.55020699e-02f, -2.52712011e-01f, -2.62793660e-01f, 5.22559404e-01f, -4.74333018e-02f, 6.31837547e-01f,
  4.78518248e-01f, -7.70273268e-01f, 4.23819363e-01f, -3.57372373e-01f, 5.17480314e-01f, -1.50637537e-01f, -1.01977671e-02f, 4.52718854e-01f, 3.05823714e-01f, -5.68607152e-01f,
  5.07288635e-01f, -8.09597373e-02f, -2.39558235e-01f, -1.03244103e-01f, -3.93031240e-01f, -2.45601997e-01f, 3.28214839e-02f, -5.89473784e-01f, 1.62291884e-01f, -4.72271144e-01f,
  2.81289458e-01f, 4.59726810e-01f, 3.59604478e-01f, -3.33116204e-02f, 1.98373124e-01f, 2.60846168e-01f, -1.12696134e-01f, -1.75623491e-01f, -1.61708206e-01f, -1.89547971e-01f,
  -1.65857553e-01f, -1.15780840e-02f, -3.57813537e-01f, -4.83366698e-01f, -2.00539887e-01f, 4.35410053e-01f, 5.05030632e-01f, -3.28983963e-01f, -1.59525022e-01f, 5.45588493e-01f,
  -6.37920618e-01f, 4.84444313e-02f, 6.51740611e-01f, -2.59490460e-01f, 6.08200014e-01f, 4.91593182e-01f, -3.14885557e-01f, -4.48985368e-01f, 5.51854074e-01f, 1.16630770e-01f,
  -1.38939410e-01f, -2.53682911e-01f, -6.57325268e-01f, 2.43471757e-01f, -1.69767261e-01f, -1.00602627e-01f, -7.19811255e-03f, 2.87203826e-02f, -3.28622639e-01f, -4.74505693e-01f,
  -2.39158094e-01f, 3.21407676e-01f, 3.71946961e-01f, -5.56726813e-01f, -4.19826746e-01f, -2.98145562e-01f, -2.49872670e-01f, -2.86183059e-01f, -2.13641793e-01f, -3.78998935e-01f,
  1.97253555e-01f, -1.03869721e-01f, -4.89849538e-01f, -6.15774572e-01f, 6.94768801e-02f, 6.16450198e-02f, 1.71601400e-01f, 5.75641513e-01f, 4.14380640e-01f, -5.10361254e-01f,
  -5.70333362e-01f, 2.24957004e-01f, -3.03426504e-01f, -3.13224494e-01f, -1.69327706e-02f, -8.94226059e-02f, -3.73085499e-01f, -5.95503747e-02f, 1.13707379e-01f, -3.48615676e-01f,
  -3.31924379e-01f, -3.92122209e-01f, 2.88861960e-01f, 2.05886766e-01f, -1.42423194e-02f, 5.62307723e-02f, 6.77946925e-01f, 1.92824438e-01f, -2.67023832e-01f, -1.78452432e-02f,
  -4.20183539e-01f, -2.20386907e-01f, 1.07271649e-01f, -5.41339517e-01f, -1.70521215e-01f, -5.38829207e-01f, -4.15079445e-01f, 3.31733137e-01f, 4.05532151e-01f, 5.49084833e-03f,
  -1.70093402e-01f, -2.15375819e-03f, 6.81516156e-02f, -2.78350592e-01f, -1.24524906e-01f, -8.93732905e-02f, -5.82803607e-01f, 1.92977428e-01f, -3.35498065e-01f, 1.61760867e-01f,
  -4.26801890e-01f, 4.41184521e-01f, -5.88656776e-02f, -2.39255562e-01f, -2.63244100e-02f, -4.76553053e-01f, 2.63569534e-01f, 2.14654267e-01f, -6.50518417e-01f, -5.88389598e-02f,
  -2.69980162e-01f, 7.06941247e-01f, -4.60173666e-01f, -3.18553120e-01f, -5.69688201e-01f, -3.61262590e-01f, 2.94049472e-01f, 2.94642627e-01f, -2.31730178e-01f, 6.68112695e-01f,
  -3.64551216e-01f, -6.16745278e-02f, 4.00051445e-01f, 2.67078340e-01f, 2.42610291e-01f, 4.25661981e-01f, -3.92481446e-01f, -2.05517650e-01f, -4.16103274e-01f, -4.81766909e-02f,
  -2.19357088e-01f, -1.14001237e-01f, -2.58653343e-01f, -1.33143574e-01f, 1.63871497e-01f, -3.23149890e-01f, -1.85801193e-01f, -2.61497438e-01f, 8.81997123e-02f, 7.98860285e-03f,
  -2.52128899e-01f, -5.00203550e-01f, 4.92284894e-01f, -3.58200073e-01f, -1.85070664e-01f, -6.76031807e-04f, 3.39595854e-01f, -4.79479402e-01f, 2.51073182e-01f, -3.57452601e-01f,
  4.00856018e-01f, -8.33282620e-02f, 1.71059638e-01f, 2.57451952e-01f, -1.83289766e-01f, -6.97969720e-02f, 1.88178234e-02f, -5.66505343e-02f, -2.43889168e-01f, 1.28528237e-01f,
  -1.27441198e-01f, -2.37998590e-01f, -1.93566307e-02f, 5.01553297e-01f, -1.23621061e-01f, -1.77423954e-01f, -2.15993077e-01f, -4.41629104e-02f, -4.68629263e-02f, 2.85875827e-01f,
  -2.45535284e-01f, -1.91315457e-01f, -2.50882566e-01f, 1.01421706e-01f, 3.58302027e-01f, -3.15723956e-01f, 8.69953036e-02f, -1.28696620e-01f, 2.71623343e-01f, 3.69371250e-02f,
  -2.66852677e-01f, 2.73750246e-01f, 1.88527286e-01f, 2.47783065e-01f, -2.79279858e-01f, 4.08635497e-01f, -1.15915015e-01f, 3.99538219e-01f, 9.43054855e-02f, -2.66590238e-01f,
  -1.39450327e-01f, 2.77344972e-01f, 4.20840420e-02f, 3.87914106e-02f, -6.05068356e-03f, -1.01180322e-01f, -3.70311141e-01f, -2.54725307e-01f, -4.23718281e-02f, 2.49822289e-01f,
  1.80141870e-02f, -1.40176356e-01f, 2.37596154e-01f, -3.32955033e-01f, -2.49023870e-01f, -3.45747381e-01f, -1.88582763e-01f, -1.81811079e-01f, -9.83361825e-02f, -1.69036955e-01f,
  -2.60284776e-03f, -2.33474880e-01f, 5.19564142e-03f, -2.26665899e-01f, -9.79659408e-02f, -4.46487755e-01f, -2.78754026e-01f, -3.26383531e-01f, 2.59335577e-01f, -3.91573906e-01f,
  -2.15725169e-01f, 4.73837048e-01f, -2.28137031e-01f, 4.24274445e-01f, -1.88810512e-01f, 3.27728093e-02f, 3.77075881e-01f, -8.34191591e-02f, -2.72819698e-01f, 3.07019409e-02f,
  1.78828493e-01f, 2.77138650e-01f, 3.00124943e-01f, 5.67485213e-01f, -1.80380404e-01f, -1.55007794e-01f, -1.84887871e-01f, -2.39427269e-01f, -2.31638968e-01f, -2.54412264e-01f,
  -1.47476658e-01f, 4.33100939e-01f, -2.71358579e-01f, -2.16177672e-01f, 5.94312735e-02f, -2.58827835e-01f, -1.07734784e-01f, -1.10629618e-01f, 3.40791315e-01f, 2.68355429e-01f,
  3.43707353e-01f, 6.37714937e-03f, 5.40704966e-01f, -1.24183469e-01f, -1.26937434e-01f, -3.59588623e-01f, 1.76903438e-02f, 1.55299187e-01f, 1.77873299e-02f, 4.60450351e-02f,
  9.34841856e-02f, 1.46283522e-01f, 2.51174867e-01f, -1.94679901e-01f, 3.36774230e-01f, -3.22271675e-01f, 2.76569486e-01f, 2.12764964e-01f, 2.81573564e-01f, 3.46763402e-01f,
  -2.25148275e-01f, 4.77055758e-01f, -2.02449262e-01f, -3.43521684e-01f, -1.63549572e-01f, -3.41015190e-01f, -9.71178040e-02f, 1.72485828e-01f, -2.79957324e-01f, -3.85814011e-01f,
  1.87113941e-01f, -3.23842257e-01f, 2.29844078e-01f, -4.39407110e-01f, 3.23101133e-01f, -2.64286339e-01f, 1.77932799e-01f, -3.87712955e-01f, -8.17934200e-02f, -3.32912475e-01f,
  -3.30616057e-01f, 2.53497124e-01f, -1.30051091e-01f, -2.40803346e-01f, -2.11054921e-01f, -9.23103020e-02f, -5.73409021e-01f, -1.80754915e-01f, -5.97899735e-01f, -6.09468579e-01f,
  3.08009952e-01f, -2.78967351e-01f, 2.91955024e-01f, -2.07232773e-01f, 5.75283587e-01f, -1.64894566e-01f, 3.76376092e-01f, 5.16066611e-01f, -4.32201713e-01f, 6.31969392e-01f,
  -4.68273014e-01f, 1.96120664e-01f, 3.20574999e-01f, -1.98912963e-01f, -6.57522857e-01f, -4.30678278e-01f, 4.88771766e-01f, -4.10862565e-01f, -8.44086893e-03f, 5.86154282e-01f,
  1.31186293e-02f, 2.21174717e-01f, 9.94041190e-02f, 2.46676713e-01f, 9.60655138e-02f, -5.24841137e-02f, -4.00868267e-01f, -2.38859519e-01f, -3.52819711e-01f, -3.82945687e-01f,
  -2.12798581e-01f, -4.38388139e-01f, -2.94102848e-01f, 3.60257596e-01f, 3.75460297e-01f, -2.37863436e-01f, 2.58963183e-02f, -1.19542658e-01f, -4.84406054e-01f, -1.88146867e-02f,
  4.26001698e-01f, -3.04599375e-01f, -2.62666583e-01f, 4.62149620e-01f, -1.21285968e-01f, -1.75599173e-01f, -6.97385669e-02f, -3.41975003e-01f, -2.36895129e-01f, -3.83019567e-01f,
  -2.14088008e-01f, 3.54288429e-01f, 3.22625846e-01f, -3.49029481e-01f, 2.26558417e-01f, 4.39587325e-01f, 4.12771732e-01f, -2.70535022e-01f, 3.56851697e-01f, -1.52138948e-01f,
  -2.64916658e-01f, -3.85951579e-01f, 2.38938704e-01f, -4.92449105e-02f, 3.40180188e-01f, 5.95141828e-01f, -4.13671792e-01f, -3.95318836e-01f, -2.55605876e-01f, 8.74583423e-02f,
  3.50225985e-01f, -2.49824345e-01f, 3.76859218e-01f, -2.46915177e-01f, -6.14304900e-01f, -6.35675862e-02f, 5.01983285e-01f, -4.27307576e-01f, -2.14859217e-01f, -5.07669568e-01f,
  -2.96724617e-01f, -3.28390688e-01f, -4.68525499e-01f, -2.60947973e-01f, 1.09277993e-01f, -6.90159053e-02f, -4.17421348e-02f, 1.79962456e-01f, 3.94942388e-02f, 1.50252819e-01f,
  8.70847888e-03f, -2.36381397e-01f, 3.90889823e-01f, 1.44039050e-01f, -2.04660609e-01f, 3.37604702e-01f, 1.25651464e-01f, -2.98877537e-01f, -1.52633458e-01f, 3.56950164e-01f,
  6.71917051e-02f, -1.20528840e-01f, -1.31704569e-01f, -3.11769128e-01f, 5.01423702e-02f, -3.32429618e-01f, 5.03981598e-02f, -5.01770914e-01f, -5.28634429e-01f, -2.01308236e-01f,
  -2.08513215e-01f, -1.92434624e-01f, -3.84911716e-01f, 5.69981158e-01f, -2.16837570e-01f, -3.21965724e-01f, -1.84198037e-01f, 6.04320824e-01f, 4.76149350e-01f, -1.02111846e-01f,
  5.42491972e-01f, -3.12873900e-01f, -3.00596237e-01f, 3.50142092e-01f, -2.24158213e-01f, -3.14229667e-01f, 5.48703492e-01f, 4.25202608e-01f, 3.20460051e-01f, -3.67775261e-01f,
  -2.20556587e-01f, 3.35909873e-01f, -3.01184028e-01f, -2.54936606e-01f, -2.52293110e-01f, -2.08482102e-01f, -1.71522111e-01f, 8.99777561e-03f, 4.88446876e-02f, -2.88950622e-01f,
  3.56253594e-01f, -7.95928296e-03f, -3.19482595e-01f, 6.06000066e-01f, -3.33646595e-01f, -2.83529371e-01f, -1.33629426e-01f, -9.37092826e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.23766284e-02f, 7.00526983e-02f, -9.67540871e-03f, -8.89384076e-02f, 1.57339811e-01f, 1.44093037e-01f, 3.33173908e-02f, -1.14654385e-01f, -1.49278164e-01f, 3.72517342e-03f,
  8.73612687e-02f, 9.96803790e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    