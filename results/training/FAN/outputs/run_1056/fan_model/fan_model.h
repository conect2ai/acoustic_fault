/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.46644980e-01f, 1.10946700e-01f, 3.74475181e-01f, -2.38444060e-01f, 5.66384122e-02f, 2.66851872e-01f, 3.26908141e-01f, 7.56276771e-02f, -9.66892615e-02f, -3.18547189e-02f,
  -2.48652566e-02f, -1.75240904e-01f, -1.56864852e-01f, -7.88166672e-02f, -7.05355313e-03f, 2.90356111e-02f, -8.23416337e-02f, -5.42333052e-02f, 1.96987600e-03f, 4.25405093e-02f,
  -2.34545827e-01f, -1.42072946e-01f, -2.41233721e-01f, -2.10947469e-01f, -4.87138927e-02f, -1.73325017e-01f, -3.92861553e-02f, -1.99303012e-02f, 2.83710603e-02f, -9.95459631e-02f,
  2.73578376e-01f, 1.59081593e-01f, -1.16957396e-01f, -8.43931511e-02f, 2.57952046e-02f, -2.12714244e-02f, 3.64362113e-02f, 7.01812878e-02f, 1.96477771e-03f, -4.47213016e-02f,
  -8.21202397e-02f, -1.18363440e-01f, -1.13284530e-03f, 4.59169177e-03f, -3.41985635e-02f, 1.91041380e-02f, -4.21115309e-02f, -7.50373378e-02f, -7.62367016e-03f, 7.89973959e-02f,
  -1.35305762e-01f, 9.82667506e-03f, 7.54159987e-02f, 1.09640285e-01f, 4.50668260e-02f, -1.06953211e-01f, 1.02549575e-01f, 3.72621790e-02f, 2.04179570e-01f, 1.06340080e-01f,
  -6.85390905e-02f, 1.25933513e-01f, 1.29087850e-01f, 1.23954624e-01f, 5.20991869e-02f, 9.35003918e-04f, 5.50894476e-02f, 1.13037720e-01f, 9.68548805e-02f, 3.79430242e-02f,
  2.91457716e-02f, 6.07049167e-02f, 9.83067974e-02f, -3.07635451e-03f, 1.05093524e-01f, 1.20385207e-01f, 4.69863936e-02f, 2.13694796e-02f, 1.36364698e-01f, 1.43208772e-01f,
  1.20702103e-01f, 3.09594739e-02f, 7.15090856e-02f, -3.28986091e-03f, 1.17305666e-01f, 4.55176942e-02f, 1.14247888e-01f, 1.13192670e-01f, 1.48380324e-01f, 2.37521119e-02f,
  -1.59114853e-01f, -9.76198986e-02f, -3.85933183e-02f, -3.26362252e-02f, -8.42328221e-02f, -1.14118353e-01f, -7.66223297e-02f, -5.11487164e-02f, -4.68955189e-02f, 1.97457392e-02f,
  6.38255402e-02f, -1.25280961e-01f, -1.14598453e-01f, -7.98702687e-02f, -3.66634615e-02f, -4.77543175e-02f, -1.70822307e-01f, -9.81761664e-02f, -7.34973028e-02f, 9.89021882e-02f,
  -4.73236591e-02f, 7.44505078e-02f, 4.67063487e-02f, -5.01402095e-02f, -5.16855940e-02f, -1.79754570e-01f, 4.56236303e-02f, 3.07834148e-02f, 2.68151909e-02f, -1.22140832e-01f,
  -5.29980600e-01f, 5.70899695e-02f, -2.74470270e-01f, -6.73632091e-03f, 1.19395539e-01f, -2.49848403e-02f, -1.10991471e-01f, -2.21933141e-01f, 1.55991558e-02f, 1.86257437e-02f,
  -1.10946586e-02f, -9.79520082e-02f, -1.19766630e-01f, -1.54526889e-01f, -3.85506213e-01f, -9.56272855e-02f, -5.24987504e-02f, -3.87756735e-01f, -3.44481409e-01f, -1.10157721e-01f,
  1.35155404e-02f, 2.24625804e-02f, -3.16765934e-01f, -1.65551439e-01f, 1.58868924e-01f, 1.15273945e-01f, -7.12011233e-02f, -9.15983766e-02f, 5.86379506e-02f, 4.59224209e-02f,
  -1.24347396e-01f, -3.19118261e-01f, -7.99723566e-02f, -4.03721258e-02f, -5.66736013e-02f, -2.14339390e-01f, -1.04574986e-01f, -2.43694499e-01f, -1.56742096e-01f, -1.21536672e-01f,
  -6.18449748e-02f, -1.27725974e-01f, -2.10037101e-02f, -1.01803243e-01f, -6.95497766e-02f, -1.65395498e-01f, -1.52686596e-01f, -2.06358731e-01f, -1.33480951e-01f, -1.75998271e-01f,
  -3.62211801e-02f, -1.05931498e-02f, -2.18834683e-01f, -1.84322208e-01f, -8.57693553e-02f, -1.81009397e-01f, -7.98753276e-02f, -2.09005833e-01f, -2.09268332e-01f, -9.67783257e-02f,
  1.36402115e-01f, 1.26972795e-01f, 7.62821585e-02f, 1.12142354e-01f, 1.27205968e-01f, 6.32070079e-02f, 8.02292898e-02f, 1.26330465e-01f, 1.47982046e-01f, 1.00478902e-01f,
  1.84112322e-02f, 1.02079317e-01f, 1.31419688e-01f, -1.14417430e-02f, 8.13226476e-02f, 5.21863624e-02f, 5.17986268e-02f, 9.59150493e-02f, 7.14334324e-02f, 1.36572421e-01f,
  1.61702409e-01f, 1.23182200e-01f, 9.32202414e-02f, 5.13117723e-02f, 6.67778328e-02f, 1.05644651e-01f, -1.39319180e-02f, 1.33704320e-01f, 1.30509362e-01f, 8.49330276e-02f,
  6.35818020e-02f, -2.81840473e-01f, 4.03624726e-03f, -1.92283243e-01f, -1.64225977e-02f, -1.49574488e-01f, -2.60086469e-02f, -1.39096677e-01f, -1.43889427e-01f, -6.68436363e-02f,
  -8.65669101e-02f, -1.30932078e-01f, -8.37268084e-02f, -4.63742018e-02f, -3.88870165e-02f, -1.23002008e-01f, 4.39400524e-02f, -9.03921574e-02f, -1.49063095e-01f, -2.28554253e-02f,
  7.62801245e-02f, -8.64168853e-02f, -1.39818624e-01f, -3.77231874e-02f, -1.93206947e-02f, -9.60397050e-02f, -4.25398760e-02f, -2.99258661e-02f, -1.75865188e-01f, -5.39774485e-02f,
  8.90420750e-02f, 2.22235799e-01f, -1.24148987e-01f, 1.02320679e-01f, -2.36076340e-01f, -3.94246101e-01f, -3.61712277e-01f, -1.66190460e-01f, -1.56098306e-01f, -8.93952399e-02f,
  -1.98739335e-01f, -2.01062799e-01f, -1.35794327e-01f, -2.30704859e-01f, -3.15794408e-01f, -1.33885756e-01f, -8.58862400e-02f, -3.47467214e-01f, -4.01405245e-01f, -2.88791358e-01f,
  -7.53854215e-02f, -1.51339471e-02f, 6.73795771e-03f, -5.49136773e-02f, 1.37062848e-03f, -7.97783732e-02f, 1.04547581e-02f, -3.78792174e-02f, -2.63848305e-01f, -2.72554625e-02f,
  -3.88283432e-01f, 8.05370801e-04f, -3.28384429e-01f, -8.19691420e-02f, -3.38002332e-02f, -1.48795158e-01f, -1.89399436e-01f, -8.46444294e-02f, -1.44321561e-01f, -9.08532962e-02f,
  -5.75911291e-02f, -5.25716692e-02f, -1.66136086e-01f, -1.84431896e-02f, -1.33492112e-01f, -2.60081172e-01f, -1.56043574e-01f, -1.18762553e-01f, -1.54524505e-01f, -1.06900528e-01f,
  -4.94072698e-02f, -1.51701406e-01f, -1.38067871e-01f, -1.50970757e-01f, -1.64664969e-01f, -1.82416365e-01f, -2.46511236e-01f, -1.52193829e-01f, -3.07346046e-01f, -1.84766620e-01f,
  7.65851960e-02f, 1.63751662e-01f, 1.64121509e-01f, 2.04128772e-01f, 2.26108015e-01f, 1.15932308e-01f, 1.61365747e-01f, 1.93907678e-01f, 1.60095930e-01f, 1.75823912e-01f,
  2.12078601e-01f, 1.82465717e-01f, 1.60216302e-01f, 1.95431754e-01f, 1.25604823e-01f, 1.98319599e-01f, 1.04567006e-01f, 1.03945106e-01f, 1.53027207e-01f, 1.78485915e-01f,
  2.00582877e-01f, 1.03686206e-01f, 1.72874421e-01f, 1.73378453e-01f, 6.01287335e-02f, 2.14865170e-02f, 1.27002105e-01f, 1.50943771e-01f, 1.95098564e-01f, 1.27481818e-01f,
  -9.10976380e-02f, -3.06711406e-01f, -1.53946161e-01f, -1.25276029e-01f, -1.94936797e-01f, -1.28545031e-01f, -7.89790899e-02f, -1.43475562e-01f, -1.51281998e-01f, -1.16417870e-01f,
  -2.68927306e-01f, -2.43955418e-01f, -1.33170649e-01f, -1.38512477e-01f, -1.68951198e-01f, -1.63651481e-01f, -3.49186212e-02f, -1.80152208e-01f, -1.66043162e-01f, -1.72488362e-01f,
  -7.67214149e-02f, -3.21911097e-01f, -3.00502419e-01f, -2.52992392e-01f, -1.66914254e-01f, -3.84697706e-01f, -2.94126272e-01f, -3.19158345e-01f, -3.87796819e-01f, -2.21410617e-01f,
  1.71666041e-01f, 2.39397764e-01f, -1.84012279e-01f, -2.96336189e-02f, 9.18819010e-02f, 1.46220252e-01f, 3.23146194e-01f, 2.06994757e-01f, -1.72156692e-02f, 1.04671828e-01f,
  6.47969171e-02f, -1.02785319e-01f, -3.88029404e-02f, -1.45837739e-01f, -8.89533460e-02f, -1.13401592e-01f, -1.46615982e-01f, -2.81360209e-01f, -1.55104771e-01f, -2.51561124e-02f,
  -2.81771366e-02f, -8.77966136e-02f, -7.65771940e-02f, -1.97085068e-01f, -2.39954546e-01f, -2.35057399e-01f, -7.97832161e-02f, -4.54902686e-02f, -2.16784123e-02f, -4.26105976e-01f,
  -4.16439980e-01f, -2.47012489e-02f, -1.18168250e-01f, -9.88584682e-02f, -1.86889600e-02f, -1.06099702e-01f, -3.83526087e-02f, -1.08340390e-01f, 3.13225538e-02f, -1.23095982e-01f,
  -6.25902787e-02f, -5.50203063e-02f, -1.71022594e-01f, -1.26538113e-01f, -1.84170548e-02f, -8.71449038e-02f, -1.42778724e-01f, -1.38091072e-01f, -6.63500205e-02f, -8.70548263e-02f,
  -7.89724961e-02f, 5.58532029e-02f, -7.88761228e-02f, -7.92750418e-02f, -4.64159027e-02f, -1.45892695e-01f, -1.61815047e-01f, -8.90337229e-02f, 5.08383475e-03f, -2.13560224e-01f,
  3.36534455e-02f, 9.66587290e-02f, 8.78669247e-02f, -2.96445144e-03f, 9.72929299e-02f, 3.67970504e-02f, 5.54803535e-02f, 1.11603037e-01f, 5.12286313e-02f, 3.12345419e-02f,
  1.47273660e-01f, 4.57293503e-02f, -3.39414575e-03f, 1.46898061e-01f, 8.20277557e-02f, 1.66188583e-01f, 6.89463317e-02f, 4.73163500e-02f, 6.39905706e-02f, 4.59693410e-02f,
  4.86388318e-02f, 1.26129566e-02f, 1.11282922e-01f, 4.24143933e-02f, 1.06885031e-01f, 8.63149539e-02f, 1.72543712e-02f, 1.16173312e-01f, 1.30787522e-01f, 6.23891428e-02f,
  4.57243212e-02f, 6.27388060e-02f, -1.44691721e-01f, -1.37409911e-01f, -1.82515636e-01f, -4.84691560e-02f, -1.06220327e-01f, -1.72715724e-01f, -1.52610466e-01f, -8.20876658e-02f,
  -4.53684442e-02f, -1.45429119e-01f, -2.38189921e-02f, -8.19984376e-02f, -1.73534974e-02f, -1.17626309e-01f, 7.09089413e-02f, -7.34624788e-02f, -8.12050477e-02f, -1.33686826e-01f,
  1.75187606e-02f, 5.96343391e-02f, -4.60039228e-02f, 3.65524292e-02f, -1.04472831e-01f, -4.54649739e-02f, -5.35794534e-02f, -9.60310474e-02f, 4.94380929e-02f, 4.69879769e-02f,
  -3.44667852e-01f, -2.55829692e-01f, 5.65283373e-02f, -3.30976546e-02f, 9.95925888e-02f, -4.34036031e-02f, -8.94932672e-02f, -2.59500474e-01f, -1.18944950e-01f, -1.93376079e-01f,
  -1.37677923e-01f, -3.97901610e-02f, -5.10194227e-02f, 1.02761593e-02f, -1.77952442e-02f, -1.12356143e-02f, 1.72496468e-01f, 1.00427166e-01f, 2.18367264e-01f, -2.19116062e-02f,
  4.25139219e-02f, 4.20288928e-02f, 8.89513418e-02f, 1.29981562e-01f, 6.73396280e-03f, 1.39103755e-01f, 1.24197982e-01f, 1.68351620e-01f, 2.18998447e-01f, 2.41722122e-01f,
  8.98100287e-02f, -8.89260694e-02f, 2.17481945e-02f, 1.67073980e-02f, 7.31713651e-03f, -5.89970388e-02f, -1.66287031e-02f, 1.09425485e-01f, 2.69849249e-03f, -3.38675524e-03f,
  8.38608071e-02f, 8.25865567e-02f, -1.76954251e-02f, 9.80143994e-02f, -1.10819354e-03f, -1.84071399e-02f, 7.55646750e-02f, 2.29028883e-04f, 9.32345837e-02f, -4.19292822e-02f,
  -6.92737754e-03f, 4.67878431e-02f, 5.19189946e-02f, -7.09164068e-02f, -7.72991311e-03f, 9.30356979e-03f, 4.79200482e-02f, -5.81832640e-02f, 5.04889805e-03f, -9.13186669e-02f,
  -9.87769961e-02f, -5.88934645e-02f, -1.83281694e-02f, -1.14340350e-01f, 7.31728151e-02f, 7.23316967e-02f, 9.70324203e-02f, 1.16076618e-01f, -7.16365054e-02f, -7.80459195e-02f,
  7.01186284e-02f, -1.62760112e-02f, 8.29953104e-02f, -1.18543796e-01f, -8.54992345e-02f, -2.56490260e-02f, 7.74428174e-02f, -7.67569542e-02f, 5.09392191e-03f, 4.07830216e-02f,
  8.28814358e-02f, -3.18113435e-03f, 8.70600119e-02f, 1.29663264e-02f, 7.79384747e-02f, 2.98260022e-02f, -2.13760044e-02f, 5.88992313e-02f, -1.17754288e-01f, -8.20612013e-02f,
  -2.03633174e-01f, 2.10242122e-01f, 2.95550954e-02f, -2.68805269e-02f, -2.97995657e-02f, 5.79487011e-02f, 8.07900447e-03f, 5.80065213e-02f, 4.09214497e-02f, -3.31809595e-02f,
  -3.52361128e-02f, -1.31352423e-02f, -1.01251319e-01f, 7.46733174e-02f, 5.94362766e-02f, -1.14357127e-02f, -7.85156386e-04f, -4.11440395e-02f, -1.30903721e-02f, 7.46007636e-02f,
  5.99955358e-02f, -6.86295852e-02f, -1.54232219e-01f, -4.68265116e-02f, 3.53825875e-02f, -3.59255038e-02f, -1.06212080e-01f, -8.81496966e-02f, -6.73262030e-02f, -1.88569278e-01f,
  1.87265798e-01f, 1.65749669e-01f, 5.83528839e-02f, -4.03902084e-02f, 2.46587127e-01f, 2.85257250e-01f, 3.21868092e-01f, 3.85891832e-02f, 2.58659627e-02f, 8.97001326e-02f,
  1.62420303e-01f, -1.84563592e-01f, -2.30164841e-01f, -6.92351833e-02f, -9.11593884e-02f, -1.35591328e-01f, -1.84460714e-01f, -2.47153535e-01f, -8.79222751e-02f, 7.31136575e-02f,
  -5.64336479e-02f, -8.99021700e-02f, -1.12585947e-01f, -2.16653451e-01f, -6.63123280e-02f, -1.79769412e-01f, -1.14858828e-01f, 8.81191716e-02f, 3.71192731e-02f, -1.54402748e-01f,
  1.43810466e-01f, 1.74667090e-01f, -7.86216781e-02f, -9.11922604e-02f, -3.64760845e-03f, 3.14448029e-02f, 7.09948763e-02f, -1.50228264e-02f, -3.41388695e-02f, 5.05160540e-02f,
  5.76989632e-03f, 2.91965604e-02f, 3.71977985e-02f, -5.73592111e-02f, 1.08291537e-01f, 3.12293470e-02f, -3.18565294e-02f, -8.15929696e-02f, -1.14381060e-01f, 6.28893003e-02f,
  1.85453631e-02f, 1.05405681e-01f, 1.85112193e-01f, -6.51478861e-03f, -9.15543991e-04f, 5.29744513e-02f, 4.34175208e-02f, -3.62059250e-02f, 5.74742071e-02f, 5.96428327e-02f,
  -6.86667487e-02f, -2.71551833e-02f, 2.25577261e-02f, -9.44827348e-02f, -2.46821679e-02f, -2.07740739e-02f, -1.50074765e-01f, -1.78034101e-02f, -7.22938105e-02f, -4.45051529e-02f,
  -8.29620734e-02f, 2.96292026e-02f, 1.18796397e-02f, 3.72176990e-02f, -7.80066922e-02f, -1.03458194e-02f, -3.45348231e-02f, 3.47037464e-02f, -4.23657484e-02f, 4.52494957e-02f,
  -1.73488986e-02f, -6.75423369e-02f, -3.30860503e-02f, -8.91031176e-02f, -7.00073466e-02f, -5.16944565e-02f, 1.51306987e-02f, 5.20593440e-03f, 1.15115218e-01f, 1.10438824e-01f,
  8.69686902e-02f, -3.13766375e-02f, -1.47719961e-02f, -3.48823927e-02f, 9.01756361e-02f, 7.18943821e-03f, 3.04569658e-02f, -6.49245735e-03f, 4.92873974e-02f, -5.58962226e-02f,
  8.90086070e-02f, 5.09195179e-02f, 5.31858988e-02f, -6.91667572e-02f, 4.07560095e-02f, 6.24735169e-02f, 1.44512933e-02f, 5.93850426e-02f, -3.66676040e-02f, 1.20761938e-01f,
  -3.83359171e-03f, 1.20145425e-01f, 1.78655505e-01f, 3.55750252e-03f, 8.05691332e-02f, 9.90582183e-02f, 1.24167755e-01f, 1.02381714e-01f, 1.41629323e-01f, 1.40399098e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.71538389e-01f, -6.62845314e-01f, -1.18306473e-01f, -6.93460405e-01f, -4.85063910e-01f, -1.63886026e-01f, -5.70773065e-01f, -1.34528965e-01f, -3.01898837e-01f, -5.26495576e-01f,
  -7.96713904e-02f, 2.22300097e-01f, 1.54599752e-02f, 2.08169609e-01f, 3.92168045e-01f, -4.47683781e-01f, -3.10844898e-01f, 2.11496547e-01f, 4.36421096e-01f, 4.07064706e-02f,
  -3.53279054e-01f, -3.56428921e-01f, -2.59373020e-02f, -9.07287374e-02f, -5.07719815e-01f, -2.35738650e-01f, -3.73981327e-01f, -3.77996236e-01f, -1.59757912e-01f, -4.45002556e-01f,
  -1.99433297e-01f, -5.38563449e-03f, 2.77922064e-01f, 5.07802255e-02f, -2.82361478e-01f, 1.00956075e-01f, -9.72935334e-02f, 5.42075559e-02f, 1.25583753e-01f, -1.41890913e-01f,
  -2.16901243e-01f, 5.98218068e-02f, 3.12462784e-02f, -8.63936245e-02f, -4.11063433e-01f, -2.00744532e-02f, -1.96492985e-01f, 1.30849943e-01f, 8.52039829e-02f, 6.86754510e-02f,
  -2.15831220e-01f, -7.58926645e-02f, 1.36623144e-01f, 1.43954679e-01f, 2.61649966e-01f, 2.00809270e-01f, -5.90500981e-02f, -2.80041583e-02f, 1.93583488e-01f, -6.77265465e-01f,
  -2.14164779e-01f, -3.52531765e-03f, -1.27369747e-01f, 2.45539807e-02f, 7.51022547e-02f, 2.63934117e-02f, 6.53252080e-02f, -1.01068732e-03f, 3.15260217e-02f, -9.43071581e-03f,
  -3.71155515e-02f, 1.95462033e-02f, 7.70359263e-02f, -1.03801511e-01f, -4.43360507e-02f, -1.53290972e-01f, -5.54325283e-02f, -1.97121184e-02f, 3.20972353e-02f, -6.47386685e-02f,
  1.03922682e-02f, -2.38056295e-03f, 8.73410422e-03f, -2.52542552e-03f, 3.56280580e-02f, 7.29858428e-02f, 4.09740545e-02f, -2.27489006e-02f, -6.75905123e-02f, 5.86842932e-03f,
  -2.04143897e-01f, 4.75666016e-01f, -2.99579084e-01f, 2.56767184e-01f, -1.89383224e-01f, 9.67176631e-02f, -4.42137420e-02f, 2.64626175e-01f, 1.25171289e-01f, -1.72510937e-01f,
  5.67097217e-02f, -8.24195519e-02f, -5.70390038e-02f, -8.30495730e-02f, -2.27160528e-02f, 6.55588275e-03f, -3.20942789e-01f, -1.60236284e-01f, 2.20989436e-01f, -1.01370521e-01f,
  -2.58049279e-01f, -1.03144668e-01f, -3.90193835e-02f, -3.62626873e-02f, -9.71940607e-02f, 1.65371224e-01f, -7.84863010e-02f, -1.63997635e-01f, 2.25012377e-01f, -6.21014118e-01f,
  -4.89804894e-02f, -2.34963506e-01f, 1.13269076e-01f, 1.53163403e-01f, 2.27987021e-01f, 2.46718258e-01f, 3.63774985e-01f, 2.18301460e-01f, 1.61764368e-01f, 1.14629842e-01f,
  5.96566796e-02f, 1.76861331e-01f, 4.57790159e-02f, 9.30818468e-02f, -6.71298057e-02f, 1.15172230e-01f, 1.32071212e-01f, -7.28883445e-02f, -5.99604659e-02f, -5.79229221e-02f,
  -2.05646724e-01f, -1.87113062e-01f, -3.60275835e-01f, -2.34447420e-01f, -6.88756024e-03f, -6.75416142e-02f, 1.39540955e-02f, 5.04120551e-02f, 3.08931209e-02f, -1.67826205e-01f,
  -1.07536756e-01f, 6.51104450e-02f, -8.75823647e-02f, -1.19743995e-01f, -1.37732431e-01f, -9.65757519e-02f, -7.08995610e-02f, -1.40558347e-01f, -7.27361366e-02f, 2.76656225e-02f,
  -9.73991305e-02f, -1.23619549e-01f, -1.04713731e-01f, -2.44726725e-02f, 4.28853594e-02f, -2.22216249e-02f, 1.05751447e-01f, 1.58014104e-01f, 1.45488784e-01f, 1.04337282e-01f,
  1.13156930e-01f, 2.48392954e-01f, 2.92066664e-01f, 1.71532437e-01f, 1.04163982e-01f, 1.09439783e-01f, -5.89484423e-02f, 1.53697476e-01f, 1.20350868e-01f, 1.17176898e-01f,
  7.89953843e-02f, 1.00255631e-01f, 8.10401440e-02f, 1.60764977e-01f, 9.76266190e-02f, -1.89682320e-02f, 8.63453373e-02f, -4.90431972e-02f, -1.65849030e-02f, -4.25325148e-02f,
  -5.70236333e-02f, 1.42963454e-01f, 1.40043840e-01f, -1.61356166e-01f, -7.93785602e-02f, 9.88794342e-02f, -5.81266098e-02f, -7.51528423e-03f, -3.16374488e-02f, 1.10266127e-01f,
  8.20306093e-02f, -2.84252744e-02f, -1.63355172e-01f, -4.73670550e-02f, 8.12443644e-02f, 2.02070791e-02f, 6.50266334e-02f, -4.69319411e-02f, -2.53002122e-02f, -4.02630158e-02f,
  5.00844000e-03f, 1.73327759e-01f, -3.09348647e-02f, 1.03560589e-01f, -3.25871119e-03f, -7.43487924e-02f, 1.92074552e-01f, -1.39357805e-01f, -1.75918713e-01f, -3.76782450e-03f,
  2.32089125e-02f, -6.19715005e-02f, -9.19930264e-03f, 7.55850412e-03f, -7.94044062e-02f, -4.05036584e-02f, 1.09053247e-01f, 1.42381623e-01f, 1.19001538e-01f, -5.28391376e-02f,
  2.58386508e-02f, 1.36272132e-01f, 7.97160119e-02f, 2.82921642e-02f, 5.08055612e-02f, -7.36696497e-02f, -3.72515693e-02f, 6.24109134e-02f, -6.46031797e-02f, -1.13008492e-01f,
  -6.53420746e-01f, 3.47464383e-01f, 4.53168541e-01f, -2.16141701e-01f, 1.92393526e-01f, 8.81834030e-02f, 3.00722960e-02f, -3.43851566e-01f, -2.14352071e-01f, 1.28917754e-01f,
  1.53732777e-01f, -1.80481747e-01f, -6.43704906e-02f, 2.99653430e-02f, -1.68778747e-01f, 2.98777878e-01f, 3.66979629e-01f, -8.49553663e-03f, -4.62788910e-01f, -2.73163885e-01f,
  3.66821364e-02f, -2.97734529e-01f, -2.67479599e-01f, -1.87577680e-01f, 4.89243269e-02f, -7.62793527e-04f, 2.38274530e-01f, 1.38706669e-01f, 3.30671430e-01f, 3.54131073e-01f,
  2.07507268e-01f, 3.35083045e-02f, -1.74870491e-01f, -1.87647820e-01f, 2.67055869e-01f, -1.56213358e-01f, -2.13672996e-01f, 4.18188386e-02f, 3.18899043e-02f, 7.95495287e-02f,
  7.56930113e-02f, 1.19205713e-01f, 1.30088136e-01f, -9.22562089e-03f, -1.91817656e-01f, -2.36167505e-01f, -2.31636196e-01f, -3.99123341e-01f, -2.68438548e-01f, 5.84010594e-02f,
  3.27410519e-01f, 1.13597192e-01f, -4.55823429e-02f, -1.41880751e-01f, -2.35349387e-01f, -2.14564249e-01f, -4.74458113e-02f, -2.19975457e-01f, -1.69117108e-01f, -1.62541330e-01f,
  -1.31617077e-02f, 6.52046055e-02f, 1.52458027e-01f, 5.78507818e-02f, 6.90971240e-02f, 8.61521214e-02f, 8.87873471e-02f, 9.89698991e-02f, 7.09726810e-02f, -8.23785365e-02f,
  -5.94286481e-03f, -1.06881090e-01f, -5.02810627e-02f, 3.95871103e-02f, -8.26185271e-02f, -1.32083490e-01f, 2.67131859e-03f, 5.31704016e-02f, 1.23609789e-01f, -7.78376013e-02f,
  -1.91658437e-02f, 2.05175625e-03f, -1.37241520e-02f, -9.39202607e-02f, 6.02298267e-02f, -5.87025136e-02f, -1.20808497e-01f, -2.09051773e-01f, -1.04012899e-01f, -1.26179215e-02f,
  -3.28903943e-01f, 2.28854313e-01f, -1.23784512e-01f, -9.93024334e-02f, 1.07911676e-01f, 2.15834845e-02f, 2.93264817e-02f, -4.44384739e-02f, 1.50330454e-01f, -2.09599957e-01f,
  -1.12598516e-01f, -1.84772238e-01f, 1.22422285e-01f, -7.87275508e-02f, -3.07804495e-01f, -1.09976619e-01f, 1.20947666e-01f, -1.43184841e-01f, -2.63270348e-01f, -8.67770463e-02f,
  4.69176024e-02f, -3.26948225e-01f, -4.09643501e-01f, -1.07085295e-01f, -1.41043916e-01f, -4.54373449e-01f, -1.80769533e-01f, -2.48667330e-01f, -2.58462042e-01f, -2.71629244e-01f,
  -5.09601057e-01f, -3.23487252e-01f, -2.55450666e-01f, 3.19984734e-01f, 3.24117213e-01f, 1.83891341e-01f, -1.35615498e-01f, -1.76556215e-01f, 1.45826563e-01f, 1.33494854e-01f,
  1.06964707e-01f, 2.23934293e-01f, 1.63427144e-01f, 8.80345032e-02f, -7.88306296e-02f, 1.23233899e-01f, 3.51477116e-01f, -4.61277217e-02f, -1.23704650e-01f, 2.88534760e-01f,
  4.38022465e-01f, 2.74754524e-01f, 3.88446003e-02f, 6.18703440e-02f, 2.79253632e-01f, 2.78439373e-01f, 8.40110332e-02f, 3.09305847e-01f, 1.91172361e-01f, 3.66207629e-01f,
  7.88541883e-02f, -2.07088068e-01f, 1.37143536e-02f, 1.36362195e-01f, 1.13875195e-02f, -1.65639549e-01f, 5.72598577e-02f, -7.27601945e-02f, 1.29503816e-01f, 1.05422199e-01f,
  1.52684480e-01f, -1.40902042e-01f, -1.01947971e-02f, 2.48990115e-02f, -2.58530676e-02f, 1.33303339e-02f, -2.00530633e-01f, -1.26375139e-01f, 5.72899245e-02f, 3.75780165e-02f,
  1.66536182e-01f, 1.94650456e-01f, -2.88411919e-02f, -2.82783713e-03f, -1.00102857e-01f, 1.63450688e-02f, -1.93688184e-01f, -1.11027107e-01f, -1.16892315e-01f, 2.88312044e-02f,
  2.06240997e-01f, 2.07063835e-02f, 5.49252219e-02f, -4.82477173e-02f, -7.11053889e-03f, -1.99669544e-02f, 1.30349368e-01f, 1.50867134e-01f, 4.08821329e-02f, 7.57596549e-03f,
  1.06453344e-01f, 6.12947494e-02f, -3.97533365e-02f, 2.89266184e-02f, 1.50403723e-01f, 9.72707570e-02f, 4.85855080e-02f, -2.44032722e-02f, 9.62890238e-02f, 1.75011083e-01f,
  4.98772003e-02f, -6.61453307e-02f, -5.24848774e-02f, -6.40042918e-03f, -5.16461432e-02f, 5.88791184e-02f, 1.43410340e-01f, 5.61685190e-02f, 6.01701587e-02f, 1.50714993e-01f,
  2.12589905e-01f, -2.02534646e-01f, 9.78869796e-02f, -2.36637816e-02f, 5.68909198e-03f, -1.53215051e-01f, 1.08186878e-01f, -1.46242976e-02f, 1.02003627e-01f, 1.96808010e-01f,
  3.92303150e-03f, -1.26669765e-01f, -1.91086322e-01f, -1.31365597e-01f, -8.01246613e-02f, 7.99704492e-02f, -9.11578973e-05f, 1.72551975e-01f, -4.95043881e-02f, 6.60838783e-02f,
  2.07730737e-02f, 8.84007439e-02f, 9.06368494e-02f, -1.05897762e-01f, 7.35543668e-02f, 8.19155499e-02f, -1.21838003e-01f, -3.18086185e-02f, -1.44432008e-01f, -2.66373660e-02f,
  5.74030280e-01f, -9.63813424e-01f, 8.09851646e-01f, 2.46928409e-01f, 1.68681532e-01f, 8.65345076e-02f, 9.70844645e-03f, 2.63696350e-02f, -1.12209171e-01f, -2.38256633e-01f,
  -7.15332687e-01f, -6.60053670e-01f, -5.04837811e-01f, -3.55909973e-01f, -1.61620732e-02f, 9.10802186e-02f, 4.59048778e-01f, 6.46752000e-01f, 6.69839025e-01f, -1.66005886e-03f,
  -4.87351030e-01f, 3.15115988e-01f, 4.67225045e-01f, 2.91590363e-01f, -2.56782711e-01f, 6.39649332e-02f, 2.40363494e-01f, -7.90696815e-02f, -2.32903421e-01f, 6.37263581e-02f,
  -2.94707110e-03f, -1.37291461e-01f, 2.48403251e-01f, -1.76732525e-01f, -1.86297297e-01f, -8.59450549e-02f, 1.24487475e-01f, 1.70255587e-01f, -1.53855786e-01f, -1.24693764e-02f,
  -4.28891256e-02f, -6.80167302e-02f, -2.34191939e-01f, -1.68167591e-01f, 1.22571923e-02f, 2.13467404e-02f, -7.73109719e-02f, 1.68507010e-01f, 1.16896972e-01f, -7.01872781e-02f,
  -3.50578308e-01f, 2.56773480e-03f, 1.54990777e-01f, 7.80802146e-02f, -3.67219299e-02f, 1.28769279e-01f, -4.96508600e-03f, -1.40270188e-01f, 5.24114780e-02f, -1.10124229e-02f,
  7.87057132e-02f, -6.27651587e-02f, -1.07774243e-01f, 9.79915187e-02f, -1.64738279e-02f, -8.33580643e-02f, -4.61631268e-02f, -1.81267813e-01f, 1.44047409e-01f, 1.75574929e-01f,
  -1.99313164e-02f, 1.37216374e-01f, 1.34689376e-01f, 2.93736514e-02f, -1.25233218e-01f, 8.67082179e-02f, 1.42679095e-01f, -1.64802462e-01f, -2.53909528e-02f, 7.36664906e-02f,
  1.29199075e-02f, 2.59840637e-02f, 3.83203551e-02f, -8.51006284e-02f, -6.32104427e-02f, 6.99830130e-02f, 6.91182092e-02f, -8.71677026e-02f, -3.93731939e-03f, 1.06437784e-02f,
  -6.43303692e-02f, -2.04784006e-01f, 1.21681370e-01f, -1.26111045e-01f, -2.34594420e-02f, -1.26412660e-01f, -1.29070729e-01f, -1.37653753e-01f, -5.54784685e-02f, -1.20568976e-01f,
  -7.95129016e-02f, -1.16984919e-01f, -1.12215802e-01f, 1.33773834e-01f, 1.77118555e-01f, 5.35966828e-02f, -2.79729158e-01f, 2.18590312e-02f, -2.49458272e-02f, -7.79013559e-02f,
  -8.42343420e-02f, 8.00564364e-02f, 3.54026198e-01f, 4.54995874e-03f, -2.18112469e-01f, 1.70659542e-01f, 7.84686506e-02f, 3.31610367e-02f, 8.12729895e-02f, 2.33428270e-01f,
  -2.27374047e-01f, -4.98102725e-01f, -3.19695085e-01f, -7.67877460e-01f, -3.59984338e-01f, 3.29152942e-02f, -1.22635581e-01f, -1.45872936e-01f, -2.53767371e-01f, -4.08533394e-01f,
  -6.64696991e-02f, 1.56589955e-01f, 5.17625511e-02f, 2.81325102e-01f, 4.82335806e-01f, -1.33943021e-01f, -6.06778450e-03f, 2.34474286e-01f, 3.68329644e-01f, 1.37138337e-01f,
  -1.10017106e-01f, -2.83447295e-01f, 1.11198120e-01f, -1.58611551e-01f, -6.93249941e-01f, -1.93751007e-01f, -3.60172302e-01f, -1.39938235e-01f, 1.77637756e-01f, -4.40289855e-01f,
  -4.62770671e-01f, -1.10578455e-01f, 1.19661815e-01f, 1.23199701e-01f, -2.14211985e-01f, 3.89220491e-02f, -2.31820643e-02f, -1.30044475e-01f, 4.07895707e-02f, -2.03564495e-01f,
  -1.57585353e-01f, -3.92843187e-02f, -1.16698556e-01f, -1.83038056e-01f, -2.70922005e-01f, -3.81157100e-02f, -1.85791761e-01f, 1.39025837e-01f, 3.89388315e-02f, 1.61526188e-01f,
  8.76222402e-02f, 1.15886465e-01f, 8.57080668e-02f, 1.87999636e-01f, 8.73801336e-02f, 2.28777200e-01f, -8.43193755e-02f, 1.36562333e-01f, 2.54853159e-01f, -2.31868982e-01f,
  6.79039657e-02f, 1.14154674e-01f, -2.41827983e-02f, -9.68461707e-02f, 6.98592961e-02f, 5.92122413e-02f, -1.25311196e-01f, -1.47000141e-02f, 4.62458208e-02f, -2.76649129e-02f,
  -8.89810249e-02f, 1.48965582e-01f, -1.22788521e-02f, -2.29516681e-02f, 6.31191283e-02f, -9.62832719e-02f, 1.56921342e-01f, 3.20138410e-02f, 4.68226597e-02f, 1.16802320e-01f,
  1.17036216e-01f, 1.17463015e-01f, -4.20231670e-02f, 5.83475567e-02f, 1.72911689e-01f, -1.77966300e-02f, 1.93355754e-02f, 9.14951339e-02f, -5.58029935e-02f, 1.44132763e-01f,
  -4.66822535e-01f, 6.89241469e-01f, -4.08327252e-01f, 1.17818296e-01f, -4.86669205e-02f, 1.18979337e-02f, -3.28159705e-02f, -9.57656372e-03f, -1.51008502e-01f, -1.58211708e-01f,
  6.18796758e-02f, -2.86044888e-02f, -4.72117364e-02f, -5.26908087e-03f, 3.51245590e-02f, 4.56055850e-02f, 8.03852454e-02f, -3.71698625e-02f, 2.15151459e-01f, -6.24027625e-02f,
  7.81463608e-02f, 6.17792606e-02f, 2.50264741e-02f, -2.20691431e-02f, 1.55281544e-01f, 1.42055228e-01f, -4.60425355e-02f, 3.28002162e-02f, 3.45863432e-01f, -3.29564214e-01f,
  -3.56064528e-01f, -2.03801885e-01f, 1.53512686e-01f, -3.28943163e-01f, -4.91712213e-01f, -3.36005658e-01f, -3.67813349e-01f, -3.08057159e-01f, -3.00984561e-01f, -2.63184547e-01f,
  -4.05975401e-01f, -3.70039433e-01f, -2.28101328e-01f, 2.90750027e-01f, 5.04041195e-01f, 2.35526890e-01f, 5.10889173e-01f, 5.72894096e-01f, 4.22010124e-01f, 1.56353056e-01f,
  1.77111626e-01f, 3.13567758e-01f, 4.62418228e-01f, 4.02413815e-01f, -1.16300531e-01f, -1.72769688e-02f, 1.43894970e-01f, 3.64207104e-02f, 2.05332130e-01f, 3.32272679e-01f,
  -2.50336081e-01f, -3.58949304e-01f, -2.82753762e-02f, -1.98488906e-02f, 9.59771723e-02f, 1.33086577e-01f, -3.10672354e-02f, 1.20534688e-01f, -6.52529001e-02f, 1.11579984e-01f,
  -9.96076986e-02f, 1.22152552e-01f, -2.41655946e-01f, 1.69952855e-01f, -1.10679768e-01f, -2.78687924e-01f, 3.69242728e-01f, 2.67907113e-01f, 1.54918984e-01f, 6.72176927e-02f,
  3.08947312e-03f, -8.97599757e-02f, -3.93686563e-01f, -1.18843935e-01f, -3.19680199e-02f, 1.88888550e-01f, -6.64980263e-02f, 1.09922029e-01f, 4.67548817e-02f, -2.30761915e-02f,
  1.59232859e-02f, 1.63246214e-01f, -2.74731144e-02f, -9.16667581e-02f, 9.35023874e-02f, -1.58314127e-02f, 1.22358739e-01f, 5.79364859e-02f, -5.88095821e-02f, -1.96299776e-01f,
  -9.83166993e-02f, 9.04418901e-02f, 9.68641862e-02f, 3.30195799e-02f, -8.55171382e-02f, -1.96934063e-02f, -4.52375179e-03f, 9.69676077e-02f, 9.32521075e-02f, -6.51053190e-02f,
  1.81650533e-03f, 2.26151403e-02f, -5.24488911e-02f, 2.22718924e-01f, -2.61680037e-03f, 1.85516894e-01f, -3.99853326e-02f, 1.93104241e-02f, -1.56337276e-01f, -3.74967009e-02f,
  -4.49531734e-01f, 2.92846352e-01f, -1.80050582e-01f, 1.31563907e-02f, -1.41845703e-01f, -8.61188676e-03f, 1.20443804e-03f, 4.85389791e-02f, -8.32174346e-02f, 9.68306288e-02f,
  -1.16020985e-01f, -2.77901702e-02f, -1.36373147e-01f, 1.34545803e-01f, -7.00817257e-02f, -3.55741024e-01f, 1.03667684e-01f, -2.66491640e-02f, -9.63069126e-02f, -4.54692729e-02f,
  -1.21032424e-01f, -3.44081193e-01f, -5.55320561e-01f, -4.80321944e-01f, -3.89689386e-01f, -3.73208165e-01f, -1.68702543e-01f, -2.49018356e-01f, -3.15572768e-01f, -3.87726098e-01f,
  2.31708631e-01f, -4.17697638e-01f, 2.49512017e-01f, 3.86822075e-01f, 3.89760405e-01f, 4.07564580e-01f, 3.10162634e-01f, 2.53744632e-01f, 2.85075665e-01f, 9.05773118e-02f,
  -1.54266907e-02f, 7.20250830e-02f, 1.02316089e-01f, 1.22476347e-01f, -9.81639698e-03f, 2.48330906e-01f, 2.97154874e-01f, 1.89196393e-01f, 3.41039032e-01f, 2.23871648e-01f,
  1.30316868e-01f, 1.14200234e-01f, 1.54566318e-02f, 2.64148433e-02f, 9.78741050e-02f, 1.81420177e-01f, -1.26047209e-02f, -2.22981889e-02f, -1.16084889e-01f, -9.78346765e-02f,
  -1.56982914e-01f, -2.03745216e-01f, 2.13567242e-01f, -1.72153234e-01f, -1.90782323e-01f, -2.31827438e-01f, -5.42037450e-02f, -1.11047283e-01f, -1.37604043e-01f, -1.06908217e-01f,
  -1.44816190e-01f, -1.43759280e-01f, -1.83021706e-02f, -8.93512592e-02f, -1.27014503e-01f, -5.28713167e-02f, -1.95159391e-01f, -5.93824498e-02f, 1.17856497e-02f, -2.44320929e-01f,
  -2.04520762e-01f, -2.28573214e-02f, -3.41716558e-02f, 7.48950010e-03f, 8.42426792e-02f, 1.30591437e-01f, 1.87475197e-02f, -4.02236097e-02f, -7.39335641e-02f, -8.30483362e-02f,
  3.75127554e-01f, 9.14342403e-02f, 2.33330101e-01f, 9.30853635e-02f, 1.64201602e-01f, 1.06507845e-01f, -3.16463187e-02f, -1.36303492e-02f, 1.56420782e-01f, 1.40952999e-02f,
  -8.45115930e-02f, 9.13658664e-02f, -3.74869257e-02f, 2.80901901e-02f, 6.57983795e-02f, -6.99479803e-02f, -1.23146802e-01f, -1.99240550e-01f, 1.06203370e-01f, 1.10481223e-02f,
  1.41106740e-01f, -6.90230587e-03f, -2.69021932e-02f, -4.11124714e-02f, -3.13251428e-02f, 1.02070227e-01f, 1.09898105e-01f, -1.94380522e-01f, -4.21103649e-02f, 2.12482065e-02f,
  -1.63060471e-01f, 6.52272180e-02f, 1.02655515e-01f, -3.03482246e-02f, -9.78054032e-02f, -8.10696110e-02f, 6.67260662e-02f, -1.07790850e-01f, -7.22393021e-02f, -7.16821030e-02f,
  -6.28324598e-02f, -1.32552519e-01f, -1.42079130e-01f, -2.43222853e-03f, 6.65448746e-03f, 1.13712244e-01f, 2.09596995e-02f, 8.77892077e-02f, -1.44623239e-02f, -6.34100363e-02f,
  -7.02388212e-02f, -3.74961644e-02f, 3.58893932e-03f, 2.98398398e-02f, -8.43248703e-03f, 1.48559779e-01f, 1.44479930e-01f, 5.33128455e-02f, 1.10552296e-01f, 9.77258831e-02f,
  7.33175993e-01f, 2.11752608e-01f, 3.62614065e-01f, 1.97662950e-01f, 2.30207741e-01f, 2.71280110e-01f, 3.07369590e-01f, 2.57653654e-01f, 1.07508905e-01f, 1.88631460e-01f,
  1.44013613e-01f, 3.64187434e-02f, 1.43991008e-01f, 9.48108360e-02f, 2.60584831e-01f, 1.44755736e-01f, 6.61124708e-03f, 1.41158760e-01f, 2.62677401e-01f, 1.22619845e-01f,
  -1.68748632e-01f, 3.96824554e-02f, 7.48701021e-02f, -2.21018270e-02f, -9.32715386e-02f, -1.15219645e-01f, 8.02977532e-02f, 5.88218216e-03f, 8.65419060e-02f, -1.26855209e-01f,
  -2.25765660e-01f, 2.61043310e-01f, -3.80972773e-02f, -1.02983288e-01f, 6.20483086e-02f, -4.43775579e-02f, -1.95684675e-02f, -9.71241072e-02f, -1.95968807e-01f, -1.05922937e-01f,
  -1.19884863e-01f, -4.85275611e-02f, 1.50870353e-01f, 1.04579002e-01f, -1.81112275e-03f, -1.14530325e-01f, 5.26921339e-02f, 1.33197695e-01f, -1.90433208e-02f, -5.57145290e-03f,
  -7.55326226e-02f, 4.43536006e-02f, 1.30205646e-01f, -9.27657541e-03f, 4.12462801e-02f, 5.20615168e-02f, 6.08512945e-02f, 9.58821550e-02f, 1.30839884e-01f, 4.40759771e-02f,
  -8.11982807e-03f, 1.44612849e-01f, 1.03565022e-01f, 1.89631447e-01f, 1.86881721e-02f, 4.86659966e-02f, -5.47051691e-02f, 6.18777275e-02f, 2.15996820e-02f, 9.98550802e-02f,
  -3.64024891e-03f, 1.01142541e-01f, 1.83390349e-01f, -3.06330825e-04f, -8.18905607e-02f, 5.28376177e-02f, 3.71503457e-02f, -3.32231708e-02f, 1.05217688e-01f, 2.39409413e-02f,
  9.86497626e-02f, -6.78738132e-02f, -8.92207623e-02f, 9.77363959e-02f, -8.64420906e-02f, 5.41192852e-02f, -7.54896104e-02f, -1.10083774e-01f, -6.86632469e-02f, -1.37539461e-01f,
  -3.22291821e-01f, 2.51794726e-01f, -9.68063772e-02f, -3.02965585e-02f, 4.12184037e-02f, -5.21897618e-03f, 9.60836187e-02f, -8.36861283e-02f, -1.16599135e-01f, -1.88188687e-01f,
  -1.19106121e-01f, -2.29224600e-02f, 6.71173409e-02f, -9.02142972e-02f, 3.51695418e-02f, -1.06347308e-01f, -5.55926114e-02f, 5.94418347e-02f, 2.11784337e-02f, -4.82863635e-02f,
  -1.35347351e-01f, 4.00249325e-02f, 5.54640703e-02f, 3.89987640e-02f, -5.01676127e-02f, 4.28019427e-02f, -3.78313139e-02f, -7.74675310e-02f, 8.52627121e-03f, -1.13826305e-01f,
  6.09298050e-01f, -3.40184003e-01f, 1.40542358e-01f, 1.70713410e-01f, -2.46972024e-01f, -4.27128643e-01f, -6.20309770e-01f, -3.48918259e-01f, -2.76710726e-02f, -7.72135034e-02f,
  7.21647218e-02f, 5.18711925e-01f, 8.36340785e-01f, 2.91418314e-01f, 1.90890595e-01f, -8.16267282e-02f, 1.39589593e-01f, 4.19899642e-01f, -9.66228172e-02f, -5.13958156e-01f,
  -4.09673750e-01f, -4.94687930e-02f, 6.03560545e-02f, -7.36783594e-02f, -1.12965912e-01f, 9.71988067e-02f, 6.35986924e-02f, -7.76837990e-02f, -1.32029861e-01f, 6.91820607e-02f,
  4.10716951e-01f, -2.52395958e-01f, 3.41476277e-02f, -5.06188460e-02f, 9.24738683e-03f, -6.09523207e-02f, -7.97453374e-02f, -1.26788139e-01f, -2.33337283e-02f, -4.33998033e-02f,
  -9.57042724e-02f, -9.93560553e-02f, -9.54391211e-02f, -1.27502099e-01f, -2.15803698e-01f, -1.30692095e-01f, -1.21298492e-01f, -2.54405737e-02f, -9.69720855e-02f, -1.44490615e-01f,
  -1.56356603e-01f, -2.30107501e-01f, 3.43930200e-02f, -1.12851873e-01f, -6.60593808e-03f, 1.74359366e-01f, -5.34819700e-02f, -1.96335271e-01f, -1.08778216e-01f, -2.62923297e-02f,
  -2.30300784e-01f, 4.02191877e-02f, -1.33471424e-02f, -4.30520624e-02f, -1.66360307e-02f, 3.53004001e-02f, -2.99482327e-02f, -9.84236225e-02f, -1.10089602e-02f, -7.35430196e-02f,
  -3.07555664e-02f, 4.22709584e-02f, 2.52817199e-03f, -1.21597685e-02f, -3.18215080e-02f, -1.06743440e-01f, -1.20405667e-01f, -5.50737642e-02f, 2.85357540e-03f, -1.83197074e-02f,
  5.88841401e-02f, -5.71140572e-02f, 2.92357504e-02f, -6.89581688e-03f, 4.88770604e-02f, 1.02383785e-01f, -2.88195945e-02f, -7.22647235e-02f, 3.12608480e-02f, -9.92828794e-03f,
  2.22251937e-01f, 1.29363924e-01f, 2.41930366e-01f, -3.72305252e-02f, -1.87969338e-02f, -5.24174087e-02f, -5.05215228e-02f, -2.31893416e-02f, 1.59172043e-01f, 1.90551660e-03f,
  -1.56031519e-01f, -4.98466147e-03f, 4.89992574e-02f, -3.59407440e-02f, -9.78288576e-02f, -7.38208815e-02f, 2.19276380e-02f, 1.15528539e-01f, -8.90766308e-02f, -1.36138290e-01f,
  -1.94830850e-01f, -1.85423661e-02f, 2.54583299e-01f, 1.97185189e-01f, -9.34763551e-02f, 2.39479974e-01f, 2.47266605e-01f, 2.96058115e-02f, 1.97241738e-01f, -8.76596663e-03f,
  3.62641454e-01f, -2.10053399e-01f, -1.33205950e-01f, 2.15219513e-01f, 1.13513380e-01f, 3.47483456e-02f, -3.34505178e-02f, -2.93461140e-02f, 1.78950652e-01f, -4.67636250e-02f,
  -2.88124949e-01f, -2.59634405e-01f, -2.71708369e-01f, -3.16553861e-01f, -2.71109492e-01f, 1.82738781e-01f, 2.30561882e-01f, 2.27896608e-02f, 1.17264129e-02f, 1.50672182e-01f,
  1.77473515e-01f, 2.63804078e-01f, 6.15218021e-02f, -4.48162146e-02f, 9.14329663e-02f, 4.88351611e-03f, -1.38005917e-03f, -6.04373636e-04f, 2.43580509e-02f, 1.21010080e-01f,
  -2.57542998e-01f, -2.60517269e-01f, -5.52322604e-02f, -5.95627874e-02f, -8.34545419e-02f, -1.11688018e-01f, -6.93173483e-02f, -9.70878676e-02f, 2.21015769e-03f, 1.16308965e-01f,
  -9.83976573e-02f, -1.26790255e-01f, -4.42271605e-02f, 2.48652548e-02f, -3.16299126e-02f, -1.68880075e-02f, -1.01997077e-01f, -1.47906214e-01f, -1.24494798e-01f, -8.82307589e-02f,
  -9.04940814e-02f, -8.74211192e-02f, -2.81577930e-02f, 2.40604579e-03f, -1.52791575e-01f, -2.08661687e-02f, -1.82630122e-01f, -2.04617139e-02f, -3.39290835e-02f, -9.69774462e-03f,
  6.22942159e-03f, -9.42521840e-02f, -1.63235068e-01f, -6.93094432e-02f, 5.88196330e-02f, 2.93626245e-02f, 1.10392720e-01f, 6.07243776e-02f, -1.69171914e-02f, 2.23599821e-02f,
  1.09556459e-01f, -6.61219005e-03f, 6.08642772e-02f, 2.11507678e-02f, -1.79300234e-02f, -5.56513332e-02f, 8.91265869e-02f, -6.34666160e-02f, -7.11478814e-02f, -4.20551151e-02f,
  -9.54830181e-03f, 1.21791743e-01f, 1.61858406e-02f, 6.60725236e-02f, -5.47206029e-02f, 5.75821884e-02f, 1.28176361e-01f, -4.77775326e-03f, -5.00637107e-02f, 8.02177265e-02f,
  2.89633930e-01f, -2.94286817e-01f, 1.03318967e-01f, -6.52624071e-02f, 5.49599081e-02f, -7.67556801e-02f, -5.70491850e-02f, -4.66011278e-02f, -5.38638560e-03f, -1.31285787e-02f,
  -1.13622241e-01f, 5.35475351e-02f, -7.90627450e-02f, 6.52078763e-02f, 1.61525130e-01f, 2.73161046e-02f, -1.95014067e-02f, -3.46743241e-02f, -5.13269603e-02f, 8.66838265e-03f,
  9.74693596e-02f, 2.17462882e-01f, 1.59010485e-01f, 8.05766582e-02f, 6.04347438e-02f, 1.26433462e-01f, 5.91731817e-03f, 1.52193710e-01f, 5.16790338e-02f, 3.69431943e-01f,
  -3.09980392e-01f, -1.68381557e-01f, -1.22571804e-01f, -4.63966846e-01f, -1.98579937e-01f, 3.32755893e-02f, -1.51602998e-01f, -4.53875996e-02f, 7.71283209e-02f, -1.31935775e-01f,
  1.00834668e-01f, -1.29988223e-01f, -2.44854793e-01f, -6.11654185e-02f, 2.21227501e-02f, -1.63849398e-01f, -3.40309173e-01f, -1.53098539e-01f, 6.34863004e-02f, 2.03202531e-01f,
  8.67614225e-02f, -1.38039440e-01f, -3.11126616e-02f, -8.85310397e-02f, -3.07761014e-01f, -3.37585628e-01f, -2.67695010e-01f, -3.85372579e-01f, -1.60522535e-01f, -5.10195315e-01f,
  -1.78946123e-01f, -1.42442554e-01f, 2.93224543e-01f, 7.75636882e-02f, 5.85763268e-02f, 1.87328726e-01f, -1.57673154e-02f, -6.62555322e-02f, 8.87258723e-02f, -4.51199571e-03f,
  -2.84166217e-01f, 1.15459651e-01f, -1.34815380e-01f, 9.29458439e-02f, -2.71146726e-02f, 6.84059858e-02f, 6.71161637e-02f, 9.31557938e-02f, 9.38436482e-03f, 1.57067537e-01f,
  -1.35865703e-01f, -2.03211963e-01f, -3.63914758e-01f, 2.66975202e-02f, 2.53143072e-01f, -1.94925472e-01f, -4.90162149e-02f, -1.27836429e-02f, 1.96970291e-02f, -3.86080533e-01f,
  1.48519203e-01f, 5.97593002e-02f, 2.44827211e-01f, 5.44476695e-02f, 1.02190048e-01f, 7.36067891e-02f, -1.95773065e-01f, -4.99237143e-02f, 6.45254999e-02f, -1.03423335e-01f,
  -1.67014431e-02f, 2.94921882e-02f, -1.13281474e-01f, -1.22290865e-01f, -2.45521173e-01f, -2.88034286e-02f, -1.90643743e-01f, 6.45402912e-03f, -1.42256171e-01f, 2.58219335e-02f,
  -9.13316086e-02f, -9.97212529e-02f, -7.06518861e-03f, 7.72867054e-02f, 1.56571060e-01f, -4.65982966e-02f, 2.62733325e-02f, 4.71256487e-02f, -6.31340146e-02f, -2.98733823e-02f,
  -1.57603174e-01f, 3.66824090e-01f, -3.59423757e-01f, -1.17878407e-01f, -5.10459840e-02f, 1.40468374e-01f, -4.96740676e-02f, 2.27877736e-01f, -1.30559191e-01f, 9.87114608e-02f,
  9.37839523e-02f, -1.55049860e-01f, -1.39239609e-01f, 8.76247287e-02f, 1.07928351e-01f, -9.46309883e-03f, -2.80493572e-02f, -1.99595332e-01f, 6.42063096e-02f, -3.86317410e-02f,
  -8.00378900e-03f, -3.79511565e-01f, -5.27639568e-01f, -3.40227485e-01f, -1.09631360e-01f, -4.46915060e-01f, -3.15279275e-01f, -2.03674406e-01f, -3.20727795e-01f, -4.58870441e-01f,
  9.00363445e-01f, 6.32321611e-02f, 2.38666739e-02f, 1.24870539e-01f, 5.81391118e-02f, 2.23356068e-01f, 2.73349315e-01f, 1.38512328e-01f, 1.94814485e-02f, 1.03026874e-01f,
  -1.26705216e-02f, -1.71699882e-01f, -1.31846026e-01f, -1.93312347e-01f, 1.69516146e-01f, -1.58246048e-02f, 4.30473313e-02f, 1.70756772e-01f, 1.25860244e-01f, 6.84716627e-02f,
  -1.26657903e-03f, 3.18457693e-01f, 3.15189183e-01f, 6.06289543e-02f, -3.04690748e-01f, -1.07630767e-01f, 6.30902275e-02f, -9.84432083e-03f, -1.29136935e-01f, -4.56697077e-01f,
  -4.64089632e-01f, 1.00734681e-01f, -9.00160074e-02f, -1.09893270e-01f, -3.83618288e-02f, 2.82621831e-02f, -6.48560897e-02f, -1.21164061e-01f, -1.46375047e-02f, 5.44735566e-02f,
  -7.74620622e-02f, -1.56085446e-01f, -8.85097533e-02f, -9.73477662e-02f, -3.42760235e-02f, -4.78777997e-02f, 2.31037270e-02f, -9.11020711e-02f, -8.40431973e-02f, -1.47948772e-01f,
  -2.70782471e-01f, -7.21301809e-02f, 3.97625491e-02f, 8.92978720e-03f, 8.33821818e-02f, 3.05520985e-02f, 4.08233665e-02f, -1.19010415e-02f, 8.22970644e-02f, 1.45111873e-03f,
  -3.46133292e-01f, 1.28298691e-02f, -5.46617396e-02f, 1.71256177e-02f, 1.10880539e-01f, 1.38269002e-02f, 2.09418056e-03f, 4.96464819e-02f, 3.83655652e-02f, 9.06193927e-02f,
  -7.36247152e-02f, -1.45275712e-01f, -1.83268607e-01f, 3.83996740e-02f, -1.29780456e-01f, -1.94594532e-01f, 6.78506941e-02f, -9.89078656e-02f, -4.40913364e-02f, -5.20262904e-02f,
  -4.96689901e-02f, 7.35793337e-02f, 9.17475484e-03f, -1.87498689e-01f, -1.15998060e-01f, -7.83600807e-02f, -6.62366077e-02f, -1.18796118e-01f, 5.61465099e-02f, -2.12184270e-03f,
  -3.30925792e-01f, -2.44927518e-02f, -7.97363520e-02f, -5.07094935e-02f, 6.63682595e-02f, -5.91943832e-03f, -1.02905884e-01f, -9.09062326e-02f, -4.27523963e-02f, -4.65200283e-03f,
  4.31023352e-02f, -2.84505337e-02f, -1.30930785e-02f, -1.38532221e-01f, 7.48051032e-02f, 7.06366971e-02f, 8.59809294e-02f, -8.10548216e-02f, -1.65263340e-01f, -2.04167128e-01f,
  5.65225855e-02f, 1.38253167e-01f, 2.20700741e-01f, 9.57029536e-02f, 4.84215282e-02f, 1.44480184e-01f, 9.82384477e-03f, 8.18369091e-02f, 1.81482822e-01f, 4.19718176e-01f,
  -6.22308493e-01f, -1.90722167e-01f, 6.24586269e-02f, 1.16409153e-01f, 2.50415444e-01f, 1.16949655e-01f, 1.49117470e-01f, -4.83663604e-02f, 9.28864330e-02f, 3.64007428e-02f,
  -3.87100987e-02f, 5.71088269e-02f, 1.20492458e-01f, 8.88439715e-02f, -2.89857071e-02f, 3.34331363e-01f, 2.43389070e-01f, 1.17658719e-01f, 1.98241733e-02f, 2.06425548e-01f,
  2.39289612e-01f, 7.09032267e-02f, -1.69520736e-01f, -1.16959378e-01f, 1.28096133e-01f, 2.56575167e-01f, -9.57870763e-03f, 6.75944164e-02f, 6.69993609e-02f, 2.19211951e-01f,
  4.07009542e-01f, -2.51893252e-01f, 1.85675517e-01f, -2.12081313e-01f, -1.34526744e-01f, -1.84568390e-01f, -6.52564317e-02f, -1.79589882e-01f, -2.22400174e-01f, 6.98875114e-02f,
  -1.14405490e-01f, -8.74722600e-02f, -6.70609847e-02f, -1.11548737e-01f, -5.15799262e-02f, -1.95431888e-01f, -1.81565061e-01f, -1.91667959e-01f, -4.51014377e-02f, -1.05440710e-02f,
  -1.02026656e-01f, -4.13392531e-03f, 6.23345412e-02f, -4.98693399e-02f, 8.05020779e-02f, -1.15540093e-02f, -2.23348483e-01f, -8.77551660e-02f, -7.79368728e-02f, -1.55367061e-01f,
  1.51771645e-03f, -7.28746057e-02f, 3.76830772e-02f, -9.65621322e-02f, -5.99333420e-02f, 5.28437383e-02f, 4.24354617e-03f, 6.38733208e-02f, -9.09060519e-03f, 7.56138936e-02f,
  4.33607437e-02f, 9.28797647e-02f, -1.25511708e-02f, 4.35019471e-02f, 3.16100963e-03f, -5.67553155e-02f, 7.98049476e-03f, -2.84151938e-02f, 1.81177780e-02f, -7.45354593e-02f,
  1.20947629e-01f, -2.24305894e-02f, -1.12871081e-01f, -8.74467846e-03f, -8.77695829e-02f, -4.23405357e-02f, 1.12214282e-01f, -8.01636130e-02f, -1.13547340e-01f, -6.54650629e-02f,
  3.88748080e-01f, -1.09138982e-02f, 3.29669505e-01f, 1.24191925e-01f, 1.12497304e-02f, -1.67139947e-01f, -7.96431024e-03f, -9.50402692e-02f, -1.44833466e-02f, 7.49828666e-02f,
  -3.88349742e-02f, -2.45545665e-03f, 8.59158300e-03f, 2.12539490e-02f, 1.86260063e-02f, -4.69672419e-02f, -1.22219585e-01f, -4.42523472e-02f, 1.12090774e-01f, -5.79335541e-02f,
  -5.65533675e-02f, 9.20394808e-02f, 2.73402691e-01f, 1.93491682e-01f, 2.08535701e-01f, 1.55202776e-01f, 1.48277849e-01f, 6.36465698e-02f, 1.34945318e-01f, 2.14748815e-01f,
  6.98509991e-01f, 2.55661517e-01f, -7.23631501e-01f, 4.46703106e-01f, -1.00550897e-01f, -4.56119448e-01f, -3.25793207e-01f, -5.72594292e-02f, 4.02260602e-01f, -1.34610720e-02f,
  9.18133631e-02f, 1.35127500e-01f, 4.94808368e-02f, -3.10711652e-01f, -4.23860610e-01f, -4.79849994e-01f, -5.07936537e-01f, -5.01203895e-01f, -5.31580627e-01f, -3.43780518e-01f,
  -1.51107028e-01f, -4.07321267e-02f, -1.95328500e-02f, -1.73161581e-01f, 7.66024143e-02f, -9.64704454e-02f, -1.38880625e-01f, -1.97681576e-01f, -3.78847867e-01f, -2.42568523e-01f,
  -5.57901025e-01f, -2.26382054e-02f, -1.59058720e-01f, 9.45938155e-02f, -3.65171232e-03f, 1.75496548e-01f, 3.46532539e-02f, 1.57826990e-01f, 3.29849064e-01f, 6.93440065e-02f,
  2.89256331e-02f, 2.41219066e-02f, 9.39546004e-02f, 2.64529586e-02f, -9.29222559e-04f, -2.65713111e-02f, 3.09782941e-02f, 1.14131995e-01f, 1.14290334e-01f, 3.62170376e-02f,
  -3.77798080e-02f, 7.76493922e-02f, 3.49492915e-02f, 1.34026587e-01f, -3.34106460e-02f, 4.60495614e-02f, -6.48488058e-03f, 7.05320314e-02f, -2.01170400e-01f, 2.19406977e-01f,
  -3.12108159e-01f, 6.41304031e-02f, -2.90094446e-02f, 1.19276561e-01f, 7.92820305e-02f, 1.03662804e-01f, 2.39132363e-02f, -1.05198324e-02f, -1.17343096e-02f, 7.44054019e-02f,
  1.27088144e-01f, -4.44776379e-02f, 1.53921684e-02f, 1.29389331e-01f, -9.03226286e-02f, -1.45342387e-02f, 1.04735084e-02f, -5.59581332e-02f, -3.64709273e-02f, 5.94670735e-02f,
  1.52086228e-01f, 4.86313086e-03f, 1.30458146e-01f, -2.31099725e-02f, -7.51516968e-02f, 4.00544377e-03f, 3.42234373e-02f, -6.42232317e-03f, -4.65290360e-02f, 1.05177192e-02f,
  3.23196620e-01f, -2.53744632e-01f, 1.50230259e-01f, 1.99950431e-02f, 1.16288010e-02f, 1.20235141e-02f, 7.17287436e-02f, 1.81126278e-02f, 1.70003951e-01f, -4.83350605e-02f,
  -1.30397126e-01f, -9.50444713e-02f, 2.26384494e-02f, 6.48825690e-02f, -1.07003383e-01f, -4.96536940e-02f, 1.38510585e-01f, 1.06503069e-01f, -1.21493883e-01f, 1.82486176e-02f,
  1.06927000e-01f, 4.43599746e-02f, 2.79919475e-01f, 1.75818726e-02f, -1.38480461e-03f, 1.00209555e-02f, -8.74028057e-02f, -9.81725901e-02f, -8.18907470e-02f, 1.64388120e-01f,
  -5.33683300e-01f, 5.14933169e-01f, -5.17634451e-01f, -3.85648191e-01f, -4.69108969e-01f, -3.12135369e-01f, 4.74115700e-01f, 2.99322486e-01f, -1.06349498e-01f, 4.84872192e-01f,
  1.92947313e-01f, -3.53263408e-01f, -3.11014891e-01f, -1.97147648e-03f, -8.95728692e-02f, 3.98537755e-01f, -2.60288268e-01f, -5.67342937e-01f, -4.34909582e-01f, 6.60932809e-02f,
  2.37507820e-01f, -2.08737046e-01f, -3.28282803e-01f, -1.33949190e-01f, -8.41529816e-02f, -4.10823196e-01f, -1.20430782e-01f, -3.24675590e-01f, -2.04925716e-01f, -2.86926538e-01f,
  4.06276762e-01f, -3.54465365e-01f, -1.24817550e-01f, -3.17564130e-01f, -3.66372219e-03f, -4.99776118e-02f, 1.02200739e-01f, -2.67080098e-01f, -1.06902815e-01f, 1.47226766e-01f,
  -2.20496312e-01f, -1.44670442e-01f, -1.45709917e-01f, -5.97655512e-02f, -1.12541862e-01f, 7.16254488e-02f, 4.18400019e-02f, -2.58135527e-01f, -3.76997292e-02f, 3.36356640e-01f,
  2.53404558e-01f, -1.84645638e-01f, -9.01664719e-02f, 1.95033222e-01f, 1.33874521e-01f, -2.59368062e-01f, 1.54967919e-01f, -1.83490306e-01f, -2.07696870e-01f, 2.96708435e-01f,
  1.78211749e-01f, -3.41225266e-02f, -2.54760832e-02f, 1.96286604e-01f, 2.52426863e-01f, -2.34870277e-02f, -8.22324529e-02f, 3.01597565e-02f, 4.24011052e-02f, 1.85086846e-01f,
  1.18349329e-01f, 2.74570286e-01f, 8.67914502e-03f, -4.25979681e-03f, -7.93571118e-03f, -1.04203306e-01f, -1.30108446e-02f, 2.65400678e-01f, 5.11954650e-02f, -7.43532628e-02f,
  -1.38421863e-01f, -1.66078597e-01f, -9.25333127e-02f, 8.09235796e-02f, -9.45233628e-02f, -6.86391592e-02f, 8.45039356e-03f, 2.10175607e-02f, -5.52511588e-03f, -1.18831538e-01f,
  3.94525796e-01f, -1.95568800e-01f, 2.35833943e-01f, -2.06649363e-01f, -6.44992962e-02f, 1.03642372e-02f, -9.54938307e-02f, 1.90057997e-02f, -1.30494133e-01f, -1.66521873e-02f,
  -1.14143342e-01f, -4.46495367e-03f, -2.30847970e-02f, 2.25901473e-02f, -1.30804658e-01f, -2.82593407e-02f, 1.44405484e-01f, -1.31414801e-01f, -6.42671138e-02f, 4.25671563e-02f,
  2.47162938e-01f, 4.84577194e-02f, 6.70582280e-02f, 8.40055868e-02f, 2.28005853e-02f, -1.90908059e-01f, 1.84401676e-01f, 1.16110012e-01f, -4.31754105e-02f, 5.92719197e-01f,
  3.89927328e-01f, -2.82003105e-01f, -3.53838831e-01f, -1.14403795e-02f, -1.99697599e-01f, 1.08411033e-02f, 3.34744751e-02f, 1.64405212e-01f, 1.37419447e-01f, -1.06295511e-01f,
  9.93913636e-02f, 4.40469444e-01f, 2.60595620e-01f, 1.55448601e-01f, 1.61292955e-01f, -2.44592622e-01f, -3.17371905e-01f, 1.23520859e-01f, 4.02093321e-01f, 1.05050571e-01f,
  -2.31396016e-02f, -4.97669131e-02f, 5.79977594e-02f, 2.70951353e-03f, -1.78765863e-01f, 1.37201995e-01f, -3.11868936e-01f, -2.66556352e-01f, -3.07475060e-01f, -5.59375882e-01f,
  3.66901904e-01f, -3.83335114e-01f, 9.68639478e-02f, -5.17337993e-02f, -2.28249237e-01f, -1.89334955e-02f, 1.56454071e-02f, -1.56543776e-01f, -1.53586745e-01f, -1.24765567e-01f,
  -2.11901709e-01f, -2.59643383e-02f, -1.73261762e-02f, 1.50336127e-04f, -1.86071005e-02f, 2.56290380e-02f, -8.84751603e-02f, -1.20934239e-02f, -3.23758721e-02f, -1.08645372e-02f,
  -1.24304697e-01f, -2.10104138e-01f, -1.30647674e-01f, 1.32796401e-02f, -6.71349093e-02f, 6.39052987e-02f, -1.08960733e-01f, -9.95679051e-02f, -5.76255508e-02f, -1.17169522e-01f,
  -5.39028458e-02f, 9.20533389e-02f, 1.01319522e-01f, 1.34048432e-01f, 8.44922438e-02f, 2.13870313e-02f, 6.07398823e-02f, 7.79478773e-02f, 4.12388965e-02f, -1.90843530e-02f,
  4.54411283e-02f, 1.19617404e-02f, 1.01465108e-02f, 2.98830634e-03f, 8.05193000e-03f, -1.30793408e-01f, -1.25709847e-01f, 4.08989862e-02f, -1.24129327e-02f, -1.20160557e-01f,
  5.48149124e-02f, 5.83899394e-03f, -1.31818503e-01f, 1.04906715e-01f, -1.06784523e-01f, -5.06741963e-02f, 3.29360478e-02f, 9.04985145e-02f, 1.54534087e-01f, -1.38172448e-01f,
  4.18376356e-01f, -6.70097321e-02f, 1.50398448e-01f, -3.56661379e-02f, -2.25368053e-01f, -7.38617927e-02f, 1.10006638e-01f, -1.84022725e-01f, -1.23073451e-01f, -6.46593720e-02f,
  -1.23563074e-01f, 3.20332386e-02f, 6.57725856e-02f, 4.82876189e-02f, 4.42743711e-02f, 7.73096690e-03f, 1.44194430e-02f, 5.15473671e-02f, -4.27964255e-02f, -3.56273763e-02f,
  -6.89195618e-02f, -3.84388980e-03f, 1.76872149e-01f, 2.37804607e-01f, -1.71618443e-02f, 3.19584340e-01f, 7.86117837e-02f, 7.68198371e-02f, 2.20097542e-01f, 2.54411280e-01f,
  -6.17820144e-01f, 4.97334480e-01f, 5.17670572e-01f, -2.02051371e-01f, 4.36556965e-01f, 3.64722610e-01f, 3.53638858e-01f, 5.18070832e-02f, 7.02082552e-03f, 2.22276017e-01f,
  3.00240278e-01f, -1.26554295e-01f, -1.11367971e-01f, -3.58078897e-01f, -5.77636719e-01f, 6.65899590e-02f, 7.22030103e-02f, -4.64285731e-01f, -5.67540944e-01f, -4.72294718e-01f,
  -1.75778016e-01f, -4.15908456e-01f, -6.02303922e-01f, -3.55846941e-01f, 2.50416934e-01f, -2.03552872e-01f, 2.94377059e-01f, -7.62017444e-02f, 3.81605700e-02f, 1.08951829e-01f,
  -4.82492931e-02f, 4.09869611e-01f, -1.72472432e-01f, -6.46877736e-02f, 8.29670727e-02f, -2.75241971e-01f, -5.17386049e-02f, 3.88273932e-02f, 2.25123819e-02f, 3.73225734e-02f,
  1.48388326e-01f, 5.93270920e-02f, 7.63811842e-02f, -6.15289761e-03f, -9.61912051e-02f, -1.77945644e-01f, -8.38647634e-02f, -3.19484651e-01f, -1.15834311e-01f, 1.41660765e-01f,
  -2.27718689e-02f, 1.65615425e-01f, 9.43044275e-02f, 1.00850165e-01f, -4.00375687e-02f, -1.88714385e-01f, -2.18366776e-02f, -1.70620084e-01f, -1.43473297e-01f, -3.76051933e-01f,
  -1.15750022e-01f, -7.42734596e-02f, -8.44558999e-02f, 1.12308599e-01f, -2.14340806e-01f, 1.22854732e-01f, -5.93329705e-02f, -1.57188863e-01f, -5.95190637e-02f, -1.49326488e-01f,
  -4.33238223e-02f, 3.84197421e-02f, -6.81630475e-03f, 9.70898196e-02f, -1.72912091e-01f, 5.07230535e-02f, -1.21141654e-02f, -9.12988037e-02f, -5.61209815e-03f, -4.94922139e-02f,
  -1.15013964e-01f, 2.42117234e-02f, -6.32679742e-03f, -1.78982750e-01f, 8.20128620e-02f, 1.31954148e-01f, 3.85930277e-02f, -4.80799451e-02f, 1.83876306e-02f, 1.08045809e-01f,
  -3.31830680e-01f, -1.72478363e-01f, -9.63034928e-02f, -2.06353024e-01f, 9.25429761e-02f, -5.62022030e-02f, 7.25263581e-02f, -1.23833649e-01f, 6.58633709e-02f, -9.14733633e-02f,
  8.51061046e-02f, -7.62044117e-02f, 7.28492439e-02f, -7.05752000e-02f, -2.42396414e-01f, 3.83432605e-03f, -2.06225723e-01f, -1.11220460e-02f, -1.24728881e-01f, 1.20179869e-01f,
  -2.15494007e-01f, -4.23958570e-01f, -5.07306576e-01f, -1.86305508e-01f, -1.60331741e-01f, -4.71811235e-01f, -3.73367399e-01f, -3.43028247e-01f, -5.02406538e-01f, -5.48847735e-01f,
  2.09739015e-01f, 3.58570069e-01f, 2.47859642e-01f, -1.27866507e-01f, -2.12163538e-01f, 3.19381990e-02f, 3.42349708e-01f, 1.61550380e-02f, -1.88026592e-01f, 2.09211051e-01f,
  -3.55645642e-02f, -1.63692489e-01f, 3.25192623e-02f, 2.07569793e-01f, 3.87449116e-01f, 2.67814219e-01f, 1.70235991e-01f, 2.74741352e-01f, 9.46269836e-03f, 1.14872441e-01f,
  6.64891442e-03f, 9.21893492e-03f, 4.99731814e-03f, 1.05376765e-01f, 5.23907579e-02f, -1.08645612e-03f, -8.30899552e-02f, -1.94828473e-02f, 3.18305761e-01f, 3.86822909e-01f,
  4.14746106e-01f, 1.83955267e-01f, -1.19620420e-01f, -3.98024917e-01f, -7.96103030e-02f, 1.71717659e-01f, 3.30738202e-02f, 3.36887427e-02f, 2.48113990e-01f, 8.85394886e-02f,
  -1.91122368e-01f, -5.38201109e-02f, -1.43921573e-03f, -6.69582859e-02f, -1.35442138e-01f, -1.51066050e-01f, -4.10072468e-02f, 1.62570715e-01f, 3.64273489e-02f, 9.06152800e-02f,
  8.42505023e-02f, -1.62828892e-01f, -3.08113188e-01f, -1.13884486e-01f, 1.64121211e-01f, -2.21416861e-01f, -7.37250149e-02f, -5.41884489e-02f, -8.27976391e-02f, 1.27623886e-01f,
  -1.46693900e-01f, -4.72277589e-02f, 2.85630375e-02f, 1.06304316e-02f, 6.22093640e-02f, -4.05243225e-02f, 1.93703428e-01f, 1.76744401e-01f, -1.64022490e-01f, -6.34969920e-02f,
  1.08513258e-01f, 6.93888068e-02f, -5.92988878e-02f, 1.07837446e-01f, -7.63969421e-02f, 5.27061932e-02f, 6.98669702e-02f, 1.97525233e-01f, 3.41545343e-02f, 1.13213189e-01f,
  6.68485612e-02f, 3.96564603e-02f, -2.40458190e-01f, 1.75097257e-01f, 1.00069702e-01f, 9.27139148e-02f, -4.86364514e-02f, 3.63793820e-02f, -6.55163303e-02f, -1.88784897e-02f,
  -3.17869931e-01f, -6.40578866e-02f, -9.20397341e-02f, -1.63155094e-01f, -1.62373688e-02f, -7.04066679e-02f, 6.23436226e-03f, 3.60368425e-03f, 1.84171572e-01f, 1.54777154e-01f,
  1.03381127e-02f, -5.98276732e-04f, -6.10060338e-03f, -5.40529899e-02f, -3.26838046e-01f, -3.92230213e-01f, -3.14056844e-01f, 1.04911834e-01f, -2.76815414e-01f, -2.21074373e-01f,
  -1.74778670e-01f, -3.41039449e-01f, -2.19392121e-01f, -1.37394875e-01f, -4.41590220e-01f, -4.45700616e-01f, -3.01697075e-01f, -3.85924518e-01f, -2.88483202e-01f, -2.52076387e-01f,
  9.79577720e-01f, 5.07081300e-02f, 1.80299263e-02f, 1.28913000e-01f, -5.56371771e-02f, -1.37771770e-01f, -1.21311858e-01f, -2.96467487e-02f, -2.11094953e-02f, 1.48196056e-01f,
  8.70600939e-02f, 1.76653504e-01f, 2.08964974e-01f, 4.13554758e-02f, 1.31148010e-01f, -1.31147981e-01f, -1.11003175e-01f, 3.66626075e-03f, 4.31781486e-02f, -1.47459731e-01f,
  -8.46838206e-02f, 1.83714867e-01f, 3.54515284e-01f, 4.95681986e-02f, -7.64868259e-02f, -3.07411398e-03f, -1.30222254e-02f, -8.72953460e-02f, -3.20970193e-02f, -2.86553185e-02f,
  -2.46820852e-01f, 7.55570363e-03f, 5.35061434e-02f, -2.09165234e-02f, 9.86417755e-02f, 4.57841791e-02f, 1.48418695e-01f, -1.44437402e-01f, -9.89597440e-02f, -1.88261375e-01f,
  -2.69535817e-02f, 6.01739399e-02f, 8.97233747e-03f, -5.94167002e-02f, -1.17114849e-01f, -7.37642795e-02f, -4.43473533e-02f, -1.84218865e-02f, -1.98904157e-01f, -2.88267098e-02f,
  -5.04175387e-02f, -1.15000352e-04f, -1.82215586e-01f, -5.90985604e-02f, -5.10956794e-02f, 2.39421986e-02f, -8.20826590e-02f, -1.76427811e-02f, 1.08600119e-02f, 1.35272024e-02f,
  -1.41039625e-01f, 6.12335615e-02f, -7.48741403e-02f, 8.18955079e-02f, 4.00136504e-03f, -1.27628222e-01f, -9.36787203e-02f, -1.20402299e-01f, 2.11473674e-01f, 1.92925870e-01f,
  -1.44760430e-01f, -1.15944862e-01f, 5.15533872e-02f, 1.72828801e-03f, 4.43743076e-03f, -6.21494465e-02f, -3.28892842e-02f, -5.36474213e-02f, 1.05690351e-02f, -9.28133503e-02f,
  3.06880828e-02f, -1.10348657e-01f, 7.59820417e-02f, -1.96889281e-01f, -1.23712450e-01f, -1.61121771e-01f, -9.50353965e-02f, 6.06390322e-03f, -1.03654917e-02f, 9.10863429e-02f,
  -2.29315594e-01f, 2.10049585e-01f, 1.87318176e-01f, 1.04053475e-01f, 4.24885228e-02f, 1.35158151e-01f, 1.32447571e-01f, -2.90346406e-02f, -1.52215570e-01f, -1.49608299e-01f,
  -5.51638082e-02f, 1.12690188e-01f, -7.34514520e-02f, -1.36881629e-02f, 1.30402192e-01f, 1.02892682e-01f, 1.46655098e-01f, -1.99543927e-02f, -3.03960834e-02f, -7.83707276e-02f,
  -2.38363631e-02f, 5.80698289e-02f, -6.80388659e-02f, 5.32040820e-02f, 7.63773099e-02f, 4.59005535e-02f, 1.00723699e-01f, -2.04053484e-02f, 1.19470768e-02f, 1.31270692e-01f,
  2.51320630e-01f, -3.32508266e-01f, -6.11629665e-01f, -3.04614127e-01f, -5.12438118e-01f, -3.92845750e-01f, -5.44796407e-01f, -1.03610411e-01f, 9.76944808e-03f, -3.55802029e-01f,
  -1.88577726e-01f, -1.93183050e-02f, 6.57811314e-02f, -1.24826454e-01f, -1.43931285e-01f, -4.14247960e-01f, -5.47280788e-01f, -4.23178643e-01f, -3.96514803e-01f, -5.69637358e-01f,
  -4.76302743e-01f, -4.74022031e-01f, -2.95568049e-01f, -1.48587301e-01f, 3.70629644e-03f, -8.66733044e-02f, -1.91486523e-01f, -1.94622755e-01f, -2.31522694e-01f, -2.12564126e-01f,
  -3.24873418e-01f, 1.45870820e-01f, -9.18462574e-02f, 2.95631494e-02f, -2.46457532e-01f, 3.95271517e-02f, 3.55856940e-02f, 1.33849442e-01f, 1.80129215e-01f, -5.43612204e-02f,
  -1.32666022e-01f, -1.94637343e-01f, 8.83447751e-02f, -1.22549228e-01f, -2.61928886e-01f, -2.36599088e-01f, -2.91173756e-01f, -2.11698741e-01f, -1.89421624e-01f, -2.05849364e-01f,
  -3.07906628e-01f, -2.78922677e-01f, 1.40329897e-01f, 1.57939121e-01f, 1.67144299e-01f, -4.91653048e-02f, 8.55123699e-02f, 1.21359445e-01f, 7.62681216e-02f, 1.23655342e-01f,
  6.61740974e-02f, 1.50957361e-01f, -4.18129712e-02f, -6.84053004e-02f, 6.69291476e-03f, 1.73763543e-01f, 1.23579308e-01f, 6.53783977e-02f, 6.46086782e-03f, -8.53782799e-03f,
  -8.59486014e-02f, -2.82848608e-02f, 9.11545381e-03f, 7.89751485e-02f, -3.67357722e-03f, 1.17140189e-02f, 1.04881816e-01f, 5.25380783e-02f, 1.11363925e-01f, 1.37167633e-01f,
  -1.12442076e-01f, 8.25544819e-02f, 4.67733443e-02f, 7.78545216e-02f, -2.54192650e-02f, 2.55973022e-02f, 2.94673648e-02f, 7.94227868e-02f, -7.84760714e-02f, -2.03620136e-01f,
  2.17682451e-01f, 4.84638028e-02f, 3.66198272e-01f, 1.93870172e-01f, 6.67217746e-02f, 4.68405709e-02f, 7.28992224e-02f, -2.35964591e-03f, 1.89205334e-01f, -9.31750685e-02f,
  -1.49504825e-01f, 2.51774341e-02f, 5.15729412e-02f, 4.72580455e-02f, -1.75055295e-01f, -1.03070466e-02f, -2.03105837e-01f, -6.48286641e-02f, 5.42112812e-02f, -4.40155491e-02f,
  -1.80168569e-01f, -7.45186955e-03f, 1.39537856e-01f, 1.91121891e-01f, 6.54121488e-02f, 2.61940032e-01f, 9.55601633e-02f, 1.35891080e-01f, 2.26227611e-01f, 1.54176205e-01f,
  5.75096428e-01f, 3.78006622e-02f, -6.28911614e-01f, 3.25815141e-01f, -4.55273092e-01f, -6.34244382e-01f, -4.64358300e-01f, 1.23787560e-01f, 2.40072697e-01f, -3.49982157e-02f,
  -4.36540812e-01f, -1.97586790e-01f, -1.66383579e-01f, -2.19048008e-01f, -4.23277557e-01f, -3.09192300e-01f, -3.01115066e-01f, -1.98286682e-01f, -2.03772932e-01f, 5.18377759e-02f,
  1.99422672e-01f, 4.98883665e-01f, 4.20071810e-01f, 2.66814679e-01f, 4.71782327e-01f, 1.76501542e-01f, 2.47590020e-01f, 1.69256806e-01f, -1.45736217e-01f, 1.91984370e-01f,
  1.64898962e-01f, 3.83824080e-01f, -3.15160424e-01f, -1.13124261e-02f, -1.02960274e-01f, 1.29943773e-01f, -6.73035579e-03f, 5.61988242e-02f, -4.13781732e-01f, -2.46852729e-03f,
  -3.47268552e-01f, -2.36267298e-01f, -1.13515772e-01f, 4.79500256e-02f, 3.21201026e-01f, 3.87698266e-04f, 6.84989989e-02f, -1.63373560e-01f, -1.65146649e-01f, -5.45241423e-02f,
  -2.90114075e-01f, -1.89361528e-01f, -4.80148345e-01f, -2.97009706e-01f, -8.34825486e-02f, -4.08761442e-01f, -1.58104911e-01f, -4.81570810e-02f, -1.96210578e-01f, 5.50873101e-01f,
  6.74920976e-02f, -1.06221162e-01f, -4.55167405e-02f, 4.63244058e-02f, 1.63500905e-02f, 1.20928381e-02f, -8.13562516e-03f, 1.14830732e-02f, -5.74486405e-02f, -3.30179818e-02f,
  -1.77454650e-01f, -1.52410578e-03f, 3.00131161e-02f, 1.32777557e-01f, 2.33694259e-02f, -1.14725512e-02f, -1.82401881e-01f, 1.50833473e-01f, 1.95612852e-02f, 1.72026575e-01f,
  2.96569597e-02f, -1.63346112e-01f, 9.50253755e-02f, 8.62792209e-02f, -8.39505717e-02f, -1.16276659e-01f, 1.74613774e-01f, -2.16225795e-02f, 2.96161473e-02f, -1.85784325e-02f,
  4.02482957e-01f, -6.44524693e-01f, 1.94714919e-01f, 7.86997154e-02f, 4.05201979e-04f, 1.23874843e-02f, -5.59358299e-03f, -1.42556369e-01f, -1.68259695e-01f, -7.93222114e-02f,
  -2.71480590e-01f, -1.68900982e-01f, 1.92506060e-01f, -1.42379418e-01f, 3.99796031e-02f, -1.29256800e-01f, -1.99941352e-01f, -3.12112898e-01f, -1.65345162e-01f, -1.13057740e-01f,
  8.08809977e-03f, -1.30865991e-01f, -5.43285869e-02f, -3.56584549e-01f, 1.88967753e-02f, -2.21026361e-01f, -1.49081826e-01f, -9.80865732e-02f, -5.13037086e-01f, 2.31514603e-01f,
  7.01387823e-01f, -6.18285656e-01f, -5.09274423e-01f, 3.44292164e-01f, -2.29039654e-01f, -4.59141552e-01f, -6.87212467e-01f, 1.34728789e-01f, 4.26743478e-01f, -5.73017836e-01f,
  -4.18850511e-01f, 2.93998659e-01f, 1.89046338e-01f, 2.00731814e-01f, 3.01650584e-01f, -5.92959464e-01f, -3.70785892e-01f, 1.32843807e-01f, 4.32163447e-01f, 8.07249472e-02f,
  6.50229007e-02f, 3.92790198e-01f, 5.41220903e-01f, 2.91454792e-01f, -4.24500644e-01f, 6.01122528e-02f, -4.76770759e-01f, -2.58737594e-01f, -4.71524030e-01f, -6.50308847e-01f,
  -5.85033298e-01f, -3.30223858e-01f, 6.67893663e-02f, 2.70182073e-01f, -1.15676649e-01f, 1.45268533e-02f, -1.36292949e-01f, -1.35328742e-02f, 2.74183191e-02f, -2.07321569e-01f,
  -1.62673801e-01f, 9.67860892e-02f, -6.34716973e-02f, -7.47506320e-02f, -1.08296871e-01f, -1.65936742e-02f, 1.64160892e-01f, 1.01765640e-01f, 6.92673400e-02f, -2.29919747e-01f,
  -3.14155221e-01f, -3.55608106e-01f, -1.74435422e-01f, -2.04301894e-01f, -4.44644839e-02f, 1.36730790e-01f, -4.20605302e-01f, -3.46769303e-01f, -3.40553522e-02f, -4.62971002e-01f,
  -1.03577017e-03f, -3.88526618e-02f, 2.93885116e-02f, -6.12525409e-03f, 3.93940322e-02f, -1.18211769e-01f, -1.97989661e-02f, -1.00650296e-01f, -8.40155855e-02f, -7.41059855e-02f,
  -4.58479300e-02f, -5.35425097e-02f, -5.63233159e-02f, -2.26947427e-01f, -6.22209720e-02f, -9.89701971e-02f, -7.83797354e-02f, 1.04102194e-01f, 3.39623503e-02f, 9.77989584e-02f,
  -1.48102106e-03f, -1.34300575e-01f, 8.33922178e-02f, 9.94851813e-02f, -6.72167242e-02f, 6.48422390e-02f, -7.39365146e-02f, 7.79104754e-02f, 2.41640538e-01f, -7.17850402e-02f,
  3.73191088e-01f, 2.53504932e-01f, -3.31487536e-01f, 1.27286807e-01f, -2.80566067e-01f, -7.68689662e-02f, -2.39704713e-01f, -6.03542104e-03f, 6.93128407e-02f, 7.42348507e-02f,
  -1.46912426e-01f, 1.05163872e-01f, -1.17307082e-01f, 7.76249450e-03f, -7.62348101e-02f, 6.33034483e-02f, 4.54236753e-02f, -4.92025390e-02f, 2.32518371e-03f, -1.27858952e-01f,
  6.03661090e-02f, -2.20003817e-03f, 2.28257105e-01f, 8.63693655e-02f, 6.36267364e-02f, 3.31673831e-01f, -1.42617688e-01f, -7.56939501e-02f, 2.13871390e-01f, -5.74863218e-02f,
  1.33931220e-01f, -1.36231512e-01f, 2.66311049e-01f, 4.70084809e-02f, 1.08885132e-01f, 1.47642776e-01f, 1.64226964e-01f, -2.14830786e-02f, -1.80256411e-01f, -3.19227315e-02f,
  -5.88027984e-02f, -1.02185436e-01f, 1.68986693e-02f, 4.90538254e-02f, 8.87046456e-02f, -1.58014372e-02f, 1.72267243e-01f, 2.61610776e-01f, 1.94826350e-01f, 5.73795699e-02f,
  9.70069785e-03f, 2.15706363e-01f, 1.06210992e-01f, -1.46072423e-02f, -3.90900560e-02f, 8.78783315e-02f, 1.31093144e-01f, 2.50524245e-02f, -1.20383359e-01f, -1.66899875e-01f,
  -1.60440207e-02f, -1.88113302e-01f, 1.41012417e-02f, -9.19334367e-02f, 6.68303892e-02f, -3.12637985e-02f, 1.61184385e-01f, -1.17523354e-02f, 1.52538735e-02f, -1.41742136e-02f,
  -1.64314896e-01f, 4.07934077e-02f, 7.95538798e-02f, -4.78065945e-03f, 1.51062056e-01f, -3.82322185e-02f, 5.49035426e-03f, -2.29506530e-02f, -1.66587561e-01f, -2.61671692e-01f,
  -2.46936917e-01f, -8.46942589e-02f, -2.73064617e-02f, -3.51342373e-02f, -2.03174978e-01f, -1.06658086e-01f, 5.54506667e-02f, -9.94653925e-02f, -4.74204496e-02f, 1.94828585e-02f,
  8.13169852e-02f, 1.83313817e-01f, 1.12806797e-01f, 1.45648077e-01f, 2.34106393e-03f, -6.50462285e-02f, -2.63157561e-02f, 1.44243404e-01f, 2.06944183e-01f, 1.98077857e-01f,
  2.13936627e-01f, 1.71340674e-01f, 2.74374306e-01f, 3.73155117e-01f, 1.22731403e-01f, 1.39265761e-01f, 3.24687064e-01f, 1.88436568e-01f, 1.36428893e-01f, 2.06229493e-01f,
  1.29563704e-01f, 2.74000049e-01f, 2.73999572e-01f, 1.97512001e-01f, 1.36155114e-01f, 2.64874518e-01f, 2.47212350e-01f, 3.10445070e-01f, 1.99556172e-01f, 2.19568431e-01f,
  2.03241929e-01f, 1.73727885e-01f, -9.83631387e-02f, -6.89428151e-02f, 5.45982122e-02f, -1.71220422e-01f, 8.24970677e-02f, 8.76306221e-02f, -6.57721162e-02f, 2.13786829e-02f,
  1.88270435e-02f, 1.84776653e-02f, 1.71219274e-01f, 2.59980243e-02f, 1.46780059e-01f, 1.10495061e-01f, -6.15981966e-03f, -8.03683847e-02f, -6.29017949e-02f, -1.32023633e-01f,
  -2.76906081e-02f, 4.94312569e-02f, 1.28163159e-01f, 9.36493203e-02f, -1.21073782e-01f, -2.92498711e-03f, 2.10228682e-01f, 4.29820828e-02f, 9.41516086e-02f, 1.46411642e-01f,
  4.64864105e-01f, 2.36267485e-02f, -3.21078062e-01f, -1.35593295e-01f, -1.33920871e-02f, 1.38914213e-01f, 2.96466470e-01f, 1.66606560e-01f, -9.74779055e-02f, -7.71152079e-02f,
  5.47217093e-02f, -1.94099024e-01f, -2.72351533e-01f, -1.53879389e-01f, 1.34396702e-02f, -1.60156384e-01f, -2.86831617e-01f, -2.46979028e-01f, 1.79488748e-01f, 2.22819299e-01f,
  2.00146899e-01f, 1.06154628e-01f, 2.73925997e-02f, -1.83961354e-02f, -1.92695186e-01f, -1.30391583e-01f, -4.21915591e-01f, -2.15024129e-01f, -1.02010898e-01f, -4.13105756e-01f,
  -2.89813429e-01f, -1.73055962e-01f, 1.02552399e-01f, 1.21345773e-01f, 1.71743914e-01f, 9.12999138e-02f, 1.06425099e-01f, 1.10683188e-01f, 1.15670554e-01f, 8.65275264e-02f,
  7.22706243e-02f, 5.74310087e-02f, -3.47291604e-02f, 1.28646255e-01f, 8.03370178e-02f, 7.30084702e-02f, 9.38066393e-02f, 2.53592189e-02f, 7.07802270e-03f, 1.63850784e-02f,
  3.11966855e-02f, -3.18874232e-02f, 2.70733815e-02f, -1.94491055e-02f, -2.95722168e-02f, -2.14038398e-02f, -4.84005176e-03f, 5.05884625e-02f, -1.08859316e-02f, 5.24601564e-02f,
  -3.41549926e-02f, 2.67261028e-01f, -2.71998288e-04f, -6.89010173e-02f, 2.82911099e-02f, 2.38629326e-01f, 1.01031372e-02f, -2.49344166e-02f, 2.97276136e-02f, 5.87841757e-02f,
  9.61642116e-02f, -2.29080036e-01f, 5.30810803e-02f, 3.78502868e-02f, -3.07011306e-02f, -5.04792556e-02f, 1.37795031e-01f, -1.53580690e-02f, -2.19620809e-01f, -1.29201889e-01f,
  -9.11397710e-02f, 2.35521011e-02f, 2.70361416e-02f, 8.14350024e-02f, 4.80849221e-02f, 1.74206458e-02f, -9.16454792e-02f, 2.39725504e-03f, -3.56680118e-02f, -5.56953205e-03f,
  -3.27107916e-03f, -3.12439561e-01f, -9.64210629e-02f, -3.46764997e-02f, -1.76617969e-02f, 1.04672492e-01f, -2.65664548e-01f, 2.19047535e-02f, 3.54431085e-02f, 3.49970832e-02f,
  -1.28676333e-02f, 1.28565565e-01f, 1.25882197e-02f, 1.04133986e-01f, 8.71685073e-02f, 1.02077149e-01f, 1.20166026e-01f, 6.92981184e-02f, -7.66812488e-02f, -8.04255381e-02f,
  1.28260413e-02f, 1.04362130e-01f, -6.67512864e-02f, 6.96583390e-02f, -2.56594503e-04f, -5.80592789e-02f, 4.22191918e-02f, 2.89250184e-02f, -4.55127023e-02f, 1.56791180e-01f,
  -5.37792921e-01f, -6.82449400e-01f, -6.18568845e-02f, -6.27047181e-01f, 1.47091404e-01f, 4.60927278e-01f, 4.79445964e-01f, 1.78003073e-01f, -2.85144925e-01f, -1.70664772e-01f,
  -2.38619685e-01f, -1.86946824e-01f, -2.59166598e-01f, -9.80282724e-02f, 1.18151307e-01f, 6.29244968e-02f, 5.61716929e-02f, 1.21335067e-01f, 5.37102282e-01f, 6.40298963e-01f,
  1.30182922e-01f, -2.86446095e-01f, -2.79836386e-01f, -2.50241756e-01f, -3.92220348e-01f, -1.35867059e-01f, -4.68333513e-01f, -3.59071553e-01f, -8.78475457e-02f, -4.12299186e-01f,
  2.50389338e-01f, -3.22358608e-01f, 1.24174349e-01f, -1.07282110e-01f, -2.16144755e-01f, -1.75337166e-01f, 6.04715832e-02f, -1.96952954e-01f, -9.59651619e-02f, -1.13485895e-01f,
  -1.98087588e-01f, -1.20908646e-02f, -5.41840829e-02f, -4.49621417e-02f, 1.99469719e-02f, 2.85887625e-02f, -1.75700024e-01f, -2.06896573e-01f, -1.48461401e-01f, -4.83901799e-02f,
  -1.23981021e-01f, 5.48963882e-02f, 3.94268334e-02f, 1.67835802e-01f, -1.70115265e-03f, -5.56557104e-02f, -3.55264917e-02f, 9.19496119e-02f, -3.36412452e-02f, -9.90640372e-02f,
  -1.44616617e-02f, 2.52347328e-02f, -3.76776233e-02f, 3.06213237e-02f, 1.05218507e-01f, 9.63247940e-02f, 8.46629962e-03f, -5.52912280e-02f, -6.08571582e-02f, -1.01084955e-01f,
  -1.72138140e-02f, 3.04614734e-02f, -9.44425389e-02f, -2.07431782e-02f, -9.82351974e-02f, -1.11563377e-01f, -3.25800478e-02f, -1.21119812e-01f, -5.81349693e-02f, -5.16222157e-02f,
  -1.08534552e-01f, 3.52727398e-02f, -6.53952267e-03f, -3.23438980e-02f, -5.03988825e-02f, -1.48058951e-01f, -6.36262298e-02f, -4.09642830e-02f, -4.12330069e-02f, 1.01823593e-02f,
  3.52222696e-02f, 2.33794093e-01f, 8.92998651e-02f, -8.71198252e-02f, -6.25500157e-02f, -7.96182826e-02f, -2.11454868e-01f, 1.32626304e-02f, 7.85013102e-03f, 1.76458314e-01f,
  6.10899292e-02f, 2.54034903e-02f, -6.78974241e-02f, -3.31371129e-02f, 1.39795497e-01f, 9.33929980e-02f, -5.63564263e-02f, -2.83087641e-02f, 1.39937587e-02f, -6.39229268e-02f,
  -1.71838537e-01f, 1.43676400e-01f, 2.71141410e-01f, 2.09276721e-01f, 7.05273449e-02f, 3.62776101e-01f, 2.70186573e-01f, 1.71804562e-01f, 3.38740557e-01f, 3.31951141e-01f,
  9.16640699e-01f, 3.25785518e-01f, -1.65817842e-01f, 2.32851774e-01f, 2.68428568e-02f, -9.00761187e-02f, 1.67509034e-01f, 8.75161961e-02f, 4.71761450e-03f, 2.33111098e-01f,
  3.15304846e-01f, 1.20075509e-01f, 1.78884998e-01f, 1.18048638e-02f, 2.95574348e-02f, -1.51984572e-01f, -1.53970763e-01f, -1.73181757e-01f, -5.69567941e-02f, -3.32841203e-02f,
  1.25930101e-01f, 1.08105406e-01f, 1.50280625e-01f, 6.33240640e-02f, 1.10168867e-01f, -9.69067588e-02f, 2.71590874e-02f, 2.11789981e-01f, 1.07687086e-01f, 5.54469451e-02f,
  8.13749135e-02f, 3.69634867e-01f, -2.65481055e-01f, 5.78287849e-03f, 1.12179369e-01f, 4.72837090e-02f, 1.28183350e-01f, 7.51103014e-02f, 1.02765232e-01f, -3.46758738e-02f,
  -3.93808708e-02f, 1.28527870e-03f, 1.98319763e-01f, 9.02855694e-02f, 3.33047323e-02f, -8.53988156e-02f, -2.59989966e-02f, -3.90589088e-02f, 1.01518095e-01f, 1.00183636e-01f,
  3.49212885e-02f, 3.96759063e-02f, -4.09490503e-02f, -1.45501330e-01f, -4.58406284e-02f, -1.20911468e-02f, -9.73313823e-02f, 6.69933483e-02f, -9.22476798e-02f, 8.88081640e-02f,
  1.65428862e-01f, 3.49522144e-01f, 3.15180808e-01f, 5.84722906e-02f, 1.33248448e-01f, 5.29670194e-02f, 1.64006203e-01f, 7.99145177e-02f, 2.59906929e-02f, -2.92982142e-02f,
  -3.75894420e-02f, 6.04737829e-03f, 1.36491999e-01f, 1.86766982e-01f, 9.49234068e-02f, 1.48592263e-01f, 7.62771890e-02f, 3.07216439e-02f, 1.52771443e-01f, 1.32956997e-01f,
  1.04607195e-02f, -4.18123454e-02f, -3.20247859e-02f, 3.48274386e-03f, -8.43183249e-02f, 4.95278314e-02f, 3.45529914e-02f, 1.78431153e-01f, 1.67085558e-01f, 1.46827057e-01f,
  -4.00456153e-02f, 7.34973252e-02f, -7.97792599e-02f, -9.19581726e-02f, -2.24593095e-03f, 9.00384970e-03f, 2.26673186e-02f, -2.66673509e-02f, 4.36967947e-02f, -8.99190530e-02f,
  -1.37750760e-01f, -4.27846313e-02f, 1.48371071e-01f, -6.66143894e-02f, 2.06345357e-02f, -6.76985905e-02f, 5.03494926e-02f, -1.05284095e-01f, -1.86576508e-02f, -1.51971206e-01f,
  -4.38318541e-03f, -2.30902527e-02f, -9.77602303e-02f, -2.32905224e-01f, -5.58350310e-02f, -1.61051020e-01f, -6.86289594e-02f, -1.40278950e-01f, -1.81534052e-01f, 6.51843147e-03f,
  -1.88166667e-02f, 4.93261039e-01f, -1.71739876e-01f, 1.16095476e-01f, 1.90368652e-01f, 2.63466477e-01f, 4.29912180e-01f, 2.72328168e-01f, -1.82029847e-02f, 1.00481749e-01f,
  1.96321324e-01f, 3.61177735e-02f, 1.84151772e-02f, 8.11856613e-02f, 9.72563475e-02f, 1.64252117e-01f, -4.69266288e-02f, -1.14218675e-01f, -1.64478630e-01f, 6.11454546e-02f,
  2.81363547e-01f, 4.13767070e-01f, 1.62834436e-01f, 5.69786318e-02f, 1.28577814e-01f, 5.63540757e-02f, 8.22187215e-02f, 1.42971441e-01f, 2.35589981e-01f, -1.63965389e-01f,
  -3.79502475e-01f, 1.70976609e-01f, -3.47441912e-01f, -1.06142469e-01f, -1.04337081e-01f, -1.15509525e-01f, -1.12779528e-01f, -7.64393955e-02f, 9.20339450e-02f, -5.93968816e-02f,
  -5.92641113e-03f, 2.08499376e-02f, 2.42835045e-01f, 2.59303842e-02f, 5.76649271e-02f, 5.92696741e-02f, 1.25869960e-01f, -4.88124862e-02f, -1.45789072e-01f, -2.22548276e-01f,
  8.47404823e-02f, 1.28343195e-01f, -8.48960876e-02f, -1.33127853e-01f, -1.88439071e-01f, -8.25960115e-02f, 6.09950302e-03f, -8.33825767e-02f, -1.35484412e-01f, -2.02453718e-01f,
  -2.76733190e-01f, -1.37343630e-01f, 2.64064316e-02f, -2.00882684e-02f, -3.97732528e-03f, 9.09054559e-03f, -9.96632576e-02f, 2.86396034e-02f, 7.75906490e-03f, 6.38738424e-02f,
  -1.29321098e-01f, -2.54371494e-01f, -2.62465477e-01f, -1.78409278e-01f, -1.26298470e-02f, -2.01110169e-02f, -1.72611792e-03f, -9.03211832e-02f, -3.87542993e-02f, 1.53503986e-02f,
  -9.14577097e-02f, -7.78908730e-02f, -9.76406112e-02f, -7.87366629e-02f, -9.62204337e-02f, -2.74170518e-01f, -8.20267200e-02f, -4.34217043e-02f, -5.66085838e-02f, 1.07305497e-01f,
  2.50773370e-01f, 2.02199563e-01f, -4.09707457e-01f, -1.79268330e-01f, -9.58528370e-02f, -4.50507216e-02f, -1.93047062e-01f, -1.54717326e-01f, 7.05563203e-02f, -1.12995416e-01f,
  1.30579576e-01f, -8.28544945e-02f, 7.77868181e-02f, 8.25037435e-02f, 9.66225937e-03f, -1.16709113e-01f, -7.12451618e-03f, -1.73219070e-01f, -1.21916614e-01f, -2.25381374e-01f,
  2.39376444e-03f, -2.57886440e-01f, -3.19322348e-01f, -1.92634046e-01f, -2.16291517e-01f, -1.62895560e-01f, -7.88218081e-02f, -3.09306026e-01f, -7.17348978e-02f, -1.16521314e-01f,
  5.04323244e-01f, -1.53273568e-01f, 1.25314936e-01f, 5.39591163e-02f, -2.40484744e-01f, -1.87739238e-01f, -4.55014437e-01f, -1.52955756e-01f, 1.43330887e-01f, -7.95732588e-02f,
  2.93506663e-02f, 1.57272264e-01f, 3.04851145e-01f, 2.89264619e-01f, 2.61736214e-01f, 8.49312544e-03f, 1.83237866e-02f, 4.20449823e-01f, 1.86475262e-01f, -1.32496223e-01f,
  -6.61818869e-03f, 1.22565575e-01f, 2.87385970e-01f, 2.98909664e-01f, -4.34133075e-02f, -3.09034511e-02f, 6.23393133e-02f, -2.75513411e-01f, -1.26159310e-01f, -1.17668957e-02f,
  -5.58241419e-02f, 6.59239711e-03f, 2.74058133e-01f, 1.64931521e-01f, 1.05658501e-01f, 2.25882530e-01f, 1.28815755e-01f, 4.65612933e-02f, -3.30369547e-02f, 6.17973655e-02f,
  1.15848593e-01f, 1.51282428e-02f, 2.02350970e-02f, -1.43663883e-01f, -2.17086673e-02f, 4.35747504e-02f, -6.95252940e-02f, -4.83678728e-02f, -2.62823515e-02f, 4.62213717e-02f,
  1.85720231e-02f, -1.12641983e-01f, -1.21534944e-01f, -3.68803479e-02f, 1.20865293e-01f, 1.23655431e-01f, -1.13203302e-01f, 5.77927530e-02f, 2.99146324e-02f, -5.31812608e-02f,
  2.48896763e-01f, 1.37604833e-01f, 8.00073817e-02f, 3.33566703e-02f, -3.33983637e-02f, -8.10146704e-02f, -2.15353906e-01f, -3.36494334e-02f, 1.06255189e-01f, 6.81370422e-02f,
  -1.83055967e-01f, 7.46166781e-02f, 6.06747828e-02f, 6.70681968e-02f, 2.25793928e-01f, -7.66987875e-02f, -9.30415839e-02f, 6.67885914e-02f, 2.02526316e-01f, 1.45573504e-02f,
  -5.59824668e-02f, -1.29969060e-01f, 4.27074358e-03f, -4.79196012e-03f, -1.66737691e-01f, 5.88059574e-02f, 3.47656310e-02f, 1.51395082e-01f, 1.78518236e-01f, -6.16485104e-02f,
  -3.21486086e-01f, 3.36718619e-01f, 1.69900343e-01f, 3.90856378e-02f, -6.02519177e-02f, 1.24953367e-01f, 9.85350832e-02f, -3.77334952e-02f, -1.39682770e-01f, -3.80823463e-02f,
  2.50767581e-02f, 9.46832374e-02f, -8.26616120e-03f, 4.60462848e-04f, -1.78905670e-02f, 4.52821404e-02f, -8.41649696e-02f, -4.17707153e-02f, -3.36775519e-02f, 2.15653814e-02f,
  8.32218081e-02f, -8.02200288e-02f, -1.05846651e-01f, 2.23339479e-02f, -1.15181571e-02f, 8.38142112e-02f, -1.80128664e-02f, -3.95719819e-02f, -2.22724411e-04f, -9.70592573e-02f,
  -1.07203767e-01f, -3.31953913e-01f, -2.75863558e-01f, 2.70657361e-01f, 4.26095128e-01f, -2.30853528e-01f, -6.41836166e-01f, -4.06148374e-01f, 1.63770422e-01f, -2.89534539e-01f,
  3.59457016e-01f, 5.24745762e-01f, 6.48818538e-02f, -3.28030661e-02f, -4.86198246e-01f, -3.99713308e-01f, -3.73540223e-01f, -3.11945409e-01f, -8.49286914e-02f, 3.27447861e-01f,
  3.98604751e-01f, 2.09468067e-01f, 3.80348451e-02f, -1.21590339e-01f, 1.18356861e-01f, 1.14159994e-01f, -1.51887715e-01f, 1.58369765e-01f, -1.16461858e-01f, -7.25734457e-02f,
  -6.69390559e-02f, -2.10378617e-01f, 1.13603652e-01f, 2.63203800e-01f, 3.73875856e-01f, -1.10546164e-01f, -2.08472729e-01f, -1.21426336e-01f, 3.84189747e-02f, -1.89147189e-01f,
  1.71829343e-01f, -5.67155844e-03f, 1.28374711e-01f, -4.15034890e-02f, 5.36550134e-02f, -2.09622890e-01f, -1.32064566e-01f, -3.55219156e-01f, -4.46947783e-01f, 2.16636937e-02f,
  3.08002532e-01f, 1.78332150e-01f, -2.62651414e-01f, -3.76272827e-01f, -4.95695561e-01f, 1.51801771e-02f, -3.15802693e-01f, -1.07780024e-01f, -5.14828503e-01f, -4.00137544e-01f,
  4.19384837e-02f, 2.06229001e-01f, 1.58103630e-01f, -1.36787236e-01f, -4.54985630e-03f, 5.88632114e-02f, 3.17024030e-02f, -4.12605666e-02f, 1.64993688e-01f, -9.57871601e-02f,
  -8.92354473e-02f, 7.43867010e-02f, -9.08093154e-02f, -9.96114463e-02f, 1.83081941e-03f, -1.02188021e-01f, 6.18520491e-02f, -8.25011134e-02f, -6.62257299e-02f, -1.08755678e-01f,
  -6.38494566e-02f, -2.67813168e-02f, 8.49712938e-02f, -7.95274973e-02f, -2.15572994e-02f, -1.35834485e-01f, 2.44958196e-02f, -9.33319256e-02f, -7.50578716e-02f, -5.23441844e-02f,
  8.53306353e-02f, 4.67607751e-02f, 3.41473185e-02f, -2.65999716e-02f, 2.52843779e-02f, 1.62168071e-01f, 9.00554061e-02f, 9.85790566e-02f, 1.47719383e-02f, -5.67103624e-02f,
  -1.29246965e-01f, -1.60370201e-01f, -1.63660735e-01f, -4.46331166e-02f, 5.69420643e-02f, 1.32975299e-02f, 5.14290594e-02f, 6.97500855e-02f, -5.83006814e-02f, 8.48037004e-02f,
  -1.03051044e-01f, -2.00681865e-01f, -2.47539088e-01f, -2.80193001e-01f, 5.26489429e-02f, 1.27466703e-02f, -2.17066050e-01f, -7.51322880e-02f, -3.30971867e-01f, -6.03173375e-01f,
  -4.22695160e-01f, 6.07521892e-01f, 5.41830420e-01f, -3.64760786e-01f, 3.24813962e-01f, 4.83694464e-01f, 5.71366072e-01f, -8.39652345e-02f, -3.92825514e-01f, 2.58967757e-01f,
  5.40693343e-01f, -2.10689336e-01f, -2.90315568e-01f, -2.26709574e-01f, -4.24618453e-01f, -1.00351088e-01f, -3.10327500e-01f, -3.10413688e-01f, -4.80988443e-01f, -2.59980708e-01f,
  -2.30268359e-01f, -2.26720214e-01f, -3.58301640e-01f, -3.15349340e-01f, -6.64732754e-02f, -1.82176739e-01f, 1.99718207e-01f, 3.40446904e-02f, 3.08073372e-01f, -2.14051619e-01f,
  4.12303537e-01f, 3.60290587e-01f, -1.99882299e-01f, -1.79957673e-01f, 1.03806563e-01f, -1.97430134e-01f, 8.28602910e-02f, -6.53272271e-02f, -8.06591958e-02f, -5.48548549e-02f,
  2.17620835e-01f, 5.52138165e-02f, 1.03966661e-01f, 1.84649289e-01f, 1.85691621e-02f, -1.41986553e-02f, -3.25039704e-03f, -2.61122793e-01f, -1.33280352e-01f, 1.92858294e-01f,
  1.37856990e-01f, 4.09033656e-01f, 3.99036139e-01f, 1.86761618e-02f, -7.73854181e-02f, -1.17161773e-01f, 2.99017370e-01f, 8.96554440e-03f, -3.90847819e-03f, -1.88984543e-01f,
  -1.64469540e-01f, 7.78155699e-02f, -3.65131907e-02f, 7.55782276e-02f, -8.28773826e-02f, 3.12640495e-03f, -4.14134143e-03f, 6.90679476e-02f, -1.49494559e-01f, 4.81435955e-02f,
  3.98331806e-02f, 1.67609066e-01f, 1.90623607e-02f, 1.77578535e-02f, -6.19870052e-02f, 1.07418224e-01f, 1.89763308e-01f, 5.03166430e-02f, 1.09369226e-01f, 5.81889190e-02f,
  6.29831031e-02f, 1.11302761e-02f, 6.01499937e-02f, -5.63227572e-02f, 1.87484726e-01f, 2.92368364e-02f, 9.92898345e-02f, 5.28810546e-02f, 1.12456731e-01f, 1.61022022e-01f,
  -1.77046806e-01f, 2.95003921e-01f, -8.06931779e-03f, -9.79110152e-02f, 1.06693856e-01f, 1.35232676e-02f, 1.28583699e-01f, 3.51873115e-02f, 1.15300819e-01f, -6.27206638e-02f,
  1.81361765e-01f, 2.12340225e-02f, 1.66755527e-01f, 6.82989955e-02f, -1.29853860e-01f, 2.31762789e-02f, 4.13943492e-02f, 3.09567545e-02f, -1.03843808e-01f, 1.14736043e-01f,
  -7.60057643e-02f, -1.26058221e-01f, -1.52701467e-01f, -1.71340391e-01f, -1.56597227e-01f, -2.25101292e-01f, -2.69319350e-03f, -4.60099708e-03f, -5.17198481e-02f, -3.79181564e-01f,
  -5.52262843e-01f, -7.32139498e-02f, 3.11650544e-01f, -4.85472903e-02f, 3.06328446e-01f, -8.90734345e-02f, -4.25213695e-01f, -4.55937326e-01f, -1.04992226e-01f, -4.87769116e-03f,
  1.67186111e-01f, 2.59902388e-01f, 3.52533579e-01f, 2.21188098e-01f, -1.70546904e-01f, 2.46341467e-01f, 5.21569133e-01f, 1.91324949e-01f, -3.27592462e-01f, -5.49259901e-01f,
  2.74871271e-02f, -1.15251586e-01f, -3.63996834e-01f, -9.60647315e-02f, 7.75883272e-02f, 9.89094526e-02f, 3.25438768e-01f, -6.18464686e-03f, 1.14119329e-01f, 3.22147012e-01f,
  4.74045128e-02f, -3.38623583e-01f, 1.27209798e-01f, 1.56375006e-01f, 2.99169630e-01f, -3.38147283e-01f, -2.81866848e-01f, -4.61696647e-03f, 3.93980136e-03f, -1.31445885e-01f,
  1.49249986e-01f, 2.85604466e-02f, 2.47785866e-01f, -7.34907463e-02f, -2.28370920e-01f, -4.23369318e-01f, -8.64997208e-02f, -2.96332479e-01f, -1.36875674e-01f, -3.68100613e-01f,
  2.91854441e-01f, -6.28560856e-02f, -1.00602672e-01f, -1.86407909e-01f, -3.29126596e-01f, 1.88785449e-01f, -3.04969698e-01f, -4.99588311e-01f, -3.82250160e-01f, -5.08089662e-01f,
  4.42635305e-02f, 1.32537633e-01f, 1.52985692e-01f, -3.46109667e-03f, -4.13180403e-02f, 4.43330668e-02f, 2.29467958e-01f, 1.34675682e-01f, 5.81129342e-02f, -1.02115571e-01f,
  1.21072441e-01f, -1.57594442e-01f, -1.23863503e-01f, 2.07580952e-03f, 5.44404238e-02f, -1.09379269e-01f, 2.62028705e-02f, -7.63583137e-03f, 3.96599434e-02f, -1.31021753e-01f,
  8.13139826e-02f, -1.21271601e-02f, 8.64177272e-02f, -6.86716735e-02f, 6.66752234e-02f, 1.19190641e-01f, -9.24019665e-02f, -1.29907638e-01f, -2.65541635e-02f, -1.34577215e-01f,
  -2.21188799e-01f, 4.56721246e-01f, -7.68315643e-02f, -6.45850524e-02f, 1.13667667e-01f, 1.58173472e-01f, 5.78953475e-02f, 5.90570681e-02f, 7.15652928e-02f, -1.98144734e-01f,
  -2.31837988e-01f, -1.70164332e-01f, 2.26583406e-01f, 7.59543329e-02f, -2.53546983e-02f, 1.93438064e-02f, 1.44704401e-01f, -4.00707722e-02f, 4.65731397e-02f, -1.08121805e-01f,
  2.26233050e-01f, -3.15771252e-01f, -2.71602750e-01f, -1.23797625e-01f, -1.18134938e-01f, -5.02799870e-03f, 4.03409358e-03f, -2.95879275e-01f, -1.95772752e-01f, -4.37539220e-01f,
  -9.91439641e-01f, 3.68156493e-01f, -2.07538940e-02f, -6.53178215e-01f, -5.28310716e-01f, -3.22829813e-01f, 1.99974969e-01f, -2.83152938e-01f, -3.39505255e-01f, 3.04476708e-01f,
  1.12586506e-01f, -2.57639498e-01f, -4.61761877e-02f, 6.64655492e-02f, -1.22930678e-02f, 3.69801581e-01f, -1.98341887e-02f, -3.95445555e-01f, -6.12239480e-01f, -4.04659569e-01f,
  -1.27652720e-01f, -5.88631630e-01f, -6.36625886e-01f, -2.21589223e-01f, -1.07858211e-01f, -3.80612850e-01f, -6.49587810e-02f, -3.71768892e-01f, -2.81515233e-02f, -1.18184730e-01f,
  2.71398753e-01f, -6.12403035e-01f, -1.07789360e-01f, -1.06472574e-01f, 2.65166666e-02f, 4.22816537e-02f, -6.89977258e-02f, -1.04953714e-01f, 7.46286288e-03f, 4.63530943e-02f,
  -1.96088985e-01f, -2.36266833e-02f, -1.46642476e-01f, 6.32383674e-02f, -1.11718953e-01f, -5.27277216e-02f, 1.10787913e-01f, -2.58076936e-02f, 8.80823359e-02f, 3.27537566e-01f,
  3.80722314e-01f, -9.16207656e-02f, 7.17994422e-02f, 3.50410491e-02f, 2.19095591e-02f, -1.37831658e-01f, 6.37040883e-02f, -2.39989813e-02f, -1.47147849e-01f, 9.05809030e-02f,
  -1.23970965e-02f, 1.25077024e-01f, -9.87570807e-02f, -5.27194329e-02f, -1.70714911e-02f, -4.86542322e-02f, -1.05228029e-01f, 1.57948449e-01f, -9.77419540e-02f, -2.23964099e-02f,
  1.56437159e-02f, 1.21113397e-02f, -9.07813534e-02f, -8.76303092e-02f, 6.37389123e-02f, -3.31205204e-02f, 3.73460501e-02f, 8.64814892e-02f, 1.43188864e-01f, -1.70322545e-02f,
  -1.00835361e-01f, 5.41878343e-02f, -1.16711490e-01f, 1.17910065e-01f, -5.54035883e-03f, 5.91242388e-02f, -2.03288998e-02f, 4.77598794e-02f, -1.01194017e-01f, -1.07554384e-01f,
  1.52657013e-02f, -2.41930410e-01f, 6.20379671e-02f, 7.12752528e-03f, 1.29778376e-02f, 1.51858076e-01f, 4.57015671e-02f, 1.05199376e-02f, -1.70052513e-01f, -3.09385471e-02f,
  -1.29193952e-02f, 7.02029318e-02f, 7.95636475e-02f, 1.55650869e-01f, -1.62402883e-01f, -6.50896057e-02f, 2.07173929e-01f, -3.60400118e-02f, 7.47147128e-02f, 3.12341005e-01f,
  3.37745249e-01f, 7.03856051e-02f, 1.17088594e-01f, 1.11015990e-01f, 7.99118280e-02f, -3.74362729e-02f, 4.62391116e-02f, 1.29282534e-01f, 1.25836208e-01f, 2.15897247e-01f,
  8.28636944e-01f, 3.19314688e-01f, 3.30215275e-01f, 1.08689405e-01f, -4.05709110e-02f, 8.31872039e-03f, -9.41637252e-03f, 9.44057480e-03f, 6.16039447e-02f, 1.58231139e-01f,
  1.66905925e-01f, 7.96791166e-02f, 7.05124661e-02f, 8.95054117e-02f, -1.14774322e-02f, 6.95141181e-02f, -1.63759626e-02f, 6.41999617e-02f, 6.72820285e-02f, 1.57090500e-01f,
  8.67338553e-02f, 1.20013148e-01f, 2.61745721e-01f, 7.13313073e-02f, 1.71337768e-01f, 2.29327269e-02f, 2.94241942e-02f, 1.72452495e-01f, 2.21717119e-01f, 2.75339097e-01f,
  3.37148726e-01f, 4.58108038e-01f, -3.26152146e-01f, -8.91350433e-02f, 8.88884366e-02f, 3.83876413e-02f, -4.20352034e-02f, -7.36186979e-03f, 8.19414575e-03f, -9.58093628e-02f,
  5.79842599e-03f, 1.38879684e-03f, -8.56054351e-02f, -1.29676424e-02f, -6.68503344e-02f, -6.29552007e-02f, 9.49535370e-02f, 1.13417119e-01f, -1.33246154e-01f, 8.27527344e-02f,
  -7.73456395e-02f, 7.23563060e-02f, 1.47503102e-02f, -1.38895839e-01f, 4.57932726e-02f, 3.59053016e-02f, 6.08774796e-02f, 1.02070048e-01f, -4.19153385e-02f, 2.18363732e-01f,
  9.76044461e-02f, 9.34268534e-02f, 2.68393993e-01f, 2.08082661e-01f, 1.84034154e-01f, 1.53291285e-01f, -5.59613807e-03f, -3.34904119e-02f, 1.06731802e-01f, -1.63827685e-03f,
  3.55218388e-02f, 3.68255377e-02f, 4.61480692e-02f, -7.42792487e-02f, 8.83193389e-02f, -6.19260892e-02f, 2.07903460e-02f, 9.53453593e-03f, -8.85213260e-03f, 3.66458064e-03f,
  1.12400874e-01f, -8.93418416e-02f, 3.93781476e-02f, 1.00350574e-01f, -2.05307510e-02f, 8.41088295e-02f, -2.35777646e-02f, -5.22630401e-02f, 5.16696600e-03f, 4.78801541e-02f,
  -5.86662233e-01f, -1.94006443e-01f, 1.17532529e-01f, -7.15078786e-02f, -4.18598875e-02f, -7.80827329e-02f, -2.15994380e-02f, 6.62150010e-02f, 4.92871478e-02f, -1.35850776e-02f,
  1.79667436e-02f, -4.57689129e-02f, -1.43031538e-01f, 4.30609100e-03f, -1.01742074e-01f, -1.69571847e-01f, -2.39378437e-02f, -4.12344038e-02f, -4.43243310e-02f, -2.14069281e-02f,
  -1.52296364e-01f, -2.42566094e-01f, -3.22480202e-01f, -2.25529909e-01f, -2.94572785e-02f, -2.08180174e-01f, -3.36180888e-02f, -1.40866026e-01f, -1.48003697e-01f, -6.46273047e-02f,
  1.30954087e-01f, 4.86097574e-01f, -1.08521789e-01f, 2.19986230e-01f, 2.65965402e-01f, 2.21184358e-01f, 7.05689728e-01f, 6.03082657e-01f, 2.10968167e-01f, 2.61223406e-01f,
  -3.67400825e-01f, -7.81983495e-01f, -5.44849753e-01f, -4.55448717e-01f, -3.12271237e-01f, 4.52577353e-01f, 3.59405607e-01f, -3.41301948e-01f, -4.73350376e-01f, -1.42203495e-01f,
  -6.28832653e-02f, 2.30376303e-01f, -6.75702766e-02f, -1.87342223e-02f, 2.54669935e-01f, -7.62346154e-03f, 4.52630252e-01f, 1.13416702e-01f, 2.81144753e-02f, -8.49620923e-02f,
  -6.48981214e-01f, 2.87873983e-01f, -4.81357098e-01f, -5.67725040e-02f, -7.80375302e-02f, -2.44696528e-01f, -7.80299976e-02f, -2.76386254e-02f, -3.23564783e-02f, 8.67212266e-02f,
  -1.72134638e-01f, -2.59698242e-01f, -2.33852282e-01f, 1.49150717e-03f, 3.48716900e-02f, -7.82878548e-02f, 8.60057771e-02f, -4.50899601e-02f, -2.01140270e-01f, -2.09438279e-01f,
  -2.37623572e-01f, -1.57778472e-01f, -5.27539216e-02f, 2.46137396e-01f, -2.04625785e-01f, -2.36058965e-01f, 1.36422709e-01f, -1.83032587e-01f, -1.67081028e-01f, 1.31979942e-01f,
  -3.40144001e-02f, 1.30587250e-01f, -5.07331360e-03f, 9.21809226e-02f, 4.79616076e-02f, -4.16631699e-02f, 1.04039125e-01f, 5.76100759e-02f, -3.31937037e-02f, 7.18329549e-02f,
  -9.28690434e-02f, -1.33281425e-01f, 3.85459960e-02f, -4.60272469e-02f, -1.23347819e-01f, -1.39334248e-02f, -7.06925010e-03f, 6.99435323e-02f, -2.86156964e-02f, 1.93710685e-01f,
  -1.13251239e-01f, 5.02460869e-03f, -6.53212592e-02f, -1.06645599e-01f, -2.78342906e-02f, -1.55029213e-02f, -1.86949521e-01f, -6.97500706e-02f, 2.00859055e-01f, 1.51068181e-01f,
  -4.49904539e-02f, 4.83594313e-02f, -2.32594714e-01f, 1.55030698e-01f, 1.69222638e-01f, 3.85926329e-02f, 2.80344244e-02f, 2.96038967e-02f, 2.00217038e-01f, -1.23568131e-02f,
  -1.43560573e-01f, -1.35869443e-01f, -1.33662477e-01f, -1.37072682e-01f, -2.83417940e-01f, -9.28631489e-05f, 1.25112295e-01f, 8.54628086e-02f, 2.23199446e-02f, 1.32070422e-01f,
  1.35570467e-01f, 2.20711783e-01f, -9.20396969e-02f, 9.20124203e-02f, 9.03160051e-02f, -1.03367239e-01f, 7.97578320e-02f, 9.06520262e-02f, -9.76506472e-02f, 4.44075257e-01f,
  -7.54262805e-01f, 5.98250851e-02f, 4.45587151e-02f, -2.46552646e-01f, 1.98123425e-01f, 3.07265490e-01f, 7.47757494e-01f, 2.79210448e-01f, 2.84861643e-02f, 4.57284987e-01f,
  -1.65153071e-01f, -5.89307129e-01f, -3.85472804e-01f, -2.64158249e-01f, -5.36173657e-02f, 6.54918015e-01f, 5.43732882e-01f, -9.32150856e-02f, -1.60753071e-01f, -1.16269691e-02f,
  1.99985832e-01f, -6.66612685e-02f, -4.41283613e-01f, -1.76598087e-01f, 3.56985000e-03f, -2.25463361e-02f, 1.59735546e-01f, -2.17592448e-01f, 7.92799145e-02f, 1.41958492e-02f,
  -2.12281078e-01f, -6.52083457e-01f, 6.31602900e-03f, -3.16501319e-01f, -2.18560562e-01f, -1.48455322e-01f, 1.45499572e-01f, -3.35809141e-01f, -2.44386926e-01f, 5.54541722e-02f,
  -1.68408275e-01f, -2.65788943e-01f, -4.37750876e-01f, -4.19098251e-02f, -1.51199713e-01f, -4.28260416e-02f, -1.60213917e-01f, -3.57819587e-01f, -3.19745690e-01f, -2.71455288e-01f,
  -9.03661847e-02f, -2.19471559e-01f, -2.31264293e-01f, 4.86529358e-02f, -3.06513399e-01f, -1.80885375e-01f, -6.73269480e-02f, -3.38553488e-01f, -4.31982726e-01f, -6.85018376e-02f,
  9.13352594e-02f, -4.68477234e-02f, 1.44250710e-02f, 1.15323387e-01f, 9.73292813e-02f, 1.25766145e-02f, -3.26920301e-02f, 1.44356685e-02f, -3.34601142e-02f, -5.89612760e-02f,
  -2.26973653e-01f, -5.11529259e-02f, -1.23870395e-01f, 7.79837966e-02f, -8.85764956e-02f, -8.79484415e-02f, 7.55716264e-02f, 4.38947696e-03f, 3.48290391e-02f, -3.00046690e-02f,
  -7.27846548e-02f, -1.76426005e-02f, 1.90632343e-02f, 2.11930294e-02f, 1.90793589e-01f, -2.62540914e-02f, 7.98264518e-02f, -6.05640886e-03f, -5.71501777e-02f, -3.52421887e-02f,
  1.27974033e-01f, -1.43067390e-01f, 1.50475994e-01f, -7.81054050e-02f, 5.02617359e-02f, -1.09415255e-01f, 8.14559162e-02f, -1.27537258e-03f, -1.73375666e-01f, -2.34047785e-01f,
  -6.23380579e-02f, -2.43028507e-01f, -1.94510162e-01f, 1.45030588e-01f, 1.87705263e-01f, 1.71524569e-01f, 2.38657996e-01f, 2.28321686e-01f, 1.52290896e-01f, 9.07215700e-02f,
  1.85872912e-01f, 4.57703322e-01f, 1.95141628e-01f, 1.73293993e-01f, 1.25133127e-01f, 1.42017424e-01f, 2.19909728e-01f, 2.31301084e-01f, 1.03085585e-01f, 6.47937894e-01f,
  6.13114424e-02f, 1.71846464e-01f, -6.25653028e-01f, -8.81574452e-02f, -5.01980007e-01f, -3.51826340e-01f, 3.98119539e-02f, 2.56857574e-01f, -5.19500822e-02f, 1.19008169e-01f,
  6.55317977e-02f, 3.54017280e-02f, 3.88311520e-02f, -1.06063133e-04f, 1.44430429e-01f, -1.77110106e-01f, -2.71140426e-01f, -4.28219289e-01f, -3.47351879e-01f, 3.08637898e-02f,
  -2.20831558e-02f, -7.54315257e-02f, -1.07640482e-01f, 2.61588804e-02f, -2.00966567e-01f, -2.75385827e-01f, -3.42925370e-01f, -4.22476768e-01f, -3.71207088e-01f, -5.16579866e-01f,
  -1.33272320e-01f, -3.13574940e-01f, -3.61570790e-02f, 1.44847453e-01f, -7.20644742e-02f, 2.88407464e-04f, -8.75229165e-02f, -4.09551756e-03f, 5.10831363e-02f, 4.20646258e-02f,
  -1.50895596e-01f, -1.33655250e-01f, -1.21513091e-01f, -1.21492170e-01f, -1.95998549e-01f, -9.57422480e-02f, -1.28121749e-01f, -2.43539751e-01f, -2.05380216e-01f, -2.11026892e-01f,
  -2.01490298e-01f, -5.39358139e-01f, -4.79477227e-01f, -2.54419241e-02f, -2.94970572e-01f, -3.03323060e-01f, -2.06364647e-01f, -3.47876787e-01f, -4.04065430e-01f, 4.56700101e-02f,
  8.29318464e-02f, -5.65584749e-03f, -1.55490741e-01f, 1.81491420e-01f, 2.99234897e-01f, 7.91304186e-03f, -4.55391631e-02f, 9.53550190e-02f, -4.82176207e-02f, 1.66759998e-01f,
  1.41885132e-01f, 8.82760435e-02f, 3.09080258e-02f, 2.21482962e-02f, -1.93666667e-01f, -5.69024459e-02f, 3.14116180e-02f, 9.50137004e-02f, 2.34432295e-02f, -4.42801863e-02f,
  -1.69433206e-02f, -1.92384377e-01f, -1.06032215e-01f, 1.29088134e-01f, -1.07174113e-01f, -9.54686403e-02f, 5.85758425e-02f, 4.67504710e-02f, 1.09005347e-02f, 8.17345828e-03f,
  3.89586627e-01f, -8.26906860e-02f, 2.18956053e-01f, 1.25263304e-01f, -9.37947929e-02f, -1.38981715e-01f, 9.23819616e-02f, 6.79458454e-02f, -6.02456331e-02f, -5.90190254e-02f,
  1.22201063e-01f, 5.57634868e-02f, -4.77685109e-02f, -3.99376638e-02f, -4.15971205e-02f, -9.88951400e-02f, 1.70815229e-01f, -2.09469184e-01f, 1.06247477e-01f, -1.07983630e-02f,
  1.78679585e-01f, 1.34872630e-01f, 2.89303780e-01f, 1.37420937e-01f, -3.80213149e-02f, 1.46257162e-01f, 2.18308032e-01f, 8.25237483e-02f, 2.25973725e-02f, 5.39665461e-01f,
  8.12454939e-01f, 4.33721572e-01f, -5.70594035e-02f, 1.31625965e-01f, -3.06393653e-01f, -4.48173672e-01f, -3.75734061e-01f, -1.60722226e-01f, -1.31127024e-02f, 2.48718917e-01f,
  1.72772527e-01f, 3.09713334e-01f, 2.17061609e-01f, 1.25183105e-01f, -1.28435597e-01f, -1.24081612e-01f, -4.09664586e-02f, 1.25271484e-01f, -1.86674241e-02f, 2.11320952e-01f,
  3.44830453e-01f, 2.66966373e-01f, 2.35061139e-01f, 1.70620576e-01f, 2.68242657e-01f, 1.49427295e-01f, -2.77070403e-02f, 1.05425335e-01f, 1.82711065e-01f, 5.44634342e-01f,
  1.44721568e-01f, 1.05624944e-01f, -9.26253125e-02f, 6.77011460e-02f, -7.67719448e-02f, 8.04579929e-02f, -3.95035073e-02f, -5.94845489e-02f, 4.55294326e-02f, 2.01595798e-02f,
  -9.09257755e-02f, -7.06234351e-02f, -1.18785411e-01f, -9.16783512e-02f, -7.40521476e-02f, -7.01552704e-02f, -1.08787045e-01f, 2.62032039e-02f, -1.37125105e-01f, 8.15538540e-02f,
  1.45733014e-01f, -1.53173236e-02f, -2.93296635e-01f, -3.48134607e-01f, -1.90862000e-01f, -1.12803109e-01f, -1.23606347e-01f, -3.94954197e-02f, -1.37265012e-01f, 1.05827980e-01f,
  -1.20149389e-01f, 4.37232330e-02f, -1.70455888e-01f, -2.85217213e-03f, -1.10301450e-01f, -2.05419194e-02f, -3.71534005e-02f, -1.52069563e-03f, -1.49588898e-01f, 5.33719896e-04f,
  -6.90370277e-02f, -5.89483418e-02f, -3.15210372e-02f, 2.85621658e-02f, 4.72657308e-02f, 3.35909962e-03f, 8.23482797e-02f, -6.13295659e-02f, -2.58494496e-01f, -1.01918899e-01f,
  -2.89300624e-02f, -4.97038651e-04f, -4.51853685e-02f, -1.53562382e-01f, -2.49110218e-02f, -1.68982834e-01f, -5.16773760e-02f, -2.79384051e-02f, 6.24225661e-03f, 1.12130724e-01f,
  7.36032948e-02f, -4.45665926e-01f, 2.99481302e-01f, 2.85888970e-01f, 3.15338299e-02f, 8.91321599e-02f, 1.12062529e-01f, 1.13529645e-01f, 1.59451254e-02f, 1.49760647e-02f,
  3.03605222e-03f, 7.62273883e-03f, 6.53861184e-03f, 3.15934643e-02f, -1.29163086e-01f, -7.13858902e-02f, 1.38515294e-01f, 1.49117842e-01f, -6.94257915e-02f, 9.11562219e-02f,
  5.30850291e-02f, -1.20907977e-01f, -1.16719134e-01f, -1.70168832e-01f, 5.15741259e-02f, 7.62120180e-04f, 3.47814076e-02f, -2.18595080e-02f, -1.54530615e-01f, -6.80670515e-02f,
  4.48328078e-01f, 1.74375519e-01f, -8.58196616e-01f, 1.60927936e-01f, -1.88249707e-01f, -3.12616736e-01f, -4.72954921e-02f, 1.91008493e-01f, 2.08884001e-01f, 1.68684959e-01f,
  -1.10830240e-01f, -3.26313674e-01f, -5.44018984e-01f, -4.98844355e-01f, -5.64895213e-01f, -3.47573012e-01f, -4.43676233e-01f, -6.36049032e-01f, -5.57390690e-01f, 1.52192950e-01f,
  1.91212252e-01f, 6.08198047e-02f, 2.50554346e-02f, -3.55637558e-02f, 8.00751150e-02f, -3.06196123e-01f, -3.95872444e-01f, -2.78511792e-01f, -1.88214347e-01f, -2.43551493e-01f,
  -4.23590809e-01f, -2.94303536e-01f, -1.16724268e-01f, 6.58326074e-02f, -7.31975865e-03f, 5.35977557e-02f, -1.18871545e-02f, -8.61393064e-02f, 2.29919210e-01f, -4.45223898e-02f,
  -1.11518703e-01f, 1.68184131e-01f, -1.11062899e-01f, -1.41512901e-01f, -6.64978623e-02f, -1.23178281e-01f, -6.69524670e-02f, -2.94655442e-01f, -2.34249234e-01f, 8.52739736e-02f,
  2.08393469e-01f, -3.19666356e-01f, -6.22687519e-01f, -3.89343612e-02f, -3.17730367e-01f, -4.21398789e-01f, -1.70191705e-01f, -2.60680228e-01f, -4.33937907e-01f, 2.48238012e-01f,
  1.53051987e-01f, -2.71251351e-02f, 2.31782440e-02f, -2.85797939e-02f, 1.23246476e-01f, -8.37293640e-02f, -4.70273234e-02f, -1.60873663e-02f, 2.98598651e-02f, 3.09938490e-02f,
  -3.77430022e-02f, 2.49622930e-02f, 4.52369824e-03f, -5.88737316e-02f, -1.06525622e-01f, -1.01896025e-01f, 1.11323401e-01f, 1.07413940e-01f, -1.40541703e-01f, 8.98273662e-03f,
  8.87218770e-03f, -6.57736585e-02f, -1.83901954e-02f, 6.16694279e-02f, -1.17881550e-02f, -8.04127529e-02f, 6.89516775e-03f, -1.28082780e-03f, -2.07038526e-03f, 3.90267149e-02f,
  1.74736470e-01f, -1.65890679e-01f, -4.87965383e-02f, -1.18409067e-01f, -6.05482906e-02f, -4.43534851e-02f, 8.44209567e-02f, 2.19090670e-01f, -2.74174009e-02f, 8.89194235e-02f,
  -4.29132730e-02f, 1.98357493e-01f, -7.67860934e-02f, 6.69056475e-02f, -1.36720136e-01f, -1.28094435e-01f, 1.29648969e-01f, -1.09089844e-01f, -1.86745644e-01f, 3.05755049e-01f,
  1.77427545e-01f, 3.31984200e-02f, -4.18942086e-02f, -4.22089994e-02f, 2.71078642e-03f, -1.64298862e-01f, -1.78018421e-01f, 4.96490411e-02f, -3.19839478e-01f, 5.05258977e-01f,
  2.49775440e-01f, -1.30096167e-01f, 3.72588605e-01f, 2.40672939e-02f, -2.26857617e-01f, -3.99084121e-01f, -6.39715552e-01f, -3.01269323e-01f, 6.01997562e-02f, -4.33880426e-02f,
  -1.33552521e-01f, -1.10933930e-01f, -1.32362247e-01f, -1.22730456e-01f, -2.01498210e-01f, -9.78690088e-02f, -3.66893560e-02f, 2.46612459e-01f, -1.29965022e-01f, -3.24015677e-01f,
  -3.56042504e-01f, -2.76742820e-02f, 3.94603252e-01f, 2.55095303e-01f, 3.46231401e-01f, -8.92061889e-02f, 3.67989063e-01f, 3.56444836e-01f, 1.21475399e-01f, 3.54330778e-01f,
  2.82182187e-01f, 4.93122667e-01f, -3.76943380e-01f, -2.22832151e-02f, 1.02211632e-01f, -7.47818733e-03f, -1.73621267e-01f, 3.49390775e-01f, -5.20203976e-05f, 2.03096330e-01f,
  -1.22158043e-01f, 1.22431576e-01f, -1.51336923e-01f, -1.10727467e-01f, -8.36405829e-02f, -1.63829520e-01f, 1.48171648e-01f, 1.81291729e-01f, 3.20919491e-02f, 9.40749049e-02f,
  -5.12986124e-01f, -9.01581440e-03f, 1.38780102e-01f, -9.68886316e-02f, 2.62743056e-01f, -1.67355955e-01f, 1.07814781e-01f, 2.40675896e-01f, 1.58998936e-01f, 2.36149654e-01f,
  1.17612325e-01f, 8.73960108e-02f, -4.93592545e-02f, 1.03592284e-01f, -1.24524273e-01f, -8.96292031e-02f, 1.19813129e-01f, -2.22146034e-01f, -5.78951044e-03f, 7.61308372e-02f,
  -2.19430542e-03f, -1.64036620e-02f, 1.49195082e-02f, -3.93348970e-02f, -3.63226384e-02f, 9.80454311e-03f, -9.72150192e-02f, -3.82610671e-02f, 1.39669493e-01f, 3.20981406e-02f,
  -1.01962768e-01f, 3.86788137e-02f, 1.49683565e-01f, 8.90625268e-03f, 1.41969353e-01f, 7.90188238e-02f, 6.52892143e-02f, 2.21229158e-02f, 6.74125403e-02f, 2.13384368e-02f,
  -4.86135542e-01f, -3.14590871e-01f, -1.89938769e-01f, 4.13038917e-02f, -4.40998971e-02f, 8.35756361e-02f, -1.00638151e-01f, -1.13268534e-03f, 3.38629819e-02f, -1.31588325e-01f,
  -1.63021728e-01f, -9.25296172e-02f, -1.23171173e-01f, -4.87550795e-02f, -3.90655011e-01f, -1.29729331e-01f, -3.52734625e-01f, -3.86748493e-01f, -2.31891870e-01f, -3.80865633e-02f,
  -2.41358995e-01f, -4.76883292e-01f, -5.14316201e-01f, -4.02479291e-01f, -1.72215030e-01f, -4.13044989e-01f, -3.58136326e-01f, -3.73304367e-01f, -4.36216950e-01f, -5.12302697e-01f,
  -7.50061870e-01f, -1.32615760e-01f, -6.62118495e-01f, -1.76064059e-01f, 3.85296792e-01f, 1.98729947e-01f, 1.31928533e-01f, 1.00644164e-01f, -5.25832213e-02f, -2.87334353e-01f,
  1.11033805e-01f, 4.00975525e-01f, -1.52615204e-01f, 1.24003232e-01f, -9.20712352e-02f, -1.45617053e-01f, -1.45773724e-01f, -2.32097208e-01f, 1.49017856e-01f, 6.99629843e-01f,
  6.76090717e-01f, 1.48744345e-01f, -2.25000054e-01f, 1.06412433e-01f, 1.36855498e-01f, 3.20167691e-02f, -2.16698423e-01f, -9.13567171e-02f, 1.40725337e-02f, -2.83214618e-02f,
  -5.56941807e-01f, -5.05440116e-01f, 1.03684440e-01f, 2.48389661e-01f, -2.95883622e-02f, -3.80189955e-01f, -2.46238783e-02f, -2.47561336e-01f, 4.62389737e-02f, -2.27823734e-01f,
  -1.76036209e-02f, -1.85040813e-02f, 1.43120229e-01f, 8.32347199e-02f, -1.42104954e-01f, -6.45327717e-02f, -2.81720281e-01f, -4.56519276e-01f, -4.68437821e-01f, -1.29583448e-01f,
  5.72919905e-01f, 1.83913648e-01f, -4.78107423e-01f, -1.82360306e-01f, -1.57012448e-01f, -1.75908968e-01f, -1.71810836e-01f, 7.79673308e-02f, -4.17442054e-01f, -3.41029793e-01f,
  1.04251672e-02f, -1.26224756e-02f, 1.61981117e-02f, -1.95633788e-02f, 5.11340126e-02f, -7.98092857e-02f, 6.74917251e-02f, 1.99775100e-01f, 4.27335575e-02f, -1.31805003e-01f,
  6.76468238e-02f, -1.50759399e-01f, 2.24649962e-02f, -1.94263868e-02f, 8.64896849e-02f, -1.61460545e-02f, 2.18609311e-02f, 6.70085922e-02f, 6.72444999e-02f, -1.62326321e-02f,
  -5.03853783e-02f, -1.16728574e-01f, -3.07776090e-02f, 9.48366970e-02f, -1.31346837e-01f, -2.70984955e-02f, -6.92623183e-02f, 3.01683359e-02f, -1.81088690e-02f, -5.14307432e-02f,
  -2.25595966e-01f, -3.04368865e-02f, -3.34855229e-01f, 3.87285687e-02f, -4.92437370e-02f, 3.34231555e-02f, -2.02562995e-02f, 8.79027098e-02f, -1.66649327e-01f, -2.74895132e-01f,
  -8.00464898e-02f, -1.04282247e-02f, -1.46209210e-01f, -7.64804855e-02f, -1.30233958e-01f, -2.24002376e-01f, 5.81892356e-02f, -1.61057651e-01f, -1.72949415e-02f, 6.39584959e-02f,
  -9.17653590e-02f, -2.35853307e-02f, -3.90907884e-01f, -3.33478540e-01f, -1.80716310e-02f, -1.99739516e-01f, -1.96147949e-01f, -1.11634880e-01f, -3.19256842e-01f, -5.64908028e-01f,
  -2.64045656e-01f, 3.97348315e-01f, -4.74792682e-02f, -2.61797667e-01f, -2.84693092e-01f, -5.11687249e-02f, 2.30330467e-01f, -6.24843128e-02f, -1.54448569e-01f, -1.11775165e-02f,
  -1.52217627e-01f, -1.96489677e-01f, -4.98734079e-02f, 7.50164166e-02f, 3.04892272e-01f, 4.29165721e-01f, 4.01138425e-01f, 1.10832050e-01f, -1.45465657e-01f, 4.40671593e-02f,
  1.03993535e-01f, 1.27887176e-02f, -8.81339237e-02f, 3.47789414e-02f, 1.44090652e-01f, -8.36672112e-02f, -6.33832961e-02f, -1.65031850e-01f, 1.61510244e-01f, 5.06168067e-01f,
  -1.60268229e-02f, -1.94499806e-01f, -1.60698071e-01f, -1.69312328e-01f, -1.81580380e-01f, 2.08525479e-01f, 1.13897569e-01f, -8.27391297e-02f, 1.33206707e-03f, 2.33907223e-01f,
  -1.22399807e-01f, 9.53897834e-02f, -4.22067344e-02f, 1.84387743e-01f, -9.05853957e-02f, -6.21300377e-02f, 2.15973109e-01f, 1.91314965e-01f, 2.02224851e-01f, -1.38152894e-02f,
  2.06105858e-01f, -1.51886970e-01f, -4.77118015e-01f, 8.55778158e-02f, 1.09810889e-01f, -1.29247978e-01f, -2.10441619e-01f, 7.48412125e-03f, -1.10218063e-01f, 2.89853871e-01f,
  -1.55541569e-01f, -2.18103640e-02f, 8.92745480e-02f, 2.09268674e-01f, 2.35844135e-01f, -2.88275201e-02f, 3.55845876e-02f, 7.93144926e-02f, 1.07005268e-01f, 1.43751413e-01f,
  -3.22406627e-02f, -1.17645591e-01f, -7.01573491e-02f, -1.22427523e-01f, -8.96348804e-02f, 3.67934653e-03f, 2.13055328e-01f, 1.86610654e-01f, 6.49717897e-02f, 1.76094323e-02f,
  -3.22596729e-02f, 5.03322147e-02f, -1.86946154e-01f, 2.57107794e-01f, 6.02416843e-02f, -2.16175374e-02f, 1.84997752e-01f, -6.21416941e-02f, -1.47492215e-01f, -4.63185199e-02f,
  -2.72278398e-01f, -1.73378080e-01f, -1.50891133e-02f, 1.84330180e-01f, -1.35002388e-02f, -1.57172486e-01f, -1.18817136e-01f, -5.87206930e-02f, -1.27361089e-01f, 3.53291002e-03f,
  -3.89361521e-03f, -2.72199418e-02f, -9.49881896e-02f, 3.57216112e-02f, -2.74704456e-01f, -1.61571354e-01f, 1.03363544e-01f, 6.32980317e-02f, 9.92775559e-02f, -2.12469459e-01f,
  6.62690625e-02f, -1.23768568e-01f, -4.19948578e-01f, -5.36972061e-02f, -8.62838104e-02f, -2.93127239e-01f, -2.72212267e-01f, -2.23286822e-01f, -3.02468747e-01f, -1.78419873e-01f,
  -1.76058158e-01f, -2.42719412e-01f, -1.29666805e-01f, 3.42010498e-01f, 2.66018867e-01f, -4.33817506e-01f, -7.18208969e-01f, -4.34863359e-01f, 4.57862824e-01f, 7.39045590e-02f,
  2.48926103e-01f, 1.39452562e-01f, 9.64145884e-02f, -2.14334711e-01f, -5.59339762e-01f, -3.71574610e-01f, -5.91154136e-02f, -3.58846098e-01f, -4.69145983e-01f, -5.71249306e-01f,
  -1.60087943e-01f, 2.55075656e-02f, -1.14654295e-01f, -5.72634414e-02f, 5.91365635e-01f, 3.10986489e-01f, 3.29637766e-01f, 1.70893222e-01f, -7.74558187e-02f, 4.78307813e-01f,
  4.98386705e-03f, -1.51739776e-01f, -1.74178228e-01f, 1.94985926e-01f, 2.10312128e-01f, -1.37742504e-01f, -7.66451806e-02f, -3.66270877e-02f, -1.66222490e-02f, -1.55930631e-02f,
  3.00943911e-01f, -4.08580266e-02f, 6.18567914e-02f, 6.16111495e-02f, -3.96888331e-02f, -2.78310031e-01f, 1.90805607e-02f, -2.88147986e-01f, -2.91873962e-01f, -6.89452738e-02f,
  1.32547962e-02f, -1.56448800e-02f, -2.59087592e-01f, -2.58771360e-01f, -1.39907062e-01f, 1.42045721e-01f, -1.19406536e-01f, 1.84662640e-02f, -1.32409602e-01f, 1.33173123e-01f,
  7.73465261e-03f, 1.04152318e-03f, 1.42361447e-01f, 2.31361203e-02f, 1.12408899e-01f, 1.39276341e-01f, 1.03166200e-01f, -1.32414531e-02f, -5.23606166e-02f, -6.54273434e-03f,
  -9.17806104e-02f, -3.86913158e-02f, -7.76465684e-02f, -1.47443354e-01f, -7.80717731e-02f, 6.31340370e-02f, -1.19177260e-01f, -5.45968339e-02f, -2.07331285e-01f, -4.24806681e-03f,
  -5.50613226e-03f, -1.38877496e-01f, 1.97126538e-01f, -8.30990896e-02f, 9.09571201e-02f, -2.65404694e-02f, 1.02531552e-01f, 3.08740828e-02f, -5.14375120e-02f, 1.52219795e-02f,
  1.27818719e-01f, -2.60906219e-01f, 3.26229818e-02f, -2.47366458e-01f, 1.40712842e-01f, 1.95697844e-01f, 1.26880139e-01f, -1.02770902e-01f, 1.31222501e-01f, -1.65662989e-01f,
  -2.06282139e-01f, -4.29346934e-02f, 1.32799298e-01f, -8.54369998e-02f, -1.15115844e-01f, -3.85097191e-02f, -1.81689084e-01f, 2.03503426e-02f, -2.16718987e-01f, 1.39009789e-01f,
  -4.12915088e-03f, -3.47869635e-01f, -2.69566655e-01f, -7.50103295e-02f, 5.43271117e-02f, -1.51887909e-01f, -2.09404334e-01f, -1.85828701e-01f, -3.63754421e-01f, -2.96161979e-01f,
  -9.31006894e-02f, -2.24912435e-01f, -1.75989911e-01f, 3.26391190e-01f, 3.75248402e-01f, 3.40762109e-01f, 3.20414722e-01f, 3.25530529e-01f, 3.66358846e-01f, 1.83646873e-01f,
  1.65160239e-01f, 2.69776553e-01f, 2.61311740e-01f, 1.91087127e-01f, 2.75936723e-01f, 2.70053595e-01f, 2.26623982e-01f, 8.82907882e-02f, 1.04516074e-01f, 1.49586424e-01f,
  3.54530901e-01f, 6.23954348e-02f, -1.32415697e-01f, 8.33924711e-02f, 5.47198905e-03f, 1.52089223e-01f, 7.19422698e-02f, -7.72327790e-03f, -1.03652664e-01f, -7.15411529e-02f,
  -5.60393155e-01f, -2.32251436e-01f, 1.11898929e-01f, -6.76613003e-02f, -1.87988788e-01f, -8.62134174e-02f, -1.87424533e-02f, -9.67142433e-02f, 3.28785069e-02f, 8.64309072e-02f,
  1.85158337e-03f, -1.69342697e-01f, -1.26189902e-01f, -1.14094302e-01f, -1.79164726e-02f, -2.36544963e-02f, -4.19690944e-02f, 8.94939527e-02f, 4.94448543e-02f, -6.67337626e-02f,
  -1.27950519e-01f, -1.02474969e-02f, 1.00523740e-01f, 1.60676092e-01f, 1.19955607e-01f, 4.35236320e-02f, -1.12021334e-01f, -4.38405722e-02f, 1.81950815e-02f, 1.58501104e-01f,
  2.32847288e-01f, 5.89129329e-02f, -1.00839496e-01f, 5.75802997e-02f, 8.41825083e-02f, 3.97476368e-02f, -2.56264769e-02f, 9.79809389e-02f, 1.74860418e-01f, 6.96970224e-02f,
  3.12532783e-02f, 4.63390909e-02f, 6.26127943e-02f, 2.42304634e-02f, -1.05354562e-01f, -9.90703702e-02f, -9.54965875e-02f, -1.67200506e-01f, -2.83941358e-01f, -8.44977573e-02f,
  3.73262935e-03f, -6.65220544e-02f, -2.28375256e-01f, -2.50084758e-01f, -1.06023215e-01f, -5.71268760e-02f, 1.41550675e-02f, 3.18585075e-02f, 7.20104873e-02f, -1.58539712e-02f,
  2.57336527e-01f, -1.81061178e-01f, 4.24019760e-03f, -2.21512839e-02f, -3.39149609e-02f, -2.77310878e-01f, -1.31515786e-01f, -8.02754089e-02f, -6.99051097e-02f, -1.88252963e-02f,
  -1.15163796e-01f, -1.81593120e-01f, -1.20415449e-01f, -4.07877788e-02f, 7.41033703e-02f, -9.78376418e-02f, -4.47066762e-02f, 9.93810967e-02f, -4.55545634e-02f, -7.42326900e-02f,
  3.43482047e-02f, 1.31115109e-01f, 1.97213352e-01f, 2.25170031e-01f, 1.21613406e-01f, 9.56529379e-02f, 4.57695462e-02f, -3.12160235e-02f, 1.49271917e-02f, 1.35495543e-01f,
  6.80241048e-01f, 5.34088135e-01f, 4.08225924e-01f, 2.10924327e-01f, -4.39402461e-02f, 4.43437807e-02f, 2.57249981e-01f, 6.57480285e-02f, -7.25089982e-02f, 6.69855326e-02f,
  -3.94071713e-02f, -3.32310379e-01f, -2.66956568e-01f, -1.42116189e-01f, 1.29013777e-01f, 2.27505639e-01f, 1.46580845e-01f, 1.98241353e-01f, 2.90866867e-02f, 1.13074414e-01f,
  -2.01631952e-02f, 1.15126848e-01f, 8.18386972e-02f, 4.21114154e-02f, 8.23298618e-02f, -1.94910258e-01f, 4.09335382e-02f, 1.18340194e-01f, 1.69168442e-01f, 2.55859524e-01f,
  2.53471881e-01f, 2.82542199e-01f, -3.36822420e-01f, -1.18553899e-01f, 5.97589649e-02f, -1.10850140e-01f, -1.51153021e-02f, -7.83986449e-02f, -5.18903285e-02f, -3.94580513e-02f,
  -2.96593457e-03f, 1.21223982e-02f, -7.87358359e-02f, -1.03390388e-01f, 6.91431807e-04f, -8.94397497e-03f, -5.21596037e-02f, -3.27314064e-02f, -1.29896449e-02f, -3.20616849e-02f,
  -7.12014660e-02f, 9.36087817e-02f, 1.42106652e-01f, -6.22673184e-02f, 1.24113886e-02f, -2.34854296e-01f, -4.40012738e-02f, 9.38289762e-02f, -8.97786170e-02f, 1.67750373e-01f,
  -4.53621209e-01f, 1.01918608e-01f, 1.04092561e-01f, -1.76052526e-01f, -7.26165697e-02f, -1.68004930e-01f, 5.60455816e-03f, 3.93032692e-02f, 4.18789200e-02f, -1.24053331e-03f,
  -9.77557227e-02f, -8.84364732e-03f, -3.93538699e-02f, -2.88680121e-02f, -1.34297460e-01f, 6.44298643e-02f, 4.88481484e-02f, -2.47346945e-02f, -1.22961670e-01f, -7.98265934e-02f,
  -4.38553020e-02f, 4.56878133e-02f, -1.06260695e-01f, 6.26998618e-02f, -1.55010641e-01f, -9.77377966e-02f, -1.09869711e-01f, -8.85930136e-02f, -1.87313288e-01f, -2.33666629e-01f,
  -3.20186317e-01f, -2.68881619e-01f, -1.34374052e-01f, 2.78598182e-02f, 2.47092143e-01f, -4.21522446e-02f, -1.32719437e-02f, -1.00135272e-02f, -1.51175871e-01f, 1.58241708e-02f,
  4.59831469e-02f, 9.27634072e-03f, 4.41780388e-02f, 7.44676730e-03f, -7.85234943e-02f, -1.67955473e-01f, -3.95831428e-02f, -1.14849210e-02f, -1.33028880e-01f, -3.95444371e-02f,
  -1.37599170e-01f, -3.12694795e-02f, -1.59988925e-01f, -1.65505335e-01f, -2.32254699e-01f, -3.17515671e-01f, -2.51670450e-01f, -1.53679587e-02f, -6.64997995e-02f, -2.04366505e-01f,
  -7.30580807e-01f, -3.28877628e-01f, -2.08062336e-01f, -6.08679056e-01f, 8.58897567e-02f, 2.83759803e-01f, 2.12733954e-01f, 1.19641475e-01f, -3.04564208e-01f, -3.30774397e-01f,
  -2.71770675e-02f, -2.45625991e-02f, -2.55785912e-01f, 1.85309991e-01f, 2.21864998e-01f, -2.44804278e-01f, -1.20808974e-01f, 5.58990836e-02f, 5.03203750e-01f, 5.82802355e-01f,
  2.12474883e-01f, -5.73487952e-02f, -1.36641890e-01f, 4.99000959e-02f, -3.24473798e-01f, -1.45942301e-01f, -3.70089054e-01f, -2.40140557e-01f, 5.03497683e-02f, -3.73243898e-01f,
  -4.79868829e-01f, -1.61938801e-01f, 3.04064900e-01f, 1.75349012e-01f, -1.34702846e-01f, -2.99385469e-02f, -2.21427111e-03f, -1.48544922e-01f, 2.24476471e-03f, -1.09563775e-01f,
  -1.07982598e-01f, 1.48030579e-01f, -3.71507965e-02f, 2.81527173e-02f, -3.09356931e-03f, 1.66155174e-01f, 7.16420114e-02f, 3.81809846e-02f, -1.68803558e-01f, -1.11618433e-02f,
  1.61029603e-02f, -1.52892724e-01f, -2.92949408e-01f, 2.03591183e-01f, 2.66176045e-01f, 1.23529686e-02f, 1.02787547e-01f, 1.96034849e-01f, 1.16587959e-01f, -4.64989454e-01f,
  4.44012135e-02f, -4.32465151e-02f, 2.58110285e-01f, 4.48186807e-02f, -1.07116863e-01f, -8.51403177e-02f, -1.55171692e-01f, 3.58458161e-02f, 1.55218661e-01f, 1.58622582e-02f,
  1.09943092e-01f, 2.51162052e-02f, 1.38534129e-01f, -1.39586642e-01f, -6.96497187e-02f, -1.96074009e-01f, -9.43522155e-02f, 3.89464498e-02f, -8.66975635e-02f, -3.32343243e-02f,
  5.56766205e-02f, -9.98328999e-02f, -3.35533991e-02f, 4.58015390e-02f, 1.87223524e-01f, -6.72767237e-02f, 1.60062760e-02f, 2.47912571e-01f, 4.01176000e-03f, -3.73869911e-02f,
  -4.43878740e-01f, 3.61830950e-01f, -4.86291617e-01f, 2.25821719e-01f, -1.16559446e-01f, -3.58935189e-03f, -8.46697688e-02f, 1.68181285e-01f, -1.30348638e-01f, 6.07962422e-02f,
  2.48123914e-01f, -7.92707056e-02f, -2.41935194e-01f, 1.90330312e-01f, 2.41918817e-01f, 1.24402665e-01f, -4.85614948e-02f, -1.86532944e-01f, 1.43700197e-01f, -1.03002243e-01f,
  -2.46207393e-03f, -1.53401896e-01f, -3.14612895e-01f, -8.92702416e-02f, -4.39279042e-02f, -6.04824945e-02f, -8.70065317e-02f, 5.82395382e-02f, -1.19105846e-01f, -4.82339650e-01f,
  9.34407711e-01f, -6.23677909e-01f, -7.75789499e-01f, 2.20580831e-01f, 3.15761805e-01f, -1.40553538e-03f, -5.14700532e-01f, -3.13819289e-01f, 1.25431493e-01f, -1.28753006e-01f,
  2.50437766e-01f, 5.95270038e-01f, 1.04587026e-01f, 1.92107886e-01f, -2.00794652e-01f, -6.07231498e-01f, -5.70485711e-01f, -7.87443593e-02f, 3.56584400e-01f, 6.21509671e-01f,
  3.02398622e-01f, 1.20353460e-01f, 2.97604769e-01f, -1.13879874e-01f, -8.86135101e-02f, 2.37504944e-01f, -4.75239426e-01f, 1.35063147e-02f, -1.54926777e-01f, -7.70128742e-02f,
  6.45207614e-02f, -2.10517973e-01f, -3.67809599e-03f, 3.85337561e-01f, 1.29575327e-01f, -1.12614125e-01f, -6.45319447e-02f, -1.84159517e-01f, 1.59788920e-04f, -1.63563013e-01f,
  1.20046310e-01f, -2.27923691e-02f, 7.71962479e-02f, -1.20722279e-01f, -9.39029381e-02f, -2.03647558e-03f, -2.88885117e-01f, -3.56878757e-01f, -4.05004740e-01f, 2.19802447e-02f,
  3.24982107e-01f, 5.32008886e-01f, -5.19678369e-02f, -4.10174161e-01f, -4.91816372e-01f, 1.31178036e-01f, -3.79019320e-01f, -1.81455955e-01f, -3.78530741e-01f, -3.11585873e-01f,
  1.36577576e-01f, -4.13573049e-02f, -1.15579419e-01f, -1.04923375e-01f, 6.04915023e-02f, 5.20316400e-02f, -5.25851287e-02f, 1.20043837e-01f, 2.25177035e-02f, -2.66177915e-02f,
  -6.69201165e-02f, 7.16897324e-02f, -7.30964728e-03f, -1.04139395e-01f, -1.75239928e-02f, 5.36573604e-02f, 6.34596869e-02f, -1.50780201e-01f, 1.77856520e-01f, -6.61056563e-02f,
  1.26730070e-01f, -1.03688464e-01f, -6.22380972e-02f, -6.99554980e-02f, -9.64966118e-02f, -9.26279053e-02f, 4.54605483e-02f, 1.07945949e-01f, 1.16181724e-01f, 4.66063470e-02f,
  7.93189779e-02f, -9.33635309e-02f, -6.97276788e-03f, -2.64511425e-02f, 7.75622427e-02f, -2.26930603e-02f, -1.24616995e-01f, 5.27812764e-02f, -2.30311733e-02f, -7.52677862e-03f,
  -5.18252738e-02f, -1.29671082e-01f, -3.23632210e-01f, -2.43396565e-01f, 4.35650758e-02f, -1.64162237e-02f, 9.48081687e-02f, 2.99032182e-01f, -7.01742768e-02f, -1.11113191e-01f,
  -2.54509926e-01f, 1.62041008e-01f, 2.66744882e-01f, -1.04617536e-01f, 4.11112374e-03f, 3.13213766e-01f, -3.42310786e-01f, -1.53848201e-01f, -6.53347522e-02f, -4.03340638e-01f,
  -6.00856900e-01f, -1.55188531e-01f, 5.83003044e-01f, -4.14324611e-01f, -1.16506472e-01f, -6.30435497e-02f, -2.12396786e-01f, -9.90478694e-02f, 5.86082190e-02f, 2.42802926e-04f,
  -1.00618713e-01f, -2.51504153e-01f, 1.28109723e-01f, -2.10093334e-02f, -3.97026762e-02f, 2.59104043e-01f, 2.38171443e-01f, -2.01390628e-02f, -3.73574466e-01f, -5.71272016e-01f,
  -3.78981590e-01f, -3.44501495e-01f, -2.64301002e-01f, -5.97782917e-02f, -3.13877352e-02f, -1.69771299e-01f, 3.34893256e-01f, -9.23741236e-03f, -2.20523812e-02f, -6.40824214e-02f,
  2.01926991e-01f, -1.25680238e-01f, 9.00202245e-02f, -2.46439978e-01f, 1.37002483e-01f, -1.16311081e-01f, -9.73280817e-02f, 2.49550492e-01f, -9.50623304e-03f, 6.50821701e-02f,
  -6.09282516e-02f, -1.51191667e-01f, -8.53460208e-02f, -3.61232646e-02f, -1.26868173e-01f, -8.85838047e-02f, 2.36277670e-01f, 7.92537630e-03f, 1.83387041e-01f, 5.95746785e-02f,
  -4.46930200e-01f, -4.72764730e-01f, -1.26637965e-01f, 8.16459488e-03f, 1.84260845e-01f, -6.62913844e-02f, -1.53228536e-01f, -2.18913719e-01f, 2.99307574e-02f, -2.40285143e-01f,
  1.45140737e-02f, 6.39868155e-02f, 7.54985735e-02f, -7.64130652e-02f, -1.15157254e-01f, 9.25222486e-02f, 4.47771810e-02f, -9.30495933e-02f, 1.32058887e-03f, -8.32814798e-02f,
  1.30587846e-01f, 1.17879741e-01f, 1.17931329e-01f, 1.37917623e-01f, 9.11555588e-02f, -2.84722913e-02f, -7.26094991e-02f, -2.20747143e-02f, 3.74507159e-03f, -7.09863529e-02f,
  -9.71517786e-02f, -1.42435534e-02f, -7.95028582e-02f, 4.50194143e-02f, 9.05947909e-02f, 1.34875938e-01f, 3.44016552e-02f, -9.57570449e-02f, 6.78924918e-02f, 8.33652020e-02f,
  -2.65425835e-02f, 2.45584026e-01f, -7.84111544e-02f, -1.78950787e-01f, 2.85432499e-04f, 4.96201403e-02f, -3.44617777e-02f, 1.37762591e-01f, -6.64142072e-02f, -9.24395025e-02f,
  -8.32531676e-02f, -1.04937054e-01f, 1.03741318e-01f, 4.18288261e-02f, -1.29637182e-01f, -4.95556593e-02f, -6.80968985e-02f, -1.26812652e-01f, -5.43472134e-02f, -5.12292050e-02f,
  4.06822236e-03f, -4.28248644e-01f, -3.89643818e-01f, -1.44930974e-01f, -2.34540507e-01f, -3.41988415e-01f, -2.52258092e-01f, -3.46753448e-01f, -1.35333642e-01f, -3.54052603e-01f,
  2.26159275e-01f, 2.06995066e-02f, -2.07686171e-01f, -3.85752344e-03f, -3.18459451e-01f, -5.12681961e-01f, -5.17669857e-01f, -3.69713336e-01f, -3.63520384e-02f, -2.18744755e-01f,
  -2.79289424e-01f, 2.07209587e-03f, 3.25477660e-01f, -1.04473285e-01f, -2.90976644e-01f, -3.75711888e-01f, -3.23478609e-01f, -2.10220709e-01f, -3.58187348e-01f, -6.06809556e-01f,
  -3.90496314e-01f, -6.98110908e-02f, 1.70894265e-02f, 4.05802317e-02f, 1.70992523e-01f, 8.84362087e-02f, 6.02742247e-02f, 1.39648877e-02f, -2.46087179e-01f, -2.10466445e-04f,
  2.12097958e-01f, -2.02296436e-01f, -5.80170043e-02f, 3.34274881e-02f, 1.75882071e-01f, 7.52786770e-02f, 6.36271164e-02f, 1.65463448e-01f, 1.49291635e-01f, 9.46967304e-02f,
  -4.37938273e-02f, -7.32101351e-02f, 9.55936313e-02f, -1.84488874e-02f, -1.61508262e-01f, -9.89680514e-02f, -1.42763257e-01f, -1.27745137e-01f, 4.13041189e-03f, -2.39156373e-02f,
  -1.10270433e-01f, -2.68060327e-01f, 3.40698883e-02f, -1.26766011e-01f, -1.33822292e-01f, -5.99990226e-02f, 3.65363108e-03f, -1.53391600e-01f, -6.61452264e-02f, 2.07080439e-01f,
  -8.54543149e-02f, 2.04257876e-01f, 2.58726757e-02f, 5.36926417e-03f, 3.07393819e-02f, 1.78018153e-01f, 1.01068445e-01f, 7.08829686e-02f, 4.94598001e-02f, 4.90984879e-02f,
  4.15385189e-03f, -6.24390543e-02f, 9.05620828e-02f, 1.55576505e-02f, 2.70944312e-02f, 8.75336677e-02f, 6.68628812e-02f, 5.68847321e-02f, 1.63084939e-01f, 1.06480375e-01f,
  -4.56847399e-02f, 4.43127640e-02f, 1.15999028e-01f, 2.92458124e-02f, -1.17967516e-01f, 7.13309795e-02f, -8.24182853e-02f, -2.62059551e-02f, -6.81774169e-02f, -1.15384266e-01f,
  3.18825454e-01f, -1.65375471e-01f, 2.42470145e-01f, -5.21886125e-02f, -3.80293909e-03f, 3.18843536e-02f, 1.03016652e-01f, 1.21128805e-01f, 2.27969751e-01f, 1.23038143e-01f,
  -8.15788805e-02f, 2.66527403e-02f, 9.34796557e-02f, 4.05402631e-02f, -4.90512624e-02f, -1.94055796e-01f, -6.84113652e-02f, 8.75104889e-02f, 6.46838024e-02f, -6.99202269e-02f,
  5.63214011e-02f, -7.46312737e-02f, 1.16377391e-01f, 1.97930381e-01f, 7.18758479e-02f, 5.17240651e-02f, 1.52617022e-01f, 6.94790408e-02f, -2.68664863e-02f, 3.42219979e-01f,
  -7.71559596e-01f, -2.76569158e-01f, 5.77113628e-01f, -5.19652188e-01f, 9.59554280e-04f, -2.06264302e-01f, -5.40270388e-01f, -5.60176551e-01f, -2.72089332e-01f, -5.09428859e-01f,
  -3.86094078e-02f, 4.45890784e-01f, 3.69945556e-01f, 9.09321234e-02f, -5.38142204e-01f, -8.02028894e-01f, -5.53176880e-01f, 6.15119077e-02f, 3.11653465e-01f, -1.26362935e-01f,
  -1.54767603e-01f, 3.33884917e-02f, -2.99806911e-02f, 1.81571431e-02f, 1.32968187e-01f, 3.61001343e-01f, 2.86829114e-01f, 1.06911130e-01f, 7.97035918e-03f, -3.13828550e-02f,
  2.80764878e-01f, -2.67959744e-01f, 6.66072667e-02f, -1.38750866e-01f, 4.25909534e-02f, -1.25610024e-01f, -1.09974615e-01f, -6.13016225e-02f, -1.46834135e-01f, -1.82846077e-02f,
  1.02567427e-01f, -8.55623782e-02f, 1.02405682e-01f, 1.46218926e-01f, -1.37003675e-01f, -4.03270535e-02f, -5.19132474e-03f, -4.29185852e-02f, -1.41828477e-01f, 7.11279586e-02f,
  -7.09266663e-02f, -2.32000694e-01f, 6.74707219e-02f, 1.21864844e-02f, -4.56001200e-02f, 2.66075671e-01f, 3.85150641e-01f, 1.70424819e-01f, 6.07137419e-02f, -1.10323556e-01f,
  -4.67349403e-02f, 1.26954556e-01f, -4.72289808e-02f, 1.06003262e-01f, 1.89123508e-02f, -2.20442470e-02f, -7.71230236e-02f, -9.88597572e-02f, 1.55234402e-02f, 7.54142106e-02f,
  -2.49125529e-02f, -9.85385403e-02f, 8.13159645e-02f, -2.12517649e-01f, 1.08373821e-01f, 6.28384501e-02f, -2.70936992e-02f, -1.06157519e-01f, -1.99762098e-02f, -8.21338072e-02f,
  -8.94362666e-03f, 2.56926324e-02f, 1.19997837e-01f, -1.02836415e-01f, -1.62232161e-01f, -7.72001445e-02f, -2.22415663e-02f, 2.21479535e-01f, 8.40423331e-02f, -3.43838427e-03f,
  2.52170265e-01f, -4.72429916e-02f, -2.08465576e-01f, -2.02208087e-02f, -1.98157206e-01f, 1.32375658e-01f, -1.43744089e-02f, -1.45366341e-01f, 6.64217547e-02f, 7.73120970e-02f,
  -5.14825843e-02f, -7.49664232e-02f, -5.11293337e-02f, 1.63340509e-01f, -5.15868142e-02f, 1.91033557e-01f, -3.34161937e-01f, 1.09044001e-01f, -1.16686642e-01f, 5.85127957e-02f,
  -1.65499270e-01f, -4.75376666e-01f, -1.24869168e-01f, -3.83952782e-02f, -5.34423962e-02f, 6.64780801e-03f, 3.48780841e-01f, 3.18723857e-01f, -2.62992352e-01f, -2.90595561e-01f,
  -5.09778142e-01f, 1.10832848e-01f, 2.61154860e-01f, -3.64261568e-02f, -1.16972335e-01f, -1.70639843e-01f, -2.03426793e-01f, -1.33003309e-01f, -3.15928683e-02f, 5.81571832e-02f,
  -2.97775492e-02f, 7.13344216e-02f, 5.21301888e-02f, 8.47195759e-02f, 7.89890364e-02f, 3.31136361e-02f, 2.18167663e-01f, 3.56265083e-02f, -6.34100139e-02f, -6.98694494e-04f,
  4.87257764e-02f, 2.68063154e-02f, -6.06491752e-02f, 1.42715514e-01f, 1.82858318e-01f, 9.95904729e-02f, 1.94348559e-01f, 1.31675139e-01f, 1.50250137e-01f, 3.36727381e-01f,
  6.00671351e-01f, -9.41967145e-02f, -5.49545251e-02f, -7.06101581e-02f, 1.37882605e-01f, -7.26074306e-03f, 6.05882630e-02f, 7.44947195e-02f, 8.88462290e-02f, 8.33202153e-02f,
  9.75205749e-02f, 6.48421869e-02f, 2.28714608e-02f, 1.09988093e-01f, 1.93466172e-01f, 6.59508482e-02f, 2.09223181e-02f, 4.60308120e-02f, -1.57386567e-02f, 1.34707794e-01f,
  4.29801531e-02f, 1.57751944e-02f, -7.37732202e-02f, -3.05549055e-02f, -1.73289016e-01f, 2.38803541e-03f, 6.96201473e-02f, -1.00501560e-01f, -1.06388375e-01f, 1.67371123e-03f,
  -9.59309191e-02f, -6.71851411e-02f, 2.45863367e-02f, -9.56840962e-02f, -1.01998508e-01f, -3.45445871e-02f, -1.85492809e-03f, -8.72708261e-02f, -1.57678604e-01f, -7.43845478e-02f,
  -2.07749400e-02f, -8.41662586e-02f, -4.88116816e-02f, -1.79130044e-02f, 1.11149997e-01f, 7.16109527e-03f, -4.73636203e-02f, 1.06680401e-01f, 1.03920370e-01f, -4.27993201e-02f,
  -8.03328305e-02f, 3.51302177e-02f, 1.74150720e-01f, 4.21293378e-02f, 5.62920421e-02f, -2.52873190e-02f, -2.66470276e-02f, -3.23591083e-02f, 1.46781415e-01f, -7.82530233e-02f,
  4.09354210e-01f, -1.77585185e-01f, -8.40540417e-03f, -5.78943640e-02f, -6.26554573e-03f, 8.79992545e-02f, 1.15278950e-02f, 1.20162159e-01f, 7.04414323e-02f, 1.34060428e-01f,
  7.20787793e-02f, 1.56328112e-01f, 6.65119514e-02f, 6.07764833e-02f, 5.91214597e-02f, -3.54822818e-03f, -4.20972332e-02f, -6.85606599e-02f, 1.06018692e-01f, 1.60432875e-01f,
  4.22128430e-03f, 5.41961100e-03f, 1.23193040e-01f, 6.72229752e-02f, -2.19533339e-01f, -3.94587927e-02f, 2.48261951e-02f, -6.11662818e-03f, 1.02421138e-02f, 4.57064062e-02f,
  2.72444904e-01f, -5.81865013e-01f, -4.78705436e-01f, -2.55899549e-01f, -2.85832912e-01f, -8.99518132e-02f, -3.07852268e-01f, -6.16605021e-02f, -1.16751626e-01f, -3.20685178e-01f,
  -8.40019956e-02f, 1.44075137e-02f, 4.67779152e-02f, 2.24700924e-02f, 1.36462778e-01f, -3.58585417e-01f, -3.84881765e-01f, -1.04332538e-02f, 2.86495626e-01f, 6.24231547e-02f,
  -2.28904355e-02f, -2.23619677e-02f, 1.36978522e-01f, 1.71969738e-02f, -3.71871740e-01f, -6.05118684e-02f, -2.70033091e-01f, -8.41414705e-02f, -1.48625121e-01f, -5.46164393e-01f,
  -1.94188759e-01f, 2.93339550e-01f, 6.67887628e-02f, 1.28515691e-01f, 6.68313950e-02f, -3.90668586e-02f, -3.88910919e-02f, 1.68335102e-02f, -4.11395282e-02f, -2.12011300e-02f,
  8.60829130e-02f, -3.83023024e-02f, 1.33878365e-01f, 7.21840933e-02f, -6.93145022e-02f, 4.43743728e-02f, 2.15670690e-01f, 1.54812470e-01f, -2.26730742e-02f, 3.33302352e-03f,
  -8.60149115e-02f, 8.17164313e-03f, 1.90488845e-02f, 2.21268266e-01f, 1.79441065e-01f, 9.07153115e-02f, 1.23088926e-01f, 1.92709118e-01f, 1.70234710e-01f, 2.48727482e-02f,
  -1.56304687e-01f, -5.09916879e-02f, 8.84649158e-02f, 2.23190725e-01f, 1.46210983e-01f, -8.21095891e-03f, 1.64155755e-02f, 9.71784070e-02f, 1.36810973e-01f, 1.04597233e-01f,
  -1.13543205e-01f, -1.45679740e-02f, 1.57493785e-01f, 3.56770889e-03f, -6.85092360e-02f, -9.94379167e-03f, 3.41400504e-02f, 1.05529681e-01f, 1.09453619e-01f, -5.00785820e-02f,
  1.03735931e-01f, -7.34740542e-03f, -1.97217882e-01f, -1.46260411e-02f, 2.93149725e-02f, -5.81315942e-02f, -6.05315231e-02f, 7.44931102e-02f, -8.42771605e-02f, -7.86457583e-02f,
  7.07464516e-02f, 5.18654585e-01f, -6.77368715e-02f, 1.53633887e-02f, -2.20206790e-02f, -9.03377831e-02f, -1.41120190e-02f, -1.51544986e-02f, -1.02883041e-01f, 4.17641029e-02f,
  3.79441008e-02f, 7.33869895e-02f, 4.43548821e-02f, 1.35846883e-01f, 8.80156085e-02f, 7.38949254e-02f, 1.12023465e-01f, 8.27494189e-02f, -9.21184104e-03f, -9.35133621e-02f,
  -1.70484617e-01f, 2.68865805e-02f, 1.21974789e-01f, 5.73078878e-02f, 2.12080777e-01f, 6.45263270e-02f, -3.28600630e-02f, 4.19941172e-02f, 3.17477137e-02f, 9.06331744e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.64108169e-01f, 1.65689483e-01f, 3.61926347e-01f, 1.65041909e-01f, 8.43111932e-01f, 2.39463314e-01f, 5.07903099e-01f, 3.08104932e-01f, 5.28674185e-01f, 7.97907591e-01f,
  4.54057246e-01f, 3.22895497e-02f, 6.71420872e-01f, 4.71244276e-01f, 5.44370770e-01f, 5.76051295e-01f, 7.75433660e-01f, 2.60005504e-01f, 3.04742813e-01f, 6.52412713e-01f,
  1.37524918e-01f, 6.18200004e-01f, 6.74026370e-01f, 3.66163135e-01f, 1.37718376e-02f, 5.54808617e-01f, 8.81482840e-01f, 3.89507234e-01f, 3.17078888e-01f, 2.00964972e-01f,
  6.19410634e-01f, 3.90557915e-01f, 6.09254241e-01f, 4.86699075e-01f, 9.78205860e-01f, 8.51909518e-01f, 4.63008434e-01f, 2.74145365e-01f, 4.99774218e-01f, 6.00703955e-01f,
  1.53540120e-01f, 4.09302294e-01f, 2.34215736e-01f, 3.23742807e-01f, 4.02680576e-01f, 1.81862548e-01f, 4.22609746e-01f, 2.07401246e-01f, 4.09017026e-01f, 6.59823954e-01f,
  2.47283638e-01f, 1.26744471e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.65899858e-01f, -9.54006612e-02f, -7.00708404e-02f, -2.86082178e-01f, -3.52314487e-02f, -4.73508313e-02f, 2.03062408e-03f, -1.01235949e-01f, -5.10078296e-02f, -9.93287098e-03f,
  -5.19953333e-02f, -5.71750626e-02f, 2.66879350e-01f, 1.78528205e-01f, -8.35061073e-01f, -3.46941113e-01f, -3.19159657e-01f, 1.45280898e-01f, 9.92843360e-02f, -1.34231165e-01f,
  -3.21718007e-01f, -7.92614043e-01f, -2.73802459e-01f, 3.47446501e-01f, -6.56303048e-01f, -3.92204165e-01f, 1.98839620e-01f, -1.84327755e-02f, 1.08660161e-01f, -2.29622528e-01f,
  -5.44403970e-01f, -3.39119226e-01f, 5.51131815e-02f, 2.13366210e-01f, 3.54805112e-01f, -4.84954625e-01f, 2.18987614e-01f, 9.09307599e-02f, -4.54595327e-01f, -3.69584054e-01f,
  9.31480527e-03f, 3.23632509e-01f, -2.32978612e-01f, -7.90150225e-01f, -3.84127766e-01f, -7.60793388e-02f, -6.62980735e-01f, -7.55050778e-01f, 9.93443057e-02f, -5.55842280e-01f,
  2.42530957e-01f, -1.62464470e-01f, 6.31056070e-01f, -3.16853225e-01f, -2.60337323e-01f, -1.79216743e-01f, -1.21065319e-01f, 5.99154353e-01f, 5.97730279e-01f, -3.19738090e-01f,
  -2.36947268e-01f, 1.71099320e-01f, -9.47910175e-02f, 4.78766501e-01f, 1.49970114e-01f, -3.01844086e-02f, 6.74834847e-02f, -6.21579066e-02f, -1.39486371e-02f, 2.24035308e-01f,
  -9.89921540e-02f, -9.36270207e-02f, -3.72721046e-01f, 3.05508692e-02f, -2.42103115e-01f, 6.99130297e-02f, 5.82619727e-01f, 5.76322637e-02f, -2.92013139e-01f, -4.47474234e-02f,
  -1.60182416e-01f, 7.04140663e-01f, -9.78624523e-01f, 3.65535438e-01f, 2.12119147e-01f, 6.66737854e-01f, -2.29052573e-01f, -2.45870665e-01f, 1.81445733e-01f, 4.00712304e-02f,
  1.78418845e-01f, -6.48869216e-01f, 4.66124564e-01f, -7.30896115e-01f, 1.32241845e-01f, 2.57140279e-01f, 4.85352278e-01f, -8.98726583e-01f, 5.54086089e-01f, -6.59288615e-02f,
  -5.86104468e-02f, -2.93721676e-01f, 1.79523408e-01f, -3.75109881e-01f, 1.20523162e-01f, -3.72012034e-02f, -6.70495689e-01f, -1.90718725e-01f, -5.79013705e-01f, 3.76396507e-01f,
  -1.53492618e+00f, -1.10522997e+00f, 1.19343653e-01f, -1.06800124e-01f, -3.03629547e-01f, -6.54598415e-01f, -5.27159333e-01f, -5.01808047e-01f, -8.70467842e-01f, 8.66969898e-02f,
  2.22716957e-01f, -3.28288406e-01f, 9.26440358e-01f, -7.32865930e-01f, 1.64725214e-01f, -2.91296452e-01f, -2.61988908e-01f, 3.73510569e-01f, -4.51102201e-03f, 9.08608586e-02f,
  1.60335764e-01f, 1.78065717e-01f, -6.00920841e-02f, -1.09113440e-01f, -3.44555199e-01f, -1.13796279e-01f, 2.83586621e-01f, -3.18930089e-01f, 2.65662044e-01f, -2.99681574e-01f,
  3.61858249e-01f, -1.77293390e-01f, 9.65502337e-02f, -1.17292844e-01f, 5.94445169e-01f, 5.08697927e-01f, 6.53636873e-01f, -1.77817926e-01f, -2.53988486e-02f, 3.12237710e-01f,
  -2.38090932e-01f, 2.65966356e-01f, 5.93444444e-02f, -3.43586236e-01f, -3.81164908e-01f, -5.82863033e-01f, -1.61281094e-01f, -6.55379117e-01f, -1.14919394e-01f, 6.28316104e-02f,
  -8.47318351e-01f, -2.32733324e-01f, 5.65190077e-01f, 1.60636574e-01f, -5.22453338e-02f, -2.57494282e-02f, -3.37906718e-01f, -2.83533245e-01f, 2.92099178e-01f, 2.76517067e-02f,
  -4.61195648e-01f, 5.19769073e-01f, -3.04372728e-01f, -2.92915285e-01f, -3.19003493e-01f, -4.44860607e-01f, -4.90786552e-01f, -3.24762791e-01f, -6.59189999e-01f, 2.83851892e-01f,
  -1.56603292e-01f, -2.00916994e-02f, 7.52765089e-02f, -4.65203285e-01f, -6.53114378e-01f, 3.34121436e-01f, -3.18566740e-01f, 4.08421189e-01f, -1.56839997e-01f, 4.83957738e-01f,
  1.29125744e-01f, 1.62755713e-01f, -3.63601536e-01f, -1.55394888e-02f, 3.56034227e-02f, 5.87891415e-02f, -9.07062069e-02f, 6.57644495e-02f, 3.13266009e-01f, 3.07992920e-02f,
  -2.34838724e-01f, 1.02231421e-01f, 6.65442646e-02f, 2.20566317e-01f, 2.74882644e-01f, -3.08976527e-02f, 4.27457541e-01f, -5.47579825e-01f, -2.30365202e-01f, 6.33172750e-01f,
  2.10201323e-01f, -3.76886219e-01f, -3.42242301e-01f, -7.90868521e-01f, -1.43214259e-02f, 2.80365974e-01f, -2.95877546e-01f, -2.42756575e-01f, -6.27088368e-01f, 2.72306830e-01f,
  -9.28712904e-01f, 2.87539393e-01f, 1.99983627e-01f, -5.49176574e-01f, -8.67954120e-02f, -9.62662876e-01f, -8.63187492e-01f, -1.69563368e-01f, -9.10399482e-02f, 4.89002466e-01f,
  -4.99551624e-01f, -2.72660583e-01f, -2.56651491e-01f, -1.04290344e-01f, 4.61276442e-01f, 2.15598196e-01f, 5.28013289e-01f, -2.69777566e-01f, 1.15531385e-02f, 5.55852294e-01f,
  -5.02733439e-02f, -2.07914442e-01f, -5.47398627e-02f, -3.15121591e-01f, 1.99444830e-01f, 3.15247357e-01f, -5.16753912e-01f, -4.28226560e-01f, -3.50536227e-01f, 5.21775007e-01f,
  -1.03648424e+00f, 2.75317013e-01f, -4.89626825e-01f, -1.10794187e-01f, -5.62365472e-01f, -2.88396001e-01f, 2.12151986e-02f, 6.11830838e-02f, -1.92932338e-01f, -7.22600967e-02f,
  8.95413384e-02f, 8.88715982e-02f, -6.61717504e-02f, 2.96243250e-01f, 2.32747644e-01f, -1.71696514e-01f, -1.73740208e-01f, 4.07780148e-02f, 4.40033674e-02f, 1.43975317e-01f,
  9.64256525e-02f, 1.19051024e-01f, -3.51237416e-01f, -5.84628284e-01f, -5.99351764e-01f, -2.28204086e-01f, 1.59189448e-01f, 1.12080462e-01f, -4.38947320e-01f, 5.74972779e-02f,
  -4.00735289e-01f, -2.68549532e-01f, 3.07437569e-01f, 1.49373030e-02f, -4.62703556e-01f, 4.89727199e-01f, -7.54901648e-01f, -1.20591007e-01f, 2.17626914e-01f, 2.93114573e-01f,
  -3.22714627e-01f, -1.47456288e-01f, -1.87530696e-01f, -8.16902518e-01f, -8.29100236e-02f, -3.98688346e-01f, -1.47494432e-02f, 1.63579047e-01f, 2.34834924e-01f, 2.38166109e-01f,
  3.68742675e-01f, -9.10530686e-02f, 5.16324878e-01f, -6.86291039e-01f, -8.05333480e-02f, -3.96854766e-02f, -5.71236722e-02f, 4.40381944e-01f, -2.17984840e-01f, -3.80165786e-01f,
  5.67775011e-01f, 8.65363702e-02f, -3.86211932e-01f, -5.22899449e-01f, -7.55854249e-01f, 4.21587348e-01f, 3.48641634e-01f, 2.41206065e-01f, 1.51257977e-01f, -3.74015987e-01f,
  1.21580712e-01f, -1.92550085e-02f, 2.76436538e-01f, 9.85655859e-02f, -2.96053477e-02f, 1.01597331e-01f, -4.31142539e-01f, 1.38654500e-01f, 3.75658512e-01f, 3.82687151e-01f,
  -2.98135817e-01f, -4.31193796e-04f, -4.11414862e-01f, -1.59462765e-01f, -5.00751138e-01f, -5.86945452e-02f, -3.64937812e-01f, -4.49887693e-01f, -1.00904427e-01f, -2.65897959e-01f,
  -3.17579955e-01f, -1.13602042e-01f, 2.86150545e-01f, -8.58708695e-02f, 2.05430582e-01f, -1.27913341e-01f, 4.43007261e-01f, 4.69188958e-01f, 1.31629169e-01f, -8.24679554e-01f,
  -3.02307665e-01f, -3.90769579e-02f, 1.55862749e-01f, 7.35729337e-01f, 1.78161740e-01f, 1.65803045e-01f, 2.43889734e-01f, -3.80472362e-01f, 4.35461372e-01f, 5.54100275e-01f,
  -1.79833472e-02f, -7.99989551e-02f, -9.18486595e-01f, -4.17387873e-01f, -1.17841661e-01f, -4.96533334e-01f, 5.47934115e-01f, 2.55171984e-01f, 4.81943280e-01f, 6.70760795e-02f,
  6.34601295e-01f, -6.61892772e-01f, -1.96696341e-01f, -6.53866827e-02f, -5.53544834e-02f, 1.49136305e-01f, -5.55152476e-01f, -1.01375544e+00f, -1.08841032e-01f, -2.26814702e-01f,
  3.24212462e-01f, -1.07530296e+00f, -4.86887172e-02f, -3.16418737e-01f, 1.32418215e-01f, 1.26490235e-01f, -6.55051246e-02f, 6.08235737e-03f, 1.56558841e-01f, 8.00028443e-02f,
  -1.46185070e-01f, -2.98659652e-01f, 9.11002085e-02f, -2.78175771e-01f, 3.42344455e-02f, -2.43640035e-01f, -2.46848285e-01f, -2.33166739e-01f, -8.76060501e-02f, -2.73604393e-01f,
  3.01088840e-01f, -2.29717672e-01f, 4.49776530e-01f, -5.71514547e-01f, -1.68131471e-01f, 5.32269925e-02f, -5.14772460e-02f, -4.09941494e-01f, -1.47449553e-01f, -4.08673316e-01f,
  -3.88606906e-01f, -1.76626280e-01f, -1.73353642e-01f, -4.31339085e-01f, 4.48207349e-01f, 2.25652561e-01f, -1.75440177e-01f, 6.63871765e-01f, -4.76803601e-01f, -1.62348434e-01f,
  2.74975076e-02f, -3.84856284e-01f, 2.29671821e-01f, -2.75004655e-01f, 1.72963351e-01f, -8.94032776e-01f, -8.60966325e-01f, -6.93146348e-01f, -1.62723050e-01f, 3.98714662e-01f,
  -2.75212348e-01f, -4.50168252e-01f, -2.09245950e-01f, 5.29764175e-01f, -5.14818728e-01f, 5.68056285e-01f, -8.61324251e-01f, 5.17814636e-01f, -3.19207162e-01f, -3.93430889e-01f,
  4.34670538e-01f, -2.33966976e-01f, -6.53667867e-01f, -1.90407217e-01f, -5.72802365e-01f, -6.98891401e-01f, 8.33729655e-03f, -5.95971227e-01f, -2.29947031e-01f, -3.42617691e-01f,
  6.49455702e-03f, -5.92607595e-02f, -1.97360516e-01f, -3.11898291e-01f, 7.21445158e-02f, 1.83046654e-01f, 3.04438826e-03f, 4.69272211e-02f, 1.83623508e-01f, -1.31345749e-01f,
  -4.39123839e-01f, 1.26848131e-01f, 3.23300123e-01f, 2.84136891e-01f, -5.58220804e-01f, -4.07342762e-01f, -6.54103532e-02f, 5.88145331e-02f, -3.38224508e-02f, -5.83505511e-01f,
  4.80898023e-02f, -5.19483387e-01f, -7.04712331e-01f, 3.60426009e-01f, -3.24523985e-01f, -6.66862130e-01f, -5.53173348e-02f, 4.81756747e-01f, 1.71069533e-01f, -5.19411802e-01f,
  -2.25002334e-01f, -5.23366570e-01f, -5.47729671e-01f, -2.05982268e-01f, -5.92045307e-01f, 4.54897024e-02f, -3.15185964e-01f, 2.05852091e-01f, -9.61731002e-03f, -2.69477338e-01f,
  -2.83057481e-01f, 4.01174963e-01f, -1.21943176e-01f, -3.30793321e-01f, 6.46338642e-01f, 5.31038880e-01f, -5.80297589e-01f, -2.34326392e-01f, -4.06851262e-01f, -7.51974642e-01f,
  6.67451262e-01f, 3.96807820e-01f, 1.21356025e-01f, 2.29904890e-01f, -1.61536008e-01f, 4.07509506e-01f, -6.07853413e-01f, -1.35057688e-01f, -2.45940894e-01f, -5.05144715e-01f,
  1.12724826e-01f, -2.57546902e-01f, 1.54845685e-01f, 1.28044590e-01f, -1.35826945e-01f, 1.20185122e-01f, 1.37530610e-01f, 1.07776178e-02f, 2.21937433e-01f, 2.05535931e-03f,
  -2.18786448e-01f, -7.73279816e-02f, -1.93792507e-02f, 1.80087373e-01f, -2.51809806e-01f, -5.84503375e-02f, -1.46040559e-01f, 1.54437155e-01f, 9.93827522e-01f, -3.67776662e-01f,
  -3.87322716e-02f, 3.20938349e-01f, -7.24528432e-02f, -1.17901592e-02f, 4.94532824e-01f, -6.47528395e-02f, 3.76151830e-01f, 1.84879616e-01f, -6.31249368e-01f, -7.40250170e-01f,
  2.32296679e-02f, -9.20055658e-02f, -2.40220487e-01f, -1.50174573e-01f, -3.31778407e-01f, -4.24335629e-01f, -4.58271336e-03f, 3.41156900e-01f, 8.68719816e-02f, 7.08354950e-01f,
  -1.49693489e-01f, -5.22876382e-01f, -2.32709482e-01f, -9.01968330e-02f, -3.97751063e-01f, -2.94069976e-01f, -8.55651975e-01f, -4.21064109e-01f, 5.12459755e-01f, 5.71614087e-01f,
  -7.03165770e-01f, -5.01030922e-01f, -4.49605048e-01f, -3.59997928e-01f, -2.65422612e-01f, -2.28004351e-01f, -2.20635518e-01f, -4.21083756e-02f, -7.32804229e-03f, -3.40947211e-01f,
  -1.53067365e-01f, -1.34684682e-01f, -1.33302957e-01f, -3.40666741e-01f, -1.29226699e-01f, -6.03763852e-03f, -2.18675494e-01f, 2.39061490e-02f, -1.71585932e-01f, -7.68314600e-02f,
  8.53739679e-03f, 5.22826537e-02f, -2.32823431e-01f, 5.63052535e-01f, 2.03930244e-01f, -2.69000351e-01f, 2.52547741e-01f, -3.06838099e-02f, -7.08560586e-01f, -2.14193329e-01f,
  2.84140438e-01f, 3.74569893e-01f, -6.32444441e-01f, -4.56424832e-01f, -1.15600480e-02f, -1.95069432e-01f, -4.65158075e-01f, 1.51865989e-01f, 1.09209819e-02f, -1.11883156e-01f,
  -7.64808774e-01f, 1.24160498e-01f, 3.86347771e-01f, -5.47089458e-01f, -6.76414132e-01f, 6.15682937e-02f, -1.00714520e-01f, 1.58007041e-01f, -6.30185068e-01f, 1.96098790e-01f,
  -5.09014308e-01f, 5.32730930e-02f, -2.64664799e-01f, -1.65277392e-01f, 1.72342673e-01f, -8.85037705e-02f, -1.58184409e-01f, 7.43897378e-01f, 2.33794361e-01f, 3.66234869e-01f,
  -9.68592107e-01f, 2.13630646e-01f, -8.13523769e-01f, -8.12963843e-01f, -4.75846648e-01f, 3.73131782e-01f, 5.39124310e-01f, 1.01811677e-01f, 2.91368932e-01f, -9.96220708e-02f,
  6.41958892e-01f, -6.54251635e-01f, -1.79949388e-01f, -5.41757345e-01f, 8.21974933e-01f, -6.81108117e-01f, 1.18946254e-01f, 3.69369358e-01f, 2.07077771e-01f, -1.69678852e-01f,
  3.12594995e-02f, -3.05996425e-02f, -7.07546249e-02f, 4.19896562e-03f, 6.80000633e-02f, 1.91283286e-01f, 2.05561385e-01f, 3.00486445e-01f, -1.97700411e-01f, -1.85464248e-01f,
  -1.48780093e-01f, 9.71884206e-02f, 1.23658786e-02f, -7.42352843e-01f, -4.80263621e-01f, -3.09408724e-01f, -2.63720602e-01f, -6.78412616e-01f, -2.84069568e-01f, -2.53347099e-01f,
  -3.98276955e-01f, 2.84319758e-01f, -2.26084292e-01f, -5.26421845e-01f, -4.66517538e-01f, 4.60759401e-01f, -8.05951893e-01f, 5.27396739e-01f, 6.26014411e-01f, -4.44803059e-01f,
  1.92116052e-02f, -5.90771198e-01f, -2.45714523e-02f, 1.03696242e-01f, -5.87049663e-01f, 2.00898618e-01f, -2.69943982e-01f, 3.77886474e-01f, -3.49654734e-01f, -3.97403955e-01f,
  -3.53617430e-01f, -4.51003015e-01f, 1.76126674e-01f, -1.40008166e-01f, 3.46910566e-01f, -2.04042211e-01f, -5.26787519e-01f, 3.68458539e-01f, 3.18603247e-01f, -3.51966731e-02f,
  -6.38458073e-01f, -4.75482553e-01f, -3.35378915e-01f, -3.82377088e-01f, -5.45344174e-01f, -1.94218934e-01f, -3.04150343e-01f, -3.01753551e-01f, -2.72584558e-01f, -6.44402206e-02f,
  2.97078222e-01f, 7.41231024e-01f, 1.45012394e-01f, -2.76742101e-01f, 7.33450204e-02f, 6.16262406e-02f, 7.87964091e-02f, 1.57200545e-02f, 2.58937001e-01f, -1.02245428e-01f,
  4.11377221e-01f, -1.27075344e-01f, 5.40777668e-02f, 3.61602336e-01f, -2.69234687e-01f, 5.47549605e-01f, 1.06685963e-02f, 3.44238505e-02f, 1.67859212e-01f, -4.94533211e-01f,
  -3.26987170e-02f, -2.29827240e-01f, -6.03441000e-01f, -2.34761119e-01f, 3.24211836e-01f, -4.49228108e-01f, -6.92294061e-01f, -1.67111367e-01f, 4.64508384e-01f, -3.49492341e-01f,
  -1.46176413e-01f, -1.88524812e-01f, -3.35690498e-01f, 7.58110046e-01f, 7.86697865e-02f, -5.27728423e-02f, -1.76853552e-01f, -6.90079570e-01f, -3.76104146e-01f, 2.13321030e-01f,
  -4.19598110e-02f, -2.87613839e-01f, 4.33551371e-01f, 5.77611625e-01f, -5.22243321e-01f, -3.99482697e-01f, 6.48000300e-01f, -3.78611296e-01f, -4.53539371e-01f, 2.84800947e-01f,
  6.85124934e-01f, -5.29351771e-01f, -3.91403705e-01f, -3.58984560e-01f, -4.35408562e-01f, 1.30966425e-01f, -2.24051371e-01f, -5.05364478e-01f, -6.39356434e-01f, -3.99728417e-01f,
  5.52403271e-01f, -2.54511565e-01f, -2.96490729e-01f, -9.86358821e-02f, -5.47067940e-01f, -4.09933068e-02f, -2.10580811e-01f, 1.74871638e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.76705319e-01f, 1.04490243e-01f, 1.93190098e-01f, -1.97329298e-01f, -5.21450378e-02f, 9.43534672e-02f, -6.89196661e-02f, 5.66247627e-02f, -1.41092314e-04f, -7.37485359e-04f,
  -6.18240125e-02f, 1.57794040e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    