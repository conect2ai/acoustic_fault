/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.27234322e-01f, -6.65263310e-02f, 2.14342877e-01f, -1.90227441e-02f, 1.35096103e-01f, 3.78979772e-01f, 3.46012533e-01f, 5.17166816e-02f, 1.73305988e-01f, -2.40630377e-02f,
  -6.42428920e-02f, 3.73693854e-02f, 1.06923962e-02f, -5.09085804e-02f, 1.07309684e-01f, 1.19626438e-02f, -1.29008675e-02f, -1.78092085e-02f, -9.83941332e-02f, -4.96559031e-02f,
  -3.33049893e-02f, -7.73663968e-02f, -7.71678016e-02f, -2.09355310e-01f, 7.39699230e-02f, -4.43805084e-02f, -1.66499615e-01f, -8.82418975e-02f, -1.90993965e-01f, 6.82051107e-02f,
  8.35688412e-02f, 2.01065447e-02f, 2.07269229e-02f, 1.41850263e-02f, 6.84739128e-02f, 2.74923965e-02f, -3.10623776e-02f, -2.64638513e-02f, -1.11953430e-01f, 5.02836183e-02f,
  7.08821341e-02f, -3.75681883e-03f, -2.90992809e-03f, 5.01925349e-02f, -2.97557097e-02f, 2.98180198e-03f, -4.62909862e-02f, 2.98836157e-02f, 4.57580127e-02f, -1.12460507e-02f,
  1.62424147e-01f, 3.16136563e-03f, 1.86084136e-02f, 6.90103546e-02f, 4.26874161e-02f, -1.22677665e-02f, 1.02703497e-01f, 1.15301386e-02f, -1.91104747e-02f, 3.70453745e-02f,
  -1.46374770e-03f, 1.13687813e-02f, -1.00192524e-01f, -8.16541985e-02f, -4.17516902e-02f, -2.72292588e-02f, -4.33017537e-02f, -5.21057658e-02f, -3.66813876e-02f, -1.09680839e-01f,
  -1.07432164e-01f, -2.32826695e-02f, -2.77598668e-02f, -1.21166334e-02f, 5.90289347e-02f, 1.04486875e-01f, -1.96659062e-02f, -9.90264416e-02f, 6.74426407e-02f, -9.18355957e-02f,
  -1.40661314e-01f, 1.43615305e-02f, -8.49561542e-02f, -1.58517137e-02f, 2.09084596e-03f, -3.59821953e-02f, -3.22583579e-02f, -2.23254575e-03f, -4.43910994e-02f, -1.28913134e-01f,
  1.32484687e-02f, -5.80056279e-04f, 3.73369046e-02f, 4.97153625e-02f, -5.30313291e-02f, -1.15687728e-01f, 1.15594696e-02f, 8.38668197e-02f, -1.42399557e-02f, 1.34214172e-02f,
  9.96827930e-02f, 2.76462231e-02f, -5.92845380e-02f, -5.93221821e-02f, 7.08947033e-02f, -1.80243365e-02f, -6.50655702e-02f, 1.19198980e-02f, 8.35460331e-03f, 8.01297091e-03f,
  3.90073322e-02f, 2.30120774e-02f, -5.68395443e-02f, 1.13906255e-02f, 8.73393863e-02f, 3.61011475e-02f, 3.52651961e-02f, -5.62577285e-02f, -8.47529024e-02f, -5.46986349e-02f,
  -2.21379459e-01f, 3.85956876e-02f, -8.62205178e-02f, -1.19732507e-01f, 5.08510834e-03f, 5.96047565e-03f, 2.13200793e-01f, -1.62871078e-01f, -1.56869292e-01f, 1.12516947e-01f,
  5.04752249e-02f, 1.08191215e-01f, 6.40159324e-02f, -2.11672783e-01f, -3.15569997e-01f, 5.30386977e-02f, -2.06249520e-01f, -2.21307185e-02f, -1.62475929e-01f, -1.33197635e-01f,
  -2.24236265e-01f, -1.57136872e-01f, -2.44272381e-01f, -1.82752445e-01f, 2.61579435e-02f, 4.18269858e-02f, -1.22971676e-01f, 1.24918245e-01f, 1.34889940e-02f, 6.51119724e-02f,
  1.75279062e-02f, 8.38266835e-02f, 4.95244190e-02f, -3.15697454e-02f, -2.70514712e-02f, 5.54411821e-02f, 3.72258462e-02f, 6.37104660e-02f, -5.25524803e-02f, 3.89930680e-02f,
  5.50381206e-02f, -1.50748461e-01f, -3.43382210e-02f, -4.52903053e-03f, 6.21807091e-02f, 1.29284963e-01f, -7.55368844e-02f, 9.66793299e-03f, -6.98989350e-03f, 5.00727259e-02f,
  -1.24698952e-02f, 1.89682562e-02f, -1.17738852e-02f, -9.45663750e-02f, -1.45982072e-01f, -4.32636961e-02f, 1.89783007e-01f, 6.67225122e-02f, 6.54632077e-02f, -1.42507292e-02f,
  -4.95008528e-02f, -2.74945702e-03f, 8.39092806e-02f, -1.39428526e-02f, 1.48957949e-02f, 5.23776188e-02f, 2.29639839e-02f, 1.05556279e-01f, -2.31675198e-03f, 2.02137325e-02f,
  4.06763256e-02f, 9.54256877e-02f, -2.07518265e-02f, -6.12456910e-02f, -1.91567931e-02f, -8.72376747e-03f, 7.97626302e-02f, 2.98656560e-02f, -3.32497843e-02f, 1.40176462e-02f,
  1.11855581e-01f, 1.62425246e-02f, 3.00073274e-03f, 1.07311226e-01f, -1.94570553e-02f, 3.69273648e-02f, -1.15369827e-01f, -1.01189613e-02f, -7.76362000e-03f, 9.81759354e-02f,
  -4.29242998e-02f, -4.61995602e-02f, -1.99073572e-02f, 1.50207765e-02f, 8.31726938e-02f, 2.59006452e-02f, -6.79303333e-02f, -7.37147033e-02f, -9.23892260e-02f, -1.06191970e-01f,
  1.19365372e-01f, -2.80265305e-02f, -1.72983892e-02f, -6.34748070e-03f, -1.00140020e-01f, 1.35929594e-02f, 1.70068480e-02f, -3.14951572e-03f, -1.21684872e-01f, -3.15372348e-02f,
  1.80198718e-02f, -2.05635466e-02f, 6.80628046e-02f, -6.36116341e-02f, -8.22612867e-02f, 4.46163453e-02f, 4.77224169e-03f, 5.02224043e-02f, -3.11510777e-03f, 2.35477500e-02f,
  -3.03958148e-01f, 3.61099273e-01f, -2.01934308e-01f, -1.14062496e-01f, 4.13482375e-02f, -7.17465654e-02f, 4.59930114e-02f, 1.02836736e-01f, -5.34096695e-02f, 3.06021631e-01f,
  -2.09653825e-02f, -1.02320693e-01f, 2.89432844e-03f, 1.20699078e-01f, -2.57346511e-01f, 6.81780279e-02f, -1.15565896e-01f, -7.19140051e-03f, -7.71064684e-02f, 8.32659528e-02f,
  -8.95519629e-02f, 5.40273264e-02f, -2.74136692e-01f, 5.82336709e-02f, -4.38841209e-02f, -1.86783060e-01f, -6.44660816e-02f, -4.00123699e-03f, -4.28113826e-02f, -1.35077596e-01f,
  2.71587372e-02f, 1.48017839e-01f, -7.51210097e-03f, 4.98182960e-02f, -8.44468325e-02f, 1.03120185e-01f, 1.12185769e-01f, -7.08443439e-03f, 2.63672844e-02f, -2.69825514e-02f,
  5.55854887e-02f, -2.92920582e-02f, -9.24320295e-02f, -5.42351566e-02f, 6.30721673e-02f, 3.75995450e-02f, -9.66857001e-02f, 1.87517833e-02f, 5.80283031e-02f, 4.76711895e-03f,
  -1.51598034e-02f, -5.36311381e-02f, 4.89366241e-03f, -8.63735154e-02f, -7.32297674e-02f, -1.34818897e-01f, -2.21803766e-02f, -1.98246725e-02f, -9.46822539e-02f, -1.17764942e-01f,
  7.63356760e-02f, 1.80763437e-03f, 2.00899485e-02f, 2.99557764e-02f, -5.16189560e-02f, -1.17329493e-01f, 3.41643915e-02f, 3.04421410e-02f, -8.47718343e-02f, 1.10957526e-01f,
  1.45399570e-02f, -8.82344879e-03f, 9.19298902e-02f, -4.68255430e-02f, -5.82610741e-02f, 7.12706428e-03f, 3.54991630e-02f, 5.81900291e-02f, 7.74814263e-02f, -4.05326374e-02f,
  -2.19921991e-02f, 2.17507500e-02f, -1.09418547e-02f, 8.87312517e-02f, -2.42354497e-02f, -1.89759471e-02f, -2.44031586e-02f, 5.75962290e-03f, -7.05181202e-03f, -3.59626003e-02f,
  1.57084778e-01f, 6.15757257e-02f, -1.25765065e-02f, 6.55068830e-02f, -5.30336984e-02f, 7.10655972e-02f, -1.67575944e-02f, 5.44928089e-02f, -1.44748017e-02f, 7.34964460e-02f,
  6.74072281e-02f, -1.01495013e-02f, 1.94236394e-02f, 1.66350082e-02f, -5.05738072e-02f, 1.14956841e-01f, 7.93501437e-02f, 2.70810314e-02f, -2.23608411e-04f, 3.98175493e-02f,
  1.01507828e-01f, -4.82451469e-02f, 2.08529849e-02f, -7.13331178e-02f, -7.42007792e-02f, 3.40567604e-02f, -7.92180300e-02f, -6.42952695e-02f, 4.83258739e-02f, -8.36108066e-03f,
  1.27398251e-02f, -9.71383899e-02f, 4.57047578e-03f, -2.67045312e-02f, 1.97273567e-01f, 1.07509129e-01f, -1.01060323e-01f, 2.15988085e-01f, 3.05190254e-02f, -1.32977426e-01f,
  -6.72323536e-03f, -1.48893654e-01f, -2.42582008e-01f, 8.71282443e-02f, -2.46735469e-01f, -2.28736237e-01f, 8.46985206e-02f, -3.83322407e-03f, 8.81357491e-02f, 6.82072192e-02f,
  1.37843028e-01f, 6.38977587e-02f, 1.03846334e-01f, 1.30362093e-01f, 1.79513499e-01f, 5.34999818e-02f, -1.21042825e-01f, -7.72986636e-02f, 7.52530918e-02f, 1.90494340e-02f,
  7.17963949e-02f, -3.49094421e-02f, 1.40052512e-01f, -4.36546654e-02f, 1.21847186e-02f, 1.23178232e-02f, 3.12351715e-03f, -8.08854103e-02f, -5.99735007e-02f, 6.93577453e-02f,
  -1.08054683e-01f, 1.69561915e-02f, 7.36805424e-02f, -1.04324132e-01f, -4.51957323e-02f, 9.67386877e-04f, 5.82232922e-02f, 4.98802215e-02f, 1.57895520e-01f, 5.96743599e-02f,
  1.49623588e-01f, 8.05059671e-02f, -2.15174500e-02f, 1.06432950e-02f, 5.59271686e-02f, 6.50954545e-02f, 4.41985652e-02f, 1.19491173e-02f, 5.35421260e-02f, 1.71671122e-01f,
  6.39515696e-03f, 3.43517885e-02f, -5.79322409e-03f, -2.92348731e-02f, -6.37549832e-02f, 2.14301813e-02f, -1.25206798e-01f, -4.49049799e-03f, -2.53807660e-02f, -5.83201833e-02f,
  4.56253365e-02f, -5.32353409e-02f, -2.19807159e-02f, -5.85504360e-02f, -1.38374753e-02f, -6.03410937e-02f, -2.70716660e-02f, 3.90967764e-02f, -3.24458331e-02f, 3.71119790e-02f,
  -8.45363513e-02f, 7.76433498e-02f, -1.28984705e-01f, 8.49176198e-03f, -3.06650214e-02f, -9.24408138e-02f, 4.49682064e-02f, 7.48927705e-04f, -6.81130290e-02f, -1.34431347e-01f,
  -9.10240188e-02f, -1.32281050e-01f, 9.32821333e-02f, 4.46447823e-03f, -1.54621542e-01f, -6.84666261e-02f, -7.07269609e-02f, 8.09377804e-02f, -1.29370466e-01f, 5.80056049e-02f,
  7.52868271e-03f, -5.33427298e-02f, -7.12255538e-02f, -2.59203296e-02f, -1.34743914e-01f, 2.22032834e-02f, -1.20669156e-01f, -9.90913063e-02f, 1.18355401e-01f, -1.29958373e-02f,
  -3.55057418e-02f, -1.01154245e-01f, -4.57539335e-02f, 1.28295720e-01f, 3.53385024e-02f, 4.46129255e-02f, 3.99811268e-02f, 3.54113095e-02f, -4.08672728e-02f, -3.09588145e-02f,
  -1.78404987e-01f, 3.91354889e-01f, 7.70923719e-02f, -1.14444539e-01f, -1.66254252e-01f, -2.19931930e-01f, -1.50445819e-01f, 5.56246527e-02f, -3.16422582e-02f, 3.51462662e-01f,
  1.49097130e-01f, 1.63529024e-01f, 1.06954783e-01f, 2.44205240e-02f, -3.12165111e-01f, -2.13193879e-01f, 3.98345813e-02f, -5.90746775e-02f, -8.93217921e-02f, 2.30852328e-02f,
  -1.54740930e-01f, -1.83021441e-01f, -5.33612035e-02f, 9.39823464e-02f, 8.06509107e-02f, 1.17078058e-01f, 3.53898294e-02f, 9.65172127e-02f, 1.95106357e-01f, -4.41990830e-02f,
  2.24471409e-02f, -2.67258734e-02f, 9.84200463e-02f, 1.14283472e-01f, 9.25170779e-02f, 1.06795684e-01f, 8.27686787e-02f, -7.87177086e-02f, 1.06790569e-02f, -1.36755006e-02f,
  1.89405549e-02f, -9.86867175e-02f, -8.16153139e-02f, 6.46175295e-02f, 4.08552364e-02f, 7.68772792e-03f, -8.47918354e-03f, 2.85178702e-02f, 1.60422493e-02f, -1.07145205e-01f,
  -2.02010684e-02f, -2.34831460e-02f, 7.42061110e-03f, -7.77139189e-03f, 1.67005472e-02f, -2.16435269e-02f, -2.65567824e-02f, 6.66983426e-02f, -1.18509777e-01f, 2.39374191e-02f,
  -3.83628085e-02f, -4.92451414e-02f, 2.53270054e-03f, 3.49302456e-04f, 1.76010914e-02f, -9.21789259e-02f, 1.38606206e-01f, 7.02916458e-02f, 1.04019225e-01f, 2.05187257e-02f,
  3.06013785e-02f, 6.09504664e-03f, 3.94638330e-02f, 4.27955203e-02f, 6.28217980e-02f, -1.02196477e-01f, 2.70514153e-02f, 4.50549163e-02f, -6.95326133e-03f, -2.59300023e-02f,
  -6.01173304e-02f, -6.64344756e-03f, 4.39183377e-02f, 6.05950952e-02f, 2.56734379e-02f, -1.99676622e-02f, 1.13866180e-01f, 2.12228135e-03f, -5.95292933e-02f, 1.73032675e-02f,
  2.18777925e-01f, 2.60841757e-01f, 6.18191920e-02f, 1.70345996e-02f, 1.36348009e-01f, 1.74813554e-01f, -2.72172000e-02f, -5.55629581e-02f, 2.68074218e-02f, -8.97524729e-02f,
  1.44391740e-02f, 8.38187262e-02f, 6.63597137e-02f, -1.86252147e-02f, 4.66018403e-03f, -1.47032151e-02f, 6.29349723e-02f, 1.16503589e-01f, -1.42200962e-02f, 3.69461142e-02f,
  1.43727101e-02f, 2.97655426e-02f, -4.12876047e-02f, -3.70098581e-03f, 4.14222255e-02f, 5.94978333e-02f, 5.52853979e-02f, 2.90685464e-02f, -6.54923469e-02f, 3.64137515e-02f,
  -3.91875118e-01f, 9.43827033e-02f, -1.34374112e-01f, -5.15064836e-01f, -7.55303651e-02f, 1.26413196e-01f, -1.52093962e-01f, -1.28249377e-01f, -2.65242159e-01f, 9.06757265e-02f,
  8.64260569e-02f, -2.07532793e-01f, 3.02189171e-01f, -2.23843068e-01f, -3.91714200e-02f, 2.39140496e-01f, 6.20914297e-03f, -1.26972079e-01f, 5.02145700e-02f, -7.93145001e-02f,
  -1.70473874e-01f, -6.84370622e-02f, -1.75938215e-02f, 7.91907459e-02f, -1.80745021e-01f, -1.01801902e-01f, -5.32115623e-02f, 1.74131513e-01f, -1.88866466e-01f, 9.85973254e-02f,
  4.12612371e-02f, -3.63272652e-02f, -1.49718523e-01f, 5.38282795e-03f, -7.12497383e-02f, 2.68108621e-02f, -1.63166802e-02f, 8.47912282e-02f, 1.11754751e-02f, -2.60092244e-02f,
  2.83510666e-02f, -9.78698768e-03f, -9.91377160e-02f, -1.31845884e-02f, -1.07139461e-02f, -5.48401289e-02f, -1.45888934e-02f, 4.79868986e-02f, -4.61963117e-02f, -9.17096213e-02f,
  -1.15607351e-01f, -1.89609900e-02f, -1.77508336e-03f, 2.77277194e-02f, -6.64356053e-02f, -3.34478579e-02f, 2.71976143e-02f, 1.04006184e-02f, -1.40355388e-03f, -4.78825445e-04f,
  -1.88825056e-02f, -4.65954356e-02f, 1.13272496e-01f, 4.68597002e-02f, 4.20330651e-02f, -5.79684377e-02f, 1.27436057e-01f, -3.02526224e-02f, -2.98287719e-03f, -3.26022878e-02f,
  1.23452291e-01f, 5.83297899e-03f, -7.04177096e-02f, 3.86336371e-02f, -5.78128882e-02f, -7.28193074e-02f, 4.31919284e-02f, -5.21933325e-02f, -7.25500584e-02f, -4.41810377e-02f,
  -1.05154321e-01f, -1.62039418e-02f, -5.98885193e-02f, -5.60916075e-03f, 9.64113995e-02f, 4.44137901e-02f, -6.31084591e-02f, 2.40254570e-02f, 5.39229997e-02f, 1.74140185e-01f,
  1.84769291e-04f, 1.55326068e-01f, -2.87258700e-02f, -8.29810575e-02f, -1.68537814e-02f, -5.44206984e-03f, 9.58712995e-02f, -1.22525450e-02f, 1.07426584e-01f, -3.53467949e-02f,
  -3.69879901e-02f, -2.00129971e-02f, 7.66933337e-02f, 3.47545110e-02f, 2.66403016e-02f, -7.20610470e-02f, -7.75739104e-02f, 3.52698490e-02f, -1.04462989e-01f, 5.61215691e-02f,
  -1.61241993e-01f, 1.02511510e-01f, 2.16533728e-02f, 6.60276487e-02f, -1.13115825e-01f, 9.83577296e-02f, -1.14013758e-02f, 1.29420841e-02f, 1.14940321e-02f, 5.72819375e-02f,
  2.15779036e-01f, -2.12167859e-01f, 1.64733097e-01f, 6.45357445e-02f, 1.66179374e-01f, -1.41652420e-01f, -3.02222788e-01f, 6.80829734e-02f, 1.80751771e-01f, -1.68230712e-01f,
  -7.75798485e-02f, -1.46646611e-02f, -2.16200933e-01f, -2.90148318e-01f, -2.55769700e-01f, -3.25459659e-01f, 5.86722456e-02f, 3.66501277e-04f, 4.79664765e-02f, 6.60774261e-02f,
  4.46803868e-02f, -1.88420102e-01f, -1.18119337e-01f, -6.18491732e-02f, 4.40777354e-02f, 3.59086022e-02f, -3.90362069e-02f, -7.35154003e-02f, -4.31498401e-02f, -2.40649521e-01f,
  5.07221445e-02f, 4.95318733e-02f, 1.59544237e-02f, -1.43863792e-02f, 1.24761395e-01f, -2.35933773e-02f, -1.01399548e-01f, -1.17576867e-01f, -6.12615608e-04f, 7.55934045e-02f,
  -8.85735974e-02f, -8.25424418e-02f, 4.38887775e-02f, 6.13748096e-02f, 4.18679416e-02f, 4.84938771e-02f, 5.53638265e-02f, 6.80404678e-02f, 2.52867229e-02f, -6.01945166e-03f,
  -7.96061382e-03f, 7.81235844e-02f, 6.30354956e-02f, -4.08125222e-02f, 2.20149085e-02f, 6.18193634e-02f, 1.26458909e-02f, -6.73171803e-02f, -8.09411183e-02f, 2.67080031e-02f,
  -1.09342001e-01f, -6.11182712e-02f, 5.42193465e-02f, 9.23636630e-02f, -7.37906946e-03f, 8.03324506e-02f, 3.78170572e-02f, -1.85962692e-02f, 1.88218169e-02f, 6.83218539e-02f,
  1.12603344e-01f, 5.01542818e-03f, 6.18131645e-02f, 1.47130966e-01f, 2.20204797e-02f, 2.44521592e-02f, 5.01823314e-02f, -1.25109732e-01f, 1.85167082e-02f, -4.21763994e-02f,
  -3.40546332e-02f, -6.31711632e-03f, 1.44110452e-02f, -1.19978916e-02f, 5.03639802e-02f, -8.81221332e-03f, -1.40554726e-03f, -2.06465963e-02f, 3.02584958e-03f, -2.08115242e-02f,
  -4.35486287e-02f, -1.36309057e-01f, -4.34575118e-02f, 2.82221660e-02f, -2.49983114e-03f, 1.30053967e-01f, -2.61999238e-02f, -2.42380444e-02f, -1.20396361e-01f, -6.25583977e-02f,
  -2.56297421e-02f, 1.68903306e-01f, 1.07687131e-01f, 4.49376851e-02f, 2.22796071e-02f, -1.82966869e-02f, -7.23916367e-02f, -7.24537373e-02f, -2.97840834e-02f, -3.60112451e-02f,
  4.62663583e-02f, -5.93112074e-02f, -1.19769678e-01f, 8.50750208e-02f, 4.12797220e-02f, 7.69519955e-02f, 6.55502900e-02f, 2.35460307e-02f, 3.18972580e-02f, 2.45821336e-03f,
  2.55504340e-01f, -1.88217089e-01f, -1.01914227e-01f, 1.82550937e-01f, -1.81978166e-01f, 9.30808634e-02f, 1.79509997e-01f, -2.13760287e-01f, -2.56517798e-01f, 2.00175926e-01f,
  5.45474105e-02f, -1.23666367e-02f, -2.09264122e-02f, 2.42671564e-01f, 1.61104605e-01f, -6.81787655e-02f, 1.53186768e-01f, 6.71958253e-02f, -3.25527251e-01f, 7.43643716e-02f,
  -7.29932860e-02f, 2.46177897e-01f, 1.81271136e-01f, -1.08888466e-02f, 1.10260576e-01f, -1.28160030e-01f, 1.67621240e-01f, -1.21096350e-01f, 1.14620253e-01f, -4.78404202e-02f,
  5.86298108e-02f, -6.49792254e-02f, 7.65503664e-03f, -8.48211423e-02f, -5.26388623e-02f, 5.09366486e-03f, 1.34025156e-01f, 1.01914387e-02f, -1.07776001e-01f, 3.69073488e-02f,
  6.32706508e-02f, 7.78060034e-03f, -4.04100865e-02f, -1.06588118e-01f, -7.63406008e-02f, -4.26597744e-02f, 1.69578046e-02f, -1.71426572e-02f, 8.07635635e-02f, 4.89994586e-02f,
  -1.70972701e-02f, -6.68810755e-02f, -4.52634543e-02f, 9.83137935e-02f, 2.04303116e-02f, -4.36055698e-02f, 5.75510506e-03f, 3.99909578e-02f, -4.15436365e-02f, -1.04925036e-01f,
  -2.46659778e-02f, -2.82452982e-02f, 3.60660702e-02f, 3.63872573e-02f, -4.24483530e-02f, 2.80340277e-02f, 3.41334827e-02f, 2.21722405e-02f, -1.33618012e-01f, 2.92230621e-02f,
  6.90815002e-02f, -1.85813215e-02f, -3.92105281e-02f, -2.07420550e-02f, 1.02968998e-01f, 1.26624018e-01f, 1.78099107e-02f, 1.73552223e-02f, -2.54100747e-02f, 2.86761317e-02f,
  3.85683253e-02f, -8.64082668e-03f, -2.36320077e-03f, 8.42931122e-02f, -2.12408230e-02f, 1.11308396e-01f, 4.11830358e-02f, -3.94043364e-02f, -4.43016440e-02f, -2.72075143e-02f,
  2.84734499e-02f, -9.79737192e-02f, -2.27733906e-02f, 5.38623780e-02f, -8.80269520e-03f, -1.20961107e-02f, -3.70011702e-02f, 7.96662048e-02f, -9.61354375e-02f, 1.30586661e-02f,
  5.55823185e-02f, -1.32007403e-02f, 3.63772139e-02f, -4.51869182e-02f, 1.28181921e-02f, -8.01278651e-03f, 1.09376751e-01f, -3.37323993e-02f, -6.95233885e-03f, 1.32865645e-02f,
  1.45233735e-01f, -4.51599844e-02f, 9.45690721e-02f, 5.77112958e-02f, 4.60901633e-02f, 6.12885840e-02f, -5.18871993e-02f, -3.72232199e-02f, 3.61758657e-02f, -7.01223761e-02f,
  -2.46980682e-01f, 2.28258491e-01f, -1.42660335e-01f, -2.32843533e-01f, 1.55206621e-01f, -1.51322797e-01f, -1.66771099e-01f, 2.06904978e-01f, -7.11837783e-02f, 7.20179081e-02f,
  -7.34076509e-03f, -1.99375749e-01f, -2.56927889e-02f, 2.20761541e-02f, -2.89948463e-01f, 2.37950310e-02f, -1.31349936e-01f, -1.39504597e-01f, 1.67591035e-01f, -4.05907296e-02f,
  -1.07766874e-01f, 1.07942581e-01f, -2.08318815e-01f, 1.80422723e-01f, -3.93581856e-03f, 5.00032753e-02f, -6.28246367e-02f, 6.32072166e-02f, -7.04665408e-02f, 4.30351384e-02f,
  -1.33891463e-01f, 1.57103352e-02f, 2.62872670e-02f, -8.04445744e-02f, -1.15293637e-01f, -5.15379272e-02f, -1.57663524e-01f, -2.69008782e-02f, 5.30971959e-02f, -8.56060982e-02f,
  -6.38729334e-02f, 1.11780770e-01f, -1.32936169e-04f, 8.00039694e-02f, 4.90304343e-02f, -4.32229452e-02f, 7.59759918e-02f, -7.55479932e-02f, 1.29594281e-02f, 2.85204705e-02f,
  1.07619902e-02f, -8.23224112e-02f, -2.19633505e-02f, -1.48121357e-01f, 1.00271650e-01f, -7.31294602e-03f, -8.50085095e-02f, -1.44673839e-01f, -1.32060498e-01f, -1.47994598e-02f,
  -3.29101160e-02f, 9.22964711e-04f, 5.41289337e-04f, -9.83432382e-02f, 9.27049145e-02f, -8.97980779e-02f, 4.59779203e-02f, -5.44130802e-03f, 6.95614889e-02f, 7.24659627e-03f,
  -6.36404939e-03f, 2.35235435e-03f, -1.26165757e-02f, -3.06637269e-02f, 8.09632018e-02f, -5.73082920e-03f, -8.22386146e-02f, -1.95228141e-02f, -1.53339412e-02f, -9.11726207e-02f,
  6.66250428e-03f, 4.84042950e-02f, -9.97413695e-03f, 8.96371454e-02f, -4.10264619e-02f, 8.72906223e-02f, 1.17487982e-01f, 4.01260098e-03f, -5.16010150e-02f, 2.21370347e-02f,
  -6.09943941e-02f, -7.87362643e-03f, 6.36688471e-02f, -7.07407072e-02f, -8.85596201e-02f, 3.51291429e-03f, 8.70226882e-03f, 6.23171171e-03f, 8.28352422e-02f, 2.32114736e-02f,
  4.95983958e-02f, 4.61526550e-02f, -1.28294334e-01f, 1.35629042e-03f, -1.33399363e-03f, -4.19735257e-03f, -1.51235405e-02f, -6.26612082e-02f, -4.94295396e-02f, 1.31397406e-02f,
  -8.88962075e-02f, -7.88382441e-02f, 1.17244624e-01f, 5.61692938e-02f, -8.20436701e-03f, -1.01271316e-01f, 3.40185352e-02f, -5.39290309e-02f, 3.27131338e-02f, 2.01315917e-02f,
  -9.73299295e-02f, -4.06028271e-01f, -1.25719309e-01f, -4.59336713e-02f, 2.30209306e-01f, 1.39559925e-01f, 1.58449441e-01f, -1.57267600e-01f, -9.25474763e-02f, -1.58105671e-01f,
  1.32463038e-01f, -2.46904433e-01f, 2.38647237e-02f, -1.84592977e-01f, 1.18220858e-01f, 3.83271575e-02f, -1.47198960e-01f, -1.31832406e-01f, -6.56488836e-02f, -7.14106709e-02f,
  3.03884153e-03f, 9.50871110e-02f, 1.66760087e-02f, -2.64253896e-02f, -4.72169230e-03f, -6.15762267e-03f, 6.34041056e-02f, 1.02523588e-01f, -8.08093417e-03f, 6.86879456e-02f,
  -1.16914585e-01f, -2.00066250e-02f, 6.99388310e-02f, -1.21497763e-02f, 3.35345906e-03f, 5.67667186e-02f, 5.99866062e-02f, 1.78835869e-01f, -1.08110467e-02f, -9.08049755e-03f,
  6.10360689e-02f, 3.66710424e-02f, 1.64919142e-02f, -4.80708443e-02f, -7.61879534e-02f, -3.13459523e-02f, 2.46465076e-02f, -5.27314097e-02f, 3.36490455e-03f, 1.00517727e-01f,
  -5.49857318e-03f, 6.92892307e-03f, -2.40846388e-02f, 9.78446603e-02f, 2.82663405e-02f, 1.23962738e-01f, 1.83331128e-03f, 1.27272084e-01f, 4.22639400e-02f, 1.03998981e-01f,
  1.04192607e-01f, 6.01538904e-02f, 3.90791669e-02f, -4.81366292e-02f, -3.89942490e-02f, -4.14245576e-03f, -7.76403546e-02f, -3.93612944e-02f, -7.15831965e-02f, -1.12004615e-02f,
  1.22202719e-02f, 1.02988044e-02f, 1.04025556e-02f, 1.92433372e-02f, -2.93823387e-02f, -4.82698232e-02f, 4.15087095e-04f, 4.27197944e-03f, -4.61780690e-02f, 8.14599078e-03f,
  8.05684477e-02f, -4.18742374e-02f, -6.74415231e-02f, -3.94879049e-03f, 5.05437553e-02f, 2.46452205e-02f, -6.71259314e-02f, -3.79158445e-02f, 7.31873233e-03f, 5.62370457e-02f,
  -2.01112375e-01f, -1.87227756e-01f, 1.31952614e-02f, -3.17172669e-02f, 4.70981486e-02f, 3.44625339e-02f, 3.32202949e-02f, 3.33752972e-03f, -8.54503810e-02f, 2.27922630e-02f,
  3.33578400e-02f, -3.78945358e-02f, -9.01554897e-02f, 2.97583248e-02f, -1.95148531e-02f, 3.95762809e-02f, 2.08475720e-02f, -5.27102724e-02f, 7.48938834e-03f, -7.05426419e-03f,
  -3.42697166e-02f, -8.94770101e-02f, 8.04023072e-02f, 4.42246012e-02f, 5.19195199e-03f, 6.59992993e-02f, -9.06856954e-02f, 4.40759994e-02f, 7.10859448e-02f, -6.89923316e-02f,
  -4.94075865e-01f, 1.67284198e-02f, -3.81498560e-02f, -2.68057883e-01f, 1.18617080e-01f, 1.58118337e-01f, -1.10482015e-01f, 6.02734312e-02f, -2.53824443e-01f, 1.17060542e-01f,
  -8.68561771e-03f, -2.56013453e-01f, -9.21181068e-02f, -7.18593970e-02f, -3.68564874e-01f, -1.17084784e-02f, -1.46622568e-01f, -2.74627730e-02f, -1.50735974e-01f, -2.50112951e-01f,
  -1.11162320e-01f, 2.46467609e-02f, 1.57440975e-01f, 2.63444722e-01f, 9.91573483e-02f, 2.81389840e-02f, 1.36733443e-01f, 9.74850580e-02f, 1.79400682e-01f, 5.68545423e-02f,
  7.38611892e-02f, 4.89196628e-02f, 1.83413401e-02f, 5.80176488e-02f, -7.38688633e-02f, 7.60915205e-02f, -1.20827639e-02f, 2.56839972e-02f, -5.99733088e-03f, -5.65115809e-02f,
  -6.21465743e-02f, -5.04750386e-03f, 2.08860449e-02f, -1.15491517e-01f, 3.68863679e-02f, -6.50618970e-02f, 1.78795699e-02f, 5.23503050e-02f, 4.68480512e-02f, 3.01611307e-03f,
  2.32465193e-02f, 1.06340773e-01f, -3.30354124e-02f, 4.31939065e-02f, 3.66775841e-02f, -6.63035586e-02f, 3.03452853e-02f, 3.71733159e-02f, 6.90851063e-02f, -6.58371672e-02f,
  2.48205028e-02f, 7.35214427e-02f, 3.30645144e-02f, 5.07571697e-02f, -1.07780799e-01f, 4.38181981e-02f, -5.96010610e-02f, -9.64525118e-02f, -2.21896879e-02f, 3.24133299e-02f,
  6.72275349e-02f, -1.13220597e-02f, -2.14332473e-02f, -1.63705703e-02f, 6.71532378e-02f, 5.86937706e-04f, -7.03757536e-03f, 1.79925133e-02f, 2.00757533e-02f, 5.64656965e-02f,
  -1.36389220e-02f, -8.03135335e-02f, -3.43079604e-02f, -5.49987331e-02f, 4.14665490e-02f, -2.30176374e-02f, 2.59299744e-02f, 6.26616254e-02f, -8.20210427e-02f, 3.43911396e-03f,
  -4.60426435e-02f, -1.24926284e-01f, 5.25941662e-02f, 3.95189077e-02f, -3.44531611e-02f, -7.91935157e-03f, -2.96800788e-02f, 2.41794009e-02f, 2.11883839e-02f, -1.79332532e-02f,
  5.15298359e-02f, -6.68105436e-03f, 1.73913874e-02f, -6.44719824e-02f, 3.51619683e-02f, 1.55545510e-02f, -7.11096600e-02f, -3.73064093e-02f, -6.22319058e-02f, 6.96889237e-02f,
  2.49298532e-02f, -5.75065240e-02f, 2.53052507e-02f, 3.27364728e-02f, 9.81052816e-02f, -5.70739619e-02f, -9.46043059e-02f, 1.20228969e-01f, 5.54684475e-02f, 1.80375688e-02f,
  3.33048820e-01f, -3.63973558e-01f, -4.50691916e-02f, -2.81486750e-01f, 1.38603732e-01f, 1.22022651e-01f, 1.92871213e-01f, -2.51268428e-02f, 2.94090156e-02f, -1.25203937e-01f,
  -1.69286355e-02f, 3.61171849e-02f, -5.28526530e-02f, -3.12062174e-01f, 1.95937585e-02f, -6.41384944e-02f, -1.91321015e-01f, -6.85751513e-02f, -7.20258951e-02f, -6.36814162e-03f,
  -1.79293174e-02f, -1.01849064e-01f, -4.43235524e-02f, -6.00860976e-02f, -5.01590930e-02f, -4.33657644e-03f, -8.86994507e-03f, -2.15601251e-02f, -1.08415648e-01f, -1.77845787e-02f,
  1.05489634e-01f, 1.09777175e-01f, -2.94006569e-03f, 8.84819031e-02f, 8.72943699e-02f, 5.74433468e-02f, 8.55909958e-02f, 1.47321932e-02f, -3.49520147e-02f, -4.65546958e-02f,
  7.87716806e-02f, 2.55744737e-02f, -2.70128138e-02f, -4.03739214e-02f, -1.05379641e-01f, 2.90546869e-03f, -5.92115186e-02f, -1.02913678e-01f, -1.24227796e-02f, 5.21222800e-02f,
  -5.86289279e-02f, -3.15512680e-02f, -3.74789611e-02f, -2.86089405e-02f, 2.10756846e-02f, 2.06563622e-02f, 4.91248444e-03f, 7.80414045e-03f, 6.36981651e-02f, 5.60586341e-02f,
  -1.12275314e-02f, 1.12567067e-01f, 6.01928309e-03f, 5.13487216e-03f, -5.78877218e-02f, -3.48797776e-02f, -9.16156098e-02f, -1.85773764e-02f, -5.52040413e-02f, -2.83140149e-02f,
  -2.21208837e-02f, -6.79294690e-02f, 1.48409847e-02f, -9.46465731e-02f, 1.26784472e-02f, -2.33593751e-02f, 3.84675637e-02f, 5.51259480e-02f, -1.87004115e-02f, 2.17961036e-02f,
  1.06187969e-01f, -2.99790706e-02f, 3.02018654e-02f, 4.52793874e-02f, 1.63244549e-02f, -9.63767990e-02f, 4.83011343e-02f, -7.98466802e-02f, -7.75604025e-02f, -1.73943825e-02f,
  -7.65690506e-02f, -6.32002056e-02f, 4.45608795e-02f, 9.81859118e-02f, -8.67793486e-02f, 1.53915649e-02f, 7.14907199e-02f, 3.21767118e-04f, -1.66044626e-02f, 4.16752771e-02f,
  9.15057063e-02f, 1.67461820e-02f, 1.82575092e-03f, -7.80543387e-02f, -9.68705118e-02f, 2.53752302e-02f, -1.72172822e-02f, -6.86233863e-02f, -3.02600302e-02f, 3.75786275e-02f,
  9.13827587e-03f, 1.44838654e-02f, 3.96597087e-02f, 2.68461425e-02f, 1.75064690e-02f, 2.47360319e-02f, -8.41550156e-02f, 5.11895493e-02f, 3.52325775e-02f, -6.44081831e-02f,
  -1.92952715e-02f, -1.73041672e-01f, 2.79514879e-01f, -8.40051994e-02f, 2.26530418e-01f, -3.84948589e-02f, -1.75195888e-01f, 6.27498701e-03f, 3.03325038e-02f, -3.75294209e-01f,
  -1.01458386e-01f, 1.04065742e-02f, -5.64923994e-02f, -1.56826660e-01f, 2.02706769e-01f, -1.44429281e-01f, -5.71579486e-02f, -1.02120876e-01f, 2.27458343e-01f, -1.11557774e-01f,
  1.01090312e-01f, -3.04243803e-01f, 1.49200216e-01f, -3.26661244e-02f, -5.16491905e-02f, -9.36533213e-02f, -4.04448472e-02f, 2.25867346e-01f, -4.89376783e-02f, 2.62615476e-02f,
  1.50755988e-02f, -1.24449313e-01f, 3.45760696e-02f, 3.69528569e-02f, -9.38476622e-03f, -3.65676433e-02f, -6.69232979e-02f, -8.32105707e-03f, 6.41419813e-02f, -1.01453930e-01f,
  -5.29257394e-02f, -2.00393330e-02f, -1.26501486e-01f, -1.48758839e-03f, 7.20127895e-02f, 6.34958595e-02f, 1.11917473e-01f, 1.49179548e-01f, 2.96178423e-02f, 8.23272094e-02f,
  1.80641174e-01f, 3.47346291e-02f, 1.38956700e-02f, -6.38622567e-02f, 7.14680105e-02f, -1.37592515e-03f, -8.95105377e-02f, 2.97041461e-02f, -4.80191410e-02f, 3.83681059e-03f,
  -1.15746241e-02f, 2.98016109e-02f, 1.56738218e-02f, -5.67205325e-02f, 2.46121455e-02f, 2.47085933e-02f, 7.64629468e-02f, -6.29063174e-02f, 1.22852042e-01f, -5.92463277e-02f,
  -4.64471243e-02f, 5.17086200e-02f, 3.43933776e-02f, 7.42499828e-02f, 1.26869287e-02f, -1.78164408e-01f, -6.03561103e-02f, -2.42916457e-02f, 8.00338387e-03f, 8.34461488e-03f,
  -9.47580338e-02f, -2.49328688e-02f, 5.01018725e-02f, 6.09787293e-02f, 7.76480127e-04f, -2.40468280e-03f, -1.58991441e-02f, -1.81687670e-03f, -5.33882193e-02f, 8.73916522e-02f,
  7.61324316e-02f, -2.87039876e-01f, -1.32230436e-02f, -2.05768552e-02f, -5.49967848e-02f, -3.15939635e-02f, -1.58263929e-02f, -2.58020200e-02f, -3.16917859e-02f, -9.22164991e-02f,
  -8.04093778e-02f, 1.00067630e-01f, -3.05634234e-02f, -3.51393893e-02f, 1.31945938e-01f, -3.07466127e-02f, -5.67190796e-02f, 2.58248914e-02f, 2.22272091e-02f, -2.84728147e-02f,
  -4.77753058e-02f, -8.32672119e-02f, -5.79522327e-02f, -7.11485222e-02f, 2.03174595e-02f, -2.48855259e-03f, 5.57594635e-02f, 2.52063833e-02f, 3.39718931e-03f, 2.93206908e-02f,
  2.30504081e-01f, 5.97715005e-02f, 7.96718076e-02f, 8.06551613e-03f, 2.75512692e-02f, -1.10160284e-01f, 1.66800022e-02f, 6.10679127e-02f, 2.70378143e-01f, -3.62207703e-02f,
  -1.72421247e-01f, 2.70396143e-01f, -5.96231706e-02f, -9.40321982e-02f, -2.92807311e-01f, -1.11845419e-01f, -2.86347628e-01f, 6.87775314e-02f, 1.39654158e-02f, 4.33056615e-02f,
  -1.18444294e-01f, -2.43267477e-01f, -2.01267138e-01f, -1.21900991e-01f, 2.76147481e-02f, 8.06069598e-02f, -1.62361160e-01f, -1.65855177e-02f, -8.20786953e-02f, -3.55879404e-02f,
  -1.41239678e-02f, 1.69259697e-01f, 3.43840495e-02f, 2.70381127e-03f, -6.48814663e-02f, -1.42523004e-02f, -2.69129612e-02f, -9.33423117e-02f, -2.80098029e-04f, -8.31276923e-02f,
  -1.14198625e-02f, -3.37602124e-02f, 4.39023897e-02f, 2.75079757e-02f, 6.74596801e-02f, 1.78006217e-02f, 1.10995159e-01f, -2.22690720e-02f, 5.50768040e-02f, -4.87096906e-02f,
  -3.44576985e-02f, 3.89066450e-02f, 5.16847260e-02f, 2.28956454e-02f, 6.56380877e-02f, -5.15476577e-02f, 3.77352908e-02f, -1.97985172e-02f, 5.67088462e-03f, 1.91210918e-02f,
  6.03577383e-02f, -6.51507825e-02f, 4.49585095e-02f, -7.70330057e-02f, 5.26602864e-02f, 2.95972712e-02f, 3.42911272e-03f, 4.68284823e-02f, 1.26089722e-01f, -4.97593209e-02f,
  -3.23738568e-02f, 1.35761708e-01f, 4.23043892e-02f, -3.81711535e-02f, 4.89976890e-02f, -1.62135288e-02f, 1.41686052e-02f, -4.26515155e-02f, 2.71270741e-02f, 2.80393027e-02f,
  1.70343053e-02f, -6.13035075e-02f, -2.39660181e-02f, -1.18050545e-01f, -7.32134655e-02f, -4.54491489e-02f, -1.22314095e-02f, 2.76524108e-02f, -5.97194582e-02f, -2.08971668e-02f,
  -5.78918643e-02f, -4.66848239e-02f, -1.89494751e-02f, 4.05856036e-02f, -2.25231722e-02f, -1.16633885e-02f, 9.01952665e-03f, -1.02676816e-01f, 1.01393662e-01f, -2.64338255e-02f,
  -8.95480886e-02f, 6.15692548e-02f, 1.17359282e-02f, 8.31876919e-02f, 3.55540998e-02f, -1.58310942e-02f, -1.57639414e-01f, 4.27130982e-02f, -2.31313407e-02f, -7.57448897e-02f,
  -4.81201448e-02f, -1.85605325e-02f, 1.51797635e-02f, -1.49140321e-02f, 6.79928809e-02f, -9.35660675e-03f, 2.77989879e-02f, 2.49143075e-02f, -2.88728643e-02f, -1.20100155e-02f,
  3.44247222e-01f, 7.35506713e-02f, -1.65050197e-02f, 9.26497281e-02f, 2.30509743e-01f, 2.05147453e-02f, 6.94263205e-02f, 9.52721313e-02f, 5.77776767e-02f, -8.42473283e-03f,
  -4.34126891e-02f, -1.62359670e-01f, -1.93979636e-01f, 5.97805828e-02f, 5.40671013e-02f, -1.30881071e-01f, 1.26923651e-01f, 5.00979237e-02f, 5.02778590e-03f, 5.73331164e-03f,
  -1.71749145e-02f, 1.11638024e-01f, -2.36261096e-02f, 1.90749578e-02f, 1.59190372e-01f, 1.14225149e-01f, 1.31999359e-01f, -4.01966013e-02f, 1.05653502e-01f, 6.13273866e-02f,
  1.25845224e-01f, 4.08135429e-02f, 1.64926127e-02f, -6.81018233e-02f, 4.71733361e-02f, 7.58130327e-02f, -2.69455593e-02f, -6.64612651e-02f, -7.01564774e-02f, -7.86195844e-02f,
  -4.07449417e-02f, 5.68537600e-02f, 6.29020482e-02f, -2.16048043e-02f, 7.70475809e-03f, -8.01909268e-02f, -8.40309411e-02f, 1.04745492e-01f, -1.48690134e-01f, -4.50231954e-02f,
  -2.33954024e-02f, -1.60955021e-03f, 5.24170101e-02f, -4.46461476e-02f, 3.64740603e-02f, -1.10379877e-02f, -4.03901897e-02f, -2.57513523e-02f, 2.73303743e-02f, 1.33462790e-02f,
  5.15695550e-02f, -2.26974972e-02f, -5.14173955e-02f, 6.10355288e-02f, 8.52951333e-02f, 8.26488808e-02f, 1.31514156e-02f, -5.86530864e-02f, 3.42637226e-02f, 2.22609006e-02f,
  6.84255213e-02f, 8.02011937e-02f, -4.15215977e-02f, -8.82295221e-02f, 3.82556510e-03f, 5.60627244e-02f, -5.56378663e-02f, 1.82881489e-01f, 4.24808674e-02f, -9.79753025e-03f,
  5.75316027e-02f, 1.50577733e-02f, 7.11934566e-02f, -3.78944948e-02f, 2.97763739e-02f, 5.04201837e-02f, 3.16195143e-03f, -5.74843138e-02f, -3.67731564e-02f, 3.55046205e-02f,
  2.30464548e-01f, 2.32601121e-01f, -6.43004328e-02f, 4.01697867e-02f, 8.14631283e-02f, -1.28181443e-01f, -6.16325401e-02f, -1.91804357e-02f, 4.00551111e-02f, 6.81707496e-03f,
  -6.92714974e-02f, 7.73022398e-02f, 1.22385368e-01f, 2.35210322e-02f, -4.05953906e-04f, 1.29389474e-02f, 9.19645652e-02f, -3.62392738e-02f, 5.64375147e-02f, 1.05377480e-01f,
  -7.40859881e-02f, -3.47760879e-02f, -1.21711619e-01f, 3.40233892e-02f, -5.32602854e-02f, 6.35693818e-02f, 9.33860093e-02f, -1.40535221e-01f, 5.10120131e-02f, -4.00884897e-02f,
  -2.75449038e-01f, 8.52543339e-02f, 1.17290087e-01f, 5.55824488e-02f, 1.61305312e-02f, 3.65168214e-01f, 3.20013762e-01f, 4.01572660e-02f, 1.31249592e-01f, 2.89407313e-01f,
  1.63010061e-01f, -3.25141512e-02f, 1.79508999e-01f, 1.16514534e-01f, 1.59252644e-01f, 1.41445220e-01f, 1.90424606e-01f, 1.11601211e-01f, 4.78306413e-02f, -5.08045480e-02f,
  -1.35729715e-01f, 2.16696430e-02f, -5.23716696e-02f, -2.64580902e-02f, 2.41339989e-02f, -1.33836269e-01f, -4.99593802e-02f, 1.05363093e-01f, 1.98221877e-02f, 1.26447141e-01f,
  5.97943068e-02f, 2.93769501e-02f, -1.66890845e-01f, 2.07166579e-02f, 3.50454040e-02f, -1.19046541e-02f, 1.35749197e-02f, -2.98546311e-02f, 3.71149704e-02f, 1.00630894e-01f,
  -5.68105802e-02f, -1.02710314e-01f, 7.77118579e-02f, -1.85610969e-02f, 1.07895611e-02f, -4.13275175e-02f, -3.83065455e-02f, 8.54726285e-02f, -1.13979600e-01f, 1.20095210e-02f,
  -7.55435750e-02f, 3.85574922e-02f, -1.90321933e-02f, 1.35933265e-01f, -5.45943789e-02f, 9.35569108e-02f, 4.88413386e-02f, -1.43240159e-02f, -8.85818824e-02f, -2.63370052e-02f,
  7.07906671e-03f, 3.34562175e-02f, 1.44989435e-02f, -3.56323346e-02f, -5.30801564e-02f, 4.03835736e-02f, 1.68094598e-02f, 4.65595275e-02f, -6.16114922e-02f, 1.42534347e-02f,
  1.96407326e-02f, 3.78305949e-02f, -3.87011915e-02f, 3.61433886e-02f, 2.83804983e-02f, -5.74304275e-02f, -1.94825046e-02f, -1.75508205e-02f, 2.16706991e-02f, 8.32957029e-03f,
  -7.14722574e-02f, 1.70246866e-02f, -8.64991322e-02f, -1.66876763e-02f, 3.81457806e-02f, 7.63304308e-02f, -5.51962592e-02f, -1.83393117e-02f, 1.41980395e-01f, -1.93951745e-02f,
  1.93703040e-01f, 1.48782611e-01f, -1.85172781e-02f, -1.11814020e-02f, -7.76056200e-03f, 6.52478784e-02f, -5.39050251e-02f, -1.03738140e-02f, 7.04162568e-02f, -1.73193645e-02f,
  7.63583044e-03f, 5.17883711e-02f, 5.69518209e-02f, 4.72168289e-02f, 6.96799457e-02f, -6.96613863e-02f, 3.26754786e-02f, 9.16294456e-02f, 5.22311889e-02f, -4.45172042e-02f,
  -8.76493230e-02f, 7.22795948e-02f, -2.30014441e-03f, -4.31637950e-02f, -1.85904447e-02f, 1.50071857e-02f, 6.72648251e-02f, -3.33269238e-02f, -6.19967934e-03f, 8.53205770e-02f,
  2.78223068e-01f, 1.25907466e-01f, -1.03696428e-01f, 1.23336874e-01f, 5.88484295e-02f, 1.19521387e-01f, -4.69305664e-02f, -1.15653172e-01f, 1.16037697e-01f, 1.23112880e-01f,
  4.58423495e-02f, -5.23141846e-02f, 1.32606640e-01f, -9.22303181e-03f, 1.54863656e-01f, 8.65868106e-02f, 1.84230849e-01f, 2.77095605e-02f, 6.65104464e-02f, 6.06029369e-02f,
  4.74682963e-03f, -1.23086333e-01f, -1.02601647e-01f, -1.45929292e-01f, -6.10350817e-02f, -1.35824550e-02f, -9.10781324e-03f, -2.06191301e-01f, -1.77259624e-01f, -4.94705997e-02f,
  1.61139578e-01f, -9.20849517e-02f, -1.68345179e-02f, -1.04279444e-01f, 6.04617223e-02f, 2.38033645e-02f, -3.57307419e-02f, -2.01339543e-01f, -2.30724216e-02f, -7.52039626e-02f,
  6.94361795e-03f, 1.14108153e-01f, -8.35378319e-02f, 1.94457769e-02f, -7.56907836e-02f, -9.15981978e-02f, -2.99456026e-02f, -3.26933595e-03f, -3.89591679e-02f, 3.56066488e-02f,
  -2.42653787e-02f, -3.25255506e-02f, -5.96694835e-03f, -7.59775564e-02f, -2.25055609e-02f, 6.22497238e-02f, -5.90009801e-03f, -1.48479015e-01f, -9.24257841e-03f, 3.41677628e-02f,
  -7.75244981e-02f, 7.50661641e-02f, -8.60649049e-02f, 2.00461205e-02f, 3.56689189e-03f, -2.06665657e-02f, 2.04315893e-02f, 5.57345301e-02f, -4.77280058e-02f, 7.79425949e-02f,
  2.57131886e-02f, -7.19105173e-03f, -9.79306176e-02f, 5.43385334e-02f, -4.71479557e-02f, -7.62839168e-02f, -5.55724725e-02f, 9.42491554e-03f, 3.38459462e-02f, -5.69933243e-02f,
  -3.12541127e-02f, 1.51935056e-01f, 1.36834225e-02f, 1.03781661e-02f, -4.74543795e-02f, -2.72037238e-02f, 9.20749009e-02f, -7.19969645e-02f, 5.30907065e-02f, -8.69560391e-02f,
  2.90970355e-01f, 9.87224504e-02f, -4.84123267e-02f, -5.75727317e-03f, 1.12731261e-02f, -6.34215400e-02f, -1.20182261e-01f, 8.43041204e-03f, -7.86465965e-03f, -5.04457317e-02f,
  -3.74609753e-02f, -3.11563611e-02f, 3.59213203e-02f, 1.03525165e-03f, -2.43690740e-02f, 2.93077659e-02f, 8.26146379e-02f, 6.64415583e-02f, 2.93725338e-02f, 6.73894435e-02f,
  -3.06157060e-02f, -7.30331913e-02f, -9.58443955e-02f, -7.03128055e-02f, 3.75370658e-03f, 5.58351725e-02f, -7.00543541e-03f, -7.09621906e-02f, -4.22765315e-02f, 4.80153523e-02f,
  3.61528754e-01f, 1.78728119e-01f, 1.26879498e-01f, 2.30638653e-01f, 3.02873347e-02f, -5.61852232e-02f, -9.60540622e-02f, 6.81781322e-02f, 6.62566945e-02f, -5.92982024e-02f,
  -1.73214138e-01f, 1.39188275e-01f, -2.02685073e-01f, 2.14798838e-01f, 3.09321601e-02f, -2.21479654e-01f, 1.85793683e-01f, 5.98918311e-02f, -6.61305189e-02f, 8.86876881e-02f,
  1.73867598e-01f, 2.19781443e-01f, 1.35090025e-02f, 6.91498816e-02f, 1.59362838e-01f, 1.69805557e-01f, -1.83942472e-03f, -1.13056451e-02f, 1.92484781e-01f, 6.64788485e-02f,
  -6.25929683e-02f, -2.38437913e-02f, 2.52215434e-02f, 1.85989961e-02f, 9.68061574e-03f, -2.89011002e-02f, -4.34818678e-04f, 4.25470481e-03f, 4.49882209e-04f, 6.92490339e-02f,
  7.09318295e-02f, -2.92223692e-03f, 9.37268808e-02f, 3.41498926e-02f, -3.26544009e-02f, 8.23414922e-02f, 2.52543800e-02f, -8.03904831e-02f, 1.20687708e-02f, -3.45938676e-03f,
  -3.92645076e-02f, 4.47146259e-02f, 3.66499834e-02f, 7.42267743e-02f, 4.39067781e-02f, -2.63092238e-02f, -3.67997065e-02f, -1.17743621e-02f, 2.54783407e-02f, 1.53678477e-01f,
  2.36265920e-02f, 3.34970094e-02f, 5.83641119e-02f, 1.20001333e-02f, 1.54484594e-02f, -1.04943325e-03f, -1.23822270e-02f, -6.19822182e-02f, -2.35549137e-02f, 4.01270054e-02f,
  -2.80647054e-02f, -5.17855696e-02f, 3.51879112e-02f, -1.43015340e-01f, 1.35720924e-01f, 7.60696828e-02f, 5.33634834e-02f, 2.25810781e-02f, 3.36147621e-02f, 4.28564996e-02f,
  -2.17647199e-02f, -1.15748402e-02f, 3.46087222e-03f, -2.71106083e-02f, -8.90501067e-02f, -9.59610119e-02f, -4.14949283e-03f, 1.42093733e-01f, -1.20669939e-01f, -1.20725282e-01f,
  7.53322942e-03f, 8.43838230e-02f, -3.23415659e-02f, 7.25721642e-02f, -1.01889409e-01f, 3.26384827e-02f, 1.58096720e-02f, 1.13257691e-01f, 9.13411975e-02f, 1.06303021e-01f,
  1.44075572e-01f, -5.35572767e-02f, -2.75697634e-02f, -6.23601079e-02f, -4.93661352e-02f, 6.49167448e-02f, -4.22961712e-02f, -2.00633425e-02f, 7.74403661e-02f, 1.05625190e-01f,
  -2.94559402e-03f, -8.42083991e-02f, -2.86311824e-02f, -2.37599760e-02f, -3.29375975e-02f, -6.99232295e-02f, -9.66896787e-02f, -7.36147631e-03f, 2.45083179e-02f, 1.38525125e-02f,
  -2.60400951e-01f, -7.04724044e-02f, -8.93775672e-02f, -2.55126245e-02f, 8.87032226e-02f, 7.06661865e-02f, 1.83427669e-02f, 1.95431963e-01f, -1.77812696e-01f, -8.75346363e-03f,
  -3.54790017e-02f, -3.03115368e-01f, -1.56752914e-01f, -1.27439843e-02f, -3.86683196e-01f, -1.81926325e-01f, -1.80224225e-01f, -1.63514227e-01f, -6.61522672e-02f, -9.32980478e-02f,
  -6.55457824e-02f, 1.46718219e-01f, 7.23719746e-02f, 2.61311859e-01f, 2.50389606e-01f, 1.86396807e-01f, 8.08730945e-02f, -2.60785706e-02f, 1.32418722e-01f, 1.98569149e-03f,
  9.66950599e-03f, 2.66401414e-02f, 4.35890853e-02f, 7.65223196e-03f, 5.77331372e-02f, 7.75364339e-02f, -9.07159522e-02f, 2.86041666e-02f, -3.20211872e-02f, 3.78877856e-02f,
  -5.49023114e-02f, 4.41701226e-02f, 4.84394804e-02f, 1.06688023e-01f, -1.38682220e-02f, -3.99663635e-02f, 5.09253480e-02f, 4.09203134e-02f, -3.20123285e-02f, 3.39714102e-02f,
  3.63720991e-02f, -2.99404404e-04f, -7.19126165e-02f, -5.60421422e-02f, 3.29955332e-02f, -2.00605989e-02f, 8.42885524e-02f, -6.87888730e-03f, 1.30636260e-01f, -3.91023495e-04f,
  1.79177336e-02f, 1.74342357e-02f, 4.92165759e-02f, 2.94739716e-02f, -8.23943764e-02f, 5.94802462e-02f, -1.46056280e-01f, 3.40309292e-02f, 1.55883823e-02f, -6.02851016e-03f,
  1.47640910e-02f, -1.95662398e-02f, 3.71142775e-02f, 9.38522350e-03f, 1.50145590e-02f, 7.52686411e-02f, -1.36588782e-01f, 9.74915847e-02f, 4.02602665e-02f, 9.61729046e-03f,
  4.77679260e-02f, -9.09647793e-02f, -1.09728932e-01f, 2.09428240e-02f, -3.95787656e-02f, -4.32803594e-02f, 1.02194250e-01f, -6.62347022e-03f, -6.75785393e-02f, -6.64300425e-03f,
  -1.48168042e-01f, -6.04429767e-02f, 4.97237034e-02f, 4.92280908e-02f, -4.75943871e-02f, 2.97713410e-02f, -1.22907154e-01f, 2.20809542e-02f, -5.42807728e-02f, 9.48932394e-02f,
  2.11434681e-02f, 4.26904075e-02f, -4.01673876e-02f, 3.42890806e-02f, -6.54479265e-02f, 6.70568272e-02f, -8.47096443e-02f, -7.35883713e-02f, 5.69488145e-02f, 2.54733898e-02f,
  8.50073472e-02f, -1.85188930e-02f, 4.02060188e-02f, 2.95076128e-02f, 8.60488936e-02f, -1.13598974e-02f, 6.48060162e-03f, -1.12679787e-02f, -1.28453067e-02f, -5.17219044e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.69069940e-02f, -1.07507594e-01f, -2.32647717e-01f, -2.93005377e-01f, 8.45064223e-02f, -2.04483420e-01f, -2.58390695e-01f, -1.41889721e-01f, -2.14170367e-02f, -2.24526808e-01f,
  -1.30237028e-01f, -3.78728397e-02f, 1.33225173e-01f, -2.75627375e-01f, 8.91867876e-02f, 9.20727625e-02f, -2.33041033e-01f, -1.09537028e-01f, 8.61855149e-02f, -1.59353122e-01f,
  -8.49772766e-02f, -1.78515166e-01f, -1.03608249e-02f, -5.87601550e-02f, -2.37925097e-01f, -2.16996714e-01f, -3.64932641e-02f, -1.76431034e-02f, -2.34564558e-01f, -3.06432531e-03f,
  5.44703100e-03f, -7.90845454e-02f, -5.56188375e-02f, -3.67239118e-02f, 5.91140985e-02f, -1.97663624e-02f, -1.03786796e-01f, -8.00181180e-02f, 1.08953431e-01f, -1.07538849e-02f,
  -5.25388457e-02f, -6.93352101e-03f, -7.24164695e-02f, -4.02713828e-02f, -1.97780263e-02f, -8.42455998e-02f, 7.89948329e-02f, 1.44147813e-01f, -1.19546808e-01f, -6.33582622e-02f,
  -4.14498560e-02f, 8.18341598e-02f, -3.11760139e-02f, 1.17473118e-02f, -7.29017705e-02f, -3.41131985e-02f, 3.01351808e-02f, -4.82301265e-02f, 1.97394062e-02f, -5.09542786e-02f,
  -5.06579578e-02f, -5.55359907e-02f, -2.27740705e-02f, -2.69156285e-02f, 2.93095596e-02f, 1.26597760e-02f, -9.96193197e-03f, 5.43582551e-02f, 3.58671658e-02f, -2.21171994e-02f,
  1.91728063e-02f, 5.45354411e-02f, 5.11702001e-02f, -1.08185954e-01f, -8.08538571e-02f, -7.08829165e-02f, -9.09141451e-02f, -5.83471842e-02f, -8.08126405e-02f, 1.12971470e-01f,
  8.13820213e-03f, -2.28707530e-02f, 1.91657264e-02f, -9.67723429e-02f, -5.28275259e-02f, 4.45113480e-02f, -6.59075081e-02f, -8.76489803e-02f, -1.12857530e-03f, 2.22457815e-02f,
  -2.56667589e-03f, -4.29671258e-03f, 1.98176708e-02f, 6.21045530e-02f, -9.82738379e-03f, 2.21375059e-02f, -5.74517697e-02f, -1.11129671e-01f, 6.33867308e-02f, -1.20158002e-01f,
  -1.08292706e-01f, 3.95287797e-02f, 1.52873144e-01f, 6.60835393e-03f, -2.08104393e-04f, -6.30466938e-02f, -3.47456001e-02f, 1.26203522e-01f, 4.60880250e-02f, -4.69865017e-02f,
  -3.50818560e-02f, -3.10221198e-03f, -1.11130197e-02f, 2.51303371e-02f, -8.02847520e-02f, 8.78385361e-03f, 1.34243518e-01f, -7.73648471e-02f, 3.22207920e-02f, 1.06788673e-01f,
  2.67974228e-01f, 1.30977258e-01f, -3.14040840e-01f, -1.12323083e-01f, -1.02952927e-01f, 2.86321908e-01f, 2.16864675e-01f, -7.88206160e-02f, -1.05894782e-01f, 2.42971808e-01f,
  1.95873767e-01f, -5.70226125e-02f, 9.03285816e-02f, 3.50199550e-01f, 2.09419653e-02f, 1.81059107e-01f, 2.06666142e-01f, 2.06641167e-01f, -4.95757349e-02f, 3.25355008e-02f,
  -2.16109343e-02f, 3.41588676e-01f, 7.17266230e-03f, -3.01362295e-02f, 1.94728032e-01f, -2.59768426e-01f, -7.70780677e-03f, -2.24125758e-01f, -4.59334813e-02f, -1.75339878e-02f,
  5.87759074e-03f, -2.14526746e-02f, -1.54848536e-02f, 2.16257013e-02f, 5.02947345e-03f, 5.10828830e-02f, 1.14827193e-02f, -2.69955024e-02f, -1.32325485e-01f, -3.00771054e-02f,
  -3.02562043e-02f, -1.78315789e-02f, 1.38708008e-02f, -4.98323850e-02f, 8.48630667e-02f, -3.02069746e-02f, -1.00112036e-02f, -1.11725785e-01f, 7.01739788e-02f, 9.85292196e-02f,
  -9.20734927e-02f, -3.58910486e-03f, -1.57317985e-02f, -9.71388221e-02f, -1.06098719e-01f, 9.19582206e-04f, 5.52738048e-02f, -4.84692454e-02f, 4.26792428e-02f, 8.48316476e-02f,
  3.21820080e-02f, 7.91992694e-02f, 5.11304699e-02f, 1.86621007e-02f, 1.16999149e-02f, -6.49358109e-02f, 6.68526515e-02f, 1.06514525e-03f, -5.84879741e-02f, 8.23592171e-02f,
  1.53798563e-02f, 1.53346602e-02f, 8.58041346e-02f, 3.45877260e-02f, -2.07614843e-02f, 3.94248925e-02f, 2.09488487e-03f, -5.34502566e-02f, -1.31832749e-01f, 4.86977398e-03f,
  7.99457952e-02f, -8.82031098e-02f, -1.07780159e-01f, 3.82958353e-02f, 3.83567065e-02f, -9.29900855e-02f, 1.33966044e-01f, -2.19598562e-02f, -3.02423667e-02f, -4.82694991e-02f,
  2.80101201e-04f, -4.67072092e-02f, -4.81464267e-02f, -4.04069275e-02f, -1.05812952e-01f, 3.72060351e-02f, 7.04788044e-02f, 1.57226920e-02f, -1.29803549e-02f, 5.25401272e-02f,
  1.22387810e-02f, -7.89533406e-02f, -2.63501294e-02f, -6.72837421e-02f, -5.97614888e-03f, 5.85370585e-02f, 7.98349380e-02f, -8.37509111e-02f, 1.79077627e-03f, -1.93262193e-02f,
  4.91210967e-02f, -1.88578144e-02f, 2.07021162e-02f, -1.24872431e-01f, 4.32267739e-03f, -2.73645390e-02f, -5.98481707e-02f, -3.89089920e-02f, 1.27331048e-01f, -8.21546987e-02f,
  -2.04028830e-01f, -3.10249507e-01f, 1.55232176e-01f, -9.84846056e-02f, 1.59852833e-01f, 3.07904154e-01f, 9.69853178e-02f, -5.66066653e-02f, -2.83012718e-01f, -2.68265486e-01f,
  -2.86276024e-02f, -2.06640214e-01f, -4.31127697e-02f, -1.54429242e-01f, 2.03495085e-01f, -7.66559318e-02f, 2.28500366e-02f, -6.35343743e-03f, -6.16308041e-02f, -2.22687144e-02f,
  -1.04110157e-02f, -8.11658055e-02f, 1.28180131e-01f, 1.05360793e-02f, -7.02322870e-02f, -9.23920721e-02f, 5.22179194e-02f, 2.65774518e-01f, 6.19185567e-02f, 7.30818585e-02f,
  1.37903348e-01f, -2.33225450e-01f, 5.91070950e-02f, 6.70161247e-02f, 1.07002288e-01f, 1.70051847e-02f, 3.77236046e-02f, 3.28091197e-02f, 2.66769864e-02f, -5.66380396e-02f,
  3.74641875e-03f, -5.01248613e-02f, -5.61694726e-02f, 4.62812111e-02f, -2.92985365e-02f, -7.96753690e-02f, 5.86278513e-02f, 2.98819244e-02f, 1.08285338e-01f, -5.48446625e-02f,
  -1.38068274e-02f, 3.15301903e-02f, -1.44754633e-01f, -9.47424620e-02f, -1.04793333e-01f, -9.22674220e-03f, 1.61590856e-02f, -3.87419276e-02f, -6.26261206e-03f, 7.63425417e-03f,
  -4.17433754e-02f, -2.80353352e-02f, 4.39828960e-03f, -3.85195799e-02f, 2.32330635e-02f, -7.24874884e-02f, 2.28523184e-02f, 1.14201317e-02f, -7.40545690e-02f, -2.80725397e-02f,
  -3.88742425e-02f, 1.77881587e-02f, 1.14148725e-02f, 2.20227949e-02f, -1.24258157e-02f, -6.13288954e-02f, 3.90946940e-02f, -3.88167910e-02f, -4.97569032e-02f, 1.94297507e-02f,
  -3.48587334e-02f, 4.29631248e-02f, -1.33876264e-01f, -9.85382870e-02f, 1.48871422e-01f, -1.25422748e-02f, -8.13324824e-02f, -2.95778904e-02f, -8.82442072e-02f, 2.08810903e-02f,
  6.56264946e-02f, -2.75647521e-01f, 3.04538365e-02f, 2.19497234e-02f, 8.64996538e-02f, 2.92556565e-02f, -2.92587504e-02f, -1.07489331e-02f, -1.07910179e-01f, -7.18148872e-02f,
  3.49663533e-02f, 4.22987007e-02f, 7.70201534e-02f, 1.85551196e-02f, 1.01678938e-01f, -8.45249221e-02f, 4.70913947e-02f, 1.54140502e-01f, 7.49013498e-02f, 7.43924528e-02f,
  1.69981867e-02f, -3.16325240e-02f, -6.87133670e-02f, -1.42016545e-01f, 3.67648490e-02f, 3.14641632e-02f, 2.38396116e-02f, -8.19278229e-03f, -1.34405479e-01f, -1.57556534e-02f,
  3.98611784e-01f, -2.31961623e-01f, -2.82900542e-01f, 8.05004463e-02f, 2.17283264e-01f, 2.27217242e-01f, 1.25382751e-01f, 7.29134232e-02f, 4.86158906e-03f, -1.18812241e-01f,
  2.22651780e-01f, -1.29676506e-01f, -1.97451293e-01f, 2.13733509e-01f, 3.00911009e-01f, -2.18046337e-01f, 1.95368588e-01f, 1.11932829e-01f, -4.85507725e-03f, 7.49072358e-02f,
  1.31837055e-01f, 3.58497292e-01f, -3.99773866e-02f, -2.39087455e-02f, 6.60300180e-02f, -1.58204511e-01f, 7.36422325e-03f, -1.50093734e-01f, 1.19906969e-01f, 1.25191748e-01f,
  3.51547413e-02f, 6.49475381e-02f, -3.44938040e-02f, 5.53018227e-03f, -4.17505056e-02f, -1.43374072e-03f, -7.80333802e-02f, -4.76210285e-03f, 9.24933702e-02f, 4.69692098e-03f,
  -5.11421077e-02f, 4.36088890e-02f, -5.74825564e-03f, 1.16207771e-01f, 8.89920369e-02f, 9.91275609e-02f, -3.30068395e-02f, -1.81779023e-02f, -1.40650317e-01f, 1.55676771e-02f,
  -1.14740513e-01f, 3.03418562e-02f, 8.14721659e-02f, -1.19700603e-01f, -7.75811598e-02f, 3.44740786e-02f, -1.13716990e-01f, -1.70274734e-01f, -7.83165172e-02f, 1.43681625e-02f,
  1.00751452e-01f, -7.04506934e-02f, 7.85364881e-02f, 6.85641468e-02f, 5.71752265e-02f, 1.64573025e-02f, 9.78484005e-02f, 2.16588415e-02f, -3.44569981e-03f, 3.34090367e-02f,
  1.58167947e-02f, 1.45125329e-01f, -6.38062414e-03f, -1.41034285e-02f, -3.86833400e-02f, -3.25372703e-02f, -2.20770966e-02f, -2.53640898e-02f, -3.45082805e-02f, -5.89988902e-02f,
  -2.24732012e-02f, -7.76539696e-03f, -1.81227867e-02f, -4.51302901e-02f, -3.94391306e-02f, 1.40860662e-01f, 1.34253621e-01f, 5.75763732e-02f, -1.85609106e-02f, 5.17167635e-02f,
  2.56763911e-03f, -1.78399369e-01f, -9.00240615e-02f, 5.11178225e-02f, -1.14981011e-01f, -6.39937213e-03f, -5.58376797e-02f, -1.69072673e-02f, -3.39141041e-02f, -8.54277462e-02f,
  -4.86196131e-02f, 7.60259554e-02f, -3.33021656e-02f, 6.14484176e-02f, 7.96681717e-02f, 5.83266579e-02f, -1.25704616e-01f, -5.35494909e-02f, 3.09981667e-02f, 2.60203774e-03f,
  -6.02300875e-02f, -3.64808962e-02f, -4.68435921e-02f, -6.36053458e-02f, 1.47225279e-02f, -1.52647167e-01f, 5.48772775e-02f, -5.90269975e-02f, -9.18888226e-02f, -8.37281346e-02f,
  1.37275293e-01f, -2.82745324e-02f, -2.69496381e-01f, -2.78866470e-01f, 1.78117886e-01f, 1.18443057e-01f, -6.50687888e-02f, 6.25314564e-02f, -3.16485107e-01f, 1.79784477e-01f,
  -6.20302744e-03f, -3.07140678e-01f, -1.58098996e-01f, -2.80910313e-01f, -2.37097919e-01f, -2.77955800e-01f, 3.03369947e-02f, -1.52390346e-01f, -2.89080366e-02f, 8.01756829e-02f,
  -4.91834506e-02f, 1.06784053e-01f, -3.26703399e-01f, 1.54436037e-01f, 1.21616267e-01f, 1.43814161e-01f, 3.87306958e-01f, 1.27515703e-01f, 1.33043408e-01f, 9.90353711e-03f,
  5.23976274e-02f, -5.80094419e-02f, -1.27902269e-01f, -6.54854253e-02f, 7.90623352e-02f, 2.02644840e-01f, 1.15230560e-01f, -7.82702267e-02f, -3.44227180e-02f, -1.07459920e-02f,
  5.12256175e-02f, -1.11896411e-01f, -3.52500379e-02f, -2.28661522e-02f, 5.13962172e-02f, 3.39694098e-02f, -1.18417338e-01f, -3.40211876e-02f, -1.42780751e-01f, -1.20386437e-01f,
  -1.73561007e-01f, -8.97165015e-03f, 2.92787980e-02f, -1.62048623e-01f, -1.43485785e-01f, 4.74001616e-02f, -1.32222585e-02f, 9.09268204e-03f, 8.30462873e-02f, 3.27897854e-02f,
  1.43984213e-01f, 1.63599551e-01f, -3.11447051e-03f, -9.64814797e-02f, -1.01717293e-01f, 2.46018674e-02f, -2.88215261e-02f, -1.44532677e-02f, -5.12736514e-02f, 3.10692918e-02f,
  -1.81398429e-02f, -5.40953279e-02f, 3.19002382e-02f, -2.05447264e-02f, 1.34423068e-02f, 3.48119102e-02f, -2.02391436e-03f, 6.38573989e-02f, -3.09218094e-02f, -5.99486008e-02f,
  -7.62134837e-03f, -3.34720430e-03f, 1.40338410e-02f, 1.74917858e-02f, 9.35459789e-03f, -5.18963113e-02f, 7.47933006e-03f, 3.79685797e-02f, 2.02447418e-02f, -5.07801445e-03f,
  7.15268403e-02f, 7.65372887e-02f, 1.54135822e-04f, -2.78231055e-02f, -5.76781295e-02f, 1.87311657e-02f, -1.70892607e-02f, -6.76725730e-02f, -1.59440357e-02f, 1.06672846e-01f,
  9.39786360e-02f, -3.52780637e-03f, 1.60483375e-01f, -8.57425574e-03f, 8.27157199e-02f, 1.29437223e-01f, 4.75743376e-02f, 4.48287316e-02f, 6.51330799e-02f, 9.49469581e-02f,
  8.23161155e-02f, 9.84728262e-02f, -1.65231321e-02f, -4.21714149e-02f, -3.51261459e-02f, 1.23497427e-01f, 1.51323482e-01f, 7.97284693e-02f, 4.18238826e-02f, -6.08411916e-02f,
  -3.49113405e-01f, 1.21926300e-01f, 1.92502186e-01f, 4.58787940e-02f, -7.14976266e-02f, -4.24046993e-01f, -2.45084777e-01f, 2.05671549e-01f, -6.65784627e-02f, 1.09193034e-01f,
  2.28350446e-01f, -1.30700231e-01f, 1.84645981e-01f, 1.59410313e-02f, -6.42195269e-02f, 2.55053416e-02f, -1.49135336e-01f, -1.92961156e-01f, 1.60891358e-02f, 1.38772637e-01f,
  3.48140486e-02f, 4.97737750e-02f, 6.81300461e-02f, 8.26481804e-02f, 2.67402586e-02f, 1.29570872e-01f, 2.53439516e-01f, 7.92302042e-02f, 1.01922441e-03f, -1.19731948e-01f,
  -3.76881361e-02f, 1.73835754e-01f, 7.80696943e-02f, -6.65510297e-02f, 1.06154695e-01f, -8.58519897e-02f, -4.93419245e-02f, -2.71957945e-02f, 2.54895184e-02f, 3.55607122e-02f,
  -7.01915696e-02f, 5.77247702e-02f, -5.83054423e-02f, -9.50317159e-02f, -1.05216779e-01f, -9.77326185e-03f, -2.38173027e-02f, -5.97550124e-02f, -4.09690067e-02f, -1.82695221e-02f,
  8.16672370e-02f, -1.04889087e-01f, -3.37484106e-02f, 3.02966442e-02f, 2.50247810e-02f, -9.09849885e-04f, -5.90608977e-02f, 2.35290406e-03f, -6.90331757e-02f, -6.61946982e-02f,
  -3.51156108e-03f, -5.67605393e-03f, -6.73293844e-02f, 1.08111687e-01f, 1.37956254e-02f, 9.63556170e-02f, -1.25223219e-01f, -4.28975448e-02f, -3.50926705e-02f, 2.75886208e-02f,
  -1.23913707e-02f, -6.71234876e-02f, 2.91911280e-03f, -3.06753088e-02f, -4.05661911e-02f, 4.62906994e-02f, -4.25485894e-02f, 3.27153541e-02f, -7.15160891e-02f, 6.38803840e-02f,
  1.78658664e-01f, -1.55886551e-02f, 5.64610176e-02f, -7.22850040e-02f, -2.00708862e-02f, 4.00874438e-03f, -3.44313830e-02f, -2.86290310e-02f, 1.22613132e-01f, -6.00196831e-02f,
  1.33573979e-01f, 3.45379055e-01f, 1.22688815e-01f, -8.76247436e-02f, -5.75054949e-03f, -6.48897067e-02f, 8.89068618e-02f, -3.05807870e-02f, -5.39056072e-03f, 2.47238521e-02f,
  2.11442932e-02f, -1.37119489e-02f, -6.96645826e-02f, -7.24349171e-03f, -4.77887057e-02f, 6.38747737e-02f, 9.11230966e-02f, 6.28785864e-02f, -3.32131423e-03f, 1.58602148e-02f,
  4.86240312e-02f, -1.01663861e-02f, -1.87863097e-01f, -5.41123971e-02f, -2.94088689e-03f, 4.69909795e-03f, -1.69978775e-02f, -3.02331280e-02f, 3.12250052e-02f, -3.93562987e-02f,
  -1.65149197e-01f, -4.81438404e-03f, 6.75318986e-02f, 2.54887432e-01f, -7.37280399e-02f, -2.92571455e-01f, -2.63150513e-01f, 3.94609682e-02f, -7.46410862e-02f, -1.95145965e-01f,
  -8.02793801e-02f, 1.15008220e-01f, -6.93663210e-02f, 3.31000894e-01f, 3.11590254e-01f, 6.41577691e-02f, 1.16805151e-01f, -5.78682944e-02f, 4.74923439e-02f, 1.89871695e-02f,
  2.13772371e-01f, 1.97608948e-01f, 1.49631098e-01f, 1.35437682e-01f, -4.03822660e-02f, 1.08193345e-01f, 2.68322796e-01f, 1.25698606e-02f, 2.84285069e-01f, 1.00829735e-01f,
  -7.79794008e-02f, 3.80470641e-02f, -1.74390397e-03f, -5.86117851e-03f, 2.83468943e-02f, -3.51435021e-02f, 3.14517468e-02f, 9.44971573e-03f, 6.79872409e-02f, 2.87289433e-02f,
  -4.00438383e-02f, 8.99623856e-02f, 6.29535317e-02f, -2.11914834e-02f, -7.71429911e-02f, -2.52634380e-02f, -3.60123366e-02f, -1.81662943e-03f, 1.33643383e-02f, -1.38015598e-01f,
  -7.35102892e-02f, 1.61658402e-03f, -2.92427950e-02f, 7.09939748e-02f, 8.23623314e-02f, -7.05856159e-02f, 9.29856021e-03f, 7.27987811e-02f, 5.64904027e-02f, 6.74576312e-02f,
  5.80875622e-03f, -4.15465757e-02f, -8.15511793e-02f, -4.50106077e-02f, -1.25219867e-01f, -2.97650658e-02f, -4.57245260e-02f, -5.69063127e-02f, 5.28925024e-02f, -4.60411236e-02f,
  4.86792177e-02f, -5.08802384e-02f, -5.38520105e-02f, -4.02607583e-02f, 6.56818077e-02f, 1.40082082e-02f, 6.93302751e-02f, 8.70081931e-02f, -7.24904016e-02f, -1.31857395e-02f,
  -3.61614674e-02f, 9.31924209e-03f, -3.52732092e-02f, 1.22974731e-01f, -4.09247875e-02f, -1.39135402e-02f, 8.74280408e-02f, -6.01979345e-02f, -1.45798139e-02f, 2.06123907e-02f,
  1.00042820e-01f, 1.25151411e-01f, -9.41682607e-02f, 2.24201903e-02f, 5.50630726e-02f, 2.74153873e-02f, 5.96691221e-02f, 7.49534592e-02f, 7.75981769e-02f, 2.02816166e-02f,
  -5.69330854e-03f, -3.22023556e-02f, -7.23136589e-02f, -1.39704049e-02f, 2.30750497e-02f, 5.99974729e-02f, 8.79055634e-02f, 5.61687760e-02f, 7.25086257e-02f, 5.11941053e-02f,
  9.87558346e-03f, -1.05734512e-01f, 5.99291921e-02f, 3.33898664e-02f, 2.04254836e-02f, -2.62912828e-02f, -5.91080785e-02f, -2.72568744e-02f, 8.03425163e-02f, 4.63829897e-02f,
  1.00756347e-01f, 3.98171484e-01f, -8.76058266e-02f, 1.03300877e-01f, 9.70902890e-02f, 2.94592619e-01f, 2.17201814e-01f, 1.05163090e-01f, 2.08570123e-01f, 2.04558820e-01f,
  -7.90178180e-02f, 1.62358046e-01f, 1.41541166e-02f, 5.07972986e-02f, 9.60682109e-02f, -3.44761088e-02f, 1.87732980e-01f, -5.72855351e-03f, -4.25402671e-02f, 2.06903130e-01f,
  2.08306964e-02f, 1.38882264e-01f, -1.65857077e-01f, -3.97169124e-03f, -1.91635396e-02f, -1.02202855e-01f, -1.71997502e-01f, -1.85718834e-01f, -2.15496905e-02f, 3.16244029e-02f,
  -8.85210838e-03f, -1.35129746e-02f, 4.05710191e-02f, 3.50350887e-02f, 6.55135512e-02f, 1.16212562e-01f, 2.44158376e-02f, -2.48231012e-02f, -1.01107642e-01f, 7.59891346e-02f,
  6.16938062e-02f, 1.31875454e-02f, 7.90463760e-02f, 2.58107278e-02f, -1.04306340e-02f, -9.80707724e-03f, -7.16953054e-02f, -1.71563804e-01f, 2.77134907e-02f, 4.49045114e-02f,
  -8.39392245e-02f, -3.54514718e-02f, -9.32587311e-04f, 3.59816290e-02f, -5.32777868e-02f, -1.00732576e-02f, 5.08993454e-02f, 3.16267870e-02f, 1.74832880e-01f, 1.16284467e-01f,
  4.03411128e-02f, 1.30605131e-01f, 8.72689113e-02f, -6.21141717e-02f, -8.38721097e-02f, -1.59970924e-01f, -1.28286527e-02f, -6.26809075e-02f, -3.10456031e-03f, 5.75119033e-02f,
  -3.62478825e-03f, -1.10500693e-01f, -7.70493075e-02f, -6.26398399e-02f, -4.27871905e-02f, 4.35105041e-02f, 3.85079198e-02f, 1.19171545e-01f, 6.48962036e-02f, -3.79277952e-02f,
  -1.86756849e-02f, 1.39343622e-03f, 5.24264649e-02f, 1.35210706e-02f, -1.04283467e-01f, -2.29880102e-02f, 1.25567755e-02f, -6.11630268e-02f, -1.09593617e-02f, -1.32726328e-02f,
  1.72850460e-01f, 3.22938979e-01f, -7.04539940e-03f, 4.17966917e-02f, -2.07226239e-02f, 7.13733807e-02f, 4.70525250e-02f, 9.32225287e-02f, 2.11766493e-02f, 1.01352304e-01f,
  9.55159590e-02f, -7.72938952e-02f, 7.53215328e-02f, -3.09601128e-02f, 5.16938744e-03f, 1.48312539e-01f, 5.52767627e-02f, -4.58957180e-02f, 8.59337151e-02f, 4.29640301e-02f,
  3.62014100e-02f, 9.29241441e-03f, 7.80551732e-02f, -2.89747808e-02f, -1.79663878e-02f, -2.12983675e-02f, 8.67178738e-02f, 3.09855789e-02f, 6.07145689e-02f, 5.74638955e-02f,
  -9.12882313e-02f, -1.16907634e-01f, -2.23879308e-01f, 8.69070590e-02f, 7.61599839e-02f, -3.79145928e-02f, -1.27321482e-01f, 1.18689500e-01f, -1.97325304e-01f, 4.23922911e-02f,
  6.70176819e-02f, 7.03756372e-03f, -1.83824360e-01f, 8.42476040e-02f, 1.73008606e-01f, -3.60479057e-01f, 2.22159356e-01f, -4.25978869e-05f, -1.83039278e-01f, 3.26793455e-02f,
  1.65964346e-02f, 3.33457708e-01f, 1.00077659e-01f, 2.29329512e-01f, 6.21679313e-02f, 1.25661135e-01f, 3.49612951e-01f, -4.27971669e-02f, 3.34410697e-01f, 1.94349900e-01f,
  -2.28142980e-02f, 2.23753741e-03f, -3.85410897e-02f, -4.52821404e-02f, 5.66747524e-02f, 9.22739208e-02f, -5.18434718e-02f, 2.74184570e-02f, -1.78688709e-02f, 2.98765041e-02f,
  -1.02418698e-01f, -2.20599417e-02f, 4.44706418e-02f, 3.36463638e-02f, 1.86429750e-02f, 4.83396687e-02f, 2.84292269e-04f, 4.43896651e-02f, -6.48648217e-02f, -3.12566869e-02f,
  -5.57243973e-02f, -2.73367297e-02f, -4.88121547e-02f, -6.12377189e-02f, -6.33574501e-02f, 8.88744369e-02f, 1.04126848e-01f, 6.79334626e-02f, -3.82282101e-02f, 1.51364788e-01f,
  -1.01067619e-02f, -4.00143489e-02f, -9.70105231e-02f, 1.82000995e-02f, -3.20251100e-02f, -1.15887756e-02f, -5.23767248e-02f, -3.32551189e-02f, -4.42791879e-02f, 5.20625785e-02f,
  6.07380178e-04f, 2.13905424e-02f, 3.02816667e-02f, 3.15493369e-03f, 4.80968468e-02f, 6.14694171e-02f, -4.49274629e-02f, 1.18872017e-01f, -7.94111043e-02f, -4.75933626e-02f,
  -1.01422876e-01f, 1.06443286e-01f, 3.84085462e-03f, -1.12208307e-01f, 2.84083635e-02f, 1.44133987e-02f, -3.61930802e-02f, 1.74634177e-02f, -7.34190866e-02f, -7.69334435e-02f,
  9.90741998e-02f, 2.64535304e-02f, 2.69788201e-04f, -2.35149078e-02f, 1.29065209e-03f, 5.81338331e-02f, 1.32150203e-02f, -3.12161893e-02f, -7.89168570e-03f, -2.41278484e-02f,
  1.16998635e-01f, 4.73774485e-02f, -7.64154270e-02f, -2.89278710e-03f, 1.12369955e-01f, 9.26507786e-02f, 1.27289211e-03f, 1.13625064e-01f, 7.71703869e-02f, 8.72064978e-02f,
  1.18442334e-01f, 2.86489706e-02f, 6.97905049e-02f, -5.98695390e-02f, 2.24748831e-02f, -5.14478981e-02f, 1.35474473e-01f, 5.46270832e-02f, 5.46171516e-02f, 2.11763531e-02f,
  -2.09169030e-01f, 4.86834198e-01f, -2.29821041e-01f, 2.37558968e-02f, 9.99325588e-02f, 4.15109158e-01f, 2.52794623e-01f, 8.23332146e-02f, 2.33137190e-01f, 3.25251073e-01f,
  2.26571821e-02f, 1.04632406e-02f, 9.87458229e-02f, 2.05864131e-01f, -7.97105432e-02f, 1.69750109e-01f, 1.97058290e-01f, 9.04359296e-02f, 4.98634651e-02f, 2.50065718e-02f,
  -6.21961877e-02f, 1.80851176e-01f, -1.87333524e-01f, 3.49318013e-02f, 1.73297767e-02f, -2.54629374e-01f, -8.41858312e-02f, -2.30546474e-01f, -2.71807220e-02f, 7.45461881e-02f,
  4.65630069e-02f, -2.14089043e-02f, -1.50935546e-01f, -5.45914657e-03f, -1.23073950e-01f, -8.04064497e-02f, -7.43996054e-02f, -6.20194860e-02f, -6.59184158e-02f, 7.63576925e-02f,
  3.64238247e-02f, 1.61619782e-02f, 1.04688667e-01f, -6.02838770e-02f, -2.08218750e-02f, -9.75870565e-02f, 7.94711262e-02f, 9.29020229e-04f, 6.09410964e-02f, -3.49224582e-02f,
  -4.52179909e-02f, 4.47462946e-02f, -2.53455788e-02f, 8.82452354e-03f, 2.75091454e-02f, 2.37776395e-02f, 6.62133768e-02f, -1.78235620e-02f, 7.71647394e-02f, 8.80496576e-02f,
  -5.29535897e-02f, 1.43963084e-01f, 2.78369524e-03f, 2.38711424e-02f, -8.17995965e-02f, -7.01958090e-02f, 2.67056525e-02f, -4.91955690e-02f, -6.55112639e-02f, -1.25092911e-02f,
  7.35560246e-03f, -1.42785730e-02f, -7.10198134e-02f, -3.91487665e-02f, 1.56498984e-01f, 9.36984550e-03f, -2.29660701e-02f, 3.81897613e-02f, 8.36396441e-02f, 4.51582484e-02f,
  -3.70486267e-03f, 9.59825814e-02f, -3.17543298e-02f, 2.02969126e-02f, 3.52002308e-02f, -2.64171939e-02f, 3.45270149e-02f, 1.63151026e-02f, -6.38573756e-03f, -5.66081665e-02f,
  3.10792029e-01f, 2.17417240e-01f, 4.02324125e-02f, -2.28039864e-02f, 2.07465235e-03f, -7.66042173e-02f, -4.35304753e-02f, 4.00205404e-02f, 4.07243185e-02f, 3.20601724e-02f,
  -1.86762381e-02f, -2.71320511e-02f, -5.61278267e-03f, -1.88829098e-03f, -5.86872734e-02f, 7.74922147e-02f, 5.58574162e-02f, -2.80794911e-02f, 5.26608825e-02f, 7.51882941e-02f,
  -2.44654287e-02f, -2.83842497e-02f, -8.89273956e-02f, -6.19037896e-02f, -1.72429010e-02f, 2.65727360e-02f, 1.39643773e-01f, -3.44439447e-02f, -3.57777858e-03f, 1.18440770e-01f,
  -5.27164638e-01f, 3.92510176e-01f, 2.79523998e-01f, -7.95824453e-02f, -2.73900609e-02f, -8.46147537e-02f, 1.30669430e-01f, 4.73615602e-02f, 1.41931653e-01f, 2.36391902e-01f,
  2.37716332e-01f, -2.08654581e-03f, 8.32284614e-02f, 9.85688418e-02f, -1.19534701e-01f, 2.54466217e-02f, -1.59341171e-01f, -2.81546544e-02f, 4.92401011e-02f, -1.75874665e-01f,
  -1.77106544e-01f, -7.11279809e-02f, -5.46768643e-02f, 5.67937456e-02f, 5.00869974e-02f, -1.99426692e-02f, -1.83585703e-01f, 3.35518718e-02f, 1.71195958e-02f, 4.35409546e-02f,
  1.21199235e-01f, 1.08596794e-01f, 1.25014976e-01f, 6.26409501e-02f, -7.68925156e-03f, 3.53525914e-02f, 8.13348219e-02f, -4.31015082e-02f, -3.52375209e-02f, 9.96830836e-02f,
  5.95153756e-02f, 8.68837908e-02f, 1.16140218e-02f, -8.86591598e-02f, 4.51232530e-02f, 4.52968553e-02f, -4.22889553e-02f, -3.20700719e-03f, 1.14837445e-01f, 2.33373955e-01f,
  1.63303494e-01f, 1.03681363e-01f, -6.05306290e-02f, 4.49570380e-02f, 2.36045104e-02f, 1.02263868e-01f, 7.30838850e-02f, -3.77920605e-02f, 1.08327396e-01f, 1.30783739e-02f,
  -1.12891018e-01f, 2.58195102e-02f, 9.12921096e-04f, 3.59217115e-02f, 6.31794855e-02f, 4.68379147e-02f, -1.01761101e-02f, -6.47983626e-02f, 3.34751164e-03f, -9.97269377e-02f,
  1.65897477e-02f, 2.64073107e-02f, -9.63559598e-02f, -1.20909289e-01f, -9.26194862e-02f, 3.56689356e-02f, -1.38633385e-01f, 1.47966355e-01f, 4.36293967e-02f, -1.46613866e-01f,
  5.62205389e-02f, 5.06490134e-02f, 1.15757268e-02f, 1.10443957e-01f, 1.15074426e-01f, 2.50573065e-02f, 6.31316900e-02f, -5.52798957e-02f, -4.70047351e-03f, -6.13557585e-02f,
  -3.97010818e-02f, -7.42312744e-02f, -1.99847333e-02f, 1.30791575e-01f, 2.63878908e-02f, -3.00764721e-02f, -6.65857941e-02f, -4.26424071e-02f, -2.64399350e-02f, 2.56057624e-02f,
  -3.16018052e-02f, 5.71065862e-03f, -5.56576550e-02f, -2.70744879e-03f, -8.76763463e-02f, -1.88342948e-02f, -2.72428879e-04f, -2.17221025e-02f, 8.36936105e-03f, 2.85682897e-03f,
  -6.87007532e-02f, -8.43423828e-02f, -1.40851960e-01f, -7.11100250e-02f, -1.48865595e-01f, 2.04592478e-02f, 7.65394000e-03f, 1.36384383e-01f, 2.13884003e-02f, 5.78429997e-02f,
  -2.69427180e-01f, 9.62027386e-02f, -2.62066741e-02f, -7.07029626e-02f, -3.46549720e-01f, 8.90109837e-02f, -1.80258218e-03f, 4.40381169e-02f, -8.91515911e-02f, 1.35491028e-01f,
  -1.24932162e-01f, -1.67377546e-01f, 1.00344546e-01f, -4.65187393e-02f, -2.04716157e-02f, 1.85257271e-01f, 3.72996069e-02f, -3.07606142e-02f, -8.04472491e-02f, -7.90504143e-02f,
  -1.27688348e-01f, -3.77983153e-02f, 2.02365085e-01f, -5.48359863e-02f, -1.87215000e-01f, -1.37641001e-02f, -1.78334489e-01f, -1.81432858e-01f, -1.10412560e-01f, -9.59882289e-02f,
  7.20860362e-02f, 1.01340279e-01f, -4.04684767e-02f, 5.38193211e-02f, -1.20651335e-01f, 5.00265174e-02f, -1.11676343e-01f, -2.59023514e-02f, -4.81224805e-02f, -1.40527179e-02f,
  7.90059380e-03f, 3.74452360e-02f, 1.10365478e-02f, -1.30911067e-01f, -2.07551211e-01f, 1.91318206e-02f, 1.45002589e-01f, -7.37893805e-02f, 3.38325910e-02f, 1.81359835e-02f,
  1.11470506e-01f, -1.05776936e-01f, -5.56233302e-02f, 3.93386222e-02f, -2.46814210e-02f, 6.54529855e-02f, 1.60052106e-01f, -1.58642642e-02f, -5.59297651e-02f, -3.06211617e-02f,
  -1.25962058e-02f, -6.50248397e-03f, 2.62515936e-02f, -7.65394568e-02f, 1.81710180e-02f, 1.94863919e-02f, -2.12168135e-02f, -3.36166210e-02f, 8.81591719e-03f, -8.75501558e-02f,
  -6.03326932e-02f, 2.18471233e-02f, 3.61234434e-02f, 6.81608990e-02f, -1.57579519e-02f, -6.41981661e-02f, 3.82956713e-02f, 5.04000224e-02f, -2.19046287e-02f, 6.55719787e-02f,
  6.47239983e-02f, 4.13549617e-02f, -3.78186777e-02f, 8.74603391e-02f, -1.15761543e-02f, 5.68905030e-04f, -8.33334848e-02f, 1.15261145e-01f, -3.54051217e-02f, -6.62202016e-02f,
  7.24594072e-02f, 2.67863292e-02f, 8.57866108e-02f, 9.39950719e-02f, -2.90057901e-02f, -5.23079187e-02f, -4.71887179e-03f, 4.82641906e-02f, -8.79132822e-02f, -1.97312776e-02f,
  5.82446065e-03f, 3.45867351e-02f, -5.22986911e-02f, -1.15191460e-01f, -9.64448452e-02f, 1.16275012e-01f, 1.85968727e-02f, -1.08458832e-01f, 2.80477982e-02f, -4.59769815e-02f,
  -2.60979924e-02f, -6.31132200e-02f, 1.37159705e-01f, 8.48014373e-03f, 8.81038457e-02f, -1.14197489e-02f, -2.60526150e-01f, 8.15873221e-02f, -5.27777290e-03f, -5.81535771e-02f,
  -6.55782521e-02f, -1.43272683e-01f, -2.85427570e-01f, -2.28118747e-01f, 3.93118598e-02f, -3.01004469e-01f, -2.90451676e-01f, -5.75035065e-02f, 5.43343909e-02f, 1.67750999e-01f,
  -1.06400438e-02f, -1.98107529e-02f, 3.83733138e-02f, -2.77543843e-01f, -1.49964035e-01f, -3.17478292e-02f, -3.81892890e-01f, -2.07070053e-01f, -9.73963812e-02f, -3.27659398e-01f,
  -1.82042971e-01f, -7.33578801e-02f, -2.41989106e-01f, -1.03611022e-01f, -2.12940052e-01f, 7.76974112e-02f, 1.51067853e-01f, -9.66487601e-02f, -1.44176662e-01f, 4.31480519e-02f,
  -1.47570804e-01f, 1.04237877e-01f, 1.04086317e-01f, 4.44287099e-02f, -3.82798649e-02f, 5.93770295e-02f, -7.90196955e-02f, -6.80551603e-02f, -1.45777334e-02f, -1.39350459e-01f,
  3.75843234e-02f, 8.77190158e-02f, -3.48855369e-02f, 8.01002085e-02f, -5.33143058e-04f, -5.90443090e-02f, -1.33892400e-02f, -1.52117880e-02f, 1.02449087e-02f, -9.07633826e-02f,
  9.28335078e-03f, 9.35479179e-02f, -1.57416370e-02f, 1.11441724e-01f, 3.23351137e-02f, 4.66776118e-02f, -5.56550808e-02f, -7.71200731e-02f, -9.85039747e-04f, 1.97495464e-02f,
  4.21326645e-02f, 1.23016844e-02f, -2.35732887e-02f, -8.41018930e-02f, 1.11077931e-02f, 1.06794350e-01f, 1.18191121e-02f, 4.95232642e-03f, 3.96578237e-02f, -2.97717974e-02f,
  5.50693087e-03f, -8.06641858e-03f, -1.35693047e-02f, -7.69997714e-03f, -3.67957316e-02f, 5.79032078e-02f, 5.27916923e-02f, -3.50297131e-02f, -8.49804953e-02f, -9.52314399e-03f,
  6.38001859e-02f, 4.98444028e-02f, -2.54681315e-02f, -6.81305826e-02f, -8.43807012e-02f, 5.29864952e-02f, 3.74681838e-02f, 3.53710577e-02f, -5.07899700e-03f, -1.06899895e-01f,
  -5.73069975e-02f, 3.02814897e-02f, 1.27087757e-02f, 1.14155650e-01f, 5.50463609e-02f, -4.65231389e-02f, -6.74509183e-02f, -5.39603159e-02f, 6.20697215e-02f, -5.07965721e-02f,
  -9.91827473e-02f, 2.89233383e-02f, 1.14689551e-01f, 5.54150008e-02f, 8.11255258e-03f, -1.35485409e-03f, 2.50294106e-03f, 1.89033017e-01f, 1.47986576e-01f, -3.97904590e-02f,
  -2.75264983e-03f, 2.61947867e-02f, 3.13257277e-02f, 5.51611334e-02f, 1.92600399e-01f, 1.86837781e-02f, 2.85678599e-02f, -9.30307712e-03f, 1.24762952e-02f, 6.10110238e-02f,
  1.91022247e-01f, -5.31860180e-02f, -8.12600832e-03f, 9.09047052e-02f, 1.07221767e-01f, -5.38440235e-02f, -3.99388447e-02f, 6.88167959e-02f, 1.53795287e-01f, -7.42590204e-02f,
  -3.08751334e-02f, -1.41117305e-01f, -6.66317195e-02f, 7.67770708e-02f, 1.79513305e-01f, -1.58928782e-01f, 1.91256195e-01f, 3.60311829e-02f, -5.26212947e-03f, 3.04281153e-02f,
  1.90270141e-01f, 1.11536860e-01f, -4.11062576e-02f, 1.44918300e-02f, 3.85006778e-02f, 8.43561962e-02f, 1.05499908e-01f, 4.89932522e-02f, 6.37816638e-02f, 5.66677935e-02f,
  -1.44577231e-02f, 7.00708115e-05f, -4.89843031e-03f, -6.27769250e-03f, 1.37415696e-02f, -1.26995705e-02f, 3.96962129e-02f, -5.32876439e-02f, 6.53762445e-02f, -2.58355588e-02f,
  -7.33427480e-02f, -3.60520114e-03f, -3.84195037e-02f, 5.86407147e-02f, 8.81431159e-03f, 1.08358124e-03f, -4.87721264e-02f, 8.93145204e-02f, 5.69381118e-02f, -1.02562152e-01f,
  8.37282743e-03f, -5.68471141e-02f, 3.16619910e-02f, 6.49087653e-02f, 9.89771709e-02f, 6.37828663e-04f, -1.00197919e-01f, -8.06667954e-02f, 7.75625184e-02f, -2.72345711e-02f,
  1.18726976e-02f, -3.81478928e-02f, -9.96815935e-02f, -3.36262695e-02f, 2.28549317e-02f, -2.05854094e-03f, 4.75417962e-03f, 5.77142648e-02f, 4.23316434e-02f, 1.59612834e-01f,
  8.64871545e-04f, 5.85532971e-02f, -2.47393772e-02f, -1.22389667e-01f, 1.86954886e-02f, 1.34743556e-01f, 3.12779583e-02f, -6.78978637e-02f, -8.79794508e-02f, -5.33758244e-03f,
  2.94030812e-02f, 3.68141346e-02f, -4.63160500e-02f, -1.04305074e-01f, -2.77684126e-02f, -5.00547513e-02f, -5.74708916e-02f, -4.52655293e-02f, 4.66353036e-02f, 6.87739067e-03f,
  7.06644133e-02f, 7.05181584e-02f, -1.32260406e-02f, 6.24464266e-02f, 2.04281099e-02f, -3.93446945e-02f, 4.25309949e-02f, 4.29451987e-02f, 9.87596810e-02f, -2.80497931e-02f,
  -6.31855568e-03f, -2.44635213e-02f, -9.21885818e-02f, -9.32096094e-02f, 6.90105408e-02f, -4.34485748e-02f, -6.38605747e-03f, 1.19546577e-01f, 1.85442865e-01f, -1.84087176e-02f,
  5.50764389e-02f, -9.71628726e-02f, 1.06466301e-01f, 1.42097205e-01f, 2.80495100e-02f, 3.20896283e-02f, -1.09953303e-02f, -3.32384519e-02f, 3.78280580e-02f, 2.15069707e-02f,
  1.84605002e-01f, -8.03927779e-02f, -3.04375321e-01f, -1.43732637e-01f, 6.60058856e-02f, 3.01732391e-01f, 6.43496513e-02f, -8.30837563e-02f, -3.21472645e-01f, 1.69424355e-01f,
  8.46889317e-02f, -1.48275182e-01f, -1.08504184e-01f, 9.66238454e-02f, -1.16104782e-01f, -1.01940364e-01f, 4.74104621e-02f, 5.23342825e-02f, -1.32065490e-01f, -1.11807017e-02f,
  -6.42563626e-02f, 2.33395427e-01f, -1.15537733e-01f, 1.35266423e-01f, 1.62588969e-01f, -4.25615115e-03f, 5.45790829e-02f, -9.97568890e-02f, 1.72562338e-02f, 1.30231947e-01f,
  1.15211971e-01f, -2.36403849e-02f, -3.82860042e-02f, -7.37044215e-02f, 1.25604004e-01f, 1.59655079e-01f, 3.53264809e-02f, 3.47385705e-02f, -1.98828280e-02f, -3.76521908e-02f,
  -2.39000581e-02f, -1.09011628e-01f, 1.13280974e-01f, -1.60742506e-01f, -7.29822144e-02f, -4.45179380e-02f, -2.92054377e-02f, -1.35922462e-01f, -1.24492534e-01f, 9.28044394e-02f,
  -2.21972689e-02f, -3.67216803e-02f, -9.23542678e-02f, -2.50172126e-03f, -4.84272093e-02f, -5.42384125e-02f, -1.11470874e-02f, -1.25921229e-02f, 1.34396777e-01f, 6.58075213e-02f,
  9.62297395e-02f, 6.24698699e-02f, 1.03161767e-01f, -9.61840432e-03f, -1.94713566e-02f, 1.78016834e-02f, -3.50866988e-02f, -5.10599650e-02f, -1.43319771e-01f, -3.42252478e-02f,
  -6.16436452e-02f, 1.24559347e-02f, -4.64170910e-02f, -7.96188712e-02f, 5.33095449e-02f, -2.82686949e-02f, -2.23191697e-02f, 1.67283699e-01f, 3.11978161e-02f, -9.75133665e-03f,
  -3.66535969e-02f, 3.69796045e-02f, 1.07850842e-01f, 1.10153062e-02f, -2.65618898e-02f, 5.04577579e-03f, 2.21094340e-02f, 3.17311333e-03f, -4.74946499e-02f, -6.24139421e-02f,
  1.12006597e-01f, 3.03332340e-02f, -4.98958305e-02f, 1.29487766e-02f, -2.11730693e-02f, 1.02606937e-01f, -1.08825322e-02f, 4.54397276e-02f, 2.55425945e-02f, 6.50449321e-02f,
  1.42438516e-01f, -7.83589110e-02f, 1.15757421e-01f, -8.36868435e-02f, -1.46926463e-01f, 2.05786571e-01f, 1.79663971e-02f, -6.07330613e-02f, -1.25079218e-03f, 1.44696131e-01f,
  3.29952762e-02f, 5.13176247e-02f, -6.95540830e-02f, 1.31481383e-02f, 1.56307980e-01f, 7.78821036e-02f, 2.78671924e-02f, 6.08417466e-02f, 7.57451430e-02f, -1.07846297e-01f,
  1.93401858e-01f, 4.49426055e-01f, 1.39432207e-01f, 2.10241795e-01f, -1.10491991e-01f, -2.50377685e-01f, -5.53999618e-02f, 5.67749068e-02f, -1.13529332e-01f, 3.57662439e-02f,
  -5.96533678e-02f, 2.66303986e-01f, -5.03062420e-02f, 6.47381172e-02f, -3.07471782e-01f, -2.92936534e-01f, 1.61066633e-02f, -5.06880470e-02f, -9.06134918e-02f, 2.20503435e-01f,
  4.28301767e-02f, -1.57567695e-01f, 9.21622813e-02f, -6.52361810e-02f, 1.19318761e-01f, 2.13936731e-01f, 1.28898188e-01f, -1.52967433e-02f, 2.21892148e-01f, -8.90053958e-02f,
  -1.38478041e-01f, 4.35898714e-02f, 2.35531921e-03f, -8.05322453e-02f, -4.32882160e-02f, 4.26942855e-02f, 7.57528618e-02f, -2.15975512e-02f, -6.51565492e-02f, 1.98888015e-02f,
  6.25725091e-02f, -8.44759345e-02f, -3.52699645e-02f, -1.10452466e-01f, 9.39715654e-02f, 9.96897593e-02f, 2.35583093e-02f, 5.00567555e-02f, 1.24325253e-01f, 1.31540120e-01f,
  1.37547031e-01f, 2.66439375e-02f, 8.68676379e-02f, -1.34754166e-01f, -3.88759561e-02f, -8.26749057e-02f, -7.03703333e-03f, 7.39648491e-02f, 5.17154820e-02f, 2.35872306e-02f,
  -1.66778881e-02f, -1.10131511e-02f, 8.35673213e-02f, -1.16912139e-04f, 1.19006438e-02f, -6.40667155e-02f, -6.83790520e-02f, -3.22363190e-02f, 6.95302151e-04f, -1.99897923e-02f,
  -2.93654166e-02f, -2.69746091e-02f, -2.09492091e-02f, 1.37751894e-02f, 1.99880321e-02f, 1.00884020e-01f, 4.50071357e-02f, -2.02716365e-02f, 3.16770822e-02f, 3.21932361e-02f,
  -5.06720692e-02f, -4.86974195e-02f, 1.43030107e-01f, 6.80707544e-02f, -1.33745357e-01f, -5.54111414e-02f, 4.25679386e-02f, 2.35980711e-04f, 8.93681943e-02f, -2.94451211e-02f,
  6.59059137e-02f, 1.35928318e-01f, -3.39691155e-02f, -7.39381090e-02f, -1.78982671e-02f, -1.40320426e-02f, 8.50127172e-03f, 4.93354388e-02f, -2.06454452e-02f, -6.59977198e-02f,
  3.74564230e-02f, 5.11447946e-03f, -1.47543296e-01f, -4.89677442e-03f, -1.30132586e-02f, -2.99144294e-02f, -1.77067611e-02f, -2.13734116e-02f, 1.58096597e-01f, 4.92876843e-02f,
  1.90614209e-01f, -2.82641556e-02f, 3.40399668e-02f, -6.34512827e-02f, 2.75187497e-03f, -8.33223760e-02f, 5.72319813e-02f, 8.41062292e-02f, 1.37693062e-01f, -4.86682057e-02f,
  3.83264363e-01f, 1.70124441e-01f, -4.72463071e-02f, -1.02649249e-01f, -2.74515510e-01f, -2.42178410e-01f, -1.70169055e-01f, -8.47587883e-02f, -2.22066231e-03f, 2.51925420e-02f,
  -2.42091417e-01f, 1.80498451e-01f, -2.36555468e-02f, -4.87935431e-02f, -2.10481182e-01f, -1.46562785e-01f, -1.03992976e-01f, -3.87893505e-02f, -6.61642924e-02f, -1.83763355e-02f,
  -5.83865643e-02f, -2.66421914e-01f, -9.43827480e-02f, -1.74119428e-01f, -8.50957558e-02f, 4.28644456e-02f, -1.94920495e-01f, -2.39253446e-01f, 7.32778609e-02f, -1.70678616e-01f,
  3.56680993e-03f, 3.31441239e-02f, 1.45404324e-01f, 7.46211559e-02f, -2.44440250e-02f, 1.09560698e-01f, -1.19192250e-01f, -9.20070335e-02f, -5.46909720e-02f, 1.34776533e-01f,
  8.87783989e-02f, -1.43831834e-01f, 9.81643721e-02f, -2.67919507e-02f, 4.76305559e-02f, -3.81791294e-02f, 1.35321006e-01f, 6.35371655e-02f, 2.06720773e-02f, 3.05826543e-03f,
  1.24995179e-01f, -4.52465890e-03f, 9.21009853e-02f, 1.23114273e-01f, 1.75286680e-02f, -4.70618978e-02f, -6.34150859e-03f, 5.18918894e-02f, 3.60433124e-02f, 7.02588856e-02f,
  -5.25991693e-02f, -5.06630633e-03f, 7.31774718e-02f, -5.84563687e-02f, -6.36751577e-03f, -4.10331413e-02f, -2.53437143e-02f, 6.68136626e-02f, 1.16113119e-01f, 2.48474404e-02f,
  -4.76442464e-02f, 3.47873867e-02f, 2.55066566e-02f, -2.55936775e-02f, 4.80326079e-02f, 6.55727535e-02f, -4.03963551e-02f, 1.17934115e-01f, 2.64517758e-02f, -8.56395587e-02f,
  -1.01554766e-01f, -7.86092356e-02f, 2.53039394e-02f, 1.25022363e-02f, -1.09622836e-01f, -6.50651054e-03f, 3.59747820e-02f, -1.66482087e-02f, -5.96487001e-02f, -9.54308733e-02f,
  -4.30315249e-02f, -5.89381084e-02f, 2.83257235e-02f, 1.44622162e-01f, -2.37148870e-02f, 2.46837921e-02f, -1.21209808e-01f, 1.17174610e-01f, -3.90409455e-02f, 4.54889834e-02f,
  -1.64989114e-03f, -3.25463787e-02f, 4.75465953e-02f, 6.07644999e-03f, 6.34440407e-02f, -7.71204159e-02f, 3.13689932e-02f, -7.90869538e-03f, 5.54210357e-02f, -6.51353365e-03f,
  2.40512239e-03f, 4.95503284e-02f, 6.48932755e-02f, 4.66272188e-03f, -1.41078057e-02f, 6.52973950e-02f, -1.57911424e-02f, 1.49459064e-01f, 8.35893452e-02f, 2.03046016e-03f,
  -4.64419395e-01f, 1.56906545e-02f, -3.28733593e-01f, -5.82056977e-02f, 1.54057980e-01f, -1.00816198e-01f, -1.90874100e-01f, 9.51183587e-02f, -3.37148726e-01f, 9.42058712e-02f,
  -1.21374847e-02f, -3.27250153e-01f, -1.09133869e-01f, -9.71261561e-02f, -9.85045955e-02f, -1.53165817e-01f, 9.87592116e-02f, 9.48540680e-03f, 2.34854082e-03f, 8.18868075e-03f,
  1.63819306e-02f, 1.16526730e-01f, -5.43765165e-02f, 3.14011335e-01f, -9.08574164e-02f, 5.90523481e-02f, 3.12756121e-01f, -6.73744408e-03f, 1.94725290e-01f, -1.05662033e-01f,
  -1.85286790e-01f, -1.04372352e-01f, -1.17130950e-01f, -9.56855267e-02f, -5.94979785e-02f, 8.42983946e-02f, 1.70972031e-02f, 4.08257470e-02f, -5.33815436e-02f, -1.98685080e-02f,
  -1.06416136e-01f, 1.02142319e-01f, -3.75867309e-03f, -1.21952720e-01f, 4.46098065e-03f, -1.23649463e-01f, 1.37819916e-01f, 1.00450136e-01f, -9.27000027e-03f, -3.13832611e-02f,
  -7.33214095e-02f, 4.05045636e-02f, 6.56156242e-02f, 1.49420854e-02f, -4.52152863e-02f, -7.19895680e-03f, 7.69448057e-02f, -9.70548540e-02f, 7.96050206e-02f, -1.75044052e-02f,
  9.02241468e-03f, -8.95891264e-02f, -5.94432801e-02f, 2.39065718e-02f, -9.28315967e-02f, 3.10278051e-02f, 1.01059228e-01f, 5.96986488e-02f, 3.05888914e-02f, -1.09435804e-01f,
  7.31380209e-02f, -2.08144505e-02f, 1.92686040e-02f, 1.50515482e-01f, -3.70279253e-02f, 3.82015458e-03f, -8.29956383e-02f, 2.08566021e-02f, 2.00764257e-02f, -6.60903528e-02f,
  -6.62585944e-02f, 6.23394251e-02f, -4.51549813e-02f, 2.13911328e-02f, -5.67444265e-02f, -1.19807189e-02f, 6.06548935e-02f, -2.03919455e-01f, -7.67887058e-03f, 1.40270203e-01f,
  -1.93641540e-02f, 2.01012358e-01f, 3.76643352e-02f, 6.48104176e-02f, -3.99612933e-02f, -6.26641288e-02f, -1.35436192e-01f, -4.23049496e-04f, -5.25379665e-02f, -8.71541873e-02f,
  6.82356814e-03f, 4.99215089e-02f, -3.84642221e-02f, -6.81437999e-02f, 3.93899083e-02f, 1.76785942e-02f, 1.43051952e-01f, 3.06595359e-02f, 1.07778177e-01f, 1.68069437e-01f,
  5.88667504e-02f, -2.42814608e-02f, 1.25906363e-01f, 1.54720739e-01f, -8.80155899e-03f, 5.38948216e-02f, 9.19116288e-02f, 7.35880062e-02f, 7.70498291e-02f, -4.96831548e-04f,
  -1.42191514e-01f, -2.50647038e-01f, 2.05951661e-01f, -2.62722015e-01f, -9.33994912e-03f, 1.54226888e-02f, 1.83066890e-01f, -3.17353368e-01f, -3.61281931e-01f, -2.18514934e-01f,
  -1.44117087e-01f, 1.93126738e-01f, 1.94324940e-01f, -8.19619149e-02f, 4.12933379e-01f, 1.63164511e-01f, -2.28539601e-01f, 3.71781141e-02f, -7.58631900e-02f, -1.61885932e-01f,
  -2.91548558e-02f, -1.50563642e-01f, 1.77110061e-01f, -2.58661151e-01f, -1.03195064e-01f, -1.33019030e-01f, 2.15194583e-01f, 7.71396533e-02f, -3.22923101e-02f, 9.57467258e-02f,
  -4.27521951e-02f, -2.01228186e-01f, -4.77610566e-02f, -3.91090512e-02f, -1.17331043e-01f, 1.37557894e-01f, 5.56954518e-02f, 1.83115631e-01f, -4.54731211e-02f, -1.76175013e-01f,
  5.23493662e-02f, 6.94245994e-02f, -1.50726736e-01f, 2.12121103e-03f, -1.87003493e-01f, -6.46519661e-02f, -3.89466695e-02f, -6.18757196e-02f, 2.96373270e-03f, 6.56959787e-02f,
  1.05270684e-01f, -2.52504665e-02f, 5.94421569e-03f, 2.38158554e-02f, 1.02828406e-01f, -1.23514488e-01f, -1.27531961e-02f, 2.07269982e-01f, 4.60539497e-02f, -8.25968012e-02f,
  -3.49748544e-02f, 1.01050541e-01f, 4.31763157e-02f, -8.32886696e-02f, -3.36815491e-02f, -4.42156941e-02f, -7.41499364e-02f, 1.25817182e-02f, 1.55526353e-02f, -4.30265032e-02f,
  -9.79647622e-04f, -7.67516904e-03f, 1.37489457e-02f, -5.56053855e-02f, 5.19343354e-02f, -2.25537270e-02f, 1.16416641e-01f, 4.54422645e-02f, -2.56422237e-02f, -2.39188354e-02f,
  9.18690860e-03f, 3.06397192e-02f, 6.34326339e-02f, 5.98595776e-02f, 1.02599775e-02f, 1.23867452e-01f, -3.76319662e-02f, -5.68887033e-03f, -1.12091243e-01f, 1.22831963e-01f,
  -1.78167254e-01f, -3.00524533e-01f, -1.95203666e-02f, -6.25309050e-02f, -3.02641783e-02f, -3.77883995e-03f, -3.31828999e-03f, -1.47328572e-02f, -9.23230425e-02f, 6.44122134e-04f,
  -1.27249658e-01f, 2.72436384e-02f, 7.12008178e-02f, 3.70228983e-04f, 1.37104327e-03f, -1.22482739e-01f, 7.00564831e-02f, -7.04469234e-02f, 5.65379020e-03f, 4.64612469e-02f,
  -1.29394587e-02f, 3.28803137e-02f, 9.61164832e-02f, -1.31307244e-02f, -1.44477338e-02f, 5.54893836e-02f, -1.29862711e-01f, -5.76420054e-02f, 1.23303652e-01f, -7.84104876e-03f,
  -7.90590346e-01f, 2.08238170e-01f, -5.78089915e-02f, -1.99718013e-01f, -1.56237260e-01f, -7.68276770e-03f, -3.00559402e-02f, 4.33079945e-03f, -1.50036618e-01f, 1.43326744e-01f,
  -5.49329259e-02f, -6.28082082e-02f, 1.34063691e-01f, 1.00777760e-01f, -2.08705366e-01f, 2.63072550e-01f, -8.28479081e-02f, -5.21347532e-03f, 2.01397464e-02f, -1.44496515e-01f,
  -5.70903718e-03f, 1.35151044e-01f, 9.48775262e-02f, 8.43180865e-02f, -1.47241324e-01f, -1.52120024e-01f, -7.31003955e-02f, -8.03817883e-02f, -7.97815323e-02f, -6.70492128e-02f,
  -3.09799403e-01f, -3.41146171e-01f, -1.61010534e-01f, -1.98801234e-01f, -9.23323855e-02f, -9.16721150e-02f, -1.39132217e-01f, 2.28466489e-03f, -5.32304123e-02f, -5.93850315e-02f,
  -2.12540329e-02f, 8.77760798e-02f, 3.10116280e-02f, 1.65552516e-02f, 2.23887973e-02f, -4.60367501e-02f, -2.01483630e-02f, -1.81660112e-02f, -1.54263275e-02f, 1.44381430e-02f,
  1.02314632e-02f, 2.73633599e-02f, -3.62268500e-02f, 7.63290515e-03f, -3.14808562e-02f, -2.11297553e-02f, 4.83667776e-02f, -3.83664221e-02f, -1.21066585e-01f, -3.33495587e-02f,
  3.08684502e-02f, 5.64115383e-02f, -4.05456126e-02f, 6.65085018e-02f, -9.97405779e-03f, -3.18760946e-02f, 3.47935334e-02f, 9.09669383e-04f, -2.55599413e-02f, 5.51418178e-02f,
  1.31174382e-02f, -1.02732196e-01f, -5.12723513e-02f, -2.57678609e-02f, -3.51465456e-02f, -2.37079174e-03f, -3.87885198e-02f, -6.42533004e-02f, 1.10391982e-01f, -7.68102333e-02f,
  -3.40809627e-03f, -3.73133793e-02f, -1.58999991e-02f, -2.13710759e-02f, -2.69003101e-02f, 6.81006834e-02f, -2.97394432e-02f, 4.16922085e-02f, -9.20367837e-02f, -1.11343071e-01f,
  -4.37285662e-01f, -3.67930025e-01f, -1.92952584e-02f, -1.01974204e-01f, 8.19412060e-03f, -6.87988773e-02f, 2.09770631e-02f, -6.87156320e-02f, -1.53207973e-01f, -1.02947719e-01f,
  -8.82629901e-02f, -3.94653752e-02f, -2.22642124e-02f, 2.78840680e-03f, 1.93703230e-02f, 4.85070273e-02f, -4.04967368e-02f, -5.75675815e-02f, -8.28177668e-03f, 6.00908101e-02f,
  8.79754219e-03f, -3.58837880e-02f, 4.21201959e-02f, 1.24001326e-02f, 7.93781951e-02f, -8.17395821e-02f, -1.02139562e-01f, -1.36674777e-01f, -1.07618757e-01f, 3.61236483e-02f,
  8.78379121e-02f, 1.46175653e-01f, 8.28480870e-02f, 1.70910046e-01f, -6.34158403e-02f, -3.67895782e-01f, -2.70110399e-01f, -5.01031391e-02f, -1.72646269e-02f, -1.02558255e-01f,
  -5.55413403e-02f, 1.07735127e-01f, 7.29835480e-02f, 2.36110836e-01f, 2.44100899e-01f, -9.91467945e-03f, 7.68461898e-02f, -6.45217225e-02f, -3.94573659e-02f, 5.25920577e-02f,
  2.13736802e-01f, 6.47295192e-02f, 1.36538535e-01f, 5.54999635e-02f, 4.15573902e-02f, 4.70125377e-02f, 2.36418337e-01f, 1.55080641e-02f, 2.27481589e-01f, 6.89930320e-02f,
  -6.56695291e-02f, -3.69313098e-02f, -1.02324069e-01f, 3.45302112e-02f, -3.52389202e-03f, -5.34274504e-02f, -4.02042903e-02f, 1.44531429e-02f, 4.66994494e-02f, -2.85194814e-02f,
  -2.44971160e-02f, 1.88640933e-02f, 6.30349591e-02f, -7.80362040e-02f, -5.24380840e-02f, -1.87767725e-02f, 3.33208926e-02f, -7.25036263e-02f, 8.28296989e-02f, 2.45762635e-02f,
  3.96702066e-02f, -5.85137792e-02f, -1.84034705e-02f, 6.58859685e-02f, 6.07839227e-02f, -8.23193043e-03f, -1.88924819e-02f, 4.57997881e-02f, 5.32459095e-02f, 7.59512335e-02f,
  1.85696818e-02f, -3.73107828e-02f, 8.65553878e-03f, 1.54048419e-02f, -8.13156553e-03f, -1.04330786e-01f, -1.30540086e-02f, -2.84423269e-02f, -4.21250910e-02f, 1.69170704e-02f,
  -5.03479429e-02f, -1.17549375e-01f, -4.96351309e-02f, -4.28523421e-02f, 2.36481987e-02f, 4.68580164e-02f, -5.19690439e-02f, 5.20850718e-03f, -5.02334200e-02f, 3.24034430e-02f,
  -2.99322475e-02f, -8.48016813e-02f, -3.30566578e-02f, 2.33707596e-02f, -5.11007495e-02f, -8.35298598e-02f, 6.85408637e-02f, -5.30475518e-03f, 3.74326147e-02f, -6.31233752e-02f,
  4.46747355e-02f, 2.56035626e-01f, 6.46849629e-04f, -5.31068631e-02f, 1.18423998e-03f, -2.40842588e-02f, 7.54517466e-02f, 4.89466190e-02f, 8.84871334e-02f, 5.84148839e-02f,
  8.02675486e-02f, -8.12850073e-02f, -5.77250645e-02f, -2.19377447e-02f, -3.49650010e-02f, 8.62094685e-02f, 1.06768981e-01f, -1.31101115e-02f, 7.27323517e-02f, 9.47115943e-02f,
  4.75881360e-02f, -5.69027811e-02f, 1.80288106e-02f, -2.11659763e-02f, 9.17065889e-02f, -1.56850030e-03f, -3.84477377e-02f, 2.07914766e-02f, 1.08071811e-01f, -6.33614277e-03f,
  4.23338383e-01f, 1.42138988e-01f, 3.95197600e-01f, 2.54994810e-01f, 1.17578931e-01f, 5.47379628e-02f, 1.45905197e-01f, 7.69103989e-02f, 4.73955512e-01f, -8.68927240e-02f,
  -1.48510724e-01f, 2.00652778e-01f, -1.39468640e-01f, 8.65767226e-02f, 2.87938048e-03f, -7.36655621e-03f, 1.43805355e-01f, 1.34849027e-01f, 1.56566948e-01f, 1.17720570e-02f,
  -1.19163422e-02f, -3.74275386e-01f, -1.35530710e-01f, -2.18733087e-01f, 3.65172774e-02f, 1.05149426e-01f, -4.21397030e-01f, 1.27732947e-01f, -1.89572841e-01f, -1.45847443e-02f,
  3.58398296e-02f, 2.88574733e-02f, 4.87337857e-02f, 1.38745978e-02f, 1.11860715e-01f, -2.93579344e-02f, -4.11220118e-02f, -1.77945748e-01f, 9.73902494e-02f, -8.11809152e-02f,
  -7.70316720e-02f, 8.35272297e-03f, -3.72293554e-02f, -3.82277891e-02f, 1.34434059e-01f, 6.45122454e-02f, -4.75421250e-02f, 1.22363521e-02f, 4.43576798e-02f, 3.53146456e-02f,
  1.96071435e-02f, 1.24616951e-01f, 1.92306831e-01f, 7.49963000e-02f, 5.08685634e-02f, 1.36165142e-01f, 1.06876018e-02f, -6.67716889e-03f, 8.87181982e-02f, 6.63281381e-02f,
  -5.02341911e-02f, -1.88771226e-02f, 1.07991742e-02f, 7.43023828e-02f, 8.36371481e-02f, -6.26210049e-02f, -2.81514153e-02f, -8.58271196e-02f, 7.95962662e-02f, 1.18890420e-01f,
  1.08781591e-01f, 5.47582023e-02f, 5.00476025e-02f, 6.12993836e-02f, -1.12784924e-02f, -4.68470640e-02f, 1.21841701e-02f, -7.34333992e-02f, 5.66936955e-02f, 3.46015319e-02f,
  -6.22216128e-02f, -2.74065826e-02f, 2.25546397e-02f, -1.24312088e-01f, 2.57029422e-02f, 6.07576445e-02f, -2.72047631e-02f, 1.09604172e-01f, 1.57048311e-02f, -4.37405594e-02f,
  -1.78876165e-02f, -9.98323709e-02f, 3.27716284e-02f, -3.04779317e-02f, 5.10239005e-02f, -3.52241918e-02f, 3.70274670e-02f, -3.32426392e-02f, 6.97566643e-02f, -1.18941188e-01f,
  -6.59195706e-02f, 3.51297595e-02f, 2.79421359e-02f, -8.85461718e-02f, 2.30718516e-02f, -4.12225388e-02f, -8.46062899e-02f, -8.28078669e-03f, -4.63173054e-02f, -7.89627805e-02f,
  -9.21030790e-02f, -4.23827171e-02f, 1.94121432e-03f, 1.05382269e-02f, -2.26116199e-02f, -1.82704050e-02f, -4.07779031e-03f, 9.84909534e-02f, -1.09118074e-01f, 4.98406962e-02f,
  -3.53800625e-01f, 1.79288164e-02f, -2.28991568e-01f, 1.50993586e-01f, -1.01152800e-01f, 1.94230080e-01f, 3.11111540e-01f, -1.46330550e-01f, -1.30235301e-02f, 2.38508508e-01f,
  2.85681129e-01f, 2.50944067e-02f, 4.21105810e-02f, 3.36198598e-01f, 2.28839010e-01f, 2.40990326e-01f, 2.61357665e-01f, 2.18636885e-01f, -5.21812327e-02f, -1.91229701e-01f,
  -2.18840480e-01f, 1.59500211e-01f, 9.68286395e-02f, -1.29507676e-01f, 1.91141926e-02f, -1.64354548e-01f, 7.70161673e-02f, -5.66124991e-02f, 2.02222362e-01f, 7.55471438e-02f,
  -1.35908484e-01f, -2.07714036e-01f, 1.84770562e-02f, -9.43114012e-02f, -2.16937787e-03f, -4.79419380e-02f, -4.92571481e-03f, 4.01679873e-02f, 4.45708856e-02f, -7.56379887e-02f,
  -3.66949625e-02f, -6.36719912e-02f, 1.26474835e-02f, 9.79781747e-02f, -3.59320920e-03f, 3.24333943e-02f, -2.65684351e-03f, 1.01001218e-01f, 2.56120730e-02f, -1.73736364e-01f,
  -1.13736587e-02f, -4.31534983e-02f, 9.18856859e-02f, 9.89595503e-02f, 1.25742495e-01f, 5.78522012e-02f, 4.83679436e-02f, -5.61778387e-03f, -4.70687598e-02f, -4.83979285e-03f,
  -4.44054455e-02f, -1.69213504e-01f, -9.48058888e-02f, -1.15874326e-02f, -7.61897340e-02f, 4.42630984e-02f, 1.09593168e-01f, 9.29208472e-02f, 5.13514020e-02f, 9.51337814e-02f,
  -4.74507920e-02f, 4.64157052e-02f, -5.59299905e-03f, 3.61571200e-02f, -2.19494142e-02f, -6.17880486e-02f, -6.58644363e-02f, -1.71034818e-03f, 7.24309459e-02f, 7.96626359e-02f,
  -2.90063228e-02f, 1.52585478e-02f, 8.27341378e-02f, 8.45152214e-02f, -6.81013241e-02f, 6.94566825e-03f, -2.41211560e-02f, -6.05575666e-02f, -2.14178674e-02f, -1.01035520e-01f,
  -1.30580775e-02f, -8.93709958e-02f, 3.69701050e-02f, -1.12278022e-01f, 4.98432666e-02f, 1.53149646e-02f, -8.14204197e-03f, -2.74323709e-02f, 7.12030195e-03f, -2.03549370e-01f,
  -6.45178854e-02f, 1.66992903e-01f, -4.45102379e-02f, 4.29586536e-04f, 3.03521543e-03f, 5.53807653e-02f, 7.57473707e-02f, 4.09455933e-02f, 9.42273345e-03f, -7.41840079e-02f,
  7.30996802e-02f, -6.69996766e-03f, -3.88927534e-02f, -2.53964979e-02f, 6.62609637e-02f, 4.51255180e-02f, -6.45136610e-02f, -7.07679540e-02f, 1.69825125e-02f, 8.60215202e-02f,
  -2.24860728e-01f, 3.27072561e-01f, -1.41729385e-01f, -3.20155025e-01f, 9.68154706e-03f, -2.80837893e-01f, -2.87754625e-01f, 9.34201181e-02f, -3.66759971e-02f, -2.02703942e-02f,
  4.18647118e-02f, 1.30114958e-01f, 5.27638085e-02f, -1.07198194e-01f, -2.38859698e-01f, 1.09488845e-01f, -2.92543232e-01f, -1.37749657e-01f, 1.31885052e-01f, -1.06103025e-01f,
  -1.37211442e-01f, -1.14390783e-01f, -1.76113546e-01f, 1.90795645e-01f, -1.40168210e-02f, 1.23466207e-02f, -1.45970061e-01f, 8.39289054e-02f, -7.08897784e-02f, 1.46698713e-01f,
  -1.36485383e-01f, -1.21472865e-01f, -5.16780987e-02f, -8.64516348e-02f, -2.34995514e-01f, 1.24960523e-02f, -1.04653068e-01f, -1.46446684e-02f, -8.78468975e-02f, -1.34632234e-02f,
  5.68823628e-02f, 4.05514464e-02f, -1.66487973e-02f, 5.98035716e-02f, 9.16925445e-03f, 5.72047457e-02f, 4.15795743e-02f, -3.17678601e-02f, -5.19446731e-02f, 1.33247554e-01f,
  2.56664176e-02f, -7.63816386e-02f, -1.02131620e-01f, -1.89272955e-01f, -7.87829980e-02f, -6.02702983e-03f, -1.23155862e-01f, -5.28371818e-02f, 1.28840432e-02f, -1.76763199e-02f,
  1.45445347e-01f, -5.54595962e-02f, 3.53192352e-02f, 5.18409871e-02f, 6.86544776e-02f, 1.53206075e-02f, -1.41405342e-02f, -5.20961843e-02f, -5.53624108e-02f, -1.25208208e-02f,
  1.89514905e-02f, -1.17879547e-02f, 1.00248670e-02f, -9.49755758e-02f, 1.18622361e-02f, -3.40069756e-02f, -1.50975753e-02f, 1.80162843e-02f, -6.80264831e-02f, 7.79579626e-03f,
  6.97749406e-02f, 3.86454491e-03f, 1.17609911e-01f, -6.32100329e-02f, 6.53847158e-02f, 3.66658084e-02f, 3.20509612e-03f, 3.55083756e-02f, 1.51187014e-02f, 5.20285480e-02f,
  -3.88889998e-01f, -2.71018624e-01f, 3.95477973e-02f, -1.42321559e-02f, 3.79038081e-02f, -2.43148506e-02f, 4.47046161e-02f, -1.97243392e-02f, -8.28519464e-02f, -1.80867538e-02f,
  1.15224416e-03f, -1.52163883e-03f, -6.30911887e-02f, -1.09237581e-01f, 1.93767715e-02f, -1.44482180e-02f, -9.96572077e-02f, -8.90655816e-02f, -8.78297687e-02f, 6.51712045e-02f,
  -3.44038978e-02f, 5.25210164e-02f, 8.23032111e-03f, -4.20230813e-02f, -3.03845461e-02f, -7.47141391e-02f, 9.69282761e-02f, -3.21886279e-02f, -1.62697323e-02f, -6.12259917e-02f,
  -5.75740263e-03f, 3.17105316e-02f, 5.73476255e-02f, 3.63988504e-02f, 3.87082025e-02f, -1.61693916e-01f, -2.81983286e-01f, 8.76896754e-02f, -2.19075099e-01f, -7.06379116e-02f,
  1.07722066e-01f, -1.62440941e-01f, -5.49176931e-02f, -2.70530313e-01f, -1.41994044e-01f, -1.69417694e-01f, -8.88296589e-02f, -5.70758954e-02f, -1.28013164e-01f, 1.30492374e-01f,
  1.74490940e-02f, -1.05700985e-01f, -3.23306732e-02f, 1.04353853e-01f, -1.45745277e-01f, 2.03145593e-01f, 3.01642150e-01f, 8.66513997e-02f, 1.75623655e-01f, -2.65039876e-02f,
  -8.62856060e-02f, -3.69142108e-02f, 1.21802557e-02f, -1.14685381e-02f, 1.09653711e-01f, 1.38624851e-02f, 5.53809181e-02f, 3.82283144e-02f, 4.13354039e-02f, -1.75255295e-02f,
  6.43358726e-05f, -7.84117356e-02f, -2.26384196e-02f, -4.12384570e-02f, -9.25891623e-02f, -3.59876379e-02f, -1.74721077e-01f, -2.82439720e-02f, -1.98829964e-01f, -6.55531362e-02f,
  -1.57035872e-01f, -9.27564874e-02f, -7.26116523e-02f, -1.26341460e-02f, -7.43879983e-03f, -9.07096490e-02f, -5.81515357e-02f, 5.92953824e-02f, -1.31632715e-01f, 2.26709973e-02f,
  -1.96461342e-02f, 2.22343132e-02f, 1.14676513e-01f, -2.09523263e-04f, -5.53033985e-02f, 3.87080875e-03f, -9.67566893e-02f, 4.21406403e-02f, 4.95520830e-02f, -3.20636928e-02f,
  8.10525194e-02f, 5.90175483e-03f, -1.20363727e-01f, 1.32645682e-01f, 7.94289783e-02f, -3.76647338e-02f, 4.59672995e-02f, 4.14560400e-02f, 6.61971495e-02f, 4.90256399e-02f,
  -5.13331965e-02f, 6.11719042e-02f, 5.34670837e-02f, -8.30585975e-03f, -1.11269131e-01f, 5.65145463e-02f, -4.71392497e-02f, 2.68293563e-02f, 8.27221423e-02f, 6.91475719e-02f,
  1.13442637e-01f, 1.78228974e-01f, -1.96724031e-02f, 1.04721621e-01f, -6.20227493e-02f, -5.61190397e-02f, -7.28074610e-02f, 8.44599903e-02f, 1.54611804e-02f, 4.92783599e-02f,
  1.78653508e-01f, -1.07637793e-01f, -1.74812060e-02f, -3.21355416e-03f, -2.67932992e-02f, 1.54494211e-01f, 8.25705007e-02f, 7.48759881e-02f, -7.13203847e-02f, 2.55632978e-02f,
  3.11289243e-02f, -7.88717493e-02f, -7.23734051e-02f, -4.61780699e-03f, -3.31549123e-02f, 7.45231509e-02f, -3.65013964e-02f, 9.16612148e-02f, -7.33269081e-02f, -8.22321549e-02f,
  1.12244591e-01f, -7.74591044e-02f, -1.40447870e-01f, -2.19421938e-01f, -1.30396232e-01f, 2.24203747e-02f, -7.79447630e-02f, 5.98992780e-02f, 1.14379242e-01f, -9.09875426e-03f,
  -1.61236495e-01f, 7.69031271e-02f, 1.19767062e-01f, -2.80317247e-01f, 2.72940129e-01f, 1.54637083e-01f, -1.62707806e-01f, -1.17078349e-01f, 8.94649234e-03f, -6.62225857e-02f,
  1.86620187e-02f, -1.32354110e-01f, 2.49426942e-02f, -7.64757767e-02f, -3.22062254e-01f, -1.66074708e-01f, -1.85968488e-01f, -2.76844382e-01f, -2.50105917e-01f, -8.97746235e-02f,
  4.44668680e-02f, 5.19798771e-02f, -5.16735204e-03f, 1.00712068e-01f, -2.72186808e-02f, -1.28735527e-01f, -8.87313113e-02f, 4.20525996e-03f, -7.68818483e-02f, -8.44612904e-03f,
  -7.16641807e-05f, 5.25523908e-02f, -1.41041994e-03f, 3.38805392e-02f, -1.05889942e-02f, -1.17451072e-01f, 7.39204958e-02f, -7.61911720e-02f, 4.33184244e-02f, -4.47783917e-02f,
  9.29442421e-02f, 9.65638738e-03f, -1.16013579e-01f, 9.22719985e-02f, 1.12950057e-02f, -7.08509758e-02f, 1.38118073e-01f, 1.44732026e-02f, 7.99472909e-03f, -3.22951339e-02f,
  5.34199327e-02f, 3.53368698e-03f, -1.07663879e-02f, -1.20074287e-01f, 9.81868953e-02f, 5.19515527e-03f, -5.43249473e-02f, 9.15236548e-02f, 1.11747652e-01f, -6.68675154e-02f,
  -3.15849297e-02f, -6.24335036e-02f, 2.24746000e-02f, -2.55585257e-02f, 3.99202742e-02f, 4.01542196e-03f, -9.03283339e-03f, 7.84062594e-03f, -1.09865561e-01f, -2.28994410e-04f,
  7.22662210e-02f, 6.61208108e-02f, -1.17512025e-01f, -1.34601876e-01f, -1.00244977e-01f, -7.58496523e-02f, 3.88529524e-02f, -6.37664199e-02f, -4.60048728e-02f, -1.55207682e-02f,
  -1.50686326e-02f, 9.48640108e-02f, -7.95998517e-03f, -5.53424761e-04f, 4.94618639e-02f, -6.83460683e-02f, 8.17228481e-02f, 6.56109378e-02f, 1.57440349e-03f, -2.10250565e-03f,
  3.03474837e-04f, 2.54863244e-03f, 1.05563581e-01f, -2.39220224e-02f, 1.02706581e-01f, 3.17952186e-02f, -1.33303925e-02f, 6.74316883e-02f, 7.06453174e-02f, 9.95421503e-03f,
  -1.98167358e-02f, 1.42730922e-01f, 2.32705325e-02f, 3.16662155e-02f, 8.31935108e-02f, 5.69432750e-02f, 1.14652030e-01f, 9.50576738e-03f, -8.43211040e-02f, 3.99055716e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.26160160e-01f, 6.40681088e-02f, 2.73261189e-01f, 2.25622877e-01f, 2.02719003e-01f, 1.05085947e-01f, 8.72773454e-02f, 8.18187147e-02f, 7.83154219e-02f, 1.68716416e-01f,
  1.69130161e-01f, 9.17785615e-03f, 1.16244629e-01f, 1.65928025e-02f, 1.64198019e-02f, 1.76852003e-01f, 1.61229566e-01f, 2.57725298e-01f, 1.39520511e-01f, 1.80909038e-01f,
  5.63833043e-02f, 2.68973708e-01f, 3.93671133e-02f, 1.09179594e-01f, 4.73307595e-02f, 5.01263328e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.15162225e-02f, -5.38859405e-02f, -1.88045446e-02f, -7.57761970e-02f, 4.65350263e-02f, -9.59916562e-02f, 9.48179662e-02f, 4.20128852e-02f, -1.25747398e-01f, -6.64877985e-03f,
  -1.66254938e-01f, 4.42489125e-02f, 7.22053275e-02f, -3.06912679e-02f, 2.33197417e-02f, -6.37416616e-02f, -8.13330188e-02f, -5.87273315e-02f, -1.84000030e-01f, -3.20971534e-02f,
  -1.00593120e-01f, -2.23061919e-01f, 1.08951099e-01f, -1.73932865e-01f, 4.91732219e-03f, -4.01491765e-03f, -3.68456095e-02f, -3.66775654e-02f, 1.98228866e-01f, 4.98774461e-03f,
  2.16173679e-02f, 3.19577128e-01f, -1.99322328e-01f, -2.22165184e-03f, -9.76391062e-02f, -1.08202167e-01f, 8.40510130e-02f, -4.95373905e-02f, 1.86791435e-01f, -2.16604352e-01f,
  1.15314007e-01f, -5.65095022e-02f, -1.85254410e-01f, -5.23751900e-02f, 2.47576639e-01f, -9.87871736e-02f, 1.04570620e-01f, -6.73050657e-02f, -6.85362145e-02f, -2.93270256e-02f,
  2.30114963e-02f, 1.15154944e-01f, -1.43501505e-01f, -1.30949944e-01f, -1.28238022e-01f, 2.93868519e-02f, 2.54335344e-01f, 1.17078070e-02f, 2.10283250e-01f, -2.76466701e-02f,
  -1.33867770e-01f, 9.56101939e-02f, -1.52287483e-01f, -3.17743495e-02f, 6.03220947e-02f, -9.91521701e-02f, 3.48347835e-02f, -9.33123287e-03f, -1.17288798e-01f, -1.31564692e-01f,
  1.39328465e-01f, 1.24165080e-01f, 5.72855293e-04f, -7.46779591e-02f, 7.48218549e-03f, 1.78185776e-01f, 1.76485151e-01f, 1.35837784e-02f, 1.73239484e-01f, 1.58482805e-01f,
  9.74551812e-02f, 3.83539274e-02f, 2.68235225e-02f, 5.94510101e-02f, 1.39891207e-01f, -5.42832986e-02f, -2.42491290e-02f, 8.51480588e-02f, -6.19344302e-02f, 1.56930462e-01f,
  -5.86841851e-02f, 1.10089015e-02f, 3.07489652e-02f, 3.89211029e-02f, 1.06880739e-01f, 1.43381223e-01f, 1.47165567e-01f, -3.65861282e-02f, -1.55085877e-01f, -7.98297524e-02f,
  -9.44081172e-02f, -4.15184759e-02f, 5.04210331e-02f, -2.12417409e-01f, 1.21211074e-02f, -1.69324890e-01f, -5.39536327e-02f, 1.85156837e-01f, -2.22359411e-02f, -2.02966691e-03f,
  -7.60835130e-03f, -1.46815732e-01f, -6.40834421e-02f, -5.71396798e-02f, 2.17269138e-01f, 2.46038055e-03f, -1.41963750e-01f, 1.50926530e-01f, 4.33374569e-02f, 2.01902837e-01f,
  2.05307886e-01f, -1.70294508e-01f, 7.03859609e-03f, 1.24052346e-01f, -2.66981691e-01f, 1.29368767e-01f, 1.47656843e-01f, -3.08900122e-02f, -2.51300577e-02f, 3.20545882e-02f,
  7.55342692e-02f, -1.22813351e-01f, 8.24237466e-02f, -1.38736712e-02f, 2.50343177e-02f, 7.83092305e-02f, -4.90362830e-02f, -5.37897162e-02f, -8.27596411e-02f, 1.31953672e-01f,
  6.66292086e-02f, -3.40738744e-02f, 2.05150425e-01f, -1.17326945e-01f, 1.35418683e-01f, 6.98613049e-03f, -8.27417746e-02f, 1.24311820e-02f, 1.30461395e-01f, 5.20522892e-02f,
  -3.64112332e-02f, 6.65251687e-02f, 1.54072568e-01f, -3.00216135e-02f, -4.72613499e-02f, -5.86050143e-03f, 1.89735368e-01f, 1.51715919e-01f, 2.58723497e-01f, 4.58386913e-02f,
  8.91883001e-02f, -1.79147467e-01f, -6.40744269e-02f, -1.20815992e-01f, -1.83436170e-01f, -3.84736061e-02f, 2.11162344e-01f, -4.32288051e-02f, 9.90571529e-02f, -9.68538225e-02f,
  5.80816902e-02f, -1.04941167e-01f, -7.98591524e-02f, -5.97232161e-03f, -1.30443498e-01f, -9.81156826e-02f, 1.83887884e-01f, 7.33355582e-02f, 2.71660656e-01f, -1.28025755e-01f,
  1.02595322e-01f, -1.80468503e-02f, 9.63235646e-02f, -1.82320513e-02f, 1.58272699e-01f, 9.41599533e-02f, -1.40391111e-01f, -6.55763894e-02f, -2.20856786e-01f, 2.02037871e-01f,
  -3.56619060e-02f, 1.06728517e-01f, -9.69037879e-03f, 1.14423357e-01f, 8.22812766e-02f, -4.60788794e-02f, 1.09185569e-01f, 5.74962944e-02f, -1.00653097e-01f, -5.83175644e-02f,
  -7.97895528e-03f, 7.22437203e-02f, 2.70366333e-02f, 1.26838489e-02f, -1.23631716e-01f, 5.17751239e-02f, -1.08464127e-02f, -2.20838532e-01f, -4.03213762e-02f, 4.54634577e-02f,
  1.25611067e-01f, -3.80249918e-02f, -1.35245293e-01f, 1.48209646e-01f, 3.06657255e-02f, -4.01570015e-02f, 7.14333877e-02f, -4.83617447e-02f, -2.49597743e-01f, 1.19252555e-01f,
  -1.22248910e-01f, 3.51510979e-02f, -7.82766044e-02f, -2.09765300e-01f, 4.82932851e-02f, -1.61901570e-03f, 5.15069254e-02f, 2.71582454e-02f, -8.84941872e-03f, -1.63260866e-02f,
  9.29581448e-02f, 7.32490420e-02f, -1.01667561e-01f, -1.00049764e-01f, 1.04877979e-01f, 2.07550183e-01f, -5.90213984e-02f, 1.02437474e-01f, -1.04535133e-01f, 2.82213151e-01f,
  1.24677785e-01f, 1.45859107e-01f, 1.88440934e-01f, 5.84943406e-02f, 9.72420722e-02f, -1.67467177e-01f, -6.26710011e-03f, -3.53434831e-02f, -1.56682938e-01f, 2.47701541e-01f,
  -1.10791937e-01f, 2.42814049e-02f, -6.73642335e-03f, 1.01517908e-01f, -3.33312154e-02f, 9.76742879e-02f, -3.90510261e-02f, 4.28872295e-02f, -1.00546628e-02f, -7.27556869e-02f,
  -2.06520688e-02f, 5.75701222e-02f, 2.91400533e-02f, 3.62643115e-02f, -5.22345491e-02f, 1.85863171e-02f, 7.02730706e-03f, -1.05985649e-01f, -6.01532720e-02f, -2.70445738e-02f,
  2.05513462e-01f, 5.34411743e-02f, 2.64133096e-01f, 1.54120028e-01f, 1.17479749e-01f, 8.03836272e-04f, 1.17290169e-01f, 4.53173034e-02f, -1.21505134e-01f, 1.90109640e-01f,
  1.86638683e-01f, -1.29271761e-01f, 3.97139825e-02f, -7.18146563e-02f, 1.76807418e-01f, 7.73489773e-02f, 1.56229120e-02f, 1.97735075e-02f, -4.07162830e-02f, -2.36263484e-01f,
  1.25619456e-01f, -1.18951060e-01f, -2.15345845e-01f, -4.72054705e-02f, -7.77042061e-02f, -2.92682629e-02f, 1.48511395e-01f, -2.03849629e-01f, -1.43596619e-01f, 2.90994663e-02f,
  -1.69629321e-01f, -8.17553103e-02f, -2.00539395e-01f, -1.89819038e-02f, 2.20280498e-01f, 1.48231968e-01f, -1.38840191e-02f, -1.11579135e-01f, 5.89378923e-02f, 3.30394022e-02f,
  -2.20707599e-02f, -1.78600773e-02f, 2.40595073e-01f, 2.16144368e-01f, -2.14984268e-01f, -6.22893963e-03f, 1.58681467e-01f, -9.72605869e-03f, -1.45894438e-01f, -1.15364082e-01f,
  -4.56370041e-02f, -5.85653670e-02f, -5.96002527e-02f, -9.39047635e-02f, -1.18351966e-01f, -1.52674943e-01f, 1.21019587e-01f, 1.28787318e-02f, 8.77356157e-04f, 4.72785644e-02f,
  -3.57541628e-02f, 1.07444137e-01f, 1.73140734e-01f, 7.81756118e-02f, 1.11400083e-01f, 1.44019395e-01f, 6.14107661e-02f, -1.25813037e-01f, -9.68925804e-02f, -9.15789753e-02f,
  -1.41813919e-01f, -6.97792619e-02f, 1.14793785e-01f, -3.19357663e-02f, -1.03271708e-01f, 1.71931311e-01f, -2.04991728e-01f, 7.30326623e-02f, 4.96278070e-02f, 2.62079332e-02f,
  2.58930046e-02f, 2.53863007e-01f, 1.69847216e-02f, -6.46193475e-02f, -1.42944008e-01f, -1.83711156e-01f, 2.38073338e-02f, 1.74848467e-01f, 6.11974932e-02f, -2.44688824e-01f,
  4.44829278e-02f, -1.11107908e-01f, 1.39307138e-02f, 8.68437961e-02f, 9.47985053e-02f, 2.23367233e-02f, 6.73971176e-02f, -1.12422131e-01f, -8.73214900e-02f, -1.42624199e-01f,
  1.73039272e-01f, 9.28834230e-02f, -2.64089882e-01f, -1.75242890e-02f, -1.82523131e-01f, 2.29926676e-01f, 8.20533279e-03f, -8.07451531e-02f, 7.10087642e-02f, 1.18705124e-01f,
  -2.33109713e-01f, 1.03940420e-01f, 1.07320942e-01f, 8.58571231e-02f, 2.38145832e-02f, 9.94688272e-02f, -4.55777235e-02f, 1.82964262e-02f, 9.45523307e-02f, 1.10837348e-01f,
  -1.19007137e-02f, -1.36017743e-02f, 1.40275598e-01f, 1.45383447e-01f, 5.18171340e-02f, -6.12403527e-02f, -8.30069706e-02f, 8.67767781e-02f, -1.17557243e-01f, -7.80800954e-02f,
  -6.91859126e-02f, 3.74300145e-02f, 1.28171667e-01f, 1.57171546e-03f, -1.34830415e-01f, 2.24260371e-02f, -8.01957697e-02f, -4.59477641e-02f, -1.05364487e-01f, -5.23086190e-02f,
  -5.87946139e-02f, 2.40757223e-02f, -2.06770763e-01f, -1.32991225e-01f, -1.99777290e-01f, -2.30429858e-01f, 5.24932444e-02f, 1.52036414e-01f, 1.31060779e-01f, 1.85877696e-01f,
  1.42576322e-01f, -2.96071563e-02f, -9.50327739e-02f, 5.70896938e-02f, -1.64617091e-01f, -9.50832739e-02f, -2.25329529e-02f, -4.98103024e-03f, 5.01857884e-02f, 1.48736447e-01f,
  -1.94275170e-03f, 1.54172614e-01f, -1.10210620e-01f, 8.71083438e-02f, -1.24165937e-01f, 7.59483352e-02f, -1.86901279e-02f, -2.81713307e-02f, 4.27786820e-02f, -7.12588206e-02f,
  -2.06824109e-01f, 7.29447827e-02f, -1.21427551e-02f, 3.31493914e-02f, 1.39436036e-01f, -1.66059792e-01f, 2.42226981e-02f, 3.13508250e-02f, -2.47241668e-02f, 1.80158824e-01f,
  1.48833469e-02f, 5.08991033e-02f, 1.62902758e-01f, 8.90673548e-02f, -7.16386810e-02f, -5.76027557e-02f, -1.32281985e-02f, 4.35373113e-02f, 5.92885874e-02f, 2.23347425e-01f,
  -8.44807625e-02f, -3.51491645e-02f, 1.15984701e-01f, -6.43659979e-02f, 1.91499427e-01f, -7.19216280e-03f, 4.37675714e-02f, 1.78538352e-01f, 1.49759293e-01f, 5.49220294e-02f,
  -2.27724582e-01f, -4.81941290e-02f, 7.89041538e-03f, -2.48019844e-02f, -2.23201886e-01f, -2.55049597e-02f, 5.58982417e-02f, -1.07882410e-01f, 1.93017066e-01f, 7.14942142e-02f,
  1.95525736e-01f, -7.47423619e-02f, 5.10729291e-02f, -5.40283918e-02f, 2.54453998e-02f, -5.78351878e-02f, -3.63969840e-02f, -9.50431526e-02f, -9.66699794e-02f, -2.33776808e-01f,
  -1.90243810e-01f, -2.04614818e-01f, -1.85964659e-01f, 6.18346930e-02f, -2.40731269e-01f, 7.08031878e-02f, 2.12789297e-01f, -4.35896032e-02f, 9.65866596e-02f, 5.93820065e-02f,
  -3.60489599e-02f, 6.65895864e-02f, 1.11802720e-01f, -2.47109622e-01f, 2.02232510e-01f, -1.56492889e-02f, -4.51531634e-02f, 2.45088652e-01f, -1.78918898e-01f, 1.84209526e-01f,
  -2.01072484e-01f, 5.21607101e-02f, -2.97403033e-03f, -2.78735776e-02f, -4.14501317e-02f, 4.82460065e-03f, -1.89369079e-02f, 2.48490460e-02f, -7.23056719e-02f, -2.51120962e-02f,
  -1.94606990e-01f, -7.17762262e-02f, -2.91340183e-02f, -6.20480478e-02f, -5.05974144e-02f, -8.98954198e-02f, 1.49267092e-01f, -3.57789211e-02f, 5.45090176e-02f, 4.60412242e-02f,
  4.50144783e-02f, -4.98873778e-02f, -3.38504091e-02f, 1.11854985e-01f, 8.57306644e-02f, 7.14435726e-02f, 7.94558004e-02f, -7.72191882e-02f, -5.84999174e-02f, 1.06410526e-01f,
  5.32400869e-02f, 1.23214841e-01f, -1.32326841e-01f, -1.38364919e-02f, 3.87995765e-02f, -1.86610460e-01f, 6.85389787e-02f, -2.51427919e-01f, -7.68701881e-02f, 1.42796323e-01f,
  -1.01084270e-01f, -7.09483325e-02f, 5.44875860e-02f, -1.90998301e-01f, -1.57068893e-01f, 1.77588701e-01f, -8.30415338e-02f, -1.21093974e-01f, -1.35374546e-01f, 8.88220072e-02f,
  2.47075662e-01f, 1.20510459e-01f, -5.13441525e-02f, -2.60638110e-02f, -6.59638923e-03f, -9.13788825e-02f, -1.85387686e-01f, 6.90137520e-02f, -2.98793782e-02f, 2.68682122e-01f,
  -1.54170781e-01f, -6.46281540e-02f, 1.30098656e-01f, 1.52898327e-01f, -1.67664766e-01f, -1.76427305e-01f, -2.25868765e-02f, -6.60547009e-03f, 1.15467340e-01f, -2.91624665e-02f,
  -5.01044989e-02f, -1.00112900e-01f, -1.25741720e-01f, 1.33230472e-02f, 6.38865381e-02f, 4.02479284e-02f, -9.01765302e-02f, 1.57672375e-01f, -6.29749745e-02f, -5.06740585e-02f,
  8.01314414e-03f, -2.30103001e-01f, -1.30113997e-02f, -2.64902767e-02f, -7.43237212e-02f, 2.04584256e-01f, -3.94026972e-02f, -1.18625209e-01f, 1.05985023e-01f, -1.37832522e-01f,
  -1.87761992e-01f, 7.88316280e-02f, -1.18777752e-01f, -1.17572226e-01f, -9.91249681e-02f, -1.65616333e-01f, 5.47283068e-02f, -1.75491832e-02f, 2.28987962e-01f, -4.13540490e-02f,
  7.01527968e-02f, 9.69716534e-02f, 2.02922150e-01f, -6.63220733e-02f, -2.56993715e-03f, -1.03306677e-03f, -1.93514541e-01f, -7.56370574e-02f, -3.58224921e-02f, -9.10819545e-02f,
  -1.87270582e-01f, 2.39333063e-01f, -1.02874815e-01f, 7.04840273e-02f, -3.41937058e-02f, 7.53637105e-02f, -4.17426042e-02f, -3.68352719e-02f, 1.31621927e-01f, 3.47725600e-02f,
  1.70955509e-01f, -2.60286212e-01f, -1.81606427e-01f, -8.87674242e-02f, -1.06312521e-01f, 2.58595794e-01f, -1.07196599e-01f, -4.77882884e-02f, -1.43675819e-01f, 1.69017613e-01f,
  -8.94329324e-02f, 1.43220695e-02f, 9.82703269e-02f, 5.30030020e-02f, -1.47749215e-01f, -4.61814031e-02f, -9.58654135e-02f, 3.35240625e-02f, 1.46389738e-01f, 8.50875974e-02f,
  -1.42390415e-01f, 1.05148315e-01f, 4.79036942e-02f, 5.86244240e-02f, 1.85232870e-02f, 1.49710208e-01f, -8.32456276e-02f, 1.19731035e-02f, -2.23538540e-02f, 8.05635974e-02f,
  -1.12026371e-01f, -2.76107322e-02f, 1.05171479e-01f, -1.15861930e-01f, 2.62526721e-02f, 1.24945663e-01f, 5.23069641e-03f, 4.13691401e-02f, 1.06905378e-01f, 6.14820644e-02f,
  2.42715850e-01f, 2.54718261e-03f, -6.71884343e-02f, 1.12853758e-01f, 2.85326131e-02f, 1.16833024e-01f, -3.37826274e-02f, 4.11518064e-04f, -2.13723537e-02f, 1.53201073e-01f,
  9.51830149e-02f, 2.04791799e-01f, 1.38027757e-01f, -2.13834211e-01f, -8.88516679e-02f, -2.43334640e-02f, 4.00345847e-02f, 1.22796046e-02f, -1.24688163e-01f, -9.98155102e-02f,
  -5.16673103e-02f, 6.17092662e-03f, 1.44835740e-01f, -1.60077274e-01f, -1.62397310e-01f, 5.35917170e-02f, -7.87896961e-02f, -2.31116071e-01f, -1.45426139e-01f, 3.36018652e-02f,
  3.17813084e-02f, -2.27239951e-01f, 2.58405991e-02f, -1.06224164e-01f, -1.29389390e-01f, -9.27339792e-02f, 1.02528483e-01f, 4.03064676e-02f, -3.06883067e-01f, -1.60867676e-01f,
  -5.89545928e-02f, 1.13890275e-01f, 4.15239111e-02f, -6.64246008e-02f, -1.28717110e-01f, -9.37395021e-02f, 6.66710138e-02f, 6.72186613e-02f, 1.48140697e-03f, 1.77102923e-01f,
  -4.80717458e-02f, 1.58845875e-02f, -8.46926495e-02f, -8.21849778e-02f, -5.59194833e-02f, -9.56475064e-02f, 2.22686782e-01f, -7.93343317e-03f, -7.68584311e-02f, 2.96005607e-01f,
  7.34132975e-02f, -2.36314110e-04f, -1.11711517e-01f, -1.19094709e-02f, -4.83867852e-03f, 6.89119324e-02f, 1.38054430e-01f, 5.43653481e-02f, -2.49346390e-01f, 9.40515380e-03f,
  1.15449920e-01f, 8.85889307e-02f, -5.93604520e-03f, 6.86063021e-02f, -5.85801341e-02f, 2.48849347e-01f, 2.18519762e-01f, -3.57877761e-02f, 7.00520203e-02f, -7.29549229e-02f,
  6.00138381e-02f, -1.26988247e-01f, -2.36448228e-01f, -4.68983455e-03f, 8.51763412e-02f, -4.68474589e-02f, 1.03743225e-01f, 2.33816057e-01f, 2.32099876e-01f, 1.49195537e-01f,
  -2.64448673e-01f, -1.59958482e-01f, 1.85691416e-02f, 1.38422877e-01f, -1.69188663e-01f, -4.69344016e-03f, 2.46738881e-01f, 1.59918540e-03f, -1.61059741e-02f, -2.72654481e-02f,
  -6.58243597e-02f, -7.21898898e-02f, -9.36303511e-02f, -9.71638039e-02f, 8.18637162e-02f, -9.13587306e-03f, 7.82320872e-02f, -1.19718013e-03f, -1.82443991e-01f, 6.93804175e-02f,
  7.55027160e-02f, 5.21617010e-02f, 9.55179185e-02f, 1.29125342e-01f, -7.98901990e-02f, 6.31305799e-02f, -1.01420045e-01f, 8.62026140e-02f, -2.24051382e-02f, -9.06347260e-02f,
  -3.38187488e-03f, -2.25472793e-01f, 2.99294330e-02f, 3.39952833e-03f, 5.55977337e-02f, 1.37013206e-02f, 2.58282632e-01f, -9.40842852e-02f, 2.83033758e-01f, 2.32198238e-01f,
  -1.38385862e-01f, 6.14911020e-02f, -1.44070713e-02f, -2.88317874e-02f, -4.36145216e-02f, 6.40150253e-03f, 5.96255772e-02f, 6.44949898e-02f, 1.52393743e-01f, 1.85625926e-01f,
  9.01139602e-02f, -2.35231757e-01f, -4.15330790e-02f, -4.01595719e-02f, 1.37439355e-01f, -1.35857791e-01f, -9.22490656e-02f, -9.65687409e-02f, -4.89525273e-02f, 6.82079867e-02f,
  3.85087281e-02f, -2.49303326e-01f, -2.28048056e-01f, 7.02952668e-02f, 2.04195440e-01f, -2.17003047e-01f, -5.13846315e-02f, 1.04026552e-02f, -5.83946006e-03f, -1.22746117e-01f,
  -5.59262484e-02f, -1.55804828e-02f, -2.19936166e-02f, 2.23255903e-01f, 5.61616682e-02f, -1.65442005e-02f, 1.55713931e-01f, 1.14385135e-01f, -6.62070066e-02f, 3.74196358e-02f,
  1.08479172e-01f, 1.79242298e-01f, 2.40636896e-02f, 1.46042973e-01f, -1.77521780e-02f, 2.67610624e-02f, 7.34523088e-02f, -1.77867226e-02f, 9.02175680e-02f, 3.22504342e-02f,
  7.48236999e-02f, -4.67965119e-02f, -2.33503923e-01f, -1.85788125e-02f, 1.34476840e-01f, -3.95805873e-02f, -2.13265885e-02f, -1.43962383e-01f, -1.54292583e-01f, 5.68621270e-02f,
  3.29533815e-02f, 4.50434908e-02f, 2.13932116e-02f, 1.15422972e-01f, -1.49795413e-01f, 6.70095459e-02f, 1.42440051e-01f, 1.31664068e-01f, 1.22255258e-01f, 1.43646121e-01f,
  -3.14924791e-02f, 8.47966000e-02f, 1.18912898e-01f, -3.56247835e-02f, -1.96733251e-01f, -2.71164060e-01f, 1.69297531e-02f, 1.20777942e-01f, -1.02900855e-01f, 2.02487782e-01f,
  1.30677149e-01f, 1.58290327e-01f, -6.14242926e-02f, 1.77094266e-02f, -8.90092552e-02f, -1.58500761e-01f, -1.01459689e-01f, -2.32797246e-02f, -2.58126892e-02f, 2.35825598e-01f,
  -1.41962364e-01f, 1.18611492e-01f, 1.11903161e-01f, -7.64026940e-02f, -2.74194747e-01f, 8.04300071e-04f, -1.65692884e-02f, 3.32446322e-02f, 3.80286351e-02f, 1.29079744e-01f,
  -3.36742960e-02f, 2.47053616e-02f, -8.63189995e-03f, 5.55688776e-02f, -8.13049302e-02f, 1.44579811e-02f, 8.67837146e-02f, -6.80290461e-02f, 1.16587527e-01f, -6.40823171e-02f,
  1.93039209e-01f, 1.54339731e-01f, 2.19361812e-01f, 1.19666651e-01f, 1.30247638e-01f, 4.64418121e-02f, 1.51986167e-01f, 1.73002735e-01f, 3.85823883e-02f, 2.86288381e-01f,
  9.40338895e-02f, 5.16668893e-03f, 5.61205251e-03f, -8.75492766e-03f, 8.02870393e-02f, 2.05231488e-01f, -3.41308229e-02f, 7.74109364e-02f, -5.96652739e-02f, -2.65649185e-02f,
  2.01943126e-02f, -1.43009111e-01f, -6.26440346e-02f, 1.13170415e-01f, -1.29151151e-01f, -4.83485423e-02f, 1.97729856e-01f, -1.44805824e-02f, -3.27866003e-02f, 7.07895458e-02f,
  -8.34633708e-02f, -7.72429556e-02f, -6.20646775e-02f, 5.35414852e-02f, 2.71823227e-01f, -4.45419364e-02f, -1.42718300e-01f, -6.18156530e-02f, 2.00303085e-02f, 4.42646854e-02f,
  -6.31282553e-02f, 1.40282750e-01f, 7.26953223e-02f, 1.64429456e-01f, -1.63560048e-01f, 1.95722878e-02f, 1.49215683e-01f, 1.62975550e-01f, -9.02222916e-02f, -1.82050139e-01f,
  -2.71759275e-02f, -3.38941514e-02f, 1.87084004e-02f, -5.06712236e-02f, 1.80265516e-01f, 2.13305607e-01f, -2.43078917e-02f, -1.78730264e-02f, 7.09676966e-02f, -4.99927700e-02f,
  6.06971746e-03f, -3.77513431e-02f, -7.61979744e-02f, -7.16690943e-02f, -2.42494687e-01f, -2.09450975e-01f, -1.89195573e-01f, -7.98331276e-02f, 7.14046359e-02f, 8.17166939e-02f,
  -5.83054870e-02f, -7.38800094e-02f, -2.01657694e-02f, -6.17798679e-02f, 1.92752611e-02f, -1.75595149e-01f, 7.28360638e-02f, -1.43044621e-01f, -1.08182482e-01f, -2.24951237e-01f,
  -5.64304255e-02f, -1.40979201e-01f, -1.05679128e-02f, 1.39131248e-01f, 1.40515298e-01f, 2.09028900e-01f, 1.68686673e-01f, -1.89210728e-01f, -2.08075177e-02f, 1.05099171e-01f,
  -8.16062465e-02f, -6.40756870e-03f, -3.82126309e-02f, 8.93595070e-03f, 2.14624461e-02f, 1.84677511e-01f, 3.48997600e-02f, 1.37627184e-01f, -4.78057154e-02f, -3.60462219e-02f,
  -1.68545157e-01f, -5.79029769e-02f, 3.23709138e-02f, 1.00824341e-01f, 1.52458787e-01f, -1.95820406e-01f, 4.42774892e-02f, -1.57415882e-01f, 1.36029229e-01f, -1.15506044e-02f,
  9.64568853e-02f, -2.39676848e-01f, -1.39100879e-01f, 1.07055776e-01f, -1.28816068e-01f, -2.07088105e-02f, 3.01154852e-02f, -6.77784532e-02f, -1.75929647e-02f, -2.17965603e-01f,
  1.44755304e-01f, 5.90235963e-02f, -4.00891639e-02f, -4.46929485e-02f, 1.55329416e-02f, -4.46838476e-02f, 1.29469335e-01f, -4.38302085e-02f, 1.22314170e-01f, -9.29618031e-02f,
  -1.66380107e-02f, -2.03079935e-02f, -7.73753524e-02f, -9.88893062e-02f, 6.38332143e-02f, 3.40363085e-02f, -3.32588367e-02f, 2.21584618e-01f, -3.26836444e-02f, 2.27673888e-01f,
  -1.26809835e-01f, 6.02318235e-02f, -1.47607341e-01f, 8.54725298e-03f, 2.24868059e-02f, -7.47471079e-02f, 2.03092873e-01f, 1.19009025e-01f, -1.64802074e-01f, 1.11486651e-01f,
  7.61479661e-02f, 3.51138562e-02f, 1.78861529e-01f, -1.92957923e-01f, -1.99727789e-01f, -9.89663824e-02f, 1.85032785e-01f, 1.62900284e-01f, -7.89071023e-02f, 1.69704352e-02f,
  -6.61928877e-02f, -3.35929617e-02f, -9.46334675e-02f, -8.89597684e-02f, 2.77884454e-01f, -7.94241875e-02f, -1.49493918e-01f, 1.87189415e-01f, 1.87404573e-01f, 9.44063663e-02f,
  -8.93808603e-02f, -1.23723119e-01f, 8.36638808e-02f, 4.96638529e-02f, -3.70302558e-01f, 1.48406446e-01f, 1.80784985e-01f, 1.84462536e-02f, 7.73436576e-02f, -1.79976925e-01f,
  -1.40761688e-01f, -6.83802143e-02f, 3.65703814e-02f, 2.12600186e-01f, -4.85935882e-02f, -3.60632166e-02f, -2.40565673e-03f, -7.20535368e-02f, 1.23484425e-01f, -1.47553205e-01f,
  -4.28722193e-03f, -5.61609343e-02f, -1.92734480e-01f, -8.98919031e-02f, -4.85386886e-02f, -5.08668572e-02f, 8.95547196e-02f, -2.79611778e-02f, 3.21223885e-02f, 7.13566914e-02f,
  -1.14271574e-01f, 1.64230958e-01f, 5.94278127e-02f, -1.45549983e-01f, 2.20440924e-01f, -3.66627350e-02f, -2.10996158e-02f, -1.05318194e-02f, -2.82804400e-01f, -3.12658966e-01f,
  -6.82052970e-02f, -7.94366300e-02f, -1.49675030e-02f, -7.90776163e-02f, -1.72784343e-01f, -4.52310313e-03f, -7.74610117e-02f, 7.67055750e-02f, 7.17167482e-02f, 1.59165889e-01f,
  2.10039914e-01f, 2.60167390e-01f, 3.96755859e-02f, 6.39485801e-03f, 2.36005187e-01f, -1.24251628e-02f, -1.60463840e-01f, 4.11430709e-02f, 2.58298907e-02f, 1.15744852e-01f,
  1.52762964e-01f, 1.75134484e-02f, -3.31438482e-02f, 1.78152636e-01f, -3.71973030e-02f, -4.33322974e-02f, -2.18252372e-02f, -3.43424827e-01f, 2.55597621e-01f, -1.72033563e-01f,
  2.82220364e-01f, -3.76116857e-02f, -2.00043861e-02f, 2.36614961e-02f, 1.37458965e-02f, 3.24979573e-02f, 4.00083140e-02f, -1.08752109e-01f, 7.19342381e-02f, -7.05433711e-02f,
  1.39300629e-01f, 3.26075479e-02f, 6.06298214e-03f, -7.12036248e-03f, 1.13847926e-01f, -6.97579533e-02f, -1.47744117e-03f, 3.33498642e-02f, -1.43922746e-01f, -1.32778123e-01f,
  8.56170580e-02f, -1.48104187e-02f, 4.80254181e-03f, 2.10624887e-03f, 1.09371923e-01f, 3.25831659e-02f, -2.20629647e-01f, 1.63105682e-01f, -1.18177839e-01f, 5.47582330e-03f,
  -1.95191592e-01f, 5.22182733e-02f, -1.69371724e-01f, -2.14570053e-02f, 8.74207839e-02f, 1.90515801e-01f, -1.85504206e-03f, 2.25023758e-02f, 2.45307535e-01f, 1.85003489e-01f,
  -2.18247101e-01f, -7.11944848e-02f, -7.02474788e-02f, 3.67976427e-02f, -1.13520809e-01f, -3.63939293e-02f, 4.67705168e-02f, 1.68218121e-01f, 8.22728202e-02f, 2.71672476e-02f,
  -6.86345920e-02f, -1.88679129e-01f, -2.35395312e-01f, 6.87659979e-02f, -4.07710075e-02f, 2.30807334e-01f, 9.89489630e-02f, 6.68827519e-02f, -2.27539048e-01f, -2.17637941e-01f,
  1.29226968e-01f, 1.30824149e-01f, -9.42985862e-02f, -2.58286335e-02f, 1.46816745e-01f, -9.19209793e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.11318631e-03f, -2.87500881e-02f, -7.31211528e-02f, 1.04498446e-01f, 6.68324810e-03f, -6.88776933e-03f, 4.22633886e-02f, -6.01351745e-02f, -1.63920775e-01f, 3.45091224e-02f,
  3.33066322e-02f, 4.34106700e-02f, 7.02551007e-02f, -9.41108465e-02f, 1.75561398e-01f, 1.37985945e-01f, 3.01788170e-02f, 1.01750433e-01f, 2.26149596e-02f, -2.62797415e-01f,
  -2.49151234e-02f, 1.73844337e-01f, 4.60785106e-02f, 1.90244660e-01f, 1.10523477e-01f, -1.32445730e-02f, -1.54041231e-01f, 1.10002577e-01f, 7.55002275e-02f, 2.44801939e-01f,
  -1.52494222e-01f, -3.33057344e-02f, 6.47033304e-02f, -1.67633459e-01f, -6.28659204e-02f, -1.86537966e-01f, -1.65012598e-01f, 1.97331116e-01f, 9.69553888e-02f, -9.99205485e-02f,
  1.91731323e-02f, -1.37341395e-01f, 6.27414733e-02f, 2.94030994e-01f, 8.75233486e-02f, -2.06637442e-01f, -2.99815205e-03f, 1.34913519e-01f, 1.53312728e-01f, 5.36300279e-02f,
  1.47818536e-01f, -1.33465910e-02f, -8.58357623e-02f, -5.51221743e-02f, -7.45950863e-02f, 2.10911617e-01f, 3.76489833e-02f, 3.68880630e-01f, 1.13689210e-02f, -2.12166473e-01f,
  6.24490716e-02f, 2.39286348e-01f, -4.93759587e-02f, -1.22481082e-02f, -3.81933781e-03f, 1.00638010e-01f, 1.45610720e-01f, 1.10084511e-01f, -1.54345557e-02f, 2.14090422e-02f,
  3.86461169e-02f, 2.07403615e-01f, 2.56381810e-01f, 1.95052490e-01f, 1.19224302e-02f, 1.41402930e-01f, 3.22038643e-02f, 2.59695262e-01f, 1.21866658e-01f, 2.40073219e-01f,
  1.15103535e-01f, 1.24635100e-01f, 1.40176997e-01f, 1.72287539e-01f, -6.98608309e-02f, -3.62925157e-02f, 8.89167562e-02f, -9.97902453e-02f, 4.16479036e-02f, 6.08120300e-02f,
  5.53421117e-03f, 6.74395934e-02f, 1.79002076e-01f, 2.87898555e-02f, 2.52770036e-01f, 1.95025150e-02f, -2.28650898e-01f, 1.66171998e-01f, 9.58774611e-02f, 2.14498281e-01f,
  -9.30592790e-02f, 3.14535499e-02f, -1.66529361e-02f, 2.68084139e-01f, 2.41393432e-01f, 2.31179267e-01f, 2.32996807e-01f, -6.25976324e-02f, -6.13505058e-02f, 1.38778880e-01f,
  1.36722729e-01f, 1.64571151e-01f, -6.02635443e-02f, -4.58744876e-02f, -1.61458835e-01f, 8.74538943e-02f, 1.92259684e-01f, -1.66158080e-01f, -6.72884360e-02f, 1.35398060e-01f,
  -4.11287025e-02f, -1.92655936e-01f, -1.06719166e-01f, 3.20426486e-02f, 1.66029677e-01f, -3.00043583e-01f, 1.83929488e-01f, 3.71443108e-02f, 2.53295079e-02f, -3.29767726e-02f,
  1.53902784e-01f, -1.30891249e-01f, 4.00988273e-02f, 3.70986909e-02f, 5.68863675e-02f, 8.11114609e-02f, 4.12361585e-02f, -5.24300225e-02f, -1.23857437e-02f, 5.82888797e-02f,
  1.23167761e-01f, 1.37795419e-01f, 3.81464846e-02f, -5.02609946e-02f, 9.56663638e-02f, 2.67848838e-02f, 6.37619523e-03f, 4.22362313e-02f, -1.07522623e-03f, -1.82371929e-01f,
  -1.03980519e-01f, -1.58645883e-01f, 2.28961721e-01f, -1.49829775e-01f, 1.14820898e-02f, -1.14070199e-01f, 2.60479122e-01f, -4.45245951e-02f, 2.42100984e-01f, 3.02868664e-01f,
  -1.28605172e-01f, -2.21884668e-01f, -1.40428066e-01f, -8.11613202e-02f, -2.71349818e-01f, -9.76556540e-02f, 3.59901935e-01f, -9.99004915e-02f, 2.72760659e-01f, 6.44866973e-02f,
  1.04973532e-01f, -4.48876359e-02f, 1.03309415e-01f, -1.78853437e-01f, -4.76158932e-02f, -1.97563127e-01f, -2.51582824e-02f, 1.22746207e-01f, 2.53390104e-01f, -1.00108370e-01f,
  3.12817618e-02f, -1.87071025e-01f, 3.74892130e-02f, -2.30427682e-02f, 4.20082867e-01f, 1.46452844e-01f, 3.57364789e-02f, -8.99705887e-02f, 4.13210690e-02f, 2.34731123e-01f,
  -6.22415431e-02f, 2.85374165e-01f, 1.65612355e-01f, 6.13650754e-02f, 1.70118824e-01f, 1.53516561e-01f, 8.51256624e-02f, 1.22486949e-01f, 2.28463509e-03f, 2.36690249e-02f,
  7.49432370e-02f, 1.60633862e-01f, 1.66110136e-02f, -4.28797603e-02f, -2.99312710e-03f, 5.89922853e-02f, 1.09942369e-01f, 1.51242375e-01f, 2.35214204e-01f, 1.68756798e-01f,
  2.78568417e-01f, 4.85680774e-02f, 5.74159324e-02f, 2.43747756e-01f, -2.80703437e-02f, 1.80274665e-01f, 2.82246411e-01f, -1.41249895e-01f, -5.04659899e-02f, -1.39541915e-02f,
  6.05681501e-02f, 2.87259609e-01f, -9.76760313e-02f, -1.98466808e-01f, -1.66112989e-01f, -8.74468535e-02f, 2.49782756e-01f, 6.04431406e-02f, -1.49254754e-01f, 6.27306988e-03f,
  9.90512036e-03f, 9.66439694e-02f, 2.38017365e-01f, -1.57182157e-01f, 2.60927618e-01f, 1.19566008e-01f, -1.43596783e-01f, -5.12193441e-02f, -1.39877915e-01f, 2.46874839e-01f,
  2.18359679e-01f, 8.74643698e-02f, -1.06631897e-01f, -9.27387178e-02f, 2.09785834e-01f, -7.01321512e-02f, -7.20947310e-02f, 1.93876192e-01f, -4.48708087e-02f, 2.42422760e-01f,
  -2.12800458e-01f, -1.96421340e-01f, 1.02678075e-01f, -8.28367174e-02f, 1.14853442e-01f, -7.92153850e-02f, 6.74404055e-02f, 1.28384069e-01f, 8.67258757e-02f, 1.25466306e-02f,
  3.23996753e-01f, 1.73047990e-01f, 1.20551102e-01f, 1.54616619e-02f, 1.40768364e-01f, 1.03027605e-01f, 2.06162035e-01f, 6.36675879e-02f, 7.67739043e-02f, 2.01467320e-01f,
  -8.95352066e-02f, -2.44277239e-01f, 6.85644969e-02f, 5.44847874e-03f, 4.05098386e-02f, 7.80685395e-02f, -1.60804316e-01f, -1.25444308e-01f, -2.30288655e-01f, -2.68004149e-01f,
  5.45711070e-02f, -2.00784862e-01f, -2.56386220e-01f, -1.26756892e-01f, -5.47165349e-02f, -3.39955717e-01f, 1.87912360e-02f, 1.26861662e-01f, 8.86337459e-02f, -5.84406257e-02f,
  3.71568315e-02f, 2.79595349e-02f, 1.08905159e-01f, -2.75006741e-01f, 3.16856831e-01f, -9.88937616e-02f, -8.45207050e-02f, -1.66151583e-01f, -1.32891953e-01f, 1.01554349e-01f,
  2.89135963e-01f, 2.42331967e-01f, -1.28421262e-02f, 2.49908522e-01f, -6.60933256e-02f, 3.02951843e-01f, 2.40558952e-01f, 1.12501256e-01f, -4.71918248e-02f, -1.66522473e-01f,
  1.97901562e-01f, -2.05874905e-01f, 1.73117220e-01f, 1.82870671e-01f, 2.37236932e-01f, 1.23572528e-01f, -8.85932371e-02f, 1.20648526e-01f, -2.79262345e-02f, 4.17405307e-01f,
  4.37661670e-02f, 9.87140015e-02f, 4.20441069e-02f, 9.95761529e-02f, -3.01481247e-01f, -9.22271460e-02f, 3.51943634e-02f, 7.46571496e-02f, 1.68689504e-01f, 5.94972223e-02f,
  3.73323821e-02f, 1.25289902e-01f, 5.16071990e-02f, 1.19362228e-01f, 1.48930117e-01f, 2.16420755e-01f, 1.41174167e-01f, 1.55609369e-01f, -8.72381479e-02f, 9.80213806e-02f,
  1.19986422e-01f, -2.43814424e-01f, 3.52021679e-02f, -1.29995018e-01f, -2.47252390e-01f, 2.54520088e-01f, 3.13208848e-01f, -2.62852192e-01f, 1.71310320e-01f, -6.56101704e-02f,
  2.16932133e-01f, 2.32030302e-01f, 1.03905261e-01f, -7.49860629e-02f, -1.33616939e-01f, -1.63480356e-01f, 2.79354323e-02f, -5.98260202e-02f, -1.38190657e-01f, 5.02205230e-02f,
  5.54691665e-02f, 2.64538080e-01f, -1.76964745e-01f, -2.76292264e-01f, -4.79067676e-02f, -1.64885178e-01f, 7.10775610e-04f, -3.42900902e-01f, 5.46514057e-02f, -1.18784986e-01f,
  -1.36545122e-01f, 1.10873636e-02f, -4.02508080e-02f, 2.52435178e-01f, 1.17764644e-01f, -1.12419114e-01f, 1.99481651e-01f, -2.93192178e-01f, -1.01918384e-01f, 3.14644307e-01f,
  1.37271538e-01f, -7.31140673e-02f, -1.33079186e-01f, -8.50246251e-02f, 6.83202446e-02f, 7.18157589e-02f, 8.24567080e-02f, 1.23380601e-01f, 1.69640020e-01f, 4.51913364e-02f,
  7.34290779e-02f, 3.99856493e-02f, -3.31864059e-02f, 2.10423395e-02f, 1.33818090e-01f, 7.83027112e-02f, 2.29878798e-02f, -1.05456054e-01f, 5.47822379e-02f, 4.14921623e-03f,
  7.33099356e-02f, 6.82098866e-02f, 1.10341087e-01f, -1.69008180e-01f, -1.72823608e-01f, 1.62213370e-01f, 1.61599725e-01f, 1.12335958e-01f, 1.35173887e-01f, 8.09733942e-03f,
  -2.46252075e-01f, 1.54497907e-01f, -5.27827702e-02f, 2.98160821e-01f, -2.72145241e-01f, 5.56146204e-02f, -9.38845351e-02f, -1.91040784e-01f, 1.11041777e-01f, -4.08932641e-02f,
  -3.82169299e-02f, 1.97250009e-01f, -3.62991877e-02f, -1.18828736e-01f, 1.55522659e-01f, -2.39293396e-01f, -1.78368866e-01f, 2.46238485e-01f, 2.23652765e-01f, -8.01923126e-02f,
  -3.27160470e-02f, 1.25398964e-01f, 3.48837078e-01f, 1.62054121e-01f, -1.41052008e-01f, -2.02809274e-02f, -1.01702258e-01f, -8.65364820e-02f, -1.63140714e-01f, 1.65832818e-01f,
  4.56480868e-02f, 4.28125352e-01f, 4.64251600e-02f, 6.28798902e-02f, 2.33488306e-02f, 1.93463489e-01f, -9.49719027e-02f, -1.22313602e-02f, 1.44821987e-01f, 1.75511748e-01f,
  -1.19547043e-02f, -5.97758368e-02f, 1.25710458e-01f, 1.20669968e-01f, 5.14937527e-02f, -6.22086525e-02f, 6.06014840e-02f, 1.28546925e-02f, 1.23651341e-01f, -3.11958455e-02f,
  -6.72927946e-02f, 1.37477472e-01f, 2.36079693e-02f, 2.90986598e-02f, 8.48951042e-02f, 4.78881411e-02f, 1.01625934e-01f, -3.99850979e-02f, 1.37369633e-01f, -2.74495836e-02f,
  -2.90427744e-01f, -1.56657159e-01f, 1.37324318e-01f, -2.92809099e-01f, 2.77833015e-01f, -1.78466097e-01f, 1.17559321e-01f, -1.96111262e-01f, 1.72212068e-03f, -8.40940177e-02f,
  -1.96435422e-01f, -2.23443419e-01f, 2.02021956e-01f, -4.32825312e-02f, -1.27995044e-01f, -2.63914466e-01f, 6.05663396e-02f, 4.42068689e-02f, 2.19596282e-01f, -7.46838674e-02f,
  -8.51306766e-02f, -9.95340720e-02f, 1.25395447e-01f, -8.47071633e-02f, -1.38648674e-02f, 1.42682483e-02f, 4.71308380e-02f, 2.44183421e-01f, 5.68498392e-03f, -1.02714812e-02f,
  4.05640429e-04f, -1.16002329e-01f, 1.03655374e-02f, -1.42732769e-01f, 3.71825010e-01f, 1.85570315e-01f, 2.31124181e-02f, -1.12718225e-01f, 3.63120228e-01f, -1.18793763e-01f,
  -1.45452125e-02f, 7.87048787e-02f, 1.07578531e-01f, -5.64120077e-02f, -1.36330724e-01f, 9.75337159e-03f, -1.93499457e-02f, 9.50791761e-02f, 6.09024800e-02f, -5.13390414e-02f,
  6.96224272e-02f, -1.70186069e-02f, 8.60992223e-02f, 4.12425883e-02f, 1.64796188e-01f, 6.81519322e-03f, -5.70949838e-02f, 1.53125986e-01f, -1.65947869e-01f, -5.57269752e-02f,
  -8.72427672e-02f, -2.49995276e-01f, -1.99402347e-01f, -1.09446876e-01f, 8.89560021e-03f, 4.35459577e-02f, -1.84254602e-01f, 6.13637120e-02f, 7.81436563e-02f, -1.46133797e-02f,
  -1.06609121e-01f, 3.94167639e-02f, -1.84367314e-01f, 2.72877421e-02f, -1.23696193e-01f, 2.06918698e-02f, -9.84076783e-02f, -2.25354552e-01f, 1.55188560e-01f, 2.41668429e-02f,
  -1.65557384e-01f, -2.23912105e-01f, 1.69251695e-01f, 1.22982927e-01f, -2.63632387e-02f, 1.59802705e-01f, 3.47547531e-01f, -4.79434654e-02f, 3.15429449e-01f, -1.78250328e-01f,
  -1.17776901e-01f, -4.72195596e-02f, -1.87209830e-01f, 1.87572688e-01f, -2.03424111e-01f, 1.47747934e-01f, -8.13765749e-02f, 2.59833276e-01f, 5.52765317e-02f, -1.07138395e-01f,
  2.66167462e-01f, -2.20257998e-03f, 1.53073296e-03f, -5.66770770e-02f, 1.68077514e-01f, -9.35335308e-02f, 1.31381914e-01f, 1.80035040e-01f, 9.58217308e-02f, 1.88375682e-01f,
  1.92196310e-01f, 1.11204043e-01f, 1.79472435e-02f, -9.11475420e-02f, 7.49943405e-02f, 1.27190053e-01f, 1.68832108e-01f, 1.18694648e-01f, 2.15480365e-02f, -9.10090655e-03f,
  -9.01764408e-02f, -1.18360752e-02f, 1.93369463e-02f, 9.16546285e-02f, 1.40083089e-01f, 6.92171231e-02f, -8.87270719e-02f, -1.01256380e-02f, 6.58942200e-03f, 1.48673639e-01f,
  -2.37907231e-01f, 1.42744333e-02f, 9.08124968e-02f, -6.78516633e-04f, -2.68118173e-01f, -1.42261639e-01f, -1.73069075e-01f, -2.80183434e-01f, 1.54059172e-01f, 2.17588261e-01f,
  5.28002903e-02f, 1.82246029e-01f, 2.34573230e-01f, -9.18963552e-02f, -2.06558540e-01f, 2.30881110e-01f, -2.26120427e-01f, 2.22570091e-01f, 7.57040530e-02f, -2.32110675e-02f,
  -5.79305589e-02f, 2.64220357e-01f, 1.53376445e-01f, 2.41563112e-01f, -2.09557209e-02f, 3.98278162e-02f, -1.10259548e-01f, 6.84062466e-02f, 1.33758813e-01f, 2.80836761e-01f,
  2.00354531e-01f, -1.07369967e-01f, -2.93493956e-01f, -1.06760755e-01f, 9.06070620e-02f, 1.53156355e-01f, 2.60910075e-02f, -1.18661344e-01f, -9.34337825e-02f, -4.60135005e-03f,
  1.18000321e-01f, 3.56523991e-02f, -3.72794129e-05f, 5.40191904e-02f, 2.09840402e-01f, 2.20385179e-01f, 4.07358445e-02f, -8.70014206e-02f, 8.05313215e-02f, 4.16178368e-02f,
  1.25133842e-01f, -6.64580837e-02f, 5.52042108e-03f, 8.44000801e-02f, -1.27526015e-01f, 4.26834598e-02f, -4.33690883e-02f, -2.70703547e-02f, 1.51439205e-01f, 1.19812731e-02f,
  5.64347729e-02f, 2.59293872e-03f, -9.98782367e-02f, -8.77287388e-02f, 1.08549595e-01f, -2.96790659e-01f, 1.23928390e-01f, -1.14816569e-01f, 4.95208241e-02f, -7.60024264e-02f,
  -1.29554227e-01f, -3.09514292e-02f, -1.87435254e-01f, -6.48047179e-02f, 1.56627402e-01f, -4.50372603e-03f, -7.78663605e-02f, -1.82346582e-01f, -5.88757023e-02f, 4.04192545e-02f,
  2.59677052e-01f, 1.01261407e-01f, -1.07756890e-02f, -4.64173779e-02f, 1.85649365e-01f, -2.51404215e-02f, 8.09609517e-02f, -2.79333945e-02f, 8.51404965e-02f, 8.38660151e-02f,
  -1.50227129e-01f, 7.13199154e-02f, 7.43775666e-02f, -4.86493297e-02f, -9.73081365e-02f, -6.08315542e-02f, 1.32086143e-01f, 2.85954606e-02f, 6.28605410e-02f, -2.99832374e-02f,
  2.34245971e-01f, -8.90937224e-02f, 3.16886641e-02f, -7.20193377e-04f, -3.66690643e-02f, 9.49250832e-02f, 1.76171094e-01f, 7.56094381e-02f, -7.46461228e-02f, -1.82533458e-01f,
  3.59242298e-02f, 2.84990311e-01f, 1.72287852e-01f, 1.91865936e-01f, -2.64753401e-03f, 1.14160232e-01f, 2.03872949e-01f, 4.74934205e-02f, 2.16111615e-01f, 2.11858600e-01f,
  4.94014174e-02f, 1.47742629e-01f, -7.74509236e-02f, 6.43122122e-02f, -4.63047810e-02f, -1.08992957e-01f, 2.20971763e-01f, -6.85668141e-02f, -1.08559262e-02f, 2.49641627e-01f,
  -8.97028968e-02f, 5.90388030e-02f, 4.91023622e-02f, 8.94709080e-02f, 2.26378649e-01f, 1.68782696e-01f, 4.70183082e-02f, -6.37652352e-02f, -1.31787151e-01f, -1.77668612e-02f,
  -5.27385399e-02f, 1.48972884e-01f, 4.12919372e-02f, 6.24830797e-02f, -2.56484821e-02f, 3.44691314e-02f, 1.16091594e-01f, -1.68600261e-01f, -9.78936106e-02f, 1.54869007e-02f,
  4.02097516e-02f, -8.92520323e-03f, 3.51692103e-02f, -6.33140579e-02f, 8.81179050e-02f, -5.44133894e-02f, -9.73192975e-02f, -1.03941737e-02f, 6.07659034e-02f, 9.66366976e-02f,
  -3.97151709e-02f, -3.80653813e-02f, -1.19240858e-01f, 2.60737687e-01f, -1.74970791e-01f, 2.63516009e-02f, -4.40618806e-02f, 3.90946195e-02f, -3.16428207e-02f, -7.09073544e-02f,
  1.07162915e-01f, 8.88154954e-02f, -9.79922041e-02f, -3.02018989e-02f, -2.15024687e-02f, 9.21649635e-02f, 6.32857382e-02f, 7.94521812e-03f, 5.18251620e-02f, 6.46756962e-02f,
  4.12325412e-02f, -2.40312871e-02f, 3.76593620e-02f, 1.21005043e-01f, 3.01505458e-02f, 9.50917453e-02f, 1.74495697e-01f, 1.90546289e-02f, 1.75562784e-01f, 1.92083836e-01f,
  9.53352451e-02f, 2.31272310e-01f, 1.69473752e-01f, -1.32133216e-02f, -6.35616705e-02f, 9.64629278e-02f, -6.96401185e-05f, 2.03252435e-01f, 6.42085075e-02f, -5.77414222e-02f,
  2.30539683e-02f, -1.07117340e-01f, -9.80634168e-02f, 6.96582198e-02f, -1.36821195e-01f, 7.90316015e-02f, -2.75372854e-03f, -6.42279908e-02f, 1.16873853e-01f, -6.87159002e-02f,
  2.50202388e-01f, 1.43890589e-01f, -1.87360853e-01f, -1.96478646e-02f, -1.83440105e-03f, 1.41540426e-03f, -3.80369909e-02f, -3.89646664e-02f, 1.09302387e-01f, -1.45001233e-01f,
  1.65039971e-01f, 3.07261795e-02f, 2.12563900e-03f, 1.89670026e-01f, -6.72525242e-02f, 1.36897657e-02f, -1.44079983e-01f, -1.88672036e-01f, -1.49264961e-01f, -8.51401910e-02f,
  5.88401556e-02f, -3.21655013e-02f, 6.23668320e-02f, 1.84673503e-01f, 2.73316592e-01f, 1.46719545e-01f, 1.42188268e-02f, -7.07976371e-02f, 2.46565249e-02f, 2.43275464e-01f,
  1.38854161e-01f, 1.07927807e-01f, 1.14295147e-02f, 3.39221269e-01f, 2.16342762e-01f, 1.39136150e-01f, 2.55650699e-01f, 1.20057680e-01f, 2.43129730e-01f, 2.04894602e-01f,
  1.25624359e-01f, 3.82069677e-01f, -2.30850838e-02f, -9.46952999e-02f, 1.01514898e-01f, -1.16061255e-01f, -4.34080400e-02f, 1.65697649e-01f, -3.01642776e-01f, -6.85201585e-02f,
  9.39611793e-02f, -1.18370019e-01f, 2.57147968e-01f, 2.78121859e-01f, 9.41522568e-02f, -5.29767051e-02f, 5.21072373e-03f, 1.10544767e-02f, 5.74448593e-02f, -2.83369422e-02f,
  4.10400884e-04f, -2.42506806e-02f, 7.53493235e-03f, -5.07555977e-02f, -2.16894254e-01f, -1.67984486e-01f, -1.64268777e-01f, 1.25698909e-01f, -3.76134336e-01f, 2.34568026e-02f,
  2.48293132e-01f, 1.08212747e-01f, -3.24572660e-02f, 3.93112451e-02f, -1.90730095e-01f, 5.75431101e-02f, 9.47650895e-02f, -3.07445735e-01f, 1.61748812e-01f, -6.69972524e-02f,
  -7.73479342e-02f, 5.20542085e-01f, -1.48717612e-01f, 1.70780644e-01f, -2.20470488e-01f, 1.79674938e-01f, 6.40380234e-02f, -7.09023029e-02f, 6.58197105e-02f, 7.47002289e-02f,
  3.39687988e-02f, 2.17130501e-03f, 1.63418785e-01f, 1.04268894e-01f, -7.91079104e-02f, 2.60483176e-02f, 1.87405556e-01f, 3.34565006e-02f, 5.83931170e-02f, -4.43999805e-02f,
  1.26079410e-01f, 1.11653097e-01f, 1.59676939e-01f, 3.96529473e-02f, 6.39581606e-02f, -1.84916571e-01f, 1.32306695e-01f, 1.82758003e-01f, 7.72203580e-02f, 3.24792892e-01f,
  4.22175080e-02f, 1.66886710e-02f, -6.78446367e-02f, 9.66169406e-03f, -2.09541783e-01f, 1.64154351e-01f, -2.05890223e-01f, 1.15664573e-02f, 1.77152142e-01f, -1.69431552e-01f,
  -1.38030410e-01f, -1.79911956e-01f, 3.28432657e-02f, 3.80669795e-02f, 3.89496200e-02f, -1.93243936e-01f, -2.33967062e-02f, -2.13311255e-01f, 4.29938883e-02f, 2.36885458e-01f,
  5.51419295e-02f, -5.59495343e-03f, -1.22632775e-02f, -1.88873394e-03f, 2.10717335e-01f, 1.12341605e-01f, 2.99394995e-01f, -5.41315228e-02f, 6.81835413e-03f, 3.01742226e-01f,
  2.66193241e-01f, 1.20144054e-01f, 7.69049004e-02f, 1.35105357e-01f, 9.40673649e-02f, 3.29392590e-03f, -1.52905509e-01f, 3.22448701e-01f, 1.33435830e-01f, 8.67706835e-02f,
  -6.73487550e-03f, 6.06869049e-02f, 6.77402392e-02f, 1.22763395e-01f, -1.55581851e-02f, -3.37036438e-02f, -1.76575570e-03f, 9.34095606e-02f, 2.60054380e-01f, 1.29330859e-01f,
  1.14958212e-01f, 1.46140292e-01f, 1.29366070e-01f, 9.25023183e-02f, -1.20279165e-02f, 1.17035724e-01f, 9.72173512e-02f, 6.78617088e-03f, 1.11980699e-02f, 1.35111198e-01f,
  -1.18888490e-01f, -9.56724733e-02f, 1.10521190e-01f, -8.70564952e-03f, -1.24237448e-01f, 2.32765347e-01f, -4.31826897e-02f, -4.01020423e-02f, -9.47742611e-02f, -9.68205035e-02f,
  7.88117871e-02f, -6.96685091e-02f, 1.03211254e-01f, 1.91166505e-01f, -1.95645113e-02f, 3.05460155e-01f, 8.41152743e-02f, 2.16222927e-02f, -2.74208263e-02f, 2.11853892e-01f,
  -1.84929177e-01f, 1.49832651e-01f, 1.84090406e-01f, -2.69699320e-02f, -1.81024730e-01f, 2.29948133e-01f, 3.98345664e-02f, 1.66104555e-01f, -1.90811127e-01f, -1.55188829e-01f,
  3.10677402e-02f, -4.16075252e-02f, 2.58259773e-02f, 1.54508814e-01f, 1.62111014e-01f, 1.88645883e-03f, -2.53479093e-01f, -3.12715799e-01f, -7.19171204e-03f, 2.65973300e-01f,
  -6.02103099e-02f, -1.22607514e-01f, 7.92979300e-02f, 4.60630320e-02f, -1.47805018e-02f, -8.62201601e-02f, -4.82815728e-02f, -3.95777300e-02f, -6.77789301e-02f, -3.14649753e-02f,
  6.66579381e-02f, 5.59215248e-02f, 8.19083899e-02f, -6.46975562e-02f, 4.52918150e-02f, 9.40153673e-02f, 1.82139799e-01f, 2.73042754e-03f, 3.59594040e-02f, 2.47227214e-02f,
  2.47524157e-02f, 7.19507691e-03f, -6.39435798e-02f, -2.18535334e-01f, -1.61953390e-01f, -1.54631644e-01f, 1.44471750e-01f, -7.27368966e-02f, -1.44642800e-01f, 1.91620171e-01f,
  -6.17403165e-02f, -9.69476160e-03f, -9.76110473e-02f, -5.42905629e-02f, -7.05249384e-02f, 1.44865215e-01f, 5.49162440e-02f, 3.55457515e-02f, -1.62604332e-01f, -3.43143716e-02f,
  1.41223997e-01f, 9.86952484e-02f, 1.97787777e-01f, -4.39008372e-03f, 4.17674035e-02f, 1.32724211e-01f, 3.85016389e-02f, 1.34325437e-02f, 2.65051782e-01f, 3.78381535e-02f,
  1.40018523e-01f, -1.37167662e-01f, -1.88489899e-01f, 1.38270450e-04f, 2.07750484e-01f, 9.67837349e-02f, -3.45451944e-02f, 2.37181243e-02f, 1.75053980e-02f, 2.07193747e-01f,
  7.23304525e-02f, -9.94162038e-02f, 1.63737163e-01f, 1.39585897e-01f, -5.23123555e-02f, 1.17458627e-01f, 1.12888306e-01f, 1.42164439e-01f, 5.17689846e-02f, -6.71183318e-02f,
  5.71754463e-02f, 1.94970846e-01f, -5.58831021e-02f, -1.39947414e-01f, 7.36726224e-02f, 1.07471958e-01f, 9.79175568e-02f, 1.30902529e-01f, 1.31677955e-01f, 2.31728077e-01f,
  1.13112047e-01f, -5.14229238e-02f, 1.52074650e-01f, 2.04893976e-01f, 2.08114177e-01f, 8.63122270e-02f, 1.67241096e-01f, -2.33980790e-02f, 5.24987429e-02f, 1.17411412e-01f,
  2.07742006e-01f, 1.24418750e-01f, -1.22994073e-01f, 2.64928758e-01f, -1.81488767e-01f, 1.45578399e-01f, -1.70558412e-02f, 1.34761035e-01f, -4.73785140e-02f, 1.32125214e-01f,
  1.98103741e-01f, -7.35103413e-02f, -1.42937824e-01f, -1.10975131e-01f, 8.51127356e-02f, 1.84977636e-01f, 1.33328442e-03f, -1.31420493e-01f, -5.88849187e-02f, -6.47821575e-02f,
  5.97500056e-02f, 2.20233127e-01f, -9.89031866e-02f, 5.80254458e-02f, -8.30074772e-03f, 7.78115615e-02f, 1.40543535e-01f, -6.55400977e-02f, 1.75657958e-01f, 4.10821140e-02f,
  -1.00533515e-01f, 2.91153878e-01f, 1.26258507e-01f, 1.11121543e-01f, -8.03723261e-02f, 3.29800658e-02f, -2.10170913e-02f, 1.70344561e-01f, -2.70636708e-01f, 2.30157033e-01f,
  3.71708572e-02f, 4.06178385e-02f, -6.19200291e-03f, 1.75238058e-01f, 2.03835711e-01f, 8.51307586e-02f, -1.16110064e-01f, -2.16614455e-02f, -1.12873167e-02f, 1.49996862e-01f,
  2.32657239e-01f, 1.94455937e-01f, -3.58226821e-02f, 6.36006370e-02f, 1.36515692e-01f, 1.19532764e-01f, 1.46353975e-01f, 2.18431816e-01f, 1.64320260e-01f, 1.06520280e-01f,
  7.04527050e-02f, 1.38310507e-01f, -3.95349786e-02f, -1.81829616e-01f, 1.38519004e-01f, -8.99571702e-02f, 7.64584243e-02f, -1.84353255e-02f, 1.43145829e-01f, 9.70980618e-03f,
  1.67713493e-01f, 5.47373779e-02f, 1.96730778e-01f, 2.09414348e-01f, -1.96352214e-01f, -1.24161702e-03f, 6.20770268e-02f, -6.14199787e-02f, -3.79418209e-02f, 2.96688713e-02f,
  5.31859472e-02f, 1.52666792e-01f, 3.47847342e-01f, 1.60189867e-01f, 8.53445157e-02f, -2.36258075e-01f, -9.10117105e-03f, -8.97949934e-02f, 9.59634483e-02f, -1.62220195e-01f,
  1.14385225e-01f, 5.40832020e-02f, -1.04058921e-01f, -1.09398793e-02f, 2.02967778e-01f, -1.33904964e-01f, -1.07058674e-01f, 1.30131453e-01f, 2.37062946e-01f, 4.85099852e-03f,
  -1.41895264e-01f, 1.67054132e-01f, 1.21895403e-01f, -1.86326981e-01f, -2.62634791e-02f, 5.72900213e-02f, 1.05972618e-01f, -8.09494033e-02f, 5.70903569e-02f, 1.41423360e-01f,
  1.04179025e-01f, 8.95835087e-02f, 5.97359948e-02f, 5.27362674e-02f, 1.14452004e-01f, -1.35772675e-01f, 1.19362101e-01f, -6.69725612e-03f, 2.88415421e-02f, -7.53336102e-02f,
  9.82461125e-03f, 1.54042514e-02f, 9.90771055e-02f, -7.74689168e-02f, 1.77362263e-01f, -1.01691179e-01f, -2.23722253e-02f, -4.35122363e-02f, -7.24597722e-02f, 1.93756297e-01f,
  -3.20671916e-01f, 1.23003768e-02f, 1.55671500e-02f, -1.90085351e-01f, -2.72598028e-01f, -1.60075128e-01f, -3.24445814e-01f, 3.24839205e-02f, 2.13434339e-01f, 2.23713759e-02f,
  -2.61695385e-02f, -1.11724369e-01f, 1.83696926e-01f, -4.87989224e-02f, -2.84007579e-01f, -1.58441529e-01f, -1.46677762e-01f, -2.00128525e-01f, -2.66957313e-01f, 2.57331669e-01f,
  2.12245345e-01f, 1.66172996e-01f, 1.08422957e-01f, -6.89670071e-02f, 1.88659653e-02f, -2.91574560e-02f, -1.59198999e-01f, 1.29527017e-01f, -1.51663020e-01f, 3.86276454e-01f,
  2.46548757e-01f, -1.07986413e-01f, -1.11378640e-01f, -2.50749290e-01f, 2.83849895e-01f, 2.53097385e-01f, -1.85759112e-01f, -5.90062067e-02f, 8.96655843e-02f, -1.19442903e-01f,
  8.84521604e-02f, 1.56161517e-01f, -3.14855129e-02f, 6.83882907e-02f, 3.12071085e-01f, 1.88673273e-01f, 6.84063211e-02f, -4.67610322e-02f, 1.55223429e-01f, 1.45179689e-01f,
  2.54374951e-01f, -8.11212137e-02f, -1.34733543e-01f, 1.13936163e-01f, -1.29337609e-01f, -2.87916847e-02f, -2.38540228e-02f, -4.44462225e-02f, 2.52217352e-01f, -5.48599474e-02f,
  -8.30226094e-02f, 1.54267058e-01f, -6.85140416e-02f, 8.40069056e-02f, -1.02286309e-03f, -2.45372802e-01f, 7.37160519e-02f, 5.33010066e-02f, -2.29572833e-01f, -7.57066756e-02f,
  -2.67831743e-01f, -3.76696706e-01f, -6.50366917e-02f, 2.35823363e-01f, 1.58798873e-01f, 2.97228128e-01f, 1.51386023e-01f, -1.59933507e-01f, -1.42557725e-01f, 2.04610839e-01f,
  -1.91211849e-02f, 8.04716870e-02f, 4.41812277e-02f, 7.09310919e-02f, 3.97628397e-02f, 2.20610976e-01f, 1.28917649e-01f, 3.70500952e-01f, -1.23518426e-02f, 1.39199600e-01f,
  -1.61722541e-01f, 5.86732998e-02f, 1.69761494e-01f, 1.05062434e-02f, 7.85932839e-02f, 2.68135089e-02f, -2.89988339e-01f, 1.65286325e-02f, 1.02740780e-01f, -1.02195896e-01f,
  2.26132140e-01f, -1.55136004e-01f, 1.32212147e-01f, 1.35168180e-01f, 2.88102571e-02f, 1.25898957e-01f, -2.20075361e-02f, 5.86455734e-03f, -1.03128769e-01f, -1.86133217e-02f,
  3.93377021e-02f, 1.24735937e-01f, 2.21102402e-01f, 9.42662954e-02f, -9.66210663e-02f, 1.03171192e-01f, 1.69848591e-01f, 1.85670242e-01f, 5.51206805e-02f, 1.83806300e-01f,
  4.97015230e-02f, 1.57405771e-02f, -2.86388285e-02f, -6.81311637e-02f, -2.06697620e-02f, -8.40042010e-02f, 1.56634837e-01f, -1.50762185e-01f, -7.60847032e-02f, 2.01111838e-01f,
  1.98137268e-01f, 1.77423786e-02f, 1.74866617e-01f, 1.01798445e-01f, 2.19873503e-01f, -4.27218294e-03f, -1.42024949e-01f, 2.59116054e-01f, -4.20795232e-02f, 5.83476946e-02f,
  -2.52880156e-02f, 2.03538373e-01f, -1.13375792e-02f, 1.68636203e-01f, 5.89243956e-02f, 3.42515260e-01f, 1.82553276e-01f, -2.14851335e-01f, 1.21276127e-02f, -3.50275561e-02f,
  2.59007931e-01f, -1.14487156e-01f, -2.63781875e-01f, -1.76737696e-01f, 1.20845765e-01f, 1.16117567e-01f, 9.03442279e-02f, -9.84566510e-02f, -2.67417189e-02f, 3.28308970e-01f,
  -1.96641102e-01f, -3.75174075e-01f, -2.37106960e-02f, 2.83770300e-02f, 4.93196584e-02f, -2.14831069e-01f, 8.52141976e-02f, -5.78278564e-02f, 9.66925919e-02f, -5.50865568e-02f,
  -7.43824095e-02f, 9.21558738e-02f, -5.63758351e-02f, 2.14187250e-01f, 1.52380899e-01f, -1.02233365e-01f, -3.82738225e-02f, 1.49935469e-01f, 1.52593583e-01f, -3.26994844e-02f,
  7.37799481e-02f, 2.47746299e-04f, 3.59688215e-02f, 2.15004057e-01f, 8.50222781e-02f, 1.30871683e-01f, 1.11587398e-01f, -2.77256221e-01f, 1.05506450e-01f, 2.47086376e-01f,
  5.87198809e-02f, 2.48341739e-01f, 1.12051718e-01f, -4.65240777e-02f, 2.96349853e-01f, 1.23824455e-01f, 4.61015664e-02f, 2.48526335e-01f, -1.17571525e-01f, -3.32054317e-01f,
  -8.63280147e-02f, 1.77484378e-01f, -6.02836013e-02f, 1.91652065e-03f, -1.69266060e-01f, 1.48936838e-01f, -7.24521652e-02f, 2.17699081e-01f, -4.31901542e-04f, 2.50899106e-01f,
  3.51400822e-01f, 1.55989990e-01f, 9.86311287e-02f, -2.83916052e-02f, 1.71205431e-01f, 1.15833901e-01f, -6.87693655e-02f, -5.79546764e-02f, 1.41179219e-01f, -1.13599576e-01f,
  1.25504926e-01f, 9.15130526e-02f, -5.28274663e-02f, 2.97095865e-01f, -1.98822439e-01f, 1.47728220e-01f, -8.98089074e-03f, -4.27171916e-01f, 2.95337439e-01f, 8.06394890e-02f,
  2.84977518e-02f, -2.45469704e-01f, 1.03568425e-02f, 5.79729080e-02f, -9.47489496e-03f, 9.26980972e-02f, -5.95091376e-03f, 4.96290065e-03f, 1.31218866e-01f, 9.40510780e-02f,
  1.89020470e-01f, 1.00194931e-01f, -3.50318663e-02f, 1.29493192e-01f, 1.61101207e-01f, 1.91826120e-01f, -6.28198311e-02f, 1.59339458e-01f, -5.14071025e-02f, 2.58221757e-02f,
  3.45938466e-02f, 4.66634259e-02f, -1.71597674e-01f, -5.28630503e-02f, 9.80235711e-02f, -7.97249749e-02f, -7.81711042e-02f, 7.00410455e-02f, 4.86197416e-03f, 9.30491313e-02f,
  -4.79816198e-02f, 2.03055777e-02f, 3.96692716e-02f, 3.73306754e-03f, -3.41006108e-02f, 2.89929837e-01f, -7.09947664e-03f, 1.57726988e-01f, 6.01156466e-02f, 5.60189486e-02f,
  -1.75343752e-02f, 6.53504133e-02f, 5.40077612e-02f, 3.05047631e-01f, 2.38044336e-01f, 5.29425293e-02f, 1.32179871e-01f, 1.15749843e-01f, 2.02567548e-01f, 1.60707071e-01f,
  -2.45365322e-01f, -1.74439430e-01f, -6.08529598e-02f, 1.47911996e-01f, 1.17982931e-01f, -1.77031141e-02f, -1.29346967e-01f, 1.39280275e-01f, -2.83029318e-01f, -2.78477639e-01f,
  1.29183769e-01f, 1.33639425e-01f, 2.40709279e-02f, -1.59117252e-01f, 1.38616234e-01f, -3.65485554e-03f, 1.66701525e-02f, -3.18031721e-02f, -5.36198504e-02f, 2.07723275e-01f,
  -4.09100763e-02f, 3.88937034e-02f, 1.94431413e-02f, 6.56204717e-03f, -2.68081836e-02f, -4.31462862e-02f, 1.45273402e-01f, 1.11478731e-01f, 8.42146203e-02f, -7.05647320e-02f,
  7.89936725e-03f, -5.02491668e-02f, 1.49719995e-02f, 1.05576895e-01f, 1.57225624e-01f, -5.33260442e-02f, 2.29279101e-01f, 1.75161198e-01f, -2.20707748e-02f, 1.97807983e-01f,
  -3.53495441e-02f, 9.77408662e-02f, 1.68404859e-02f, -2.55778711e-02f, -1.28816515e-01f, 8.51094201e-02f, 7.80368075e-02f, -2.11636871e-01f, 1.55217856e-01f, -3.82643491e-02f,
  -1.65681303e-01f, 2.16110162e-02f, -3.34462002e-02f, 2.09887978e-02f, -1.66920312e-02f, 4.13680226e-02f, -2.10917592e-01f, 1.39788926e-01f, 2.49146387e-01f, 6.32891580e-02f,
  -2.11054415e-01f, -1.25284456e-02f, 5.19254394e-02f, -7.01414980e-03f, 3.54956612e-02f, -1.21772431e-01f, 2.57841438e-01f, -1.30451202e-01f, 1.06827661e-01f, 2.49343708e-01f,
  1.61703676e-01f, 9.16066095e-02f, -6.89188913e-02f, -7.99810067e-02f, -2.37756018e-02f, -9.80121568e-02f, -1.02123134e-01f, 7.98010305e-02f, 1.60185453e-02f, -1.18895955e-01f,
  9.33056176e-02f, 1.73957005e-01f, 1.09496705e-01f, 8.02223757e-02f, 1.69547811e-01f, 2.46843413e-01f, -5.43530472e-02f, -6.28006160e-02f, 5.74604534e-02f, 1.79241627e-01f,
  1.25690550e-01f, 8.90694745e-03f, -1.70551091e-01f, 1.10761940e-01f, -5.78726046e-02f, -9.05226916e-03f, 6.95535317e-02f, 9.78928283e-02f, 1.72149524e-01f, 1.91978663e-01f,
  6.14812039e-02f, 5.29236272e-02f, -2.50556976e-01f, -1.04325384e-01f, 1.83710665e-01f, -1.36768892e-01f, 1.71033174e-01f, -1.37551039e-01f, 1.64037161e-02f, -1.86935097e-01f,
  2.68188901e-02f, -2.50285476e-01f, -5.99894188e-02f, -2.67024199e-03f, 2.28788018e-01f, 2.13648185e-01f, -6.68652505e-02f, -1.50476575e-01f, -6.55230880e-02f, 2.92730540e-01f,
  -6.26810566e-02f, 1.49209648e-01f, -4.97597978e-02f, -1.11580409e-01f, -9.14088339e-02f, 7.84359053e-02f, -1.21784255e-01f, 2.47289255e-01f, 5.25724553e-02f, 1.18524760e-01f,
  -1.06410757e-01f, 3.32844793e-03f, 2.31611252e-01f, -5.40553257e-02f, 6.58568665e-02f, -2.70283937e-01f, -1.91289987e-02f, 1.73768401e-01f, -8.89466144e-03f, 3.59313306e-03f,
  2.65336722e-01f, -1.51722208e-01f, -5.62371984e-02f, -1.01896860e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.90581065e-02f, 1.28507599e-01f, 1.06804781e-01f, 2.94899736e-02f, 1.26616493e-01f, 1.60541967e-01f, 1.16240988e-02f, 4.22354639e-02f, -6.42288551e-02f, 1.48708988e-02f,
  1.69724394e-02f, 9.51198414e-02f, -3.34600545e-02f, 1.49758667e-01f, 1.13891453e-01f, 1.80660076e-02f, 1.11361124e-01f, 9.22604874e-02f, 1.66183054e-01f, 3.88871692e-02f,
  8.40863511e-02f, 1.48880169e-01f, 2.60289256e-02f, 4.17631976e-02f, 5.50595373e-02f, 1.61789730e-03f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.18761832e-02f, 5.46312965e-02f, 2.82092579e-02f, -3.96767259e-02f, 5.10347411e-02f, 1.02725096e-01f, 1.19401671e-01f, -7.23176226e-02f, -3.33351754e-02f, 3.41411568e-02f,
  8.67226571e-02f, 4.15641069e-02f, -4.19535786e-02f, 6.65239170e-02f, -3.40057872e-02f, 1.41975418e-01f, 3.44504453e-02f, 7.56324902e-02f, -4.78357933e-02f, 1.70823604e-01f,
  -4.96465750e-02f, 5.03091365e-02f, -8.46819766e-03f, -5.71527034e-02f, 1.08836731e-02f, 1.92057993e-02f, 9.12585482e-03f, -1.60336897e-01f, -4.95878384e-02f, 1.77313276e-02f,
  -4.03190292e-02f, 1.23918414e-01f, 8.45912695e-02f, -1.35847598e-01f, 3.90339158e-02f, -6.24381937e-02f, -1.11692972e-01f, -2.03521326e-02f, -6.22673817e-02f, -1.38723142e-02f,
  2.33168483e-01f, -9.50067043e-02f, 1.36785671e-01f, 7.13770688e-02f, 9.25734057e-04f, 1.06484570e-01f, 6.70394599e-02f, -1.46642506e-01f, 1.65912107e-01f, -2.25327723e-03f,
  -1.30375803e-01f, 8.78480971e-02f, -1.60748750e-01f, -9.37411040e-02f, -2.39916649e-02f, -3.61682102e-02f, 1.27476931e-01f, -1.26594529e-01f, -1.08077705e-01f, 1.09451212e-01f,
  -1.86157569e-01f, 1.44942163e-03f, -3.14140543e-02f, -1.02539778e-01f, -5.87512963e-02f, 5.14764488e-02f, -5.53245470e-02f, -8.19942951e-02f, -3.33751775e-02f, 8.39215517e-02f,
  -6.13269694e-02f, -5.88005632e-02f, 5.28034978e-02f, -1.38454288e-01f, -1.21603109e-01f, -4.10434902e-02f, 2.85225431e-03f, 1.66595064e-03f, -6.51294366e-02f, 9.34605077e-02f,
  1.12555690e-01f, -5.56961894e-02f, -8.62385631e-02f, 8.17808136e-02f, -2.21202448e-02f, -1.82729781e-01f, -2.53196880e-02f, -1.49100691e-01f, 1.32866129e-01f, 2.10730191e-02f,
  -1.55517146e-01f, 1.25877820e-02f, 6.36961088e-02f, -2.43281219e-02f, 1.69414192e-01f, 4.33905758e-02f, 9.61295702e-03f, -5.13108112e-02f, -1.21678956e-01f, -2.11966913e-02f,
  2.43658628e-02f, 1.92627743e-01f, -3.85454786e-03f, 4.71732579e-02f, -1.84401974e-01f, -1.11592308e-01f, -1.16932459e-01f, 3.84915918e-02f, 1.75902680e-01f, -1.27925038e-01f,
  1.60469219e-01f, -9.81803164e-02f, -1.74671020e-02f, 4.84520756e-02f, -1.99148133e-01f, -8.48118141e-02f, -5.16645201e-02f, 5.00831492e-02f, -7.56579963e-03f, -7.12120980e-02f,
  2.01001819e-02f, 1.04087375e-01f, -1.04019240e-01f, 1.13356337e-01f, -2.28898585e-01f, 5.00111431e-02f, -2.62345493e-01f, -1.95978999e-01f, 6.59554228e-02f, -4.44318578e-02f,
  1.31265804e-01f, 6.18383326e-02f, -1.33421168e-01f, -2.48525608e-02f, 4.52194363e-02f, 9.79383737e-02f, 5.07001728e-02f, -7.00144991e-02f, 9.92783625e-03f, -2.46253964e-02f,
  -8.87081400e-02f, 1.05804890e-01f, -9.61563643e-03f, 5.02647310e-02f, 2.25037001e-02f, 6.41199388e-03f, 4.64322083e-02f, -8.94385502e-02f, 4.36532870e-02f, 6.04732744e-02f,
  -6.94259331e-02f, 1.78935558e-01f, -2.00107694e-02f, -9.29301530e-02f, 4.20359895e-02f, 9.42994878e-02f, -6.62444755e-02f, -2.38640141e-02f, -9.76300891e-03f, 1.83002874e-02f,
  2.02892870e-02f, 2.17509165e-01f, -5.17695397e-02f, -1.21925334e-02f, -9.79816094e-02f, -5.51660992e-02f, 3.21116261e-02f, -1.04078380e-02f, -8.36054087e-02f, 1.22510090e-01f,
  -1.67300835e-01f, 3.05631340e-01f, 3.87715222e-03f, 7.17488229e-02f, -1.23342507e-01f, -9.25215334e-02f, 3.20272346e-04f, 2.52573732e-02f, 6.18048571e-02f, 1.34075403e-01f,
  1.14634864e-01f, -4.32513468e-02f, -1.38397604e-01f, 7.79269561e-02f, 1.32677972e-01f, 2.91154552e-02f, -1.57037094e-01f, -4.50301617e-02f, 7.13129193e-02f, -1.98645011e-01f,
  6.64610863e-02f, 8.45807046e-02f, -1.53263941e-01f, -1.11898877e-01f, -1.15723507e-02f, 3.52847911e-02f, 1.02050975e-02f, 8.50808993e-02f, 2.44870782e-02f, 8.23500473e-03f,
  6.15047431e-03f, 1.11527018e-01f, 8.78034309e-02f, 8.07854459e-02f, 4.71540913e-02f, -7.39600658e-02f, 6.08754903e-02f, 2.64001116e-02f, -1.96427703e-01f, -1.17017686e-01f,
  3.59169655e-02f, -3.61213610e-02f, 9.94562823e-03f, 5.86989783e-02f, -9.36468393e-02f, 4.62657623e-02f, -1.79679453e-01f, 7.77787762e-03f, 9.84076113e-02f, -1.74736232e-01f,
  5.53329960e-02f, -1.33289059e-03f, -1.29795983e-01f, -5.84594789e-04f, 4.90874163e-06f, -6.09789602e-02f, 1.80311128e-01f, 6.03452586e-02f, 5.25082871e-02f, 1.99546684e-02f,
  -1.69453725e-01f, 4.47750837e-02f, 1.90210313e-01f, -5.46587966e-02f, 8.84475000e-03f, 2.47025909e-03f, -2.26329237e-01f, 1.13015071e-01f, -4.47702594e-02f, 1.18648708e-01f,
  4.31224070e-02f, -1.28491610e-01f, 1.42421097e-01f, -1.23270892e-01f, 8.89586508e-02f, 1.58666641e-01f, 9.81988832e-02f, 9.90868313e-04f, 1.03668362e-01f, 3.81669588e-02f,
  1.38522640e-01f, -2.83156522e-02f, -5.23907766e-02f, 3.41344997e-03f, 1.87074006e-01f, 3.07377353e-02f, 4.99034999e-03f, -3.10669299e-02f, 5.02161309e-02f, -5.76976910e-02f,
  1.52036350e-03f, -4.45522070e-02f, 3.69421914e-02f, 3.16681042e-02f, 6.47664815e-02f, -1.00386646e-02f, 7.61486497e-03f, 6.40746728e-02f, 8.09636265e-02f, 5.27669564e-02f,
  4.75935973e-02f, -3.98939662e-02f, -8.75212103e-02f, -2.75135413e-02f, 6.69977590e-02f, -9.46072489e-02f, -1.41976044e-01f, 4.75731231e-02f, 1.26331121e-01f, 1.26261562e-01f,
  -7.13833421e-02f, 7.22211152e-02f, -3.66679800e-04f, 8.87371600e-02f, -5.16474359e-02f, 1.98116023e-02f, -1.55054078e-01f, 1.87925640e-02f, -7.33112991e-02f, 6.50573298e-02f,
  1.42392188e-01f, 1.91124959e-03f, 2.05880105e-01f, -1.78143695e-01f, 1.52198300e-01f, 1.12040073e-01f, 1.44733265e-02f, 1.86648726e-01f, -3.99445370e-02f, -1.62403539e-01f,
  4.32435274e-02f, 1.03291243e-01f, -7.42238164e-02f, 1.13579750e-01f, -1.62156916e-03f, 3.10554933e-02f, 1.23183198e-01f, -1.75681308e-01f, -9.95310955e-03f, -3.93611938e-02f,
  -1.05117373e-01f, 7.44648576e-02f, 1.33181782e-02f, -2.14028686e-01f, 2.10911766e-01f, 1.17576933e-02f, 1.68858424e-01f, -2.99938302e-02f, 1.43977970e-01f, 1.83278888e-01f,
  -5.35904728e-02f, -1.09786436e-01f, -1.85868040e-01f, -2.23225094e-02f, 4.03005444e-03f, -1.12123601e-01f, -5.54849282e-02f, 4.70045209e-02f, -7.91360959e-02f, 7.21638650e-02f,
  -5.34121878e-02f, -2.11557876e-02f, -2.55432650e-02f, 7.85840023e-03f, -6.81826398e-02f, -9.92930755e-02f, -1.04632787e-01f, -8.96610469e-02f, 4.86014262e-02f, -3.02201975e-02f,
  3.46789844e-02f, -2.59416774e-02f, 5.59660085e-02f, -8.23658034e-02f, 1.87315885e-02f, -1.15627116e-02f, -1.00866314e-02f, -5.87966517e-02f, -2.85470709e-02f, -8.35805684e-02f,
  -8.01093057e-02f, -7.78213367e-02f, -8.40605423e-02f, -1.29017189e-01f, 1.04681492e-01f, 1.51001096e-01f, 1.12325691e-01f, 1.14713768e-02f, 8.40558857e-02f, -1.48574695e-01f,
  1.29973561e-01f, -3.27118188e-02f, 7.44369030e-02f, -2.18289152e-01f, -5.04636168e-02f, -1.09931566e-01f, -2.43209414e-02f, 7.47692734e-02f, 4.00976948e-02f, -5.37906326e-02f,
  3.86168249e-03f, -2.26419732e-01f, 6.31875694e-02f, -5.05920127e-02f, 1.12100922e-01f, 6.31220490e-02f, -1.29428029e-01f, 5.51821068e-02f, 1.17397442e-01f, -9.76003855e-02f,
  9.65758190e-02f, 9.26036946e-03f, 1.33083329e-01f, -3.18896323e-02f, 9.58425403e-02f, 4.56633829e-02f, 1.54216895e-02f, 5.60261048e-02f, 8.43878649e-03f, 4.59426381e-02f,
  1.18442737e-02f, 3.54411900e-02f, -7.96303824e-02f, -1.19781144e-01f, -7.68441930e-02f, 1.50704458e-01f, -2.55860277e-02f, 8.34361538e-02f, -6.54035956e-02f, -1.03598490e-01f,
  -3.99287194e-02f, 7.13635832e-02f, 9.57571194e-02f, 2.04120070e-01f, -9.13512558e-02f, -2.04697967e-01f, 9.33097769e-03f, -2.13656351e-01f, 2.24287242e-01f, 5.81077188e-02f,
  -1.69968277e-01f, 5.45887500e-02f, -1.67646170e-01f, 9.42751318e-02f, 2.12186322e-01f, 1.84069514e-01f, 5.46805300e-02f, -3.01255099e-02f, -1.01868436e-01f, -9.07446519e-02f,
  -6.22189678e-02f, 8.98247808e-02f, 2.10351557e-01f, 1.59661882e-02f, 2.45443247e-02f, -1.39535114e-01f, -1.16541786e-02f, 2.23654211e-02f, 6.88186660e-02f, -1.21764250e-01f,
  1.28539905e-01f, -1.24875724e-01f, 1.01416573e-01f, 9.52833965e-02f, -1.84556425e-01f, 1.36483796e-02f, -1.48351416e-01f, -7.26175532e-02f, 1.11731276e-01f, -8.09589550e-02f,
  -6.61511123e-02f, -1.48128495e-01f, -1.61987156e-01f, 2.67026499e-02f, 8.60316977e-02f, 1.09373227e-01f, -1.57774821e-01f, -9.48297977e-02f, -1.68816112e-02f, -1.00145675e-01f,
  -5.58097400e-02f, -8.06144327e-02f, -6.59341365e-02f, 3.06027457e-02f, -9.57934372e-03f, -7.75245130e-02f, -2.89499369e-02f, -7.31551051e-02f, -6.41771406e-02f, -1.55583739e-01f,
  5.12706414e-02f, -1.99286431e-01f, -1.26588931e-02f, -1.56592235e-01f, -9.17567238e-02f, -1.72926724e-01f, 4.32092920e-02f, -1.33086577e-01f, -6.56800866e-02f, -1.13168351e-01f,
  -7.69513547e-02f, -9.30965170e-02f, 5.87523319e-02f, 2.97722570e-03f, -1.66887464e-03f, -2.60709766e-02f, -1.50171006e-02f, 1.61141679e-01f, 3.29075605e-02f, 5.56616746e-02f,
  -5.90323061e-02f, 1.08497150e-01f, -9.72736031e-02f, 1.17227718e-01f, 1.36245847e-01f, 1.35997429e-01f, 9.21922699e-02f, 1.20289743e-01f, -2.24624932e-01f, -2.03847103e-02f,
  -1.57959118e-01f, 8.61604977e-03f, -1.04349002e-01f, -2.30390698e-01f, 6.82260469e-02f, 6.17146045e-02f, -8.53580311e-02f, -6.59404248e-02f, 3.59026790e-02f, -1.41595811e-01f,
  -1.37383923e-01f, 1.13141812e-01f, 3.75277288e-02f, 1.09518118e-01f, -1.62662432e-01f, 6.16679015e-03f, 8.01693369e-03f, 6.04905225e-02f, 2.32123345e-01f, 1.74468502e-01f,
  8.46243203e-02f, -1.21931113e-01f, -1.56520009e-02f, -7.66962813e-03f, 5.50770797e-02f, 3.38405222e-02f, 3.68626118e-02f, 1.07625701e-01f, 1.15394995e-01f, 7.97213614e-02f,
  4.32110652e-02f, -3.20175886e-02f, 1.09153047e-01f, 1.80059648e-03f, 1.12609617e-01f, 1.36372343e-01f, 1.38667122e-01f, 1.28283827e-02f, 4.19187453e-03f, -8.62602070e-02f,
  4.18738388e-02f, -1.45156771e-01f, 1.84034444e-02f, 6.03958219e-02f, -1.99808776e-01f, -1.05746835e-01f, 6.36139140e-02f, -9.78537127e-02f, -1.60608307e-01f, -1.35899767e-01f,
  -4.26953696e-02f, 1.34004280e-01f, 2.44204849e-01f, 1.56374499e-01f, -1.91004038e-01f, -5.21989129e-02f, 2.94933487e-02f, 7.36384317e-02f, 1.38262719e-01f, 3.65117863e-02f,
  -2.69051529e-02f, 2.14158684e-01f, 5.83682470e-02f, -3.62848565e-02f, -7.15320557e-02f, 1.79110259e-01f, -1.45976886e-01f, -1.10763624e-01f, 1.22592561e-01f, 9.06997174e-02f,
  7.74876103e-02f, 1.05222158e-01f, 9.10584703e-02f, -5.60629368e-02f, -7.88083896e-02f, 2.28628859e-01f, 3.19526307e-02f, -2.16631535e-02f, 7.98110757e-03f, 6.87434990e-03f,
  -6.58171484e-03f, 2.15597898e-01f, 1.60599738e-01f, 1.81242704e-01f, 2.25944430e-01f, 4.42378558e-02f, -2.68803705e-02f, -6.67940304e-02f, -1.11053117e-01f, -5.13725495e-03f,
  -5.74612468e-02f, 2.82485434e-03f, -8.70691985e-02f, -1.49083763e-01f, 1.57602262e-02f, -1.06093764e-01f, 2.89047770e-02f, -3.38049792e-02f, -8.07324722e-02f, -4.48932275e-02f,
  -3.24341170e-02f, -2.14240178e-02f, -1.28981367e-01f, -2.57234611e-02f, -4.92132120e-02f, 7.04925358e-02f, 1.62755907e-01f, 2.07359344e-02f, -7.86033124e-02f, 4.22170572e-02f,
  1.85776129e-01f, -1.72259033e-01f, -3.54854693e-03f, 3.49468179e-02f, -8.75861496e-02f, -1.59437925e-01f, 1.01383077e-02f, -6.58983961e-02f, -1.93011537e-01f, -2.57379208e-02f,
  -6.69355839e-02f, 1.73569664e-01f, 1.75983384e-02f, 9.80120748e-02f, 5.59878349e-02f, -1.78892061e-01f, -1.55834869e-01f, 3.01373377e-02f, -5.89145720e-02f, -8.54872540e-02f,
  -1.29272733e-02f, -6.53802603e-02f, 1.47832140e-01f, -1.60716418e-02f, -4.53011505e-02f, -1.55936033e-01f, 1.40359193e-01f, -5.34732305e-02f, 1.45412177e-01f, -1.51788756e-01f,
  1.18592754e-01f, 1.19410649e-01f, -1.79623514e-01f, 2.21459225e-01f, -2.10371390e-02f, -1.38432264e-01f, 4.05550003e-02f, -1.28124133e-01f, 9.70550328e-02f, -1.69741318e-01f,
  -1.97885744e-02f, -3.25138718e-02f, 1.59266144e-01f, -1.38823930e-02f, 1.18508749e-02f, -1.40330181e-01f, -5.26178628e-02f, 3.72716971e-02f, 8.94436706e-03f, -4.75817472e-02f,
  -5.92656853e-03f, -1.08817503e-01f, -8.08329806e-02f, 6.96874633e-02f, 1.12596005e-01f, -1.62421223e-02f, -1.68575160e-02f, -1.68358460e-01f, 4.95463349e-02f, -1.31998301e-01f,
  -7.21355081e-02f, 8.62716261e-05f, 2.33096890e-02f, 2.79952027e-02f, -7.05759227e-02f, 2.30365638e-02f, 7.28011355e-02f, 6.28378391e-02f, 2.36551594e-02f, 2.84579359e-02f,
  1.70413721e-02f, -3.93857621e-02f, 1.50810227e-01f, 3.60249467e-02f, 5.12383319e-02f, -1.40828580e-01f, -2.15624999e-02f, 2.74338014e-02f, -7.71853998e-02f, 7.33271241e-02f,
  -1.58028439e-01f, -5.36597893e-02f, -6.14875630e-02f, 1.94196969e-01f, -1.56823769e-01f, 4.83865961e-02f, -1.68071002e-01f, 7.94820115e-02f, 8.04916397e-03f, -1.48616079e-02f,
  -1.79001704e-01f, 1.28051341e-01f, -6.30547181e-02f, 1.25662331e-02f, -1.17501274e-01f, -1.00899376e-02f, 6.64635599e-02f, 5.76226525e-02f, 2.34652497e-02f, -6.35711402e-02f,
  -1.06211808e-02f, -4.55264486e-02f, -5.15155084e-02f, 1.95227101e-01f, -1.66188106e-02f, 1.71898380e-02f, 6.08828217e-02f, -2.13260073e-02f, -4.06385250e-02f, -1.93089366e-01f,
  -2.06797272e-02f, -6.62707686e-02f, 1.14719011e-02f, 6.59200773e-02f, -5.70670143e-03f, 6.07592333e-03f, -5.25839478e-02f, -1.09187074e-01f, -2.95693465e-02f, -6.35609701e-02f,
  -5.73878139e-02f, -9.24957097e-02f, -2.83163358e-02f, -8.91019478e-02f, -9.82282236e-02f, -1.31402001e-01f, -8.62818137e-02f, -2.19751783e-02f, -1.30041167e-01f, 6.61879107e-02f,
  -7.94676393e-02f, -3.67523655e-02f, -3.57396305e-02f, 2.49110553e-02f, -1.12533100e-01f, 4.28717490e-03f, -1.92077868e-02f, 9.95657519e-02f, 1.34380504e-01f, -1.63402230e-01f,
  1.92932665e-01f, -3.47646587e-02f, -2.26808786e-01f, 3.19953891e-03f, -1.39350921e-01f, -3.13090626e-03f, -4.83341888e-03f, -4.35212106e-02f, -7.00072795e-02f, 5.12216836e-02f,
  8.12254176e-02f, 1.96165383e-01f, 1.45377412e-01f, -1.18618026e-01f, -1.68471679e-01f, -1.66482702e-01f, -2.23892242e-01f, -8.28893185e-02f, -1.14881895e-01f, -1.19141079e-01f,
  -3.66770965e-03f, 1.47098815e-03f, 2.22049743e-01f, 5.78761399e-02f, -6.55994937e-02f, 8.22218880e-03f, -8.00366029e-02f, 1.42189920e-01f, -1.13357939e-01f, -4.75941300e-02f,
  -1.18674286e-01f, 1.85816083e-02f, -6.45645559e-02f, 6.50563017e-02f, -3.63142379e-02f, 7.07553746e-03f, 2.87581384e-02f, -1.59226581e-02f, 4.06173281e-02f, -3.64913698e-03f,
  -6.16369769e-02f, -9.17337984e-02f, -5.99162430e-02f, 1.84791330e-02f, -7.20651075e-02f, 1.00302380e-02f, -8.31386745e-02f, -5.02254888e-02f, -1.48546211e-02f, 2.00063866e-02f,
  -6.97987527e-02f, 1.00779608e-01f, 2.42852536e-03f, -3.76576073e-02f, -1.30247563e-01f, 3.08337230e-02f, -1.49686232e-01f, -3.09075732e-02f, -6.05197996e-02f, -7.26114735e-02f,
  -1.85548618e-01f, 1.18140422e-01f, 3.45553011e-02f, 6.08298331e-02f, 1.53383344e-01f, 6.33651391e-03f, 8.91028345e-02f, -4.80786674e-02f, 1.05436563e-01f, 1.76902071e-01f,
  -6.72309250e-02f, 2.28938889e-02f, 1.24177143e-01f, -3.84806506e-02f, 6.73682243e-03f, 4.86872755e-02f, 7.15236664e-02f, -9.65802819e-02f, 8.96354243e-02f, -1.66869819e-01f,
  1.76829129e-01f, -8.60890895e-02f, -1.61658395e-02f, -2.73753237e-03f, -1.49585661e-02f, 5.67496791e-02f, 1.05910487e-01f, -9.63222533e-02f, 1.63502842e-01f, 3.43185365e-02f,
  5.59186153e-02f, -1.27751753e-01f, 4.06504571e-02f, 5.71467765e-02f, 1.02910317e-01f, -1.80963650e-02f, 1.12181410e-01f, 3.12594660e-02f, -1.55035742e-02f, 1.37296021e-01f,
  3.32423747e-02f, -1.92916282e-02f, -3.68205272e-02f, -4.74951789e-02f, -2.71692476e-03f, 4.10690866e-02f, -4.40212563e-02f, 3.35962400e-02f, 1.41570047e-01f, 1.29065886e-01f,
  -2.60736663e-02f, 2.77563855e-02f, 1.33837447e-01f, 1.81253746e-01f, 4.60949019e-02f, 8.34230632e-02f, 3.95866595e-02f, 2.40636803e-02f, 1.60836995e-01f, -4.13752310e-02f,
  2.09673822e-01f, 2.45258287e-02f, 1.62448436e-01f, -5.12200110e-02f, 6.42338842e-02f, -1.52549863e-01f, -9.89771485e-02f, 2.92916335e-02f, -2.18213111e-01f, 1.59098394e-02f,
  -8.44808519e-02f, -5.70021570e-02f, 6.00507036e-02f, -4.71365266e-03f, 1.71818584e-01f, 4.92022820e-02f, 3.81884575e-02f, -9.11735222e-02f, -5.35165183e-02f, 2.33314019e-02f,
  -2.28570864e-01f, 1.43634841e-01f, 2.17014477e-02f, 2.46339425e-01f, 3.26677039e-02f, 1.00434367e-02f, 3.48650105e-02f, -7.17233494e-02f, 6.24282174e-02f, -3.25293280e-02f,
  -6.51134476e-02f, -9.80514586e-02f, -2.75782257e-01f, -1.41074017e-01f, -1.58852667e-01f, -8.37731212e-02f, 4.99394871e-02f, 1.25839204e-01f, 4.33006100e-02f, 3.60678285e-02f,
  1.11805201e-02f, 6.65274113e-02f, 9.25428420e-02f, 1.19272321e-01f, -3.01236985e-03f, 2.17915233e-02f, 4.31587622e-02f, 4.51604165e-02f, 9.81511474e-02f, 2.66816486e-02f,
  1.08828001e-01f, 1.45599976e-01f, 2.95812283e-02f, 1.08614706e-01f, 1.75820962e-02f, 9.79972109e-02f, 4.84335832e-02f, 1.24771520e-01f, 1.09096467e-01f, 5.50458394e-03f,
  -5.03245853e-02f, -6.54914752e-02f, 7.06962571e-02f, -8.28686729e-02f, 1.68944877e-02f, 1.66430369e-01f, -3.79748158e-02f, 1.85361683e-01f, 1.33948356e-01f, -3.88551317e-02f,
  -4.39163297e-02f, -8.55080634e-02f, -6.00958243e-02f, -1.77981108e-01f, -4.82092053e-03f, 7.66924843e-02f, 1.99097693e-01f, 1.24175809e-01f, 7.14449435e-02f, 2.45945137e-02f,
  -4.13076207e-02f, 1.75178349e-01f, -8.44388232e-02f, -1.74728185e-01f, -4.38422151e-02f, 1.00778349e-01f, 2.54446883e-02f, 5.25739901e-02f, -5.77840693e-02f, 8.51205513e-02f,
  2.79507786e-03f, -4.98497225e-02f, 1.69763401e-01f, -2.33996391e-01f, -1.48237795e-01f, 2.24267002e-02f, -1.07013933e-01f, 1.41217839e-02f, -1.19177125e-01f, 7.44319260e-02f,
  -2.19197385e-02f, -1.10231467e-01f, 2.78132297e-02f, -4.07227427e-02f, -8.91604125e-02f, 3.62176560e-02f, -6.38353974e-02f, 3.72630544e-02f, 1.98510922e-02f, -3.21044028e-02f,
  -1.97668690e-02f, 5.20686172e-02f, -1.55837551e-01f, 1.43852979e-01f, 4.19043191e-02f, -1.00680916e-02f, -2.09458858e-01f, -6.95328712e-02f, -1.32571995e-01f, -1.06338123e-02f,
  7.03537390e-02f, 1.68898813e-02f, -2.80316263e-01f, 6.62579834e-02f, 1.65819097e-02f, -8.23318437e-02f, 4.52179834e-02f, -3.25653926e-02f, -1.21638998e-01f, -9.08183977e-02f,
  1.10579163e-01f, 5.38784601e-02f, -2.69495428e-01f, 9.31946337e-02f, -1.48909427e-02f, 7.32747838e-02f, 1.52889162e-01f, 9.21208132e-03f, 2.33076196e-02f, -1.02482244e-01f,
  -3.10659818e-02f, -1.38839677e-01f, -1.79726735e-01f, 2.69657522e-01f, -8.98093581e-02f, 1.31456003e-01f, 1.22245505e-01f, -6.37015030e-02f, 6.07605241e-02f, -5.53020090e-02f,
  3.57364081e-02f, -2.71145515e-02f, 1.33559555e-01f, 1.80439018e-02f, 9.14996341e-02f, 6.44462034e-02f, -5.67263663e-02f, 1.70998946e-01f, -3.21178176e-02f, 6.13908954e-02f,
  1.67211145e-01f, -8.62964243e-02f, 7.07793757e-02f, -5.38074449e-02f, 1.32112414e-01f, 7.59053081e-02f, -1.52795929e-02f, -4.40512262e-02f, 5.27804196e-02f, 5.78542985e-02f,
  -2.27923461e-04f, -1.97977945e-02f, -2.65648644e-02f, 1.14604682e-01f, 7.77784139e-02f, 4.92545553e-02f, 5.11523224e-02f, 3.61376256e-02f, 1.73470955e-02f, 4.24344763e-02f,
  -3.25733423e-03f, 3.51609699e-02f, 7.57490098e-03f, 6.25881851e-02f, -6.29308149e-02f, -9.43056941e-02f, -1.56630695e-01f, -1.36433259e-01f, -4.53825220e-02f, 6.69508204e-02f,
  1.37086451e-01f, -1.72890916e-01f, 6.58122674e-02f, 7.74530619e-02f, -2.20999718e-02f, 1.46467417e-01f, 6.14599586e-02f, -2.27704510e-01f, 2.07030967e-01f, -4.89618629e-02f,
  3.06690764e-02f, 1.42957261e-02f, -1.24062240e-01f, 3.69288512e-02f, 4.34087925e-02f, -2.09196597e-01f, 2.15567023e-01f, 1.58320129e-01f, -2.25103974e-01f, 5.12862485e-03f,
  -5.85401654e-02f, 7.34450519e-02f, 1.25344083e-01f, -2.53409371e-02f, -1.55441180e-01f, 1.55901775e-01f, -1.35759473e-01f, 1.09045379e-01f, 3.83047424e-02f, -1.16500206e-01f,
  1.06120199e-01f, -3.46719325e-02f, 6.32354617e-02f, 8.87391716e-03f, -1.95210516e-01f, -6.73727924e-03f, -2.63624154e-02f, 1.10299021e-01f, -3.67507339e-02f, 1.27796251e-02f,
  -5.55546507e-02f, -4.53046663e-03f, 8.19476843e-02f, 1.53656164e-02f, 4.25740853e-02f, 4.15089801e-02f, 4.51976396e-02f, 1.25559390e-01f, -7.04197362e-02f, -5.22394329e-02f,
  6.35165796e-02f, 5.96756637e-02f, 2.34911516e-02f, 3.24812764e-03f, -7.69633129e-02f, 6.48211986e-02f, 1.36496201e-01f, -6.85002562e-03f, -6.32872954e-02f, -8.20192471e-02f,
  -2.30508484e-02f, -1.86654218e-02f, -1.77900374e-01f, 6.40611723e-02f, 2.04823777e-01f, -3.34468633e-02f, 1.29204884e-01f, 7.68129826e-02f, -6.38091424e-03f, 2.50886846e-02f,
  1.49258092e-01f, -1.07169487e-01f, 1.53662741e-01f, -1.48895040e-01f, -9.90527868e-02f, -1.07008433e-02f, -1.29209146e-01f, 3.23895589e-02f, 8.48919675e-02f, -1.54547468e-01f,
  2.06884012e-01f, 1.81803018e-01f, -1.24702312e-01f, 4.76266854e-02f, -3.99668626e-02f, 1.27897024e-01f, 1.39168277e-01f, -4.35616747e-02f, -1.71911642e-01f, 7.51148611e-02f,
  -1.34472102e-01f, 1.11290276e-01f, 1.03111312e-01f, -5.10550216e-02f, 1.68927625e-01f, -6.13984801e-02f, -5.45807779e-02f, -4.04904224e-02f, -1.66680068e-01f, 6.40543923e-02f,
  -1.95438303e-02f, 1.54381111e-01f, -7.58619010e-02f, -1.28483176e-01f, 1.84137911e-01f, -3.71367820e-02f, 7.58809075e-02f, 2.31695715e-02f, -3.91916074e-02f, -1.44988829e-02f,
  -4.01058160e-02f, -1.05446704e-01f, 1.71365105e-02f, -3.82457003e-02f, 1.54754788e-01f, -4.17716876e-02f, 4.05844375e-02f, 2.87960097e-02f, -2.41131373e-02f, -1.55865684e-01f,
  4.27779518e-02f, -1.84215814e-01f, -5.57489786e-03f, -1.51119698e-02f, 6.67433590e-02f, -6.64068311e-02f, -5.56910746e-02f, 7.68292099e-02f, 2.27638334e-02f, -1.75945550e-01f,
  2.26256400e-01f, 6.67645410e-02f, 1.68074980e-01f, -5.43276556e-02f, 2.92989407e-02f, -1.49305880e-01f, 4.29288521e-02f, 1.20196611e-01f, -1.35699632e-02f, 9.57694948e-02f,
  -1.47503614e-01f, 1.84599906e-01f, -1.41178936e-01f, 1.01858713e-02f, -8.39625075e-02f, 8.11239332e-02f, -2.01467395e-01f, -1.74498275e-01f, -1.81235686e-01f, 8.21365640e-02f,
  -2.03581080e-01f, 1.23602048e-01f, 1.69659153e-01f, 1.68091878e-02f, 2.49615917e-03f, 2.20233217e-01f, -9.36147198e-03f, -1.20750461e-02f, 3.24527128e-03f, -1.22155115e-01f,
  8.96130428e-02f, 4.73984666e-02f, -3.33793722e-02f, 4.12786789e-02f, 5.59294261e-02f, 3.20471115e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.78892690e-02f, 1.51880696e-01f, 5.00885881e-02f, -1.11794416e-02f, 1.10673428e-01f, -1.27800927e-01f, -5.87115400e-02f, 3.25628072e-02f, 4.08192575e-02f, 4.32123840e-02f,
  4.39985394e-02f, -2.43783481e-02f, 4.36292104e-02f, -1.23663209e-01f, 8.63640457e-02f, 4.64167399e-03f, 9.75411236e-02f, -5.23674414e-02f, 2.60530077e-02f, -3.48728001e-02f,
  -1.87400430e-01f, -6.06784597e-02f, 1.41588911e-01f, -9.04099122e-02f, 8.07708800e-02f, 2.24112898e-01f, -1.42223237e-03f, -1.14261694e-01f, 2.92341467e-02f, -6.07054085e-02f,
  -1.77440554e-01f, -4.18335237e-02f, -2.48691700e-02f, -1.55869991e-01f, 4.40598838e-02f, -1.20928451e-01f, 1.73489317e-01f, 4.56734858e-02f, -3.17230209e-04f, 2.11655274e-01f,
  -1.56946406e-01f, 9.31309611e-02f, 3.46906066e-01f, -3.09409022e-01f, 7.20072817e-03f, 1.26110539e-01f, 2.31302306e-01f, 2.10971713e-01f, 1.91623047e-01f, -1.42390147e-01f,
  -6.04530610e-02f, -2.02635616e-01f, -1.17354706e-01f, 9.08682197e-02f, 1.64282590e-01f, -7.15598986e-02f, 1.58962756e-02f, 1.16446644e-01f, 3.58418673e-01f, 1.12555176e-01f,
  1.54610604e-01f, 1.84807599e-01f, 3.09403110e-02f, 6.15486093e-02f, 7.21004531e-02f, 1.23757280e-01f, -2.85170954e-02f, 3.77284959e-02f, -5.21698482e-02f, 2.03737766e-02f,
  6.97820261e-02f, 1.10682301e-01f, -3.47668938e-02f, 1.06619470e-01f, 9.58319753e-02f, 1.08641088e-02f, 4.50234674e-02f, -7.38543049e-02f, -6.04732595e-02f, 3.80618237e-02f,
  2.19928756e-01f, -6.28719479e-02f, 8.81288871e-02f, -8.48189741e-02f, -6.72971606e-02f, 6.96338899e-03f, 2.17314571e-01f, 1.25226483e-01f, -1.16898105e-01f, 5.19536138e-02f,
  -1.16423592e-01f, 3.13004732e-01f, -6.09203316e-02f, -1.85589999e-01f, -1.29267573e-01f, -2.71026820e-01f, 1.97104797e-01f, 2.44045764e-01f, -1.93577651e-02f, -1.03016928e-01f,
  -6.55348599e-02f, -8.95451531e-02f, 1.95269227e-01f, 6.95248097e-02f, -3.45413648e-02f, 2.54113019e-01f, 2.24981783e-03f, -4.10964847e-01f, 3.94377321e-01f, 7.89090395e-02f,
  3.16925198e-02f, 5.89982001e-03f, 6.41455650e-02f, -9.48277339e-02f, 3.27074602e-02f, -5.53710992e-03f, 1.05845176e-01f, -7.15896264e-02f, 1.77865755e-03f, 1.75479814e-01f,
  4.52979840e-02f, 1.32643143e-02f, 3.29267621e-01f, -2.22965315e-01f, 2.44469926e-01f, 1.87022742e-02f, -2.07880829e-02f, 1.62739456e-01f, 3.82588282e-02f, 1.06376015e-01f,
  1.17007352e-01f, 1.09033957e-01f, 1.07928865e-01f, 7.94228762e-02f, 1.60971731e-01f, 5.82723990e-02f, 1.51806027e-01f, -4.34165858e-02f, 2.26078946e-02f, 5.72791584e-02f,
  7.46184289e-02f, 1.01150073e-01f, 7.76649788e-02f, 1.22355856e-02f, 4.94019836e-02f, 9.37187986e-04f, 2.01446667e-01f, 5.75662255e-02f, 9.40366536e-02f, -1.00119315e-01f,
  2.79016867e-02f, -3.29184486e-03f, 2.20361754e-01f, 1.46280723e-02f, -2.62832224e-01f, -1.08941890e-01f, -4.86356765e-02f, 2.52433807e-01f, 2.18088686e-01f, 2.58903384e-01f,
  3.42741348e-02f, 1.08196631e-01f, -2.36843944e-01f, -1.68127716e-01f, 7.05382414e-03f, 7.52761886e-02f, -1.40962237e-02f, 3.39580178e-01f, 2.61109881e-02f, 1.53304532e-01f,
  -1.92202628e-01f, 6.71473816e-02f, 9.13158506e-02f, -9.20287371e-02f, 6.85647354e-02f, -7.82959238e-02f, -2.00047381e-02f, 2.68243283e-01f, 1.32990927e-01f, 1.31595612e-01f,
  -1.42551005e-01f, 1.16376050e-01f, 1.53665945e-01f, 7.59619474e-02f, 3.36080849e-01f, -2.62508333e-01f, -1.51819915e-01f, 3.89681518e-01f, 1.63220420e-01f, 3.28664303e-01f,
  -3.81942019e-02f, -7.62428567e-02f, 7.68738538e-02f, -1.75888091e-01f, 6.83972538e-02f, 1.62434071e-01f, 1.55089512e-01f, -1.86951552e-02f, 1.40477419e-01f, 3.52419801e-02f,
  3.58943380e-02f, -6.19367175e-02f, 7.49431923e-02f, 1.21097535e-01f, 4.64976691e-02f, 1.57954901e-01f, 1.76182855e-02f, -3.49909673e-03f, -1.12372540e-01f, 2.50801519e-02f,
  4.35542390e-02f, -1.16424553e-01f, 5.54082841e-02f, -1.20550990e-01f, -1.23997599e-01f, -1.80580854e-01f, -9.46142152e-02f, 5.50601035e-02f, 4.96645197e-02f, -2.46472642e-01f,
  1.54765159e-01f, 1.24081418e-01f, 2.56110579e-01f, 1.22199215e-01f, -1.57249749e-01f, -5.99444062e-02f, 5.19321822e-02f, 9.69052985e-02f, 5.19731268e-02f, 1.84101090e-01f,
  -2.15647787e-01f, 1.83776051e-01f, 1.06970504e-01f, -1.70439795e-01f, 1.36876553e-01f, 3.99994284e-01f, -3.53431463e-01f, -1.93394944e-02f, -1.03403181e-01f, 3.12797427e-01f,
  -1.74690802e-02f, 1.86175436e-01f, 2.46601626e-02f, 2.07206815e-01f, 6.12024032e-02f, 3.03132743e-01f, 1.15677230e-01f, 8.10362324e-02f, 1.63881674e-01f, 1.73227802e-01f,
  4.72683124e-02f, 2.38064423e-01f, 1.22888666e-02f, 1.63389236e-01f, 2.62832046e-01f, 9.92061123e-02f, 2.55905949e-02f, 1.32395491e-01f, -5.63573278e-02f, 5.04979910e-03f,
  1.30130172e-01f, 2.58445770e-01f, 8.73825327e-02f, 4.16774722e-03f, -3.23675424e-02f, 8.95152017e-02f, 3.84337083e-02f, 5.06593771e-02f, 6.47658929e-02f, 7.07875192e-02f,
  -6.46492988e-02f, 8.35373029e-02f, 1.34419575e-01f, 1.17637262e-01f, 6.64780065e-02f, 3.18597220e-02f, 1.30102009e-01f, 7.30290338e-02f, 1.12180524e-01f, 8.92879367e-02f,
  1.34592876e-01f, -7.37965340e-03f, 2.50966936e-01f, 6.42817095e-02f, 1.30917922e-01f, -2.29506418e-01f, -8.37602019e-02f, -3.00445378e-01f, 1.38768375e-01f, 2.38339379e-02f,
  9.57023539e-03f, 1.54190660e-01f, -2.21762657e-01f, 9.90830958e-02f, 2.53570348e-01f, -1.96260244e-01f, 3.37775983e-02f, 1.43081769e-01f, 3.22034001e-01f, -1.57936931e-01f,
  2.88025051e-01f, -1.35190398e-01f, 1.13876291e-01f, 1.85012385e-01f, -9.99630466e-02f, 7.24813491e-02f, 5.95040284e-02f, 3.51371884e-01f, 3.89645934e-01f, 3.87331285e-02f,
  1.72675475e-01f, 3.03822726e-01f, -1.61607638e-01f, 3.77032638e-01f, 9.23273414e-02f, -2.55549371e-01f, 6.15925528e-02f, -7.56395459e-02f, 2.16580302e-01f, -1.59668475e-01f,
  -6.31932616e-02f, -2.77692992e-02f, 1.43624349e-02f, 9.07104760e-02f, 9.02334005e-02f, 2.35391315e-02f, 7.35154077e-02f, -3.20916325e-02f, 4.48558293e-02f, -8.23509768e-02f,
  2.28641089e-02f, 5.66918291e-02f, 9.81527567e-02f, 2.64897104e-02f, 2.72813011e-02f, -5.79684004e-02f, 1.68050814e-03f, -1.87618867e-01f, 6.31782562e-02f, -4.37425449e-02f,
  5.27269719e-03f, -1.98144332e-01f, -1.05638597e-02f, -1.18026555e-01f, 1.81345373e-01f, 1.21176690e-01f, -2.98617989e-01f, -1.49594113e-01f, -8.24969709e-02f, 1.18702427e-01f,
  2.43582293e-01f, 5.37659824e-02f, -2.09309444e-01f, 7.06930831e-03f, -1.65675744e-01f, 5.19301705e-02f, 2.68126130e-01f, 1.18240334e-01f, -5.99000938e-02f, 2.76807338e-01f,
  -7.66079277e-02f, -5.16601503e-02f, -6.34398237e-02f, 1.22751463e-02f, -1.43275514e-01f, -1.41070694e-01f, 2.90022671e-01f, 8.01722705e-02f, -7.91818649e-03f, 1.08649157e-01f,
  2.50801686e-02f, -2.07775757e-01f, -7.99052417e-02f, 2.01942191e-01f, 2.54800379e-01f, 3.87045555e-02f, 1.43263817e-01f, -1.40256165e-02f, 1.84351698e-01f, 4.61229116e-01f,
  2.44225457e-01f, 4.15298969e-01f, -3.15411687e-02f, -9.28324610e-02f, 1.54196694e-01f, 9.45360437e-02f, 7.08469003e-02f, 6.17644144e-03f, 2.81452667e-02f, 1.69714063e-01f,
  6.12124950e-02f, -4.11623381e-02f, 1.26218498e-01f, -8.45140517e-02f, 3.72375473e-02f, 7.70211741e-02f, -3.06588151e-02f, 4.65323143e-02f, 1.18284389e-01f, 8.12683925e-02f,
  2.36569345e-01f, 9.39500183e-02f, -3.44353318e-02f, -2.95489952e-02f, 1.80203944e-01f, -6.36158464e-03f, -6.18476234e-02f, 6.10639155e-02f, 1.47842675e-01f, 8.88254419e-02f,
  1.04120627e-01f, 1.16073340e-02f, 4.03965376e-02f, -9.46166292e-02f, 1.22765213e-01f, -1.89364068e-02f, -1.11946985e-02f, 9.17107686e-02f, -1.04959883e-01f, -8.54576845e-03f,
  -6.25925735e-02f, 1.64607942e-01f, 2.53321175e-02f, 1.18473031e-01f, -2.32268780e-01f, -3.74261849e-02f, -9.64361951e-02f, 2.87791431e-01f, 1.35915846e-01f, -7.11654648e-02f,
  2.28865728e-01f, 9.71759558e-02f, -7.73297548e-02f, 9.95741338e-02f, -1.09866764e-02f, 3.82398665e-01f, -1.11341719e-02f, 1.94720075e-01f, 4.21263091e-02f, 2.84264505e-01f,
  -1.73328072e-02f, 3.56629550e-01f, -8.43904912e-02f, 6.54201061e-02f, -1.21106006e-01f, 1.32021934e-01f, 9.47480462e-03f, -4.54986142e-03f, 1.30391464e-01f, 1.14882246e-01f,
  6.82227314e-02f, -4.24747821e-03f, 3.92922536e-02f, -2.96436064e-02f, -9.78437811e-02f, 1.23908408e-01f, 6.67358786e-02f, 2.65819252e-01f, 1.25995860e-01f, -8.64946693e-02f,
  1.77263275e-01f, -1.86044216e-01f, 6.22976534e-02f, -4.02080826e-02f, 1.60642222e-01f, 3.12032010e-02f, -8.28590419e-04f, 9.79175139e-03f, -1.33489951e-01f, -2.83380933e-02f,
  1.67326048e-01f, 2.32088212e-02f, -1.22124828e-01f, 6.02203645e-02f, 3.68556827e-02f, 4.52790000e-02f, 8.78260434e-02f, 2.03623604e-02f, -2.86384940e-01f, -1.83939934e-02f,
  2.73145139e-01f, -1.52074784e-01f, 1.14587121e-01f, -1.98297963e-01f, 2.41645221e-02f, -1.78505063e-01f, -4.98179011e-02f, 2.38475263e-01f, 2.21026212e-01f, 1.33455306e-01f,
  4.33467120e-01f, -2.78349489e-01f, 2.46019452e-03f, 2.18587413e-01f, -1.22988522e-01f, 1.67544693e-01f, 1.50904670e-01f, -8.64242315e-02f, -6.02898449e-02f, 1.12608597e-01f,
  -5.87226152e-02f, 1.25442386e-01f, 2.58071087e-02f, -1.51982203e-01f, -1.50955180e-02f, -1.05581321e-02f, 2.95741439e-01f, -1.31431282e-01f, -2.07607001e-01f, 1.20223373e-01f,
  -8.55408236e-02f, 3.20761532e-01f, 1.04123298e-02f, -9.48636457e-02f, -7.11919293e-02f, 5.64588308e-02f, 1.19917154e-01f, -1.05974056e-01f, -1.83634534e-02f, 7.16259927e-02f,
  -1.81670152e-02f, 5.62848570e-03f, -1.36019990e-01f, 7.67080858e-02f, -1.23046665e-02f, 5.70640601e-02f, 6.87054242e-04f, -1.04475409e-01f, -6.40259609e-02f, -1.05330661e-01f,
  1.95495281e-02f, -1.79912627e-01f, 7.45880604e-02f, -9.84559506e-02f, 5.91101497e-02f, -1.69556975e-01f, 1.36767104e-01f, 2.27523521e-02f, -2.79869717e-02f, -1.89799845e-01f,
  1.12774707e-01f, 2.94392947e-02f, 3.59803617e-01f, -3.15311216e-02f, -1.61060721e-01f, -2.00787112e-01f, -1.61431059e-01f, 2.75313705e-01f, -1.24179073e-01f, 1.35276929e-01f,
  7.06785098e-02f, 2.62932503e-03f, 3.97081897e-02f, -1.25680134e-01f, 2.06813421e-02f, 2.59223338e-02f, -2.49793530e-01f, -3.14339459e-01f, -7.32140020e-02f, 1.47170484e-01f,
  -2.86871612e-01f, 2.98660278e-01f, 9.12201777e-02f, 8.28486681e-02f, 3.99355665e-02f, 2.46322349e-01f, 1.93585992e-01f, 3.04957479e-01f, 6.35225908e-04f, 3.97070646e-02f,
  -1.33291528e-01f, 2.34587744e-01f, 1.21918082e-01f, 9.16174203e-02f, 1.95767507e-01f, -1.70323938e-01f, 4.19125929e-02f, -9.43955034e-02f, 1.84982300e-01f, 1.56298026e-01f,
  1.59852490e-01f, -1.03489019e-01f, 3.97206936e-03f, 1.03384145e-01f, -1.51767069e-02f, 1.65141329e-01f, 3.84397916e-02f, 2.11082026e-02f, 1.79223716e-01f, -1.54079214e-01f,
  3.25918272e-02f, -5.75052500e-02f, 2.06169374e-02f, -2.01816589e-01f, 2.40395769e-01f, -2.89136171e-01f, -1.24508031e-01f, -8.40448886e-02f, 2.26988927e-01f, -3.87673415e-02f,
  -1.73112154e-01f, 1.17381483e-01f, -1.61555275e-01f, -6.41995072e-02f, 1.30327031e-01f, 2.25382000e-01f, 1.45006403e-01f, 2.00263318e-02f, 3.38879228e-02f, -4.48385775e-02f,
  -5.11086453e-03f, 2.45315172e-02f, 1.31020814e-01f, -3.14633809e-02f, -8.47201943e-02f, 1.88064218e-01f, -8.34408849e-02f, 2.06576049e-01f, -2.41151880e-02f, -8.76992866e-02f,
  -1.41235143e-01f, -4.27484252e-02f, -2.62979984e-01f, 1.26246497e-01f, -9.05801728e-02f, 8.22153687e-02f, 1.00683458e-01f, -1.31015480e-02f, -1.59436449e-01f, 1.65338069e-01f,
  -1.15738548e-01f, -1.43205859e-02f, 5.07201403e-02f, -2.98185557e-01f, 2.35512242e-01f, 1.58595964e-01f, 1.41217411e-01f, 4.69087400e-02f, 1.49307281e-01f, 3.06930006e-01f,
  1.35218143e-01f, 6.95100054e-02f, 5.03783002e-02f, 8.09838846e-02f, 7.80845359e-02f, 2.50215679e-02f, 7.42620602e-02f, 1.20233130e-02f, 3.25701348e-02f, -2.90520350e-03f,
  3.12710889e-02f, 5.13338819e-02f, 2.74835676e-02f, 1.26925036e-01f, 7.41559193e-02f, 3.25375982e-02f, 1.45930063e-03f, 6.26068339e-02f, 1.50676921e-01f, 1.65833995e-01f,
  -1.23368047e-01f, -1.46382824e-01f, -6.17580190e-02f, -2.29182318e-01f, 6.00673929e-02f, -1.30194873e-02f, -7.95423891e-03f, -1.03488289e-01f, 1.56312883e-02f, 1.77703589e-01f,
  1.48627505e-01f, 3.16785336e-01f, 1.04016669e-01f, -8.31622034e-02f, 2.66901013e-02f, -2.09775835e-01f, -3.79494652e-02f, 4.32513170e-02f, -1.53149143e-01f, 2.57121205e-01f,
  9.88966078e-02f, -3.26501429e-01f, 1.92396622e-02f, 3.32667589e-01f, -1.81461751e-01f, 1.04675099e-01f, 1.14196219e-01f, 1.42831787e-01f, 1.47543371e-01f, 1.58408314e-01f,
  -1.95904493e-01f, 7.66666830e-02f, -3.69951785e-01f, 1.29804209e-01f, 2.31631607e-01f, -1.66445643e-01f, 3.56142133e-01f, -2.14173883e-01f, 2.07128506e-02f, 3.26709777e-01f,
  1.68334376e-02f, 2.94621438e-01f, -2.12288290e-01f, 1.23170525e-01f, 2.05948517e-01f, 1.70060337e-01f, 1.12371154e-01f, 1.19262941e-01f, 5.57630695e-02f, 2.15652406e-01f,
  1.38538212e-01f, -7.42032379e-02f, 4.43767682e-02f, 1.74571071e-02f, 1.27490357e-01f, 6.87708035e-02f, 9.72630456e-02f, 1.37700155e-01f, 1.32920995e-01f, 2.80766487e-01f,
  1.84472412e-01f, 2.63267457e-01f, 9.86922532e-02f, 2.67753482e-01f, 8.93534422e-02f, 6.97560161e-02f, -8.29979479e-02f, -1.95437316e-02f, 1.07809693e-01f, -5.16483188e-02f,
  2.32234538e-01f, -1.36101589e-01f, 3.04957032e-02f, 2.75849514e-02f, 1.51026975e-02f, 1.41100273e-01f, 3.48926723e-01f, -5.94360977e-02f, -4.10927534e-02f, -2.32879788e-01f,
  -3.10855865e-01f, -6.93918392e-02f, -1.28400072e-01f, 1.92658812e-01f, 2.63728887e-01f, -1.15782849e-01f, 3.42370331e-01f, 3.60287756e-01f, 1.04541004e-01f, 2.13500127e-01f,
  5.78594021e-02f, -1.96052149e-01f, 7.74157047e-02f, 2.81806111e-01f, -3.00361980e-02f, 5.04112244e-01f, 3.42867002e-02f, -2.25815121e-02f, 1.88748568e-01f, 6.23882897e-02f,
  3.83431524e-01f, 1.68461874e-02f, -1.37244448e-01f, 1.15442164e-01f, -4.07731950e-01f, -1.71123017e-02f, -9.55346376e-02f, -8.18235502e-02f, 7.18649430e-03f, -6.66992590e-02f,
  -1.40875712e-01f, 1.18313301e-02f, -8.11001007e-03f, 4.76144589e-02f, -5.52890040e-02f, 2.11935006e-02f, -4.98861168e-03f, -9.31920111e-02f, -7.85956830e-02f, 3.59035805e-02f,
  -4.21671383e-02f, 2.94423793e-02f, -2.40132120e-03f, -7.78228119e-02f, -4.40100171e-02f, 3.81954983e-02f, -1.71376318e-01f, -7.62407556e-02f, 1.08539790e-01f, -5.77746034e-02f,
  -1.01550803e-01f, -6.00660294e-02f, 9.69998837e-02f, -3.49197909e-02f, 6.45035580e-02f, -2.66335569e-02f, -3.04349065e-02f, -1.79916620e-01f, 2.71639582e-02f, -1.77157834e-01f,
  -1.78616449e-01f, -4.46609035e-02f, 1.13997333e-01f, 1.97087139e-01f, -1.34978313e-02f, 1.42004997e-01f, 1.18807510e-01f, -1.29754633e-01f, -1.46479040e-01f, -1.64974004e-01f,
  7.74924085e-02f, 5.06394245e-02f, 2.07847562e-02f, -2.11286530e-01f, 2.13280827e-01f, 1.63060933e-01f, -4.17292193e-02f, -9.77907628e-02f, -1.24046765e-03f, 3.17303091e-02f,
  4.01854664e-01f, 9.42480192e-02f, 1.96088910e-01f, 3.32493722e-01f, -2.82543212e-01f, 5.11897743e-01f, 2.24255491e-02f, -1.06145613e-01f, 7.75998384e-02f, 1.14897184e-01f,
  1.10885896e-01f, -2.68291116e-01f, -2.88763158e-02f, -1.74793541e-01f, 3.25452983e-02f, 7.09708855e-02f, 1.20510340e-01f, -3.90457883e-02f, 1.03796095e-01f, 8.95198211e-02f,
  4.28183116e-02f, 8.17923024e-02f, -6.74407631e-02f, 1.10215284e-01f, 4.40160669e-02f, 1.18638505e-03f, -1.10168763e-01f, -1.57514602e-01f, -7.36607388e-02f, -1.42844722e-01f,
  1.93130836e-01f, -2.56756932e-01f, 4.29013185e-02f, 1.05940551e-01f, 7.05128014e-02f, 1.40313372e-01f, -8.83775204e-02f, 5.21832518e-03f, -1.79594800e-01f, 4.12201397e-02f,
  -5.18269092e-02f, 1.36638999e-01f, 1.62393168e-01f, -5.88365979e-02f, -1.42977715e-01f, 2.12266132e-01f, -1.57182604e-01f, 1.44875318e-01f, 9.94536057e-02f, -2.35297885e-02f,
  1.52713805e-01f, 2.32623875e-01f, -2.28405982e-01f, 3.63302201e-01f, -2.72727221e-01f, -3.00005917e-02f, -8.31765532e-02f, -1.46451041e-01f, -2.46374384e-01f, 1.41604185e-01f,
  -1.89030439e-01f, 2.18211323e-01f, 2.83662319e-01f, -5.46370819e-02f, 2.40917727e-01f, 2.15189919e-01f, -8.68197978e-02f, 3.67674589e-01f, -2.99118925e-02f, -1.82795808e-01f,
  1.30411088e-01f, 1.18492410e-01f, 4.27995682e-01f, 3.49597745e-02f, 3.39280456e-01f, -3.18516754e-02f, 1.13160133e-01f, 1.45644575e-01f, -7.35982731e-02f, 7.04587325e-02f,
  -4.02659513e-02f, 8.50854740e-02f, 1.56264342e-02f, 8.75632046e-04f, 1.31323915e-02f, 1.11654647e-01f, 1.27476603e-01f, 6.50826097e-03f, 1.28719032e-01f, -1.64579283e-02f,
  -5.67840934e-02f, 2.85468940e-02f, 2.04387661e-02f, 1.82802752e-01f, 6.79635778e-02f, 1.92125499e-01f, 2.35648174e-02f, 1.50442421e-01f, 1.24051176e-01f, 2.21415967e-01f,
  2.52655689e-02f, -1.99761316e-01f, 1.63756281e-01f, 1.17464855e-01f, -1.17461778e-01f, -1.70167759e-01f, -2.26575971e-01f, -1.50131002e-01f, 1.91295803e-01f, 8.47118124e-02f,
  -1.47631913e-01f, -4.43515293e-02f, -2.83047110e-01f, -2.53080994e-01f, 1.92446917e-01f, 7.37496167e-02f, 3.31181705e-01f, 2.60323167e-01f, 2.40364283e-01f, -1.18680507e-01f,
  2.22204775e-01f, 1.32580623e-01f, -6.03879206e-02f, -2.88789004e-01f, 9.86180529e-02f, 9.10379365e-02f, 1.25745088e-01f, 2.40884244e-01f, 2.00996324e-01f, -5.52926324e-02f,
  1.15078636e-01f, 2.02804431e-01f, 1.53617620e-01f, -1.09446365e-02f, -1.90533414e-01f, -2.20966965e-01f, 7.51169175e-02f, -1.14078797e-01f, 3.59163582e-02f, -1.59311265e-01f,
  5.69423363e-02f, -5.58312722e-02f, 1.16010848e-03f, 5.71132787e-02f, 6.40529245e-02f, 4.94308174e-02f, 1.12657093e-01f, 4.62201200e-02f, 8.98442194e-02f, 3.98519598e-02f,
  4.45030704e-02f, 7.66241848e-02f, -5.80199435e-02f, 1.14385955e-01f, 8.53635892e-02f, 3.98338661e-02f, -1.07752286e-01f, 1.11231953e-01f, 2.38416605e-02f, 1.77106678e-01f,
  1.86498880e-01f, 1.07744493e-01f, -7.68045485e-02f, 2.54566707e-02f, 2.10367605e-01f, -2.00292051e-01f, 4.42980863e-02f, -1.35786265e-01f, -1.81659460e-01f, 7.92557076e-02f,
  1.69933200e-01f, 1.38717875e-01f, -3.36926281e-02f, -7.65145407e-04f, -2.17682377e-01f, 1.32300988e-01f, -9.85894725e-02f, -1.34680420e-01f, 1.69722274e-01f, 1.23015746e-01f,
  3.70600224e-01f, 4.74143960e-02f, -2.42585782e-02f, 2.08255395e-01f, -9.68281552e-02f, 6.72804937e-02f, -1.19661717e-02f, -2.55896926e-01f, -3.54679041e-02f, 1.82493314e-01f,
  1.52185187e-01f, 1.27631366e-01f, 1.24139540e-01f, 4.53456268e-02f, 1.85278505e-01f, 1.18197225e-01f, 2.03121334e-01f, -2.09655613e-01f, -3.10487360e-01f, 2.95239896e-01f,
  1.74623594e-01f, 5.72791323e-02f, 1.30790681e-01f, -2.10924610e-01f, -9.67463925e-02f, -3.82550992e-02f, 1.06651559e-02f, 1.04068860e-01f, 1.38537228e-01f, 4.89221439e-02f,
  -1.99545659e-02f, -3.87124904e-02f, 8.35303664e-02f, -6.24633245e-02f, 1.17207639e-01f, 9.78549272e-02f, 1.68362945e-01f, -9.28784311e-02f, -5.48711307e-02f, 5.25725335e-02f,
  2.35254094e-02f, -1.39214173e-01f, 7.47555494e-02f, -1.88143238e-01f, 2.72472110e-03f, -7.76669458e-02f, 3.22382003e-02f, 7.30875880e-02f, -9.30900723e-02f, 1.11192361e-01f,
  -1.90936059e-01f, -1.15018211e-01f, 6.96879700e-02f, 5.08922972e-02f, 2.28466969e-02f, -1.54296070e-01f, -1.55539215e-01f, 5.61403111e-02f, -3.04305386e-02f, -1.80629157e-02f,
  1.72515899e-01f, 1.09613821e-01f, -1.21412680e-01f, 2.29483530e-01f, -2.19486669e-01f, 1.72395214e-01f, 1.15664877e-01f, -1.77663192e-01f, -3.94528843e-02f, -4.38583270e-02f,
  1.68636367e-01f, 2.73093283e-01f, 1.47438645e-01f, -4.78445739e-02f, 8.52063000e-02f, -1.40816584e-01f, 5.68092801e-02f, 2.49583364e-01f, 4.60583763e-03f, -4.68990812e-03f,
  1.54672544e-02f, 2.36772910e-01f, 3.53890687e-01f, 9.93477404e-02f, 9.43765864e-02f, 1.49496049e-01f, 4.02315222e-02f, 1.12179488e-01f, -5.16394116e-02f, -5.74189946e-02f,
  1.10874183e-01f, 9.03888643e-02f, 6.88936338e-02f, 4.42185290e-02f, 1.37083784e-01f, -1.06312381e-02f, 1.16341330e-01f, -4.70120236e-02f, 8.27905312e-02f, 3.34568582e-02f,
  -9.75404084e-02f, 9.46900249e-02f, 8.49556327e-02f, 1.28157288e-01f, -6.52554482e-02f, -4.60526757e-02f, -1.72124524e-02f, -1.56249642e-01f, -6.23119622e-02f, -1.20123006e-01f,
  -1.35648578e-01f, -2.32208204e-02f, -6.04283176e-02f, 3.20114121e-02f, -1.37692437e-01f, -1.37730539e-01f, 3.16127539e-02f, 9.75504145e-02f, 1.93177298e-01f, 1.18460685e-01f,
  -1.42998815e-01f, 1.25442356e-01f, -1.14472844e-01f, 4.80240397e-03f, 1.76715538e-01f, 5.81781901e-02f, -1.76950902e-01f, 1.45727098e-01f, -6.20830357e-02f, 1.46488985e-02f,
  -1.51611894e-01f, 4.39527810e-01f, -2.05652013e-01f, 1.59779668e-01f, 4.18780558e-02f, 1.99573293e-01f, 1.44741341e-01f, 9.30101797e-02f, -1.06595472e-01f, 6.45557046e-02f,
  -1.40106991e-01f, 6.63988143e-02f, 1.31576896e-01f, 2.56349351e-02f, 2.65922189e-01f, -1.61302499e-02f, -2.70655341e-02f, 2.64113605e-01f, 1.88697711e-01f, 6.93065897e-02f,
  1.20638356e-01f, 1.26218826e-01f, 1.24360740e-01f, 1.48834705e-01f, 2.36463279e-01f, 1.04230307e-01f, 2.95213033e-02f, 1.60963178e-01f, 3.07477470e-02f, 3.01292296e-02f,
  1.24396302e-01f, 3.46912071e-02f, 5.61163835e-02f, -9.56806634e-03f, 1.22348703e-01f, 1.21630654e-01f, 7.54053369e-02f, 6.76740408e-02f, 1.97577462e-01f, 2.31607258e-01f,
  1.44701093e-01f, -2.34127641e-01f, 6.50517568e-02f, 1.25845909e-01f, 8.90905112e-02f, 1.15646340e-01f, -1.74385577e-01f, 6.36774749e-02f, 2.99857378e-01f, 1.00551851e-01f,
  1.66647702e-01f, 2.88367551e-02f, -8.06123391e-02f, -4.57231365e-02f, 2.28000328e-01f, 1.97331145e-01f, 3.03742979e-02f, -5.25011495e-02f, -2.71922797e-01f, 1.40001457e-02f,
  1.73781589e-02f, 1.13853633e-01f, -1.20124191e-01f, 1.79260910e-01f, 3.08025610e-02f, 2.40254790e-01f, 1.99806616e-01f, 4.40691635e-02f, -2.50123531e-01f, 5.58187626e-02f,
  -8.85149557e-03f, 2.52491951e-01f, 7.72253796e-02f, 5.18289566e-01f, 1.34463698e-01f, 1.93960458e-01f, -1.75022945e-01f, 2.42326856e-01f, 7.87714645e-02f, 6.46505803e-02f,
  7.76790380e-02f, -1.36387989e-01f, -7.28889480e-02f, -9.43018645e-02f, 1.30703658e-01f, 1.30764902e-01f, -9.48700309e-02f, -1.15858465e-01f, 3.42160766e-03f, -1.76967140e-02f,
  -1.29039496e-01f, -1.95597216e-01f, 1.09975282e-02f, 1.26997195e-02f, -6.51945919e-02f, -6.00785464e-02f, 5.37379412e-03f, 3.07195615e-02f, -1.35579139e-01f, -1.74963608e-01f,
  2.70739663e-02f, 1.53131947e-01f, -7.76969790e-02f, -1.18845411e-01f, -1.11223139e-01f, 1.40021488e-01f, -1.26635805e-01f, -1.41105413e-01f, -1.00208677e-01f, -3.57670188e-02f,
  1.11275181e-01f, 4.87194285e-02f, -4.54955101e-01f, 4.47917581e-02f, -3.56022686e-01f, -3.45564494e-03f, 1.30116299e-01f, 4.41865288e-02f, -9.93803814e-02f, 1.46630526e-01f,
  -1.27075762e-01f, -1.42602190e-01f, 3.53683352e-01f, -2.46065911e-02f, 9.04708430e-02f, 1.49403736e-01f, 6.23781346e-02f, 6.61477447e-02f, -1.00944778e-02f, -6.71665967e-02f,
  2.60218441e-01f, 2.19297424e-01f, 4.09804016e-01f, -2.98011377e-02f, 1.89903393e-01f, -1.82313338e-01f, 2.59049935e-03f, -5.39804339e-01f, 4.65319194e-02f, -1.82378050e-02f,
  1.34036526e-01f, -1.93094477e-01f, 1.41442940e-01f, 2.37019900e-02f, 2.56975204e-01f, 2.74551779e-01f, 4.08131808e-01f, 1.98356330e-01f, 3.89950769e-03f, 3.73080224e-02f,
  1.06519856e-01f, 1.71514060e-02f, 1.22923061e-01f, -6.08212501e-02f, -8.97188485e-03f, -1.02709480e-01f, -1.88113879e-02f, 8.99343714e-02f, 1.52912643e-02f, 2.04170063e-01f,
  1.31636366e-01f, -2.19322313e-02f, 9.87046212e-02f, -3.47935408e-02f, 8.51551890e-02f, 3.69637683e-02f, 5.53915091e-03f, 1.75936893e-01f, -1.30454287e-01f, -8.68285000e-02f,
  -1.68813035e-01f, 4.90453839e-02f, -3.18793617e-02f, 1.76920041e-01f, -2.64930665e-01f, 1.08218811e-01f, 1.02193303e-01f, 7.57715553e-02f, 1.78272685e-03f, -9.23544019e-02f,
  -3.33989471e-01f, -6.04325384e-02f, 5.72218411e-02f, 1.06423348e-01f, 2.88804173e-01f, -1.88354954e-01f, 2.32613802e-01f, -2.14003757e-01f, -1.80354342e-01f, 1.82828188e-01f,
  1.59326985e-01f, 2.36647069e-01f, 3.35035235e-01f, 3.89117338e-02f, 4.26244037e-03f, 4.81333345e-01f, -1.53607085e-01f, 1.46118715e-01f, 2.71771878e-01f, -2.86626786e-01f,
  -5.87011538e-02f, 9.04197767e-02f, -1.48541704e-01f, -3.89102586e-02f, -1.63087472e-01f, -3.30598265e-01f, 8.27033632e-03f, 2.69120950e-02f, 3.86755884e-01f, -1.70750737e-01f,
  -3.50047722e-02f, 3.79111408e-03f, -2.55140811e-02f, 4.52486038e-01f, -1.02914507e-02f, -1.54955545e-02f, -3.12931428e-04f, 4.23067510e-02f, -1.46583989e-01f, 5.57502434e-02f,
  -2.58247014e-02f, -6.57003522e-02f, 4.12506722e-02f, 1.14883579e-01f, 9.86076072e-02f, 8.92629698e-02f, -9.63054746e-02f, 4.87558246e-02f, 9.51037854e-02f, 1.15907282e-01f,
  -1.45598292e-01f, 1.76924050e-01f, -1.11442223e-01f, 2.18336150e-01f, 5.72228245e-02f, 1.33484542e-01f, -1.56811759e-01f, 2.62675464e-01f, 8.50926638e-02f, -2.61372358e-01f,
  6.40973076e-02f, -9.56489444e-02f, -3.83495301e-01f, -3.92564349e-02f, -1.66069493e-01f, 1.13955207e-01f, -4.04645056e-02f, 1.20388806e-01f, -2.81527881e-02f, 5.00265695e-02f,
  1.69769570e-01f, -2.21998647e-01f, 1.61065444e-01f, 1.37761205e-01f, 4.01370466e-01f, 1.38235435e-01f, 5.02831712e-02f, 7.14404806e-02f, -6.85667843e-02f, 4.42145705e-01f,
  1.55337378e-01f, -3.22886854e-01f, 1.51504591e-01f, 3.76426168e-02f, 1.14803866e-01f, -7.74179921e-02f, 7.59482235e-02f, -1.71596274e-01f, 1.81411337e-02f, -1.44770816e-01f,
  1.68400496e-01f, -2.18464047e-01f, -1.76840708e-01f, 1.22780375e-01f, 2.54782736e-01f, -1.16349958e-01f, 1.53904825e-01f, 3.01347896e-02f, -5.77595085e-02f, -6.41700849e-02f,
  -2.14532716e-04f, -2.97956802e-02f, -1.33475125e-01f, -1.59337848e-01f, 2.21225414e-02f, 1.92329377e-01f, -3.66372839e-02f, 1.82804421e-01f, 5.24297282e-02f, 2.94464960e-04f,
  1.89682320e-02f, -1.95713505e-01f, -1.07058898e-01f, 6.96578100e-02f, -5.87904751e-02f, -1.39842525e-01f, 9.03266072e-02f, -1.50152072e-01f, -1.56609014e-01f, -5.82171977e-02f,
  2.85465837e-01f, 1.10593706e-01f, -1.11231036e-01f, 1.02525517e-01f, -2.96447963e-01f, 2.60131657e-01f, -1.53270870e-01f, -1.94487907e-02f, -9.17023420e-02f, -1.66261569e-01f,
  1.04731619e-01f, 1.70313880e-01f, -8.57351869e-02f, -9.78607312e-02f, 1.30285203e-01f, -1.90066084e-01f, 3.19062293e-01f, 2.62409467e-02f, 1.76526736e-02f, 4.91701454e-01f,
  -8.56516957e-02f, -4.14729029e-01f, 3.61592859e-01f, 1.96349055e-01f, -2.00393513e-01f, 1.09265469e-01f, 1.09525979e-01f, -1.06558181e-01f, 1.84659109e-01f, -1.27341107e-01f,
  1.86186194e-01f, -6.73475116e-02f, -9.10395756e-02f, -5.03053591e-02f, 7.50097036e-02f, -3.05265695e-01f, 1.47544071e-01f, -7.59473741e-02f, 3.87867451e-01f, -1.06860198e-01f,
  1.27017006e-01f, 1.84398696e-01f, 7.38711953e-02f, 2.40002498e-01f, 1.05822824e-01f, 1.40527382e-01f, 1.42597660e-01f, 1.32396579e-01f, 8.63208324e-02f, -3.16287763e-03f,
  2.00849660e-02f, 1.19896576e-01f, 1.32257149e-01f, 3.57707106e-02f, 2.95561731e-01f, -1.93064332e-01f, -6.02641562e-03f, 5.72046824e-02f, 2.52771884e-01f, 1.09981067e-01f,
  2.60284662e-01f, -5.36760092e-02f, -5.70833590e-03f, 1.76072435e-03f, 3.45625937e-01f, 6.12475676e-04f, 2.07917318e-02f, 1.86349720e-01f, -2.86819553e-03f, -3.25402571e-03f,
  1.53354883e-01f, 1.93221569e-01f, -6.03827573e-02f, 7.53518194e-02f, 3.27869773e-01f, -1.77941434e-02f, -1.14489593e-01f, -1.16283104e-01f, -1.59576669e-01f, -4.10985127e-02f,
  -1.22309849e-01f, 3.06363851e-01f, 2.93622706e-02f, 2.16052353e-01f, 2.37473831e-01f, -1.68808788e-01f, 4.11716551e-02f, -5.69735877e-02f, -2.05264449e-01f, -5.69447950e-02f,
  1.90518256e-02f, 1.29528269e-01f, 1.20802455e-01f, 2.66151428e-01f, -1.01009063e-01f, 1.97165564e-01f, -5.20704314e-02f, 7.27967918e-02f, 8.14853832e-02f, -2.25946739e-01f,
  3.68552953e-02f, 7.33816298e-03f, -3.04623574e-01f, 2.14008182e-01f, -7.22796097e-02f, 1.15618721e-01f, 8.14356748e-03f, 1.00915872e-01f, 6.52342141e-02f, -5.26997773e-03f,
  1.87907144e-01f, 8.01845416e-02f, -5.58228903e-02f, -9.46886465e-02f, 2.71876901e-02f, -1.13345254e-02f, 7.91310668e-02f, -1.90877207e-02f, 1.43881634e-01f, 6.38962537e-02f,
  1.65340438e-01f, 5.49516827e-02f, 8.72326866e-02f, 6.19381107e-02f, -8.26702937e-02f, 6.55290708e-02f, 8.02832618e-02f, -1.44855946e-01f, 5.71914157e-03f, -1.64773956e-01f,
  6.76955357e-02f, 2.08505452e-01f, 2.20250204e-01f, -2.71092683e-01f, 2.51104236e-01f, -9.76753309e-02f, 3.66868004e-02f, -9.02046636e-02f, 8.99559855e-02f, -3.30957800e-01f,
  2.67030418e-01f, -2.67425403e-02f, -1.43696681e-01f, 2.32874230e-01f, -2.26750344e-01f, -8.48676786e-02f, 6.10733628e-02f, -2.99541980e-01f, 4.59646553e-01f, 1.85543746e-02f,
  -1.18489467e-01f, 1.28188357e-01f, 2.77029276e-01f, 3.05682540e-01f, -2.88607515e-02f, 9.14870873e-02f, -1.34003773e-01f, 1.88622102e-01f, 1.18248731e-01f, 2.67584383e-01f,
  3.20888400e-01f, 1.47167206e-01f, -1.30715817e-01f, 4.02692974e-01f, 7.46293515e-02f, 3.46242562e-02f, -2.32088506e-01f, 1.82487071e-01f, 1.64059661e-02f, -2.99913343e-03f,
  -5.80335222e-02f, -1.15220033e-01f, -2.26331711e-01f, -5.38715012e-02f, 1.12384267e-01f, -1.02909833e-01f, 3.87742221e-02f, 6.97113574e-02f, -3.70966494e-02f, 5.53900376e-02f,
  -9.22415629e-02f, 9.31656733e-02f, -3.78706940e-02f, 2.28784308e-01f, -5.18779159e-02f, -2.02272177e-01f, -1.56429201e-01f, 5.83308414e-02f, -7.99572691e-02f, 1.65638283e-01f,
  2.17355266e-02f, -1.22993044e-03f, 1.05767578e-01f, -1.24649443e-01f, 1.31211445e-01f, -9.74724442e-02f, 2.37857580e-01f, -1.29101938e-02f, -2.86626946e-02f, -2.05794245e-01f,
  -1.01486295e-01f, -6.64325356e-02f, -8.83550271e-02f, -2.08558068e-01f, 8.69287103e-02f, 2.04874650e-01f, -3.67435627e-02f, -1.71580210e-01f, 2.11166561e-01f, -3.79107922e-01f,
  2.14599013e-01f, -9.91179887e-03f, 1.71062112e-01f, -1.10511653e-01f, 2.65907440e-02f, -1.24222916e-02f, -1.87662676e-01f, -3.10164928e-01f, -2.78580993e-01f, -2.44995151e-02f,
  7.39609748e-02f, -6.49252161e-02f, 1.83659866e-01f, -5.47212660e-02f, 1.00656606e-01f, 2.48456504e-02f, -3.43197197e-01f, -2.01663300e-01f, -2.95423388e-01f, -1.90835610e-01f,
  5.48298657e-02f, -1.99069470e-01f, 1.47734269e-01f, -2.61158079e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.18305907e-02f, -2.65837833e-03f, -1.12100691e-02f, 1.01087488e-01f, 1.77626342e-01f, 7.34426603e-02f, -6.12708880e-03f, 1.10940389e-01f, -7.32597113e-02f, 7.05813840e-02f,
  3.10406033e-02f, 1.12877294e-01f, 1.28246527e-02f, 6.69850707e-02f, 1.10654727e-01f, 1.18206196e-01f, 6.84336498e-02f, 5.50053734e-03f, 1.66457579e-01f, 3.16296294e-02f,
  1.42400011e-01f, 3.52971703e-02f, 1.31687326e-02f, 1.24452978e-01f, 4.49771844e-02f, 5.49666621e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.46711702e-02f, -9.97177064e-02f, 5.41317128e-02f, 1.51565582e-01f, 5.31136524e-03f, 1.49190411e-01f, 2.94422954e-02f, -1.04594573e-01f, 2.28073254e-01f, 2.30178554e-02f,
  9.96393412e-02f, 3.91340405e-02f, 6.13109916e-02f, -8.84516835e-02f, 1.84197888e-01f, 6.39697984e-02f, 1.28418759e-01f, -6.35596551e-03f, -7.56554529e-02f, -1.61406383e-01f,
  7.01110065e-03f, 1.72037110e-01f, -2.03695923e-01f, -2.13166177e-02f, -3.10543645e-02f, -1.81655377e-01f, -1.21868700e-01f, -2.85765111e-01f, -1.71865612e-01f, 1.85629189e-01f,
  2.84659982e-01f, 1.80989340e-01f, -2.91341960e-01f, 5.35310246e-02f, -2.83076558e-02f, -2.26582214e-02f, 8.16705599e-02f, -2.83649802e-01f, 8.58915001e-02f, 2.08838135e-01f,
  -4.05888617e-01f, -4.28483993e-01f, -3.08388978e-01f, -3.25681001e-01f, -3.98402035e-01f, 1.19703338e-01f, -1.34366751e-01f, 1.54380292e-01f, -3.33806127e-01f, -3.97482455e-01f,
  -4.33325171e-02f, 8.03172588e-03f, -1.22861832e-01f, -2.45800540e-01f, 5.12355240e-04f, 2.25363653e-02f, -1.46838985e-02f, 3.48427594e-01f, 2.76849955e-01f, 1.52211770e-01f,
  4.24413770e-01f, -1.81226313e-01f, -4.53780472e-01f, -1.48637429e-01f, 3.67653929e-02f, -1.50793940e-01f, 8.98346305e-02f, -8.65821093e-02f, -2.63317168e-01f, -7.98183829e-02f,
  1.58128992e-01f, 7.53017142e-02f, -3.18009555e-01f, -1.83342576e-01f, -3.36991176e-02f, -9.06059667e-02f, 1.64892167e-01f, -8.14072601e-03f, 3.38807032e-02f, 1.79312620e-02f,
  2.70848759e-02f, -1.30828321e-01f, -6.55550733e-02f, -1.40842900e-01f, -3.37022319e-02f, -1.63221523e-01f, 6.86658993e-02f, 1.59316380e-02f, 2.93765366e-01f, -2.30641916e-01f,
  2.86132067e-01f, -2.73813512e-02f, -4.52094227e-02f, 8.01555663e-02f, 9.86432210e-02f, -3.86717021e-02f, -2.22534522e-01f, -1.04231387e-01f, -2.04203412e-01f, 1.97993979e-01f,
  5.68164419e-03f, 8.16381574e-02f, 1.20290384e-01f, -4.53902893e-02f, -2.08673347e-02f, 1.81507528e-01f, -3.99861068e-01f, 1.43156305e-01f, -3.44738871e-01f, 1.87129498e-01f,
  7.74346665e-02f, 3.21872711e-01f, 8.28322396e-02f, -3.81933719e-01f, -2.81543374e-01f, 2.46258378e-01f, -4.14043814e-01f, -2.53241360e-01f, 2.09669411e-01f, 1.25762060e-01f,
  -1.77921146e-01f, 8.11529979e-02f, 1.13615893e-01f, -3.20788622e-01f, 1.14764452e-01f, 1.49986856e-02f, -1.38759091e-01f, 3.68086211e-02f, 1.76812131e-02f, -3.37909209e-03f,
  7.90960491e-02f, 5.94988763e-02f, 1.84239835e-01f, 1.19256504e-01f, -1.63966611e-01f, 7.24704042e-02f, -9.53028500e-02f, -1.01889938e-01f, 4.02553305e-02f, 5.26193641e-02f,
  9.99263152e-02f, 8.17041695e-02f, -1.34594226e-02f, -2.77431291e-02f, 6.69946223e-02f, 1.39575163e-02f, 4.01981222e-03f, 2.22604096e-01f, 2.21552134e-01f, -1.85315877e-01f,
  -2.01513052e-01f, 9.69839394e-02f, -6.90339273e-03f, 2.50965774e-01f, 4.24178839e-02f, 8.48022550e-02f, -1.66018710e-01f, -9.46670920e-02f, 2.37336755e-01f, -5.66479452e-02f,
  -1.42809004e-01f, -1.01169623e-01f, 2.72574306e-01f, -7.15964884e-02f, -1.44722983e-01f, -2.27704063e-01f, 1.35774791e-01f, -4.45358902e-01f, 1.97470456e-01f, 3.31467055e-02f,
  -4.06012028e-01f, 2.60344535e-01f, 2.32358091e-02f, -1.90835789e-01f, -1.24682985e-01f, -2.95878023e-01f, 3.41350853e-01f, 5.56629039e-02f, -2.06274822e-01f, -1.51919723e-01f,
  -3.65756571e-01f, 8.36498216e-02f, 3.33926976e-02f, 2.45648041e-01f, -5.11338949e-01f, 3.18010628e-01f, -1.86726958e-01f, 1.50011629e-01f, -4.93410081e-01f, -3.73960614e-01f,
  3.48457918e-02f, -3.78550738e-02f, -1.89977035e-01f, -1.59678668e-01f, -3.64478789e-02f, 3.50344330e-02f, -1.60471976e-01f, -1.05101131e-01f, 5.99466041e-02f, 2.51936972e-01f,
  1.35730296e-01f, -9.27556530e-02f, 2.07622210e-03f, 2.88856439e-02f, -1.85781028e-02f, 1.48044065e-01f, 7.82387480e-02f, 7.58186057e-02f, -4.72873747e-02f, -9.62162018e-02f,
  1.44536555e-01f, -2.20516458e-01f, 1.10443287e-01f, 1.53769910e-01f, -1.69179693e-01f, -9.97176114e-03f, 1.59527257e-01f, 1.39133587e-01f, 1.03492849e-01f, 4.75012697e-02f,
  3.12759936e-01f, 2.47457018e-03f, 1.44395858e-01f, -2.99441069e-02f, -1.03527606e-01f, -1.60304159e-01f, 2.52932072e-01f, -1.03675332e-02f, -2.86950409e-01f, -1.92830324e-01f,
  -3.42749834e-01f, 1.43381372e-01f, -2.42501989e-01f, -2.84572393e-01f, 2.41744444e-01f, -3.92834157e-01f, -1.07767150e-01f, -4.76286054e-01f, 1.08317398e-02f, -3.18139344e-01f,
  7.85966683e-03f, -2.37747744e-01f, 3.29485029e-01f, 2.40098044e-01f, 1.73429519e-01f, 1.08061358e-01f, -2.92218149e-01f, -3.38483572e-01f, 9.14337188e-02f, -2.23412633e-01f,
  -3.00350249e-01f, 1.14759065e-01f, 1.43537045e-01f, -3.81812215e-01f, -2.92946815e-01f, 4.29603726e-01f, 2.04402909e-01f, 1.67512506e-01f, 6.60103709e-02f, 2.23864075e-02f,
  9.55347940e-02f, 9.89004895e-02f, -4.33049947e-02f, -1.85249865e-01f, -3.04150973e-02f, 1.36434093e-01f, 1.63807482e-01f, -4.89174686e-02f, 1.88692942e-01f, 9.20040533e-02f,
  -1.55618340e-01f, -2.04460751e-02f, 2.80017078e-01f, 3.10247421e-01f, -1.16651773e-01f, 2.15930268e-01f, -9.09593254e-02f, 1.66849211e-01f, -2.38655150e-01f, 3.35818768e-01f,
  -1.62752658e-01f, 1.89216420e-01f, -1.51370317e-01f, -1.26195043e-01f, -2.15480775e-01f, -4.21700865e-01f, -3.83099556e-01f, 2.65501559e-01f, 1.41583726e-01f, 1.25526875e-01f,
  -3.43221307e-01f, -3.65145534e-01f, 1.94572136e-01f, -1.59867868e-01f, -1.64028957e-01f, 3.39491844e-01f, 1.48229897e-01f, -3.89154345e-01f, 1.54883355e-01f, 2.44348925e-02f,
  -5.29195629e-02f, 4.64686528e-02f, -4.22975987e-01f, -1.57913879e-01f, -2.36541897e-01f, 2.33219489e-01f, -3.23780447e-01f, -1.06858097e-01f, 3.58851045e-01f, 6.24019131e-02f,
  -8.20497200e-02f, -2.68076509e-01f, 1.45057485e-01f, -7.52047775e-03f, -1.88518271e-01f, 3.00622266e-02f, 1.90250844e-01f, 3.13840032e-01f, -3.40744168e-01f, -3.49343985e-01f,
  2.28327930e-01f, -1.41503856e-01f, 1.96797654e-01f, 8.42724591e-02f, 7.71871442e-03f, -4.09923792e-02f, -1.60712764e-01f, 1.84353620e-01f, 1.71927586e-01f, -4.43597063e-02f,
  -3.21223575e-04f, 2.85529345e-01f, 6.58390624e-03f, 2.61363298e-01f, 7.03098029e-02f, -1.55713096e-01f, -1.75265610e-01f, -2.04177245e-01f, 2.98417471e-02f, -7.49764079e-03f,
  -7.98620563e-03f, -1.05043575e-01f, 1.93223521e-01f, 2.42687315e-01f, 8.98888055e-03f, -1.01756550e-01f, -2.80093104e-01f, 2.11485684e-01f, -1.21750683e-01f, 3.51687372e-01f,
  3.17411065e-01f, -1.95208892e-01f, 2.60598719e-01f, 1.01423442e-01f, -5.76072186e-02f, 2.33171508e-01f, 1.06448106e-01f, 2.46968299e-01f, 2.12833986e-01f, -8.80824924e-02f,
  -3.09448183e-01f, -4.49866466e-02f, 1.23677351e-01f, -3.10736239e-01f, 4.94805574e-02f, 3.04452866e-01f, -2.50745088e-01f, 8.23313817e-02f, -9.26408768e-02f, 9.74151045e-02f,
  -1.93479061e-02f, -2.21788913e-01f, -6.52064458e-02f, -4.63026792e-01f, 5.32475859e-02f, -1.40363514e-01f, 2.23265395e-01f, -5.60592473e-01f, 3.05004746e-01f, -2.45646194e-01f,
  -2.51734555e-01f, 2.70796686e-01f, 3.32167089e-01f, -2.13679582e-01f, 8.54547545e-02f, 1.36359721e-01f, 7.79446736e-02f, 1.12572245e-01f, -1.33974239e-01f, -1.20154679e-01f,
  8.24968889e-02f, 2.34866381e-01f, -1.16669580e-01f, -9.79107320e-02f, -1.92152321e-01f, -2.69064941e-02f, -3.71300071e-01f, -1.20973088e-01f, -1.02252096e-01f, -1.65492207e-01f,
  9.33613852e-02f, -3.02406922e-02f, -1.70306817e-01f, 3.67282957e-01f, 1.79930910e-01f, 9.75474641e-02f, -2.39390403e-01f, -1.61073014e-01f, -7.65269697e-02f, 3.78031850e-01f,
  -1.29991338e-01f, 1.16202153e-01f, 6.11777697e-03f, 8.94417763e-02f, -1.84085831e-01f, -7.36806020e-02f, 5.31489290e-02f, 2.59831250e-01f, -1.57501832e-01f, 1.09980814e-01f,
  3.70097496e-02f, 2.48284578e-01f, -2.04698801e-01f, -3.77884537e-01f, 2.71782517e-01f, 1.86738715e-01f, -2.85889894e-01f, 1.08403295e-01f, 2.34981373e-01f, -8.09253231e-02f,
  3.18718135e-01f, 1.59051865e-01f, 2.63096392e-01f, 1.91689849e-01f, -3.51853579e-01f, 1.10995106e-03f, -2.88954675e-01f, 9.68909115e-02f, -2.18551055e-01f, 1.05000533e-01f,
  4.90293987e-02f, -4.86024946e-01f, -4.05680746e-01f, -4.93110687e-01f, -1.92384928e-01f, 1.71961993e-01f, 5.69600090e-02f, -1.04122303e-01f, -7.78556615e-02f, -7.92081282e-02f,
  7.01321214e-02f, -2.00593680e-01f, 1.57367051e-01f, 7.98264612e-03f, 2.04501912e-01f, -1.08368583e-01f, -9.77142155e-02f, 1.51644379e-01f, -1.77849963e-01f, -1.10454068e-01f,
  4.66588736e-02f, -2.00790703e-01f, -9.05463099e-02f, 3.87692116e-02f, 1.73607081e-01f, 3.57989483e-02f, -7.25145638e-02f, 1.41565904e-01f, -5.46186492e-02f, -3.01503479e-01f,
  2.44471759e-01f, -1.08732343e-01f, 3.22939605e-01f, 6.54494297e-03f, -1.52753666e-02f, -1.71686172e-01f, 1.04310058e-01f, -2.47668684e-01f, 3.49653549e-02f, -7.01196641e-02f,
  -9.98024084e-03f, 1.03800453e-01f, -6.92523345e-02f, 2.69098151e-02f, 6.84138760e-02f, 7.31546208e-02f, 9.47048236e-03f, -4.12072778e-01f, -3.05232257e-01f, 3.34678665e-02f,
  1.60950482e-01f, -1.01539031e-01f, -3.74464750e-01f, 3.91476490e-02f, 2.08421513e-01f, -5.04482761e-02f, -1.52430117e-01f, 1.95117652e-01f, 1.24946855e-01f, -2.37532020e-01f,
  1.77414924e-01f, 2.62930393e-01f, -1.58563629e-01f, -2.90736884e-01f, -2.79979467e-01f, -6.18706755e-02f, -2.06416026e-01f, 1.96464315e-01f, -2.70916194e-01f, -1.02281325e-01f,
  3.19277734e-01f, 4.08389032e-01f, 5.48201166e-02f, 1.80181712e-01f, -2.24935729e-02f, 1.27501547e-01f, 6.94084987e-02f, -1.92097977e-01f, 7.49117956e-02f, -9.15861577e-02f,
  -8.24081600e-02f, 7.21322149e-02f, -1.48731604e-01f, 3.74121480e-02f, -7.11209774e-02f, 6.59339875e-02f, -2.08477080e-01f, 6.08747080e-02f, 3.94175239e-02f, 3.88678312e-02f,
  -5.48714995e-02f, -1.25176951e-01f, 2.29730546e-01f, -1.55056596e-01f, -9.62559879e-02f, -1.42330363e-01f, 1.74934670e-01f, 1.25675663e-01f, 1.16486020e-01f, 8.53882879e-02f,
  2.49093056e-01f, -2.07498834e-01f, 1.78652570e-01f, 2.02826321e-01f, -1.63850844e-01f, -9.83481482e-02f, 1.90984473e-01f, -2.81920042e-02f, 7.70251006e-02f, -2.37571716e-01f,
  2.20312372e-01f, 6.80019483e-02f, -1.78279310e-01f, -5.95809799e-03f, 9.46615934e-02f, 2.21987650e-01f, 1.88134462e-01f, 1.08416498e-01f, 1.04520194e-01f, -3.46672744e-01f,
  -1.13486543e-01f, -2.45161772e-01f, 5.75270534e-01f, -1.65195718e-01f, -1.38221100e-01f, -2.38112777e-01f, 2.03206196e-01f, -5.20111285e-02f, -2.89483428e-01f, 2.21041769e-01f,
  -2.50006095e-02f, -1.47263438e-01f, -1.78398192e-01f, -2.75833070e-01f, 2.70588815e-01f, -5.65141328e-02f, -1.74590886e-01f, -1.40041083e-01f, -1.44681901e-01f, -4.05652076e-02f,
  2.50962406e-01f, -1.07870720e-01f, 7.34482482e-02f, -3.16273987e-01f, 4.73922044e-02f, -1.32104561e-01f, 1.30783096e-01f, 1.84839934e-01f, 1.02704689e-01f, 1.37595534e-01f,
  -8.91265124e-02f, 1.48567483e-01f, -2.53399134e-01f, -2.11969972e-01f, 9.26491022e-02f, 8.77406597e-02f, -2.32310653e-01f, 2.06057906e-01f, 1.22853599e-01f, -8.81752446e-02f,
  -1.24944523e-01f, -1.26765698e-01f, -4.21812981e-02f, 1.88706666e-01f, -1.21475078e-01f, 2.03597099e-01f, -1.28845692e-01f, -2.02513322e-01f, -5.59896929e-03f, -1.76611934e-02f,
  4.02459642e-03f, 2.37613916e-01f, 9.85739008e-02f, -1.26954108e-01f, -3.84263396e-01f, -4.71047997e-01f, -4.35095616e-02f, 8.78580362e-02f, -4.11415070e-01f, -4.59031850e-01f,
  -3.82119976e-02f, 5.14356345e-02f, -4.71081138e-01f, -1.74320191e-01f, 1.13634378e-01f, 2.50323445e-01f, -3.87556925e-02f, -4.85868394e-01f, 1.31425112e-01f, 2.22955257e-01f,
  -3.97289455e-01f, 6.93940520e-02f, 7.44232163e-02f, -2.75969893e-01f, 2.38142401e-01f, 4.37756956e-01f, -4.27333593e-01f, -1.06257312e-02f, -1.94113627e-01f, -3.58708471e-01f,
  -1.46253020e-01f, -1.00931667e-01f, -1.49311218e-02f, 1.18756607e-01f, -2.97045857e-01f, 1.10532880e-01f, 8.22957009e-02f, -1.18530147e-01f, -2.49966577e-01f, 1.58046097e-01f,
  -1.41452104e-01f, -1.37355059e-01f, -2.16384362e-02f, 3.68386554e-03f, -7.25792274e-02f, 9.97369438e-02f, -1.62979081e-01f, 1.92297753e-02f, -1.34877548e-01f, -1.33215025e-01f,
  4.75459499e-03f, 2.16836959e-01f, 7.66517445e-02f, 1.20955054e-02f, -4.51566800e-02f, -2.09696800e-01f, -9.34579130e-03f, -4.67545539e-03f, 1.68677777e-01f, -1.10698998e-01f,
  -6.00830726e-02f, -3.58129628e-02f, -2.39392184e-02f, 8.77800509e-02f, 2.16864407e-01f, -1.40412480e-01f, -3.26448798e-01f, 2.17490301e-01f, -6.32956773e-02f, -1.00635305e-01f,
  2.75292367e-01f, -3.58580686e-02f, -1.81658894e-01f, 2.67182797e-01f, 4.26945500e-02f, -3.14118177e-01f, 2.07971141e-01f, 1.42336681e-01f, -5.48850536e-01f, -2.48005226e-01f,
  -3.20465863e-02f, 3.41770023e-01f, -5.95101155e-02f, 2.32192233e-01f, 1.87805891e-01f, 1.05577536e-01f, -9.31343588e-04f, 1.03776008e-01f, -3.62691343e-01f, 2.03060701e-01f,
  9.45458189e-02f, 3.11540104e-02f, -5.40879428e-01f, -1.85331792e-01f, 1.30805761e-01f, 3.33632492e-02f, -9.42407325e-02f, 5.00892997e-02f, 1.08065486e-01f, 1.92069128e-01f,
  -1.73615247e-01f, 1.41728252e-01f, -1.12293875e-02f, 7.86754861e-02f, 1.87258616e-01f, -4.30973917e-02f, 1.32992819e-01f, -1.04436949e-01f, 9.54911858e-02f, 3.18411291e-02f,
  6.98723048e-02f, 1.05136134e-01f, -1.95685133e-01f, -3.27768415e-01f, -2.01526918e-02f, 1.34809166e-01f, 1.23639062e-01f, -1.02051117e-01f, -1.18915252e-01f, -2.65060514e-01f,
  -1.98683818e-03f, 8.04940164e-02f, 2.82046467e-01f, 2.06994623e-01f, -7.35869706e-02f, 4.43031415e-02f, 1.29155576e-01f, -2.04217702e-01f, 2.82252520e-01f, -1.28321484e-01f,
  1.46731526e-01f, 5.40157743e-02f, -4.54665303e-01f, -2.96961397e-01f, -1.44695073e-01f, 2.75707066e-01f, 2.53240466e-01f, -1.33196250e-01f, 2.12069958e-01f, -4.58227605e-01f,
  2.28407443e-01f, -2.16310903e-01f, -3.11419517e-01f, 6.83637336e-02f, 4.81435210e-01f, 1.16143294e-01f, -7.69717991e-02f, 2.69495486e-03f, 6.03214875e-02f, 1.49263054e-01f,
  2.04371810e-01f, -3.73145342e-01f, -3.63166958e-01f, -3.90951246e-01f, -4.30018246e-01f, -2.39069700e-01f, 1.91763058e-01f, -2.95464605e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.73108634e-02f, 5.33559211e-02f, -4.56673559e-03f, -4.26987186e-02f, 1.41240209e-01f, -4.10467908e-02f, -1.17478110e-01f, -1.14635482e-01f, -3.13793421e-02f, 8.51505771e-02f,
  -5.73465861e-02f, 3.46618406e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    