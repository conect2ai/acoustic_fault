/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.81799787e-01f, -2.94168532e-01f, 1.38561949e-01f, -7.81954527e-02f, -1.75687626e-01f, -2.75040329e-01f, 8.23034048e-02f, -1.75318614e-01f, -6.39615282e-02f, 1.31851034e-02f,
  1.28317550e-01f, -1.40277207e-01f, 1.46614894e-01f, 7.96969011e-02f, 9.43730846e-02f, -5.35493251e-03f, 8.51263702e-02f, -1.59859329e-01f, 7.97320381e-02f, -6.57274649e-02f,
  6.22848747e-03f, 2.42450759e-02f, 1.43577933e-01f, 7.47882947e-02f, -1.04560919e-01f, -7.38969520e-02f, -1.22631248e-02f, 4.39966284e-02f, -2.68846266e-02f, -1.19938608e-02f,
  -3.04160379e-02f, 4.52977568e-02f, -1.03376443e-02f, 8.19635466e-02f, -9.68280435e-02f, -3.94476540e-02f, 1.55206574e-02f, 6.80075362e-02f, 4.19528112e-02f, -2.78038271e-02f,
  -9.55696926e-02f, 5.19693876e-03f, -1.47425523e-02f, -1.26327435e-02f, -3.13736238e-02f, 6.39056191e-02f, 2.19080895e-02f, 8.65003001e-03f, 4.40073833e-02f, 3.65385204e-03f,
  -5.62803037e-02f, -2.05929931e-02f, -7.51347020e-02f, 4.37907688e-02f, -3.27733651e-05f, 3.81228537e-03f, 3.99276055e-02f, 1.28287841e-02f, -3.15232985e-02f, -1.55684222e-02f,
  -2.43625510e-02f, -1.48757659e-02f, 1.42880585e-02f, 4.90101315e-02f, -1.89193748e-02f, 1.85299087e-02f, -5.04723145e-03f, 3.35490219e-02f, 3.49528864e-02f, -1.61035191e-02f,
  -3.80385555e-02f, -4.99557965e-02f, -1.87337697e-02f, -3.41677666e-02f, -2.94420216e-02f, -1.13882655e-02f, -3.00674811e-02f, 8.26772675e-02f, -6.03992566e-02f, 1.85668562e-02f,
  3.63281891e-02f, -2.07140315e-02f, -2.60376893e-02f, 1.34358890e-02f, -1.56470283e-03f, 2.90453210e-02f, -2.70472083e-04f, 3.37479189e-02f, 1.87330600e-02f, -4.39583249e-02f,
  -3.85195762e-01f, -3.09269726e-01f, -1.55782308e-02f, 2.42228974e-02f, 4.03919183e-02f, 4.22533602e-02f, 1.19799364e-03f, 1.89120620e-02f, 2.81394180e-02f, 6.92731738e-02f,
  6.84039667e-02f, 1.80313606e-02f, -6.35782406e-02f, 1.94316334e-03f, -3.92601453e-02f, -3.15597728e-02f, -4.13636081e-02f, -5.34000285e-02f, -5.32111451e-02f, 2.34727617e-02f,
  2.20335238e-02f, -4.36786450e-02f, 1.08451828e-01f, -6.71532229e-02f, 3.00089195e-02f, 1.81976671e-03f, -1.16886131e-01f, -4.73057525e-03f, -2.45749764e-03f, 2.01675035e-02f,
  -3.96862030e-01f, -1.80868536e-01f, 5.99440522e-02f, -8.50354433e-02f, 1.68051183e-01f, -6.19845316e-02f, -2.11743250e-01f, 5.80817312e-02f, -2.38074034e-01f, -1.85402095e-01f,
  -5.85943535e-02f, -1.55491129e-01f, -1.18543297e-01f, -3.55653733e-01f, -8.31468329e-02f, -3.25872183e-01f, -2.66481161e-01f, -1.83422565e-01f, -1.15747549e-01f, 5.53744622e-02f,
  -4.68827002e-02f, -5.36192097e-02f, -2.22423095e-02f, 6.41683191e-02f, -1.49787813e-02f, 6.51272535e-02f, 1.34484336e-01f, 7.24837780e-02f, 3.82604785e-02f, 7.93580897e-03f,
  -3.59130353e-02f, -5.07743247e-02f, 1.19842906e-02f, 4.02706582e-03f, 1.16002634e-01f, 3.21469158e-02f, 6.42333403e-02f, 3.22851464e-02f, 5.36303595e-02f, -3.58804576e-02f,
  1.24122426e-02f, 3.92631181e-02f, 5.63393161e-03f, 1.29337627e-02f, -1.85242798e-02f, 2.30359193e-02f, -3.10532693e-02f, -2.41337903e-02f, -4.55045328e-02f, -1.25667285e-02f,
  -3.05728316e-02f, -1.60666779e-02f, 2.86397766e-02f, -2.83081215e-02f, 3.42494845e-02f, -1.18977604e-02f, -1.28074614e-02f, -3.59198377e-02f, -1.99199282e-02f, -5.27280048e-02f,
  -7.45483115e-03f, -4.39547887e-03f, -1.40322950e-02f, 1.32262455e-02f, -1.59868237e-03f, 1.00770565e-02f, 1.16524892e-02f, 3.93807190e-03f, -6.47433326e-02f, -5.94443642e-03f,
  -2.21396703e-02f, 4.05131951e-02f, -5.47905341e-02f, -9.41715110e-03f, 3.49813215e-02f, 2.36831568e-02f, 7.18268827e-02f, -9.34729911e-03f, 2.13544779e-02f, -2.71099824e-02f,
  -4.24142182e-03f, -5.85578149e-04f, 3.91141651e-03f, 1.51767069e-02f, 4.07260656e-03f, 5.79445623e-02f, -5.66077344e-02f, -3.81931774e-02f, 3.53246257e-02f, 9.95718036e-03f,
  4.27791551e-02f, 1.56855006e-02f, -6.34579211e-02f, 1.22909686e-02f, -5.82794882e-02f, -1.27985363e-03f, -5.52336909e-02f, -3.24466527e-02f, -2.79823970e-02f, 3.56133236e-03f,
  -9.23959818e-03f, -3.24774720e-03f, 2.48344876e-02f, 3.30941714e-02f, 5.29628992e-02f, -1.12585045e-01f, 5.09251691e-02f, 1.04472205e-01f, 4.59780730e-02f, -1.16439816e-02f,
  1.59207080e-02f, 4.27848399e-02f, -3.10743432e-02f, 4.99466509e-02f, 4.47782092e-02f, -4.72942786e-03f, 8.14277306e-02f, 1.20762028e-02f, 3.52775701e-03f, -1.25902519e-02f,
  -2.33231559e-01f, 1.97829321e-01f, 1.11377873e-01f, -1.59256952e-03f, -1.36405483e-01f, -1.24109544e-01f, 2.23413438e-01f, -3.18711549e-02f, 3.23576659e-01f, 1.02296412e-01f,
  2.55258903e-02f, -2.70938218e-01f, 4.52998012e-01f, -9.97639000e-02f, -1.66171834e-01f, 3.07652533e-01f, -9.59560797e-02f, -8.79612938e-02f, 4.85571958e-02f, -1.07982159e-01f,
  3.15324105e-02f, -7.49817342e-02f, -4.93594408e-02f, -3.55566889e-02f, -1.05534330e-01f, -5.05083613e-02f, -8.68427902e-02f, 1.55908307e-02f, -3.71549517e-01f, -2.26390824e-01f,
  -6.86509013e-02f, -1.39670864e-01f, 3.00181434e-02f, -5.76492911e-03f, -3.22676860e-02f, -7.41298944e-02f, -2.34231111e-02f, -6.71610162e-02f, -4.65982482e-02f, -5.29436283e-02f,
  6.50600791e-02f, -7.16235265e-02f, -1.89854708e-02f, 1.17188320e-02f, 2.25436911e-02f, -5.42822480e-03f, -5.02565093e-02f, -2.22443137e-03f, -4.05335128e-02f, -3.05933487e-02f,
  7.44918585e-02f, -1.20474603e-02f, 7.56964236e-02f, -4.12407182e-02f, 5.07285893e-02f, -1.55063451e-03f, 2.73482259e-02f, -1.16432281e-02f, -6.29414544e-02f, -8.46182555e-02f,
  3.13222259e-02f, 3.89122497e-03f, 8.58408734e-02f, -3.56304795e-02f, 4.89518009e-02f, -3.29939686e-02f, 4.32923026e-02f, 2.69688554e-02f, 5.29451407e-02f, -1.79787446e-02f,
  1.41914710e-02f, 2.89087165e-02f, 3.32467146e-02f, 1.08599504e-02f, 6.74388260e-02f, 2.50012744e-02f, 7.23470524e-02f, 2.80378144e-02f, 9.09639820e-02f, -7.69117428e-03f,
  7.72481412e-02f, 7.45429099e-03f, -3.29166129e-02f, 8.22642967e-02f, 3.91761139e-02f, 5.57793640e-02f, 2.66070757e-02f, 5.04092611e-02f, 6.99419305e-02f, -7.18311453e-03f,
  -1.44558653e-01f, -2.93207645e-01f, 3.51873413e-02f, 1.18050715e-02f, -1.30296021e-03f, -8.21707398e-03f, 1.66000463e-02f, 4.07936610e-03f, -1.93259567e-02f, -2.91347373e-02f,
  -7.11219460e-02f, -7.07410648e-02f, -2.87460126e-02f, -1.18710482e-02f, -7.97815025e-02f, 3.30055729e-02f, 2.80716792e-02f, -2.11646911e-02f, -3.16209830e-02f, -7.85329416e-02f,
  -1.51172038e-02f, -5.48872107e-04f, 7.05893966e-04f, 4.48154546e-02f, -6.59810603e-02f, 1.23250075e-02f, -1.54636819e-02f, 9.90441162e-03f, -4.69405651e-02f, 5.14234751e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.95441142e-01f, -2.87550658e-01f, 3.46678942e-01f, 1.81996465e-01f, 3.28946322e-01f, -4.04526405e-02f, 3.12636256e-01f, 7.32852221e-02f, 1.91000789e-01f, -3.77998501e-01f,
  -1.24601923e-01f, -2.85728812e-01f, -8.74217227e-02f, -2.56733894e-01f, 1.21710062e-01f, -2.89379120e-01f, -5.76691590e-02f, -1.56685412e-01f, 7.95841403e-03f, 1.23769119e-02f,
  1.27857044e-01f, 1.07994527e-02f, 8.52791443e-02f, -1.56281382e-01f, 6.26391992e-02f, 1.49168342e-01f, -1.63160879e-02f, 1.32586345e-01f, -1.08850077e-01f, 6.21123426e-02f,
  1.32968515e-01f, 1.66978359e-01f, -3.52352820e-02f, -4.12806682e-02f, 9.19751152e-02f, -4.34819646e-02f, -2.98529137e-02f, 6.65701926e-02f, 2.58386396e-02f, 5.17699495e-02f,
  -7.90723711e-02f, 2.29659062e-02f, 2.34712828e-02f, 4.21852060e-02f, 1.10623144e-01f, 4.05104179e-03f, 7.44286180e-02f, 2.12089699e-02f, 6.20811619e-02f, 7.41356462e-02f,
  6.49872795e-02f, -1.03172027e-01f, 8.81358907e-02f, 2.47918088e-02f, 2.45532040e-02f, 1.67028129e-03f, 2.36472581e-02f, 5.23699969e-02f, -4.75301817e-02f, -5.84710278e-02f,
  9.27852374e-03f, 8.55404064e-02f, -1.70460474e-02f, 4.66965251e-02f, 3.54963392e-02f, 9.20235813e-02f, -4.16617170e-02f, 1.47575922e-02f, -7.44390041e-02f, -1.45140626e-02f,
  1.79613717e-02f, 1.52230458e-02f, -4.92395274e-02f, -8.54543131e-03f, -4.53074276e-02f, -5.20741083e-02f, -2.45032273e-02f, -4.69683371e-02f, -3.63445096e-02f, 1.94767900e-02f,
  -1.22135490e-01f, 2.92724781e-02f, -2.05404293e-02f, -1.09312520e-03f, 5.23700844e-03f, 8.97060856e-02f, -8.22406858e-02f, -6.36023954e-02f, -1.54526709e-02f, 2.47110035e-02f,
  -3.66681628e-02f, -1.23099923e-01f, 7.96401873e-02f, 6.66940911e-03f, -7.03855529e-02f, -1.09685145e-01f, 3.78901623e-02f, -4.27975729e-02f, 5.04589118e-02f, -8.04920793e-02f,
  -4.11286876e-02f, -2.40495196e-03f, -1.66006517e-02f, -3.46053094e-02f, -1.36810601e-01f, 2.55894456e-02f, 2.80144177e-02f, -5.70035838e-02f, 7.43878335e-02f, -1.16808221e-01f,
  -1.06723554e-01f, 4.76155952e-02f, -2.11179745e-03f, -3.74509133e-02f, 4.75434288e-02f, -4.61020730e-02f, 2.34167837e-02f, -1.94441192e-02f, 7.51360087e-04f, -5.35873584e-02f,
  -9.05281246e-01f, 6.38450444e-01f, 4.99857217e-01f, -6.34922862e-01f, 1.48712769e-01f, 2.77901530e-01f, -1.62808165e-01f, 1.42228797e-01f, -1.97724104e-01f, -1.68615222e-01f,
  -1.82700574e-01f, -8.60833973e-02f, 2.10626751e-01f, -3.00374534e-02f, -3.41273785e-01f, -2.90946811e-02f, -1.84352100e-01f, -4.06377912e-02f, 1.98951274e-01f, 5.06052338e-02f,
  -1.07979774e-01f, -4.33352739e-01f, 8.86766315e-02f, 1.39112145e-01f, 8.02082568e-02f, 9.17448848e-02f, -4.34424967e-01f, 2.41460204e-01f, -6.25742541e-04f, -5.56286797e-02f,
  -6.46368321e-03f, 6.81889355e-02f, 1.17486492e-01f, 1.17164955e-01f, 1.37797305e-02f, -1.83259379e-02f, -5.78791872e-02f, -5.60287274e-02f, -2.24877018e-02f, -2.65315492e-02f,
  1.04859471e-01f, 1.75933857e-02f, -7.82315955e-02f, -1.56970993e-02f, 5.90141341e-02f, 1.40469953e-01f, 1.06922947e-01f, 1.23703882e-01f, 5.64997718e-02f, 2.41349533e-01f,
  1.12963051e-01f, 6.22247048e-02f, -7.92293772e-02f, 3.04246321e-02f, 4.43809293e-03f, 1.41513934e-02f, -9.93000157e-03f, 8.56368318e-02f, 1.30466774e-01f, -1.09369062e-01f,
  2.58255433e-02f, -6.52071163e-02f, -6.02916144e-02f, -1.38727101e-02f, -2.34502144e-02f, 1.61898494e-01f, -1.66558716e-02f, -2.33647048e-01f, 7.42404908e-02f, -1.37174547e-01f,
  -1.64189026e-01f, -8.37160349e-02f, 1.90666784e-02f, 7.00697675e-02f, -8.36709067e-02f, -3.11211403e-02f, -2.91437712e-02f, -3.86036858e-02f, -3.69502716e-02f, 1.42901735e-02f,
  -1.52660355e-01f, -6.61168993e-02f, 2.14291271e-03f, -3.47743966e-02f, 6.35806844e-02f, 3.72096449e-02f, 1.49313845e-02f, 9.58071500e-02f, 9.66421217e-02f, -6.84154257e-02f,
  -1.82858914e-01f, -2.65883148e-01f, -5.88743128e-02f, 5.65881492e-04f, 3.80844697e-02f, -6.05642945e-02f, -8.94835517e-02f, 6.52837604e-02f, -2.91311350e-02f, -1.54360067e-02f,
  -1.67434849e-02f, -1.36536464e-01f, -8.16382989e-02f, 1.25504136e-01f, -3.32825072e-02f, -7.10384222e-03f, -8.73808190e-02f, -1.48332030e-01f, -5.42125180e-02f, -1.51811726e-02f,
  -8.87072757e-02f, -7.91426152e-02f, -1.42822579e-01f, 8.58633444e-02f, -3.82560045e-02f, -1.05136804e-01f, -2.59041730e-02f, 2.41508335e-02f, -7.64654391e-03f, 1.24104410e-01f,
  -9.60354507e-02f, -2.39041105e-01f, 2.50059485e-01f, -2.58572370e-01f, 4.27522548e-02f, -8.44419226e-02f, 2.87944973e-01f, -2.14685604e-01f, -1.74801916e-01f, -3.34613323e-01f,
  4.39238138e-02f, 3.76454405e-02f, 1.82359979e-01f, -2.36592323e-01f, 4.35690135e-01f, 1.78817838e-01f, -1.71652257e-01f, -2.27094498e-02f, 4.87597659e-02f, -1.70957908e-01f,
  9.00937095e-02f, -1.01820521e-01f, 2.47775808e-01f, -1.87442973e-01f, 5.30398488e-02f, -6.84061274e-02f, 1.52979642e-01f, 1.55722991e-01f, -2.36907586e-01f, 4.21361849e-02f,
  -8.31531435e-02f, -1.56761363e-01f, 2.19837315e-02f, -6.10952862e-02f, -4.76813242e-02f, -7.61118578e-03f, 5.83470613e-03f, 8.28067213e-02f, -1.33434394e-02f, -1.01317570e-01f,
  5.81587926e-02f, -6.93188831e-02f, -6.39181435e-02f, 8.88521783e-03f, -8.52216929e-02f, -1.64578035e-01f, 9.49514564e-03f, -5.64125106e-02f, -5.73139079e-02f, 3.90958786e-02f,
  7.54275173e-02f, 8.63799229e-02f, 6.63582534e-02f, -4.66686813e-03f, 9.40981880e-02f, 1.95189323e-02f, -6.16256632e-02f, 7.05189779e-02f, 2.26017218e-02f, -1.76657289e-01f,
  6.55799955e-02f, 6.13130219e-02f, 5.00756167e-02f, -4.75776428e-03f, -1.56151522e-02f, 3.44344079e-02f, -3.45097184e-02f, 1.18139096e-01f, 3.46067101e-02f, 6.34277314e-02f,
  4.38969657e-02f, 6.04026532e-03f, 4.34206128e-02f, 9.54652578e-02f, 5.16917333e-02f, -1.65887907e-01f, -8.12192075e-03f, 5.74396290e-02f, 7.10439608e-02f, 2.97532957e-02f,
  3.70913669e-02f, 3.82582806e-02f, 1.53629288e-01f, -4.13299166e-03f, 5.86148128e-02f, -3.79479341e-02f, -1.94279626e-02f, 7.02575734e-03f, -9.15088598e-03f, 1.08833807e-02f,
  -1.30744234e-01f, -3.59753579e-01f, 6.53237328e-02f, 2.58925818e-02f, -1.73612908e-02f, -5.98311312e-02f, 4.44208309e-02f, -6.50130138e-02f, -5.55803627e-02f, 3.83082889e-02f,
  -2.60574240e-02f, 4.74329405e-02f, 6.32976443e-02f, -2.01520678e-02f, 2.75006425e-02f, 5.10214120e-02f, -4.98136953e-02f, -5.26466072e-02f, 2.38860734e-02f, -2.84420401e-02f,
  5.75077869e-02f, 3.98370175e-04f, 3.71687189e-02f, 3.02329548e-02f, -1.75526783e-01f, 3.70826684e-02f, -9.59308594e-02f, 4.30657528e-02f, 3.79343033e-02f, 3.20874676e-02f,
  1.16069913e-01f, 4.13715780e-01f, 3.50686997e-01f, 2.08429351e-01f, -3.15892100e-01f, -7.02714682e-01f, -3.39227676e-01f, -7.88287297e-02f, 1.24421760e-01f, 1.50021031e-01f,
  -3.22631806e-01f, 6.33584738e-01f, -1.31654859e-01f, 1.37049286e-02f, -4.42152143e-01f, -1.16432264e-01f, -1.10899732e-01f, 8.55462532e-03f, 2.15044729e-02f, -1.63580477e-02f,
  3.57012302e-02f, -5.74787915e-01f, -1.54611105e-02f, -3.22258443e-01f, -8.78853276e-02f, 3.11862826e-01f, -3.77562903e-02f, -2.10753337e-01f, 2.42131472e-01f, -1.85786635e-01f,
  -2.16191094e-02f, 1.99320704e-01f, 1.99317411e-01f, 1.38906330e-01f, 3.24648945e-03f, -4.21544425e-02f, -3.21004540e-02f, -6.10742196e-02f, 1.01596445e-01f, 1.41290110e-02f,
  1.02875642e-01f, 9.43433866e-02f, -7.21429065e-02f, -7.27448985e-02f, 5.08391187e-02f, 1.20176002e-01f, 2.17869595e-01f, -1.33589450e-02f, 1.52680725e-01f, -1.83008369e-02f,
  -1.91039685e-02f, 8.61829892e-02f, 4.76823598e-02f, 1.65681034e-01f, 4.87843454e-02f, -4.48396280e-02f, -1.71415806e-02f, 1.35515317e-01f, 5.54490946e-02f, 1.69971615e-01f,
  -3.65432203e-02f, 6.71422435e-03f, -8.34869817e-02f, 1.20442092e-01f, 3.04769003e-03f, -2.17555482e-02f, 7.59273593e-04f, -1.39705688e-02f, 1.84340328e-02f, -7.54499212e-02f,
  -7.46229617e-03f, 2.67138835e-02f, 3.90529111e-02f, 2.33177058e-02f, -8.65738932e-03f, 1.48160215e-02f, 2.45017931e-02f, 8.93713087e-02f, -1.05391247e-02f, -1.04101188e-02f,
  3.22602503e-03f, 2.80453097e-02f, 9.17307138e-02f, -6.75103515e-02f, -1.55603617e-01f, 4.98748310e-02f, 1.00186154e-01f, 1.39411792e-01f, -9.50240120e-02f, -4.34573442e-02f,
  -1.25188241e-02f, 1.71900108e-01f, -8.89426917e-02f, -7.45474547e-02f, -2.49439329e-02f, -4.59402762e-02f, 1.27812833e-01f, 8.95505771e-02f, 8.18744826e-04f, -7.16692656e-02f,
  -5.73947327e-03f, -5.65784499e-02f, 4.15425263e-02f, -1.78211331e-02f, -2.02819258e-02f, -2.41193660e-02f, -1.05404174e-02f, 8.33736137e-02f, 4.57397327e-02f, 8.49115327e-02f,
  6.53322116e-02f, 5.16180806e-02f, 6.88518807e-02f, -5.70014119e-03f, 7.40871504e-02f, -6.58591539e-02f, 9.36925039e-02f, 1.72299281e-01f, 7.63644427e-02f, 1.09016635e-01f,
  -2.79590279e-01f, 2.41492316e-01f, -2.07503047e-03f, -1.24713585e-01f, 5.73160462e-02f, -4.38697070e-01f, -2.08723158e-01f, 8.24360922e-02f, -1.45705327e-01f, 1.77565023e-01f,
  -1.39640242e-01f, 2.18120560e-01f, 5.51646985e-02f, -3.25985998e-01f, -9.00532305e-01f, -3.20527762e-01f, -5.06456435e-01f, -1.04965940e-01f, -1.43362314e-01f, 3.12123336e-02f,
  -2.39946678e-01f, -2.26752996e-01f, -3.75260353e-01f, 3.94516066e-02f, 1.73514843e-01f, 2.52204299e-01f, 1.21530809e-01f, 2.23271579e-01f, 9.72671062e-02f, 5.19764237e-03f,
  -2.19208881e-01f, 2.49031067e-01f, 2.72877991e-01f, -2.62232940e-03f, -8.63077268e-02f, 5.71556687e-02f, 8.84916261e-02f, -2.20621936e-02f, -4.18461934e-02f, 6.86548725e-02f,
  6.62276521e-02f, -6.77488521e-02f, -6.28732890e-02f, -7.97853023e-02f, 6.20692298e-02f, 8.42694417e-02f, 3.37880254e-02f, -7.69312978e-02f, 4.45788093e-02f, 9.34955031e-02f,
  3.85117754e-02f, 2.20093988e-02f, 1.35230824e-01f, -2.88251489e-02f, -4.26330306e-02f, 5.25485016e-02f, -7.57559240e-02f, 3.14979739e-02f, 1.28540117e-02f, -3.47617902e-02f,
  -4.40653525e-02f, -1.15883360e-02f, -1.82378870e-02f, -6.40286580e-02f, 8.49768668e-02f, -3.19933146e-02f, -7.49140829e-02f, 2.74198217e-04f, 3.14673223e-02f, -8.56908690e-03f,
  5.78233115e-02f, 2.69917864e-02f, 3.97972912e-02f, -7.19149248e-04f, -1.72530822e-02f, -1.35503700e-02f, -3.77466120e-02f, 5.91305979e-02f, -1.30446672e-01f, -1.76561158e-02f,
  4.49221209e-02f, 1.72346141e-02f, 4.80551720e-02f, -2.38386244e-02f, -4.30568233e-02f, 1.11659758e-01f, -4.54898737e-02f, 1.80193763e-02f, 7.47527033e-02f, 2.36426871e-02f,
  3.58258672e-02f, 1.97878659e-01f, -9.50956121e-02f, 1.18564209e-02f, -2.72407494e-02f, -8.48226547e-02f, -7.69522637e-02f, -8.55310783e-02f, -5.87564483e-02f, -7.77323321e-02f,
  3.77566591e-02f, 3.76423746e-02f, 1.47620328e-02f, -7.24227494e-03f, -1.00324191e-01f, -1.23523958e-01f, 3.43810022e-02f, 5.46693094e-02f, 8.02891701e-02f, -7.69272298e-02f,
  1.21381305e-01f, 1.25881592e-02f, -6.75764903e-02f, -9.67039466e-02f, 5.21667441e-03f, -3.72058270e-03f, 2.25414857e-02f, -1.16155267e-01f, 4.07684855e-02f, -1.00836702e-01f,
  -9.30050388e-02f, 1.50194034e-01f, -1.02860324e-01f, -3.74774933e-01f, -9.51808318e-02f, -4.18064684e-01f, -4.93448645e-01f, -3.97978202e-02f, 1.31180495e-01f, -2.68158317e-01f,
  -1.09353088e-01f, 4.49318327e-02f, 3.59093882e-02f, -2.43342236e-01f, 7.51810148e-02f, 3.67599889e-03f, -3.16730946e-01f, -2.06425875e-01f, -8.44748877e-03f, -2.23840594e-01f,
  -8.95715132e-02f, -3.44446003e-01f, -1.87154308e-01f, 1.79607584e-03f, -2.63923496e-01f, -1.65305972e-01f, 1.72284059e-02f, -1.60054024e-02f, 1.94134153e-02f, 1.66233793e-01f,
  -2.70363092e-01f, -1.70982316e-01f, -9.58388969e-02f, -4.92378436e-02f, -1.72588900e-01f, 8.17463994e-02f, 3.72586481e-04f, -7.17018964e-03f, -7.83276111e-02f, -1.42090255e-02f,
  -6.52491078e-02f, 1.81390733e-01f, 2.89792311e-03f, 6.32529557e-02f, -1.10888764e-01f, 1.48676438e-02f, -5.46819903e-02f, 4.51712357e-03f, -1.43430665e-01f, 3.44791710e-02f,
  3.08641475e-02f, -1.37834132e-01f, -8.40441510e-02f, -3.80040482e-02f, 6.48932680e-02f, 5.88468276e-02f, -1.22178886e-02f, 8.58084336e-02f, -3.02533284e-02f, -4.86542098e-02f,
  2.04638913e-02f, 3.48207913e-02f, -5.07040471e-02f, 7.64994398e-02f, -7.55599216e-02f, 6.27997965e-02f, -8.55153948e-02f, 1.41068106e-03f, -8.86742771e-03f, -7.22507089e-02f,
  4.94496636e-02f, -2.03827582e-02f, 1.67913847e-02f, -1.17131639e-02f, -2.06029758e-01f, 5.20281307e-02f, -4.03303914e-02f, 5.60289212e-02f, -9.60327983e-02f, 2.48089116e-02f,
  1.25470191e-01f, 2.08067335e-02f, -2.42626183e-02f, -3.16011123e-02f, -2.55800206e-02f, 3.78457680e-02f, -1.12212216e-03f, 8.11789855e-02f, -6.51863664e-02f, -2.03987937e-02f,
  -3.50553781e-01f, -3.32965463e-01f, 4.98134792e-02f, -8.30729082e-02f, 5.27343713e-02f, -5.30841127e-02f, -9.42657217e-02f, 5.74916489e-02f, -6.47211820e-02f, -7.09956437e-02f,
  -3.92160378e-02f, -1.48870930e-01f, -5.02229705e-02f, 3.40489857e-02f, 3.79277207e-02f, 1.03675827e-01f, -1.79048497e-02f, -1.41251102e-01f, -7.95454457e-02f, 1.45382574e-02f,
  -4.59308140e-02f, 4.87173945e-02f, 7.71888420e-02f, -1.21347010e-01f, 3.09210103e-02f, -5.45931458e-02f, 1.15200561e-02f, 9.27015021e-03f, -3.16933207e-02f, 1.83182098e-02f,
  -1.18652508e-01f, -1.81695864e-01f, -1.52347669e-01f, -3.20608914e-01f, 1.37804464e-01f, -2.54912585e-01f, -1.66153178e-01f, -3.92124414e-01f, -1.35310024e-01f, -2.91471660e-01f,
  -7.32809976e-02f, 1.30560130e-01f, 2.41229504e-01f, -3.05466473e-01f, 3.58814269e-01f, 2.20041797e-01f, -3.43340248e-01f, -2.25053638e-01f, 6.55587241e-02f, -2.45229751e-01f,
  -1.15671799e-01f, -2.58878738e-01f, 3.41513455e-02f, -1.01845354e-01f, -1.42936945e-01f, -1.72156125e-01f, 5.68061620e-02f, 1.73478961e-01f, -1.41600311e-01f, 2.98061464e-02f,
  5.89865185e-02f, -2.82691307e-02f, 5.20820767e-02f, -5.38304672e-02f, -5.54897711e-02f, -2.35893074e-02f, -6.25525936e-02f, 9.64902490e-02f, 6.46760985e-02f, 6.54295832e-02f,
  -6.56088628e-03f, -1.29290983e-01f, -7.38923326e-02f, -7.32465312e-02f, -1.16591156e-01f, 1.09656267e-01f, 5.99732734e-02f, 1.07060626e-01f, -2.40202527e-02f, 5.29297590e-02f,
  1.38399741e-02f, -1.83412451e-02f, -1.45115778e-01f, -9.07529593e-02f, -4.83486131e-02f, -7.13245943e-02f, 2.14972068e-02f, 6.55474439e-02f, -3.61298509e-02f, -1.09416023e-02f,
  -1.00275502e-01f, -6.72120675e-02f, 7.09005594e-02f, -1.37917742e-01f, 2.65271682e-02f, -3.31226513e-02f, -8.85563623e-03f, -1.01052508e-01f, -9.29391384e-02f, -1.89744249e-01f,
  -6.79152086e-02f, -9.34515148e-03f, 7.92289898e-03f, -1.44680440e-01f, -8.02453458e-02f, 9.19352770e-02f, 6.01312378e-03f, -7.43607357e-02f, -5.22194803e-02f, -3.63920331e-02f,
  -1.69636644e-02f, -7.94115290e-02f, -3.70669588e-02f, -5.03271967e-02f, -4.85653989e-02f, 1.08084686e-01f, -4.60697487e-02f, -3.39642502e-02f, 1.23015918e-01f, 5.18529415e-02f,
  -4.75198217e-02f, -2.16022938e-01f, -6.63191155e-02f, 1.55951194e-02f, 1.93813927e-02f, -3.21716741e-02f, 2.97345128e-02f, -6.20831922e-02f, -5.28485142e-02f, 1.31395168e-03f,
  -1.52921915e-01f, -7.03007206e-02f, 2.66907625e-02f, 7.37055689e-02f, 1.91853717e-02f, 2.99835969e-02f, 4.66162898e-02f, 2.41196640e-02f, -4.50963452e-02f, -1.81565713e-02f,
  -8.13684240e-02f, 3.26839928e-03f, -6.45675361e-02f, 2.41267923e-02f, -3.63953784e-02f, -5.52034006e-02f, 3.00328266e-02f, -1.10048302e-01f, 4.66872081e-02f, 1.25367905e-03f,
  3.29724729e-01f, 1.91716477e-02f, 6.37451708e-01f, 8.37650076e-02f, 5.30093946e-02f, 2.65081644e-01f, 4.92078066e-01f, -6.84419414e-04f, 3.18545938e-01f, -2.45266736e-01f,
  -1.34651110e-01f, 5.02355322e-02f, 1.61033958e-01f, -2.24430114e-01f, 2.10439771e-01f, 2.50394326e-02f, -5.60692325e-02f, -4.52919453e-02f, 1.07757986e-01f, 9.44385305e-02f,
  1.01990297e-01f, -2.51979202e-01f, 5.30694649e-02f, -2.76614994e-01f, -5.99151701e-02f, -4.27170889e-03f, -5.06374300e-01f, 1.05705164e-01f, -3.73196155e-01f, -2.06369180e-02f,
  -5.79663925e-02f, 2.71122307e-02f, -2.98991892e-02f, 9.78609845e-02f, 4.84706182e-03f, 1.08475335e-01f, 4.14331965e-02f, 1.07967444e-01f, 2.45091934e-02f, -8.67011398e-03f,
  -5.50399907e-03f, -3.86608057e-02f, -4.96878214e-02f, -2.16545425e-02f, 6.82083517e-02f, 2.17271317e-02f, -9.42757633e-03f, 8.36980045e-02f, 2.57690251e-02f, 1.06518634e-01f,
  3.36878523e-02f, -9.88991186e-03f, -9.65443265e-04f, -5.82309300e-03f, -5.81256626e-03f, 3.89153361e-02f, 1.04496069e-01f, 7.84981716e-03f, -6.35297075e-02f, 1.60841793e-02f,
  -9.92525276e-03f, 9.35832933e-02f, -2.98133716e-02f, -7.91878849e-02f, -5.30168563e-02f, -2.52693556e-02f, -7.29123056e-02f, -6.92063570e-02f, 1.07492939e-01f, -6.57394528e-02f,
  -3.97824943e-02f, -5.55385761e-02f, 2.15207934e-02f, 1.95465945e-02f, 1.11207366e-01f, -2.90780049e-02f, 7.21872002e-02f, -1.23934798e-01f, 6.72343969e-02f, -2.71257223e-03f,
  3.79077569e-02f, 1.57397764e-03f, -1.36662140e-01f, 5.61757851e-03f, 1.19675718e-01f, 1.13899238e-01f, -7.39106759e-02f, -6.24239957e-03f, 4.38635014e-02f, -2.53721401e-02f,
  -1.96808815e-01f, 9.71707702e-02f, -8.25961530e-02f, -1.06516751e-02f, -4.96694669e-02f, -1.15383081e-01f, 8.01201793e-04f, -5.59850559e-02f, 1.72525924e-03f, 4.22498360e-02f,
  3.46383788e-02f, -7.13720499e-03f, 5.38846962e-02f, -4.87151137e-03f, 2.46967655e-02f, -7.18487352e-02f, 5.93322441e-02f, -1.30425962e-02f, 5.32500185e-02f, -5.58993518e-02f,
  3.70230936e-02f, -5.53525891e-03f, -2.62992419e-02f, -3.93409915e-02f, -8.08195993e-02f, -4.08656858e-02f, 5.62331378e-02f, -1.10132895e-01f, -1.05024250e-02f, 1.58144496e-02f,
  -1.44704161e-02f, -2.43260607e-01f, 3.23678166e-01f, 2.21004263e-01f, -2.37752572e-01f, -4.00180757e-01f, -5.33731580e-01f, -9.08224881e-02f, -2.51212239e-01f, -2.99902916e-01f,
  4.79594842e-02f, -2.04378769e-01f, -2.13543817e-01f, 8.68563503e-02f, 3.02269489e-01f, -2.57893503e-01f, 8.67927521e-02f, -1.57337308e-01f, 3.49103175e-02f, 7.48870298e-02f,
  2.69802511e-01f, 3.58119048e-03f, 3.89209032e-01f, 2.30820194e-01f, -8.92301276e-02f, 2.58404285e-01f, 4.08023775e-01f, 2.83944458e-01f, 3.72240305e-01f, 1.38866931e-01f,
  -3.79824117e-02f, -1.02040738e-01f, 2.34949049e-02f, 4.14973944e-02f, -1.23890124e-01f, 2.33858055e-03f, -6.50103344e-03f, -1.60528384e-02f, 3.96016277e-02f, 4.12978120e-02f,
  -5.48712984e-02f, 6.88029751e-02f, 1.86594725e-02f, -3.10804043e-02f, -8.42551887e-02f, 6.72732666e-02f, 4.86809425e-02f, 5.23727713e-03f, -5.13276830e-02f, -1.10690026e-02f,
  2.26803534e-02f, -7.09759369e-02f, 5.26795015e-02f, 4.19825800e-02f, 5.93029335e-02f, -9.96800140e-03f, -2.53110770e-02f, 3.30633521e-02f, 8.20250511e-02f, 4.95084422e-03f,
  -7.91231766e-02f, 1.83049291e-02f, -7.11299106e-02f, 7.05199018e-02f, -8.45573004e-03f, 6.64421916e-02f, -5.73105253e-02f, 2.93470901e-02f, 3.67249101e-02f, -8.37978050e-02f,
  1.39874175e-01f, -9.50868800e-02f, 4.63063084e-02f, -6.44424856e-02f, -2.91291755e-02f, -7.88703784e-02f, -2.03008167e-02f, -2.88348068e-02f, 3.10062151e-02f, -4.74020243e-02f,
  -8.43368620e-02f, -6.50758250e-03f, 5.17809838e-02f, -4.33918387e-02f, 5.33205494e-02f, 1.46897705e-02f, 2.73778150e-03f, 1.84934475e-02f, -2.11448055e-02f, -2.90328618e-02f,
  -8.69622007e-02f, 3.87529992e-02f, 8.30474123e-03f, -7.76515529e-02f, 4.78997193e-02f, -4.59227115e-02f, 7.56420717e-02f, 7.51992464e-02f, 6.43610284e-02f, -4.35628183e-02f,
  1.51732769e-02f, -4.42132130e-02f, 5.35762077e-03f, -6.15123622e-02f, 7.92157874e-02f, -3.35058980e-02f, 3.48690785e-02f, 3.76785025e-02f, 8.92600492e-02f, -1.61229856e-02f,
  1.97324399e-02f, -6.49295077e-02f, 7.94525295e-02f, -6.23803362e-02f, 2.35358961e-02f, -8.53938684e-02f, -5.50568141e-02f, -6.02224283e-02f, -8.60637228e-04f, -1.91754499e-03f,
  2.68712252e-01f, 9.53202173e-02f, 1.61436528e-01f, 1.61469907e-01f, -5.63421585e-02f, -2.92780489e-01f, -2.56514937e-01f, 8.13176334e-02f, -1.98980451e-01f, -7.01683294e-03f,
  1.22329831e-01f, -4.23130505e-02f, 1.20754711e-01f, 1.29381612e-01f, 2.49373674e-01f, -3.57133180e-01f, 3.26591045e-01f, -2.04059526e-01f, -6.05855174e-02f, 2.33058006e-01f,
  -4.70525920e-02f, 1.83742151e-01f, 1.57567665e-01f, 1.04991220e-01f, 2.12363929e-01f, 2.26418506e-02f, 2.72856236e-01f, 1.21439965e-02f, 1.98617771e-01f, 1.76531810e-03f,
  -8.91867001e-03f, 1.89838428e-02f, 4.07465324e-02f, 6.70177862e-03f, 7.78311417e-02f, 7.11129829e-02f, -7.86943361e-02f, -4.96044271e-02f, 4.57031131e-02f, -5.10163233e-02f,
  -1.34499352e-02f, 5.17853573e-02f, -2.35805586e-02f, 1.76413450e-02f, -1.14726625e-01f, 2.45598778e-02f, -2.79130898e-02f, 3.90690379e-02f, -3.01475823e-02f, 6.21604957e-02f,
  -7.55872428e-02f, -3.90200019e-02f, -6.96009174e-02f, -9.20928791e-02f, 6.14520125e-02f, 1.13176778e-01f, -9.11458954e-02f, -1.01613151e-02f, -1.12794481e-01f, -7.71305263e-02f,
  1.65206511e-02f, -2.95424424e-02f, 3.81196029e-02f, 1.87379215e-03f, 2.60092281e-02f, 1.99216828e-02f, -4.62589972e-02f, -5.65402722e-03f, 3.82752828e-02f, 9.93568897e-02f,
  -4.03402597e-02f, -6.06958680e-02f, -3.93443368e-02f, -7.47498199e-02f, -1.50516042e-02f, -2.86720395e-02f, -3.76708172e-02f, 4.54913601e-02f, -8.70073438e-02f, -7.27159455e-02f,
  4.48654369e-02f, 3.85830435e-03f, -2.03308016e-02f, -3.97939533e-02f, 4.65926388e-03f, 4.91685756e-02f, -1.19439047e-02f, 4.34414372e-02f, -6.75538108e-02f, -3.76258530e-02f,
  7.87076056e-02f, 1.79116681e-01f, -6.14949130e-02f, -6.75928369e-02f, -4.39205915e-02f, -2.97336932e-02f, 4.41160277e-02f, 4.92943972e-02f, 1.60207257e-01f, 6.57892972e-02f,
  1.06661171e-01f, 6.60404637e-02f, 1.46067357e-02f, 6.96398541e-02f, -4.30075862e-02f, 6.12612516e-02f, -1.83377713e-02f, -7.96925798e-02f, 5.43186963e-02f, 9.41594690e-02f,
  1.23267835e-02f, 1.70465931e-02f, -2.08449345e-02f, -5.36813494e-03f, -3.18193734e-02f, -1.21937104e-01f, -9.37961340e-02f, 1.77947991e-02f, 3.68879251e-02f, -1.85007742e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  5.60663827e-03f, 4.58134025e-01f, -5.19855246e-02f, 4.06107455e-01f, 1.87936008e-01f, -1.45790294e-01f, -1.04782023e-01f, 5.09420693e-01f, -2.28782579e-01f, -1.92931265e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.76412687e-01f, -2.89094150e-01f, -5.72154261e-02f, -3.97820145e-01f, -2.45822042e-01f, 2.08262041e-01f, 3.74970675e-01f, -1.05623811e-01f, -4.08559084e-01f, -6.06492758e-02f,
  -1.21251456e-01f, -3.24715860e-02f, -2.63009161e-01f, 3.87410894e-02f, -6.12181537e-02f, 3.68610471e-01f, -4.11452278e-02f, 1.90063506e-01f, 8.74879211e-02f, 2.82890826e-01f,
  -1.99512795e-01f, 2.44156554e-01f, -4.37394381e-02f, 8.28232691e-02f, 5.15134990e-01f, -2.91330785e-01f, -2.91066825e-01f, -3.79198104e-01f, -2.39833444e-01f, 1.45881012e-01f,
  -2.34826817e-03f, 1.11027636e-01f, 1.92652941e-01f, 1.20417334e-01f, -1.12688690e-01f, 4.63223219e-01f, 2.25716650e-01f, 5.55360429e-02f, -3.26385915e-01f, 6.79485779e-03f,
  -2.32246280e-01f, -6.95431530e-02f, 5.55104315e-01f, -3.21759969e-01f, -2.42357165e-01f, -3.51893455e-01f, 1.88381657e-01f, 1.46520108e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.03093901e-01f, 4.33059216e-01f, 3.08162302e-01f, -7.98136532e-01f, -5.89699030e-01f, -2.59259343e-01f, -1.59483686e-01f, 6.81117952e-01f, 1.09656597e-03f, 6.34861231e-01f,
  2.21979707e-01f, 2.74043590e-01f, -4.94250581e-02f, 1.06033695e+00f, 1.58881292e-01f, 4.48772758e-01f, 2.20245123e-01f, 3.29105616e-01f, 6.57116845e-02f, -4.37052190e-01f,
  -4.46053386e-01f, -3.92726362e-01f, -2.50635445e-01f, -5.09114683e-01f, -2.87265062e-01f, -3.43524069e-01f, -2.93852657e-01f, -1.18670121e-01f, -1.60899997e-01f, -3.04282397e-01f,
  8.14766169e-01f, 3.51933151e-01f, -2.73045897e-01f, 5.44510186e-01f, 4.86736447e-01f, 2.84400791e-01f, -8.78995508e-02f, -5.44860542e-01f, 3.27529550e-01f, -5.91643974e-02f,
  4.66749489e-01f, 2.85865039e-01f, -2.73837801e-02f, 5.17766356e-01f, 6.02876663e-01f, 7.32644275e-02f, -2.51024276e-01f, -1.89310938e-01f, -1.57703720e-02f, -5.76170813e-03f,
  4.85119939e-01f, -7.86615789e-01f, -4.70184803e-01f, -3.14336717e-01f, -2.58010566e-01f, 1.11022256e-01f, -2.88282096e-01f, 5.65852284e-01f, 1.48303688e-01f, -2.67792940e-01f,
  -2.51120478e-01f, 4.50816244e-01f, 2.76419185e-02f, 5.43352485e-01f, 8.25153217e-02f, 4.28608179e-01f, 3.51918548e-01f, 5.36253393e-01f, -3.36106807e-01f, 6.11477137e-01f,
  7.26824164e-01f, 7.85247266e-01f, 4.48552221e-01f, -2.43515633e-02f, -4.90089394e-02f, 2.02892110e-01f, 7.59994239e-02f, 3.99064243e-01f, -6.56756153e-03f, -2.12463990e-01f,
  2.68489599e-01f, -1.71004105e-02f, 4.50078040e-01f, -3.00892562e-01f, 9.67682377e-02f, -5.01559794e-01f, -4.16618496e-01f, 2.62720615e-01f, 1.32860005e-01f, 6.65513098e-01f,
  7.91759968e-01f, 8.12974051e-02f, 4.99700606e-02f, 1.04085594e-01f, 1.37919188e-01f, 3.70618291e-02f, 2.26860121e-01f, 2.93821335e-01f, 5.24475932e-01f, -2.44804755e-01f,
  -4.00802821e-01f, -2.45845810e-01f, 2.72505075e-01f, -3.85857135e-01f, 6.07159197e-01f, 4.94319946e-01f, -1.69261128e-01f, 2.15419754e-01f, 4.48017120e-01f, 7.16560662e-01f,
  -2.72653461e-01f, 9.95158479e-02f, 7.46561885e-02f, 5.28106451e-01f, -1.17171891e-02f, 5.28756320e-01f, 3.74223322e-01f, -2.68720776e-01f, -1.47717804e-01f, 2.96293020e-01f,
  4.23115313e-01f, 4.28419054e-01f, 5.36550224e-01f, 8.23558927e-01f, 6.06711805e-01f, -1.54957235e-01f, -4.53685582e-01f, -1.38833821e-01f, 6.49942160e-02f, -1.58798635e-01f,
  3.03128690e-01f, -3.21481287e-01f, -4.56177033e-02f, -3.95684123e-01f, -1.26743659e-01f, 9.14444868e-03f, -2.77954608e-01f, 1.72302961e-01f, 2.22617075e-01f, -9.44147557e-02f,
  -3.37859780e-01f, -1.96685612e-01f, 6.50506139e-01f, 3.34817111e-01f, 2.56254107e-01f, 1.52568564e-01f, -2.26441026e-01f, 7.40331933e-02f, 8.21124971e-01f, -5.38710691e-02f,
  -3.07418466e-01f, 3.89865935e-01f, 2.35535249e-01f, 1.57484725e-01f, 8.91152501e-01f, 5.14978707e-01f, 3.01735461e-01f, -6.07422441e-02f, 6.48247898e-01f, 9.78973657e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  4.46244955e-01f, 2.95756787e-01f, -6.55962154e-02f, -8.07171129e-03f, 3.01536143e-01f, 1.77555457e-01f, 3.20715100e-01f, 8.54172483e-02f, 3.20463508e-01f, 2.22662657e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -6.65460229e-02f, 1.08164459e-01f, 2.91117411e-02f, 4.39079434e-01f, -2.05697089e-01f, -4.94467944e-01f, -7.61287734e-02f, -1.84611693e-01f, 3.62470031e-01f, -2.57296916e-02f,
  -2.85729676e-01f, -4.85331975e-02f, 4.68730122e-01f, 1.89503700e-01f, -2.98465818e-01f, -1.60957679e-01f, 3.99092352e-03f, 3.39116864e-02f, -3.30057979e-01f, -6.26039281e-02f,
  4.28027987e-01f, 3.04327816e-01f, 1.41929820e-01f, 3.88741970e-01f, -5.20311177e-01f, -2.46274024e-01f, 7.44482353e-02f, -3.22351269e-02f, -4.27264661e-01f, 3.62983532e-02f,
  -2.48772502e-02f, 2.06901580e-01f, 1.49421200e-01f, -2.10893929e-01f, 3.64604086e-01f, -5.10173976e-01f, 2.73509435e-02f, 3.49309564e-01f, 2.62225330e-01f, 1.65766969e-01f,
  -3.77506107e-01f, 5.18902361e-01f, -2.20901251e-01f, 1.69330925e-01f, -1.22661620e-01f, -2.86077440e-01f, 1.52596042e-01f, -2.16897085e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.18949509e-01f, 6.25006258e-01f, 4.74937856e-01f, 3.89799595e-01f, 2.83429235e-01f, 4.23264414e-01f, 5.12323976e-01f, 8.30512166e-01f, -4.67096686e-01f, 4.45867687e-01f,
  3.88484627e-01f, -8.67690295e-02f, -3.62313926e-01f, -3.03494707e-02f, 5.22294223e-01f, 1.15680203e-01f, 4.52299178e-01f, 3.46191674e-01f, 4.09250736e-01f, 2.17040315e-01f,
  -2.17914701e-01f, 6.34629607e-01f, 2.22384602e-01f, 1.08493984e+00f, -3.05169791e-01f, 2.25512594e-01f, -2.42948472e-01f, 2.93995470e-01f, -1.33024588e-01f, -2.92458087e-01f,
  6.78419054e-01f, 5.03055096e-01f, -7.01379254e-02f, -7.37320423e-01f, 1.71166718e-01f, -8.25939834e-01f, -7.72404909e-01f, 3.64287257e-01f, 3.38432491e-01f, -7.50973880e-01f,
  5.77965140e-01f, 2.20274612e-01f, -3.08037102e-01f, 5.88053226e-01f, 3.30369800e-01f, 8.35381627e-01f, -2.72184789e-01f, 3.55005473e-01f, 1.73279509e-01f, -4.51132476e-01f,
  -1.37832448e-01f, -5.59360623e-01f, -2.90407181e-01f, -2.78825849e-01f, 3.96684349e-01f, -6.53642356e-01f, 7.05998480e-01f, 6.86170608e-02f, 5.81986785e-01f, 5.56966849e-02f,
  2.79185474e-01f, 5.22410512e-01f, -4.06369001e-01f, 1.85838059e-01f, -2.28560299e-01f, 1.22586437e-01f, -1.23317093e-01f, 4.58709538e-01f, -1.24443270e-01f, -3.09417158e-01f,
  2.82019049e-01f, 2.56870538e-01f, 2.14821443e-01f, 6.37949824e-01f, -1.49793074e-01f, 1.61247686e-01f, 5.87337911e-01f, -2.33024105e-01f, 2.81623453e-01f, -1.04298890e-01f,
  2.78151393e-01f, 3.54633182e-01f, 5.01393259e-01f, -4.41633403e-01f, -3.16117555e-02f, 2.93429583e-01f, 5.39906085e-01f, -2.63748970e-02f, 3.69651914e-01f, -3.85859966e-01f,
  7.30591595e-01f, 2.99881697e-01f, -2.42316827e-01f, 6.25326335e-01f, -2.71034688e-02f, 6.93571091e-01f, 3.02364051e-01f, 8.61114502e-01f, 7.30878770e-01f, 8.93445790e-01f,
  6.69747114e-01f, -1.03241217e+00f, 4.39931482e-01f, 1.88578859e-01f, 3.38555843e-01f, 2.31778949e-01f, 8.62802744e-01f, 7.01787323e-02f, 8.44910204e-01f, -9.55496728e-02f,
  7.75717944e-02f, -4.25817758e-01f, -2.00493097e-01f, -3.47827256e-01f, -3.54514062e-01f, -8.07286277e-02f, -2.40284711e-01f, -7.44936287e-01f, 7.42418051e-01f, -2.03271076e-01f,
  6.51886106e-01f, 3.43136638e-01f, 2.59768814e-01f, 2.08218232e-01f, 1.07431209e+00f, 5.04354537e-01f, 4.92985249e-02f, 7.21611008e-02f, 1.22324355e-01f, 1.90955792e-02f,
  1.48570407e-02f, -4.80448812e-01f, -7.09877610e-01f, 8.81068110e-01f, 2.86116183e-01f, 2.39496648e-01f, -2.69260108e-01f, 3.65220755e-01f, -1.84325710e-01f, 8.21225464e-01f,
  -2.36349791e-01f, 5.37350833e-01f, 7.06215382e-01f, 8.12948942e-01f, 2.53058225e-01f, 2.01627195e-01f, 1.59816995e-01f, 5.36544085e-01f, -3.24078500e-01f, -1.24953359e-01f,
  7.32651949e-01f, 6.53676748e-01f, -4.64049339e-01f, 8.70073557e-01f, -3.17024946e-01f, 2.96190679e-01f, 2.08040878e-01f, -5.58876514e-01f, 5.10683119e-01f, -3.46581750e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.64057159e-01f, 3.03858340e-01f, -1.37804493e-01f, 1.05176322e-01f, -2.40645766e-01f, 5.17917454e-01f, 5.01146853e-01f, 9.42191258e-02f, 2.51829833e-01f, 3.82206857e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.26271799e-01f, 3.42717141e-01f, -2.19949812e-01f, -4.08584960e-02f, -6.78812116e-02f, 3.62912983e-01f, 2.80033559e-01f, -1.45855218e-01f, 6.16647154e-02f, -1.87791988e-01f,
  -6.23757243e-02f, -7.71130174e-02f, -2.13569865e-01f, 2.70287227e-02f, 1.01568371e-01f, 3.29647481e-01f, 1.71099082e-01f, 3.07690501e-01f, 2.14531552e-02f, -3.00003648e-01f,
  4.20917541e-01f, 5.01636863e-01f, 6.29067793e-02f, 1.69586942e-01f, -3.55893582e-01f, -1.93275481e-01f, 6.38563186e-02f, -6.18446022e-02f, -1.91892743e-01f, 7.62730315e-02f,
  8.42418671e-02f, 2.26146877e-01f, -3.76293302e-01f, -4.06701386e-01f, 2.36325875e-01f, 1.45181581e-01f, 1.97058216e-01f, -4.66940075e-01f, -4.18165885e-02f, -8.88518840e-02f,
  2.20119618e-02f, 1.37403190e-01f, 1.65289357e-01f, 1.96888775e-01f, 1.67085618e-01f, -7.50549734e-02f, -2.23689675e-01f, -3.27611953e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  1.06267542e-01f, 2.40315691e-01f, 4.81616020e-01f, -5.08057848e-02f, 8.78496617e-02f, 3.64210486e-01f, 7.99504697e-01f, 5.79163730e-01f, -5.82980216e-01f, -5.07722557e-01f,
  3.62458795e-01f, 6.93824366e-02f, 6.29411042e-01f, -2.16736346e-01f, 3.94704342e-01f, 9.54386234e-01f, -3.23996842e-01f, -5.37240148e-01f, -5.60708582e-01f, 8.46310735e-01f,
  -4.13353115e-01f, 5.29784203e-01f, -3.76995414e-01f, -2.63659030e-01f, 8.60821187e-01f, 5.45109868e-01f, 5.92394352e-01f, -7.30533749e-02f, 2.05089703e-01f, 8.74515176e-01f,
  2.88221687e-01f, 7.06876576e-01f, 4.49484140e-01f, 4.58480656e-01f, 4.35859352e-01f, -8.88739228e-01f, 4.89444166e-01f, 2.46308982e-01f, 1.36953250e-01f, 5.05405217e-02f,
  9.70799685e-01f, 6.60211444e-01f, -5.63091636e-01f, 9.54622209e-01f, -4.74707842e-01f, 2.38465786e-01f, 6.94732487e-01f, -5.15521169e-01f, 6.44768476e-01f, 1.07303393e+00f,
  5.22303939e-01f, -7.20618546e-01f, 4.28415418e-01f, 5.24217248e-01f, 8.88133466e-01f, 8.32293212e-01f, -2.88309693e-01f, -1.13996826e-01f, -1.74255833e-01f, 4.62175101e-01f,
  3.73557031e-01f, -3.64324093e-01f, 4.09427047e-01f, 4.95773196e-01f, -6.19234860e-01f, -4.27551031e-01f, -2.94187427e-01f, -3.63658130e-01f, 5.01357138e-01f, -5.56005239e-01f,
  2.76090711e-01f, 5.22344291e-01f, -4.72874232e-02f, -2.02133536e-01f, 6.81456253e-02f, 2.15075195e-01f, -6.24731600e-01f, -4.61448170e-02f, 5.73939919e-01f, 2.86141634e-01f,
  -6.03385627e-01f, -9.61523592e-01f, -1.10229516e+00f, 6.76732659e-01f, -4.68262374e-01f, -8.00431550e-01f, 8.30473937e-03f, 2.93643922e-02f, -5.66628240e-02f, 3.12131226e-01f,
  6.79133952e-01f, 8.32977295e-02f, 3.87567788e-01f, 6.24499679e-01f, -1.13031462e-01f, 2.76944667e-01f, 9.17445958e-01f, 7.37458467e-01f, 3.62278461e-01f, 4.77352440e-01f,
  -8.07789385e-01f, 2.01506287e-01f, 5.06502867e-01f, 2.25412901e-02f, -5.19378960e-01f, 3.31855148e-01f, 1.48987830e-01f, 1.31113723e-01f, 1.05148780e+00f, 3.03180933e-01f,
  -3.29052985e-01f, 3.87811214e-01f, 1.92062035e-02f, -1.47668615e-01f, 3.63889784e-01f, 6.95761383e-01f, -3.99207830e-01f, -9.36776936e-01f, -2.15918869e-01f, -6.48443997e-01f,
  8.17584246e-02f, 5.10284126e-01f, -1.26731582e-02f, 6.10970259e-01f, 5.18193662e-01f, 5.48692048e-01f, -1.35432521e-03f, -5.41791618e-01f, 2.02958688e-01f, -6.50923923e-02f,
  -5.17426610e-01f, 4.36746795e-03f, 8.81125256e-02f, 3.41375440e-01f, 4.28126991e-01f, 7.52048135e-01f, 1.33312494e-01f, -2.12401405e-01f, 5.74491680e-01f, -5.67077622e-02f,
  -2.91142762e-01f, -1.93089336e-01f, 4.55869019e-01f, 6.99633777e-01f, -4.92985208e-40f, -4.92981004e-40f, -4.93233237e-40f, 4.92933359e-40f, 5.43950433e-40f, 4.93331328e-40f,
  4.95096964e-40f, 4.90507712e-40f, -6.50385145e-22f, -1.58387261e-26f, 4.94016563e-40f, -1.10839556e-23f, -1.87317657e-23f, -1.77964923e-19f, -1.29126892e-20f, 4.91348491e-40f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  3.59355241e-01f, 5.75519539e-02f, 1.90304682e-01f, 6.70847952e-01f, -1.67444751e-01f, -2.98781753e-01f, 6.43515706e-01f, 1.92996189e-01f, -3.63913924e-02f, -4.92930557e-40f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  5.69269896e-01f, 4.15190637e-01f, 6.08305275e-01f, -4.18478101e-01f, -2.63740331e-01f, 5.76104283e-01f, 2.66962856e-01f, -1.30215180e+00f, 6.94092363e-02f, 3.91617388e-01f,
  -6.50989830e-01f, -1.05281484e+00f, 6.67124391e-01f, 7.67176002e-02f, -6.75327718e-01f, 4.91533462e-40f, -3.20634604e-01f, -1.77368715e-01f, -4.93668407e-01f, 5.58095634e-01f,
  4.43767786e-01f, -2.90802419e-01f, 2.07147181e-01f, -3.62219840e-01f, -6.91380799e-01f, 2.14348868e-01f, -5.70045531e-01f, -1.67241007e-01f, 4.05585200e-01f, -1.26352632e+00f,
  2.43734092e-01f, 4.90727716e-40f, -7.07532689e-02f, -5.64278424e-01f, -2.68538326e-01f, 6.81411386e-01f, 3.19036752e-01f, -6.30080223e-01f, 4.06591833e-01f, -1.42848134e+00f,
  -1.26775615e-02f, 4.55495298e-01f, 2.00297251e-01f, -8.65241110e-01f, -3.22315812e-01f, -5.01569986e-01f, 1.13903835e-01f, 4.92032325e-40f, 3.22384685e-01f, -7.92862698e-02f,
  4.49703246e-01f, 2.51441360e-01f, -3.71055424e-01f, 2.72196412e-01f, -7.26744115e-01f, -1.81398273e-01f, 5.13964295e-01f, -3.14299136e-01f, 9.92368981e-02f, -2.37291247e-01f,
  -1.08979571e+00f, 2.60260999e-01f, 8.40786844e-02f, -2.59182779e-11f, -1.78895332e-02f, -2.59575874e-01f, -1.87473983e-01f, -4.32204783e-01f, -7.87510201e-02f, 3.93091470e-01f,
  -4.71583277e-01f, -2.65183955e-01f, 4.55018282e-01f, -4.37853262e-02f, -6.02409780e-01f, -1.69630751e-01f, 1.42192304e-01f, 2.05491900e-01f, -6.17336631e-01f, -4.94802692e-40f,
  6.33523524e-01f, 6.68015838e-01f, 9.09218848e-01f, 1.05973490e-01f, -5.43556809e-01f, 2.00882912e-01f, 3.04155380e-01f, 1.95955783e-01f, -8.11706722e-01f, -2.39861250e-01f,
  -5.54599345e-01f, -1.95482880e-01f, 3.57721835e-01f, -1.27091378e-01f, -4.03338641e-01f, -4.92587239e-40f, -6.45976484e-01f, -1.14643383e+00f, -7.67336965e-01f, -8.03621173e-01f,
  -2.98669249e-01f, 6.50426269e-01f, -3.44148092e-02f, -7.27827698e-02f, -9.67947662e-01f, -5.85567772e-01f, -3.28439288e-02f, 2.27891982e-01f, 3.37880313e-01f, 4.49807644e-01f,
  -9.81881440e-01f, 4.90851030e-40f, -1.80624306e-01f, -3.96449044e-02f, -9.45217386e-02f, -2.74354011e-01f, 1.01763392e-02f, 3.21913004e-01f, -2.91986793e-01f, 4.79775697e-01f,
  2.36563653e-01f, -9.95230198e-01f, -3.68512273e-01f, -4.55541462e-02f, -8.67176414e-01f, 1.64288789e-01f, -4.67718750e-01f, 1.29314975e-13f, -1.48578316e-01f, 2.26737902e-01f,
  1.63154081e-01f, -2.83623427e-01f, 2.24056721e-01f, 7.34158754e-02f, 3.00722897e-01f, -2.12612495e-01f, -5.48099637e-01f, -1.48712890e-02f, 5.41162670e-01f, 5.77477455e-01f,
  -7.76788294e-01f, -5.70962727e-01f, 2.23303944e-01f, -4.94941420e-40f, -3.85586321e-01f, 2.08596304e-01f, -1.99428722e-01f, 2.41324544e-01f, -1.90699518e-01f, -6.98692054e-02f,
  -9.91196990e-01f, 2.25168809e-01f, -2.15805069e-01f, -1.21756673e+00f, -3.41418743e-01f, 2.82011896e-01f, 1.46318778e-01f, 2.49890774e-01f, -5.30752778e-01f, -1.56573574e-15f,
  -1.71431094e-01f, 6.54216111e-01f, -1.22590795e-01f, 5.39523602e-01f, 5.44041872e-01f, -3.31768513e-01f, -9.46058892e-03f, -4.36365940e-02f, 3.14246655e-01f, 3.85946184e-01f,
  6.70437664e-02f, -7.39130974e-01f, -9.54424024e-01f, -7.89070487e-01f, 7.37946033e-02f, -4.93157567e-40f, -2.61438966e-01f, -2.45794922e-01f, -2.86513478e-01f, 2.85848826e-01f,
  -1.33939967e-01f, -6.66283786e-01f, -3.47198635e-01f, 1.01235390e-01f, 2.70768642e-01f, -3.53375345e-01f, -1.76484019e-01f, 2.16311827e-01f, -1.66325122e-01f, -3.83561313e-01f,
  8.21772069e-02f, 9.42485239e-13f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.12950552e-01f, 1.78772062e-01f, 2.06367910e-01f, 4.25832458e-02f, 2.01891214e-02f, 8.00133869e-02f, 1.57322749e-01f, -9.73083302e-02f, -3.77280176e-01f, 2.13610262e-01f,
  2.34289914e-01f, -7.97859132e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    