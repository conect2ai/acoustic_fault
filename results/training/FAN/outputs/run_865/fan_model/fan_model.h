/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.57570529e-01f, 1.84829369e-01f, -8.84294212e-02f, -2.16509262e-03f, 9.90531072e-02f, -5.52877262e-02f, 1.58899844e-01f, 3.69252376e-02f, 7.78016523e-02f, 3.69516537e-02f,
  1.79986328e-01f, 1.28405750e-01f, 1.34294167e-01f, 1.22270241e-01f, 8.79139900e-02f, -1.56693738e-02f, -8.59423801e-02f, -1.71099767e-01f, -2.33679757e-01f, -7.11009055e-02f,
  6.99156225e-02f, -8.67878422e-02f, -2.75827229e-01f, -8.79793316e-02f, 1.24523535e-01f, 1.60988849e-02f, 2.80801603e-03f, 8.08120593e-02f, -4.28244956e-02f, 1.28014416e-01f,
  6.44682571e-02f, -4.13956419e-02f, -9.56854522e-02f, 1.40105691e-02f, -3.55736949e-02f, -1.03297628e-01f, 2.10312079e-03f, 1.18563166e-02f, -5.44781238e-03f, 8.78982712e-03f,
  -8.21716338e-03f, 1.63211972e-02f, 1.33043259e-01f, 9.99299660e-02f, -5.51598743e-02f, -1.12516314e-01f, 4.54953127e-02f, 4.08337655e-04f, -4.65901420e-02f, 7.56354779e-02f,
  7.57844746e-02f, -3.55997197e-02f, 7.76401779e-04f, 8.73956382e-02f, 5.36752380e-02f, -8.05909708e-02f, 1.25264600e-01f, -1.86091091e-03f, -1.20928213e-01f, -1.03806801e-01f,
  -8.86615925e-03f, -9.61672589e-02f, 1.02839455e-01f, 6.83817035e-03f, 2.00632191e-03f, -5.08079007e-02f, -7.68643478e-03f, 7.67772794e-02f, -5.04475459e-02f, 3.41439135e-02f,
  8.97616707e-03f, 1.30174216e-02f, 9.25736725e-02f, -3.11594959e-02f, 9.29449424e-02f, -1.98596027e-02f, -6.26359973e-03f, -2.78949607e-02f, 4.40635197e-02f, -2.00394709e-02f,
  -3.22559774e-02f, -2.21148483e-03f, 1.55336363e-02f, 4.46634032e-02f, -2.94878781e-02f, 2.90258434e-02f, -3.88385020e-02f, -6.36209175e-02f, 6.77027628e-02f, -4.62143682e-02f,
  6.80251494e-02f, -1.10831119e-01f, 1.00380503e-01f, 9.39193368e-02f, 1.70497000e-02f, 1.94385163e-02f, 1.18153296e-01f, -7.91523904e-02f, 4.28025052e-02f, 8.59406069e-02f,
  6.53067455e-02f, 1.81690864e-02f, -9.60192736e-03f, -1.10586789e-02f, -1.15612604e-01f, -4.65434603e-03f, 9.57476869e-02f, 1.86586492e-02f, 8.39968622e-02f, 6.91307932e-02f,
  -2.45027971e-02f, -2.76040379e-02f, -4.97981953e-03f, -6.91347495e-02f, 1.47649487e-02f, -1.04001485e-01f, -4.90498589e-03f, -5.92652708e-02f, -1.13107078e-01f, -1.46565706e-01f,
  2.06671193e-01f, -1.35824487e-01f, -2.02980921e-01f, -1.51799709e-01f, -1.49867624e-01f, -5.14374599e-02f, -1.83885600e-02f, -1.88114867e-02f, -8.67032539e-03f, -7.92294517e-02f,
  -1.32052153e-01f, -2.19646003e-02f, -8.97670016e-02f, 2.94749886e-02f, 1.49654418e-01f, -7.19260350e-02f, -9.06212926e-02f, 8.85034576e-02f, 1.20683320e-01f, 1.75585017e-01f,
  1.26096442e-01f, 1.31155297e-01f, 2.17773736e-01f, 1.35861859e-01f, -1.94591265e-02f, -1.33121297e-01f, -1.61932915e-01f, -1.15457594e-01f, -4.63901684e-02f, -5.35276346e-02f,
  -3.19583178e-01f, 7.28907064e-02f, 8.72496143e-03f, 1.02982679e-02f, -4.01351117e-02f, 9.19307992e-02f, -1.88691933e-02f, -1.30193844e-01f, 6.22551441e-02f, 1.70080625e-02f,
  -4.31112461e-02f, 1.57411862e-02f, 3.92113589e-02f, 4.02239896e-02f, -8.49748217e-03f, -2.21996475e-02f, 2.25213803e-02f, 1.85478538e-01f, 5.97115494e-02f, -3.42640877e-02f,
  -2.78772172e-02f, -3.63572165e-02f, -6.29199967e-02f, -7.20559880e-02f, 5.19341528e-02f, 1.03828035e-01f, -1.06779717e-01f, 7.54862651e-02f, 9.87399649e-03f, -2.75572408e-02f,
  3.88197997e-03f, -7.43531212e-02f, -6.36246130e-02f, -2.37076334e-03f, 4.84246910e-02f, 1.30080329e-02f, 2.52024606e-02f, -8.70875083e-03f, 1.06544262e-02f, 1.75787117e-02f,
  -1.12393927e-02f, 2.05938816e-02f, 5.91545887e-02f, -5.68141881e-03f, -1.43390000e-02f, 2.08104290e-02f, 1.42607363e-02f, -5.38259992e-05f, 4.76185232e-02f, 6.62242621e-02f,
  1.76733509e-02f, -4.06182371e-03f, -7.03369379e-02f, 1.83539763e-02f, 6.38494790e-02f, -7.62351276e-03f, -3.45060742e-03f, -4.95393090e-02f, -9.72573012e-02f, 7.74239190e-04f,
  -2.68996686e-01f, 9.32577997e-03f, 1.02232015e-02f, 1.00629561e-01f, -6.18969351e-02f, -1.52358050e-02f, -3.63676399e-02f, 8.36803764e-02f, -1.55542921e-02f, 5.21683469e-02f,
  2.32679918e-02f, 7.38282502e-02f, -7.75234252e-02f, 1.12798147e-01f, -5.93974814e-03f, 1.81149191e-03f, 4.27205935e-02f, 4.99476343e-02f, 4.01787274e-03f, 6.87456550e-03f,
  -5.92157394e-02f, -8.20878055e-03f, -1.24677248e-01f, -1.20025493e-01f, -1.16738006e-01f, -1.35832608e-01f, -9.24766138e-02f, -9.02732611e-02f, -2.95541715e-02f, -1.54433921e-01f,
  3.83481026e-01f, -2.55804211e-01f, -1.19990736e-01f, 5.39881028e-02f, -7.63153075e-04f, 3.97559069e-02f, -1.39466062e-01f, 1.09787710e-01f, 1.95026472e-01f, -5.78557663e-02f,
  -1.78728960e-02f, -1.21798262e-03f, -4.80395555e-03f, -1.29647613e-01f, -2.86937971e-02f, -1.37626901e-01f, -1.73346683e-01f, -3.46114822e-02f, 4.81560864e-02f, 1.35370284e-01f,
  1.14331795e-02f, 1.35077061e-02f, 5.99020859e-03f, -2.75498275e-02f, -1.74395144e-01f, -1.55070230e-01f, -1.19935662e-01f, -1.30108252e-01f, -7.79351443e-02f, -2.98743814e-01f,
  -1.29972830e-01f, 1.67384312e-01f, 3.26015837e-02f, -5.85831590e-02f, 2.58156620e-02f, 2.90878434e-02f, -9.81190242e-04f, 9.00300816e-02f, 4.38190363e-02f, 2.83753015e-02f,
  2.97960471e-02f, 3.62623320e-03f, 5.23885675e-02f, -2.85913032e-02f, 4.46024910e-02f, 2.92326510e-02f, -2.03163065e-02f, 4.95220674e-03f, 5.02290875e-02f, -5.94749078e-02f,
  -1.48467124e-01f, -1.30898058e-01f, -9.91523117e-02f, -9.98571888e-02f, 5.91441393e-02f, 3.23069058e-02f, -7.18308315e-02f, -3.99944857e-02f, -2.86382344e-02f, -9.98394215e-04f,
  -4.52268086e-02f, -6.26622066e-02f, 4.23393846e-02f, -2.14730352e-02f, 7.06161791e-03f, 4.67761569e-02f, -1.23633808e-02f, -3.62491831e-02f, 5.20990826e-02f, -3.12635414e-02f,
  3.14455852e-02f, -4.70257401e-02f, -5.33703417e-02f, -7.97844306e-02f, -1.02365404e-01f, -1.22283539e-02f, -6.21960834e-02f, 2.08348315e-03f, -3.80411819e-02f, -3.13611738e-02f,
  4.48175669e-02f, 6.29903302e-02f, 6.37692511e-02f, -5.12025617e-02f, -7.18142390e-02f, -1.06340675e-02f, 2.48333625e-02f, 2.16836501e-02f, 1.11186624e-01f, 1.04877383e-01f,
  1.25141621e-01f, -8.44860375e-02f, 4.52777557e-03f, 4.79276851e-02f, -1.22615248e-02f, 1.16124274e-02f, -9.15729403e-02f, -3.81490067e-02f, 1.50341466e-02f, 2.83948947e-02f,
  6.37296140e-02f, 8.39048475e-02f, -3.03237867e-02f, -4.90928777e-02f, 1.16823271e-01f, 3.95091958e-02f, -8.87409970e-02f, -7.21408650e-02f, -1.21637583e-01f, 6.29038587e-02f,
  -8.31123069e-02f, 4.90338840e-02f, 6.23256341e-02f, -3.14387716e-02f, 8.31046999e-02f, 7.55162910e-02f, -3.74204852e-02f, 5.97794987e-02f, 9.62071270e-02f, -2.77529415e-02f,
  1.24575444e-01f, 2.58485097e-02f, 1.37451097e-01f, 5.70537299e-02f, 3.37120332e-02f, 1.49205700e-01f, 2.21986607e-01f, 6.78912774e-02f, 3.55753824e-02f, 8.57202634e-02f,
  -3.37478071e-01f, -2.01093346e-01f, -7.89174531e-03f, 1.33604473e-02f, 1.93568096e-01f, 3.05141240e-01f, 4.48467046e-01f, 3.64611864e-01f, 2.17398092e-01f, -3.43452506e-02f,
  5.90858720e-02f, 6.18569702e-02f, 4.56593186e-02f, 1.22753248e-01f, -3.35629098e-02f, -9.25047249e-02f, 4.90850396e-02f, -2.15954278e-02f, -9.91411358e-02f, -4.87636887e-02f,
  -7.79939070e-02f, -1.40846282e-01f, -8.56602471e-03f, -3.74030471e-02f, -3.48648764e-02f, -1.98813379e-02f, -1.67947002e-02f, -4.01564017e-02f, -3.83146480e-02f, 7.64888227e-02f,
  -1.47216707e-01f, -2.59148870e-02f, 2.07308270e-02f, -3.06265801e-02f, -3.11086997e-02f, 3.17139067e-02f, 1.90043554e-01f, 4.77392301e-02f, -1.79349557e-02f, -7.17574358e-02f,
  -9.26929265e-02f, -1.67594314e-01f, 5.41587695e-02f, 4.48462041e-03f, -1.26686953e-02f, -6.23213388e-02f, -7.80735090e-02f, -3.14447805e-02f, -5.05640963e-03f, 4.44851443e-02f,
  7.34398142e-02f, -2.80843563e-02f, 5.29301446e-03f, -1.02920122e-02f, 7.37933666e-02f, -5.51182367e-02f, -4.24889848e-03f, 5.78627400e-02f, -3.52323428e-02f, 3.69711816e-02f,
  -2.33269352e-02f, -7.37664849e-02f, 2.33727265e-02f, 8.58178809e-02f, -5.57551719e-02f, 6.00497760e-02f, 3.53641920e-02f, 6.34136498e-02f, 8.32701698e-02f, 1.17829386e-02f,
  -4.99365516e-02f, -6.77700341e-02f, -2.29273494e-02f, 2.24976775e-05f, -8.54732469e-02f, 3.53596956e-02f, 5.18257134e-02f, -1.11973204e-01f, 7.95638375e-03f, -2.77905017e-02f,
  1.19311355e-01f, -1.41840115e-01f, 1.24244034e-01f, 8.20671543e-02f, 5.59238382e-02f, 7.75799155e-02f, -8.37618709e-02f, -1.85923129e-02f, -1.14517190e-01f, 2.09674686e-02f,
  3.09863966e-03f, 1.13733888e-01f, 2.07287390e-02f, -7.56629780e-02f, 5.15953787e-02f, -2.00143941e-02f, 1.31259307e-01f, 3.58994715e-02f, -6.58756793e-02f, 3.89916040e-02f,
  1.30237058e-01f, 1.29478678e-01f, 1.64935723e-01f, 1.22581035e-01f, -6.89727301e-03f, 1.49773479e-01f, 1.07876353e-01f, 9.72096696e-02f, 2.33546302e-01f, 3.22231889e-01f,
  -3.37497517e-02f, 3.21403921e-01f, -2.74253905e-01f, -2.26583276e-02f, 1.94811642e-01f, -2.95771528e-02f, 4.53733169e-02f, 1.52737033e-02f, -5.74308708e-02f, 1.33793801e-01f,
  2.17441604e-01f, 4.83412072e-02f, 3.12203970e-02f, -1.05557956e-01f, -2.70152271e-01f, -2.11428031e-01f, -1.59751743e-01f, -3.43138218e-01f, -2.35611722e-01f, 3.07290703e-02f,
  1.27096206e-01f, -4.38024551e-02f, -5.85131347e-02f, 3.82564100e-03f, 1.07095681e-01f, 3.52589190e-02f, 4.00446206e-02f, 7.34368339e-02f, 1.14631332e-01f, 1.12871699e-01f,
  -1.61312684e-01f, 1.12067185e-01f, -1.52861327e-01f, 1.37338340e-01f, 1.43096119e-01f, -9.15870667e-02f, -5.03432378e-02f, -2.57309768e-02f, -8.44562892e-03f, -1.02717154e-01f,
  1.04850613e-01f, 9.26353037e-02f, 7.21917972e-02f, -9.81619582e-03f, 1.31163113e-02f, 4.79595475e-02f, 3.75595056e-02f, -2.60588259e-01f, -1.10953338e-01f, 5.45071065e-02f,
  2.17398956e-01f, 1.35472715e-01f, 9.76132974e-03f, -2.45583225e-02f, -3.16694193e-02f, -1.31081408e-02f, -8.46033916e-04f, 9.28626731e-02f, -1.32811353e-01f, -4.55591595e-03f,
  1.69612411e-02f, -2.99543422e-02f, 4.10989299e-02f, 9.34199081e-04f, 6.41536266e-02f, -4.56186719e-02f, -6.26491234e-02f, 2.26663109e-02f, -8.24097618e-02f, 5.15757911e-02f,
  -8.34250525e-02f, 1.46848699e-02f, -8.26705073e-04f, -4.79344139e-03f, 1.74647197e-02f, -3.01053412e-02f, -3.35410126e-02f, 1.58022828e-02f, -5.94081124e-03f, -9.91185661e-03f,
  3.02803982e-02f, -4.40929532e-02f, 8.40578414e-03f, -2.58328337e-02f, 2.02735607e-02f, -3.17732804e-02f, 1.28647182e-02f, 1.17195323e-01f, 6.34886101e-02f, 7.84905851e-02f,
  -5.40415607e-02f, -3.71115282e-02f, -3.03561948e-02f, -6.89053163e-02f, 8.71148407e-02f, 1.05221786e-01f, 5.26044965e-02f, -1.32793104e-02f, 7.69790262e-02f, 7.13034114e-03f,
  3.54524553e-02f, -1.76684223e-02f, 8.62861350e-02f, 9.74188559e-03f, -9.30038840e-03f, 5.81965782e-03f, 1.01666451e-01f, -8.50071535e-02f, -8.15490931e-02f, 1.28103256e-01f,
  2.27039158e-02f, -1.57872796e-01f, -1.78523928e-01f, -9.49718952e-02f, -2.99121793e-02f, -1.19332047e-02f, -1.00175440e-01f, -9.99800563e-02f, -1.06240667e-01f, -1.20640859e-01f,
  -1.97865844e-01f, -1.77608564e-01f, -1.19192749e-01f, -2.98087269e-01f, -2.68642485e-01f, -9.43295807e-02f, -5.90031892e-02f, 5.37100956e-02f, -5.42901084e-02f, -2.27141038e-01f,
  -7.57892430e-02f, 1.96170155e-03f, 6.12871209e-03f, -1.05578817e-01f, -1.94992535e-02f, -1.86927870e-01f, -1.88028410e-01f, -1.28324658e-01f, 4.45784554e-02f, -8.90072212e-02f,
  -1.88189298e-01f, -2.25003675e-01f, -1.94936752e-01f, -4.13528942e-02f, -1.71328560e-01f, -4.36978042e-02f, -7.79680982e-02f, -1.84306324e-01f, -1.96474001e-01f, -2.27795467e-01f,
  -1.39992625e-01f, -7.40501806e-02f, 1.20337814e-01f, 4.84324917e-02f, -9.31723639e-02f, 5.74611202e-02f, -1.70842465e-02f, 1.35400876e-01f, 5.28607443e-02f, -2.38645636e-02f,
  -5.88765405e-02f, -8.08783714e-03f, 1.51418587e-02f, -5.69674820e-02f, -3.31155770e-02f, 2.89807245e-02f, 2.02407539e-02f, -4.37884368e-02f, -1.76692642e-02f, 5.79519309e-02f,
  5.84355704e-02f, 3.23653892e-02f, 9.57900062e-02f, 4.57618646e-02f, 1.23671584e-01f, 6.42093224e-03f, 6.50661662e-02f, 1.38520461e-03f, 9.27767679e-02f, 1.06671313e-02f,
  1.09673835e-01f, 9.29214526e-03f, 1.90076418e-03f, 8.03963095e-02f, -5.54329203e-03f, 4.42761965e-02f, 4.55330797e-02f, 4.21368219e-02f, 2.86321659e-02f, 1.55842230e-02f,
  3.45395245e-02f, -1.03226185e-01f, -7.04108411e-03f, -5.82282394e-02f, -3.44083123e-02f, -1.86501183e-02f, -2.11839508e-02f, 1.26533061e-02f, 8.26222301e-02f, -2.44507845e-02f,
  3.39861810e-02f, 8.26075599e-02f, -6.80001359e-03f, 2.53744628e-02f, -1.97193343e-02f, -6.30934015e-02f, 4.37180661e-02f, 8.03636312e-02f, -1.20495725e-02f, 4.14650925e-02f,
  -5.02346084e-02f, 2.37144679e-02f, -7.11930469e-02f, 5.06149232e-02f, -4.23990097e-03f, 2.92694550e-02f, -7.88850561e-02f, 4.55418266e-02f, -2.24089250e-02f, 3.95834334e-02f,
  7.50144571e-02f, -8.04998633e-03f, -2.81598489e-03f, 6.90701306e-02f, -4.24735807e-03f, 1.62518844e-02f, -2.03353465e-02f, -8.20479915e-02f, 4.03414182e-02f, 1.94665249e-02f,
  1.80992987e-02f, 6.05265275e-02f, 1.92842439e-01f, 1.29660055e-01f, 8.52439553e-02f, 4.53030579e-02f, 3.49199548e-02f, 1.65398419e-01f, 1.52473941e-01f, 9.21927989e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.14694871e-01f, -1.30892187e-01f, 6.75444379e-02f, -1.54995710e-01f, 1.33201987e-01f, 1.23066776e-01f, -9.97272134e-02f, 4.80706571e-03f, -5.23182750e-02f, 7.35755544e-03f,
  -1.09401336e-02f, 8.95553753e-02f, 8.07628185e-02f, -1.30329449e-02f, -7.57934079e-02f, -1.01882815e-01f, 9.35795903e-02f, -2.18087882e-02f, -5.26170358e-02f, 1.16403237e-01f,
  2.42414102e-02f, -5.33668511e-02f, 4.99135396e-03f, -1.72929168e-02f, -5.80994077e-02f, -1.39503889e-02f, -2.28734687e-02f, -5.87669238e-02f, 6.00084700e-02f, -3.98922376e-02f,
  2.16725245e-02f, -7.26729557e-02f, -6.66352510e-02f, 7.74944993e-03f, 7.31381215e-03f, -2.54194159e-02f, 3.75688486e-02f, -5.09425290e-02f, -5.87749816e-02f, 3.83231528e-02f,
  1.93267409e-02f, -4.73929308e-02f, 4.05683294e-02f, -4.89895828e-02f, 1.15743829e-02f, -4.83814403e-02f, -4.18139584e-02f, -1.28462270e-01f, 4.37698252e-02f, -7.91060925e-02f,
  1.08442679e-01f, -7.23622218e-02f, -4.00986485e-02f, -5.22997119e-02f, -3.93490084e-02f, 5.60359880e-02f, -7.83822208e-04f, -5.31746866e-03f, -1.10874303e-01f, -1.73398688e-01f,
  3.52728702e-02f, 4.11791131e-02f, -2.21670605e-02f, -2.36193929e-02f, -1.18513592e-02f, -7.18858913e-02f, 5.72945774e-02f, -6.56527057e-02f, 7.77544677e-02f, -4.12255235e-04f,
  5.11491438e-03f, 7.73792118e-02f, -5.16624935e-02f, -5.46742454e-02f, -3.66781130e-02f, 2.50226837e-02f, -7.87355155e-02f, -1.91048160e-02f, 4.01878655e-02f, -1.50751118e-02f,
  4.05524336e-02f, 1.20008169e-02f, -7.20416233e-02f, 2.44778767e-02f, 3.68498941e-03f, -8.34471583e-02f, -6.90217018e-02f, 2.43797991e-02f, -7.42540658e-02f, 1.09686349e-02f,
  -1.85543329e-01f, 6.92961887e-02f, -2.87627727e-02f, -2.61859577e-02f, -1.50839761e-02f, -5.88010699e-02f, -3.21971960e-02f, 5.70568070e-03f, 6.51637986e-02f, -9.35539007e-02f,
  -5.31988628e-02f, -1.35503225e-02f, -6.36951923e-02f, 3.21636871e-02f, -1.31176626e-02f, -1.19542621e-01f, 6.71619922e-02f, -2.83254664e-02f, -6.33574724e-02f, -6.21754937e-02f,
  -9.04613063e-02f, -5.58068976e-02f, -6.64730594e-02f, -1.15024619e-01f, -6.75012171e-02f, -1.59888566e-01f, -1.13109097e-01f, -8.17257091e-02f, -7.26220906e-02f, -1.32592663e-01f,
  -4.72724736e-02f, -9.98202115e-02f, 8.44555721e-02f, -1.12117687e-02f, -1.88599862e-02f, -2.53765315e-01f, -4.11143899e-01f, -2.44904891e-01f, -5.55997267e-02f, -1.08991310e-01f,
  -5.55633232e-02f, -7.50389695e-03f, 1.40729919e-01f, 4.13973853e-02f, -7.27479830e-02f, -1.65683448e-01f, 4.58304323e-02f, -6.08619303e-02f, -1.30207449e-01f, -2.42538333e-01f,
  -1.23930439e-01f, -3.27551775e-02f, 1.13788038e-01f, -1.00359907e-02f, 3.74654680e-02f, 9.98214856e-02f, 1.41067281e-01f, 1.17306054e-01f, -2.36051623e-03f, 8.71702656e-02f,
  3.76373343e-02f, -4.94828187e-02f, -5.26650297e-03f, -5.91347069e-02f, 1.06472880e-01f, -1.70656145e-02f, -3.98077443e-02f, 1.91144999e-02f, 1.05744451e-01f, -7.20763057e-02f,
  4.75395992e-02f, -1.82462819e-02f, -1.66963357e-02f, -9.65901092e-02f, -1.15899220e-01f, -1.32395193e-01f, 1.40564702e-02f, 1.19260643e-02f, 5.39086796e-02f, -9.85914692e-02f,
  -6.76547587e-02f, -8.93704519e-02f, -7.91159198e-02f, -1.95871368e-02f, -2.79391855e-02f, 9.68316644e-02f, 8.04726407e-02f, 4.51039011e-03f, -7.47236162e-02f, 3.43509242e-02f,
  -1.47249982e-01f, -5.90680167e-02f, -6.95001483e-02f, 6.58524048e-04f, -2.97680926e-02f, 4.39569615e-02f, -6.76939115e-02f, -7.35893771e-02f, -9.04578716e-02f, -4.08042297e-02f,
  1.19228405e-03f, 9.42774937e-02f, -3.11499368e-02f, -1.54709080e-02f, 5.82984090e-02f, -2.59589534e-02f, -2.37438027e-02f, -8.24405476e-02f, -9.49607510e-03f, 4.11756374e-02f,
  2.15135943e-02f, -5.05671948e-02f, 3.43074910e-02f, -8.12946334e-02f, 5.57995327e-02f, -5.79237528e-02f, 7.18085095e-02f, -4.44380827e-02f, 5.19447774e-02f, 7.61273205e-02f,
  1.22771457e-01f, 1.18665017e-01f, -4.51743938e-02f, -9.54281241e-02f, 7.89299607e-02f, -9.15138144e-03f, 6.84238747e-02f, -3.90168093e-02f, 2.91032181e-03f, -1.05998896e-01f,
  -2.44907793e-02f, -2.47158613e-02f, 3.87226753e-02f, -7.21393302e-02f, -6.68435544e-02f, -1.57105803e-01f, 2.80720778e-02f, 1.57579576e-04f, 3.87578718e-02f, -5.31605026e-03f,
  3.18781510e-02f, -2.22467557e-02f, -9.69384834e-02f, 2.84414496e-02f, 3.53160352e-02f, 7.73563236e-02f, 4.47907634e-02f, -6.29130676e-02f, -2.05922723e-02f, -1.00880548e-01f,
  -4.65908527e-01f, -6.30704686e-02f, -1.54854417e-01f, -1.27270997e-01f, 2.97533143e-02f, 4.05816063e-02f, 1.69913724e-01f, -1.88597329e-02f, -3.36802378e-03f, 5.40077239e-02f,
  -9.54259485e-02f, 5.73594235e-02f, -5.54784574e-02f, -1.75012741e-02f, -8.03674832e-02f, 1.33710563e-01f, 4.31290753e-02f, 6.08250611e-02f, -1.21706538e-01f, 9.73025262e-02f,
  1.53944761e-01f, -1.11623339e-01f, -2.19982833e-01f, 4.96115908e-02f, 1.19176447e-01f, 1.56929914e-03f, 7.72205293e-02f, 2.39970274e-02f, 1.13328621e-01f, 9.09643844e-02f,
  -1.78752139e-01f, -1.43555582e-01f, -6.43691327e-03f, -2.58186180e-02f, -8.44549015e-03f, 6.29036203e-02f, -6.02051653e-02f, -5.96584007e-02f, 4.48754616e-02f, -6.87981844e-02f,
  -2.06362512e-02f, 1.49814840e-02f, -4.95772436e-02f, -8.30507278e-02f, -4.56760190e-02f, -8.62983242e-02f, -4.46709581e-02f, -1.41934216e-01f, -2.61383057e-02f, 2.48735454e-02f,
  1.48232758e-01f, -9.60868150e-02f, -1.77397221e-01f, 7.29038799e-03f, -1.09488137e-01f, -7.81679526e-02f, -1.47944167e-01f, -8.41837227e-02f, -1.18993938e-01f, -1.25759393e-01f,
  -3.80556993e-02f, -6.30616695e-02f, -5.20927086e-02f, 1.33584719e-02f, -5.57414070e-03f, 1.01545818e-01f, 9.26649570e-02f, -3.22688892e-02f, 1.92173310e-02f, -8.24987590e-02f,
  7.08254427e-02f, -5.99743985e-02f, -5.72573431e-02f, 1.00002494e-02f, -9.68369376e-03f, 3.15632671e-02f, -6.72566965e-02f, 1.20486403e-02f, -1.02441557e-01f, 4.66002559e-04f,
  6.65140375e-02f, -8.16542134e-02f, -5.91731891e-02f, 1.02056816e-01f, 3.87994535e-02f, 5.81629239e-02f, 2.74109785e-02f, 3.05788480e-02f, -8.46310258e-02f, -3.64877507e-02f,
  -1.65831596e-01f, -8.00361633e-02f, -4.27526645e-02f, 4.83793393e-02f, -5.40757850e-02f, -9.12860334e-02f, 2.90241838e-02f, -8.58938694e-02f, 3.28345746e-02f, -1.77853815e-02f,
  -3.93703021e-03f, -8.93438831e-02f, 8.45798850e-03f, 5.30752055e-02f, -1.06562190e-01f, -1.29343253e-02f, -6.10321276e-02f, 7.12867407e-03f, -4.16382141e-02f, -4.94471975e-02f,
  4.95882779e-02f, -2.16046125e-02f, -1.59004390e-01f, -1.06198303e-01f, -3.02065033e-02f, -1.36532113e-01f, -1.03201754e-01f, -1.07268572e-01f, -1.67425260e-01f, -2.05920428e-01f,
  5.02909720e-01f, 3.50310147e-01f, 1.73351496e-01f, 1.29407151e-02f, -2.81869262e-01f, -7.73065984e-02f, 2.34373175e-02f, 2.17228189e-01f, 1.84457507e-02f, 1.62640885e-01f,
  -1.07771240e-01f, -2.65736375e-02f, -6.62312433e-02f, 1.29449904e-01f, 1.59844458e-01f, 1.97792724e-01f, 7.73836449e-02f, 1.80630818e-01f, -1.77955963e-02f, 6.31892607e-02f,
  -4.19532433e-02f, 2.51578279e-02f, 7.23274350e-02f, 1.17211103e-01f, -4.03188951e-02f, 3.66338491e-02f, 4.87882048e-02f, -1.04882121e-01f, 6.21536840e-03f, 8.44012480e-03f,
  -5.13795614e-02f, 1.71426341e-01f, -9.91733596e-02f, -2.24479083e-02f, -6.67565838e-02f, 1.85388431e-01f, 6.85062781e-02f, 8.66917800e-03f, -5.32872714e-02f, -3.78777049e-02f,
  -1.19526647e-01f, -5.59899807e-02f, -9.17800292e-02f, -1.22662932e-01f, -1.89484227e-02f, 5.83842844e-02f, 1.98347983e-03f, 9.76944938e-02f, 7.88771361e-03f, 2.11429987e-02f,
  -8.66799653e-02f, -1.48717508e-01f, -6.03195727e-02f, 2.43643168e-02f, 1.10986896e-01f, -1.22920908e-01f, -2.35309079e-02f, 9.02666226e-02f, 1.49978861e-01f, 1.36236817e-01f,
  -5.46565503e-02f, 5.07717989e-02f, 2.83205323e-03f, 3.55326384e-02f, -4.65700552e-02f, -6.15295861e-03f, -8.38278458e-02f, -4.08439226e-02f, 3.83857032e-03f, 3.74779687e-03f,
  2.69746277e-02f, -6.08173870e-02f, -3.38197425e-02f, -7.45935664e-02f, -4.51858304e-02f, -7.64812455e-02f, -6.87544793e-02f, 5.77610582e-02f, 5.56147133e-04f, -2.39102133e-02f,
  -8.97983555e-03f, 6.50780499e-02f, -3.98123227e-02f, -3.80756073e-02f, -5.99273704e-02f, 9.53456562e-04f, 6.14895113e-02f, -9.92081463e-02f, 7.02621266e-02f, -4.32479568e-02f,
  -1.28248319e-01f, -1.48774490e-01f, 1.68120973e-02f, 9.87337232e-02f, -6.44143522e-02f, -3.57026570e-02f, -4.13477011e-02f, 1.47124175e-02f, -7.80910999e-03f, -3.09489053e-02f,
  -5.76571887e-03f, 8.87407064e-02f, 8.25584978e-02f, 2.92259380e-02f, -7.63598084e-02f, -1.29819080e-01f, -1.52828526e-02f, -1.03464695e-02f, 2.79008150e-02f, -4.19196226e-02f,
  6.09248914e-02f, -6.65811151e-02f, -9.96115655e-02f, 3.36468518e-02f, -1.52838705e-02f, -2.56212428e-02f, -5.56522086e-02f, -1.37860216e-02f, -2.53780205e-02f, 8.15135315e-02f,
  3.60418372e-02f, -4.44317371e-01f, -3.19711834e-01f, -3.57895315e-01f, -1.82201430e-01f, -9.50638056e-02f, -1.69089407e-01f, 2.56749019e-02f, -1.41583905e-01f, -2.76167035e-01f,
  -4.34916876e-02f, 1.88399732e-01f, 8.51707458e-02f, 2.03737408e-01f, 2.68406779e-01f, -1.86292335e-01f, -2.48098448e-01f, 1.19391903e-01f, 3.85951579e-01f, 2.26408273e-01f,
  7.48167336e-02f, 7.81445578e-03f, 8.07078481e-02f, -5.25155291e-02f, -2.18756273e-01f, -3.74748036e-02f, -1.99385703e-01f, -1.23390310e-01f, -8.06620866e-02f, -3.26118290e-01f,
  -2.52399951e-01f, -7.11405128e-02f, 7.04644844e-02f, 1.05868399e-01f, -1.61767721e-01f, 5.43542616e-02f, 3.07380240e-02f, -4.97855023e-02f, -1.89778060e-02f, -8.64547193e-02f,
  -4.71300408e-02f, 8.50790814e-02f, 8.01278129e-02f, -5.95499426e-02f, 2.23932862e-02f, 2.22497135e-02f, 4.52715755e-02f, -3.37291025e-02f, -2.48234030e-02f, -9.52297542e-03f,
  -1.28185436e-01f, -7.91117251e-02f, 8.39169919e-02f, -2.27919109e-02f, -4.11249734e-02f, 1.55193701e-01f, -7.40860105e-02f, -4.97276597e-02f, 1.21313348e-01f, -2.33314171e-01f,
  -6.47655800e-02f, -4.98371162e-02f, 4.06529978e-02f, 2.99602877e-02f, 3.36362869e-02f, -6.50506988e-02f, -1.00425616e-01f, 7.80456439e-02f, 1.11812586e-02f, -4.55880053e-02f,
  1.81246605e-02f, -1.89508282e-04f, 1.22509794e-02f, -2.93637719e-02f, -5.69204278e-02f, 5.79239950e-02f, -4.20758687e-02f, -5.71692362e-02f, -5.35107888e-02f, 5.38124926e-02f,
  -5.95399830e-03f, 4.95656133e-02f, 1.64184645e-02f, -8.18635710e-03f, -7.27064162e-02f, 1.07981348e-02f, -4.34503891e-02f, 1.40465811e-01f, 7.11387545e-02f, -8.98514241e-02f,
  -3.03172283e-02f, 3.11945707e-01f, -1.83614478e-01f, 9.67491865e-02f, -7.73896351e-02f, -1.36434371e-02f, -4.71641831e-02f, -6.84863999e-02f, -1.46130994e-02f, 3.03709097e-02f,
  5.26324250e-02f, 9.76036042e-02f, -1.06761247e-01f, -2.95339376e-02f, -5.79252504e-02f, 1.01691512e-02f, -2.20004339e-02f, -2.08471436e-03f, 1.41461670e-01f, -1.25351369e-01f,
  -4.56134528e-02f, -2.00689286e-02f, 9.23765674e-02f, -1.84892733e-02f, 2.47734115e-02f, 7.04547986e-02f, -1.90516412e-02f, -5.81124946e-02f, 1.43117845e-01f, -2.19823003e-01f,
  -1.78663724e-03f, 7.09378198e-02f, -1.37792364e-01f, -1.54883936e-01f, -6.50650635e-02f, -8.59734192e-02f, -3.06165963e-02f, 4.72836718e-02f, -1.07327532e-02f, 9.65868309e-02f,
  9.88094732e-02f, 1.58232376e-01f, 6.67414665e-02f, 1.83444932e-01f, 7.48158479e-03f, 8.54598880e-02f, -5.24220839e-02f, -4.61481288e-02f, 4.77859601e-02f, -6.82075098e-02f,
  6.79067448e-02f, -6.39223009e-02f, -6.75043240e-02f, -1.81993865e-03f, -5.60054649e-03f, 6.00805730e-02f, 1.52933886e-02f, -1.10745341e-01f, -4.52932306e-02f, -7.86919072e-02f,
  1.67277902e-01f, -8.49358365e-02f, 6.51482195e-02f, -5.84628023e-02f, -3.38702053e-02f, -1.15309633e-01f, -2.05164198e-02f, -1.12275876e-01f, -6.67357817e-02f, -8.04746449e-02f,
  -1.38427377e-01f, -3.50063592e-02f, 1.92221384e-02f, 7.89745478e-04f, -1.18867986e-01f, -2.08326019e-02f, -1.35192961e-01f, -3.92754078e-02f, 2.42029242e-02f, 9.77272168e-03f,
  5.49283400e-02f, -1.20861866e-01f, 3.33327316e-02f, -5.55761121e-02f, -6.41992539e-02f, -3.52684818e-02f, -5.10043055e-02f, -5.05909622e-02f, -2.70237792e-02f, 1.56268049e-02f,
  1.89421102e-02f, 9.50986743e-02f, -2.78298352e-02f, 4.92586344e-02f, -3.67209991e-03f, 7.09405243e-02f, 6.83845356e-02f, 7.94989839e-02f, 5.97721115e-02f, -3.75015289e-02f,
  4.24573123e-02f, 1.15782972e-02f, -7.27432668e-02f, 4.21739928e-03f, 2.81183552e-02f, -7.63009936e-02f, 7.46846870e-02f, 4.22079042e-02f, 3.80946174e-02f, -1.03051476e-01f,
  5.19757494e-02f, -2.24987622e-02f, -9.17470902e-02f, -2.02144422e-02f, -9.27385017e-02f, 3.41115519e-02f, 3.51154357e-02f, 3.24549377e-02f, -7.19563887e-02f, -1.08274529e-02f,
  2.35321552e-01f, 1.24527337e-02f, 6.17935546e-02f, 7.06774667e-02f, -3.51614356e-02f, 4.06878144e-02f, -6.48388639e-02f, 4.27758433e-02f, 2.36204430e-03f, -1.23046907e-02f,
  3.13442852e-03f, 7.01008290e-02f, -2.98600849e-02f, -2.70566531e-02f, -4.65114880e-03f, 5.22510372e-02f, -3.11103836e-02f, 5.14025539e-02f, -5.55822700e-02f, 7.46197477e-02f,
  -1.23659400e-02f, 1.23932600e-01f, 1.22995913e-01f, 7.56226107e-02f, 5.80870546e-02f, 1.26847759e-01f, 8.15410763e-02f, 9.60710794e-02f, 9.91633460e-02f, 1.75819874e-01f,
  1.78762287e-01f, 4.50479798e-02f, -1.43113822e-01f, -1.07809277e-02f, -7.67884403e-02f, -8.74349549e-02f, -1.90462947e-01f, 1.87620930e-02f, 1.12064101e-01f, -5.77117801e-02f,
  -5.40245771e-02f, -8.59253630e-02f, -2.70700864e-02f, -6.19149953e-02f, -2.42491476e-02f, -7.17810392e-02f, -1.86250508e-02f, -7.50728920e-02f, -1.25189394e-01f, -8.27001035e-02f,
  -9.74715650e-02f, -3.57397348e-02f, -3.69910970e-02f, -5.11204712e-02f, 1.05868347e-01f, 3.99701595e-02f, -8.67764726e-02f, -3.20166461e-02f, -6.03595050e-03f, 2.46647298e-02f,
  -1.67844445e-01f, 2.26941351e-02f, -2.05380972e-02f, 6.91259503e-02f, -1.12418182e-01f, 4.47830334e-02f, -8.88182372e-02f, 7.02399090e-02f, -3.88275087e-02f, -4.13780846e-02f,
  -2.95059960e-02f, -2.76658963e-03f, 3.00620421e-04f, -7.94904679e-03f, -7.16133192e-02f, 2.34651156e-02f, -6.69743046e-02f, -4.77610081e-02f, -6.39775246e-02f, -3.32128555e-02f,
  -1.01389535e-01f, -1.87851358e-02f, -9.10290703e-02f, 2.30994001e-02f, 1.76166520e-02f, -5.32057062e-02f, -4.04984355e-02f, 8.85091200e-02f, 7.90570006e-02f, 4.53292392e-02f,
  7.52984434e-02f, -1.00830145e-01f, 3.68796177e-02f, 7.95978233e-02f, -3.87365855e-02f, 3.95545363e-02f, 4.05985080e-02f, -4.24528532e-02f, 6.37470633e-02f, 7.50796199e-02f,
  -4.65334617e-02f, 7.95561448e-02f, -6.35382310e-02f, 3.08215115e-02f, -3.81041178e-03f, 7.77799040e-02f, -7.01703355e-02f, -3.51976342e-02f, -2.42230576e-02f, -1.73489731e-02f,
  5.42873926e-02f, -6.35425076e-02f, -5.57333082e-02f, -4.45327256e-03f, 2.91824173e-02f, 7.29409903e-02f, -5.66675887e-02f, 5.74813895e-02f, 3.32814492e-02f, 4.13010418e-02f,
  -1.01778582e-02f, -1.12695456e-01f, -6.66092262e-02f, -5.49758924e-03f, 3.24342996e-02f, -6.30071163e-02f, -7.64316395e-02f, 2.82410234e-02f, 4.32706363e-02f, -1.98115818e-02f,
  -4.83409762e-02f, -5.45870028e-02f, -4.59988080e-02f, -8.29725638e-02f, -7.37228841e-02f, 3.99404727e-02f, 9.07728449e-02f, 6.66107535e-02f, -4.66274880e-02f, 1.35451406e-02f,
  4.95702438e-02f, 8.32897201e-02f, 5.42981960e-02f, -1.87137257e-02f, 3.97252738e-02f, -1.00429967e-01f, -9.07639228e-03f, -6.01049028e-02f, -8.11760649e-02f, 1.09297983e-01f,
  -3.38716507e-01f, 1.75341412e-01f, -9.78095978e-02f, -1.00996855e-04f, 5.77769503e-02f, 2.23849967e-01f, 3.18372577e-01f, 1.98671266e-01f, 6.02881797e-02f, 5.35947978e-02f,
  -5.57429567e-02f, -1.57924026e-01f, -1.35325650e-02f, -7.94784948e-02f, 5.38505688e-02f, 1.77829400e-01f, 5.01136854e-02f, -5.71319722e-02f, -1.32036120e-01f, 3.45218182e-02f,
  1.45562097e-01f, -1.03198536e-01f, -7.55152628e-02f, -1.09508641e-01f, -4.52828147e-02f, -1.41153857e-01f, -3.49218026e-02f, -6.40540719e-02f, 1.51332319e-02f, -1.76022388e-02f,
  -3.30131680e-01f, -9.95236784e-02f, -3.86297852e-02f, -9.50215533e-02f, -1.40719131e-01f, -9.64151546e-02f, -7.93217272e-02f, -1.22293971e-01f, 3.12955678e-02f, -5.26353233e-02f,
  -1.16035759e-01f, 3.69582437e-02f, -4.94264103e-02f, 9.57458932e-03f, -6.73889667e-02f, 2.88318582e-02f, 6.86395308e-03f, -4.51877899e-02f, -9.60385278e-02f, -4.79432978e-02f,
  7.24989027e-02f, 6.77871481e-02f, -3.77797000e-02f, 7.75321126e-02f, -1.82422362e-02f, -3.44285145e-02f, -5.86146489e-02f, -8.45749825e-02f, -1.11387558e-01f, -9.63689294e-03f,
  2.25556828e-02f, -1.84403080e-02f, 1.73967909e-02f, 2.10538376e-02f, -5.80961769e-03f, 7.79630691e-02f, -3.66476439e-02f, 1.13967665e-01f, -4.92586335e-03f, -3.83205637e-02f,
  1.22642359e-02f, -8.07107091e-02f, -1.15991561e-02f, -5.72947487e-02f, 4.07504067e-02f, -3.01307123e-02f, 1.14903878e-02f, 5.23924828e-02f, -1.00636631e-02f, 1.81485079e-02f,
  -3.92104387e-02f, 2.33680978e-02f, -5.24964295e-02f, 6.51744232e-02f, -6.97815567e-02f, 2.60543022e-02f, 5.02379378e-03f, -9.52572823e-02f, -1.58447563e-03f, -5.58881424e-02f,
  -2.05079764e-01f, 2.01992281e-02f, -2.06544232e-02f, -1.13923088e-01f, -6.02860190e-02f, -7.99455866e-02f, 4.36845645e-02f, 5.60635142e-02f, -7.70829841e-02f, -5.30820526e-02f,
  7.51578584e-02f, -6.67008311e-02f, -5.11560775e-03f, 3.84981781e-02f, -8.22110847e-02f, -8.50867108e-02f, 8.67070630e-02f, 1.32823708e-02f, 4.84780781e-02f, -6.52875304e-02f,
  1.44383654e-01f, 7.92449713e-02f, 1.63901632e-03f, 1.29460357e-02f, 3.48834805e-02f, -4.31919331e-03f, 2.59311381e-03f, -2.72986032e-02f, 4.02202095e-05f, 1.26138628e-01f,
  3.39141414e-02f, 1.94971673e-02f, -2.01357573e-01f, -6.55091461e-03f, 1.13354824e-01f, -3.48459631e-02f, 1.17450602e-01f, 6.27260208e-02f, 5.53427860e-02f, 9.58340466e-02f,
  7.23456293e-02f, 3.00011691e-02f, -1.09645493e-01f, -1.71943471e-01f, -7.20932409e-02f, 8.52818340e-02f, 1.28042344e-02f, -1.51065618e-01f, -1.10345565e-01f, 6.44778758e-02f,
  6.99363202e-02f, -1.42210452e-02f, 2.87035294e-02f, 1.84254367e-02f, 1.05095074e-01f, -1.92974042e-02f, 3.20835002e-02f, 3.12361773e-02f, 2.03803815e-02f, -2.44109649e-02f,
  -1.77889764e-01f, 5.90231568e-02f, -1.82302427e-02f, -8.13570991e-02f, -2.41893120e-02f, -5.13773821e-02f, -1.25559596e-02f, 6.88868156e-03f, 1.33796260e-02f, -5.69362380e-02f,
  -1.93825494e-02f, -6.28005415e-02f, -6.82498366e-02f, -9.67558660e-03f, 7.28275031e-02f, 5.20384535e-02f, -9.40328315e-02f, -8.12320486e-02f, -1.02332614e-01f, 1.94443166e-02f,
  3.57905552e-02f, -8.51095542e-02f, 2.57790741e-02f, 7.44988071e-03f, -6.87380135e-02f, -1.51586244e-02f, -9.56136659e-02f, -1.14908271e-01f, -1.34599366e-04f, 1.57728232e-02f,
  2.63277013e-02f, -1.56908855e-02f, 1.69057921e-02f, 7.64907375e-02f, 5.58050163e-02f, 4.89212871e-02f, -4.21995670e-02f, 4.15206392e-04f, -6.43576756e-02f, 1.91090610e-02f,
  -4.49381471e-02f, 1.54956477e-02f, -5.97097389e-02f, 3.41115077e-03f, -2.23331898e-02f, 2.14819767e-04f, -7.22632650e-03f, 7.87656978e-02f, -1.41962012e-02f, 1.99784841e-02f,
  -8.90175551e-02f, 2.55614109e-02f, -2.03293059e-02f, -2.44618505e-02f, 2.89445184e-03f, -5.30711263e-02f, -1.25560202e-02f, 3.15228961e-02f, 3.63531634e-02f, -4.29015653e-03f,
  1.78684518e-01f, -8.28477144e-02f, -1.21375784e-01f, -7.15628862e-02f, -2.95468885e-02f, -8.45707133e-02f, 7.89644793e-02f, -1.32861614e-01f, -2.94737816e-02f, -1.47465775e-02f,
  -6.95384517e-02f, -1.23756926e-03f, -4.39576022e-02f, 3.31667513e-02f, 1.99713819e-02f, 1.93264019e-02f, 9.65728387e-02f, -9.96803492e-02f, 1.63374580e-02f, 6.62436336e-02f,
  4.96854670e-02f, 8.24968517e-02f, 5.66662960e-02f, -2.26237904e-02f, 6.86641186e-02f, 2.33989693e-02f, -8.35039914e-02f, -5.48663624e-02f, -6.08860292e-02f, 1.24827258e-01f,
  1.22529089e-01f, -8.36773962e-02f, -1.31008580e-01f, 1.97680041e-01f, 7.85341337e-02f, -5.12883030e-02f, -5.71325347e-02f, 1.31043002e-01f, 1.64710209e-01f, -1.92217287e-02f,
  9.36679076e-03f, -5.38122002e-03f, 1.02644227e-01f, -3.96102257e-02f, 2.69327145e-02f, -8.31093714e-02f, 1.51258046e-02f, 2.12963875e-02f, 1.30424291e-01f, -1.73185337e-02f,
  2.04475652e-02f, -3.43675986e-02f, 7.54089355e-02f, 8.69079232e-02f, -1.02383886e-02f, -1.88193806e-02f, -5.40444404e-02f, -1.70764610e-01f, -5.63356988e-02f, -1.47237197e-01f,
  -2.54648358e-01f, -1.74233124e-01f, 8.86057541e-02f, 2.70146672e-02f, -9.68605354e-02f, -3.60531569e-03f, -4.89797331e-02f, 1.47720994e-02f, -2.00583152e-02f, 5.41533493e-02f,
  -4.25893590e-02f, -9.41707492e-02f, 8.68855976e-03f, -8.34331941e-03f, -1.06065283e-02f, -7.32187778e-02f, 4.61288393e-02f, -1.12237670e-01f, -7.93182254e-02f, -1.13593638e-01f,
  -7.84750953e-02f, -1.14268828e-02f, -1.04937725e-01f, 1.77746825e-02f, 9.98910982e-03f, -1.98808592e-02f, -4.96537685e-02f, -1.87331572e-01f, 2.91850418e-02f, 3.48703824e-02f,
  9.23695266e-02f, -2.75934748e-02f, 2.66002435e-02f, 7.04091638e-02f, -5.79394288e-02f, -2.31802110e-02f, 8.88959765e-02f, 4.94202692e-03f, 8.08550790e-02f, -6.44480363e-02f,
  3.94785665e-02f, 5.07893264e-02f, -9.02246758e-02f, -6.44359970e-03f, -4.35582884e-02f, -9.54339430e-02f, 3.85071076e-02f, -5.79384379e-02f, -5.47357872e-02f, 4.10917141e-02f,
  1.68963727e-02f, -1.10422403e-01f, -8.85130912e-02f, -3.78030688e-02f, -1.08514085e-01f, -7.78519586e-02f, 7.05733523e-02f, -2.30497159e-02f, 2.21288707e-02f, 3.15833464e-02f,
  9.58160236e-02f, 1.54139921e-01f, 3.72357965e-02f, 7.41790533e-02f, -5.20333536e-02f, -5.36660617e-03f, -3.01236343e-02f, -7.41451653e-03f, -2.51886826e-02f, 5.11544906e-02f,
  -1.15145959e-01f, -6.47685453e-02f, -3.63377742e-02f, -8.70242566e-02f, 8.51541013e-02f, -3.13478857e-02f, 3.76627855e-02f, -2.20343634e-03f, -3.24133746e-02f, 2.92013995e-02f,
  1.00557096e-02f, 1.30682170e-01f, 1.92349210e-01f, 5.15399463e-02f, -5.09299748e-02f, 1.45719916e-01f, 3.24245915e-02f, 9.02801380e-02f, 3.17529142e-02f, 1.80165291e-01f,
  -1.72924533e-01f, -1.60670146e-01f, -4.63062942e-01f, -2.59616971e-01f, -1.42534241e-01f, 1.78608298e-02f, 9.93541554e-02f, -1.19085638e-02f, -8.47241133e-02f, -2.16959804e-01f,
  -8.50278363e-02f, -3.76274511e-02f, -1.21694759e-01f, -2.81210691e-02f, -1.29156886e-02f, -1.76422015e-01f, -1.15887426e-01f, -1.38915107e-01f, 5.97726693e-03f, 4.46651019e-02f,
  -4.39763218e-02f, -2.92898983e-01f, -1.92192212e-01f, -1.97595343e-01f, -1.48898840e-01f, -2.24155292e-01f, -3.68893921e-01f, -1.29147381e-01f, -1.32500529e-01f, -2.94538856e-01f,
  -1.26375794e-01f, -3.59368213e-02f, 5.90073355e-02f, 6.09323569e-02f, -1.56894922e-01f, 5.53074246e-03f, -8.02155286e-02f, -9.57332402e-02f, 5.60603961e-02f, -9.04341042e-02f,
  2.70873215e-02f, 7.37645999e-02f, 2.93399557e-03f, -2.18099561e-02f, -1.06864870e-01f, 5.69119379e-02f, -6.39865361e-03f, -5.02441898e-02f, -2.90776100e-02f, 1.29729614e-01f,
  -8.68256669e-03f, 7.49237016e-02f, -2.13216264e-02f, 7.51124248e-02f, 1.54439151e-01f, 4.31165844e-02f, -4.12800461e-02f, 5.15941009e-02f, 4.23828475e-02f, -1.14637636e-01f,
  4.84063178e-02f, -7.61750117e-02f, 1.09668355e-02f, -4.50306013e-02f, 6.19715415e-02f, -3.29780877e-02f, -6.04400896e-02f, -3.88226882e-02f, 3.68385948e-03f, -1.29239053e-01f,
  8.69666599e-03f, -1.80616998e-03f, 5.07203154e-02f, -4.83715981e-02f, -7.05635399e-02f, -5.95593937e-02f, 1.36757255e-01f, -1.20963459e-03f, 6.04229607e-02f, -4.49197367e-02f,
  8.31449330e-02f, -5.78009943e-03f, -4.79604974e-02f, -1.21987099e-02f, 2.58737542e-02f, -3.16991434e-02f, 8.85500833e-02f, 8.36745203e-02f, 3.52399098e-03f, 1.19077545e-02f,
  -2.68559247e-01f, 3.91133688e-02f, -9.32375863e-02f, -4.67178226e-02f, -3.32175791e-02f, 1.19044620e-03f, -1.30698591e-01f, -1.16428398e-02f, 1.24712661e-02f, 1.42001119e-02f,
  2.48077754e-02f, -1.21096307e-02f, -1.32701069e-01f, -1.61524191e-02f, -3.68836969e-02f, 6.08247705e-03f, -3.41362320e-02f, -6.91380203e-02f, 1.06414087e-01f, 3.89184095e-02f,
  5.61931916e-02f, 7.43195415e-02f, -4.38156500e-02f, 5.93710840e-02f, 1.14587769e-01f, -4.58491175e-03f, 3.66921313e-02f, -6.72028540e-03f, 6.92687035e-02f, -1.84224859e-01f,
  5.05794764e-01f, 2.69712687e-01f, -4.28624809e-01f, 1.08269565e-01f, -2.43761748e-01f, -1.89348340e-01f, -5.84910400e-02f, 4.57325876e-02f, 1.51929677e-01f, 1.42699271e-01f,
  -7.14896061e-03f, 4.44408730e-02f, 2.19620690e-02f, 4.85018715e-02f, 5.57751544e-02f, -1.08337268e-01f, -9.95806083e-02f, -1.95703566e-01f, -2.79638857e-01f, -1.41536161e-01f,
  4.97736409e-02f, 6.24498166e-02f, 1.04610972e-01f, 3.29803266e-02f, 3.23503129e-02f, -1.04889181e-02f, -9.39217359e-02f, 6.59068814e-03f, -8.55067223e-02f, -3.22567225e-02f,
  -2.95146883e-01f, -6.31221086e-02f, -1.55876189e-01f, 1.80448338e-01f, -1.11532770e-01f, 5.54520451e-02f, 4.22084145e-02f, 4.11622338e-02f, 5.57420850e-02f, 1.30440414e-01f,
  1.28863463e-02f, 2.27106130e-03f, 1.33739822e-02f, 1.20324055e-02f, 8.35163891e-03f, 1.82058681e-02f, 1.11611269e-01f, 6.24226108e-02f, 5.04375212e-02f, 3.05756573e-02f,
  2.08737189e-03f, -4.90517765e-02f, -6.35571703e-02f, -3.58586684e-02f, -1.01834469e-01f, -1.28424734e-01f, -1.78473443e-01f, -4.62080911e-02f, -1.43261090e-01f, 1.86543897e-01f,
  -9.76137910e-03f, -5.23669124e-02f, -4.19188105e-02f, 3.21144313e-02f, 9.43558440e-02f, -4.34990264e-02f, 3.84621769e-02f, -5.60219735e-02f, -2.62393747e-02f, 7.28691146e-02f,
  2.66449563e-02f, -1.11532733e-01f, -3.00793210e-03f, 2.13063192e-02f, 2.11914983e-02f, 2.38856096e-02f, -5.65601513e-02f, -1.69746093e-02f, -6.63067326e-02f, -2.92018503e-02f,
  1.74560230e-02f, -2.04332918e-02f, 2.27125157e-02f, -2.37293337e-02f, -5.75737804e-02f, -4.02038246e-02f, -6.67517409e-02f, 4.53738198e-02f, 2.72382144e-02f, 4.45179008e-02f,
  2.20120400e-01f, -2.31881499e-01f, 9.32370722e-02f, 5.70324548e-02f, -1.36419520e-01f, 5.71434796e-02f, -1.95923764e-02f, -8.07183515e-03f, -3.02128382e-02f, 7.55028287e-03f,
  -8.28927606e-02f, 4.14637998e-02f, -1.24700470e-02f, 4.11609672e-02f, -4.68624048e-02f, -3.21156345e-02f, 1.74144700e-01f, 6.58418462e-02f, -7.30316117e-02f, -1.06868523e-04f,
  1.05890967e-01f, 3.43443751e-02f, 4.95689623e-02f, 2.83606835e-02f, 2.10725907e-02f, 4.08459194e-02f, 2.91580427e-02f, -5.96084520e-02f, 1.42621659e-02f, 4.06021744e-01f,
  -3.37664396e-01f, 4.70539462e-03f, -1.76127508e-01f, -2.06372980e-02f, -1.18459865e-01f, -1.71903893e-01f, 2.95869745e-02f, -2.09642667e-02f, -7.46810958e-02f, 9.47056562e-02f,
  9.36739072e-02f, -1.29282236e-01f, -1.26363486e-01f, -1.11787982e-01f, -1.61797479e-01f, -3.87764648e-02f, -1.01236880e-01f, -3.14220876e-01f, -2.74320453e-01f, -1.57620057e-01f,
  -7.04120770e-02f, -6.08280711e-02f, -1.76499188e-01f, -1.12224877e-01f, -2.31249779e-02f, -5.47661819e-02f, -7.47302324e-02f, -1.19125068e-01f, -1.58179179e-01f, -1.20914899e-01f,
  2.36380473e-02f, -1.14436850e-01f, 1.75128188e-02f, -7.60262460e-02f, -1.06754705e-01f, -6.50768429e-02f, -8.57979506e-02f, -7.11024776e-02f, -1.73549876e-02f, 3.77909793e-03f,
  -2.64444277e-02f, -8.75447541e-02f, -1.11918807e-01f, -2.38046944e-02f, -5.64706661e-02f, -6.62803277e-02f, -1.01660028e-01f, -1.63606182e-01f, -1.10658392e-01f, 8.30809325e-02f,
  2.98010707e-02f, -1.73073560e-01f, -1.42101929e-01f, -5.63939139e-02f, -2.64872741e-02f, -1.08338237e-01f, 5.76184504e-02f, -8.68505761e-02f, 1.54969878e-02f, 1.16520695e-01f,
  -4.11602035e-02f, 8.47211629e-02f, 8.35287571e-02f, 1.12168737e-01f, 2.71535721e-02f, -1.02563649e-02f, 2.65402179e-02f, -4.54354361e-02f, 4.16721590e-02f, 4.81279530e-02f,
  4.86480668e-02f, 7.21932501e-02f, 5.68942726e-02f, -6.44117743e-02f, 1.28050474e-02f, -9.06181931e-02f, 4.73806262e-02f, -1.81838349e-02f, 4.26990129e-02f, 2.69577019e-02f,
  -1.18539343e-02f, -2.02551167e-02f, 6.61177710e-02f, 8.81485045e-02f, -4.91775423e-02f, -5.47950417e-02f, 8.78764763e-02f, 7.12213591e-02f, -3.53083089e-02f, 2.23810319e-02f,
  1.57421574e-01f, -2.12669954e-01f, 3.32628493e-03f, 1.46331610e-02f, 3.64548266e-02f, -7.13303834e-02f, 5.52940741e-02f, 4.29824702e-02f, 4.55037430e-02f, -4.97359829e-03f,
  -5.75684607e-02f, 8.61447826e-02f, -3.96477021e-02f, -5.86750470e-02f, -4.43492234e-02f, 3.92787755e-02f, -4.07859683e-02f, -1.47859007e-01f, -1.39368987e-02f, 1.03146350e-02f,
  3.74129452e-02f, -1.33208767e-01f, -4.38936390e-02f, 3.32691520e-02f, -5.73021285e-02f, -9.29827020e-02f, -1.91413760e-02f, 3.59370746e-02f, -2.60718875e-02f, 1.48660466e-01f,
  -2.34430194e-01f, -4.25783582e-02f, 4.74324971e-02f, -1.47458225e-01f, 8.62371363e-03f, 8.52289349e-02f, 1.42963767e-01f, -4.98047844e-02f, -1.41920105e-01f, -1.21769182e-01f,
  -7.01941997e-02f, -1.85667291e-01f, -4.63900790e-02f, 2.57025883e-02f, -2.27449629e-02f, 1.24288723e-02f, 1.50548303e-02f, 9.04077291e-02f, 2.56492589e-02f, -1.09559363e-02f,
  1.80234443e-02f, -1.41421616e-01f, -1.19067609e-01f, -2.91956384e-02f, -1.93482235e-01f, -3.48208137e-02f, -5.80846705e-02f, -1.16201982e-01f, 4.75799441e-02f, -9.32586938e-03f,
  -1.38251588e-01f, -6.88965917e-02f, 1.00262769e-01f, -1.88974068e-02f, 2.91710980e-02f, 4.91985567e-02f, -3.29986885e-02f, -9.78650078e-02f, 2.55568381e-02f, -2.61816531e-02f,
  -7.74220377e-02f, 8.61777179e-03f, -1.56876132e-01f, 3.90130281e-02f, 3.20996158e-02f, -5.89767657e-02f, -4.65205088e-02f, -2.43883617e-02f, 3.80734950e-02f, -5.01205400e-02f,
  4.90540713e-02f, -1.21348146e-02f, -1.44570425e-01f, -9.39699262e-03f, 7.74877593e-02f, -6.14334038e-03f, -5.73029406e-02f, 5.60690463e-02f, 1.60685310e-03f, -1.54664338e-01f,
  5.26053198e-02f, 2.68808436e-02f, 2.86608469e-02f, -5.08627817e-02f, -6.56158403e-02f, -5.24915606e-02f, -2.56304611e-02f, -2.85163941e-03f, -3.75747122e-02f, 1.88566465e-02f,
  3.02970354e-02f, 1.11425705e-02f, -3.59896012e-02f, 3.30067053e-02f, -9.55379233e-02f, 2.02738736e-02f, -1.17459586e-02f, 1.25415875e-02f, -1.75815802e-02f, -8.15242603e-02f,
  2.70033255e-02f, -3.99947679e-03f, -2.43267659e-02f, 3.36980410e-02f, -4.54549789e-02f, 5.58181070e-02f, -3.46263722e-02f, -2.90706828e-02f, -4.59963493e-02f, 3.36973593e-02f,
  -1.69600129e-01f, 3.07680935e-01f, -9.15016457e-02f, -6.40070587e-02f, -5.26324008e-03f, 5.26478477e-02f, -3.31173353e-02f, -4.84170355e-02f, -4.63061184e-02f, -8.64731967e-02f,
  -3.85194011e-02f, -5.43567389e-02f, -2.11421438e-02f, -5.72716519e-02f, 3.76245491e-02f, -6.44694045e-02f, -5.68773001e-02f, -1.37282923e-01f, -6.84269592e-02f, -7.28111416e-02f,
  2.76971306e-03f, -2.15602368e-02f, -1.73138082e-01f, -1.47615731e-01f, -9.86414775e-02f, -1.80453792e-01f, -4.00572233e-02f, -1.86504975e-01f, -5.20886704e-02f, -1.77635312e-01f,
  9.38376188e-02f, -2.85610817e-02f, 1.56094253e-01f, 2.16673717e-01f, 2.03855604e-01f, 1.36992052e-01f, 2.88402792e-02f, 1.04655489e-01f, 1.64023116e-02f, -2.77567338e-02f,
  -1.52835712e-01f, -2.45811671e-01f, -1.58491477e-01f, -7.29408115e-02f, -7.55389929e-02f, -1.06482804e-02f, 6.99245483e-02f, 1.59302637e-01f, 2.01907903e-02f, 1.31782949e-01f,
  4.49837223e-02f, 2.48197597e-02f, 1.83366090e-01f, 3.64136994e-02f, -2.81929914e-02f, -8.60685855e-02f, -1.20562799e-02f, -3.35615650e-02f, -8.63095000e-02f, 1.31950617e-01f,
  -1.73231333e-01f, -3.18526924e-02f, 8.06580782e-02f, -3.17614377e-02f, -1.73920333e-01f, -3.52880266e-03f, -1.18252460e-03f, -9.90779474e-02f, -1.13111846e-01f, 1.78327225e-02f,
  -1.13263249e-01f, -2.84439567e-02f, 1.16575854e-02f, -8.57770517e-02f, 7.72363618e-02f, 5.09121418e-02f, 7.10411742e-02f, -3.54189202e-02f, -6.94068000e-02f, -6.75808489e-02f,
  -1.64344177e-01f, -1.63544081e-02f, -1.55799184e-02f, 3.75180840e-02f, -2.11507455e-02f, -1.92007963e-02f, -7.36970007e-02f, -1.01348601e-01f, 2.62333751e-02f, 5.80378957e-02f,
  3.23260352e-02f, -9.17411521e-02f, 3.99720706e-02f, -5.94658703e-02f, 3.08617093e-02f, -1.81388147e-02f, -3.04928441e-02f, -2.78162211e-02f, 1.24840990e-01f, 1.09141126e-01f,
  8.52518082e-02f, -3.59904580e-02f, 7.24699274e-02f, 1.64628476e-02f, -3.81723978e-02f, 3.44512537e-02f, 1.97927319e-02f, -5.53647876e-02f, -4.59996872e-02f, -5.05208634e-02f,
  5.89221381e-02f, 4.19748053e-02f, 7.42055327e-02f, -1.32967317e-02f, 5.28707840e-02f, -1.87763423e-02f, -2.86772870e-03f, -6.89568045e-03f, 2.36929525e-02f, 1.81832034e-02f,
  -6.31629229e-02f, -7.83606172e-02f, -1.09592713e-02f, -9.07708406e-02f, -1.89159326e-02f, 5.07914685e-02f, -4.76450101e-02f, 6.58746138e-02f, 3.42079364e-02f, -1.28019452e-02f,
  9.95070022e-03f, -1.06978239e-02f, -1.65138915e-01f, 8.95455033e-02f, 6.58014789e-02f, 4.87941019e-02f, -3.36172096e-02f, 8.81994143e-02f, 3.50009557e-03f, -9.24847052e-02f,
  3.81052606e-02f, 1.01677448e-01f, 1.85555488e-01f, 1.12051234e-01f, -6.45406991e-02f, 4.73537445e-02f, 8.82901475e-02f, -4.82396670e-02f, -1.18757668e-03f, 2.23826811e-01f,
  3.48235965e-01f, 1.43515870e-01f, 2.54310250e-01f, -1.07177265e-01f, -2.54164100e-01f, -1.96289554e-01f, -1.30199835e-01f, -9.68529657e-02f, 2.74408497e-02f, -4.91086282e-02f,
  -1.53301939e-01f, 4.22939146e-03f, 2.42692195e-02f, 6.85321540e-02f, 2.36556858e-01f, -1.57868993e-02f, 1.36892393e-01f, 2.85407126e-01f, 2.09348738e-01f, 7.47284293e-02f,
  8.69413838e-03f, -1.63185457e-03f, 3.00272435e-01f, 1.39398515e-01f, -9.10243168e-02f, -4.57829349e-02f, 1.02086455e-01f, 9.04903859e-02f, -2.96199359e-02f, 9.53165889e-02f,
  5.88222407e-02f, 1.54698700e-01f, -8.14892724e-02f, -7.85022750e-02f, -1.19830303e-01f, 3.48393954e-02f, -6.70198277e-02f, 6.57649562e-02f, 5.94532676e-03f, -4.47776392e-02f,
  -1.45043761e-01f, 7.14084357e-02f, 2.13434845e-02f, -8.08059610e-03f, -3.10784578e-02f, 5.46450280e-02f, 6.54995367e-02f, 2.03187242e-01f, 9.69679579e-02f, 9.88001078e-02f,
  -1.96990013e-01f, -7.16904104e-02f, -7.56472349e-02f, -5.56129403e-03f, -1.58800948e-02f, -9.01798308e-02f, 4.24876735e-02f, 8.20906684e-02f, 1.75537579e-02f, 8.19236636e-02f,
  1.46291628e-02f, 3.34245898e-02f, 2.21500956e-02f, -1.18465116e-02f, -2.30367929e-02f, 6.49847835e-02f, 2.19394243e-03f, -5.51085956e-02f, 1.22325039e-02f, -3.05795148e-02f,
  -1.14573343e-02f, 4.18032706e-02f, -3.56887048e-03f, 4.40645143e-02f, 5.37419841e-02f, 1.78476404e-02f, 6.52792305e-02f, 2.12417133e-02f, -7.45132193e-02f, 4.05697338e-02f,
  5.68668954e-02f, 1.76569223e-02f, 8.40068795e-04f, 1.09258205e-01f, 4.03200798e-02f, -4.44741687e-03f, 6.23029144e-03f, -8.86685625e-02f, 9.46097309e-04f, 7.10102841e-02f,
  -1.23594746e-01f, -7.12385401e-02f, -4.78368290e-02f, -1.81037523e-02f, -9.16127041e-02f, -1.49368756e-02f, -1.23085029e-01f, -2.34657619e-02f, -1.24822974e-01f, 1.41840624e-02f,
  -1.49717461e-02f, 1.67652983e-02f, -9.47183445e-02f, 3.13136354e-02f, 9.25198290e-03f, -7.16398507e-02f, -8.26442707e-03f, 3.81933376e-02f, 5.00463098e-02f, 2.54782382e-02f,
  8.28040205e-03f, -1.60778999e-01f, -9.32510942e-02f, -1.13510668e-01f, -8.30909535e-02f, -1.63671538e-01f, 1.24399364e-02f, -5.13804629e-02f, -6.69547319e-02f, -6.13417849e-02f,
  2.32647553e-01f, 2.04328746e-01f, 2.26546839e-01f, -1.78653449e-02f, -1.27698198e-01f, -1.12737231e-01f, -1.05722643e-01f, -6.03562593e-02f, -7.00784698e-02f, -6.53410330e-02f,
  -1.58776328e-01f, -1.90160833e-02f, 3.56959389e-03f, -1.04816891e-01f, -5.89192919e-02f, 2.30868068e-02f, 2.61103418e-02f, 9.47011560e-02f, -6.92337379e-02f, -1.57800585e-01f,
  -1.14945568e-01f, 1.04623241e-02f, 1.10868074e-01f, 6.73838928e-02f, 1.14923999e-01f, 4.96780910e-02f, 1.59765527e-01f, 1.59762412e-01f, -3.06488387e-02f, 4.11440469e-02f,
  3.10351159e-02f, 1.55575886e-01f, -1.40287414e-01f, -8.00838098e-02f, 8.53092596e-02f, 7.70758018e-02f, 4.32285927e-02f, 1.58508882e-01f, -5.65059260e-02f, 2.97536310e-02f,
  -1.08428791e-01f, 6.49242755e-03f, -5.81733547e-02f, 6.44366890e-02f, 6.59536337e-03f, -2.98081245e-02f, 2.09853128e-02f, 1.28762186e-01f, 6.49946481e-02f, -1.09824790e-02f,
  -8.36474448e-02f, -7.21138120e-02f, -4.36962247e-02f, -7.47341439e-02f, 1.74882244e-02f, 8.30247253e-03f, -5.68966102e-03f, 3.78980450e-02f, 7.41562769e-02f, 1.94808468e-02f,
  -2.45575588e-02f, 5.00714965e-02f, -6.15761476e-03f, 4.85069305e-02f, -4.39027697e-02f, 1.23678166e-02f, 8.42231736e-02f, -9.55673009e-02f, 2.54353974e-02f, -2.37381402e-02f,
  9.99203324e-02f, 3.14073749e-02f, 6.08197823e-02f, 7.77992457e-02f, -2.90436745e-02f, 1.80374291e-02f, -2.38171276e-02f, 3.31091583e-02f, -2.10271105e-02f, -7.92281982e-03f,
  -1.08215949e-02f, 4.27783504e-02f, -5.55691682e-03f, 1.12881854e-01f, -6.76661208e-02f, 6.13353960e-03f, -1.64287314e-02f, 2.64467616e-02f, -1.12786088e-02f, -7.87174180e-02f,
  -1.23420887e-01f, -1.08402275e-01f, -1.64891109e-01f, 3.60805541e-02f, 7.67367485e-04f, 5.74557856e-02f, -1.03477210e-01f, 6.64349496e-02f, -1.00904368e-02f, -2.90836411e-04f,
  -8.04815907e-03f, -5.88706287e-04f, 3.72788198e-02f, -5.25738969e-02f, -3.56090218e-02f, -1.78290308e-02f, -3.31047513e-02f, -3.72266583e-02f, -1.69698838e-02f, 4.97904606e-02f,
  -1.20357357e-01f, -1.34084776e-01f, -1.58949733e-01f, -6.58613294e-02f, -7.64456019e-02f, -1.65253371e-01f, -1.86397567e-01f, -1.38671160e-01f, -9.83468220e-02f, -2.16523796e-01f,
  -1.61782593e-01f, 3.92376371e-02f, 1.70270622e-01f, 6.92691430e-02f, 3.01137883e-02f, -4.15717363e-02f, 1.36781335e-02f, -9.14089009e-02f, -2.25059651e-02f, -1.98555626e-02f,
  4.11248058e-02f, -5.57660265e-03f, 3.84395779e-03f, -7.83242434e-02f, -1.03601210e-01f, -5.30157723e-02f, 7.77044445e-02f, -3.29201948e-03f, 1.43160308e-02f, -1.74627528e-01f,
  -1.42257720e-01f, -2.56287232e-02f, -8.11886694e-03f, -2.94487067e-02f, -2.95573752e-02f, -6.58195093e-02f, 7.78178871e-02f, -4.89163250e-02f, -8.98322538e-02f, -7.41723403e-02f,
  2.77329162e-02f, 6.34419248e-02f, -2.04342045e-02f, 4.10387553e-02f, 6.34601861e-02f, -2.13428568e-02f, 4.28040922e-02f, 1.31320968e-01f, 2.62503698e-02f, 8.95289406e-02f,
  1.29156455e-01f, 7.73776621e-02f, 7.95626715e-02f, 1.03445329e-01f, 6.16679713e-02f, -3.71767431e-02f, 1.57846332e-01f, 3.36924642e-02f, 1.38269007e-01f, 6.29027858e-02f,
  -2.02954356e-02f, 1.45077007e-02f, 4.17477265e-02f, 1.13653436e-01f, 1.06464013e-01f, 3.49846929e-02f, 1.37507329e-02f, -5.87134212e-02f, -1.04589295e-02f, -1.19134299e-01f,
  -4.75341305e-02f, 5.84316626e-02f, -1.90024301e-02f, 4.53994125e-02f, -7.88415298e-02f, -7.31188152e-03f, -1.44245499e-03f, 2.21179798e-02f, -2.93208547e-02f, -4.61498685e-02f,
  -4.14790958e-02f, 5.10287434e-02f, 1.99268982e-02f, 1.42433159e-02f, 1.28894690e-02f, 6.28931224e-02f, -4.64076698e-02f, 3.94589603e-02f, 2.97644176e-02f, 8.45999047e-02f,
  -6.16611578e-02f, 4.62044001e-04f, 1.54560864e-01f, 4.80516208e-03f, 7.13658184e-02f, -3.81270349e-02f, -3.52327824e-02f, 7.67151415e-02f, 5.42643517e-02f, -4.19914871e-02f,
  -1.02619067e-01f, 9.69662666e-02f, -1.06526434e-01f, 2.18450977e-03f, 4.62534502e-02f, 1.34696990e-01f, -6.44308254e-02f, 1.09482057e-01f, -5.96741855e-04f, 1.81991793e-02f,
  1.05932625e-02f, 3.16956267e-02f, -1.03274789e-02f, 7.35654905e-02f, 8.23758834e-04f, -4.05670516e-02f, 4.33717892e-02f, 1.74529757e-02f, 1.12701587e-01f, 1.86877146e-01f,
  1.27140194e-01f, -2.01470125e-02f, -8.95317346e-02f, -2.68574376e-02f, -6.91682398e-02f, -1.15388751e-01f, 1.14848847e-02f, -1.07312270e-01f, -1.13722958e-01f, -1.82741314e-01f,
  6.10411316e-02f, -1.82075098e-01f, -3.52626055e-01f, 1.21509060e-01f, -2.51907874e-02f, -1.36517227e-01f, -2.43789867e-01f, -9.18112472e-02f, 5.68113253e-02f, -1.77341431e-01f,
  -8.79600495e-02f, 2.87840422e-02f, -1.16711678e-02f, -1.14944972e-01f, -2.07016662e-01f, -3.19310427e-01f, -3.64934742e-01f, -2.79553682e-01f, -1.91953078e-01f, 2.68702153e-02f,
  -1.38418928e-01f, -5.67893172e-03f, -9.24595520e-02f, 7.28158429e-02f, 1.28047327e-02f, -7.43948342e-03f, -1.16019651e-01f, 4.17063013e-03f, -1.30669221e-01f, -2.96365451e-02f,
  -4.71300147e-02f, 3.50930728e-02f, 4.43251745e-04f, 2.62496453e-02f, -6.20684735e-02f, -2.35802867e-03f, 5.02698869e-02f, -4.85786758e-02f, 4.02044803e-02f, -2.58999839e-02f,
  -5.68842925e-02f, 8.69245604e-02f, 1.18833624e-01f, -3.94974947e-02f, 6.02846518e-02f, -2.01371778e-02f, -3.92156802e-02f, -6.00767098e-02f, -6.31872043e-02f, -9.06548928e-03f,
  1.36064366e-03f, -1.28811494e-01f, -9.03842002e-02f, -1.00757293e-01f, 6.72780052e-02f, -8.48832652e-02f, -5.20862155e-02f, 5.72105013e-02f, 7.05832317e-02f, 1.26433745e-01f,
  -3.58494744e-03f, 2.37389375e-02f, -4.92277034e-02f, -4.75671440e-02f, 6.82444423e-02f, -7.11055100e-03f, 2.85372138e-02f, 4.54627909e-02f, -8.45902041e-03f, 3.21789458e-02f,
  5.37405871e-02f, -4.27584574e-02f, 7.69790262e-02f, 2.88027730e-02f, 3.94099094e-02f, 2.17374824e-02f, -3.99368368e-02f, -6.35768697e-02f, -2.55780164e-02f, -3.36471060e-03f,
  -6.56022131e-02f, 2.57428102e-02f, 1.22230845e-02f, 5.53611219e-02f, -7.28453100e-02f, -3.94825451e-02f, -7.06062764e-02f, -5.04080579e-02f, -6.81694746e-02f, -4.35192175e-02f,
  2.22788304e-01f, -2.80714989e-01f, 6.63666874e-02f, 5.91737702e-02f, -7.94263184e-02f, -8.83377641e-02f, 1.08448416e-01f, -6.21143505e-02f, -3.74018252e-02f, -6.03784025e-02f,
  -4.23975326e-02f, -3.46850827e-02f, -4.27067727e-02f, 4.01328132e-03f, -8.73906612e-02f, 3.69904824e-02f, 2.48141028e-02f, 4.21755053e-02f, -2.51613054e-02f, 3.54879759e-02f,
  -6.31366596e-02f, -5.70740104e-02f, -1.16640225e-01f, -5.42856157e-02f, 7.41236564e-03f, -9.24307331e-02f, -4.81357276e-02f, -9.42089967e-03f, -9.89743695e-02f, -6.22795522e-02f,
  -2.37315163e-01f, -4.70000785e-03f, -2.89659686e-02f, -9.61883217e-02f, -4.47632559e-02f, -2.14878675e-02f, 4.25509661e-02f, -1.18423901e-01f, -1.26620099e-01f, -7.08722770e-02f,
  -4.68439311e-02f, -5.02280258e-02f, -2.21563708e-02f, 1.11537695e-01f, 3.65691073e-02f, 5.79862222e-02f, 5.18144146e-02f, 9.39337537e-02f, 1.00689285e-01f, -5.97291663e-02f,
  5.18095754e-02f, -5.61407097e-02f, 1.01209991e-01f, 8.04638714e-02f, -1.03167884e-01f, 1.07750874e-02f, 9.11091864e-02f, 4.50650342e-02f, 2.97133178e-02f, -6.72489479e-02f,
  1.35208592e-01f, -1.04070880e-01f, -5.75965047e-02f, -9.81842168e-03f, -1.09604886e-02f, 2.59805545e-02f, -2.87012476e-02f, 5.03785871e-02f, -3.50289978e-02f, -7.39275366e-02f,
  -7.43846521e-02f, 5.65266423e-02f, -7.76738450e-02f, 2.51461156e-02f, -6.94175065e-02f, -3.38520892e-02f, 8.14207420e-02f, 1.41114183e-02f, 3.75557914e-02f, 4.06514220e-02f,
  6.89344928e-02f, -1.47021562e-01f, -4.31539603e-02f, -1.90686267e-02f, -4.02947031e-02f, -4.11273167e-02f, -1.11678187e-02f, -8.02623406e-02f, -5.94272539e-02f, 3.18373889e-02f,
  -2.52094641e-02f, 4.76364326e-03f, -6.68907762e-02f, -6.44132048e-02f, 7.92954769e-03f, 4.09744270e-02f, -7.93296471e-02f, 8.36577192e-02f, -1.44196507e-02f, 1.66187473e-02f,
  -5.56512438e-02f, 3.16827744e-02f, -5.55840284e-02f, 6.87811151e-02f, -3.09680551e-02f, 3.69268693e-02f, -4.48626350e-04f, 1.04073295e-02f, -2.16851439e-02f, -6.19567484e-02f,
  -7.29354238e-03f, 4.43838052e-02f, -3.56064504e-03f, 7.47876018e-02f, -6.72449321e-02f, -1.32915955e-02f, 2.98702135e-03f, 4.72243577e-02f, 6.27586246e-02f, -4.82505709e-02f,
  2.08410397e-01f, 4.02682722e-02f, 4.73028561e-03f, -6.82934895e-02f, -5.11718094e-02f, 3.51966172e-03f, 2.48959288e-02f, 5.07671013e-02f, -7.05815628e-02f, -2.10252143e-02f,
  1.64085515e-02f, -7.87124708e-02f, 8.85091648e-02f, 4.86649126e-02f, 4.36392203e-02f, 2.76315082e-02f, 6.23940788e-02f, -8.15630406e-02f, 5.07277660e-02f, -5.87008372e-02f,
  -4.96940948e-02f, -8.16319510e-02f, -8.70196335e-03f, 8.94754604e-02f, -3.82733420e-02f, -3.06712892e-02f, 1.08960070e-01f, -6.09256960e-02f, 7.76911005e-02f, 1.19666882e-01f,
  3.31329554e-01f, 1.07409477e-01f, 2.01947540e-01f, 1.95052490e-01f, 2.79445767e-01f, 2.70232320e-01f, 2.24565133e-01f, 4.10847180e-02f, 7.24354386e-02f, 1.96529478e-01f,
  1.27677813e-01f, 6.22757897e-02f, 3.44218733e-03f, 7.64075965e-02f, 4.98934649e-02f, 4.09942046e-02f, 2.31766775e-02f, 4.50903773e-02f, 1.01539027e-02f, -2.71228738e-02f,
  3.06847971e-03f, 2.69503873e-02f, 5.29764071e-02f, 5.95517345e-02f, -6.38485402e-02f, 3.46081884e-04f, 6.74836934e-02f, 1.19238898e-01f, 2.05411483e-02f, -1.34300152e-02f,
  1.58002868e-01f, 2.61185348e-01f, -2.96935998e-02f, -1.25165746e-01f, -1.30388550e-02f, -9.71168429e-02f, 1.06310606e-01f, -4.33825999e-02f, 1.14171077e-02f, -1.19250767e-01f,
  1.10890586e-02f, 2.54555978e-02f, 1.02030970e-01f, -6.16980903e-03f, 5.26739955e-02f, -9.23425034e-02f, -2.86525730e-02f, -3.91948372e-02f, 2.71105357e-02f, -1.27964169e-02f,
  5.22917770e-02f, -7.14466255e-03f, 1.58615768e-01f, -5.70625924e-02f, -3.37113626e-02f, -7.22799227e-02f, 6.66799098e-02f, -6.92802817e-02f, 3.13750841e-02f, -1.11178085e-01f,
  3.28096673e-02f, 5.59727773e-02f, 1.59161128e-02f, 3.00850905e-02f, 2.99804681e-03f, -5.18836677e-02f, 7.53665268e-02f, 9.74477381e-02f, 3.78117710e-02f, 7.42211193e-02f,
  1.05402414e-02f, 9.31373164e-02f, 2.43214983e-02f, 7.21147954e-02f, 6.38110414e-02f, 2.40283161e-02f, 5.44678383e-02f, 8.57603475e-02f, -2.50086822e-02f, 2.69070677e-02f,
  9.87308994e-02f, 6.34675846e-02f, 7.47552887e-02f, 3.61952484e-02f, 4.77958135e-02f, 9.43219885e-02f, -5.64195514e-02f, 7.40832761e-02f, 8.79687071e-02f, 1.59542561e-02f,
  -1.66675881e-01f, 9.08960551e-02f, -4.48018573e-02f, -9.34589058e-02f, 9.42812264e-02f, -8.00116584e-02f, 5.05459495e-02f, -1.52256846e-01f, -5.28130569e-02f, -7.97071978e-02f,
  8.33596289e-02f, 7.85416737e-03f, 6.93003684e-02f, -5.21978065e-02f, -8.26078579e-02f, -5.93587123e-02f, -3.63517441e-02f, -8.02265704e-02f, -2.97175720e-02f, -1.01999946e-01f,
  2.41715014e-02f, -9.68578979e-02f, 1.35790408e-02f, -4.83113937e-02f, -7.53447413e-02f, -1.12307988e-01f, -6.23293258e-02f, -3.11170667e-02f, -3.42783034e-02f, -1.51532516e-01f,
  1.16123766e-01f, -1.24241702e-01f, -8.30930397e-02f, 8.18191618e-02f, 2.78796703e-02f, -4.75849658e-02f, -2.53901690e-01f, -1.54535279e-01f, 1.41319828e-02f, 2.72186343e-02f,
  5.53157441e-02f, 2.01245710e-01f, 1.55166119e-01f, 2.47262083e-02f, -4.35392037e-02f, -5.23572713e-02f, -1.32398516e-01f, -6.26953021e-02f, -8.50761905e-02f, 1.47203552e-02f,
  1.37665004e-01f, 1.22679949e-01f, 4.94207107e-02f, 1.15019418e-02f, -4.12171409e-02f, 1.58127502e-01f, -1.47723267e-03f, 8.97877738e-02f, -5.71345091e-02f, -3.71746980e-02f,
  -1.89872846e-01f, -1.77024454e-01f, 1.66421719e-02f, 1.32940486e-01f, -7.51874782e-03f, -1.34506136e-01f, -9.59753469e-02f, 5.56141697e-02f, 1.37919905e-02f, -1.35020509e-01f,
  9.58089065e-03f, 1.58524252e-02f, -1.13523575e-02f, -1.40539687e-02f, 4.34860401e-02f, -1.16569236e-01f, -3.44092958e-02f, -1.44251302e-01f, 2.87979711e-02f, -1.08998537e-01f,
  -3.23334299e-02f, -6.14200644e-02f, -1.39324889e-01f, -2.23397128e-02f, -4.50887531e-02f, -6.31024092e-02f, -3.48709412e-02f, -8.94738361e-03f, -9.33975726e-02f, -7.48007447e-02f,
  4.73366715e-02f, 2.14688443e-02f, -4.91470471e-02f, 6.18579686e-02f, -1.79723110e-02f, -8.30395985e-03f, 8.45846534e-03f, -8.02233294e-02f, 4.16139141e-02f, 6.35337979e-02f,
  -4.34829593e-02f, -5.17619997e-02f, 6.33231848e-02f, -3.25870924e-02f, -2.43408009e-02f, 3.80978063e-02f, -2.12241150e-02f, 3.99394520e-02f, -1.57347322e-02f, -3.98668759e-02f,
  1.42763723e-02f, 2.46853903e-02f, 2.75463350e-02f, 4.02831752e-03f, -4.39059101e-02f, -8.01314488e-02f, 3.84071320e-02f, -6.69244537e-03f, 9.07995477e-02f, 6.68706372e-02f,
  1.87471986e-01f, 7.31037557e-02f, -3.58707048e-02f, -5.85628599e-02f, -3.27479374e-03f, 3.71829933e-03f, 2.68824100e-02f, -8.30425471e-02f, -1.15492595e-02f, -1.11439593e-01f,
  -6.33979142e-02f, -4.47148532e-02f, -4.99606617e-02f, 2.78068986e-02f, 6.48778155e-02f, 1.44122755e-02f, 2.12192200e-02f, -6.99427500e-02f, -2.42536608e-02f, -6.38644919e-02f,
  6.87422231e-02f, -7.56450146e-02f, -4.45393510e-02f, -9.82650220e-02f, -9.29887965e-02f, 7.81721771e-02f, -4.99377698e-02f, -1.06685892e-01f, -2.26533171e-02f, -1.83063671e-02f,
  -1.03000470e-01f, 1.16299897e-01f, 1.45236641e-01f, 2.22206637e-01f, 3.49295527e-01f, 4.10774022e-01f, 4.68351781e-01f, 3.17822993e-01f, -3.56697757e-03f, 1.21373512e-01f,
  -1.06328264e-01f, -1.72099456e-01f, -8.60002488e-02f, -1.33222371e-01f, -8.81362930e-02f, 1.50797933e-01f, 2.34588593e-01f, 6.57472163e-02f, -3.82240512e-03f, 2.28290111e-02f,
  4.98953573e-02f, 3.09130419e-02f, -6.66686743e-02f, 2.62665953e-02f, 3.72604765e-02f, -1.11330323e-01f, 1.07469745e-01f, 5.35317184e-03f, -1.61927659e-02f, -8.67253169e-02f,
  -3.83196235e-01f, 1.25432491e-01f, -1.11552134e-01f, -1.75880671e-01f, -6.62520975e-02f, -1.69229358e-01f, 3.60998288e-02f, -7.11509213e-02f, 3.94887961e-02f, -1.59301758e-02f,
  -3.44064943e-02f, -1.62824214e-01f, -3.21754627e-02f, 2.56044008e-02f, -1.49405813e-02f, -4.66613136e-02f, -8.88115913e-03f, -1.33320391e-01f, -4.96537760e-02f, -5.62302209e-02f,
  3.15559432e-02f, 1.81177985e-02f, 1.18017197e-01f, 1.00392699e-01f, 2.10946333e-03f, -6.70052841e-02f, 1.34386625e-02f, -9.76048633e-02f, 1.68058102e-03f, -1.28545821e-01f,
  -1.43264398e-01f, -1.05287030e-01f, 2.55450755e-02f, -2.60715336e-02f, 2.27500368e-02f, 5.13811670e-02f, 2.17648111e-02f, 7.95710925e-03f, -4.25744914e-02f, 2.51756310e-02f,
  -2.65428964e-02f, -2.45415252e-02f, -3.08918729e-02f, -3.35665233e-02f, -5.87651916e-02f, 1.80555601e-02f, 6.78773969e-02f, -6.78811148e-02f, 8.19104444e-03f, -6.22171387e-02f,
  -5.70951262e-03f, 5.09053878e-02f, 6.26947954e-02f, -7.56819695e-02f, 1.86253786e-02f, 2.44934279e-02f, -5.03398366e-02f, -1.15714833e-01f, 1.43339473e-03f, 4.96460833e-02f,
  8.62595960e-02f, 1.24436758e-01f, -1.34822443e-01f, -5.26963696e-02f, 1.40901683e-02f, -2.90051792e-02f, -1.13874845e-01f, -4.20203358e-02f, 5.83391264e-03f, -1.73844770e-03f,
  6.46246374e-02f, -5.59103712e-02f, 2.09353156e-02f, 1.93591639e-02f, 9.90646780e-02f, 4.91436087e-02f, -1.10249445e-01f, 7.20718950e-02f, -4.25559953e-02f, -3.54221389e-02f,
  5.68214208e-02f, 1.54258311e-01f, 8.24298114e-02f, 6.86861277e-02f, 3.20073254e-02f, -7.46550038e-02f, 7.43056042e-03f, 7.63425305e-02f, 4.76779826e-02f, 7.67569542e-02f,
  5.35425127e-01f, -2.40627065e-01f, 4.79803011e-02f, 1.42765855e-02f, 4.84533384e-02f, 1.97080582e-01f, 2.17107125e-02f, 1.49689289e-03f, -3.78688648e-02f, 2.00867951e-02f,
  1.65624127e-01f, 2.40106523e-01f, 8.34757090e-02f, -1.31875454e-02f, 4.38121594e-02f, 2.24434061e-05f, -9.74029303e-02f, 1.93090394e-01f, 2.31470570e-01f, 5.56869619e-02f,
  -8.74858499e-02f, -3.74180041e-02f, 7.02050924e-02f, -7.89822340e-02f, -1.23696297e-01f, -5.33046350e-02f, -1.23380199e-01f, -1.39477625e-01f, -2.00635213e-02f, -2.45125890e-01f,
  -7.76287392e-02f, 3.18028890e-02f, 3.68772261e-02f, -6.81140460e-03f, -2.00950820e-02f, -5.56580424e-02f, 7.31150061e-02f, -1.21973820e-01f, -1.85806695e-02f, -3.37294526e-02f,
  6.98875412e-02f, -1.01095326e-01f, 9.57360640e-02f, -1.22045301e-01f, -1.22101262e-01f, -6.56220391e-02f, -6.59364238e-02f, -3.16542089e-02f, -4.75909933e-02f, -8.06096185e-04f,
  -1.06139645e-01f, 5.56191653e-02f, 1.75403938e-01f, 2.11357437e-02f, 5.12189418e-02f, 1.69025540e-01f, -6.01631068e-02f, -7.41742179e-02f, 3.31777185e-02f, -8.77794325e-02f,
  -1.94286127e-02f, 4.40777391e-02f, 9.00934637e-02f, 4.44985507e-03f, 1.05324917e-01f, 6.55759871e-02f, -6.29883483e-02f, 5.74722812e-02f, -2.65850555e-02f, -4.70133163e-02f,
  2.99789943e-02f, 2.26954222e-02f, -1.11306319e-02f, 3.59313600e-02f, 3.18238288e-02f, 6.65547252e-02f, -4.80743721e-02f, -6.98623881e-02f, 2.09793951e-02f, -3.74017172e-02f,
  1.10507391e-01f, -2.75598336e-02f, -6.00556377e-03f, -2.29534581e-02f, -8.97571743e-02f, -5.64007387e-02f, -1.70590207e-02f, -6.42305687e-02f, -3.39164063e-02f, 5.09877615e-02f,
  -2.31620848e-01f, 2.87965536e-01f, -2.73799654e-02f, -1.01409638e-02f, -1.43578993e-02f, -7.64878914e-02f, 5.80302514e-02f, -3.66832153e-03f, -3.70311327e-02f, -1.28714979e-01f,
  -3.24734598e-02f, 5.74503876e-02f, -5.97688593e-02f, -9.09790844e-02f, -1.07084401e-02f, 7.51328245e-02f, -7.95394853e-02f, 1.07560746e-01f, -1.03850678e-01f, -1.01497881e-01f,
  -1.40137658e-01f, 8.01276565e-02f, 1.51315749e-01f, 4.11157236e-02f, 1.23961130e-02f, 3.10797989e-01f, 6.92903772e-02f, -1.21384999e-02f, 1.72641695e-01f, -1.55294277e-02f,
  -1.43061474e-01f, 2.62928307e-01f, 2.55477130e-01f, -1.64125532e-01f, -6.73615485e-02f, -1.98049564e-02f, 1.29212052e-01f, -7.77153745e-02f, -1.27760351e-01f, -2.20940690e-02f,
  9.73568484e-02f, -8.26272815e-02f, -7.62467533e-02f, -5.82756326e-02f, 2.34575663e-02f, 1.71906933e-01f, 1.12955750e-03f, -3.88685167e-02f, -1.03766002e-01f, -2.10260078e-01f,
  -1.16672292e-01f, -7.75784701e-02f, -1.56235889e-01f, -1.10379636e-01f, -8.65666345e-02f, -1.03590287e-01f, 8.00609663e-02f, 1.28695909e-02f, 6.86942562e-02f, -5.36775403e-02f,
  1.55132324e-01f, -2.28514778e-03f, -5.56884781e-02f, -1.32270366e-01f, 7.15964958e-02f, -1.08901165e-01f, -2.09730957e-02f, 3.09578367e-02f, -5.62413484e-02f, 1.02526486e-01f,
  -7.69395903e-02f, -1.77703742e-02f, -3.86721641e-03f, -6.74700439e-02f, -1.04312189e-01f, -2.84080505e-02f, 3.98399644e-02f, -2.97982171e-02f, 3.61232902e-03f, 5.50740100e-02f,
  1.16124917e-02f, 5.91435693e-02f, 5.87625131e-02f, -5.70519976e-02f, 1.40135121e-02f, -6.48713612e-04f, 6.34225383e-02f, -2.06152014e-02f, 7.11342916e-02f, -5.08096069e-02f,
  -9.99108404e-02f, -4.31243777e-02f, -9.77129303e-03f, -2.55177580e-02f, -1.61133092e-02f, -1.13620721e-02f, -8.93083867e-03f, 9.10607800e-02f, -1.56377368e-02f, -6.59986213e-03f,
  -8.71938094e-02f, 6.54051751e-02f, -6.95460513e-02f, -5.85597716e-02f, -3.67129706e-02f, 6.89830855e-02f, -4.76460345e-02f, 1.05088837e-01f, 5.82233071e-02f, 7.56131858e-02f,
  -2.58267038e-02f, 3.47679779e-02f, 2.56044250e-02f, 3.84346433e-02f, 1.13770731e-01f, 6.07805606e-03f, 9.61652473e-02f, -7.88690075e-02f, -8.41073040e-03f, -3.35241109e-02f,
  -1.12759270e-01f, 9.06766951e-02f, 9.98330712e-02f, -1.53312668e-01f, 7.56505993e-04f, 1.67982467e-03f, 4.05292884e-02f, -2.87829917e-02f, -3.69860884e-03f, 2.09331848e-02f,
  -6.15287200e-02f, -6.67707920e-02f, 7.48703033e-02f, -9.93531495e-02f, 2.88465223e-03f, -7.23590776e-02f, -7.77891055e-02f, -1.04334671e-03f, -6.43382370e-02f, 7.31493160e-02f,
  -3.84474918e-02f, -1.07396126e-01f, -3.36154215e-02f, 6.16515502e-02f, -8.09741765e-02f, -4.82507497e-02f, 4.93656360e-02f, -7.40878955e-02f, -2.22889185e-02f, -2.97193062e-02f,
  -1.28504530e-01f, -3.18091601e-01f, -2.20796719e-01f, -2.14505494e-01f, -2.17340752e-01f, -1.04763262e-01f, -1.43549010e-01f, -5.09619154e-02f, -9.77949202e-02f, -1.60713270e-01f,
  -1.44105956e-01f, 6.08333163e-02f, -1.67282000e-02f, 1.79575905e-01f, -3.29169142e-03f, -1.48004964e-01f, -1.61271751e-01f, 1.11941904e-01f, 2.36559853e-01f, 5.30967563e-02f,
  3.77357341e-02f, -4.20697546e-03f, 1.07994653e-01f, 5.21810725e-02f, -2.04510137e-01f, 1.93610173e-02f, -2.06050202e-01f, -1.12712502e-01f, -1.59041569e-01f, -1.62072003e-01f,
  -4.07477245e-02f, 6.64275810e-02f, 8.14723298e-02f, 1.32731169e-01f, -2.95202620e-02f, -4.32728454e-02f, 7.85759911e-02f, -4.33301227e-03f, -3.92547362e-02f, -6.71708658e-02f,
  5.34640849e-02f, 7.88376555e-02f, 6.01768307e-02f, 9.43300724e-02f, -6.91705272e-02f, 1.02620795e-01f, 3.12515981e-02f, 1.29663330e-02f, 4.16611135e-02f, 2.40233839e-02f,
  -4.37502982e-03f, 1.11974239e-01f, 1.49777019e-02f, 1.57719523e-01f, 1.02835119e-01f, 1.24407485e-01f, 1.09246016e-01f, 4.81354892e-02f, 8.69277120e-03f, -3.40786986e-02f,
  -1.04845449e-01f, -1.68398041e-02f, 2.16908306e-02f, 8.41649920e-02f, 7.40954429e-02f, 1.56269353e-02f, -2.11719126e-02f, -4.32953760e-02f, 7.17085823e-02f, 1.08026508e-02f,
  -1.08946476e-03f, -4.24620323e-02f, 7.17990175e-02f, -9.66076627e-02f, 7.58472607e-02f, -2.75718980e-02f, -5.07803373e-02f, 5.50190583e-02f, -3.93100753e-02f, 1.83966868e-02f,
  -3.18406187e-02f, -4.47159819e-02f, -4.72221449e-02f, -6.25404939e-02f, 1.09470915e-02f, -9.49912369e-02f, 6.53408021e-02f, -1.02609927e-02f, 3.65923345e-02f, 1.85567401e-02f,
  -1.45822177e-02f, 2.70354182e-01f, -8.08668584e-02f, 1.19964451e-01f, -6.33214936e-02f, 8.56338535e-03f, -1.16468947e-02f, 2.33839396e-02f, -7.28981197e-02f, -2.50202175e-02f,
  8.08376968e-02f, 1.45478062e-02f, -1.23428911e-01f, 7.95927197e-02f, 8.54965523e-02f, 6.35720044e-02f, -5.36254756e-02f, 2.23940331e-02f, 4.04051133e-02f, -2.97037493e-02f,
  -1.04475781e-01f, -6.53402209e-02f, -5.06400168e-02f, -4.52644266e-02f, 2.98693776e-02f, 1.92031920e-01f, -1.41860060e-02f, -6.44535199e-02f, 1.24579974e-01f, -1.77513868e-01f,
  -4.82992418e-02f, -2.03118529e-02f, -1.26317933e-01f, 5.64856119e-02f, 9.62237641e-02f, -9.14444849e-02f, -3.20149183e-01f, -2.67969847e-01f, -4.26982194e-02f, 5.43963872e-02f,
  2.59971004e-02f, 4.63475920e-02f, 1.37815818e-01f, 7.71215707e-02f, -7.16240797e-03f, 8.03586468e-02f, 1.58465460e-01f, 1.37529507e-01f, 4.86293323e-02f, 1.03248395e-01f,
  2.23681152e-01f, 2.13447377e-01f, 1.29419670e-01f, 1.49936676e-01f, 2.48434022e-01f, 1.84957296e-01f, 9.29648727e-02f, 4.23916131e-02f, 1.69977114e-01f, 3.63508165e-01f,
  5.56919128e-02f, -1.97491080e-01f, -7.78539553e-02f, 8.30838010e-02f, 5.77677079e-02f, 8.70829099e-05f, -9.56523269e-02f, -8.50580484e-02f, -5.06955106e-03f, -5.31350216e-03f,
  1.06965639e-01f, 3.62661444e-02f, 3.69651578e-02f, -5.47247380e-02f, 3.57377678e-02f, -8.64750966e-02f, -8.27666372e-02f, -9.18272510e-02f, -1.28939375e-01f, -7.28220819e-03f,
  1.75931126e-01f, -1.97159755e-03f, -1.04174197e-01f, -1.55990794e-01f, -7.66649693e-02f, -1.20981904e-02f, -1.41844988e-01f, -1.14977196e-01f, -2.28592753e-01f, -1.07448943e-01f,
  2.49781664e-02f, -5.04994839e-02f, 8.43468681e-03f, -3.67480852e-02f, 1.88249610e-02f, 4.78714369e-02f, 4.09361236e-02f, 9.19963047e-02f, -3.77672575e-02f, -4.44247574e-02f,
  3.60466577e-02f, -5.93824722e-02f, -7.05191791e-02f, -3.72212529e-02f, 1.20271901e-02f, -2.52349861e-02f, 4.53307070e-02f, 1.19061405e-02f, 5.69513142e-02f, 1.34474924e-02f,
  -3.33777517e-02f, -2.72699818e-02f, 4.09479178e-02f, 7.02658892e-02f, -4.44756746e-02f, 5.81853203e-02f, 4.07680608e-02f, -5.19292951e-02f, -2.74521019e-02f, 6.62484318e-02f,
  -4.35652994e-02f, -2.14659840e-01f, 1.85862388e-02f, 1.01641901e-02f, -3.17862332e-02f, 5.91978095e-02f, 3.08730872e-03f, 5.70256040e-02f, 7.61047602e-02f, -5.55502623e-02f,
  -1.66016910e-02f, -6.01601042e-02f, -5.19005321e-02f, -3.36875431e-02f, -9.90800858e-02f, -5.48768714e-02f, 2.12093379e-04f, -3.67144751e-03f, -6.67261146e-03f, -2.68995762e-02f,
  4.55365330e-02f, -6.27011508e-02f, -2.07390353e-01f, -2.19237551e-01f, -1.18831329e-01f, -3.33275758e-02f, -1.48648500e-01f, -1.09168999e-01f, -2.93685287e-01f, -2.90199906e-01f,
  -1.63162053e-01f, -1.58194557e-01f, -1.27137182e-02f, -2.17155628e-02f, -3.46238585e-03f, 1.61688402e-01f, 8.48684460e-02f, 2.74148043e-02f, 7.75397196e-03f, -7.69042671e-02f,
  -1.49091169e-01f, -1.66495349e-02f, -5.69910035e-02f, -8.13415349e-02f, -9.80618373e-02f, -9.64252502e-02f, -8.78249928e-02f, 3.78182568e-02f, 1.10401288e-01f, 3.68549861e-02f,
  -1.93973519e-02f, -2.79298574e-02f, -7.90049359e-02f, 6.32765442e-02f, -7.47473910e-02f, 5.24772480e-02f, -3.83335687e-02f, -8.04922581e-02f, 1.43435663e-02f, 6.09377958e-03f,
  1.38155550e-01f, -1.40191436e-01f, 1.00982048e-01f, -5.27460873e-02f, 4.54277173e-02f, 4.13026748e-04f, 3.45686041e-02f, 3.97039577e-03f, -3.45855835e-03f, -5.71000353e-02f,
  -9.57562253e-02f, -1.83099378e-02f, -9.64333862e-02f, 3.55245247e-02f, -6.61464334e-02f, 2.17521209e-02f, 1.68127418e-02f, 6.62477911e-02f, 2.52423938e-02f, -1.54432710e-02f,
  -8.30718949e-02f, 3.94269712e-02f, -1.42690195e-02f, 4.91555519e-02f, 6.62526861e-02f, 6.45760354e-03f, -6.05084039e-02f, 8.84490609e-02f, -2.40671169e-02f, -5.94876101e-03f,
  7.59741990e-03f, -1.85534731e-02f, -4.45098169e-02f, 5.78482747e-02f, -5.67648634e-02f, -5.39735481e-02f, -2.73586847e-02f, 4.25394215e-02f, -9.91574954e-03f, -8.11719298e-02f,
  -8.07583332e-02f, 3.68982647e-03f, 8.25332180e-02f, 4.50152176e-04f, 5.38050346e-02f, 9.70710367e-02f, -3.88593487e-02f, -3.91222797e-02f, -2.25875061e-02f, 1.01046525e-02f,
  2.01205704e-02f, 3.51124182e-02f, 3.01865977e-03f, 8.23280141e-02f, -7.85250664e-02f, -5.16226701e-02f, -6.56742379e-02f, 3.38406526e-02f, 1.96210784e-03f, -1.53375817e-02f,
  -3.91605757e-02f, -6.34334190e-03f, -8.20587873e-02f, -1.12284925e-02f, -5.17502986e-02f, -6.53470084e-02f, -5.79471961e-02f, -7.74674788e-02f, 1.88677162e-02f, 1.05048336e-01f,
  -4.25975444e-03f, -6.11034781e-03f, -2.69659515e-02f, -1.84435640e-02f, 7.31331557e-02f, 1.85589306e-02f, 7.39534106e-03f, 4.65490296e-02f, 3.67266238e-02f, 3.96863073e-02f,
  9.35307611e-03f, -4.68452349e-02f, 9.15080309e-02f, 1.48840509e-02f, -6.86760247e-02f, 2.25411542e-02f, 1.35805070e-01f, 1.03976898e-01f, 1.45963458e-02f, -4.17892039e-02f,
  5.94063811e-02f, -7.35949650e-02f, -1.78669944e-01f, 1.11947179e-01f, 8.93705115e-02f, -2.35721990e-01f, -3.66351813e-01f, -1.72079444e-01f, 8.37061107e-02f, 8.17285012e-03f,
  1.18981944e-02f, 1.26141816e-01f, 4.96698096e-02f, -6.88750595e-02f, -2.78855532e-01f, -2.18962878e-01f, -1.77333783e-02f, -2.43738927e-02f, 2.19539236e-02f, 1.63687661e-01f,
  2.98678607e-01f, 1.52867287e-01f, -1.57173406e-02f, 5.78109063e-02f, 3.09935838e-01f, 1.94947556e-01f, -3.13213989e-02f, 8.51982981e-02f, -1.64681040e-02f, 2.76297390e-01f,
  1.78958923e-02f, -3.04632098e-03f, -5.75937517e-02f, 1.19581260e-01f, 2.51645036e-02f, 3.71800624e-02f, -7.21035823e-02f, -2.21137684e-02f, 3.64310946e-03f, 4.67308378e-03f,
  -7.30859465e-04f, 1.63286664e-02f, 5.07435128e-02f, 8.96643251e-02f, -8.23973268e-02f, -1.08687788e-01f, -8.42563137e-02f, -9.81245190e-02f, -1.89553410e-01f, -5.51857203e-02f,
  9.90185738e-02f, 7.78960884e-02f, -1.15517206e-01f, -2.49965340e-01f, -1.23241812e-01f, -4.97786775e-02f, -1.34916931e-01f, -4.88058664e-02f, -2.20255375e-01f, -2.99960617e-02f,
  -4.85232174e-02f, 3.07322182e-02f, -4.63712029e-02f, -9.87648312e-03f, 1.91280281e-03f, 6.17685262e-03f, 2.16439348e-02f, 4.40144427e-02f, 7.69088627e-04f, -5.00623882e-02f,
  -9.98044852e-03f, -3.21657769e-02f, 7.25064352e-02f, -7.79608637e-02f, 1.07321605e-01f, -1.61618963e-02f, 5.22045754e-02f, -3.43085267e-02f, 8.85832496e-03f, -3.53571251e-02f,
  8.02204087e-02f, -3.33441794e-03f, -1.27808871e-02f, -1.31549155e-02f, -2.66063772e-02f, -4.70474549e-02f, 1.09166600e-01f, -6.75756335e-02f, 1.38478773e-02f, 2.38398463e-02f,
  -3.48840281e-03f, -3.23064893e-01f, 4.88698334e-02f, 2.81305853e-02f, -3.06891557e-02f, -6.44859895e-02f, -1.18575431e-02f, -6.75045773e-02f, -5.31276595e-03f, -8.58395845e-02f,
  3.17685194e-02f, -8.58975872e-02f, -7.07992762e-02f, -6.54595625e-03f, 3.79443839e-02f, -5.09655811e-02f, -2.59903576e-02f, -5.27155772e-03f, -1.67918116e-01f, -1.27678430e-02f,
  -4.62036207e-02f, -1.49480209e-01f, -1.37399167e-01f, -1.98002964e-01f, -8.66756737e-02f, -3.47613692e-02f, -1.62214473e-01f, -6.78218082e-02f, -3.22334051e-01f, -2.32325941e-01f,
  6.06360197e-01f, 3.10362309e-01f, 3.00473720e-01f, 1.95084408e-01f, -9.56314243e-03f, -8.90562013e-02f, -6.35093302e-02f, 9.29590315e-04f, -5.88276237e-02f, 2.72921473e-02f,
  -3.37155536e-02f, -1.88892812e-01f, -2.08810523e-01f, -1.83741778e-01f, -2.31773645e-01f, -1.11666895e-01f, 1.91680118e-02f, -9.12420973e-02f, -1.94196522e-01f, -9.66325998e-02f,
  -1.38248205e-01f, 6.18054755e-02f, 1.40128255e-01f, 2.68229842e-02f, 1.51071817e-01f, -6.40978813e-02f, 1.18644468e-01f, 1.40305519e-01f, 1.45300373e-01f, 1.82425886e-01f,
  1.96647182e-01f, 5.22076070e-01f, -3.29619408e-01f, -1.32988602e-01f, 1.08538168e-02f, -4.87289280e-02f, -8.16551596e-02f, 1.26742378e-01f, 2.81137172e-02f, 4.49112132e-02f,
  1.85791850e-02f, 6.70475215e-02f, 2.80800350e-02f, 6.41403487e-03f, -1.38630876e-02f, 2.31192932e-02f, 2.07091942e-02f, -3.73922139e-02f, -1.32647797e-01f, -1.86716125e-03f,
  -4.17100899e-02f, 1.10515311e-01f, 1.12090454e-01f, -1.30045488e-01f, -6.28100261e-02f, -3.41317914e-02f, 9.30151865e-02f, 4.37124521e-02f, -6.67145476e-02f, 1.82154790e-01f,
  -4.74304445e-02f, -2.31394209e-02f, 5.48904538e-02f, -1.19617442e-02f, -5.97885661e-02f, -1.65788142e-03f, -7.98909217e-02f, -2.72353925e-03f, 2.54091364e-03f, -1.68792494e-02f,
  -4.00285833e-02f, -7.41018578e-02f, -3.72745320e-02f, 8.65266006e-03f, -1.27612934e-01f, 3.10333427e-02f, -5.65461330e-02f, -1.38523616e-02f, -1.87881999e-02f, -2.16502044e-02f,
  -8.48346762e-03f, -1.34209469e-02f, 6.85313046e-02f, -7.46577308e-02f, -5.85920624e-02f, 2.97741741e-02f, -5.53191192e-02f, -7.49571472e-02f, -2.65566166e-02f, 8.24430659e-02f,
  -2.11195305e-01f, -2.86081046e-01f, -7.15119317e-02f, -1.24149425e-02f, 8.55603591e-02f, -2.15484966e-02f, 6.26403391e-02f, -3.78895327e-02f, 5.22228032e-02f, -1.04258219e-02f,
  8.08436275e-02f, -4.91252318e-02f, 3.42207216e-02f, -8.08664113e-02f, -9.37396809e-02f, -8.18343982e-02f, -1.06251910e-01f, -8.03264454e-02f, -1.01554580e-01f, 5.59642985e-02f,
  -1.53332025e-01f, -1.23428643e-01f, -1.60387591e-01f, -2.15747893e-01f, -1.60646960e-02f, -2.23643214e-01f, -1.36616111e-01f, 1.85912885e-02f, -1.55360073e-01f, -1.30760640e-01f,
  1.52724281e-01f, -2.36939460e-01f, -8.22477695e-03f, 6.37870654e-02f, 4.65163682e-03f, -7.85775483e-03f, -2.29942814e-01f, -1.25788957e-01f, 3.80828716e-02f, 3.70850926e-03f,
  -1.15060978e-01f, -5.72585613e-02f, -2.99402718e-02f, -9.58569627e-03f, -9.96992067e-02f, -9.46020484e-02f, 2.13623960e-02f, -3.35403532e-02f, 4.25592251e-02f, -1.20230734e-01f,
  -7.36165717e-02f, -9.94467139e-02f, 1.38765611e-02f, -7.96256289e-02f, 7.66289979e-02f, 1.27068698e-01f, 1.17750891e-01f, -6.71322793e-02f, 5.23131043e-02f, 7.23676980e-02f,
  3.61151807e-02f, 6.62914244e-03f, -4.62143868e-02f, 2.51678582e-02f, -8.26290473e-02f, -9.71569587e-03f, 3.45937423e-02f, -3.01214252e-02f, 9.00983438e-02f, 8.09485465e-02f,
  1.80873908e-02f, 3.68420035e-02f, -1.23323761e-02f, -5.37544005e-02f, -2.75897849e-02f, 3.51560041e-02f, 4.28430475e-02f, -1.21802529e-02f, 7.33412206e-02f, 1.20097240e-02f,
  -1.15603581e-01f, 3.59142162e-02f, 7.67357182e-03f, 5.46576008e-02f, -5.58524579e-02f, 4.37177811e-03f, 7.85324126e-02f, -3.21199745e-02f, 1.54530657e-02f, 7.91523010e-02f,
  9.33969952e-03f, 1.36592001e-01f, 6.94925338e-02f, 5.98647445e-02f, 8.13388790e-04f, -3.04987691e-02f, 6.24250844e-02f, 3.08327656e-02f, -9.09130722e-02f, 4.44651814e-05f,
  -5.18712308e-03f, -4.85987961e-02f, -8.74709934e-02f, -4.45153937e-02f, 6.95483834e-02f, -1.13496669e-02f, -2.22079363e-02f, 7.02230185e-02f, 5.88814728e-03f, 7.64641387e-04f,
  2.87504308e-02f, 3.77630070e-02f, 1.23476855e-01f, 1.27081396e-02f, -5.74936867e-02f, 7.43635669e-02f, -2.19830801e-03f, 3.06184310e-03f, 8.04390088e-02f, 8.00373107e-02f,
  -6.97956830e-02f, 7.61387274e-02f, 1.36377230e-01f, 6.20377883e-02f, 6.71916232e-02f, 5.47233932e-02f, 6.93135522e-03f, -5.69038466e-02f, 9.16943625e-02f, 3.59443319e-03f,
  -9.95062888e-02f, -9.79247093e-02f, 2.14326512e-02f, 6.06513117e-03f, 1.07560800e-02f, 6.20743334e-02f, -9.95670408e-02f, 5.23935189e-04f, -1.74524579e-02f, -5.06092086e-02f,
  -1.30491592e-02f, -5.65699041e-02f, -5.55626452e-02f, 3.34859155e-02f, -1.66614242e-02f, 5.86264729e-02f, 6.13626316e-02f, 8.43372792e-02f, -1.87296048e-02f, -1.09515078e-01f,
  -2.97938436e-01f, 2.65099015e-02f, 7.30870888e-02f, 8.55503827e-02f, 1.50269866e-01f, 2.22254083e-01f, 7.62092024e-02f, 9.84531194e-02f, 7.07385093e-02f, 6.45410046e-02f,
  -7.64480457e-02f, -1.33469507e-01f, 9.65578109e-03f, -5.43524772e-02f, -1.48278773e-02f, 1.89076290e-02f, 9.83741507e-02f, 1.59515757e-02f, 6.47162348e-02f, 3.00279651e-02f,
  8.65055323e-02f, -3.06814872e-02f, -1.75843701e-01f, -7.12931342e-03f, 1.71146646e-01f, 3.43323611e-02f, -1.52472835e-02f, -8.56725965e-04f, 7.82965571e-02f, 6.00989684e-02f,
  -1.63967833e-01f, -9.55168977e-02f, -4.11642827e-02f, -9.13027078e-02f, -3.09036467e-02f, -3.00796442e-02f, 6.16375310e-03f, -3.61013971e-02f, 2.19708178e-02f, -4.06567454e-02f,
  -1.27726188e-03f, 1.41571341e-02f, 8.71082544e-02f, -2.27838013e-04f, -1.09496593e-01f, -1.71450786e-02f, -7.40080774e-02f, -2.08834987e-02f, -2.81859934e-02f, 4.11438644e-02f,
  -2.88635753e-02f, 1.28449187e-01f, 2.75086295e-02f, 1.38264075e-02f, -3.04375719e-02f, -1.68130994e-02f, -4.31536138e-02f, -8.80583078e-02f, -1.11846700e-01f, -1.14796668e-01f,
  -4.44914252e-02f, -1.81890037e-02f, 2.27064849e-03f, 2.57601310e-02f, 7.86107313e-03f, 2.37515178e-02f, 1.55887567e-02f, -7.94372708e-02f, 8.81716684e-02f, 8.31773728e-02f,
  -7.30279163e-02f, -3.17387320e-02f, -2.79432554e-02f, -7.85373822e-02f, 2.26375442e-02f, 1.42367575e-02f, 8.67186394e-03f, 3.13757248e-02f, 3.07002459e-02f, -9.01520476e-02f,
  -6.92431862e-03f, -3.89276929e-02f, -2.72389632e-02f, -1.36657553e-02f, -8.92572105e-03f, 7.48773441e-02f, -6.87557906e-02f, -1.12198219e-01f, -7.18760341e-02f, 2.29023397e-02f,
  -1.53860915e-02f, -8.09325874e-02f, 5.31995390e-03f, -3.97861972e-02f, 1.09830804e-01f, -9.06904563e-02f, -2.08586659e-02f, -5.59815206e-02f, 2.33649351e-02f, 4.94602658e-02f,
  -8.72829482e-02f, 1.88335050e-02f, -6.45334274e-02f, 6.06365241e-02f, 9.99185909e-03f, 5.44686280e-02f, -3.38926539e-02f, 1.25757277e-01f, 6.28984720e-02f, 5.69251478e-02f,
  1.36901410e-02f, 9.32907686e-02f, 5.51212691e-02f, 9.12803859e-02f, -1.74047705e-02f, -6.14485815e-02f, -3.91187258e-02f, -4.56481706e-03f, -3.25836018e-02f, -1.11427404e-01f,
  -5.20592332e-01f, -6.73401803e-02f, 3.31756324e-01f, -1.77152678e-01f, 7.94299096e-02f, 1.13420911e-01f, 6.72371164e-02f, -1.23946682e-01f, -2.16830000e-01f, 5.63510805e-02f,
  -4.15366963e-02f, -1.99925676e-01f, -1.03872634e-01f, -1.24980167e-01f, -1.55981824e-01f, 3.34968492e-02f, 1.00534618e-01f, -2.10078843e-02f, -9.41720512e-03f, -1.61031365e-01f,
  -9.47857946e-02f, -2.28732035e-01f, -3.07213992e-01f, -7.44342580e-02f, -5.82189038e-02f, -7.96491653e-03f, 3.30012143e-02f, -1.24153337e-02f, 9.53709483e-02f, -3.44835259e-02f,
  3.80394608e-01f, -2.17002422e-01f, -1.12192206e-01f, -8.32295194e-02f, -2.32164636e-02f, 3.43576185e-02f, -3.17404489e-03f, -9.10121575e-02f, -1.27846703e-01f, 8.32679719e-02f,
  -6.28922507e-02f, -9.03362632e-02f, 2.40245014e-02f, 6.04174323e-02f, -8.39159936e-02f, 5.86223565e-02f, -3.13505754e-02f, -1.21723421e-01f, 5.71744842e-03f, 1.44012459e-02f,
  -5.00726178e-02f, -6.59792572e-02f, -5.00941230e-03f, -1.08968243e-02f, 2.79293973e-02f, -4.11072597e-02f, 2.28445176e-02f, 7.96601828e-03f, 1.01752691e-01f, 6.71215057e-02f,
  -2.38587577e-02f, 1.07242428e-01f, -9.32530835e-02f, 1.78266019e-02f, 2.86844634e-02f, 3.39746401e-02f, 4.40570386e-03f, 5.41228056e-02f, -7.12758899e-02f, 5.04431240e-02f,
  -1.75319389e-02f, 3.90139781e-02f, -3.39089036e-02f, -2.55350936e-02f, -2.98679993e-02f, 1.77233797e-02f, -5.34790345e-02f, -1.07059740e-02f, 1.13466484e-02f, -1.66749526e-02f,
  -1.16907477e-01f, -3.53876762e-02f, -1.45351114e-02f, -3.37813683e-02f, -1.84574518e-02f, -7.06344843e-02f, 2.53930073e-02f, 1.20454151e-02f, 2.79124081e-02f, -1.91490706e-02f,
  -1.96233280e-02f, -5.28658591e-02f, 8.71336609e-02f, -1.37445070e-02f, 4.54179347e-02f, -2.07601450e-02f, 2.10184455e-02f, 2.92400401e-02f, -5.60922585e-02f, -1.84052102e-02f,
  -3.24534513e-02f, -3.76147516e-02f, -5.25449552e-02f, 1.65817682e-02f, 8.30923859e-03f, -6.14640117e-03f, 3.55160213e-03f, 8.26683566e-02f, 8.24383795e-02f, 5.83575033e-02f,
  5.96883371e-02f, -2.88292971e-02f, 7.38241747e-02f, 1.30193353e-01f, 8.48863274e-02f, 4.95398119e-02f, 2.09931776e-01f, 1.11199737e-01f, 1.94262415e-02f, 7.53222778e-02f,
  3.44698429e-01f, 1.24082357e-01f, -2.73381501e-01f, 1.66656598e-01f, -1.26099825e-01f, -2.06329316e-01f, -4.64488752e-02f, -1.26950353e-01f, 9.17332098e-02f, -2.31694356e-02f,
  -7.15605691e-02f, -3.10075488e-02f, -2.87259631e-02f, -7.36637115e-02f, -1.71539187e-01f, -1.34136379e-01f, -3.34965289e-02f, -8.03338066e-02f, -1.16221629e-01f, -3.50688919e-02f,
  -2.72666644e-02f, 4.23306935e-02f, 2.14026794e-02f, -3.66293192e-02f, 1.71905570e-02f, 2.89307199e-02f, -1.03283137e-01f, -1.18435085e-01f, -5.51527888e-02f, 6.73786849e-02f,
  -1.11759357e-01f, 6.94918409e-02f, -3.62975821e-02f, 1.22718111e-01f, -7.98647255e-02f, -6.91097379e-02f, -3.11822928e-02f, -1.05708048e-01f, 1.01507343e-01f, -7.14932233e-02f,
  -7.46618211e-02f, -8.69210716e-03f, 1.90785993e-02f, -3.59996520e-02f, -2.11898331e-02f, -2.08185110e-02f, -8.39141086e-02f, -1.39909253e-01f, -1.78705771e-02f, -1.04749180e-01f,
  -4.76056943e-03f, 2.23559374e-03f, -6.53910637e-02f, 8.95644724e-03f, -9.13395360e-02f, -6.51889518e-02f, -1.30288741e-02f, -1.12200513e-01f, -5.47391810e-02f, -2.52651870e-02f,
  -4.57380004e-02f, -4.97042313e-02f, -4.53049615e-02f, 2.87620686e-02f, -3.45046079e-04f, 6.62277862e-02f, -4.78483513e-02f, 4.81831431e-02f, 8.78318120e-03f, -1.61887426e-02f,
  -4.04405072e-02f, -5.18789664e-02f, -3.41429040e-02f, 1.22143896e-02f, 2.92961691e-02f, 4.92379181e-02f, 6.38719499e-02f, 8.36114138e-02f, -2.60410272e-03f, 5.86855710e-02f,
  -6.20308034e-02f, 2.77758557e-02f, 3.54914889e-02f, -5.88423060e-03f, 7.08165718e-03f, -3.79049815e-02f, 6.83081746e-02f, -3.45960744e-02f, 6.53878897e-02f, 6.93207607e-02f,
  6.72558248e-02f, -1.07521027e-01f, -1.62809286e-02f, 1.03937536e-01f, 5.78310043e-02f, 3.88915986e-02f, 2.30032615e-02f, 6.22674152e-02f, -3.42280045e-02f, 7.21934438e-02f,
  4.95339977e-03f, 1.35724694e-02f, -4.15253155e-02f, 5.24456427e-02f, -4.56043892e-02f, 1.90980975e-02f, 6.52263314e-03f, -1.10071823e-02f, 2.02347543e-02f, -1.78844538e-02f,
  8.34704340e-02f, 1.16681755e-01f, 1.00203924e-01f, -6.05583750e-03f, 4.68642004e-02f, 4.66813967e-02f, -2.24090274e-02f, -7.03080148e-02f, -7.20987022e-02f, 2.04542667e-01f,
  -4.70256843e-02f, -3.21418166e-01f, -1.74626395e-01f, -1.11628786e-01f, 3.07545513e-02f, -6.21421449e-02f, -1.48374200e-01f, 4.23505977e-02f, 4.17399742e-02f, -1.49828300e-01f,
  -1.13635615e-01f, 1.82514433e-02f, 8.28757957e-02f, -6.62562698e-02f, -5.69685437e-02f, -9.59489420e-02f, -1.91247806e-01f, 1.06660565e-02f, 2.51203656e-01f, 4.46046032e-02f,
  -3.17255557e-02f, 7.50031024e-02f, -4.87220138e-02f, 5.06603532e-02f, -6.70350268e-02f, 5.38662449e-03f, -1.36319011e-01f, -1.26469791e-01f, -1.05537198e-01f, -7.38503039e-02f,
  2.16711313e-01f, -1.51085272e-01f, 6.08948916e-02f, -7.87516609e-02f, -3.53737822e-04f, -8.62133503e-02f, 2.59501822e-02f, 4.18484025e-02f, -8.76201019e-02f, -5.19186556e-02f,
  -1.64625514e-03f, -5.51296696e-02f, -3.30452085e-03f, -9.45893303e-02f, 7.33285323e-02f, -1.80549477e-03f, -1.14713185e-01f, -4.53044176e-02f, -1.27537519e-01f, -1.47314698e-01f,
  -7.02334791e-02f, -4.10065055e-02f, 1.57801341e-03f, -6.76663592e-02f, -6.69370815e-02f, 2.97269411e-02f, 5.81955686e-02f, 2.35302616e-02f, -9.65464637e-02f, -7.74907768e-02f,
  6.24081008e-02f, -3.12041454e-02f, -1.73071846e-02f, -2.40835324e-02f, -2.99331918e-02f, 2.78766826e-02f, 5.48240766e-02f, 7.84205273e-02f, -4.45251577e-02f, 3.81659809e-03f,
  -5.62276058e-02f, 5.04900031e-02f, 2.47474443e-02f, 8.08046535e-02f, -7.44805187e-02f, -8.54944661e-02f, 6.34732172e-02f, -5.20231053e-02f, 6.74631596e-02f, -1.58941140e-03f,
  3.24112782e-03f, -2.77663209e-02f, -2.02221554e-02f, -1.47801777e-03f, -3.28389145e-02f, -2.25914177e-02f, -2.84313690e-02f, -4.20956798e-02f, -6.01676516e-02f, 8.53135902e-03f,
  2.67315358e-01f, -1.59931660e-01f, 7.39018843e-02f, 8.71406049e-02f, -6.28496578e-04f, -7.02714026e-02f, -5.59254326e-02f, 5.35789132e-02f, 3.92141081e-02f, -2.46989317e-02f,
  4.74904664e-02f, 6.13935404e-02f, 3.30415703e-02f, 1.16616152e-02f, 1.16349310e-01f, 8.51587728e-02f, -9.26688984e-02f, -4.97064181e-02f, 3.73360440e-02f, 3.29532139e-02f,
  -8.67021605e-02f, 6.23432621e-02f, 2.19334766e-01f, 2.27882527e-02f, -2.30182670e-02f, 2.48691645e-02f, 4.76423763e-02f, 1.05918795e-01f, 1.38691649e-01f, 1.16905391e-01f,
  2.02018782e-01f, -8.31173733e-02f, 9.72838476e-02f, -2.76845377e-02f, 3.46624292e-02f, 1.07663684e-01f, -3.09459632e-03f, 5.34906797e-02f, -5.32649979e-02f, -7.34865367e-02f,
  7.01689571e-02f, 5.65968938e-02f, 2.99428012e-02f, -3.27052251e-02f, 6.42816797e-02f, -7.93540254e-02f, -5.62087409e-02f, 5.09608425e-02f, 2.21295133e-01f, 1.63484335e-01f,
  3.61585319e-02f, -5.69908065e-04f, -7.26040006e-02f, -1.55988062e-04f, -4.53503989e-02f, -4.24356051e-02f, -1.86344925e-02f, -9.86847952e-02f, -8.15391839e-02f, -1.20637212e-02f,
  2.56528497e-01f, -6.42334372e-02f, 1.42440200e-01f, -9.81103405e-02f, -6.50496781e-02f, -6.45081326e-02f, -4.63711172e-02f, -7.92813003e-02f, -6.76916614e-02f, -1.03469364e-01f,
  5.35711274e-02f, -2.40684878e-02f, -1.45095643e-02f, -6.08725064e-02f, -4.92368499e-03f, -4.00600694e-02f, 1.87383089e-02f, -7.73539990e-02f, -9.42205414e-02f, -8.83822516e-02f,
  -8.11417103e-02f, -1.11013919e-01f, 1.14823602e-01f, -2.69694850e-02f, -4.16206121e-02f, 1.23521676e-02f, -1.94151606e-02f, 8.53409432e-03f, -4.94668819e-02f, -4.53591682e-02f,
  2.12767348e-02f, 4.74226214e-02f, -1.46631319e-02f, -6.94910809e-02f, -3.02084889e-02f, 3.75426188e-02f, 5.88913634e-02f, -8.37437660e-02f, -7.50850961e-02f, 5.27449287e-02f,
  8.87612253e-02f, -5.78056974e-03f, -6.36155233e-02f, 7.98601508e-02f, 5.14010005e-02f, 1.01085985e-02f, 2.11812835e-02f, -1.11715853e-01f, -1.47040579e-02f, 5.15075475e-02f,
  5.17265722e-02f, -1.99139416e-02f, -3.59792029e-03f, 1.53132081e-02f, 2.01074835e-02f, 4.23248149e-02f, -1.68257428e-03f, -2.98256334e-02f, 2.07242798e-02f, -1.17897756e-01f,
  5.58017194e-03f, -1.23238075e-03f, 1.68903410e-01f, 4.17637415e-02f, 2.66621038e-02f, -2.78420951e-02f, -3.88513990e-02f, 1.59304813e-02f, 2.12152936e-02f, -5.82450675e-03f,
  -7.56677389e-02f, -2.79074651e-04f, 3.65028344e-02f, 2.50302069e-02f, 1.57175183e-01f, 3.11734006e-02f, -1.14633180e-01f, 9.05460492e-02f, -1.07046336e-01f, -1.40888557e-01f,
  -6.79466873e-02f, 1.35013998e-01f, 6.88527301e-02f, 1.38531849e-01f, -8.38157162e-03f, 2.32249260e-01f, 7.67515376e-02f, 7.11023510e-02f, 4.82719876e-02f, 8.43979716e-02f,
  -1.17718384e-01f, -2.28032187e-01f, 2.05719441e-01f, -9.57963616e-02f, 9.27070156e-02f, 2.07487613e-01f, 7.35123381e-02f, -8.62060115e-03f, -1.12350672e-01f, -1.06938168e-01f,
  -1.93467006e-01f, -8.83673802e-02f, -1.53674185e-01f, -4.08394113e-02f, -5.93684725e-02f, 7.33880624e-02f, 1.14039168e-01f, 5.26284762e-02f, 2.00224727e-01f, 1.78163737e-01f,
  -1.60538461e-02f, 5.57392761e-02f, -7.36670271e-02f, 5.21762371e-02f, -7.68285394e-02f, 4.33316268e-02f, -4.02300321e-02f, 9.20092594e-03f, 4.48335297e-02f, -2.62035094e-02f,
  2.67316014e-01f, -2.34326422e-01f, 9.12746340e-02f, -8.13991204e-02f, 4.49846312e-02f, -7.15312362e-02f, -2.84898281e-02f, 1.44903194e-02f, -3.37723233e-02f, 5.59665589e-03f,
  -1.42152691e-02f, -5.30557223e-02f, 9.53498948e-03f, 9.80988797e-03f, -2.59888545e-02f, 8.35243613e-02f, -2.95790825e-02f, -1.53543064e-02f, -2.08128970e-02f, -6.61255373e-03f,
  -7.26803765e-02f, 2.11528167e-02f, 1.03073403e-01f, 6.62784837e-03f, -1.08528517e-01f, -1.27090126e-01f, 4.50173989e-02f, 2.44223922e-02f, -2.05764621e-02f, -3.07252072e-02f,
  2.80517638e-02f, 4.90782484e-02f, 4.99298349e-02f, 7.03685582e-02f, 6.78922236e-02f, 1.27921989e-02f, 2.15373430e-02f, -3.47915702e-02f, 4.93096337e-02f, -1.69023406e-02f,
  9.64425784e-03f, -6.00187667e-02f, 6.89631626e-02f, -6.09327406e-02f, -3.39055806e-02f, -2.26784740e-02f, 3.17699723e-02f, 5.18882200e-02f, -5.22862934e-02f, 3.07867415e-02f,
  3.00108418e-02f, 5.14032133e-02f, -2.48457715e-02f, -5.91846257e-02f, -1.02004290e-01f, 1.40020438e-02f, 4.22278605e-03f, -4.16760817e-02f, -8.80528521e-03f, -1.09226573e-02f,
  1.39246091e-01f, -1.07122205e-01f, 4.92699780e-02f, -1.27616927e-01f, -1.58619881e-02f, -5.08379266e-02f, -3.92744690e-02f, -6.16594255e-02f, -7.83766210e-02f, 1.40932217e-01f,
  -1.30674441e-03f, -8.26484710e-02f, 3.13760191e-02f, 7.51255155e-02f, 1.49414524e-01f, 7.21085295e-02f, -2.74173189e-02f, 8.62754881e-02f, -4.39713486e-02f, 4.95995283e-02f,
  -1.13787971e-01f, 9.83675122e-02f, 1.34057581e-01f, 1.23264506e-01f, -5.25770187e-02f, 8.59565288e-02f, 6.96313903e-02f, 1.28057450e-01f, 1.41862631e-01f, 1.76860377e-01f,
  -8.64220187e-02f, 1.72935445e-02f, -5.08739650e-02f, 2.25297511e-01f, -1.97723042e-02f, 5.88832311e-02f, 2.11932790e-02f, 1.88235074e-01f, 2.17924312e-01f, 2.25616079e-02f,
  9.14207252e-04f, 2.28815809e-01f, 2.28631169e-01f, 2.36053810e-01f, 2.26188675e-01f, 2.00032651e-01f, 2.31063321e-01f, 2.25915328e-01f, 9.96007919e-02f, -3.75164002e-02f,
  5.05746156e-02f, 6.52617291e-02f, 8.45505148e-02f, 1.65973648e-01f, 1.00617729e-01f, 1.34846911e-01f, 7.60040581e-02f, -8.30047578e-02f, 1.01731911e-01f, 1.85846895e-01f,
  -1.73227832e-01f, -1.18619703e-01f, 5.62243536e-02f, -1.43691069e-02f, -1.49645954e-01f, 6.71701655e-02f, 2.44209114e-02f, -1.02975868e-01f, -2.79896557e-02f, -1.74895511e-03f,
  -8.28790814e-02f, -1.05413720e-01f, -2.48288102e-02f, -1.01923849e-02f, -1.08629256e-01f, 8.62782914e-03f, 3.58685888e-02f, 1.02753621e-02f, 3.84221412e-02f, -3.04417871e-02f,
  -2.20116116e-02f, -5.63109070e-02f, -7.95559511e-02f, 8.35850239e-02f, 4.49265242e-02f, 1.44781070e-02f, -3.43437605e-02f, 4.15625945e-02f, 5.58019541e-02f, 1.48977861e-01f,
  -2.47678403e-02f, 2.60354783e-02f, -1.36062289e-02f, 3.06868870e-02f, 7.80321434e-02f, -6.13849051e-02f, -4.21359241e-02f, -5.17321452e-02f, 7.84714893e-02f, -7.51772597e-02f,
  -5.92268892e-02f, 3.45266163e-02f, 8.32331330e-02f, 2.41054688e-03f, 9.57504213e-02f, -9.64617133e-02f, 3.57645974e-02f, 5.36532402e-02f, -4.37059365e-02f, -1.87807698e-02f,
  3.35922316e-02f, 3.54554094e-02f, -8.94708931e-02f, 6.20975764e-03f, -3.88940773e-03f, -1.24481851e-02f, 1.21552125e-02f, 6.74139857e-02f, -3.44608985e-02f, -1.14941627e-01f,
  -7.99443722e-02f, -2.79131662e-02f, 9.43017825e-02f, 7.03852847e-02f, 7.00608641e-03f, -4.44669090e-02f, -3.35845277e-02f, 1.42805856e-02f, -2.53359526e-02f, -3.63427922e-02f,
  -1.54585801e-02f, -8.38021412e-02f, 1.60187650e-02f, -6.86129704e-02f, 3.92507501e-02f, 3.04194214e-03f, -8.37067589e-02f, -5.00577642e-03f, 1.06840404e-02f, -1.11781329e-01f,
  -1.01760710e-02f, -1.89491245e-03f, -9.08179581e-03f, 4.51021194e-02f, 1.27419099e-01f, 8.60933959e-02f, -8.23535696e-02f, -4.07948755e-02f, -1.18675508e-01f, 5.18599898e-02f,
  3.11456442e-01f, 8.22498351e-02f, -1.40475065e-01f, 1.48381084e-01f, -8.52058232e-02f, -1.02587976e-01f, -1.20940015e-01f, 5.44864908e-02f, 3.57172824e-02f, 1.05457798e-01f,
  1.09286964e-01f, 2.24947900e-01f, 1.07414916e-01f, 1.15220644e-01f, 1.49307653e-01f, -9.28611830e-02f, -2.05309913e-01f, -7.53262341e-02f, 7.06299469e-02f, -6.84613585e-02f,
  -2.62517715e-03f, 6.67258818e-03f, 7.88176060e-02f, -4.49184924e-02f, -1.35616392e-01f, 1.21504469e-02f, -7.25454139e-03f, -5.67163080e-02f, -1.55158713e-01f, -1.77317590e-01f,
  -8.38619173e-02f, 3.13004060e-03f, 2.18852814e-02f, 1.01452515e-01f, 3.76717597e-02f, 4.91703786e-02f, 2.32107006e-02f, 1.47756310e-02f, 9.26608162e-04f, -1.16723195e-01f,
  -2.97263768e-02f, -1.04988858e-01f, -5.95849603e-02f, -7.53504783e-03f, 4.55103666e-02f, 5.92209073e-03f, -5.86584210e-02f, -5.70187680e-02f, 1.62347071e-02f, -1.92725589e-03f,
  4.33846982e-03f, -1.45686612e-01f, -1.23979017e-01f, 1.83558967e-02f, -1.04343362e-01f, -2.72554662e-02f, -4.19548154e-02f, -8.14710977e-04f, 4.95017469e-02f, -8.29650983e-02f,
  2.03773994e-02f, 4.90838103e-02f, -1.08938418e-01f, 2.43123751e-02f, 1.06482260e-01f, -2.06583645e-02f, -6.42139539e-02f, 1.99191589e-02f, 3.43345068e-02f, -4.91874963e-02f,
  -5.17567359e-02f, 6.55125529e-02f, 1.05277719e-02f, -9.79303848e-04f, -6.75965697e-02f, -7.59747401e-02f, -1.47975888e-02f, -2.80525256e-02f, 1.05396837e-01f, 1.81721598e-02f,
  7.90043548e-02f, 1.45326518e-02f, -1.61560886e-02f, -1.09924620e-03f, 1.53796291e-02f, 5.44350035e-02f, -4.15131338e-02f, 6.69936240e-02f, -1.72055140e-02f, -6.60790652e-02f,
  1.66831404e-01f, 1.42193094e-01f, 3.29428054e-02f, 4.88164388e-02f, -1.01968147e-01f, -7.94681534e-02f, 6.55792877e-02f, -1.06610812e-01f, 5.37216756e-03f, 1.10747255e-02f,
  1.38130225e-02f, -1.51342722e-02f, -1.08777592e-02f, -2.83798901e-03f, -2.67982353e-02f, 5.17814362e-04f, 1.05426267e-01f, 4.46619801e-02f, -4.69589718e-02f, -1.22941405e-01f,
  -3.14796492e-02f, 5.61276861e-02f, 1.95975855e-01f, 1.01915181e-01f, 4.80066538e-02f, 9.56356153e-02f, 4.25997786e-02f, 2.33941283e-02f, 3.18849906e-02f, 7.14349002e-02f,
  1.71939895e-01f, -2.14471832e-01f, 1.21090822e-01f, 1.89056888e-01f, 2.03470156e-01f, 2.26676345e-01f, 6.55239895e-02f, 1.31849358e-02f, 1.26107380e-01f, 4.15570959e-02f,
  -1.19889833e-01f, -1.00848898e-01f, -3.55032422e-02f, -1.49196789e-01f, 3.47553417e-02f, -6.59791827e-02f, 3.18263136e-02f, 1.69762641e-01f, 1.11702956e-01f, 4.24264297e-02f,
  -1.02233090e-01f, -4.73692417e-02f, 5.27293198e-02f, -6.14954270e-02f, -1.65409055e-02f, -9.02394727e-02f, -2.10526623e-02f, -4.27341573e-02f, -3.99425402e-02f, -1.23251006e-01f,
  -8.96147415e-02f, -1.12203710e-01f, 1.19728401e-01f, -3.01758666e-02f, -5.15796021e-02f, 1.76727697e-02f, 9.30241197e-02f, -9.61666405e-02f, -5.08406162e-02f, 2.93342415e-02f,
  -1.12903967e-01f, 3.97098176e-02f, -3.03639397e-02f, 2.56779436e-02f, -6.80419505e-02f, -6.33368194e-02f, -4.98142838e-02f, 4.67415154e-02f, 3.83285880e-02f, -8.66183341e-02f,
  -1.30698591e-01f, 3.50349993e-02f, 1.36148974e-01f, 3.25429291e-02f, -1.94422901e-03f, 1.26927286e-01f, -7.12746382e-02f, 7.42331613e-03f, 4.96220738e-02f, -2.85658818e-02f,
  -5.50152287e-02f, 5.25539666e-02f, -1.83426682e-02f, -4.89245877e-02f, -1.36165358e-02f, -5.62158711e-02f, 8.84151682e-02f, 2.56276131e-02f, 2.45679952e-02f, -4.42375876e-02f,
  5.08205183e-02f, 5.16338423e-02f, -4.99919839e-02f, 8.74338746e-02f, 4.70859604e-03f, 2.12507918e-02f, 7.70981386e-02f, -6.16374239e-03f, 6.71257675e-02f, 2.41214391e-02f,
  -5.61275519e-02f, 9.36731547e-02f, -1.51788956e-02f, -4.58255876e-03f, -2.97953282e-02f, 4.06462476e-02f, 5.10953367e-02f, -5.81815019e-02f, -1.50502725e-02f, 6.43249275e-03f,
  -2.02763200e-01f, 8.08166787e-02f, -3.05413306e-02f, -9.51866657e-02f, 3.33985537e-02f, -7.79878348e-02f, 1.32440077e-03f, -9.65706483e-02f, -2.21930202e-02f, -3.17376778e-02f,
  -5.28753996e-02f, -1.26359105e-01f, -1.00289173e-01f, -1.48543585e-02f, 1.13911875e-01f, 1.11599959e-01f, -1.55114327e-02f, 7.26923645e-02f, -7.79622346e-02f, -1.08768910e-01f,
  -1.04109414e-01f, 2.21992478e-01f, 2.11219490e-01f, -1.76247656e-02f, 3.67387235e-02f, 1.53984860e-01f, 6.52130693e-02f, 8.18967670e-02f, 7.41237104e-02f, 4.20149358e-04f,
  3.26102942e-01f, -8.89810100e-02f, -1.69096529e-01f, 6.40317425e-02f, -2.44537428e-01f, -3.06212455e-01f, -3.32690954e-01f, -9.43293050e-02f, -2.88585946e-03f, -1.30650699e-01f,
  -1.50547400e-01f, -6.80963174e-02f, -5.75547554e-02f, -5.95834218e-02f, -9.90118459e-02f, -1.34174109e-01f, -1.14520803e-01f, -9.39299092e-02f, -1.23904392e-01f, -1.39260083e-01f,
  -1.34185776e-01f, 1.19649291e-01f, 1.55026197e-01f, -6.16520867e-02f, -1.08131610e-01f, -1.23985447e-01f, -1.34189427e-01f, 1.06533673e-02f, -1.27593890e-01f, -5.39151765e-03f,
  -3.65926117e-01f, -2.11834371e-01f, 8.02216306e-02f, 9.61047038e-02f, 2.15167757e-02f, 8.44695792e-02f, 1.65619589e-02f, 1.74153857e-02f, 2.88428646e-02f, 9.63575114e-03f,
  -4.05171476e-02f, -4.84335348e-02f, -4.73915935e-02f, -1.26094446e-01f, 1.91380531e-02f, -2.93515716e-02f, 1.08733863e-01f, -2.60556606e-03f, 3.58202346e-02f, -1.46329597e-01f,
  -9.93862152e-02f, -9.92857665e-03f, -1.62110925e-02f, 4.97075990e-02f, -4.29230370e-02f, 3.44052762e-02f, -1.66243553e-01f, -1.90294713e-01f, -1.23429574e-01f, -5.28631099e-02f,
  -2.10269112e-02f, 7.83053599e-03f, 2.34228326e-03f, -6.37080148e-02f, 1.07930765e-01f, 6.75628036e-02f, -8.51766095e-02f, 1.01589829e-01f, -8.70856494e-02f, 1.23478565e-02f,
  2.66657863e-02f, 1.88223515e-02f, 8.29332173e-02f, 6.79232702e-02f, 3.57449241e-02f, -8.10708404e-02f, -1.42700123e-02f, 6.37146160e-02f, 7.12055117e-02f, 1.74036790e-02f,
  3.07131521e-02f, -6.12648018e-02f, -3.70601229e-02f, -3.58935073e-02f, -6.05449155e-02f, 4.82617244e-02f, -4.41218987e-02f, 1.73596535e-02f, -7.57295936e-02f, 6.61409518e-04f,
  1.29765496e-01f, -2.09635794e-02f, -6.01661354e-02f, -5.58666214e-02f, 3.33648399e-02f, -3.44269425e-02f, -4.66234908e-02f, 8.56951326e-02f, 6.80943057e-02f, -4.75144424e-02f,
  -1.35915905e-01f, 5.24752736e-02f, 1.39999110e-03f, 2.56776083e-02f, -4.07863967e-02f, -3.06374151e-02f, 6.87272176e-02f, 2.15113629e-02f, 7.05795875e-03f, -1.04950376e-01f,
  1.08771071e-01f, 1.13727063e-01f, 1.43513650e-01f, 3.98464911e-02f, -5.31554930e-02f, 7.16820313e-03f, -3.03418916e-02f, -1.48635060e-02f, 6.47701174e-02f, 1.87514529e-01f,
  -1.85758770e-01f, 3.20254922e-01f, -2.28504166e-02f, -1.24262862e-01f, -1.60271507e-02f, 1.81340441e-01f, 2.81091869e-01f, 1.07282028e-02f, -6.48036227e-02f, 7.27806389e-02f,
  -2.95053646e-02f, -7.32029453e-02f, -2.64190342e-02f, 5.38726151e-03f, -5.96510954e-02f, 1.24324590e-01f, 2.11945012e-01f, -2.77725197e-02f, -1.99324936e-01f, -5.68662994e-02f,
  2.21047997e-02f, -9.25710276e-02f, -9.96904969e-02f, -9.01461542e-02f, -5.28407982e-03f, -5.54085933e-02f, 1.09299108e-01f, -6.70885071e-02f, -2.76506646e-03f, 1.29620120e-01f,
  -1.34863690e-01f, 6.93535060e-02f, -1.12474963e-01f, 3.22858132e-02f, 7.24574029e-02f, -4.49022502e-02f, 8.86052400e-02f, -1.10929450e-02f, -6.42632395e-02f, -1.15668029e-02f,
  -7.06296042e-02f, 3.12168077e-02f, -1.50894905e-02f, -1.16511680e-01f, -9.78348553e-02f, -4.39337566e-02f, -3.13084237e-02f, -2.33219620e-02f, -1.17512606e-01f, -4.12916988e-02f,
  6.19544312e-02f, -7.89444670e-02f, -1.21887706e-01f, -6.70455247e-02f, -3.57310176e-02f, -1.04622349e-01f, -2.05135364e-02f, 1.79539584e-02f, -1.06552191e-01f, 5.08888476e-02f,
  1.28375456e-01f, 9.67792720e-02f, 5.06175235e-02f, -6.10003173e-02f, 1.86578855e-02f, 9.00452584e-02f, 1.14816949e-01f, -6.24372885e-02f, 1.76367741e-02f, 2.64410488e-03f,
  3.06239934e-03f, -1.89434905e-02f, 8.03325623e-02f, -8.12300071e-02f, 6.10810407e-02f, 8.21054950e-02f, 1.22702345e-01f, 8.13043416e-02f, 7.29134830e-04f, -1.40167018e-02f,
  4.52489778e-02f, -6.99502900e-02f, 6.14225008e-02f, -9.01841745e-02f, 1.37612754e-02f, 7.22588673e-02f, -3.61454710e-02f, 2.43321583e-02f, -1.36264497e-02f, -3.89671437e-02f,
  -2.04596028e-01f, 1.09585449e-02f, -7.60909840e-02f, 3.85253355e-02f, 9.88857672e-02f, -6.76437095e-02f, -2.35436168e-02f, -8.78945813e-02f, -1.21059669e-02f, -4.88780737e-02f,
  -1.04845902e-02f, -1.05543517e-01f, -4.04032692e-02f, -2.74614803e-02f, -1.78580079e-02f, -6.18836209e-02f, -3.85983079e-03f, -1.24833293e-01f, -8.70804638e-02f, 5.21689802e-02f,
  3.14966477e-02f, -4.19354141e-02f, -9.73143429e-02f, -3.88306715e-02f, 3.95667367e-02f, -1.15555778e-01f, -8.65656696e-03f, -2.72360314e-02f, -5.03651202e-02f, 2.76165158e-02f,
  -3.90914649e-01f, 1.78011373e-01f, 5.90514503e-02f, -3.12084824e-01f, -1.26060858e-01f, 1.80009544e-01f, 2.05819175e-01f, 4.23460566e-02f, -6.38954267e-02f, 1.06903628e-01f,
  -6.33067191e-02f, -1.89977081e-03f, 1.85520574e-02f, -5.35460450e-02f, 1.01992458e-01f, 8.03370029e-02f, 2.14876048e-02f, -3.02335713e-02f, -1.16535470e-01f, 3.53587195e-02f,
  2.12251544e-02f, -2.02931538e-01f, -2.42830098e-01f, -1.07615687e-01f, -6.83560176e-03f, 5.45967184e-03f, 2.11400092e-02f, -1.33959413e-01f, 1.06365541e-02f, -6.85110092e-02f,
  2.08443850e-01f, -2.23268360e-01f, 2.80574593e-03f, -1.95979521e-01f, -7.37108737e-02f, 1.67532675e-02f, -7.30991969e-03f, -1.81524187e-01f, -3.44200209e-02f, 2.07420699e-02f,
  -2.15032860e-03f, -1.48749173e-01f, -2.78710276e-02f, -2.88684722e-02f, -5.47506772e-02f, -1.50845600e-02f, -8.50497559e-02f, -1.47012591e-01f, -1.10476516e-01f, 6.54817447e-02f,
  2.80617494e-02f, 5.37921414e-02f, -9.21920314e-02f, -1.79990903e-02f, 3.61494534e-02f, -3.89785916e-02f, 8.33103731e-02f, -1.39423728e-01f, 8.47367942e-03f, -3.47665735e-02f,
  -2.48056669e-02f, -4.05312479e-02f, -3.06801684e-02f, -4.22565043e-02f, -8.90708715e-02f, -5.54040745e-02f, 4.82023656e-02f, 3.80420238e-02f, -3.90899740e-02f, 4.71965186e-02f,
  -6.85431855e-03f, 1.07754365e-01f, 9.66057256e-02f, 3.86963785e-02f, -3.52947004e-02f, 3.60579863e-02f, -3.05476831e-03f, 9.68951359e-03f, 5.47143631e-02f, 1.04640573e-02f,
  -2.84415409e-02f, -3.70117612e-02f, -8.28178786e-03f, -5.07075563e-02f, 8.57736543e-03f, -3.91911380e-02f, -3.36858258e-02f, 1.79170426e-02f, -2.77323760e-02f, 4.87475470e-03f,
  1.73227519e-01f, -2.45966148e-02f, -2.45035421e-02f, -1.60529897e-01f, -3.56008089e-03f, -3.66203822e-02f, -3.41382138e-02f, -6.00408912e-02f, -5.07444851e-02f, 2.69276407e-02f,
  8.19888525e-03f, 2.29182187e-02f, 9.66549665e-02f, -4.00307542e-03f, 7.94085711e-02f, 8.13564360e-02f, 4.41422127e-02f, -4.93792398e-03f, -1.79005582e-02f, 7.18997121e-02f,
  7.59624615e-02f, 1.23063520e-01f, 8.00771415e-02f, 1.54005140e-02f, -6.67003021e-02f, 5.57450578e-02f, 1.43016115e-01f, 8.34843516e-03f, 1.50651425e-01f, 1.05308108e-01f,
  -2.01148480e-01f, -2.21157163e-01f, 2.51496345e-01f, -1.94508538e-01f, -1.80962071e-01f, -2.12907493e-01f, -2.21375808e-01f, -9.13912803e-02f, -1.38586894e-01f, -2.68351555e-01f,
  -2.18450487e-01f, -7.93824345e-02f, -2.44641136e-02f, -3.69031318e-02f, -2.88298279e-02f, -7.41143078e-02f, -4.19989638e-02f, 6.48526549e-02f, 7.51997456e-02f, -1.33309051e-01f,
  -2.14861631e-01f, -7.57510960e-03f, 9.56950989e-03f, 5.38055934e-02f, -5.08360974e-02f, -4.24154960e-02f, 5.23690470e-02f, -9.18026865e-02f, -8.52343142e-02f, -2.71703526e-02f,
  -1.41406879e-01f, 6.49677068e-02f, 3.66091765e-02f, 2.33754180e-02f, -2.92029809e-02f, -3.26013565e-02f, -3.35822031e-02f, 3.02634928e-02f, 5.19477725e-02f, 1.64706614e-02f,
  3.09530962e-02f, -2.73204944e-03f, -5.22697940e-02f, 3.38810943e-02f, -4.79285121e-02f, -5.64153567e-02f, 1.79784726e-02f, 1.45879015e-01f, 8.52281079e-02f, -5.01610199e-03f,
  -1.59289524e-01f, -1.01841658e-01f, -4.08852622e-02f, 4.59709764e-02f, 7.80132413e-03f, 5.22696488e-02f, -6.40824065e-03f, -7.45653063e-02f, -1.15917958e-02f, -2.20343471e-01f,
  -6.21263031e-03f, -1.05600236e-02f, 1.19924946e-02f, -3.91423665e-02f, -3.51132788e-02f, 7.02947229e-02f, 8.25942382e-02f, -8.28011930e-02f, -1.15619833e-02f, 2.90833022e-02f,
  6.20188601e-02f, -4.83684167e-02f, 1.60675868e-02f, 4.25582565e-02f, 2.95849498e-02f, -1.47527931e-02f, 1.01287812e-02f, 7.72461714e-03f, 7.16014132e-02f, -5.22138923e-02f,
  4.07233499e-02f, 7.85508901e-02f, 6.39388487e-02f, -5.98997585e-02f, 5.45647554e-02f, 1.80366542e-02f, -4.11536824e-03f, -3.36379036e-02f, -2.51017306e-02f, 6.70072511e-02f,
  -1.68806091e-01f, 1.73897058e-01f, -1.97969705e-01f, -3.94034088e-02f, -1.60699282e-02f, 5.42220734e-02f, -7.96467662e-02f, 1.19270487e-02f, -1.80120543e-02f, -9.89979729e-02f,
  1.32239191e-02f, 1.22045400e-02f, -1.18608057e-01f, -9.80129316e-02f, -3.37201282e-02f, -4.59934510e-02f, -1.46920204e-01f, -9.02400315e-02f, -7.78974071e-02f, -1.01821654e-01f,
  -1.45030051e-01f, -2.85787255e-01f, -2.66183794e-01f, -1.12710975e-01f, -1.70180306e-01f, -6.72650337e-02f, -2.12346703e-01f, -1.48924872e-01f, -2.06902847e-01f, -3.43978345e-01f,
  -2.20146254e-01f, 1.78762481e-01f, -5.73452637e-02f, -3.40645537e-02f, -1.05569705e-01f, -1.24232359e-01f, -1.76926538e-01f, -1.12695165e-01f, 2.19851509e-02f, 1.39740735e-01f,
  3.51025127e-02f, -6.34566173e-02f, 2.91702766e-02f, -1.26098692e-01f, -3.25665057e-01f, -1.31794229e-01f, -1.36698773e-02f, -3.29255134e-01f, -3.58775407e-01f, -2.38424137e-01f,
  -1.04421213e-01f, -8.18223953e-02f, -2.58496225e-01f, -1.59986004e-01f, 9.67357308e-02f, 6.41591400e-02f, 1.15153223e-01f, 8.53555799e-02f, -1.65308581e-03f, 1.57858714e-01f,
  3.53556722e-01f, 4.33778577e-02f, -1.45254627e-01f, -5.08939326e-02f, 1.11881383e-01f, 4.37944159e-02f, -2.39655394e-02f, -6.38277158e-02f, 2.40834486e-02f, -9.35764089e-02f,
  -9.21346713e-03f, -1.97434474e-05f, 5.95844351e-02f, -6.94602579e-02f, -2.94174217e-02f, -7.79866204e-02f, -1.00297809e-01f, -8.74868408e-02f, -5.38128540e-02f, -6.74268827e-02f,
  -3.57538313e-02f, 1.34701990e-02f, -9.60006341e-02f, -5.83806867e-03f, 2.33827624e-02f, -7.56428717e-03f, -1.07563995e-02f, -7.59692788e-02f, -8.80055949e-02f, 1.25083953e-01f,
  8.14209431e-02f, 1.73519943e-02f, 3.33441645e-02f, -4.58323099e-02f, 3.77386436e-02f, 4.85552549e-02f, -3.76239382e-02f, 3.48222069e-02f, -1.58156101e-02f, -5.24095632e-02f,
  3.73816676e-02f, 6.59228861e-02f, 5.71489753e-03f, 1.00913659e-01f, -1.77274998e-02f, 1.45380003e-02f, 2.60354280e-02f, 3.80506576e-03f, -8.87932405e-02f, 2.93473415e-02f,
  -4.94017377e-02f, 1.18830353e-02f, 1.25104249e-01f, -6.77902848e-02f, -3.59578729e-02f, 5.01887761e-02f, -8.66319388e-02f, -8.34314898e-02f, -6.09624982e-02f, -5.80648743e-02f,
  1.81171194e-01f, -2.34790847e-01f, 8.34707916e-02f, 9.84755810e-03f, -2.21852753e-02f, -6.31596369e-04f, 8.11474025e-02f, -6.71933219e-02f, 1.98885985e-02f, 5.05224578e-02f,
  1.08110672e-03f, -6.88489294e-03f, 3.73597480e-02f, 6.72293752e-02f, -4.98302728e-02f, -2.65811719e-02f, -9.52397380e-03f, -5.15733212e-02f, -1.32592216e-01f, -7.24799652e-03f,
  -4.60546836e-02f, -9.92308650e-03f, -1.31990477e-01f, 1.17362857e-01f, -9.82106552e-02f, -9.94327068e-02f, 5.21304319e-03f, -7.68183311e-03f, -1.50295319e-02f, 1.90989926e-01f,
  -2.90305078e-01f, -6.38699457e-02f, 1.63069502e-01f, -1.79448277e-01f, 2.30364669e-02f, -6.19154572e-02f, -4.02745679e-02f, -1.48277849e-01f, -9.44182649e-02f, -1.29719257e-01f,
  -1.07578345e-01f, -9.96478349e-02f, -3.26191187e-02f, 9.31579024e-02f, 5.40148839e-02f, 6.01508319e-02f, 6.76910430e-02f, 9.23311487e-02f, 1.67373922e-02f, -5.50574390e-03f,
  -1.84913408e-02f, 4.73577790e-02f, 2.55805887e-02f, -2.24508196e-02f, -9.15871635e-02f, -5.26745990e-02f, -8.46965984e-03f, -9.70716961e-03f, 1.34443223e-01f, 1.57640148e-02f,
  -6.43446892e-02f, -1.64923131e-01f, -1.15984073e-03f, -8.66877213e-02f, 7.89240599e-02f, -8.69022906e-02f, -1.11948152e-03f, 4.42610420e-02f, -6.86964989e-02f, -3.65521275e-02f,
  4.01438214e-02f, -3.44247185e-02f, -1.06224328e-01f, -6.10356703e-02f, -5.56605030e-03f, -1.94147490e-02f, 7.74139985e-02f, 1.17791720e-01f, -1.74177755e-02f, -8.70758519e-02f,
  6.48237765e-02f, -1.25090852e-01f, -4.42617983e-02f, 3.55095929e-03f, 5.61886057e-02f, -3.82552333e-02f, -7.34271854e-02f, -2.18577441e-02f, 9.07970220e-03f, -6.61479011e-02f,
  -1.71600524e-02f, -2.46750135e-02f, 7.21353223e-04f, -1.66130010e-02f, 4.88354787e-02f, -3.68535966e-02f, -4.43756469e-02f, -1.75202657e-02f, 7.26623833e-02f, 7.75673334e-03f,
  -1.48192532e-02f, -2.73635201e-02f, -5.20435162e-03f, -4.88467850e-02f, -2.76077744e-02f, 4.57535498e-02f, 5.70152290e-02f, -3.77744213e-02f, -2.95802895e-02f, 3.49010434e-03f,
  -3.54025513e-02f, -3.41515280e-02f, -8.83836113e-03f, 4.11776081e-02f, 9.16862488e-02f, 1.37787834e-01f, -2.62905397e-02f, 3.02878884e-03f, 2.12541055e-02f, -1.38939898e-02f,
  -1.56666264e-01f, 2.42495060e-01f, -1.54332817e-01f, 3.30948122e-02f, -1.07585646e-01f, -2.52959300e-02f, -3.02927312e-03f, -1.54813360e-02f, 7.57890716e-02f, 1.83326583e-02f,
  -7.43047521e-02f, -7.53004337e-03f, 1.65169220e-02f, 6.81247786e-02f, -8.59307647e-02f, -5.26706800e-02f, -1.15173139e-01f, -3.58123817e-02f, 3.22094411e-02f, -1.35652646e-01f,
  1.02490541e-02f, -9.83694047e-02f, -2.69868881e-01f, -9.37654600e-02f, -1.55434087e-01f, -3.79501469e-02f, -1.83583185e-01f, -1.11245364e-01f, -4.46426049e-02f, -1.11547135e-01f,
  -2.94366479e-01f, -1.87466815e-01f, 1.99120548e-02f, 1.43970940e-02f, 9.31130052e-02f, 1.26075700e-01f, -4.11309265e-02f, -2.47976230e-03f, -6.02311343e-02f, -9.86572448e-03f,
  7.62539357e-02f, 3.29654515e-02f, 6.11997508e-02f, 8.29553828e-02f, 8.36645216e-02f, 7.72165507e-02f, 4.45527025e-02f, 1.98805854e-02f, 1.29230380e-01f, -3.89171429e-02f,
  -2.35840715e-02f, -4.07476164e-03f, -6.22725263e-02f, 8.61930102e-02f, 3.36480513e-03f, 5.48605882e-02f, 1.09174572e-01f, -2.33186428e-02f, -3.18495333e-02f, 6.87772483e-02f,
  -1.51428968e-01f, -1.64254725e-01f, 2.48889066e-02f, -5.69920205e-02f, 3.77519131e-02f, -1.52302399e-01f, -1.52212512e-02f, -6.68174252e-02f, 1.83877274e-02f, -1.14570884e-02f,
  6.30969033e-02f, -9.55575705e-03f, 1.72122736e-02f, -1.01005211e-01f, -9.55821815e-06f, -3.99486423e-02f, -9.29493606e-02f, -1.15002636e-02f, 2.18518414e-02f, -1.12599581e-01f,
  1.03201538e-01f, 1.69961769e-02f, -8.91039521e-02f, -4.22745384e-02f, 1.27484053e-02f, 4.16181497e-02f, -3.45388763e-02f, -1.37896851e-01f, -6.43514767e-02f, -1.58281296e-01f,
  8.35831389e-02f, 1.30849751e-02f, 4.42862622e-02f, -8.42799842e-02f, 1.03333946e-02f, -4.55168635e-02f, -4.77204658e-02f, -1.76919624e-02f, 9.63507518e-02f, 3.01328711e-02f,
  6.03029132e-02f, 4.86116894e-02f, -5.30722849e-02f, -6.80247918e-02f, -4.46518511e-02f, 3.66949104e-02f, -3.96349952e-02f, 5.18497340e-02f, 3.83929573e-02f, 5.99634200e-02f,
  -4.15618308e-02f, 6.98352382e-02f, 4.05853242e-02f, 2.18070950e-02f, -6.44383058e-02f, 7.55095929e-02f, 2.59981081e-02f, -8.58631805e-02f, -9.67504457e-03f, -1.17725298e-01f,
  -1.11271486e-01f, 1.69642612e-01f, -1.22617163e-01f, -1.03501663e-01f, 1.75698120e-02f, 2.18417551e-02f, -6.84810653e-02f, 4.64784950e-02f, -7.15343878e-02f, -6.64106756e-02f,
  3.76422219e-02f, -8.15130994e-02f, 4.32232544e-02f, -9.71548855e-02f, 4.13598008e-02f, -6.92974627e-02f, -4.12727334e-02f, 1.21086498e-03f, -5.29715568e-02f, -1.02492437e-01f,
  -6.22585528e-02f, -1.05237141e-01f, -1.81135580e-01f, -1.50642237e-02f, -1.26613498e-01f, 3.64669822e-02f, -9.43301767e-02f, -1.12784162e-01f, -2.91485935e-02f, -2.16135323e-01f,
  8.43683630e-02f, 8.34222808e-02f, 1.12336747e-01f, 6.91803172e-02f, -1.44098878e-01f, -1.17255598e-01f, -7.01236650e-02f, -1.82495534e-01f, -6.94409832e-02f, -2.63633691e-02f,
  8.75835400e-03f, -5.03792875e-02f, 1.56835765e-02f, -7.86176845e-02f, 5.93184866e-02f, -1.73541419e-02f, 4.11615297e-02f, 1.39789373e-01f, 7.11813197e-02f, -9.24025849e-02f,
  6.65099174e-02f, 7.02713728e-02f, 1.40886396e-01f, 5.67132086e-02f, 1.27408549e-01f, 6.31961692e-03f, 1.14939898e-01f, 1.37278214e-01f, 7.85801858e-02f, 1.71304464e-01f,
  3.53901349e-02f, 6.57344237e-02f, -1.09245904e-01f, 8.71182047e-03f, 3.22907344e-02f, -2.20933352e-02f, 1.20854806e-02f, 2.66819429e-02f, -8.43955427e-02f, 9.03568044e-03f,
  -1.86858978e-02f, -5.18537536e-02f, 1.52219506e-02f, 6.88632429e-02f, -1.72436703e-02f, 4.52120882e-03f, 8.31524357e-02f, 7.04895556e-02f, -8.95016789e-02f, -3.80652933e-03f,
  -6.81377873e-02f, 5.32217473e-02f, -6.89658895e-02f, -1.39194518e-01f, 4.13240194e-02f, -1.47558022e-02f, 3.85699980e-02f, 9.77415666e-02f, -6.37292191e-02f, 7.70612657e-02f,
  3.48524936e-02f, 7.41477087e-02f, 3.98492664e-02f, -2.51096804e-02f, 1.12394445e-01f, -3.03684976e-02f, 6.05911501e-02f, 6.20320514e-02f, -3.96710560e-02f, -5.01335636e-02f,
  3.85440141e-02f, 9.46249696e-04f, 2.10443642e-02f, -2.89471413e-04f, 4.63046692e-02f, 5.52049875e-02f, 8.79003182e-02f, 6.47156090e-02f, -2.51904000e-02f, -5.98134212e-02f,
  -1.43784622e-03f, -4.07835143e-03f, 8.33031982e-02f, -4.93837893e-02f, 1.01791292e-01f, 8.23697373e-02f, 2.64874659e-02f, -6.85166270e-02f, 5.93528450e-02f, 3.07014287e-02f,
  -4.25030217e-02f, -2.77297627e-02f, 6.41827583e-02f, -6.63778337e-04f, 6.36946410e-02f, -4.60618585e-02f, -4.63743210e-02f, 1.47828087e-02f, 3.36461551e-02f, -7.20931739e-02f,
  -1.86196528e-02f, -3.34011461e-03f, -2.77481060e-02f, -2.97076884e-04f, -6.90074414e-02f, -1.08977690e-01f, -9.75109339e-02f, -4.11478020e-02f, 4.42856215e-02f, 6.53177127e-02f,
  -7.31974319e-02f, -2.44932976e-02f, -6.51221201e-02f, -7.82161877e-02f, -1.18209444e-01f, -1.41055644e-01f, -3.57936881e-02f, -2.88096629e-02f, -8.65499750e-02f, 2.62363744e-03f,
  -1.25566915e-01f, 1.40049875e-01f, 1.70911565e-01f, -6.99949563e-02f, 1.21325076e-01f, -4.14090082e-02f, -6.82507083e-02f, -1.41537279e-01f, -7.86179211e-03f, 1.32777557e-01f,
  4.43485454e-02f, 9.63928774e-02f, -1.03227749e-01f, -1.55109406e-01f, -2.21361697e-01f, -7.44986832e-02f, -4.46017273e-02f, -1.09530561e-01f, -1.00860134e-01f, -3.90652902e-02f,
  -1.34125754e-01f, -2.95864362e-02f, -2.17529595e-01f, -7.51162991e-02f, 2.44409144e-02f, 3.52293290e-02f, 8.15944076e-02f, 7.24966750e-02f, -2.01731920e-02f, 4.61605452e-02f,
  2.89416581e-01f, 7.43297115e-02f, -3.73075977e-02f, -5.91285154e-02f, 4.86682989e-02f, -1.64839290e-02f, 7.39134522e-03f, -8.33222270e-02f, 8.46039597e-03f, -4.33453880e-02f,
  1.01252787e-01f, 4.32693958e-02f, -4.25423309e-02f, -3.71566862e-02f, -1.16849370e-01f, 4.47831526e-02f, -8.73295292e-02f, -1.20033123e-01f, 1.01798698e-02f, -9.30024832e-02f,
  -5.24664260e-02f, 6.10758178e-02f, 2.40060799e-02f, -1.11526385e-01f, 3.13863717e-02f, 5.94234429e-02f, 5.38652614e-02f, 3.56324241e-02f, -9.98927876e-02f, -2.16639740e-03f,
  -2.27693338e-02f, 4.50256222e-04f, -4.36600707e-02f, 4.23412323e-02f, 6.02931436e-03f, 8.67995098e-02f, -7.00234994e-02f, 3.60039473e-02f, -8.66583362e-02f, 7.77031407e-02f,
  -7.00279176e-02f, 7.17172772e-02f, -7.79132620e-02f, -3.24022435e-02f, -6.51422609e-03f, -4.34726402e-02f, -4.27046306e-02f, -4.86398228e-02f, -2.96132658e-02f, -4.22267988e-03f,
  1.95009615e-02f, 4.84564975e-02f, 5.45217879e-02f, -3.11474036e-02f, -3.28889117e-02f, -7.82877281e-02f, 3.57633606e-02f, 6.11496717e-02f, 6.16026297e-02f, -3.95533033e-02f,
  -4.50184047e-02f, -1.01173662e-01f, -2.77739838e-02f, -1.32754892e-01f, -5.11244200e-02f, -6.71521178e-04f, 4.51463573e-02f, 3.41535658e-02f, -1.05040148e-02f, -9.74384975e-03f,
  6.91158846e-02f, 8.30885693e-02f, -1.48285367e-02f, -4.48124669e-02f, -1.60286613e-02f, -7.87448809e-02f, -9.90204439e-02f, 4.26336490e-02f, -7.45197684e-02f, 3.85792949e-03f,
  -9.81054604e-02f, -6.16422258e-02f, 7.34826317e-03f, 3.22235636e-02f, 2.24171150e-02f, -5.72794564e-02f, 5.02729183e-03f, 3.01846936e-02f, -1.24524739e-02f, -6.43951297e-02f,
  -7.77677670e-02f, 3.09639603e-01f, -2.68625449e-02f, -1.47623003e-01f, 5.90978861e-02f, 1.99260280e-01f, 3.11120600e-01f, 7.26256818e-02f, -1.15560740e-01f, 1.43799737e-01f,
  -1.20192533e-02f, -8.08608308e-02f, -1.80124611e-01f, -1.39355078e-01f, 1.50376707e-02f, 1.68380246e-01f, 2.67626904e-02f, -6.53992072e-02f, -1.46943077e-01f, 3.53534594e-02f,
  6.39339015e-02f, -1.56328559e-01f, -1.18050560e-01f, -1.46411523e-01f, -1.62949309e-01f, -2.20995620e-01f, -1.38708070e-01f, -6.48562163e-02f, 5.23047112e-02f, -8.91678184e-02f,
  -1.14548706e-01f, -2.10761707e-02f, -6.99117333e-02f, -1.67604834e-02f, -4.03692946e-02f, -3.92448977e-02f, -7.22741932e-02f, -4.29073684e-02f, -7.79753998e-02f, -5.60423732e-02f,
  -2.68279184e-02f, -5.55187510e-03f, -1.59582481e-01f, 1.24420216e-02f, -7.94781651e-03f, -9.98476297e-02f, 1.13919340e-02f, -1.41879275e-01f, -7.72895589e-02f, 1.10998876e-01f,
  5.60548231e-02f, 1.19162902e-01f, 2.87041776e-02f, 5.40325232e-02f, 2.19109692e-02f, -1.38513371e-01f, 1.18387364e-01f, 3.64086367e-02f, -5.11591733e-02f, 2.22100187e-02f,
  4.23989072e-02f, 3.02552376e-02f, -1.43740596e-02f, 2.36745030e-02f, -3.84556092e-02f, 1.73647646e-02f, -1.39887899e-03f, 4.45158519e-02f, -4.68385518e-02f, -8.27744380e-02f,
  1.22599667e-02f, 6.98876306e-02f, -2.59148087e-02f, -1.39685096e-02f, -4.44999002e-02f, -5.23363799e-02f, 3.98243666e-02f, 1.00180119e-01f, 8.59383568e-02f, -8.30856636e-02f,
  -5.47125153e-02f, 5.32488227e-02f, -7.44542181e-02f, -1.62540004e-02f, 5.81648648e-02f, 8.14499706e-03f, -4.95135784e-02f, -3.24269608e-02f, -2.41420101e-02f, 9.46912318e-02f,
  -2.45237648e-01f, 1.07296810e-01f, -1.04618713e-01f, -7.67936483e-02f, -6.60480261e-02f, -5.60388677e-02f, -1.53095415e-02f, -5.37003251e-03f, -2.40032505e-02f, -1.60755981e-02f,
  7.53635317e-02f, -7.12397182e-03f, -2.70984396e-02f, -2.04644799e-02f, 1.04581518e-02f, 4.05227095e-02f, 1.11545958e-01f, -7.34832976e-03f, 5.62852919e-02f, -1.84988312e-03f,
  2.51709688e-02f, 2.35465337e-02f, -1.07766213e-02f, 5.88229038e-02f, 1.63590796e-02f, -6.42717779e-02f, 9.97878984e-03f, 5.37729962e-03f, -7.01123662e-03f, 7.39521012e-02f,
  -7.19593242e-02f, -1.16819039e-01f, -1.30302981e-01f, -4.75188866e-02f, -9.32666436e-02f, -2.90844217e-03f, -4.19767238e-02f, 1.17181033e-01f, 6.96455538e-02f, -9.09010917e-02f,
  -8.71394649e-02f, -1.91931482e-02f, -2.16557160e-02f, -1.05182834e-01f, -4.06409465e-02f, -1.59184784e-01f, -1.54960871e-01f, -2.65410185e-01f, -1.34740815e-01f, -1.37831673e-01f,
  -9.20714140e-02f, -5.31808287e-02f, -7.50968903e-02f, -1.18155062e-01f, -1.08786754e-01f, -1.90200940e-01f, -5.88161219e-03f, -1.38015613e-01f, -1.48713678e-01f, -9.58683938e-02f,
  7.11486617e-04f, -5.39940745e-02f, -1.24161296e-01f, -1.40372232e-01f, 7.42488727e-02f, 8.60732943e-02f, 5.74069284e-03f, 7.07180277e-02f, 6.70262426e-02f, 2.30433196e-02f,
  -5.15863597e-02f, -5.58008663e-02f, 4.06726114e-02f, -3.54767628e-02f, 7.45706260e-02f, -6.89451769e-02f, -8.93650874e-02f, -5.78408167e-02f, -1.34006456e-01f, 5.72964642e-03f,
  -8.87426082e-03f, -1.38274670e-01f, -1.77909248e-02f, -9.77707282e-02f, 2.70024966e-02f, -1.31120279e-01f, -2.29560006e-02f, -1.25798937e-02f, -1.36682242e-01f, -1.08530410e-01f,
  5.26632890e-02f, -1.00239804e-02f, -6.21478111e-02f, -2.23453692e-03f, -7.24435830e-03f, -4.90642674e-02f, 6.68124855e-02f, -5.87459505e-02f, -3.48438136e-02f, 4.20366190e-02f,
  -5.34602739e-02f, 5.07660285e-02f, 1.23919304e-02f, 1.04731275e-02f, 4.20835894e-03f, 6.10789694e-02f, -8.72177705e-02f, 5.95036969e-02f, -8.14532042e-02f, -5.36635891e-02f,
  -9.45785567e-02f, -2.33364049e-02f, 3.55280121e-03f, 6.06779791e-02f, -5.66808619e-02f, -6.49836138e-02f, 7.27514103e-02f, -2.19986234e-02f, 2.09553689e-02f, 2.30590478e-02f,
  -6.47261515e-02f, 1.57416950e-03f, 2.82197469e-03f, 5.34376223e-03f, 2.57150251e-02f, 3.66230831e-02f, 3.76348719e-02f, -4.90679443e-02f, -7.23505393e-02f, -5.89781702e-02f,
  1.97517755e-03f, -7.86254629e-02f, 4.93387356e-02f, -8.57855845e-03f, -7.20323175e-02f, 3.15970182e-02f, -7.40592852e-02f, -1.24318302e-01f, -6.56641871e-02f, 1.45103177e-03f,
  1.73956808e-02f, -4.37961407e-02f, -2.42618322e-01f, 6.05871482e-03f, -4.19818684e-02f, -1.83164477e-01f, -8.04838613e-02f, -2.25635581e-02f, -2.33821809e-01f, -4.51840088e-02f,
  2.33262971e-01f, 4.66117263e-01f, 2.20702127e-01f, -7.12370325e-04f, 1.18665330e-01f, 2.78046042e-01f, 4.32584703e-01f, 1.90504611e-01f, -7.13898763e-02f, 1.50878921e-01f,
  6.49212673e-02f, -1.66782960e-01f, -1.54737830e-01f, -1.11995026e-01f, 1.64155692e-01f, 1.22622579e-01f, -7.27605596e-02f, -5.29528633e-02f, -1.24383353e-01f, 1.65306274e-02f,
  -2.22967602e-02f, 4.01353799e-02f, -3.16031463e-02f, -4.38154154e-02f, 2.98229810e-02f, -7.88132548e-02f, 7.53854355e-03f, 1.72680289e-01f, -4.21524197e-02f, -1.23738572e-01f,
  -1.10260576e-01f, 4.54235822e-01f, -2.55234390e-01f, -8.02172124e-02f, 6.35025725e-02f, -2.22801957e-02f, -6.32016584e-02f, -1.13028698e-01f, 3.06626726e-02f, -3.14359963e-02f,
  -1.05652343e-02f, 3.74678448e-02f, 8.57989304e-03f, 2.05558091e-02f, 1.05089396e-01f, 8.69582519e-02f, 2.44097877e-02f, -1.46097708e-02f, 1.02769036e-03f, 7.45631158e-02f,
  2.03797407e-02f, 8.97823796e-02f, 1.71407267e-01f, 1.20945677e-01f, 4.38130796e-02f, -2.69632135e-02f, 8.17309320e-02f, -3.20673995e-02f, 6.11804314e-02f, -2.85763200e-02f,
  -1.27074286e-01f, -4.77380864e-02f, -4.16536145e-02f, 3.00623407e-03f, -1.48504637e-02f, -3.67720500e-02f, 3.03852675e-03f, -1.73725206e-02f, 3.56219970e-02f, -4.63318601e-02f,
  2.40709353e-02f, 3.36402208e-02f, 5.05229644e-02f, -2.67459303e-02f, -1.32508099e-01f, 8.25464725e-02f, 1.14470422e-02f, -3.58444117e-02f, 5.63885756e-02f, -4.70050424e-03f,
  2.56924052e-02f, -2.84193680e-02f, 1.70074236e-02f, 3.80352400e-02f, 8.02940503e-03f, 7.88385347e-02f, -1.84175335e-02f, 2.47052554e-02f, 1.92896500e-02f, 4.52509075e-02f,
  -2.02136338e-01f, 1.43282741e-01f, -1.94175795e-01f, -7.23150820e-02f, -1.85557883e-02f, 2.48812838e-03f, -8.95554125e-02f, -8.91452134e-02f, 4.20166180e-02f, 2.84554381e-02f,
  -8.11506645e-04f, -4.53722961e-02f, 1.29246682e-01f, -3.32239158e-02f, -1.29318759e-02f, -8.63576159e-02f, -8.23927969e-02f, -1.26578296e-02f, -1.12134144e-01f, -1.05411157e-01f,
  -8.88928846e-02f, 1.15932487e-02f, -4.35588248e-02f, -1.23166710e-01f, -2.28877366e-02f, -1.71270683e-01f, -1.06975116e-01f, -1.42554164e-01f, 5.72840869e-02f, -1.38611779e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.23758461e-02f, 1.27951235e-01f, 1.47250310e-01f, 1.29930198e-01f, 1.99584737e-01f, 8.71801227e-02f, 1.53189287e-01f, 3.09705824e-01f, 2.60251790e-01f, 3.12496096e-01f,
  1.14390247e-01f, 3.79087478e-01f, 2.71130294e-01f, 4.99827228e-02f, 1.17045820e-01f, 1.88800544e-01f, 2.10899800e-01f, 2.42044047e-01f, 9.60996002e-02f, 1.83398113e-01f,
  1.00789256e-01f, 2.15271786e-01f, 2.54524767e-01f, 3.63262177e-01f, 1.81878492e-01f, 6.22916929e-02f, 1.78810999e-01f, 1.46490276e-01f, 1.80898577e-01f, 4.10019189e-01f,
  8.41657445e-02f, 7.96803609e-02f, 2.71249473e-01f, 2.00787649e-01f, 1.35461301e-01f, 2.42710754e-01f, 1.16542555e-01f, 5.57404719e-02f, 2.30146483e-01f, 1.02045260e-01f,
  2.31420025e-01f, 2.11457953e-01f, 2.35216409e-01f, 2.95217365e-01f, 3.34050119e-01f, 1.50375038e-01f, 7.83578008e-02f, 4.32249047e-02f, 1.13678128e-01f, 3.32787782e-01f,
  2.31703520e-02f, 1.30604655e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -6.89248880e-03f, -2.81983703e-01f, -5.82489908e-01f, -4.22371984e-01f, -1.82510808e-01f, -3.14706743e-01f, 1.42737431e-02f, 3.86208355e-01f, 7.54976571e-02f, -8.72706845e-02f,
  1.44922078e-01f, 9.08269454e-03f, 8.02763924e-02f, -3.12726736e-01f, 3.30347754e-02f, 2.26619113e-02f, 6.67835891e-01f, -2.28068963e-01f, 1.16872609e-01f, -7.18542263e-02f,
  1.02981500e-01f, 1.10157086e-02f, 5.90644896e-01f, -7.27919117e-02f, 2.42349297e-01f, 1.15501687e-01f, -1.26938060e-01f, -1.26299366e-01f, -1.01225905e-01f, 8.89679883e-03f,
  6.05324447e-01f, -1.17345974e-01f, -2.21036926e-01f, 1.22416981e-01f, -1.65967077e-01f, -1.45937294e-01f, -4.10124063e-01f, 5.18611550e-01f, -1.07921623e-01f, 1.91460833e-01f,
  2.36071482e-01f, -2.80992866e-01f, -9.40349475e-02f, -7.13787451e-02f, -3.96148473e-01f, -1.02405343e-02f, 3.13710600e-01f, -2.61538215e-02f, 8.30312148e-02f, -1.86570495e-01f,
  3.04160770e-02f, -3.28286464e-04f, 3.64363454e-02f, -3.68131638e-01f, -2.71827400e-01f, 2.41950497e-01f, -2.44979247e-01f, -7.91385863e-03f, 4.05030809e-02f, -1.51023999e-01f,
  -1.13196127e-01f, -1.21038951e-01f, 3.47591460e-01f, -8.37838203e-02f, 1.28615648e-02f, 9.36396495e-02f, -1.89809948e-01f, 2.70848334e-01f, 1.04751647e-01f, -5.45168698e-01f,
  -1.30623817e-01f, 8.36163014e-02f, 3.19928318e-01f, 1.48236509e-02f, -3.96727443e-01f, 1.41079083e-01f, -7.94098750e-02f, 1.25795111e-01f, -3.20877731e-01f, 2.72037655e-01f,
  7.08788693e-01f, 2.68856943e-01f, 8.21559876e-02f, -3.56078029e-01f, -2.53596008e-01f, 2.68826306e-01f, 4.43748325e-01f, 1.57008231e-01f, -2.11503282e-01f, -1.61725029e-01f,
  -2.51073748e-01f, 1.46182179e-01f, -3.32517296e-01f, -2.89444268e-01f, 6.36328682e-02f, -1.70762464e-01f, 5.07501006e-01f, 8.47760290e-02f, -1.67809784e-01f, 8.43308449e-01f,
  -1.43302411e-01f, 4.30116266e-01f, -1.62833542e-01f, -4.72907759e-02f, -2.62848377e-01f, -2.67793238e-01f, 1.70797557e-01f, -9.16194394e-02f, -3.17755312e-01f, 1.60036653e-01f,
  2.29290873e-01f, 3.50071967e-01f, -3.31953347e-01f, 3.73453200e-01f, 5.35961509e-01f, 2.39278495e-01f, 4.15285677e-01f, -2.90126622e-01f, -1.91342622e-01f, -8.19960237e-02f,
  -3.36472481e-01f, -2.88562149e-01f, 5.30658662e-02f, -1.76779106e-01f, -1.38284609e-01f, -2.17508093e-01f, -8.56290236e-02f, 1.70476347e-01f, 1.95230916e-01f, 5.80421686e-02f,
  2.29331538e-01f, 4.78225291e-01f, 2.00859010e-01f, 6.38400137e-01f, -3.71907473e-01f, 3.20287645e-01f, -1.72891647e-01f, -1.34963125e-01f, -3.45530778e-01f, -2.23311201e-01f,
  1.44135639e-01f, 4.05435920e-01f, -5.92150986e-02f, -1.42597139e-01f, 3.54761392e-01f, -1.62796184e-01f, -1.93027537e-02f, -7.08875358e-02f, -2.61051029e-01f, 7.61431828e-02f,
  -3.47226530e-01f, -3.99160028e-01f, -1.92458317e-01f, 2.71288633e-01f, -1.16826259e-02f, 3.01235437e-01f, 2.49571100e-01f, 2.54423916e-01f, -2.34735921e-01f, 1.49125800e-01f,
  -2.85859644e-01f, 2.53959686e-01f, -3.10077339e-01f, 5.88557087e-02f, 1.01538412e-01f, 2.58874923e-01f, 1.40918896e-01f, 7.43693933e-02f, -1.24464348e-01f, -3.09345692e-01f,
  1.13985844e-01f, -1.59703568e-01f, -9.87959728e-02f, -2.55661458e-01f, 1.40749868e-02f, -1.04356073e-01f, -4.08904143e-02f, 2.29509585e-02f, -6.38499716e-03f, 5.28432019e-02f,
  2.22788244e-01f, -1.43929556e-01f, -1.71680629e-01f, 7.58389175e-01f, -2.97559619e-01f, 5.20234525e-01f, 3.89814049e-01f, 7.78954476e-02f, -2.00008482e-01f, -2.00526208e-01f,
  -9.06829908e-02f, -3.45660061e-01f, 3.25953169e-03f, 8.63580704e-02f, 2.75341928e-01f, -9.71750244e-02f, 9.74554010e-03f, -5.98102324e-02f, -3.88899595e-02f, 9.75459348e-03f,
  -1.08781360e-01f, -2.85565168e-01f, 1.96455598e-01f, 5.60312457e-02f, 2.64575571e-01f, -3.12118143e-01f, 3.69945735e-01f, -8.00041556e-02f, 5.85038140e-02f, 4.60074581e-02f,
  -1.26360059e-01f, 3.88961703e-01f, -9.24887788e-03f, -2.42650539e-01f, 5.76263666e-01f, -3.58076334e-01f, 2.18806878e-01f, 5.52241027e-01f, -5.84581494e-02f, -2.25631848e-01f,
  -1.59379929e-01f, 8.70151967e-02f, -3.39548796e-01f, -3.90610136e-02f, -1.79931819e-01f, -3.26966286e-01f, -1.02009103e-01f, -5.27182259e-02f, 4.15067226e-01f, -5.30268764e-03f,
  -1.18692987e-01f, 1.63241699e-01f, -4.60101277e-01f, -4.29814726e-01f, -1.71953604e-01f, 6.21395148e-02f, 5.19654930e-01f, -3.10137659e-01f, -3.75266880e-01f, -2.16676116e-01f,
  -9.97682363e-02f, -1.44888878e-01f, -2.39493057e-01f, 1.13947928e-01f, -4.05968904e-01f, 4.03186321e-01f, 4.92709100e-01f, 2.88344771e-01f, 3.56467105e-02f, 3.49556148e-01f,
  8.60507861e-02f, -1.78559721e-01f, 1.24187596e-01f, 6.04299009e-01f, 1.88632980e-01f, -8.55634883e-02f, -1.47247389e-01f, -4.86620441e-02f, 3.19903670e-03f, -5.35727024e-01f,
  -2.78353870e-01f, 7.00019896e-02f, 1.44430995e-01f, -4.07434821e-01f, 2.66489774e-01f, -2.89421201e-01f, 1.41153827e-01f, 4.95088995e-01f, -2.59875674e-02f, 4.29658085e-01f,
  -3.73270153e-03f, 7.41359740e-02f, -5.92093945e-01f, -1.56141028e-01f, 2.64513105e-01f, -2.79192716e-01f, 3.05947587e-02f, -2.40140498e-01f, -6.84585497e-02f, 5.70410229e-02f,
  4.55554932e-01f, -6.70673028e-02f, -1.19632907e-01f, -2.12664828e-01f, 2.98677385e-01f, 3.90209556e-01f, 4.72950608e-01f, -2.17544526e-01f, -1.86908349e-01f, 6.00110143e-02f,
  -2.13277666e-03f, -1.49668887e-01f, 1.92361251e-01f, -2.61689663e-01f, -2.55862981e-01f, -2.36716010e-02f, 4.62758297e-04f, 3.10996979e-01f, 2.98545212e-01f, 7.34033820e-04f,
  2.46418342e-01f, -2.70362757e-02f, -1.45544082e-01f, -2.65898913e-01f, -3.60915400e-02f, 9.53482464e-02f, -1.29378900e-01f, -1.11251041e-01f, 1.57163963e-02f, 8.95015821e-02f,
  -1.77740440e-01f, 4.42195565e-01f, 6.15500093e-01f, -3.88559587e-02f, -8.48216265e-02f, -6.69697598e-02f, 3.22625905e-01f, -2.73767412e-01f, 4.54395026e-01f, 1.00016132e-01f,
  2.27382421e-01f, 2.80553669e-01f, 1.41788423e-01f, 4.28317338e-01f, 2.54117638e-01f, 4.63306382e-02f, -2.12086901e-01f, -3.69242695e-03f, 2.33623073e-01f, 4.65720147e-01f,
  1.77774757e-01f, 2.63369113e-01f, -2.10725501e-01f, 3.80687905e-03f, -1.41958609e-01f, 1.13216355e-01f, -3.27697545e-01f, 1.63072050e-01f, 2.89023042e-01f, 2.33539462e-01f,
  3.88726592e-01f, 3.83926690e-01f, -8.24740902e-02f, 9.19108689e-01f, 3.46967489e-01f, -1.54270768e-01f, 2.14533404e-01f, -9.16596949e-02f, -2.27697864e-01f, -9.36823711e-02f,
  1.54327437e-01f, 7.28674680e-02f, -1.38281524e-01f, 3.12452674e-01f, 1.68749124e-01f, -1.55743077e-01f, -1.21769179e-02f, -4.49804068e-01f, -8.40016603e-02f, -1.87678263e-01f,
  -3.57958749e-02f, -3.13232273e-01f, -1.27655447e-01f, -1.80450365e-01f, -1.82560027e-01f, 4.88427997e-01f, -2.82076932e-02f, -1.76834747e-01f, -2.23053738e-01f, 1.16743155e-01f,
  3.35372508e-01f, -1.32729992e-01f, 6.57291591e-01f, 9.31690931e-02f, 1.68218940e-01f, -4.38433677e-01f, 2.44912684e-01f, -2.29874521e-01f, -1.63720518e-01f, -1.32353172e-01f,
  -1.81627929e-01f, 2.61737794e-01f, 1.89558104e-01f, -1.08266175e-02f, 2.77992617e-03f, -1.90488786e-01f, 8.59561712e-02f, 2.88084984e-01f, 2.69892931e-01f, -9.50480700e-02f,
  -7.26333410e-02f, 3.62778217e-01f, -1.66535705e-01f, 2.54008085e-01f, -2.69970775e-01f, -5.49733698e-01f, -2.45588437e-01f, -2.26814657e-01f, -1.49462342e-01f, 7.18622446e-01f,
  -2.04485744e-01f, -1.69141769e-01f, 1.07978374e-01f, -2.80239433e-01f, -1.79488942e-01f, -1.76355541e-01f, -2.48174854e-02f, 2.04739556e-01f, -3.20733815e-01f, -2.35645577e-01f,
  8.98189843e-02f, 7.32720137e-01f, 5.19470036e-01f, -4.54608090e-02f, -2.42457643e-01f, -1.01014189e-01f, -1.02442816e-01f, -3.00796270e-01f, -4.62088346e-01f, -3.31842929e-01f,
  8.27677771e-02f, -2.08524421e-01f, 1.28564596e-01f, -1.53504848e-01f, 1.29988834e-01f, 7.54300058e-01f, 5.73642179e-02f, -1.36579365e-01f, -2.27292299e-01f, 5.04098684e-02f,
  3.24646547e-03f, 4.70778113e-03f, -1.76964313e-01f, 8.15098956e-02f, -1.47059068e-01f, -7.68001303e-02f, -2.96318531e-01f, 2.65656132e-02f, -1.76611960e-01f, 6.49157763e-02f,
  -2.27721781e-01f, -3.90002620e-03f, -3.56328219e-01f, 3.62485230e-01f, -2.08941370e-01f, -2.11418092e-01f, -2.32745484e-01f, 2.08426174e-02f, -4.49191391e-01f, -6.22581132e-02f,
  -2.99114287e-01f, -1.03852727e-01f, -2.74504185e-01f, -2.31317461e-01f, 3.89223486e-01f, 1.89817250e-01f, -2.80104548e-01f, 1.80594742e-01f, 4.74203564e-02f, -2.28272632e-01f,
  7.64178410e-02f, -1.71063453e-01f, 5.75819850e-01f, -1.46133304e-01f, -1.52321815e-01f, 1.05828844e-01f, -9.45903827e-03f, 5.22850931e-01f, 1.41324714e-01f, 8.92553851e-02f,
  -1.67185813e-01f, -1.15818508e-01f, -7.21405819e-02f, -3.33082825e-02f, -1.62917804e-02f, -3.47923845e-01f, -5.67755699e-02f, -8.53396431e-02f, -1.01275973e-01f, 3.99692841e-02f,
  -1.49241880e-01f, 9.48339105e-02f, 4.92912203e-01f, -2.80972898e-01f, -5.28153777e-02f, 3.88863422e-02f, 3.18239987e-01f, 2.93104500e-02f, 2.09651843e-01f, -3.77380848e-01f,
  -1.73173413e-01f, 4.69777316e-01f, 1.95459500e-02f, -4.04311940e-02f, -1.63378995e-02f, -1.95963770e-01f, -5.86762466e-03f, 3.91623557e-01f, -9.27632898e-02f, -8.91318545e-02f,
  -9.25678536e-02f, 4.09370095e-01f, 1.12540077e-03f, -1.94773287e-01f, -1.25007376e-01f, 8.20203200e-02f, 4.08951253e-01f, -1.12411790e-01f, -1.14363588e-01f, 1.24019682e-01f,
  -1.54108629e-01f, 4.03217115e-02f, -8.59489515e-02f, 2.04361916e-01f, 2.42271200e-01f, -4.15786892e-01f, -7.64595494e-02f, 2.15881869e-01f, -5.13626337e-01f, -1.59713462e-01f,
  3.81588489e-01f, 6.18389606e-01f, -3.63762230e-01f, 1.70949429e-01f, -1.06998421e-01f, -7.32638314e-02f, -1.06462650e-01f, -1.38772488e-01f, -1.76570967e-01f, -1.20608605e-01f,
  1.85363404e-02f, 1.74807105e-02f, 6.42666519e-02f, 2.92339921e-01f, -2.93488234e-01f, -3.67609352e-01f, -3.31591785e-01f, 1.24337785e-02f, 5.69988966e-01f, -1.78841457e-01f,
  -2.04762056e-01f, -2.42757440e-01f, -2.01750696e-01f, -1.68032810e-01f, 6.85967505e-02f, -1.83014005e-01f, 5.07098198e-01f, 3.98720264e-01f, -1.61487684e-01f, -1.25850379e-01f,
  -2.11541578e-01f, 2.53087252e-01f, -1.14516178e-02f, 5.50013334e-02f, 1.92989781e-01f, 2.37231031e-01f, 2.15827689e-01f, -6.83560036e-03f, 2.57912934e-01f, 3.62004638e-01f,
  5.08719623e-01f, -1.37916982e-01f, -2.94624120e-01f, 6.76979363e-01f, 3.81252319e-02f, -6.97424542e-03f, 1.48525217e-03f, -2.49122351e-01f, -3.07558805e-01f, -1.22281238e-01f,
  -2.31473558e-02f, -1.66772023e-01f, -9.58389416e-03f, -3.55315395e-02f, -2.06661910e-01f, -4.90782075e-02f, 2.38237649e-01f, 1.43381432e-01f, -3.55641022e-02f, -1.79647863e-01f,
  -2.47342035e-01f, 7.16802701e-02f, 2.16973156e-01f, 6.16537482e-02f, -2.85320312e-01f, -5.83635747e-01f, 5.66476882e-01f, -4.29242879e-01f, 1.90214068e-01f, 1.85911611e-01f,
  6.14187643e-02f, -3.84067893e-01f, -3.65826637e-01f, 2.23732721e-02f, 2.29701935e-03f, -2.78773695e-01f, 6.80358056e-03f, -1.58649281e-01f, -2.50628591e-01f, 9.42609757e-02f,
  -1.02156304e-01f, -1.18733041e-01f, -2.17161015e-01f, -1.85917348e-01f, 2.10328531e-02f, 4.87850159e-02f, 1.07948393e-01f, -1.60907537e-01f, 8.65523219e-02f, 2.82913983e-01f,
  -3.65808100e-01f, 2.77494024e-02f, -8.93178433e-02f, -1.02066569e-01f, 8.01017821e-01f, -4.17203084e-02f, 9.14871514e-01f, 3.76812398e-01f, 1.46155462e-01f, 6.72517195e-02f,
  -9.87159163e-02f, 1.95448473e-01f, -1.52124435e-01f, 3.12580876e-02f, -4.82985899e-02f, -1.31398082e-01f, -1.81932095e-02f, -1.24965027e-01f, 7.23224552e-03f, -1.35723203e-02f,
  -2.13503078e-01f, -1.10720448e-01f, 2.88193703e-01f, -7.74569213e-02f, 1.07533269e-01f, 1.67567745e-01f, 2.63147712e-01f, -1.45839348e-01f, -8.46592262e-02f, -4.15429384e-01f,
  1.47751525e-01f, -1.86780572e-01f, 4.10439000e-02f, 3.41754138e-01f, 9.62255299e-02f, -1.91060882e-02f, 1.48461759e-01f, -5.24779320e-01f, -8.28414410e-02f, 1.32810071e-01f,
  -3.10294658e-01f, 2.38659486e-01f, -1.66159660e-01f, 1.01567701e-01f, -1.44372627e-01f, -2.26637334e-01f, -1.02025725e-01f, 3.57572079e-01f, -2.52484113e-01f, -1.22283079e-01f,
  -3.06876954e-02f, -1.35342851e-01f, -2.85698444e-01f, -2.23955378e-01f, 3.45386326e-01f, -2.64814824e-01f, -1.99277431e-01f, -7.90403038e-02f, -1.66894704e-01f, -2.69611597e-01f,
  4.06054519e-02f, 3.14641982e-01f, -9.85479951e-02f, -1.91653907e-01f, -2.18847528e-01f, -1.51422217e-01f, 1.98734358e-01f, 2.69444920e-02f, -1.96928695e-01f, 2.10591421e-01f,
  -1.62175909e-01f, -2.85732955e-01f, -1.62432849e-01f, -7.74464756e-02f, 6.05775118e-01f, -2.61293143e-01f, 4.75338459e-01f, 2.56333143e-01f, 4.27506059e-01f, -2.20172614e-01f,
  -4.17030342e-02f, -2.56789535e-01f, -2.66780257e-01f, -1.19041979e-01f, 5.82467675e-01f, -2.60107875e-01f, 4.17844146e-01f, -1.18639566e-01f, -1.00160487e-01f, -8.44712704e-02f,
  2.48927370e-01f, -1.02201700e-01f, -4.93065491e-02f, -1.27538472e-01f, 2.80713048e-02f, 1.61276624e-01f, 1.25669599e-01f, 2.25805882e-02f, -2.87385546e-02f, 1.26087526e-02f,
  9.22591537e-02f, -5.69911161e-03f, -3.20704393e-02f, -1.41492680e-01f, 3.19358706e-01f, -1.55034602e-01f, -6.06605131e-03f, -3.10844891e-02f, -3.45916569e-01f, 9.65946391e-02f,
  -3.22672874e-02f, -6.93861619e-02f, -4.91731688e-02f, 1.49370387e-01f, 1.23391636e-01f, -2.72425592e-01f, -7.80767575e-02f, -2.02261865e-01f, -2.38659382e-01f, 7.99230114e-02f,
  -8.59406963e-02f, -6.29280582e-02f, 1.99603200e-01f, 1.43950999e-01f, -1.68921784e-01f, -4.93971854e-02f, 4.88651097e-01f, -6.61976216e-03f, 4.86844510e-01f, 2.33146757e-01f,
  3.01226497e-01f, -1.65583283e-01f, -4.94488269e-01f, -1.43768489e-01f, -3.85536194e-01f, 6.87087357e-01f, -1.66725591e-01f, 3.40861529e-02f, -5.80424033e-02f, -2.21351292e-02f,
  -2.02992365e-01f, -2.62972098e-02f, -1.54174194e-01f, -5.28202355e-01f, 1.76050942e-02f, -3.28330472e-02f, -2.11754456e-01f, 1.80517450e-01f, 3.90734896e-02f, -8.79293159e-02f,
  -1.63948178e-01f, -8.84997398e-02f, 5.45903929e-02f, -5.36867678e-02f, 1.47044390e-01f, 4.14480448e-01f, -1.29552530e-02f, 1.00979185e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.03589469e-01f, -2.53249314e-02f, 5.95805496e-02f, -1.37454122e-01f, 1.03187875e-03f, 2.48307526e-01f, -2.70875804e-02f, -1.79772854e-01f, 1.13868952e-01f, 1.49161711e-01f,
  1.28479883e-01f, 7.53580406e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    