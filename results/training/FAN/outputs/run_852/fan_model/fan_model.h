/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.04320264e-01f, 1.24240946e-02f, -1.10035799e-01f, -9.32505541e-03f, 1.25427753e-01f, 5.22353686e-04f, -8.15327913e-02f, 9.45265293e-02f, 1.09466232e-01f, 3.56415920e-02f,
  2.46607572e-01f, 2.14988172e-01f, 9.13952291e-02f, 1.39074787e-01f, -1.10821098e-01f, -4.23528738e-02f, -1.69724196e-01f, -1.69470206e-01f, -5.95919676e-02f, 1.99803442e-01f,
  1.32508576e-01f, -7.45723471e-02f, -9.89575088e-02f, 6.95375800e-02f, 1.16783157e-01f, 1.74502611e-01f, 6.67714998e-02f, -6.15321547e-02f, 1.13193899e-01f, -7.78498277e-02f,
  -5.33609511e-03f, -4.02930565e-02f, -1.26928231e-03f, -3.07777571e-03f, -3.39838900e-02f, -8.73421356e-02f, 2.20098277e-03f, -5.91759533e-02f, -2.49453280e-02f, 3.72841768e-03f,
  4.96805608e-02f, -8.23771656e-02f, -4.57602106e-02f, 1.01300418e-01f, 1.31031694e-02f, -3.65795828e-02f, -1.17549462e-04f, -3.52553464e-02f, -9.20021161e-02f, 5.61184324e-02f,
  1.31046429e-01f, 6.53419644e-02f, -1.35349892e-02f, 3.11166327e-03f, -5.63136078e-02f, 3.40128713e-03f, 5.99198304e-02f, 1.06731035e-01f, -2.50960477e-02f, 3.92532647e-02f,
  4.57806028e-02f, 1.75908282e-02f, -2.11069509e-02f, -3.55733633e-02f, 1.13560982e-01f, 3.25866300e-03f, -5.77585399e-02f, 5.82437925e-02f, 3.60414758e-03f, -8.50018263e-02f,
  4.88757715e-02f, 1.76225007e-02f, 1.34145049e-02f, 2.84396168e-02f, 3.90899703e-02f, -3.72861475e-02f, 2.44800802e-02f, -5.75055182e-03f, 4.08490747e-03f, -1.29690185e-01f,
  3.24582420e-02f, -2.16058120e-02f, -2.35587079e-02f, -1.25815747e-02f, -2.54037157e-02f, 6.53347420e-03f, 1.18145840e-02f, 4.43125926e-02f, 8.07160884e-02f, -3.41542400e-02f,
  3.30203213e-02f, -8.48060474e-02f, -9.14224014e-02f, 4.33778316e-02f, -6.73231632e-02f, -7.65185524e-03f, 3.09843626e-02f, 1.23984506e-02f, -2.55851969e-02f, -3.09682433e-02f,
  4.17956449e-02f, 3.52998599e-02f, -5.65648787e-02f, 3.76934446e-02f, 8.34466238e-03f, -1.92207424e-03f, 9.42000654e-03f, 8.39931704e-03f, -5.88967651e-03f, -2.05648295e-03f,
  3.85704227e-02f, -3.99006978e-02f, -5.94717264e-02f, -3.29946801e-02f, 1.10688247e-03f, -7.03088045e-02f, 3.59513536e-02f, -8.89404342e-02f, -3.21397856e-02f, -6.07930198e-02f,
  3.36004972e-01f, -3.86658370e-01f, -2.00584561e-01f, 8.30101222e-02f, -2.72087175e-02f, 6.54847547e-02f, -9.42923650e-02f, 1.37075735e-03f, -3.26138511e-02f, -1.84436426e-01f,
  -1.53240087e-02f, 1.52360231e-01f, 7.60132372e-02f, 7.34633356e-02f, 2.90818196e-02f, -4.93764840e-02f, -1.36010885e-01f, -6.93108002e-03f, 3.77248675e-01f, 1.28709525e-01f,
  1.01711206e-01f, -4.07585166e-02f, -1.69305243e-02f, 1.41552538e-01f, -1.05383813e-01f, 3.23264673e-02f, -1.04443580e-01f, -1.83771431e-01f, 4.29795915e-03f, -3.55691195e-01f,
  1.38513193e-01f, -9.02100876e-02f, 8.72364044e-02f, -1.65494084e-02f, -4.62337621e-02f, 8.57124925e-02f, 7.62234256e-02f, -3.91850658e-02f, -2.70683672e-02f, -2.91217845e-02f,
  4.98340875e-02f, 2.42653396e-02f, 8.91298354e-02f, 3.19222105e-03f, -3.04554328e-02f, 5.51081402e-03f, -2.75890864e-02f, -7.34370649e-02f, -1.29531249e-01f, 3.32833417e-02f,
  -7.99296722e-02f, -1.21909261e-01f, -1.10170059e-01f, -3.03271580e-02f, -2.88770981e-02f, -4.33376692e-02f, -1.65353447e-01f, -2.05755625e-02f, -3.05983629e-02f, -2.15954900e-01f,
  -2.69465372e-02f, -4.48507816e-02f, 2.43317205e-02f, -7.02096820e-02f, 5.75067475e-02f, -6.74632937e-02f, -3.11730709e-03f, -4.63211909e-02f, 7.15011135e-02f, -3.84737141e-02f,
  1.54308490e-02f, -5.73323369e-02f, 2.74779294e-02f, 7.12016225e-03f, 1.95707530e-02f, 1.53409196e-02f, 6.77057030e-03f, -3.99187319e-02f, 2.16893740e-02f, 5.59111424e-02f,
  -2.16405094e-02f, 2.46211234e-02f, -8.20605271e-03f, 8.85080770e-02f, -2.74851527e-02f, 2.00314913e-02f, 3.99930589e-02f, 9.45605990e-03f, 5.51358536e-02f, 4.92654257e-02f,
  1.84922293e-01f, -9.00607631e-02f, 3.46644297e-02f, -1.99080389e-02f, -3.79948281e-02f, 2.32306886e-02f, -4.80914302e-03f, 2.54528802e-02f, -2.15515904e-02f, 4.44641395e-04f,
  4.05633673e-02f, 6.67234883e-02f, -9.63175148e-02f, -1.41409039e-02f, 4.45274599e-02f, 8.93673301e-02f, 3.98103669e-02f, 5.18534333e-02f, -1.34806745e-02f, 2.00594552e-02f,
  1.84100028e-02f, 3.02998740e-02f, 5.05430549e-02f, -3.71806361e-02f, 3.54228131e-02f, 1.25295520e-01f, 3.68759520e-02f, 9.03375074e-02f, 4.72902432e-02f, 1.09780982e-01f,
  1.38663709e-01f, -1.64283793e-02f, -1.95722550e-01f, 1.25565007e-01f, 1.82030708e-01f, -9.01653394e-02f, -2.27127552e-01f, -1.46313310e-01f, 1.67214587e-01f, -5.82722463e-02f,
  6.28867447e-02f, 1.31639645e-01f, -2.32462175e-02f, 1.02774382e-01f, -2.46412218e-01f, -7.47992694e-02f, 1.32492021e-01f, 1.33163139e-01f, -1.63275659e-01f, -1.83548123e-01f,
  4.08553779e-02f, -1.81955099e-02f, -1.06853865e-01f, -4.95841466e-02f, 3.42312828e-02f, 5.09870658e-03f, 2.96262130e-02f, 3.98446396e-02f, 9.57299545e-02f, 2.29934067e-01f,
  -3.24128792e-02f, 1.99577168e-01f, -1.01558059e-01f, 7.93078840e-02f, 7.63159916e-02f, 3.95641439e-02f, -5.81683181e-02f, 1.20987311e-01f, 1.50868595e-02f, 4.05575186e-02f,
  8.31698775e-02f, -1.69149917e-02f, 1.24430768e-01f, -2.33869944e-02f, 2.58884719e-03f, 5.66700883e-02f, 7.52048194e-02f, 2.76690591e-02f, 2.82673482e-02f, 5.60929216e-02f,
  1.46770149e-01f, 1.27149582e-01f, -3.33018415e-02f, 4.71314229e-02f, -5.32711558e-02f, 1.57319486e-01f, -6.09513074e-02f, 7.82492459e-02f, -3.22067887e-02f, -1.82601940e-02f,
  -7.25597218e-02f, 2.01644916e-02f, 5.29703461e-02f, -3.32598351e-02f, -2.05003675e-02f, -9.55058169e-03f, 2.20211390e-02f, -6.95773587e-02f, 4.58370149e-03f, -1.91107187e-02f,
  6.00301288e-03f, -6.52625412e-02f, -1.35506149e-02f, 2.21688077e-02f, 2.46310513e-02f, -2.54949816e-02f, -1.85397472e-02f, -7.21086413e-02f, 2.46828850e-02f, 3.03669311e-02f,
  -3.30627076e-02f, 6.27530320e-03f, 1.22737894e-02f, -6.36773631e-02f, 4.87233400e-02f, -5.23592753e-04f, 4.57928665e-02f, 3.05722784e-02f, 1.83440801e-02f, 4.61358428e-02f,
  -2.33106375e-01f, 8.01638886e-02f, -5.53628914e-02f, -8.09909776e-03f, 1.77340247e-02f, 1.30159380e-02f, 7.08463341e-02f, -2.89720446e-02f, 7.11348206e-02f, -4.05727774e-02f,
  9.94527340e-03f, 5.56671172e-02f, 1.72281992e-02f, -3.42677124e-02f, -7.34629780e-02f, -5.50666973e-02f, 7.05895200e-02f, -8.64839703e-02f, -3.64180729e-02f, 1.40450650e-03f,
  -5.00430018e-02f, -2.21262738e-01f, -1.54624209e-01f, -1.64674714e-01f, 1.90718994e-02f, -1.21435918e-01f, -1.98436484e-01f, -1.32388249e-01f, -1.45640120e-01f, -4.45149094e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.72047196e-02f, -9.56235230e-02f, 6.33923039e-02f, -8.74412246e-03f, -2.66208891e-02f, 6.32010400e-02f, 4.17885520e-02f, 2.54905056e-02f, -4.87989979e-03f, 6.42750859e-02f,
  -2.15324089e-02f, 5.42835109e-02f, 8.68608057e-02f, -4.50422354e-02f, -4.03242633e-02f, 6.17902689e-02f, 5.91153279e-02f, -1.08363725e-01f, 3.67889069e-02f, 1.48731861e-02f,
  -6.48194253e-02f, 1.10723823e-03f, -1.18540535e-02f, -4.52654250e-02f, 7.91945402e-03f, 8.53770152e-02f, -4.09033801e-03f, 4.56261523e-02f, 8.48447084e-02f, -7.07124248e-02f,
  -8.65019783e-02f, -2.74154898e-02f, 3.46796475e-02f, -2.17667017e-02f, 1.19556598e-02f, 1.06795551e-02f, 3.75714190e-02f, -1.01776183e-01f, 5.43532521e-02f, 5.02524190e-02f,
  -7.70405009e-02f, -4.65791449e-02f, 9.41505134e-02f, -8.73243809e-02f, -1.90903991e-02f, -8.74759927e-02f, 7.81922042e-02f, -2.36351658e-02f, -2.09969059e-02f, 5.05306162e-02f,
  4.80854511e-02f, 4.92892088e-03f, 4.02307604e-03f, -2.29581743e-02f, 6.15949221e-02f, 2.03093588e-02f, -4.38384227e-02f, 9.25504938e-02f, 9.93568450e-02f, 4.49695252e-02f,
  8.36318359e-02f, 5.38822562e-02f, -1.83407199e-02f, 6.14588596e-02f, -2.99175885e-02f, -1.92238539e-02f, -3.94902378e-02f, -7.85854608e-02f, -4.39129546e-02f, 6.20212667e-02f,
  1.53580774e-02f, 5.43284882e-03f, -3.65804508e-02f, 6.20543957e-02f, 9.31553543e-02f, 1.38214871e-01f, 6.52231500e-02f, -5.82131147e-02f, -4.31900918e-02f, 7.23314583e-02f,
  3.71213034e-02f, 9.14759338e-02f, 9.60235000e-02f, 2.39596553e-02f, 1.41416751e-02f, -1.12357438e-02f, -3.74987200e-02f, 6.43924326e-02f, 1.16305590e-01f, 8.13968480e-02f,
  -8.26160833e-02f, -3.41577083e-02f, -6.20178357e-02f, 1.35574164e-02f, -5.20536378e-02f, -1.83242410e-02f, 3.97430211e-02f, 3.11584282e-03f, -7.55972788e-02f, -2.45620832e-02f,
  -5.40510677e-02f, -1.00944534e-01f, -3.97674702e-02f, 6.04020543e-02f, -3.73754352e-02f, -2.53787804e-02f, 8.28740895e-02f, 1.50214704e-02f, 8.19869265e-02f, 6.53983206e-02f,
  4.11964506e-02f, 3.33780050e-02f, -7.01935887e-02f, 1.08222269e-01f, 1.10989194e-02f, -7.34248059e-03f, 7.77919963e-02f, -3.93864699e-02f, -6.63665831e-02f, -5.23960181e-02f,
  2.49023274e-01f, 4.23159003e-01f, 8.50187242e-02f, 3.10522586e-01f, 1.81475818e-01f, -3.54072005e-02f, 2.00225025e-01f, -9.07120332e-02f, -8.10751766e-02f, 3.82428057e-02f,
  1.75033957e-01f, -1.91228446e-02f, -6.14865758e-02f, -7.19115064e-02f, -7.93382972e-02f, 6.88245222e-02f, 1.29484534e-01f, -1.15504116e-01f, -1.38995722e-01f, 7.28959218e-02f,
  2.32019633e-01f, 1.82939366e-01f, -1.99663546e-02f, 1.92869008e-02f, 3.48450154e-01f, -7.15026632e-02f, -4.63006347e-02f, 9.25932974e-02f, 1.54969484e-01f, 3.62862438e-01f,
  1.23085804e-01f, 2.71059334e-01f, -8.18929374e-02f, 1.45458030e-02f, 5.26712136e-03f, -7.99729228e-02f, -4.86012362e-02f, -1.19827509e-01f, -8.59087929e-02f, -2.25159451e-02f,
  1.16777472e-01f, -1.31981121e-02f, 1.56757191e-01f, 5.86609244e-02f, 1.78108774e-02f, -8.21350217e-02f, -1.10274479e-01f, -3.35978754e-02f, -7.61380047e-02f, 4.71687354e-02f,
  2.31716603e-01f, 1.39642730e-01f, 3.22288536e-02f, -6.50920942e-02f, 1.00392386e-01f, 8.67561996e-02f, 1.37521043e-01f, 4.68779057e-02f, -8.43584239e-02f, 2.78118011e-02f,
  -5.38925938e-02f, 6.72604740e-02f, -1.12821003e-02f, 1.86636429e-02f, 7.12389350e-02f, 8.89649091e-04f, 6.48793653e-02f, 2.87378132e-02f, 3.24435197e-02f, 5.43665551e-02f,
  -7.32704401e-02f, 4.62856628e-02f, -8.00841376e-02f, -3.89668606e-02f, -3.25250551e-02f, 4.21514958e-02f, 4.91911136e-02f, 3.56832854e-02f, -5.37303090e-02f, -6.16690554e-02f,
  4.95216623e-02f, -8.63751397e-02f, -2.60333851e-04f, -1.00973159e-01f, 8.05174410e-02f, 9.42132808e-03f, 7.15717673e-02f, 1.77896470e-02f, -4.55312710e-03f, 2.72653978e-02f,
  -1.86445296e-01f, -1.69603527e-01f, 2.44259331e-02f, -9.26271372e-04f, 2.24729516e-02f, -3.66555974e-02f, 6.69729486e-02f, -4.42164540e-02f, -2.56644264e-02f, -1.08286172e-01f,
  1.22350566e-01f, 6.89620478e-03f, -1.47969797e-02f, -6.39287308e-02f, -4.26101945e-02f, -3.18749025e-02f, -3.23244371e-02f, 3.68399575e-04f, -2.00158387e-01f, -2.13528946e-02f,
  4.15586010e-02f, -1.36678904e-01f, -1.14270702e-01f, -1.51828691e-01f, -4.61830758e-03f, -1.59643814e-01f, -9.82320830e-02f, -7.90819973e-02f, -2.19881058e-01f, -2.67064124e-01f,
  2.47528806e-01f, -1.62828684e-01f, -2.04280719e-01f, -6.00496531e-02f, -1.28216892e-01f, -1.75270811e-01f, -2.47493848e-01f, 7.84680073e-04f, 6.51096478e-02f, -1.25440210e-01f,
  1.95450392e-02f, 1.47693753e-01f, -3.69868018e-02f, -4.21624407e-02f, 4.64738719e-02f, -2.79315740e-01f, -2.29514197e-01f, -4.86692227e-02f, 1.69640169e-01f, 8.20004568e-02f,
  5.95588237e-02f, -3.15689966e-02f, 1.17386431e-01f, 1.25694618e-01f, -1.83701441e-01f, -1.15729161e-02f, -1.30325750e-01f, -9.72720310e-02f, -1.35411680e-01f, -3.02525789e-01f,
  -1.31497592e-01f, 1.11408815e-01f, 1.02363013e-01f, -3.17174173e-03f, 5.49504301e-03f, 4.83760983e-02f, 3.34681086e-02f, -9.15294588e-02f, 1.00362867e-01f, 2.80949268e-02f,
  5.99434040e-02f, 4.98970859e-02f, 1.00550294e-01f, 2.28936337e-02f, -1.07106697e-02f, -7.17079565e-02f, 2.87795756e-02f, 4.05567139e-02f, 4.29285802e-02f, -4.23341170e-02f,
  -4.96912003e-02f, 1.40044555e-01f, -1.63523816e-02f, -3.03550232e-02f, 6.46725222e-02f, 5.48747508e-03f, -2.74344236e-02f, -4.53927852e-02f, -6.40576333e-02f, 5.70183061e-02f,
  -3.14178988e-02f, -1.27230389e-02f, 2.78915595e-02f, 1.83227379e-02f, 5.45122549e-02f, 3.00547719e-04f, -4.10518795e-02f, 7.72637203e-02f, 3.30654494e-02f, 2.64578238e-02f,
  1.03640202e-02f, -1.43564567e-01f, -1.71260498e-02f, -6.43192697e-03f, -5.40873297e-02f, -2.98067573e-02f, 1.92753822e-02f, -2.60242019e-02f, 5.37515618e-02f, -5.56361862e-02f,
  -2.31605079e-02f, -1.39485057e-02f, 4.39308248e-02f, -1.28624421e-02f, -3.83842997e-02f, -8.05930793e-03f, 1.77632757e-02f, 6.31114561e-03f, -5.38613871e-02f, 1.82247534e-02f,
  7.33763948e-02f, 3.74369286e-02f, -2.06809510e-02f, 1.06221832e-01f, 7.67511502e-02f, -3.88991907e-02f, -5.46109341e-02f, 8.73373598e-02f, -3.08598150e-02f, 7.98479887e-04f,
  -1.79475767e-03f, 6.32933080e-02f, 2.89510526e-02f, -6.89314902e-02f, 1.05435755e-02f, -5.58336936e-02f, -1.96363330e-02f, 9.79473591e-02f, 9.10828635e-02f, -7.98470452e-02f,
  -2.03506481e-02f, -2.71953214e-02f, 1.13176368e-01f, 2.53452230e-02f, 2.40479968e-02f, 4.49502133e-02f, 2.70722751e-02f, -5.39962910e-02f, 6.84328601e-02f, -2.47712340e-02f,
  1.76280513e-01f, -1.98032528e-01f, -3.07454448e-03f, 9.30795297e-02f, 1.32251859e-01f, 4.74509597e-02f, 1.41655043e-01f, 1.82904564e-02f, 1.44950300e-01f, 9.63919610e-02f,
  5.73561676e-02f, 8.45242143e-02f, 3.80170308e-02f, 6.97887614e-02f, 2.06266735e-02f, 1.13023274e-01f, 3.15047652e-02f, -3.11832484e-02f, 1.27101302e-01f, 3.39552872e-02f,
  8.89544860e-02f, -5.57223596e-02f, -2.27058250e-02f, 8.92413929e-02f, 7.75136501e-02f, 1.88490093e-01f, 9.57698822e-02f, 1.98445152e-02f, -1.03866518e-01f, -7.10721919e-03f,
  1.68589547e-01f, -4.31063734e-02f, 6.12870231e-02f, -2.75635123e-02f, -1.25576437e-01f, 1.60140134e-02f, 6.23781122e-02f, 4.01071993e-05f, -1.50579304e-01f, -5.40303811e-02f,
  -1.24588259e-01f, 6.75370870e-03f, 4.57947887e-02f, -1.05398595e-01f, 4.66684178e-02f, -7.97447190e-03f, -7.67945126e-02f, 4.38716216e-03f, 1.00913502e-01f, 8.65829736e-03f,
  -7.98933953e-02f, -6.92144260e-02f, -1.02976292e-01f, 8.41564983e-02f, 8.92321840e-02f, 1.04922689e-02f, -2.91307941e-02f, 4.11112793e-02f, 3.52182202e-02f, 2.68087797e-02f,
  2.47709714e-02f, -6.46341592e-02f, -3.47414166e-02f, -2.62954403e-02f, 3.94395925e-02f, -6.51415531e-03f, 6.18110411e-02f, 2.79558506e-02f, -3.70352119e-02f, 4.93932739e-02f,
  3.23600024e-02f, 4.58464585e-02f, -7.03096017e-02f, -1.55411642e-02f, -6.86758161e-02f, -8.03494677e-02f, 5.37551977e-02f, 2.94301398e-02f, -8.83277133e-02f, 6.66751191e-02f,
  1.24530280e-02f, 1.35683210e-03f, -7.63656721e-02f, -7.36166090e-02f, -9.58631709e-02f, -6.13379404e-02f, 7.88857564e-02f, -1.55194476e-01f, 1.48415528e-02f, 1.76206809e-02f,
  2.17123866e-01f, -3.84770334e-02f, 5.21341749e-02f, -1.51653970e-02f, -1.26788216e-02f, -7.87580311e-02f, 1.29909255e-02f, -6.73309490e-02f, -2.40077227e-02f, 6.56074844e-03f,
  1.76288839e-02f, -6.16084971e-02f, -1.11650862e-01f, -6.00970723e-03f, -3.04206908e-02f, -3.81846316e-02f, 3.54868770e-02f, 3.00820321e-02f, 6.73506781e-02f, 1.63151119e-02f,
  -2.35034637e-02f, -2.20453609e-02f, 1.39634103e-01f, 8.81911442e-02f, -1.45853329e-02f, 4.71378118e-02f, 2.04048544e-01f, 7.02747181e-02f, 1.80781737e-01f, 1.96912363e-01f,
  -6.99699447e-02f, 7.26040602e-02f, -2.90829353e-02f, -6.89170277e-03f, 1.04945466e-01f, 2.81082913e-02f, 9.33022238e-03f, 1.21494859e-01f, 7.86651112e-03f, 5.36052845e-02f,
  1.01680554e-01f, 1.15687281e-01f, 7.44153094e-03f, 1.39487937e-01f, -2.97047086e-02f, 2.26970296e-02f, 1.05249032e-01f, -1.29036037e-02f, 8.28921236e-03f, 1.36622399e-01f,
  -2.89357323e-02f, 1.20651841e-01f, 4.09276336e-02f, 5.79672679e-02f, 3.27669047e-02f, 5.46034519e-03f, 1.64123774e-02f, -3.41405198e-02f, -1.57696083e-02f, 1.15616113e-01f,
  1.48920789e-01f, 4.87716682e-02f, -9.43100639e-03f, -5.30365482e-02f, 7.94610474e-03f, 1.69769097e-02f, 9.27461460e-02f, -1.94288436e-02f, 3.98551002e-02f, 9.38930139e-02f,
  -7.02206232e-03f, 5.75765446e-02f, -9.20683593e-02f, 1.01474524e-02f, 9.49256197e-02f, 1.46547770e-02f, 2.13179365e-02f, 3.31242234e-02f, 6.85304329e-02f, 2.64786333e-02f,
  7.61854649e-02f, -3.32785537e-03f, -4.59095277e-02f, 5.71793430e-02f, -5.69653548e-02f, -3.16179320e-02f, -1.97447240e-02f, 5.83293363e-02f, 8.61127209e-03f, 1.08439200e-01f,
  8.05718154e-02f, -7.91552514e-02f, 6.88784122e-02f, 2.61901300e-02f, -5.87933548e-02f, 3.72941303e-03f, 5.68080693e-02f, -1.57657284e-02f, 3.86686325e-02f, -9.27057490e-02f,
  -3.03974599e-02f, -5.16776554e-02f, 5.00585549e-02f, -1.29728438e-02f, -2.20905896e-03f, 7.94444978e-03f, 4.60170284e-02f, 6.98068514e-02f, 6.27069101e-02f, -1.52413861e-03f,
  -2.03537792e-02f, 1.09182596e-02f, 1.08383633e-01f, -6.61645830e-02f, 3.65752503e-02f, -2.52360199e-02f, -9.68359858e-02f, -2.78549530e-02f, -9.51988697e-02f, -1.45174563e-01f,
  9.83570591e-02f, -9.86594856e-02f, 8.75504017e-02f, -9.22231062e-04f, 4.43416163e-02f, 4.00834493e-02f, 4.83580306e-02f, -4.05350402e-02f, -2.45399941e-02f, 4.25793603e-02f,
  8.62675905e-03f, -2.02440489e-02f, 6.92612082e-02f, -8.42835754e-02f, -7.52388090e-02f, -4.03961018e-02f, -4.22588037e-03f, 7.03748316e-02f, 5.75122749e-03f, 9.53444559e-03f,
  -6.75030425e-02f, 1.04991227e-01f, 2.46631429e-02f, 7.10940063e-02f, -2.32964680e-02f, 1.88001376e-02f, 2.22742930e-02f, 7.47927651e-02f, -7.73266926e-02f, 2.27036681e-02f,
  -3.32926154e-01f, 2.14770287e-02f, -2.27204278e-01f, -2.43029654e-01f, -7.57765472e-02f, 1.37099490e-01f, 8.97207111e-02f, 6.65313229e-02f, 1.11406343e-03f, -2.04098612e-01f,
  -3.39742489e-02f, -6.65124282e-02f, -1.44707009e-01f, 3.16217951e-02f, -2.04480737e-02f, -1.61284506e-01f, -2.68151373e-01f, -2.16796517e-01f, -1.39694557e-01f, 1.22484259e-01f,
  -1.54123217e-01f, -3.41364145e-01f, -1.52974859e-01f, 3.19760740e-02f, -1.74406752e-01f, -2.04321772e-01f, -2.54061610e-01f, -1.98168978e-01f, 1.11276560e-01f, -2.57577419e-01f,
  -4.19687480e-01f, 1.40268296e-01f, -4.75784875e-02f, -1.97859071e-02f, -7.47695044e-02f, 8.48599374e-02f, 2.75058150e-02f, -1.06832989e-01f, 9.43129137e-02f, -7.48534501e-02f,
  3.11407931e-02f, 1.28049012e-02f, 1.57562401e-02f, -3.24874856e-02f, -1.28648266e-01f, 1.38242524e-02f, -2.29191445e-02f, -4.97555127e-04f, -3.32972826e-03f, 1.23752818e-01f,
  3.34652923e-02f, 8.97009447e-02f, 7.20700398e-02f, 1.25860870e-02f, 1.30549893e-01f, 6.98456988e-02f, 7.99160004e-02f, 1.02495722e-01f, 3.36619765e-02f, -1.39769822e-01f,
  -3.59738967e-03f, -2.23448849e-03f, -7.93598592e-03f, 7.21808076e-02f, -3.46548744e-02f, -4.60784175e-02f, 3.23523693e-02f, -5.17334417e-02f, 2.06954367e-02f, -8.07019100e-02f,
  3.37535031e-02f, 5.29489927e-02f, 6.55879779e-03f, -4.17429693e-02f, 1.42584853e-02f, -1.82973854e-02f, 6.88284039e-02f, -4.43962812e-02f, 3.49831805e-02f, -1.96048748e-02f,
  -6.79448396e-02f, 6.78945333e-02f, -5.40219955e-02f, 6.95646852e-02f, -2.35205069e-02f, -4.16834131e-02f, -4.21792008e-02f, 8.35562795e-02f, 2.21767705e-02f, 9.64411572e-02f,
  -2.40051091e-01f, 8.88606682e-02f, -5.45209385e-02f, -4.29539912e-04f, 1.91923827e-02f, 5.65428473e-02f, -1.07777771e-02f, 6.57999888e-02f, 2.76207365e-02f, 3.09806559e-02f,
  4.14115861e-02f, -4.96791750e-02f, -3.59957442e-02f, 1.01068281e-01f, -4.86314632e-02f, 8.42436478e-02f, 2.95584393e-03f, -1.57594189e-01f, 1.12196565e-01f, 4.84827794e-02f,
  1.15260975e-02f, 8.73540491e-02f, -5.38879335e-02f, 2.25378331e-02f, 3.22737396e-02f, -1.06360048e-01f, -1.16761476e-01f, -6.77378103e-02f, -5.98481623e-03f, -9.92338210e-02f,
  -2.36072958e-01f, 1.93380341e-02f, -3.27438600e-02f, -3.89205180e-02f, 1.28654897e-01f, 4.13105153e-02f, -7.42651522e-02f, -6.99322671e-02f, 1.96253275e-03f, 1.80108529e-02f,
  -1.17037311e-01f, 8.20252821e-02f, -4.36686501e-02f, 2.66399677e-03f, -6.57807887e-02f, 1.64275110e-01f, 6.67673573e-02f, 1.26782417e-01f, -3.26128006e-02f, 3.17057930e-02f,
  9.00520831e-02f, 6.43178225e-02f, 3.23329233e-02f, -8.06339160e-02f, 7.42144417e-03f, 3.65068540e-02f, 1.07533909e-01f, 6.93879649e-02f, 8.13600495e-02f, 1.24661453e-01f,
  -4.90053706e-02f, -9.16456580e-02f, 1.05186738e-01f, 3.96346897e-02f, 1.23536708e-02f, -5.92042394e-02f, -8.39240104e-02f, -9.21223238e-02f, -2.56460570e-02f, 2.79498305e-02f,
  1.01845466e-01f, 2.65185870e-02f, 1.18403370e-02f, -2.21779458e-02f, -1.37763619e-02f, -7.74208158e-02f, -5.49251400e-02f, 2.36827657e-02f, 4.79170913e-03f, -3.47385975e-03f,
  6.99901655e-02f, -5.12966886e-02f, -4.15242799e-02f, 9.20873415e-03f, 2.73032356e-02f, 2.79257447e-02f, 3.55439931e-02f, -1.01438716e-01f, -1.17893601e-02f, -9.50238407e-02f,
  -8.63897055e-03f, 9.28761736e-02f, -2.70691756e-02f, 2.68843379e-02f, -5.77550046e-02f, -7.49585927e-02f, -7.46050403e-02f, 2.66953148e-02f, 3.56921256e-02f, -2.87199859e-02f,
  -2.76465230e-02f, 7.14731440e-02f, -2.65978295e-02f, -7.40285665e-02f, -8.62287637e-03f, -9.09534376e-03f, 5.28331846e-02f, 3.00927721e-02f, 4.76427050e-03f, 3.39463577e-02f,
  -2.74947118e-02f, -7.13335946e-02f, 6.38763830e-02f, 8.58906955e-02f, 8.56882855e-02f, -6.62596524e-02f, -5.42924292e-02f, 7.53270686e-02f, -6.16631955e-02f, -5.65835796e-02f,
  6.50442317e-02f, 8.58507901e-02f, 1.52041269e-02f, 3.24226841e-02f, -2.89589185e-02f, -2.75992882e-03f, 8.75832438e-02f, -6.44261064e-03f, 6.99321106e-02f, -4.74090055e-02f,
  -2.87574362e-02f, -6.81997836e-02f, -6.41821623e-02f, 5.24492301e-02f, -2.60629393e-02f, 2.81609893e-02f, 1.03035830e-01f, -3.60011049e-02f, 2.60345335e-03f, -2.24585347e-02f,
  8.50537121e-02f, -4.11371365e-02f, 8.34637955e-02f, 2.64126022e-04f, -1.48011860e-03f, 7.26844044e-03f, -3.13983448e-02f, 3.59726660e-02f, 2.58749966e-02f, -8.04639130e-04f,
  -3.14030820e-03f, -1.43240809e-01f, -1.20378733e-02f, -1.18574761e-01f, 8.88275430e-02f, 1.50602907e-01f, -1.99782792e-02f, 8.61569420e-02f, 3.42779867e-02f, -1.48079526e-02f,
  1.13727495e-01f, 5.23433201e-02f, -3.73155723e-04f, -8.64815805e-03f, 8.65937695e-02f, -8.90671238e-02f, -1.23059183e-01f, -1.39905989e-01f, -9.56778228e-03f, 3.94655243e-02f,
  5.87253049e-02f, -1.32857248e-01f, -6.78427145e-02f, 3.92455459e-02f, -1.03223640e-04f, 2.26340611e-02f, -4.98907976e-02f, 3.76434848e-02f, 1.11270361e-01f, -5.44071309e-02f,
  2.29835231e-02f, 8.32381845e-02f, 6.82928637e-02f, 4.45023961e-02f, 4.45984229e-02f, 4.61849235e-02f, 1.05875887e-01f, -6.77297860e-02f, -3.14890333e-02f, -5.68348356e-02f,
  -9.95362327e-02f, 9.84799936e-02f, -4.62571122e-02f, 7.03844801e-03f, 3.04476125e-03f, 6.66778758e-02f, -3.36900284e-03f, -1.97979044e-02f, -4.25669597e-04f, -2.43494660e-03f,
  -1.05732322e-01f, -1.27154380e-01f, -1.32534087e-01f, -3.57045382e-02f, 8.39784220e-02f, 1.85789587e-03f, -4.18978855e-02f, 2.15986874e-02f, 1.21732995e-01f, -6.71671107e-02f,
  -7.46539384e-02f, 1.36329690e-02f, -2.14280207e-02f, -4.96152453e-02f, -4.39358465e-02f, -1.78354867e-02f, 4.74769734e-02f, -9.78253186e-02f, 3.97093333e-02f, 9.79144964e-03f,
  2.94675268e-02f, 3.42854373e-02f, 8.20744410e-02f, 3.29444036e-02f, 2.27313768e-03f, -1.95984226e-02f, -6.61661057e-03f, 3.28480825e-02f, -8.87780823e-03f, 6.69343546e-02f,
  -3.32999043e-02f, 5.79350851e-02f, -1.12449981e-01f, -2.41409168e-02f, -6.43998235e-02f, -2.41825525e-02f, -6.99868649e-02f, -4.95675653e-02f, 2.09871400e-03f, -1.01371236e-01f,
  -7.86733106e-02f, 5.15528359e-02f, -9.46104899e-02f, -6.76586926e-02f, 3.44655737e-02f, -1.12677449e-02f, 1.75569747e-02f, -2.78208964e-02f, -8.02192688e-02f, 1.24033447e-03f,
  -6.77484125e-02f, -3.53443138e-02f, 8.08878615e-03f, 1.05671433e-03f, -3.38861011e-02f, -1.16289079e-01f, -1.11354046e-01f, -1.10705629e-01f, -9.32656527e-02f, -5.68652637e-02f,
  -1.09879531e-01f, -9.06350017e-02f, -1.31444663e-01f, -9.13128257e-02f, -1.18837871e-01f, -9.38498005e-02f, 2.56903906e-04f, -9.83024202e-03f, 5.49696572e-02f, -1.53194487e-01f,
  2.90838987e-01f, 4.72951075e-03f, 6.93743750e-02f, -5.39661525e-03f, -9.97996107e-02f, -1.03730582e-01f, -6.92395791e-02f, -4.22665551e-02f, -1.15313649e-01f, -3.54752466e-02f,
  4.34772484e-02f, -1.41709566e-01f, -1.16612315e-01f, -8.79479572e-02f, -4.85132895e-02f, 8.50507990e-02f, 1.31821737e-01f, 1.03278585e-01f, 3.57081252e-03f, 1.30723463e-02f,
  -8.28499049e-02f, 9.91169289e-02f, 8.42634961e-02f, 9.50900167e-02f, -4.35677022e-02f, -6.03121705e-02f, -3.22488174e-02f, 1.09679461e-01f, 7.77203068e-02f, -1.46473646e-02f,
  1.39401093e-01f, 1.00635283e-01f, 5.58224600e-03f, 2.32138690e-02f, -8.68560001e-02f, 7.79746100e-02f, 3.59513164e-02f, 1.23609379e-01f, -8.13919082e-02f, -6.56749029e-03f,
  -9.10331160e-02f, -8.21557716e-02f, -3.39424908e-02f, -7.59002864e-02f, 3.64217795e-02f, 8.07882696e-02f, 4.00408506e-02f, 1.63259029e-01f, -1.53940013e-02f, 9.65863839e-02f,
  -3.30231898e-02f, 2.28118356e-02f, -5.32482862e-02f, 2.80293766e-02f, -4.17287722e-02f, 7.60783553e-02f, -2.98174582e-02f, 7.29157925e-02f, 1.76352710e-02f, -5.72218485e-02f,
  5.89332916e-02f, 6.15122244e-02f, -4.96349707e-02f, 1.80842467e-02f, 2.95596290e-02f, 6.46924153e-02f, -2.00316794e-02f, -5.11747114e-02f, 3.66099030e-02f, 3.95161323e-02f,
  -1.48589611e-02f, -3.06479968e-02f, 5.30195422e-02f, 8.22368339e-02f, -7.42873102e-02f, 2.60640518e-03f, -7.13207573e-03f, 3.98938432e-02f, 7.10974187e-02f, 1.86434444e-02f,
  -6.65882230e-02f, 1.10435121e-01f, 9.25673991e-02f, 7.42770582e-02f, 3.11847366e-02f, -9.82173998e-03f, 5.98988757e-02f, 5.41915633e-02f, 6.52069319e-03f, -3.93962637e-02f,
  9.19483230e-02f, -4.55336124e-02f, 5.23973396e-03f, -4.41418588e-02f, -3.96211781e-02f, 4.85477708e-02f, 4.13997807e-02f, -5.30558079e-03f, 1.85911059e-02f, 4.65495028e-02f,
  -1.29899308e-01f, -1.97350699e-02f, -1.32805808e-02f, 6.57356828e-02f, -2.36345604e-02f, -1.60014909e-02f, 3.60728079e-03f, -3.19966562e-02f, -3.93010527e-02f, 1.78802647e-02f,
  -1.97476055e-02f, -9.18611139e-02f, 5.40863387e-02f, -3.01895407e-03f, -1.18805304e-01f, -4.89163361e-02f, 7.47397393e-02f, 6.46861494e-02f, -7.18942285e-02f, 2.59477459e-02f,
  5.56649804e-01f, 7.51024932e-02f, 3.29145968e-01f, 2.41377100e-01f, 2.22842082e-01f, 2.26166263e-01f, 1.71017334e-01f, 9.71487835e-02f, 3.59622873e-02f, 2.96875630e-02f,
  -3.30022126e-02f, -1.14539944e-01f, -2.26374418e-02f, -2.25249514e-01f, 7.36869201e-02f, 4.29178849e-02f, 5.79365082e-02f, 3.07598431e-02f, 7.51671568e-02f, -7.64775276e-02f,
  -4.12627682e-02f, -1.23343706e-01f, -3.94815430e-02f, 1.32665206e-02f, 3.36184017e-02f, 6.95725391e-03f, -5.35153747e-02f, -4.67564315e-02f, -2.28083618e-02f, -9.55670625e-02f,
  5.66412248e-02f, 2.43187904e-01f, -4.41597551e-02f, -4.27367911e-02f, -3.56446058e-02f, 2.35179551e-02f, -2.90151983e-02f, -6.16164282e-02f, -3.49139050e-02f, 4.96785082e-02f,
  -6.89471364e-02f, -2.98903715e-02f, -7.76993334e-02f, -1.23347700e-01f, 7.65716806e-02f, 5.95366172e-02f, -5.08223251e-02f, 9.61947069e-02f, -7.36051500e-02f, -1.15149520e-01f,
  -9.27024558e-02f, 3.97268459e-02f, 1.96863085e-01f, 2.10750885e-02f, 3.84607874e-02f, 6.15216121e-02f, 1.06105521e-01f, 1.61660183e-02f, 1.10236131e-01f, -4.41995189e-02f,
  2.42380053e-02f, 7.30241612e-02f, 3.46282721e-02f, -1.11797355e-01f, -3.76074668e-03f, -1.88313574e-02f, 3.37942806e-03f, -4.14099991e-02f, 5.32400981e-02f, -9.00324658e-02f,
  -3.53699848e-02f, 4.22936119e-02f, 3.22346911e-02f, 3.80084254e-02f, 4.13535908e-02f, -3.68961915e-02f, 5.48693351e-02f, 5.26809581e-02f, -1.13358967e-01f, -1.45642217e-02f,
  2.95880586e-02f, 5.70838526e-02f, 9.97425616e-02f, -9.02734697e-02f, -4.68656159e-04f, -3.84618416e-02f, -5.95367327e-02f, -4.88896444e-02f, 2.85757007e-03f, 2.42237914e-02f,
  -1.81396857e-01f, 1.31571800e-01f, 6.31181244e-03f, -6.52669296e-02f, 5.25494106e-02f, 8.33435133e-02f, 4.34228517e-02f, -2.76671499e-02f, -2.44472381e-02f, -5.00400439e-02f,
  7.76644349e-02f, -2.00922731e-02f, 3.36686037e-02f, 9.92964134e-02f, 6.97410107e-02f, 1.60726998e-02f, -2.96935476e-02f, -5.07466570e-02f, -9.22254622e-02f, -1.84316002e-02f,
  -1.56277418e-02f, -1.89573374e-02f, 3.56606953e-02f, 6.53666109e-02f, 6.22220896e-02f, 4.41781171e-02f, -4.52335030e-02f, -7.93997645e-02f, 1.71640232e-01f, -4.14573178e-02f,
  -4.33985412e-01f, 2.57508177e-02f, 1.21410899e-01f, -8.61651078e-03f, 9.13770422e-02f, 4.16387618e-02f, -1.52991548e-01f, -2.14104772e-01f, -4.58512157e-02f, 6.36840910e-02f,
  1.19051158e-01f, 1.52887538e-01f, 1.14681490e-01f, -4.54947837e-02f, -3.78453583e-01f, -2.18018904e-01f, -1.94685355e-01f, -1.08382814e-01f, -9.31264982e-02f, -1.20321698e-01f,
  -2.97430679e-02f, -8.69683027e-02f, -1.34336978e-01f, -1.71134263e-01f, 1.43224075e-01f, 8.20776969e-02f, 1.17382295e-01f, 2.13455455e-03f, 7.20311850e-02f, 1.92759365e-01f,
  3.94121796e-01f, -3.13997678e-02f, -1.08889483e-01f, -7.82706216e-02f, -4.93143126e-03f, -4.04070411e-03f, -1.97023824e-02f, -5.76789714e-02f, 2.42684763e-02f, -1.39964698e-02f,
  -1.24464855e-02f, -3.44928131e-02f, 1.31555423e-02f, 1.07830755e-01f, -1.06315449e-01f, -4.16730903e-02f, -2.02430889e-01f, -1.43410653e-01f, -8.32941756e-02f, 2.00566966e-02f,
  3.54454555e-02f, 1.20366132e-02f, -8.44439268e-02f, -8.74909684e-02f, -6.10211072e-03f, -3.79921723e-04f, -2.45788731e-02f, -9.22366418e-03f, -1.32023543e-01f, 7.19645172e-02f,
  -1.01165799e-02f, -5.01710214e-02f, -2.35996284e-02f, -5.10537475e-02f, 1.42238783e-02f, 6.79830369e-03f, 1.11388743e-01f, 4.22720950e-06f, -6.81818575e-02f, 3.02637275e-02f,
  3.76829691e-03f, 1.27090737e-02f, 1.93529297e-02f, -3.62260193e-02f, -2.93734744e-02f, 3.87113504e-02f, -9.62562487e-02f, 1.29948063e-02f, -4.29795347e-02f, 5.96683361e-02f,
  -4.27856594e-02f, 5.97593710e-02f, 9.02303904e-02f, 4.31918241e-02f, 3.27998735e-02f, -7.20881820e-02f, -1.10250220e-01f, -3.52230519e-02f, -5.18798120e-02f, -1.11779300e-02f,
  4.44101123e-03f, -2.92363968e-02f, 5.27224019e-02f, -1.37782946e-01f, -3.28623801e-02f, 9.46829692e-02f, 1.33398607e-01f, -8.38130042e-02f, 1.33619588e-02f, -6.05682656e-02f,
  1.77215389e-03f, -1.24909833e-01f, 9.89593472e-03f, 9.30864457e-03f, 3.52340937e-02f, -1.91384461e-02f, -1.99103564e-01f, -1.00861639e-02f, -5.06418794e-02f, -9.57047008e-03f,
  -6.18737638e-02f, -7.74341896e-02f, -1.93876289e-02f, 8.36008228e-03f, 7.78943449e-02f, -4.56164069e-02f, 6.97727203e-02f, 7.51993209e-02f, -4.64297123e-02f, -1.42225534e-01f,
  -3.41831446e-01f, -4.13940102e-02f, 1.66423693e-01f, 1.52264327e-01f, 3.52265060e-01f, 3.24757725e-01f, 1.96286991e-01f, 1.40472474e-02f, 5.57274930e-02f, 1.01778932e-01f,
  -6.90215528e-02f, -1.90938130e-01f, -1.85035571e-01f, -2.02398285e-01f, -3.89249548e-02f, 1.36215374e-01f, 2.51893163e-01f, 3.91882136e-02f, -2.73757260e-02f, 6.29579425e-02f,
  2.39132885e-02f, 4.51019360e-03f, -1.93074510e-01f, -6.54392987e-02f, 8.06013569e-02f, 9.60537582e-04f, -3.07217576e-02f, 2.02537328e-02f, -7.48867020e-02f, 1.43590987e-01f,
  -1.66802242e-01f, -3.79988961e-02f, 5.76897599e-02f, -1.17096663e-01f, 1.87679511e-02f, -1.13325112e-01f, -1.64875221e-02f, 2.64331698e-03f, -5.97153530e-02f, -3.19660157e-02f,
  -3.89202088e-02f, -3.20817195e-02f, 4.74305637e-02f, -5.40621094e-02f, -1.97940525e-02f, -7.22377747e-03f, -6.06387593e-02f, -7.53431842e-02f, -1.58435423e-02f, -6.59796894e-02f,
  3.97523940e-02f, 1.08031869e-01f, 1.49419131e-02f, 1.00392438e-01f, -4.25570197e-02f, -6.95434436e-02f, 6.77698404e-02f, 9.16220620e-02f, -1.76170245e-02f, -5.70362136e-02f,
  -5.25787510e-02f, 2.37583113e-03f, 1.92212593e-02f, 1.36500932e-02f, -4.73004393e-02f, -3.43877338e-02f, -4.98228222e-02f, -4.87715229e-02f, 8.19638595e-02f, -8.70814398e-02f,
  6.42350316e-02f, -8.04912522e-02f, 2.60700062e-02f, -6.65260479e-04f, -1.44739710e-02f, 8.15014467e-02f, -4.39387113e-02f, 1.49684418e-02f, -6.99231178e-02f, -1.53422207e-02f,
  2.11896654e-03f, 3.78820710e-02f, 4.87386473e-02f, 7.02534197e-03f, -3.28975148e-03f, -5.67907188e-03f, -3.42218131e-02f, -5.43286875e-02f, 4.51234449e-03f, -1.10363374e-02f,
  -1.67771846e-01f, -1.06899694e-01f, -5.32483198e-02f, 8.18509888e-03f, -1.79177299e-02f, -1.75215647e-01f, -5.59176132e-02f, -9.25910324e-02f, 3.62955965e-02f, -4.22140323e-02f,
  2.80733337e-04f, -2.36501768e-02f, -5.03053367e-02f, 5.96536919e-02f, 3.39276269e-02f, -4.51095141e-02f, -4.03844267e-02f, 1.82972737e-02f, 4.32716962e-03f, -4.06658314e-02f,
  5.47715500e-02f, 1.08455792e-01f, 5.59636690e-02f, 6.37353212e-02f, -3.40329409e-02f, -4.67714295e-02f, 5.81437647e-02f, -3.89327970e-03f, -1.64228734e-02f, 1.04276026e-02f,
  -2.00249124e-02f, -5.60444826e-03f, 1.22713521e-01f, 4.73088324e-02f, 4.47382592e-02f, -5.09807244e-02f, -3.55171144e-01f, -2.34227419e-01f, -3.20675708e-02f, -1.30959287e-01f,
  -6.48804232e-02f, -2.55473033e-02f, 1.29037593e-02f, 1.04928613e-01f, -5.41945361e-02f, -7.38270134e-02f, 4.23225723e-02f, 1.15365632e-01f, -5.16026244e-02f, -1.06676817e-01f,
  1.36300698e-02f, 9.58851874e-02f, 2.44964417e-02f, 4.76988740e-02f, 9.17193294e-02f, 1.13703951e-01f, 4.05811295e-02f, 2.01680467e-01f, 1.66097715e-01f, 2.86332160e-01f,
  8.79600421e-02f, 1.17884852e-01f, 8.57273042e-02f, -2.08772197e-02f, 9.76203978e-02f, -1.74113829e-02f, 5.65079739e-03f, -2.11958960e-02f, -4.55886684e-02f, 2.60082204e-02f,
  -1.20350420e-02f, 6.99318126e-02f, -3.28949578e-02f, -7.07321241e-02f, -4.47389632e-02f, -3.12124602e-02f, 8.11423268e-03f, -1.30200908e-02f, 3.89433950e-02f, -1.33215711e-01f,
  -6.27637953e-02f, -4.31983732e-02f, 2.20889021e-02f, -1.06638111e-01f, -1.08665982e-02f, 2.56920103e-02f, 6.85751438e-02f, -5.15098758e-02f, 9.55152151e-04f, 1.03025042e-01f,
  3.41354609e-02f, 3.45752798e-02f, 3.46637405e-02f, 1.12801848e-03f, 9.54275876e-02f, -7.04559535e-02f, 7.41427839e-02f, 9.12207067e-02f, -9.38638952e-03f, 3.36951896e-04f,
  -6.94321170e-02f, 9.17708501e-02f, -5.76536506e-02f, 4.07371344e-03f, 6.30130172e-02f, 4.54868749e-02f, 5.53638525e-02f, 4.35407870e-02f, -5.71566354e-03f, 5.26910201e-02f,
  6.35880157e-02f, 8.75062495e-02f, 2.83861272e-02f, 6.20433316e-02f, -5.68020716e-02f, 1.22326411e-01f, 2.20908225e-02f, -1.29368494e-03f, -4.51510251e-02f, -2.70781890e-02f,
  -2.01592326e-01f, 4.03958894e-02f, 3.86433154e-02f, -6.91178739e-02f, 1.23437688e-01f, -3.29089686e-02f, -7.52535835e-02f, 3.32446322e-02f, 2.35676914e-02f, 1.69229899e-02f,
  -6.69382215e-02f, 1.87432161e-03f, -1.36185616e-01f, -1.16094220e-02f, 2.83444282e-02f, -4.36425507e-02f, -7.54149584e-03f, 3.17116790e-02f, -9.10815373e-02f, -7.29959551e-03f,
  -1.50396705e-01f, -1.43881470e-01f, -2.32356980e-01f, -1.26062423e-01f, -5.51075637e-02f, 1.03480020e-03f, -7.45457038e-02f, -3.38843986e-02f, -1.00436218e-01f, -1.28872663e-01f,
  -4.18022454e-01f, 1.25180870e-01f, 1.92833573e-01f, -2.20709164e-02f, 9.46157500e-02f, 2.08541259e-01f, 4.54872757e-01f, 2.37534828e-02f, -1.48954719e-01f, 6.15298785e-02f,
  6.35442212e-02f, -1.29817620e-01f, -1.53532773e-01f, 4.00569290e-02f, 7.25600868e-02f, 1.69017449e-01f, 1.82270259e-01f, -9.59013328e-02f, -5.65398633e-02f, 3.82965431e-03f,
  5.95727488e-02f, -1.44064486e-01f, -2.31731102e-01f, -3.79040465e-02f, -5.63609973e-02f, -7.04989657e-02f, -3.76698710e-02f, 1.70672517e-02f, 1.69221148e-01f, 1.05034485e-01f,
  7.94981956e-04f, 1.18224770e-01f, 5.87758012e-02f, -2.98325624e-02f, -4.30157110e-02f, 1.60036162e-02f, -1.02908500e-02f, -6.44501969e-02f, 1.62443146e-02f, 2.29113922e-03f,
  1.05366977e-02f, 3.54141556e-02f, -2.61985045e-02f, 1.30772833e-02f, -8.13248679e-02f, 3.22183892e-02f, -3.26856747e-02f, -5.96998185e-02f, -1.50250578e-02f, 4.96979691e-02f,
  4.27192897e-02f, -3.18440236e-02f, 4.67795841e-02f, -4.71982695e-02f, 2.71060392e-02f, -1.08404204e-01f, 1.66638996e-02f, -2.25216448e-02f, 8.29072446e-02f, -1.67555794e-01f,
  4.17461097e-02f, -8.05520564e-02f, 1.11699263e-02f, -7.92367477e-03f, -3.00350469e-02f, -3.63060795e-02f, 1.86850745e-02f, 1.07583538e-01f, 1.33461994e-03f, -8.17829892e-02f,
  9.04525223e-04f, -4.99932580e-02f, -9.03999358e-02f, 1.34367086e-02f, 3.05149071e-02f, -3.08973528e-02f, -6.40607476e-02f, 7.08371028e-02f, 6.02376983e-02f, 4.33942798e-04f,
  -5.07741980e-02f, 6.43783957e-02f, -9.53686796e-03f, 7.41089229e-03f, 6.31271899e-02f, -5.58744483e-02f, 6.17158972e-02f, -3.55051905e-02f, -9.42214355e-02f, -6.99042752e-02f,
  -1.65520594e-01f, 2.40062192e-01f, -4.92930561e-02f, -8.79542306e-02f, 1.54604251e-02f, -3.60721275e-02f, 9.41209719e-02f, -2.49783825e-02f, 5.24826767e-03f, 6.79332614e-02f,
  1.00191779e-01f, 5.43499179e-02f, 1.28697501e-02f, -3.34001854e-02f, 2.42014118e-02f, 1.98881384e-02f, 2.92199496e-02f, 2.00272724e-02f, -5.34516852e-03f, -8.66909996e-02f,
  -7.87022635e-02f, -9.87538174e-02f, -2.35306546e-01f, -4.10475098e-02f, -8.10683593e-02f, -1.31819099e-01f, -1.44124150e-01f, -1.31657720e-01f, -1.13214806e-01f, -1.52930573e-01f,
  8.72551948e-02f, -5.68701476e-02f, -1.33143455e-01f, -3.93704250e-02f, -1.89548843e-02f, 4.22205264e-03f, -9.95369852e-02f, 3.81324440e-02f, 4.73551750e-02f, -8.20122734e-02f,
  3.49040050e-03f, 6.29547657e-03f, 6.36007870e-03f, 4.62200381e-02f, -1.24696665e-03f, 1.59786697e-02f, -1.43166080e-01f, -3.24294530e-02f, 1.01578921e-01f, -1.41060445e-02f,
  3.03887911e-02f, 2.65785195e-02f, 1.11033164e-01f, -1.32798846e-03f, -1.15962131e-02f, 3.67149860e-02f, -1.69835255e-01f, -5.89527301e-02f, -3.34802791e-02f, -1.82258070e-01f,
  -9.57500003e-03f, -4.27251635e-03f, 1.41321458e-02f, 7.67195225e-02f, -1.42914578e-01f, -9.61836055e-03f, -4.27812748e-02f, -7.67510682e-02f, -3.48966047e-02f, -8.77564773e-02f,
  -9.50933844e-02f, 1.25607952e-01f, -7.13354424e-02f, -2.15271525e-02f, -8.09421688e-02f, 2.68675499e-02f, 4.31154929e-02f, -5.56209199e-02f, -5.44077344e-03f, -9.59946215e-02f,
  5.30733801e-02f, -8.62505063e-02f, -5.28911501e-02f, -1.02399597e-02f, 1.20607065e-02f, -6.47805035e-02f, -8.79077613e-02f, -8.58411640e-02f, -2.61397939e-02f, -1.62555739e-01f,
  -6.30843788e-02f, -3.01683471e-02f, 3.13256606e-02f, -5.31952716e-02f, -1.50007978e-02f, 8.24456885e-02f, -9.14012790e-02f, 6.33620992e-02f, -7.15075061e-02f, -7.02223703e-02f,
  5.73938638e-02f, 3.05233616e-03f, -1.91307850e-02f, 6.63558096e-02f, -5.79479523e-02f, -4.41964380e-02f, -9.92895011e-03f, -1.59939621e-02f, -8.16626661e-03f, -1.91554669e-02f,
  -1.14893563e-01f, -1.02877043e-01f, 5.97688854e-02f, 4.78437133e-02f, -2.29121707e-02f, -2.12725755e-02f, -5.99767864e-02f, -4.07964736e-02f, -2.14820765e-02f, -5.92203662e-02f,
  6.13438450e-02f, 7.90561214e-02f, -6.54197857e-02f, 4.52380534e-03f, -7.15052858e-02f, 2.17260397e-03f, -2.76379213e-02f, -8.08011144e-02f, -6.41551316e-02f, -6.18801219e-03f,
  -6.61580563e-02f, 2.73785535e-02f, -2.31612027e-02f, -6.38537258e-02f, 7.91179463e-02f, 8.09036661e-03f, 8.63686800e-02f, -1.98897328e-02f, -2.56205350e-02f, 4.63230833e-02f,
  -8.38934258e-02f, -2.86754761e-02f, 6.79704025e-02f, -6.66440651e-02f, -3.18443254e-02f, -3.84341218e-02f, 2.10079085e-02f, -7.82614797e-02f, 3.52202207e-02f, 4.52988548e-03f,
  -1.03504688e-01f, 2.42496040e-02f, 5.50946873e-03f, 4.25064974e-02f, -3.99536602e-02f, -1.42656311e-01f, -7.74809569e-02f, -3.67240310e-02f, 4.30018790e-02f, -6.31955937e-02f,
  -1.20418027e-01f, -1.87579561e-02f, -1.06986545e-01f, 5.54434620e-02f, -2.03938290e-01f, -1.54271543e-01f, -2.80192673e-01f, -1.01025008e-01f, -1.67018577e-01f, 1.09274723e-02f,
  -4.13611606e-02f, -1.56434372e-01f, -1.46050707e-01f, -2.97157057e-02f, 7.39608631e-02f, 2.00551562e-02f, -1.80188811e-03f, -9.38371941e-02f, -8.73708948e-02f, -5.30162379e-02f,
  -1.03073969e-01f, 1.13395855e-01f, 3.75203080e-02f, -1.47698689e-02f, 4.22568917e-02f, 1.55617772e-02f, -1.04637347e-01f, -4.95035499e-02f, 6.90588504e-02f, 8.83635785e-03f,
  -1.81341749e-02f, -4.98057855e-03f, -3.95241454e-02f, 1.77559312e-02f, 4.89304997e-02f, -3.58853186e-03f, 2.59584580e-02f, -6.81010708e-02f, -4.88982871e-02f, -2.37199757e-02f,
  5.64988926e-02f, 3.42934254e-05f, 1.09291032e-01f, 6.84681535e-02f, 8.44198018e-02f, 7.50225969e-04f, 1.49249464e-01f, 1.32777438e-01f, 3.82292853e-03f, 1.63854063e-01f,
  -5.43086184e-03f, -1.64899360e-02f, 2.67969612e-02f, -5.44958375e-02f, -5.90872811e-03f, 9.56386626e-02f, -5.94545864e-02f, -1.03147775e-01f, 2.27739736e-02f, 6.33347631e-02f,
  -1.45954080e-02f, -9.64154825e-02f, -1.82276573e-02f, -7.29418099e-02f, -5.23470230e-02f, -3.53151932e-02f, -5.43484278e-02f, -3.07342019e-02f, 2.51152776e-02f, 4.31067171e-03f,
  9.99826342e-02f, -6.16141409e-02f, 4.50052470e-02f, 1.57525361e-01f, 5.30782491e-02f, 3.16222683e-02f, 6.36073872e-02f, 4.41137776e-02f, 3.70917283e-03f, -6.71849214e-03f,
  1.40611827e-02f, -1.08846910e-01f, -4.18445375e-03f, 8.66993442e-02f, -7.35245571e-02f, -3.77277471e-02f, -6.46618800e-03f, 1.12064868e-01f, 2.54442245e-02f, 4.78039123e-02f,
  5.82548529e-02f, 2.80894972e-02f, 1.14082254e-03f, 8.69217142e-02f, -4.18320112e-02f, -2.18093526e-02f, 4.92711179e-02f, -6.37828484e-02f, 7.32170939e-02f, 7.49033019e-02f,
  -1.03419852e-02f, -5.52098863e-02f, -7.66509073e-03f, 6.01443164e-02f, 3.08572184e-02f, -8.25473592e-02f, -1.77884847e-03f, 9.55954045e-02f, -1.00751013e-01f, 2.38295998e-02f,
  -4.85840254e-02f, -1.57365128e-02f, 2.33394839e-02f, 1.89608447e-02f, 5.44511527e-02f, -9.03028846e-02f, 2.09649168e-02f, -5.91865405e-02f, -7.59738311e-02f, 8.35176632e-02f,
  -1.79912634e-02f, -4.80591878e-02f, -6.33734986e-02f, -5.32551333e-02f, -6.10128082e-02f, 5.58534870e-03f, 2.02942267e-02f, -3.04148532e-02f, -1.82442695e-01f, -1.37912378e-01f,
  2.72683743e-02f, -5.95166162e-02f, -1.39790729e-01f, -1.26075789e-01f, 7.11422265e-02f, -6.08905740e-02f, -3.17315720e-02f, 1.59881972e-02f, -4.52111363e-02f, -4.15328257e-02f,
  3.05390302e-02f, 6.81895344e-03f, -1.33850444e-02f, -8.42709967e-04f, 2.39016488e-02f, -1.45236552e-02f, 8.99667591e-02f, -6.52331766e-03f, 4.51424085e-02f, 7.74737298e-02f,
  6.67628050e-02f, -6.88891858e-03f, 1.21753225e-02f, 4.26830761e-02f, 9.04290229e-02f, -3.63434083e-03f, -4.84595895e-02f, -6.81659207e-02f, 4.94250655e-02f, -8.73002317e-03f,
  -5.12833707e-02f, 5.30168302e-02f, -6.04660474e-02f, 4.26880382e-02f, 9.09936428e-03f, -8.95018950e-02f, -7.37587363e-02f, 8.45425110e-03f, -1.68933475e-03f, 3.21430969e-03f,
  -3.31715420e-02f, -7.40164444e-02f, -5.55676920e-03f, -7.52655789e-02f, -8.13759863e-02f, 4.07067686e-02f, -3.15739810e-02f, -5.60105033e-02f, -8.62949118e-02f, 1.95561033e-02f,
  -8.20410699e-02f, 5.13223857e-02f, -2.09419914e-02f, -4.28678058e-02f, -2.84755398e-02f, 5.69942035e-03f, -2.14225799e-02f, 1.95224863e-02f, 3.93713266e-02f, 6.94599450e-02f,
  3.68661359e-02f, -4.27004658e-02f, 4.91056517e-02f, 9.76707190e-02f, 5.88754006e-03f, -4.31254692e-02f, 1.68301445e-02f, 3.86373028e-02f, 4.97188643e-02f, 9.14898142e-02f,
  7.52561688e-02f, -4.16320860e-02f, 1.01792842e-01f, -3.15994844e-02f, 1.86778884e-02f, 5.14968671e-02f, 8.90128836e-02f, -1.66105721e-02f, -6.05325550e-02f, 4.67870869e-02f,
  -1.21489726e-01f, 2.55958941e-02f, 2.30908990e-04f, -3.78743522e-02f, 8.19869041e-02f, -5.93012124e-02f, -2.44207680e-02f, -3.44086662e-02f, 3.74739021e-02f, 1.09601706e-01f,
  5.94393238e-02f, -1.19898625e-01f, -3.49212401e-02f, -1.52589725e-02f, 8.29223096e-02f, 3.68317105e-02f, -2.65479181e-02f, 1.91414785e-02f, 4.14918140e-02f, 8.09292421e-02f,
  -3.13159406e-01f, 1.15776425e-02f, -7.41975233e-02f, 9.26084742e-02f, 5.05180210e-02f, 7.62900221e-04f, 1.43644735e-02f, -5.94559163e-02f, -5.20238020e-02f, 1.02031834e-01f,
  7.71597698e-02f, 5.58686964e-02f, 6.56197891e-02f, 2.83404142e-02f, -1.14629185e-02f, 1.06450871e-01f, 1.57406092e-01f, -8.54914542e-03f, -4.88085262e-02f, -5.54076256e-03f,
  1.74329087e-01f, -6.14470290e-03f, -1.63818687e-01f, -1.46205202e-01f, -5.87086426e-03f, 6.79019466e-02f, -1.67079810e-02f, 7.12718070e-02f, 9.58034918e-02f, 1.69156820e-01f,
  2.17265487e-02f, -1.41970485e-01f, -2.63872538e-02f, 1.49376020e-01f, 1.94733739e-02f, -1.27603352e-01f, 7.45110214e-02f, -8.29780772e-02f, -3.75220105e-02f, -3.44702080e-02f,
  3.83994244e-02f, 1.55544681e-02f, 4.98431437e-02f, -5.01730777e-02f, -7.50330538e-02f, -6.99546246e-04f, -3.82671133e-02f, -1.04986466e-01f, -5.13688885e-02f, -4.43280935e-02f,
  8.97805765e-02f, 6.86535165e-02f, -5.17971702e-02f, -4.36623544e-02f, -9.75875258e-02f, -7.55708739e-02f, -7.01252893e-02f, 1.33317811e-02f, -5.25159687e-02f, -1.00487217e-01f,
  -2.51795761e-02f, 9.51137990e-02f, -3.58830504e-02f, -8.00553989e-03f, -1.05848943e-03f, 4.94589619e-02f, 5.70388697e-02f, 5.99916792e-03f, -5.44048212e-02f, -8.88504237e-02f,
  5.39562628e-02f, -1.06039070e-01f, 4.79173772e-02f, -1.14055552e-01f, -1.05401777e-01f, -8.96985307e-02f, -1.80259235e-02f, -4.56575816e-03f, -8.44606012e-03f, -4.14473414e-02f,
  5.14509622e-03f, 3.59067582e-02f, -6.11162446e-02f, 7.54256546e-02f, -1.38276182e-02f, -6.91001117e-02f, -6.96846619e-02f, -1.14591733e-01f, -2.65755467e-02f, 2.90064383e-02f,
  -1.57386065e-01f, 1.97305474e-02f, 5.70284016e-02f, -2.68248841e-02f, -7.59651661e-02f, 1.18401386e-01f, -2.65234727e-02f, 7.60911554e-02f, 2.10017208e-02f, -1.89158227e-02f,
  -8.98037776e-02f, -6.77033812e-02f, -2.73572747e-02f, 7.04406425e-02f, -9.55767557e-02f, -7.48841166e-02f, 1.90734770e-02f, 7.70099089e-03f, -4.00774963e-02f, -2.46414170e-02f,
  -1.66076589e-02f, -9.41188782e-02f, -7.74519816e-02f, -1.87826715e-02f, -7.66366720e-02f, 3.68315764e-02f, -1.16294384e-01f, -1.68599963e-01f, -9.24172029e-02f, -2.12587878e-01f,
  -2.16708601e-01f, -1.33867770e-01f, -1.04460027e-02f, -9.54315905e-03f, 6.83927685e-02f, 1.62267908e-01f, 2.02116370e-02f, -6.99650124e-02f, -2.76902765e-02f, -8.91906023e-02f,
  -9.02761221e-02f, 5.46570309e-02f, -4.14195377e-03f, -7.20910355e-02f, 4.86630984e-02f, 1.66605935e-01f, 2.10595697e-01f, 3.38472202e-02f, 3.72224785e-02f, 1.27594873e-01f,
  6.21698685e-02f, 4.79298607e-02f, 7.44300801e-03f, 4.47700173e-02f, 3.97739112e-02f, 1.16866849e-01f, 7.10744038e-02f, -4.40220833e-02f, 5.79047389e-02f, 1.20220676e-01f,
  1.09297216e-01f, -1.19228490e-01f, 1.31113753e-01f, -2.93365791e-02f, 7.03610554e-02f, -5.47304340e-02f, 6.79858699e-02f, -4.55900244e-02f, 4.27892879e-02f, 2.74661444e-02f,
  -5.42799868e-02f, 4.57349606e-02f, -1.81113854e-02f, -1.84011683e-02f, 6.77233040e-02f, -7.64565095e-02f, -5.68680577e-02f, -4.10539247e-02f, 1.85875091e-04f, -1.01648673e-01f,
  1.33280316e-02f, 1.02210522e-01f, -4.98558693e-02f, 3.90320048e-02f, 2.75551155e-02f, 6.82412041e-03f, 5.33887707e-02f, -7.10190162e-02f, -1.14257261e-01f, -4.39043269e-02f,
  5.34355938e-02f, 9.23707616e-03f, 7.96159953e-02f, -8.24928358e-02f, -2.32154820e-02f, 4.75859903e-02f, 1.03934750e-01f, 1.53774628e-02f, -4.71068360e-02f, -3.33476700e-02f,
  -4.57585230e-02f, 3.48684378e-02f, -2.87012327e-02f, 3.36432271e-02f, -9.35310312e-03f, 3.12994607e-02f, -5.45810163e-02f, -5.44718765e-02f, -5.72032444e-02f, -1.07950501e-01f,
  5.72145805e-02f, -1.36472918e-02f, -8.52380022e-02f, -7.34876543e-02f, 3.12006939e-02f, 8.80802274e-02f, -2.15357039e-02f, -2.57998649e-02f, 1.60597600e-02f, 6.18067989e-03f,
  2.69870902e-03f, -1.02221286e-02f, 5.31649962e-02f, -1.27118984e-02f, 1.05425633e-01f, -1.07131265e-01f, -9.45973471e-02f, 5.15821241e-02f, -5.48474602e-02f, -6.88968645e-03f,
  2.07598251e-03f, -9.72050577e-02f, -3.23307025e-03f, 3.93418968e-03f, -5.45429401e-02f, 5.29090762e-02f, 2.65919808e-02f, 6.78311065e-02f, 1.68717839e-03f, -1.71318781e-02f,
  -8.65859389e-02f, 4.55953553e-02f, 2.23631412e-02f, 1.04809560e-01f, 7.88911432e-02f, 7.18917251e-02f, 8.87079760e-02f, 7.99688101e-02f, -5.26274089e-03f, 6.34408817e-02f,
  -2.78495103e-02f, 1.86192058e-02f, 5.05833514e-02f, 5.63883632e-02f, 1.03305988e-01f, 4.12654504e-02f, 4.30110469e-02f, -1.52631864e-01f, -1.25853002e-01f, -1.38535528e-02f,
  -7.56923407e-02f, -5.73762245e-02f, 9.36999395e-02f, -5.76011324e-03f, -3.03121824e-02f, -7.71505684e-02f, 4.23803888e-02f, 5.65630272e-02f, 1.89241767e-02f, 1.05425812e-01f,
  1.59554303e-01f, 6.20536618e-02f, 1.13169074e-01f, -8.66331812e-03f, 1.11898169e-01f, 1.71866994e-02f, 3.72260474e-02f, 9.75197926e-03f, 9.92038846e-02f, 8.97761062e-02f,
  1.97754219e-01f, 2.73829140e-02f, -3.43349241e-02f, 5.74847609e-02f, -4.33249883e-02f, -2.85491943e-02f, 6.58592880e-02f, -7.68059716e-02f, 4.15075794e-02f, -1.32043799e-02f,
  6.66717999e-03f, -8.53562262e-03f, 3.09032332e-02f, 7.24468902e-02f, 1.88003257e-02f, -2.50711460e-02f, 3.30777653e-02f, -2.51528434e-02f, -7.79769793e-02f, 5.13212010e-02f,
  7.86576197e-02f, -4.59979735e-02f, 1.08591169e-01f, -3.82381156e-02f, -1.08985081e-01f, 8.08263347e-02f, 1.15004316e-01f, -2.08733641e-02f, -1.00183906e-02f, 4.36582901e-02f,
  -4.86468710e-02f, -4.80587035e-02f, -4.74413931e-02f, -5.84457554e-02f, -8.83425847e-02f, 9.87851992e-03f, 1.56333633e-02f, 8.36929381e-02f, 2.46110708e-02f, -7.52420947e-02f,
  3.92799303e-02f, -7.27071762e-02f, 8.81609544e-02f, 2.82627102e-02f, -5.79750771e-03f, 5.73912077e-02f, 7.94109851e-02f, -1.77346747e-02f, -5.02843000e-02f, -5.31090684e-02f,
  -1.76637433e-02f, 7.19963312e-02f, 2.18688380e-02f, 8.05007666e-03f, -3.22047882e-02f, -6.58828840e-02f, 2.08442695e-02f, 5.32791093e-02f, -1.10653508e-02f, 5.11425994e-02f,
  1.18266068e-01f, -1.05675347e-01f, 1.00505911e-01f, 1.58931781e-02f, -5.32453395e-02f, 7.53553137e-02f, 5.62626421e-02f, 3.39386798e-02f, -3.10600679e-02f, 1.02498345e-01f,
  8.12525228e-02f, -1.04523860e-02f, 3.62708233e-02f, 5.73800094e-02f, 6.09719716e-02f, -1.89593602e-02f, 5.58681926e-03f, 1.26063570e-01f, -1.96499936e-02f, 7.97302201e-02f,
  2.29134541e-02f, -6.70434386e-02f, 1.99873410e-02f, -8.58370885e-02f, 3.83494683e-02f, 8.46440196e-02f, -1.08900322e-02f, -7.93982949e-03f, -2.11827997e-02f, -6.03558086e-02f,
  1.67993292e-01f, -3.58376533e-01f, -1.21577822e-01f, 9.01751146e-02f, 1.74985006e-02f, 1.61485612e-01f, 8.63708109e-02f, 3.53258699e-02f, 2.13898662e-02f, -2.96072681e-02f,
  -3.02745178e-02f, 6.44695982e-02f, 1.46763533e-01f, 7.80304074e-02f, 8.94374028e-02f, -3.67206708e-02f, -2.65231486e-02f, 7.01508000e-02f, 1.45820081e-01f, 6.47281334e-02f,
  -5.04857413e-02f, -3.07055339e-02f, -9.21077132e-02f, 1.20458538e-02f, -6.11809455e-02f, 1.98541626e-01f, -1.43630549e-01f, -1.49279892e-01f, 5.97172556e-03f, 6.79090014e-03f,
  -9.97564569e-02f, -2.23013267e-01f, 7.81247243e-02f, 2.08952725e-02f, -5.58131337e-02f, -1.24932021e-01f, -1.13703534e-01f, -1.25009194e-01f, 9.40755531e-02f, -4.54410836e-02f,
  3.69526260e-02f, -8.60701129e-02f, 2.29959898e-02f, -2.52466910e-02f, -1.73404645e-02f, -5.29477969e-02f, -1.81245327e-01f, -4.63963952e-03f, 1.00403428e-01f, -8.00623596e-02f,
  5.27631491e-02f, 1.90332979e-02f, -1.51911750e-01f, -5.80820115e-03f, 1.60026774e-01f, 4.49367277e-02f, -1.67040467e-01f, -9.94143635e-02f, -4.45446596e-02f, -5.44743575e-02f,
  7.29484856e-02f, 1.82267018e-02f, -2.21230350e-02f, 3.26905474e-02f, 2.07770895e-02f, 1.10815339e-01f, 1.19250968e-01f, 5.73766455e-02f, -7.90447220e-02f, -6.14330806e-02f,
  -3.21658924e-02f, 1.77644476e-01f, 2.73787603e-03f, 4.48089801e-02f, -7.08018169e-02f, -3.31825092e-02f, 5.08083850e-02f, -1.47338763e-01f, 4.57748957e-03f, 5.65921366e-02f,
  1.47732468e-02f, -8.11178312e-02f, -5.36587313e-02f, 3.36513929e-02f, -3.89216691e-02f, -5.58810309e-02f, 6.38636127e-02f, -5.65568879e-02f, -3.43772843e-02f, 1.17582008e-02f,
  -8.15167502e-02f, 3.67350243e-02f, 1.18785478e-01f, 4.01052348e-02f, -6.86830580e-02f, -4.53773625e-02f, 1.45061687e-01f, -4.62876298e-02f, 3.86520810e-02f, -2.00233590e-02f,
  -9.05765742e-02f, -2.21314933e-02f, -7.79015273e-02f, 2.84896810e-02f, 7.62289539e-02f, 5.19754924e-02f, -1.05592541e-01f, 2.17450634e-01f, -4.56463695e-02f, 3.44483703e-02f,
  -5.12629235e-03f, 8.89852792e-02f, 1.08479008e-01f, 1.45527929e-01f, 4.62846532e-02f, 2.06691027e-01f, 4.18608040e-02f, -6.64147036e-03f, 1.72871485e-01f, -3.59709701e-03f,
  6.09152541e-02f, 9.09581184e-02f, 9.88408774e-02f, 2.46198714e-01f, 2.43562922e-01f, 2.47768059e-01f, 2.46501595e-01f, 1.73567235e-01f, -2.01143194e-02f, 4.85687144e-02f,
  1.78022966e-01f, -4.11407985e-02f, -3.62300873e-02f, -6.69772625e-02f, 7.63152614e-02f, 8.03332850e-02f, 3.20165269e-02f, 3.03546488e-02f, 1.35832615e-02f, 1.14229567e-01f,
  -5.63337430e-02f, -8.15958083e-02f, -9.89463851e-02f, -5.60245328e-02f, 1.56337451e-02f, 1.92202386e-02f, 4.14293036e-02f, 2.71227537e-03f, 9.35927480e-02f, -4.28136475e-02f,
  8.19162056e-02f, 2.48238683e-01f, -2.76446883e-02f, -6.92800581e-02f, 1.12790048e-01f, 1.96647346e-02f, 3.06333378e-02f, -1.39619485e-02f, 2.13307515e-02f, 1.60333309e-02f,
  -4.16951180e-02f, -4.89459261e-02f, 9.86329839e-02f, 1.20421918e-02f, -6.10847473e-02f, 6.58845827e-02f, 3.12826782e-02f, -6.39193133e-02f, 7.55263120e-02f, 5.14629483e-02f,
  7.35263377e-02f, 9.15714726e-02f, 9.89369228e-02f, -2.22886894e-02f, 6.69578537e-02f, 1.82905588e-02f, 4.39864248e-02f, 8.13410878e-02f, 8.97823572e-02f, 5.33491485e-02f,
  7.68408692e-03f, -3.28977895e-03f, 6.84439987e-02f, -2.71196254e-02f, 8.71706083e-02f, -3.43204923e-02f, 2.78622303e-02f, -1.61026642e-02f, 2.35521197e-02f, -1.07660703e-01f,
  -4.10573371e-02f, 5.40761836e-03f, 1.13248015e-02f, 1.67006422e-02f, 7.64328912e-02f, 7.88549632e-02f, -1.75411142e-02f, -8.45443085e-02f, -4.14537303e-02f, 5.74860387e-02f,
  -4.92465757e-02f, 4.44377847e-02f, 2.17414387e-02f, -8.64980817e-02f, -1.31723117e-02f, 4.91636433e-02f, -3.03750690e-02f, 4.23710234e-03f, 2.61801109e-02f, -3.91526110e-02f,
  -1.24796622e-01f, 7.45327622e-02f, -1.33142397e-01f, -1.32080644e-01f, 2.65788231e-02f, -8.92130435e-02f, -4.23749685e-02f, 6.70907423e-02f, -3.17983776e-02f, -7.44980481e-03f,
  1.62659641e-02f, -7.51067102e-02f, -2.24192049e-02f, 1.51767815e-03f, 1.19023258e-02f, -1.00973904e-01f, 4.94236946e-02f, 6.50346950e-02f, 2.42303666e-02f, -2.15698965e-02f,
  -2.84992158e-02f, -5.31281941e-02f, -7.32314363e-02f, -4.63163666e-02f, -3.60852964e-02f, -6.93234131e-02f, -8.64245445e-02f, 4.39226888e-02f, -9.99804735e-02f, -3.18684243e-02f,
  5.38260758e-01f, 3.18738401e-01f, 6.65530711e-02f, -3.53609920e-02f, -1.25670999e-01f, -6.62645251e-02f, -6.65444955e-02f, -4.61441539e-02f, -8.50697905e-02f, 7.55670443e-02f,
  8.36729165e-03f, -1.55442402e-01f, -1.56855136e-01f, -9.41899326e-03f, 6.46945229e-03f, -3.83269927e-03f, 4.77778129e-02f, 1.19427420e-01f, -2.19303332e-02f, -8.52711648e-02f,
  5.60483821e-02f, 9.08459947e-02f, 2.32700512e-01f, 1.26998788e-02f, 1.16197886e-02f, -1.91757411e-01f, -3.69860828e-02f, 6.64717406e-02f, 2.13175733e-02f, 2.97904283e-01f,
  1.57229319e-01f, 2.61663586e-01f, -2.60999411e-01f, -4.68811877e-02f, 1.84272770e-02f, 6.90261126e-02f, 9.74111706e-02f, -5.27989073e-03f, -7.11387396e-03f, -5.41959330e-02f,
  6.13650121e-03f, 5.77590093e-02f, 3.49488184e-02f, -5.88027611e-02f, 4.28879783e-02f, -6.54948503e-02f, 1.62847433e-02f, 7.07427040e-02f, 3.21965627e-02f, 1.26054496e-01f,
  -3.61945927e-02f, 1.35602564e-01f, 9.63292867e-02f, -1.32507965e-01f, -7.32249916e-02f, -1.35422125e-01f, 6.22743964e-02f, 3.24481688e-02f, -3.17959897e-02f, 1.08622037e-01f,
  -6.60147071e-02f, -4.73312549e-02f, -8.20894056e-05f, -7.00353063e-04f, 5.92005067e-02f, -1.23597339e-01f, -5.65402173e-02f, -9.77091566e-02f, -6.27508536e-02f, -4.81573911e-03f,
  -2.28199717e-02f, -5.67357726e-02f, -8.79715160e-02f, 2.60719974e-02f, -1.14458404e-01f, 2.87847091e-02f, -2.53253672e-02f, 2.74895001e-02f, 1.04080904e-02f, 1.56018725e-02f,
  -5.17550260e-02f, -7.13286782e-03f, 6.53183982e-02f, 9.99031216e-03f, -7.96281919e-02f, -2.71696635e-02f, -1.08975329e-01f, -8.27008411e-02f, 1.12949712e-02f, 3.14860865e-02f,
  -1.96770668e-01f, -2.13667363e-01f, -6.62062243e-02f, 4.90112044e-02f, -3.68721262e-02f, -1.88145190e-02f, -4.30222377e-02f, 5.40891960e-02f, -4.95796241e-02f, 3.31601053e-02f,
  -3.74372341e-02f, 3.36554162e-02f, 2.98947170e-02f, 4.97021945e-04f, -4.16608388e-03f, 8.00554175e-03f, -8.92728008e-03f, -6.71050251e-02f, 3.46788913e-02f, 4.47637141e-02f,
  2.66946703e-02f, 2.00328231e-02f, -7.13930801e-02f, -2.03074533e-02f, -2.68074311e-02f, -1.82293534e-01f, -6.22981973e-02f, -6.44495264e-02f, 1.37641365e-02f, -5.05746305e-02f,
  3.85862678e-01f, -6.30317330e-02f, 2.78672036e-02f, 7.72031322e-02f, -8.71597081e-02f, -6.68040141e-02f, 4.56599370e-02f, -8.22564960e-03f, -1.16823345e-01f, 2.96625588e-02f,
  7.66085461e-02f, -4.24286909e-02f, -9.26036015e-02f, -6.28618747e-02f, 4.11129296e-02f, 5.77846095e-02f, -6.19665422e-02f, 3.82117964e-02f, 7.83119574e-02f, -2.32559200e-02f,
  -9.21156406e-02f, 3.11495177e-02f, 1.04579329e-01f, 8.03909302e-02f, -7.04308376e-02f, -4.20192890e-02f, -7.35506862e-02f, -1.00462614e-02f, 2.90100407e-02f, -1.26401111e-01f,
  1.61358956e-02f, 1.14093266e-01f, -1.09141029e-01f, 4.34747413e-02f, -5.21930978e-02f, 4.58649881e-02f, 8.66168961e-02f, 6.91680564e-03f, 3.32919657e-02f, 1.86555684e-02f,
  -4.00921628e-02f, -9.25855711e-02f, -7.19518438e-02f, 1.01424651e-02f, 5.84696867e-02f, -9.36708152e-02f, -3.19512598e-02f, -9.86363515e-02f, 4.71660402e-03f, 1.69452578e-02f,
  -1.16914123e-01f, -1.70144551e-02f, 1.04225174e-01f, 5.74113168e-02f, 9.52020474e-03f, 1.01634331e-01f, 8.69560465e-02f, 1.26077896e-02f, 1.88463125e-02f, -1.05003104e-01f,
  -1.21140607e-01f, -5.55474171e-03f, 1.67321041e-02f, -1.02571696e-01f, 9.75779146e-02f, -2.81456336e-02f, -2.78982036e-02f, -7.93284699e-02f, -6.22811867e-03f, 2.30343756e-03f,
  3.05393003e-02f, 1.19292540e-02f, 3.32283042e-02f, -8.98480043e-02f, -4.29111682e-02f, -2.12255158e-02f, -5.19274808e-02f, 7.53341019e-02f, 2.43621320e-02f, 4.37499955e-02f,
  8.53842273e-02f, 5.75059317e-02f, -1.09560393e-01f, 3.27851214e-02f, 3.75039130e-02f, 1.34556880e-02f, -5.91177046e-02f, 1.93411310e-03f, -4.24145572e-02f, -4.24345434e-02f,
  -1.22595966e-01f, 5.10399044e-02f, -1.22773886e-01f, 2.50457227e-02f, 4.39697839e-02f, -8.40586722e-02f, -1.54231815e-02f, 4.39307131e-02f, 2.20695622e-02f, -4.92170900e-02f,
  6.75585419e-02f, 3.78264971e-02f, -1.95314828e-02f, 6.55556619e-02f, -1.03891604e-01f, 3.25481128e-03f, -4.31877114e-02f, -1.25079602e-01f, -3.50689925e-02f, -7.42837489e-02f,
  1.47598060e-02f, 6.82336465e-02f, -3.37136202e-02f, 2.82284096e-02f, -1.00596072e-02f, 3.66687477e-02f, 1.99966729e-02f, 1.38079543e-02f, 9.99840870e-02f, -2.37247720e-02f,
  1.45727158e-01f, 6.34435639e-02f, -2.31701788e-02f, 1.52973837e-04f, -2.18097772e-02f, 5.82303368e-02f, 9.41639245e-02f, -7.44068846e-02f, -6.56137690e-02f, -4.08781953e-02f,
  5.84479608e-02f, -1.51962250e-01f, -1.36507303e-01f, -2.55425964e-02f, -2.20082384e-02f, -6.14461116e-02f, -1.19051673e-02f, -9.19192657e-02f, -3.90461423e-02f, -1.26085550e-01f,
  5.31030595e-02f, -3.08920648e-02f, -8.23479444e-02f, -6.95737675e-02f, 3.75106782e-02f, -6.45750435e-03f, 6.49042875e-02f, -7.06668794e-02f, -1.00166053e-01f, 2.89523657e-02f,
  -1.67773571e-02f, 2.11478453e-02f, -1.33576557e-01f, 2.87786890e-02f, 4.75686230e-02f, -3.27194668e-02f, 4.35586050e-02f, -1.86399743e-02f, -6.00679591e-02f, -1.02610057e-02f,
  6.62366971e-02f, 1.12373635e-01f, -2.89511401e-02f, 1.17971271e-01f, 2.34601796e-02f, 9.90879759e-02f, 4.04071361e-02f, -6.89634532e-02f, 1.27350762e-02f, 6.32375628e-02f,
  -1.81362778e-02f, 1.35039510e-02f, -3.74307930e-02f, -6.88483119e-02f, -1.29757691e-02f, -4.16612402e-02f, 1.77250579e-02f, 2.95778597e-03f, -1.77863240e-02f, 7.75801167e-02f,
  -6.19811267e-02f, 8.29964504e-02f, -1.31230494e-02f, 4.51607257e-02f, 3.28266099e-02f, -3.49613326e-03f, 4.63343598e-03f, -3.30721913e-03f, -1.87013112e-02f, -3.13611291e-02f,
  3.24683171e-03f, 3.43270265e-02f, 6.66190684e-02f, 1.10162728e-01f, 7.44087696e-02f, 5.79349585e-02f, 5.04799746e-02f, -3.58123519e-02f, -6.47759438e-02f, 8.56669173e-02f,
  -1.31078353e-02f, -2.16891803e-02f, -5.08341640e-02f, 4.22972292e-02f, 1.47734955e-02f, -2.47816201e-02f, 9.16115940e-02f, 4.94434405e-03f, -2.61108857e-02f, 5.65041006e-02f,
  2.49822810e-03f, -1.10273696e-01f, 1.15931787e-01f, -6.48145229e-02f, -9.50339064e-02f, 7.52103254e-02f, 1.90077201e-02f, 7.40295872e-02f, 1.05764374e-01f, -1.69755239e-02f,
  9.27244350e-02f, 8.89597908e-02f, 1.29925430e-01f, -4.80106915e-04f, 1.90586969e-02f, 7.08349273e-02f, 1.00128777e-01f, -4.88750711e-02f, 2.71623749e-02f, 6.56350926e-02f,
  6.30431622e-02f, -6.25317404e-03f, -5.77807846e-03f, 3.30658555e-02f, 3.91212516e-02f, 3.18199582e-02f, -1.63990411e-03f, -2.97212284e-02f, 3.84911448e-02f, 5.60107268e-02f,
  -3.00966114e-01f, 1.01763338e-01f, 1.45578235e-01f, -1.13676719e-01f, 5.41035198e-02f, 1.57128572e-01f, 3.33709061e-01f, 2.32575350e-02f, -5.90574332e-02f, -4.96158469e-03f,
  7.83938244e-02f, -1.20577127e-01f, -1.42055362e-01f, 1.40044093e-03f, 1.20498441e-01f, 6.59881756e-02f, 1.44004971e-01f, -6.07849658e-02f, -1.22315526e-01f, 1.80974919e-02f,
  -7.51270168e-03f, -7.04577193e-02f, -2.08970487e-01f, -6.44482002e-02f, 5.91713339e-02f, -6.87226206e-02f, -4.62247021e-02f, -6.01654723e-02f, -1.47590265e-02f, 4.10300791e-02f,
  -7.15411603e-02f, -4.87716533e-02f, 6.99777901e-02f, -7.11176395e-02f, 1.05342850e-01f, 6.82530971e-03f, -9.21562687e-02f, -1.36671558e-01f, -7.57547468e-02f, 8.07590038e-02f,
  5.15192673e-02f, -4.16636169e-02f, -3.03432881e-03f, -2.04715524e-02f, 2.20584013e-02f, 4.11616042e-02f, 1.65048447e-02f, 6.73663840e-02f, 3.81202139e-02f, 3.98494676e-02f,
  1.46495774e-01f, 6.52400851e-02f, 4.40789349e-02f, 4.24903911e-03f, 1.73025459e-01f, -9.45755094e-03f, 1.01075597e-01f, 5.58827370e-02f, 6.67456985e-02f, -7.02990741e-02f,
  -4.90320437e-02f, 1.07342629e-02f, 9.77055281e-02f, -5.96043840e-03f, 2.45586094e-02f, 5.78989461e-02f, -3.11059430e-02f, -7.33515769e-02f, 1.28530676e-03f, -3.77703458e-02f,
  1.26554864e-02f, 5.48118204e-02f, 2.55165491e-02f, -4.84536663e-02f, 5.28252032e-03f, 3.10940929e-02f, 8.06006640e-02f, 2.43588146e-02f, 2.33598743e-02f, -2.87029985e-02f,
  5.87588213e-02f, 5.54000810e-02f, -3.38659398e-02f, 3.19892890e-03f, 5.60613573e-02f, 8.53300989e-02f, -7.23881051e-02f, 5.46017028e-02f, 6.48178384e-02f, -1.88444257e-02f,
  -3.05451870e-01f, 1.38995662e-01f, -1.91584662e-01f, -7.30340630e-02f, 6.98669106e-02f, -7.38922656e-02f, -4.94597596e-04f, -1.14812344e-01f, -5.65288588e-02f, -3.97747755e-02f,
  -3.69270742e-02f, -1.24002747e-01f, 7.36238733e-02f, 5.80068715e-02f, 6.40313327e-02f, -4.41286573e-03f, -8.55073556e-02f, -8.39719027e-02f, 1.04886070e-01f, -2.08623689e-02f,
  1.13310188e-01f, -4.22546081e-02f, -1.20172188e-01f, -1.00508012e-01f, 6.05029939e-03f, 7.27522466e-03f, -1.98000912e-02f, 2.31526624e-02f, 4.82233651e-02f, -1.13389879e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.87820572e-02f, 1.02980629e-01f, -1.26879364e-01f, 1.55607581e-01f, -9.32768136e-02f, 1.82770118e-01f, 1.76505875e-02f, 2.47485079e-02f, 1.48774713e-01f, 1.83736280e-01f,
  2.09147200e-01f, 9.32138264e-02f, 9.35919434e-02f, 1.43963769e-01f, -1.61178578e-02f, 1.38672367e-02f, -7.88264126e-02f, 1.88161552e-01f, 1.27991036e-01f, 7.16053545e-02f,
  8.35016221e-02f, 1.15276933e-01f, 2.26922899e-01f, 2.36666635e-01f, -8.53462666e-02f, 2.39501983e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.86968952e-01f, -3.00373435e-01f, 1.57849178e-01f, 2.95068741e-01f, 8.46151337e-02f, 6.53298646e-02f, 1.23362310e-01f, -1.46818042e-01f, 5.78446984e-02f, 9.14446451e-03f,
  -3.62142213e-02f, 3.08764935e-01f, 4.80367020e-02f, 2.35750154e-01f, -9.61285084e-02f, 7.11462498e-02f, -1.01935370e-02f, -2.76521385e-01f, 1.15809537e-01f, 5.33640236e-02f,
  -7.18951821e-02f, 3.54727209e-02f, -1.52379543e-01f, -1.33784533e-01f, 1.55048603e-02f, -1.49614483e-01f, 3.84977506e-03f, -7.20726028e-02f, -1.13823429e-01f, 9.95607749e-02f,
  -1.95261657e-01f, 2.82522514e-02f, 1.94442812e-02f, -1.52737737e-01f, 5.92452101e-02f, -4.22836065e-01f, 1.82294548e-01f, 6.67618439e-02f, -6.38212860e-02f, 3.57139647e-01f,
  1.07872590e-01f, -4.48436812e-02f, -1.08993441e-01f, -1.86207488e-01f, -1.16000138e-01f, -2.86659598e-01f, 2.40898579e-01f, 2.83621401e-01f, -2.76937008e-01f, 2.58557796e-01f,
  -2.98041731e-01f, 1.75982818e-01f, -1.14078276e-01f, -1.91515103e-01f, 1.15405671e-01f, -4.17038724e-02f, 9.11340415e-02f, -1.47092745e-01f, 2.31227875e-02f, 3.87393117e-01f,
  1.73795730e-01f, 1.25441268e-01f, -2.20504235e-02f, -3.52033749e-02f, 6.31148294e-02f, -2.33252980e-02f, -5.72363511e-02f, 7.37581402e-02f, 7.07646310e-02f, -1.67303324e-01f,
  -1.15516379e-01f, -4.12248731e-01f, 1.27194360e-01f, 3.18038613e-01f, 2.09192634e-01f, 1.08119041e-01f, -1.18441172e-01f, -1.54657781e-01f, -1.44443825e-01f, 2.27104545e-01f,
  1.17927484e-01f, 3.55060361e-02f, -1.49346858e-01f, -2.65773594e-01f, 1.53555632e-01f, 9.00831968e-02f, 2.47818464e-03f, -2.68947065e-01f, -9.49624851e-02f, -1.36529714e-01f,
  -1.81991495e-02f, 2.66449340e-02f, 6.89536631e-02f, -8.14604945e-03f, -1.46429837e-01f, -2.30411977e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -6.05608858e-02f, -2.32581794e-02f, 7.42831603e-02f, -7.27906600e-02f, -1.86876386e-01f, -2.40208413e-02f, -6.24147542e-02f, 1.98449537e-01f, 1.34437039e-01f, -1.55442566e-01f,
  4.17970913e-03f, -8.20141658e-02f, 7.56403953e-02f, 7.44455084e-02f, 6.38972744e-02f, -5.47862500e-02f, -5.17389104e-02f, -1.29838020e-01f, -1.39047280e-01f, -4.77468893e-02f,
  5.24748974e-02f, -1.57075569e-01f, 1.47279471e-01f, 1.82513520e-01f, 1.16569802e-01f, -8.12980682e-02f, -7.55866244e-02f, -1.32301208e-02f, 9.26435590e-02f, -4.93706837e-02f,
  3.22096683e-02f, -8.20593238e-02f, -5.90126738e-02f, -5.44371121e-02f, -1.38149261e-01f, -1.51974902e-01f, -5.82747944e-02f, -1.43531725e-01f, -8.51661786e-02f, 6.82350919e-02f,
  -1.58657819e-01f, 2.64509112e-01f, 1.79237172e-01f, -1.31674960e-01f, 8.07068497e-02f, -6.76146895e-02f, 1.56448051e-01f, 7.94208143e-03f, 6.10482022e-02f, 3.10662538e-02f,
  -2.92368680e-02f, 4.25999798e-02f, 1.62935965e-02f, -2.12052777e-01f, 1.83602218e-02f, 7.61404485e-02f, -3.20557505e-02f, 8.49724934e-02f, 2.83160865e-01f, 2.85693891e-02f,
  -2.14323893e-01f, -3.97117734e-02f, -1.25254944e-01f, 1.88710392e-01f, 5.23977317e-02f, 1.90963417e-01f, 8.84311795e-02f, -1.34148344e-01f, -2.27186516e-01f, 3.78444791e-01f,
  -6.84120879e-02f, 1.14230335e-01f, -2.16891006e-01f, -2.06962988e-01f, -8.56087804e-02f, 2.06411242e-01f, -1.26728341e-01f, 1.77930444e-01f, 5.28052859e-02f, 3.36250998e-02f,
  2.32522607e-01f, -8.58003721e-02f, 3.36302847e-01f, 3.07770409e-02f, -1.02559589e-01f, -3.63631062e-02f, 1.89005256e-01f, 1.25649780e-01f, -1.09042954e-02f, 1.45441398e-01f,
  -1.70749828e-01f, -1.00806050e-01f, 3.02372217e-01f, 5.57545424e-02f, 1.96438506e-01f, 1.22983940e-02f, 1.32373143e-02f, -1.24124587e-01f, 5.31844556e-01f, -1.09609112e-01f,
  1.88503131e-01f, 8.79279375e-02f, -3.66406478e-02f, 1.35736033e-01f, 2.37151965e-01f, 2.31046662e-01f, -1.98445827e-01f, 1.65048748e-01f, 3.58413793e-02f, 1.45878792e-01f,
  -6.93675727e-02f, 3.63960639e-02f, -3.10451090e-02f, 2.46382266e-01f, -1.55832902e-01f, 4.84651357e-01f, -7.93767199e-02f, -1.30074378e-02f, -2.00035349e-01f, 1.51741818e-01f,
  1.50263667e-01f, 3.22046340e-03f, 3.86946827e-01f, 8.60409960e-02f, -2.72694319e-01f, 2.11857945e-01f, -2.49267086e-01f, 4.07785833e-01f, -1.90096758e-02f, -1.26947343e-01f,
  2.67541021e-01f, 1.92393571e-01f, 2.00979024e-01f, 1.38407201e-01f, 4.21340391e-02f, 1.61943391e-01f, 1.50702536e-01f, -2.40651388e-02f, -8.87862742e-02f, 1.50944134e-02f,
  -1.36775047e-01f, 2.09251300e-01f, -5.84250316e-03f, 1.80292770e-01f, -9.42128003e-02f, 5.57749495e-02f, 1.11068726e-01f, 4.58545499e-02f, -1.95594830e-03f, -5.15084006e-02f,
  -3.85997165e-03f, 2.05891371e-01f, 1.44053772e-01f, -2.97001153e-02f, -3.07481010e-02f, 1.22301355e-01f, -1.67527869e-01f, -2.74937451e-02f, -1.59195125e-01f, 5.75760752e-02f,
  2.08675966e-01f, -6.32572826e-03f, 6.03680730e-01f, -2.59803116e-01f, 1.92095488e-01f, -2.88322389e-01f, 2.26169258e-01f, 3.40165347e-01f, 8.02373812e-02f, -7.84099996e-02f,
  -9.68268216e-02f, 2.20664069e-01f, -1.04763292e-01f, -1.71374790e-02f, 2.36959010e-01f, 3.70463431e-01f, -3.16262215e-01f, 2.67353803e-02f, 5.35498969e-02f, 4.64465827e-01f,
  1.93694606e-01f, -2.01762512e-01f, -1.74841713e-02f, -2.23080553e-02f, -3.38900864e-01f, -1.89382672e-01f, 1.12416543e-01f, 1.40500069e-01f, 1.27912045e-01f, 3.32464129e-01f,
  -3.44115905e-02f, 3.20333123e-01f, -8.28444511e-02f, -5.51785044e-02f, 1.30367115e-01f, -2.50051796e-01f, 6.04525115e-03f, -8.13089758e-02f, 1.85068429e-01f, 6.15089200e-02f,
  1.89002156e-01f, -1.21561691e-01f, -1.56795606e-01f, -1.00250751e-01f, -2.13457812e-02f, -1.71925589e-01f, 4.85420227e-02f, 3.60202909e-01f, -2.30073810e-01f, 2.66004175e-01f,
  7.38050491e-02f, 1.60917714e-01f, -8.04757923e-02f, -6.60323575e-02f, 1.48253009e-01f, -1.78304583e-01f, 1.14619933e-01f, -1.41663933e-02f, 4.58597466e-02f, -4.70039733e-02f,
  2.90948391e-01f, 1.61498398e-01f, 1.72883496e-01f, 1.54362753e-01f, 3.79403263e-01f, 7.97443166e-02f, 1.96771994e-01f, -3.71264398e-01f, -1.29956573e-01f, -1.39745459e-01f,
  1.36430904e-01f, 2.80434340e-01f, 1.08449757e-01f, 9.09747407e-02f, -2.18559667e-01f, -1.21555246e-01f, -7.31526539e-02f, 1.78078637e-02f, 2.14131474e-01f, 2.67186314e-01f,
  -3.14869165e-01f, -9.94924232e-02f, -3.72661650e-02f, 1.04552254e-01f, 8.08306560e-02f, -4.40106951e-02f, -1.36469170e-01f, -1.51317343e-01f, -1.16150156e-01f, 2.38065887e-02f,
  5.55545688e-02f, 1.00907534e-01f, 4.54093844e-01f, 9.02841985e-02f, 1.55988380e-01f, 6.21562963e-03f, -1.68675885e-01f, 1.11677922e-01f, -1.15705840e-01f, -1.39217407e-01f,
  1.79982278e-02f, 1.10717848e-01f, -5.09790555e-02f, -1.04675092e-01f, 1.78883374e-01f, -7.83085749e-02f, -8.03707689e-02f, 7.01793761e-05f, 1.96409691e-03f, 3.92811634e-02f,
  -6.09721569e-03f, 1.55704945e-01f, 2.27464247e-03f, 1.13228366e-01f, 5.41689247e-02f, 1.26880467e-01f, 1.54442430e-01f, 1.42747462e-02f, 4.14904542e-02f, 1.90288462e-02f,
  -1.40408188e-01f, 8.52840915e-02f, -1.71281382e-01f, -3.51287834e-02f, -9.37458873e-02f, -4.54898179e-02f, 1.35321051e-01f, -4.06760769e-03f, 4.85035270e-01f, 7.09392726e-01f,
  1.82504863e-01f, -4.24333774e-02f, -4.03495848e-01f, 2.40960836e-01f, 1.27448365e-01f, 5.38193047e-01f, -3.07746619e-01f, -1.62560567e-01f, -4.87052910e-02f, 3.31722081e-01f,
  2.36976575e-02f, -7.55729079e-02f, -2.64822263e-02f, -1.28263667e-01f, 3.03667635e-01f, 4.49480265e-02f, 3.29862595e-01f, 1.28890812e-01f, 8.13247859e-02f, -9.40105245e-02f,
  1.43955573e-01f, 2.26540491e-01f, 1.19080678e-01f, 6.27817959e-02f, -1.62888423e-01f, -8.93625766e-02f, 3.29929769e-01f, -9.67900828e-03f, 1.36376441e-01f, 2.89282858e-01f,
  4.42318559e-01f, 2.88079292e-01f, 4.50548708e-01f, -3.11950296e-01f, -1.48879901e-01f, -5.44509590e-02f, -1.18986778e-01f, 2.32004255e-01f, 1.04697444e-01f, 6.20792657e-02f,
  -1.43055648e-01f, 1.93229258e-01f, -1.75335169e-01f, -5.83725795e-02f, 2.73645133e-01f, 1.58603519e-01f, -2.12093547e-01f, -1.09026819e-01f, -8.24574605e-02f, 1.68076918e-01f,
  -4.97619174e-02f, -1.05120122e-01f, -1.21258140e-01f, -1.16613507e-01f, -2.64690518e-01f, -2.16520932e-02f, 9.02416259e-02f, 1.08364202e-01f, 3.80570769e-01f, 1.26689881e-01f,
  -1.13907412e-01f, 2.33811848e-02f, -7.55545571e-02f, 2.30479807e-01f, -2.10934296e-01f, -8.33298713e-02f, 9.68780145e-02f, -3.21890324e-01f, -1.17668584e-01f, -1.71227515e-01f,
  -8.40598047e-02f, 7.12869242e-02f, -8.47891793e-02f, -1.79964885e-01f, -8.46860856e-02f, -1.01804636e-01f, 1.08249038e-01f, 5.20837195e-02f, 3.04568112e-01f, 1.19161308e-02f,
  -1.82302788e-01f, 2.75933649e-02f, -7.00911805e-02f, 2.60379724e-02f, 1.36233553e-01f, 2.83114631e-02f, 2.38253742e-01f, 1.49790794e-01f, 5.19314483e-02f, -1.65883586e-01f,
  2.88890507e-02f, -1.50528196e-02f, 1.28054574e-01f, -1.47139460e-01f, 7.32953325e-02f, 8.78798440e-02f, 1.04696698e-01f, -1.54407555e-02f, 7.19872937e-02f, -3.11262850e-02f,
  4.42738421e-02f, 1.63375288e-01f, 1.31539017e-01f, 1.45961270e-01f, 7.59129450e-02f, -1.52629048e-01f, 2.11470664e-01f, -1.70018077e-01f, 3.53195667e-02f, -1.83092460e-01f,
  -3.52949537e-02f, 2.39868581e-01f, 5.63892610e-02f, 8.22042972e-02f, -8.81279185e-02f, -1.26353920e-01f, -1.51021793e-01f, 1.30249575e-01f, 7.51108825e-02f, -1.55633511e-02f,
  -1.19741531e-02f, 1.88060462e-01f, 1.24396617e-02f, -1.45881161e-01f, -1.23583317e-01f, -8.02970603e-02f, 4.69863415e-02f, 1.84015468e-01f, -8.69131610e-02f, 1.63831353e-01f,
  1.45931204e-03f, 2.24630713e-01f, -1.30831162e-02f, 1.19559139e-01f, -2.96684001e-02f, -1.45976871e-01f, -5.56650525e-03f, -1.89034075e-01f, -1.54621765e-01f, 9.85626015e-04f,
  -1.59129605e-01f, 2.06457898e-02f, 1.55097842e-01f, -2.12952927e-01f, 2.22807437e-01f, -2.65710265e-03f, 6.56351121e-03f, 7.83827454e-02f, -1.00412495e-01f, -9.46586281e-02f,
  1.23790279e-01f, 1.90895349e-01f, -1.59777388e-01f, 1.68142855e-01f, -4.59822975e-02f, 1.12347435e-02f, -5.88873364e-02f, -2.00254321e-01f, 2.82294035e-01f, 2.85865128e-01f,
  -2.87288968e-02f, -7.26605207e-03f, 2.85700709e-01f, -2.92333543e-01f, 8.71473774e-02f, 1.17571354e-01f, -1.06384315e-01f, 2.14884683e-01f, -1.28594264e-01f, -4.79883105e-02f,
  2.19519272e-01f, 8.15192685e-02f, 7.31119215e-02f, 1.01607494e-01f, 2.33632013e-01f, 2.66161382e-01f, -1.43497184e-01f, -2.19626054e-02f, -1.92479212e-02f, -1.69874802e-02f,
  8.07560980e-02f, 2.25245908e-01f, 2.77361482e-01f, 9.98414308e-02f, 3.17324488e-03f, -2.05123380e-01f, -1.35339722e-01f, 1.04579195e-01f, -1.79315137e-03f, 4.21399325e-02f,
  2.39826571e-02f, -1.29660279e-01f, -2.89156232e-02f, -1.04638197e-01f, -2.56517585e-02f, 6.27285987e-02f, 1.41877919e-01f, -1.06972843e-01f, 1.09628826e-01f, 1.46822169e-01f,
  1.67327970e-01f, 6.17358722e-02f, -1.57785177e-01f, -8.47404525e-02f, 1.40394226e-01f, 4.07776423e-02f, 1.37062699e-01f, -1.26545876e-01f, 2.17075348e-02f, -1.73840076e-01f,
  9.77823138e-02f, 1.52863070e-01f, -5.30074760e-02f, 7.22179636e-02f, -1.21024728e-01f, 1.06951073e-01f, 1.32919446e-01f, 1.33129105e-01f, -4.72209938e-02f, -1.27302542e-01f,
  -1.28113702e-01f, 1.03216209e-01f, -1.10412188e-01f, -1.15408719e-01f, 7.52390027e-02f, 2.87340917e-02f, 2.50677466e-01f, -7.10992441e-02f, 5.97291887e-02f, -2.86879335e-02f,
  3.92266840e-01f, 2.76165362e-02f, 4.77313288e-02f, 2.47725874e-01f, -1.67787373e-01f, 1.37203559e-01f, -2.83571407e-02f, 1.67941153e-01f, -6.25825897e-02f, -1.01868980e-01f,
  -1.49684891e-01f, -1.52684152e-01f, 2.59981155e-01f, 1.17944643e-01f, -1.56623125e-01f, -1.10440508e-01f, -1.21738963e-01f, 1.14381291e-01f, 1.71349838e-01f, -3.62777859e-02f,
  -2.91961990e-02f, 2.74190456e-02f, -5.40676825e-02f, -1.96361110e-01f, 4.19038497e-02f, 3.22474450e-01f, -1.79455146e-01f, 1.01976894e-01f, -1.10532194e-01f, 1.60352528e-01f,
  5.33438437e-02f, 7.34759346e-02f, 7.14029670e-02f, 1.79420426e-01f, -4.72358130e-02f, -1.35442764e-01f, 1.22530103e-01f, -9.74791571e-02f, 1.15801297e-01f, -2.17347547e-01f,
  3.45173448e-01f, -1.21893100e-01f, 2.44016543e-01f, -7.50805885e-02f, 7.55299181e-02f, 1.93525761e-01f, -8.18535388e-02f, 1.99795604e-01f, 3.25702988e-02f, -2.85436232e-02f,
  -1.05971687e-01f, -1.77245796e-01f, 7.59931281e-02f, -1.45632029e-01f, -6.72096685e-02f, 1.01289898e-01f, 8.68281797e-02f, -1.22647464e-01f, -1.34277448e-01f, 4.27339152e-02f,
  1.22746285e-02f, -1.29643977e-01f, -4.43799309e-02f, -8.13772976e-02f, -5.81431463e-02f, 1.76354066e-01f, -3.54851857e-02f, -3.36913168e-02f, -3.40461247e-02f, 5.23727611e-02f,
  -4.85775769e-02f, -1.35924760e-02f, -2.50247307e-02f, 8.71218890e-02f, -1.63103417e-01f, -1.92450918e-02f, -1.26853228e-01f, -1.15407363e-01f, 9.00696367e-02f, 5.49922884e-02f,
  -2.84723267e-02f, -1.86130479e-02f, -5.37086986e-02f, 4.37627397e-02f, 4.74040350e-03f, 3.18296142e-02f, -1.40225068e-01f, -7.04526380e-02f, -1.68534108e-02f, 1.55716315e-01f,
  2.46049929e-02f, -2.29723752e-01f, 6.66136295e-02f, -4.47183661e-02f, 1.10286631e-01f, -9.49047431e-02f, -4.92625386e-02f, 1.40988231e-01f, -1.18145920e-01f, -5.92663996e-02f,
  -1.28758416e-01f, 1.09096743e-01f, 2.20033545e-02f, 2.35345498e-01f, 1.15379050e-01f, -8.75679404e-02f, -1.30027384e-01f, -5.41972890e-02f, 1.32400200e-01f, 8.69265664e-03f,
  -5.61530218e-02f, -1.74218938e-01f, 1.91718742e-01f, 3.75498272e-02f, 6.50102645e-02f, 1.93647929e-02f, -1.68224558e-01f, 1.48156643e-01f, -6.49464726e-02f, 7.29351342e-02f,
  8.63454863e-02f, -1.85097560e-01f, 1.09556355e-01f, -1.32333664e-02f, 2.02730328e-01f, -1.73709229e-01f, -5.46831079e-02f, 2.00181082e-01f, 2.65195131e-01f, 1.50528952e-01f,
  1.51607469e-01f, 2.01665357e-01f, -1.08775921e-01f, 8.00499693e-02f, -1.19062454e-01f, 1.57695949e-01f, -2.90949434e-01f, 7.87396953e-02f, -1.10466070e-01f, -5.86935058e-02f,
  2.31422246e-01f, 9.35457721e-02f, -9.54579264e-02f, -1.36476547e-01f, 3.55105549e-02f, -1.07152248e-02f, 1.91310599e-01f, 2.19163552e-01f, 2.27023751e-01f, 2.34154478e-01f,
  -8.99972543e-02f, 2.13327304e-01f, 2.60612577e-01f, 1.17323205e-01f, -1.28607154e-01f, -1.75940618e-02f, 5.13031520e-02f, -1.67651802e-01f, -8.22401866e-02f, 1.57266662e-01f,
  -5.98862842e-02f, 2.55180359e-01f, 2.02359453e-01f, -9.12839025e-02f, 1.03755690e-01f, 1.31230950e-01f, 2.63824761e-02f, -1.31158859e-01f, 2.65798420e-01f, -1.18770912e-01f,
  1.49432644e-01f, -6.13364689e-02f, -1.23643301e-01f, 9.01561379e-02f, 1.17897369e-01f, -5.49751893e-03f, 1.91215590e-01f, 2.45557129e-01f, -1.35429949e-01f, 4.97610122e-02f,
  2.43317530e-01f, 3.20676267e-02f, -3.76019739e-02f, -6.76108990e-03f, 6.00748807e-02f, 1.60949712e-03f, -1.40985111e-02f, 3.39509904e-01f, -1.69590205e-01f, -1.87824234e-01f,
  4.37433459e-02f, 4.15003568e-01f, -1.56663626e-01f, -2.40539402e-01f, -2.03666568e-01f, 4.56486978e-02f, 1.48717955e-01f, -7.59119242e-02f, -1.61155969e-01f, -4.11960334e-02f,
  1.52283758e-01f, 3.57632816e-01f, -8.77083689e-02f, 3.50658536e-01f, -9.52037126e-02f, 4.77854535e-02f, 9.23964456e-02f, 3.52426440e-01f, 4.58798781e-02f, -1.75392977e-03f,
  7.69955814e-02f, 6.60950691e-02f, -1.81567371e-01f, -5.65342940e-02f, -8.19942132e-02f, 3.51454318e-01f, -1.11432046e-01f, -5.80677250e-03f, 1.22231051e-01f, -1.69551317e-02f,
  -8.65432844e-02f, -1.24093756e-01f, 9.56100821e-02f, -1.46614864e-01f, -1.51887685e-02f, 2.37769023e-01f, 1.24236703e-01f, -2.16808081e-01f, -3.45128514e-02f, -9.88814514e-03f,
  9.82366502e-02f, 2.37576757e-02f, -5.59304133e-02f, -2.78182924e-02f, -1.49746805e-01f, -1.25141934e-01f, 7.68637061e-02f, 3.92911881e-02f, -1.41237631e-01f, 1.04681533e-02f,
  6.56318963e-02f, 1.27387241e-01f, -3.05495299e-02f, 2.67866045e-01f, 1.39158249e-01f, 9.11607221e-02f, -1.55095577e-01f, -3.65050398e-02f, 2.29523316e-01f, 5.74375167e-02f,
  5.69668949e-01f, 3.44116718e-01f, -3.92146874e-03f, 9.84833166e-02f, 6.69882223e-02f, -1.30387515e-01f, 2.76281714e-01f, 1.46617398e-01f, -5.75236604e-02f, 7.52265394e-01f,
  -1.90069556e-01f, 2.96071202e-01f, -8.90360698e-02f, 2.05010697e-01f, 7.32207969e-02f, -2.81291962e-01f, -2.20260639e-02f, 1.05799854e-01f, 2.06188142e-01f, 4.64133590e-01f,
  2.27996409e-02f, 1.45032719e-01f, -1.23412110e-01f, -1.55484512e-01f, 5.37018254e-02f, 2.15956256e-01f, -1.88525826e-01f, -5.04494384e-02f, 2.55517457e-02f, 3.09765488e-02f,
  1.74577251e-01f, 3.06947213e-02f, 2.73094505e-01f, -6.66342750e-02f, 3.17183346e-01f, -2.40269482e-01f, 2.34056175e-01f, 1.79657698e-01f, 5.63413687e-02f, 8.24530497e-02f,
  -4.87172231e-02f, 2.33009145e-01f, -1.79355487e-03f, -1.14345677e-01f, -4.25512418e-02f, 2.59963453e-01f, -2.43737064e-02f, 2.17738435e-01f, -2.35619470e-01f, 3.47596020e-01f,
  8.58794227e-02f, -1.28992453e-01f, -1.10194400e-01f, 2.47183844e-01f, 1.42752782e-01f, -1.11172803e-01f, 4.33502287e-01f, 1.51749432e-01f, -3.56470346e-01f, 1.90290004e-01f,
  -8.13875049e-02f, 1.65137827e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -7.65987635e-02f, 5.66531383e-02f, 1.96069255e-01f, 1.76053181e-01f, 4.71073352e-02f, 4.79356229e-01f, 1.83430135e-01f, 3.09555799e-01f, -1.61213726e-01f, 5.91354787e-01f,
  4.70551610e-01f, 3.07483047e-01f, 1.37592986e-01f, 1.59991547e-01f, 7.14631577e-04f, -1.06378153e-01f, 6.05721697e-02f, 3.15184861e-01f, -1.59062564e-01f, -2.21720692e-02f,
  1.27019778e-01f, -5.20215072e-02f, 9.03826281e-02f, 1.49348006e-01f, 2.17209101e-01f, 1.24409810e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.98283613e-02f, 2.45745704e-01f, 2.45356694e-01f, 9.10919383e-02f, -3.31234992e-01f, -2.20057979e-01f, 8.46262425e-02f, -2.45139107e-01f, 2.12907150e-01f, 1.57886177e-01f,
  2.10421413e-01f, -2.57545173e-01f, -2.62386113e-01f, -3.25352430e-01f, -1.59413934e-01f, 3.07929337e-01f, -1.43287137e-01f, -5.32033592e-02f, 9.80582088e-02f, 2.25240901e-01f,
  3.36624756e-02f, -1.78505033e-01f, -4.10245135e-02f, -3.09612714e-02f, 7.83639867e-03f, 1.23344979e-03f, -2.87451297e-01f, -1.11144684e-01f, 5.12255393e-02f, 6.23538420e-02f,
  -4.05293889e-02f, 6.44605979e-02f, 2.48493761e-01f, 1.49871752e-01f, -1.49662346e-01f, -2.30005115e-01f, -2.36519322e-01f, 1.28804669e-01f, -1.15864955e-01f, -2.08347201e-01f,
  -1.39441922e-01f, 4.67868485e-02f, -1.57921359e-01f, -1.66522712e-01f, -8.81921053e-02f, -1.18938178e-01f, -1.02302879e-01f, 2.19007462e-01f, -2.59672821e-01f, 5.05324639e-02f,
  1.85764328e-01f, 6.73156008e-02f, 1.74746096e-01f, -7.14089125e-02f, -1.34081826e-01f, 1.86063364e-01f, -6.65962324e-02f, -1.99758917e-01f, -1.04012266e-01f, 2.53501814e-02f,
  3.30545694e-01f, -1.38276294e-01f, -1.20979086e-01f, -2.41009444e-01f, -2.10047916e-01f, -2.46669371e-02f, -3.33799012e-02f, -1.04098044e-01f, 2.16247052e-01f, -1.00133687e-01f,
  -1.50004148e-01f, 2.14526877e-01f, -1.31833404e-01f, 2.01723546e-01f, 1.62391812e-01f, 1.06379144e-01f, -1.46829754e-01f, -2.46081114e-01f, 1.09862581e-01f, -2.45122209e-01f,
  -2.10495993e-01f, -1.44557312e-01f, 6.06251583e-02f, -2.40259409e-01f, 2.14585468e-01f, 1.92952459e-03f, 5.01137562e-02f, -9.98379961e-02f, -1.04747452e-01f, 9.78672728e-02f,
  1.13959163e-01f, -4.21419032e-02f, 1.89242288e-01f, 2.08374947e-01f, 3.17251831e-01f, 3.65059972e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.66119471e-01f, 1.23177812e-01f, 3.75121504e-01f, -1.12531729e-01f, -2.07282051e-01f, -6.19443171e-02f, 9.15137678e-02f, -1.11547895e-01f, 4.06451374e-01f, -2.76157588e-01f,
  -2.20683947e-01f, 1.04874998e-01f, -2.01070279e-01f, -2.23208275e-02f, -2.34711822e-02f, 7.83454001e-01f, 2.16673881e-01f, 4.26230356e-02f, -1.97996926e-02f, -5.22011295e-02f,
  -3.04780249e-02f, -2.23352402e-01f, -1.48088530e-01f, 3.03806692e-01f, -2.03560498e-02f, -2.30214149e-02f, -6.32637963e-02f, 1.45753160e-01f, -1.70527175e-02f, -5.59940562e-02f,
  2.95150280e-01f, -1.62620753e-01f, 2.43259035e-02f, 1.43328056e-01f, -1.30101532e-01f, -2.47373000e-01f, 6.96445704e-02f, -3.98546100e-01f, 2.21993506e-01f, -4.88929972e-02f,
  1.44415855e-01f, 1.12165637e-01f, -1.53404832e-01f, 1.58871323e-01f, 9.40000415e-02f, 2.53068000e-01f, -1.39863774e-01f, 3.54786634e-01f, 3.54714662e-01f, -1.17923580e-01f,
  6.09499887e-02f, -6.20090477e-02f, -5.03611341e-02f, -1.05850801e-01f, -1.86496779e-01f, -1.21773653e-01f, -1.67507485e-01f, 4.89634164e-02f, -7.00066984e-02f, 1.11294068e-01f,
  2.88548827e-01f, -3.54862325e-02f, -1.55031115e-01f, 1.98726120e-04f, -1.53047785e-01f, 1.35274887e-01f, -2.85831630e-01f, 1.63257077e-01f, 2.24577442e-01f, -2.12725654e-01f,
  1.32847697e-01f, 2.52545893e-01f, -1.16118342e-01f, 3.31489891e-01f, 1.67509511e-01f, 2.04263985e-01f, -1.19725175e-01f, 2.48491745e-02f, -3.94416079e-02f, -4.82935831e-02f,
  -8.71889014e-03f, -1.54330462e-01f, 2.44506046e-01f, -3.19135562e-02f, 2.97969788e-01f, -1.70446351e-01f, -1.27092842e-02f, -8.22297707e-02f, 1.76908299e-02f, -6.49910048e-02f,
  -1.01757854e-01f, -1.03033669e-01f, 4.03009772e-01f, -1.28520831e-01f, 1.83309346e-01f, 4.46772665e-01f, 2.66597867e-02f, 2.94278622e-01f, 3.02753061e-01f, 2.10059881e-01f,
  -9.80077311e-02f, 1.93461418e-01f, -5.40725738e-02f, -9.65570956e-02f, -7.34855607e-02f, 6.89676404e-02f, 1.91169009e-01f, 3.71051021e-02f, -2.01485887e-01f, -8.40125978e-02f,
  -4.89923880e-02f, 1.10858409e-02f, 8.32063332e-02f, 1.07673965e-01f, -1.45624280e-01f, -1.29108042e-01f, 6.48916736e-02f, 4.83434685e-02f, 3.48665088e-01f, -3.47242765e-02f,
  1.15095854e-01f, 6.11496344e-03f, 5.80234937e-02f, -1.39629796e-01f, -1.34715974e-01f, -1.15834169e-01f, 5.52355468e-01f, 8.16510543e-02f, 2.78731287e-01f, 2.02828586e-01f,
  1.60713896e-01f, -1.99775562e-01f, -6.85161576e-02f, 1.11208126e-01f, -3.24004069e-02f, -1.61855146e-02f, -6.46883622e-02f, -1.98899582e-01f, -9.40460563e-02f, -1.66817710e-01f,
  -1.27838641e-01f, 1.49044320e-01f, -1.07890684e-02f, 3.21229160e-01f, -6.81318417e-02f, 2.90898919e-01f, -2.20589526e-02f, -2.67348196e-02f, 2.73758620e-01f, 1.54106110e-01f,
  1.59798302e-02f, 2.01714471e-01f, -1.12434462e-01f, 1.03569999e-01f, 3.27020958e-02f, 2.93072432e-01f, -1.34083265e-02f, 1.48080349e-01f, -9.98346508e-02f, -1.06626071e-01f,
  1.35647118e-01f, 4.41846102e-01f, 2.59770900e-01f, -2.52330303e-01f, 4.02517736e-01f, -2.91021410e-02f, -7.97605738e-02f, 5.96338138e-02f, -3.02561671e-02f, -7.89663382e-03f,
  5.30717894e-03f, 4.53934520e-01f, 7.60282949e-02f, 4.03210908e-01f, 7.91322440e-02f, 3.22490722e-01f, 5.82047820e-01f, -1.85292482e-01f, 7.75651708e-02f, -9.90496427e-02f,
  8.12832564e-02f, -6.85081109e-02f, -2.45037317e-01f, 8.19631815e-02f, -1.79603249e-01f, -1.01525024e-01f, 4.60887291e-02f, 1.05707332e-01f, -2.54515707e-01f, 6.14341116e-03f,
  -1.65767714e-01f, 9.81800407e-02f, 6.55568540e-02f, -1.03048064e-01f, 6.91968724e-02f, 2.74332196e-01f, -2.74406224e-01f, 2.86651224e-01f, 1.53122619e-01f, -1.17932178e-01f,
  3.34593132e-02f, -1.38020381e-01f, -9.12059247e-02f, -4.49037366e-02f, -1.98607266e-01f, 4.35995869e-02f, -6.76457770e-03f, -1.44212365e-01f, 5.99904023e-02f, -8.89027938e-02f,
  -9.08922777e-02f, 2.42978744e-02f, 7.68240467e-02f, 3.05438675e-02f, 1.24597803e-01f, 7.93191120e-02f, 8.12080875e-03f, 7.23128393e-02f, 6.84344769e-02f, -7.62155354e-02f,
  -5.54260239e-02f, -4.02953438e-02f, 2.72682291e-02f, 6.69264719e-02f, 1.26785412e-01f, -4.61160019e-02f, 1.06105179e-01f, 4.19619232e-01f, -2.43049264e-01f, 1.53270587e-01f,
  8.31371024e-02f, -1.81032091e-01f, -6.38680086e-02f, 2.47284651e-01f, 1.26732156e-01f, 3.96439463e-01f, -5.52736074e-02f, 7.19059482e-02f, 1.08791199e-02f, 4.39486951e-02f,
  1.99956924e-01f, -2.86346257e-01f, 3.22791375e-02f, -6.71462715e-02f, -2.17577055e-01f, -2.12579183e-02f, 9.61287767e-02f, -1.98713630e-01f, -1.41749695e-01f, 4.06197757e-02f,
  3.19683045e-01f, -3.07811014e-02f, -2.23352879e-01f, -1.90542396e-02f, 6.76862478e-01f, 4.95676361e-02f, -1.15513857e-02f, 4.34668362e-02f, 1.72970489e-01f, 3.06975007e-01f,
  -3.75497878e-01f, 1.49917126e-01f, -1.56376883e-01f, 2.99682487e-02f, 2.16385931e-01f, 2.55174428e-01f, 2.49297116e-02f, 1.98581845e-01f, -2.23297402e-01f, -4.14821319e-03f,
  1.26161650e-01f, -4.17050272e-02f, 1.74358621e-01f, -1.35455534e-01f, -4.18318771e-02f, 9.83824506e-02f, -2.31912971e-01f, 2.30117768e-01f, 3.11065465e-01f, -5.26944436e-02f,
  -2.90652290e-02f, -2.11993158e-01f, 2.19761640e-01f, 3.58117372e-02f, -1.68158233e-01f, 1.51453674e-01f, 6.56902671e-01f, -8.31314102e-02f, 3.11932504e-01f, 2.64582068e-01f,
  2.41452828e-01f, -3.29046637e-01f, 3.36524040e-01f, -1.70013726e-01f, 4.90251631e-02f, -4.61291522e-02f, 6.65251017e-02f, 8.46401230e-02f, 3.18594761e-02f, 2.65019625e-01f,
  1.12430289e-01f, 3.11745614e-01f, 6.99381204e-03f, 3.04550659e-02f, 1.26093507e-01f, 2.32968152e-01f, 2.04986930e-01f, 1.54864311e-01f, -6.06454499e-02f, 1.11532770e-02f,
  1.33361652e-01f, 1.13347881e-01f, 1.03510424e-01f, 1.18850879e-01f, 8.91383588e-02f, -4.21637967e-02f, -1.38804525e-01f, -5.99543611e-03f, -1.39819637e-01f, -2.10914593e-02f,
  1.12649985e-01f, 1.90377459e-01f, 1.65157095e-01f, 1.07251098e-02f, 1.05885416e-02f, -4.05261606e-01f, 4.76519093e-02f, -1.82548583e-01f, 3.87016386e-01f, 7.08002001e-02f,
  9.31048766e-02f, 1.96324781e-01f, -3.12299374e-02f, 1.87348157e-01f, 1.12086289e-01f, 5.66732287e-01f, 3.48699316e-02f, -2.39193454e-01f, -1.02532774e-01f, 2.40738645e-01f,
  -1.62789956e-01f, 1.15928955e-01f, -2.48686165e-01f, 1.78689267e-02f, -1.26936406e-01f, -9.56779122e-02f, -1.65029272e-01f, -1.37603670e-01f, -1.41196083e-02f, -1.94973454e-01f,
  -9.04889405e-02f, -1.44911095e-01f, 3.49662721e-01f, 4.12678450e-01f, 3.49528313e-01f, 3.45646925e-02f, -3.51039231e-01f, 2.69813806e-01f, -8.76342654e-02f, 1.10738039e-01f,
  -1.38307780e-01f, -7.26932734e-02f, 6.21268824e-02f, 9.76219401e-03f, 8.55709543e-04f, -1.50455713e-01f, -1.57237425e-01f, 2.72256345e-01f, 1.33031746e-02f, 1.81044310e-01f,
  -1.13558263e-01f, -1.09343283e-01f, 8.73743370e-02f, 1.32486627e-01f, -1.43015593e-01f, 2.51585454e-01f, 5.19042984e-02f, -4.33270298e-02f, -2.19782963e-01f, 1.27354905e-01f,
  -1.03393592e-01f, -1.45274445e-01f, 2.42593050e-01f, 9.98169035e-02f, 1.35694042e-01f, -1.26960635e-01f, 1.74331591e-01f, -5.39376698e-02f, -9.04870778e-02f, -5.27890660e-02f,
  -1.11778677e-01f, -1.10416539e-01f, -4.90674302e-02f, 1.54988855e-01f, 7.85158500e-02f, 4.69149828e-01f, 1.71988949e-01f, 1.68095216e-01f, 1.60135806e-01f, -2.53614448e-02f,
  2.32969314e-01f, -2.29994193e-01f, 3.13857198e-02f, -1.83970585e-01f, -2.35189229e-01f, -2.02731311e-01f, 4.25110720e-02f, -2.03991994e-01f, 1.56416491e-01f, -1.82275936e-01f,
  1.69811189e-01f, -1.85618043e-01f, 1.51013896e-01f, 1.21842489e-01f, 2.48659924e-01f, 1.09518401e-01f, 1.05324559e-01f, 1.54829383e-01f, 4.08370867e-02f, -1.64687365e-01f,
  -1.20019071e-01f, -7.21172690e-02f, -1.42115444e-01f, -2.30627671e-01f, 8.11517909e-02f, -1.96657345e-01f, -6.43866882e-02f, 5.83809987e-02f, -1.52333781e-01f, 1.04013771e-01f,
  8.98770317e-02f, 5.88311434e-01f, 2.56062806e-01f, -7.75981694e-02f, -1.83521003e-01f, -6.17190860e-02f, -8.01748186e-02f, 6.88650906e-02f, -1.77503601e-01f, 2.47545451e-01f,
  -5.37964441e-02f, -2.67049279e-02f, 9.44472011e-03f, -2.20912620e-02f, 1.86447904e-01f, -3.79428975e-02f, 2.60620922e-01f, -2.19346583e-01f, -1.18092656e-01f, 6.78195758e-03f,
  -6.89097568e-02f, -8.79776627e-02f, 8.74999389e-02f, 7.77665377e-02f, 3.13853174e-02f, 8.44970420e-02f, -1.64523616e-01f, 2.61965930e-01f, -5.17493812e-03f, 1.40721008e-01f,
  6.56253323e-02f, -1.14149274e-02f, -1.17480746e-02f, -1.73327897e-03f, -1.11090623e-01f, -1.66964307e-02f, 2.06107140e-01f, -1.35528773e-01f, 1.71440333e-01f, 3.25677544e-02f,
  1.93114549e-01f, -7.54574537e-02f, 1.79077294e-02f, -1.01076089e-01f, 8.13476220e-02f, 3.79831493e-02f, 5.28750606e-02f, 2.06258416e-01f, 2.00541764e-01f, 1.87142164e-01f,
  7.39678442e-02f, -2.80789673e-01f, -8.88428688e-02f, -1.41791552e-02f, 1.42723203e-01f, 7.62176374e-03f, -1.28750980e-01f, -1.16038829e-01f, -2.41246466e-02f, 4.11758542e-01f,
  1.15633428e-01f, 2.75916666e-01f, -2.52939742e-02f, 7.81695172e-02f, 1.75447047e-01f, 2.21790239e-01f, -3.65059488e-02f, -1.95906281e-01f, 1.82458743e-01f, -9.65328515e-02f,
  4.35565636e-02f, -6.09480264e-03f, -8.85272324e-02f, -2.17190973e-04f, -1.77112639e-01f, -1.18346259e-01f, 2.04126880e-01f, -8.65506660e-03f, 4.29614305e-01f, -1.40468642e-01f,
  -4.23492678e-03f, 2.15205505e-01f, -5.83043993e-02f, 1.79669052e-01f, -1.16344921e-01f, 1.86748177e-01f, -2.77898073e-01f, -9.24634486e-02f, 1.63172513e-01f, -9.02984738e-02f,
  -1.97622348e-02f, 2.00964361e-01f, 1.94923341e-01f, 6.67398125e-02f, -1.02148846e-01f, -1.17909187e-03f, -1.43011287e-01f, 1.94949228e-02f, -1.37366289e-02f, 9.89364646e-03f,
  -8.72724131e-02f, -1.18092857e-01f, 7.45913312e-02f, 1.33314580e-01f, 1.12244654e-02f, 1.27926081e-01f, 1.23661146e-01f, -3.92111689e-02f, 1.39694452e-01f, 8.98851752e-02f,
  -1.48572385e-01f, 1.15331756e-02f, 2.34870732e-01f, 1.60544328e-02f, 2.83167847e-02f, -6.04899004e-02f, 2.55626082e-01f, 6.99481666e-02f, 4.40211922e-01f, 1.13893539e-01f,
  2.21393295e-02f, 5.24348654e-02f, -2.24056184e-01f, 5.16995132e-01f, 7.13461563e-02f, 7.62235105e-01f, 3.74374896e-01f, 3.67464572e-01f, -1.01756990e-01f, -1.03004672e-01f,
  2.81973779e-01f, 1.40685849e-02f, -1.13700248e-01f, -2.35783175e-01f, 7.58261383e-02f, -1.51211351e-01f, 2.21519113e-01f, -2.18977645e-01f, -1.74159184e-01f, 1.79521799e-01f,
  2.36481503e-01f, -4.24635798e-01f, 1.92535967e-02f, -1.54742792e-01f, 1.13521954e-02f, 4.50874537e-01f, -2.11297229e-01f, 4.10771705e-02f, -5.43103740e-02f, -2.04933360e-01f,
  2.71437079e-01f, -6.09253421e-02f, -7.94054344e-02f, -1.69385925e-01f, 2.74834096e-01f, -1.81143612e-01f, 7.20452443e-02f, 1.73722461e-01f, 1.16582148e-01f, 5.80289774e-02f,
  -9.92233828e-02f, 3.03981543e-01f, 8.38109180e-02f, 2.42525637e-02f, 1.49927840e-01f, 3.10559906e-02f, -1.15779519e-01f, 3.51266703e-03f, -1.21523380e-01f, 4.20264862e-02f,
  9.63180661e-02f, -6.46086857e-02f, 6.88995868e-02f, -4.26840074e-02f, 2.30738729e-01f, -1.95240423e-01f, 4.16021682e-02f, -9.72341001e-02f, 9.37539786e-02f, -6.15606010e-02f,
  -1.39988914e-01f, -1.57793462e-01f, -2.38049049e-02f, -1.81809396e-01f, 3.87213118e-02f, 1.01663291e-01f, -1.35111183e-01f, 2.30146244e-01f, 1.96348518e-01f, 2.81048082e-02f,
  -2.27780804e-01f, -1.69749320e-01f, -1.42718339e-02f, 3.06722045e-01f, -4.45709750e-02f, -1.73184082e-01f, 2.18573704e-01f, -1.06524099e-02f, -3.05779018e-02f, 2.99791731e-02f,
  2.25430783e-02f, -1.22046815e-02f, -1.16500735e-01f, -1.03172876e-01f, 7.03950003e-02f, 1.29802138e-01f, 3.20319444e-01f, 7.29392618e-02f, -1.87669061e-02f, 3.39040518e-01f,
  2.33070821e-01f, 1.56660274e-01f, 1.80558458e-01f, -8.66165161e-02f, -1.00963570e-01f, 2.53139913e-01f, -6.06983751e-02f, -1.11591183e-01f, -1.78430319e-01f, -5.36630154e-02f,
  4.35176131e-04f, 6.09785356e-02f, 5.40357567e-02f, 1.68913394e-01f, -8.71212408e-02f, -1.34455338e-01f, 9.09246057e-02f, 1.00807600e-01f, -2.17784904e-02f, -1.22838981e-01f,
  1.61482036e-01f, 1.03162872e-02f, 2.11073026e-01f, 1.43067345e-01f, 3.98756452e-02f, 4.04906608e-02f, 8.90479088e-02f, 8.83476138e-02f, 2.51761172e-02f, -1.45506620e-01f,
  1.29307941e-01f, 9.71187577e-02f, 1.65408909e-01f, 1.53741948e-02f, -4.24093641e-02f, -4.50256430e-02f, -1.45524070e-01f, 1.20322995e-01f, -1.37128711e-01f, -4.57619540e-02f,
  -1.87181726e-01f, -4.09171581e-02f, 8.97192955e-02f, -1.65115342e-01f, 7.39802197e-02f, 1.04438327e-01f, 9.64517668e-02f, -1.59396961e-01f, 1.02092028e-01f, 2.07252294e-01f,
  1.05382614e-01f, -1.39126226e-01f, 6.18107244e-02f, -1.36748955e-01f, 1.58571646e-01f, -5.68488911e-02f, 7.15278015e-02f, -5.77696934e-02f, -1.24422416e-01f, 1.33154187e-02f,
  9.59775150e-02f, 1.39530957e-01f, -1.92348715e-02f, 1.57182559e-01f, -1.32776022e-01f, 1.96661010e-01f, 1.13194687e-02f, -1.54650137e-01f, 4.10775654e-02f, -8.56656954e-02f,
  1.12025090e-01f, 9.89728421e-02f, 2.01831326e-01f, 1.53651327e-01f, 5.33496812e-02f, -7.31423795e-02f, -1.94944218e-01f, -1.66521057e-01f, -5.86528927e-02f, 3.22573483e-01f,
  9.75048020e-02f, -7.07534328e-02f, 9.77001265e-02f, 2.06873879e-01f, -1.89507136e-03f, -2.08751000e-02f, 2.24329010e-02f, 1.57892346e-01f, 9.77504626e-02f, -1.46297783e-01f,
  -2.04707712e-01f, 1.30119711e-01f, -1.81181580e-02f, -1.23425173e-02f, 1.58906356e-01f, -1.24971449e-01f, -5.22905402e-02f, 2.21522301e-01f, -1.22361043e-02f, -1.63238779e-01f,
  -1.22632623e-01f, -7.97882974e-02f, -1.61593422e-01f, 8.62586275e-02f, 2.74095356e-01f, -2.33127236e-01f, -1.08570091e-01f, 1.34728923e-01f, -1.07797839e-01f, 2.95771480e-01f,
  1.32378101e-01f, 1.35077208e-01f, 6.26200885e-02f, -1.76027596e-01f, 1.72027722e-02f, 6.35930523e-02f, 3.66977341e-02f, -1.81014895e-01f, 8.88818726e-02f, -1.04663789e-01f,
  1.74966119e-02f, -3.74577753e-03f, 6.01165555e-02f, 2.11017087e-01f, -2.99459428e-01f, 1.39388084e-01f, 1.01929933e-01f, 2.11654697e-02f, 2.34938279e-01f, 1.73202336e-01f,
  1.31152034e-01f, -2.73376077e-01f, 3.91922176e-01f, -3.10039204e-02f, -6.54643029e-02f, 1.79169178e-01f, -3.09335943e-02f, 1.84696198e-01f, -1.21121652e-01f, 2.78451353e-01f,
  -1.01706550e-01f, 3.10728729e-01f, -1.39019877e-01f, 2.43407413e-01f, 3.17083806e-01f, -5.70176467e-02f, 8.17636326e-02f, -2.28559166e-01f, 1.21468976e-01f, 1.49281102e-03f,
  -2.27631964e-02f, -1.06868163e-01f, 1.49637207e-01f, 1.67608351e-01f, 1.38844579e-01f, 6.99436963e-02f, 1.43272772e-01f, -8.30905363e-02f, -1.42522275e-01f, 2.02591226e-01f,
  6.20715022e-02f, 7.21121281e-02f, 2.92580370e-02f, 1.35513647e-02f, 3.06832224e-01f, -3.16183828e-02f, 9.74067524e-02f, -7.34816641e-02f, -6.89086691e-02f, 1.04838654e-01f,
  1.10487580e-01f, 2.66330242e-01f, 1.67145245e-02f, 2.55144089e-01f, -4.29223068e-02f, 9.61390212e-02f, 3.73091817e-01f, -1.60890415e-01f, -9.57291126e-02f, -4.43096980e-02f,
  1.92740828e-01f, 1.35920867e-01f, -1.16190389e-01f, -1.99793711e-01f, -9.64954942e-02f, -4.08400781e-02f, 1.90160409e-01f, 7.84426630e-02f, -1.25610605e-01f, 4.31402214e-02f,
  -3.78909707e-02f, 2.06415609e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.11889338e-01f, 2.09282026e-01f, 2.97692865e-02f, 2.04463989e-01f, 2.90333778e-02f, 3.31940055e-01f, 2.50353932e-01f, 2.48824269e-01f, 3.26256931e-01f, 1.31957799e-01f,
  1.63797423e-01f, 2.51565576e-01f, 5.09881862e-02f, 3.52300674e-01f, -7.27432817e-02f, -2.18604907e-01f, -1.24956844e-02f, 3.02613556e-01f, 9.62102115e-02f, -3.30023505e-02f,
  -2.58304849e-02f, 3.11643351e-02f, -7.04482123e-02f, 1.38177305e-01f, 2.44695082e-01f, -1.88329890e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.16545925e-01f, -3.09240758e-01f, -2.12288976e-01f, -4.68363687e-02f, 6.52575344e-02f, 1.83127031e-01f, -5.46929874e-02f, 1.87926352e-01f, -2.69443374e-02f, -2.62172461e-01f,
  4.55465764e-02f, 1.71279386e-01f, -1.91423342e-01f, -2.38609061e-01f, -3.17889184e-01f, 6.30094707e-02f, -6.85134763e-03f, -1.04784407e-01f, -9.05613974e-02f, -2.00129766e-02f,
  1.89242333e-01f, -1.10714883e-01f, -1.73055619e-01f, -9.41999480e-02f, 1.28894567e-01f, 1.20783202e-01f, -4.56160940e-02f, -1.39181772e-02f, 1.20498426e-01f, 2.24731758e-01f,
  2.53654182e-01f, 5.16264699e-02f, -8.99216235e-02f, -3.04962486e-01f, -5.14750004e-01f, -1.83224246e-01f, -3.50689664e-02f, 2.05561575e-02f, -1.01900212e-01f, 9.81015116e-02f,
  6.36304021e-02f, -2.24988669e-01f, 6.40192404e-02f, 2.67250866e-01f, -1.23592265e-01f, -1.72028109e-01f, 1.36131588e-02f, 8.61035287e-02f, 1.24850962e-02f, -2.74038792e-01f,
  7.51579255e-02f, -1.19978257e-01f, -5.89819551e-02f, -2.05810174e-01f, -5.60854562e-02f, -1.75429329e-01f, -6.88990578e-03f, 8.34440514e-02f, -2.14790374e-01f, -6.90704063e-02f,
  -9.44194943e-02f, 5.50289750e-02f, 2.37072289e-01f, 2.48880133e-01f, -1.77761763e-01f, -5.41612357e-02f, -2.08473578e-01f, 1.62431061e-01f, -6.35194853e-02f, 1.51462153e-01f,
  3.01264059e-02f, 2.07293436e-01f, 3.12579870e-01f, -2.41309807e-01f, 1.51450872e-01f, 1.03023104e-01f, -1.71344385e-01f, -1.94264844e-01f, -1.98555484e-01f, -3.73061746e-02f,
  8.95201638e-02f, -1.98499516e-01f, -1.93599790e-01f, -6.36319816e-02f, 1.17122874e-01f, 7.37026408e-02f, -7.36471191e-02f, -2.10921243e-01f, 9.42071527e-02f, 7.35406876e-02f,
  -1.86936427e-02f, -1.86818093e-01f, 2.08848849e-01f, 1.14158258e-01f, 1.94460377e-01f, 2.19237894e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.27967631e-02f, 3.48970175e-01f, 3.46932858e-01f, 1.93107411e-01f, 2.58229017e-01f, -1.93785369e-01f, 4.86617625e-01f, 1.54237658e-01f, -2.07784355e-01f, -5.60745448e-02f,
  2.41968870e-01f, 1.71128437e-01f, 9.69006307e-03f, -1.86040848e-01f, -2.30280031e-02f, 1.75299972e-01f, 1.33298144e-01f, 2.59055614e-01f, -1.50028333e-01f, 3.41765373e-03f,
  -2.73757339e-01f, -2.74906605e-01f, -9.64531004e-02f, -3.10489446e-01f, -7.95440376e-02f, -1.97324857e-01f, -3.56826596e-02f, -1.02232685e-02f, 9.05337781e-02f, 1.09757353e-02f,
  3.46307270e-02f, -4.91139069e-02f, 1.57440320e-01f, 2.99994498e-02f, 9.53399092e-02f, -3.31125200e-01f, -1.25895515e-01f, 2.04677299e-01f, 8.07987377e-02f, 9.02438238e-02f,
  7.77228177e-02f, 1.55730695e-01f, -3.42142745e-03f, 1.22079201e-01f, 1.55170262e-01f, -1.09496921e-01f, 1.70993409e-03f, 8.74195769e-02f, -1.06712952e-01f, -1.13759696e-01f,
  -1.33275226e-01f, -1.42298130e-04f, 9.10733715e-02f, -1.35934532e-01f, 1.93042345e-02f, 2.95480579e-01f, 2.05571651e-01f, -1.00099608e-01f, -7.43477270e-02f, -9.40677598e-02f,
  -1.62183046e-01f, -9.14538875e-02f, 2.27605432e-01f, -7.59567097e-02f, -1.02762185e-01f, -9.05054510e-02f, -1.36219367e-01f, 2.39789963e-01f, 8.10054913e-02f, -1.82977453e-01f,
  3.31577450e-01f, 7.57022947e-02f, -9.91683826e-02f, 4.57649492e-02f, 3.55147086e-02f, -1.47295386e-01f, 3.29301544e-02f, 2.08987907e-01f, 1.33972630e-01f, -2.31823191e-01f,
  2.12895527e-01f, -1.59507960e-01f, 6.78922012e-02f, 2.38408923e-01f, -3.98832075e-02f, 2.40404278e-01f, 8.60134512e-02f, -1.02053717e-01f, 2.67302930e-01f, 1.74818069e-01f,
  -1.81340441e-01f, 1.06800348e-01f, 1.26490489e-01f, 9.74492729e-02f, -2.36893505e-01f, 4.01747748e-02f, -1.85382187e-01f, -1.10387385e-01f, 1.29600510e-01f, 3.74196805e-02f,
  3.48283239e-02f, 1.65228620e-01f, -1.92221776e-01f, -3.21102701e-02f, -1.18541278e-01f, 3.16814855e-02f, 9.00773406e-02f, 1.93395540e-01f, -4.52875085e-02f, -2.67577227e-02f,
  -4.56002131e-02f, 1.49214372e-01f, 1.05022132e-01f, -7.91519508e-02f, 1.42845228e-01f, -5.53864874e-02f, -3.41325905e-03f, -1.85368210e-02f, 1.95492040e-02f, 3.14754367e-01f,
  7.03354701e-02f, -5.45827672e-02f, -1.47517309e-01f, 2.64753532e-02f, 1.05959944e-01f, -9.57054198e-02f, -1.24216713e-01f, 1.13704279e-01f, 6.74912781e-02f, 4.27480824e-02f,
  2.01611444e-01f, -5.64662755e-01f, -3.13264728e-01f, 8.09057057e-02f, -3.88285629e-02f, 2.94736683e-01f, -6.38494045e-02f, -2.45436206e-01f, -2.49081284e-01f, 4.47822690e-01f,
  -1.24518119e-01f, -9.10482258e-02f, -2.33055428e-01f, 4.03205425e-01f, -1.33163035e-02f, -3.14896107e-01f, 3.58208388e-01f, -1.67812705e-02f, -1.28666824e-02f, 1.56414136e-01f,
  -2.47679025e-01f, 6.64820731e-01f, 2.54299104e-01f, -1.75510630e-01f, 3.53195076e-03f, 1.45093024e-01f, -3.12680632e-01f, -5.05063199e-02f, 4.20288444e-01f, 3.87728959e-01f,
  -1.36663526e-01f, 3.65011394e-02f, 3.21735777e-02f, 2.64206469e-01f, -3.03311527e-01f, -2.97160625e-01f, 2.87327468e-01f, 1.45047605e-01f, -2.08079308e-01f, -7.33842030e-02f,
  -2.81996727e-01f, 2.82063127e-01f, -1.53518721e-01f, 4.06870544e-01f, 3.34692776e-01f, 1.25107527e-01f, 5.00015855e-01f, -1.87789798e-01f, 3.08708727e-01f, 3.31916004e-01f,
  -1.50345922e-01f, 1.26752824e-01f, -1.15745990e-02f, -3.42670851e-03f, 1.11008979e-01f, -3.74297351e-02f, -1.74538851e-01f, -2.25447789e-01f, 1.60135049e-02f, 1.66934684e-01f,
  -2.96891928e-02f, 2.43082549e-02f, -7.70212114e-02f, -1.77174076e-01f, -5.12196757e-02f, 9.33342800e-02f, -8.90944898e-02f, -8.56628455e-03f, -1.47882834e-01f, -3.40383202e-02f,
  -3.53588350e-03f, 1.31898940e-01f, 1.98577847e-02f, 2.99964752e-02f, -4.32435870e-02f, 3.29915509e-02f, 1.11675382e-01f, -3.43868956e-02f, -2.50735372e-01f, 1.67350441e-01f,
  2.40066960e-01f, -2.01384082e-01f, 6.72242790e-02f, 3.45793441e-02f, -1.08073549e-02f, 3.73636127e-01f, -1.44443482e-01f, 5.72455451e-02f, 2.05049559e-01f, 2.44704187e-02f,
  7.19249547e-02f, 1.44351974e-01f, 1.41318843e-01f, 1.10169575e-01f, 1.24407418e-01f, -6.36543473e-03f, -7.19863251e-02f, 8.29504728e-02f, -3.65456454e-02f, -5.82245365e-02f,
  1.89769074e-01f, 2.62161624e-02f, -2.31019943e-03f, 1.96148500e-01f, 1.45424247e-01f, -1.35447294e-01f, -1.48564607e-01f, 1.67327464e-01f, 1.28480315e-01f, 3.59256715e-02f,
  -2.53251754e-02f, 7.89510384e-02f, -2.69859787e-02f, 2.32400149e-01f, 1.73971623e-01f, 1.17309606e-02f, -1.04366124e-01f, -2.25583494e-01f, 1.51451603e-01f, 1.04043312e-01f,
  -1.04671875e-02f, -8.99987966e-02f, -1.33640289e-01f, 5.72938249e-02f, -2.36477740e-02f, -1.27325179e-02f, 2.39519104e-01f, 2.27960438e-01f, -3.84385288e-02f, -1.48140356e-01f,
  -1.81608289e-01f, -6.83634430e-02f, 1.85165584e-01f, -2.14283228e-01f, -9.24595520e-02f, 3.55234385e-01f, -4.36226614e-02f, -1.44253433e-01f, 2.52603531e-01f, 3.48990619e-01f,
  2.09437802e-01f, -1.29902050e-01f, -1.32015556e-01f, 1.00195393e-01f, 6.42912388e-02f, 1.35938391e-01f, -5.23165986e-02f, 1.54909762e-02f, -4.41568345e-03f, -4.39387672e-02f,
  -8.43020156e-03f, -6.32043406e-02f, 1.33379415e-01f, -1.40225828e-01f, 2.37599239e-02f, 1.13710396e-01f, 7.24860653e-02f, 6.04825430e-02f, -1.10351719e-01f, 4.83430438e-02f,
  8.71853530e-03f, -1.21350572e-01f, 2.04466417e-01f, 1.85176551e-01f, -1.41110897e-01f, 2.08541259e-01f, 4.40604150e-01f, -2.39067022e-02f, -1.89836379e-02f, -1.27561644e-01f,
  -1.31830098e-02f, 6.69444446e-03f, 1.12414323e-01f, -2.04582378e-01f, -3.44386585e-02f, 5.63071594e-02f, 3.07195365e-01f, 1.20994806e-01f, -3.77031155e-02f, 3.47184956e-01f,
  2.58171298e-02f, 4.25889678e-02f, 3.50880399e-02f, 2.75582731e-01f, 1.01191804e-01f, -9.07276496e-02f, -1.75952375e-01f, -1.72365546e-01f, 1.38556257e-01f, -7.61577394e-03f,
  3.70965675e-02f, 4.49875325e-01f, 1.72873735e-01f, 4.48088765e-01f, 3.18931907e-01f, -1.79804981e-01f, 4.17931706e-01f, 1.08049102e-01f, -9.19742435e-02f, -1.31134614e-01f,
  2.25856289e-01f, 3.11683565e-01f, -1.57888576e-01f, -7.57202655e-02f, 4.16239053e-02f, 1.63263604e-02f, 3.09359312e-01f, 3.14942807e-01f, -1.27481461e-01f, 3.66192758e-01f,
  1.47347733e-01f, -4.60779630e-02f, 3.29665169e-02f, -2.90872544e-01f, 1.51951134e-01f, 2.86558390e-01f, -1.18157387e-01f, -3.08078472e-02f, 1.67881235e-01f, 2.35242769e-01f,
  1.99096739e-01f, 1.18635938e-01f, -6.47673532e-02f, 5.50334677e-02f, -1.78284883e-01f, 2.10761324e-01f, 4.69081998e-02f, 1.37397289e-01f, 1.18170351e-01f, -3.14526074e-03f,
  -5.35782017e-02f, 1.73085239e-02f, 4.46224250e-02f, 2.27502555e-01f, -2.13583633e-02f, -2.56402969e-01f, -2.02673331e-01f, 1.88546821e-01f, -7.33094960e-02f, 8.28919262e-02f,
  -1.80619404e-01f, 2.42759332e-01f, 2.16336939e-02f, 1.66554935e-02f, -4.37136590e-02f, -1.71124831e-01f, 2.44779363e-01f, -9.08664316e-02f, -1.00603141e-01f, 7.55506083e-02f,
  1.24996230e-01f, -6.79099485e-02f, -1.25456564e-02f, -3.06864567e-02f, 3.51857901e-01f, 2.87882000e-01f, 4.34159100e-01f, 3.79534483e-01f, 3.20965886e-01f, -5.07511377e-01f,
  6.90020263e-01f, 8.26578289e-02f, -4.13317829e-01f, 1.30449116e-01f, 3.88001055e-01f, 4.39128637e-01f, 5.01787616e-03f, -2.55671561e-01f, 5.64575940e-03f, 3.26972276e-01f,
  1.04061723e-01f, 2.73107767e-01f, -2.19960153e-01f, 4.28425133e-01f, -3.19336444e-01f, -4.02231961e-01f, -1.10203832e-01f, -3.98867011e-01f, -3.64138335e-02f, -2.58861423e-01f,
  2.03852057e-01f, 9.24221426e-02f, 1.72860309e-01f, 1.81893110e-01f, 2.01977700e-01f, 8.12406614e-02f, -2.79469900e-02f, 3.43735293e-02f, 8.87196437e-02f, 4.18045111e-02f,
  7.20520467e-02f, -1.20045863e-01f, 1.61077529e-02f, 4.23380435e-01f, 2.83614248e-01f, 2.96050049e-02f, 1.24857407e-02f, 3.70403469e-01f, -1.64672375e-01f, -1.46048695e-01f,
  -3.05196881e-01f, 1.94824144e-01f, 2.96719551e-01f, 3.47236805e-02f, 5.53936474e-02f, 1.23569809e-01f, 1.26947284e-01f, 1.09015286e-01f, 6.32020086e-02f, 5.46991937e-02f,
  1.31060094e-01f, 6.84569106e-02f, -2.21336231e-01f, -1.59179389e-01f, 1.45877227e-01f, -1.96823135e-01f, 1.94129527e-01f, 7.78608248e-02f, 5.04980907e-02f, -2.20720787e-02f,
  6.27201274e-02f, 2.03089672e-03f, -2.21059084e-01f, 9.28983018e-02f, 2.00390667e-01f, -8.68064836e-02f, -1.62177607e-01f, 3.94867688e-01f, -1.33811280e-01f, -8.13599899e-02f,
  2.01485027e-02f, 5.61592042e-01f, 6.74892604e-01f, -2.34688669e-01f, 8.61557128e-05f, 8.49337354e-02f, 1.54024661e-01f, 1.08706258e-01f, 1.62277788e-01f, -4.88513298e-02f,
  2.88968951e-01f, 8.28753114e-02f, 7.93534219e-02f, 1.02468312e-01f, -7.65181482e-02f, 8.93259645e-02f, -4.42583747e-02f, -6.30437676e-03f, -4.97483723e-02f, -1.20075293e-01f,
  -2.43050512e-02f, -2.16239795e-01f, -2.22568899e-01f, 1.98288694e-01f, 2.06482053e-01f, 1.93209574e-01f, -1.62533239e-01f, 3.11121903e-02f, 3.99268478e-01f, 1.88881651e-01f,
  2.18589767e-03f, -5.56928664e-02f, 9.47232023e-02f, -9.00471509e-02f, 1.66199967e-01f, 1.16184846e-01f, -3.37876491e-02f, 6.30013719e-02f, 1.69204976e-02f, -2.73308039e-01f,
  2.15712234e-01f, 3.01268578e-01f, 2.64172833e-02f, 2.13940099e-01f, 2.42820419e-02f, 3.19604486e-01f, 1.18143916e-01f, -2.05322746e-02f, -3.89938764e-02f, -2.20770150e-01f,
  8.17093104e-02f, 2.36005157e-01f, 1.34659037e-01f, 2.13359445e-01f, 4.09761220e-02f, 3.16721983e-02f, -1.25933737e-01f, 4.88863289e-02f, 1.73139453e-01f, -2.16388479e-01f,
  1.03089288e-02f, 3.98824692e-01f, -2.44495168e-01f, 2.07847282e-01f, 9.55975652e-02f, 5.45723379e-01f, 3.07030112e-01f, -5.64954020e-02f, -1.50522158e-01f, 1.46497875e-01f,
  1.56943664e-01f, 8.40922073e-02f, -5.44759147e-02f, 2.16780067e-03f, 1.26624033e-01f, 4.83668119e-01f, -2.19308868e-01f, -6.47040978e-02f, 5.21999672e-02f, -5.47278970e-02f,
  -6.79697609e-03f, -4.58173864e-02f, 9.62792262e-02f, 1.41035214e-01f, -2.48223301e-02f, -7.71369711e-02f, -1.57203361e-01f, 1.93119179e-02f, 6.07109927e-02f, 5.46018966e-02f,
  1.03057683e-01f, 3.11716720e-02f, -2.33802050e-01f, 9.40778181e-02f, 5.08869663e-02f, 2.51887679e-01f, -1.82690397e-02f, 1.75633490e-01f, 1.47631735e-01f, 1.34932980e-01f,
  1.71916500e-01f, -1.63557455e-01f, 1.61120277e-02f, -1.03285432e-01f, 5.98305576e-02f, -4.67521511e-02f, -1.76169962e-01f, 7.96020851e-02f, 2.23584279e-01f, 1.26923099e-01f,
  -8.56843069e-02f, 2.34774705e-02f, 6.34935359e-03f, 2.33050331e-01f, -6.14667796e-02f, 2.34025419e-01f, 5.20997085e-02f, -1.78504735e-02f, 5.98053969e-02f, 9.72294882e-02f,
  -4.31101881e-02f, 2.11637825e-01f, 2.99611926e-01f, 3.56798857e-01f, 1.84348106e-01f, -2.07823515e-01f, -1.70226708e-01f, 2.62114733e-01f, -2.98252013e-02f, -1.47398412e-01f,
  -2.18736961e-01f, 7.66282007e-02f, 3.08828205e-01f, -2.55678624e-01f, -1.68173946e-02f, 1.67666357e-02f, -5.26827527e-03f, 1.22596338e-01f, 2.50053834e-02f, 2.25677118e-02f,
  1.73141643e-01f, 3.06330651e-01f, 4.81847599e-02f, 7.39757577e-03f, 7.21025616e-02f, 3.55073996e-02f, 2.74536759e-01f, -1.00888848e-01f, -1.30479574e-01f, 1.78873360e-01f,
  -3.10205277e-02f, 5.12303561e-02f, 4.21653055e-02f, 5.45900688e-02f, 1.21066146e-01f, 2.26692617e-01f, 3.37510519e-02f, 2.40754336e-02f, -3.46100219e-02f, -5.83421588e-02f,
  -1.86981276e-01f, 5.84606081e-02f, -8.46482143e-02f, -1.87727347e-01f, -1.86974555e-02f, -2.55938135e-02f, 1.62837237e-01f, 1.78841040e-01f, -1.34261921e-01f, 2.72871017e-01f,
  -1.36546627e-01f, 5.57779009e-03f, 2.93742210e-01f, 4.75265943e-02f, -1.97365418e-01f, -7.70158470e-02f, 2.25259215e-01f, -1.83712676e-01f, -6.51423708e-02f, 8.35990086e-02f,
  -1.02429010e-01f, -7.51930848e-02f, -2.38137320e-01f, 8.07326138e-02f, -1.10464118e-01f, 1.83239877e-01f, -3.10541689e-01f, -3.83980386e-02f, 6.31420910e-02f, 1.79957524e-01f,
  -1.84476495e-01f, 9.66183394e-02f, -3.84985507e-02f, 2.21707255e-01f, 2.36138731e-01f, 1.85256824e-01f, -1.37328014e-01f, -1.48919716e-01f, -9.37810913e-02f, -1.39837012e-01f,
  3.22334729e-02f, 1.91338614e-01f, -1.17513254e-01f, 2.14429274e-02f, -1.78030767e-02f, 2.42079757e-02f, 7.28747323e-02f, -1.26086742e-01f, 8.56957808e-02f, -9.44810137e-02f,
  6.38822839e-02f, 1.02597818e-01f, -3.00873406e-02f, 1.32942885e-01f, 2.68139511e-01f, 2.39262447e-01f, 2.15922296e-02f, -1.54838756e-01f, 2.72247463e-01f, 1.19360089e-01f,
  -9.03901383e-02f, -1.58446267e-01f, -8.74965414e-02f, 2.77243406e-01f, -1.56801686e-01f, -4.66692698e-04f, 2.67898217e-02f, -9.02236067e-03f, 2.44809121e-01f, 1.79130614e-01f,
  -1.59595951e-01f, 2.23971561e-01f, 3.18276463e-03f, -2.35485405e-01f, 6.49187639e-02f, -1.56046152e-01f, 1.83040529e-01f, -9.23772305e-02f, 4.34906688e-03f, 1.77817214e-02f,
  1.17097944e-01f, 1.74992681e-01f, -7.38361701e-02f, 9.67754498e-02f, 1.38605431e-01f, 1.39720151e-02f, -9.98494774e-03f, -3.65919173e-01f, -9.14905369e-02f, 3.62570226e-01f,
  -1.20837353e-01f, 1.07534349e-01f, 1.04992785e-01f, -1.53859397e-02f, -1.57100439e-01f, 2.38439262e-01f, -1.63147628e-01f, 4.61238772e-02f, -2.77781337e-01f, 2.18894854e-01f,
  -5.42674735e-02f, 1.69735476e-01f, -1.60005726e-02f, -8.05733129e-02f, 2.63782479e-02f, 1.96618572e-01f, -1.24516085e-01f, 5.98304152e-01f, -8.67506638e-02f, 1.54215038e-01f,
  2.18581129e-02f, 1.39007121e-01f, 1.29572982e-02f, -1.76803529e-01f, 3.28142852e-01f, 3.04046631e-01f, 1.42241260e-02f, -1.57391801e-01f, -3.12223565e-03f, -2.73811817e-01f,
  -3.10584337e-01f, 3.98346819e-02f, -2.24235784e-02f, 2.74180025e-01f, -5.45624606e-02f, -8.42026901e-03f, -1.66746005e-01f, 2.67331421e-01f, -1.00996777e-01f, -7.25207180e-02f,
  -5.81107996e-02f, 1.95032030e-01f, 2.19866514e-01f, -1.72352001e-01f, 3.14054221e-01f, 4.53663170e-02f, 2.36911718e-02f, 8.95957500e-02f, -1.62473187e-01f, 2.88493246e-01f,
  4.75606956e-02f, -8.61167014e-02f, 8.53400156e-02f, -1.66184306e-01f, -1.64673820e-01f, 2.36367568e-01f, 3.68031144e-01f, 2.78549612e-01f, 7.33190179e-02f, -5.56728430e-02f,
  2.19563976e-01f, -2.63587590e-02f, -3.06834966e-01f, 1.17307261e-01f, -2.69959003e-01f, -1.90378949e-01f, 4.18089069e-02f, -3.25867310e-02f, 1.07488640e-01f, 3.50805014e-01f,
  -1.46642178e-01f, 2.09639996e-01f, -5.96994534e-02f, 1.28718600e-01f, -2.88655192e-01f, -1.14569686e-01f, 2.67365217e-01f, -2.45320842e-01f, 1.44517168e-01f, -1.12184547e-01f,
  -1.86593309e-01f, 5.09858847e-01f, -5.57199381e-02f, -2.05908492e-01f, 2.81300277e-01f, 4.30902205e-02f, -6.92133084e-02f, -1.86516368e-03f, 1.14597052e-01f, 1.34561747e-01f,
  -1.24952644e-01f, 9.96805951e-02f, -8.60788152e-02f, -2.58943550e-02f, 7.15757385e-02f, 9.17310547e-03f, 1.10587105e-01f, -8.93105417e-02f, 2.09519997e-01f, 3.48387025e-02f,
  -5.74857108e-02f, -4.55675572e-02f, -4.05663736e-02f, -1.15641922e-01f, -8.85829180e-02f, 1.68382406e-01f, 2.59985507e-01f, -7.29148313e-02f, 1.14593320e-01f, 7.10483491e-02f,
  9.30619240e-02f, 4.85211909e-02f, 1.23717137e-01f, 1.83866099e-01f, 1.52537361e-01f, -4.11795871e-03f, -3.74227576e-02f, -1.44899562e-01f, 1.21689282e-01f, -2.04882205e-01f,
  -5.82564101e-02f, -7.86685497e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  2.94433236e-01f, -1.10478826e-01f, 2.05513574e-02f, -1.46174625e-01f, 4.33530807e-02f, -9.02792588e-02f, -4.82804999e-02f, -1.14950813e-01f, 1.78752959e-01f, -6.53452575e-02f,
  1.13583483e-01f, -2.89828442e-02f, 4.90447521e-01f, -5.55650145e-02f, 1.50296271e-01f, -8.27685148e-02f, 1.35510042e-01f, -6.35683537e-02f, -1.72295541e-01f, 1.25174269e-01f,
  -2.58223508e-02f, 4.70222458e-02f, 2.43660882e-01f, 3.92206460e-02f, 2.23460063e-01f, -3.41379605e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.17663908e-01f, -2.74218768e-01f, -9.71155390e-02f, -1.81982845e-01f, -3.66940312e-02f, -3.35347325e-01f, -3.79240125e-01f, 1.70117423e-01f, 1.31415769e-01f, -1.24297589e-01f,
  -4.99053508e-01f, 8.12341124e-02f, 2.37221569e-01f, 7.24434182e-02f, 4.93241578e-01f, 8.73619765e-02f, -3.52314442e-01f, -6.09900877e-02f, -5.38486362e-01f, -4.74913031e-01f,
  6.38394892e-01f, 1.38450250e-01f, 4.59840447e-01f, -1.42934516e-01f, -3.07313919e-01f, -9.00054872e-02f, 1.99203745e-01f, -3.07326376e-01f, -3.08920413e-01f, -3.06199789e-01f,
  -4.01186273e-02f, -1.79246366e-01f, 1.71386421e-01f, 1.20074287e-01f, -3.01270466e-02f, -4.56811219e-01f, -2.43028075e-01f, -1.25460744e-01f, -2.19206318e-01f, 6.74107149e-02f,
  -3.34150583e-01f, 1.06596887e-01f, 1.45904973e-01f, 4.30443883e-02f, 4.60295945e-01f, -2.33757347e-01f, 5.23030758e-02f, 1.39677659e-01f, -4.83890563e-01f, 7.98139200e-02f,
  -5.54249585e-01f, -3.01717948e-02f, 1.78696528e-01f, 4.29261565e-01f, 9.11488608e-02f, 1.63763449e-01f, -6.86805546e-02f, -2.59375334e-01f, 4.22319442e-01f, -3.25927883e-01f,
  2.56088823e-01f, 3.01658303e-01f, 4.12560612e-01f, -8.49551186e-02f, 7.65465975e-01f, 6.89237833e-01f, 7.35229015e-01f, 1.14865877e-01f, -1.97056875e-01f, 6.49293125e-01f,
  3.62361133e-01f, -2.57270157e-01f, -2.31464982e-01f, -3.89839038e-02f, -2.26167992e-01f, 4.60852504e-01f, -2.16216654e-01f, 5.54851480e-02f, -1.27323285e-01f, -6.18375614e-02f,
  3.14529777e-01f, -5.96480332e-02f, 3.80731821e-01f, 3.15826178e-01f, -7.91226253e-02f, -4.13224325e-02f, 1.65071771e-01f, -1.13204114e-01f, -2.53562238e-02f, -1.93573102e-01f,
  -3.59184891e-02f, 3.71924371e-01f, -2.70860851e-01f, -1.30653739e-01f, -6.89827139e-03f, 4.08214815e-02f, -1.50950067e-02f, -8.80883113e-02f, 3.26188743e-01f, -5.64064860e-01f,
  -1.47494301e-01f, -2.18552500e-01f, -1.96534470e-01f, -1.83120042e-01f, 2.98735231e-01f, -1.60062119e-01f, -4.40109670e-01f, 3.74827087e-01f, 5.95947504e-02f, -1.25134751e-01f,
  -2.30714194e-02f, 1.68754801e-01f, 2.23501176e-01f, 4.72171530e-02f, -2.00404286e-01f, 4.99103405e-02f, 2.23742515e-01f, 1.41700804e-01f, 3.11107725e-01f, -1.19544216e-01f,
  1.92911983e-01f, 3.99979532e-01f, -3.93412933e-02f, -1.10087648e-01f, 1.21630557e-01f, -1.51394203e-01f, -4.34617192e-01f, 1.55141756e-01f, -4.17934239e-01f, -2.84396440e-01f,
  1.78917702e-02f, -2.79374123e-01f, -2.56081134e-01f, -2.07904190e-01f, 2.06849396e-01f, -7.90055394e-02f, 4.83751237e-01f, -6.02698103e-02f, -5.35846353e-01f, 3.48299414e-01f,
  -1.28751472e-01f, 2.85658002e-01f, 2.51928389e-01f, -1.63738027e-01f, 3.25099498e-01f, 6.23723045e-02f, 4.21702087e-01f, -4.29925770e-01f, 2.21101254e-01f, -1.88138649e-01f,
  -1.58336669e-01f, -4.61211987e-02f, -3.70910555e-01f, 8.41643438e-02f, 1.12358645e-01f, 2.82032698e-01f, -4.32997555e-01f, -4.29496437e-01f, -2.15229541e-01f, 9.23572332e-02f,
  4.12301391e-01f, 2.32982174e-01f, 3.46245855e-01f, -1.98441163e-01f, -3.00440162e-01f, -5.43923199e-01f, -1.50104582e-01f, 2.49337107e-01f, -2.83232868e-01f, -1.39716625e-01f,
  1.95107102e-01f, -2.32916981e-01f, 8.77891183e-02f, 1.01290075e-02f, 3.37673157e-01f, 3.98781151e-03f, 1.50852308e-01f, -2.07178861e-01f, 2.83606619e-01f, -1.17279723e-01f,
  9.50204954e-02f, -3.63960087e-01f, 4.42664921e-01f, 9.59095210e-02f, -8.83042440e-02f, 1.95332617e-02f, -2.78169662e-01f, 1.01814203e-01f, 1.87529132e-01f, 1.36927485e-01f,
  3.03729773e-01f, -2.35473722e-01f, -1.91914648e-01f, -4.00324374e-01f, -3.51859063e-01f, 4.26222503e-01f, 7.45215356e-01f, 3.91092151e-01f, 1.46174923e-01f, 2.06918478e-01f,
  -8.85614473e-03f, -5.76555952e-02f, 3.20165753e-01f, 2.19841510e-01f, -8.24919045e-02f, -1.10972241e-01f, -7.48839974e-02f, -4.29409176e-01f, 2.79520117e-02f, 2.96027899e-01f,
  3.05563122e-01f, 3.52093652e-02f, -2.96700358e-01f, -2.20023051e-01f, -2.93545425e-01f, 1.90713838e-01f, 2.14244738e-01f, 1.18947685e-01f, -5.88991046e-02f, 8.56858492e-02f,
  -4.61960919e-02f, 3.07958961e-01f, -3.33612084e-01f, -1.86934084e-01f, -6.77271664e-01f, -4.86985147e-01f, -6.88164532e-01f, 2.66442567e-01f, 3.14928055e-01f, -1.33401528e-01f,
  -2.85707921e-01f, 2.15446860e-01f, -1.52636454e-01f, -1.68355510e-01f, 1.06758930e-01f, -2.66223282e-01f, -8.51550773e-02f, 2.49650888e-02f, -1.49360552e-01f, 5.47447383e-01f,
  1.61559567e-01f, 2.06932425e-01f, -5.58293104e-01f, 3.60179901e-01f, -2.41926536e-01f, 4.62625980e-01f, -1.87064126e-01f, -1.35531604e-01f, 3.48030299e-01f, 1.85760692e-01f,
  -8.54595192e-03f, -1.80395499e-01f, 3.79986972e-01f, 1.75119509e-04f, -1.56746030e-01f, 1.27384067e-01f, 1.48913532e-01f, 3.61201316e-01f, 2.79661953e-01f, 7.85081983e-01f,
  4.05723870e-01f, 2.00384021e-01f, -1.77625969e-01f, 2.77916253e-01f, 8.31140950e-03f, 2.23485261e-01f, 7.47308135e-01f, -4.31168735e-01f, 2.04626009e-01f, -1.54370502e-01f,
  -2.75785506e-01f, -9.81419384e-02f, -5.26278317e-01f, -1.37940809e-01f, -6.19695783e-01f, -8.89137760e-02f, -5.46689868e-01f, 9.62547362e-02f, -1.96606651e-01f, -2.13405073e-01f,
  -2.49072304e-03f, -4.19474393e-02f, 1.48920640e-01f, -4.41250876e-02f, 6.45667851e-01f, 1.12952910e-01f, 4.77983057e-01f, 8.95427689e-02f, -7.22635463e-02f, 5.02059102e-01f,
  -5.69077194e-01f, 6.25101864e-01f, 5.19419074e-01f, 3.80646527e-01f, 2.92026311e-01f, -1.08666085e-01f, 1.78372771e-01f, -1.65678769e-01f, -4.46793526e-01f, 4.90030088e-02f,
  -6.12832718e-02f, 2.36772951e-02f, -1.30636230e-01f, 1.57334551e-01f, 4.60814476e-01f, 3.42073619e-01f, 3.02277476e-01f, 2.70605862e-01f, -4.71994281e-01f, -5.83450831e-02f,
  -6.55027092e-01f, -1.36193121e-02f, 4.79515463e-01f, 1.97772264e-01f, 8.67919549e-02f, 3.41741085e-01f, -4.11712855e-01f, -1.77452102e-01f, -2.02650055e-01f, 9.65067223e-02f,
  5.34041166e-01f, 1.35171399e-01f, 5.60452938e-01f, -5.85849762e-01f, -8.73623192e-01f, -1.28980979e-01f, 6.65408254e-01f, 1.88537072e-02f, -1.33496046e-01f, -8.74271318e-02f,
  -5.29051006e-01f, -6.26563191e-01f, 3.38847525e-02f, 2.76431981e-02f, 3.94398831e-02f, -1.95524544e-01f, 3.13172072e-01f, 1.75631031e-01f, 9.91808712e-01f, -2.50526160e-01f,
  -2.05441698e-01f, -5.84792392e-03f, -2.03479514e-01f, -3.47190082e-01f, -4.38447058e-01f, -9.36959907e-02f, -2.11612865e-01f, 8.28348473e-02f, -7.13985562e-02f, -5.30067325e-01f,
  -5.98336272e-02f, -1.59337208e-01f, -1.84231028e-01f, -1.53106511e-01f, -3.13253611e-01f, 3.97797406e-01f, 6.21994734e-01f, 5.10071754e-01f, -1.27697244e-01f, 1.23588163e-02f,
  1.73263997e-01f, 1.67256251e-01f, 6.54135406e-01f, 4.63227868e-01f, -4.16849405e-02f, -8.80462229e-02f, -1.11190468e-01f, 1.62310019e-01f, -3.72024298e-01f, -1.94533005e-01f,
  -3.18553001e-01f, 1.28693609e-02f, -5.66241778e-02f, -3.34001869e-01f, -1.05071932e-01f, 1.59512714e-01f, -1.66049488e-02f, 9.85892564e-02f, 1.32969301e-02f, -1.19330861e-01f,
  -2.41644271e-02f, 4.01815027e-01f, 8.08518678e-02f, -9.42576956e-03f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.17531806e-01f, 2.32627732e-03f, 1.09814882e-01f, -4.14658189e-02f, 1.20577745e-01f, 2.19048962e-01f, -3.96151274e-01f, -3.75518352e-01f, -1.16128914e-01f, -2.29428336e-01f,
  5.88089645e-01f, -3.30130965e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    