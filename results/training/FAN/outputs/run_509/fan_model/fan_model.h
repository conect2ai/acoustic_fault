/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36169451e-01f, -1.47440415e-02f, 1.27564609e-01f, 1.41483247e-01f, 1.01308852e-01f, -1.51001751e-01f, 7.58429766e-02f, -1.82915088e-02f, -1.38009042e-01f, -8.19393024e-02f,
  -9.27129388e-02f, 1.36025576e-02f, -1.57594696e-01f, 2.43492052e-02f, -9.19038281e-02f, -2.32037902e-01f, 1.01525985e-01f, -3.33023146e-02f, -5.09059764e-02f, 3.76879871e-02f,
  -1.25905471e-02f, -4.23202664e-02f, 8.61959159e-02f, 1.18421111e-02f, 1.92727253e-01f, -4.17347578e-03f, 1.21265143e-01f, -3.08283418e-03f, 7.18783736e-02f, 3.06488536e-02f,
  1.19338576e-02f, -6.19349778e-02f, -1.53304811e-03f, -6.67231604e-02f, -4.88491282e-02f, 7.73523748e-02f, 2.03232169e-02f, 1.20596588e-02f, -3.45978886e-02f, -3.21509913e-02f,
  2.91135106e-02f, 3.46873738e-02f, -1.27125114e-01f, -8.52717981e-02f, 5.03761843e-02f, 1.51391905e-02f, -3.24995406e-02f, 2.86421366e-02f, -2.80629229e-02f, 5.76370582e-02f,
  3.63768488e-02f, 1.99648198e-02f, 9.31829363e-02f, -4.52525690e-02f, -5.83961196e-02f, 5.99913066e-04f, 1.85839534e-02f, 1.37332752e-01f, 2.56800856e-02f, -1.70247275e-02f,
  -5.77211343e-02f, 2.91395430e-02f, -4.34921570e-02f, 6.57095853e-03f, 4.22944166e-02f, 1.02176733e-01f, -5.65019511e-02f, -4.97295074e-02f, -1.08306184e-02f, 5.03783263e-02f,
  3.72646726e-03f, 2.41471697e-02f, -1.07031073e-02f, -2.76674628e-02f, -2.55688392e-02f, 2.91561242e-02f, -2.90664509e-02f, -6.49969131e-02f, 6.23570718e-02f, -2.68386938e-02f,
  -6.99078590e-02f, 2.73002349e-02f, 3.54784280e-02f, -4.96731214e-02f, 2.70706904e-03f, -6.59374595e-02f, 2.09145416e-02f, 2.81946659e-02f, 5.36572970e-02f, 7.37606548e-03f,
  8.88572559e-02f, -4.96741012e-02f, -6.76880181e-02f, -5.11836112e-02f, -3.49345268e-03f, -7.23900693e-03f, 5.38140237e-02f, -8.92971084e-02f, -6.18022829e-02f, 3.37358788e-02f,
  4.35272418e-02f, 9.57546383e-03f, 7.35765323e-02f, 5.35566621e-02f, 1.08533397e-01f, 2.68333871e-03f, 5.90098649e-02f, -4.46905419e-02f, 7.86137506e-02f, -2.98271459e-02f,
  7.78480917e-02f, 6.03113435e-02f, 3.51418667e-02f, 4.11819555e-02f, -7.93695450e-02f, 1.13970183e-01f, -3.39366589e-03f, -3.12497877e-02f, 7.17821764e-03f, -2.97478288e-02f,
  -3.77731137e-02f, -1.02630772e-01f, 1.06211007e-01f, -1.64905235e-01f, 1.01542138e-01f, 4.23372574e-02f, 4.41891551e-02f, -1.25990361e-01f, 3.87269072e-02f, -1.23687714e-01f,
  -3.30739468e-02f, 1.35685027e-01f, -3.91600728e-02f, -3.46637182e-02f, -1.85375109e-01f, 6.62621409e-02f, -1.71596050e-01f, -7.21143261e-02f, 1.33315459e-01f, -8.66886079e-02f,
  -1.28719836e-01f, -4.17619273e-02f, -9.35097877e-03f, -1.38311908e-02f, 6.07456341e-02f, -2.43109260e-02f, -2.30888054e-01f, 6.24518022e-02f, -5.85057214e-02f, 5.21056447e-03f,
  -2.57526897e-02f, 2.68009361e-02f, -3.80551703e-02f, 3.63652073e-02f, -7.34030083e-02f, 3.46193202e-02f, 2.51523834e-02f, 9.29103270e-02f, 1.44778294e-02f, 1.59860775e-02f,
  1.06161192e-01f, 3.25964838e-02f, 9.65371877e-02f, -1.88419446e-02f, 7.05968663e-02f, 7.06971362e-02f, 3.54416855e-02f, 3.24887484e-02f, -2.29591690e-02f, -2.51929853e-02f,
  1.15272313e-01f, 1.45269737e-01f, 6.84635863e-02f, 6.86082095e-02f, 6.41562119e-02f, -1.24075515e-02f, 2.22897548e-02f, 2.08589341e-02f, -3.79264392e-02f, 3.49641703e-02f,
  1.01221114e-01f, -6.98315874e-02f, -2.31523141e-02f, 4.03773300e-02f, -4.48538326e-02f, -4.89343069e-02f, -2.62699705e-02f, -8.79925713e-02f, 1.46565465e-02f, 1.24089816e-03f,
  -1.08204775e-01f, 1.69666708e-02f, 1.41201112e-02f, 2.40083244e-02f, 1.11130793e-02f, 1.14702629e-02f, -1.05344979e-02f, -5.59979156e-02f, 8.01174119e-02f, 1.36296786e-02f,
  1.41232470e-02f, -7.06032962e-02f, -9.55252945e-02f, -3.90519984e-02f, -5.48356250e-02f, -1.72794778e-02f, -6.97613345e-04f, 1.26421005e-02f, 1.87503826e-02f, -1.05948634e-01f,
  -2.46652097e-01f, -1.45728141e-01f, 5.54456115e-02f, 5.37070148e-02f, -8.71199965e-02f, -8.32375810e-02f, -1.56104080e-02f, 4.68450487e-02f, -1.23680243e-02f, -7.05624968e-02f,
  -4.55519445e-02f, 3.94303259e-03f, -7.21534267e-02f, 4.81870782e-04f, -9.32327434e-02f, 2.84100678e-02f, -1.00209124e-01f, -6.43157773e-03f, -7.29576945e-02f, -4.49156538e-02f,
  -2.35835928e-02f, -7.57661015e-02f, 4.58092168e-02f, -1.01212095e-02f, 5.77660613e-02f, -2.80908030e-02f, -7.29184076e-02f, 7.12024048e-02f, 4.85457629e-02f, -1.86413527e-02f,
  2.25508243e-01f, -1.86709031e-01f, -1.89492837e-01f, -1.39299735e-01f, -3.16364653e-02f, -9.28634964e-03f, 7.21680000e-02f, -2.11101040e-01f, -1.21303126e-01f, 3.61767504e-03f,
  7.72329792e-03f, 3.93805653e-02f, 6.23799749e-02f, -2.00233027e-01f, -1.38199637e-02f, -9.73306447e-02f, -1.43564478e-01f, 1.36503711e-01f, -3.07686888e-02f, 1.29277874e-02f,
  2.77398452e-02f, -1.69961348e-01f, -1.05803616e-01f, -1.93555310e-01f, 7.75703276e-03f, -5.54431230e-02f, 4.26630490e-03f, -2.92862654e-02f, -2.44581345e-02f, 5.93772382e-02f,
  -8.13029483e-02f, -6.52433857e-02f, -7.70195350e-02f, -5.63143194e-02f, -2.26760395e-02f, -5.64649925e-02f, 6.35551335e-03f, 1.83295533e-02f, 1.43036144e-02f, -3.74181941e-02f,
  4.12657708e-02f, -2.21411698e-02f, -7.40350857e-02f, 1.80936493e-02f, -4.59193178e-02f, -4.88584526e-02f, -6.59780130e-02f, -7.23310411e-02f, -8.83285627e-02f, -2.04453059e-02f,
  -3.80969606e-02f, -1.20733157e-01f, 2.25332007e-02f, 3.09779346e-02f, -1.86447043e-03f, -1.82484891e-02f, -1.59045123e-02f, 9.98067111e-02f, 3.15500237e-02f, -2.44424418e-02f,
  7.23330155e-02f, -5.69647439e-02f, 2.03192178e-02f, 9.42031387e-04f, -4.58256342e-02f, 2.31295780e-04f, -2.37273593e-02f, 1.94342136e-02f, 3.55130509e-02f, 1.77339942e-03f,
  8.42926744e-03f, -7.42395744e-02f, -2.05177404e-02f, 1.57256033e-02f, -1.63947493e-02f, 1.82198938e-02f, 5.80875650e-02f, 4.52456065e-02f, -7.40394890e-02f, -1.25763062e-02f,
  -1.67510025e-02f, 2.84990296e-02f, 7.55102653e-03f, 6.06819652e-02f, 3.66052985e-02f, -9.53048375e-03f, -3.65780368e-02f, -5.56642078e-02f, 5.25744036e-02f, 3.29163373e-02f,
  -1.80805512e-02f, -7.90792704e-02f, -1.68999657e-03f, 3.70481312e-02f, -2.88139321e-02f, -2.63848472e-02f, 3.95928174e-02f, 3.48234698e-02f, 2.79057566e-02f, -7.08543137e-02f,
  5.92405349e-02f, 6.86321780e-02f, 1.20196827e-01f, -2.46765018e-02f, 4.52347510e-02f, 2.86817813e-04f, 2.75459681e-02f, -1.08799478e-03f, 3.16498503e-02f, -3.75424400e-02f,
  4.03994359e-02f, 8.89806747e-02f, 5.69042517e-03f, -3.49272043e-02f, 9.69669297e-02f, 9.36794579e-02f, -5.00498153e-02f, 1.48344168e-03f, -2.50512157e-02f, 3.48272026e-02f,
  -2.16247112e-01f, 3.68735105e-01f, -1.10349573e-01f, 2.25843236e-01f, -9.37370583e-02f, 2.03092881e-02f, 6.60958216e-02f, 7.41128400e-02f, 6.20334856e-02f, 1.57710567e-01f,
  -1.77280411e-01f, 1.14445664e-01f, -2.16874443e-02f, 1.69101179e-01f, -2.16998801e-01f, 9.04221311e-02f, 8.32386613e-02f, -6.32554665e-02f, 1.12314053e-01f, 6.18742891e-02f,
  -2.83197537e-02f, 6.66682497e-02f, -2.00654492e-02f, 7.54584372e-02f, -7.87113234e-03f, 9.68307406e-02f, -8.30793828e-02f, -3.00304778e-02f, -3.08982339e-02f, 5.48748970e-02f,
  3.66782333e-05f, -1.21902272e-01f, -1.04292996e-01f, 3.19701619e-02f, -1.30101353e-01f, -4.95586209e-02f, -7.95150921e-02f, -5.72755486e-02f, -2.62046438e-02f, 5.98543696e-02f,
  -1.74152385e-02f, 9.92142502e-03f, 1.76784173e-02f, 6.45724544e-03f, -1.75854657e-02f, 1.99182946e-02f, 7.75310770e-02f, -2.94532273e-02f, 4.22758050e-02f, -4.08814549e-02f,
  5.85358553e-02f, -7.65313767e-03f, -2.72063054e-02f, 6.86263666e-02f, -4.20943089e-02f, 4.42535914e-02f, 2.50134673e-02f, 1.46761183e-02f, -5.45508340e-02f, -1.90028758e-03f,
  3.62170897e-02f, -5.65331914e-02f, 1.08884238e-01f, -3.14966626e-02f, 1.83688458e-02f, -2.35689674e-02f, 4.02676649e-02f, -4.99809440e-03f, -1.26067537e-03f, -1.42663475e-02f,
  2.51625497e-02f, 4.29962687e-02f, 4.05162461e-02f, 6.72584847e-02f, -6.59055486e-02f, -8.35961476e-03f, 2.45909560e-02f, -3.62714659e-03f, 6.00047708e-02f, 6.24970905e-02f,
  -1.20090712e-02f, -2.04038415e-02f, -2.93952301e-02f, -4.63343449e-02f, 1.20576210e-02f, 3.11633479e-02f, 4.60390337e-02f, 6.85714856e-02f, 4.63741459e-02f, -7.49188513e-02f,
  -1.19820222e-01f, -1.30578175e-01f, -1.37757408e-02f, -4.29930314e-02f, 4.15485464e-02f, -1.66076478e-02f, 3.19890678e-02f, 5.53241819e-02f, 7.89363682e-02f, -8.05247873e-02f,
  -2.21609622e-02f, -3.28505076e-02f, -4.51584235e-02f, 3.06179766e-02f, 8.86192843e-02f, -5.70005774e-02f, -1.53501453e-02f, 7.49346465e-02f, -9.91491377e-02f, 3.09890360e-02f,
  -1.18256412e-01f, -6.11190684e-02f, -2.89312080e-02f, -9.60393399e-02f, -1.02303801e-02f, 2.44137924e-02f, -4.22434881e-02f, -2.79439222e-02f, 6.99526863e-03f, 7.96572212e-03f,
  9.33688506e-02f, -2.61753887e-01f, 1.00818053e-01f, -7.78956041e-02f, -4.09389846e-02f, 1.03384368e-01f, 6.21529995e-03f, -3.79799716e-02f, 1.20363809e-01f, -1.02425851e-01f,
  -7.46551827e-02f, 1.80761889e-02f, -1.05552353e-01f, -1.83805183e-01f, 1.38107717e-01f, 6.72110915e-02f, -5.36660068e-02f, -1.60572287e-02f, 8.75751674e-02f, -5.17159216e-02f,
  4.51724492e-02f, -1.55518085e-01f, 2.82022711e-02f, -4.30501662e-02f, -1.18353367e-01f, 1.65277094e-01f, -1.16422839e-01f, -2.25852523e-02f, -3.35466936e-02f, -7.49090612e-02f,
  2.82537621e-02f, -5.77210002e-02f, -5.16321547e-02f, 1.02673257e-02f, 5.68433180e-02f, 2.60386225e-02f, 2.96833850e-02f, -3.57735530e-02f, 1.46222506e-02f, 4.56652045e-02f,
  -1.00760404e-02f, 5.20797111e-02f, 1.61638316e-02f, -9.29432511e-02f, -4.55880584e-03f, -2.88632382e-02f, -2.34706756e-02f, 5.94995208e-02f, -3.67828459e-02f, -2.79728416e-02f,
  8.80347844e-03f, -3.32244150e-02f, -1.72841139e-02f, 4.11372725e-03f, 7.19452649e-02f, 2.73628347e-02f, 8.86613950e-02f, -1.96202081e-02f, 7.21588358e-02f, 2.16648006e-03f,
  3.19302231e-02f, -6.33185077e-03f, -2.64287670e-03f, -3.77157293e-02f, -5.12856431e-02f, -1.45217683e-02f, 2.37205196e-02f, 3.45994420e-02f, -4.22496581e-03f, 2.80044917e-02f,
  -4.50156406e-02f, 1.88437272e-02f, -3.72667760e-02f, 2.82199178e-02f, -2.12548487e-03f, -3.23471315e-02f, 7.79733434e-02f, -5.51064797e-02f, 3.26545574e-02f, 4.69881408e-02f,
  1.24372421e-02f, -6.94390433e-03f, 2.20295996e-03f, -4.70644981e-02f, 2.05718260e-02f, 5.19859567e-02f, 1.95026565e-02f, 4.02051099e-02f, -5.49252145e-03f, -1.29596386e-02f,
  1.86005663e-02f, -5.44237345e-02f, -1.87691711e-02f, 1.42494775e-03f, -3.80739127e-03f, -4.42923140e-03f, -6.46019913e-03f, 4.52555642e-02f, 6.72103092e-02f, 4.37455066e-02f,
  -1.77794266e-02f, -3.65954712e-02f, 5.00565544e-02f, 1.90440696e-04f, -7.12274807e-03f, 8.86271894e-03f, -4.32284735e-03f, 1.41412299e-02f, -9.67747252e-03f, 4.73695397e-02f,
  -6.65403232e-02f, 6.54030815e-02f, 9.00137201e-02f, -3.37860547e-03f, -2.77776271e-02f, 4.79292534e-02f, 3.63043393e-03f, 6.22405857e-02f, -2.25986540e-02f, 7.57788541e-03f,
  -4.89780083e-02f, -2.29125023e-02f, 1.76680550e-01f, -5.77005297e-02f, -2.93101609e-01f, -5.12729064e-02f, -8.74501020e-02f, -1.50803715e-01f, -8.99501443e-02f, -7.83393905e-03f,
  -1.69309527e-01f, 1.04795218e-01f, 8.73373598e-02f, 6.09553047e-02f, 2.36867607e-01f, 2.06020340e-01f, 6.37014136e-02f, 6.65980726e-02f, -7.65165314e-02f, -4.82000001e-02f,
  -2.28266660e-02f, -1.73791170e-01f, 1.73790693e-01f, -1.53372005e-01f, -8.06735978e-02f, 2.52016019e-02f, 3.70579883e-02f, -1.40610576e-01f, 5.38093224e-02f, -1.72814541e-02f,
  -4.80935164e-02f, -1.58015370e-01f, -1.00451922e-02f, 1.52534153e-02f, 2.63956897e-02f, -2.27783769e-02f, 2.03303453e-02f, -1.06905084e-02f, -1.22013157e-02f, -6.55026641e-03f,
  2.32821088e-02f, -2.70411931e-02f, -4.09250706e-02f, 2.34554671e-02f, 1.29601778e-02f, 1.41012911e-02f, 7.02964067e-02f, 1.93329696e-02f, -5.71439303e-02f, 6.60092086e-02f,
  3.65558676e-02f, 4.96227257e-02f, 7.22889006e-02f, 2.39203405e-02f, -4.10680845e-02f, -1.04616277e-01f, 1.31353348e-01f, 2.23483685e-02f, 4.84498441e-02f, -5.20620914e-03f,
  -1.96269415e-02f, -2.39253417e-02f, -3.58838290e-02f, -4.86665927e-02f, -3.20203975e-02f, -7.07583353e-02f, 2.77729686e-02f, 2.59204172e-02f, 2.35358272e-02f, -2.08067335e-02f,
  -6.64039180e-02f, -1.53604317e-02f, -1.16455138e-01f, 7.60522410e-02f, 1.83558427e-02f, -3.63308862e-02f, 5.94354346e-02f, -6.59330888e-03f, 1.97228454e-02f, 3.58252116e-02f,
  -5.42187877e-02f, 4.37022047e-03f, -6.01467630e-03f, -1.34160519e-02f, 5.11167152e-03f, 5.74945696e-02f, -6.95657879e-02f, 5.59569523e-02f, -7.28221610e-02f, 3.06017343e-02f,
  -8.99095163e-02f, -1.15845978e-01f, -4.99776565e-02f, -7.00813755e-02f, -3.74583304e-02f, 7.52083212e-02f, 6.66638240e-02f, 7.21089020e-02f, 2.08252091e-02f, -2.44656969e-02f,
  2.17292253e-02f, -1.99926980e-02f, 5.51067367e-02f, 1.40620321e-02f, 5.43542095e-02f, 5.31585217e-02f, 3.36574800e-02f, 4.63146158e-02f, -8.84455070e-02f, -1.93790998e-02f,
  9.60245915e-03f, -5.54402210e-02f, -1.45233120e-03f, -8.01177323e-02f, 1.11345677e-02f, -8.17882735e-03f, -4.43981327e-02f, 4.94953804e-02f, -8.77115224e-03f, -1.29131395e-02f,
  -4.69999537e-02f, 7.66632631e-02f, -1.25448391e-01f, -5.60835265e-02f, 1.73339695e-01f, 2.00805981e-02f, -1.27914101e-02f, 1.20703734e-01f, 3.51993069e-02f, 1.04218744e-01f,
  9.09590498e-02f, -2.04527482e-01f, -1.11009842e-02f, -9.57233608e-02f, -2.76838183e-01f, -1.01115957e-01f, -4.74536158e-02f, -2.79918388e-02f, 3.74966227e-02f, 1.09220296e-01f,
  -2.13255733e-02f, 1.61170214e-01f, -1.39991879e-01f, 2.17840061e-01f, 6.26721159e-02f, 1.45344034e-01f, 9.23294798e-02f, -2.46715620e-02f, 1.48077920e-01f, -9.45501626e-02f,
  1.53793707e-01f, 6.33619204e-02f, -1.22776292e-02f, -1.06745446e-02f, 4.69569564e-02f, -5.63915521e-02f, -2.28337217e-02f, -1.11501493e-01f, -2.36962810e-02f, -7.08337314e-03f,
  -6.86148927e-02f, 3.23841535e-02f, 9.57269687e-03f, 1.54092703e-02f, 8.51655081e-02f, 8.92159715e-03f, 1.42675852e-02f, 4.20168638e-02f, 7.17168674e-02f, -3.38422656e-02f,
  -2.31908672e-02f, -1.64684299e-02f, 4.83476557e-02f, -1.94434803e-02f, -3.94012332e-02f, 1.24610215e-02f, -4.00004126e-02f, -2.49867737e-02f, -8.27641562e-02f, 5.51420748e-02f,
  8.68911073e-02f, -3.49501744e-02f, -8.02093819e-02f, 3.89825292e-02f, 2.54666880e-02f, -5.43671567e-03f, -9.75008681e-03f, 4.35942486e-02f, -7.58035034e-02f, 6.40470237e-02f,
  6.98581571e-04f, -1.32637070e-02f, 7.49834105e-02f, 2.31582932e-02f, 3.37911136e-02f, 3.04417312e-02f, -5.81506081e-02f, 2.52759270e-02f, -7.34299198e-02f, 3.12314369e-02f,
  -1.28805051e-02f, 1.51225692e-02f, -2.09798552e-02f, -1.09640462e-03f, -2.10629459e-02f, -2.68281996e-03f, 6.44202381e-02f, 1.80578139e-02f, -4.02784944e-02f, 2.65580770e-02f,
  2.10585266e-01f, 1.19329035e-01f, 1.13687247e-01f, 9.76850614e-02f, 2.85080113e-02f, 2.37361025e-02f, -1.19493827e-02f, -1.73372440e-02f, -5.98667488e-02f, 7.74986744e-02f,
  1.62275194e-03f, 6.46187365e-02f, -5.04734516e-02f, 4.46557067e-03f, -1.14627024e-02f, 3.97168770e-02f, -5.21138869e-02f, -3.54436822e-02f, -2.97909603e-02f, 9.34842527e-02f,
  2.08902881e-02f, -1.99526008e-02f, -3.93315852e-02f, 6.55331090e-02f, 6.59702793e-02f, -1.76731087e-02f, 3.80622372e-02f, 3.85265145e-03f, 2.06570998e-02f, -2.09341384e-02f,
  -1.49904385e-01f, 1.94085557e-02f, -5.16616032e-02f, -1.37181908e-01f, 5.99309094e-02f, -3.17479461e-01f, -2.24931240e-01f, 1.45910859e-01f, -2.35230625e-02f, -7.68760666e-02f,
  -1.09762110e-01f, 8.14915746e-02f, -9.14886817e-02f, -2.34361649e-01f, -2.52004892e-01f, -1.42536521e-01f, -2.28861898e-01f, -1.23411067e-01f, 2.99063195e-02f, 4.08294126e-02f,
  2.42931414e-02f, -1.15495078e-01f, -4.43684608e-02f, 2.16767311e-01f, -7.59013137e-03f, 1.13963716e-01f, 4.78559919e-02f, 9.13484544e-02f, 6.17955402e-02f, 2.86487378e-02f,
  3.60438675e-02f, 4.63956483e-02f, 4.78640534e-02f, 5.27716018e-02f, -3.90711613e-02f, -6.39040768e-02f, -3.52901481e-02f, -5.49851544e-02f, 6.80392012e-02f, -5.69909289e-02f,
  -3.70304361e-02f, -1.62332095e-02f, 1.28234932e-02f, 4.99240234e-02f, 3.71041484e-02f, 6.86715916e-02f, 5.29595353e-02f, -5.97340278e-02f, -2.08537281e-02f, 1.75964851e-02f,
  7.84970727e-03f, -2.38706116e-02f, -6.53981790e-02f, -1.37800199e-03f, 7.12534413e-02f, 3.46684898e-03f, -5.67512289e-02f, 1.80094559e-02f, 2.80806050e-02f, -1.97994355e-02f,
  -5.42809479e-02f, -2.90058157e-03f, -2.84541063e-02f, -4.91460739e-03f, 1.87982414e-02f, 4.21460383e-02f, -3.66942734e-02f, 3.18773910e-02f, 9.73045453e-02f, -1.60887334e-02f,
  -2.40420233e-02f, -3.55347432e-02f, 3.20233032e-02f, -5.85666634e-02f, -1.55735267e-02f, -1.53707154e-02f, -3.58080789e-02f, -6.41762465e-03f, -2.63010580e-02f, -4.44402620e-02f,
  -5.53041548e-02f, -1.17057068e-02f, -5.17340899e-02f, 1.78213995e-02f, -1.74600873e-02f, 1.25552993e-02f, -5.65513447e-02f, 3.64628956e-02f, 1.44178485e-02f, -5.28622232e-02f,
  -1.61121637e-01f, -1.45791890e-02f, 2.97222771e-02f, 6.25114609e-03f, 3.87722179e-02f, -6.75495341e-03f, -4.44547972e-03f, 4.24720757e-02f, 2.70267222e-02f, -1.94209795e-02f,
  1.29097430e-02f, 2.57912874e-02f, 4.65389267e-02f, 2.97361724e-02f, 2.76426389e-03f, -5.86154386e-02f, -1.04701340e-01f, 4.16618250e-02f, 3.51129770e-02f, -3.16529609e-02f,
  -6.11145571e-02f, -6.63496181e-02f, 2.06554830e-02f, 1.14131421e-02f, -5.08383885e-02f, -1.36345457e-02f, 2.88209934e-02f, 7.93773755e-02f, -4.48137149e-03f, -8.49947426e-03f,
  -5.95698841e-02f, 7.68277645e-02f, -2.32950542e-02f, -7.08250180e-02f, -1.45442441e-01f, 9.11971331e-02f, 5.31073622e-02f, -9.24285129e-02f, 1.94253892e-01f, 3.10088675e-02f,
  -2.33034194e-02f, 2.96867844e-02f, 9.41550434e-02f, -1.35519683e-01f, -1.17850401e-01f, 1.45964280e-01f, -2.28679571e-02f, 5.53901792e-02f, -3.71788219e-02f, -1.12852648e-01f,
  -5.40397689e-02f, -2.07044363e-01f, -6.40347004e-02f, -5.31092212e-02f, 1.99351739e-02f, 3.10847890e-02f, -5.45669235e-02f, 5.35971299e-02f, -2.22342804e-01f, -5.73713966e-02f,
  9.30899829e-02f, 7.20004365e-02f, 4.10402380e-02f, 4.12649428e-03f, -3.66355740e-02f, -5.49675785e-02f, 4.36644964e-02f, 2.65996973e-03f, -3.12525705e-02f, 4.87451144e-02f,
  8.38929862e-02f, -5.46010174e-02f, -1.00641392e-01f, 6.71790214e-04f, 7.98676312e-02f, -3.98602802e-03f, 4.16683853e-02f, 9.74015333e-03f, -3.48444209e-02f, -4.80150208e-02f,
  2.36830357e-02f, -1.59984026e-02f, -5.79103455e-02f, -5.32617122e-02f, -1.48524018e-02f, -1.90946553e-02f, -8.19890648e-02f, -1.07688420e-01f, -3.45699862e-02f, -1.23020761e-01f,
  2.25645527e-02f, -3.24035138e-02f, -4.26178984e-02f, -4.54118699e-02f, -2.66674254e-02f, -4.50535938e-02f, 8.73131827e-02f, -4.51986082e-02f, 6.73818439e-02f, 5.83604723e-02f,
  1.34693692e-02f, 5.23094721e-02f, -2.19136346e-02f, -8.61290284e-03f, -5.06185070e-02f, 6.30239546e-02f, 7.13002011e-02f, 2.88315397e-02f, -5.13160564e-02f, -8.96150544e-02f,
  2.36703586e-02f, 3.48864384e-02f, 6.46254839e-03f, 2.82984339e-02f, 3.49637456e-02f, 3.93755436e-02f, 6.85564009e-03f, 5.77857159e-02f, -7.56761897e-03f, 3.06947287e-02f,
  1.70336722e-03f, 5.50634880e-03f, -4.96969186e-02f, -1.88929513e-02f, -3.43967453e-02f, 1.45049840e-02f, 5.05722426e-02f, 4.54270914e-02f, 7.02433512e-02f, -4.89669293e-02f,
  -8.35516676e-02f, -1.54261077e-02f, 1.60583556e-01f, 4.35935371e-02f, 4.06524502e-02f, -4.60482426e-02f, -2.06695590e-02f, 2.65826732e-02f, 2.63019465e-02f, -1.28518701e-01f,
  -5.78242959e-03f, -1.85257271e-02f, 9.26021393e-03f, -3.24353779e-04f, -9.15831551e-02f, 9.92775057e-03f, -4.36585769e-02f, -1.05189249e-01f, 2.21530581e-03f, 1.01837311e-02f,
  3.66756499e-01f, -1.74504921e-01f, 1.47385499e-03f, 1.41475141e-01f, 8.93703848e-02f, -2.18970850e-01f, -1.17992498e-01f, -1.64648965e-02f, -2.26817504e-02f, -1.79341108e-01f,
  -1.01546437e-01f, 1.45684659e-01f, -1.29327908e-01f, -5.25445752e-02f, 5.40542305e-02f, -1.51130646e-01f, 2.92699113e-02f, 7.56501779e-02f, 5.18496595e-02f, 1.45216286e-01f,
  2.22920831e-02f, -7.13270605e-02f, 1.72026269e-02f, -1.33127138e-01f, 8.95488262e-02f, 4.86587286e-02f, 6.01758063e-02f, -2.13120263e-02f, -2.84261964e-02f, -8.74055699e-02f,
  -1.15151145e-02f, -2.75907293e-02f, -3.70133929e-02f, -5.27340546e-02f, 5.02839945e-02f, -8.56186787e-04f, 5.40891737e-02f, 3.53580788e-02f, -3.21989367e-03f, 3.54562476e-02f,
  -4.93300427e-03f, -8.50788783e-03f, -9.42281261e-03f, 2.13101953e-02f, -3.41643728e-02f, -3.07842977e-02f, -5.21682315e-02f, 8.57718196e-03f, 2.76935045e-02f, -2.29270551e-02f,
  -7.03438697e-03f, 1.35144009e-03f, -3.39981206e-02f, 9.08082444e-03f, -6.76156860e-03f, 8.76416564e-02f, 6.40024059e-03f, -1.19443890e-02f, 1.08342944e-03f, 3.96866612e-02f,
  1.44877220e-02f, 3.53204049e-02f, 1.17031131e-02f, -6.00632578e-02f, -3.00472640e-02f, 1.22136613e-02f, -3.06166522e-02f, 4.64836182e-03f, 3.62081937e-02f, -6.95719048e-02f,
  9.44730267e-02f, 3.40432487e-02f, -4.22690064e-02f, 1.45906238e-02f, 3.36270668e-02f, -3.41269746e-02f, 7.17659444e-02f, 3.10573149e-02f, 7.73765817e-02f, 2.20044963e-02f,
  4.43598256e-02f, -3.19359452e-02f, -1.24759143e-02f, 1.33027500e-02f, -3.28991488e-02f, 3.34323309e-02f, 3.96489305e-03f, -1.47364438e-02f, -3.00887879e-02f, 4.11909223e-02f,
  -6.56004474e-02f, -3.83236408e-02f, 2.10704412e-02f, -4.57647219e-02f, 2.42933035e-02f, 4.10730485e-03f, -5.11743613e-02f, 2.23146770e-02f, 1.00454008e-02f, -2.22813282e-02f,
  1.12794507e-02f, -1.31835882e-02f, 6.51163533e-02f, -4.83326651e-02f, -2.35428829e-02f, 3.40968035e-02f, -4.08914639e-03f, 5.63247167e-02f, 6.86871931e-02f, 3.66060287e-02f,
  2.93708383e-03f, -6.10120706e-02f, -4.21203151e-02f, -5.21849431e-02f, 9.01509076e-03f, -7.39967600e-02f, -4.99262959e-02f, 7.55668804e-02f, 1.98889002e-02f, -4.50150594e-02f,
  1.13821469e-01f, -1.24921128e-01f, 1.34819478e-01f, -2.28572622e-01f, -4.91078459e-02f, -9.02044773e-03f, -5.48872128e-02f, 7.18500046e-03f, -1.00269511e-01f, -1.81075335e-01f,
  -1.41153559e-01f, -4.14753966e-02f, -1.32106513e-01f, -2.69993007e-01f, -2.86930967e-02f, -1.17768601e-01f, -1.79969907e-01f, -8.30420014e-03f, -1.94864087e-02f, 9.69520118e-03f,
  -3.55212041e-03f, -9.56257656e-02f, -8.20446163e-02f, 1.51016936e-02f, -5.58139831e-02f, 1.12701260e-01f, 2.56974176e-02f, 6.57951310e-02f, -9.20825526e-02f, -6.18146434e-02f,
  1.30639493e-01f, 2.09014744e-01f, 9.03822929e-02f, 9.47349891e-02f, 4.70284224e-02f, 8.11331868e-02f, 5.18197715e-02f, 8.46316665e-02f, 3.73561420e-02f, -6.94040433e-02f,
  -3.85749266e-02f, 1.79937463e-02f, -2.85182558e-02f, -5.62822782e-02f, -5.38962558e-02f, -1.29123637e-03f, -4.04097177e-02f, -6.78849295e-02f, -4.44205254e-02f, -6.59044413e-03f,
  -4.17599687e-03f, 3.02883461e-02f, -8.52251649e-02f, 9.26914159e-03f, -6.46519437e-02f, -6.63601831e-02f, -2.16586068e-02f, -1.65189169e-02f, -1.00679070e-01f, -7.26293847e-02f,
  1.71565823e-02f, 1.01867469e-03f, 2.22004019e-02f, -4.62413207e-02f, 9.57719609e-03f, 1.16135469e-02f, -6.87972233e-02f, -1.88151840e-02f, -3.20547037e-02f, 3.56175029e-03f,
  -1.18858077e-01f, -9.89242494e-02f, -1.20448666e-02f, -4.21323702e-02f, -1.23246759e-02f, -8.95421021e-03f, 6.58752695e-02f, 5.97926741e-03f, -7.20693767e-02f, 5.23067601e-02f,
  -1.28823724e-02f, -1.14029115e-02f, -3.96283120e-02f, -2.70562829e-03f, -4.12699319e-02f, -3.26664150e-02f, 3.08510661e-02f, 7.96969421e-03f, 5.56560829e-02f, 5.91328740e-02f,
  -2.36028787e-02f, -3.40102687e-02f, -1.68753807e-02f, -6.83939159e-02f, 3.40619646e-02f, 6.89077657e-03f, 2.10347231e-02f, -5.69951981e-02f, 7.13573443e-03f, 1.35705173e-01f,
  6.70923665e-02f, -7.76937827e-02f, 5.55962548e-02f, -1.08164765e-01f, -1.07333489e-01f, -2.65193488e-02f, 4.33744192e-02f, 2.18322896e-03f, -1.03524484e-01f, 7.34432694e-03f,
  -3.46774384e-02f, 1.20184303e-03f, 4.12401035e-02f, -1.41179347e-02f, 4.82533574e-02f, 6.21876381e-02f, 9.89289116e-03f, -5.32361679e-02f, 1.63320284e-02f, -4.45767120e-02f,
  3.46140843e-03f, -1.04752876e-01f, -2.85436381e-02f, 1.02442853e-01f, 2.09969565e-01f, 4.83106077e-02f, -1.74816683e-01f, 2.21141502e-01f, 1.77071601e-01f, -1.97493657e-01f,
  2.63720024e-02f, -1.80888429e-01f, -1.39592499e-01f, 8.03854764e-02f, 8.75929296e-02f, -1.09373629e-01f, 9.29846317e-02f, -7.53069669e-02f, 8.83911401e-02f, 4.16901931e-02f,
  4.25425917e-02f, 1.42463416e-01f, -1.24461412e-01f, 1.49345681e-01f, 4.01762612e-02f, -2.41015325e-04f, -8.13078657e-02f, -1.36639640e-01f, -1.73735991e-02f, -7.24976957e-02f,
  6.22517392e-02f, -1.80646274e-02f, -1.00683961e-02f, 6.60443539e-03f, -3.15010734e-02f, -5.91105074e-02f, -8.18612203e-02f, -7.55229443e-02f, 5.98464236e-02f, -8.56469944e-03f,
  -6.58532605e-02f, 4.76589687e-02f, -9.59091913e-03f, 2.40598507e-02f, 3.27578224e-02f, 1.56703368e-02f, 5.08028641e-02f, 1.87813642e-03f, 1.51043562e-02f, -5.08864447e-02f,
  -2.77674720e-02f, -6.09723106e-02f, -4.33487035e-02f, -1.05949350e-01f, -5.14120385e-02f, 8.64393786e-02f, -8.33377093e-02f, -1.19625926e-01f, 4.35567647e-02f, -1.83067825e-02f,
  -4.99327742e-02f, -2.86770836e-02f, 2.54634824e-02f, 3.29473577e-02f, 2.97070574e-03f, 6.38200492e-02f, -1.78771019e-02f, -1.53068900e-02f, -6.41289516e-04f, -1.68178789e-02f,
  7.29142651e-02f, -1.22187827e-02f, 1.34139438e-03f, 7.58632049e-02f, -6.56335577e-02f, -1.43026737e-02f, -1.83441788e-02f, 2.70477291e-02f, 1.24309566e-02f, 1.29983695e-02f,
  -2.54783519e-02f, 8.17926452e-02f, -3.40581662e-03f, -1.07220381e-01f, -1.75317209e-02f, -6.48185909e-02f, -8.04258976e-03f, -4.50090971e-03f, 4.19589989e-02f, -3.69948037e-02f,
  -9.25634876e-02f, -3.38886790e-02f, -4.20256071e-02f, 1.17501887e-02f, -9.46005748e-04f, 4.77544963e-02f, 8.06228165e-03f, 4.69213128e-02f, 2.48004887e-02f, 1.31111637e-01f,
  8.90124030e-03f, 1.90548059e-02f, 3.62146795e-02f, 2.30300147e-02f, 3.16055194e-02f, 2.50054654e-02f, -4.36227247e-02f, -4.95695919e-02f, -8.72109979e-02f, 7.28388056e-02f,
  7.68963294e-03f, -4.77077998e-02f, 2.60479469e-02f, 5.27669974e-02f, -3.57082188e-02f, -7.93319419e-02f, 8.22348371e-02f, 1.57720875e-02f, -6.16839975e-02f, 1.32696349e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.77907300e-01f, 2.74339080e-01f, 1.73547283e-01f, 3.99026535e-02f, -2.07955856e-02f, 2.15379819e-01f, 2.49502659e-02f, 1.41497806e-01f, 5.10340594e-02f, -6.58799931e-02f,
  -6.39297664e-02f, -1.07327059e-01f, 5.97846322e-02f, 7.62231648e-02f, -7.49748498e-02f, 1.76226273e-01f, 6.46400601e-02f, 7.58515811e-03f, 5.67512810e-02f, -3.02707590e-02f,
  1.45049719e-02f, -1.47434343e-02f, 1.86026499e-01f, 2.82779895e-02f, 5.20761535e-02f, 7.47835413e-02f, -4.44339141e-02f, 6.68987557e-02f, 8.00347999e-02f, 1.07542828e-01f,
  -5.81562854e-02f, -3.24502848e-02f, 5.57102636e-02f, 1.07224092e-01f, 9.62329656e-02f, -6.90535903e-02f, 1.24180026e-01f, -6.80077150e-02f, 3.38608250e-02f, 8.31080899e-02f,
  -7.89662153e-02f, -2.36972608e-02f, -2.60163145e-03f, -3.13718282e-02f, -7.19986856e-02f, 4.92251851e-02f, -1.00439698e-01f, 8.97713378e-02f, 5.59654087e-02f, -6.66083992e-02f,
  -3.69646214e-02f, 1.40347958e-01f, 7.58042037e-02f, 9.48194191e-02f, 9.94520411e-02f, -1.33185834e-02f, 5.25002107e-02f, -7.86455050e-02f, 1.09338611e-01f, -6.07030932e-03f,
  5.10537550e-02f, 9.58034471e-02f, -2.22064648e-02f, -8.52845237e-02f, 7.44874179e-02f, -1.14203580e-02f, 3.54892723e-02f, -1.11831807e-01f, 4.02871929e-02f, -4.34613740e-03f,
  5.46011403e-02f, 5.72918728e-02f, -3.94341871e-02f, 3.69577259e-02f, -5.85973822e-02f, -1.06687948e-01f, 5.27153835e-02f, -5.85899279e-02f, 4.98035103e-02f, -2.57074069e-02f,
  -3.81891467e-02f, 1.08247705e-01f, -2.52126493e-02f, 3.79821695e-02f, 5.77830747e-02f, -2.71904357e-02f, 1.09225214e-01f, -4.96308655e-02f, 4.88296971e-02f, 4.54377336e-03f,
  1.95395291e-01f, 2.66974002e-01f, -1.98280457e-02f, -3.45316492e-02f, 8.47197473e-02f, 1.87319238e-02f, -3.86088826e-02f, -2.35118736e-02f, 1.32932827e-01f, 7.52652287e-02f,
  6.32923469e-02f, -1.48356603e-02f, 8.12888592e-02f, -3.70208733e-02f, -4.68294583e-02f, 5.55963367e-02f, -2.77512893e-02f, 4.52671498e-02f, 1.86733957e-02f, 9.41773355e-02f,
  -4.53558005e-03f, -6.78403527e-02f, -7.19532594e-02f, 4.42598090e-02f, -1.59191806e-02f, -2.68352628e-02f, 7.53192157e-02f, 6.79625338e-03f, 6.20540231e-03f, 4.49600369e-02f,
  6.01434000e-02f, -4.40128967e-02f, -1.59355521e-01f, -1.36155589e-02f, -1.17492668e-01f, -1.39947131e-01f, -1.95261270e-01f, 7.88107216e-02f, -9.38720107e-02f, 1.64347947e-01f,
  2.42696300e-01f, -1.66452616e-01f, -3.48664671e-02f, 2.36108288e-01f, -1.00401089e-01f, 3.98673788e-02f, 1.64027855e-01f, -2.26306226e-02f, -1.28427178e-01f, 1.05638374e-02f,
  -1.46942521e-02f, 2.65812039e-01f, -6.92683738e-03f, 1.19608797e-01f, 3.92860733e-02f, 1.01634517e-01f, 1.31664023e-01f, 1.57012530e-02f, 1.27054900e-01f, -7.35713020e-02f,
  9.64376330e-02f, 8.19179043e-02f, -1.33143803e-02f, -7.16159195e-02f, 7.25754574e-02f, 3.89587581e-02f, -8.45297426e-02f, 6.75613508e-02f, -5.26741473e-03f, 2.11340282e-03f,
  -4.19504941e-02f, -3.42150033e-02f, 3.81086133e-02f, -4.91502285e-02f, -2.96856742e-02f, -1.10039718e-01f, 8.11087154e-03f, -8.46102908e-02f, -1.45207539e-01f, -1.82274133e-02f,
  1.57664809e-02f, -4.68842871e-02f, -4.09231037e-02f, -4.81783040e-02f, -3.13705541e-02f, 1.76968668e-02f, -1.01213269e-01f, -4.92263474e-02f, -1.44786539e-03f, -1.24406330e-01f,
  4.41641808e-02f, -2.40282528e-02f, 4.69131693e-02f, -9.17157829e-02f, 2.62566339e-02f, -6.53726608e-03f, 2.96938829e-02f, -7.70143280e-03f, -1.73656382e-02f, 7.10932165e-02f,
  -4.41443757e-04f, -1.59832016e-02f, -2.25506071e-02f, 6.83279783e-02f, -4.52191234e-02f, 4.13459912e-02f, 6.12489022e-02f, 3.17999274e-02f, -2.00568866e-02f, 7.93401003e-02f,
  3.74753550e-02f, -4.77139018e-02f, 2.36822348e-02f, 2.10015830e-02f, -3.35149243e-02f, -7.70332515e-02f, -2.15518046e-02f, 3.90972421e-02f, -5.51920049e-02f, 4.60896827e-02f,
  3.87259014e-02f, 1.16890840e-01f, 3.29039246e-02f, -4.31155637e-02f, -6.98714480e-02f, 4.11160924e-02f, 5.59516661e-02f, 1.50438054e-02f, 3.79395708e-02f, 5.22371265e-04f,
  8.74385703e-03f, -8.02498218e-03f, 1.06258154e-01f, 2.37252042e-02f, -9.63006094e-02f, 1.36034808e-03f, 3.61908600e-02f, -4.95883562e-02f, -8.84986147e-02f, 6.87236562e-02f,
  8.48628879e-02f, -1.61770768e-02f, -1.14865340e-01f, -1.04316294e-01f, 1.07945036e-02f, 7.64857605e-03f, -1.12929530e-01f, -4.53428403e-02f, 1.03289932e-01f, -1.66249741e-02f,
  -2.53063138e-03f, 1.69353653e-02f, -9.63838026e-02f, -2.99923997e-02f, 1.08339921e-01f, -1.34322867e-01f, -1.35046437e-01f, 1.22738205e-01f, -2.13514328e-01f, 7.29496107e-02f,
  1.26342744e-01f, -3.73273715e-02f, 9.94821414e-02f, -3.48958969e-02f, -1.00894682e-01f, -7.79432431e-02f, -4.66655567e-02f, -7.37082511e-02f, -1.53443422e-02f, 2.18379840e-01f,
  6.45345449e-02f, 1.35292709e-01f, 1.21594034e-01f, 2.06055999e-01f, 7.88641572e-02f, -1.97671130e-02f, 2.37612560e-01f, 1.10599384e-01f, 1.49542302e-01f, 7.19585344e-02f,
  -1.23331301e-01f, 4.69691716e-02f, 3.59936245e-02f, -1.31736174e-01f, 5.28491773e-02f, -7.40338564e-02f, -7.28320107e-02f, -2.54027881e-02f, 4.59471941e-02f, 7.39350840e-02f,
  -1.05705723e-01f, -4.72968398e-03f, -1.20569862e-01f, -1.41435817e-01f, -5.86120822e-02f, -1.44957490e-02f, 5.88128753e-02f, -3.18329558e-02f, -3.24167460e-02f, -4.31347899e-02f,
  -4.46584150e-02f, -3.70837301e-02f, -9.40897968e-03f, 7.01534227e-02f, -6.58964692e-03f, -8.24460387e-02f, -1.10589772e-01f, 1.01782583e-01f, -4.86002341e-02f, 2.69435346e-02f,
  3.56096365e-02f, -2.54648123e-02f, -3.02937869e-02f, -9.45806783e-03f, 9.57043916e-02f, -2.35810224e-02f, -1.95510313e-02f, 5.47024794e-03f, -1.36705851e-02f, 1.87474024e-02f,
  5.07883877e-02f, -4.45159189e-02f, -4.43125190e-03f, -5.02451137e-02f, 7.10798101e-03f, -8.08475912e-02f, -6.34396598e-02f, 6.26038164e-02f, 7.80510083e-02f, 3.63366082e-02f,
  -5.83962835e-02f, 6.55185059e-02f, -3.67995724e-02f, -3.03963553e-02f, -5.18671758e-02f, 5.06046601e-02f, 8.13701600e-02f, -5.80579415e-02f, -2.23101303e-02f, -1.50220366e-02f,
  7.48450235e-02f, 1.34425879e-01f, -4.83641997e-02f, 3.69920805e-02f, 1.89886632e-04f, 1.35924732e-02f, -8.32949653e-02f, -9.09051374e-02f, 4.25699800e-02f, -2.99930926e-02f,
  8.49182457e-02f, -2.37235595e-02f, 6.92121387e-02f, 7.09399432e-02f, -7.14525729e-02f, 4.46061380e-02f, 1.25125542e-01f, -4.17828076e-02f, 1.01454005e-01f, 1.22348599e-01f,
  3.72576527e-02f, 5.49089350e-02f, -1.14428699e-02f, -6.31224662e-02f, 1.14670597e-01f, -1.18474904e-02f, 5.60033973e-03f, -1.52983032e-02f, 9.57699493e-02f, -6.03025733e-03f,
  -2.78736979e-01f, 6.03664666e-02f, 2.55306493e-02f, -1.56254217e-01f, -3.89177322e-01f, 1.16886526e-01f, 1.71736568e-01f, -4.60997857e-02f, 7.87600875e-02f, 1.18119419e-01f,
  -3.58849242e-02f, 1.17622651e-01f, 1.83074340e-01f, 7.19657307e-03f, 1.84842587e-01f, 3.48079085e-01f, 7.83635378e-02f, 2.28243321e-02f, -2.02124007e-02f, -1.50700644e-01f,
  -1.94584921e-01f, -1.38147607e-01f, -2.44280882e-02f, -2.11299136e-01f, -3.45390946e-01f, -1.80374831e-01f, -1.71070725e-01f, -1.02754474e-01f, -1.17989272e-01f, -9.17630419e-02f,
  -1.99092254e-01f, -1.82042211e-01f, -4.53211702e-02f, -2.55532600e-02f, -1.72140673e-01f, -3.21859829e-02f, 4.84551750e-02f, 1.23243220e-02f, -7.08847791e-02f, -4.34332564e-02f,
  -6.04901686e-02f, 8.03907886e-02f, -4.17222343e-02f, 1.22601360e-01f, -1.03150681e-01f, -1.29970834e-01f, -3.03204544e-02f, -1.22487225e-01f, -4.10158671e-02f, 9.37081950e-06f,
  -4.45896536e-02f, -5.37087917e-02f, -1.01862196e-03f, 7.47511163e-02f, -5.42210490e-02f, -6.33065999e-02f, 8.37873891e-02f, 5.09138405e-03f, -1.57292888e-01f, -3.64115536e-02f,
  -7.98990577e-02f, 1.02464214e-01f, -2.74220034e-02f, -2.34358944e-02f, -4.80674542e-02f, -1.62487611e-01f, -6.60344735e-02f, 1.00774899e-01f, 6.98733795e-03f, 2.68458035e-02f,
  5.99948913e-02f, -9.34500694e-02f, 4.28508827e-03f, -2.15844661e-02f, 9.97502450e-03f, 3.58649045e-02f, -1.05358497e-03f, -1.43716574e-01f, -1.27952397e-02f, 3.31955701e-02f,
  -1.84939187e-02f, 2.48405319e-02f, -9.94612835e-03f, -4.36512232e-02f, -3.86597812e-02f, -3.15141492e-02f, -4.02134508e-02f, 8.08965415e-02f, 4.50988822e-02f, -3.13131437e-02f,
  -1.77974984e-01f, -3.22521552e-02f, 4.31658365e-02f, -1.46433711e-01f, -1.02799879e-02f, -1.20394237e-01f, 9.16782841e-02f, -1.83519442e-02f, -4.87108305e-02f, 3.29260640e-02f,
  -3.51347104e-02f, -3.21015762e-03f, -7.59273469e-02f, 5.61980829e-02f, 6.50680214e-02f, -8.97702351e-02f, 2.84727458e-02f, -1.05488800e-01f, 1.87626630e-02f, -1.66939646e-02f,
  8.10476765e-02f, 1.06001541e-01f, 1.26550600e-01f, -9.13447142e-02f, -6.21612463e-03f, -5.71645685e-02f, -2.79697422e-02f, 1.11223593e-01f, -1.57561138e-01f, -5.84589615e-02f,
  8.32947437e-03f, -2.56535113e-01f, -1.54820040e-01f, 1.21531852e-01f, 8.03612918e-02f, -3.60248089e-02f, -1.59983531e-01f, 1.25150561e-01f, 1.98532771e-02f, -2.15946764e-01f,
  5.34715019e-02f, -2.30057210e-01f, -2.04523757e-01f, 1.29397273e-01f, 2.06983134e-01f, -7.41179362e-02f, 2.73861766e-01f, 1.76264539e-01f, 4.78219725e-02f, 8.79192054e-02f,
  1.57644644e-01f, 3.66851360e-01f, 1.65439904e-01f, 2.43174434e-01f, 2.40958363e-01f, 2.37594306e-01f, 1.45945892e-01f, 4.51985374e-02f, 2.15230569e-01f, 1.19445115e-01f,
  -2.52823293e-01f, -5.96757513e-04f, 2.84306165e-02f, -1.03463205e-02f, -1.44704953e-01f, -1.33708835e-01f, -1.74731806e-01f, 2.75908355e-02f, -7.33046532e-02f, -9.74156428e-03f,
  -1.25484481e-01f, 2.09918600e-02f, 1.70590296e-01f, 6.40037060e-02f, -6.53470010e-02f, 5.39935939e-02f, 3.50675136e-02f, 4.65882421e-02f, -5.13786525e-02f, 1.16016921e-02f,
  1.79127213e-02f, 5.96650429e-02f, -2.03635897e-02f, 6.84761181e-02f, 4.76874448e-02f, -2.47124564e-02f, 6.77804463e-03f, 2.18040254e-02f, -3.21654789e-03f, 3.95107344e-02f,
  1.65568128e-01f, 2.39101872e-02f, 1.10784033e-02f, -3.07222027e-02f, -9.59895849e-02f, -7.82441720e-02f, -6.72480464e-02f, -5.98566160e-02f, -3.83604914e-02f, -1.54357150e-01f,
  -2.92039029e-02f, -1.00241108e-02f, -1.04647633e-02f, -7.51869157e-02f, 1.20282527e-02f, 3.73240709e-02f, -5.62936291e-02f, 9.21734646e-02f, 3.83701146e-04f, 8.34988207e-02f,
  -6.78057745e-02f, 2.52256133e-02f, 1.81804299e-02f, 1.05374150e-01f, 4.25609499e-02f, 5.04849590e-02f, -3.31782387e-03f, -9.74805877e-02f, 2.93162866e-05f, 9.51942578e-02f,
  -3.24911118e-01f, -2.10531488e-01f, -3.32783274e-02f, -2.24254932e-02f, -7.28163794e-02f, -4.53671515e-02f, 8.09602533e-03f, 8.20420012e-02f, -1.35699838e-01f, 1.03185617e-03f,
  -1.00206323e-02f, 1.68405063e-02f, -6.27464876e-02f, 6.97814599e-02f, 1.06802033e-02f, -2.54783817e-02f, -3.93519457e-03f, -4.34604101e-02f, 2.20332686e-02f, 3.09638921e-02f,
  7.25632533e-02f, 3.36803775e-03f, 9.73576587e-03f, 1.40550360e-01f, 8.67031962e-02f, 5.51058650e-02f, 7.46926591e-02f, -1.45997163e-02f, 7.70711824e-02f, 2.37851753e-03f,
  -3.38065565e-01f, 8.66131708e-02f, -2.57607460e-01f, -2.06725389e-01f, 6.98806792e-02f, 5.05787767e-02f, 1.21523194e-01f, -7.18240514e-02f, -1.32471234e-01f, 2.81083763e-01f,
  1.92504898e-01f, -2.12306902e-01f, 1.46058857e-01f, 4.97707985e-02f, -3.67113471e-01f, 1.00627102e-01f, 5.87760611e-03f, -2.11893078e-02f, -7.32988417e-02f, 5.87485060e-02f,
  -1.85187072e-01f, 1.81846067e-01f, -1.67944834e-01f, 1.34708792e-01f, 4.51434664e-02f, -8.04234892e-02f, 1.71352848e-01f, 7.59271299e-03f, 6.17627352e-02f, 4.51224558e-02f,
  8.24706182e-02f, -6.38897493e-02f, -7.58033991e-02f, -9.82133523e-02f, 6.63690642e-02f, 5.94120584e-02f, 6.01069555e-02f, 1.88255392e-03f, -1.53068490e-02f, -1.31178185e-01f,
  3.40323523e-02f, -9.48541090e-02f, 3.89732793e-02f, 2.58606896e-02f, -4.08321209e-02f, -5.53526841e-02f, -1.30724087e-01f, -3.48742194e-02f, 4.52838140e-03f, -8.86406973e-02f,
  -4.94287349e-03f, 4.92492982e-04f, -9.59282964e-02f, 2.82059740e-02f, -1.16961293e-01f, 3.19224447e-02f, -8.88624489e-02f, -7.59217814e-02f, 5.91352582e-02f, -5.29169142e-02f,
  3.71214300e-02f, 3.68659198e-02f, 8.16908404e-02f, 3.94115597e-02f, 8.11314117e-03f, 1.33003995e-01f, 1.46650700e-02f, 1.01766601e-01f, -5.39939106e-02f, -4.71212389e-03f,
  -2.37394571e-02f, -5.09008802e-02f, -2.39587687e-02f, -1.22409267e-02f, -5.49758635e-02f, 3.19667459e-02f, -6.73567876e-02f, 4.29137386e-02f, -4.42455988e-03f, -7.09426254e-02f,
  8.99946094e-02f, 2.33422816e-02f, 1.05559707e-01f, 8.02609846e-02f, -2.82616466e-02f, -4.57312576e-02f, 3.46192941e-02f, -2.67631859e-02f, 1.14088058e-01f, -6.17071986e-02f,
  8.77994299e-02f, -4.92386147e-02f, 1.14004269e-01f, -2.34379098e-02f, 6.64756969e-02f, 3.16022262e-02f, 4.08253968e-02f, -1.03515955e-02f, 6.84901606e-03f, 3.51276807e-02f,
  2.84462087e-02f, 5.41891232e-02f, 3.41841113e-03f, -1.21108694e-02f, -1.31066486e-01f, 7.19138458e-02f, 1.17010742e-01f, 5.66187799e-02f, -1.86437722e-02f, -6.60489779e-03f,
  5.24769984e-02f, 1.38271293e-02f, 6.63497078e-04f, -2.58739125e-02f, -1.66311132e-04f, 1.00063764e-01f, -6.97199255e-02f, 5.43041006e-02f, -5.63788898e-02f, -1.98842469e-03f,
  2.05535181e-02f, 1.08884133e-01f, -7.47207226e-03f, 1.00596182e-01f, -1.37385741e-01f, -2.08262548e-01f, -2.15380266e-01f, 1.21276639e-01f, -2.39464819e-01f, -1.65820252e-02f,
  1.57905474e-01f, -1.03751786e-01f, 9.79063883e-02f, -2.91998684e-02f, -6.62382692e-02f, 7.70535041e-03f, 2.26805788e-02f, -1.25588745e-01f, -8.30270499e-02f, 9.46726575e-02f,
  1.42888308e-01f, 1.46582276e-01f, 9.51812193e-02f, 1.46963015e-01f, 1.04848882e-02f, 1.47242948e-01f, 2.07541987e-01f, 1.04349084e-01f, 1.40069380e-01f, -8.53039399e-02f,
  7.89783150e-02f, 1.19143866e-01f, -3.81372496e-02f, -2.45032199e-02f, -6.94919657e-03f, 6.33445084e-02f, 6.88941106e-02f, 1.98602322e-02f, -7.39798844e-02f, -6.85644820e-02f,
  -1.59803759e-02f, 2.93837432e-02f, -7.51839802e-02f, -3.76183214e-03f, 2.91149933e-02f, 2.42324229e-02f, 1.81283355e-02f, -5.01265451e-02f, -5.26087098e-02f, -1.36621678e-02f,
  -1.01944871e-01f, -3.36056426e-02f, -1.86489057e-02f, -3.84750441e-02f, -1.91796031e-02f, -1.01085514e-01f, 1.79766715e-02f, 4.23528999e-02f, -1.34755550e-02f, -6.08968548e-02f,
  1.26680685e-02f, -3.46587226e-02f, -3.55284810e-02f, 4.13640067e-02f, -1.48883918e-02f, -3.02612837e-02f, -3.58539782e-02f, 5.86458221e-02f, 7.53718093e-02f, 8.36544782e-02f,
  -5.39033599e-02f, 6.24247454e-02f, 1.64381471e-02f, 2.32249070e-02f, 2.43496634e-02f, 5.45903780e-02f, 3.93598266e-02f, -5.53264134e-02f, 4.21744818e-03f, -1.00163314e-02f,
  1.08677018e-02f, 3.03270556e-02f, -9.13442019e-03f, 5.79801090e-02f, -5.49157560e-02f, -6.34063855e-02f, 7.00872689e-02f, 4.38855849e-02f, -4.48999815e-02f, -2.46788096e-02f,
  -1.10937636e-02f, 2.06838518e-01f, -8.28416739e-03f, -3.10887024e-03f, -5.36704995e-02f, -7.33172446e-02f, -3.51589285e-02f, 4.17643748e-02f, 1.11211054e-01f, 3.44040357e-02f,
  -1.97547711e-02f, -8.60152394e-02f, -1.06772818e-01f, -8.06280002e-02f, -5.93083166e-02f, 4.25801016e-02f, 1.06452651e-01f, 2.64284741e-02f, -4.84371698e-03f, 9.17234123e-02f,
  1.43299490e-01f, -5.53391650e-02f, -9.63501334e-02f, -7.57665262e-02f, -4.37506177e-02f, 8.77413973e-02f, 6.77225227e-03f, -5.83172701e-02f, 8.98902416e-02f, 5.80549352e-02f,
  -4.00585413e-01f, 1.96700767e-01f, 5.24069741e-02f, -3.98144990e-01f, 1.23808511e-01f, 1.15198746e-01f, -1.43394098e-01f, 1.62508428e-01f, 3.81778404e-02f, 1.96713462e-01f,
  5.00534177e-02f, -8.85623544e-02f, 1.48765892e-01f, -2.99636215e-01f, -1.98938549e-01f, -1.77980736e-01f, -2.64745176e-01f, -2.40829155e-01f, -1.02962442e-02f, -1.09533727e-01f,
  -3.02336328e-02f, -1.51249334e-01f, -2.13874385e-01f, 2.09872901e-01f, 1.78242270e-02f, 4.17386480e-02f, -1.93176225e-01f, 2.12692812e-01f, -1.74705938e-01f, 5.63134924e-02f,
  -9.70401913e-02f, 2.95374058e-02f, 1.57453970e-03f, 1.15066923e-01f, 1.51756434e-02f, 4.12026159e-02f, -2.59116013e-02f, 3.77427526e-02f, -1.05161068e-03f, 7.90833756e-02f,
  -1.38845500e-02f, 1.66447565e-01f, -1.05388366e-01f, 9.67472568e-02f, 3.86044011e-02f, 8.21140110e-02f, -8.77984837e-02f, 9.60690808e-03f, 9.82598402e-03f, 1.16855025e-01f,
  -1.93075333e-02f, 2.34251507e-02f, -9.34518466e-04f, -7.80683905e-02f, -9.19707716e-02f, 1.21020362e-01f, 1.15730157e-02f, 1.20892748e-02f, 1.64513011e-02f, -7.66172186e-02f,
  -1.00847080e-01f, -4.30692136e-02f, 6.74623903e-03f, 6.20811731e-02f, 7.13237971e-02f, 5.99670857e-02f, 1.25619337e-01f, -5.17485216e-02f, 3.12770121e-02f, 1.01162933e-01f,
  -6.38656840e-02f, 2.60635489e-03f, -5.34582548e-02f, -9.65437666e-03f, -5.32114357e-02f, -2.23186705e-03f, -7.26568997e-02f, 8.49837512e-02f, -7.82751143e-02f, -2.32318370e-03f,
  -7.76062440e-03f, -5.85048227e-03f, -3.71926539e-02f, -4.93743718e-02f, 4.95792553e-02f, 6.48635551e-02f, 5.80830052e-02f, 4.10787091e-02f, -9.91146918e-03f, -8.63035321e-02f,
  -2.49869693e-02f, 1.04799934e-01f, 9.08274576e-02f, 1.66558191e-01f, 7.63048381e-02f, -3.09668873e-02f, 3.60012241e-02f, 3.90195362e-02f, -4.17807288e-02f, -1.60528757e-02f,
  -5.80260204e-03f, -4.27652039e-02f, -1.73781943e-02f, -5.22965081e-02f, 3.85645404e-02f, -8.25512484e-02f, -9.90765318e-02f, -9.01954919e-02f, 5.42496108e-02f, 1.62020177e-01f,
  2.97088083e-02f, 7.49395862e-02f, -6.55910522e-02f, -2.26524696e-02f, 3.21648493e-02f, -3.27906162e-02f, 3.05976626e-02f, 1.11706130e-01f, -3.05768959e-02f, -7.98708424e-02f,
  1.63384989e-01f, 2.41936937e-01f, 2.48191375e-02f, 7.34417439e-02f, -3.76236327e-02f, -2.87225425e-01f, -1.94385141e-01f, -6.51943758e-02f, 1.07639693e-01f, 1.64977923e-01f,
  -1.98757187e-01f, 3.11630189e-01f, -1.31001517e-01f, -1.26054943e-01f, -3.28070790e-01f, -2.61312753e-01f, -2.09449291e-01f, -3.04980781e-02f, 8.60694870e-02f, -5.45669943e-02f,
  -1.12062514e-01f, -1.96660146e-01f, -1.97537869e-01f, -3.41917872e-02f, 8.82827342e-02f, 1.89087540e-01f, -1.76654518e-01f, 1.01177813e-02f, 4.87608686e-02f, -5.14877290e-02f,
  -9.41173658e-02f, -3.53694372e-02f, 1.11802042e-01f, 6.52421936e-02f, -1.38707638e-01f, 8.98740143e-02f, 3.87359895e-02f, 4.04195786e-02f, -5.70542626e-02f, 1.35087259e-02f,
  -1.89697719e-03f, -3.44815552e-02f, 3.81776728e-02f, -9.38457623e-03f, 1.24646783e-01f, 6.43237829e-02f, -3.72688510e-02f, -3.29165831e-02f, 3.93208005e-02f, 2.62340307e-02f,
  -3.01776966e-03f, 1.27346115e-02f, 5.58642112e-02f, 1.04172966e-02f, -7.96988234e-02f, 4.69783396e-02f, 7.46629313e-02f, 5.20387962e-02f, -1.32547328e-02f, 4.56305109e-02f,
  -3.07028135e-03f, -2.32089348e-02f, -2.20039021e-03f, 2.44307034e-02f, -1.90352544e-03f, -2.56214174e-03f, -3.89326573e-03f, -4.67071272e-02f, 6.61118850e-02f, -2.44329162e-02f,
  2.53017503e-03f, 1.43626258e-01f, 4.99044023e-02f, 6.06400222e-02f, -6.94572479e-02f, 2.21744422e-02f, 1.09271444e-01f, 2.83808243e-02f, 1.69616118e-02f, 7.61378035e-02f,
  4.16751094e-02f, -9.58259553e-02f, 5.90939745e-02f, -1.38426162e-02f, -6.78670704e-02f, -2.14834157e-02f, -5.00995442e-02f, 7.27347434e-02f, -8.37809369e-02f, -7.75794610e-02f,
  -3.13614488e-01f, -2.74923176e-01f, 9.32223164e-03f, 5.11066541e-02f, -9.58526973e-03f, -7.07905889e-02f, -1.35247018e-02f, 9.77954417e-02f, -1.27445251e-01f, 6.00679666e-02f,
  9.37023386e-03f, -8.70851427e-02f, -8.56027007e-03f, 3.41049470e-02f, -1.26876738e-02f, -7.85560533e-02f, 5.38101280e-03f, -4.16190624e-02f, 1.11636063e-02f, -5.77615611e-02f,
  -2.55256798e-02f, 5.23185432e-02f, -1.30394213e-02f, 4.53377841e-03f, 1.65392819e-03f, -8.12535882e-02f, -1.83239803e-02f, -9.49508790e-03f, 9.97995608e-04f, -6.29085395e-03f,
  -3.23008567e-01f, 2.35044695e-02f, -8.00620839e-02f, -1.40548736e-01f, -5.79554625e-02f, 2.60123461e-01f, 8.47905129e-02f, -1.02058306e-01f, -3.48979115e-01f, -1.90477651e-02f,
  1.61260143e-01f, -2.28706256e-01f, 8.28967616e-02f, -5.29772006e-02f, -5.21731861e-02f, 1.62635192e-01f, 2.63710245e-02f, 9.71691567e-04f, 1.63625460e-03f, -1.66860819e-01f,
  -1.30087018e-01f, 3.86708118e-02f, 5.39329387e-02f, -6.60123825e-02f, -6.56444430e-02f, -1.33254260e-01f, -6.15131631e-02f, -6.41855225e-02f, -6.26790524e-02f, -1.37783647e-01f,
  5.81666455e-02f, -3.26403640e-02f, 5.14442809e-02f, -7.36865774e-02f, 5.87767102e-02f, -2.20782273e-02f, 1.14486016e-01f, 1.05372407e-01f, -6.22864552e-02f, 3.45351286e-02f,
  -1.88701097e-02f, -1.21410996e-01f, 5.99706033e-03f, -1.53014094e-01f, -1.06404461e-01f, -2.82732099e-02f, 1.89512800e-02f, 2.73161214e-02f, 5.83943538e-02f, -7.76435509e-02f,
  -2.95130182e-02f, 2.03198697e-02f, -4.55659069e-02f, 9.64128524e-02f, -1.50944218e-01f, -3.63772959e-02f, 9.65401456e-02f, 1.02493376e-01f, 1.97499432e-02f, -1.45927876e-01f,
  -5.40546374e-03f, 6.57335818e-02f, 1.33921325e-01f, 6.68094084e-02f, 1.03848234e-01f, 1.60008855e-02f, 4.84410785e-02f, -3.16675007e-02f, -4.43774462e-02f, -7.42009580e-02f,
  1.81897136e-03f, -1.18614426e-02f, -7.31980056e-02f, -6.09472059e-02f, 2.83764163e-03f, -8.22227821e-02f, -2.67343484e-02f, -5.59167415e-02f, -4.57351841e-02f, -9.73594654e-03f,
  3.58889215e-02f, -1.12438388e-01f, -3.22215771e-03f, 1.16808884e-01f, 7.55092874e-02f, -1.74855832e-02f, -2.03589369e-02f, -4.13619727e-02f, 3.70633230e-02f, -1.21419253e-02f,
  1.05687201e-01f, -1.40563637e-01f, 6.66638985e-02f, -1.48890931e-02f, 9.74438339e-02f, 1.17348887e-01f, -3.39134447e-02f, -8.37124959e-02f, -1.35372498e-03f, -1.14311809e-02f,
  2.74096038e-02f, 5.43939061e-02f, -1.01625212e-01f, -6.70183823e-02f, -6.82671219e-02f, 1.42126247e-01f, 1.45583883e-01f, 8.61271255e-05f, -1.71679705e-02f, 6.35428950e-02f,
  -1.46657648e-02f, -1.64488144e-02f, -4.38260175e-02f, 6.74100965e-02f, -7.03579222e-04f, -4.23181728e-02f, -3.34755704e-02f, 5.19430786e-02f, 1.28788009e-01f, -4.53713462e-02f,
  -1.37793437e-01f, 9.66587663e-03f, 2.46702895e-01f, 2.74994690e-02f, 2.29373947e-01f, 3.60626310e-01f, 2.23816484e-01f, 2.68014640e-01f, 3.17037940e-01f, -1.51557863e-01f,
  -1.73067436e-01f, -2.35035419e-01f, -5.63968495e-02f, -6.50306046e-02f, 1.69406772e-01f, 7.33946860e-02f, 2.14893743e-01f, -7.30288103e-02f, 1.56455770e-01f, 6.67752847e-02f,
  8.38706419e-02f, 2.78099049e-02f, 3.06013525e-02f, -2.27382947e-02f, -1.16681168e-02f, -8.82180631e-02f, -2.27618322e-01f, 1.24347903e-01f, -3.37122753e-02f, 9.35589746e-02f,
  -2.20172219e-02f, -1.06291287e-01f, 3.15771741e-03f, -4.15298305e-02f, 5.68641387e-02f, 6.68892497e-03f, 9.71940160e-02f, 1.93721354e-02f, -2.78133526e-02f, -1.55708585e-02f,
  -1.44745722e-01f, -1.32250078e-02f, 6.12945594e-02f, -6.10563159e-03f, 1.20825134e-01f, -6.48596976e-03f, 5.14920391e-02f, -3.14896815e-02f, 5.26050404e-02f, 2.08832193e-02f,
  1.02339953e-01f, -2.22624261e-02f, 6.39190748e-02f, 7.09128007e-02f, 4.25464660e-02f, -1.85456201e-02f, 4.29503694e-02f, 6.48589954e-02f, 5.32244258e-02f, 9.40123945e-03f,
  6.18538857e-02f, 1.80110242e-02f, 4.07972978e-03f, -1.07320428e-01f, 3.97251127e-03f, 1.25259105e-02f, 5.54034999e-03f, -1.27413794e-01f, -3.54301669e-02f, 1.02197208e-01f,
  6.36291504e-02f, -2.03508455e-02f, 1.21272035e-01f, 5.93682239e-03f, -5.89955598e-02f, 1.76944863e-02f, -1.62098911e-02f, -3.80895589e-03f, 3.00497226e-02f, 2.29589008e-02f,
  -6.93145171e-02f, -2.15796065e-02f, -1.00945637e-01f, -8.07344615e-02f, -3.82473432e-02f, 6.06203824e-02f, 2.11193692e-02f, 2.41065416e-02f, -1.39693571e-02f, 2.90609319e-02f,
  -1.11874916e-01f, -6.24896586e-02f, -4.58087251e-02f, 6.66537657e-02f, 2.36222278e-02f, -3.42192017e-02f, 1.20443754e-01f, 7.43246526e-02f, 2.52735075e-02f, -7.30476081e-02f,
  -8.84971246e-02f, -1.19432844e-01f, 5.10087758e-02f, -5.23919761e-02f, 1.80379152e-02f, 1.22629568e-01f, -8.84326082e-03f, 1.70758646e-02f, -1.47893235e-01f, -9.36658680e-02f,
  -3.03796474e-02f, -1.01219714e-01f, -1.08028449e-01f, -1.06569715e-01f, -7.16149658e-02f, -7.05369487e-02f, -1.37644634e-01f, 4.38197283e-03f, 2.30092723e-02f, 3.28277200e-02f,
  2.63344198e-01f, -3.76906335e-01f, 3.60063687e-02f, 1.51407793e-01f, 3.55001688e-01f, 6.10624738e-02f, 1.66419730e-01f, 1.02865070e-01f, 1.83348164e-01f, -2.22838268e-01f,
  -9.27818492e-02f, -2.39996701e-01f, -3.15090626e-01f, 9.49312374e-02f, 1.65841550e-01f, -1.35587856e-01f, 1.86142311e-01f, -5.67628965e-02f, -1.89903043e-02f, -6.61134049e-02f,
  8.20206627e-02f, 1.35998413e-01f, 8.29527974e-02f, 5.29988445e-02f, 1.73674718e-01f, 9.36379135e-02f, 5.79792075e-02f, 6.98791891e-02f, 1.54777691e-01f, 1.48929805e-01f,
  1.15853414e-01f, -6.65689111e-02f, 3.42698172e-02f, -7.68045411e-02f, 2.10580621e-02f, -7.49839693e-02f, 4.65147570e-02f, 1.22626238e-01f, 1.29434897e-03f, 8.14024173e-03f,
  -2.82599754e-03f, 8.78086165e-02f, 5.19625330e-03f, 3.80890891e-02f, 4.08947878e-02f, -2.23526470e-02f, 6.93295524e-02f, -2.15959065e-02f, -6.40641227e-02f, -6.35368153e-02f,
  -1.26662016e-01f, -2.53266911e-03f, 2.57909093e-02f, 5.52236922e-02f, -7.35053420e-03f, 1.18126303e-01f, -6.69580251e-02f, -3.92946489e-02f, 2.95908935e-02f, -1.15216831e-02f,
  -5.18296361e-02f, -1.12729087e-01f, 8.03635716e-02f, 1.06183201e-01f, 7.31148273e-02f, 1.05933070e-01f, -1.22880301e-04f, -1.70915897e-04f, 4.86163348e-02f, -3.59913744e-02f,
  -3.95705039e-03f, 3.42865437e-02f, -2.53836811e-02f, -6.29773363e-02f, -4.56305072e-02f, -5.46719208e-02f, 8.35513547e-02f, -3.66481841e-02f, -7.29260594e-02f, 3.96626368e-02f,
  -1.15680611e-02f, 6.08697943e-02f, -5.82195399e-03f, 1.53027415e-01f, 3.51843871e-02f, 7.50598535e-02f, -7.03169033e-02f, 1.63536868e-03f, -6.67518526e-02f, 2.84249950e-02f,
  -1.17886573e-01f, -2.76714116e-01f, -7.06346631e-02f, -2.04622727e-02f, 4.87773344e-02f, -2.47965455e-02f, -1.26120867e-02f, 6.34260941e-03f, 1.30839599e-02f, -5.13202744e-04f,
  4.20991853e-02f, 4.98513542e-02f, 3.15556414e-02f, 1.06839724e-01f, -4.60732542e-02f, -5.63673582e-03f, -3.16057280e-02f, -2.08147205e-02f, 7.87010789e-02f, -4.00366634e-02f,
  4.03924063e-02f, 1.43479286e-02f, 5.16964160e-02f, 9.27421153e-02f, -7.97776356e-02f, -3.50306071e-02f, 6.02883250e-02f, -1.10793728e-02f, -2.19999626e-02f, 1.97639428e-02f,
  2.13242099e-01f, -2.88394272e-01f, -2.33420506e-01f, -1.33134974e-02f, 1.46457896e-01f, 3.48581940e-01f, 9.64470282e-02f, -1.02333404e-01f, -2.98725903e-01f, -5.73846549e-02f,
  1.33849546e-01f, 6.25952482e-02f, -2.38359526e-01f, 7.50661939e-02f, 1.71763167e-01f, -1.56973571e-01f, 8.48866478e-02f, 2.63628289e-02f, -2.05481634e-01f, 8.30978826e-02f,
  -1.28194690e-01f, 1.53247431e-01f, -5.07142134e-02f, 1.60675436e-01f, 1.01661995e-01f, 4.93404903e-02f, 1.99977890e-01f, 9.09162313e-02f, 1.87472403e-01f, 2.51068950e-01f,
  -3.38988118e-02f, -7.37104118e-02f, -1.33966338e-02f, 3.79114784e-02f, -8.55315477e-03f, 1.42134503e-01f, 1.61253795e-01f, 1.26300961e-01f, -1.03188433e-01f, 1.73128154e-02f,
  -4.08540107e-02f, 1.16778165e-01f, 4.61309850e-02f, 3.92536484e-02f, -3.41227395e-03f, -5.80616370e-02f, -9.30641443e-02f, 7.66318515e-02f, -9.40941721e-02f, -8.14631879e-02f,
  -1.24658190e-01f, 4.30983715e-02f, -3.83219905e-02f, 6.00632280e-02f, 1.03156054e-02f, -1.24024384e-01f, 8.92048422e-03f, 4.98995222e-02f, -4.49272580e-02f, 3.33112776e-02f,
  4.13413625e-03f, 1.12299677e-02f, 1.32484054e-02f, -1.17051467e-01f, 3.81330736e-02f, -1.50879221e-02f, -1.88260674e-02f, -1.31161466e-01f, -4.37948592e-02f, -4.56942730e-02f,
  -7.47851059e-02f, 1.35024516e-02f, -1.46478992e-02f, 8.74341130e-02f, 1.09650768e-01f, -4.35400661e-03f, 4.83030155e-02f, 8.41604918e-02f, -1.28574699e-01f, -1.05655402e-01f,
  -2.18301043e-02f, 3.71612087e-02f, 2.11352482e-03f, -9.33331177e-02f, -4.27231416e-02f, 6.92326427e-02f, 2.59809792e-02f, -6.17491454e-02f, 8.95463750e-02f, -3.26079465e-02f,
  1.36645734e-01f, 6.47450332e-03f, -8.19435194e-02f, -3.73054408e-02f, -3.49240936e-02f, -6.26938269e-02f, -7.09455088e-02f, -4.30020243e-02f, -4.57820892e-02f, -1.01743773e-01f,
  1.69450656e-01f, 2.41619982e-02f, -3.75018567e-02f, 7.19154552e-02f, 4.03689444e-02f, -3.93579826e-02f, -1.56668145e-02f, 9.14960261e-03f, 7.86039010e-02f, -1.76763367e-02f,
  1.08897185e-03f, 1.02156676e-01f, 8.18014666e-02f, 5.38606159e-02f, -2.13713571e-02f, 6.54173940e-02f, 1.52201504e-01f, -2.38011032e-02f, -8.48852098e-02f, -7.87337217e-03f,
  -8.70639011e-02f, 2.50419497e-01f, -9.18535292e-02f, -1.08962543e-01f, 1.33122817e-01f, 3.57470922e-02f, -1.86793745e-01f, 9.05626789e-02f, -1.73089176e-01f, 1.90367088e-01f,
  -6.70398176e-02f, 1.24984264e-01f, -1.21688008e-01f, -2.27456272e-01f, -2.11551711e-01f, -3.08423042e-01f, 7.46312924e-03f, -8.48618746e-02f, -1.82359591e-02f, 6.47887811e-02f,
  -1.29450813e-01f, -8.48781466e-02f, -2.73070693e-01f, 8.61627385e-02f, 1.18843816e-01f, 9.19188112e-02f, 1.24707736e-01f, -7.24539906e-03f, 1.61667377e-01f, -1.40363678e-01f,
  -8.53317603e-02f, -1.11178808e-01f, -8.60330015e-02f, -1.56762134e-02f, -6.96922839e-02f, 7.69898966e-02f, -2.83573382e-02f, -1.08376198e-01f, -1.41956151e-01f, 9.96174011e-03f,
  1.55200779e-01f, -6.07767841e-03f, 4.53420915e-02f, -3.41247059e-02f, 4.45912331e-02f, -9.92310466e-04f, -2.55700201e-03f, 5.58368713e-02f, 6.89552948e-02f, -4.32554595e-02f,
  -1.29892394e-01f, -1.68978423e-02f, 1.80953294e-01f, -6.69014156e-02f, -1.38139194e-02f, 2.23998651e-02f, 4.85446900e-02f, -2.72130333e-02f, 1.83577970e-01f, -1.15098953e-01f,
  -2.96782963e-02f, 1.65239442e-02f, 2.47366494e-03f, -1.02316923e-01f, -7.15622380e-02f, -4.56390642e-02f, -2.32711043e-02f, 6.80227801e-02f, -3.06909923e-02f, -6.07398525e-02f,
  2.03940514e-02f, -3.15489881e-02f, 6.14522696e-02f, 8.00330285e-03f, -3.35862301e-02f, -3.94395962e-02f, 4.30119075e-02f, -4.05785255e-02f, -2.51670312e-02f, 8.46028626e-02f,
  -7.54284114e-02f, 2.95048151e-02f, 1.79876778e-02f, 1.01338275e-01f, 4.20239531e-02f, -5.56341633e-02f, 1.27745271e-02f, -4.14576791e-02f, 2.39245035e-02f, 8.02598000e-02f,
  1.33734569e-01f, 1.45259798e-01f, -2.24023722e-02f, -8.19994975e-03f, 2.78009456e-02f, 8.36241320e-02f, -2.39241458e-02f, 1.19114421e-01f, 7.51307085e-02f, 1.42378971e-01f,
  6.95215687e-02f, 2.86407191e-02f, 1.33747205e-01f, -1.30696343e-02f, 6.51881397e-02f, 1.18129075e-01f, -3.08047514e-02f, -5.03528975e-02f, 1.04654603e-01f, 1.98013261e-02f,
  4.80714552e-02f, 1.38463244e-01f, 7.95997232e-02f, 3.60789113e-02f, 1.05056643e-01f, 1.19178675e-01f, 1.30171284e-01f, 4.65422161e-02f, 4.13191691e-02f, 9.43153203e-02f,
  5.57959490e-02f, 1.77575439e-01f, 1.11618511e-01f, -9.27091949e-03f, -1.88031048e-01f, 1.50909990e-01f, 1.77624643e-01f, 1.31300747e-01f, 1.70972377e-01f, 1.58374429e-01f,
  -1.66628823e-01f, 2.46895418e-01f, 5.99808395e-02f, 2.59762281e-03f, -4.27526794e-02f, 1.03842899e-01f, 4.37365621e-02f, -3.97517309e-02f, 2.17776876e-02f, 1.62465841e-01f,
  -4.97025326e-02f, -1.93140030e-01f, -9.41975489e-02f, -9.30643231e-02f, -1.31472675e-02f, -4.76899259e-02f, -2.98608601e-01f, -1.23795532e-01f, -1.13264523e-01f, -1.47415087e-01f,
  9.88690630e-02f, 2.40708739e-01f, 7.35851899e-02f, 2.25404605e-01f, 4.07793224e-02f, -5.30025549e-02f, 3.81301790e-02f, 5.68718230e-03f, 6.12649545e-02f, 9.26192626e-02f,
  5.37266657e-02f, 2.85131708e-02f, 1.33433193e-01f, -1.08700141e-01f, 2.12432761e-02f, -6.49679452e-02f, 2.99387928e-02f, 6.20612018e-02f, 6.81801364e-02f, -2.68885661e-02f,
  -1.70252402e-03f, 9.61467996e-02f, 1.94347929e-02f, 3.95683907e-02f, 4.30913083e-02f, 8.64081923e-03f, 2.46236697e-02f, -1.64587989e-01f, 1.83077063e-02f, 5.57734519e-02f,
  -5.64374775e-02f, -4.21202276e-03f, 8.90424848e-02f, -6.08005095e-03f, 7.15374155e-03f, -8.20891261e-02f, -7.03376308e-02f, 1.74848307e-02f, 2.75710672e-02f, -8.69729370e-02f,
  5.44257276e-02f, 9.63558350e-03f, 7.36544132e-02f, 1.60481874e-02f, -9.89963263e-02f, 6.07727654e-02f, -5.73252998e-02f, -7.60795772e-02f, 7.62518719e-02f, 3.96656618e-02f,
  1.46915736e-02f, 1.12453587e-01f, -1.09152332e-01f, -1.06690682e-01f, -2.68805269e-02f, -8.54946822e-02f, -7.06757009e-02f, 2.64817216e-02f, -2.55170297e-02f, -3.75161842e-02f,
  9.99958962e-02f, 1.78951308e-01f, 1.30423576e-01f, 5.59643582e-02f, 6.73917159e-02f, -1.59234479e-02f, 9.27603468e-02f, 5.93659244e-02f, 7.79488608e-02f, 7.09818676e-02f,
  -7.86467828e-03f, 1.10634655e-01f, 4.11571451e-02f, -3.44410650e-02f, -3.03060617e-02f, 6.41966611e-02f, 1.55176604e-02f, 5.96667789e-02f, 2.10583652e-03f, -9.10167098e-02f,
  5.09521812e-02f, -1.60191078e-02f, 6.42245933e-02f, -5.47160618e-02f, -4.29441519e-02f, 2.17912290e-02f, 1.06413439e-02f, 9.08212662e-02f, -1.34689063e-01f, -7.41511062e-02f,
  -5.01984954e-01f, 2.53108948e-01f, -1.79870546e-01f, -1.08872466e-01f, -1.34030864e-01f, 1.32249668e-02f, -1.07530914e-01f, -1.47565883e-02f, -1.52209699e-01f, 1.02603219e-01f,
  -9.30174589e-02f, -2.10807472e-01f, 2.33605549e-01f, 8.50459039e-02f, -1.29699752e-01f, 2.63348728e-01f, -6.98645264e-02f, -2.22570468e-02f, 9.53410640e-02f, -2.56036744e-02f,
  -2.26890799e-02f, 1.62988529e-02f, 1.39899626e-01f, 1.92002714e-01f, -2.01768085e-01f, -1.42812401e-01f, -4.58587296e-02f, 4.52398546e-02f, -9.63506252e-02f, -3.75637524e-02f,
  -2.70147204e-01f, -1.00432977e-01f, -4.13447246e-02f, -1.67839140e-01f, -2.29866534e-01f, -1.88396256e-02f, -1.14899009e-01f, -8.27435851e-02f, -6.23009056e-02f, -4.91995215e-02f,
  3.81214358e-02f, 3.94348279e-02f, 6.00660220e-02f, 4.92778532e-02f, 2.79392265e-02f, -6.53859377e-02f, 1.47639392e-02f, -1.34799890e-02f, 4.30796035e-02f, 1.11346088e-01f,
  2.52402481e-02f, -6.10616850e-03f, -5.67927510e-02f, 3.73265594e-02f, 5.14309667e-02f, 2.44821515e-02f, 3.70404273e-02f, 3.02627441e-02f, -5.47786355e-02f, -4.59797829e-02f,
  -3.29209678e-02f, -3.74393277e-02f, -5.95026389e-02f, -1.13214962e-01f, -1.32779013e-02f, 2.61545610e-02f, -6.72594979e-02f, -7.26004094e-02f, -1.57967024e-02f, -7.10076699e-03f,
  -4.76340018e-02f, -1.19576074e-01f, 6.12151399e-02f, 1.05048260e-02f, -9.01406929e-02f, -1.18775576e-01f, 5.10432981e-02f, 1.33216167e-02f, -3.06793842e-02f, -3.84371094e-02f,
  -3.53652611e-02f, 4.29253578e-02f, 7.40444660e-02f, -2.68639587e-02f, 4.54101041e-02f, 1.94160957e-02f, -1.22183282e-02f, 2.25545857e-02f, 2.32592952e-02f, -3.08162458e-02f,
  -2.03436568e-01f, -3.48979592e-01f, -3.67682464e-02f, -2.75909305e-02f, -1.06680505e-01f, 3.76070403e-02f, 5.19798435e-02f, 2.59392746e-02f, -7.18395486e-02f, -2.95734592e-02f,
  -8.24205577e-02f, -7.88584873e-02f, -3.73410597e-03f, -8.35410058e-02f, 1.16553460e-03f, 2.57317200e-02f, -6.37447760e-02f, -1.31303929e-02f, -1.45611420e-01f, -6.18876070e-02f,
  3.45471874e-02f, -7.51733482e-02f, -1.04737002e-02f, 6.17135651e-02f, 2.91675534e-02f, -8.46773107e-03f, -1.62580892e-01f, 4.31397893e-02f, 3.02880909e-02f, 1.13900542e-01f,
  -3.13051194e-02f, 2.06385806e-01f, 5.40046655e-02f, 3.75549309e-02f, 1.24049030e-01f, -1.06029570e-01f, -1.42692402e-01f, 1.55956835e-01f, -1.92200065e-01f, 7.28353858e-02f,
  1.53070182e-01f, 1.16711818e-01f, -5.26460782e-02f, 2.68759970e-02f, -4.06727269e-02f, -1.99885547e-01f, 4.29949164e-02f, -6.21487014e-02f, 2.60547865e-02f, 4.28097099e-02f,
  3.89662129e-03f, 1.36908293e-01f, -7.17973784e-02f, 2.64481455e-02f, 2.51407363e-03f, 9.68081206e-02f, 1.03359826e-01f, -3.44118886e-02f, 2.19946310e-01f, 2.28567477e-02f,
  -8.21367279e-02f, -4.53043915e-02f, -8.64680260e-02f, -8.39692503e-02f, 6.58174977e-02f, 1.23318285e-01f, -2.20887437e-02f, 7.45339096e-02f, -5.51190786e-02f, -4.86716591e-02f,
  -1.31669883e-02f, 2.12291605e-03f, -3.70925926e-02f, -6.59529939e-02f, 8.06677267e-02f, -1.37680516e-01f, 2.90721375e-02f, 9.64346752e-02f, -7.40906596e-02f, -1.68895740e-02f,
  9.98977497e-02f, 5.16741909e-02f, -1.27115101e-02f, 9.94672403e-02f, -3.42662968e-02f, 1.11236307e-03f, -1.51267126e-01f, -1.78211518e-02f, 3.13264430e-02f, 2.37420350e-02f,
  1.58343464e-01f, -1.04176886e-01f, 2.97158258e-03f, -6.73615113e-02f, -5.92982061e-02f, 1.65390912e-02f, 6.41310588e-02f, -3.64180617e-02f, -1.71268303e-02f, -9.81710181e-02f,
  1.57828089e-02f, 5.63625284e-02f, -8.53051841e-02f, 4.03970256e-02f, 2.96004652e-03f, -9.11598504e-02f, 4.41176817e-02f, 1.17057808e-01f, 1.98198371e-02f, -2.12031975e-02f,
  -1.34658590e-02f, -4.76883128e-02f, -1.51843026e-01f, -1.13095632e-02f, -1.35474026e-01f, 1.89183354e-02f, 9.99907926e-02f, -9.49047506e-03f, -3.24115111e-03f, 9.25716236e-02f,
  2.32230321e-01f, 2.10412055e-01f, 4.75623459e-02f, -8.54764581e-02f, -6.48992360e-02f, 2.29923651e-02f, -1.93030480e-02f, 1.43227473e-01f, 1.08576111e-01f, -5.40012754e-02f,
  7.03594461e-02f, 8.37550014e-02f, 1.53132528e-01f, -8.67558569e-02f, 7.42595270e-02f, 1.75022963e-03f, -3.55363525e-02f, 1.23755962e-01f, 7.44328350e-02f, -3.54149677e-02f,
  1.41814038e-01f, 2.04837974e-02f, -8.74363855e-02f, 1.09708384e-01f, 1.07962519e-01f, 4.80980575e-02f, 2.23151315e-02f, -1.24895260e-01f, 1.68897286e-01f, 4.71970392e-03f,
  -1.94454402e-01f, -1.36374980e-02f, 2.94922948e-01f, -2.15730399e-01f, 1.27382949e-01f, 3.30762088e-01f, 2.58981436e-01f, -1.72090501e-01f, -3.34514946e-01f, -1.09857433e-01f,
  -7.10926950e-02f, 8.40764493e-02f, 2.42684975e-01f, -2.80518472e-01f, 4.66977730e-02f, 5.69855981e-03f, -1.62080824e-01f, -3.12809795e-02f, 1.00342877e-01f, 8.22229162e-02f,
  -1.26083806e-01f, -2.89424419e-01f, 1.43528059e-01f, 5.12794368e-02f, 1.21203773e-01f, 1.01582505e-01f, -2.22656921e-01f, 3.05844218e-01f, 1.00753702e-01f, 2.07833722e-01f,
  1.28602654e-01f, -3.75364199e-02f, -4.47431616e-02f, -3.19457576e-02f, 9.83201712e-02f, 4.40442301e-02f, 6.92970976e-02f, 1.20347910e-01f, -1.10160690e-02f, -8.14913139e-02f,
  -8.07207972e-02f, 7.31680915e-02f, -1.38764098e-01f, 2.63112150e-02f, -6.34711981e-02f, -9.26078781e-02f, 1.31176203e-01f, 1.09676324e-01f, 4.08629589e-02f, 6.63718954e-02f,
  7.32567012e-02f, 7.90411904e-02f, -7.06088170e-02f, -1.91529561e-02f, -3.74083929e-02f, -4.54139076e-02f, 7.46642277e-02f, 1.38232797e-01f, 5.20936549e-02f, -1.17048156e-02f,
  -1.12846389e-01f, -1.93671323e-02f, 2.66249292e-03f, 2.70748828e-02f, 8.62556845e-02f, -4.71049026e-02f, -5.89333735e-02f, 8.38218704e-02f, -2.35540420e-02f, -1.28067330e-01f,
  -1.08017609e-01f, -5.82398288e-02f, -1.47648258e-02f, -6.43577352e-02f, -5.77129126e-02f, -7.23927021e-02f, 6.12570830e-02f, 1.04708359e-01f, 1.65957585e-02f, -8.24232623e-02f,
  -3.26639577e-03f, 5.62847219e-02f, -3.16234790e-02f, -8.69629085e-02f, 1.35410102e-02f, 2.68510580e-02f, -8.48121047e-02f, -1.91695476e-03f, -4.72766086e-02f, 7.46770799e-02f,
  9.41646397e-02f, -1.53981164e-01f, -3.89858223e-02f, 4.96760709e-03f, -8.06672219e-03f, -4.78509404e-02f, -4.53342870e-02f, -4.81382571e-02f, -2.45988723e-02f, -2.52984744e-03f,
  7.36692129e-03f, -4.17848378e-02f, -6.92798272e-02f, 2.52652448e-02f, 4.36878502e-02f, -1.89458746e-02f, 7.66239017e-02f, -8.07202011e-02f, -6.54533952e-02f, 9.86589640e-02f,
  -1.23139126e-02f, -2.15076469e-02f, 2.03697098e-04f, -1.65032893e-01f, -1.16157763e-01f, -6.35245368e-02f, -3.90154426e-03f, 8.69326293e-03f, -1.49748838e-02f, 1.19872494e-02f,
  -4.52129915e-02f, 1.74241781e-01f, 1.41936988e-01f, 2.08416998e-01f, 2.27015391e-01f, 2.00283915e-01f, -5.25266752e-02f, 2.57595271e-01f, 2.12508768e-01f, -3.61626968e-02f,
  1.09819481e-02f, -1.41079262e-01f, -2.20670793e-02f, 1.38161957e-01f, -2.11894184e-01f, 1.97975457e-01f, 6.62712827e-02f, 6.77390769e-02f, 1.46764681e-01f, -3.09489947e-02f,
  1.48767784e-01f, 8.25536400e-02f, 6.15786575e-02f, 1.18939981e-01f, 1.28499016e-01f, 4.77167405e-02f, -2.86829382e-01f, -9.09115672e-02f, -4.79775071e-02f, -1.20569482e-01f,
  -1.89631760e-01f, -6.42394722e-02f, -1.41779870e-01f, -1.46720633e-01f, 6.03128150e-02f, -1.52417764e-01f, -1.75126567e-01f, -1.84463456e-01f, -1.06916420e-01f, -4.19178754e-02f,
  -3.65164094e-02f, -5.99500397e-03f, -3.64429057e-02f, -6.19302690e-02f, -8.66636112e-02f, 6.87723048e-03f, 3.32957059e-02f, 1.45721510e-01f, 1.32551640e-02f, 6.20879903e-02f,
  -1.63144339e-02f, 4.18000817e-02f, 7.11643323e-02f, -3.83744761e-02f, -2.46265549e-02f, 4.44063805e-02f, 4.17232700e-02f, -9.04572681e-02f, -3.34468447e-02f, 3.15506905e-02f,
  3.09516564e-02f, -3.33168581e-02f, -1.73685569e-02f, -6.95605725e-02f, 4.38766629e-02f, -1.54827833e-02f, 1.16643654e-02f, 1.45013193e-02f, -2.50966325e-02f, -1.71587206e-02f,
  -5.51410243e-02f, 9.85933188e-03f, 1.49174586e-01f, 4.62375395e-02f, 4.39432561e-02f, 4.97424882e-03f, -2.37676036e-02f, -1.46439010e-02f, 2.73582153e-02f, -7.09300265e-02f,
  -2.48379223e-02f, -5.98274209e-02f, -5.86849712e-02f, -7.55981430e-02f, -1.09123550e-01f, 1.56757254e-02f, 7.70774037e-02f, 1.06953599e-01f, -7.21415207e-02f, -1.24373943e-01f,
  -1.25224516e-01f, -1.21772237e-01f, -1.77982256e-01f, -6.10885508e-02f, -1.22295208e-01f, -4.30538040e-03f, -6.50613196e-03f, -6.27772808e-02f, -4.67981733e-02f, -4.56904992e-02f,
  5.35005517e-02f, 4.44129892e-02f, -6.29495531e-02f, 3.56602222e-02f, -7.98167661e-02f, -9.07175243e-02f, 8.42330884e-03f, -1.09953299e-01f, -1.45829529e-01f, -2.71498598e-02f,
  -5.87477610e-02f, 6.10061772e-02f, -4.20922190e-02f, -1.08266011e-01f, 6.44395454e-03f, -1.23949997e-01f, -1.56537611e-02f, -7.88205713e-02f, -7.41924122e-02f, -2.54609864e-02f,
  8.30418169e-02f, -1.41279057e-01f, -1.84296519e-01f, -1.21685587e-01f, 1.06853142e-01f, 1.23464257e-01f, -5.54036610e-02f, -9.75736305e-02f, -2.46306136e-01f, 2.15066746e-01f,
  -7.20585287e-02f, -1.54759109e-01f, -2.27317750e-03f, -2.63488203e-01f, -1.25561699e-01f, -2.63922930e-01f, -1.87845714e-02f, -3.76991183e-02f, -1.85901612e-01f, 2.07644969e-01f,
  -5.87104782e-02f, 3.67620550e-02f, -2.42091030e-01f, 1.25023589e-01f, 1.25567034e-01f, -1.10894535e-02f, 2.14115947e-01f, 5.67657687e-02f, 1.34056360e-01f, -1.10088967e-01f,
  1.97801441e-02f, -1.03503972e-01f, -5.06558046e-02f, -1.04259945e-01f, -2.25476269e-02f, 9.95491073e-02f, 1.37235388e-01f, -9.85102057e-02f, -5.29791862e-02f, -6.04271777e-02f,
  7.33406469e-02f, -9.05590539e-04f, -5.60594536e-03f, -4.22615819e-02f, -3.09463944e-02f, -3.74388546e-02f, 8.89412500e-03f, 4.47009392e-02f, 6.07764497e-02f, 1.56472754e-02f,
  -4.09509130e-02f, 3.68529335e-02f, 7.09244981e-02f, -1.56217143e-02f, -3.93926762e-02f, 2.64340769e-02f, 2.70226561e-02f, -8.12310167e-03f, -1.27241462e-02f, -2.02323571e-02f,
  5.90042993e-02f, 1.16495430e-01f, 3.78204994e-02f, -1.08021148e-01f, -3.77453193e-02f, 1.93327144e-02f, -1.59413032e-02f, 3.40589173e-02f, 3.75472521e-03f, 5.45453764e-02f,
  6.14629760e-02f, 2.80239936e-02f, 3.08483783e-02f, -1.34974951e-02f, -6.39381446e-03f, 5.45810238e-02f, 9.34679992e-03f, 7.91868493e-02f, 5.06966189e-02f, -1.02923103e-01f,
  -2.04316191e-02f, 4.97024469e-02f, 5.73498756e-02f, 5.73548004e-02f, -2.24651136e-02f, -3.21050547e-02f, -5.33189923e-02f, 1.90415420e-02f, -2.13457714e-03f, -3.90584697e-03f,
  2.61055287e-02f, 1.68648615e-01f, 7.86906108e-03f, -1.77035779e-02f, 3.12970728e-02f, 1.29419953e-01f, -8.84319767e-02f, -9.33274478e-02f, 5.48276640e-02f, 6.80819899e-02f,
  2.42073536e-02f, -1.81185491e-02f, 1.33933097e-01f, 4.27181013e-02f, -2.02654693e-02f, 7.57596791e-02f, 1.15528837e-01f, 7.00192824e-02f, 1.26620345e-02f, 1.10396385e-01f,
  1.13383748e-01f, 1.36610912e-02f, 2.19428279e-02f, -3.33351530e-02f, -3.38627137e-02f, 2.79220995e-02f, 3.39670330e-02f, 9.39155445e-02f, 4.55312543e-02f, -1.85837597e-02f,
  3.82833257e-02f, -2.05327883e-01f, -1.41862497e-01f, 1.06083244e-01f, -1.98120009e-02f, -2.30599388e-01f, -3.90270710e-01f, -1.39328800e-02f, -2.12777302e-01f, -2.22749487e-01f,
  -4.97579463e-02f, -1.79432437e-01f, -2.51721442e-01f, 7.54595548e-02f, 2.43696213e-01f, -2.42520705e-01f, 9.33853835e-02f, -8.71748477e-03f, -9.24480557e-02f, 4.26639803e-03f,
  1.67654738e-01f, 1.46650478e-01f, 2.22451106e-01f, 3.28541875e-01f, 4.80305515e-02f, 1.97966278e-01f, 3.23587984e-01f, -2.76672840e-02f, 3.24756622e-01f, 1.72412187e-01f,
  -5.25054038e-02f, -1.15221284e-01f, -2.81664031e-03f, 4.18427959e-02f, 7.84273371e-02f, 3.70261655e-03f, -7.43878931e-02f, -3.01513411e-02f, -2.88983304e-02f, -2.88411174e-02f,
  -4.22046185e-02f, 3.72934006e-02f, 8.63253027e-02f, 2.45303065e-02f, 9.77622122e-02f, 7.14496300e-02f, -8.74843448e-03f, -4.16667685e-02f, -8.45921338e-02f, 8.45949426e-02f,
  -4.71453518e-02f, -7.28056058e-02f, 7.96241872e-03f, 1.07195474e-01f, 1.00526111e-02f, 9.18174982e-02f, -1.74013097e-02f, -2.80423276e-02f, 3.25979032e-02f, -9.36604384e-03f,
  2.19331626e-02f, 6.76087663e-02f, -5.88720366e-02f, 4.45423611e-02f, 6.24557734e-02f, 4.01543491e-02f, 5.49403504e-02f, 7.64647201e-02f, 6.66169599e-02f, -3.59470695e-02f,
  2.44812500e-02f, 5.68212895e-03f, 6.52651489e-03f, -1.08924821e-01f, 2.51909383e-02f, 7.31762312e-03f, 2.55623460e-03f, -2.57168226e-02f, -3.64592969e-02f, -3.61272134e-02f,
  -1.01470724e-02f, -2.37407647e-02f, -9.61506814e-02f, -2.75234133e-02f, -4.79600346e-03f, -1.00862287e-01f, -5.28410636e-03f, 2.02350784e-02f, -4.28108312e-02f, 1.30554643e-02f,
  6.27947152e-02f, 9.58735049e-02f, -3.49097289e-02f, 1.92950796e-02f, -3.40648484e-03f, 4.86019850e-02f, 9.31583494e-02f, 1.10113777e-01f, 2.61471774e-02f, -4.42553125e-02f,
  -4.44646813e-02f, 8.27614591e-02f, -3.93971754e-03f, 5.56939980e-03f, 4.38658036e-02f, -7.59297386e-02f, -8.30172077e-02f, 1.16982929e-01f, 7.32529238e-02f, 2.38844799e-03f,
  -8.04311931e-02f, -8.89969021e-02f, 3.46204527e-02f, -9.03808698e-02f, -4.31691296e-02f, -7.73246437e-02f, 1.11172479e-02f, 2.58516357e-03f, 8.28887597e-02f, -2.09944397e-02f,
  2.93339882e-02f, 2.50657171e-01f, -2.75742292e-01f, 1.29716456e-01f, -2.06997067e-01f, 5.69710881e-02f, 2.46199802e-01f, -2.69670691e-02f, 1.78507447e-01f, 2.70311177e-01f,
  1.14256956e-01f, 1.06387205e-01f, 1.84933633e-01f, 2.04523340e-01f, 1.71420295e-02f, 2.07898468e-01f, 2.44412199e-01f, 1.80939168e-01f, -9.40177366e-02f, 1.40750140e-01f,
  -6.45334497e-02f, 1.99241757e-01f, -9.34030861e-02f, -2.52474211e-02f, -1.31231859e-01f, -2.45491743e-01f, -8.28655958e-02f, -1.92974836e-01f, -6.54099137e-02f, -1.28558412e-01f,
  -6.17137365e-02f, -8.50609690e-02f, 1.08227581e-02f, 6.00035936e-02f, 4.95474711e-02f, -1.52710617e-01f, -1.96812954e-02f, -1.13068953e-01f, -1.16852857e-01f, 4.60875519e-02f,
  8.97132829e-02f, 2.06101537e-02f, 9.51172188e-02f, 2.55289655e-02f, -9.22472477e-02f, -2.72974540e-02f, -4.63401936e-02f, -6.32925406e-02f, -2.53183767e-02f, -3.84568167e-03f,
  -3.68565507e-02f, -6.79151192e-02f, 4.04078849e-02f, 6.39389008e-02f, -1.45996884e-01f, 6.24498986e-02f, -4.59018834e-02f, -8.50925893e-02f, 6.52507022e-02f, 2.50977594e-02f,
  -5.51244058e-02f, 5.49180135e-02f, 7.21151801e-03f, -5.66451587e-02f, -3.06461267e-02f, -1.12765551e-01f, -1.07884100e-02f, -5.74809834e-02f, -1.67626829e-03f, -5.42454515e-03f,
  6.83230013e-02f, -6.36401102e-02f, -6.56773448e-02f, 1.66072957e-02f, 3.55706923e-02f, 8.76451805e-02f, -2.83660311e-02f, 8.22849348e-02f, 1.60997938e-02f, -8.08240771e-02f,
  -5.32379597e-02f, 5.14069013e-02f, 5.58422022e-02f, -7.19551668e-02f, -6.96458248e-03f, 3.35000758e-03f, 2.66071147e-04f, 3.12978439e-02f, -1.39999634e-03f, -9.92006883e-02f,
  7.91008472e-02f, 1.12186763e-02f, 2.28357073e-02f, 1.55638689e-02f, 5.74990064e-02f, -9.73645225e-02f, 2.78305169e-02f, 6.63441569e-02f, -3.08417343e-03f, -2.28857119e-02f,
  1.00116327e-01f, -3.53564359e-02f, 3.01415613e-03f, 7.90782571e-02f, -4.08835448e-02f, -3.72647829e-02f, 4.48597334e-02f, -4.40975502e-02f, 8.70194361e-02f, 2.31107883e-02f,
  -7.98560157e-02f, 5.27801365e-03f, 5.34561574e-02f, 4.04017493e-02f, 1.42288255e-03f, -5.14151193e-02f, 6.24258481e-02f, -1.26623318e-01f, -1.26421154e-01f, 4.30228515e-03f,
  8.99785608e-02f, -1.03337035e-01f, -2.50026017e-01f, -1.98625550e-02f, 5.52582070e-02f, 2.06120104e-01f, 9.17401537e-02f, -4.52717207e-02f, -2.16779947e-01f, 9.16534439e-02f,
  1.63158879e-01f, -1.11037739e-01f, -1.63435876e-01f, 9.80599374e-02f, 1.74048290e-01f, -2.12031897e-04f, 1.38723269e-01f, 1.84753790e-01f, -7.54901245e-02f, 8.83843973e-02f,
  6.47536740e-02f, 3.17038804e-01f, -5.38205542e-03f, 1.77302048e-01f, 5.54131046e-02f, -5.64912334e-03f, 5.33957705e-02f, -1.79730490e-01f, 2.79249758e-01f, 1.21618949e-01f,
  8.39951783e-02f, -2.76286993e-02f, 7.95886200e-03f, 1.80991031e-02f, 1.34527765e-03f, 1.23433452e-02f, 4.88444651e-03f, 9.56062824e-02f, -1.97768491e-02f, -1.30235394e-02f,
  -3.49272676e-02f, 4.52740975e-02f, -3.11838035e-02f, -1.00155354e-01f, -8.29360411e-02f, -5.83826564e-02f, -8.24152976e-02f, -8.01668912e-02f, -7.20955580e-02f, -6.84096813e-02f,
  -1.48224384e-01f, 3.54335345e-02f, -5.06139956e-02f, 2.71230284e-02f, -1.10538946e-02f, 2.35077105e-02f, -4.41142794e-04f, -5.73671609e-02f, -7.14213476e-02f, 4.08439115e-02f,
  -8.13756790e-03f, 5.78494594e-02f, -2.26355325e-02f, 2.60093268e-02f, -1.71169895e-03f, 3.90027575e-02f, 4.85021546e-02f, 1.84522029e-02f, -8.86743739e-02f, 4.54344880e-03f,
  1.52668264e-02f, -8.95687714e-02f, 2.94623487e-02f, -5.30783571e-02f, 1.11058112e-02f, -6.61498085e-02f, -1.05784886e-01f, -3.78546901e-02f, -9.35248658e-02f, -7.59717450e-02f,
  5.84364822e-03f, 1.48512116e-02f, -7.28588700e-02f, -2.55678012e-03f, 7.72116426e-03f, 2.88528316e-02f, 2.87742075e-02f, 3.39112878e-02f, -3.90206575e-02f, 1.15160672e-02f,
  8.90140161e-02f, 1.18726626e-01f, -4.50900346e-02f, 1.03549948e-02f, -5.35398610e-02f, -8.03654641e-03f, 4.05528545e-02f, 8.99764076e-02f, -4.63918298e-02f, 8.09675008e-02f,
  8.79587829e-02f, -4.07979526e-02f, 1.37332908e-03f, -4.64542024e-02f, 1.35104898e-02f, -5.67501485e-02f, 9.44342092e-02f, -8.44276771e-02f, -4.66277599e-02f, 2.04904433e-02f,
  -8.38918090e-02f, 1.96388829e-02f, 4.92797084e-02f, -5.70383258e-02f, 3.07411794e-02f, 5.29956026e-03f, -8.00205097e-02f, -8.37962851e-02f, -1.78742334e-02f, -3.70556004e-02f,
  2.11302549e-01f, -3.37836176e-01f, 1.23691358e-01f, 1.29736021e-01f, 2.80956775e-01f, 1.99781358e-01f, 2.16622084e-01f, 1.83452275e-02f, 1.84232756e-01f, -3.45380992e-01f,
  8.86392742e-02f, -1.45793959e-01f, -1.09575121e-02f, -2.16102794e-01f, 1.55719697e-01f, -9.04866010e-02f, -7.17741847e-02f, -1.94840550e-01f, 1.69047490e-02f, 1.05849216e-02f,
  1.48136213e-01f, -1.94871798e-02f, -8.44827220e-02f, -2.88541645e-01f, -4.03590277e-02f, -5.37287183e-02f, 4.71268557e-02f, -3.72958072e-02f, -2.75069952e-01f, -1.35931477e-01f,
  1.47294924e-01f, -4.70116436e-02f, 5.87629639e-02f, -4.26863544e-02f, 3.29091810e-02f, -3.22468579e-02f, 9.23639722e-03f, 3.63214836e-02f, 2.15246737e-01f, 6.60926029e-02f,
  -8.60901847e-02f, -8.28439817e-02f, -5.71228378e-02f, -2.99819838e-02f, 1.78558789e-02f, -6.55946583e-02f, 8.80543366e-02f, 2.18465496e-02f, -7.93396905e-02f, -1.22920059e-01f,
  2.23497041e-02f, -8.43299702e-02f, -4.18488961e-03f, -1.89733163e-01f, -7.97487870e-02f, 2.04355791e-02f, 6.12094114e-03f, -3.48387770e-02f, -3.87570262e-02f, -3.92690767e-03f,
  -4.12963377e-03f, -2.71553528e-02f, -6.23424277e-02f, -3.64024788e-02f, -8.26241225e-02f, 9.65471640e-02f, 4.50428165e-02f, -7.70538151e-02f, -2.81662736e-02f, 1.20949568e-02f,
  7.34130442e-02f, -6.90099820e-02f, 8.81556198e-02f, -2.29593143e-02f, -2.55777165e-02f, 2.37452872e-02f, -8.15251246e-02f, -1.32974043e-01f, 4.08797599e-02f, -2.89575662e-02f,
  1.37472674e-02f, 1.89493597e-02f, 1.20036835e-02f, 3.64398360e-02f, 8.40386450e-02f, -8.28539254e-04f, -1.74914017e-01f, -1.01413533e-01f, 1.59348711e-01f, -5.91885708e-02f,
  1.66102592e-02f, -2.66015768e-01f, 1.01078704e-01f, 9.73135792e-03f, -4.90661785e-02f, -4.02642302e-02f, -2.92186700e-02f, -3.98362465e-02f, -5.79236411e-02f, -8.60806927e-02f,
  -2.60708737e-03f, -6.02270290e-02f, 4.64397557e-02f, -5.86796440e-02f, 5.37889637e-02f, -4.41332487e-03f, -2.38693412e-02f, -7.73269758e-02f, 8.38609561e-02f, -3.21789458e-02f,
  -4.40499112e-02f, -1.22271992e-01f, 3.36755230e-03f, -4.65527698e-02f, -3.30361798e-02f, -4.88181151e-02f, 3.58819589e-02f, -1.04632214e-01f, -1.43523337e-02f, 3.34057659e-02f,
  2.56013334e-01f, -1.97187737e-01f, -1.25131518e-01f, 1.81828216e-01f, 2.87172850e-02f, -6.34867921e-02f, 3.21057998e-02f, -7.94423521e-02f, -7.63695389e-02f, -2.61835963e-01f,
  8.03891718e-02f, 1.19249560e-02f, -3.88660952e-02f, 1.83469713e-01f, 3.91358525e-01f, 9.06172395e-02f, 4.33456823e-02f, 6.71020746e-02f, 6.22175746e-02f, 1.15447983e-01f,
  1.99846789e-01f, 1.83425501e-01f, 2.10930333e-01f, -3.87757458e-02f, 1.47560328e-01f, -7.17618782e-03f, 3.99995446e-02f, -9.63132828e-02f, 1.77849550e-02f, 1.14474073e-01f,
  4.00751196e-02f, 8.44696462e-02f, -2.56941020e-02f, -3.05503537e-03f, 1.53693035e-01f, -2.41625942e-02f, -4.57335413e-02f, -2.11435021e-03f, 1.13693014e-01f, -4.14233468e-02f,
  -4.52249721e-02f, 7.10134134e-02f, 5.08152181e-03f, 6.92621171e-02f, -4.64069284e-02f, -5.53002842e-02f, -5.53977536e-03f, 1.51240109e-02f, 9.28004924e-03f, -6.79345280e-02f,
  -1.17348721e-02f, -4.50040735e-02f, -3.59736867e-02f, -4.91179377e-02f, -6.30413443e-02f, -5.52608445e-02f, 8.01581424e-03f, -8.44626408e-03f, -5.48969433e-02f, 7.56685883e-02f,
  -1.02754503e-01f, -3.91336940e-02f, -5.14439531e-02f, 2.62355208e-02f, 7.30072632e-02f, -1.52005823e-02f, -7.42113292e-02f, 2.70123556e-02f, -1.12018390e-02f, 1.42025217e-01f,
  5.14712967e-02f, 9.77591276e-02f, 8.99179578e-02f, -1.40051380e-01f, -2.07038242e-02f, 7.94784799e-02f, -5.78375394e-03f, -6.57238141e-02f, 2.92483997e-02f, 2.95917112e-02f,
  -9.85824969e-04f, 6.26529604e-02f, -1.76489223e-02f, -1.12039000e-01f, -9.02348161e-02f, -4.45586257e-02f, -4.34392951e-02f, 1.33778062e-02f, 4.89143021e-02f, 3.63648385e-02f,
  1.05530448e-01f, 1.04298361e-01f, 6.38342317e-05f, 4.71469238e-02f, -3.75292450e-02f, -6.35233521e-02f, 1.11262359e-01f, -8.23084712e-02f, 9.26950499e-02f, 2.06173752e-02f,
  1.43957010e-03f, 6.41644523e-02f, -1.09400660e-01f, -2.88436618e-02f, 3.94967236e-02f, 5.28608635e-02f, 4.31314819e-02f, 2.30393782e-02f, 5.74905090e-02f, 2.04390008e-02f,
  1.49979061e-02f, -1.29943445e-01f, 7.69886374e-02f, -1.04783267e-01f, -5.39455302e-02f, 2.43533943e-02f, -9.20123160e-02f, 1.97329577e-02f, -4.25600074e-02f, 2.76190112e-03f,
  2.56087780e-01f, 3.14317167e-01f, 3.01938318e-02f, 2.54543424e-01f, -3.68141793e-02f, 2.25058541e-01f, 1.71120584e-01f, -2.24971976e-02f, 1.78440049e-01f, 8.93983021e-02f,
  1.15247567e-04f, 1.77546546e-01f, 7.68542755e-03f, 2.38275737e-01f, 2.18130559e-01f, -5.16805649e-02f, 1.92516997e-01f, 1.79323003e-01f, 5.98248392e-02f, 2.58837193e-01f,
  6.99200183e-02f, 7.39162490e-02f, -3.11567914e-02f, -7.96887875e-02f, 5.27856871e-02f, -4.97584678e-02f, -7.27452114e-02f, -2.04693004e-01f, -7.20668063e-02f, 1.81804933e-02f,
  1.00579359e-01f, 8.63716006e-02f, -5.93785979e-02f, -2.84048449e-02f, -2.71701217e-02f, 2.35799290e-02f, -3.88163999e-02f, -5.53753339e-02f, 7.63656385e-03f, 1.37551306e-02f,
  1.17862217e-01f, -1.12026734e-02f, 8.94093364e-02f, 1.82353482e-02f, -1.30820954e-02f, -7.60622695e-02f, -1.60516817e-02f, -8.96883607e-02f, -9.95191000e-03f, -1.96561427e-03f,
  2.07234137e-02f, 6.16845377e-02f, -4.57031541e-02f, 4.43015844e-02f, 2.17769612e-02f, 4.06906381e-02f, 1.58095583e-02f, -2.48553120e-02f, 7.69513473e-02f, 7.11778179e-02f,
  -1.36539517e-02f, -1.53685119e-02f, -3.11996974e-03f, 4.30145748e-02f, 4.42768075e-02f, 1.49569316e-02f, 3.76216546e-02f, -1.07643858e-01f, -2.16660704e-02f, 6.30534962e-02f,
  3.67270522e-02f, 7.56987184e-03f, -2.85918601e-02f, 1.61542408e-02f, 4.34384383e-02f, 4.87740524e-02f, 1.45461047e-02f, 3.69598828e-02f, 7.57330805e-02f, -1.07716106e-01f,
  -4.76970710e-02f, 6.90596625e-02f, -2.98902555e-03f, 1.00070769e-02f, 6.11016266e-02f, -9.30752307e-02f, -1.04190793e-03f, -3.64883021e-02f, -7.62277022e-02f, 3.48401591e-02f,
  1.42045751e-01f, 1.61784872e-01f, 7.18318522e-02f, 6.16208836e-02f, -5.55209219e-02f, 7.25567937e-02f, -4.12269570e-02f, 7.95793906e-02f, 4.22736108e-02f, 8.21000338e-02f,
  9.82126147e-02f, 1.06089421e-01f, 2.38905419e-02f, -2.92464346e-02f, 1.14325304e-02f, -2.40138453e-02f, 1.18209273e-01f, -3.04261949e-02f, -1.53732700e-02f, -8.30867141e-02f,
  5.27692065e-02f, 3.94854546e-02f, 8.22684094e-02f, -2.58959569e-02f, 6.15307689e-02f, 3.10614668e-02f, 2.66771503e-02f, 8.12585000e-03f, 1.03655770e-01f, 5.81368320e-02f,
  -5.37014663e-01f, 3.55765313e-01f, 7.44932741e-02f, -2.29233518e-01f, 2.48168260e-02f, 1.34709671e-01f, -5.91956154e-02f, 9.84597430e-02f, -1.77218206e-02f, 8.39142054e-02f,
  4.00472321e-02f, -5.81068061e-02f, 1.26772672e-01f, 1.26006484e-01f, -1.86495036e-01f, 1.41807169e-01f, -5.14419340e-02f, -7.43682235e-02f, 1.26511499e-01f, 3.46546732e-02f,
  -1.05956040e-01f, -2.47829203e-02f, 1.65502816e-01f, 2.57292241e-01f, 9.62287094e-03f, -4.83566970e-02f, -7.71871060e-02f, 1.46331772e-01f, -1.39484582e-02f, 4.87937918e-03f,
  -2.11384505e-01f, -2.11088255e-01f, -1.85310200e-01f, -1.31562606e-01f, -9.02670473e-02f, -1.27520919e-01f, -5.95187135e-02f, -8.12467933e-02f, 5.88820688e-02f, -8.87952894e-02f,
  -2.41313670e-02f, 2.40684431e-02f, -4.54964228e-02f, 4.26756342e-05f, -1.53260361e-02f, -2.89617795e-02f, 1.40525579e-01f, 1.19016310e-02f, 3.41115221e-02f, 4.82493937e-02f,
  2.00395241e-01f, 1.34324003e-02f, -1.40180625e-02f, 1.05591649e-02f, -6.01367615e-02f, -6.29122034e-02f, -6.66860193e-02f, -4.11542691e-02f, 5.92089258e-02f, -9.42400545e-02f,
  -1.21842334e-02f, 1.05796307e-02f, 1.13263791e-02f, 2.67212968e-02f, 8.12949836e-02f, 4.06249538e-02f, -3.90894599e-02f, -3.45506094e-04f, 1.74722709e-02f, 4.21937518e-02f,
  -5.50226010e-02f, -3.34765166e-02f, -9.25216451e-02f, -8.89965240e-03f, 1.04928344e-01f, -6.61385953e-02f, -3.21092792e-02f, 9.47388541e-03f, 7.96182752e-02f, 4.49409038e-02f,
  -9.16919559e-02f, -2.01799478e-02f, -1.52562493e-02f, 2.10780837e-02f, 6.57093674e-02f, -1.07427100e-02f, -9.03645158e-02f, -4.62641212e-04f, -1.36117106e-02f, -4.73497361e-02f,
  -4.32256758e-01f, -3.25630933e-01f, -4.89083976e-02f, -1.03582017e-01f, -1.37873823e-02f, -3.45428400e-02f, -1.04788482e-01f, -4.93411049e-02f, -1.31255403e-01f, 2.36388408e-02f,
  1.70781184e-03f, -8.30752254e-02f, -7.30162114e-02f, -1.28124179e-02f, 3.38201597e-02f, 2.89685633e-02f, -5.57195172e-02f, -1.68216094e-01f, -1.06218860e-01f, -7.20373541e-02f,
  1.89290401e-02f, 4.73824069e-02f, 9.30315703e-02f, -2.08573863e-02f, -9.87112746e-02f, -5.63104711e-02f, -2.01352891e-02f, -2.77437121e-02f, -3.32841277e-02f, 1.03903607e-01f,
  -1.72000885e-01f, 1.32592097e-01f, 5.95766380e-02f, 4.23574299e-02f, 1.63882688e-01f, 3.17129910e-01f, 1.25206560e-01f, 1.81338415e-01f, 2.77711719e-01f, -1.15419719e-02f,
  -1.68844640e-01f, -1.38936713e-01f, -2.11417541e-01f, -2.99981516e-03f, 1.16775207e-01f, 1.29508838e-01f, 2.31218636e-01f, -2.16072276e-02f, 1.13403685e-01f, 1.19010903e-01f,
  1.56099766e-01f, 5.57837337e-02f, -4.86092530e-02f, -4.56727929e-02f, -5.65873235e-02f, -1.83202401e-01f, -2.58403301e-01f, -6.34585321e-02f, -1.10455394e-01f, 1.50831267e-02f,
  9.18740258e-02f, -7.83588067e-02f, -1.75647810e-01f, -3.52115780e-02f, -7.96092600e-02f, -2.12427322e-02f, -9.90444236e-03f, 1.54210059e-02f, -2.10466981e-02f, -9.19142924e-03f,
  2.90629221e-03f, -6.00549914e-02f, 6.61059842e-02f, -5.41541763e-02f, 4.88702282e-02f, 5.45961373e-02f, 2.37984639e-02f, 4.32435609e-02f, -3.05297505e-02f, -8.04993231e-03f,
  -6.22046515e-02f, 8.59916806e-02f, -3.99283320e-02f, 5.70775121e-02f, 1.43295834e-02f, 7.60681033e-02f, 1.17941245e-01f, -3.77240442e-02f, -1.09053217e-02f, 3.60495448e-02f,
  3.35905328e-02f, 1.32544994e-01f, -8.13056678e-02f, -6.50941133e-02f, -8.19872227e-03f, 2.38403808e-02f, -6.17412897e-03f, -3.52917686e-02f, 3.28666866e-02f, 3.10115647e-02f,
  -1.06072582e-01f, -7.61928484e-02f, -1.87271256e-02f, 7.85662308e-02f, 9.68843177e-02f, -2.67487336e-02f, -4.19194102e-02f, 6.68177083e-02f, 1.17760375e-02f, 1.01986304e-01f,
  5.06110601e-02f, -1.86766107e-02f, -1.50093213e-01f, 5.31548001e-02f, 2.88313255e-02f, -3.07523571e-02f, -7.19750226e-02f, -9.44015384e-02f, 3.53406905e-03f, 7.45817423e-02f,
  2.62103617e-01f, 2.84804732e-01f, -9.71852764e-02f, -6.24105856e-02f, -9.86922011e-02f, 3.10006775e-02f, 1.04387201e-01f, 5.23901582e-02f, -5.73754311e-02f, -4.06519882e-02f,
  -3.11898589e-02f, -1.18783843e-02f, 4.03229110e-02f, -4.13204655e-02f, 2.34732442e-02f, 9.63777304e-03f, -4.81544323e-02f, 9.09074023e-03f, 8.14228132e-02f, 5.36645129e-02f,
  -1.72218289e-02f, 1.01259559e-01f, -8.09929371e-02f, 1.49218859e-02f, 7.39675090e-02f, -2.28142757e-02f, -1.02373287e-02f, -9.70089510e-02f, 2.25555282e-02f, 6.49113208e-02f,
  3.31363529e-01f, 3.26853633e-01f, 2.29911149e-01f, 2.26484910e-01f, -2.51342446e-01f, -3.38707268e-01f, -2.30275661e-01f, -3.18490863e-02f, 1.46859914e-01f, -3.24641950e-02f,
  -1.92377329e-01f, 4.05153930e-01f, -9.91720036e-02f, 9.43024680e-02f, 2.58176439e-02f, -8.23310316e-02f, 1.50820896e-01f, -5.16097210e-02f, 9.80644748e-02f, 2.20318735e-01f,
  1.14914574e-01f, -1.56634346e-01f, 7.29194134e-02f, -1.19136222e-01f, 3.94681760e-04f, 2.04464287e-01f, 2.36321576e-02f, -5.66088259e-02f, 2.07854614e-01f, -7.46476427e-02f,
  -9.38216299e-02f, 1.30308852e-01f, 9.56426933e-02f, 8.57843831e-03f, 4.96303067e-02f, -5.27056940e-02f, -9.54630971e-02f, -1.26276135e-01f, 4.91187796e-02f, -3.90824676e-03f,
  -2.10970547e-02f, 5.36479205e-02f, 2.50538439e-02f, -1.20814174e-01f, -6.68987334e-02f, 8.86481702e-02f, 5.14501594e-02f, 4.14929427e-02f, 1.35266826e-01f, -1.45150134e-02f,
  1.23232819e-01f, -3.33951488e-02f, 1.30905345e-01f, 1.69484928e-01f, 1.33961827e-01f, 2.27797450e-03f, 5.99407032e-02f, 6.97099417e-02f, 8.98574889e-02f, 1.19817480e-01f,
  5.80899231e-02f, -8.15947354e-02f, 3.44636589e-02f, 7.76893571e-02f, 9.28478595e-03f, -1.93075296e-02f, 4.36307080e-02f, -1.58095527e-02f, 8.03390890e-02f, 1.50926802e-02f,
  -9.15044844e-02f, 6.24208301e-02f, -4.47740704e-02f, -6.08894899e-02f, 5.94176911e-02f, 8.21134821e-02f, 4.68598045e-02f, -3.68366279e-02f, 1.72567423e-02f, 6.00912049e-02f,
  -9.49054807e-02f, -6.71945214e-02f, 8.06479231e-02f, -2.50662751e-02f, -3.78275998e-02f, 3.43715809e-02f, 1.60974264e-02f, 3.04476339e-02f, 3.80252190e-02f, -5.72250672e-02f,
  9.49638858e-02f, 2.74037331e-01f, 1.06080785e-01f, 3.44125405e-02f, -4.78762994e-03f, 3.85480039e-02f, 1.67828649e-02f, 9.13621560e-02f, 1.19043142e-02f, -1.74918808e-02f,
  4.93053757e-02f, -4.97317291e-04f, -5.65361157e-02f, 1.65875889e-02f, 1.69115122e-02f, 6.05673902e-02f, 4.54226462e-03f, 7.05724657e-02f, 7.16487840e-02f, 7.73022175e-02f,
  3.15687023e-02f, -8.23846236e-02f, 2.88425107e-02f, -3.79399620e-02f, -5.66641465e-02f, 4.47368212e-02f, 2.97013973e-03f, 1.15323216e-01f, -3.25652026e-02f, 1.30106032e-01f,
  1.08815089e-01f, -1.77082136e-01f, 1.67015359e-01f, -1.35991499e-01f, 2.03960150e-01f, -8.61676410e-02f, 2.37919986e-02f, -3.75083461e-02f, -1.25164874e-02f, -3.03249478e-01f,
  -1.09315157e-01f, 3.88335921e-02f, 4.14782465e-02f, -1.62191167e-01f, 2.92945474e-01f, 1.17755778e-01f, -1.87079415e-01f, -5.85149452e-02f, 5.91800660e-02f, -9.53607336e-02f,
  6.09154515e-02f, -4.45549600e-02f, 6.21341309e-03f, -2.58951545e-01f, -1.42938316e-01f, -1.87968746e-01f, -9.41384137e-02f, 5.26065119e-02f, -1.25701979e-01f, 2.91010868e-02f,
  -1.45959824e-01f, -2.47575920e-02f, 2.62146369e-02f, -1.01012565e-01f, -6.54185489e-02f, -9.99956741e-04f, -4.30199802e-02f, 9.98433083e-02f, -5.96414134e-02f, -4.26334441e-02f,
  2.10008733e-02f, -4.08016369e-02f, 6.97339606e-03f, -4.60186880e-03f, -9.76885036e-02f, -7.63370171e-02f, 1.93615947e-02f, 3.18362415e-02f, 1.54016109e-03f, 5.21188676e-02f,
  5.17812446e-02f, -3.12763825e-03f, 9.50828120e-02f, -9.22393948e-02f, 1.29441649e-01f, -2.78134574e-03f, 6.22407682e-02f, -7.31681520e-03f, -5.85223027e-02f, 2.06124596e-02f,
  -1.38412416e-02f, 1.08751051e-01f, -5.40970601e-02f, -3.09773553e-02f, 6.10624887e-02f, 4.57569435e-02f, -3.86942774e-02f, 1.00947350e-01f, -7.01847970e-02f, -2.04969030e-02f,
  4.46212525e-03f, 4.19596136e-02f, 6.06837235e-02f, 6.22547492e-02f, 2.49711052e-02f, 8.51059216e-04f, -5.83638214e-02f, 7.72646219e-02f, -6.46647364e-02f, 9.35851336e-02f,
  8.59296531e-04f, -7.70800337e-02f, -6.13220483e-02f, 3.51045392e-02f, -1.90688968e-01f, -8.24199244e-03f, 1.97431445e-02f, -1.08593285e-01f, -3.26290727e-02f, 8.24820027e-02f,
  -2.87760198e-01f, -1.94212914e-01f, -1.88637152e-02f, -8.90536681e-02f, -5.62410280e-02f, -9.19060037e-02f, 1.31453812e-01f, -1.11184068e-01f, -2.14437339e-02f, -7.16948323e-03f,
  -9.20830444e-02f, -1.49557088e-02f, -6.34446964e-02f, -2.88486038e-03f, -2.96860449e-02f, 9.26339477e-02f, -8.06408562e-03f, -2.69836634e-02f, -1.10887170e-01f, 8.56954791e-03f,
  -9.57968980e-02f, 8.46468061e-02f, 1.09866083e-01f, -9.06912759e-02f, 7.21175447e-02f, -6.00784533e-02f, 1.12196706e-01f, -3.38616297e-02f, 5.06234355e-02f, -4.41496484e-02f,
  -1.07873924e-01f, -2.06454635e-01f, 3.14740241e-01f, -8.47762898e-02f, 1.55706808e-01f, 1.15172267e-01f, 1.95387155e-01f, 4.34749556e-04f, -1.60722882e-01f, -2.19953895e-01f,
  -6.15607165e-02f, -3.34540121e-02f, 1.50076911e-01f, -7.30866194e-02f, 3.61300915e-01f, 5.32050356e-02f, -1.07614823e-01f, -1.16729178e-01f, -6.80241957e-02f, -4.55725640e-02f,
  8.31865426e-03f, -1.83183879e-01f, 2.15712741e-01f, -7.83930644e-02f, 3.82417627e-02f, 3.06036361e-02f, -1.17611684e-01f, 2.68574029e-01f, -1.48264602e-01f, 7.86659792e-02f,
  -8.99264887e-02f, -1.79699481e-01f, -7.58366659e-02f, -2.35457588e-02f, -4.55936119e-02f, -4.69858237e-02f, -4.10508290e-02f, -1.18963504e-02f, -1.09238839e-02f, 1.12508856e-01f,
  3.37639339e-02f, 2.42910553e-02f, -1.23623438e-01f, 1.25574380e-01f, -5.19883186e-02f, 5.83135299e-02f, -6.40462525e-03f, 5.37449121e-02f, -1.43304141e-02f, 1.29858971e-01f,
  3.96519378e-02f, -1.42356670e-02f, 3.14535946e-02f, -1.13806815e-03f, -1.23764677e-02f, -4.66670422e-03f, -1.01365678e-01f, 1.51785776e-01f, 7.48433685e-03f, 8.27264413e-02f,
  3.78483534e-02f, 3.98102589e-02f, 1.02371112e-01f, 3.61844972e-02f, 1.13463867e-02f, -7.06584156e-02f, 1.05519615e-01f, 4.54222560e-02f, 2.48463359e-02f, -4.88100224e-04f,
  3.85503098e-02f, 3.80653143e-02f, -8.28870088e-02f, 2.57502180e-02f, 2.88362093e-02f, -6.49108142e-02f, 5.22222444e-02f, -4.26731147e-02f, -3.64835970e-02f, 1.17627718e-02f,
  -1.27603874e-01f, 2.74628215e-02f, 9.57784504e-02f, 5.55542074e-02f, 7.68158212e-02f, 1.29789487e-01f, -3.77908535e-02f, 2.18393818e-01f, -3.49822342e-02f, 2.85746362e-02f,
  -2.19673529e-01f, -3.30267012e-01f, 1.82044525e-02f, -1.43002227e-01f, 4.77622338e-02f, -4.38571833e-02f, -7.15772733e-02f, -7.28310943e-02f, 2.58151609e-02f, -4.87170964e-02f,
  -4.09263819e-02f, 6.16893321e-02f, -7.30218068e-02f, 4.34509963e-02f, -5.08630201e-02f, -5.63801378e-02f, -1.53311104e-01f, -1.53743461e-01f, -2.01925589e-03f, -3.08566052e-03f,
  -7.15694129e-02f, -6.42264932e-02f, -5.41914254e-02f, 3.24072130e-02f, -1.21194191e-01f, 9.82439294e-02f, -8.49518999e-02f, 3.03773861e-02f, 8.26086029e-02f, -1.65644530e-02f,
  -1.66071862e-01f, 1.58569083e-01f, 1.53844625e-01f, 1.62312448e-01f, 2.04427004e-01f, 2.47724429e-01f, 2.33882919e-01f, 9.40314978e-02f, 2.79540658e-01f, 1.15811594e-01f,
  -1.30946159e-01f, 8.86196718e-02f, -2.78785098e-02f, 8.91103297e-02f, -4.28048708e-02f, 1.08474933e-01f, 1.27844602e-01f, 1.25225350e-01f, 1.66540742e-01f, -2.36955546e-02f,
  -1.20170049e-01f, -7.89425001e-02f, -1.73213974e-01f, -8.57072696e-02f, -1.33624271e-01f, -9.18567702e-02f, -2.34486148e-01f, -2.88589615e-02f, -1.54411733e-01f, -2.90251356e-02f,
  -3.96269523e-02f, 6.35029897e-02f, -1.83392242e-02f, -6.80245161e-02f, 1.02850818e-03f, 5.06752580e-02f, -6.69650212e-02f, -4.11299756e-03f, 4.34170803e-03f, 2.51383148e-02f,
  -5.87848574e-02f, -2.97597572e-02f, 8.88556466e-02f, 7.94492662e-03f, 1.01991005e-01f, 7.54428506e-02f, -7.90047497e-02f, -9.29915756e-02f, -1.26049584e-02f, -7.59432763e-02f,
  -7.15315789e-02f, -3.43920179e-02f, 1.63411051e-02f, -1.10693173e-02f, -9.96074826e-02f, 4.57171313e-02f, 2.85448357e-02f, 4.22517024e-02f, 6.55875504e-02f, 1.43410727e-01f,
  3.28981802e-02f, 7.92070106e-02f, -2.06858087e-02f, 9.32668522e-03f, -2.96798423e-02f, -5.55632054e-04f, -5.43382904e-03f, 3.88487466e-02f, -5.48483841e-02f, -3.14404033e-02f,
  -1.08623967e-01f, 1.78775545e-02f, 4.32906151e-02f, -5.21860383e-02f, 9.93462279e-03f, -2.94454806e-02f, -5.16207218e-02f, 6.04398437e-02f, -5.26109859e-02f, -7.65172094e-02f,
  -3.13743278e-02f, -2.24109944e-02f, 4.13917340e-02f, 7.02453330e-02f, -3.10147628e-02f, -3.04858629e-02f, -9.37152058e-02f, -8.01084042e-02f, -2.85138320e-02f, 1.52953360e-02f,
  2.01694861e-01f, 2.58401096e-01f, 1.84293371e-02f, -6.79904297e-02f, 7.18527287e-02f, -1.05522759e-01f, -1.85927935e-02f, 4.30461921e-04f, 1.01900607e-01f, 8.04604441e-02f,
  -3.85980420e-02f, -2.27461327e-02f, 5.12402505e-02f, -7.18152151e-02f, 6.44275546e-02f, 2.04409589e-03f, 8.26702826e-03f, 6.37259195e-03f, -5.05180731e-02f, 1.14347022e-02f,
  -2.78956443e-02f, -2.70909872e-02f, 9.56190191e-03f, 4.00277749e-02f, -6.52495623e-02f, 1.19649107e-02f, 9.74014308e-03f, 3.10033429e-02f, -9.65192541e-03f, 7.70796686e-02f,
  3.38972360e-01f, 3.80013697e-02f, 1.88650131e-01f, 3.55685085e-01f, 1.37325585e-01f, 8.12051073e-02f, 1.76025163e-02f, 1.08948179e-01f, 3.85988861e-01f, -2.74495542e-01f,
  -7.97164738e-02f, -3.61197069e-02f, -2.76017040e-01f, 1.16088614e-01f, -1.38743117e-01f, -2.35703900e-01f, 1.94327742e-01f, -3.32281329e-02f, 1.38318032e-01f, -6.99611427e-03f,
  1.86992571e-01f, -1.48308471e-01f, 3.82371321e-02f, -4.47534584e-02f, 2.39880502e-01f, 1.69849098e-01f, -1.04881093e-01f, -4.31921743e-02f, 4.42472175e-02f, 4.51649018e-02f,
  6.33172840e-02f, 1.12731554e-01f, 8.58508199e-02f, 9.57617983e-02f, 1.37593709e-02f, 1.14462681e-01f, -3.33717167e-02f, -8.24038088e-02f, 2.56733894e-02f, -5.02737612e-02f,
  1.23130996e-02f, -3.38763520e-02f, 7.84834474e-02f, -9.93325934e-03f, 1.62186682e-01f, 1.11310616e-01f, 5.71986102e-02f, 8.92241672e-02f, 7.07816705e-03f, -1.09908413e-02f,
  -5.20030782e-03f, 6.56276345e-02f, 9.50080976e-02f, 8.35941359e-02f, -4.90547642e-02f, 8.72083157e-02f, -5.31203263e-02f, 9.77132916e-02f, 1.27437830e-01f, 2.31434479e-02f,
  -1.56694889e-01f, 5.21374047e-02f, 3.31961215e-02f, 6.86116442e-02f, -2.21439451e-02f, -1.30577898e-02f, 1.47201568e-02f, -1.55359069e-02f, 6.93675652e-02f, -2.98010912e-02f,
  6.54871985e-02f, 3.56768370e-02f, -9.21304431e-03f, 9.94243696e-02f, -7.91834518e-02f, 6.13367967e-02f, -6.22311048e-02f, 7.83440396e-02f, 6.53491542e-02f, 4.65414226e-02f,
  -6.28897399e-02f, -1.07600819e-02f, -1.48066273e-02f, 7.18567669e-02f, -5.65629564e-02f, -6.91781119e-02f, 5.48200961e-03f, 7.00559169e-02f, 2.41173152e-02f, -5.45134321e-02f,
  -1.07982352e-01f, -1.10560618e-01f, 7.98999518e-02f, -2.32746080e-02f, -5.94392195e-02f, 3.10542118e-02f, -6.75709993e-02f, 2.38791131e-03f, -3.39732133e-02f, 4.80063967e-02f,
  -1.34691209e-01f, -1.04251176e-01f, -9.37215760e-02f, -3.56542915e-02f, -9.95597243e-02f, 4.70840037e-02f, -9.87307355e-02f, -1.39814634e-02f, -4.80098799e-02f, -1.17206397e-02f,
  -1.12493701e-01f, -7.65496492e-02f, -5.14066890e-02f, 4.27895859e-02f, -1.98267139e-02f, -5.88965006e-02f, -2.43153214e-03f, 9.70835239e-02f, -2.63809096e-02f, -5.65394945e-03f,
  -3.62486601e-01f, 2.05328222e-02f, -3.67077917e-01f, -3.42230871e-02f, -5.14568947e-03f, 3.41656953e-01f, 2.37996250e-01f, -7.10536689e-02f, -6.97977692e-02f, 2.44652778e-01f,
  1.95675120e-01f, -1.54937327e-01f, 8.65589231e-02f, 3.03601533e-01f, -8.22069421e-02f, 8.56671706e-02f, 2.12227166e-01f, 1.39768705e-01f, -9.60881636e-02f, -5.69609664e-02f,
  -1.02830030e-01f, 3.05295587e-01f, -2.25158427e-02f, 3.39195319e-02f, 6.46935925e-02f, -1.98046789e-01f, 1.25533313e-01f, -1.01933926e-01f, 1.21519409e-01f, 1.69254038e-02f,
  4.21652347e-02f, -1.36312515e-01f, -5.22835441e-02f, 3.20984656e-03f, 2.76983362e-02f, -1.33311963e-02f, 8.11434761e-02f, -6.66605830e-02f, -9.12585184e-02f, -2.59324033e-02f,
  5.62533513e-02f, -1.00911632e-02f, 3.08230780e-02f, -9.07246023e-02f, -3.50634344e-02f, 2.65629292e-02f, -7.03297704e-02f, 1.05224527e-01f, -7.35280067e-02f, 7.66407698e-03f,
  -3.52515876e-02f, -7.45901763e-02f, 7.56815448e-02f, 3.83700021e-02f, -1.54343294e-02f, 5.39260805e-02f, 1.01861522e-01f, 7.12372363e-02f, 1.15464911e-01f, -1.94440838e-02f,
  8.73127021e-03f, -9.74632800e-02f, 6.59928545e-02f, 9.50640365e-02f, -8.93741250e-02f, 5.16590364e-02f, 4.75884415e-02f, -1.13512449e-01f, -5.91167845e-02f, 1.19753659e-01f,
  -9.51887742e-02f, -5.63116278e-03f, 2.57231630e-02f, 3.92726734e-02f, -2.23114472e-02f, 7.14142397e-02f, -6.97785392e-02f, 2.26026010e-02f, 5.83506227e-02f, 6.41428903e-02f,
  -1.59866605e-02f, -1.47000104e-01f, -3.53898220e-02f, 2.10978631e-02f, -2.89242528e-02f, -9.84715149e-02f, -6.26659244e-02f, 3.88654806e-02f, 3.29438737e-03f, -1.16159897e-02f,
  1.24116741e-01f, 5.77908084e-02f, -3.75857428e-02f, -4.44787592e-02f, -7.47357085e-02f, -3.92737985e-02f, -7.10463077e-02f, -1.93520561e-02f, 2.14067698e-02f, 1.76272895e-02f,
  1.79239251e-02f, 4.24501821e-02f, 9.29078460e-02f, -1.60833765e-02f, -3.66863608e-02f, 1.37918636e-01f, -2.32496224e-02f, -7.69140944e-02f, 1.07734360e-01f, -2.47801319e-02f,
  4.11618873e-02f, 6.38691038e-02f, -5.40210269e-02f, -4.13782634e-02f, 1.79146640e-02f, 2.19903551e-02f, 1.25441058e-02f, 1.61250718e-02f, -9.73621756e-03f, -4.94351238e-02f,
  8.31723958e-02f, -2.08690852e-01f, -2.38924593e-01f, -2.36060441e-01f, -1.83130592e-01f, -3.29255074e-01f, -2.86600649e-01f, -7.29278624e-02f, -5.22705503e-02f, 4.59419424e-03f,
  -1.03476025e-01f, 9.55228955e-02f, 8.41078386e-02f, -1.33029610e-01f, 3.33192721e-02f, 2.43287072e-01f, -3.20294499e-01f, -2.04877034e-01f, 3.35562974e-02f, -1.45637378e-01f,
  -7.57888928e-02f, -9.89062414e-02f, -1.23354428e-01f, -1.58663929e-01f, -2.71637738e-01f, -8.69617760e-02f, 1.98817328e-01f, -6.18399046e-02f, -2.81954765e-01f, -9.00480002e-02f,
  1.09962620e-01f, 4.59859036e-02f, -2.18525454e-02f, 2.72735953e-02f, -1.62033178e-02f, -1.23326354e-01f, -8.17472562e-02f, 2.81847380e-02f, 2.81645656e-02f, -1.07573569e-01f,
  6.54905438e-02f, 3.02477414e-03f, -7.16461986e-02f, 6.82495907e-02f, -1.27600715e-01f, -6.99000135e-02f, -2.99371816e-02f, -3.23030390e-02f, -4.90733720e-02f, -1.21108517e-01f,
  -1.59513161e-01f, -1.27444863e-01f, -3.48875597e-02f, 8.40129033e-02f, 4.67060022e-02f, -4.82572429e-02f, 4.78507802e-02f, 3.38801742e-02f, -9.31219012e-03f, -7.60006905e-02f,
  -2.69378740e-02f, -3.88493650e-02f, 6.00823797e-02f, -2.08404250e-02f, -1.97414681e-02f, 9.00964439e-02f, 3.65952104e-02f, 5.70103377e-02f, -2.78168060e-02f, 4.85885516e-02f,
  -2.87375264e-02f, -1.66728219e-03f, 5.81656508e-02f, -9.11227241e-02f, 1.49821872e-02f, 3.04447077e-02f, -9.56877600e-03f, 6.01864494e-02f, 2.34508011e-02f, 4.98601981e-02f,
  3.04109771e-02f, -7.62409940e-02f, 3.76652963e-02f, -2.67807618e-02f, -3.09499335e-02f, 1.42787723e-02f, -1.67601518e-02f, 5.21255471e-03f, -8.55962653e-03f, 3.93901505e-02f,
  -1.02579445e-02f, -2.54251566e-02f, -3.39357257e-02f, -2.68925389e-04f, 5.60115092e-03f, -1.99837498e-02f, -3.29657272e-02f, -1.21407017e-01f, -5.94803318e-02f, -5.74468113e-02f,
  -6.86637983e-02f, 1.42972246e-01f, -4.86824848e-02f, 2.93694362e-02f, -2.04590615e-02f, -1.39562935e-01f, 9.75100882e-03f, 4.29568766e-03f, -1.36496544e-01f, 2.24895850e-02f,
  -2.40524905e-03f, 1.29923657e-01f, 4.07029651e-02f, 8.95829946e-02f, 6.05401723e-03f, -6.91686869e-02f, -3.99573473e-03f, 5.01868874e-02f, -4.52635847e-02f, 3.75594087e-02f,
  1.49582639e-01f, 2.23825783e-01f, 2.78211445e-01f, 3.87647301e-01f, -6.82905242e-02f, -2.98396528e-01f, -7.21899867e-02f, 1.77292362e-01f, 1.44206479e-01f, -1.11146562e-01f,
  8.58929530e-02f, 1.79107800e-01f, 3.89211886e-02f, 3.32478993e-02f, -1.47907302e-01f, -8.37282538e-02f, 1.62450355e-02f, 5.93706220e-02f, 1.17621325e-01f, 2.62886673e-01f,
  2.13091709e-02f, -5.46076819e-02f, 9.95111465e-02f, 7.79074058e-03f, 1.59282699e-01f, 2.25532845e-01f, 4.52965461e-02f, -4.48020473e-02f, 5.32304049e-02f, -2.08895624e-01f,
  -9.31665599e-02f, 1.78455785e-01f, -3.59734930e-02f, -8.49157944e-02f, -9.74448211e-03f, -1.13037452e-01f, 1.78252440e-02f, -1.34501353e-01f, -7.26283118e-02f, -7.97093138e-02f,
  2.19526421e-02f, -1.02129571e-01f, -5.19645261e-03f, 7.59732202e-02f, -6.68063089e-02f, 3.39728175e-03f, 3.82417366e-02f, 1.17174380e-01f, 3.43642868e-02f, 8.99209529e-02f,
  1.56919777e-01f, -3.03683616e-03f, -4.70289849e-02f, 2.42630355e-02f, 1.49550261e-02f, 1.71225742e-02f, -3.63499112e-02f, 1.76777709e-02f, 1.69650018e-02f, -6.23089522e-02f,
  1.19926604e-02f, 1.05224652e-02f, -2.95224674e-02f, -4.28455360e-02f, 1.07120350e-02f, -2.90007312e-02f, -5.94126321e-02f, -1.01930276e-01f, -7.91416019e-02f, -7.84609392e-02f,
  -2.54461803e-02f, 6.36531264e-02f, -2.25654803e-02f, -1.11835357e-02f, 1.69655997e-02f, -3.62043791e-02f, -1.31605044e-01f, 2.79556699e-02f, 2.51762290e-02f, -2.62198485e-02f,
  4.14149128e-02f, -9.46324095e-02f, 8.80953446e-02f, -7.39740357e-02f, 1.44639574e-02f, 1.59991756e-02f, 6.35930672e-02f, 6.64860532e-02f, -4.98921424e-03f, -1.06173337e-01f,
  -2.85304822e-02f, 2.50450432e-01f, -7.99620971e-02f, -1.17627054e-01f, -1.41289476e-02f, -1.64112061e-01f, 5.49269877e-02f, 1.71452877e-03f, -6.81255981e-02f, -3.50794755e-02f,
  -4.96510155e-02f, -5.58086075e-02f, -1.08794384e-01f, -1.40540734e-01f, -7.86542669e-02f, -1.99615378e-02f, 7.18642101e-02f, 4.08562794e-02f, -3.29033658e-02f, 1.32335663e-01f,
  1.93107009e-01f, -9.08302516e-02f, -7.32930601e-02f, -1.01220086e-02f, -4.48612086e-02f, -4.47138175e-02f, 4.62462939e-02f, 6.73864856e-02f, 9.89768375e-03f, -5.73641844e-02f,
  -1.02186456e-01f, 6.43423817e-04f, -1.63223743e-01f, -1.18444942e-01f, -6.70671836e-02f, -2.63637185e-01f, -6.28939942e-02f, 8.85396376e-02f, -1.17074944e-01f, 3.01716685e-01f,
  2.71155059e-01f, -9.89517644e-02f, 1.58205390e-01f, 8.66908059e-02f, -3.20025384e-01f, 9.61278751e-02f, -8.42745528e-02f, -7.11535439e-02f, -5.65808360e-03f, 6.63507879e-02f,
  -1.74353629e-01f, 2.69247532e-01f, -1.51406184e-01f, 1.72081158e-01f, -9.24358144e-02f, 1.53455767e-03f, 1.15282148e-01f, 1.47561863e-01f, 1.02025062e-01f, 1.20176468e-02f,
  2.31879316e-02f, 1.36908889e-01f, -6.87387818e-03f, -9.82661545e-02f, -2.14428548e-02f, 2.95410659e-02f, -6.69071451e-02f, -3.08745988e-02f, 3.04179955e-02f, -1.19859040e-01f,
  -1.37650549e-01f, -4.31313664e-02f, -1.44155622e-01f, -4.51238863e-02f, -4.18827534e-02f, 4.85942774e-02f, 4.23756009e-03f, -2.92171892e-02f, -5.40433228e-02f, -1.64344683e-01f,
  -7.54237408e-04f, -5.06012067e-02f, 1.26604270e-02f, -4.65181880e-02f, -4.01901379e-02f, 5.35282716e-02f, 1.75617170e-02f, -1.14076622e-01f, -7.46851265e-02f, -5.38992733e-02f,
  7.96517655e-02f, 3.53045315e-02f, 3.78710479e-02f, 3.41027044e-02f, 3.48401330e-02f, 9.97396260e-02f, -8.30505416e-03f, 1.04188830e-01f, 5.53985545e-03f, 1.13591902e-01f,
  -4.54039760e-02f, -4.78755347e-02f, 1.03392387e-02f, -2.63284091e-02f, -9.84739233e-03f, -3.36105488e-02f, 6.92940131e-02f, 5.07259555e-02f, -4.53127995e-02f, 2.27785446e-02f,
  1.14148937e-01f, 4.54794941e-03f, 8.26701447e-02f, -1.98693592e-02f, -7.34168589e-02f, -2.52369186e-03f, -1.33706229e-02f, -6.12608269e-02f, -1.20922718e-02f, -1.72364116e-02f,
  -1.19981961e-02f, 1.53788581e-01f, 5.39909229e-02f, 4.51667532e-02f, -2.03318298e-02f, -6.94833649e-03f, 4.58573923e-02f, -5.76894321e-02f, -1.59181599e-02f, -5.32677723e-03f,
  -2.29141731e-02f, -2.93350760e-02f, -5.67892604e-02f, 1.10852659e-01f, 2.43709460e-02f, 5.66865355e-02f, 6.77038059e-02f, -4.70381528e-02f, -3.28830862e-03f, -1.77368503e-02f,
  -6.38772771e-02f, -2.78246775e-02f, -1.04536824e-01f, 6.91307187e-02f, -5.48629500e-02f, -1.76506434e-02f, -3.84877063e-02f, -5.42961620e-02f, -6.64531142e-02f, 1.76290516e-02f,
  1.71196878e-01f, -2.51312256e-02f, -5.47629558e-02f, 1.45760581e-01f, -1.96898639e-01f, 4.84997779e-02f, -2.23821420e-02f, -1.20902983e-02f, -1.94884837e-01f, -2.66109668e-02f,
  9.46934745e-02f, 1.84784327e-02f, 1.77104682e-01f, 2.06714317e-01f, 1.78185627e-01f, 9.38828140e-02f, 8.84234384e-02f, 5.05907908e-02f, 2.20765211e-02f, 1.42997429e-01f,
  1.80365980e-01f, 1.21616766e-01f, 1.06860973e-01f, -7.73596251e-03f, 8.91447887e-02f, 6.78831786e-02f, -5.14169503e-03f, 1.93607993e-02f, 1.63754597e-01f, -6.55131662e-05f,
  6.55930862e-02f, 2.08491217e-02f, -3.75669375e-02f, 2.03521494e-02f, 1.24271542e-01f, 3.78113538e-02f, 5.47939427e-02f, 8.56222510e-02f, -7.28414953e-02f, -3.79090719e-02f,
  -5.30536361e-02f, 4.43041744e-03f, 4.23589274e-02f, -6.66181296e-02f, 6.46672100e-02f, -1.37151539e-01f, -1.36226371e-01f, -9.91956070e-02f, -8.70866328e-02f, -4.70652767e-02f,
  -1.23561434e-02f, -1.14332989e-01f, -7.63672069e-02f, 4.66498721e-04f, -8.85659829e-02f, -1.14868410e-01f, -3.65305133e-02f, -3.44266593e-02f, -7.82649145e-02f, -6.47250935e-02f,
  1.25813261e-01f, -6.32998869e-02f, 1.27302185e-01f, 6.50162175e-02f, 8.59936476e-02f, 3.80260050e-02f, 1.82665959e-02f, -3.20508890e-02f, 6.10337146e-02f, 1.01295285e-01f,
  3.57858948e-02f, -3.06368247e-02f, 4.55480963e-02f, -6.86899498e-02f, 8.86956975e-02f, -1.13698490e-01f, 4.08654511e-02f, -6.73973486e-02f, -7.22414926e-02f, -4.59600091e-02f,
  3.35998461e-02f, 5.60430624e-02f, 9.17854682e-02f, -5.13325371e-02f, -4.68848944e-02f, 7.43544772e-02f, 5.62582389e-02f, -9.69296228e-03f, -1.25963345e-01f, -5.68142012e-02f,
  1.37722669e-02f, 9.17657241e-02f, 8.50600824e-02f, -9.11044478e-02f, 4.61630197e-03f, 6.24705441e-02f, 4.90729474e-02f, 7.08010495e-02f, 1.50358573e-01f, 4.43888605e-02f,
  -5.40322401e-02f, -3.09349578e-02f, -7.08322972e-02f, -6.31510690e-02f, -9.65704694e-02f, 1.74844470e-02f, -1.00499270e-02f, -1.02806864e-02f, 1.66182052e-02f, 4.77370480e-03f,
  1.27661824e-02f, -7.52230436e-02f, 5.44710420e-02f, -4.12918478e-02f, -8.47769007e-02f, -5.22592776e-02f, 2.30495837e-02f, -9.93092954e-02f, 3.18555310e-02f, 2.90393457e-02f,
  -1.04438946e-01f, -4.12870124e-02f, -1.16126098e-01f, 7.21903965e-02f, -6.47743493e-02f, 2.31472239e-01f, 2.62852967e-01f, 8.28092098e-02f, -2.16642246e-01f, 3.37148011e-02f,
  2.46213526e-01f, -9.45877284e-02f, 1.68606490e-01f, 3.97587121e-01f, 3.04229259e-01f, 2.13349655e-01f, 2.58152157e-01f, 2.31963605e-01f, -4.89124097e-02f, 7.78753543e-03f,
  3.85884903e-02f, 3.01750332e-01f, 2.42427915e-01f, 4.91351336e-02f, 1.06479675e-01f, -2.00057209e-01f, 4.46244739e-02f, -1.12325907e-01f, 1.54215753e-01f, 7.68259764e-02f,
  4.77831550e-02f, -1.20604038e-01f, -7.36499280e-02f, 5.00028208e-03f, -5.72635978e-02f, 4.70496854e-03f, -6.38184026e-02f, 8.75966251e-02f, 3.85317951e-02f, -4.76937275e-03f,
  -8.35199580e-02f, -5.21814935e-02f, -1.00246005e-01f, 3.11757587e-02f, -1.42359156e-02f, -1.77500155e-02f, 1.13384366e-01f, 2.35830992e-02f, 5.62916920e-02f, 6.28149882e-02f,
  -1.64475981e-02f, 3.91729996e-02f, 1.05162174e-01f, -5.10077439e-02f, -7.10191112e-03f, 8.94918591e-02f, 4.31908220e-02f, -9.61485729e-02f, -6.92486987e-02f, 2.52186097e-02f,
  -5.48605062e-02f, -3.22759859e-02f, -4.54239780e-03f, 6.12278432e-02f, 1.31133050e-02f, 8.17647204e-02f, 9.03972611e-02f, 9.22849253e-02f, -1.93794409e-03f, 2.10623499e-02f,
  1.08775683e-02f, -9.33730882e-03f, 2.58067828e-02f, -1.56183103e-02f, -3.83998118e-02f, 4.53055836e-02f, 5.81810810e-02f, 2.03234237e-02f, -5.11268005e-02f, 2.68424600e-02f,
  -5.74449860e-02f, -6.23933859e-02f, 8.13675150e-02f, 2.27182936e-02f, 4.50939387e-02f, 1.08678825e-02f, 6.89350590e-02f, -6.35696426e-02f, 5.01373149e-02f, -3.93194892e-02f,
  1.86867993e-02f, -3.35035324e-02f, 6.40619127e-03f, -1.83038078e-02f, 3.03157693e-04f, 1.12293726e-02f, -5.32871522e-02f, 1.01854540e-02f, -5.66752814e-02f, -4.16405909e-02f,
  1.65126305e-02f, -1.43338487e-01f, -3.09925787e-02f, 3.71863917e-02f, 4.23386917e-02f, 4.50170040e-02f, -7.92316049e-02f, 9.20935534e-03f, 3.85041460e-02f, 9.24541131e-02f,
  9.98572111e-02f, 4.76045497e-02f, -3.04570124e-02f, 2.25058254e-02f, 3.94916981e-02f, 8.60302672e-02f, -1.21045664e-01f, -5.29854745e-03f, -4.38920893e-02f, 4.78924857e-03f,
  -5.07676713e-02f, 8.86299536e-02f, 3.38621251e-02f, -1.79957032e-01f, 4.65476587e-02f, -2.68236786e-01f, -2.29876876e-01f, 9.11668539e-02f, 6.82186633e-02f, -5.88032790e-03f,
  -6.02870621e-02f, 1.36280522e-01f, 3.69864702e-02f, -2.23078012e-01f, -1.63136229e-01f, -2.86332835e-02f, -2.50548989e-01f, -2.05911398e-01f, -2.56905090e-02f, -1.56473950e-01f,
  -1.27926037e-01f, -2.36051038e-01f, -1.36413679e-01f, 2.70180237e-02f, -8.63284022e-02f, 2.88638938e-02f, -1.46643251e-01f, -6.23578839e-02f, -9.95601267e-02f, 7.63975037e-03f,
  -1.28609553e-01f, -1.17137730e-01f, -1.60284024e-02f, -9.11268592e-02f, -1.07933193e-01f, -7.92533755e-02f, -1.15139373e-01f, -6.60217032e-02f, 7.00011989e-03f, 9.35119092e-02f,
  7.46929944e-02f, -3.36738005e-02f, 3.21025439e-02f, 1.07856423e-01f, 3.83434705e-02f, -2.70789638e-02f, 2.51662489e-02f, 3.53458486e-02f, 8.50677267e-02f, 1.28183505e-02f,
  -2.04374958e-02f, -2.41095331e-02f, -8.33228230e-02f, 2.30449755e-02f, 1.07159177e-02f, -6.56728670e-02f, -1.29846469e-01f, 6.72276244e-02f, -3.45408209e-02f, 1.88713521e-02f,
  5.37323765e-02f, -3.08212955e-02f, 3.83664817e-02f, 1.43007278e-01f, 2.36135796e-02f, 6.75428063e-02f, 4.73334640e-03f, -1.83231961e-02f, -3.30111720e-02f, -7.67227560e-02f,
  -4.27674390e-02f, -6.75408989e-02f, -4.11054865e-02f, -6.42933697e-02f, 8.21575616e-03f, 7.12556615e-02f, -1.16156921e-01f, 3.63305993e-02f, -1.27138168e-01f, -9.22565907e-02f,
  -4.22231928e-02f, -5.60007840e-02f, 6.94084987e-02f, -5.16214669e-02f, -7.00133368e-02f, 6.91453414e-03f, 4.56287386e-03f, -1.03957774e-02f, -7.85257295e-03f, -3.57938707e-02f,
  -3.03795367e-01f, -2.91861832e-01f, -5.69202006e-02f, -4.48637009e-02f, 3.20976693e-03f, 4.56205048e-02f, -2.92279515e-02f, 5.35386503e-02f, 1.55302510e-02f, 4.04506959e-02f,
  1.61731429e-02f, -1.30282249e-04f, -2.41317376e-02f, 1.79067887e-02f, 1.14947692e-01f, -5.87009788e-02f, -2.54062805e-02f, 3.08282487e-02f, -5.22658564e-02f, 7.06543922e-02f,
  1.14195291e-02f, 4.57084887e-02f, -6.90872455e-03f, -9.92661044e-02f, -1.08720094e-01f, 9.80713144e-02f, 7.15342686e-02f, -8.47410336e-02f, -5.54743968e-02f, 6.36925921e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.87605232e-01f, 2.65138317e-02f, 1.80789202e-01f, 1.79165885e-01f, 1.99699908e-01f, 1.58256784e-01f, -1.97689496e-02f, 2.77118981e-01f, 1.64353535e-01f, 1.76810086e-01f,
  2.29197547e-01f, 1.66385129e-01f, 2.42815584e-01f, 1.53974563e-01f, 8.91390368e-02f, 1.44346222e-01f, 1.17958032e-01f, 2.28559464e-01f, 2.02790394e-01f, 3.75504196e-02f,
  4.56038266e-02f, 1.38460964e-01f, 1.40670553e-01f, 3.17850858e-01f, 2.39820376e-01f, 3.23331833e-01f, 2.03003809e-01f, 2.45936364e-01f, 2.91417599e-01f, 2.56142795e-01f,
  2.43541107e-01f, 1.07020542e-01f, 1.92277864e-01f, 6.58038259e-02f, 2.06347369e-02f, 1.60125688e-01f, 2.61653196e-02f, 1.14063591e-01f, 2.91441292e-01f, 1.37655094e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.89987794e-01f, -1.65356636e-01f, -1.26312058e-02f, -1.20281249e-01f, -1.61483034e-01f, 3.81061696e-02f, 1.19060971e-01f, -6.02102168e-02f, -6.03747703e-02f, -4.00617383e-02f,
  -9.73762851e-03f, -3.89365330e-02f, 2.90485118e-02f, -1.90595478e-01f, -2.46208102e-01f, 1.10706471e-01f, -7.37940660e-03f, -4.78393957e-02f, -4.43971232e-02f, -1.99416012e-01f,
  -5.28344791e-03f, -3.32051702e-02f, -1.25452161e-01f, 1.09791860e-01f, -6.04443960e-02f, 4.50893529e-02f, 5.18867411e-02f, 1.02932580e-01f, 1.70098129e-03f, -1.05412997e-01f,
  1.38960287e-01f, -1.69696942e-01f, -1.22924194e-01f, -1.82438448e-01f, 8.26463476e-02f, -2.49481518e-02f, -3.46856043e-02f, -1.30163804e-01f, 2.36827862e-02f, -1.31696090e-02f,
  1.05392888e-01f, -2.72417754e-01f, 1.94631696e-01f, -2.00873002e-01f, 1.93682313e-01f, 1.10072754e-01f, 1.32576123e-01f, -2.90386006e-02f, 1.80025265e-01f, 1.22049093e-01f,
  -4.69846018e-02f, 1.10538773e-01f, 5.40747456e-02f, -2.18121588e-01f, -4.05499078e-02f, 1.97444141e-01f, 1.46750942e-01f, -2.19262168e-02f, -7.23855495e-02f, 3.40525471e-02f,
  -1.06020525e-01f, 1.38725922e-01f, 1.53623849e-01f, -2.24648803e-01f, -8.47493410e-02f, -4.10129912e-02f, -1.28893569e-01f, 3.75022292e-02f, -9.90583673e-02f, -1.18364461e-01f,
  9.88893062e-02f, -1.10436052e-01f, 1.39568318e-02f, -7.07583874e-02f, -2.88098268e-02f, -7.57692382e-02f, -1.16363481e-01f, 1.41822934e-01f, -1.73223749e-01f, 3.85670103e-02f,
  -2.78925914e-02f, -7.49273896e-02f, -6.78023100e-02f, 1.51324838e-01f, 5.52765876e-02f, 6.06671395e-03f, 7.62696117e-02f, -6.02542944e-02f, -1.26367539e-01f, 8.40067416e-02f,
  -1.13548353e-01f, -5.48100024e-02f, 6.61203265e-02f, 2.73921154e-02f, 9.36351717e-03f, 7.64504299e-02f, 2.02792302e-01f, 1.09892078e-02f, 4.13836129e-02f, -4.77845259e-02f,
  -2.91585386e-01f, -2.21009582e-01f, 1.14692718e-01f, 1.47912547e-01f, -8.91380608e-02f, -1.20165639e-01f, 2.33051628e-01f, -1.26568332e-01f, 6.28633425e-02f, 8.54143575e-02f,
  -1.29405692e-01f, 1.08903339e-02f, 7.26420879e-02f, 4.43531573e-02f, 9.70365480e-02f, -7.36828670e-02f, 3.12803119e-01f, 9.96442959e-02f, -1.73672348e-01f, -4.22201818e-03f,
  7.32540712e-02f, -2.10757092e-01f, 9.60310400e-02f, 7.33578280e-02f, 1.32740056e-02f, -1.78607792e-01f, -5.27924998e-03f, 1.66375175e-01f, 1.19306274e-01f, 5.35609871e-02f,
  -1.04323424e-01f, -3.07755396e-02f, 4.25022095e-02f, 4.54296432e-02f, -2.05268338e-01f, -1.14963844e-01f, 1.54171094e-01f, 7.64539838e-02f, -1.78037956e-02f, 1.98439024e-02f,
  2.16602273e-02f, 3.18583772e-02f, 1.10000558e-01f, -1.39061958e-01f, 1.16539057e-02f, 1.50958061e-01f, -1.33415520e-01f, -8.32425356e-02f, 2.83113383e-02f, -5.06367534e-03f,
  4.26171683e-02f, -1.77544236e-01f, -9.66617763e-02f, 6.63893968e-02f, 2.01142475e-01f, 2.87187882e-02f, 1.00587502e-01f, 1.57869250e-01f, 2.93459394e-03f, -1.76221300e-02f,
  -1.97745964e-01f, 3.45543511e-02f, 7.27948323e-02f, -1.49639985e-02f, -7.00974464e-02f, -1.59081712e-01f, -2.52724737e-01f, 2.40681469e-02f, 9.66745019e-02f, 6.74870536e-02f,
  -2.51481771e-01f, 1.94156449e-02f, -1.04429990e-01f, -7.53762275e-02f, -4.24329080e-02f, -3.08635011e-02f, 1.75145939e-01f, -3.22215818e-02f, 1.58470243e-01f, -1.58423871e-01f,
  -1.70814902e-01f, 6.40354529e-02f, 1.49351612e-01f, -2.27675542e-01f, -2.96808720e-01f, 1.09214693e-01f, 1.49940953e-01f, -2.02252641e-01f, 9.00305063e-02f, 5.81517331e-02f,
  2.77380109e-01f, -6.52333796e-02f, 1.07901052e-01f, 1.15065239e-01f, -6.08925521e-02f, 7.72472396e-02f, 7.53964260e-02f, -6.73175678e-02f, -5.68928234e-02f, 2.47772217e-01f,
  -9.28995851e-03f, -3.21339704e-02f, 1.70009837e-01f, 8.30723345e-02f, -4.62875664e-02f, 1.52750313e-01f, -1.70455426e-01f, -6.80721551e-02f, 1.28601655e-01f, 7.47985765e-02f,
  -1.79240212e-01f, -2.47348100e-01f, 7.63275921e-02f, 2.41225939e-02f, -2.05830261e-02f, 1.25022575e-01f, -7.76290288e-03f, -1.89389110e-01f, -1.62240386e-01f, 1.27389073e-01f,
  -1.07173614e-01f, -2.80449301e-01f, -1.89693019e-01f, -5.97724319e-02f, -1.86396092e-01f, -1.62674248e-01f, 1.98655784e-01f, 2.39473417e-01f, -2.64409240e-02f, -6.41904026e-02f,
  1.81683213e-01f, -1.94834862e-02f, -1.21330217e-01f, 1.26130432e-01f, -7.17224777e-02f, -1.66201517e-01f, 7.95973390e-02f, -1.05540127e-01f, -1.50712639e-01f, 1.99109018e-01f,
  -4.03261557e-02f, -5.69406226e-02f, 8.81321803e-02f, -2.62154695e-02f, -6.65199161e-02f, 2.40875478e-03f, 1.25273213e-01f, 1.33011326e-01f, 1.27299845e-01f, -2.59683281e-01f,
  -1.47386253e-01f, -4.27295864e-02f, -8.32496807e-02f, -1.03734404e-01f, -4.38372418e-02f, -4.44919877e-02f, 7.96081033e-03f, -1.39984548e-01f, -1.51242152e-01f, -1.52277090e-02f,
  6.21292852e-02f, -3.33181955e-02f, 1.61722839e-01f, 1.52063265e-01f, -1.63593553e-02f, 3.81384678e-02f, 7.50954673e-02f, -6.75469264e-03f, -1.10938147e-01f, -2.38421168e-02f,
  -6.37640208e-02f, -2.17904560e-02f, 3.56688946e-02f, 1.68586433e-01f, -1.69328645e-01f, -2.25460231e-01f, -2.97996122e-02f, -4.87164855e-02f, -1.69891089e-01f, -1.56812087e-01f,
  1.77653551e-01f, 7.50016198e-02f, 5.08606657e-02f, 6.64462596e-02f, 9.26483124e-02f, -3.88406366e-02f, -2.17066780e-02f, -1.06802499e-02f, -2.63088405e-01f, 9.98528749e-02f,
  -3.77465822e-02f, -1.02776065e-01f, 1.56693652e-01f, 6.36402443e-02f, 2.38771737e-02f, 1.08056935e-02f, 1.00692160e-01f, -2.18000542e-02f, -1.04609113e-02f, 1.20452285e-01f,
  2.43237972e-01f, 1.28371716e-01f, 1.21291786e-01f, -1.60030872e-01f, 1.09166600e-01f, 8.43376014e-03f, -1.21885128e-01f, 1.95031077e-01f, 1.18407868e-01f, -1.99180782e-01f,
  -1.30293882e-02f, 1.05724365e-01f, -1.37130350e-01f, 9.51662734e-02f, -1.73530832e-01f, -1.15503572e-01f, -1.86330393e-01f, 1.57223284e-01f, 1.66461647e-01f, -1.32927969e-01f,
  5.61470613e-02f, -2.27579288e-02f, -4.45365012e-02f, -3.04140262e-02f, 3.86807993e-02f, -1.03866510e-01f, -5.28939255e-02f, 6.44862354e-02f, -8.99751410e-02f, 1.44031540e-01f,
  -1.39497325e-01f, -3.07868253e-02f, 1.38667494e-01f, 3.89601067e-02f, 1.98248461e-01f, -1.52885392e-01f, -1.14121005e-01f, 1.48585320e-01f, -2.20657349e-01f, -2.06449218e-02f,
  -1.82489883e-02f, 1.69933327e-02f, 1.04252085e-01f, -1.98948801e-01f, -6.72277017e-03f, 9.42111611e-02f, 1.14198163e-01f, -8.31610486e-02f, -9.07399803e-02f, -1.22789636e-01f,
  2.24545840e-02f, -1.65359601e-01f, 2.50360429e-01f, 1.16335109e-01f, -1.49576440e-01f, -9.13726352e-03f, 5.79202026e-02f, 1.19612418e-01f, 5.31113371e-02f, -9.06030685e-02f,
  1.56032488e-01f, 1.57565579e-01f, -2.05049619e-01f, 2.16405109e-01f, 6.19101571e-03f, -4.32904474e-02f, 1.88293338e-01f, -1.14080925e-02f, 1.07964821e-01f, 1.35932416e-01f,
  -2.02894300e-01f, -1.88539848e-01f, 7.36550391e-02f, -5.22399619e-02f, 8.36045071e-02f, -8.84714425e-02f, -1.48927659e-01f, 5.96388942e-03f, 1.70614958e-01f, 5.38604893e-02f,
  -1.00253388e-01f, 1.52105838e-01f, -1.70682173e-03f, 4.87248302e-02f, -9.55488384e-02f, -2.84725428e-02f, -5.25005208e-03f, 1.14821613e-01f, -6.47752658e-02f, 2.57067010e-02f,
  1.15997866e-01f, 1.25775591e-01f, -1.12533994e-01f, 1.40846968e-01f, 1.38423085e-01f, -3.16878520e-02f, -1.09326579e-02f, -2.21751884e-01f, -9.97694731e-02f, 6.88859820e-02f,
  6.07452868e-03f, -2.46673167e-01f, 1.95939183e-01f, -4.91209179e-02f, -1.05969340e-01f, 6.01240471e-02f, 3.83897275e-02f, 1.66019708e-01f, -2.13553235e-02f, -1.12614766e-01f,
  1.03735045e-01f, 7.24407360e-02f, -8.81716236e-02f, -9.22046676e-02f, 7.65252102e-04f, 8.31880122e-02f, -1.59034193e-01f, -1.45505294e-01f, -2.15390082e-02f, 1.02994941e-01f,
  1.62470922e-01f, 1.18886322e-01f, 7.53853843e-02f, -1.44167155e-01f, 1.18371502e-01f, -3.05506229e-01f, 1.32733256e-01f, -2.61950698e-02f, 2.03478262e-01f, 4.52732146e-02f,
  -2.59682201e-02f, 9.03424695e-02f, 9.79201347e-02f, 7.22854435e-02f, -1.72718525e-01f, 2.36157581e-01f, 1.80340618e-01f, -1.81695983e-01f, -1.96083829e-01f, 2.13532507e-01f,
  8.68459493e-02f, -2.27598518e-01f, -7.14325383e-02f, 2.20089167e-01f, -1.43770501e-01f, 4.76772338e-02f, -1.38092920e-01f, -1.78183481e-01f, -1.24516778e-01f, -1.01094477e-01f,
  -1.30583644e-01f, 1.03155889e-01f, 4.44408245e-02f, 1.21302135e-01f, 4.32451256e-02f, -1.16290577e-01f, 1.48441136e-01f, -5.04495203e-02f, -1.58467665e-01f, 7.58191273e-02f,
  1.43515676e-01f, -1.50345340e-01f, -1.11107931e-01f, 2.24070400e-01f, -1.55238166e-01f, -6.10296875e-02f, 9.82485190e-02f, -2.34225750e-01f, 7.47620016e-02f, 2.82263961e-02f,
  -1.96536660e-01f, 2.62754709e-02f, -6.02887645e-02f, -3.52738015e-02f, -1.78284179e-02f, -4.84703667e-02f, -1.14710508e-02f, 7.62513727e-02f, 1.06144451e-01f, -3.16783011e-01f,
  6.29899674e-04f, -7.61626055e-03f, -1.00288972e-01f, -1.58224344e-01f, -1.38003632e-01f, -3.88357863e-02f, 9.69075784e-02f, -1.21236190e-01f, 8.40044692e-02f, -2.51706153e-01f,
  2.41426557e-01f, -8.05734023e-02f, -1.36564776e-01f, 2.85316795e-01f, 8.32286105e-03f, -1.30429212e-02f, 3.76309385e-03f, 7.05719441e-02f, 2.92515121e-02f, 4.45368364e-02f,
  1.97336137e-01f, -1.50916740e-01f, 5.30064991e-03f, 1.43470868e-01f, 1.08040109e-01f, 1.83935553e-01f, 3.54942158e-02f, 2.43698582e-01f, 1.19810037e-01f, 1.16392314e-01f,
  -2.47306526e-02f, -1.55691832e-01f, 1.34034693e-01f, 3.12848687e-02f, 7.30616674e-02f, 7.29958043e-02f, 8.12300667e-02f, 1.47269756e-01f, -2.39814315e-02f, -5.76962531e-02f,
  -1.16558060e-01f, 1.30130783e-01f, 3.87486555e-02f, 6.49723634e-02f, 1.01172797e-01f, -1.69152290e-01f, 1.90657720e-01f, -1.02288745e-01f, -8.35316852e-02f, -1.71541050e-01f,
  -2.08649375e-02f, -5.48970141e-02f, -1.53564215e-01f, 1.49222448e-01f, -2.80249286e-02f, -1.12859093e-01f, -8.05890858e-02f, -6.54392084e-03f, 1.20428391e-01f, -1.64830163e-01f,
  1.29525561e-03f, -2.43454039e-01f, 1.05359972e-01f, -8.95505846e-02f, 2.54914593e-02f, -5.50939813e-02f, 1.04148053e-01f, -1.89050511e-02f, 1.78663731e-01f, 2.41889134e-01f,
  -1.21182635e-01f, -2.92128325e-01f, 2.62364000e-01f, 1.23620585e-01f, -2.07210124e-01f, 2.57236153e-01f, 1.16598740e-01f, 7.34903142e-02f, 7.38104805e-02f, -1.00881204e-01f,
  4.03310955e-02f, 2.15353996e-01f, -2.26348415e-01f, -3.31516564e-02f, 2.59878319e-02f, 7.69717842e-02f, 6.43332005e-02f, 3.64250764e-02f, -7.59623572e-02f, 1.32656088e-02f,
  -9.09487605e-02f, -2.22736429e-02f, -9.73779187e-02f, 2.52405368e-02f, 5.12970313e-02f, -7.45415920e-03f, -2.01610867e-02f, -5.57685345e-02f, -4.27553877e-02f, -5.41836321e-02f,
  -3.59278958e-04f, -1.94160547e-02f, 1.01963297e-01f, -6.20772131e-02f, -3.02852187e-02f, -8.25170130e-02f, -1.67726830e-01f, 7.94113129e-02f, -5.23227267e-02f, -1.21050291e-01f,
  -5.25755854e-03f, 9.49121825e-03f, -1.61856823e-02f, 8.52307901e-02f, -7.07917660e-02f, -2.08448917e-01f, -1.49792135e-01f, -2.16109186e-01f, -2.07399502e-01f, -1.07512541e-01f,
  5.72939888e-02f, 6.16240837e-02f, 1.05073221e-01f, 1.42653463e-02f, -5.35552613e-02f, 1.29031092e-01f, 1.26001015e-01f, -1.98515400e-01f, -1.78405017e-01f, 1.89269423e-01f,
  1.11708514e-01f, 1.06972009e-01f, 2.53940433e-01f, 1.92411579e-02f, -9.40827131e-02f, -5.90645336e-02f, 3.39084826e-02f, -4.36491035e-02f, -6.82273656e-02f, 1.16833486e-01f,
  2.21259266e-01f, 5.68189984e-03f, 1.02842808e-01f, -1.05599336e-01f, 8.00688192e-02f, 5.21715023e-02f, 6.01378940e-02f, 8.86576101e-02f, -9.98489261e-02f, -1.52313396e-01f,
  2.37377658e-02f, -9.70529094e-02f, -9.86024737e-02f, 3.13066572e-01f, -1.74167961e-01f, -2.08360910e-01f, -8.93983319e-02f, 1.23083949e-01f, 2.27211133e-01f, -1.97073907e-01f,
  -2.29017287e-02f, 3.96784581e-02f, -5.27421124e-02f, -1.69394746e-01f, 4.22372594e-02f, -1.09924577e-01f, 4.50180173e-02f, -3.46054547e-02f, -9.11254361e-02f, 3.12620327e-02f,
  -1.60071880e-01f, -5.25261760e-02f, -1.10477738e-01f, 2.07592562e-01f, -1.50405481e-01f, 1.25570878e-01f, -8.14939663e-02f, 1.17039710e-01f, -9.48924944e-03f, 1.85424656e-01f,
  6.07946776e-02f, -1.08658433e-01f, -9.71833393e-02f, -1.28656179e-01f, -4.00763527e-02f, 1.03077836e-01f, -4.71960455e-02f, 1.25353903e-01f, -9.70746353e-02f, -2.91507728e-02f,
  -6.14292473e-02f, 1.36955202e-01f, 2.37828210e-01f, 8.03025439e-02f, -1.39498310e-02f, -1.24128573e-02f, -8.25532973e-02f, -8.37799609e-02f, 4.01547141e-02f, 2.24559337e-01f,
  -7.19568059e-02f, -1.02004506e-01f, 1.21889554e-01f, -1.96959496e-01f, -1.48883417e-01f, 1.10457554e-01f, -1.80619374e-01f, -1.52133867e-01f, -2.34414846e-01f, -1.55148700e-01f,
  1.75888583e-01f, -1.73895493e-01f, -1.49421506e-02f, 3.89732309e-02f, -1.15201898e-01f, 7.99959302e-02f, 4.90327217e-02f, 5.30029181e-03f, 3.51389237e-02f, 3.04550342e-02f,
  1.59447923e-01f, -1.53338671e-01f, -1.42747998e-01f, 6.04320737e-03f, 8.46486390e-02f, -6.55644387e-02f, -1.50807142e-01f, 1.70150027e-01f, -1.35218818e-02f, 6.13350794e-02f,
  1.28075734e-01f, 1.34685367e-01f, 8.01191758e-03f, 1.26902655e-01f, 5.33495508e-02f, 2.60504838e-02f, 5.50414920e-02f, -3.09101138e-02f, -9.14103985e-02f, -6.71162922e-03f,
  -1.35296490e-02f, 7.89527670e-02f, -1.08918697e-01f, 9.90724750e-03f, -1.19913779e-01f, 9.91652012e-02f, -1.88295037e-01f, 4.89203446e-02f, 7.82817304e-02f, 8.65806043e-02f,
  1.50319397e-01f, 1.48235848e-02f, -8.37704986e-02f, -2.12093309e-01f, 1.01846538e-01f, -7.57438093e-02f, -1.24950528e-01f, -4.41596992e-02f, 3.62398028e-02f, -1.18975833e-01f,
  1.46721482e-01f, 1.24777399e-01f, 8.04587826e-03f, -5.18522970e-02f, 1.64678887e-01f, 2.70394869e-02f, -1.41428411e-01f, 5.70630059e-02f, 1.46570966e-01f, -5.92649654e-02f,
  1.86295323e-02f, -6.31737188e-02f, -3.83064449e-02f, 4.79695350e-02f, -6.81561083e-02f, 2.00742856e-01f, 1.85863152e-01f, -1.59144744e-01f, 9.62792188e-02f, -1.60499718e-02f,
  -1.28056645e-01f, -1.57898545e-01f, -2.28725791e-01f, 7.66831264e-02f, -1.50943860e-01f, 1.75212920e-01f, 4.94861789e-02f, -1.27483353e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.32759252e-01f, 2.65711695e-01f, 3.43484432e-02f, -3.76995973e-04f, 1.99069306e-01f, 7.52031654e-02f, 5.92519529e-02f, 1.91446692e-01f, 1.80511191e-01f, 1.36938602e-01f,
  9.72101539e-02f, 2.72339910e-01f, -1.84226230e-01f, 1.32616550e-01f, -6.95764646e-02f, 1.77886531e-01f, 2.35526524e-02f, 2.29290053e-01f, -2.23364756e-01f, -1.67536125e-01f,
  1.01673782e-01f, -5.37911616e-02f, -6.23764321e-02f, -9.30251405e-02f, 9.20201540e-02f, -1.08424708e-01f, -9.50881541e-02f, 2.96874464e-01f, 7.61559531e-02f, 1.34928133e-02f,
  -6.94176182e-02f, -1.08299777e-01f, -1.86234564e-01f, 3.45432013e-01f, 1.70200229e-01f, 3.96578051e-02f, 9.21080559e-02f, -2.31292248e-01f, -9.26370639e-03f, 3.02483141e-01f,
  -1.36719868e-01f, 1.44724518e-01f, 8.59103873e-02f, -1.66341603e-01f, -9.56084058e-02f, 2.01677009e-01f, 1.19215041e-01f, 1.54911831e-01f, 1.61459073e-01f, -2.37415964e-03f,
  1.68059796e-01f, 1.74086347e-01f, -1.44653291e-01f, 8.66217092e-02f, 6.53794110e-02f, 1.24501817e-01f, -7.18944967e-02f, 7.09189847e-02f, 2.82263517e-01f, -2.67619401e-01f,
  4.36132699e-02f, 2.29253903e-01f, 2.81726420e-01f, 6.84963986e-02f, 8.12020376e-02f, 1.73090801e-01f, 2.77740369e-03f, 1.35272026e-01f, 9.58294272e-02f, -5.31825125e-02f,
  2.41203442e-01f, 1.44949714e-02f, 2.15095624e-01f, 1.89269349e-01f, 1.15101799e-01f, -4.83816862e-03f, -2.17652202e-01f, -4.86480109e-02f, -1.53787956e-01f, 1.77160904e-01f,
  -5.91874309e-02f, -7.23430291e-02f, -7.07015917e-02f, -2.75950313e-01f, -4.29846831e-02f, -1.94448188e-01f, -1.42135262e-01f, 6.95312247e-02f, 1.54487684e-01f, -1.45824794e-02f,
  -6.64259354e-03f, 2.73178548e-01f, 5.94023354e-02f, 1.19299173e-01f, -9.64350104e-02f, -3.47841308e-02f, -1.04143053e-01f, 8.67421087e-03f, 1.78439125e-01f, 1.88704841e-02f,
  -6.75666006e-03f, -7.12278411e-02f, 1.74865112e-01f, 1.88517541e-01f, -6.23023361e-02f, -2.98933983e-02f, 4.20037359e-02f, -2.47842241e-02f, -2.02894092e-01f, 2.39153504e-01f,
  1.06681406e-01f, -3.10923927e-03f, -6.24349266e-02f, 2.81434119e-01f, -3.86707224e-02f, 2.80866116e-01f, -8.25589150e-02f, -2.50154167e-01f, -1.95456445e-01f, 1.68222651e-01f,
  9.20758173e-02f, 2.92500883e-01f, 9.00862515e-02f, -6.89460337e-02f, 9.82640162e-02f, -6.58953115e-02f, 2.88602449e-02f, -4.79678623e-02f, 7.29084313e-02f, 1.15741342e-01f,
  1.59217983e-01f, 5.50259613e-02f, 2.26435319e-01f, 3.42332721e-01f, 2.93574125e-01f, 2.50914425e-01f, 5.44190742e-02f, 1.37415782e-01f, 5.08677214e-02f, 2.17817903e-01f,
  7.63132945e-02f, -1.75431982e-01f, -1.65279821e-01f, 1.75741673e-01f, -1.61899984e-01f, 7.43103921e-02f, 1.28303036e-01f, -1.17032997e-01f, -1.73404917e-01f, 7.25867227e-03f,
  -2.16889501e-01f, 1.15801439e-01f, 1.13636076e-01f, 5.26664592e-02f, 4.17784899e-02f, -1.38279786e-02f, 1.72791898e-01f, -6.91764727e-02f, -5.56849055e-02f, -8.22854564e-02f,
  -3.94855589e-02f, -8.39328207e-03f, 8.95437822e-02f, 1.91475496e-01f, 3.96288961e-01f, 8.24436247e-02f, -3.37817259e-02f, -4.02147360e-02f, 1.35112256e-01f, 3.01848277e-02f,
  1.99368209e-01f, 1.11510735e-02f, 1.75290525e-01f, 9.78086144e-02f, 2.62924820e-01f, 1.00001700e-01f, 2.76975960e-01f, 3.25902224e-01f, 9.12164897e-02f, 1.80111215e-01f,
  1.08254943e-02f, -2.51337308e-02f, -1.05607823e-01f, 1.96999133e-01f, 2.20643491e-01f, 1.04442850e-01f, -7.34536499e-02f, 1.85601376e-02f, 8.96324310e-03f, 2.23629743e-01f,
  1.80591628e-01f, -2.01441526e-01f, -2.30205692e-02f, 2.73626417e-01f, 1.92885712e-01f, 2.74456263e-01f, 1.59802318e-01f, 7.39582926e-02f, 2.15439826e-01f, 2.43902102e-01f,
  -4.26199138e-02f, 1.25333056e-01f, 1.81319892e-01f, 5.92185073e-02f, 1.02584690e-01f, 4.88223545e-02f, -6.11163303e-02f, 3.21127400e-02f, 1.42111361e-01f, -1.63626239e-01f,
  1.46827489e-01f, -1.24751776e-01f, -2.94990577e-02f, -4.54499014e-02f, -1.47867605e-01f, 2.22501785e-01f, 1.71574242e-02f, -9.71913040e-02f, -2.76075095e-01f, 1.52199760e-01f,
  2.27339298e-01f, -1.56113341e-01f, -2.07676008e-01f, -8.61625969e-02f, -3.61637697e-02f, -1.36405170e-01f, 1.73720390e-01f, 2.01734141e-01f, 1.47065386e-01f, -7.76638240e-02f,
  1.09537780e-01f, -2.62517948e-02f, -6.81813955e-02f, 6.11032657e-02f, 2.11997613e-01f, 6.77170679e-02f, 2.56594926e-01f, 1.95669636e-01f, 1.92409486e-01f, 2.46611267e-01f,
  5.82765415e-02f, 2.48440102e-01f, 1.00655146e-02f, 3.24658602e-01f, -2.02505678e-01f, -4.62335348e-02f, -5.30878268e-03f, 7.34803006e-02f, 1.64824426e-01f, 8.69162288e-03f,
  -2.55667895e-01f, -2.95862615e-01f, -1.93169385e-01f, -9.06642601e-02f, 9.86098573e-02f, -5.34584410e-02f, -2.10830849e-02f, -2.79048830e-02f, 1.26770874e-02f, 2.39141673e-01f,
  3.58219668e-02f, -1.24646118e-02f, 1.95638597e-01f, 1.40406579e-01f, -5.93579896e-02f, 8.33345875e-02f, 1.02756627e-01f, 6.54276907e-02f, 8.06118101e-02f, -1.54907718e-01f,
  -3.35196137e-01f, -1.68953463e-01f, -1.10919094e-02f, -7.44005367e-02f, 1.41780183e-01f, 1.76356375e-01f, -2.39851534e-01f, 2.97300428e-01f, -2.78138351e-02f, 2.83908099e-01f,
  1.01425879e-01f, -1.47202713e-02f, 2.22487286e-01f, -1.17567018e-01f, 3.15090001e-01f, -1.71087936e-01f, 9.02519971e-02f, -1.54534936e-01f, 4.58493941e-02f, -1.85224161e-01f,
  1.61299944e-01f, 1.86244667e-01f, -8.59732181e-02f, -3.38823050e-02f, 1.00877240e-01f, 8.13703518e-03f, 6.21879771e-02f, -3.10384542e-01f, 3.34326744e-01f, -9.49356258e-02f,
  3.09119970e-01f, -1.40585974e-02f, -1.40607050e-02f, 6.61594868e-02f, 2.11541325e-01f, 5.03421649e-02f, -5.67028075e-02f, 6.75329864e-02f, 3.73917401e-01f, 4.94941771e-02f,
  6.44870847e-02f, 3.73788737e-02f, 1.34495392e-01f, -1.02531016e-01f, -1.31829921e-02f, 4.26671118e-01f, 2.96963584e-02f, 7.46970857e-03f, 1.39732093e-01f, 1.13632016e-01f,
  1.61345899e-01f, 6.78991303e-02f, 2.24610999e-01f, 3.16899866e-02f, 2.24903673e-01f, 1.57710120e-01f, 1.86638847e-01f, 1.71735764e-01f, 3.34130339e-02f, 2.15733629e-02f,
  2.43584946e-01f, 1.62605122e-01f, -3.75798158e-02f, 1.83138266e-01f, -7.94141367e-03f, -1.34344399e-01f, 3.31199020e-01f, 3.41567695e-02f, -1.36624053e-01f, -2.71638501e-02f,
  -1.46843761e-01f, 1.34463072e-01f, 1.63713783e-01f, 9.07081217e-02f, -1.82180300e-01f, -1.39161423e-01f, -2.18172640e-01f, 2.65651226e-01f, 1.10060461e-01f, -2.14025423e-01f,
  -1.71523929e-01f, 4.02065460e-03f, -1.52249306e-01f, -6.60639480e-02f, 2.93754458e-01f, 3.49061757e-01f, 1.75907016e-01f, -1.59073636e-01f, 1.33715421e-01f, -6.45433441e-02f,
  -2.05581263e-01f, 8.84703100e-02f, -9.76283401e-02f, -2.05998927e-01f, 1.19296581e-01f, 1.48982499e-02f, -1.13775142e-01f, 3.04113835e-01f, 7.70198032e-02f, -2.03464162e-02f,
  2.60933936e-02f, 1.12735689e-01f, -1.29730403e-01f, 3.23252738e-01f, 2.04496533e-01f, -6.09049648e-02f, 2.37570062e-01f, -2.03554392e-01f, 9.14515345e-04f, -2.06372261e-01f,
  -3.24490666e-01f, 5.54723814e-02f, 5.31865731e-02f, 9.55173895e-02f, 2.40336284e-01f, -1.56471673e-02f, 6.00354522e-02f, 3.71914543e-02f, 1.86536446e-01f, 2.47425541e-01f,
  -3.50546986e-02f, 2.13214934e-01f, 2.02640802e-01f, 1.10977538e-01f, 1.05441168e-01f, 9.71617624e-02f, 1.17042623e-01f, 1.42958552e-01f, 1.79832235e-01f, -1.89882457e-01f,
  -1.45205989e-01f, -2.66081184e-01f, 1.22147039e-01f, 3.58889550e-01f, 1.10925026e-01f, -6.51527494e-02f, 1.54741496e-01f, -4.07876410e-02f, 1.02064379e-01f, 7.75721967e-02f,
  1.28898889e-01f, -2.09172353e-01f, -2.00103689e-02f, 3.36371243e-01f, 5.58436103e-02f, 2.11866051e-01f, 6.82885200e-02f, 1.82238594e-01f, -1.35923788e-01f, -8.12637135e-02f,
  2.08225176e-01f, 3.16984862e-01f, -4.09519859e-02f, 3.81063782e-02f, 2.45338619e-01f, 1.40790433e-01f, 4.28534262e-02f, 2.00782448e-01f, 3.07317227e-02f, -3.47059399e-01f,
  7.72094205e-02f, 1.76655307e-01f, -2.94835478e-01f, -1.66313276e-01f, 1.74893960e-01f, -1.40262887e-01f, -2.09768698e-01f, -2.68894844e-02f, 6.57103285e-02f, 7.27772638e-02f,
  -1.12109698e-01f, 1.30552694e-01f, -9.19948369e-02f, 1.00217629e-02f, 1.32936120e-01f, -1.33594377e-02f, -4.30892520e-02f, 2.13361725e-01f, 5.91358580e-02f, 1.10958703e-01f,
  1.66029721e-01f, 2.74499595e-01f, 2.37910807e-01f, 2.75434852e-01f, 1.76858991e-01f, 1.23834424e-01f, 3.88950817e-02f, 1.98897392e-01f, 1.03804067e-01f, 6.02966873e-03f,
  8.96628276e-02f, -1.04937226e-01f, -1.97562188e-01f, -1.73377976e-01f, -1.23693375e-02f, -7.94395953e-02f, 2.98297554e-01f, 8.24062377e-02f, -1.24792300e-01f, 2.12348312e-01f,
  -1.43168010e-02f, 2.22825080e-01f, -2.47788690e-02f, 1.56396776e-01f, 1.21141493e-01f, -2.35361814e-01f, 1.49313450e-01f, -6.65797144e-02f, 1.12516493e-01f, -3.22385281e-02f,
  1.74605474e-01f, -2.53905505e-01f, 8.34384486e-02f, 2.41392642e-01f, 3.80347252e-01f, 2.78597325e-01f, -9.94409546e-02f, -1.69541433e-01f, 3.54634225e-01f, -1.42357081e-01f,
  6.14372976e-02f, 2.66943485e-01f, 2.05323413e-01f, 1.16015360e-01f, 2.12211445e-01f, -1.41526580e-01f, 1.00406498e-01f, 1.40333712e-01f, -2.80150473e-01f, 2.52098233e-01f,
  5.16135506e-02f, -7.69600123e-02f, -1.02627717e-01f, -7.52864704e-02f, 1.52271733e-01f, 4.99533787e-02f, -1.83944702e-01f, 6.39505759e-02f, 6.44836277e-02f, 1.09236695e-01f,
  1.30975023e-01f, -1.92344055e-01f, -5.09053294e-04f, 5.02251573e-02f, 1.10317372e-01f, -1.02705264e-03f, 3.28045748e-02f, 3.13100927e-02f, 1.81636453e-01f, 1.11497805e-01f,
  3.06832850e-01f, 6.29962385e-02f, -1.05708316e-01f, 6.76473007e-02f, -7.01080039e-02f, -1.60929233e-01f, -5.18473722e-02f, 2.49797508e-01f, -2.45466828e-01f, 4.70944084e-02f,
  1.42857507e-01f, -2.83298105e-01f, 1.35281980e-01f, -1.16421305e-01f, -6.64464459e-02f, -7.35339001e-02f, 1.96826980e-01f, 2.31343154e-02f, -1.21011131e-01f, 1.60390705e-01f,
  -2.87440360e-01f, 2.75564253e-01f, -1.00092907e-02f, -4.10746876e-03f, -3.59012008e-01f, 1.91038206e-01f, 1.96264476e-01f, -1.83112592e-01f, 2.66940981e-01f, 1.97622746e-01f,
  4.97291535e-02f, 1.58127621e-01f, 4.68833931e-02f, -5.36204427e-02f, 3.02797630e-02f, 1.62896827e-01f, -2.41135284e-01f, 1.68374285e-01f, 1.59472510e-01f, -6.13000058e-02f,
  -4.55256216e-02f, 2.40082622e-01f, 4.07797098e-03f, 1.80606857e-01f, -1.90660402e-01f, -3.23309541e-01f, -2.75488406e-01f, 1.82737172e-01f, -1.19533762e-02f, 4.87011850e-01f,
  1.20660421e-02f, -1.48223609e-01f, -1.76366288e-02f, 1.28101587e-01f, 2.35310569e-01f, -3.09845954e-01f, 7.60062933e-02f, 1.14198901e-01f, 1.99859381e-01f, 1.23300940e-01f,
  1.07219145e-01f, -1.10603552e-02f, 1.89722374e-01f, 1.71894595e-01f, 8.11572149e-02f, 5.67222983e-02f, 1.88203469e-01f, 2.24347055e-01f, 2.91316328e-03f, 1.44047245e-01f,
  -4.96674590e-02f, 2.18839064e-01f, -1.33971021e-01f, 1.35336503e-01f, -6.88721761e-02f, 1.97858587e-01f, -5.27016260e-02f, 2.96335723e-02f, 8.58301520e-02f, -1.94680661e-01f,
  9.72132385e-02f, 8.93793479e-02f, 2.35935152e-01f, -1.45081893e-01f, 1.30231202e-01f, 1.11080371e-01f, 1.42414480e-01f, 3.03349733e-01f, 2.97726899e-01f, -6.30685687e-02f,
  -4.51005213e-02f, -2.53314793e-01f, -1.71061203e-01f, 7.54646808e-02f, -1.16606122e-02f, 2.73596704e-01f, 1.48494616e-01f, 2.01290026e-01f, 1.35528713e-01f, -1.70995563e-01f,
  2.32540116e-01f, -2.43786499e-01f, -8.13381746e-02f, -1.75048694e-01f, -1.74943969e-01f, -1.54198915e-01f, 2.77406067e-01f, -2.21292689e-01f, 2.89338619e-01f, 1.31663054e-01f,
  8.71684104e-02f, -1.42027587e-01f, 2.27777690e-01f, -2.18942583e-01f, 6.22493215e-02f, 2.35465571e-01f, 2.37869620e-01f, -9.40224677e-02f, -2.47703418e-02f, 4.23090398e-01f,
  1.56176463e-01f, 1.76973671e-01f, 1.11409970e-01f, 2.76070565e-01f, 2.59710431e-01f, 6.41991571e-02f, -1.96730494e-02f, 1.04303122e-01f, 9.77519527e-02f, 8.36348236e-02f,
  2.64728069e-01f, 1.99426100e-01f, 1.58431336e-01f, 1.55782506e-01f, 3.57557952e-01f, -3.91081423e-01f, 1.74338669e-01f, 1.51181906e-01f, -1.48701325e-01f, 1.03891373e-03f,
  2.17665389e-01f, 1.84052914e-01f, 1.78801343e-01f, -2.69833267e-01f, -1.58329442e-01f, -5.95973097e-02f, 3.36789154e-02f, 1.57430485e-01f, -1.58051923e-01f, 3.29552242e-03f,
  -1.57565981e-01f, 1.39795110e-01f, 9.69249308e-02f, 2.42556166e-02f, 6.33940324e-02f, 1.21099785e-01f, 8.24410617e-02f, 2.00354174e-01f, -6.01016916e-02f, 9.06643122e-02f,
  1.58566788e-01f, 1.69879735e-01f, -3.90824750e-02f, 1.69735833e-03f, -3.07562262e-01f, 7.51873776e-02f, -1.22938298e-01f, 2.93609023e-01f, 2.06911396e-02f, 2.97706518e-02f,
  -1.12527914e-01f, 2.51744483e-02f, 2.00202614e-01f, 2.78373778e-01f, 2.47250870e-01f, 1.04048632e-01f, 1.19897127e-01f, -2.00480998e-01f, 2.46553272e-01f, -6.06200211e-02f,
  -2.11950138e-01f, -2.84804823e-03f, 1.11887669e-02f, 1.49675041e-01f, 2.94754952e-01f, 1.64737910e-01f, 8.31110254e-02f, 1.79850250e-01f, 1.55586347e-01f, 2.64300764e-01f,
  6.69114292e-02f, 1.80504154e-02f, 1.24072261e-01f, 1.17095761e-01f, 1.61177635e-01f, 1.72138587e-01f, 1.46922261e-01f, 1.21942513e-01f, 3.77056956e-01f, -2.32346967e-01f,
  -2.40799058e-02f, -2.21193377e-02f, 1.35092195e-02f, -8.87013748e-02f, -1.44270919e-02f, 7.16429800e-02f, 4.85535897e-02f, -2.20021099e-01f, 5.33986650e-02f, 2.30510291e-02f,
  1.79728881e-01f, 9.01865959e-02f, -2.23014802e-01f, 1.43223941e-01f, -1.81809694e-01f, -1.03111930e-01f, 3.93596739e-02f, 1.17461719e-01f, 1.35716379e-01f, -1.18876427e-01f,
  3.38117659e-01f, 9.47076753e-02f, -1.34096205e-01f, -2.71956831e-01f, 8.99025798e-02f, 3.33621860e-01f, -3.46059591e-01f, 2.41216138e-01f, -3.62690479e-01f, -2.70260721e-01f,
  1.13580292e-02f, 9.18581113e-02f, -1.98234115e-02f, 9.61376056e-02f, -7.40571460e-03f, -1.97129652e-01f, -1.23672292e-01f, 1.48792386e-01f, 3.26193690e-01f, -1.16613649e-01f,
  -1.49677113e-01f, 1.38801843e-01f, -1.50982559e-01f, 4.13251072e-02f, -5.77869415e-02f, 8.25254992e-02f, 1.68119267e-01f, -1.61199346e-01f, 8.59596729e-02f, -3.24409753e-02f,
  1.46829009e-01f, 1.67903438e-01f, 1.97678506e-01f, 1.75806671e-01f, -1.29624516e-01f, 1.70804579e-02f, -3.48558612e-02f, 5.06151505e-02f, 1.13011070e-01f, 5.00581153e-02f,
  1.46080349e-02f, -1.69277981e-01f, 3.58812243e-01f, -1.19900249e-01f, 1.90618560e-01f, -1.79126590e-01f, 1.03353053e-01f, 9.64220911e-02f, -1.93557203e-01f, 1.38955787e-01f,
  1.18386984e-01f, 1.03899062e-01f, -8.96316171e-02f, 1.04995809e-01f, 1.78462490e-01f, -2.18686461e-01f, 1.26983792e-01f, 1.60372838e-01f, 3.51900645e-02f, 6.73098490e-02f,
  -9.88017246e-02f, 8.81968141e-02f, -1.03021249e-01f, 2.92441189e-01f, 2.91199565e-01f, 3.11474651e-01f, -2.03244016e-01f, -2.61330217e-01f, 2.64575601e-01f, 7.87754729e-02f,
  -3.31400424e-01f, 3.40088159e-01f, 1.48466989e-01f, -9.68974605e-02f, 2.03765675e-01f, 1.27767846e-01f, 1.09259613e-01f, -1.95528537e-01f, -1.65837526e-01f, 1.06824609e-02f,
  -1.52279004e-01f, 9.78336204e-03f, -5.02828807e-02f, -2.54349351e-01f, -3.32339369e-02f, 2.68912435e-01f, 7.05700591e-02f, -2.26689324e-01f, 5.03658801e-02f, -7.77289271e-02f,
  3.57686467e-02f, 1.76915154e-02f, 2.94021547e-01f, 6.85533062e-02f, 1.35887682e-01f, -4.40968759e-02f, 2.17208296e-01f, 4.35205624e-02f, -1.55068804e-02f, 7.29016289e-02f,
  1.05637841e-01f, 1.76292643e-01f, 9.90829393e-02f, 3.13590556e-01f, -1.04111373e-01f, 1.83068767e-01f, 1.46278311e-02f, 6.24114759e-02f, 9.13076475e-02f, -1.76480412e-02f,
  -3.25410254e-02f, -9.11268368e-02f, -7.40842754e-03f, -3.27241629e-01f, 2.87407674e-02f, -9.67294499e-02f, 1.07173249e-01f, 1.48953333e-01f, 1.34137303e-01f, 2.02554166e-02f,
  -1.05315641e-01f, 2.09125936e-01f, -6.77680671e-02f, 1.84277475e-01f, -3.10467988e-01f, 2.99631387e-01f, 1.48068666e-01f, -5.22681363e-02f, 1.71799004e-01f, 1.45062774e-01f,
  1.35791060e-02f, 2.68128633e-01f, 5.92039041e-02f, 4.15591359e-01f, 2.58370396e-02f, 2.48013154e-01f, -1.86413433e-02f, -7.15068430e-02f, 4.68824282e-02f, 5.39216287e-02f,
  1.85564589e-02f, -1.71744257e-01f, 2.53130883e-01f, 1.81775510e-01f, -1.44393280e-01f, -3.27443071e-02f, 1.45244136e-01f, -5.97741967e-03f, -1.14735819e-01f, 2.63587326e-01f,
  -8.25517997e-02f, -1.50749072e-01f, -4.98557501e-02f, 8.21893513e-02f, 1.66681379e-01f, -1.85577974e-01f, 1.35207281e-01f, -6.76457062e-02f, 1.00301325e-01f, 2.79101163e-01f,
  1.71492010e-01f, 8.56245011e-02f, 1.25601873e-01f, 1.28021792e-01f, -4.46200222e-02f, 1.00387916e-01f, 1.63957208e-01f, 9.97918472e-02f, 1.99575007e-01f, 1.77513305e-02f,
  -1.94708675e-01f, -6.92878570e-03f, -6.08175248e-02f, 4.04764786e-02f, 1.14333749e-01f, 1.63346753e-01f, -1.95619732e-01f, 1.99444205e-01f, -1.97923884e-01f, 4.65483069e-02f,
  1.81697737e-02f, 4.89254296e-02f, 1.35024026e-01f, -2.22355217e-01f, 7.93490335e-02f, -2.15481237e-01f, 7.31448829e-02f, 7.03466684e-03f, 2.28407443e-01f, -1.88260168e-01f,
  4.39588614e-02f, 1.48575559e-01f, 1.04842082e-01f, 2.72777349e-01f, 9.67250988e-02f, -2.48388708e-01f, 2.57324725e-01f, -1.76189452e-01f, 2.09878609e-01f, 1.16017684e-01f,
  3.05288374e-01f, 1.36217594e-01f, 1.16485842e-01f, -7.04413578e-02f, 1.09280244e-01f, 3.17434818e-02f, -2.02390537e-01f, -1.66406669e-02f, 2.61583090e-01f, -1.04993537e-01f,
  -1.54191926e-01f, -7.27456659e-02f, 3.01345229e-01f, 8.82688258e-03f, -1.52747437e-01f, 3.09381843e-01f, -4.92835715e-02f, 3.78770456e-02f, 1.70296803e-01f, 7.36115500e-02f,
  2.13184729e-01f, 9.32913199e-02f, 1.08584963e-01f, 3.33547071e-02f, 2.05447048e-01f, 2.56703645e-01f, 1.00688092e-01f, 1.05047941e-01f, 5.12004979e-02f, 1.61475420e-01f,
  -2.25639772e-02f, 1.11131094e-01f, -1.85140416e-01f, -1.61227807e-01f, 1.55622616e-01f, -1.48205578e-01f, 3.76493149e-02f, 2.21024126e-01f, -3.48314643e-02f, -9.14948657e-02f,
  -1.12317398e-01f, -1.48939550e-01f, -6.06311969e-02f, -2.86515448e-02f, -5.98161109e-02f, 9.05722901e-02f, 2.42414758e-01f, 2.49883041e-01f, 1.79560632e-01f, 1.75282508e-01f,
  1.73157826e-01f, 5.42893223e-02f, -4.75424752e-02f, 1.16410665e-01f, -9.86108631e-02f, 1.05913974e-01f, 2.75060654e-01f, 5.91389611e-02f, -1.65194571e-01f, 1.52782023e-01f,
  2.46213153e-01f, 7.46076331e-02f, -1.95140928e-01f, 2.46170059e-01f, 2.91859835e-01f, -4.65713143e-02f, 2.91239887e-01f, 3.67603675e-02f, 1.42130226e-01f, -3.21450941e-02f,
  -1.38801094e-02f, -5.10477982e-02f, -4.95581664e-02f, 2.31661245e-01f, 2.37233058e-01f, -5.12482524e-02f, -3.08630109e-01f, 3.22893620e-01f, 3.12803149e-01f, -1.35259464e-01f,
  2.06100568e-02f, 1.39973685e-01f, 1.82017207e-01f, 1.14717625e-01f, 5.61115704e-02f, 4.65699136e-02f, 5.16552329e-02f, 1.66057661e-01f, 1.61375850e-01f, 6.04899228e-02f,
  2.72865564e-01f, -9.41843726e-03f, 6.08366765e-02f, 1.90943792e-01f, 1.20977974e-02f, 2.55771160e-01f, -1.20375939e-01f, -2.81400800e-01f, -2.16192782e-01f, 9.13798809e-02f,
  -6.72283694e-02f, -2.17174917e-01f, 1.76050976e-01f, -1.90986931e-01f, -1.07875153e-01f, -2.59711564e-01f, -2.60930896e-01f, -5.56182005e-02f, 2.99882710e-01f, 6.90791607e-02f,
  1.79974258e-01f, 8.01062211e-02f, -1.38288423e-01f, 2.10095927e-01f, 1.74371988e-01f, 5.28485468e-03f, -1.94318876e-01f, 6.37257844e-02f, 1.74248934e-01f, -5.40027469e-02f,
  -6.63730875e-02f, 1.49690490e-02f, -6.13956824e-02f, 1.27029061e-01f, 2.89974868e-01f, -2.44603604e-02f, 2.63406783e-02f, 3.94816957e-02f, 2.64521013e-03f, 1.54991552e-01f,
  4.74073365e-02f, -2.67774880e-01f, 3.80673073e-02f, 1.58760175e-01f, -2.05438975e-02f, 1.73013374e-01f, 1.65663436e-01f, -2.20875487e-01f, -1.55042008e-01f, 2.55971760e-01f,
  6.20571198e-03f, 3.03332299e-01f, 1.69798099e-02f, 2.46644393e-01f, 1.15254015e-01f, 2.85859913e-01f, 2.43275851e-01f, -9.13137477e-03f, 1.67548805e-01f, 2.33795002e-01f,
  2.34977692e-01f, 8.26519355e-02f, 2.56746471e-01f, 1.70070976e-01f, 1.99318960e-01f, 1.67602345e-01f, 2.32179731e-01f, 2.34163910e-01f, 5.56985922e-02f, 1.13690142e-02f,
  1.44108266e-01f, 6.89528361e-02f, 3.92052867e-02f, 8.74642804e-02f, -1.85022894e-02f, -1.44586489e-01f, 1.63212463e-01f, -2.66308308e-01f, 8.14125463e-02f, 3.92698720e-02f,
  -2.27164954e-01f, 1.52888700e-01f, -2.29783669e-01f, 1.60937756e-01f, -1.79465115e-01f, 4.57603112e-02f, 5.36626913e-02f, -2.61471391e-01f, -1.90095335e-01f, -1.80684760e-01f,
  8.17160904e-02f, -5.32931127e-02f, 3.11034739e-01f, 2.74528027e-01f, 1.65839985e-01f, 6.32057786e-02f, 2.19146892e-01f, -1.07746661e-01f, -1.69565916e-01f, -2.05358610e-01f,
  2.63824314e-01f, -4.19945307e-02f, 2.12101098e-02f, 2.52035916e-01f, 9.54853594e-02f, 1.68142095e-01f, 1.33879051e-01f, 3.55947256e-01f, -1.78741720e-02f, 3.34047019e-01f,
  6.26747683e-02f, 2.04242170e-02f, -1.54072354e-02f, 2.78701484e-01f, 3.77416193e-01f, 7.40010142e-02f, -1.72671184e-01f, 5.53437918e-02f, -1.84004292e-01f, 9.19846594e-02f,
  1.56371102e-01f, -2.00763479e-01f, -2.87057762e-03f, 9.99769419e-02f, 7.14476630e-02f, 9.53716040e-02f, 1.43161222e-01f, -1.04931377e-01f, -7.19577596e-02f, -5.62446415e-02f,
  9.32807401e-02f, -6.35587201e-02f, -1.01799741e-01f, 1.96964517e-01f, -2.52541959e-01f, 1.72340751e-01f, 1.50384963e-01f, 1.43221959e-01f, -1.16930678e-01f, 1.73374578e-01f,
  2.42568422e-02f, -4.92607988e-03f, 1.01233751e-01f, -1.63790807e-01f, 9.24913287e-02f, -1.80278167e-01f, -4.32446338e-02f, 1.17675945e-01f, -3.47213857e-02f, 3.80842417e-01f,
  -8.51617903e-02f, 1.64776340e-01f, -1.16858892e-01f, 2.23182008e-01f, 2.65868932e-01f, 1.15520075e-01f, -1.07887194e-01f, -2.78274149e-01f, -3.10940117e-01f, -6.30167723e-02f,
  -2.90577989e-02f, 3.89338076e-01f, -3.91890667e-02f, -2.15113863e-01f, 1.13695655e-02f, -1.11378275e-01f, -8.72765407e-02f, 1.27796486e-01f, -1.23457566e-01f, 5.21869063e-02f,
  -3.37674320e-02f, -1.11108072e-01f, 2.66455144e-01f, -1.53143212e-01f, 1.54602900e-02f, 1.64659902e-01f, -1.33054793e-01f, -8.03317428e-02f, -1.26763284e-01f, 5.32945916e-02f,
  1.29417747e-01f, -4.87286747e-02f, 1.84504360e-01f, -3.78845595e-02f, 8.85613188e-02f, 3.12809527e-01f, 2.04995111e-01f, 2.39312574e-01f, 1.63355932e-01f, 1.02922179e-01f,
  2.67349094e-01f, 1.50850385e-01f, 1.27944857e-01f, 1.31005839e-01f, 9.40738171e-02f, 2.87176102e-01f, 1.92866370e-01f, 1.67987242e-01f, 4.15836275e-03f, 3.92405055e-02f,
  -4.26346213e-02f, 2.86316752e-01f, 1.79560319e-01f, 2.81040162e-01f, -2.68692493e-01f, 1.62432596e-01f, 2.34112099e-01f, 5.98282404e-02f, -5.11674816e-03f, -2.52958506e-01f,
  2.09811673e-01f, -1.03570335e-01f, -5.29067628e-02f, 3.02343398e-01f, -9.08282697e-02f, -1.57713160e-01f, 5.32271378e-02f, 2.67185390e-01f, 1.54885009e-01f, -7.80411363e-02f,
  1.08306751e-01f, -1.36351287e-01f, -1.32613316e-01f, 1.63303141e-03f, 3.21398556e-01f, 1.21068634e-01f, -9.33530629e-02f, 3.23795080e-01f, 1.05144925e-01f, -2.33958989e-01f,
  -1.38852596e-01f, 1.95624068e-01f, -2.09343493e-01f, -8.66227970e-02f, -1.08497143e-01f, 2.22543284e-01f, 1.65006414e-01f, 1.42052889e-01f, 2.49693111e-01f, 2.41426080e-02f,
  8.35244432e-02f, 7.10369349e-02f, 1.75504297e-01f, -1.90330252e-01f, 2.86673665e-01f, 1.85106248e-01f, -1.11313350e-01f, -1.71703137e-02f, -2.46225581e-01f, 3.40668827e-01f,
  1.87299624e-01f, 1.82423487e-01f, 2.15042695e-01f, 1.58611283e-01f, 2.44317964e-01f, 6.90249726e-02f, 5.93765220e-03f, 2.85044223e-01f, 1.43422469e-01f, 2.06621170e-01f,
  3.29127237e-02f, 1.31156757e-01f, -2.12748542e-01f, 1.17241971e-01f, -1.32931486e-01f, -8.71929154e-02f, 6.69977590e-02f, -1.78417906e-01f, 6.48912266e-02f, 1.24529883e-01f,
  1.27789125e-01f, -1.71401247e-01f, 1.50458843e-01f, 8.01348537e-02f, 2.82768570e-02f, -9.46035832e-02f, 1.31743103e-01f, 3.50329615e-02f, -4.68353890e-02f, 8.93569887e-02f,
  -1.25785455e-01f, 3.06085706e-01f, -1.50519535e-01f, 2.69626200e-01f, 2.24810496e-01f, 1.05452269e-01f, -2.62657881e-01f, -9.49850827e-02f, 1.01720810e-01f, 2.65153021e-01f,
  -7.96308368e-02f, 5.97566441e-02f, 1.53965697e-01f, -1.36904204e-02f, -6.91686794e-02f, -1.08072415e-01f, 2.46478170e-02f, 2.99115598e-01f, 5.60245141e-02f, 6.16385415e-02f,
  2.04145670e-01f, 1.12277083e-01f, -8.47165510e-02f, 2.01318935e-01f, 1.72369838e-01f, 1.84439257e-01f, -8.31286330e-03f, -1.01553917e-01f, -7.58170933e-02f, -7.98635706e-02f,
  1.34754730e-02f, -1.13224760e-01f, -1.09908856e-01f, 2.01230645e-01f, 1.17314123e-01f, -2.55940408e-02f, 5.88869452e-02f, -4.02876697e-02f, 8.36359411e-02f, -1.72124729e-02f,
  1.79264173e-01f, -1.36418566e-01f, 1.25911698e-01f, 6.37931097e-03f, -6.96480423e-02f, 1.10657141e-01f, -3.61411832e-02f, -1.03991143e-01f, 1.79012157e-02f, -3.82787287e-02f,
  -1.40674084e-01f, -1.15092225e-01f, 2.57118106e-01f, -1.76322922e-01f, -6.21517096e-03f, -2.40561396e-01f, -2.48772427e-01f, -1.64376214e-01f, -8.25093761e-02f, 2.07695261e-01f,
  2.00772211e-01f, 9.18767974e-02f, -7.84302875e-02f, 3.17714483e-01f, 5.92682138e-02f, 6.30955994e-02f, -5.49286194e-02f, 1.98490918e-01f, -4.62303199e-02f, -1.97958902e-01f,
  1.66045845e-01f, 6.65435707e-03f, -2.19878629e-01f, 8.89222249e-02f, 2.67064627e-02f, -1.28566146e-01f, 1.18637130e-01f, 1.44535437e-01f, -1.58604816e-01f, 2.20016107e-01f,
  1.47315383e-01f, 3.38948853e-02f, 7.44355544e-02f, 5.72309867e-02f, -1.86353344e-02f, -3.38150077e-02f, -9.39044356e-02f, -3.00170481e-01f, -2.85555154e-01f, 1.70361176e-01f,
  -4.40344438e-02f, 1.65177554e-01f, 1.55588817e-02f, -5.76031767e-02f, 2.79395580e-01f, 1.73244745e-01f, 2.90007889e-01f, -5.61415106e-02f, -9.13737044e-02f, 1.35428265e-01f,
  1.74107730e-01f, 4.09089364e-02f, 1.57848537e-01f, 5.92780262e-02f, 1.02027752e-01f, 1.35914370e-01f, 1.08784720e-01f, -2.25394852e-02f, -5.97838610e-02f, 1.67206243e-01f,
  -6.40234500e-02f, -1.34235486e-01f, -7.41037428e-02f, 1.53117254e-01f, 9.84173194e-02f, 1.98748559e-01f, -1.34575441e-01f, -1.76358432e-01f, 9.42055434e-02f, -2.27442741e-01f,
  -2.27119863e-01f, -2.88273662e-01f, 3.96190137e-02f, 2.22445428e-01f, -1.01539440e-01f, 1.81172103e-01f, -2.08624780e-01f, 6.54302612e-02f, 1.44350410e-01f, 1.07468635e-01f,
  -1.92242563e-01f, 2.30202690e-01f, 1.18242189e-01f, -2.21642822e-01f, -5.29809110e-02f, -5.01645766e-02f, 2.48158932e-01f, 2.59612858e-01f, -1.59583554e-01f, 1.49924038e-02f,
  7.73380995e-02f, 2.84584463e-02f, -1.13414219e-02f, 2.25586727e-01f, 1.94973767e-01f, -1.04130236e-02f, 5.03565744e-02f, 1.30744457e-01f, 6.28839508e-02f, 4.99206921e-03f,
  2.91408282e-02f, -6.04780950e-02f, -1.25203356e-01f, 2.62794852e-01f, -2.28044152e-01f, 4.36705239e-02f, 3.74050379e-01f, -1.00875208e-02f, 2.33031422e-01f, 2.64051527e-01f,
  7.41268769e-02f, -9.68872309e-02f, 6.70108050e-02f, 2.75366940e-02f, 2.63219088e-01f, 2.38978475e-01f, 8.18950981e-02f, 2.19402567e-01f, 1.16570726e-01f, 2.44833067e-01f,
  3.63341682e-02f, 1.48465097e-01f, 2.28297114e-01f, 4.96421121e-02f, 8.14038739e-02f, 5.34191877e-02f, -2.98786946e-02f, -2.48313949e-01f, -7.92561248e-02f, -1.36238769e-01f,
  1.22676246e-01f, 8.77889898e-03f, -1.25353977e-01f, 1.95642456e-01f, -1.60991430e-01f, 2.69443870e-01f, -1.95576966e-01f, 1.29670799e-01f, 2.21357003e-01f, -1.03408784e-01f,
  3.73994708e-01f, -6.16891403e-03f, 1.39728129e-01f, 1.78397186e-02f, -5.46898320e-02f, 1.49888927e-02f, 2.50566989e-01f, 3.28890979e-01f, 2.78418750e-01f, -5.92218935e-02f,
  -1.27570346e-01f, -1.25416279e-01f, 1.15595430e-01f, 3.17726843e-02f, 2.17219546e-01f, -1.08582854e-01f, 3.25403690e-01f, -1.40015811e-01f, 1.18776433e-01f, 3.74812424e-01f,
  2.95001775e-01f, 2.12917969e-01f, 3.93949263e-03f, 1.82287425e-01f, -1.13557046e-02f, 1.96242556e-01f, 2.16768533e-01f, -4.97833788e-02f, 1.33264571e-01f, -6.77873492e-02f,
  -1.66724145e-01f, 6.34376630e-02f, -3.26588266e-02f, 2.44802520e-01f, 1.64077699e-01f, -2.27040514e-01f, 1.12355845e-02f, 1.17597990e-01f, 1.65021032e-01f, -1.98288970e-02f,
  -3.49027961e-02f, 2.89895147e-01f, 2.19132304e-01f, 8.17848071e-02f, 1.53997436e-01f, -8.75971466e-02f, -1.28359079e-01f, 2.32985057e-02f, -1.01306997e-01f, -2.24575445e-01f,
  -9.53432769e-02f, 1.51501313e-01f, -1.83311477e-01f, 8.08733255e-02f, -4.18913029e-02f, -1.76932111e-01f, -1.10385884e-02f, -6.56670406e-02f, -1.72955453e-01f, -2.21063763e-01f,
  2.18708500e-01f, 1.89314201e-01f, 7.78114945e-02f, 2.15382248e-01f, 1.05198570e-01f, -6.35488182e-02f, 8.32344741e-02f, -3.78525198e-01f, -2.82248586e-01f, 4.28253859e-02f,
  6.66118935e-02f, -1.39048144e-01f, 1.03495777e-01f, -3.47844660e-02f, -8.87803882e-02f, 8.12736154e-02f, 5.91291115e-02f, -3.25026751e-01f, 7.14561790e-02f, -8.16688463e-02f,
  6.01470247e-02f, 3.35758775e-01f, 1.29632270e-02f, -2.22068310e-01f, 2.65849978e-01f, 1.85641631e-01f, -1.15346499e-01f, 1.98984414e-01f, 2.84779578e-01f, -3.19838494e-01f,
  -1.34649992e-01f, 1.97342113e-01f, 8.10601376e-03f, 1.59151837e-01f, 6.80821463e-02f, 1.31265432e-01f, 1.47312745e-01f, 1.66605577e-01f, 2.02712476e-01f, -3.13674837e-01f,
  5.37615009e-02f, 1.11189410e-01f, 1.09868698e-01f, 6.89190105e-02f, 1.68752432e-01f, 1.89739555e-01f, 1.56034917e-01f, 1.08553149e-01f, 3.26387957e-02f, 2.69736826e-01f,
  2.91922897e-01f, 3.18206251e-02f, 1.93204641e-01f, 1.80985466e-01f, 2.21124291e-01f, -1.54075921e-01f, 1.14762500e-01f, -1.64703786e-01f, -2.27816731e-01f, -2.02907920e-02f,
  -6.84238039e-03f, 3.05865407e-01f, 1.14327051e-01f, 2.29363739e-01f, -1.46405324e-01f, -2.40820367e-02f, -1.35673240e-01f, 5.68821058e-02f, 2.67284811e-01f, -2.01130703e-01f,
  -2.04885900e-01f, -1.05912946e-01f, 2.40503654e-01f, 9.13062133e-04f, 2.58115530e-01f, 1.59509107e-01f, 1.68644920e-01f, -1.30322248e-01f, 2.94372384e-02f, -1.00309633e-01f,
  -1.12504177e-02f, 1.14854321e-01f, 1.37154698e-01f, -5.77853844e-02f, 1.47215366e-01f, -4.33661826e-02f, 1.56897660e-02f, 2.90712923e-01f, 2.14686677e-01f, -2.65538618e-02f,
  -4.22223769e-02f, 1.09283499e-01f, 5.18101081e-02f, 2.25033045e-01f, 2.55343616e-01f, -9.58511680e-02f, 2.56150395e-01f, -1.01233311e-01f, 1.28643900e-01f, -1.47776857e-01f,
  -2.15399981e-01f, 2.21901741e-02f, 3.32553796e-02f, 1.04771301e-01f, 7.62099996e-02f, 1.67944193e-01f, 6.87025189e-02f, -1.52566835e-01f, -1.58400089e-02f, 1.77811086e-02f,
  1.46845579e-01f, 1.53175130e-01f, 2.46969357e-01f, -5.12103550e-02f, -1.68928310e-01f, 2.32285663e-01f, 3.84326838e-02f, 2.19193950e-01f, -1.32976070e-01f, 1.09462678e-01f,
  -3.18403468e-02f, 3.77588600e-01f, -2.21674204e-01f, 1.43378563e-02f, 3.03890873e-02f, -2.53003418e-01f, -6.81995898e-02f, -3.18503737e-01f, 2.09204301e-01f, 2.20225379e-01f,
  8.24039578e-02f, 2.41893873e-01f, 1.20042358e-02f, 2.69876242e-01f, 1.07563727e-01f, -8.26417059e-02f, -1.44928500e-01f, 2.92745024e-01f, 1.88111328e-02f, -2.22088601e-02f,
  -1.09902121e-01f, -1.06415048e-01f, 1.25684202e-01f, 3.54815423e-01f, -2.17178047e-01f, 2.51214474e-01f, -4.15808558e-02f, -8.83954018e-02f, -1.57473221e-01f, -2.89366487e-02f,
  -4.13950793e-02f, 1.38493568e-01f, 7.91529343e-02f, 5.17760112e-04f, 2.08460793e-01f, -1.05320036e-01f, -1.03405223e-03f, 2.17789501e-01f, 2.13053763e-01f, -5.15060052e-02f,
  -2.97535598e-01f, 1.46887183e-01f, 7.41575062e-02f, -3.01839352e-01f, 4.68289107e-02f, 1.29917130e-01f, 2.57651269e-01f, 5.47970645e-03f, 1.84384927e-01f, 1.25934407e-01f,
  6.51151687e-02f, 8.53392482e-02f, 2.88824618e-01f, 5.34563325e-02f, 2.50788659e-01f, 3.35479438e-01f, 2.15333909e-01f, 1.40450418e-01f, 1.20672189e-01f, 3.27943563e-02f,
  8.90224949e-02f, -9.10128281e-02f, 9.44248065e-02f, -9.44777876e-02f, 1.55756146e-01f, 1.03341274e-01f, -2.10784316e-01f, -3.06311876e-01f, 2.64251769e-01f, -8.13023373e-02f,
  1.11757651e-01f, -1.02150097e-01f, 1.72651738e-01f, -2.94717014e-01f, -1.88894033e-01f, 3.07289451e-01f, -2.16127262e-01f, -3.23663592e-01f, -1.94948718e-01f, 3.39725763e-02f,
  -1.25348181e-01f, 4.77480777e-02f, 2.01605737e-01f, 1.71852350e-01f, -1.51193470e-01f, -1.56035259e-01f, 3.19020927e-01f, -5.24498038e-02f, -1.96128920e-01f, 1.08977035e-01f,
  7.08643869e-02f, -7.26396069e-02f, -2.75497019e-01f, 1.80875704e-01f, -5.47029674e-02f, 2.14129716e-01f, 1.20743908e-01f, 1.05019949e-01f, -1.47068324e-02f, 2.26745620e-01f,
  2.05654785e-01f, 1.10524021e-01f, 1.86177567e-01f, 3.03456515e-01f, 2.22223818e-01f, -2.20537260e-01f, -1.45812616e-01f, -3.65529023e-03f, -2.21977189e-01f, -1.01276234e-01f,
  -2.21332774e-01f, -5.39778695e-02f, 8.98071602e-02f, 2.45088339e-01f, 5.13149351e-02f, 1.24616459e-01f, 7.57855922e-02f, 7.16107041e-02f, 1.98489502e-01f, 1.13700710e-01f,
  7.75852576e-02f, 1.27333373e-01f, 5.11532389e-02f, 1.14194475e-01f, -1.81452543e-01f, 1.21935971e-01f, -2.57622749e-01f, 2.04946041e-01f, -6.20353781e-02f, 2.38817051e-01f,
  -2.41536528e-01f, -1.75465286e-01f, -1.05464406e-01f, -1.29610226e-01f, -1.60609484e-01f, -2.45320201e-02f, 2.02897176e-01f, -1.36533618e-01f, 2.40773931e-02f, 1.24068290e-01f,
  1.32747501e-01f, 1.13413163e-01f, -2.25977302e-01f, 1.08950198e-01f, -2.59583831e-01f, 1.32849723e-01f, 2.78949529e-01f, 1.85576111e-01f, 2.38294397e-02f, -1.75949678e-01f,
  4.55491729e-02f, 1.76049218e-01f, -2.29720976e-02f, 3.22929621e-01f, 2.02691272e-01f, -1.29644781e-01f, -2.24562995e-02f, -3.12006264e-03f, 1.88741669e-01f, -7.53886700e-02f,
  1.24226250e-02f, -2.06829105e-02f, 2.55429476e-01f, 2.25887254e-01f, -2.76047915e-01f, 7.96297118e-02f, 2.61334330e-01f, 8.81785229e-02f, 7.66973849e-03f, 2.48843193e-01f,
  -2.36094072e-01f, -9.87425447e-02f, -2.49247208e-01f, 1.63081605e-02f, 2.89759696e-01f, -1.38981313e-01f, 2.08669692e-01f, 8.23071525e-02f, 1.61610484e-01f, 1.86581910e-02f,
  2.93038458e-01f, 1.84902966e-01f, 2.17248693e-01f, 3.07185382e-01f, 2.39772201e-01f, 1.63371742e-01f, 1.90680638e-01f, 1.13176376e-01f, 1.35871068e-01f, 2.79152114e-02f,
  -2.33097851e-01f, -1.12441599e-01f, 2.77422905e-01f, 2.25577578e-01f, 2.70534121e-02f, -2.76084822e-02f, 3.63344848e-02f, 1.14665523e-01f, 1.80890054e-01f, -3.89760733e-02f,
  2.51865089e-01f, -2.14052677e-01f, -2.15338856e-01f, -2.90172752e-02f, 2.65486352e-02f, -2.75921911e-01f, -1.29517302e-01f, 1.84756577e-01f, 2.31822897e-02f, -8.72977078e-02f,
  2.76958168e-01f, 6.40640408e-02f, -1.81427881e-01f, -1.43772170e-01f, 2.19843477e-01f, 4.77944873e-02f, -9.94521081e-02f, 3.37668926e-01f, 1.92916438e-01f, -2.20240295e-01f,
  -2.44628012e-01f, -2.10852847e-01f, -1.76850423e-01f, 1.95455045e-01f, -7.31289014e-03f, 5.79891428e-02f, 1.74209550e-01f, 1.93846121e-01f, 2.02214971e-01f, 1.03747584e-01f,
  3.50584984e-01f, 9.75124612e-02f, 3.10048938e-01f, -2.61326373e-01f, -4.28765029e-01f, 1.96520418e-01f, -2.32742056e-01f, 6.25830963e-02f, 1.48356361e-02f, 2.86873360e-03f,
  6.03157319e-02f, 8.36630091e-02f, 1.77843958e-01f, 6.52598962e-02f, 2.72169411e-01f, 1.20216079e-01f, 1.08527996e-01f, 2.78116643e-01f, 7.58513436e-02f, 5.70040271e-02f,
  2.26420686e-01f, 1.06626600e-01f, -8.60517770e-02f, 2.50481337e-01f, 3.58507261e-02f, 8.24014544e-02f, 3.90782841e-02f, 2.06887111e-01f, -4.86863144e-02f, 1.89738914e-01f,
  1.91098735e-01f, -1.80046156e-01f, 2.44354591e-01f, -1.85423747e-01f, 1.34339824e-01f, -1.90867670e-02f, 1.19640835e-01f, -1.74516886e-02f, -3.34420614e-02f, 2.88647443e-01f,
  4.54479717e-02f, 3.83583337e-01f, 3.51436108e-01f, 1.75846219e-01f, -1.42047837e-01f, -1.74798012e-01f, -2.76658256e-02f, 1.43553495e-01f, 1.49041206e-01f, 3.35302562e-01f,
  1.25758320e-01f, 2.42233589e-01f, 1.61338240e-01f, 8.29583853e-02f, -3.89618911e-02f, -8.96280631e-02f, -1.25049874e-01f, -1.48469165e-01f, -2.40060270e-01f, -4.97726277e-02f,
  4.15939063e-01f, -1.09024927e-01f, 2.78869301e-01f, 1.77395605e-02f, -2.92701107e-02f, -3.89752025e-03f, 1.72480851e-01f, -7.94638693e-02f, 3.47663522e-01f, 1.23899095e-01f,
  2.97649473e-01f, -2.10976526e-01f, 7.08289584e-03f, 2.06380576e-01f, 2.38265768e-01f, 8.45205486e-02f, 2.71283269e-01f, -4.59534414e-02f, 1.68482482e-01f, 2.71471944e-02f,
  1.03329249e-01f, 3.75419818e-02f, 1.67668968e-01f, 2.24364847e-01f, 1.62807554e-02f, 2.42058277e-01f, -2.12044224e-01f, 1.54032916e-01f, -2.09063873e-01f, 1.51233628e-01f,
  6.73696175e-02f, -2.92119682e-01f, 1.77847847e-01f, 2.58099049e-01f, 8.72257128e-02f, -1.00558631e-01f, 2.82735378e-02f, 3.31487447e-01f, 2.07371205e-01f, 1.59031123e-01f,
  6.10079542e-02f, -1.00044958e-01f, 4.02156740e-01f, 2.60346472e-01f, 1.81879789e-01f, 3.94945681e-01f, -1.15045957e-01f, 3.24086457e-01f, 8.10311958e-02f, 1.64093420e-01f,
  7.65134171e-02f, 1.72254056e-01f, -5.70229068e-02f, 3.53639960e-01f, -1.02204762e-01f, 1.26597151e-01f, 1.13354452e-01f, 6.57686144e-02f, 1.73687473e-01f, -2.78783232e-01f,
  2.03694686e-01f, 1.51264131e-01f, 1.44025967e-01f, -3.25652033e-01f, 2.77949542e-01f, 1.63972095e-01f, -2.39344329e-01f, 7.96281993e-02f, 2.60871559e-01f, -5.01720458e-02f,
  9.93087217e-02f, 3.85754593e-02f, 2.34933719e-01f, -2.32581839e-01f, 3.31906915e-01f, -4.22698334e-02f, -2.21741721e-02f, 1.37699306e-01f, 1.86973155e-01f, 1.83972925e-01f,
  1.85706377e-01f, 1.44531429e-01f, 2.41660327e-01f, 1.05235063e-01f, -1.04230851e-01f, 9.22393501e-02f, 3.53747196e-02f, 1.84349656e-01f, 1.11700237e-01f, 1.05848107e-02f,
  7.65161291e-02f, 1.99850410e-01f, 2.95005172e-01f, -2.61809945e-01f, 6.74675405e-02f, 1.86770082e-01f, -2.92354614e-01f, -1.71394378e-01f, 1.56783670e-01f, 2.39851549e-01f,
  4.25079577e-02f, -1.47548079e-01f, -2.47827366e-01f, -1.82903618e-01f, -2.56777525e-01f, 2.40691572e-01f, -5.89398481e-02f, -3.08354974e-01f, -1.91286594e-01f, -1.16849929e-01f,
  5.75720742e-02f, 1.62598103e-01f, 9.54623986e-03f, 1.10805072e-01f, -5.39289936e-02f, -2.42704615e-01f, -4.38927487e-03f, -2.78896075e-02f, -9.54179186e-03f, 8.51681232e-02f,
  -2.39353046e-01f, -2.23250598e-01f, 5.42715639e-02f, -5.63780926e-02f, -1.53974965e-01f, 2.59535074e-01f, 2.74807125e-01f, 1.84613361e-03f, -1.21392548e-01f, -3.33837569e-02f,
  1.24434948e-01f, 3.30061972e-01f, 3.07807624e-01f, -8.23540837e-02f, 1.84340030e-02f, -1.90418273e-01f, 2.34934732e-01f, -2.30670273e-01f, -1.80350199e-01f, -7.61039704e-02f,
  4.43895551e-04f, 1.59670934e-01f, -1.42702106e-02f, 9.39434171e-02f, 2.57886589e-01f, 2.36130729e-01f, 2.21285880e-01f, 1.49532259e-01f, 1.02587298e-01f, 1.83059812e-01f,
  6.80695549e-02f, 1.59325898e-01f, 2.49789178e-01f, 1.06351472e-01f, 1.47627015e-02f, 1.58879563e-01f, 7.13709593e-02f, 2.31420979e-01f, 2.21359864e-01f, -8.44829343e-03f,
  -2.81184673e-01f, -1.72798663e-01f, 1.03060111e-01f, 1.10125721e-01f, -6.89537358e-03f, -1.57652929e-01f, 3.55242528e-02f, -2.42947087e-01f, -3.05538327e-01f, 1.95735961e-01f,
  -2.96675980e-01f, -2.32461751e-01f, -1.25851676e-01f, 3.64968623e-03f, 1.38779044e-01f, -2.88197964e-01f, 6.20358065e-02f, 1.13778092e-01f, 3.99736315e-02f, 8.13395903e-03f,
  2.58025378e-01f, -1.47009879e-01f, 5.72663285e-02f, 2.04461396e-01f, 8.94570127e-02f, -4.56829108e-02f, -2.60509908e-01f, 1.10540845e-01f, -1.48296282e-01f, 8.43410790e-02f,
  -1.07598744e-01f, 2.28421450e-01f, 2.01941095e-02f, 2.14065462e-01f, 3.53681684e-01f, 2.23084450e-01f, -9.65201762e-03f, 3.02164316e-01f, 3.54275614e-01f, -3.11263084e-01f,
  -1.77572504e-01f, 9.43489745e-02f, -2.14200512e-01f, -5.27797192e-02f, -1.91399753e-01f, 5.48522845e-02f, 2.55889475e-01f, 1.63888052e-01f, 1.06756635e-01f, 1.91392973e-01f,
  4.95921336e-02f, 2.26681501e-01f, 1.97625816e-01f, 2.59001330e-02f, 1.05821364e-01f, 2.35599324e-01f, 2.39997327e-01f, 1.09162271e-01f, 1.52111322e-01f, -4.42455634e-02f,
  -4.33056839e-02f, 2.73442090e-01f, -1.12915367e-01f, -6.74428642e-02f, 1.63049981e-01f, 1.38038605e-01f, 1.82893902e-01f, 9.63736624e-02f, 3.87155376e-02f, -1.76697895e-01f,
  1.04077801e-01f, 1.00115471e-01f, 8.03608596e-02f, -8.50007012e-02f, -2.10305676e-01f, 6.26305416e-02f, -3.23044043e-03f, 2.05913126e-01f, 3.48476917e-01f, -9.50181559e-02f,
  -1.23954609e-01f, -2.67246783e-01f, -1.24302125e-02f, 3.36730093e-01f, 7.05071017e-02f, 7.30480999e-02f, 1.30730465e-01f, -3.51802930e-02f, 1.02951273e-01f, 2.03906730e-01f,
  -7.32894465e-02f, 7.74926171e-02f, -7.06769750e-02f, -1.97906420e-02f, -8.08078274e-02f, 3.01569521e-01f, 1.01886392e-01f, -2.81832423e-02f, 3.21559042e-01f, -1.21654317e-01f,
  -2.20543116e-01f, 3.08360487e-01f, 2.97329903e-01f, -4.94806617e-02f, -4.78840582e-02f, 3.10523212e-01f, 1.27466500e-01f, 2.43739095e-02f, -1.39741644e-01f, 1.84347808e-01f,
  1.65883750e-01f, 1.09598450e-01f, 2.68010318e-01f, -2.07833387e-02f, 1.80971265e-01f, 2.52074659e-01f, 1.50805980e-01f, 2.47094795e-01f, 2.90557951e-01f, 5.27928621e-02f,
  9.98624861e-02f, 2.88623601e-01f, -1.87010884e-01f, 1.31705925e-01f, -3.07029486e-01f, 3.34394217e-01f, -2.54418254e-01f, -1.45838678e-01f, 1.41416863e-01f, 2.48939693e-01f,
  1.55233279e-01f, -2.57552952e-01f, -6.99804500e-02f, -5.58777116e-02f, 3.38853210e-01f, 9.53244790e-02f, 1.00106575e-01f, 3.17552984e-02f, -1.61549523e-02f, 2.87140250e-01f,
  9.63561162e-02f, 3.10578972e-01f, 1.83213010e-01f, 3.09130043e-01f, 1.60363436e-01f, -2.66641796e-01f, -8.99520516e-02f, 2.42390111e-01f, 2.66350955e-01f, 2.77339041e-01f,
  1.99307799e-01f, 2.11931184e-01f, 1.19626895e-01f, 1.33216903e-01f, -9.00492445e-02f, 1.30601138e-01f, -2.06207950e-02f, -1.57248497e-01f, -3.32317464e-02f, 1.34474412e-01f,
  3.01982999e-01f, 1.26717435e-02f, 3.74453291e-02f, -2.04670355e-01f, 6.42509907e-02f, 2.23520502e-01f, 4.51129209e-03f, 2.75934696e-01f, -2.06783071e-01f, 7.23090693e-02f,
  2.98837245e-01f, 4.71309423e-02f, -5.41489087e-02f, 1.74345791e-01f, 4.08529788e-02f, -3.33138406e-02f, 5.25857415e-03f, 1.62751555e-01f, -3.20751332e-02f, -3.55019793e-02f,
  -1.93402439e-01f, -1.09374136e-01f, -9.41917226e-02f, 1.21827580e-01f, 7.56859779e-02f, 2.24992651e-02f, 2.74607055e-02f, 9.98102054e-02f, 3.02137017e-01f, -4.73792583e-01f,
  2.88950592e-01f, 3.72687489e-01f, -2.54228473e-01f, 1.23010743e-02f, -2.47368813e-02f, 3.11527848e-01f, 6.28549010e-02f, 1.05239926e-02f, -4.44390118e-01f, -7.66702890e-02f,
  -6.99902028e-02f, 2.28274971e-01f, 3.91207069e-01f, -2.22341821e-01f, -7.14933723e-02f, -2.35927984e-01f, 2.34339297e-01f, 7.43509904e-02f, 1.37779891e-01f, 1.64096996e-01f,
  2.01290160e-01f, -2.30881318e-01f, 1.80060174e-02f, 2.17499472e-02f, -7.49678612e-02f, -2.01750435e-02f, -1.50949344e-01f, -1.28873214e-01f, 1.30027726e-01f, -3.65075171e-02f,
  6.85075223e-02f, 1.01522289e-01f, 2.04598203e-01f, -5.19221164e-02f, -2.39724159e-01f, 3.48399803e-02f, 7.16268346e-02f, 3.40535969e-01f, 2.15695694e-01f, -1.03490613e-01f,
  9.01956186e-02f, -1.44975409e-01f, 1.74656674e-01f, -3.75987589e-01f, -1.59640402e-01f, -1.43261060e-01f, 1.89224765e-01f, 3.01792949e-01f, -3.28331999e-02f, 2.18122363e-01f,
  1.21149831e-01f, 2.57715464e-01f, 1.74222112e-01f, 4.84509505e-02f, 4.14075293e-02f, 5.27685471e-02f, 1.31921396e-01f, 2.20749155e-01f, -3.63215096e-02f, 1.94059536e-01f,
  2.83939205e-02f, -2.72541136e-01f, 2.94793189e-01f, 1.57301039e-01f, 3.23160216e-02f, -1.69932365e-01f, 1.56708226e-01f, -1.53190166e-01f, 1.51417181e-01f, -2.15369370e-02f,
  -1.76408052e-01f, -1.00206874e-01f, -9.44694504e-02f, -4.53961119e-02f, -1.54086864e-02f, 2.04331711e-01f, -2.14610040e-01f, 7.80679211e-02f, 1.15680764e-03f, 1.55996576e-01f,
  5.20894788e-02f, -1.49962604e-01f, 2.49069054e-02f, -8.49315673e-02f, 1.33183405e-01f, 2.26511255e-01f, 1.73876047e-01f, -1.12640604e-01f, 1.36882231e-01f, 1.63884815e-02f,
  -3.32592092e-02f, 2.20997348e-01f, -9.59432274e-02f, 2.37049222e-01f, 9.87701043e-02f, -7.71470666e-02f, -9.99467224e-02f, 1.51020095e-01f, -6.38687611e-02f, 2.62877226e-01f,
  3.46327871e-02f, -8.34891796e-02f, -2.58764774e-01f, 2.55308419e-01f, -2.31108144e-01f, 1.08477443e-01f, 3.00233811e-01f, -1.98204026e-01f, 1.16392396e-01f, 1.91649526e-01f,
  5.83404617e-04f, -2.00353563e-02f, 8.91868174e-02f, -2.45054835e-03f, 1.23445347e-01f, 1.24583513e-01f, -8.96351296e-04f, 1.22360252e-01f, 1.83824882e-01f, 7.25351050e-02f,
  1.73303246e-01f, 1.01065740e-01f, 2.70416379e-01f, 1.09463632e-02f, 9.31605250e-02f, 2.22070992e-01f, 8.59996527e-02f, -2.27273032e-01f, -2.65254881e-02f, -1.23929456e-01f,
  -2.84010060e-02f, 1.21878214e-01f, -3.61442417e-02f, 2.20634714e-01f, 2.71169573e-01f, 1.02989711e-01f, -2.47577280e-01f, -4.67844196e-02f, 6.75073937e-02f, -9.83584151e-02f,
  2.39375476e-02f, 1.78911626e-01f, 1.56034539e-02f, 1.21214554e-01f, 3.62285793e-01f, -1.33066505e-01f, -1.57122314e-01f, 1.04762852e-01f, -1.93775102e-01f, 1.63196579e-01f,
  1.40144959e-01f, -7.45399371e-02f, 3.09544951e-02f, -1.36732131e-01f, 1.33463264e-01f, -4.35304344e-02f, -1.35012403e-01f, 1.48498848e-01f, -2.29808256e-01f, 3.42329741e-01f,
  8.04498866e-02f, 1.88446030e-01f, 8.64718929e-02f, -1.43218353e-01f, 2.13212609e-01f, 1.71845555e-01f, -6.09837426e-03f, 2.97647100e-02f, 1.46118030e-01f, -2.80861825e-01f,
  2.50235766e-01f, 2.17846364e-01f, 1.97432414e-01f, -1.49186924e-01f, 3.60280722e-02f, 2.30889395e-01f, 2.24399921e-02f, 2.29078427e-01f, -1.67558901e-02f, 1.97257757e-01f,
  2.51305014e-01f, -3.36719714e-02f, -1.07712418e-01f, 2.81961977e-01f, 8.85978714e-02f, 1.12963691e-01f, 1.19553462e-01f, 2.15032011e-01f, 1.50158489e-02f, -1.27494439e-01f,
  3.11357141e-01f, -2.93038458e-01f, 2.78015673e-01f, 2.52894670e-01f, -1.05340064e-01f, -6.46360442e-02f, -3.15323062e-02f, -2.40672752e-02f, 1.96965143e-01f, -2.28468522e-01f,
  -5.28726019e-02f, -4.53910120e-02f, -9.83625278e-03f, 1.97497994e-01f, -8.10534880e-02f, 4.25391691e-03f, -8.07761699e-02f, 2.41427813e-02f, -5.98588958e-02f, 2.32004851e-01f,
  1.60708562e-01f, 5.47473244e-02f, 3.12290519e-01f, 1.90170273e-01f, -9.74237397e-02f, -1.68786440e-02f, -2.12701820e-02f, 1.81262895e-01f, -1.71706900e-01f, 1.46659017e-01f,
  2.94951890e-02f, -4.16039824e-02f, 2.33709618e-01f, 1.22274138e-01f, 8.27540606e-02f, -4.04058322e-02f, -1.78805217e-02f, 1.43870011e-01f, 2.31113266e-02f, 5.45945391e-02f,
  2.05146179e-01f, -9.19239298e-02f, -3.44078511e-01f, 1.77659631e-01f, 2.89299905e-01f, -3.49424273e-01f, 3.55624631e-02f, -5.59615605e-02f, -4.51312065e-02f, 7.33708367e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.55895129e-01f, 1.87398434e-01f, 2.82532156e-01f, 1.86357498e-01f, 2.20418617e-01f, 2.44567633e-01f, -2.38733809e-03f, 1.95411906e-01f, 2.09376197e-02f, 1.70857549e-01f,
  2.49591455e-01f, 1.69081375e-01f, 1.32598385e-01f, 9.84827727e-02f, 2.02904388e-01f, 1.31727129e-01f, 4.67729606e-02f, 2.52387255e-01f, -7.98980822e-04f, 8.58930871e-02f,
  2.33981580e-01f, 1.19081102e-01f, 6.82056770e-02f, 1.14867926e-01f, -8.70730262e-03f, 6.30007237e-02f, 4.14945111e-02f, 2.46219803e-02f, 1.55777708e-01f, 1.07933186e-01f,
  2.53227711e-01f, 2.14902595e-01f, 7.91426972e-02f, 2.53002971e-01f, 1.74275383e-01f, 1.31617591e-01f, 7.38188475e-02f, 7.55197629e-02f, 1.19038619e-01f, 1.60744250e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  9.08724144e-02f, -6.48708791e-02f, -7.00317472e-02f, -5.11030033e-02f, 9.12031531e-02f, 1.20784029e-01f, -1.55588414e-03f, 1.99164953e-02f, -8.11007619e-02f, -1.64689079e-01f,
  -8.32204968e-02f, 1.52328134e-01f, -1.88291848e-01f, 2.90025156e-02f, 1.83365911e-01f, 9.21245292e-02f, -2.55901623e-03f, 9.61363092e-02f, -1.02024965e-01f, -8.69162530e-02f,
  1.86123373e-03f, -1.16432324e-01f, 1.30156457e-01f, 5.86413220e-02f, 5.50659150e-02f, -5.30655757e-02f, 4.54557650e-02f, 4.25424837e-02f, -1.83430806e-01f, 7.20527116e-03f,
  4.84260246e-02f, -1.29428610e-01f, -4.10420597e-02f, 8.04704428e-02f, -1.50603950e-02f, 4.32159714e-02f, 3.95970494e-02f, 2.22992878e-02f, -5.31624444e-02f, 2.51388587e-02f,
  -8.56525302e-02f, 9.10921022e-03f, 3.05940434e-02f, -4.10974259e-03f, -1.16002835e-01f, 4.55960166e-03f, 1.24193698e-01f, -8.96944106e-02f, -1.53920263e-01f, 1.88473016e-02f,
  1.94413096e-01f, -4.92891483e-03f, 1.23656400e-01f, 4.62554358e-02f, 1.47642970e-01f, -1.92616448e-01f, 4.36255373e-02f, -1.13531925e-01f, 7.63998181e-03f, 1.29523516e-01f,
  5.14977165e-02f, -2.35283282e-02f, -1.32610276e-02f, 1.96237877e-01f, -8.03994760e-02f, -7.96567574e-02f, -4.98956186e-04f, 1.34477362e-01f, -3.55495885e-02f, 4.42100763e-02f,
  -3.24726775e-02f, 1.30960897e-01f, -8.23074579e-02f, 6.01476468e-02f, 1.15820728e-01f, -9.35246721e-02f, -1.84482187e-01f, -8.75732452e-02f, -1.01235747e-01f, 1.62523344e-01f,
  3.37864310e-02f, -5.11980876e-02f, 7.87013546e-02f, -1.55643478e-01f, 6.20197281e-02f, -1.33156747e-01f, 8.91732499e-02f, 1.23084933e-01f, -7.19321743e-02f, -1.13591880e-01f,
  -6.48187846e-02f, 1.96839310e-03f, -1.25531647e-02f, -6.16654381e-03f, 9.58699957e-02f, -1.41006529e-01f, 7.13027567e-02f, 3.56785022e-02f, 7.86702633e-02f, 6.35350123e-02f,
  -9.12367776e-02f, 1.25006586e-01f, 3.48574072e-02f, -3.12126838e-02f, -9.69025493e-02f, -9.53221321e-02f, -5.50814979e-02f, 1.04114868e-01f, 4.14824160e-03f, -1.69843942e-01f,
  -9.69560370e-02f, 1.68215092e-02f, -1.37399659e-01f, 8.83452296e-02f, -4.54908386e-02f, 1.30428582e-01f, -6.26151487e-02f, 2.44671162e-02f, 2.19556496e-01f, 6.43387483e-03f,
  5.07477447e-02f, 1.54110089e-01f, -2.91492585e-02f, 6.65872693e-02f, 1.60155613e-02f, 1.22182220e-01f, -1.76994964e-01f, 6.83349296e-02f, 7.37406760e-02f, 1.35505442e-02f,
  -1.30910158e-01f, -8.40431824e-02f, 1.32530063e-01f, 5.40242903e-02f, 5.00206240e-02f, 5.90094291e-02f, -2.47035455e-02f, 5.64013533e-02f, 4.35211770e-02f, 1.01276390e-01f,
  -7.05598667e-02f, 4.79846708e-02f, -2.59020329e-02f, 6.34627044e-02f, -6.22841232e-02f, -5.30627333e-02f, -1.01624995e-01f, -1.76232517e-01f, 2.17939354e-02f, -7.76946545e-02f,
  6.16288818e-02f, 2.64114924e-02f, -1.63762689e-01f, -7.18086679e-03f, -7.36551418e-04f, -3.50374803e-02f, -7.57174101e-03f, 5.68686761e-02f, 2.08398297e-01f, -8.16944093e-02f,
  7.31394514e-02f, -7.03074643e-03f, 1.40443459e-01f, 1.19212188e-01f, -1.21055178e-01f, 8.74337181e-02f, -1.21104792e-01f, -1.01807751e-01f, 1.97266825e-02f, -1.64139736e-02f,
  -2.77134068e-02f, 6.34017661e-02f, 1.39188275e-01f, -1.38193473e-01f, -2.55958527e-01f, -3.47624049e-02f, -1.92232206e-01f, 9.89782885e-02f, 1.25922980e-02f, -3.73415537e-02f,
  5.82040735e-02f, 1.57481059e-01f, 7.95693323e-02f, -4.67012310e-03f, -1.77188125e-02f, -9.08410475e-02f, 4.94762734e-02f, 4.09152322e-02f, -8.61168057e-02f, -2.31007084e-01f,
  5.07660918e-02f, -1.30555883e-01f, 8.41227919e-02f, -9.31730587e-03f, 2.12744847e-02f, -3.91763933e-02f, -7.86385685e-02f, -7.42863491e-02f, 9.78117213e-02f, -2.37504859e-02f,
  -1.29733771e-01f, 4.61251475e-02f, 2.58776341e-02f, -1.19109983e-02f, -5.44313006e-02f, -1.42554820e-01f, 1.58062771e-01f, -1.11083865e-01f, -1.05435677e-01f, 1.68358266e-01f,
  -2.17247531e-01f, -1.47183910e-01f, -3.48316506e-02f, 8.70278403e-02f, 1.29967686e-02f, -3.29893976e-02f, 4.33208095e-03f, -4.99495193e-02f, -5.66186532e-02f, 1.00737952e-01f,
  -5.66029847e-02f, 9.22097191e-02f, 1.95184588e-01f, 2.81996746e-02f, -1.08277821e-03f, -4.28305790e-02f, 1.46795297e-02f, 1.26309127e-01f, 1.87176034e-01f, -6.00421838e-02f,
  -8.51967633e-02f, 2.13458166e-01f, -1.19736403e-01f, -7.59747922e-02f, 2.08054446e-02f, -8.42358693e-02f, -1.61018237e-01f, 3.52258049e-02f, 1.99325293e-01f, 2.59026624e-02f,
  2.58559287e-02f, 1.65840447e-01f, 8.51396248e-02f, -1.65126115e-01f, -1.25393674e-01f, -1.74788788e-01f, 1.03265576e-01f, -1.75430715e-01f, 1.74194053e-01f, -6.72477670e-03f,
  -1.68187708e-01f, -1.54980749e-01f, 2.19055712e-02f, 1.32014513e-01f, -5.80226518e-02f, 2.29690358e-01f, -5.12101986e-02f, -7.45939836e-02f, 1.05090868e-02f, -1.47776246e-01f,
  -1.26147106e-01f, 8.22398588e-02f, -1.68149143e-01f, 5.58139794e-02f, 5.22891618e-02f, -1.54325858e-01f, -1.06423229e-01f, -1.72881007e-01f, -5.97094558e-02f, -1.40672654e-01f,
  8.89177173e-02f, -2.30199639e-02f, 1.23910092e-01f, 8.06802288e-02f, -1.52183518e-01f, 5.10570370e-02f, 6.03347868e-02f, 3.32296453e-02f, -1.32891193e-01f, 1.08481884e-01f,
  1.46945909e-01f, -8.70833918e-02f, 4.13725190e-02f, 2.20570602e-02f, -3.44980918e-02f, -7.76692256e-02f, -2.33831242e-01f, 4.42167334e-02f, 1.05940953e-01f, -1.46335453e-01f,
  9.79964528e-03f, 1.16151325e-01f, -1.03442639e-01f, 1.15946410e-02f, -4.31699753e-02f, 1.28986865e-01f, 6.81370795e-02f, -1.24633193e-01f, 6.92212135e-02f, 6.89738318e-02f,
  -1.09091180e-03f, -6.35325501e-04f, 5.64987399e-02f, -1.49690151e-01f, 1.96804553e-01f, -1.46368816e-01f, 1.05068013e-01f, 3.36830951e-02f, 6.60454631e-02f, 6.12521321e-02f,
  4.51058485e-02f, -1.24039464e-01f, 1.50123909e-01f, -1.18760079e-01f, -8.38349164e-02f, 2.87658311e-02f, 1.04414053e-01f, -8.00580829e-02f, -1.05036415e-01f, -2.00129207e-03f,
  -3.73720601e-02f, -5.91344684e-02f, 1.00004822e-01f, -3.26119699e-02f, 1.34235919e-01f, -1.26184464e-01f, -5.86557798e-02f, 6.97337762e-02f, -5.28183673e-03f, 1.35509670e-01f,
  6.31319284e-02f, -1.92400776e-02f, -1.26763672e-01f, 8.41533020e-02f, 1.77642956e-01f, 6.96327761e-02f, 1.50039151e-01f, -6.42121211e-02f, -9.32896435e-02f, -1.97015211e-01f,
  -2.47408450e-02f, -2.04127431e-02f, -9.41470116e-02f, -1.76334567e-02f, -5.88926710e-02f, -6.67444170e-02f, -1.91163346e-02f, 7.22905397e-02f, -9.99109745e-02f, 1.73137352e-01f,
  6.98759928e-02f, 1.12200361e-02f, -1.35867044e-01f, 5.95436320e-02f, 2.23267954e-02f, 2.34683491e-02f, 2.47213706e-01f, 5.41427955e-02f, -9.47108194e-02f, 1.57763120e-02f,
  -1.51610687e-01f, 5.57399839e-02f, 5.27310520e-02f, -1.35698989e-02f, 5.59289157e-02f, -1.32067636e-01f, 6.00753091e-02f, 9.04640704e-02f, -4.05065902e-02f, 9.09529626e-02f,
  -1.12241432e-01f, 2.70154253e-02f, 8.15589875e-02f, 9.62359980e-02f, -2.49955710e-02f, -7.42495572e-03f, 7.22104311e-02f, -1.86716422e-01f, -9.66084450e-02f, -1.05292663e-01f,
  4.44648117e-02f, -9.68652517e-02f, 4.01283018e-02f, 2.87019998e-01f, 8.82679746e-02f, 2.97442414e-02f, 3.05956081e-02f, -2.52174698e-02f, 7.24126101e-02f, 7.05284923e-02f,
  -1.35584518e-01f, 1.18788108e-01f, -2.92753130e-02f, 4.91779596e-02f, 3.84641737e-02f, -2.00088285e-02f, 1.75425380e-01f, -8.84093437e-03f, -1.19746752e-01f, 1.67364478e-01f,
  -1.00555532e-01f, 6.54851943e-02f, 1.69479460e-01f, 1.24914065e-01f, -1.37230292e-01f, -2.53386330e-02f, 6.92319870e-02f, 1.27289578e-01f, -1.63955502e-02f, 1.17517188e-01f,
  1.12461895e-01f, 9.86638516e-02f, 1.15756571e-01f, 1.75704900e-02f, -4.57856581e-02f, 7.70377666e-02f, -6.65503740e-02f, 8.33190158e-02f, -6.64124191e-02f, -4.29229215e-02f,
  -6.19690940e-02f, -3.66275981e-02f, -5.95805096e-03f, -1.59084603e-01f, -3.46305296e-02f, -2.05242783e-02f, -1.29311725e-01f, 5.19736595e-02f, 1.22467928e-01f, -1.12189390e-01f,
  -6.08613379e-02f, 1.16114117e-01f, 5.53073771e-02f, -9.69894789e-03f, -1.16256945e-01f, 1.42331958e-01f, 8.12193155e-02f, 7.62798265e-02f, 7.60535374e-02f, 1.01844333e-02f,
  -8.18983614e-02f, 9.37603638e-02f, -6.78581297e-02f, 1.47892103e-01f, -1.78552166e-01f, -2.18823969e-01f, 4.14851680e-02f, -2.22923800e-01f, 8.43195766e-02f, 2.14187205e-02f,
  -1.36440709e-01f, -1.02206796e-01f, 7.04545453e-02f, 8.17079246e-02f, -1.25895336e-01f, -1.48248225e-01f, -7.63911977e-02f, 6.66026324e-02f, 1.12885520e-01f, -1.10646978e-01f,
  -1.58596143e-01f, -1.81440078e-02f, 5.31810448e-02f, -6.58907965e-02f, -4.04351354e-02f, 8.04745555e-02f, 3.23920115e-03f, -8.96122232e-02f, 6.26286343e-02f, 7.41739990e-03f,
  -1.47520855e-01f, -1.08917288e-01f, -9.04562473e-02f, 1.43104922e-02f, -6.19445406e-02f, -1.07336447e-01f, 4.75877076e-02f, 2.61421055e-02f, 7.33860908e-03f, 2.02975255e-02f,
  -1.32468138e-02f, 9.61773843e-02f, 1.22871071e-01f, -7.27184340e-02f, 1.52922496e-01f, 3.82241271e-02f, 1.14647031e-01f, 7.75050819e-02f, -1.44249886e-01f, 6.03010366e-03f,
  -2.14714110e-02f, 3.67771946e-02f, -3.91139425e-02f, -1.07299626e-01f, -1.58293754e-01f, 9.72090438e-02f, -1.37546167e-01f, 9.98684987e-02f, 1.73264563e-01f, -3.92875895e-02f,
  4.84676026e-02f, 1.62801594e-01f, 1.06939390e-01f, 5.02393059e-02f, 1.23157457e-01f, -1.72941536e-01f, -2.27832720e-01f, -5.75299263e-02f, 7.41980448e-02f, -2.18302175e-01f,
  3.30342725e-02f, 1.19838163e-01f, 3.95686701e-02f, -3.51212136e-02f, 9.76871476e-02f, 7.48231411e-02f, -9.20472965e-02f, 1.40202999e-01f, 1.71541311e-02f, -2.24894807e-02f,
  -1.66198779e-02f, -7.23843277e-02f, -8.94638225e-02f, -1.46841571e-01f, 9.53008831e-02f, -3.26236673e-02f, 3.20945531e-02f, -2.47771397e-01f, 2.25124583e-02f, 1.19945249e-02f,
  2.35924590e-02f, 2.07348645e-01f, -2.16170568e-02f, -1.09437123e-01f, 1.26703843e-01f, -3.94836031e-02f, -1.61641568e-01f, -2.60626385e-03f, 1.23103142e-01f, -1.44319445e-01f,
  -8.14877227e-02f, -1.23666301e-01f, 1.38378114e-01f, -1.52440276e-02f, 1.42442107e-01f, 1.48643285e-01f, -9.04371887e-02f, 1.17038980e-01f, -2.23444760e-01f, 1.34905539e-02f,
  9.83011350e-02f, -7.33794644e-02f, 9.03241895e-03f, -1.40594523e-02f, -3.21487822e-02f, -3.10801179e-03f, -1.54589579e-01f, 1.43842116e-01f, -5.68779521e-02f, 7.42134005e-02f,
  1.71168849e-01f, -1.58226505e-01f, 3.32553796e-02f, -1.11175217e-02f, -3.84592898e-02f, 4.21732105e-02f, -9.74661671e-03f, -3.01671773e-02f, -1.03085101e-01f, 4.85826023e-02f,
  1.20808057e-01f, 1.64717957e-01f, 8.19145329e-03f, -1.54834324e-02f, 1.15192086e-01f, -2.53124535e-01f, 3.92989293e-02f, 7.82611296e-02f, -1.09413184e-01f, -6.29601479e-02f,
  -4.09810729e-02f, -9.23523605e-02f, 4.87066060e-02f, -1.31860942e-01f, -1.39350712e-01f, -1.22637615e-01f, -7.95706734e-02f, 7.26468861e-02f, 7.09412992e-02f, -1.26713917e-01f,
  -1.06398627e-01f, -1.67386577e-01f, 1.70102995e-02f, 1.38196215e-01f, 1.81987002e-01f, 1.29817158e-01f, -9.45295859e-03f, 1.51377633e-01f, -1.38460279e-01f, -1.59116741e-02f,
  -4.44293618e-02f, -1.11692287e-01f, -3.99146788e-02f, 6.04094081e-02f, -6.09531291e-02f, -1.79699957e-01f, -3.43496799e-02f, 1.12333901e-01f, 7.11277649e-02f, -6.98929885e-03f,
  -1.09510146e-01f, 2.10178476e-02f, 2.21334293e-01f, 3.89200523e-02f, 1.39753118e-01f, 1.66721210e-01f, 1.72821537e-01f, -1.34456437e-02f, -1.11199431e-01f, -3.60533432e-03f,
  -4.72453237e-02f, 1.50734887e-01f, 1.14162289e-01f, -1.75303414e-01f, -2.27005370e-02f, -1.53191596e-01f, -4.47725272e-03f, 6.20395551e-03f, -7.68926442e-02f, -2.34694332e-02f,
  -6.41982481e-02f, -1.22770391e-01f, -5.82704470e-02f, -1.39286578e-01f, -3.27488594e-02f, -4.80202213e-02f, 7.16229901e-02f, 1.94749489e-01f, 2.71159336e-02f, 1.43209308e-01f,
  -1.82921529e-01f, -8.65977928e-02f, -9.57471356e-02f, -2.94606388e-02f, -5.90415439e-03f, 1.91991609e-02f, 1.03665113e-01f, -3.76175791e-02f, -3.75191681e-02f, -7.41785318e-02f,
  -1.27820104e-01f, 9.03654471e-02f, -5.20036817e-02f, -9.93956849e-02f, 2.25896552e-01f, -1.02778710e-01f, -6.15248717e-02f, 1.41095176e-01f, 5.44784069e-02f, -4.72853566e-03f,
  2.04718947e-01f, 1.34657055e-01f, -1.36710316e-01f, 1.59195829e-02f, -1.44186467e-01f, -1.49893641e-01f, 5.27371280e-03f, -6.21566102e-02f, -8.91077667e-02f, 9.51983617e-04f,
  1.93804547e-01f, 6.18353263e-02f, -1.44889027e-01f, -1.25006393e-01f, -7.11803660e-02f, 1.59464866e-01f, 1.53862685e-01f, 1.50716081e-01f, 3.32067311e-02f, 1.15579560e-01f,
  6.30903617e-02f, -3.31104174e-02f, -1.14524841e-01f, -1.15824744e-01f, -7.85677284e-02f, 9.36018750e-02f, 8.89344700e-03f, 3.22668403e-02f, 5.08687943e-02f, -8.24794769e-02f,
  -5.66461794e-02f, -1.05828866e-01f, -3.65804210e-02f, 1.11026272e-01f, -7.15787113e-02f, 2.08565537e-02f, -6.19758852e-02f, -5.20548485e-02f, -8.64510164e-02f, -1.46969050e-01f,
  5.53600974e-02f, -7.37938955e-02f, 1.13746233e-03f, 1.56917423e-01f, -1.43887838e-02f, -1.00315753e-02f, 1.68217838e-01f, 1.49965823e-01f, -2.72686817e-02f, -2.05169246e-02f,
  1.60954565e-01f, -7.94711486e-02f, 7.92752132e-02f, -1.71111658e-01f, 1.58551857e-02f, 9.51445997e-02f, -6.58232048e-02f, 1.88906461e-01f, 7.43441358e-02f, -2.09635794e-01f,
  -2.43879706e-01f, 5.35928831e-02f, 7.34102055e-02f, 1.60538003e-01f, -5.94000518e-02f, -2.52975106e-01f, 2.08203904e-02f, -1.38400033e-01f, -1.23480029e-01f, -1.09368436e-01f,
  8.06478858e-02f, -1.69890355e-02f, 1.39996737e-01f, -1.67038649e-01f, -1.02892881e-02f, -1.06793866e-02f, -2.61292327e-02f, 6.97926879e-02f, 2.22909942e-01f, 8.23529735e-02f,
  -1.51690543e-01f, -1.31946713e-01f, 5.43915369e-02f, -1.20409066e-02f, 3.04668713e-02f, 1.04430869e-01f, 6.79843798e-02f, -1.11343890e-01f, -2.21678708e-02f, 1.33613333e-01f,
  -1.23350874e-01f, -7.06589594e-02f, 5.07042035e-02f, 8.92835930e-02f, -1.48263335e-01f, -1.85384423e-01f, -8.57492313e-02f, -1.80955268e-02f, 1.26290604e-01f, 9.29478463e-03f,
  2.50093509e-02f, -1.17448363e-02f, 8.87974799e-02f, 1.98245347e-02f, 4.93125096e-02f, -3.54361683e-02f, 2.49247283e-01f, -7.42667615e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.89605474e-02f, 4.56818268e-02f, 4.49500931e-03f, 1.30942082e-02f, 1.10568017e-01f, 1.74137816e-01f, 1.52086169e-01f, 7.43563250e-02f, -1.81594454e-02f, -2.06958037e-02f,
  -5.49827479e-02f, 1.65292323e-01f, 1.63474783e-01f, -2.78513581e-01f, 1.87754199e-01f, -1.58963740e-01f, 1.77243307e-01f, 1.83681712e-01f, 2.63722003e-01f, -6.99370801e-02f,
  3.17275852e-01f, 1.34070024e-01f, -3.13620836e-01f, 2.50909448e-01f, -7.11209886e-03f, 6.63813651e-02f, 1.49109751e-01f, 7.79394433e-02f, 2.14079753e-01f, 2.02066004e-02f,
  2.90766448e-01f, 1.96482301e-01f, 6.04981333e-02f, -1.94246992e-02f, -8.15820228e-03f, 6.45209774e-02f, 3.19795519e-01f, 1.71029344e-01f, 1.15930729e-01f, 2.10223407e-01f,
  7.71661773e-02f, 1.55285355e-02f, -3.01336706e-01f, -3.93640310e-01f, 5.01762629e-02f, 4.10715938e-02f, -1.12350293e-01f, 3.95860165e-01f, -1.00188009e-01f, 1.83745191e-01f,
  -1.39751196e-01f, -8.24571028e-02f, -7.44205564e-02f, -5.69350198e-02f, -8.70319828e-02f, 2.31860533e-01f, -1.24166191e-01f, -2.77782112e-01f, -1.76425278e-01f, 1.39009297e-01f,
  -1.83752477e-01f, 1.09388217e-01f, -1.03848539e-01f, 1.27668843e-01f, -2.40517799e-02f, -5.20241149e-02f, -7.31779933e-02f, 3.68054956e-02f, 5.95599934e-02f, 3.89643982e-02f,
  2.04124991e-02f, 1.84038997e-01f, 1.22798398e-01f, 2.16956481e-01f, 2.63353705e-01f, 1.45983800e-01f, 3.64936143e-02f, -3.23802590e-01f, -1.17867641e-01f, 5.37771955e-02f,
  2.41769195e-01f, 1.24993160e-01f, 7.70449489e-02f, 2.64471501e-01f, 1.32035956e-01f, 1.65863156e-01f, -1.25286922e-01f, 1.96193218e-01f, 8.97409692e-02f, 1.64011329e-01f,
  1.61374867e-01f, 1.53305650e-01f, -2.98206449e-01f, -1.20778643e-01f, 3.90332192e-02f, 4.04278412e-02f, 3.62463534e-01f, -2.08559275e-01f, 1.27926871e-01f, 2.82179683e-01f,
  7.63329118e-03f, 2.54115820e-01f, -1.33916855e-01f, 9.83765200e-02f, 1.10179707e-01f, 1.79516360e-01f, -1.95237592e-01f, 8.89928564e-02f, 6.87747225e-02f, 1.32539064e-01f,
  2.48772711e-01f, -1.52891442e-01f, 2.15968177e-01f, -1.09133743e-01f, 6.18957058e-02f, 3.84155303e-01f, 2.02501297e-01f, 1.75341293e-01f, -5.44846170e-02f, -2.49661431e-01f,
  -1.69164851e-01f, 3.88273150e-01f, 2.66876787e-01f, 9.22824070e-02f, -3.05008799e-01f, 2.42585361e-01f, -1.84821486e-01f, 3.20322186e-01f, 2.27158666e-02f, 1.78606555e-01f,
  -4.63294350e-02f, 1.80619374e-01f, 3.34824473e-02f, 6.01440035e-02f, 1.41047716e-01f, 1.03074238e-01f, 1.75298229e-01f, 7.36440793e-02f, -4.85947989e-02f, 2.51120217e-02f,
  -1.20284639e-01f, 8.48387927e-02f, 1.04768947e-01f, -5.92033304e-02f, -2.37093166e-01f, -1.28934562e-01f, -3.23381186e-01f, -1.84634238e-01f, -3.38693708e-01f, -4.51576300e-02f,
  2.70586967e-01f, -1.27109960e-01f, 2.20118552e-01f, 6.17186390e-02f, -1.44156739e-01f, -2.23628253e-01f, -1.75132118e-02f, -1.47833833e-02f, 1.07290603e-01f, -2.92438149e-01f,
  -4.93717901e-02f, 3.91005039e-01f, -1.41823879e-02f, 1.11054689e-01f, -2.10870460e-01f, 2.39887852e-02f, -2.11142644e-01f, 2.30207354e-01f, 1.37558997e-01f, -2.10844368e-01f,
  3.32304657e-01f, 1.10206075e-01f, 2.35369384e-01f, -1.34301949e-02f, 1.27147868e-01f, -1.91493571e-01f, 1.15268836e-02f, 3.42454659e-05f, 2.38112211e-01f, -1.35718629e-01f,
  1.96984529e-01f, 1.21842183e-01f, 3.45051855e-01f, 3.23565662e-01f, -2.26621963e-02f, -2.04570115e-01f, -4.49377596e-02f, 2.80211419e-01f, -2.38276217e-02f, -1.62814870e-01f,
  2.47949928e-01f, 1.91932321e-01f, 1.77776471e-01f, 4.82690707e-02f, 1.80258483e-01f, 2.94101867e-03f, 9.63806883e-02f, -4.54562753e-02f, 1.47264987e-01f, 1.37081802e-01f,
  1.07990630e-01f, 1.45768583e-01f, 1.37043417e-01f, 2.30773434e-01f, -2.19674081e-01f, 2.92715169e-02f, -3.29543613e-02f, 1.11413330e-01f, -3.14687192e-01f, -1.18949391e-01f,
  -1.03361934e-01f, -1.32964000e-01f, -2.07389578e-01f, -2.20809922e-01f, 3.67145403e-03f, -1.21822506e-01f, -1.46453746e-03f, -6.79395348e-02f, -2.85350494e-02f, 8.32644403e-02f,
  7.27082416e-02f, 1.07179396e-01f, 3.82381946e-01f, 1.60947964e-01f, -2.70370990e-01f, 1.50235459e-01f, 1.42535761e-01f, 1.25269189e-01f, 1.82815805e-01f, 1.61668569e-01f,
  -4.96700071e-02f, -5.99665046e-02f, -2.48021975e-01f, 5.92901222e-02f, -1.15046650e-02f, 5.36233559e-02f, 1.28265098e-01f, -1.91168205e-04f, -9.22395959e-02f, 2.39650682e-01f,
  -3.72054279e-01f, 6.25633970e-02f, -2.26691216e-02f, -3.19479220e-02f, 2.39765905e-02f, 2.35049799e-01f, 2.53825724e-01f, 4.00859416e-01f, 1.84904322e-01f, -8.21142364e-03f,
  5.64511083e-02f, 1.11752674e-02f, -2.37838812e-02f, -2.67439514e-01f, 1.80484921e-01f, 1.32049233e-01f, 1.37254506e-01f, -4.68814038e-02f, 5.57929054e-02f, -4.11343090e-02f,
  1.93225950e-01f, 1.06979482e-01f, 7.96839520e-02f, 2.23421037e-01f, 8.46326277e-02f, 5.61990589e-02f, 1.46466494e-01f, 2.02790588e-01f, -4.19362932e-02f, -2.23648280e-01f,
  -3.72866914e-02f, 1.58038571e-01f, 1.34011492e-01f, -2.51155972e-01f, 2.55404562e-01f, -1.25322312e-01f, 1.14212595e-01f, 1.06051065e-01f, -1.94364950e-01f, -9.93874669e-02f,
  1.77731410e-01f, 2.36763522e-01f, 6.51650503e-02f, 3.53728056e-01f, 3.30661163e-02f, 2.99018711e-01f, 4.85041961e-02f, -4.68506943e-03f, 1.37927458e-01f, -3.27889860e-01f,
  3.89382057e-02f, 1.90639287e-01f, 1.55850098e-01f, 2.20043644e-01f, -9.54316109e-02f, -1.16225444e-02f, 6.50078654e-02f, 1.53541774e-01f, -4.52381596e-02f, -1.14849009e-01f,
  2.87142366e-01f, -3.30590978e-02f, 1.65004209e-01f, 2.30384991e-01f, -2.28903577e-01f, 1.88505694e-01f, -1.50832027e-01f, 1.78764522e-01f, 2.70554543e-01f, -5.08762263e-02f,
  -2.04113290e-01f, 3.56626213e-01f, -1.95208527e-02f, 1.14099532e-01f, -2.54218608e-01f, 1.19095452e-01f, -9.94305089e-02f, 2.63438374e-01f, -1.33547634e-01f, 5.21254614e-02f,
  2.56550699e-01f, -8.33781995e-03f, -1.11151021e-02f, -1.04482003e-01f, 6.95340708e-02f, -5.10830618e-02f, 3.52745578e-02f, 2.27618024e-01f, 1.94571108e-01f, 3.39179635e-01f,
  4.97011170e-02f, 1.91254660e-01f, -1.49646532e-02f, 1.03526870e-02f, -8.58976245e-02f, 2.48808116e-01f, -1.56813506e-02f, -2.53826022e-01f, 1.36853397e-01f, -6.35734573e-02f,
  -1.77621484e-01f, -1.71783224e-01f, 1.46874800e-01f, -2.69140340e-02f, -3.57208438e-02f, -2.65961997e-02f, -7.88189843e-02f, 1.30485654e-01f, 2.39209399e-01f, 1.59175888e-01f,
  2.49003060e-02f, -1.81864172e-01f, -1.44742597e-02f, 1.79772586e-01f, 6.69627637e-02f, -1.63219348e-01f, -2.91144699e-01f, 1.20735161e-01f, -8.59221965e-02f, -1.57484755e-01f,
  1.18319746e-02f, -2.75315177e-02f, -1.25870422e-01f, 3.28101516e-01f, 2.94449061e-01f, -6.17160015e-02f, 2.03245223e-01f, -3.39747071e-02f, -3.04237437e-02f, -1.72855444e-02f,
  3.18873189e-02f, 2.80257523e-01f, 1.98376969e-01f, 4.24640030e-01f, 9.96360406e-02f, 2.53045738e-01f, -5.59095629e-02f, 3.32621515e-01f, -2.52761343e-03f, 6.82615414e-02f,
  -3.43334258e-01f, -4.48272191e-02f, -4.28776219e-02f, -8.33357275e-02f, 1.13807425e-01f, 1.39395565e-01f, 2.56492384e-02f, 2.16401190e-01f, 9.00019426e-04f, -1.13210334e-02f,
  -5.19654639e-02f, 1.20906383e-02f, 1.39931679e-01f, -1.45613447e-01f, 3.07491701e-02f, -2.47931220e-02f, -6.41823262e-02f, 4.42908883e-01f, -3.80116776e-02f, -1.49849832e-01f,
  -1.82103425e-01f, -2.71452606e-01f, -1.29357159e-01f, 1.96758211e-01f, -1.40710965e-01f, -2.25953564e-01f, 3.50489795e-01f, -2.74347663e-01f, 1.23147026e-01f, 2.13727385e-01f,
  -5.47457300e-02f, 4.71973047e-02f, 1.39599949e-01f, -2.50313580e-02f, -8.88240337e-02f, -2.33965591e-01f, -1.30393635e-02f, 2.41934165e-01f, 4.35815193e-02f, -2.66111374e-01f,
  -3.00466508e-01f, -6.14489727e-02f, -7.56115913e-02f, -6.27573133e-02f, -2.43390277e-02f, 1.80905983e-02f, 2.93870062e-01f, 2.80467510e-01f, 1.84469059e-01f, 2.81951278e-02f,
  2.30867580e-01f, -2.19518155e-01f, 8.33781734e-02f, 9.48134810e-02f, 2.44038835e-01f, 6.53579608e-02f, 9.06514898e-02f, -1.47069678e-01f, 3.37643325e-01f, 1.37012273e-01f,
  8.91579911e-02f, -3.07873189e-02f, 2.80807734e-01f, 7.53078535e-02f, 1.36349082e-01f, 7.32966047e-03f, 2.44678646e-01f, -9.53691900e-02f, 7.97225684e-02f, 1.82043999e-01f,
  1.41487896e-01f, -2.31771320e-02f, 4.91506280e-03f, 6.34742454e-02f, 4.37173918e-02f, -1.56672336e-02f, 8.65921229e-02f, 5.32961451e-02f, 1.26347065e-01f, -2.35233009e-02f,
  1.77852988e-01f, 9.70812235e-03f, -1.25857502e-01f, 9.12363380e-02f, 8.40059146e-02f, 1.12670071e-01f, 1.04977459e-01f, 4.57836777e-01f, 2.55723037e-02f, 9.49909613e-02f,
  7.00940266e-02f, 3.19160745e-02f, 2.52480768e-02f, 3.00635010e-01f, 1.87769786e-01f, 1.32181257e-01f, 1.05295464e-01f, -1.79593116e-01f, -2.23095238e-01f, 2.00503767e-01f,
  2.11710036e-01f, 1.38044611e-01f, -8.05974975e-02f, -2.12232042e-02f, -3.82331014e-01f, -3.56880738e-03f, 2.66372651e-01f, -2.19593555e-01f, 1.71950862e-01f, 3.36329639e-01f,
  1.59201786e-01f, 3.15150470e-01f, -1.07745759e-01f, 1.63753405e-01f, 2.77330786e-01f, -6.59622028e-02f, 3.19911420e-01f, -1.09300405e-01f, 2.25571953e-02f, 2.55547285e-01f,
  2.03669712e-01f, 2.62405515e-01f, 1.74758941e-01f, -3.08983386e-01f, -8.61586481e-02f, 3.77936363e-01f, 3.63624036e-01f, 2.91297972e-01f, -3.63827527e-01f, 1.49185553e-01f,
  3.43447849e-02f, -1.35063007e-01f, 1.27072364e-01f, 1.18209263e-02f, 5.99257611e-02f, 5.16427867e-02f, -1.23054162e-01f, 6.60381233e-03f, 7.94272348e-02f, -7.29267001e-02f,
  6.64428324e-02f, 3.75730135e-02f, -1.15881693e-02f, 9.65016261e-02f, 7.13380426e-02f, -1.02450706e-01f, 2.38381013e-01f, 1.27009138e-01f, 9.89876911e-02f, 3.02968044e-02f,
  -1.06950905e-02f, 2.12429762e-01f, 9.73515809e-02f, 7.58472979e-02f, -1.94944859e-01f, 9.84892622e-02f, 5.13534658e-02f, 1.75680339e-01f, -9.94681381e-03f, -1.05782554e-01f,
  -1.22033216e-01f, 2.13524476e-01f, -1.80400401e-01f, 1.37977116e-02f, 1.24070778e-01f, -3.49002510e-01f, 2.07920581e-01f, 1.88832164e-01f, -1.55353054e-01f, 9.32059512e-02f,
  -5.69641292e-02f, 2.95796663e-01f, 1.85092852e-01f, 1.86767764e-02f, -6.78765103e-02f, 7.94508085e-02f, 3.45574208e-02f, 1.67129323e-01f, 2.88081288e-01f, 7.88346678e-02f,
  2.82226861e-01f, -1.00556739e-01f, 1.87136129e-01f, 2.99105555e-01f, 4.37262058e-02f, -4.35869843e-02f, -1.81725591e-01f, -1.22735292e-01f, 2.69019932e-01f, 1.82334006e-01f,
  -6.97034672e-02f, -9.51568633e-02f, -1.48156686e-02f, 1.95805997e-01f, -3.05218194e-02f, 1.95265174e-01f, -1.58121571e-01f, 1.24170691e-01f, 6.25991970e-02f, 1.10236391e-01f,
  -8.80877003e-02f, 6.38175234e-02f, -5.59053086e-02f, 7.02102780e-02f, -3.80120985e-02f, -5.28784096e-03f, 8.02480057e-02f, -1.81427211e-01f, -1.35248825e-02f, 3.14858586e-01f,
  1.93389878e-01f, -2.17304945e-01f, -8.10213834e-02f, 2.57591605e-01f, 1.51092559e-01f, 8.19295347e-02f, 1.93549544e-02f, -1.07312359e-01f, -5.38438419e-03f, 7.75462836e-02f,
  -1.87531486e-01f, -1.33819148e-01f, -7.61237368e-02f, -4.46344167e-01f, 3.51210177e-01f, -1.07789777e-01f, -6.02726713e-02f, 4.83830227e-03f, -1.29779324e-01f, 3.48472774e-01f,
  1.69285387e-01f, -2.12508857e-01f, 7.52405152e-02f, -8.61822441e-02f, 2.02173740e-01f, 2.99297333e-01f, 1.12402812e-01f, -1.85321391e-01f, 1.59734547e-01f, 2.17253596e-01f,
  -3.33398394e-02f, 1.99318938e-02f, 1.78690016e-01f, -1.15867658e-02f, 1.80502579e-01f, -3.04885861e-02f, 4.44494337e-02f, -1.43436700e-01f, -4.03156400e-01f, -1.17606819e-01f,
  3.36546928e-01f, -2.00337321e-02f, 6.15734607e-02f, -3.58704589e-02f, 2.91637152e-01f, -9.39734802e-02f, 9.94832516e-02f, 1.34991974e-01f, 3.44334751e-01f, 1.20927341e-01f,
  8.73562992e-02f, -7.37080770e-03f, -8.57080668e-02f, 1.67925656e-01f, 1.25839099e-01f, 1.71319231e-01f, -1.82495732e-02f, -8.89268368e-02f, -3.86180468e-02f, -1.16121456e-01f,
  1.06181435e-01f, 6.63900981e-04f, -7.37606809e-02f, -4.90030311e-02f, 2.17478201e-01f, -1.18420288e-01f, 1.28272966e-01f, 8.08655471e-02f, -2.83987850e-01f, -1.86958417e-01f,
  6.39628805e-03f, 4.78560738e-02f, 2.32966810e-01f, -1.44136980e-01f, 2.66497374e-01f, 1.63475141e-01f, 7.99159557e-02f, -1.01888441e-01f, -1.98391303e-01f, -2.83655822e-02f,
  4.75233234e-02f, -1.77153394e-01f, 2.90947706e-01f, 7.52698332e-02f, 7.65261576e-02f, 2.56866217e-01f, -1.11794539e-01f, 2.90148675e-01f, -3.06723207e-01f, 3.20031971e-01f,
  1.52130783e-01f, -1.09930128e-01f, 2.18038693e-01f, 8.15074965e-02f, 6.74269274e-02f, 3.36984932e-01f, 1.61340684e-01f, -3.65506597e-02f, 2.14022338e-01f, 1.84372347e-03f,
  2.97025025e-01f, 6.40490949e-02f, 1.44913211e-01f, -9.60142240e-02f, 1.34744927e-01f, 2.34188259e-01f, 2.10008338e-01f, -4.37565744e-02f, -4.85950522e-02f, 1.98510021e-01f,
  6.15707710e-02f, 1.83613658e-01f, -9.04778466e-02f, 1.88872993e-01f, 6.31282330e-02f, -5.86689338e-02f, 8.43901485e-02f, 1.08807772e-01f, 2.06560805e-01f, 1.52829275e-01f,
  4.29238491e-02f, -5.91748543e-02f, 1.23274140e-01f, 1.40470341e-01f, 3.43841799e-02f, 1.74368545e-01f, -3.19781780e-01f, -6.98056072e-02f, 2.45674357e-01f, -1.43992558e-01f,
  2.15389580e-02f, 2.27989018e-01f, -3.13651532e-01f, -3.78123462e-01f, 8.31789002e-02f, -8.75534415e-02f, 1.09104097e-01f, 1.03377372e-01f, 9.57622975e-02f, -2.17792735e-01f,
  -1.03982702e-01f, -1.56363174e-01f, 6.39785156e-02f, 1.16069317e-01f, 2.97928929e-01f, 5.79638407e-02f, -1.92036375e-01f, 4.11220878e-01f, 1.30270064e-01f, 1.58503294e-01f,
  2.50425249e-01f, 2.51887739e-01f, 4.51451316e-02f, 2.90950924e-01f, -1.84596553e-01f, -1.72527745e-01f, 2.33485047e-02f, 1.35368437e-01f, 8.43427517e-03f, -1.67576551e-01f,
  -6.31405190e-02f, 2.09397301e-01f, -3.47266525e-01f, 2.05501884e-01f, 1.41666159e-01f, -2.31583580e-01f, 1.51682347e-01f, 2.23411873e-01f, 1.93808839e-01f, 3.99620444e-01f,
  3.03350240e-01f, 3.63766290e-02f, -8.85317028e-02f, 1.20881468e-01f, 7.31038153e-02f, -6.70945421e-02f, 1.15601055e-01f, 2.13288426e-01f, 1.85589701e-01f, 4.21777181e-02f,
  -5.47734695e-03f, 1.64545953e-01f, 7.40624070e-02f, 2.34943673e-01f, 1.15516201e-01f, 2.06490591e-01f, 1.15259774e-02f, 1.41206846e-01f, 3.66330729e-03f, 8.72426480e-02f,
  -2.74874121e-01f, -1.84435159e-01f, -5.36588533e-03f, 2.54649445e-02f, -1.08545110e-01f, -3.91253754e-02f, -1.15860336e-01f, -2.40706086e-01f, 1.97163634e-02f, -2.56225079e-01f,
  -1.76761314e-01f, -1.39083304e-02f, -1.99366257e-01f, -1.45765841e-01f, -5.53248636e-02f, -7.96194375e-02f, -1.70188397e-01f, 2.45484654e-02f, 4.01625246e-01f, 4.91080135e-02f,
  7.20378682e-02f, 5.17550260e-02f, 2.27505520e-01f, 3.44179392e-01f, 1.44161239e-01f, 2.13672876e-01f, -9.02393982e-02f, 6.12528203e-03f, -1.00651197e-02f, -2.41726153e-02f,
  -2.53254864e-02f, -1.28598849e-03f, 2.20578864e-01f, 1.19812168e-01f, -2.68912524e-01f, 1.31639361e-01f, -4.39105630e-01f, 1.47061229e-01f, -5.02320528e-02f, 1.23784216e-02f,
  -5.35948277e-02f, 4.22832608e-01f, 1.77143559e-01f, 2.62580633e-01f, -1.18121631e-01f, 1.00921728e-01f, 2.76675910e-01f, 2.15117529e-01f, -2.67288208e-01f, -2.29384769e-02f,
  1.59389511e-01f, 5.51382042e-02f, 1.75824553e-01f, 3.53813320e-02f, -9.05285180e-02f, -1.13585785e-01f, 2.51812756e-01f, 6.34789169e-02f, -3.44267264e-02f, 1.63124636e-01f,
  1.82435900e-01f, 2.62610734e-01f, 1.68277457e-01f, 1.58824086e-01f, -1.39678672e-01f, 1.81407519e-02f, -2.17106547e-02f, 1.58013046e-01f, -1.36205599e-01f, 1.19827881e-01f,
  -2.10330486e-02f, 1.46607142e-02f, 2.15473007e-02f, -2.11709604e-01f, -2.56180704e-01f, 6.64618835e-02f, 1.16866700e-01f, -9.96608511e-02f, -1.10764876e-01f, -8.80629346e-02f,
  -8.66361633e-02f, 3.11697662e-01f, 7.35382587e-02f, -2.94580031e-02f, -6.58489391e-02f, 2.39518229e-02f, 2.24748209e-01f, 2.27898106e-01f, 1.30301431e-01f, 5.86414477e-03f,
  5.43007292e-02f, 1.89773068e-02f, -1.41579166e-01f, 1.24262750e-01f, -1.13181770e-01f, 2.37277433e-01f, 2.70330876e-01f, -1.12207100e-01f, 5.81655391e-02f, -1.11355409e-02f,
  -2.61166453e-01f, 2.52971739e-01f, 8.05944502e-02f, 4.02041584e-01f, 7.09964111e-02f, 3.22693467e-01f, 4.07857783e-02f, -1.07347697e-01f, 3.65503758e-01f, 3.45916569e-01f,
  9.98430885e-03f, -1.43517256e-01f, 2.55730115e-02f, 1.26377359e-01f, 3.33471954e-01f, 3.48673195e-01f, -5.19962981e-03f, -4.06209528e-02f, 1.12984955e-01f, 8.17933008e-02f,
  -9.48588029e-02f, 1.38133973e-01f, 1.42050430e-01f, 5.14389165e-02f, 8.23926367e-03f, -1.53287366e-01f, -7.67883137e-02f, -5.04778549e-02f, 2.53354907e-01f, -7.94775635e-02f,
  -2.64585521e-02f, -2.84804046e-01f, 2.03426018e-01f, 1.44926578e-01f, 6.71072081e-02f, 1.29667953e-01f, 2.14022532e-01f, 2.87268341e-01f, -1.43335938e-01f, 6.20978624e-02f,
  -1.10150799e-01f, 1.02442391e-01f, 2.17859194e-01f, 1.21050045e-01f, 5.18641286e-02f, -6.85311034e-02f, 8.94153342e-02f, 3.25160652e-01f, 1.57794565e-01f, 1.27539605e-01f,
  -1.90035343e-01f, 4.88734469e-02f, 1.28642917e-01f, -5.40394969e-02f, 3.15637022e-01f, 2.90260553e-01f, 5.35099469e-02f, 1.78742707e-01f, -2.73347676e-01f, -2.10225329e-01f,
  -3.66450287e-02f, 1.37547210e-01f, -1.33925967e-03f, 1.05343997e-01f, 4.94061969e-02f, -9.50629935e-02f, -1.88575864e-01f, -3.11821818e-01f, 1.20364629e-01f, -2.24954978e-01f,
  -8.08269456e-02f, 1.95187241e-01f, -2.83237129e-01f, -1.69011459e-01f, 2.46521346e-02f, 7.94889126e-03f, -1.63470134e-01f, 2.06812266e-02f, -1.67615801e-01f, -5.80048561e-02f,
  1.46010384e-01f, 1.93971838e-03f, -8.92012045e-02f, 1.34272993e-01f, 2.45953590e-01f, 5.24655636e-03f, 1.76866770e-01f, 9.35078040e-02f, 1.80189937e-01f, 2.35861242e-01f,
  1.01929016e-01f, 1.31587520e-01f, -6.44963756e-02f, 4.72682454e-02f, -3.77626233e-02f, 2.81622887e-01f, 2.49965325e-01f, 1.38247132e-01f, 2.20372915e-01f, -7.81461895e-02f,
  2.63651639e-01f, 1.00715213e-01f, -1.38219357e-01f, 1.38096839e-01f, 1.94785759e-01f, 1.15455195e-01f, 1.95251599e-01f, 3.28436136e-01f, -1.43553197e-01f, 2.71095842e-01f,
  -7.46339411e-02f, 1.09879307e-01f, 5.41019067e-02f, -9.07874852e-02f, 3.09632212e-01f, 2.52557397e-01f, 1.92600489e-01f, -6.40154630e-02f, 1.04352273e-01f, 7.20690787e-02f,
  -1.75084651e-01f, 3.10700357e-01f, -4.57856944e-03f, 2.02686891e-01f, 4.68825214e-02f, -6.90414086e-02f, 8.15834180e-02f, 2.43880033e-01f, -5.40888906e-02f, 3.33154202e-01f,
  -8.15522224e-02f, 3.80363464e-01f, 9.61737260e-02f, 1.05442844e-01f, -1.24687050e-03f, 1.45909833e-02f, 3.68261039e-01f, 3.61602157e-01f, -5.05823046e-02f, -2.15746328e-01f,
  3.20877880e-01f, 2.28207275e-01f, 1.09366007e-01f, 3.83343101e-01f, -3.81415673e-02f, 3.12666744e-02f, -1.23539753e-01f, 1.82848066e-01f, -3.20376530e-02f, 9.31509212e-02f,
  -4.51141335e-02f, 4.52670977e-02f, -1.47967115e-01f, -1.05155744e-01f, -1.02071561e-01f, 4.94417995e-02f, -1.82441384e-01f, -1.07338011e-01f, 1.47998989e-01f, 1.56633958e-01f,
  8.97284523e-02f, 1.01503931e-01f, -1.49104357e-01f, -1.06966928e-01f, 1.62300348e-01f, 8.44298005e-02f, 3.65205221e-02f, -3.67419608e-02f, 9.00929794e-02f, -1.10340128e-02f,
  3.44680287e-02f, 1.49796441e-01f, 1.15010776e-01f, 3.59645694e-01f, -1.39703676e-01f, 9.32212472e-02f, -5.26821502e-02f, -3.73153836e-02f, 2.31407911e-01f, 1.31208733e-01f,
  1.15478091e-01f, 2.83687413e-02f, -3.25976796e-02f, 1.52539670e-01f, -1.36931255e-01f, 9.59767774e-02f, 1.60024211e-01f, 2.74901658e-01f, 3.60914133e-02f, -1.02479883e-01f,
  4.87132929e-02f, -5.59721924e-02f, -4.66080680e-02f, 1.38412908e-01f, -1.07855992e-02f, 2.23126128e-01f, -1.77623536e-02f, -1.03667453e-01f, 4.04272228e-02f, -1.69705436e-01f,
  2.03732282e-01f, 1.11417264e-01f, -2.26849750e-01f, -3.17232311e-01f, 4.70061660e-01f, 1.72455341e-01f, 1.12141846e-02f, 1.90473780e-01f, -8.93018488e-03f, 1.87970251e-01f,
  1.70415178e-01f, 5.61243407e-02f, 5.69549426e-02f, -1.18944325e-01f, -2.41677985e-02f, -3.80712487e-02f, 5.62529340e-02f, -1.08118139e-01f, -7.00775012e-02f, 3.75453755e-02f,
  2.75718629e-01f, 3.31401005e-02f, -3.64774582e-03f, -1.07838094e-01f, 1.21589586e-01f, -1.99791342e-01f, 1.43388540e-01f, 2.40746066e-01f, 6.05437271e-02f, 1.44770831e-01f,
  -1.69605792e-01f, 1.79924786e-01f, 2.53895640e-01f, 2.23746717e-01f, 2.98554629e-01f, 2.89430529e-01f, 3.54570955e-01f, -2.57151406e-02f, -1.72601447e-01f, 2.13123411e-01f,
  1.25731170e-01f, -1.46235034e-01f, -1.69262305e-01f, -2.74155051e-01f, -1.24319665e-01f, 2.74233259e-02f, 6.54698908e-02f, 1.22966491e-01f, 3.46484542e-01f, 2.84725994e-01f,
  -1.76145285e-01f, -8.76626670e-02f, 8.33309069e-02f, 1.05355062e-01f, 2.53087312e-01f, 2.43343472e-01f, 3.61701757e-01f, 4.59256135e-02f, 2.36709595e-01f, 3.42958085e-02f,
  3.06261420e-01f, 1.02958351e-01f, -3.86438258e-02f, 1.25432506e-01f, -2.05376402e-01f, -1.44260317e-01f, -1.03927590e-01f, 2.36194164e-01f, -1.64718866e-01f, -4.16678973e-02f,
  -2.96246588e-01f, -7.98986927e-02f, -1.26375044e-02f, 8.61581415e-03f, 1.58500686e-01f, 1.06585905e-01f, 5.91212213e-02f, 7.54259666e-03f, 2.34418027e-02f, -4.39185612e-02f,
  -4.55748737e-02f, -8.63016956e-03f, -1.89453755e-02f, -1.66028425e-01f, 1.65665969e-01f, -7.60434493e-02f, 1.25107989e-01f, -2.43576527e-01f, 9.89701897e-02f, 1.36354029e-01f,
  1.59955829e-01f, 2.00725913e-01f, 1.10579394e-01f, 2.13365719e-01f, -2.41219535e-01f, 7.03666806e-02f, 8.78798366e-02f, -9.85498205e-02f, 4.59065065e-02f, -1.04173450e-02f,
  1.61963135e-01f, -2.08227560e-01f, 4.97702090e-03f, 1.54518396e-01f, -5.35490289e-02f, 1.60849214e-01f, -2.13245094e-01f, 9.84720071e-04f, 1.17834993e-02f, -1.61436852e-02f,
  2.09629685e-01f, 1.04924373e-01f, 2.92489082e-01f, 8.02966207e-02f, -3.11544508e-01f, -2.30496630e-01f, -1.96681246e-01f, 1.31215826e-01f, 1.69473186e-01f, 2.43103817e-01f,
  2.33228534e-01f, -7.53512308e-02f, 9.51000378e-02f, -2.24665418e-01f, -1.10641912e-01f, -2.66842879e-02f, -1.21914148e-01f, 1.38234347e-01f, -3.41421664e-02f, -1.95547298e-01f,
  2.22428534e-02f, -7.06970394e-02f, 1.00382045e-02f, 1.14492394e-01f, -6.06408380e-02f, -6.07792614e-03f, -3.59197054e-03f, 6.38760906e-03f, 6.88080341e-02f, 1.84995830e-01f,
  1.10022174e-02f, 2.31731996e-01f, 1.68295860e-01f, 4.54626940e-02f, 3.08118667e-02f, -1.17296502e-01f, -8.18830580e-02f, 1.53317740e-02f, -1.97943613e-01f, 3.10579743e-02f,
  -6.20153733e-02f, -1.66575104e-01f, -3.09634298e-01f, 2.12275814e-02f, -6.88824654e-02f, -2.19356820e-01f, 1.39919549e-01f, -1.93343908e-01f, 1.12916455e-01f, -5.46921827e-02f,
  -5.22042699e-02f, -8.95108655e-02f, -1.06064305e-01f, -5.19840121e-02f, -7.41735026e-02f, 5.56993522e-02f, 1.88825533e-01f, 2.02432901e-01f, -1.10877290e-01f, 2.28204727e-01f,
  8.00180882e-02f, 1.13934822e-01f, 2.48332754e-01f, -8.31935778e-02f, 2.50569582e-01f, 1.64809346e-01f, -1.00939400e-01f, -1.46117434e-01f, 2.79386908e-01f, 8.09116364e-02f,
  -5.69255687e-02f, -9.43519324e-02f, -3.99472788e-02f, -6.31064828e-03f, -1.43635362e-01f, 6.22439496e-02f, -2.73112599e-02f, -1.43704399e-01f, -1.60315752e-01f, -2.32156459e-02f,
  2.45516822e-01f, 1.02435872e-01f, 3.97658534e-02f, 1.50559783e-01f, 2.26156220e-01f, 6.20465875e-02f, 2.09226996e-01f, 7.21214786e-02f, 1.61152288e-01f, 1.45291924e-01f,
  -7.64603913e-02f, 2.32482348e-02f, 2.80297808e-02f, 1.44682806e-02f, 1.40176162e-01f, -4.02336195e-02f, -4.02938128e-02f, 1.47153884e-01f, 1.26743987e-01f, 9.40131322e-02f,
  -1.19083710e-01f, 5.24607487e-03f, -7.76307238e-03f, -9.01565924e-02f, 2.98008442e-01f, 1.37140840e-01f, -7.57430792e-02f, 1.39826342e-01f, -7.89530799e-02f, -1.40366599e-01f,
  1.90918073e-02f, 4.99730855e-02f, -3.22014660e-01f, -8.61461684e-02f, 1.68135315e-01f, -7.75816217e-02f, -8.35398510e-02f, 2.21466467e-01f, 2.06640869e-01f, 3.07160825e-01f,
  6.27000555e-02f, 1.79932415e-01f, -3.67449105e-01f, -4.11163270e-02f, 3.31676126e-01f, 9.27041173e-02f, 1.56320378e-01f, -1.62572965e-01f, -9.05767158e-02f, 1.69293165e-01f,
  -3.65374953e-01f, 9.34243668e-03f, 5.29346876e-02f, -1.21425048e-01f, 1.57220334e-01f, -7.57059082e-02f, -1.09290257e-01f, 1.45860881e-01f, -1.79543963e-03f, 3.82391065e-01f,
  -5.74448667e-02f, 1.02377139e-01f, 1.09359927e-01f, 8.33076164e-02f, -8.59861355e-03f, 7.07342997e-02f, 4.33229864e-01f, -7.66816065e-02f, -4.24487442e-01f, -4.18388635e-01f,
  5.86292386e-01f, -1.60218358e-01f, 2.38903552e-01f, 2.44308650e-01f, 9.22630951e-02f, 8.47794488e-02f, -4.19625118e-02f, -4.76237312e-02f, 2.08873287e-01f, 1.45846859e-01f,
  2.60738377e-02f, 1.82553664e-01f, 9.97540131e-02f, 2.31180638e-01f, 1.28870040e-01f, 1.64567754e-01f, 4.49532317e-03f, 2.09129527e-02f, -2.46693432e-01f, 4.67101075e-02f,
  -4.92178537e-02f, 1.11103348e-01f, 2.49240085e-01f, 1.08156458e-01f, 1.64093629e-01f, -1.80749103e-01f, -1.28439948e-01f, 4.96504270e-02f, 6.51558638e-02f, 4.56646271e-02f,
  1.81095794e-01f, 1.94789007e-01f, 1.80381387e-01f, 2.74134070e-01f, -1.44519657e-01f, 7.13994801e-02f, -1.85353726e-01f, 2.00348645e-02f, 3.43036354e-01f, 6.28439011e-03f,
  -3.99581157e-02f, -3.06788385e-01f, 2.23192364e-01f, -1.39892280e-01f, -6.71537593e-02f, 1.90532491e-01f, 6.39623925e-02f, 2.18274131e-01f, -1.51706524e-02f, -2.49480292e-01f,
  -1.53172061e-01f, 1.58026621e-01f, 2.75473762e-02f, 3.60065997e-01f, -1.80838723e-03f, 2.98356235e-01f, -1.74484834e-01f, 3.94151330e-01f, 1.21104881e-01f, -1.85447142e-01f,
  2.45968059e-01f, 3.42832208e-01f, 6.97308704e-02f, 4.01567072e-02f, -7.62887374e-02f, -1.09170124e-01f, 2.40752429e-01f, -1.03555143e-01f, 2.57740989e-02f, 1.15750335e-01f,
  9.07063708e-02f, -5.05226851e-02f, -1.75562911e-02f, 2.93105710e-02f, 7.72749074e-03f, 1.55225068e-01f, -1.57412942e-02f, 2.14320764e-01f, 8.63792375e-02f, -1.04757912e-01f,
  -1.05314583e-01f, 2.36847907e-01f, -2.69037485e-01f, 4.14939076e-02f, 8.02024081e-02f, -1.30339980e-01f, 1.32872283e-01f, 6.90966990e-05f, -1.60863668e-01f, -8.19383413e-02f,
  2.64531732e-01f, -2.01169550e-02f, 9.22131464e-02f, 1.29343808e-01f, -2.98924502e-02f, -1.19836874e-01f, 1.66660026e-01f, -1.26948625e-01f, 2.02519223e-01f, 1.01497527e-02f,
  -1.22368917e-01f, 2.89712965e-01f, 7.38655478e-02f, -2.23662212e-01f, -1.65325105e-02f, 3.16385962e-02f, 1.71335623e-01f, 1.63596421e-01f, 1.70277189e-02f, -1.72589421e-01f,
  2.81452119e-01f, 4.96649593e-01f, 8.15654099e-02f, -8.26493427e-02f, 4.31477651e-02f, -3.32605392e-01f, -1.27856463e-01f, -9.13409814e-02f, 7.17831403e-02f, 9.29246992e-02f,
  -2.07611881e-02f, 1.26197711e-01f, 4.08869147e-01f, 2.14149967e-01f, -5.45378658e-04f, 2.41857126e-01f, 4.62647736e-01f, 3.03813398e-01f, -1.21642351e-01f, 2.72466093e-01f,
  7.17170015e-02f, 2.26471480e-02f, 7.57326484e-02f, -7.24621564e-02f, 5.68175353e-02f, 1.95902437e-01f, 1.34265246e-02f, 1.10805459e-01f, 1.46515563e-01f, 1.14904046e-01f,
  -5.93062118e-03f, -9.06427428e-02f, 7.83492811e-03f, 7.43778199e-02f, -1.16201676e-01f, -1.98782206e-01f, -1.24021411e-01f, -1.07513234e-01f, -5.81855550e-02f, 1.81825757e-01f,
  1.42876357e-01f, 1.13873936e-01f, 2.96129972e-01f, 2.73622163e-02f, -1.90931544e-01f, 1.21055149e-01f, -1.10718563e-01f, -1.46681294e-01f, 2.21213102e-01f, -7.03269616e-02f,
  1.88907921e-01f, -1.64070174e-01f, 2.33433887e-01f, 2.72271365e-01f, 3.73854078e-02f, 2.14746490e-01f, 8.40303525e-02f, 1.22017898e-01f, 2.77098924e-01f, -5.68883233e-02f,
  2.35095188e-01f, 8.50603729e-02f, 1.32849261e-01f, -2.77657360e-02f, -1.96992084e-01f, -5.75843863e-02f, 3.29915658e-02f, 6.39239838e-03f, -1.33239523e-01f, 2.46944446e-02f,
  5.25409654e-02f, 1.14590086e-01f, -1.35217324e-01f, -1.85606927e-01f, 2.32263878e-02f, 8.61610994e-02f, 1.59811303e-01f, 4.07776497e-02f, -2.52208501e-01f, 1.25451013e-01f,
  2.20220119e-01f, 2.08359078e-01f, -2.13326484e-01f, 7.87259936e-02f, 1.87450752e-01f, 6.49420032e-03f, -1.23447120e-01f, 1.39449120e-01f, 1.89407505e-02f, 1.60576373e-01f,
  1.31523758e-01f, 5.33840619e-02f, -9.15641859e-02f, 6.35315990e-03f, -4.04379852e-02f, 1.73971623e-01f, 3.12038790e-02f, -7.42961168e-02f, 1.63140714e-01f, -2.48666853e-01f,
  -5.25115468e-02f, -4.27831598e-02f, 2.07760841e-01f, 2.02608705e-01f, 8.39650109e-02f, -9.49229822e-02f, 1.45447865e-01f, 1.32578894e-01f, -2.05259517e-01f, 3.03943723e-01f,
  -2.16108024e-01f, -1.12639949e-01f, 1.62548140e-01f, 1.69846892e-01f, 1.62254989e-01f, 1.36327068e-03f, 1.29165784e-01f, 3.34436923e-01f, -1.28381938e-01f, 1.49455100e-01f,
  -3.39339934e-02f, 5.79626895e-02f, 2.61189997e-01f, -3.56417638e-03f, 3.51479203e-01f, 1.57779723e-01f, 1.94877952e-01f, -6.03075176e-02f, -2.93769151e-01f, 4.42693420e-02f,
  -2.48597056e-01f, -2.80830190e-02f, 1.72707215e-02f, 1.11840367e-01f, 1.66017249e-01f, -1.24188466e-02f, -1.52837813e-01f, -1.64054349e-01f, 4.88321297e-02f, -3.52238417e-02f,
  8.31637904e-02f, 7.62071386e-02f, -2.75287688e-01f, 4.87987213e-02f, 1.77249551e-01f, 3.91905904e-02f, 8.59502852e-02f, -1.13962060e-02f, -1.68584548e-02f, 5.50816096e-02f,
  1.52754858e-01f, 5.77256037e-03f, -4.35192995e-02f, 6.15874231e-02f, 1.33048013e-01f, 8.44692066e-02f, 9.77266803e-02f, 9.90602821e-02f, -5.45136034e-02f, -3.13266031e-02f,
  3.14409770e-02f, 2.14969531e-01f, 4.89700288e-02f, -2.93709934e-01f, 6.40712753e-02f, -6.27724528e-02f, 2.68710911e-01f, 1.00354530e-01f, 2.58212090e-02f, 8.09118450e-02f,
  1.17066242e-01f, 2.89368391e-01f, -6.69423416e-02f, 1.77582517e-01f, 2.26931781e-01f, 2.00273827e-01f, 1.04442164e-01f, 1.23332992e-01f, -2.90816784e-01f, -1.34228632e-01f,
  1.25356033e-01f, -1.98753048e-02f, 3.21160525e-01f, -2.81024963e-01f, -1.81014035e-02f, 2.00113297e-01f, 1.75823808e-01f, 3.56355608e-01f, -1.94931015e-01f, 1.79244876e-01f,
  2.97811240e-01f, 1.48752466e-01f, -5.79316504e-02f, 1.20830685e-01f, 2.25012094e-01f, 1.29502058e-01f, 1.29200265e-01f, -1.86497837e-01f, 2.60055006e-01f, -2.20207140e-01f,
  1.91680416e-01f, 1.06159464e-01f, 2.09236920e-01f, 9.42197368e-02f, -8.72219428e-02f, 1.50082573e-01f, -1.73785463e-01f, 3.00828591e-02f, -1.42739881e-02f, 2.59137720e-01f,
  -2.93933809e-01f, 1.04458213e-01f, -3.02925676e-01f, 3.39724213e-01f, 1.49216428e-01f, 1.37070447e-01f, 1.82773143e-01f, 1.74000636e-02f, 5.88486381e-02f, 3.88678648e-02f,
  -6.76517785e-02f, 1.08046673e-01f, -2.59833056e-02f, 2.18127012e-01f, -7.98178390e-02f, -9.97605249e-02f, 2.34923109e-01f, 1.77981988e-01f, -1.53108060e-01f, 1.27802819e-01f,
  1.83858737e-01f, -9.65617076e-02f, 2.25997880e-01f, 1.34394720e-01f, 1.13982439e-01f, 6.81755692e-02f, -8.74847621e-02f, 3.45524326e-02f, 2.69475020e-02f, 1.16409875e-01f,
  2.48300195e-01f, 2.13247955e-01f, 4.13677871e-01f, 2.01915607e-01f, -2.54884034e-01f, 7.88499340e-02f, -3.13965604e-02f, -1.72845438e-01f, -4.61735912e-02f, -1.87934056e-01f,
  4.31881398e-02f, -3.27588677e-01f, 2.85548031e-01f, 7.89141469e-03f, 9.71591398e-02f, 2.09349215e-01f, -1.58451684e-02f, 1.18214786e-01f, -3.60070653e-02f, -4.98924591e-02f,
  1.24819554e-01f, 3.35470110e-01f, 2.32212260e-01f, 2.77472377e-01f, -3.19844753e-01f, 6.58454373e-02f, -1.22664794e-01f, 1.54149875e-01f, -2.49704346e-01f, 4.54983599e-02f,
  -5.03390767e-02f, 2.16926143e-01f, 5.02845924e-03f, -1.06577672e-01f, -5.63699082e-02f, -1.00035220e-01f, 1.31615967e-01f, -3.26487236e-02f, 1.17103241e-01f, -2.60979123e-03f,
  -9.34181809e-02f, -6.09367378e-02f, -8.63232010e-04f, 7.99962226e-03f, -3.05450652e-02f, -3.98767181e-02f, -7.64570013e-02f, 1.40215769e-01f, -3.59039344e-02f, -5.10990294e-03f,
  -1.48533136e-01f, -1.15729779e-01f, 3.26540560e-01f, 3.30202758e-01f, 1.16120242e-01f, -1.60859842e-02f, -2.27091745e-01f, -1.41302779e-01f, -1.47093892e-01f, 1.69586644e-01f,
  -7.35225677e-02f, 2.47023217e-02f, 2.91643679e-01f, -9.65997800e-02f, 1.41956910e-01f, 1.61863174e-02f, -5.28394133e-02f, 7.87355453e-02f, -1.31264567e-01f, -2.03897581e-02f,
  3.38946804e-02f, -7.56512806e-02f, 2.70907450e-02f, 1.99910775e-01f, 3.29447277e-02f, 2.82789081e-01f, -3.68386619e-02f, 1.37852326e-01f, -9.50927660e-03f, -2.45317202e-02f,
  -4.49789315e-02f, 2.23612636e-02f, -4.43595462e-03f, -1.03538178e-01f, -3.71786915e-02f, 2.22844765e-01f, -1.85058594e-01f, 1.28623724e-01f, 3.82716179e-01f, 4.36569564e-02f,
  2.04500049e-01f, 2.97212273e-01f, 1.17403835e-01f, -2.15748698e-02f, 2.14817345e-01f, 1.03840142e-01f, -1.99177995e-01f, 1.22169048e-01f, 9.83807072e-02f, -1.94963172e-01f,
  -3.41757059e-01f, 7.98965394e-02f, 5.07530347e-02f, 1.68606743e-01f, 1.02785692e-01f, 4.86411192e-02f, 1.33663148e-01f, 1.84350740e-02f, 1.94884138e-03f, 8.69744867e-02f,
  5.52126914e-02f, 1.76246390e-02f, 1.18157543e-01f, 1.59744486e-01f, -3.07550818e-01f, -1.68404534e-01f, 3.71975541e-01f, 2.22792223e-01f, 1.97614387e-01f, -7.25620613e-02f,
  -3.43111902e-01f, -1.47911206e-01f, -1.84017226e-01f, 1.07991911e-01f, -1.05278485e-01f, 3.88698578e-02f, 2.85602868e-01f, -7.61389136e-02f, 1.17367417e-01f, -3.84554639e-02f,
  -3.15945178e-01f, 2.34711990e-01f, -3.69771309e-02f, -3.54783326e-01f, 2.60314066e-02f, 1.01260468e-01f, 2.27778167e-01f, 2.84029573e-01f, -1.18627235e-01f, 3.30029249e-01f,
  -3.02893937e-01f, 1.34009287e-01f, -5.51014505e-02f, -1.36076540e-01f, 7.11945165e-03f, 1.05105519e-01f, 9.43027586e-02f, -1.48404902e-02f, 1.98564325e-02f, -2.34649703e-02f,
  -9.34330672e-02f, 1.14035144e-01f, 4.23415184e-01f, 1.10538602e-01f, 2.88352787e-01f, 1.69625759e-01f, 4.31325100e-02f, -2.68249918e-04f, 2.48367473e-01f, 3.01644560e-02f,
  -3.14750493e-01f, -5.65055804e-03f, 5.73898889e-02f, -2.43855000e-01f, -9.73037630e-02f, 1.38194278e-01f, -1.41444474e-01f, -8.64769369e-02f, 1.31733999e-01f, 6.45228401e-02f,
  6.80473968e-02f, 6.17413840e-04f, 1.11790143e-01f, -4.28540446e-02f, 2.40661134e-03f, -3.25649112e-01f, 1.24138653e-01f, 5.73448045e-03f, 9.19904187e-02f, -1.20342700e-02f,
  4.23545688e-02f, -3.85773063e-01f, -1.61305621e-01f, -2.19844319e-02f, 6.41553998e-02f, 2.04429850e-02f, 3.41440625e-02f, 1.71788380e-01f, -6.97775185e-02f, -1.96631208e-01f,
  1.47029892e-01f, 1.00212865e-01f, 9.95834619e-02f, 1.27200574e-01f, -3.66921350e-02f, -1.94998816e-01f, 3.55125576e-01f, 1.90355435e-01f, 1.12724468e-01f, -7.27829933e-02f,
  1.25138119e-01f, -9.11010616e-03f, 1.35817736e-01f, 2.63556361e-01f, 1.32553473e-01f, 2.28428945e-01f, 1.34443700e-01f, -2.59302021e-03f, 1.46507308e-01f, -2.01498106e-01f,
  1.42446682e-01f, 3.07895511e-01f, -3.18731815e-02f, 2.90510673e-02f, 1.03054829e-01f, -2.21163183e-02f, 1.32385597e-01f, -2.92490989e-01f, -7.16673136e-02f, -4.33753371e-01f,
  1.95505083e-01f, 2.43616790e-01f, -3.75872962e-02f, -2.57636547e-01f, 1.45595565e-01f, 1.92454800e-01f, 1.40408173e-01f, 1.66199937e-01f, -9.40267183e-03f, 5.48967458e-02f,
  -6.72154650e-02f, 9.30188224e-02f, 5.09536406e-03f, 2.33541001e-02f, -5.49242832e-02f, 8.29880238e-02f, -1.50321936e-03f, -7.60174403e-03f, -4.19548992e-03f, 2.92540163e-01f,
  5.18428832e-02f, -9.65529904e-02f, 1.37944430e-01f, -4.14505079e-02f, -2.36862808e-01f, -2.07228959e-02f, 4.29213196e-02f, 2.56445974e-01f, 1.16211221e-01f, 2.69521713e-01f,
  2.20441401e-01f, 4.87800054e-02f, -1.85809538e-01f, 3.73170921e-03f, -4.28276770e-02f, 1.13174826e-01f, 1.92258153e-02f, -1.34188965e-01f, 2.40866587e-01f, -1.70401067e-01f,
  1.58031672e-01f, 1.94408432e-01f, -1.09555395e-02f, 1.06829561e-01f, 2.74300367e-01f, 3.23410630e-01f, -5.61744049e-02f, -1.46922141e-01f, 1.17225312e-01f, -9.11242291e-02f,
  2.79068798e-01f, 1.63248274e-02f, 4.57183495e-02f, 1.35838285e-01f, 3.67923416e-02f, 4.18493571e-03f, -1.35480314e-01f, 1.16080478e-01f, 7.93316141e-02f, -9.77811366e-02f,
  -2.32180893e-01f, 4.42194045e-02f, -2.42717087e-01f, 1.05057232e-01f, 2.07046375e-01f, -2.67095625e-01f, 2.46307328e-02f, 4.06406969e-01f, 3.34434837e-01f, 1.78028017e-01f,
  -1.82036027e-01f, 1.09085418e-01f, 3.55523407e-01f, -2.82374695e-02f, 2.48166267e-02f, 1.83988616e-01f, 1.57324597e-01f, -4.90699410e-02f, -3.74622159e-02f, 1.82848983e-02f,
  -7.77125806e-02f, 8.44097063e-02f, 9.42597017e-02f, -1.48204863e-01f, 3.59777398e-02f, 4.53798100e-02f, -1.00668900e-01f, 1.28024220e-01f, 1.94413327e-02f, -5.69934994e-02f,
  -2.24773094e-01f, 1.81617677e-01f, -2.40306724e-02f, 4.93983813e-02f, 1.34660080e-01f, -2.42663592e-01f, 8.05891305e-02f, -7.59099573e-02f, 5.06900297e-03f, -6.68170974e-02f,
  2.90380847e-02f, -3.65167260e-02f, 3.37299198e-01f, 1.41350226e-02f, -1.24097548e-01f, 1.76831827e-01f, -4.04246956e-01f, 1.91159397e-01f, 2.44282350e-01f, 1.74192525e-02f,
  -3.16627100e-02f, -2.94493794e-01f, 3.46679866e-01f, 8.15337300e-02f, -2.48358712e-01f, 2.09780276e-01f, -3.09431273e-02f, 1.27514079e-01f, -6.40298799e-02f, -3.94839458e-02f,
  -1.93915084e-01f, 5.94480969e-02f, 2.02432945e-02f, 3.59720647e-01f, -1.40095621e-01f, 3.87233007e-03f, -1.70457304e-01f, 3.76625831e-04f, 5.80391772e-02f, -1.71170980e-01f,
  3.11912388e-01f, 2.98804045e-01f, 5.83890937e-02f, -2.35713227e-03f, 3.64734709e-01f, -1.26978800e-01f, 2.78831571e-01f, -6.17064489e-03f, 1.38840333e-01f, 4.81463820e-02f,
  1.48889393e-01f, 9.99849290e-02f, 3.92413512e-02f, 1.06365770e-01f, 3.15997303e-02f, 6.67097345e-02f, 8.96954834e-02f, 1.61487326e-01f, 1.99299783e-01f, 1.20219752e-01f,
  4.23502587e-02f, 1.33166313e-01f, -3.17448348e-01f, 1.45463839e-01f, 1.52703956e-01f, -1.82988822e-01f, 2.30003074e-01f, -8.72276723e-02f, -1.36011630e-01f, -7.58929998e-02f,
  4.06054966e-03f, 8.11063647e-02f, 8.33665803e-02f, 4.55133505e-02f, 1.55799687e-01f, 2.38346964e-01f, 3.30355942e-01f, 3.35828215e-01f, -9.24004391e-02f, 2.09443793e-01f,
  -1.47476465e-01f, 8.21378753e-02f, -1.28597334e-01f, -2.17895299e-01f, -9.95161459e-02f, -3.57500948e-02f, 2.25196809e-01f, -2.66462058e-01f, 6.07812963e-03f, 1.34891301e-01f,
  -1.03123449e-01f, 2.90989839e-02f, 1.58687264e-01f, -2.85095572e-01f, -6.20483160e-02f, 2.44732872e-01f, -1.79802701e-01f, 2.90667057e-01f, -8.73670727e-02f, 1.76948175e-01f,
  5.84138148e-02f, 3.76781583e-01f, 4.77900095e-02f, 1.43510267e-01f, 1.66012589e-02f, 3.70499253e-01f, -8.39114860e-02f, 1.44594550e-01f, -1.15993887e-01f, -5.70732839e-02f,
  -8.29942673e-02f, -1.10046506e-01f, 1.01114541e-01f, 1.19679131e-01f, 8.69680271e-02f, -1.16861798e-02f, 1.44025851e-02f, 9.92966518e-02f, 1.16756655e-01f, 6.09621741e-02f,
  1.55857485e-02f, 1.43188179e-01f, 5.59340231e-03f, 6.22833334e-02f, -2.17946023e-01f, -2.37029921e-02f, 1.62094447e-03f, 4.34682593e-02f, -8.93556476e-02f, -1.02988929e-02f,
  1.33282006e-01f, -9.70834568e-02f, 8.32358282e-03f, -2.78313726e-01f, 6.49874955e-02f, 1.13711640e-01f, 9.43928957e-02f, 1.51576385e-01f, -5.20068109e-02f, 1.29745930e-01f,
  -2.37074375e-01f, 1.62315816e-01f, 1.29538953e-01f, 6.76259547e-02f, -4.20382917e-02f, 7.18810186e-02f, 9.67767462e-02f, 2.52220660e-01f, 1.46875381e-01f, 1.00940458e-01f,
  -6.59318864e-02f, -1.80860519e-01f, -8.89537577e-03f, 1.50528446e-01f, -1.06211789e-01f, 1.25286669e-01f, 3.44282746e-01f, -1.94571109e-03f, 8.92636105e-02f, -8.30782056e-02f,
  -2.23346531e-01f, 8.05457532e-02f, -3.97976711e-02f, 2.34112099e-01f, 1.04621157e-01f, 2.68486828e-01f, 2.09756747e-01f, 2.67611027e-01f, -1.46824062e-01f, 1.39464632e-01f,
  2.99122691e-01f, 2.10754439e-01f, -3.28136772e-01f, 1.92882627e-01f, 7.72439763e-02f, 1.45217916e-03f, 1.34168550e-01f, -7.20170736e-02f, 1.50553528e-02f, 4.34826501e-02f,
  -5.75116277e-02f, 6.61007762e-02f, 4.95515913e-02f, 7.28634968e-02f, 1.33794054e-01f, -1.79125696e-01f, -4.18166257e-02f, 1.34862199e-01f, -1.64479509e-01f, 2.98070699e-01f,
  3.69069353e-02f, 1.55098401e-02f, -2.04756647e-01f, 2.57379174e-01f, -2.41531938e-01f, -2.37614140e-01f, -7.89219961e-02f, -2.38162473e-01f, 2.33440474e-01f, -3.43337059e-02f,
  1.82997346e-01f, -1.75317049e-01f, -1.74372733e-01f, -1.91525310e-01f, -5.32772904e-03f, 7.41381422e-02f, -9.48024318e-02f, -2.28563398e-01f, -3.16167921e-01f, 2.96689808e-01f,
  1.30355880e-01f, 3.73276286e-02f, -2.22073615e-01f, 5.20811602e-02f, 1.26973882e-01f, 1.41227081e-01f, -2.36431912e-01f, -8.61834437e-02f, 2.01563343e-01f, 3.65565985e-01f,
  7.02801496e-02f, -3.07210594e-01f, 2.13477574e-03f, -1.41657323e-01f, -1.38659745e-01f, 1.20705992e-01f, 2.09096313e-01f, -1.08265817e-01f, -3.06669604e-02f, 7.49790482e-03f,
  3.29685390e-01f, 3.08372565e-02f, 1.04875974e-01f, 2.83888787e-01f, 2.42717281e-01f, 7.23761097e-02f, 1.69533283e-01f, -1.15390509e-01f, 5.55220246e-02f, 2.40590423e-01f,
  1.25811517e-01f, 3.54564674e-02f, -8.62058774e-02f, 7.49524385e-02f, 9.51605141e-02f, -3.10613122e-02f, 1.13120444e-01f, 6.00996427e-02f, 7.07677752e-02f, -1.11842372e-01f,
  8.90830234e-02f, 1.90449804e-01f, 8.41850415e-02f, -1.21311635e-01f, 2.08146051e-01f, 1.27260908e-01f, 1.23430371e-01f, -3.22391689e-02f, -2.06759959e-01f, 9.79210250e-03f,
  -1.43694356e-01f, 2.71840394e-01f, -3.24479900e-02f, 1.08529761e-01f, 3.74432951e-01f, 1.95254371e-01f, 1.84733957e-01f, 2.53135949e-01f, -1.09288365e-01f, 1.74394086e-01f,
  -1.86542466e-01f, 1.46023380e-02f, 2.51944095e-01f, -1.81261435e-01f, -1.89426720e-01f, -4.64833416e-02f, 6.88329190e-02f, 2.07190782e-01f, -2.14684963e-01f, 1.51053309e-01f,
  5.74803613e-02f, 2.53225029e-01f, 1.34266943e-01f, -4.05915417e-02f, -4.28210162e-02f, 1.23249009e-01f, 2.41260439e-01f, 8.12930763e-02f, 1.45997688e-01f, 1.99550092e-02f,
  4.02543277e-01f, 3.27237672e-03f, 3.89874130e-01f, 4.85491306e-02f, -1.99156627e-02f, 2.29861379e-01f, 1.06708623e-01f, -2.02478796e-01f, -2.35217646e-01f, 1.79911733e-01f,
  -5.14670610e-02f, -2.95988657e-02f, -2.85548985e-01f, 3.38901356e-02f, 3.63043919e-02f, 1.82998955e-01f, 1.14040319e-02f, 4.14100178e-02f, -3.83188166e-02f, 6.54207394e-02f,
  -3.92287672e-02f, 2.00292498e-01f, 1.23462722e-01f, 4.25393414e-03f, -1.42003775e-01f, 1.24525525e-01f, 6.65467456e-02f, 2.41547465e-01f, -2.00686425e-01f, -2.92989872e-02f,
  -2.97936648e-01f, -1.23874240e-01f, -7.40360618e-02f, 1.19808100e-01f, -1.70899302e-01f, -1.78830639e-01f, 9.75898206e-02f, -2.01147139e-01f, -2.79433411e-02f, -1.09201342e-01f,
  8.98623019e-02f, 1.02669299e-01f, 3.55512917e-01f, 5.49791120e-02f, 1.64569989e-01f, 2.54380964e-02f, -2.30469853e-01f, 3.76964062e-01f, 1.88680291e-02f, -5.99478148e-02f,
  -5.34946360e-02f, -1.05139464e-01f, 1.79430991e-01f, -1.67255729e-01f, -1.01505734e-01f, 1.84590057e-01f, 6.19259961e-02f, 9.25343409e-02f, 9.48331952e-02f, 1.53473802e-02f,
  2.31855214e-02f, 2.39168212e-01f, -8.95338953e-02f, 1.34179369e-01f, -9.46645886e-02f, -8.67504254e-02f, -3.65577377e-02f, 1.89876810e-01f, 1.22392140e-01f, 3.07127368e-02f,
  1.05269186e-01f, 4.43835668e-02f, 8.74524564e-03f, -8.99959430e-02f, 1.04169585e-01f, -1.28405973e-01f, 4.34473604e-01f, -3.72744560e-01f, -1.65533379e-01f, 4.11794782e-02f,
  4.55845334e-02f, 1.62840873e-01f, 4.02697325e-02f, 1.66656405e-01f, 4.79490682e-02f, 4.46133688e-02f, -1.01713389e-01f, 5.28543927e-02f, 7.07853734e-02f, -6.99521825e-02f,
  -1.56448483e-01f, -3.93946171e-02f, 1.36821032e-01f, -1.05277166e-01f, -1.03087179e-01f, 2.29667917e-01f, -1.56409219e-01f, 5.60763404e-02f, 6.04025163e-02f, 1.15950964e-01f,
  1.56984217e-02f, 1.77910730e-01f, -1.88765004e-01f, -1.23428673e-01f, 1.12213813e-01f, -4.04602364e-02f, 8.08030367e-02f, -2.26407662e-01f, 3.75027746e-01f, 1.98118746e-01f,
  3.28455050e-03f, 3.19050580e-01f, 1.40585154e-01f, 3.18128973e-01f, -2.08498724e-02f, 1.99274912e-01f, 2.03472853e-01f, -1.95643455e-02f, 1.84859425e-01f, -7.49762356e-02f,
  -1.37836263e-01f, 1.34628862e-01f, 5.45294546e-02f, 1.16906792e-01f, -4.66207936e-02f, 1.15090363e-01f, -4.82362211e-02f, -8.22768882e-02f, -1.09778896e-01f, -1.86596945e-01f,
  -6.42691180e-03f, 6.95421100e-02f, 1.51112184e-01f, 2.31993478e-02f, -6.23883978e-02f, -4.19187620e-02f, 2.59610325e-01f, 2.22954407e-01f, -2.25789368e-01f, 2.33820435e-02f,
  1.12014100e-01f, -1.95672229e-01f, 1.20929983e-02f, -1.29126951e-01f, 1.27672255e-01f, -3.31035163e-03f, 1.13771316e-02f, 1.29185751e-01f, -1.79457590e-02f, 8.79198238e-02f,
  -8.07854999e-03f, 8.08558911e-02f, 2.32831556e-02f, 6.11283630e-02f, -1.91211686e-01f, -3.16721760e-03f, 1.59290671e-01f, -2.29437768e-01f, -2.72472277e-02f, -1.43699467e-01f,
  -3.19549814e-02f, -2.41650283e-01f, -1.36888757e-01f, -8.04631859e-02f, 1.29468530e-01f, -8.18610713e-02f, 5.66107221e-02f, 1.15563981e-01f, -1.39177322e-01f, -1.23705924e-01f,
  -7.35981241e-02f, 1.36167333e-01f, -1.37733473e-02f, -9.22539532e-02f, 2.19075665e-01f, 1.15060240e-01f, 2.63579339e-01f, -1.01895027e-01f, 1.17070869e-01f, 1.59514651e-01f,
  2.86045875e-02f, 1.75908595e-01f, -6.94063157e-02f, -3.01248014e-01f, 2.98197567e-01f, 1.59253955e-01f, 2.03238502e-01f, 1.54312640e-01f, 2.23363444e-01f, -3.79098028e-01f,
  -7.06765475e-03f, -1.73466787e-01f, 7.06120059e-02f, -8.63028504e-03f, 3.27658355e-02f, -2.40038216e-01f, 3.08415085e-01f, 2.75754243e-01f, 2.37508267e-01f, -4.52423990e-02f,
  -3.24974842e-02f, 1.52720690e-01f, 1.64053112e-01f, 2.10970759e-01f, 3.19821090e-02f, 2.71088600e-01f, 4.67401035e-02f, 1.53676271e-01f, 1.33293331e-01f, -4.39044945e-02f,
  7.42738768e-02f, 2.35194247e-02f, 1.27748683e-01f, 1.32340968e-01f, 3.04768495e-02f, -1.45200431e-01f, 4.02157009e-02f, -4.78459056e-03f, -6.06160872e-02f, 1.91042528e-01f,
  1.64901152e-01f, -1.62284389e-01f, -1.17511272e-01f, -3.50806385e-01f, -2.70429909e-01f, -9.08515602e-02f, -3.13491434e-01f, -1.75232083e-01f, 1.62582293e-01f, -3.71220917e-01f,
  1.53010607e-01f, 1.06911644e-01f, 1.00409798e-02f, -1.61604792e-01f, 7.64169404e-03f, -1.39631495e-01f, 7.58138970e-02f, -2.37165049e-01f, 2.18844324e-01f, 1.83394149e-01f,
  -1.56735048e-01f, -1.47095725e-01f, -2.58537263e-01f, 2.24486843e-01f, -2.75121063e-01f, 2.80896612e-02f, 1.27222717e-01f, -6.46671951e-02f, 2.38854751e-01f, 4.13748287e-02f,
  2.80211180e-01f, 1.36581406e-01f, 2.64831871e-01f, 5.29577062e-02f, 4.91429046e-02f, -1.71031520e-01f, 2.96674013e-01f, -1.43318117e-01f, 1.94524452e-01f, -6.35525137e-02f,
  2.97989756e-01f, 4.75189298e-01f, -2.54936606e-01f, -2.02381685e-01f, 7.51303956e-02f, 3.19718689e-01f, -8.46034512e-02f, -9.04731899e-02f, 5.67151904e-02f, -4.13656384e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.83979124e-01f, 9.35012400e-02f, 1.49943724e-01f, 6.19715154e-02f, 3.96995656e-02f, 3.59451324e-02f, 1.11724801e-01f, 3.70380469e-02f, 1.15968890e-01f, 9.09207910e-02f,
  1.36171594e-01f, 1.65393934e-01f, -1.29343346e-02f, 1.15559898e-01f, 1.29829437e-01f, 2.80230753e-02f, -4.77360860e-02f, 1.98089480e-01f, 1.22462794e-01f, 5.38094752e-02f,
  -3.66952196e-02f, 4.07316051e-02f, 5.77684827e-02f, 3.59666348e-02f, 1.65678293e-01f, 7.72054195e-02f, -2.56641284e-02f, 7.00905100e-02f, 9.24913660e-02f, 2.98815016e-02f,
  1.82138845e-01f, 5.12973778e-02f, 1.75729811e-01f, 7.86251947e-02f, -7.22775906e-02f, -4.23707161e-03f, 1.61526687e-02f, 1.04112297e-01f, 8.09911117e-02f, -9.74904373e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -4.97426204e-02f, -1.70117155e-01f, -7.24451840e-02f, 1.10166885e-01f, -1.59406021e-01f, -1.48493633e-01f, 1.65248692e-01f, -8.47588703e-02f, -8.74785557e-02f, 9.05457288e-02f,
  -1.55622527e-01f, 6.62477762e-02f, 2.20436782e-01f, -2.03038514e-01f, -2.10280299e-01f, -6.12475276e-02f, 1.59380853e-01f, -7.46400356e-02f, -2.49148086e-01f, -1.96168035e-01f,
  1.49426326e-01f, 9.88035873e-02f, -8.02398995e-02f, -1.96228981e-01f, -2.79771119e-01f, 1.29393235e-01f, 1.50266722e-01f, -2.56555408e-01f, 3.43598868e-03f, -9.34849530e-02f,
  1.99261442e-01f, 8.03603232e-02f, 5.76965064e-02f, -2.88192838e-01f, 2.70285249e-01f, -2.72104412e-01f, -1.54178038e-01f, -3.53723347e-01f, -7.92396143e-02f, -2.85342216e-01f,
  9.10555664e-03f, 1.31010190e-01f, -1.11587845e-01f, -2.76594251e-01f, -8.28610584e-02f, -2.59494543e-01f, -1.28195673e-01f, -3.07384044e-01f, -3.50225866e-01f, 2.05065086e-01f,
  -3.35024625e-01f, 5.66929206e-02f, 8.71495232e-02f, 1.01091057e-01f, -2.44635716e-01f, -9.38220993e-02f, -2.81500131e-01f, -3.98608297e-02f, -2.66666442e-01f, 2.48654932e-01f,
  -9.71491113e-02f, -2.10282966e-01f, 8.50058347e-02f, 2.61022747e-01f, 1.59502223e-01f, -2.03541353e-01f, 4.60868664e-02f, -1.38781160e-01f, -1.13069154e-02f, 5.16032763e-02f,
  2.77070329e-02f, -1.21312246e-01f, -2.10918915e-02f, 4.11523925e-03f, 3.86568112e-03f, 1.61068887e-01f, -2.18856990e-01f, -1.51749313e-01f, -7.53447637e-02f, -1.24823622e-01f,
  1.55536130e-01f, -1.15979545e-01f, -9.21107233e-02f, -2.18544751e-01f, 1.06420144e-01f, 1.13889761e-01f, 5.32233864e-02f, 2.77375411e-02f, 2.45475978e-01f, 1.34787038e-01f,
  -4.39325541e-01f, -2.99378514e-01f, 8.10616463e-02f, -3.07097077e-01f, -3.05932194e-01f, 4.94540483e-02f, 1.46563441e-01f, 7.08009824e-02f, 8.96054655e-02f, -2.09017396e-01f,
  -2.39311770e-01f, -1.74983472e-01f, 3.17668408e-01f, 8.48066807e-02f, -1.81108430e-01f, 2.54112214e-01f, 1.69416204e-01f, -2.37607181e-01f, -1.77810565e-01f, -3.36993724e-01f,
  -2.82550871e-01f, 1.29563868e-01f, -1.73346568e-02f, 1.62315905e-01f, -6.34196997e-02f, -1.28729984e-01f, -3.09789777e-01f, 1.73639178e-01f, -7.10795894e-02f, -3.24439555e-01f,
  -1.54993966e-01f, 3.98696624e-02f, 1.52750723e-02f, 1.46810904e-01f, -3.25975507e-01f, 8.15920625e-03f, -2.88119614e-01f, -1.04057305e-02f, 1.43237449e-02f, 8.32097605e-02f,
  -6.72933757e-02f, 5.16624600e-02f, -1.25515386e-01f, -1.03820533e-01f, -1.07153170e-01f, -8.87979008e-03f, -6.62795231e-02f, 7.01759979e-02f, 1.45730451e-01f, 3.80586050e-02f,
  -9.62417349e-02f, -7.37692937e-02f, -2.12665230e-01f, 2.30064213e-01f, -1.69739187e-01f, 5.36280870e-02f, 1.50941893e-01f, 1.78621024e-01f, -2.11107507e-01f, -1.22175477e-02f,
  5.79106919e-02f, -9.51651707e-02f, 1.59059674e-01f, -3.52441549e-01f, -2.51006663e-01f, 1.15238531e-02f, 1.21614099e-01f, -4.12186533e-01f, -1.62865534e-01f, -3.26797009e-01f,
  -2.00155333e-01f, -3.60983759e-01f, -2.98377037e-01f, 8.25750604e-02f, -1.95755497e-01f, -2.97139168e-01f, 1.69894233e-01f, 1.86062202e-01f, 2.08221868e-01f, 8.52585435e-02f,
  -2.47723330e-02f, 1.53201401e-01f, 1.98930249e-01f, 2.79203728e-02f, -2.51716703e-01f, 2.77757775e-02f, 2.53466547e-01f, -2.11657852e-01f, 1.99507669e-01f, 1.01116076e-01f,
  -2.26983458e-01f, 1.87928937e-02f, -1.88962162e-01f, 1.01895407e-02f, 2.07806572e-01f, -2.51405358e-01f, -7.52439126e-02f, 1.44962952e-01f, 6.00757226e-02f, -9.67141986e-02f,
  -2.12188929e-01f, -4.24113385e-02f, 1.04457580e-01f, -1.89281199e-02f, 5.70149533e-02f, -7.39723295e-02f, 5.90023212e-02f, 3.99309117e-03f, 9.69087780e-02f, 4.89441259e-03f,
  -5.70776537e-02f, 1.08749485e-02f, -1.73393264e-02f, -7.59363845e-02f, 2.24784553e-01f, 9.44814160e-02f, 1.71123251e-01f, -1.92580611e-01f, -1.62810817e-01f, -4.50667292e-02f,
  -2.83178855e-02f, -1.71214238e-01f, 1.96464002e-01f, -7.61169046e-02f, -2.57846743e-01f, 1.80476785e-01f, -2.49986127e-01f, -3.45059156e-01f, 2.29973257e-01f, 1.18331783e-01f,
  -2.83384770e-02f, 3.70998010e-02f, 2.88840204e-01f, -1.32917210e-01f, -1.53152660e-01f, 1.29026115e-01f, 1.69940516e-01f, 2.21166275e-02f, 9.11551639e-02f, -1.82331413e-01f,
  -3.28315020e-01f, -5.24196565e-01f, -2.23797202e-01f, -2.35954583e-01f, -2.48354375e-01f, 2.37523377e-01f, -2.77818829e-01f, -2.96599001e-01f, 1.71129093e-01f, 3.22922766e-02f,
  -3.24894547e-01f, -1.96685120e-01f, -8.46049860e-02f, -2.11010039e-01f, -1.15549356e-01f, 8.72075558e-02f, 4.82712574e-02f, -2.94941906e-02f, -2.35697523e-01f, 1.53117508e-01f,
  1.36484459e-01f, -1.19857304e-01f, 1.81212232e-01f, 1.12530053e-01f, 3.45966592e-02f, 2.81236529e-01f, -5.93132377e-02f, -1.12260036e-01f, -2.99596079e-02f, -1.08977318e-01f,
  1.33900523e-01f, -4.73362617e-02f, -9.96540114e-02f, 4.78822179e-02f, 1.45693138e-01f, -1.34860784e-01f, -4.02700417e-02f, 1.38724551e-01f, 6.28654957e-02f, 5.80586866e-02f,
  1.83512688e-01f, -1.80343524e-01f, 7.91117474e-02f, 2.69335747e-01f, 1.20708324e-01f, 7.38183483e-02f, -2.23290846e-01f, 6.94741830e-02f, -8.69294181e-02f, -2.59252727e-01f,
  1.23547567e-02f, -5.87081462e-02f, 1.78100988e-01f, 1.91407785e-01f, 6.13129027e-02f, 2.80092984e-01f, 1.76833756e-02f, -1.21673562e-01f, -1.16611168e-01f, -2.17579916e-01f,
  6.13504387e-02f, 9.02164802e-02f, 6.10585883e-02f, 6.64841980e-02f, -1.77424878e-01f, -5.65888323e-02f, -1.49228796e-01f, 8.92446712e-02f, 7.52727762e-02f, -8.68290588e-02f,
  -1.66112483e-01f, -8.63399431e-02f, 1.00457713e-01f, -1.04607001e-01f, -5.84306531e-02f, 2.50466466e-02f, -2.67921299e-01f, 1.55041963e-01f, 1.58919007e-01f, -2.10755870e-01f,
  -2.99871743e-01f, -2.75432736e-01f, 1.63091734e-01f, 1.58523008e-01f, 4.68833633e-02f, 1.01189137e-01f, 1.24381436e-02f, -5.02572395e-02f, 9.32832807e-03f, 1.77344918e-01f,
  1.99591629e-02f, 2.44829312e-01f, -2.17153970e-02f, 1.13525651e-02f, 7.02006221e-02f, 2.30768304e-02f, -4.68164198e-02f, -1.47022247e-01f, 7.01175779e-02f, 1.71098098e-01f,
  -9.24869552e-02f, -1.52212098e-01f, -8.45485106e-02f, 1.05705373e-02f, -1.86368406e-01f, -9.95627716e-02f, 9.03465003e-02f, -7.24271536e-02f, -3.85788903e-02f, -1.89820006e-01f,
  -8.88135657e-02f, -4.87896726e-02f, -4.72940691e-03f, -8.24324936e-02f, -3.05032223e-01f, 2.44137764e-01f, -1.97699249e-01f, -2.96189100e-01f, 1.41465664e-01f, 2.12993726e-01f,
  2.47183349e-02f, 1.23730153e-01f, 1.54460892e-01f, -2.27463394e-02f, -3.08918692e-02f, -4.34399366e-01f, -1.54319108e-01f, 3.76966894e-02f, -2.61425972e-01f, 1.88002169e-01f,
  9.36489850e-02f, 3.48154604e-02f, -2.51432627e-01f, -1.33460313e-01f, -3.32618237e-01f, 9.15434510e-02f, 2.33863086e-01f, -1.12951934e-01f, 3.23009938e-02f, 1.54081509e-01f,
  1.32404625e-01f, -2.95431167e-02f, -1.46847904e-01f, -2.58154094e-01f, 2.26252541e-01f, -2.05499247e-01f, 1.46142289e-01f, 1.44398436e-01f, -3.50599498e-01f, -9.60128556e-04f,
  -2.46673405e-01f, -2.74338275e-01f, 1.31355673e-02f, -7.94880465e-02f, -6.26036897e-04f, 8.33010525e-02f, 1.23003386e-01f, 1.02245331e-01f, -1.09805472e-01f, -8.26231912e-02f,
  -2.05980361e-01f, 1.33671209e-01f, -6.08008243e-02f, -1.24913722e-01f, -4.32827137e-02f, 7.97228590e-02f, -1.70741409e-01f, -4.50109914e-02f, 1.71402976e-01f, -2.81249642e-01f,
  -1.30513489e-01f, 2.67269760e-01f, 1.06100224e-01f, 1.59757957e-01f, -1.91850543e-01f, 1.05903104e-01f, -1.14182130e-01f, 1.91425711e-01f, -5.84612899e-02f, -1.47261709e-01f,
  -1.31292656e-01f, 2.08693936e-01f, 1.63288727e-01f, 1.12680532e-01f, 1.97648443e-03f, -7.54048750e-02f, -3.23755555e-02f, -1.18386485e-01f, -4.08320993e-01f, -1.77567169e-01f,
  4.93267477e-02f, 2.04960346e-01f, -3.67133230e-01f, 1.81859031e-01f, -1.22325998e-02f, 1.39122522e-02f, -1.64544597e-01f, -5.50037920e-02f, 1.47753075e-01f, 2.20485315e-01f,
  -3.20195287e-01f, -7.73005337e-02f, -2.89249688e-01f, -3.66338581e-01f, 2.16482058e-01f, -1.01028286e-01f, -1.01660281e-01f, -2.66183764e-01f, 3.15416157e-02f, 1.52927682e-01f,
  2.13895455e-01f, 1.19937837e-01f, -3.10906500e-01f, -1.06423520e-01f, 2.80154258e-01f, -2.56724089e-01f, -2.79419690e-01f, -3.99759524e-02f, -5.90148158e-02f, -5.29204607e-02f,
  1.09297380e-01f, -4.41501103e-02f, 6.05433024e-02f, -1.45560592e-01f, 3.02393697e-02f, -1.45440772e-01f, -1.79267749e-01f, 5.61526939e-02f, -1.43870294e-01f, -2.64499318e-02f,
  7.46773034e-02f, 1.55586924e-03f, -5.18597849e-02f, 1.42806187e-01f, 1.31832004e-01f, 1.76656038e-01f, -2.18639776e-01f, 9.40672085e-02f, -1.66481957e-01f, -7.18747973e-02f,
  1.82160828e-02f, 1.48103803e-01f, -2.14978471e-01f, -2.66004503e-01f, 1.49368525e-01f, 2.47527882e-02f, -2.45389119e-01f, -2.08151177e-01f, 2.32332423e-01f, -2.71883279e-01f,
  6.78129345e-02f, 2.74436086e-01f, 1.45559594e-01f, 5.24262004e-02f, -2.62334913e-01f, 1.53605551e-01f, -1.28652498e-01f, 8.29943120e-02f, 2.80525386e-01f, -1.79537639e-01f,
  1.56015353e-02f, 2.26877436e-01f, 2.29196578e-01f, -4.15647998e-02f, 1.28099337e-01f, -1.62169918e-01f, 4.11487781e-02f, -2.73835123e-01f, -4.72871885e-02f, -2.11118728e-01f,
  -7.93281496e-02f, 1.01706609e-01f, -1.46672264e-01f, 2.34400779e-01f, -1.94706514e-01f, -1.11285232e-01f, 2.97264606e-01f, -2.11580351e-01f, -5.90509288e-02f, -3.01883370e-01f,
  2.61256516e-01f, -1.11676119e-01f, -2.02581063e-01f, -7.06976056e-02f, -1.25243962e-01f, 4.99522761e-02f, -3.13862748e-02f, 7.26867244e-02f, -8.03694576e-02f, 9.26828831e-02f,
  -1.51724204e-01f, 1.07709266e-01f, 8.18227753e-02f, -2.26304568e-02f, -1.47616178e-01f, -2.35362872e-02f, -1.72658920e-01f, -1.43925339e-01f, 4.54410613e-02f, -2.08585605e-01f,
  1.17632389e-01f, 1.84055075e-01f, 2.06934437e-01f, 1.13735951e-01f, 1.42075852e-01f, 2.59647548e-01f, 5.66228665e-02f, -2.16220394e-01f, -1.47790536e-01f, -2.75413960e-01f,
  -3.83399427e-01f, -3.18840444e-02f, -5.10734022e-02f, 9.50747430e-02f, -3.89764979e-02f, 2.88022637e-01f, -3.06322485e-01f, -6.41620308e-02f, -1.52349740e-01f, -2.60580420e-01f,
  2.25657076e-01f, -2.97048420e-01f, -2.16694042e-01f, 1.87289387e-01f, 2.51620948e-01f, -4.07927670e-03f, -7.41017088e-02f, 8.43737274e-02f, 2.92129349e-02f, 1.41316921e-01f,
  2.29949802e-01f, -1.56117901e-01f, 2.26080164e-01f, -1.43976346e-01f, -1.81324556e-01f, -6.69438839e-02f, 2.95137674e-01f, 1.54271021e-01f, -2.70249490e-02f, -3.03098261e-01f,
  -7.15600252e-02f, -2.88177997e-01f, 1.17806211e-01f, 2.60306090e-01f, -2.45940402e-01f, -8.27036873e-02f, -1.03933498e-01f, 3.94323468e-03f, 5.23865633e-02f, 5.39865298e-03f,
  1.60734385e-01f, 3.67673859e-03f, 1.88400850e-01f, -1.76981818e-02f, -3.18853632e-02f, -1.37123346e-01f, 2.01834381e-01f, 1.20673748e-03f, 2.37506106e-01f, 9.65222940e-02f,
  5.98284602e-02f, 2.91806906e-01f, 1.31231979e-01f, -2.75467280e-02f, -1.04642962e-03f, 1.60220414e-01f, 6.35171756e-02f, -1.48300409e-01f, 2.00420301e-02f, -2.16327012e-01f,
  -6.01847237e-03f, -2.77325381e-02f, -2.97294110e-02f, 2.09558811e-02f, 9.25263315e-02f, -1.20632105e-01f, -3.50678712e-01f, -3.74670804e-01f, 2.34709173e-01f, -2.46940538e-01f,
  1.95453510e-01f, 1.14618964e-01f, 6.60603121e-02f, 1.94205806e-01f, -2.81291634e-01f, 2.39010856e-01f, 2.22477213e-01f, -2.52117753e-01f, -2.02136248e-01f, 6.86711520e-02f,
  2.58246362e-01f, 1.91587284e-02f, -3.79618704e-01f, -9.56628099e-02f, -3.06933850e-01f, -4.46397774e-02f, -1.90934941e-01f, 1.54504269e-01f, 2.64806896e-01f, -2.86708891e-01f,
  -5.29965274e-02f, 2.95920279e-02f, -1.35904551e-01f, 7.86578357e-02f, 4.51017991e-02f, 6.24337159e-02f, -4.01829630e-02f, 5.61069348e-04f, -1.69862106e-01f, -3.76388043e-01f,
  9.09740180e-02f, 9.18742269e-02f, 8.34050216e-03f, -9.96379778e-02f, -4.89210412e-02f, -1.02598712e-01f, 1.27146989e-01f, 6.83484674e-02f, 1.28978729e-01f, 8.54357183e-02f,
  1.29278690e-01f, 7.01265261e-02f, 5.71766607e-02f, 2.36329421e-01f, 8.55951533e-02f, 1.95987299e-01f, -6.98095141e-03f, 1.04459733e-01f, -1.75231457e-01f, 2.17006251e-01f,
  1.44990966e-01f, 2.08881468e-01f, 2.53902733e-01f, 1.72622830e-01f, 3.18013489e-01f, 1.38835877e-01f, -5.30647188e-02f, 1.73354015e-01f, 6.26352802e-02f, -9.45860296e-02f,
  -2.95060515e-01f, -2.43824333e-01f, -2.41051167e-01f, -5.29695414e-02f, -7.71705210e-02f, 1.19341016e-01f, 2.48891070e-01f, 5.92250079e-02f, 9.46209803e-02f, -1.22214019e-01f,
  -1.00895800e-01f, -2.85329729e-01f, -9.36755911e-02f, 1.83519661e-01f, -1.95220813e-01f, -3.77953351e-02f, 5.14767878e-02f, 2.03061730e-01f, 1.97129726e-01f, 1.95026070e-01f,
  -3.78715783e-01f, -1.86159164e-01f, -1.99346840e-01f, 2.00802863e-01f, 1.73471346e-01f, -1.21712953e-01f, -1.62826598e-01f, 1.44040629e-01f, -2.43921012e-01f, -3.15952450e-01f,
  -2.30776906e-01f, 1.69822246e-01f, 1.18307330e-01f, -4.13411371e-02f, -3.23730707e-02f, -1.27643839e-01f, -3.63616385e-02f, 1.47488773e-01f, -3.19889709e-02f, 1.64933249e-01f,
  5.29574975e-02f, 1.28057063e-01f, -4.32345457e-02f, -7.02039851e-03f, -1.37136847e-01f, -1.31827295e-01f, 1.81532905e-01f, 1.64268047e-01f, 1.04274556e-01f, 1.43197170e-02f,
  -6.48521706e-02f, 1.25771333e-02f, 7.81755671e-02f, 7.73866549e-02f, 2.29098827e-01f, -1.39436200e-01f, -8.34531784e-02f, 1.09669879e-01f, -3.50847125e-01f, 8.99825767e-02f,
  -4.46506143e-02f, 9.85049922e-03f, -3.08146328e-01f, -4.23586406e-02f, 1.03933625e-01f, 2.45466739e-01f, -2.32717261e-01f, -1.20556364e-02f, -2.23175347e-01f, -1.74595956e-02f,
  7.22962171e-02f, 1.04537889e-01f, -1.02294512e-01f, 1.33268222e-01f, -5.66886365e-02f, -3.28134030e-01f, -2.04099685e-01f, 2.15138733e-01f, -3.32199991e-01f, 1.88404843e-01f,
  8.61256421e-02f, 1.99761122e-01f, 6.42916141e-03f, -3.27119589e-01f, -2.75455415e-01f, -7.91710690e-02f, -1.08776741e-01f, -3.18490207e-01f, 1.82333946e-01f, 2.63645649e-01f,
  1.02215447e-01f, 6.86086565e-02f, 2.73134947e-01f, -2.77384192e-01f, 2.04673082e-01f, 1.63640350e-01f, -3.35322499e-01f, -2.62357175e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.97121871e-02f, 6.46835640e-02f, -5.55310808e-02f, -5.73659763e-02f, -5.63644022e-02f, 4.76401299e-02f, -7.63604790e-02f, 2.05979533e-02f, 1.50488326e-02f, -1.76344253e-02f,
  4.12309617e-02f, -6.96814358e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    