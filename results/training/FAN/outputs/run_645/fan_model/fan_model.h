/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.07029907e-02f, 2.50895083e-01f, -4.97464150e-01f, -1.63190216e-02f, -8.00561383e-02f, -2.61158675e-01f, -2.74397880e-01f, -8.27450827e-02f, 8.03144882e-04f, 6.37638420e-02f,
  2.25188047e-01f, 2.71712780e-01f, 1.49091542e-01f, 1.01078786e-01f, -2.55507916e-01f, -2.44556606e-01f, -3.10186654e-01f, -3.02894175e-01f, -1.54435158e-01f, -7.65535086e-02f,
  1.36137784e-01f, 5.57212196e-02f, 2.28384323e-02f, -9.39671770e-02f, 5.56650497e-02f, 9.59101021e-02f, 1.30667808e-02f, -9.48316185e-04f, -2.79288199e-02f, -4.67467830e-02f,
  -1.55000649e-02f, -4.46292385e-02f, -1.13007337e-01f, 1.59490500e-02f, 7.41856992e-02f, -3.86366919e-02f, -7.08529493e-03f, 3.22580896e-02f, 8.23972598e-02f, -3.75167169e-02f,
  5.90259433e-02f, 5.79556972e-02f, -7.18412129e-03f, 4.95770052e-02f, -2.48670559e-02f, 4.99969907e-02f, -2.11586710e-02f, -1.35204136e-01f, -1.05404399e-01f, -5.73319644e-02f,
  -2.53609456e-02f, 4.39331010e-02f, -1.40330255e-01f, -2.54993606e-02f, -1.54066950e-01f, -2.60052029e-02f, -4.25747596e-02f, -1.16372958e-01f, -2.09020436e-01f, 2.09804960e-02f,
  9.17495638e-02f, -1.72822569e-02f, 9.20466613e-03f, 5.26222847e-02f, 1.74809322e-02f, 6.13972433e-02f, 1.06497824e-01f, 9.84146670e-02f, -1.86684448e-02f, 1.17125608e-01f,
  3.78974527e-02f, -1.02181390e-01f, -3.24901715e-02f, 7.74847940e-02f, 3.32872979e-02f, -3.48942056e-02f, -2.35195477e-02f, 1.10653043e-01f, 3.07170898e-02f, -1.59620102e-02f,
  6.81463331e-02f, -5.62293082e-02f, 4.68552224e-02f, -6.13973364e-02f, -5.30786887e-02f, -7.76395621e-03f, 1.11422315e-02f, 6.62255362e-02f, 1.09380230e-01f, 2.86938231e-02f,
  2.63923913e-01f, -2.58310974e-01f, 1.81922197e-01f, 8.20940137e-02f, -2.80611962e-02f, 1.14629976e-03f, 2.96179894e-02f, -5.06136380e-02f, -1.26931090e-02f, -9.05538793e-04f,
  -6.49377406e-02f, -3.15374718e-03f, 4.69205379e-02f, -4.81849350e-02f, 3.17349620e-02f, 5.93168288e-03f, 6.89653382e-02f, 7.52254436e-03f, -8.51309523e-02f, -9.62145403e-02f,
  -2.32712124e-02f, -1.23991827e-02f, 1.09510057e-01f, -3.17597855e-03f, 2.06552199e-04f, -2.88955867e-02f, 7.49939010e-02f, -4.45052981e-03f, -6.13924749e-02f, 1.13327235e-01f,
  -5.82959890e-01f, 4.59985644e-01f, 1.46217458e-02f, -1.78411365e-01f, 2.99053907e-01f, 1.27392277e-01f, 3.84892762e-01f, -2.14525208e-01f, -3.97272289e-01f, 8.86736289e-02f,
  3.43526483e-01f, 7.34501183e-02f, -3.25475968e-02f, -1.04906157e-01f, -1.19884655e-01f, 1.74380049e-01f, 9.56075862e-02f, -2.60831922e-01f, -3.32811892e-01f, -1.62036434e-01f,
  1.92118570e-01f, -1.09412022e-01f, -2.64627755e-01f, -1.12840146e-01f, 1.87483453e-03f, -1.12570271e-01f, 9.17239115e-02f, 3.82658839e-02f, 2.24936888e-01f, 2.14445680e-01f,
  1.08778171e-01f, 6.93839118e-02f, -5.54607883e-02f, 9.20878630e-03f, 1.11796305e-01f, -1.32017955e-01f, 4.33479846e-02f, -6.99427947e-02f, -2.37262547e-02f, 3.37343337e-03f,
  1.52493799e-02f, -8.33730120e-03f, -5.35709225e-03f, -6.65951148e-02f, 5.39064184e-02f, -1.85180902e-02f, -1.45201311e-01f, -1.11566715e-01f, -1.58948004e-01f, 6.36836812e-02f,
  1.92869619e-01f, 1.50812298e-01f, 1.87476858e-01f, 3.76986451e-02f, -1.52414441e-01f, -1.07790314e-01f, 3.22679244e-02f, -9.48474184e-02f, -9.14455801e-02f, -1.40501276e-01f,
  -1.32480711e-01f, 3.32861207e-03f, 9.72215533e-02f, 8.33928213e-02f, 2.72207847e-03f, 3.51968147e-02f, 3.60421184e-03f, 5.53682260e-02f, -3.83979380e-02f, 5.49323931e-02f,
  9.54201538e-03f, -1.65906996e-02f, -3.68886851e-02f, -4.10805549e-03f, 5.59513941e-02f, 5.39970025e-02f, -6.68850392e-02f, 2.51319669e-02f, -1.08385934e-02f, 3.30014862e-02f,
  -4.62114736e-02f, 4.20443565e-02f, 5.63683845e-02f, -2.43287832e-02f, 6.26858547e-02f, -6.93808496e-02f, -6.75059715e-03f, -8.65177158e-03f, -1.95941925e-02f, 7.41527900e-02f,
  -1.35491446e-01f, 2.28136063e-01f, 8.88679698e-02f, 5.87344766e-02f, -2.51117032e-02f, 7.01657087e-02f, 9.33859050e-02f, 3.77077460e-02f, 1.74327381e-02f, -4.88755219e-02f,
  6.07857890e-02f, -3.77422385e-02f, 1.65795520e-01f, -2.40347572e-02f, 3.76177542e-02f, -1.55852810e-02f, 7.82099813e-02f, 3.13209519e-02f, 5.35961539e-02f, -5.91963937e-04f,
  -5.62154204e-02f, -4.29261802e-03f, -8.81151557e-02f, 2.40094941e-02f, 2.15502065e-02f, -5.41604161e-02f, 6.53895736e-02f, -1.15888618e-01f, -1.54117690e-02f, -1.29948378e-01f,
  6.96858242e-02f, 1.63271919e-01f, 2.78305352e-01f, 1.58144951e-01f, 2.69233495e-01f, -1.63103379e-02f, 1.52418360e-01f, -5.81013113e-02f, -1.05623223e-01f, 2.23312840e-01f,
  -6.53779283e-02f, -1.77521437e-01f, -1.56837001e-01f, -2.47639790e-01f, -2.09723517e-01f, 5.86635731e-02f, 6.24943450e-02f, -1.51185244e-01f, -2.82838136e-01f, -7.25410953e-02f,
  1.48297381e-02f, 4.96265963e-02f, -1.15897752e-01f, -2.22274512e-01f, 3.31811458e-01f, -3.36115956e-02f, 1.19053416e-01f, 2.12382361e-01f, -7.97167048e-02f, 4.72110540e-01f,
  1.66125908e-01f, 3.06545228e-01f, -1.32259831e-01f, -8.73584077e-02f, 1.33700728e-01f, -9.26048681e-03f, -6.10581636e-02f, -4.47333530e-02f, 4.28193249e-02f, -3.55297364e-02f,
  1.37435362e-01f, 9.75359417e-03f, -6.03228658e-02f, 3.26025560e-02f, 9.52236056e-02f, 1.27163902e-01f, 3.82737443e-02f, -7.98132736e-03f, -1.26931995e-01f, -9.60487232e-04f,
  -4.53629680e-02f, 1.24560758e-01f, 1.31308258e-01f, -7.14045838e-02f, -1.15782125e-02f, -5.72787859e-02f, 1.92966103e-03f, -3.98547985e-02f, -4.40509245e-02f, 1.14834808e-01f,
  -3.77666801e-02f, 7.42818192e-02f, -4.92265169e-03f, 3.72502506e-02f, -2.41615232e-02f, -1.75972860e-02f, 5.63471615e-02f, 1.28217367e-02f, -1.75613519e-02f, 6.84212241e-03f,
  -3.72270704e-03f, -1.03781000e-01f, -7.60183483e-02f, 4.99257371e-02f, -2.44493596e-02f, 4.97333705e-02f, -6.12048246e-02f, 2.06573885e-02f, 5.94294304e-03f, -1.91953480e-02f,
  -1.77498553e-02f, 5.93396276e-02f, 2.34562270e-02f, -2.40470525e-02f, -6.80121258e-02f, 3.54420394e-02f, -5.12151346e-02f, -3.99133749e-02f, 3.72943021e-02f, 5.17299660e-02f,
  -3.54241878e-01f, -2.76924133e-01f, -3.75082307e-02f, -3.37157436e-02f, 2.83613671e-02f, -1.84735544e-02f, 5.52521981e-02f, 1.57052446e-02f, 7.53852129e-02f, 6.65882826e-02f,
  -6.84059337e-02f, 2.62194732e-03f, 5.59723824e-02f, -2.22164541e-02f, -3.18655781e-02f, -1.06103029e-02f, -1.16466127e-01f, -2.25928519e-03f, -9.97651890e-02f, 3.95533703e-02f,
  -9.41797793e-02f, -1.62204787e-01f, -1.71404362e-01f, 1.32318707e-02f, -4.63049784e-02f, -4.48232256e-02f, 3.17900162e-03f, -2.07326021e-02f, -1.55785322e-01f, 1.01100923e-02f,
  2.94068545e-01f, -8.07220191e-02f, -2.11176857e-01f, 1.94486615e-03f, 2.44012207e-01f, 4.05118078e-01f, 4.98076111e-01f, 1.83776841e-01f, -2.77158320e-02f, 6.72803167e-03f,
  -5.83744086e-02f, -2.62888074e-01f, -2.74270624e-01f, -1.76130787e-01f, 6.05956130e-02f, 1.75316468e-01f, 1.79308087e-01f, -7.40418583e-02f, -3.88381407e-02f, 8.11485350e-02f,
  2.63260007e-02f, 8.36932138e-02f, -5.20875268e-02f, -1.75819509e-02f, -2.01370180e-01f, -1.12506278e-01f, -1.36872709e-01f, -8.79733711e-02f, 5.26297502e-02f, -2.60273457e-01f,
  -2.02384710e-01f, -1.16106741e-01f, 1.07764429e-03f, 7.32966885e-02f, 3.11382003e-02f, 1.19156457e-01f, 7.78654814e-02f, 3.96641381e-02f, -2.55262498e-02f, 7.24523515e-02f,
  -1.25440741e-02f, 4.43347692e-02f, 7.81377591e-03f, -4.08369452e-02f, -1.15320063e-03f, 1.92240663e-02f, 3.94292399e-02f, -2.44064555e-02f, 1.11351639e-01f, -7.48777911e-02f,
  8.50339141e-03f, 5.23481853e-02f, 6.61177710e-02f, 1.31053075e-01f, 5.54622076e-02f, 1.00504190e-01f, -4.17306796e-02f, 1.27697531e-02f, -2.58299708e-02f, -7.31072715e-03f,
  1.16795108e-01f, -4.71493006e-02f, 4.59256992e-02f, 2.39507947e-02f, 3.34610231e-02f, 8.44319463e-02f, 4.51539643e-02f, -3.11003756e-02f, -1.22913383e-02f, 2.95418613e-02f,
  5.84874712e-02f, 9.07042343e-03f, 3.86581719e-02f, 1.05337180e-01f, -7.13838041e-02f, -3.83991227e-02f, 1.18784815e-01f, -2.60319076e-02f, -2.66605224e-02f, 2.10840032e-02f,
  -6.42583296e-02f, 2.79598422e-02f, -5.72893536e-04f, -3.06296889e-02f, -7.24309077e-03f, -1.01216389e-02f, -8.24862346e-02f, 4.28462774e-02f, 2.96760965e-02f, 6.52234480e-02f,
  -6.36064773e-03f, 1.69836730e-01f, -1.54130459e-01f, -1.65780351e-01f, -1.37746530e-02f, -6.92535117e-02f, -1.69728160e-01f, -2.38545425e-03f, 7.04068840e-02f, -5.40176891e-02f,
  -6.05532061e-03f, -1.83250085e-02f, 1.56727172e-02f, -7.14353705e-03f, 6.75789416e-02f, -7.19459681e-03f, 8.50425884e-02f, -2.89615914e-02f, -8.87530297e-03f, 8.74315016e-03f,
  -3.14020738e-02f, 6.62318841e-02f, -1.98817980e-02f, -2.55236905e-02f, -5.16713299e-02f, 9.23568159e-02f, -1.19493075e-01f, 2.10590083e-02f, 1.16554707e-01f, 2.22434238e-01f,
  -1.10705249e-01f, 4.98546749e-01f, -1.14105649e-01f, 4.79040742e-02f, 1.58112019e-01f, 9.61794183e-02f, 3.70099723e-01f, 1.95090607e-01f, -1.07443526e-01f, 1.23940287e-02f,
  1.05923705e-01f, 3.03569864e-02f, -9.19934064e-02f, -8.78141820e-02f, -2.33217150e-01f, -1.01332478e-01f, -3.62624496e-01f, -3.76641005e-01f, -1.91002980e-01f, -2.81624291e-02f,
  1.15696536e-02f, -5.12017263e-03f, -3.95402201e-02f, -2.26347595e-01f, -5.53914160e-02f, -9.01750401e-02f, -1.30261667e-02f, 4.80876975e-02f, -1.01003394e-01f, -4.69608456e-01f,
  -3.26824933e-02f, 3.38850439e-01f, -1.01135224e-01f, -6.92800060e-02f, 6.15515262e-02f, -2.93318368e-02f, 5.68807591e-03f, -5.12458384e-03f, 5.12799770e-02f, -2.56748721e-02f,
  -8.59197602e-02f, -1.68590844e-02f, 5.08403027e-05f, 3.07006054e-02f, 1.13778129e-01f, 3.90095674e-02f, 2.92972736e-02f, -5.64243421e-02f, -7.75437132e-02f, 1.48825020e-01f,
  -7.12058097e-02f, -2.97955964e-02f, 3.18986252e-02f, -5.78650855e-04f, 5.99744208e-02f, -8.76119584e-02f, 1.21124610e-01f, -1.24676123e-01f, -2.12727308e-01f, -9.39706787e-02f,
  1.91767178e-02f, 1.46492030e-02f, -3.62627115e-03f, 9.96770263e-02f, 9.15877987e-03f, 6.14797845e-02f, -5.30889258e-02f, 5.86318225e-03f, -8.07587653e-02f, -8.53443705e-03f,
  3.47896330e-02f, -8.17418471e-03f, 4.69812527e-02f, 2.01923437e-02f, -7.86740109e-02f, -6.81682304e-02f, -3.17594483e-02f, -3.92777212e-02f, -3.07825785e-02f, -6.08335212e-02f,
  -5.00782207e-02f, -4.97450493e-02f, 3.28672081e-02f, 1.28276162e-02f, -2.61145309e-02f, -1.74586959e-02f, -2.14295462e-03f, 9.10121650e-02f, -1.52360403e-03f, -2.97630299e-02f,
  2.52044052e-01f, -1.43424720e-01f, -1.01004373e-02f, -7.77700096e-02f, -4.90059182e-02f, -5.42219169e-02f, 1.38213765e-02f, 6.75064838e-03f, 1.08966284e-01f, -1.15871234e-02f,
  3.19588520e-02f, -7.42593482e-02f, 3.74200121e-02f, -8.41459259e-02f, -1.07447192e-01f, -3.46055739e-02f, -2.61201542e-02f, -3.47753651e-02f, -6.99560419e-02f, -3.98981459e-02f,
  -2.89088432e-02f, -7.56063759e-02f, 1.25007089e-02f, 3.72319892e-02f, 1.46504156e-02f, -4.13036048e-02f, 2.48220935e-02f, 8.86332942e-04f, -1.82933616e-03f, 8.62254873e-02f,
  6.59374297e-01f, -5.34121096e-01f, 2.14634374e-01f, 6.78779185e-02f, -3.49279284e-01f, -5.87513261e-02f, -4.00031865e-01f, 6.63787499e-03f, -1.07146762e-02f, -2.77088642e-01f,
  -1.79621056e-01f, 3.30281705e-02f, 3.09740622e-02f, 5.66707850e-02f, 1.37219280e-01f, -1.79066956e-01f, -2.19827250e-01f, 3.20404619e-01f, 4.93847907e-01f, 4.68987562e-02f,
  -2.33234584e-01f, 1.29575664e-02f, 1.79698080e-01f, 9.16404873e-02f, -2.56290466e-01f, -5.68585806e-02f, -1.66371435e-01f, -1.41928613e-01f, -2.10260853e-01f, -3.23960513e-01f,
  8.69787708e-02f, -6.13278039e-02f, -1.74415652e-02f, -2.17225924e-01f, -1.74176261e-01f, -4.31849658e-02f, -5.64407855e-02f, -1.06511451e-01f, -5.06668426e-02f, -9.33332965e-02f,
  -2.56709278e-01f, -6.22636117e-02f, -1.06979899e-01f, -1.48874030e-01f, -6.99292272e-02f, -1.09774135e-01f, -3.51115465e-02f, 1.12589356e-02f, -3.10892183e-02f, -1.43862084e-01f,
  -3.48146588e-01f, -2.25622118e-01f, -1.41389966e-01f, -1.39730975e-01f, -9.51756909e-02f, -2.67958753e-02f, -1.18356884e-01f, -1.28836885e-01f, -3.73849943e-02f, -1.58174768e-01f,
  -5.50735034e-02f, 8.49461630e-02f, 8.58717710e-02f, 1.92630123e-02f, 3.61899287e-02f, 1.07203081e-01f, 6.66146204e-02f, -2.39831693e-02f, 1.33570507e-01f, 1.33556694e-01f,
  8.49791840e-02f, 1.90563887e-01f, 8.98667276e-02f, 1.42393142e-01f, 1.50257707e-01f, 6.07685558e-02f, 9.45877358e-02f, 3.39225903e-02f, 1.36393040e-01f, 7.20832422e-02f,
  5.85527234e-02f, 1.17162973e-01f, 6.95604682e-02f, 1.25508890e-01f, 9.28579122e-02f, 1.26914203e-01f, 1.47199035e-01f, 1.23578303e-01f, 1.56873778e-01f, 5.76561354e-02f,
  -1.79996416e-02f, 5.55842295e-02f, -4.95764837e-02f, -2.25643385e-02f, -3.36952135e-02f, -6.31183237e-02f, 1.52074080e-03f, -9.16779637e-02f, -1.37185812e-01f, 4.28793617e-02f,
  -3.12788039e-02f, 7.62043819e-02f, -5.79237267e-02f, -1.34446239e-03f, -5.01678288e-02f, -9.49274302e-02f, -1.04030870e-01f, -5.47489263e-02f, -7.53483325e-02f, -1.69963002e-01f,
  -1.24091908e-01f, -8.61840695e-02f, 2.35106796e-02f, -4.48745266e-02f, -1.11672349e-01f, 6.21668249e-02f, -1.20081544e-01f, 4.52213846e-02f, 6.92336634e-02f, -1.72920302e-01f,
  -2.78962284e-01f, -2.57047862e-01f, 2.55757958e-01f, 8.33513141e-02f, 2.36307010e-01f, 4.50406782e-02f, -1.31678030e-01f, -2.17906207e-01f, -3.78052779e-02f, -3.85095142e-02f,
  6.11662604e-02f, 1.78938180e-01f, 1.32630259e-01f, 1.61397815e-01f, -5.69096133e-02f, 1.26480445e-01f, 3.01248372e-01f, 2.90133476e-01f, 1.66001126e-01f, -8.94763246e-02f,
  1.10682778e-01f, -1.69287801e-01f, -2.51839906e-01f, -1.27017453e-01f, -1.83663815e-02f, 4.46446091e-02f, -4.37945575e-02f, -3.80743258e-02f, 2.58441940e-02f, 3.04324955e-01f,
  4.50257242e-01f, -1.15534462e-01f, 1.41110808e-01f, 8.55604261e-02f, 4.97053303e-02f, -1.35008863e-03f, -1.06117755e-01f, -5.52856661e-02f, -1.75278261e-02f, 3.23359407e-02f,
  1.57079965e-01f, -8.33232328e-03f, 1.73134655e-01f, 4.94158790e-02f, 3.73082086e-02f, -3.13071385e-02f, 1.36614740e-02f, -2.71818284e-02f, 8.90490860e-02f, 2.29194444e-02f,
  1.17775172e-01f, 1.85605749e-01f, 8.49099085e-02f, -2.16224361e-02f, 1.32119760e-01f, 1.99573353e-01f, 3.79997119e-02f, -8.15098826e-03f, 7.73337334e-02f, -1.53450176e-01f,
  -5.45069501e-02f, -4.88149300e-02f, -1.02267824e-01f, -1.30199984e-01f, -5.78890070e-02f, -5.80982130e-04f, 2.45246887e-02f, -4.65181395e-02f, -7.28884935e-02f, -1.83800250e-01f,
  8.51977710e-03f, -1.12851165e-01f, -5.63863702e-02f, -1.72998860e-01f, -2.92144697e-02f, -1.36138409e-01f, -5.68181537e-02f, -1.12675048e-01f, -5.73521256e-02f, -1.17036752e-01f,
  -2.78938375e-02f, -2.59666014e-02f, -4.74617444e-02f, -8.29811990e-02f, -1.19029768e-01f, -9.40675382e-03f, -1.59819886e-01f, -9.33795273e-02f, -1.52376369e-01f, -1.15915306e-01f,
  4.39659730e-02f, 2.59563595e-01f, 1.45234056e-02f, -5.27466414e-03f, 8.42739344e-02f, 2.07015453e-03f, 5.06102182e-02f, 3.63794491e-02f, 1.17444672e-01f, -3.74370664e-02f,
  3.20288613e-02f, 1.23314641e-01f, 6.70810267e-02f, 1.69097222e-02f, 5.84365800e-02f, 5.87460259e-03f, 9.10320086e-04f, 1.75241545e-01f, 8.92046988e-02f, -1.72831118e-02f,
  -2.04874855e-02f, 4.62295040e-02f, 5.11997007e-02f, 8.91633853e-02f, 8.33525434e-02f, 1.59634560e-01f, 3.65894884e-02f, 1.01193070e-01f, 8.13931972e-02f, -2.19176590e-01f,
  -2.99995840e-01f, -5.09086922e-02f, 4.70704585e-02f, -1.81485027e-01f, 1.55425012e-01f, 1.74930826e-01f, -1.84329897e-02f, -7.78821856e-02f, -1.31852299e-01f, -9.64148343e-02f,
  3.30178261e-01f, 3.15437675e-01f, 9.31170583e-02f, 2.37162098e-01f, -2.28594653e-02f, -3.96339506e-01f, -4.22508717e-01f, -2.50409782e-01f, -2.09110789e-02f, 2.74618834e-01f,
  6.23958260e-02f, -3.32933366e-01f, -2.56945729e-01f, -6.78735077e-02f, -2.95562260e-02f, 1.16363861e-01f, 1.70161817e-02f, 1.26566214e-03f, 2.26382896e-01f, -1.32215515e-01f,
  2.31434554e-01f, 9.44797918e-02f, 1.78306058e-01f, 5.20986468e-02f, 1.07897721e-01f, -6.96771545e-03f, 6.80137575e-02f, -8.49552378e-02f, -2.39997404e-03f, -9.68195200e-02f,
  1.17865510e-01f, 7.91813508e-02f, -4.32624668e-02f, 5.80297485e-02f, -5.63652441e-02f, 8.78034905e-02f, -8.75591561e-02f, -1.21735401e-01f, -7.52429664e-02f, 3.53595912e-02f,
  1.26259267e-01f, 4.73295152e-02f, 1.22154824e-01f, -4.58631963e-02f, 2.01858263e-02f, 1.33247569e-01f, 1.73835270e-02f, 1.42612800e-01f, 1.04002498e-01f, -1.99620947e-01f,
  5.51617779e-02f, -3.25025879e-02f, 7.41925836e-02f, -1.13213947e-02f, 1.02288853e-02f, 6.38243482e-02f, -4.84440289e-02f, 7.53628016e-02f, -2.18517054e-02f, -6.48337184e-03f,
  4.43045236e-02f, -4.36032470e-03f, 1.69424433e-02f, -6.15272962e-04f, 1.63360685e-02f, -2.10740343e-02f, -2.93187443e-02f, -6.10040165e-02f, -2.42880434e-02f, 3.34122404e-03f,
  6.41779741e-03f, 5.08689843e-02f, 3.51226516e-03f, -5.22256903e-02f, 1.09470924e-02f, 2.80616935e-02f, -3.88565734e-02f, 1.13040619e-01f, -2.66960617e-02f, -3.63811068e-02f,
  -3.88424098e-02f, 1.77088886e-01f, -9.71784368e-02f, -5.97482212e-02f, 8.99894983e-02f, 5.25562540e-02f, 1.19163796e-01f, -2.90285554e-02f, 5.43963052e-02f, 3.55549343e-03f,
  6.84469193e-02f, 3.04656867e-02f, -1.14654414e-02f, 2.12291926e-02f, 6.22771904e-02f, -2.34584212e-02f, -3.09520308e-02f, 9.52360686e-03f, -2.63742432e-02f, 4.40152548e-03f,
  -1.55289665e-01f, -1.19590759e-01f, -1.20750228e-02f, 1.31635170e-04f, 5.35953678e-02f, -1.09171078e-01f, -1.71877611e-02f, -3.96566950e-02f, 1.77772138e-02f, -2.78918475e-01f,
  1.79266423e-01f, 6.85957819e-02f, 3.21798712e-01f, 2.70843990e-02f, 1.04638658e-01f, 1.72112584e-01f, 2.71123260e-01f, -1.87236797e-02f, -1.78941205e-01f, 1.85758308e-01f,
  2.18112059e-02f, -1.82950065e-01f, -6.54210988e-03f, -1.16849326e-01f, -3.60236280e-02f, 2.27488756e-01f, 2.26799652e-01f, 2.61881322e-01f, 4.12401296e-02f, 1.22566447e-01f,
  -5.07318377e-02f, -2.16524571e-01f, -2.10414097e-01f, -9.40466523e-02f, 7.64794126e-02f, -6.01820350e-02f, -3.72279361e-02f, -2.97607891e-02f, 1.54857766e-02f, 2.58043826e-01f,
  2.95541465e-01f, 7.47463629e-02f, 1.66238949e-01f, -1.09386584e-02f, 1.42504141e-01f, 1.11777559e-01f, 7.69726485e-02f, 7.55258277e-02f, 1.13134747e-02f, 8.54915008e-03f,
  -8.21702778e-02f, 3.95459756e-02f, 1.08006477e-01f, -7.78770894e-02f, -7.51031116e-02f, 4.10324410e-02f, -6.82160407e-02f, 9.62810293e-02f, 1.05692193e-01f, 6.75054565e-02f,
  -3.46000455e-02f, -3.74617241e-02f, -3.27310674e-02f, 2.53578015e-02f, -1.68208424e-02f, 8.50617513e-02f, -4.02800404e-02f, -1.08753987e-01f, -1.06711062e-02f, -2.29062270e-02f,
  1.55006558e-01f, 4.14378941e-02f, 1.79095492e-02f, 5.00628799e-02f, -1.13628373e-01f, 4.20195647e-02f, -2.09480356e-02f, -5.31832464e-02f, -3.84538956e-02f, -9.74410102e-02f,
  -8.35541189e-02f, 1.19517408e-01f, 2.34425180e-02f, 2.79923398e-02f, -6.73623309e-02f, -1.75745357e-02f, -3.89119275e-02f, -6.30123019e-02f, -6.65669516e-02f, -3.15616280e-02f,
  -1.88242868e-02f, 5.88643085e-03f, 9.55042765e-02f, -3.31385434e-02f, 5.89987859e-02f, -1.77215114e-02f, -2.62433644e-02f, -5.90511560e-02f, -3.20849195e-02f, -4.26557809e-02f,
  -2.38872692e-01f, 6.83531389e-02f, 1.50011048e-01f, -1.38502298e-02f, 4.48205881e-02f, 4.16575819e-02f, 1.73132885e-02f, 5.49788470e-04f, 8.98907520e-03f, -1.28475844e-03f,
  -2.46284250e-02f, -2.39919834e-02f, -4.50163186e-02f, -5.33410646e-02f, -4.89950506e-03f, -1.83702856e-02f, -4.68273200e-02f, 2.58422457e-02f, 2.68989112e-02f, -2.84037758e-02f,
  -7.75236450e-03f, -6.78460002e-02f, 2.64032837e-02f, -2.03398746e-02f, 1.24467090e-02f, 1.31958231e-01f, 2.12472491e-02f, 6.05800226e-02f, 9.11510289e-02f, 8.67339075e-02f,
  -3.94320607e-01f, 1.16371296e-01f, -1.07078729e-02f, -2.30065286e-01f, 1.60316706e-01f, 2.26832092e-01f, 3.42730999e-01f, 1.16689734e-01f, -1.74932942e-01f, -8.53053108e-02f,
  -1.22380368e-01f, -1.25344172e-01f, -1.28292665e-01f, 2.80045029e-02f, 1.46611422e-01f, 1.44893482e-01f, 2.87976295e-01f, 1.33913308e-01f, -5.17303310e-02f, 9.18607712e-02f,
  1.93022117e-01f, -8.70066285e-02f, -1.49122715e-01f, -3.85102183e-02f, -2.82987719e-03f, -2.17151016e-01f, -7.67440200e-02f, 6.44402727e-02f, 1.50823787e-01f, 1.11369833e-01f,
  -1.56326890e-01f, 8.13294761e-03f, -8.04312676e-02f, -1.18587404e-01f, -3.66180129e-02f, -6.79738075e-02f, -6.79331794e-02f, -1.15737617e-02f, 7.60255530e-02f, 9.41459388e-02f,
  2.92986985e-02f, 5.61521435e-03f, 6.04148116e-03f, 8.09915662e-02f, 8.89588334e-03f, 5.60897663e-02f, 8.34238753e-02f, 6.12786524e-02f, 4.25605066e-02f, 5.08821234e-02f,
  1.30355701e-01f, 3.79471146e-02f, 9.06104594e-02f, 1.02019534e-01f, 6.93960488e-02f, 1.44512340e-01f, 1.05230644e-01f, 9.04988721e-02f, 6.13871962e-02f, -1.17167220e-01f,
  -1.93367898e-02f, 3.04879528e-02f, 9.19255167e-02f, 3.47330794e-02f, 6.36864603e-02f, -1.02533378e-01f, -1.29942885e-02f, -6.01116009e-03f, 3.61956246e-02f, -4.76968437e-02f,
  5.35439141e-02f, 2.05791108e-02f, 3.71273514e-03f, -7.26804212e-02f, -9.56483632e-02f, 4.77329828e-02f, 6.12569135e-03f, -7.00559244e-02f, 3.03141233e-02f, -4.43493621e-03f,
  6.83487132e-02f, 1.18330449e-01f, 1.91701911e-02f, -5.18085398e-02f, 7.88564608e-02f, 6.45520464e-02f, 8.04226175e-02f, 8.02316740e-02f, 7.34916404e-02f, 5.27365953e-02f,
  -4.41453695e-01f, 2.90674388e-01f, -1.98756859e-01f, -3.01756151e-02f, -3.24078426e-02f, -3.14065702e-02f, -1.34766996e-01f, -2.87129544e-02f, -2.33456083e-02f, -2.67054811e-02f,
  9.59701091e-03f, -3.55603807e-02f, -3.54439802e-02f, 1.59500055e-02f, -1.02900416e-01f, -7.37668648e-02f, 1.05184384e-01f, -1.57379076e-01f, -2.19350476e-02f, -1.08843878e-01f,
  6.41758591e-02f, -8.09773207e-02f, -1.77847758e-01f, -1.23742633e-01f, -1.48326391e-02f, -1.56142697e-01f, -3.58740203e-02f, -1.08328447e-01f, -7.25908056e-02f, -2.41614968e-01f,
  -3.81156325e-01f, -1.49661779e-01f, -2.32685581e-01f, 2.17584029e-01f, 1.27518415e-01f, -1.53999716e-01f, -3.49849045e-01f, -2.49703620e-02f, 1.39082581e-01f, -2.14006871e-01f,
  -1.50153533e-01f, -1.49032757e-01f, -1.84734493e-01f, -1.50942951e-01f, -4.42112058e-01f, -4.90330935e-01f, -2.07874730e-01f, -3.23061734e-01f, -1.65434986e-01f, -3.49814855e-02f,
  -3.34855989e-02f, 7.40783066e-02f, -1.89557839e-02f, 7.91963190e-02f, 1.55126229e-02f, 1.32562682e-01f, 4.06822637e-02f, 4.88200560e-02f, -3.60908099e-02f, -4.55891974e-02f,
  -5.55002868e-01f, -1.50325060e-01f, -2.25752108e-02f, 7.32388813e-03f, -5.14642708e-02f, -1.01786017e-01f, -1.69676930e-01f, -9.94184334e-03f, 8.39237645e-02f, -4.70414571e-02f,
  -2.06569303e-02f, -9.03851725e-03f, -8.65062401e-02f, -3.02783307e-02f, -1.20609283e-01f, -1.09818093e-01f, 4.49082777e-02f, -4.22701500e-02f, -3.72980647e-02f, -1.27289161e-01f,
  -5.28539643e-02f, -9.67553779e-02f, -1.55262575e-01f, -2.24016570e-02f, -1.20819565e-02f, -8.73603150e-02f, -2.87864581e-02f, -6.98419884e-02f, -6.49377033e-02f, 1.44707803e-02f,
  1.17141038e-01f, 9.65380576e-03f, 4.41990122e-02f, 2.52126437e-02f, 9.34514254e-02f, 1.36769369e-01f, 6.21616803e-02f, -5.42025603e-02f, 3.56173106e-02f, 3.15082520e-02f,
  6.22871704e-02f, -2.75470931e-02f, 5.22198081e-02f, -4.29787859e-02f, -2.93500442e-02f, 2.11123023e-02f, 5.06335273e-02f, -9.23649892e-02f, 3.38628143e-02f, 9.37087685e-02f,
  -7.06772506e-03f, 9.54376757e-02f, 6.01463355e-02f, 2.38026306e-03f, -3.95638589e-03f, -4.69500525e-03f, -2.29285434e-02f, 1.89959761e-02f, 6.68743625e-02f, 3.64177935e-02f,
  1.11142598e-01f, -1.05700247e-01f, -8.36050957e-02f, -1.62812799e-01f, -9.93104465e-03f, -2.83070747e-02f, -2.12604124e-02f, -4.67263274e-02f, -3.64250913e-02f, -1.05042271e-01f,
  -5.99913932e-02f, -6.84953406e-02f, -1.61104828e-01f, -5.62297925e-02f, -5.89988790e-02f, -4.03814241e-02f, -1.76695079e-01f, -4.96394113e-02f, -7.75613934e-02f, -3.11741307e-02f,
  5.59480116e-03f, -7.68452585e-02f, -1.22190960e-01f, -1.48095101e-01f, -6.35093674e-02f, -1.74007341e-01f, -4.22060825e-02f, -4.72310111e-02f, -3.15272778e-01f, -6.99001700e-02f,
  -8.39482605e-01f, 1.84573531e-02f, -7.66902417e-02f, -1.84637249e-01f, 1.88638449e-01f, -7.06591681e-02f, -4.00406629e-01f, -1.26881257e-01f, -4.11028937e-02f, -1.20051555e-01f,
  2.78399199e-01f, 3.44160914e-01f, 2.58059472e-01f, 1.81021020e-01f, -9.20528695e-02f, -2.61749923e-01f, -2.42454454e-01f, -2.54696101e-01f, -1.22106671e-01f, 8.71447250e-02f,
  1.58865765e-01f, -1.94030493e-01f, -4.38130707e-01f, -4.61213812e-02f, -2.69337129e-02f, 1.02780551e-01f, -6.21939264e-02f, -1.00486822e-01f, 1.29489824e-01f, -1.13410555e-01f,
  9.81562808e-02f, -1.26982570e-01f, 1.09553456e-01f, 8.50666985e-02f, 8.64506662e-02f, -1.13370627e-01f, -8.17926303e-02f, -1.15939610e-01f, -1.71216466e-02f, -8.57933760e-02f,
  -6.98483288e-02f, 3.60467248e-02f, -8.10746327e-02f, 1.76469404e-02f, -1.11026555e-01f, -1.65126935e-01f, -1.72616601e-01f, -1.55993715e-01f, -4.66206856e-02f, 1.37435580e-02f,
  1.48215771e-01f, -6.70320913e-02f, -8.21484998e-02f, 3.39063928e-02f, -4.37188186e-02f, 9.81263518e-02f, 3.66483442e-02f, 5.42069934e-02f, -2.17543747e-02f, -2.30482399e-01f,
  6.61781207e-02f, 9.59753711e-03f, 9.88123845e-03f, -4.78167497e-02f, 6.89306390e-03f, 5.21593690e-02f, 3.47315222e-02f, 9.96548124e-03f, 4.70165774e-04f, -8.16673189e-02f,
  7.99559057e-03f, 6.66371221e-03f, -3.64159048e-02f, -1.13178328e-01f, 2.95930393e-02f, -1.90367289e-02f, -9.80802029e-02f, -5.96371442e-02f, 1.57826394e-02f, -9.95122269e-02f,
  1.96510050e-02f, -2.05383673e-02f, -3.11118905e-02f, -2.35549230e-02f, 1.43507114e-02f, 5.72526641e-03f, 2.20035063e-03f, 4.70302999e-02f, -5.53311892e-02f, -1.75440684e-02f,
  -2.01308444e-01f, 1.36454299e-01f, -1.01954758e-01f, -7.00737759e-02f, -1.59050897e-01f, -6.14779741e-02f, 2.25142483e-02f, -4.60109152e-02f, 8.43412429e-03f, -1.05238765e-01f,
  -7.72000700e-02f, -7.90452138e-02f, -2.06730179e-02f, -3.74471508e-02f, -1.64466366e-01f, -6.76317662e-02f, -6.31859992e-03f, -7.21995756e-02f, -2.33340710e-02f, -8.91331583e-03f,
  -9.47260857e-02f, -9.78688002e-02f, 1.12664150e-02f, -5.47048897e-02f, -3.29830088e-02f, 4.55029234e-02f, -4.42190804e-02f, -1.21656269e-01f, -9.85745713e-02f, -2.77053982e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.05035865e+00f, -9.86179486e-02f, -6.86059296e-01f, -2.90117085e-01f, 2.18921289e-01f, 3.19565266e-01f, 6.07950926e-01f, 1.27557233e-01f, -1.36651859e-01f, 2.52777450e-02f,
  1.80962875e-01f, 1.61070883e-01f, 7.44920745e-02f, 2.29089931e-01f, 2.03057408e-01f, 3.02705944e-01f, 1.85176730e-01f, -7.17359781e-02f, 2.02637091e-01f, 5.67690790e-01f,
  4.48435307e-01f, -1.49686798e-01f, -4.06532973e-01f, 1.93064027e-02f, -9.38717872e-02f, 1.27916753e-01f, -2.77254224e-01f, -2.63527066e-01f, 1.08114123e-01f, -2.80877680e-01f,
  -1.44912615e-01f, -6.21582270e-01f, 2.88978726e-01f, 1.04816787e-01f, -2.36108333e-01f, -8.77701677e-03f, 1.82979256e-02f, -2.79278606e-01f, -9.06228870e-02f, -7.42813200e-02f,
  -2.24305749e-01f, -3.20880115e-02f, 3.03906924e-03f, 5.18614277e-02f, -8.27805176e-02f, 8.44921097e-02f, -1.03409871e-01f, -1.25325337e-01f, -1.95047051e-01f, 1.02098718e-01f,
  4.39235866e-01f, -1.03978906e-02f, -5.25600374e-01f, -4.19408223e-03f, -3.15032303e-02f, 8.41131527e-03f, -1.06361225e-01f, -1.43509820e-01f, -2.02492237e-01f, -5.53586483e-01f,
  6.47448152e-02f, -1.14792407e-01f, -1.22357786e-01f, -8.79517943e-02f, 1.76719986e-02f, -1.17026985e-01f, 4.60785180e-02f, 1.31197125e-01f, 4.08190414e-02f, -1.00120872e-01f,
  7.20149279e-02f, 5.14949337e-02f, -2.02589445e-02f, 1.09489402e-02f, -4.58439812e-04f, -9.12764445e-02f, 1.03893526e-01f, -1.03759736e-01f, 8.56358856e-02f, -2.70727836e-02f,
  -1.72269659e-03f, -8.98331255e-02f, -2.28963152e-01f, 1.16007566e-01f, 9.01211277e-02f, 6.42262548e-02f, 5.20760790e-02f, 2.72735972e-02f, 7.31260749e-03f, -2.04164073e-01f,
  1.22478791e-02f, -3.76851676e-04f, -2.46937588e-01f, 6.06929101e-02f, -1.17833592e-01f, -2.08262801e-01f, -2.91701220e-02f, 3.46789472e-02f, -1.00334175e-01f, -5.48558496e-03f,
  8.82839113e-02f, -2.26242527e-01f, -1.44666180e-01f, 5.11456542e-02f, 1.12072021e-01f, -1.31182849e-01f, 5.54829203e-02f, 8.73584375e-02f, 1.30085990e-01f, -2.32967302e-01f,
  -7.98457116e-02f, 4.18151394e-02f, -2.02072263e-01f, -1.55596301e-01f, -1.22707270e-01f, 1.85958687e-02f, -2.80585080e-01f, 2.02352591e-02f, -2.17502952e-01f, -1.95528269e-01f,
  -5.12468517e-01f, 3.13818663e-01f, -2.10126951e-01f, -1.57302484e-01f, 1.82200417e-01f, 5.67977466e-02f, 3.95299435e-01f, 1.01942383e-01f, 1.26754194e-01f, 4.41872776e-01f,
  4.16864127e-01f, -3.95068526e-01f, -3.79930049e-01f, -4.59643215e-01f, -7.73531199e-01f, -1.70283854e-01f, -4.45107698e-01f, -7.57469058e-01f, -1.10642779e+00f, -3.09292108e-01f,
  -9.73863974e-02f, -3.77085775e-01f, -6.42766178e-01f, -2.16378152e-01f, 2.86833078e-01f, -1.92279175e-01f, 1.94370076e-01f, -1.76948294e-01f, -1.93942383e-01f, 1.07106037e-01f,
  1.36788085e-01f, 1.57082565e-02f, 1.31345198e-01f, -3.68251279e-02f, 2.63542831e-01f, -1.11572176e-01f, 2.76046130e-03f, 5.33668771e-02f, 4.59465533e-02f, -2.13070557e-01f,
  9.84741896e-02f, 1.42700106e-01f, -1.88866004e-01f, -6.80035576e-02f, -1.90320790e-01f, -2.33992547e-01f, -3.61313641e-01f, -2.20604777e-01f, -2.70929664e-01f, -9.06993672e-02f,
  -3.17594737e-01f, -7.02299923e-02f, -3.31102222e-01f, 7.68752173e-02f, 9.72649157e-02f, 1.08326413e-01f, 6.20632172e-02f, 1.70544803e-01f, 2.65899394e-02f, 4.24306691e-01f,
  1.65322974e-01f, 3.30115817e-02f, -6.88465387e-02f, 9.45045575e-02f, -5.60863018e-02f, 1.93430796e-01f, 1.61399646e-03f, 1.12208068e-01f, 7.61718303e-02f, 3.10908770e-03f,
  1.43972673e-02f, 1.22116096e-01f, 1.40923262e-01f, 1.61533002e-02f, -2.09964067e-01f, -1.62010252e-01f, -1.28001779e-01f, -7.14593604e-02f, -1.09968521e-02f, 1.69757549e-02f,
  -2.92434096e-01f, 3.04268241e-01f, 4.08212207e-02f, 2.19061375e-02f, -1.74504444e-01f, -7.75816888e-02f, 2.21362635e-02f, -1.20037116e-01f, 1.82062965e-02f, -1.59183860e-01f,
  -1.85570404e-01f, -3.15240771e-01f, 4.67001200e-02f, -1.30879626e-01f, -1.83819577e-01f, -6.92346692e-02f, 2.04831939e-02f, 6.90468624e-02f, 1.67797841e-02f, 6.10776665e-03f,
  3.66500542e-02f, 1.12273134e-01f, 3.18050347e-02f, 2.19130106e-02f, 1.33370340e-01f, 4.22004983e-02f, -1.35789186e-01f, -1.42485872e-01f, -3.07546943e-01f, -2.49341317e-03f,
  -1.27740890e-01f, -8.24978501e-02f, -2.03821883e-01f, 1.17152715e-02f, 1.72154188e-01f, -1.95784286e-01f, -5.29336110e-02f, 8.86223018e-02f, -4.67069298e-01f, 1.97877780e-01f,
  2.25896627e-01f, -5.03789246e-01f, -1.38859767e-02f, 4.49971288e-01f, -1.14600696e-01f, -5.63979268e-01f, -1.03978479e+00f, -3.52269500e-01f, 3.12152743e-01f, -8.73046666e-02f,
  -2.73750611e-02f, 4.60430771e-01f, 2.81812161e-01f, 1.77435815e-01f, -4.36212569e-01f, -2.90756047e-01f, 2.80429363e-01f, 2.58384794e-01f, 5.16524203e-02f, -1.23320021e-01f,
  3.41149151e-01f, 2.69284010e-01f, 1.89270973e-01f, -4.64771613e-02f, 4.00610059e-01f, 2.15786889e-01f, 1.10130154e-01f, 1.04802176e-01f, -1.30941197e-01f, 7.45058775e-01f,
  8.93720984e-02f, -1.22265413e-01f, 1.52644981e-02f, 2.64120698e-01f, 5.09407148e-02f, 9.91187990e-02f, -1.54700701e-03f, 1.84988245e-01f, -1.76964188e-03f, 4.58418019e-02f,
  2.45704234e-01f, 1.04922585e-01f, 1.51180729e-01f, 9.43730921e-02f, -2.94170946e-01f, -1.70122638e-01f, 1.30441695e-01f, -4.08690535e-02f, -8.89296085e-02f, -1.25132263e-01f,
  1.51322767e-01f, -7.37226158e-02f, -4.70019996e-01f, -3.53242338e-01f, -9.79389176e-02f, 2.28325576e-01f, -3.70600820e-01f, -7.61059746e-02f, -3.61256987e-01f, -7.21266540e-03f,
  -1.13841435e-02f, 7.30690919e-03f, 2.53927466e-02f, 3.27788107e-02f, -5.61168119e-02f, 2.64497809e-02f, 1.63215622e-01f, -6.85723871e-02f, 1.59753948e-01f, -9.10153426e-03f,
  3.79786803e-03f, 1.33664887e-02f, 5.96469380e-02f, -5.10574831e-03f, 1.04496330e-01f, -4.19116765e-02f, -6.72725737e-02f, -5.23248911e-02f, -7.75772408e-02f, 3.76735963e-02f,
  1.45464595e-02f, 4.70982566e-02f, 3.41577083e-02f, 5.47030345e-02f, -7.89327845e-02f, 6.71996772e-02f, 1.75539315e-01f, -5.55198602e-02f, 8.30663666e-02f, -1.00104161e-01f,
  -4.69796285e-02f, -1.29493818e-01f, 1.73722338e-02f, 6.03418946e-02f, -8.08625221e-02f, -2.06230935e-02f, 9.50091407e-02f, -6.10576458e-02f, -2.66466606e-02f, -2.46206224e-01f,
  -2.54085779e-01f, -9.15506855e-02f, -1.43828075e-02f, -3.44971828e-02f, -1.24120817e-01f, -3.70248966e-02f, -1.42375559e-01f, -1.06996588e-01f, -3.30803320e-02f, -1.24782458e-01f,
  -2.68235896e-02f, -4.76008236e-01f, -4.22907293e-01f, -4.54337299e-01f, 1.99446711e-03f, -2.91833878e-01f, -3.88949275e-01f, -2.47561008e-01f, -6.23891354e-01f, -8.73424053e-01f,
  -6.53255105e-01f, -6.73583508e-01f, 9.81549770e-02f, -3.57654810e-01f, -3.40110481e-01f, -1.82438210e-01f, -8.99216831e-01f, 1.67246349e-02f, 2.20087826e-01f, -6.70835137e-01f,
  -2.94038296e-01f, 2.19142392e-01f, -1.18776925e-01f, 9.83856693e-02f, 1.53259775e-02f, -6.37887955e-01f, -3.30282897e-01f, 2.78383106e-01f, 6.08413041e-01f, 1.82646528e-01f,
  -1.02346189e-01f, -2.28339434e-02f, 5.03353357e-01f, 4.00279671e-01f, -4.42235261e-01f, -1.15990989e-01f, -3.00239921e-01f, -2.24371776e-01f, -1.74343795e-01f, -8.98566306e-01f,
  -4.18971241e-01f, -9.52255502e-02f, 2.40920275e-01f, -1.99134469e-01f, -1.87509030e-01f, -1.92815326e-02f, -1.67188540e-01f, 5.21643683e-02f, 1.35856524e-01f, -1.38151050e-02f,
  8.18926394e-02f, 1.60534039e-01f, -2.49375384e-02f, 7.98774287e-02f, -4.08656755e-03f, -5.22456206e-02f, 1.71301052e-01f, 1.39151827e-01f, -1.25163212e-01f, -1.72604561e-01f,
  -1.97253972e-01f, -2.20164612e-01f, 2.35208254e-02f, 1.99973896e-01f, 2.11594731e-01f, 1.89925715e-01f, 1.38029933e-01f, 2.22783431e-01f, 2.86038101e-01f, -5.40803850e-01f,
  -2.26528980e-02f, 2.85047926e-02f, 4.12060693e-02f, 1.37643754e-01f, 5.75603507e-02f, -8.06958601e-03f, 4.41264249e-02f, -1.18622229e-01f, 3.00466437e-02f, 1.30327325e-02f,
  6.67131087e-03f, -9.17058289e-02f, 5.67176566e-02f, -5.72511777e-02f, -6.14386518e-03f, 8.26947540e-02f, -3.78141105e-02f, 6.05866052e-02f, 3.20216902e-02f, -1.08122781e-01f,
  -4.64345189e-03f, 6.30499125e-02f, -3.58243361e-02f, 1.29740641e-01f, -5.59952483e-02f, -4.98985872e-02f, 1.96475349e-02f, 2.48119142e-02f, 5.84178604e-02f, -4.68101203e-02f,
  -1.74639031e-01f, 3.54843974e-01f, -3.65511745e-01f, 1.52162556e-02f, 1.01619497e-01f, 3.38179134e-02f, -9.49787274e-02f, 1.81698725e-01f, 1.56723969e-02f, -9.45817530e-02f,
  1.30339727e-01f, 3.35835442e-02f, -7.41829053e-02f, 4.77673262e-02f, 8.27857703e-02f, 1.64801970e-01f, -1.02078997e-01f, -1.46497071e-01f, 1.26913130e-01f, 3.35208923e-02f,
  1.38789508e-02f, -4.32473011e-02f, -2.89359778e-01f, -3.58625166e-02f, 3.78744900e-02f, -2.11683214e-01f, -1.86117038e-01f, -2.22459510e-01f, -1.39932185e-01f, -5.47099590e-01f,
  1.16124952e+00f, -5.61417222e-01f, -6.22969091e-01f, 3.55599254e-01f, 3.42917107e-02f, 1.17373839e-01f, 2.16286872e-02f, 2.49919966e-01f, 3.51190895e-01f, -1.68862253e-01f,
  -2.43715141e-02f, 2.96249270e-01f, 4.16459031e-02f, 2.30262093e-02f, 5.93458749e-02f, -2.60612786e-01f, -2.85852551e-01f, 8.95103142e-02f, 5.86594403e-01f, 3.61709386e-01f,
  -6.91866875e-02f, 7.48130158e-02f, 6.07393496e-02f, 1.51164666e-01f, -2.84122854e-01f, 1.62440255e-01f, -5.17835081e-01f, -3.05878371e-01f, -2.97190964e-01f, -6.33147180e-01f,
  -1.42284378e-01f, -2.01973110e-01f, 2.03100845e-01f, 6.79563209e-02f, -9.56221744e-02f, 7.72283450e-02f, 6.39713332e-02f, -1.61431551e-01f, -3.59562412e-02f, -1.28751233e-01f,
  -1.35906907e-02f, 1.40409276e-01f, 1.12189300e-01f, -8.61916021e-02f, -7.23765045e-02f, -5.94323035e-03f, -1.83185458e-01f, -1.03610761e-01f, -1.29134908e-01f, -1.64965659e-01f,
  -2.46131942e-01f, 2.42865346e-02f, -7.78981252e-03f, -7.56045282e-02f, 1.13967843e-01f, 1.05219558e-01f, -1.41484216e-01f, 2.14395858e-02f, -2.68013738e-02f, -2.70483524e-01f,
  1.99289694e-02f, -5.24665974e-02f, 5.51420003e-02f, 3.70799787e-02f, 5.94848208e-02f, 1.24823034e-01f, 2.89565474e-02f, 8.01460519e-02f, 1.26614690e-01f, 3.99028063e-02f,
  4.51215617e-02f, 1.06452946e-02f, 4.51893881e-02f, -4.96955030e-02f, -1.24343343e-01f, -8.32104832e-02f, -1.09033510e-01f, -7.94082135e-02f, -2.06602085e-02f, 9.43246111e-02f,
  4.89152931e-02f, 1.66439205e-01f, -5.40833585e-02f, -3.42602096e-02f, -1.60947353e-01f, -3.08638848e-02f, 5.12747094e-03f, -1.15614995e-01f, 1.34303227e-01f, -1.19739380e-02f,
  -1.93985049e-02f, 1.47157922e-01f, 1.64547399e-01f, 1.32069603e-01f, -1.26948714e-01f, -7.17597976e-02f, -1.61712617e-02f, -3.85269187e-02f, -1.19304538e-01f, -2.35906560e-02f,
  -5.60535118e-02f, 7.74418190e-02f, -8.47061649e-02f, -8.16322044e-02f, 1.94529250e-01f, 4.72849458e-02f, -4.29344438e-02f, 1.17887355e-01f, -3.02629229e-02f, -6.06725737e-02f,
  -4.74463962e-02f, 1.94467410e-01f, 3.37719023e-01f, 1.66647032e-01f, 1.52323678e-01f, 3.62076670e-01f, 1.18324347e-01f, 2.76868735e-02f, 1.65803596e-01f, 1.75002545e-01f,
  -1.09224379e+00f, -2.08016470e-01f, 6.10480487e-01f, -8.82662609e-02f, 2.11531788e-01f, 2.77326673e-01f, 3.95304590e-01f, 2.79499423e-02f, -1.78745747e-01f, 4.46389727e-02f,
  -1.08683906e-01f, -6.06097542e-02f, 1.12393215e-01f, 5.91978244e-02f, 4.95328009e-03f, 2.24983379e-01f, 1.79053709e-01f, 2.03576073e-01f, 3.24671388e-01f, 2.41347447e-01f,
  1.20274022e-01f, 2.03562360e-02f, -2.46980771e-01f, -5.96808828e-02f, 8.07318613e-02f, 1.87492490e-01f, 1.20101444e-01f, 3.54710259e-02f, 1.11295572e-02f, 2.00724199e-01f,
  6.30744994e-01f, -2.80880630e-01f, 2.40383267e-01f, -1.23252153e-01f, -1.01257689e-01f, -1.36688918e-01f, 9.64147970e-02f, -2.75131837e-02f, -1.22715116e-01f, -9.03013814e-03f,
  -2.66377702e-02f, -7.86264166e-02f, -4.03063335e-02f, -6.04092516e-02f, -3.82950641e-02f, -7.82433748e-02f, -2.87406892e-01f, -1.18383721e-01f, 4.49017249e-02f, 3.29473913e-02f,
  -1.59012794e-01f, -2.26392392e-02f, 8.91814232e-02f, -2.98753008e-02f, -1.92652032e-01f, 1.77864283e-02f, 3.26135382e-03f, -1.31973922e-01f, -1.11075528e-01f, -2.36007422e-02f,
  1.15346424e-01f, 1.22901045e-01f, 6.13353513e-02f, 4.12290432e-02f, -4.10304591e-02f, -6.68542646e-03f, 1.37599736e-01f, 2.16859698e-01f, -1.43926088e-02f, -1.73509773e-02f,
  3.12605686e-02f, 2.60632932e-02f, 7.24816099e-02f, -1.14681786e-02f, 2.13285703e-02f, -1.06826676e-02f, 1.86572932e-02f, -1.41988974e-02f, -1.48176089e-01f, -2.93367624e-01f,
  -1.12151355e-01f, 4.07174826e-02f, -7.37656727e-02f, 1.26508502e-02f, -7.72626400e-02f, -1.05313629e-01f, 8.49982798e-02f, -1.31676316e-01f, -2.44958457e-02f, 6.38147071e-02f,
  3.53710502e-01f, -3.29824954e-01f, 1.79872304e-01f, -6.16057143e-02f, -8.24784301e-03f, -1.48912147e-01f, -4.57832552e-02f, 1.26445554e-02f, -3.52026150e-02f, 4.99885827e-02f,
  3.84793319e-02f, 1.99497677e-02f, -5.65280654e-02f, 4.12739143e-02f, 1.32721961e-01f, -6.01800112e-03f, -1.43797904e-01f, 1.04920112e-01f, 8.11883807e-02f, 1.45594493e-01f,
  -4.44674641e-02f, 1.65903255e-01f, 3.89766634e-01f, 2.71866024e-01f, 1.07174687e-01f, 1.85130820e-01f, 3.53428364e-01f, 1.56536520e-01f, 1.91112325e-01f, 1.88221931e-01f,
  1.22553885e+00f, 4.61135894e-01f, 5.65766096e-01f, 1.71994999e-01f, -2.32017517e-01f, -3.64689082e-02f, 1.56595245e-01f, 7.28829056e-02f, 4.80117537e-02f, 1.02141954e-01f,
  1.47470847e-01f, -7.87071884e-04f, 3.09563074e-02f, -7.04454929e-02f, 1.58693746e-01f, -3.86892892e-02f, -2.24521905e-01f, 8.69704187e-02f, 2.28634760e-01f, 8.81140530e-02f,
  -2.72105575e-01f, -5.16023412e-02f, 1.98411852e-01f, -5.01420489e-03f, -2.75880676e-02f, -1.41422227e-01f, 4.72156182e-02f, -1.07229389e-01f, 3.93855423e-02f, -1.20673003e-02f,
  3.97897810e-01f, 6.79742754e-01f, 6.55248389e-02f, -5.17190844e-02f, 3.44943479e-02f, -1.99900046e-02f, 2.84808762e-02f, -1.31234247e-02f, -6.00183234e-02f, -1.40303731e-01f,
  -1.76036432e-02f, -2.59187026e-03f, -1.59145799e-03f, -9.55628008e-02f, -1.81710064e-01f, 6.00489564e-02f, 2.79306937e-02f, 8.80185738e-02f, 4.17181328e-02f, 1.51975410e-05f,
  -9.47108790e-02f, 3.65608707e-02f, 9.98847932e-02f, -4.93053384e-02f, 1.89467549e-01f, 5.39804026e-02f, 5.90967797e-02f, 1.10023826e-01f, 1.57863703e-02f, 5.82512356e-02f,
  1.31151065e-01f, -1.88169014e-02f, -3.82075049e-02f, 2.00480390e-02f, -1.47404891e-04f, -2.26701535e-02f, -7.33290659e-03f, -1.33171499e-01f, -1.81756057e-02f, 6.92707077e-02f,
  -1.95234299e-01f, -2.96148844e-02f, 1.65295377e-01f, 7.25049153e-02f, -4.57351729e-02f, -8.54063630e-02f, 3.59686241e-02f, 2.63734031e-02f, -3.15784919e-03f, -1.36050999e-01f,
  1.08323008e-01f, 9.32210169e-05f, 2.17034426e-02f, -2.23307330e-02f, -1.12456419e-01f, 7.98985437e-02f, 6.27518967e-02f, -7.50041455e-02f, -8.73012021e-02f, -1.12863600e-01f,
  -2.30645254e-01f, 2.89066046e-01f, 9.83182564e-02f, 4.03051302e-02f, -4.29587252e-02f, 1.18173882e-02f, 1.90252751e-01f, 9.84576158e-03f, -5.51108792e-02f, -2.45018955e-02f,
  8.90267044e-02f, 1.48856714e-01f, 9.28230286e-02f, -5.76248281e-02f, -3.39249969e-02f, -4.53756414e-02f, 2.37731952e-02f, 1.59830943e-01f, 3.00211739e-02f, 7.41566569e-02f,
  -4.68631871e-02f, 3.55230197e-02f, 1.57605022e-01f, 8.94126147e-02f, 2.99224649e-02f, -5.20620644e-02f, -4.77793962e-02f, 8.91935155e-02f, 4.40342352e-02f, -1.68088764e-01f,
  2.34912887e-01f, 5.30675173e-01f, 1.73133954e-01f, 4.19977158e-01f, 3.47147197e-01f, 3.58569026e-01f, 3.44724685e-01f, 3.26584280e-01f, 1.99711367e-01f, 2.04890445e-01f,
  3.31438035e-01f, 2.27548301e-01f, 2.79617786e-01f, 1.72334835e-01f, 2.37310752e-01f, 3.15714091e-01f, 1.08294062e-01f, 2.65849251e-02f, 6.34079287e-03f, 7.32022971e-02f,
  2.51150101e-01f, 2.37757921e-01f, 8.20727274e-02f, 1.29347369e-01f, 2.52464771e-01f, 1.15788028e-01f, 1.21289290e-01f, 1.25511378e-01f, 2.78889269e-01f, 2.02567875e-01f,
  -1.28045559e-01f, 5.85464537e-02f, -2.48469204e-01f, -2.33109090e-02f, -1.48666278e-01f, -2.77298719e-01f, -9.88481268e-02f, -8.16751346e-02f, -1.51055932e-01f, -1.05389960e-01f,
  -9.82215777e-02f, -1.04744695e-01f, 1.81931823e-01f, -6.18040822e-02f, -1.30073622e-01f, -2.14899942e-01f, -1.45293653e-01f, 5.22994660e-02f, 7.93571547e-02f, -4.91973907e-02f,
  1.66528776e-01f, 1.37022585e-02f, -1.27990106e-02f, 6.31337091e-02f, 2.94508040e-01f, -2.76335981e-03f, -3.29821780e-02f, 1.60999112e-02f, 7.58177834e-03f, 2.48232391e-02f,
  4.35816079e-01f, 2.91940808e-01f, 2.56164134e-01f, 5.48339188e-02f, 1.05895177e-01f, -3.33618335e-02f, -3.71658094e-02f, 9.81560871e-02f, 1.85327113e-01f, 9.38934237e-02f,
  -2.83610802e-02f, -7.93456007e-03f, -6.40571341e-02f, -6.76554665e-02f, 3.96667235e-03f, 1.34766661e-03f, -1.24906786e-01f, -2.27848198e-02f, -8.19217488e-02f, -1.18689919e-02f,
  1.35736898e-01f, -1.52043588e-02f, -3.73276733e-02f, 8.73617362e-03f, -7.67382607e-02f, 4.49149497e-03f, 7.54112452e-02f, 8.08753446e-02f, 1.40876425e-02f, -2.28565149e-02f,
  -1.29872307e-01f, 5.83379641e-02f, -9.36100259e-02f, -2.51899310e-03f, -1.72277465e-02f, -7.32488781e-02f, 7.86937922e-02f, -8.00023451e-02f, -1.84794858e-01f, -7.77214020e-02f,
  3.11020985e-02f, 4.67720218e-02f, 1.46769181e-01f, 6.74341694e-02f, -1.09596528e-01f, -7.26115108e-02f, -8.44426975e-02f, -3.05457599e-02f, -1.55702839e-02f, -9.97890905e-02f,
  4.04624902e-02f, -1.54480308e-01f, -1.87584132e-01f, 3.23362760e-02f, 1.69404522e-02f, -6.81160241e-02f, -6.29621968e-02f, -1.72862887e-01f, -8.99142772e-02f, -8.83127749e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.97873944e-01f, 8.61365139e-01f, 6.92945600e-01f, 2.34868184e-01f, 5.50532460e-01f, 8.82761925e-02f, 2.03045085e-01f, 4.22052473e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.63877428e-02f, 5.40232845e-02f, -2.02465393e-02f, 1.17378034e-01f, -1.86423749e-01f, -2.59434313e-01f, -9.01401192e-02f, 1.12123445e-01f, -1.43742695e-01f, -4.38798293e-02f,
  -1.40974030e-01f, 3.39898616e-01f, 4.88261245e-02f, 1.63244039e-01f, 1.59085661e-01f, 8.59764293e-02f, 6.97313100e-02f, 5.67296781e-02f, 1.85753450e-01f, 4.00073916e-01f,
  2.32001301e-03f, -1.06832951e-01f, -9.11456123e-02f, 2.63659120e-01f, 3.96665096e-01f, -3.49733829e-02f, -2.94044465e-01f, 3.82025421e-01f, 1.86944962e-01f, -3.80276322e-01f,
  1.25016645e-02f, 2.07403541e-01f, -9.03553516e-02f, -8.67444575e-02f, 8.59896392e-02f, 1.28519773e-01f, 3.34349781e-01f, -1.45704046e-01f, 1.67012125e-01f, 4.37271409e-02f,
  2.11945418e-02f, -8.68210644e-02f, 2.42629692e-01f, 1.21341519e-01f, -3.18103790e-01f, -2.39341617e-01f, -3.73123050e-01f, 2.30663270e-01f, -4.89484966e-02f, 1.36356086e-01f,
  1.39693394e-02f, -1.77196726e-01f, 4.66883145e-02f, -5.91669008e-02f, -7.00868666e-02f, -1.55773729e-01f, 4.79091346e-01f, -3.20020728e-02f, -3.87754738e-01f, 1.55613273e-01f,
  6.04825139e-01f, -2.09225312e-01f, -4.87399250e-02f, 2.07680762e-01f, -1.12837717e-01f, -5.31288087e-02f, 1.17175780e-01f, 1.12391576e-01f, 6.08693510e-02f, -1.96888745e-02f,
  1.22564971e-01f, 1.51282758e-01f, -9.86629352e-02f, 9.12163127e-03f, 3.07082478e-02f, 3.88762988e-02f, 7.90801889e-04f, -8.45567614e-04f, -3.44822168e-01f, 1.32484779e-01f,
  -1.11866340e-01f, 1.66039057e-02f, -8.06417316e-03f, -3.99869634e-03f, -1.05564192e-01f, -3.83776836e-02f, 5.01346439e-02f, 2.76159912e-01f, 5.44969440e-01f, -9.00030509e-02f,
  -2.35113785e-01f, 3.60852808e-01f, 3.75006348e-01f, 1.71059266e-01f, -1.11743025e-01f, -1.03466228e-01f, -9.13208816e-03f, 4.25633043e-01f, 2.03695476e-01f, -8.36993009e-02f,
  -4.21362609e-01f, 1.59564182e-01f, -1.37891591e-01f, -4.89987917e-02f, -3.91978711e-01f, -2.44660750e-01f, -2.93488413e-01f, 8.08675066e-02f, 4.80809242e-01f, -2.70090014e-01f,
  -1.00286283e-01f, -6.42132163e-01f, 5.47943786e-02f, 2.66563296e-01f, -1.42410353e-01f, 1.78074822e-01f, -3.02126080e-01f, -2.52949297e-01f, -5.82797639e-02f, 3.00215762e-02f,
  -3.24360371e-01f, -2.14216653e-02f, 6.11064397e-03f, 7.18585923e-02f, -1.24157093e-01f, 7.70495981e-02f, 8.89983922e-02f, -6.85977265e-02f, 7.74849728e-02f, 1.22785024e-01f,
  -1.18118957e-01f, 7.61916190e-02f, 1.02238417e-01f, -6.13960400e-02f, 1.05701774e-01f, -1.59570873e-02f, 1.84940211e-02f, -4.96255867e-02f, -1.31135955e-01f, -5.82423843e-02f,
  4.61437255e-01f, -3.21891457e-02f, -1.06061481e-01f, -1.02774382e-01f, 1.68351725e-01f, -4.97179478e-02f, -5.54039069e-02f, 1.67568773e-01f, -1.37209922e-01f, -3.60472500e-02f,
  -2.79171970e-02f, 2.36613065e-01f, 6.91682637e-01f, -2.50904262e-02f, -2.94404328e-01f, 3.00348222e-01f, 1.10875785e-01f, -8.01208094e-02f, -9.55609307e-02f, -1.65656283e-01f,
  -3.88503559e-02f, 2.06988111e-01f, 2.19416767e-01f, 1.14937887e-01f, 2.59514123e-01f, 9.50285718e-02f, 2.25476876e-01f, 2.42834777e-01f, 1.18460797e-01f, 1.47384271e-01f,
  1.44145146e-01f, 7.58426636e-02f, -2.80129880e-01f, -2.87478268e-01f, -2.36080401e-02f, 1.18513547e-01f, 3.13314162e-02f, 1.57872438e-01f, -2.04284303e-02f, -1.89093933e-01f,
  1.66969106e-01f, -1.46134198e-01f, -2.03236639e-01f, -2.79499620e-01f, -5.33271849e-01f, -2.49389596e-02f, 1.24626808e-01f, -9.11434516e-02f, 1.17952652e-01f, 2.81287432e-01f,
  1.36865020e-01f, -1.28283590e-01f, -1.59606233e-01f, -7.97182173e-02f, -3.91984768e-02f, -1.94052786e-01f, 2.07233485e-02f, 1.41828850e-01f, 6.55872077e-02f, -9.67672020e-02f,
  -2.46461913e-01f, -9.50565115e-02f, -3.59908827e-02f, -4.51731905e-02f, -4.33418602e-02f, -1.43633321e-01f, -2.88476974e-01f, -2.59316452e-02f, 4.61389720e-02f, 4.71796915e-02f,
  -9.08269584e-02f, 3.72486152e-02f, 6.75239414e-02f, -1.33662641e-01f, -8.36021900e-02f, 1.27643704e-01f, 4.56110835e-01f, 2.65878253e-02f, -5.05272150e-01f, 1.61310405e-01f,
  2.82609850e-01f, 2.80995011e-01f, -2.56446987e-01f, 4.10418026e-02f, -1.29537702e-01f, 1.66388988e-01f, -7.07031488e-02f, -1.38035361e-02f, -1.98775500e-01f, -7.17546493e-02f,
  -2.01375205e-02f, 1.87304646e-01f, -1.61164045e-01f, 1.19818099e-01f, -5.97208142e-02f, 9.83474851e-02f, 2.00715527e-01f, -2.99693763e-01f, -2.14709029e-01f, -1.45529315e-01f,
  -1.06931455e-01f, 5.45793734e-02f, -6.88695954e-03f, 5.25222905e-03f, -8.81514177e-02f, -1.17781095e-01f, -1.38227329e-01f, 9.01795998e-02f, -1.47789598e-01f, -1.44907013e-01f,
  -1.09648362e-01f, 4.84724313e-01f, 2.67712295e-01f, -1.90726966e-01f, -1.46661699e-01f, -3.81837040e-02f, 1.46306396e-01f, -1.78188607e-02f, 2.13623241e-01f, 2.30805371e-02f,
  3.77103575e-02f, 1.39036193e-01f, 7.82875810e-03f, -7.60113373e-02f, 1.84257075e-01f, -1.50082722e-01f, 1.90736745e-02f, -5.20150699e-02f, 3.37589234e-01f, 1.26558498e-01f,
  -5.08189723e-02f, -2.74765901e-02f, 1.92229956e-01f, -6.15360914e-03f, -2.54387334e-02f, 4.64806110e-02f, -1.24214813e-01f, 4.73677665e-02f, 1.37366936e-01f, -1.03678718e-01f,
  2.92672396e-01f, 5.54287255e-01f, 2.13776916e-01f, -1.45745024e-01f, -3.46136987e-01f, -3.48187327e-01f, -7.18805492e-02f, 9.07584950e-02f, 1.14379421e-01f, -3.36223766e-02f,
  -1.21740885e-02f, 3.72756124e-02f, -2.05810592e-01f, -6.31815642e-02f, -1.01788387e-01f, -1.61329322e-02f, 7.45948553e-02f, -2.56876238e-02f, -2.97588911e-02f, 6.92279637e-02f,
  7.67231435e-02f, -9.88291055e-02f, 1.46064693e-02f, -1.49317816e-01f, -1.65273353e-01f, -8.27240720e-02f, 7.65161663e-02f, 2.07324833e-01f, 5.16744517e-02f, 1.43157735e-01f,
  1.57641038e-01f, 3.57292265e-01f, 3.81009698e-01f, -3.61959279e-01f, 1.42970636e-01f, 5.15745938e-01f, 1.07619934e-01f, 1.32750005e-01f, 1.52052149e-01f, -8.37358311e-02f,
  -2.67484710e-02f, 2.28209764e-01f, 1.92696065e-01f, -1.42826021e-01f, 1.45667009e-02f, 1.27282590e-01f, -1.61991090e-01f, -2.46101785e-02f, -6.94371834e-02f, -5.00935912e-02f,
  1.14350818e-01f, 2.12560281e-01f, 6.59246743e-01f, -2.04797179e-01f, -2.12396398e-01f, -3.81140739e-01f, 6.90961955e-03f, 1.79458573e-01f, -9.85841155e-02f, -3.06048021e-02f,
  -2.81291425e-01f, -2.18913257e-01f, 1.57604381e-01f, -1.44072130e-01f, -1.68053508e-01f, 1.29180714e-01f, 1.30072877e-01f, -3.35816264e-01f, -2.84341574e-01f, -3.04195359e-02f,
  -1.65090576e-01f, 1.44553185e-01f, -1.07927293e-01f, 1.00643679e-01f, -2.66660806e-02f, 3.04323770e-02f, -1.75708421e-02f, 2.31629908e-02f, -1.98692409e-03f, -1.02207609e-01f,
  -5.69231361e-02f, -5.19800931e-02f, 1.19487517e-01f, -1.43166007e-02f, 2.72906303e-01f, 2.02409595e-01f, 5.02670407e-02f, -4.98662293e-02f, 1.08234070e-01f, -4.04385924e-02f,
  -3.25283525e-03f, -7.56995156e-02f, -2.54406810e-01f, -2.38380823e-02f, 1.06360547e-01f, -1.28644094e-01f, -3.09476107e-01f, 2.95786023e-01f, 1.00393437e-01f, -4.51857209e-01f,
  -2.82021075e-01f, 1.10218078e-01f, 2.60655880e-01f, 8.79314318e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.89594293e-01f, 3.16182554e-01f, 2.35216841e-01f, 4.72018868e-01f, 2.43820906e-01f, -1.12342713e-02f, 3.39042455e-01f, 2.73262799e-01f, 2.84384731e-02f, 1.16724849e-01f,
  2.64310777e-01f, 4.04441774e-01f, 1.45590752e-01f, -1.02508329e-01f, 3.79580170e-01f, 2.01202720e-01f, -8.65437239e-02f, 1.43861875e-01f, -2.41402626e-01f, -3.63632172e-01f,
  1.98732033e-01f, -5.84901989e-01f, -1.35678813e-01f, -5.70722044e-01f, 2.56950319e-01f, 2.62622740e-02f, 7.78746068e-01f, -1.94103152e-01f, 9.84040201e-01f, 5.29054403e-02f,
  7.87352771e-03f, 7.11888850e-01f, 3.02638978e-01f, 3.10894072e-01f, -3.60861532e-02f, 1.25014698e-02f, -2.77643025e-01f, -5.43672359e-03f, 1.96356460e-01f, 7.92834312e-02f,
  -3.36478986e-02f, 1.58100218e-01f, -2.57086188e-01f, 2.77691215e-01f, 2.68902004e-01f, -5.54540515e-01f, 5.71322888e-02f, -7.81998515e-01f, -3.48090827e-01f, 1.59021676e-01f,
  1.79352373e-01f, 3.59601736e-01f, -1.09908640e-01f, -4.16906029e-01f, -2.30167452e-02f, 2.41493449e-01f, -4.65943158e-01f, 3.82003607e-03f, 1.10606730e+00f, 9.45913136e-01f,
  3.25226635e-01f, -4.39549774e-01f, 4.00875449e-01f, 8.22022408e-02f, 2.40121186e-01f, 1.39913214e-02f, -1.99222207e-01f, 6.89511240e-01f, 3.19750071e-01f, 1.93442583e-01f,
  1.70372635e-01f, 1.91531882e-01f, 1.29565746e-01f, -5.84810711e-02f, 2.47669309e-01f, 2.21456736e-01f, -1.69458594e-02f, 2.85219699e-01f, -4.37305599e-01f, 2.59073883e-01f,
  6.76763773e-01f, 4.75252755e-02f, -1.98913500e-01f, 2.83104032e-01f, -1.62709862e-01f, -3.23939836e-03f, 1.53646693e-02f, 1.71353474e-01f, 4.60422814e-01f, 6.61054373e-01f,
  -5.59349120e-01f, 6.23488367e-01f, 3.49885434e-01f, -7.76684463e-01f, 1.84119239e-01f, 4.19397086e-01f, 2.29812533e-01f, 5.16129673e-01f, 4.81110752e-01f, -7.38651156e-02f,
  -3.52752954e-01f, 2.57695436e-01f, 2.11574569e-01f, 4.69497472e-01f, 3.42256784e-01f, 3.94665271e-01f, -2.72517264e-01f, 3.00893277e-01f, 6.43726349e-01f, 5.79951108e-01f,
  -1.22237109e-01f, -6.62848413e-01f, 1.42122582e-01f, -1.37303263e-01f, 2.00210929e-01f, 9.74640429e-01f, -4.42796797e-02f, -1.42630309e-01f, -1.09245837e-01f, 8.42637002e-01f,
  -1.81038767e-01f, 5.68512082e-01f, 5.52048385e-01f, 2.26966664e-01f, -4.70885575e-01f, 4.61149752e-01f, -8.36551428e-01f, -1.47443712e-01f, 4.52638954e-01f, 2.33497992e-02f,
  5.81103921e-01f, 5.36210716e-01f, -9.38016698e-02f, -3.98554951e-01f, 1.23047821e-01f, 8.81042182e-02f, 9.09531474e-01f, -9.66576301e-03f, 3.45744491e-01f, 2.80724734e-01f,
  -5.72789252e-01f, 8.49521339e-01f, 4.93196577e-01f, -1.30646735e-01f, -8.30347061e-01f, -3.80993575e-01f, 3.98405403e-01f, -1.90845087e-01f, 1.01305723e-01f, 8.92598331e-01f,
  5.46910107e-01f, 4.04823512e-01f, 2.69626349e-01f, 1.78317964e-01f, 6.03198111e-01f, 3.32269907e-01f, -1.29914844e+00f, -5.68615198e-01f, -5.01358747e-01f, 2.23424911e-01f,
  6.70833047e-03f, 3.65467578e-01f, 2.43893057e-01f, 2.44198274e-02f, 2.30297342e-01f, 1.13573857e-01f, 1.05946045e-02f, 2.67221779e-01f, 4.06941801e-01f, -1.16787300e-01f,
  1.24421805e-01f, 5.05331635e-01f, 9.34280396e-01f, 4.31889117e-01f, 1.24181218e-01f, -3.53076458e-01f, 2.07018644e-01f, -1.70392916e-01f, 4.16165471e-01f, 2.65026629e-01f,
  2.10482627e-01f, -3.44677657e-01f, 3.85955215e-01f, 9.07528222e-01f, 4.86265570e-01f, 3.95117491e-01f, 2.76607245e-01f, -8.13210189e-01f, -3.12897444e-01f, 5.05770743e-01f,
  -1.70240745e-01f, -3.24390046e-02f, 1.55672461e-01f, 2.15445295e-01f, 4.79860753e-01f, 2.63695531e-02f, 2.03127503e-01f, 4.26082671e-01f, 3.11757147e-01f, 1.69198066e-01f,
  -1.04733355e-01f, 3.75618994e-01f, 2.34359995e-01f, 2.62753427e-01f, -1.28936246e-01f, -7.10446775e-01f, -1.11056305e-01f, 1.14916392e-01f, -3.89658898e-01f, 3.04605458e-02f,
  1.99595373e-03f, -4.03588027e-01f, 4.78064269e-02f, -4.90710735e-02f, 2.07826450e-01f, -6.15699887e-01f, -3.65222432e-02f, -1.91467628e-01f, 1.01228666e+00f, 3.41143340e-01f,
  8.61808360e-01f, -2.39065498e-01f, 2.44363561e-01f, -3.87467563e-01f, 1.52636468e-01f, 3.37168127e-01f, 7.43015468e-01f, 4.27903175e-01f, 1.81582063e-01f, 2.90748328e-01f,
  -9.65128765e-02f, 2.33869739e-02f, 6.14987314e-02f, -1.26540244e-01f, 7.48495897e-03f, -1.23433456e-01f, 2.26278305e-01f, 1.76263042e-02f, -8.22431564e-01f, 4.21409190e-01f,
  5.61161637e-01f, -4.36719209e-01f, -4.26514387e-01f, -5.55732667e-01f, -8.40677798e-01f, -1.66170951e-02f, 2.22983584e-01f, -3.52678522e-02f, 8.66420925e-01f, 9.24466789e-01f,
  -6.05001934e-02f, 1.99325368e-01f, -2.22026303e-01f, -7.19248056e-01f, -3.27248782e-01f, 9.60342214e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.72276610e-01f, -2.10927669e-02f, 2.42591679e-01f, 1.45434197e-02f, 6.60213053e-01f, 2.25604832e-01f, 3.81433129e-01f, 2.96734631e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -5.25602281e-01f, -8.33999459e-03f, -3.19068849e-01f, -2.94616580e-01f, -5.23573458e-01f, -2.48673871e-01f, -4.06855047e-01f, -4.30937082e-01f, -2.92912126e-01f, -3.24230403e-01f,
  3.78490537e-02f, -1.10156544e-01f, -3.95927399e-01f, -1.02522366e-01f, -6.56185508e-01f, 4.60209101e-01f, -2.97139674e-01f, -7.62249887e-01f, 6.06849313e-01f, 5.80111444e-01f,
  5.15850961e-01f, -1.83738962e-01f, 3.17526489e-01f, -2.27519140e-01f, -4.83153492e-01f, 3.52724463e-01f, 2.42298037e-01f, 6.56003552e-03f, -9.08652186e-01f, -6.62055969e-01f,
  2.74359882e-01f, 3.55771810e-01f, -3.24176252e-01f, -5.46806216e-01f, -5.11255443e-01f, 2.69863307e-01f, -8.55177104e-01f, -2.33193234e-01f, 2.53099978e-01f, -7.50962853e-01f,
  -5.92782237e-02f, -2.96340019e-01f, 3.58256072e-01f, -6.22098148e-01f, 1.06209707e+00f, 2.55009472e-01f, 3.01032037e-01f, 2.95652419e-01f, 4.21294838e-01f, 5.50870836e-01f,
  4.16166842e-01f, 1.85287148e-01f, -7.24705398e-01f, 8.48032773e-01f, -1.91989169e-01f, -9.88930762e-01f, 3.60559046e-01f, 4.23240751e-01f, 4.94417012e-01f, -1.32680714e+00f,
  -1.37321675e+00f, -2.16924891e-01f, 1.12437651e-01f, -5.92626214e-01f, 2.10417449e-01f, 3.05497497e-01f, 2.40474731e-01f, 1.47346467e-01f, 3.55216771e-01f, -1.07240520e-01f,
  -3.02649856e-01f, -6.57894492e-01f, 1.11958466e-01f, -1.06004083e+00f, -5.92481270e-02f, -5.85297227e-01f, 1.06577156e-03f, -3.59242447e-02f, 7.18311369e-01f, 2.11789191e-01f,
  -7.34611526e-02f, -7.25809708e-02f, -6.02808893e-01f, 6.52202785e-01f, 2.37292007e-01f, -2.39072010e-01f, 2.92089671e-01f, -1.19505775e+00f, -4.07260358e-01f, 3.92775863e-01f,
  -4.32538658e-01f, -1.86966583e-01f, 3.59318823e-01f, -7.87151754e-01f, 4.14455593e-01f, -4.55952644e-01f, -1.31682545e-01f, 4.46624458e-01f, -4.60694611e-01f, -3.93066555e-01f,
  -1.03714205e-01f, -5.60905576e-01f, 8.44129473e-02f, 5.97792089e-01f, -3.33707839e-01f, 1.05039805e-01f, -1.58343241e-01f, 4.67985690e-01f, -2.36242026e-01f, 5.50852656e-01f,
  8.82628679e-01f, -9.83268142e-01f, 4.70750593e-03f, 9.81247425e-02f, 5.60414135e-01f, -8.43063414e-01f, 2.29038280e-02f, 6.97439432e-01f, -1.28540850e+00f, -1.02001667e+00f,
  -1.07502282e+00f, -1.00394619e+00f, 3.58735681e-01f, 3.86809697e-03f, 4.56139028e-01f, 9.31326523e-02f, -7.93365240e-01f, 4.17611659e-01f, 1.08499099e-02f, 3.16007882e-01f,
  4.70718056e-01f, 1.90988392e-01f, 1.68524444e-01f, 3.27816188e-01f, 8.80136073e-01f, 4.68789130e-01f, 2.59565264e-01f, 2.33621895e-01f, -2.58051634e-01f, 7.68774152e-02f,
  8.91533494e-02f, -1.28198767e+00f, -8.61898363e-02f, 4.94967908e-01f, 7.23365903e-01f, -5.25024474e-01f, -6.27324164e-01f, 5.50794661e-01f, -5.82480133e-01f, -5.11351191e-02f,
  2.35376254e-01f, 8.49732041e-01f, -7.20788166e-02f, 3.45725447e-01f, -1.27986684e-01f, 4.85557199e-01f, -1.20416358e-01f, -8.64996612e-02f, -9.16953444e-01f, 1.52465314e-01f,
  3.95218730e-01f, -2.81993866e-01f, 4.33199048e-01f, 1.89154118e-01f, 3.66540402e-01f, 5.37364304e-01f, 8.03251386e-01f, 3.80278856e-01f, -1.96501881e-01f, 2.47093424e-01f,
  -1.07150465e-01f, 1.03461218e+00f, 1.84829071e-01f, 6.92370713e-01f, 9.67478335e-01f, 2.62898147e-01f, 8.08117568e-01f, 4.20306891e-01f, 2.43833467e-01f, 7.99814701e-01f,
  5.98872423e-01f, -8.49995613e-01f, 1.26143694e+00f, 6.97670102e-01f, 6.84668645e-02f, -3.90771538e-01f, 1.97039053e-01f, -6.02814734e-01f, -9.74813700e-01f, 9.56493020e-02f,
  2.18284696e-01f, 5.61095595e-01f, -4.41225410e-01f, 2.38555238e-01f, -4.42270160e-01f, 2.14532658e-01f, -8.41016844e-02f, -1.23555437e-01f, -7.33355105e-01f, 2.80492038e-01f,
  6.58763587e-01f, 4.79025632e-01f, 3.98215175e-01f, -2.97422349e-01f, -5.70606053e-01f, -6.41727984e-01f, -8.33593845e-01f, 6.19448535e-02f, -1.74665749e-01f, 6.86285675e-01f,
  -2.55932629e-01f, -3.85860234e-01f, 7.07692653e-02f, 5.18298566e-01f, 5.52410424e-01f, 8.04056346e-01f, -1.01163059e-01f, 4.32963520e-01f, -8.19478631e-01f, -1.65492141e+00f,
  4.73951288e-02f, -7.93646097e-01f, 3.01047444e-01f, -1.15632176e+00f, -3.32567602e-01f, -2.18454227e-01f, 2.24984184e-01f, -4.60459441e-01f, -5.54913431e-02f, -6.92547262e-01f,
  3.38214964e-01f, -7.74726331e-01f, -1.54390961e-01f, -8.06943059e-01f, -3.23089868e-01f, 2.52755463e-01f, 2.23644197e-01f, -9.14962217e-02f, 1.42276987e-01f, 2.17933267e-01f,
  -5.48029952e-02f, -6.83372676e-01f, 7.43990391e-02f, 1.90033659e-01f, 3.55033129e-01f, 1.15282938e-01f, -4.36035335e-01f, -3.59219909e-02f, 2.94410944e-01f, -5.64871907e-01f,
  -7.38719821e-01f, -3.78493547e-01f, 7.53249049e-01f, 4.48264569e-01f, -1.05297577e+00f, -4.44600871e-03f, 1.48162827e-01f, -4.60264534e-01f, 7.65999779e-02f, -1.73166767e-01f,
  3.59016567e-01f, -5.28999567e-01f, 6.54578432e-02f, 3.04928571e-01f, -2.63493985e-01f, 1.70099169e-01f, -4.00207996e-01f, -2.88714170e-02f, -7.94824362e-01f, 5.86580455e-01f,
  4.28947031e-01f, -5.68182111e-01f, -6.67196035e-01f, -3.92536819e-01f, 2.89269924e-01f, 5.82312159e-02f, -8.79418910e-01f, -5.55540085e-01f, -7.03085899e-01f, -6.81773663e-01f,
  5.04191518e-01f, -8.20236683e-01f, -1.11225152e+00f, -5.36090374e-01f, -3.96184891e-01f, -4.04267520e-01f, 5.07831454e-01f, -1.03787422e+00f, 5.25800526e-01f, -4.80715752e-01f,
  4.50320661e-01f, 1.85188338e-01f, 3.48408997e-01f, 5.15774488e-01f, -4.07248706e-01f, -9.17745084e-02f, -9.88472223e-01f, -1.18073501e-01f, -2.17574939e-01f, -1.05220579e-01f,
  -1.68975189e-01f, -8.51526141e-01f, -1.03631759e+00f, -7.80047551e-02f, -5.74540615e-01f, -3.57273668e-01f, -2.08097726e-01f, -6.24203444e-01f, -8.40261206e-02f, 6.04655564e-01f,
  4.48036313e-01f, 2.54643559e-01f, -2.35395804e-01f, -1.32433670e-02f, -1.18239009e+00f, 2.94442356e-01f, 3.91343951e-01f, 6.13503993e-01f, -3.64010152e-03f, -5.29493213e-01f,
  3.42718065e-02f, 5.00885487e-01f, -3.97735417e-01f, 4.01814640e-01f, -2.59586424e-01f, -2.63209075e-01f, 1.17159477e-02f, 3.28898460e-01f, 3.78346860e-01f, 3.32427084e-01f,
  5.08187294e-01f, 6.06855035e-01f, -6.82345152e-01f, 4.74509634e-02f, 3.43769640e-01f, 4.22984749e-01f, 8.90382290e-01f, 6.24074638e-01f, 6.45642817e-01f, -8.37681144e-02f,
  1.51837721e-01f, -3.93720120e-01f, 3.84171516e-01f, 2.22727805e-01f, -3.74998510e-01f, -1.23342609e+00f, -3.09743077e-01f, 1.23199463e+00f, -1.09788120e+00f, 7.03693151e-01f,
  -5.18761694e-01f, -3.83188844e-01f, 1.55264482e-01f, 3.53017569e-01f, 6.09353334e-02f, -2.64801621e-01f, -1.80687189e-01f, 4.30033028e-01f, -5.54289043e-01f, 4.69561666e-02f,
  6.77420259e-01f, 6.56068325e-01f, 4.72321399e-02f, -3.20866466e-01f, 9.76284921e-01f, 7.03049242e-01f, -1.13163972e+00f, -5.18022716e-01f, -9.54736233e-01f, 6.05208278e-01f,
  -7.11212695e-01f, -6.36013925e-01f, 4.52666640e-01f, -8.06187272e-01f, -4.22968924e-01f, 9.96367812e-01f, 6.28171936e-02f, -4.64692235e-01f, 8.56686294e-01f, -3.41332406e-01f,
  -1.24698617e-01f, -6.61214888e-01f, -6.37618661e-01f, -2.45951265e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.94452524e-01f, -3.69293451e-01f, -1.63500234e-01f, 2.35908240e-01f, 1.54418677e-01f, 1.89886153e-01f, 5.92294559e-02f, 2.19526380e-01f, -2.36695763e-02f, -2.83914745e-01f,
  -2.73971647e-01f, 2.11863250e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    