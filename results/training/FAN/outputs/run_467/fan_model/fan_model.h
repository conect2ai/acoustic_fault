/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.25192147e-01f, 8.32787231e-02f, 2.25153044e-01f, -1.35899484e-01f, -1.14178866e-01f, -3.19375664e-01f, -7.84267932e-02f, -7.92413428e-02f, 1.82845350e-02f, 1.18745692e-01f,
  -2.15590850e-01f, 9.39904153e-02f, 8.28426257e-02f, -1.49155483e-01f, -4.04094249e-01f, 7.47305080e-02f, -1.85010567e-01f, -2.74437889e-02f, 6.42569438e-02f, -1.50389969e-01f,
  -7.30407164e-02f, -1.38679609e-01f, 1.37361735e-01f, 1.79003309e-02f, -1.42330565e-02f, 1.02992188e-02f, -1.69287756e-01f, 2.72734277e-02f, 4.57536206e-02f, -1.50154352e-01f,
  -4.01453115e-02f, 8.41690898e-02f, 1.66343674e-02f, 5.55755906e-02f, -9.37313512e-02f, -2.12676898e-02f, 3.03071272e-02f, -2.05448251e-02f, -3.80047038e-02f, 2.00224090e-02f,
  -3.29348110e-02f, 2.41091698e-02f, -9.92410351e-03f, 2.66542062e-02f, 3.75034139e-02f, 8.08292702e-02f, 7.10677281e-02f, 1.98014956e-02f, 1.19677909e-01f, 8.60988051e-02f,
  1.68036848e-01f, 4.78137732e-02f, 7.42110014e-02f, 8.42432082e-02f, 4.80363406e-02f, 3.33973020e-03f, -8.55385326e-03f, -4.72379476e-03f, -4.93964851e-02f, -7.81401098e-02f,
  -2.95080303e-04f, 6.85135275e-02f, 1.98276769e-02f, 2.08941568e-02f, 4.89716530e-02f, 2.31353976e-02f, -3.08576655e-02f, -1.78369079e-02f, 4.09069993e-02f, 6.13021702e-02f,
  -1.72836613e-02f, -1.12976041e-02f, -4.34244014e-02f, 1.03712678e-01f, -1.13905361e-02f, 1.67717766e-02f, 5.02195070e-03f, -5.88206686e-02f, 5.26084527e-02f, 4.30878811e-02f,
  -1.16820922e-02f, 4.04271530e-04f, -5.13887256e-02f, 6.31384959e-04f, -3.98969091e-03f, 3.31302825e-03f, 4.08329405e-02f, 6.74316240e-03f, -7.26422220e-02f, -6.77582994e-02f,
  -1.01431847e-01f, -1.43140450e-01f, 3.26609313e-02f, 2.70485971e-02f, -2.92388536e-02f, 4.29439470e-02f, -2.42885631e-02f, 1.69355497e-02f, -6.27709925e-03f, -2.89283916e-02f,
  -2.11273283e-02f, 4.60744984e-02f, -5.77690490e-02f, -7.30656611e-04f, -4.20955159e-02f, -5.87945618e-02f, -9.88401473e-02f, 6.02544611e-03f, -6.46670312e-02f, -1.16420485e-01f,
  4.68799984e-03f, -1.34100765e-01f, -1.43900616e-02f, 4.00305819e-03f, 1.51120303e-02f, -6.02445612e-03f, -1.03365928e-01f, 1.05971219e-02f, -3.33089195e-02f, 5.44121563e-02f,
  -2.19141364e-01f, 3.30943495e-01f, 4.84397449e-03f, 2.12257966e-01f, -1.58714727e-01f, 1.72504783e-01f, 1.40011087e-01f, 1.00433551e-01f, 1.12256058e-01f, 1.22943036e-01f,
  3.50721776e-02f, -8.88546556e-03f, 1.86188027e-01f, 1.72698244e-01f, 2.86069244e-01f, 2.39577964e-01f, 1.80420473e-01f, 6.05555139e-02f, 8.04731771e-02f, 4.77220528e-02f,
  4.76214960e-02f, 1.39562294e-01f, 1.37896702e-01f, 3.81148383e-02f, -5.30386195e-02f, -2.73940936e-02f, 4.31341156e-02f, -7.64296576e-02f, -4.86654080e-02f, 7.84179848e-03f,
  -2.16273945e-02f, 3.09903622e-02f, -4.57815640e-02f, -4.12820987e-02f, 6.37864694e-02f, -7.96809793e-02f, -2.01384258e-02f, 8.57715681e-02f, -4.22916003e-02f, -2.51234788e-02f,
  -4.96084169e-02f, -1.01832151e-02f, 6.17383011e-02f, 3.58150639e-02f, -1.06287085e-01f, -2.64425818e-02f, 4.60501481e-03f, 2.24604998e-02f, 1.33053306e-02f, 4.24016975e-02f,
  3.72004360e-02f, -2.94968318e-02f, -2.20079720e-02f, 9.82025936e-02f, 3.10781877e-03f, -3.75207849e-02f, 8.30920413e-02f, -6.62802458e-02f, -4.90373522e-02f, 4.00495939e-02f,
  6.93434617e-03f, 1.11863978e-01f, -6.63036888e-04f, 2.09594332e-02f, 1.08453386e-01f, -6.50500804e-02f, 2.73737069e-02f, -4.33693081e-02f, 3.07451300e-02f, 2.41270605e-02f,
  6.98038284e-03f, -2.57392265e-02f, 7.22704902e-02f, -2.35382877e-02f, 3.24405804e-02f, 3.31723616e-02f, 1.14149274e-02f, -7.92706609e-02f, -1.00342445e-02f, -6.48559537e-03f,
  -6.43187319e-04f, 5.00102565e-02f, -4.37883027e-02f, -2.59920005e-02f, 3.07435426e-03f, -2.78966017e-02f, -2.31313501e-02f, -9.73570999e-03f, 1.67620629e-02f, 2.28310246e-02f,
  1.80191055e-01f, 1.44177109e-01f, 1.16003333e-02f, -8.51120986e-03f, -5.20210043e-02f, -3.60514894e-02f, 3.77451181e-02f, -4.64075208e-02f, 6.87635988e-02f, 1.10367239e-01f,
  -6.37775511e-02f, 5.55920191e-02f, -4.93427180e-02f, -7.77483806e-02f, 6.12435956e-03f, 5.36894426e-02f, 4.00300138e-02f, -2.77099591e-02f, -2.41845958e-02f, -2.04832293e-02f,
  -1.80955548e-02f, 7.96060115e-02f, -7.62807392e-03f, -3.42814289e-02f, -8.99455100e-02f, -8.04152340e-02f, -2.56188475e-02f, 1.22420667e-02f, -8.61372519e-03f, -5.48011884e-02f,
  -3.89324218e-01f, 7.48214200e-02f, -1.10074349e-01f, -1.45557627e-01f, -2.63669118e-02f, 4.10771519e-01f, 2.22082391e-01f, -4.30637971e-02f, 1.70631275e-01f, 2.81203717e-01f,
  -2.76037920e-02f, 1.69756159e-01f, 5.73255531e-02f, 2.67403483e-01f, 7.81634226e-02f, 1.66872829e-01f, 1.69534400e-01f, 1.09238744e-01f, -1.56678297e-02f, -1.22839093e-01f,
  -7.41166025e-02f, -4.92357835e-02f, -1.06241152e-01f, -1.96219936e-01f, -2.29014516e-01f, -2.46899799e-01f, -1.58328891e-01f, -7.63000622e-02f, -2.93100346e-03f, 4.55185622e-02f,
  -1.43676862e-01f, -1.21161617e-01f, -9.14474204e-03f, -1.23119436e-03f, -4.98494729e-02f, -9.38571151e-03f, -5.54610454e-02f, -5.89884222e-02f, -5.66506060e-03f, 1.70748122e-03f,
  7.10230842e-02f, -5.24825379e-02f, 3.80983427e-02f, -7.08411681e-03f, 2.74643470e-02f, 3.40775736e-02f, -3.84074938e-03f, -3.47057804e-02f, -1.12783491e-04f, -6.59800470e-02f,
  1.68458913e-02f, 3.28163779e-03f, -3.80891077e-02f, -6.97491392e-02f, -4.41935919e-02f, 3.36249210e-02f, 1.22890901e-02f, -1.48953171e-02f, 5.88193983e-02f, 1.60807781e-02f,
  -2.52481475e-02f, -2.08773781e-02f, -1.01011526e-03f, 9.08443797e-03f, -6.70020431e-02f, -9.90309864e-02f, 1.63081773e-02f, 4.10067141e-02f, -7.41358846e-02f, 1.62864197e-02f,
  -1.79196112e-02f, 3.62653546e-02f, -1.10500995e-02f, 5.02110682e-02f, -3.52406166e-02f, -1.56992842e-02f, -6.79910704e-02f, 3.18386666e-02f, 1.88670645e-03f, 1.20670469e-02f,
  3.65831889e-02f, 1.70721486e-02f, -6.39145542e-03f, -2.83266772e-02f, 4.40346524e-02f, -2.38731112e-02f, 6.19352795e-02f, -4.57031950e-02f, -2.24392337e-04f, -7.68369017e-03f,
  1.02542631e-01f, 5.60463220e-03f, 5.44449612e-02f, 6.54937848e-02f, 6.59058755e-03f, 3.53309661e-02f, 9.61918160e-02f, -6.43385053e-02f, -3.14547457e-02f, -6.14722911e-03f,
  1.97310280e-02f, 1.57627072e-02f, -1.80303212e-02f, -1.42804189e-02f, 1.52961556e-02f, -1.43913291e-02f, 8.85840971e-03f, -2.00713854e-02f, 4.40465249e-02f, -4.46395837e-02f,
  -6.01914488e-02f, 1.38495592e-02f, 8.65078792e-02f, -4.74848375e-02f, -3.84821673e-03f, -2.23406660e-03f, -4.72480133e-02f, -2.40148790e-02f, 6.12188466e-02f, 5.40105551e-02f,
  3.72122496e-01f, 1.45015433e-01f, 1.56973377e-01f, 3.51463497e-01f, -2.59649660e-02f, 1.45032043e-02f, 4.24045652e-01f, 2.06837300e-02f, -2.43609287e-02f, 6.72480091e-02f,
  1.05395414e-01f, 1.17918380e-01f, 6.41782656e-02f, 1.62357450e-01f, 5.48115224e-02f, -9.72847939e-02f, 1.58937246e-01f, 7.98709095e-02f, -1.06241167e-01f, 9.72760618e-02f,
  -4.42185020e-03f, 2.49600392e-02f, 1.94325402e-01f, -1.08474679e-01f, 1.76937774e-01f, -1.09618530e-01f, -5.27026355e-02f, 6.72144592e-02f, 5.66416159e-02f, 7.08457232e-02f,
  -2.94666849e-02f, -5.03097810e-02f, -3.22971754e-02f, -1.17530702e-02f, 4.72429730e-02f, 5.78150759e-03f, 6.24024197e-02f, 2.09649727e-02f, -6.78065270e-02f, 6.49637356e-02f,
  2.02400405e-02f, -3.91072631e-02f, -3.29245403e-02f, -6.87554106e-02f, -2.86830566e-03f, -1.46572432e-02f, -2.92945169e-02f, 6.02363236e-02f, 2.99626179e-02f, 1.05685862e-02f,
  -1.34091936e-02f, 6.40880987e-02f, 2.62178928e-02f, -5.88272698e-02f, 6.02944707e-03f, -4.99439053e-03f, 1.29581685e-03f, 7.83057362e-02f, 5.02881706e-02f, -9.07578021e-02f,
  -7.34538138e-02f, -7.55076557e-02f, -1.75623260e-02f, 1.20058970e-03f, -1.43611869e-02f, 5.94231039e-02f, -3.70226987e-02f, 1.86486002e-02f, -3.79676856e-02f, -3.04087140e-02f,
  5.16753979e-02f, -1.80259440e-02f, 3.68193933e-03f, -3.44927646e-02f, -4.42079604e-02f, -2.68658670e-03f, 2.32696198e-02f, 1.41069721e-02f, 4.85618450e-02f, 3.44474949e-02f,
  1.88617851e-03f, -5.85505441e-02f, -2.44019483e-03f, 6.28051013e-02f, -1.19875697e-02f, 2.79894341e-02f, -4.93578129e-02f, 2.08113380e-02f, 5.42005114e-02f, 5.99502623e-02f,
  6.85459375e-02f, 8.47547352e-02f, 1.46737667e-02f, 6.06417581e-02f, -5.28765656e-02f, -2.83633377e-02f, -5.27133867e-02f, -1.88365094e-02f, -1.57156233e-02f, -3.35888169e-03f,
  4.18726448e-03f, 4.75976914e-02f, 1.90150610e-03f, 4.32547294e-02f, -8.37499741e-03f, -2.21063700e-02f, 2.14958955e-02f, -2.56085414e-02f, 8.09265077e-02f, 7.33427517e-03f,
  1.20553449e-01f, -6.76982384e-03f, -8.62720907e-02f, -3.11012771e-02f, 4.05769832e-02f, 4.04199846e-02f, -5.42257205e-02f, -7.64995515e-02f, -2.45603640e-02f, 4.51449342e-02f,
  1.27547700e-02f, -3.98174763e-01f, -4.60155942e-02f, 6.32880628e-02f, 5.22983037e-02f, 4.12487417e-01f, 2.10901052e-01f, 3.31482701e-02f, 1.62076384e-01f, -2.13075504e-01f,
  1.66178063e-01f, -9.23514366e-02f, 1.05082817e-01f, 8.33037421e-02f, 5.40201426e-01f, 2.49873042e-01f, 2.67768621e-01f, -5.29053099e-02f, 1.32202357e-01f, -2.82465760e-03f,
  1.31841093e-01f, 2.78319597e-01f, 2.04551816e-01f, 2.36535771e-03f, -1.26828790e-01f, -1.86778933e-01f, -8.27362165e-02f, -5.05620316e-02f, -2.49824505e-02f, 2.81331427e-02f,
  1.07546844e-01f, -3.88677046e-02f, -1.00788116e-01f, 4.67457110e-03f, 3.08204368e-02f, -1.15650915e-01f, -8.33352879e-02f, -9.58645530e-03f, 4.46406305e-02f, -3.72759774e-02f,
  -8.35200399e-02f, 3.16292308e-02f, 5.34603931e-02f, 3.12422626e-02f, -3.69914435e-02f, -9.13341623e-03f, -4.72408123e-02f, -2.61979699e-02f, -5.61131071e-03f, -1.84671450e-02f,
  5.39092012e-02f, -6.22484535e-02f, -3.23740579e-02f, -3.93094644e-02f, 3.62639129e-02f, -2.73491796e-02f, 8.02235585e-03f, -9.79914740e-02f, 9.73278843e-03f, -3.17641534e-02f,
  -3.63993794e-02f, -3.55971642e-02f, 5.74192181e-02f, -1.32755265e-02f, 5.41737303e-02f, 6.28423365e-03f, 1.79009158e-02f, -6.10026019e-03f, -5.00303395e-02f, 8.62620305e-03f,
  -3.65268514e-02f, -8.87508132e-03f, -1.03480099e-02f, 4.53842729e-02f, 1.72091139e-04f, -4.31693867e-02f, -2.42261700e-02f, -1.81922223e-02f, 2.12400928e-02f, 1.47853000e-02f,
  -8.06620810e-03f, 1.04496181e-01f, -1.44566484e-02f, -6.32081851e-02f, 9.06534567e-02f, -1.07824914e-02f, 2.83801388e-02f, -7.44228661e-02f, -1.67046152e-02f, 4.87966165e-02f,
  -3.44846696e-02f, -1.03755295e-03f, 5.68273477e-03f, 1.78480651e-02f, -4.78796996e-02f, 7.77030317e-03f, 4.63707484e-02f, 8.56786873e-03f, 1.65786818e-02f, 1.30254999e-01f,
  -1.68711506e-02f, -3.51824276e-02f, -2.74471063e-02f, -1.19028473e-02f, 4.24579438e-03f, 5.30411527e-02f, -8.12324416e-03f, -4.92939092e-02f, 9.72734205e-03f, -2.71162298e-02f,
  -1.23641521e-01f, 5.90933906e-03f, 5.10603189e-02f, 7.36789629e-02f, 4.21440601e-02f, -6.93224147e-02f, -4.22946997e-02f, 2.94807628e-02f, -4.06753831e-03f, -6.13347115e-03f,
  -4.18213099e-01f, -2.25429252e-01f, -2.02159300e-01f, -2.17947721e-01f, 2.46196520e-04f, 1.77157208e-01f, 2.42354318e-01f, -1.89842343e-01f, -8.62416178e-02f, -1.97044909e-02f,
  1.60850734e-01f, -1.93498597e-01f, 1.88195989e-01f, -1.80703968e-01f, 1.05329551e-01f, 1.95843384e-01f, -1.75368488e-01f, -6.52271807e-02f, -9.87014920e-02f, -8.41499642e-02f,
  -3.22690904e-02f, 4.47291881e-02f, 9.20346007e-03f, -4.21174318e-02f, -9.46117416e-02f, -1.47133693e-01f, -4.09536287e-02f, 1.47306710e-01f, -1.31135732e-01f, -3.65289897e-02f,
  5.20241782e-02f, 8.73703435e-02f, -8.85813534e-02f, 2.02549752e-02f, 1.45558156e-02f, 2.16402095e-02f, -3.42866145e-02f, 1.34560153e-01f, -4.75457199e-02f, -7.72289513e-03f,
  3.33425067e-02f, -8.02022740e-02f, -5.59905469e-02f, -3.66663357e-04f, -1.99611727e-02f, -8.97912160e-02f, -7.41104707e-02f, -1.87370200e-02f, -4.54650447e-02f, -7.47926459e-02f,
  -1.83602534e-02f, -2.25887448e-02f, -3.98075245e-02f, -3.95809971e-02f, 4.62883674e-02f, -7.17814360e-03f, 6.71407133e-02f, -7.40890503e-02f, 3.39208506e-02f, -2.33948193e-02f,
  8.85221884e-02f, 2.55655497e-02f, 5.46363555e-03f, -5.94551004e-02f, -4.93047433e-03f, -1.79491751e-02f, -1.88723393e-03f, 4.29791920e-02f, 1.69215314e-02f, -1.74689516e-02f,
  -5.40460050e-02f, -2.29711868e-02f, -1.27244899e-02f, -3.14886495e-02f, -1.93740949e-02f, 2.82935817e-02f, 4.48246747e-02f, -2.39824075e-02f, -1.01175331e-01f, -2.07583345e-02f,
  3.52786481e-02f, -1.54879997e-02f, 8.11321363e-02f, -8.88348278e-03f, 3.84296738e-02f, -6.14359491e-02f, -3.41915227e-02f, -2.22459268e-02f, 3.15539315e-02f, 3.47180404e-02f,
  7.27627426e-03f, 6.63224161e-02f, 6.31038472e-02f, -3.10786869e-02f, 3.67380190e-03f, -1.02826282e-01f, 2.16549430e-02f, -1.10122673e-02f, 8.78905728e-02f, 9.85472742e-03f,
  -1.43419867e-02f, 4.48601656e-02f, -1.31245796e-02f, 3.38811980e-04f, 1.00652277e-02f, 1.12531483e-02f, 7.93806314e-02f, -4.27009501e-02f, 2.08490919e-02f, -4.87981737e-02f,
  -6.69241557e-03f, 3.51255052e-02f, 5.20339161e-02f, 1.57347489e-02f, -2.56204661e-02f, 4.39922474e-02f, -2.26353382e-04f, -8.66160449e-03f, 8.15890264e-03f, -5.70980348e-02f,
  5.66884540e-02f, -6.89252242e-02f, -2.96471715e-01f, -2.37394139e-01f, 2.18524769e-01f, 1.61675915e-01f, -5.62751628e-02f, 9.20570195e-02f, -1.74696475e-01f, 1.29672885e-01f,
  1.03027366e-01f, -1.24614879e-01f, -1.45946860e-01f, 7.20441192e-02f, -1.47978678e-01f, -2.49662563e-01f, 8.99318904e-02f, 7.30730891e-02f, -8.84062275e-02f, 1.97051968e-02f,
  -1.90421659e-02f, 1.88348353e-01f, -9.96368080e-02f, 2.45670483e-01f, 6.65728841e-03f, 8.30202103e-02f, 1.36289984e-01f, -8.92938301e-03f, 1.56954855e-01f, 1.69376601e-02f,
  8.62773284e-02f, -1.10021539e-01f, -2.22077090e-02f, -9.11266357e-02f, 3.72395627e-02f, 1.58449426e-01f, 7.06679747e-02f, 8.05849582e-02f, -4.85715419e-02f, -2.45645531e-02f,
  3.80002558e-02f, -4.67492873e-03f, -2.20483728e-03f, -5.45404851e-03f, 4.16842736e-02f, 9.39958543e-03f, -3.02129099e-03f, 6.05518930e-04f, -2.95865480e-02f, -3.61665264e-02f,
  8.21889658e-03f, 1.02610588e-02f, 1.19212512e-02f, -5.40175922e-02f, -7.57916346e-02f, -3.83552201e-02f, 1.11477949e-01f, 5.48928007e-02f, 6.46291152e-02f, -1.00111607e-02f,
  1.35550499e-01f, 3.66023295e-02f, -3.08748279e-02f, 2.07202025e-02f, -2.61967443e-02f, -2.87663285e-03f, -1.94822047e-02f, 5.74380010e-02f, -2.53624823e-02f, 5.16424840e-03f,
  1.57484214e-03f, -7.04036979e-03f, -3.55110765e-02f, 2.50240788e-02f, -2.38067918e-02f, 3.07782032e-02f, 3.05299163e-02f, -5.32053374e-02f, -3.85279581e-02f, 3.54672223e-02f,
  -1.46132223e-02f, 1.45873269e-02f, -7.58528262e-02f, 4.26756516e-02f, 3.27329524e-02f, -6.77308738e-02f, -1.39257796e-02f, -1.34602124e-02f, 3.19077335e-02f, 1.04098007e-01f,
  -6.24126382e-02f, -1.65252725e-03f, -5.51251993e-02f, -1.54818641e-02f, -2.04085447e-02f, 5.21805882e-03f, -6.61437437e-02f, 5.09551205e-02f, 4.68970416e-03f, 3.67967375e-02f,
  8.14635009e-02f, 1.23680212e-01f, 1.50859309e-02f, 1.18975509e-02f, 3.78076322e-02f, -1.19841378e-02f, -5.07989638e-02f, 1.79224741e-02f, 1.20761313e-01f, 1.47994654e-02f,
  6.95727393e-02f, -2.46420167e-02f, 7.78392032e-02f, 4.96992655e-02f, 6.92685470e-02f, -2.76147425e-02f, -7.49510620e-03f, -4.04730625e-02f, 5.25402837e-02f, 7.55247893e-04f,
  3.86920214e-01f, -1.36625931e-01f, 6.28382489e-02f, -1.97829068e-01f, -5.72845750e-02f, -2.35733628e-01f, -9.48984176e-02f, -5.04963659e-02f, -8.12635794e-02f, -2.16565073e-01f,
  -6.72917441e-02f, 5.73080927e-02f, -7.74918869e-02f, -7.33301044e-02f, 1.43913120e-01f, 1.80294085e-02f, -6.84180646e-04f, -1.63770005e-01f, 4.98789810e-02f, 3.81292365e-02f,
  5.39139509e-02f, -1.14819221e-01f, 4.23816824e-03f, 1.32775875e-02f, -7.23206811e-03f, 5.06977513e-02f, 1.07567810e-01f, 4.09197025e-02f, 1.11756124e-01f, 1.50407270e-01f,
  -9.28811803e-02f, -1.23208292e-01f, -9.91831254e-03f, 5.15003596e-03f, -3.49752232e-02f, -5.05225770e-02f, 3.09784454e-03f, 2.04296745e-02f, 1.27791213e-02f, 7.07947230e-03f,
  -4.17487547e-02f, 4.52815592e-02f, -5.96233085e-02f, -5.38600534e-02f, -4.37806807e-02f, 7.60900304e-02f, 4.73192846e-03f, -7.80716864e-03f, -6.31455006e-03f, -6.78765178e-02f,
  -2.67510545e-02f, -4.38088290e-02f, -3.61888832e-03f, -2.21684743e-02f, -4.65755388e-02f, -1.39297722e-02f, -2.31845621e-02f, -1.43496087e-02f, -4.94473651e-02f, -4.91636954e-02f,
  -1.13814346e-01f, 1.15494415e-01f, 5.37014455e-02f, 3.64851877e-02f, 3.74979759e-03f, -3.23613081e-03f, 5.01875803e-02f, -4.88675758e-02f, 6.25566617e-02f, -3.59559394e-02f,
  5.58798388e-02f, -5.43478802e-02f, 1.68602716e-03f, 1.95749570e-02f, 1.40962489e-02f, -2.67515630e-02f, 7.21753715e-03f, 7.30413347e-02f, 2.99708173e-02f, -2.99397539e-02f,
  -3.79392989e-02f, 3.88928801e-02f, -1.69773251e-02f, 1.09559810e-02f, -1.04364799e-02f, -1.03710815e-02f, -4.82244529e-02f, 5.77295348e-02f, 4.56691049e-02f, 5.41642718e-02f,
  -1.12616807e-01f, 2.24177726e-02f, -3.80605683e-02f, 2.32401360e-02f, 2.44580470e-02f, -4.56888154e-02f, -2.86784470e-02f, 5.56478053e-02f, 9.38890129e-03f, 5.38936965e-02f,
  2.16981731e-02f, -8.53874013e-02f, -7.83099905e-02f, 1.24585731e-02f, 5.82606569e-02f, -5.98815382e-02f, 9.44297016e-02f, 1.10208162e-03f, 2.34069452e-02f, 2.56528873e-02f,
  -2.67801285e-02f, -8.85553136e-02f, 1.42851993e-02f, -1.19741276e-01f, -1.14711396e-01f, 1.68006029e-02f, -8.22156817e-02f, -1.26245897e-02f, 3.75236906e-02f, -3.96736190e-02f,
  -1.55044764e-01f, -5.04046753e-02f, 3.62509727e-01f, -3.11600622e-02f, -2.33104099e-02f, -5.79665564e-02f, 9.58261862e-02f, -1.02424845e-01f, 2.24035531e-01f, -2.36362517e-02f,
  -2.60448873e-01f, 1.07413284e-01f, 1.20060794e-01f, -2.44652137e-01f, -1.02831841e-01f, 6.63329959e-02f, -1.24797806e-01f, -4.50893417e-02f, 8.18219930e-02f, -6.42896146e-02f,
  1.01891279e-01f, -2.54680395e-01f, 4.35984656e-02f, -2.18161628e-01f, -1.13801220e-02f, 1.38609022e-01f, -2.59764522e-01f, 4.95147146e-02f, -1.45149767e-01f, -8.40685144e-02f,
  7.59387808e-03f, -3.45087261e-03f, -4.64369096e-02f, 2.13311589e-03f, 5.94264716e-02f, 2.80912481e-02f, 9.87399090e-03f, 5.86504824e-02f, 1.27846636e-02f, 1.58136152e-02f,
  1.11264363e-01f, 4.59798984e-03f, -2.19366848e-02f, 5.86852692e-02f, 7.45311007e-02f, 2.64402060e-03f, 4.26070951e-02f, 2.26622336e-02f, 3.01457681e-02f, -1.25434250e-03f,
  4.32662107e-02f, 5.59111163e-02f, 6.50578067e-02f, 4.35559228e-02f, 6.48779571e-02f, -5.32936752e-02f, 2.89051421e-02f, 1.17231600e-01f, 6.58548027e-02f, 1.07800821e-02f,
  2.50828173e-02f, -1.56734046e-02f, -1.73378941e-02f, -5.35535365e-02f, -6.53213635e-02f, -5.66351488e-02f, -2.77751498e-02f, -7.36592934e-02f, -1.28870206e-02f, -7.28588551e-02f,
  -4.46793288e-02f, -6.53282627e-02f, -2.33020987e-02f, 1.59325842e-02f, 1.46531776e-04f, -3.25140869e-03f, 3.26614194e-02f, 3.04867011e-02f, 2.42268965e-02f, 4.29322757e-02f,
  2.06735302e-02f, 1.70446299e-02f, -1.14217848e-01f, 4.84184809e-02f, -1.21703872e-03f, 1.74480956e-02f, -1.64853148e-02f, 4.29704599e-02f, 8.61002207e-02f, 1.08652934e-02f,
  -1.27223358e-01f, -1.03364065e-01f, -6.34782314e-02f, -4.13388088e-02f, -4.45707440e-02f, -4.84522544e-02f, 1.00688770e-01f, -1.60250887e-02f, 3.64027321e-02f, 4.93887924e-02f,
  5.82309291e-02f, -8.49910267e-03f, 9.85020213e-03f, 1.87918711e-02f, -4.06854600e-02f, 3.85610089e-02f, 2.76873773e-03f, -4.98566702e-02f, -6.72923028e-02f, 9.37355682e-03f,
  -6.04848266e-02f, -6.15023114e-02f, -1.74548645e-02f, 6.29489217e-03f, -7.83933476e-02f, 4.25534770e-02f, 1.42492764e-02f, 2.34356821e-02f, 1.77680776e-02f, 2.07105186e-02f,
  -5.32355011e-01f, -9.90585610e-03f, -7.50581995e-02f, -4.07145500e-01f, -1.54239237e-01f, -5.45482188e-02f, -3.72330993e-02f, -1.47472203e-01f, -8.68889838e-02f, 1.24750182e-01f,
  2.96842176e-02f, -1.33507177e-01f, 1.04633719e-01f, -2.63769627e-01f, -3.09993699e-02f, 1.58964500e-01f, -1.16409466e-01f, -1.23258695e-01f, 1.01792507e-01f, 8.09875969e-03f,
  -6.44726232e-02f, -6.02221340e-02f, -4.23859768e-02f, -2.88477950e-02f, -1.12061150e-01f, -4.98974212e-02f, 8.55520666e-02f, 2.06124961e-01f, -1.78564876e-01f, -4.98530455e-02f,
  -7.68408850e-02f, -1.58065096e-01f, -1.65178135e-01f, 8.26260000e-02f, -9.52231046e-03f, 1.06864478e-02f, -8.13817699e-03f, -3.48067023e-02f, -5.05808890e-02f, 8.57141539e-02f,
  3.51929218e-02f, -5.77502921e-02f, -1.23178205e-02f, 8.26021135e-02f, -6.97541013e-02f, -1.08480819e-01f, -9.67421755e-02f, -1.74975675e-03f, -7.17556253e-02f, -7.31756538e-02f,
  -2.74691544e-02f, -3.03230323e-02f, -2.08569621e-03f, -1.65321622e-02f, 4.41041659e-04f, -9.76209268e-02f, 1.54275028e-03f, -3.28219570e-02f, 4.25188802e-02f, -1.22177796e-02f,
  3.87577638e-02f, 1.16041288e-01f, 2.75050718e-02f, 4.32990585e-03f, 1.42284147e-02f, 4.12844568e-02f, 4.26758341e-02f, 4.84596081e-02f, 5.37192076e-02f, -6.16926663e-02f,
  4.45201062e-02f, 2.90761571e-02f, 6.01397716e-02f, -7.85715505e-03f, 4.71749306e-02f, -7.41868988e-02f, -4.48032888e-03f, -5.52359745e-02f, -3.67285893e-03f, 2.75325458e-02f,
  1.68093164e-02f, -1.15357956e-03f, -1.49430446e-02f, -3.26853730e-02f, -1.91416859e-03f, 1.21467551e-02f, -2.28126980e-02f, -3.16836759e-02f, 6.73357844e-02f, 7.80049115e-02f,
  1.19723253e-01f, 2.52055168e-01f, 7.09483773e-02f, -5.40240631e-02f, 5.98394535e-02f, 3.90624441e-02f, 2.40167640e-02f, -9.57842916e-02f, 2.48391908e-02f, 5.10642454e-02f,
  -7.93965533e-03f, -3.77324480e-03f, 9.91412327e-02f, -1.34165943e-01f, 3.31315286e-02f, 2.14414187e-02f, 6.19294643e-02f, 4.08134684e-02f, 8.34143255e-03f, 6.65125102e-02f,
  3.66556831e-02f, 9.24237818e-02f, 3.94941382e-02f, -5.45951985e-02f, -1.76853053e-02f, 1.10339202e-01f, 4.57921065e-02f, -2.01323442e-02f, 2.49893907e-02f, 7.87796974e-02f,
  4.77304667e-01f, -1.44795477e-01f, 1.90245494e-01f, 7.92345405e-03f, 2.21772015e-01f, 1.42248362e-01f, -1.42867537e-02f, 1.02148719e-01f, 3.15993637e-01f, -8.01621825e-02f,
  -2.00928710e-02f, 1.10691972e-01f, -1.75109714e-01f, -1.14399530e-01f, 1.70597553e-01f, -1.72361016e-01f, 7.21576512e-02f, -7.11174216e-04f, -2.06859559e-02f, -2.43898146e-02f,
  6.72363937e-02f, 5.99817326e-03f, -1.80797368e-01f, -5.92705607e-02f, 9.82680395e-02f, 8.70169774e-02f, -2.23358534e-02f, 8.92816926e-04f, 2.63565220e-02f, 6.33046851e-02f,
  -4.29454893e-02f, 1.70654319e-02f, 7.76864961e-02f, 1.54471630e-03f, 1.05579555e-01f, 7.33903423e-02f, -4.62164879e-02f, 2.28334311e-03f, -3.20125148e-02f, 5.59563376e-03f,
  -3.34453955e-02f, 5.62280454e-02f, 1.56579800e-02f, 1.43366344e-02f, 1.25228629e-01f, 9.65219457e-03f, -4.62076254e-02f, -3.17902043e-02f, -4.93862033e-02f, -3.83481644e-02f,
  2.60511171e-02f, -2.36680526e-02f, 3.37486565e-02f, -1.15827201e-02f, 5.96663170e-02f, 3.66085861e-03f, -3.87773588e-02f, -1.10230688e-02f, 1.56944506e-02f, 3.73946838e-02f,
  7.10919723e-02f, 2.24956386e-02f, -2.44116168e-02f, 2.87608653e-02f, -1.47761768e-02f, -1.05985533e-02f, 4.58038505e-03f, -4.73982468e-02f, 8.26899707e-02f, -2.98182410e-03f,
  -7.51823932e-03f, 5.98101020e-02f, -2.60934327e-02f, 2.90179718e-02f, 3.84080708e-02f, 1.63247027e-02f, -7.83137679e-02f, 6.23656809e-02f, -2.71081254e-02f, -2.63201958e-03f,
  1.48876279e-03f, 1.09148659e-02f, 3.58345509e-02f, -5.31848371e-02f, -5.76121529e-05f, -1.29311746e-02f, 1.89224221e-02f, -7.99697563e-02f, -6.26076087e-02f, -4.09129681e-03f,
  -7.10006580e-02f, 2.74807960e-01f, -3.66234966e-02f, 1.38594583e-01f, -8.47878680e-02f, 4.81229462e-03f, -2.93676686e-02f, -1.23442216e-02f, 3.32882330e-02f, 6.20526262e-02f,
  6.06159382e-02f, -2.69991234e-02f, 3.59087512e-02f, 4.67747683e-03f, -3.42228897e-02f, 1.10908458e-02f, 1.96247664e-03f, 4.38883230e-02f, 2.83380840e-02f, 2.91982256e-02f,
  4.27259691e-03f, 3.97484787e-02f, -1.35450624e-02f, 4.92468523e-03f, -3.74557916e-03f, 1.23421196e-02f, 8.41495097e-02f, -3.00145932e-02f, 5.50810173e-02f, -2.22071679e-03f,
  2.55721062e-01f, -1.05528139e-01f, 2.84344763e-01f, -2.35363826e-01f, -1.80978104e-02f, -1.50544345e-01f, 8.14162344e-02f, -8.59663635e-02f, -1.68243706e-01f, -8.75126943e-02f,
  2.27829181e-02f, 1.60560921e-01f, 7.96084777e-02f, -1.25806779e-01f, 3.56108532e-03f, -1.09441899e-01f, -1.24641851e-01f, 3.15398611e-02f, -8.77007172e-02f, -4.10855524e-02f,
  -4.80147786e-02f, -2.50609279e-01f, 1.27702206e-01f, -1.22321904e-01f, 5.67662045e-02f, 6.70400187e-02f, 6.07354753e-02f, 5.90695143e-02f, -6.02329299e-02f, 4.16202396e-02f,
  -2.80387271e-02f, 2.22010493e-01f, 2.10124195e-01f, 7.04514831e-02f, 8.55682939e-02f, 9.63827074e-02f, 3.33107337e-02f, 1.84426218e-01f, 8.30859914e-02f, -8.89386609e-02f,
  3.97794098e-02f, -2.95359530e-02f, -2.28795726e-02f, 2.14436259e-02f, -2.65307035e-02f, -2.91988663e-02f, 2.62946039e-02f, -7.70009160e-02f, -1.93646532e-02f, 1.06758596e-02f,
  -4.26811464e-02f, -5.67852519e-02f, -7.82058537e-02f, -4.49689887e-02f, 9.69341490e-03f, -6.47632778e-02f, -4.57369797e-02f, 1.09760100e-02f, -6.41379282e-02f, -1.55245392e-02f,
  1.25725521e-02f, 4.58583198e-02f, 2.10881662e-02f, 3.16713788e-02f, 1.23376930e-02f, -7.20569342e-02f, 1.62170362e-02f, 1.98522247e-02f, 3.48474309e-02f, -4.28295769e-02f,
  -9.82373655e-02f, 8.48000403e-03f, -9.02469177e-03f, -2.53859684e-02f, 6.69520870e-02f, -5.77546731e-02f, 7.93278664e-02f, -7.14754611e-02f, -1.37656564e-02f, -7.73740783e-02f,
  -3.59669281e-03f, 1.83370207e-02f, -3.82192470e-02f, 4.79799733e-02f, -5.44241862e-03f, -8.27084109e-03f, 4.99617448e-03f, -7.01869801e-02f, 4.03413996e-02f, -5.82782552e-03f,
  4.56567444e-02f, 1.52319893e-01f, -1.48309655e-02f, -8.16488713e-02f, -6.10048277e-03f, -3.07550300e-02f, 3.56484428e-02f, -9.21234712e-02f, 2.12139334e-03f, 6.02667518e-02f,
  -7.57304877e-02f, 7.31095225e-02f, 1.21774673e-01f, -8.54552016e-02f, -1.13786519e-01f, 4.99967784e-02f, 1.88565589e-02f, 6.57886192e-02f, 2.11024862e-02f, 3.53816524e-02f,
  1.37430001e-02f, 2.88633034e-02f, 8.67836550e-03f, 2.71938671e-03f, -4.93341573e-02f, -4.60499786e-02f, 1.06727681e-03f, -1.75480768e-02f, 3.54907699e-02f, 4.89357486e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.68480401e-02f, -5.93583435e-02f, -1.04702435e-01f, -2.25003138e-01f, -1.64664537e-01f, -2.87379641e-02f, -2.81815082e-01f, -1.15121201e-01f, 1.76786169e-01f, -8.69687498e-02f,
  -2.39916876e-01f, 1.03325799e-01f, 1.39960468e-01f, -4.89710540e-01f, 3.88997227e-01f, 2.45879501e-01f, -9.09648389e-02f, 2.64463034e-02f, 8.17767717e-03f, -1.88427240e-01f,
  4.63123992e-02f, -1.37960285e-01f, 1.60312671e-02f, -1.18010990e-01f, -3.21834564e-01f, -1.64237559e-01f, -1.13606080e-01f, -2.21702978e-01f, -3.20486248e-01f, -4.20371853e-02f,
  -5.35496064e-02f, -1.42179608e-01f, -9.83206630e-02f, 2.45168284e-02f, 7.53000155e-02f, -2.02875324e-02f, -9.10452604e-02f, -1.32090136e-01f, -7.89491460e-02f, -4.31021154e-02f,
  6.26134947e-02f, 2.52363458e-02f, -9.98145435e-03f, 7.15682358e-02f, -1.07954681e-01f, -6.08410835e-02f, -2.62121726e-02f, -3.85533459e-02f, -5.47940060e-02f, -7.57236108e-02f,
  4.09336761e-02f, 1.56730954e-02f, -5.31007461e-02f, 5.30466810e-02f, -9.27585065e-02f, -1.41992373e-02f, 1.80930048e-01f, -1.32590923e-02f, 1.05646588e-02f, 9.33857039e-02f,
  -1.29762581e-02f, -3.13099995e-02f, -1.02769479e-01f, -1.56776179e-02f, -1.46689471e-02f, 2.50712689e-02f, -2.46564168e-02f, -4.75953668e-02f, -1.49763431e-02f, 6.05862075e-03f,
  -1.86968725e-02f, -6.63027316e-02f, -1.27996597e-02f, 9.13627632e-03f, -3.94633226e-02f, 7.26472437e-02f, 9.85633656e-02f, -3.78944278e-02f, 2.59592999e-02f, 6.44278601e-02f,
  2.74682790e-03f, -4.98462357e-02f, -4.23553139e-02f, -1.61105886e-01f, 6.48272336e-02f, 1.68132722e-01f, -4.82872948e-02f, -1.30956331e-02f, -1.35080487e-01f, 1.07810413e-02f,
  8.85245875e-02f, 1.60348207e-01f, 2.29882263e-02f, 3.26804183e-02f, 8.75248387e-03f, -1.29668191e-02f, -9.06245708e-02f, 4.46330309e-02f, 7.53512233e-02f, 3.12081110e-02f,
  -1.04117110e-01f, 1.32657299e-02f, -9.92445424e-02f, -8.67994651e-02f, 1.14697859e-01f, 7.70993484e-03f, -9.48710144e-02f, -4.06413339e-02f, 6.57590553e-02f, -3.34740393e-02f,
  -1.47472359e-02f, -1.79630816e-02f, 1.51722535e-01f, -2.59219785e-03f, 1.28450379e-01f, 3.05301752e-02f, 2.85880975e-02f, -3.80540476e-03f, 1.09314418e-03f, 6.80231825e-02f,
  9.00658034e-03f, -4.71093506e-03f, -6.96728304e-02f, -5.44900745e-02f, 5.11705205e-02f, -4.28721368e-01f, -3.34527075e-01f, -1.23400912e-02f, -6.22930750e-02f, 1.25510901e-01f,
  -2.48911843e-01f, 4.36376370e-02f, -1.12697944e-01f, -4.73544687e-01f, -4.77397367e-02f, -8.00651908e-02f, -1.66598529e-01f, -3.39472592e-02f, -8.95291269e-02f, 5.59749827e-02f,
  -6.80306256e-02f, -2.27427557e-01f, -1.72138512e-01f, -1.28832653e-01f, -9.93116722e-02f, 6.09405376e-02f, 4.04053301e-01f, -4.07391861e-02f, 4.08655889e-02f, -8.56631845e-02f,
  -1.43369392e-01f, 6.90901801e-02f, -2.68745217e-02f, 1.80794317e-02f, 4.98368777e-02f, 1.27830386e-01f, 3.28340270e-02f, -1.25333354e-01f, 5.59018515e-02f, -9.42649245e-02f,
  2.04033822e-01f, -1.22665614e-01f, -3.38683799e-02f, -6.86863884e-02f, -2.46688090e-02f, -1.19399754e-02f, -2.99950968e-02f, -8.22216198e-02f, 2.38546468e-02f, -4.77501452e-02f,
  -6.18881993e-02f, 6.33398294e-02f, 1.38419345e-01f, 1.53538376e-01f, -2.34565642e-02f, -1.98800880e-02f, 1.26930410e-02f, 1.59852933e-02f, 1.14959575e-01f, 3.57638970e-02f,
  5.63340224e-02f, 7.83297420e-02f, -4.09431048e-02f, 4.00391184e-02f, -2.17002809e-01f, 2.99956929e-02f, -2.63779089e-02f, -1.81945134e-02f, -3.50346565e-02f, -3.84253822e-02f,
  -4.20584194e-02f, -2.86119501e-03f, 7.49316216e-02f, 1.36188626e-01f, -7.83001184e-02f, 4.82442081e-02f, -9.81355608e-02f, 1.02095060e-01f, -6.55881241e-02f, -3.41501236e-02f,
  1.57391094e-02f, 9.56152081e-02f, -5.28951734e-02f, -6.27750158e-02f, -2.12664828e-01f, 2.75130291e-02f, 6.35260344e-02f, 7.58755803e-02f, 1.49014354e-01f, 9.06954035e-02f,
  1.79649234e-01f, 3.32075059e-01f, -1.35042414e-01f, -6.88442737e-02f, -4.88066301e-02f, -1.09062426e-01f, -1.17041081e-01f, -1.29419014e-01f, 4.07974534e-02f, 8.43159482e-02f,
  1.00415967e-01f, 3.71099710e-02f, 3.50161754e-02f, -2.96374187e-02f, 1.04759699e-02f, 7.66995475e-02f, 1.37344137e-01f, 9.17929634e-02f, -6.47462113e-03f, 8.24158788e-02f,
  1.16108045e-01f, 6.56992383e-03f, 4.67044897e-02f, -1.06642492e-01f, 1.14374653e-01f, 4.21152860e-02f, 5.46128191e-02f, -1.15550399e-01f, 1.43031403e-01f, -2.53099459e-03f,
  -3.13469954e-02f, 3.48765217e-02f, -1.87818438e-01f, 3.58053267e-01f, -2.34967947e-01f, -1.05106935e-01f, -9.73837674e-02f, -4.63173501e-02f, -1.36031061e-01f, 2.41177857e-01f,
  2.85419583e-01f, -1.28046334e-01f, 1.60645932e-01f, 5.52190483e-01f, 1.01786293e-01f, 1.18229628e-01f, 4.07012016e-01f, 1.96290195e-01f, -7.63925090e-02f, 8.57651383e-02f,
  1.21795639e-01f, 4.07818556e-01f, 3.00557733e-01f, 1.29778937e-01f, 1.52362347e-01f, 1.49816340e-02f, 2.87984401e-01f, -1.01828218e-01f, 2.38560066e-01f, -3.94060314e-02f,
  -1.23326983e-02f, -1.59671076e-03f, 3.37707810e-02f, -8.52844417e-02f, -1.45649348e-04f, 3.32869478e-02f, 3.69172124e-03f, -5.64217009e-03f, -1.16372928e-01f, -5.15037291e-02f,
  -6.42887503e-02f, 9.43894982e-02f, -5.37031963e-02f, -2.47348752e-02f, -3.21874693e-02f, -4.23560925e-02f, 2.18704939e-02f, -3.80381495e-02f, -3.87108587e-02f, -5.91717251e-02f,
  -8.54889452e-02f, -6.23576641e-02f, 4.43822667e-02f, -5.32845617e-04f, -2.80554872e-02f, 7.03699142e-02f, -1.27081156e-01f, -8.30586441e-03f, -1.52746335e-01f, -9.23741981e-02f,
  -5.25397807e-03f, -6.65407628e-02f, 3.48865502e-02f, -5.73607348e-03f, -1.94315221e-02f, 6.42487109e-02f, 1.39108673e-01f, 2.27499921e-02f, 1.61371864e-02f, 8.74089301e-02f,
  1.43425083e-02f, -4.15058322e-02f, -1.91221461e-02f, 7.65421835e-04f, -3.60474177e-03f, 7.57098347e-02f, -4.23600003e-02f, 9.58789736e-02f, -4.07371819e-02f, 1.04320385e-01f,
  1.98826231e-02f, -3.14973406e-02f, -1.79668926e-02f, 5.29259071e-02f, 6.41444419e-03f, -5.56658581e-02f, 1.09426960e-01f, -1.12719368e-02f, -5.36686592e-02f, -1.82208791e-02f,
  3.10368892e-02f, 1.68946907e-01f, 1.43247470e-03f, -4.30563986e-02f, -2.78507303e-02f, 6.55313805e-02f, 4.43034209e-02f, -3.70596163e-03f, 8.21879804e-02f, -2.16603931e-02f,
  -1.05243661e-02f, -7.35252500e-02f, 2.21215039e-02f, -1.36681311e-02f, -1.45727983e-02f, 2.90675797e-02f, 9.91615094e-03f, -5.35256490e-02f, 8.61076489e-02f, -1.26448311e-02f,
  1.92064010e-02f, -1.11887403e-01f, -3.26630572e-04f, -1.09852120e-01f, 5.65631427e-02f, 2.38286555e-02f, -1.93570722e-02f, -6.67342991e-02f, 6.75914437e-02f, 9.63933021e-03f,
  2.48072334e-02f, 7.73414299e-02f, 5.81286177e-02f, 3.32720816e-01f, -1.02087758e-01f, -3.32881421e-01f, -3.79128247e-01f, 1.23205431e-01f, -1.46502644e-01f, -1.60749108e-01f,
  -3.99019979e-02f, 6.33475408e-02f, -5.68245240e-02f, 2.38540351e-01f, 3.17173988e-01f, 4.52084169e-02f, 1.74444839e-01f, -9.68122184e-02f, 6.87065274e-02f, 1.95889831e-01f,
  2.07413346e-01f, 1.67822599e-01f, 2.12265030e-01f, 1.62089169e-01f, 9.80926603e-02f, 1.67154774e-01f, 2.33645603e-01f, 1.58796221e-01f, 1.50790676e-01f, 5.47945797e-02f,
  -9.87335965e-02f, 1.40852556e-01f, 2.84019187e-02f, -7.02615157e-02f, 5.52718081e-02f, -1.22720517e-01f, -3.67989354e-02f, 3.63715440e-02f, -2.22258903e-02f, 3.74686681e-02f,
  1.93419196e-02f, 5.29934876e-02f, 4.35208296e-03f, 8.57396722e-02f, 7.10576773e-02f, 5.18454686e-02f, -7.92444497e-02f, -6.36554807e-02f, -4.06118892e-02f, 1.84296034e-02f,
  -4.91503738e-02f, 1.71408728e-02f, 3.68561670e-02f, 2.20732428e-02f, 5.94964176e-02f, -3.32460576e-03f, -3.52058224e-02f, 8.74923095e-02f, 6.02671355e-02f, 2.05401913e-03f,
  2.89065577e-02f, -3.43945026e-02f, -4.72199507e-02f, -6.76254332e-02f, 8.76003951e-02f, -3.27272192e-02f, -6.02183584e-03f, -5.33432700e-02f, 4.61817905e-02f, -1.26338620e-02f,
  3.49406078e-02f, 1.57023165e-02f, -2.26378813e-02f, -3.23119983e-02f, 1.31755238e-02f, -7.42592812e-02f, -2.76868157e-02f, 1.69091411e-02f, -5.45743816e-02f, -3.21936533e-02f,
  -3.51084471e-02f, 8.81099701e-02f, 8.30805488e-03f, 1.94543763e-03f, 6.84991255e-02f, 1.25094466e-02f, 8.45795795e-02f, -2.05128100e-02f, 5.27211577e-02f, -8.25673267e-02f,
  4.97337505e-02f, 3.38765115e-01f, 4.11487333e-02f, -2.38582380e-02f, 3.46321985e-02f, 4.28992882e-02f, -3.57999955e-03f, 8.86435509e-02f, 1.29769191e-01f, 5.12610748e-02f,
  3.90325785e-02f, -8.61588679e-03f, -1.94809902e-02f, 2.79058758e-02f, 2.58459635e-02f, 6.45606965e-02f, 6.11843318e-02f, 5.69022186e-02f, 9.74022299e-02f, 1.31796733e-01f,
  2.70708892e-02f, -4.19048071e-02f, 5.06653963e-03f, -5.20258285e-02f, 2.06183791e-02f, -1.94562599e-02f, -9.73989964e-02f, -8.31241012e-02f, -1.30926678e-02f, 4.09208238e-02f,
  6.15359247e-01f, -4.59891520e-02f, 1.71185941e-01f, 4.00576591e-01f, 1.81351870e-01f, -1.42236918e-01f, 2.11701632e-01f, 1.74943745e-01f, 6.74584270e-01f, -9.28388461e-02f,
  -1.16196133e-01f, 1.30851537e-01f, -1.01026908e-01f, 3.86873982e-03f, 4.07971535e-03f, -1.23350732e-01f, 1.94868237e-01f, -2.36694654e-03f, 1.98666975e-01f, 6.37876540e-02f,
  2.27327079e-01f, -1.17201790e-01f, -9.25896540e-02f, -3.15132916e-01f, 5.58874421e-02f, -1.67735089e-02f, -3.43637913e-01f, -5.80055900e-02f, -2.67524928e-01f, -2.10665911e-01f,
  9.35723186e-02f, 8.66026357e-02f, 9.46795493e-02f, 1.84400305e-02f, -5.59347076e-03f, -1.79934986e-02f, -6.26738816e-02f, -1.66657567e-01f, 8.52260962e-02f, 3.17650801e-03f,
  -1.19352546e-02f, -8.34507346e-02f, 5.88245690e-02f, 4.65506315e-02f, 1.24566428e-01f, -1.76071599e-02f, 2.28332169e-02f, 8.48362371e-02f, 1.39526427e-02f, -3.17089185e-02f,
  -4.77869762e-03f, 5.19249290e-02f, 1.73354566e-01f, -7.84189925e-02f, 3.77329066e-02f, 4.55154553e-02f, -3.88083048e-03f, -3.12824808e-02f, 3.43929455e-02f, 5.85371889e-02f,
  -5.31152934e-02f, 2.62134010e-03f, -7.15053305e-02f, -1.08910212e-02f, -2.48357560e-02f, 4.20900285e-02f, -4.79749143e-02f, -7.49674859e-03f, 5.61104380e-02f, 3.53113972e-02f,
  7.37905735e-03f, 6.86329827e-02f, 5.98895177e-02f, 4.41813134e-02f, 7.29986699e-03f, 9.51041728e-02f, -1.44675048e-02f, -7.30687007e-02f, 4.56771776e-02f, 6.73493147e-02f,
  5.84163293e-02f, 3.83247212e-02f, -9.25017446e-02f, -3.97174992e-02f, -1.90591682e-02f, -1.56689656e-03f, -7.42010190e-04f, -3.01188026e-02f, 5.98937757e-02f, -2.47955415e-02f,
  -1.14697158e-01f, -1.61211938e-01f, 6.86679333e-02f, -2.89576817e-02f, -1.00275740e-01f, -6.83928356e-02f, 4.55861054e-02f, -1.55107975e-02f, -4.00231332e-02f, 2.40201559e-02f,
  3.10986433e-02f, 7.64273927e-02f, 2.25008782e-02f, -1.86392535e-02f, -5.36459759e-02f, -5.08304909e-02f, -1.60868634e-02f, -2.53303312e-02f, -2.57221982e-02f, -5.14627062e-02f,
  -1.31393154e-03f, -6.18598145e-03f, 1.95364486e-02f, 1.07182693e-02f, 2.56439019e-02f, 2.89307423e-02f, 2.90475767e-02f, 8.64038803e-03f, -4.01193947e-02f, 2.47407388e-02f,
  3.24450672e-01f, 1.39653698e-01f, 2.30582356e-01f, 3.62594664e-01f, -1.34333894e-01f, -4.71621364e-01f, -4.61369693e-01f, 1.70686580e-02f, 1.89822949e-02f, -3.15936953e-01f,
  -1.83763787e-01f, 4.98214543e-01f, -3.52148294e-01f, 2.83593893e-01f, -9.18079987e-02f, -3.01113009e-01f, 3.07744406e-02f, 1.19608745e-01f, 7.45345280e-02f, -1.53945265e-02f,
  2.01654613e-01f, -4.19785306e-02f, 3.19670886e-01f, -2.65928283e-02f, 2.45567247e-01f, 3.81569564e-01f, 1.39445662e-01f, 2.36011972e-03f, 3.54823649e-01f, 1.60329849e-01f,
  -2.49300629e-01f, 1.17276199e-01f, 1.35635972e-01f, 5.19418679e-02f, -1.35354608e-01f, -1.18887976e-01f, -1.47176464e-03f, 4.12882380e-02f, 1.33231319e-02f, 2.23757513e-02f,
  2.86860056e-02f, 7.30108935e-03f, 2.16037735e-01f, -4.65397835e-02f, -3.88223045e-02f, 1.36109784e-01f, 1.03808023e-01f, 7.59333596e-02f, -7.97818787e-03f, 3.42468955e-02f,
  -2.02950798e-02f, 8.94519240e-02f, -9.99199785e-03f, 8.97150934e-02f, 1.26908123e-01f, 5.93986548e-02f, 1.30898312e-01f, 5.24045005e-02f, 7.19715431e-02f, 6.83300421e-02f,
  7.78675228e-02f, -2.01478582e-02f, -1.83062889e-02f, -6.07366003e-02f, -1.42713459e-02f, 1.60452459e-04f, -5.85860573e-03f, 7.50056058e-02f, 2.75378637e-02f, -1.34740695e-01f,
  -4.26678844e-02f, 3.14199477e-02f, 7.40641654e-02f, -1.27615035e-01f, -1.58082079e-02f, -7.21370280e-02f, 9.27039310e-02f, -5.47788218e-02f, -2.04969440e-02f, 8.07702839e-02f,
  3.43428068e-02f, 2.46471539e-02f, 3.10637597e-02f, -4.26498279e-02f, -3.91916893e-02f, 2.16317959e-02f, -4.57245810e-03f, -1.13980040e-01f, 2.37676948e-02f, 8.68092477e-03f,
  -4.51467156e-01f, -1.72705889e-01f, -4.73569594e-02f, -6.08540475e-02f, 8.63420814e-02f, 4.96303057e-03f, 9.32496861e-02f, -4.63952012e-02f, 2.81488081e-03f, -7.66173974e-02f,
  -7.33666793e-02f, 3.07386704e-02f, -4.18245345e-02f, -2.59850104e-03f, -1.61928888e-02f, -1.10089391e-01f, -5.64501993e-02f, 6.25788420e-02f, 5.42476438e-02f, 4.48249243e-02f,
  7.17047006e-02f, -5.97982220e-02f, 4.45068516e-02f, -2.44400036e-02f, -1.64260603e-02f, -6.94358200e-02f, 8.23186114e-02f, 1.85948238e-02f, 1.52851399e-02f, -1.18123395e-02f,
  -6.47130728e-01f, 1.88172549e-01f, -9.92770791e-02f, -2.24061713e-01f, 1.03680909e-01f, -5.00367880e-01f, -2.79804319e-01f, 1.59316659e-01f, 1.53281793e-01f, 5.41388504e-02f,
  1.07072608e-03f, 2.91019846e-02f, 2.36594722e-01f, -1.14625186e-01f, -3.00172716e-01f, -1.04570193e-02f, -3.79310161e-01f, -2.48236865e-01f, 8.80031735e-02f, -2.02564865e-01f,
  -8.77415240e-02f, -3.89777720e-02f, -3.19002688e-01f, 2.32878506e-01f, -9.80405062e-02f, -4.21485864e-03f, -1.35376513e-01f, 2.27481350e-01f, -1.49449900e-01f, 1.05669707e-01f,
  -2.42019147e-01f, 1.14748023e-01f, 2.36352589e-02f, -5.16476184e-02f, -1.58848852e-01f, -5.71267009e-02f, -1.27791911e-01f, -1.26811611e-02f, 1.29803950e-02f, -1.34196840e-02f,
  -1.75169632e-02f, 6.46415725e-02f, 6.23444468e-03f, 5.50255179e-02f, 4.61033098e-02f, 3.24446857e-02f, 6.93731084e-02f, -3.36160772e-02f, 4.42465506e-02f, -1.01327328e-02f,
  -2.10119840e-02f, -3.90005521e-02f, -7.94405863e-02f, -4.85988297e-02f, -6.64618192e-03f, -8.09394196e-03f, -9.66230109e-02f, -4.10364149e-03f, -4.20808345e-02f, -8.05383399e-02f,
  8.54222029e-02f, -5.04426584e-02f, -4.48621288e-02f, 4.60139811e-02f, 1.75678097e-02f, 1.03422977e-01f, 1.77306142e-02f, 3.35607491e-02f, 7.90577233e-02f, 6.22502388e-03f,
  -5.38515523e-02f, -5.35794708e-04f, 2.24357564e-02f, -7.76925236e-02f, -1.48249924e-01f, 1.15973072e-03f, -1.79345906e-01f, 7.26274699e-02f, -8.98031071e-02f, 8.26971512e-03f,
  1.35400072e-01f, 3.84847261e-02f, 5.81707098e-02f, -9.83530656e-02f, 4.03475761e-02f, -5.92695083e-03f, -2.41678255e-03f, 3.58982803e-03f, 3.28841731e-02f, -2.77394708e-02f,
  -4.17647392e-01f, -1.86290845e-01f, 3.44561525e-02f, 1.39224932e-01f, 1.68290157e-02f, -7.42023736e-02f, -1.86276529e-02f, -7.77374282e-02f, -4.12795208e-02f, 4.06175368e-02f,
  -9.78131294e-02f, -9.11698788e-02f, -1.46456331e-01f, 1.38224894e-02f, -2.06070300e-02f, -3.43454257e-02f, -5.93702979e-02f, 2.58649457e-02f, -8.24759454e-02f, 5.75233959e-02f,
  1.06156003e-02f, 2.96951942e-02f, 9.01887789e-02f, -5.43658948e-03f, -3.85580733e-02f, -6.30876422e-02f, 5.81464265e-03f, -3.09905633e-02f, -1.64089352e-02f, -3.14910747e-02f,
  1.57666132e-01f, -3.29228014e-01f, 1.09316386e-01f, -3.36835310e-02f, 1.85100317e-01f, -5.07196411e-02f, 7.57277831e-02f, -2.24557936e-01f, -2.92261541e-01f, -2.55324006e-01f,
  2.39497647e-02f, 4.07078378e-02f, 2.99480170e-01f, -2.00928777e-01f, 6.42519653e-01f, 1.41274378e-01f, -1.92007154e-01f, -9.36687365e-02f, -5.49162105e-02f, -2.07900032e-01f,
  -1.21494215e-02f, -3.27530980e-01f, 1.80650026e-01f, -3.21780443e-01f, -1.18334040e-01f, -1.38408065e-01f, 1.23024218e-01f, 1.72948554e-01f, -1.68429181e-01f, 2.02350810e-01f,
  -1.67703763e-01f, -2.78559059e-01f, -5.56296892e-02f, -1.58433095e-01f, -9.72480103e-02f, 6.67756498e-02f, 1.07378803e-01f, 2.26842910e-01f, -3.22870095e-03f, 5.25845475e-02f,
  1.27969719e-02f, 2.03389116e-02f, -1.06805027e-01f, 2.34994572e-02f, -3.64539847e-02f, -1.05375268e-01f, -7.60761350e-02f, -3.69486921e-02f, 2.87223011e-02f, 1.33821294e-01f,
  3.75766791e-02f, -2.19625402e-02f, -3.67350206e-02f, 3.01946737e-02f, 1.16440356e-01f, -4.72575501e-02f, -3.02797109e-02f, 1.98197559e-01f, -7.69855157e-02f, -1.66503385e-01f,
  8.81451741e-03f, 3.37877981e-02f, 4.32007872e-02f, -1.10452533e-01f, -3.15342546e-02f, -7.25464299e-02f, -3.82354110e-02f, 8.66663530e-02f, 1.13280863e-02f, 2.33610403e-02f,
  -2.87719984e-02f, 3.63045707e-02f, -8.79998356e-02f, -4.50514033e-02f, -1.03731886e-01f, -3.93314194e-03f, -3.55108175e-03f, 3.57965603e-02f, -7.19277561e-02f, 5.19115012e-03f,
  2.81919297e-02f, 1.74492337e-02f, 6.70903921e-02f, 3.56446505e-02f, 3.34534161e-02f, 7.36331940e-02f, 3.25262523e-03f, 8.70189294e-02f, -6.07476989e-03f, 1.04617976e-01f,
  -2.21162781e-01f, -3.33011389e-01f, -9.96809676e-02f, -2.66001113e-02f, -1.34287300e-02f, -3.39772888e-02f, -1.73614118e-02f, -4.02853675e-02f, -3.13790776e-02f, -9.73189995e-02f,
  -6.03566393e-02f, -7.03907982e-02f, -1.46568362e-02f, 4.75411899e-02f, 6.65389048e-03f, -8.62667635e-02f, 2.50269547e-02f, -1.49510317e-02f, -8.92608985e-02f, -1.05919421e-01f,
  2.55715549e-02f, 6.65247366e-02f, 3.42312381e-02f, -8.87821540e-02f, 1.59702482e-04f, 2.93946639e-02f, -3.58480215e-02f, -1.02225738e-02f, 8.10632557e-02f, -1.62749588e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.01390906e-01f, 3.21355551e-01f, 2.60711759e-01f, -3.62591334e-02f, 2.58056313e-01f, 1.93624213e-01f, 1.50065482e-01f, 1.52685130e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.37832594e-01f, 4.27636318e-02f, -1.20725103e-01f, -1.21768430e-01f, 5.20437844e-02f, -1.86589524e-01f, 2.67073840e-01f, 2.51549445e-02f, -3.39412987e-01f, 3.01442683e-01f,
  -2.26674914e-01f, -1.37044311e-01f, 2.09209859e-01f, 1.82996303e-01f, 2.01718345e-01f, 2.78657287e-01f, -7.21136257e-02f, 1.97631553e-01f, 5.36062941e-02f, -2.72038221e-01f,
  -7.00993910e-02f, -2.14224517e-01f, -3.24259996e-01f, -3.71324688e-01f, -2.15000048e-01f, 2.42836922e-02f, 1.83763921e-01f, -5.28282151e-02f, -3.75446945e-01f, -3.02219808e-01f,
  2.83468395e-01f, 1.81655601e-01f, -2.43032083e-01f, -8.77473578e-02f, 1.39990866e-01f, -2.47640740e-02f, -2.30275944e-01f, -2.37662345e-01f, -3.37781042e-01f, -1.24726314e-02f,
  -6.25990853e-02f, -2.08508581e-01f, 3.25538158e-01f, 2.26649165e-01f, -1.21140242e-01f, -2.26097465e-01f, -1.67633623e-01f, 8.03268552e-02f, -3.31232041e-01f, -8.91332179e-02f,
  2.23150760e-01f, 6.70943037e-02f, -3.88309002e-01f, -1.59950614e-01f, 1.46005467e-01f, 1.82036862e-01f, 1.59127086e-01f, 1.11100666e-01f, 3.93047780e-02f, 3.59485857e-02f,
  2.56020240e-02f, 2.04258159e-01f, -9.14488509e-02f, 7.36975372e-02f, 1.84309989e-01f, -9.86288413e-02f, 1.99174136e-01f, 7.16696009e-02f, -1.71112597e-01f, -1.31214663e-01f,
  -2.15934888e-01f, 1.68273643e-01f, 1.27230927e-01f, -1.05466798e-01f, 4.34440017e-01f, 1.56552523e-01f, -1.55310869e-01f, -3.00844550e-01f, -1.93967402e-01f, -1.04985805e-02f,
  -1.82656094e-01f, -1.82987317e-01f, 2.88451701e-01f, 3.92428935e-01f, -1.36292025e-01f, -1.03238322e-01f, 2.59260982e-01f, 2.54566371e-01f, 1.64590180e-01f, 2.73044318e-01f,
  -1.10858843e-01f, -7.76013508e-02f, 2.55821228e-01f, 1.74532533e-01f, -2.51998365e-01f, 3.09971213e-01f, 4.01247628e-02f, 2.58667588e-01f, 6.13388538e-01f, 6.23805635e-03f,
  -4.41210210e-01f, -3.51069570e-02f, -8.06756318e-02f, -3.17048095e-02f, 1.06959835e-01f, 1.29472747e-01f, 2.04526588e-01f, -1.80094972e-01f, 3.75696838e-01f, -4.87440109e-01f,
  -5.93214594e-02f, -9.77754965e-03f, -1.92959279e-01f, -3.18883657e-02f, 4.23888415e-02f, 1.50459766e-01f, 2.44489625e-01f, 1.15493484e-01f, -2.69375026e-01f, 4.30933744e-01f,
  3.23250405e-02f, 9.99030545e-02f, -2.19020918e-01f, -1.69782694e-02f, -2.21444160e-01f, 1.50989637e-01f, 2.07925424e-01f, 3.75992239e-01f, 3.06369275e-01f, -2.64391154e-01f,
  -2.04777807e-01f, -1.67951837e-01f, 2.81179339e-01f, 3.76100689e-02f, 2.18611121e-01f, -1.57081798e-01f, 2.35778406e-01f, 3.03982556e-01f, 5.17806374e-02f, 1.40585095e-01f,
  -4.01447192e-02f, 2.95396924e-01f, 3.51695985e-01f, 5.62553108e-02f, 3.54145944e-01f, 2.17286915e-01f, -4.74794120e-01f, 6.45719916e-02f, 2.11732071e-02f, 3.47947866e-01f,
  -3.09239894e-01f, 2.51569480e-01f, 2.70615995e-01f, 1.16013706e-01f, -4.04593768e-03f, 2.74282545e-01f, -2.85102010e-01f, -1.21555619e-01f, -3.39896679e-02f, 4.18098152e-01f,
  1.97427213e-01f, -1.97480410e-01f, -4.36137646e-01f, 2.38455296e-01f, -5.48713915e-02f, 1.17724366e-01f, -1.48398116e-01f, 1.30169140e-02f, -9.77615118e-02f, -1.43172830e-01f,
  7.28770420e-02f, 1.22588724e-01f, -2.91838437e-01f, 2.16113031e-01f, -1.84926704e-01f, 6.48583397e-02f, -2.79134601e-01f, -3.53476763e-01f, 2.59194940e-01f, -2.08672598e-01f,
  -2.85648733e-01f, -1.85852841e-01f, 3.23349833e-01f, -2.77285248e-01f, -1.90305367e-01f, 1.22783758e-01f, 2.64947593e-01f, 1.44797415e-01f, 4.09296393e-01f, 3.64231355e-02f,
  -3.23973686e-01f, -4.50812012e-01f, 2.58228987e-01f, -2.14523375e-02f, -5.84580190e-02f, -3.32056016e-01f, -2.41571441e-02f, -2.92301208e-01f, 1.67558655e-01f, -1.80543646e-01f,
  3.08496624e-01f, 2.27607340e-01f, -4.41612750e-01f, 2.27412526e-02f, 4.47297603e-01f, 1.61594879e-02f, 2.44109258e-01f, -1.95101984e-02f, -3.30134541e-01f, 9.19302553e-02f,
  -5.33761919e-01f, -2.40533054e-03f, 2.48930410e-01f, 2.90174276e-01f, -4.58514333e-01f, 2.14854077e-01f, -2.05869868e-01f, 1.16167687e-01f, 1.72316372e-01f, 4.58401181e-02f,
  -3.24132293e-01f, 2.27121636e-01f, 3.44065875e-01f, 3.30412649e-02f, 2.82580405e-01f, -2.85707474e-01f, -3.04025203e-01f, -1.57872692e-01f, 2.85085976e-01f, -2.62551546e-01f,
  7.15486407e-02f, -3.11839759e-01f, -8.34585801e-02f, 4.15284216e-01f, -1.16987295e-01f, -8.06634724e-02f, -1.42575607e-01f, 2.72803247e-01f, 1.33767024e-01f, 5.67415953e-01f,
  -1.16901562e-01f, 2.08988637e-01f, -3.36954594e-01f, -1.89190060e-01f, -3.81593704e-02f, -6.75517991e-02f, 7.04192221e-02f, 3.88482213e-01f, 2.15183437e-01f, 3.94181490e-01f,
  1.72827512e-01f, 1.33399367e-01f, -2.01311126e-01f, -1.12415597e-01f, -4.52285200e-01f, 5.12236595e-01f, 1.62376300e-01f, -4.88657281e-02f, -3.62687498e-01f, 1.17178127e-01f,
  2.29257852e-01f, 3.28549631e-02f, 5.00181923e-03f, -2.11973995e-01f, 8.09071139e-02f, 3.57682317e-01f, -1.14478044e-01f, -1.51947707e-01f, -8.94512013e-02f, 4.49472457e-01f,
  2.24402055e-01f, 1.03434049e-01f, 8.24485533e-03f, 8.63594636e-02f, -4.17927712e-01f, -2.27829233e-01f, 1.93590522e-02f, 1.40087456e-01f, -6.98678717e-02f, -2.74585802e-02f,
  -2.25822274e-02f, 2.70599514e-01f, 2.28034630e-01f, 3.02602321e-01f, -3.06613475e-01f, -2.46154144e-01f, -7.87945762e-02f, -2.45319456e-01f, -2.77739704e-01f, -2.00859472e-01f,
  -1.96049169e-01f, -1.31837010e-01f, -2.61442363e-01f, -2.86643893e-01f, -3.01555574e-01f, -1.89494804e-01f, -3.86979669e-01f, -2.11201757e-01f, 2.02034220e-01f, 2.02293888e-01f,
  -2.40422249e-01f, -1.58741876e-01f, -2.00093821e-01f, 3.96871746e-01f, -3.48327011e-01f, -1.28445387e-01f, -3.27617815e-03f, 9.80437994e-02f, -3.86231273e-01f, -1.80005044e-01f,
  2.20047683e-01f, -1.17258094e-01f, -1.03402659e-01f, 1.97201088e-01f, 4.78657633e-02f, 1.79870069e-01f, 9.17720795e-02f, -4.24217246e-02f, -4.97461438e-01f, -1.63154796e-01f,
  4.19226214e-02f, -9.86895408e-04f, -1.77709550e-01f, 6.43947301e-03f, 1.53755620e-02f, 2.01239064e-01f, 1.56118289e-01f, -1.35186061e-01f, -4.66428921e-02f, 2.30810732e-01f,
  -1.43176869e-01f, -4.97775264e-02f, 1.66074663e-01f, 1.49888769e-01f, -1.37257546e-01f, -1.69433504e-01f, -1.82849020e-01f, 3.06683481e-02f, 2.02505827e-01f, -1.65872157e-01f,
  -1.31965652e-01f, -2.62526888e-02f, -1.96716115e-01f, -4.17917192e-01f, -3.73343676e-01f, -6.85439184e-02f, 2.91609019e-01f, 2.11108625e-01f, -3.23145986e-01f, -4.91018966e-02f,
  2.79107422e-01f, -2.62530744e-01f, 9.46518555e-02f, -3.73343170e-01f, -7.35455632e-01f, 5.78407533e-02f, 2.86203027e-01f, 7.65604079e-02f, -6.06725141e-02f, -3.08605060e-02f,
  -2.49414682e-01f, 1.41488627e-01f, -3.61815751e-01f, 3.56328301e-02f, -3.16135675e-01f, 4.38648343e-01f, 7.54479095e-02f, 1.26625076e-01f, -6.29855096e-02f, -1.06056586e-01f,
  1.39047623e-01f, -1.34255171e-01f, -3.14066589e-01f, 5.46264313e-02f, -1.59935355e-01f, -4.50647891e-01f, -1.53354362e-01f, 9.77264196e-02f, 2.77984291e-01f, 2.74740189e-01f,
  -1.02004647e-01f, -9.70400125e-02f, -3.97115648e-01f, -9.67579633e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.11137964e-01f, 4.03290242e-01f, -1.50779217e-01f, 3.50387365e-01f, -1.11630289e-02f, 1.92217246e-01f, 9.45202038e-02f, 2.91192681e-01f, -5.27776480e-02f, 2.99551967e-03f,
  5.23670137e-01f, 4.24831718e-01f, -3.04415166e-01f, 2.07771346e-01f, 8.22371989e-02f, 2.84923375e-01f, -8.96835420e-03f, -4.96217221e-01f, 5.18366814e-01f, -6.00108989e-02f,
  -5.11381626e-01f, -4.01189893e-01f, 6.87521040e-01f, -4.09610569e-01f, -1.72456473e-01f, 3.63486379e-01f, 3.86999547e-01f, 5.36626518e-01f, 2.73535494e-02f, 4.04285580e-01f,
  -3.15102279e-01f, -3.89529049e-01f, 1.74002945e-01f, 3.05504680e-01f, 4.85337287e-01f, 3.57097864e-01f, -3.45877975e-01f, -4.23111431e-02f, 3.15975994e-01f, 2.36502141e-01f,
  6.56377897e-02f, -9.88308042e-02f, 4.14145470e-01f, 3.06906998e-01f, -2.05451950e-01f, -4.73311335e-01f, -1.87690914e-01f, 2.87390441e-01f, 2.07856596e-01f, -1.95809692e-01f,
  1.51705503e-01f, 3.82011831e-01f, 8.49079341e-02f, -6.11358404e-01f, 3.54177266e-01f, 3.82082015e-01f, -9.03322622e-02f, -3.27010691e-01f, 1.17804840e-01f, -2.17761531e-01f,
  4.89822716e-01f, 5.60822725e-01f, -1.61801338e-01f, 4.45555955e-01f, 1.41122207e-01f, 3.81849498e-01f, 4.34500754e-01f, 2.59663463e-01f, -2.05322415e-01f, 4.80730832e-02f,
  4.65883374e-01f, 3.44126791e-01f, 4.67621744e-01f, 2.81336755e-01f, 1.95890978e-01f, 1.60786569e-01f, 2.59285867e-01f, -1.44923016e-01f, -3.40853721e-01f, 3.32966298e-01f,
  -2.92705536e-01f, 1.30932510e-01f, -3.65487039e-01f, 2.08492205e-01f, 3.86399090e-01f, 8.72794986e-02f, 1.11072034e-01f, 6.78741813e-01f, -9.36142728e-02f, 9.76864994e-02f,
  -5.04459590e-02f, 1.09395146e-01f, 3.42275232e-01f, 2.53694266e-01f, 1.92266420e-01f, 4.46097732e-01f, 5.59452295e-01f, 1.55215114e-01f, 1.59015246e-02f, 4.90331620e-01f,
  6.21152580e-01f, 5.92170775e-01f, 4.41045851e-01f, 5.10225832e-01f, 3.25273693e-01f, 1.87564194e-01f, 2.40650967e-01f, 2.48984799e-01f, -3.88056964e-01f, 4.56081212e-01f,
  1.21535331e-01f, 1.46839321e-01f, 6.06271267e-01f, 1.61532730e-01f, -4.22732562e-01f, -8.59425291e-02f, 5.30253649e-01f, 2.30931774e-01f, 1.72923923e-01f, 5.02895378e-02f,
  4.65002626e-01f, -1.53140247e-01f, -4.54826921e-01f, -2.38048390e-01f, 5.34410238e-01f, -3.84469479e-01f, -1.82034820e-01f, 4.54628617e-01f, 1.18954346e-01f, 2.73105502e-01f,
  7.08778873e-02f, 5.68838060e-01f, 2.06965119e-01f, 7.31950283e-01f, 1.97245911e-01f, 5.35143137e-01f, 2.20065475e-01f, 5.69752395e-01f, -2.65323594e-02f, 3.90191637e-02f,
  1.67488143e-01f, 8.41746405e-02f, 9.79501382e-02f, -3.89050335e-01f, -2.19564378e-01f, 6.67442858e-01f, 4.32034135e-01f, -5.58893800e-01f, -6.27984926e-02f, 7.25371122e-01f,
  -5.12533188e-01f, -5.20830929e-01f, -2.57986039e-01f, 3.26500237e-01f, 4.99081284e-01f, -1.64267719e-01f, -7.18847692e-01f, -8.56008112e-01f, 3.24336857e-01f, -4.77550238e-01f,
  1.86123863e-01f, 2.70203769e-01f, 2.53134757e-01f, -1.58609569e-01f, 1.95464239e-01f, -2.46459961e-01f, 2.62662232e-01f, -7.28306994e-02f, 2.88854241e-01f, 1.65671483e-01f,
  3.00913900e-01f, 4.21996444e-01f, 1.10780068e-01f, -1.20096162e-01f, 1.50215164e-01f, -3.33506092e-02f, -3.44021022e-01f, 5.82742179e-03f, -4.59839165e-01f, 1.18796512e-01f,
  -1.76572487e-01f, 7.63883665e-02f, -3.53687018e-01f, 2.80487567e-01f, 4.80001688e-01f, 2.60209978e-01f, 3.75769526e-01f, 4.47340012e-01f, -2.68305659e-01f, 3.98764104e-01f,
  6.07297361e-01f, 4.41472173e-01f, 2.25661874e-01f, 3.54529798e-01f, 7.23079443e-01f, 2.02280983e-01f, -1.33215755e-01f, 4.46530730e-02f, 1.16051279e-01f, 2.26240516e-01f,
  3.55748147e-01f, 7.19471052e-02f, 3.50360453e-01f, 1.63353339e-01f, 5.87796450e-01f, -7.30410278e-01f, -2.53775865e-01f, -5.94034016e-01f, -6.81171298e-01f, 2.92250603e-01f,
  -6.93858229e-03f, 2.68637091e-01f, 1.49254128e-01f, 4.70562220e-01f, -3.16889495e-01f, 6.40816331e-01f, 2.33019263e-01f, 5.56916475e-01f, -5.44296265e-01f, -1.77955851e-01f,
  -1.00653753e-01f, 8.01833719e-02f, 4.82682467e-01f, 1.01287067e-01f, -1.57180354e-01f, 1.12620316e-01f, -1.47746891e-01f, -6.60444200e-02f, 3.02358478e-01f, 2.01091155e-01f,
  2.18719721e-01f, -1.89848825e-01f, 5.29154390e-02f, 5.53672165e-02f, 5.24313331e-01f, 4.42750722e-01f, -6.22200191e-01f, 3.43756795e-01f, 1.27598301e-01f, 2.47143224e-01f,
  3.68976772e-01f, -7.60743320e-02f, -1.51776418e-01f, 2.67295897e-01f, -3.81118029e-01f, -2.42109299e-01f, 5.26701868e-01f, 6.06069230e-02f, 4.84335005e-01f, 3.62845957e-01f,
  2.70946801e-01f, 5.76574206e-01f, -4.73564923e-01f, 3.96616638e-01f, -4.50880706e-01f, 2.12458044e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.83824533e-01f, 3.30481976e-01f, 4.74730819e-01f, 3.72113436e-01f, 5.50411999e-01f, 3.32930386e-01f, 4.03989524e-01f, 1.62179515e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.83604270e-01f, -9.73585472e-02f, -1.96105391e-01f, 1.48271084e-01f, 1.20675622e-03f, -7.65147731e-02f, 7.82657415e-02f, -1.57961680e-03f, -6.15275744e-03f, 5.05284481e-02f,
  -9.09435302e-02f, -5.66261671e-02f, -3.87657434e-01f, 2.98801959e-01f, 3.71338278e-01f, 1.07827023e-01f, -3.83484483e-01f, 5.74055463e-02f, 1.97628647e-01f, -3.33244316e-02f,
  -2.23783985e-01f, -5.12753092e-02f, 2.77470529e-01f, -1.97827131e-01f, 8.47401321e-02f, -6.11928925e-02f, -7.11239651e-02f, -3.32650065e-01f, -9.62107070e-03f, 1.16399758e-01f,
  2.59803504e-01f, -1.79791138e-01f, 1.95109710e-01f, 1.99712381e-01f, -1.18706800e-01f, -2.03950033e-01f, -1.72547251e-01f, 1.07632622e-01f, 2.53266782e-01f, 2.39571199e-01f,
  2.76845068e-01f, 2.97668457e-01f, -1.44449607e-01f, -2.14207575e-01f, -1.79246608e-02f, 3.82763624e-01f, 3.23107034e-01f, 2.00417325e-01f, -2.18704358e-01f, 2.34810337e-01f,
  -1.83484197e-01f, -1.35928333e-01f, -2.18542535e-02f, 2.46635273e-01f, 3.33306864e-02f, 2.92714387e-02f, 1.18091784e-01f, 1.66405544e-01f, -3.20677787e-01f, -3.10871273e-01f,
  -2.10529968e-01f, 4.45491709e-02f, 2.48976380e-01f, 7.62452260e-02f, -1.55886458e-02f, 1.55646950e-01f, 3.50241423e-01f, 1.49908498e-01f, 1.97862178e-01f, -2.87253380e-01f,
  -1.81082368e-01f, -2.73560256e-01f, 5.12816459e-02f, -2.53475279e-01f, 2.93093234e-01f, 3.30613111e-03f, 1.16360784e-01f, -3.23090963e-02f, -2.75939941e-01f, 2.11700827e-01f,
  -3.56809497e-01f, -1.45013601e-01f, -1.70706332e-01f, -2.34119922e-01f, 3.04260664e-02f, 4.53047812e-01f, 3.53206873e-01f, 8.74613896e-02f, 1.77610710e-01f, -1.28745824e-01f,
  1.87849384e-02f, -2.75455892e-01f, -4.37130071e-02f, 6.28095940e-02f, 1.38749510e-01f, 5.85917979e-02f, 2.05982272e-02f, -9.39318389e-02f, 1.75571352e-01f, -1.85866565e-01f,
  -5.74915558e-02f, -1.91550657e-01f, -4.28994119e-01f, -1.43653169e-01f, 5.35854548e-02f, 4.30522822e-02f, -1.97291508e-01f, -1.40681580e-01f, 1.93495914e-01f, 9.04575959e-02f,
  8.32785368e-02f, 1.58298269e-01f, 1.86688542e-01f, -1.10975981e-01f, 1.17809080e-01f, 5.96263446e-02f, -1.98407948e-01f, 1.12583734e-01f, 3.38294923e-01f, 2.17631370e-01f,
  1.40651330e-01f, -1.30120842e-02f, -2.74728477e-01f, -1.91987857e-01f, -3.47608984e-01f, 2.92794973e-01f, 1.26873150e-01f, 1.82331666e-01f, 1.13526553e-01f, -2.02870034e-02f,
  -2.96596825e-01f, -8.53490829e-02f, 1.39427304e-01f, 1.85629323e-01f, 3.26186061e-01f, 6.60056621e-02f, -2.04916090e-01f, 2.02996060e-01f, 1.50183976e-01f, -1.88346535e-01f,
  3.18273306e-01f, 5.12519740e-02f, -1.24642104e-01f, 2.96732247e-01f, -1.91903070e-01f, 3.30831409e-02f, 2.47450635e-01f, 2.64917701e-01f, 2.22271353e-01f, -1.61243796e-01f,
  2.83041716e-01f, 2.67662972e-01f, 2.95888702e-03f, 3.38107012e-02f, 3.23781334e-02f, -2.81267345e-01f, 3.96617591e-01f, -3.21438849e-01f, 2.73292661e-01f, -1.35674894e-01f,
  7.70052150e-03f, -1.17794991e-01f, -2.90510505e-01f, -1.12955146e-01f, -1.75755143e-01f, -3.52957174e-02f, 1.56324372e-01f, 2.35780939e-01f, -4.06355485e-02f, -2.57519275e-01f,
  -8.49721506e-02f, -1.40971705e-01f, -2.19093189e-02f, -3.05638254e-01f, -2.50874728e-01f, -2.50952959e-01f, 4.65818137e-01f, 3.05885263e-02f, 2.09802821e-01f, 8.06802586e-02f,
  2.17044681e-01f, -3.08263123e-01f, -5.35266511e-02f, 3.56797278e-01f, 7.75356963e-02f, -2.55423218e-01f, -2.44377241e-01f, 1.56907871e-01f, -1.11585066e-01f, 2.77963787e-01f,
  -1.99554160e-01f, 2.51359791e-01f, 1.69910163e-01f, -1.60526425e-01f, -2.40574647e-02f, -1.21288985e-01f, -6.69139177e-02f, 5.24390154e-02f, -6.08772747e-02f, 2.89960392e-02f,
  3.56455743e-02f, -3.30969468e-02f, -1.38438279e-02f, -1.90548413e-02f, 1.07776538e-01f, 1.27040386e-01f, 1.55402839e-01f, 4.44424421e-01f, -3.13945919e-01f, -1.00198478e-01f,
  9.86113101e-02f, -7.29436800e-02f, -3.64910215e-01f, 3.79485376e-02f, 3.53294127e-02f, -1.60643205e-01f, 1.31106377e-02f, 7.02568516e-02f, -2.20134020e-01f, -3.22650224e-01f,
  2.85203457e-01f, 2.49499381e-02f, 3.24754000e-01f, -1.19927198e-01f, 1.15332462e-01f, -3.25864255e-01f, 2.43732125e-01f, -2.98382156e-02f, -1.18503094e-01f, -1.40024602e-01f,
  2.99870431e-01f, 5.70895411e-02f, 1.73749343e-01f, -3.97116572e-01f, -2.38744412e-02f, 2.27464095e-01f, -5.79004176e-02f, 6.75061867e-02f, -3.88916805e-02f, 1.10584132e-01f,
  4.92252678e-01f, -4.37111259e-01f, 8.45776275e-02f, -2.12878063e-02f, 2.85941422e-01f, 3.90146971e-02f, -2.26785287e-01f, -1.50987595e-01f, -1.00450441e-01f, 2.52172351e-02f,
  -2.64891833e-01f, 2.43450657e-01f, -3.49689871e-01f, 2.51203597e-01f, 7.90510233e-03f, 1.47826120e-01f, -1.63096562e-02f, 1.32490605e-01f, -1.26443297e-01f, -2.19801307e-01f,
  6.83065057e-02f, 2.10336745e-01f, -1.47096306e-01f, 4.92335558e-02f, 7.93597549e-02f, 2.44015023e-01f, -1.73662841e-01f, -1.56518251e-01f, 3.42932194e-01f, 3.83935601e-01f,
  3.09000462e-01f, 1.17099106e-01f, -2.89126247e-01f, 2.57393926e-01f, -7.21070245e-02f, 1.39551073e-01f, -2.59796996e-02f, 1.36722093e-02f, 2.49284714e-01f, 2.91167796e-01f,
  2.18964964e-01f, 4.33053933e-02f, -2.80169815e-01f, -2.96972483e-01f, -3.71237472e-02f, 1.31608829e-01f, 2.40640283e-01f, -3.53777260e-02f, -1.26473114e-01f, -1.04907088e-01f,
  1.83911659e-02f, 1.09691948e-01f, -1.22488998e-01f, 6.88334852e-02f, -9.00286362e-02f, 3.52095179e-02f, -1.41776428e-01f, -2.87959009e-01f, 1.02793187e-01f, -5.91472797e-02f,
  5.98249547e-02f, -1.99976057e-01f, -2.95022935e-01f, -4.22893524e-01f, 4.16340858e-01f, 5.71967103e-02f, 2.04914138e-01f, 1.17910914e-01f, 1.42202213e-01f, -1.16668001e-01f,
  -6.04917854e-02f, 3.49279046e-01f, 1.42491490e-01f, -2.34205738e-01f, -3.87334451e-02f, 1.00272439e-01f, -2.35637009e-01f, 2.92618543e-01f, -1.85781538e-01f, 1.71829775e-01f,
  -1.94423079e-01f, 2.72722185e-01f, 2.99940184e-02f, 6.76800236e-02f, -1.30239904e-01f, 1.40510201e-01f, -1.15490565e-02f, 1.70788050e-01f, 1.04228832e-01f, 4.12789136e-01f,
  8.09735283e-02f, 1.47298649e-01f, -3.00051570e-01f, 2.58706748e-01f, 3.91273171e-01f, -2.81062990e-01f, -2.13256419e-01f, 3.32133383e-01f, -1.22393757e-01f, -3.04298699e-01f,
  -3.55966151e-01f, -1.08660169e-01f, -3.39392155e-01f, -1.08034134e-01f, -2.37948503e-02f, 3.37962270e-01f, -2.27424532e-01f, 2.18725890e-01f, -1.44403875e-01f, -5.91275580e-02f,
  1.63145155e-01f, -1.20105810e-01f, -1.05006792e-01f, -6.62641600e-02f, -1.79519486e-02f, 4.03072760e-02f, 1.99409083e-01f, 7.40293786e-02f, -2.14807287e-01f, 1.98358729e-01f,
  2.37248391e-01f, 9.07924324e-02f, 2.21626118e-01f, 1.70316949e-01f, -2.21242309e-01f, 1.41347870e-01f, 7.29587823e-02f, -3.18216175e-01f, -3.02670687e-01f, 4.73370969e-01f,
  -2.96245992e-01f, -4.15170163e-01f, 3.67525369e-02f, -8.86668190e-02f, 1.35848388e-01f, 8.53972286e-02f, 4.45386656e-02f, 8.53030235e-02f, -1.84289128e-01f, 1.84003755e-01f,
  2.14256600e-01f, -3.49886209e-01f, -1.69963539e-01f, 9.84850377e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.73727861e-02f, 5.45262635e-01f, -1.61381334e-01f, -4.38368410e-01f, 5.36807120e-01f, -3.49008352e-01f, -3.40788126e-01f, -7.86965340e-03f, 1.81462184e-01f, -1.89287458e-02f,
  -8.17034766e-02f, -4.95908916e-01f, 9.49755430e-01f, -1.25235155e-01f, -5.38266122e-01f, -1.27808064e-01f, 1.63385704e-01f, 2.83674002e-01f, 5.80665708e-01f, 5.45511663e-01f,
  3.26012373e-01f, 9.84364599e-02f, 9.51196969e-01f, 4.36747909e-01f, 3.31249863e-01f, -7.61426151e-01f, 5.27506545e-02f, -3.44816178e-01f, 1.07394755e+00f, 6.54892385e-01f,
  9.21122432e-01f, 1.41576707e-01f, 4.71977830e-01f, 2.09168598e-01f, 1.83617488e-01f, -4.97441977e-01f, -5.22724032e-01f, -5.64003706e-01f, -1.99530795e-02f, -4.51948047e-01f,
  1.72045201e-01f, -5.66962838e-01f, -3.61722082e-01f, -7.33745337e-01f, 2.45984033e-01f, -1.79557770e-01f, -2.75504906e-02f, 6.01059735e-01f, 4.06104952e-01f, -7.97776937e-01f,
  4.64551598e-01f, 7.94540226e-01f, -1.82139173e-01f, 1.96360946e-01f, -6.51429892e-02f, -4.92230207e-01f, -2.33768284e-01f, 2.40046784e-01f, 4.82642800e-01f, 7.74609074e-02f,
  -2.23135263e-01f, 9.47662413e-01f, 3.50395083e-01f, 3.80846292e-01f, 4.67453338e-02f, 1.08776122e-01f, -4.31697577e-01f, 4.18280065e-02f, -4.50309403e-02f, 5.73995531e-01f,
  5.94987094e-01f, 2.88451970e-01f, 4.24725295e-04f, 5.43455005e-01f, 1.81959569e-01f, -7.09832758e-02f, -1.15624332e+00f, 9.57123995e-01f, 8.83962095e-01f, 4.78172749e-01f,
  -5.41468203e-01f, 4.58169729e-01f, 1.66685015e-01f, -4.54401046e-01f, -8.49828422e-01f, -1.93019167e-01f, -3.75034571e-01f, -4.18258458e-01f, 6.09515131e-01f, 7.58441865e-01f,
  6.51241124e-01f, -2.40227178e-01f, -6.66868985e-01f, 6.71668530e-01f, 6.10840678e-01f, 1.92752019e-01f, 1.40899196e-01f, -2.00877160e-01f, -1.11432448e-01f, 3.73609424e-01f,
  2.15459272e-01f, 4.54895914e-01f, 4.63673115e-01f, 5.44829011e-01f, 1.51110142e-01f, -4.29015517e-01f, 5.17648280e-01f, 4.05389339e-01f, 3.17245245e-01f, -6.11186326e-01f,
  -4.33871925e-01f, 5.51760972e-01f, 3.69030327e-01f, -3.50533366e-01f, 7.48204172e-01f, -5.91084003e-01f, 1.81625634e-01f, -1.60688996e-01f, 6.57869637e-01f, -1.78731248e-01f,
  -1.97414219e-01f, -4.26362127e-01f, 9.95725393e-02f, 1.93310440e-01f, 8.80649686e-01f, 2.90364176e-01f, 5.38280487e-01f, -5.82324982e-01f, -3.24853696e-02f, 4.53410149e-01f,
  4.88024145e-01f, 5.36388993e-01f, 5.14461040e-01f, 3.35261911e-01f, -1.61761194e-01f, 5.01717567e-01f, 6.03902400e-01f, 1.38649330e-01f, 6.68903470e-01f, 5.16797602e-01f,
  -5.35302162e-01f, -4.34556544e-01f, 4.19314176e-01f, -3.73771340e-01f, -2.81899989e-01f, 4.65295464e-01f, -6.33385181e-01f, -8.54973197e-01f, -3.39177549e-01f, -2.14616999e-01f,
  -3.61869544e-01f, -6.26642823e-01f, 4.25142318e-01f, 8.76458645e-01f, 4.26781118e-01f, 9.12142873e-01f, 2.51110256e-01f, -4.88712013e-01f, -1.30074173e-01f, 4.80319187e-02f,
  1.14919417e-01f, 2.89116353e-01f, 2.14211926e-01f, -1.13129072e-01f, 1.90040320e-01f, 4.51073080e-01f, 1.78541467e-01f, 3.15371186e-01f, -1.64924443e-01f, 1.97041437e-01f,
  3.02646637e-01f, 2.64801383e-01f, 3.47025871e-01f, -5.61249554e-01f, -4.81216520e-01f, -8.48637283e-01f, 5.24205685e-01f, 6.84522927e-01f, -9.93683338e-02f, 6.57315671e-01f,
  8.09371591e-01f, -4.98349160e-01f, 2.13873506e-01f, 7.50225127e-01f, 3.70896727e-01f, -7.23164499e-01f, -1.24574266e-01f, 5.49539149e-01f, 3.99779886e-01f, 3.95873874e-01f,
  -5.42005241e-01f, 3.27238142e-01f, 5.58038533e-01f, 2.09425583e-01f, 1.89235702e-01f, -2.38134384e-01f, 3.76774855e-02f, -1.16204686e-01f, 3.78551900e-01f, 8.01676959e-02f,
  5.96827745e-01f, -2.84450322e-01f, 2.35259011e-01f, 4.32942837e-01f, -4.64719623e-01f, -2.74013966e-01f, 2.82174915e-01f, 5.26624262e-01f, 5.78470349e-01f, -7.03257501e-01f,
  6.44199625e-02f, 1.14070654e-01f, 3.63118917e-01f, -1.78643569e-01f, -4.73579377e-01f, -5.20907819e-01f, -3.28724295e-01f, -1.10994570e-01f, 3.91435802e-01f, 5.24833679e-01f,
  5.62131941e-01f, 2.12530553e-01f, 6.21650636e-01f, 6.51485547e-02f, 3.35105896e-01f, 7.99884349e-02f, 4.70229506e-01f, 3.26316237e-01f, 2.27044404e-01f, -3.51108402e-01f,
  -2.04914883e-01f, 1.23229250e-01f, 4.26480621e-01f, 4.54933137e-01f, 4.93665248e-01f, 3.64717543e-01f, -3.31836864e-02f, 6.47485435e-01f, 7.67869726e-02f, -2.98843741e-01f,
  1.51594654e-01f, 5.87598205e-01f, -5.07722437e-01f, -6.08392321e-02f, 3.50718945e-01f, 5.57990968e-01f, 5.50567150e-01f, 5.13045788e-01f, 8.11913788e-01f, 1.70824215e-01f,
  -5.12448132e-01f, -1.15313657e-01f, 5.55599779e-02f, 3.76020610e-01f, -6.03567779e-01f, 8.26889992e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.56256413e-01f, 2.82323003e-01f, 1.16372347e-01f, 2.02080488e-01f, 5.50452232e-01f, 3.30591887e-01f, 7.69063309e-02f, 3.09166878e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  3.65226083e-02f, -4.19351488e-01f, -1.05588324e-01f, -2.90218610e-02f, -3.42309535e-01f, -4.18015987e-01f, 7.08576217e-02f, 8.26906636e-02f, 4.38221455e-01f, -1.01012282e-01f,
  -1.59505084e-01f, 3.35033357e-01f, -3.10326755e-01f, -3.22524011e-01f, -5.52534342e-01f, -3.16335589e-01f, 3.43725502e-01f, 2.78497666e-01f, -1.01430446e-01f, -4.74790245e-01f,
  -3.03955942e-01f, 4.62398946e-01f, -4.14727479e-01f, 3.68855186e-02f, 4.82334822e-01f, -5.32730877e-01f, -5.73658407e-01f, 2.88259000e-01f, -6.64007902e-01f, 5.75250745e-01f,
  -3.76916021e-01f, -3.30902636e-01f, -2.41438419e-01f, 4.12462801e-01f, 7.45790750e-02f, 3.96011561e-01f, 3.15137058e-01f, 2.72776335e-01f, 3.32183614e-02f, -1.21853471e-01f,
  1.23633020e-01f, 2.06115961e-01f, 3.79998535e-01f, -1.33765653e-01f, -2.55858988e-01f, 4.95195985e-01f, 3.51664513e-01f, 1.64645404e-01f, 5.23034155e-01f, 3.06159109e-01f,
  -2.97421694e-01f, -5.09204745e-01f, 5.78290105e-01f, 2.45557696e-01f, 7.73601755e-02f, 2.55250812e-01f, 4.24657911e-01f, -5.92380285e-01f, -8.35506320e-01f, -8.54666412e-01f,
  3.01845167e-02f, 4.25995380e-01f, -6.78996205e-01f, 5.11626482e-01f, -4.08026017e-02f, -4.56910998e-01f, 1.05823584e-01f, 2.08292291e-01f, -2.80896574e-01f, 2.63690472e-01f,
  2.64184535e-01f, 4.08965498e-02f, -2.05738410e-01f, 2.72124439e-01f, -3.00100505e-01f, -2.78612167e-01f, 3.33941907e-01f, 3.74296784e-01f, 4.59116787e-01f, 5.60480118e-01f,
  -3.77440661e-01f, -2.52793193e-01f, 8.16406831e-02f, -2.55290773e-02f, 5.72982550e-01f, 2.68903136e-01f, 3.36890996e-01f, 3.77078950e-01f, -7.47274041e-01f, -6.18710041e-01f,
  2.11347401e-01f, -3.52527529e-01f, 1.11303598e-01f, -4.66495574e-01f, -6.52031541e-01f, 5.96057773e-01f, 4.03598733e-02f, 2.25603268e-01f, -5.08749127e-01f, 1.23970471e-01f,
  -3.37886572e-01f, -2.89836794e-01f, -4.33987647e-01f, -1.69822931e-01f, 1.43495589e-01f, 4.06090505e-02f, -4.84231003e-02f, -2.70815134e-01f, 4.80433941e-01f, -5.09744883e-01f,
  5.05452693e-01f, 2.98119068e-01f, 3.71425211e-01f, -4.67167616e-01f, -8.39483142e-02f, -6.67000830e-01f, 7.31429085e-02f, -4.39575106e-01f, -5.33822417e-01f, -1.73790827e-01f,
  5.37904620e-01f, 4.29987878e-01f, -5.89753389e-01f, -4.51260526e-03f, -7.90231407e-01f, -5.49677134e-01f, 9.05078128e-02f, -2.05591187e-01f, 3.15452546e-01f, -3.67070436e-01f,
  3.99322897e-01f, -1.52912989e-01f, 5.58212817e-01f, 5.48908472e-01f, 3.81459117e-01f, 7.28144124e-02f, -4.55805749e-01f, 4.73101377e-01f, 2.62296468e-01f, 1.28286093e-01f,
  -6.75974667e-01f, -4.74210024e-01f, 3.17695081e-01f, -1.56556979e-01f, 4.55886096e-01f, 3.46756242e-02f, 5.32876849e-01f, 7.11923003e-01f, -5.40793359e-01f, -1.78054154e-01f,
  -5.22933841e-01f, -3.13838363e-01f, 3.36574465e-02f, 9.72679257e-02f, -7.19585061e-01f, 5.07650435e-01f, 1.09549344e-01f, -3.43525648e-01f, 1.96440205e-01f, -4.66427803e-01f,
  -2.74765342e-01f, -1.39452890e-01f, -3.40679854e-01f, -1.52906746e-01f, -4.60539795e-02f, 1.32102102e-01f, -3.97178024e-01f, -1.42162098e-02f, -2.30499446e-01f, 4.15236801e-02f,
  4.68337387e-02f, -7.27253184e-02f, -5.09933718e-02f, -3.37487698e-01f, -4.55212265e-01f, -2.25134522e-01f, -4.63791162e-01f, 6.57814384e-01f, -6.16373320e-04f, 6.93209708e-01f,
  -3.56061488e-01f, 6.49463773e-01f, 6.15563154e-01f, 2.26777315e-01f, -7.11456239e-01f, -5.72282016e-01f, -3.02028596e-01f, -1.78956509e-01f, 2.83384979e-01f, 5.81209004e-01f,
  2.26599365e-01f, 7.95966685e-02f, 1.13855697e-01f, 4.75284576e-01f, -2.07862128e-02f, -3.16860497e-01f, -3.83349687e-01f, -1.87438965e-01f, -2.92716324e-01f, 2.79151618e-01f,
  2.97568068e-02f, 1.09748863e-01f, -2.13553421e-02f, -3.14630747e-01f, -3.39719892e-01f, -4.90221500e-01f, -3.74717146e-01f, -4.63153750e-01f, -2.71648109e-01f, -4.73036438e-01f,
  -3.34333599e-01f, -5.14568031e-01f, -5.51700056e-01f, -5.22073627e-01f, -4.02807146e-01f, 5.73273897e-01f, -3.18348169e-01f, -6.88587308e-01f, 8.39892104e-02f, -5.21684885e-01f,
  6.10829592e-01f, -5.70154428e-01f, -3.60313773e-01f, -3.68443519e-01f, 7.42122605e-02f, 6.67673349e-02f, 1.80269688e-01f, -1.48621738e-01f, -1.72684073e-01f, 3.17572236e-01f,
  1.31820917e-01f, -3.42276603e-01f, 2.26981014e-01f, 2.75973618e-01f, -1.10208496e-01f, -1.80080548e-01f, 2.80154169e-01f, 3.80277634e-01f, -1.37154534e-01f, 5.19549727e-01f,
  -3.81161988e-01f, 5.58564961e-01f, 4.26990569e-01f, 5.18327057e-01f, 2.92036355e-01f, 5.41789532e-01f, 3.13796848e-01f, -9.26752836e-02f, 2.66620040e-01f, 5.79701364e-01f,
  2.25009069e-01f, -4.95247036e-01f, -8.98719251e-01f, -4.02169675e-01f, -1.14814220e-02f, -5.42216778e-01f, 2.28926674e-01f, -2.90369503e-02f, -2.45583523e-02f, -3.44465405e-01f,
  -2.30022311e-01f, -2.48941854e-01f, -3.67553979e-01f, -6.27839789e-02f, -2.92077605e-02f, -2.90837705e-01f, 1.09293528e-01f, 4.29912619e-02f, 8.28724653e-02f, 2.78399885e-01f,
  3.23353738e-01f, 2.73563236e-01f, -3.32161188e-01f, 7.82056823e-02f, -2.22348541e-01f, 3.06872249e-01f, 3.00724387e-01f, 1.50270030e-01f, -3.09914410e-01f, -4.54158217e-01f,
  1.57688096e-01f, 3.30349892e-01f, 2.00192034e-01f, -5.53674877e-01f, -7.01030314e-01f, 1.41779006e-01f, -6.31043017e-01f, 3.39889526e-01f, -1.20839417e-01f, 2.08769768e-01f,
  -4.62935001e-01f, 3.65197174e-02f, -1.45337000e-01f, 4.17215168e-01f, -8.29700902e-02f, -8.46355557e-02f, -7.35728145e-02f, 6.29222989e-02f, -1.88634172e-01f, 5.70861995e-02f,
  -6.00606322e-01f, -1.86154842e-01f, -2.21959263e-01f, -3.41503531e-01f, -5.49370468e-01f, -4.38994050e-01f, -4.93423074e-01f, 5.80495238e-01f, -3.07934880e-01f, -1.70470059e-01f,
  3.81791413e-01f, -6.10568166e-01f, -7.16846824e-01f, 6.03623748e-01f, 2.37778947e-02f, -7.93319345e-01f, -6.78355321e-02f, -4.40822899e-01f, 3.16435426e-01f, -3.29462260e-01f,
  -3.25028896e-01f, 2.92335033e-01f, 3.00394535e-01f, -3.45462352e-01f, -3.95966679e-01f, -3.11358094e-01f, -4.44250762e-01f, -2.90207058e-01f, 6.84195161e-02f, -4.83186364e-01f,
  2.03860149e-01f, 3.34885627e-01f, 5.06202579e-01f, 4.47364330e-01f, 2.81368215e-02f, -2.35619575e-01f, 8.94410834e-02f, -2.60912508e-01f, 2.79889673e-01f, -4.43280160e-01f,
  2.42829055e-01f, 7.12230355e-02f, 6.05995297e-01f, 2.49608792e-02f, 2.35940203e-01f, -5.65577745e-01f, 1.11224204e-01f, 2.39439815e-01f, -7.76123032e-02f, -5.00885785e-01f,
  2.23181039e-01f, -6.82995170e-02f, -2.21214499e-02f, -2.30963185e-01f, 4.13375586e-01f, 4.84591946e-02f, 5.79719841e-01f, -5.02573133e-01f, 2.34175086e-01f, 2.20353156e-01f,
  2.68980026e-01f, -2.44231284e-01f, -3.98116410e-01f, 2.31103078e-01f, 7.15875626e-01f, 6.28923476e-01f, -2.78165996e-01f, -3.06537330e-01f, 3.62582058e-01f, -1.97126508e-01f,
  5.66622913e-01f, -6.84268594e-01f, 2.48270437e-01f, -3.45972955e-01f, 1.77805647e-01f, -2.67450243e-01f, -6.65870607e-01f, 1.14744015e-01f, 6.07748330e-01f, -3.40061128e-01f,
  -1.49744466e-01f, -2.02009231e-01f, -2.69642860e-01f, -6.60537541e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.99117652e-02f, 7.85120297e-03f, 6.75607920e-02f, 3.93928550e-02f, 1.76203638e-01f, 3.35983001e-02f, -1.32679641e-02f, 7.61008933e-02f, -9.21560393e-04f, -9.07580927e-03f,
  9.11943018e-02f, 1.74181849e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    