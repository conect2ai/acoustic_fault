/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.92227978e-01f, 1.33128166e-01f, -1.03713386e-01f, 6.67962618e-03f, 1.77339494e-01f, 2.60100216e-01f, -9.69849974e-02f, 1.36890203e-01f, 8.81135166e-02f, 4.44184579e-02f,
  -1.47791415e-01f, -5.34821637e-02f, -2.46309325e-01f, -6.64345250e-02f, -7.48392940e-02f, -2.77201146e-01f, 1.31432965e-01f, 1.46541167e-02f, 2.88406108e-03f, 1.39641568e-01f,
  -1.46462694e-02f, 6.37557730e-03f, -8.85957405e-02f, 5.79973049e-02f, 1.88897833e-01f, 1.22510634e-01f, 3.30513865e-02f, -8.30975026e-02f, 1.23003632e-01f, -3.73386070e-02f,
  1.23454437e-01f, -4.62514237e-02f, -4.58666831e-02f, -1.09460000e-02f, 1.81226179e-01f, -5.13862856e-02f, 1.13386521e-02f, -2.03151092e-01f, -5.03295287e-02f, -4.00918722e-02f,
  -1.48262009e-02f, -1.90863628e-02f, 7.05223754e-02f, -1.31005362e-01f, 1.24693960e-01f, -8.09345692e-02f, -2.18614340e-02f, 1.36430049e-02f, 2.71826237e-03f, 2.57019717e-02f,
  1.56653244e-02f, -6.81115612e-02f, 5.00427969e-02f, 5.83642460e-02f, -2.28652880e-02f, -5.97672760e-02f, -4.50518057e-02f, -4.30719629e-02f, 1.43652102e-02f, 1.96190059e-01f,
  -3.53216305e-02f, -1.74452981e-03f, -5.03680087e-04f, 1.15978094e-02f, -9.46024433e-03f, 4.82914522e-02f, -1.87143330e-02f, -6.02454729e-02f, 5.29183038e-02f, 3.56632308e-03f,
  1.23164311e-01f, 1.78543311e-02f, -3.34969535e-02f, 5.41491881e-02f, 4.24164385e-02f, 4.70561683e-02f, 7.22162575e-02f, 7.39528984e-02f, 1.40869379e-01f, -1.91537421e-02f,
  -1.00270085e-01f, 1.05502538e-01f, -4.56935838e-02f, -5.86019829e-04f, -6.00314364e-02f, -9.05161723e-02f, -5.93148172e-02f, 1.48984930e-02f, -2.69096158e-02f, 4.41458896e-02f,
  2.39813581e-01f, 1.14732631e-01f, 7.27568101e-03f, 7.04266950e-02f, 2.59431778e-03f, 7.68240318e-02f, -6.17426336e-02f, -6.27300590e-02f, -1.00849029e-02f, 1.06432885e-02f,
  1.23096025e-02f, 8.60815048e-02f, 1.01411045e-01f, 3.76131311e-02f, -3.79579403e-02f, -2.02687667e-03f, -2.02529524e-02f, 4.18850631e-02f, 9.25374478e-02f, 1.45986736e-01f,
  -1.01300534e-02f, 6.44303337e-02f, -8.49036220e-03f, 8.53406042e-02f, 2.45720986e-03f, 6.94318041e-02f, 1.42850459e-01f, -1.52016827e-03f, -1.59351565e-02f, 3.69627923e-02f,
  -4.95506264e-03f, -2.92014360e-01f, 2.22280264e-01f, -1.05753802e-01f, -2.97810752e-02f, 1.15523264e-01f, -7.25124627e-02f, -8.80100206e-02f, -1.52948156e-01f, -3.32670659e-01f,
  -2.97723282e-02f, -8.30939338e-02f, 1.62629727e-02f, 9.27456468e-03f, 3.20403844e-01f, 2.40669042e-01f, 5.54515831e-02f, -8.15402567e-02f, 2.12115273e-02f, -1.97020739e-01f,
  1.42719552e-01f, -8.10210034e-02f, 3.67561996e-01f, -5.93075603e-02f, 2.94584669e-02f, 4.06153426e-02f, 2.97107361e-02f, 5.82607239e-02f, -6.08891807e-02f, 7.13036284e-02f,
  -4.34942991e-02f, -1.78338408e-01f, 1.11563243e-01f, -9.33595235e-04f, 4.54787724e-02f, 4.77653444e-02f, -4.48057912e-02f, 9.82619226e-02f, 7.96192735e-02f, 1.33501673e-02f,
  3.72297950e-02f, 1.10017814e-01f, -2.62721721e-02f, 1.56538188e-02f, -5.20105511e-02f, 6.49945140e-02f, 1.04958005e-02f, 9.98885334e-02f, -6.80381209e-02f, 7.69018680e-02f,
  1.03674736e-02f, 1.03451312e-01f, 9.04976651e-02f, 9.25398842e-02f, 1.76540211e-01f, 3.71831730e-02f, 1.24366485e-01f, 1.23195447e-01f, 5.35753556e-02f, 2.43216287e-02f,
  -4.54008877e-02f, -3.21171768e-02f, 4.69023734e-02f, -2.52651721e-02f, -1.19489819e-01f, 6.87259734e-02f, -1.18110761e-01f, 1.13174722e-01f, -2.99435179e-03f, -5.97820394e-02f,
  -8.02580267e-03f, -1.20282128e-01f, -5.24068512e-02f, -5.80433607e-02f, 2.10909192e-02f, -3.48679349e-02f, 6.93426505e-02f, 8.44893418e-03f, -5.96966818e-02f, 4.00607195e-03f,
  -4.48500663e-02f, -5.35936914e-02f, -6.30384386e-02f, -1.74245574e-02f, -4.26330194e-02f, -5.24090864e-02f, -1.12458523e-02f, -4.14939560e-02f, -1.91823463e-03f, 1.47534953e-02f,
  -1.92856804e-01f, -3.74502540e-01f, -5.71416318e-02f, -2.68157925e-02f, -3.69747691e-02f, 4.58743423e-03f, 7.81107619e-02f, 9.54629295e-03f, -4.31196727e-02f, -6.73440471e-02f,
  6.65700585e-02f, -5.90596832e-02f, 5.68803400e-02f, -6.65077716e-02f, 2.24293564e-02f, -2.20126119e-02f, -4.07093437e-03f, 3.11901909e-03f, 4.11956497e-02f, -5.98953627e-02f,
  -4.99692596e-02f, -8.38536397e-02f, 3.77444997e-02f, 2.92085465e-02f, 4.39170450e-02f, -4.96082567e-02f, -1.09001501e-02f, -4.84544039e-02f, 5.50409630e-02f, -9.47731454e-03f,
  3.27595696e-03f, -2.97050625e-02f, -2.12549239e-01f, -2.48185232e-01f, 1.68419972e-01f, 8.13018382e-02f, -6.98519796e-02f, 5.67936786e-02f, -3.26070964e-01f, 3.32140736e-02f,
  -5.47297252e-03f, 2.53822794e-03f, -9.39289480e-02f, -6.15019090e-02f, -3.39171678e-01f, -2.89627254e-01f, -5.36251664e-02f, 8.62424597e-02f, -9.40479934e-02f, 9.55624431e-02f,
  -1.22686766e-01f, 8.43249261e-02f, -1.80796325e-01f, 1.50154591e-01f, 2.38589376e-01f, 6.20702021e-02f, 1.29683226e-01f, 1.71999377e-03f, 1.70270115e-01f, 1.68627203e-01f,
  4.70658019e-02f, -9.41911340e-02f, -2.19970122e-02f, -8.65246579e-02f, 3.40361521e-02f, 3.86214964e-02f, 2.44897027e-02f, 1.83921885e-02f, -2.23063715e-02f, 8.70768502e-02f,
  5.27527444e-02f, 2.33728644e-02f, 3.86642851e-02f, 1.31184096e-02f, 1.07412916e-02f, -8.88194889e-02f, -4.09076475e-02f, 2.62220763e-02f, -1.38731580e-02f, -3.96685116e-02f,
  -2.86541134e-02f, -4.60181311e-02f, 1.95984282e-02f, 4.18010838e-02f, 3.46185965e-03f, -7.20019788e-02f, -4.37608222e-03f, 1.11155517e-01f, 6.99938387e-02f, -4.24026810e-02f,
  1.12647392e-01f, 1.03923073e-02f, 5.73157035e-02f, -2.59101335e-02f, -9.69588384e-02f, 1.35352677e-02f, 1.51767228e-02f, 1.31936282e-01f, 5.60075007e-02f, -4.34315503e-02f,
  2.74940766e-02f, -9.24067721e-02f, 5.71783744e-02f, -5.39672300e-02f, 1.13006849e-02f, 3.39606963e-02f, -4.63735349e-02f, 7.02657327e-02f, -5.31198876e-03f, -6.22010743e-03f,
  6.45025773e-03f, -1.50411790e-02f, -1.11955497e-02f, 1.40442610e-01f, 1.39155909e-02f, -7.07558244e-02f, -3.87524371e-03f, -6.04379587e-02f, -2.21632011e-02f, 5.37496917e-02f,
  -1.08086038e-02f, -5.54722659e-02f, -4.04734015e-02f, -2.39069853e-02f, -1.33151531e-01f, -4.41163555e-02f, -1.07323609e-01f, 6.46508783e-02f, -5.64972460e-02f, -5.86552061e-02f,
  2.76811477e-02f, 3.59331407e-02f, 2.05050092e-02f, 9.12474282e-03f, 4.87305485e-02f, 3.13993692e-02f, -4.32303362e-02f, 1.03594460e-01f, 9.71788540e-02f, 5.07788062e-02f,
  1.06582314e-01f, 2.10819952e-02f, 3.61748189e-02f, 3.41753773e-02f, 3.65200937e-02f, 3.71270366e-02f, 1.18346445e-01f, -6.33568093e-02f, 1.12014368e-01f, 6.96448609e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.52680659e-01f, 5.04549704e-02f, 4.57742572e-01f, 2.88656298e-02f, 2.38953084e-01f, 4.26652014e-01f, 3.16367507e-01f, 1.06742345e-02f, 2.76462972e-01f, -4.05704290e-01f,
  -1.99031442e-01f, 2.43626297e-01f, 2.39748701e-01f, -9.89948586e-02f, 6.17710985e-02f, -8.23844373e-02f, 2.08485015e-02f, -3.36464830e-02f, 2.54085153e-01f, 8.56561065e-02f,
  -5.94279356e-03f, -3.78129363e-01f, 8.34405646e-02f, -4.04059768e-01f, -8.16769525e-03f, -5.37191629e-02f, -4.71921891e-01f, 1.96512327e-01f, -4.21374708e-01f, -1.45900212e-02f,
  5.06257676e-02f, 4.47452962e-02f, 3.08965653e-01f, 2.11949572e-01f, 3.03508695e-02f, 1.51345385e-02f, 6.87255710e-02f, 2.20240392e-02f, 1.25610322e-01f, -1.47611760e-02f,
  1.07857324e-01f, -6.09891377e-02f, -1.01261251e-01f, -6.80588884e-03f, 1.30766228e-01f, -2.56190244e-02f, 1.98358968e-01f, 1.02590963e-01f, 1.28513038e-01f, 2.02394888e-01f,
  2.00088680e-01f, 2.19763011e-01f, 1.01329803e-01f, -1.86582655e-01f, -8.02078657e-03f, -3.43004838e-02f, 3.10089290e-02f, 1.04802154e-01f, 6.68600723e-02f, 2.76372246e-02f,
  -2.25493945e-02f, -1.83975752e-02f, 1.24255484e-02f, -1.13271244e-01f, 9.33244079e-03f, 1.99236926e-02f, 7.43680745e-02f, -1.30908474e-01f, -1.59371924e-02f, -2.49053873e-02f,
  -7.22884983e-02f, 1.90620851e-02f, 8.86899605e-02f, 1.37118489e-01f, -1.54922791e-02f, -8.35636351e-03f, -1.00608312e-01f, -1.11842692e-01f, 3.67527418e-02f, 2.72642951e-02f,
  -7.53828436e-02f, -1.24675624e-01f, -9.00814906e-02f, -4.39005420e-02f, 2.93152016e-02f, 8.78277868e-02f, 1.36212939e-02f, 3.97475474e-02f, 4.67286929e-02f, 8.25809613e-02f,
  -1.50051802e-01f, -4.08282489e-01f, 2.20579579e-02f, 1.46933481e-01f, -2.76069734e-02f, -6.95600659e-02f, 4.47535031e-02f, 7.96796829e-02f, 5.19565009e-02f, -1.06627114e-01f,
  8.93727764e-02f, -5.31690978e-02f, -3.51252453e-03f, -6.32565692e-02f, 7.41363242e-02f, -5.83847165e-02f, -3.04894429e-02f, -3.51166129e-02f, 2.87522916e-02f, -5.28840348e-02f,
  4.47735377e-02f, -7.04500899e-02f, -3.79806869e-02f, -1.74527436e-01f, -1.14936166e-01f, -7.73086548e-02f, 2.33292598e-02f, 2.40492653e-02f, -2.06456725e-02f, -2.61194967e-02f,
  -3.21971864e-01f, 1.75555810e-01f, -5.05230010e-01f, -7.98180774e-02f, 5.41979484e-02f, 2.79093921e-01f, 2.69145429e-01f, -1.17627606e-02f, -4.21129078e-01f, 4.04238194e-01f,
  4.44296688e-01f, -4.08203781e-01f, 1.49313107e-01f, 2.39838272e-01f, -3.69388252e-01f, 3.69993374e-02f, 3.12389314e-01f, 2.42629141e-01f, -2.48894572e-01f, 1.40547425e-01f,
  -2.10522711e-01f, 3.78172815e-01f, -1.05013907e-01f, 1.63411453e-01f, 1.40943855e-01f, -1.09166302e-01f, 2.59506017e-01f, -6.40467256e-02f, 2.10321084e-01f, -1.12079576e-01f,
  1.42949358e-01f, -1.26863286e-01f, -1.03304960e-01f, -2.06070766e-01f, 1.07773229e-01f, 1.34272397e-01f, 3.73998210e-02f, -1.18982948e-01f, -1.74275920e-01f, -7.52306283e-02f,
  -1.14816777e-01f, 7.62674841e-04f, -5.35811000e-02f, -1.20562337e-01f, -7.05609098e-03f, -7.77214486e-03f, -7.29196966e-02f, -2.51694303e-02f, -7.18166977e-02f, -4.81902696e-02f,
  -9.73380134e-02f, 1.84973050e-02f, 9.45931748e-02f, 8.49864818e-03f, -7.05745444e-02f, -8.01335201e-02f, -6.24471679e-02f, -4.16396465e-03f, 3.33312638e-02f, -3.33765112e-02f,
  5.83067648e-02f, 1.10451244e-01f, 1.40046075e-01f, -9.12639424e-02f, 6.65863529e-02f, 1.93578731e-02f, 1.68193784e-02f, -1.74248014e-02f, -1.29350245e-01f, 8.84666145e-02f,
  -5.23991250e-02f, -1.07492790e-01f, -2.11645896e-03f, 7.50126957e-04f, 7.65151158e-02f, -1.23169668e-01f, 7.22722039e-02f, -5.12771234e-02f, -1.84093602e-02f, -5.26139652e-03f,
  -3.58273312e-02f, -6.65073171e-02f, 2.34172717e-02f, 8.78838375e-02f, 2.42583994e-02f, -1.06325693e-01f, 4.23523188e-02f, -3.55827697e-02f, 1.40561312e-02f, 7.78656453e-03f,
  1.64991736e-01f, 8.38518292e-02f, 3.25111933e-02f, -1.12654813e-01f, -7.06617534e-02f, 1.09090678e-01f, 2.22410075e-03f, -2.80023105e-02f, -2.34481059e-02f, 1.18369721e-02f,
  8.00852478e-02f, -1.24320528e-02f, 3.13934721e-02f, 1.09425439e-02f, -7.54213706e-02f, 1.12172961e-01f, 1.22258000e-01f, -1.07766874e-01f, -3.78985368e-02f, -6.99179545e-02f,
  1.87239602e-01f, 1.91490129e-02f, 1.10487454e-02f, 7.12433457e-02f, 1.03109725e-01f, 1.17725506e-01f, -5.03056981e-02f, -2.71047186e-02f, 1.86392479e-02f, -1.18918705e-03f,
  -3.91500503e-01f, 3.67615998e-01f, -2.13265017e-01f, 4.19282883e-01f, -5.88371567e-02f, 1.06448226e-01f, 2.29094401e-01f, 3.00181508e-02f, 5.23654073e-02f, 3.25053036e-01f,
  1.39160886e-01f, -1.28108978e-01f, 8.94682705e-02f, 3.87084037e-01f, -1.52907912e-02f, -6.82853907e-03f, 5.11084259e-01f, 2.55063683e-01f, -1.39113143e-01f, 1.42537905e-02f,
  9.72176865e-02f, 3.40758622e-01f, -4.93959226e-02f, 2.18067057e-02f, -6.19770736e-02f, -6.75996020e-02f, 1.99087813e-01f, -1.37719601e-01f, 1.77914619e-01f, 4.47225831e-02f,
  -1.09907568e-01f, 4.37133871e-02f, -7.60397315e-02f, -7.71688819e-02f, 2.36925054e-02f, -9.62104648e-02f, 9.65638366e-03f, -6.70865625e-02f, -3.55513617e-02f, 4.27779816e-02f,
  -9.75331888e-02f, -1.62786484e-01f, -4.16169204e-02f, -1.00533895e-01f, -1.90717895e-02f, -6.55620545e-03f, -7.94784278e-02f, 6.41722828e-02f, 6.53116256e-02f, -9.12653729e-02f,
  -1.57060772e-01f, -1.04020640e-01f, 5.87554052e-02f, 1.06793918e-01f, -2.81876698e-02f, 8.79220665e-02f, 1.15707129e-01f, -1.41515266e-02f, 1.25333369e-01f, 8.40642210e-03f,
  1.08209029e-01f, -1.44705713e-01f, -1.04508571e-01f, 4.27260622e-02f, 8.77690762e-02f, 8.03102106e-02f, 3.45501453e-02f, 3.22664082e-02f, 2.58168504e-02f, 1.00778546e-02f,
  5.95083274e-03f, -1.91457141e-02f, 4.44432162e-02f, 1.44761370e-03f, 7.44733065e-02f, -2.24236777e-04f, -1.75009910e-02f, 4.14876156e-02f, 1.19189501e-01f, 7.54863210e-03f,
  -7.53475539e-03f, -2.97186058e-02f, -8.51963311e-02f, -4.94980961e-02f, 4.57654111e-02f, 5.49557731e-02f, 9.77361128e-02f, -1.09166950e-01f, 5.11780716e-02f, 1.48399994e-02f,
  2.44419068e-01f, 3.08888853e-01f, -1.30886007e-02f, -1.38976544e-01f, 1.14268079e-01f, -4.21648026e-02f, 5.45470342e-02f, -3.29520032e-02f, 1.15889937e-01f, -4.59875353e-02f,
  -1.71319991e-02f, 4.88951467e-02f, -1.32151907e-02f, 1.10992908e-01f, 5.89363910e-02f, 8.94645452e-02f, 1.32952854e-01f, 8.57635811e-02f, 9.77271646e-02f, 2.52970934e-01f,
  -8.74884427e-03f, -2.58650985e-02f, -6.21872172e-02f, 9.64334235e-03f, -2.89234947e-02f, -4.71016094e-02f, 9.76391062e-02f, -2.44764276e-02f, -9.13407188e-03f, -4.13480252e-02f,
  -5.45886233e-02f, -6.88786805e-02f, 3.37270796e-01f, 2.40812585e-01f, 1.78017288e-01f, 5.05862594e-01f, 4.43380445e-01f, 5.30474722e-01f, 6.38888776e-01f, 2.02430934e-01f,
  -1.87929068e-02f, -3.17349195e-01f, -8.96419957e-02f, -1.05097242e-01f, -2.06147537e-01f, -2.51294319e-02f, 2.14235723e-01f, -5.55683263e-02f, 1.02024347e-01f, -9.28964168e-02f,
  1.03314810e-01f, -1.15248062e-01f, -1.83372468e-01f, -1.07274204e-01f, 1.48269236e-01f, 8.94922316e-02f, -3.18255305e-01f, -2.63194423e-02f, -2.73793489e-01f, 1.08566590e-01f,
  -2.58986056e-01f, 2.21160743e-02f, -1.78485334e-01f, -9.86122936e-02f, 1.27460733e-02f, 8.89466628e-02f, -1.51891783e-01f, -1.56361295e-03f, 7.41856843e-02f, 1.06389269e-01f,
  -5.44353649e-02f, 1.51041493e-01f, -6.21112473e-02f, 2.00054139e-01f, 6.45370632e-02f, 2.08014220e-01f, 2.64700074e-02f, 1.12087421e-01f, 1.32192850e-01f, 1.37156755e-01f,
  8.26158375e-02f, -6.50027469e-02f, 3.98135558e-02f, -1.39105888e-02f, -7.23444372e-02f, 1.62138566e-01f, 7.66218305e-02f, -1.54098362e-01f, -9.89573821e-02f, 9.71058607e-02f,
  -1.02152996e-01f, -1.20039359e-01f, -1.27677722e-02f, 7.88993761e-02f, -3.84830795e-02f, 8.62752497e-02f, -4.63579819e-02f, -1.38277914e-02f, -3.18902135e-02f, -1.05558760e-01f,
  -1.44687388e-02f, -1.19447730e-01f, -1.02553502e-01f, 4.96410951e-02f, -1.32992016e-02f, 1.38180941e-01f, -6.83512092e-02f, 6.16040006e-02f, 3.75386998e-02f, 6.98093101e-02f,
  -7.10231066e-02f, -1.76976144e-01f, 1.31899826e-02f, 1.27581179e-01f, -1.69103723e-02f, -6.68988898e-02f, 3.35366055e-02f, 8.48572031e-02f, 4.52111335e-03f, -9.82287228e-02f,
  -5.16815305e-01f, -1.54983670e-01f, -1.32694498e-01f, -4.97739874e-02f, -6.64038286e-02f, 4.59511727e-02f, -1.50527954e-01f, -4.18783166e-02f, -7.27771968e-02f, 1.59282967e-01f,
  -6.34566844e-02f, 2.85785124e-02f, -1.70198396e-01f, 8.43464285e-02f, -5.30039780e-02f, 2.13096753e-01f, -1.36772037e-01f, -1.23666622e-01f, -1.21797860e-01f, -8.07677284e-02f,
  -8.07051659e-02f, -1.03971958e-01f, -5.33210449e-02f, 3.86480689e-02f, 2.07464043e-02f, -5.81815504e-02f, -4.33695540e-02f, -5.91137074e-02f, -5.01029156e-02f, -7.40625802e-03f,
  -7.74843097e-02f, -1.91861287e-01f, -2.69764483e-01f, -3.24827254e-01f, -3.98969889e-01f, -7.73164108e-02f, -1.45710498e-01f, -1.82322204e-01f, -4.13812287e-02f, 1.73330843e-01f,
  -1.95485458e-01f, -8.66921991e-02f, 2.75086433e-01f, -2.40654081e-01f, 2.48485178e-01f, 4.39220697e-01f, -2.67643016e-02f, 1.35738686e-01f, -1.25359327e-01f, -2.75935054e-01f,
  -5.11797778e-02f, -2.11143315e-01f, 1.67582184e-01f, -3.20814967e-01f, -4.00753707e-01f, -3.14691901e-01f, 6.05264492e-02f, -4.04530019e-01f, -3.46222699e-01f, -2.58934677e-01f,
  -1.32206410e-01f, -2.17564911e-01f, -1.18309043e-01f, 7.81093761e-02f, -3.06015671e-03f, -1.43570248e-02f, -2.46330932e-01f, -8.60528722e-02f, -2.66810656e-02f, -1.26049012e-01f,
  -5.53102605e-03f, 1.24109797e-01f, -2.47227848e-02f, 1.16344839e-01f, -7.81601593e-02f, 3.24901603e-02f, 4.46778201e-02f, -1.06098661e-02f, -1.11311756e-01f, 2.12584101e-02f,
  -6.76033348e-02f, -4.81767356e-02f, -3.55209112e-02f, 5.83210774e-02f, -1.06177129e-01f, -1.28583416e-01f, 1.00954928e-01f, -1.26421705e-01f, -7.13064820e-02f, -1.49434745e-01f,
  -2.13047583e-02f, 9.02267545e-02f, 1.99934300e-02f, -3.79242450e-02f, -1.04426723e-02f, -4.85590659e-02f, -2.62597539e-02f, 8.42033178e-02f, 5.96264936e-02f, 1.81860104e-02f,
  -3.28474417e-02f, -1.09263007e-02f, -5.39376698e-02f, 1.84962839e-01f, 9.30187851e-02f, 3.63040008e-02f, 1.09840333e-01f, -2.33783200e-02f, -8.62592645e-03f, 1.10154271e-01f,
  9.34537426e-02f, 1.29250530e-02f, 1.16230465e-01f, 6.39633164e-02f, -1.25935733e-01f, 1.24575524e-02f, -1.21236563e-01f, 8.30370001e-03f, 5.26657030e-02f, -1.09701172e-01f,
  -4.38170768e-02f, -1.33448526e-01f, 1.08093627e-01f, 4.97605279e-02f, 4.48232554e-02f, -6.69341534e-02f, -5.22575602e-02f, -1.47194518e-02f, -8.19558799e-02f, 2.47013289e-02f,
  1.96346850e-03f, 1.54856920e-01f, -7.05026984e-02f, -2.48803850e-02f, 3.55603732e-02f, -2.38678269e-02f, -2.98071783e-02f, 1.28328605e-02f, 7.90328067e-03f, 2.47199312e-02f,
  8.24294165e-02f, -3.02606751e-03f, 1.83986425e-01f, 1.19970351e-01f, 7.51520321e-02f, 6.30318671e-02f, -1.44465744e-01f, 1.82109419e-02f, -4.24997993e-02f, 3.94653380e-02f,
  -1.47506535e-01f, 5.01828551e-01f, -6.64477050e-02f, 1.70668811e-01f, -4.63827163e-01f, 1.97272331e-01f, 4.84698683e-01f, 2.71786954e-02f, 3.47432882e-01f, 3.86577755e-01f,
  -1.27744019e-01f, 2.74890989e-01f, 1.60204634e-01f, 3.28139514e-01f, -2.00109392e-01f, 2.89344937e-01f, 4.58836764e-01f, 3.12646061e-01f, 5.99530041e-02f, 2.07075790e-01f,
  -8.15882012e-02f, 2.19367117e-01f, -2.19255850e-01f, -4.24318612e-02f, -9.15541034e-03f, -8.21371078e-02f, -2.28534982e-01f, -2.01508418e-01f, 3.38407233e-02f, -5.96647412e-02f,
  -4.98463884e-02f, 1.64972886e-01f, -1.43165991e-03f, 9.91398692e-02f, -6.53962046e-02f, -6.74798563e-02f, -5.66431321e-02f, -1.04979724e-01f, -9.27326307e-02f, 8.69407430e-02f,
  8.53376761e-02f, 4.79389466e-02f, 1.87525019e-01f, -3.66960689e-02f, -7.04301347e-04f, -7.10255802e-02f, 3.00407112e-02f, -1.18147880e-01f, 7.54850879e-02f, -1.93126068e-01f,
  -2.13040691e-02f, 2.24014074e-02f, -6.50763186e-03f, 1.01503387e-01f, -6.13560490e-02f, 7.79394731e-02f, 1.48493201e-01f, -2.04514135e-02f, 6.95198029e-02f, 6.01841062e-02f,
  3.93702835e-02f, 1.76835611e-01f, 2.97652418e-03f, -9.38443989e-02f, -7.34193549e-02f, -4.01988029e-02f, 2.55654193e-02f, -7.48102367e-02f, -6.25699684e-02f, -7.97241926e-02f,
  3.98296714e-02f, 2.55957637e-02f, -7.90497437e-02f, 1.47222979e-02f, 5.44833057e-02f, 2.48032510e-02f, -6.38031065e-02f, 3.69000472e-02f, 4.25824448e-02f, -1.51772350e-01f,
  2.82825045e-02f, 1.09899096e-01f, 4.65982258e-02f, -6.75460920e-02f, 5.24890348e-02f, -6.64406121e-02f, 1.56471110e-03f, 2.17107646e-02f, -1.34689763e-01f, -5.98955639e-02f,
  2.51976430e-01f, 4.90209937e-01f, 8.52511078e-02f, 1.64923862e-01f, 5.80993816e-02f, -1.40509254e-03f, 9.25374106e-02f, 9.17883813e-02f, 1.72837511e-01f, 1.20009579e-01f,
  1.39066363e-02f, 1.06647134e-01f, 2.47150082e-02f, -1.76573098e-01f, 4.96108718e-02f, 7.21612796e-02f, 8.40328932e-02f, 4.91125472e-02f, -6.72202185e-03f, -1.32565245e-01f,
  -4.58829626e-02f, 1.06939949e-01f, 6.56630322e-02f, 3.88636142e-02f, 1.98506024e-02f, 1.57995224e-02f, -2.04607733e-02f, -1.03095084e-01f, -1.41220048e-01f, 3.60558257e-02f,
  6.26135170e-01f, 2.44995654e-01f, 4.54520792e-01f, 5.44142485e-01f, -2.11924151e-01f, -1.97123617e-01f, -3.53543684e-02f, 4.00143601e-02f, 2.95463383e-01f, 7.14763999e-02f,
  -3.25953960e-01f, 5.18956363e-01f, -3.61624718e-01f, 8.58184919e-02f, -3.05209965e-01f, -4.31175083e-01f, 1.03564663e-02f, 1.34404868e-01f, -4.08609696e-02f, 2.69774377e-01f,
  -4.55054678e-02f, -2.37571523e-01f, 5.24653830e-02f, -1.79360196e-01f, 3.68449181e-01f, 3.03637713e-01f, -3.40691835e-01f, -2.22412437e-01f, 3.33662033e-01f, -3.25938344e-01f,
  -6.24919161e-02f, 7.75996521e-02f, 1.15892284e-01f, -7.02168494e-02f, 7.43880272e-02f, 3.11120879e-02f, -2.15492770e-03f, -1.60999954e-01f, -1.09222913e-02f, 4.04546149e-02f,
  5.65211996e-02f, 6.85310811e-02f, 3.19176950e-02f, -9.59212333e-03f, 1.19563565e-01f, 1.98632032e-01f, 1.63296655e-01f, 9.46927667e-02f, 1.43704563e-01f, 1.11746706e-01f,
  2.12295324e-01f, 1.56101137e-01f, 8.80758688e-02f, -5.15360124e-02f, 9.45647061e-02f, 1.77688478e-03f, 1.61285363e-02f, 8.03386867e-02f, 9.79363546e-02f, 1.36972189e-01f,
  1.66200940e-02f, -1.03607051e-01f, -2.17011720e-02f, 4.72908914e-02f, 1.13784112e-02f, 1.30797885e-02f, 1.87501013e-02f, -1.43938931e-02f, 4.56972346e-02f, -5.59019446e-02f,
  4.05395357e-03f, 6.05636723e-02f, -4.55453619e-02f, 9.97749120e-02f, 4.84221429e-02f, 7.99364075e-02f, 5.88375777e-02f, 4.06907015e-02f, 4.93628494e-02f, 1.00281693e-01f,
  -8.91895741e-02f, -1.41256005e-01f, 1.08312249e-01f, 2.31987424e-02f, -6.29192144e-02f, -1.00424734e-03f, 6.04559518e-02f, 1.65828854e-01f, -4.35330942e-02f, -9.56575722e-02f,
  -3.76751065e-01f, -2.50523686e-01f, -1.90094970e-02f, -5.48860990e-02f, -7.06517175e-02f, -5.97710721e-02f, 4.27178573e-03f, 9.94341597e-02f, -1.16085269e-01f, 7.30498582e-02f,
  -6.45149872e-02f, 7.23420084e-02f, -8.71923268e-02f, -7.71570802e-02f, -1.26054257e-01f, -8.80737826e-02f, -6.87626600e-02f, -5.87906018e-02f, -1.09077737e-01f, -8.04420654e-03f,
  6.29348308e-02f, 3.55956294e-02f, 2.39703041e-02f, 6.25590160e-02f, -8.70341957e-02f, -2.25494113e-02f, 7.51939788e-02f, -1.32998908e-02f, -1.10842459e-01f, -1.18457191e-01f,
  2.64699310e-01f, 2.28088677e-01f, -5.25768735e-02f, 1.76138401e-01f, 3.36133003e-01f, 4.01772559e-01f, 1.42266810e-01f, 3.09011817e-01f, 4.76078153e-01f, 1.49395121e-02f,
  -6.20593131e-02f, -7.80685470e-02f, -3.79651964e-01f, 2.56300986e-01f, 1.78914696e-01f, -1.54639289e-01f, 4.35720086e-01f, -5.90263400e-04f, 1.43617988e-01f, 1.24899954e-01f,
  6.27005398e-02f, 2.26314634e-01f, -2.88975060e-01f, -9.84281376e-02f, 9.08810738e-03f, -1.56802014e-01f, -3.46875638e-01f, -3.14007550e-01f, -2.32673928e-01f, -5.54328086e-03f,
  4.47993428e-02f, 1.19671613e-01f, -8.71673524e-02f, -1.48708925e-01f, 4.56252843e-02f, 3.71699892e-02f, -8.17569997e-03f, -8.38838592e-02f, -1.62716001e-01f, -1.01779968e-01f,
  -7.79753923e-02f, -1.99466236e-02f, 1.70522675e-01f, -1.32844627e-01f, 4.92976122e-02f, 9.33149923e-03f, -3.15336809e-02f, 1.18358403e-01f, -1.17048174e-01f, 6.35661483e-02f,
  7.88724422e-02f, -1.32891221e-03f, 1.03257753e-01f, 4.19672132e-02f, 4.98978142e-03f, 1.01065001e-04f, 7.38331228e-02f, -1.00462712e-04f, 7.30354562e-02f, 1.59844309e-01f,
  -2.13236990e-03f, 1.88504308e-02f, -1.63330650e-03f, -1.09610543e-01f, 1.21235199e-01f, -5.53301945e-02f, 3.45382020e-02f, 5.60927726e-02f, 1.51995882e-01f, 5.29078618e-02f,
  -4.45447974e-02f, 2.72481479e-02f, 2.15631023e-01f, -1.40212238e-01f, 8.72313827e-02f, 1.22437395e-01f, -4.98525426e-02f, -6.71147257e-02f, 1.34308964e-01f, 3.53488848e-02f,
  -1.83495469e-02f, 2.17045881e-02f, -1.57611057e-01f, -2.24037498e-01f, -7.53422594e-03f, -9.39865559e-02f, 1.16842985e-02f, 4.27968167e-02f, -1.81684326e-02f, 2.82485709e-02f,
  1.54983252e-01f, 2.61325151e-01f, 3.69019248e-02f, -1.02068193e-01f, 6.92464858e-02f, 2.68145576e-02f, 5.75610623e-02f, 1.56192973e-01f, -2.50948686e-02f, -2.99098226e-03f,
  9.52719301e-02f, -2.94312034e-02f, 1.58100113e-01f, -1.62942469e-01f, -7.01668635e-02f, 1.17550187e-01f, -2.52456982e-02f, 6.03602864e-02f, 1.44191071e-01f, -3.94738168e-02f,
  -6.50796592e-02f, 1.03501573e-01f, 1.34197846e-01f, 1.32030293e-01f, 1.75837561e-01f, -4.08112956e-03f, -7.32621411e-03f, -4.90193479e-02f, -6.60636276e-02f, 1.07656747e-01f,
  1.57628193e-01f, -5.55771351e-01f, 2.00329006e-01f, 3.58646885e-02f, 3.83258969e-01f, 2.56536812e-01f, 8.76076594e-02f, -1.95393413e-01f, -7.06672594e-02f, -4.32552189e-01f,
  -1.61380589e-01f, -4.52564098e-02f, -3.88205916e-01f, 2.11551264e-02f, 4.33539033e-01f, -1.40841365e-01f, 1.32339105e-01f, -8.73815194e-02f, 4.24009487e-02f, 3.32008721e-03f,
  1.68676019e-01f, 8.96974728e-02f, 2.11515769e-01f, 2.86995694e-02f, 1.06795087e-01f, 1.24552995e-01f, -7.09326342e-02f, 1.72977939e-01f, 2.41838992e-01f, 2.02509522e-01f,
  -2.29793534e-01f, -1.24842383e-01f, -1.16470017e-01f, -1.71039522e-01f, 5.34672588e-02f, -7.43766502e-02f, 7.55487010e-02f, 1.90742448e-01f, 2.66010896e-03f, -7.69678727e-02f,
  -8.45837966e-02f, 1.11197606e-01f, 2.01620907e-02f, -1.01830900e-01f, -1.57256603e-01f, 1.09570315e-02f, 8.50868747e-02f, -8.17926824e-02f, 1.08218275e-01f, -3.36456932e-02f,
  3.10923364e-02f, -1.45969754e-02f, -1.67014834e-04f, 7.36126229e-02f, 2.44515296e-02f, 5.74679337e-02f, 7.72226229e-02f, 6.87067211e-02f, -3.68708223e-02f, 1.34341985e-01f,
  1.96003228e-01f, -2.33163647e-02f, -5.60380146e-02f, -7.72317052e-02f, 2.00621970e-02f, -3.35929655e-02f, -2.99048442e-02f, 1.17707342e-01f, 1.25956833e-01f, -5.61236888e-02f,
  1.57045722e-02f, -9.98144820e-02f, 6.81427121e-02f, -1.62197053e-01f, -3.59853618e-02f, -1.02270424e-01f, 1.14401162e-01f, -2.23291032e-02f, -2.07963530e-02f, 8.00115019e-02f,
  4.57009487e-02f, 5.06033339e-02f, -9.67986956e-02f, 9.73650813e-02f, -7.84791410e-02f, -9.68882143e-02f, -1.31702930e-01f, -9.59272310e-02f, -3.52539793e-02f, 1.60152853e-01f,
  -5.39608240e-01f, -4.26244974e-01f, -1.11859195e-01f, -1.95543319e-01f, -7.07901567e-02f, -1.14932030e-01f, 2.89278235e-02f, 4.65564802e-03f, -2.10162878e-01f, -1.81297977e-02f,
  -9.42889377e-02f, 4.27877437e-03f, -4.16432619e-02f, 4.22240570e-02f, -3.67536061e-02f, -1.63537756e-01f, -7.74327889e-02f, -1.54944509e-01f, -1.79231036e-02f, -1.00557692e-01f,
  -3.50155905e-02f, 1.08586866e-02f, 9.55959857e-02f, 8.73544887e-02f, 5.40500022e-02f, 1.85182020e-02f, -3.13194096e-02f, 5.19861504e-02f, 4.68331277e-02f, -6.42093942e-02f,
  3.69926035e-01f, -4.00680125e-01f, -2.94564724e-01f, -1.88967377e-01f, -1.60063699e-01f, -2.77171463e-01f, -1.51157781e-01f, -3.16534191e-01f, -1.90229535e-01f, -2.74806827e-01f,
  -2.55674422e-01f, 1.14142641e-01f, 1.65677518e-01f, -3.05618137e-01f, 4.94605184e-01f, 2.53557324e-01f, -3.53338569e-01f, -1.74417913e-01f, -1.65407732e-01f, -4.04894501e-02f,
  6.89401105e-03f, -1.92746460e-01f, -4.14356450e-03f, -3.29635054e-01f, -2.86643744e-01f, -2.18791202e-01f, 1.91453159e-01f, -5.81161827e-02f, -3.76734823e-01f, 1.57099199e-02f,
  -6.24829940e-02f, 4.17261049e-02f, -3.39683145e-02f, -2.64797565e-02f, -1.19738216e-02f, 5.06751202e-02f, -1.20485194e-01f, 1.62243187e-01f, 3.65319178e-02f, 8.69014934e-02f,
  1.82248801e-01f, 1.89292863e-01f, -1.06935553e-01f, 1.02345474e-01f, -2.17336608e-04f, -4.83659022e-02f, -6.71350658e-02f, -9.79252043e-04f, -4.98084128e-02f, 7.80538544e-02f,
  9.42092910e-02f, -5.66957402e-04f, -2.21187547e-02f, 5.73576875e-02f, 3.36902142e-02f, -1.29106507e-01f, 3.05937845e-02f, 1.56109989e-01f, 4.05874737e-02f, 4.11156751e-02f,
  1.12304650e-03f, 4.45080400e-02f, 1.05010256e-01f, -1.36830270e-01f, -3.13677341e-02f, -1.54158175e-01f, -2.80333497e-02f, -1.81823764e-02f, 7.79825598e-02f, 1.01021957e-02f,
  -8.08667839e-02f, -5.08041829e-02f, 6.68559223e-02f, -1.42662670e-03f, -5.23978733e-02f, 7.83213228e-02f, -6.42944267e-03f, -6.51522055e-02f, -1.44705787e-01f, -1.45067751e-01f,
  3.00744791e-02f, 1.57323235e-03f, -2.20528450e-02f, 5.86376004e-02f, -1.10749453e-01f, 1.28385499e-01f, -2.18424704e-02f, -1.98274069e-02f, -4.59796190e-02f, 1.30372047e-01f,
  -1.30096957e-01f, -1.02108359e-01f, -1.31493106e-01f, -4.63474467e-02f, -1.37729980e-02f, 9.98598989e-03f, -6.83529601e-02f, -4.79362011e-02f, 3.68937477e-02f, 9.31936726e-02f,
  -1.31203786e-01f, 1.28499679e-02f, 2.52713561e-02f, -1.09858878e-01f, -5.57596097e-03f, -1.16170406e-01f, 1.45969063e-01f, -9.41009223e-02f, 8.70493427e-03f, -6.29750565e-02f,
  2.63522975e-02f, 4.01706770e-02f, 9.94001329e-02f, 1.74385943e-02f, 4.19461764e-02f, 8.53321105e-02f, 2.94774324e-02f, -2.21990142e-02f, 1.54810160e-01f, 1.61828827e-02f,
  -2.91022919e-02f, 2.91742776e-02f, -3.31194133e-01f, -1.25112295e-01f, -1.93117619e-01f, 2.07774431e-01f, 3.54287505e-01f, -2.08970606e-01f, -3.53251755e-01f, 4.77099746e-01f,
  4.64818150e-01f, -1.70533672e-01f, 3.43876928e-01f, 6.40011549e-01f, 1.13310888e-01f, 4.62030143e-01f, 4.07360435e-01f, 3.90864760e-01f, -5.79448640e-02f, 9.23387259e-02f,
  -6.65234774e-02f, 4.20951456e-01f, 1.80895269e-01f, -2.81595197e-02f, 2.01629281e-01f, -2.41664901e-01f, 1.10638298e-01f, -1.82519451e-01f, 3.37106735e-01f, 2.92362794e-02f,
  8.96616131e-02f, 4.06332985e-02f, -7.90178850e-02f, -1.46604389e-01f, 1.05895959e-02f, -2.43258551e-02f, -1.46594066e-02f, 4.15445454e-02f, -1.39627621e-01f, 4.77089919e-02f,
  -8.21943581e-02f, -4.83936444e-02f, 1.23800915e-02f, -1.63636938e-01f, -1.33347839e-01f, -8.21505338e-02f, -1.59072094e-02f, -5.73667251e-02f, 4.54449803e-02f, 5.42804860e-02f,
  -3.93794812e-02f, 6.59916829e-03f, -5.46336696e-02f, 4.37400043e-02f, -1.14068434e-01f, 1.91594509e-03f, -3.27283926e-02f, -6.95447344e-03f, 7.14848097e-03f, -4.77598086e-02f,
  -3.74337249e-02f, -2.08585598e-02f, 1.11269601e-01f, -1.58261787e-02f, -1.31115578e-02f, 4.77942303e-02f, 5.45124598e-02f, 6.53063059e-02f, -8.15786049e-02f, 8.67364705e-02f,
  1.05744554e-02f, -1.04714066e-01f, -1.99349108e-03f, 4.02785577e-02f, 4.60852943e-02f, 9.47018936e-02f, -5.33993021e-02f, -4.13092710e-02f, -6.03268184e-02f, -3.09257898e-02f,
  3.17820758e-02f, -5.31086512e-02f, 2.85840947e-02f, 3.51851285e-02f, 5.55497706e-02f, -2.51756441e-02f, 1.75675955e-02f, 1.85353458e-02f, -2.13469528e-02f, -6.18847879e-03f,
  1.09527394e-01f, -5.66037819e-02f, 8.99218675e-03f, -8.41314252e-03f, 5.16811013e-03f, -8.74243826e-02f, 5.65038249e-02f, 6.08454421e-02f, -2.29994822e-02f, 2.50632106e-03f,
  -9.72872227e-02f, -8.55126679e-02f, 5.94004095e-02f, -4.91782203e-02f, -1.08392134e-01f, 5.38005494e-02f, 1.31213620e-01f, -9.89145190e-02f, 5.51159345e-02f, -1.73441060e-02f,
  -3.77854779e-02f, -1.11614823e-01f, -1.19548410e-01f, -7.09349439e-02f, -1.42961256e-02f, 6.38401583e-02f, -1.31259143e-01f, -9.07100961e-02f, -7.44533762e-02f, 5.16861305e-02f,
  2.87217498e-01f, 4.19571579e-01f, 3.89313281e-01f, 2.55967736e-01f, -1.37372047e-01f, -4.61861491e-01f, -3.97919923e-01f, -1.17210098e-01f, -1.78758249e-01f, -5.14728911e-02f,
  -1.89952806e-01f, 3.38546604e-01f, -1.52147278e-01f, 2.54032940e-01f, -1.03337884e-01f, -1.73124164e-01f, 2.98656709e-02f, 2.27126237e-02f, 1.35945052e-01f, 1.72638386e-01f,
  1.74661502e-01f, -1.77372470e-01f, 2.32593566e-01f, -1.08790644e-01f, 2.42499352e-01f, 3.79789859e-01f, 2.16819525e-01f, -3.42719331e-02f, 2.51244068e-01f, -5.44833653e-02f,
  4.57258448e-02f, 1.89163744e-01f, 8.37532580e-02f, -5.09890774e-03f, 1.19342975e-01f, 9.70836654e-02f, 2.75458284e-02f, 4.49528284e-02f, -1.78858899e-02f, 8.82208943e-02f,
  4.35963683e-02f, 9.63170547e-03f, 6.15871847e-02f, -7.03064799e-02f, -1.06874675e-01f, 8.59409869e-02f, 1.00852415e-01f, 1.35222465e-01f, 1.38194755e-01f, 1.32439405e-01f,
  7.29016364e-02f, 9.90007743e-02f, 6.68845028e-02f, 9.49709043e-02f, 5.93913160e-02f, -6.69625029e-02f, 2.56438311e-02f, 1.43459469e-01f, 8.09301585e-02f, 3.83534096e-02f,
  3.21086496e-02f, -1.42184002e-02f, 1.34822438e-02f, -1.03216618e-01f, -5.38202561e-02f, -4.47260626e-02f, -3.52904648e-02f, -7.52854301e-03f, 6.07728772e-02f, -4.48030978e-03f,
  -4.02236730e-02f, 1.47343799e-01f, 6.08473900e-04f, -8.86250213e-02f, -5.48605844e-02f, -8.28647800e-03f, -1.54864611e-02f, 2.65416782e-03f, 3.18632722e-02f, 2.21484695e-02f,
  -1.42823039e-02f, -6.07548021e-02f, 1.19851522e-01f, -2.51459284e-03f, -1.41267329e-01f, 8.28756690e-02f, 1.36545897e-01f, 5.74843101e-02f, -1.91462133e-02f, -6.90303445e-02f,
  2.38854918e-04f, 3.22101325e-01f, 5.25385067e-02f, -3.16616036e-02f, -4.12712842e-02f, 3.50036733e-02f, -3.86985950e-02f, 7.36498609e-02f, 1.19985260e-01f, -2.32773554e-02f,
  1.24726467e-01f, -9.15037319e-02f, 2.64353361e-02f, -3.68847623e-02f, 1.38662464e-03f, 5.45578934e-02f, -9.12701525e-03f, 6.78392276e-02f, -1.19941114e-02f, 1.38447925e-01f,
  1.35184407e-01f, 1.99798830e-02f, 1.22453440e-02f, -1.17837772e-01f, -2.79741082e-02f, 3.98614444e-02f, -5.93006238e-02f, 1.14924528e-01f, 3.12249232e-02f, 1.19865790e-01f,
  4.64195371e-01f, -4.96472090e-01f, -2.74196446e-01f, 2.52641737e-01f, 3.88310492e-01f, 3.05407077e-01f, 2.39235148e-01f, -1.24554880e-01f, -8.31628069e-02f, -3.74889702e-01f,
  5.25566079e-02f, -2.34793484e-01f, -2.89756954e-01f, -2.46805456e-02f, 3.94974738e-01f, -2.16468006e-01f, 8.74413699e-02f, -8.51161554e-02f, -1.33037090e-01f, 2.38587502e-02f,
  1.90565124e-01f, 2.47630641e-01f, -1.30812928e-01f, -1.09582007e-01f, 1.60670087e-01f, -1.04025491e-01f, 8.91675502e-02f, -1.01187080e-01f, -1.09754957e-01f, 1.56270772e-01f,
  1.80006519e-01f, -4.91672046e-02f, 1.20821558e-01f, -6.89540878e-02f, -1.58168897e-02f, 1.16595775e-01f, -2.98147909e-02f, 5.68785705e-02f, 1.04919106e-01f, 2.13700589e-02f,
  2.72640269e-02f, -3.74805480e-02f, 2.97952536e-02f, 9.90227386e-02f, 2.36394480e-02f, -1.25493631e-02f, -7.60781467e-02f, 5.77602573e-02f, -2.55097747e-01f, -4.83833998e-02f,
  -9.07719880e-02f, -9.82298031e-02f, 6.17350973e-02f, -1.11978829e-01f, 1.65194869e-02f, -7.75705725e-02f, -6.02279864e-02f, -1.18814297e-01f, -8.80231336e-02f, 2.45211367e-02f,
  2.83693080e-04f, 1.62115705e-03f, 5.23990467e-02f, -2.23212633e-02f, 1.40613005e-01f, 8.02985877e-02f, -6.14425316e-02f, -1.26901583e-03f, 1.28590157e-02f, -9.06673912e-03f,
  3.21632773e-02f, 6.99576586e-02f, -3.58079635e-02f, 2.92543955e-02f, 4.16671485e-02f, -9.35572945e-03f, 8.48261416e-02f, -9.07524377e-02f, -1.53432246e-02f, -2.73632817e-02f,
  -6.11614548e-02f, 1.87838338e-02f, 2.23711189e-02f, -1.13702625e-01f, 3.44872959e-02f, 4.37107719e-02f, -3.10430098e-02f, -4.20931056e-02f, 1.97206773e-02f, -2.90209148e-02f,
  -9.31169316e-02f, -2.86919355e-01f, 2.38927063e-02f, 4.64076772e-02f, -2.07716115e-02f, 1.05853245e-01f, 1.46993739e-03f, 8.20408110e-03f, -1.02445424e-01f, 2.28923261e-02f,
  -1.21474871e-02f, -3.50384712e-02f, -5.26900180e-02f, 9.59513485e-02f, -5.42896353e-02f, 1.00210421e-01f, -8.03642496e-02f, 3.59378308e-02f, -8.50457624e-02f, -7.41724297e-02f,
  1.71882566e-02f, -8.13979581e-02f, -6.96864724e-02f, 1.19158283e-01f, -1.01673186e-01f, -3.65768746e-02f, 1.25446662e-01f, -6.53042868e-02f, -1.77513808e-01f, -3.56276147e-02f,
  3.17620367e-01f, -2.76752204e-01f, -5.10247171e-01f, -1.17223404e-01f, 3.34966630e-01f, 4.48241949e-01f, -5.66006787e-02f, 5.81027418e-02f, -3.49066556e-01f, 3.39636654e-02f,
  1.99197948e-01f, -1.85831964e-01f, -3.07877839e-01f, 2.03898400e-01f, 2.86375940e-01f, -3.76033366e-01f, 2.45627597e-01f, 1.41437277e-01f, -1.92883253e-01f, -1.94776896e-02f,
  -9.98173095e-03f, 3.85026515e-01f, -2.26560786e-01f, 2.63409704e-01f, 3.06576699e-01f, -1.33018032e-01f, 2.30334610e-01f, -5.39554516e-03f, 2.42768705e-01f, 2.00993761e-01f,
  4.30496363e-03f, -1.14800997e-01f, -3.67766172e-02f, -7.47189224e-02f, 1.69799272e-02f, 2.26819053e-01f, 8.42770711e-02f, -5.68282902e-02f, 3.53637561e-02f, -1.47347972e-01f,
  1.10831842e-01f, 2.86388043e-02f, -6.05975352e-02f, -1.27738249e-02f, 6.97739422e-02f, 3.55236568e-02f, -9.60491300e-02f, -5.59824742e-02f, 5.53607531e-02f, -7.05496147e-02f,
  -1.41686425e-01f, -8.88448507e-02f, 4.72507533e-03f, 2.60259472e-02f, -1.63388073e-01f, 8.25548265e-03f, 3.54865901e-02f, -5.13168834e-02f, 1.30729660e-01f, -1.02487266e-01f,
  1.01335682e-01f, 9.04785469e-02f, -7.05827549e-02f, -6.46363199e-02f, 2.09233649e-02f, 7.15669990e-02f, 2.26151533e-02f, 3.87543216e-02f, -7.34032243e-02f, 3.97368856e-02f,
  9.18684620e-03f, 6.15004189e-02f, -3.60244997e-02f, 1.00994725e-02f, 7.22632781e-02f, 2.01224592e-02f, 1.05276234e-01f, 1.83623470e-02f, -1.15606606e-01f, -4.43466194e-02f,
  -1.34254238e-02f, 7.80527368e-02f, -2.10861862e-03f, 6.52625188e-02f, 8.48694369e-02f, 2.73862947e-03f, 6.63933903e-02f, -9.93448962e-03f, -4.27005067e-02f, 2.88868006e-02f,
  -6.46877140e-02f, -7.93554187e-02f, -2.11941883e-01f, 5.53842187e-02f, -4.16154526e-02f, 1.78172052e-01f, 1.11900918e-01f, 1.27974909e-03f, 2.24909130e-02f, 6.56509846e-02f,
  7.36578926e-02f, 6.46693334e-02f, 3.07422746e-02f, -3.43461521e-02f, 3.74110998e-03f, -7.12400526e-02f, -4.53941785e-02f, 4.21016337e-03f, 1.91875920e-01f, 2.38068607e-02f,
  5.40384725e-02f, 1.23259805e-01f, 4.17417735e-02f, -5.30542918e-02f, -4.68385518e-02f, 9.75951031e-02f, 2.14591175e-02f, -1.10328630e-01f, 1.61880597e-01f, -6.95218742e-02f,
  7.37931505e-02f, -3.16191763e-02f, -1.37101859e-01f, -3.73752803e-01f, -6.37707189e-02f, -2.96001166e-01f, -3.80610228e-01f, -6.09967336e-02f, -7.55756050e-02f, 2.83809960e-01f,
  -2.02277064e-01f, 1.84718266e-01f, 5.95072508e-02f, -4.29656923e-01f, -6.37758732e-01f, -2.47144029e-01f, -4.72731560e-01f, -4.74944711e-02f, 4.14558966e-03f, -1.32222429e-01f,
  -2.19562054e-01f, -4.64648962e-01f, -2.99429655e-01f, -7.13922158e-02f, -1.09551087e-01f, 2.54093468e-01f, 7.93872401e-02f, 3.16946357e-02f, 2.03360757e-03f, -8.18268731e-02f,
  -1.40266065e-02f, 8.86728093e-02f, 5.75682484e-02f, 1.05880491e-01f, -1.82122104e-02f, 2.08462313e-01f, -2.17373879e-03f, -6.51851818e-02f, -6.31093532e-02f, 4.60601971e-02f,
  6.52805567e-02f, 2.03372110e-02f, 5.14788646e-03f, 1.43531552e-02f, -4.37331796e-02f, -9.59239900e-03f, -9.17113647e-02f, 5.83729632e-02f, -2.01781988e-02f, -7.31369108e-02f,
  -1.19020157e-01f, -9.04245302e-03f, 1.63027830e-02f, -3.31312455e-02f, 1.88661776e-02f, -7.38652050e-02f, -3.20603959e-02f, -1.95522364e-02f, 4.37096544e-02f, -1.97491143e-02f,
  2.16813534e-02f, 3.38252783e-02f, -1.22110128e-01f, 4.74439710e-02f, -1.90465171e-02f, 4.87238839e-02f, -6.89201280e-02f, 3.43239345e-02f, 1.15838554e-02f, -4.66326848e-02f,
  -1.72881708e-02f, 3.80330905e-02f, -4.05254029e-02f, 8.06102157e-03f, 8.63388740e-03f, -1.44487470e-02f, -5.64000942e-03f, -8.15996144e-04f, -1.44192018e-02f, -1.52880788e-01f,
  2.66864169e-02f, -8.12155777e-04f, -6.90224841e-02f, 5.66462567e-03f, -1.35979891e-01f, -9.13018640e-03f, 3.16981375e-02f, 6.04820400e-02f, 7.09098624e-03f, -1.12902015e-01f,
  -9.26535726e-02f, -1.30572245e-01f, -4.54280153e-02f, -3.45088802e-02f, 9.92761645e-03f, 5.41280583e-02f, -1.44077867e-01f, -3.74359228e-02f, -8.45461041e-02f, -4.47028466e-02f,
  1.18998885e-01f, -2.13923845e-02f, 5.36248982e-02f, -4.76003475e-02f, -9.95225608e-02f, -9.91293043e-02f, -2.12547835e-02f, 3.05965953e-02f, -2.32800841e-02f, -3.89639065e-02f,
  5.12297405e-03f, 2.82430686e-02f, 5.28615117e-02f, -3.72568369e-02f, 8.03664923e-02f, 6.52070865e-02f, -1.23530114e-02f, 7.86189511e-02f, -5.56141958e-02f, 8.51245075e-02f,
  -6.97688639e-01f, 5.56912422e-01f, 2.24214315e-01f, -3.88646089e-02f, 1.26237208e-02f, -4.21161592e-01f, -2.93322980e-01f, 2.61694849e-01f, -1.05832659e-01f, -3.58774997e-02f,
  2.36556269e-02f, -8.74481201e-02f, 2.24409521e-01f, 2.49031007e-01f, -1.85500234e-01f, 2.10123852e-01f, -1.71750262e-01f, -2.10372999e-01f, 7.17873499e-02f, 1.09060049e-01f,
  -2.63349339e-02f, 7.02582076e-02f, 2.52010316e-01f, 3.07972997e-01f, 5.77197298e-02f, 5.33072427e-02f, 1.37163606e-02f, 2.71398067e-01f, -1.08627021e-01f, 6.41653165e-02f,
  -2.30948538e-01f, 2.08946392e-01f, -9.38333869e-02f, -1.86296687e-01f, -1.47598937e-01f, -2.22671703e-01f, -1.35419771e-01f, -1.20831653e-01f, -6.94598779e-02f, -1.53896362e-01f,
  -1.35020033e-01f, 1.05278395e-01f, -8.08072984e-02f, 4.67832340e-03f, -1.12902008e-01f, 3.77335702e-03f, 1.24240890e-01f, -1.69621944e-01f, 9.24675614e-02f, 1.55848905e-01f,
  1.73268825e-01f, 3.12801488e-02f, -6.90586492e-02f, 2.02512220e-02f, 1.15819946e-01f, 9.85576659e-02f, -1.10711150e-01f, -5.68102114e-03f, 2.02026870e-02f, -3.17621864e-02f,
  1.07339628e-01f, -1.08018100e-01f, -2.37949695e-02f, 2.23861951e-02f, 3.15784924e-02f, 8.95078387e-03f, 2.26923060e-02f, -6.48288056e-02f, -3.36696394e-02f, 9.10861883e-03f,
  -9.41482410e-02f, -4.03345414e-02f, 7.62799606e-02f, -9.99229923e-02f, 1.59210600e-02f, -9.67931747e-02f, -2.61494238e-02f, -1.00940295e-01f, -9.09547284e-02f, -5.35957739e-02f,
  5.99558046e-03f, -1.00181460e-01f, 1.60852820e-01f, -1.43793598e-01f, -1.17496643e-02f, -7.43169663e-03f, 1.42257646e-01f, 1.49910748e-01f, -2.35546622e-02f, -9.35418010e-02f,
  -3.78733158e-01f, 2.29638517e-01f, -1.19900219e-02f, -1.25421703e-01f, 2.54523195e-03f, -6.25242963e-02f, 1.12988241e-01f, -1.11479439e-01f, -2.24329792e-02f, -9.16290805e-02f,
  -1.10714823e-01f, -2.03004524e-01f, -2.92802416e-02f, -8.29520524e-02f, -2.98510063e-02f, 6.58855736e-02f, -2.52579879e-02f, -1.38950184e-01f, -1.36437058e-01f, -1.92035008e-02f,
  5.70272952e-02f, -1.05447962e-03f, -2.79577561e-02f, -5.85431233e-02f, -1.21886574e-01f, -1.36803985e-01f, 2.11703591e-02f, -4.63453606e-02f, 2.06902400e-02f, 1.47815406e-01f,
  -7.78389275e-01f, 6.54107034e-01f, 2.68713295e-01f, -3.81231785e-01f, 2.69643366e-01f, 2.55385101e-01f, -1.61818847e-01f, 3.20154250e-01f, 3.84853035e-02f, 1.79209158e-01f,
  -1.68653131e-01f, -8.17302838e-02f, 1.83942989e-01f, 4.07712273e-02f, -2.75178581e-01f, 5.34490533e-02f, -1.88667744e-01f, -1.36339381e-01f, 2.03687489e-01f, -1.29550248e-01f,
  -1.04930907e-01f, -4.28321734e-02f, 1.10240420e-02f, 4.28259641e-01f, 5.57675138e-02f, -7.24205449e-02f, -3.29651296e-01f, 1.62089080e-01f, -1.41110331e-01f, 1.44706294e-01f,
  -4.26011205e-01f, -3.66863310e-01f, -2.44275957e-01f, -5.07912263e-02f, -1.85728267e-01f, -1.18235037e-01f, -1.53497934e-01f, 5.55979926e-03f, -3.54385227e-02f, 4.87179607e-02f,
  -1.15054838e-01f, 9.46985409e-02f, 3.00568296e-03f, 2.32546180e-02f, 7.66997635e-02f, 6.30732579e-03f, 1.39420733e-01f, 3.39076743e-02f, 9.83892158e-02f, 1.71004936e-01f,
  1.39398932e-01f, 3.30119468e-02f, -9.56722274e-02f, -6.01768270e-02f, -1.19537879e-02f, -2.75074951e-02f, -4.50608693e-02f, -9.62704048e-02f, -2.23179087e-02f, -4.84533086e-02f,
  6.47472218e-02f, 5.18987291e-02f, 1.05100088e-01f, -1.79931484e-02f, 6.10136241e-02f, -6.33188561e-02f, -8.10092390e-02f, -1.45285204e-01f, 6.37827590e-02f, 1.15013674e-01f,
  -3.25989760e-02f, 1.42914876e-02f, -4.56746556e-02f, -5.14339246e-02f, -7.36334845e-02f, -4.53578904e-02f, -1.32383898e-01f, -3.41992304e-02f, 1.06780171e-01f, -1.10660858e-01f,
  1.47079444e-02f, -2.19845586e-02f, 9.24380645e-02f, 2.34407187e-02f, 5.26459590e-02f, -1.67687852e-02f, -3.01755220e-02f, -5.16949128e-03f, -2.34008487e-03f, -5.63209280e-02f,
  -5.04611373e-01f, -5.47182798e-01f, -1.28016070e-01f, -8.61508772e-03f, -2.94620227e-02f, -4.22821566e-02f, -4.25575860e-02f, 3.78263295e-02f, -1.14826739e-01f, -7.47554936e-03f,
  2.15204917e-02f, -6.28474131e-02f, -1.30358011e-01f, -1.02572374e-01f, -2.55115274e-02f, 2.69899145e-02f, -1.74509227e-01f, -7.46138766e-02f, -1.71605930e-01f, 3.04841027e-02f,
  -1.25032291e-01f, -1.65344533e-02f, 8.35338831e-02f, 3.00553851e-02f, -1.53481588e-01f, -1.01830587e-01f, -6.30522296e-02f, 8.06701332e-02f, -1.43935457e-02f, 3.20917256e-02f,
  -5.76738358e-01f, -3.80477719e-02f, 3.59817863e-01f, -4.33050334e-01f, -8.21920112e-02f, 4.84733701e-01f, 3.60329300e-01f, -2.46696398e-01f, -3.40131730e-01f, -1.69417292e-01f,
  8.07757080e-02f, -1.22616038e-01f, 3.45967829e-01f, -1.74549833e-01f, 4.53194201e-01f, 2.35979110e-01f, -5.52768037e-02f, 1.37494802e-01f, -1.13395669e-01f, -3.68410021e-01f,
  -2.50982583e-01f, -2.47371018e-01f, 2.63896078e-01f, -2.38177940e-01f, -1.76046506e-01f, -3.16518217e-01f, -2.36002013e-01f, 1.94391713e-01f, -2.41581082e-01f, 1.31759331e-01f,
  -2.00501949e-01f, -3.90496492e-01f, -1.75251558e-01f, -2.63701696e-02f, -1.11063913e-01f, 6.03724271e-02f, 1.44132018e-01f, 1.40314087e-01f, -1.01504073e-01f, -2.26760413e-02f,
  -2.11089607e-02f, -2.69328654e-02f, -1.38202399e-01f, 9.12190676e-02f, -1.64644793e-01f, -1.17952548e-01f, -4.11393307e-02f, -7.98797905e-02f, -4.45283204e-02f, 1.25335112e-01f,
  1.74102604e-01f, -1.79522596e-02f, 6.23684861e-02f, -5.51426634e-02f, 1.19063566e-02f, 1.29636051e-02f, 7.62730166e-02f, 1.16451554e-01f, -5.41777238e-02f, -1.82576910e-01f,
  7.29928240e-02f, 9.53332707e-02f, 2.28995178e-02f, 3.63933365e-03f, 2.72786226e-02f, -5.45849965e-04f, 1.07554551e-02f, 4.01110649e-02f, -8.59059319e-02f, 1.64153089e-03f,
  -9.50993001e-02f, -1.12832189e-01f, -1.88105062e-01f, -5.60120679e-02f, -4.07496244e-02f, -1.02083988e-01f, 1.39876664e-01f, -1.28565609e-01f, 1.01705372e-01f, -1.18776664e-01f,
  -5.43949939e-02f, 3.32967974e-02f, 5.17795719e-02f, -1.11532374e-03f, 2.69574635e-02f, -2.08820365e-02f, -7.08359256e-02f, 6.53697103e-02f, -1.56158760e-01f, 8.49413276e-02f,
  -2.71701455e-01f, -4.01056111e-01f, -9.45428461e-02f, -1.39769062e-01f, 1.05213426e-01f, -2.66980622e-02f, 1.64710507e-02f, -9.53063145e-02f, -1.10670850e-01f, -1.25332907e-01f,
  -1.93088204e-02f, -5.66367470e-02f, -6.94364086e-02f, -1.72709802e-03f, 7.84849226e-02f, -6.54182956e-02f, -4.37838919e-02f, -6.24281503e-02f, -1.02616102e-01f, 5.54324389e-02f,
  -1.09975092e-01f, 4.49474603e-02f, 1.90977111e-01f, -1.50651842e-01f, 3.10788453e-02f, -1.06171304e-02f, -1.30071327e-01f, 4.38148947e-03f, 1.21219712e-03f, 7.96743482e-03f,
  -4.43156868e-01f, -8.37637763e-03f, -2.61408716e-01f, -1.42908216e-01f, 1.72303334e-01f, -2.49833435e-01f, -3.11277002e-01f, 9.62314904e-02f, -4.87355083e-01f, -1.19047158e-03f,
  4.46299277e-02f, -4.75867391e-01f, -7.00037777e-02f, -2.91545868e-01f, -4.78564352e-01f, -2.89715201e-01f, -2.44228020e-01f, -2.65277594e-01f, -2.10471883e-01f, 2.46353149e-01f,
  1.64587256e-02f, 4.29125577e-02f, -3.99505310e-02f, 3.95830005e-01f, -8.43382441e-03f, 2.20281228e-01f, 4.83844161e-01f, 2.94083983e-01f, 2.06308171e-01f, -1.60502002e-01f,
  -2.09385812e-01f, -1.00405619e-01f, -1.18395954e-01f, -1.85005873e-01f, 5.79171814e-02f, 7.50884488e-02f, 6.80143386e-02f, -8.39006461e-05f, 4.35990468e-02f, 4.77434602e-03f,
  4.56474610e-02f, 5.02726212e-02f, -3.49335335e-02f, -1.08912162e-01f, -5.49277738e-02f, 3.25512104e-02f, -2.87828557e-02f, -1.05404869e-01f, -3.96078862e-02f, -1.17016956e-01f,
  3.74995754e-03f, -5.64018041e-02f, 1.21531732e-01f, -7.27169886e-02f, -2.72309892e-02f, 1.80233028e-02f, 1.96933411e-02f, 5.44870384e-02f, 3.09738033e-02f, -7.33553022e-02f,
  6.79617822e-02f, 3.00938152e-02f, 2.32737865e-02f, -1.22619882e-01f, -1.16715245e-01f, 5.20729758e-02f, -5.35588376e-02f, 4.82123084e-02f, 3.34959663e-02f, 4.49346751e-02f,
  3.82995307e-02f, 1.17619056e-02f, -5.01732603e-02f, 2.74183936e-02f, 6.59973547e-02f, -1.12756699e-01f, 1.16777010e-01f, 2.36961525e-02f, 3.57576683e-02f, -8.93780664e-02f,
  -1.06270932e-01f, 4.74732332e-02f, 2.46444177e-02f, 1.20770216e-01f, -1.52762711e-01f, 4.91981842e-02f, 7.41631612e-02f, -3.38664949e-02f, 2.72936188e-02f, 9.70933121e-03f,
  3.69841009e-02f, 3.50716770e-01f, -1.28411055e-02f, -2.57302634e-03f, -2.04999838e-02f, -3.43000442e-02f, -9.26281214e-02f, 1.74036389e-03f, 7.27329478e-02f, -6.09592209e-03f,
  1.61329776e-01f, 3.91584588e-03f, 1.55101225e-01f, -9.46627855e-02f, 6.20440766e-02f, 1.03248088e-02f, 1.28558904e-01f, 8.70767888e-03f, 9.38585326e-02f, 1.50092378e-01f,
  1.95438772e-01f, 1.62358806e-01f, -5.01696169e-02f, 4.43193913e-02f, 7.61712193e-02f, 6.61470145e-02f, -1.97529811e-02f, 3.46837267e-02f, 5.68871945e-02f, 5.96664287e-02f,
  2.63850033e-01f, 1.78505597e-03f, 6.75979331e-02f, 3.82327825e-01f, -8.55542123e-02f, -1.95894122e-01f, -3.89973879e-01f, 1.15052022e-01f, -3.61758098e-02f, -3.12639952e-01f,
  -2.47862842e-03f, 4.53649759e-02f, -3.36908102e-01f, 4.32714283e-01f, 4.02411163e-01f, -1.17668658e-01f, 3.23580265e-01f, 1.81584969e-01f, -8.74340907e-02f, 1.14884406e-01f,
  2.45244533e-01f, 3.51493955e-01f, 2.63003260e-01f, 2.98413813e-01f, 1.29921034e-01f, 2.40113735e-01f, 2.93854147e-01f, -1.69104822e-02f, 3.59963059e-01f, 1.40785649e-01f,
  -7.09536299e-02f, 3.92254591e-02f, 6.87540174e-02f, 2.84015946e-02f, 3.49302143e-02f, -7.38768205e-02f, -1.19079113e-01f, 5.77472448e-02f, -3.51410657e-02f, -2.81360596e-02f,
  -8.79612751e-03f, 1.84173301e-01f, 2.02579290e-01f, 4.02090997e-02f, -2.38771061e-03f, 1.24954373e-01f, -3.67835239e-02f, -9.50280651e-02f, -3.02206371e-02f, 5.62968142e-02f,
  -3.76463979e-02f, -1.39069119e-02f, -2.24287044e-02f, 4.15804563e-03f, 2.40300689e-02f, 5.48755378e-02f, -3.57520171e-02f, 2.44843774e-02f, -1.91265400e-02f, 1.61401346e-01f,
  -3.89411487e-03f, -1.10787340e-01f, -7.88921192e-02f, -4.46872711e-02f, 3.93409468e-02f, 2.77960841e-02f, 2.32278239e-02f, -3.59607711e-02f, -5.04680090e-02f, 4.27160747e-02f,
  3.02217770e-02f, 7.28592724e-02f, -4.39172387e-02f, 2.95272302e-02f, 1.28143840e-02f, -8.42489973e-02f, -3.59007902e-02f, 4.00805883e-02f, -4.44271155e-02f, 9.14633572e-02f,
  -2.47366671e-02f, 4.40663248e-02f, 1.10767840e-03f, 7.66258165e-02f, -8.07523206e-02f, 4.12707739e-02f, 2.18020566e-02f, -1.08802900e-01f, -6.49501309e-02f, -9.23309661e-03f,
  3.75600308e-02f, 2.19773173e-01f, -4.97178882e-02f, -1.85613253e-03f, -1.88940614e-02f, 5.33656403e-03f, -9.54079907e-03f, 1.66504860e-01f, 1.76010296e-01f, 5.23203686e-02f,
  7.31650516e-02f, -2.23669372e-02f, -1.17284685e-01f, 7.14685097e-02f, 1.11941308e-01f, 1.11041062e-01f, 8.54743570e-02f, 8.68864655e-02f, 1.97697952e-01f, 8.01005810e-02f,
  1.22993916e-01f, -1.89358771e-01f, 6.54121041e-02f, 3.76473833e-03f, 1.39051199e-01f, -3.13299447e-02f, -6.86173439e-02f, -1.06170081e-01f, 4.59313951e-02f, 1.49283949e-02f,
  1.52132601e-01f, -8.10148660e-03f, 4.83096302e-01f, 3.82550597e-01f, -9.12984461e-02f, -2.21665531e-01f, 3.57969970e-01f, -3.10658246e-01f, -3.22417200e-01f, -1.98727280e-01f,
  -1.05835393e-01f, 4.50751275e-01f, 2.99345665e-02f, 6.15094937e-02f, 5.22870898e-01f, -3.15699816e-01f, 5.76451160e-02f, 5.93877174e-02f, -1.07098281e-01f, 1.50164768e-01f,
  -1.54873952e-01f, -2.06656814e-01f, 2.14278325e-01f, -2.24011213e-01f, 2.31174231e-01f, 2.26991042e-01f, 4.52324480e-01f, 3.57411981e-01f, 3.51546884e-01f, 1.77927732e-01f,
  -2.22033456e-01f, -1.07882753e-01f, 2.02223081e-02f, -9.54742879e-02f, -9.99954790e-02f, 2.25847140e-02f, 1.18340388e-01f, 1.28748223e-01f, 8.52332115e-02f, 2.87725627e-02f,
  -3.78162190e-02f, 8.60835761e-02f, -6.13364913e-02f, 5.08760847e-02f, -6.38270974e-02f, 7.85454512e-02f, -1.66054547e-01f, -4.31181155e-02f, -7.02561438e-02f, 1.11418463e-01f,
  5.93389943e-02f, -6.49478137e-02f, -1.34718725e-02f, 8.00867677e-02f, 1.28003374e-01f, -6.64527640e-02f, 1.04287788e-01f, 6.12985454e-02f, -1.59256216e-02f, -1.74268875e-02f,
  -1.38902321e-01f, -4.58615497e-02f, -6.09276332e-02f, 1.88744757e-02f, -1.83896790e-03f, -1.04104631e-01f, -2.74110772e-02f, -1.38426507e-02f, 7.16960430e-02f, -6.83551580e-02f,
  5.91560872e-03f, 5.22785261e-02f, -1.17426164e-01f, 3.19452398e-02f, -8.74086246e-02f, -8.14256594e-02f, 1.92541003e-01f, 6.56656250e-02f, 2.07845867e-02f, -8.84446427e-02f,
  7.78853137e-04f, -1.02587566e-02f, 1.11765705e-01f, 8.09157193e-02f, -1.75055876e-01f, 3.44536453e-03f, 5.59955649e-02f, 9.99764651e-02f, -1.55309737e-02f, 6.18267767e-02f,
  6.99808672e-02f, 2.29615569e-01f, -7.09295422e-02f, -7.63533711e-02f, 3.40652876e-02f, 2.75188852e-02f, -8.30023885e-02f, -1.22752704e-01f, 5.01996130e-02f, -1.21989608e-01f,
  -1.30686998e-01f, 1.27257824e-01f, -4.35540313e-03f, 5.83557375e-02f, 4.97278273e-02f, 8.28151256e-02f, 1.21453516e-01f, 1.91840138e-02f, -4.15820489e-03f, -1.21643243e-03f,
  6.23291805e-02f, -5.56085669e-02f, 4.49314993e-03f, -5.21809570e-02f, -1.06159151e-01f, 1.01838112e-01f, -2.19836961e-02f, -8.87542516e-02f, 1.81688935e-01f, 9.74974558e-02f,
  2.91918904e-01f, -5.15214354e-02f, 3.63806784e-01f, 2.99973726e-01f, 9.97823775e-02f, 3.54197323e-01f, 5.12604415e-01f, 2.13362888e-01f, 5.73178709e-01f, -9.23655853e-02f,
  -2.46434227e-01f, 2.91202180e-02f, 1.47792138e-02f, -1.05998851e-01f, 2.77379870e-01f, 1.94448397e-01f, 2.09089249e-01f, 2.50676334e-01f, 1.84112519e-01f, -6.94531724e-02f,
  1.15412094e-01f, -2.81644732e-01f, -3.16501349e-01f, -2.82582939e-01f, -1.38705090e-01f, -1.37060598e-01f, -4.55876201e-01f, 1.25110924e-01f, -3.16813916e-01f, 1.08061306e-01f,
  4.55512591e-02f, -2.65049003e-03f, -2.01744765e-01f, -4.52287011e-02f, -5.92812989e-03f, 6.80317357e-02f, 1.09657599e-02f, 9.51096714e-02f, 9.33889449e-02f, -1.48529932e-02f,
  -1.37127778e-02f, -1.58197619e-02f, -3.71998958e-02f, -6.82349131e-02f, 1.05126597e-01f, -1.69919953e-01f, 4.17507626e-02f, -9.17698592e-02f, 3.57553386e-03f, -4.30774093e-02f,
  -8.45407918e-02f, 3.61661203e-02f, -7.11000636e-02f, -8.10022056e-02f, 1.05997818e-02f, 3.47358920e-02f, 1.18295364e-01f, -7.68908020e-03f, -8.80911574e-03f, 8.64269510e-02f,
  7.78813437e-02f, 1.64775848e-01f, 3.80319171e-02f, 1.12122521e-02f, 9.52157304e-02f, -9.35483724e-02f, -9.94222239e-02f, -1.34910569e-01f, 1.11006208e-01f, -3.96104679e-02f,
  1.25079444e-02f, -1.20647006e-01f, 1.33932471e-01f, -3.13028470e-02f, 8.43064568e-04f, -6.33100141e-03f, 7.52793904e-03f, -7.03843683e-02f, -8.74231681e-02f, -1.57607049e-01f,
  1.04053155e-01f, 1.70596704e-01f, -1.85563996e-01f, -2.51452662e-02f, 9.32146683e-02f, 3.24403401e-03f, -9.51427296e-02f, 8.29912946e-02f, 7.30238631e-02f, -2.72929873e-02f,
  1.20586246e-01f, 1.76245391e-01f, -1.28454208e-01f, -7.70762488e-02f, -7.97541291e-02f, -2.00100601e-01f, 1.52042508e-01f, -8.49088803e-02f, 2.20748112e-02f, 3.53448130e-02f,
  -1.10062072e-03f, -9.15537253e-02f, 3.21288519e-02f, 4.33172509e-02f, -1.13283113e-01f, -6.25330880e-02f, 6.55662939e-02f, -6.32830635e-02f, -5.43435179e-02f, -1.08812645e-01f,
  -5.85502200e-02f, 3.51632130e-03f, -1.78035796e-02f, -1.50852889e-01f, -1.54153675e-01f, -4.10168730e-02f, -4.27299626e-02f, 4.34923079e-03f, -6.07623719e-02f, -8.01080316e-02f,
  1.75922453e-01f, -2.53267199e-01f, -1.89722642e-01f, 1.26612663e-01f, 1.01545192e-01f, -1.18652627e-01f, -4.50075656e-01f, 1.55293018e-01f, -3.09542269e-01f, -2.36341879e-01f,
  1.17184959e-01f, -1.98177382e-01f, -3.06313068e-01f, 2.12448820e-01f, 3.88156503e-01f, -2.92855114e-01f, 4.10578877e-01f, 1.48136541e-01f, -5.38366474e-02f, 3.11681449e-01f,
  2.74534792e-01f, 4.34312433e-01f, 3.05358320e-01f, 4.69855756e-01f, 1.63572371e-01f, 1.37259230e-01f, 2.40239441e-01f, 3.15510556e-02f, 3.49924475e-01f, 2.32341707e-01f,
  -6.24961443e-02f, -2.77221669e-03f, -1.30484579e-02f, 4.69287252e-03f, 2.61518341e-02f, -6.56553730e-02f, -2.59138290e-02f, 1.00442111e-01f, -1.01856604e-01f, -2.74852179e-02f,
  -6.06701039e-02f, 1.85170352e-01f, 3.99063677e-02f, 5.14510237e-02f, 3.41411941e-02f, -2.87228916e-02f, -1.20067380e-01f, -6.49579093e-02f, -1.13772482e-01f, -1.92660931e-02f,
  -6.31603375e-02f, -4.43919376e-02f, -6.29887581e-02f, -6.33875951e-02f, -5.31331077e-02f, -1.55393630e-02f, -1.06851108e-01f, -8.86056796e-02f, -5.41303121e-02f, -7.00686406e-03f,
  9.86194164e-02f, 6.16331138e-02f, -1.26953959e-01f, -5.38667627e-02f, -5.02291285e-02f, -8.01638141e-02f, -3.82089391e-02f, -1.26534939e-01f, -4.14905399e-02f, -8.95182565e-02f,
  -1.62714534e-02f, -1.26478761e-01f, -3.21348794e-02f, 1.13146633e-01f, 7.41467923e-02f, 4.30624299e-02f, 1.27550960e-02f, 1.32741749e-01f, -7.04731643e-02f, -5.43949381e-02f,
  1.58119071e-02f, 5.70017286e-02f, -7.70514160e-02f, 3.37625518e-02f, 8.92548338e-02f, -1.47595927e-02f, 5.32932281e-02f, -1.85143808e-03f, -3.82452155e-04f, 3.73026468e-02f,
  1.85758080e-02f, 1.26794398e-01f, 1.89906952e-03f, -1.26395253e-02f, -1.43717723e-02f, 8.38618726e-02f, 6.60701618e-02f, -4.62227538e-02f, 2.98977364e-02f, 3.60363647e-02f,
  9.98642668e-02f, 5.19383103e-02f, 1.62152983e-02f, 2.69149281e-02f, 6.84829131e-02f, 4.08208594e-02f, 8.95695668e-03f, 5.46363220e-02f, -8.94822776e-02f, 2.33333245e-01f,
  2.59423088e-02f, 3.31080705e-02f, -7.27153057e-03f, -1.04648300e-01f, -1.07487321e-01f, 4.80528316e-03f, 6.98965117e-02f, 3.00153177e-02f, 1.63818616e-02f, -4.40822318e-02f,
  -3.37868363e-01f, 2.67370582e-01f, -3.09594393e-01f, -1.90184832e-01f, -1.06526189e-01f, -4.72385556e-01f, -3.06413263e-01f, -6.87099472e-02f, 1.87616780e-01f, 1.96261346e-01f,
  -1.37165681e-01f, 1.30981401e-01f, 1.07190564e-01f, -1.64118499e-01f, -4.22424734e-01f, 2.58519232e-01f, -4.39341038e-01f, -2.63878196e-01f, 1.31241009e-01f, -2.56534606e-01f,
  -1.35503083e-01f, -1.88070863e-01f, -3.95151615e-01f, 2.08271313e-02f, -3.11882377e-01f, -5.79711460e-02f, -8.37004557e-02f, 9.85622499e-03f, -4.19851482e-01f, -1.54253282e-02f,
  -2.67262936e-01f, -2.43262649e-02f, -1.50920195e-03f, -3.81545424e-02f, -1.96637988e-01f, -1.71879396e-01f, -2.08607748e-01f, 7.26690143e-03f, 8.26005936e-02f, -2.99693104e-02f,
  9.60796401e-02f, 7.43768644e-03f, -7.98895657e-02f, 1.58199042e-01f, 5.54591268e-02f, 6.36384934e-02f, -6.01424389e-02f, -1.63705990e-01f, -5.16049266e-02f, 7.03567937e-02f,
  -6.32210672e-02f, -3.18709537e-02f, -1.07683212e-01f, -7.17578903e-02f, -4.13092338e-02f, -3.18087749e-02f, -1.58028871e-01f, -5.82114607e-02f, -1.57727391e-01f, -9.19842348e-02f,
  -4.96033244e-02f, -1.27995118e-01f, -2.85175387e-02f, 1.46536333e-02f, -7.78822973e-02f, -7.24067464e-02f, -9.19022597e-03f, -4.17771377e-02f, 1.03573002e-01f, -5.75634949e-02f,
  -5.30970953e-02f, -9.84910503e-02f, 1.42976359e-01f, -8.79830047e-02f, 3.84744965e-02f, 6.66138679e-02f, -1.32951811e-02f, 8.54519457e-02f, -2.05916148e-02f, -2.95902304e-02f,
  3.74525003e-02f, -6.34099618e-02f, 2.22138856e-02f, -2.38012411e-02f, -5.87180816e-03f, 1.17943361e-01f, -3.32432613e-02f, -2.86886282e-02f, 2.44076755e-02f, 1.54071841e-02f,
  -3.04630399e-01f, -1.36526659e-01f, 4.69038039e-02f, 1.39393955e-01f, 1.62225738e-02f, -6.53974637e-02f, 5.86121865e-02f, -1.42816007e-02f, -5.02372645e-02f, 1.15212128e-02f,
  7.27524923e-04f, 3.77807990e-02f, -1.47656038e-01f, 1.76092386e-01f, 1.79647636e-02f, -2.19848543e-01f, -8.47740471e-02f, 6.55959249e-02f, -1.20050453e-01f, -1.34016335e-01f,
  -5.72522134e-02f, -3.86055261e-02f, 7.07686916e-02f, 5.01547679e-02f, -6.56839609e-02f, -8.92970860e-02f, -1.19811267e-01f, 7.57793477e-03f, -6.62677959e-02f, -6.88439608e-02f,
  -5.41075170e-01f, 9.56280082e-02f, 5.84737491e-03f, -4.00425315e-01f, 2.35586256e-01f, -4.86347340e-02f, -2.86446452e-01f, 1.25006512e-01f, -8.18411708e-02f, 3.16339642e-01f,
  8.69809389e-02f, 1.24716155e-01f, -5.94416587e-03f, -2.43083552e-01f, -5.75277984e-01f, -4.19724733e-01f, -4.83763218e-01f, -2.00925454e-01f, -2.09596753e-01f, -6.54026419e-02f,
  -2.74372458e-01f, -1.99067548e-01f, -3.65541577e-01f, 2.32664987e-01f, 1.75683394e-01f, 3.29706043e-01f, 1.03985049e-01f, 2.60328203e-01f, 1.02460809e-01f, 4.06900905e-02f,
  3.13143842e-02f, 5.57492562e-02f, 3.09576601e-01f, 1.24566577e-01f, -3.87221351e-02f, 2.69194264e-02f, 9.49467719e-02f, 8.06735530e-02f, -6.08696789e-02f, 5.23462184e-02f,
  7.67573714e-02f, 8.41286033e-03f, 1.03355579e-01f, 7.81587586e-02f, 1.12048082e-01f, 1.18682776e-02f, 4.92312163e-02f, 6.24211431e-02f, 4.02168557e-02f, -1.48831293e-01f,
  -1.20318145e-01f, -3.17658670e-02f, -5.56320325e-02f, -4.13126796e-02f, -6.95698634e-02f, 1.07542083e-01f, 1.62104592e-02f, 6.13002330e-02f, -2.74683237e-02f, -2.75701284e-04f,
  -1.19289599e-01f, -1.63644716e-01f, -3.78889628e-02f, -6.48786488e-04f, -1.08126234e-02f, 5.94819244e-03f, 5.17136082e-02f, 6.31963164e-02f, -4.99639101e-03f, 1.45161934e-02f,
  2.31519174e-02f, -1.18181488e-04f, 2.75427680e-02f, 1.23721492e-02f, -9.88638550e-02f, 7.53491968e-02f, 5.13697602e-02f, 7.99148716e-03f, -1.64628804e-01f, 3.17793190e-02f,
  2.66931541e-02f, 4.43758303e-03f, 2.99486648e-02f, 5.24787174e-04f, -8.96881893e-02f, -1.67402010e-02f, 8.29410478e-02f, 3.11782379e-02f, -8.19806755e-02f, -3.99812832e-02f,
  3.49938460e-02f, 1.08063124e-01f, 1.74386159e-01f, 9.84536484e-02f, 1.05773956e-01f, 2.51741428e-02f, -1.20799467e-02f, 2.86993273e-02f, -1.88724510e-02f, -4.90200147e-02f,
  -2.93509057e-03f, 4.80703376e-02f, 8.09579864e-02f, 1.47102738e-03f, -1.65263396e-02f, -6.78613025e-04f, -7.58802816e-02f, -3.56234610e-02f, 4.72694449e-02f, 3.56449187e-02f,
  9.00367722e-02f, 9.59967598e-02f, -5.09679615e-02f, -1.65388789e-02f, 1.45610914e-01f, -3.60791571e-02f, 2.92363111e-02f, -6.64300621e-02f, -2.59651653e-02f, 5.78658376e-03f,
  5.39778531e-01f, -2.17613697e-01f, -2.99167305e-01f, 1.97340757e-01f, 2.03941166e-01f, 2.52095968e-01f, 1.75664470e-01f, 2.60356784e-01f, 3.59520018e-01f, -6.48024753e-02f,
  2.45490462e-01f, -1.33029163e-01f, -1.64084971e-01f, 3.14050734e-01f, 3.04534435e-01f, -8.58973488e-02f, 1.92488477e-01f, 4.00539227e-02f, 1.80902883e-01f, 2.59299964e-01f,
  1.95910260e-01f, 3.49191397e-01f, -8.76305178e-02f, -5.01359291e-02f, 2.35751197e-01f, -8.69007483e-02f, -2.53126383e-01f, -3.83899361e-01f, -4.02423665e-02f, -8.35682377e-02f,
  9.92656350e-02f, 2.84719560e-02f, 1.45628687e-03f, -1.16447778e-02f, -9.80055481e-02f, -2.02650279e-01f, -2.55967200e-01f, -2.08588883e-01f, 8.34261253e-02f, 4.85070795e-02f,
  -1.15446799e-01f, 1.01620436e-01f, 1.44286230e-01f, -5.51394522e-02f, 1.78409398e-01f, 9.10026282e-02f, 4.89221513e-02f, -4.37824316e-02f, -2.06286404e-02f, -5.22940012e-04f,
  1.34406954e-01f, -7.76901376e-03f, 1.42729372e-01f, -1.36771396e-01f, 1.09041288e-01f, 1.02631330e-01f, -8.70064721e-02f, -7.90716782e-02f, -1.06860541e-01f, 5.85160553e-02f,
  4.64920439e-02f, -1.55551033e-02f, -5.12263365e-02f, 1.30263403e-01f, 4.06151786e-02f, -6.84068799e-02f, 2.05819961e-02f, -1.11963488e-01f, -3.90491746e-02f, -1.15627423e-01f,
  -5.94197679e-03f, 5.17463759e-02f, -8.28410871e-03f, 9.47320536e-02f, -8.25345516e-04f, -1.98723879e-02f, -8.81060138e-02f, 1.93716995e-02f, -6.80994010e-03f, 7.43835792e-02f,
  -2.30327658e-02f, 8.53009075e-02f, 6.84807971e-02f, 1.40503692e-02f, -5.50292581e-02f, 5.41292503e-02f, 3.59495431e-02f, 1.48155913e-01f, 6.32064464e-03f, -6.06844351e-02f,
  6.06786087e-02f, -2.19205245e-01f, -6.98721688e-03f, 1.75266508e-02f, -2.58677691e-01f, -1.44065218e-02f, -1.26787707e-01f, 1.96759868e-02f, -5.97789325e-02f, 3.57420817e-02f,
  -1.22803241e-01f, -4.29758094e-02f, -8.92528445e-02f, 4.49756756e-02f, -1.07800163e-01f, 9.84957516e-02f, -7.50431865e-02f, -9.95270610e-02f, -8.24777782e-02f, 7.99562484e-02f,
  -1.29320351e-02f, 5.24407178e-02f, -4.49569635e-02f, 6.60825446e-02f, 1.05304524e-01f, -1.81346565e-01f, 1.38709828e-01f, -5.18531092e-02f, 5.03614657e-02f, -7.37446100e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.87925911e-01f, 3.72870028e-01f, 3.10299307e-01f, 5.20068467e-01f, 2.28104979e-01f, 4.89998966e-01f, 3.01582336e-01f, 4.63251710e-01f, 4.68690962e-01f, 1.07845908e-03f,
  3.00533026e-01f, 3.82359236e-01f, 3.91425461e-01f, 2.98603237e-01f, 4.36296284e-01f, 5.20244360e-01f, 3.11168909e-01f, 4.60807115e-01f, 3.67204368e-01f, 1.93951279e-01f,
  4.69673306e-01f, 4.43049759e-01f, 2.67324835e-01f, 1.65731162e-01f, 4.97530818e-01f, 2.89217383e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.44657448e-01f, -1.58220574e-01f, 2.24055037e-01f, -1.57433465e-01f, -1.56788230e-02f, -2.58782804e-01f, -1.27199352e-01f, -2.27440476e-01f, 1.89601079e-01f, -6.69111088e-02f,
  2.65727907e-01f, 2.43789151e-01f, -4.18831676e-01f, 7.77929202e-02f, -1.27003357e-01f, 1.73394576e-01f, 3.32352728e-01f, 1.72755539e-01f, -1.01089850e-01f, -6.09068125e-02f,
  -1.86197177e-01f, 3.92845720e-02f, -1.27071040e-02f, 3.80503505e-01f, -2.10866913e-01f, 1.39139414e-01f, 2.47094497e-01f, 3.75479199e-02f, 1.36247739e-01f, 1.04339659e-01f,
  -2.09366351e-01f, -1.53887331e-01f, -2.04613641e-01f, 1.28756911e-01f, 5.95496036e-02f, -1.33617878e-01f, 9.87376571e-02f, -2.53743470e-01f, 9.02847946e-02f, -3.72699425e-02f,
  -1.05926648e-01f, 1.58405468e-01f, 2.26452857e-01f, 1.21283919e-01f, -3.14486682e-01f, -1.40654324e-02f, 7.38676311e-03f, 2.13368297e-01f, 2.68627435e-01f, -1.53150439e-01f,
  1.50895700e-01f, -1.53026775e-01f, -2.08497956e-01f, -1.97431803e-01f, -5.60646877e-02f, 1.10361166e-01f, -1.47247136e-01f, -7.60788992e-02f, -7.25336447e-02f, 2.02259123e-01f,
  -7.95183629e-02f, 2.34522019e-02f, -1.74085855e-01f, 8.11968464e-03f, 7.64217898e-02f, -8.74363407e-02f, 1.24981096e-02f, -1.23652168e-01f, -2.56858736e-01f, -1.17617451e-01f,
  -7.81472474e-02f, 2.46405393e-01f, 3.14479798e-01f, 9.35413688e-02f, -1.51905403e-01f, 2.90534109e-01f, 3.63658756e-01f, -3.16511989e-02f, -2.52229214e-01f, -2.52452850e-01f,
  1.69272751e-01f, 2.74799224e-02f, -2.19092205e-01f, -1.73507035e-01f, -5.92377968e-02f, 1.56461954e-01f, -1.26269106e-02f, -3.19280207e-01f, 3.81769687e-02f, 3.42722163e-02f,
  5.60960099e-02f, -5.89889660e-02f, -1.20803997e-01f, 2.26192579e-01f, -1.94252450e-02f, 1.74448133e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.26952299e-01f, 1.62483603e-01f, 2.46010870e-01f, -2.43882418e-01f, 6.71959698e-01f, -5.02442479e-01f, 4.00849432e-01f, -2.89993376e-01f, -5.21656334e-01f, 4.11825240e-01f,
  1.78394735e-01f, -3.32670152e-01f, -2.93644875e-01f, 3.11287250e-02f, 5.61965108e-01f, -1.43300235e-01f, -3.57459933e-01f, -2.11187482e-01f, 3.75523210e-01f, 3.83443952e-01f,
  -3.04158658e-01f, 2.16688477e-02f, 2.49896660e-01f, 4.16008443e-01f, -2.76211709e-01f, 1.14339948e-01f, 2.12256566e-01f, 2.94629425e-01f, 2.72381395e-01f, -4.12059069e-01f,
  2.07894266e-01f, 3.11859041e-01f, 2.92231530e-01f, 2.04332590e-01f, 3.43025863e-01f, -3.40539277e-01f, 1.88127235e-01f, -4.08456802e-01f, 9.06062126e-02f, -3.44947189e-01f,
  3.75341028e-01f, -4.86986563e-02f, 2.22168908e-01f, 2.60202110e-01f, 3.83966148e-01f, -8.25201795e-02f, -1.88586175e-01f, 3.57231706e-01f, -7.13608488e-02f, 5.67037106e-01f,
  -4.60486442e-01f, -4.13641870e-01f, 1.60056785e-01f, 5.77525437e-01f, 1.07961915e-01f, 2.79719651e-01f, -3.87084447e-02f, 5.27093410e-01f, 4.01634961e-01f, 1.35859415e-01f,
  5.68412431e-02f, 5.06550431e-01f, 8.82598385e-02f, -2.71678835e-01f, 1.91357300e-01f, 3.47870797e-01f, 3.35057020e-01f, -3.39146942e-01f, 5.40277004e-01f, -3.17320973e-01f,
  5.16751826e-01f, -2.16141120e-01f, -6.56504095e-01f, 4.53363597e-01f, -4.00733382e-01f, -2.61048436e-01f, 2.92226613e-01f, -1.19624600e-01f, 3.88245165e-01f, -4.49579246e-02f,
  -2.73385704e-01f, 9.55342129e-02f, 3.96394014e-01f, -2.63997674e-01f, -8.27782005e-02f, 3.84397566e-01f, 4.42277730e-01f, 2.83305764e-01f, -3.28052789e-02f, -1.96824774e-01f,
  2.25785188e-02f, 1.35723352e-01f, 6.09120913e-02f, -3.65619332e-01f, 1.61264941e-01f, 2.82143921e-01f, 2.19959170e-02f, -3.73729281e-02f, 2.65605748e-01f, 1.47639811e-01f,
  -5.29180765e-01f, 3.58034700e-01f, -3.86032611e-01f, 3.86972576e-01f, 4.30831969e-01f, 5.50659336e-02f, -2.49677703e-01f, 2.95834154e-01f, -4.39428091e-01f, 7.95347467e-02f,
  -8.45550820e-02f, 3.12401038e-02f, 2.66232848e-01f, -1.81733072e-01f, 1.85486764e-01f, 3.90515536e-01f, 2.87554115e-01f, 2.84806758e-01f, 1.49232998e-01f, -1.52606457e-01f,
  1.24709152e-01f, -1.32733971e-01f, -5.44861197e-01f, -3.18212867e-01f, 8.71792659e-02f, 2.50868350e-01f, 4.60848600e-01f, 4.14474845e-01f, 1.94166243e-01f, -1.76517591e-01f,
  3.73197526e-01f, -6.57213271e-01f, 4.86845732e-01f, -4.02696669e-01f, -1.02371611e-01f, 3.03772181e-01f, 8.09951648e-02f, 2.16284379e-01f, 4.83331442e-01f, 1.08182840e-01f,
  -3.84271234e-01f, -2.42649406e-01f, 7.30188414e-02f, -4.00885679e-02f, 2.70000786e-01f, 4.87713665e-02f, -2.36459762e-01f, -5.45125127e-01f, 1.69528395e-01f, 5.53923488e-01f,
  5.47148705e-01f, 2.63088405e-01f, -5.25505692e-02f, -1.54875025e-01f, -6.54988766e-01f, -3.54509979e-01f, 1.02277577e-01f, 5.27988315e-01f, 2.42549881e-01f, -4.18114334e-01f,
  2.41729960e-01f, 1.29983515e-01f, 2.23289683e-01f, -1.55079618e-01f, 4.07226592e-01f, -2.81554669e-01f, -8.12166333e-02f, 3.77256989e-01f, 2.89210767e-01f, 2.43109643e-01f,
  9.20209289e-02f, -2.12684110e-01f, -2.39274055e-01f, 2.56757259e-01f, 3.37902874e-01f, -1.97419018e-01f, 4.57202047e-01f, 2.94711500e-01f, 3.83236945e-01f, 4.23617274e-01f,
  -1.81708097e-01f, 3.66623372e-01f, 4.01862770e-01f, 4.36054140e-01f, -1.75276756e-01f, 4.29184914e-01f, -1.90857753e-01f, -1.76301733e-01f, 5.15833020e-01f, -3.90536726e-01f,
  -2.48356044e-01f, 4.18343067e-01f, 3.60464692e-01f, -2.17033967e-01f, 3.40233326e-01f, -6.07453823e-01f, 4.06895489e-01f, -1.50962159e-01f, 2.40840271e-01f, 1.00102220e-02f,
  -2.33445808e-01f, 1.62043050e-01f, -1.81332052e-01f, -2.48551011e-01f, -5.40596724e-01f, -5.64972937e-01f, 1.27022788e-01f, 8.58435482e-02f, 1.64043397e-01f, -2.98011303e-01f,
  3.67609411e-01f, -1.26833081e-01f, 1.28542572e-01f, 4.04828370e-01f, 4.41258967e-01f, 4.99325424e-01f, -9.18917283e-02f, -1.69027641e-01f, 7.21206367e-02f, 1.08537115e-01f,
  1.06679253e-01f, 3.34327906e-01f, 3.25132102e-01f, -4.77553606e-01f, 2.15885028e-01f, 2.83162087e-01f, 6.58145323e-02f, -1.57641083e-01f, -6.47770166e-02f, 9.53351036e-02f,
  1.07490115e-01f, 5.30148149e-01f, 2.25519583e-01f, 1.73065424e-01f, 7.46974349e-03f, 1.21629685e-01f, 4.37743336e-01f, -3.64885181e-01f, -1.63376722e-02f, -2.64822185e-01f,
  1.89432412e-01f, 3.50528687e-01f, -3.13071936e-01f, -1.94553927e-01f, 6.18150890e-01f, 4.62664813e-01f, 4.27076995e-01f, 2.86746711e-01f, 3.23863119e-01f, -4.21566933e-01f,
  -1.75700113e-01f, -3.37358505e-01f, -2.21966118e-01f, 4.33875978e-01f, 6.18968666e-01f, -4.66447234e-01f, 1.84958413e-01f, -1.60562158e-01f, 4.18046385e-01f, -5.58053672e-01f,
  3.00983816e-01f, -2.40612864e-01f, 3.08333725e-01f, -4.36995715e-01f, -4.29947942e-01f, -8.89140964e-02f, 3.52168024e-01f, -4.25919354e-01f, -5.03776133e-01f, -4.48672622e-01f,
  2.26096556e-01f, 5.03984451e-01f, -2.55624741e-01f, 2.79513836e-01f, 2.63759434e-01f, -6.35868162e-02f, 4.67629343e-01f, 5.52994192e-01f, 4.86474514e-01f, 5.71829498e-01f,
  2.36123800e-02f, -1.19817585e-01f, -6.37298217e-03f, 4.01277393e-02f, 1.63881600e-01f, 4.53893989e-01f, 1.64852977e-01f, -5.02059102e-01f, 2.19909832e-01f, 8.86894688e-02f,
  1.73836261e-01f, -3.23132604e-01f, 1.53688550e-01f, -2.99582064e-01f, 3.13358754e-01f, 1.90711603e-01f, 1.87369734e-02f, 3.75575155e-01f, 2.85908878e-01f, 4.50967073e-01f,
  2.59848505e-01f, -9.44485292e-02f, 3.28700125e-01f, 1.12832179e-02f, 2.16388300e-01f, 4.82098430e-01f, -3.38168666e-02f, -4.22155112e-01f, -1.03591993e-01f, 5.51662408e-02f,
  9.23403278e-02f, 4.37227845e-01f, -3.66179854e-01f, -4.95810285e-02f, 7.28971064e-01f, 4.24451798e-01f, -3.85936975e-01f, -2.96278059e-01f, -1.84836283e-01f, -3.26059818e-01f,
  2.44095072e-01f, 4.32915330e-01f, 5.01962721e-01f, 1.24278339e-02f, 3.47976774e-01f, -5.02112508e-01f, 5.44716179e-01f, -4.25121009e-01f, -3.91737640e-01f, 3.44825566e-01f,
  3.29131097e-01f, 1.54760689e-01f, 2.61146873e-01f, 2.86543012e-01f, 3.71177018e-01f, 5.78432381e-01f, -2.33578920e-01f, 3.23094934e-01f, 2.85418212e-01f, -2.30477244e-01f,
  1.90841630e-01f, -2.14639157e-02f, -7.84457922e-02f, 4.68287408e-01f, -5.92791796e-01f, -1.17754340e-01f, 4.42212760e-01f, 6.17219090e-01f, -5.03985882e-01f, 1.27238095e-01f,
  -1.64820001e-01f, -1.62198152e-02f, 2.73389399e-01f, 2.92973131e-01f, -2.62646675e-02f, 1.35861695e-01f, -2.97531873e-01f, 1.81337539e-02f, 1.12508819e-01f, -3.68289873e-02f,
  3.82798910e-01f, -2.39877805e-01f, -1.39499560e-01f, 3.50419283e-01f, 3.09628993e-01f, 2.26430640e-01f, 3.83328855e-01f, -4.19523597e-01f, -4.58080143e-01f, 3.13963801e-01f,
  -2.62791365e-01f, -2.61297598e-02f, 6.73016980e-02f, 5.51925063e-01f, 1.83207199e-01f, 6.85932934e-02f, 5.88458002e-01f, 5.23704469e-01f, 2.83526927e-01f, -2.30043102e-02f,
  4.51732695e-01f, 1.68139905e-01f, 7.23152578e-01f, -1.57050461e-01f, -7.61870146e-02f, 6.06057495e-02f, 1.37220532e-01f, 8.11718553e-02f, -2.00128749e-01f, 2.71082222e-01f,
  -4.05153960e-01f, 6.17512286e-01f, 4.81863022e-01f, 5.91939352e-02f, 2.82736242e-01f, 8.33156407e-02f, -5.38507223e-01f, 4.72889207e-02f, -5.43272495e-01f, 3.98810327e-01f,
  5.42111158e-01f, 3.98344517e-01f, -8.55665430e-02f, 2.27041200e-01f, 2.56951720e-01f, 3.52898926e-01f, -1.97575793e-01f, 8.93824175e-02f, 5.96667886e-01f, 7.62255788e-02f,
  -8.74132514e-02f, -3.25413018e-01f, 8.38257521e-02f, 4.47854489e-01f, 6.81021959e-02f, -5.20702414e-02f, 7.05130547e-02f, 4.76086915e-01f, 2.40441293e-01f, 1.75913632e-01f,
  -1.31710425e-01f, -4.39476579e-01f, 2.51988769e-01f, 4.12360817e-01f, 7.08937421e-02f, 5.61111808e-01f, 1.54191181e-02f, 3.08673501e-01f, -2.27567300e-01f, 5.90453923e-01f,
  1.23297684e-01f, 1.64477248e-02f, 4.34061438e-01f, -2.18809456e-01f, 3.36435229e-01f, 1.96837291e-01f, -1.19860061e-01f, 3.49201262e-02f, 2.90239155e-01f, -1.71587914e-01f,
  -3.74681950e-01f, 9.27226394e-02f, -6.12017334e-01f, 2.90216595e-01f, 1.86236516e-01f, -2.51491278e-01f, -2.99245238e-01f, 6.00478470e-01f, 2.31901646e-01f, 2.00466067e-01f,
  3.02327424e-01f, -1.66652933e-01f, -2.21896872e-01f, -4.44269091e-01f, 8.26900080e-02f, 1.13445684e-01f, 2.60595709e-01f, 2.56938905e-01f, 3.77039492e-01f, 5.62143505e-01f,
  -5.22705674e-01f, 5.42178266e-02f, -1.55310005e-01f, -4.88597095e-01f, 5.60710020e-02f, -2.04746738e-01f, -5.07558405e-01f, -5.08276761e-01f, -1.45128027e-01f, 2.76626408e-01f,
  4.03865755e-01f, 3.25875819e-01f, -1.02548453e-03f, -3.96517776e-02f, 6.91688445e-04f, 3.34224939e-01f, -3.41569990e-01f, 4.89887223e-02f, 3.28596145e-01f, -3.90712947e-01f,
  -5.55138197e-03f, 1.62902758e-01f, 2.30728835e-01f, -4.78422418e-02f, 2.03506261e-01f, 4.91013139e-01f, 2.89955437e-01f, 3.80994529e-01f, 2.89239753e-02f, -1.66040599e-01f,
  -9.74855013e-03f, -2.11613283e-01f, -1.24783449e-01f, -1.11306414e-01f, 5.55185437e-01f, -1.40587598e-01f, 4.92087603e-01f, 3.28214141e-04f, 5.00527442e-01f, 5.94372869e-01f,
  1.11686094e-02f, -2.72120029e-01f, -1.26127988e-01f, 5.63075185e-01f, 3.13634604e-01f, 1.85689002e-01f, 3.34292322e-01f, -1.91022068e-01f, 2.62420177e-01f, -3.62746537e-01f,
  2.66142040e-01f, 2.18546316e-01f, -4.69441861e-02f, 1.23659270e-02f, 7.78126568e-02f, 1.80902511e-01f, -9.43519361e-03f, -3.04354191e-01f, -3.73991370e-01f, -2.57875502e-01f,
  1.37936026e-01f, -3.56669158e-01f, -2.71726757e-01f, 3.34259063e-01f, 3.67669761e-02f, 7.35527351e-02f, 1.93684056e-01f, 1.57695353e-01f, 1.59480646e-01f, 4.73320961e-01f,
  6.12842292e-02f, 2.27916121e-01f, -3.52003187e-01f, 4.29200411e-01f, -2.50181019e-01f, -1.77987456e-01f, 1.51230589e-01f, 6.09673440e-01f, 3.04939508e-01f, 2.37745289e-02f,
  5.31803250e-01f, -3.62665176e-01f, -1.88025832e-01f, 5.19077405e-02f, 2.57865399e-01f, 2.05670223e-01f, 1.24388315e-01f, 6.46462962e-02f, 1.18701614e-01f, -3.15826029e-01f,
  3.30574632e-01f, -4.90565628e-01f, -2.18411997e-01f, 3.41092080e-01f, 2.71179259e-01f, 3.85303795e-01f, 1.82246983e-01f, 1.89377621e-01f, 4.74818856e-01f, 2.32977405e-01f,
  -3.87355313e-02f, -1.17658481e-01f, 4.57662046e-01f, 3.68239373e-01f, -5.21162927e-01f, -5.60731709e-01f, -4.47711140e-01f, 1.40930295e-01f, -3.31694007e-01f, 5.07167995e-01f,
  7.28128970e-01f, 7.07242489e-01f, -2.85285600e-02f, -2.38941789e-01f, -5.75493693e-01f, 5.33563375e-01f, -1.07478350e-02f, 4.54789698e-02f, 1.86017796e-01f, -4.81906325e-01f,
  -2.11327478e-01f, -2.53793150e-01f, 4.95243780e-02f, -5.71212508e-02f, 3.38363111e-01f, 3.04914296e-01f, 4.81100708e-01f, 6.06541753e-01f, 5.90412803e-02f, 2.38629803e-02f,
  -1.83662519e-01f, 2.50196546e-01f, 2.31073558e-01f, 1.15688495e-01f, -4.88730520e-01f, -2.58728236e-01f, 2.80939251e-01f, 1.11378938e-01f, 5.28176665e-01f, 4.37296748e-01f,
  -2.97602415e-01f, -2.92543080e-02f, 1.55859783e-01f, 2.55811363e-01f, -4.62630183e-01f, 4.06138510e-01f, 1.00125365e-01f, -2.95070589e-01f, 5.78318164e-02f, 7.62351453e-02f,
  1.97554410e-01f, 1.12257339e-01f, -7.35443160e-02f, 3.61495465e-01f, 3.78387630e-01f, 3.81433785e-01f, -6.60052672e-02f, 1.40855834e-01f, -1.65474877e-01f, 1.24091819e-01f,
  3.83493662e-01f, -2.30136096e-01f, -2.11017475e-01f, -3.56745690e-01f, 5.08462973e-02f, 2.45389581e-01f, -4.46441829e-01f, -1.22572005e-01f, 5.23575306e-01f, 4.08664763e-01f,
  5.05201697e-01f, 1.82465181e-01f, 3.53784263e-01f, -4.80084836e-01f, 2.85240691e-02f, -2.23878101e-01f, -1.87786713e-01f, 4.91119921e-01f, 6.11796975e-01f, -3.30453277e-01f,
  2.43102908e-01f, 4.62475628e-01f, 2.34606415e-01f, 5.69059908e-01f, -3.58628154e-01f, -4.38456647e-02f, 2.47973889e-01f, -4.55783941e-02f, -6.01722002e-02f, 5.04882514e-01f,
  -2.70459712e-01f, 4.87699628e-01f, 5.93546331e-01f, 5.69813669e-01f, -4.21016961e-02f, -3.10502052e-01f, -2.33356237e-01f, 1.27791613e-01f, 2.08090827e-01f, -1.36810184e-01f,
  3.46855998e-01f, -1.55586645e-01f, 2.12260976e-01f, -4.26857561e-01f, -4.21248734e-01f, -4.61246185e-02f, -2.43814841e-01f, 5.26268363e-01f, -2.86373943e-01f, -3.29369195e-02f,
  2.82539606e-01f, 4.02699232e-01f, 1.72860950e-01f, 4.23203468e-01f, 2.49533623e-01f, 5.73069632e-01f, -3.13166350e-01f, 2.06117481e-01f, -8.37534294e-03f, 1.74621850e-01f,
  1.12628683e-01f, 1.93897799e-01f, 3.11369449e-01f, 4.39860731e-01f, 4.52237725e-01f, 5.84134102e-01f, -3.33259761e-01f, 2.79699206e-01f, 1.97377160e-01f, 4.67713565e-01f,
  4.74932007e-02f, 1.57660067e-01f, 3.93669158e-01f, -2.24354371e-01f, -1.56352445e-01f, -2.85831690e-01f, 1.30489066e-01f, 1.34336501e-01f, 1.90188646e-01f, 2.67937124e-01f,
  3.75974476e-02f, 9.91486460e-02f, -6.96139038e-02f, 4.80820179e-01f, 2.87679970e-01f, 2.76052266e-01f, 1.87556595e-01f, 5.11450529e-01f, -3.71288151e-01f, 5.36986351e-01f,
  -3.38830739e-01f, 2.83857256e-01f, 1.90121025e-01f, -2.93477979e-02f, -1.99485511e-01f, -2.25697353e-01f, -2.46057913e-01f, 4.27619845e-01f, 2.16888323e-01f, -2.50570685e-01f,
  -8.28026980e-03f, -1.32622570e-01f, 4.58494484e-01f, 5.88020027e-01f, 3.05397362e-02f, -3.84793788e-01f, -2.78343379e-01f, -4.26967084e-01f, 6.03874028e-01f, 3.43146861e-01f,
  6.04340732e-02f, 3.96321304e-02f, 5.55694759e-01f, -3.24383676e-01f, 4.35348839e-01f, 4.10207808e-01f, 6.12586923e-02f, 2.18547478e-01f, 3.84120941e-01f, -2.19889000e-01f,
  -2.79153466e-01f, -8.35278779e-02f, -9.22935307e-02f, 5.44363976e-01f, 4.36321080e-01f, 1.92548424e-01f, 4.68962789e-01f, 5.79657614e-01f, -3.65797669e-01f, 2.45226637e-01f,
  -5.36232293e-01f, -6.46988153e-02f, 5.43057978e-01f, 3.51095676e-01f, -2.13975087e-01f, 7.50496089e-02f, -7.14956522e-02f, 2.36041471e-01f, -1.31655097e-01f, 4.84006792e-01f,
  1.94293242e-02f, 1.94631532e-01f, 3.44670683e-01f, 1.93357691e-01f, 1.10596098e-01f, -2.25863844e-01f, -4.43534732e-01f, -2.44015492e-02f, 2.41586924e-01f, 8.90920535e-02f,
  4.35695589e-01f, 1.49325013e-01f, -4.34547402e-02f, 2.28988647e-01f, 7.81232491e-02f, 4.58779544e-01f, 3.64162862e-01f, 3.04414213e-01f, -1.30818570e-02f, 4.81469743e-02f,
  -6.41551495e-01f, 2.53537029e-01f, -3.23331803e-01f, -8.72810259e-02f, 4.12655443e-01f, -1.03058666e-01f, 1.51528135e-01f, 3.55172753e-01f, 4.46090966e-01f, 1.96141869e-01f,
  4.94639635e-01f, 2.43054733e-01f, 5.41933477e-01f, -3.63735586e-01f, -6.34801388e-01f, -2.47836262e-01f, 1.03965923e-01f, 2.53294051e-01f, 4.12808269e-01f, 5.57466336e-02f,
  3.63849044e-01f, 2.56517589e-01f, 3.43280852e-01f, -2.40480050e-01f, 1.70466721e-01f, -2.13864535e-01f, 3.61902684e-01f, -7.87793249e-02f, -4.09126878e-01f, 3.34108680e-01f,
  -3.33193660e-01f, -3.31951678e-01f, 8.09716165e-01f, 3.18199664e-01f, 4.63282228e-01f, -6.24596715e-01f, -2.99819916e-01f, 1.24916442e-01f, 2.46244639e-01f, 1.77766681e-01f,
  1.82275027e-02f, 5.92318296e-01f, 5.69291115e-01f, -1.47113159e-01f, -1.13265842e-01f, 5.08612752e-01f, -1.91890150e-01f, 9.82579514e-02f, 4.77427572e-01f, 2.05784872e-01f,
  3.51878762e-01f, 2.11028054e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  4.98243779e-01f, 2.96305597e-01f, 2.80224234e-01f, 3.08022529e-01f, 6.97095245e-02f, 1.52705267e-01f, 2.24953175e-01f, 2.03542352e-01f, 1.79598406e-01f, 3.72716427e-01f,
  1.86463937e-01f, 1.50597990e-01f, 3.46949220e-01f, 4.68358874e-01f, 3.77188593e-01f, 2.31980145e-01f, 4.63129841e-02f, 1.49199083e-01f, 1.65206477e-01f, 4.04395521e-01f,
  3.66321862e-01f, 4.22871977e-01f, 1.61033839e-01f, 1.62642941e-01f, 3.06053042e-01f, 1.71827659e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  3.76120955e-02f, -2.04990670e-01f, 6.60732342e-03f, -2.42074695e-03f, 2.85139710e-01f, 2.30625167e-01f, -2.59960085e-01f, -1.54258430e-01f, -4.58042145e-01f, 8.48476663e-02f,
  3.87040943e-01f, 2.65889615e-01f, -1.81554735e-01f, 3.19474429e-01f, -4.96669739e-01f, 3.42785507e-01f, -3.56523424e-01f, -5.98704159e-01f, 2.99244255e-01f, 1.44522786e-01f,
  2.17969641e-01f, -2.55192257e-03f, -3.95141304e-01f, -3.89056563e-01f, 4.06217277e-01f, -5.22834174e-02f, -4.66481656e-01f, -2.48289481e-01f, -5.13602018e-01f, 4.29154217e-01f,
  1.44236505e-01f, -6.55213833e-01f, 1.74166337e-01f, 9.04830545e-02f, -9.15388688e-02f, 2.63834715e-01f, 2.83382889e-02f, 9.82223079e-02f, -4.93586391e-01f, -6.24774814e-01f,
  -5.75399637e-01f, 4.79231119e-01f, -6.78496361e-01f, 2.52438337e-01f, -5.02641499e-01f, -5.84752858e-01f, 7.48796165e-02f, -4.64057714e-01f, -4.95654404e-01f, -4.76555496e-01f,
  3.66791189e-01f, 4.57791984e-01f, -4.90668803e-01f, 1.48477972e-01f, 1.10898115e-01f, -1.24665331e-02f, -4.68155235e-01f, -4.54675823e-01f, 1.97662637e-01f, 4.32966560e-01f,
  1.39191136e-01f, 2.58862704e-01f, 3.17853898e-01f, -2.32945904e-01f, 1.12598985e-02f, -2.26210967e-01f, -3.99526097e-02f, -1.11532912e-01f, -1.49984837e-01f, -4.27582562e-01f,
  3.75602454e-01f, -4.72318381e-01f, -4.04706031e-01f, -4.06595459e-03f, -1.82414174e-01f, 3.50000530e-01f, -3.08737934e-01f, -2.45100200e-01f, -3.67978811e-01f, -5.77448130e-01f,
  -5.07535517e-01f, 2.93523788e-01f, -5.65283895e-01f, 1.23757660e-01f, -2.06143767e-01f, 4.26347971e-01f, 3.61519516e-01f, 3.76463503e-01f, -2.44170070e-01f, -2.35160634e-01f,
  -2.97220856e-01f, -2.01192826e-01f, 2.85908610e-01f, -5.67517996e-01f, -4.42927778e-01f, 2.95347601e-01f, 1.35059834e-01f, 3.25764297e-03f, -5.80115579e-02f, -1.90096170e-01f,
  -1.32217795e-01f, 2.32925028e-01f, -6.42467678e-01f, 8.23477507e-02f, -7.00042173e-02f, 3.84067327e-01f, 3.74363124e-01f, -5.85180998e-01f, 3.72981310e-01f, 3.19510967e-01f,
  3.05648655e-01f, -6.96574748e-01f, -6.70703292e-01f, 1.74147218e-01f, -2.20795758e-02f, -5.74768424e-01f, 1.48260161e-01f, -7.70656466e-01f, 6.45808876e-02f, 1.00881746e-02f,
  2.79953986e-01f, 3.16580564e-01f, -6.26708493e-02f, -5.62392235e-01f, -6.13002837e-01f, -5.15898347e-01f, 3.25691700e-01f, 2.14350551e-01f, 2.34701112e-01f, 2.78693944e-01f,
  2.20985830e-01f, 4.00672883e-01f, 2.02601343e-01f, -5.10493457e-01f, 3.37341160e-01f, -8.58913809e-02f, 4.54552233e-01f, -3.59868437e-01f, 3.09370100e-01f, 2.95614392e-01f,
  3.17856044e-01f, 1.34095177e-01f, 3.00214350e-01f, -8.06831475e-03f, 2.57641282e-02f, -3.20068076e-02f, -3.02586883e-01f, 1.57534316e-01f, 1.70569226e-01f, 8.41077119e-02f,
  -1.28913611e-01f, -8.15895975e-01f, -3.37949917e-02f, 1.39402568e-01f, -1.16457261e-01f, -5.56529522e-01f, -3.00302088e-01f, -1.75721541e-01f, 2.41301507e-01f, 3.25970471e-01f,
  -8.41096044e-02f, 1.16839647e-01f, 2.15606034e-01f, 5.67591190e-01f, 4.22242790e-01f, 4.69017416e-01f, -9.54335406e-02f, 1.02736376e-01f, -4.23763394e-01f, -2.15336099e-01f,
  -3.02544653e-01f, -4.30619180e-01f, -3.12472254e-01f, -5.15935600e-01f, -3.87145132e-01f, 3.01102698e-01f, 2.35402912e-01f, 9.70197767e-02f, -3.85056108e-01f, 2.11321682e-01f,
  5.06684244e-01f, -6.03154063e-01f, 5.50654978e-02f, 4.44771528e-01f, 5.58262944e-01f, -3.99586499e-01f, 3.87730211e-01f, 3.17980766e-01f, -2.94449180e-01f, 1.54135406e-01f,
  -1.31666228e-01f, -3.23731691e-01f, 4.73409854e-02f, 3.28357914e-03f, 2.46547297e-01f, -6.05050564e-01f, 2.33635053e-01f, -3.24999809e-01f, 3.66973966e-01f, -5.19583404e-01f,
  4.85871524e-01f, -3.10134292e-01f, -2.76259273e-01f, 7.27364644e-02f, -4.17543590e-01f, -4.85406518e-01f, -4.65510547e-01f, -1.08682532e-02f, 2.37862632e-01f, -4.13471997e-01f,
  -3.55362743e-01f, 4.01089877e-01f, -6.27841592e-01f, -2.90771842e-01f, -3.45696390e-01f, 3.62160772e-01f, -7.08504796e-01f, -5.46924233e-01f, 4.82162744e-01f, 1.10471398e-01f,
  -5.73683232e-02f, -6.95051312e-01f, -1.67251870e-01f, 3.81740808e-01f, -1.75341740e-01f, -4.27454002e-02f, -6.64257705e-02f, 1.77748039e-01f, 2.71865100e-01f, -3.72827291e-01f,
  -2.28314579e-01f, 4.17473912e-01f, -4.54034656e-01f, -3.15018624e-01f, 3.05691481e-01f, -4.87753510e-01f, -2.37052161e-02f, 1.60483658e-01f, 4.89341944e-01f, -3.56358021e-01f,
  4.04646099e-01f, -5.17090499e-01f, 3.75850976e-01f, -4.21925545e-01f, -3.45907778e-01f, -5.26547790e-01f, -7.84352198e-02f, -1.23448551e-01f, 3.73140454e-01f, 3.60104330e-02f,
  -4.67343897e-01f, 2.52064079e-01f, -4.11812127e-01f, -2.48763621e-01f, 8.29854757e-02f, -4.05122340e-01f, -6.35023490e-02f, -3.42841148e-01f, -1.02707952e-01f, 2.29659930e-01f,
  -2.16901705e-01f, 2.67261267e-01f, -4.68985230e-01f, 5.49588978e-01f, -6.44041225e-02f, -2.76924521e-01f, -2.14814305e-01f, 1.69246510e-01f, -3.01827729e-01f, -2.45538622e-01f,
  -7.55967051e-02f, 5.65328859e-02f, -5.31366229e-01f, 5.32348990e-01f, 1.70316383e-01f, -3.39582950e-01f, -2.76286751e-01f, -1.76315784e-01f, 4.61704850e-01f, -2.11353470e-02f,
  -2.63054490e-01f, -3.99577588e-01f, -4.17888552e-01f, 1.13709256e-01f, -7.49031380e-02f, 2.65067816e-01f, -3.82484198e-01f, 1.65172771e-01f, 1.41338646e-01f, -8.85598660e-02f,
  -3.19838583e-01f, 3.95154238e-01f, 1.30721882e-01f, -3.30124229e-01f, 4.41301823e-01f, 7.54021574e-03f, 3.42592955e-01f, -4.76007313e-01f, -5.35020590e-01f, -1.92864239e-02f,
  3.60374302e-01f, -4.64239568e-01f, 3.01336557e-01f, 4.11152840e-01f, 4.28405255e-01f, -5.88798821e-01f, -2.33844221e-01f, -2.81853735e-01f, -2.40306482e-01f, 4.95658994e-01f,
  -1.36661917e-01f, 3.83246541e-01f, -9.68526676e-02f, -4.17399764e-01f, -6.82778656e-01f, -6.14947796e-01f, -3.98025244e-01f, -3.73706147e-02f, -6.12926781e-01f, -2.93208838e-01f,
  -2.15586558e-01f, -2.33272329e-01f, 2.48370126e-01f, -3.77995372e-01f, -3.34098190e-01f, 3.52692194e-02f, -4.69632298e-01f, -5.48079848e-01f, -4.39137042e-01f, 3.38760853e-01f,
  -3.26815367e-01f, -4.89561021e-01f, -3.00454646e-01f, 3.09545964e-01f, -2.82857060e-01f, -5.77667415e-01f, -5.02794564e-01f, 3.24259013e-01f, 3.74370307e-01f, -4.68866676e-01f,
  -8.58493298e-02f, 1.24712475e-01f, -4.80205148e-01f, -1.71002969e-01f, -5.80948353e-01f, 2.45844156e-01f, -3.70802507e-02f, 2.00144306e-01f, 4.99666989e-01f, -1.40415698e-01f,
  4.99968380e-01f, -2.57739216e-01f, 3.18775512e-03f, -2.54883170e-01f, -8.87759216e-03f, -3.22409570e-01f, -2.87831336e-01f, 1.63147852e-01f, -3.39009792e-01f, 2.61134326e-01f,
  6.36023581e-02f, -2.90029466e-01f, -4.32846218e-01f, -5.07442057e-01f, -4.92041677e-01f, 3.39750290e-01f, -2.06131890e-01f, 2.69339919e-01f, 1.92573696e-01f, 2.15152800e-01f,
  -4.89208430e-01f, -4.12201136e-01f, -3.65667731e-01f, -3.28794830e-02f, -1.73972830e-01f, -1.00492075e-01f, 1.04235753e-01f, 4.19807732e-01f, 4.76789266e-01f, 3.46946150e-01f,
  -5.08060634e-01f, -5.28049946e-01f, -4.89886850e-01f, 2.72078127e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.87400123e-02f, 2.09492501e-02f, -1.38011113e-01f, -2.97874808e-01f, -9.39379483e-02f, -7.06148148e-02f, 2.71427315e-02f, -5.20927906e-02f, -4.12204042e-02f, 1.55578032e-01f,
  7.48915598e-02f, 8.22143555e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    