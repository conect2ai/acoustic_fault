/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.38335663e-01f, -4.51367199e-02f, -3.80610079e-01f, -3.78846340e-02f, -2.03447640e-01f, -3.22738111e-01f, -2.84879357e-01f, -1.77185256e-02f, 7.47102425e-02f, 7.29878666e-03f,
  2.22741663e-02f, 2.27323204e-01f, 1.82655901e-01f, 9.67611149e-02f, -1.52739128e-02f, -3.50731611e-01f, -2.94048041e-01f, -1.33667439e-01f, 4.25446145e-02f, 1.41072916e-02f,
  3.33956862e-03f, 8.21846500e-02f, 2.93063730e-01f, 1.18967049e-01f, -2.01112598e-01f, -1.56123474e-01f, -1.52101323e-01f, -6.33905977e-02f, -1.41453609e-01f, -2.15065658e-01f,
  -2.73390889e-01f, 7.05663580e-03f, -9.83382910e-02f, 1.18053213e-01f, -8.60219002e-02f, -5.98982684e-02f, -7.01270327e-02f, 1.00017525e-02f, -7.59375142e-03f, -7.09756985e-02f,
  2.06805989e-02f, -3.83433960e-02f, 1.11241387e-02f, -4.25702557e-02f, -5.46652079e-02f, -8.92650038e-02f, -9.94853117e-03f, -1.07298739e-01f, -1.10724851e-01f, -5.54842688e-02f,
  -2.52122637e-02f, -6.03426844e-02f, -1.80852294e-01f, -1.02285177e-01f, -1.21089377e-01f, 1.19386651e-02f, -1.98971909e-02f, -1.64800644e-01f, -1.91956505e-01f, -1.63041919e-01f,
  3.37995887e-02f, 4.44191992e-02f, 1.70208439e-02f, 1.21486947e-01f, 1.11855650e-02f, 4.81566191e-02f, 5.12258038e-02f, 5.10089211e-02f, 2.91648991e-02f, 1.13622449e-01f,
  8.59261379e-02f, 3.85275632e-02f, 5.05987853e-02f, 1.30607896e-02f, 2.11095512e-02f, 1.95634319e-03f, 1.85751095e-02f, 2.85234936e-02f, 6.45965636e-02f, 1.07732788e-01f,
  3.38645652e-02f, 2.15533152e-02f, 4.39142175e-02f, 2.56739520e-02f, -6.71039522e-02f, -2.38730572e-02f, 1.50866974e-02f, 1.29659146e-01f, 1.19188718e-01f, 1.28233925e-01f,
  -7.04896301e-02f, 2.33642384e-02f, -7.08414987e-02f, -5.90847842e-02f, -1.78727731e-02f, -1.20885260e-01f, -8.68557543e-02f, -3.03910170e-02f, 4.24794992e-03f, -6.02859519e-02f,
  -5.59514351e-02f, -2.82984003e-02f, -6.02644347e-02f, -8.93559530e-02f, -9.81132984e-02f, -3.12824845e-02f, -6.90902248e-02f, -3.57461050e-02f, -4.75832149e-02f, -3.25726457e-02f,
  -4.37983088e-02f, -6.28149956e-02f, -3.46321650e-02f, -1.58649057e-01f, -1.56223789e-01f, -9.56555307e-02f, -1.74548998e-01f, -1.57920271e-01f, -5.30677922e-02f, -9.38344821e-02f,
  1.64670959e-01f, -2.94859125e-03f, -4.26027663e-02f, -4.20901701e-02f, -6.32889718e-02f, 6.95164278e-02f, 4.49887216e-02f, -1.52259618e-02f, 1.20612331e-01f, -2.68467311e-02f,
  6.92321733e-03f, 6.78534284e-02f, -3.57988365e-02f, 5.93759157e-02f, 3.19445394e-02f, 3.92569080e-02f, -1.19436570e-01f, 4.06576134e-02f, 2.48294711e-01f, 2.05829233e-01f,
  1.06131127e-02f, 4.95337099e-02f, 1.15811951e-01f, 1.09204091e-02f, 3.72081511e-02f, 1.53361082e-01f, -2.23585479e-02f, 5.35971373e-02f, -6.43570162e-03f, -8.26250017e-02f,
  2.80945957e-01f, 2.30806336e-01f, 1.74200892e-01f, 1.38696089e-01f, 1.57877281e-02f, 1.36748761e-01f, 1.81510881e-01f, 1.63987905e-01f, 1.34758711e-01f, 1.77791297e-01f,
  7.65519291e-02f, 1.34522215e-01f, 7.31108636e-02f, 7.94970170e-02f, 7.67797977e-02f, 1.64513513e-01f, 1.10009022e-01f, 9.72866043e-02f, 1.55573785e-01f, 1.22451611e-01f,
  4.36050594e-02f, 8.69808942e-02f, 9.30934101e-02f, 1.13021202e-01f, 1.98094577e-01f, 1.65812716e-01f, 1.07832775e-01f, 2.13853553e-01f, 1.73082262e-01f, 1.92634106e-01f,
  -8.74707624e-02f, -6.24303222e-02f, 3.18777910e-03f, -3.69670130e-02f, -1.19980454e-01f, -4.54358049e-02f, -1.55771941e-01f, -6.09719306e-02f, -9.61834937e-02f, -1.07508771e-01f,
  -7.04531893e-02f, -4.04034406e-02f, -1.17273420e-01f, 4.96913381e-02f, -6.00557663e-02f, -5.75241297e-02f, -1.17054135e-01f, -3.44439633e-02f, 4.06770315e-03f, -1.34233907e-01f,
  2.30730567e-02f, -1.13568604e-02f, -8.49540904e-02f, -5.24270721e-02f, -6.02141619e-02f, -9.06997547e-02f, -1.03450812e-01f, 5.01653692e-03f, -2.96890941e-02f, -1.15972916e-02f,
  2.67570049e-01f, 9.38091576e-02f, 1.37482703e-01f, 1.14490688e-01f, 1.78213403e-01f, 1.38585925e-01f, 9.43911225e-02f, 1.52817681e-01f, 1.30248249e-01f, 1.24640971e-01f,
  1.08498514e-01f, 1.50425985e-01f, 9.00275931e-02f, 7.56305978e-02f, 2.33705193e-02f, 8.95904526e-02f, 5.85107803e-02f, 9.65105463e-03f, 1.67045787e-01f, 1.10794812e-01f,
  1.19874962e-01f, 2.53745615e-01f, 2.47879416e-01f, 1.97816208e-01f, 1.48218602e-01f, 1.68258771e-01f, 1.41209602e-01f, 1.37400016e-01f, 3.21073651e-01f, 2.90745169e-01f,
  4.24290806e-01f, -9.91568118e-02f, -3.56666520e-02f, 1.42944351e-01f, -3.99927534e-02f, -9.97579247e-02f, -2.42912933e-01f, -6.33236989e-02f, 1.64117426e-01f, 1.87663957e-02f,
  1.46063464e-02f, -2.32279319e-02f, 4.71467152e-02f, -1.16040930e-02f, -3.37729827e-02f, -2.03204080e-02f, 4.62794118e-02f, 8.08897093e-02f, -9.60399583e-02f, -1.91553459e-01f,
  -2.75865570e-02f, 1.68687925e-01f, 1.68866828e-01f, 8.61969888e-02f, 1.66649893e-01f, -3.04549783e-02f, -1.74182449e-02f, 9.25778002e-02f, 2.61948965e-02f, 1.95128575e-01f,
  7.62355775e-02f, 1.01964317e-01f, -1.29614159e-01f, 1.50332507e-02f, 9.47655812e-02f, 2.60177758e-02f, 9.09453630e-02f, 7.62795135e-02f, 6.82213604e-02f, 2.48959921e-02f,
  3.20113897e-02f, 4.97711673e-02f, 3.88775431e-02f, 5.94099537e-02f, -2.46983208e-02f, 6.77935854e-02f, 1.31759912e-01f, 6.25730380e-02f, 1.11614712e-01f, 7.32409135e-02f,
  -7.49163330e-02f, -8.86387099e-03f, 6.57883361e-02f, 2.22873595e-02f, -3.05984709e-02f, 7.24292174e-02f, -5.05638160e-02f, 1.53441057e-01f, 6.58128550e-03f, 8.94254074e-02f,
  8.96105636e-03f, -7.11138323e-02f, -6.84548467e-02f, -8.66089314e-02f, -2.77244803e-02f, -6.85368925e-02f, -3.13400216e-02f, -9.61247236e-02f, -5.76676689e-02f, 7.99662154e-03f,
  7.23423064e-03f, 2.50943494e-03f, -5.69393411e-02f, -1.60906762e-02f, -6.28682524e-02f, 3.01554669e-02f, -4.38397899e-02f, -7.28985816e-02f, -2.70731859e-02f, -1.23702297e-02f,
  3.64124663e-02f, 2.53185388e-02f, 2.52668858e-02f, -8.37266147e-02f, -1.74860153e-02f, -8.69729370e-02f, -3.76173221e-02f, -4.24104854e-02f, 1.44361993e-02f, 3.34671885e-02f,
  1.32903159e-01f, -7.49008656e-02f, 1.51849940e-01f, -2.62851249e-02f, 8.29305276e-02f, 4.16584760e-02f, 9.68872532e-02f, 7.10766613e-02f, 2.62832874e-03f, 2.70657204e-02f,
  7.36701414e-02f, 1.05519280e-01f, 2.67251804e-02f, 4.58317660e-02f, 8.91756043e-02f, -6.09718189e-02f, 3.95612121e-02f, 7.92500973e-02f, 2.38671079e-02f, 2.95807570e-02f,
  -1.10539244e-02f, -2.01946571e-02f, 7.99900293e-02f, 2.85565667e-02f, 1.81676517e-03f, 6.58505708e-02f, -1.68890029e-03f, -1.17808860e-02f, -4.57117148e-02f, -2.91251633e-02f,
  -4.61040825e-01f, -4.72718552e-02f, -5.42900041e-02f, -1.03508048e-01f, 2.73357660e-01f, 3.61659139e-01f, 4.38419193e-01f, 3.16494480e-02f, -2.65563023e-03f, 1.48757203e-02f,
  -3.54666188e-02f, -1.75091952e-01f, -2.55537122e-01f, -3.74938548e-02f, -8.43394399e-02f, 2.01538548e-01f, 1.65989809e-02f, -1.99447662e-01f, -1.89920422e-02f, 2.37967536e-01f,
  1.40470043e-01f, -1.89167678e-01f, -1.95259988e-01f, -7.76729211e-02f, 1.15997471e-01f, 1.00112565e-01f, 5.47273234e-02f, 6.86248690e-02f, 1.17885321e-01f, -1.53933451e-01f,
  5.90904988e-02f, -1.05266362e-01f, 1.37005419e-01f, -2.23029032e-02f, 5.65942489e-02f, 3.85130085e-02f, 6.67618886e-02f, -5.13321608e-02f, 1.89896151e-02f, 8.16482157e-02f,
  4.13152389e-02f, -1.74702872e-02f, 9.81677547e-02f, 9.55139324e-02f, 4.28656451e-02f, 5.53830229e-02f, -2.71790680e-02f, -1.02067545e-01f, -9.25492346e-02f, -1.65003967e-02f,
  7.57999346e-02f, -1.27655100e-02f, 5.08690327e-02f, 4.39775512e-02f, 9.71538424e-02f, -6.98109195e-02f, 1.07431196e-01f, -4.55430448e-02f, -3.22064087e-02f, -2.79487316e-02f,
  6.24844879e-02f, -4.89908308e-02f, 5.71243577e-02f, 2.90987324e-02f, -1.52922086e-02f, -6.41303603e-03f, 1.97696630e-02f, -3.21054123e-02f, -5.47523461e-02f, 1.41248927e-02f,
  -2.05100998e-02f, -5.81634603e-02f, -3.16432528e-02f, -7.84465522e-02f, -9.12546888e-02f, 8.55691638e-03f, -3.74150127e-02f, -1.87269393e-02f, -2.34359968e-02f, -5.76835088e-02f,
  -4.53063782e-04f, 2.29971781e-02f, 8.45937245e-03f, -2.26796269e-02f, -4.89433073e-02f, 4.39241994e-04f, 2.07103998e-03f, -1.95376929e-02f, 4.13584895e-03f, -3.54707055e-02f,
  5.22250086e-02f, -1.56801399e-02f, 6.91049621e-02f, -1.95286851e-02f, 1.20342486e-01f, 1.09356493e-02f, 7.98739493e-02f, 5.16989082e-02f, 1.20235095e-02f, -3.95264756e-03f,
  8.51128548e-02f, 1.74632054e-02f, 1.02407850e-01f, 7.48982951e-02f, 1.47929117e-01f, 5.19385412e-02f, 1.21245928e-01f, -4.93567996e-02f, 4.63037007e-03f, 8.31928328e-02f,
  9.64182708e-03f, 9.85936075e-02f, -2.52278429e-03f, 1.17819965e-01f, -1.08215734e-02f, 1.15538813e-01f, 1.38103172e-01f, 1.84805453e-01f, 1.32425249e-01f, 1.77095801e-01f,
  2.88010448e-01f, -4.66759115e-01f, -7.93249905e-02f, 1.44246995e-01f, -1.32794499e-01f, -1.79598376e-01f, -3.70099723e-01f, -7.83955529e-02f, 7.50486180e-02f, -6.74309805e-02f,
  -2.73107797e-01f, -3.55459563e-02f, 5.51778078e-02f, 2.06548106e-02f, -1.27527952e-01f, -3.50870192e-02f, -2.54060384e-02f, 1.72196597e-01f, 9.33578685e-02f, -8.20532218e-02f,
  -8.54454264e-02f, 8.44414830e-02f, 6.93927780e-02f, -2.86066160e-02f, 1.50453806e-01f, 1.94308609e-01f, -1.10851759e-02f, 9.31478143e-02f, 4.42012586e-02f, 2.63448775e-01f,
  2.92053223e-01f, -7.24051967e-02f, 6.43600896e-03f, -2.04388686e-02f, 4.61539850e-02f, 6.68992996e-02f, 4.89156693e-02f, -3.57929841e-02f, 1.02300486e-02f, 2.74492521e-02f,
  -1.64900981e-02f, -8.95731896e-02f, -4.97535765e-02f, -5.16088940e-02f, -4.90522897e-03f, 6.88429251e-02f, -9.15128589e-02f, 1.20609395e-01f, -1.85841620e-02f, -3.82035263e-02f,
  -6.47221953e-02f, 1.43266767e-02f, 6.34954348e-02f, -2.78999824e-02f, -5.41570457e-03f, 1.23656571e-01f, -1.42455045e-02f, 1.04083046e-01f, 1.23037547e-01f, 2.17402965e-01f,
  7.44845569e-02f, 3.36272479e-03f, -1.02318257e-01f, 3.78194675e-02f, 1.38552045e-03f, -5.60643114e-02f, -6.28881855e-03f, -5.55771813e-02f, -2.81911390e-03f, 1.11348496e-03f,
  -3.29977125e-02f, 1.35425702e-02f, -4.47479216e-03f, 6.92303702e-02f, 9.84510556e-02f, -3.87616232e-02f, 8.04516114e-03f, 2.16516666e-03f, 2.89880298e-02f, -7.22717270e-02f,
  1.82889551e-02f, 7.89043903e-02f, -4.37803827e-02f, 5.38395718e-02f, 3.91714787e-03f, 3.15542519e-02f, -2.05081198e-02f, 6.23924565e-03f, 1.07260440e-02f, -5.33710457e-02f,
  1.06732950e-01f, -1.64944783e-01f, 1.04890332e-01f, -3.94714139e-02f, 4.39651757e-02f, 1.61855761e-02f, -9.02804956e-02f, 1.45189289e-03f, -4.65966500e-02f, 2.61624809e-02f,
  -1.38402358e-01f, 1.24314530e-02f, -6.71468228e-02f, -6.68099970e-02f, 5.82123436e-02f, 6.31543482e-03f, -6.99460730e-02f, 4.73657064e-02f, -4.72532175e-02f, -4.70726900e-02f,
  -1.20975040e-01f, -6.45093024e-02f, 8.86174664e-02f, -9.51004177e-02f, -2.76918169e-02f, -1.19737936e-02f, 5.41380718e-02f, 1.66745931e-01f, 1.13111459e-01f, 1.92658484e-01f,
  1.44828841e-01f, 1.61970869e-01f, 5.91883138e-02f, -1.23525463e-01f, -7.85160065e-02f, -1.19912632e-01f, 1.10031843e-01f, 4.57200669e-02f, 1.04533672e-01f, 1.05755009e-01f,
  1.64917633e-02f, -2.70302713e-01f, -1.97688773e-01f, -1.12370066e-01f, -9.15402099e-02f, 9.70843509e-02f, -1.13977529e-01f, -1.52713686e-01f, -1.79267511e-01f, 1.62065588e-02f,
  -1.45757973e-01f, 8.84068608e-02f, 1.54771805e-01f, -1.46864327e-02f, -7.11948574e-02f, -1.89831138e-01f, 1.62804082e-01f, 1.10956468e-01f, -8.42123777e-02f, 2.22132038e-02f,
  1.04833748e-02f, 1.72968850e-01f, -9.20803770e-02f, 2.21624188e-02f, -6.59673885e-02f, 4.40979041e-02f, -4.52932827e-02f, -9.02766734e-03f, -1.75943915e-02f, 1.37853161e-01f,
  -6.70821816e-02f, -2.01265421e-03f, -5.70731470e-03f, -5.26101794e-03f, 4.82474007e-02f, -6.41258731e-02f, 6.27479032e-02f, 1.05612598e-01f, 3.47018838e-02f, 6.19678535e-02f,
  -1.65447131e-01f, 9.82365105e-03f, 1.35314360e-01f, 9.37228799e-02f, 5.21881394e-02f, -1.49666756e-01f, 4.74329256e-02f, -5.22243418e-02f, 5.86722158e-02f, 4.48013805e-02f,
  5.69526525e-03f, -2.18656939e-02f, -4.14670259e-02f, 5.06646633e-02f, 4.97476608e-02f, 9.64706670e-03f, -1.01974085e-01f, -4.33903560e-03f, 3.84997837e-02f, -4.20346633e-02f,
  1.13832243e-02f, 5.48968762e-02f, -2.45425254e-02f, 2.64976956e-02f, 1.20596895e-02f, -6.70080306e-03f, -2.88853385e-02f, -2.05173213e-02f, -2.73720399e-02f, 3.12600844e-02f,
  4.36844537e-03f, 4.51197773e-02f, -1.13067858e-01f, -1.20770149e-01f, -7.32344314e-02f, -7.49209598e-02f, -4.61516343e-02f, 7.71832559e-03f, -8.76623467e-02f, 4.62887343e-03f,
  -4.48331758e-02f, -2.60726195e-02f, 3.81787866e-02f, 2.49192100e-02f, -6.36525601e-02f, 1.26732802e-02f, -3.75138894e-02f, -2.59409174e-02f, -6.74465969e-02f, -2.62882449e-02f,
  5.63642234e-02f, 5.63543774e-02f, 3.22314538e-02f, -1.83782335e-02f, -2.49296464e-02f, -4.51089814e-02f, 3.66135798e-02f, -9.78777334e-02f, 6.11841418e-02f, 3.64653394e-02f,
  6.96436912e-02f, 5.46374656e-02f, -1.03631265e-01f, -4.38209251e-02f, -4.56124358e-02f, -9.17049199e-02f, 9.02302843e-03f, -6.43084869e-02f, -5.18603716e-03f, -7.15249544e-03f,
  -5.42014897e-01f, 1.05177864e-01f, 2.03353062e-01f, -1.38525069e-01f, 5.27310595e-02f, 1.36178643e-01f, 5.59061468e-02f, -9.48605090e-02f, -2.11726576e-02f, 6.80802390e-02f,
  1.16060302e-01f, 5.45126647e-02f, 1.53107913e-02f, 1.21387318e-01f, -1.26725361e-01f, 1.11758687e-01f, 1.83637694e-01f, -9.86889191e-03f, -1.18301593e-01f, -1.26881137e-01f,
  4.64996416e-03f, -4.74833436e-02f, -2.10923925e-01f, -6.14649989e-02f, 1.51551530e-01f, 4.89553437e-02f, 2.02280954e-01f, 9.96670946e-02f, 2.02593014e-01f, 3.32125872e-01f,
  1.56836540e-01f, 6.96704164e-03f, 7.95488283e-02f, -4.08754237e-02f, 7.78404400e-02f, -1.02654211e-01f, -8.07940140e-02f, 6.44432455e-02f, -7.82071277e-02f, -4.36741952e-03f,
  1.06229827e-01f, -6.49398640e-02f, 4.14277986e-02f, 1.07378595e-01f, 4.39091809e-02f, 1.00410506e-02f, 6.20380454e-02f, -9.82975960e-02f, 3.00617260e-03f, 3.99010926e-02f,
  5.84214069e-02f, 9.75843221e-02f, 1.90912168e-02f, 5.18811084e-02f, 4.70710769e-02f, -3.09056067e-03f, 6.57443404e-02f, 6.83312863e-02f, 3.03780548e-02f, -2.99420934e-02f,
  -2.77382601e-03f, -6.80627162e-03f, -4.00131987e-03f, -1.25197181e-02f, -5.27782366e-02f, -4.86140065e-02f, 1.54932756e-02f, 3.74469720e-02f, -7.18803890e-03f, -4.54067290e-02f,
  -1.38198771e-02f, -5.48497140e-02f, -4.07061569e-04f, -1.19747765e-01f, 3.15433205e-03f, -7.29361083e-03f, 6.55988790e-03f, -7.24504590e-02f, 3.87040116e-02f, -8.77355039e-02f,
  -2.43845265e-02f, -1.05401084e-01f, 3.54647897e-02f, -5.35175987e-02f, -5.40860854e-02f, 2.44739372e-02f, -2.38020960e-02f, 5.77308238e-02f, -1.16213493e-01f, 4.91343811e-02f,
  1.17094221e-03f, -8.74045026e-03f, 6.88971654e-02f, -2.24764161e-02f, -1.89911053e-02f, 3.98596898e-02f, 3.27308066e-02f, 1.01575777e-01f, 1.18066110e-01f, -4.27232264e-03f,
  1.01679834e-02f, -4.82618660e-02f, -1.98091213e-02f, 1.28000239e-02f, -5.65508753e-02f, 1.33481966e-02f, 5.22266999e-02f, 9.79581699e-02f, 5.29226810e-02f, 3.16561200e-02f,
  7.48470128e-02f, -5.17513342e-02f, -7.84359202e-02f, 3.20912413e-02f, -2.10078247e-02f, 2.59466004e-02f, 6.70203343e-02f, -5.38741723e-02f, -7.15495497e-02f, -1.81747854e-01f,
  4.32241149e-02f, -4.29930165e-02f, -2.20472999e-02f, 9.63743106e-02f, 2.64022592e-02f, -2.05518246e-01f, -1.47886902e-01f, -1.58372030e-01f, -1.79243863e-01f, -1.42813951e-01f,
  -1.24433264e-01f, -2.17519134e-01f, -8.65095705e-02f, -1.87329844e-01f, -1.43109947e-01f, -1.11796401e-01f, 1.07606798e-01f, 5.95643856e-02f, -6.32905737e-02f, -1.10830329e-01f,
  -1.18122250e-02f, -2.37691700e-02f, -4.41035740e-02f, -6.58372268e-02f, -8.82134289e-02f, -1.44888192e-01f, -1.67916596e-01f, -9.02576149e-02f, -1.63240299e-01f, 8.77664611e-02f,
  1.11390643e-01f, -1.84823453e-01f, -1.70072407e-01f, -1.33860230e-01f, -1.67256147e-01f, -1.39704704e-01f, -7.10481480e-02f, -8.98255706e-02f, -6.16023280e-02f, -1.13872088e-01f,
  -5.12122624e-02f, -1.81264296e-01f, -8.73859525e-02f, -7.74600506e-02f, -8.55832845e-02f, -1.76876202e-01f, -1.02297019e-03f, -1.85823254e-02f, -7.00472668e-02f, -7.34845176e-02f,
  2.07747769e-04f, -1.28865600e-01f, -4.98149469e-02f, -2.27855146e-01f, -1.56718552e-01f, -1.34484723e-01f, -2.01015860e-01f, -1.26401976e-01f, -2.42680594e-01f, -8.44958425e-02f,
  8.27905834e-02f, 7.66814128e-02f, 1.30569443e-01f, 9.77446511e-02f, 1.04862407e-01f, 5.69256954e-02f, 3.58683281e-02f, 6.79852292e-02f, 8.43067840e-02f, 4.95997369e-02f,
  5.00598326e-02f, 2.32264698e-02f, 4.44275402e-02f, 2.06187610e-02f, 6.07099570e-02f, -2.80459807e-03f, 1.96119491e-02f, 8.25462211e-03f, 1.83561184e-02f, 3.32510583e-02f,
  7.66538605e-02f, 5.50477616e-02f, 1.13498624e-02f, 1.12713359e-01f, -3.80460583e-02f, 1.01910271e-01f, 2.24043354e-02f, -5.09074097e-03f, -5.84861683e-03f, 9.74356160e-02f,
  -1.43873468e-01f, -1.76790848e-01f, -5.24263456e-02f, -4.87722233e-02f, -1.73808843e-01f, -1.49857968e-01f, -7.60927424e-02f, -1.30148903e-01f, -1.45141825e-01f, -6.36250675e-02f,
  -1.37353897e-01f, -1.78715736e-01f, -1.56098157e-01f, -7.81564415e-02f, -1.15209110e-01f, -6.13870211e-02f, -1.77959099e-01f, -1.01729751e-01f, -1.15212113e-01f, -4.38902900e-02f,
  -1.03215881e-01f, -1.99070558e-01f, -9.22523886e-02f, -1.43592507e-01f, -1.13351829e-01f, 2.78831087e-03f, -1.00471094e-01f, -6.95986524e-02f, -9.94791910e-02f, -2.18530819e-01f,
  9.79177728e-02f, -2.07721606e-01f, -1.48686573e-01f, 5.60326613e-02f, 2.31653992e-02f, 9.92858112e-02f, 5.87960295e-02f, 1.57314777e-01f, 1.20407633e-01f, -1.14407457e-01f,
  -7.74027184e-02f, 1.32402062e-01f, -4.81885783e-02f, -1.50004076e-02f, 5.78152351e-02f, -8.11441988e-02f, -1.40214235e-01f, 5.47451787e-02f, 2.12766901e-01f, 1.94295838e-01f,
  -1.38081815e-02f, 1.40878940e-02f, 1.25826253e-02f, 2.69264039e-02f, -6.01763697e-03f, 1.87916711e-01f, -9.65888947e-02f, 4.68342975e-02f, 2.92582531e-03f, -2.12171733e-01f,
  -2.11955801e-01f, -2.13307232e-01f, 1.40972689e-01f, -1.69990007e-02f, 4.97595742e-02f, 9.27106664e-03f, -8.48820433e-03f, 3.49215679e-02f, 1.99975702e-03f, -1.09825976e-01f,
  9.56406724e-03f, -8.72694775e-02f, -5.86999655e-02f, 6.06032759e-02f, 4.17711399e-02f, 1.00248232e-01f, 3.47181670e-02f, -5.80458231e-02f, -2.59927809e-02f, -1.85707528e-02f,
  -6.28900379e-02f, -1.61574259e-02f, 7.62651414e-02f, -3.60744493e-03f, 6.82599843e-02f, 1.07504182e-01f, 3.28156911e-02f, 4.86264564e-02f, 6.80776238e-02f, 5.46163805e-02f,
  1.05585188e-01f, -2.83598043e-02f, -4.61719595e-02f, 1.55781535e-02f, 2.48513737e-04f, -4.60279398e-02f, -3.53769287e-02f, 6.43251613e-02f, 2.85069030e-02f, 6.28322139e-02f,
  -4.22026627e-02f, 8.82930979e-02f, -3.87895554e-02f, 2.02442072e-02f, 6.78934082e-02f, -1.84899084e-02f, -2.17787903e-02f, 2.88721416e-02f, 5.47951460e-02f, -4.72492464e-02f,
  3.63612967e-03f, 3.24089751e-02f, 2.35879179e-02f, 7.23929936e-03f, 2.18503196e-02f, 7.53734112e-02f, 1.04489932e-02f, 1.37201948e-02f, -7.90324900e-03f, 1.16872944e-01f,
  1.36580512e-01f, 4.04445603e-02f, -4.40090038e-02f, 9.73646343e-02f, -1.62086803e-02f, 6.51333062e-03f, -1.10973325e-02f, 1.24711962e-02f, -6.06543981e-02f, -4.65773940e-02f,
  8.37196335e-02f, 2.40926426e-02f, -8.55039954e-02f, 6.56339945e-03f, 3.85428630e-02f, 3.56045105e-02f, 9.95410904e-02f, 7.84138516e-02f, 1.35550588e-01f, 8.29292834e-02f,
  3.51516977e-02f, 1.22967422e-01f, 2.09337696e-01f, 1.28722847e-01f, 9.16135907e-02f, 2.19044343e-01f, 1.02904864e-01f, 4.46151458e-02f, 1.60937488e-01f, 1.92356214e-01f,
  -4.68129031e-02f, 2.41266992e-02f, 1.38087243e-01f, 6.12070113e-02f, 2.60067195e-01f, 6.89883977e-02f, 1.76016137e-01f, -7.95539543e-02f, -3.41398194e-02f, 7.71478415e-02f,
  -1.42445639e-01f, -1.97326809e-01f, -2.59621382e-01f, -1.43424213e-01f, -2.64794230e-01f, 1.64150611e-01f, 2.28782803e-01f, -8.82564038e-02f, -1.91340536e-01f, -9.23133865e-02f,
  -5.30734546e-02f, -1.06640652e-01f, -1.88952878e-01f, -1.10480361e-01f, 6.11366183e-02f, -3.14725935e-02f, 1.62490189e-01f, 1.15238264e-01f, 1.04720376e-01f, 2.72290260e-01f,
  -4.26952019e-02f, 1.16392635e-01f, -2.50661671e-02f, -5.45776263e-02f, 1.19586527e-01f, -8.27919468e-02f, 3.76448184e-02f, -1.62745640e-02f, 5.83996475e-02f, -1.36446115e-02f,
  4.23464850e-02f, 3.34844962e-02f, 8.47785175e-02f, -3.39912437e-02f, -4.95083258e-03f, 4.51598167e-02f, -4.62647937e-02f, -2.89404765e-03f, 3.12431138e-02f, -6.73196372e-03f,
  6.63299412e-02f, 1.65417612e-01f, 1.49502352e-01f, 1.04001313e-02f, 6.31434023e-02f, -9.44763124e-02f, 8.07099324e-03f, 6.01476058e-03f, -2.27068067e-02f, 4.25401367e-02f,
  -7.29246661e-02f, 1.51720271e-01f, 5.23266122e-02f, 3.08925076e-03f, -1.05211381e-02f, 5.63430004e-02f, 2.44276486e-02f, 9.97881070e-02f, -1.03212101e-02f, 3.99563275e-03f,
  2.53500957e-02f, 1.33803859e-02f, 6.72090426e-02f, 5.59558719e-02f, -6.52457820e-04f, 4.34574224e-02f, -4.25114715e-03f, -2.87370030e-02f, -5.03491499e-02f, 4.95423302e-02f,
  1.64919291e-02f, 1.04478143e-01f, -2.11767573e-02f, 7.67939240e-02f, 1.42694414e-02f, -6.37222305e-02f, 6.77543581e-02f, -1.50175802e-02f, 4.81470954e-03f, -3.54531445e-02f,
  -2.11457804e-01f, -1.75118297e-02f, 4.79467288e-02f, 4.13851403e-02f, 1.14975654e-01f, 1.15327043e-02f, 5.36862686e-02f, 6.70588836e-02f, 5.78226522e-02f, 6.87339529e-02f,
  1.11216262e-01f, -2.65984517e-02f, 3.68202780e-03f, 3.53652537e-02f, -5.89636378e-02f, 7.99642727e-02f, -1.59605723e-02f, 8.04886408e-03f, 9.58951414e-02f, 4.24948372e-02f,
  2.70976573e-02f, 3.71044502e-02f, -4.24115844e-02f, 3.71814799e-03f, 8.17831755e-02f, -1.35799244e-01f, -2.46654544e-02f, -6.41467609e-03f, 6.55152183e-03f, -1.80780783e-01f,
  -2.69124836e-01f, 5.61102442e-02f, 3.15233737e-01f, 3.50916609e-02f, 1.46896735e-01f, 1.46678254e-01f, 9.35104042e-02f, -3.08998730e-02f, 9.16502718e-03f, -3.20434906e-02f,
  3.71296778e-02f, 1.62084758e-01f, 8.79071727e-02f, 2.34062180e-01f, 2.48436686e-02f, 9.07312185e-02f, 1.77549765e-01f, 2.34636337e-01f, 1.68299705e-01f, 2.04077631e-01f,
  1.55166462e-01f, -2.02374011e-02f, -1.26097754e-01f, -7.06383735e-02f, 1.27154097e-01f, 1.18438028e-01f, 9.07968581e-02f, -9.24647823e-02f, 1.32827505e-01f, 2.72939682e-01f,
  2.09351137e-01f, -9.72871035e-02f, 2.15387896e-01f, 4.05385345e-02f, 1.63871109e-01f, 5.83047867e-02f, 8.10163543e-02f, 7.67461536e-03f, -3.14926207e-02f, 8.41570646e-02f,
  1.54248878e-01f, 5.94690591e-02f, 7.37765208e-02f, 1.77688256e-01f, 5.24488874e-02f, 1.34307116e-01f, -2.72406288e-03f, 5.54597415e-02f, 1.46378785e-01f, 1.61093697e-01f,
  1.64101467e-01f, 1.13301955e-01f, 7.73465261e-02f, 1.51318610e-01f, 5.12937829e-02f, 2.35903203e-01f, 7.61221051e-02f, 1.75798163e-01f, 5.71959056e-02f, -3.50631736e-02f,
  -4.55585383e-02f, -1.19978346e-01f, -1.05677225e-01f, -9.96923372e-02f, -1.40059516e-01f, -8.08207467e-02f, -5.40919229e-02f, -9.37050283e-02f, -8.30005705e-02f, -1.90537378e-01f,
  -1.57438695e-01f, -1.04211614e-01f, -1.27667114e-01f, -1.34569347e-01f, -7.40031451e-02f, -7.48015195e-02f, -5.45977801e-02f, -1.05532251e-01f, -1.65852860e-01f, -1.60205767e-01f,
  -1.00660749e-01f, -1.45367339e-01f, -1.40028119e-01f, 3.26661766e-02f, -8.19961727e-02f, -7.88379088e-02f, -1.53678820e-01f, -8.88840631e-02f, -1.24177948e-01f, -1.22151718e-01f,
  5.09210303e-03f, 9.70026255e-02f, 1.02726273e-01f, 1.26684085e-01f, 1.26582161e-01f, 6.01933300e-02f, 1.72720492e-01f, 9.21628848e-02f, 1.34230375e-01f, 8.04948360e-02f,
  5.01449257e-02f, 4.51696776e-02f, 1.14157915e-01f, 9.26381350e-02f, 1.57832220e-01f, 4.99726608e-02f, 1.28630638e-01f, 1.68542221e-01f, 1.19245008e-01f, 2.34858543e-02f,
  1.69729352e-01f, 1.07108437e-01f, 1.72980309e-01f, 1.38716474e-01f, 1.45905763e-01f, 1.24457680e-01f, 2.00219855e-01f, 1.21682093e-01f, 1.91668525e-01f, 6.58289939e-02f,
  -3.84174377e-01f, 7.56420419e-02f, -2.59919316e-01f, -2.47834533e-01f, 9.35491621e-02f, 8.30251873e-02f, 1.76198244e-01f, 1.07188709e-01f, 3.44566517e-02f, 3.82905789e-02f,
  1.72697634e-01f, 4.66269106e-02f, -9.36224461e-02f, -1.12805866e-01f, -7.03544393e-02f, -6.99385107e-02f, -8.67866278e-02f, -3.24638575e-01f, -7.85540044e-02f, 1.16847061e-01f,
  7.89836198e-02f, -7.07535222e-02f, -8.97898898e-02f, 2.93738116e-03f, -3.50240245e-02f, 1.85836405e-02f, -8.13405141e-02f, -4.39957939e-02f, 1.09676383e-02f, -9.62512493e-02f,
  9.01279524e-02f, -1.82450950e-01f, -1.01308040e-01f, -8.78412873e-02f, 6.30775318e-02f, -1.18477121e-01f, -8.11289102e-02f, -6.70126528e-02f, -2.52400376e-02f, 4.14324589e-02f,
  2.10475530e-02f, -3.08015645e-02f, -1.53701529e-01f, 6.23502135e-02f, -7.12195933e-02f, 5.48641793e-02f, -8.21852759e-02f, -1.44563079e-01f, -1.69640586e-01f, 5.33301383e-02f,
  -5.49300276e-02f, -1.82672236e-02f, -1.21639073e-01f, 7.34110549e-02f, -6.58878312e-03f, -1.90289080e-01f, 1.41754909e-03f, 4.51286417e-03f, -5.85500039e-02f, -4.63733599e-02f,
  -7.97473639e-02f, 5.17890342e-02f, 5.42452335e-02f, 9.83297229e-02f, 5.74213006e-02f, 1.21056572e-01f, 2.85088085e-02f, 3.37060839e-02f, 8.35681632e-02f, 8.18441734e-02f,
  -2.33210027e-02f, 1.79075897e-02f, 8.81330222e-02f, 2.95587517e-02f, -2.41570380e-02f, 1.89441536e-02f, -1.57622993e-02f, -2.05488559e-02f, 3.28219309e-02f, 1.80706941e-02f,
  6.70662150e-02f, 2.27930564e-02f, 5.50751314e-02f, 6.52801543e-02f, 8.92724842e-02f, -6.27535209e-02f, -2.01800335e-02f, 2.11718436e-02f, 1.17286652e-01f, 7.95628037e-03f,
  1.56720996e-01f, -1.50634736e-01f, -5.35536483e-02f, -7.43362680e-02f, -6.32736832e-02f, -1.62101492e-01f, -1.79014690e-02f, -1.38024360e-01f, -9.15989280e-02f, -8.16802904e-02f,
  6.68687671e-02f, -1.00105360e-01f, -8.10182244e-02f, -2.64631622e-02f, -4.75215428e-02f, -3.57727669e-02f, 2.13367660e-02f, -6.59627244e-02f, -7.79041424e-02f, 4.07530405e-02f,
  -5.21478094e-02f, -4.26582247e-02f, 4.39976826e-02f, -3.88975739e-02f, -8.84845853e-02f, -5.90358414e-02f, 9.75553319e-02f, 4.54356801e-03f, -1.00994602e-01f, 1.12151138e-01f,
  1.11408774e-02f, -1.24460995e-01f, -1.41806349e-01f, 6.39534220e-02f, -1.60883784e-01f, -3.27486694e-01f, -2.18398720e-01f, -1.80028796e-01f, 1.09158292e-01f, -1.08180545e-01f,
  -1.36201128e-01f, 8.96394476e-02f, 1.29055485e-01f, 8.94789584e-03f, 1.65549770e-03f, -1.97626382e-01f, 5.29239029e-02f, 8.74516517e-02f, -1.44934043e-01f, -1.07183613e-01f,
  1.09871142e-01f, 9.44210216e-02f, 2.33496979e-01f, -1.05551649e-02f, 1.30971253e-01f, -6.88056797e-02f, 2.95759887e-02f, 3.43650468e-02f, -7.98527803e-03f, 1.42292947e-01f,
  -1.71121433e-01f, -1.15893796e-01f, -7.49684200e-02f, -7.98236504e-02f, 5.22527732e-02f, -8.44142064e-02f, -1.50487602e-01f, 6.50347844e-02f, -8.45081806e-02f, 1.09856566e-02f,
  5.56003787e-02f, -6.32983148e-02f, -2.72435602e-02f, 6.63009956e-02f, 2.02948507e-02f, -5.66154681e-02f, 9.29137692e-02f, 4.37877066e-02f, 7.96112567e-02f, -2.61077825e-02f,
  -2.54598297e-02f, 4.58094589e-02f, -1.11438937e-01f, -1.53210983e-01f, -4.31323200e-02f, 6.19760975e-02f, 1.28499186e-02f, 8.05675238e-02f, -7.82275125e-02f, -4.97402735e-02f,
  -1.04203587e-03f, 4.13825661e-02f, 1.72647201e-02f, 3.57822590e-02f, 3.33248712e-02f, -1.02590676e-02f, 7.05063939e-02f, 4.62650731e-02f, 9.65223741e-03f, -9.32414271e-03f,
  -2.99130380e-02f, 6.18858598e-02f, 1.33378031e-02f, -3.29698361e-02f, 3.81827950e-02f, 5.57251498e-02f, 4.94158268e-02f, -3.02667008e-03f, -2.91984119e-02f, 4.71860878e-02f,
  3.65359820e-02f, 5.88949248e-02f, -2.23344024e-02f, 6.08614013e-02f, -2.20199171e-02f, -3.91744822e-02f, 2.84726750e-02f, 7.14033917e-02f, 7.10093752e-02f, 4.66377363e-02f,
  7.19615724e-03f, -1.49361104e-01f, 2.94796266e-02f, -3.69494455e-03f, 6.59926385e-02f, 2.44220421e-02f, 7.40559325e-02f, 2.54410468e-02f, 9.61958021e-02f, -1.04528129e-01f,
  2.32877024e-02f, 1.31218731e-02f, -3.75410914e-02f, 5.66852726e-02f, -8.77072141e-02f, -1.97222121e-02f, -6.29434315e-03f, 1.22340083e-01f, -2.80441618e-05f, -8.81072953e-02f,
  5.59985153e-02f, -1.39805883e-01f, -1.44168183e-01f, -1.51062580e-02f, -2.89540011e-02f, -1.24323256e-01f, -9.10061598e-02f, -6.87259510e-02f, -3.61027159e-02f, -6.45152181e-02f,
  2.24359095e-01f, -2.57490486e-01f, -1.29421547e-01f, -1.00163557e-02f, 8.83520916e-02f, 1.52714431e-01f, -4.03049476e-02f, 6.78018807e-03f, 1.53376712e-02f, -2.43732594e-02f,
  -4.26221676e-02f, 1.18881226e-01f, 8.91948789e-02f, -3.12333684e-02f, 6.95186108e-02f, -1.78706437e-01f, -2.24086568e-01f, -8.41920972e-02f, 1.31184995e-01f, 1.48133546e-01f,
  3.24309506e-02f, -2.14875210e-03f, -5.69985174e-02f, -1.20685771e-01f, -9.40444693e-02f, 7.94014707e-02f, -8.56197178e-02f, -5.20758815e-02f, -6.26091436e-02f, -2.00472578e-01f,
  4.33069915e-02f, 2.33414158e-01f, 9.19272900e-02f, 9.87407118e-02f, 3.96437123e-02f, 1.57665201e-02f, 9.07316208e-02f, -1.14469416e-01f, 8.79557952e-02f, -9.30214673e-02f,
  -9.49075504e-04f, 2.38670912e-02f, -1.76002588e-02f, -2.77063195e-02f, -5.17061315e-02f, 7.87730962e-02f, -1.04508549e-01f, -9.42611098e-02f, 5.09099662e-02f, 1.07856594e-01f,
  -1.12910904e-01f, 3.02479323e-03f, 1.15347505e-01f, 1.55991644e-01f, 5.16980328e-02f, 5.32400943e-02f, 7.52544701e-02f, 1.32807223e-02f, 1.42224476e-01f, -2.05148775e-02f,
  -9.15670171e-02f, 5.44287078e-02f, -4.86328937e-02f, -6.55553490e-02f, 2.13023345e-03f, -6.29179999e-02f, -3.36416848e-02f, 4.06744611e-03f, -9.18574929e-02f, -9.88988876e-02f,
  -4.89630289e-02f, 7.66045377e-02f, -2.11057514e-02f, -1.25103472e-02f, -1.18299415e-02f, 6.52782768e-02f, 2.13070912e-03f, -1.07162870e-01f, 2.43594665e-02f, -5.15111834e-02f,
  3.23312916e-02f, 3.66367539e-03f, 5.22174276e-02f, -4.99067344e-02f, -3.71158756e-02f, -8.18710104e-02f, 5.49875982e-02f, 2.22652289e-03f, -5.08654900e-02f, 2.32164692e-02f,
  8.50141123e-02f, 1.29335508e-01f, 1.34657070e-01f, 1.57985277e-02f, 5.81838414e-02f, 7.01734424e-03f, 3.67044471e-02f, 8.03010017e-02f, 8.72135907e-02f, 8.17306563e-02f,
  4.63825949e-02f, -7.27567216e-03f, 4.96107899e-02f, 5.87848499e-02f, 4.12078612e-02f, 3.56744975e-02f, -2.53205653e-02f, 5.28513640e-02f, 1.04025684e-01f, 1.33661907e-02f,
  -9.78489071e-02f, 1.74759045e-01f, 1.97833210e-01f, 3.89199220e-02f, 1.11184649e-01f, 2.14076996e-01f, 7.72133097e-02f, 1.34249493e-01f, 2.48615012e-01f, -4.44168895e-02f,
  -7.87351578e-02f, -1.80791974e-01f, 2.22664257e-03f, -5.01262061e-02f, -1.93241671e-01f, -1.10450290e-01f, -3.46733451e-01f, -1.67701244e-01f, -1.48633599e-01f, -1.80679485e-01f,
  -1.03310071e-01f, 2.00451598e-01f, 1.63108975e-01f, 1.21553317e-01f, 2.23280951e-01f, -3.85861099e-02f, 1.16986491e-01f, 3.18799883e-01f, 2.62672663e-01f, -2.07152069e-02f,
  3.30994138e-03f, 2.33939663e-02f, 1.22000668e-02f, 8.69413987e-02f, -1.04970694e-01f, 1.56121731e-01f, -4.65542488e-02f, -5.79743460e-02f, 5.68235107e-02f, 3.28347862e-01f,
  2.07179207e-02f, 4.07171575e-03f, 4.16437201e-02f, 1.99011192e-02f, -5.48506714e-02f, 1.00315392e-01f, -9.77702215e-02f, -2.73412075e-02f, -1.27337901e-02f, 1.76225621e-02f,
  1.31340632e-02f, 2.10284581e-03f, 4.89936769e-02f, 1.87820867e-02f, -8.85322690e-02f, 2.47970801e-02f, 5.65645546e-02f, 2.11288840e-01f, 8.51662904e-02f, -6.44516721e-02f,
  -1.18997768e-02f, -1.13890536e-01f, -7.07486048e-02f, -2.34744214e-02f, 5.88107966e-02f, 7.05758929e-02f, -1.37641788e-01f, 9.76796821e-02f, 1.03810973e-01f, -8.44507851e-03f,
  2.68519204e-02f, -1.24775376e-02f, 1.76517088e-02f, 2.01951806e-02f, 6.47812500e-04f, -3.82127725e-02f, 4.36424017e-02f, -7.59983584e-02f, 7.59066939e-02f, 5.96984066e-02f,
  1.08470656e-01f, -7.75412023e-02f, 2.05020234e-02f, -6.16330467e-02f, 6.09985068e-02f, -4.96446900e-02f, -3.36018726e-02f, 6.33072481e-02f, -3.32511365e-02f, -5.61654679e-02f,
  2.49388888e-02f, 1.00482844e-01f, -1.17665837e-02f, 1.04797289e-01f, 4.20177951e-02f, 6.98508695e-02f, 3.75043303e-02f, -3.66339311e-02f, -4.36538421e-02f, -9.22680572e-02f,
  -2.84261078e-01f, 8.54308754e-02f, -9.97556094e-03f, 6.69653863e-02f, 1.03559345e-01f, -4.03820835e-02f, 3.01049035e-02f, 7.29517043e-02f, -5.47471382e-02f, 2.23571677e-02f,
  -7.19442144e-02f, 7.43366638e-03f, -6.80423975e-02f, 8.72011017e-03f, 4.37834784e-02f, -1.25061378e-01f, -5.59521988e-02f, 1.09853745e-02f, 3.71430703e-02f, 7.00520235e-04f,
  -1.62926316e-02f, -1.56967193e-01f, -3.64272892e-02f, -5.67778274e-02f, -5.62645076e-03f, -2.15480290e-02f, -1.39453679e-01f, -6.24604709e-02f, -8.35624784e-02f, -1.54856682e-01f,
  4.64527428e-01f, -1.17328465e-01f, 2.59317812e-02f, 4.25110310e-02f, -2.18004152e-01f, 7.95727316e-03f, -5.40802032e-02f, 5.36479475e-03f, 3.82830538e-02f, -4.69234772e-03f,
  -2.18311086e-01f, 2.67052054e-02f, -1.16622172e-01f, -9.58156437e-02f, 9.35595576e-03f, 5.89643978e-02f, -6.38982132e-02f, 1.85252294e-01f, 1.77039713e-01f, 3.24162729e-02f,
  -1.68954988e-03f, 5.57847740e-03f, 1.02141455e-01f, 1.55072078e-01f, 4.41891849e-02f, 1.38106737e-02f, 1.54789109e-02f, 6.05149381e-02f, -1.36129275e-01f, 1.33542687e-01f,
  1.74226418e-01f, -8.27953219e-02f, 6.57319427e-02f, 4.59652022e-02f, -4.97465059e-02f, -2.14460101e-02f, 8.43317136e-02f, 5.92225976e-03f, -7.51847550e-02f, -2.28113700e-02f,
  -1.10579573e-01f, -3.27017643e-02f, -8.55982900e-02f, -5.47778606e-02f, 5.72258048e-02f, -1.62132345e-02f, -1.12281246e-02f, 6.30484372e-02f, 6.65492713e-02f, -3.43493856e-02f,
  -1.35190725e-01f, -4.89817373e-02f, -1.78993605e-02f, -1.36424052e-02f, 7.79030621e-02f, -4.67140004e-02f, -8.71412084e-03f, 1.07060224e-01f, -2.72543561e-02f, 2.24764913e-01f,
  4.79816794e-02f, -7.36097619e-02f, -5.51790092e-03f, -2.77772285e-02f, 5.43482229e-02f, -7.02324230e-03f, -4.98544089e-02f, -1.19889723e-02f, -3.77564430e-02f, -1.23327328e-02f,
  -3.05641983e-02f, -5.95671833e-02f, -2.36494187e-02f, 2.79932339e-02f, 2.94057596e-02f, -8.01886544e-02f, -1.40540265e-02f, 3.52197886e-02f, -2.69229542e-02f, -7.10245222e-02f,
  -2.90273149e-02f, 3.64647508e-02f, -8.22536927e-03f, 4.48985323e-02f, -1.90589149e-02f, 3.08837760e-02f, 3.40965167e-02f, -1.00599095e-01f, -1.11167885e-01f, -9.55635905e-02f,
  8.28948393e-02f, -2.16251910e-01f, 1.68169767e-01f, 6.88953474e-02f, 2.58131959e-02f, 6.89759925e-02f, 4.98980060e-02f, 6.12484291e-02f, 2.18604542e-02f, 1.18496597e-01f,
  3.51507938e-03f, 1.30735263e-01f, 6.46945611e-02f, 3.82968970e-02f, 1.22626470e-02f, 1.03095599e-01f, -8.70458968e-03f, 1.08291164e-01f, 8.36380124e-02f, -2.15842272e-03f,
  2.27055401e-02f, 1.46425694e-01f, 1.24113977e-01f, 1.01129912e-01f, 9.95040908e-02f, 7.50993490e-02f, 1.25663325e-01f, 1.18570477e-01f, 1.23325549e-01f, 2.04987302e-01f,
  -1.70748517e-01f, 1.03347123e-01f, -6.85405955e-02f, 1.07875705e-01f, 1.77949015e-02f, -2.08876103e-01f, -1.41870201e-01f, -6.04341999e-02f, 3.68224755e-02f, 5.03543615e-02f,
  1.23697177e-01f, 1.01344950e-01f, 2.22785100e-02f, 1.25816502e-02f, -2.37583160e-01f, -3.75659913e-02f, -7.00827166e-02f, -2.12895975e-01f, -3.46971065e-01f, -1.72904059e-01f,
  -5.63875325e-02f, -8.89615268e-02f, -2.67826408e-01f, -8.83622319e-02f, 1.29448131e-01f, 6.81418329e-02f, 1.05300255e-01f, -5.97729571e-02f, -5.12009040e-02f, 1.71805099e-01f,
  1.03280917e-01f, -6.77313209e-02f, -1.01872887e-02f, 3.84501964e-02f, 1.39681831e-01f, 1.41930422e-02f, 2.49012373e-02f, -1.07081449e-02f, 6.46810979e-02f, 2.95979287e-02f,
  8.64417553e-02f, -1.50690153e-02f, 2.84498036e-02f, -1.11057470e-02f, -9.44322161e-03f, -6.29462451e-02f, -7.41509125e-02f, -7.42386803e-02f, 2.97583863e-02f, 4.76191752e-02f,
  8.34701806e-02f, 6.73313662e-02f, -1.30506292e-01f, -3.23188193e-02f, -3.93687468e-03f, 5.38838133e-02f, -2.20098570e-02f, -3.70220654e-02f, 4.23006825e-02f, 9.38371271e-02f,
  -8.78611133e-02f, -4.22797129e-02f, -4.03295457e-02f, 5.79118691e-02f, 3.87416445e-02f, 7.13710338e-02f, -3.35445888e-02f, -1.01928348e-02f, -5.27182892e-02f, -9.41506773e-03f,
  5.55972531e-02f, 8.50541145e-02f, -5.55597506e-02f, -7.28529096e-02f, -7.25300238e-03f, -1.00786136e-02f, -1.01378307e-01f, 6.01746403e-02f, 1.01284146e-01f, -5.06151766e-02f,
  6.89440221e-02f, 7.60120228e-02f, 4.44882810e-02f, -3.67844589e-02f, 1.54820643e-02f, -2.28899252e-02f, 3.04806866e-02f, -1.14871357e-02f, -2.77219247e-02f, -4.43461910e-02f,
  6.60291268e-03f, -1.16239049e-01f, -7.76664121e-03f, 8.55389331e-03f, -1.27029205e-02f, 3.03673036e-02f, 9.24816728e-02f, 2.60864180e-02f, 6.04219586e-02f, -3.20801586e-02f,
  5.83051667e-02f, -2.92459992e-03f, -4.78389636e-02f, 8.27575102e-02f, -3.98381427e-02f, 1.01179176e-03f, 5.11842407e-02f, -1.64708067e-02f, -5.18564209e-02f, 8.48499313e-02f,
  -3.10354158e-02f, 4.48213369e-02f, 1.49146216e-02f, -2.72447355e-02f, 3.31061333e-02f, -5.19462600e-02f, 3.35136317e-02f, 2.13689078e-03f, -1.77040145e-01f, -8.91119018e-02f,
  5.95829338e-02f, -2.06471473e-01f, 4.43238690e-02f, -1.27619863e-01f, 1.16852000e-02f, 8.14076886e-02f, 7.20499679e-02f, 1.16561711e-01f, -2.91969869e-02f, -4.36021090e-02f,
  2.52260230e-02f, 1.94513500e-02f, -6.41585216e-02f, 1.02986380e-01f, 1.49574518e-01f, -3.56504358e-02f, -2.41580755e-02f, 1.19405068e-01f, 1.86202869e-01f, 1.76639453e-01f,
  5.14495075e-02f, -2.03900024e-01f, -1.86579585e-01f, -1.06867597e-01f, -6.10796586e-02f, -2.06091646e-02f, -2.24201933e-01f, -1.51324794e-01f, -4.24267072e-03f, -2.13469401e-01f,
  4.79430668e-02f, -5.82681373e-02f, 1.38374195e-01f, 1.87432282e-02f, -2.12091096e-02f, 5.05348742e-02f, 1.19769536e-01f, -1.71038061e-02f, 4.95422930e-02f, -4.33725007e-02f,
  -1.04131170e-01f, 9.60616802e-04f, 1.97806265e-02f, 1.37403409e-03f, 1.46262636e-02f, 7.51712471e-02f, -1.31870747e-01f, -6.41187876e-02f, -3.14506404e-02f, 2.44017094e-02f,
  6.81557730e-02f, -9.99991782e-03f, 5.50109474e-03f, 1.94026716e-02f, 6.81039616e-02f, 9.34838057e-02f, -1.14905592e-02f, -4.35853899e-02f, 4.17565778e-02f, -1.66800451e-02f,
  5.83116636e-02f, -7.43429288e-02f, -5.89387007e-02f, 6.73237629e-03f, 3.72095741e-02f, -7.91445300e-02f, -4.03941423e-02f, -1.57458764e-02f, -1.00279776e-02f, -8.03460926e-02f,
  2.39834413e-02f, -3.65122454e-03f, 7.54743814e-02f, -4.94197235e-02f, -3.00793238e-02f, -3.86852473e-02f, -5.41384965e-02f, -3.44801918e-02f, -6.84902817e-02f, -2.75613964e-02f,
  -5.32289147e-02f, 4.43932340e-02f, -5.32914046e-03f, 6.09773248e-02f, 5.96892908e-02f, 4.56262976e-02f, -4.40536067e-02f, -6.24963976e-02f, 5.17730229e-02f, -1.13550790e-01f,
  -2.17929855e-02f, 2.27653384e-01f, 9.90511179e-02f, 4.29823622e-02f, -4.23761867e-02f, 2.14507505e-02f, 4.03031707e-03f, 3.53940092e-02f, 6.12009764e-02f, 1.31486179e-02f,
  1.34482279e-01f, 1.00777395e-01f, -6.00395426e-02f, -7.53795728e-02f, 1.29863564e-02f, 8.01444694e-04f, -8.11888725e-02f, 6.29542693e-02f, 3.77319311e-03f, -8.40414762e-02f,
  3.08988411e-02f, 9.31044444e-02f, 2.59301569e-02f, 9.07895155e-03f, 7.68871829e-02f, 1.69192314e-01f, -7.49952998e-03f, 4.34382148e-02f, 1.73773035e-01f, 6.06641881e-02f,
  -2.32344985e-01f, -5.04229702e-02f, 1.99671909e-01f, -1.15028307e-01f, 7.94447660e-02f, 6.26336643e-03f, -1.98083505e-01f, -1.91100046e-01f, -7.66046494e-02f, -7.62573257e-02f,
  8.47483799e-03f, 1.78438514e-01f, 2.28557810e-01f, 9.08872560e-02f, 2.39734519e-02f, 1.03231966e-01f, -1.26658322e-03f, 1.60006419e-01f, 2.95426011e-01f, 1.60657987e-01f,
  1.64413869e-01f, 3.89235131e-02f, -1.04663581e-01f, -1.49853732e-02f, -1.12054810e-01f, 1.89409733e-01f, 9.66654159e-03f, -4.95932670e-03f, -1.30400704e-02f, 1.50814205e-01f,
  1.82831869e-01f, -2.93898970e-01f, -5.72279952e-02f, -7.61246532e-02f, -3.97054106e-03f, -2.01495543e-01f, -2.65046488e-02f, -1.70051634e-01f, -1.76006630e-01f, -1.33502617e-01f,
  -2.55354587e-02f, -1.29369989e-01f, 1.07413940e-02f, 1.54451700e-02f, -2.06674691e-02f, -5.04385009e-02f, -2.06790343e-01f, -9.76145118e-02f, -7.95707628e-02f, -8.36537853e-02f,
  -5.52532263e-03f, -7.67666176e-02f, -9.61002037e-02f, -1.55511856e-01f, -8.42242166e-02f, -6.39609247e-02f, -1.97475642e-01f, -1.50426775e-01f, -4.31517325e-02f, -9.98434201e-02f,
  -4.74598147e-02f, 1.00607775e-01f, 1.00164205e-01f, -7.72511736e-02f, 4.96994220e-02f, -1.14601478e-02f, 1.10931925e-01f, 4.03485401e-03f, 1.13417253e-01f, -1.37234256e-02f,
  1.03906840e-01f, 1.05980419e-01f, 6.25378788e-02f, 4.87466268e-02f, 4.39448319e-02f, 9.04013366e-02f, 2.18413118e-02f, -1.04012182e-02f, -4.66853409e-04f, 1.58524103e-02f,
  1.02007296e-02f, 5.96026927e-02f, 8.25099573e-02f, 9.67504606e-02f, 8.13890435e-03f, -7.65873259e-03f, 1.25423625e-01f, 3.44296098e-02f, 3.02356649e-02f, 1.10670261e-01f,
  1.77101552e-01f, -1.18860714e-01f, -8.84276349e-03f, -9.35155600e-02f, -1.98144633e-02f, -1.13509446e-01f, -2.65045222e-02f, -8.04199576e-02f, -3.11776102e-02f, -2.51501985e-02f,
  9.27610695e-03f, 1.69736594e-02f, 7.53682330e-02f, -4.81203245e-03f, -2.28998605e-02f, 6.72536669e-03f, -3.18382904e-02f, 3.07320040e-02f, -9.38314125e-02f, -5.60417250e-02f,
  -8.36275145e-02f, 8.56202934e-03f, -1.95184387e-02f, -4.04316708e-02f, -9.01433080e-02f, 1.16805211e-01f, 1.02603458e-01f, -7.43230283e-02f, 4.35125679e-02f, -1.66792329e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.12021044e-01f, -3.83238167e-01f, -9.15231705e-02f, 2.71377116e-01f, 6.85188472e-02f, -2.44205907e-01f, -4.12635326e-01f, -2.60889888e-01f, 1.26247749e-01f, -1.40407398e-01f,
  1.09551668e-01f, 1.39252067e-01f, 3.57632786e-02f, -4.31205705e-02f, -4.84603584e-01f, -3.54267716e-01f, -2.41813481e-01f, -2.70996273e-01f, -1.98186904e-01f, -1.59957319e-01f,
  -1.87626202e-02f, 9.81565043e-02f, 1.74207892e-02f, 4.69454341e-02f, 3.46378088e-01f, 3.08450252e-01f, 2.45421171e-01f, 1.58633977e-01f, 1.39304072e-01f, 1.96147993e-01f,
  6.80788606e-02f, -1.94590427e-02f, 1.56131327e-01f, 1.35104850e-01f, 2.15101335e-02f, -1.05311044e-01f, -9.81369540e-02f, 2.31520310e-02f, 7.30878487e-03f, -3.35855931e-02f,
  1.96015358e-01f, 8.40725824e-02f, -1.01937931e-02f, -1.84980780e-02f, -5.90029918e-02f, 5.93383051e-03f, -9.72834826e-02f, -1.84466764e-01f, -2.13838637e-01f, -1.88746020e-01f,
  -8.99297222e-02f, -5.05790813e-03f, -4.81675342e-02f, -4.34298702e-02f, 3.24686291e-03f, 1.78092584e-01f, 1.71692356e-01f, 1.41360581e-01f, 5.97017929e-02f, 1.85600985e-02f,
  6.02377253e-03f, 3.07168718e-02f, -1.74697675e-03f, 2.11706944e-02f, -1.02123983e-01f, 9.37985554e-02f, -2.19974238e-02f, 9.35255364e-02f, 6.39688522e-02f, 2.40564086e-02f,
  -7.12527484e-02f, -4.03445475e-02f, 1.09247686e-02f, 4.99397591e-02f, -4.50946484e-03f, 4.79249255e-04f, 8.14929754e-02f, -3.55727575e-03f, -1.45959467e-01f, 2.36290763e-03f,
  -5.76077886e-02f, 1.35271341e-01f, 5.02344556e-02f, -1.06547862e-01f, -1.16987927e-02f, 3.16121951e-02f, 1.43525805e-02f, 5.32295635e-05f, -2.41779741e-02f, 9.18132886e-02f,
  1.09926939e-01f, -1.04546407e-02f, -4.74422313e-02f, -6.58899993e-02f, 6.22637644e-02f, 1.38112724e-01f, 5.58019914e-02f, -8.60414058e-02f, 1.76925540e-01f, -1.19382553e-01f,
  9.97621194e-03f, -2.27734707e-02f, -2.86436011e-03f, 5.32217994e-02f, -1.09696403e-01f, 8.85020941e-02f, -2.49271557e-01f, -3.39221470e-02f, -4.33855094e-02f, -4.13258784e-02f,
  -1.35634169e-01f, -2.01322049e-01f, -1.42358169e-01f, -1.31600633e-01f, -7.55829439e-02f, -1.17312863e-01f, -1.17361009e-01f, 4.65737693e-02f, -1.50842205e-01f, -2.37226903e-01f,
  -3.34990233e-01f, -9.23946872e-02f, -1.19948983e-01f, 8.54128674e-02f, 3.68881643e-01f, 2.91174829e-01f, 3.01541507e-01f, 5.65828159e-02f, 1.67432830e-01f, 1.14627063e-01f,
  -3.82901132e-02f, 2.37366613e-02f, 8.70889574e-02f, 1.45776987e-01f, -5.10577820e-02f, 1.14792883e-01f, 8.71365070e-02f, 2.07645055e-02f, 1.27995461e-01f, 1.94286779e-01f,
  1.33043125e-01f, -1.60749685e-02f, -2.21312761e-01f, -3.07808211e-03f, -2.31165104e-02f, 1.85867101e-01f, -7.90525377e-02f, 7.19575062e-02f, 1.95543647e-01f, 9.93236676e-02f,
  -1.80765763e-01f, -3.36114347e-01f, -3.17469202e-02f, -4.35937531e-02f, -1.44509926e-01f, -1.78062752e-01f, -4.49594781e-02f, -1.30247250e-01f, -1.47998080e-01f, -1.95299685e-01f,
  -1.25298858e-01f, -1.74318552e-01f, -1.03998147e-01f, 5.45777008e-02f, -5.32219037e-02f, -5.70843443e-02f, -5.42324334e-02f, -2.61477798e-01f, -2.48866916e-01f, -2.14312717e-01f,
  1.36326984e-01f, 6.74467608e-02f, -1.19809173e-01f, 5.06483503e-02f, -2.41454199e-01f, -2.28918955e-01f, -1.56126246e-01f, -1.93413332e-01f, -3.40426475e-01f, -3.01577985e-01f,
  -8.98734331e-02f, 4.16064486e-02f, 2.04083584e-02f, -1.23611182e-01f, 8.25247318e-02f, -3.57948826e-04f, -1.60639416e-02f, 3.28691378e-02f, 4.11627479e-02f, -1.03414632e-01f,
  7.40872920e-02f, 4.45351675e-02f, -1.49707659e-03f, -1.25340521e-02f, 1.24862753e-01f, -6.78366199e-02f, 1.08533710e-01f, -1.04797088e-01f, -2.34022271e-02f, 3.27043720e-02f,
  7.75152519e-02f, 1.92517098e-02f, -1.59981996e-02f, 4.07579429e-02f, 1.57282636e-01f, 1.15104564e-01f, 1.75244734e-02f, 3.72960828e-02f, 3.25407870e-02f, -4.70269211e-02f,
  -4.05158065e-02f, -7.78280348e-02f, -7.48697519e-02f, -9.00250301e-02f, -1.08460329e-01f, -1.98005456e-02f, -9.51183885e-02f, 3.15063074e-02f, -1.27799541e-01f, -5.37388884e-02f,
  -7.59844184e-02f, -8.07681531e-02f, -1.68213800e-01f, -3.21614034e-02f, 2.18968838e-02f, -3.60722444e-03f, 3.66235431e-03f, 1.73541948e-01f, -1.46449292e-02f, -2.44985521e-02f,
  -2.92076916e-03f, 9.74156708e-02f, 6.43087272e-03f, -7.56088644e-02f, -8.42336789e-02f, -7.54970461e-02f, -1.57733575e-01f, 1.02681387e-03f, -1.47549883e-01f, -3.01028285e-02f,
  -1.74953878e-01f, -3.43936861e-01f, -2.33846694e-01f, -4.26426142e-01f, -2.48896465e-01f, -1.91236332e-01f, -2.92300403e-01f, -2.25331873e-01f, -2.75551975e-01f, -3.01462293e-01f,
  -3.42817605e-02f, 3.13905120e-01f, 5.20343520e-02f, 9.34676006e-02f, 1.72171295e-01f, -3.61255616e-01f, -2.44687960e-01f, 1.78866565e-01f, 3.65553916e-01f, 1.05648674e-02f,
  -1.32755160e-01f, 1.19115889e-01f, 2.99508244e-01f, 2.50345916e-02f, -2.62905508e-01f, 9.97962207e-02f, -1.54385090e-01f, -4.87869494e-02f, -8.11230987e-02f, -1.99581340e-01f,
  8.70707110e-02f, -1.10487141e-01f, 8.51559341e-02f, 7.63305873e-02f, 4.85346243e-02f, -8.97138938e-02f, -7.88329542e-02f, 4.46778424e-02f, 7.90781900e-02f, 3.79423704e-03f,
  7.24301562e-02f, -2.78449412e-02f, 9.76742804e-02f, -1.50415421e-01f, -6.29873425e-02f, 7.28787249e-03f, -7.24683376e-03f, 5.97977564e-02f, 4.09546383e-02f, -5.56424782e-02f,
  -1.02184728e-01f, -6.01393394e-02f, 4.52477410e-02f, 4.94183898e-02f, 6.35219365e-02f, 1.04872897e-01f, -2.15678178e-02f, 8.42963606e-02f, 1.36266902e-01f, -2.21370563e-01f,
  -1.18461408e-01f, 5.80904186e-02f, -5.59814945e-02f, -4.64183502e-02f, 8.92918259e-02f, 4.78872769e-02f, -7.33700721e-03f, -9.94391646e-03f, 1.33060301e-02f, 5.31877950e-02f,
  -2.68927272e-02f, 6.76466990e-03f, 1.95154771e-02f, -1.47916365e-03f, -9.94940568e-03f, 3.57419178e-02f, 2.52411086e-02f, 6.66200146e-02f, 2.00139266e-02f, 7.84502644e-03f,
  6.30776286e-02f, 9.50935557e-02f, -2.76187379e-02f, 1.22996464e-01f, -7.36691058e-02f, -1.26119822e-01f, -8.75157341e-02f, 3.81617136e-02f, -5.97875044e-02f, -2.14343648e-02f,
  3.28529105e-02f, 9.08572227e-02f, -1.38958111e-01f, 1.92275383e-02f, -5.36350869e-02f, -1.62132606e-02f, -1.72707606e-02f, 6.52438775e-02f, 8.89693722e-02f, -7.61129186e-02f,
  6.56081215e-02f, 7.01755956e-02f, -7.50909075e-02f, -1.04510576e-01f, 5.44811226e-02f, 6.93341251e-03f, -1.85962126e-01f, 2.94936523e-02f, 5.36693186e-02f, -4.45403866e-02f,
  -5.67836501e-02f, -3.56087424e-02f, -2.16442514e-02f, 4.89381105e-02f, -4.63453904e-02f, 1.16734922e-01f, 1.57338977e-01f, -4.97649871e-02f, 9.55196992e-02f, -1.60086766e-01f,
  3.00648779e-01f, -1.31111443e-01f, -3.95358682e-01f, -1.05153814e-01f, -2.18691915e-01f, -7.25658983e-02f, -1.94561958e-01f, -5.99525087e-02f, -5.77154532e-02f, -2.99962044e-01f,
  -6.65614232e-02f, 8.82545486e-02f, 7.61348233e-02f, 2.70276666e-02f, -4.14482765e-02f, -2.84056276e-01f, -3.20932180e-01f, 1.03379476e-04f, 1.89463794e-01f, 1.09026194e-01f,
  -8.72292891e-02f, -5.70952408e-02f, 2.72341594e-02f, 3.03472169e-02f, -2.47393534e-01f, -1.02206685e-01f, -3.07498157e-01f, -1.32744342e-01f, -2.30728373e-01f, -3.30139130e-01f,
  -5.20156659e-02f, -1.31278649e-01f, 4.44249026e-02f, -9.76377632e-03f, -1.77483205e-02f, 5.01313359e-02f, 6.87610433e-02f, -6.92274645e-02f, -1.65411662e-02f, 1.17321005e-02f,
  -1.38932245e-03f, 1.08243115e-01f, 1.75070569e-01f, 8.19739625e-02f, 6.38839677e-02f, 8.16553906e-02f, -1.89848822e-02f, -4.34462205e-02f, -1.35163339e-02f, -9.11431685e-02f,
  -7.85419159e-03f, 5.75389788e-02f, 7.51559809e-02f, 5.79357557e-02f, -1.40843159e-02f, 5.50352447e-02f, -1.17500328e-01f, -5.73927872e-02f, -3.90186161e-02f, -7.88091719e-02f,
  6.85479771e-03f, 7.07744658e-02f, 5.92934936e-02f, 1.03430778e-01f, 1.31292865e-01f, 7.63182640e-02f, 1.38151750e-01f, 2.58141365e-02f, 1.31714329e-01f, 1.49318054e-01f,
  -5.07581756e-02f, -1.46731555e-01f, -1.21633440e-01f, -7.24498704e-02f, -1.00253783e-01f, -1.09941207e-01f, -6.87806755e-02f, 3.23174484e-02f, -1.44532165e-02f, 6.49391906e-03f,
  4.07521911e-02f, -2.83761844e-02f, -8.37816596e-02f, -7.15406239e-02f, -1.66046202e-01f, -4.74432111e-02f, -4.08240333e-02f, 1.29400007e-02f, 1.05695715e-02f, -1.51540324e-01f,
  1.51346996e-01f, -1.39375314e-01f, 1.23788640e-02f, 1.61559563e-02f, -7.15217143e-02f, -9.52368751e-02f, -7.93358833e-02f, 1.95686463e-02f, -6.21875981e-03f, -1.15915081e-02f,
  -5.28806821e-02f, 7.56650046e-02f, 5.44478446e-02f, 5.97186834e-02f, 9.38821808e-02f, -4.47014906e-02f, 1.83354560e-02f, 8.28710794e-02f, -2.87173502e-02f, 4.82834689e-03f,
  -9.27748997e-03f, 1.75829113e-01f, 2.58507848e-01f, 1.30100906e-01f, 1.12587258e-01f, 2.30242237e-01f, 7.28926659e-02f, 5.35686985e-02f, 2.03675792e-01f, 7.85691142e-02f,
  -2.43345812e-01f, 1.87905524e-02f, -2.69993693e-01f, 5.78490347e-02f, 1.51734576e-01f, 8.75370204e-02f, 1.13796871e-02f, 2.31615212e-02f, 4.29245383e-02f, 6.50386661e-02f,
  3.77897061e-02f, 3.28521281e-02f, -2.38060523e-02f, -3.70668434e-02f, -8.79025385e-02f, 4.06653062e-02f, 2.30984405e-01f, -6.80347160e-02f, -1.17901668e-01f, 1.18026108e-01f,
  2.91345745e-01f, -7.42712691e-02f, -1.70226589e-01f, -1.95995029e-02f, 1.89097464e-01f, 1.29651770e-01f, -4.30790223e-02f, 3.61561775e-02f, 1.20394073e-01f, 2.69857526e-01f,
  -2.74443895e-01f, -2.09887639e-01f, -1.48297504e-01f, 1.59682795e-01f, -6.96039796e-02f, -9.52577516e-02f, -6.69789985e-02f, -1.99483201e-01f, -4.24948968e-02f, -1.07574500e-01f,
  4.12698723e-02f, -1.15860827e-01f, 1.71368152e-01f, -3.69673185e-02f, -4.81021404e-02f, 1.69660188e-02f, -9.85270366e-02f, -1.63564101e-01f, -2.80448496e-01f, -1.50401488e-01f,
  3.65543038e-01f, 1.91086665e-01f, -1.42314568e-01f, -2.96965819e-02f, -1.13911912e-01f, -1.23415515e-01f, -9.03992504e-02f, -6.82420731e-02f, -3.61128688e-01f, -1.64787322e-01f,
  -1.79898087e-02f, -5.54769002e-02f, -6.47014976e-02f, 7.01140612e-03f, 2.91470531e-02f, 1.17567340e-02f, 6.97499737e-02f, 1.23319790e-01f, 3.31247263e-02f, -1.40162222e-02f,
  -8.44840705e-02f, 2.58543696e-02f, -6.48208857e-02f, -1.19097337e-01f, -2.47033816e-02f, 2.17570849e-02f, 4.13038433e-02f, -1.02837197e-01f, -3.43715772e-02f, -1.33479252e-01f,
  -1.68884806e-02f, 1.64366327e-03f, -1.00762285e-01f, 2.66988706e-02f, 6.36197403e-02f, -1.41723290e-01f, -8.46773200e-03f, -5.71210906e-02f, -1.14656046e-01f, -1.73148010e-02f,
  -3.58063757e-01f, -2.58500334e-02f, 3.75002436e-03f, 4.03933637e-02f, 3.87818962e-02f, -3.90909165e-02f, 1.28848702e-02f, -4.70924936e-02f, -1.62278675e-02f, 6.09956160e-02f,
  -8.69650766e-02f, 5.87384775e-03f, 3.16443481e-03f, 2.46332921e-02f, -3.77615020e-02f, 8.34775567e-02f, -1.96109470e-02f, 1.65585920e-01f, -1.33990292e-02f, 7.31980195e-03f,
  -1.07522057e-02f, -4.08811495e-02f, -9.71385464e-02f, -9.39163566e-02f, 8.23696181e-02f, -5.04872622e-03f, -2.09842026e-01f, -1.94681019e-01f, -2.77479142e-01f, -3.08359802e-01f,
  -3.78685415e-01f, 2.91572530e-02f, -1.49324626e-01f, -2.63218343e-01f, 9.58851576e-02f, 1.16701469e-01f, 3.08181085e-02f, 4.95588779e-02f, 9.30791348e-02f, -5.96768185e-02f,
  1.78913876e-01f, 1.43219188e-01f, 2.82165385e-03f, -8.98700655e-02f, -1.79483667e-01f, -1.69905245e-01f, -2.62840867e-01f, -1.72603950e-01f, 1.53147995e-01f, 2.98282683e-01f,
  1.01218522e-01f, 8.17248449e-02f, -8.50065276e-02f, 5.29667884e-02f, -1.34026080e-01f, -2.10582856e-02f, -1.66571483e-01f, -2.23846361e-01f, -1.07398182e-01f, -2.99162716e-01f,
  -2.49215111e-01f, 1.50066435e-01f, 4.36741523e-02f, 5.19534647e-02f, -4.75136489e-02f, -3.54132056e-02f, 1.37798682e-01f, 1.48358243e-02f, 1.41951248e-01f, -9.15553197e-02f,
  7.60755986e-02f, 1.50245175e-01f, -7.74739608e-02f, 1.85600728e-01f, 9.43574235e-02f, 2.50136796e-02f, -3.19846682e-02f, -8.04093704e-02f, -1.43557668e-01f, 8.82085040e-02f,
  7.06177726e-02f, 1.11463510e-01f, -6.53278381e-02f, -5.36090136e-02f, -2.11656224e-02f, 2.80718263e-02f, 3.16256136e-02f, -1.22804254e-01f, -1.74577981e-01f, -4.42921549e-01f,
  7.56596997e-02f, -5.00035658e-02f, 1.92813184e-02f, -1.27006814e-01f, -3.69671211e-02f, 3.36281992e-02f, -2.01718807e-02f, -9.18188840e-02f, -8.14086961e-05f, -1.05837613e-01f,
  2.16024909e-02f, 2.57286672e-02f, 3.06373835e-02f, 6.04466759e-02f, -7.95433521e-02f, -4.32461649e-02f, -4.65017650e-03f, -1.35364473e-01f, -1.97311137e-02f, 4.21786122e-02f,
  9.23160985e-02f, 2.36374196e-02f, -3.31546813e-02f, 5.74510992e-02f, 1.94945838e-02f, -1.45145223e-01f, 2.90989019e-02f, 1.16676673e-01f, -7.21996650e-02f, 6.14999197e-02f,
  -2.21024036e-01f, 1.61852360e-01f, -1.25964463e-01f, -3.58612947e-02f, -1.37784898e-01f, -7.29717091e-02f, -1.88419953e-01f, -1.06429927e-01f, 9.49995071e-02f, 4.80128191e-02f,
  1.81164220e-01f, 5.35728522e-02f, -1.07188731e-01f, -3.32790473e-03f, -2.48416290e-02f, 1.53179914e-02f, -1.63156033e-01f, -1.21230721e-01f, -2.08318308e-02f, -8.20903853e-02f,
  -3.83363366e-01f, -1.39518321e-01f, -2.63302594e-01f, -2.76404321e-01f, -5.92489466e-02f, -7.34159797e-02f, -2.35587984e-01f, -9.06190425e-02f, -2.25791395e-01f, -3.21734726e-01f,
  -2.33121544e-01f, 2.53201034e-02f, -7.39801973e-02f, 1.65546238e-01f, 1.86187983e-01f, 1.89615875e-01f, 7.42720515e-02f, 2.76532341e-02f, 1.67284459e-01f, 6.60823211e-02f,
  1.18844494e-01f, 2.55422801e-01f, 1.95118487e-01f, 2.61770248e-01f, 1.72089428e-01f, 1.33905485e-01f, 1.99979722e-01f, 1.41568407e-01f, -1.21147307e-02f, -4.14830968e-02f,
  2.03202724e-01f, -1.42879754e-01f, -9.70958248e-02f, 1.93127710e-02f, 7.62926340e-02f, 1.43047661e-01f, 1.12789109e-01f, -5.26991598e-02f, 9.74872857e-02f, 1.21187344e-01f,
  1.17909104e-01f, -4.09903973e-02f, 1.12038285e-01f, 1.97390001e-02f, -6.87875375e-02f, -2.21208677e-01f, -6.43557534e-02f, -1.73005223e-01f, -9.02075991e-02f, 4.72256076e-03f,
  -8.64689499e-02f, -8.68173018e-02f, -3.31480652e-02f, -1.22473136e-01f, -1.59022644e-01f, -1.82561085e-01f, -1.35850817e-01f, -2.54894327e-02f, 1.24890216e-01f, 5.38027436e-02f,
  1.54846683e-01f, 1.80591960e-02f, 5.76387569e-02f, 2.93319561e-02f, 1.05866045e-01f, -2.13060584e-02f, 4.80931625e-02f, 6.94948733e-02f, 1.15243774e-02f, 5.52106947e-02f,
  6.63661137e-02f, 4.75354269e-02f, 8.73197392e-02f, 3.74939144e-02f, 6.00874946e-02f, 3.15124653e-02f, 5.98180480e-02f, 5.51567264e-02f, 7.31174424e-02f, -1.59841165e-01f,
  2.25576442e-02f, 1.23050533e-01f, 1.80249780e-01f, 5.18964678e-02f, 9.59095731e-02f, 8.93764719e-02f, -3.47954258e-02f, 7.69213885e-02f, -3.72058973e-02f, -3.85267250e-02f,
  -7.06699416e-02f, -5.48701957e-02f, -1.49489731e-01f, -1.27464473e-01f, -1.49721190e-01f, 1.14229366e-01f, 2.08219513e-02f, -7.64556006e-02f, -7.70004913e-02f, -7.36659393e-02f,
  9.09071490e-02f, 1.33908451e-01f, 1.71760753e-01f, 8.42163935e-02f, 1.83608457e-02f, -1.21474110e-01f, 2.99487300e-02f, -6.48937896e-02f, -3.50526050e-02f, 1.68715447e-01f,
  -8.39265659e-02f, 2.35416777e-02f, -1.17035322e-01f, -1.49108976e-01f, -1.62146594e-02f, -8.38933960e-02f, 3.50691304e-02f, 1.58665746e-01f, 2.95580551e-02f, 1.50161190e-02f,
  -4.97754514e-02f, 4.99747582e-02f, 1.59746066e-01f, 2.36276448e-01f, 2.21902713e-01f, 6.68369010e-02f, -4.24076654e-02f, -6.77144751e-02f, -3.29751000e-02f, -1.37299716e-01f,
  2.48896033e-01f, -2.49044329e-01f, 7.37100169e-02f, 1.47217169e-01f, 2.99954802e-01f, 3.26638609e-01f, 2.75630981e-01f, 4.19366509e-02f, 4.50688452e-02f, 1.59802823e-03f,
  -2.48698711e-01f, -4.32949185e-01f, -2.70151198e-01f, -3.89339596e-01f, -2.64406443e-01f, 1.55710420e-02f, 8.63664970e-02f, 2.51797512e-02f, 2.17296302e-01f, 7.13445097e-02f,
  -1.09201826e-01f, 1.51049972e-01f, 2.08491638e-01f, 6.26104996e-02f, -5.65859899e-02f, -6.97355568e-02f, -5.61494753e-02f, 7.40044042e-02f, -1.76190749e-01f, -1.90212160e-01f,
  -1.03187785e-01f, 5.74068017e-02f, 5.74432500e-02f, -1.18707918e-01f, -1.63619071e-01f, -8.15949440e-02f, -1.26541391e-01f, -9.44506600e-02f, -9.85578448e-02f, 6.22760830e-03f,
  -3.91442925e-02f, -1.03001464e-02f, 3.20028095e-03f, -5.58545664e-02f, 1.76592693e-01f, -8.65189731e-03f, -3.73272225e-02f, -5.33497967e-02f, -1.19017959e-01f, -2.01241840e-02f,
  -2.29223385e-01f, 5.82909659e-02f, 3.84934321e-02f, -8.82215798e-03f, -1.30627289e-01f, -1.03992268e-01f, -4.27920036e-02f, 1.05099902e-02f, -8.18014070e-02f, 3.67413685e-02f,
  -3.95278558e-02f, 3.65277119e-02f, -6.83465600e-02f, -2.59404797e-02f, 4.81795743e-02f, 1.66325662e-02f, -1.12335227e-01f, 4.99181077e-02f, 5.31569049e-02f, 4.95165884e-02f,
  2.69822236e-02f, -3.77255604e-02f, -3.73287611e-02f, 3.09752324e-03f, -1.27427071e-01f, -9.79956239e-02f, -4.75951657e-02f, -6.42555580e-02f, 8.69371463e-03f, -4.34916839e-02f,
  -5.82788549e-02f, -4.31717723e-04f, 2.11931276e-03f, -2.12050095e-01f, -8.20176080e-02f, -9.26132128e-02f, -8.70383605e-02f, -1.03440687e-01f, -1.82721596e-02f, 2.38578231e-03f,
  -1.98715240e-01f, -8.87943879e-02f, 5.38165979e-02f, -9.99693200e-02f, 9.43563730e-02f, 4.89315996e-03f, -1.61113143e-01f, -2.00447403e-02f, 6.18439913e-02f, 6.70713335e-02f,
  -2.48245075e-02f, -1.27557991e-02f, -5.28472625e-02f, 1.55460453e-02f, 6.83099255e-02f, 2.10772101e-02f, -1.19524717e-01f, 4.49161269e-02f, -1.04338042e-01f, 9.79951932e-04f,
  -1.51677812e-02f, 1.09452568e-01f, 1.47008747e-01f, 2.92982515e-02f, -3.48608755e-02f, 1.39124110e-01f, 1.25122860e-01f, 1.17149234e-01f, 3.88429053e-02f, 1.62669927e-01f,
  1.22869059e-01f, 8.68588686e-02f, 1.17729440e-01f, -5.28924866e-03f, 2.94597179e-01f, 2.33495638e-01f, 4.17009085e-01f, 9.82260182e-02f, 3.24645415e-02f, 1.59627333e-01f,
  -6.29931465e-02f, -2.70114809e-01f, -2.79826730e-01f, -1.84129477e-01f, -8.30739066e-02f, 1.29550457e-01f, -4.14931178e-02f, -1.36821583e-01f, -7.20034987e-02f, 7.37193674e-02f,
  -7.66960233e-02f, 8.43346789e-02f, 9.09192041e-02f, -1.91526785e-01f, 4.71151844e-02f, -1.90522447e-01f, 1.30496845e-01f, 1.47183910e-01f, 1.63948312e-01f, -7.77006894e-02f,
  3.01528294e-02f, 2.56543934e-01f, -2.37884104e-01f, -4.62947637e-02f, 1.12290129e-01f, -1.31791949e-01f, -4.26234528e-02f, -7.18199387e-02f, -9.07122809e-03f, -1.45906910e-01f,
  4.33409326e-02f, -9.83463004e-02f, 9.72871557e-02f, 6.77112639e-02f, 5.16289547e-02f, 6.36228770e-02f, -1.91934861e-03f, -4.27082628e-02f, -7.91747496e-02f, 4.64952067e-02f,
  -1.16497062e-01f, 1.49735853e-01f, 2.73382217e-01f, 9.00044590e-02f, -1.21906772e-02f, -1.18072316e-01f, 3.17352489e-02f, 4.72578816e-02f, 3.37002613e-02f, -1.64124727e-01f,
  -2.11652741e-01f, -8.24981332e-02f, 6.31168187e-02f, -3.95706370e-02f, -3.05599645e-02f, 2.94832122e-02f, -4.63094190e-02f, -7.43072703e-02f, -6.25045151e-02f, 5.61132655e-02f,
  -1.84800439e-02f, 3.78737599e-02f, -1.27817392e-01f, -2.75186151e-02f, -1.17154531e-01f, 1.42377004e-01f, 2.64262129e-02f, -1.62744559e-02f, 6.43063933e-02f, 1.29571959e-01f,
  2.58793752e-03f, -6.98595420e-02f, -2.80554220e-02f, -2.28937697e-02f, 4.77677444e-03f, -1.05325967e-01f, -7.73148313e-02f, 5.76260649e-02f, -7.43280724e-02f, -1.10559724e-01f,
  -6.95758611e-02f, 9.74722281e-02f, -1.91600502e-01f, -1.52421877e-01f, 4.62323315e-02f, -3.07247322e-02f, -4.53208312e-02f, -7.29135051e-02f, -7.18002170e-02f, 1.64045040e-02f,
  4.66993675e-02f, -1.48515597e-01f, 5.07509941e-03f, -5.63011616e-02f, -6.81071654e-02f, -6.34589642e-02f, 2.38519516e-02f, 7.47520030e-02f, 8.92963819e-03f, 1.84685681e-02f,
  1.64754968e-02f, 3.64123359e-02f, 5.10786474e-02f, -8.42969567e-02f, -4.73781377e-02f, -1.34457260e-01f, -1.06555503e-02f, 9.62657630e-02f, -1.05154235e-03f, -6.76449314e-02f,
  5.65186620e-01f, -3.91816705e-01f, -2.79168278e-01f, 1.27849907e-01f, -1.18734799e-01f, 7.93412235e-03f, -2.53873050e-01f, 1.07322469e-01f, 2.30700552e-01f, -1.74142092e-01f,
  -5.00243679e-02f, 2.99162507e-01f, 2.35756591e-01f, 5.31178266e-02f, 1.37657434e-01f, -2.64023840e-01f, -3.81972849e-01f, 4.59128655e-02f, 1.80945143e-01f, 5.44361882e-02f,
  -3.72278318e-02f, 9.28309262e-02f, 5.13713993e-02f, 1.32944668e-02f, -4.71586846e-02f, -9.07471627e-02f, -3.79300326e-01f, -1.19378120e-01f, -1.45942897e-01f, -3.63431215e-01f,
  -1.63352832e-01f, 1.80529356e-01f, 1.04743093e-02f, 1.01973064e-01f, -1.54658547e-02f, 9.68152508e-02f, -7.14014173e-02f, -3.60450447e-02f, 4.33206819e-02f, 3.91728953e-02f,
  2.67350767e-02f, -5.53373620e-03f, 8.77605230e-02f, -3.28677520e-02f, -7.89923444e-02f, 8.53157341e-02f, -5.45905121e-02f, 7.85622820e-02f, 1.64701547e-02f, 1.78654271e-03f,
  -1.56495675e-01f, -9.28299651e-02f, -8.23896751e-03f, -1.19722947e-01f, -7.92843401e-02f, 3.95305157e-02f, -2.11123660e-01f, -3.80974561e-02f, -1.23922497e-01f, -1.87712818e-01f,
  -4.92867194e-02f, -6.56464603e-03f, -1.43657522e-02f, 3.27938907e-02f, 1.40244933e-02f, -1.65063869e-02f, 1.20275272e-02f, 4.95053176e-03f, -4.61856462e-02f, -1.60700157e-02f,
  -8.52744803e-02f, 4.35923785e-02f, -1.12162746e-01f, 9.36489273e-03f, -9.21853334e-02f, 6.41550049e-02f, -2.84444597e-02f, 5.88951353e-03f, 4.22350084e-03f, -2.85776928e-02f,
  7.24930223e-03f, -2.31415965e-02f, -4.07203771e-02f, -2.32255682e-02f, -3.20680067e-02f, -1.89948995e-02f, 1.01490550e-01f, 1.28345475e-01f, 1.28698915e-01f, 1.84539091e-02f,
  1.20985001e-01f, -1.28886580e-01f, 6.49941489e-02f, 4.78122793e-02f, -8.24702233e-02f, 7.10805878e-03f, -6.61626607e-02f, -1.44887730e-01f, 5.21077923e-02f, 6.39131293e-02f,
  -8.56551528e-03f, -1.07827917e-01f, -3.13509107e-02f, -1.11482084e-01f, -6.27677590e-02f, -4.29545380e-02f, -8.37795883e-02f, -4.34972420e-02f, 3.51313092e-02f, 3.12733576e-02f,
  -1.65984631e-01f, 7.10318312e-02f, 1.85558394e-01f, 1.08279930e-02f, 1.16680510e-01f, 1.24226948e-02f, -1.64840948e-02f, -7.68675059e-02f, 5.47647402e-02f, -2.04017282e-01f,
  -6.17027283e-01f, 5.74023637e-04f, 1.10741124e-01f, -4.49203849e-01f, -8.83128121e-02f, -1.44908139e-02f, 3.74510735e-02f, 8.34851526e-03f, -2.14862794e-01f, -8.17736164e-02f,
  8.93173367e-02f, -6.24379255e-02f, -9.45847183e-02f, 4.37112711e-02f, 1.68874301e-02f, -2.98244096e-02f, -1.31996423e-01f, -1.53241055e-02f, 2.34356672e-01f, 3.16279322e-01f,
  9.20672715e-03f, -2.31320083e-01f, -2.26896256e-01f, -1.04137972e-01f, -6.89996257e-02f, 3.12993005e-02f, -2.09988371e-01f, -1.54773220e-01f, 8.05619359e-02f, -3.14562798e-01f,
  2.08852664e-01f, -1.61712900e-01f, 1.64002389e-01f, -1.12915456e-01f, 9.02153775e-02f, 2.71946341e-02f, 7.08948867e-03f, -4.75526527e-02f, -1.16793320e-01f, -4.36141901e-02f,
  -5.49851619e-02f, 5.35299815e-02f, -1.89950522e-02f, 4.65071723e-02f, -1.00736484e-01f, -6.79180026e-02f, -1.15255862e-01f, -1.69263072e-02f, -3.81329730e-02f, 1.33371606e-01f,
  2.40296759e-02f, -3.45146656e-02f, -3.34408917e-02f, 2.65140031e-02f, 5.87333180e-02f, -1.48495466e-01f, 4.56707478e-02f, 4.67335768e-02f, -7.09692538e-02f, -2.16643408e-01f,
  6.51985109e-02f, -7.01220753e-03f, 7.17230663e-02f, -5.29188439e-02f, -4.34732549e-02f, -1.04663059e-01f, -5.00905812e-02f, -1.20182708e-02f, 3.33905965e-02f, -1.15391510e-02f,
  3.76380719e-02f, -4.49180938e-02f, -1.56820193e-02f, -7.39992037e-02f, 2.79865321e-02f, -8.13081563e-02f, 1.58685595e-02f, -2.23810915e-02f, -2.13106666e-02f, -5.06737493e-02f,
  -9.54810157e-03f, 2.97852047e-02f, -1.31652296e-01f, 6.25395924e-02f, -4.93784808e-02f, -3.44812647e-02f, -1.58254579e-02f, 1.54587924e-01f, -2.63769291e-02f, -5.56325540e-02f,
  -5.81692085e-02f, 2.39805374e-02f, 2.30725836e-02f, -2.92239841e-02f, 1.44182332e-02f, -4.38131467e-02f, -4.66543883e-02f, 1.27920397e-02f, -1.86231807e-02f, -1.14988210e-02f,
  1.07433818e-01f, 3.43738981e-02f, -1.09431958e-02f, 5.27248718e-02f, 1.24329794e-02f, 7.09494352e-02f, 6.71656942e-03f, -8.06828141e-02f, 6.44163340e-02f, 6.45371601e-02f,
  -4.99825142e-02f, -9.13165584e-02f, -7.58621544e-02f, -1.35441227e-02f, -3.35724689e-02f, -5.72742801e-03f, 9.28275511e-02f, 4.89850268e-02f, -5.41224051e-03f, -3.44903320e-02f,
  -6.72724128e-01f, -1.59013763e-01f, 2.71673173e-01f, -3.94792825e-01f, -1.31507158e-01f, 3.07224691e-02f, -1.13249242e-01f, -1.54439807e-01f, -2.91539848e-01f, -2.81000674e-01f,
  -2.52730638e-01f, -1.77035362e-01f, -1.33469939e-01f, 2.63285469e-02f, 1.72644630e-01f, -1.10438369e-01f, 1.27938792e-01f, 3.20858657e-01f, 3.14764470e-01f, 3.80682796e-02f,
  -1.07877865e-01f, -7.73855895e-02f, 3.10474467e-02f, 2.02677757e-01f, -2.22095296e-01f, -4.77337763e-02f, 1.62949771e-01f, -3.99982519e-02f, 2.02488422e-01f, -2.45204434e-01f,
  -3.23248655e-01f, -5.26671559e-02f, 2.18640268e-01f, -2.58863773e-02f, 6.48530722e-02f, -4.76031974e-02f, -7.56313745e-03f, 1.14520922e-01f, 1.45508662e-01f, -7.85406455e-02f,
  -2.00234577e-01f, -1.42227253e-02f, -1.03025354e-01f, -6.32415013e-03f, -1.85046375e-01f, -1.29468828e-01f, 1.80381890e-02f, 1.61647826e-01f, 5.98971769e-02f, 1.84714925e-02f,
  -1.03295974e-01f, 6.34693056e-02f, 1.68552548e-02f, 1.69759333e-01f, 1.65976007e-02f, 4.68386784e-02f, 1.49031952e-01f, 9.97352749e-02f, 2.88800895e-01f, -2.65357584e-01f,
  1.40409684e-02f, 7.13268481e-03f, 5.34856655e-02f, 1.93200577e-02f, -1.14026196e-01f, -1.86317749e-02f, 4.84220162e-02f, -1.11159191e-01f, 8.10885876e-02f, -5.80824353e-02f,
  -1.01214414e-02f, -1.66310314e-02f, 6.72814250e-03f, -3.72752175e-02f, -7.53139481e-02f, 1.92460995e-02f, -5.75218303e-03f, 4.48164940e-02f, -2.91311964e-02f, 8.77704099e-02f,
  -6.95780478e-03f, 6.50758147e-02f, 6.87200204e-02f, 2.04119124e-02f, 1.16295256e-01f, 3.77323963e-02f, -3.02771144e-02f, 6.01646956e-03f, -1.32163644e-01f, -1.21192157e-01f,
  -4.33874696e-01f, 2.97091186e-01f, -2.26400331e-01f, -4.74548265e-02f, -3.69213521e-02f, 1.16443068e-01f, -5.98465689e-02f, -2.04912871e-02f, -1.81789622e-01f, -7.91998208e-02f,
  1.75362751e-02f, -1.49764225e-01f, -1.67148486e-01f, 1.33998752e-01f, -1.18560597e-01f, -1.17653355e-01f, -1.50806755e-01f, -1.52637869e-01f, 2.07218975e-01f, -1.06165305e-01f,
  -1.16470894e-02f, -7.93060586e-02f, -1.92920282e-01f, -1.30964965e-01f, -1.53085485e-01f, -1.47111535e-01f, -1.81693017e-01f, -2.21581906e-02f, 8.05584118e-02f, -4.45958853e-01f,
  6.04779124e-01f, 5.43600678e-01f, 7.89867863e-02f, -2.74566449e-02f, -1.92820743e-01f, 5.43282658e-04f, 1.67258993e-01f, 2.22198203e-01f, -6.82680309e-02f, 1.61351055e-01f,
  2.48166751e-02f, -1.78973317e-01f, -7.25859255e-02f, -4.60707247e-02f, 1.59517422e-01f, 1.58250153e-01f, -6.19893298e-02f, 8.05610046e-02f, 7.60555565e-02f, -1.11873494e-02f,
  -4.83672284e-02f, 1.01142243e-01f, 2.79138029e-01f, 9.40138847e-02f, -4.07300256e-02f, -1.62844688e-01f, 1.06902197e-01f, 3.95777933e-02f, 2.22455896e-02f, 7.31008202e-02f,
  -9.74713787e-02f, 2.85630256e-01f, -2.32909590e-01f, 5.33554554e-02f, 1.64306819e-01f, 1.02350622e-01f, -3.73685919e-02f, 9.13135707e-03f, -7.40110353e-02f, -6.88126162e-02f,
  4.85427259e-03f, 4.39812839e-02f, -6.08895794e-02f, 3.97053584e-02f, 1.01593509e-01f, -5.62752634e-02f, -5.33798523e-03f, 2.06327606e-02f, -7.54678473e-02f, 2.35295054e-02f,
  -5.12925684e-02f, 7.19279498e-02f, 6.33018464e-02f, -1.09158389e-01f, -5.66205159e-02f, -6.25443682e-02f, 9.37513914e-03f, 4.12473604e-02f, -1.15582868e-02f, 1.35856673e-01f,
  -2.89601892e-01f, -1.59409381e-02f, -3.89636829e-02f, -7.41563365e-02f, -6.96284324e-02f, -1.18530162e-01f, -1.30842641e-01f, 2.26971842e-02f, -1.44531420e-02f, 1.92845464e-02f,
  -1.42211169e-01f, -1.34153634e-01f, -7.71073997e-02f, -9.23343003e-02f, -4.84327190e-02f, 5.71582466e-02f, 3.72318961e-02f, -9.47360694e-02f, -9.35222879e-02f, -9.35889781e-02f,
  -1.27094612e-01f, -6.34055957e-02f, 6.58193231e-02f, 9.48183760e-02f, 7.28806183e-02f, -9.53794867e-02f, -6.95565566e-02f, 2.44676489e-02f, 2.80708377e-03f, 2.42619663e-02f,
  -3.00913930e-01f, -2.16830239e-01f, -9.06632766e-02f, 1.21320851e-01f, 5.51027171e-02f, 7.12444931e-02f, 3.20040956e-02f, -4.33734916e-02f, -1.07882833e-02f, -8.88050124e-02f,
  1.20998740e-01f, 4.99308035e-02f, 6.71980828e-02f, -1.35470589e-03f, -2.74185576e-02f, -9.05746818e-02f, 5.07048480e-02f, -7.85582364e-02f, -2.10228823e-02f, 1.84075162e-02f,
  -6.24109432e-02f, -9.72051397e-02f, -1.28890663e-01f, -1.78211749e-01f, -1.14086814e-01f, -1.28082797e-01f, -1.14391394e-01f, -1.15022875e-01f, -5.02330996e-02f, -4.36774548e-03f,
  -5.74577972e-03f, -8.35633255e-04f, -1.08688064e-01f, 1.26127809e-01f, -1.88642025e-01f, -3.24577481e-01f, -3.42872620e-01f, 3.60124297e-02f, 1.15612306e-01f, -3.97248864e-02f,
  -1.20596476e-01f, -2.53997952e-01f, -7.81350583e-02f, -3.34108137e-02f, -1.67806581e-01f, -4.10379805e-02f, -7.91038647e-02f, -1.79872409e-01f, -3.73330653e-01f, -3.74697685e-01f,
  -2.10939586e-01f, -9.16438326e-02f, -7.58930594e-02f, -8.09468925e-02f, -2.08927169e-02f, -2.18329459e-01f, 4.18939739e-02f, -1.17961228e-01f, -2.10728332e-01f, -5.07114232e-02f,
  -3.13982874e-01f, -3.20931934e-02f, 2.05940418e-02f, 1.92735717e-02f, -7.05340728e-02f, -4.87282462e-02f, -9.04386677e-03f, -7.00062839e-03f, 5.45696616e-02f, 7.58528360e-04f,
  -5.18389232e-02f, -6.12913743e-02f, -7.97846541e-02f, -8.83641616e-02f, -4.29657437e-02f, -1.01689510e-01f, 3.23566161e-02f, -2.44940934e-03f, 1.08730577e-01f, -8.27692747e-02f,
  -6.83730170e-02f, -1.79625496e-01f, -7.17410445e-02f, 1.66402161e-01f, 7.64863417e-02f, 2.60828193e-02f, 5.60790226e-02f, -7.40378648e-02f, -7.98337460e-02f, 7.74932131e-02f,
  7.34279752e-02f, 9.14050862e-02f, -3.39911208e-02f, -2.02444587e-02f, -7.83355609e-02f, 6.30137697e-02f, 3.32147107e-02f, -9.89474058e-02f, 1.05901323e-02f, 9.19857472e-02f,
  6.90752044e-02f, 2.56641563e-02f, 3.27597186e-02f, 1.76411942e-02f, 2.01101098e-02f, -1.34503230e-01f, -1.54977158e-01f, -2.59350110e-02f, -1.22878224e-01f, -7.80084953e-02f,
  -1.55886739e-01f, 1.12382481e-02f, -1.40842749e-03f, -4.08573076e-02f, 8.13959911e-03f, 7.24682584e-02f, -9.84155163e-02f, -5.47146164e-02f, 4.44418974e-02f, -4.96998616e-02f,
  1.32653490e-01f, -1.38262272e-01f, 3.73583212e-02f, 1.69334561e-02f, -1.05819799e-01f, 8.11268389e-03f, -1.42956488e-02f, -9.60776880e-02f, 6.88794628e-02f, 1.37448320e-02f,
  -2.96042413e-02f, 5.14269955e-02f, 2.22663805e-02f, 1.34891853e-01f, -4.32129838e-02f, 6.01821579e-02f, 6.68928474e-02f, -3.96243930e-02f, 5.28401174e-02f, 4.53504138e-02f,
  7.90334642e-02f, -3.38454880e-02f, -8.78373682e-02f, 3.86758856e-02f, 1.03168972e-02f, -4.73521538e-02f, -1.17790937e-01f, -6.02319092e-02f, -2.08639749e-03f, 9.44937766e-02f,
  3.56671542e-01f, 2.53124952e-01f, 1.65987179e-01f, 1.62398756e-01f, 3.20518501e-02f, 3.77076268e-02f, 1.46595240e-01f, 1.12780528e-02f, 4.97506186e-02f, 5.36983423e-02f,
  2.09721163e-01f, 1.57331154e-01f, 1.40064090e-01f, 8.55643826e-04f, 1.39005795e-01f, 2.85722371e-02f, 1.06410332e-01f, 1.06613882e-01f, 1.26024112e-01f, 2.28327632e-01f,
  1.73785955e-01f, 1.35330319e-01f, 9.96217579e-02f, 5.76997809e-02f, 1.54845148e-01f, 7.93456137e-02f, 6.67794719e-02f, 1.23720020e-01f, 1.50625467e-01f, 2.46408671e-01f,
  1.44028142e-01f, 2.52800465e-01f, -8.55487287e-02f, 4.00215313e-02f, -4.12068050e-03f, -1.41769320e-01f, -5.07561117e-02f, -1.32116720e-01f, -9.69173238e-02f, -4.98267524e-02f,
  1.22056916e-01f, 6.43300809e-05f, -1.95959845e-04f, -2.05060374e-02f, 1.30575905e-02f, -1.45119697e-01f, -8.72939173e-03f, -4.63193320e-02f, -9.86323878e-02f, 4.10243124e-02f,
  2.33748313e-02f, 9.72898155e-02f, -1.16866946e-01f, -6.89860433e-02f, 1.77434217e-02f, 7.59491920e-02f, 1.88582949e-02f, 1.01219110e-01f, -1.99836423e-03f, 1.33954445e-02f,
  5.32034822e-02f, 3.27321738e-02f, -3.71994963e-03f, 2.07458511e-01f, 9.48273987e-02f, 8.49221274e-02f, 1.27142295e-01f, 9.01197083e-03f, -7.45846378e-03f, 1.37279667e-02f,
  6.70225942e-04f, 8.23884737e-03f, 8.58501196e-02f, 4.58650626e-02f, -1.54156126e-02f, 5.35224983e-03f, 5.52421995e-02f, -6.40640631e-02f, 1.65127218e-02f, -2.34442391e-02f,
  -4.27858941e-02f, -5.76486848e-02f, 3.59724015e-02f, 8.26072171e-02f, -5.62821999e-02f, 5.94906285e-02f, -2.09226478e-02f, 2.21303906e-02f, 6.03061616e-02f, -5.84633276e-02f,
  -3.66569996e-01f, -4.76670973e-02f, 2.01143518e-01f, -1.28051102e-01f, 1.11409435e-02f, -6.12194128e-02f, -4.24093641e-02f, -8.75719190e-02f, -2.48115305e-02f, -9.67230946e-02f,
  5.63952997e-02f, -2.14439072e-02f, -1.07940331e-01f, -4.35439274e-02f, -6.05187118e-02f, -1.98709741e-01f, -6.04392923e-02f, -4.85441424e-02f, -1.65058792e-01f, -1.69605576e-02f,
  -1.00801103e-01f, -2.01783299e-01f, -1.03275515e-01f, -1.55065179e-01f, -2.35403865e-03f, -1.64682776e-01f, -4.72422987e-02f, 1.50334816e-02f, -1.93921864e-01f, -1.69035643e-01f,
  1.91112250e-01f, 3.46443206e-02f, 2.08543494e-01f, 9.04973745e-02f, -1.54724151e-01f, -3.31363976e-01f, -1.33284867e-01f, -2.08067015e-01f, -5.36263101e-02f, 1.06045879e-01f,
  3.81566100e-02f, -4.19034176e-02f, 1.57314111e-02f, -7.35222250e-02f, -1.58842921e-01f, 1.32872716e-01f, 6.40495569e-02f, -9.75106955e-02f, -2.17268363e-01f, -2.67254770e-01f,
  -1.70830444e-01f, -3.07592750e-02f, 5.70600554e-02f, -8.37159306e-02f, 2.00664699e-01f, -1.86118446e-02f, 9.48445797e-02f, 8.61739367e-03f, -1.34407440e-02f, 3.79876792e-01f,
  2.49827087e-01f, 1.86447918e-01f, -1.81158081e-01f, -1.29941061e-01f, -9.43247527e-02f, -1.11060357e-02f, 2.89363367e-03f, 7.59270936e-02f, -5.45721203e-02f, 7.29068443e-02f,
  -7.14415535e-02f, -3.61133888e-02f, 5.54676587e-03f, 4.62572053e-02f, -1.65848032e-01f, -3.41926399e-03f, 3.17505226e-02f, -1.91510729e-02f, -1.53939296e-02f, 9.37841982e-02f,
  4.14150283e-02f, -1.68122053e-02f, 8.59839469e-02f, -2.29757726e-02f, -1.47725700e-03f, -4.01334539e-02f, -9.80239734e-02f, -6.72912523e-02f, -6.97854087e-02f, 3.81532013e-02f,
  7.29190707e-02f, 1.48580335e-02f, 1.12271756e-02f, -2.19144225e-02f, 1.47236371e-02f, -4.07328047e-02f, 5.00994399e-02f, -7.39642903e-02f, -3.19702476e-02f, -4.80271392e-02f,
  -3.73689570e-02f, 2.39199083e-02f, -1.63795605e-01f, 6.44991696e-02f, -6.37968245e-04f, -7.56492168e-02f, -2.95497570e-02f, 6.86623901e-02f, 2.14753486e-02f, -1.82712059e-02f,
  -4.55090813e-02f, 6.73447102e-02f, -9.32333991e-02f, -2.15636268e-02f, 5.32999970e-02f, 4.95760376e-03f, -6.02878854e-02f, -7.71934912e-02f, -2.50066854e-02f, 1.48999408e-01f,
  -1.49538428e-01f, -2.27412581e-01f, -5.14614135e-02f, -1.31074429e-01f, -1.01485640e-01f, 4.33721915e-02f, -2.17744075e-02f, -1.63104720e-02f, 7.82273486e-02f, 3.41441408e-02f,
  -1.01391092e-01f, 3.21790902e-03f, 8.88809934e-02f, -1.29469633e-02f, -6.40995875e-02f, 2.32679700e-03f, -1.32694438e-01f, -6.55241013e-02f, -2.05184817e-01f, 1.62731484e-03f,
  -1.33483917e-01f, -1.68453887e-01f, -9.27805603e-02f, 4.78500985e-02f, -7.43243620e-02f, -1.33079842e-01f, -1.74904943e-01f, -2.29810655e-01f, -2.13586941e-01f, -1.13918215e-01f,
  6.32609010e-01f, 1.31089583e-01f, 2.84015298e-01f, 2.69602090e-01f, 1.76211491e-01f, 2.14790687e-01f, 2.59927958e-01f, 2.83773363e-01f, 1.57762364e-01f, 1.03505455e-01f,
  6.23053014e-02f, 2.39743083e-03f, 1.18368544e-01f, 5.65511398e-02f, 1.82374537e-01f, 1.49498070e-02f, -7.26574957e-02f, 1.27023771e-01f, 1.67713121e-01f, 2.09062427e-01f,
  -4.32372652e-02f, 6.37299344e-02f, 2.12508172e-01f, 8.06650445e-02f, -1.26054078e-01f, 1.61457136e-02f, -7.15545565e-02f, 2.85937600e-02f, -4.43210863e-02f, -2.05671847e-01f,
  -1.86348766e-01f, 5.80248609e-02f, -7.21846372e-02f, -1.57203469e-02f, -9.69130546e-03f, -3.66964824e-02f, -1.49016734e-02f, 8.82059038e-02f, 8.59462917e-02f, 1.40812257e-02f,
  -4.17247042e-02f, 6.16847444e-03f, -2.53398884e-02f, -4.09263894e-02f, -7.20293745e-02f, -9.31229368e-02f, -3.30266058e-02f, 1.51072711e-01f, 8.77649188e-02f, 5.59968986e-02f,
  -1.55330926e-01f, 5.51720932e-02f, 1.03042319e-01f, 6.37119487e-02f, 9.74546149e-02f, -2.51961546e-03f, -1.00037128e-01f, 1.94260627e-02f, 8.17562863e-02f, 1.18914992e-02f,
  4.98482138e-02f, 1.08699732e-01f, 4.40479629e-02f, -1.74452737e-02f, 8.90179500e-02f, 7.34682828e-02f, -5.31912073e-02f, -2.59721689e-02f, 2.25068666e-02f, -7.79505670e-02f,
  -1.13062441e-01f, 1.17342897e-01f, 6.52401987e-03f, 4.36502919e-02f, 2.12363414e-02f, -1.31669104e-01f, -2.06403993e-02f, -7.52593353e-02f, -7.60522708e-02f, 3.88636291e-02f,
  5.04645593e-02f, 3.10520791e-02f, -1.13246426e-01f, -8.82742926e-02f, 5.96625768e-02f, 4.46953513e-02f, 3.46856378e-03f, 4.04591002e-02f, -3.19928117e-02f, 6.23917617e-02f,
  -2.93586642e-01f, -2.65075918e-03f, -1.58165265e-02f, -1.67475551e-01f, -1.15974739e-01f, -8.69701281e-02f, -1.99444778e-02f, -9.83034149e-02f, -4.12551053e-02f, 9.01992526e-03f,
  -2.87095085e-02f, -1.48710862e-01f, -1.05525255e-01f, -7.32823461e-02f, 3.60043272e-02f, -5.02527766e-02f, -1.84802532e-01f, -4.53932956e-02f, 7.30200559e-02f, -4.71660867e-02f,
  -1.23293530e-02f, -3.32621150e-02f, 1.00026846e-01f, 2.41338257e-02f, -2.70825699e-02f, -5.76182939e-02f, 5.88071533e-03f, -9.81542617e-02f, 8.00315663e-02f, 7.85347074e-02f,
  9.28226709e-02f, 2.21705381e-02f, 5.14144413e-02f, 4.62797470e-02f, -5.69884516e-02f, -6.24114685e-02f, -8.35460275e-02f, -1.60391126e-02f, 2.75808629e-02f, -1.93510558e-02f,
  1.73551857e-01f, 4.55129594e-02f, 9.77089331e-02f, -5.87804578e-02f, -6.10806197e-02f, -1.85489148e-01f, -3.21031719e-01f, -1.56539530e-01f, -1.65080369e-01f, -1.98715821e-01f,
  -2.42810726e-01f, -1.93179742e-01f, -9.12008528e-03f, 1.31809255e-02f, 7.43930638e-02f, -3.57913487e-02f, -1.26105517e-01f, -2.64154430e-02f, -1.05957881e-01f, -1.90011695e-01f,
  -2.82533020e-02f, 2.95752555e-01f, 5.73258512e-02f, 7.94186294e-02f, 7.62027055e-02f, 1.69257000e-01f, 1.08893812e-01f, 1.52998805e-01f, 1.48481235e-01f, -4.79543693e-02f,
  1.64322823e-01f, 1.11493073e-01f, 9.49141905e-02f, 3.45498789e-04f, 4.41565067e-02f, 1.58160135e-01f, 1.28055945e-01f, -6.31535053e-02f, 1.12023927e-01f, 2.43601892e-02f,
  1.15288764e-01f, 1.68615542e-02f, 1.25304669e-01f, 1.03037834e-01f, 1.13816045e-01f, 4.09901403e-02f, 1.41282469e-01f, 2.02477291e-01f, 1.19152002e-01f, 5.81998453e-02f,
  -9.43748802e-02f, -2.16892231e-02f, 1.21769503e-01f, -4.39818688e-02f, -1.28083266e-02f, -8.99890140e-02f, 2.39200853e-02f, 4.46310220e-03f, -3.77129093e-02f, 1.58506930e-02f,
  1.74787771e-02f, 2.04099100e-02f, -3.41125503e-02f, 7.06759915e-02f, 1.45827413e-01f, 4.12473716e-02f, 3.19672370e-04f, 1.19147219e-01f, 2.05853373e-01f, 1.19197719e-01f,
  4.14571678e-03f, -2.55801901e-02f, 4.38251905e-02f, 2.69663539e-02f, 1.80763826e-01f, 1.36584997e-01f, 7.52017200e-02f, 2.00534746e-01f, 3.45709957e-02f, -6.64587170e-02f,
  -2.81575263e-01f, 1.29728109e-01f, -6.59158602e-02f, 8.55978280e-02f, 5.86389750e-02f, 1.23307399e-01f, 7.49105439e-02f, -6.64266804e-03f, 4.10064943e-02f, 9.86452699e-02f,
  5.97103424e-02f, 4.34983037e-02f, 5.31967506e-02f, -6.70695603e-02f, -7.75459316e-03f, 7.90104941e-02f, 9.79884937e-02f, 6.61166534e-02f, -5.16760573e-02f, 3.31662409e-02f,
  7.33657256e-02f, -7.23948553e-02f, -7.36778304e-02f, -2.44834963e-02f, 1.67007055e-02f, -4.93489467e-02f, 1.10042505e-02f, -6.20001890e-02f, -2.41775736e-02f, -1.02802239e-01f,
  9.59291533e-02f, 4.73248251e-02f, -4.58254933e-01f, 2.74717182e-01f, 8.00347701e-02f, -2.80304551e-01f, -4.77484584e-01f, -2.28955254e-01f, 1.32521912e-01f, -8.09831619e-02f,
  -8.68480001e-03f, 1.96999952e-01f, -1.67354476e-02f, -2.99250573e-01f, -4.41127658e-01f, -5.85584879e-01f, -4.92407739e-01f, -4.46528435e-01f, -5.01613975e-01f, -1.12185262e-01f,
  6.75362125e-02f, 1.19851135e-01f, 1.28299445e-02f, -2.81831678e-02f, 2.55883574e-01f, 3.32768410e-02f, -1.47079572e-01f, 5.21701062e-03f, -1.18097141e-01f, 1.39906062e-02f,
  -3.73961717e-01f, -9.74232145e-03f, -1.07711926e-01f, 8.40207860e-02f, 7.42024332e-02f, 6.33653207e-03f, -1.91358656e-01f, -9.97211114e-02f, 5.97452112e-02f, -1.07269868e-01f,
  -5.63344099e-02f, 3.47413421e-02f, -8.08632821e-02f, -4.76187915e-02f, -1.07908994e-01f, -1.91491708e-01f, -1.11453429e-01f, -1.12882584e-01f, -2.02116460e-01f, 9.82894935e-03f,
  1.60404414e-01f, 4.81372364e-02f, -1.70609906e-01f, -1.52750269e-01f, -2.24356696e-01f, 2.87113953e-02f, 2.81442367e-02f, -7.91811347e-02f, -7.18550980e-02f, 1.32281765e-01f,
  2.00617276e-02f, -8.91868547e-02f, -4.40475866e-02f, 1.65888593e-02f, 8.83043259e-02f, 6.16183225e-03f, -7.43902773e-02f, -8.54871422e-02f, -8.62984881e-02f, -2.78526042e-02f,
  -7.71685913e-02f, -1.05169706e-01f, -1.09052740e-01f, -8.44079256e-02f, 3.21849063e-02f, -4.34479266e-02f, -1.58126786e-01f, -1.12898476e-01f, 1.74500011e-02f, -3.18719447e-02f,
  -8.84593502e-02f, 7.67873041e-03f, 6.60818592e-02f, -3.77307422e-02f, -1.49559006e-01f, -1.61306798e-01f, -6.45187050e-02f, 1.19482595e-02f, 1.66072287e-02f, -8.28075558e-02f,
  9.80237573e-02f, -1.50115564e-01f, -1.39851242e-01f, 1.00978399e-02f, -7.03269839e-02f, 8.55986923e-02f, 1.66239187e-01f, 1.81736809e-03f, 6.31765872e-02f, -6.61298335e-02f,
  -4.17241566e-02f, 3.69268842e-02f, 1.79404691e-02f, -1.71376206e-02f, -1.22836918e-01f, 1.62249543e-02f, 1.22224890e-01f, -6.18151501e-02f, 6.95267245e-02f, 1.79710045e-01f,
  1.66399255e-01f, -6.35137558e-02f, -4.44784798e-02f, 5.53871356e-02f, 2.96950573e-03f, -1.55327823e-02f, -1.38970539e-01f, -8.50538630e-03f, -1.32261083e-01f, 6.73790947e-02f,
  7.05686510e-02f, -1.16594754e-01f, 8.55149776e-02f, 2.04215050e-01f, -6.14865534e-02f, -2.94030696e-01f, -5.03716648e-01f, -1.68918654e-01f, 9.93942469e-02f, -2.61522625e-02f,
  1.51615441e-02f, 1.41980648e-01f, 8.86835903e-02f, 6.38728961e-02f, -1.25142351e-01f, -1.09450761e-02f, 1.17748804e-01f, 1.25788137e-01f, -2.33306542e-01f, -2.21752688e-01f,
  7.85512775e-02f, 9.02889296e-02f, 3.51313949e-02f, 2.39086580e-02f, 1.72335610e-01f, 7.47443065e-02f, 1.14867873e-01f, 1.37833685e-01f, -2.41062529e-02f, 2.67977148e-01f,
  1.81603268e-01f, -7.39669204e-02f, 3.68152298e-02f, 1.42462283e-01f, 1.15032546e-01f, 1.10282376e-01f, -7.25042149e-02f, 2.27150574e-01f, 5.30662052e-02f, 7.80266300e-02f,
  2.00565144e-01f, 8.34321231e-02f, 1.43045306e-01f, -3.59316403e-03f, 5.10859191e-02f, -9.18900743e-02f, -4.11557965e-02f, -2.50732340e-02f, -1.44919589e-01f, -1.67112514e-01f,
  1.38015732e-01f, 2.67436225e-02f, -2.26723149e-01f, -1.94984168e-01f, -1.18609041e-01f, 3.57399695e-02f, -1.59305632e-01f, 5.03816344e-02f, -1.42213076e-01f, -1.44189149e-01f,
  -9.01962966e-02f, -2.53250618e-02f, 2.27978453e-02f, -1.23011414e-02f, -8.74880850e-02f, 5.77794388e-02f, -2.39465293e-02f, -4.73816209e-02f, -4.91006523e-02f, -3.37793343e-02f,
  -5.37567064e-02f, 2.22014561e-02f, 8.03737715e-02f, 5.39972931e-02f, -3.25034223e-02f, 5.89331836e-02f, -4.77231741e-02f, -6.44634431e-03f, -2.33077817e-02f, 2.09995043e-02f,
  5.97097306e-03f, 2.35876832e-02f, -1.48846265e-02f, -7.86126480e-02f, -6.05612248e-02f, 2.42918581e-02f, 8.99434686e-02f, -4.28009517e-02f, -1.16920203e-01f, -2.21733656e-02f,
  1.71024665e-01f, -3.37687917e-02f, 5.35688549e-02f, 2.05497686e-02f, 2.62414161e-02f, -1.32546080e-02f, -2.87008397e-02f, -6.05357960e-02f, 5.73337413e-02f, -1.07699826e-01f,
  -7.09843785e-02f, -4.24784943e-02f, 5.25539815e-02f, -1.53241856e-02f, 7.39721805e-02f, -2.46001910e-02f, -1.15620550e-02f, -9.10798237e-02f, -4.27693920e-03f, 8.24042931e-02f,
  -9.72634181e-02f, -1.65864199e-01f, -1.46804824e-01f, -1.97109103e-01f, -1.36537654e-02f, -1.57208771e-01f, -2.24966094e-01f, -1.50628746e-01f, -3.07473630e-01f, -3.18438381e-01f,
  3.43668073e-01f, -1.06634058e-01f, 9.69802290e-02f, 1.45358378e-02f, -3.64120305e-01f, -2.34878600e-01f, -3.34699899e-01f, -2.52830982e-01f, -2.14203313e-01f, -1.48525745e-01f,
  -1.04746893e-01f, 1.11042991e-01f, 2.20264137e-01f, 1.98424146e-01f, 2.05690697e-01f, -7.70504028e-02f, -1.27247751e-01f, 3.02716434e-01f, 2.23581910e-01f, -1.22230954e-01f,
  -1.77592203e-01f, -1.16661452e-01f, 1.79270118e-01f, 1.10371158e-01f, -2.31424943e-01f, 1.78414322e-02f, -8.11838433e-02f, -1.79521203e-01f, -7.63584003e-02f, -8.00826401e-02f,
  1.58702031e-01f, 7.19336197e-02f, 1.26942128e-01f, 2.26489864e-02f, 5.77708473e-03f, 9.31905657e-02f, -4.16356474e-02f, 4.31234576e-02f, 2.27800217e-02f, -9.96246636e-02f,
  2.68421862e-02f, -5.15817665e-02f, 1.73481833e-02f, -1.38924211e-01f, -5.50910421e-02f, -4.20824178e-02f, -5.22305854e-02f, -8.45062286e-02f, 2.16768626e-02f, -1.08333074e-01f,
  -1.41357541e-01f, -8.21442679e-02f, -1.26751497e-01f, -3.97421010e-02f, -7.90553689e-02f, 3.33431698e-02f, -1.42505199e-01f, -5.80609962e-02f, -5.01628108e-02f, -5.80472648e-02f,
  1.02976719e-02f, 2.32645851e-02f, -7.57452920e-02f, -1.21250160e-01f, -1.73137873e-01f, -1.39357224e-02f, -7.16801137e-02f, -1.50367901e-01f, -9.89956558e-02f, -9.30610970e-02f,
  -7.43239895e-02f, 6.13685930e-03f, -4.62239422e-02f, -3.86101082e-02f, 1.16229922e-01f, -1.20655850e-01f, -3.94482985e-02f, -6.48537949e-02f, 2.66264714e-02f, -5.15876375e-02f,
  3.65947699e-03f, -2.90776808e-02f, 5.47729097e-02f, -1.33001074e-01f, -8.74802992e-02f, 2.71691531e-02f, -7.46021196e-02f, -7.62257054e-02f, -8.31536651e-02f, -2.93033030e-02f,
  -7.19175413e-02f, 2.71499306e-01f, 6.07189797e-02f, 5.72365448e-02f, -3.60078104e-02f, 4.07600552e-02f, 2.76052170e-02f, 5.54187261e-02f, 1.43592313e-01f, 1.31285982e-02f,
  7.41287023e-02f, 1.84874833e-01f, 9.66008566e-03f, -1.54223582e-02f, -5.76714128e-02f, 9.49382260e-02f, -5.63889667e-02f, 7.32088163e-02f, -4.08881828e-02f, -5.87683208e-02f,
  -7.77990883e-03f, 1.57876778e-02f, 1.06669188e-01f, 1.09143257e-01f, 7.55320787e-02f, 1.96286157e-01f, 1.46755517e-01f, -3.96012701e-02f, -2.13310160e-02f, -7.28866458e-02f,
  -8.15087080e-01f, -6.02304190e-02f, 6.74976334e-02f, -5.19027710e-01f, -1.65026724e-01f, 9.00248215e-02f, 6.87954575e-02f, 1.72788091e-02f, -2.84912705e-01f, -1.42876521e-01f,
  -3.44419256e-02f, -1.43471301e-01f, -1.31266192e-01f, -8.79434794e-02f, -6.57404354e-03f, -8.97101685e-02f, -1.52033895e-01f, -2.66433626e-01f, -1.58641301e-02f, 8.69793519e-02f,
  -1.14810793e-02f, -4.18008983e-01f, -4.15064752e-01f, -1.48997411e-01f, -8.38824734e-02f, -9.97453257e-02f, -2.10476562e-01f, -8.89095291e-02f, 8.91468488e-03f, -3.10166568e-01f,
  2.08745942e-01f, -3.71968038e-02f, -6.40407670e-03f, -2.88283918e-02f, -1.09866776e-01f, -1.37746066e-01f, 8.64166021e-03f, -8.04428682e-02f, -5.12985736e-02f, 1.21816419e-01f,
  -4.87611964e-02f, 2.04958804e-02f, -3.64041291e-02f, 3.08640227e-02f, -3.45476228e-03f, 1.28792718e-01f, 1.19280651e-01f, 1.79054625e-02f, 4.99967001e-02f, 1.53023437e-01f,
  1.07165426e-01f, 1.20180428e-01f, 5.67516824e-03f, 2.36188859e-01f, 2.04651877e-01f, 7.42050074e-03f, 9.23117176e-02f, 1.84815228e-01f, 1.93577275e-01f, -2.76361592e-03f,
  8.02367106e-02f, 1.22605516e-02f, -4.94520813e-02f, -4.32767682e-02f, 7.86630139e-02f, -3.03609227e-03f, -8.54751691e-02f, 6.07177243e-02f, -2.47853827e-02f, -7.30454251e-02f,
  -1.57992020e-02f, 1.60515402e-02f, 1.65245011e-02f, -1.04791783e-01f, 1.89387966e-02f, -8.81240666e-02f, -1.53366283e-01f, 3.34372930e-02f, 8.70081335e-02f, -1.27427801e-01f,
  -6.13592900e-02f, 8.88909549e-02f, -1.01725861e-01f, -3.85672189e-02f, 4.28004339e-02f, -8.06406364e-02f, 6.69246465e-02f, 3.38657424e-02f, 1.37579553e-02f, 1.45848095e-02f,
  -9.60919037e-02f, -1.55204803e-01f, -1.67770356e-01f, 5.27094007e-02f, 1.12462044e-02f, 6.14987910e-02f, -9.48868543e-02f, -4.23764549e-02f, -3.33256684e-02f, 1.70952994e-02f,
  9.13609341e-02f, 4.69409339e-02f, 1.96710210e-02f, 3.08238026e-02f, -6.50136992e-02f, 4.56385650e-02f, 6.39087930e-02f, -5.09611256e-02f, -3.33681144e-02f, -2.66899180e-04f,
  1.56945914e-01f, -4.43858206e-02f, -1.23135559e-02f, 8.93632621e-02f, 1.15889929e-01f, -1.17637813e-02f, 1.22024536e-01f, 1.48953646e-01f, 7.58844465e-02f, -1.18927313e-02f,
  5.27209759e-01f, 2.74663721e-03f, 3.50657344e-01f, 1.61411390e-01f, 2.05592647e-01f, 2.79861808e-01f, 2.29600728e-01f, -2.14555976e-03f, -5.07900007e-02f, 1.71212032e-01f,
  4.74773161e-02f, -5.38112931e-02f, -2.70599071e-02f, -3.75951305e-02f, -1.97867788e-02f, -3.54787596e-02f, 7.73478970e-02f, 2.62357354e-01f, 2.97989756e-01f, 2.61694372e-01f,
  2.80650575e-02f, -1.93659179e-02f, 2.27077216e-01f, 6.68356288e-03f, 1.37548083e-02f, -5.68433590e-02f, -1.92246512e-02f, 5.68067245e-02f, -1.26664490e-02f, 8.54605585e-02f,
  9.05213803e-02f, 1.45340458e-01f, -7.49801025e-02f, -7.41968825e-02f, -9.10562947e-02f, -9.90700275e-02f, -2.57023070e-02f, 7.19424039e-02f, -9.97803062e-02f, -1.36323452e-01f,
  -1.12984076e-01f, 7.89104998e-02f, 7.18115047e-02f, -8.21806043e-02f, -5.49815074e-02f, 2.72517428e-02f, -2.04250962e-02f, 2.43133381e-02f, -3.34645435e-02f, -8.89620557e-02f,
  -8.74096900e-02f, 1.06360495e-01f, 1.69891119e-01f, 3.00847478e-02f, 4.47885692e-03f, 6.59099743e-02f, 2.23864708e-02f, 8.05042684e-02f, 5.38752833e-03f, 1.15283683e-01f,
  6.99489564e-02f, 1.93839952e-01f, 1.25392228e-01f, 6.45841286e-02f, 6.07201681e-02f, -7.64825121e-02f, 7.00705722e-02f, 8.15426335e-02f, 1.57189667e-01f, 4.46201414e-02f,
  7.99544230e-02f, 1.12680987e-01f, 6.17728531e-02f, -2.77579445e-02f, 4.20176648e-02f, 4.79213558e-02f, -5.43769300e-02f, -7.02299178e-02f, -6.97020441e-02f, -4.16305885e-02f,
  3.35629731e-02f, 1.80560909e-02f, -7.95857757e-02f, 5.62095456e-02f, 6.45961910e-02f, 8.36902261e-02f, 9.06754285e-03f, -3.14204209e-02f, 3.31941918e-02f, 5.34283295e-02f,
  -3.71901929e-01f, -1.86388522e-01f, 8.44166651e-02f, -1.02355452e-02f, 3.12778503e-02f, -8.04551765e-02f, 8.24009907e-03f, 4.95433509e-02f, -1.13240875e-01f, -1.12948023e-01f,
  -7.26698861e-02f, -1.04863159e-02f, -8.35774094e-02f, 9.24375206e-02f, 4.24302667e-02f, 5.46076335e-03f, -5.48522286e-02f, 4.23058793e-02f, -7.22952411e-02f, 5.01453783e-03f,
  -1.24512494e-01f, 5.19708358e-02f, 1.45714730e-02f, 6.06704429e-02f, -8.07115808e-02f, 1.12494223e-01f, -3.60540152e-02f, 1.30285574e-02f, -2.12884657e-02f, 3.98021713e-02f,
  -1.17432244e-01f, 6.14826158e-02f, 2.20251456e-03f, 2.13837504e-01f, 2.05331787e-01f, -1.19790137e-02f, 9.23141688e-02f, 8.50725919e-02f, 9.32593197e-02f, 1.21369168e-01f,
  4.53840122e-02f, 1.37910634e-01f, 1.38734758e-01f, 1.45025879e-01f, 3.05827800e-03f, 1.91802725e-01f, 2.03389898e-01f, 1.18967958e-01f, 1.44253224e-02f, -3.01567167e-02f,
  1.04557417e-01f, -1.38770059e-01f, -2.03220561e-01f, -5.82585186e-02f, 1.27909899e-01f, 1.40012056e-01f, 2.46498710e-03f, -1.34385210e-02f, -6.09783567e-02f, 8.35465416e-02f,
  1.07894279e-01f, -1.77426994e-01f, 1.12535857e-01f, -2.26228982e-02f, -4.93181348e-02f, -8.96323025e-02f, -7.00297430e-02f, -1.02215275e-01f, 6.33184910e-02f, 9.91382748e-02f,
  -2.97900196e-02f, -1.33097902e-01f, -9.94780939e-03f, -1.45775139e-01f, -1.21312670e-01f, -2.99156383e-02f, -3.49988714e-02f, 3.76369548e-03f, 8.42786878e-02f, 8.19715038e-02f,
  1.27251029e-01f, -7.25017339e-02f, 2.74879299e-02f, 3.02757025e-02f, 1.91287696e-02f, -1.77662708e-02f, 4.59352657e-02f, 7.87084997e-02f, -2.35975832e-02f, -6.35828823e-02f,
  -3.67135406e-02f, -6.06189817e-02f, -1.38367787e-01f, -1.48984985e-02f, -5.98935001e-02f, -1.16189225e-02f, 8.51534903e-02f, 6.51734928e-03f, -1.04369327e-01f, -1.15638793e-01f,
  -1.64110437e-02f, -1.09841488e-01f, -3.21875997e-02f, 3.31668071e-02f, -7.01109022e-02f, -1.41656235e-01f, 6.75290227e-02f, 6.71892688e-02f, -1.49139479e-01f, -1.41911685e-01f,
  -3.34980786e-02f, 1.44047970e-02f, -9.93645564e-02f, -1.03561312e-01f, -1.22464575e-01f, -3.38874124e-02f, -6.76664189e-02f, -1.25663668e-01f, -7.42976367e-02f, -6.90172464e-02f,
  3.45418565e-02f, -8.94109085e-02f, 1.69356346e-01f, 3.58204208e-02f, -1.46945175e-02f, -6.59763590e-02f, 6.41598329e-02f, 1.40907064e-01f, 8.44141543e-02f, 6.13450408e-02f,
  -1.66821480e-02f, 4.97945733e-02f, -1.05411470e-01f, -1.24979369e-01f, -4.44152318e-02f, -3.75871593e-03f, 7.04732686e-02f, 7.78445154e-02f, 1.82352185e-01f, 1.07551239e-01f,
  1.82645038e-01f, 3.25132795e-02f, 7.86608458e-02f, 1.04562074e-01f, 1.02887675e-01f, 4.45568860e-02f, 1.08000666e-01f, 8.05651695e-02f, 1.73087977e-02f, -9.90210101e-02f,
  -2.67669946e-01f, -2.05561250e-01f, -2.17104405e-01f, -1.63723394e-01f, -4.93939966e-02f, 1.10434681e-01f, 6.11351170e-02f, 1.08163282e-01f, 1.71673112e-02f, -1.49381235e-01f,
  -5.36782630e-02f, 1.03340298e-01f, -2.08436102e-01f, -1.02315061e-01f, 3.86881456e-02f, -3.29862207e-01f, -3.00616801e-01f, -1.76417783e-01f, 2.28782415e-01f, 2.88376570e-01f,
  1.67337313e-01f, 6.26201630e-02f, 4.85861376e-02f, 8.78432244e-02f, 1.87974051e-02f, 3.92603874e-02f, -1.37928173e-01f, -1.15300551e-01f, -5.02193570e-02f, -4.29714710e-01f,
  -4.55880910e-01f, -3.43042240e-02f, 2.20960885e-01f, 1.26150638e-01f, 5.58769591e-02f, 9.64784920e-02f, 9.53963697e-02f, 1.92191735e-01f, 6.52858317e-02f, -1.90020204e-02f,
  7.35404715e-02f, 4.82977927e-02f, 5.57963066e-02f, 1.61254376e-01f, 2.72997543e-02f, 4.48515415e-02f, 2.74683982e-02f, -2.07839571e-02f, -1.24374088e-02f, 3.11784595e-02f,
  -8.45795050e-02f, -1.00332238e-01f, -1.96682900e-01f, 1.70203913e-02f, 2.27066688e-02f, -9.84961465e-02f, 4.05514892e-03f, 8.07434246e-02f, -4.74405512e-02f, -2.36501977e-01f,
  -1.90428626e-02f, 1.74331795e-02f, 3.84065919e-02f, 3.59596424e-02f, -6.94633871e-02f, -7.57465363e-02f, -6.75914660e-02f, -3.34373256e-03f, -9.21719801e-03f, -1.99424885e-02f,
  4.50338311e-02f, -5.30682430e-02f, 3.19247060e-02f, 9.35325120e-03f, -1.97995342e-02f, -9.22777317e-03f, -5.01731178e-04f, -7.34939575e-02f, -5.49119860e-02f, 5.32301292e-02f,
  3.94383483e-02f, -6.13730326e-02f, -1.41860127e-01f, 7.46659338e-02f, -1.10339085e-02f, 1.36356903e-02f, -1.62880309e-02f, 1.25486359e-01f, 7.50757605e-02f, 1.37672126e-02f,
  -1.38648108e-01f, -3.00452467e-02f, -1.91599816e-01f, 6.18963409e-03f, -3.90005969e-02f, 1.26529094e-02f, -2.30405003e-01f, 9.87350047e-02f, -4.91238125e-02f, 6.42639995e-02f,
  8.81243125e-02f, -1.66081786e-02f, -1.27677917e-01f, -1.44012226e-02f, 1.57877639e-01f, 1.24495409e-01f, -7.61819258e-02f, -1.29608721e-01f, 5.58572225e-02f, 5.81911393e-02f,
  -4.68061045e-02f, 3.50209437e-02f, -2.59950280e-01f, -1.19836926e-01f, -4.35169004e-02f, -1.15550317e-01f, -1.07757054e-01f, -1.39986366e-01f, -1.98287398e-01f, -1.07377410e-01f,
  9.26348045e-02f, 8.76101926e-02f, 2.37198219e-01f, 2.45870072e-02f, 6.13400005e-02f, -8.47014561e-02f, 7.24760965e-02f, 1.97837427e-02f, -4.61758906e-03f, 1.21212311e-01f,
  1.19537413e-01f, -2.74905026e-01f, -9.89300758e-02f, -4.40096594e-02f, 2.71090660e-02f, 1.06126644e-01f, 1.12774014e-01f, -5.86503297e-02f, -4.11528111e-01f, -2.41069332e-01f,
  -2.80778378e-01f, -1.44724205e-01f, -2.03401268e-01f, -2.32697595e-02f, 1.40100926e-01f, -1.75772041e-01f, 1.57010540e-01f, -2.54592467e-02f, -6.94000944e-02f, -3.57996114e-02f,
  1.31268203e-01f, 2.01086313e-01f, -5.54840788e-02f, -1.34590864e-01f, 4.90172654e-02f, -7.87920058e-02f, -6.81622028e-02f, -3.11015709e-03f, -7.55454674e-02f, -3.98568669e-03f,
  -1.85171917e-01f, -4.98592332e-02f, -2.36167952e-01f, -3.17402959e-01f, -1.75775200e-01f, -5.89919649e-03f, -1.43965676e-01f, -1.33371660e-02f, -5.23960590e-02f, -2.23695347e-03f,
  -2.22808450e-01f, -1.76456682e-02f, -9.85787343e-03f, 4.12732251e-02f, 9.95090883e-03f, -5.97806759e-02f, 9.16016027e-02f, 1.20980762e-01f, 1.53515622e-01f, 2.82911081e-02f,
  1.12882212e-01f, -5.63085079e-02f, 9.80375800e-04f, 1.47065029e-01f, -3.10029611e-02f, 3.85918431e-02f, -2.97781434e-02f, 1.18602747e-02f, -3.46229062e-03f, -1.31945193e-01f,
  2.73747984e-02f, 1.09356977e-01f, 1.49025828e-01f, 3.78615558e-02f, 2.41540149e-02f, 6.52501509e-02f, 4.62360606e-02f, -9.52571910e-03f, 3.32655199e-02f, 8.62648487e-02f,
  -3.31033990e-02f, 4.33360673e-02f, 5.15112504e-02f, -2.03848090e-02f, 3.97736020e-02f, 1.01723760e-01f, 8.81731808e-02f, -6.38680160e-02f, 8.39173496e-02f, 1.38682768e-01f,
  -6.57620728e-02f, 7.85980597e-02f, 4.25334536e-02f, -3.61047462e-02f, 1.09407276e-01f, 7.93487877e-02f, -3.44035737e-02f, -2.00353544e-02f, 7.31086954e-02f, -3.58954594e-02f,
  -1.11198872e-01f, 7.17183128e-02f, 2.58142818e-02f, -2.10253850e-01f, -1.81882888e-01f, -5.82728051e-02f, -2.03791022e-01f, -1.55725598e-01f, -7.76996687e-02f, -8.16688240e-02f,
  -5.38186217e-03f, -2.11762011e-01f, -2.32974589e-01f, -2.84491554e-02f, -1.13254383e-01f, -2.33969137e-01f, -1.94762602e-01f, 3.12544126e-03f, -3.21281999e-02f, -1.45396233e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.50666669e-01f, 1.95693672e-01f, 6.10387810e-02f, 8.38689059e-02f, -4.44200374e-02f, 7.68314600e-02f, -1.49150327e-01f, 2.32933104e-01f, 2.53018260e-01f, 1.55084506e-01f,
  1.24945119e-01f, 5.26264429e-01f, 1.59504637e-01f, 1.23954855e-01f, 1.33465335e-01f, 8.80080611e-02f, 2.28030741e-01f, 9.77634341e-02f, 2.47385263e-01f, 2.21917048e-01f,
  1.48130074e-01f, 1.82820529e-01f, 2.46673435e-01f, -9.57902223e-02f, 4.56959680e-02f, 1.47096545e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.02162907e-01f, -1.23415463e-01f, 8.11735094e-02f, 6.29732087e-02f, -7.54384473e-02f, 9.64583829e-02f, -1.30468821e-02f, 1.13615334e-01f, 9.12763178e-02f, 1.05895169e-01f,
  -2.06686482e-02f, 8.87670815e-02f, -3.69004346e-02f, 1.98266834e-01f, -2.82329191e-02f, -4.37190421e-02f, 7.96816126e-02f, 1.10319361e-01f, 5.26426248e-02f, -9.12921056e-02f,
  -7.27128983e-02f, -2.66160399e-01f, 6.76222965e-02f, -1.29505768e-01f, -1.15914727e-02f, 2.46434733e-01f, -2.35402416e-02f, 3.91347483e-02f, -1.55127972e-01f, 8.88037607e-02f,
  1.30669937e-01f, -1.58572435e-01f, -7.79688358e-02f, -4.85946685e-02f, -1.73487335e-01f, 7.59924203e-02f, -3.62270325e-03f, -7.26046646e-03f, -1.06515713e-01f, 3.65622729e-01f,
  1.32127516e-02f, -1.10141926e-01f, 2.07835808e-01f, 2.28735935e-02f, -1.13162503e-01f, -1.86008438e-01f, 1.51781394e-04f, -3.02511185e-01f, 2.67663866e-01f, 1.38280854e-01f,
  -1.13101102e-01f, 4.53504138e-02f, -8.00615363e-03f, -2.36795366e-01f, -1.43638730e-01f, 1.19508564e-01f, -5.08302674e-02f, -1.45560578e-01f, -6.11408874e-02f, 7.04202354e-02f,
  -1.56189844e-01f, -9.28770378e-02f, 1.99925914e-01f, 1.49002085e-02f, -3.87008721e-03f, -1.63056701e-01f, -1.83833041e-03f, 9.99378711e-02f, 9.05368105e-02f, -7.91713074e-02f,
  3.80389728e-02f, -1.22560866e-01f, 4.94579449e-02f, 4.38827239e-02f, 5.75269572e-02f, 8.95743445e-02f, -5.19814231e-02f, -3.63380164e-02f, 5.86187392e-02f, 1.12987466e-01f,
  8.40566978e-02f, 5.86623624e-02f, -1.11590378e-01f, 6.87282234e-02f, 9.59515944e-02f, 8.80648792e-02f, -4.84925471e-02f, -1.38816118e-01f, 7.14868531e-02f, -2.84247994e-01f,
  -4.64466475e-02f, -7.18960464e-02f, 1.40179321e-01f, -8.54520202e-02f, 1.38545232e-02f, 2.05170307e-02f, -1.14130296e-01f, -2.08897144e-01f, 1.04844049e-01f, 2.28763193e-01f,
  6.58585876e-03f, -2.40829110e-01f, -8.40528011e-02f, -2.34111980e-01f, -6.51416183e-02f, 8.11912641e-02f, -3.42513733e-02f, -1.61173269e-01f, -9.25248712e-02f, 4.02557962e-02f,
  2.22069860e-01f, -6.65923059e-02f, -1.71975717e-01f, -3.97086680e-01f, 3.29164028e-01f, -5.40535292e-03f, 2.71522373e-01f, 6.99074864e-02f, 7.69612612e-04f, 4.44970913e-02f,
  7.43131936e-02f, 1.20468356e-01f, -6.92142248e-02f, -8.61564837e-03f, 1.91662863e-01f, -1.69977561e-01f, -7.42186904e-02f, 9.91010144e-02f, 2.34523863e-01f, 9.81671214e-02f,
  -1.71199767e-03f, 9.69289914e-02f, -1.17468968e-01f, 7.35699609e-02f, 1.29942715e-01f, 9.08141434e-02f, -8.71017203e-02f, 1.43331131e-02f, 1.18144206e-03f, 1.49374515e-01f,
  1.07513174e-01f, 4.72965576e-02f, 1.33653991e-02f, -5.72237931e-02f, -7.66824558e-02f, 1.03307493e-01f, 1.56072140e-01f, -6.94938079e-02f, 1.52658284e-01f, 5.48190475e-02f,
  1.63036168e-01f, 1.98670588e-02f, 1.58351976e-02f, 3.31753157e-02f, -3.83248143e-02f, -8.31849128e-02f, 2.57333785e-01f, -1.04078148e-02f, 2.17407152e-01f, -1.31636322e-01f,
  -1.27255023e-01f, -2.76527613e-01f, 3.27607058e-02f, 8.25557951e-03f, -1.02352373e-01f, -1.84233427e-01f, 9.78234783e-02f, -6.41128421e-02f, -2.62024552e-01f, -5.32686599e-02f,
  -1.65037036e-01f, 7.78038334e-03f, -3.01572561e-01f, 2.57034361e-01f, 2.05952689e-01f, -1.24881893e-01f, 2.56070197e-02f, -1.54530827e-03f, 3.97940204e-02f, 1.42646685e-01f,
  -6.73276708e-02f, 2.75418192e-01f, -1.38685852e-01f, 4.70078588e-02f, -5.47834896e-02f, 7.46771544e-02f, -1.96386784e-01f, 1.64563328e-01f, 4.14007790e-02f, 3.33915800e-02f,
  -1.96301386e-01f, 2.77162760e-01f, 9.07097086e-02f, 1.33769870e-01f, -5.10485433e-02f, 9.22826603e-02f, -3.77008282e-02f, -2.58349013e-02f, 2.42958367e-01f, 8.39132518e-02f,
  1.60136018e-02f, 7.53138661e-02f, 1.23869866e-01f, 1.57054856e-01f, 1.63158178e-02f, 1.69636294e-01f, -1.74475327e-01f, 1.41561985e-01f, 3.57369669e-02f, 5.69090731e-02f,
  1.74769148e-01f, -3.79424803e-02f, -1.04806244e-01f, 6.58056438e-02f, -1.47099169e-02f, 8.49958062e-02f, 1.36348739e-01f, -1.97065827e-02f, 5.29725254e-02f, 3.67145874e-02f,
  1.17774708e-02f, 4.57668602e-02f, 1.63917691e-02f, 3.11819948e-02f, 5.00536151e-02f, 2.18167081e-02f, -1.52622432e-01f, 7.09610805e-02f, -1.12783210e-02f, 2.14232411e-02f,
  1.31702840e-01f, -1.63165674e-01f, 1.57193176e-03f, 5.72987050e-02f, -2.21673459e-01f, 8.68187249e-02f, 2.57137530e-02f, 9.12147313e-02f, 2.45466493e-02f, -2.11242199e-01f,
  2.59410262e-01f, 4.56968099e-01f, -1.52064011e-01f, -7.41690677e-03f, -9.16279778e-02f, 1.79302782e-01f, 6.43815845e-02f, -1.17107527e-02f, -2.34800518e-01f, 3.15351933e-02f,
  1.34417951e-01f, 2.98552006e-01f, -1.15710802e-01f, 1.84207574e-01f, 1.66288897e-01f, 2.14395076e-01f, 2.11072862e-01f, -5.35534113e-04f, 7.07023665e-02f, -1.34700954e-01f,
  2.16222070e-02f, -8.47761855e-02f, -9.70639586e-02f, -1.50633045e-02f, 2.26232428e-02f, -7.87832402e-03f, 6.44388795e-02f, -1.93067655e-01f, -5.07283285e-02f, 3.94443274e-02f,
  -7.24162236e-02f, -4.77837212e-02f, 5.34599610e-02f, -5.44799790e-02f, 8.90349969e-02f, 1.05277665e-01f, 2.00566798e-02f, 4.59714718e-02f, -3.52124050e-02f, 9.13653970e-02f,
  -4.01932001e-02f, 5.77498786e-02f, 9.06907916e-02f, -1.33083984e-01f, -1.39057830e-01f, 1.26751229e-01f, -1.94661647e-01f, 4.71900664e-02f, -1.72873884e-01f, 2.83382833e-01f,
  -8.70502070e-02f, 3.03062666e-02f, 9.56097767e-02f, 1.76617131e-01f, -1.02417789e-01f, 2.45544612e-02f, 1.99525267e-01f, -9.98566523e-02f, 1.56547084e-01f, -1.98969215e-01f,
  1.10190520e-02f, -7.71646574e-02f, -3.20749313e-01f, -6.13809237e-03f, 1.35032609e-01f, 1.42615587e-01f, -5.66359330e-03f, -8.82860795e-02f, 1.43539682e-01f, 1.54193938e-01f,
  -6.12586029e-02f, -9.07889828e-02f, -2.07853258e-01f, 1.80267558e-01f, 4.51395921e-02f, -6.20090365e-02f, -7.40350932e-02f, 1.61260784e-01f, 9.40393098e-03f, -1.08879499e-01f,
  -1.40039191e-01f, 8.43748450e-02f, -1.46387324e-01f, 1.84336770e-02f, -5.94818406e-03f, -3.34345214e-02f, 6.36174530e-03f, 3.73100452e-02f, 1.63328890e-02f, -4.38223444e-02f,
  -3.14224362e-02f, 5.90415448e-02f, 1.45280555e-01f, -3.37787904e-02f, 1.05394490e-01f, -2.86369771e-02f, 3.90559137e-02f, 1.01503752e-01f, -8.46027117e-03f, 4.36776178e-03f,
  1.33943036e-01f, 2.98794382e-03f, 6.30091578e-02f, 1.40347540e-01f, -8.11046138e-02f, -2.32351214e-01f, -1.19698443e-01f, 1.48528039e-01f, -3.06148767e-01f, -1.09554641e-01f,
  1.51127517e-01f, -1.19811177e-01f, 1.49768651e-01f, -2.35921800e-01f, 1.79664880e-01f, 2.28414275e-02f, 1.22768164e-01f, 2.58846171e-02f, -1.20327398e-01f, -3.24127125e-03f,
  7.84131512e-02f, 3.19898337e-01f, -3.21180075e-02f, 3.78881060e-02f, -1.82562098e-02f, 8.38822275e-02f, -4.92491908e-02f, 3.81008863e-01f, 1.12516060e-01f, -4.23973948e-01f,
  -2.07405597e-01f, 4.13576290e-02f, 4.36356850e-02f, -2.10100755e-01f, 2.32663572e-01f, -1.03422247e-01f, -1.10480282e-02f, -2.62822628e-01f, -1.42943412e-02f, -2.28302386e-02f,
  2.54847761e-02f, 7.60170296e-02f, 2.21910328e-01f, -1.69137046e-01f, 3.24952751e-02f, -1.10319406e-01f, -1.60002872e-01f, -1.78464428e-02f, -7.73308575e-02f, -2.78843679e-02f,
  9.29720551e-02f, 3.59160937e-02f, -1.32900421e-02f, 8.33826736e-02f, 9.80344117e-02f, -1.38681069e-01f, 5.37221972e-03f, -1.54619649e-01f, -8.25859085e-02f, 6.33777305e-02f,
  3.25095616e-02f, -4.43005227e-02f, 1.38621658e-01f, -5.63143529e-02f, -2.20267717e-02f, -5.46376919e-03f, -2.04721749e-01f, 2.35115632e-01f, 6.12659976e-02f, 1.69380993e-01f,
  -2.20548641e-02f, -1.88277945e-01f, 9.79788005e-02f, 9.78425592e-02f, -2.53899455e-01f, -1.93773545e-02f, 7.99228624e-03f, 2.73523748e-01f, -4.78936248e-02f, -1.85252074e-02f,
  -2.91835740e-02f, 2.49796420e-01f, -2.94266138e-02f, -7.58540928e-02f, 1.43244207e-01f, 1.03308842e-01f, 2.16778025e-01f, -9.96783897e-02f, -7.00006038e-02f, -1.00035712e-01f,
  -1.72922552e-01f, -1.54661685e-01f, 1.60731077e-01f, 2.75754273e-01f, -7.98539966e-02f, -2.24379718e-01f, 7.05377907e-02f, 5.54970764e-02f, -1.20577231e-01f, -1.52388122e-02f,
  -4.08868879e-01f, 4.11421880e-02f, 1.61624789e-01f, 1.75237015e-01f, -8.47069621e-02f, 1.20795801e-01f, -3.29120964e-01f, -1.26606718e-01f, 5.79330884e-02f, 4.94660288e-02f,
  7.06110671e-02f, -1.73501093e-02f, 1.21198282e-01f, 2.32028222e-04f, -6.99998625e-03f, 9.53133125e-03f, 5.37581816e-02f, 1.35373130e-01f, -1.18715040e-01f, -5.43303192e-02f,
  -5.04805408e-02f, 8.03430565e-03f, 2.51007732e-03f, 1.97218746e-01f, 7.03400075e-02f, -5.37450612e-03f, -5.55080660e-02f, 8.02422240e-02f, 4.26571630e-02f, -1.87754985e-02f,
  -1.07073434e-01f, 1.26759276e-01f, -6.06194437e-02f, -1.03805453e-01f, 6.44807797e-03f, -1.55115426e-01f, 3.26342806e-02f, 2.57161446e-02f, -9.10883620e-02f, 1.00696459e-02f,
  9.12114978e-03f, 2.16646299e-01f, 1.12927012e-01f, -5.78195602e-02f, -6.38760254e-02f, 1.30025446e-01f, -7.05354102e-03f, -2.91647501e-02f, 5.12199365e-02f, -1.45215586e-01f,
  -7.72707611e-02f, -1.33695796e-01f, 1.41104460e-01f, -1.22182921e-01f, -2.07435876e-01f, 6.60967380e-02f, -1.75241768e-01f, 1.51616499e-01f, 6.20657839e-02f, -3.56191234e-03f,
  1.29845114e-02f, 8.46988410e-02f, -5.61730899e-02f, 7.23630264e-02f, -1.97993338e-01f, 9.87549722e-02f, 1.53914958e-01f, -2.17147350e-01f, -2.68429331e-02f, 1.46386683e-01f,
  -8.52371454e-02f, -7.14612603e-02f, -1.25966534e-01f, 7.77013600e-02f, -8.16372037e-03f, 1.07393175e-01f, 1.10207655e-01f, -4.17242758e-02f, -1.69568092e-01f, -8.56115967e-02f,
  4.83518839e-02f, -5.51240332e-02f, -5.88354878e-02f, 3.22895683e-03f, 1.29287867e-02f, 6.19342513e-02f, 1.44858554e-01f, 7.73027539e-02f, 5.69696687e-02f, 2.72493325e-02f,
  -1.76873118e-01f, -9.78638455e-02f, -7.44633526e-02f, 4.08197716e-02f, 4.42383476e-02f, -1.26534238e-01f, -2.98881289e-02f, -4.36551094e-01f, 3.26071703e-03f, 1.75038710e-01f,
  -2.90119767e-01f, -2.38945007e-01f, 2.62428641e-01f, 1.48713952e-02f, 1.40945166e-01f, -3.39097470e-01f, 1.43452331e-01f, -6.46736473e-02f, 8.35582167e-02f, -1.34146824e-01f,
  -8.82556885e-02f, 2.03854755e-01f, 9.48984772e-02f, 1.21904433e-01f, 1.71712588e-03f, -2.43456196e-02f, -9.14436113e-03f, 2.87120193e-02f, -1.08473673e-01f, 2.10577279e-01f,
  3.71883176e-02f, -3.10757279e-01f, -5.55195883e-02f, -3.36239710e-02f, -1.44224241e-01f, -2.09936082e-01f, 2.02992707e-02f, 4.64600101e-02f, 5.51830940e-02f, -5.04192673e-02f,
  4.82774451e-02f, -1.02416486e-01f, -1.72863171e-01f, 1.00461043e-01f, 2.21794784e-01f, -7.20497966e-02f, 4.88884039e-02f, 8.77927393e-02f, -6.38815984e-02f, -7.78905023e-03f,
  3.21839601e-02f, 3.61674577e-02f, 8.10420364e-02f, -5.78273088e-02f, 1.74926385e-01f, 9.07685235e-02f, -1.49705149e-02f, 1.41124547e-01f, 1.06638083e-02f, 1.42649770e-01f,
  -7.20488727e-02f, 5.73935397e-02f, -1.07899733e-01f, -7.25361779e-02f, -1.57618254e-01f, 9.12299678e-02f, 9.11413357e-02f, 1.82700545e-01f, -1.31698295e-01f, 2.04181112e-02f,
  1.58601508e-01f, -1.96059361e-01f, 3.62676941e-02f, 1.39434345e-03f, -1.67794824e-01f, -7.14946585e-03f, -1.51496083e-02f, 5.29873297e-02f, -1.80166483e-01f, -7.59295747e-02f,
  1.54487088e-01f, -5.27187251e-02f, 1.60075575e-02f, -1.54925868e-01f, -1.00919083e-01f, -8.97369236e-02f, -9.78024527e-02f, -9.97559726e-02f, -2.39482164e-01f, -2.86797378e-02f,
  -1.74380422e-01f, -8.98358151e-02f, -1.27829224e-01f, 1.51453882e-01f, -2.39010543e-01f, -2.14243561e-01f, 2.51821816e-01f, 1.79515466e-01f, 1.55136824e-01f, 2.10403219e-01f,
  -4.73886244e-02f, 4.18845788e-02f, 1.20849445e-01f, 8.00737739e-02f, 1.10601090e-01f, -3.01680863e-01f, -3.44712287e-02f, -8.26320723e-02f, 6.25906885e-02f, 4.58645709e-02f,
  -7.00098947e-02f, 6.64357515e-03f, -5.51276617e-02f, 1.74271315e-01f, -1.62992686e-01f, 5.52268811e-02f, 1.28568634e-01f, 5.27013205e-02f, -6.57796040e-02f, -8.24543610e-02f,
  7.77161941e-02f, 1.43970892e-01f, 1.18583091e-01f, 1.01403385e-01f, 1.49294272e-01f, -1.25955403e-01f, -4.21005897e-02f, 5.57694361e-02f, -2.31544133e-02f, 7.57619971e-03f,
  3.79179977e-02f, -2.29593098e-01f, 1.58795640e-01f, -2.37092733e-01f, 1.11924477e-01f, -6.12026639e-02f, -1.12440616e-01f, 1.77707180e-01f, 4.28963043e-02f, -7.74343014e-02f,
  2.31042519e-01f, -1.24276146e-01f, 3.03321797e-02f, -2.32966200e-01f, -5.39475167e-03f, 6.49255067e-02f, 3.27979624e-02f, -2.29802847e-01f, 8.27632546e-02f, -1.15829222e-01f,
  -1.72347441e-01f, -1.83825940e-01f, -3.09183359e-01f, 3.48661989e-01f, -1.70357272e-01f, 1.39595091e-01f, 2.09212020e-01f, -1.24816179e-01f, 3.40269096e-02f, 1.08185939e-01f,
  1.51122048e-01f, 1.62770003e-01f, 7.27291685e-03f, -1.68461025e-01f, 1.26379938e-03f, 4.89122001e-03f, 1.13639273e-01f, -1.05475344e-01f, -1.78634018e-01f, 2.42045969e-02f,
  -3.60883144e-03f, -1.12498604e-01f, 2.39232123e-01f, 2.34950185e-01f, -4.18892410e-03f, 7.58700967e-02f, 2.67449394e-02f, 6.41763257e-03f, 1.60497025e-01f, 2.58333678e-03f,
  1.75345074e-02f, 8.54692534e-02f, 8.63344520e-02f, 7.46545792e-02f, 8.75691995e-02f, 7.45136105e-03f, 1.75643280e-01f, -1.13845065e-01f, 9.65788811e-02f, 5.42106554e-02f,
  7.89807662e-02f, 5.86701035e-02f, -1.38514163e-02f, -7.09473789e-02f, -1.84234958e-02f, 3.66569981e-02f, -7.85721764e-02f, 1.59628570e-01f, -1.30452976e-01f, -1.07317179e-01f,
  2.94923559e-02f, -4.98865880e-02f, -3.68323401e-02f, -6.59287944e-02f, -1.58214092e-01f, 1.07643433e-01f, 5.88607369e-03f, 3.66215631e-02f, 9.22442451e-02f, -4.27000709e-02f,
  1.87548608e-01f, 6.53182715e-02f, 2.18759980e-02f, -5.81687652e-02f, 3.71762455e-01f, 4.34544459e-02f, -1.17849363e-02f, -1.64982021e-01f, 1.26836061e-01f, 9.74289998e-02f,
  -6.62918314e-02f, 1.38530165e-01f, -1.60401508e-01f, 3.44521645e-03f, -8.97181332e-02f, 1.01674516e-02f, -2.55919304e-02f, -5.01823053e-03f, 4.40489352e-02f, -1.82429682e-02f,
  -1.50194749e-01f, 1.52356457e-02f, 2.02474654e-01f, -2.70676941e-01f, 9.09509882e-02f, 1.81095228e-01f, 2.14371644e-02f, -1.71211138e-01f, -2.02097729e-01f, -1.49633572e-01f,
  -1.39964774e-01f, -7.26006106e-02f, -4.00068462e-02f, -5.00145815e-02f, -8.38106126e-02f, -2.82703321e-02f, 4.69332486e-02f, -7.12385550e-02f, 1.04518972e-01f, -6.33631200e-02f,
  2.35038884e-02f, -1.93435475e-02f, 1.36457413e-01f, 6.13604523e-02f, 3.86492461e-02f, -1.89369529e-01f, -1.45691752e-01f, -1.13374598e-01f, 7.99608454e-02f, -6.65360689e-03f,
  1.58789650e-01f, 3.80472876e-02f, -1.80938363e-01f, -4.87741493e-02f, 1.02981053e-01f, -6.20594099e-02f, -6.31585281e-05f, 2.74371915e-02f, -5.63880093e-02f, -1.09356001e-01f,
  1.39561996e-01f, -2.13515125e-02f, -1.69194266e-01f, 1.40063077e-01f, 1.50653556e-01f, 1.16517842e-01f, -1.68080430e-03f, 2.58923858e-01f, 1.28561214e-01f, 1.29987359e-01f,
  8.10522810e-02f, 1.92517698e-01f, 4.15707799e-03f, -3.96920480e-02f, 2.50136829e-04f, 8.47979113e-02f, 1.53997660e-01f, -1.74189717e-01f, -6.21334203e-02f, -2.34655336e-01f,
  6.14662878e-02f, -2.03616410e-01f, -7.59660155e-02f, 7.07064793e-02f, -9.41062048e-02f, -2.06486434e-01f, 2.03980193e-01f, 2.07594156e-01f, -9.01817828e-02f, 1.29579201e-01f,
  2.13672608e-01f, -2.51514256e-01f, -5.69899306e-02f, 1.33381458e-02f, -3.52635235e-02f, 2.97570638e-02f, -8.55824798e-02f, 1.08256213e-01f, -7.76678615e-04f, 1.52297840e-01f,
  1.01694837e-02f, 6.85997158e-02f, 7.61279762e-02f, 4.84370068e-02f, 2.14459971e-02f, 4.37858095e-03f, 6.64968640e-02f, 7.37571297e-03f, 4.53162380e-02f, 2.47962251e-02f,
  2.95742676e-02f, -1.48884401e-01f, 2.04359386e-02f, -2.16801032e-01f, 1.09818697e-01f, 9.60028023e-02f, -2.03984916e-01f, 1.88488290e-01f, 6.48523718e-02f, 6.44093603e-02f,
  -7.94049650e-02f, 1.23242818e-01f, -2.08475918e-01f, -8.70011896e-02f, 1.62849873e-01f, 2.63761371e-01f, -7.36120716e-02f, -1.42753944e-01f, 3.13322335e-01f, 5.40303811e-02f,
  -4.44644429e-02f, 2.90432930e-01f, 2.88914561e-01f, 1.07105352e-01f, 1.24018319e-01f, 1.71983078e-01f, -5.31040169e-02f, 2.28747522e-04f, -1.60934418e-01f, 1.86943840e-02f,
  1.80222213e-01f, 4.65559304e-01f, -2.64211297e-01f, -2.14142695e-01f, -5.00467345e-02f, -2.91750044e-01f, 5.24518779e-03f, -1.51137367e-01f, -1.97817266e-01f, -2.65418947e-01f,
  1.09056152e-01f, 1.26104057e-01f, 2.84506287e-02f, -1.14045113e-01f, 1.81890488e-01f, -1.59448728e-01f, -6.13541715e-02f, -5.25090136e-02f, 9.28138718e-02f, -2.11700499e-02f,
  -1.50497943e-01f, 5.42435050e-02f, -2.29358271e-01f, -3.80269550e-02f, -1.00634173e-01f, 1.04574330e-01f, -4.64027077e-02f, 1.72899552e-02f, -9.06628817e-02f, -1.26475850e-02f,
  1.19273253e-01f, 8.19216445e-02f, 4.05753814e-02f, -6.17241748e-02f, -6.51421323e-02f, 2.81366017e-02f, 8.69984701e-02f, 7.06687244e-03f, 2.02486709e-01f, 2.01289251e-01f,
  -1.60419628e-01f, -1.14511140e-01f, 7.90827945e-02f, 1.71656862e-01f, -9.30123106e-02f, 1.60705615e-02f, -1.12912379e-01f, -1.75314307e-01f, 9.59267616e-02f, -3.22260894e-02f,
  1.48200970e-02f, -2.38342211e-03f, 2.43601546e-01f, 2.40478039e-01f, -8.84941369e-02f, 2.85966128e-01f, 1.86017096e-01f, -3.41088586e-02f, 1.48403078e-01f, 1.34751916e-01f,
  1.25930294e-01f, -4.19883579e-02f, -1.35910243e-01f, 1.19472541e-01f, 1.83459505e-01f, -1.95558771e-01f, -3.13444436e-01f, -1.47044677e-02f, -1.85735762e-01f, -2.35624909e-01f,
  -2.11484395e-02f, -1.44754797e-01f, 1.66175216e-02f, -5.61281182e-02f, -9.31280851e-02f, -2.19531525e-02f, 1.09326644e-02f, 5.94073683e-02f, 1.43120244e-01f, -1.79262415e-01f,
  -1.38140544e-01f, 6.48519173e-02f, 3.28109115e-02f, 5.73541820e-02f, 2.20667288e-01f, -8.55124071e-02f, -1.34004369e-01f, -5.69981635e-02f, 1.01653315e-01f, -1.40548602e-01f,
  -5.47769144e-02f, -6.99523184e-03f, 2.46512592e-02f, -2.87832208e-02f, -1.66717917e-01f, 7.46004358e-02f, 5.54899946e-02f, -1.34775922e-01f, -7.33775124e-02f, 1.78345203e-01f,
  -4.00394872e-02f, 8.62152576e-02f, -2.82713532e-01f, -9.67666581e-02f, 8.43348354e-02f, -3.47339213e-01f, -9.53872055e-02f, 8.78653601e-02f, -2.07385972e-01f, -6.48942888e-02f,
  -1.58587813e-01f, 5.83719015e-02f, 1.77399427e-01f, 2.10443944e-01f, -4.19339612e-02f, -2.33270183e-01f, 8.47742776e-04f, -2.61392564e-01f, -1.04959704e-01f, -1.28730699e-01f,
  1.51588857e-01f, 7.89141953e-02f, -2.43230298e-01f, -4.97257896e-02f, 5.40430062e-02f, -2.97922324e-02f, -9.19414684e-02f, 3.70815665e-01f, -2.21813872e-01f, 4.90059294e-02f,
  4.17084321e-02f, 1.65067136e-01f, -6.70123696e-02f, -8.74487162e-02f, 2.01003805e-01f, 1.52499035e-01f, 4.90382053e-02f, 9.40549076e-02f, 4.03212458e-02f, -2.83621252e-01f,
  8.01406205e-02f, -4.61102426e-02f, 5.46316318e-02f, -3.23094465e-02f, 3.34275104e-02f, 8.74129534e-02f, 9.91319045e-02f, 1.37426138e-01f, 2.22408384e-01f, 8.61502215e-02f,
  2.39676265e-05f, -5.06076477e-02f, 9.99023393e-02f, 1.71366215e-01f, -4.80404161e-02f, -5.07806288e-03f, -4.27778438e-02f, 2.07498297e-02f, -3.56170209e-03f, 1.22909285e-01f,
  5.41075170e-02f, 3.10270824e-02f, 2.98817605e-02f, -1.00563861e-01f, 1.16715934e-02f, 5.75699881e-02f, -3.85705233e-02f, 9.79360268e-02f, -1.05357684e-01f, 6.68050945e-02f,
  -1.71570033e-02f, 4.14476767e-02f, -3.40215117e-01f, 1.11022532e-01f, -3.43624055e-02f, 3.84996198e-02f, -1.06787905e-01f, 2.12093934e-01f, -2.11451128e-02f, 5.56969717e-02f,
  -3.88698131e-02f, 1.98412195e-01f, -1.71597406e-01f, 9.87399071e-02f, 2.60077029e-01f, -7.64426142e-02f, 1.74832523e-01f, -2.75246263e-01f, 2.39479557e-01f, -9.96598750e-02f,
  -1.09128386e-01f, -4.92091887e-02f, -1.14349283e-01f, 2.28671469e-02f, -2.01936603e-01f, -1.68245137e-01f, 1.71315759e-01f, 9.43235084e-02f, -5.31689376e-02f, -5.86104691e-02f,
  -5.68442345e-02f, 1.29589319e-01f, 1.96227115e-02f, -1.64245367e-01f, -9.25351232e-02f, -4.70588282e-02f, -1.79164842e-01f, -3.46884787e-01f, 2.26269886e-01f, 1.30668759e-01f,
  1.87073965e-02f, -2.21195519e-02f, 3.39252234e-01f, 2.07150057e-01f, 1.77447215e-01f, 7.12612420e-02f, 2.82126904e-01f, 5.30958027e-02f, -1.37378976e-01f, -5.34245074e-02f,
  3.46548185e-02f, -5.50000221e-02f, 1.85834970e-02f, 1.83138907e-01f, 6.91789240e-02f, 1.84525028e-01f, 3.52682769e-02f, -2.74084173e-02f, -3.52640636e-02f, 1.54031217e-01f,
  -7.96741769e-02f, 2.49852240e-01f, 6.74219280e-02f, -2.39820614e-01f, -9.15401790e-04f, 1.32758939e-03f, -2.64906347e-01f, -1.50332022e-02f, -1.47632763e-01f, 5.65360151e-02f,
  -1.09826826e-01f, -4.53001671e-02f, 2.43918583e-01f, -1.16517045e-01f, -4.35813479e-02f, 2.46180985e-02f, -1.76821053e-01f, 4.85335290e-02f, 7.71889612e-02f, 1.73909694e-01f,
  -2.48441860e-01f, -2.32091933e-01f, -1.84766874e-01f, 1.34407416e-01f, -1.12569921e-01f, -1.65550888e-01f, -1.47583425e-01f, -1.63703293e-01f, 1.19793758e-01f, 6.66626617e-02f,
  -6.55182377e-02f, -2.16738526e-02f, -1.19023561e-01f, -2.59975076e-01f, -2.46912971e-01f, -2.60052551e-02f, 6.30712882e-02f, 5.81522472e-02f, -9.41878110e-02f, -7.26259500e-02f,
  -2.28960216e-01f, 1.33290231e-01f, 1.79794952e-01f, 1.96587350e-02f, -4.02254276e-02f, 7.39040896e-02f, -1.26876488e-01f, -5.82421683e-02f, 1.85306117e-01f, 4.61662188e-02f,
  4.82172258e-02f, -1.76799241e-02f, 1.28145153e-02f, 1.87199160e-01f, 1.72309607e-01f, 2.41786659e-01f, 5.22657447e-02f, 4.18170318e-02f, 1.80108130e-01f, 1.12177730e-01f,
  6.11207308e-03f, 2.83973902e-01f, -1.11105338e-01f, -2.54569035e-02f, -1.16895624e-01f, -1.13034800e-01f, 2.65226603e-01f, 8.62126201e-02f, 8.29614699e-02f, -1.05016433e-01f,
  2.49789972e-02f, -1.06422827e-01f, 1.23208240e-01f, 1.70944706e-01f, 2.64273770e-02f, -2.44640514e-01f, -3.06464713e-02f, 1.92579776e-01f, -7.03570247e-02f, -9.38007310e-02f,
  1.11248232e-01f, -2.44963214e-01f, -2.79622644e-01f, -1.17145933e-01f, -2.07576811e-01f, 1.49015740e-01f, -1.65838063e-01f, -7.60440305e-02f, 7.64886960e-02f, -1.98159471e-01f,
  -6.41144291e-02f, 5.20662181e-02f, 2.40747139e-01f, 1.26414925e-01f, 1.21204562e-01f, 1.25134617e-01f, 7.75144026e-02f, -8.45678151e-02f, 2.03439832e-01f, 2.49840111e-01f,
  9.69538279e-03f, 3.53095271e-02f, -2.12276503e-02f, -1.42628342e-01f, -5.73014934e-03f, 2.39159316e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.78290394e-02f, 2.06060335e-02f, -3.49182710e-02f, -6.16399460e-02f, 2.77138129e-02f, 2.75058717e-01f, 1.03467293e-01f, -2.04926115e-02f, -2.01371480e-02f, 2.13811249e-01f,
  9.40551460e-02f, -6.63810596e-02f, 3.29406932e-03f, -9.09562856e-02f, 6.82534873e-02f, 8.80033672e-02f, 2.28533465e-02f, 1.19508401e-01f, 5.64506054e-02f, -2.03789502e-01f,
  -1.29375968e-03f, -2.33164325e-01f, 2.37640440e-01f, 3.76099497e-01f, -4.70448062e-02f, -7.14101642e-02f, -9.89447236e-02f, 1.77890360e-01f, -3.86780836e-02f, 1.20131724e-01f,
  7.60769621e-02f, -2.09128588e-01f, 2.45540053e-01f, -2.49662399e-01f, 1.94836542e-01f, -1.53885722e-01f, 4.40824807e-01f, 2.58260846e-01f, -6.75250813e-02f, 1.92464724e-01f,
  3.42496991e-01f, 1.56779975e-01f, 1.55836895e-01f, 1.10811749e-02f, 8.48366842e-02f, 1.29951358e-01f, 3.06526804e-03f, 2.48639658e-01f, 1.71145871e-01f, -1.56778738e-01f,
  -3.49377394e-01f, -1.25587592e-03f, 5.63285723e-02f, -2.31595173e-01f, 2.13614389e-01f, -7.15769976e-02f, -8.35808814e-02f, -1.46279827e-01f, -1.99195351e-02f, 4.74057794e-02f,
  1.85724661e-01f, -1.11205690e-02f, -1.64343402e-01f, -1.15179159e-02f, 1.77037910e-01f, 1.35302007e-01f, 6.84028640e-02f, -6.05535917e-02f, 3.59015204e-02f, 1.34824812e-01f,
  1.66271657e-01f, 1.29723161e-01f, 1.33798003e-01f, 1.99376523e-01f, 1.83328129e-02f, 7.30656013e-02f, 5.17779924e-02f, -4.41315398e-02f, -3.46915075e-03f, 6.64434657e-02f,
  2.46828556e-01f, 1.75665066e-01f, 1.45115331e-01f, -1.78318676e-02f, -1.05309226e-01f, 2.57199824e-01f, -1.79305539e-01f, -3.26070450e-02f, -1.09930612e-01f, 2.85668641e-01f,
  1.57870054e-01f, -6.91238716e-02f, -5.91915194e-03f, 3.16324621e-01f, -2.27382481e-01f, 2.93714374e-01f, -5.79881109e-02f, 3.67771834e-01f, -1.39951736e-01f, 9.56296325e-02f,
  -2.91392744e-01f, 1.28699034e-01f, 4.14426863e-01f, 1.87230811e-01f, 4.14270610e-02f, -1.79513127e-01f, 1.62807018e-01f, 1.62946194e-01f, -5.12333214e-02f, -2.33103469e-01f,
  -1.29373595e-01f, 2.97180824e-02f, 8.00467655e-02f, 4.10665363e-01f, -2.55484939e-01f, -1.03484668e-01f, 9.92398560e-02f, 3.83179970e-02f, -2.37026155e-01f, 9.65175480e-02f,
  2.75799930e-01f, 3.74637783e-01f, 6.66377023e-02f, -1.23269238e-01f, -7.33057931e-02f, 6.27133623e-02f, -1.81566051e-04f, 2.65361276e-02f, -9.89993140e-02f, 8.83631334e-02f,
  -7.53147453e-02f, -2.38754153e-01f, -6.81035873e-03f, -3.93481366e-02f, -4.85033877e-02f, 3.11723985e-02f, -9.19854641e-02f, -1.57924548e-01f, -2.29617447e-01f, -2.49212429e-01f,
  -6.44217506e-02f, 1.87718421e-02f, -3.68022323e-01f, -1.19888619e-01f, 5.97475842e-02f, -4.89869416e-02f, -1.58111244e-01f, -3.52243595e-02f, 4.59164567e-02f, 4.19092998e-02f,
  1.34526968e-01f, -1.02375433e-01f, 7.32029080e-02f, 4.64761145e-02f, -7.40704685e-02f, -5.28425053e-02f, 1.22565888e-02f, -1.35576442e-01f, 1.63549885e-01f, 3.58635783e-02f,
  -3.92026827e-02f, 7.95674101e-02f, 1.43927215e-02f, 1.24613091e-01f, -5.31706512e-02f, -1.55079430e-02f, -8.58721510e-02f, -4.71789716e-03f, 1.71841457e-02f, 5.30636795e-02f,
  -3.05796769e-02f, -4.86701988e-02f, 1.25768393e-01f, -3.60878080e-01f, -1.12481035e-01f, -1.20647706e-01f, 1.10786974e-01f, 9.10618901e-02f, 2.25967824e-01f, -9.99099016e-02f,
  2.68218815e-01f, 8.37641880e-02f, 1.28661856e-01f, -1.34004995e-01f, -5.63669018e-02f, -1.94187507e-01f, -2.75694668e-01f, 6.88978564e-03f, 5.53836934e-02f, -1.09979093e-01f,
  4.23165746e-02f, 1.19769182e-02f, 1.39749376e-02f, 1.32245079e-01f, 1.33563101e-01f, 2.12442160e-01f, -7.00090379e-02f, -2.49167345e-03f, 1.84898466e-01f, -9.86373145e-03f,
  8.56635571e-02f, 1.92562789e-01f, 2.19861045e-01f, 1.45050868e-01f, 1.11132406e-01f, 4.10169438e-02f, 1.04545765e-01f, 1.17186569e-02f, 1.01768244e-02f, -1.08192869e-01f,
  3.02190334e-01f, -3.07212397e-02f, -2.17633322e-02f, -7.52062947e-02f, -6.77462742e-02f, -7.28774443e-02f, 2.14804411e-01f, -1.49420857e-01f, 2.61843316e-02f, 7.21345237e-03f,
  -1.24791767e-02f, -2.06252992e-01f, -9.88106132e-02f, -3.02835613e-01f, 1.11349272e-02f, 5.23150414e-02f, -5.05674034e-02f, -1.65862530e-01f, 2.83817708e-01f, -8.32052007e-02f,
  -1.71510115e-01f, -2.14157421e-02f, 1.59287602e-01f, 7.72908553e-02f, -1.70451522e-01f, 1.17197730e-01f, 1.34540394e-01f, -1.07223503e-01f, 5.19366376e-02f, 1.20489307e-01f,
  2.92123049e-01f, 4.63411868e-01f, 1.88543200e-01f, 2.52645284e-01f, 1.20188653e-01f, 1.55484498e-01f, 3.11203331e-01f, -8.11060832e-04f, -1.85766220e-01f, -1.27068341e-01f,
  -1.07238501e-01f, 2.17837393e-01f, 2.38121986e-01f, -2.98395436e-02f, 7.16483174e-03f, 3.45098436e-01f, 1.76108778e-02f, 1.43294677e-01f, 3.13356906e-01f, -5.23679750e-03f,
  3.04820955e-01f, 1.69437662e-01f, 3.06676105e-02f, 6.47231936e-02f, 1.31351382e-01f, 1.55068696e-01f, 2.12495606e-02f, 1.05174616e-01f, 1.31632239e-01f, 9.90759134e-02f,
  1.81803659e-01f, 1.53653309e-01f, 1.06726840e-01f, 2.28078067e-01f, 1.37075588e-01f, 1.75947234e-01f, 1.29879951e-01f, 1.16484374e-01f, -3.02643448e-01f, 2.56988615e-01f,
  -1.15324341e-01f, -3.55346084e-01f, 3.20813917e-02f, 2.83090830e-01f, -2.96544999e-01f, -7.27430359e-02f, -9.53727365e-02f, 1.60574302e-01f, -2.00868631e-03f, 4.14248332e-02f,
  2.16095343e-01f, -8.07871222e-02f, -1.15318187e-01f, -8.55088159e-02f, 1.48932397e-01f, 1.45831138e-01f, 3.78017515e-01f, 3.55112314e-01f, -1.24769688e-01f, -6.88004643e-02f,
  4.97128777e-02f, 1.46463796e-01f, -3.12279403e-01f, 4.54581708e-01f, -1.22248642e-01f, -1.41590744e-01f, -3.24917361e-02f, 4.45299111e-02f, 4.85662147e-02f, 5.96055128e-02f,
  2.99663879e-02f, -2.48233490e-02f, 1.90055221e-01f, 2.97206759e-01f, 2.67499566e-01f, -6.18054681e-02f, -6.82733506e-02f, 1.21537670e-01f, 1.46885067e-01f, -6.64416552e-02f,
  3.10497373e-01f, 3.51120234e-02f, 2.41336167e-01f, 2.71908846e-02f, 1.53643042e-01f, -7.49830455e-02f, 1.16395645e-01f, 9.65508446e-02f, -3.39621529e-02f, -4.74460535e-02f,
  -3.18604745e-02f, 4.57183085e-02f, 1.65235922e-01f, 1.93340614e-01f, -4.02937084e-02f, 1.01138011e-01f, -7.07708597e-02f, 1.91405546e-02f, 2.50452697e-01f, -6.52452782e-02f,
  -1.07766867e-01f, 5.87000847e-02f, -1.53488040e-01f, 2.96815652e-02f, 3.36352766e-01f, 1.78035304e-01f, 6.19351193e-02f, -2.27865398e-01f, 2.74194330e-01f, -1.20740645e-01f,
  3.89068462e-02f, 6.96821734e-02f, -3.92363034e-02f, -3.20984840e-01f, -1.40432417e-01f, -3.61860320e-02f, -2.67305523e-01f, -9.30005237e-02f, 9.26704481e-02f, -7.96640888e-02f,
  -1.05309047e-01f, -1.88572958e-01f, -2.21957624e-01f, -8.37147981e-02f, -1.67207524e-01f, 6.67125657e-02f, 3.81561965e-01f, 4.95812446e-02f, 4.37730998e-02f, 1.04009934e-01f,
  2.35178962e-01f, 2.09682137e-01f, 6.88070729e-02f, 2.62109280e-01f, 3.51970866e-02f, 5.14764301e-02f, 5.97061962e-02f, 1.55756459e-01f, -2.21284062e-01f, 1.19241700e-01f,
  1.40852615e-01f, -3.49437386e-01f, -8.43003467e-02f, 2.58964390e-01f, 8.19535926e-02f, 1.08570613e-01f, -1.17810667e-01f, 7.65556395e-02f, 6.04201928e-02f, -8.35275948e-02f,
  1.27681673e-01f, -6.88022673e-02f, 6.84354231e-02f, 7.51308426e-02f, -5.47535494e-02f, 8.18281546e-02f, -3.55201960e-02f, 2.04118997e-01f, -2.63857186e-01f, -1.42555088e-02f,
  3.32467295e-02f, -2.43152939e-02f, 1.35178506e-01f, -9.35229883e-02f, 5.25809601e-02f, -8.56757239e-02f, 2.67017484e-02f, -1.29585862e-01f, 1.23155214e-01f, 2.43292954e-02f,
  9.32847783e-02f, -3.76157872e-02f, 9.39189568e-02f, -2.02310354e-01f, -7.29844719e-02f, 2.99085374e-03f, -6.73618987e-02f, 5.51480614e-02f, 1.31025508e-01f, 5.27834054e-03f,
  1.18600346e-01f, 6.39394000e-02f, -2.04230428e-01f, -2.00819671e-01f, -1.21430703e-01f, -4.90613937e-01f, -4.96758297e-02f, -2.21424177e-01f, 1.21866047e-01f, -7.43916333e-02f,
  4.41369116e-02f, -2.06927992e-02f, 8.46261457e-02f, 1.55880541e-01f, 3.25752228e-01f, 1.55314147e-01f, 1.64251015e-01f, 3.28820258e-01f, 3.38172108e-01f, 1.25498101e-01f,
  -4.96495187e-01f, -2.06279024e-01f, 1.03321284e-01f, 7.47045651e-02f, 8.64102170e-02f, 1.72590509e-01f, -2.31787041e-01f, 2.25406379e-01f, -4.42082174e-02f, -1.13941669e-01f,
  2.36705810e-01f, 2.30122581e-01f, 2.64134333e-02f, 1.73239008e-01f, 4.67111804e-02f, -3.59186120e-02f, 1.50212243e-01f, 1.01642095e-01f, 4.89753522e-02f, 2.82657117e-01f,
  1.68800399e-01f, 1.31145030e-01f, 4.63146456e-02f, 1.64690688e-01f, 1.75300151e-01f, 7.87260160e-02f, 2.03832582e-01f, 2.22422749e-01f, 4.79628742e-02f, -1.54522737e-03f,
  -1.17187336e-01f, -2.23385200e-01f, 6.02907725e-02f, -2.77577251e-01f, -2.76461598e-02f, 3.70883584e-01f, -1.57113835e-01f, -1.90921858e-01f, -2.73711700e-02f, 5.00131920e-02f,
  2.24426225e-01f, 1.69247106e-01f, -2.54734475e-02f, -2.40366776e-02f, -7.09493533e-02f, -1.47939637e-01f, 2.63716131e-01f, 2.24674627e-01f, 1.01578228e-01f, 1.81457907e-01f,
  1.86729833e-01f, 3.70830715e-01f, 4.81011197e-02f, -1.48811579e-01f, -2.25190610e-01f, 2.53246993e-01f, -2.79360861e-02f, 2.11817220e-01f, -1.25981987e-01f, 7.75420442e-02f,
  -2.55261399e-02f, -2.37583563e-01f, 2.54114554e-03f, 1.26526356e-01f, 3.25458050e-01f, 3.71722877e-02f, -8.72752964e-02f, 4.26664986e-02f, -3.97087008e-01f, -5.42729162e-02f,
  1.76309094e-01f, -9.39739794e-02f, -1.34831639e-02f, 5.05039617e-02f, 7.55013674e-02f, -7.46929049e-02f, -1.20026119e-01f, 1.33892611e-01f, 1.56801507e-01f, 7.44327530e-02f,
  8.87272805e-02f, 1.98418461e-02f, 1.30601406e-01f, 2.32338533e-01f, 1.70708168e-02f, 1.15801744e-01f, 3.54078785e-02f, 1.12128519e-01f, -1.38892442e-01f, -3.24099474e-02f,
  7.89579302e-02f, 1.12014972e-01f, -6.92404136e-02f, 8.93298686e-02f, -9.32628438e-02f, -2.04624757e-01f, 5.10229170e-02f, 3.16821247e-01f, -2.79947728e-01f, -7.21780211e-02f,
  3.30484122e-01f, 8.90357047e-02f, -7.11101890e-02f, -6.59768283e-02f, 4.93973633e-03f, 1.22751124e-01f, -2.27072895e-01f, 1.37578696e-01f, -9.79925990e-02f, -1.31519705e-01f,
  3.97585660e-01f, -5.45243546e-02f, -1.05769537e-01f, -5.46978898e-02f, -6.76051602e-02f, 3.61243129e-01f, -9.05089900e-02f, -8.83075893e-02f, 1.42424420e-01f, -6.63695931e-02f,
  3.69306616e-02f, 2.99283206e-01f, -2.09478021e-01f, 1.56215161e-01f, 2.47345045e-02f, 1.85114637e-01f, -2.15185881e-01f, 2.93267101e-01f, 2.19380766e-01f, 2.87024438e-01f,
  -4.48254906e-02f, 2.40005881e-01f, 1.20434791e-01f, -5.86627945e-02f, 1.76795319e-01f, 1.59344688e-01f, -5.78475073e-02f, 4.00909446e-02f, -1.33824283e-02f, -1.78030044e-01f,
  1.78152323e-02f, 1.54605180e-01f, 2.99344540e-01f, 2.30492204e-01f, -8.81004483e-02f, 2.55584806e-01f, 1.28212661e-01f, 1.10527903e-01f, 1.85885131e-02f, 1.92357264e-02f,
  -3.35665420e-02f, 1.80237147e-03f, 1.90294281e-01f, 1.53733656e-01f, 2.05751613e-01f, -2.01344520e-01f, -7.59605169e-02f, 2.19334096e-01f, 1.46551475e-01f, 2.67695636e-01f,
  1.90713778e-01f, -2.32434630e-01f, 1.83713391e-01f, 2.49244198e-01f, 2.50392735e-01f, -1.60825655e-01f, -5.49102873e-02f, -5.28243780e-02f, -1.55629531e-01f, -2.52561748e-01f,
  3.58040512e-01f, -3.48000348e-01f, 4.00090450e-03f, -2.71623909e-01f, -9.53874663e-02f, 6.96883500e-02f, -4.20236439e-01f, 7.20452070e-02f, -1.49175003e-01f, -2.49361470e-01f,
  -3.37460071e-01f, 5.39830029e-01f, 3.72902036e-01f, -2.16821760e-01f, -2.29942143e-01f, -1.15840934e-01f, 1.79774180e-01f, -6.56191632e-02f, -5.64223975e-02f, 1.30435219e-02f,
  1.56149030e-01f, -1.17148310e-01f, -1.25612468e-01f, -7.70184696e-02f, -2.47017741e-01f, -1.34575501e-01f, 1.43840730e-01f, -9.30377617e-02f, 4.24575806e-02f, 2.01768175e-01f,
  2.29051504e-02f, 7.46596837e-03f, -7.07555711e-02f, -1.08881937e-02f, -2.51381304e-02f, 1.54669181e-01f, 5.54257743e-02f, 3.47411372e-02f, -1.96971834e-01f, 2.13206127e-01f,
  1.26640067e-01f, 8.70175809e-02f, 8.77998620e-02f, -8.83369297e-02f, 1.73799008e-01f, 2.89481245e-02f, 8.76293629e-02f, 8.97058323e-02f, 2.07273439e-01f, -3.01875234e-01f,
  -2.78911497e-02f, 1.99312910e-01f, 1.10756449e-01f, 3.87533814e-01f, -1.92745268e-01f, 6.43765330e-02f, 1.85410067e-01f, -1.74565628e-01f, 3.01261306e-01f, 3.47428143e-01f,
  -2.33706549e-01f, 1.05986916e-01f, -1.43344074e-01f, 1.74682409e-01f, 1.96688771e-01f, -1.31531795e-02f, -2.26104888e-03f, 1.80518717e-01f, 2.65643537e-01f, 3.38742137e-01f,
  -4.03736413e-01f, 3.06890737e-02f, 3.67297679e-01f, -1.01054214e-01f, 2.33701378e-01f, 2.22943157e-01f, 3.47382799e-02f, -1.35074928e-01f, -1.05775662e-01f, -4.63993788e-01f,
  -2.81348109e-01f, -4.05873507e-01f, 1.04810804e-01f, 1.75872013e-01f, -1.53911352e-01f, -1.38662085e-01f, 8.16337839e-02f, 1.75410464e-01f, 3.65305692e-02f, -1.76250607e-01f,
  1.87635988e-01f, 8.36641863e-02f, -4.49168356e-03f, -1.23850405e-01f, -3.80535610e-02f, 1.44508824e-01f, 4.76362929e-02f, 4.61981744e-02f, -8.09637830e-02f, 9.03635770e-02f,
  1.56921685e-01f, 1.29138082e-01f, 1.87547177e-01f, 1.40389249e-01f, 1.67455360e-01f, -1.38422409e-02f, 2.01972574e-02f, 7.34247938e-02f, 9.45534371e-03f, 2.19802201e-01f,
  2.58217633e-01f, 1.47462055e-01f, 8.08278993e-02f, 1.27847090e-01f, 7.16458857e-02f, -3.38668972e-02f, 1.47053013e-02f, -4.74789813e-02f, 4.65276791e-03f, -1.17289655e-01f,
  -3.27194370e-02f, 1.24035537e-01f, -2.70665586e-01f, 1.07217506e-02f, -1.29602522e-01f, -8.36333632e-03f, 3.80151835e-03f, 1.07878678e-01f, -6.28688484e-02f, -4.44857143e-02f,
  5.21773212e-02f, -1.30837364e-02f, 5.97008877e-02f, 6.86131716e-02f, 3.13843131e-01f, 2.19530672e-01f, -1.28800258e-01f, 3.26436698e-01f, 2.07425337e-02f, -3.00401688e-01f,
  -1.65304154e-01f, 1.77691638e-01f, 1.73775628e-01f, 4.05706435e-01f, -1.67850137e-01f, 1.32743165e-01f, -2.05553740e-01f, -2.57573783e-01f, 2.20646826e-03f, 6.54728860e-02f,
  1.07516669e-01f, -5.86574851e-03f, -5.10646254e-02f, 3.39176536e-01f, -2.96817660e-01f, 2.75590792e-02f, 2.95992464e-01f, 4.01156582e-02f, 2.24407688e-01f, 8.05623755e-02f,
  1.98199630e-01f, 1.66815847e-01f, 3.28180492e-01f, 2.14857057e-01f, -8.27359408e-03f, 3.77465487e-02f, 1.83928028e-01f, 1.37487426e-01f, 1.48274928e-01f, 1.79257691e-01f,
  4.95540313e-02f, 9.07630324e-02f, 7.51033723e-02f, 2.22665727e-01f, 7.41026923e-02f, 2.37148628e-01f, 5.18950308e-03f, 1.53804600e-01f, -7.22076073e-02f, 2.16142938e-01f,
  -6.60108551e-02f, -3.62335332e-02f, 3.12018804e-02f, -1.65359721e-01f, 7.62694763e-05f, 1.70490835e-02f, 4.62444909e-02f, 1.56970054e-01f, 3.50528583e-02f, 9.37522650e-02f,
  1.12682216e-01f, -4.44893837e-02f, -2.35085025e-01f, 2.28707433e-01f, -7.04676285e-02f, 6.53719231e-02f, 2.45003253e-02f, 2.37163037e-01f, -2.22096190e-01f, 6.75853342e-02f,
  2.49564439e-01f, 1.70964807e-01f, 2.13016093e-01f, -6.71892762e-02f, -6.89966381e-02f, 7.46819302e-02f, -2.12599009e-01f, -4.68354046e-01f, -5.83912395e-02f, 6.96765780e-02f,
  2.04480574e-01f, 1.22633599e-01f, 1.23096898e-01f, 8.49879459e-02f, 3.79833043e-01f, 2.28623018e-01f, -8.85398164e-02f, -4.36961442e-01f, 1.11736292e-02f, 7.72312209e-02f,
  1.39249101e-01f, -1.06185906e-01f, -8.58590566e-03f, -1.41240671e-01f, -4.53884304e-02f, 1.07711218e-01f, -4.03825790e-02f, -1.56161591e-01f, 2.35622406e-01f, 1.63146526e-01f,
  -3.78763005e-02f, 4.30297256e-02f, 1.12573080e-01f, 1.34070382e-01f, -3.46633010e-02f, -1.44442335e-01f, 1.48473606e-01f, -3.12182531e-02f, 1.65860161e-01f, 1.80403993e-01f,
  8.72777253e-02f, -2.45658979e-01f, -1.40610840e-02f, -6.57002777e-02f, 2.43733361e-01f, -1.84877291e-01f, 1.88869417e-01f, 4.29572873e-02f, 2.20770076e-01f, -8.36220756e-03f,
  3.87302637e-01f, -3.05395760e-02f, -2.10457575e-02f, -9.03723412e-04f, 4.22355607e-02f, -6.87145218e-02f, -6.11570626e-02f, -3.31826270e-01f, 4.72388789e-02f, -8.64406154e-02f,
  -1.48039654e-01f, -4.40146402e-02f, -3.99818331e-01f, 4.94395324e-04f, 2.03803405e-01f, -1.57949194e-01f, 3.22488137e-02f, 2.16172844e-01f, 4.12817121e-01f, -2.38444731e-01f,
  -2.04532087e-01f, 2.18042389e-01f, 3.99331748e-01f, -4.71072555e-01f, 1.64035663e-01f, 2.47305289e-01f, -3.81714925e-02f, -1.59485281e-01f, -4.54739481e-01f, -1.92721128e-01f,
  2.52956562e-02f, -1.13531262e-01f, 9.00691673e-02f, 1.72680929e-01f, -1.30076423e-01f, 1.36311561e-01f, 1.89002812e-01f, 2.07347170e-01f, 2.00074073e-03f, 1.99203014e-01f,
  -1.99356183e-01f, 1.80607229e-01f, 2.04388082e-01f, 7.67806023e-02f, 2.26370558e-01f, 2.19551265e-01f, 9.46482047e-02f, 1.98536273e-02f, 1.79727614e-01f, 2.48104572e-01f,
  1.18741140e-01f, 5.06034754e-02f, 1.97349831e-01f, 9.49207693e-02f, 2.94321299e-01f, 4.79120724e-02f, -2.47801449e-02f, -3.26910704e-01f, 3.99608374e-01f, -1.42244384e-01f,
  1.08406089e-01f, 2.48572931e-01f, 2.64093019e-02f, 6.52118921e-02f, -2.08643764e-01f, 9.72606838e-02f, 2.25328743e-01f, -3.13813895e-01f, -2.83075310e-02f, -1.84223816e-01f,
  6.36206642e-02f, 2.86366373e-01f, 1.61886573e-01f, -3.53362709e-02f, -7.96224996e-02f, 3.61836374e-01f, -4.15761285e-02f, -4.78183590e-02f, 1.47311568e-01f, 1.24663323e-01f,
  2.66037643e-01f, -2.37878367e-01f, 1.63209870e-01f, -3.96718830e-01f, 3.61333489e-01f, 2.48522580e-01f, -7.70459622e-02f, 4.91591543e-02f, 3.19603900e-03f, -9.80523378e-02f,
  -3.15670632e-02f, -2.38666251e-01f, -7.65865147e-02f, -1.50232747e-01f, -1.93684638e-01f, 3.15007925e-01f, -2.34937221e-01f, 2.11751293e-02f, 7.87625462e-02f, 1.99693084e-01f,
  -9.40602496e-02f, 3.79027426e-02f, 2.82873064e-01f, -2.06938144e-02f, 1.61525011e-01f, 9.64140370e-02f, 2.20590040e-01f, 2.00003460e-01f, 9.53487977e-02f, 2.28570685e-01f,
  -2.14431100e-02f, 1.57585457e-01f, 1.10288978e-01f, 8.52162987e-02f, 8.21563452e-02f, 1.32617399e-01f, 5.93890296e-03f, 1.06258625e-02f, 1.62233144e-01f, -3.05471569e-01f,
  1.11468062e-01f, 1.11851834e-01f, -7.22310878e-03f, 2.46006131e-01f, -4.39961404e-02f, -4.17872109e-02f, 8.73748288e-02f, 4.90135923e-02f, -8.52893218e-02f, 3.15049179e-02f,
  1.30508840e-01f, 2.12933913e-01f, -2.65198108e-02f, 9.02995244e-02f, 2.86777169e-01f, -6.99865818e-02f, -1.34356096e-01f, 1.27800524e-01f, 3.08043331e-01f, 1.06045149e-01f,
  2.97817796e-01f, 8.31826553e-02f, -1.07090265e-01f, 2.50392035e-02f, -1.94966942e-01f, 3.73345077e-01f, -2.06251293e-01f, 2.48815536e-01f, -2.17435118e-02f, -4.79754135e-02f,
  7.76912197e-02f, 8.90415683e-02f, -1.72762051e-01f, 1.32806655e-02f, -1.25577033e-01f, 3.01094670e-02f, 1.67718485e-01f, 1.88719437e-01f, 1.59765899e-01f, -6.90826848e-02f,
  7.36271665e-02f, -2.34028208e-03f, -3.96515895e-03f, 8.74521211e-02f, 1.31917283e-01f, 3.88324596e-02f, -1.62335373e-02f, 2.03109562e-01f, -1.75988168e-01f, 8.22376087e-02f,
  3.33694592e-02f, 2.19193846e-01f, 1.36824042e-01f, 1.28699332e-01f, 7.60732144e-02f, 1.94711387e-01f, 8.44045207e-02f, 2.16834947e-01f, 7.52157122e-02f, -9.18932110e-02f,
  -5.70018962e-02f, -9.79959685e-03f, 1.19276032e-01f, 8.99653956e-02f, 4.70200405e-02f, 1.60367861e-02f, 1.16331711e-01f, -1.07355483e-01f, -1.97634790e-02f, 2.26348415e-01f,
  -9.24846977e-02f, -1.00531630e-01f, 2.39760339e-01f, -2.71185562e-02f, -1.66290868e-02f, -1.27514094e-01f, 1.57687500e-01f, -1.08808152e-01f, -2.24989146e-01f, 2.07974896e-01f,
  -2.48855725e-01f, -2.27805793e-01f, 3.19692343e-01f, 3.05241406e-01f, -5.84837645e-02f, -2.66097672e-02f, 3.40964437e-01f, 3.55842113e-01f, 1.32601827e-01f, -2.14072287e-01f,
  1.67004377e-01f, -1.56770200e-01f, 1.14483349e-01f, 2.00656235e-01f, -1.56003803e-01f, 1.89983728e-03f, -1.59382652e-02f, 4.00625654e-02f, -1.84309974e-01f, 3.90638821e-02f,
  3.27644855e-01f, 2.40339175e-01f, -2.50300825e-01f, 2.79767185e-01f, -1.24715501e-03f, 1.21209659e-01f, 1.88547701e-01f, 9.89707261e-02f, 1.39394507e-01f, 1.48187548e-01f,
  3.64195034e-02f, 4.95979413e-02f, 1.62229076e-01f, 2.75283784e-01f, 1.33893013e-01f, 5.96842207e-02f, 1.24178804e-01f, 1.62268922e-01f, 1.73690975e-01f, -7.99561217e-02f,
  2.47510374e-01f, 1.14246495e-01f, 2.12859362e-01f, 5.71965873e-02f, 1.40916273e-01f, 7.19725564e-02f, 4.37314473e-02f, 3.42823714e-02f, -3.08109876e-02f, 8.56823921e-02f,
  5.29679842e-02f, 9.98067483e-02f, -8.55353400e-02f, -8.76295939e-02f, -9.67728943e-02f, 2.17674837e-01f, -2.23054647e-01f, -4.75700013e-02f, 7.01342672e-02f, -1.46296248e-01f,
  6.34008050e-02f, 1.49588045e-02f, 1.22430101e-01f, -7.27038831e-02f, 1.30810797e-01f, 1.59395263e-01f, 8.38490725e-02f, 1.73021168e-01f, 2.57609844e-01f, 2.73095846e-01f,
  -2.34823018e-01f, 7.07342997e-02f, -4.02896525e-03f, 2.82966375e-01f, -1.01293601e-01f, 1.04818098e-01f, 1.98231816e-01f, 3.01977158e-01f, -1.48016572e-01f, 1.58020943e-01f,
  -1.21936098e-01f, -1.98178500e-01f, -1.49261933e-02f, -2.59875208e-01f, 7.54792010e-03f, -1.89098790e-01f, 1.34620935e-01f, 3.94351870e-01f, 8.28003436e-02f, -6.40940219e-02f,
  7.78463259e-02f, 1.31722927e-01f, 2.65177637e-01f, 7.45369643e-02f, 2.82883018e-01f, 8.62541124e-02f, 3.64760995e-01f, 1.77044913e-01f, 1.12539619e-01f, 4.28467654e-02f,
  2.50444382e-01f, 3.02534968e-01f, 1.04131006e-01f, 2.09250212e-01f, 2.13666722e-01f, 1.23206735e-01f, -2.85720788e-02f, 2.79058009e-01f, 6.68032840e-02f, 1.90297842e-01f,
  1.73030570e-01f, 2.39610791e-01f, -1.15188412e-01f, 3.20417911e-01f, -2.23310694e-01f, 6.66027889e-02f, 2.49231204e-01f, 1.80010702e-02f, 2.72909887e-02f, -1.42090529e-01f,
  -1.07516041e-02f, 2.89256163e-02f, -1.44042447e-02f, 3.25109482e-01f, -7.98917636e-02f, -4.48972173e-02f, 6.90968931e-02f, 3.02030127e-02f, -2.14170784e-01f, -1.44877536e-02f,
  2.44186863e-01f, -1.34464160e-01f, -1.31247729e-01f, 1.40205873e-02f, -7.88868964e-03f, -9.15860981e-02f, -2.19958603e-01f, -1.97361544e-01f, 5.12081571e-02f, -7.50591308e-02f,
  -2.48508483e-01f, -1.85314700e-01f, 2.94762552e-01f, 1.14011429e-01f, 2.15502664e-01f, 1.79531917e-01f, -1.60417259e-01f, 1.88603923e-02f, 1.73067600e-01f, 3.24741960e-01f,
  1.68728724e-01f, -2.52488613e-01f, 9.67960060e-02f, 4.97023277e-02f, -2.88207103e-02f, 1.23938501e-01f, -1.36572883e-01f, 1.70589730e-01f, 2.61598259e-01f, 2.02783093e-01f,
  1.74326807e-01f, 9.32441428e-02f, 1.44541234e-01f, 2.36993387e-01f, 8.24495777e-02f, 8.96861032e-02f, -1.93672290e-03f, 1.35044351e-01f, 9.42648128e-02f, 2.77883589e-01f,
  -5.30165993e-03f, -9.59576070e-02f, -1.72593787e-01f, 7.08083734e-02f, 1.22281365e-01f, -1.22043207e-01f, 1.80859521e-01f, 6.72995821e-02f, 1.02482542e-01f, -1.18863031e-01f,
  1.70711018e-02f, 1.26950100e-01f, 3.34896706e-02f, 1.13368563e-01f, 4.72388230e-02f, -8.36187676e-02f, 3.34551215e-01f, -1.26751244e-01f, 1.38928100e-01f, -4.11772847e-01f,
  -1.12896189e-01f, 5.79702407e-02f, -3.39973152e-01f, -1.33369491e-01f, 3.43169034e-01f, -8.19734782e-02f, -3.08952719e-01f, 1.18485116e-03f, -7.47728869e-02f, 2.24465862e-01f,
  -1.99753433e-01f, 3.32020432e-01f, 2.13917956e-01f, -3.32647860e-02f, -5.33164628e-02f, -1.38982177e-01f, 1.25907153e-01f, 2.57764101e-01f, -1.61955699e-01f, 7.91573673e-02f,
  1.35057554e-01f, -3.95430326e-02f, 2.84039050e-01f, 6.07213713e-02f, -2.25686625e-01f, 3.24038416e-02f, -7.09077641e-02f, 1.26391068e-01f, -1.18072040e-01f, 3.39603841e-01f,
  1.40089402e-02f, 8.45562741e-02f, 6.14178600e-03f, -9.82636660e-02f, 2.02789661e-02f, -1.45924941e-01f, 2.13466823e-01f, 4.65951152e-02f, -1.31108910e-01f, 9.27498415e-02f,
  5.96686341e-02f, 3.98731828e-02f, 9.61339027e-02f, 6.11509793e-02f, 1.13189012e-01f, -8.74540731e-02f, 9.37411636e-02f, 1.07993037e-01f, 1.37430906e-01f, -2.23550588e-01f,
  -8.77406150e-02f, 1.18952028e-01f, 1.18846141e-01f, 1.72694668e-01f, -2.61284783e-02f, -9.83626395e-03f, 1.82655439e-01f, -2.00286806e-01f, 2.86820114e-01f, 3.17916228e-03f,
  -1.47235766e-01f, -2.38645792e-01f, -1.32785574e-01f, -8.37912858e-02f, 1.97582483e-01f, -5.68674132e-02f, 4.18852270e-02f, 1.07741930e-01f, -7.29664415e-02f, -3.36529426e-02f,
  -3.42111021e-01f, -2.17248768e-01f, 2.26167738e-01f, 1.97053552e-02f, -7.27594569e-02f, 3.02618861e-01f, 2.48346701e-01f, -8.53361636e-02f, -2.19797552e-01f, -9.72345471e-02f,
  1.44615978e-01f, -4.17707175e-01f, 2.78904676e-01f, 3.53089005e-01f, 7.68628791e-02f, 7.61329010e-02f, 2.28186399e-02f, 1.50409624e-01f, -9.78860632e-02f, -2.11846352e-01f,
  2.80306309e-01f, -1.37500003e-01f, -2.81844348e-01f, -4.59387712e-02f, 8.82245228e-02f, -2.06594378e-01f, 4.35151309e-02f, -4.57261726e-02f, -8.84140506e-02f, -1.83720924e-02f,
  -1.03392877e-01f, 3.89039367e-02f, 6.63033277e-02f, -1.30692003e-02f, -1.08259119e-01f, 5.29238284e-02f, -5.89097030e-02f, -1.36702836e-01f, 1.03444785e-01f, 7.49007016e-02f,
  1.78813949e-01f, -1.80428382e-03f, 8.88114274e-02f, -6.24454506e-02f, -1.28957424e-02f, 1.45501588e-02f, 1.94863290e-01f, -1.30058080e-01f, -1.50090545e-01f, 5.29752709e-02f,
  1.38584808e-01f, -2.56479830e-01f, 2.12960169e-01f, 1.40290335e-01f, -8.16114321e-02f, 2.21357524e-01f, -2.57144719e-01f, -6.73542023e-02f, -2.68383205e-01f, 2.21101150e-01f,
  2.13903524e-02f, 4.47136573e-02f, 1.88607857e-01f, 1.96848214e-01f, -4.99744564e-01f, -2.13313520e-01f, 3.21055770e-01f, 6.14120774e-02f, 2.78183520e-01f, -1.66062042e-02f,
  -4.07426469e-02f, -1.53767630e-01f, -1.08141311e-01f, -2.95641929e-01f, -2.49696091e-01f, -3.39079738e-01f, 3.06194965e-02f, 1.36022475e-02f, -1.05446078e-01f, -2.16574639e-01f,
  4.32031363e-01f, 2.93714583e-01f, -1.86827660e-01f, -2.24001125e-01f, -1.31910264e-01f, 1.85871497e-01f, 3.35288644e-02f, -2.42823988e-01f, 3.16461287e-02f, 1.65252686e-01f,
  5.48375845e-02f, 1.30993471e-01f, 2.86634773e-01f, 1.47678390e-01f, 1.73337653e-01f, 2.41483469e-03f, 6.61030924e-03f, -1.16598159e-02f, 5.83176203e-02f, 2.46022075e-01f,
  7.71019906e-02f, 1.57332003e-01f, 1.96873412e-01f, 2.08039418e-01f, -5.20391166e-02f, 1.04315393e-01f, 1.06848396e-01f, 1.43727139e-01f, 1.05383992e-01f, 4.91210259e-02f,
  -1.90232918e-01f, -9.63683128e-02f, 1.07003652e-01f, -1.98276758e-01f, -1.26071289e-01f, 6.73909336e-02f, -8.56206864e-02f, -1.95904419e-01f, 2.63824500e-02f, 7.23588020e-02f,
  2.20178723e-01f, 6.84807822e-02f, -1.56295612e-01f, 1.26824424e-01f, -1.87975131e-02f, -2.91749239e-01f, 3.78249586e-01f, -3.87610383e-02f, 4.41752709e-02f, 1.30309165e-01f,
  2.49866042e-02f, 3.20866704e-01f, -8.39638337e-03f, -6.92674518e-02f, 9.60018858e-02f, 3.46208662e-01f, -5.46854781e-03f, -1.94456175e-01f, 8.58802646e-02f, 2.08605871e-01f,
  1.65391967e-01f, -1.22461624e-01f, 1.41465560e-01f, 2.37149343e-01f, 4.94216532e-01f, 2.16112398e-02f, -1.71964243e-01f, -5.12918681e-02f, 1.59176022e-01f, 5.60822040e-02f,
  2.57671446e-01f, 1.19072266e-01f, -6.95646927e-02f, 9.24671888e-02f, 2.86056280e-01f, 2.25113392e-01f, 5.48113398e-02f, 1.35847360e-01f, 1.41825959e-01f, 7.37790316e-02f,
  -1.23669326e-01f, 1.15189381e-01f, 7.62282386e-02f, 1.36793226e-01f, -1.82233825e-02f, 4.05786978e-03f, 1.52853385e-01f, 7.90880099e-02f, 1.06849283e-01f, 7.93611035e-02f,
  2.03589052e-01f, 3.09006684e-02f, -8.10796320e-02f, -3.65787745e-03f, -3.78323346e-03f, 1.35424837e-01f, 1.37899205e-01f, -4.09712583e-01f, -8.56280923e-02f, 2.66092211e-01f,
  1.34516403e-01f, -1.12180255e-01f, 4.80475836e-02f, -3.82226795e-01f, 8.70245546e-02f, -2.70278931e-01f, 2.87724622e-02f, -2.99478263e-01f, 1.71953350e-01f, -1.46063298e-01f,
  -2.24081278e-01f, 1.58040877e-02f, 4.72825393e-02f, 3.77588749e-01f, -2.20606551e-01f, -2.27707282e-01f, -5.83468564e-02f, 2.46158555e-01f, 2.55664915e-01f, 2.65740991e-01f,
  -2.00020596e-01f, -1.11883499e-01f, 4.31831367e-03f, 1.38098210e-01f, 9.85780358e-02f, -5.57491407e-02f, 1.73380584e-01f, 8.44067782e-02f, 1.16160102e-01f, -2.08584324e-01f,
  -4.32692058e-02f, -1.96940705e-01f, 2.55460560e-01f, -1.71912640e-01f, -9.98689979e-02f, 1.90144569e-01f, 1.36053145e-01f, 8.65019932e-02f, 1.33269578e-01f, -8.12257733e-03f,
  2.38004982e-01f, 9.81030315e-02f, 8.18057731e-02f, 5.52008972e-02f, 5.91063872e-02f, 1.97439924e-01f, 8.33541751e-02f, -4.14843895e-02f, 1.46368399e-01f, -8.94944370e-02f,
  1.01219274e-01f, 1.89957291e-01f, 9.42031071e-02f, -1.02087997e-01f, 2.15797946e-01f, 9.59319696e-02f, -1.75677761e-02f, 3.99354547e-02f, -2.01486841e-01f, 1.36383086e-01f,
  -7.03897700e-03f, 4.91843559e-02f, 1.26685724e-01f, -1.30990013e-01f, -3.98525670e-02f, 2.18550578e-01f, -2.32303679e-01f, 1.92133054e-01f, -5.89568950e-02f, 3.76954317e-01f,
  6.47914633e-02f, -2.27364883e-01f, 1.27877807e-03f, 6.65291771e-02f, 2.09597737e-01f, 8.41490701e-02f, 1.75955877e-01f, -1.09058753e-01f, 6.86175898e-02f, -1.31458119e-01f,
  -8.81942362e-02f, -7.70361423e-02f, -1.76003322e-01f, 8.78880769e-02f, 2.26645079e-02f, 2.79789895e-01f, -3.76860052e-03f, 1.02853358e-01f, 2.46718228e-01f, 8.34580958e-02f,
  -1.43742353e-01f, 1.65121049e-01f, -1.87888518e-01f, 2.92744905e-01f, 2.38443613e-01f, -1.34083554e-01f, 8.70870873e-02f, 9.71471425e-03f, -8.59263614e-02f, -4.09419127e-02f,
  5.31293862e-02f, 9.86139476e-02f, 9.47788805e-02f, -1.15932122e-01f, 1.75569192e-01f, -3.11324117e-03f, 7.64035508e-02f, 8.60565454e-02f, -6.12063147e-02f, 6.13788515e-02f,
  -4.82516326e-02f, -3.05442815e-03f, 1.93870246e-01f, 4.30760160e-02f, -6.35709846e-03f, -9.19089243e-02f, -2.68606901e-01f, -1.19076267e-01f, -5.17876968e-02f, -6.69230148e-02f,
  1.31824702e-01f, 1.75223932e-01f, -1.43544927e-01f, 1.31182626e-01f, 1.03280477e-01f, 2.17875987e-01f, -8.38755965e-02f, -2.76893497e-01f, 1.33507490e-01f, -2.44944729e-02f,
  -3.17025222e-02f, 1.61522776e-01f, -7.62159470e-05f, -2.07704846e-02f, -1.97954234e-02f, 2.32489154e-01f, -3.08078736e-01f, -1.47274494e-01f, 2.10447952e-01f, -1.97000757e-01f,
  -4.88478020e-02f, 6.73934892e-02f, -9.11704749e-02f, -1.30066454e-01f, 2.23917335e-01f, -1.92597687e-01f, -1.52584568e-01f, 1.11130916e-03f, -8.00550729e-02f, -2.40542084e-01f,
  2.77648680e-02f, 2.99109109e-02f, 1.00274216e-02f, 3.68411154e-01f, -6.08416423e-02f, -4.46403585e-02f, 1.43925309e-01f, 3.09777737e-01f, -2.46361457e-03f, 7.71096349e-02f,
  2.47535944e-01f, 1.39826149e-01f, -1.43875211e-01f, 5.61769903e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  6.01980314e-02f, 1.94426268e-01f, -2.29276910e-01f, 1.23686597e-01f, 1.82072520e-01f, 5.81941865e-02f, 2.17820629e-02f, 1.03873618e-01f, 3.83335240e-02f, 2.58894473e-01f,
  2.23346144e-01f, 1.16241589e-01f, 2.12935120e-01f, 2.38417774e-01f, 2.70449281e-01f, 3.28353763e-01f, 6.35405928e-02f, 2.21578971e-01f, 1.58775553e-01f, 1.98553711e-01f,
  9.28944126e-02f, 1.24392271e-01f, 5.16769364e-02f, 2.56426901e-01f, 1.14211336e-01f, 3.69801074e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.46465670e-02f, -8.56284797e-02f, -1.03666149e-01f, 1.36855021e-01f, 5.28234802e-02f, 5.47577217e-02f, 1.92246825e-01f, 1.78770632e-01f, 1.03214175e-01f, 5.65481409e-02f,
  1.26248538e-01f, 8.03210735e-02f, 1.77127242e-01f, 8.75744130e-03f, -9.28864032e-02f, 1.86840996e-01f, 4.03087251e-02f, 1.55572295e-01f, 1.88027360e-02f, -1.58460408e-01f,
  1.30793322e-02f, 3.40910614e-01f, 1.85670145e-02f, -1.67905509e-01f, 3.90241034e-02f, -2.27250621e-01f, -1.91517740e-01f, -1.89862952e-01f, 9.03294683e-02f, 1.86364010e-01f,
  -1.83451381e-02f, 1.00868955e-01f, -1.64031744e-01f, -6.84163198e-02f, -1.04840457e-01f, -1.21969424e-01f, -1.83737233e-01f, 1.32456183e-01f, 5.02008498e-02f, -4.58513536e-02f,
  7.59805441e-02f, 4.92934957e-02f, -2.73511052e-01f, 1.95637241e-01f, -1.90353274e-01f, 6.97616562e-02f, 3.04544866e-01f, 2.62173653e-01f, -1.09973261e-02f, -9.03678313e-02f,
  -9.12279338e-02f, -1.55785754e-01f, 7.16701001e-02f, 6.90284446e-02f, 1.63737670e-01f, -1.24213450e-01f, -9.88871381e-02f, 5.79957590e-02f, -4.91166003e-02f, -1.59235731e-01f,
  1.03455149e-01f, 1.98031470e-01f, -3.49107385e-02f, -4.55500074e-02f, 4.78414707e-02f, -1.36348426e-01f, 4.01740372e-02f, 4.32565287e-02f, 8.99645239e-02f, 1.29903734e-01f,
  -6.87248632e-02f, -1.36403874e-01f, -4.53802384e-02f, -8.28409195e-03f, -6.81766942e-02f, -9.62169543e-02f, 6.82437122e-02f, -1.60008490e-01f, -4.69997413e-02f, 1.94585025e-01f,
  -8.85512307e-02f, 1.03304133e-01f, -6.94808587e-02f, -1.61184102e-01f, -4.02848087e-02f, 1.79904148e-01f, 8.10356289e-02f, -7.82844499e-02f, -1.88833863e-01f, 1.72682971e-01f,
  1.05269514e-01f, -2.67279714e-01f, -8.62585530e-02f, -1.22330608e-02f, 2.17854921e-02f, -4.64570858e-02f, -1.80940896e-01f, -2.77752966e-01f, -1.35208338e-01f, -2.69895680e-02f,
  -1.08076096e-01f, 1.57698952e-02f, -1.00270025e-01f, 7.95041397e-02f, 6.01558052e-02f, -1.19129613e-01f, -7.25823492e-02f, -2.00069174e-02f, 7.78163821e-02f, -1.33228660e-01f,
  2.66047150e-01f, -1.16664425e-01f, 1.29586617e-02f, -1.26347408e-01f, -4.02013883e-02f, 2.53362618e-02f, -1.32311136e-01f, 1.03911154e-01f, 3.54303829e-02f, -2.45478898e-01f,
  5.99605925e-02f, 1.55320808e-01f, 1.94335788e-01f, -1.43755376e-01f, 7.22999349e-02f, -7.93661326e-02f, 3.08915903e-03f, 2.61254489e-01f, 1.01634845e-01f, 1.69075727e-01f,
  8.17051008e-02f, 9.99024510e-02f, 5.57492822e-02f, -1.02028750e-01f, 1.04741864e-02f, 2.49160565e-02f, -1.88640371e-01f, -6.59450516e-02f, 1.44717336e-01f, 1.87491328e-01f,
  3.91863734e-02f, 6.75437227e-02f, 1.36098579e-01f, 2.31538326e-01f, 2.88712792e-02f, -2.01190859e-01f, -2.28557531e-02f, 1.70375645e-01f, -1.81679092e-02f, -1.35435715e-01f,
  1.09316535e-01f, 7.75628686e-02f, 2.68307000e-01f, -1.06172748e-01f, 6.44456297e-02f, 5.41284308e-02f, 2.43776128e-01f, 1.73174739e-01f, 4.67302985e-02f, 9.19144824e-02f,
  8.19992647e-03f, -3.11677158e-03f, 1.80754796e-01f, 7.75474757e-02f, 9.93350372e-02f, 2.22976789e-01f, -3.45742665e-02f, -5.90879396e-02f, -5.57283685e-03f, 1.78389207e-01f,
  5.69578074e-02f, -3.00658941e-01f, 1.04807988e-01f, 5.65807372e-02f, -3.17962980e-03f, -4.02251855e-02f, -1.08227320e-01f, 1.59175292e-01f, 1.54881477e-01f, -2.48881310e-01f,
  -9.95238200e-02f, 9.65406373e-02f, -8.30907002e-02f, -5.45145050e-02f, -9.80521217e-02f, 3.03518735e-02f, -1.97821841e-01f, -7.81972036e-02f, 2.18569502e-01f, 1.00152522e-01f,
  4.69248630e-02f, 1.09990299e-01f, -4.31225076e-02f, 1.44397944e-01f, -3.62344719e-02f, 1.12502299e-01f, 9.56077874e-02f, 1.41100883e-02f, 8.75602663e-02f, -2.97318213e-02f,
  5.37416488e-02f, 1.27196601e-02f, -5.26392423e-02f, -9.29978192e-02f, 1.78286493e-01f, -9.02454741e-03f, 9.69433039e-02f, -2.24762589e-01f, 1.88668892e-01f, -1.74994349e-01f,
  1.78793073e-01f, -5.13404198e-02f, -1.01812877e-01f, -1.43970639e-01f, 3.60272825e-02f, -6.80709407e-02f, 2.21811369e-01f, 5.81582859e-02f, 1.41399860e-01f, 1.42437309e-01f,
  -1.24679126e-01f, -2.89445788e-01f, 1.99872032e-01f, 2.07450137e-01f, 2.06014231e-01f, 1.25426903e-01f, 1.39782548e-01f, 1.41225815e-01f, 5.01607656e-02f, -2.08320126e-01f,
  2.01015204e-01f, -1.11461185e-01f, 3.96817513e-02f, 9.05685574e-02f, 1.41201973e-01f, -1.51026919e-01f, 4.61559445e-02f, -1.41390368e-01f, -8.90590474e-02f, -1.46646559e-01f,
  1.02076404e-01f, 7.61816185e-03f, -5.96153643e-03f, -1.23514965e-01f, 1.16469758e-02f, -5.73701877e-03f, -1.10566944e-01f, -5.66943958e-02f, -1.64427429e-01f, 7.23507535e-03f,
  9.07932371e-02f, -5.18066436e-02f, -1.34555489e-01f, 9.98066515e-02f, -1.11631760e-02f, 7.99163580e-02f, 1.43531278e-01f, -1.62851840e-01f, -1.97185040e-01f, 1.74910173e-01f,
  4.29392532e-02f, -8.14993903e-02f, 1.31497383e-01f, 8.23116452e-02f, -1.87382460e-01f, -6.76328540e-02f, 1.80193886e-01f, 6.58168942e-02f, 1.27867788e-01f, -1.32511750e-01f,
  1.80639140e-02f, -1.80252895e-01f, -1.25284921e-02f, 4.77191247e-02f, -3.05484720e-02f, 2.75362004e-02f, 1.31261125e-01f, 1.04196079e-01f, -1.72463104e-01f, 4.16195542e-02f,
  -5.42576145e-03f, -4.96866517e-02f, 3.78068723e-02f, 9.87365842e-04f, 2.10867003e-01f, -2.07145028e-02f, 1.46014869e-01f, -1.49281725e-01f, -2.14395225e-01f, -2.64323533e-01f,
  8.67086649e-02f, 1.38069540e-02f, -4.68840115e-02f, 1.86429188e-01f, -2.17092529e-01f, 7.20629022e-02f, 6.16846643e-02f, -9.37992781e-02f, 6.47927541e-03f, 1.00834608e-01f,
  1.13396667e-01f, -2.61547230e-02f, -3.19622010e-02f, -1.04798540e-01f, 4.75826636e-02f, -4.40674052e-02f, 1.50432199e-01f, 7.73366215e-03f, 9.57027376e-02f, -1.54099405e-01f,
  -1.38443723e-01f, -1.25244945e-01f, 1.98472068e-01f, -7.04776421e-02f, -8.62713009e-02f, 1.28366604e-01f, -8.43357965e-02f, 1.14361597e-02f, -9.98224244e-02f, 1.03580104e-02f,
  2.27615297e-01f, -1.08686006e-02f, 2.39735991e-01f, 2.26899520e-01f, 1.57244399e-01f, 3.62555534e-02f, 7.47375563e-02f, -5.96668795e-02f, -1.26428995e-02f, 6.37972355e-02f,
  2.61325032e-01f, 7.48548284e-02f, 1.19147740e-01f, -2.63585038e-02f, -8.19186792e-02f, 2.02582002e-01f, 7.00922087e-02f, 2.55629420e-02f, 2.43917983e-02f, -3.78669389e-02f,
  1.85827315e-01f, 1.85025603e-01f, 3.36469710e-01f, -1.02016278e-01f, 1.92996319e-02f, 4.84727770e-02f, -4.51733544e-02f, 1.42389191e-02f, 1.06681235e-01f, -5.92739619e-02f,
  2.61776626e-01f, -1.26536891e-01f, -2.50326604e-01f, -1.59401640e-01f, -1.69350505e-02f, -2.54869764e-03f, 6.77248389e-02f, -3.76331694e-02f, 5.00277765e-02f, 1.15761809e-01f,
  1.02029204e-01f, -1.48946822e-01f, 1.56619921e-01f, 1.18157715e-01f, -8.80260915e-02f, -1.72291040e-01f, -7.65340254e-02f, 4.55432646e-02f, 1.69928912e-02f, 3.06149246e-03f,
  -4.03031893e-02f, -3.54385488e-02f, -1.96488395e-01f, 2.84885287e-01f, -3.03504560e-02f, 1.26454726e-01f, 1.53994322e-01f, 2.05101848e-01f, 9.15388837e-02f, -1.62814647e-01f,
  5.64259291e-02f, 1.91412807e-01f, 2.02036425e-02f, -6.03564382e-02f, -1.35517210e-01f, 1.98494941e-02f, 1.74679101e-01f, -8.96307901e-02f, 4.83202636e-02f, -1.15989588e-01f,
  4.20425534e-02f, -1.78748369e-01f, 7.36396909e-02f, -1.57009333e-01f, -1.05306648e-01f, -2.45959833e-01f, 4.57199570e-03f, -8.42380375e-02f, 6.44803271e-02f, 2.59748138e-02f,
  -1.68541651e-02f, 7.24803656e-02f, -5.82589507e-02f, -1.04942687e-01f, -6.78002611e-02f, -1.16769344e-01f, -8.46038461e-02f, 2.61893958e-01f, -1.91655189e-01f, 1.73114240e-01f,
  4.94507253e-02f, -1.63571849e-01f, -2.33983919e-01f, -1.26476794e-01f, -1.45101652e-01f, -1.80937067e-01f, -2.39214394e-03f, -1.97214112e-01f, -2.81637639e-01f, 3.56064364e-02f,
  1.78407151e-02f, -2.19937652e-01f, -5.08146025e-02f, 1.97807863e-01f, 9.45779905e-02f, 3.18107679e-02f, -7.68431053e-02f, 1.11657083e-01f, -1.93545371e-01f, -2.07562998e-01f,
  7.63852596e-02f, 2.24675655e-01f, 1.58768237e-01f, -9.64287110e-03f, -1.33494139e-01f, 8.05716291e-02f, 3.57814170e-02f, 1.27032489e-01f, 1.76969282e-02f, 1.53489187e-01f,
  -6.19948953e-02f, -1.45253643e-01f, 1.52578801e-01f, 8.58685449e-02f, -2.26172239e-01f, -2.59622503e-02f, 6.16826676e-02f, -3.43339257e-02f, -1.86217546e-01f, -1.87714681e-01f,
  2.74003241e-02f, 1.18501030e-01f, 9.45521593e-02f, 9.13054049e-02f, 5.42967319e-02f, -1.71436623e-01f, -6.28445968e-02f, -1.58131301e-01f, 3.64345089e-02f, -2.81748325e-02f,
  3.05433959e-01f, 3.10096401e-03f, -3.28936726e-02f, 1.85556278e-01f, 6.58064783e-02f, -1.32954434e-01f, -1.38713166e-01f, -2.84230560e-01f, 1.66201353e-01f, 8.26389194e-02f,
  -1.08782895e-01f, 1.79008067e-01f, -5.81142232e-02f, -1.23994753e-01f, 2.97130227e-01f, -2.52742201e-01f, 2.58874655e-01f, 5.46726435e-02f, 1.49290860e-01f, -5.53917289e-02f,
  -2.64096141e-01f, -8.38535801e-02f, 1.48903385e-01f, 4.24747877e-02f, 3.34866196e-02f, 2.98656136e-01f, -8.19629133e-02f, 7.18383417e-02f, -2.27106944e-01f, 9.89067927e-03f,
  -1.05780914e-01f, -1.60080776e-01f, 1.50977641e-01f, -1.06857233e-01f, 1.66315585e-01f, 6.07667267e-02f, -2.44756006e-02f, 9.59148537e-03f, 8.21617395e-02f, -6.71066865e-02f,
  1.65787205e-01f, -1.12792000e-01f, -1.24384752e-02f, -1.55845031e-01f, 1.08179472e-01f, -7.72860795e-02f, 1.37025118e-01f, -2.89050579e-01f, -3.07287872e-02f, 5.96702239e-03f,
  1.32973328e-01f, 2.11370662e-01f, -9.49548855e-02f, 9.69412923e-02f, -3.95739079e-02f, -1.57691658e-01f, -3.48085649e-02f, 6.97145984e-02f, -1.54860064e-01f, 1.13148481e-01f,
  3.21855992e-02f, 9.76138785e-02f, -5.04651889e-02f, 1.21151671e-01f, -5.60142398e-02f, 3.27580459e-02f, 1.30714655e-01f, 3.54079232e-02f, 5.92707358e-02f, 1.05721362e-01f,
  -1.23674080e-01f, -2.15989407e-02f, -7.92898014e-02f, 2.23051146e-01f, -3.53747904e-02f, -2.76343129e-03f, 1.04299679e-01f, 5.91017716e-02f, -1.67997837e-01f, 9.71858129e-02f,
  -1.36908427e-01f, 7.56952092e-02f, -2.01370180e-01f, -3.84855211e-01f, -5.81666303e-04f, -1.82106227e-01f, -2.99963057e-01f, -1.54033393e-01f, 2.85077751e-01f, -1.14463262e-01f,
  4.38855104e-02f, -6.03779731e-03f, -8.38276073e-02f, 5.04104272e-02f, -6.73259571e-02f, 2.03331038e-01f, -6.53663278e-02f, -1.71423793e-01f, -1.39953092e-01f, 2.60615021e-01f,
  6.18155561e-02f, 1.38077261e-02f, -1.27474874e-01f, 1.45501897e-01f, 2.20509171e-01f, 6.40384257e-02f, 2.12471223e-05f, 4.13856320e-02f, 1.11517839e-01f, 1.57102585e-01f,
  1.21487956e-02f, -2.67320663e-01f, -1.54800430e-01f, -1.38735920e-01f, 2.97424686e-03f, 1.06293082e-01f, 2.45608523e-01f, -7.84185231e-02f, 1.58037916e-01f, 6.00277111e-02f,
  1.66728701e-02f, 8.02302808e-02f, -1.75115898e-01f, -1.52705878e-01f, -2.10314002e-02f, -3.87129672e-02f, -2.37342174e-04f, 2.70528346e-02f, -7.96888173e-02f, 8.89942497e-02f,
  4.71785329e-02f, 2.66840219e-01f, 9.87784937e-02f, 9.24253687e-02f, 3.44191566e-02f, -7.07625970e-02f, -5.83270937e-02f, 2.21700713e-01f, -7.45749772e-02f, -4.54852805e-02f,
  -1.09543838e-01f, -2.28117174e-03f, -9.63131487e-02f, 1.46257356e-01f, 2.94089708e-02f, 2.15652123e-01f, -8.48374441e-02f, -3.16304229e-02f, -4.27833408e-01f, -8.26730207e-02f,
  1.32356837e-01f, -2.98236706e-03f, -2.32081339e-01f, 2.92260021e-01f, -1.98174492e-01f, 3.17390375e-02f, 9.17724986e-03f, -8.85144398e-02f, -2.72593424e-02f, -6.54825196e-02f,
  1.39518544e-01f, 1.14765428e-01f, 2.51165807e-01f, 5.77261709e-02f, -3.43560870e-03f, 3.81219313e-02f, -8.49269505e-04f, -1.67496830e-01f, -2.65727658e-02f, 3.04528442e-03f,
  2.17189595e-01f, -8.59110877e-02f, 9.37772766e-02f, 1.87569708e-01f, -4.21325192e-02f, -1.60955489e-02f, 1.36517882e-01f, -1.56378105e-01f, 4.72161844e-02f, 1.75004646e-01f,
  -3.53772268e-02f, -1.23133332e-01f, -6.86318800e-02f, -4.74689268e-02f, 1.38051584e-02f, -5.10011166e-02f, 9.15733427e-02f, -1.88658744e-01f, 5.72160184e-02f, -6.01538718e-02f,
  1.93171114e-01f, -9.72764641e-02f, -1.27974436e-01f, -3.14802453e-02f, -1.55595526e-01f, -1.59862176e-01f, 1.35931581e-01f, -1.04110233e-01f, -1.16097718e-01f, 1.12857170e-01f,
  1.50969952e-01f, -1.07880019e-01f, 8.29510912e-02f, -2.14197300e-03f, -2.10942596e-01f, 1.73277646e-01f, 1.68306708e-01f, -1.54978499e-01f, 1.47144422e-01f, -2.79847920e-01f,
  2.01497838e-01f, -1.66991383e-01f, -5.36494963e-02f, -7.01893121e-02f, 2.10110825e-02f, 2.04414040e-01f, 8.70839581e-02f, 3.82479168e-02f, 2.69846153e-02f, -9.47177187e-02f,
  2.41151750e-01f, 1.77021012e-01f, -1.66431680e-01f, 7.08580762e-02f, 1.42900199e-02f, -7.21940249e-02f, -1.18133776e-01f, -3.96556817e-02f, -2.37171724e-01f, 4.31864299e-02f,
  2.22478565e-02f, 4.64774929e-02f, 2.63976067e-01f, -1.69741195e-02f, -1.58517733e-01f, 6.23432826e-03f, 1.66121915e-01f, -1.62819475e-01f, -2.85449754e-02f, -1.70671150e-01f,
  -5.75638339e-02f, -1.54127285e-01f, 1.89610541e-01f, -1.15929529e-01f, 2.45271027e-02f, 4.84146588e-02f, -1.38114303e-01f, -1.66147664e-01f, 9.55582336e-02f, 3.15370783e-02f,
  1.32110476e-01f, -1.08768761e-01f, -6.86127171e-02f, -1.18837439e-01f, -1.17707707e-01f, -1.19287767e-01f, 6.76581487e-02f, -4.67357561e-02f, 4.26932871e-02f, -1.56599551e-01f,
  -4.00191583e-02f, 7.06151202e-02f, 6.95848316e-02f, -1.23702466e-01f, -4.11377177e-02f, -7.76977390e-02f, -5.36212772e-02f, -7.78106228e-02f, 8.74067619e-02f, 6.62621632e-02f,
  6.08284399e-02f, -9.45365056e-02f, -1.08387761e-01f, -3.91556323e-03f, -1.67794541e-01f, 2.56712884e-01f, 1.07211716e-01f, 3.09651136e-01f, -2.04689220e-01f, 1.97692037e-01f,
  -2.98669279e-01f, -1.90156221e-01f, -4.36986936e-03f, 6.06142022e-02f, -5.90357408e-02f, -6.53194711e-02f, -1.21249720e-01f, -1.87280551e-01f, 1.31067216e-01f, 1.46568477e-01f,
  2.14279875e-01f, -2.78472722e-01f, 3.08916229e-03f, 1.48867238e-02f, 1.51639387e-01f, -1.70658693e-01f, 2.81198323e-02f, 1.16325831e-02f, 2.19902128e-01f, -2.98912898e-02f,
  -1.89417914e-01f, 2.62339711e-02f, 2.28286553e-02f, 2.07027286e-01f, 4.92359651e-03f, 3.48548405e-02f, 3.43365818e-02f, -8.94713029e-02f, -2.54470017e-02f, -6.33866712e-02f,
  1.07098185e-01f, -5.66249453e-02f, -9.09357425e-03f, 2.51403693e-02f, -2.04906873e-02f, 1.82844023e-03f, 3.64830606e-02f, 9.90883708e-02f, 3.23197688e-03f, -7.76751386e-03f,
  1.48818329e-01f, 1.62854850e-01f, 2.35223100e-01f, 1.15315452e-01f, -3.40332016e-02f, 1.06613059e-02f, 3.62594202e-02f, 1.72033682e-01f, -8.53481963e-02f, -2.96186749e-02f,
  9.62581486e-02f, 3.32668023e-05f, 6.44904748e-02f, -1.77713379e-01f, 8.04831390e-04f, -6.97908551e-02f, -2.27737740e-01f, 5.55971973e-02f, 2.39933338e-02f, -1.46619573e-01f,
  8.99556130e-02f, -5.20341285e-02f, -1.07434601e-01f, -6.83994889e-02f, -6.22268170e-02f, -2.29872420e-01f, 1.71152502e-02f, 7.13416040e-02f, -5.23635335e-02f, -1.41072214e-01f,
  3.39154080e-02f, -1.09230140e-02f, -1.26701593e-01f, 1.25918418e-01f, 7.62965828e-02f, 1.46152794e-01f, -4.91801500e-02f, 1.77074611e-01f, -1.29532034e-03f, -3.47916991e-03f,
  3.43892127e-02f, 1.29273653e-01f, 1.61455311e-02f, 2.35410079e-01f, -2.52286363e-02f, 4.75382954e-02f, -1.18889280e-01f, 1.66367888e-01f, -6.02307618e-02f, 1.82904676e-01f,
  -1.38798609e-01f, -1.22775085e-01f, 8.58432055e-03f, -7.90307000e-02f, 1.47299200e-01f, 1.66928619e-01f, -8.27071741e-02f, 6.13277953e-05f, -1.68983359e-02f, -4.70081605e-02f,
  2.19639000e-02f, 8.08025450e-02f, 3.04556973e-02f, -6.12179488e-02f, 9.27770808e-02f, -1.08066745e-01f, 2.19025707e-04f, 2.39427947e-02f, 1.47112116e-01f, -4.67380099e-02f,
  -1.51691765e-01f, -4.28251505e-01f, 2.26938855e-02f, -3.09786461e-02f, -1.01947002e-01f, -4.99414504e-02f, 1.43193435e-02f, -4.16853242e-02f, 1.89867049e-01f, 1.05060250e-01f,
  2.64415383e-01f, -7.11112171e-02f, 2.32396379e-01f, -1.74127132e-01f, -1.71880931e-01f, -7.15987310e-02f, 1.36695281e-01f, -2.93854833e-01f, 2.17375904e-02f, -1.62175640e-01f,
  -1.26540512e-02f, 4.59753051e-02f, 2.92842895e-01f, -2.03668669e-01f, 1.15655139e-01f, 4.81969081e-02f, -8.78312346e-03f, -4.44793329e-03f, -1.85811579e-01f, 2.74633169e-01f,
  -5.07221266e-04f, -1.14369102e-01f, 9.87191312e-03f, 1.16146497e-01f, -2.35455185e-01f, -2.48846086e-03f, -2.49676835e-02f, -7.10646287e-02f, 1.14587903e-01f, -2.51129176e-02f,
  -5.18762274e-04f, -2.05835570e-02f, -4.71142903e-02f, 1.82299033e-01f, 1.93812214e-02f, -7.20728487e-02f, 9.41343978e-02f, 1.45509347e-01f, 7.76234195e-02f, -7.15287495e-03f,
  1.19317847e-03f, -1.05984993e-01f, -9.77530181e-02f, 1.01890989e-01f, -4.24474068e-02f, 1.63246274e-01f, 1.03218310e-01f, -5.75796030e-02f, -1.59695715e-01f, -7.82451928e-02f,
  -6.18634522e-02f, 3.33378166e-02f, 5.14604747e-02f, 8.83367956e-02f, 1.47794455e-01f, 1.31554097e-01f, 8.81552249e-02f, -1.73155397e-01f, 2.87069917e-01f, -2.65425920e-01f,
  2.10778546e-02f, 5.54781854e-02f, 9.63731036e-02f, 1.53434619e-01f, -2.01529518e-01f, -9.13212001e-02f, -4.62088995e-02f, 7.84966126e-02f, 2.19425842e-01f, -7.14867637e-02f,
  -1.28386999e-02f, -1.10446267e-01f, 4.91430648e-02f, -4.74907132e-03f, -2.78526675e-02f, 3.86626795e-02f, 9.70874056e-02f, -3.73527296e-02f, 1.65808827e-01f, 5.10279611e-02f,
  -1.87656760e-01f, 1.94253609e-01f, -2.60874256e-02f, -5.41688576e-02f, -4.35412079e-02f, 1.02652915e-01f, -7.63440952e-02f, -2.01793894e-01f, -1.84273556e-01f, 1.32758677e-01f,
  5.04362397e-02f, 1.30298451e-01f, -1.18212342e-01f, 4.13787477e-02f, -1.00062378e-01f, -1.14743292e-01f, -4.15698476e-02f, 1.64515808e-01f, -1.33926466e-01f, -2.47957736e-01f,
  1.45842522e-01f, -3.37720104e-02f, 9.15007107e-03f, 4.93578566e-03f, -2.01555610e-01f, -3.46002765e-02f, -1.84391081e-01f, 1.18056409e-01f, 9.16450396e-02f, 1.36190981e-01f,
  5.92074217e-03f, 4.36695144e-02f, -3.87256071e-02f, 2.49702364e-01f, 5.36837503e-02f, 3.92388970e-01f, -1.17788767e-03f, 2.09818497e-01f, -3.46304923e-02f, 1.18673034e-01f,
  -2.85336953e-02f, 1.40344411e-01f, 9.43448469e-02f, -1.51233017e-01f, -1.22607678e-01f, -1.05389066e-01f, -1.35919238e-02f, -1.62828475e-01f, 2.55284943e-02f, 2.48061761e-01f,
  -1.38013974e-01f, -2.67901123e-01f, -9.97758377e-03f, -2.18220890e-01f, 4.76077460e-02f, -1.92683980e-01f, -7.86450412e-03f, -1.73884816e-02f, -4.66296114e-02f, 4.88953218e-02f,
  -6.56789392e-02f, -1.09522669e-02f, -1.39280498e-01f, 1.09556049e-01f, 1.09344848e-01f, 4.74262871e-02f, 1.93122298e-01f, 2.93719351e-01f, -1.23538144e-01f, 7.38541931e-02f,
  -1.87459141e-01f, -7.64590036e-03f, 1.36292223e-02f, 1.63776442e-01f, 1.86884589e-02f, -1.25778317e-01f, 3.05818412e-02f, 2.19240695e-01f, 3.05970199e-03f, -1.91760495e-01f,
  -1.77452639e-02f, -2.36891638e-02f, 1.39604434e-01f, -1.36960998e-01f, -7.93353021e-02f, -1.39041930e-01f, 1.92932367e-01f, 2.44233936e-01f, -8.95653069e-02f, 1.21366419e-02f,
  -5.26629351e-02f, 2.34507531e-01f, 2.83827409e-02f, -8.73706937e-02f, -3.77266966e-02f, 1.77980497e-01f, 1.78028569e-01f, 4.16158475e-02f, -9.87422690e-02f, 7.53732100e-02f,
  5.36756068e-02f, 1.37831211e-01f, 2.26029456e-02f, -3.36188711e-02f, 1.06952816e-01f, 1.18235290e-01f, -4.87401187e-02f, -2.18480211e-02f, 9.94707122e-02f, -3.30177218e-01f,
  -5.68855591e-02f, 3.77947986e-02f, 2.23331332e-01f, 1.77434608e-01f, -9.79670789e-03f, 9.45873372e-03f, -1.94957346e-01f, -1.45266697e-01f, 2.09381245e-02f, -1.28539205e-01f,
  8.73419046e-02f, 1.10230356e-01f, -2.56898790e-03f, -5.43464720e-02f, -2.40180921e-02f, -8.84184539e-02f, 1.63401868e-02f, 1.57716155e-01f, 1.96985006e-02f, -1.02560215e-01f,
  -1.71481937e-01f, 2.49662414e-01f, 4.92710173e-02f, -1.08606063e-01f, -1.59822673e-01f, 2.37844184e-01f, -3.23274881e-02f, 7.79570714e-02f, -1.17644928e-01f, 1.61240287e-02f,
  4.34133299e-02f, 9.71927345e-02f, 6.97419420e-02f, -9.38451439e-02f, -9.56241488e-02f, -2.04671752e-02f, -1.16415970e-01f, -1.34082675e-01f, 2.30059177e-01f, 4.25546728e-02f,
  1.73711136e-01f, 2.67153591e-01f, 7.68736526e-02f, -1.47653624e-01f, 7.13611916e-02f, -4.15321775e-02f, -5.61432950e-02f, -8.02898556e-02f, -7.49436468e-02f, -6.25159666e-02f,
  6.23820387e-02f, -7.63925985e-02f, 9.72353145e-02f, -9.94079709e-02f, -2.20792621e-01f, -2.07105069e-03f, -2.58980487e-02f, 7.43772313e-02f, 8.53010044e-02f, -2.43968144e-01f,
  -4.64997208e-03f, 2.41890792e-02f, 2.44683370e-01f, -2.09198251e-01f, -2.96850335e-02f, 2.19809353e-01f, -3.73236984e-02f, -1.05051413e-01f, 2.23113239e-01f, 1.73532262e-01f,
  3.59243214e-01f, 2.41532251e-01f, 2.19062284e-01f, 1.14440881e-01f, 1.31341457e-01f, -1.04080573e-01f, 8.53691548e-02f, 3.44696790e-02f, -3.11727822e-02f, -1.12960011e-01f,
  2.46106595e-01f, -1.18035614e-01f, 8.55291113e-02f, 8.43721777e-02f, -4.21956852e-02f, -5.60914166e-02f, -5.94843328e-02f, 4.54783514e-02f, 1.85072273e-02f, -1.66028261e-01f,
  -1.49241453e-02f, 2.16293689e-02f, -1.13625936e-01f, 3.21417302e-02f, -6.53164908e-02f, -5.72955608e-02f, -1.25524998e-01f, 2.33015865e-01f, -3.99785861e-02f, 1.41033232e-01f,
  1.37970336e-02f, -1.55474350e-01f, -2.67819017e-02f, 3.37157361e-02f, -4.10801135e-02f, 1.87197104e-01f, 8.77190605e-02f, 3.60904448e-02f, 1.68221742e-01f, -1.37493908e-01f,
  -3.83622833e-02f, -3.95225845e-02f, 1.01137370e-01f, -1.74551278e-01f, 9.39202905e-02f, 2.09141616e-02f, -5.61096705e-02f, 2.19236524e-03f, 3.54070663e-02f, -1.45182475e-01f,
  -3.57452631e-02f, -2.43453041e-01f, 1.71884924e-01f, -7.08172768e-02f, 8.66119191e-03f, 1.29545778e-01f, -5.06592728e-02f, -1.10448748e-01f, 2.27852017e-01f, -1.22358531e-01f,
  3.28895092e-01f, -1.11518770e-01f, 1.14751995e-01f, 3.27549339e-03f, -1.46855205e-01f, -1.55320708e-02f, 1.15349740e-01f, -1.28044467e-02f, 8.91246274e-02f, 1.35779142e-01f,
  7.30271786e-02f, -2.83437148e-02f, 2.83180743e-01f, -6.90280721e-02f, 2.10092679e-01f, 6.97833225e-02f, 7.74845928e-02f, -7.95290712e-03f, 7.32689425e-02f, -1.64629772e-01f,
  6.11341037e-02f, -6.50261492e-02f, -1.21606410e-01f, -1.23365417e-01f, -1.16403599e-03f, 8.99888668e-03f, -5.55985458e-02f, -2.13955104e-01f, 8.72720182e-02f, -1.70957491e-01f,
  6.02147505e-02f, 7.51467124e-02f, -1.16213724e-01f, -1.23993069e-01f, 2.00288981e-01f, 1.83269188e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.34288692e-02f, 5.91532476e-02f, -2.27834862e-02f, -1.78906098e-02f, -1.15750320e-01f, 2.48266846e-01f, -1.86021253e-01f, 1.59560159e-01f, 1.81594715e-01f, 1.82938024e-01f,
  7.26186531e-03f, 1.43818945e-01f, -5.75222373e-02f, 1.68602586e-01f, 3.24125611e-03f, 4.11955804e-01f, -7.40667135e-02f, 2.36923769e-01f, 8.81771371e-02f, -5.23277652e-03f,
  1.12299562e-01f, 3.65754366e-01f, -5.34308665e-02f, -3.76587719e-01f, -1.51753807e-02f, -2.55336761e-01f, -2.04220772e-01f, 1.08021803e-01f, -1.21032856e-01f, 2.26939753e-01f,
  -1.17711052e-01f, -1.81668028e-01f, -2.78133750e-01f, -1.70129254e-01f, -2.77651519e-01f, -3.56054097e-01f, -3.74540798e-02f, 2.66591106e-02f, -2.48613525e-02f, 8.35691169e-02f,
  -1.92203283e-01f, -1.50712430e-01f, 2.34879050e-02f, 3.20513994e-01f, -2.76967824e-01f, -3.17283012e-02f, 2.74542958e-01f, 4.24020916e-01f, 2.76700944e-01f, -1.07796833e-01f,
  4.49289801e-03f, -9.89863202e-02f, -1.70955747e-01f, 7.21941292e-02f, 1.14717655e-01f, 6.48958189e-03f, 2.48945326e-01f, 3.28880638e-01f, 2.11718023e-01f, 7.34561980e-02f,
  1.56542018e-01f, 1.90317571e-01f, -5.91296516e-02f, 2.16538072e-01f, 1.78661253e-02f, -4.28325385e-02f, -4.74826135e-02f, 6.15664124e-01f, 3.25872451e-02f, -3.19461687e-04f,
  4.37167026e-02f, 3.00328583e-01f, 6.71375617e-02f, 2.94963837e-01f, 1.04619525e-01f, -5.66792153e-02f, 4.91612226e-01f, 1.25345126e-01f, 1.13644429e-01f, 8.91056471e-03f,
  2.57404238e-01f, 1.38252407e-01f, 1.20103434e-01f, -3.69045675e-01f, 3.99821728e-01f, 3.48184109e-02f, 1.16877459e-01f, -3.20157379e-01f, 1.69442773e-01f, -1.34359866e-01f,
  1.19142614e-01f, -1.00050934e-01f, 3.48342955e-01f, -1.16244517e-02f, 3.69340181e-01f, -1.41993836e-01f, -8.37445930e-02f, -1.37936383e-01f, 2.81599641e-01f, -2.53369927e-01f,
  1.49184167e-01f, 1.06357485e-02f, 1.23511404e-01f, -2.94487923e-01f, 7.26200193e-02f, 1.03936180e-01f, 7.29277730e-02f, 1.42993450e-01f, 7.58749619e-02f, 1.57451600e-01f,
  -2.65347958e-01f, 2.16431022e-01f, 5.39567741e-03f, -5.78998886e-02f, 1.50706798e-01f, 1.43807963e-01f, -3.45556438e-01f, 3.17132622e-02f, -3.63600373e-01f, 8.23853612e-02f,
  8.15098360e-02f, -1.94184091e-02f, 3.76374096e-01f, 2.04398707e-02f, 1.12031557e-01f, 4.84746546e-01f, 6.97462587e-03f, -7.51452670e-02f, 1.66351646e-01f, 4.41033617e-02f,
  1.94783941e-01f, -2.40378886e-01f, 1.46018356e-01f, -9.69064459e-02f, 1.37060910e-01f, -1.34069592e-01f, -4.04349416e-02f, 1.42511442e-01f, 3.03856492e-01f, -8.54766518e-02f,
  -6.25616759e-02f, -2.40684766e-02f, -1.54527977e-01f, 3.78483869e-02f, 1.31340278e-02f, -5.86510003e-02f, 7.82594457e-02f, -2.11079255e-01f, -8.66013858e-03f, -2.91649371e-01f,
  3.88671011e-01f, 3.51470530e-01f, -3.46080840e-01f, 4.76450622e-01f, 4.08010870e-01f, -2.08884373e-01f, 1.47539586e-01f, -5.01597941e-01f, 2.32833251e-01f, -6.09461032e-02f,
  6.99847490e-02f, -1.94772154e-01f, 1.92997679e-01f, 3.55285704e-01f, 1.48192629e-01f, 1.01295024e-01f, -5.94262481e-02f, 3.44173282e-01f, 2.26408705e-01f, -9.34434682e-03f,
  2.62062281e-01f, 6.14942200e-02f, -1.60461683e-02f, -5.85470442e-03f, 2.53562719e-01f, 3.60915922e-02f, 1.72644436e-01f, 7.24010766e-02f, 2.12130863e-02f, -1.38284922e-01f,
  -2.25976676e-01f, 3.83691549e-01f, -2.41064519e-01f, 1.94641218e-01f, 4.13167953e-01f, -3.38279337e-01f, 5.63226677e-02f, 6.00674190e-03f, 1.01577505e-01f, -7.59589206e-03f,
  4.78427619e-01f, 3.41790654e-02f, -9.78627428e-02f, -4.18495573e-02f, 2.37630289e-02f, 3.37138474e-01f, -5.67006432e-02f, 2.99243361e-01f, -1.46001149e-02f, 1.46883830e-01f,
  1.05354033e-01f, -4.89005633e-02f, 3.34008299e-02f, 2.94889599e-01f, 1.99160933e-01f, -5.31097990e-04f, -2.91452389e-02f, 1.40688658e-01f, 1.23526640e-01f, 8.36073980e-02f,
  1.80992596e-02f, -7.45341331e-02f, 3.00940216e-01f, 4.41167563e-01f, 2.03170180e-02f, -7.98793808e-02f, -2.18985900e-01f, -2.08223060e-01f, -7.97745585e-02f, -1.13592371e-01f,
  2.51284003e-01f, 2.72665054e-01f, -1.58091515e-01f, -3.31614524e-01f, -4.30968434e-01f, -2.61765331e-01f, 8.61648023e-02f, -2.68743426e-01f, 1.50013372e-01f, 3.95012051e-01f,
  -6.99609742e-02f, -5.86228594e-02f, -2.56552160e-01f, 2.49209926e-01f, -1.61927834e-01f, 3.01392436e-01f, -1.92730933e-01f, -1.88521165e-02f, -1.17454035e-02f, 5.48328459e-01f,
  -1.29084662e-01f, -3.71032320e-02f, -7.99391642e-02f, 3.69323701e-01f, 2.88425624e-01f, -9.03071910e-02f, 1.75360501e-01f, 1.30046150e-02f, 2.01240376e-01f, 1.03860997e-01f,
  -1.20545803e-02f, -1.43496925e-02f, -1.28258280e-02f, 3.20162207e-01f, -7.03657791e-02f, -9.46513563e-02f, 2.84202009e-01f, 2.65297472e-01f, -1.01617239e-01f, 2.73758452e-02f,
  1.14070415e-01f, 1.73423681e-02f, 6.95721209e-02f, 1.75844263e-02f, 1.32580236e-01f, 3.19820970e-01f, -3.83549295e-02f, 4.20047268e-02f, 6.26979209e-03f, 2.92944878e-01f,
  2.02135563e-01f, 2.84330845e-01f, -1.94129851e-02f, 8.79870058e-05f, -6.17561042e-02f, 6.52758852e-02f, 1.33393094e-01f, 1.67190433e-01f, 1.28941610e-01f, -2.22068295e-01f,
  5.50284646e-02f, -1.71454042e-01f, -2.76018493e-02f, 1.56896412e-01f, 1.27196819e-01f, 1.27431348e-01f, 1.25860617e-01f, -3.46411377e-01f, -1.28937364e-01f, -2.75790989e-01f,
  2.22650766e-01f, -2.65843898e-01f, 1.72184482e-01f, -6.08969145e-02f, 1.59326911e-01f, 1.16922453e-01f, 7.13949371e-03f, 1.30204096e-01f, -2.07037553e-02f, 2.37481184e-02f,
  -1.11092396e-01f, 3.94252017e-02f, 1.15564935e-01f, 2.66052306e-01f, -1.40717760e-01f, -1.58016458e-02f, 2.12422252e-01f, -8.13549086e-02f, -2.63288915e-01f, 7.89471623e-03f,
  -1.22989692e-01f, -7.35823363e-02f, 1.44009724e-01f, 1.62535638e-01f, 6.91131502e-02f, -1.02649048e-01f, 1.71215743e-01f, 3.60076308e-01f, 1.73871964e-01f, -6.25557229e-02f,
  5.22833131e-02f, -3.42124373e-01f, 3.75264466e-01f, 4.30975974e-01f, -2.99362447e-02f, 6.13546893e-02f, 1.88013818e-02f, 1.56168357e-01f, -2.27161474e-03f, 2.20017418e-01f,
  6.79027885e-02f, 1.42031029e-01f, -4.42632996e-02f, -6.01927675e-02f, -3.79189737e-02f, 2.00761721e-01f, 2.70837516e-01f, 2.60879129e-01f, 1.47857264e-01f, -5.02169907e-01f,
  2.96048582e-01f, 1.18820854e-01f, 1.31541684e-01f, -9.30874720e-02f, -3.28742974e-02f, -1.55211553e-01f, 1.90148413e-01f, 8.16223845e-02f, 5.26441932e-01f, -3.67926285e-02f,
  3.27137500e-01f, -1.63760096e-01f, -3.89335603e-01f, -3.55251320e-02f, 1.06801778e-01f, -3.23042035e-01f, 2.66165644e-01f, 1.71307281e-01f, 6.71171173e-02f, -4.83059511e-02f,
  -8.27090144e-02f, -1.56020135e-01f, 2.18989879e-01f, -4.48539965e-02f, -1.07585140e-01f, -1.34522960e-01f, 4.91085276e-03f, 3.83994520e-01f, 2.54752070e-01f, -1.87380001e-01f,
  2.30242506e-01f, 1.73150763e-01f, -2.62818903e-01f, 3.04696541e-02f, -1.74226567e-01f, -1.06664889e-01f, 4.70435381e-01f, -4.12661657e-02f, 2.02047348e-01f, 1.05023265e-01f,
  1.91639483e-01f, 5.22930324e-01f, 2.12786704e-01f, 1.26825431e-02f, 5.18604100e-01f, 1.47115648e-01f, 2.28298739e-01f, 2.28277996e-01f, -2.94993585e-03f, -1.77139699e-01f,
  -2.80509830e-01f, -1.70006812e-01f, -1.62292615e-01f, 2.74197549e-01f, 7.36830086e-02f, -9.00114775e-02f, 2.04905868e-01f, 2.23377526e-01f, 2.47354776e-01f, 2.03186601e-01f,
  3.70467231e-02f, -1.80584133e-01f, 2.11503878e-01f, -6.66602552e-02f, 5.18200435e-02f, -3.45723271e-01f, 1.21260591e-01f, -8.97502899e-02f, 2.19540969e-01f, -3.64758223e-01f,
  2.58249432e-01f, 3.11899990e-01f, 2.90019959e-01f, 9.52084288e-02f, 2.28613332e-01f, -1.69295147e-01f, -1.61346897e-01f, -1.78969979e-01f, 6.00040972e-01f, 7.50647932e-02f,
  5.25486656e-03f, 1.60614699e-01f, -8.30887482e-02f, 1.75949067e-01f, 8.05717409e-02f, -8.04022178e-02f, 4.82326776e-01f, -2.92553753e-01f, -9.57861096e-02f, 3.61340523e-01f,
  1.22052312e-01f, -2.66265810e-01f, -6.96154162e-02f, 2.41670489e-01f, 5.24132438e-02f, -3.20429742e-01f, -2.27806687e-01f, 9.18069184e-02f, 1.19041562e-01f, -3.55650298e-03f,
  1.98136985e-01f, 4.84004691e-02f, -1.82395875e-01f, 3.89930345e-02f, 2.52085656e-01f, 2.39131171e-02f, 1.40211672e-01f, -9.18064415e-02f, 1.26485273e-01f, 9.22070965e-02f,
  -3.58559075e-03f, 3.04382071e-02f, 1.75787434e-01f, -1.35479033e-01f, 2.54584461e-01f, -1.47246778e-01f, 1.34757727e-01f, 6.56173900e-02f, 1.68841794e-01f, -1.69383079e-01f,
  -9.41485465e-02f, 7.42280781e-02f, 7.84766674e-02f, -1.91595748e-01f, 3.09234083e-01f, 1.01254106e-01f, -4.22508493e-02f, -3.61669391e-01f, 2.24391520e-01f, -7.36384243e-02f,
  1.89280570e-01f, 3.28569651e-01f, -3.30814868e-01f, 2.88745165e-01f, 2.71758050e-01f, -2.20871329e-01f, 2.28673607e-01f, -4.07144517e-01f, 4.09963787e-01f, 5.26275486e-02f,
  -2.33355507e-01f, -1.67696044e-01f, 7.16664121e-02f, 3.33697498e-01f, -1.63848624e-01f, -7.49676526e-02f, 9.10417438e-02f, 3.15323412e-01f, 3.89945626e-01f, 1.38852045e-01f,
  2.78325617e-01f, 9.77080595e-03f, 5.23741357e-03f, 2.35992260e-02f, 2.70916913e-02f, -3.20106179e-01f, 3.38940829e-01f, -1.83804575e-02f, 3.59391868e-01f, 7.63306692e-02f,
  -3.20996612e-01f, 4.50151525e-02f, -2.99135633e-02f, -5.36041846e-03f, 3.02689284e-01f, -8.29824209e-02f, 9.56392735e-02f, 3.65469068e-01f, 1.76200002e-01f, -1.76935513e-02f,
  3.70773613e-01f, 1.87280864e-01f, 7.60393813e-02f, 1.62223354e-01f, 8.87924060e-02f, 1.27991498e-01f, 8.50995928e-02f, 3.30218405e-01f, 2.99373090e-01f, 1.55445114e-01f,
  2.45298833e-01f, -4.50627469e-02f, 9.23301578e-02f, 8.67315158e-02f, 4.42400724e-01f, 8.35657865e-02f, 1.49816886e-01f, -2.47351885e-01f, 1.08915597e-01f, 6.87729865e-02f,
  -9.87649430e-03f, 1.83752216e-02f, 1.32267997e-01f, 3.42044711e-01f, -9.61957797e-02f, -1.24281392e-01f, -2.95832872e-01f, -1.00372196e-03f, -6.43439293e-02f, -2.39055410e-01f,
  -2.07549170e-01f, -6.32741973e-02f, -7.41009116e-02f, 4.02512215e-03f, -1.67115420e-01f, -1.88098744e-01f, -4.57267314e-01f, 1.01547681e-01f, -2.70447046e-01f, -8.27081501e-02f,
  7.97937438e-02f, 2.08481357e-01f, -1.48237258e-01f, -1.83826402e-01f, -1.78829879e-01f, 2.88720634e-02f, -3.29322070e-01f, 1.80341322e-02f, 5.11388630e-02f, -1.96703821e-01f,
  1.60522684e-01f, 7.16817081e-02f, 1.88608229e-01f, -1.16481639e-01f, 3.48889440e-01f, -4.54373397e-02f, 2.95814544e-01f, 1.19841263e-01f, 1.02357753e-01f, 1.82937041e-01f,
  3.14654261e-02f, 4.13255990e-01f, -3.87659371e-02f, -1.10748254e-01f, 4.42847945e-02f, 4.90526762e-03f, 2.97400802e-02f, 3.73226241e-04f, -9.08282101e-02f, -3.33285391e-01f,
  1.64209515e-01f, 1.38907000e-01f, 3.20511609e-01f, 1.12955220e-01f, 3.06166500e-01f, 1.07275315e-01f, -2.10429281e-01f, -2.35964004e-02f, 1.20738663e-01f, -1.11845769e-02f,
  1.17564937e-02f, -3.69666480e-02f, -1.41492292e-01f, 1.43274412e-01f, -5.70951514e-02f, 2.94940174e-01f, 1.94896050e-02f, 1.77222595e-01f, 1.38646945e-01f, -2.72436738e-01f,
  -2.43229985e-01f, 2.27515120e-02f, -3.00868273e-01f, -2.45065734e-01f, -2.86379576e-01f, 3.57733279e-01f, -4.36555326e-01f, 1.16217852e-01f, 7.80787542e-02f, -2.00771689e-01f,
  -4.76771951e-01f, -2.29540274e-01f, -3.12481344e-01f, 8.04079026e-02f, -5.11162579e-02f, -4.08502258e-02f, -1.37443185e-01f, 3.30701798e-01f, -3.88326228e-01f, 4.48557228e-01f,
  4.76093106e-02f, -1.80452596e-02f, 3.77800018e-01f, -1.37960762e-01f, -1.72957033e-01f, 1.63765177e-01f, -7.53112882e-02f, 1.19678117e-01f, 2.13846296e-01f, -4.93657403e-02f,
  3.39127272e-01f, 1.65138111e-01f, -1.44173250e-01f, 2.21726701e-01f, 1.77511141e-01f, -3.16537440e-01f, 3.03279340e-01f, 4.94043231e-02f, -1.27207696e-01f, -7.21750036e-02f,
  2.49189064e-02f, 7.02292249e-02f, 3.13149355e-02f, 1.52699590e-01f, -1.33056700e-01f, 2.33547702e-01f, -1.17060356e-01f, 4.03193533e-01f, 2.51083132e-02f, 4.30870019e-02f,
  -3.82155403e-02f, 4.04372871e-01f, -1.10022984e-01f, 2.58420140e-01f, 1.77344203e-01f, 4.94615972e-01f, 1.26887366e-01f, 9.93447453e-02f, -9.76273119e-02f, 3.17450278e-02f,
  2.94291079e-01f, 2.21288592e-01f, 8.22345465e-02f, -1.86021581e-01f, 1.75799489e-01f, -5.54624982e-02f, -4.90415663e-01f, 2.63424754e-01f, 1.16340950e-01f, 3.21576655e-01f,
  -1.16406292e-01f, -2.91727722e-01f, -2.15631545e-01f, -2.77507544e-01f, -3.74398679e-02f, -5.05597949e-01f, -1.46542694e-02f, 1.11515634e-01f, -1.29033148e-01f, -7.90209416e-03f,
  -3.35890740e-01f, -2.95721348e-02f, 1.95197240e-01f, 2.45495066e-01f, -1.50988907e-01f, -1.06201470e-01f, -2.79857945e-02f, 4.85784292e-01f, 9.76804048e-02f, -2.30304658e-01f,
  1.70117229e-01f, 1.37324154e-01f, -9.87114310e-02f, 1.12904593e-01f, 6.77680895e-02f, -1.13963403e-01f, 2.80460924e-01f, 3.73826295e-01f, 3.92039157e-02f, -6.89871982e-02f,
  1.57739207e-01f, 2.01494336e-01f, -5.20722643e-02f, 3.02268296e-01f, 1.31209930e-02f, 1.62082598e-01f, -5.85492514e-02f, 4.04104404e-03f, 5.44985458e-02f, 7.94862807e-02f,
  2.10923657e-01f, -2.63241064e-02f, 2.12773308e-01f, 1.29731400e-02f, 5.31164035e-02f, -3.02493870e-01f, 2.06203908e-01f, 1.07858494e-01f, 2.57879794e-01f, -2.13661566e-01f,
  2.41392806e-01f, 8.01074877e-02f, 2.58151412e-01f, -3.78882706e-01f, -5.32715246e-02f, -1.74962953e-01f, -1.25896081e-01f, -7.46229365e-02f, 3.44924837e-01f, -8.48869160e-02f,
  1.16502896e-01f, 9.64386314e-02f, -3.04741293e-01f, -2.37825781e-01f, 1.60463005e-01f, 4.16967660e-01f, 2.47834757e-01f, 4.41758364e-01f, -1.49687678e-01f, 1.35128573e-01f,
  4.50254604e-02f, -5.56379259e-01f, 3.77577782e-01f, -1.37708029e-02f, 3.26673351e-02f, 1.84022352e-01f, 5.22541702e-02f, -2.91657627e-01f, 3.05368230e-02f, -8.06137547e-02f,
  -3.44836265e-02f, 1.75597414e-01f, 4.06578124e-01f, -3.40883695e-02f, 6.12949356e-02f, -3.29231210e-02f, -2.26199642e-01f, 1.88510031e-01f, 3.12522724e-02f, 2.32465398e-02f,
  -1.22601204e-01f, -2.10173607e-01f, 2.48841405e-01f, 3.66218805e-01f, 5.30816391e-02f, 2.09837958e-01f, 7.13159740e-02f, 2.09748372e-01f, 2.79089183e-01f, 1.21188968e-01f,
  -7.49901682e-03f, -1.39293484e-02f, 1.96995270e-02f, 1.43128216e-01f, 1.39569910e-03f, 1.04671463e-01f, 1.14318550e-01f, 2.07570732e-01f, 1.05731472e-01f, 1.74735561e-02f,
  2.58179814e-01f, 2.43027911e-01f, 2.06120610e-01f, 2.44304851e-01f, 1.78006291e-03f, 2.61608828e-02f, 3.92842367e-02f, 1.74279973e-01f, 2.12273777e-01f, 2.61867382e-02f,
  -6.03944324e-02f, -1.81665748e-01f, -1.16612367e-01f, -1.21513024e-01f, 5.44043779e-02f, 1.16095424e-01f, 1.88062131e-01f, 8.30568224e-02f, -1.40414491e-01f, -2.52459377e-01f,
  -1.00800253e-01f, -2.28274152e-01f, 1.07888639e-01f, -1.49172574e-01f, -3.26614112e-01f, 8.45064819e-02f, -9.15160254e-02f, 2.24437788e-01f, 4.98411395e-02f, -1.57644317e-01f,
  2.96346903e-01f, 5.09167984e-02f, -4.46951807e-01f, 3.73942494e-01f, 2.11756945e-01f, -2.35121056e-01f, -6.42214417e-02f, 1.84759781e-01f, 6.93092719e-02f, -5.48470795e-01f,
  -1.08742975e-01f, 9.88624394e-02f, 2.65489876e-01f, 1.63235933e-01f, 3.00829351e-01f, 2.24115565e-01f, -3.22169244e-01f, 7.45840147e-02f, 2.71414071e-01f, 2.07792930e-02f,
  6.35867473e-04f, 1.07859679e-01f, 1.79317132e-01f, -1.52256005e-02f, 1.05323317e-02f, 1.57295715e-03f, -8.61647446e-03f, 1.34342805e-01f, 2.57928431e-01f, 1.06551439e-01f,
  1.25632510e-01f, -6.35076165e-02f, 6.06984124e-02f, 1.38766810e-01f, 3.25452715e-01f, 1.65288579e-02f, 4.79973368e-02f, -9.56161395e-02f, 2.27203574e-02f, 4.35202606e-02f,
  1.91520583e-02f, 2.01266676e-01f, 7.04000331e-03f, -9.44196135e-02f, -2.38183662e-01f, 1.09193571e-01f, -1.17587678e-01f, -1.59179568e-01f, 1.82377338e-01f, -1.02397978e-01f,
  -1.89850792e-01f, -1.49393752e-01f, 2.50958025e-01f, 1.33428812e-01f, -4.93738167e-02f, -9.90274847e-02f, 2.05986090e-02f, 2.71121800e-01f, -2.98891217e-01f, -2.03159451e-01f,
  -8.41844603e-02f, 1.61610186e-01f, -1.23159423e-01f, -4.33121473e-01f, -6.59268647e-02f, -1.31956041e-01f, -3.89571309e-01f, 1.02676123e-01f, 1.71690375e-01f, -4.20600981e-01f,
  3.37009370e-01f, -1.54186457e-01f, 2.66502321e-01f, -1.72076240e-01f, -1.52042713e-02f, -1.13509364e-01f, 2.66781628e-01f, -3.76547068e-01f, 8.03844407e-02f, -1.19959414e-01f,
  2.06146538e-01f, 5.31884730e-01f, 2.36417782e-02f, -1.54561445e-01f, 1.10337213e-01f, -2.04023030e-02f, 2.18818486e-01f, 5.94555438e-02f, 1.76443860e-01f, 1.20203704e-01f,
  1.31308064e-01f, -5.43559082e-02f, 1.15659111e-03f, 1.38221726e-01f, 7.34770820e-02f, -2.59653982e-02f, 4.38454062e-01f, 1.75006077e-01f, -5.90147823e-03f, -2.46937503e-04f,
  9.83672962e-02f, -2.19273031e-01f, 2.85601556e-01f, 8.02001730e-02f, 2.53899097e-01f, 5.22035301e-01f, 1.69497523e-02f, -2.04009145e-01f, 2.52853751e-01f, 1.05693750e-01f,
  1.35189444e-01f, 2.35548586e-01f, 1.75975636e-01f, 2.15377107e-01f, -1.05629424e-02f, -1.99545577e-01f, 8.97598639e-02f, 1.87594518e-01f, 2.30569333e-01f, 1.69560295e-02f,
  2.44089235e-02f, 4.57083195e-01f, 5.99771500e-01f, 7.55733177e-02f, 6.48557395e-02f, 2.14452907e-01f, -1.17897414e-01f, -3.15216221e-02f, 1.48563981e-01f, -9.23781469e-02f,
  -1.81906894e-01f, 6.22730851e-02f, -1.52944863e-01f, -1.56205535e-01f, -8.33210349e-02f, 4.98994216e-02f, 2.08041102e-01f, -4.69065100e-01f, 4.41356152e-01f, 4.85548265e-02f,
  6.71398640e-02f, 2.17408255e-01f, 2.80985802e-01f, -4.87389266e-02f, -1.20810479e-01f, -6.78665340e-02f, -1.77195162e-01f, 3.97195891e-02f, 3.19928288e-01f, -2.36270905e-01f,
  3.08191746e-01f, 7.79508874e-02f, 1.58331603e-01f, 6.08865730e-02f, 7.76821151e-02f, 1.70336708e-01f, -9.33898613e-02f, 1.03025369e-01f, 8.58117566e-02f, 1.41479000e-01f,
  -6.13322994e-03f, 6.34423196e-02f, -3.90248820e-02f, 3.06393385e-01f, 2.40785971e-01f, -4.08996791e-02f, 2.48533748e-02f, 1.55536132e-02f, -1.07782632e-01f, 5.74203059e-02f,
  6.53266832e-02f, -1.13406681e-01f, -1.71905175e-01f, 2.83321321e-01f, 1.46341234e-01f, -6.56347871e-02f, 1.47063792e-01f, 3.38368356e-01f, -9.95191336e-02f, -2.20397294e-01f,
  2.47307226e-01f, 2.03442723e-01f, -3.80959511e-01f, 7.15886131e-02f, -5.23714945e-02f, 2.13714391e-01f, -3.79730880e-01f, -3.36879343e-01f, 2.15269119e-01f, 1.25257969e-01f,
  -1.41819015e-01f, -2.52480209e-01f, 9.60257798e-02f, -1.26134574e-01f, -2.03316584e-01f, 2.86640525e-02f, -3.77238318e-02f, -3.19400817e-01f, 4.17936027e-01f, -1.11652594e-02f,
  2.55722970e-01f, 1.98832095e-01f, 1.76532000e-01f, -1.65558785e-01f, 3.06255162e-01f, -1.66644469e-01f, 3.28442380e-02f, -1.97051166e-04f, 5.82272597e-02f, 5.86521983e-01f,
  2.45911777e-02f, -2.34932631e-01f, -5.57284392e-02f, 1.26951173e-01f, 2.18408331e-01f, -1.23329282e-01f, 1.84307352e-01f, 3.49242240e-03f, 2.53446735e-02f, -1.28229588e-01f,
  -2.61784643e-01f, 1.19453959e-01f, 4.73664422e-03f, -1.83638886e-01f, 7.85128325e-02f, 5.09446084e-01f, -1.08678713e-01f, -1.48733808e-02f, 8.03070664e-02f, 1.69644892e-01f,
  3.31933126e-02f, -1.99179146e-02f, 9.87347364e-02f, 5.25581419e-01f, -1.14782631e-01f, 3.19378793e-01f, 3.15786183e-01f, -4.93629929e-03f, 3.45521361e-01f, -1.70102954e-01f,
  -4.01509516e-02f, 2.82041073e-01f, -1.67339250e-01f, 1.06919385e-01f, 4.84363735e-02f, 1.41594708e-01f, -2.01458950e-02f, 3.26236367e-01f, -5.97547032e-02f, 3.68062198e-01f,
  3.09538096e-01f, 3.61642838e-01f, 2.87645310e-01f, -9.32659730e-02f, -2.09641606e-01f, -4.99192290e-02f, -3.06597427e-02f, -1.07394708e-02f, 5.56870624e-02f, 1.37656657e-02f,
  -1.63121849e-01f, 5.47080953e-03f, -3.47730741e-02f, 6.92406595e-02f, 2.54683763e-01f, -3.49072635e-01f, 4.11940485e-01f, 6.61999583e-02f, -3.31068859e-02f, 1.28028363e-01f,
  -1.58296316e-03f, 2.14686617e-01f, -4.30074364e-01f, 3.01003829e-02f, 1.03985947e-02f, -5.08757345e-02f, -3.56476903e-01f, -2.06866465e-03f, 6.82273209e-02f, -1.91946357e-01f,
  -3.83721367e-02f, -1.26034006e-01f, -1.08488627e-01f, 3.05094004e-01f, 3.04499537e-01f, 8.10973421e-02f, 2.48267263e-01f, 7.12141842e-02f, 3.33980732e-02f, 2.61561334e-01f,
  1.96318282e-03f, -8.13502297e-02f, -9.65839159e-03f, 4.01395075e-02f, -4.80030514e-02f, 1.23753287e-01f, -1.09665275e-01f, 5.70358243e-04f, 1.85405657e-01f, 3.19663405e-01f,
  -1.14583462e-01f, 9.28406417e-02f, -5.71445882e-01f, 2.53908336e-01f, -2.01010946e-02f, -4.91797090e-01f, -1.95023581e-01f, -9.24186856e-02f, -2.49195307e-01f, -2.56791443e-01f,
  -2.24083304e-01f, -3.28831166e-01f, -2.87181109e-01f, -1.17495604e-01f, -5.35954058e-01f, 5.97537197e-02f, -1.57298967e-01f, 3.06804031e-01f, -1.83140293e-01f, 7.06933215e-02f,
  -3.67722869e-01f, 3.72832477e-01f, -2.13367373e-01f, 1.48733854e-01f, 3.19639653e-01f, -6.15665205e-02f, -2.92904163e-03f, -2.50336062e-02f, -4.63701449e-02f, 3.04030150e-01f,
  1.90066561e-01f, -1.76391192e-03f, 2.67664671e-01f, -8.29650089e-02f, 2.61129975e-01f, 5.31325266e-02f, 1.39850035e-01f, 2.64954776e-01f, 1.74304843e-02f, 2.04249434e-02f,
  2.22386509e-01f, -1.10006763e-03f, 1.47491395e-01f, -1.23898480e-02f, 1.93488374e-01f, 1.46932835e-02f, -3.48360557e-03f, 9.05090049e-02f, -1.61211208e-01f, 2.14348733e-01f,
  -4.47723642e-02f, 3.02762866e-01f, 1.49979651e-01f, 4.51006055e-01f, -1.17420398e-01f, -8.28380734e-02f, -1.36448905e-01f, 1.67157471e-01f, 6.38809009e-03f, 1.03567943e-01f,
  5.81706651e-02f, 5.52323945e-02f, 3.12070638e-01f, 3.13436426e-03f, 2.19175547e-01f, -1.48200721e-01f, -4.68553416e-02f, 4.02163900e-02f, 6.33845776e-02f, 1.13738604e-01f,
  3.16300899e-01f, 6.23597726e-02f, -2.60258783e-02f, -3.06876063e-01f, -3.11394036e-01f, -3.59996885e-01f, 2.71545172e-01f, -1.75037712e-01f, 4.41292636e-02f, 3.94272983e-01f,
  -2.71617442e-01f, 2.74400532e-01f, -1.79685466e-02f, 1.16304956e-01f, 2.01351643e-01f, 2.66711324e-01f, 5.80313988e-02f, 1.61821917e-01f, 1.01631947e-01f, -3.37464106e-03f,
  -3.23123455e-01f, -4.27450053e-02f, 1.54419512e-01f, -2.13393271e-02f, -2.11129621e-01f, 2.65685290e-01f, -5.70970736e-02f, -4.27128524e-02f, 5.39966285e-01f, 3.34028192e-02f,
  3.67830470e-02f, -1.99690148e-01f, 1.92565531e-01f, -2.15503648e-02f, 2.02590838e-01f, 8.99988487e-02f, 1.15604371e-01f, 1.82103902e-01f, 1.22759394e-01f, 3.36900026e-01f,
  2.40647018e-01f, -4.12806049e-02f, 6.89513013e-02f, 8.92651975e-02f, 2.74493158e-01f, -4.23997492e-02f, -8.55653211e-02f, -4.36256379e-02f, 3.33714038e-01f, -1.48867294e-01f,
  2.69707799e-01f, 6.79479504e-04f, -1.25461742e-01f, -3.88632976e-02f, 2.20209152e-01f, -1.34135559e-01f, 2.05622930e-02f, 6.78191930e-02f, 7.39336312e-02f, -2.19237342e-01f,
  1.96537524e-01f, -3.63169461e-01f, -1.20248273e-01f, 4.28717397e-02f, -2.73112744e-01f, 2.49851838e-01f, -2.73531862e-02f, 1.77416295e-01f, 1.81990743e-01f, 1.13954805e-01f,
  8.90342072e-02f, 2.36152648e-03f, 6.43718541e-02f, -4.35322896e-02f, 2.76921123e-01f, -1.70087069e-01f, -2.85587925e-02f, 3.28193545e-01f, 8.04243088e-02f, -5.27236089e-02f,
  1.31914809e-01f, 3.03251415e-01f, 1.02937564e-01f, 1.92604840e-01f, 7.55556077e-02f, 4.11654234e-01f, -1.33453846e-01f, 1.86208084e-01f, 2.79773831e-01f, -3.78585830e-02f,
  2.27069706e-01f, 3.47368479e-01f, -3.11110020e-01f, 1.28829017e-01f, -4.32363637e-02f, -1.59177214e-01f, 2.03031227e-01f, 5.13458610e-01f, -9.77487564e-02f, -5.52032422e-03f,
  -5.44531923e-03f, -1.01050124e-01f, 1.25440240e-01f, -3.06698889e-01f, 4.08922359e-02f, -6.18479215e-02f, 3.44154358e-01f, -1.12877883e-01f, 3.96074168e-03f, -1.96941989e-03f,
  7.93515816e-02f, 3.31074670e-02f, -1.94487050e-01f, -2.40756467e-01f, -5.35698200e-04f, -1.37485132e-01f, -6.99612796e-02f, -1.91792473e-02f, 1.61078408e-01f, 1.81979209e-01f,
  -4.84111249e-01f, -8.88948143e-02f, 8.03441778e-02f, 1.59654990e-02f, -5.02482019e-02f, 1.55976281e-01f, -1.40703589e-01f, 2.82392036e-02f, -2.32329547e-01f, 1.73196927e-01f,
  -5.67725524e-02f, 3.18463296e-01f, 4.67394769e-01f, 2.06135511e-01f, -1.70683965e-01f, 2.42554337e-01f, -4.54911441e-02f, 2.13768452e-01f, 2.98205853e-01f, 2.44739071e-01f,
  -2.25258932e-01f, 2.20002040e-01f, -8.88555124e-02f, 1.84970498e-02f, 7.07681030e-02f, 2.43585244e-01f, 1.42622396e-01f, -1.43334940e-01f, 4.73914295e-02f, 1.70173109e-01f,
  5.30280769e-02f, -1.01686157e-01f, 4.18562472e-01f, 1.56337786e-02f, 1.09049574e-01f, 9.36776698e-02f, -1.61426142e-01f, -8.54252055e-02f, -2.35518232e-01f, 4.12734896e-01f,
  3.18760201e-02f, -1.46219805e-01f, 2.27001876e-01f, -1.57178715e-01f, -1.50831025e-02f, 4.38297421e-01f, 1.21175334e-01f, 3.52046907e-01f, 1.85278594e-01f, -3.87234762e-02f,
  3.00108105e-01f, 2.28613280e-02f, 1.31042466e-01f, -2.35259291e-02f, 1.82070941e-01f, -7.66861066e-02f, 2.60778535e-02f, 9.55204293e-02f, 1.85733318e-01f, -3.29473093e-02f,
  1.12073444e-01f, 8.61392394e-02f, 2.49929018e-02f, -1.09560892e-01f, 5.81337921e-02f, 1.29131958e-01f, 4.10366535e-01f, 9.43544805e-02f, 2.44640827e-01f, 3.74236181e-02f,
  2.89193273e-01f, 1.70295127e-02f, -1.45219877e-01f, -2.74280190e-01f, 4.32378411e-01f, 7.27643967e-02f, 1.71803743e-01f, 2.65878171e-01f, -2.16724455e-01f, -2.86094397e-02f,
  5.24143577e-01f, -2.91782916e-01f, 3.94321322e-01f, 2.81761009e-02f, -4.71846052e-02f, 1.01642564e-01f, 3.32994491e-01f, 2.30113603e-02f, 2.37546265e-02f, -2.80865192e-01f,
  -3.02693307e-01f, 2.23287344e-01f, 3.08761507e-01f, 7.20545202e-02f, -1.91393435e-01f, -1.55101806e-01f, 9.71637573e-03f, 3.94115031e-01f, -3.08549881e-01f, 4.26650882e-01f,
  2.30777472e-01f, -1.97136421e-02f, 1.51705027e-01f, -2.77233064e-01f, -2.49200627e-01f, 1.86030477e-01f, 1.30987391e-01f, -2.11368725e-02f, 1.10670459e-02f, 1.80439159e-01f,
  1.70334697e-01f, -1.01749793e-01f, 1.99154571e-01f, -1.94389783e-02f, 2.03691516e-02f, -1.54443353e-01f, 6.15664124e-02f, 1.31854847e-01f, 3.05071305e-02f, 1.24856062e-01f,
  5.32911457e-02f, 1.07459754e-01f, 3.34586506e-03f, 1.98601678e-01f, 2.31325999e-02f, 1.15904734e-02f, 1.36416480e-02f, 2.48314843e-01f, -1.49464414e-01f, 2.39194669e-02f,
  8.12680200e-02f, -3.09284553e-02f, 5.95025197e-02f, -1.27490908e-01f, -2.16762170e-01f, -9.18622017e-02f, -6.83914647e-02f, 2.53484011e-01f, 3.76477353e-02f, -4.04685512e-02f,
  1.63831964e-01f, -5.51348664e-02f, -1.49824962e-01f, 4.51371893e-02f, -2.84890905e-02f, 3.76574010e-01f, -5.79724759e-02f, 2.34470993e-01f, -1.25491768e-01f, 3.91342901e-02f,
  1.19175166e-01f, -1.31477684e-01f, -1.97012067e-01f, 2.57885814e-01f, 2.67983109e-01f, 1.14764974e-01f, -6.33081198e-02f, 2.79619813e-01f, -1.03399299e-01f, -4.36367959e-01f,
  3.94764930e-01f, 2.15359867e-01f, 2.03451291e-01f, 1.68192416e-01f, 8.00069049e-02f, 2.30014950e-01f, -3.35377544e-01f, -3.56079221e-01f, 2.04366714e-01f, -1.85556084e-01f,
  1.54167423e-02f, -2.05164731e-01f, -7.27556124e-02f, -4.79538776e-02f, 3.83226499e-02f, 2.87834883e-01f, 8.78629535e-02f, 2.40641966e-01f, 2.61840492e-01f, -4.10167500e-02f,
  3.49039763e-01f, -5.91941625e-02f, 4.78686430e-02f, -1.96330473e-01f, -3.86828147e-02f, -1.59182042e-01f, -1.89449057e-01f, 2.10387364e-01f, 1.48850337e-01f, -1.31930532e-02f,
  2.50747383e-01f, -2.57802546e-01f, 9.93680358e-02f, 3.68779004e-02f, 1.41944468e-01f, -1.96337774e-01f, -8.16753656e-02f, 2.79630907e-03f, 2.52984822e-01f, -2.14811713e-01f,
  1.83118153e-02f, -9.24007595e-02f, 9.80879962e-02f, -1.97515562e-02f, -7.78644681e-02f, -1.18606716e-01f, 1.61265045e-01f, 3.91599210e-03f, 7.19880536e-02f, -1.44452676e-01f,
  4.99872193e-02f, -1.27967060e-01f, 3.31855305e-02f, 2.38184214e-01f, -2.79186487e-01f, 2.48562649e-01f, 2.89862975e-02f, -3.60573649e-01f, 2.19502263e-02f, 3.20171982e-01f,
  -4.15602103e-02f, -2.26298198e-01f, 2.17489358e-02f, 3.63754541e-01f, 1.19363330e-01f, -2.62257665e-01f, -1.81020543e-01f, 7.67809302e-02f, 2.00926200e-01f, 1.24324642e-01f,
  4.02342618e-01f, -1.89293385e-01f, -4.41326834e-02f, 3.68665636e-01f, 5.72485887e-02f, -1.39759079e-01f, -3.24477255e-02f, 1.90717742e-01f, 2.25824475e-01f, 2.87846178e-01f,
  2.82540381e-01f, -1.21458218e-01f, -4.08749580e-02f, 4.41841409e-02f, -6.44773319e-02f, -4.63681715e-03f, 1.39683068e-01f, 1.74278378e-01f, 1.27068246e-02f, 1.09390356e-01f,
  2.58049488e-01f, -1.57225549e-01f, 2.73498416e-01f, -2.30041593e-02f, 1.36299267e-01f, -1.20859981e-01f, 7.14546740e-02f, -2.11513281e-01f, 3.36910859e-02f, -1.13887504e-01f,
  5.39468229e-01f, -9.80304554e-02f, -6.79111779e-02f, 5.43127477e-01f, 1.82895556e-01f, 2.67901807e-04f, 1.93265572e-01f, 2.02670395e-01f, 2.40091488e-01f, 1.72847405e-01f,
  1.86737746e-01f, -9.62580293e-02f, 2.24806443e-01f, 6.20998628e-02f, 3.22063208e-01f, -3.18343714e-02f, -2.24458352e-01f, 2.42104426e-01f, 6.55387118e-02f, -2.64810652e-01f,
  -1.44516677e-01f, 1.12280965e-01f, -9.50311497e-02f, -5.32013588e-02f, -8.42146203e-02f, 1.87433124e-01f, 1.19821496e-01f, -1.21464767e-01f, 3.15102309e-01f, -7.91228339e-02f,
  7.18730688e-02f, 1.31694436e-01f, -1.25809461e-01f, -3.59159075e-02f, -1.53595194e-01f, -2.29991004e-01f, 1.72412291e-01f, 1.68268770e-01f, -2.90746599e-01f, -3.33547294e-01f,
  -4.08900589e-01f, 6.73441822e-03f, -8.07799250e-02f, -3.25093754e-02f, -1.12937562e-01f, -3.76476124e-02f, 7.66637698e-02f, 1.49269387e-01f, -2.80538708e-01f, -3.25051367e-01f,
  -6.13989606e-02f, 7.11144656e-02f, -1.37302384e-01f, -2.70311326e-01f, 5.05606942e-02f, -3.62310678e-01f, -1.95713341e-01f, -1.30427957e-01f, -3.00327748e-01f, 1.64076596e-01f,
  1.33173978e-02f, -1.37758672e-01f, -2.06896458e-02f, -1.71759352e-03f, 1.44309580e-01f, 9.37993228e-02f, -3.52151930e-01f, 1.80826381e-01f, -3.57795835e-01f, 2.29979530e-02f,
  -1.31128430e-01f, 1.27334632e-02f, 2.57085592e-01f, 2.67728716e-01f, -5.38827013e-03f, 2.94466782e-02f, -2.41103813e-01f, 8.51368308e-02f, 2.62972772e-01f, -2.96769962e-02f,
  -7.80581534e-02f, 9.64011326e-02f, -7.00875893e-02f, -2.26691082e-01f, 3.03439349e-01f, -2.42515635e-02f, -2.22593427e-01f, -3.97583753e-01f, 1.19499959e-01f, -9.53573883e-02f,
  2.97378331e-01f, 3.05997521e-01f, -1.35776000e-02f, -1.90947831e-01f, 5.22042550e-02f, -1.59670770e-01f, -2.11247146e-01f, 5.93604445e-02f, -3.81330326e-02f, 3.50998372e-01f,
  1.02236636e-01f, -1.48482740e-01f, -1.05763406e-01f, 1.76005825e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  7.71107972e-02f, 1.42790182e-02f, 1.48656368e-01f, 3.04229021e-01f, 2.15116009e-01f, 2.90722847e-01f, 4.91418503e-02f, -2.09746007e-02f, 1.73833430e-01f, 1.55312881e-01f,
  1.91655561e-01f, 1.42029785e-02f, 9.81751457e-03f, 8.12092945e-02f, 1.66237906e-01f, 1.49854511e-01f, 1.12594746e-01f, 4.49034572e-02f, 1.47385657e-01f, 2.31900990e-01f,
  -5.52467778e-02f, 2.33212650e-01f, 1.05946735e-01f, 4.81382124e-02f, 1.86407343e-01f, 4.45496701e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  4.73224968e-02f, -2.95426399e-02f, 2.51470171e-02f, 3.24846469e-02f, -6.76692203e-02f, 1.47681504e-01f, -3.44784558e-01f, -4.05467331e-01f, -1.98360041e-01f, -3.42219546e-02f,
  -2.77810544e-01f, -1.93080112e-01f, 4.48246934e-02f, -2.38632768e-01f, -1.22871958e-01f, -1.27546206e-01f, -1.15996443e-01f, -6.43152073e-02f, -1.99601755e-01f, 2.72304833e-01f,
  -2.14486644e-01f, -4.33215141e-01f, -1.65943399e-01f, 2.71699101e-01f, 4.88205254e-02f, -6.76093176e-02f, -3.13645341e-02f, -2.47642443e-01f, -7.20353499e-02f, 1.40735686e-01f,
  1.51595667e-01f, -2.28687257e-01f, -3.27686965e-02f, -4.04074788e-01f, 1.97081506e-01f, 2.49591488e-02f, 4.43665057e-01f, 1.26828700e-01f, -4.27888823e-04f, -3.93753380e-01f,
  -3.48387696e-02f, -4.90696937e-01f, -3.14419232e-02f, -3.02096337e-01f, 3.24683219e-01f, -2.00022683e-01f, -3.26501548e-01f, 4.96660136e-02f, -2.88611978e-01f, -1.83885008e-01f,
  8.87868181e-02f, 9.10226181e-02f, -1.02611013e-01f, -2.53831685e-01f, 1.87961578e-01f, -3.15932006e-01f, 1.29635200e-01f, 1.42213255e-01f, 2.36817032e-01f, -3.70631158e-01f,
  2.02381164e-01f, 1.13276251e-01f, 2.07330063e-01f, -1.44566387e-01f, 3.34136039e-01f, -1.77547023e-01f, -2.86550462e-01f, -2.62671679e-01f, 9.31152552e-02f, 6.59421310e-02f,
  -3.55714597e-02f, -3.60626608e-01f, -1.25191897e-01f, 5.74661121e-02f, 5.28345406e-02f, 1.94587708e-02f, 1.17981724e-01f, 3.36709052e-01f, -1.46481127e-01f, 1.02076866e-01f,
  6.16526790e-02f, -4.07114178e-02f, -4.98435423e-02f, -2.62010217e-01f, 2.89139077e-02f, 9.36914608e-02f, 2.39014670e-01f, -8.75349641e-02f, 8.84768665e-02f, -4.66726780e-01f,
  1.79622322e-01f, -3.58760774e-01f, -3.42312872e-01f, -3.30255926e-02f, 1.86391413e-01f, -8.60154405e-02f, 1.25370964e-01f, -3.59480441e-01f, -4.93636787e-01f, -1.51730105e-01f,
  -1.98411688e-01f, 2.41506323e-01f, -4.75868136e-01f, 3.01040947e-01f, 4.25108932e-02f, -2.14733467e-01f, 3.05668693e-02f, -1.32534318e-02f, 2.60863543e-01f, 1.66292205e-01f,
  -4.92771059e-01f, -1.30785018e-01f, -2.46891886e-01f, 3.16918522e-01f, 5.09842150e-02f, -1.94006994e-01f, -1.46715175e-02f, -1.09534860e-02f, -5.29408574e-01f, -2.91047841e-01f,
  -7.21201077e-02f, 2.14782432e-01f, -2.85495788e-01f, 1.11694656e-01f, -9.43576247e-02f, 2.74580419e-01f, 1.85395524e-01f, 2.23891772e-02f, 5.99939488e-02f, 1.16587646e-01f,
  -1.49381310e-01f, 8.03708062e-02f, 1.02487400e-01f, -6.52499124e-02f, 6.65314049e-02f, 2.68684387e-01f, 1.16125986e-01f, -7.72406086e-02f, 2.32184261e-01f, 8.76775980e-02f,
  -2.62099635e-02f, 2.38819897e-01f, 5.59042348e-03f, -8.47809482e-04f, -2.18442217e-01f, 6.46408573e-02f, 2.07228437e-01f, -1.53709188e-01f, 7.95312226e-02f, 3.04883569e-01f,
  -2.21941069e-01f, -1.08952094e-02f, 1.71326518e-01f, 2.31556386e-01f, 3.60328943e-01f, -3.33139896e-01f, 1.87171817e-01f, 3.22204441e-01f, -8.51533860e-02f, 1.97992623e-01f,
  -2.27489859e-01f, 2.29117513e-01f, 2.49297470e-01f, -1.20471291e-01f, 1.42936185e-01f, 2.07218125e-01f, -4.01068062e-01f, -2.86142826e-01f, 3.52624089e-01f, -2.05126077e-01f,
  1.85177326e-01f, -1.66294977e-01f, 1.76101580e-01f, 1.41732410e-01f, -3.13259810e-01f, -9.52830464e-02f, -4.41034913e-01f, -3.88882190e-01f, -1.12526910e-02f, -5.94241582e-02f,
  3.55941266e-01f, -4.72465545e-01f, -3.44528735e-01f, 7.66072869e-02f, 1.79485559e-01f, -2.42513254e-01f, 2.56475300e-01f, 6.81612492e-02f, 2.64591444e-02f, -2.72162914e-01f,
  -6.09640896e-01f, 3.70651707e-02f, -2.13077247e-01f, 1.78506717e-01f, 2.32820258e-01f, -4.56388853e-03f, -1.40112683e-01f, -1.42720565e-02f, 6.17524683e-02f, 1.19737618e-01f,
  -3.77712548e-02f, -1.90430835e-01f, 1.41471371e-01f, -2.72648811e-01f, -7.23442137e-02f, 6.79222271e-02f, 1.73308566e-01f, 2.21416340e-04f, -2.16151059e-01f, 1.04835607e-01f,
  -1.48093402e-01f, 8.40207115e-02f, -1.23195171e-01f, 2.93427315e-02f, -2.65616715e-01f, -1.60196736e-01f, -5.37528396e-01f, 2.13438287e-01f, -1.31802270e-02f, 3.27946812e-01f,
  2.54413694e-01f, -1.43090129e-01f, 9.30089429e-02f, 3.01245879e-02f, 6.28712401e-02f, 1.56701982e-01f, 2.28547305e-01f, -9.21192318e-02f, -3.66340369e-01f, -1.94463432e-01f,
  -1.21129259e-01f, -9.39246938e-02f, -5.50688326e-01f, 2.12867215e-01f, -2.73270369e-01f, -1.67470336e-01f, -3.46933782e-01f, -4.77014840e-01f, 2.20651254e-01f, 2.61357009e-01f,
  -5.07343233e-01f, -1.49126306e-01f, 1.66272372e-02f, -2.56000876e-01f, -1.88604221e-01f, -2.42819220e-01f, -1.18003279e-01f, 2.11150154e-01f, -3.20659012e-01f, 1.49212003e-01f,
  3.42496604e-01f, -3.91859084e-01f, 1.84620306e-01f, -5.89233339e-02f, 9.61969346e-02f, -2.56775260e-01f, -2.83663929e-01f, 1.32950768e-01f, 2.09859163e-02f, 3.70792635e-02f,
  -1.28056034e-01f, -6.40515089e-02f, 1.38830449e-02f, 4.28569987e-02f, 1.05542570e-01f, -4.74130921e-02f, -2.09121659e-01f, 1.10532016e-01f, -2.48890445e-01f, -3.30998957e-01f,
  -7.03407302e-02f, -1.91909850e-01f, -1.52912721e-01f, 8.59788805e-02f, 1.89415529e-01f, -1.18146755e-01f, 2.21700937e-01f, 1.44435838e-01f, 1.51327491e-01f, -1.16144687e-01f,
  1.47723928e-01f, -1.87187731e-01f, -1.21840440e-01f, 1.69145823e-01f, -2.40259506e-02f, -2.34175995e-01f, 2.94612646e-01f, 1.14190184e-01f, -3.02907526e-01f, 5.07353246e-01f,
  -2.48448253e-01f, -3.25161397e-01f, -4.24557120e-01f, -1.49901345e-01f, 2.11616531e-01f, -2.34952867e-01f, -2.11377233e-01f, 1.22607974e-02f, 1.12764031e-01f, -5.51571906e-01f,
  -4.81967703e-02f, -3.89720201e-02f, 6.73722699e-02f, 1.51353315e-01f, 3.34148556e-01f, -6.57345727e-02f, 2.29141071e-01f, -2.79627293e-01f, -3.28796297e-01f, -1.33772075e-01f,
  -1.49496138e-01f, 2.03359306e-01f, 1.84246004e-01f, -1.47254737e-02f, -1.60832748e-01f, -2.00097740e-01f, 5.36741018e-02f, -2.35713825e-01f, -3.47838849e-01f, 2.37422079e-01f,
  1.85539931e-01f, 3.56763266e-02f, -2.26235032e-01f, 3.03122193e-01f, 2.85500288e-01f, 1.11089326e-01f, -2.81018555e-01f, 3.23894054e-01f, 1.89763770e-01f, -9.48051736e-02f,
  -1.15738727e-01f, -6.94334507e-02f, -9.17437524e-02f, 2.03125194e-01f, -1.03711873e-01f, 2.32346892e-01f, 2.60859996e-01f, 8.01359192e-02f, 1.11239389e-01f, 3.18394005e-01f,
  -2.31902659e-01f, -3.27462405e-02f, -1.22701421e-01f, 4.28330041e-02f, -1.39306530e-01f, -8.00632536e-02f, -7.96235576e-02f, 1.72521666e-01f, 4.70644295e-01f, -1.94696590e-01f,
  -2.54427999e-01f, 8.16292092e-02f, -4.62528039e-03f, 2.49703556e-01f, 3.93101037e-01f, 3.50174427e-01f, 4.11628097e-01f, -5.77189252e-02f, 3.37080657e-02f, 1.26830265e-01f,
  -3.35285425e-01f, 2.70477682e-01f, 1.47885665e-01f, 1.03109002e-01f, 2.10284993e-01f, -2.05370352e-01f, -1.88845649e-01f, -3.18748176e-01f, 3.28178465e-01f, -3.28380644e-01f,
  9.16143432e-02f, 1.84206292e-02f, 1.79593656e-02f, 1.48971170e-01f, 2.22661123e-01f, -4.25866872e-01f, 1.48492619e-01f, 5.50946407e-02f, -5.59126616e-01f, -1.04103059e-01f,
  7.06025511e-02f, -3.11849296e-01f, 2.35768095e-01f, 2.31561363e-01f, 2.45274797e-01f, -6.51606545e-02f, 1.39922529e-01f, -1.65531132e-02f, -9.48305801e-02f, -1.65211841e-01f,
  7.89324939e-02f, -1.33188933e-01f, 1.71309635e-02f, 9.84510854e-02f, -1.52549613e-02f, -2.94213802e-01f, -2.33347088e-01f, -2.15567067e-01f, -1.02344982e-01f, 1.74889565e-01f,
  2.01403096e-01f, -1.91915214e-01f, -3.21683943e-01f, 1.98732480e-01f, 1.69937536e-01f, 1.41792133e-01f, -2.01550081e-01f, 1.91630110e-01f, -2.56138463e-02f, 2.05779999e-01f,
  -1.91594645e-01f, -9.06935800e-03f, 3.08448195e-01f, 3.18288714e-01f, -1.17828846e-01f, -3.71329814e-01f, 2.68729538e-01f, -4.48935814e-02f, 2.37037241e-01f, 3.77283007e-01f,
  -1.59662887e-01f, 2.28298277e-01f, -5.16986586e-02f, 1.00049987e-01f, 3.11613053e-01f, 1.78882465e-01f, -1.04224034e-01f, 2.52486527e-01f, -2.06720307e-01f, 2.15687469e-01f,
  -4.07352567e-01f, -5.16217411e-01f, 7.35830143e-02f, -2.35423222e-01f, -4.31914836e-01f, -2.85723537e-01f, -2.95783639e-01f, -4.31001961e-01f, 2.57471427e-02f, 6.27131909e-02f,
  2.61248022e-01f, -4.70954537e-01f, -4.12871130e-02f, 2.32850045e-01f, -4.05278593e-01f, 1.54968023e-01f, -1.54089332e-01f, -2.26110443e-02f, -3.08880247e-02f, 2.20815659e-01f,
  -1.52998149e-01f, 5.85383624e-02f, 1.56267896e-01f, -1.39295042e-01f, -9.25508887e-02f, 1.87122136e-01f, -2.02332474e-02f, 1.19412005e-01f, 2.41404846e-02f, -1.56954199e-01f,
  6.99371397e-02f, -2.00812388e-02f, -7.81899691e-02f, -2.49623686e-01f, -6.25637323e-02f, 7.39992633e-02f, 9.33295414e-02f, -2.23167717e-01f, -6.46200404e-02f, -3.27522963e-01f,
  1.76660642e-01f, 1.78909361e-01f, -1.80241331e-01f, 2.11377546e-01f, 4.12733294e-02f, -2.04446658e-01f, -3.73696722e-02f, -1.14488989e-01f, 1.70318887e-01f, 1.70767426e-01f,
  -1.79305017e-01f, -8.34914669e-02f, -2.18706250e-01f, -1.48324907e-01f, -3.56544666e-02f, 6.67803064e-02f, -2.39483833e-01f, -1.74009025e-01f, -8.40309113e-02f, 1.27843976e-01f,
  -3.68894368e-01f, -1.02561422e-01f, -4.94325519e-01f, 1.59294352e-01f, 2.91990250e-01f, -1.67150855e-01f, -1.07872345e-01f, 1.94303915e-01f, -3.39570463e-01f, 3.20768028e-01f,
  1.31592438e-01f, 3.33289027e-01f, 8.01643059e-02f, 2.56000042e-01f, -2.50514358e-01f, -9.36399847e-02f, 3.56867105e-01f, -4.79297996e-01f, -3.10836226e-01f, -1.34028092e-01f,
  -1.11024678e-01f, 1.35079995e-01f, -2.39442661e-01f, 3.70411128e-02f, 3.01466674e-01f, 5.60545065e-02f, -2.37867057e-01f, -1.68303668e-01f, 2.32026786e-01f, 2.12273762e-01f,
  -3.00646991e-01f, 7.89644346e-02f, -2.81405866e-01f, -1.77331388e-01f, -1.62664607e-01f, -1.35641322e-01f, 2.61204213e-01f, 5.88555075e-02f, -2.00829491e-01f, 2.57141441e-01f,
  -8.51203278e-02f, 3.19698423e-01f, -2.90451646e-01f, -1.52522489e-01f, 1.17774703e-01f, -3.38974833e-01f, 2.31090337e-02f, 5.61144948e-01f, -4.44362491e-01f, 4.93572801e-01f,
  -5.63573837e-01f, -1.86484203e-01f, -3.54236454e-01f, 2.36497536e-01f, 2.86498219e-01f, 1.95565253e-01f, 2.89328009e-01f, 3.56958240e-01f, 1.86448410e-01f, 1.31301361e-03f,
  2.32244417e-01f, 1.02350406e-01f, -6.52037561e-02f, 1.01804249e-01f, 1.85869068e-01f, 5.68569526e-02f, -3.02356690e-01f, -1.97397366e-01f, -6.03084527e-02f, -4.27122377e-02f,
  2.71168917e-01f, 3.23535353e-01f, -4.01229113e-01f, -4.94657923e-03f, -3.49460155e-01f, -2.15189785e-01f, -4.20114785e-01f, -2.79028445e-01f, -3.60703796e-01f, 1.29114017e-01f,
  -1.26533723e-02f, 3.62784952e-01f, -1.69950560e-01f, 9.78984013e-02f, -9.95214060e-02f, -6.06869869e-02f, -1.75020367e-01f, -2.39703149e-01f, 2.80948490e-01f, 2.89871749e-02f,
  -9.38048884e-02f, -5.13305478e-02f, 7.78051838e-02f, -1.54290050e-01f, -3.70920710e-02f, -1.94732368e-01f, 1.92230135e-01f, 3.30271125e-01f, 2.86960632e-01f, 4.57108431e-02f,
  7.36800730e-02f, 1.43270627e-01f, 1.03048354e-01f, 1.19060270e-01f, 3.56371589e-02f, 1.28054217e-01f, 2.25000575e-01f, 6.73831180e-02f, 2.18370892e-02f, 1.92847952e-01f,
  -9.95898712e-03f, 1.63307846e-01f, 2.40099594e-01f, -3.42492387e-02f, -5.37379906e-02f, -3.64077330e-01f, 3.76041792e-02f, -1.14373341e-01f, 3.09890568e-01f, -3.59614134e-01f,
  6.56983927e-02f, -3.70482951e-01f, -1.73136741e-01f, 3.16530377e-01f, 1.53160334e-01f, -7.48226345e-02f, 9.58336815e-02f, -1.82308704e-01f, 6.42260537e-02f, 1.83908060e-01f,
  9.97828022e-02f, 1.67147368e-01f, 3.31057429e-01f, -1.58862442e-01f, 4.00861688e-02f, 2.46619005e-02f, 1.42182320e-01f, 3.68632883e-01f, -1.73065767e-01f, 1.88073009e-01f,
  -3.71431280e-03f, 1.40176490e-01f, 8.67350772e-02f, -6.22941017e-01f, -6.18732214e-01f, -2.38790676e-01f, -2.29358613e-01f, -3.91273648e-01f, -5.23552418e-01f, -4.81476277e-01f,
  2.22405851e-01f, -1.09703541e-01f, 2.62704194e-01f, -1.47058979e-01f, -1.50005162e-01f, 1.69120550e-01f, 2.15621725e-01f, -2.09456384e-01f, -1.11029431e-01f, 1.70792285e-02f,
  1.80922911e-01f, 2.10672975e-01f, -5.36860228e-02f, -1.55609518e-01f, -1.63245514e-01f, 9.10935551e-02f, 2.08165914e-01f, -6.10023877e-03f, -7.11247623e-02f, -1.96870431e-01f,
  -1.26404926e-01f, 1.08087659e-01f, 3.20665181e-01f, -1.98101059e-01f, 2.23041132e-01f, 1.51934341e-01f, -9.84026790e-02f, 3.68015826e-01f, -3.01741093e-01f, 6.64316639e-02f,
  1.14644572e-01f, 1.17274776e-01f, -2.52649486e-01f, 3.65961790e-01f, -2.82283634e-01f, -2.18575627e-01f, 3.49306494e-01f, -1.86567113e-01f, -1.58414498e-01f, -3.06394279e-01f,
  -1.57490477e-01f, -3.09364349e-01f, -2.54067779e-01f, -4.56696272e-01f, -4.10204113e-01f, -4.12605941e-01f, 8.58619586e-02f, 1.85512344e-03f, -2.63217449e-01f, 1.27331242e-01f,
  -1.54923350e-01f, -1.27627850e-01f, 4.62962180e-01f, -2.56339982e-02f, 4.66574162e-01f, -4.14952457e-01f, -3.43604505e-01f, 8.78236815e-02f, 1.38414443e-01f, 3.26182544e-01f,
  9.98938233e-02f, -5.13950109e-01f, 2.84112364e-01f, -3.47212166e-01f, -2.48607561e-01f, 1.50678515e-01f, 1.56671792e-01f, -1.31937057e-01f, 1.96327552e-01f, -1.13634266e-01f,
  4.67882529e-02f, 4.78575937e-02f, 9.32082906e-03f, 4.30555865e-02f, 1.57730371e-01f, -9.41007659e-02f, 2.38978595e-01f, -4.77532335e-02f, 7.62657300e-02f, -2.59445995e-01f,
  -1.61082983e-01f, -1.59211934e-01f, 2.14365825e-01f, -9.07553360e-02f, 2.46753424e-01f, -2.03755602e-01f, -3.60644937e-01f, 2.32506081e-01f, 1.70969635e-01f, -2.03051075e-01f,
  4.31404531e-01f, 1.19041204e-01f, 1.90162495e-01f, 3.08102113e-03f, -1.85223937e-01f, -8.73808842e-03f, 2.96616182e-02f, -2.22427800e-01f, -3.16816494e-02f, 2.23679781e-01f,
  -1.04798704e-01f, -3.67683321e-01f, 1.04820304e-01f, 1.83358029e-01f, -3.91666114e-01f, 3.05732131e-01f, 1.69552401e-01f, 7.30811283e-02f, -4.51722026e-01f, -2.46666074e-01f,
  -1.49911538e-01f, 3.21718782e-01f, 1.24705166e-01f, -2.82405674e-01f, -3.70087385e-01f, -5.00785746e-02f, -2.75623918e-01f, -8.51550326e-02f, -5.59854954e-02f, 2.18163550e-01f,
  1.51607439e-01f, 7.72080272e-02f, -2.17932627e-01f, -3.29406589e-01f, -3.83435488e-01f, 3.34429860e-01f, -4.54314351e-01f, -4.43370730e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.08610995e-01f, -6.11949799e-05f, -5.81036545e-02f, 1.05378449e-01f, 1.26408920e-01f, 7.20599443e-02f, -6.79399073e-02f, 3.21562551e-02f, 9.29041579e-02f, -6.88427389e-02f,
  -2.42448356e-02f, 1.35659974e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    