/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.08818787e-01f, -3.76704559e-02f, -3.47424597e-01f, -4.87810671e-02f, -6.37326017e-02f, -2.40126308e-02f, -8.63888115e-02f, -1.70898840e-01f, -2.36271601e-02f, 1.89263634e-02f,
  6.57071397e-02f, 8.74032974e-02f, 1.23628885e-01f, 2.06157193e-02f, -1.38978764e-01f, -9.57283378e-02f, -1.89036593e-01f, -1.73248738e-01f, -2.05929354e-01f, 6.94708228e-02f,
  6.46768063e-02f, 5.99099416e-03f, -7.94531927e-02f, 6.48112223e-03f, -3.77296610e-03f, 4.87265997e-02f, 6.29206374e-02f, -7.20976144e-02f, 1.81974560e-01f, 4.44289744e-02f,
  -9.24934912e-03f, -1.13461435e-01f, -2.30206270e-02f, 1.32589847e-01f, -3.22054746e-03f, -2.22390946e-02f, -4.31796722e-02f, -8.00367892e-02f, 1.52837681e-02f, -9.88645107e-03f,
  -4.86151257e-04f, 1.91866308e-02f, -8.44338685e-02f, 7.05223903e-02f, -8.17219391e-02f, -1.23762460e-02f, 1.13285193e-02f, -3.19103785e-02f, -8.97991359e-02f, 5.64807318e-02f,
  7.17738494e-02f, 8.47158432e-02f, -1.23673610e-01f, -7.52224028e-02f, 1.11538777e-02f, -5.56974160e-03f, -2.77631395e-02f, 1.97766977e-03f, -3.64332460e-02f, 1.99301839e-02f,
  1.44489110e-02f, -8.45216289e-02f, 1.81371719e-02f, 5.02948556e-03f, 5.28791212e-02f, -2.64462153e-03f, -2.26243585e-03f, 6.54387251e-02f, 2.34989226e-02f, -3.32903527e-02f,
  1.92899015e-02f, -3.14209200e-02f, -1.31299049e-02f, -1.00996800e-01f, 1.76003091e-02f, -5.94132170e-02f, 2.63487883e-02f, 2.21434757e-02f, 8.62759128e-02f, 3.47542241e-02f,
  5.69151752e-02f, 2.85306340e-03f, -5.77015243e-02f, -1.82044134e-02f, -3.14473249e-02f, -6.94688689e-03f, -6.17404282e-03f, 6.94449022e-02f, 3.90044749e-02f, -1.60336737e-02f,
  7.83692449e-02f, -3.53627875e-02f, 5.91565669e-02f, -2.45805271e-02f, 3.06475200e-02f, 2.22240500e-02f, 1.00405008e-01f, 2.99570467e-02f, 9.05860290e-02f, -4.16939758e-04f,
  4.22763042e-02f, -4.20233570e-02f, 6.05427288e-02f, 4.54736128e-02f, -1.30702388e-02f, 5.99453337e-02f, 1.01854824e-01f, -1.15179671e-02f, 6.14988059e-02f, 4.37739864e-02f,
  4.42395881e-02f, -1.27570471e-03f, 1.87012926e-02f, 2.45990790e-02f, -1.14210928e-02f, -4.09021899e-02f, -1.71223637e-02f, -1.23991538e-02f, -7.40282610e-02f, -4.57605384e-02f,
  3.30411419e-02f, 2.70411652e-02f, 4.06947941e-01f, 1.91119954e-01f, 2.48491749e-01f, 1.07062161e-01f, 1.67668194e-01f, 4.10023257e-02f, -3.83779686e-03f, -4.58969735e-02f,
  -4.19808133e-03f, 1.54442489e-02f, 1.45518750e-01f, 3.89775001e-02f, 5.81266917e-02f, 2.30010957e-01f, 2.49220163e-01f, 3.00731689e-01f, 1.20950207e-01f, 3.82707939e-02f,
  8.61302242e-02f, 2.47323308e-02f, -1.37904631e-02f, -1.90984719e-02f, -6.20198064e-02f, 2.97135822e-02f, 1.37634039e-01f, 1.05004512e-01f, -4.15880717e-02f, 1.82906941e-01f,
  2.40090996e-01f, -5.15219979e-02f, 7.65643939e-02f, 3.77848349e-03f, 6.08916357e-02f, 2.71829050e-02f, 2.37182318e-03f, 5.15437126e-02f, -1.33926168e-01f, 7.55725950e-02f,
  6.12276271e-02f, -2.68294439e-02f, 1.81856640e-02f, 3.27113196e-02f, 7.31464550e-02f, 1.13838963e-01f, -5.66336466e-03f, 9.37120523e-04f, 1.56038888e-02f, -1.06949650e-01f,
  -4.41408791e-02f, 7.37014413e-02f, 1.11182667e-02f, -4.22360115e-02f, -5.79002984e-02f, 6.96217641e-02f, -7.42535666e-02f, 7.10238528e-04f, 4.70666513e-02f, -5.35990670e-03f,
  -6.14946224e-02f, -3.99612226e-02f, 4.83638458e-02f, -6.96663707e-02f, -6.09626994e-03f, -1.01185832e-02f, 1.09366225e-02f, 6.28278358e-03f, -1.05854506e-02f, -1.15490660e-01f,
  3.60282063e-02f, 9.76476166e-03f, -5.01803048e-02f, 2.48617437e-02f, 1.43201752e-02f, -4.60498855e-02f, -1.05315037e-02f, 2.81941704e-02f, -9.36248712e-03f, -1.80271845e-02f,
  1.93608701e-02f, -4.21836823e-02f, 1.63626019e-02f, -5.65464720e-02f, -1.04856100e-02f, 7.85838217e-02f, 7.95770809e-02f, -3.64827104e-02f, -3.96158453e-03f, -1.64927635e-02f,
  -4.96265627e-02f, 3.10543180e-02f, -3.71366665e-02f, 1.68871216e-03f, -1.05771115e-02f, 4.40254956e-02f, -1.48887029e-02f, 3.39162052e-02f, 3.18481438e-02f, -9.75459516e-02f,
  -5.47579043e-02f, -7.10302293e-02f, 6.18226826e-02f, -5.21191023e-02f, -2.35502273e-02f, -3.48685496e-02f, 4.36081290e-02f, 1.99132413e-02f, 1.56253632e-02f, -1.02064550e-01f,
  -2.77836956e-02f, -6.01390079e-02f, -4.48696502e-02f, -1.20066918e-01f, -1.08679295e-01f, 8.93844813e-02f, -1.02591604e-01f, -5.02835289e-02f, 2.87723597e-02f, -1.81371555e-01f,
  3.53377134e-01f, -6.68525370e-03f, -2.71934122e-01f, 6.58431202e-02f, -1.67545974e-02f, -5.93143515e-02f, 3.23897451e-02f, 2.42152974e-01f, 5.45669459e-02f, 2.42199413e-02f,
  -2.85420772e-02f, 1.62441418e-01f, 2.22468190e-02f, -6.61219582e-02f, 4.00878601e-02f, -1.47315785e-01f, -1.53225124e-01f, -7.01339841e-02f, -4.95227333e-03f, 1.10868365e-02f,
  8.92055109e-02f, 2.24450906e-03f, 1.27240911e-01f, 2.37819385e-02f, -7.82977790e-02f, -8.24259743e-02f, -1.27217665e-01f, -1.00857586e-01f, -1.46588683e-01f, -4.37282950e-01f,
  -3.01582664e-01f, 2.08204351e-02f, 1.48703065e-02f, 8.92502442e-02f, -2.20085289e-02f, 9.63274762e-02f, -1.67673919e-02f, 6.44955784e-03f, 3.10221072e-02f, 1.25716925e-02f,
  -5.75218536e-02f, 8.43006819e-02f, 3.71794365e-02f, -1.15419418e-01f, 6.70723841e-02f, -3.55754211e-03f, -6.64540827e-02f, -2.47451197e-02f, -3.44943926e-02f, -6.35846145e-03f,
  -1.92962307e-02f, -9.47115943e-02f, -6.41450211e-02f, -1.21754825e-01f, -5.17237112e-02f, 6.86810687e-02f, -1.12147167e-01f, -9.05943364e-02f, -5.19164838e-02f, -1.71694547e-01f,
  1.61390863e-02f, -4.51314338e-02f, 2.21638326e-02f, 1.07951956e-02f, 7.98123479e-02f, -5.72639634e-04f, 4.47268976e-04f, -8.38359967e-02f, 1.85436220e-03f, -2.09888257e-02f,
  7.60592073e-02f, -4.16057035e-02f, -4.21477249e-03f, 2.19774954e-02f, -5.54384924e-02f, -6.03717193e-02f, -2.21756124e-03f, 1.88841764e-02f, -2.95397751e-02f, -1.15222409e-02f,
  -2.80609094e-02f, -5.10447435e-02f, 3.48804183e-02f, -6.18889853e-02f, -4.01572771e-02f, -4.40556295e-02f, 4.94986624e-02f, 9.17914659e-02f, 6.68373518e-03f, 1.08877987e-01f,
  2.24929705e-01f, -2.40876200e-03f, -8.45302176e-03f, -2.24542320e-02f, -3.43307368e-02f, -3.61113995e-02f, 4.16967496e-02f, 3.87433879e-02f, -6.10096566e-02f, 3.60684954e-02f,
  7.33470470e-02f, 8.04711580e-02f, 2.29436513e-02f, -4.93835434e-02f, 3.44144925e-02f, 1.14196101e-02f, 6.41003177e-02f, -1.02483623e-01f, -1.08010121e-01f, -8.36568773e-02f,
  6.00969652e-03f, 6.14858465e-03f, 1.22048795e-01f, 3.79044898e-02f, -1.01044392e-02f, 5.70820235e-02f, -6.13859631e-02f, 5.64766265e-02f, 9.72888321e-02f, 1.68303236e-01f,
  5.46033502e-01f, -5.88286445e-02f, -3.47361863e-02f, 4.22162861e-02f, -5.44800749e-03f, 9.04207602e-02f, 1.27269831e-02f, -6.36712369e-03f, -1.87859964e-02f, -4.65858243e-02f,
  -7.09886849e-02f, -1.20328516e-01f, -5.98355941e-02f, -4.54875715e-02f, 6.53119236e-02f, -9.80891753e-03f, -1.81075893e-02f, 9.79055371e-03f, 8.27361941e-02f, -2.46370919e-02f,
  -5.42822033e-02f, -5.17929271e-02f, 1.56206980e-01f, -6.35210723e-02f, -1.92397505e-01f, -6.18816800e-02f, -7.40985572e-02f, 4.90451008e-02f, -4.99761384e-03f, -2.48643950e-01f,
  -1.44078523e-01f, 2.49737531e-01f, -8.56637508e-02f, 3.06992382e-02f, 2.97518857e-02f, -2.43397467e-02f, -9.54626277e-02f, 2.35097308e-04f, 2.92558353e-02f, 1.25652300e-02f,
  5.19235283e-02f, 1.68592390e-02f, -2.48497762e-02f, -8.27821204e-04f, 4.71939705e-02f, 4.33135033e-02f, -4.01438121e-03f, 9.18531865e-02f, 8.66842717e-02f, -3.56881656e-02f,
  -1.18411526e-01f, -7.85931125e-02f, 1.03026718e-01f, 8.70342627e-02f, 6.10818975e-02f, 5.86361438e-02f, -2.12082863e-02f, 9.63641629e-02f, 1.29036978e-01f, -9.15299729e-02f,
  3.31212929e-03f, -1.30136395e-02f, 6.75636902e-02f, -1.72955431e-02f, 1.53707331e-02f, 4.31965254e-02f, 1.64251141e-02f, 7.11803418e-03f, -1.45885227e-02f, 2.31638160e-02f,
  5.71388751e-02f, -5.69240525e-02f, -1.15035661e-02f, -8.28787033e-03f, -1.17017038e-01f, 3.06734443e-02f, 2.17952169e-02f, -1.10656902e-01f, 2.18702592e-02f, 1.23781078e-02f,
  7.92897400e-03f, 2.54089441e-02f, -3.25996019e-02f, -7.42179854e-03f, 1.49823269e-02f, 3.07342373e-02f, 1.87782533e-02f, -5.14337197e-02f, -1.32366709e-04f, -4.58795018e-02f,
  -1.38027072e-01f, 1.26150832e-01f, -1.51450960e-02f, 6.03218004e-03f, 2.73954775e-02f, 8.08299147e-03f, 4.25569601e-02f, 4.28740680e-02f, 1.09549001e-01f, -1.15017844e-02f,
  1.97145529e-02f, 3.11238598e-02f, -1.98181737e-02f, -2.31599417e-02f, -2.07555760e-03f, -8.49317852e-03f, 5.34998998e-02f, 6.30517602e-02f, 4.27292287e-02f, -4.42146845e-02f,
  2.23636068e-02f, 3.17371525e-02f, -4.24928814e-02f, -8.35125055e-03f, 5.33945784e-02f, 6.44748434e-02f, -1.65982060e-02f, -3.58237326e-02f, 6.83568344e-02f, -1.23192072e-01f,
  -3.84594113e-01f, -2.01239541e-01f, -4.14277583e-01f, 1.77774858e-03f, 4.03663777e-02f, -2.80525237e-01f, -3.87159050e-01f, -1.25107793e-02f, 2.27148697e-01f, -1.46768719e-01f,
  -2.85462718e-02f, 1.89616993e-01f, 2.45065436e-01f, 5.59316985e-02f, -2.57808641e-02f, -1.45383731e-01f, -1.01343162e-01f, -1.43393517e-01f, -3.70256091e-03f, -3.54042202e-02f,
  1.37051702e-01f, 7.44711235e-02f, 1.13503793e-02f, 8.78166333e-02f, 7.34615419e-03f, 1.98413417e-01f, 2.32670791e-02f, 3.40200737e-02f, 9.69917607e-03f, 4.93888669e-02f,
  -3.47838759e-01f, -3.46164137e-01f, 2.36587543e-02f, 1.99361071e-01f, -3.03740744e-02f, 2.26573348e-02f, -6.04346581e-02f, 4.40432206e-02f, 4.05892320e-02f, 4.88490611e-02f,
  8.38854313e-02f, 1.40338140e-02f, 7.38595799e-02f, -1.80583261e-02f, -2.55760569e-02f, -2.66669206e-02f, 2.05329414e-02f, -6.48230910e-02f, -9.94493738e-02f, -4.11790051e-02f,
  3.39876376e-02f, -2.71716770e-02f, -1.27685994e-01f, -4.23920676e-02f, -8.38445202e-02f, 1.67118236e-02f, -3.45256776e-02f, 2.71916483e-03f, -1.69149861e-01f, -1.22523092e-01f,
  1.72844585e-02f, -4.16797101e-02f, 1.04862414e-02f, 1.51762879e-02f, 6.20958768e-02f, -2.39249505e-02f, 3.40236239e-02f, -2.78356369e-03f, -3.13168112e-03f, 1.68179499e-03f,
  3.97545882e-02f, -7.74920881e-02f, -1.42145818e-02f, 1.03838062e-02f, 3.75577137e-02f, -5.38328514e-02f, -7.07695307e-03f, 1.03360564e-02f, 6.50519580e-02f, -5.27547039e-02f,
  -3.27340551e-02f, -3.75782624e-02f, 4.81413826e-02f, -4.23604473e-02f, -4.05816585e-02f, 4.31148298e-02f, -2.99677886e-02f, 5.87791353e-02f, 1.23504639e-01f, -1.39988065e-02f,
  2.11365059e-01f, 1.64830461e-02f, -4.37928364e-02f, 2.31525861e-03f, 4.45008688e-02f, -2.97692535e-03f, 4.28012619e-03f, 4.09933738e-02f, 3.60093899e-02f, -7.15123713e-02f,
  -1.16223119e-01f, -2.17418782e-02f, 6.85831707e-04f, 8.60618334e-03f, 2.71971449e-02f, -4.40458208e-02f, 1.13030657e-01f, -2.92896759e-03f, 4.83261570e-02f, -2.50543617e-02f,
  5.31609096e-02f, -6.45170510e-02f, -1.22767806e-01f, 1.47337401e-02f, -5.47920307e-03f, 6.82047009e-02f, -5.39852120e-02f, -5.87356873e-02f, -7.02798963e-02f, 6.03207089e-02f,
  1.48613781e-01f, 3.23824286e-01f, -9.03217867e-02f, 6.34481087e-02f, 8.94326121e-02f, 2.79733781e-02f, 2.07254037e-01f, 5.81785664e-02f, -1.32257706e-02f, 1.14741653e-01f,
  -1.19670689e-01f, -1.99964464e-01f, -1.15077987e-01f, -1.46220356e-01f, -1.64704725e-01f, 1.85342550e-01f, 2.89693952e-01f, -7.31449947e-02f, -3.38334143e-01f, -2.47942418e-01f,
  -7.46282749e-03f, 1.14678718e-01f, -1.28021941e-01f, -9.65919420e-02f, 2.19861582e-01f, -1.81577820e-02f, 1.09360792e-01f, 1.29995242e-01f, 1.59429535e-01f, 4.29648042e-01f,
  -4.99699190e-02f, 1.42723933e-01f, -1.49661407e-01f, -2.64580152e-03f, 4.01369669e-02f, -3.35532650e-02f, -3.71079370e-02f, 3.74898128e-02f, -5.25465123e-02f, 6.18958548e-02f,
  -1.92329679e-02f, -9.30950511e-03f, 8.30289572e-02f, -1.84600595e-02f, -4.22860980e-02f, -2.00584084e-02f, 8.19637850e-02f, 4.75819968e-03f, -8.17557871e-02f, -1.23271132e-02f,
  7.31922910e-02f, 6.17160946e-02f, -7.62766087e-03f, -1.18585564e-01f, -5.61657548e-02f, 1.57221463e-02f, 6.21087151e-03f, 5.22295572e-02f, -3.68978865e-02f, 2.67083526e-01f,
  2.61601321e-02f, 5.98153286e-03f, -3.81441973e-02f, 1.16429729e-02f, 1.98453348e-02f, 1.20621582e-03f, 8.55566040e-02f, -1.30337952e-02f, 6.12444477e-04f, -2.65964307e-04f,
  -3.78593355e-02f, -5.47633469e-02f, -2.92537566e-02f, -2.41611153e-02f, 1.17057916e-02f, 9.68318246e-03f, -4.48253788e-02f, -4.44776146e-03f, -4.11878303e-02f, 9.99104604e-03f,
  2.25284956e-02f, -2.58637797e-02f, 1.99221242e-02f, -1.56762172e-02f, 6.14267588e-02f, 2.21225414e-02f, -3.76498699e-03f, -8.52191448e-02f, 8.60197470e-03f, 3.23389396e-02f,
  -1.85279790e-02f, -1.41346589e-01f, 1.04322754e-01f, 1.11466840e-01f, 2.43496578e-02f, -2.40236521e-02f, 6.14453591e-02f, -8.59772041e-03f, -4.25501801e-02f, -5.64109311e-02f,
  -4.46467251e-02f, -4.23894487e-02f, 1.19734639e-02f, -4.51112166e-02f, -4.60345596e-02f, -4.97827167e-03f, 4.29717414e-02f, -2.92618386e-02f, -3.12689580e-02f, 5.68452291e-02f,
  -1.85565967e-02f, -2.42375471e-02f, -4.98987101e-02f, 6.95517845e-03f, -2.78244987e-02f, 1.34976376e-02f, -5.09889722e-02f, -7.34270662e-02f, -9.39115062e-02f, 6.81292117e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.25178206e-01f, 2.05622882e-01f, -7.55682513e-02f, 6.46402314e-02f, 4.48534824e-02f, -1.22845225e-01f, -2.60973107e-02f, 1.49933994e-01f, -8.89294315e-03f, 1.51102275e-01f,
  -8.10753405e-02f, -1.55414253e-01f, -1.00767694e-01f, -5.03281765e-02f, -1.29449740e-01f, 8.16024765e-02f, -4.21586670e-02f, -1.28926724e-01f, -1.24690332e-01f, 1.22244274e-02f,
  1.64920278e-02f, 1.06155194e-01f, 9.35357213e-02f, 8.59828815e-02f, 1.30661368e-01f, -6.47219270e-02f, 4.33321530e-03f, -1.17594739e-02f, -2.13184878e-02f, -1.82026508e-03f,
  -7.94952959e-02f, 5.11232391e-02f, -9.12392586e-02f, 8.16293284e-02f, -1.35584235e-01f, -1.94750782e-02f, -7.73776397e-02f, 3.25322412e-02f, 9.58993360e-02f, 2.64046099e-02f,
  -7.12746158e-02f, 4.43654656e-02f, -1.08139589e-01f, -5.22566326e-02f, 1.19022906e-01f, -4.00042050e-02f, 4.53684777e-02f, 5.04799448e-02f, -8.08065310e-02f, -5.28597720e-02f,
  -3.54513824e-02f, -9.85078141e-02f, -7.35530108e-02f, 6.75726533e-02f, -1.62546605e-01f, -1.24248751e-01f, 3.15618850e-02f, -2.33670902e-02f, 2.68503930e-02f, 2.25946948e-01f,
  -5.34724034e-02f, -1.19448528e-01f, 6.33287337e-03f, -3.68989259e-02f, -5.98835498e-02f, 7.58128539e-02f, -6.03609532e-02f, 3.02982051e-03f, -4.64886650e-02f, 7.74831176e-02f,
  3.69215645e-02f, -6.42687827e-02f, -3.84151824e-02f, 1.02064289e-01f, -3.69337276e-02f, -5.88508211e-02f, -7.02992305e-02f, 4.60016876e-02f, -4.02880646e-02f, 5.65558411e-02f,
  1.52368089e-02f, 1.89227927e-02f, 6.06074370e-02f, 2.45109131e-03f, 2.19640732e-02f, -6.53891191e-02f, -5.94068319e-03f, 5.36125191e-02f, 3.35905924e-02f, -2.80463584e-02f,
  1.39358893e-01f, -2.49816939e-01f, -7.69413114e-02f, -1.15623872e-03f, 4.30660918e-02f, -1.65222250e-02f, 3.78852524e-02f, -5.11718728e-02f, 1.51448837e-02f, 6.84128851e-02f,
  -6.57563359e-02f, 7.07423408e-03f, 2.62498315e-02f, 2.62630526e-02f, -5.08614704e-02f, -4.14714441e-02f, 5.20369597e-02f, -2.45044716e-02f, 5.47631010e-02f, 1.21003650e-01f,
  9.25405696e-02f, 1.21722139e-01f, 5.98723143e-02f, -2.06329748e-02f, 3.21303792e-02f, -8.90275314e-02f, -3.91689539e-02f, 1.28524140e-01f, 3.84497419e-02f, 3.20712268e-01f,
  4.18015495e-02f, 5.90745639e-03f, 1.09346671e-04f, 7.99585283e-02f, 3.87309901e-02f, -2.04447895e-01f, -2.94469953e-01f, -1.92212477e-01f, 6.38958737e-02f, 8.08573663e-02f,
  1.41568437e-01f, 1.84081290e-02f, 3.98578718e-02f, -1.26036763e-01f, -2.19795585e-01f, -1.72992453e-01f, -1.91842198e-01f, -2.25150838e-01f, -2.95569003e-01f, -2.26520911e-01f,
  3.28103155e-02f, 2.00346746e-02f, 4.75152545e-02f, -6.50138706e-02f, 6.72091097e-02f, 1.23065054e-01f, 1.11094922e-01f, 1.25209957e-01f, -4.93980907e-02f, 2.13183761e-01f,
  1.20155148e-01f, -3.82638462e-02f, -1.14181243e-01f, 6.96332231e-02f, 1.39132023e-01f, -5.63507434e-03f, -5.77945299e-02f, 7.27112889e-02f, 4.25284058e-02f, 4.07043751e-03f,
  -4.95404191e-03f, -8.22932869e-02f, 3.18421051e-02f, 4.04600240e-02f, -1.67149715e-02f, -9.06932652e-02f, 3.05478331e-02f, -1.71029031e-01f, -1.43493325e-01f, -1.04299821e-01f,
  4.46992032e-02f, 4.05564383e-02f, -1.35450035e-01f, -1.27058804e-01f, -3.88635881e-02f, 7.81595781e-02f, -9.67816785e-02f, 5.71861379e-02f, 9.13657807e-03f, 7.02501461e-02f,
  1.14947744e-03f, 1.92687064e-02f, 3.71745713e-02f, 4.64063622e-02f, -7.32496101e-03f, 4.19282354e-02f, -5.52511029e-02f, -1.12786684e-02f, -1.82605889e-02f, -1.59356855e-02f,
  6.33461177e-02f, 1.19861007e-01f, -7.54505545e-02f, 9.19279829e-02f, -4.33993004e-02f, 9.67251360e-02f, 4.02915664e-02f, -2.76867095e-02f, -1.15355300e-02f, 3.56017090e-02f,
  7.23955855e-02f, -5.78493290e-02f, 1.54582769e-01f, -7.35871866e-02f, 2.98652030e-03f, 7.27016106e-02f, -3.16418521e-02f, 7.61598349e-02f, 7.52539486e-02f, 1.88360643e-02f,
  1.25817999e-01f, -1.54367134e-01f, 5.51608987e-02f, -4.54307571e-02f, 3.26576680e-02f, 3.46290320e-02f, 2.14087944e-02f, -8.65733474e-02f, 1.68099165e-01f, -8.29982609e-02f,
  -2.52829213e-02f, -3.75306830e-02f, -1.54596940e-02f, -8.24791864e-02f, -8.44214186e-02f, -7.38545731e-02f, 2.91956645e-02f, -7.77852088e-02f, -3.96208614e-02f, -4.74366248e-02f,
  2.79749800e-02f, -1.44536525e-01f, -4.52151522e-02f, -1.33544922e-01f, -5.73238619e-02f, -1.36305178e-02f, -1.10654168e-01f, -1.50698079e-02f, -7.78568238e-02f, -1.27467617e-01f,
  2.97763199e-02f, -2.67561674e-01f, -8.62535015e-02f, 1.18422702e-01f, -1.04380250e-01f, -3.65078092e-01f, -5.09178877e-01f, -2.14534044e-01f, 5.31503260e-02f, -3.16702366e-01f,
  -1.18732214e-01f, -3.22583318e-02f, 1.09674565e-01f, 4.11201678e-02f, -1.70466736e-01f, -4.20234263e-01f, -1.93544403e-01f, -8.33476335e-03f, 2.31547188e-02f, -1.37614012e-01f,
  -1.72489867e-01f, -1.47557389e-02f, 1.03557594e-01f, 1.10138459e-02f, -1.13721468e-01f, -3.75839807e-02f, -6.77840635e-02f, -8.99480954e-02f, -2.11389169e-01f, -2.30515406e-01f,
  -8.80100057e-02f, 2.04399414e-02f, -6.35359958e-02f, -1.97630115e-02f, 4.15718881e-03f, -5.57940938e-02f, -1.19843900e-01f, 1.00244194e-01f, 3.13660949e-02f, -2.43911203e-02f,
  -5.89677468e-02f, -6.74415473e-03f, -3.97060020e-03f, -7.16124177e-02f, 2.75903922e-02f, -1.19868629e-01f, 3.34159061e-02f, 7.14633539e-02f, 1.05486698e-02f, -1.01950295e-01f,
  -1.44653589e-01f, -1.31727770e-01f, 4.81125973e-02f, -6.61154613e-02f, -4.53219302e-02f, -4.28205170e-02f, -5.96193448e-02f, -2.29418520e-02f, -1.12376995e-01f, -1.03844941e-01f,
  -6.97266087e-02f, 4.61926349e-02f, -1.02081552e-01f, -5.40888309e-02f, -8.24257880e-02f, 3.96347828e-02f, 4.90021855e-02f, -2.49814279e-02f, 4.35847379e-02f, -3.37281860e-02f,
  -1.12344436e-02f, -3.05914208e-02f, 9.61010382e-02f, 5.15302643e-02f, 4.62848097e-02f, 6.23870902e-02f, -3.69193591e-02f, -6.24561943e-02f, -3.53971273e-02f, -3.45991924e-02f,
  4.83575426e-02f, 5.76564446e-02f, -9.58102383e-03f, 8.88075754e-02f, -1.12039112e-01f, -6.33390471e-02f, 1.00500777e-01f, -8.20705593e-02f, 8.95078927e-02f, -3.38557698e-02f,
  2.52951086e-01f, 2.37866212e-02f, -1.31245136e-01f, 2.20617556e-04f, -1.90859344e-02f, 2.65366375e-03f, 1.80775265e-03f, 7.75671974e-02f, 3.08151748e-02f, -7.08412975e-02f,
  -7.96567872e-02f, -6.90119117e-02f, -3.43777277e-02f, -4.46229130e-02f, 7.24934181e-03f, -2.58790771e-03f, -1.52322605e-01f, 4.47719954e-02f, -7.52008334e-02f, 5.80919571e-02f,
  -1.06028654e-01f, -4.03711386e-02f, -3.10670026e-02f, -1.84268653e-02f, 1.22669269e-03f, 3.99337374e-02f, -4.72076517e-03f, -1.33689508e-01f, -9.65973362e-02f, -1.75456092e-01f,
  -1.52469641e-02f, 5.74196354e-02f, 6.06271215e-02f, 2.14105584e-02f, -9.18457732e-02f, -2.34099299e-01f, -1.40521765e-01f, -9.29196551e-02f, -2.00262833e-02f, 3.47375534e-02f,
  1.20775662e-01f, 1.10997662e-01f, 3.97223458e-02f, -9.38236117e-02f, -2.24852487e-01f, -1.32622197e-01f, -1.08142376e-01f, -7.27726743e-02f, -1.76778287e-01f, -2.42900640e-01f,
  -7.60818571e-02f, -1.32210344e-01f, -1.69963986e-01f, -1.12218587e-02f, 1.48160368e-01f, 6.11596517e-02f, 4.57571074e-02f, -8.17807764e-02f, 1.67925265e-02f, 1.31937653e-01f,
  2.12953150e-01f, -3.37985195e-02f, -7.71575095e-03f, -8.19284916e-02f, 9.41492021e-02f, -4.27359901e-02f, 8.30307677e-02f, 8.22506696e-02f, -3.89733389e-02f, 1.03620831e-02f,
  7.00087175e-02f, 5.56590892e-02f, 6.18212707e-02f, -1.27798468e-02f, -5.83163388e-02f, 5.48652485e-02f, -3.41616385e-02f, -1.09828725e-01f, -1.75618120e-02f, -3.56436633e-02f,
  2.69148368e-02f, -5.57293892e-02f, -2.85910852e-02f, -5.12056537e-02f, 5.87480478e-02f, 2.40022670e-02f, 8.67646858e-02f, 3.43680717e-02f, 8.24755728e-02f, 1.17266260e-01f,
  -8.26349109e-02f, 2.75633167e-02f, -3.14718932e-02f, 2.24615112e-02f, 1.08243739e-02f, 5.00736050e-02f, -1.02066055e-01f, -9.51913074e-02f, -2.62751691e-02f, 4.41315658e-02f,
  -4.27290872e-02f, -6.69191554e-02f, 5.78537136e-02f, -6.93140179e-02f, -5.72114401e-02f, -1.46360658e-02f, -3.27895433e-02f, 7.09094107e-02f, -7.60608092e-02f, 8.40873737e-03f,
  9.14094783e-03f, -3.46882828e-02f, 3.13261561e-02f, 1.64099503e-02f, -8.68881047e-02f, -7.59848952e-02f, -8.70634466e-02f, -1.04843058e-01f, -4.25766185e-02f, -5.99700436e-02f,
  2.09603801e-01f, -8.58813301e-02f, 1.19050341e-02f, 8.09430704e-02f, -3.91665623e-02f, 5.40647656e-02f, -1.13794897e-02f, -8.92714337e-02f, -4.15674523e-02f, 3.74722332e-02f,
  -5.04783019e-02f, 3.94208431e-02f, -3.32866907e-02f, 5.32453880e-02f, 2.81389449e-02f, -4.91318479e-02f, -9.27186608e-02f, -5.86313047e-02f, 2.36393642e-02f, 2.19238270e-02f,
  -2.34835763e-02f, -8.12958851e-02f, 3.77143249e-02f, -2.37438399e-02f, -3.11986879e-02f, -3.82177234e-02f, 3.12236343e-02f, -1.29975406e-02f, -4.64298204e-02f, -1.71588678e-02f,
  -2.94099361e-01f, -1.60096526e-01f, -3.76524739e-02f, -1.33889928e-01f, 4.53774109e-02f, -3.25373970e-02f, 7.55567010e-03f, -1.37057360e-02f, -9.26916972e-02f, 6.27793372e-02f,
  3.21026444e-02f, 6.36846796e-02f, -2.16250047e-02f, -3.58330533e-02f, -3.65291908e-02f, -1.93429869e-02f, 1.15957567e-02f, -4.29844633e-02f, 5.28516173e-02f, 1.23435698e-01f,
  6.65639862e-02f, 2.25206017e-02f, -1.42718568e-01f, 7.97140673e-02f, 8.58388469e-02f, 1.13953324e-02f, 1.53326802e-02f, 2.62468886e-02f, -3.99311297e-02f, -4.27582748e-02f,
  5.74127911e-03f, -8.49433169e-02f, 3.00204251e-02f, -9.26411431e-03f, 7.10853487e-02f, -3.06300279e-02f, -1.81114543e-02f, -2.71925479e-02f, -1.75580755e-02f, 2.04728190e-02f,
  7.51809776e-02f, 6.59061670e-02f, -1.15738586e-02f, 5.95678501e-02f, -9.82291251e-02f, -2.70530656e-02f, 2.94466633e-02f, -1.49635047e-01f, 1.27476417e-02f, -8.18389878e-02f,
  -1.52524123e-02f, 6.94152266e-02f, -4.42465954e-02f, -1.05924569e-01f, -5.91668375e-02f, 4.19488773e-02f, -7.29760900e-02f, -4.03392017e-02f, -9.74368006e-02f, -6.15500025e-02f,
  2.18435209e-02f, 2.52044853e-02f, -5.45010827e-02f, 7.34167099e-02f, -7.57282227e-02f, -3.55669670e-02f, -3.53884809e-02f, -2.31087487e-02f, -4.02807519e-02f, 3.36118713e-02f,
  -1.43617019e-02f, -3.27324532e-02f, 8.30243248e-03f, -2.28286367e-02f, -6.47028089e-02f, -7.24424347e-02f, -1.10409874e-02f, 1.73614325e-03f, -6.07469380e-02f, 7.84677491e-02f,
  1.18579678e-02f, -7.66352490e-02f, 6.01834357e-02f, 1.16637927e-02f, -3.88282910e-02f, -8.40103105e-02f, 6.62393589e-03f, 2.74072052e-03f, 4.09457870e-02f, -5.43120317e-02f,
  -2.69345697e-02f, 6.29903004e-02f, 3.13152419e-03f, 3.64668816e-02f, 5.03218994e-02f, -3.88107635e-02f, 9.29525122e-02f, -1.57530326e-02f, 6.05343655e-02f, -4.67451401e-02f,
  1.97945889e-02f, 3.87322269e-02f, 1.88848041e-02f, -5.25461398e-02f, 1.70532633e-02f, 8.91740061e-03f, -6.61806315e-02f, -1.10434324e-01f, -6.98160455e-02f, -9.84801874e-02f,
  -4.77233082e-02f, -7.21513852e-03f, -1.65439159e-01f, -9.88552812e-03f, 1.98281035e-02f, -2.83965450e-02f, -3.60286348e-02f, -1.08335637e-01f, -8.68496224e-02f, 8.52814224e-03f,
  6.59612799e-03f, 7.78185874e-02f, -6.59742132e-02f, 1.04725532e-01f, 4.19860557e-02f, -6.71261027e-02f, -5.85670806e-02f, 6.59060702e-02f, 7.96637312e-02f, -5.25881387e-02f,
  4.50908728e-02f, 1.22180887e-01f, 7.14168977e-03f, 6.66872710e-02f, -6.89011440e-02f, 8.98596868e-02f, 7.51379132e-02f, 6.04705187e-03f, 3.92977195e-03f, -1.10077389e-01f,
  1.59981903e-02f, 7.78250024e-02f, -6.34262711e-02f, -1.67264193e-02f, 1.39652729e-01f, 1.75324231e-02f, 3.55678685e-02f, 7.45118558e-02f, 8.05727690e-02f, 1.30519867e-01f,
  -4.87344339e-02f, 1.20117456e-01f, -9.69452485e-02f, 3.43615226e-02f, 1.19266346e-01f, -7.81807210e-03f, -1.71240102e-02f, -3.84342857e-02f, -8.32428262e-02f, -6.59744889e-02f,
  1.31309494e-01f, -6.44767610e-03f, 2.82150693e-03f, -7.06072301e-02f, -3.56774665e-02f, -3.99378277e-02f, 5.11122309e-02f, -7.31765777e-02f, 3.23309414e-02f, 6.44127950e-02f,
  -3.54845189e-02f, -5.67164645e-02f, -5.22267297e-02f, -5.18177683e-03f, -6.51205927e-02f, 2.24677543e-03f, -1.37829650e-02f, 3.57644260e-02f, -9.49857533e-02f, -2.99302898e-02f,
  -1.99257932e-03f, -3.62533554e-02f, -6.55819923e-02f, -7.33874068e-02f, 9.25557781e-03f, -2.01680940e-02f, -3.67646813e-02f, -7.89030790e-02f, -5.16204089e-02f, -5.12681715e-02f,
  4.84802462e-02f, -3.51268500e-02f, 2.84065306e-02f, 1.92515105e-02f, -6.79250285e-02f, 2.19257991e-03f, -8.19843411e-02f, -2.97051854e-02f, 8.76616221e-04f, -3.62093560e-03f,
  -6.46686181e-02f, 5.65433642e-03f, 7.30186477e-02f, 2.91340444e-02f, -9.77338627e-02f, -2.87952367e-02f, -4.14788350e-02f, 3.48998122e-02f, -4.03867736e-02f, -7.91536421e-02f,
  -7.96926245e-02f, 4.12871828e-03f, -4.82352413e-02f, 6.50298521e-02f, 5.55292778e-02f, 5.45347296e-02f, 2.86725927e-02f, 3.37609313e-02f, 1.18063413e-01f, 6.25280738e-02f,
  4.63086590e-02f, 9.73431394e-02f, 6.45800829e-02f, -2.72551868e-02f, -7.79346228e-02f, -4.36431449e-03f, 2.01093424e-02f, 8.09939206e-02f, 5.36764693e-03f, 1.13401078e-01f,
  8.70215595e-02f, -2.68785823e-02f, -7.92282596e-02f, 4.33424339e-02f, -5.79551719e-02f, -5.54447211e-02f, -3.57524678e-02f, 5.75403906e-02f, -6.74814582e-02f, -1.49750933e-01f,
  3.38033348e-01f, -1.76819637e-01f, 1.28862515e-01f, 5.00991158e-02f, 1.20675871e-02f, 3.90392467e-02f, -9.17314291e-02f, -4.88681793e-02f, 6.17611632e-02f, -5.61007150e-02f,
  -6.66599870e-02f, -3.41974050e-02f, 7.33051971e-02f, -1.90756600e-02f, 4.58672531e-02f, -9.62188747e-03f, 1.12060927e-01f, 2.10491270e-01f, 2.17828110e-01f, 1.50584951e-01f,
  2.62623578e-02f, 9.14035067e-02f, 2.19163299e-01f, 1.22346409e-01f, -2.82167811e-02f, 8.99620131e-02f, 2.12111324e-02f, 8.66441950e-02f, 5.50083816e-02f, 4.76889163e-02f,
  9.57348198e-02f, -1.42578352e-02f, 1.28145188e-01f, -1.67844091e-02f, -1.00603901e-01f, 1.16952602e-03f, 6.52943924e-03f, 3.95503528e-02f, -3.98946926e-02f, 6.05980642e-02f,
  -1.02571920e-01f, -5.20314872e-02f, 2.62250192e-02f, 1.83318276e-02f, -2.65695881e-02f, -7.20039085e-02f, -2.28564814e-02f, 4.70344462e-02f, -4.45784815e-02f, -2.01060083e-02f,
  -1.19443409e-01f, -6.24917746e-02f, -3.26187722e-02f, -3.87933664e-02f, 6.18831739e-02f, 7.12850597e-03f, -1.01283006e-01f, 5.42527921e-02f, 2.82536037e-02f, 7.27330241e-03f,
  -7.01997131e-02f, 6.66361600e-02f, 5.32655418e-02f, 3.37954387e-02f, 7.32775331e-02f, 7.00833723e-02f, -1.65484808e-02f, -9.67971087e-02f, -5.66770844e-02f, -4.35861461e-02f,
  -6.14608154e-02f, 1.17519714e-01f, -5.01429141e-02f, -6.77470565e-02f, 5.23310192e-02f, -3.99855971e-02f, 4.37189415e-02f, -3.03076580e-02f, -2.92563578e-03f, 1.76923163e-02f,
  3.24741192e-02f, -5.95040321e-02f, 6.79226294e-02f, -5.83227575e-02f, -9.88153666e-02f, 7.92263970e-02f, 6.59041554e-02f, -3.70247848e-02f, 1.40863229e-02f, 4.89613414e-02f,
  -1.94376320e-01f, -4.39748503e-02f, 1.17885917e-01f, 6.59294799e-02f, 6.99250326e-02f, -1.09979045e-02f, 2.53627636e-02f, -3.07864677e-02f, -6.42239377e-02f, 3.86027843e-02f,
  7.38165248e-03f, 7.85737634e-02f, -5.66457026e-02f, -1.55543163e-02f, 1.22670442e-01f, 8.00782815e-02f, -1.33120120e-01f, 4.32377718e-02f, -3.21384743e-02f, -4.44083624e-02f,
  -8.67841095e-02f, 1.10678501e-01f, 1.37864918e-01f, 2.89217122e-02f, 6.22272864e-03f, 9.49701071e-02f, 7.04244897e-02f, -5.44410609e-02f, -1.63747333e-02f, -6.58545364e-03f,
  3.97551358e-01f, -2.97294229e-01f, 7.23297596e-02f, -4.10559848e-02f, -1.23366043e-01f, -9.93842334e-02f, -1.57625496e-01f, 7.50625879e-02f, 1.92397442e-02f, -3.51484492e-02f,
  3.04595660e-02f, 1.89560726e-01f, 2.29960844e-01f, 1.86897144e-01f, 1.54353961e-01f, -1.01972267e-01f, -7.23716393e-02f, 2.04291865e-01f, 2.71209687e-01f, -3.66484001e-02f,
  -1.11881651e-01f, -5.82097620e-02f, -7.78362714e-03f, -7.31317792e-03f, -3.72070037e-02f, 6.49873689e-02f, -1.34112775e-01f, -1.32362977e-01f, -9.64502692e-02f, -1.40554398e-01f,
  3.37665342e-02f, 1.36639029e-02f, 1.42486945e-01f, 1.16448320e-01f, -3.39196920e-02f, 5.22684120e-03f, 9.27102417e-02f, -8.56670439e-02f, -6.86891451e-02f, -1.58581316e-01f,
  8.46691523e-03f, -3.27620655e-02f, 6.34347647e-02f, -8.24364126e-02f, -1.31171778e-01f, -3.84596735e-02f, -6.47360608e-02f, 1.70020778e-02f, 2.91221477e-02f, -2.97897886e-02f,
  -2.75600492e-03f, 2.99469400e-02f, -2.34709238e-03f, 1.61553291e-03f, 3.27572301e-02f, 1.99088961e-01f, -8.50725099e-02f, 9.28297713e-02f, 1.65891916e-01f, -4.90215942e-02f,
  7.04528317e-02f, 2.66815107e-02f, 1.28649488e-01f, 4.37309630e-02f, -3.16942967e-02f, -2.18563527e-02f, -4.35294472e-02f, -1.07507773e-01f, 4.17242534e-02f, -7.13712797e-02f,
  -1.20848268e-02f, 2.21798085e-02f, -6.52378201e-02f, 1.80421378e-02f, 4.82218452e-02f, -6.60519907e-03f, 3.99113558e-02f, -1.02338448e-01f, -5.45113236e-02f, 5.54418229e-02f,
  7.41443336e-02f, 1.40248835e-02f, -1.68725029e-02f, -8.79707336e-02f, 6.60524741e-02f, 1.09124370e-01f, 2.24450938e-02f, 8.80218446e-02f, 4.92361858e-02f, -5.23453616e-02f,
  -1.65300921e-01f, 1.15433015e-01f, 2.55880170e-02f, 4.91305217e-02f, 9.90292523e-03f, 1.90233327e-02f, -7.86096416e-03f, 1.79200247e-02f, 2.59174909e-02f, 1.17665520e-02f,
  2.41155904e-02f, 1.30511105e-01f, -2.72070244e-03f, -2.74645444e-02f, -6.42946884e-02f, 8.72498378e-03f, -4.13397253e-02f, 6.23481311e-02f, 8.20550546e-02f, -1.08225204e-01f,
  -4.41454770e-03f, 7.73650408e-02f, 1.66700900e-01f, 1.15959793e-02f, 1.27847314e-01f, 1.25865757e-01f, 5.88898323e-02f, 6.33616522e-02f, 1.99947074e-01f, -8.16795081e-02f,
  -3.54586430e-02f, 8.35039914e-02f, -1.59514416e-02f, -2.82529294e-02f, 1.05978504e-01f, -6.61321208e-02f, 5.26099205e-02f, 4.00218181e-03f, 5.91926537e-02f, 8.58505294e-02f,
  5.46114482e-02f, -6.69274852e-02f, -4.85673063e-02f, -7.11363181e-02f, -1.77931175e-01f, -5.36112534e-03f, -6.36681542e-02f, -2.42236987e-01f, -3.29253644e-01f, -1.23164102e-01f,
  1.17466385e-02f, -4.98267822e-02f, -1.72963142e-01f, -8.34969953e-02f, 8.65688324e-02f, 8.48734304e-02f, -2.92081404e-02f, 3.13308934e-04f, 1.28082603e-01f, 1.34263366e-01f,
  5.50952516e-02f, 3.91540490e-02f, -1.44101858e-01f, 1.25565097e-01f, -5.10492176e-03f, 3.43557373e-02f, 1.22985970e-02f, 3.24502662e-02f, -4.75131199e-02f, -2.88323238e-02f,
  5.93715683e-02f, 6.80462942e-02f, 5.91824315e-02f, -7.07451478e-02f, -2.78334972e-03f, -1.14872187e-01f, -1.07817270e-01f, -9.67813581e-02f, -1.14204288e-01f, -8.03740025e-02f,
  -2.14740559e-02f, 1.08283617e-01f, 2.44410113e-02f, 1.13410261e-02f, 3.00941989e-02f, -3.68572176e-02f, 1.81089086e-03f, -4.59974771e-03f, 6.51410669e-02f, 1.02014065e-01f,
  -6.48091137e-02f, 3.59948166e-02f, 7.17637464e-02f, 4.48936038e-02f, -4.91243377e-02f, 4.82986979e-02f, -8.34462941e-02f, 6.41571805e-02f, -6.65422007e-02f, -7.29855970e-02f,
  -1.01424403e-01f, 2.77773086e-02f, -1.63434707e-02f, 2.77803149e-02f, 9.76163056e-03f, -2.39405185e-02f, 4.16075112e-03f, -5.50749153e-02f, -5.86926080e-02f, 3.03896591e-02f,
  -6.72558174e-02f, 4.89497408e-02f, -2.50895582e-02f, 1.83969289e-02f, -1.74293406e-02f, -5.48988618e-02f, 6.59301728e-02f, 1.90567616e-02f, -1.76811814e-02f, 5.56424744e-02f,
  -1.86079502e-01f, -4.57045212e-02f, 2.36542355e-02f, -8.54078755e-02f, -6.40260708e-03f, -6.54139146e-02f, -3.43054682e-02f, -9.05207321e-02f, -1.13745742e-02f, -1.11835971e-01f,
  6.37195185e-02f, -4.54355367e-02f, 1.24202203e-02f, -8.66242871e-02f, -1.13608316e-01f, -2.87703387e-02f, 8.26070830e-02f, -3.82886529e-02f, 2.10652519e-02f, -3.80964428e-02f,
  -5.21637127e-02f, -2.43197624e-02f, -1.32399514e-01f, -8.33455399e-02f, -1.04304086e-02f, -6.38294891e-02f, -2.28952412e-02f, -9.92305875e-02f, -6.31525591e-02f, -9.30848625e-03f,
  -2.85535734e-02f, 8.40072855e-02f, 8.51761699e-02f, 4.78239916e-02f, 1.03189431e-01f, 1.75253615e-01f, 1.34621337e-01f, -1.90560371e-02f, -4.86042388e-02f, 7.89849670e-04f,
  7.47762993e-02f, 3.91936526e-02f, -1.56500172e-02f, 8.49667564e-02f, -2.91634016e-02f, -7.13382736e-02f, -4.73245382e-02f, -9.67917815e-02f, -7.00388029e-02f, 4.71102744e-02f,
  -4.57888432e-02f, -8.14345479e-02f, -9.68032256e-02f, -7.66354278e-02f, -4.24246415e-02f, -9.68272611e-03f, -1.09478645e-01f, 6.37234598e-02f, -2.56446004e-02f, -1.54265627e-01f,
  2.37107668e-02f, 1.12529442e-01f, 3.82530801e-02f, 2.42072437e-03f, 7.00669289e-02f, -1.14014149e-01f, 8.69576633e-03f, 2.21468993e-02f, -5.68208396e-02f, 6.66835383e-02f,
  3.07785049e-02f, 6.72014430e-02f, -2.74743382e-02f, 2.71587372e-02f, -3.18281017e-02f, -2.32383497e-02f, 2.07651895e-03f, -9.67647135e-02f, 3.72802429e-02f, -2.90747192e-02f,
  2.69403346e-02f, 7.36435577e-02f, -1.71831157e-02f, 3.53491530e-02f, 2.62891147e-02f, 5.68226315e-02f, 4.42770682e-02f, -4.40266319e-02f, 9.11029205e-02f, -8.57172981e-02f,
  -7.83070326e-02f, 6.20988049e-02f, 1.99595429e-02f, 2.56722551e-02f, -1.09420959e-02f, 3.86357047e-02f, -3.59825827e-02f, 2.81998329e-02f, 9.19466559e-03f, 2.87263282e-02f,
  7.41928965e-02f, -6.28329068e-03f, 3.01142037e-02f, -9.55517963e-02f, -1.19693680e-02f, -6.32220209e-02f, -8.91499396e-04f, 2.35138088e-02f, 8.06106254e-02f, 7.88251869e-03f,
  -3.89035679e-02f, 9.95344892e-02f, -7.69371465e-02f, 8.38379636e-02f, 5.02646826e-02f, 7.81864747e-02f, -7.45016113e-02f, 9.80866402e-02f, 1.02243483e-01f, 2.94785202e-02f,
  6.66353106e-03f, 1.87607542e-01f, -1.29212260e-01f, -8.88576284e-02f, 6.08118773e-02f, 2.44335905e-02f, -4.96901460e-02f, 2.35744249e-02f, 4.83466163e-02f, -6.28499091e-02f,
  -1.14072766e-02f, -1.62466485e-02f, 5.85697731e-03f, 4.10759225e-02f, 9.80476588e-02f, 3.00045293e-02f, 4.00892347e-02f, -3.29713151e-02f, -5.22685647e-02f, 7.43837953e-02f,
  4.32055220e-02f, -1.92136280e-02f, -1.67412907e-02f, -9.15641487e-02f, 6.84467554e-02f, 9.49464738e-02f, 5.11823408e-02f, -2.50705667e-02f, -4.45110276e-02f, -1.38228923e-01f,
  -2.18087673e-01f, 6.19510449e-02f, 1.73539333e-02f, -8.07288475e-03f, 1.33590445e-01f, 1.27583250e-01f, 1.97542682e-01f, 1.05518803e-01f, -5.64057641e-02f, 4.35723551e-02f,
  1.44935036e-02f, 3.21176685e-02f, -3.73585522e-02f, 9.40257013e-02f, -2.03929972e-02f, 1.28824919e-01f, -1.43504189e-02f, -2.15005670e-02f, -1.00863829e-01f, 5.73427118e-02f,
  -3.10025323e-04f, -7.96526112e-03f, -6.82060570e-02f, -1.00056035e-02f, 6.35362715e-02f, -1.42130349e-02f, -3.61550003e-02f, -8.03570170e-03f, 1.13033749e-01f, 3.36722285e-02f,
  6.55204430e-03f, -7.70218819e-02f, 2.69704289e-03f, 6.61748573e-02f, 7.03057200e-02f, -1.16459560e-02f, -6.45066500e-02f, -8.20117071e-02f, -6.78618613e-04f, 4.72485758e-02f,
  -2.63485610e-02f, 7.94615299e-02f, 9.22505036e-02f, -1.80718973e-02f, 3.04709505e-02f, -7.81031027e-02f, 3.02631967e-02f, 3.49210985e-02f, -6.02056496e-02f, -5.59950322e-02f,
  1.19667158e-01f, 5.72519004e-02f, 7.88865834e-02f, 4.41557588e-03f, 1.65498797e-02f, -8.31198022e-02f, -2.66633071e-02f, -2.58713253e-02f, -7.62840509e-02f, 1.96367055e-02f,
  3.29130776e-02f, 4.35458608e-02f, -1.15068750e-02f, 1.09922455e-03f, -4.11793999e-02f, 1.24814101e-02f, 7.92225450e-02f, 5.15497029e-02f, 1.86313093e-02f, -8.50949138e-02f,
  -4.46040705e-02f, 6.32697493e-02f, -9.82635617e-02f, -5.93511686e-02f, 6.13540709e-02f, -5.14233895e-02f, 4.58958820e-02f, 4.74476852e-02f, -4.75603342e-02f, -1.21261133e-02f,
  -3.48339528e-02f, -1.55383497e-02f, -9.87638012e-02f, 5.77804670e-02f, -6.58551604e-02f, -2.20769588e-02f, 8.02503452e-02f, 4.77750041e-03f, -4.51057553e-02f, -6.68414682e-02f,
  -2.50249058e-02f, -6.77065691e-03f, -1.42887142e-02f, -5.21554761e-02f, -4.08943258e-02f, -6.18720055e-02f, -3.10173500e-02f, -3.47873755e-02f, 6.04776591e-02f, -6.44720793e-02f,
  -6.36542216e-02f, -7.79298618e-02f, -5.99855781e-02f, -5.09002209e-02f, 5.59821874e-02f, -3.40547748e-02f, -6.07668273e-02f, 2.66414359e-02f, 5.64629957e-02f, -1.81238893e-02f,
  -5.26561253e-02f, -7.01498166e-02f, 4.15634038e-03f, -3.22658457e-02f, 2.43930332e-02f, 5.54261804e-02f, -6.84368238e-02f, -1.01381920e-01f, -8.39254707e-02f, 2.02909019e-03f,
  -3.25417757e-01f, -1.93903208e-01f, -1.48632243e-01f, 1.10960595e-01f, 6.11994117e-02f, -5.34704067e-02f, -9.00283754e-02f, -3.73553745e-02f, -5.61142750e-02f, -1.74217019e-02f,
  -1.84336808e-02f, 1.28596321e-01f, 6.59761950e-02f, 1.03468165e-01f, -7.55579919e-02f, -6.05039969e-02f, -2.46062502e-03f, 6.78519234e-02f, -1.41271679e-02f, -4.61418517e-02f,
  1.26758054e-01f, 3.62108834e-02f, 4.89739329e-02f, 7.78834149e-02f, 3.72160636e-02f, -9.13590251e-04f, 6.76406994e-02f, -5.79270497e-02f, 7.43229836e-02f, 2.46338755e-01f,
  9.90830828e-03f, -3.05181649e-02f, 5.75163327e-02f, 1.81181170e-02f, 7.06972778e-02f, -3.14156972e-02f, 8.38971406e-04f, 8.08684751e-02f, -5.48470914e-02f, -1.07142990e-02f,
  6.21574894e-02f, 2.99440622e-02f, 4.62640040e-02f, 6.71289712e-02f, -2.75889095e-02f, 6.32752141e-04f, 2.37269476e-02f, -3.16336658e-03f, -1.17879421e-01f, 3.41488682e-02f,
  2.13835984e-02f, -1.78809296e-02f, -1.52716115e-01f, -9.70814601e-02f, -9.46509913e-02f, -1.74291842e-02f, -4.11995724e-02f, -5.34361750e-02f, -1.39501780e-01f, -9.37651396e-02f,
  3.01625915e-02f, 2.11220162e-04f, -4.47618170e-03f, -3.33299749e-02f, -1.99340861e-02f, 5.77333272e-02f, 9.79052782e-02f, 1.49617195e-02f, 6.74141422e-02f, -1.70941316e-02f,
  1.57433636e-02f, -7.75017962e-02f, -1.65657327e-02f, -6.75749704e-02f, 3.21867615e-02f, -1.82510987e-02f, 8.04606304e-02f, -4.43396606e-02f, -5.16817458e-02f, -4.12337072e-02f,
  5.88370003e-02f, -8.20444375e-02f, 4.01593335e-02f, -2.94901021e-02f, -4.73966915e-03f, 9.01276469e-02f, 6.81215376e-02f, 1.03795063e-02f, -5.75538650e-02f, -9.43783894e-02f,
  -1.41440853e-01f, -8.06436688e-02f, -1.14263624e-01f, -3.58006544e-02f, 2.57382207e-02f, 2.05587968e-03f, 9.01630241e-03f, -7.12156817e-02f, -5.52165695e-02f, -1.33854961e-02f,
  -8.34225565e-02f, -9.53258350e-02f, -1.59888770e-02f, 5.67213865e-03f, -6.44611269e-02f, -1.87877286e-02f, -9.45766941e-02f, 2.75405720e-02f, 4.76876833e-03f, 2.67601311e-02f,
  -3.47578414e-02f, -1.03639796e-01f, -1.80319473e-01f, -9.94949639e-02f, -6.68937936e-02f, -8.90754238e-02f, -7.45649859e-02f, -1.06909737e-01f, -2.63769150e-01f, -2.70152420e-01f,
  1.14585325e-01f, 1.02652520e-01f, -1.66515544e-01f, 5.37606189e-03f, 5.44827618e-02f, -2.58286893e-02f, -6.83228811e-03f, 5.93393557e-02f, 1.70987472e-01f, 1.69769414e-02f,
  -4.07221094e-02f, 5.55863697e-03f, 4.68281060e-02f, -1.00930251e-01f, -5.61305918e-02f, -1.07925385e-01f, -7.29338229e-02f, -1.13800518e-01f, -4.91362847e-02f, 8.13514814e-02f,
  1.00593470e-01f, 4.08114567e-02f, -4.03416436e-03f, 1.20906122e-02f, -8.83757975e-03f, 6.69267923e-02f, 1.02875903e-02f, 4.63408269e-02f, 4.57305387e-02f, -1.18587904e-01f,
  -1.66738212e-01f, -1.50992721e-02f, -6.26858547e-02f, 8.56908634e-02f, -1.68556757e-02f, 7.84473941e-02f, 2.44451989e-03f, -3.32227498e-02f, 6.06208714e-03f, 6.86812997e-02f,
  1.09153902e-02f, -7.59186149e-02f, -1.63156502e-02f, 5.90408482e-02f, 1.16403885e-01f, 5.67016751e-02f, 5.68371564e-02f, 7.87366927e-02f, 6.74146637e-02f, 2.52753776e-03f,
  9.62876901e-03f, -9.20360386e-02f, 1.44446278e-02f, -5.01150191e-02f, 3.09267174e-02f, -6.20989725e-02f, 6.77982271e-02f, -4.23280150e-02f, 3.07959374e-02f, 8.93997401e-02f,
  7.96139520e-03f, -2.01238319e-02f, 6.80549536e-04f, -5.23061715e-02f, -8.04314110e-03f, 2.06221174e-02f, 2.85773221e-02f, -3.27263474e-02f, 6.23492151e-02f, 3.35030854e-02f,
  5.13109155e-02f, -4.85703945e-02f, 3.74414735e-02f, -5.71717788e-03f, 6.97000995e-02f, 4.21265252e-02f, 3.82310897e-03f, -3.60730477e-02f, -4.93491665e-02f, -3.43030728e-02f,
  -3.74835804e-02f, -9.44338664e-02f, -4.97000106e-02f, -3.28889186e-03f, -6.58127666e-02f, -7.27946311e-02f, -2.73139365e-02f, -1.56814480e-04f, 8.14851969e-02f, 1.16183143e-02f,
  2.00620398e-01f, -1.29570439e-01f, -5.44094369e-02f, 2.72590797e-02f, 6.50947765e-02f, 3.05646379e-02f, 4.57030535e-02f, 8.93382579e-02f, -2.88697351e-02f, 2.60538273e-02f,
  1.97758861e-02f, -3.36235091e-02f, 1.10374026e-01f, 8.95863846e-02f, 7.10633642e-04f, 3.68567035e-02f, 6.14626408e-02f, 5.34289107e-02f, 9.23002735e-02f, -3.48097049e-02f,
  3.17560136e-02f, -1.61191504e-02f, -5.31732515e-02f, 1.69428089e-03f, -5.48260398e-02f, 3.42246443e-02f, -1.26035539e-02f, -1.94791202e-02f, -9.47302356e-02f, 7.13684857e-02f,
  -2.65092194e-01f, -2.19006930e-02f, 1.32582366e-01f, -9.36764628e-02f, -1.55702010e-02f, 3.10643315e-02f, -2.10218616e-02f, -1.79431304e-01f, -1.59892112e-01f, -1.84099022e-02f,
  3.16608921e-02f, -8.19948614e-02f, 1.53978085e-02f, 7.83032551e-03f, -9.13339388e-03f, 5.34957387e-02f, 6.11596517e-02f, 9.17427316e-02f, -8.82620886e-02f, 5.12985140e-02f,
  -1.44533608e-02f, -8.85889977e-02f, -1.30130336e-01f, 1.61577500e-02f, 5.02240509e-02f, 3.88043858e-02f, 2.76285987e-02f, -1.08429482e-02f, 4.11791690e-02f, 1.78317875e-01f,
  3.39826137e-01f, 2.94692647e-02f, -2.59656776e-02f, -9.87223834e-02f, 1.06160358e-01f, 4.88237552e-02f, -3.52753773e-02f, 4.97535579e-02f, -1.02487713e-01f, -5.18475808e-02f,
  2.58367024e-02f, 9.07228701e-03f, 2.29616221e-02f, -1.55340126e-02f, 8.31761509e-02f, 2.77429577e-02f, -9.00470167e-02f, 7.34381750e-02f, 2.44653858e-02f, 5.13481200e-02f,
  -1.44240614e-02f, 3.84291783e-02f, -1.01598296e-02f, -8.86168238e-03f, -6.51364774e-02f, 8.29916671e-02f, -8.58050678e-03f, -5.29781682e-03f, 1.06158920e-01f, 6.98468983e-02f,
  6.09169062e-03f, -6.63161725e-02f, -7.02401996e-02f, -8.13150629e-02f, 5.27182221e-02f, -3.76753218e-04f, 4.88894545e-02f, -4.80867960e-02f, 1.70784183e-02f, 5.25761843e-02f,
  2.11185496e-02f, 7.41918944e-03f, 2.70036347e-02f, 1.70162506e-02f, -1.74299683e-02f, 8.82663727e-02f, 5.12342826e-02f, -8.40860829e-02f, 6.37983903e-02f, 1.74736474e-02f,
  -5.83917797e-02f, -2.28927322e-02f, 4.58908416e-02f, 7.37195760e-02f, -5.69235254e-03f, -2.81534959e-02f, 4.89900596e-02f, 6.91817924e-02f, 1.69538967e-02f, -1.83077005e-03f,
  5.05591147e-02f, -2.10696775e-02f, 1.14566542e-01f, 3.03470790e-02f, -5.76157635e-03f, 5.01295328e-02f, -9.71681904e-03f, 5.23545817e-02f, 3.45379002e-02f, 7.89805129e-02f,
  1.07474491e-01f, -2.34784521e-02f, -4.99128224e-03f, 9.38227102e-02f, 1.07475370e-02f, -1.06729986e-02f, -1.02107404e-02f, -7.99548626e-03f, 3.93969901e-02f, 1.39205649e-01f,
  4.02701795e-02f, -6.91270158e-02f, 5.26843369e-02f, -1.02474829e-02f, -3.10409069e-02f, 7.11930022e-02f, 1.73467442e-01f, 1.02493525e-01f, 2.21507549e-02f, -3.02398261e-02f,
  1.41258031e-01f, 5.40342107e-02f, -1.41227692e-01f, 5.80375269e-03f, 1.40406527e-02f, -1.49070993e-01f, -1.70767345e-02f, -1.13761351e-01f, 8.38811472e-02f, -8.13583564e-03f,
  9.60880518e-02f, -2.57471148e-02f, -1.27868960e-02f, 6.78852051e-02f, -5.10893501e-02f, 5.88479899e-02f, -3.59525234e-02f, 5.74112572e-02f, -1.73193291e-02f, 8.26767534e-02f,
  1.11024447e-01f, -1.55447610e-02f, -4.19985969e-03f, 3.25118303e-02f, 1.36655509e-01f, 1.00082830e-01f, 4.76180576e-02f, 1.25448748e-01f, 1.28573164e-01f, 2.10866868e-01f,
  4.71123122e-03f, 1.21000841e-01f, -2.79256329e-02f, 7.73532540e-02f, 5.49765714e-02f, 1.24085695e-01f, 1.17322721e-01f, 1.18195720e-01f, 6.95896223e-02f, 9.55385268e-02f,
  8.60769600e-02f, 9.32881981e-02f, 1.01743065e-01f, 6.94898888e-02f, 5.72520234e-02f, 9.93055850e-02f, 5.59911057e-02f, -3.73350158e-02f, 1.68089778e-03f, 9.80301499e-02f,
  6.68265224e-02f, -4.76828665e-02f, -3.91469970e-02f, 2.28604805e-02f, 1.60506535e-02f, -4.19686064e-02f, -5.10940440e-02f, -1.28312055e-02f, -9.24696624e-02f, 1.22490205e-01f,
  5.11185192e-02f, 9.99490637e-03f, 6.16674870e-02f, -4.24967110e-02f, -1.43601801e-02f, -9.31387395e-02f, 2.65928879e-02f, 5.55022322e-02f, 1.74827799e-02f, -5.07156514e-02f,
  -7.14374930e-02f, 3.97711620e-02f, -6.66049421e-02f, -1.52597539e-02f, 2.49620993e-02f, 7.19979852e-02f, 8.49345401e-02f, -7.24934088e-03f, -4.39848900e-02f, -2.20093932e-02f,
  -3.06522474e-02f, -6.40719384e-02f, -6.00435622e-02f, 1.09384298e-01f, -7.13743791e-02f, -3.11509776e-03f, -5.67293307e-03f, -7.23398943e-03f, -6.50160238e-02f, -2.01821160e-02f,
  -8.09358358e-02f, -1.43278882e-01f, 1.14933036e-01f, 1.57220036e-01f, -1.43624777e-02f, 5.88285699e-02f, -5.57898581e-02f, 3.93009000e-02f, 4.04325090e-02f, 2.74018627e-02f,
  -4.76637259e-02f, -5.23033515e-02f, 7.46340007e-02f, 5.22174984e-02f, 3.84548530e-02f, -8.90402347e-02f, 1.14969805e-01f, -4.83157709e-02f, -9.98242795e-02f, -1.25240590e-02f,
  -9.98129416e-03f, -9.16327685e-02f, -8.47253948e-02f, -1.22083493e-01f, 1.86242349e-02f, -3.61684188e-02f, -1.13394842e-01f, -2.94944178e-03f, 6.39963709e-03f, -1.59101054e-01f,
  5.36053777e-02f, -2.93205172e-01f, -7.12905899e-02f, -1.20921426e-01f, -2.07505375e-01f, -1.94245994e-01f, -2.36131355e-01f, -6.08752817e-02f, -1.11405039e-02f, -2.55915642e-01f,
  -1.13478489e-01f, -4.54088412e-02f, 8.17480832e-02f, 1.06854483e-01f, 1.22403577e-01f, -1.97720081e-01f, -7.52875656e-02f, 1.38065428e-01f, 1.12279356e-01f, 9.39319581e-02f,
  -1.34389132e-01f, -6.02588989e-02f, 1.25688106e-01f, -4.02609967e-02f, -1.70435622e-01f, -1.33647412e-01f, -4.36870456e-02f, -9.19761285e-02f, -2.01182626e-02f, -2.22258314e-01f,
  -1.04143657e-01f, -1.17260525e-02f, 8.75936300e-02f, 8.53541344e-02f, -2.93898080e-02f, -2.97850333e-02f, -1.15577325e-01f, 1.19442865e-02f, -1.48686683e-02f, 2.12468933e-02f,
  3.70132327e-02f, 1.92615995e-03f, 3.84498574e-02f, 4.95593324e-02f, -6.67932630e-02f, -4.09881920e-02f, 5.20809740e-02f, 6.18762821e-02f, 1.32027149e-01f, -1.43300379e-02f,
  -8.00700411e-02f, -1.10499017e-01f, -2.77373623e-02f, 1.36926631e-02f, 1.26658995e-02f, 1.00318086e-03f, -2.75307372e-02f, -5.89705482e-02f, 4.64363061e-02f, -6.19285628e-02f,
  -2.20504943e-02f, -2.34347750e-02f, -1.07700899e-02f, -4.80619110e-02f, -4.11370285e-02f, 7.45384172e-02f, -4.64743227e-02f, -5.81733212e-02f, 6.90000877e-02f, -5.80676012e-02f,
  7.22593665e-02f, -5.37944473e-02f, -5.40857501e-02f, -4.49753329e-02f, -1.84988305e-02f, 1.32461414e-02f, 3.76470797e-02f, 5.39094992e-02f, 6.30479380e-02f, -6.76628724e-02f,
  8.87917951e-02f, -4.64960113e-02f, 1.65620502e-02f, 6.88881874e-02f, 7.00424751e-03f, -2.42407620e-02f, 9.60530527e-03f, 5.30160703e-02f, 7.02882558e-02f, -2.69151926e-02f,
  -8.70103985e-02f, 1.72216415e-01f, -3.37472074e-02f, 1.82816964e-02f, -2.54575666e-02f, 3.83997075e-02f, -8.42741653e-02f, 7.70295337e-02f, -4.85948753e-03f, -8.11455995e-02f,
  6.66378951e-03f, -4.13507558e-02f, -5.84635772e-02f, -3.53790843e-03f, -5.46238013e-02f, -1.11517189e-02f, -1.22666918e-01f, 1.34245204e-02f, 1.62326191e-02f, 6.30166605e-02f,
  2.95111928e-02f, 3.52099724e-02f, -9.81139718e-04f, 5.04790768e-02f, -8.25689435e-02f, 9.51872300e-03f, -9.11295041e-02f, -9.65231284e-02f, 1.06552623e-01f, -1.35325417e-01f,
  6.44951463e-02f, 1.38477264e-02f, 8.61129388e-02f, -4.71341982e-03f, -3.11443377e-02f, -1.06556952e-01f, -1.29765511e-01f, -9.63034853e-03f, 7.52588734e-02f, -6.05765507e-02f,
  -3.76968794e-02f, 3.91298197e-02f, 7.63792172e-02f, 1.14040658e-01f, 8.91421661e-02f, -1.04247570e-01f, -1.20536154e-02f, 3.43773142e-02f, 2.59399824e-02f, 3.30094397e-02f,
  -8.20705667e-02f, 3.97079848e-02f, 1.24852629e-02f, -8.69454350e-03f, -1.07512407e-01f, -2.85739452e-02f, -2.71078870e-02f, -8.36386606e-02f, -1.31808922e-01f, -6.82519609e-03f,
  -8.62152800e-02f, -1.25613257e-01f, 1.51399285e-01f, -1.22109782e-02f, 9.24064219e-02f, 8.58473480e-02f, -8.99906736e-03f, 6.24369308e-02f, 3.47408392e-02f, 1.24636125e-02f,
  -6.16845191e-02f, 3.55610698e-02f, -7.74276406e-02f, 5.42133451e-02f, -6.62830696e-02f, -2.96516065e-02f, 1.59480833e-02f, 1.14043936e-01f, 1.30326778e-01f, 2.76845321e-02f,
  3.53773274e-02f, 2.72214115e-02f, -6.82925209e-02f, -5.02447821e-02f, 8.31840634e-02f, 2.16598753e-02f, -2.14356016e-02f, -2.10812707e-02f, 2.56751012e-03f, -7.39655271e-03f,
  3.12007796e-02f, 2.68556345e-02f, -4.47073877e-02f, 9.31764860e-03f, -4.16618027e-02f, -5.66923805e-02f, -6.51488155e-02f, 6.71937317e-02f, -9.29574296e-02f, -7.48886168e-02f,
  -4.46286127e-02f, -4.42865118e-02f, -2.89670080e-02f, 3.99952382e-02f, 6.26258329e-02f, -6.27470165e-02f, -1.10466652e-01f, -9.96483937e-02f, -5.61462753e-02f, 4.43868078e-02f,
  1.01963254e-02f, -1.14763983e-01f, -4.32209596e-02f, -6.28501251e-02f, 3.51758935e-02f, 1.11809671e-02f, -8.71357992e-02f, 3.87433060e-02f, -8.46983269e-02f, -1.09987289e-01f,
  1.52954832e-01f, 7.09773675e-02f, 2.82774288e-02f, 4.63292859e-02f, -4.52689492e-05f, -4.27339822e-02f, 6.62477687e-02f, 4.29573953e-02f, -3.53552103e-02f, 2.23177299e-02f,
  4.62758653e-02f, -5.99040501e-02f, -4.62598503e-02f, -6.10838234e-02f, -7.56062567e-02f, 4.01534811e-02f, 9.36000645e-02f, 2.53401995e-02f, 1.27294641e-02f, 7.72607401e-02f,
  2.99286246e-02f, 2.57356092e-02f, 1.49980545e-01f, 2.95336712e-02f, -3.18788625e-02f, 3.87536474e-02f, 1.25677034e-01f, 6.38165176e-02f, -2.66354792e-02f, 1.38325438e-01f,
  6.87933192e-02f, 1.19147981e-02f, 9.05297399e-02f, 9.52147767e-02f, 1.38938487e-01f, -7.33583346e-02f, 5.68766594e-02f, -1.13270264e-02f, 9.78770256e-02f, -2.77973339e-02f,
  1.60256043e-01f, 9.24131251e-04f, 2.16343272e-02f, 1.43153677e-02f, -4.86228578e-02f, 8.13881978e-02f, -1.27636138e-02f, 2.61214399e-03f, -2.50842459e-02f, 3.76398414e-02f,
  1.51461475e-02f, -3.16656716e-02f, 7.60517642e-02f, -6.59245178e-02f, 2.41198372e-02f, 9.37410742e-02f, 5.51649295e-02f, 6.69459477e-02f, 5.68263903e-02f, 1.18322307e-02f,
  1.29377589e-01f, -3.57209984e-03f, 4.07563895e-02f, 1.09627843e-01f, 7.59358555e-02f, -3.02632488e-02f, 7.77327344e-02f, -5.60929701e-02f, 9.26065072e-02f, -6.72813430e-02f,
  3.03020962e-02f, 3.00543886e-02f, 5.22473119e-02f, 1.07753370e-02f, -2.03437023e-02f, 6.99066417e-03f, 4.10670834e-03f, -2.04295423e-02f, -3.54581629e-03f, -7.59708807e-02f,
  2.56682886e-03f, 4.24684063e-02f, -2.41595041e-02f, 2.22414266e-02f, -8.61661136e-02f, -6.07076101e-03f, 1.21144159e-02f, -3.17550860e-02f, 3.02361380e-02f, -6.59333020e-02f,
  6.55178679e-04f, 1.65882837e-02f, 8.16473961e-02f, -6.76605552e-02f, -6.60169274e-02f, -3.55854467e-03f, 2.55697519e-02f, 5.04156649e-02f, -4.24190685e-02f, -6.56443685e-02f,
  7.21270218e-02f, -7.28220027e-03f, 1.19056115e-02f, 2.32782327e-02f, 5.09149432e-02f, -3.78765166e-02f, -5.83131202e-02f, -6.50339648e-02f, 4.07098308e-02f, -3.35688554e-02f,
  5.44968806e-02f, -2.18028910e-02f, 9.33589712e-02f, -4.28635348e-03f, 6.78054541e-02f, -5.57071082e-02f, -4.80093621e-03f, -6.41874298e-02f, -5.30462563e-02f, -7.03448206e-02f,
  -1.26649644e-02f, 9.50658917e-02f, 4.82096747e-02f, -2.97750793e-02f, 4.83503863e-02f, -1.86217707e-02f, 5.71394376e-02f, 1.90218147e-02f, 8.19842070e-02f, -9.43949744e-02f,
  9.63416249e-02f, 3.19988355e-02f, -3.17918770e-02f, 5.84815554e-02f, -5.28654158e-02f, -6.13486208e-02f, -8.02737251e-02f, 1.50981499e-02f, -4.31502908e-02f, 3.84510756e-02f,
  -5.47600240e-02f, -4.24976125e-02f, 1.96474493e-02f, -1.01086535e-01f, -2.57655699e-02f, -9.61153582e-02f, -2.16370467e-02f, -1.24340788e-01f, -7.13661164e-02f, -1.22180134e-01f,
  9.54177156e-02f, 2.83404049e-02f, -4.34174873e-02f, -6.01873361e-02f, -3.55423018e-02f, 6.21035807e-02f, -5.28699830e-02f, -7.48616681e-02f, 3.78027111e-02f, 1.02075804e-02f,
  8.63411352e-02f, 7.16472566e-02f, -8.74962006e-03f, 9.82643515e-02f, 7.97377452e-02f, 1.55906538e-02f, -4.34047766e-02f, 9.62715130e-03f, -5.01665403e-04f, 7.31046125e-02f,
  -2.22409591e-02f, 1.58940610e-02f, -1.31141189e-02f, -4.54456098e-02f, -1.80311818e-02f, -6.80785626e-02f, -5.57375513e-02f, 8.65721703e-03f, -6.55267611e-02f, -7.45489001e-02f,
  -1.35751665e-01f, -9.46417078e-02f, 1.80659704e-02f, -4.75923829e-02f, -1.34183550e-02f, -6.31247461e-02f, -2.25509573e-02f, 7.40123838e-02f, -5.46773076e-02f, 3.83901633e-02f,
  3.93497311e-02f, -3.42723913e-02f, -1.01052605e-01f, 3.04512046e-02f, -2.62747728e-03f, -2.25873273e-02f, 9.87735949e-03f, -4.64976281e-02f, -1.07295355e-02f, 4.26406227e-02f,
  3.70650017e-03f, -3.64723499e-04f, 4.01373357e-02f, -8.41700211e-02f, -8.29210877e-02f, -4.98772375e-02f, 9.47275548e-04f, -1.07562512e-01f, -4.66910675e-02f, 1.65807270e-02f,
  -9.15057585e-03f, -5.75073175e-02f, -6.18233234e-02f, -7.42106661e-02f, -3.88342030e-02f, -7.03050569e-02f, 7.59729519e-02f, 5.17116450e-02f, -8.68976936e-02f, 2.52644569e-02f,
  9.80683640e-02f, -6.97230175e-02f, 3.17588337e-02f, -2.59524002e-03f, 1.64755452e-02f, -5.88515773e-02f, 1.78331360e-02f, -4.01070789e-02f, 2.06201449e-02f, -3.53767700e-03f,
  4.93452232e-03f, -4.11514044e-02f, -4.10893410e-02f, 1.72924567e-02f, -5.68181649e-02f, 3.50630060e-02f, 6.61006644e-02f, 8.54698792e-02f, -3.16710249e-02f, -8.55042413e-02f,
  -6.93550259e-02f, -1.02975639e-02f, 6.91769971e-03f, -8.55789613e-03f, 9.46673192e-03f, -1.80757195e-02f, -3.98298316e-02f, -4.71408218e-02f, -1.72297773e-03f, -9.88124385e-02f,
  3.13601941e-02f, -4.55042720e-02f, 6.98952302e-02f, 2.70255748e-02f, -1.26618904e-03f, -1.44114774e-02f, 1.01479674e-02f, -9.45268199e-03f, 1.00190043e-02f, -7.99498782e-02f,
  1.08648621e-01f, 2.08421648e-02f, 7.21838251e-02f, 7.72734731e-02f, 4.67139669e-02f, -1.24173276e-02f, 5.86740263e-02f, 1.32451607e-02f, -3.11854333e-02f, 5.88219464e-02f,
  -1.19809404e-01f, 4.22327816e-02f, -5.76394983e-02f, -1.91518143e-01f, -9.69699249e-02f, -3.34881395e-02f, 5.31252585e-02f, -2.36063357e-02f, -8.78637359e-02f, 6.71669170e-02f,
  1.43469982e-02f, -1.33783728e-01f, -1.14708669e-01f, -7.93019235e-02f, 9.03280601e-02f, 9.68217999e-02f, 5.17691225e-02f, -1.10574404e-03f, 1.30634634e-02f, 5.96550107e-03f,
  4.73904274e-02f, -1.59212016e-02f, -1.26965567e-01f, -1.37420371e-01f, -3.80339399e-02f, -7.86970835e-04f, -3.83578986e-02f, -1.54156625e-01f, -1.70719232e-02f, -8.43896121e-02f,
  4.89781909e-02f, -1.75044879e-01f, 8.23133141e-02f, -4.21979055e-02f, -4.55001183e-03f, -2.77508702e-02f, -1.98517577e-03f, -4.03543077e-02f, 1.46763008e-02f, -1.75553672e-02f,
  -1.07937790e-01f, -1.05870157e-01f, -6.01444840e-02f, -1.24980025e-01f, 3.68736289e-03f, -4.06655371e-02f, -1.10221259e-01f, -9.04430375e-02f, -1.25425542e-03f, -1.00475356e-01f,
  8.52454826e-02f, 2.19591092e-02f, 3.97996418e-02f, 9.18540806e-02f, 2.98853144e-02f, -1.04308397e-01f, -2.37632939e-03f, -9.23862830e-02f, -4.48235683e-02f, -4.56101522e-02f,
  3.45342308e-02f, 1.86508670e-02f, -2.92909835e-02f, -6.45338371e-02f, -3.25280242e-02f, 6.39836639e-02f, -9.63007845e-03f, 7.03343973e-02f, 8.02178979e-02f, -7.61043280e-02f,
  -2.92732976e-02f, -3.57182510e-02f, -3.19621637e-02f, 5.33506088e-02f, 7.07726181e-02f, -5.41575439e-02f, 8.18160027e-02f, 4.34565060e-02f, 2.20017470e-02f, 2.64531989e-02f,
  -4.38297242e-02f, -5.67726158e-02f, 8.71220082e-02f, 4.81686778e-02f, 3.51837426e-02f, 4.37115580e-02f, 4.63845171e-02f, -3.79468128e-02f, -1.80366170e-02f, 7.81777427e-02f,
  7.62921572e-02f, 6.51476830e-02f, 5.48345782e-02f, 8.06467682e-02f, 4.80085379e-03f, -1.38786971e-03f, -1.50617333e-02f, 4.19603959e-02f, -6.36661202e-02f, 5.51042147e-02f,
  -1.50632001e-02f, -1.83852986e-02f, 2.83191819e-02f, 5.48536181e-02f, -5.01487553e-02f, 4.44802791e-02f, 9.34820399e-02f, -3.21516357e-02f, -1.36968512e-02f, -3.02900374e-02f,
  6.31689057e-02f, 7.19490200e-02f, 1.90376341e-01f, 1.15514353e-01f, 3.30411717e-02f, -2.73821391e-02f, 5.11495359e-02f, 5.99378459e-02f, 7.21870959e-02f, 2.14381680e-01f,
  -2.55965441e-01f, -1.02920100e-01f, -1.62960663e-01f, -1.02343388e-01f, 6.31316379e-02f, 1.50277808e-01f, 1.13476194e-01f, 1.18238747e-01f, 3.92833492e-03f, -7.33303949e-02f,
  -5.12565486e-02f, 1.19195897e-02f, -1.20522454e-01f, -1.34169683e-01f, -1.30469173e-01f, -7.78509080e-02f, -2.24334523e-01f, -2.27210477e-01f, -1.63466617e-01f, -8.33525043e-03f,
  5.65280207e-02f, -1.91911459e-01f, -1.77997187e-01f, -7.91513994e-02f, -1.87626868e-01f, -1.80601165e-01f, -1.39238939e-01f, -1.60127789e-01f, -1.40682191e-01f, -2.96504676e-01f,
  -1.34661838e-01f, 2.58291196e-02f, 9.39590670e-03f, -1.09663740e-01f, -6.98827282e-02f, -3.92310731e-02f, 5.77095598e-02f, -2.53997743e-02f, -1.49631184e-02f, 1.64655559e-02f,
  4.64482754e-02f, -3.92645597e-02f, -8.33925754e-02f, 4.62224111e-02f, 4.31253053e-02f, -1.05950590e-02f, -6.62394613e-02f, -1.36372894e-01f, -3.51198739e-03f, 1.73598155e-01f,
  1.25792012e-01f, -6.26737848e-02f, -7.74429664e-02f, -5.84152117e-02f, 1.15922503e-01f, -1.27790183e-01f, -3.69525515e-02f, -3.71164829e-02f, -9.16180462e-02f, -4.58067283e-02f,
  -4.35094871e-02f, 6.74259961e-02f, 9.43379179e-02f, -7.20885256e-03f, 1.20932842e-02f, 1.52911488e-02f, -8.29367638e-02f, 1.00495592e-02f, 5.13338670e-02f, -8.25087056e-02f,
  -8.11931342e-02f, 6.07974222e-03f, 3.00683198e-03f, 1.76740903e-02f, -1.31779090e-01f, -3.49251591e-02f, 1.41105941e-02f, 8.77474714e-03f, -1.32612079e-01f, -4.60918471e-02f,
  9.83526581e-04f, 5.42194694e-02f, -2.77607720e-02f, -2.01437771e-02f, -9.49513465e-02f, -6.25431389e-02f, 9.73857790e-02f, 3.93751599e-02f, 6.88719600e-02f, -2.17381194e-02f,
  -1.48313433e-01f, 1.04574878e-02f, 3.42680626e-02f, 5.69251273e-03f, -5.97780906e-02f, 2.65331678e-02f, -7.89035335e-02f, -1.57060176e-02f, -2.31554620e-02f, -3.40582877e-02f,
  7.52237961e-02f, 7.44464770e-02f, -1.04720891e-01f, 3.89312059e-02f, -2.58073006e-02f, -6.90055117e-02f, -8.90955776e-02f, -1.46761462e-01f, 9.80203822e-02f, 9.32666659e-02f,
  -8.37097615e-02f, -8.81117582e-02f, -7.57803172e-02f, -6.04975000e-02f, -8.00557733e-02f, -5.88428751e-02f, -1.65708512e-01f, -9.23719630e-02f, -1.27558365e-01f, -2.11770162e-01f,
  7.90666342e-02f, 3.67212176e-01f, 2.02779680e-01f, -7.41674900e-02f, 2.19565079e-01f, 1.77888200e-01f, 1.45251900e-01f, -5.07213660e-02f, -1.67463332e-01f, 9.54888016e-02f,
  2.86290497e-01f, -1.36565939e-01f, -4.87564616e-02f, -2.10321710e-01f, -1.54844567e-01f, -4.99711521e-02f, -1.04214385e-01f, -1.78434923e-01f, -2.19215497e-01f, -1.42136306e-01f,
  -1.32160693e-01f, -1.48614511e-01f, -1.83367878e-01f, -1.29454777e-01f, -2.86471210e-02f, -1.34522125e-01f, 4.19755355e-02f, 2.25351918e-02f, 1.77780256e-01f, -4.18281257e-02f,
  1.39466107e-01f, 4.07021016e-01f, -2.08684385e-01f, -1.13864116e-01f, 2.03699425e-01f, -4.85790595e-02f, 8.30685347e-02f, -1.22979796e-02f, 1.37134790e-02f, -9.97880176e-02f,
  3.14512849e-03f, 1.69713106e-02f, 4.59175296e-02f, -7.91482031e-02f, -7.58679286e-02f, -4.86326553e-02f, -1.11111209e-01f, -8.54839310e-02f, 1.49258636e-02f, 7.96701610e-02f,
  -3.72607671e-02f, 1.59951016e-01f, 1.25916481e-01f, 8.68401006e-02f, 7.06526041e-02f, -3.06107458e-02f, 3.27207893e-02f, -2.45946292e-02f, -2.50905342e-02f, -1.12738311e-01f,
  -5.28660901e-02f, 1.29598677e-02f, 2.64170282e-02f, -8.11707303e-02f, -9.37651023e-02f, 8.32207203e-02f, -2.70126406e-02f, 1.04547562e-02f, 4.69976338e-03f, -7.47726038e-02f,
  1.62877385e-02f, -9.12736449e-03f, -1.14918500e-02f, 2.30399761e-02f, -5.06756045e-02f, 5.28990999e-02f, -1.47791412e-02f, -2.49342285e-02f, 5.72728813e-02f, -5.97324409e-03f,
  -7.88815040e-03f, -2.07601953e-02f, 9.34747830e-02f, -9.64210480e-02f, 1.02627143e-01f, 2.17528343e-02f, -4.87187691e-02f, 4.60970625e-02f, -4.83443849e-02f, 1.02687635e-01f,
  -3.35249931e-01f, 1.80396214e-01f, -1.71777263e-01f, -2.00197905e-01f, 2.78116539e-02f, 2.73701083e-02f, 7.95680285e-02f, -2.99636889e-02f, 8.91603380e-02f, -3.79149318e-02f,
  1.18469201e-01f, 4.47969846e-02f, 4.52430956e-02f, -1.24536902e-01f, -6.38702661e-02f, 2.97518000e-02f, -7.63015775e-03f, -1.72206596e-01f, -8.39905217e-02f, 4.43026330e-03f,
  -1.40432073e-02f, -1.73315391e-01f, -1.22518189e-01f, -1.05348103e-01f, -3.95213701e-02f, -9.82746929e-02f, -6.87274989e-03f, -4.64354604e-02f, -1.97043702e-01f, -2.93968827e-01f,
  -3.55979115e-01f, 7.49163330e-02f, 1.49287999e-01f, 3.80121986e-03f, 2.59363689e-02f, 1.17973778e-02f, 5.03892079e-02f, 2.52947882e-02f, -8.20477009e-02f, 6.97195157e-02f,
  2.10023504e-02f, 5.54524036e-03f, -5.35272509e-02f, 5.83257452e-02f, -3.89578044e-02f, -1.65667795e-02f, 5.07917330e-02f, 3.41515765e-02f, -4.38260467e-04f, -1.38835311e-01f,
  -5.85251004e-02f, -3.20271738e-02f, -1.67038888e-01f, -2.15723719e-02f, -9.82334986e-02f, 2.21102946e-02f, 2.37983130e-02f, -3.23710330e-02f, 1.04455240e-01f, -6.22675866e-02f,
  6.08997531e-02f, -5.34651838e-02f, -8.04234445e-02f, -9.34234858e-02f, 1.25178203e-01f, -7.23978654e-02f, -9.92200896e-02f, -8.75574909e-03f, 6.08687289e-02f, 4.87704352e-02f,
  6.15247414e-02f, 7.36447657e-03f, 4.17141151e-03f, -4.24953364e-02f, -1.12104081e-01f, 1.36401346e-02f, -5.54028414e-02f, -6.32692501e-02f, 6.05846420e-02f, -9.94844511e-02f,
  1.22680157e-01f, -4.25325409e-02f, -1.05828032e-01f, -3.25575620e-02f, 6.47081658e-02f, 3.98304388e-02f, -4.02404964e-02f, -3.07246726e-02f, -1.14169523e-01f, -1.29202560e-01f,
  -1.11370347e-03f, -6.94975331e-02f, 7.70156318e-03f, -9.50190052e-02f, -2.92638373e-02f, -2.12503113e-02f, 8.80719721e-02f, 2.18382329e-02f, -4.66320338e-03f, -4.47921008e-02f,
  6.45097941e-02f, -5.45852855e-02f, 5.68643808e-02f, 4.10608016e-02f, 6.41899109e-02f, 7.91959241e-02f, -1.06288455e-02f, -6.96271732e-02f, -1.31048430e-02f, -6.03337847e-02f,
  1.15922373e-02f, -2.62676496e-02f, 1.27705941e-02f, -7.95322135e-02f, 3.35512757e-02f, -2.71466351e-03f, -1.32800005e-02f, -6.48712143e-02f, 1.70051735e-02f, 6.36393204e-02f,
  -1.14205793e-01f, 1.70680761e-01f, -6.07901588e-02f, -1.27253801e-01f, -2.54941676e-02f, -5.78537658e-02f, 7.28954077e-02f, 9.44536626e-02f, -4.50614281e-02f, -2.13766936e-02f,
  -3.03984620e-02f, 1.06787367e-03f, 2.14335546e-02f, -3.31782028e-02f, -1.28665745e-01f, -1.31998599e-01f, -3.90305929e-02f, -3.72167714e-02f, 2.03927550e-02f, 2.02106610e-02f,
  -8.06927234e-02f, -1.35802433e-01f, -1.23094752e-01f, 1.89420208e-02f, 1.61634386e-02f, -1.53962672e-01f, -1.14869349e-01f, 2.96893879e-03f, -5.43092936e-02f, -2.04219118e-01f,
  6.41247779e-02f, -5.55187128e-02f, -7.26900771e-02f, 2.85007190e-02f, -1.43663332e-01f, 1.10374391e-03f, -4.85373102e-02f, -7.53563195e-02f, 4.45525870e-02f, -7.55446032e-02f,
  7.54082948e-03f, 4.43337038e-02f, -6.33877516e-02f, -1.24132680e-02f, -4.92203310e-02f, -8.66489038e-02f, -1.68943167e-01f, 2.91575417e-02f, 3.07673942e-02f, 2.06579119e-02f,
  -7.59771466e-02f, -1.23930678e-01f, -1.28521055e-01f, -1.29323984e-02f, 6.10528747e-04f, -1.11603558e-01f, 1.72652937e-02f, -9.59983841e-02f, -1.25445396e-01f, -1.32466286e-01f,
  -8.10846016e-02f, 2.52883099e-02f, 5.00145974e-03f, -4.21075895e-02f, 8.45896918e-03f, -4.96768318e-02f, -1.02856662e-02f, -2.93509346e-02f, -8.21249094e-03f, 6.37287199e-02f,
  4.36123461e-02f, -1.98378377e-02f, 5.08708060e-02f, -2.39641359e-03f, 2.32083406e-02f, 4.57549952e-02f, 7.16546774e-02f, -1.00018099e-01f, 6.06720662e-03f, -8.76026005e-02f,
  -1.23175874e-03f, 3.79699133e-02f, -2.87921559e-02f, 8.63422006e-02f, 3.88193643e-03f, -2.92530153e-02f, -1.11912098e-02f, -5.75207621e-02f, -9.58686844e-02f, -8.30263048e-02f,
  2.25000381e-02f, 7.26004168e-02f, -5.95933199e-02f, 2.30351929e-02f, -5.98886050e-02f, -6.63208589e-02f, -5.47439009e-02f, -3.18901911e-02f, 3.34012634e-06f, -3.09996568e-02f,
  -5.89836426e-02f, 9.16432887e-02f, -9.27936379e-03f, 1.02545731e-02f, -6.50101826e-02f, -6.95999563e-02f, 1.83528531e-02f, -6.66557252e-02f, -5.73238395e-02f, 5.36013506e-02f,
  -7.12794578e-03f, 9.85551812e-03f, 3.18854302e-02f, -1.16515486e-02f, 1.62175074e-02f, -6.29079565e-02f, -8.19899216e-02f, 2.40492951e-02f, 2.12750654e-03f, -3.33536416e-02f,
  -4.95750597e-03f, 1.14541404e-01f, -3.66158485e-02f, -2.35558092e-03f, -3.46400030e-02f, 8.09367560e-03f, -6.74157217e-02f, -3.30300182e-02f, 8.35400894e-02f, -1.13336453e-02f,
  -2.43436508e-02f, 2.43246537e-02f, -7.26445615e-02f, -1.79310478e-02f, 3.02850343e-02f, 1.68359596e-02f, -4.62158173e-02f, -3.59137245e-02f, -7.21267909e-02f, 2.39536185e-02f,
  -1.04717342e-02f, -8.06277916e-02f, 3.08031458e-02f, -6.67441860e-02f, -3.96045111e-02f, 7.31670707e-02f, 1.22395565e-03f, 2.57387422e-02f, -7.64847472e-02f, -5.68964407e-02f,
  -1.06268086e-01f, 3.08287907e-02f, 1.95487514e-02f, -1.16056986e-01f, -3.15403156e-02f, -3.64372879e-02f, 6.12752847e-02f, -1.62902828e-02f, 3.88069935e-02f, 4.94066514e-02f,
  6.75758198e-02f, -5.99090494e-02f, 9.75000206e-04f, 5.01118749e-02f, -6.50422871e-02f, -7.59857660e-03f, -2.50202566e-02f, -6.50071874e-02f, -9.77793336e-02f, 2.05647275e-02f,
  -2.22236905e-02f, -2.85574477e-02f, 4.66967467e-03f, 2.65194234e-02f, -5.98445572e-02f, 7.64145553e-02f, -9.07589216e-03f, -6.93709999e-02f, -1.33221429e-02f, -1.31743997e-01f,
  7.44432677e-03f, -1.23170190e-01f, -1.70896742e-02f, -1.74381658e-02f, 4.83086482e-02f, -2.59792972e-02f, -6.35352954e-02f, -2.44086068e-02f, -5.18753976e-02f, -1.82340275e-02f,
  -6.67375922e-02f, -5.71820177e-02f, -5.45877814e-02f, 7.33626634e-02f, 6.70109242e-02f, 1.58593282e-02f, 5.42538650e-02f, -8.88307318e-02f, 6.98393434e-02f, 6.31676763e-02f,
  -7.45814517e-02f, -6.18052669e-02f, -1.29100243e-02f, 7.59212449e-02f, -3.23780510e-03f, -8.81047919e-02f, 3.70980427e-02f, 3.38200554e-02f, -8.20569322e-02f, 4.81971167e-02f,
  4.50091437e-02f, -8.31565529e-04f, 2.70362701e-02f, 3.42230429e-03f, 5.23825455e-03f, -8.27395022e-02f, 6.81192204e-02f, -5.11121601e-02f, -8.12998712e-02f, 5.70197105e-02f,
  -1.65970949e-03f, -5.16345464e-02f, -4.17559408e-02f, -8.45483877e-03f, 8.82557854e-02f, 5.54007851e-02f, -7.97402486e-02f, -3.97706255e-02f, 5.17508499e-02f, -6.27535135e-02f,
  6.22241795e-02f, 1.16016828e-02f, -4.93093096e-02f, 3.26192342e-02f, 6.09493256e-02f, 2.60474347e-02f, -2.44659614e-02f, -5.73206283e-02f, 5.20105399e-02f, -9.49436054e-02f,
  1.13688029e-01f, -3.41507867e-02f, -9.91760194e-03f, -5.15096262e-02f, 8.06807801e-02f, 9.86856874e-03f, -4.28226553e-02f, 2.50667166e-02f, -2.77480911e-02f, 1.81554295e-02f,
  -6.56955643e-04f, -6.70077652e-02f, -5.92475645e-02f, 1.66967623e-02f, 1.25498902e-02f, 1.22653518e-03f, 5.03011141e-03f, 2.86070444e-03f, -3.95747758e-02f, -9.95695591e-03f,
  2.86999661e-02f, -7.03382492e-02f, -8.94722342e-03f, 3.86108048e-02f, -4.56169769e-02f, -9.15755481e-02f, 1.24331832e-01f, 1.06331654e-01f, 6.57697842e-02f, -3.20509411e-02f,
  -3.91221672e-01f, 1.80365145e-01f, 2.20699608e-02f, -9.76608470e-02f, 4.40931320e-02f, 2.57504974e-02f, 2.04886556e-01f, -1.65845752e-01f, -1.58454448e-01f, 1.06213205e-01f,
  1.30786464e-01f, -5.83257377e-02f, -4.54773195e-02f, -5.60221188e-02f, -7.70630911e-02f, 2.12502688e-01f, 9.67822894e-02f, -8.82020369e-02f, -1.87581658e-01f, -1.12791866e-01f,
  -3.05391625e-02f, -6.09748363e-02f, -2.99448848e-01f, -1.38200954e-01f, -9.81468614e-03f, -1.11180335e-01f, -2.39225365e-02f, -5.23148896e-03f, 2.24702001e-01f, 1.42522067e-01f,
  1.29784327e-02f, -4.19058912e-02f, -1.00628123e-01f, -6.02614097e-02f, -3.92280668e-02f, -9.05795768e-02f, 1.91354435e-02f, -3.19889374e-02f, -3.19856741e-02f, 5.84734231e-02f,
  6.95328265e-02f, 1.93726532e-02f, -7.15345070e-02f, 1.05676297e-02f, -2.13080482e-03f, -1.15623428e-02f, -4.91237938e-02f, -1.56430617e-01f, -1.89487599e-02f, 2.56882384e-02f,
  2.36223921e-01f, 2.14489594e-01f, -8.20624977e-02f, -5.80123477e-02f, -3.92134488e-02f, -6.48902133e-02f, 7.41909146e-02f, -5.45125790e-02f, -1.14723437e-01f, -6.06979206e-02f,
  5.44956215e-02f, 1.44512102e-01f, -3.48030739e-02f, 7.09766671e-02f, 4.02313732e-02f, -2.32620351e-02f, -4.86783423e-02f, 4.44423594e-02f, -8.47499818e-02f, -3.59463915e-02f,
  7.18027446e-03f, 7.39123672e-02f, -3.54909338e-02f, -9.86678973e-02f, 3.85921374e-02f, 1.33239618e-02f, 3.86376344e-02f, 1.31810661e-02f, -3.47553939e-02f, -5.79364263e-02f,
  1.25088319e-02f, 5.48387356e-02f, -9.76844653e-02f, 7.15108588e-02f, 6.63972180e-03f, -6.86096549e-02f, -5.02242595e-02f, -6.98413178e-02f, -7.88050964e-02f, 6.84415400e-02f,
  -3.71914148e-01f, 1.60727799e-01f, -5.07617518e-02f, -1.55489966e-01f, -1.94363594e-02f, -9.01537314e-02f, -1.31348968e-02f, 2.36099046e-02f, -1.68874208e-02f, 5.55943586e-02f,
  -1.87533535e-02f, -5.58757968e-02f, -1.97064225e-02f, -2.45554280e-03f, 5.84912440e-03f, -6.25376254e-02f, 7.45340809e-02f, -3.41605321e-02f, -3.60678360e-02f, 5.01254797e-02f,
  7.59709335e-04f, 2.33317651e-02f, -9.58865806e-02f, -8.55612308e-02f, -4.90689687e-02f, -5.67985959e-02f, -9.68421102e-02f, -2.02457413e-01f, -1.28477216e-01f, -2.34401509e-01f,
  8.22837502e-02f, -1.53649777e-01f, -5.56900464e-02f, -6.40331060e-02f, 9.51091424e-02f, -8.30482617e-02f, -1.72207490e-01f, -7.49874488e-02f, 7.60279745e-02f, 1.05368644e-01f,
  2.94458598e-01f, 3.97382855e-01f, 3.28557819e-01f, 2.71169275e-01f, 5.93466684e-02f, 3.99431624e-02f, 7.50811631e-03f, 7.19938502e-02f, 1.30627334e-01f, 7.86937177e-02f,
  8.11343119e-02f, -3.18927094e-02f, 1.39290113e-02f, 3.33019048e-02f, -1.82035174e-02f, 1.39472485e-01f, -6.16246350e-02f, -5.06274626e-02f, 6.37463201e-03f, -1.19403720e-01f,
  3.88077885e-01f, -1.24506861e-01f, 1.25135466e-01f, 9.17673931e-02f, -5.90023883e-02f, -1.89417135e-02f, 8.06880668e-02f, -1.53344423e-01f, -1.06609985e-01f, 2.46221721e-02f,
  -2.79888092e-03f, -4.85811979e-02f, 9.40964185e-03f, 2.12569013e-02f, -1.62674394e-02f, -4.70583439e-02f, -5.22152558e-02f, -6.52592555e-02f, -2.78921947e-02f, 2.05601510e-02f,
  -7.40987211e-02f, 3.00904159e-02f, -5.83772808e-02f, 5.96708730e-02f, -6.56532124e-02f, 1.35646105e-01f, 5.90098388e-02f, -3.78905376e-03f, -1.11228511e-01f, -7.15018958e-02f,
  6.90099448e-02f, 3.55188400e-02f, 3.90842743e-02f, 4.08921354e-02f, 1.19704247e-01f, 5.97586073e-02f, -5.27548045e-03f, 5.47070689e-02f, 1.46264071e-02f, -6.00226372e-02f,
  1.28514674e-02f, 4.01678029e-03f, 5.58169819e-02f, 3.25790420e-02f, 6.81484044e-02f, -7.45722950e-02f, 1.33947898e-02f, -1.69988759e-02f, 4.23877947e-02f, 3.97670157e-02f,
  -4.62674461e-02f, 3.58140953e-02f, 4.10661567e-03f, 4.49165292e-02f, 3.64536718e-02f, -2.84596905e-02f, 2.52286159e-02f, -4.36270647e-02f, -6.46617562e-02f, -1.48258537e-01f,
  -2.20269188e-02f, 9.09956992e-02f, 1.70691505e-01f, 9.47496518e-02f, -1.42020181e-01f, -1.40995994e-01f, 3.29296589e-02f, -1.16339795e-01f, -1.10635795e-01f, -4.59885262e-02f,
  -9.12775546e-02f, 7.21880570e-02f, 1.53784524e-03f, -6.19577505e-02f, 3.16929445e-02f, 6.90357876e-04f, -1.07927874e-01f, 9.75515842e-02f, 3.36206071e-02f, -9.54808071e-02f,
  -9.38473791e-02f, -3.14038843e-02f, 6.17643595e-02f, 9.30581242e-02f, 7.13060424e-02f, 1.87460199e-01f, 5.35171805e-03f, 4.84710280e-03f, 1.27714276e-01f, -1.13858776e-02f,
  -6.21772371e-02f, 1.74625501e-01f, 6.34826869e-02f, -4.02881987e-02f, 8.92645568e-02f, 2.33125337e-03f, -8.57870132e-02f, -1.80011451e-01f, -5.91245778e-02f, 8.32962021e-02f,
  1.59445539e-01f, 9.78566334e-02f, -7.54296333e-02f, -2.64980141e-02f, -2.15347514e-01f, -1.60851732e-01f, -1.44487366e-01f, -2.01000273e-01f, -2.26732865e-01f, -6.28317297e-02f,
  7.54048675e-02f, 7.37776384e-02f, -9.98417363e-02f, -1.02256097e-01f, 1.05910897e-01f, -2.15574075e-02f, 1.05244048e-01f, 1.46925956e-01f, 4.03867848e-02f, 2.88976729e-01f,
  2.07745895e-01f, 2.29722261e-01f, -2.58441065e-02f, 1.26011759e-01f, 2.04418302e-01f, -6.04955293e-02f, 1.33046851e-04f, -8.67276713e-02f, -1.97904301e-03f, -3.07014827e-02f,
  1.02399707e-01f, 4.08982784e-02f, 8.27725902e-02f, 2.28722822e-02f, -8.15412924e-02f, -1.05865128e-01f, -1.02278866e-01f, -1.38366401e-01f, -1.53441867e-02f, 4.90601435e-02f,
  1.74990863e-01f, 2.11307377e-01f, 7.79448301e-02f, -1.02893263e-01f, -8.37898701e-02f, 3.84580791e-02f, 4.98260297e-02f, -3.67709510e-02f, -1.03375494e-01f, -6.04878226e-03f,
  1.87766775e-02f, 7.13252574e-02f, -4.41260310e-03f, 1.18708275e-02f, -5.02851605e-02f, 7.87276179e-02f, 8.75367895e-02f, -3.14361863e-02f, -3.26677226e-02f, -2.91303322e-02f,
  2.19519995e-03f, -2.04312187e-02f, 2.82048732e-02f, -2.47027706e-02f, 1.90392341e-02f, 1.70047022e-02f, 1.81842707e-02f, -3.53827663e-02f, -6.09258823e-02f, 1.39684081e-02f,
  -7.64796585e-02f, -3.98754627e-02f, 5.12342043e-02f, -6.83017597e-02f, 1.04177296e-02f, 2.97094714e-02f, 1.91979390e-02f, 3.51614803e-02f, 2.52723265e-02f, 9.79146436e-02f,
  -2.25202829e-01f, -3.34591419e-02f, 6.82547539e-02f, -1.05428003e-01f, 6.28474131e-02f, 3.30962501e-02f, 1.03227183e-01f, 6.59533590e-02f, 3.38838883e-02f, -6.43832535e-02f,
  -3.63708623e-02f, -5.90888076e-02f, -3.93358804e-02f, 1.53876683e-02f, -8.77268091e-02f, -4.40409854e-02f, -2.34636050e-02f, -1.13394521e-02f, -9.08787549e-02f, 3.96824777e-02f,
  -2.62097511e-02f, -2.03835040e-01f, -1.74942434e-01f, -1.33568868e-01f, -4.15669940e-03f, -1.02952141e-02f, -8.81085172e-02f, -1.97607558e-02f, -1.68105111e-01f, -2.61947274e-01f,
  -1.62080768e-02f, -7.46707171e-02f, 4.42389864e-03f, -8.71430337e-02f, -1.41831085e-01f, -1.14918336e-01f, -2.84199327e-01f, -2.31767923e-01f, -1.00802392e-01f, -1.39841205e-02f,
  -5.86020797e-02f, 1.26714846e-02f, 6.77484348e-02f, 1.61612723e-02f, -6.60104156e-02f, -1.65552109e-01f, -1.09483600e-01f, -7.83741400e-02f, -1.19586654e-01f, -1.45348579e-01f,
  -6.57822415e-02f, -3.86312865e-02f, 2.19757445e-02f, -1.05953634e-01f, 1.56421680e-02f, -7.76247010e-02f, 3.95137742e-02f, 4.69414704e-02f, -8.94511938e-02f, 4.43757214e-02f,
  8.62227231e-02f, -8.30304250e-02f, 3.37865502e-02f, 2.89066397e-02f, 5.46406917e-02f, 6.40497282e-02f, 1.50021054e-02f, 7.55378455e-02f, -3.06583438e-02f, -4.30469885e-02f,
  8.41680095e-02f, -1.81615856e-02f, 6.28474504e-02f, -4.10620123e-02f, 6.99429587e-03f, -1.80429574e-02f, 3.90787683e-02f, -4.54968438e-02f, 8.61329958e-02f, 4.92381305e-02f,
  -4.89326380e-02f, -1.29486412e-01f, 3.28905098e-02f, -6.80418685e-02f, -3.56211364e-02f, -3.94917801e-02f, 6.78231567e-02f, -1.10199369e-01f, 4.99961339e-03f, -4.52482291e-02f,
  6.12395145e-02f, 6.93349838e-02f, 4.49304394e-02f, 2.95782052e-02f, 3.07679269e-02f, -3.77140157e-02f, 2.56706960e-02f, -6.89188531e-03f, 5.80379628e-02f, 1.48397973e-02f,
  -6.94649741e-02f, 7.09715784e-02f, -2.23495499e-05f, 2.40229256e-02f, -4.26014476e-02f, 4.62211855e-02f, -6.66071698e-02f, 1.00393124e-01f, 3.32922908e-03f, -7.15382397e-02f,
  1.21942358e-02f, -5.66284172e-02f, 5.21716243e-03f, -6.89036995e-02f, -4.97433171e-02f, 5.40558668e-03f, 3.04801622e-03f, -6.78775609e-02f, 8.85892436e-02f, -2.06137076e-02f,
  9.39662308e-02f, -5.77682778e-02f, 8.85010138e-02f, -1.45136472e-02f, -3.99884321e-02f, 1.05106480e-01f, 6.72914684e-02f, 4.96366620e-02f, 1.31077453e-01f, -6.53226003e-02f,
  -7.66638964e-02f, 6.73958510e-02f, 1.08705118e-01f, -2.85205431e-02f, 2.59936042e-02f, 4.34857346e-02f, 1.09389059e-01f, 8.63235965e-02f, 1.99152697e-02f, -5.41963317e-02f,
  1.33517701e-02f, 7.83933327e-03f, -4.83087227e-02f, 1.98066561e-03f, -6.98967651e-02f, 1.97355952e-02f, -3.63100320e-02f, -5.89285651e-03f, 2.03211866e-02f, -5.16465567e-02f,
  -1.31023511e-01f, 1.23291366e-01f, 1.63211003e-01f, 1.26618505e-01f, 2.68485248e-01f, 3.83457005e-01f, 4.79141861e-01f, 3.09316248e-01f, 1.45465076e-01f, 2.28527281e-02f,
  5.59062846e-02f, -2.55176052e-02f, -5.44022508e-02f, -4.07150481e-03f, 7.62055442e-02f, 8.53508785e-02f, 8.57388303e-02f, -5.14768772e-02f, -1.20274602e-02f, -9.98518430e-04f,
  1.44952253e-01f, -2.60076467e-02f, -1.49981812e-01f, 6.35306165e-02f, 9.32850763e-02f, -6.59892187e-02f, -3.67324613e-02f, 9.10847038e-02f, 1.26702353e-01f, 2.30743294e-03f,
  -2.48351276e-01f, 6.44121841e-02f, -2.60085501e-02f, -2.07012054e-02f, 6.90405024e-03f, -1.61270380e-01f, 6.55070990e-02f, -1.47830978e-01f, -1.56566147e-02f, -2.68068872e-02f,
  -5.13541698e-02f, -8.58962014e-02f, 9.62278247e-02f, -9.52835977e-02f, 3.58149335e-02f, -5.61508760e-02f, -1.89084671e-02f, 6.38593286e-02f, 4.93833013e-02f, 8.99381787e-02f,
  9.47631449e-02f, 6.20656589e-04f, 8.27967152e-02f, 9.15600806e-02f, 3.72706801e-02f, -5.54206669e-02f, 7.76867345e-02f, -1.50267435e-02f, 3.24129723e-02f, -3.55815031e-02f,
  2.01122873e-02f, 5.27529791e-02f, -6.85703829e-02f, 5.55252358e-02f, -4.83596772e-02f, -1.95339303e-02f, 2.29857974e-02f, 7.48309642e-02f, 2.95372512e-02f, 9.29121207e-03f,
  3.38571407e-02f, 3.39861736e-02f, 5.68483621e-02f, -8.16513896e-02f, -2.92876605e-02f, 1.14828534e-02f, -5.93031757e-04f, 3.15085277e-02f, 4.49925773e-02f, 3.25453794e-03f,
  -5.62540081e-04f, 8.19875821e-02f, -9.39262509e-02f, 6.09492064e-02f, 2.65496019e-02f, 3.02863773e-02f, -4.35889997e-02f, -6.05445020e-02f, 3.65221575e-02f, -9.80700105e-02f,
  -1.18284382e-01f, 1.50468543e-01f, -1.06886894e-01f, -9.07561779e-02f, -2.67744646e-03f, -5.06993085e-02f, -6.39767870e-02f, -3.80142629e-02f, -2.45224405e-02f, -3.32573839e-02f,
  4.21435796e-02f, 6.13367138e-03f, 8.21685567e-02f, 5.90921678e-02f, -1.32434636e-01f, 2.30342406e-03f, 2.13869885e-02f, -9.71432030e-03f, 4.12010439e-02f, -8.26101452e-02f,
  -1.12976804e-02f, 1.39546432e-02f, -3.25322710e-02f, 9.47430357e-02f, 1.93975624e-02f, -4.22649346e-02f, -5.44004068e-02f, -2.65499242e-02f, -1.43502438e-02f, -1.03666082e-01f,
  3.38761896e-01f, -5.08744223e-03f, 3.95028703e-02f, 1.23753190e-01f, 1.08856931e-02f, -3.27669121e-02f, 1.36321679e-01f, 1.00307502e-01f, 9.69160870e-02f, -6.60059880e-03f,
  -2.31472775e-02f, 2.37699579e-02f, 4.87124771e-02f, 9.29402560e-02f, 5.64593337e-02f, -1.19441533e-02f, 7.42022917e-02f, 1.25781402e-01f, 1.28716215e-01f, 1.19291551e-01f,
  3.80523428e-02f, -1.13770002e-02f, 7.03656748e-02f, 3.66970561e-02f, -1.09238885e-01f, -5.84266037e-02f, 5.87218292e-02f, -6.37947917e-02f, -1.06813028e-01f, 1.33465687e-02f,
  2.93600969e-02f, 1.19183563e-01f, -7.78742880e-02f, 1.60316098e-02f, 3.58576253e-02f, 6.11447031e-03f, -6.31450638e-02f, 3.09024379e-02f, -3.57060879e-02f, -1.00962415e-01f,
  -4.41571027e-02f, -7.80331250e-03f, -1.67659596e-02f, -5.60444370e-02f, -7.24240020e-02f, 2.96818037e-02f, 2.08177362e-02f, 1.72057245e-02f, 3.57877165e-02f, -3.64567414e-02f,
  -7.83878192e-02f, 7.04808235e-02f, 1.19346194e-01f, 5.87412082e-02f, -9.06593539e-03f, -2.64848326e-03f, 3.12918909e-02f, -3.63901742e-02f, 6.69181114e-03f, -6.16053268e-02f,
  7.38378912e-02f, -3.31319608e-02f, 3.02084833e-02f, 3.77942398e-02f, 1.56192500e-02f, -3.36219892e-02f, -6.13915883e-02f, -2.84168008e-03f, 5.80581278e-02f, -1.89636573e-02f,
  2.18531676e-02f, 1.12073541e-01f, 8.55057314e-02f, 2.47526579e-02f, -2.77936761e-03f, 6.70741946e-02f, -5.15408963e-02f, 1.56479515e-02f, 4.68487665e-02f, -4.90100719e-02f,
  1.03489585e-01f, 5.39716184e-02f, 3.71693186e-02f, 1.19795622e-02f, 5.82271516e-02f, -2.95999199e-02f, -8.34894553e-03f, 8.07371512e-02f, 1.63730495e-02f, 5.97911477e-02f,
  -3.47685479e-02f, 1.41867921e-01f, -5.48700523e-03f, -6.54002503e-02f, 2.01272615e-03f, -8.56125802e-02f, 4.30703908e-02f, 3.25487554e-02f, -1.27148051e-02f, 3.18139382e-02f,
  -6.67257309e-02f, -7.94970989e-02f, -5.47533035e-02f, -4.17919829e-02f, 8.68042782e-02f, -8.82299542e-02f, 6.97433650e-02f, -6.98259696e-02f, -8.84088352e-02f, -7.70322084e-02f,
  -8.74629095e-02f, -8.35849121e-02f, -4.58615385e-02f, 4.56280373e-02f, 4.33177948e-02f, -4.46989089e-02f, 4.21815403e-02f, -8.88771638e-02f, 2.86400206e-02f, 7.95159787e-02f,
  1.85644701e-01f, 4.46757637e-02f, 4.27493341e-02f, -9.09462105e-03f, -1.38847619e-01f, -1.05840877e-01f, -2.38302574e-01f, -1.50927231e-01f, -1.17785439e-01f, -1.98154915e-02f,
  1.54354312e-02f, 2.66585425e-02f, 1.15627758e-02f, -8.04611966e-02f, -5.05584665e-03f, 3.12461406e-02f, 6.78993911e-02f, 1.12227201e-01f, -1.37328645e-02f, -4.30594794e-02f,
  8.50733519e-02f, 1.27465148e-02f, -4.06628661e-02f, -1.01406975e-02f, 1.18569188e-01f, -5.40794991e-02f, 7.40934312e-02f, 8.73897597e-02f, 7.88790658e-02f, 2.21044883e-01f,
  5.22321351e-02f, 2.23721638e-01f, -1.44064039e-01f, 6.44238517e-02f, 1.25139225e-02f, 5.88203892e-02f, -3.83144841e-02f, -3.68659757e-02f, -7.08902553e-02f, -2.57932749e-02f,
  -5.05804345e-02f, 3.44950333e-02f, -3.65801901e-02f, -8.60064700e-02f, 5.91591410e-02f, 2.79271398e-02f, 7.75527284e-02f, 1.24712415e-01f, 1.03361346e-02f, 4.23147343e-02f,
  2.16004252e-02f, -2.60976050e-02f, -9.94101018e-02f, -1.33054420e-01f, 5.72282337e-02f, -1.59011334e-02f, -3.26718502e-02f, 7.89655373e-02f, -8.34105983e-02f, -2.63087712e-02f,
  -6.54994547e-02f, 2.65041571e-02f, 7.04173371e-03f, -1.99486589e-04f, -7.34041035e-02f, -8.13215151e-02f, 7.57151097e-02f, -8.55383724e-02f, -7.39312246e-02f, 3.02534550e-02f,
  -4.47010361e-02f, -2.43535321e-02f, -6.80001527e-02f, 2.90542115e-02f, -5.06187864e-02f, -2.63653565e-02f, 3.90737578e-02f, 4.80851755e-02f, -4.74970937e-02f, 2.08751708e-02f,
  -1.59902144e-02f, 7.54075795e-02f, -4.75136489e-02f, -9.25061852e-03f, 1.03729807e-01f, 5.59501052e-02f, 1.23586971e-02f, 2.05404982e-02f, -2.44606473e-02f, -6.32982254e-02f,
  -1.64362907e-01f, -2.31784075e-01f, 3.59468386e-02f, 8.81334841e-02f, -6.30425215e-02f, 5.04072905e-02f, 2.30222344e-02f, 5.31274863e-02f, 1.98891442e-02f, 3.96332555e-02f,
  4.32481468e-02f, -5.34968004e-02f, -5.54911792e-02f, -6.04480086e-03f, -7.18670413e-02f, -3.94065678e-02f, -9.84787121e-02f, -5.45974150e-02f, -1.28066033e-01f, -8.04426372e-02f,
  -2.06437670e-02f, -1.70503318e-01f, -9.44851935e-02f, -1.02961421e-01f, 8.20236374e-03f, -1.58890560e-01f, -1.40680179e-01f, -8.62327889e-02f, -2.21562639e-01f, -2.21959949e-01f,
  -2.62841545e-02f, -2.78939330e-03f, -1.14483155e-01f, 3.54389586e-02f, -8.47991705e-02f, 6.62834272e-02f, 9.57213119e-02f, 6.81586713e-02f, -3.64868715e-02f, -1.85075402e-02f,
  -1.12374932e-01f, -8.90550613e-02f, -7.25980243e-03f, -9.00178999e-02f, -1.93176884e-02f, -1.82409268e-02f, -4.92332131e-03f, -9.75369141e-02f, 2.96177585e-02f, 6.40617236e-02f,
  -1.86207760e-02f, -1.78773310e-02f, -4.23213094e-02f, 4.34803069e-02f, 2.75482889e-03f, -1.05685228e-02f, -8.46111551e-02f, 5.32647632e-02f, 2.23136302e-02f, 4.11937572e-03f,
  -2.33144108e-02f, 6.10361099e-02f, 4.52400651e-03f, 2.30867937e-02f, -2.37149484e-02f, -7.17576295e-02f, 5.43118119e-02f, -5.62471487e-02f, 4.98210117e-02f, 3.55020305e-03f,
  -7.19426051e-02f, 3.29730101e-02f, -4.39483002e-02f, -2.70068608e-02f, -2.99405423e-03f, 9.07533914e-02f, -3.98105867e-02f, 8.53191242e-02f, 5.06928526e-02f, 1.05826125e-01f,
  -6.44183382e-02f, 8.70018452e-03f, -8.70991778e-03f, 3.08556352e-02f, 9.40768346e-02f, -4.86857779e-02f, 9.54018012e-02f, 1.07453741e-01f, -6.49839863e-02f, 5.08339778e-02f,
  -5.59909120e-02f, -2.11244039e-02f, -8.76613520e-03f, -9.01811104e-03f, 8.49772692e-02f, 2.51783803e-02f, 6.99184537e-02f, 7.96322227e-02f, 7.13661462e-02f, -5.48492596e-02f,
  7.42660984e-02f, -9.65990350e-02f, -5.95065914e-02f, -4.90482561e-02f, -9.75518227e-02f, -6.95886612e-02f, 4.86230887e-02f, -6.32728711e-02f, 2.32403050e-03f, 4.67797257e-02f,
  -6.70311376e-02f, -5.01079075e-02f, -4.51822169e-02f, 6.12590574e-02f, -6.02799840e-02f, 3.58412303e-02f, 8.14775079e-02f, -3.99933197e-02f, 4.36928049e-02f, 7.83238485e-02f,
  -4.56159227e-02f, -1.77034289e-01f, -6.71507493e-02f, 4.07536030e-02f, 4.53717187e-02f, -7.87962675e-02f, 3.51523757e-02f, 5.66847846e-02f, 4.06491272e-02f, 8.72538462e-02f,
  1.01009928e-01f, 2.26268265e-02f, 4.55697067e-02f, -2.49146987e-02f, 5.05023487e-02f, -1.56331044e-02f, 1.00218721e-01f, -6.52149096e-02f, 5.26413284e-02f, -6.24726564e-02f,
  1.74097996e-03f, 1.20597966e-01f, 8.05869922e-02f, -2.73825787e-02f, -6.64107036e-03f, 3.45635340e-02f, -5.25976568e-02f, -2.63960473e-02f, -3.76346037e-02f, 7.09719583e-02f,
  -1.70468584e-01f, -6.75633922e-02f, -5.86626679e-02f, -8.08324143e-02f, -1.51094764e-01f, -3.46821658e-02f, 5.39131754e-04f, -1.11416474e-01f, -1.51101351e-01f, -6.36556223e-02f,
  3.11853662e-02f, 1.10252038e-01f, 3.14801582e-03f, 4.82134707e-02f, -2.74897758e-02f, -1.30097166e-01f, -1.58694133e-01f, -1.53656796e-01f, 5.66569902e-02f, -7.98706263e-02f,
  -3.73432264e-02f, -1.51020810e-01f, -1.36984497e-01f, -1.46154135e-01f, -8.99343044e-02f, -7.05046058e-02f, -1.55966863e-01f, -2.95756664e-02f, -9.61821526e-03f, -9.82080773e-02f,
  1.90715790e-01f, -2.82720644e-02f, 1.52308205e-02f, -1.07297003e-01f, -8.09971765e-02f, 6.56743869e-02f, 4.91899699e-02f, -6.38747513e-02f, 2.20153723e-02f, -8.85279477e-03f,
  -4.76335995e-02f, -7.02733472e-02f, 4.11943905e-02f, 2.76293252e-02f, -1.07146889e-01f, -9.26079825e-02f, -8.21294915e-03f, 1.23175988e-02f, -7.42710903e-02f, -4.82863821e-02f,
  -3.26473452e-02f, -7.23627657e-02f, 8.43266398e-02f, 1.03095584e-02f, -6.30889460e-02f, 3.52085494e-02f, -7.32642189e-02f, -8.24503750e-02f, 6.88307881e-02f, -2.31885705e-02f,
  -2.06600130e-02f, 1.75730921e-02f, 1.26984669e-02f, -1.32452827e-02f, -9.81904846e-03f, -4.53014746e-02f, -1.59055740e-02f, 7.52297565e-02f, 2.03649811e-02f, 1.32766869e-02f,
  -4.53508869e-02f, -9.15504545e-02f, -4.37989086e-02f, 3.76609117e-02f, -7.15092421e-02f, 5.50869899e-03f, -9.67202857e-02f, 2.94801779e-02f, -5.14471568e-02f, -7.66362390e-03f,
  4.55501676e-02f, 6.40270114e-02f, -9.24038365e-02f, -4.98066433e-02f, -1.87070407e-02f, -9.00600925e-02f, 4.12820764e-02f, -1.29262321e-02f, -4.90403455e-03f, -4.48405370e-03f,
  7.42910430e-02f, 4.42771316e-02f, 4.24096920e-03f, 7.11100101e-02f, -1.06048128e-02f, 4.80592903e-03f, 5.03553785e-02f, 2.31049750e-02f, 4.29862142e-02f, -4.55933996e-02f,
  2.18837950e-02f, -5.69543540e-02f, 3.19398567e-02f, -4.12222296e-02f, -6.17829598e-02f, -3.57627943e-02f, 3.83062512e-02f, 2.35460997e-02f, -5.16027473e-02f, -1.54105388e-03f,
  2.55828947e-02f, -5.01629636e-02f, 5.64964935e-02f, 2.62215827e-02f, 9.97944996e-02f, 8.44726339e-02f, 7.18879402e-02f, 1.21506251e-01f, 8.17536414e-02f, -8.19285773e-03f,
  5.31531721e-02f, -4.45911326e-02f, -4.88343611e-02f, 7.05910176e-02f, 1.31972209e-01f, -7.18750656e-02f, -1.03681199e-02f, -2.32991576e-02f, 7.30475783e-02f, 1.28426254e-01f,
  1.17434978e-01f, 6.77308887e-02f, 1.47040561e-01f, -1.67174917e-02f, -4.90831397e-02f, 1.13156065e-01f, 1.10534534e-01f, 6.49893656e-02f, -3.91405486e-02f, -8.29227492e-02f,
  -3.02438606e-02f, -5.05962782e-02f, -2.34927703e-02f, 1.02409348e-01f, 1.14761263e-01f, -9.57056135e-03f, 1.10199846e-01f, -1.03105726e-02f, -1.38827804e-02f, 1.12263024e-01f,
  2.78209448e-02f, -2.90948693e-02f, 2.33656052e-03f, 7.73198754e-02f, 5.54800080e-03f, -9.88677144e-02f, -6.98036700e-02f, 4.96331416e-02f, -4.03106026e-02f, 9.44286287e-02f,
  8.62174407e-02f, 1.45061500e-02f, 1.21209119e-02f, -8.47499073e-02f, -9.16891098e-02f, 3.11124772e-02f, -1.99088976e-02f, -2.19621751e-02f, 5.36053628e-03f, 3.66185047e-02f,
  -1.89890098e-02f, -8.45715553e-02f, -3.51773277e-02f, -2.54703443e-02f, -6.47489205e-02f, 6.93752170e-02f, -4.77407239e-02f, -8.79363567e-02f, -1.09867476e-01f, 4.80833352e-02f,
  9.66604874e-02f, 2.79073156e-02f, 6.04333915e-02f, 9.48836133e-02f, -6.41316175e-02f, 7.78725743e-02f, -4.18238388e-03f, 5.80347739e-02f, 7.51265660e-02f, 2.09557991e-02f,
  -7.53889978e-02f, -6.97518066e-02f, 3.81597430e-02f, 2.88987905e-03f, 3.58433761e-02f, -4.35951799e-02f, -6.36676475e-02f, -5.37208654e-02f, 6.01459667e-02f, 4.86215204e-02f,
  9.90623143e-03f, -6.67698234e-02f, 7.54809827e-02f, 3.94029506e-02f, 4.30002734e-02f, 2.86257640e-03f, 9.55745950e-03f, -6.50122687e-02f, -3.84192392e-02f, 8.30566976e-04f,
  2.41221711e-02f, -4.41284217e-02f, -6.04731636e-03f, 5.64243132e-03f, 1.63994431e-02f, -5.53133246e-03f, 1.06697127e-01f, 9.78607163e-02f, 1.09835662e-01f, -4.36225906e-02f,
  4.09644842e-02f, -2.06277184e-02f, 6.24095127e-02f, -4.31344360e-02f, 6.57535940e-02f, 7.32174814e-02f, 4.73738573e-02f, 3.36501263e-02f, 2.04353128e-02f, 8.59229192e-02f,
  6.67470992e-02f, 7.41536170e-02f, 1.47476019e-02f, -7.90207908e-02f, -1.86107270e-02f, 2.27373186e-02f, -8.81350115e-02f, 7.28614628e-02f, -8.00004303e-02f, -1.00191362e-01f,
  -1.29035339e-01f, 6.06054403e-02f, -4.59317118e-03f, -2.46050395e-02f, -4.02310528e-02f, 1.42567009e-01f, 1.29037321e-01f, -1.12506822e-02f, -2.80031580e-02f, -1.11677265e-02f,
  4.54326421e-02f, 7.40344748e-02f, -6.10705726e-02f, 8.05879831e-02f, -3.80117670e-02f, -6.60037771e-02f, -8.66681188e-02f, -1.47958482e-02f, -1.59297474e-02f, 1.26016364e-01f,
  1.01006508e-01f, -1.32024540e-02f, -1.46007305e-02f, -5.05470484e-02f, 6.82251006e-02f, 1.14333354e-01f, 7.86971152e-02f, -7.44009688e-02f, -4.46623378e-03f, -6.22934066e-02f,
  3.21694732e-01f, -3.59268300e-02f, -5.10287248e-02f, -7.44114965e-02f, -2.28780378e-02f, -5.73944189e-02f, 9.56873782e-03f, -9.03216079e-02f, -2.97815423e-04f, 5.31007834e-02f,
  7.46297538e-02f, 4.80496623e-02f, -6.66180849e-02f, 7.07555888e-03f, -2.87441090e-02f, -2.43771225e-02f, -8.56397152e-02f, -2.23116204e-02f, -7.70462351e-03f, 6.99415337e-03f,
  8.78907591e-02f, 6.48738369e-02f, 4.02436629e-02f, -7.20782205e-03f, -1.24799162e-01f, -9.77059603e-02f, 7.04286322e-02f, -2.53341552e-02f, -3.54868430e-03f, 2.52472367e-02f,
  1.91936977e-02f, 2.73817759e-02f, 2.84310877e-02f, -6.51940778e-02f, 6.84551001e-02f, -1.23949787e-02f, 2.38964278e-02f, -1.55073525e-02f, 7.74309114e-02f, -4.09316011e-02f,
  4.35330458e-02f, -2.03250293e-02f, 1.00344524e-01f, -8.50597993e-02f, -7.81567991e-02f, -7.79234543e-02f, -5.83488941e-02f, 6.45522820e-03f, -7.74056017e-02f, -2.70799249e-02f,
  7.15840980e-02f, -1.56127876e-02f, 5.19377105e-02f, -6.99214339e-02f, -3.92536260e-02f, -6.78090826e-02f, 2.73975115e-02f, 6.57600611e-02f, -8.10365975e-02f, 8.88379738e-02f,
  2.16713175e-01f, -2.03075796e-01f, -1.18514141e-02f, 2.57226266e-02f, -8.24925750e-02f, 1.42152573e-03f, -8.96357223e-02f, -9.66170281e-02f, 9.54804942e-02f, 1.00583784e-01f,
  -4.52545360e-02f, -9.80740562e-02f, -2.45359596e-02f, 8.44413489e-02f, 2.94603910e-02f, -5.68407923e-02f, -2.88454574e-02f, 4.25316021e-02f, -7.12189078e-02f, 8.11928064e-02f,
  5.24593443e-02f, 6.33918345e-02f, 1.24251515e-01f, 8.73960555e-02f, -9.31985304e-03f, 6.20794147e-02f, 1.92277923e-01f, 2.55471673e-02f, -1.44889662e-02f, 1.39442950e-01f,
  -2.11388573e-01f, -2.87236385e-02f, 6.02389546e-03f, -5.72484732e-02f, 2.30640322e-02f, -5.38407639e-02f, -4.20523509e-02f, -2.74885651e-02f, 6.52482733e-02f, -8.63151848e-02f,
  7.78803602e-02f, -9.30960253e-02f, 2.72218641e-02f, -8.92240703e-02f, 5.67018539e-02f, 6.05513416e-02f, 9.13733765e-02f, -1.90799031e-03f, -6.43121302e-02f, -6.02499619e-02f,
  5.03916740e-02f, 7.68858520e-03f, -1.56546876e-01f, 6.69932365e-02f, -5.32494448e-02f, 6.07491434e-02f, -1.01796225e-01f, -4.01917212e-02f, 5.08553488e-03f, -4.94530424e-02f,
  4.30310778e-02f, -1.07228868e-01f, 7.46204192e-03f, 8.84638503e-02f, -4.48037088e-02f, -8.26731324e-02f, 3.79226469e-02f, 8.21525007e-02f, -2.97150817e-02f, 6.95353374e-02f,
  7.91797489e-02f, -7.03234524e-02f, 1.25557175e-02f, 4.68590036e-02f, -1.14253893e-01f, -9.32606906e-02f, -9.66854915e-02f, -1.00457199e-01f, -5.13435341e-02f, -9.15790424e-02f,
  -1.84643622e-02f, 7.12287426e-02f, -7.10123330e-02f, 2.22982336e-02f, -6.54958263e-02f, -9.56293121e-02f, -7.53110573e-02f, 1.73782632e-02f, -2.34741978e-02f, 2.40858197e-02f,
  -1.25807514e-02f, -5.65025676e-03f, -1.11548146e-02f, -5.79162315e-02f, 1.16380882e-02f, 7.58263469e-02f, -5.89030460e-02f, 6.20183460e-02f, -2.13691685e-02f, -6.00553863e-02f,
  -5.05929142e-02f, -7.75089338e-02f, 6.46493658e-02f, -7.17008859e-02f, 4.83199991e-02f, 2.15848559e-03f, 1.45333605e-02f, -3.37598729e-04f, -2.95672696e-02f, -7.19863549e-02f,
  -7.68183768e-02f, -4.96133696e-03f, 1.89526398e-02f, -3.49563137e-02f, 5.41181974e-02f, -8.73088315e-02f, 6.32645711e-02f, -1.35269976e-04f, 2.69587431e-02f, 8.95007607e-03f,
  -1.70054838e-01f, -1.30534284e-02f, 3.78279611e-02f, 5.46457954e-02f, -3.42795402e-02f, -3.87422852e-02f, -4.29036580e-02f, 4.95823175e-02f, 6.72206506e-02f, -1.24310061e-01f,
  1.08455708e-02f, -9.05428231e-02f, -4.92827669e-02f, 5.54261059e-02f, -9.08025503e-02f, -1.67651027e-02f, 1.91850476e-02f, -5.82937971e-02f, -6.55195909e-03f, 7.27977157e-02f,
  -5.97224608e-02f, -1.45339921e-01f, -1.30501002e-01f, -2.36427635e-02f, 3.08533292e-02f, -1.39511675e-01f, -5.17365485e-02f, -1.44164845e-01f, -1.32642463e-01f, -1.71672627e-01f,
  6.57806098e-02f, -1.21653251e-01f, -3.17618959e-02f, -8.73917714e-04f, 6.44315258e-02f, -7.90813342e-02f, 3.10192592e-02f, 1.47293555e-02f, -1.03072509e-01f, 1.61319245e-02f,
  -3.49715240e-02f, 1.11939162e-01f, -2.00870484e-02f, 2.73843966e-02f, 2.04501860e-02f, 2.53277482e-03f, -1.23638242e-01f, 2.18728110e-02f, 7.03630298e-02f, 3.63241769e-02f,
  -5.47778048e-02f, -8.47698748e-02f, 1.63460299e-02f, -1.91059671e-02f, -1.61646813e-01f, -7.83795305e-03f, -1.31306365e-01f, -1.38133943e-01f, 6.35072663e-02f, -8.54600668e-02f,
  -4.63953279e-02f, 9.13214311e-02f, -4.96053584e-02f, 1.13458447e-01f, 4.28089239e-02f, 1.63927320e-02f, 1.75147131e-02f, -1.21146008e-01f, 7.85935745e-02f, -6.74746335e-02f,
  5.63967861e-02f, -4.46280204e-02f, -6.72827438e-02f, -5.26491702e-02f, -8.63008797e-02f, 1.94524731e-02f, 7.50042312e-03f, -3.26684937e-02f, -5.97569458e-02f, 1.01095870e-01f,
  3.11769154e-02f, 6.83200061e-02f, 9.52109229e-03f, -3.04867625e-02f, 3.29609774e-02f, -1.06358873e-02f, -1.28062069e-02f, 5.49039692e-02f, 8.83428007e-02f, -3.02571803e-02f,
  -6.92160577e-02f, -8.04776922e-02f, -5.93681037e-02f, -2.79572867e-02f, 7.75595084e-02f, -7.12507740e-02f, 5.60205765e-02f, 8.26936290e-02f, -2.49777753e-02f, 1.05071515e-02f,
  6.18500300e-02f, 3.42360511e-02f, 8.66698176e-02f, -4.58104685e-02f, -3.47635038e-02f, -8.59551281e-02f, -7.57894367e-02f, -6.49128556e-02f, -2.29932517e-02f, -4.69454266e-02f,
  1.29750827e-02f, 6.86014369e-02f, -4.06842642e-02f, -3.52690257e-02f, -5.25685810e-02f, 6.48920015e-02f, -9.21226814e-02f, 4.73798849e-02f, 1.10287406e-02f, -1.97818205e-02f,
  -6.07193038e-02f, 8.17760155e-02f, -2.75151501e-03f, -1.48375528e-02f, 4.61090654e-02f, 3.39049585e-02f, 2.36633662e-02f, -7.47739524e-02f, -8.43200460e-02f, -6.14902228e-02f,
  3.89577337e-02f, 5.76471118e-03f, 5.15148677e-02f, 2.21548527e-02f, 9.30901244e-02f, 4.52543199e-02f, 6.67345151e-02f, -1.99592952e-02f, 9.68346745e-02f, 2.76687797e-02f,
  -4.46224660e-02f, 5.40653504e-02f, -5.64746968e-02f, 6.91820867e-03f, -4.86524068e-02f, 1.08909056e-01f, 5.70461638e-02f, -2.56555993e-03f, -3.90068777e-02f, -3.55283655e-02f,
  -5.06384552e-01f, -1.06224149e-01f, -2.89135933e-01f, 1.07647799e-01f, 1.60729870e-01f, 1.51211753e-01f, 3.41719508e-01f, 2.59751052e-01f, 1.83726832e-01f, 8.25607106e-02f,
  1.54478416e-01f, 9.38710570e-02f, 1.85872361e-01f, 1.71789557e-01f, 1.65878907e-01f, 1.00404397e-01f, 1.14117891e-01f, -1.18022740e-01f, -1.08832426e-01f, 1.03034608e-01f,
  1.60778567e-01f, 6.30211234e-02f, -2.36902162e-01f, -3.12840566e-03f, 1.01674154e-01f, -3.30201015e-02f, -5.01633696e-02f, 1.38034318e-02f, 3.34783681e-02f, 4.08790857e-02f,
  -2.54128337e-01f, -2.21701369e-01f, -3.24561819e-02f, -3.20076756e-02f, -8.43822062e-02f, -2.42310353e-02f, -1.10794269e-01f, -1.79517969e-01f, -5.16704731e-02f, -1.34617105e-01f,
  -1.10742018e-01f, -5.66447377e-02f, -2.37214919e-02f, -8.28090757e-02f, 1.49877984e-02f, -1.93658732e-02f, -3.23681086e-02f, -1.62842587e-01f, -1.06275722e-01f, -2.86623742e-02f,
  7.71262571e-02f, -6.50898293e-02f, -1.08041391e-01f, -8.10689107e-02f, -8.89387950e-02f, -3.62968743e-02f, -7.93050602e-02f, -1.22596391e-01f, -1.99514434e-01f, -2.07541689e-01f,
  -1.68514773e-02f, -6.91555440e-02f, 7.02489689e-02f, -6.29021367e-03f, 3.72582227e-02f, 7.76058063e-02f, -6.61813021e-02f, 2.51365919e-02f, 3.83988358e-02f, -1.57773960e-02f,
  -1.78307146e-02f, 2.90688891e-02f, 9.89602320e-03f, -7.20318453e-03f, -3.57793004e-04f, -3.47474925e-02f, 2.22732127e-02f, -5.06515019e-02f, -7.90102854e-02f, -5.07648811e-02f,
  -5.91140017e-02f, -4.61162217e-02f, -1.31704599e-01f, 1.22328736e-02f, 2.69402005e-02f, 6.05712570e-02f, -4.42226790e-02f, -7.08129033e-02f, -4.07298841e-02f, -9.45058279e-03f,
  8.24133754e-02f, -3.20531204e-02f, -4.23765779e-02f, -9.14600119e-03f, -8.38744789e-02f, -5.72943874e-02f, -3.55906039e-02f, -7.54616633e-02f, 2.70255320e-02f, 4.22696099e-02f,
  -3.48453224e-02f, -2.99208742e-02f, 5.06785475e-02f, -4.98159672e-04f, -9.55610573e-02f, 2.04362031e-02f, 4.06295769e-02f, 5.48903421e-02f, -3.37461270e-02f, -8.77510086e-02f,
  2.05667107e-03f, 2.26131976e-02f, -1.10197872e-01f, 4.10914747e-03f, -4.18399125e-02f, -7.24490285e-02f, -7.28814527e-02f, -1.62753284e-01f, -8.33153203e-02f, -1.01849973e-01f,
  2.21879587e-01f, -1.76228210e-01f, -3.94763410e-01f, -1.42256305e-01f, -2.51912445e-01f, -2.60872561e-02f, -6.35262355e-02f, -8.61933231e-02f, -4.23571058e-02f, -2.31751725e-01f,
  -1.24970168e-01f, 7.90882558e-02f, -6.61020949e-02f, -4.94100004e-02f, -4.47306857e-02f, -1.76593423e-01f, -2.00672790e-01f, -7.10173398e-02f, 8.04360509e-02f, 1.07085116e-01f,
  -1.23544209e-01f, -1.43977568e-01f, -2.63707619e-02f, -9.02681947e-02f, -2.26464048e-01f, -1.40678016e-02f, -2.98099816e-01f, -1.84342742e-01f, -1.03702284e-01f, -1.78207770e-01f,
  -1.64983511e-01f, -3.39506939e-02f, 1.18761450e-01f, 1.56926975e-01f, -4.08406034e-02f, 1.06852360e-01f, 1.83028542e-02f, -9.05396193e-02f, 2.09248532e-02f, 2.33728848e-02f,
  5.62860491e-03f, 9.05168205e-02f, -2.35598851e-02f, 7.66168982e-02f, 8.21145102e-02f, 9.31517556e-02f, -6.38991967e-02f, 7.41062462e-02f, -5.75523190e-02f, -2.48790178e-02f,
  -2.14363206e-02f, -4.31641517e-03f, 3.97636108e-02f, -1.62024945e-02f, -2.75888182e-02f, 8.34102929e-02f, -3.42599712e-02f, -3.07126734e-02f, 1.09231129e-01f, 5.65992482e-03f,
  -3.23759802e-02f, -3.26965936e-03f, -4.35120799e-02f, -7.40193157e-03f, 6.04380220e-02f, 2.00705882e-02f, 4.17900085e-02f, 7.75729120e-02f, 8.25126842e-02f, -4.48149145e-02f,
  -3.10951825e-02f, -5.37820114e-03f, -2.43436340e-02f, 6.28897967e-03f, -1.08182743e-01f, 2.15543061e-02f, 6.91651329e-02f, -8.13017040e-02f, 3.41787189e-02f, -7.20258430e-03f,
  9.57829803e-02f, -6.74079135e-02f, 6.20884821e-03f, -5.09441234e-02f, -7.12549984e-02f, -8.16232860e-02f, 1.05157373e-02f, -3.68894562e-02f, -3.99444811e-02f, 4.66142111e-02f,
  -3.83534916e-02f, 8.20006803e-02f, -9.50419903e-02f, 8.43313634e-02f, -3.00451051e-02f, -5.76224253e-02f, 1.50917843e-02f, -2.75055729e-02f, 1.15315981e-01f, -2.59953290e-02f,
  1.05400495e-01f, 9.91940591e-03f, -5.20968474e-02f, 1.66167300e-02f, -1.89026892e-02f, 2.82313637e-02f, 3.95232402e-02f, -5.90116978e-02f, 4.23587784e-02f, 5.32751530e-03f,
  -1.10667013e-01f, 1.01479985e-01f, 2.03040928e-01f, -4.16779239e-03f, -5.88961551e-03f, 1.49532273e-01f, -4.11405861e-02f, 2.35993117e-02f, 9.93883386e-02f, -6.47319257e-02f,
  -1.42043615e-02f, -1.58932228e-02f, -1.07622750e-01f, 6.52823597e-03f, 4.02062945e-02f, 1.08584411e-01f, 9.67159048e-02f, -3.48515064e-02f, -2.64585670e-02f, -2.75827199e-03f,
  7.88405631e-03f, -1.11037493e-01f, -1.33199885e-01f, -8.19914490e-02f, -6.56891987e-03f, -9.91248898e-03f, 1.29096419e-01f, -5.65681607e-02f, 1.05764456e-02f, 4.01795434e-04f,
  1.09870680e-01f, -2.36061476e-02f, 7.45908394e-02f, 3.57347690e-02f, 2.19231155e-02f, -5.25220111e-02f, 6.26633540e-02f, -3.12664323e-02f, -9.42143351e-02f, -4.27903347e-02f,
  -1.26799062e-01f, -2.16376379e-01f, 9.34178159e-02f, -2.43254043e-02f, 2.08930783e-02f, -6.42887782e-03f, -2.07890123e-02f, 2.83567235e-02f, -9.00407284e-02f, -1.06009342e-01f,
  -5.55227771e-02f, -5.29580452e-02f, -9.08004642e-02f, -1.77568458e-02f, 2.06180587e-02f, -9.96264294e-02f, 1.06286466e-01f, -8.04174617e-02f, -9.38912332e-02f, -1.39970809e-01f,
  -8.85680784e-03f, -3.57065797e-02f, -1.18503273e-01f, -4.75266129e-02f, -3.11158337e-02f, -1.28384158e-01f, -1.31169409e-01f, -8.24959725e-02f, -1.08172506e-01f, -6.29016757e-02f,
  -1.93153769e-02f, 7.60195963e-03f, 9.14908648e-02f, 1.02120705e-01f, 5.42702377e-02f, 2.37583388e-02f, 1.04047418e-01f, 7.59824887e-02f, 5.35295233e-02f, 4.12957668e-02f,
  -2.06799880e-02f, -6.13722578e-02f, 6.29266899e-04f, -6.26956448e-02f, -1.19000077e-02f, -6.82773814e-02f, 8.13555047e-02f, -3.20420638e-02f, -2.73313224e-02f, -3.60872447e-02f,
  3.42893787e-02f, -1.47831216e-02f, -3.86680849e-02f, 7.79290572e-02f, -8.34004581e-02f, 8.69921818e-02f, -7.58926347e-02f, -2.46290248e-02f, 2.58352738e-02f, -7.30640069e-02f,
  1.14893399e-01f, -7.99915567e-02f, 4.14623925e-03f, -3.68496217e-02f, -4.32389118e-02f, -1.17574073e-02f, 3.80150368e-03f, 1.77600719e-02f, -8.19769725e-02f, -1.05071180e-01f,
  -1.00449339e-01f, -2.29249224e-02f, -9.21138376e-02f, 2.41030976e-02f, -3.59747768e-03f, 2.43463386e-02f, -4.20499966e-02f, -4.04002778e-02f, 9.56430733e-02f, -5.77907115e-02f,
  1.39437839e-01f, 6.15632311e-02f, 1.38517171e-01f, 4.80252914e-02f, 6.15620241e-02f, 6.73755480e-04f, 5.16843721e-02f, 8.28906447e-02f, 1.23787142e-01f, 1.75865024e-01f,
  -4.69937027e-01f, 3.53523679e-02f, -1.93190962e-01f, -2.67011344e-01f, -1.53121218e-01f, -8.20413977e-02f, -1.72513686e-02f, -7.05397204e-02f, -1.11418717e-01f, -5.43038696e-02f,
  5.71258739e-02f, -1.69189158e-03f, -1.35050371e-01f, -8.97308812e-02f, -2.05433115e-01f, -8.01836923e-02f, -2.22536176e-01f, -3.42593223e-01f, -2.84615308e-01f, -1.12805247e-01f,
  -1.48190290e-01f, -1.74844131e-01f, -3.13636452e-01f, -5.47277033e-02f, -2.96286028e-02f, 6.38041319e-03f, -1.27902374e-01f, -1.05895072e-01f, 5.62452748e-02f, -8.04991201e-02f,
  1.64614171e-01f, 4.26713238e-03f, 3.11774798e-02f, -3.00021283e-02f, -1.55297024e-02f, 4.87993993e-02f, -4.50951047e-02f, -9.82936006e-03f, 1.77829172e-02f, 3.16184014e-02f,
  -8.94286782e-02f, -5.28383814e-02f, -6.14639595e-02f, -7.91040715e-03f, -1.39469225e-02f, -8.95577855e-03f, 6.28447160e-02f, 5.44341793e-03f, -1.23228291e-02f, 8.76673982e-02f,
  7.23975226e-02f, 1.39692342e-02f, 8.00627917e-02f, 1.13665164e-01f, 1.16709322e-01f, -6.13609478e-02f, 1.89363450e-01f, 1.21834658e-01f, 1.47763029e-01f, 5.23760505e-02f,
  -2.12401990e-02f, -7.98633769e-02f, 6.54236600e-02f, -7.33567178e-02f, 3.55093740e-02f, 6.47204369e-02f, 7.29759410e-03f, -1.11567423e-01f, -1.02054784e-02f, 4.29401249e-02f,
  -1.07968627e-02f, -2.83720833e-03f, 2.65719164e-02f, -7.90154114e-02f, -2.42216978e-02f, 3.01321987e-02f, -1.96450353e-02f, -2.65015401e-02f, 9.18424726e-02f, -2.24792939e-02f,
  4.78585344e-03f, 4.96911332e-02f, -4.71070930e-02f, 1.07809260e-01f, 1.09303243e-01f, 7.29302987e-02f, 5.68044558e-02f, -1.36687877e-02f, 2.30800156e-02f, -9.70101506e-02f,
  7.76915699e-02f, -8.53324607e-02f, -1.00620359e-01f, -5.20316437e-02f, -5.85433915e-02f, 7.26677924e-02f, 4.32276307e-03f, 7.33062476e-02f, -4.04157080e-02f, -3.68807763e-02f,
  1.03972733e-01f, 7.69692007e-03f, 4.72844392e-02f, 1.30809527e-02f, -6.95103109e-02f, -6.08089715e-02f, -6.64359853e-02f, -2.69657057e-02f, 3.38018909e-02f, 1.59949690e-01f,
  7.33970031e-02f, -1.08213253e-01f, 3.57290022e-02f, 8.16215351e-02f, 6.07912354e-02f, -2.92743258e-02f, 1.34409741e-01f, 1.98890284e-01f, -3.98553535e-02f, 2.30324380e-02f,
  7.34782666e-02f, 1.48241639e-01f, 2.79853512e-02f, 7.49055222e-02f, -2.79083904e-02f, -1.79986820e-01f, -2.84125894e-01f, -1.38089001e-01f, -9.80405882e-02f, 1.01768645e-03f,
  -1.16925664e-01f, 2.75181253e-02f, -1.71623565e-02f, 1.51557192e-01f, -3.71992635e-03f, 1.07220143e-01f, 1.96966678e-01f, 2.84726560e-01f, 7.11504743e-02f, -6.58948952e-03f,
  1.49504557e-01f, 1.40850142e-01f, 2.22009808e-01f, 1.64451510e-01f, 1.03459947e-01f, 7.93880895e-02f, 5.09392521e-05f, 8.66685659e-02f, 1.35443389e-01f, 3.70344341e-01f,
  3.45544443e-02f, -2.06281804e-02f, -7.96132460e-02f, -2.72731911e-02f, -4.07881588e-02f, -3.52271870e-02f, -7.58452341e-02f, 8.93544629e-02f, 6.87676296e-02f, -7.17329830e-02f,
  7.18451440e-02f, 1.26130134e-01f, -2.52015702e-02f, -3.87191214e-02f, -6.13921843e-02f, -7.91961774e-02f, 5.03491983e-02f, 5.20485081e-02f, 1.05869912e-01f, 9.08216462e-02f,
  1.70235291e-01f, 1.24193765e-02f, -9.62570608e-02f, 1.23933591e-02f, -5.55732958e-02f, 5.57410903e-02f, -1.28071606e-01f, -3.82989133e-03f, -6.31500185e-02f, -1.54380058e-03f,
  5.51810898e-02f, -1.30961575e-02f, -4.19943146e-02f, 1.09000094e-01f, 3.89571860e-02f, -4.31763101e-03f, -2.69078035e-02f, 2.30443925e-02f, 3.65093239e-02f, 9.92111936e-02f,
  -5.47463149e-02f, 7.70571688e-03f, 4.30348516e-02f, 8.51834007e-03f, 6.70015067e-02f, -2.97611039e-02f, -2.07541864e-02f, 5.83373830e-02f, -5.90311624e-02f, -1.55065181e-02f,
  6.61885664e-02f, -3.17616723e-02f, 3.13419774e-02f, 1.29016921e-01f, -9.95807932e-04f, -1.26631176e-02f, 8.19847584e-02f, -9.59234461e-02f, 6.58119544e-02f, -9.40861832e-03f,
  -2.39936367e-01f, -7.35717416e-02f, -9.27168354e-02f, -1.84582695e-02f, -1.79843456e-02f, -5.55244386e-02f, -9.57769975e-02f, -4.54613660e-03f, 2.66269594e-02f, -1.13710789e-02f,
  7.58670038e-03f, -1.66781936e-02f, -3.46835405e-02f, 1.48072727e-02f, -3.12905423e-02f, -9.21766162e-02f, -1.99550614e-02f, 3.18303406e-02f, -4.14896570e-02f, -2.96466164e-02f,
  -7.09242225e-02f, -2.40218610e-01f, -1.16103239e-01f, -2.16049671e-01f, -1.26701698e-01f, -1.58563331e-01f, -1.65293485e-01f, -1.49580970e-01f, -2.73646653e-01f, -2.69745588e-01f,
  8.86281878e-02f, 5.97031079e-02f, 1.66710272e-01f, -1.05022073e-01f, 5.60374260e-02f, 3.77436839e-02f, 4.98537235e-02f, -6.04754835e-02f, -5.05802780e-02f, 1.84374228e-02f,
  4.03919891e-02f, -8.67945030e-02f, -1.21507667e-01f, 6.20074458e-02f, -6.74666390e-02f, 7.33578671e-03f, 8.21178779e-02f, 8.05940777e-02f, 6.89536631e-02f, -2.22393945e-02f,
  -8.06574747e-02f, -5.15310466e-02f, -3.29472050e-02f, -7.06749829e-03f, -7.83108771e-02f, -9.68111977e-02f, 4.98271845e-02f, 1.00383043e-01f, -4.44502756e-02f, 9.32706892e-02f,
  -2.92403009e-02f, 1.10767603e-01f, -9.67319235e-02f, -8.81133899e-02f, -5.81277497e-02f, 2.26481725e-02f, 5.25659695e-02f, 7.49690458e-02f, 1.81749370e-03f, -6.19779043e-02f,
  -9.19902325e-02f, 6.73023164e-02f, 5.17716855e-02f, -7.36156031e-02f, 4.97022495e-02f, -3.37678082e-02f, 2.68875752e-02f, 1.10200368e-01f, 8.54187012e-02f, 5.17504103e-02f,
  -6.35624304e-02f, -1.97465997e-02f, -5.66541813e-02f, -4.81541902e-02f, -4.56622103e-03f, -7.83514678e-02f, -2.04184540e-02f, -5.24937622e-02f, 1.04347222e-01f, 3.00665032e-02f,
  -7.07293153e-02f, -3.05176638e-02f, 1.78055745e-02f, 1.71476584e-02f, -6.52108490e-02f, 7.25220935e-03f, -7.35067874e-02f, 9.08438414e-02f, 4.88913171e-02f, -3.80666628e-02f,
  5.42894527e-02f, 5.44767193e-02f, 4.93097566e-02f, 8.99707079e-02f, -2.05353405e-02f, 3.78312431e-02f, 1.04066305e-01f, 1.04419954e-01f, 7.31318742e-02f, -3.98341417e-02f,
  -7.31596202e-02f, -6.85810447e-02f, 1.10873438e-01f, -5.79812229e-02f, -4.70387079e-02f, 1.04936965e-01f, 7.43244169e-03f, -3.27613624e-03f, 2.80736815e-02f, -5.25677800e-02f,
  -7.96212554e-02f, -2.20324146e-03f, -9.45343226e-02f, -5.05753122e-02f, -7.93516170e-03f, -1.67023204e-02f, -6.70218915e-02f, 3.23536880e-02f, 1.50426589e-02f, -1.04564596e-02f,
  -5.25317080e-02f, -3.11733559e-02f, -1.92463044e-02f, 7.61509463e-02f, 3.58859859e-02f, -9.80653148e-03f, -8.37683082e-02f, 6.11613728e-02f, -3.22984532e-02f, 5.80717176e-02f,
  1.73978694e-02f, -9.08346847e-02f, -1.01525046e-01f, -2.69722305e-02f, -1.26028538e-01f, -1.72146335e-01f, -4.50438298e-02f, -3.81949209e-02f, -8.17835629e-02f, -5.55770546e-02f,
  1.18237644e-01f, -1.83560525e-03f, 1.12262137e-01f, 1.20118052e-01f, 1.40064299e-01f, 1.84232384e-01f, 4.13343608e-02f, 4.98490082e-03f, 6.22378625e-02f, -4.75048386e-02f,
  -1.35223502e-02f, -6.41043112e-02f, 2.83666495e-02f, -5.51575087e-02f, 4.08741049e-02f, 1.48794651e-01f, 1.91252790e-02f, 1.20004676e-02f, 1.65862050e-02f, 9.29779410e-02f,
  -2.03025527e-02f, 1.12644024e-01f, -2.54103448e-02f, -2.00950559e-02f, -1.08135734e-02f, -6.69327378e-03f, 5.37024997e-02f, -2.71662045e-02f, 6.05927669e-02f, 2.37185601e-02f,
  -6.20003790e-02f, 9.71596409e-03f, 2.79660001e-02f, 3.51050533e-02f, -4.73783314e-02f, 3.85990702e-02f, 6.51448071e-02f, -5.06674647e-02f, 5.23134060e-02f, 8.70749354e-02f,
  6.50788918e-02f, -4.99694608e-04f, -2.15025097e-02f, -3.40212509e-02f, 1.18403891e-02f, 7.78679550e-02f, 6.68920353e-02f, 3.18473205e-02f, -5.63651696e-03f, -6.31158724e-02f,
  -3.14506399e-03f, 9.60440189e-02f, -1.55327497e-02f, -5.93191870e-02f, 4.03375588e-02f, -2.98421923e-02f, -1.51579874e-03f, 2.90919393e-02f, 5.32893315e-02f, -6.17460860e-03f,
  -1.44819161e-02f, 5.45865484e-02f, 6.17401861e-02f, 4.23939191e-02f, 4.12277468e-02f, 1.69893093e-02f, -5.95948845e-02f, 2.98544932e-02f, 5.03812172e-02f, -2.03114320e-02f,
  -4.35333103e-02f, -3.18849087e-02f, -4.59672548e-02f, 7.77227730e-02f, -9.73566025e-02f, -1.21027157e-02f, -1.06035369e-02f, -7.82825984e-03f, 5.99667653e-02f, 6.65927827e-02f,
  4.23728637e-02f, 1.44506749e-02f, 7.68452883e-02f, 6.77083209e-02f, 1.02303298e-02f, -6.23788238e-02f, 4.88117076e-02f, -9.40342695e-02f, 6.16392866e-02f, -6.96492344e-02f,
  -6.68391809e-02f, -3.40063423e-02f, -8.46187845e-02f, 2.70229913e-02f, -5.26514575e-02f, 2.62693339e-03f, 1.59908645e-02f, -4.86035906e-02f, 6.87412620e-02f, 6.05883934e-02f,
  -8.20885450e-02f, -3.65847908e-02f, -8.59047379e-03f, -4.10477854e-02f, 4.99209389e-02f, -3.14020067e-02f, 1.36470050e-02f, -3.38160316e-03f, 6.61220402e-02f, 6.88273832e-02f,
  -7.78186992e-02f, 1.29981697e-01f, -2.08652820e-02f, 3.91379185e-02f, 2.14008968e-02f, 6.86550289e-02f, 2.24294476e-04f, 1.14771649e-01f, 5.70645444e-02f, -2.39064153e-02f,
  -2.58803107e-02f, 8.75440836e-02f, 3.23706307e-02f, -2.20540930e-02f, -6.90888464e-02f, -2.24071503e-01f, -4.63444926e-02f, -6.27906397e-02f, -7.93489069e-02f, -4.81285006e-02f,
  3.53373624e-02f, -8.38995501e-02f, 3.26637477e-02f, -1.58248797e-01f, -6.79145157e-02f, -8.43804702e-02f, -5.89615889e-02f, -1.76586911e-01f, -2.24027053e-01f, -1.61281109e-01f,
  -3.49978060e-02f, 9.77951940e-03f, -1.64398730e-01f, -1.44473761e-01f, 1.28029853e-01f, 7.25490302e-02f, 1.04143903e-01f, -3.41790691e-02f, 1.20302280e-02f, 1.05771206e-01f,
  1.23845547e-01f, -7.83441290e-02f, -6.71674684e-02f, -9.00136158e-02f, 3.53677496e-02f, -5.02050407e-02f, -4.32573631e-02f, 7.21150870e-03f, 4.34449762e-02f, 4.59358841e-02f,
  -2.30335654e-03f, 1.91129297e-02f, -2.25473456e-02f, 8.06140602e-02f, 5.36733121e-02f, 2.61035166e-04f, -1.99372433e-02f, 5.72870076e-02f, -1.61466245e-02f, 1.14957817e-01f,
  -5.33394068e-02f, -1.12427279e-01f, 6.08311407e-03f, 3.88442762e-02f, 1.99326631e-02f, -9.97311920e-02f, 1.80053171e-02f, 5.82459979e-02f, -7.66720399e-02f, 1.47754833e-01f,
  7.65486658e-02f, 5.20450883e-02f, -7.23726079e-02f, 1.07179187e-01f, 6.22496903e-02f, 9.47930943e-03f, 5.21050431e-02f, 4.67559099e-02f, 5.23376130e-02f, 8.90684351e-02f,
  6.13535270e-02f, 5.53005794e-03f, -6.27461672e-02f, 5.06008640e-02f, 8.85348096e-02f, -3.72762047e-02f, -1.25791542e-02f, 2.04943065e-02f, -1.55421942e-02f, 3.69302183e-02f,
  -3.74758393e-02f, 7.95030221e-02f, -1.43501973e-02f, -1.03403693e-02f, -8.73086508e-03f, 9.27123800e-02f, 4.91184816e-02f, -3.65105309e-02f, -9.08723101e-02f, -5.62469382e-03f,
  7.86336511e-02f, -1.87989056e-01f, 1.66613817e-01f, -7.97583014e-02f, 5.94513752e-02f, 8.22000355e-02f, 1.31156236e-01f, 2.08868482e-03f, 1.58896241e-02f, 1.00314245e-01f,
  -9.27496031e-02f, 1.10053912e-01f, -1.31430207e-02f, 8.98184851e-02f, -2.97056721e-03f, -5.22160009e-02f, 1.20924219e-01f, -7.03233331e-02f, -1.20160304e-01f, 1.10442400e-01f,
  -1.86065014e-03f, -2.29088701e-02f, -7.44147301e-02f, 1.10094510e-01f, 7.51462160e-03f, -4.72459793e-02f, 3.19935419e-02f, 4.72627021e-02f, 7.05187395e-02f, 3.53342034e-02f,
  -1.24156222e-01f, -4.26513813e-02f, 1.11304820e-02f, -2.09296033e-01f, 8.85195062e-02f, 1.03580385e-01f, 2.84976810e-01f, 1.16872877e-01f, -6.18077349e-04f, 2.95347646e-02f,
  -1.72507256e-01f, -2.14257866e-01f, -1.40481263e-01f, -2.04013422e-01f, 3.04246582e-02f, 1.41724810e-01f, 1.00069627e-01f, 3.53145823e-02f, 3.60152498e-02f, 1.36328354e-01f,
  6.85672387e-02f, -6.08554184e-02f, -6.09508641e-02f, -1.55640066e-01f, -1.25521287e-01f, -7.68845156e-02f, -8.31566006e-02f, -8.85722116e-02f, -3.58315837e-03f, -6.10025376e-02f,
  2.10177273e-01f, -1.60987273e-01f, -5.68675324e-02f, -1.74038962e-01f, -1.25476152e-01f, 2.87389532e-02f, 6.90447092e-02f, -7.73808658e-02f, -1.90258548e-02f, 8.83432198e-03f,
  -1.04912765e-01f, -6.32138848e-02f, -8.23825672e-02f, 2.71550864e-02f, 4.97646816e-02f, 4.66040000e-02f, -1.21463336e-01f, 1.91341676e-02f, -1.00523420e-01f, -8.87638181e-02f,
  -5.87208979e-02f, 1.20898150e-02f, -5.18178381e-02f, -4.72170524e-02f, -1.53734431e-01f, -7.27768093e-02f, 8.51571783e-02f, -6.92601427e-02f, -2.69025117e-02f, 5.84490150e-02f,
  1.28200874e-01f, -5.73629048e-03f, -6.24923967e-03f, -5.26800789e-02f, -2.73971502e-02f, -7.71367550e-03f, 9.73185226e-02f, -5.12158349e-02f, 3.50464918e-02f, 2.48387679e-02f,
  5.50666526e-02f, -7.82767162e-02f, 7.13994578e-02f, 2.57688239e-02f, -7.93425590e-02f, -2.39550229e-03f, 8.37613642e-02f, 4.91173081e-02f, -5.77480420e-02f, -1.98081583e-02f,
  -8.36031437e-02f, 1.11332033e-02f, -8.84666145e-02f, -1.15974899e-02f, -4.40216251e-03f, -1.17922775e-01f, 9.25475731e-03f, -7.78912231e-02f, 4.07564752e-02f, -8.91038030e-02f,
  -8.08873847e-02f, -1.17557511e-01f, 5.77992648e-02f, -1.06832020e-01f, 8.77736416e-03f, -1.09744787e-01f, -5.75619116e-02f, -7.02272058e-02f, 1.01670222e-02f, 1.24582551e-01f,
  -5.71451224e-02f, 5.22208698e-02f, -8.44580308e-02f, -1.15394425e-02f, 1.39567181e-02f, -2.21416317e-02f, 7.00253323e-02f, -6.44549280e-02f, -3.78008485e-02f, 7.79787898e-02f,
  6.82639331e-02f, 2.30798587e-01f, 6.09178804e-02f, 1.08162999e-01f, 7.17145875e-02f, 6.70237979e-03f, 2.20260039e-01f, 8.03246051e-02f, 1.23946153e-01f, 2.88965106e-01f,
  -9.71151441e-02f, -2.73344755e-01f, 1.26919374e-01f, -1.18124284e-01f, 1.55301215e-02f, 1.28020542e-02f, 1.36606008e-01f, -5.80348223e-02f, 1.98024474e-02f, -1.75065082e-02f,
  -1.68087602e-01f, 6.74551353e-02f, 6.50486792e-04f, 7.33600482e-02f, 8.46962780e-02f, 6.22109622e-02f, -2.12372597e-02f, 2.61620376e-02f, 1.89306825e-01f, 1.44359306e-01f,
  -1.03637027e-02f, -6.03653938e-02f, -1.01948626e-01f, -4.08074856e-02f, 4.49311640e-03f, 7.71862194e-02f, 1.49081610e-02f, -5.17306663e-02f, -9.79286060e-02f, -1.65845782e-01f,
  2.10925087e-01f, -3.50965530e-01f, 8.07515904e-02f, -7.43243992e-02f, 5.10561652e-03f, -8.76474082e-02f, 5.35341538e-02f, -1.74067973e-03f, -8.81219655e-02f, -5.49022928e-02f,
  -9.32940096e-03f, -3.31243165e-02f, -6.59156442e-02f, -3.76075096e-02f, 1.89608373e-02f, -4.12421599e-02f, -9.15054902e-02f, -5.29301986e-02f, -8.28020871e-02f, -3.48928235e-02f,
  -2.07569554e-01f, -5.39173093e-03f, -1.83880841e-03f, -6.75572874e-03f, -1.15548618e-01f, 1.81329306e-02f, -4.73219581e-04f, -9.83785987e-02f, -3.84750180e-02f, -3.87120768e-02f,
  1.57162175e-02f, 5.08324942e-03f, -9.30356532e-02f, 4.30344455e-02f, 6.75547495e-02f, -6.27332106e-02f, 4.23171483e-02f, 1.67113896e-02f, 2.34758686e-02f, 1.20070099e-03f,
  3.26647386e-02f, -7.36170821e-03f, -4.33243513e-02f, 7.62220174e-02f, 4.50763293e-03f, 4.41279262e-04f, -1.66388880e-02f, -6.17966726e-02f, 1.66768655e-02f, -6.91896826e-02f,
  -2.79997960e-02f, 3.50808613e-02f, -6.18607439e-02f, -7.46218534e-03f, -9.04213544e-03f, -1.85809359e-02f, 1.04102921e-02f, -7.33713526e-03f, -7.60711432e-02f, -4.53568548e-02f,
  1.34705976e-01f, -7.62582347e-02f, 1.44989997e-01f, -6.99554756e-03f, 6.06527226e-03f, 7.41823856e-03f, -1.04937226e-01f, 2.21291129e-02f, -8.71522278e-02f, -5.34164421e-02f,
  5.18868864e-02f, 4.29831371e-02f, 3.33196260e-02f, -2.08230168e-02f, 1.57113120e-01f, 1.26540422e-01f, 4.31233970e-03f, 3.31573039e-02f, -5.81777319e-02f, -4.44608405e-02f,
  -5.20469248e-02f, 1.42672583e-01f, 2.32872978e-01f, 2.34690353e-01f, 2.62841005e-02f, 1.96149677e-01f, 1.29640132e-01f, 1.65370807e-01f, 6.00105338e-02f, 2.33653843e-01f,
  1.63096651e-01f, 2.16386229e-01f, 6.54779971e-02f, 1.11390099e-01f, 1.36207864e-01f, 2.00451881e-01f, 2.54439801e-01f, 1.87937394e-01f, 4.44796756e-02f, 4.05077189e-02f,
  5.15641365e-03f, 7.45540783e-02f, 8.35167151e-03f, 5.44521175e-02f, 6.21109642e-02f, 4.13137302e-02f, 1.40760494e-02f, -8.97120684e-02f, -4.05781530e-03f, -8.55867472e-03f,
  -6.34430647e-02f, -6.84824074e-03f, -4.31849174e-02f, -5.01287393e-02f, 1.45995161e-02f, -3.81648727e-02f, 1.41081391e-02f, 9.34685990e-02f, -5.29092737e-02f, -1.03744000e-01f,
  -9.71423537e-02f, 6.69405982e-02f, -3.34140076e-03f, 1.09586902e-02f, -2.15548538e-02f, -9.96733382e-02f, -9.01663750e-02f, -4.26657312e-02f, 3.78920510e-02f, 6.27650917e-02f,
  1.63521562e-02f, 5.33488803e-02f, -2.48219427e-02f, 6.46676347e-02f, 1.09140404e-01f, -4.82999720e-02f, -2.18271725e-02f, 6.82645710e-03f, 1.04992278e-01f, -1.89273581e-02f,
  -3.89877260e-02f, -1.08186807e-02f, 1.81343511e-01f, 7.86734149e-02f, 2.25298163e-02f, -2.30124444e-02f, 9.28182155e-02f, -1.97615437e-02f, 1.00696102e-01f, -3.81454639e-02f,
  -9.37872231e-02f, -8.65055397e-02f, 7.20518380e-02f, 4.08485010e-02f, 1.29800458e-02f, -4.49979827e-02f, 1.00406118e-01f, 2.32841987e-02f, -1.37769254e-02f, 6.79183304e-02f,
  -7.76894763e-02f, 5.25008775e-02f, 4.15716060e-02f, 3.56591903e-02f, 4.25182059e-02f, -6.26203939e-02f, 4.28778864e-02f, 4.31127287e-02f, -5.85120730e-02f, 1.78543553e-02f,
  2.10409742e-02f, -3.56853530e-02f, -3.71458530e-02f, -7.70259649e-02f, -5.33589348e-02f, 6.62268028e-02f, 3.72760892e-02f, -7.42363408e-02f, 3.85764092e-02f, 8.97111148e-02f,
  1.46231174e-01f, 1.17482267e-01f, -5.31348921e-02f, 5.92304654e-02f, 9.03324261e-02f, 7.11693615e-02f, 5.31639233e-02f, -2.19908897e-02f, 7.53352642e-02f, 1.12425283e-01f,
  -4.18345965e-02f, 4.36944328e-02f, 5.55559946e-03f, 6.42528534e-02f, 1.19244559e-02f, -4.93158512e-02f, 9.96554270e-02f, -4.42731045e-02f, 8.32383409e-02f, 1.34279862e-01f,
  4.15191129e-02f, 1.78014580e-02f, 4.06697728e-02f, 9.83974040e-02f, 1.20468505e-01f, -7.42198061e-03f, -4.39218208e-02f, -4.76570763e-02f, -5.69162965e-02f, -6.03528507e-02f,
  -2.85608679e-01f, 2.61050668e-02f, -2.51416303e-02f, -1.35217637e-01f, -7.05240816e-02f, 1.47068799e-02f, 1.43528834e-01f, 3.45256962e-02f, -1.05330080e-01f, -4.31267768e-02f,
  1.30084082e-02f, -1.44124180e-01f, -6.19218089e-02f, 8.29301327e-02f, 7.60935545e-02f, 3.83124896e-03f, -8.69573206e-02f, -7.41971061e-02f, -8.34517777e-02f, 5.85702946e-03f,
  6.43599033e-02f, -3.50485630e-02f, -1.06368996e-01f, -6.61227331e-02f, -4.24690768e-02f, -1.29588276e-01f, -4.87121567e-02f, -2.33872272e-02f, -1.37563767e-02f, -1.37137830e-01f,
  -1.67755842e-01f, -1.11102276e-02f, 1.19294681e-01f, 2.36174762e-02f, -4.33870479e-02f, 4.84975055e-02f, -7.43677914e-02f, 3.67445825e-03f, 5.94378822e-02f, 1.84196718e-02f,
  -2.70837918e-02f, 8.68695751e-02f, -1.02191783e-01f, -8.13536346e-02f, -3.04167513e-02f, -6.40274882e-02f, -2.62166709e-02f, -7.92361349e-02f, -9.70851537e-03f, 1.41508216e-02f,
  -6.05003908e-02f, -1.13367394e-01f, 6.44256547e-03f, 2.65276209e-02f, -2.33143177e-02f, -8.99297446e-02f, 5.00682592e-02f, 3.84772383e-02f, -6.25198381e-03f, -1.55305699e-01f,
  -1.91069711e-02f, -5.84780350e-02f, -2.57053096e-02f, 4.51603672e-03f, -4.77797650e-02f, 5.06214648e-02f, -6.25550076e-02f, 1.43487072e-02f, 6.27710447e-02f, 5.46425395e-02f,
  2.92318985e-02f, 6.11742847e-02f, -2.29894109e-02f, 5.79223521e-02f, -1.00582808e-01f, 4.07529697e-02f, -3.75447348e-02f, 1.08229272e-01f, 7.84305260e-02f, 8.70028585e-02f,
  -2.97146253e-02f, 5.64315654e-02f, 2.71513853e-02f, 7.09150955e-02f, 1.64421517e-02f, -4.40887697e-02f, -4.89544310e-03f, -3.82379815e-02f, -8.55571851e-02f, 8.61810371e-02f,
  -8.46500173e-02f, 2.43670225e-01f, 2.06590374e-03f, 9.92077868e-03f, -5.35661913e-02f, 5.44959754e-02f, 1.83479190e-02f, 1.05357990e-02f, 7.71645457e-03f, 3.53744738e-02f,
  -3.40167768e-02f, -1.02464415e-01f, -2.76659406e-03f, -2.94135232e-02f, 7.05695450e-02f, 5.48939705e-02f, 5.19502535e-02f, -2.40135286e-02f, -5.34264669e-02f, -6.70626834e-02f,
  -6.22106604e-02f, 2.02708002e-02f, -1.76128536e-01f, -1.28590062e-01f, 3.79601493e-02f, -1.10102683e-01f, -4.04644497e-02f, -1.15380296e-02f, -9.95192751e-02f, -1.40961707e-01f,
  -9.90751311e-02f, 7.70947710e-02f, -2.32099757e-01f, -1.49234265e-01f, -5.62515222e-02f, 2.18993407e-02f, 2.11522877e-01f, 9.61076692e-02f, 7.18241045e-03f, 8.26484784e-02f,
  -9.19984132e-02f, -1.16643585e-01f, -1.73061192e-01f, 1.32176736e-02f, -2.26365831e-02f, 1.46177948e-01f, -1.55671872e-02f, -1.56626895e-01f, -1.66628435e-02f, 3.44359763e-02f,
  -2.97682304e-02f, 3.90304998e-02f, -8.00302401e-02f, -5.11569157e-02f, -5.88028468e-02f, -1.32955298e-01f, -1.62023991e-01f, -1.49882540e-01f, -8.20861906e-02f, -1.42694101e-01f,
  -3.02629203e-01f, -1.20499976e-01f, -2.23836005e-02f, -2.76889987e-02f, -7.07176551e-02f, -1.30134104e-02f, -7.16784298e-02f, -1.31335137e-02f, -1.35715544e-01f, -1.21200331e-01f,
  -9.10840929e-02f, -9.11246240e-02f, -7.29305670e-02f, -6.38410598e-02f, -1.30161151e-01f, -7.04298466e-02f, -3.89067121e-02f, -4.68359105e-02f, -9.86563712e-02f, 4.25051898e-03f,
  4.03662100e-02f, 4.30578664e-02f, -1.33646011e-01f, 8.29246789e-02f, -9.09978077e-02f, -1.16257379e-02f, -9.57989395e-02f, 4.98060975e-03f, -1.86212156e-02f, 7.07162693e-02f,
  1.41133666e-01f, 5.60066383e-03f, 3.59882861e-02f, 1.17951743e-01f, -1.22359507e-02f, -6.67020008e-02f, -7.88001269e-02f, -2.04643961e-02f, -8.88423249e-02f, 6.47865161e-02f,
  -5.07512502e-02f, 7.57014826e-02f, 4.38252799e-02f, 4.16381564e-03f, 1.47908833e-02f, 5.26718684e-02f, -9.82261263e-03f, 1.10250697e-01f, 1.97459776e-02f, 2.31316555e-02f,
  -5.29580861e-02f, 3.58551294e-02f, 5.84989898e-02f, -5.67881800e-02f, 2.04610601e-02f, -1.26106862e-03f, 3.39680426e-02f, -8.04301351e-03f, -2.63095610e-02f, -4.40831482e-02f,
  -1.13909572e-01f, 1.05369106e-01f, -8.77189040e-02f, 1.14433117e-01f, -4.06327024e-02f, 1.34332897e-02f, -2.98441239e-02f, -4.55217399e-02f, -2.79891957e-02f, -2.74126511e-02f,
  -1.92578416e-02f, 1.40684061e-02f, -1.15559429e-01f, 7.15757161e-02f, 8.00150409e-02f, 5.36342338e-02f, 1.52296692e-01f, 2.10813768e-02f, 8.67243707e-02f, 1.41003344e-03f,
  1.85748320e-02f, 8.36794153e-02f, 2.84340885e-02f, 1.17226921e-01f, -2.00579446e-02f, -4.74696718e-02f, 5.74496714e-03f, 4.20617945e-02f, 3.62125002e-02f, 2.24792719e-01f,
  -3.36335331e-01f, -3.70800704e-01f, -1.52045667e-01f, -1.83032200e-01f, -9.43696871e-02f, -1.39974043e-01f, -2.00043663e-01f, -4.50516716e-02f, -7.63475895e-02f, -1.84711486e-01f,
  -4.03639637e-02f, 1.01951659e-01f, -2.58190669e-02f, 1.97416879e-02f, -5.15870936e-02f, -1.78838521e-01f, -2.49313384e-01f, -5.68268374e-02f, 5.17723449e-02f, 1.14080869e-01f,
  6.52784258e-02f, 6.98033571e-02f, 6.24889098e-02f, 1.12432301e-01f, -9.75354668e-03f, 2.33987048e-02f, -1.27127945e-01f, -6.80993348e-02f, 2.55871397e-02f, -1.19641297e-01f,
  -1.25885949e-01f, 1.81904044e-02f, 1.92781717e-01f, 5.77936098e-02f, 7.19413012e-02f, -7.38145709e-02f, 7.44046718e-02f, 1.00690760e-02f, -3.73510341e-03f, -9.22982022e-02f,
  -9.37995315e-03f, 7.93510973e-02f, -1.34357736e-02f, 4.81386073e-02f, -7.35993385e-02f, -2.22466639e-04f, -5.50046787e-02f, -1.33516174e-02f, -9.62674338e-03f, 7.62057118e-03f,
  -1.00907274e-02f, -1.16079085e-01f, -8.96297842e-02f, 5.00769354e-03f, -3.01159956e-02f, -5.06364927e-02f, 3.75969592e-03f, 9.27011743e-02f, 6.46542087e-02f, -1.85990274e-01f,
  -2.95052584e-02f, -4.87475842e-03f, 2.58062873e-02f, -1.87459489e-04f, -7.62662152e-03f, 1.82877574e-02f, -4.13960591e-02f, 6.39137253e-02f, 6.81798160e-02f, -5.24050742e-02f,
  2.23317556e-03f, 7.07215890e-02f, -2.26317812e-02f, -9.52541977e-02f, 8.42453167e-02f, -7.11013824e-02f, 8.32281262e-02f, 1.52849155e-02f, 4.25744802e-03f, 3.10673583e-02f,
  5.75522007e-03f, -3.69283631e-02f, -6.71778396e-02f, 1.25048950e-01f, 5.67507483e-02f, -2.20510680e-02f, 7.43794739e-02f, 1.58704836e-02f, -9.14208591e-02f, -2.00276822e-02f,
  -1.44872695e-01f, 2.29798168e-01f, -1.38296321e-01f, 7.49085918e-02f, -5.04860207e-02f, -2.32598800e-02f, 2.61764228e-02f, -1.64776091e-02f, 9.57318465e-04f, 5.13613224e-02f,
  1.41761974e-01f, -3.54849249e-02f, -8.83050784e-02f, -8.89453199e-03f, 1.44081593e-01f, 2.73007597e-03f, -9.60141793e-02f, -4.58941683e-02f, 7.86456019e-02f, 1.78000256e-02f,
  2.62610335e-02f, -1.27061889e-01f, -3.62337120e-02f, -1.52977020e-01f, -7.14690685e-02f, -1.13319634e-02f, 1.56646464e-02f, -6.39978349e-02f, -1.34097636e-01f, -1.17432013e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.77684531e-01f, 2.20354810e-01f, 3.44386786e-01f, 1.29036948e-01f, 4.89987209e-02f, 5.33837266e-02f, 2.51367688e-01f, 2.41245463e-01f, 1.31366178e-01f, 1.13387510e-01f,
  -6.10041358e-02f, 1.70278147e-01f, 8.66897553e-02f, 1.04204729e-01f, -3.02546397e-02f, 2.60306209e-01f, 1.03163436e-01f, -6.28164187e-02f, -6.87565431e-02f, 1.50339454e-01f,
  6.92469105e-02f, 3.23935091e-01f, 1.54845759e-01f, -8.95416085e-03f, -6.57391250e-02f, 2.95732975e-01f, 2.88965821e-01f, 1.70710638e-01f, 2.51188040e-01f, 1.77587554e-01f,
  6.51999414e-02f, 2.38741934e-02f, -4.80883829e-02f, 5.05641550e-02f, -1.98506210e-02f, 1.02057859e-01f, -1.43629070e-02f, -2.93814531e-03f, 1.40024081e-01f, 5.40329218e-02f,
  1.68816864e-01f, 2.00720057e-01f, 2.12822720e-01f, 1.30082816e-01f, 9.60596371e-03f, 8.67592171e-02f, 2.98760176e-01f, 2.59877115e-01f, -6.26012776e-03f, 1.62866507e-02f,
  2.06335738e-01f, 2.82215655e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.93692386e-01f, 1.68656126e-01f, -8.13659355e-02f, 1.30428851e-01f, -1.10291794e-01f, 1.42336160e-01f, -1.14503384e-01f, 4.94105332e-02f, 2.14057360e-02f, 2.41303518e-01f,
  -4.85853851e-01f, 5.02492368e-01f, 2.81637818e-01f, -5.41979708e-02f, -2.49556422e-01f, 8.03312957e-02f, -1.73663497e-01f, -7.67243840e-03f, 1.92852244e-01f, -1.63636521e-01f,
  2.30910555e-01f, -6.81465864e-02f, -5.38524017e-02f, -1.97031319e-01f, 7.29675740e-02f, 8.29182640e-02f, 1.64683670e-01f, -1.63326427e-01f, -1.87265724e-01f, 8.27682614e-02f,
  -4.84983176e-02f, 3.51442955e-02f, 1.38844401e-01f, 2.80592382e-01f, -2.71884769e-01f, 3.47675830e-02f, -1.17144570e-01f, 9.70146731e-02f, -4.53005657e-02f, 2.87145190e-02f,
  -8.99809897e-02f, -5.99138699e-02f, 2.01798707e-01f, 2.43452802e-01f, 1.38775691e-01f, -1.29387751e-01f, 3.70710455e-02f, -5.16870171e-02f, -4.03639190e-02f, 4.36939672e-02f,
  -3.01404506e-01f, -1.30234892e-03f, 3.04612471e-03f, -1.27159413e-02f, 1.17854223e-01f, 1.21922128e-01f, 1.30720481e-01f, 6.06196746e-02f, 1.67470798e-01f, -1.84765682e-01f,
  8.66420344e-02f, 6.03095666e-02f, 1.87481210e-01f, -2.69966066e-01f, 6.44900650e-02f, -6.77909106e-02f, 1.78942770e-01f, -1.97595775e-01f, 1.40556797e-01f, -8.76594111e-02f,
  3.04087937e-01f, -1.84818879e-01f, -1.42699242e-01f, -2.34686151e-01f, 4.39242512e-01f, 9.78341550e-02f, -8.21650177e-02f, -4.68437932e-02f, 1.91557501e-02f, 1.01380765e-01f,
  1.98963881e-01f, 2.95039173e-02f, -2.29003847e-01f, -2.00833619e-01f, 1.58351794e-01f, 8.30775052e-02f, 1.16009086e-01f, 2.69616634e-01f, 6.39985651e-02f, -9.42194313e-02f,
  2.73697495e-01f, -1.59884408e-01f, -1.59886703e-01f, 1.16461881e-01f, -8.89816135e-02f, -7.89503157e-02f, 5.93927912e-02f, 7.74549320e-02f, 8.31919909e-02f, -2.31778119e-02f,
  7.03121647e-02f, 2.40121111e-01f, 3.10707279e-02f, 3.07995647e-01f, -1.09645881e-01f, -2.14402471e-03f, -6.30827621e-02f, 9.73764136e-02f, -1.67560391e-02f, -9.17950124e-02f,
  -1.17065432e-02f, -6.20253608e-02f, 1.20809421e-01f, 2.65413872e-03f, 8.81295726e-02f, -1.68166962e-02f, 1.14129288e-02f, -1.11754034e-02f, 8.76765102e-02f, -1.32691756e-01f,
  -1.05708271e-01f, -1.31891832e-01f, 3.27756479e-02f, -2.34417647e-01f, -1.18107207e-01f, 1.51625693e-01f, 4.86824699e-02f, 2.41595432e-01f, -9.79987010e-02f, -1.47284165e-01f,
  -1.13247871e-01f, 1.20715916e-01f, -1.73780814e-01f, -1.79030985e-01f, -8.70719180e-02f, -1.27809646e-03f, 6.27257377e-02f, 1.99213013e-01f, 2.75453687e-01f, 1.67601883e-01f,
  1.55801862e-01f, 7.14386702e-02f, -5.78535870e-02f, -1.89271569e-01f, -4.02809866e-02f, 6.07841611e-02f, -1.11135811e-01f, 5.21127023e-02f, 1.79826468e-02f, 3.52584803e-03f,
  9.28492844e-03f, 3.65377329e-02f, 2.11600289e-01f, -1.32371411e-01f, -1.95807144e-02f, 9.69781727e-02f, 1.07608847e-01f, -1.70867860e-01f, -8.44397247e-02f, -2.71603540e-02f,
  1.16891950e-01f, 3.38557325e-02f, 7.15266466e-02f, 3.06838728e-03f, 1.02582775e-01f, 5.83967119e-02f, -2.28553653e-01f, -8.54033902e-02f, -6.09813631e-02f, 1.10717967e-01f,
  8.55230540e-02f, 1.52778238e-01f, -1.25482408e-02f, -1.41830415e-01f, 1.96695253e-02f, -5.80895022e-02f, 5.42833358e-02f, 7.56600574e-02f, 1.38308302e-01f, 9.74023193e-02f,
  -1.57967228e-02f, 2.52954289e-02f, 9.07905176e-02f, 1.13666048e-02f, -3.33934613e-02f, -1.00821197e-01f, -6.40629306e-02f, -2.66405642e-01f, 2.19939709e-01f, 2.19791964e-01f,
  2.17710927e-01f, 4.90525588e-02f, -2.66779065e-02f, 5.37093282e-02f, 1.60615683e-01f, 8.96542072e-02f, 5.17353304e-02f, 1.42847657e-01f, -2.09613472e-01f, 2.65329212e-01f,
  -2.33806312e-01f, -7.66451582e-02f, -1.52781919e-01f, 2.19005853e-01f, 8.79626051e-02f, -7.15177208e-02f, -3.43586206e-02f, -1.98937561e-02f, -1.13603391e-01f, -1.61091015e-01f,
  2.42384464e-01f, 2.56533660e-02f, -9.57574844e-02f, -1.48484230e-01f, -7.02712983e-02f, -1.08867414e-01f, -8.57120603e-02f, 2.17923015e-01f, -3.05537581e-02f, -8.60729292e-02f,
  -6.04940504e-02f, -1.47087649e-01f, -1.23244315e-01f, 1.76045429e-02f, -1.78408474e-01f, -1.89256385e-01f, -1.41355246e-01f, 7.83100352e-03f, -6.87779626e-04f, -1.64281845e-01f,
  -1.82992533e-01f, -5.51295467e-02f, 1.02273650e-01f, 2.31131185e-02f, -4.99085672e-02f, 1.28674403e-01f, 1.27021179e-01f, -1.96471973e-03f, -8.91455784e-02f, 1.34685457e-01f,
  -5.20640658e-03f, -1.12682484e-01f, -3.13907921e-01f, -5.94847165e-02f, -3.50696556e-02f, -4.39485349e-02f, 8.17185119e-02f, -4.68047075e-02f, 4.23985161e-03f, 6.41512126e-02f,
  2.33696207e-01f, 3.28362405e-01f, -1.82411298e-01f, -1.92130268e-01f, -1.20199293e-01f, -1.58914968e-01f, 1.27417492e-02f, -1.04799736e-02f, -1.84655562e-01f, 6.15340918e-02f,
  -1.95859641e-01f, -2.01541260e-01f, 7.14592487e-02f, 4.28923815e-02f, -8.44870582e-02f, 1.90372154e-01f, 2.96446413e-01f, -4.25125360e-02f, 2.79816203e-02f, -1.23570830e-01f,
  -7.71182179e-02f, -1.85293965e-02f, 9.97273475e-02f, 8.17431509e-02f, -2.90093608e-02f, 1.17763810e-01f, 1.55829608e-01f, 8.26452300e-02f, -3.76137882e-03f, 1.98952377e-01f,
  -9.38113928e-02f, 5.22000790e-02f, -7.61147290e-02f, 1.01896301e-01f, -2.59939302e-02f, 1.16897316e-03f, 7.66720995e-02f, 6.23498000e-02f, 1.64760202e-01f, 1.03513829e-01f,
  8.23574960e-02f, 2.13292204e-02f, -9.91835669e-02f, 3.11886430e-01f, -9.80821028e-02f, 5.08695841e-02f, -1.23201117e-01f, 2.07404599e-01f, 1.34516302e-02f, 2.45760269e-02f,
  -2.26406287e-02f, -4.16187271e-02f, -4.97006774e-02f, -9.60313231e-02f, 1.10129505e-01f, 7.41136298e-02f, 2.02756986e-01f, 6.26480356e-02f, -5.25096208e-02f, -1.23943478e-01f,
  -4.49550971e-02f, 5.30427173e-02f, 1.26823559e-01f, -1.48273438e-01f, -1.72601044e-01f, -1.21104315e-01f, 1.42196730e-01f, 4.54762876e-02f, 1.38482019e-01f, 6.50365353e-02f,
  -1.34249199e-02f, -1.86704010e-01f, 1.34758487e-01f, -3.14960349e-03f, -7.35771507e-02f, 8.04014057e-02f, 1.00458115e-01f, -8.34221616e-02f, 3.11959535e-01f, 4.41398099e-02f,
  7.98885673e-02f, -3.80819291e-01f, -7.71632716e-02f, -4.82228473e-02f, 6.16023578e-02f, 2.66631749e-02f, 5.80886155e-02f, -2.04927266e-01f, -4.45569865e-02f, 1.01413831e-01f,
  -1.67679489e-01f, 1.53379694e-01f, -5.38101010e-02f, -9.23474208e-02f, 2.24521793e-02f, -5.27099632e-02f, -2.05829248e-01f, 7.11561218e-02f, 1.27374336e-01f, -9.26400572e-02f,
  8.92420039e-02f, 6.87341690e-02f, 1.84272006e-01f, -1.39780967e-02f, 3.10039539e-02f, 1.69112757e-01f, 1.29980534e-01f, -2.11589828e-01f, 1.88779518e-01f, -2.34338462e-01f,
  -3.15517634e-02f, 1.62695736e-01f, 3.11820228e-02f, -7.44792074e-02f, -1.37642343e-02f, 1.02840409e-01f, 1.57668814e-02f, 1.09270349e-01f, -8.21576491e-02f, 1.21844083e-01f,
  2.62601115e-02f, 1.05573542e-01f, -1.40307963e-01f, 1.62465081e-01f, -2.45228007e-01f, 4.69316356e-02f, 1.00475932e-02f, -1.12121761e-01f, -1.48623675e-01f, 7.03297555e-02f,
  9.68230814e-02f, 7.63947144e-02f, 2.79509220e-02f, 9.36580971e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.88674349e-02f, 2.49456195e-03f, -4.98333527e-03f, 4.02886644e-02f, 1.26590803e-01f, 1.24431169e-03f, -7.18062669e-02f, 2.48115771e-02f, -1.12554021e-01f, -6.49903640e-02f,
  -7.75765851e-02f, 1.67366162e-01f, -9.40905809e-02f, 1.06508717e-01f, -1.22161075e-01f, -2.93336362e-02f, -9.13306773e-02f, -4.62608188e-02f, -3.17318849e-02f, -8.09086338e-02f,
  5.55215999e-02f, 8.00346956e-02f, -4.28480320e-02f, 6.95409328e-02f, 4.88586240e-02f, -4.44766022e-02f, -3.05582564e-02f, -7.00897053e-02f, -4.08938620e-03f, -4.88584712e-02f,
  3.79580562e-03f, -1.25427395e-01f, 1.28123745e-01f, -6.64744824e-02f, -1.47621399e-02f, 7.07109347e-02f, -1.90739632e-02f, 6.48480132e-02f, -1.57972917e-01f, 6.12858310e-02f,
  -6.10245913e-02f, 9.15233716e-02f, -1.17070615e-01f, -6.37467206e-02f, 1.25450622e-02f, -1.83599889e-02f, -6.22872375e-02f, -1.00071952e-01f, -8.34889039e-02f, -1.01782851e-01f,
  -5.33876307e-02f, -1.07388973e-01f, 1.72218755e-02f, 9.07614306e-02f, 1.15793072e-01f, -1.59056820e-02f, 6.98726624e-02f, -2.58654375e-02f, 5.33851832e-02f, 1.34272957e-02f,
  -7.22168609e-02f, -4.82424684e-02f, -5.82435215e-03f, -3.49539332e-02f, 1.02449656e-01f, -2.72167455e-02f, -3.25545929e-02f, 1.06041513e-01f, 9.08259451e-02f, 1.96862265e-01f,
  1.72662929e-01f, -3.47712561e-02f, 5.12833744e-02f, -1.55521734e-02f, 9.53451172e-02f, 1.18746459e-01f, 2.09301963e-01f, 1.69946507e-01f, -8.96465704e-02f, 1.05135344e-01f,
  1.47040188e-01f, 2.42123418e-02f, -1.54913142e-01f, -1.85349181e-01f, 4.43491563e-02f, 1.33395538e-01f, 9.61069018e-02f, -9.24143195e-03f, 2.61503868e-02f, -1.13934658e-01f,
  1.27395958e-01f, 6.68674335e-03f, -6.87825829e-02f, 1.18270762e-01f, -2.49513723e-02f, -7.28327706e-02f, 2.73743153e-01f, 2.47142687e-02f, 7.27628246e-02f, 4.43902127e-02f,
  -6.02607839e-02f, 9.36905220e-02f, -1.14295907e-01f, 1.04299933e-01f, -7.36611784e-02f, -3.34780384e-03f, -1.02783456e-01f, -4.47184220e-02f, 1.16291866e-01f, -1.01757519e-01f,
  -6.09710962e-02f, 2.54349783e-02f, 1.79789066e-01f, -7.27332532e-02f, 2.71240264e-01f, 2.01468095e-02f, 1.27363175e-01f, 1.83661640e-01f, -4.00911421e-02f, -5.45710549e-02f,
  -4.16982025e-02f, 6.16561584e-02f, 2.41381694e-02f, -3.44801843e-02f, -9.02328044e-02f, 1.88928187e-01f, 1.63423449e-01f, 3.30172181e-02f, 1.89771175e-01f, 2.47455344e-01f,
  3.54144096e-01f, -1.14766210e-02f, 9.47180390e-02f, 1.58686489e-01f, 4.80473563e-02f, 5.01275547e-02f, -2.55064256e-02f, -1.14516303e-01f, -3.28290433e-01f, -1.95231568e-02f,
  1.88101336e-01f, 8.97019263e-03f, -1.09328732e-01f, 9.05347243e-03f, 1.39158340e-02f, -2.53356099e-02f, -5.31463102e-02f, -1.12016603e-01f, -1.25236018e-02f, -4.29486204e-03f,
  -2.82055866e-02f, -1.48333341e-01f, -1.06905652e-02f, 4.59421612e-02f, -1.44452497e-01f, -1.62446827e-01f, -1.13825155e-02f, -1.02973148e-01f, -2.44992357e-02f, 2.49237105e-01f,
  1.78950787e-01f, 2.09305704e-01f, 3.99799459e-02f, 7.32299313e-02f, 1.28108039e-01f, 1.82343066e-01f, -5.69846109e-02f, 6.06317492e-03f, 3.72534543e-02f, 1.12472810e-01f,
  1.18094519e-01f, -1.35160431e-01f, 1.37735587e-02f, 6.79833516e-02f, 7.28153661e-02f, 1.14902630e-01f, 9.82629880e-02f, -1.32441884e-02f, 1.11274107e-03f, -9.41112414e-02f,
  1.68757349e-01f, 2.49642089e-01f, -1.81401357e-01f, -8.18199385e-03f, 1.45237237e-01f, 1.70823082e-01f, 2.25649148e-01f, 3.19677919e-01f, 1.59683600e-01f, 1.58417195e-01f,
  1.67335533e-02f, -9.91322920e-02f, 2.26801366e-01f, 2.23539203e-01f, 2.16886595e-01f, 2.01511905e-01f, 8.47728252e-02f, 6.00803308e-02f, -8.27567354e-02f, -1.38498157e-01f,
  -1.44952774e-01f, 2.09724963e-01f, 1.29946187e-01f, 1.69070840e-01f, 9.13336407e-03f, 2.37664893e-01f, 2.93266714e-01f, 1.41754359e-01f, -1.40761629e-01f, 1.61911353e-01f,
  1.14005782e-01f, 1.20724864e-01f, 6.83180988e-02f, -6.92571178e-02f, -1.12502061e-01f, 1.09834671e-01f, -3.05535309e-02f, 3.08099184e-02f, 1.86742693e-01f, 4.39342204e-03f,
  8.59120414e-02f, 1.63077787e-01f, -7.20964372e-02f, -1.18955605e-01f, 9.10298750e-02f, 4.10085440e-01f, -2.95317476e-03f, 2.11732797e-02f, -1.53299838e-01f, 5.82288653e-02f,
  -3.91524434e-02f, 3.00525606e-01f, 1.64671421e-01f, -6.08786680e-02f, 1.04405552e-01f, 2.36583427e-01f, -2.26234179e-02f, -9.31132808e-02f, 1.60649829e-02f, -3.89689989e-02f,
  -6.27123266e-02f, 5.95950857e-02f, -3.22139502e-01f, 5.31645231e-02f, -1.57270014e-01f, 6.67587742e-02f, 3.04923713e-01f, 1.11534916e-01f, 7.11130053e-02f, 7.88482949e-02f,
  -3.06816727e-01f, -3.07238221e-01f, -3.93598340e-02f, 3.75153944e-02f, -2.38563225e-01f, 2.06126515e-02f, 1.40244603e-01f, -1.83096230e-02f, 5.33112921e-02f, 2.28845209e-01f,
  -5.90106938e-03f, 2.34551877e-01f, 8.74799788e-02f, -7.56105483e-02f, 1.98283345e-01f, 8.80514979e-02f, -9.06352028e-02f, 1.42578725e-02f, 1.38064131e-01f, 6.69082254e-02f,
  -2.55827773e-02f, -1.97388306e-01f, 1.51449770e-01f, -7.51299784e-02f, -2.98763253e-03f, 4.02252451e-02f, -1.34060547e-01f, 5.98644326e-03f, -5.30360732e-03f, -7.98858106e-02f,
  4.14518304e-02f, -1.64509326e-01f, -5.08008637e-02f, 9.44554433e-02f, 1.22294597e-01f, -9.35965404e-02f, 1.32201657e-01f, 1.40253782e-01f, 4.05134335e-02f, -9.21034664e-02f,
  -3.79774533e-02f, -1.02419965e-01f, -7.19099957e-03f, 1.56729877e-01f, -2.13564962e-01f, -1.02373362e-01f, 6.97449595e-02f, 1.05197154e-01f, 1.55398875e-01f, -8.37645382e-02f,
  6.78257570e-02f, -1.33470654e-01f, -8.90212730e-02f, -6.35532755e-03f, 1.04338475e-01f, 1.48263261e-01f, 6.70104623e-02f, 2.39934310e-01f, 2.32683048e-01f, 7.75634199e-02f,
  -5.49448617e-02f, 1.74119417e-02f, 7.73938298e-02f, -1.45914545e-02f, 1.32152438e-01f, 1.11738130e-01f, 4.89493320e-03f, 1.20418496e-01f, 3.45126718e-01f, 1.70450494e-01f,
  -1.38673224e-02f, 1.10005133e-01f, -3.14627178e-02f, -4.58231568e-02f, 8.04530606e-02f, -9.73962173e-02f, 4.75539826e-02f, -1.20785557e-01f, 7.80944899e-03f, 1.06829524e-01f,
  -4.07936200e-02f, -1.48445860e-01f, -8.78548156e-03f, 8.96457881e-02f, 1.51952794e-02f, 1.13610320e-01f, 2.37898203e-03f, -4.43548299e-02f, -9.11774561e-02f, -5.03086075e-02f,
  -8.29227120e-02f, 1.29238397e-01f, -1.04870945e-01f, 5.69577068e-02f, 3.21926549e-03f, -1.04184251e-03f, -3.78782526e-02f, 1.68412045e-01f, 8.99509713e-02f, -2.96479072e-02f,
  -1.33871913e-01f, 1.03862159e-01f, -3.48305963e-02f, 2.01657668e-01f, 2.45363116e-02f, 1.28468081e-01f, 1.61752813e-02f, 1.02139890e-01f, 4.38155010e-02f, 6.20030565e-03f,
  1.05421454e-01f, -8.71584713e-02f, -2.92801075e-02f, 5.78126162e-02f, -9.69169065e-02f, 9.89427194e-02f, 8.34969580e-02f, 5.00543602e-02f, 6.98645785e-02f, -5.56284301e-02f,
  -2.88949776e-02f, 1.24272145e-01f, -1.50592938e-01f, 1.56718910e-01f, -1.05843253e-01f, 7.24540502e-02f, -8.99162740e-02f, -3.24177109e-02f, -1.32195756e-01f, -4.91743498e-02f,
  9.65636969e-02f, -9.74059850e-02f, 7.24651366e-02f, 1.43325284e-01f, 2.64502525e-01f, 1.82100147e-01f, 1.29723236e-01f, 2.38263849e-02f, 2.60175049e-01f, 1.56102821e-01f,
  1.33855417e-01f, 4.29080054e-02f, -4.04143214e-01f, -3.00098211e-01f, 4.38043699e-02f, 6.86619654e-02f, -5.51376976e-02f, 3.39421213e-01f, 2.42010504e-01f, 1.84886128e-01f,
  -8.05909038e-02f, 1.87561035e-01f, 6.01505153e-02f, 6.20169714e-02f, -3.68108265e-02f, -5.04128784e-02f, -1.00839175e-01f, 1.80102006e-01f, -1.17407404e-01f, 3.23930621e-01f,
  1.44135997e-01f, 1.59952566e-02f, 4.82313186e-02f, 5.73863760e-02f, -1.62740380e-01f, -6.82211891e-02f, -2.89154891e-02f, 2.66517457e-02f, 8.41573253e-02f, -1.13112673e-01f,
  -7.91204572e-02f, 4.71135788e-02f, 2.47708932e-01f, 2.70205200e-01f, 1.71023086e-01f, -3.22555721e-01f, -1.62310854e-01f, 3.75298738e-01f, -7.38715976e-02f, 4.18122746e-02f,
  1.50950730e-01f, 1.61334593e-02f, 1.48168504e-01f, -8.70668441e-02f, -2.87857205e-01f, -1.93498671e-01f, -1.70260876e-01f, 3.04807369e-02f, 4.65150267e-01f, 6.59159943e-02f,
  -1.83190517e-02f, 2.47601584e-01f, -5.76700680e-02f, 1.02146968e-01f, -1.06334664e-01f, -1.06765226e-01f, -2.59958625e-01f, -7.60848820e-02f, 9.33305770e-02f, 2.11075947e-01f,
  2.38138840e-01f, 1.70532227e-01f, 1.52434796e-01f, 2.23293379e-01f, 1.67379677e-01f, 2.54089013e-02f, -1.07845187e-01f, -1.12454162e-03f, 1.45738602e-01f, -3.56779844e-01f,
  -2.20832840e-01f, 5.89901116e-04f, 6.13184012e-02f, -2.30511501e-02f, -7.91856423e-02f, 3.87052111e-02f, 5.65002337e-02f, 2.39429101e-01f, -1.21709667e-01f, 4.30335104e-02f,
  1.04178026e-01f, -4.70484942e-02f, -1.04263358e-01f, 1.34557113e-01f, -1.85069516e-02f, 2.32943386e-01f, 1.92499667e-01f, 6.77006021e-02f, -6.49795979e-02f, 9.06630605e-02f,
  -9.83057693e-02f, 1.64386615e-01f, 1.68925330e-01f, 1.22405358e-01f, 7.64951929e-02f, 1.81742042e-01f, 8.16986784e-02f, 3.61639098e-03f, 1.60221606e-01f, 2.96553485e-02f,
  4.46327031e-02f, -1.45749757e-02f, -1.64766952e-01f, 1.92389011e-01f, -4.79685999e-02f, -1.12123467e-01f, 1.17468402e-01f, 1.38257489e-01f, -1.37480080e-01f, -9.69178379e-02f,
  -4.88763265e-02f, 8.82024467e-02f, 1.25066414e-01f, -8.68366435e-02f, -7.74627626e-02f, -1.26152992e-01f, -3.96577045e-02f, 2.41588335e-02f, -9.65055525e-02f, 2.04306543e-02f,
  -5.21382242e-02f, 1.77045718e-01f, 1.40405655e-01f, 2.82325186e-02f, 2.40857564e-02f, 1.94813997e-01f, 2.28565753e-01f, -6.79928362e-02f, 4.38648164e-01f, -5.36260426e-01f,
  1.54401362e-01f, -3.47422600e-01f, 2.04319865e-01f, -3.21530104e-01f, -2.39211041e-02f, 4.32704315e-02f, 1.16058744e-01f, 1.56081945e-01f, 9.93065909e-02f, -1.41987026e-01f,
  -4.65313792e-02f, -4.73667942e-02f, 2.17395738e-01f, -3.46887335e-02f, -4.12308611e-02f, 1.25672162e-01f, 4.67266627e-02f, 6.03829511e-02f, 1.41356699e-02f, 4.89650629e-02f,
  1.25381857e-01f, -2.37628371e-02f, -5.58824465e-02f, 9.85737890e-02f, 4.60375249e-01f, 2.04825476e-01f, 1.45296618e-01f, 1.14135645e-01f, 6.35349080e-02f, 1.36069253e-01f,
  1.68466628e-01f, -4.91017429e-03f, 1.96033224e-01f, -1.30429445e-02f, -1.58004954e-01f, -2.95250420e-03f, 1.98756501e-01f, 2.27731898e-01f, -1.49515092e-01f, 2.29029343e-01f,
  1.50105909e-01f, 8.53211805e-03f, 1.44351646e-01f, 9.39699039e-02f, 2.31984314e-02f, 6.48699522e-01f, -2.44802549e-01f, -8.41416642e-02f, -4.79288511e-02f, 1.59363851e-01f,
  8.41747522e-02f, -3.76876593e-02f, 1.83136687e-02f, 9.95851457e-02f, 1.94858268e-01f, 3.43418896e-01f, 6.55395165e-02f, -1.23633966e-01f, -6.26325011e-02f, 7.36850053e-02f,
  -1.31950721e-01f, 1.17250048e-01f, 4.02690731e-02f, -1.12029672e-01f, 1.16847582e-01f, 4.58058640e-02f, 1.39715582e-01f, -1.43207729e-01f, 2.43217126e-01f, 2.88977861e-01f,
  4.05661255e-01f, 2.51536574e-02f, 3.48037109e-02f, 1.11733422e-01f, -9.96744558e-02f, 5.64985611e-02f, -7.11136386e-02f, -1.04771778e-01f, -1.83479235e-01f, 7.76937744e-03f,
  1.89963132e-01f, 3.09830662e-02f, -8.30895379e-02f, 8.74070823e-03f, 8.42891559e-02f, -1.11230761e-01f, -3.84966517e-03f, -1.38532728e-01f, 8.49402994e-02f, -3.76288667e-02f,
  -7.72975152e-04f, 1.79096818e-01f, -6.98670140e-03f, -1.85494617e-01f, -6.55174181e-02f, -1.62380841e-02f, 1.56138927e-01f, 1.55207636e-02f, 9.95679200e-02f, 7.23126829e-02f,
  1.26661301e-01f, 8.46161693e-02f, -6.21366911e-02f, -9.13906917e-02f, 1.10861853e-01f, -1.77383353e-03f, -1.29086539e-01f, 9.53759402e-02f, 2.86302492e-02f, 8.07454810e-03f,
  -1.26170099e-01f, 1.08335186e-02f, 6.17508031e-02f, 5.71050905e-02f, -1.15729123e-01f, -2.74840612e-02f, 1.29791256e-02f, 4.16165441e-02f, 1.62368361e-02f, 9.76184662e-03f,
  1.55888468e-01f, -1.01006486e-01f, -6.64451346e-02f, -2.84133153e-03f, 2.26357907e-01f, 1.53688461e-01f, 1.44520581e-01f, -1.02512836e-01f, 1.37302607e-01f, -1.43125996e-01f,
  3.39785188e-01f, 2.02543750e-01f, 4.93330732e-02f, 3.62079203e-01f, 1.32882193e-01f, 2.02139646e-01f, 6.50378317e-02f, 5.22880107e-02f, 7.78369457e-02f, -1.62565902e-01f,
  2.18557313e-01f, -9.05105993e-02f, -7.50748143e-02f, 2.12161034e-01f, 1.38960287e-01f, -2.48105191e-02f, 4.02641157e-03f, -1.19451523e-01f, -2.64036115e-02f, -5.35223372e-02f,
  -6.91512302e-02f, 2.31596474e-02f, 4.32035550e-02f, -6.51936010e-02f, -1.07826993e-01f, -9.81537774e-02f, -7.56871775e-02f, 1.07371166e-01f, 1.43495217e-01f, 6.92641512e-02f,
  1.51951775e-01f, -2.54040938e-02f, -7.89871290e-02f, -4.82927822e-02f, -4.01985012e-02f, 8.10884014e-02f, 2.29883760e-01f, 7.82273486e-02f, 8.51349458e-02f, -7.31717423e-02f,
  2.91921943e-01f, -5.26265837e-02f, 1.15991570e-01f, -3.96180414e-02f, 2.04625696e-01f, -1.28611743e-01f, 2.19238568e-02f, 1.61795676e-01f, -9.56481397e-02f, -9.05308723e-02f,
  -4.28249799e-02f, 2.92587262e-02f, -4.81757894e-02f, -1.14399292e-01f, 9.82380006e-03f, 2.33934671e-01f, 2.80293941e-01f, 1.60251111e-01f, 5.14878966e-02f, 8.83890390e-02f,
  -1.93836480e-01f, 2.05511361e-01f, -6.42460287e-02f, 2.12705620e-02f, -2.38460451e-01f, -7.23393187e-02f, 7.76903555e-02f, -1.00892723e-01f, -9.19795707e-02f, 2.50837812e-03f,
  -2.06797309e-02f, -6.14259131e-02f, 1.75314695e-01f, -5.61759435e-02f, -4.52501886e-02f, 1.08453549e-01f, -8.38984698e-02f, 3.06342132e-02f, -1.00386895e-01f, -1.51397064e-02f,
  3.39053646e-02f, 3.07352114e-02f, -2.15013940e-02f, -1.36791412e-02f, -1.37516662e-01f, -2.96516214e-02f, -1.42893061e-01f, -1.83548462e-02f, 5.27925938e-02f, 5.25706522e-02f,
  4.41451259e-02f, -3.86791416e-02f, -5.09980507e-03f, -7.47284144e-02f, -2.60764603e-02f, 5.67752905e-02f, 9.20248032e-02f, 8.26916322e-02f, -4.49012443e-02f, 4.13499884e-02f,
  -1.38460577e-01f, 4.21340652e-02f, 2.76053268e-02f, -7.97524452e-02f, -1.25621378e-01f, -8.84791240e-02f, 1.07563779e-01f, 1.05193622e-01f, 1.37415063e-02f, 3.52554694e-02f,
  2.39761192e-02f, 6.64843023e-02f, 1.98760957e-01f, 1.15132220e-01f, -1.42096984e-03f, -4.34117876e-02f, -3.39195766e-02f, -1.63829729e-01f, 1.35256305e-01f, 1.16236754e-01f,
  1.70771956e-01f, 2.76493262e-02f, 7.22528808e-03f, 1.62055105e-01f, -2.33822644e-01f, 3.14762890e-02f, 9.09201950e-02f, 2.20974460e-01f, -2.86303878e-01f, -1.76529419e-02f,
  -1.24647662e-01f, -1.07587963e-01f, -7.08995899e-03f, -6.71122000e-02f, -4.64193709e-02f, -5.07908948e-02f, 2.32912362e-01f, 3.31757843e-01f, -7.54316226e-02f, 1.58777580e-01f,
  -6.38251081e-02f, -1.52158514e-01f, -1.36456713e-01f, -1.52466610e-01f, -1.71937495e-01f, 1.79876193e-01f, -4.87080775e-02f, 7.98211545e-02f, 9.93408784e-02f, 3.42864334e-03f,
  -1.51256546e-01f, 1.39204174e-01f, 3.23603339e-02f, 1.44799262e-01f, 4.06318810e-03f, -1.01836383e-01f, 1.62673503e-01f, -1.43120140e-01f, -5.44293672e-02f, 2.80192286e-01f,
  1.46816462e-01f, -1.53368741e-01f, -7.92127028e-02f, 1.49498582e-01f, -3.32226939e-02f, -1.28319815e-01f, -1.63261265e-01f, 1.10715359e-01f, 4.81235124e-02f, 2.77583241e-01f,
  -1.20457366e-01f, -2.13613845e-02f, -9.07120183e-02f, -8.44095498e-02f, 6.09229468e-02f, -1.52979106e-01f, -2.00833529e-02f, 1.16858542e-01f, 1.01111017e-01f, 7.73125235e-03f,
  9.06695239e-03f, -4.11681272e-02f, -7.24455938e-02f, 1.03778718e-02f, -9.83437225e-02f, 6.23142682e-02f, -7.65197724e-02f, -1.41322473e-02f, 6.61190376e-02f, -1.73756778e-01f,
  9.73257422e-02f, -1.31802768e-01f, 5.51414154e-02f, -1.27447754e-01f, 1.99292116e-02f, 1.75186157e-01f, 1.68072179e-01f, 1.99481621e-01f, -8.61483812e-02f, -1.05466917e-01f,
  -6.56734779e-02f, -1.65279761e-01f, 8.95040184e-02f, 3.18013802e-02f, -9.78732780e-02f, -7.38570094e-02f, -8.01409408e-03f, 4.40794826e-02f, 6.17557857e-03f, 2.90497625e-03f,
  9.16366577e-02f, 2.38746554e-02f, 3.03099714e-02f, -1.25073478e-01f, -7.28974259e-03f, 1.43145233e-01f, 7.59496465e-02f, 4.84677876e-04f, 1.15790360e-01f, -1.17083497e-01f,
  -3.53128277e-02f, -4.27681133e-02f, 1.25564216e-02f, -6.63919151e-02f, -7.82839656e-02f, 7.13068098e-02f, -1.03600435e-01f, -1.43302819e-02f, 4.96634878e-02f, -1.02639519e-01f,
  -6.42141886e-03f, 6.10376224e-02f, -7.32089654e-02f, -8.65723640e-02f, 6.16465919e-02f, 2.46195421e-01f, 1.20647652e-02f, -3.07268798e-02f, -9.10659414e-03f, 1.23948075e-01f,
  3.87659818e-02f, -6.55410737e-02f, -1.18395470e-01f, -5.06974850e-03f, -9.41649675e-02f, -9.09277424e-02f, 3.00959367e-02f, 1.91804230e-01f, -4.00217213e-02f, 6.74451813e-02f,
  9.70331877e-02f, 3.01829800e-02f, -1.66615173e-01f, 6.64908066e-02f, -3.48757595e-01f, 1.08226174e-02f, -4.97652628e-02f, 2.22991243e-01f, 2.03434397e-02f, 1.17975712e-01f,
  1.39913019e-02f, 8.73623937e-02f, 7.69089733e-04f, 1.30096734e-01f, 1.63504660e-01f, 1.34902000e-01f, -4.16657794e-03f, -1.54469997e-01f, -1.07256025e-01f, 1.51498958e-01f,
  1.75692402e-02f, 1.07818760e-01f, 1.27812535e-01f, -1.02369815e-01f, 5.06567731e-02f, 3.94754447e-02f, 4.24105823e-02f, -1.42490089e-01f, -1.70782268e-01f, 1.33687988e-01f,
  1.17023908e-01f, -4.55189832e-02f, -8.79535824e-02f, 1.12714514e-01f, -2.09127497e-02f, 4.62647937e-02f, 8.06819573e-02f, -8.41875598e-02f, 6.70171306e-02f, 3.13106090e-01f,
  -7.48033077e-02f, -1.36052698e-01f, -7.24850968e-02f, -9.87471715e-02f, 8.17794874e-02f, 4.19375338e-02f, -1.47766829e-01f, -1.93401165e-02f, 5.69852768e-03f, -1.79849774e-01f,
  3.06057572e-01f, 5.31208925e-02f, -1.42259434e-01f, 6.63487390e-02f, -5.23316562e-02f, 2.70821992e-02f, -2.58299969e-02f, 2.51492187e-02f, -6.10037185e-02f, 1.13228045e-01f,
  -2.16007102e-02f, 1.56809151e-01f, 8.30026716e-02f, 7.61564448e-02f, -2.05474887e-02f, 1.99125499e-01f, -9.32222698e-03f, -2.08406318e-02f, 1.70323491e-01f, 8.09539035e-02f,
  -1.77530095e-01f, -1.89240705e-02f, 2.09994465e-01f, -5.45543954e-02f, -4.77742665e-02f, -4.74631302e-02f, -5.88345900e-02f, -5.51919043e-02f, 1.63599908e-01f, 2.10738219e-02f,
  7.98412338e-02f, -4.37138230e-02f, -1.67388469e-02f, -4.85139564e-02f, 1.34323299e-01f, -1.52483210e-01f, 1.37114763e-01f, -5.15353233e-02f, -5.55259027e-02f, 1.07390158e-01f,
  5.66256531e-02f, 8.63469392e-02f, -1.03421696e-01f, 1.24058850e-01f, -4.23423015e-02f, -1.15605086e-01f, -4.39289212e-02f, -1.02662826e-02f, -1.62786767e-01f, -5.83258383e-02f,
  -5.43836355e-02f, 8.86212941e-03f, 1.51366681e-01f, -8.16340074e-02f, -2.10961420e-02f, -3.32632381e-03f, 4.90056910e-03f, -1.61333904e-02f, -1.16595000e-01f, -5.16569950e-02f,
  -1.04410827e-01f, -1.21656759e-02f, 1.07650295e-01f, -6.69566691e-02f, 1.60106476e-02f, 9.20619443e-02f, 1.09396480e-01f, 7.76096880e-02f, 1.24454528e-01f, -2.93839853e-02f,
  2.08178926e-02f, -7.23584462e-03f, 5.94964400e-02f, -9.95915160e-02f, -5.02422154e-02f, -1.02598675e-01f, 8.22899118e-02f, 9.09838378e-02f, -6.04800694e-02f, -5.03094681e-03f,
  -1.40627226e-05f, -1.13943785e-01f, -3.49557288e-02f, 1.17463015e-01f, -1.59493193e-01f, -8.11015964e-02f, -1.41126692e-01f, 5.35092922e-03f, -1.99564490e-02f, -2.35240124e-02f,
  3.89475599e-02f, -1.48654342e-01f, -8.65818560e-02f, 1.40444264e-01f, -9.02823508e-02f, -6.87097907e-02f, 1.14232134e-02f, -2.14397106e-02f, -1.09163180e-01f, 6.63357824e-02f,
  6.03501722e-02f, -5.78342341e-02f, 1.31271809e-01f, -5.92697263e-02f, -9.85761285e-02f, 5.46584018e-02f, 8.63019302e-02f, -1.18274242e-02f, -3.45425084e-02f, 3.92420962e-02f,
  5.80512658e-02f, 9.70039889e-02f, -1.90497488e-02f, -6.00744300e-02f, -1.29430741e-01f, 4.51928563e-02f, -5.67917675e-02f, -5.05443439e-02f, 1.44307464e-01f, -6.66774735e-02f,
  -1.45629510e-01f, -4.42100428e-02f, -3.17846201e-02f, 9.59721357e-02f, -7.45588690e-02f, 1.75488487e-01f, 1.39539978e-02f, 1.64596811e-01f, -1.86601460e-01f, -9.80039909e-02f,
  -1.06917232e-01f, 6.80535212e-02f, 2.10175231e-01f, 6.04082011e-02f, 3.99211049e-02f, 8.33368674e-02f, 2.14279294e-02f, -6.78611323e-02f, -2.54226811e-02f, 4.00058292e-02f,
  3.01939528e-03f, 9.24184024e-02f, 7.85425957e-03f, 1.13210978e-03f, 1.47098228e-01f, 9.64631960e-02f, -1.51073202e-01f, -9.23505519e-03f, 8.40429589e-02f, 8.84642676e-02f,
  -8.56515542e-02f, 1.27237275e-01f, -1.31799340e-01f, 1.98536068e-02f, 5.98020107e-02f, 1.11229606e-01f, -1.16721943e-01f, -6.00849986e-02f, 1.44404516e-01f, -5.73265254e-02f,
  1.76388547e-01f, 2.20238879e-01f, -8.42042938e-02f, 7.13421404e-02f, -3.28106470e-02f, -4.32308577e-03f, 5.93189001e-02f, 9.56470966e-02f, 3.91425639e-02f, -5.49096651e-02f,
  3.25675271e-02f, 2.45598271e-01f, 1.14093564e-01f, -1.77064352e-02f, -5.28943837e-02f, 2.74800360e-01f, 1.59762502e-01f, 2.28560686e-01f, 6.42893091e-02f, 2.01054722e-01f,
  5.42158782e-02f, -5.51450253e-02f, -5.92206046e-02f, -5.64079024e-02f, 3.42929810e-02f, 5.54206558e-02f, 1.44343957e-01f, 1.15748174e-01f, 2.46748790e-01f, 1.22362673e-01f,
  -2.92453002e-02f, -7.63802156e-02f, 9.11398232e-03f, 8.09337124e-02f, -4.45637554e-02f, 3.06342561e-02f, -1.41111761e-02f, -1.32588074e-01f, 4.18907367e-02f, 1.42459041e-02f,
  -4.29476500e-02f, 1.40708312e-01f, 9.46678296e-02f, -1.18538365e-01f, -1.47225484e-01f, 9.57752839e-02f, 8.13316256e-02f, -4.32446003e-02f, -5.17350174e-02f, -1.18580677e-01f,
  -2.84162816e-02f, 8.40522945e-02f, -1.04831541e-02f, 1.00817882e-01f, 3.47950645e-02f, -5.53530902e-02f, 8.75255559e-03f, 1.35632763e-02f, 1.97111499e-02f, -2.57276706e-02f,
  -1.14127703e-01f, -3.15496251e-02f, -7.21072927e-02f, -1.63997337e-02f, -2.43650898e-02f, -1.03132166e-01f, -5.00423834e-02f, -5.62743992e-02f, 8.08560923e-02f, -3.91910924e-03f,
  -8.02665651e-02f, -1.23969629e-01f, 8.99537727e-02f, 1.46570519e-01f, -2.42913030e-02f, 8.07064623e-02f, -8.18912536e-02f, -3.98214236e-02f, -7.52471089e-02f, -4.91959117e-02f,
  -5.53856716e-02f, -1.35115653e-01f, 6.20790236e-02f, -9.52192172e-02f, 1.23716645e-01f, 1.39771367e-03f, 2.53829709e-03f, -2.19389144e-02f, 7.26887956e-02f, -9.87032652e-02f,
  -7.87818804e-02f, -7.65190199e-02f, 3.92877087e-02f, 1.08979158e-01f, 8.14994052e-02f, 1.34850144e-02f, 4.13336940e-02f, -9.39250290e-02f, 9.21369123e-04f, 8.71246606e-02f,
  -3.45979147e-02f, 9.31495205e-02f, 2.82708276e-02f, -1.20477781e-01f, -4.30931188e-02f, -2.75849756e-02f, 9.91078168e-02f, 1.77001789e-01f, -4.59927469e-02f, -5.31756058e-02f,
  1.28928065e-01f, 1.94357961e-01f, 1.11726522e-02f, -1.36944741e-01f, -5.96177056e-02f, -2.09454760e-01f, 1.79078862e-01f, -1.83266863e-01f, -4.47972231e-02f, 2.68984497e-01f,
  3.25190216e-01f, 2.02120215e-01f, 1.44156814e-01f, 9.99074131e-02f, 4.43270653e-02f, -1.17480747e-01f, -1.26754329e-01f, 6.70689717e-02f, -1.14224195e-01f, 6.14510961e-02f,
  -4.85457368e-02f, 3.74399163e-02f, -8.29221960e-03f, 9.94091481e-03f, 7.03897402e-02f, 7.78255686e-02f, 1.21501669e-01f, 6.86985925e-02f, -5.97504787e-02f, -1.50572136e-01f,
  -1.00932747e-01f, 8.62252265e-02f, 8.09109509e-02f, -1.98956981e-01f, 1.30816251e-01f, 4.60852636e-03f, 1.25444010e-01f, -1.90414175e-01f, -1.01115830e-01f, 1.14972085e-01f,
  -6.58188248e-03f, 1.04392990e-02f, -7.87339061e-02f, 1.94976568e-01f, -3.85207124e-02f, 4.00002766e-03f, 7.90850297e-02f, 1.17174452e-02f, 8.96676537e-03f, 5.60998209e-02f,
  2.00930685e-02f, 8.06984901e-02f, -1.63646132e-01f, 1.40373409e-01f, -2.31040847e-02f, 1.57524347e-01f, -1.04534468e-02f, -6.00059777e-02f, -1.76376089e-01f, 1.77548409e-01f,
  8.21896046e-02f, -2.39677746e-02f, -9.23595130e-02f, 9.74483863e-02f, -8.32644925e-02f, 3.23873237e-02f, 2.80974023e-02f, -2.54407637e-02f, 1.00193761e-01f, 1.01734689e-02f,
  -9.50224176e-02f, 3.46725225e-03f, 6.86399788e-02f, -8.27663690e-02f, 6.69887941e-03f, -1.24113351e-01f, 3.78549695e-02f, 8.01316872e-02f, 5.25422432e-02f, 7.94288740e-02f,
  6.44518286e-02f, -6.64326549e-02f, -7.67584071e-02f, -5.72613291e-02f, -5.77695221e-02f, -1.28668293e-01f, -1.24992639e-01f, 1.16312824e-01f, -3.94825526e-02f, 1.03766620e-01f,
  -3.33453976e-02f, -1.13008775e-01f, 1.83587614e-02f, 4.11865860e-03f, -1.04628645e-01f, 1.14096589e-02f, -1.72363054e-02f, -7.04841986e-02f, 1.10067785e-01f, -9.34116691e-02f,
  9.23184305e-02f, -1.01102209e-02f, -4.24595959e-02f, 1.12462431e-01f, -1.18187875e-01f, 4.58865575e-02f, 3.93102020e-02f, -2.48169377e-02f, -5.04980050e-02f, 1.24790907e-01f,
  -1.05784193e-01f, 2.84205470e-02f, -5.01944423e-02f, -8.87816399e-02f, -3.89039814e-02f, -4.67593521e-02f, -7.15069845e-02f, -9.79162380e-02f, -6.00503273e-02f, 8.87535699e-03f,
  6.34035245e-02f, 1.20595424e-02f, -6.65781349e-02f, -5.05214408e-02f, 1.11426435e-01f, 3.07427365e-02f, 1.73218340e-01f, 4.18861806e-02f, 2.17414424e-01f, 1.72555491e-01f,
  -1.67770442e-02f, -1.54689983e-01f, 1.04056291e-01f, -1.33296236e-01f, -1.14020094e-01f, 1.54091865e-02f, 1.19681939e-01f, 4.57476079e-02f, 2.59626880e-02f, 8.99406075e-02f,
  -3.01021542e-02f, 5.50640598e-02f, -2.78281793e-02f, -1.61914662e-01f, 6.85397442e-03f, 5.98937646e-02f, -1.02298252e-01f, -1.71084762e-01f, 1.03086852e-01f, 1.07084416e-01f,
  -3.46260928e-02f, -8.73323008e-02f, 4.09662388e-02f, -9.59274247e-02f, -3.59912030e-02f, 1.64730594e-01f, -7.38114268e-02f, -2.28327792e-03f, -1.32369950e-01f, 4.48781513e-02f,
  9.18602869e-02f, -1.04147345e-01f, -8.07766840e-02f, -4.50257771e-02f, -8.95800628e-03f, 1.31248817e-01f, -7.32866153e-02f, -1.81228116e-01f, -7.23802298e-02f, 1.60292447e-01f,
  1.05908133e-01f, 1.57687277e-01f, -7.53144324e-02f, -3.82768698e-02f, 1.15568988e-01f, -1.21543214e-01f, 1.04339562e-01f, 2.34576613e-01f, -1.47889480e-01f, 2.18231976e-02f,
  7.84131810e-02f, 1.93461165e-04f, 2.00143784e-01f, 1.99716046e-01f, 5.44761233e-02f, -2.35628448e-02f, 1.28935963e-01f, -5.41553833e-02f, 6.50275871e-02f, -6.19253032e-02f,
  -1.50256297e-02f, 1.06623061e-01f, 1.97343975e-01f, -3.29503492e-02f, 1.39779583e-01f, 1.25117660e-01f, -1.75129235e-01f, 9.91228372e-02f, -1.35370260e-02f, 8.13046694e-02f,
  -1.38664441e-02f, 1.26435146e-01f, 5.40830642e-02f, 1.60382658e-01f, 3.48403081e-02f, 1.03352265e-02f, 9.00521502e-02f, 9.54504088e-02f, -6.29082546e-02f, -1.44835547e-01f,
  1.60226822e-02f, -3.95114981e-02f, 7.29012191e-02f, -1.01188540e-01f, 3.46357264e-02f, 1.27887456e-02f, 1.95832588e-02f, -5.75725408e-03f, -5.46819083e-02f, -1.31697029e-01f,
  7.67035261e-02f, 1.26085326e-01f, 5.78918681e-02f, 9.13783535e-02f, 1.52659118e-02f, 4.24350873e-02f, 1.20727256e-01f, 1.85674056e-01f, 1.56702965e-01f, 4.47309241e-02f,
  2.00091787e-02f, 6.09170198e-02f, -9.54445377e-02f, -3.09085511e-02f, 1.34492949e-01f, 3.25016826e-02f, -8.03206339e-02f, -3.94630544e-02f, -1.03333771e-01f, -5.91278188e-02f,
  -3.88334878e-02f, 9.11602229e-02f, 6.77814633e-02f, -2.05191374e-02f, -3.97855304e-02f, 8.15622360e-02f, -1.96435496e-01f, 3.06094973e-03f, 1.21212915e-01f, -1.35452747e-01f,
  -1.97494905e-02f, -4.82808910e-02f, 4.04903516e-02f, 5.82604855e-02f, -8.34679604e-02f, 7.14780539e-02f, 1.20801307e-01f, 1.17554426e-01f, 8.27455074e-02f, -1.06086858e-01f,
  6.75995871e-02f, 8.13407153e-02f, 5.18273078e-02f, -1.64931715e-01f, -2.05722805e-02f, -9.42511205e-03f, 2.41777390e-01f, -7.94300362e-02f, 4.39422578e-02f, -1.02090351e-01f,
  -1.01475209e-01f, -1.31026730e-01f, -1.05573855e-01f, 6.94696233e-02f, 4.06833068e-02f, 3.71106304e-02f, 8.39828886e-03f, 5.48361428e-02f, -1.05402716e-01f, 2.01162845e-01f,
  -1.09482504e-01f, -8.09269920e-02f, 2.80522238e-02f, 2.59272773e-02f, 9.57386792e-02f, 6.92333728e-02f, -7.64516890e-02f, -8.12061597e-03f, -8.25430974e-02f, 9.72288623e-02f,
  -1.14048503e-01f, 9.35424417e-02f, -4.11684513e-02f, -1.38983026e-01f, 1.36506082e-02f, 9.59271342e-02f, 4.17902097e-02f, 2.51581315e-02f, -4.47070897e-02f, -1.50954396e-01f,
  -7.34617002e-03f, -1.24424152e-01f, 8.79442226e-03f, -1.00394059e-02f, -1.74043588e-02f, -2.69118370e-03f, 5.98934898e-03f, -7.55090341e-02f, -8.62537473e-02f, 6.01269491e-02f,
  -1.27231941e-01f, 3.75014618e-02f, 1.76871624e-02f, 1.97748199e-01f, -8.46426636e-02f, 1.69578880e-01f, 8.92551988e-02f, 7.28566721e-02f, -2.23788247e-03f, 1.02843560e-01f,
  1.62468962e-02f, 1.99344959e-02f, -1.26068607e-01f, 1.33428648e-01f, -3.46963704e-02f, 2.44969293e-01f, 1.25359967e-01f, -2.76782870e-01f, -2.64379084e-01f, -1.09480545e-01f,
  3.22644144e-01f, 8.25900137e-02f, 2.84986198e-02f, -1.33408783e-02f, 1.56671014e-02f, 2.97205985e-01f, -9.92127359e-02f, 6.14363886e-02f, -1.10287696e-01f, 9.73427743e-02f,
  1.95417227e-03f, -2.96042375e-02f, 5.33061698e-02f, 3.08346897e-01f, 1.43140391e-01f, -9.85356327e-03f, 2.69914791e-02f, 8.51666033e-02f, -1.45176843e-01f, 1.07866237e-02f,
  3.75828445e-02f, 5.95502220e-02f, -1.43369257e-01f, -9.41800103e-02f, 2.54800647e-01f, -1.30813703e-01f, 1.33756757e-01f, 4.82997745e-02f, 1.81832805e-01f, -1.22890733e-01f,
  -1.11997820e-01f, 6.11635111e-02f, -1.00570560e-01f, -1.91662222e-01f, 6.21127225e-02f, 1.85234576e-01f, -5.82710579e-02f, 2.55784363e-01f, 6.11572750e-02f, -5.26924506e-02f,
  6.55897856e-02f, -9.44349542e-02f, -3.40630524e-02f, -2.28670940e-01f, -6.91713244e-02f, 4.72050458e-02f, 3.22284475e-02f, 7.59794936e-02f, -1.02726653e-01f, 1.19419962e-01f,
  -1.64535586e-02f, 1.41465887e-01f, 1.41658649e-01f, -1.32236145e-02f, -6.50197174e-03f, 1.35967672e-01f, 1.46303549e-01f, -1.81565419e-01f, -3.10608670e-02f, -1.15145117e-01f,
  5.31108752e-02f, 9.06661674e-02f, 1.57472372e-01f, -2.52167298e-03f, 1.14025168e-01f, 1.64688766e-01f, -1.14546165e-01f, 1.40180856e-01f, -1.01104885e-01f, -4.83722240e-02f,
  4.16732319e-02f, -4.58007939e-02f, -1.34497285e-01f, 4.77999523e-02f, -6.87820911e-02f, 1.81338713e-02f, -2.93658078e-02f, 6.10121340e-02f, -5.94856888e-02f, -3.61016244e-02f,
  5.72861061e-02f, 5.55461869e-02f, -3.53008211e-02f, 5.85563853e-02f, 7.62287304e-02f, -7.25664273e-02f, 5.42607382e-02f, 4.08412740e-02f, 6.82721660e-02f, 1.65738046e-01f,
  1.18505668e-04f, -6.57624230e-02f, 7.70256622e-03f, 7.32139358e-03f, -7.70401061e-02f, -2.04187445e-02f, -2.40250155e-02f, -7.34572187e-02f, -5.22432849e-02f, 1.00161796e-02f,
  -1.55007303e-01f, 2.69150436e-02f, -7.84780979e-02f, 5.40646091e-02f, -1.61777455e-02f, -7.28636747e-03f, -6.69161454e-02f, 2.11319417e-01f, -2.48211212e-02f, -1.56531274e-01f,
  -9.10684988e-02f, 1.12423398e-01f, -1.25602633e-02f, -6.92699850e-02f, 1.54310778e-01f, 1.44981340e-01f, 2.92514041e-02f, 1.76223535e-02f, 1.35830656e-01f, -7.41673931e-02f,
  -2.65785486e-01f, 2.26280570e-01f, -8.91797692e-02f, 5.21307886e-02f, 2.68821400e-02f, 1.74522683e-01f, -1.09135658e-01f, -1.99931383e-01f, 7.33681247e-02f, -6.89718947e-02f,
  3.68125960e-02f, 9.93640050e-02f, 3.86229344e-02f, 2.64858995e-02f, -4.78420220e-02f, 3.82821634e-02f, 1.49982378e-01f, 1.48945108e-01f, 3.48926298e-02f, -5.43250144e-02f,
  -3.94204482e-02f, -1.16964221e-01f, 9.95248109e-02f, -8.54290649e-02f, -6.90406933e-02f, 1.19978018e-01f, -6.12641834e-02f, 2.70960908e-02f, 5.54849878e-02f, -9.90753248e-02f,
  -1.70996152e-02f, 9.99556854e-02f, 3.21594179e-02f, -1.26846701e-01f, -6.46142066e-02f, 3.68450671e-01f, 3.33111696e-02f, 1.11548990e-01f, 3.91542241e-02f, -1.41644835e-01f,
  1.18417516e-01f, 1.85293779e-02f, 1.26024321e-01f, 2.80970568e-03f, 4.13046777e-01f, 1.13416962e-01f, 1.65835828e-01f, -1.55200794e-01f, 2.22582504e-01f, -3.36941704e-02f,
  -2.86192708e-02f, -1.06782436e-01f, -6.20109309e-03f, 1.08701840e-01f, 2.30767652e-01f, 5.84871583e-02f, 4.69187722e-02f, -1.10204563e-01f, 1.13515544e-03f, -8.57979432e-02f,
  7.22839460e-02f, -7.20482841e-02f, 3.31984041e-03f, 2.63743736e-02f, 9.77670401e-02f, 5.54456823e-02f, -3.04130316e-02f, 1.79243997e-01f, 4.33168970e-02f, 7.54405856e-02f,
  9.93797705e-02f, 2.60006726e-01f, 2.26698905e-01f, 1.56886235e-01f, -1.15623191e-01f, 5.91842532e-02f, -1.17672831e-02f, -5.80347097e-03f, 1.27087653e-01f, 1.47562623e-01f,
  3.96217741e-02f, -2.84009706e-02f, -1.93194468e-02f, 1.65061615e-02f, -1.01798344e-02f, 3.10293809e-02f, -1.12773649e-01f, -1.03575317e-02f, -4.63023782e-03f, -8.82632583e-02f,
  3.80124711e-02f, 2.99736232e-01f, 5.01634702e-02f, 5.38256811e-03f, 4.04133946e-02f, 2.27196030e-02f, -2.79993713e-02f, 1.00478806e-01f, 1.08587369e-01f, 1.50992163e-03f,
  -3.55800949e-02f, 6.96679577e-02f, 4.14430648e-02f, 3.45952548e-02f, 1.02761209e-01f, 3.37345153e-02f, 5.47660254e-02f, -1.15596801e-01f, -1.56205863e-01f, 1.06876932e-01f,
  -6.93030953e-02f, 1.39870703e-01f, -3.91471609e-02f, -2.56544780e-02f, -1.10007964e-01f, 1.64456397e-01f, -1.08986951e-01f, -1.91263825e-01f, 1.12395562e-01f, -9.60308984e-02f,
  -1.87266424e-01f, -1.02090456e-01f, 4.02438864e-02f, -1.10177368e-01f, 1.46116823e-01f, -5.43203624e-03f, -1.84493780e-01f, 1.01280995e-01f, -3.42128314e-02f, 2.58066203e-03f,
  -1.44603088e-01f, 4.22551781e-02f, -1.37106374e-01f, 1.84534207e-01f, -7.83432946e-02f, -4.41060476e-02f, 3.22769322e-02f, -8.12171623e-02f, 4.71411645e-02f, 3.28123244e-03f,
  6.12789802e-02f, -1.35759324e-01f, 1.03568278e-01f, 1.56065151e-01f, 9.13781151e-02f, 7.15782121e-02f, 1.58379655e-02f, -1.59260258e-02f, 1.07290052e-01f, 2.70845219e-02f,
  3.43702696e-02f, 3.67726833e-02f, -5.66764250e-02f, 5.47791161e-02f, -3.45580716e-04f, 1.43557861e-01f, 4.73992303e-02f, 1.47011265e-01f, -2.29857620e-02f, 5.50001487e-02f,
  -1.50513366e-01f, 1.89307854e-01f, 4.77370508e-02f, -2.48207990e-02f, 8.20369273e-02f, -2.29008831e-02f, -7.53734121e-03f, -5.74517474e-02f, -1.04188569e-01f, -3.12665999e-02f,
  1.35117158e-01f, 5.85836358e-02f, -1.04659066e-01f, 7.48974457e-02f, -1.02493115e-01f, 1.44282162e-01f, 9.87846553e-02f, -7.86820203e-02f, 5.84339947e-02f, -8.78996477e-02f,
  -1.59427226e-02f, 2.27216184e-02f, 6.32028282e-02f, -1.05168901e-01f, 6.32403120e-02f, 2.30597556e-02f, -5.26477257e-03f, 1.48739710e-01f, 1.29636511e-01f, 8.44250098e-02f,
  1.56287655e-01f, 1.66378945e-01f, 9.61016640e-02f, -7.59947172e-04f, -9.89888757e-02f, -2.49314949e-01f, 7.82414246e-03f, -1.42418861e-01f, -1.81226153e-02f, 1.23748235e-01f,
  -1.14652421e-02f, 1.41817287e-01f, 1.47670135e-01f, 6.88503385e-02f, -1.58775121e-01f, -1.38499439e-01f, 1.47472695e-02f, 4.10863943e-02f, 6.15391601e-03f, -4.38393727e-02f,
  9.13202167e-02f, 2.10530117e-01f, -1.52455643e-01f, 5.75725697e-02f, -4.27066255e-03f, -9.40381885e-02f, -5.13765663e-02f, 8.01148936e-02f, 3.93778682e-02f, 1.63100138e-01f,
  1.87819481e-01f, -1.31391391e-01f, 1.11179650e-01f, -1.19374217e-02f, 6.58496842e-02f, 1.70869499e-01f, 1.56436235e-01f, -1.88924268e-01f, 1.88190769e-02f, -3.46236266e-02f,
  9.38570052e-02f, -9.02992487e-02f, 6.30229115e-02f, 3.94448377e-02f, 2.48222351e-02f, 4.30183671e-02f, 2.87915710e-02f, -3.02316621e-02f, 2.36268863e-02f, 2.54900157e-01f,
  -6.61440864e-02f, 6.80025592e-02f, -1.08283527e-01f, 1.72195435e-01f, 6.54090717e-02f, 9.91842151e-02f, -4.54122685e-02f, 9.61435884e-02f, 3.65753844e-03f, 1.11123778e-01f,
  -7.07034618e-02f, -8.21138769e-02f, -5.96423447e-02f, -1.20980991e-02f, 6.55035973e-02f, -1.10087626e-01f, 6.15421087e-02f, 7.49943256e-02f, -8.20135325e-02f, 6.91215247e-02f,
  -8.00191313e-02f, -7.81800523e-02f, 8.13503284e-03f, -1.43619463e-01f, 8.54236931e-02f, -1.29876018e-01f, -4.40071523e-02f, -1.96219478e-02f, -1.15487523e-01f, 4.11631614e-02f,
  -3.49490754e-02f, 7.18108639e-02f, -7.04609454e-02f, 9.28709432e-02f, -4.91377153e-02f, 9.45785865e-02f, -1.25318170e-01f, 2.17737049e-01f, -9.81830731e-02f, -8.96693692e-02f,
  -6.33739159e-02f, -1.03318123e-02f, 8.84285718e-02f, 4.04973375e-03f, -8.89906436e-02f, -2.13601459e-02f, -1.00954652e-01f, 1.38592310e-02f, -1.28792658e-01f, -7.86862373e-02f,
  1.02067336e-01f, 7.02802539e-02f, 5.05740494e-02f, -9.83349420e-03f, 4.57213260e-02f, 1.01893291e-01f, -3.13584358e-02f, -7.97504783e-02f, 1.29973605e-01f, 1.13636479e-01f,
  2.01942772e-03f, 1.83925673e-01f, 3.47269699e-02f, 5.96845113e-02f, 1.02304585e-01f, 2.46472768e-02f, -3.83354202e-02f, -4.55343165e-02f, -3.59526388e-02f, -8.33005160e-02f,
  -1.04358360e-01f, 3.34857069e-02f, 1.45490989e-01f, 2.65367538e-01f, 2.49417305e-01f, 6.85514137e-02f, -5.84818423e-02f, 2.48217702e-01f, 2.84875184e-01f, -6.31254120e-03f,
  -3.04867681e-02f, -1.53283384e-02f, -4.10754383e-02f, 1.84787452e-01f, 1.18998505e-01f, 6.82738889e-03f, 6.60337135e-02f, -1.15394153e-01f, 2.18958095e-01f, 3.00282543e-03f,
  -4.42506671e-02f, -3.81205641e-02f, 1.58477426e-01f, 2.59662688e-01f, -1.53258070e-01f, -5.14063053e-02f, 5.96796051e-02f, 1.55874997e-01f, -9.24630240e-02f, -1.49074957e-01f,
  -5.78016602e-02f, 1.78693593e-01f, 6.54434115e-02f, 4.95572537e-02f, 8.51301104e-02f, 1.88556779e-02f, -4.89985682e-02f, -1.82784826e-01f, 1.29474357e-01f, -1.26664387e-03f,
  -4.82280068e-02f, -6.35588095e-02f, 2.49016240e-01f, -8.62780511e-02f, 1.88750625e-01f, 2.14428380e-02f, 1.51854292e-01f, -2.70700604e-02f, -6.24494534e-03f, -3.98341380e-02f,
  6.90181479e-02f, -1.99193791e-01f, 3.88133302e-02f, -5.74373268e-02f, -2.16291081e-02f, 2.38589481e-01f, 1.28703695e-02f, -1.47332862e-01f, 1.82792157e-01f, 3.10690459e-02f,
  2.15094276e-02f, -1.51594490e-01f, -1.21653192e-01f, -1.35225626e-02f, -7.06221089e-02f, -8.27264879e-03f, -4.51054461e-02f, 1.50921106e-01f, 1.75187632e-01f, 2.39908397e-01f,
  3.92001309e-02f, 1.26387581e-01f, 9.83155221e-02f, 1.74521223e-01f, -3.07789773e-01f, 3.39273602e-01f, -2.10574031e-01f, 6.58925846e-02f, -3.74464124e-01f, 3.62205446e-01f,
  1.26240507e-01f, -1.70500189e-01f, -1.56935558e-01f, -1.71073809e-01f, -8.29166919e-02f, 1.63736552e-01f, 9.50943455e-02f, -5.32987043e-02f, 2.02227682e-02f, -1.14894971e-01f,
  1.02866396e-01f, 7.69715756e-02f, 7.60251731e-02f, -5.72753251e-02f, 1.44009456e-01f, 4.07817736e-02f, 2.99430788e-02f, -7.90374577e-02f, -1.30305933e-02f, -5.31042553e-02f,
  -1.49363637e-01f, -1.21000640e-01f, -4.63364534e-02f, -1.79110155e-01f, -1.18132740e-01f, 1.71658322e-01f, -2.22729787e-01f, -1.02849782e-01f, -1.65246338e-01f, 3.59806642e-02f,
  -5.56218065e-02f, 2.09022626e-01f, -3.41312587e-02f, -1.48836359e-01f, -4.69750874e-02f, 2.66870372e-02f, 2.65416726e-02f, 7.38527998e-02f, -7.36403931e-03f, 8.94269422e-02f,
  8.15618187e-02f, -2.13308558e-01f, 3.24309826e-01f, 1.38572216e-01f, 8.18640217e-02f, -1.02323800e-01f, 1.64639667e-01f, -3.31964791e-02f, -6.13664277e-02f, -1.15644351e-01f,
  9.92152989e-02f, -2.47560829e-01f, 1.99701786e-01f, 2.92623714e-02f, 1.13176025e-01f, 1.67672291e-01f, 1.85901493e-01f, 1.91400692e-01f, -5.25313839e-02f, 9.76850539e-02f,
  6.53304718e-03f, 6.32958859e-02f, 2.32693359e-01f, -7.11843222e-02f, 4.35686707e-02f, 1.43225923e-01f, 2.41152123e-01f, -6.16635419e-02f, -9.82635096e-02f, -2.72189118e-02f,
  -5.10632582e-02f, 1.40047535e-01f, 2.85052415e-02f, -8.42853859e-02f, -9.71644297e-02f, 1.78353876e-01f, -8.28269720e-02f, -5.66756576e-02f, 2.22848114e-02f, 1.55712336e-01f,
  1.50947854e-01f, 1.23615498e-02f, 3.29383984e-02f, -8.29640627e-02f, -1.59983277e-01f, -2.18293697e-01f, -5.06249107e-02f, 4.88634892e-02f, -1.24330521e-01f, 8.89288038e-02f,
  -1.38407633e-01f, -1.67208627e-01f, 1.85907066e-01f, -1.26994714e-01f, -3.00402101e-02f, -2.70877127e-02f, -7.71336481e-02f, -1.24819465e-01f, 1.22783538e-02f, -1.60246462e-01f,
  -8.34082514e-02f, -9.13838446e-02f, 1.16387859e-01f, 1.33602679e-01f, 1.48420066e-01f, -1.34979963e-01f, 1.90663427e-01f, 1.24170259e-01f, 7.37612322e-02f, 5.91959246e-02f,
  -1.05736330e-01f, 3.04608177e-02f, -9.26246196e-02f, -4.72373590e-02f, 1.13651291e-01f, 1.00622222e-01f, 3.89845446e-02f, -2.19479185e-02f, -2.18551829e-01f, 2.03856796e-01f,
  -8.84568766e-02f, 8.73105973e-02f, 5.37322462e-02f, -2.04421535e-01f, 2.42085651e-01f, 5.90176992e-02f, 4.02016416e-02f, -3.83420698e-02f, 2.37786293e-01f, -6.94004148e-02f,
  3.84037346e-02f, 6.51180893e-02f, 2.47754324e-02f, -6.22014143e-02f, -9.59185958e-02f, -1.19187370e-01f, -8.14552903e-02f, 4.47185710e-02f, 6.86155539e-03f, 3.49119306e-02f,
  1.75881892e-01f, -7.94350803e-02f, 1.02131285e-01f, 8.85832235e-02f, 1.28523083e-02f, -1.55621812e-01f, 3.14072222e-02f, 1.33802608e-01f, 1.72289521e-01f, -4.06292975e-02f,
  -4.89575714e-02f, 4.05461639e-02f, 7.36802518e-02f, -1.56592712e-01f, 7.72193167e-03f, -1.56019768e-02f, 4.46912795e-02f, -1.52884036e-01f, 1.18165039e-01f, 1.10815011e-03f,
  1.52203947e-01f, 1.29751787e-01f, -8.04944709e-02f, 9.21564270e-03f, -1.00668430e-01f, 3.01112421e-03f, -3.47992592e-02f, 1.70429364e-01f, 2.25700047e-02f, 6.16551610e-03f,
  -1.84464827e-02f, -1.71329021e-01f, -1.21852756e-01f, -4.99874353e-02f, 6.82180421e-03f, -3.23304236e-02f, 1.37839884e-01f, -6.64590076e-02f, 1.33804262e-01f, 1.70313433e-01f,
  1.85905650e-01f, 2.69680202e-01f, 2.40283623e-01f, 5.84191009e-02f, 1.34056941e-01f, 8.36948082e-02f, -1.04424201e-01f, 5.80462702e-02f, -8.35513696e-02f, -2.51408726e-01f,
  -1.77786537e-02f, -1.35005325e-01f, 7.16108084e-02f, -3.19381952e-02f, -3.18418927e-02f, 6.95658326e-02f, 1.21539615e-01f, -1.00330532e-01f, 9.04462188e-02f, -1.22392684e-01f,
  -6.04078323e-02f, -1.66945043e-03f, 2.28033084e-02f, -3.13044675e-02f, -3.72838080e-02f, -3.77212353e-02f, -4.73025814e-02f, 1.09831519e-01f, 1.24520719e-01f, -1.07302897e-01f,
  2.29665730e-02f, 1.70178965e-01f, -9.79607925e-02f, -1.57174505e-02f, 1.14793979e-01f, -1.19051948e-01f, -7.58021176e-02f, 3.24467644e-02f, 1.54815063e-01f, -1.15363948e-01f,
  1.57255679e-01f, -1.53778568e-01f, 1.75994635e-02f, -1.18267454e-01f, -8.77409428e-02f, 8.94125029e-02f, -4.17659581e-02f, 6.37849942e-02f, -7.82697229e-04f, -1.45579353e-02f,
  -1.57048315e-01f, -8.93767644e-03f, 1.64123669e-01f, -2.13894597e-03f, -1.88685711e-02f, 1.19474515e-01f, -7.30137527e-03f, 3.59062701e-02f, 2.27935150e-01f, 1.89063877e-01f,
  -1.49011940e-01f, -1.17089204e-01f, -8.60644132e-02f, -7.02730864e-02f, -8.65652636e-02f, -1.59199655e-01f, -2.56147444e-01f, 4.99832742e-02f, -3.41863520e-02f, -5.25478832e-02f,
  -2.30501816e-02f, -1.59007788e-01f, 2.43841603e-01f, 1.02906793e-01f, -1.67662427e-01f, -4.24275100e-01f, -2.35928833e-01f, -1.49264440e-01f, 2.25645661e-01f, 6.17114478e-04f,
  -8.36000144e-02f, -5.32110333e-02f, 2.32842013e-01f, 3.78909886e-01f, -2.08478108e-01f, 1.25461951e-01f, 1.14405259e-01f, -5.43428138e-02f, -1.35608137e-01f, -1.59093678e-01f,
  -7.47636929e-02f, 1.41517803e-01f, -8.13492090e-02f, 1.08805280e-02f, -9.70494077e-02f, -4.79495563e-02f, 1.09865807e-01f, -1.30838677e-01f, -1.68685675e-01f, -1.29114604e-03f,
  -1.23901844e-01f, -2.73531914e-01f, 4.07117009e-01f, -1.67024776e-01f, -3.35124508e-02f, 5.15062101e-02f, 2.13499472e-01f, -7.72736445e-02f, -2.68776366e-03f, 1.33058429e-01f,
  1.03727272e-02f, 2.43075155e-02f, -1.63621336e-01f, 1.63345784e-01f, 2.02206582e-01f, 4.65817988e-01f, -1.26598582e-01f, 1.46039397e-01f, 8.90107602e-02f, -2.45094225e-02f,
  -1.51084345e-02f, -9.37977135e-02f, -1.03750445e-01f, 1.95925757e-01f, -1.90806344e-01f, 4.87084128e-02f, -1.93467140e-02f, 1.47214085e-01f, 1.11967385e-01f, -1.06986329e-01f,
  -1.20713189e-01f, 1.00338059e-02f, -1.99742034e-01f, -3.08249658e-03f, 1.13652214e-01f, -4.94661890e-02f, 2.78502017e-01f, 3.85976993e-02f, 6.38927892e-02f, -9.37727243e-02f,
  1.37271196e-01f, 1.01594537e-01f, 2.97612309e-01f, 8.68812427e-02f, -5.88714965e-02f, 1.09304540e-01f, 8.59965906e-02f, -4.63008992e-02f, 7.94630200e-02f, -1.26000002e-01f,
  -1.81602806e-01f, 1.03468478e-01f, 8.02185982e-02f, -1.34863675e-01f, 9.42090824e-02f, 2.14622274e-01f, 7.11320192e-02f, 1.24425571e-02f, -7.24977031e-02f, -5.14003672e-02f,
  2.65205711e-01f, -1.37969628e-01f, -1.14477091e-01f, 1.73076510e-01f, -3.86653841e-02f, -2.81323493e-01f, -8.74208882e-02f, -1.49640724e-01f, 6.89536259e-02f, -6.91883191e-02f,
  1.06402576e-01f, 4.86604907e-02f, 1.12514399e-01f, 6.46846741e-02f, -2.41573974e-02f, -8.96211155e-03f, 2.50434559e-02f, 1.57251414e-02f, -1.53828889e-01f, 1.29219398e-01f,
  -9.49694514e-02f, 1.43448710e-01f, -8.49625692e-02f, -1.28665596e-01f, -1.91187626e-03f, 4.58013192e-02f, -1.18175812e-01f, -4.94826548e-02f, 5.63783608e-02f, -1.35889173e-01f,
  -4.77546006e-02f, 2.57058918e-01f, 2.15688109e-01f, 7.47281238e-02f, 1.30511627e-01f, 1.98325828e-01f, 1.15877934e-01f, 2.29821190e-01f, -2.46047422e-01f, 1.47738501e-01f,
  -5.06521538e-02f, 2.18288749e-01f, 1.25959471e-01f, -4.46614139e-02f, -1.23389542e-01f, -8.06904957e-02f, 2.97697663e-01f, 5.05206212e-02f, -1.08731061e-01f, -6.97909296e-02f,
  2.15873793e-01f, 7.53375590e-02f, -1.89878508e-01f, -1.42629758e-01f, -4.20270720e-03f, 1.25634760e-01f, -1.34117842e-01f, -9.77557525e-03f, -1.60270810e-01f, 1.75408274e-01f,
  -3.73459049e-02f, 6.08827099e-02f, -7.37982839e-02f, -1.28104225e-01f, -4.87200506e-02f, 2.49313451e-02f, -2.61579156e-02f, 1.08098030e-01f, -2.08158065e-02f, -1.27654314e-01f,
  -1.23244017e-01f, -1.46864891e-01f, 1.51634201e-01f, -7.58092403e-02f, 2.47770920e-02f, -3.93397510e-02f, 4.88234870e-02f, -1.29869223e-01f, -4.35470566e-02f, -4.59447913e-02f,
  6.35959655e-02f, -1.15458310e-01f, -2.73047328e-01f, -2.20789425e-02f, -2.67062988e-03f, -9.46906134e-02f, 1.44746631e-01f, 2.05233768e-01f, 1.84655506e-02f, 2.69330665e-02f,
  -5.50525971e-02f, 6.57455474e-02f, -4.68047559e-02f, 7.61868283e-02f, 1.05439983e-01f, 2.52427850e-02f, 1.79243669e-01f, 8.08697268e-02f, -5.72287180e-02f, 2.62302637e-01f,
  1.66578755e-01f, 1.36948293e-02f, -2.58014584e-03f, -2.81110466e-01f, 2.99389899e-01f, -1.12701438e-01f, 2.02181652e-01f, -9.27391127e-02f, 9.24905986e-02f, 2.40709409e-02f,
  1.34272784e-01f, -1.43881040e-02f, 2.22467259e-02f, -1.07513271e-01f, -7.28012100e-02f, 2.87714396e-02f, 1.22285716e-01f, -8.56587291e-03f, -1.80012155e-02f, -3.63849401e-02f,
  9.44457427e-02f, -1.76605821e-01f, 1.13064021e-01f, 1.75829455e-02f, 1.27862871e-01f, 5.34471497e-02f, -2.62024836e-03f, 6.99086636e-02f, 2.31269017e-01f, -3.91033851e-02f,
  -2.25067195e-02f, 1.14365771e-01f, 7.42968917e-02f, 9.75170061e-02f, -2.98836473e-02f, -1.37210086e-01f, 1.68757543e-01f, -3.86168435e-02f, 8.71753246e-02f, -1.27179563e-01f,
  -3.96356499e-03f, -4.83782738e-02f, 3.84973399e-02f, -4.25813496e-02f, 1.18729956e-01f, -9.50888619e-02f, 7.20079988e-02f, 1.12994783e-01f, 9.81909111e-02f, 1.81710303e-01f,
  -1.79325402e-01f, 1.06166430e-01f, -7.26332068e-02f, 1.64461453e-02f, 8.40306357e-02f, -1.05708487e-01f, 1.39375314e-01f, 7.21375570e-02f, 2.10914165e-01f, 8.93959776e-02f,
  8.92556831e-02f, 3.03764403e-01f, 3.24605733e-01f, 1.11212872e-01f, 2.11027816e-01f, 2.28508323e-01f, -2.74514407e-02f, 8.34382251e-02f, -2.72657007e-01f, -7.33644590e-02f,
  -1.27095655e-01f, -5.67649677e-02f, -4.67612706e-02f, -2.28050604e-01f, -2.37958953e-01f, -1.78627133e-01f, 9.92235914e-02f, -9.44664329e-02f, 6.87519386e-02f, -9.86769125e-02f,
  3.36276460e-03f, 3.51084433e-02f, 1.04884356e-01f, 2.88263126e-03f, -1.15762942e-01f, 1.85022429e-01f, -4.56799269e-02f, 1.54637918e-01f, -1.47775961e-02f, -1.23211183e-01f,
  1.03632331e-01f, 2.20239103e-01f, 1.72613338e-01f, 1.43085584e-01f, 2.42052689e-01f, 4.30933312e-02f, -5.74262589e-02f, 2.69311070e-01f, -2.44848579e-01f, 3.46419066e-02f,
  -9.32755023e-02f, 1.08723377e-03f, 5.10400720e-02f, 8.70130360e-02f, -1.86526179e-02f, 7.03113899e-02f, -4.77291197e-02f, -1.43177122e-01f, 8.36789701e-03f, -3.61654572e-02f,
  -1.43811703e-01f, -5.03446236e-02f, 4.06039730e-02f, 1.60599872e-01f, 1.59555987e-01f, 1.86373234e-01f, 5.52140810e-02f, -7.74040818e-02f, 2.12020576e-01f, -8.16331729e-02f,
  -1.14909202e-01f, 2.90911883e-01f, 8.13167021e-02f, 1.13760166e-01f, -1.01609372e-01f, -4.85889018e-02f, -1.49212768e-02f, -8.54387358e-02f, -1.56807885e-01f, -1.40947431e-01f,
  -2.31486764e-02f, -2.51647597e-03f, -1.00971431e-01f, -8.36654007e-02f, 7.40900561e-02f, 1.27054200e-01f, 1.74312498e-02f, -9.14464071e-02f, -5.06586060e-02f, 4.13179174e-02f,
  5.72565980e-02f, 6.34273291e-02f, -1.21740505e-01f, -5.29568866e-02f, -9.06584337e-02f, 8.83538425e-02f, 1.80932079e-02f, -8.17498341e-02f, 7.23023340e-02f, 1.56516567e-01f,
  1.92390960e-02f, -8.41991827e-02f, -5.14609329e-02f, 8.40539932e-02f, -7.23911524e-02f, 7.40012601e-02f, 2.51187123e-02f, 7.64357895e-02f, 1.19274296e-01f, 7.99386203e-02f,
  6.43574446e-02f, 1.52135836e-02f, 9.57228392e-02f, -3.56234834e-02f, 7.77519569e-02f, 1.37427345e-01f, -7.44103715e-02f, -8.38717744e-02f, -4.39274125e-02f, 1.19127825e-01f,
  1.02153420e-01f, 4.84396331e-02f, 4.45092395e-02f, 4.13146392e-02f, -3.43014151e-02f, 5.87307522e-03f, 7.05609545e-02f, -6.20641559e-02f, -8.72461945e-02f, -2.11490877e-02f,
  -1.15983278e-01f, -7.46810809e-02f, 9.72712338e-02f, 2.88321283e-02f, 1.20602496e-01f, 6.69606328e-02f, -9.45584327e-02f, 1.58122391e-01f, 1.99489161e-01f, -1.25959963e-01f,
  -7.10106492e-02f, -9.37387124e-02f, 2.44092569e-02f, 1.14225358e-01f, 8.13335404e-02f, 1.06323138e-02f, 8.89780670e-02f, -1.44389756e-02f, 1.90403566e-01f, 4.34185145e-03f,
  1.57679081e-01f, 1.57046720e-01f, 2.52564460e-01f, 1.06397584e-01f, 9.84347910e-02f, 3.22729908e-02f, -1.51083127e-01f, -1.36295795e-01f, 1.92016754e-02f, 4.59132120e-02f,
  -7.51952752e-02f, 1.87675969e-03f, 5.44392876e-02f, 1.03029206e-01f, -3.03413179e-02f, 1.79819055e-02f, 6.24638274e-02f, 9.81597528e-02f, -1.07838012e-01f, -4.33073640e-02f,
  -9.55286995e-03f, -3.59870903e-02f, 1.52374893e-01f, 1.19633287e-01f, 4.22291644e-02f, 1.01585552e-01f, 1.06281571e-01f, -3.41493562e-02f, -4.84175608e-02f, 1.00877568e-01f,
  2.65647825e-02f, -1.00246988e-01f, 7.02520832e-02f, -6.22615516e-02f, 6.75542057e-02f, -4.00367267e-02f, -1.27882017e-02f, -1.29688263e-01f, 1.86412260e-01f, -1.53072566e-01f,
  -3.64841335e-02f, 4.75599617e-02f, -6.39056638e-02f, 1.04442693e-01f, 6.32080287e-02f, 5.96623085e-02f, -4.29462343e-02f, 9.87808183e-02f, 2.26296514e-01f, -5.92032298e-02f,
  -1.04531400e-01f, 8.46699998e-02f, 7.39396811e-02f, -1.56770218e-02f, -1.25280410e-01f, 7.20046386e-02f, -2.91334763e-02f, -1.73249170e-01f, -1.33380145e-01f, 7.56612420e-03f,
  -9.82732549e-02f, 7.88504854e-02f, -1.84817404e-01f, -2.46288516e-02f, -6.81972727e-02f, 4.30596136e-02f, 4.69173640e-02f, -1.52279899e-01f, 7.99096227e-02f, 3.26289982e-02f,
  -7.68529475e-02f, -1.43356025e-02f, 9.84072406e-03f, -2.65943464e-02f, 6.99594766e-02f, 1.68271527e-01f, 3.70838195e-02f, -3.58875692e-02f, 1.41794607e-01f, 1.08496711e-01f,
  -2.01003905e-02f, -5.69316372e-02f, -1.93946697e-02f, 9.24494267e-02f, 2.24262223e-01f, -6.00341260e-02f, -1.17025495e-01f, 1.22107483e-01f, 2.89185289e-02f, 1.05944797e-01f,
  -1.00121088e-01f, 7.46011063e-02f, -9.69500020e-02f, -1.84737556e-02f, 9.10426229e-02f, 1.60023451e-01f, -6.66935509e-03f, 6.67830855e-02f, -2.41597686e-02f, 7.34993741e-02f,
  1.31010443e-01f, 1.01723813e-01f, -7.83677846e-02f, 1.85573299e-03f, 4.40177182e-03f, 1.82102341e-02f, 2.26552505e-02f, 1.13922313e-01f, 1.19410843e-01f, -1.42555013e-02f,
  1.16206504e-01f, 1.28255002e-02f, 4.24250923e-02f, 1.10749669e-01f, 8.60604271e-02f, 2.45236456e-01f, 6.10551126e-02f, 1.48348272e-01f, 2.16099024e-01f, -6.90733716e-02f,
  -9.96751245e-03f, 1.43355489e-01f, 2.69195344e-02f, 1.25670314e-01f, -1.62387699e-01f, -4.09947382e-03f, 9.59620774e-02f, -1.34114772e-01f, -6.84538633e-02f, 9.12833959e-03f,
  1.72463909e-01f, -8.52643698e-02f, 1.51699141e-01f, -5.57927042e-02f, 9.55385640e-02f, -4.04951125e-02f, 1.04281105e-01f, 5.50776795e-02f, -1.95069157e-03f, 5.29098213e-02f,
  -2.07444355e-02f, -6.15234040e-02f, -9.61336866e-02f, -3.46504040e-02f, -4.81259376e-02f, 2.71443762e-02f, 3.95612530e-02f, 1.04976989e-01f, -5.04957587e-02f, -7.59403408e-02f,
  -3.91890928e-02f, -7.06014112e-02f, -1.09216057e-01f, 1.04034171e-01f, -6.66450635e-02f, 1.45904168e-01f, 2.69886591e-02f, -1.27743734e-02f, 6.13821931e-02f, -6.52324557e-02f,
  -1.02569990e-01f, 7.73384497e-02f, 5.92990853e-02f, -5.66485375e-02f, -2.96904519e-02f, 6.19958453e-02f, -4.60084975e-02f, -1.09520212e-01f, 1.28228134e-02f, 1.46262292e-02f,
  1.25190184e-01f, -1.24055237e-01f, -1.01078220e-01f, 9.00031775e-02f, -2.58162450e-02f, -9.25557222e-04f, -4.12030704e-02f, -7.65511394e-02f, -1.45687968e-01f, 2.06582710e-01f,
  1.79570809e-01f, 2.27292463e-01f, 8.48646164e-02f, 9.60654169e-02f, 1.20539047e-01f, 3.87365848e-01f, -6.28066286e-02f, -1.62593290e-01f, 3.73858750e-01f, -1.70648977e-01f,
  -7.60030970e-02f, -1.34623975e-01f, 1.25285909e-01f, -6.67673070e-03f, 9.59654301e-02f, 1.27416179e-02f, -1.20919742e-01f, 2.95011550e-02f, 1.59622505e-01f, -1.19581588e-01f,
  2.18702406e-02f, -1.50823742e-01f, 6.31618127e-02f, -1.28052905e-01f, -4.20117937e-02f, -6.60671445e-04f, -1.24576241e-01f, -1.01371650e-02f, 1.80324212e-01f, -2.32375991e-02f,
  7.94428065e-02f, 1.99758768e-01f, 2.64767352e-02f, -2.59359807e-01f, -1.34841695e-01f, 5.50259948e-02f, -4.30714190e-02f, 4.99611162e-02f, 1.32882029e-01f, -2.40135431e-01f,
  1.00280963e-01f, 3.93643007e-02f, 8.97680782e-03f, -2.40447208e-01f, -3.21250707e-02f, 1.78780332e-01f, -7.74807706e-02f, 2.10008398e-01f, -3.49198394e-02f, 1.95132904e-02f,
  5.33019891e-04f, 1.38681129e-01f, 1.75596789e-01f, -6.11712225e-02f, -1.74807027e-01f, -6.29976392e-02f, -6.73176944e-02f, 7.54076019e-02f, 2.62043625e-01f, 2.26648450e-01f,
  -1.27967581e-01f, -5.36793433e-02f, 2.86361784e-01f, -1.07571453e-01f, -3.01897824e-02f, 1.65659502e-01f, 2.71320105e-01f, 4.75828769e-03f, -2.43535295e-01f, 5.66736758e-02f,
  -2.41030842e-01f, 9.41035450e-02f, -3.63797545e-02f, 2.51417965e-01f, -2.83717752e-01f, 4.85224687e-02f, 4.01652269e-02f, 2.64493003e-02f, 6.01545982e-02f, -1.18281625e-01f,
  -2.61305459e-02f, 1.04495838e-01f, -1.71821192e-01f, -1.56055972e-01f, 2.08801478e-02f, 2.43707031e-01f, 6.65936098e-02f, -1.07868135e-01f, -1.05542742e-01f, 6.46195859e-02f,
  -2.41852850e-02f, -1.59848277e-02f, -1.36805400e-01f, 7.16997758e-02f, -7.66498148e-02f, 7.26657687e-04f, -4.45302576e-02f, 4.53273356e-01f, 1.54090792e-01f, -2.14633513e-02f,
  -2.04678196e-02f, 2.32935429e-01f, -1.81804419e-01f, 1.70124814e-01f, -8.38012900e-03f, 3.48658741e-01f, 3.68604437e-02f, -1.05198517e-01f, -6.70289323e-02f, 5.45279570e-02f,
  -1.40162006e-01f, 1.44377559e-01f, -6.20315708e-02f, -4.08890890e-03f, 3.64325679e-04f, 6.49155006e-02f, -1.09249614e-01f, -1.21987667e-02f, -1.13644898e-01f, 1.51344910e-01f,
  1.78458239e-03f, -4.98232208e-02f, 1.25676349e-01f, -1.09638996e-01f, 1.89257666e-01f, -9.34458524e-02f, -5.33139287e-03f, -1.88951064e-02f, 1.01915643e-01f, 1.47675108e-02f,
  2.08127126e-03f, -7.52304941e-02f, 1.99339807e-01f, -8.70177820e-02f, 1.87210441e-02f, 8.48760828e-02f, -1.03693634e-01f, -2.68549144e-01f, 1.74450859e-01f, -6.23376342e-03f,
  -1.19470298e-01f, 1.22708462e-01f, -1.08397707e-01f, -1.18467314e-02f, 1.03203081e-01f, 1.15287475e-01f, -4.82090227e-02f, -8.05041939e-02f, -1.13282107e-01f, 2.53101233e-02f,
  7.96592236e-02f, 1.98297992e-01f, -1.08277448e-01f, 1.13617681e-01f, 6.26683235e-02f, -5.18097915e-02f, -4.76154797e-02f, 6.55541718e-02f, -4.25918028e-03f, 1.90126188e-02f,
  4.01802128e-03f, 2.31867060e-02f, -1.07859457e-02f, 2.52045691e-02f, 1.49351686e-01f, 5.87791577e-02f, 8.26226100e-02f, -7.92035758e-02f, 8.25585350e-02f, 1.00817993e-01f,
  -8.94642472e-02f, 9.65580158e-03f, -1.25035748e-01f, 1.57537505e-01f, -9.19249579e-02f, 1.62915453e-01f, -1.79211833e-02f, -5.55617251e-02f, 1.87635213e-01f, 1.00030102e-01f,
  -4.00491878e-02f, 1.79761335e-01f, -3.45511399e-02f, -6.83356375e-02f, -1.20469093e-01f, -3.39796906e-03f, 9.49114785e-02f, 1.16683230e-01f, -8.90008733e-02f, 5.94646707e-02f,
  3.54886614e-02f, 9.57382321e-02f, -1.03524486e-02f, -5.74386269e-02f, 9.50866640e-02f, 7.95298293e-02f, -1.50784761e-01f, 1.90662174e-03f, -5.38616143e-02f, 6.42021447e-02f,
  -4.39507514e-02f, -5.38600497e-02f, -1.93599537e-01f, -1.97826087e-01f, 6.35681376e-02f, -9.23609361e-02f, 8.23552012e-02f, -1.54727707e-02f, 6.78949356e-02f, 8.04955140e-02f,
  -1.08326457e-01f, 3.90253961e-02f, -7.26208836e-03f, 1.42292842e-01f, 4.13941368e-02f, -7.35217109e-02f, 8.28228667e-02f, -1.08983420e-01f, -4.17041369e-02f, 1.08976215e-01f,
  3.26150320e-02f, -2.71867290e-02f, -7.99168423e-02f, -1.25594065e-01f, 2.01301306e-01f, 1.29069149e-01f, 1.33653870e-02f, -3.80619951e-02f, 3.65189761e-02f, -9.24885347e-02f,
  -1.10327890e-02f, -7.01561943e-03f, -3.89854722e-02f, -5.46851009e-03f, 3.48928533e-02f, -7.14475065e-02f, 3.87425125e-02f, 1.28993988e-01f, -1.15425913e-02f, 7.62003139e-02f,
  -5.80778010e-02f, -5.71025088e-02f, -8.57200772e-02f, 1.30594924e-01f, 6.43862337e-02f, 4.52203266e-02f, 1.31232487e-02f, -9.55333412e-02f, -2.14906931e-02f, -1.42396957e-01f,
  1.44446462e-01f, -6.69663623e-02f, 2.35232548e-03f, 5.27744293e-02f, -1.17736220e-01f, 1.93754718e-01f, 8.32682028e-02f, 6.90327063e-02f, 5.48936836e-02f, 1.87002301e-01f,
  1.92528695e-01f, 2.82808632e-01f, 2.35502616e-01f, -2.26808071e-01f, -3.85041684e-02f, -6.18112572e-02f, 1.34682029e-01f, 2.36630112e-01f, 4.67954874e-02f, 2.15286627e-01f,
  -1.89076096e-01f, 4.17349823e-02f, 8.89472142e-02f, -3.61109339e-02f, -2.41553150e-02f, -2.13871002e-02f, 2.82655150e-01f, 1.71047762e-01f, 8.80468413e-02f, 1.63967729e-01f,
  -4.76167537e-02f, -2.85682641e-02f, 1.28025517e-01f, -1.30294725e-01f, -1.17110036e-01f, -2.30245255e-02f, 3.20358351e-02f, -3.70468199e-03f, 1.12075038e-01f, 3.87877196e-01f,
  9.37398225e-02f, 7.93828741e-02f, -4.28530946e-02f, 2.53533125e-01f, 1.48651361e-01f, 4.15471196e-01f, 1.56787410e-01f, -1.22605234e-01f, 8.54765847e-02f, 7.71307573e-02f,
  -1.23670273e-01f, 1.22784488e-01f, 6.92431033e-02f, 1.03335664e-01f, 4.19991277e-02f, 8.70270953e-02f, -1.09238967e-01f, -4.62285951e-02f, -1.61199480e-01f, 2.38887995e-01f,
  8.30544904e-03f, 5.49778938e-02f, -1.71820913e-02f, 6.22650841e-03f, -1.30575970e-01f, -2.13285133e-01f, -2.96552312e-02f, 1.74429063e-02f, -5.15844189e-02f, 9.10505652e-03f,
  4.46292385e-02f, 5.10673784e-02f, -2.64539830e-02f, 9.62944999e-02f, 1.13690980e-01f, 1.72857225e-01f, -8.01892430e-02f, -1.60209358e-01f, 3.40606421e-01f, 8.23814943e-02f,
  1.91867158e-01f, -1.12541661e-01f, 1.12951621e-01f, -7.40558580e-02f, 2.44210154e-01f, -3.15327048e-02f, -1.86039153e-02f, 1.63077209e-02f, 9.12362039e-02f, 1.15229726e-01f,
  -8.01215097e-02f, -5.86679913e-02f, -9.86026749e-02f, -6.62995949e-02f, 1.45148337e-01f, -1.45908222e-01f, 7.94174820e-02f, 2.21909165e-01f, 1.35003507e-01f, -1.16235495e-01f,
  4.35195714e-02f, 1.18913520e-02f, -3.49913724e-02f, -1.76890180e-01f, 4.38536443e-02f, 5.57847880e-02f, 4.57978845e-02f, -1.39451951e-01f, 9.92874876e-02f, -3.73509414e-02f,
  -5.40689491e-02f, 1.08760826e-01f, 1.70172855e-01f, -5.88698424e-02f, -1.06499709e-01f, 5.22839196e-04f, -1.37134157e-02f, -1.79284990e-01f, -4.72877324e-02f, 1.59739643e-01f,
  -5.22269756e-02f, 2.00722232e-01f, 1.27892911e-01f, -2.28046030e-02f, -4.60083447e-02f, -4.42110077e-02f, 1.26437441e-01f, -1.81042533e-02f, -7.98744783e-02f, 9.00000855e-02f,
  -6.87680542e-02f, 1.34998530e-01f, -2.80599948e-02f, 6.24382421e-02f, 1.57578915e-01f, -4.58101854e-02f, -3.76061462e-02f, 1.10881098e-01f, -1.09613471e-01f, 9.22180861e-02f,
  -1.78761825e-01f, -6.08548410e-02f, 2.57688481e-02f, -6.12432882e-03f, -2.37995550e-01f, 2.11582020e-01f, -7.50555890e-03f, -1.23833314e-01f, -3.30824070e-02f, 8.36068839e-02f,
  -1.08646862e-01f, 7.08676130e-02f, -1.53142884e-01f, -1.44453496e-01f, 1.62707105e-01f, 2.81857029e-02f, 1.63387880e-02f, 1.94793567e-02f, -2.87811663e-02f, -8.45073462e-02f,
  -9.05509889e-02f, -9.15447250e-02f, -7.46217221e-02f, 6.91277757e-02f, -3.23069431e-02f, -1.08032778e-01f, 1.94235787e-01f, 3.74173880e-01f, 1.79744735e-01f, -8.31451714e-02f,
  -1.27160668e-01f, 2.59236634e-01f, -1.71134904e-01f, 1.69692278e-01f, 6.19970001e-02f, 3.51791859e-01f, -3.03882686e-03f, -6.69213831e-02f, 1.20182961e-01f, -4.06936817e-02f,
  3.06646130e-03f, -1.03089191e-01f, -1.31806992e-02f, -7.88567588e-03f, 2.24927232e-01f, -5.51043637e-02f, -1.18272081e-01f, 6.28124690e-03f, -3.58092450e-02f, 1.61780387e-01f,
  1.14856184e-01f, 1.85270235e-02f, 1.64918005e-01f, -8.94485787e-02f, 1.07391827e-01f, 4.52005342e-02f, 5.18721305e-02f, -8.27322081e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -1.09125942e-01f, 1.23744868e-01f, 2.65022844e-01f, 1.50587469e-01f, 3.90209928e-02f, -4.81639355e-02f, 2.54998416e-01f, 8.48935023e-02f, 2.82754123e-01f, 6.91826567e-02f,
  2.20909581e-01f, 9.57594253e-03f, 1.66651040e-01f, 9.20153037e-02f, 7.14388639e-02f, 7.52598941e-02f, 1.40217990e-01f, -2.51283105e-02f, 9.56143588e-02f, 1.85131431e-01f,
  1.49177248e-02f, 6.89754263e-02f, 2.39827447e-02f, 9.83400419e-02f, 1.81399062e-01f, 1.77405506e-01f, 2.45157436e-01f, 1.47426113e-01f, -1.30955419e-02f, 3.10413521e-02f,
  -4.49444391e-02f, 5.74688651e-02f, 1.86672419e-01f, 9.25401896e-02f, 8.40121880e-02f, 2.28285402e-01f, 1.49487659e-01f, 3.35352682e-02f, 2.54095644e-02f, 1.98753074e-01f,
  1.02393620e-01f, 3.07603180e-02f, 5.42709939e-02f, -2.08705962e-02f, -4.33564037e-02f, 1.27018079e-01f, 2.25643739e-01f, -2.14384943e-02f, -1.01020420e-02f, 1.47503361e-01f,
  1.73098311e-01f, 2.75469348e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.31048876e-01f, -1.51178062e-01f, -9.68879908e-02f, -2.35651866e-01f, -2.79317826e-01f, -3.76289070e-01f, -1.50896877e-01f, 1.61809683e-01f, 1.52562022e-01f, -1.11657083e-01f,
  1.68386344e-02f, 9.05008316e-02f, 4.83887270e-03f, 7.82163292e-02f, -3.44427675e-01f, -7.16359243e-02f, 1.48309410e-01f, 3.60737480e-02f, -3.66072327e-01f, -2.34074637e-01f,
  4.75983083e-01f, 3.18727016e-01f, -1.14842422e-01f, -7.70446211e-02f, -1.11660376e-01f, 1.00542180e-01f, -5.81537373e-02f, -6.98830187e-02f, 1.39373258e-01f, 3.96978408e-02f,
  -5.39379977e-02f, 1.25134602e-01f, -4.07295115e-02f, -1.48238271e-01f, -1.13499418e-01f, 1.93404093e-01f, 2.07621418e-02f, -1.83868527e-01f, -1.06933892e-01f, -3.86421345e-02f,
  9.80661809e-02f, -5.69107942e-02f, 2.70462632e-01f, -1.96264475e-03f, -1.91813633e-01f, -6.97377399e-02f, 3.61396849e-01f, -1.67180806e-01f, 4.74520326e-01f, 5.10037422e-01f,
  -2.03061514e-02f, 1.81090131e-01f, -3.27130377e-01f, 1.45889610e-01f, 2.19404418e-02f, 3.10842752e-01f, -4.77066934e-02f, -2.32273147e-01f, -1.86857179e-01f, 3.97925600e-02f,
  3.06647927e-01f, -2.34710053e-01f, 1.32533729e-01f, -8.49441290e-02f, -1.12425283e-01f, 1.37433216e-01f, 1.07461758e-01f, 2.73963362e-01f, 6.12508953e-02f, -1.06640533e-01f,
  -1.34904474e-01f, -7.94792831e-01f, -2.14491114e-01f, -2.10780725e-01f, -1.24461930e-02f, 3.40364337e-01f, -1.15048893e-01f, -3.02766442e-01f, -4.08887416e-01f, -5.67977428e-02f,
  -2.58783530e-02f, 1.53831944e-01f, -3.55782777e-01f, 2.28554651e-01f, 7.54152462e-02f, 1.03915840e-01f, -2.16159612e-01f, -7.06120208e-02f, 5.86840212e-01f, 8.84426571e-03f,
  -8.45258832e-02f, -7.83757940e-02f, 1.22727200e-01f, 7.25219548e-02f, 1.17283441e-01f, 6.39853328e-02f, 1.16853736e-01f, -2.37746492e-01f, 1.10202447e-01f, 1.92979630e-02f,
  5.48840821e-01f, -1.62049964e-01f, 1.96464032e-01f, 5.27908728e-02f, -1.27389565e-01f, -2.74978161e-01f, 6.91438764e-02f, 4.28987324e-01f, -6.74028546e-02f, 8.61858726e-02f,
  1.26887485e-01f, -1.04840912e-01f, 8.42054367e-01f, 1.51786879e-01f, 8.65400210e-03f, 8.68431851e-02f, -4.36918497e-01f, -9.26716179e-02f, -1.48903027e-01f, -1.29689038e-01f,
  -1.33423060e-01f, 1.45271063e-01f, -1.26945958e-01f, -1.33759484e-01f, -5.82448673e-03f, -2.54831880e-01f, 4.12293434e-01f, -3.03344000e-02f, 7.71084055e-02f, 3.82148594e-01f,
  1.26925737e-01f, 1.53861955e-01f, 3.03688049e-01f, 4.03028041e-01f, -6.64595544e-01f, 2.53358901e-01f, 2.18953006e-02f, -8.79532248e-02f, 1.26121506e-01f, 4.08842824e-02f,
  -3.00640408e-02f, -2.05772325e-01f, -2.78653830e-01f, 3.54207039e-01f, 3.64763103e-02f, 9.56778303e-02f, 2.36574709e-01f, 5.59288859e-01f, -2.83883750e-01f, 7.51374289e-02f,
  -1.24617457e-01f, -3.77082848e-04f, -9.14805830e-02f, 5.33277057e-02f, 1.05519623e-01f, -1.53194994e-01f, -2.18703806e-01f, -8.63301307e-02f, -1.61675453e-01f, 2.53475487e-01f,
  2.02865116e-02f, -2.22174287e-01f, -5.28617464e-02f, 2.55409449e-01f, 4.17096764e-01f, 1.17064387e-01f, -1.09291285e-01f, -6.08369187e-02f, -6.96223155e-02f, 1.56656474e-01f,
  9.74371880e-02f, 3.69253844e-01f, -2.69830048e-01f, 4.56921607e-01f, -1.67055324e-01f, 2.30606750e-01f, -2.30622515e-01f, -4.58636247e-02f, 5.15848160e-01f, -2.24945899e-02f,
  2.14108944e-01f, 7.37199858e-02f, 5.83157055e-02f, -6.52341917e-02f, 2.67709970e-01f, -1.83158904e-01f, -1.19307391e-01f, -3.75601798e-02f, -6.73090667e-02f, -2.11375415e-01f,
  1.82552814e-01f, -3.12000364e-01f, 1.25701830e-01f, -4.38775390e-01f, 8.55512097e-02f, -2.01752812e-01f, -1.73180014e-01f, -4.24683951e-02f, -1.61405742e-01f, 1.11134715e-01f,
  -7.65467715e-03f, -5.39157055e-02f, 2.77349651e-01f, 2.15679184e-01f, 3.56894173e-02f, 2.48307645e-01f, 3.19250882e-01f, -2.17938811e-01f, 2.56342381e-01f, 8.02104622e-02f,
  -1.85852185e-01f, 2.92642236e-01f, 6.66905165e-01f, -4.05132622e-01f, -2.77238578e-01f, 4.92989719e-02f, -4.25101742e-02f, -3.18841860e-02f, -1.68815926e-01f, -9.44784656e-02f,
  2.01577008e-01f, 2.60743648e-01f, -2.38961037e-02f, -3.25645477e-01f, -1.68789312e-01f, 1.47268584e-03f, -2.08115444e-01f, 8.33979920e-02f, -1.96888641e-01f, 5.52642718e-02f,
  -2.03879625e-01f, -1.55414343e-01f, 2.94231605e-02f, 2.82026023e-01f, 1.50593385e-01f, -1.48912683e-01f, -2.39877120e-01f, -1.49321631e-01f, -9.84552130e-02f, -2.92097889e-02f,
  -1.40427053e-01f, -4.46145743e-01f, -2.54002422e-01f, 1.51929602e-01f, 6.10011697e-01f, 1.01008698e-01f, -2.23284930e-01f, 8.09791759e-02f, -1.03436850e-01f, -8.22508242e-03f,
  -1.54774711e-02f, 1.47756711e-01f, -3.89228091e-02f, 3.52831036e-01f, -1.25626355e-01f, 1.36149898e-01f, -5.05793840e-02f, -2.57628977e-01f, -4.11656797e-02f, -4.32461381e-01f,
  8.93331543e-02f, -9.99903902e-02f, 9.93840471e-02f, 2.13616803e-01f, -1.62987560e-01f, -3.17388415e-01f, -6.44891113e-02f, 3.73153776e-01f, 3.64512019e-02f, 1.81636468e-01f,
  8.32378492e-02f, 3.89800996e-01f, -2.98953056e-01f, 1.41828850e-01f, 1.83858842e-01f, -1.08237229e-01f, 4.45006698e-01f, 3.08831096e-01f, 3.02840918e-01f, -8.31386074e-02f,
  4.98596579e-02f, 4.29046631e-01f, -2.22328335e-01f, 6.69568703e-02f, -9.74657014e-02f, 2.34192628e-02f, -3.38519067e-02f, 6.37344494e-02f, -9.58239287e-02f, 1.09946340e-01f,
  1.89134449e-01f, 1.15282327e-01f, -2.66413242e-01f, 3.01065505e-01f, -2.67128646e-01f, 4.71080631e-01f, 1.21774347e-02f, 2.48545617e-01f, -2.14918837e-01f, -2.12045133e-01f,
  -3.27660561e-01f, -7.04196319e-02f, -1.70064956e-01f, -1.96332350e-01f, -3.82447422e-01f, 1.49543419e-01f, 4.42532711e-02f, 6.53767064e-02f, -3.31953287e-01f, 7.09462687e-02f,
  1.92604810e-01f, -1.62448570e-01f, -1.48802057e-01f, -2.28060052e-01f, -1.62540171e-02f, -1.17806718e-01f, -1.45478621e-01f, 4.03934211e-01f, -7.67560676e-02f, 4.43259850e-02f,
  5.13927281e-01f, 5.20217717e-01f, 3.14756125e-01f, 5.28071105e-01f, 3.52921873e-01f, 3.92643511e-01f, 1.57745124e-03f, -2.64855832e-01f, 1.22337691e-01f, -2.62745321e-01f,
  -2.42939517e-01f, 5.24180770e-01f, -2.66221296e-02f, 2.87200242e-01f, 5.64544462e-02f, -2.15777785e-01f, 5.28587520e-01f, -1.51005775e-01f, -4.29083019e-01f, -2.65754431e-01f,
  9.03975219e-02f, 2.31557965e-01f, 3.67102474e-01f, -1.63575575e-01f, -1.85955331e-01f, 1.10213459e-01f, -2.54449338e-01f, 2.76939243e-01f, -6.74313158e-02f, -7.84788653e-02f,
  1.95529684e-01f, 8.68169516e-02f, -3.21973972e-02f, 2.52646208e-01f, -1.24591976e-01f, 7.81891868e-02f, -3.38813573e-01f, 1.13886103e-01f, 7.12186247e-02f, -1.03059933e-01f,
  -1.19581185e-01f, 2.03915383e-03f, -7.63083920e-02f, 7.05183521e-02f, 1.78421158e-02f, 2.57800668e-01f, 4.10262853e-01f, 4.40372601e-02f, -2.61234403e-01f, 1.75976947e-01f,
  -5.12820296e-02f, 5.25556624e-01f, -1.63696826e-01f, -1.08566999e-01f, 1.39381975e-01f, -1.30507469e-01f, -1.16144039e-01f, 5.29584885e-01f, -2.18208015e-01f, -1.24483965e-02f,
  -1.84036762e-01f, -1.59507375e-02f, 3.47251952e-01f, 4.02760170e-02f, -3.98192376e-01f, 4.44236368e-01f, 8.94668177e-02f, -1.86977655e-01f, 1.58894598e-01f, -4.27124232e-01f,
  6.27685785e-01f, 5.86267859e-02f, 1.17150337e-01f, 4.90526378e-01f, -1.04459785e-01f, -2.81010658e-01f, 1.52333885e-01f, -1.68548763e-01f, -1.08512938e-01f, 3.58574450e-01f,
  -1.16504356e-01f, -1.80751637e-01f, 5.23296237e-01f, -2.04825997e-01f, -5.82109272e-01f, -1.08216047e-01f, -1.77120015e-01f, 2.02013150e-01f, -1.84671655e-01f, 1.28866322e-02f,
  5.34981966e-01f, 1.22469090e-01f, -7.61125460e-02f, -1.67260021e-01f, 1.43206507e-01f, -2.34323427e-01f, -3.73791195e-02f, -1.67435691e-01f, 1.41612798e-01f, -1.22606330e-01f,
  -2.07457140e-01f, 3.42096686e-02f, 3.92718874e-02f, -3.03147528e-02f, 2.10610982e-02f, -1.96886644e-01f, 4.18597013e-02f, 9.47781503e-02f, 6.95179462e-01f, 8.78721327e-02f,
  5.06243221e-02f, 6.05114810e-02f, -1.85962349e-01f, -8.60147737e-03f, 1.75921395e-01f, -3.26555103e-01f, 2.21685186e-01f, -1.76738240e-02f, -2.52152920e-01f, 1.70020744e-01f,
  -1.46367177e-01f, -2.98576862e-01f, -2.66052663e-01f, -1.12537391e-01f, -1.62263289e-01f, -1.12469055e-01f, -1.79661900e-01f, -1.23715274e-01f, -6.97337976e-03f, -4.83930498e-01f,
  -1.47966862e-01f, -1.55310720e-01f, -4.30746943e-01f, -3.30051273e-01f, -2.64559627e-01f, 3.34218681e-01f, 5.17334640e-01f, -2.23093048e-01f, 2.80273616e-01f, -1.15316622e-01f,
  1.55600905e-01f, 2.67407328e-01f, -1.12597942e-01f, -3.67095262e-01f, 9.91150644e-03f, -6.43352270e-02f, -8.82952511e-02f, -2.06163421e-01f, -1.95863575e-01f, -1.94436565e-01f,
  2.80160010e-01f, -1.76169977e-01f, -1.33329034e-01f, -1.84734445e-02f, 5.34846522e-02f, -2.08620489e-01f, -9.47345793e-02f, 3.59334469e-01f, -7.97872469e-02f, -2.18323573e-01f,
  -1.29792795e-01f, -1.20937034e-01f, 6.83552772e-02f, -8.35530609e-02f, -2.87340283e-02f, -1.77415580e-01f, 6.83849335e-01f, -1.76632553e-01f, -2.92154215e-02f, -1.83536246e-01f,
  -2.35937368e-02f, 1.15715437e-01f, 2.60773718e-01f, 1.08791247e-01f, -1.37537062e-01f, -1.68196172e-01f, -1.96262822e-01f, -1.24812953e-01f, -1.78641930e-01f, -9.97209027e-02f,
  3.23007889e-02f, 1.97085500e-01f, 2.37102568e-01f, -4.43281024e-04f, -5.62464036e-02f, -2.00752974e-01f, -3.56825367e-02f, 2.33094260e-01f, -2.10765839e-01f, -2.17115313e-01f,
  -9.35018957e-02f, 2.64557749e-01f, 2.98213325e-02f, -2.34835073e-01f, 4.96077426e-02f, -4.08091694e-01f, 1.15779918e-02f, 3.05449039e-01f, 4.59797949e-01f, -5.36749363e-01f,
  -3.76630872e-01f, 5.73235989e-01f, -2.77008295e-01f, 8.11510086e-02f, -4.48540039e-02f, -2.10451186e-01f, 4.38306808e-01f, -4.30476576e-01f, 2.62952030e-01f, -1.89937830e-01f,
  -2.20323771e-01f, -1.34593174e-01f, -6.80984676e-01f, -1.94199290e-02f, -1.60310030e-01f, 4.27720219e-01f, 3.92331094e-01f, -1.59553349e-01f, -1.18264124e-01f, 2.60059536e-01f,
  2.01635852e-01f, -1.65237904e-01f, -4.97511066e-02f, -1.35951668e-01f, -2.23963186e-02f, 2.04204053e-01f, -1.98607892e-01f, -2.40621522e-01f, -1.06389588e-02f, -1.33570582e-01f,
  2.48646766e-01f, -1.49420187e-01f, -2.71538943e-02f, -4.90251817e-02f, -1.13141835e-01f, -1.17252082e-01f, 4.08286095e-01f, 3.23486626e-02f, -9.07231942e-02f, 3.42918873e-01f,
  1.05377762e-02f, -1.60433024e-01f, 2.25167170e-01f, -2.14605987e-01f, 8.09807777e-02f, -6.42303154e-02f, -2.04353571e-01f, -1.50682069e-02f, 6.88473927e-03f, 3.96641523e-01f,
  1.13933437e-01f, -1.86581582e-01f, 7.63757378e-02f, -3.64292741e-01f, 4.83994484e-02f, -9.01064724e-02f, 5.68403542e-01f, -5.38275838e-01f, 5.87224364e-02f, 1.65921971e-01f,
  5.45861572e-02f, -1.86498761e-01f, 2.34836608e-01f, 4.36498910e-01f, -1.74976468e-01f, -1.73821479e-01f, 1.65339679e-01f, -2.46754244e-01f, -2.89039668e-02f, 7.73074524e-03f,
  -1.43176496e-01f, 4.33840483e-01f, -8.80673453e-02f, -6.65605813e-02f, 7.21197426e-01f, 1.28831595e-01f, -2.69863158e-01f, -1.40631840e-01f, 4.62851793e-01f, -1.23427629e-01f,
  -2.97971845e-01f, -7.62817264e-02f, 2.96721190e-01f, -1.95973143e-01f, -6.48471937e-02f, 3.37797612e-01f, -3.94499786e-02f, 1.65239468e-01f, -2.40779240e-02f, -1.96269378e-01f,
  1.99508801e-01f, -1.04505166e-01f, -1.77042976e-01f, 1.14950106e-01f, -1.61216244e-01f, 1.94450766e-01f, 1.64324254e-01f, 1.24408260e-01f, -1.78047493e-01f, 1.00093130e-02f,
  -1.95895985e-01f, 4.87835370e-02f, -5.38629591e-02f, 2.41077226e-03f, -9.20523107e-02f, -1.94713026e-01f, -2.20081091e-01f, -1.69883728e-01f, -2.00757667e-01f, 1.07112788e-02f,
  -7.34174624e-02f, -8.51625130e-02f, 2.05315351e-01f, -2.53303766e-01f, -1.91598922e-01f, 6.92948028e-02f, -5.47992215e-02f, 5.73159873e-01f, -1.63940519e-01f, -2.46543124e-01f,
  -1.82851821e-01f, 2.30707407e-01f, -5.51711857e-01f, -5.49131259e-03f, -3.81065756e-01f, -7.69845620e-02f, -4.32296455e-01f, -1.19504243e-01f, -3.56856406e-01f, 2.71841586e-01f,
  -4.40397590e-01f, 2.48548865e-01f, 8.21523275e-03f, -1.87578455e-01f, 3.40083688e-01f, -3.21456164e-01f, -2.18092158e-01f, 2.22129188e-02f, 2.75701225e-01f, 1.26936764e-01f,
  3.36842477e-01f, -1.44987062e-01f, 4.22155224e-02f, 1.49561435e-01f, -1.68065786e-01f, 1.66160166e-01f, -6.10156097e-02f, -1.34010017e-01f, 2.77242735e-02f, -1.50289088e-01f,
  3.70991901e-02f, 4.80412751e-01f, -1.26150653e-01f, 3.46591234e-01f, -5.48021942e-02f, -5.47719523e-02f, -1.55591741e-01f, 1.05951421e-01f, -2.39751562e-01f, -1.57549322e-01f,
  -1.42358229e-01f, 3.81519437e-01f, -1.79111242e-01f, -2.65911460e-01f, -2.12300643e-01f, -2.65144080e-01f, -2.15594731e-02f, 4.57034528e-01f, 3.63233946e-02f, -1.41709000e-01f,
  -2.57530898e-01f, -5.42570762e-02f, -3.34833600e-02f, 5.18596321e-02f, 4.81077842e-02f, -1.17247120e-01f, 9.73457843e-02f, 3.39085937e-01f, 2.39673499e-02f, 3.53760034e-01f,
  7.59960189e-02f, -1.64751276e-01f, -1.84620067e-01f, -6.78009689e-02f, -3.18864107e-01f, 2.72680521e-01f, 2.12263167e-01f, 1.48381367e-01f, 1.47811383e-01f, 1.48126364e-01f,
  5.79684913e-01f, -1.16103785e-02f, 1.94481865e-01f, -6.31258041e-02f, 3.75271529e-01f, -2.47961447e-01f, 1.03467353e-01f, 9.40181036e-03f, 2.59519130e-01f, 2.92104661e-01f,
  8.40480179e-02f, 1.02128074e-01f, -3.63137066e-01f, -5.78197204e-02f, -3.99374038e-01f, -1.47356838e-01f, -2.36594930e-01f, 1.28120616e-01f, 2.01792777e-01f, -6.96098804e-02f,
  2.23031044e-02f, 1.71339482e-01f, -5.33127300e-02f, 2.19900608e-01f, -7.20013753e-02f, -2.34847799e-01f, -6.55693188e-02f, -9.74504948e-02f, -4.65597399e-02f, 4.04780284e-02f,
  -1.62378401e-01f, 6.69537410e-02f, 2.36422382e-02f, 2.40490407e-01f, 2.95801193e-01f, -3.10149267e-02f, 1.03662573e-01f, -2.94782072e-01f, 1.17182761e-01f, -3.49349111e-01f,
  -6.90401942e-02f, -1.28052160e-01f, -2.22768217e-01f, -1.94451451e-01f, -8.04401040e-02f, -8.61937255e-02f, 2.26714194e-01f, 9.63795930e-02f, -5.37939817e-02f, 4.43340503e-02f,
  -3.59491035e-02f, -2.57061809e-01f, 8.11836183e-01f, -2.09244117e-01f, 1.63703769e-01f, 1.37873113e-01f, -1.67737320e-01f, 5.72963476e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.12455505e-01f, 2.17683744e-02f, -5.80122955e-02f, -9.80520900e-03f, -7.30629191e-02f, 2.13354692e-01f, 5.82954939e-03f, -6.42302632e-02f, 2.06343174e-01f, -3.74236773e-03f,
  -1.63248777e-01f, -2.58527864e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    