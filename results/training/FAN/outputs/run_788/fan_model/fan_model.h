/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.58361457e-02f, 2.75512617e-02f, 6.25580549e-01f, -7.64195025e-02f, -2.42922213e-02f, -5.19812778e-02f, -4.04515676e-02f, -9.54150930e-02f, -1.99931622e-01f, 1.18164375e-01f,
  -1.74014151e-01f, -2.52826065e-01f, -1.35144427e-01f, -1.32698476e-01f, -8.92051235e-02f, -6.89800754e-02f, 1.43169180e-01f, 1.67980537e-01f, -6.84083477e-02f, -2.57941961e-01f,
  -2.30363458e-01f, 2.39002943e-01f, 3.05272996e-01f, -1.67190611e-01f, 1.26828104e-01f, -2.30374053e-01f, 3.23538989e-01f, 2.83774465e-01f, -3.86602245e-02f, 1.98158190e-01f,
  3.26612532e-01f, 1.39094904e-01f, 4.39276127e-03f, -1.64825514e-01f, 1.66121811e-01f, 3.60593349e-02f, -4.80322354e-02f, 2.24114567e-01f, -9.01799574e-02f, 1.09213263e-01f,
  5.28913960e-02f, 8.57145637e-02f, -6.38999194e-02f, 7.65151605e-02f, 1.38104901e-01f, 4.42871312e-03f, 1.73948497e-01f, 1.24805495e-01f, 6.64332807e-02f, 1.39804389e-02f,
  -1.03394762e-01f, 3.08430251e-02f, 1.79984972e-01f, -1.44475237e-01f, -8.18374380e-02f, -1.44422844e-01f, 6.31220452e-03f, 2.61602178e-03f, 1.10262617e-01f, 2.43734255e-01f,
  -4.26940918e-02f, 3.32350172e-02f, -4.25377898e-02f, 1.46233495e-02f, -5.18280640e-02f, -6.37111664e-02f, 2.56430954e-02f, 9.03937370e-02f, -8.68934393e-02f, 9.00371745e-02f,
  -7.59708211e-02f, -1.82147101e-02f, -1.09784724e-02f, 2.19829381e-02f, -6.76534772e-02f, 2.03568324e-01f, 8.76771379e-03f, -4.32847021e-03f, -3.62559259e-02f, -2.50723213e-02f,
  -5.38098514e-02f, -7.21836463e-02f, 5.16123325e-02f, 9.36443172e-03f, -2.16332525e-02f, -1.41759906e-02f, -1.19741941e-02f, -2.62811203e-02f, -2.52123503e-03f, -4.38172137e-03f,
  -2.21892089e-01f, -4.13001180e-02f, -4.06008475e-02f, 7.56649971e-02f, 8.75412300e-02f, -8.75421464e-02f, -3.96524137e-03f, -2.14322768e-02f, 1.28952330e-02f, -4.82255220e-03f,
  -4.94952761e-02f, -2.19154358e-02f, -1.43264187e-03f, -1.77166443e-02f, -9.92177203e-02f, -3.64217125e-02f, -8.83850679e-02f, 2.55755577e-02f, -7.70551786e-02f, 4.36596796e-02f,
  -1.53838679e-01f, -7.53112808e-02f, -1.04966819e-01f, -2.33047027e-02f, -3.67919244e-02f, -1.29464462e-01f, -1.46199921e-02f, 7.06325343e-04f, -3.84390354e-02f, -1.23528190e-01f,
  8.26750398e-02f, 4.75675344e-01f, -7.05464631e-02f, 6.06412739e-02f, -6.36027846e-03f, -1.32621024e-02f, 4.93044220e-02f, 4.35234122e-02f, 4.75254729e-02f, 2.06695899e-01f,
  5.08947410e-02f, -3.18118691e-01f, -2.09549710e-01f, -1.54252037e-01f, -4.42478321e-02f, -2.97596911e-03f, 7.80785307e-02f, -2.09161639e-01f, -4.21344727e-01f, -1.10967629e-01f,
  4.73369239e-03f, 3.82407829e-02f, 8.12480599e-02f, -4.34607454e-02f, 6.64051697e-02f, -2.06004232e-01f, 2.35526100e-01f, 1.09175161e-01f, 1.11824470e-02f, 1.16000555e-01f,
  -1.65646866e-01f, 3.70732158e-01f, -2.04714388e-01f, 1.20878190e-01f, 5.27949780e-02f, 1.00663900e-02f, -6.84731379e-02f, 2.13614125e-02f, -6.44619167e-02f, 3.84543091e-03f,
  -2.33925442e-04f, 1.45373559e-02f, -8.69868919e-02f, 3.09382249e-02f, 4.65714857e-02f, -2.83950311e-03f, 1.41519248e-01f, 6.37107044e-02f, 5.77084050e-02f, 8.50929692e-02f,
  -1.85467992e-02f, -6.41518552e-03f, 9.09191594e-02f, 5.11169285e-02f, 1.12902438e-02f, -1.33400872e-01f, 2.34853774e-01f, 1.17901444e-01f, 5.32076992e-02f, 1.17918529e-01f,
  -2.26229224e-02f, -7.30789080e-02f, 2.12752745e-02f, 5.16842976e-02f, -5.23656830e-02f, -9.64483619e-03f, -2.34749285e-03f, -4.21933755e-02f, -3.85054722e-02f, -1.91110261e-02f,
  3.43711535e-03f, 2.18116343e-02f, 5.41629735e-03f, 6.55820873e-03f, -4.08233260e-04f, 3.94590758e-02f, -9.37156379e-02f, 7.64392167e-02f, 5.30374050e-02f, 7.98750669e-02f,
  -1.03507675e-02f, 5.52421948e-03f, 3.02245468e-02f, -1.12037085e-01f, 1.11917742e-01f, 1.10115288e-02f, 9.78498068e-03f, 4.38874476e-02f, 3.37562002e-02f, 7.92214200e-02f,
  3.60446610e-02f, -6.34471923e-02f, -5.25314845e-02f, 2.96667404e-03f, -4.19532694e-02f, 5.06089702e-02f, -5.10492846e-02f, 3.49500664e-02f, 4.43508336e-03f, 1.60662681e-02f,
  2.14910675e-02f, 1.60769746e-02f, 8.62813145e-02f, 6.19621649e-02f, -5.93737885e-02f, -3.74112725e-02f, 6.72385171e-02f, -1.63227066e-01f, -2.01753876e-03f, 1.17046721e-01f,
  1.31704018e-01f, -6.61694854e-02f, -1.95308059e-01f, -1.13099068e-01f, 2.82234829e-02f, -1.36900067e-01f, -1.75427780e-01f, -9.80419368e-02f, -1.45316750e-01f, -1.60088353e-02f,
  1.53262421e-01f, -1.13158561e-01f, -4.09772247e-02f, 3.56433421e-01f, -2.97859192e-01f, -4.18938309e-01f, -6.92869127e-01f, -7.34607577e-02f, 1.34940177e-01f, -4.15826440e-02f,
  -2.44474351e-01f, 1.37891248e-01f, 1.82231516e-01f, 2.48315930e-01f, 1.48946578e-02f, -1.18240923e-01f, 1.34228155e-01f, 2.79638559e-01f, -7.73529932e-02f, -3.10783744e-01f,
  6.70691673e-03f, 1.39203906e-01f, 1.73025638e-01f, 1.43778160e-01f, 1.54582160e-02f, -7.02209398e-02f, -2.25348286e-02f, -7.10506588e-02f, -2.46973887e-01f, 3.28289151e-01f,
  -1.33335322e-01f, 8.62985998e-02f, -8.15197378e-02f, 5.48760407e-02f, 4.33225418e-03f, -1.51151605e-02f, -8.21225941e-02f, 9.01473016e-02f, -6.44236163e-04f, -1.28415716e-03f,
  8.83893296e-02f, 8.03937614e-02f, 1.55387186e-02f, 4.98535559e-02f, -7.19616115e-02f, -6.99838698e-02f, 1.30704492e-01f, 2.42654249e-01f, 1.25623807e-01f, -1.40816122e-01f,
  2.29996024e-03f, -5.74857555e-02f, -6.30123839e-02f, -4.42708172e-02f, 7.56337075e-03f, 1.20155424e-01f, -1.11212805e-01f, 6.32073954e-02f, -9.32238549e-02f, 3.46546471e-02f,
  -2.79076560e-03f, 3.95541266e-02f, -5.67959845e-02f, 1.06349159e-02f, -6.33534193e-02f, 3.53415981e-02f, 6.48109149e-03f, -1.00293374e-02f, 5.59851155e-02f, -4.48981300e-02f,
  3.58867534e-02f, 1.91012155e-02f, -2.75197793e-02f, 4.00744453e-02f, 2.95775873e-03f, 5.44843189e-02f, -2.64529185e-03f, -3.77464108e-02f, 8.57733339e-02f, -6.34433106e-02f,
  6.39859065e-02f, -5.48599474e-02f, -1.60472398e-03f, -1.01333635e-03f, 7.89887272e-03f, 7.26304352e-02f, 8.74816999e-02f, 1.04268175e-02f, -1.02427769e-02f, 6.18601404e-02f,
  1.03942547e-02f, -8.61636624e-02f, 8.93534273e-02f, 7.51692653e-02f, 3.19618322e-02f, 3.25460471e-02f, -3.03340405e-02f, 1.69400107e-02f, 6.72836453e-02f, -1.45479012e-02f,
  -1.58568501e-01f, -4.48121130e-03f, -7.85074309e-02f, -5.46709783e-02f, -1.38484299e-01f, -2.13978440e-02f, -1.43890277e-01f, -1.50452601e-02f, 5.47018694e-03f, -5.45112751e-02f,
  -1.95644088e-02f, -1.25061870e-01f, -9.02362317e-02f, -5.81708066e-02f, -4.38674018e-02f, -2.76182741e-02f, -1.29419148e-01f, -1.24355920e-01f, -1.26122728e-01f, -2.80082673e-01f,
  4.50107008e-01f, -2.29581013e-01f, 3.21241498e-01f, -1.81760743e-01f, -2.11172774e-01f, 3.01601291e-01f, 1.48728490e-01f, 5.80929965e-02f, -1.51624173e-01f, -1.75960690e-01f,
  -5.64570166e-02f, -2.34767850e-02f, -7.49097243e-02f, 7.34950928e-03f, 3.24182123e-01f, 4.29817736e-02f, -2.20399335e-01f, 1.92706510e-02f, 4.62224215e-01f, 2.68655390e-01f,
  -1.83974519e-01f, -1.83373898e-01f, 5.47704771e-02f, 9.75831300e-02f, -3.16226184e-01f, 3.52336541e-02f, -1.49370044e-01f, -4.15181182e-02f, 5.48708253e-02f, -6.33001924e-01f,
  1.42881766e-01f, 7.59196505e-02f, 1.79839715e-01f, -1.69624165e-01f, -4.52345163e-02f, 7.87368938e-02f, 3.78140509e-02f, -6.17123209e-02f, 2.24131737e-02f, -7.09471181e-02f,
  -4.00208943e-02f, 1.30796097e-02f, -7.83536583e-02f, 7.32324738e-03f, 4.36820555e-03f, 3.41767669e-02f, -3.49854268e-02f, 1.02562092e-01f, 9.07792449e-02f, 1.07600570e-01f,
  -1.97905481e-01f, -7.61029050e-02f, 8.71058851e-02f, 1.95058677e-02f, 6.94294795e-02f, -6.05167896e-02f, 2.26904377e-02f, 6.76153526e-02f, 1.58271909e-01f, -1.64079785e-01f,
  1.36888856e-02f, -1.68340150e-02f, 3.35895009e-02f, 1.97120570e-02f, 2.40956321e-02f, 1.13711134e-02f, -5.99407405e-02f, 2.96208952e-02f, -2.48754257e-03f, -2.04820968e-02f,
  2.01000441e-02f, -9.00025573e-03f, -1.74337644e-02f, 7.68768415e-02f, -8.66990630e-03f, -1.64569840e-02f, 7.03507289e-02f, 2.35231733e-03f, 3.11405621e-02f, 2.62668170e-02f,
  3.21490527e-03f, -9.63354018e-03f, -7.16265738e-02f, 3.74498516e-02f, 4.18755086e-03f, 5.49627841e-02f, 5.89517616e-02f, 3.27222869e-02f, -3.43995690e-02f, 1.28660351e-02f,
  5.00266999e-02f, 9.20848027e-02f, -2.14490164e-02f, 1.23837210e-01f, 3.89916264e-03f, -7.96477124e-02f, -2.89149527e-02f, -4.60747490e-03f, -6.91947713e-02f, 7.26753548e-02f,
  7.02450424e-02f, 6.53193966e-02f, -3.43384072e-02f, 2.14165170e-02f, 7.05232518e-03f, -2.79248618e-02f, -4.79464270e-02f, -1.57070477e-02f, -4.89109084e-02f, -5.49622392e-03f,
  -4.70989384e-02f, 8.06492567e-02f, 1.01404965e-01f, -7.41505921e-02f, -4.73168492e-02f, 5.62355332e-02f, 6.98302016e-02f, 2.39234846e-02f, 2.88890153e-01f, 6.38465956e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.08231580e-01f, -1.99559867e-01f, 5.34372590e-02f, -9.36330482e-02f, 3.34803946e-02f, 1.65834501e-01f, 1.76062435e-01f, 9.37940702e-02f, -9.40798149e-02f, -1.00516550e-01f,
  -1.36729911e-01f, -6.48975298e-02f, -9.44951549e-02f, 4.84320745e-02f, 1.30580395e-01f, 7.35073835e-02f, 4.73391451e-02f, 9.12862793e-02f, -3.36148739e-02f, 1.18563212e-01f,
  1.79313123e-02f, -4.86033782e-02f, -3.18747163e-02f, 1.00756705e-01f, -3.53477821e-02f, -1.54779822e-01f, -1.46512851e-01f, -6.20160550e-02f, -4.49572094e-02f, -5.82737178e-02f,
  -1.84770286e-01f, -3.05748492e-01f, 1.20588876e-02f, -4.13606837e-02f, -7.49478191e-02f, -2.60883588e-02f, -4.93005216e-02f, -6.84475666e-03f, 6.32607713e-02f, 5.31135201e-02f,
  -6.67966381e-02f, -2.41946839e-02f, -4.39254753e-02f, 1.02840833e-01f, 7.39583978e-03f, -3.71381715e-02f, 6.85788393e-02f, 2.24935003e-02f, 2.07768381e-02f, -2.08099410e-02f,
  -4.23035026e-02f, -5.47147356e-02f, -9.52039361e-02f, 7.80488104e-02f, -1.51191922e-02f, -1.82822883e-01f, -2.55940985e-02f, -5.31155150e-03f, 4.80927527e-02f, -1.41664997e-01f,
  1.05912924e-01f, -2.80894525e-02f, 6.58898726e-02f, -3.17965075e-02f, 1.89908897e-03f, -2.21091006e-02f, 1.28070023e-02f, 7.70005491e-03f, 1.75987855e-02f, 6.34250194e-02f,
  -8.04778337e-02f, 3.38910669e-02f, -5.90801910e-02f, -2.73846369e-03f, -2.95818206e-02f, -9.88678169e-03f, 3.09596560e-03f, -7.20767444e-03f, -6.60016164e-02f, -7.22405463e-02f,
  -2.10893489e-02f, 4.12195623e-02f, -1.49782151e-01f, -7.52323046e-02f, 9.81285423e-03f, -4.22759466e-02f, 3.54036093e-02f, -1.51903974e-02f, -2.02176478e-02f, -9.44824610e-03f,
  -1.68344229e-01f, 4.08225097e-02f, -1.63670257e-01f, -3.21492627e-02f, -6.92546414e-03f, -9.62808356e-02f, -1.01200603e-02f, -6.90014800e-03f, -5.08899018e-02f, 8.19365010e-02f,
  8.46026000e-04f, 3.81797776e-02f, -6.06117323e-02f, -5.13554784e-03f, 2.45341007e-02f, 6.09893650e-02f, 2.06534844e-02f, -2.21745037e-02f, -1.19773727e-02f, -2.99592298e-02f,
  3.54883820e-02f, -1.28657252e-01f, -1.31981209e-01f, -5.56251071e-02f, -1.76247194e-01f, -1.86591670e-01f, -1.32443875e-01f, -5.51279038e-02f, -6.06212988e-02f, -2.77314689e-02f,
  8.52341771e-01f, 2.99365640e-01f, 2.16120437e-01f, 7.96953812e-02f, -2.27056473e-01f, -2.31229722e-01f, 1.71856731e-02f, 9.72759053e-02f, 4.74551879e-02f, 1.95326358e-01f,
  4.28214818e-02f, -5.75132780e-02f, 6.49605319e-03f, 1.27755646e-02f, 1.45363167e-01f, 2.24843957e-02f, -4.92568165e-02f, 1.60066038e-01f, 1.40532926e-01f, 3.74217751e-03f,
  -3.39550637e-02f, 3.13462943e-01f, 4.91809607e-01f, 1.71935976e-01f, -1.45932445e-02f, -1.59250647e-01f, 5.50412163e-02f, 1.34634376e-01f, -2.90126167e-02f, 1.76736414e-01f,
  1.24038532e-01f, 3.72940987e-01f, -2.04075962e-01f, -2.18397230e-02f, -8.58324245e-02f, 1.52536660e-01f, 3.86549383e-02f, 5.06779030e-02f, -5.17687164e-02f, -5.88335693e-02f,
  -7.43111074e-02f, 4.20558150e-04f, -8.50206614e-02f, -1.75635498e-02f, 4.15406637e-02f, 1.58457346e-02f, 8.17085430e-02f, 5.72341494e-02f, -9.69607979e-02f, 5.27232401e-02f,
  -1.19227245e-01f, -8.49997699e-02f, 7.05407839e-03f, -9.10429358e-02f, 1.67195313e-02f, -1.08496197e-01f, -3.81293800e-03f, -9.25491154e-02f, 9.55363065e-02f, 1.80872813e-01f,
  -7.09310248e-02f, 5.82954325e-02f, 6.89707622e-02f, -8.09402205e-03f, 9.64513142e-03f, 7.70785101e-03f, -4.68247645e-02f, -6.56679571e-02f, 9.95024852e-03f, 5.14012016e-02f,
  -1.32130340e-01f, -2.11397577e-02f, 4.44133813e-03f, -6.72878101e-02f, -1.58606470e-02f, -7.84560889e-02f, -5.91634866e-03f, -1.19633134e-02f, -5.18728793e-02f, 7.19328299e-02f,
  1.93273500e-02f, -1.77212078e-02f, 2.45582517e-02f, 2.51263715e-02f, -2.68382933e-02f, -2.18003057e-02f, -4.70035896e-02f, -3.85278687e-02f, 3.31164747e-02f, 6.42711818e-02f,
  -2.12084621e-01f, -1.73772901e-01f, -1.00402976e-03f, 3.35424058e-02f, -7.47769885e-03f, -1.51788909e-02f, 3.64661366e-02f, -8.03644657e-02f, -6.86228201e-02f, 5.82882389e-02f,
  6.47578239e-02f, 7.98370168e-02f, -2.15310175e-02f, -7.29457848e-03f, -8.20255429e-02f, -5.43474331e-02f, -6.23241533e-03f, 9.93659440e-03f, -9.46675763e-02f, -1.42841460e-02f,
  -9.65459049e-02f, -4.13502119e-02f, -3.30829844e-02f, -1.35223493e-01f, -8.27037469e-02f, -2.03759670e-01f, -1.05496921e-01f, -5.83406202e-02f, -1.39752567e-01f, -2.45665573e-02f,
  6.35584652e-01f, -1.17145896e-01f, 3.66054654e-01f, 2.77027220e-01f, 2.77103096e-01f, 3.04461807e-01f, 2.63394833e-01f, 2.03803644e-01f, 6.28364384e-02f, 9.10693780e-02f,
  -1.13930732e-01f, -2.53224343e-01f, -1.14664771e-01f, -1.56702489e-01f, -3.11852470e-02f, 6.89622313e-02f, 4.76743802e-02f, 1.08796403e-01f, 2.07988054e-01f, 1.31689146e-01f,
  1.54832576e-03f, 4.59799021e-02f, -8.28804728e-03f, 7.83915594e-02f, -6.30119024e-03f, 4.29426283e-02f, -5.11788391e-02f, -2.58867368e-02f, -1.19232632e-01f, -3.79803106e-02f,
  -9.80774164e-02f, 1.85212150e-01f, -6.49846047e-02f, -1.28942966e-01f, -5.92006892e-02f, -9.16147903e-02f, -1.32163018e-02f, 1.94758642e-02f, 3.61568145e-02f, 4.68108281e-02f,
  1.47793535e-02f, -9.74152610e-02f, -1.02276742e-01f, -9.27020386e-02f, 7.60415420e-02f, 1.03071835e-02f, -1.70833543e-02f, -3.94014046e-02f, 4.54532355e-02f, -2.07193717e-02f,
  -2.00876236e-01f, 9.95327607e-02f, 1.88439980e-01f, 3.36466059e-02f, 1.25309065e-01f, 7.13628829e-02f, 4.36125956e-02f, -3.74598801e-02f, 9.35638025e-02f, 6.92139119e-02f,
  -4.32396904e-02f, 7.39739984e-02f, -8.56295824e-02f, -8.96191597e-03f, -7.26255774e-02f, 5.13088368e-02f, 2.47952361e-02f, -1.73339192e-02f, 8.17432813e-03f, -8.64650682e-03f,
  5.24232419e-05f, 1.75485834e-02f, 8.29061493e-02f, 5.19203059e-02f, -1.06714994e-01f, 1.78314224e-02f, -3.67416348e-03f, -8.04044753e-02f, -5.62506802e-02f, -1.11047132e-02f,
  2.93270219e-02f, 3.36778238e-02f, 7.49012381e-02f, -8.43355656e-02f, -3.30765471e-02f, 2.91841738e-02f, 2.85321269e-02f, -5.37772812e-02f, -5.32370806e-02f, 1.26763418e-01f,
  -2.90219873e-01f, 5.99723682e-02f, 6.28502853e-03f, -3.21069919e-02f, 4.60622981e-02f, -3.58729213e-02f, -7.07232160e-03f, -6.65434077e-02f, -1.58698410e-02f, 4.37756963e-02f,
  -8.94027725e-02f, 4.43383157e-02f, -2.79378053e-02f, -5.77599406e-02f, 5.08928224e-02f, 7.29644150e-02f, -3.22061069e-02f, 6.38501123e-02f, -5.04915565e-02f, -1.61532417e-01f,
  -1.00370206e-01f, 1.41608030e-01f, 1.21905640e-01f, 5.36168143e-02f, -3.21116596e-02f, 1.11403592e-01f, 1.71393119e-02f, 1.96917970e-02f, 9.08275843e-02f, 7.59594887e-02f,
  4.67715366e-03f, 1.94406509e-01f, -1.91876590e-01f, -2.05132496e-02f, -1.35771468e-01f, -3.44104499e-01f, -3.05908948e-01f, -1.87003762e-01f, 4.69240882e-02f, 1.36266993e-02f,
  1.27658308e-01f, 2.69028634e-01f, 1.00946300e-01f, 4.51099761e-02f, -3.68464082e-01f, -2.85551310e-01f, -3.40492696e-01f, -3.10941637e-01f, -3.12770098e-01f, -3.53241891e-01f,
  -2.08786711e-01f, -1.07231699e-01f, -1.21985123e-01f, -2.29593500e-01f, 3.23741823e-01f, 2.51665980e-01f, 1.37943864e-01f, -2.20052414e-02f, -7.75719527e-03f, 2.09997371e-01f,
  3.45321506e-01f, -3.21857892e-02f, -1.64730772e-01f, -8.38996097e-03f, 4.22390215e-02f, 3.26910317e-02f, -1.33974652e-03f, 2.38425285e-02f, 1.30604297e-01f, 1.23643978e-02f,
  2.18920913e-02f, -9.76507645e-03f, 3.88763249e-02f, 1.02573380e-01f, -3.63289425e-03f, -2.82905810e-02f, -1.12283066e-01f, -1.22902118e-01f, -8.59082267e-02f, -2.14636233e-03f,
  -7.36702904e-02f, -1.13072321e-01f, -9.05807409e-03f, -1.07411347e-01f, -7.94910714e-02f, -6.19760714e-03f, 2.58904528e-02f, 2.23645717e-02f, -1.66688323e-01f, 1.76817104e-01f,
  9.28889308e-03f, 4.53243069e-02f, 6.31840676e-02f, 8.15901756e-02f, 3.81899029e-02f, 7.92099312e-02f, 3.44171226e-02f, 1.67719387e-02f, -6.40509874e-02f, 4.06250171e-02f,
  -9.60586499e-03f, -7.25300834e-02f, -3.34566412e-03f, 2.21198630e-02f, -5.27161348e-04f, -4.74850088e-02f, -4.70866784e-02f, 2.29849257e-02f, -5.25872894e-02f, -1.31864399e-02f,
  4.94513176e-02f, 1.44601837e-02f, 3.63538414e-02f, -3.63329761e-02f, -1.01814978e-01f, -6.72484562e-02f, 4.90409881e-02f, -1.24434289e-02f, -3.70626040e-02f, -3.40557396e-02f,
  4.75526214e-01f, -3.93211931e-01f, 1.76786199e-01f, -6.11744225e-02f, -3.99608426e-02f, 1.87484436e-02f, 1.97904274e-01f, 1.41191343e-02f, 1.15754038e-01f, 9.85605493e-02f,
  -5.43850139e-02f, 4.04997217e-03f, 3.27299796e-02f, 4.94673029e-02f, -5.59651628e-02f, 1.17483707e-02f, -5.00288233e-02f, 7.03932270e-02f, -1.67721510e-01f, 1.27536863e-01f,
  -1.58125795e-02f, -1.41049191e-01f, 1.15191415e-01f, 1.37414932e-01f, -2.56831180e-02f, -8.06495324e-02f, 1.81475446e-01f, 1.17840402e-01f, -4.81454395e-02f, 2.35678330e-01f,
  -3.58126998e-01f, 2.03632429e-01f, 1.20781966e-01f, -1.14445426e-01f, 1.01095855e-01f, 1.95223838e-01f, 9.40881222e-02f, -2.12506503e-01f, -3.16258036e-02f, 1.03553692e-02f,
  2.33589157e-01f, -1.91134363e-01f, -1.07763447e-01f, -1.38833955e-01f, -4.00488347e-01f, -4.99689765e-02f, -1.51042059e-01f, -3.12503219e-01f, -4.18457419e-01f, -1.44962147e-01f,
  -1.31171182e-01f, -3.04301202e-01f, -3.18572998e-01f, -2.13212594e-01f, -6.42536953e-02f, -1.99131280e-01f, 2.53950935e-02f, -5.42122386e-02f, 9.97455791e-02f, 4.22806256e-02f,
  2.13568598e-01f, 1.89436689e-01f, -8.93786401e-02f, -1.18958587e-02f, 1.38638243e-01f, 1.48671754e-02f, 4.32918854e-02f, 5.05753793e-02f, 7.55639821e-02f, -5.68940479e-04f,
  8.63993764e-02f, 5.92682548e-02f, 4.29747365e-02f, -3.29003595e-02f, -1.76419884e-01f, 2.27457006e-02f, -8.76278728e-02f, -2.60875702e-01f, -1.20199621e-01f, 1.55602172e-01f,
  1.64996181e-02f, 5.71004525e-02f, -1.83213770e-01f, -1.50248001e-03f, -3.97144929e-02f, -6.68692309e-03f, 3.48340794e-02f, -9.04624835e-02f, -1.21382199e-01f, -2.59357601e-01f,
  -2.56358813e-02f, 8.87368098e-02f, 3.01365685e-02f, -2.16208976e-02f, -3.53766978e-02f, 4.70132045e-02f, -2.37585325e-02f, -2.18563788e-02f, -4.67562452e-02f, -8.04175213e-02f,
  -6.79501379e-03f, 8.13749060e-02f, 3.18539664e-02f, -7.85636455e-02f, 3.72892208e-02f, -2.82394979e-02f, 4.75204289e-02f, -1.25619590e-01f, -3.08420956e-02f, 3.39535065e-04f,
  -8.48376825e-02f, -1.76484585e-02f, -2.10733637e-02f, 1.65406987e-02f, -3.67439748e-03f, 5.35989329e-02f, 9.08747166e-02f, -3.98634933e-03f, -1.36889517e-03f, 6.70128688e-02f,
  -3.78390312e-01f, 1.19916193e-01f, -6.42895624e-02f, -1.08245842e-01f, -3.27561498e-02f, 5.63232675e-02f, 6.24894314e-02f, -6.83904439e-02f, 1.26778841e-01f, -1.05876386e-01f,
  4.39589955e-02f, -3.13637592e-02f, -9.84616876e-02f, -1.03352591e-01f, 2.60986993e-03f, -4.66744378e-02f, -1.89372942e-01f, -1.18041523e-01f, -3.03712226e-02f, 9.72774029e-02f,
  -1.24672160e-01f, -2.53405392e-01f, -3.50279003e-01f, -2.06822738e-01f, -3.71718444e-02f, -2.51240492e-01f, -1.90330625e-01f, -2.30997398e-01f, -2.08988279e-01f, -4.45416719e-01f,
  -4.55610901e-02f, -5.85279167e-01f, -1.54837206e-01f, -1.04931556e-01f, -1.32673830e-01f, -3.57445925e-01f, -5.58827937e-01f, -6.54221252e-02f, 5.23294415e-03f, -3.47311407e-01f,
  -8.93875957e-02f, 1.05162062e-01f, 5.28520979e-02f, -4.69668917e-02f, -8.14176723e-03f, -6.04051530e-01f, -3.70716184e-01f, -1.80657003e-02f, 3.27479631e-01f, 6.10378534e-02f,
  4.81458940e-03f, 1.07717089e-01f, 2.48834193e-01f, 2.35845610e-01f, -1.91584885e-01f, -2.36895122e-02f, -2.28671536e-01f, -1.37116397e-02f, -1.97776943e-01f, -4.67757434e-01f,
  -2.01652765e-01f, 8.41209814e-02f, 8.92476663e-02f, 6.89378614e-03f, 3.58505622e-02f, 7.02490739e-04f, -2.38831136e-02f, 8.08849037e-02f, 1.19456733e-02f, -2.35890746e-02f,
  1.00605801e-01f, 9.41824168e-02f, 4.66079712e-02f, 1.27661273e-01f, 3.92770022e-02f, 2.42207907e-02f, 6.79459721e-02f, 6.17751405e-02f, 3.79020981e-02f, -5.88817745e-02f,
  -6.86497986e-02f, -1.21766694e-01f, 3.20389308e-02f, -4.32626344e-02f, 3.47463079e-02f, 4.26747799e-02f, 5.38339317e-02f, -2.51598973e-02f, -7.09209815e-02f, -2.82367229e-01f,
  -8.28123018e-02f, 1.81841720e-02f, 7.40419142e-03f, 2.17863061e-02f, -3.81299481e-02f, -2.35840250e-02f, 3.23444530e-02f, -1.04742907e-01f, 2.88915858e-02f, -3.28111425e-02f,
  3.28165479e-02f, -3.32363844e-02f, 1.18290251e-02f, -6.01869524e-02f, -5.46112247e-02f, 4.72329706e-02f, -8.55029970e-02f, -6.68599606e-02f, -8.68626405e-03f, 4.61606048e-02f,
  -5.12400875e-03f, 3.72978789e-03f, 2.01265837e-04f, 5.48858009e-02f, -4.74903099e-02f, -2.92786048e-03f, 3.77025194e-02f, 5.38719222e-02f, 9.83507782e-02f, 5.28171994e-02f,
  -7.64280418e-03f, 1.33860737e-01f, -2.06240252e-01f, 1.13544047e-01f, -5.95909916e-02f, 2.74578165e-02f, -9.28678736e-02f, 7.62908459e-02f, 7.68084228e-02f, -4.72326614e-02f,
  2.59003136e-02f, -3.81818227e-02f, -5.55569306e-02f, 3.32626179e-02f, -3.20237242e-02f, -1.55429989e-02f, -1.10686377e-01f, -3.23976614e-02f, -4.14123700e-04f, -2.45302613e-03f,
  -8.93323198e-02f, -2.17467174e-01f, -1.76945165e-01f, -6.07341528e-02f, 4.98282574e-02f, -7.11465627e-02f, -1.59264565e-01f, -1.11107484e-01f, -2.01781988e-01f, -3.30661774e-01f,
  -1.13102727e-01f, 1.29420966e-01f, -3.50193679e-02f, 4.23423946e-01f, 3.49217534e-01f, 2.35760346e-01f, 6.71679974e-02f, 7.10403696e-02f, 1.09630808e-01f, 1.81742370e-01f,
  2.51914144e-01f, 2.27127865e-01f, 2.24735558e-01f, 1.95678145e-01f, 6.45840093e-02f, 1.40697151e-01f, 2.13185027e-01f, 3.12420372e-02f, -2.62558274e-02f, 1.09120242e-01f,
  2.55171537e-01f, 1.06234223e-01f, -2.89543793e-02f, 9.19059590e-02f, 1.97122127e-01f, 3.30802619e-01f, 1.11962162e-01f, 2.26347774e-01f, 7.53496215e-02f, 3.00997287e-01f,
  -5.25588095e-02f, 2.34557614e-02f, 7.58243352e-02f, 1.97496727e-01f, 2.89675919e-03f, -2.29252040e-01f, -2.97836624e-02f, -1.96259797e-01f, -9.07969698e-02f, -1.29842043e-01f,
  1.09291844e-01f, -1.05963208e-01f, 6.92381561e-02f, -2.72147860e-02f, -5.59281409e-02f, -1.90202832e-01f, -1.80387050e-01f, -1.76677778e-02f, -3.39475386e-02f, -3.13202664e-02f,
  1.72466934e-01f, 7.86445066e-02f, -6.21526539e-02f, -1.01008058e-01f, -8.22231360e-03f, 1.25874355e-01f, -1.26174822e-01f, -6.41629919e-02f, -7.49713480e-02f, -1.22965751e-02f,
  5.41001512e-03f, -4.74259295e-02f, 2.52907090e-02f, -1.23436200e-02f, 7.82367140e-02f, -1.81279995e-03f, -3.48384976e-02f, -6.43165829e-03f, 9.72540453e-02f, -1.47662222e-01f,
  5.26849031e-02f, 4.41358984e-02f, -1.33407069e-02f, -5.02953772e-03f, 6.29305094e-02f, -2.14580204e-02f, -7.16454163e-03f, -8.28367248e-02f, -4.49099764e-02f, -3.80504504e-02f,
  -2.39018654e-03f, -6.75558373e-02f, -6.92664534e-02f, -8.16962793e-02f, -4.18785959e-02f, 8.64038542e-02f, -2.82652043e-02f, 1.91495400e-02f, -3.74972485e-02f, 2.69835815e-02f,
  4.40151338e-03f, -4.99880984e-02f, 1.01073738e-02f, -2.20179446e-02f, 3.81342545e-02f, -1.01548627e-01f, 1.51328668e-01f, -1.07996628e-01f, 1.55053400e-02f, 3.83544862e-02f,
  2.77208537e-02f, -8.54576230e-02f, 5.19924890e-03f, -1.48493171e-01f, -6.57843202e-02f, -9.54678953e-02f, 9.91013199e-02f, -2.72456855e-02f, -1.26820542e-02f, -3.03518446e-03f,
  -6.92343935e-02f, -9.31261107e-02f, -1.94772840e-01f, -3.66828740e-02f, -5.38792200e-02f, 2.81679537e-02f, -9.45779085e-02f, -4.55063321e-02f, -1.10446155e-01f, -2.78106838e-01f,
  2.52052933e-01f, 7.51787946e-02f, -5.91845989e-01f, -1.18221022e-01f, -2.93952703e-01f, -3.16325843e-01f, -1.36397749e-01f, 4.21217643e-02f, 5.20181581e-02f, -1.68210790e-02f,
  -8.56634080e-02f, -1.22874916e-01f, -2.10304826e-01f, -2.40887761e-01f, -5.21937236e-02f, -1.89863056e-01f, -3.50815594e-01f, -3.75382185e-01f, -3.34124446e-01f, -1.08641975e-01f,
  -1.29613951e-01f, -2.48391315e-01f, -9.19883549e-02f, 3.94135602e-02f, -1.12116784e-01f, -1.69813752e-01f, -2.28567824e-01f, -2.59612918e-01f, -1.95185512e-01f, -1.93029568e-01f,
  -5.51585555e-01f, -1.02145702e-01f, -9.46887955e-02f, 1.71187162e-01f, -1.04119614e-01f, 1.73643053e-01f, -6.55269623e-02f, 8.51007774e-02f, 1.03905745e-01f, -5.54520376e-02f,
  -1.70111936e-02f, 4.70851958e-02f, -7.82331452e-02f, -3.61248702e-02f, -9.96308774e-02f, -8.01537558e-02f, 4.01177257e-02f, -4.19745706e-02f, -6.76017627e-02f, -3.45764756e-02f,
  -4.42051739e-02f, -7.95524344e-02f, -5.34075387e-02f, -4.50761057e-02f, -1.03287078e-01f, -9.44470316e-02f, -1.40003338e-01f, -8.21612626e-02f, -2.04363316e-02f, 1.44577459e-01f,
  5.14058992e-02f, -8.67684856e-02f, 1.21443067e-02f, 8.18025991e-02f, 9.00287703e-02f, -3.67023703e-03f, 8.72652698e-03f, 4.84337546e-02f, -3.52797210e-02f, 5.07670380e-02f,
  -1.31924590e-02f, -3.64387408e-02f, -1.32664600e-02f, 2.95422431e-02f, -4.79723662e-02f, -1.58779286e-02f, 3.91064361e-02f, 5.94258383e-02f, -1.14143211e-02f, -5.03509007e-02f,
  -1.19888391e-02f, -4.48969305e-02f, 6.66626692e-02f, -3.56739573e-02f, -5.93074784e-02f, -8.45308006e-02f, -3.17809246e-02f, 5.17887399e-02f, -3.16052996e-02f, -1.07276172e-03f,
  1.04880124e-01f, -3.87860164e-02f, 8.91058426e-03f, 1.53215453e-01f, -1.21573787e-02f, 1.50761055e-02f, 2.21990123e-02f, 1.10877827e-01f, 1.37607247e-01f, -1.92429386e-02f,
  -4.99875583e-02f, 7.51188910e-03f, -9.40048918e-02f, 5.45102928e-04f, -8.67014751e-02f, -2.92405263e-02f, 2.76736617e-01f, -2.53790934e-02f, -1.51293380e-02f, -2.48079393e-02f,
  -8.72194208e-03f, 1.34129375e-01f, 3.48167196e-02f, 1.83166675e-02f, -4.63447012e-02f, -9.42860171e-02f, -5.72179817e-02f, -1.67595670e-02f, 7.58152977e-02f, 3.43394578e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.10632259e-02f, 4.95120853e-01f, 1.33423269e-01f, 5.79478383e-01f, 1.50391459e-01f, 2.02376619e-01f, 1.92720830e-01f, 4.49085385e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.22994483e-01f, 4.66468744e-02f, 2.32048184e-01f, -6.99296296e-02f, -7.13938415e-01f, -1.48479104e-01f, -7.01849684e-02f, 5.57743430e-01f, 2.85795569e-01f, -4.38508481e-01f,
  5.12009323e-01f, -2.59433329e-01f, -1.97298616e-01f, 4.10265923e-01f, 9.35221240e-02f, 2.33769715e-01f, 1.00963283e-02f, 1.17901236e-01f, -2.51983374e-01f, 1.18092977e-01f,
  6.08130634e-01f, 2.46788591e-01f, 7.11669683e-01f, -4.11065578e-01f, -3.48394901e-01f, 2.93060392e-01f, -5.50334692e-01f, 5.47344506e-01f, -1.55811638e-01f, 4.17813398e-02f,
  -3.14430818e-02f, -1.98820323e-01f, 4.48902369e-01f, 1.29908174e-01f, 1.53803766e-01f, -2.20560029e-01f, 2.55787671e-01f, 2.07195044e-01f, 8.12573656e-02f, -2.03708276e-01f,
  -3.80862027e-01f, 3.62434387e-01f, -2.34154910e-01f, 4.64540452e-01f, 1.93757832e-01f, -6.42990291e-01f, -7.66850039e-02f, 2.26232871e-01f, -9.63337049e-02f, 2.12972060e-01f,
  -2.60945916e-01f, -1.10550299e-01f, 6.55892968e-01f, 6.90118670e-01f, 4.36312109e-01f, -5.79479992e-01f, 1.07656300e-01f, 8.72709677e-02f, 4.34564263e-01f, -7.31069520e-02f,
  1.29321873e-01f, -4.25540358e-01f, -1.03672266e-01f, -2.64833402e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.03727356e-01f, 6.40457511e-01f, 1.61086991e-01f, 9.04707193e-01f, -5.85932052e-03f, 1.82937637e-01f, -7.14493215e-01f, 2.95710832e-01f, 3.65198433e-01f, 3.24183136e-01f,
  7.72396028e-02f, -3.08997601e-01f, 2.32722938e-01f, -2.64440924e-01f, -2.39251733e-01f, 5.55322826e-01f, 3.81472379e-01f, 8.83495927e-01f, 4.09464598e-01f, -3.23742718e-01f,
  -6.14459813e-01f, -5.04076242e-01f, 8.50021660e-01f, -6.26785696e-01f, 1.57374188e-01f, -3.97382885e-01f, -2.44335726e-01f, 1.24184079e-01f, -3.29829931e-01f, -4.95793521e-02f,
  9.12881196e-01f, 5.56701541e-01f, 8.40120435e-01f, 5.59852226e-03f, -1.13931812e-01f, -1.74174700e-02f, 3.48485678e-01f, -8.95721734e-01f, -7.26409853e-01f, 7.67172337e-01f,
  5.70546910e-02f, -1.89733505e-01f, 9.00012255e-02f, 6.60458684e-01f, -3.00131679e-01f, -2.87320346e-01f, -1.52123064e-01f, -1.83121502e-01f, 1.16098084e-01f, -1.02531359e-01f,
  3.84538025e-01f, -1.40880629e-01f, -4.96901393e-01f, -7.43596554e-01f, 4.17402208e-01f, 7.98626423e-01f, -4.17294800e-01f, 2.24025726e-01f, 1.31950686e-02f, 4.16045547e-01f,
  -4.84814256e-01f, 9.20785844e-01f, 1.65391654e-01f, 5.58292866e-01f, -9.45328027e-02f, 1.07876495e-01f, 6.29810452e-01f, 3.80319476e-01f, -3.17355692e-01f, 2.50048190e-01f,
  -8.79996568e-02f, 5.14847934e-01f, -3.41221660e-01f, 8.60621691e-01f, 3.60847145e-01f, 3.40672433e-01f, -3.12857270e-01f, -3.87163579e-01f, 3.12744945e-01f, 6.50275946e-01f,
  2.20534340e-01f, 2.55109996e-01f, 4.86165166e-01f, 8.85426044e-01f, -3.12982708e-01f, 3.19763362e-01f, -5.20039797e-01f, -7.56168440e-02f, 1.73820376e-01f, -3.15164894e-01f,
  -5.06591976e-01f, 7.64956653e-01f, 9.02839303e-01f, 6.19400382e-01f, -2.47683972e-01f, 8.09326530e-01f, 1.03762046e-01f, 5.54307461e-01f, -1.10641196e-01f, 5.68641245e-01f,
  6.63652897e-01f, 3.30648184e-01f, 9.92652178e-01f, -2.47430831e-01f, 1.36986375e-01f, 7.79543102e-01f, -2.08622590e-01f, -3.98123473e-01f, -3.57347846e-01f, 6.14369750e-01f,
  -4.20289934e-02f, -3.66659909e-01f, 3.80881280e-01f, 3.97675894e-02f, 1.29235104e-01f, -4.26328272e-01f, 5.18589556e-01f, 6.58246994e-01f, 5.01342595e-01f, -6.66413128e-01f,
  -3.02943915e-01f, 8.31966773e-02f, -2.58320998e-02f, 5.43261349e-01f, 8.62984061e-01f, 4.16943073e-01f, 5.07191181e-01f, 8.35840181e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.06433892e-01f, 6.00963712e-01f, 6.30958438e-01f, -1.53066084e-01f, 2.62166411e-01f, 4.71076548e-01f, 3.81831944e-01f, 3.71993423e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.02267635e+00f, -2.76352465e-01f, -2.54287213e-01f, -8.11361313e-01f, -2.05436036e-01f, -1.40756384e-01f, -8.49951684e-01f, -9.27461013e-02f, 2.95715183e-01f, -3.35392088e-01f,
  -4.15105730e-01f, 6.26640737e-01f, -2.15337172e-01f, 6.38657629e-01f, 1.12035409e-01f, -9.73569602e-02f, -7.44383633e-01f, -3.87369394e-01f, 3.19439322e-01f, -9.69742477e-01f,
  5.27687967e-01f, -4.93528157e-01f, -3.60247970e-01f, -4.84537631e-01f, -2.63762683e-01f, 3.54358137e-01f, -3.04420918e-01f, 1.37003934e+00f, 6.75766587e-01f, -3.39864463e-01f,
  -7.11709112e-02f, -5.04943848e-01f, 6.21820867e-01f, 2.68035084e-01f, 4.22343463e-01f, 6.54858887e-01f, -6.92624226e-02f, 8.69843721e-01f, -8.41726720e-01f, 8.83482695e-02f,
  1.06193349e-01f, 1.92111537e-01f, 4.94412743e-02f, 1.27358645e-01f, -7.19989955e-01f, 8.29124998e-04f, 1.06575382e+00f, -2.74647661e-02f, 1.06474839e-01f, -5.96140206e-01f,
  3.12054604e-01f, 1.63809493e-01f, 6.43933892e-01f, -8.62906516e-01f, 6.60351887e-02f, -5.19294083e-01f, 9.02623236e-01f, -5.14722764e-01f, -3.30490440e-01f, -8.79112720e-01f,
  -4.48366731e-01f, 9.18902993e-01f, -1.43005624e-01f, -3.41639072e-01f, 1.78667516e-01f, 2.52003431e-01f, -3.68442684e-01f, 2.53057063e-01f, 4.57013883e-02f, 7.46616364e-01f,
  -7.44155943e-02f, 6.23199977e-02f, -3.86791378e-01f, -4.27472472e-01f, -5.99236190e-02f, -2.03478232e-01f, -2.22827736e-02f, 5.99826276e-01f, -5.51657319e-01f, 8.99097145e-01f,
  4.57181893e-02f, 4.40627962e-01f, -3.33007365e-01f, 2.80598938e-01f, 6.09859705e-01f, 1.24110974e-01f, 3.64585668e-01f, -4.93744403e-01f, 6.13220096e-01f, 5.02136171e-01f,
  -3.02232862e-01f, -2.35168710e-02f, 5.83493114e-01f, 3.48429680e-01f, -3.71555418e-01f, -5.06515384e-01f, -5.02278447e-01f, -3.63256812e-01f, 1.68666877e-02f, -8.35154653e-01f,
  -6.70273662e-01f, 8.30764472e-01f, 4.53490317e-01f, 5.38463235e-01f, -2.62779623e-01f, -4.30748194e-01f, -9.43593234e-02f, -2.55494028e-01f, 1.97711349e-01f, -9.07274187e-01f,
  1.24922240e+00f, -1.85766906e-01f, 2.57335365e-01f, 3.78469318e-01f, 1.14129163e-01f, 4.39139679e-02f, 5.40913492e-02f, -5.19143879e-01f, -3.72680545e-01f, 1.73528552e-01f,
  -6.07455730e-01f, 1.39434135e+00f, -4.47724164e-01f, -2.34303534e-01f, -1.78984642e-01f, -6.50357902e-01f, -3.62850577e-01f, 1.50244251e-01f, -2.36255631e-01f, -4.94880080e-01f,
  3.74347448e-01f, 6.81505144e-01f, 4.27820712e-01f, -7.58421779e-01f, 2.41574347e-02f, -2.03242525e-01f, 2.10600719e-01f, -1.84042513e-01f, 1.21824765e+00f, 5.15436567e-02f,
  2.97825277e-01f, -1.06066084e+00f, -2.19566077e-01f, -5.75639307e-01f, -3.07824850e-01f, -2.97758877e-01f, -4.35364604e-01f, -1.13160469e-01f, -5.71421385e-01f, 8.25219512e-01f,
  6.87822461e-01f, 6.93672419e-01f, -4.74495858e-01f, 5.71752846e-01f, -2.14735642e-01f, -4.51976992e-02f, -6.32140517e-01f, -2.91360795e-01f, 3.02725494e-01f, 1.11547303e+00f,
  6.25826955e-01f, 5.21813273e-01f, -6.02608584e-02f, -6.15165472e-01f, -3.35759372e-01f, 1.92821801e-01f, 2.71084458e-01f, -8.27996492e-01f, -1.86900243e-01f, -4.38138127e-01f,
  1.15399230e+00f, 3.90784502e-01f, -2.95911342e-01f, 2.73656845e-01f, -3.47995013e-01f, -4.10341173e-01f, 5.31089425e-01f, 9.03794825e-01f, 3.16956013e-01f, 2.11995877e-02f,
  -6.17348313e-01f, -4.04656917e-01f, 4.48174417e-01f, 1.21666312e+00f, 5.48658967e-01f, -9.21362102e-01f, -1.30768105e-01f, -4.34475571e-01f, 5.42860746e-01f, -1.23622507e-01f,
  7.27820098e-02f, 3.48147243e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.86603409e-01f, 1.00757359e-02f, 3.05286855e-01f, -1.89616606e-01f, -4.10370857e-01f, -1.58735678e-01f, 3.15443277e-01f, -1.78024948e-01f, 8.59656557e-02f, 9.81312022e-02f,
  -2.32804436e-02f, 2.15323031e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    