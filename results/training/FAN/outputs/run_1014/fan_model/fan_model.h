/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26150697e-01f, 5.63924372e-01f, -1.18383250e-04f, 4.13159490e-01f, 2.45105833e-01f, -3.16929221e-02f, 1.95437461e-01f, -3.22087407e-02f, 1.41552687e-01f, 2.91613877e-01f,
  1.52114868e-01f, 9.72522497e-02f, -1.54895708e-02f, -1.25442564e-01f, -1.70370966e-01f, 1.28961757e-01f, 9.24562514e-02f, -1.84889659e-01f, -2.94896543e-01f, -5.73502406e-02f,
  2.05763578e-01f, 2.20271006e-01f, -3.57452966e-02f, -3.42509858e-02f, 3.26872379e-01f, 3.74382921e-02f, 1.18201643e-01f, 9.04423296e-02f, -7.96216503e-02f, 3.40838522e-01f,
  1.82464868e-01f, -1.41902030e-01f, -7.34354258e-02f, 2.97853164e-02f, 1.84134915e-01f, -4.65766788e-02f, 1.72432419e-02f, 1.63093936e-02f, -6.52873795e-03f, 9.64371189e-02f,
  8.35041478e-02f, 4.80642654e-02f, 4.63318117e-02f, -2.55163061e-03f, 9.47997421e-02f, 2.22393069e-02f, 3.47577734e-03f, -1.10054016e-02f, -9.35917571e-02f, 7.68891871e-02f,
  1.87544018e-01f, 8.45700577e-02f, -8.72913152e-02f, -4.15406898e-02f, -6.36843592e-02f, -1.15799271e-01f, 5.09076789e-02f, -1.00748964e-01f, -1.83919579e-01f, 5.17336242e-02f,
  9.78728905e-02f, 8.40014741e-02f, 4.99501862e-02f, 2.02109814e-02f, 9.40341055e-02f, 4.12167348e-02f, 4.37483424e-03f, 8.74453858e-02f, -2.94528324e-02f, 2.71044467e-02f,
  1.04618538e-02f, 5.66560961e-02f, 2.02373825e-02f, 3.06366961e-02f, 4.23044227e-02f, 2.77620321e-03f, 8.08104202e-02f, 9.50678289e-02f, 9.42619890e-02f, -1.08750919e-02f,
  4.35786173e-02f, -1.01520885e-02f, 7.75039718e-02f, -2.07234528e-02f, 1.55958245e-02f, 5.63702360e-02f, -3.72198150e-02f, 3.95982750e-02f, -5.56499921e-02f, -2.16548853e-02f,
  2.01714963e-01f, -1.50361076e-01f, 6.45352378e-02f, -1.08675659e-02f, 3.57571654e-02f, 2.40507768e-03f, 1.23215422e-01f, 9.20927227e-02f, 2.22332496e-02f, 3.66154723e-02f,
  1.38774347e-02f, 8.27110559e-02f, 7.04004169e-02f, 8.58105049e-02f, -3.83503400e-02f, 4.11422364e-02f, 1.43730223e-01f, 8.06266963e-02f, 4.96683829e-02f, 7.51714259e-02f,
  1.34929880e-01f, 7.95125887e-02f, 8.63878801e-02f, 1.12841450e-01f, -6.07714206e-02f, 1.99473854e-02f, 1.63760543e-01f, 9.86043140e-02f, -4.10204381e-02f, 4.13866431e-01f,
  -5.34885287e-01f, 2.14691997e-01f, 5.82393408e-01f, -2.69926071e-01f, -2.15738416e-01f, 9.01933238e-02f, 3.20454717e-01f, 1.36217907e-01f, -1.88905686e-01f, 2.22469643e-02f,
  4.09397185e-02f, -3.64047498e-01f, -1.22021817e-01f, -2.11931244e-01f, 7.80079188e-03f, 4.06347632e-01f, 2.69732028e-01f, -3.42488326e-02f, -1.88529119e-01f, -2.29244083e-01f,
  -2.22522721e-01f, -2.95101047e-01f, -2.08814114e-01f, 4.44873348e-02f, 1.06911741e-01f, -2.09309280e-01f, 2.72120953e-01f, 5.71294650e-02f, 1.99005857e-01f, 6.86984211e-02f,
  3.00258875e-01f, 2.43170708e-01f, -1.45808756e-01f, -1.35737896e-01f, 7.96591416e-02f, 7.86163658e-02f, -1.37072159e-02f, 7.20241666e-02f, 6.40284196e-02f, 1.05397068e-01f,
  -3.92966308e-02f, -1.24283778e-02f, 7.46167311e-03f, 8.99972990e-02f, 8.94377008e-02f, 6.73399270e-02f, 9.96928141e-02f, 2.02105239e-01f, 1.13744318e-01f, 1.87541813e-01f,
  -1.89916492e-02f, -5.55408113e-02f, 1.14589162e-01f, 1.17610998e-01f, 3.09276849e-01f, -1.16724633e-01f, 1.86697036e-01f, 1.86329067e-01f, 1.56406686e-01f, 7.21587911e-02f,
  -8.12685341e-02f, 7.55403042e-02f, 3.93040106e-03f, -1.96301956e-02f, -2.68219355e-02f, 4.44038063e-02f, 6.71651140e-02f, 1.58443451e-02f, 9.55509488e-03f, 3.82089913e-02f,
  -6.30553439e-03f, 4.95205149e-02f, -3.85584775e-03f, 5.30941486e-02f, 4.99098562e-02f, 7.95311704e-02f, 3.25888731e-02f, 6.79550096e-02f, 9.29047167e-02f, 8.71089026e-02f,
  -2.93613393e-02f, 1.58390198e-02f, -4.01892923e-02f, -1.49601949e-02f, 6.06139898e-02f, 6.42382205e-02f, -7.82677718e-03f, 4.66754287e-02f, 2.08210498e-02f, 2.37393770e-02f,
  -2.50263184e-01f, -1.01800367e-01f, 2.39509903e-02f, -5.78114996e-03f, 3.17074209e-02f, 6.74897507e-02f, -5.78393936e-02f, -4.23601195e-02f, -2.69883927e-02f, 3.12110074e-02f,
  4.86015081e-02f, -2.56734416e-02f, 1.47916991e-02f, 4.56571355e-02f, -3.56765576e-02f, -5.32161538e-03f, 6.18889986e-04f, -1.05330087e-01f, 3.38814929e-02f, 1.57733098e-01f,
  5.58646098e-02f, -6.99329898e-02f, -2.02561453e-01f, -6.84937239e-02f, 4.36851457e-02f, -2.34645441e-01f, -1.30681684e-02f, 2.27594992e-05f, -1.08352825e-01f, -1.08920462e-01f,
  -4.20299947e-01f, -1.38002902e-01f, -2.44937271e-01f, -1.94821283e-01f, -6.38499763e-03f, -1.69014819e-02f, -8.94438848e-02f, 7.19978511e-02f, 5.65243848e-02f, -3.10050161e-03f,
  1.26541764e-01f, 2.41108850e-01f, 5.33155501e-02f, 1.40887603e-01f, 4.77769785e-02f, -1.94576517e-01f, -2.73407757e-01f, -8.24649110e-02f, 4.00684029e-02f, 2.53929615e-01f,
  7.91103989e-02f, 1.44927800e-01f, 1.95609644e-01f, 1.30617604e-01f, -5.21883629e-02f, -1.38138672e-02f, -1.28314883e-01f, -1.04489550e-01f, -5.77347428e-02f, -2.22373411e-01f,
  6.10440411e-02f, -2.33345568e-01f, 7.91783556e-02f, 1.07762553e-01f, 6.70700595e-02f, 1.65857151e-02f, 9.65826330e-04f, 4.54963669e-02f, -3.98830660e-02f, -7.02858120e-02f,
  -4.46465239e-02f, 6.33046478e-02f, 3.73743214e-02f, 3.47095989e-02f, -2.21597981e-02f, 3.65684601e-03f, 4.71469313e-02f, -1.10740066e-01f, -3.88367251e-02f, 4.85658087e-02f,
  6.63442463e-02f, -1.00599140e-01f, -1.92692786e-01f, -1.49393668e-02f, -1.38210118e-01f, -1.01273268e-01f, 3.66404951e-02f, -2.58053448e-02f, -3.15668322e-02f, -3.16235200e-02f,
  1.57358691e-01f, 7.06769079e-02f, -2.95459647e-02f, 7.12062716e-02f, -3.92794274e-02f, -5.98384887e-02f, -1.42135814e-01f, -7.62844319e-03f, 3.67086194e-02f, -1.00317337e-01f,
  -6.39790669e-02f, -6.65190956e-03f, -7.43365735e-02f, -6.03109561e-02f, 2.29902510e-02f, -1.20331474e-01f, -1.33351624e-01f, 4.87182550e-02f, -4.52097841e-02f, -1.03817405e-02f,
  -7.22616464e-02f, 3.02825798e-03f, 4.27090451e-02f, -9.43642668e-03f, -5.22438064e-02f, -8.28347132e-02f, -1.79986842e-02f, -5.57040563e-03f, 6.82713091e-02f, 2.90821362e-02f,
  3.34893495e-01f, 1.37821183e-01f, -1.25515550e-01f, 1.25439335e-02f, -2.81656403e-02f, 1.06784776e-02f, 9.42603573e-02f, -1.46689154e-02f, -8.88087898e-02f, 5.97648323e-03f,
  1.28909767e-01f, 8.19157809e-02f, -1.60961393e-02f, 1.88832611e-01f, 1.06957212e-01f, 3.72073054e-03f, 9.81534272e-02f, -4.72383238e-02f, 1.55138494e-02f, -1.14333369e-02f,
  1.16793290e-01f, -1.14113942e-01f, -2.76458859e-02f, -3.31599042e-02f, -5.08295372e-02f, -1.14253148e-01f, -4.27027568e-02f, -9.37902555e-03f, 6.49120379e-03f, 9.50425118e-03f,
  3.24336708e-01f, 4.21176404e-01f, 2.14395568e-01f, -2.72422489e-02f, 1.73067197e-01f, 3.74073565e-01f, 4.13128078e-01f, 2.05079615e-01f, -7.78031573e-02f, 8.21034089e-02f,
  -3.31334174e-02f, -3.12437207e-01f, -3.96439970e-01f, -2.82025963e-01f, 2.00764090e-02f, 1.03412487e-01f, 7.52229095e-02f, -5.13427667e-02f, -2.67337263e-02f, 1.84313118e-01f,
  2.74444930e-03f, -5.98807004e-04f, 6.35726675e-02f, 3.90016995e-02f, 7.83995464e-02f, -2.37558156e-01f, -2.07356494e-02f, 2.84416811e-03f, 1.25820890e-01f, -4.95337732e-02f,
  -6.72602057e-02f, 3.29175264e-01f, -5.91353029e-02f, -2.71801036e-02f, 1.90953419e-01f, 1.63120419e-01f, 1.48565128e-01f, 2.22291335e-01f, 7.34847263e-02f, 7.21992776e-02f,
  1.17336951e-01f, 1.56043336e-01f, 3.06830015e-02f, 7.37909526e-02f, 1.76225141e-01f, 1.24173224e-01f, 1.48289859e-01f, 1.32273749e-01f, 8.53840485e-02f, 1.96268246e-01f,
  7.25510865e-02f, 2.89096475e-01f, 2.21147373e-01f, 1.16247386e-01f, 1.64670601e-01f, -1.16956323e-01f, 1.53759852e-01f, 1.84360459e-01f, 1.04224153e-01f, 5.72177321e-02f,
  -1.92829192e-01f, -9.49688852e-02f, 1.57416854e-02f, -1.20327808e-01f, -1.34421572e-01f, -9.02645662e-02f, -9.33674350e-02f, -8.82106349e-02f, -1.39027506e-01f, 4.69335850e-04f,
  -6.88714534e-02f, -2.76137572e-02f, -6.38966784e-02f, 7.05009047e-03f, -1.73095644e-01f, 4.97040078e-02f, -3.44467275e-02f, -1.09035797e-01f, -8.92360508e-02f, -6.23961315e-02f,
  -6.76052868e-02f, -1.22688346e-01f, -3.72923501e-02f, -7.70674348e-02f, -5.86470924e-02f, -1.49569251e-02f, -6.02142233e-03f, -2.91160494e-02f, -2.60047540e-02f, 5.98861696e-03f,
  -3.07530046e-01f, 5.24265431e-02f, -1.05874360e-01f, 3.32331434e-02f, 7.21682534e-02f, 2.11467948e-02f, -3.66716348e-02f, 1.30923307e-02f, -2.07477789e-02f, 8.18202421e-02f,
  3.85792404e-02f, -4.50692885e-02f, 6.71402067e-02f, 1.19442791e-01f, 7.07825040e-03f, -5.06291837e-02f, -4.25628088e-02f, 5.41366683e-03f, -2.77515762e-02f, 1.63439244e-01f,
  -3.78668271e-02f, 3.69004235e-02f, -8.62298906e-02f, -8.98803473e-02f, -3.71675752e-02f, -1.67287737e-01f, -5.85123412e-02f, 3.37217748e-02f, -4.09194492e-02f, -1.06174998e-01f,
  4.91083592e-01f, -6.93057328e-02f, 2.70083278e-01f, 1.52896509e-01f, -1.43442467e-01f, -4.09665197e-01f, -5.30067742e-01f, -2.95926332e-01f, 4.83364202e-02f, 2.79742219e-02f,
  1.26777619e-01f, 1.28459692e-01f, 2.05219209e-01f, 1.02258146e-01f, -1.29705220e-01f, -2.13979483e-01f, 7.98930004e-02f, 1.61419883e-01f, -2.33909473e-01f, -4.06048983e-01f,
  -3.14620554e-01f, -1.34894103e-01f, 1.19323485e-01f, 2.46601459e-02f, -5.50448187e-02f, 5.57870697e-03f, 2.45488554e-01f, 2.20002443e-01f, 9.65921879e-02f, 1.90757960e-01f,
  1.96894228e-01f, 2.28358567e-01f, -1.09350093e-01f, 6.17678352e-02f, 1.53892621e-01f, 7.65091330e-02f, -3.51512246e-02f, 1.71253636e-01f, 1.49380565e-01f, 3.21809808e-03f,
  1.48511529e-01f, 1.41093969e-01f, 5.02812341e-02f, -4.55461182e-02f, -2.06011981e-02f, 5.47418408e-02f, 6.88661486e-02f, 1.16762385e-01f, 1.69587597e-01f, -2.69242562e-02f,
  1.19972266e-02f, 1.63541466e-01f, 1.01950847e-01f, -8.19942802e-02f, 8.42651278e-02f, 1.05008431e-01f, -1.37509517e-02f, 1.08189382e-01f, 1.65714815e-01f, -5.91662526e-02f,
  -4.45633382e-02f, 6.08028173e-02f, -7.53414184e-02f, -3.13978200e-03f, -5.60331792e-02f, 7.63237700e-02f, 4.19234745e-02f, 1.31229386e-02f, -8.03845525e-02f, 5.05358819e-03f,
  -5.10190986e-02f, 1.40519179e-02f, 1.96497946e-04f, 6.68795854e-02f, 2.33974177e-02f, 5.07727079e-02f, 4.12693582e-02f, -2.16950942e-03f, 9.83753130e-02f, -8.46555736e-03f,
  7.43215233e-02f, 4.09670509e-02f, 1.44961178e-01f, -1.53314238e-02f, 5.24590835e-02f, 9.91885513e-02f, -3.74855241e-03f, -1.37814218e-02f, 1.14672286e-02f, 4.00055759e-02f,
  -1.99467734e-01f, 8.34951177e-02f, 1.28009534e-02f, -2.40753335e-03f, 1.56575561e-01f, 2.60264836e-02f, 1.10748641e-01f, 7.62424469e-02f, 7.36874342e-02f, -2.95694601e-02f,
  8.13333914e-02f, -6.64446354e-02f, 5.68388402e-02f, -2.34394409e-02f, -7.55470544e-02f, -4.24822755e-02f, -6.04354292e-02f, 6.94208369e-02f, -6.27915561e-02f, -1.61025636e-02f,
  -1.20374657e-01f, -1.71040118e-01f, -1.76477045e-01f, -1.25604361e-01f, -5.47323935e-02f, -7.83994421e-02f, -5.65415025e-02f, -1.32532641e-01f, -9.84244123e-02f, -3.40231717e-01f,
  7.14221179e-01f, 6.04434133e-01f, -2.14300901e-01f, 5.06451130e-01f, 9.22158957e-02f, -1.16099179e-01f, -1.18142188e-01f, 2.58306656e-02f, 2.15429619e-01f, 2.18554959e-01f,
  1.68603972e-01f, -6.59827739e-02f, -1.70784727e-01f, -2.81852245e-01f, -3.05791199e-01f, -6.27023131e-02f, -1.08511761e-01f, -3.83320957e-01f, -2.91100264e-01f, -1.19770363e-01f,
  1.10601686e-01f, 2.21623912e-01f, 2.02713862e-01f, 2.20491886e-02f, 3.30673575e-01f, 5.40111326e-02f, 8.44135657e-02f, 1.98933020e-01f, -1.52627543e-01f, 1.61813170e-01f,
  -1.03765950e-01f, 3.26237410e-01f, -2.16179878e-01f, 5.54180518e-02f, -6.99273590e-03f, 9.01718996e-03f, 2.57427767e-02f, 9.41618010e-02f, 2.33728383e-02f, 7.11774528e-02f,
  5.03151342e-02f, 1.02867730e-01f, 6.88367756e-03f, -1.51686203e-02f, 1.19163394e-01f, -2.29227692e-02f, 8.57086182e-02f, -1.08805396e-01f, -8.62765834e-02f, 1.13120014e-02f,
  -6.50666133e-02f, 3.04663740e-02f, -3.76085415e-02f, -4.91392054e-02f, -1.02620639e-01f, -7.12955669e-02f, -7.13183731e-03f, -1.48384478e-02f, -1.12511948e-01f, 2.11165175e-01f,
  9.90679711e-02f, -9.02774930e-03f, -7.97476918e-02f, 1.60751734e-02f, -3.41724940e-02f, -4.84275036e-02f, 4.04604115e-02f, -3.76672521e-02f, -8.35291296e-03f, 1.99421253e-02f,
  -7.58334100e-02f, 2.28904095e-02f, -1.59887709e-02f, 6.67615607e-02f, 3.81409377e-02f, -2.79412679e-02f, -2.51607061e-03f, 4.57917489e-02f, -1.03306596e-03f, 1.68496482e-02f,
  -8.02497342e-02f, -9.18602496e-02f, 1.06998906e-01f, -1.16674237e-01f, -6.22247942e-02f, -1.59023399e-03f, 7.19092339e-02f, -4.30941321e-02f, 9.90629941e-02f, 9.69855040e-02f,
  2.36005858e-01f, -2.93751925e-01f, 4.39427383e-02f, -8.43447149e-02f, 8.83832648e-02f, 7.38514513e-02f, 4.06447537e-02f, 1.22991437e-02f, 1.56789646e-02f, 3.59792113e-02f,
  -2.28479505e-03f, 5.53592779e-02f, -2.22277809e-02f, -6.67757392e-02f, -1.17734848e-02f, 3.51646356e-02f, 7.71507397e-02f, -5.10294177e-02f, -3.86651196e-02f, 3.55648547e-02f,
  7.44058639e-02f, 8.11110660e-02f, 3.54716815e-02f, -4.40519527e-02f, -5.25368657e-03f, -3.13205682e-02f, -1.14050187e-01f, -4.27959934e-02f, -4.96582873e-02f, 3.07198107e-01f,
  2.80767888e-01f, 2.38137707e-01f, -8.84526521e-02f, 1.15528144e-01f, 2.07813755e-01f, 3.40478539e-01f, 4.66474473e-01f, 8.77097398e-02f, 1.37449667e-01f, 2.85030663e-01f,
  3.78127419e-03f, -1.97867285e-02f, -9.82655063e-02f, -3.59797291e-02f, 9.83172134e-02f, 2.19944999e-01f, 2.25708827e-01f, -7.10018501e-02f, -7.51307979e-02f, 2.39344284e-01f,
  3.24887961e-01f, 2.07910523e-01f, 6.53196722e-02f, 2.96009313e-02f, 3.87105882e-01f, 1.43553779e-01f, 2.30989695e-01f, 2.90458411e-01f, 3.69789064e-01f, 3.44897717e-01f,
  1.30934089e-01f, 1.24116227e-01f, -3.51205505e-02f, 5.70899919e-02f, 1.33625478e-01f, 5.56354634e-02f, 1.45109445e-01f, -3.57430242e-02f, 7.75543451e-02f, 3.61346602e-02f,
  -6.38964698e-02f, 1.05372868e-01f, 6.50222376e-02f, 5.11824526e-02f, 1.17014781e-01f, 3.43922414e-02f, 2.00757831e-02f, 7.12305829e-02f, 2.40852199e-02f, 5.86112551e-02f,
  1.58566907e-01f, 2.25539610e-01f, 2.88797412e-02f, -2.63449866e-02f, 7.75203928e-02f, 1.71240624e-02f, 5.89507818e-02f, 1.45549372e-01f, 1.10125877e-01f, 4.14544582e-01f,
  6.17658235e-02f, -1.12171523e-01f, -8.14374611e-02f, -7.97267631e-02f, -5.83774708e-02f, -1.60180792e-01f, -5.01551898e-03f, -1.91137865e-02f, -1.74537003e-02f, -1.11817807e-01f,
  -1.05533652e-01f, -3.01008634e-02f, -4.44434509e-02f, 1.05667626e-02f, -5.43732867e-02f, -7.83280507e-02f, -5.29944636e-02f, 3.51253375e-02f, 4.37841341e-02f, -5.81548437e-02f,
  -2.24490035e-02f, -3.42886299e-02f, -6.99663162e-02f, -7.73984715e-02f, -4.12242748e-02f, -4.71673198e-02f, -8.43107477e-02f, -9.86234769e-02f, -1.29502699e-01f, -1.08739004e-01f,
  -1.17869854e-01f, -1.87743306e-01f, 1.58850282e-01f, 3.57609801e-02f, 1.15971066e-01f, 8.80614370e-02f, 4.64943983e-02f, 5.47300503e-02f, 9.18349177e-02f, 1.60953298e-01f,
  5.49078323e-02f, 8.34326744e-02f, 4.28481959e-02f, 1.30799502e-01f, 7.81095549e-02f, 1.80733457e-01f, 1.19505219e-01f, 1.16656512e-01f, 7.03439340e-02f, 5.48934266e-02f,
  1.67686403e-01f, 1.56182349e-01f, 4.19438779e-02f, 7.63120577e-02f, 1.46114334e-01f, 1.53223917e-01f, 2.34150160e-02f, 2.08690792e-01f, 1.51872352e-01f, 2.95146763e-01f,
  5.13955176e-01f, -2.57504821e-01f, -3.78491014e-01f, -2.26924568e-03f, -2.33435687e-02f, -2.21793041e-01f, -4.18816209e-01f, -5.39509170e-02f, 2.17688698e-02f, -9.93630663e-02f,
  2.52825648e-01f, 4.00837511e-01f, 2.39322245e-01f, 1.68870121e-01f, -1.65217766e-03f, -3.61465633e-01f, -4.32057023e-01f, -1.51627451e-01f, 6.60315901e-02f, 5.34309335e-02f,
  -5.18207476e-02f, -8.58875886e-02f, 1.17426611e-01f, 2.78850133e-03f, -2.78685167e-02f, 6.36359304e-02f, -2.09524244e-01f, 3.35610397e-02f, -1.17022745e-01f, -2.90546954e-01f,
  3.41857858e-02f, 2.50222236e-01f, -4.16200496e-02f, 1.19446293e-01f, 6.99341595e-02f, 8.90610814e-02f, -4.78028916e-02f, 7.35204741e-02f, 5.38622439e-02f, -1.07684378e-02f,
  6.65277615e-02f, 1.19266912e-01f, 3.37378345e-02f, 9.31680202e-02f, 7.85439461e-02f, -1.33521715e-02f, -5.87915396e-03f, 5.81553299e-03f, -4.73288409e-02f, 1.53498678e-02f,
  -5.66168614e-02f, -4.07546163e-02f, 5.76965697e-02f, -1.03767246e-01f, -4.31220122e-02f, 1.60872221e-01f, -9.51938331e-02f, 7.75252283e-02f, -7.81534091e-02f, -1.53781578e-01f,
  -5.77463098e-02f, 7.03360662e-02f, 5.42526767e-02f, 8.42353851e-02f, 5.42148761e-02f, 3.52511741e-02f, -3.12997773e-02f, 3.02260835e-02f, 1.37141421e-02f, -8.13023746e-02f,
  -1.44578991e-02f, 6.60561770e-02f, 2.69651384e-04f, 3.03587038e-02f, 2.72840541e-02f, -8.75520036e-02f, -3.17816995e-02f, -6.55515790e-02f, 7.27976784e-02f, -1.60944741e-02f,
  1.22761935e-01f, -6.61083963e-03f, 3.44353728e-02f, -3.62036638e-02f, 2.85245664e-02f, -3.42510715e-02f, 3.55896354e-02f, 5.87404445e-02f, -3.66207808e-02f, 1.07007185e-02f,
  -5.05245253e-02f, 2.43208874e-02f, -4.55508456e-02f, -1.51596256e-02f, -3.03112306e-02f, -2.69443747e-02f, -1.64106134e-02f, 2.46594213e-02f, 1.52352229e-01f, 5.39593305e-03f,
  7.83647448e-02f, 3.23629230e-02f, 1.44731114e-03f, -6.42912521e-04f, -2.57246327e-02f, 1.22858658e-02f, -1.61395948e-02f, -2.89861709e-02f, -9.33254045e-03f, -4.16996554e-02f,
  -6.18439540e-02f, -5.38201109e-02f, -1.22127950e-01f, -7.58597031e-02f, -5.06266057e-02f, -7.81811122e-03f, -1.01451397e-01f, -4.66951728e-02f, 1.33306789e-03f, -2.43777379e-01f,
  3.42676759e-01f, -7.52727330e-01f, -1.08282387e-01f, -2.57684380e-01f, 5.14743440e-02f, 6.38497099e-02f, -3.14069003e-01f, -2.45493174e-01f, -2.18914617e-02f, -3.40203911e-01f,
  -2.13266715e-01f, -4.41741906e-02f, -1.49826407e-01f, -2.49899328e-01f, -3.25620919e-01f, -4.17559981e-01f, -4.88124788e-01f, -1.45849913e-01f, 1.64302662e-02f, -2.53502354e-02f,
  -1.14077047e-01f, -2.23528057e-01f, -1.90415889e-01f, -2.57463723e-01f, -1.77237183e-01f, -6.32957667e-02f, -4.14063066e-01f, -1.51366621e-01f, -2.13235736e-01f, -3.02785307e-01f,
  1.71214312e-01f, -5.57677858e-02f, 7.70976022e-02f, -1.81624189e-01f, -1.21719502e-01f, 4.09786738e-02f, -4.94566448e-02f, -1.08289413e-01f, -8.38115662e-02f, -9.67054963e-02f,
  -1.08663522e-01f, -4.72839139e-02f, -8.10481608e-02f, -3.12283058e-02f, -8.17024410e-02f, -4.76439372e-02f, -2.28589043e-01f, -1.85509443e-01f, -1.86865881e-01f, -1.29368976e-01f,
  -2.69454241e-01f, -9.05385092e-02f, -1.39989242e-01f, -1.59859523e-01f, -2.14789182e-01f, -2.11232398e-02f, -2.19104588e-01f, -1.15098223e-01f, -1.92314580e-01f, -1.86988190e-01f,
  -5.15268184e-02f, 1.36949450e-01f, 1.94382980e-01f, 1.13735273e-01f, 6.14851229e-02f, 1.73017427e-01f, 9.26785618e-02f, 9.07783434e-02f, 8.41634795e-02f, 7.05163777e-02f,
  3.71092372e-02f, 1.15928955e-01f, 3.76139320e-02f, -7.22196847e-02f, 8.68475512e-02f, -1.42997818e-03f, 5.90675808e-02f, -4.73218854e-04f, 1.49581388e-01f, 7.85034671e-02f,
  1.22002117e-01f, 1.07990161e-01f, 6.20988533e-02f, 7.49514764e-03f, 4.92714904e-02f, 1.16010541e-02f, 6.15372881e-02f, 9.23643187e-02f, 1.45628572e-01f, 1.07858196e-01f,
  -5.32389432e-02f, -1.25951990e-01f, -2.67401561e-02f, -9.86197963e-02f, -6.10008240e-02f, -1.39528394e-01f, -9.52610672e-02f, -9.76088941e-02f, -7.07042357e-03f, -9.64002013e-02f,
  -1.34332731e-01f, -9.80901942e-02f, -2.40994424e-01f, -1.30118519e-01f, -6.50045872e-02f, -7.15193897e-02f, -2.48116687e-01f, -7.63886869e-02f, -1.58125788e-01f, -9.93881300e-02f,
  -3.30432177e-01f, -6.18237853e-02f, 2.77647395e-02f, -8.09998438e-02f, -1.58578441e-01f, 1.15396529e-01f, 1.91577543e-02f, -5.44022629e-03f, 1.37551036e-02f, -2.85397828e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.78755915e+00f, -3.98432642e-01f, -2.89482743e-01f, -4.42550302e-01f, 3.71878862e-01f, 2.02003613e-01f, 3.47607255e-01f, -8.84831995e-02f, -3.58709037e-01f, -4.47214067e-01f,
  -3.75211865e-01f, -6.55578822e-02f, -6.57447204e-02f, 4.00866151e-01f, 3.37372780e-01f, 2.86874831e-01f, 7.97430813e-01f, 3.97910178e-01f, 3.40177417e-01f, 2.07620263e-01f,
  4.37528938e-01f, -2.26112589e-01f, -3.24389756e-01f, 2.70563215e-01f, -2.78831184e-01f, 2.66615570e-01f, 1.51917994e-01f, -1.02361917e-01f, 5.61651513e-02f, -4.07458991e-02f,
  -1.04353666e+00f, -6.23022556e-01f, 5.21148682e-01f, -1.06786333e-01f, -1.20355591e-01f, -2.01765984e-01f, 9.36361682e-03f, -2.41559476e-01f, 9.47292820e-02f, -1.20664082e-01f,
  -1.06571369e-01f, -1.36694416e-01f, 6.69912323e-02f, 1.34055957e-01f, -1.75116390e-01f, -2.53106266e-01f, 1.56138405e-01f, 2.88635138e-02f, -9.41365808e-02f, -2.84999073e-01f,
  3.23879361e-01f, -2.76649386e-01f, -6.51819229e-01f, 4.28123921e-01f, -2.42503677e-02f, 2.39116311e-01f, -7.63858408e-02f, -4.21165258e-01f, -2.33892918e-01f, -7.76270330e-01f,
  -6.97854385e-02f, -2.58384757e-02f, 7.30815455e-02f, 7.30404407e-02f, 2.88144469e-01f, -1.32290527e-01f, 1.40336005e-03f, 1.92711964e-01f, 1.45062119e-01f, -2.76778545e-02f,
  1.75374076e-01f, 6.53942823e-02f, 7.56787509e-02f, -2.30741948e-01f, 6.84141144e-02f, 6.92190975e-02f, -8.29322040e-02f, 1.33294284e-01f, 1.70349658e-01f, 5.09192646e-02f,
  -1.73177049e-01f, 4.92148399e-02f, -6.20050095e-02f, 1.47024855e-01f, 2.09973916e-01f, 1.69724882e-01f, 4.13155369e-02f, -5.87159283e-02f, -6.85249269e-02f, 5.65138785e-03f,
  -4.87597525e-01f, 5.73972881e-01f, -5.82480431e-01f, 3.12040467e-02f, -1.62732616e-01f, 9.38001499e-02f, 6.34069145e-02f, 6.33439049e-02f, -1.93552345e-01f, -2.48580441e-01f,
  1.33982122e-01f, -2.50985712e-01f, -1.76026225e-01f, 2.84545690e-01f, 1.23353586e-01f, -1.86100870e-01f, 1.38723537e-01f, -5.51807359e-02f, 1.37257278e-01f, -1.01807207e-01f,
  1.30409330e-01f, 1.31827980e-01f, -8.13283503e-01f, -1.50917426e-01f, -2.22987592e-01f, -5.05549192e-01f, -2.56550759e-01f, -4.15442497e-01f, -4.00951564e-01f, -5.42242825e-01f,
  -1.46048144e-01f, -4.63761747e-01f, -5.03799655e-02f, 7.80884027e-01f, 7.47873724e-01f, 5.58587313e-01f, 4.19712007e-01f, 4.01076376e-01f, 3.36069703e-01f, 2.71499693e-01f,
  3.99392903e-01f, 5.22306740e-01f, 3.74473602e-01f, 2.36566663e-01f, 8.99251550e-02f, 3.50007832e-01f, 5.06483018e-01f, -9.63456854e-02f, 2.09606066e-01f, 4.06376421e-01f,
  3.76986206e-01f, 1.19442418e-01f, -1.20632879e-01f, 9.90545154e-02f, 1.22560225e-01f, 4.28304493e-01f, 1.86391786e-01f, 6.88920692e-02f, 6.50172606e-02f, -1.13673538e-01f,
  -3.16022336e-01f, -1.00134686e-01f, 2.64026046e-01f, 4.98216003e-02f, -1.76865473e-01f, -3.34461600e-01f, -8.50316361e-02f, -1.43322781e-01f, -2.45204970e-01f, 1.87680367e-02f,
  -1.18803896e-01f, -2.25654230e-01f, -2.40429901e-02f, -1.41372725e-01f, -8.42302106e-03f, -1.19144067e-01f, -1.55503616e-01f, 9.68263373e-02f, 1.49477080e-01f, -1.31712845e-02f,
  -7.49208964e-03f, 2.37389784e-02f, 1.56972438e-01f, 3.76828909e-02f, 1.23948045e-02f, 1.55527860e-01f, -2.10788459e-01f, -1.32318258e-01f, -6.01741951e-03f, -1.32509265e-02f,
  3.59367728e-01f, -6.38217991e-03f, 1.02660619e-01f, 4.86344919e-02f, 1.55927567e-02f, 1.09058358e-01f, 1.33204937e-01f, 1.26077637e-01f, 2.52779543e-01f, 1.36043327e-02f,
  1.40215740e-01f, 1.90193713e-01f, 1.23641402e-01f, 1.22895479e-01f, 1.69386789e-01f, 2.55175456e-02f, -2.57002622e-01f, 9.26177017e-03f, -1.10396519e-02f, -6.22629840e-03f,
  -1.51882827e-01f, -7.15618134e-02f, -1.84802070e-01f, -2.22679779e-01f, 2.25184243e-02f, 1.78458735e-01f, 1.10300735e-01f, -2.68929582e-02f, 1.10678049e-02f, 1.86262317e-02f,
  4.50810879e-01f, 2.85484552e-01f, 2.04114281e-02f, 3.88746299e-02f, -4.60708626e-02f, -2.16703534e-01f, -3.15135866e-02f, -1.38456047e-01f, -2.84638345e-01f, -6.11374117e-02f,
  -1.31642714e-01f, -2.52464771e-01f, -1.36157453e-01f, -5.31103648e-02f, -1.15968145e-01f, 1.86770651e-02f, -1.27455071e-01f, 9.67659056e-02f, 3.74891423e-02f, -8.58365148e-02f,
  -2.34915987e-01f, 2.43569374e-01f, 2.25757167e-01f, 1.13977931e-01f, -2.78303809e-02f, 1.54142231e-01f, -1.89052865e-01f, -7.90343285e-02f, 6.13843277e-02f, 1.13295363e-02f,
  1.35510397e+00f, 4.48655933e-02f, 4.93354470e-01f, 1.00935750e-01f, -3.95785153e-01f, -3.48770410e-01f, -3.63468200e-01f, -1.67651832e-01f, -4.43414599e-02f, -5.72935157e-02f,
  -9.47462842e-02f, 6.65591583e-02f, 2.29829699e-01f, 2.15031430e-01f, 3.74838799e-01f, -6.92340583e-02f, -9.58873704e-02f, 4.95941043e-01f, 2.77772516e-01f, -1.50221303e-01f,
  -1.70976743e-01f, 6.59771543e-03f, 3.19878250e-01f, 1.72579825e-01f, -1.58388048e-01f, -1.65054038e-01f, -8.50747824e-02f, -1.30849496e-01f, -8.01380277e-02f, -5.40797673e-02f,
  1.10517465e-01f, 4.37662303e-01f, -5.19637428e-02f, -4.88315299e-02f, 7.60851651e-02f, 7.13237822e-02f, -7.86009133e-02f, -1.00691967e-01f, -2.26842031e-01f, -2.96251357e-01f,
  -1.39929533e-01f, 1.19058490e-01f, 2.12579399e-01f, -7.28933141e-02f, -1.48426041e-01f, -1.17458649e-01f, 1.09694995e-01f, 1.45017818e-01f, -4.16367408e-03f, -4.95425835e-02f,
  -1.43442862e-02f, -3.64401080e-02f, -1.62559167e-01f, -1.48528486e-01f, 9.65122804e-02f, 1.06898323e-01f, 6.81836233e-02f, 1.62851527e-01f, 1.63483828e-01f, -3.42297405e-02f,
  1.18132889e-01f, 2.89599776e-01f, 1.82693660e-01f, 1.36246979e-01f, -3.95007012e-03f, -1.29202306e-01f, -1.21401347e-01f, -1.70263439e-01f, 1.36942104e-01f, 2.08463639e-01f,
  -7.84141645e-02f, 1.07898876e-01f, -1.68029461e-02f, -1.04783826e-01f, 1.06857643e-01f, 2.46634111e-02f, -4.73886542e-02f, -1.47296056e-01f, 1.05026858e-02f, 1.68153495e-02f,
  6.59205765e-02f, -1.26850139e-03f, 7.53671154e-02f, -3.28825526e-02f, -1.57428026e-01f, 1.03251554e-01f, -7.18804374e-02f, -9.50269252e-02f, -3.26979421e-02f, -3.12317926e-02f,
  -6.04663432e-01f, 4.27172095e-01f, 1.84050232e-01f, 1.96703091e-01f, 6.15362898e-02f, 1.40019268e-01f, 1.94940433e-01f, -7.30330348e-02f, -2.70367026e-01f, -9.88090485e-02f,
  -2.12380625e-02f, 1.83234230e-01f, 1.40013888e-01f, 5.32943755e-02f, 3.87951522e-03f, 4.21440899e-02f, 3.41421179e-02f, 7.20499530e-02f, -4.91395891e-02f, -1.27440512e-01f,
  -5.40891953e-04f, -1.86939567e-01f, -2.23000884e-01f, -2.55132411e-02f, -3.65511738e-02f, 3.66789848e-02f, -2.14601401e-03f, -1.18769839e-01f, 8.39541033e-02f, -1.08111411e-01f,
  3.01022142e-01f, 6.47944391e-01f, -1.19868867e-01f, 5.31660676e-01f, -5.03828108e-01f, -6.08363807e-01f, -3.10631990e-01f, 1.69720575e-01f, 3.14941317e-01f, 5.42663872e-01f,
  -3.08469772e-01f, -6.84248090e-01f, -2.52829585e-02f, -2.94864893e-01f, -3.98682296e-01f, 5.65127015e-01f, 7.15675950e-01f, -3.30322355e-01f, -1.23093176e+00f, -9.25977767e-01f,
  -1.29555896e-01f, 1.69040188e-01f, 3.42220366e-02f, -1.24829680e-01f, 6.25028133e-01f, -1.26962569e-02f, 6.67394519e-01f, 2.90684164e-01f, -1.59743875e-01f, 8.15611184e-01f,
  -1.59780398e-01f, 2.52928715e-02f, -5.04165769e-01f, -2.16815978e-01f, -1.22815281e-01f, 1.18568271e-01f, -1.65024608e-01f, 2.61457801e-01f, -2.06436068e-01f, 2.84893483e-01f,
  -2.51571536e-01f, 9.77818519e-02f, -3.60453099e-01f, -2.01561406e-01f, -1.01373956e-01f, -3.05091798e-01f, 2.78730124e-01f, -1.13300167e-01f, 1.46889850e-01f, -3.46089721e-01f,
  -1.23075165e-01f, -3.74427289e-01f, -4.70260501e-01f, 7.17327371e-02f, -3.38667125e-01f, -3.29931885e-01f, -3.29164296e-01f, -3.64654541e-01f, -4.09278393e-01f, 8.18933368e-01f,
  -4.72862199e-02f, 5.12576178e-02f, 6.94292039e-02f, 1.00102529e-01f, 7.79261142e-02f, -1.75320491e-01f, 4.07748595e-02f, 6.27975985e-02f, 1.56113021e-02f, -5.05388267e-02f,
  -4.04599272e-02f, 5.73015250e-02f, 1.11844321e-03f, -2.51078662e-02f, -1.08950995e-01f, 5.39959595e-02f, -8.92749727e-02f, 1.99743330e-01f, 2.75214277e-02f, 1.08914599e-01f,
  -2.42367521e-01f, -2.50593349e-02f, 2.35032901e-01f, -1.20447837e-02f, -8.67996663e-02f, 5.33340052e-02f, -4.29210020e-03f, -1.97060838e-01f, 1.12273738e-01f, -1.17319040e-01f,
  3.46039951e-01f, -5.04668415e-01f, 3.59375119e-01f, -7.05997571e-02f, 2.96713077e-02f, -1.89006448e-01f, 1.11587390e-01f, -1.06718659e-01f, 3.56421657e-02f, -1.73562795e-01f,
  -3.05328071e-01f, -1.71533003e-01f, 3.07639629e-01f, 1.38327688e-01f, -1.70341775e-01f, -2.21489951e-01f, 1.48991108e-01f, -2.23062143e-01f, -4.04833723e-03f, 1.32172734e-01f,
  3.61179471e-01f, -1.44208567e-02f, -1.69299856e-01f, 1.79500684e-01f, -1.46808941e-02f, -3.78405213e-01f, 6.30490407e-02f, -2.45339647e-01f, -4.74971682e-01f, 7.04101801e-01f,
  -1.22303748e+00f, 1.02084136e+00f, 3.94986540e-01f, -4.68096256e-01f, 5.23072183e-01f, 6.21917844e-01f, 9.78254199e-01f, 7.03821480e-02f, -4.47223604e-01f, 6.05298042e-01f,
  5.61005592e-01f, -5.76715052e-01f, -1.34332374e-01f, -2.32781112e-01f, -1.37443140e-01f, 7.08051920e-01f, 4.98701334e-01f, -4.66667980e-01f, -1.01233935e+00f, -4.97015536e-01f,
  3.83025184e-02f, -4.02512223e-01f, -9.26195502e-01f, -5.47529876e-01f, -3.50215845e-03f, -3.56999576e-01f, 4.59223628e-01f, 1.27579793e-01f, 5.43349922e-01f, 9.08153802e-02f,
  -1.86962605e-01f, 2.98986137e-01f, -3.78619343e-01f, -2.08869919e-01f, 2.24891320e-01f, -1.10186055e-01f, -5.57319596e-02f, -1.26300976e-01f, 9.79475528e-02f, -4.40501235e-02f,
  1.88505039e-01f, 1.20546952e-01f, 2.94752926e-01f, 9.17314067e-02f, -6.63513839e-02f, -2.56812684e-02f, -5.44102043e-02f, -3.94195944e-01f, -1.42129868e-01f, 1.40030667e-01f,
  3.52855682e-01f, 3.15037608e-01f, 1.25614598e-01f, 1.97665110e-01f, 8.92769918e-02f, -2.61788607e-01f, 1.49487004e-01f, -4.77118567e-02f, -9.82181355e-02f, -1.75830498e-01f,
  -2.10506152e-02f, 6.94516078e-02f, 4.14552614e-02f, -2.71726605e-02f, 5.14214151e-02f, 6.49687275e-02f, 4.68704440e-02f, -1.29625037e-01f, 3.45907919e-02f, 6.15300685e-02f,
  -3.90697196e-02f, -2.34545078e-02f, -1.61209609e-02f, 9.00414288e-02f, 8.21052585e-03f, 1.43229052e-01f, 2.60794729e-01f, 1.52486833e-02f, 4.87072244e-02f, -4.80129896e-03f,
  -7.76669979e-02f, 7.76082724e-02f, -8.74303877e-02f, -1.17534153e-01f, 2.81441957e-01f, 6.15757890e-02f, 3.31738219e-02f, 2.42825039e-02f, -1.73000880e-02f, 3.93441677e-01f,
  -5.24372101e-01f, 4.40703213e-01f, -2.43864134e-01f, -3.46426852e-02f, 2.19805300e-01f, 1.17813312e-02f, 1.49457350e-01f, 1.51260927e-01f, 5.24143577e-02f, -3.52600992e-01f,
  6.62882626e-02f, -5.96006983e-04f, 3.42596412e-01f, -1.04366735e-01f, -4.39320356e-01f, -8.42709988e-02f, 1.84676528e-01f, -1.99251577e-01f, -6.96861418e-03f, 6.52703270e-02f,
  9.84174162e-02f, -2.44718850e-01f, -6.09854162e-01f, -2.48500645e-01f, -4.71960120e-02f, -4.86932158e-01f, -2.54733622e-01f, -1.65321410e-01f, -2.24184364e-01f, -5.73980987e-01f,
  -6.88564718e-01f, -8.01110029e-01f, -3.14287990e-01f, 1.18925072e-01f, 4.38011616e-01f, -6.92354679e-01f, -1.45935297e+00f, -7.92799175e-01f, -1.32887781e-01f, -4.05636817e-01f,
  1.79876685e-01f, 5.16511381e-01f, -1.28322765e-01f, 8.73292163e-02f, -4.08681154e-01f, -5.16069353e-01f, -8.00478607e-02f, 1.98973060e-01f, 4.21335489e-01f, 2.58519500e-01f,
  4.17314738e-01f, 3.76761317e-01f, 3.96748662e-01f, 1.72890663e-01f, 5.49404323e-01f, 1.91146433e-01f, -5.22812940e-02f, 5.21520138e-01f, -8.18149224e-02f, 4.58686024e-01f,
  3.44778240e-01f, -5.48008740e-01f, -1.59671411e-01f, 6.10215962e-01f, 5.74552238e-01f, -4.94917572e-01f, -3.27187777e-01f, -4.23619300e-02f, -7.89814740e-02f, -1.99071378e-01f,
  4.63299602e-01f, 1.73894927e-01f, 3.97469044e-01f, -1.30770370e-01f, 3.39207649e-02f, -3.18496943e-01f, -1.65591896e-01f, -3.54114920e-01f, -3.96976054e-01f, -1.64790764e-01f,
  5.04241228e-01f, 5.95129609e-01f, -1.36844113e-01f, -2.59936601e-01f, -4.64757591e-01f, 4.52671230e-01f, -1.51658282e-01f, 1.13482885e-01f, -7.35418022e-01f, -1.43510878e-01f,
  2.77852006e-02f, 5.42818010e-02f, -1.25926316e-01f, -3.72218817e-01f, 1.06960371e-01f, 5.29478118e-02f, 2.78747290e-01f, 2.27375954e-01f, -3.19544524e-02f, -2.10725382e-01f,
  -1.32980898e-01f, 7.86427185e-02f, -1.29166746e-03f, -7.82057121e-02f, 1.38360754e-01f, 1.15135938e-01f, 7.57215396e-02f, 1.02639645e-01f, 1.48015514e-01f, -1.03353083e-01f,
  3.74609940e-02f, 4.43730317e-02f, 1.25125870e-01f, -6.53053746e-02f, -2.59831697e-01f, -1.06358834e-01f, 8.53335410e-02f, -9.04895589e-02f, 1.12661466e-01f, -1.77204803e-01f,
  -1.68063852e-03f, 9.83447656e-02f, -2.12269232e-01f, 1.62291422e-01f, 7.44714662e-02f, 1.22558393e-01f, 1.13521867e-01f, -1.59225598e-01f, 2.05598444e-01f, -2.67855048e-01f,
  -1.41175464e-01f, -2.48493940e-01f, 1.84849471e-01f, -1.94367856e-01f, 7.51707181e-02f, -4.28825259e-01f, -1.31055474e-01f, -3.83279383e-01f, -2.61678010e-01f, 1.85092241e-01f,
  -2.41601855e-01f, -2.15525001e-01f, -4.43889469e-01f, -7.41409242e-01f, 1.36090457e-01f, -3.66365194e-01f, -4.42512810e-01f, -2.12658510e-01f, -8.45613480e-01f, -1.17838287e+00f,
  -1.20331621e+00f, -2.62798518e-02f, 4.78988469e-01f, -3.51768076e-01f, 8.79248440e-01f, 2.98599631e-01f, -4.54960227e-01f, -2.74319977e-01f, -1.35433802e-03f, -3.06771249e-01f,
  2.96715289e-01f, 2.98870385e-01f, -3.34254116e-01f, -2.66831696e-01f, -1.15504575e+00f, -8.18091691e-01f, -5.38880706e-01f, -7.63928115e-01f, -3.61798257e-01f, 3.76336873e-02f,
  2.41673008e-01f, -2.03757361e-01f, -6.39174998e-01f, -4.47632700e-01f, -2.94380300e-02f, -1.64811045e-01f, -1.25121564e-01f, -1.57330215e-01f, -1.16128467e-01f, -4.55629975e-02f,
  -3.61344755e-01f, -3.27387974e-02f, 2.70972371e-01f, 8.73216093e-02f, 2.24114075e-01f, -2.58042246e-01f, -1.49532348e-01f, 1.52162537e-01f, 7.60270134e-02f, -1.81284606e-01f,
  1.69835076e-01f, 1.30524844e-01f, 2.78818190e-01f, 1.79435775e-01f, -3.86549234e-02f, -2.39855736e-01f, 1.18059978e-01f, -2.79772341e-01f, -5.08571267e-01f, -1.09098461e-02f,
  4.01651323e-01f, 1.43464245e-02f, -4.92580682e-01f, 7.11453110e-02f, -3.66405815e-01f, -7.74293542e-02f, 3.11133534e-01f, -5.16271964e-02f, -3.22277069e-01f, -4.78483915e-01f,
  4.86569479e-02f, -1.71935320e-01f, 2.40578666e-01f, -2.77877655e-02f, -8.60291794e-02f, 7.14561418e-02f, -1.91411480e-01f, -2.80668139e-01f, -1.16665125e-01f, -5.78214079e-02f,
  5.69896773e-02f, 1.72185674e-01f, -8.77980292e-02f, -2.12121233e-01f, -2.48013943e-01f, 8.55435506e-02f, 1.57994498e-03f, -3.80355120e-01f, -3.51614743e-01f, -1.32343918e-01f,
  -1.10311247e-01f, -5.20564057e-02f, 1.14652239e-01f, -2.30964750e-01f, 5.30463420e-02f, -2.57068098e-01f, 2.27521092e-01f, 1.98455766e-01f, 1.59753755e-01f, 4.33454812e-02f,
  -4.82538670e-01f, 3.14178437e-01f, -6.74367011e-01f, -6.97408095e-02f, -8.40894133e-02f, 1.14281021e-01f, -3.76267475e-03f, 1.25180259e-01f, 1.13675445e-01f, -1.95844010e-01f,
  -2.90828682e-02f, -2.22683355e-01f, -4.90748584e-02f, 1.85962468e-01f, 4.60673049e-02f, -6.33844733e-02f, -1.59257337e-01f, -2.01360762e-01f, -1.65801793e-01f, 2.38342449e-01f,
  -2.01807931e-01f, -8.47269654e-01f, -7.86462545e-01f, -3.34812790e-01f, -3.27382714e-01f, -6.35352254e-01f, -6.25685275e-01f, -4.10653412e-01f, -8.30705345e-01f, -1.21336627e+00f,
  -1.09301805e+00f, -8.90921354e-02f, 3.51775914e-01f, 1.69088185e-01f, 4.17153835e-01f, -4.61385041e-01f, -6.87338352e-01f, -7.53546417e-01f, -3.56065780e-02f, 2.82198489e-01f,
  6.01659775e-01f, 5.26299298e-01f, 5.05819023e-01f, -6.36802092e-02f, -7.80211687e-01f, -3.19417715e-01f, -3.44516635e-01f, -6.99537516e-01f, -7.79870808e-01f, -4.89286631e-01f,
  -5.80774061e-02f, -1.65768817e-01f, -5.90558767e-01f, -3.01332980e-01f, 7.03141868e-01f, 4.12123263e-01f, 4.48454320e-01f, 3.16373557e-01f, -7.32769072e-02f, 5.94211698e-01f,
  7.30832815e-01f, -1.19142488e-01f, -1.58790573e-01f, -2.58073449e-01f, 2.40073293e-01f, -1.99095055e-01f, -9.99897048e-02f, -1.26566470e-01f, -1.12925284e-02f, -3.27008241e-03f,
  1.36687547e-01f, -1.79907847e-02f, -3.31695974e-02f, 1.84648588e-01f, -1.24042660e-01f, -3.71853635e-02f, -1.38480559e-01f, -2.76488751e-01f, -1.01282068e-01f, 2.58332133e-01f,
  3.27492386e-01f, 9.40438882e-02f, -1.10245207e-02f, -1.86046794e-01f, -2.27662146e-01f, 5.96605241e-02f, 7.00285584e-02f, -7.60191604e-02f, -2.46198818e-01f, 2.95665581e-02f,
  4.15132344e-02f, 1.36568502e-01f, -4.95845303e-02f, 1.26573384e-01f, 1.15814798e-01f, 1.08579315e-01f, 1.36652187e-01f, 5.91550842e-02f, -1.15036391e-01f, 8.32265541e-02f,
  1.14149734e-01f, 6.47849739e-02f, 9.64685716e-03f, -3.05343959e-02f, 1.04285032e-01f, 6.65580034e-02f, 1.51480157e-02f, -6.53209239e-02f, 4.27002832e-02f, 9.52776615e-03f,
  2.59771035e-03f, -1.56256646e-01f, 2.29987428e-01f, 7.21522495e-02f, -1.24092206e-01f, -5.51564842e-02f, 1.15873098e-01f, -3.81684154e-02f, 1.06358631e-02f, 9.37441662e-02f,
  2.31593579e-01f, -3.99405748e-01f, 3.45385104e-01f, -2.26105168e-01f, 6.89156875e-02f, 2.56163962e-02f, 3.04373056e-01f, -5.92592806e-02f, 1.32554710e-01f, 1.37199406e-02f,
  -1.01341888e-01f, -8.55438113e-02f, 8.74902308e-02f, 1.03129391e-02f, -1.19518191e-02f, 1.57302804e-02f, -3.32006961e-02f, 1.61271065e-01f, -1.47261262e-01f, 2.26387754e-01f,
  -6.16532862e-02f, -2.43615225e-01f, -2.04272270e-01f, 9.33451429e-02f, -6.07366636e-02f, -1.41840547e-01f, 1.80017263e-01f, 1.14418149e-01f, -2.22992852e-01f, -8.86475891e-02f,
  8.51547122e-01f, -2.34174401e-01f, 3.99484992e-01f, 3.51776570e-01f, 7.37509489e-01f, 6.33145750e-01f, 6.98433936e-01f, 6.43134415e-02f, -3.50484401e-02f, 1.48640245e-01f,
  -1.92568913e-01f, -6.18334532e-01f, -8.34389508e-01f, -6.59523249e-01f, -5.23932278e-01f, 6.50161281e-02f, 3.93319219e-01f, 1.51231751e-01f, 1.38434634e-01f, 3.16597164e-01f,
  1.01761699e-01f, 4.54058260e-01f, 2.10139170e-01f, -1.84198543e-02f, 2.15789899e-01f, -8.07609707e-02f, 1.68654829e-01f, 4.26959008e-01f, -7.96321332e-02f, 1.04981177e-01f,
  -6.37246296e-04f, 7.79803768e-02f, -2.74855435e-01f, -2.60730326e-01f, 1.82867199e-02f, -2.70657957e-01f, 1.95734557e-02f, -1.90641969e-01f, -5.16348667e-02f, 6.39717504e-02f,
  1.94986239e-01f, 1.22935558e-02f, 7.42345229e-02f, -9.96591300e-02f, 1.63015381e-01f, 1.34393901e-01f, -7.59972408e-02f, -3.82679790e-01f, -5.31220555e-01f, -2.16865733e-01f,
  -7.52208233e-02f, 3.41107994e-01f, 3.65349203e-01f, -2.50279933e-01f, -3.28260332e-01f, -1.01665355e-01f, -1.51781589e-02f, -1.69178158e-01f, -2.50924289e-01f, -1.22521795e-01f,
  -5.34164459e-02f, -1.31297871e-01f, 1.50172710e-01f, -5.17044589e-02f, 1.11032113e-01f, 2.75863409e-02f, -4.53306176e-02f, 1.59020066e-01f, 1.02952264e-01f, 2.69349307e-01f,
  -1.71974510e-01f, -1.01641044e-01f, -1.14968501e-01f, -6.91464171e-02f, -2.34413430e-01f, 4.96863388e-02f, 1.61682516e-01f, -2.50293344e-01f, -1.09491795e-01f, 1.54056564e-01f,
  1.51210753e-02f, 2.55826209e-02f, 1.09133035e-01f, -1.31410912e-01f, -2.86802109e-02f, -1.40487909e-01f, -4.00855206e-02f, -1.02389537e-01f, -1.00373864e-01f, 1.30622894e-01f,
  -6.24025539e-02f, -3.85673553e-01f, -9.91463587e-02f, -4.05052155e-01f, 2.28326187e-01f, -1.39762178e-01f, -9.01118889e-02f, -1.24608919e-01f, 9.38180685e-02f, -2.81586021e-01f,
  -3.82027924e-02f, -2.40941480e-01f, -1.78643271e-01f, 1.98359955e-02f, 3.42626482e-01f, 1.46889493e-01f, -4.34933417e-02f, 1.69273272e-01f, -2.85182655e-01f, -1.30628407e-01f,
  -7.10088834e-02f, 2.83634812e-01f, 2.70285517e-01f, -2.53171682e-01f, -3.56857121e-01f, 3.90038490e-02f, 1.90650478e-01f, 1.41282752e-01f, -9.02296677e-02f, 2.79430717e-01f,
  -4.10214113e-03f, 5.84372759e-01f, 5.32936215e-01f, -6.02678239e-01f, 6.83366433e-02f, 3.87686729e-01f, 5.19372642e-01f, -2.31495202e-02f, -4.52242672e-01f, 2.46584550e-01f,
  6.76348031e-01f, 2.59430230e-01f, 2.82421291e-01f, 3.98003459e-01f, 4.31726724e-01f, 2.26284012e-01f, -1.33893371e-01f, 8.39687884e-02f, -8.64066929e-03f, -1.12840913e-01f,
  -4.03029799e-01f, -4.63388741e-01f, -2.52254456e-01f, -2.09566191e-01f, -3.79460454e-01f, -2.73600489e-01f, 1.28666490e-01f, 1.80607347e-03f, 4.50847983e-01f, -4.50817317e-01f,
  4.38485205e-01f, 1.51914507e-01f, -2.39515275e-01f, -1.23480722e-01f, 1.36876076e-01f, -2.94292837e-01f, 2.51746196e-02f, -2.74760395e-01f, -8.46821740e-02f, -1.72106355e-01f,
  -6.72605680e-03f, -2.18920395e-01f, -3.84346992e-02f, -5.09640649e-02f, 3.08824498e-02f, -6.10493384e-02f, -1.96186125e-01f, -1.08636402e-01f, 3.45721766e-02f, 2.22538576e-01f,
  -1.32836446e-01f, 5.49160242e-02f, 3.32114607e-01f, 1.43063977e-01f, 2.44238496e-01f, -5.56989536e-02f, 3.20657402e-01f, -9.37332064e-02f, 3.28898937e-01f, -4.50994849e-01f,
  -4.35744002e-02f, -1.00264177e-01f, 7.56981224e-02f, -1.15126200e-01f, 2.95905136e-02f, 3.09785400e-02f, 4.39277291e-02f, 2.04267502e-01f, 9.86562446e-02f, -1.75750598e-01f,
  -3.42154615e-02f, 1.71934113e-01f, 9.38535258e-02f, 2.29518153e-02f, -9.99223664e-02f, -1.15379982e-01f, -2.26024748e-03f, 1.07575074e-01f, 2.77975380e-01f, -1.64788999e-02f,
  -1.59738287e-01f, -5.99615686e-02f, -6.14869148e-02f, -1.41005486e-01f, 4.14522067e-02f, -5.10905869e-02f, -1.00278676e-01f, -6.74371747e-03f, -4.52286936e-02f, -2.24186093e-01f,
  -1.81204364e-01f, 4.77556199e-01f, -1.46084532e-01f, -3.68262990e-03f, 6.52235467e-03f, 1.07066318e-01f, 3.53911854e-02f, -5.41512594e-02f, 2.68683750e-02f, -8.59881286e-03f,
  1.38692215e-01f, -6.27326742e-02f, 4.75603268e-02f, -1.06793001e-01f, -1.85805976e-01f, -1.70890868e-01f, -2.15547998e-02f, 4.30013575e-02f, 1.54621035e-01f, -1.68535531e-01f,
  -2.44217992e-01f, -1.22279644e-01f, 1.00431554e-01f, -1.58113632e-02f, -1.81347817e-01f, -1.28441826e-01f, 4.34084125e-02f, -1.99436083e-01f, 3.28769296e-01f, -2.78561741e-01f,
  1.34435976e+00f, 1.80856258e-01f, -1.91015637e+00f, 7.36267194e-02f, -1.10206711e+00f, -7.24226832e-01f, 6.58125728e-02f, 6.22551262e-01f, 5.48135459e-01f, 1.49295166e-01f,
  2.18350798e-01f, 1.41770482e-01f, -2.85276413e-01f, -3.19495022e-01f, 6.78199902e-02f, -4.81463790e-01f, -7.66038179e-01f, -9.37094867e-01f, -6.96606696e-01f, -1.83351353e-01f,
  9.01089236e-03f, -9.36955586e-02f, -1.49757832e-01f, -2.42598131e-01f, -4.58051324e-01f, -5.06555140e-01f, -9.72593546e-01f, -7.78346658e-01f, -9.06080663e-01f, -1.28277385e+00f,
  -1.15521002e+00f, -1.65825576e-01f, -5.97195268e-01f, 2.44855568e-01f, -3.07217479e-01f, 2.29430974e-01f, -1.71463773e-01f, -1.58843175e-01f, 8.11345801e-02f, 6.83554402e-03f,
  -3.33528042e-01f, 1.39830455e-01f, -9.55791399e-02f, -4.55129713e-01f, -1.91779882e-01f, 1.45427838e-01f, -4.87499982e-02f, -3.47157359e-01f, -2.67353505e-01f, 3.25313173e-02f,
  7.45208114e-02f, -2.59682894e-01f, -6.18012667e-01f, -1.32564232e-01f, -2.66480178e-01f, -2.52685070e-01f, -5.72568834e-01f, -3.81906688e-01f, -5.18891692e-01f, -2.30095536e-01f,
  2.02257216e-01f, -2.75419541e-02f, -4.81058545e-02f, 1.05072647e-01f, 4.02692378e-01f, -6.78857863e-02f, -7.88760558e-02f, -3.34150195e-02f, 4.72228266e-02f, -6.27779067e-02f,
  1.26505539e-01f, 1.50173947e-01f, 1.97979346e-01f, 7.85102993e-02f, -2.35090062e-01f, -2.07629353e-02f, 2.81741291e-01f, 2.01878428e-01f, -8.31400603e-02f, 6.72733039e-02f,
  -1.36581555e-01f, -1.13736436e-01f, -7.10545853e-02f, 3.43366042e-02f, -8.78777355e-02f, -1.97771518e-03f, 5.24651306e-03f, 1.55108064e-01f, -2.81355251e-02f, 1.81333907e-02f,
  1.53140977e-01f, 1.04057744e-01f, 9.16280672e-02f, 1.50366440e-01f, -8.52989778e-02f, -5.24226688e-02f, -5.65859675e-03f, 7.02581778e-02f, -8.02418590e-03f, 2.20753942e-02f,
  -2.52061505e-02f, 1.29860163e-01f, -9.26860645e-02f, 7.51716569e-02f, -1.80951618e-02f, -2.15176884e-02f, 2.32271582e-01f, -2.61339843e-01f, 5.20727672e-02f, 2.61159629e-01f,
  3.94133985e-01f, 3.78714323e-01f, 2.56571740e-01f, -1.30482884e-02f, -1.85308158e-02f, 2.31488466e-01f, -2.46624410e-01f, -1.84330016e-01f, -4.54714186e-02f, 4.52463925e-01f,
  1.20703554e+00f, 5.10888815e-01f, 1.45671126e-02f, 4.46311355e-01f, -2.23236308e-01f, -3.04393172e-01f, -5.00097536e-02f, 1.44455299e-01f, 2.66606361e-01f, 4.60678011e-01f,
  2.29310647e-01f, 3.18037510e-01f, 2.81344563e-01f, 2.23346666e-01f, 3.39249492e-01f, 3.14854234e-01f, 1.85178295e-01f, 2.56192774e-01f, 1.88988596e-01f, 4.46845323e-01f,
  3.64288509e-01f, 3.16189885e-01f, 3.77184510e-01f, 2.77608991e-01f, 3.89981747e-01f, 2.56390959e-01f, 3.76000293e-02f, 6.86542392e-02f, 2.00257763e-01f, 6.00361586e-01f,
  3.90598476e-01f, 3.60895514e-01f, -2.93161213e-01f, -1.20528020e-01f, -1.06105134e-01f, 3.89015190e-02f, 1.32072970e-01f, 1.41006978e-02f, -2.19820905e-03f, -9.46383830e-03f,
  -1.22882254e-01f, 5.59659377e-02f, -1.20381620e-02f, -3.20025794e-02f, -1.29497975e-01f, -3.86477299e-02f, 5.22770286e-02f, 8.81308317e-02f, -1.05559021e-01f, 1.14132740e-01f,
  3.46064125e-03f, -9.86289009e-02f, -3.71811032e-01f, -2.99264431e-01f, -6.94122165e-02f, -2.00648680e-01f, -1.47673547e-01f, -9.40392539e-03f, -1.79009095e-01f, 3.29394639e-01f,
  -2.21444890e-02f, 1.09486870e-01f, 2.48487130e-01f, 3.65473151e-01f, 3.34799021e-01f, -4.82857088e-03f, 2.38244757e-02f, -1.18197970e-01f, -1.17530581e-02f, 8.54773149e-02f,
  -2.40004249e-02f, 5.13011450e-03f, -3.64070535e-02f, 1.51028961e-01f, 1.28512070e-01f, 1.33262545e-01f, -3.94025110e-02f, -3.89383994e-02f, -1.37487590e-01f, 3.62318456e-02f,
  -4.13157828e-02f, -2.33024001e-01f, -1.41863257e-01f, 1.29762858e-01f, -8.68842900e-02f, 1.33679926e-01f, 1.48825690e-01f, 1.20133594e-01f, 1.11466736e-01f, 1.54605076e-01f,
  -4.17231172e-01f, -5.03025055e-01f, 3.74466389e-01f, 3.94819640e-02f, -7.53172636e-02f, -1.42239422e-01f, 1.32241488e-01f, -9.83870402e-02f, -1.26335263e-01f, 1.53822497e-01f,
  -1.04428172e-01f, 2.51550470e-02f, -8.88580829e-02f, -2.39723437e-02f, -5.47704566e-03f, -1.39816657e-01f, -5.58437742e-02f, -2.01113775e-01f, -2.45259374e-01f, -1.79264709e-01f,
  -2.40634665e-01f, -4.43686664e-01f, -4.06621069e-01f, -3.46252352e-01f, -1.90926880e-01f, -3.87229145e-01f, -3.32318395e-01f, -2.02373654e-01f, -3.91569138e-01f, -2.24742681e-01f,
  -3.47670704e-01f, -8.75628531e-01f, 5.01222253e-01f, -4.11307275e-01f, -4.27842746e-03f, 2.93317437e-01f, 2.08654732e-01f, -3.39212120e-01f, -4.23377872e-01f, -2.14963391e-01f,
  -2.39889398e-01f, -1.44175768e-01f, 4.24694410e-03f, -6.01508357e-02f, 1.17012464e-01f, 3.63905579e-01f, 3.62542838e-01f, 5.65575600e-01f, 7.06783414e-01f, 7.44527876e-02f,
  -2.03437939e-01f, -4.29231882e-01f, -3.59139383e-01f, -2.04200044e-01f, -4.83422965e-01f, -7.12194592e-02f, -2.36662596e-01f, -3.63938779e-01f, -9.22850072e-02f, -4.47988838e-01f,
  5.92879474e-01f, -4.70558316e-01f, 5.42168468e-02f, -2.04599991e-01f, -1.81760892e-01f, -4.21910435e-02f, 5.41313598e-03f, -2.10559547e-01f, -9.03816149e-02f, 5.01803262e-03f,
  -2.67180145e-01f, -9.89215523e-02f, -6.44918159e-02f, -7.68892467e-02f, -3.79224047e-02f, -4.38025594e-02f, -1.96592271e-01f, -2.01851889e-01f, -3.15126628e-01f, -1.55280501e-01f,
  -1.35066792e-01f, -6.52355179e-02f, 1.43814698e-01f, -1.64399538e-02f, -2.84381837e-01f, 5.50401099e-02f, -2.00514346e-01f, -1.74883917e-01f, -1.29248813e-01f, -6.05899543e-02f,
  2.62093842e-01f, 1.65568516e-02f, -3.25066969e-02f, -2.35461872e-02f, -4.54111323e-02f, 1.50603801e-01f, 1.78756669e-01f, -2.28873771e-02f, -1.30946308e-01f, -7.09186122e-02f,
  -7.30383173e-02f, -5.56599116e-03f, -8.16638097e-02f, 1.08945146e-01f, -6.99094534e-02f, -2.02665791e-01f, 8.72177184e-02f, -2.31903885e-02f, -9.79714617e-02f, -1.53786421e-01f,
  -1.65360376e-01f, -1.33295238e-01f, 7.57664368e-02f, 9.30222683e-03f, -6.31583929e-02f, -1.78848933e-02f, -8.27191491e-03f, -4.16209511e-02f, 9.25706625e-02f, -4.98928726e-02f,
  1.91482499e-01f, 1.46179318e-01f, 1.55152783e-01f, -8.41639787e-02f, -1.27721503e-01f, -1.78041846e-01f, -3.36613990e-02f, -9.45824832e-02f, -1.35696828e-01f, 1.46628231e-01f,
  -1.71027765e-01f, 8.30803216e-02f, 1.73728876e-02f, -1.18618488e-01f, 2.25035399e-01f, 1.13313250e-01f, 4.95630950e-02f, 5.66245094e-02f, -1.26630263e-02f, -1.21034116e-01f,
  6.19943663e-02f, 2.02845708e-01f, 4.39492315e-01f, 3.40547800e-01f, 8.22669566e-02f, 4.59705919e-01f, 3.54307890e-01f, 3.30917329e-01f, 3.62850577e-01f, 4.87729967e-01f,
  -7.95974016e-01f, -3.82805139e-01f, -1.18057263e+00f, -5.44531882e-01f, -1.03805220e+00f, -5.55390775e-01f, -2.74285793e-01f, 5.98636150e-01f, 1.77261516e-01f, -5.83084762e-01f,
  -2.26815179e-01f, 2.08379477e-01f, 4.30950075e-02f, 3.03397886e-02f, -4.25480381e-02f, -8.31473231e-01f, -9.42008197e-01f, -7.79446125e-01f, -3.08120430e-01f, -1.45618275e-01f,
  -3.92588556e-01f, -3.42949182e-01f, -1.22671627e-01f, -2.55582243e-01f, -1.40626937e-01f, -5.52545115e-02f, -5.42114556e-01f, -5.04183710e-01f, -3.32730025e-01f, -9.66038942e-01f,
  -1.29679471e-01f, -1.99732363e-01f, -1.84798270e-01f, 2.70314980e-02f, -3.10777634e-01f, 8.67463946e-02f, 1.02509737e-01f, -4.67331372e-02f, 8.15390870e-02f, -1.96190208e-01f,
  -2.03015357e-01f, -1.00086639e-02f, 9.38043091e-03f, -6.43337891e-02f, -1.38696255e-02f, -1.74666837e-01f, -2.12625399e-01f, -6.08762980e-01f, -3.93268675e-01f, -3.41428399e-01f,
  -6.64937913e-01f, -7.30935097e-01f, -1.69890329e-01f, -3.18792649e-02f, -2.56229155e-02f, -3.74455869e-01f, 2.86289960e-01f, 9.91151556e-02f, -3.17865200e-02f, 3.24902833e-02f,
  -9.91582125e-02f, 2.58814767e-02f, -1.18818454e-01f, 1.93661928e-01f, 1.41303718e-01f, 6.95579872e-02f, 2.59637535e-01f, 1.14930414e-01f, -2.71080881e-02f, -3.79874259e-02f,
  -7.77289346e-02f, -1.79964885e-01f, 1.18652076e-01f, -2.10043928e-03f, -1.04548693e-01f, -9.15220529e-02f, -1.18583225e-01f, 1.31696016e-01f, -3.66256535e-02f, 3.08320317e-02f,
  -1.56464353e-02f, -3.15079354e-02f, -7.81605914e-02f, 3.92078489e-01f, -3.66614729e-01f, 2.34631635e-02f, -1.95400417e-02f, 2.29448676e-01f, 1.17286958e-01f, -3.15323114e-01f,
  1.00026035e+00f, -4.40835238e-01f, 7.53354654e-02f, 1.35658249e-01f, -2.52418429e-01f, -8.88635069e-02f, 1.80659503e-01f, -1.28720719e-02f, -9.29062814e-03f, -4.67275362e-03f,
  -9.17854384e-02f, 3.57477218e-01f, 2.02744439e-01f, 8.76352005e-03f, 6.60554320e-02f, 9.18559730e-03f, 6.58642873e-02f, -1.76242799e-01f, 1.57178901e-02f, -1.19465813e-01f,
  -2.15442002e-01f, -1.12183310e-01f, 3.40448886e-01f, 3.08100373e-01f, -4.35649641e-02f, 2.69707409e-03f, 3.29101503e-01f, 2.48883799e-01f, 1.72596604e-01f, 4.66124028e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.85378313e-01f, 3.56463850e-01f, 1.21521902e+00f, 1.16952586e+00f, 1.00827193e+00f, 8.55710879e-02f, 2.03704864e-01f, 7.87492156e-01f, 1.35268223e+00f, 1.19214916e+00f,
  9.39109921e-01f, 6.23931408e-01f, 1.62852848e+00f, 8.15968573e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.42607319e-01f, 2.81043977e-01f, -1.16048372e+00f, -3.66811454e-03f, 4.71178889e-02f, 2.85004348e-01f, -8.11532587e-02f, -5.57283282e-01f, -2.40976438e-01f, -1.68464407e-01f,
  -5.20511448e-01f, 2.38657430e-01f, 2.29399636e-01f, -6.91611409e-01f, -3.29669178e-01f, 9.80313346e-02f, 3.34869355e-01f, 1.49647102e-01f, 3.38538915e-01f, -9.50977147e-01f,
  1.96630597e-01f, -1.95690942e+00f, -1.46425891e+00f, 2.29221866e-01f, 2.80535907e-01f, -9.67863560e-01f, -5.40423095e-01f, -6.86732709e-01f, 3.43184292e-01f, -3.90334636e-01f,
  -9.84858334e-01f, 4.63062257e-01f, -2.94007272e-01f, -4.16820079e-01f, 5.44425666e-01f, 5.64300604e-02f, 2.78525770e-01f, 5.06014287e-01f, -1.34536996e-01f, -3.01240474e-01f,
  -1.50279135e-01f, -4.79393601e-01f, -2.20000654e-01f, 1.05237305e-01f, -3.27630490e-01f, 1.61386341e-01f, -5.39214611e-01f, -1.76892914e-02f, 6.44889474e-01f, 2.12692022e-02f,
  -6.81846738e-01f, 8.79907310e-02f, 4.49762613e-01f, -2.08341265e+00f, -1.64895999e+00f, -1.13434720e+00f, -1.51317787e+00f, -1.49418330e+00f, -4.41609114e-01f, 3.56942147e-01f,
  5.50621092e-01f, 3.53625357e-01f, -4.46877480e-02f, 5.06426573e-01f, -1.93049535e-02f, 1.56938314e-01f, 1.67611599e-01f, 5.18858768e-02f, 1.61549792e-01f, 2.47424990e-01f,
  -3.12801115e-02f, 2.02395394e-01f, 1.14173681e-01f, -6.84859097e-01f, -2.46150680e-02f, 5.65321803e-01f, -3.93079340e-01f, 4.53551918e-01f, -8.17032397e-01f, -3.76944721e-01f,
  2.16182902e-01f, -3.34639996e-01f, 1.30626273e+00f, -6.60564303e-01f, 4.51526552e-01f, -2.21983548e-02f, -1.33659613e+00f, 8.66256893e-01f, 3.79161656e-01f, -6.87254250e-01f,
  -1.14462495e+00f, -3.12674940e-01f, -1.33957124e+00f, -8.20060551e-01f, 1.73438266e-01f, -1.01218462e+00f, -3.62990558e-01f, -6.59846842e-01f, -5.82787514e-01f, -1.11569449e-01f,
  -2.70002514e-01f, -5.92485845e-01f, -7.56882727e-02f, -2.05804735e-01f, 3.19610447e-01f, -4.78485346e-01f, 1.34286314e-01f, -2.08805159e-01f, 3.04221392e-01f, -5.69143295e-01f,
  -1.16171432e+00f, 2.14169592e-01f, -4.21787560e-01f, -1.65287435e-01f, 8.17384779e-01f, -8.68300974e-01f, -1.23601902e+00f, -7.83246934e-01f, 1.09316874e+00f, -1.09845078e+00f,
  2.48800591e-01f, -6.33693218e-01f, -9.34395969e-01f, 5.15431345e-01f, -1.67549372e-01f, -4.91078705e-01f, 5.61139584e-01f, -3.30791086e-01f, -7.00892508e-02f, -1.14379324e-01f,
  4.34923291e-01f, -2.05836967e-01f, -4.46078181e-02f, 2.60342419e-01f, -2.77813554e-01f, 9.60391834e-02f, -1.04636170e-01f, -1.51882738e-01f, 3.65696281e-01f, -1.54551759e-01f,
  -9.10179038e-03f, 5.93121469e-01f, 6.18983626e-01f, 6.79088607e-02f, 9.82180983e-02f, 1.03818819e-01f, -6.83594286e-01f, 2.63842374e-01f, -1.75127000e-01f, 7.91781306e-01f,
  6.23312406e-03f, 2.26619504e-02f, 3.94156486e-01f, 9.39028919e-01f, -1.41186237e+00f, -4.61942196e-01f, -2.22425506e-01f, -9.56192672e-01f, -1.04951739e+00f, 1.04124352e-01f,
  2.91037112e-01f, -1.09226905e-01f, -5.62132820e-02f, 7.46241659e-02f, 1.05516016e-01f, -6.84051991e-01f, 4.37375039e-01f, 4.79269147e-01f, 6.25777841e-01f, 7.93169022e-01f,
  -5.89433730e-01f, 3.93685549e-01f, -3.46532166e-02f, -5.67276955e-01f, 1.39904559e+00f, -2.78243750e-01f, 1.37032392e-02f, -2.71143734e-01f, -5.51110685e-01f, 1.82548448e-01f,
  -1.02356541e+00f, 9.08011973e-01f, -9.53870475e-01f, -5.88890731e-01f, -1.25297999e+00f, -6.52651072e-01f, 2.54811775e-02f, -1.27737892e+00f, 8.06373298e-01f, 1.82298437e-01f,
  -6.15647495e-01f, 2.70949543e-01f, 7.47902989e-02f, 3.83439250e-02f, -5.52464500e-02f, 5.20228922e-01f, -3.24873716e-01f, -3.56814235e-01f, -1.90937649e-02f, 1.01217620e-01f,
  -5.21023348e-02f, -2.02368677e-01f, 6.22252464e-01f, -6.81223631e-01f, 9.46731642e-02f, 3.07923198e-01f, 6.98111117e-01f, 3.18036050e-01f, 4.02756669e-02f, -2.40093321e-01f,
  -1.29481018e+00f, -1.00495827e+00f, 4.96682882e-01f, 1.15514457e+00f, -7.62077391e-01f, -1.14076748e-01f, -1.30846405e+00f, -1.33030915e+00f, -1.13737918e-02f, -1.03079188e+00f,
  -9.34668958e-01f, 8.83945167e-01f, -7.38821328e-01f, -5.15435815e-01f, -2.77230799e-01f, -9.46439952e-02f, -4.71981496e-01f, -4.59936745e-02f, -3.43042351e-02f, -5.82931191e-02f,
  -4.25422564e-02f, -4.32716757e-01f, -4.15362209e-01f, -3.48991118e-02f, -1.28596142e-01f, -1.05925247e-01f, -3.83913256e-02f, -2.52084255e-01f, 1.81188993e-02f, 3.64130363e-02f,
  -5.11044413e-02f, -3.75234820e-02f, 1.02457452e+00f, 4.17066514e-01f, -9.86310542e-01f, 6.34216726e-01f, 5.33129513e-01f, -5.26592851e-01f, 1.83063194e-01f, -1.62419334e-01f,
  -5.11601508e-01f, -1.52899563e-01f, -1.27184880e+00f, -3.78553152e-01f, 1.01027332e-01f, -1.40020490e+00f, 2.42019400e-01f, 2.31307402e-01f, 2.45420262e-01f, 1.99435204e-01f,
  6.14030585e-02f, 3.18273276e-01f, -1.62829876e-01f, 1.10698622e-02f, -2.25118801e-01f, -1.85113460e-01f, -1.22201815e-01f, -2.21415192e-01f, 1.23414084e-01f, -4.37152952e-01f,
  2.46445946e-02f, 2.58610994e-01f, -2.54110575e-01f, 3.03346366e-01f, -1.00276217e-01f, 3.13455015e-01f, -3.83436471e-01f, -2.77179748e-01f, -1.92146510e-01f, -7.03345776e-01f,
  -5.37682891e-01f, -9.28885400e-01f, 1.23593938e+00f, -1.63864994e+00f, -7.82990992e-01f, -7.23871827e-01f, 6.77760482e-01f, -7.87988842e-01f, -8.95289630e-02f, 1.11848347e-01f,
  -2.39909232e-01f, 1.05198614e-01f, -3.00108641e-01f, -3.64186466e-01f, 2.86841005e-01f, -9.40281898e-02f, 9.72707793e-02f, 4.96030837e-01f, -3.34098488e-01f, 4.32839602e-01f,
  -2.73696452e-01f, 2.82258332e-01f, 7.54063606e-01f, 1.88829750e-01f, 4.95007485e-01f, 7.69367442e-02f, -5.95740378e-01f, -3.55620533e-01f, -1.95183884e-02f, -5.53042628e-02f,
  -1.88327879e-02f, 1.12525797e+00f, 5.28035462e-01f, 7.74272323e-01f, 1.54692633e-02f, -9.53540385e-01f, -3.70802164e-01f, 1.40301704e-01f, -1.30902493e+00f, -1.48826623e+00f,
  1.11722089e-01f, 2.62455046e-02f, 2.20248520e-01f, -1.55118247e-02f, -2.06587061e-01f, 1.53250366e-01f, 9.90439802e-02f, 2.18820870e-01f, 5.68045191e-02f, 2.80500948e-01f,
  3.57638896e-01f, 6.39062762e-01f, -3.18829298e-01f, -4.10775334e-01f, -6.19972348e-01f, -2.78943747e-01f, -3.02864581e-01f, 1.68831095e-01f, -9.13577259e-01f, -6.32309377e-01f,
  -1.00471091e+00f, -5.96975505e-01f, -7.95543313e-01f, -3.84364665e-01f, -1.16108942e+00f, 6.89033389e-01f, -1.00032187e+00f, 1.12166047e+00f, -1.14715505e+00f, -2.17582449e-01f,
  4.21690315e-01f, 6.64800525e-01f, -1.60607129e-01f, 5.04938662e-02f, -4.77649420e-02f, -3.22661072e-01f, 1.41206637e-01f, -2.57201374e-01f, -3.56901437e-02f, 6.95365146e-02f,
  -3.64279263e-02f, -2.02809423e-01f, 2.09462464e-01f, -2.25777358e-01f, 2.12622970e-01f, 2.81420469e-01f, 1.36499023e-02f, -1.00696959e-01f, 1.38111010e-01f, -2.92002827e-01f,
  -1.26301217e+00f, -5.97026527e-01f, -1.34597987e-01f, -4.81587410e-01f, 1.25944495e+00f, -7.80969918e-01f, 1.28683880e-01f, -1.17237675e+00f, 7.33969212e-01f, 1.12420547e+00f,
  -6.88140154e-01f, -1.39744520e-01f, -1.09236431e+00f, -2.94062197e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  5.94374597e-01f, 2.54406989e-01f, 2.29455173e-01f, -5.83015800e-01f, -9.40941796e-02f, 6.39488339e-01f, 4.92628068e-02f, -2.92640150e-01f, -4.69713032e-01f, -3.39925200e-01f,
  -1.00404155e+00f, -6.17202520e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    