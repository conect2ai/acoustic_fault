/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.41198316e-01f, 1.15819670e-01f, 4.82771426e-01f, -9.63367969e-02f, 9.43254828e-02f, 1.25864893e-01f, 2.25459561e-01f, 2.91923359e-02f, 2.62370527e-01f, -2.45713532e-01f,
  -2.03699440e-01f, 4.21130545e-02f, 1.01274729e-01f, -2.55070627e-01f, 1.47741120e-02f, 1.14282086e-01f, -5.80959991e-02f, 6.81187492e-03f, 1.59476325e-01f, -1.06479689e-01f,
  6.46846602e-03f, -3.83511275e-01f, 9.52457711e-02f, -2.43266359e-01f, -5.98384961e-02f, 8.13045204e-02f, -2.58933961e-01f, 1.06718600e-01f, -2.38361523e-01f, -4.65336293e-02f,
  -3.41295227e-02f, 3.42815183e-02f, 1.26520127e-01f, 7.52370688e-04f, -4.40945737e-02f, -4.34554145e-02f, -2.68506166e-02f, 2.00139005e-02f, 1.92742553e-02f, 3.66775785e-03f,
  3.27637754e-02f, -7.31199762e-05f, -1.99888330e-02f, 3.22579183e-02f, 4.75680158e-02f, -6.24968810e-03f, -9.04450193e-03f, 5.34399860e-02f, 1.88483577e-02f, 9.86070558e-02f,
  4.05983068e-02f, 4.11600471e-02f, 1.42679363e-02f, 5.84966168e-02f, 1.01485617e-01f, 4.86603417e-02f, -1.92860737e-02f, 7.78673366e-02f, 5.60409017e-03f, 4.60184999e-02f,
  4.27873842e-02f, 6.62086010e-02f, -2.49589533e-02f, -5.12632765e-02f, -2.60488000e-02f, -7.50503540e-02f, -5.84605373e-02f, 1.39587279e-02f, 3.05944849e-02f, -6.52040541e-02f,
  -5.78054301e-02f, 1.33723095e-02f, 3.05415913e-02f, 3.19708441e-03f, -4.62016053e-02f, 1.68307759e-02f, -2.17688456e-02f, 1.83222461e-02f, 2.65521482e-02f, 3.18443626e-02f,
  7.01875985e-03f, 1.85962543e-02f, -3.20719043e-03f, 3.15001532e-02f, 6.94113038e-03f, 3.88218835e-02f, -3.03587243e-02f, -1.35383317e-02f, -1.00252610e-02f, -1.40442103e-02f,
  -2.35263288e-01f, -1.10993184e-01f, -4.11107615e-02f, -5.17089330e-02f, -3.76659036e-02f, 4.57122223e-03f, -3.86279426e-03f, 2.45351531e-02f, 6.14505000e-02f, 1.21369446e-02f,
  1.18751293e-02f, -7.52773657e-02f, -4.19940725e-02f, 5.30336099e-03f, -7.00002071e-03f, 2.81359628e-02f, -3.25970985e-02f, -5.69835231e-02f, -4.41329069e-02f, -4.18116935e-02f,
  -1.33370562e-02f, -5.15955426e-02f, -5.79830036e-02f, -7.17237964e-02f, -6.00857586e-02f, -6.81281239e-02f, 1.83595400e-02f, 3.66717787e-03f, -7.38573726e-03f, -2.31900215e-02f,
  -6.69029951e-01f, 5.74612282e-02f, -2.30940834e-01f, -9.65243056e-02f, -7.97144696e-02f, 2.11417228e-01f, 8.06298107e-02f, -4.58573401e-02f, -2.16698289e-01f, 3.01382504e-02f,
  2.29967125e-02f, -1.41073138e-01f, 8.49397257e-02f, -8.10016170e-02f, -2.11349472e-01f, -2.03474741e-02f, -1.30499080e-01f, 1.23989871e-02f, -1.18526362e-01f, -4.53795679e-02f,
  -8.58917087e-02f, 2.23273393e-02f, -1.26205504e-01f, 7.24254176e-02f, -9.50926766e-02f, 2.22884063e-02f, 4.38391902e-02f, 3.83346342e-02f, -1.11771775e-02f, -9.08831432e-02f,
  -6.96479063e-03f, -4.88188341e-02f, -8.29967707e-02f, 1.38466153e-02f, 2.76204254e-02f, 1.04271593e-02f, 3.38457152e-02f, 2.28681080e-02f, -1.22768455e-03f, -2.78164633e-02f,
  3.28238234e-02f, -7.58772716e-03f, 1.88980028e-02f, 1.16313593e-02f, -8.25218216e-04f, -1.02274613e-02f, -2.92715672e-02f, 2.01124847e-02f, -1.68331377e-02f, -3.67011735e-03f,
  -4.52259779e-02f, 7.41050765e-03f, 2.16528829e-02f, -2.38821725e-03f, 4.86641712e-02f, 3.55296433e-02f, 8.40837881e-02f, -2.57826783e-02f, -4.25594226e-02f, -3.43740843e-02f,
  -1.02735013e-02f, -4.97903563e-02f, -4.94226487e-03f, -6.08009137e-02f, 5.57101890e-03f, 6.09231256e-02f, -4.65747640e-02f, -1.87004860e-02f, -2.35634744e-02f, -2.52920222e-02f,
  6.93659205e-03f, 2.48598997e-02f, -3.86819430e-03f, -2.62179859e-02f, 1.31206606e-02f, 5.95449295e-04f, 1.98083394e-03f, 3.56286124e-04f, -3.82405929e-02f, -7.33072683e-02f,
  -1.37345842e-03f, -3.88758741e-02f, 1.71431210e-02f, 6.38877302e-02f, 2.45961025e-02f, -5.45182778e-03f, -8.49132463e-02f, -4.33093309e-02f, -1.41457422e-02f, 1.95737816e-02f,
  1.75285056e-01f, 1.22322300e-02f, 1.12117045e-02f, -6.92368895e-02f, 3.05710547e-02f, -1.03288934e-04f, -4.42118868e-02f, -1.14042964e-02f, -4.40827198e-03f, 3.28861177e-02f,
  3.44494581e-02f, 2.50192210e-02f, 6.20964319e-02f, -1.80111849e-03f, -2.54815002e-03f, 1.77979786e-02f, 1.78178698e-02f, -4.66041416e-02f, 4.24866155e-02f, -2.82103755e-02f,
  7.99042657e-02f, -1.02561126e-02f, 1.45081505e-02f, 1.50403688e-02f, -5.58262318e-02f, 3.64625524e-03f, 1.59137268e-02f, -6.39462890e-03f, 5.43369576e-02f, -3.53620462e-02f,
  -2.03552485e-01f, 2.36119166e-01f, -2.44461559e-02f, -2.17654303e-01f, -1.62490010e-01f, 1.72634006e-01f, 1.83851525e-01f, -1.86500087e-01f, 1.31756276e-01f, 6.64439872e-02f,
  -3.31927501e-02f, 2.84797519e-01f, 1.15654550e-01f, 1.54080957e-01f, -1.07363127e-02f, 2.63689399e-01f, 2.10211221e-02f, 7.25950599e-02f, 1.16130769e-01f, -9.23711210e-02f,
  -6.67875633e-02f, -8.11996162e-02f, 1.91579182e-02f, -1.77182734e-01f, -1.08210675e-01f, -1.79952189e-01f, -3.10074449e-01f, -5.77828325e-02f, -1.90035880e-01f, 3.94470524e-04f,
  4.61934060e-02f, 3.45744193e-02f, 5.40397689e-03f, -1.07374368e-02f, -9.05912817e-02f, -1.42569870e-01f, -6.80298312e-03f, 1.10769801e-01f, -2.00150367e-02f, 3.04833148e-02f,
  6.78875968e-02f, 2.37533506e-02f, 2.46764086e-02f, 1.95414051e-02f, -1.25850737e-02f, -6.60025980e-04f, 6.66026175e-02f, 3.07046343e-02f, 4.69499528e-02f, 8.55655000e-02f,
  7.58746192e-02f, -3.17510264e-03f, -3.52467783e-02f, 4.84004952e-02f, 2.07192637e-02f, 6.10419177e-02f, -1.37153687e-02f, 3.62302177e-02f, -3.07471063e-02f, 7.27671459e-02f,
  -4.62995768e-02f, -4.95344549e-02f, -3.85810323e-02f, -2.88987495e-02f, -4.12047431e-02f, -3.86257954e-02f, -3.38776819e-02f, -4.20124568e-02f, -3.06022614e-02f, -7.49323750e-03f,
  -1.02725886e-01f, 1.55963954e-02f, -1.55970296e-02f, -3.08885779e-02f, 2.68852580e-02f, 7.63742020e-03f, 1.95539165e-02f, -2.33024284e-02f, -1.77082624e-02f, 4.75098826e-02f,
  -1.45814642e-02f, -3.37352343e-02f, -8.77926033e-03f, -3.14192660e-02f, -2.93434113e-02f, -1.44980298e-02f, -1.88503955e-02f, -4.71989531e-03f, -4.36630053e-03f, -4.59287837e-02f,
  -6.47173226e-02f, -2.52134144e-01f, -5.58772422e-02f, 6.26247004e-02f, 5.02808094e-02f, 1.57780666e-02f, 1.26241380e-02f, -4.08624820e-02f, -4.90731932e-02f, -8.60259384e-02f,
  -7.16847032e-02f, -5.99565059e-02f, -1.46458969e-01f, 1.17093865e-02f, 2.23048450e-03f, -1.66544393e-02f, -5.26243486e-02f, -4.95378003e-02f, -9.12994221e-02f, 5.15807362e-04f,
  -1.00229532e-01f, -5.45661710e-02f, -9.31186136e-03f, -1.21673964e-01f, -2.48983614e-02f, -4.83200885e-02f, -7.02606663e-02f, 1.40178073e-02f, -5.94069064e-02f, 4.85024229e-02f,
  4.90436345e-01f, -4.10021059e-02f, 6.72453940e-02f, -4.36681733e-02f, 1.22310175e-02f, 1.11145250e-01f, 3.54209123e-03f, -2.17296816e-02f, 5.84166385e-02f, 1.32675981e-03f,
  1.51317343e-01f, 3.70799005e-02f, 7.67341703e-02f, 7.41456896e-02f, 1.41218305e-01f, -4.09509800e-02f, 1.93209648e-01f, 3.31629552e-02f, 7.36978054e-02f, 1.23595437e-02f,
  5.80315515e-02f, -6.02454552e-03f, 2.84166448e-02f, 5.72466338e-03f, -1.70326885e-02f, -9.61640663e-03f, -4.13468331e-02f, -9.45885405e-02f, -7.67717659e-02f, -5.57239912e-02f,
  1.05287015e-01f, 6.74541295e-02f, 1.78261921e-02f, -4.70130891e-02f, 1.32932991e-01f, -1.64527819e-02f, -3.52096260e-02f, 8.52163788e-03f, 6.08713068e-02f, -1.42575847e-02f,
  1.74366478e-02f, 2.07125749e-02f, 6.66915625e-02f, -2.03169137e-02f, 5.21827191e-02f, 1.40188765e-02f, -5.20122759e-02f, -2.03807596e-02f, 2.55017616e-02f, 5.29469848e-02f,
  -2.89340094e-02f, 2.14729700e-02f, -5.20818755e-02f, 6.43685535e-02f, 4.32561971e-02f, 7.11162388e-02f, 1.89985335e-02f, -6.03808835e-02f, -7.32276682e-03f, 6.01927303e-02f,
  -2.48463303e-02f, -1.63052175e-02f, 1.66881382e-02f, -4.40299883e-02f, -3.46807763e-02f, -3.85078881e-03f, -1.91073846e-02f, -4.20102105e-02f, -3.80273648e-02f, 2.07263883e-03f,
  -2.34107357e-02f, 1.85558188e-03f, 1.65857635e-02f, 3.32105942e-02f, 3.22329998e-02f, 7.16236904e-02f, -6.56095818e-02f, 3.37199727e-03f, 3.44340736e-03f, -2.33799275e-02f,
  6.55467063e-02f, -1.82270594e-02f, -5.27684540e-02f, -3.16707278e-03f, 7.45522156e-02f, 2.09405553e-02f, -4.23631780e-02f, -9.95285064e-03f, 3.87569480e-02f, 3.57285291e-02f,
  -1.18031703e-01f, 1.24907941e-02f, 9.39581357e-03f, -3.11369798e-03f, 1.63866188e-02f, -7.65092438e-04f, 1.15085825e-01f, 9.28059127e-03f, 1.67760570e-02f, 3.32460701e-02f,
  5.52822351e-02f, 2.60756770e-03f, 6.15129694e-02f, -1.34001486e-02f, -9.81682073e-03f, -9.48823150e-03f, 2.75913626e-02f, -3.97566054e-03f, -9.45887342e-03f, 2.30505224e-02f,
  -3.83686796e-02f, -1.02002308e-01f, 8.02548826e-02f, -9.46848243e-02f, 1.26887672e-02f, -2.21022237e-02f, -2.93953456e-02f, -1.00461710e-02f, 6.04368933e-02f, 3.75196449e-02f,
  3.08511615e-01f, 1.58299711e-02f, -4.19164598e-02f, 3.36399078e-01f, 6.64532706e-02f, 4.86461706e-02f, 7.54923075e-02f, -2.30771489e-02f, 1.69879422e-01f, -1.30611546e-02f,
  3.71023752e-02f, 5.81719391e-02f, -1.26001611e-01f, 2.07412448e-02f, -1.46078253e-02f, -2.26887628e-01f, 8.32332596e-02f, 9.89740938e-02f, 9.63168591e-03f, 1.35444812e-02f,
  -6.98718429e-02f, 5.95640577e-02f, -1.17084511e-01f, -4.64373827e-02f, 8.45313817e-02f, 1.31918892e-01f, -1.71508249e-02f, 1.35930860e-03f, 9.23076496e-02f, -3.06676520e-04f,
  1.21193349e-01f, 1.54891595e-01f, 1.43791065e-02f, -9.16420147e-02f, -4.62516258e-03f, -6.03331178e-02f, 6.92286715e-02f, 2.27660057e-03f, -3.80773768e-02f, 4.86356243e-02f,
  -1.40125575e-02f, 6.45900741e-02f, 6.76147193e-02f, -6.27258932e-03f, 3.51973176e-02f, 5.84041700e-04f, 2.93015670e-02f, 4.19575460e-02f, 9.47488323e-02f, 7.89300799e-02f,
  3.18057602e-04f, 3.89829203e-02f, 5.02527505e-02f, 3.31743397e-02f, -2.56308652e-02f, 8.14231709e-02f, 4.24014553e-02f, 2.79965661e-02f, 9.55570489e-02f, 7.36347288e-02f,
  1.08141847e-01f, -4.73839939e-02f, 2.41136011e-02f, -1.36954132e-02f, 7.57165998e-02f, 3.88999693e-02f, -3.63274105e-02f, 1.16451038e-02f, -3.00885551e-02f, -3.72324809e-02f,
  8.88654031e-03f, -1.17814755e-02f, 5.95018379e-02f, -7.35682845e-02f, -2.95695178e-02f, 2.73504481e-02f, 1.53077720e-02f, 1.01146989e-01f, -2.99878214e-02f, -2.09678710e-03f,
  5.72527349e-02f, 1.57046430e-02f, -4.22235280e-02f, -8.06712266e-03f, 1.26174465e-02f, -3.40972729e-02f, -3.71320397e-02f, 5.23216203e-02f, -2.06993129e-02f, 3.42106596e-02f,
  1.61489204e-01f, 3.07393819e-01f, 6.92417473e-02f, 6.32861033e-02f, 1.00903720e-01f, 2.53301822e-02f, -1.11134753e-01f, -4.42816429e-02f, 4.08836603e-02f, 3.17719877e-02f,
  -6.93018874e-03f, -1.96554903e-02f, 5.10348268e-02f, -1.79960597e-02f, -7.88609833e-02f, 6.80120438e-02f, 6.49378523e-02f, -3.58487736e-03f, 8.69824141e-02f, -2.23488715e-02f,
  5.37795052e-02f, 4.54185624e-03f, 1.17966859e-02f, 2.48678047e-02f, 2.87538059e-02f, 8.13947991e-03f, 5.10355085e-02f, 2.32350156e-02f, -7.10866824e-02f, -4.89269756e-02f,
  2.71810621e-01f, -3.41503881e-02f, -2.34967228e-02f, 1.82616636e-01f, -1.85564876e-01f, 1.27058625e-01f, 2.42489025e-01f, -8.86464119e-02f, 5.25419302e-02f, 8.20963606e-02f,
  9.89272520e-02f, -1.10281736e-01f, 6.06772192e-02f, 2.52828896e-01f, 1.66913509e-01f, 1.49065137e-01f, 3.40707004e-01f, 1.26332179e-01f, -2.31878925e-02f, -1.25552034e-02f,
  1.32496610e-01f, 1.00068547e-01f, 1.18827172e-01f, -1.11596271e-01f, 1.31462503e-03f, -9.16322991e-02f, -7.52204796e-03f, -5.68013825e-02f, 5.64535484e-02f, -1.03273327e-02f,
  -3.30157578e-02f, -8.62622112e-02f, -5.96404374e-02f, -7.97227956e-04f, 6.37261048e-02f, -3.39591056e-02f, -2.96512595e-03f, -1.60228647e-02f, -9.02222842e-03f, -4.06152196e-02f,
  5.16830385e-03f, -3.53785083e-02f, -1.59897394e-02f, 3.24792825e-02f, -3.08826491e-02f, -7.15320781e-02f, -7.32335150e-02f, -3.38370092e-02f, -4.51024547e-02f, -2.85844114e-02f,
  2.46864511e-03f, 1.35946907e-02f, 4.72232848e-02f, 3.60042341e-02f, 3.51069383e-02f, -1.54495360e-02f, 3.45450900e-02f, -5.27528580e-04f, -1.71421356e-02f, 3.40148471e-02f,
  3.08832265e-02f, -3.14112939e-02f, -1.11580994e-02f, -2.44357977e-02f, -1.07471487e-02f, -4.40467801e-03f, 2.17707008e-02f, -4.93567474e-02f, 6.18789271e-02f, 2.27691978e-02f,
  3.08369529e-02f, -4.23675515e-02f, -3.25405858e-02f, 4.24239710e-02f, 7.61879012e-02f, 2.20764223e-02f, 8.53277594e-02f, -7.11275488e-02f, -1.74628962e-02f, 1.75281446e-02f,
  -1.25221414e-02f, 6.70982408e-05f, -7.84945395e-03f, 1.58842579e-02f, -6.80913255e-02f, 1.05912816e-02f, -4.35122848e-03f, -1.88654201e-04f, -2.55007446e-02f, 3.58931199e-02f,
  -1.22759514e-03f, 1.85438469e-02f, 3.27099711e-02f, -1.02852276e-02f, -1.82326492e-02f, 1.30407363e-02f, 7.10366592e-02f, 7.94695094e-02f, 4.93141674e-02f, -1.94838662e-02f,
  -3.52339149e-02f, -9.64702107e-03f, -3.16731166e-03f, -1.30815636e-02f, 2.09934656e-02f, 5.62189519e-02f, 4.66009639e-02f, 4.60774712e-02f, 6.45259246e-02f, -4.43673767e-02f,
  -5.23106121e-02f, 1.39580211e-02f, -4.65672910e-02f, -2.97476780e-02f, -1.75117236e-02f, 2.54967306e-02f, -5.88526949e-02f, 4.32122685e-02f, -1.98240448e-02f, 6.30486384e-03f,
  -4.49161053e-01f, 5.42903971e-03f, -1.11708373e-01f, -1.01205640e-01f, 2.67961826e-02f, -7.91003183e-02f, -1.30532354e-01f, -4.11184877e-02f, -7.81628117e-02f, 7.00149834e-02f,
  9.16136652e-02f, -2.22287863e-01f, 5.06830178e-02f, 1.36901185e-01f, -2.27563214e-02f, 4.46672328e-02f, 9.51994658e-02f, 6.43534288e-02f, 8.06070939e-02f, -5.82359405e-03f,
  2.52674893e-02f, 6.90558180e-02f, 3.28010246e-02f, 7.79189169e-02f, 4.99163894e-03f, -4.89213783e-03f, 3.59596722e-02f, 3.35288942e-02f, 4.84141745e-02f, -1.94947179e-02f,
  -4.89537865e-02f, -5.56327053e-04f, 2.23596394e-02f, -3.85137871e-02f, 3.58325727e-02f, -7.06524849e-02f, 5.15657524e-03f, -3.60761844e-02f, -5.82103617e-02f, -1.72290914e-02f,
  -3.02096400e-02f, -2.33320929e-02f, -4.56707329e-02f, 2.40682177e-02f, 1.43025341e-02f, -3.75899952e-03f, 1.47879298e-03f, 6.63460866e-02f, 4.53563109e-02f, 6.19009621e-02f,
  -3.75139080e-02f, -5.60432710e-02f, -9.78406332e-03f, 6.66840896e-02f, 2.38294974e-02f, 1.87528916e-02f, 1.07723121e-02f, -1.16047869e-02f, 6.51874691e-02f, 4.41434681e-02f,
  4.83237952e-02f, 2.11043116e-02f, 5.74769452e-02f, 3.10110394e-02f, 1.51605308e-02f, -9.85130109e-03f, 5.35704149e-03f, -6.62890300e-02f, -9.84450523e-03f, -6.66565597e-02f,
  4.05454496e-03f, 8.36442132e-03f, -1.82461273e-02f, 4.91554998e-02f, 3.02092414e-02f, 2.78117917e-02f, -5.42384796e-02f, 2.91380845e-02f, -6.48819730e-02f, -1.84556302e-02f,
  4.23080437e-02f, 2.89930496e-02f, -2.31365357e-02f, 2.20157132e-02f, 1.03795249e-02f, 4.08525253e-03f, 4.32600081e-02f, -5.84853441e-03f, -7.27403816e-03f, 4.90715504e-02f,
  3.77429761e-02f, 8.74288678e-02f, -3.98850068e-02f, -6.00692257e-03f, 1.42563821e-03f, -4.80041057e-02f, 5.68019077e-02f, 5.05224429e-02f, 9.25597697e-02f, 4.19838093e-02f,
  2.27278601e-02f, -7.96270836e-03f, 1.25245918e-02f, 2.65917052e-02f, -1.76116675e-02f, 5.05409390e-02f, 2.04915497e-02f, -1.99036151e-02f, -9.48393717e-03f, 1.73655376e-02f,
  -4.19931374e-02f, 5.28401732e-02f, -2.63971742e-02f, -2.15316564e-02f, -2.84207705e-02f, 5.90895303e-03f, 2.46758927e-02f, 4.40697111e-02f, -2.01861691e-02f, 1.71763934e-02f,
  1.61691561e-01f, -3.40986460e-01f, -3.83105762e-02f, 1.35633424e-01f, 2.66477317e-01f, 1.22076146e-01f, 1.28025353e-01f, 1.94748014e-01f, -7.01335812e-05f, -5.70697114e-02f,
  1.67490989e-01f, -2.77562112e-01f, -6.11264147e-02f, -2.35836785e-02f, 2.03167811e-01f, -1.35327829e-02f, 8.29151347e-02f, -3.97828370e-02f, -1.72851488e-01f, 7.13814646e-02f,
  1.11163944e-01f, 1.38479277e-01f, -5.02993912e-02f, 6.83687776e-02f, 2.16138940e-02f, 2.53332369e-02f, 2.74210602e-01f, -2.47908849e-02f, -4.76460978e-02f, 1.92860607e-02f,
  -1.13897569e-01f, 5.02181128e-02f, 2.73326994e-03f, 6.79781958e-02f, 1.12725005e-01f, 1.05167322e-01f, -2.30292734e-02f, -9.43315923e-02f, 8.22971463e-02f, 1.53141916e-02f,
  -2.77626626e-02f, -1.06466293e-01f, -8.04517232e-03f, -9.85246710e-03f, 3.44386548e-02f, 7.01319575e-02f, -4.45371531e-02f, -8.76933709e-02f, -6.63920268e-02f, -1.25607267e-01f,
  -7.64348060e-02f, -6.28553554e-02f, 2.10005958e-02f, -2.37968080e-02f, 8.20202008e-02f, -6.13896213e-02f, -1.69605874e-02f, -5.61465174e-02f, -4.66656908e-02f, -4.76250350e-02f,
  -2.15283278e-02f, 5.74323721e-02f, 2.15939451e-02f, -1.36389360e-02f, 7.80764176e-03f, -2.67635770e-02f, 4.67872582e-02f, 4.97054914e-03f, 4.26705889e-02f, 1.52657814e-02f,
  9.27286968e-02f, 5.83922416e-02f, 5.95969260e-02f, 1.01298839e-01f, 3.40225473e-02f, 2.87058037e-02f, -5.70980832e-02f, -9.66887623e-02f, -1.13133537e-02f, -8.66043102e-03f,
  -3.69639471e-02f, 1.26981712e-03f, -3.39599438e-02f, 5.94177935e-03f, 3.98757420e-02f, 6.92197413e-04f, -8.20892900e-02f, -1.00245155e-01f, 1.06811626e-02f, 2.47780811e-02f,
  4.78254706e-02f, 2.69815087e-01f, 1.00741506e-01f, -8.34367424e-02f, -6.97967112e-02f, -4.34956439e-02f, 3.00502777e-02f, 5.87301664e-02f, 2.88212225e-02f, 3.34984884e-02f,
  6.02205992e-02f, 2.71435771e-02f, 6.36244332e-03f, 6.23723865e-03f, -5.75206243e-02f, 2.64455285e-02f, 6.55690432e-02f, 2.78728586e-02f, 2.72301845e-02f, 3.32945809e-02f,
  -2.53263786e-02f, 4.40398715e-02f, -5.55025414e-03f, 2.58610938e-02f, 1.16205655e-01f, 8.67120922e-03f, 9.31729004e-02f, -4.07369807e-02f, 6.44458905e-02f, -6.38850033e-02f,
  -1.84537753e-01f, 1.34704009e-01f, -6.31284788e-02f, -2.37551406e-02f, 4.01782766e-02f, -1.48819014e-01f, -9.88464206e-02f, 6.78026006e-02f, -4.56256866e-02f, 1.85477771e-02f,
  -4.48809266e-02f, 1.18972555e-01f, 2.13180576e-02f, 8.30476955e-02f, 1.65858164e-01f, 5.07574901e-02f, 1.91060305e-02f, 8.27370211e-02f, -4.32048962e-02f, 8.67218524e-02f,
  -8.25806260e-02f, -5.93988374e-02f, 3.61092240e-02f, 4.49420400e-02f, 4.89694029e-02f, -4.73264940e-02f, 6.31760359e-02f, -5.46557046e-02f, 8.27226415e-02f, 4.68315184e-02f,
  -1.69150203e-01f, -9.71537977e-02f, 2.80478392e-02f, 2.44887993e-02f, -6.19434230e-02f, -1.21951275e-01f, -7.10612983e-02f, 2.88683884e-02f, -7.68825263e-02f, 4.56332928e-03f,
  -5.30967452e-02f, 3.22472118e-02f, -6.90568238e-03f, 6.79286197e-03f, -9.01747271e-02f, -4.59998362e-02f, -4.33596410e-02f, -1.53469369e-02f, 2.54061371e-02f, 2.72547156e-02f,
  -5.24581186e-02f, -3.58185284e-02f, 4.73623313e-02f, -8.10329244e-02f, -4.98268269e-02f, 3.13061364e-02f, -5.78582324e-02f, 4.86235926e-03f, -3.02892528e-03f, 1.55841289e-02f,
  -1.57513767e-02f, -5.68007976e-02f, 5.20338584e-03f, -2.22948175e-02f, 4.29552980e-03f, -4.39113267e-02f, 4.49456759e-02f, 8.71631056e-02f, -3.93520147e-02f, -8.39403179e-03f,
  3.12688984e-02f, -8.13950598e-02f, -2.85868649e-03f, -8.68101232e-03f, -1.07716694e-01f, 8.16316083e-02f, -6.00704700e-02f, 1.75288878e-02f, -4.99911718e-02f, -1.23132570e-02f,
  3.54734510e-02f, -1.70609076e-02f, -6.47096485e-02f, 1.60733126e-02f, -8.47773813e-03f, 3.97720896e-02f, 4.78071608e-02f, 1.86608955e-02f, 2.84642167e-02f, 4.61636409e-02f,
  1.24283522e-01f, 1.77216843e-01f, -2.83515416e-02f, -2.27852985e-02f, -2.34763119e-02f, 2.56138369e-02f, 9.85330530e-03f, -2.86269505e-02f, 7.39082024e-02f, 3.06824986e-02f,
  -6.05655201e-02f, 8.44305754e-03f, 8.77176598e-02f, 2.11577639e-02f, 6.40280470e-02f, -2.30558738e-02f, 6.82755634e-02f, 1.82808656e-02f, -8.39245878e-03f, 1.55263348e-02f,
  6.73073381e-02f, -5.44322617e-02f, 6.94330186e-02f, 7.20221847e-02f, -2.47101020e-02f, 2.40030093e-03f, -1.35356849e-02f, -2.44511552e-02f, -2.17966847e-02f, 1.19465077e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.27482787e-01f, -1.11617789e-01f, 1.87799990e-01f, 1.46330497e-03f, 3.95792536e-02f, 9.21092704e-02f, 1.50997922e-01f, -3.43050100e-02f, -1.20193638e-01f, -7.31574371e-02f,
  -1.27595384e-02f, 8.74660835e-02f, 1.42855451e-01f, -3.60379890e-02f, 1.37042448e-01f, 4.67970110e-02f, -2.06842311e-02f, 5.80279939e-02f, -1.00188822e-01f, -4.71386500e-02f,
  -1.01634882e-01f, -9.49511454e-02f, 9.67885256e-02f, -1.18285008e-01f, -5.38109615e-02f, -9.49040949e-02f, -2.34903414e-02f, 8.25421065e-02f, -7.91362748e-02f, 3.86202633e-02f,
  1.05445264e-02f, 4.12483327e-02f, 1.48605090e-02f, 3.89728919e-02f, -5.92804551e-02f, 4.97993827e-02f, 2.35828422e-02f, 1.10984445e-01f, 2.61670016e-02f, 9.13685933e-03f,
  3.42984609e-02f, -7.06381649e-02f, -1.03862397e-01f, 5.91230690e-02f, -5.53885140e-02f, 1.81536609e-03f, -1.06910363e-01f, -8.38710088e-03f, 9.53114256e-02f, 7.56015703e-02f,
  -5.92216440e-02f, 7.04105059e-03f, 2.47071739e-02f, 5.77862039e-02f, 1.42897591e-02f, 2.89661847e-02f, -3.17078717e-02f, 1.85341924e-01f, 8.37170798e-03f, -1.12084365e-02f,
  4.40704152e-02f, -1.87730920e-02f, 3.24874669e-02f, 4.59867753e-02f, 3.62009630e-02f, -1.36334628e-01f, 3.12471129e-02f, -1.94902197e-02f, 8.32365304e-02f, -2.91625224e-02f,
  7.19408877e-03f, 2.08278876e-02f, -4.90958616e-02f, 3.60342339e-02f, 2.56910753e-02f, -4.13862430e-02f, 5.49069308e-02f, -6.11540638e-02f, -9.12101567e-02f, -6.96623921e-02f,
  -1.94443632e-02f, -6.34514581e-05f, -5.96063696e-02f, 4.06055860e-02f, 4.42845449e-02f, 8.62992704e-02f, -1.01728681e-02f, 9.64890867e-02f, -2.20286194e-02f, 5.02286479e-02f,
  -8.00020844e-02f, 4.45547216e-02f, 8.87602102e-03f, -1.09954223e-01f, -8.70451108e-02f, -2.58789565e-02f, -2.81736683e-02f, 5.07565476e-02f, 6.79003671e-02f, 1.61276534e-02f,
  -3.67350727e-02f, -3.35352421e-02f, 1.42442891e-02f, 7.40553364e-02f, -3.57323773e-02f, -7.90750980e-02f, 9.62538570e-02f, -8.13335106e-02f, 2.68765148e-02f, 2.22699028e-02f,
  2.82575898e-02f, 6.44425377e-02f, 6.50669932e-02f, 1.51405670e-02f, -5.11246324e-02f, 6.01221062e-02f, -2.66529620e-02f, -2.32088938e-03f, 1.49634983e-02f, 2.32808888e-02f,
  -4.34644967e-02f, -2.35563293e-01f, -1.52415350e-01f, -1.53449208e-01f, -2.84311175e-02f, -2.55481035e-01f, -2.30047584e-01f, -6.51538745e-02f, 4.48888876e-02f, -3.08728386e-02f,
  -1.07101932e-01f, -7.52019230e-03f, 5.97404875e-02f, -1.52328521e-01f, 1.03714533e-01f, 1.36613905e-01f, -1.40238121e-01f, 2.15236861e-02f, -8.99037439e-03f, -7.61138201e-02f,
  -5.70354797e-02f, -6.78979009e-02f, -5.08450754e-02f, -2.36758851e-02f, -1.74534708e-01f, 4.05677371e-02f, 6.26051351e-02f, -1.28031775e-01f, -3.30255181e-02f, 6.29524980e-03f,
  -7.32725933e-02f, 1.30914658e-01f, 3.06546651e-02f, 4.17639054e-02f, 5.09514250e-02f, -7.66574293e-02f, -3.61836073e-03f, -7.99054652e-03f, -7.95019493e-02f, 1.21245824e-01f,
  2.43925732e-02f, -1.35027720e-02f, -8.30131844e-02f, -3.27520780e-02f, 6.80413619e-02f, 2.94921529e-02f, -1.14239333e-03f, -9.59003195e-02f, -1.95675101e-02f, -5.26225828e-02f,
  -5.58795370e-02f, -9.33972746e-03f, -4.25038524e-02f, 2.54522469e-02f, -3.30709899e-03f, -9.30666775e-02f, -5.00152670e-02f, -2.68676300e-02f, 1.69256702e-02f, -6.28965022e-03f,
  2.56813020e-02f, -6.99080452e-02f, -1.20825954e-01f, -3.18920761e-02f, -9.98601243e-02f, -3.03312615e-02f, 4.28266963e-03f, -3.56278978e-02f, 1.79688781e-02f, 4.54790555e-02f,
  -5.30075058e-02f, 2.93275584e-02f, -7.36407889e-03f, -2.09192913e-02f, 1.85362883e-02f, 1.03026167e-01f, 3.64464782e-02f, 3.03346142e-02f, -4.93658856e-02f, -3.83394845e-02f,
  3.05542182e-02f, -7.02041090e-02f, 2.38868352e-02f, -2.09329538e-02f, -1.92908756e-02f, -1.90240182e-02f, -1.01545244e-01f, 5.61979227e-02f, -5.99974999e-03f, -7.32228532e-02f,
  -5.33070527e-02f, -3.24333459e-02f, 4.13652807e-02f, 1.00318342e-01f, 6.06043488e-02f, 2.10880972e-02f, 2.58612707e-02f, 6.40320173e-03f, 1.90999042e-02f, 4.03086543e-02f,
  -4.75732572e-02f, 9.00294781e-02f, -4.85757254e-02f, 3.11226547e-02f, -1.02986991e-02f, 4.31991322e-03f, 4.99220304e-02f, 5.29317744e-03f, -9.26468894e-03f, -1.93833131e-02f,
  2.37137526e-02f, -2.84414906e-02f, -4.55934294e-02f, 1.36000952e-02f, 9.51595530e-02f, 1.64162666e-02f, 6.11531828e-03f, -4.47524199e-03f, -3.64185944e-02f, -3.41668800e-02f,
  2.07937777e-01f, -2.87213968e-03f, 6.03563488e-02f, 1.59381717e-01f, 1.51852041e-01f, -3.74979973e-02f, 3.60376239e-02f, 7.05453828e-02f, 1.90361738e-01f, -1.47005975e-01f,
  -2.30060723e-02f, -5.50538674e-02f, -8.11715052e-02f, 6.31083250e-02f, 1.37007594e-01f, -5.46235107e-02f, 1.60180718e-01f, 6.11930080e-02f, 5.31627331e-04f, 8.66758749e-02f,
  6.85141236e-02f, 7.70923048e-02f, -5.50622679e-02f, 2.10499577e-02f, -9.10714641e-02f, 2.95578260e-02f, -4.55588251e-02f, -1.01389065e-01f, 5.38638197e-02f, -8.70723873e-02f,
  1.04115680e-01f, 1.47901461e-01f, -4.28496394e-03f, 4.92030382e-02f, -5.45170531e-02f, -6.96744546e-02f, -1.32373005e-01f, 9.69032757e-03f, -3.11044231e-02f, 1.57399625e-02f,
  -5.72553761e-02f, -9.13392603e-02f, 4.86481637e-02f, 9.02589113e-02f, 3.40288095e-02f, 1.32612037e-02f, -1.39361890e-02f, 5.07797673e-02f, 2.36976659e-03f, -7.40078986e-02f,
  -3.12092509e-02f, 5.25706671e-02f, 1.51448194e-02f, -7.72084221e-02f, -2.84154285e-02f, -1.07406927e-02f, -6.57877401e-02f, 5.29765859e-02f, 6.22067824e-02f, -6.06165733e-03f,
  7.73016587e-02f, -6.63623307e-03f, -7.78673962e-02f, -6.60537630e-02f, 3.72863039e-02f, -4.15814891e-02f, -6.44000173e-02f, -6.28875755e-03f, -1.04938306e-01f, -6.26871139e-02f,
  -6.52835444e-02f, 6.07972071e-02f, -7.59470537e-02f, 1.00183323e-01f, 3.69292311e-02f, -2.07650252e-02f, 5.54228798e-02f, -7.83583522e-02f, -2.17526108e-02f, -5.91197424e-02f,
  1.93997994e-02f, -1.76798683e-02f, -6.82194531e-02f, 1.94327328e-02f, -6.21608347e-02f, 7.58368373e-02f, -1.91466529e-02f, 7.73312431e-03f, 2.99302712e-02f, 3.56269404e-02f,
  -9.46478732e-03f, 1.20887302e-01f, -1.36473787e-03f, 2.22808421e-02f, 6.28872439e-02f, -6.23137318e-03f, -1.09938845e-01f, -1.96236502e-02f, 6.47903830e-02f, 5.33897057e-02f,
  6.53354898e-02f, -3.17588635e-02f, 4.27531376e-02f, -5.83139732e-02f, -1.73153300e-02f, 5.18535338e-02f, -4.58828099e-02f, -3.05473544e-02f, -4.18708175e-02f, -3.02761588e-02f,
  -3.03073227e-03f, 5.05250543e-02f, -2.92826407e-02f, 4.41620015e-02f, 4.69263084e-02f, 1.18059870e-02f, 2.55456055e-03f, 5.81807271e-02f, 1.50904976e-04f, -6.13706037e-02f,
  -5.10573573e-02f, -5.75368255e-02f, -1.08352810e-01f, -1.67554263e-02f, 8.47357418e-03f, 6.38060495e-02f, -4.42710482e-02f, -3.53490710e-02f, -2.69395392e-02f, 1.08323516e-02f,
  8.30372274e-02f, 5.18841855e-02f, -3.86620797e-02f, -5.50141409e-02f, -4.46923003e-02f, -4.64097336e-02f, -1.61897745e-02f, 7.71070197e-02f, 5.84241860e-02f, 6.93201870e-02f,
  -2.03867387e-02f, -1.74205713e-02f, -4.28040028e-02f, -9.95743088e-03f, -9.64206085e-02f, -1.38638131e-02f, -7.18123391e-02f, -7.00390115e-02f, -2.06215326e-02f, 4.01633186e-03f,
  -2.20372658e-02f, 5.50415181e-02f, 2.80957520e-02f, -4.42216732e-02f, 5.17014042e-02f, 4.49398672e-03f, 3.55864130e-02f, 4.82364893e-02f, -6.25873804e-02f, -4.46529388e-02f,
  3.73623110e-02f, -4.63010445e-02f, -9.12575051e-02f, -8.02687034e-02f, 7.81927630e-02f, 9.18422267e-02f, -8.81884247e-02f, -3.74031104e-02f, -1.15971416e-04f, 2.94205621e-02f,
  9.61943995e-03f, 4.25504670e-02f, -8.83769765e-02f, 8.20048898e-02f, -5.44602051e-02f, -2.43939329e-02f, 8.28575864e-02f, -1.67027321e-02f, 2.74761319e-02f, -3.28880847e-02f,
  -6.84767589e-02f, 3.49387378e-02f, 4.69331592e-02f, 5.85296191e-02f, -7.60923102e-02f, 8.67166265e-04f, -4.83830599e-03f, -5.26563078e-02f, 7.03334361e-02f, -4.95748371e-02f,
  1.72681157e-02f, 1.21700962e-03f, -3.42828259e-02f, -1.11746434e-02f, 3.14553231e-02f, -4.92240079e-02f, -1.71328355e-02f, 3.38349119e-02f, 6.71238219e-03f, -9.42156687e-02f,
  -2.54178811e-02f, 3.29893902e-02f, 3.71830761e-02f, 4.06585708e-02f, 3.69744860e-02f, -2.17966493e-02f, 3.84212472e-02f, 4.53149993e-03f, -4.82876860e-02f, 1.26086161e-01f,
  9.01833922e-02f, -6.75189048e-02f, 3.81497294e-02f, -1.64456554e-02f, -5.56686185e-02f, -6.95418194e-02f, -2.53867712e-02f, -2.74314061e-02f, -5.53532690e-02f, 3.88857946e-02f,
  -6.09634928e-02f, 9.07806829e-02f, 5.04370928e-02f, 1.59406420e-02f, 3.43689285e-02f, -7.21887946e-02f, -1.90596692e-02f, 5.35566919e-02f, 1.30002080e-02f, -9.72089991e-02f,
  -8.20303336e-02f, -4.13021296e-02f, -2.24221461e-02f, 2.02450734e-02f, -6.10486157e-02f, 9.93044972e-02f, 5.08966856e-02f, 7.08484054e-02f, -3.19755040e-02f, 6.27399907e-02f,
  -7.26380059e-03f, -2.48482600e-01f, -2.48588309e-01f, -5.83211966e-02f, 7.26366416e-03f, -3.15202981e-01f, -2.43177757e-01f, -1.73446432e-01f, 5.58287874e-02f, 5.19281551e-02f,
  -3.55792381e-02f, 7.24092722e-02f, 4.35365178e-02f, -1.18659139e-01f, 1.12589717e-01f, 9.09493268e-02f, -1.62107065e-01f, -1.07026957e-01f, -1.11652911e-01f, -2.30884477e-01f,
  1.79509399e-03f, -1.05926119e-01f, -1.19795345e-01f, -8.34734216e-02f, -2.39495143e-01f, 1.70328300e-02f, 1.24919184e-01f, -3.39379124e-02f, -1.78567603e-01f, 3.05850003e-02f,
  -1.55660249e-02f, 1.72542244e-01f, -7.70675912e-02f, -1.73296547e-03f, -8.37299451e-02f, -8.57623667e-02f, -8.72643963e-02f, 5.80997840e-02f, 7.24094436e-02f, -7.95654766e-03f,
  -5.63869737e-02f, -6.72363769e-03f, 8.32145289e-03f, 1.05221808e-01f, -8.65605250e-02f, 1.68741141e-02f, -9.35470462e-02f, 4.95121256e-03f, -2.83561572e-02f, 5.88457547e-02f,
  -7.47615248e-02f, -2.25620456e-02f, -1.30447641e-01f, 3.39371935e-02f, -8.60639811e-02f, -4.65859585e-02f, 8.07307952e-04f, 1.37163736e-02f, -5.84217235e-02f, -7.35763507e-03f,
  -2.71596503e-03f, 4.34302688e-02f, 6.29351735e-02f, -1.11102231e-01f, 3.70732695e-02f, 9.41990092e-02f, 3.13587263e-02f, -3.24815363e-02f, -1.90067920e-03f, -5.08484952e-02f,
  -9.49567370e-03f, 2.68169511e-02f, 2.44180541e-02f, 7.59251695e-03f, -9.91726518e-02f, 4.75458847e-03f, -5.69316596e-02f, 4.38524522e-02f, -8.16354901e-02f, -1.10935442e-04f,
  3.73173021e-02f, -1.39550900e-03f, -7.59228319e-03f, -2.95546390e-02f, -5.76975942e-02f, 1.02665648e-01f, -2.85727512e-02f, -1.06757777e-02f, 5.87184466e-02f, 1.06843084e-01f,
  -1.37606442e-01f, 3.03525687e-03f, 8.45529288e-02f, -5.99112622e-02f, 2.26656944e-02f, 5.36361076e-02f, -4.50309925e-02f, -2.75972094e-02f, -2.45889463e-02f, -1.85935330e-02f,
  -5.83342612e-02f, -3.64102088e-02f, -6.29450604e-02f, -6.73095509e-02f, -1.53037729e-02f, 6.49017990e-02f, 2.30312012e-02f, -2.46336795e-02f, -1.57149360e-02f, -1.13451175e-01f,
  -7.48004168e-02f, 7.15672225e-03f, 1.28351450e-01f, -2.36036982e-02f, 2.65216678e-02f, -4.36794423e-02f, 7.54598007e-02f, 2.97749788e-02f, 8.66582501e-04f, -1.50518771e-02f,
  1.31081074e-01f, 1.83746010e-01f, 7.75886998e-02f, 1.19825855e-01f, -2.22090960e-01f, -2.76954204e-01f, -1.40562922e-01f, -1.74658090e-01f, 6.86217248e-02f, 3.11531201e-02f,
  -3.48713100e-02f, 3.86146516e-01f, -1.08308166e-01f, -1.52801173e-02f, -2.62354374e-01f, -1.96963444e-01f, -1.29764602e-01f, -2.60586534e-02f, 6.38485840e-03f, -6.39460459e-02f,
  -9.67398286e-02f, -2.49476522e-01f, -1.38760924e-01f, -8.23211297e-02f, 3.11601628e-02f, 1.58304080e-01f, -2.92219152e-03f, -1.08459197e-01f, 3.83853354e-02f, -8.87135416e-02f,
  3.43151093e-02f, 6.93459213e-02f, 1.27356529e-01f, 4.14142199e-02f, -3.94289047e-02f, 7.34447986e-02f, 1.62622146e-02f, -1.50602488e-02f, 3.75277996e-02f, -1.28614400e-02f,
  1.15441330e-01f, -4.10699025e-02f, 7.67096877e-02f, -4.52151336e-02f, -5.19614145e-02f, 1.01273350e-01f, 9.93555188e-02f, 8.25343207e-02f, 9.19828285e-03f, 6.10371418e-02f,
  1.18786424e-01f, 6.25487417e-02f, -5.82789816e-02f, -1.11040557e-02f, -4.14889418e-02f, 2.71492004e-02f, 4.56279628e-02f, 4.43735197e-02f, 7.76989684e-02f, 3.21248025e-02f,
  -8.89132023e-02f, -4.77271294e-03f, 5.70476763e-02f, 7.39556327e-02f, 1.67076401e-02f, -4.90442337e-03f, 4.71249297e-02f, 1.65321939e-02f, 6.80530667e-02f, -4.37038066e-03f,
  -6.13736128e-03f, 3.30312401e-02f, -5.90131357e-02f, -7.72434324e-02f, 4.75939661e-02f, 3.10671274e-02f, 6.78510293e-02f, 2.31810892e-03f, -1.91757344e-02f, 3.14869732e-02f,
  2.04691105e-02f, -1.03919266e-03f, -4.49767970e-02f, -2.15956625e-02f, 3.04767676e-02f, 1.75566226e-02f, 2.33052466e-02f, 9.28906351e-03f, -2.07739009e-04f, -4.24836054e-02f,
  -1.00722536e-01f, -8.19981843e-02f, -6.86413329e-03f, -1.07797245e-02f, -6.41687289e-02f, -6.47918060e-02f, -4.52361703e-02f, -6.15493162e-03f, -2.50225258e-03f, -6.90607652e-02f,
  -2.68345121e-02f, 2.82885563e-02f, 7.88881853e-02f, 1.67426281e-02f, -3.41280848e-02f, 8.89865961e-03f, -3.67197655e-02f, -3.60724479e-02f, -1.26028329e-03f, 5.44992015e-02f,
  1.37626268e-02f, 3.84449773e-02f, 3.45706232e-02f, 3.24905664e-02f, -3.12075596e-02f, -3.82206589e-02f, -4.38782386e-04f, 1.18975259e-01f, -1.16892241e-01f, -5.36058508e-02f,
  -4.57356637e-03f, 4.82433401e-02f, 5.61448140e-03f, -1.45086646e-01f, -1.14626527e-01f, 1.50743216e-01f, 7.71552622e-02f, -1.77869529e-01f, -1.11959860e-01f, -8.38676319e-02f,
  7.62145221e-02f, 6.56228215e-02f, 1.45424902e-01f, -8.29106867e-02f, 1.14297241e-01f, 1.00990040e-02f, 5.94118200e-02f, 3.16736028e-02f, 6.01658374e-02f, 9.45930406e-02f,
  5.87189347e-02f, -6.66724797e-03f, 4.97573167e-02f, -1.48381948e-01f, -2.26629190e-02f, -1.06171504e-01f, -5.20295240e-02f, 5.65277301e-02f, -1.19648978e-01f, -2.17238516e-02f,
  3.55736613e-02f, 4.35958281e-02f, 8.25750083e-02f, 4.72122394e-02f, 2.32714340e-02f, 6.64027967e-03f, 6.50263429e-02f, 9.67794582e-02f, 1.90650381e-03f, -2.88917720e-02f,
  -5.69567867e-02f, -4.26608883e-03f, -6.02057017e-02f, -1.37667403e-01f, 8.70796945e-03f, -5.72667420e-02f, 1.66071244e-02f, 8.38435814e-02f, 4.62263934e-02f, 1.68159436e-02f,
  -9.69858095e-02f, -3.39823849e-02f, 4.49497998e-02f, -1.73553750e-02f, 1.45117063e-02f, -2.63374224e-02f, 6.96163774e-02f, -3.90415005e-02f, -4.10992429e-02f, 2.54441164e-02f,
  3.03645190e-02f, 3.28120515e-02f, 4.13141698e-02f, 1.07323872e-02f, -3.06418892e-02f, 1.58667937e-02f, 4.47168648e-02f, -1.43443812e-02f, 1.68427601e-02f, -7.28349900e-03f,
  -4.50532371e-03f, 3.93282957e-02f, 5.04005626e-02f, 5.37607409e-02f, 5.37100583e-02f, 7.46794268e-02f, -2.52288729e-02f, -5.23008890e-02f, -6.63360860e-03f, 5.93495741e-03f,
  -8.20052624e-02f, 4.04203385e-02f, 5.16658165e-02f, -4.28593457e-02f, -1.13395333e-01f, 2.46632658e-02f, -5.13719171e-02f, -3.38861276e-03f, 6.87502995e-02f, 1.42235551e-02f,
  5.09483591e-02f, -4.73465398e-02f, -7.02633038e-02f, 3.43393572e-02f, 6.65894821e-02f, -1.17650079e-02f, 6.78489683e-03f, -1.16601236e-01f, 5.12004569e-02f, 1.35808721e-01f,
  5.19277938e-02f, -4.77025732e-02f, 5.74865639e-02f, -7.58115351e-02f, 7.27171311e-04f, 3.06157824e-02f, 7.34888166e-02f, 4.69112508e-02f, -5.21134622e-02f, -6.50126934e-02f,
  4.40137871e-02f, 4.05537561e-02f, -5.70188509e-03f, -3.68355364e-02f, 5.04426798e-03f, -6.50964156e-02f, 1.96740660e-03f, -1.25883147e-02f, -1.97204296e-02f, 7.87161738e-02f,
  -8.29496533e-02f, -2.53788475e-02f, -7.00805858e-02f, -4.47833128e-02f, 8.96695722e-03f, -6.06100028e-03f, 7.32085481e-02f, -3.71174961e-02f, -9.04613454e-03f, 1.11754432e-01f,
  -6.77156895e-02f, 6.90512657e-02f, 1.18053719e-01f, 7.91982114e-02f, -2.08331011e-02f, 7.30706453e-02f, -3.76028605e-02f, 1.41004939e-02f, 5.70549034e-02f, 2.47914046e-02f,
  1.82881635e-02f, -1.58224478e-02f, 4.73770238e-02f, -5.86591475e-02f, -1.66736245e-02f, -3.40378424e-03f, -1.07826084e-01f, 5.04294634e-02f, -9.07510296e-02f, -3.49206552e-02f,
  8.09741393e-02f, -7.07711130e-02f, 4.75460403e-02f, -6.80034608e-02f, -3.15337628e-02f, -8.64093155e-02f, -5.74851409e-02f, -4.61427607e-02f, -8.62621516e-02f, 2.64773201e-02f,
  3.83188017e-02f, 8.44624918e-03f, -4.61280793e-02f, -5.63261770e-02f, 1.65539067e-02f, -8.89600255e-03f, 2.16668658e-03f, -1.13304406e-01f, -3.37235592e-02f, -1.08637594e-01f,
  4.34524752e-02f, -9.84427985e-03f, 2.75099836e-03f, -5.82898818e-02f, 3.44966352e-02f, -1.10074140e-01f, 7.05120638e-02f, 4.50376570e-02f, -6.79515973e-02f, -7.62157887e-02f,
  -7.47046024e-02f, -7.65911341e-02f, -2.34292578e-02f, 5.42610623e-02f, 3.80907580e-02f, 1.94130596e-02f, 8.05987567e-02f, -3.85955609e-02f, 3.80283743e-02f, -3.90177630e-02f,
  3.36822979e-02f, -9.21191275e-03f, -3.21515910e-02f, 8.88825282e-02f, -9.49189216e-02f, -9.80182085e-03f, 2.06943955e-02f, 9.34463069e-02f, -7.21933842e-02f, -1.44729279e-02f,
  -1.61924548e-02f, 5.80826961e-02f, -5.73153682e-02f, -5.78058735e-02f, 3.20889764e-02f, 3.35951075e-02f, -6.22768179e-02f, -5.03331348e-02f, -1.03908241e-01f, 5.24658803e-03f,
  -3.81146297e-02f, 6.69221729e-02f, -1.99068394e-02f, -4.02465165e-02f, 1.03614241e-01f, -9.46232006e-02f, -6.53063357e-02f, 4.75701243e-02f, 2.64471900e-02f, -7.07904249e-02f,
  -5.71184717e-02f, 9.93367508e-02f, -3.61917913e-02f, -2.59537697e-02f, -2.63819285e-02f, -1.08886836e-02f, 1.06779551e-02f, 6.45464435e-02f, -7.03479722e-02f, -1.57709327e-02f,
  8.66737217e-02f, 3.65832113e-02f, -3.85172963e-02f, 4.40540351e-03f, 1.28243258e-02f, 6.04580604e-02f, -1.59244370e-02f, -9.66017693e-02f, -5.09558618e-02f, -6.19991831e-02f,
  8.80473033e-02f, -1.13701960e-02f, 5.47223201e-04f, 1.01758651e-01f, -8.64276364e-02f, -2.45129243e-01f, -4.60733250e-02f, 4.17956412e-02f, -7.09315017e-02f, -6.03234104e-04f,
  -1.30119277e-02f, 4.08459194e-02f, 6.31675571e-02f, -1.76268853e-02f, 2.45493241e-02f, 7.46315643e-02f, -7.39103882e-03f, -1.61639005e-02f, 3.76275331e-02f, 9.64848548e-02f,
  2.02665254e-01f, 1.27157280e-02f, 8.18419680e-02f, 4.02429104e-02f, -3.75890471e-02f, 1.57530457e-01f, 8.78841355e-02f, 3.79606970e-02f, 4.90210541e-02f, -9.84645113e-02f,
  -1.35618195e-01f, 1.21542156e-01f, 5.15247621e-02f, -6.36808723e-02f, 3.49202231e-02f, 5.37432469e-02f, -9.71953943e-02f, -5.25321402e-02f, -7.90948607e-03f, -4.87478673e-02f,
  5.40944934e-02f, 1.14296600e-01f, -1.02439724e-01f, 3.96405905e-02f, -4.99153174e-02f, -3.66112404e-02f, -2.23985463e-02f, -3.87046412e-02f, -3.66333872e-02f, 5.30971326e-02f,
  -2.90263910e-03f, -4.41944189e-02f, 6.23490289e-02f, -2.91461032e-02f, 1.70996115e-02f, -6.04787730e-02f, 7.20102116e-02f, -1.11962752e-02f, 5.27928118e-04f, -1.14467572e-02f,
  -1.02024917e-02f, -4.30914350e-02f, 7.26328194e-02f, -6.53013960e-02f, -3.95502038e-02f, -5.42723201e-02f, 6.16972111e-02f, 3.36923040e-02f, -5.66356294e-02f, -5.87859601e-02f,
  -4.11259569e-02f, -5.15436754e-02f, 1.49791697e-02f, -3.42248790e-02f, 8.91048834e-02f, -5.38138971e-02f, 4.45758514e-02f, 1.68363168e-03f, -2.23973747e-02f, -4.55352105e-02f,
  -2.08427813e-02f, -5.11616357e-02f, -1.62037108e-02f, -3.10558602e-02f, -6.74141422e-02f, 7.09980950e-02f, 9.61786043e-03f, 9.29367468e-02f, -1.25279129e-02f, -8.80535506e-03f,
  1.00295782e-01f, 1.41760841e-01f, 4.81713144e-03f, -4.59200591e-02f, 3.38955410e-03f, -1.14206694e-01f, 8.70082229e-02f, -4.45233285e-02f, 9.34929848e-02f, -7.32282326e-02f,
  1.88896079e-02f, -1.54605936e-02f, -2.63175764e-03f, -1.87076665e-02f, 9.66575870e-04f, 6.73549622e-02f, -4.62141037e-02f, 4.38988209e-02f, -1.10852823e-01f, 4.75045443e-02f,
  4.82198447e-02f, -8.98905396e-02f, 4.59784009e-02f, 1.27579374e-02f, 2.26110313e-02f, 3.94594818e-02f, -5.47185130e-02f, 6.67440221e-02f, -7.84238726e-02f, 7.74751306e-02f,
  7.62147903e-02f, -1.23073664e-02f, -5.54980487e-02f, 1.80829770e-03f, -9.73259732e-02f, -1.69374254e-02f, 2.72355005e-02f, -4.42544259e-02f, 6.85566217e-02f, 1.74270302e-01f,
  -1.46268820e-03f, 1.15287602e-01f, 9.89586040e-02f, 1.66455470e-02f, 6.52953833e-02f, 1.41960932e-02f, 1.41738385e-01f, -5.90275154e-02f, -6.89459592e-02f, 1.04596436e-01f,
  -3.35172750e-02f, 8.16799477e-02f, -7.97937661e-02f, 8.66881311e-02f, -9.45164040e-02f, -1.08527958e-01f, 1.06784906e-02f, -4.28295806e-02f, -2.05003209e-02f, 7.78269917e-02f,
  1.66411642e-02f, 1.20113455e-01f, 2.50055902e-02f, -4.79060858e-02f, -3.46016847e-02f, 1.07413903e-01f, 3.64499306e-03f, -1.26841711e-02f, 9.96559300e-03f, -1.37519315e-02f,
  -2.77108084e-02f, -7.07702413e-02f, -1.54187214e-02f, -5.07840104e-02f, 5.55079542e-02f, -2.40345988e-02f, 1.23487981e-02f, -7.69157261e-02f, -7.13496804e-02f, 3.67294960e-02f,
  -6.67304769e-02f, 1.10436985e-02f, -1.06630094e-01f, -2.28455551e-02f, -3.34637463e-02f, -1.26261473e-01f, -8.57612714e-02f, 3.80216837e-02f, -1.28628928e-02f, -8.23631510e-02f,
  -6.01628385e-02f, 5.35194464e-02f, 2.46864483e-02f, 2.74172928e-02f, -1.69290807e-02f, -6.26292592e-03f, 2.92991996e-02f, -8.73726048e-03f, -2.41338648e-02f, 5.86607680e-02f,
  -9.88111738e-03f, -1.10371588e-02f, -7.53196329e-02f, 3.19197774e-02f, 3.11143696e-02f, -3.28956060e-02f, -2.28124065e-03f, 3.67883369e-02f, 2.53408123e-02f, 6.24220408e-02f,
  -6.30713180e-02f, 4.69961241e-02f, 4.77684364e-02f, 6.62154332e-02f, 1.37610054e-02f, 4.24391441e-02f, 7.38950372e-02f, -3.93525437e-02f, -3.96293588e-02f, 6.25359714e-02f,
  3.50013189e-02f, -1.49046211e-02f, 9.58602875e-02f, 3.17000486e-02f, -5.46231531e-02f, 5.79297878e-02f, -4.00209762e-02f, 7.40015730e-02f, -2.85824221e-02f, 8.87872502e-02f,
  2.61131190e-02f, -2.00981349e-02f, 8.22709315e-03f, -5.03496751e-02f, -4.24198620e-02f, 8.51611346e-02f, -4.17585410e-02f, -2.95485668e-02f, 8.33325740e-03f, -7.21963421e-02f,
  -4.93518300e-02f, 1.76563915e-02f, 1.51797123e-02f, -7.04456940e-02f, -4.26999293e-03f, -2.76442394e-02f, -1.38040846e-02f, -4.54556337e-03f, 9.87785161e-02f, 1.25058070e-02f,
  3.31894368e-01f, -5.19318342e-01f, 7.66828358e-02f, 2.18715146e-01f, 2.79363155e-01f, 5.45769557e-02f, 2.67747521e-01f, -1.34196475e-01f, -8.41966122e-02f, -3.16015393e-01f,
  -7.55029097e-02f, -8.40380937e-02f, -1.22634627e-01f, -9.64611098e-02f, 2.25838825e-01f, -1.65070415e-01f, -1.22545712e-01f, -6.54959381e-02f, -1.03767373e-01f, -1.51577285e-02f,
  8.38023424e-02f, 8.60700160e-02f, 3.29224244e-02f, -7.20146894e-02f, 8.84346887e-02f, 6.29584789e-02f, 1.17211722e-01f, 1.27378792e-01f, 3.88604924e-02f, 1.46703094e-01f,
  -2.87441239e-02f, -5.97554669e-02f, 2.77799610e-02f, -1.18624531e-01f, -3.61110866e-02f, -4.88316566e-02f, 3.96106206e-02f, 4.98195328e-02f, -4.23108563e-02f, -4.21188585e-02f,
  -9.01264101e-02f, 1.81334186e-02f, 3.59166600e-02f, 7.71650150e-02f, 4.26112413e-02f, -4.73994389e-02f, 2.93490030e-02f, -1.32546034e-02f, -4.38639615e-03f, -1.16523402e-02f,
  -8.46188441e-02f, -3.59224640e-02f, -1.06672791e-03f, -2.39357445e-02f, -1.54363150e-02f, -7.36259343e-03f, 8.41180012e-02f, 2.80846208e-02f, -4.23043640e-03f, -6.77729771e-02f,
  -6.29572496e-02f, -2.38057766e-02f, -2.96727344e-02f, 1.71492565e-02f, -1.49713159e-02f, 9.50892270e-02f, 1.68019086e-02f, 3.38591971e-02f, 9.33944341e-03f, -4.90281656e-02f,
  4.73004207e-02f, -1.74455089e-03f, -3.04995030e-02f, 4.21740748e-02f, -3.76528390e-02f, 1.83230974e-02f, 2.49683508e-03f, 6.99718520e-02f, 8.34208506e-04f, 5.50107099e-04f,
  5.26323840e-02f, 4.94793728e-02f, -1.53846713e-02f, 4.91278172e-02f, -3.46310101e-02f, 4.73119728e-02f, 1.19071193e-02f, -3.13926265e-02f, -4.19314802e-02f, 7.12681115e-02f,
  -2.35757858e-01f, -2.11496532e-01f, -7.06313774e-02f, -1.42631689e-02f, 2.57993471e-02f, -7.00973198e-02f, 1.61262508e-02f, 1.39569743e-02f, -5.85951768e-02f, 1.34313351e-03f,
  -3.38310115e-02f, 7.99935460e-02f, -1.45463897e-02f, 1.16895726e-02f, -2.47665448e-03f, -1.57696921e-02f, 5.52062951e-02f, -1.67828668e-02f, -4.96771149e-02f, -3.72727439e-02f,
  1.54066002e-02f, 3.73228523e-03f, 3.62103176e-03f, -5.19200182e-03f, -5.03597874e-03f, 7.17927562e-03f, -2.86910385e-02f, 1.61554199e-02f, -5.73493093e-02f, -1.26088932e-02f,
  2.85066605e-01f, -9.85048413e-02f, 2.47590877e-02f, 2.62223959e-01f, -8.85067657e-02f, -1.40940830e-01f, -2.84938604e-01f, 6.11013593e-03f, -1.56285018e-01f, -1.29574671e-01f,
  1.04483515e-01f, -4.98160943e-02f, -1.60057023e-01f, 1.78947121e-01f, 2.27382928e-01f, -7.46046156e-02f, 7.65961930e-02f, -3.63204256e-02f, -1.15132786e-01f, -1.91671066e-02f,
  1.13657840e-01f, 1.82739943e-01f, 2.27037981e-01f, 1.72893271e-01f, 7.14516034e-03f, 7.31653571e-02f, 1.44933447e-01f, -1.11559421e-01f, 6.16760179e-02f, 3.80854011e-02f,
  -1.46615133e-01f, -7.99393877e-02f, 7.24469647e-02f, 3.25827263e-02f, 3.81053127e-02f, -1.16293326e-01f, -5.78143410e-02f, 1.18898287e-01f, 6.01290166e-02f, 1.46530697e-03f,
  -2.79756244e-02f, -4.13197465e-03f, 2.97844391e-02f, 7.67222547e-04f, 3.41760293e-02f, 9.07371268e-02f, 1.95261706e-02f, -1.55860290e-03f, -2.79566608e-02f, 5.35812750e-02f,
  -1.51381241e-02f, 1.08334180e-02f, 1.00053158e-02f, 8.29316154e-02f, 1.07432120e-01f, 5.87734841e-02f, -1.98151600e-02f, 3.09871454e-02f, -8.79820213e-02f, 7.25616068e-02f,
  -4.78943400e-02f, -7.59174228e-02f, -2.60924771e-02f, 1.12553714e-02f, 1.80002060e-02f, 2.13035289e-02f, -1.99350659e-02f, -1.30632762e-02f, 4.42657508e-02f, 1.31076630e-02f,
  -2.17444133e-02f, 9.83845741e-02f, 5.80971539e-02f, -2.02071220e-02f, 3.49514885e-03f, 1.20087974e-02f, -2.77867578e-02f, 2.96524949e-02f, 4.60633971e-02f, -1.69404615e-02f,
  -8.22584108e-02f, 4.17180136e-02f, -3.54518667e-02f, -5.65183423e-02f, 6.52851760e-02f, -1.58251543e-02f, -4.97335847e-03f, -4.18927567e-03f, -5.06722629e-02f, -5.33614829e-02f,
  4.10148241e-02f, 1.14821382e-01f, -2.46531107e-02f, -2.24200562e-02f, -6.49863407e-02f, 2.83835493e-02f, -8.28724168e-03f, -3.94831784e-03f, 1.85005029e-03f, 6.40047388e-03f,
  1.10595103e-03f, -1.41940173e-02f, -6.81932643e-02f, 4.16708030e-02f, 3.07128690e-02f, -6.74640015e-02f, 6.06781915e-02f, -5.79914786e-02f, 6.75986931e-02f, 9.61766914e-02f,
  -2.14219615e-02f, -1.03289459e-03f, -2.19696257e-02f, -5.68578169e-02f, -1.45383263e-02f, -1.08622596e-01f, -3.22434083e-02f, -3.83729003e-02f, 1.16321363e-01f, -9.33260424e-04f,
  -1.83024272e-01f, -1.16619460e-01f, 9.56616104e-02f, -1.84138358e-01f, 3.39569002e-02f, -2.81287402e-01f, -1.30879357e-01f, 3.98142487e-02f, -8.02097693e-02f, 1.05974033e-01f,
  9.21927989e-02f, -1.37229249e-01f, 2.22767055e-01f, -2.69150048e-01f, -1.85515821e-01f, -1.69363320e-01f, -2.20398143e-01f, -1.65637448e-01f, -5.57460412e-02f, 1.24733821e-01f,
  -1.22302778e-01f, -8.96813814e-03f, -8.21425617e-02f, 1.04463771e-01f, 2.14465540e-02f, 1.17101418e-02f, 3.72084886e-01f, 1.25158921e-01f, -7.02106357e-02f, -1.91351566e-02f,
  -8.98315087e-02f, 1.04555339e-01f, 5.97519539e-02f, 5.25049046e-02f, 3.60012986e-02f, 1.63917616e-02f, 8.12973529e-02f, -2.59920415e-02f, -1.02965441e-02f, -4.81364429e-02f,
  -1.96052343e-03f, -4.57856320e-02f, -3.46885286e-02f, 2.88023073e-02f, -1.03196697e-02f, -3.57620046e-02f, -5.30026220e-02f, -8.18821639e-02f, -2.49228347e-02f, -5.77112436e-02f,
  -2.76756156e-02f, -2.69906390e-02f, -3.12492028e-02f, 8.75679683e-03f, -4.39409465e-02f, 1.31897563e-02f, 4.49157506e-02f, 1.26407184e-02f, -3.81404310e-02f, -8.28588009e-02f,
  -2.71252114e-02f, 8.16729758e-03f, -2.38974998e-03f, -2.42145117e-02f, -3.05446349e-02f, 2.70076003e-02f, -3.57022062e-02f, 1.92292295e-02f, 4.36308281e-03f, 9.05247927e-02f,
  -4.47283639e-03f, 3.26271392e-02f, 1.60080045e-02f, 3.15871723e-02f, 2.82941684e-02f, 4.31413241e-02f, 3.84259634e-02f, 4.88032401e-02f, -1.90271772e-02f, 7.06107682e-03f,
  1.29820585e-01f, 4.65017632e-02f, -6.22421056e-02f, -7.78300595e-03f, 1.94165278e-02f, 2.05562878e-02f, 1.10751530e-03f, 7.01861572e-04f, 7.26253465e-02f, -1.60909481e-02f,
  1.15094319e-01f, 1.95970625e-01f, -2.22969763e-02f, -5.09855114e-02f, -8.60940758e-03f, -5.96452281e-02f, -5.31887524e-02f, 1.47698894e-02f, 9.78108495e-02f, 3.89302224e-02f,
  3.08960844e-02f, -2.80190222e-02f, 6.03932142e-02f, -6.70046210e-02f, -2.69354377e-02f, 4.79200929e-02f, 1.25388026e-01f, 3.12276389e-02f, -2.38467641e-02f, 1.79760847e-02f,
  5.80410883e-02f, -1.45999314e-02f, -4.02793027e-02f, -4.70301211e-02f, 3.86106931e-02f, 1.30308317e-02f, -2.46275831e-02f, 2.30897963e-02f, -2.13736780e-02f, 6.53726310e-02f,
  2.37479419e-01f, -1.00671031e-01f, -8.76126066e-02f, 4.30302508e-02f, 1.61782622e-01f, 2.75681205e-02f, 5.52640902e-03f, 4.87070307e-02f, 1.45582780e-01f, -1.77239165e-01f,
  9.66386124e-02f, -3.04358965e-03f, 1.35184428e-05f, 4.24655937e-02f, 1.04650475e-01f, -1.68044046e-02f, 1.09424360e-01f, 1.20884761e-01f, -5.17727574e-03f, -1.39451940e-02f,
  6.37615426e-03f, 3.75910848e-02f, 1.74852442e-02f, -1.03034042e-01f, -1.90470815e-02f, -8.59830305e-02f, -2.30266037e-03f, -4.15454321e-02f, -6.86421618e-02f, -1.20528676e-01f,
  -3.05239484e-03f, 2.16290597e-02f, -2.53420919e-02f, -3.77748646e-02f, -1.05456457e-01f, 2.55845245e-02f, -4.81912531e-02f, -4.42572311e-02f, 6.47456869e-02f, -4.69253846e-02f,
  1.66375414e-02f, 5.14222123e-02f, -5.92634194e-02f, 8.91855918e-03f, -3.39480005e-02f, -4.10330035e-02f, 2.28293962e-03f, 5.91214607e-03f, 1.97305698e-02f, 2.29506474e-03f,
  4.69284765e-02f, -5.51918969e-02f, 7.56868273e-02f, -6.44419491e-02f, -1.20341048e-01f, -7.28583720e-04f, 2.58908942e-02f, -6.92549646e-02f, 8.12579133e-03f, 1.51760681e-02f,
  3.29907127e-02f, 2.72438768e-02f, -4.18395102e-02f, 1.19465426e-01f, 4.36184257e-02f, 8.34175050e-02f, 2.96557005e-02f, 4.70934212e-02f, -8.52253102e-03f, 1.78643540e-02f,
  6.35738745e-02f, 3.11366655e-03f, 4.59664427e-02f, -7.44103044e-02f, -3.21990065e-02f, -1.36185959e-02f, -3.57816592e-02f, 3.68477255e-02f, -9.97268856e-02f, -6.83144554e-02f,
  2.65354235e-02f, -6.14746101e-03f, -7.33068883e-02f, 7.29442686e-02f, 9.34985839e-03f, 4.65980805e-02f, 6.87143859e-03f, -2.82142516e-02f, -1.71818957e-02f, -4.80699390e-02f,
  7.08929682e-03f, -6.20817654e-02f, -6.79293573e-02f, -8.19716079e-04f, -3.66923586e-02f, -6.46890402e-02f, -6.52274350e-04f, 6.86396100e-03f, -4.00018245e-02f, 6.94541112e-02f,
  -3.31208371e-02f, 7.13624582e-02f, -5.59099279e-02f, 9.75181982e-02f, -5.81286028e-02f, 8.53489488e-02f, -9.49974805e-02f, -9.52523723e-02f, 9.51254368e-03f, 4.83056856e-03f,
  5.26560433e-02f, -3.55920680e-02f, 1.88398473e-02f, 6.90955892e-02f, -1.36300936e-01f, -5.14380336e-02f, 8.79380703e-02f, -5.84370978e-02f, -2.71335281e-02f, -6.32454902e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.20197553e-02f, -1.97044373e-01f, 1.13459706e-01f, -5.41434363e-02f, -2.05478266e-01f, 1.16143830e-03f, 1.13586495e-04f, -4.51715924e-02f, -8.62274766e-02f, 6.12341836e-02f,
  6.44343123e-02f, -6.62556291e-02f, 4.54016402e-02f, 8.45832527e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.25736469e-02f, 4.00214344e-02f, -3.05046588e-01f, -5.26740626e-02f, 1.02331109e-01f, -2.69518476e-02f, 5.61281256e-02f, 1.81348905e-01f, -1.05948821e-01f, -2.36945719e-01f,
  -1.93986654e-01f, 1.46345720e-01f, 2.62117416e-01f, 1.98461547e-01f, 4.27711219e-01f, 2.73261797e-02f, 1.68653011e-01f, 1.64890006e-01f, -2.19506081e-02f, -1.62755355e-01f,
  1.98612779e-01f, 1.07099332e-01f, -1.41765296e-01f, -2.58894473e-01f, -9.07365903e-02f, -4.38828580e-02f, 1.62219808e-01f, 1.85518235e-01f, 1.18652277e-03f, 3.59206200e-01f,
  -1.08617999e-01f, 1.05743110e-01f, -3.67518328e-03f, -6.59694001e-02f, 1.46161407e-01f, -1.21076472e-01f, -1.22899145e-01f, -1.03681244e-01f, -1.04172423e-01f, 2.06180196e-02f,
  -8.54252875e-02f, -1.45654678e-01f, 2.12403163e-01f, 1.49249494e-01f, -2.27394029e-01f, -1.65191337e-01f, -6.91324696e-02f, 1.80192351e-01f, 3.68427671e-02f, -3.42744263e-03f,
  1.61873728e-01f, 2.33377576e-01f, 4.44801003e-02f, -2.24916693e-02f, 2.47707009e-01f, -1.98499128e-01f, -3.02385818e-02f, 9.00317654e-02f, 1.72766939e-01f, -3.10791340e-02f,
  3.99164185e-02f, -1.59560934e-01f, 6.78180903e-02f, -1.79186597e-01f, 1.69221647e-02f, -1.44763887e-01f, -1.49879546e-03f, 2.33509280e-02f, -1.23920880e-01f, 3.32536474e-02f,
  3.62419896e-03f, 1.08962052e-01f, 1.74557656e-01f, -9.35441628e-02f, 4.09419537e-01f, 9.61645171e-02f, -1.39666563e-02f, -2.01294571e-01f, -1.95703372e-01f, 3.51397395e-01f,
  -2.76744161e-02f, 6.15158379e-02f, -1.64275438e-01f, 6.37783320e-04f, 2.59373803e-02f, 1.22225516e-01f, 3.10623527e-01f, -1.02845281e-01f, -1.68503448e-01f, -3.05793229e-02f,
  1.17804371e-01f, 9.97444466e-02f, -4.16263163e-01f, -1.84120074e-01f, 2.39495426e-01f, 1.77640803e-02f, 2.56589111e-02f, 6.19012117e-03f, 2.67350346e-01f, 2.14855015e-01f,
  1.68763548e-02f, 1.97928220e-01f, -2.17563882e-01f, 1.05504908e-01f, 1.24773972e-01f, 3.72282177e-01f, -2.23558351e-01f, 8.59099999e-02f, 3.49513948e-01f, 1.64882600e-01f,
  9.06521678e-02f, -1.76551566e-01f, -5.71518801e-02f, -2.26660401e-01f, 1.53484628e-01f, 1.59719571e-01f, 2.32944638e-01f, 2.47063022e-02f, 1.77285030e-01f, 1.55838177e-01f,
  -5.41965440e-02f, -1.14734925e-03f, 5.30921035e-02f, -2.43994053e-02f, 2.50007063e-01f, -3.50365907e-01f, -2.69017190e-01f, 1.72437474e-01f, -6.41008839e-02f, -2.57948190e-01f,
  -2.88562328e-01f, -1.78371936e-01f, 2.61036873e-01f, 4.42143343e-02f, -1.88386172e-01f, 8.54874868e-03f, -2.14561298e-01f, -5.48509732e-02f, -2.01708019e-01f, -2.54238576e-01f,
  -5.63699640e-02f, 2.57777482e-01f, -2.38446280e-01f, -2.43408620e-01f, 2.13156864e-01f, -6.10887073e-02f, -1.55215830e-01f, -2.65531391e-01f, -8.16446617e-02f, 9.72585455e-02f,
  -2.27411032e-01f, 1.05440333e-01f, -1.44356340e-01f, -1.30824521e-01f, 1.09220244e-01f, -1.35202095e-01f, 1.87985286e-01f, 2.92487919e-01f, 8.41778517e-03f, 1.06956877e-01f,
  1.97233215e-01f, 2.58358140e-02f, -1.63794398e-01f, 1.10023193e-01f, 2.39529207e-01f, 5.03363833e-02f, 1.02253221e-01f, 1.05468124e-01f, 4.27916944e-02f, -1.37132019e-01f,
  1.21468313e-01f, -9.78582427e-02f, -1.80663645e-01f, -7.91946948e-02f, 6.22684658e-02f, 1.58592746e-01f, 9.09107327e-02f, 2.84387290e-01f, 8.27123784e-03f, 7.61656091e-02f,
  -9.69384685e-02f, 1.21119283e-01f, -1.73376739e-01f, 1.11044116e-01f, 4.74164970e-02f, 5.18536009e-02f, 1.23716295e-01f, 1.57028303e-01f, -1.00918382e-01f, 1.22739658e-01f,
  2.97181875e-01f, 1.56672284e-01f, -1.51921555e-01f, -3.97868380e-02f, 4.93603423e-02f, -1.16661154e-01f, 9.82671455e-02f, 2.47357607e-01f, -6.35071518e-03f, -1.79758772e-01f,
  -2.60583200e-02f, 1.44220740e-01f, -1.35897875e-01f, 6.94878623e-02f, 1.65109590e-01f, -1.56349465e-01f, 8.74262378e-02f, -2.24222973e-01f, 1.69694677e-01f, -2.57136106e-01f,
  -4.75566238e-02f, -2.25967243e-01f, -9.37845185e-02f, 5.36137633e-02f, -8.26042704e-03f, -2.40594313e-01f, 1.18845165e-01f, 3.79027762e-02f, -2.14038923e-01f, -1.55588323e-02f,
  4.89457488e-01f, -3.06593142e-02f, -2.84986228e-01f, 1.91849291e-01f, 1.12829758e-02f, -1.98586136e-01f, 4.04879116e-02f, 1.51825413e-01f, -1.37544960e-01f, -1.53899699e-01f,
  -3.16032232e-03f, -3.17693055e-02f, 1.67689562e-01f, 1.76172573e-02f, 1.54242396e-01f, 1.46831930e-01f, -1.50350362e-01f, -1.69089437e-01f, 1.52132764e-01f, 1.44825503e-01f,
  1.20755687e-01f, 9.15521607e-02f, 9.85503495e-02f, -9.44175720e-02f, -9.58155245e-02f, -5.97895458e-02f, -1.39327303e-01f, -2.58888662e-01f, -9.98112783e-02f, -7.75983408e-02f,
  -2.00841382e-01f, 1.37565834e-02f, -8.76268819e-02f, 4.42368053e-02f, 1.08136743e-01f, -1.84942037e-01f, 1.32709563e-01f, 2.01095920e-02f, 6.83127493e-02f, 1.44368321e-01f,
  -7.03859478e-02f, 6.33823425e-02f, -1.03783831e-01f, -9.43838879e-02f, -7.56680965e-02f, 2.10581645e-01f, -2.00227126e-01f, -1.47242948e-01f, 4.62040268e-02f, -6.28698245e-02f,
  1.24130853e-01f, -1.12575836e-01f, 8.33393335e-02f, -1.21003613e-01f, 1.12926692e-01f, 2.27708668e-01f, -1.53963789e-01f, -7.59217888e-03f, 1.64221916e-02f, 2.39009395e-01f,
  2.00929597e-01f, 8.85102898e-02f, -2.08748523e-02f, -3.03872414e-02f, 3.01995844e-01f, 1.07920565e-01f, -9.90199372e-02f, 8.18645507e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  8.51490945e-02f, -3.07687502e-02f, 1.09252520e-02f, 8.65996480e-02f, 3.59436274e-02f, 5.69447242e-02f, 1.03875667e-01f, -6.61522150e-02f, -8.46346691e-02f, 1.49807990e-01f,
  -1.49214894e-01f, -6.71269894e-02f, -4.15464193e-02f, -1.74313262e-01f, 1.36961833e-01f, -4.80484031e-03f, 2.18557511e-02f, -2.18426764e-01f, 1.12805866e-01f, -1.53248847e-01f,
  -5.26002469e-03f, 1.29307106e-01f, 3.58618908e-02f, -1.71554849e-01f, 5.90423606e-02f, -1.33522928e-01f, -1.69550911e-01f, -1.38792291e-01f, 3.37895453e-01f, 2.11412489e-01f,
  -7.40143135e-02f, 1.83726057e-01f, -7.92721938e-03f, -2.00641993e-02f, -9.33180600e-02f, -1.72877192e-01f, -1.50409952e-01f, -8.93410668e-02f, -1.36525437e-01f, -2.75076553e-02f,
  -8.87857899e-02f, -6.86085522e-02f, 3.87243591e-02f, 1.03878431e-01f, -9.70551968e-02f, 8.52133557e-02f, -9.18459147e-02f, 1.34598352e-02f, -2.71251127e-02f, 1.21282496e-01f,
  -6.00168249e-03f, -2.59189866e-02f, -1.55361131e-01f, 1.04479035e-02f, 9.69077200e-02f, -1.25919014e-01f, -1.18730038e-01f, 7.07970932e-02f, -2.09910404e-02f, 1.23030394e-01f,
  1.11525595e-01f, -4.53059375e-02f, 1.15767889e-01f, 1.12727173e-01f, 1.02872789e-01f, -6.11422509e-02f, -1.18088812e-01f, -4.61171344e-02f, -7.64028355e-02f, 5.25943283e-03f,
  1.87588573e-01f, 9.24020633e-02f, -1.27084866e-01f, -1.90395564e-01f, 1.40654042e-01f, -1.56308323e-01f, -1.54891148e-01f, 1.77334286e-02f, -8.50529149e-02f, -2.88859066e-02f,
  1.25158191e-01f, -2.26537921e-02f, 1.33726910e-01f, 6.87419996e-02f, 6.20953646e-03f, -1.47812426e-01f, 8.67685974e-02f, 1.38329193e-01f, -1.45919710e-01f, -1.04136989e-01f,
  1.13117903e-01f, -1.41727641e-01f, -6.97440282e-02f, 1.96204409e-01f, 1.27846554e-01f, -3.20972539e-02f, -9.45384279e-02f, -1.29386768e-01f, -5.24833016e-02f, 1.29728779e-01f,
  3.34841490e-01f, 2.33762249e-01f, 1.53611720e-01f, 2.35359102e-01f, -1.63657099e-01f, -2.63878196e-01f, -1.48909882e-01f, -2.36107320e-01f, -7.86724612e-02f, 2.77531892e-01f,
  3.62354796e-03f, 7.94086009e-02f, 3.20660472e-01f, -3.79132256e-02f, -2.64070868e-01f, 8.85995850e-03f, 3.57940078e-01f, 5.54649197e-02f, -1.19889744e-01f, -1.60920143e-01f,
  -1.78865999e-01f, -2.06111893e-01f, 1.64210290e-01f, -1.17960140e-01f, 1.07738130e-01f, 2.22904623e-01f, 1.20233037e-01f, 1.08912808e-03f, -6.58317655e-02f, 2.00871095e-01f,
  1.78464547e-01f, 2.77189314e-01f, 1.73315883e-01f, 1.71727225e-01f, 1.99732512e-01f, 8.47432390e-03f, -3.42668369e-02f, 2.87528515e-01f, -7.23872557e-02f, 1.36380851e-01f,
  2.76425004e-01f, 5.03412448e-02f, 3.95701006e-02f, -1.76190674e-01f, 8.45528990e-02f, -1.77573130e-01f, 3.02062333e-01f, 2.05266595e-01f, 2.67656092e-02f, -7.73830861e-02f,
  2.05798298e-02f, 9.66192335e-02f, 6.99203461e-02f, -1.52995005e-01f, -1.22302540e-01f, -1.06110640e-01f, 3.89795862e-02f, 9.50381998e-03f, -1.15706660e-01f, 1.82684764e-01f,
  9.66029316e-02f, 2.77557075e-01f, -1.45538285e-01f, 1.92972183e-01f, 2.35396072e-01f, 2.99460441e-01f, 3.72679740e-01f, 2.39846006e-01f, 3.19520533e-01f, 5.35866171e-02f,
  -1.75811008e-01f, 1.03170946e-01f, 1.93873033e-01f, 1.43736184e-01f, 3.93717557e-01f, 1.32962083e-03f, 1.61699325e-01f, 4.94928584e-02f, 2.19490796e-01f, -2.51362622e-01f,
  3.06753874e-01f, 6.14006445e-02f, -3.09415460e-01f, -8.02176967e-02f, 2.25367308e-01f, 1.49212122e-01f, -2.56744381e-02f, 1.39656514e-01f, 3.94952565e-01f, 6.09393120e-02f,
  -1.27558917e-01f, 3.33388776e-01f, 5.93850426e-02f, -9.33668762e-02f, -8.52933004e-02f, 2.14257501e-02f, -1.58660427e-01f, 1.74508482e-01f, 1.60518333e-01f, -9.76469517e-02f,
  -1.01646064e-02f, 1.57092661e-01f, 1.67188130e-03f, -4.32905294e-02f, 1.40526816e-01f, 1.50303274e-01f, -1.20059036e-01f, 8.26849118e-02f, -3.06467488e-02f, 1.26991197e-01f,
  -1.66961193e-01f, 2.19159573e-01f, -1.22866631e-01f, 6.36945739e-02f, -7.61919748e-03f, -7.31557654e-03f, -1.08180441e-01f, -1.27069443e-01f, -7.75611028e-02f, -5.68063445e-02f,
  1.10617608e-01f, 3.56115587e-02f, -1.33612975e-01f, -1.03990957e-01f, 1.51998192e-01f, 2.17181072e-03f, -1.09413914e-01f, 1.48507312e-01f, 1.79898664e-01f, 8.31767768e-02f,
  1.66088700e-01f, 2.35634327e-01f, 1.65342361e-01f, -1.84136704e-01f, 6.96207508e-02f, 2.56522223e-02f, -1.20262586e-01f, 7.55185559e-02f, 1.76620275e-01f, 1.01611137e-01f,
  1.65535510e-01f, -5.27249500e-02f, -1.62313625e-01f, -1.54657692e-01f, -6.40140399e-02f, -4.56070062e-03f, -1.83284447e-01f, 6.35061041e-02f, 1.10377043e-01f, 3.08085419e-02f,
  1.95802689e-01f, -5.58532998e-02f, -5.20732962e-02f, -1.79353170e-02f, 3.21179420e-01f, 1.78179592e-01f, 1.01707816e-01f, -1.14015099e-02f, 1.70630053e-01f, 1.30140007e-01f,
  1.53912446e-02f, -1.66626319e-01f, 2.99191214e-02f, -1.06708817e-01f, 5.37247024e-02f, 7.75760179e-03f, -9.92844030e-02f, 1.31661594e-01f, -1.28553107e-01f, -1.47093728e-01f,
  -2.79102683e-01f, -1.13795795e-01f, -2.56132931e-01f, -3.26531604e-02f, 8.34244788e-02f, 3.17948014e-01f, -5.03637232e-02f, 1.24589326e-02f, 2.74189919e-01f, 2.16345057e-01f,
  -1.00970700e-01f, 8.19585994e-02f, -3.62840458e-03f, 6.51329011e-02f, 1.59504071e-01f, -4.66955192e-02f, -2.42354386e-02f, -6.23004287e-02f, 8.90547261e-02f, 8.96928236e-02f,
  7.62433708e-02f, 1.61269739e-01f, 1.92149729e-01f, -3.69696617e-02f, 1.66573837e-01f, -1.32410169e-01f, -3.23742554e-02f, -5.56839295e-02f, -2.12005358e-02f, -1.90891132e-01f,
  -4.38724756e-02f, 1.60351098e-01f, -1.88301690e-02f, -6.67242631e-02f, -1.34202868e-01f, -8.13433975e-02f, -1.19108051e-01f, 1.68124922e-02f, -5.28914519e-02f, 4.48029600e-02f,
  2.35039130e-01f, 3.19524288e-01f, -5.15210927e-02f, 6.84671476e-02f, -4.35771048e-02f, -8.94310847e-02f, 1.98520735e-01f, 5.94784021e-02f, 2.04737589e-01f, -5.29730879e-03f,
  2.43890155e-02f, 6.84756562e-02f, 8.49335045e-02f, -1.20116949e-01f, -6.70330450e-02f, -1.11381702e-01f, 1.45193934e-01f, -6.85971007e-02f, 6.12973981e-02f, -6.28116727e-02f,
  1.40101230e-02f, 1.10801952e-02f, 4.18562889e-02f, -5.60964085e-02f, 5.37716709e-02f, 1.53583082e-04f, 1.53350979e-01f, -3.60049345e-02f, -1.22538181e-02f, -5.87579980e-02f,
  -1.13520533e-01f, 1.31585971e-01f, -9.53849331e-02f, -1.27274645e-02f, -7.64273331e-02f, 5.21932244e-02f, -1.11989900e-01f, 4.67530731e-03f, 8.26740116e-02f, 1.27092540e-01f,
  -9.64435376e-03f, 9.35431123e-02f, 1.19926818e-01f, 1.17989905e-01f, -2.57427305e-01f, 1.20827481e-01f, -4.90365848e-02f, 1.52776033e-01f, 1.82147995e-01f, 1.34901658e-01f,
  2.20280349e-01f, -3.87852006e-02f, -4.80950847e-02f, 3.18929523e-01f, -1.35626942e-01f, 7.29767159e-02f, 3.23285252e-01f, 5.52367009e-02f, 1.20818265e-01f, -2.23947503e-02f,
  -1.06125101e-01f, -6.68306947e-02f, -5.93127944e-02f, 7.04651177e-02f, -1.36463687e-01f, -1.72337547e-01f, 1.30847350e-01f, 4.79132719e-02f, 1.08076051e-01f, 1.75599515e-01f,
  -1.09103449e-01f, 2.20635325e-01f, -1.35894120e-01f, 2.17037201e-01f, 1.33939981e-01f, 4.91359890e-01f, 2.25209475e-01f, 3.82789463e-01f, -9.54004005e-02f, 2.30446771e-01f,
  5.67367896e-02f, -1.67288240e-02f, 3.56090754e-01f, 2.17701048e-01f, -2.09867179e-01f, 3.05409849e-01f, 1.61114678e-01f, -2.51581520e-01f, -6.35104626e-02f, -5.45247383e-02f,
  -2.03533277e-01f, 2.89205983e-02f, 1.36306748e-01f, 2.18884334e-01f, 9.51380935e-03f, -1.37908310e-01f, 4.41202193e-01f, 3.65564764e-01f, 2.56556034e-01f, 1.50712401e-01f,
  -1.16566300e-01f, -1.48304015e-01f, 3.33330482e-01f, -2.05774173e-01f, -3.91155690e-01f, -5.07006329e-03f, -3.10674887e-02f, 3.27319056e-02f, -1.07217804e-01f, 1.39344767e-01f,
  2.81877238e-02f, 2.11913660e-01f, -4.02300730e-02f, 6.83414862e-02f, -9.69901681e-03f, -2.63763722e-02f, -5.46974503e-02f, -1.67993680e-01f, -1.14957623e-01f, -2.31669825e-02f,
  3.23954485e-02f, -3.51533554e-02f, -1.50354996e-01f, 1.48971662e-01f, 1.32269830e-01f, -1.14986777e-01f, -4.23520394e-02f, 8.43151361e-02f, -1.46844178e-01f, -1.82984307e-01f,
  8.99546444e-02f, 1.40864730e-01f, 9.13119912e-02f, 1.40287802e-01f, 2.31575683e-01f, -2.91381776e-02f, -1.57026440e-01f, -6.58219010e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -7.51851723e-02f, -5.50395101e-02f, 1.01957828e-01f, 2.86433776e-03f, -9.41492319e-02f, 1.60385802e-01f, -1.02286808e-01f, 2.86058873e-01f, -3.33699323e-02f, -2.18398478e-02f,
  -1.42505199e-01f, 2.09238991e-01f, 3.48001748e-01f, 7.25122988e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.08197676e-02f, 8.70018378e-02f, -1.17472813e-01f, -2.58930504e-01f, -1.23696454e-01f, -3.98872867e-02f, 1.44759789e-01f, -1.22076996e-01f, -2.01884389e-01f, -2.71289349e-01f,
  -1.40825380e-02f, -1.27177358e-01f, 2.50340015e-01f, -1.39526561e-01f, -2.01298133e-01f, 5.03512025e-02f, -1.53156251e-01f, 2.85179913e-01f, -2.59071011e-02f, -4.71441373e-02f,
  -1.48743048e-01f, -1.59954712e-01f, 4.87816297e-02f, -8.71924162e-02f, 1.49166778e-01f, -2.37498820e-01f, 2.13229477e-01f, 2.36400619e-01f, -8.92625377e-02f, -1.71414286e-01f,
  3.60927463e-01f, -7.69306673e-03f, -4.07128781e-02f, -5.16589135e-02f, -3.47176082e-02f, 1.39209285e-01f, 4.20935405e-03f, -4.03405465e-02f, 1.79833204e-01f, 1.51115544e-02f,
  1.58431649e-01f, -3.39753985e-01f, 2.20506087e-01f, 4.19282705e-01f, 4.82014678e-02f, -1.13603421e-01f, 4.49520685e-02f, -2.43285567e-01f, -7.59916082e-02f, -1.51260957e-01f,
  -1.77614510e-01f, 4.59954217e-02f, 1.60042211e-01f, -1.51903555e-01f, -1.91255957e-02f, -3.21358383e-01f, 1.29154503e-01f, 1.86297745e-01f, 8.27249885e-02f, -4.04598564e-02f,
  1.12916648e-01f, -6.56756088e-02f, 6.43663481e-02f, -1.33004859e-01f, 1.99593097e-01f, 6.25700280e-02f, 1.57188252e-01f, 1.47123024e-01f, -1.34762451e-01f, 1.50756612e-01f,
  1.44756958e-01f, 2.20244542e-01f, 7.62617439e-02f, -4.37969118e-01f, 1.51940845e-02f, 3.21906060e-01f, -6.17798530e-02f, -3.80830467e-01f, 1.64779678e-01f, -8.06265995e-02f,
  -1.77626908e-01f, -1.73647061e-01f, -1.38307720e-01f, 1.61605954e-01f, -5.38978875e-02f, -6.65117577e-02f, 1.86183378e-01f, -2.25617021e-01f, 9.86321867e-02f, -6.05492629e-02f,
  6.42843312e-03f, 5.13658039e-02f, -1.46502042e-02f, -2.38497347e-01f, 1.29682422e-01f, -7.24721029e-02f, 2.23228000e-02f, 7.10187256e-02f, 1.42934874e-01f, -1.27738282e-01f,
  6.11481853e-02f, 2.12632358e-01f, 1.94331184e-01f, 1.02651477e-01f, -9.17092934e-02f, -5.95755577e-02f, 5.15461303e-02f, -1.74803600e-01f, 3.06608856e-01f, -1.16870236e-02f,
  -1.73557252e-01f, 2.35716343e-01f, 4.60396670e-02f, 2.33566284e-01f, 2.35802621e-01f, 5.90852601e-03f, 4.82037803e-03f, -1.07740887e-01f, -7.04072341e-02f, -6.51203678e-04f,
  -1.02367520e-01f, -2.20582057e-02f, -1.21735528e-01f, 1.83274314e-01f, 5.73602319e-02f, -1.75184041e-01f, 9.30479914e-02f, 1.26584262e-01f, 1.92035317e-01f, -8.71989056e-02f,
  -7.60873035e-02f, -1.44213289e-02f, -2.39553884e-01f, 1.15767084e-01f, -1.63813844e-01f, 7.63482749e-02f, -1.63364381e-01f, -3.62537265e-01f, 2.21296728e-01f, 1.52316585e-01f,
  2.63874650e-01f, -2.79189050e-01f, -5.56348860e-02f, 7.50404447e-02f, 1.39200594e-02f, 1.58394784e-01f, -1.48650452e-01f, -1.49773434e-01f, -5.19691147e-02f, -2.81835020e-01f,
  9.51947719e-02f, -8.61404836e-02f, 1.29644364e-01f, -6.07176423e-02f, 2.21743330e-01f, -5.97926229e-03f, 1.27544612e-01f, 6.23007165e-03f, 2.35883668e-01f, 3.13353650e-02f,
  -1.02991119e-01f, -5.93505464e-02f, 4.70930636e-02f, -1.75464869e-01f, -1.21405073e-01f, 4.32608798e-02f, 1.89235032e-01f, 2.48719081e-02f, -1.72939911e-01f, -4.96549197e-02f,
  -2.12907102e-02f, 2.04958841e-01f, 2.24864230e-01f, -2.39446372e-01f, 7.01523870e-02f, -2.70780742e-01f, -1.60279617e-01f, -4.76970151e-02f, -1.67059794e-01f, 1.76721081e-01f,
  -1.15125291e-01f, -2.32178286e-01f, -6.72690272e-02f, -6.92468435e-02f, 1.09140754e-01f, -1.70207217e-01f, 7.07492158e-02f, 1.37867585e-01f, 2.72092223e-02f, -2.15136230e-01f,
  1.60125896e-01f, -1.50426075e-01f, -9.97503921e-02f, 8.88698474e-02f, 1.82466537e-01f, 8.03037807e-02f, 2.89995402e-01f, -1.97386593e-01f, -6.88229352e-02f, 1.53288096e-01f,
  2.23912410e-02f, 4.13596146e-02f, -2.31012240e-01f, -2.59988338e-01f, 4.48226817e-02f, 3.69485140e-01f, -1.20458066e-01f, 9.91220325e-02f, -2.33335331e-01f, -8.12921971e-02f,
  -2.59324741e-02f, -6.25531226e-02f, 1.72787279e-01f, 2.99894035e-01f, 8.11732709e-02f, 2.96488106e-01f, 2.37590838e-02f, -1.59572735e-02f, 4.29720804e-02f, 1.06985696e-01f,
  -4.36962284e-02f, -7.35212341e-02f, -5.05135134e-02f, -4.87230830e-02f, 2.28199407e-01f, 1.88100204e-01f, -1.82917699e-01f, 1.20609216e-01f, 1.01157902e-02f, 1.46369517e-01f,
  1.69646144e-01f, 1.96798772e-01f, 1.39259463e-02f, -3.72105181e-01f, 2.95819074e-01f, 2.54323900e-01f, 2.02356782e-02f, -2.60364443e-01f, 1.48962745e-02f, -1.23460315e-01f,
  3.20307836e-02f, -1.71781659e-01f, 9.83916745e-02f, 6.22207485e-02f, -1.07840076e-01f, -1.57353282e-01f, -9.76146087e-02f, -8.32281113e-02f, 9.42863226e-02f, -9.90539417e-02f,
  -2.58630863e-03f, 9.50424969e-02f, -1.65988579e-01f, -5.70047200e-02f, 4.50557657e-02f, -6.59348890e-02f, 5.95787056e-02f, 1.72606483e-01f, 1.70185015e-01f, 2.73742884e-01f,
  -8.33732039e-02f, -5.81402853e-02f, 2.36133486e-01f, 2.70562053e-01f, 2.63580680e-01f, 3.06472003e-01f, 2.57711280e-02f, 2.68456936e-02f, -1.32295683e-01f, -1.47739410e-01f,
  2.54038453e-01f, 1.19971596e-01f, 2.12507486e-01f, -4.62617874e-02f, -1.75894096e-01f, 1.22348569e-01f, -1.38568893e-01f, -2.72847275e-04f, -1.58662349e-01f, 2.54831314e-01f,
  4.32139635e-02f, 2.13043392e-01f, 4.94631752e-02f, -1.34287119e-01f, -1.06470184e-02f, 1.88861847e-01f, -3.06129009e-01f, -1.92517973e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.68287426e-01f, 2.74331242e-01f, 2.04353202e-02f, 5.43915145e-02f, -1.19583178e-02f, 6.75681904e-02f, 2.60389149e-01f, 3.16733032e-01f, 1.41541973e-01f, -4.67080742e-01f,
  2.35773146e-01f, 1.16789348e-01f, -2.30481662e-02f, -5.59359044e-02f, 1.32682651e-01f, -6.32283241e-02f, 5.75092025e-02f, 8.84874091e-02f, 3.68297845e-02f, 1.31628782e-01f,
  1.30542830e-01f, -1.24219753e-01f, -6.17212169e-02f, -2.59667248e-01f, 7.93039501e-02f, 1.14061579e-01f, 1.23874001e-01f, 8.54813382e-02f, 1.64270103e-02f, -3.17065299e-01f,
  7.61287212e-02f, -1.77715316e-01f, 3.55674684e-01f, 3.06510329e-02f, 8.81984532e-02f, -8.89289603e-02f, 4.73786332e-02f, 3.48740995e-01f, 1.53205305e-01f, 5.26050590e-02f,
  1.04209110e-01f, -5.33389114e-02f, 6.61526620e-02f, -2.30455980e-01f, 1.93972200e-01f, -3.01758558e-01f, -6.53423145e-02f, 5.10618210e-01f, -1.22657970e-01f, 3.34192246e-01f,
  2.61799902e-01f, -4.56706844e-02f, 4.63050567e-02f, -2.60105044e-01f, 4.15856451e-01f, 5.30798674e-01f, 1.40461445e-01f, -2.42047265e-01f, -7.70707652e-02f, -1.66606337e-01f,
  2.22741789e-03f, 4.74145636e-02f, 5.60566902e-01f, 1.89442292e-01f, 2.59227276e-01f, 1.86809167e-01f, 1.44227311e-01f, 3.15414101e-01f, -9.00922641e-02f, 2.15730995e-01f,
  2.28216708e-01f, 1.62708849e-01f, 3.58721286e-01f, -3.16811323e-01f, 2.31115237e-01f, 4.63900208e-01f, -3.58893722e-02f, -3.02472204e-01f, 2.38034412e-01f, -2.30890691e-01f,
  -7.57294446e-02f, 6.38871789e-02f, -2.23053191e-02f, -8.81018862e-02f, 2.25807101e-01f, -5.40889166e-02f, -1.59133300e-01f, -2.11074397e-01f, 4.41327691e-02f, -1.44140711e-02f,
  3.25808853e-01f, -6.20585009e-02f, -1.52003840e-01f, -6.30593672e-02f, 3.58377784e-01f, -7.27001429e-02f, 6.75669238e-02f, 1.72928050e-01f, -7.99674913e-03f, 1.43995166e-01f,
  2.61661530e-01f, -2.03613892e-01f, -3.96238267e-02f, 1.25911593e-01f, -2.61359140e-02f, 2.20373273e-02f, -1.38207346e-01f, 3.76740843e-02f, -3.60002011e-01f, 3.41619760e-01f,
  5.59993200e-02f, -3.45094085e-01f, -1.29216120e-01f, 2.18324102e-02f, 9.93385911e-02f, 7.83630908e-02f, 2.00485379e-01f, 3.53560090e-01f, -5.86168468e-02f, 1.39284879e-01f,
  1.35642096e-01f, 3.32880884e-01f, 1.56130910e-01f, 2.90986925e-01f, 1.53047726e-01f, -4.20555472e-02f, -2.98076481e-01f, 1.73858464e-01f, -1.40154576e-02f, 3.88207734e-01f,
  1.65418163e-01f, 3.25636595e-01f, 4.72468995e-02f, -2.36134566e-02f, 1.63875446e-01f, 4.22746986e-01f, 4.15007740e-01f, -5.65180182e-02f, 1.45487115e-01f, 2.99489886e-01f,
  -1.54150993e-01f, -9.95743275e-03f, 3.42808425e-01f, -2.52188712e-01f, 2.15885162e-01f, -2.71584988e-01f, -1.91919971e-02f, -1.49708048e-01f, 7.80493841e-02f, 2.97663003e-01f,
  -1.20932326e-01f, -9.72332899e-03f, 1.40772648e-02f, 1.99698821e-01f, 1.68228462e-01f, 6.02082685e-02f, -9.14623812e-02f, 1.34913072e-01f, 1.25212343e-02f, -8.73591825e-02f,
  3.73301469e-03f, 2.99682736e-01f, 1.90322753e-02f, 3.06304067e-01f, 1.34302109e-01f, 7.28085786e-02f, 1.10776804e-01f, 1.35255009e-01f, 5.70334941e-02f, -2.76787467e-02f,
  -4.18545455e-02f, 1.35514349e-01f, 1.50001571e-01f, -2.29961723e-01f, 1.28212422e-02f, 3.74546833e-02f, 2.02908665e-01f, -5.21797575e-02f, -9.88896787e-02f, 5.96985631e-02f,
  -1.41222313e-01f, -1.84603091e-02f, 3.87324058e-02f, -1.28557816e-01f, -1.66020930e-01f, 1.46242902e-01f, 3.72791961e-02f, -9.32904035e-02f, -6.59970120e-02f, -2.81539187e-02f,
  1.75299242e-01f, 9.23276842e-02f, 1.41711444e-01f, 2.24299043e-01f, 5.86219225e-03f, -1.45411462e-01f, 1.99650019e-01f, 1.07829250e-01f, 1.03489958e-01f, 1.96219212e-03f,
  1.74731985e-01f, 4.30139095e-01f, -1.68340147e-01f, -2.60209322e-01f, 1.28552690e-01f, -7.19676018e-02f, 8.57610852e-02f, -2.91448217e-02f, -2.21597344e-01f, 8.03146586e-02f,
  -7.90489241e-02f, -1.00276016e-01f, 1.49158746e-01f, 2.71264046e-01f, 2.83173084e-01f, 4.20110106e-01f, 1.77811861e-01f, 1.06697492e-01f, -2.34963875e-02f, -6.08262159e-02f,
  7.95064569e-02f, 1.66502133e-01f, 3.11623067e-01f, -6.29398301e-02f, -6.60394952e-02f, 5.63706383e-02f, 3.60298641e-02f, -8.14192519e-02f, -1.84880733e-01f, 8.03166777e-02f,
  -3.99354324e-02f, -7.79238865e-02f, 6.94624428e-03f, 1.52499422e-01f, 6.26134798e-02f, 8.50480273e-02f, -8.57972950e-02f, -1.26159504e-01f, 1.01270184e-01f, 8.71488154e-02f,
  8.97347778e-02f, -5.17660715e-02f, -1.05033414e-02f, -6.42009154e-02f, 4.02988419e-02f, -1.69774294e-01f, 4.72205132e-02f, 1.47907184e-02f, 1.66134536e-02f, 1.26992300e-01f,
  1.37948692e-02f, 7.66877830e-02f, 1.03585072e-01f, 1.46720529e-01f, 1.08665623e-01f, -1.72094315e-01f, 1.35096477e-03f, -1.26315191e-01f, -5.39085232e-02f, -1.20783091e-01f,
  2.97526494e-02f, 9.83040556e-02f, 9.56374332e-02f, 1.34472877e-01f, 1.24131158e-01f, 1.15868948e-01f, -1.96718290e-01f, -1.66424960e-01f, 1.84566930e-01f, 6.06584437e-02f,
  6.16087466e-02f, -1.01083154e-02f, 1.30303472e-01f, 3.46055925e-02f, 7.03821555e-02f, -5.04099540e-02f, -1.08197168e-01f, 2.46182323e-01f, 2.50788420e-01f, 5.67884505e-01f,
  1.42694935e-01f, 1.94919065e-01f, -1.41041130e-01f, -4.48223837e-02f, -1.86806507e-02f, 1.85987383e-01f, 2.95653850e-01f, 1.66902337e-02f, -1.21235244e-01f, 9.85745108e-04f,
  -1.62792146e-01f, -2.66867336e-02f, 8.86610821e-02f, -5.74608929e-02f, -2.17010066e-01f, 3.32499389e-03f, 2.10458003e-02f, 1.32583976e-01f, -9.88972783e-02f, -1.05447806e-01f,
  1.35782316e-01f, 1.02257945e-01f, -1.44386649e-01f, 2.08292007e-01f, -1.16689932e-02f, -9.80974808e-02f, 1.25248507e-01f, -3.70077416e-02f, -3.93465534e-02f, 4.34986278e-02f,
  1.01985961e-01f, 4.23546135e-03f, 1.76620498e-01f, 4.67377976e-02f, 7.65698478e-02f, 1.44685090e-01f, 1.70137316e-01f, -1.32777952e-02f, 5.07140346e-02f, -2.34890189e-02f,
  8.27280357e-02f, 2.76652366e-01f, 9.90786254e-02f, 1.38011634e-01f, -6.20831922e-02f, -1.14796042e-01f, 2.27713153e-01f, 2.41484538e-01f, 2.52517432e-01f, 1.41465575e-01f,
  1.83382154e-01f, 2.87663728e-01f, -1.62713647e-01f, -3.76134783e-01f, 3.44169065e-02f, -3.08224648e-01f, 3.28257717e-02f, -9.62237790e-02f, -1.38027698e-01f, 5.39231636e-02f,
  8.78608041e-03f, -9.37988311e-02f, -6.61722049e-02f, 2.56236345e-01f, 1.00916758e-01f, 1.28976345e-01f, 5.14196791e-02f, -2.66912669e-01f, 1.47604747e-02f, 2.86407143e-01f,
  -7.55476132e-02f, 1.59197077e-01f, 3.29250582e-02f, -7.02841505e-02f, 4.39071395e-02f, -8.40521883e-03f, -6.12719264e-03f, -2.94349212e-02f, -1.22491345e-01f, 1.85796604e-01f,
  -9.47770923e-02f, 1.10165449e-02f, -6.55751750e-02f, -1.00771926e-01f, 1.63447931e-01f, 3.94199379e-02f, 8.76057968e-02f, 2.79077202e-01f, -6.47557946e-03f, 4.07089107e-02f,
  1.05027124e-01f, 1.57047972e-01f, 3.71668935e-02f, -1.46400332e-01f, 1.69864386e-01f, 2.30544657e-01f, 2.04695892e-02f, 1.12919807e-02f, -7.35730156e-02f, -4.85850014e-02f,
  1.80134669e-01f, 1.50653109e-01f, 2.89065599e-01f, -2.62609310e-02f, 4.02980655e-01f, 1.88983262e-01f, 2.42417589e-01f, -8.79350379e-02f, 6.66393712e-02f, 1.46603271e-01f,
  3.04069161e-01f, 1.64339855e-01f, 9.33501944e-02f, -3.93039733e-01f, 4.24256735e-02f, 3.92191619e-01f, 4.59637940e-01f, -5.94020247e-01f, 5.08892797e-02f, -1.18339546e-01f,
  -1.28976330e-01f, 2.12715328e-01f, -1.58751860e-01f, -9.25464332e-02f, 2.34418083e-02f, -3.99625391e-01f, 2.89900541e-01f, -1.92495242e-01f, 9.29671153e-02f, 2.14063507e-02f,
  3.91295254e-01f, 1.12919450e-01f, 1.14557691e-01f, 4.63004299e-02f, 7.27812111e-01f, -9.56844613e-02f, -1.66994780e-01f, -1.52764171e-01f, -1.53756738e-01f, 9.40227509e-03f,
  -1.08512402e-01f, 1.35789722e-01f, -2.02298556e-02f, 7.73593038e-02f, -2.53854915e-02f, -1.00857601e-01f, 7.66312405e-02f, -6.19857125e-02f, 1.33470997e-01f, 2.47949809e-02f,
  -7.98437861e-04f, -1.79337680e-01f, -1.47784621e-01f, 1.16707765e-01f, 7.31548592e-02f, -2.50663850e-02f, 1.15545630e-01f, -2.00403169e-01f, 2.02695727e-01f, -1.82898805e-01f,
  -1.13088444e-01f, 2.32098764e-03f, 1.70950890e-01f, 2.25157514e-01f, -1.51477143e-01f, -1.51206970e-01f, 2.59711981e-01f, 8.60066190e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.43670052e-01f, 1.07558884e-01f, 3.72938663e-01f, 1.11602016e-01f, 2.09383160e-01f, -1.05486577e-02f, 9.23965052e-02f, 1.04606792e-01f, 1.02997556e-01f, 5.96029088e-02f,
  2.23258436e-01f, 1.87154621e-01f, 2.76672125e-01f, 1.33276954e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.09131736e-01f, -2.58995801e-01f, 6.91940710e-02f, -1.32351547e-01f, 1.87277779e-01f, 2.09046900e-01f, -1.34239569e-01f, -1.00289643e-01f, 3.12562808e-02f, 4.65825982e-02f,
  -2.45310575e-01f, -1.24911748e-01f, 1.41085699e-01f, -5.99536449e-02f, -3.13971117e-02f, 1.23570509e-01f, 5.35184667e-02f, 2.54112810e-01f, -1.12987436e-01f, 1.69481248e-01f,
  1.61218029e-02f, -2.33384311e-01f, -1.34584412e-01f, 4.66581061e-02f, 6.50090799e-02f, 1.22230276e-01f, -2.42715180e-02f, -7.18128607e-02f, 9.78520289e-02f, -2.16912162e-02f,
  -1.00258633e-01f, -2.35817477e-01f, -2.12071881e-01f, -2.55605560e-02f, -6.15103655e-02f, -2.77396858e-01f, -4.54112813e-02f, 4.29455843e-03f, -7.25793317e-02f, 1.23366617e-01f,
  2.80557185e-01f, 2.93076009e-01f, 8.55452120e-02f, 2.06808653e-02f, -3.34389284e-02f, 2.09478050e-01f, 2.35983625e-01f, 2.23014727e-01f, -1.75066248e-01f, -3.04862440e-01f,
  -2.94528663e-01f, 1.91420749e-01f, -1.47218257e-01f, -2.07679614e-01f, -2.69523889e-01f, -1.38121456e-01f, 4.70144339e-02f, 1.27205938e-01f, -2.69539468e-02f, 1.58368096e-01f,
  -2.64064819e-01f, -1.33793801e-01f, 2.04678684e-01f, 2.06424326e-01f, 1.76588491e-01f, -1.79436937e-01f, 7.17548281e-02f, 1.97782025e-01f, 9.88275856e-02f, -4.20518592e-02f,
  -8.29328373e-02f, 1.20561436e-01f, -1.37444824e-01f, -1.31984413e-01f, 2.31095403e-03f, -5.97869838e-03f, -1.91679552e-01f, -3.86101246e-01f, -1.95774168e-01f, 1.74182028e-01f,
  -4.21948545e-02f, 2.79748499e-01f, -6.46642223e-02f, -2.35131741e-01f, -3.66206728e-02f, 3.40479255e-01f, 2.54064739e-01f, 1.23761512e-01f, -3.05493250e-02f, -1.14536561e-01f,
  -3.86829115e-02f, 1.75404891e-01f, -2.97983433e-03f, -8.78466442e-02f, -3.21261585e-01f, -1.15382813e-01f, 1.74387380e-01f, -3.13326865e-02f, -1.79499015e-01f, 1.97798554e-02f,
  -1.56981468e-01f, 1.01983175e-01f, 2.48853907e-01f, -3.11741792e-02f, -4.42548059e-02f, 2.12383494e-01f, -7.78224170e-02f, 2.07298562e-01f, 2.19156772e-01f, 3.66780996e-01f,
  1.30408198e-01f, -1.84070706e-01f, 6.29297271e-02f, 7.14339614e-02f, 2.16831446e-01f, 2.28408650e-01f, 2.21785352e-01f, -2.43360683e-01f, -1.47373572e-01f, 1.62933365e-01f,
  -1.84309497e-01f, 1.57344803e-01f, -1.60384715e-01f, 7.89210424e-02f, -7.57119134e-02f, -8.97364691e-02f, 2.53186196e-01f, 1.39555767e-01f, 3.99554260e-02f, -1.78362742e-01f,
  -2.31483594e-01f, -3.27642083e-01f, -5.89730702e-02f, -1.20261855e-01f, 6.29727077e-03f, -1.05875209e-01f, 1.92569748e-01f, 2.98167646e-01f, -7.85653144e-02f, 5.04128495e-03f,
  2.93960035e-01f, 1.68242231e-01f, 5.26196808e-02f, -1.19250819e-01f, 9.20855626e-02f, -3.18614751e-01f, -8.86375532e-02f, 3.01715225e-01f, 2.56327037e-02f, -1.52672455e-01f,
  -2.75368303e-01f, 7.77869970e-02f, 5.89091294e-02f, -6.70120269e-02f, -6.43679053e-02f, 1.03503801e-01f, -2.51987547e-01f, 1.65668592e-01f, 3.24330062e-01f, -3.67348790e-02f,
  1.37263030e-01f, -1.29692480e-01f, -1.24994725e-01f, 1.38204023e-01f, 2.02743754e-01f, -3.81882116e-02f, -9.30502862e-02f, -2.38165960e-01f, 3.58654633e-02f, -3.54385912e-01f,
  1.11043207e-01f, -2.06443802e-01f, -1.86074927e-01f, -4.47435915e-01f, -5.64040467e-02f, 8.69091600e-02f, -2.02366143e-01f, 3.86744626e-02f, -2.56073158e-02f, -3.43016982e-01f,
  7.77075812e-02f, 3.66393119e-01f, 2.69989163e-01f, 1.24633588e-01f, 3.31872068e-02f, 5.23847044e-02f, 8.39811116e-02f, 1.37970969e-01f, -5.65045848e-02f, 5.13411947e-02f,
  -4.11637187e-01f, -3.45817395e-02f, -1.74174979e-01f, 1.38397858e-01f, 7.97872990e-03f, 2.05829933e-01f, -6.01332560e-02f, -1.06459260e-01f, -6.71329051e-02f, 2.38491986e-02f,
  -1.86258405e-01f, -3.80548239e-01f, -2.70212114e-01f, 2.85237376e-02f, -1.73203036e-01f, -2.44312242e-01f, -8.45705047e-02f, 2.43083954e-01f, -2.73355693e-01f, 7.85443112e-02f,
  1.03870519e-01f, -2.92030245e-01f, -8.28590244e-02f, 4.01022166e-01f, 1.64585672e-02f, 4.74903658e-02f, -9.44463722e-03f, 1.18139144e-02f, -5.64686134e-02f, 7.35251755e-02f,
  -8.62046797e-03f, -1.31415859e-01f, -2.27328718e-01f, -1.12779677e-01f, -1.09993137e-01f, -1.03354037e-01f, -7.49265254e-02f, 3.30309756e-02f, -1.79005295e-01f, 8.65544528e-02f,
  7.12821037e-02f, 1.93017237e-02f, 7.59224892e-02f, 1.82241216e-01f, 2.24374518e-01f, -3.67161026e-03f, -2.81260293e-02f, 1.77659512e-01f, 1.76932216e-01f, -9.60476026e-02f,
  1.93732545e-01f, -3.06792706e-01f, 6.48783445e-02f, 4.66600023e-02f, 1.58770368e-01f, 4.51378450e-02f, -2.66710341e-01f, -1.19643398e-01f, 4.41635139e-02f, 5.25163524e-02f,
  -2.19365358e-01f, 6.33164570e-02f, -9.54924673e-02f, -3.58982719e-02f, 3.17813605e-01f, 1.54424429e-01f, 2.20001355e-01f, 2.68572271e-02f, 2.36786634e-01f, 1.65505800e-02f,
  1.03229485e-01f, 7.42895901e-02f, -3.36803310e-02f, 2.80167580e-01f, 1.15124367e-01f, -5.07438667e-02f, -3.42417330e-01f, -3.91472667e-01f, 2.13973641e-01f, 5.44004515e-02f,
  -3.49807017e-03f, 1.26150101e-01f, -2.23912075e-01f, -7.82359466e-02f, -2.17483282e-01f, 2.80585438e-01f, -1.84683055e-02f, -1.79295436e-01f, -2.06429914e-01f, 4.40392904e-02f,
  1.18620448e-01f, -1.21353783e-01f, 1.51358634e-01f, 1.22994088e-01f, -9.04395655e-02f, 7.78753012e-02f, -1.46571472e-01f, -1.37111589e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.17167642e-02f, -3.05407137e-01f, -1.24693274e-01f, -9.42043662e-02f, -1.99225962e-01f, -2.01069817e-01f, -3.51943225e-01f, 9.73649547e-02f, 2.34352291e-01f, -1.09651975e-01f,
  -1.81241155e-01f, -3.37199658e-01f, -1.67454837e-03f, -1.90405443e-01f, -1.84773117e-01f, 1.92652166e-01f, -3.60917032e-01f, 1.26974612e-01f, -1.34348154e-01f, 6.90703541e-02f,
  -2.34950066e-01f, 2.78336048e-01f, -1.81107875e-02f, -2.12571591e-01f, 1.32096335e-01f, -5.73692359e-02f, 3.27803612e-01f, 1.13482662e-01f, -8.89615342e-03f, 6.44121990e-02f,
  -3.04379046e-01f, -5.40149510e-02f, -2.79183686e-01f, -1.67027533e-01f, -1.24307320e-01f, -1.03659503e-01f, -7.57767260e-02f, -1.03377797e-01f, -2.47637883e-01f, -4.04104181e-02f,
  2.00423878e-02f, 2.24428941e-02f, -1.24050654e-01f, -1.40573695e-01f, 1.35511801e-01f, -2.38974635e-02f, 2.14354038e-01f, -5.55338375e-02f, -6.93436936e-02f, -1.41602263e-01f,
  8.74104425e-02f, 1.81230068e-01f, -1.22679681e-01f, 9.70242545e-02f, -2.86072027e-02f, -2.88661234e-02f, 1.69659019e-01f, -1.64875403e-01f, -5.78887425e-02f, -5.61233144e-03f,
  -2.77452767e-01f, 1.38212264e-01f, 2.97727495e-01f, 3.02587539e-01f, 4.92346063e-02f, 3.62666696e-02f, 4.09160331e-02f, 4.24959809e-02f, 9.10989344e-02f, 1.02225512e-01f,
  -2.26497322e-01f, 2.03970969e-01f, 2.30765149e-01f, 3.46623927e-01f, -2.85206050e-01f, -2.98497796e-01f, 3.46995503e-01f, 1.87192895e-02f, 1.21742509e-01f, 2.66032904e-01f,
  -3.79508406e-01f, -1.11803174e-01f, 1.77667718e-02f, 2.50668347e-01f, -9.54503268e-02f, 1.51071686e-03f, -2.17001259e-01f, -5.52508198e-02f, 4.41050202e-01f, 6.23681322e-02f,
  3.34815681e-01f, 5.18487468e-02f, -2.82924414e-01f, 2.49181211e-01f, 3.03958088e-01f, 3.47560421e-02f, -2.48813350e-03f, -3.34224515e-02f, 1.45589322e-01f, -4.13068123e-02f,
  8.53553787e-03f, 6.60932139e-02f, -1.10763550e-01f, -1.43821850e-01f, -9.55816582e-02f, 8.34482834e-02f, 6.97726533e-02f, -4.86143753e-02f, -1.00286908e-01f, 1.58431716e-02f,
  -9.29645896e-02f, -8.33520368e-02f, 8.46661553e-02f, 1.28921699e-02f, 1.98375918e-02f, -4.00755964e-02f, -5.19866496e-02f, -3.72665152e-02f, 5.13438089e-03f, 7.97531158e-02f,
  -2.77569164e-02f, 1.76383987e-01f, -1.68819517e-01f, 1.21320888e-01f, 7.24097788e-02f, 1.19506821e-01f, -1.39233038e-01f, -8.49866644e-02f, 2.63027668e-01f, 3.76373142e-01f,
  6.25054836e-01f, 2.42494285e-01f, 4.65195715e-01f, 1.91428393e-01f, -1.75739080e-02f, 5.51004231e-01f, -1.56665578e-01f, 1.56792682e-02f, -5.76777756e-01f, -2.15439443e-02f,
  2.35554621e-01f, 1.43328384e-01f, -2.74463505e-01f, 3.71786773e-01f, -1.73998460e-01f, 4.75670129e-01f, -3.82390827e-01f, 9.32376921e-01f, -3.91569495e-01f, -1.11952931e-01f,
  8.07046816e-02f, 6.12321310e-02f, 5.72461605e-01f, 6.42409995e-02f, 5.97657442e-01f, -8.82960781e-02f, 2.71971166e-01f, 4.40597534e-01f, 3.25007260e-01f, -1.82644218e-01f,
  5.56799173e-02f, -9.34190601e-02f, 1.48930416e-01f, -7.64750019e-02f, -5.01456484e-02f, -1.13914125e-01f, -9.74119678e-02f, 1.54848592e-02f, 7.54991546e-02f, -1.33230284e-01f,
  1.08851984e-01f, -7.15870559e-02f, 8.04167613e-02f, 1.00379862e-01f, 1.21871881e-01f, -1.80638701e-01f, 4.21486199e-02f, -2.22266167e-02f, -1.05986468e-01f, -6.79825097e-02f,
  4.19512242e-02f, 4.21858318e-02f, -1.29790843e-01f, 4.00594287e-02f, -8.16094726e-02f, -1.11223102e-01f, 1.65571600e-01f, -1.70775905e-01f, 1.21828407e-01f, 1.03069358e-01f,
  -3.64005491e-02f, 7.31147900e-02f, 4.79566753e-02f, 2.02928022e-01f, -3.07655726e-02f, 6.25859722e-02f, 2.41140187e-01f, 2.01640084e-01f, 2.22463608e-01f, 8.49662274e-02f,
  2.43930355e-01f, 1.50438115e-01f, 1.37135386e-01f, 2.93989092e-01f, 2.64415056e-01f, 1.43945947e-01f, -2.45097443e-01f, 3.00036311e-01f, 2.24066481e-01f, -1.84959043e-02f,
  4.94830132e-01f, 2.69350231e-01f, 1.87364981e-01f, 1.84783220e-01f, 2.60895729e-01f, 1.36252329e-01f, -1.16235629e-01f, -1.72187060e-01f, -1.68361351e-01f, 1.51795313e-01f,
  -1.57659337e-01f, -7.06529170e-02f, 2.56100416e-01f, -1.50166139e-01f, -3.79190333e-02f, 6.84603527e-02f, -6.20486066e-02f, 1.60434157e-01f, 6.53234124e-02f, -2.36262958e-02f,
  1.88836479e-03f, -5.59834614e-02f, -9.28661972e-02f, 1.60968244e-01f, -6.95103332e-02f, 4.11455594e-02f, -1.37063727e-01f, 1.16172455e-01f, -9.02722999e-02f, 8.98352340e-02f,
  1.18893042e-01f, -1.07436515e-02f, -1.14628235e-02f, -1.35515779e-01f, -1.70553952e-01f, -1.56182930e-01f, 9.01559070e-02f, 1.72652364e-01f, -1.65302336e-01f, 7.68985227e-02f,
  -4.38874848e-02f, -7.44546577e-02f, -6.10697977e-02f, 1.04421452e-01f, -1.27548143e-01f, -5.95267713e-02f, -2.76490264e-02f, -2.78884023e-01f, -1.07470565e-02f, 1.33002907e-01f,
  -1.60368215e-02f, -5.09966947e-02f, -2.54623026e-01f, -3.02363597e-02f, 1.33359451e-02f, -2.82577202e-02f, 5.66125177e-02f, -2.72019774e-01f, 1.01191722e-01f, 5.05590886e-02f,
  -2.04701573e-01f, -9.23040584e-02f, 3.52889001e-02f, -5.28904386e-02f, 7.75766224e-02f, 7.12508634e-02f, -2.19422445e-01f, -1.91357285e-02f, -9.61316526e-02f, 5.47290519e-02f,
  8.79471898e-02f, -1.15272574e-01f, 1.23213574e-01f, -1.54899769e-02f, -4.41398695e-02f, 2.32968718e-01f, 4.32242043e-02f, -1.26878753e-01f, -1.80639297e-01f, -1.62790179e-01f,
  6.72043264e-02f, -1.21715583e-01f, 1.01450182e-01f, -1.49459764e-01f, 1.28620435e-02f, 1.17361709e-01f, -5.46029359e-02f, -1.34034485e-01f, -5.47584482e-02f, -1.45765081e-01f,
  -9.05533656e-02f, -6.50731400e-02f, 1.64741918e-01f, -1.45319566e-01f, 9.83935073e-02f, -1.81337800e-02f, 1.52428433e-01f, 7.92098939e-02f, -7.20166564e-02f, 4.26662639e-02f,
  -1.27172889e-02f, -1.27382085e-01f, -1.14989512e-01f, 1.38219997e-01f, -1.46758312e-03f, 1.25068678e-02f, 6.10080883e-02f, 4.92004566e-02f, 5.72922118e-02f, -8.95389616e-02f,
  -4.03110422e-02f, -4.91124718e-03f, 2.73599595e-01f, 3.79691452e-01f, 3.48742634e-01f, 5.51781133e-02f, 3.16543989e-02f, 2.46626899e-01f, 1.00546747e-01f, -1.45390242e-01f,
  -9.94571075e-02f, -1.48464506e-02f, 9.00764763e-02f, -6.00423664e-02f, 1.95062961e-02f, 3.87781769e-01f, -7.51696005e-02f, 1.24916770e-01f, -1.30814995e-04f, 9.43053514e-03f,
  -3.25288326e-02f, 3.48485976e-01f, 3.24765533e-01f, 1.09898925e-01f, 1.47326872e-01f, -8.95133689e-02f, -1.62275173e-02f, -4.99267168e-02f, -1.45728230e-01f, -1.56701356e-01f,
  -6.58701956e-02f, 8.38947296e-02f, 1.07084453e-01f, 2.66408622e-01f, -9.69770998e-02f, 3.70853931e-01f, 6.47340864e-02f, 2.85803556e-01f, 5.90187252e-01f, 1.35019183e-01f,
  2.40197390e-01f, 1.40953436e-01f, 5.48014939e-01f, 6.27024412e-01f, 1.14525072e-01f, 2.59367526e-01f, 3.67204130e-01f, -2.61109829e-01f, 5.71825922e-01f, 2.15146929e-01f,
  4.97929364e-01f, 1.56001553e-01f, 9.94465351e-01f, -1.82898670e-01f, 5.41864634e-01f, 4.31247115e-01f, -1.12363420e-01f, 1.08005598e-01f, -1.60363466e-01f, -6.82804734e-02f,
  5.20258844e-01f, 1.86452419e-02f, 1.13360631e+00f, 8.13607424e-02f, -1.43238949e-02f, -1.16047561e-01f, 1.10279582e-01f, -7.03899562e-02f, -1.03689492e-01f, 1.77725092e-01f,
  1.68605298e-01f, 1.30806133e-01f, 3.05152778e-03f, -8.93345401e-02f, 1.05893910e-01f, -1.16521850e-01f, 4.68262918e-02f, 3.63132060e-02f, -5.62735535e-02f, -5.23676425e-02f,
  9.25335139e-02f, -1.53788745e-01f, -6.69429675e-02f, -1.59534648e-01f, 1.44482493e-01f, 1.68772489e-01f, 4.55518030e-02f, 1.54949918e-01f, 4.95333923e-03f, -4.01246510e-02f,
  -3.10089998e-02f, 6.40220419e-02f, -1.12663686e-01f, 8.16915631e-02f, -1.37578562e-01f, 7.17360079e-02f, 8.31367150e-02f, 4.80157256e-01f, 4.71377760e-01f, 4.82930005e-01f,
  3.40715274e-02f, 3.95983279e-01f, -8.63314196e-02f, 2.91875333e-01f, -2.73569793e-01f, -6.02156937e-01f, -7.96579495e-02f, -5.78270704e-02f, -1.43350422e-01f, -4.86710012e-01f,
  -1.32709086e-01f, 1.59600869e-01f, -1.93408914e-02f, 3.44116807e-01f, -1.90541759e-01f, -3.35190386e-01f, 1.82330236e-01f, 3.06692868e-01f, 5.01667738e-01f, 5.06415255e-02f,
  5.11041522e-01f, -2.35693548e-02f, 1.40266523e-01f, -2.46513918e-01f, 5.11505902e-01f, -2.20766645e-02f, -1.11469649e-01f, -2.05500111e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -8.18077996e-02f, 6.63928986e-02f, 2.07464248e-01f, -8.28425437e-02f, 8.62585306e-02f, 8.24444517e-02f, -1.09701594e-02f, -1.22698642e-01f, 6.70252517e-02f, -9.94105414e-02f,
  3.79497826e-01f, 3.14645946e-01f, -1.20535001e-01f, 3.42369914e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.23787855e-02f, -3.07919681e-01f, 4.45793599e-01f, 5.90889037e-01f, 1.38784394e-01f, 5.99292517e-01f, 1.93896815e-01f, 2.10763961e-01f, 3.36021721e-01f, -1.61699399e-01f,
  -1.53680190e-01f, -1.25357062e-01f, 5.52353740e-01f, -5.52914858e-01f, -2.64269173e-01f, -2.48857364e-01f, 3.87698710e-02f, -2.28579894e-01f, 1.29654765e-01f, 6.83368370e-02f,
  -4.54304725e-01f, -1.21616632e-01f, 3.46771702e-02f, 6.37183264e-02f, -2.10137248e-01f, 1.06471114e-01f, 1.95778292e-02f, 1.48545876e-01f, -2.07996070e-01f, 5.14803052e-01f,
  -1.13667712e-01f, 3.10816348e-01f, 3.67338598e-01f, 2.43842714e-02f, 3.24314296e-01f, 4.57432717e-01f, 1.31462187e-01f, 5.25490522e-01f, 4.56774116e-01f, 9.79880020e-02f,
  9.90750715e-02f, 2.53614813e-01f, -1.34153083e-01f, 2.53586471e-01f, -6.29196525e-01f, -5.67055404e-01f, 5.79057872e-01f, 2.35168561e-01f, -1.41203508e-01f, 4.76869404e-01f,
  -5.29080749e-01f, -2.92988092e-01f, -1.08444996e-01f, -6.16904683e-02f, 4.76950288e-01f, -5.05506899e-03f, -3.25786509e-02f, -1.35776788e-01f, -2.92939425e-01f, -8.42878968e-02f,
  2.15460569e-01f, -4.12289083e-01f, -1.14991456e-01f, 6.16387725e-01f, -1.38408849e-02f, 7.56260194e-03f, 2.28450492e-01f, -1.35407656e-01f, 6.23046219e-01f, -2.54780389e-02f,
  5.56946993e-01f, -1.15443520e-01f, -3.90024811e-01f, 2.14923248e-01f, -2.14829221e-01f, 3.73878330e-01f, -6.14244998e-01f, -7.03186467e-02f, 6.01811945e-01f, 2.72007614e-01f,
  -5.73473811e-01f, 2.39281043e-01f, 4.35305595e-01f, 9.52528939e-02f, 4.15288061e-01f, -8.21485147e-02f, 3.48669112e-01f, 3.26338969e-02f, -3.63700837e-01f, 5.75123467e-02f,
  3.11510801e-01f, 7.09035695e-02f, 2.05588490e-01f, -1.00736570e+00f, -3.46566662e-02f, 2.60481760e-02f, 6.82432353e-02f, -2.82142520e-01f, 1.91025764e-01f, -5.00832856e-01f,
  3.39369506e-01f, 1.90203339e-01f, -9.30155069e-02f, -1.54702619e-01f, -5.09443998e-01f, 8.24519608e-04f, -3.21108848e-01f, -1.75793096e-01f, 5.46969891e-01f, -3.35262269e-01f,
  3.91509086e-02f, -2.17566207e-01f, 4.43663716e-01f, -3.51589471e-01f, -1.38882637e-01f, -1.15415402e-01f, -4.85697210e-01f, 1.28881454e-01f, -1.35047209e+00f, -5.24453782e-02f,
  3.33388984e-01f, -1.52539089e-01f, 3.64518464e-02f, 6.36027232e-02f, -6.62537888e-02f, 8.74124765e-01f, -5.85012883e-02f, -2.14510933e-01f, 1.26711028e-02f, 2.62733877e-01f,
  -1.90968916e-01f, -4.21357483e-01f, 1.62754804e-01f, -3.10426682e-01f, -3.18544894e-01f, 1.05832443e-01f, 3.07694703e-01f, 4.04425748e-02f, -3.86089295e-01f, -5.07815778e-01f,
  2.67429113e-01f, 5.64144373e-01f, -4.44372207e-01f, -4.69092317e-02f, 3.87777776e-01f, -1.33169308e-01f, -1.27957575e-02f, -2.99935073e-01f, -3.63432884e-01f, 5.69876693e-02f,
  -5.81941456e-02f, 2.69300751e-02f, 4.76382166e-01f, 6.42599165e-02f, -1.44863605e-01f, -1.48081928e-01f, -3.10186237e-01f, 6.07832849e-01f, 1.08703196e-01f, -2.84697443e-01f,
  -1.20276779e-01f, 2.58148223e-01f, 1.54326290e-01f, 3.20341825e-01f, 5.11304796e-01f, -1.20696932e-01f, -1.73618183e-01f, -6.10867850e-02f, -1.09553054e-01f, 1.60492361e-01f,
  2.19471455e-02f, -4.69182163e-01f, 2.55988091e-01f, 5.56952059e-01f, -5.31590521e-01f, -4.81765628e-01f, -1.09053552e-01f, 4.75818127e-01f, -3.40385139e-01f, -1.92022428e-01f,
  9.34831128e-02f, -3.74349132e-02f, 5.88400841e-01f, 1.13808222e-01f, -1.37283474e-01f, 3.56336869e-02f, -7.98530802e-02f, 1.58156350e-01f, -1.73430994e-01f, -6.32406399e-02f,
  1.54763684e-01f, 1.88666642e-01f, 3.84918638e-02f, 2.00565904e-01f, 3.26834381e-01f, 4.49687421e-01f, -2.78237969e-01f, 6.19385302e-01f, -1.13219038e-01f, 3.45823526e-01f,
  -3.32177162e-01f, 3.68769556e-01f, 4.57655996e-01f, -6.32407844e-01f, -2.83896685e-01f, 3.83771896e-01f, -5.89272022e-01f, -5.31051636e-01f, -1.96338207e-01f, 7.71288127e-02f,
  4.51916844e-01f, 7.53604397e-02f, 4.04422671e-01f, 4.97781374e-02f, 5.50180316e-01f, -4.18099388e-02f, 1.32625494e-02f, -8.73149931e-03f, 1.54973581e-01f, -4.75387499e-02f,
  5.24366163e-02f, -1.08698404e+00f, -1.43426433e-01f, -3.28231424e-01f, -4.54454988e-01f, -9.54001490e-03f, -3.97214085e-01f, -4.17195618e-01f, -3.44603717e-01f, -4.41355288e-01f,
  -3.73118818e-01f, -5.33203363e-01f, -9.05023068e-02f, -4.01738107e-01f, 4.10381287e-01f, 1.20647185e-01f, -1.54542223e-01f, -1.12248845e-01f, 9.95313525e-02f, 1.33991435e-01f,
  -3.03996354e-01f, -4.20908004e-01f, 8.82638395e-02f, 3.48960698e-01f, -1.27772659e-01f, 1.45769473e-02f, -8.63485515e-01f, -1.17553242e-01f, 7.62376795e-03f, -1.68429330e-01f,
  1.35285139e-01f, 2.35870946e-02f, -6.53155804e-01f, 8.87875140e-01f, -1.59208238e-01f, -3.79599869e-01f, -4.15475015e-03f, -8.61148238e-02f, -1.86673597e-01f, -5.71506560e-01f,
  -4.33985472e-01f, -2.48948425e-01f, -3.54413807e-01f, -3.74540612e-02f, 3.74391437e-01f, -1.00171186e-01f, 8.83395672e-02f, 3.18942130e-01f, -3.09794396e-01f, -2.55146235e-01f,
  4.64785576e-01f, 4.53562170e-01f, -9.67647508e-02f, 1.93944164e-02f, 2.97776580e-01f, -1.19327366e-01f, -8.81747231e-02f, -9.36756879e-02f, -6.99462518e-02f, -2.56599318e-02f,
  -4.60950017e-01f, -6.18978739e-02f, -6.86413934e-03f, 1.62339345e-01f, 2.64861226e-01f, -7.48644352e-01f, 7.05063045e-02f, 8.63845646e-01f, 4.36112545e-02f, -6.14816397e-02f,
  -3.29045415e-01f, 3.35869074e-01f, -3.36792618e-01f, -3.87342632e-01f, -1.25630245e-01f, 1.38074517e-01f, -2.67102957e-01f, 1.85415551e-01f, 2.99588501e-01f, -2.07202598e-01f,
  5.29670775e-01f, -1.29529923e-01f, -2.56013721e-01f, 1.67720512e-01f, 2.57043958e-01f, 1.92915022e-01f, -2.12481450e-02f, 1.86539814e-01f, 2.88329482e-01f, 7.18339011e-02f,
  6.32974565e-01f, -6.45229742e-02f, 2.57503122e-01f, -8.61683339e-02f, 1.20599568e-01f, -1.12132579e-01f, -2.00981617e-01f, -4.20199662e-01f, 1.09994166e-01f, -7.65833616e-01f,
  -7.98019953e-03f, -1.70933515e-01f, -3.82719547e-01f, 2.72256225e-01f, -4.22680020e-01f, -9.04594548e-03f, 2.62733042e-01f, 2.00818256e-01f, 6.63717017e-02f, -4.13616717e-01f,
  -1.79513507e-02f, 5.93150854e-01f, -3.74403208e-01f, -3.39864880e-01f, 5.69637239e-01f, 4.99112755e-01f, -8.41700584e-02f, -6.29559338e-01f, -2.92794764e-01f, 3.66052240e-02f,
  -2.66438901e-01f, 7.68253356e-02f, -4.60435778e-01f, 1.09975353e-01f, 4.49680030e-01f, 1.07310236e-01f, 3.65140401e-02f, 1.67627960e-01f, 2.10443601e-01f, 2.33117074e-01f,
  1.87142119e-01f, 4.89046991e-01f, 1.11115202e-01f, 5.05203344e-02f, -4.63532567e-01f, -2.28148520e-01f, -4.93400335e-01f, -3.85351717e-01f, -3.29947621e-01f, -3.65145773e-01f,
  1.60096437e-01f, -3.78509581e-01f, 6.97667420e-01f, -7.20466375e-02f, 5.08150041e-01f, 3.39271814e-01f, -3.47381756e-02f, -1.82360739e-01f, 4.26766247e-01f, 2.80785680e-01f,
  8.71230736e-02f, 3.69837791e-01f, 5.02468109e-01f, -9.49631706e-02f, -1.22351997e-01f, -1.66320950e-01f, 3.63424391e-01f, 1.06574796e-01f, -1.01698466e-01f, -8.93844441e-02f,
  6.17638528e-02f, 3.25047046e-01f, 1.11692198e-01f, -5.96266150e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.68971969e-02f, -5.65376179e-03f, 1.83755800e-01f, -1.97119731e-02f, 8.12531263e-02f, -9.65028256e-02f, 1.32347131e-02f, -2.80373484e-01f, -3.21270786e-02f, 1.64250024e-02f,
  2.19487861e-01f, -1.16563827e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    