/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.08558255e-01f, 4.55831021e-01f, 9.31971222e-02f, -7.99776763e-02f, 1.44412741e-01f, 1.47213638e-01f, 3.17036837e-01f, 5.03773652e-02f, -6.41337335e-02f, 1.37949035e-01f,
  1.42189011e-01f, -1.40352607e-01f, -1.12747857e-02f, -3.30116600e-02f, -4.70267683e-02f, 2.90899068e-01f, 2.73059160e-01f, -2.42424551e-02f, -3.12283158e-01f, -1.12903677e-01f,
  -2.05437988e-02f, -9.69169512e-02f, -2.74815857e-01f, -4.93640117e-02f, -1.56028382e-02f, -1.00087121e-01f, 6.87573180e-02f, -2.85039172e-02f, 1.86494514e-01f, 1.94665447e-01f,
  1.37853995e-01f, -7.01247603e-02f, -1.16706356e-01f, -1.34098336e-01f, -4.16325703e-02f, -4.67402078e-02f, -6.71106353e-02f, -1.15791395e-01f, -2.92774532e-02f, 4.82841581e-02f,
  -4.03953157e-02f, -1.40028328e-01f, -1.79384917e-03f, -7.42688328e-02f, -1.48982229e-02f, -1.04638964e-01f, -1.33633241e-01f, -4.40904126e-02f, -1.08725108e-01f, 4.72956337e-02f,
  -3.11541613e-02f, 2.36957874e-02f, 5.38718328e-02f, -7.23327398e-02f, -4.25541885e-02f, -2.85848416e-02f, -3.60401012e-02f, -3.74031588e-02f, -3.49628143e-02f, -2.95700002e-02f,
  5.37385829e-02f, 1.66963786e-02f, 6.86066523e-02f, 1.14709891e-01f, 3.80821042e-02f, 2.44918093e-02f, -3.12103378e-03f, 1.17515713e-01f, -5.55274189e-02f, 1.17134685e-02f,
  -2.01055724e-02f, 9.20340568e-02f, 1.33674564e-02f, -4.96617630e-02f, -7.11881295e-02f, 4.31450233e-02f, 3.18086357e-03f, 5.39857522e-02f, -4.15765718e-02f, 6.60823360e-02f,
  -1.19532868e-02f, 1.40420664e-02f, 8.96811858e-02f, -3.27316895e-02f, -1.79795045e-02f, -3.73169370e-02f, -1.92128848e-02f, -1.06749423e-01f, 2.19745208e-02f, 1.24425068e-02f,
  1.44156858e-01f, -1.78806987e-02f, 8.76261666e-02f, -6.75822571e-02f, -5.41783832e-02f, -1.38627619e-01f, 4.54214364e-02f, -2.72928067e-02f, -6.43896386e-02f, 2.98417024e-02f,
  -1.02433734e-01f, -1.89346224e-02f, 6.06897324e-02f, -7.36943185e-02f, -4.71735261e-02f, -3.21497247e-02f, 1.01374179e-01f, -8.98620263e-02f, 8.95960629e-03f, 4.23988514e-02f,
  1.93849392e-02f, 4.51199897e-02f, 6.21195994e-02f, 9.49860271e-03f, 4.97487597e-02f, -8.84669051e-02f, 1.07657343e-01f, 5.82056530e-02f, 2.01851632e-02f, 1.99419990e-01f,
  2.62609750e-01f, -1.22263748e-03f, 2.74834126e-01f, 6.48014620e-02f, 8.09537470e-02f, 8.83727372e-02f, 4.19875956e-04f, -4.86494079e-02f, 2.04936694e-02f, -4.74948995e-02f,
  1.81226194e-01f, 2.20856592e-01f, 2.77118891e-01f, 1.58516347e-01f, 1.70806840e-01f, 1.07580787e-02f, -9.55901518e-02f, 8.35112259e-02f, 2.39708751e-01f, 6.61198422e-02f,
  -8.79001096e-02f, -2.26314813e-02f, 1.71345726e-01f, 1.53731871e-02f, -9.84709337e-02f, 2.93308739e-02f, 6.48561046e-02f, 3.08824275e-02f, 1.50425389e-01f, -1.20203411e-02f,
  3.80445182e-01f, 1.78801998e-01f, 8.22665244e-02f, 6.58381879e-02f, 2.11186856e-01f, 1.49632841e-01f, 1.93515703e-01f, 2.13132992e-01f, 8.85854959e-02f, 1.28704861e-01f,
  2.26802930e-01f, 1.94555581e-01f, 2.29852691e-01f, 7.57441251e-03f, 1.47305205e-01f, 9.14319605e-02f, -4.31620143e-03f, 1.98592648e-01f, 2.00403035e-01f, 2.11366311e-01f,
  5.39626479e-02f, 1.44671321e-01f, 3.55827153e-01f, 1.06260613e-01f, 2.01797023e-01f, 2.76042312e-01f, 1.18299872e-01f, 5.97288050e-02f, 1.16502099e-01f, 6.17577098e-02f,
  -5.18096611e-02f, 7.20065236e-02f, 2.35848334e-02f, -1.73326302e-02f, -7.76101500e-02f, 4.73896042e-02f, -1.14631597e-02f, -3.94450650e-02f, -6.71059266e-02f, -5.56118740e-03f,
  2.91913804e-02f, 9.27487984e-02f, -1.56154195e-02f, 5.63422106e-02f, -1.07733244e-02f, 3.60870436e-02f, 3.20221521e-02f, -8.06960464e-02f, -3.65556404e-02f, -4.10113558e-02f,
  7.77503476e-02f, 3.76371630e-02f, -9.51483920e-02f, 1.34369731e-02f, -5.08022569e-02f, -7.67135099e-02f, -1.28481716e-01f, -2.81401258e-02f, -3.73198651e-02f, 6.89065680e-02f,
  7.07216859e-02f, 2.73903370e-01f, 7.69114792e-02f, 1.40719578e-01f, 1.38421655e-01f, 9.40028206e-02f, 1.36359349e-01f, 1.60866857e-01f, 1.51800886e-01f, 9.05509070e-02f,
  1.37615576e-01f, 1.34243876e-01f, 1.53179720e-01f, 1.40022352e-01f, 1.83343798e-01f, 2.76635047e-02f, 1.43539337e-02f, 1.94281295e-01f, 6.61196709e-02f, 5.46450689e-02f,
  -4.68677375e-03f, 8.30685347e-02f, 1.96645960e-01f, 2.22440183e-01f, 1.88372031e-01f, 3.10999990e-01f, 2.66283840e-01f, 1.15526095e-01f, 2.17811853e-01f, -4.77641113e-02f,
  -3.37815017e-01f, -3.97799879e-01f, -1.81008205e-01f, -2.04254359e-01f, -1.65270925e-01f, -1.42187059e-01f, -2.20013693e-01f, -2.41592988e-01f, -1.44422352e-01f, -1.43808901e-01f,
  -3.37757580e-02f, 1.50542393e-01f, 1.44228190e-01f, 2.05628127e-01f, 1.13231074e-02f, -8.00648332e-03f, 6.97514638e-02f, 1.36365205e-01f, 1.45942956e-01f, -8.16230029e-02f,
  -9.37940925e-02f, -1.62134141e-01f, -1.79956496e-01f, -9.25010908e-03f, -2.34781187e-02f, 5.32069802e-02f, -2.17960045e-01f, -1.73611820e-01f, 1.15361623e-03f, 1.04890749e-01f,
  -1.03318552e-02f, -4.07205224e-01f, 8.64665210e-02f, -2.92491596e-02f, -1.29071280e-01f, -9.14393365e-02f, -4.24652426e-05f, -1.53330430e-01f, -4.29160669e-02f, -1.03984550e-01f,
  -4.98269908e-02f, -1.49372801e-01f, -7.62034068e-03f, -1.52799249e-01f, -2.18787462e-01f, -1.19494870e-01f, -1.81171402e-01f, -1.08585887e-01f, -1.05139226e-01f, -7.86800161e-02f,
  -2.85864361e-02f, -1.88426957e-01f, -1.67893365e-01f, -2.06710219e-01f, -1.29335716e-01f, 3.15865353e-02f, -1.92583501e-01f, -1.09064102e-01f, -1.80336446e-01f, -1.64739162e-01f,
  -2.75937468e-02f, 3.53869274e-02f, 8.54986608e-02f, -5.30809090e-02f, -4.63063195e-02f, 2.82365512e-02f, 1.09553665e-01f, -9.29942913e-03f, 1.36694267e-01f, -5.70493378e-02f,
  9.93679911e-02f, 4.04495411e-02f, 3.22960950e-02f, 2.03871541e-02f, 1.35392815e-01f, 7.16472939e-02f, 3.99471000e-02f, -3.66484337e-02f, 2.31997557e-02f, 5.82723394e-02f,
  5.55731505e-02f, -5.01548592e-03f, -8.79402533e-02f, 5.00497743e-02f, 4.16909121e-02f, 3.91041525e-02f, 9.85127240e-02f, -1.24311373e-02f, 6.62598982e-02f, -1.24322493e-02f,
  -7.33183548e-02f, -1.41951442e-01f, -8.42596462e-04f, -8.20492879e-02f, -4.81541231e-02f, -1.16551362e-01f, -3.24455164e-02f, -1.21087171e-01f, -1.10421598e-01f, -2.89703831e-02f,
  -1.51997522e-01f, -3.53407604e-03f, -5.77045828e-02f, -1.13110639e-01f, 3.60000022e-02f, -7.39465132e-02f, -5.10879979e-02f, 3.84744704e-02f, -7.76062459e-02f, -2.17807487e-01f,
  -1.20760903e-01f, -1.08029261e-01f, 2.72261873e-02f, -7.02828690e-02f, -1.26917303e-01f, 5.20255491e-02f, -1.57857463e-02f, -5.44101791e-03f, 4.34712172e-02f, -6.44820556e-02f,
  2.54850928e-02f, -1.19418345e-01f, -2.62860477e-01f, 1.68567106e-01f, -5.20437881e-02f, -1.01615004e-02f, 1.53384991e-02f, 5.19780666e-02f, 1.12907544e-01f, 8.78218412e-02f,
  -1.26448885e-01f, -9.86796990e-02f, -1.69349596e-01f, -1.51453521e-02f, 4.64966595e-02f, 1.84445173e-01f, 1.87868714e-01f, 1.62703022e-01f, -1.73581094e-02f, 6.30806535e-02f,
  1.40272588e-01f, 1.09889418e-01f, 2.08325073e-01f, 9.13015679e-02f, 1.07742675e-01f, 3.13189812e-02f, -4.26077060e-02f, 8.30899477e-02f, -5.41444449e-03f, 7.71183074e-02f,
  -1.99218050e-01f, -1.47062451e-01f, -5.29882833e-02f, -4.97914553e-02f, -9.55047682e-02f, -1.18027091e-01f, -5.69484197e-02f, 7.50601478e-03f, -1.57142915e-02f, -8.76643807e-02f,
  -2.31997669e-01f, -5.04601784e-02f, -1.14444613e-01f, -6.29921779e-02f, -4.81408881e-03f, -6.90302849e-02f, 5.53174987e-02f, -3.30172665e-02f, -1.39025122e-01f, -2.04877093e-01f,
  -2.78156064e-02f, -1.13332689e-01f, -1.53701514e-01f, -6.20185547e-02f, -1.61755502e-01f, -1.73150167e-01f, -8.51571038e-02f, -9.92961973e-02f, -1.05311796e-01f, 2.58373376e-02f,
  8.90153572e-02f, 6.24879189e-02f, 5.57924770e-02f, 1.27524272e-01f, 1.77257627e-01f, -1.00767678e-02f, 1.49622500e-01f, 1.20463327e-01f, 1.51515856e-01f, 6.32480904e-02f,
  7.94793963e-02f, 4.58311662e-02f, 1.66918859e-01f, 2.12425947e-01f, 9.56782699e-02f, 1.28806740e-01f, 1.04919687e-01f, 1.69841573e-01f, 1.56211078e-01f, 1.28787637e-01f,
  1.16627544e-01f, 4.90481146e-02f, 3.70174199e-02f, 9.21514705e-02f, 6.35438189e-02f, 2.70411093e-02f, -3.51090264e-03f, 5.49073331e-02f, -3.27887908e-02f, 4.73847724e-02f,
  -1.02443047e-01f, -2.96002001e-01f, 2.02070680e-02f, -1.15318775e-01f, -3.47256176e-02f, -9.00111496e-02f, -2.11301833e-01f, -1.39684945e-01f, -2.25400373e-01f, -2.77514327e-02f,
  -2.16739163e-01f, -2.53702980e-02f, -1.57540038e-01f, -7.79081360e-02f, -1.64143015e-02f, -1.24343917e-01f, 5.71713932e-02f, -3.36184092e-02f, -1.30453691e-01f, -3.64984870e-02f,
  -1.94117557e-02f, 2.05822266e-03f, 2.08177194e-02f, 8.29482358e-03f, -5.84133267e-02f, -1.46493256e-01f, -1.83479279e-01f, -1.11701012e-01f, -1.00070864e-01f, 1.57978348e-02f,
  -4.01187181e-01f, -2.30979621e-01f, -2.58746088e-01f, -9.32062864e-02f, -8.47368985e-02f, -3.20455506e-02f, -2.76521385e-01f, -5.68816513e-02f, 1.68179244e-01f, 4.87586260e-02f,
  1.65916115e-01f, 2.77472258e-01f, 1.02130808e-01f, 8.17185864e-02f, -1.11192185e-02f, -1.24903500e-01f, -1.06682755e-01f, -4.42021564e-02f, -2.12902054e-02f, 1.44784153e-01f,
  1.28337324e-01f, -1.71464473e-01f, -2.50670761e-01f, 1.05529157e-02f, 2.44832173e-01f, 6.61240295e-02f, -4.48466651e-03f, -1.00144492e-02f, 3.51137370e-02f, 2.16538012e-01f,
  1.91163331e-01f, -2.14643441e-02f, 1.29467055e-01f, 1.73874363e-01f, 1.67758837e-02f, 1.14396334e-01f, 1.05958499e-01f, 7.07238391e-02f, 1.32995993e-01f, 4.64704745e-02f,
  9.31251273e-02f, 1.43372551e-01f, 7.12088272e-02f, 1.13945320e-01f, 7.04447404e-02f, 8.86604711e-02f, 5.47729246e-02f, -4.40805703e-02f, 3.50072235e-02f, 1.16543591e-01f,
  9.94620398e-02f, -6.29469659e-03f, -2.28575394e-02f, -2.68194936e-02f, 1.01440497e-01f, 4.84618098e-02f, -2.61176880e-02f, 1.26968563e-01f, 7.86405131e-02f, 1.28418893e-01f,
  2.15897732e-03f, -8.08781758e-02f, -1.16740979e-01f, -1.60496995e-01f, -1.05926007e-01f, -7.25285411e-02f, -5.63317798e-02f, -2.72341818e-02f, -8.65067989e-02f, -5.09777293e-02f,
  -1.03024095e-01f, 3.27290446e-02f, -5.35555929e-02f, -6.51646033e-02f, 1.02145769e-01f, -5.49794659e-02f, -6.24126047e-02f, -6.51325807e-02f, -5.88936135e-02f, -1.10163875e-01f,
  -1.17283359e-01f, -1.06531739e-01f, 1.90518573e-02f, -2.85403077e-02f, -5.53448312e-02f, -4.25443314e-02f, -3.90088744e-02f, 1.57218315e-02f, -3.70644517e-02f, -1.64371744e-01f,
  1.33449897e-01f, -1.87835515e-01f, 1.63918838e-01f, -1.01480205e-02f, 9.66025516e-02f, 6.17928244e-02f, 1.67837560e-01f, -9.33679473e-03f, 8.95688161e-02f, 1.21792376e-01f,
  1.84129283e-01f, 6.00789040e-02f, 4.79243658e-02f, 1.33469209e-01f, 7.73734972e-02f, 2.22377293e-02f, -2.63022073e-02f, 7.47247413e-02f, 9.47275311e-02f, 1.30917192e-01f,
  -4.99040633e-02f, -8.59864354e-02f, -1.16358493e-02f, -7.45870471e-02f, 8.29274058e-02f, 6.18321002e-02f, 5.12401871e-02f, 9.53535438e-02f, -2.38279402e-02f, -6.60717711e-02f,
  3.84502351e-01f, -1.62886575e-01f, 1.01809846e-02f, -1.55619130e-01f, -2.43106008e-01f, -9.00341943e-02f, -3.12818259e-01f, -1.34417951e-01f, 8.13363642e-02f, -1.94627166e-01f,
  -1.41296297e-01f, -5.87018207e-02f, 1.96855962e-02f, -8.18189010e-02f, 3.39363776e-02f, -1.67052403e-01f, -1.91887781e-01f, -1.94891635e-02f, 3.85618216e-04f, -1.54464990e-01f,
  -2.14959607e-01f, -5.99560626e-02f, -6.24721460e-02f, -4.69036587e-02f, -1.06906243e-01f, 2.61832755e-02f, -2.73274668e-02f, -3.22334357e-02f, 5.64442091e-02f, 1.30870612e-03f,
  1.02664329e-01f, 2.54118443e-01f, 5.10508195e-02f, -5.21677770e-02f, -1.57014474e-01f, 5.25936186e-02f, -9.24700201e-02f, 5.93475029e-02f, -1.15919216e-02f, -6.27897680e-03f,
  -6.98356777e-02f, -8.44463054e-03f, -7.07053319e-02f, 1.53281707e-02f, 3.61711867e-02f, -3.94728258e-02f, -1.26030788e-01f, -6.69957176e-02f, -7.99616128e-02f, -7.31989294e-02f,
  -1.72261655e-01f, -3.22476327e-02f, 4.61820811e-02f, 6.63096681e-02f, 1.09020986e-01f, -6.43116757e-02f, -2.77014240e-03f, 8.07729438e-02f, 8.08208436e-02f, 4.49117906e-02f,
  -1.97275609e-01f, 1.26026481e-01f, -1.04188006e-02f, -6.09538443e-02f, -1.34185073e-03f, 4.22691694e-03f, 6.96570128e-02f, 2.32930155e-03f, -7.62021095e-02f, 5.81494682e-02f,
  -9.86499190e-02f, 2.53500827e-02f, 9.00006574e-03f, -6.31708652e-03f, -1.07294023e-02f, 6.74421936e-02f, -3.47042307e-02f, -3.66855785e-02f, 4.19906788e-02f, 5.42816967e-02f,
  9.44906939e-03f, -1.77399516e-02f, 2.44711358e-02f, 1.47563992e-02f, 5.24528064e-02f, -2.56105047e-02f, 5.55038266e-03f, -4.26976383e-02f, 5.59382290e-02f, -5.07652126e-02f,
  9.41653624e-02f, 6.63592108e-03f, 1.04350589e-01f, 9.46854427e-02f, 4.42426186e-03f, 1.77023897e-03f, 1.73222795e-02f, -1.97058152e-02f, 4.22160737e-02f, -1.25002991e-02f,
  2.10886411e-02f, -1.43125728e-01f, -1.66351311e-02f, -1.05252318e-01f, -1.01983249e-02f, 3.42459381e-02f, -1.25805572e-01f, -5.11065573e-02f, -5.17296419e-02f, -3.99688631e-03f,
  -9.65477154e-02f, -3.74617614e-03f, -2.71069314e-02f, -4.14827429e-02f, 5.84639888e-03f, 6.77299574e-02f, 1.77065493e-03f, 4.68945354e-02f, 6.24573082e-02f, 7.03547150e-03f,
  -5.68677008e-01f, 2.64896005e-02f, -2.54178822e-01f, -1.35621101e-01f, -1.61138531e-02f, -3.52585465e-02f, -9.10642222e-02f, 3.21814418e-02f, -1.11571841e-01f, -1.00876853e-01f,
  1.12256803e-01f, -1.02345143e-02f, -1.39978379e-02f, -1.37547255e-01f, -1.66939244e-01f, -1.15257464e-01f, -1.47296935e-01f, -3.02627981e-01f, -3.13350737e-01f, 9.70688835e-02f,
  1.64907187e-01f, -1.95754711e-02f, -3.09961438e-01f, -1.73891764e-02f, 1.85151935e-01f, 1.47384359e-02f, -1.95539132e-01f, 2.73892917e-02f, 1.00899369e-01f, 1.26437038e-01f,
  -4.90945987e-02f, -9.25705284e-02f, -9.78599414e-02f, -6.96167722e-02f, -8.41518790e-02f, -1.38788298e-01f, -8.93608034e-02f, -1.37372851e-01f, -3.93754877e-02f, -6.65131882e-02f,
  7.48426244e-02f, 4.27424014e-02f, -1.03776500e-01f, -3.25198695e-02f, -4.57582530e-03f, 2.01817360e-02f, -4.56345342e-02f, -1.31299525e-01f, -1.30795419e-01f, -6.00537285e-02f,
  7.83893615e-02f, 3.56097296e-02f, -8.36842880e-02f, 6.24437444e-03f, -4.47712690e-02f, -1.09266162e-01f, 1.70903560e-02f, 6.57186657e-02f, -2.11888939e-01f, -2.29255054e-02f,
  4.77121472e-02f, 9.16507468e-02f, 3.69266607e-02f, 3.74655202e-02f, 9.27740335e-02f, 8.97824168e-02f, 4.56947945e-02f, 1.31233528e-01f, 1.03877366e-01f, 4.07781638e-02f,
  9.03891474e-02f, -2.43503880e-02f, 4.66043726e-02f, -3.88120636e-02f, -9.58015397e-03f, 4.13148776e-02f, 2.96073426e-02f, 2.36727279e-02f, 1.94312837e-02f, 3.87701839e-02f,
  1.81777775e-02f, 4.88118269e-02f, -2.61246078e-02f, 7.16769770e-02f, 7.30339661e-02f, 3.83427478e-02f, 3.65138538e-02f, 1.06924504e-01f, 7.19215572e-02f, 9.43054855e-02f,
  -9.33035240e-02f, -3.68037462e-01f, 1.84708554e-02f, 6.92263071e-04f, -4.45947349e-02f, -5.90045266e-02f, -6.32510632e-02f, -1.22594744e-01f, -4.00961973e-02f, -7.64376968e-02f,
  -3.57920565e-02f, -1.02553882e-01f, -4.61101122e-02f, -3.52360941e-02f, -7.33676329e-02f, -1.08842673e-02f, -6.33951975e-03f, -3.71043049e-02f, -1.22028463e-01f, 5.16160540e-02f,
  -8.42580199e-02f, -2.08924115e-01f, -2.12492362e-01f, -1.47059917e-01f, 1.82533097e-02f, -1.39201552e-01f, -2.36595739e-02f, -7.75366873e-02f, -2.49165133e-01f, -1.55763805e-01f,
  1.28120974e-01f, -1.33905932e-01f, 3.07442933e-01f, -1.04864566e-02f, -1.15692176e-01f, -7.61164129e-02f, -7.16188326e-02f, -1.94767773e-01f, 4.05506417e-02f, -5.30235805e-02f,
  -2.09083855e-01f, -1.95136100e-01f, 4.55140024e-02f, 2.08784584e-02f, -5.76808536e-03f, 1.99748233e-01f, 3.27396035e-01f, 2.84142435e-01f, 1.28005624e-01f, -7.12584471e-03f,
  -1.62978505e-03f, -5.28587624e-02f, 1.66930109e-02f, 3.19642425e-02f, -2.83268047e-04f, -4.78426591e-02f, 1.05418243e-01f, 6.97463900e-02f, -6.50654212e-02f, 1.49201795e-01f,
  1.88235864e-01f, -1.40875831e-01f, 3.11778113e-03f, -1.25902295e-02f, -1.22827636e-02f, -2.36718282e-02f, -1.72191393e-02f, -6.73738122e-02f, -6.26563728e-02f, -2.15806020e-03f,
  -3.40093710e-02f, -1.17294997e-01f, -7.70539641e-02f, -8.34389701e-02f, 1.81054752e-02f, -9.61262360e-02f, -8.30080360e-02f, -1.78012997e-02f, 1.48719279e-02f, -1.64907292e-01f,
  -1.90193862e-01f, -1.30122244e-01f, -1.01057015e-01f, -4.10212055e-02f, 7.58925546e-03f, 1.20563321e-01f, -8.30604881e-02f, -2.52132246e-04f, -7.14113191e-02f, 8.46211985e-02f,
  -5.19257365e-03f, 1.14294246e-01f, -7.30191916e-02f, -4.26202361e-03f, -3.94207016e-02f, 3.80984508e-02f, -1.07740685e-02f, -6.38608411e-02f, -9.35096517e-02f, 4.96523827e-03f,
  -4.42398563e-02f, 1.76678505e-03f, 8.17193389e-02f, -4.79357243e-02f, 1.04717938e-02f, 4.04519066e-02f, -1.50865037e-02f, -9.29052569e-03f, -5.21587357e-02f, -9.05521438e-02f,
  -1.54508790e-02f, -2.78882552e-02f, 4.54420894e-02f, 3.85257415e-03f, -7.65424594e-03f, 1.10382512e-01f, 5.68565503e-02f, -9.56449956e-02f, 7.90065303e-02f, 2.54545752e-02f,
  1.53660187e-02f, -8.58824179e-02f, 6.25804141e-02f, -5.15047275e-02f, -7.02037141e-02f, -5.37434146e-02f, -7.46745914e-02f, -2.35541128e-02f, -3.44826393e-02f, 1.14604244e-02f,
  -9.43648294e-02f, 4.07303460e-02f, 2.54199430e-02f, -8.56586397e-02f, -8.32856297e-02f, -7.44820163e-02f, -2.92542716e-03f, 3.10039464e-02f, -3.28515023e-02f, -1.34817928e-01f,
  -1.11037530e-01f, -1.55615034e-02f, 9.75315720e-02f, -3.34533006e-02f, -2.13452633e-02f, 1.33003443e-01f, 8.71755257e-02f, -1.62764154e-02f, 1.13002375e-01f, 1.07301868e-01f,
  -8.18132609e-02f, 1.20084219e-01f, -1.75635785e-01f, 1.08877912e-01f, 2.50857021e-03f, -4.77288030e-02f, 5.67343421e-02f, 7.37272128e-02f, 6.43302798e-02f, 1.76623017e-01f,
  -2.52753049e-02f, -3.33853550e-02f, -1.11271806e-01f, -4.96503785e-02f, -2.12704346e-01f, -2.04647928e-02f, -2.90508810e-02f, -2.18820810e-01f, -2.73296654e-01f, 1.22700468e-01f,
  1.03832990e-01f, -1.14966951e-01f, -1.22881681e-01f, 1.30635679e-01f, 1.42204523e-01f, 4.78651598e-02f, 1.10849306e-01f, 4.79681324e-03f, 4.47127409e-02f, 1.61783591e-01f,
  -1.32573647e-02f, -3.41147371e-02f, 4.61868010e-02f, 9.54896212e-02f, 9.09891650e-02f, 1.99739143e-01f, 3.33127677e-02f, 6.15867376e-02f, 6.04948811e-02f, 6.59116432e-02f,
  1.51414528e-01f, 1.54761389e-01f, 8.60486999e-02f, 1.16331026e-01f, 9.85506698e-02f, 5.14293723e-02f, 5.53359054e-02f, 6.72072172e-02f, 1.50182709e-01f, 2.28749096e-01f,
  2.54876137e-01f, 4.78778817e-02f, -1.97538584e-02f, 4.19379883e-02f, 9.84928086e-02f, 7.51289129e-02f, 5.42466789e-02f, 1.83578089e-01f, 1.19752243e-01f, 1.77409083e-01f,
  -2.77332161e-02f, -1.87529042e-01f, -1.40529886e-01f, -8.69299918e-02f, -4.01702337e-02f, -2.22837068e-02f, -1.09106116e-01f, -5.27980030e-02f, -9.49309245e-02f, -1.19512556e-02f,
  -7.18178526e-02f, -1.27329882e-02f, -5.48805110e-02f, -6.73938543e-02f, -3.77172907e-03f, -1.04571536e-01f, -5.27322143e-02f, 3.11184041e-02f, 6.35687029e-03f, -3.20332237e-02f,
  -8.13036561e-02f, -9.90428552e-02f, -8.76056254e-02f, 4.03326824e-02f, -2.28251563e-03f, -1.11129418e-01f, -8.03692639e-02f, -2.19328925e-02f, -8.75220746e-02f, -1.10813938e-01f,
  3.81282605e-02f, -6.60352334e-02f, 1.91106930e-01f, 1.65628850e-01f, 1.40685841e-01f, 1.54194146e-01f, 2.58282572e-01f, 1.23796798e-01f, 2.15336338e-01f, 1.92967057e-01f,
  1.31874144e-01f, 5.60546555e-02f, 1.47541776e-01f, 8.26626942e-02f, 2.03318782e-02f, 1.17965207e-01f, 1.67552933e-01f, 4.91891652e-02f, 1.34475350e-01f, 1.64699793e-01f,
  2.42609248e-01f, 9.48538780e-02f, 1.54558728e-02f, 1.54182792e-01f, 5.23749217e-02f, -1.37756905e-02f, 5.52488081e-02f, 1.17839105e-01f, -3.81872361e-03f, 2.35870197e-01f,
  4.05015089e-02f, 2.65060276e-01f, -4.12200093e-01f, 8.90480950e-02f, 1.56410830e-03f, -2.03919038e-01f, -1.84662983e-01f, -5.14373854e-02f, 7.55333528e-02f, 1.08951926e-01f,
  1.54871821e-01f, 7.39988089e-02f, -5.72324507e-02f, -8.49033073e-02f, -2.28570879e-01f, 3.01603563e-02f, 7.00597614e-02f, -3.53504717e-01f, -4.21249539e-01f, -2.53236771e-01f,
  9.97667313e-02f, 1.02782555e-01f, -8.21566433e-02f, -8.52213949e-02f, 3.22635829e-01f, -1.84358992e-02f, 1.43799577e-02f, 1.20809585e-01f, 2.08583958e-02f, 2.88166046e-01f,
  2.04976901e-01f, -9.72949788e-02f, -1.59100622e-01f, -4.06246819e-02f, 6.33864105e-02f, -1.25670999e-01f, 2.97791734e-02f, -7.89287128e-03f, 3.74838598e-02f, 2.58306991e-02f,
  1.81590617e-02f, -2.88195871e-02f, -1.73720978e-02f, 1.02321282e-02f, 3.25181186e-02f, -2.03879848e-02f, -9.22195837e-02f, -2.04284251e-01f, -7.75348023e-02f, -8.05900320e-02f,
  9.89640057e-02f, -7.91277736e-02f, -1.68910176e-01f, -5.34735695e-02f, -1.84768140e-01f, -1.49099067e-01f, -1.72315225e-01f, -6.86075315e-02f, -2.90164024e-01f, 1.77827194e-01f,
  1.04507744e-01f, 3.65820900e-02f, -2.00166721e-02f, 3.51843983e-02f, 7.98143223e-02f, 2.08720509e-02f, 5.58849722e-02f, -2.04499736e-02f, 3.70967947e-02f, 4.90982421e-02f,
  3.67165804e-02f, 5.12562394e-02f, -5.02525978e-02f, 2.39599980e-02f, 4.45902860e-03f, -5.44241257e-03f, -9.79624465e-02f, 7.47714043e-02f, 5.43097742e-02f, -1.78443901e-02f,
  9.40111876e-02f, -4.00928333e-02f, 3.04956287e-02f, 2.24406403e-02f, -6.89653009e-02f, -2.53265947e-02f, -4.17516287e-03f, -3.38660479e-02f, 8.88229609e-02f, 8.11649188e-02f,
  2.76363194e-01f, -3.23225796e-01f, 9.78746489e-02f, 5.65931685e-02f, 2.68211053e-03f, 1.64795611e-02f, -2.31255107e-02f, -1.00497203e-02f, -1.15717482e-02f, -9.79899019e-02f,
  -1.44813299e-01f, -1.11745395e-01f, -6.51289225e-02f, 5.54649811e-03f, -2.62152869e-03f, -1.44143272e-02f, 7.71064172e-03f, -5.52270263e-02f, -1.33343741e-01f, -5.94397746e-02f,
  -4.78427969e-02f, 2.55882554e-02f, -3.74209471e-02f, -2.07789056e-02f, -3.64813171e-02f, -1.20334439e-01f, -8.14861581e-02f, 3.59683484e-02f, -1.22110903e-01f, 2.13211268e-01f,
  4.16364372e-01f, -3.12126249e-01f, 2.65691519e-01f, 1.68937847e-01f, -2.00495124e-02f, -3.97311263e-02f, -2.59140283e-01f, -1.15454480e-01f, 4.68933024e-03f, -1.29553735e-01f,
  -1.19837373e-01f, -3.16862129e-02f, -8.64802822e-02f, -7.64337927e-02f, -1.89238459e-01f, -1.34790123e-01f, 1.02282669e-02f, 1.24037676e-01f, 1.84659958e-01f, -6.31229281e-02f,
  -9.45085585e-02f, -1.28372431e-01f, -8.33714157e-02f, 5.35187200e-02f, -5.57424501e-02f, 5.47477864e-02f, -6.67902827e-02f, -4.56663072e-02f, -1.66909695e-01f, 1.35663092e-01f,
  2.04465583e-01f, -8.53653327e-02f, -5.52352481e-02f, -1.09022312e-01f, -1.08076707e-01f, -3.33183333e-02f, -1.00733630e-01f, -3.69570553e-02f, -3.23395282e-02f, -1.74706113e-02f,
  -8.96027312e-02f, -1.26686841e-02f, -1.05618082e-01f, -3.54955308e-02f, -1.24402195e-02f, -5.27651235e-02f, -1.22572951e-01f, 1.21530015e-02f, -8.46330598e-02f, -4.52136360e-02f,
  -2.13583991e-01f, -1.03384785e-01f, 4.56073433e-02f, -2.04147965e-01f, -1.77612647e-01f, -5.06141805e-04f, -1.34492055e-01f, -1.15822658e-01f, -2.95224432e-02f, -7.93685392e-03f,
  -2.88316440e-02f, 1.48402020e-01f, 1.53929219e-01f, 2.69217268e-02f, 1.08490035e-01f, 5.50496802e-02f, 1.39853701e-01f, 5.15778996e-02f, 1.54922213e-02f, 3.49019393e-02f,
  8.61704126e-02f, 1.13000832e-01f, 5.41562885e-02f, 2.96686757e-02f, 2.99429242e-02f, 7.63672683e-03f, 1.41222745e-01f, 2.51220819e-03f, 6.02089353e-02f, 7.27722496e-02f,
  8.60767215e-02f, 5.37268519e-02f, 1.26114473e-01f, 3.53444405e-02f, 3.30219269e-02f, 1.29201353e-01f, 1.00183055e-01f, 2.66765803e-02f, 1.26678452e-01f, 3.69872083e-03f,
  -1.12258092e-01f, -3.97345811e-01f, 3.82260121e-02f, -1.48619339e-01f, -1.25820294e-01f, -8.25644881e-02f, -5.17598726e-02f, -1.64279744e-01f, -1.91752955e-01f, -5.17219231e-02f,
  -1.32225662e-01f, -1.82805493e-01f, -1.02282993e-01f, -1.29498228e-01f, 1.26008689e-02f, -4.89065535e-02f, -1.59398392e-01f, -1.08688928e-01f, -1.98856056e-01f, -8.25855136e-02f,
  -1.87182665e-01f, -3.91759165e-02f, -3.88647057e-02f, -7.14413598e-02f, -1.10232927e-01f, 3.28422748e-02f, 4.40748408e-03f, -1.04477435e-01f, -1.17046893e-01f, -7.70404041e-02f,
  -3.41756433e-01f, 3.02826107e-01f, -2.19927579e-01f, -4.34283800e-02f, 3.12162526e-02f, 2.26031229e-01f, 3.63894761e-01f, 2.28242457e-01f, 3.27255912e-02f, 1.83427006e-01f,
  -3.16621512e-02f, -2.37960473e-01f, -2.67972887e-01f, -1.55235857e-01f, -1.57492177e-03f, 1.16154544e-01f, 1.32274453e-03f, -2.62251824e-01f, -4.14938033e-01f, -6.51970804e-02f,
  4.48157974e-02f, -7.41546080e-02f, -2.48522118e-01f, -1.85658664e-01f, 1.07572854e-01f, -2.17536241e-01f, 6.76826984e-02f, -1.74571574e-02f, -1.66428052e-02f, -1.76135421e-01f,
  -3.22308600e-01f, -2.16478226e-03f, -2.08053783e-01f, -1.52753681e-01f, -7.73040429e-02f, -7.86025450e-02f, -4.32185903e-02f, -1.09127527e-02f, -4.39135134e-02f, 6.35810345e-02f,
  -9.48601887e-02f, -5.03201857e-02f, -1.58704817e-01f, -6.35719225e-02f, -8.43795314e-02f, -9.57431570e-02f, -1.07213706e-01f, -9.42971036e-02f, -1.55519217e-01f, -3.04375384e-02f,
  7.09678158e-02f, -6.79420009e-02f, -8.03413242e-02f, 7.10164458e-02f, 2.35371816e-04f, -2.08115414e-01f, -1.12990722e-01f, -1.25431657e-01f, 3.56369372e-03f, 9.09061208e-02f,
  5.26481681e-03f, 2.13303585e-02f, 7.47271255e-02f, 2.91620046e-02f, 9.97973904e-02f, 5.90140969e-02f, -4.76974398e-02f, 1.04718655e-01f, 1.34923076e-02f, -3.49873584e-03f,
  -3.31286304e-02f, 3.53275873e-02f, -5.66773638e-02f, 1.01281814e-01f, -3.15914042e-02f, 3.64348032e-02f, -3.84242944e-02f, 8.91270041e-02f, 6.53711110e-02f, 5.13921678e-03f,
  -8.51853564e-02f, -9.67340022e-02f, 2.78379675e-02f, 5.17200567e-02f, -3.53629962e-02f, 2.83906199e-02f, 8.61807689e-02f, 9.07226000e-03f, 1.02971554e-01f, -9.19830427e-03f,
  -4.64918558e-03f, -1.77046403e-01f, -1.73936281e-02f, -7.53710046e-02f, -3.99159081e-02f, -1.97486654e-02f, -1.06571227e-01f, -2.02057809e-02f, -1.24895230e-01f, -3.69907171e-02f,
  -1.91889945e-02f, -5.20214848e-02f, -2.06927881e-02f, -7.00502545e-02f, -5.98125383e-02f, 5.98481745e-02f, 7.00914674e-03f, -9.19946432e-02f, -9.72914845e-02f, -5.41181490e-02f,
  1.26699209e-01f, 5.66944517e-02f, -2.29564961e-02f, 3.27843800e-02f, 5.18806232e-03f, -1.54315606e-01f, -5.96613449e-04f, 5.76871680e-03f, -1.04610607e-01f, 1.45253122e-01f,
  1.12605669e-01f, 4.31979060e-01f, -1.17726006e-01f, 1.66983396e-01f, -9.89525542e-02f, -2.87690639e-01f, -2.94018894e-01f, -1.65564045e-01f, 3.55671868e-02f, 1.39987916e-01f,
  -1.37887531e-04f, -7.40859583e-02f, 1.54115437e-02f, -9.51605067e-02f, -1.90196782e-01f, 5.49620353e-02f, 9.07538980e-02f, -1.17104784e-01f, -4.23298746e-01f, -2.27711007e-01f,
  6.10042177e-02f, 1.58376783e-01f, 6.96025789e-02f, -6.14064857e-02f, 1.78019762e-01f, -4.04587798e-02f, 9.25954282e-02f, 7.40642771e-02f, 3.66582833e-02f, 4.04001534e-01f,
  2.79453471e-02f, -3.28644067e-02f, -2.07110018e-01f, -7.57500604e-02f, -1.11485168e-01f, -1.56974509e-01f, -7.16474280e-02f, -1.07590050e-01f, -1.14551291e-01f, -3.54377925e-02f,
  -7.78182149e-02f, -1.36359528e-01f, -1.10875502e-01f, -7.55448788e-02f, -3.48909087e-02f, -1.48240730e-01f, -8.06103274e-02f, -1.05755404e-01f, -1.05808266e-01f, -1.24629840e-01f,
  3.69991548e-02f, -1.38172001e-01f, -2.01192155e-01f, -8.95129591e-02f, -2.02645585e-01f, -2.05120534e-01f, -9.28025171e-02f, -1.06398232e-01f, -1.94468111e-01f, 1.18101031e-01f,
  3.67524475e-02f, 9.37926248e-02f, 1.27567157e-01f, 9.20865014e-02f, 6.50122464e-02f, 1.18381917e-01f, 4.99456301e-02f, 1.17811829e-01f, 7.67502561e-02f, 1.20174713e-01f,
  6.94904178e-02f, 8.25534835e-02f, 7.97176510e-02f, 6.51063249e-02f, 1.74076229e-01f, 3.70534807e-02f, 4.31877635e-02f, 8.73988569e-02f, -4.90949154e-02f, -4.38806824e-02f,
  7.05751553e-02f, 5.47364764e-02f, 6.64379820e-02f, 1.05091713e-01f, 3.69674303e-02f, 3.80319133e-02f, 3.67717482e-02f, 3.52239460e-02f, 1.14398949e-01f, 3.19762379e-02f,
  1.65626615e-01f, -2.57945329e-01f, -2.99868863e-02f, -1.62230924e-01f, -1.35118067e-01f, -6.19066209e-02f, 4.33379337e-02f, -7.27167279e-02f, -1.81551129e-02f, -6.86241165e-02f,
  -1.99263647e-01f, -1.12732686e-01f, 2.34343354e-02f, -6.88925087e-02f, -2.36281142e-01f, -2.03845993e-01f, 2.64313295e-02f, 9.37560853e-03f, -1.37571335e-01f, -6.74600899e-02f,
  8.00349340e-02f, -1.97791398e-01f, -1.51742876e-01f, -1.22277588e-01f, -1.52928472e-01f, -9.59272534e-02f, 1.30787725e-02f, -9.34669822e-02f, -1.24573849e-01f, 2.76609100e-02f,
  6.50678352e-02f, -3.73002023e-01f, 1.77588746e-01f, 7.67731443e-02f, -2.05308665e-02f, 1.17508382e-01f, -2.58944869e-01f, -9.19876471e-02f, 1.01465166e-01f, -6.48229048e-02f,
  5.23922332e-02f, 3.02692682e-01f, 2.53571182e-01f, 2.57325083e-01f, 8.65103453e-02f, -1.38978153e-01f, 3.62274423e-02f, 2.17535898e-01f, 3.66337329e-01f, 6.69747293e-02f,
  -8.01488608e-02f, -1.07929125e-01f, -7.21583962e-02f, 6.82892799e-02f, -4.41381745e-02f, 7.23854825e-02f, -6.06972463e-02f, -1.22545689e-01f, -3.92758399e-02f, -7.21817613e-02f,
  2.48032749e-01f, -2.04637960e-01f, 1.45274580e-01f, 1.44959753e-02f, 7.35321045e-02f, 4.18131761e-02f, 8.78645573e-03f, 3.86063196e-02f, -3.87733951e-02f, -5.97995035e-02f,
  5.09481542e-02f, 8.05196073e-03f, 4.72608842e-02f, 2.77514532e-02f, -1.03936940e-01f, 1.06552169e-01f, -9.36111510e-02f, 3.91111337e-02f, 1.21129125e-01f, -6.83014765e-02f,
  2.84253489e-02f, 4.35559563e-02f, 1.86489955e-01f, -5.43567026e-03f, -3.41359898e-02f, 1.49214014e-01f, -3.95406671e-02f, -1.80924125e-02f, 2.42358763e-02f, -1.21368503e-03f,
  2.14946419e-02f, -2.17886362e-02f, 1.85632613e-02f, -4.48575914e-02f, -1.13532497e-02f, -4.19509634e-02f, 4.75056581e-02f, -9.13285092e-02f, -1.16434898e-02f, -1.14628188e-01f,
  3.34179662e-02f, 8.79643261e-02f, -6.10000528e-02f, 2.10268013e-02f, -1.46972258e-02f, -4.32149856e-04f, 2.38366947e-02f, -3.85814197e-02f, 1.09252091e-02f, -6.00651167e-02f,
  5.50713465e-02f, 1.60211012e-01f, 1.27274152e-02f, -1.50398044e-02f, 5.29905744e-02f, -2.17823070e-02f, 3.25710550e-02f, 3.51945907e-02f, -3.53934765e-02f, 1.46469893e-02f,
  9.54833105e-02f, 6.78688362e-02f, 1.46333128e-01f, -1.33130392e-02f, -6.21045791e-02f, -1.40824681e-02f, 8.57461989e-02f, 6.64335117e-02f, -3.74300443e-02f, 7.25049525e-02f,
  -5.48769943e-02f, -3.18332165e-02f, -3.08361650e-02f, -4.13884372e-02f, 8.58421996e-03f, -1.84326358e-02f, -1.94671862e-02f, 1.68629423e-01f, 1.19874746e-01f, 4.61308211e-02f,
  5.81791885e-02f, 2.11118773e-01f, 2.31178388e-01f, 1.79713532e-01f, 8.61642137e-02f, 1.71434745e-01f, 1.97798416e-01f, 1.95803419e-01f, 1.95096180e-01f, -1.66899804e-02f,
  -2.11980507e-01f, -9.60048512e-02f, 2.58493334e-01f, -3.65828335e-01f, 1.98795035e-01f, 4.30882275e-01f, 4.77015436e-01f, 1.75034642e-01f, -2.83960462e-01f, -7.92260692e-02f,
  5.94808115e-03f, -9.09513161e-02f, -2.69845098e-01f, -1.48923859e-01f, 1.61416009e-01f, 3.12760510e-02f, 3.03515028e-02f, 8.62544402e-02f, 2.37521455e-01f, 2.20732898e-01f,
  5.21665998e-02f, -6.97628483e-02f, -1.99111290e-02f, -9.73857418e-02f, -2.26749673e-01f, -9.33973044e-02f, -1.64049745e-01f, -5.93145974e-02f, 2.03053311e-01f, -3.54617238e-01f,
  -1.70205049e-02f, 1.10530391e-01f, 4.38628830e-02f, -1.63797870e-01f, -2.30808593e-02f, -1.43112019e-02f, 6.97064847e-02f, -6.46208879e-03f, -2.45849583e-02f, -6.13009138e-03f,
  -4.69605662e-02f, -9.73190814e-02f, -9.38262939e-02f, -6.74329000e-03f, -1.18829384e-02f, -3.97627503e-02f, -8.88995975e-02f, -1.06876321e-01f, -8.49208012e-02f, -4.68447246e-02f,
  7.19569111e-03f, 9.44230035e-02f, 2.09222823e-01f, 1.06386498e-01f, 9.34037343e-02f, 1.48269236e-02f, 4.15127426e-02f, -4.22831178e-02f, 9.57547575e-02f, -1.17738962e-01f,
  -1.94834769e-02f, -3.03014554e-03f, 7.02584768e-03f, 5.25643267e-02f, -2.17394419e-02f, 1.82598028e-02f, -7.93668814e-03f, 3.86647992e-02f, 8.50652233e-02f, -3.98916714e-02f,
  1.03236169e-01f, 4.07160744e-02f, 4.75093685e-02f, 1.47309788e-02f, 4.47877161e-02f, 3.28198671e-02f, 8.26295987e-02f, 4.39339355e-02f, 1.07344128e-01f, 1.16237039e-02f,
  2.33219489e-02f, 1.12164589e-02f, -5.97359575e-02f, 1.26163289e-02f, 4.04397324e-02f, 3.60663347e-02f, 8.91127437e-02f, 1.31329343e-01f, 4.75758165e-02f, 7.42016509e-02f,
  -2.56251067e-01f, 1.25244915e-01f, -2.20092058e-01f, -3.04081887e-02f, -4.18236740e-02f, -1.53916135e-01f, -9.99212712e-02f, -1.32460773e-01f, -7.49215260e-02f, -8.32252130e-02f,
  3.52924168e-02f, 2.46694610e-02f, -9.86207649e-02f, -2.66758613e-02f, -7.70742074e-03f, -8.25937018e-02f, -1.66244254e-01f, -7.85761848e-02f, -1.94733329e-02f, -7.42772669e-02f,
  -5.57739846e-02f, 2.19529793e-02f, -4.82755750e-02f, -7.01290369e-02f, -4.19130549e-02f, -1.35157853e-01f, 3.32108438e-02f, -6.45325109e-02f, 9.95619446e-02f, -5.49291149e-02f,
  -2.10284412e-01f, -8.15623440e-03f, 2.52044797e-01f, 2.23291591e-01f, -1.92781821e-01f, -1.46955669e-01f, -1.54751018e-01f, 1.05304299e-02f, 1.41971901e-01f, 2.13939667e-01f,
  -9.69972089e-02f, 5.41332848e-02f, 1.82059452e-01f, 2.68484056e-01f, 1.32901341e-01f, 3.26573759e-01f, 2.90257215e-01f, 2.03990281e-01f, 1.31266773e-01f, 1.28047049e-01f,
  8.04287568e-02f, 1.55559599e-01f, 2.03405946e-01f, 2.57496923e-01f, 2.51958191e-01f, 2.36651987e-01f, 2.23252684e-01f, 7.36249089e-02f, 1.14397928e-01f, 3.20904046e-01f,
  3.99491370e-01f, -6.85797706e-02f, 1.00107275e-01f, 5.42438924e-02f, 2.51591057e-02f, 7.57808462e-02f, -2.12803762e-02f, 1.01112314e-01f, -5.68250269e-02f, 1.04445234e-01f,
  -1.05267912e-02f, 7.58690313e-02f, 1.14649847e-01f, 5.37616685e-02f, 7.16595212e-03f, -4.04195487e-02f, 1.24067843e-01f, 1.93081707e-01f, 1.15549684e-01f, -4.69638258e-02f,
  -1.43138878e-02f, -1.41434908e-01f, -7.47341514e-02f, 7.64934404e-04f, 1.36475384e-01f, 4.47429009e-02f, 2.18535005e-03f, 2.79012918e-02f, 6.23366833e-02f, 1.19136833e-01f,
  4.07664366e-02f, 2.86651757e-02f, -1.66713819e-02f, -9.65619907e-02f, -4.62624198e-03f, -1.17757782e-01f, 6.37011304e-02f, 6.98544234e-02f, -1.89726148e-03f, -2.93034092e-02f,
  -1.68303363e-02f, -1.23694785e-01f, 8.33223760e-02f, -3.24848294e-03f, 3.74370068e-02f, -1.02307074e-01f, -4.05775979e-02f, 6.06018603e-02f, -4.30974923e-02f, -2.68947911e-02f,
  -3.79782952e-02f, -3.92074697e-02f, -4.00340296e-02f, 4.80784476e-02f, -2.28371006e-02f, -3.09196562e-02f, 1.00028785e-02f, -2.45277118e-02f, -7.82251284e-02f, -1.21724121e-01f,
  1.23238221e-01f, -1.59109369e-01f, 1.90535963e-01f, 1.32174209e-01f, 2.65908986e-02f, 8.54488164e-02f, 3.63502838e-02f, 7.83298980e-04f, -3.65975276e-02f, 8.55043381e-02f,
  1.37981856e-02f, 1.54330865e-01f, 1.34566665e-01f, 6.97372183e-02f, 3.18252556e-02f, 9.16604102e-02f, 3.02457251e-03f, 6.77262023e-02f, 4.27951850e-02f, 8.40180218e-02f,
  9.49839279e-02f, -3.59256379e-02f, 6.75542727e-02f, -3.39725465e-02f, -1.86130665e-02f, 4.70514297e-02f, 6.86565712e-02f, 5.57959750e-02f, 8.93166140e-02f, 4.45653759e-02f,
  1.94916144e-01f, 2.80418158e-01f, 4.30669755e-01f, 2.51028180e-01f, 3.00280321e-02f, -8.51936191e-02f, -2.78488304e-02f, 9.58995819e-02f, 4.22994643e-02f, 1.03026114e-01f,
  -2.11417396e-02f, -6.80373311e-02f, -4.60337102e-02f, -6.82062879e-02f, -3.28225875e-03f, 2.50401199e-01f, 1.68002829e-01f, 1.63744196e-01f, -1.74732000e-01f, -1.40197754e-01f,
  -1.30237103e-01f, 8.06482732e-02f, 2.08875593e-02f, 1.79617167e-01f, 2.11227745e-01f, -4.34173383e-02f, 1.84540495e-01f, 1.14985518e-01f, 1.34486049e-01f, 3.62725735e-01f,
  1.08663172e-01f, 2.72489935e-01f, -5.06669655e-02f, 6.04372891e-03f, 2.52924133e-02f, 1.11130640e-01f, 4.63632867e-02f, 1.42735705e-01f, 5.87361008e-02f, 7.96156526e-02f,
  1.11800745e-01f, 4.38489765e-02f, 4.01916355e-02f, 4.74229734e-03f, 1.37972340e-01f, 8.75820369e-02f, 1.13629967e-01f, 1.26144245e-01f, 2.00391263e-01f, 1.37776271e-01f,
  1.14977099e-01f, 1.73804253e-01f, 6.11746535e-02f, 1.64530128e-01f, 1.13133602e-01f, -3.33587043e-02f, 1.48595855e-01f, 6.26756847e-02f, 1.21487997e-01f, 1.01968504e-01f,
  -9.81160402e-02f, -6.40644357e-02f, -1.15390584e-01f, -1.56725943e-01f, -1.60723746e-01f, -7.46042058e-02f, -1.89091899e-02f, -1.65351450e-01f, -2.22672060e-01f, -2.97824740e-02f,
  -3.50152589e-02f, -2.04974543e-02f, -4.49609645e-02f, -1.17140695e-01f, -1.56268179e-02f, 1.63337588e-03f, -6.68982342e-02f, -1.13455266e-01f, -2.57085208e-02f, -5.21428362e-02f,
  -9.43794250e-02f, -8.47165436e-02f, -5.04287295e-02f, -5.94719499e-02f, -9.63318124e-02f, -6.91183433e-02f, -1.20528534e-01f, -1.63521841e-01f, -1.68305665e-01f, -2.44935253e-03f,
  -2.58659832e-02f, 9.90758017e-02f, 1.04811788e-01f, 2.63970578e-04f, 1.15431048e-01f, 1.04620919e-01f, 6.05275445e-02f, 6.06706589e-02f, 1.82033673e-01f, 1.12115657e-02f,
  -9.66711342e-03f, 1.24567822e-01f, 1.53068855e-01f, 8.04754347e-03f, -2.47720182e-02f, -6.62088916e-02f, 8.97157341e-02f, 6.82041347e-02f, 3.88559997e-02f, 1.75384760e-01f,
  8.82455483e-02f, -2.35100444e-02f, -1.20473402e-02f, -6.36239909e-03f, 1.13879777e-01f, -8.05276260e-02f, -6.74352497e-02f, 3.33605148e-02f, -2.13527586e-02f, -2.17831656e-02f,
  4.24434721e-01f, -2.36813724e-01f, -4.28875983e-01f, 2.21827745e-01f, -7.92524219e-02f, -4.06484634e-01f, -5.20649374e-01f, -1.57252565e-01f, 6.05692230e-02f, -1.62589610e-01f,
  1.06275469e-01f, 3.69407237e-01f, 1.99138522e-01f, 1.00561425e-01f, -6.78813504e-03f, -3.12813967e-01f, -3.08709949e-01f, -2.89917346e-02f, 9.37328339e-02f, 1.21742032e-01f,
  1.57816097e-01f, 2.17269048e-01f, 1.39278799e-01f, 1.05744779e-01f, 1.35527635e-02f, 1.04734883e-01f, -2.54506290e-01f, 2.59372648e-02f, -2.21969798e-01f, 1.51032591e-02f,
  -5.96980238e-03f, -7.46143609e-02f, 6.06695935e-02f, 1.40469402e-01f, 6.88668573e-03f, 5.49817458e-03f, -5.34686148e-02f, -2.02817731e-02f, 1.01899154e-01f, -8.37995186e-02f,
  4.01176773e-02f, 8.17680880e-02f, 1.09147072e-01f, 5.64025454e-02f, 2.05599349e-02f, -5.70954755e-02f, -2.00682245e-02f, 1.67360604e-02f, -1.99943632e-02f, -5.47820926e-02f,
  -4.85389121e-02f, 5.79370148e-02f, -1.91934984e-02f, -1.89089462e-01f, -9.49756578e-02f, -5.86121576e-03f, -1.06400121e-02f, -2.79073790e-02f, -7.54722804e-02f, 6.48262128e-02f,
  8.13022554e-02f, -4.05814461e-02f, 2.18860433e-02f, 6.16763309e-02f, 1.98584106e-02f, -1.49091484e-03f, -6.25473261e-02f, 9.12084617e-03f, 2.51513887e-02f, -2.18322277e-02f,
  7.72115402e-03f, -4.44206037e-03f, 1.03054254e-03f, -3.13167833e-02f, 5.35434000e-02f, -5.35038114e-02f, -5.23796678e-02f, -3.20777744e-02f, -1.92400552e-02f, 3.41214761e-02f,
  7.76960701e-02f, -8.99589956e-02f, 5.95596023e-02f, -3.27484868e-03f, -6.85020834e-02f, -6.44617602e-02f, 2.46839728e-02f, 2.22976897e-02f, -9.81569570e-03f, 7.96320103e-03f,
  2.63294131e-01f, -1.96403757e-01f, 8.38737860e-02f, 3.58001217e-02f, -1.71705130e-02f, -1.48336831e-02f, 5.80594651e-02f, 8.03437680e-02f, -6.80539906e-02f, 1.30349612e-02f,
  -1.16704488e-02f, 3.04756537e-02f, -1.49385063e-02f, 2.28418224e-02f, 1.66077092e-02f, 4.08939868e-02f, 8.60037580e-02f, 8.48764554e-02f, 1.98269337e-02f, -1.63477268e-02f,
  3.61036770e-02f, 1.43273016e-02f, 8.50799829e-02f, -2.58892123e-02f, -2.73723006e-02f, 4.41880636e-02f, -8.39069560e-02f, -1.96943469e-02f, -4.39684978e-03f, -6.38214275e-02f,
  1.65651679e-01f, -1.64055731e-02f, -1.85988620e-01f, -1.62833095e-01f, -2.91410267e-01f, -2.33965237e-02f, 1.33957013e-01f, 1.07356019e-01f, -1.00692719e-01f, -5.11125252e-02f,
  -1.43501744e-01f, -1.12259723e-01f, -6.10247664e-02f, 1.20278366e-01f, 2.93425798e-01f, 2.55984157e-01f, 3.79234590e-02f, 1.92217916e-01f, 1.75960854e-01f, 1.17708921e-01f,
  1.20987117e-01f, 5.88806495e-02f, 3.95688564e-02f, 2.10246686e-02f, -7.78557807e-02f, -5.30796759e-02f, -2.19701156e-01f, -1.72888547e-01f, -1.07301645e-01f, -1.35253593e-01f,
  -4.33530062e-02f, -1.40587494e-01f, 1.79541223e-02f, 8.35049339e-03f, -1.84698656e-01f, -5.05422382e-03f, -5.50051332e-02f, -2.49618795e-02f, -1.10490903e-01f, 1.38331885e-02f,
  -1.19198784e-01f, -6.15229495e-02f, -1.45924777e-01f, -5.60198389e-02f, -1.42792780e-02f, -6.23005778e-02f, 2.20394507e-03f, 3.45091745e-02f, -1.00188605e-01f, -4.14205119e-02f,
  -9.46105644e-02f, -9.16507095e-02f, -1.58222467e-01f, -1.49590820e-01f, -1.00231722e-01f, -1.76550373e-01f, -6.77213818e-02f, -5.86788766e-02f, -1.49940819e-01f, 6.28863694e-04f,
  -4.78508063e-02f, -4.64777537e-02f, 5.45743257e-02f, 1.34621292e-01f, 1.43213287e-01f, 8.52486342e-02f, 3.25781340e-03f, 7.10114017e-02f, 7.67319724e-02f, 4.55003418e-02f,
  9.96891856e-02f, 8.66074339e-02f, 1.00000612e-01f, 6.41567186e-02f, 5.18247522e-02f, 6.15168922e-02f, -5.22703379e-02f, 1.67432085e-01f, 9.26616509e-03f, 1.21070080e-01f,
  1.48654118e-01f, -2.84942351e-02f, -3.76144536e-02f, 6.55483380e-02f, 5.61828129e-02f, -2.49687433e-02f, 9.19466987e-02f, -1.31007358e-02f, -4.20831069e-02f, 6.49242662e-03f,
  -1.08601391e-01f, -1.92605138e-01f, -1.65601913e-02f, -7.32920226e-03f, -8.03823099e-02f, -1.35089397e-01f, -7.53910318e-02f, -1.41102616e-02f, -1.84795633e-01f, -1.60065182e-02f,
  -9.44257602e-02f, -2.17838157e-02f, -1.33570313e-01f, -1.33598477e-01f, -4.71608862e-02f, -4.83195223e-02f, 7.87806809e-02f, -9.09109414e-02f, -2.83319633e-02f, -8.23764056e-02f,
  1.40896421e-02f, 8.55006427e-02f, 7.99046680e-02f, 1.69320852e-02f, -2.74033900e-02f, -4.18087468e-02f, 7.16499891e-03f, -1.25980049e-01f, -9.19103622e-02f, 1.77091911e-01f,
  1.71115473e-01f, -2.95000136e-01f, -2.73400564e-02f, -2.91652143e-01f, -1.39785990e-01f, -1.53716728e-02f, -2.64018863e-01f, -1.84960306e-01f, -1.08538039e-01f, -1.87739313e-01f,
  1.91831347e-02f, 1.28034353e-01f, 1.15008518e-01f, 1.74766421e-01f, 2.13160232e-01f, -2.51834005e-01f, -1.96630940e-01f, 1.95021510e-01f, 2.16299236e-01f, 2.24019945e-01f,
  -3.42598814e-03f, -1.27695650e-01f, 1.32727236e-01f, 5.52597977e-02f, -2.24540070e-01f, 1.85642764e-02f, -2.60329366e-01f, -1.13733038e-01f, 8.37834105e-02f, -1.45938888e-01f,
  1.35573015e-01f, -6.00680858e-02f, 6.05986603e-02f, -1.66593920e-02f, -1.48570225e-01f, -9.77833644e-02f, -7.10139945e-02f, -8.95850062e-02f, -8.68648887e-02f, -1.75105836e-02f,
  -7.03601260e-03f, -2.90540326e-02f, -2.63360441e-02f, -5.41885868e-02f, -1.10072501e-01f, -2.64243875e-02f, -4.15768735e-02f, -2.95740888e-02f, -6.80148900e-02f, 2.45507471e-02f,
  -9.52080488e-02f, -1.22364610e-02f, -3.22161950e-02f, -6.74153492e-02f, -6.44196197e-02f, -2.83772014e-02f, -4.30450812e-02f, 3.70689780e-02f, 8.37822780e-02f, -1.22855514e-01f,
  1.03620961e-01f, 1.82258878e-02f, 4.46834676e-02f, -1.63688436e-02f, 2.25480609e-02f, 6.59654941e-03f, 6.82959333e-03f, 7.12611973e-02f, 3.62148918e-02f, 1.06408717e-02f,
  5.11886477e-02f, 2.25281389e-03f, 6.52406141e-02f, -4.49768677e-02f, -1.93118136e-02f, -5.09234890e-02f, -9.36032310e-02f, -3.14590894e-02f, 2.93643624e-02f, -4.15579341e-02f,
  9.08160284e-02f, 4.90912683e-02f, -7.12233707e-02f, 8.11643153e-02f, -4.20381501e-02f, 3.99330035e-02f, -6.90241754e-02f, -5.64233176e-02f, -9.45691299e-03f, 1.54172415e-02f,
  -2.99261302e-01f, 8.38544741e-02f, -7.26988018e-02f, 8.84869918e-02f, -1.35601312e-01f, 2.53641196e-02f, -9.02362466e-02f, -4.66449708e-02f, -7.28930533e-02f, -1.05510477e-03f,
  8.07930604e-02f, -2.63903197e-02f, -2.07283814e-02f, -8.85631815e-02f, 7.30114803e-02f, -8.20475593e-02f, -1.45829439e-01f, -2.10601259e-02f, 7.16739986e-03f, -2.31750309e-02f,
  -1.40972689e-01f, -6.73976541e-02f, 5.97449727e-02f, -8.82369205e-02f, -3.82423326e-02f, -1.01601556e-02f, -8.50459486e-02f, -1.14465714e-01f, -7.11672977e-02f, -3.66799742e-01f,
  -3.12823623e-01f, 5.79009317e-02f, 3.32737565e-01f, -2.90426463e-02f, 1.37972087e-01f, 1.52252600e-01f, 5.68220690e-02f, -3.87206115e-02f, -1.21765241e-01f, 2.99277026e-02f,
  -7.36209676e-02f, -1.58277676e-01f, -2.26719826e-01f, -2.79636588e-02f, -7.85487890e-02f, 1.16684496e-01f, 2.56763130e-01f, 2.52164472e-02f, -3.29351728e-03f, 4.91105840e-02f,
  8.63147154e-02f, 1.16358727e-01f, -4.92904745e-02f, 1.00568607e-01f, 8.90268087e-02f, 8.42495933e-02f, 5.85096851e-02f, 7.07271621e-02f, 1.61603659e-01f, 3.04771841e-01f,
  -1.19081549e-01f, -1.37946069e-01f, -1.56698748e-01f, -1.43230394e-01f, 8.50524101e-03f, -7.11518675e-02f, -1.22603402e-01f, -1.33688673e-01f, -1.46210790e-01f, -8.63058120e-02f,
  6.97373878e-03f, -1.40941307e-01f, -2.70839855e-02f, -2.14757044e-02f, -9.53847095e-02f, -2.04621956e-01f, -1.49520218e-01f, -1.26643389e-01f, -8.90319273e-02f, -1.03121251e-01f,
  -5.04863150e-02f, 4.19215672e-02f, -5.21893576e-02f, -1.55155420e-01f, 7.97025103e-04f, -6.27481788e-02f, -1.02766067e-01f, -1.43425852e-01f, -2.83537824e-02f, -9.04768705e-02f,
  3.93814687e-03f, 5.88920750e-02f, 1.27528742e-01f, 1.02174900e-01f, 6.22394904e-02f, 5.10365462e-05f, 1.46658301e-01f, -3.72875598e-03f, -2.42308658e-02f, -4.22109589e-02f,
  -2.44539771e-02f, 1.35273308e-01f, -1.34403137e-02f, 4.18794826e-02f, 4.59601841e-04f, 1.19841516e-01f, 1.42598107e-01f, 8.12405944e-02f, 4.24038954e-02f, 6.83636665e-02f,
  -4.13657390e-02f, 6.96159974e-02f, 4.67170924e-02f, -3.30678793e-03f, 8.47338438e-02f, 7.22944140e-02f, 5.65460920e-02f, -3.95757146e-03f, 1.33641899e-01f, 4.95817028e-02f,
  -2.91969389e-01f, 4.77467552e-02f, -3.68405506e-02f, -1.79791957e-01f, 3.05398926e-03f, 1.73579939e-02f, -2.86787581e-02f, -5.25842682e-02f, 1.98967569e-02f, -1.86624806e-02f,
  -4.37177904e-02f, -4.60226052e-02f, -1.10867865e-01f, -1.17601179e-01f, -8.47982317e-02f, -3.21935713e-02f, 4.48743552e-02f, -6.44162521e-02f, -2.91181710e-02f, -5.63227199e-02f,
  2.79925410e-02f, -2.08020005e-02f, -5.91534227e-02f, -8.02307725e-02f, -1.45253316e-01f, -2.43532415e-02f, -6.90471977e-02f, -6.11706749e-02f, -6.38474301e-02f, -1.05810307e-01f,
  -1.83147177e-01f, -4.61077183e-01f, 1.35578394e-01f, -5.85702807e-02f, -2.44451910e-01f, -2.43079066e-01f, -2.54267603e-01f, -1.99029688e-02f, 3.91135924e-02f, -5.80347404e-02f,
  -3.53091881e-02f, 5.01656272e-02f, 1.65042028e-01f, 1.56825155e-01f, 7.81017095e-02f, -1.86848164e-01f, -2.18419105e-01f, 1.57569200e-02f, 2.04993114e-01f, 1.41097382e-02f,
  -8.54884982e-02f, -1.68902144e-01f, 2.53170580e-02f, 5.94655946e-02f, -1.16875790e-01f, -1.59988664e-02f, -9.39599499e-02f, -1.75431073e-01f, -7.94191286e-02f, -2.48558268e-01f,
  2.40093336e-01f, -2.23510310e-01f, 5.28370924e-02f, -1.24297395e-01f, 9.47162732e-02f, -1.12164347e-02f, -1.17116809e-01f, 6.44706562e-02f, 5.20429872e-02f, -2.15763394e-02f,
  -5.32358848e-02f, -1.25407586e-02f, -5.39785735e-02f, -7.38277063e-02f, -7.89296031e-02f, -4.08122689e-02f, -2.90798023e-02f, 1.23593109e-02f, 5.43788671e-02f, -6.01419061e-03f,
  -4.23121899e-02f, -2.12454110e-01f, -5.43247573e-02f, 3.27600539e-03f, 2.90924702e-02f, -2.34096535e-02f, -1.58874560e-02f, 6.00003684e-03f, 6.25348464e-02f, -1.77180544e-01f,
  1.04416542e-01f, 1.13377474e-01f, -1.03606062e-03f, -1.06203504e-01f, -2.39065085e-02f, 7.34292045e-02f, 3.38035114e-02f, 4.75133769e-03f, -4.07815762e-02f, -2.44474411e-02f,
  8.73452201e-02f, 1.26949936e-01f, 3.86193916e-02f, 1.13562055e-01f, -8.48762412e-03f, 6.05890295e-03f, -9.40076541e-03f, -3.73016521e-02f, 6.52446970e-02f, 8.52663293e-02f,
  -3.42806056e-02f, 2.58280113e-02f, 1.12028113e-02f, 9.81565639e-02f, 5.30835763e-02f, 1.56023307e-02f, -4.24646810e-02f, -2.93047056e-02f, 1.32437780e-01f, 9.05168336e-03f,
  5.35450205e-02f, 1.47583321e-01f, -1.15522414e-01f, -1.22782644e-02f, -6.94781691e-02f, 1.32739628e-02f, -2.49238014e-02f, -3.46474908e-02f, 2.43436340e-02f, -1.12970382e-01f,
  -7.34932125e-02f, -5.64806536e-02f, -7.56537691e-02f, -1.59278158e-02f, 3.97912078e-02f, 1.93726961e-02f, -1.05647966e-01f, -4.04760204e-02f, 3.06946095e-02f, -4.21491219e-03f,
  -1.87135950e-01f, -1.35286465e-01f, -1.02095760e-01f, -9.90299508e-02f, 9.87050589e-03f, -1.56053090e-02f, -2.17632316e-02f, -1.44915417e-01f, 1.51606807e-02f, -1.54171571e-01f,
  1.43266857e-01f, 2.23006248e-01f, -4.09084745e-02f, -8.80791694e-02f, -1.71416879e-01f, -2.56415065e-02f, 4.91937920e-02f, 3.07380091e-02f, -6.52150139e-02f, 6.18496537e-02f,
  2.07735643e-01f, 1.05688803e-01f, 1.27139568e-01f, 1.54403463e-01f, 7.55019411e-02f, -1.35047063e-01f, -2.41984740e-01f, -1.06726184e-01f, 8.82298127e-02f, 1.34993996e-02f,
  -7.10054766e-03f, -7.92571157e-02f, 1.11453623e-01f, -5.07828139e-04f, -1.29064903e-01f, -1.15324050e-01f, -1.20423824e-01f, -1.69726275e-02f, 2.60387883e-02f, -3.18981051e-01f,
  7.74993226e-02f, 1.93752021e-01f, 2.28630915e-01f, 8.42356980e-02f, 1.05662204e-01f, 1.47979528e-01f, 1.63764700e-01f, 7.89385363e-02f, -3.57711199e-03f, 1.14663370e-01f,
  2.92657726e-02f, 1.36468470e-01f, -8.01522192e-03f, 4.34801504e-02f, 7.31901778e-03f, 7.21460432e-02f, 7.98203424e-02f, -8.61086231e-03f, 4.51304540e-02f, 7.83534124e-02f,
  4.64958586e-02f, 7.74321780e-02f, 3.40118706e-02f, 6.38805106e-02f, 7.83786327e-02f, 5.67555092e-02f, 1.45221114e-01f, 1.09986670e-01f, 7.00874403e-02f, 1.34485699e-02f,
  -9.68672615e-03f, -1.04716748e-01f, -2.23620236e-01f, -5.58459796e-02f, -1.53259858e-01f, -1.97327211e-01f, -7.31863752e-02f, -9.48403478e-02f, -3.54511440e-02f, -9.99374166e-02f,
  -7.13620260e-02f, 1.29630615e-03f, -1.41163841e-01f, -1.49267897e-01f, -7.69484267e-02f, -1.27467647e-01f, -9.92207527e-02f, -1.22627050e-01f, -4.76587750e-02f, -1.26156017e-01f,
  -5.07094711e-02f, -1.01107165e-01f, -7.22443834e-02f, -1.73113272e-01f, -1.49027407e-01f, -1.05139218e-01f, -1.59714520e-01f, -1.56788141e-01f, -5.22831157e-02f, -5.97788729e-02f,
  1.01185270e-01f, 4.13895309e-01f, 8.78630430e-02f, 1.27594993e-01f, 1.18903682e-01f, 3.50047462e-03f, 1.39708966e-01f, 8.56575221e-02f, 1.59404889e-01f, 6.38444498e-02f,
  1.52314112e-01f, 1.36107400e-01f, 1.70659751e-01f, -5.54726506e-03f, 4.90365438e-02f, 1.15911774e-01f, 1.64509311e-01f, 2.60917731e-02f, 1.25757501e-01f, 1.56863667e-02f,
  1.45716324e-01f, 5.99274971e-02f, 1.45918489e-01f, 2.01639533e-01f, 1.22690246e-01f, 1.71005264e-01f, 1.73323408e-01f, 5.79193141e-03f, 2.54593015e-01f, 1.66541427e-01f,
  3.64188731e-01f, 1.74938112e-01f, -1.43576503e-01f, 2.44770706e-01f, 1.30520955e-01f, 2.04249784e-01f, 2.54812658e-01f, 1.49623528e-01f, 1.38101473e-01f, -2.06009373e-02f,
  1.47201136e-01f, -3.79894744e-03f, -1.01927131e-01f, -1.71223342e-01f, -1.85939148e-01f, -1.24929182e-01f, -2.37396747e-01f, -2.77523100e-01f, -7.93802440e-02f, 2.10993476e-02f,
  -1.58960670e-02f, -1.12268282e-02f, 4.26399708e-02f, -9.23009738e-02f, -8.45524445e-02f, -3.95399481e-02f, -1.42810330e-01f, 5.14516495e-02f, -7.06674233e-02f, -2.22116277e-01f,
  -2.89189309e-01f, 1.30380943e-01f, -1.05751216e-01f, 1.70103107e-02f, -8.47924575e-02f, 2.93499231e-02f, -8.02695900e-02f, -1.31132742e-02f, 3.00499219e-02f, -8.73682648e-02f,
  4.45638634e-02f, -8.66548568e-02f, -9.67741907e-02f, -5.89085035e-02f, 6.16626367e-02f, -8.11161771e-02f, -6.31509523e-04f, -3.50256450e-02f, -7.69879073e-02f, -1.43734897e-02f,
  -1.11903809e-01f, -2.57011643e-03f, 3.45585570e-02f, 1.53191769e-02f, -3.12132128e-02f, 2.05630641e-02f, 8.03982317e-02f, 1.51020493e-02f, 5.42501248e-02f, 3.64317857e-02f,
  -4.64732293e-03f, 1.40771031e-01f, -1.90093741e-02f, 7.09072500e-02f, 3.86498719e-02f, -5.19600231e-03f, -5.35704121e-02f, -1.85926557e-02f, -1.51090734e-02f, 5.56556275e-03f,
  -3.83298174e-02f, 6.52058516e-05f, -6.67630211e-02f, 4.29583117e-02f, -1.70801431e-01f, 7.76459128e-02f, -1.05666975e-02f, -6.36759028e-02f, -1.24962062e-01f, 6.12801537e-02f,
  -8.55934769e-02f, -4.06673849e-02f, 4.88004200e-02f, -9.07157660e-02f, -3.00796460e-02f, -1.30117517e-02f, -6.13279231e-02f, 4.79352884e-02f, 1.07442252e-01f, 9.58547369e-02f,
  -1.84022691e-02f, -1.49615537e-02f, -1.26660421e-01f, -9.68591869e-02f, -8.87102168e-03f, -1.01944253e-01f, -5.00663407e-02f, -1.70864955e-01f, -4.95300479e-02f, -6.51177466e-02f,
  -1.59479007e-02f, -3.90874036e-02f, -6.79912418e-02f, -1.07845645e-02f, -7.15454947e-03f, 3.85324359e-02f, -2.31213663e-02f, -5.11133205e-03f, -7.22296983e-02f, -5.52985538e-03f,
  -7.96598867e-02f, -1.13077788e-02f, 1.02044165e-01f, -6.99054375e-02f, 1.45419929e-02f, 2.12909337e-02f, -1.58115625e-01f, -9.65589751e-03f, -1.60920285e-02f, 1.60133895e-02f,
  1.21547453e-01f, -2.05279186e-01f, -2.76059419e-01f, 1.62511580e-02f, 6.36803955e-02f, -3.45801637e-02f, -1.91620097e-01f, 1.75448116e-02f, 9.03984979e-02f, -9.26483274e-02f,
  -2.07813736e-02f, -6.17133128e-03f, -1.69919387e-01f, -1.16583943e-01f, -2.34811783e-01f, -3.58752489e-01f, -2.44924098e-01f, -1.41583323e-01f, -8.56749415e-02f, -2.72316467e-02f,
  -5.23180291e-02f, 2.24758312e-02f, 4.64490764e-02f, 6.37619793e-02f, 5.22430763e-02f, 4.48836051e-02f, -3.25948000e-02f, 4.28783707e-02f, -4.21745144e-02f, 1.35529255e-02f,
  -1.33511111e-01f, 1.34884849e-01f, 5.40538244e-02f, 1.78769961e-01f, 2.09983870e-01f, 6.03604056e-02f, 4.03596796e-02f, 1.37821659e-01f, 2.12519243e-01f, 1.02089956e-01f,
  2.04681918e-01f, 6.63910806e-02f, 1.44947758e-02f, 1.17248006e-01f, 4.97258976e-02f, 1.54315323e-01f, 8.60064924e-02f, 6.97509795e-02f, 5.97480424e-02f, 3.44195403e-02f,
  6.71084970e-02f, 1.95652172e-01f, 3.58942077e-02f, 1.57354195e-02f, 1.67603195e-01f, 5.78799061e-02f, 1.60480946e-01f, 1.85874075e-01f, 1.00533411e-01f, 5.16817067e-03f,
  -1.09311916e-01f, -3.39231044e-02f, 2.30835453e-02f, -9.27324966e-03f, 4.67540845e-02f, 7.37730786e-02f, -9.70279574e-02f, -1.35852501e-03f, -4.43127751e-02f, -4.19474579e-02f,
  -1.06462866e-01f, -3.18430476e-02f, -1.92378890e-02f, -1.35493115e-01f, -2.05418915e-02f, -5.74310087e-02f, 1.05910050e-02f, -1.33121684e-01f, 1.02060405e-03f, 6.32744655e-02f,
  1.22315688e-02f, -7.97699466e-02f, -5.12738004e-02f, -9.12762284e-02f, -1.68058902e-01f, -8.78031403e-02f, -5.76991402e-02f, -2.88096033e-02f, -1.09789103e-01f, -5.80333099e-02f,
  7.98780844e-02f, 7.17857033e-02f, 4.02429663e-02f, 8.72172341e-02f, 6.03401996e-02f, 8.74458551e-02f, 1.46343425e-01f, 8.94080326e-02f, 2.07077771e-01f, 1.00332133e-01f,
  1.20733390e-02f, 8.27819034e-02f, 1.25867715e-02f, 7.99684301e-02f, 3.58179100e-02f, 7.32086971e-02f, 3.26501951e-02f, 5.58738001e-02f, 1.18996292e-01f, 4.45711017e-02f,
  -1.91156920e-02f, -4.36609685e-02f, 5.82733452e-02f, -2.57140771e-02f, 7.31323138e-02f, -5.65592665e-04f, -1.32637983e-03f, 6.08862527e-02f, 6.90806583e-02f, -1.58175547e-02f,
  5.32039285e-01f, 2.52545089e-01f, 2.02125236e-01f, 2.01252684e-01f, -1.80849344e-01f, -1.89176574e-01f, -3.77495348e-01f, -1.76391825e-01f, -2.45095510e-02f, 1.32334143e-01f,
  1.59103081e-01f, 1.30140796e-01f, 1.34609610e-01f, 7.87369981e-02f, -5.30398730e-03f, -2.15873286e-01f, -1.77411914e-01f, -3.80155072e-02f, -1.70657769e-01f, -1.36620730e-01f,
  -1.46327674e-01f, 1.21805882e-02f, 1.32629961e-01f, -2.72543058e-02f, 1.22937396e-01f, 5.79806305e-02f, 5.46849892e-02f, 1.16692923e-01f, -6.72327057e-02f, 1.48412272e-01f,
  2.96419293e-01f, 3.87317389e-01f, -4.76155095e-02f, 9.61884260e-02f, 1.49614975e-01f, 5.53958975e-02f, 3.79478224e-02f, 7.56522268e-02f, 8.47611129e-02f, 1.20372601e-01f,
  7.65481144e-02f, 7.71127045e-02f, 5.23610413e-02f, 5.63196931e-03f, 5.78629486e-02f, 1.38683422e-02f, 2.16575172e-02f, 1.09680951e-01f, 9.88648385e-02f, 8.47011879e-02f,
  8.18370283e-02f, 1.30086774e-02f, 1.92623317e-01f, 1.60223451e-02f, 1.24637939e-01f, 1.03106983e-01f, 5.54448701e-02f, 2.49406435e-02f, 1.71840396e-02f, 4.67120223e-02f,
  -1.51612625e-01f, 1.35480091e-02f, -5.07965758e-02f, 5.14379330e-02f, -6.85526431e-02f, -3.18414122e-02f, 3.00382003e-02f, -8.49295333e-02f, -6.75171763e-02f, -6.65500090e-02f,
  2.80333031e-03f, -1.20938458e-02f, -7.65290810e-03f, 1.82343554e-02f, -6.12044781e-02f, 1.16710868e-02f, 2.67472980e-03f, -2.49731750e-03f, 1.69457891e-03f, 4.78765741e-02f,
  4.75973636e-02f, 6.50833994e-02f, 4.27435478e-03f, -7.11607412e-02f, -2.84525659e-02f, -4.54899296e-03f, -3.82109359e-02f, 2.62168348e-02f, 4.86779436e-02f, 3.63356583e-02f,
  4.99862023e-02f, -5.23487143e-02f, -4.05762531e-02f, 7.31912777e-02f, 9.77525786e-02f, 3.79580520e-02f, 7.78418705e-02f, 4.61766012e-02f, 1.27970949e-01f, 1.84209682e-02f,
  9.27360505e-02f, 1.08579196e-01f, 5.28332219e-02f, -2.92259129e-03f, -3.34136561e-02f, -1.01901935e-02f, 4.16680705e-04f, -2.28866860e-02f, 4.86911647e-03f, 5.57609834e-02f,
  -6.84708729e-02f, -1.64946660e-01f, 1.10648843e-02f, -1.19598709e-01f, 9.01576318e-03f, -5.50738797e-02f, 1.64512750e-02f, -7.82839283e-02f, -1.35512903e-01f, -2.02978492e-01f,
  3.04380268e-01f, 1.78871304e-01f, 4.08581972e-01f, 1.50764316e-01f, 3.02253187e-01f, 1.59972697e-01f, 6.40994981e-02f, -1.60118729e-01f, -1.87572651e-03f, 1.55169562e-01f,
  1.93127155e-01f, -3.25161852e-02f, -4.35056277e-02f, -8.25808793e-02f, -1.95218250e-01f, 1.22162007e-01f, 5.29212803e-02f, 1.75157737e-03f, -4.16955054e-02f, -6.10029325e-02f,
  -1.14577830e-01f, 9.45402607e-02f, 6.34198785e-02f, 2.58654859e-02f, 9.12931934e-02f, 7.11398274e-02f, 2.22837135e-01f, 9.14117396e-02f, 6.63617775e-02f, 2.13869482e-01f,
  3.87303054e-01f, 2.00198784e-01f, 1.01449126e-02f, -9.13224965e-02f, 4.63482700e-02f, -6.48687184e-02f, 1.42427124e-02f, 5.67132188e-03f, 3.65041606e-02f, -2.88219228e-02f,
  1.13656662e-01f, 2.09237449e-02f, 8.84450674e-02f, 6.15568943e-02f, -1.19061326e-03f, 8.04022700e-02f, -2.58612242e-02f, -6.13284260e-02f, -5.38345277e-02f, 3.53860557e-02f,
  1.09181792e-01f, 1.67880744e-01f, 4.55305614e-02f, 2.86568161e-02f, -3.21924649e-02f, 1.10655539e-01f, 1.14618326e-02f, -3.37232389e-02f, 4.55562808e-02f, -6.80944473e-02f,
  1.47615131e-02f, -2.09758990e-02f, 1.37446383e-02f, -1.25923574e-01f, -8.82461201e-03f, -1.47119844e-02f, -3.61231938e-02f, 5.62217720e-02f, -1.96141265e-02f, -4.34478931e-02f,
  4.08413960e-03f, 6.67623058e-02f, -3.34277228e-02f, -9.90423653e-03f, 8.81484002e-02f, 7.54342675e-02f, -7.20585734e-02f, -8.09621066e-02f, 6.16402067e-02f, -1.38016734e-02f,
  -1.44990552e-02f, 1.27048499e-03f, 2.57364530e-02f, -2.61800680e-02f, 1.55157142e-03f, 4.79300693e-02f, 2.54062507e-02f, 5.98374754e-02f, 3.32903266e-02f, 1.13840938e-01f,
  -5.69100864e-02f, 8.59825239e-02f, -4.65514846e-02f, -1.55349880e-01f, 6.47787675e-02f, 9.29231942e-03f, 1.17701381e-01f, 3.22457477e-02f, 5.75660728e-02f, 1.35852575e-01f,
  -3.55068594e-02f, 7.24866092e-02f, 3.42920236e-02f, -2.60287393e-02f, 7.07062185e-02f, -2.87841372e-02f, -1.07968658e-01f, 9.16488748e-03f, 2.29565147e-03f, 7.71853402e-02f,
  -5.68969995e-02f, -3.73412892e-02f, -1.14163108e-01f, -2.94114351e-02f, -6.25637993e-02f, -6.03102259e-02f, -3.54146957e-02f, -4.74871509e-02f, -8.94288123e-02f, -1.41095027e-01f,
  -5.67087233e-01f, 2.89438725e-01f, 2.46532813e-01f, -1.33147046e-01f, 1.58825070e-01f, 1.69068456e-01f, 1.58540145e-01f, -7.27349287e-03f, -1.67513683e-01f, 1.06978178e-01f,
  -4.03048657e-02f, -6.15659803e-02f, -6.29664958e-02f, -6.04248513e-03f, 2.64313444e-02f, 9.73131061e-02f, 2.94056892e-01f, -4.75193523e-02f, -8.05074275e-02f, -6.86093345e-02f,
  4.07630168e-02f, -2.32035350e-02f, -2.14952394e-01f, 5.92673710e-03f, 2.59896033e-02f, -3.88282388e-02f, 2.07894504e-01f, 1.56056508e-01f, 2.60731429e-01f, 1.95802778e-01f,
  -5.29930927e-02f, -7.82528147e-02f, -3.43282558e-02f, -5.23756370e-02f, 1.14137672e-01f, -1.10364314e-02f, -6.84045767e-03f, -4.18328959e-03f, -1.58630628e-02f, -3.69520709e-02f,
  -2.14055693e-03f, 4.61064652e-02f, 6.51418567e-02f, -1.82351265e-02f, -1.27658341e-02f, 3.86118591e-02f, 1.66676547e-02f, 2.66288128e-03f, 1.91998128e-02f, -2.37882994e-02f,
  3.80498804e-02f, 1.09991230e-01f, -2.20875870e-02f, 3.56232487e-02f, 5.50910048e-02f, 4.27327044e-02f, 1.92616172e-02f, 3.73461246e-02f, -7.52920806e-02f, -1.40508398e-01f,
  -1.01157710e-01f, 2.47091111e-02f, 3.80869247e-02f, -2.42382102e-03f, 2.19021495e-02f, 1.26919188e-02f, 2.27913931e-02f, 9.47197899e-02f, 6.89133778e-02f, -1.11892112e-02f,
  8.01085532e-02f, -4.89697494e-02f, -2.37662159e-02f, -3.66389193e-02f, -2.73443181e-02f, 2.93255411e-02f, -2.18963977e-02f, -1.62774045e-02f, 2.10291427e-03f, -1.69025753e-02f,
  4.20942679e-02f, -2.42951848e-02f, -6.86357692e-02f, 2.55316086e-02f, 6.53534159e-02f, -3.94154899e-02f, -5.80938533e-02f, -2.45487434e-03f, 9.06640571e-03f, -8.81284624e-02f,
  -3.23808104e-01f, 2.16046959e-01f, -1.69242203e-01f, -1.43707424e-01f, -5.04392013e-02f, -5.07892482e-02f, 4.99352142e-02f, 4.54106331e-02f, -7.77289420e-02f, -4.24712487e-02f,
  -2.15372797e-02f, -1.14530742e-01f, -2.80428547e-02f, 7.37253800e-02f, 3.63767110e-02f, -7.24109858e-02f, -4.92567867e-02f, -1.03961386e-01f, 6.49162829e-02f, -1.98720973e-02f,
  -5.83036467e-02f, -9.10925213e-03f, -8.12912881e-02f, -2.41076201e-02f, -1.43693820e-01f, -2.05103889e-01f, -9.14076418e-02f, -1.73207417e-01f, -1.78978994e-01f, -8.57055411e-02f,
  -3.75343859e-02f, 4.45571244e-01f, 4.29666758e-01f, -4.09844257e-02f, -1.74081847e-01f, -1.35053292e-01f, -3.20195220e-02f, -9.99944881e-02f, -1.64159194e-01f, 1.32921502e-01f,
  1.22669891e-01f, -1.08147748e-01f, 8.37575048e-02f, 1.12609796e-01f, 8.57108012e-02f, 4.85565737e-02f, 7.68276379e-02f, -5.07262200e-02f, -1.47615165e-01f, -3.18442822e-01f,
  -1.29564509e-01f, -4.35253233e-02f, -4.06969525e-02f, 1.25151938e-02f, 1.03271410e-01f, 5.18598184e-02f, 2.09703520e-01f, 1.27066672e-01f, -5.00336029e-02f, 9.58366022e-02f,
  3.24825436e-01f, 7.66373724e-02f, -9.31378379e-02f, 2.92908978e-02f, 1.42754868e-01f, 1.02667227e-01f, 5.04251271e-02f, 1.85988665e-01f, 1.32128149e-01f, 6.14000000e-02f,
  2.92565618e-02f, 8.04769918e-02f, 9.59793255e-02f, 1.32808745e-01f, 3.37710008e-02f, 9.93223190e-02f, 8.16944465e-02f, 1.21461414e-01f, 6.82009310e-02f, 1.25325993e-01f,
  6.08753376e-02f, -3.14827748e-02f, 8.02384615e-02f, 1.42471701e-01f, 5.23321377e-03f, 4.10295874e-02f, 1.10456735e-01f, 5.69151603e-02f, 7.82653689e-02f, 6.30711392e-02f,
  -9.72797796e-02f, 7.81291127e-02f, -1.76832583e-02f, -1.72361676e-02f, -1.15019185e-02f, -1.03969559e-01f, 3.18429880e-02f, 1.03997700e-02f, 2.28215568e-02f, -2.67727450e-02f,
  2.41543911e-02f, -5.03331050e-02f, 2.90155094e-02f, -4.54648361e-02f, -5.93444146e-02f, 7.87764415e-02f, -1.07512593e-01f, 1.03735015e-01f, 4.36885618e-02f, 2.09698174e-02f,
  2.87205596e-02f, -7.22308382e-02f, -6.25984184e-03f, -5.47560900e-02f, -1.00154705e-01f, -4.16097268e-02f, -7.25968406e-02f, 4.86691222e-02f, -2.36812653e-03f, -5.08341901e-02f,
  2.25921348e-01f, 7.77686834e-02f, 1.14300221e-01f, 4.76591811e-02f, -2.31318232e-02f, 5.50993979e-02f, 1.42879654e-02f, -5.14021935e-03f, 1.69284478e-01f, 6.42026141e-02f,
  6.21218048e-02f, 8.26621205e-02f, 1.80518374e-01f, -4.01737392e-02f, -5.57518527e-02f, -1.60362143e-02f, 4.31219600e-02f, 1.49507578e-02f, 4.31449190e-02f, 1.15997322e-01f,
  5.76992817e-02f, -9.34008583e-02f, -3.08879856e-02f, 8.61733407e-02f, -1.40468432e-02f, -8.66601691e-02f, 1.35456398e-01f, -3.14483754e-02f, -5.14017791e-02f, 6.99557438e-02f,
  2.32590273e-01f, 1.87277064e-01f, -1.40178606e-01f, 4.95214872e-02f, 6.66735694e-02f, -1.32121906e-01f, -1.56692266e-01f, -8.80406201e-02f, 5.44082597e-02f, 9.28941462e-03f,
  1.77025452e-01f, 8.65363553e-02f, -2.17421055e-02f, 7.50266388e-02f, -5.18836677e-02f, -2.33598247e-01f, -1.57848641e-01f, -1.19664036e-01f, -1.89092770e-01f, -2.08189070e-01f,
  -6.95340261e-02f, -2.34674793e-02f, -6.62027001e-02f, 1.21674836e-02f, -6.40025586e-02f, -4.37770933e-02f, -6.38898043e-03f, -2.85216738e-02f, -7.59158432e-02f, -8.43767673e-02f,
  -2.38079295e-01f, 1.55121252e-01f, 1.01316601e-01f, 2.31579572e-01f, 3.04972827e-01f, 2.61849016e-01f, 2.75483668e-01f, 1.44428939e-01f, 1.88158467e-01f, 2.06714198e-01f,
  2.05812082e-01f, 2.74178356e-01f, 2.03452885e-01f, 7.13539645e-02f, 1.22516342e-01f, 1.33363888e-01f, 9.95100141e-02f, 1.17516451e-01f, 1.86069250e-01f, 1.33423403e-01f,
  2.58824378e-01f, 2.14552268e-01f, 1.65561974e-01f, 1.04878418e-01f, 1.34210750e-01f, 1.47806540e-01f, 8.69037434e-02f, 1.65331155e-01f, 3.26216631e-02f, 6.70022666e-02f,
  -1.65912524e-01f, -5.24275750e-02f, -1.54655650e-01f, -1.60559058e-01f, -1.10214856e-02f, -4.36001420e-02f, -1.24549091e-01f, -7.52263144e-02f, -2.16666326e-01f, -2.59675253e-02f,
  -1.24201722e-01f, -8.76250118e-02f, -1.85354799e-01f, -1.00911371e-01f, -4.96117473e-02f, -9.90446731e-02f, -1.49175361e-01f, -3.55750658e-02f, -6.32968768e-02f, -9.72305685e-02f,
  -4.81498912e-02f, -9.17773843e-02f, -4.70996983e-02f, -6.46610484e-02f, -4.34487052e-02f, -8.98821577e-02f, -1.56046629e-01f, -1.40040651e-01f, -8.79846960e-02f, -1.34614497e-01f,
  2.29051515e-01f, 1.91510111e-01f, 1.72833189e-01f, 2.36334562e-01f, 1.23896293e-01f, 2.73242444e-01f, 2.07752421e-01f, 1.50901809e-01f, 2.19745338e-01f, 1.08558930e-01f,
  1.04409337e-01f, 2.14519352e-01f, 1.64948210e-01f, 7.76353553e-02f, 6.82039857e-02f, 1.33755326e-01f, 2.52450645e-01f, 1.36712521e-01f, 2.09122121e-01f, 1.91108271e-01f,
  2.49712676e-01f, 8.00509229e-02f, 1.16390251e-01f, 1.23457819e-01f, 1.53005123e-01f, 2.27779359e-01f, -8.74472503e-03f, 3.85191441e-02f, 1.13838956e-01f, -6.14196248e-02f,
  -1.30112946e-01f, 1.35875925e-01f, -1.86418086e-01f, -1.07798986e-01f, 7.06588104e-02f, 1.24546401e-01f, 5.91000393e-02f, 5.86621910e-02f, -4.61605564e-02f, 8.18008780e-02f,
  2.10948139e-01f, 3.23878080e-01f, 1.87364593e-01f, 4.52471413e-02f, 1.46371033e-02f, -1.42500028e-01f, -2.05990806e-01f, -2.06764653e-01f, -7.70703750e-03f, 3.19931586e-03f,
  5.32685034e-02f, -7.22717717e-02f, -1.71594158e-01f, -7.03133941e-02f, -3.93906198e-02f, 2.26917434e-02f, -1.54011384e-01f, -9.63869914e-02f, -9.21404585e-02f, -1.21486671e-01f,
  5.76653220e-02f, -1.26329333e-01f, 9.40505117e-02f, 1.44613177e-01f, -3.50714661e-02f, -2.32534055e-02f, 6.32041767e-02f, -9.36286151e-02f, 1.00875646e-01f, -1.01960577e-01f,
  2.24081539e-02f, 4.53973748e-02f, 3.21293622e-02f, -2.16892902e-02f, -2.08089799e-02f, 5.55133522e-02f, -7.07176886e-03f, -1.26869768e-01f, -1.86887737e-02f, -2.62507889e-02f,
  1.53325006e-01f, -8.22232068e-02f, -4.24686931e-02f, -4.39807400e-02f, -4.40690294e-02f, -1.58646386e-02f, 6.10455945e-02f, 1.40213482e-02f, -6.68368787e-02f, -8.00850466e-02f,
  3.53532424e-03f, -1.93566608e-03f, 5.61428536e-03f, -1.46575328e-02f, -5.57028763e-02f, -2.75834836e-02f, -7.88893476e-02f, 1.11733116e-02f, -6.55725747e-02f, -4.73386012e-02f,
  -3.47543648e-03f, -4.18372825e-02f, 2.50420384e-02f, 2.74058082e-03f, 1.48376171e-03f, -4.60324362e-02f, -5.97465374e-02f, 9.12185237e-02f, 1.48293311e-02f, -9.41484720e-02f,
  -9.44541618e-02f, 3.65035085e-04f, -7.01333433e-02f, 1.81378815e-02f, -1.06274597e-01f, -1.15675651e-01f, 3.87925655e-03f, 6.38736859e-02f, -7.39168897e-02f, -1.13639288e-01f,
  3.99813473e-01f, 4.85291258e-02f, 1.15875825e-01f, 2.84059122e-02f, -5.35015687e-02f, 3.60317603e-02f, 2.55237054e-02f, -1.69127749e-03f, 8.54451135e-02f, 6.41230494e-02f,
  9.86093134e-02f, 2.82311197e-02f, -6.47588586e-03f, -4.21215184e-02f, 4.02146988e-02f, 3.34652290e-02f, 2.05909312e-02f, 6.20158091e-02f, 4.88154255e-02f, 8.27508494e-02f,
  5.96820302e-02f, 1.22792386e-01f, 8.06361958e-02f, 1.33185476e-01f, 5.97668216e-02f, 1.92093045e-01f, 6.64142296e-02f, 8.17583650e-02f, 1.09695598e-01f, 1.10030428e-01f,
  1.63480669e-01f, -8.28339085e-02f, -1.07876910e-02f, -2.57026404e-01f, -9.35932845e-02f, 8.17967504e-02f, 2.40037829e-01f, 1.84688032e-01f, -1.45743296e-01f, -1.40850917e-02f,
  -1.48947433e-01f, -8.07886645e-02f, 1.79488733e-02f, -5.28294928e-02f, 2.03101844e-01f, 8.89149830e-02f, -2.07182970e-02f, -3.58895585e-02f, 1.63238216e-02f, 3.89045775e-02f,
  -1.79123387e-01f, -1.46319792e-02f, -3.19010392e-02f, -1.97479799e-01f, -2.18009025e-01f, -1.05446689e-01f, -1.94156632e-01f, -1.98473260e-01f, -1.15128867e-01f, -3.23040664e-01f,
  -8.88457969e-02f, -2.14512587e-01f, -1.16676897e-01f, -1.52919486e-01f, -1.05864994e-01f, -1.10699698e-01f, -8.53909776e-02f, -2.45937422e-01f, -4.85125631e-02f, -1.70478970e-01f,
  -1.62039772e-01f, -1.58604175e-01f, -9.93245244e-02f, -8.75781104e-02f, -8.30846429e-02f, -4.88111600e-02f, -1.85727671e-01f, -3.45070846e-02f, -9.31931958e-02f, -4.47138287e-02f,
  -2.20587865e-01f, -5.94368614e-02f, 5.34782521e-02f, 3.47219668e-02f, -1.44473016e-01f, -7.28738979e-02f, -1.09819338e-01f, -1.39484316e-01f, -1.13825724e-01f, -1.33259892e-01f,
  -4.19595093e-02f, 5.29687926e-02f, 1.01247512e-01f, 1.80615745e-02f, 1.55496389e-01f, 9.66302305e-02f, 4.97057475e-02f, 8.27447101e-02f, 5.47560900e-02f, 8.19962695e-02f,
  3.80855687e-02f, 1.73537403e-01f, -4.43836721e-03f, 1.13768816e-01f, 1.20641757e-02f, 1.25300795e-01f, 6.17534779e-02f, 1.31510526e-01f, 3.17267701e-02f, 1.12921193e-01f,
  1.51418373e-01f, 6.10747673e-02f, -3.46724316e-02f, 5.82348742e-02f, 4.02250178e-02f, 4.69949655e-02f, 7.62227625e-02f, 8.41346011e-02f, 1.71037838e-01f, 3.34621780e-02f,
  6.44252822e-02f, -4.04540114e-02f, -3.58336121e-02f, 1.23789813e-02f, -1.56700701e-01f, -7.69366026e-02f, -1.68400675e-01f, -1.13326758e-01f, -1.84638530e-01f, 4.80806641e-03f,
  -4.10593599e-02f, -2.97731329e-02f, -8.93353522e-02f, -1.04539588e-01f, -3.26813906e-02f, 9.82094929e-03f, -1.23490477e-02f, -1.72702949e-02f, -2.91526914e-02f, -9.86149386e-02f,
  -6.62299991e-02f, 9.22878906e-02f, 1.83201298e-01f, -3.32281590e-02f, -1.15827367e-01f, 1.37442425e-01f, -7.66153494e-03f, 7.14125484e-02f, 1.00154333e-01f, 4.60743569e-02f,
  -4.98221308e-01f, -5.35131618e-02f, 2.58541077e-01f, -2.64692456e-01f, 2.56258696e-01f, 3.59315693e-01f, 3.82563263e-01f, 9.82081220e-02f, -1.43796831e-01f, -1.11808173e-01f,
  -2.27899048e-02f, 1.91243365e-02f, 3.45158167e-02f, 3.61708342e-03f, 1.61556631e-01f, 1.86519638e-01f, 1.26903877e-01f, 8.30341056e-02f, 9.15670022e-02f, 1.59445643e-01f,
  -3.58271189e-02f, -1.42364338e-01f, -3.58796626e-01f, -1.96210563e-01f, 3.39566544e-02f, 8.35417062e-02f, -5.48070371e-02f, -8.52286369e-02f, 4.27656360e-02f, -7.66748041e-02f,
  1.02725804e-01f, -1.97500333e-01f, 9.64017734e-02f, -1.86347086e-02f, -3.65645369e-03f, -2.46465579e-02f, 3.81482355e-02f, -9.78100598e-02f, -4.09482606e-02f, 2.26368271e-02f,
  4.00146283e-02f, -5.80853298e-02f, 8.96391459e-03f, 4.58461381e-02f, 6.75934926e-02f, -6.68859780e-02f, -1.50266245e-01f, -1.77738871e-02f, 3.65326479e-02f, 6.14045300e-02f,
  -3.00867148e-02f, 2.14796234e-02f, 2.14195158e-02f, 1.36183128e-01f, 6.95401505e-02f, 1.21941969e-01f, 1.07540257e-01f, 7.65827969e-02f, -2.92493831e-02f, -1.59069821e-01f,
  2.46328972e-02f, 5.28769083e-02f, -1.24999411e-01f, 1.16329556e-02f, -6.75462782e-02f, -1.84789170e-02f, 8.17602351e-02f, -5.01327850e-02f, 4.67514945e-03f, -8.16433206e-02f,
  -4.46156971e-02f, -2.28141248e-02f, 1.36763407e-02f, -6.03967942e-02f, -1.04098851e-02f, 2.76126601e-02f, 8.10455903e-02f, -8.45170617e-02f, 8.52943491e-03f, -7.10382313e-02f,
  -5.95296025e-02f, 3.53710800e-02f, -3.35201323e-02f, -1.54880723e-02f, -6.38631657e-02f, -4.75218408e-02f, -1.48444334e-02f, -8.94246846e-02f, -3.64213027e-02f, -1.08826317e-01f,
  -7.71246552e-02f, 6.19238131e-02f, 1.14172651e-02f, -4.83179018e-02f, -4.16162536e-02f, -1.76675385e-04f, -1.86709315e-02f, -7.32676778e-03f, -5.08409813e-02f, -4.79430519e-02f,
  -6.46544993e-02f, 3.15102898e-02f, -1.37915639e-02f, -8.24622717e-03f, 2.35084444e-02f, 8.09154734e-02f, -4.98427600e-02f, 1.05180480e-02f, 2.36985441e-02f, 5.28838746e-02f,
  -3.88992764e-02f, 1.19149938e-01f, 1.54836848e-01f, 1.01991780e-01f, -3.54231894e-02f, 1.94946259e-01f, 6.97200298e-02f, 4.57019210e-02f, 1.86384499e-01f, 7.21528158e-02f,
  -3.12604934e-01f, 7.46417940e-02f, -4.56035994e-02f, -2.85881847e-01f, -2.03339964e-01f, -2.25525916e-01f, -2.46086001e-01f, -1.21740200e-01f, -1.48661867e-01f, 4.55240496e-02f,
  -4.30711582e-02f, 1.17848307e-01f, 1.23653514e-03f, -4.69855554e-02f, -1.36492968e-01f, -6.49201544e-03f, -1.71936095e-01f, -1.50076628e-01f, -2.78507862e-02f, 5.28742298e-02f,
  -6.74492046e-02f, -1.07197918e-01f, -8.16289559e-02f, -1.41059667e-01f, 6.50051758e-02f, 9.73094702e-02f, -4.81640622e-02f, -3.08356173e-02f, 1.41665727e-01f, 1.83729440e-01f,
  1.05860330e-01f, 1.10608809e-01f, -1.03090480e-01f, -1.02835119e-01f, -4.33209464e-02f, 8.53861496e-02f, 3.65645811e-02f, 4.86724228e-02f, 2.10873014e-03f, -6.64940104e-02f,
  -9.22591658e-04f, 6.95783123e-02f, -7.22756833e-02f, 4.84602116e-02f, -3.05218454e-02f, 9.57037415e-03f, -1.35203391e-01f, 4.14430648e-02f, -1.26609117e-01f, 1.15547121e-01f,
  -6.18609898e-02f, -1.29781261e-01f, -1.99550942e-01f, -2.56495513e-02f, -6.01555184e-02f, -1.27037600e-01f, -7.07897097e-02f, 2.25575827e-02f, -8.49868283e-02f, -7.43356207e-03f,
  5.04392609e-02f, 1.46230767e-02f, -4.31949459e-03f, 4.12890129e-02f, -4.29153554e-02f, 3.85583639e-02f, 3.55749987e-02f, 1.04740292e-01f, 3.44414038e-05f, 7.43302796e-03f,
  -2.27834675e-02f, 1.23565476e-02f, 4.65073809e-02f, 1.09673813e-01f, -1.48247527e-02f, -7.63275996e-02f, 1.28900399e-02f, 3.32909711e-02f, -6.44650832e-02f, -6.58069253e-02f,
  5.88065498e-02f, -5.87299913e-02f, 2.54921746e-02f, 3.34591530e-02f, 4.47986182e-03f, -2.57074181e-02f, 2.11925041e-02f, -2.14493126e-02f, -6.11684918e-02f, -1.52632230e-04f,
  -1.05962738e-01f, -2.65741885e-01f, 1.27479946e-02f, 9.41510499e-03f, 3.62141691e-02f, -9.35285240e-02f, 1.56340692e-02f, -7.64400288e-02f, -1.40815228e-02f, -6.56096963e-03f,
  -8.94918218e-02f, 2.61162221e-03f, -7.28415176e-02f, -1.08010620e-02f, -6.18343381e-03f, 2.15841946e-03f, -1.71841249e-01f, -8.66515711e-02f, -1.13336965e-01f, -2.98953094e-02f,
  -1.51976570e-01f, -2.33393416e-01f, -2.60098577e-01f, -1.74359828e-01f, -1.85403246e-02f, -1.59796521e-01f, -9.48107764e-02f, 1.69512611e-02f, -6.96057081e-02f, -1.15589440e-01f,
  -3.28830361e-01f, 3.56159985e-01f, 1.47313505e-01f, -1.14785761e-01f, -6.98594237e-03f, -1.73891503e-02f, 1.61613807e-01f, -8.82802904e-03f, -8.76320899e-02f, 8.13265294e-02f,
  6.82827309e-02f, -1.55037850e-01f, -1.20841540e-01f, -1.32681310e-01f, 4.45525125e-02f, 1.30990624e-01f, 7.26747364e-02f, -1.93470240e-01f, -2.72580355e-01f, -2.02435225e-01f,
  -1.37128681e-01f, -2.31400132e-01f, -2.33194441e-01f, -4.54842336e-02f, 1.18757077e-02f, -1.41654491e-01f, 7.87636116e-02f, 4.91569377e-02f, 3.60869803e-03f, -1.51722714e-01f,
  1.30128264e-01f, 1.40421391e-01f, -9.80579406e-02f, -1.58872604e-02f, 3.82182300e-02f, 3.74938473e-02f, 8.31937566e-02f, -1.15229841e-02f, 1.31074816e-01f, -3.14679407e-02f,
  9.25260708e-02f, 4.21115346e-02f, -1.43108368e-02f, 1.02333520e-02f, -5.08944467e-02f, 3.41416225e-02f, -5.48015386e-02f, -2.62949336e-02f, 9.17295888e-02f, 7.79186040e-02f,
  -7.72706990e-05f, -5.50708473e-02f, 8.23222101e-03f, 1.83620483e-01f, 1.22802816e-01f, -1.06969170e-01f, 1.81103975e-01f, -5.39586693e-03f, -9.10082366e-03f, 6.70932829e-02f,
  -1.26522742e-02f, 1.78535134e-02f, 2.08726805e-02f, 4.20335447e-03f, 9.02235229e-03f, 1.83259733e-02f, -3.58399400e-03f, -5.20808110e-03f, 4.08057943e-02f, 3.16036195e-02f,
  6.45548925e-02f, 6.83804601e-02f, 1.64970011e-02f, 1.40956044e-01f, 5.65095693e-02f, -4.69169468e-02f, 6.55068010e-02f, 6.97638886e-03f, 5.29553406e-02f, -5.61661683e-02f,
  1.42012322e-02f, -3.62653956e-02f, 1.89864021e-02f, -2.91698109e-02f, -4.29326855e-02f, -3.31564248e-02f, 2.90929060e-02f, 2.49677338e-03f, -3.20638046e-02f, -9.46832523e-02f,
  -1.35975145e-02f, 5.77217676e-02f, 1.97536536e-02f, 2.56940722e-02f, 3.04383058e-02f, 1.21976897e-01f, 1.01701632e-01f, -1.24453129e-02f, 7.55932331e-02f, -2.22303476e-02f,
  1.41364783e-01f, -1.16564082e-02f, 9.39435884e-02f, 4.54665348e-02f, 4.36738543e-02f, 3.07694860e-02f, 9.82457250e-02f, -5.63977733e-02f, -1.82000659e-02f, 8.94929320e-02f,
  5.15586101e-02f, -7.02036992e-02f, 5.60788554e-04f, 8.54669064e-02f, 8.19577426e-02f, -1.10466264e-01f, 1.27104491e-01f, 6.36317283e-02f, 1.39022293e-02f, 1.84432834e-01f,
  1.90148205e-01f, 1.73233356e-02f, 3.91994826e-02f, -6.10140748e-02f, -1.54526040e-01f, -1.45625189e-01f, -3.10791761e-01f, -1.29521236e-01f, 8.91402513e-02f, -4.28294539e-02f,
  3.88731621e-02f, 1.10669851e-01f, -6.19808026e-03f, 6.91974610e-02f, 7.92564154e-02f, -1.60204127e-01f, -1.88435972e-01f, -8.87264982e-02f, -6.41649961e-02f, -7.66736344e-02f,
  -2.35206246e-01f, -1.16257265e-01f, -4.96554226e-02f, -4.32485156e-03f, 3.04679852e-02f, 5.79373278e-02f, -2.19316464e-02f, -3.28037776e-02f, 9.12195668e-02f, 7.84130320e-02f,
  -1.03907153e-01f, 1.15699746e-01f, -1.40433073e-01f, 3.26154083e-02f, -3.56117077e-02f, -4.56474163e-02f, -1.29024640e-01f, 6.92618638e-02f, 4.14960943e-02f, -4.94931005e-02f,
  4.30408530e-02f, -1.05123185e-01f, -1.21277906e-01f, -1.77880228e-02f, -6.37547225e-02f, -8.86021107e-02f, -4.55077775e-02f, 5.44816591e-02f, -2.88827661e-02f, 5.63988686e-02f,
  -2.81177256e-02f, -4.81985547e-02f, -1.16158724e-01f, -6.65907562e-02f, 1.58213437e-01f, 6.86649680e-02f, -1.68634541e-02f, 1.23079251e-02f, 1.19670689e-01f, -3.78132053e-02f,
  -1.02633491e-01f, 3.80957611e-02f, 9.18242708e-02f, 3.13063078e-02f, -2.40811221e-02f, -3.73809859e-02f, 3.01397704e-02f, 5.14004305e-02f, -3.98934148e-02f, -5.39441779e-02f,
  2.64528710e-02f, 1.05044998e-01f, -1.55398054e-02f, 6.41780123e-02f, 6.89617991e-02f, 6.25967085e-02f, -8.48830864e-03f, 3.71247865e-02f, 6.20246492e-02f, 1.08466238e-01f,
  9.05343443e-02f, 4.79169302e-02f, -2.86232866e-02f, 6.55452535e-02f, 1.01680748e-01f, -8.82873937e-05f, 8.62972140e-02f, 1.18333697e-01f, 8.56331289e-02f, 8.52337256e-02f,
  -2.70769507e-01f, 1.81571748e-02f, -8.68490431e-03f, -4.47557457e-02f, 2.45720986e-02f, -1.80389192e-02f, 6.83740228e-02f, -3.65685858e-02f, -4.25485298e-02f, -2.55727116e-02f,
  -1.13535800e-03f, 5.08840047e-02f, 1.80082135e-02f, -1.26205474e-01f, -1.83414817e-01f, -1.01707801e-01f, -1.07978940e-01f, -1.33487768e-02f, -2.15896722e-02f, -6.38152435e-02f,
  -5.38173988e-02f, -1.11006893e-01f, -3.94622721e-02f, -1.37668446e-01f, -3.48544270e-02f, 2.67824456e-02f, -6.47297502e-02f, -5.31201288e-02f, -1.09152630e-01f, -2.93798804e-01f,
  -2.25761861e-01f, -2.50813723e-01f, -2.24954277e-01f, -1.60155520e-01f, -1.95789486e-01f, -9.56743285e-02f, -2.28791341e-01f, -1.04142644e-01f, -3.18981409e-02f, -1.69468477e-01f,
  -3.55120338e-02f, 2.41316389e-02f, 2.37965770e-02f, -4.12592525e-03f, -5.85993491e-02f, -1.60022050e-01f, -7.20677227e-02f, 7.22311363e-02f, 4.62881774e-02f, -8.46912488e-02f,
  -7.64323920e-02f, -6.71785101e-02f, -9.19537619e-02f, -1.42719345e-02f, -1.19744185e-02f, -7.93899223e-02f, -4.24068533e-02f, -1.56530868e-02f, -1.53098805e-02f, -2.08922043e-01f,
  -2.10847512e-01f, -8.95053223e-02f, 2.15464622e-01f, 6.91511557e-02f, 5.25315255e-02f, 7.40448833e-02f, 4.40271990e-03f, 2.08277762e-01f, 7.67032802e-02f, 1.05017573e-02f,
  7.25531429e-02f, 5.22454269e-02f, 3.21379900e-02f, 8.37089568e-02f, 8.00038204e-02f, 2.20806152e-02f, 1.16696261e-01f, 3.56037691e-02f, 4.23562676e-02f, 9.07764118e-03f,
  2.48376075e-02f, -1.11009680e-01f, 3.33509520e-02f, 1.29310563e-01f, 1.59876253e-02f, 2.15100795e-02f, 5.80290556e-02f, 1.06077954e-01f, 1.17740817e-01f, 5.69613688e-02f,
  6.45156056e-02f, 3.73656712e-02f, 5.30198738e-02f, 1.23216221e-02f, 8.53953511e-02f, 4.30680923e-02f, 4.25535142e-02f, 1.44263394e-02f, 1.50481891e-02f, 2.83141471e-02f,
  3.79398055e-02f, -1.02716930e-01f, 2.80446224e-02f, -8.55970457e-02f, -7.64215887e-02f, 2.51443963e-02f, -9.64366794e-02f, -4.50327732e-02f, 9.89267528e-02f, -4.26891819e-03f,
  3.16497982e-02f, 2.01153159e-02f, -2.46547293e-02f, 1.40873343e-01f, -7.98747241e-02f, -3.35011110e-02f, -1.08865723e-02f, 3.47294211e-02f, -4.07471769e-02f, 2.72723902e-02f,
  1.44164726e-01f, 1.34563178e-01f, -1.52488267e-02f, 9.91799980e-02f, 2.95548979e-02f, 1.38064414e-01f, 2.15646718e-02f, 1.45993620e-01f, 3.41367139e-03f, 8.38656873e-02f,
  2.84562949e-02f, 1.34317860e-01f, 3.70031931e-02f, 6.76500946e-02f, 1.57747731e-01f, 1.53908968e-01f, 9.38832462e-02f, 5.60642630e-02f, 6.05993047e-02f, 4.56994735e-02f,
  7.72364065e-02f, 1.73218712e-01f, 2.16116682e-01f, 1.68241218e-01f, 8.79245475e-02f, 1.51757568e-01f, 1.20722160e-01f, 1.93823233e-01f, 1.35480627e-01f, 1.64391682e-01f,
  -4.15384352e-01f, -3.21439832e-01f, 3.02598953e-01f, -1.78519204e-01f, 1.90197825e-01f, 1.14217021e-01f, 2.01120958e-01f, -1.25105351e-01f, -1.41328603e-01f, 1.04693346e-01f,
  1.27993762e-01f, 2.43007783e-02f, 1.23410486e-02f, 7.00751022e-02f, 6.93569183e-02f, 2.61862308e-01f, 2.84610927e-01f, 2.47503683e-01f, 2.39794597e-01f, -1.13728261e-02f,
  -1.45889804e-01f, -8.67699012e-02f, -7.02927038e-02f, -2.60001551e-02f, -1.19572930e-01f, 8.30277503e-02f, 2.69379877e-02f, -7.70962834e-02f, 1.54043078e-01f, 1.22988470e-01f,
  1.29760116e-01f, -3.83468151e-01f, 1.12527847e-01f, -1.48046747e-01f, 2.44066101e-02f, -8.00264776e-02f, 3.87142934e-02f, -7.90059566e-02f, -1.18551135e-01f, -7.27419034e-02f,
  -2.69110072e-02f, -9.96092483e-02f, -1.32944554e-01f, -1.37934595e-01f, -2.30304766e-02f, -7.78446868e-02f, -6.11053454e-03f, -3.34523357e-02f, -7.02256039e-02f, -7.55077302e-02f,
  -4.95293876e-03f, -9.49984193e-02f, -5.37512861e-02f, 4.98768091e-02f, -1.27682492e-01f, -1.24459220e-02f, -7.52859265e-02f, -7.65246823e-02f, 2.04684678e-02f, -8.07741582e-02f,
  8.05399716e-02f, 1.82661325e-01f, 9.68104601e-02f, 7.55017027e-02f, 1.24282621e-01f, 8.84705409e-02f, 1.19559392e-01f, 6.68263957e-02f, 1.89878754e-02f, 6.87881336e-02f,
  1.38431102e-01f, 1.39717147e-01f, -1.80213191e-02f, -4.88108397e-02f, 1.36240393e-01f, 8.58129784e-02f, 8.51871520e-02f, 1.28721610e-01f, 5.14230095e-02f, 1.03654496e-01f,
  4.79139239e-02f, 1.52335823e-01f, -4.57248986e-02f, 3.44277620e-02f, 1.13483891e-01f, 1.77236557e-01f, 1.81301795e-02f, 2.50932537e-02f, 3.22153494e-02f, 1.86822421e-04f,
  -1.75482392e-01f, 1.10529503e-02f, -4.04263176e-02f, -1.09682173e-01f, -1.76204652e-01f, -1.13922983e-01f, -1.02196708e-01f, -5.80877587e-02f, -5.09922728e-02f, -1.29284292e-01f,
  -3.69792990e-02f, -3.01530827e-02f, -6.82180971e-02f, -1.26075566e-01f, -3.92238609e-03f, -1.12348637e-02f, -1.31630629e-01f, 3.16674709e-02f, -5.12892343e-02f, -1.00983858e-01f,
  -6.46806136e-02f, 2.87667941e-02f, 4.13386635e-02f, -1.20769944e-02f, -6.42090887e-02f, 4.62025851e-02f, 1.00387493e-03f, -7.07058161e-02f, 9.62308794e-02f, -2.94782892e-02f,
  -3.60104859e-01f, 9.12275165e-02f, -5.52924816e-03f, -8.13906863e-02f, -1.37134837e-02f, -2.20618799e-01f, -1.43758833e-01f, -1.12408936e-01f, 4.36917432e-02f, 1.01904511e-01f,
  -2.43088957e-02f, -4.57834341e-02f, -1.53096691e-01f, -9.73453596e-02f, -3.26304853e-01f, -1.73510492e-01f, -5.34594506e-02f, -1.99918687e-01f, -3.10783923e-01f, -2.34932885e-01f,
  -4.70417030e-02f, -2.12501302e-01f, -2.38937214e-01f, -1.51165769e-01f, -1.14078233e-02f, -7.88371917e-03f, 6.14666343e-02f, -1.67321451e-02f, -2.62563745e-03f, -2.11591721e-02f,
  -4.98406515e-02f, -1.76671550e-01f, -1.51907787e-01f, -2.21805125e-01f, 3.56815173e-03f, -1.85655788e-01f, -1.80053413e-01f, -7.30728805e-02f, -1.29049018e-01f, -1.61686406e-01f,
  -1.54650524e-01f, -1.20807506e-01f, -1.44466028e-01f, -1.10147245e-01f, -2.05547526e-01f, -2.38639548e-01f, -1.04815654e-01f, -1.51975065e-01f, -1.68715954e-01f, -1.54510871e-01f,
  -7.17700422e-02f, -2.05642074e-01f, -1.57621324e-01f, -1.35641217e-01f, -7.25831464e-02f, -2.07933635e-01f, -4.81458418e-02f, 5.14584535e-04f, -1.46861151e-01f, -9.80891883e-02f,
  1.44812867e-01f, 1.77861288e-01f, 1.63400665e-01f, 2.14750364e-01f, 1.89370915e-01f, 1.73554137e-01f, 8.29117000e-02f, 1.96567073e-01f, 4.28855754e-02f, 6.86692372e-02f,
  5.17410673e-02f, 1.61764085e-01f, 1.09410144e-01f, 1.03348643e-01f, 1.11704744e-01f, 9.92506742e-02f, 1.36217564e-01f, 8.05705786e-02f, 6.71718866e-02f, 1.00678556e-01f,
  -4.44125198e-02f, 6.59502074e-02f, 5.93877323e-02f, 3.91056649e-02f, 7.07849637e-02f, 1.50333792e-01f, 3.69942598e-02f, 4.31986339e-02f, 5.46174832e-02f, 1.31030411e-01f,
  -2.38818955e-02f, -3.69358212e-01f, -3.01243305e-01f, -2.34465435e-01f, -1.78495161e-02f, -4.90646102e-02f, -7.43790567e-02f, -1.44818306e-01f, -1.69456571e-01f, -8.59255195e-02f,
  -2.16631472e-01f, -1.93932265e-01f, -1.60294592e-01f, -1.85456857e-01f, -2.30497837e-01f, -2.33432561e-01f, -4.26186137e-02f, -2.22257659e-01f, -1.55610859e-01f, -6.67550229e-03f,
  -1.04908831e-01f, -2.62717426e-01f, -1.79577172e-01f, -7.14008287e-02f, -2.00160787e-01f, -2.09196687e-01f, -1.78763956e-01f, -6.82529733e-02f, -2.52654016e-01f, -6.57206252e-02f,
  -4.35339689e-01f, -2.09880590e-01f, -8.09076503e-02f, -2.32027143e-01f, -6.50625750e-02f, -5.92266880e-02f, 1.87122095e-02f, -4.84159961e-02f, -9.50901285e-02f, -1.86804339e-01f,
  -1.72490075e-01f, 4.03761230e-02f, 5.12366667e-02f, 1.29218504e-01f, 1.22984484e-01f, 3.58465575e-02f, 5.75983673e-02f, 1.52492267e-03f, 2.44833976e-01f, 2.26128876e-01f,
  1.17143840e-01f, 7.61351585e-02f, 4.86023016e-02f, 1.03131175e-01f, 8.95215049e-02f, 1.59626767e-01f, -9.63191167e-02f, -6.11509979e-02f, 1.91489346e-02f, 2.76692351e-03f,
  -1.51601344e-01f, -1.61106676e-01f, 1.16139434e-01f, 7.00973943e-02f, -5.69440890e-03f, -6.25892505e-02f, -1.62037835e-03f, 9.42081362e-02f, -9.95087177e-02f, -1.12924923e-03f,
  -4.67760954e-03f, 1.42833404e-02f, -6.15712218e-02f, 9.84333977e-02f, -4.71577048e-02f, -4.68909442e-02f, 9.11534578e-02f, 7.32239932e-02f, 2.80001592e-02f, 2.31841858e-02f,
  6.07134737e-02f, 1.34688579e-02f, -1.42556876e-01f, -5.23719266e-02f, 8.85692760e-02f, -1.60327908e-02f, -1.81766115e-02f, 1.75565612e-02f, -5.44957146e-02f, -1.55596450e-01f,
  -3.48057045e-04f, 3.43653373e-02f, -9.94580463e-02f, 1.05197756e-02f, 3.65524665e-02f, -1.84429977e-02f, 3.17856744e-02f, 3.02050263e-02f, 5.48584480e-03f, -2.98975166e-02f,
  4.26835865e-02f, -6.45116270e-02f, 7.78444186e-02f, -1.66669965e-01f, 7.43775889e-02f, -6.21767715e-02f, -8.61225873e-02f, 6.14385232e-02f, -3.42300236e-02f, 6.01204000e-02f,
  -6.32767603e-02f, 1.22034196e-02f, -4.17200401e-02f, 1.30020201e-01f, -5.80934472e-02f, -3.60668376e-02f, -5.99817745e-02f, 3.85856926e-02f, -4.35440755e-03f, -1.10065071e-02f,
  -3.37454267e-02f, 2.78190966e-03f, -2.60276459e-02f, 2.10260358e-02f, -4.53167073e-02f, 6.57540336e-02f, 1.35756480e-02f, 1.22157214e-02f, -3.06099392e-02f, -4.67158407e-02f,
  3.95325981e-02f, 2.71232259e-02f, -4.43665171e-03f, 9.41206142e-02f, -1.27711864e-02f, -2.07275413e-02f, -8.17288235e-02f, 7.12953433e-02f, -2.78493054e-02f, -4.79060151e-02f,
  -5.76701760e-02f, -1.72503740e-01f, -2.51101017e-01f, -6.60169870e-02f, 5.34170605e-02f, -1.24008730e-01f, -3.92787904e-02f, 3.68957929e-02f, -1.17148995e-01f, -1.16956852e-01f,
  3.21426481e-01f, -2.93645114e-01f, -1.05724022e-01f, 1.08716063e-01f, -1.85164958e-01f, -1.44246280e-01f, -2.18905881e-01f, 1.45962257e-02f, -2.38521975e-02f, -1.49323702e-01f,
  -2.84297287e-01f, -1.10580549e-01f, -1.56665638e-01f, -6.67490885e-02f, 6.76568178e-03f, 4.72227298e-02f, 5.78606017e-02f, 1.55160666e-01f, 2.27748379e-01f, 1.29439726e-01f,
  -4.87575866e-02f, 8.45053233e-03f, 2.11885020e-01f, 4.65657115e-02f, 3.40912044e-02f, 9.41811427e-02f, 3.48447450e-02f, 1.24592155e-01f, 8.15786701e-03f, 1.77083999e-01f,
  8.75786841e-02f, -1.00004405e-01f, 6.73654601e-02f, -8.74743015e-02f, -4.67968322e-02f, 1.19304992e-01f, -2.92357076e-02f, -1.54920034e-02f, -4.60436381e-02f, 5.07887304e-02f,
  -1.73473597e-01f, 1.06299361e-02f, 2.81737056e-02f, 2.29438096e-02f, 1.09227568e-01f, 3.56092374e-03f, -9.90947243e-03f, 5.54696284e-02f, 1.44415364e-01f, 4.36961092e-02f,
  -2.27226224e-02f, 1.12029806e-01f, 2.56857909e-02f, 6.42171800e-02f, 1.47829294e-01f, 1.30873337e-01f, -8.72049406e-02f, 2.18055964e-01f, 1.96265623e-01f, 1.07281826e-01f,
  1.04866914e-01f, -5.91706745e-02f, -5.60690230e-03f, -5.39294556e-02f, -5.66022396e-02f, -6.93928972e-02f, -2.66495980e-02f, -3.80992554e-02f, 5.64587712e-02f, 6.15192764e-02f,
  -3.24026756e-02f, 1.99275743e-02f, 6.26827078e-03f, 7.54786516e-03f, 5.61222881e-02f, -1.53106302e-02f, 4.56571728e-02f, 1.03647979e-02f, -1.31408218e-03f, 7.63958022e-02f,
  -4.35718596e-02f, 8.52141678e-02f, -3.37958112e-02f, 4.83356677e-02f, -2.01296341e-02f, -3.64032900e-03f, -3.70899588e-02f, 3.15514691e-02f, -6.63903952e-02f, 3.97059647e-03f,
  -8.87883008e-02f, -1.15581408e-01f, 8.28235298e-02f, 1.17972508e-01f, -2.72708070e-02f, -3.36842351e-02f, -1.51438192e-02f, 4.47536036e-02f, -1.57749996e-01f, 1.02437371e-02f,
  -6.01888783e-02f, -3.85858491e-02f, -6.41216263e-02f, 1.82316713e-02f, 1.33436779e-03f, -5.28880907e-03f, -3.93622518e-02f, 9.09825191e-02f, -1.94813460e-02f, -4.14728113e-02f,
  -2.28370465e-02f, 3.49605158e-02f, 1.33623526e-01f, 5.39860204e-02f, 1.32499393e-02f, 7.27548124e-03f, 6.49959594e-02f, 1.57462284e-01f, 1.55523151e-01f, 7.29109859e-03f,
  -7.14054763e-01f, 8.91105756e-02f, -1.72567576e-01f, -2.42171794e-01f, 1.25856295e-01f, 1.06742002e-01f, 3.55357379e-01f, 1.73989624e-01f, -3.02466862e-02f, 9.37305614e-02f,
  -1.09393939e-01f, -2.91327327e-01f, -2.95645863e-01f, -1.87106818e-01f, -1.72012806e-01f, 1.48195982e-01f, 2.54839629e-01f, -2.39306107e-01f, -2.96257347e-01f, -6.90201391e-03f,
  8.92864093e-02f, -1.29002273e-01f, -2.68521041e-01f, -1.20008044e-01f, -3.43041569e-02f, -1.74017906e-01f, -2.90105734e-02f, 7.62390764e-03f, 1.11015541e-02f, -5.11968648e-03f,
  -1.83359846e-01f, -3.79715055e-01f, -1.19330928e-01f, -1.88025862e-01f, -1.01009607e-01f, -1.03644818e-01f, -1.08639799e-01f, -1.49201497e-01f, -1.90978959e-01f, -8.59369859e-02f,
  -2.07579345e-01f, -7.26067200e-02f, -1.44514963e-01f, -2.88830400e-02f, -1.10304765e-01f, -2.98452899e-02f, -1.90811843e-01f, -2.35603288e-01f, -1.01738080e-01f, -5.36189079e-02f,
  -3.70327360e-03f, -1.24312773e-01f, -1.74150959e-01f, -1.12529704e-02f, -3.89938764e-02f, -2.32784465e-01f, -8.25926363e-02f, -8.62042606e-02f, -3.76665927e-02f, 3.33734788e-02f,
  -5.53235337e-02f, 6.13693781e-02f, 1.00719251e-01f, 7.16088116e-02f, 1.91896006e-01f, 4.21835780e-02f, 1.22837931e-01f, 1.11226998e-01f, 8.97423550e-02f, 1.79129660e-01f,
  1.58112571e-01f, 5.63994870e-02f, 1.63848549e-01f, 1.13406248e-01f, 1.09259643e-01f, 3.58573236e-02f, 7.23915696e-02f, 1.57207057e-01f, 8.66633132e-02f, 1.02968872e-01f,
  3.00473976e-03f, 1.28491744e-01f, 1.08806835e-02f, 1.58293486e-01f, 5.89616112e-02f, 1.19000584e-01f, 3.10023259e-02f, 1.12584785e-01f, 8.11489075e-02f, 8.26199725e-02f,
  9.17708576e-02f, -7.19661862e-02f, -1.35426387e-01f, -1.76329330e-01f, -1.35551840e-01f, -1.28341958e-01f, -1.49012879e-01f, -1.63411483e-01f, -2.49009654e-01f, -5.10986112e-02f,
  -7.75336847e-02f, -1.23810969e-01f, -1.21585235e-01f, -1.25127196e-01f, -8.93980414e-02f, -1.43875644e-01f, -7.24057434e-03f, -1.33259475e-01f, -1.19695790e-01f, -1.50110513e-01f,
  3.50020081e-02f, 1.87298357e-02f, 6.85368374e-04f, -5.79334162e-02f, -2.88013443e-02f, -1.48605585e-01f, 1.09899119e-02f, -7.37757757e-02f, 3.92111309e-04f, 1.62205040e-01f,
  4.88710195e-01f, 1.51143745e-01f, 1.79057524e-01f, 3.81371766e-01f, 2.06670344e-01f, 1.09316036e-01f, 1.83599234e-01f, 1.11447208e-01f, 1.80391669e-01f, 2.79985368e-01f,
  1.10665515e-01f, 9.91952419e-02f, -4.14690301e-02f, -7.35508744e-03f, -1.16356269e-01f, 7.48399198e-02f, -4.47408222e-02f, -8.87255892e-02f, -1.89666122e-01f, -1.00752451e-01f,
  -3.30176279e-02f, -5.25235608e-02f, -9.82733592e-02f, -1.47220433e-01f, 1.74727976e-01f, 6.11590445e-02f, 1.59574106e-01f, 8.43357071e-02f, -5.65100200e-02f, -3.47818881e-02f,
  2.97201872e-01f, 3.36448520e-01f, 2.23645680e-02f, 5.56882620e-02f, 1.21670365e-01f, 1.54012084e-01f, 9.84461084e-02f, 1.07768402e-01f, 7.86333010e-02f, 7.21524730e-02f,
  9.93596762e-02f, 1.06791019e-01f, 7.04979617e-03f, 9.56068262e-02f, 6.68284371e-02f, 5.54542355e-02f, 5.60144372e-02f, -9.82292742e-03f, 2.90720966e-02f, 6.84866831e-02f,
  -4.61423211e-02f, 9.66397002e-02f, 2.58526832e-01f, 1.44186020e-01f, 1.37773424e-01f, 2.71521113e-03f, 1.30712807e-01f, 1.83742017e-01f, 1.35065839e-01f, 2.43235946e-01f,
  -4.76782769e-02f, 2.39409544e-02f, -7.97446445e-02f, -3.44329979e-03f, -1.06611229e-01f, -2.34827935e-03f, -4.07075137e-03f, -4.18856964e-02f, -1.27512410e-01f, -1.04231074e-01f,
  -1.13800347e-01f, -1.11275783e-03f, -2.73202802e-03f, -1.13440258e-02f, -1.29171580e-01f, -1.60670560e-02f, -1.07837446e-01f, -1.27883062e-01f, -2.35118829e-02f, -6.05399199e-02f,
  -9.08619389e-02f, -5.61970212e-02f, -4.65670452e-02f, -1.22906670e-01f, -1.27663061e-01f, -1.23796888e-01f, -1.97940432e-02f, -4.32469659e-02f, -3.05542955e-03f, -8.79412964e-02f,
  3.36428493e-01f, -6.45761192e-02f, 1.14413969e-01f, -1.46683003e-03f, 2.25829303e-01f, 1.15015842e-01f, 1.39109835e-01f, 3.46316509e-02f, 4.38282788e-02f, 1.43525794e-01f,
  1.27244204e-01f, 2.40216851e-02f, 1.87871456e-01f, 9.59045738e-02f, 5.45952506e-02f, 1.02490731e-01f, 6.24966249e-02f, 8.29946250e-02f, 1.73583794e-02f, 1.06196441e-01f,
  1.21338397e-01f, 1.57821029e-01f, 1.44990832e-01f, 2.20492333e-01f, 1.11806966e-01f, 7.85691217e-02f, 1.45958960e-01f, 1.03967085e-01f, 2.14541167e-01f, 2.98605591e-01f,
  -1.59391165e-01f, -1.39781013e-01f, 2.16567591e-01f, 5.13363406e-02f, 7.43793398e-02f, -2.13770911e-01f, -2.35856727e-01f, -2.29939163e-01f, -8.95762220e-02f, -1.00891910e-01f,
  -1.56785622e-01f, -1.57414898e-01f, -2.40773857e-01f, -2.29198456e-01f, -3.42514455e-01f, 1.02496095e-01f, 2.83563823e-01f, 8.43294263e-02f, -1.17756791e-01f, -1.32151440e-01f,
  -2.25556064e-02f, 1.17738605e-01f, 8.27045590e-02f, -4.52320538e-02f, 1.58638701e-01f, 1.23203523e-01f, 2.87751317e-01f, 6.12114407e-02f, 2.10750923e-02f, 2.85984546e-01f,
  1.48112118e-01f, -2.51188666e-01f, -1.27544791e-01f, -1.43823866e-02f, -9.78544950e-02f, -7.61074796e-02f, -9.22926292e-02f, -5.56048751e-02f, -1.98818833e-01f, -2.98168715e-02f,
  -1.46523297e-01f, -1.46102488e-01f, -2.12815285e-01f, -9.85157862e-02f, -1.69604588e-02f, -8.67462680e-02f, -3.85638103e-02f, -1.01498306e-01f, 2.62934598e-03f, -1.46001041e-01f,
  -4.06084061e-02f, 6.43907562e-02f, -4.36287224e-02f, -8.53831470e-02f, -1.98398426e-01f, -1.13795087e-01f, -3.28432061e-02f, -8.36679563e-02f, -1.32517442e-01f, 5.50435819e-02f,
  -5.18433079e-02f, 3.00669931e-02f, 7.59067163e-02f, 6.41453266e-02f, 7.97746480e-02f, 6.03683777e-02f, 8.33378285e-02f, 5.00610378e-03f, 8.23194161e-03f, 9.81979668e-02f,
  3.25153582e-02f, 1.01785846e-01f, 7.35568404e-02f, 1.09460101e-01f, 1.10934779e-01f, 6.81433007e-02f, 1.01837233e-01f, -2.05077119e-02f, 4.41848487e-02f, -1.44097209e-02f,
  1.08992212e-01f, 9.11737904e-02f, 1.05155811e-01f, 2.53967568e-03f, 7.52731338e-02f, -7.40452763e-03f, 3.07302456e-02f, 6.96371272e-02f, -3.53646558e-03f, 3.26019749e-02f,
  7.58836046e-02f, -2.49470994e-01f, -4.17113723e-03f, -1.84446856e-01f, 6.33193459e-03f, -9.22356024e-02f, -4.32978831e-02f, -3.34907807e-02f, -5.59899583e-02f, -1.02245942e-01f,
  -6.83219582e-02f, -1.08719975e-01f, -4.44041677e-02f, -9.57365558e-02f, -2.23808400e-02f, -1.46752940e-02f, -4.94746603e-02f, 4.78291549e-02f, -1.21730573e-01f, -4.15395014e-02f,
  5.85577749e-02f, -8.95987917e-03f, 2.98588304e-03f, 1.00975558e-02f, -2.39009878e-05f, 7.82859847e-02f, 1.31386025e-02f, 1.88431200e-02f, -5.15213646e-02f, 9.43419486e-02f,
  2.55110651e-01f, 2.19962820e-01f, 4.39642131e-01f, -1.19086184e-01f, 1.39218658e-01f, 3.10022295e-01f, 2.71962345e-01f, 7.65179917e-02f, -9.30147022e-02f, 1.55481026e-01f,
  1.04368413e-02f, -1.04333587e-01f, -3.73489186e-02f, 3.04385368e-02f, 2.26291567e-01f, 1.64345235e-01f, 1.23866469e-01f, 9.98718590e-02f, 1.18134199e-02f, -1.28087148e-01f,
  -1.96132600e-01f, -3.36763799e-01f, -2.14632913e-01f, -7.68054724e-02f, -2.28391483e-01f, -1.67965576e-01f, -6.15587048e-02f, 2.27415152e-02f, 1.04554981e-01f, 1.22701656e-02f,
  6.48488775e-02f, 2.56384283e-01f, -3.70473787e-02f, -8.17242637e-02f, -4.91626970e-02f, -6.31381050e-02f, -1.86646217e-03f, 1.47677967e-02f, 3.63958739e-02f, -2.07137987e-02f,
  -4.40101288e-02f, 8.33381042e-02f, -2.22904012e-02f, -6.39804527e-02f, 6.70997947e-02f, 5.87846488e-02f, 1.52959032e-02f, 9.57356319e-02f, 4.36377116e-02f, -4.74528484e-02f,
  6.36006817e-02f, 1.55736461e-01f, 1.58071667e-01f, 5.09797595e-02f, 1.27875894e-01f, -2.83867717e-02f, 4.91066724e-02f, 8.31013620e-02f, 1.69286877e-01f, -1.01444930e-01f,
  3.33219506e-02f, -3.07195168e-02f, 1.99963655e-02f, -6.08731359e-02f, -6.10710941e-02f, -6.43161498e-03f, -2.44971588e-02f, -3.32033150e-02f, -3.18890736e-02f, 1.03258304e-02f,
  4.76554669e-02f, -2.30390672e-02f, 6.11547083e-02f, -3.29929451e-03f, -1.64677091e-02f, 1.98703222e-02f, 1.57749169e-02f, -6.38934150e-02f, 4.28284258e-02f, -7.57499561e-02f,
  5.97567037e-02f, -6.34467974e-02f, -1.00299686e-01f, -8.06651413e-02f, 7.35060424e-02f, 1.60326215e-03f, -1.04416336e-03f, -6.14768118e-02f, -9.17272791e-02f, -2.92684343e-02f,
  -2.31413692e-01f, 7.84358382e-02f, -3.52318473e-02f, -7.73611711e-03f, 4.35121097e-02f, -6.94693439e-03f, 2.56600790e-03f, -1.13838129e-01f, 2.90777422e-02f, -4.08616215e-02f,
  -1.68470722e-02f, -1.06489025e-01f, 1.09157898e-02f, -2.14521587e-02f, -1.16068058e-01f, -1.18436795e-02f, -3.92128453e-02f, -9.21574049e-03f, 1.00216037e-02f, -7.01309508e-03f,
  -1.11496367e-01f, 1.23133719e-01f, 2.46031601e-02f, 2.26481948e-02f, 4.28437395e-03f, -5.48027735e-03f, -2.50789132e-02f, -2.50640605e-02f, 1.50109053e-01f, -9.65129212e-02f,
  -2.79322177e-01f, -1.38497934e-01f, 2.92768717e-01f, 1.85810745e-01f, 2.99071252e-01f, 3.02231371e-01f, 5.65659367e-02f, -8.91699791e-02f, 5.00710383e-02f, 1.31553486e-01f,
  1.02297373e-01f, 1.96455970e-01f, 2.07727015e-01f, 6.72658309e-02f, -5.43773035e-03f, 6.85552731e-02f, 1.89890340e-01f, 2.21623391e-01f, 2.00008497e-01f, 2.38291882e-02f,
  9.39206183e-02f, -3.07618249e-02f, -4.61931862e-02f, -9.33320727e-03f, 5.22469096e-02f, 2.18906581e-01f, 1.95400551e-01f, 9.95578021e-02f, 4.41762991e-02f, 2.25634336e-01f,
  3.44273090e-01f, -2.41281718e-01f, 2.20481575e-01f, 1.30015358e-01f, 1.78887576e-01f, -6.26787692e-02f, 6.63124621e-02f, 1.35112450e-01f, 3.64549495e-02f, 1.04141541e-01f,
  1.19245045e-01f, -7.85530731e-03f, 2.39858553e-02f, -3.83056924e-02f, -4.37204726e-02f, 4.24972959e-02f, -1.45652831e-01f, -1.21613815e-01f, 8.29575658e-02f, -1.30828381e-01f,
  -6.65740902e-03f, 3.04891691e-02f, 1.95207000e-02f, -2.12219562e-02f, -9.44815353e-02f, 1.12912372e-01f, 7.28244707e-02f, -5.60094835e-03f, 5.53641729e-02f, -4.68288548e-02f,
  -5.34212664e-02f, 8.52313638e-03f, -6.91121817e-02f, -1.62467778e-01f, -1.40928939e-01f, -6.45917952e-02f, -9.57088768e-02f, -7.88974017e-02f, -1.39634371e-01f, -1.70652417e-03f,
  -1.55902237e-01f, -6.92365244e-02f, -3.10676079e-02f, -1.51473701e-01f, -3.05264555e-02f, -8.96737576e-02f, -5.98969162e-02f, -6.44756258e-02f, -9.19055939e-02f, -8.44905600e-02f,
  -3.19967493e-02f, -1.48723256e-02f, -2.14782916e-02f, -2.79679056e-02f, -1.20335430e-01f, 2.28734557e-02f, -5.84526546e-02f, -1.42374307e-01f, -7.45679662e-02f, -2.94138175e-02f,
  2.47520000e-01f, 1.61397845e-01f, 6.26562163e-02f, -4.32001799e-02f, 1.96052790e-01f, 6.06884807e-02f, 5.19821048e-02f, 9.34673920e-02f, 9.59168896e-02f, -5.58274705e-03f,
  -3.01308893e-02f, -3.32256369e-02f, 1.25456065e-01f, -3.16892155e-02f, 8.49861056e-02f, 3.56003754e-02f, 8.19598362e-02f, 1.29299566e-01f, 1.25920817e-01f, 1.00069195e-01f,
  1.04076855e-01f, 1.38454959e-01f, 2.45081186e-01f, 1.67563885e-01f, 1.08516693e-01f, 2.24109903e-01f, 1.99883476e-01f, 2.06928447e-01f, 1.72614202e-01f, 1.01936735e-01f,
  -8.58592913e-02f, 2.26064086e-01f, -2.84370910e-02f, 7.77946711e-02f, -1.62899330e-01f, -8.42516869e-03f, 4.18212004e-02f, 1.12623222e-01f, -1.75441857e-02f, 1.36644244e-01f,
  8.94916654e-02f, 3.49850133e-02f, -1.74828758e-03f, 9.53686088e-02f, 9.35622305e-02f, -4.30026762e-02f, -1.02360681e-01f, -2.60691438e-03f, -7.01734144e-03f, -8.53056982e-02f,
  -1.35195538e-01f, -1.66126136e-02f, -8.55342299e-02f, -1.06509946e-01f, -7.15220645e-02f, -1.15140393e-01f, -9.36842114e-02f, -3.00750509e-03f, 1.67520270e-02f, -2.76344568e-02f,
  2.90427268e-01f, -3.62114869e-02f, 4.36366983e-02f, 1.77672163e-01f, 9.61821079e-02f, 1.03131101e-01f, 1.45034835e-01f, 1.47157937e-01f, 1.97083473e-01f, 1.07051440e-01f,
  8.63613188e-02f, 1.16671994e-01f, 1.34677410e-01f, 1.54600078e-02f, 5.52337579e-02f, 1.08834848e-01f, 1.69603467e-01f, 4.56339642e-02f, 2.01604255e-02f, 7.45505095e-02f,
  1.30871115e-02f, 2.12120526e-02f, 1.23404004e-01f, 1.89263344e-01f, 1.27502546e-01f, 1.02225328e-02f, 1.68687433e-01f, 1.15481712e-01f, -3.03294379e-02f, 1.17261946e-01f,
  2.62044799e-02f, -6.16491623e-02f, -1.67932495e-01f, -4.48919870e-02f, -7.60491043e-02f, -1.48217276e-01f, -1.08405516e-01f, -4.83567268e-02f, -6.21204488e-02f, 5.70232719e-02f,
  -7.86092803e-02f, -7.53556238e-03f, -1.82749853e-01f, -6.48377910e-02f, -7.36961663e-02f, -2.26395249e-01f, -1.15132809e-01f, -2.71342397e-02f, -6.35226145e-02f, -9.97017696e-02f,
  -1.24453222e-02f, -1.59822330e-01f, -4.09496911e-02f, -9.17172730e-02f, -1.83994696e-01f, -1.04127467e-01f, -1.55998871e-01f, -4.99296188e-02f, -4.80978303e-02f, -1.09218538e-01f,
  1.14604108e-01f, -1.53595254e-01f, 2.39622459e-01f, 1.67505160e-01f, 1.44625872e-01f, 2.01852679e-01f, 8.24593976e-02f, 1.39132872e-01f, 5.93667887e-02f, 1.03965148e-01f,
  5.55630736e-02f, 2.23375648e-01f, 1.12117410e-01f, 2.12383360e-01f, 1.35417819e-01f, 1.12070732e-01f, 1.63782448e-01f, 1.77945718e-01f, 1.19397216e-01f, 1.91512734e-01f,
  2.12561533e-01f, 8.95479321e-02f, 2.59445131e-01f, 2.82596707e-01f, 1.11776337e-01f, 9.24033821e-02f, 1.13394387e-01f, 1.91525757e-01f, 8.28177035e-02f, 3.74163210e-01f,
  -3.24742705e-01f, -7.90726915e-02f, -1.12430252e-01f, -1.89356133e-01f, 9.73149836e-02f, 1.99071705e-01f, 2.85862356e-01f, 1.51043922e-01f, -3.34255658e-02f, -4.82059345e-02f,
  4.76218723e-02f, 1.64326668e-01f, 1.97947040e-01f, 1.70025870e-01f, 1.88407689e-01f, 1.04833215e-01f, 3.91574837e-02f, 4.86746579e-02f, 7.52702653e-02f, -4.08803038e-02f,
  -8.00457448e-02f, -1.23345464e-01f, -1.54361397e-01f, -1.07619517e-01f, -2.47375771e-01f, -2.02125292e-02f, -1.27184376e-01f, -1.75486624e-01f, -1.58595238e-02f, -3.43609393e-01f,
  -3.30971241e-01f, -2.29787558e-01f, 1.35071054e-02f, -6.60002679e-02f, -4.80532199e-02f, -3.60831581e-02f, -5.32650687e-02f, -6.23022802e-02f, -1.23491518e-01f, -1.44205779e-01f,
  -1.02362134e-01f, -1.60934076e-01f, -1.02911666e-01f, -4.07171212e-02f, -5.78163974e-02f, -5.82703128e-02f, -1.81336880e-01f, -4.59768474e-02f, 2.69749202e-03f, -1.32607967e-01f,
  3.74603420e-02f, -1.00000866e-01f, -8.22130591e-02f, 1.11464441e-01f, -4.43277024e-02f, 7.56544247e-02f, -7.25941882e-02f, -1.61519125e-01f, -6.47007897e-02f, -2.44847536e-01f,
  -1.19799897e-01f, 3.61502394e-02f, -2.44247988e-02f, -4.52354737e-02f, 1.14759058e-01f, 1.33525893e-01f, -2.20518969e-02f, 7.79555365e-02f, 1.75890680e-02f, 2.15538451e-03f,
  6.77593648e-02f, 4.67100069e-02f, 7.48880133e-02f, 3.34991626e-02f, 1.63261071e-02f, 5.47286011e-02f, 1.16691235e-02f, 9.91902202e-02f, 2.75031384e-02f, 3.12788785e-02f,
  6.86599761e-02f, 8.17630365e-02f, 5.61582334e-02f, -2.45104264e-02f, -3.08065973e-02f, 7.84226209e-02f, 5.88133857e-02f, 1.28859788e-01f, 1.12574846e-01f, -4.61821929e-02f,
  1.29560664e-01f, 2.65454262e-01f, -8.30431934e-03f, -4.73570824e-02f, -1.35663807e-01f, 2.63545010e-02f, -4.89284061e-02f, -8.75378847e-02f, -7.62502430e-03f, -8.30011293e-02f,
  -3.49155702e-02f, 1.74361207e-02f, -5.47875650e-02f, -1.78918447e-02f, -3.04875914e-02f, -5.84285706e-02f, 1.90913584e-02f, 3.99355292e-02f, 1.08134031e-01f, -1.22224569e-01f,
  3.97027582e-02f, 4.44157794e-03f, 6.88405633e-02f, 1.99314058e-01f, -1.21860681e-02f, 2.03565329e-01f, 5.84695041e-02f, 1.68647647e-01f, 1.05204150e-01f, 1.29772812e-01f,
  -5.28103672e-02f, -4.25847143e-01f, 1.34155676e-01f, 4.47269455e-02f, -1.03761725e-01f, -1.96543366e-01f, -4.06445622e-01f, -6.07002862e-02f, 8.80490243e-02f, -1.08305126e-01f,
  -3.53271216e-02f, 2.99598396e-01f, 2.08332106e-01f, 3.35905612e-01f, 9.22643617e-02f, -1.96107015e-01f, -8.86271596e-02f, 3.25065196e-01f, 2.42906317e-01f, 1.04832612e-01f,
  -3.77601571e-02f, -4.67507578e-02f, 1.03969395e-01f, 6.94383010e-02f, -9.08669308e-02f, 8.86563510e-02f, -5.79646714e-02f, -7.62770325e-02f, -1.00097232e-01f, 5.96303865e-02f,
  4.80985679e-02f, -8.94536600e-02f, 1.98098436e-01f, 1.87617898e-01f, 5.83224371e-02f, 6.04224950e-02f, 9.42706782e-03f, 1.32607967e-01f, 6.09513670e-02f, -4.87049036e-02f,
  2.90642045e-02f, 1.76408872e-01f, 5.99538870e-02f, 5.74409291e-02f, 5.75256683e-02f, 8.67731571e-02f, -1.35560613e-02f, 1.56443536e-01f, 2.25797310e-01f, 5.82221784e-02f,
  2.45681852e-02f, -4.23115045e-02f, -5.30899800e-02f, -4.38265270e-03f, 1.60236582e-01f, 2.04005048e-01f, 1.41601241e-03f, 5.25272712e-02f, 1.47061311e-02f, -1.49932221e-01f,
  5.68416109e-03f, -4.78547700e-02f, -8.95361323e-03f, -4.50820662e-02f, -9.52920914e-02f, 6.84214309e-02f, -2.42065098e-02f, -8.07048567e-03f, 1.00404657e-02f, 1.81417726e-03f,
  1.05364434e-03f, -2.52380185e-02f, 1.73761938e-02f, -6.89612553e-02f, -4.78768162e-02f, -3.94369178e-02f, -1.58069972e-02f, -1.55087207e-02f, -4.36854884e-02f, -7.31032044e-02f,
  9.25389603e-02f, 6.88456148e-02f, -3.56157832e-02f, 5.59516326e-02f, -2.81948932e-02f, -1.87587477e-02f, -1.40937064e-02f, 2.13055536e-02f, 7.43604032e-03f, -1.39948741e-01f,
  -6.72016516e-02f, 2.34308288e-01f, 1.08971804e-01f, 8.51982310e-02f, -9.54807084e-03f, 3.88147458e-02f, 1.44404992e-02f, 1.23734675e-01f, 1.37035191e-01f, 2.01461799e-02f,
  1.09354511e-01f, 3.98768159e-03f, -4.73076478e-02f, 5.53455129e-02f, 1.21977448e-03f, 5.08694649e-02f, -5.72819896e-02f, 7.75977150e-02f, 9.65284854e-02f, -2.69647576e-02f,
  -1.03883214e-01f, 1.55090960e-02f, 4.84735612e-03f, -5.35060987e-02f, -6.92301383e-03f, 1.90658912e-01f, -1.12719126e-01f, -4.25289720e-02f, 7.19585642e-02f, -2.22556114e-01f,
  -4.14156795e-01f, -3.76810670e-01f, -1.16178751e-01f, 1.53722912e-02f, 1.64311394e-01f, 5.01303002e-02f, -1.94881082e-01f, 1.25470823e-02f, 9.01983380e-02f, -1.38515100e-01f,
  2.72229537e-02f, 1.54016092e-01f, 5.95061630e-02f, 2.62666512e-02f, -6.60252348e-02f, -3.36488664e-01f, -1.30532488e-01f, -1.20879486e-02f, 1.28091201e-01f, 1.19206958e-01f,
  8.17004368e-02f, 8.08625016e-03f, 6.57521337e-02f, 4.04807068e-02f, -6.09456841e-03f, 6.70116395e-02f, -1.76172480e-01f, 1.98546592e-02f, 7.88996443e-02f, -1.58465549e-01f,
  -2.10835636e-01f, 2.41058823e-02f, 1.25765294e-01f, 1.59236565e-01f, 5.79418149e-03f, -2.41486728e-02f, -5.91129698e-02f, 8.31088498e-02f, 9.90310609e-02f, -9.09031332e-02f,
  1.20404407e-01f, 2.30597891e-02f, 1.28621802e-01f, 9.60895419e-02f, -3.31437066e-02f, 1.13930412e-01f, -3.50399911e-02f, 3.53086181e-02f, 8.76070186e-02f, 1.51173621e-02f,
  8.60560015e-02f, -4.42233048e-02f, 2.27453131e-02f, 4.11769375e-02f, 1.26378059e-01f, 1.85414758e-02f, 7.93248564e-02f, 4.18711528e-02f, -1.85285439e-03f, -1.01560622e-01f,
  9.38472226e-02f, -4.81603667e-02f, 5.31354249e-02f, -7.64583051e-02f, -8.55105594e-02f, -1.95973013e-02f, -4.60990332e-02f, -5.67784011e-02f, 9.62314457e-02f, -3.75481471e-02f,
  -2.49727201e-02f, 2.22292170e-02f, 9.05937776e-02f, -2.60517057e-02f, -2.76292134e-02f, 3.96410972e-02f, -1.35911424e-02f, -3.12821865e-02f, 5.16904779e-02f, 3.21940593e-02f,
  1.41884079e-02f, 4.18857858e-02f, 8.34731236e-02f, 3.88614321e-03f, -3.28363404e-02f, 7.32029304e-02f, -4.78604659e-02f, -3.93961109e-02f, -5.17826192e-02f, 5.39786480e-02f,
  -2.81846374e-01f, 1.12460837e-01f, -1.13860376e-01f, 8.30010548e-02f, 2.83129103e-02f, 5.94214611e-02f, -6.63913414e-02f, 5.04115820e-02f, -2.45890804e-02f, 4.14046980e-02f,
  1.66475233e-02f, -4.13120128e-02f, 4.72081825e-02f, -6.91956002e-03f, 7.01312497e-02f, -1.34627623e-02f, -3.34641710e-02f, 3.68941054e-02f, 1.07169792e-03f, 6.50109798e-02f,
  -8.27788748e-03f, -1.59346789e-01f, -1.27374172e-01f, -3.23166661e-02f, 8.98678154e-02f, -7.89187551e-02f, -3.67515162e-02f, -5.36659881e-02f, -4.77838591e-02f, -2.73226500e-01f,
  -5.19148052e-01f, 6.71025738e-02f, -5.08126803e-02f, -3.71770822e-02f, 1.63413674e-01f, 2.19632238e-01f, 1.49303466e-01f, 4.15498093e-02f, 7.53037557e-02f, 2.27988176e-02f,
  5.36304191e-02f, 7.67444223e-02f, 1.42699922e-03f, 1.19775020e-01f, -2.78467126e-02f, 1.05371185e-01f, -2.48059202e-02f, -1.50910556e-01f, -3.14052477e-02f, -4.28702049e-02f,
  7.82294348e-02f, -7.62799233e-02f, -2.64906853e-01f, -1.68050043e-02f, 7.28389919e-02f, -5.66884782e-03f, 1.14265025e-01f, -2.78519299e-02f, 7.91912973e-02f, -8.25933591e-02f,
  -2.32730418e-01f, 1.18441433e-01f, 2.76048146e-02f, -5.25202081e-02f, 4.24327217e-02f, -8.55908729e-03f, 5.40573373e-02f, 4.75039594e-02f, 9.97968763e-02f, 6.13115802e-02f,
  2.76648402e-02f, -1.00216148e-02f, 1.02101833e-01f, 3.81879956e-02f, 3.19947340e-02f, 1.53803406e-02f, 7.14168921e-02f, -9.79937613e-02f, 7.61516690e-02f, 6.96592629e-02f,
  1.96806833e-01f, 7.70189315e-02f, -9.56060812e-02f, 6.64087906e-02f, 1.39039814e-01f, -4.59108762e-02f, -1.43086282e-03f, 9.48058888e-02f, 4.82329167e-02f, -1.77093357e-01f,
  -1.76265202e-02f, -1.26778940e-02f, 3.14437225e-02f, 2.66409814e-02f, -8.41339603e-02f, -9.98319592e-04f, 5.47312126e-02f, -1.65800378e-02f, -3.14944386e-02f, -5.72462268e-02f,
  -6.77960692e-04f, -7.21046561e-03f, -9.56243463e-03f, -6.91058263e-02f, -3.92791294e-02f, 3.03498022e-02f, 3.20148189e-03f, 3.65611203e-02f, 4.48057316e-02f, -4.79659550e-02f,
  -6.60558343e-02f, -4.40164022e-02f, 6.32488802e-02f, 3.15539911e-02f, 5.30823134e-02f, 7.86212087e-03f, -6.84947819e-02f, 3.39819584e-03f, -5.93873002e-02f, -2.01596449e-05f,
  -1.73352271e-01f, 2.63740122e-01f, -1.11527793e-01f, -6.01489954e-02f, -4.00543064e-02f, -2.83444934e-02f, 6.06612600e-02f, 4.03033420e-02f, 6.23099655e-02f, -4.67219874e-02f,
  4.12810594e-02f, -5.39052784e-02f, 8.68673995e-02f, 4.33792472e-02f, -1.66292172e-02f, 7.78956385e-03f, 9.41343233e-02f, -4.67404202e-02f, -1.54346861e-02f, 1.04134634e-01f,
  6.76037371e-02f, 1.75241684e-03f, -1.31044045e-01f, 5.74609637e-02f, 4.82931025e-02f, -9.25187320e-02f, -5.35443053e-02f, -1.41228735e-01f, -8.91600177e-02f, -2.03896835e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.65219229e-01f, -6.82099462e-01f, 6.87504828e-01f, -3.31475794e-01f, -2.37330824e-01f, -1.58721998e-01f, -3.67749006e-01f, -4.53932941e-01f, -3.19065392e-01f, -2.27946118e-01f,
  -2.08103374e-01f, 1.29181758e-01f, 3.83826166e-01f, 1.55079722e-01f, -1.62885979e-01f, 2.92380271e-03f, 1.28139406e-01f, 3.21136922e-01f, 1.04326509e-01f, -2.65507162e-01f,
  -4.27639514e-01f, -1.95401222e-01f, -1.85006127e-01f, -1.03070192e-01f, -2.33891279e-01f, 9.54331532e-02f, 1.78832531e-01f, -1.11426398e-01f, -1.15619205e-01f, -8.95798765e-03f,
  5.98191023e-01f, -4.27070975e-01f, 1.02666497e-01f, -2.36467481e-01f, -1.33596987e-01f, -2.68955883e-02f, -7.25012645e-02f, -1.66411360e-03f, -1.08374566e-01f, -8.00519437e-03f,
  -9.41924229e-02f, -3.11743207e-02f, 6.03619181e-02f, -7.29587022e-03f, -8.28235671e-02f, -5.65572083e-02f, -7.90735260e-02f, -1.77988917e-01f, -1.00744873e-01f, -4.98269647e-02f,
  -1.91260457e-01f, -2.01266512e-01f, 3.59666683e-02f, 3.83705311e-02f, -4.45013493e-02f, 6.21310845e-02f, -2.45444663e-02f, -1.51348397e-01f, -7.28859082e-02f, -6.61147460e-02f,
  -7.43470788e-02f, 1.05369411e-01f, -7.00724646e-02f, -8.14861655e-02f, 3.03922128e-02f, -9.93437916e-02f, 2.94753350e-02f, -8.59457403e-02f, 4.05964628e-02f, -2.00686790e-02f,
  -2.58999079e-01f, -4.66095619e-02f, -8.38980824e-02f, -6.72328323e-02f, -1.77670587e-02f, -1.57111257e-01f, -1.03157803e-01f, -1.20260395e-01f, -1.92460552e-01f, -2.03183934e-01f,
  -1.66455641e-01f, -1.06146872e-01f, -3.61373052e-02f, -1.29053965e-01f, -1.70515925e-01f, -2.27337345e-01f, -1.54114142e-01f, -7.31954873e-02f, -5.49502522e-02f, -1.23058379e-01f,
  1.84085935e-01f, 1.36947945e-01f, 1.14657432e-01f, 1.21307477e-01f, 5.03902510e-03f, -2.66443528e-02f, 9.61395204e-02f, 5.67593500e-02f, 1.38771430e-01f, 1.30115479e-01f,
  -8.03689361e-02f, 1.55251712e-01f, -1.29142227e-02f, -4.87473533e-02f, 1.21590167e-01f, 5.97995035e-02f, -3.10618341e-01f, -8.34030136e-02f, 2.76902225e-02f, -1.70529619e-01f,
  -1.23221003e-01f, -4.52574082e-02f, 2.04639211e-01f, 1.99708030e-01f, -3.55959684e-02f, 1.90752685e-01f, 2.70400226e-01f, 1.33847132e-01f, 1.53081089e-01f, -1.34434747e-02f,
  1.24145722e+00f, -6.36707306e-01f, -7.95020461e-01f, 6.63319901e-02f, -3.88246059e-01f, -2.77211994e-01f, -6.11289859e-01f, 2.70341802e-03f, 1.95896834e-01f, -5.38148463e-01f,
  7.79966339e-02f, 7.57022619e-01f, 4.33387935e-01f, 4.41267222e-01f, 5.73470950e-01f, -7.83894897e-01f, -8.51387620e-01f, 1.38482198e-01f, 6.68893397e-01f, 2.78880358e-01f,
  1.13099050e-02f, 7.66393170e-02f, 4.16897595e-01f, 4.83195186e-02f, -8.17852736e-01f, -1.47593096e-01f, -1.01824665e+00f, -5.06468713e-01f, -3.68020326e-01f, -1.10227895e+00f,
  -3.05425733e-01f, -1.06767260e-01f, 1.37383699e-01f, 3.18575263e-01f, -7.98585936e-02f, 1.85545281e-01f, 3.54028009e-02f, -1.46248296e-01f, 1.87816933e-01f, 5.03167473e-02f,
  2.97654942e-02f, 2.25787029e-01f, 2.57610947e-01f, -2.71196589e-02f, -1.51421249e-01f, -6.07386157e-02f, -1.98669836e-01f, 1.04068495e-01f, 1.81693286e-01f, -1.99128449e-01f,
  -2.51752287e-01f, -1.56719759e-01f, -3.15646589e-01f, -1.41469687e-01f, 1.00647092e-01f, 1.57338098e-01f, -4.08650339e-01f, -8.40671211e-02f, -4.17113379e-02f, -9.43420053e-01f,
  -1.19696647e-01f, -1.83884019e-03f, -7.52417371e-02f, 3.56530882e-02f, 7.60154724e-02f, 7.67794251e-03f, 8.27745721e-02f, 1.90439850e-01f, 2.76378635e-02f, -1.17782362e-01f,
  -3.18532274e-03f, -2.22295225e-02f, 1.89631060e-01f, -1.98163405e-01f, -1.52117610e-01f, -1.18411273e-01f, -9.51660797e-02f, -1.60313025e-01f, 4.67873458e-03f, 4.58120555e-02f,
  9.40522850e-02f, 5.38781583e-02f, 8.56055915e-02f, 1.97488964e-01f, -1.38935134e-01f, -3.21716303e-03f, -4.56683040e-02f, 6.46028072e-02f, 1.71186611e-01f, -9.46302041e-02f,
  3.00519347e-01f, 3.14958781e-01f, -2.20440999e-01f, 1.31024793e-01f, -8.61535892e-02f, -1.46834916e-02f, -2.00873807e-01f, 8.02221801e-03f, 1.22277848e-01f, 1.46705076e-01f,
  -8.64000916e-02f, 1.67788222e-01f, -3.71235721e-02f, -1.10602669e-01f, -6.55891523e-02f, -1.06386200e-01f, 6.80961534e-02f, -4.99733128e-02f, 6.62016198e-02f, -3.42151195e-01f,
  -6.81217238e-02f, -5.02429679e-02f, 3.53467673e-01f, -1.01026641e-02f, -1.42224282e-01f, 1.31824166e-01f, -4.07458603e-01f, -3.50284934e-01f, 2.06661373e-01f, -2.78262377e-01f,
  -1.02430083e-01f, -4.79077876e-01f, 1.95203468e-01f, -1.71348795e-01f, -1.89892232e-01f, -1.57221675e-01f, -3.34819138e-01f, -1.37105107e-01f, -2.72051156e-01f, -2.32089162e-01f,
  1.65192317e-02f, 3.75538141e-01f, 3.24450552e-01f, 2.83024162e-01f, 1.19031549e-01f, -2.67646700e-01f, -2.06191689e-01f, 1.71175733e-01f, 3.24713141e-01f, -4.88338172e-02f,
  -1.59193292e-01f, 9.26275551e-03f, 7.33897015e-02f, 9.65777934e-02f, -2.71777898e-01f, 6.50864318e-02f, -1.42050385e-01f, 2.96528917e-03f, -2.33584300e-01f, -4.45915729e-01f,
  6.49799347e-01f, 2.00418264e-01f, 1.93851516e-01f, 6.49588108e-02f, 1.08410299e-01f, -5.25379516e-02f, 8.68924335e-02f, -8.51678327e-02f, -7.58609399e-02f, -1.14395298e-01f,
  7.15628266e-02f, 1.13490783e-01f, 1.54260576e-01f, 4.93215993e-02f, 8.60589817e-02f, 1.50196982e-04f, 1.09657951e-01f, 9.00288224e-02f, 2.87041496e-02f, 6.85909465e-02f,
  2.78970953e-02f, 7.18599483e-02f, 1.93323627e-01f, 1.04069941e-01f, 1.72059730e-01f, 1.44693419e-01f, 7.16004893e-02f, 6.78984448e-02f, 1.32046208e-01f, 6.86156526e-02f,
  -2.97539737e-02f, -1.77858304e-02f, 1.45600796e-01f, 2.37117738e-01f, 1.22847892e-01f, -5.50668947e-02f, -6.77137077e-02f, 8.72679055e-02f, 9.28178281e-02f, 1.25110909e-01f,
  -1.35402873e-01f, 6.34944811e-02f, 4.05279621e-02f, -1.64257586e-01f, 5.21218479e-02f, -2.51568835e-02f, -3.36894803e-02f, 9.73003730e-02f, 1.44037515e-01f, -4.68091816e-02f,
  1.07269257e-01f, -1.43319920e-01f, -9.16955695e-02f, 5.24668582e-02f, -2.16762498e-01f, 7.05992803e-02f, 3.85659793e-03f, 1.05860151e-01f, -4.89245774e-03f, -1.94170937e-01f,
  5.06276131e-01f, 4.75960314e-01f, -2.59949639e-02f, -1.67540554e-03f, -1.01938203e-01f, -2.23362029e-01f, 1.79634783e-02f, -7.80763030e-02f, -9.83534828e-02f, -1.38178971e-02f,
  -6.77223578e-02f, 7.22278208e-02f, 4.45799045e-02f, -9.22618657e-02f, -4.62199412e-02f, -1.37363328e-02f, -7.60335550e-02f, -5.36712930e-02f, -1.00096367e-01f, -1.41447991e-01f,
  -2.35046178e-01f, -1.40926898e-01f, 8.18216428e-02f, -3.72347385e-02f, -2.52719223e-02f, -6.52619964e-03f, 8.82269219e-02f, 6.15811087e-02f, 1.23652078e-01f, -8.52227286e-02f,
  4.85387415e-01f, 2.31871665e-01f, 4.01802033e-01f, 2.52992362e-01f, 3.83865297e-01f, 5.49601972e-01f, 5.61906993e-01f, 2.30679244e-01f, -6.67168424e-02f, 6.78679049e-02f,
  -1.20019041e-01f, -3.96486849e-01f, -4.08909172e-01f, -3.81087780e-01f, -1.18199006e-01f, 4.87326942e-02f, -5.57719767e-02f, 9.70402807e-02f, 1.37779400e-01f, 4.47684601e-02f,
  -1.84833139e-01f, 2.00903103e-01f, 2.47399524e-01f, -3.45641300e-02f, -2.04297185e-01f, -1.92958549e-01f, -7.21787009e-03f, 1.21937655e-01f, 2.22572312e-02f, -2.87105799e-01f,
  -1.43254891e-01f, 2.83991098e-01f, -3.27798337e-01f, -3.25071186e-01f, -3.32016014e-02f, -8.45607892e-02f, 2.09112629e-01f, -8.17199145e-03f, -4.40498777e-02f, -1.76050782e-01f,
  -5.07896692e-02f, -7.31233228e-03f, 1.82624012e-01f, 1.22908436e-01f, 1.74318507e-01f, 1.46944344e-01f, 7.46679828e-02f, 4.61906828e-02f, -1.47671863e-01f, -6.82310238e-02f,
  -1.69660434e-01f, 2.35030398e-01f, 2.62974113e-01f, 8.70054588e-03f, -2.02300847e-02f, -9.84423235e-02f, 1.89908280e-03f, 7.33633563e-02f, 1.21305168e-01f, -1.32557839e-01f,
  1.22014523e-01f, 3.30660045e-02f, 1.22123122e-01f, 7.68105537e-02f, 4.54426892e-02f, 3.97038013e-02f, -4.28377539e-02f, 9.57535952e-02f, 9.16794240e-02f, 1.27372608e-01f,
  1.58687100e-01f, 8.58682245e-02f, 2.06336021e-01f, 7.61576518e-02f, -5.06657846e-02f, 2.64505863e-01f, 9.50107425e-02f, -7.93211386e-02f, 1.31178245e-01f, 2.78914422e-02f,
  2.06230164e-01f, 4.29981807e-03f, 1.37080744e-01f, 6.72955215e-02f, -2.42491774e-02f, 3.15355286e-02f, 6.45110160e-02f, 1.39443399e-02f, 1.19539283e-01f, 2.72542447e-01f,
  -1.02848448e-01f, 2.57430851e-01f, -2.29033604e-01f, -1.15181133e-01f, 1.21815205e-01f, 2.36673630e-03f, 4.36108224e-02f, -7.58488402e-02f, -2.75313258e-02f, -3.78719792e-02f,
  4.11997512e-02f, -1.02101760e-02f, 2.34915644e-01f, 1.54508114e-01f, 1.62961408e-01f, 1.67616680e-01f, -8.16921797e-03f, -5.51962852e-02f, -1.79967344e-01f, -1.44460365e-01f,
  -1.01343341e-01f, 7.54767284e-02f, 8.63504410e-02f, 7.88209867e-03f, 1.07001655e-01f, -4.62540090e-02f, 7.68840462e-02f, 5.89590939e-03f, 1.23032704e-01f, 2.34819576e-02f,
  -9.57095742e-01f, 5.43068171e-01f, 1.58597380e-01f, -5.12038350e-01f, -4.41530615e-01f, -3.68252277e-01f, 1.05907314e-01f, -6.40547648e-02f, -5.37202433e-02f, 4.99514908e-01f,
  2.98477024e-01f, -3.23528886e-01f, 5.32647548e-03f, -1.22627519e-01f, -2.18414977e-01f, 4.40006793e-01f, 7.96181038e-02f, -6.94810987e-01f, -1.02010500e+00f, -6.72370434e-01f,
  -3.82476062e-01f, -7.28847921e-01f, -8.22781324e-01f, -3.16492230e-01f, 6.56697825e-02f, -3.59909892e-01f, 1.92683220e-01f, -2.74839252e-01f, -1.43643459e-02f, 2.23919883e-01f,
  1.38149515e-01f, -3.78009498e-01f, -1.02883868e-01f, -1.41385168e-01f, 1.51275247e-01f, -6.96766600e-02f, -1.10908255e-01f, 4.68898043e-02f, 1.19328387e-02f, 1.47283956e-01f,
  -8.12344253e-02f, -3.08073442e-02f, 3.50308814e-03f, 2.82747056e-02f, -8.35805908e-02f, -8.56085792e-02f, 6.11243956e-02f, -3.31876837e-02f, 1.42255798e-01f, 3.05776417e-01f,
  1.54361174e-01f, -6.83215111e-02f, 1.44707458e-02f, 1.47394940e-01f, 3.64670195e-02f, -2.42623657e-01f, 1.93598375e-01f, -7.53501877e-02f, 8.51497576e-02f, 2.22459838e-01f,
  9.75553505e-03f, 3.05832773e-01f, 2.53207237e-02f, 2.70971041e-02f, 8.37247670e-02f, 6.77826628e-02f, -7.04565272e-03f, 1.58873498e-01f, -8.35151747e-02f, 6.65496662e-02f,
  -1.85969705e-03f, 1.55216694e-01f, 2.19010952e-04f, -3.59027386e-02f, -1.37215499e-02f, -1.25892490e-01f, -1.76506191e-01f, 1.37976989e-01f, 8.28116089e-02f, 6.96086586e-02f,
  -5.85658401e-02f, 1.92445517e-02f, -2.38008425e-02f, 4.74492386e-02f, 5.24074063e-02f, -9.01992898e-03f, -4.75781411e-02f, 1.17994100e-01f, -8.44783038e-02f, -1.00025579e-01f,
  -7.92242289e-02f, -3.54900092e-01f, 1.15962178e-01f, -9.71856639e-02f, 4.14121561e-02f, 9.21467617e-02f, 1.08485566e-02f, -2.66722906e-02f, -2.53512729e-02f, -5.24063222e-02f,
  -8.12850744e-02f, 4.16184217e-02f, 1.17435604e-01f, 1.16657265e-01f, -8.52250531e-02f, -1.61218897e-01f, 1.64160758e-01f, 1.78322215e-02f, 7.03791901e-02f, 1.99354738e-01f,
  3.37254167e-01f, 1.90193877e-01f, 1.15530856e-01f, 2.39091679e-01f, 1.38278559e-01f, -1.37923673e-01f, 5.60800359e-02f, 1.17517948e-01f, 8.66886973e-02f, 3.88524443e-01f,
  8.00197005e-01f, -8.12087715e-01f, -5.70462942e-01f, 5.85698366e-01f, 3.05673629e-01f, 2.12891757e-01f, -1.21469595e-01f, 5.69707513e-01f, 6.36721551e-01f, -3.62664536e-02f,
  -4.73485202e-01f, -4.17864293e-01f, -3.90780389e-01f, -3.99062961e-01f, -3.03827018e-01f, -2.66971201e-01f, -1.96280643e-01f, -1.52718425e-01f, 2.50352889e-01f, 3.61081302e-01f,
  1.60530150e-01f, 4.47046280e-01f, 3.23387176e-01f, 2.87811667e-01f, 1.82151352e-03f, -7.10051730e-02f, -3.14298034e-01f, -1.82454526e-01f, -6.52706504e-01f, -5.99239469e-01f,
  -6.02943778e-01f, -3.20717514e-01f, 1.67161003e-01f, -8.85975882e-02f, -5.46664037e-02f, -4.68796724e-03f, 1.12561258e-02f, 1.16779536e-01f, 6.10039644e-02f, -8.57425183e-02f,
  -1.17888995e-01f, -4.55998220e-02f, -9.57958773e-02f, -1.78749859e-01f, 2.46362001e-01f, 1.33436359e-02f, -5.53729795e-02f, -5.93916960e-02f, -9.98254344e-02f, -1.52695939e-01f,
  -4.15300131e-01f, -1.46725878e-01f, -7.49208927e-02f, -3.12382504e-02f, -4.53421250e-02f, 1.58535666e-03f, -7.35537410e-02f, 6.87055439e-02f, -7.84454197e-02f, 1.27379656e-01f,
  9.36761219e-03f, -6.51184395e-02f, 6.23337645e-03f, 8.10504556e-02f, 1.56975776e-01f, 6.46701455e-03f, -9.72885787e-02f, -4.20662239e-02f, -4.86511588e-02f, 6.80764392e-02f,
  6.73163042e-04f, -5.01417667e-02f, -8.24801102e-02f, -6.54158443e-02f, -2.08856791e-01f, -1.04028061e-01f, -1.10128382e-02f, -5.23127727e-02f, -1.00887574e-01f, -8.05674121e-02f,
  -5.45787141e-02f, -8.81952792e-02f, 6.86307577e-03f, -5.11122271e-02f, -2.39094123e-01f, -1.00714967e-01f, -1.95766971e-01f, -4.82504219e-02f, 3.30011398e-02f, -6.22909479e-02f,
  2.90257007e-01f, -4.03938860e-01f, 4.32711169e-02f, -1.23891406e-01f, -4.60067950e-02f, -1.47070184e-01f, -4.21670407e-01f, -6.19509928e-02f, 1.59656361e-03f, -5.45830950e-02f,
  -1.77616164e-01f, -1.25566065e-01f, -9.49651673e-02f, -3.35982442e-02f, 3.05438012e-01f, -3.07079460e-02f, -7.46525750e-02f, -1.55443519e-01f, -5.00909835e-02f, 9.67087299e-02f,
  -5.20589668e-03f, 2.18284726e-01f, 3.66748184e-01f, 1.43798187e-01f, 1.12757877e-01f, 2.05896050e-01f, 9.65091214e-02f, 1.41505599e-01f, 6.88361600e-02f, 4.15376365e-01f,
  7.31917500e-01f, 2.20717132e-01f, -9.92294997e-02f, 8.88307616e-02f, -2.71934062e-01f, -4.16608006e-02f, 5.63034555e-03f, 2.05967009e-01f, 2.33083442e-01f, 7.40229934e-02f,
  2.16232911e-01f, 2.88770884e-01f, 2.76287675e-01f, 2.06128061e-01f, 2.66731858e-01f, 7.78604075e-02f, 5.04882187e-02f, 2.02243164e-01f, 5.44572175e-02f, -1.33681893e-01f,
  6.96961349e-03f, -5.99335581e-02f, 1.51626766e-01f, 9.19424146e-02f, -3.68715040e-02f, 5.84184602e-02f, 1.14614010e-01f, -1.66859180e-01f, -2.09038749e-01f, -1.30992368e-01f,
  -4.63921279e-01f, -1.12044327e-01f, 1.53515115e-01f, 1.44880414e-01f, 1.56374246e-01f, 1.98949665e-01f, 1.01187088e-01f, -5.37277684e-02f, 5.01927473e-02f, 2.04564389e-02f,
  3.85355763e-02f, 7.15404656e-03f, -4.71732058e-02f, -4.02645171e-02f, -1.53191775e-01f, -3.02538406e-02f, 3.88131291e-02f, 1.27767950e-01f, 1.23079360e-01f, 4.15213332e-02f,
  -1.10214781e-02f, -1.72693819e-01f, -1.29033133e-01f, 1.41956016e-01f, 1.49615318e-01f, 1.45827919e-01f, 6.92084339e-03f, -1.68874785e-02f, 8.40727165e-02f, -1.61809735e-02f,
  2.49438003e-01f, 1.31624550e-01f, -1.69621278e-02f, 2.78514624e-03f, 7.19051389e-03f, -7.78595880e-02f, -1.24630302e-01f, 7.94313625e-02f, 1.32459998e-01f, 7.44307637e-02f,
  -5.08447215e-02f, -9.03619360e-03f, 1.55076338e-02f, -2.17287615e-02f, 1.23013973e-01f, -8.37740749e-02f, -1.44713491e-01f, -4.60035354e-02f, -1.02570981e-01f, -2.28371471e-03f,
  -1.19299166e-01f, -7.98478648e-02f, 1.45912673e-02f, -2.15374202e-01f, -6.92715347e-02f, 3.80354337e-02f, -8.63015652e-02f, 4.71628532e-02f, 3.27397548e-02f, -3.72501090e-02f,
  -5.13284393e-02f, 1.21872298e-01f, -4.06902283e-02f, 6.20215237e-02f, -9.23037305e-02f, 4.44546714e-02f, 4.27080356e-02f, -1.41379356e-01f, -2.25435212e-01f, -1.49516910e-01f,
  -1.46070376e-01f, 2.18887776e-02f, -1.96138886e-03f, -6.52241632e-02f, -1.45583197e-01f, 5.14850672e-03f, 5.71837127e-02f, 5.82576655e-02f, -3.26688886e-02f, -9.85718295e-02f,
  1.99949928e-02f, -7.55543709e-02f, -3.39601934e-03f, 5.60898855e-02f, -2.87104510e-02f, 5.08016832e-02f, -6.63499758e-02f, -7.73050264e-02f, -3.38150151e-02f, -2.56528449e-03f,
  -3.05980921e-01f, 1.11411132e-01f, -3.47948149e-02f, 4.35358077e-01f, 3.89277756e-01f, 4.29816186e-01f, 4.16746408e-01f, 3.63086522e-01f, 2.80233055e-01f, 2.96131074e-01f,
  3.56663227e-01f, 3.45793158e-01f, 2.89520919e-01f, 2.85213411e-01f, 2.55062670e-01f, 4.14022118e-01f, 4.37416315e-01f, -1.20342076e-02f, -5.65922298e-02f, 2.95006335e-01f,
  3.73629481e-01f, 1.45292416e-01f, -1.32637113e-01f, 9.80957970e-02f, 2.98518777e-01f, 3.17491025e-01f, 2.62074828e-01f, 3.36740017e-01f, 2.96843946e-01f, 2.10637540e-01f,
  -1.39439076e-01f, -1.62056863e-01f, -4.90927091e-03f, -2.44534342e-03f, -1.38158798e-01f, -2.35571310e-01f, -7.98136517e-02f, -4.55997586e-02f, 1.23747000e-02f, -1.05223870e-02f,
  -7.72277117e-02f, -2.55608670e-02f, 3.27311121e-02f, -1.19186901e-02f, -1.36815190e-01f, -1.16366059e-01f, -6.65023476e-02f, 4.24197502e-02f, 1.83427587e-01f, 1.11611247e-01f,
  4.24735621e-02f, 6.57637939e-02f, 4.70814519e-02f, -6.24942640e-03f, 4.79587205e-02f, -9.66199394e-03f, -1.19094029e-01f, -1.38573602e-01f, -1.01735175e-01f, 4.28513512e-02f,
  2.09135905e-01f, 1.01692915e-01f, 1.57438412e-01f, 1.84257835e-01f, 1.25706811e-02f, -7.15272152e-04f, -7.78404716e-03f, 1.24792978e-01f, 5.89368157e-02f, 1.38392551e-02f,
  -1.45429755e-02f, 1.40652299e-01f, 4.68568988e-02f, 6.97287917e-02f, 5.01123741e-02f, 1.00272790e-01f, -5.81370620e-03f, -3.19313109e-02f, -3.53644080e-02f, 1.77241000e-03f,
  -2.32163569e-04f, -6.45854250e-02f, -1.53173044e-01f, 5.00900950e-03f, 6.82100579e-02f, 1.77699663e-02f, 4.94285636e-02f, 9.31684971e-02f, -2.26361956e-02f, -2.78490447e-02f,
  3.75889897e-01f, -4.43041371e-03f, -6.79011419e-02f, -2.10445449e-02f, -6.53540939e-02f, -2.77134091e-01f, 4.87464033e-02f, -1.01198301e-01f, -1.73870400e-01f, -4.40550037e-02f,
  -2.23754887e-02f, -1.16145916e-01f, -1.66297689e-01f, 1.59490276e-02f, -9.73156914e-02f, -1.26209751e-01f, 2.78175920e-02f, 1.66158140e-01f, 7.83452168e-02f, -2.83667129e-02f,
  7.73910945e-03f, 1.11569449e-01f, 1.17420986e-01f, -1.01804519e-02f, 7.68464506e-02f, 1.34127036e-01f, -8.02949592e-02f, -8.89436752e-02f, -8.95005614e-02f, 1.85545217e-02f,
  6.23290420e-01f, -1.81146756e-01f, 7.21578002e-02f, 9.82038453e-02f, -2.28761554e-01f, -6.40151426e-02f, -2.32226118e-01f, 3.08607742e-02f, 9.81965959e-02f, 6.67241365e-02f,
  7.65924156e-02f, 3.25784944e-02f, 4.37441058e-02f, -2.83207055e-02f, 1.49300983e-02f, -7.43231997e-02f, -1.56111956e-01f, 1.44493789e-03f, 1.82021976e-01f, 1.64748266e-01f,
  -1.46986321e-02f, 2.09734514e-02f, 5.57206683e-02f, 8.06107223e-02f, 1.91080831e-02f, 7.53075210e-03f, -1.72544152e-01f, -3.21096003e-01f, -2.62712836e-01f, -5.61137795e-02f,
  -2.90302396e-01f, -4.21196409e-02f, 3.09096545e-01f, 5.56404218e-02f, 1.59835234e-01f, 3.18476796e-01f, 1.12362325e-01f, 1.55534267e-01f, 8.02375153e-02f, 1.30512536e-01f,
  -6.94746245e-03f, 7.74230622e-03f, 4.62543182e-02f, 1.35551067e-02f, 1.26436189e-01f, 2.71928236e-02f, 1.53088614e-01f, 7.31991753e-02f, -1.37796074e-01f, -1.48941791e-02f,
  7.84844980e-02f, -1.03303589e-01f, -4.79620211e-02f, -8.21400285e-02f, 4.09788229e-02f, -7.14947730e-02f, -6.79593980e-02f, 2.15430111e-02f, 2.36894446e-03f, 1.18599236e-01f,
  -3.96137126e-02f, 2.29122713e-01f, -5.19050173e-02f, 1.38313606e-01f, 1.52641088e-01f, 2.07872555e-01f, 1.93795785e-02f, -1.78064615e-01f, -1.33743003e-01f, -4.73679639e-02f,
  8.44873264e-02f, -6.68656826e-02f, -3.04932948e-02f, 2.97932830e-02f, 3.13904434e-02f, -1.67441890e-01f, -9.23273116e-02f, -1.70620307e-02f, -1.38869002e-01f, -2.91562523e-03f,
  -5.49671203e-02f, -3.16287950e-02f, -3.55059728e-02f, -4.49303947e-02f, -4.93236482e-02f, 1.82383761e-01f, 6.44336222e-03f, -1.52624995e-01f, -8.05395022e-02f, -6.43353686e-02f,
  -2.55345017e-01f, -2.16234118e-01f, 1.25034556e-01f, -3.97076495e-02f, 3.98121178e-02f, 2.05289766e-01f, 1.48916110e-01f, 5.91003709e-02f, 1.27067203e-02f, 9.25705880e-02f,
  1.39011130e-01f, 1.86828956e-01f, 1.45703256e-01f, 3.27110104e-02f, 1.80234894e-01f, 1.95426613e-01f, 1.10785671e-01f, 1.58706635e-01f, 3.83066051e-02f, 6.17756285e-02f,
  8.66715908e-02f, 1.35785788e-01f, 1.62876129e-01f, 1.38663605e-01f, 2.24596523e-02f, 1.25324234e-01f, 4.45840769e-02f, 2.53723133e-02f, -3.39465030e-02f, 9.54560563e-02f,
  -7.39106387e-02f, -1.54547960e-01f, -3.60067874e-01f, 1.84576176e-02f, 1.89717636e-01f, 3.27127017e-02f, -2.70529926e-01f, -3.86167228e-01f, -6.30981997e-02f, 6.58725277e-02f,
  2.92142276e-02f, 2.48684660e-01f, 2.14198902e-01f, 2.16189265e-01f, 4.34893481e-02f, -4.81596924e-02f, 2.66024381e-01f, 1.81147248e-01f, 4.60449718e-02f, 2.45808944e-01f,
  5.08675873e-01f, 1.23354554e-01f, 2.48390734e-01f, 1.48473948e-01f, 1.27817869e-01f, 2.77664870e-01f, -9.23420712e-02f, 1.79075107e-01f, 5.30184448e-01f, 5.00995040e-01f,
  -3.37122470e-01f, -3.26523542e-01f, 7.49067664e-02f, 1.16115667e-01f, 1.67310819e-01f, 1.24792457e-01f, 1.97113112e-01f, 1.03757903e-01f, 1.88447058e-01f, 1.90206364e-01f,
  2.19998583e-01f, 1.41764238e-01f, 1.43083647e-01f, 3.60332057e-02f, -9.47355032e-02f, -1.37511805e-01f, -1.11045152e-01f, -2.34462872e-01f, -4.32663381e-01f, -8.27614665e-02f,
  6.87819481e-01f, 3.03590238e-01f, -3.84138018e-01f, -3.15318614e-01f, -3.16906095e-01f, 2.25572869e-01f, -2.73488581e-01f, -6.46843091e-02f, -3.51148874e-01f, -7.46003389e-02f,
  3.68111534e-03f, -3.47337574e-02f, 1.24811614e-02f, -8.65586028e-02f, 3.15135680e-02f, -7.75948986e-02f, 9.18497797e-03f, -5.06562591e-02f, 7.17671216e-02f, -2.20960200e-01f,
  -1.08734630e-01f, -9.19371843e-03f, -2.38300458e-01f, -1.55959767e-03f, 2.65119374e-01f, -1.24986969e-01f, 9.74843577e-02f, 2.01128066e-01f, 1.35575971e-02f, -1.27543822e-01f,
  -7.58457184e-03f, -1.44916251e-01f, 8.96035880e-02f, -2.00299695e-01f, 8.44894275e-02f, -1.03599779e-01f, 2.26189524e-01f, 2.32978076e-01f, 3.72485667e-02f, 1.94357201e-01f,
  -4.89943653e-01f, 1.45350918e-01f, -2.09550962e-01f, -3.00296694e-01f, -2.68621802e-01f, 1.01924632e-02f, -2.06838548e-01f, 5.43708578e-02f, -2.13521272e-01f, -1.16348207e-01f,
  -2.20376641e-01f, -1.76678151e-01f, -1.45891577e-01f, 5.39011806e-02f, 8.72296318e-02f, -2.48892471e-01f, -8.87118578e-02f, -2.58160889e-01f, -4.18527395e-01f, -2.54796475e-01f,
  6.66600689e-02f, -3.78641993e-01f, -3.38920444e-01f, -4.11623865e-01f, -9.02220532e-02f, 2.40710303e-01f, -1.63070962e-01f, -2.84172893e-01f, -4.70139623e-01f, -3.29418033e-01f,
  1.32077610e+00f, -2.48888731e-01f, -1.03984880e+00f, 6.26506135e-02f, -3.65845472e-01f, -3.28247786e-01f, -3.78422350e-01f, -2.52175219e-02f, 6.96064606e-02f, -2.81332105e-01f,
  -1.04043104e-01f, 4.12246168e-01f, 1.17685571e-01f, 1.05590232e-01f, 2.66194969e-01f, -4.78736758e-01f, -6.67634964e-01f, -1.21394463e-01f, 3.62856835e-01f, 3.11414450e-01f,
  1.58204436e-01f, 1.58703804e-01f, 3.38827908e-01f, 1.39626056e-01f, -3.65801305e-01f, -8.26204419e-02f, -6.57104731e-01f, -1.70692697e-01f, -2.26084337e-01f, -5.04527688e-01f,
  -5.42917609e-01f, -2.93564409e-01f, -8.77917856e-02f, 2.21888885e-01f, 7.78767420e-03f, 1.44100219e-01f, -6.90573710e-04f, -9.03714597e-02f, 1.08368598e-01f, 3.54882376e-03f,
  6.34495839e-02f, 4.75506783e-02f, 2.59591304e-02f, 5.49480729e-02f, -7.26250112e-02f, 1.41664917e-04f, -1.61256582e-01f, 3.87392752e-02f, 9.71470550e-02f, -7.06201419e-02f,
  -4.47656251e-02f, -1.49255143e-02f, -1.37195498e-01f, -5.93791306e-02f, -5.60306804e-03f, -2.79464554e-02f, -1.46409035e-01f, 3.14682387e-02f, -6.74004778e-02f, -1.55567974e-01f,
  9.40409824e-02f, 6.90409774e-03f, -6.26784749e-03f, 8.29756930e-02f, 2.64350861e-01f, -1.24457002e-01f, 9.42807570e-02f, 1.91012457e-01f, 1.02882616e-01f, 2.13318571e-01f,
  -1.82545967e-02f, -4.92251553e-02f, -7.04310089e-02f, -1.24199845e-01f, -8.17175731e-02f, 6.20037615e-02f, -3.21526751e-02f, -8.12610164e-02f, 1.41317949e-01f, 9.06852707e-02f,
  1.08744018e-01f, 8.23958442e-02f, 1.38796670e-02f, 1.88631922e-01f, -1.17904082e-01f, 4.41026576e-02f, 6.31470159e-02f, 1.08909324e-01f, 2.12627172e-01f, 6.16539530e-02f,
  9.70490277e-02f, -3.95763144e-02f, -1.12683691e-01f, 1.17202066e-02f, -7.03757396e-03f, -1.26614168e-01f, -1.42018497e-01f, 1.07046410e-01f, 4.76629548e-02f, 7.40505829e-02f,
  -4.83941101e-02f, 1.45165354e-01f, -6.14383407e-02f, -1.53294593e-01f, -1.24282660e-02f, -1.02665924e-01f, 1.26339853e-01f, 1.29803956e-01f, 7.18162879e-02f, -8.19462687e-02f,
  1.38709066e-03f, 1.25785857e-01f, 3.08958441e-01f, 3.71015407e-02f, 3.12175918e-02f, -3.04397941e-03f, -1.48109525e-01f, -5.96420839e-02f, 1.17183506e-01f, 1.77010089e-01f,
  -1.07357836e+00f, -1.55270413e-01f, -2.45455801e-01f, -1.26927459e+00f, -6.74951136e-01f, 8.75362083e-02f, 4.39083949e-02f, -2.82286853e-01f, -7.02467978e-01f, -5.25357008e-01f,
  1.20572776e-01f, 3.84422064e-01f, 2.12806240e-01f, 3.95677656e-01f, 6.89760923e-01f, -3.19702566e-01f, -7.19221890e-01f, -3.03763505e-02f, 5.40248334e-01f, 5.32545865e-01f,
  1.51716396e-01f, -4.89375442e-01f, -2.56080151e-01f, -2.09712461e-01f, -5.71875811e-01f, -6.00612611e-02f, -7.02473521e-01f, -4.00772691e-01f, 1.06966749e-01f, -8.59816849e-01f,
  2.32722312e-01f, -3.56025845e-01f, 1.08487763e-01f, -1.02889389e-02f, -2.19491318e-01f, 7.48923421e-02f, -1.07044891e-01f, -3.59177440e-01f, 9.57173854e-02f, -3.09317142e-01f,
  -2.58647531e-01f, 3.69392224e-02f, -1.10318147e-01f, 1.13522552e-01f, -3.03421855e-01f, 7.04097971e-02f, -8.32191631e-02f, -1.19663686e-01f, -6.18839078e-02f, 3.20291400e-01f,
  2.06181362e-01f, -4.87115122e-02f, -8.89736190e-02f, 1.87958315e-01f, 3.00469369e-01f, 8.82942751e-02f, 2.63990551e-01f, 1.94978520e-01f, 1.57566443e-01f, -3.93326223e-01f,
  -6.66619465e-02f, 8.39253366e-02f, 4.17940356e-02f, -1.72016118e-02f, -6.40929386e-04f, 1.26313418e-01f, -1.58833712e-01f, -1.48663893e-01f, 1.50742710e-01f, 2.17571840e-01f,
  1.42675554e-02f, -5.60452081e-02f, 1.09485783e-01f, 2.07648575e-02f, -9.49317887e-02f, -1.26186863e-01f, 5.68975247e-02f, 1.77815873e-02f, -8.31144955e-03f, -1.49914518e-01f,
  1.08915836e-01f, 1.11617431e-01f, -5.01596555e-02f, -1.48372352e-02f, 1.36404723e-01f, -2.60598212e-01f, -4.92346250e-02f, 2.13126361e-01f, -1.00123892e-02f, 3.83814462e-02f,
  -1.41419530e-01f, 2.48826548e-01f, -3.37087780e-01f, -3.23367231e-02f, -2.55724341e-01f, 8.23996868e-03f, -2.15160429e-01f, -4.32810299e-02f, -1.63650930e-01f, -6.95682764e-02f,
  2.02597395e-01f, 7.62944669e-02f, 3.42843682e-02f, 9.43756998e-02f, -2.74752062e-02f, 9.36511979e-02f, -3.60609181e-02f, -2.45572209e-01f, 1.93045899e-01f, 4.03760672e-02f,
  9.54764150e-03f, -6.41730949e-02f, 4.38785069e-02f, 1.46116734e-01f, 2.92379782e-02f, 1.47175878e-01f, 1.93117410e-01f, 3.58653307e-01f, 1.75719053e-01f, -1.44168243e-01f,
  4.50805664e-01f, 6.31887019e-01f, -1.45586938e-01f, 2.65432149e-01f, -2.22234473e-01f, -1.95607498e-01f, 2.06776500e-01f, 2.47530445e-01f, 1.01942368e-01f, 1.28360465e-01f,
  -2.12895483e-01f, -1.77896142e-01f, -1.81540132e-01f, 1.98531281e-02f, 1.45129830e-01f, 1.58687875e-01f, 2.45952845e-01f, 1.81928035e-02f, -2.15675965e-01f, -9.72274411e-03f,
  1.18277175e-02f, 1.42185271e-01f, -1.36401821e-02f, 8.88688937e-02f, 2.44206950e-01f, -3.84467319e-02f, 6.27678037e-02f, 4.97327046e-03f, -8.18180367e-02f, 4.16620582e-01f,
  -4.32822615e-01f, -2.68427413e-02f, -3.65712047e-01f, -2.67904401e-01f, -7.46006370e-02f, 2.92001873e-01f, 1.59745887e-01f, 1.84860736e-01f, -2.54804380e-02f, 1.59471676e-01f,
  1.59491673e-01f, 1.12916753e-01f, 1.03943408e-01f, 1.30504295e-01f, 1.55174717e-01f, -4.12499011e-02f, 2.54432797e-01f, 2.23018721e-01f, 5.58762811e-02f, 5.30257486e-02f,
  1.18958272e-01f, -2.03208998e-01f, -2.96901852e-01f, -2.46154830e-01f, 3.38851884e-02f, -4.96565402e-01f, -2.71401256e-01f, -9.80170630e-03f, -4.33489025e-01f, 1.44484013e-01f,
  -2.29372457e-01f, 6.66706339e-02f, 1.29153594e-01f, 3.01490366e-01f, 2.55628139e-01f, 2.90280282e-02f, 2.35434577e-01f, 6.28526062e-02f, -7.92034157e-03f, 2.68642634e-01f,
  1.01402722e-01f, -1.82989568e-01f, 6.19785003e-02f, -6.39359802e-02f, -2.29512930e-01f, -1.40127569e-01f, 6.86600506e-02f, 4.22321297e-02f, -2.74717450e-01f, -2.09640097e-02f,
  6.09162040e-02f, 1.58468351e-01f, -3.99285071e-02f, 2.53950030e-01f, 1.19002257e-02f, -7.39561021e-02f, 4.55712937e-02f, 1.24811307e-01f, 1.80483814e-02f, -7.86662325e-02f,
  -2.24102616e-01f, -8.78512025e-01f, 2.07717642e-01f, 1.26687735e-01f, 6.27509058e-02f, -1.67020425e-01f, -1.82798386e-01f, -3.13748717e-01f, 4.28754464e-02f, 1.01799525e-01f,
  -1.25594616e-01f, 2.55937696e-01f, 6.79418817e-02f, 1.03915848e-01f, 1.24179609e-01f, -2.63280459e-02f, 9.95605439e-02f, 6.83203712e-02f, 1.06040396e-01f, 5.29918522e-02f,
  9.84811485e-02f, -2.56729215e-01f, -4.65632051e-01f, -1.05676994e-01f, 9.86628607e-02f, -3.40658218e-01f, -3.47725868e-01f, -2.01090261e-01f, -5.07984459e-01f, 2.84174066e-02f,
  6.51752651e-01f, 5.14565170e-01f, 4.59794194e-01f, 2.01989412e-01f, 1.22900330e-01f, 1.56821281e-01f, 3.22729915e-01f, 1.64564967e-01f, 1.13221362e-01f, 7.73315728e-02f,
  1.27916979e-02f, -7.07126781e-02f, 9.57495719e-02f, 1.03186660e-01f, 2.97700107e-01f, 1.04418933e-01f, 1.78687528e-01f, 1.12253398e-01f, 1.79982185e-01f, 4.67117056e-02f,
  4.76368628e-02f, 9.02150758e-03f, 2.04916179e-01f, 1.28151208e-01f, 1.11561067e-01f, -1.29492387e-01f, -1.55937569e-02f, 1.71921059e-01f, 1.60487860e-01f, 1.30216122e-01f,
  -1.17935494e-01f, 2.22471595e-01f, -2.46231347e-01f, -1.90349281e-01f, 5.83584048e-02f, -1.21620037e-01f, -5.84769025e-02f, -1.00159861e-01f, -8.12660977e-02f, -6.18471391e-02f,
  -1.28827691e-01f, -7.74633288e-02f, 7.27939829e-02f, -2.71686236e-04f, 1.02340458e-02f, 2.43135057e-02f, 6.60184100e-02f, 1.75481796e-01f, 1.50471449e-01f, 1.09259769e-01f,
  -1.38475806e-01f, -1.25468493e-01f, 7.52391592e-02f, 1.31650642e-01f, 2.53063411e-01f, -1.36086240e-01f, 7.11506307e-02f, 3.74267846e-02f, 1.72117241e-02f, 2.00319082e-01f,
  -1.64970264e-01f, 2.64252961e-01f, 2.22622395e-01f, 3.25509347e-02f, 5.18980511e-02f, 8.83180052e-02f, 1.15959384e-02f, -6.97194086e-03f, 7.48575032e-02f, 1.35979265e-01f,
  -2.25366261e-02f, 8.24608356e-02f, 2.48349495e-02f, 1.26767427e-01f, 2.43563987e-02f, 1.16080739e-01f, 1.13553472e-01f, -1.27820494e-02f, -3.27459052e-02f, -1.58021659e-01f,
  -2.87574250e-02f, -1.06847854e-02f, -1.67740896e-01f, 1.23864427e-01f, -1.11480378e-01f, -3.07007357e-02f, -6.98954985e-02f, -6.03367537e-02f, -4.41130102e-02f, -1.90301850e-01f,
  -5.91153443e-01f, -1.62892848e-01f, -1.24434106e-01f, -1.32564351e-01f, 9.12930444e-02f, -8.80788937e-02f, 6.73085600e-02f, 9.52633657e-03f, -1.43784449e-01f, -9.70532373e-02f,
  -5.62202558e-03f, -6.65660482e-03f, -1.61764454e-02f, -8.92938599e-02f, -7.57814050e-02f, -1.68026328e-01f, -1.53115049e-01f, -1.24759369e-01f, -9.29179043e-02f, -1.52742013e-01f,
  -1.22837581e-01f, -1.21236585e-01f, -2.14782894e-01f, -3.45494375e-02f, -1.01319432e-01f, -3.14041436e-01f, -1.64275602e-01f, -1.60781443e-01f, -5.36747053e-02f, -6.43565729e-02f,
  6.75303578e-01f, 2.16605768e-01f, 2.24910334e-01f, 1.34954974e-01f, -1.16377056e-01f, -3.65268260e-01f, -4.41684008e-01f, -3.35737169e-01f, -1.11117721e-01f, 1.32996574e-01f,
  1.66012987e-01f, 1.94420159e-01f, 2.51478422e-02f, 7.97122940e-02f, -8.45236257e-02f, -2.51663923e-01f, -2.03075543e-01f, 1.24276191e-01f, 7.54268989e-02f, 5.98294064e-02f,
  -1.33625576e-02f, 1.18406326e-01f, 3.67947310e-01f, 1.03790864e-01f, 2.25013852e-01f, 2.30261043e-01f, 2.75572538e-02f, 1.54345438e-01f, 1.25444949e-01f, 3.15146893e-01f,
  5.30853689e-01f, 2.40755379e-01f, -1.19850628e-01f, 2.17249662e-01f, 2.81207234e-01f, 7.15054944e-02f, -3.48600447e-02f, 1.88100506e-02f, -2.07312465e-01f, -1.93739012e-01f,
  1.86912462e-01f, 1.35961547e-01f, 1.12762950e-01f, 2.25221738e-02f, -4.62445896e-03f, -1.01354055e-01f, -1.56332165e-01f, -1.19282827e-01f, -2.49449462e-01f, 4.25012372e-02f,
  -6.47766590e-02f, 7.76187778e-02f, -1.89992785e-01f, -3.03964972e-01f, -2.12548062e-01f, 6.21627755e-02f, -4.16730456e-02f, 9.81437713e-02f, -2.87200678e-02f, 2.99882628e-02f,
  4.84514516e-03f, -6.61093891e-02f, 1.22517899e-01f, -1.00323953e-01f, -4.24816534e-02f, -1.31181076e-01f, -4.99183424e-02f, -1.34566098e-01f, -9.69330370e-02f, 3.86757590e-02f,
  -4.78903577e-02f, -5.28880395e-02f, -1.85067981e-01f, -2.06794273e-02f, 2.23095924e-01f, 4.77255322e-02f, -2.21640039e-02f, -4.33318876e-02f, 1.12800911e-01f, 4.71108891e-02f,
  6.26641065e-02f, -1.64097711e-01f, 2.48977721e-01f, -7.85431545e-03f, -1.24349698e-01f, -7.75098279e-02f, -4.30740835e-03f, -4.47687432e-02f, 7.68355429e-02f, -1.01603583e-01f,
  -1.00455284e-01f, -7.93530419e-03f, 6.32078871e-02f, -5.50851226e-03f, 2.74147779e-01f, 2.92243034e-01f, 1.86240032e-01f, 1.96491614e-01f, 6.52226210e-02f, -1.62871972e-01f,
  5.82420640e-02f, 8.45968127e-02f, 1.02036960e-01f, 1.55348936e-02f, 5.75552024e-02f, -3.13429278e-03f, 1.12048730e-01f, -6.44010454e-02f, -1.33961305e-01f, 1.18292682e-01f,
  -1.09748386e-01f, -2.68351346e-01f, -2.76335210e-01f, -2.35100895e-01f, -1.60532534e-01f, -1.57242883e-02f, -1.02760298e-02f, 2.31880005e-02f, 2.11100392e-02f, -1.47054493e-01f,
  1.47481227e+00f, 6.69074893e-01f, -1.14395845e+00f, 6.22552037e-01f, -8.01533163e-01f, -9.07994568e-01f, -4.72266942e-01f, 1.27694786e-01f, 3.72321635e-01f, 2.18426377e-01f,
  -2.10004255e-01f, 7.50015453e-02f, 1.94946408e-01f, -1.33883461e-01f, -7.22180381e-02f, -1.13786563e-01f, -2.79557616e-01f, -5.79247057e-01f, -7.17831612e-01f, -3.49419683e-01f,
  2.25459293e-01f, 6.33371472e-01f, 3.99282366e-01f, 4.15769592e-03f, 2.44678408e-01f, -1.56067073e-01f, -1.55497476e-01f, 5.61055392e-02f, -2.55554289e-01f, 2.05527231e-01f,
  -1.32795379e-01f, -3.26663628e-02f, -6.60950065e-01f, 1.13491781e-01f, -2.88774550e-01f, 1.53907210e-01f, 9.86332893e-02f, -3.07870377e-02f, -3.35495695e-02f, 1.94369450e-01f,
  -1.88714176e-01f, -1.26958817e-01f, -3.81393358e-02f, -1.28285997e-02f, 1.47336898e-02f, -7.35068647e-03f, 3.83729860e-02f, -9.50703472e-02f, -2.59304009e-02f, -1.49759501e-01f,
  9.09130462e-03f, -5.49573481e-01f, -7.67617643e-01f, -3.87109727e-01f, -4.26058590e-01f, -3.19529235e-01f, -4.87638205e-01f, -3.66787642e-01f, -6.09959066e-01f, 7.79935241e-01f,
  5.83557636e-02f, 1.06374346e-01f, -6.37469664e-02f, -7.40697160e-02f, 2.44922742e-01f, -9.07310937e-03f, -1.78664215e-02f, -4.20408547e-02f, -6.47178036e-04f, 1.39560431e-01f,
  -1.74151331e-01f, 1.19841367e-01f, -6.63347319e-02f, 8.78581405e-02f, 1.81350306e-01f, -8.51673335e-02f, -1.42850697e-01f, 3.08750644e-02f, -1.66065350e-01f, 1.30849034e-01f,
  -3.54438201e-02f, -2.39621207e-01f, 6.30932599e-02f, -4.35225852e-02f, -1.80941850e-01f, -2.65319422e-02f, -2.64702621e-03f, -9.92901716e-03f, 2.16797411e-01f, 9.02219675e-03f,
  8.10918987e-01f, -3.67942452e-01f, 4.14648592e-01f, -1.44157141e-01f, 1.59861594e-02f, 4.56569195e-02f, 1.04362138e-01f, -1.70834631e-01f, 4.92422730e-02f, -7.56868720e-02f,
  -3.02223742e-01f, 1.26945525e-01f, 2.11620957e-01f, -2.56451182e-02f, -6.26993179e-02f, -1.31218350e-02f, 2.00160444e-01f, -2.15401232e-01f, -7.74779618e-02f, 9.46045220e-02f,
  3.99734378e-01f, 1.46635458e-01f, 7.04969838e-02f, 1.34177521e-01f, 2.81511813e-01f, 2.32910439e-02f, 1.08444072e-01f, -4.97818626e-02f, -3.28927159e-01f, 8.26598883e-01f,
  7.67321348e-01f, 6.42062426e-01f, 5.48009239e-02f, 2.59435654e-01f, 1.76953584e-01f, 2.51818478e-01f, 4.69148219e-01f, 3.02837372e-01f, 2.47421339e-02f, 2.72679448e-01f,
  4.64602023e-01f, 2.51236051e-01f, 2.44857013e-01f, 9.40862596e-02f, 1.56465754e-01f, -5.08571044e-02f, -1.92170143e-01f, -1.05734095e-01f, -1.39872417e-01f, 6.30623698e-02f,
  -1.16662411e-02f, 2.14224681e-01f, 1.48005649e-01f, -1.07906260e-01f, 2.01291025e-01f, 3.11722569e-02f, 1.32402778e-01f, 2.41188377e-01f, 1.14176475e-01f, -5.03849499e-02f,
  -9.22666937e-02f, 3.60685170e-01f, -3.46590966e-01f, 7.61253666e-03f, -3.66091635e-03f, -1.02725096e-01f, -1.31457910e-01f, -1.18780546e-01f, -1.97738837e-02f, -7.80178607e-02f,
  4.69618514e-02f, 2.36277394e-02f, -5.71844615e-02f, -1.58133600e-02f, -7.01227188e-02f, -1.32624865e-01f, -4.67884988e-02f, -4.83072177e-02f, -1.39718220e-01f, -6.64814785e-02f,
  3.88662145e-02f, 7.44112954e-02f, 7.91787282e-02f, -7.53200352e-02f, -1.74994767e-02f, -1.63819581e-01f, 9.34486836e-03f, -1.68496501e-02f, -1.09136909e-01f, -2.31730733e-02f,
  -3.25420231e-01f, -2.75721550e-02f, -2.68964116e-02f, -2.44378835e-01f, -9.35550779e-02f, -2.73719370e-01f, -2.14774311e-01f, 1.77641455e-02f, 4.29828698e-03f, 1.05147697e-02f,
  -1.16216242e-01f, -5.99579886e-02f, -8.03603455e-02f, -1.81364208e-01f, -2.16759667e-01f, -6.27347231e-02f, -3.87116731e-03f, -2.10725754e-01f, -1.80706993e-01f, -2.76777949e-02f,
  -5.43104559e-02f, -1.31231025e-01f, -9.07511339e-02f, -1.07132010e-01f, -2.13942185e-01f, -1.14733435e-01f, -2.20513359e-01f, -1.40980199e-01f, -7.01371804e-02f, 5.79251014e-02f,
  -3.22425574e-01f, -1.65460389e-02f, -1.06501512e-01f, 1.34990932e-02f, 1.86573565e-01f, 4.62194718e-02f, 1.78541765e-01f, 5.70920743e-02f, 6.16091304e-02f, -1.14792466e-01f,
  -2.37646792e-02f, -2.36735195e-02f, 1.11870028e-01f, -3.97828557e-02f, -1.33964404e-01f, -9.78371650e-02f, 1.23467006e-01f, 4.61237095e-02f, -2.09637061e-01f, -8.16021040e-02f,
  -2.26915047e-01f, -2.70304263e-01f, -1.16596952e-01f, -2.35264421e-01f, -1.02578998e-01f, -3.07129771e-01f, -6.29762858e-02f, -1.62218586e-01f, -1.71562731e-01f, -2.45077148e-01f,
  -6.73866689e-01f, -4.60671514e-01f, 2.37512931e-01f, 2.07887813e-01f, 4.46339577e-01f, 4.08006310e-01f, 3.53367329e-01f, 1.57800242e-01f, 3.03352028e-02f, -7.49904513e-02f,
  -1.69299409e-01f, -5.01818508e-02f, -9.90961343e-02f, 3.96269448e-02f, 7.66933039e-02f, 3.17520857e-01f, 3.26678365e-01f, 6.91938102e-02f, 1.08588643e-01f, 1.33131534e-01f,
  8.59848633e-02f, 7.62902871e-02f, -2.61265993e-01f, -2.17965664e-03f, 2.14976668e-02f, 8.13300759e-02f, 1.38910592e-01f, 1.61294624e-01f, 6.12243675e-02f, 1.59319304e-02f,
  3.06480378e-02f, -4.20783430e-01f, 4.05174606e-02f, -1.79851681e-01f, -2.15082034e-01f, -3.00821066e-01f, -1.11473009e-01f, -8.94823149e-02f, -6.47788346e-02f, 4.11639698e-02f,
  -2.74680480e-02f, -1.50528744e-01f, -4.99509051e-02f, 3.01382709e-02f, 1.12339936e-01f, -3.66632603e-02f, -1.76487640e-01f, -9.34597943e-03f, 9.20201242e-02f, -8.01452249e-02f,
  -1.49629757e-01f, -1.19970299e-01f, 1.80123106e-01f, 7.91283399e-02f, 1.32025946e-02f, -4.18540323e-03f, -1.87939152e-01f, -5.30676991e-02f, -7.12921768e-02f, -1.18172951e-01f,
  -7.69569203e-02f, -1.63265839e-01f, -2.08270937e-01f, -3.10250819e-02f, -3.31974514e-02f, 2.37998385e-02f, 1.48374319e-01f, 1.29833713e-01f, 1.31646082e-01f, -3.38293798e-02f,
  1.15022674e-01f, 1.47022203e-01f, -8.95252898e-02f, 4.21318635e-02f, -9.65823308e-02f, -1.56024948e-01f, -1.13240570e-01f, -2.06566945e-01f, -1.40368909e-01f, -1.22268006e-01f,
  3.41266580e-03f, 4.87229638e-02f, -1.52218774e-01f, -8.42015967e-02f, -1.18564062e-01f, 1.61365289e-02f, 4.06992063e-02f, 2.40968578e-02f, -1.06051154e-02f, 4.16117311e-02f,
  4.36421186e-01f, 6.85834661e-02f, 8.54270905e-02f, -9.21995044e-02f, 7.71452149e-04f, -2.73345798e-01f, -4.11122032e-02f, -1.02743022e-01f, -4.86358674e-03f, 4.37405147e-02f,
  4.08956856e-02f, -1.39443755e-01f, 4.07720245e-02f, 5.16520031e-02f, 1.53323710e-01f, 1.09108604e-01f, -1.26179785e-01f, -4.04493250e-02f, 3.93325612e-02f, 8.26962665e-02f,
  -9.64348763e-02f, 1.46673724e-01f, 1.96050867e-01f, 2.28756130e-01f, 1.07480489e-01f, 1.62800148e-01f, 1.68475255e-01f, 5.34691662e-02f, 1.33351922e-01f, 2.00511754e-01f,
  2.62619048e-01f, 2.27820382e-01f, 5.98423660e-01f, -3.11444283e-01f, -5.32446742e-01f, -3.34400594e-01f, -1.20375857e-01f, -2.36368641e-01f, -4.28331435e-01f, -2.67610520e-01f,
  -4.57571924e-01f, -4.68491882e-01f, -2.31277853e-01f, 1.29908724e-02f, 3.63086611e-01f, 1.36273354e-01f, 3.68634582e-01f, 5.72226346e-01f, 4.10457939e-01f, -6.98224595e-03f,
  -1.67790398e-01f, 4.02428448e-01f, 4.64609236e-01f, 4.11905646e-01f, 3.74347009e-02f, -9.64613929e-02f, 1.60901889e-01f, 6.62603080e-02f, 1.08623020e-01f, 1.87490240e-01f,
  1.41358778e-01f, 2.00273305e-01f, -1.22153573e-01f, 6.19785022e-03f, 1.35896996e-01f, -3.32136601e-02f, 1.38260731e-02f, 5.95923513e-02f, -6.23561218e-02f, -6.44404814e-02f,
  -8.59571621e-02f, 5.19053778e-03f, -1.44707918e-01f, 1.67546384e-02f, -8.04247558e-02f, -4.76787761e-02f, 1.53939784e-01f, 3.11714441e-01f, 1.46401033e-01f, 4.00381424e-02f,
  -2.81157583e-01f, -7.72575960e-02f, 1.25149131e-01f, -4.43890318e-02f, 3.63829024e-02f, -6.16740882e-02f, 2.51947157e-02f, -7.43229315e-02f, 1.46086589e-01f, -8.71882811e-02f,
  -3.37912023e-01f, 1.54362559e-01f, 1.45352915e-01f, -6.85760677e-02f, -1.29303902e-01f, -1.66342303e-01f, -1.27942726e-01f, 7.58645707e-04f, -8.87217447e-02f, 1.22159980e-02f,
  -1.05186738e-01f, -6.15060478e-02f, -4.87066470e-02f, -7.95586705e-02f, -4.56697606e-02f, 9.75097939e-02f, -6.71722814e-02f, -9.04171448e-03f, 4.88393679e-02f, -1.02877319e-01f,
  -8.13056678e-02f, -5.08862473e-02f, 3.88785675e-02f, 1.55809268e-01f, -1.06685780e-01f, 2.58931201e-02f, -1.10234596e-01f, -1.85170814e-01f, 1.04885884e-01f, -5.63714467e-02f,
  -9.34461355e-02f, 3.69755663e-02f, -2.77579725e-01f, 6.88827634e-02f, 1.34119973e-01f, 1.23295851e-01f, -1.14764906e-01f, 6.77717733e-04f, -5.00868447e-02f, 9.12894309e-02f,
  4.76242825e-02f, -2.50865500e-02f, 6.96143322e-03f, 1.32603765e-01f, -1.07206203e-01f, -1.37371883e-01f, -4.81296703e-02f, -8.43606815e-02f, -4.26797941e-02f, 4.56618518e-02f,
  1.21937528e-01f, -3.77030708e-02f, -2.44919196e-01f, -3.25526327e-01f, -3.06605160e-01f, -2.49182627e-01f, -1.93919316e-02f, -1.77409306e-01f, -6.41135573e-02f, -1.30339175e-01f,
  4.16186541e-01f, -3.66597116e-01f, 2.87777811e-01f, 2.97140002e-01f, 2.90460587e-01f, 6.04458898e-02f, -9.95230824e-02f, -6.69148266e-02f, 1.60994202e-01f, 1.01478368e-01f,
  2.66785622e-01f, 3.63241047e-01f, 3.69410396e-01f, 2.90497333e-01f, 1.98279694e-01f, -5.25378017e-03f, 8.03102776e-02f, 3.15329611e-01f, 2.33179331e-01f, 2.08275914e-01f,
  4.35734354e-02f, -3.76181081e-02f, 1.56428084e-01f, 1.44831568e-01f, 5.45981415e-02f, 1.86302900e-01f, 1.35713145e-01f, 7.77744800e-02f, 1.05707355e-01f, 1.01054721e-01f,
  1.78750575e-01f, -6.69673607e-02f, 2.23949954e-01f, 2.27042697e-02f, -4.02672999e-02f, -2.46171102e-01f, -2.59070359e-02f, -1.06331043e-01f, -1.53217509e-01f, -1.05739400e-01f,
  -2.28531975e-02f, -7.21002817e-02f, -8.69763121e-02f, -1.27808601e-01f, -9.69831124e-02f, -1.60782576e-01f, -4.08141389e-02f, -9.27837640e-02f, 1.34247810e-01f, -1.03628509e-01f,
  5.96917346e-02f, -9.60641131e-02f, -7.83030018e-02f, -8.81103575e-02f, 1.32554367e-01f, 1.46871552e-01f, -3.87865379e-02f, 3.68770882e-02f, -1.14747947e-02f, -1.19490772e-01f,
  3.20589274e-01f, 1.11862741e-01f, 2.78609455e-01f, -2.42525358e-02f, 2.50026196e-01f, 4.70479168e-02f, 6.30632043e-02f, -4.42031138e-02f, 7.51754194e-02f, -5.54990023e-02f,
  5.60606318e-03f, 9.40041691e-02f, -2.12766957e-02f, -4.54324819e-02f, 1.52305067e-01f, 2.17829365e-02f, -1.20737046e-01f, -3.35498638e-02f, 1.77681267e-01f, -3.53107564e-02f,
  7.15207681e-02f, -4.89271507e-02f, 1.21072344e-01f, -3.90139967e-02f, 3.30987200e-02f, 1.35896176e-01f, 1.26637161e-01f, 8.01639482e-02f, 9.78782624e-02f, -1.96282174e-02f,
  -5.60979486e-01f, 3.58519495e-01f, 9.95330364e-02f, -8.39477926e-02f, -2.57208757e-02f, -1.05313156e-02f, 6.99096546e-02f, -1.00197874e-01f, -1.25047714e-01f, -1.54106900e-01f,
  -1.54713765e-01f, -7.94657916e-02f, -4.69496921e-02f, -1.12146802e-01f, -7.07181543e-02f, -7.37036765e-02f, -7.41653610e-03f, -8.24203789e-02f, -7.22735301e-02f, -6.48960546e-02f,
  2.93684984e-03f, -6.81430250e-02f, -1.92292199e-01f, -4.71561514e-02f, 2.67291199e-02f, 5.25942305e-03f, 1.72686409e-02f, -1.54493880e-02f, -2.11222209e-02f, -5.28647602e-02f,
  9.16295528e-01f, -4.50303644e-01f, 1.00820012e-01f, 6.48126230e-02f, 3.81171256e-02f, 7.78711513e-02f, -3.34796906e-02f, 5.35125136e-02f, 1.20087951e-01f, 6.80074394e-02f,
  -3.75153795e-02f, 1.02202065e-01f, 1.32474765e-01f, 5.55163473e-02f, 1.60247218e-02f, -1.10273093e-01f, -8.43842849e-02f, 1.05282240e-01f, 3.27653795e-01f, 1.02293082e-01f,
  -1.48997605e-01f, -1.71846047e-01f, 1.38289869e-01f, -9.65694487e-02f, -1.99389115e-01f, -8.42029601e-02f, -1.26484409e-01f, -1.06379755e-01f, -1.77522287e-01f, -3.03644449e-01f,
  -3.47015291e-01f, 5.30797020e-02f, 6.55516014e-02f, -1.84561938e-01f, -1.21966705e-01f, 7.43772015e-02f, 5.02631022e-03f, -1.64911628e-01f, -5.68081588e-02f, -1.89835981e-01f,
  -3.31932195e-02f, -1.04890458e-01f, 1.20017026e-02f, -2.98375692e-02f, -1.67249680e-01f, 1.30393123e-02f, 1.59437358e-02f, -1.22750722e-01f, -3.76422368e-02f, -5.72838187e-02f,
  -7.01733157e-02f, 2.17314642e-02f, 4.33628410e-02f, -4.85363193e-02f, 1.14887342e-01f, 1.96105257e-01f, -4.60539721e-02f, 7.90815279e-02f, 2.02724233e-01f, 1.12972334e-01f,
  -4.08087038e-02f, -1.45379826e-02f, 3.29557620e-02f, 1.31288290e-01f, 1.91207156e-01f, 3.84634994e-02f, -3.71424519e-02f, 7.46780308e-03f, 1.59811959e-01f, 6.94748014e-02f,
  -1.37583688e-01f, 1.57754093e-01f, 1.21214308e-01f, 1.06580975e-02f, -8.37121624e-03f, -1.08509362e-01f, -1.05160214e-01f, -1.86899841e-01f, 3.53732072e-02f, -9.68105812e-03f,
  1.54671878e-01f, -8.30975398e-02f, -6.27441555e-02f, -1.84727326e-01f, -9.32461619e-02f, -8.61104503e-02f, 4.68076393e-03f, -2.90731937e-02f, 2.71009523e-02f, -1.05833203e-01f,
  -5.69423735e-01f, 3.67796928e-01f, 2.07950056e-01f, 2.19747890e-02f, -4.03638706e-02f, -3.23864594e-02f, 1.97972372e-01f, -8.45982432e-02f, -2.71300673e-01f, -1.67801067e-01f,
  -8.45944583e-02f, 4.67324331e-02f, -5.30113615e-02f, -3.87072787e-02f, 1.53940827e-01f, 1.74870007e-02f, -2.25128457e-02f, 2.73801498e-02f, -9.38590690e-02f, -9.40230638e-02f,
  -9.99202356e-02f, 1.20164827e-01f, 1.28780320e-01f, 2.01395392e-01f, 2.12944314e-01f, 2.66791224e-01f, 1.51609862e-02f, 1.97999403e-02f, 2.20230013e-01f, 7.81645179e-02f,
  -6.38994396e-01f, 7.91086257e-01f, -5.51129226e-04f, -5.79421103e-01f, 1.36929065e-01f, 6.78197503e-01f, 1.01867795e+00f, 6.41856313e-01f, -3.26200515e-01f, 2.94429779e-01f,
  7.26204574e-01f, -4.38342780e-01f, -6.43733859e-01f, -4.04129058e-01f, -3.36752743e-01f, 7.47456253e-02f, -8.94840240e-01f, -9.29100513e-01f, -3.09974074e-01f, 5.18574715e-01f,
  -2.42446046e-02f, -5.13774633e-01f, -4.34525490e-01f, -5.25231779e-01f, -3.83067816e-01f, -6.18806362e-01f, -6.26985192e-01f, -4.04650390e-01f, -2.25908548e-01f, -1.10056734e+00f,
  2.56973535e-01f, 4.34932470e-01f, -5.62591776e-02f, -4.05546665e-01f, -1.73388734e-01f, -1.30044267e-01f, 2.25891531e-01f, -1.07500747e-01f, -1.64733410e-01f, 1.25598595e-01f,
  4.36262079e-02f, 3.00157726e-01f, -1.67364061e-01f, 3.81868817e-02f, 3.04496050e-01f, 2.20076248e-01f, -1.46187797e-01f, -1.12549430e-02f, -1.12601310e-01f, 3.65205079e-01f,
  1.61455661e-01f, -7.14358017e-02f, -1.06297180e-01f, 2.01323673e-01f, 3.50245625e-01f, -1.53596848e-01f, 4.25083876e-01f, 7.88471848e-02f, -4.25597467e-02f, -4.67024326e-01f,
  -2.83020046e-02f, -3.12593579e-01f, 1.28842935e-01f, 1.24742270e-01f, 4.71181655e-03f, 7.89566487e-02f, -8.72556791e-02f, -4.87326607e-02f, 1.07130237e-01f, 1.00378990e-01f,
  9.69028771e-02f, 3.16713125e-01f, 2.03819454e-01f, -1.65430710e-01f, -2.47764781e-01f, 5.06380247e-03f, -5.80226295e-02f, -7.92462751e-02f, -1.32056803e-01f, -8.65375474e-02f,
  -3.94013636e-02f, 6.01946265e-02f, 7.78642818e-02f, 7.42972568e-02f, 1.68666571e-01f, 2.43367665e-02f, 2.80557007e-01f, 4.02986944e-01f, 8.99433568e-02f, 1.50505871e-01f,
  -2.53528535e-01f, 1.77416354e-01f, -3.42239231e-01f, -9.36442912e-02f, -1.08704135e-01f, 7.46501759e-02f, -1.41488820e-01f, 1.04188226e-01f, 9.35188830e-02f, 1.38167128e-01f,
  3.97282004e-01f, 2.47247815e-01f, 4.68341410e-02f, 2.25481540e-02f, 9.86191556e-02f, 6.53453469e-02f, -1.55144315e-02f, -3.30996901e-01f, -7.32077956e-02f, 1.73492238e-01f,
  -4.91118208e-02f, -1.79374173e-01f, -5.89234233e-01f, -5.24093270e-01f, -5.91199771e-02f, -4.56127316e-01f, -2.93291360e-01f, -1.09648556e-01f, -4.42961872e-01f, -4.00872707e-01f,
  -7.92681515e-01f, 7.76969343e-02f, -2.94477344e-01f, 2.89826095e-01f, 7.98337340e-01f, 6.17707372e-02f, -5.18644035e-01f, -5.78640461e-01f, 9.16479453e-02f, 1.00034855e-01f,
  5.52384257e-01f, 3.65071476e-01f, 1.48562759e-01f, -6.98256940e-02f, -5.26085377e-01f, -1.51861116e-01f, 1.14392683e-01f, -4.85970080e-01f, -7.36586750e-01f, -2.84875810e-01f,
  3.84908676e-01f, 8.28665346e-02f, -5.17095089e-01f, -1.06542632e-01f, 4.95889246e-01f, 2.91304678e-01f, 1.17267311e-01f, 3.82294655e-01f, 1.38689727e-01f, 5.26477635e-01f,
  -3.39301586e-01f, -4.69217777e-01f, -6.19416833e-02f, 5.83047509e-01f, 4.04770851e-01f, -3.15321445e-01f, -4.54871327e-01f, -2.42862985e-01f, 5.00798672e-02f, -2.36660764e-01f,
  4.39254731e-01f, 1.33506004e-02f, 4.47278678e-01f, -5.25626652e-02f, -1.39576688e-01f, -5.48481882e-01f, -2.35891610e-01f, -7.16289341e-01f, -6.67190731e-01f, -3.90334219e-01f,
  7.37153530e-01f, 6.69967294e-01f, -4.73620325e-01f, -1.25405535e-01f, -6.06588125e-01f, -2.27572411e-01f, -6.23378694e-01f, -5.29505491e-01f, -1.01696432e+00f, -6.95859671e-01f,
  -4.49686050e-02f, 1.74886629e-01f, 5.58459908e-02f, -1.16996944e-01f, 1.45414192e-02f, 1.44960061e-01f, 1.68608323e-01f, 1.10122651e-01f, 8.51906091e-03f, -2.39940658e-02f,
  -8.93302485e-02f, -5.53903058e-02f, -8.09682906e-02f, -1.19467795e-01f, -1.31054185e-02f, 7.00490549e-02f, 9.86501276e-02f, -2.12564841e-01f, -1.34521738e-01f, -1.50298432e-01f,
  -4.24573990e-03f, -1.55705690e-01f, 1.58751205e-01f, -2.80586611e-02f, -4.37777396e-03f, -1.38879687e-01f, -5.49984276e-02f, -9.07891169e-02f, -1.66372657e-01f, -1.29750609e-01f,
  -1.55023172e-01f, -8.10998902e-02f, -1.41155243e-01f, -2.11792383e-02f, 1.16338879e-01f, 1.24779187e-01f, 2.17813566e-01f, 4.36915876e-03f, 6.59438595e-02f, -2.99159259e-01f,
  -2.45499462e-01f, -2.01874554e-01f, 1.33272886e-01f, -2.42253989e-01f, -2.43950874e-01f, -3.33843753e-02f, 2.27022871e-01f, 1.37914464e-01f, -1.55175969e-01f, 1.17496625e-01f,
  1.81877822e-01f, -3.75435233e-01f, -3.78483623e-01f, -1.69100389e-01f, -2.98107485e-03f, -3.03253591e-01f, -5.39500296e-01f, -4.36769724e-01f, -7.21409321e-01f, -9.44663465e-01f,
  -1.25978017e+00f, -2.36020699e-01f, 4.34111834e-01f, -4.77751404e-01f, 1.28338158e-01f, 3.72726470e-02f, -3.02815646e-01f, 7.07418248e-02f, -2.12525483e-02f, -1.86073288e-01f,
  -2.14117840e-01f, -1.48855835e-01f, -6.51490912e-02f, -1.09395767e-02f, -1.77067921e-01f, 4.85815816e-02f, 2.15144962e-01f, -6.62341565e-02f, -1.81228682e-01f, -3.08491737e-01f,
  -1.35342449e-01f, -2.65009135e-01f, -3.28028411e-01f, -8.21968019e-02f, -2.46517062e-01f, -2.08530247e-01f, 1.88638687e-01f, -4.15454179e-01f, -3.94632310e-01f, -4.85498011e-01f,
  -4.79124010e-01f, -4.94840860e-01f, 4.65352803e-01f, -2.31927782e-01f, 1.64133713e-01f, -2.92947173e-01f, -2.03902781e-01f, 1.87164143e-01f, -2.37209294e-02f, -1.51509896e-01f,
  -1.24393180e-01f, 9.12020579e-02f, -1.56725511e-01f, 1.48390263e-01f, -2.68911839e-01f, -6.74430504e-02f, 4.87663656e-01f, 2.02209413e-01f, 1.44097835e-01f, 1.52326217e-02f,
  -2.03105122e-01f, -4.19983089e-01f, -6.81953251e-01f, 2.94896781e-01f, 2.13830203e-01f, 3.72397155e-02f, 3.43886614e-02f, -2.83362389e-01f, -1.49223641e-01f, -9.71039772e-01f,
  2.01213025e-02f, 2.28502154e-01f, 2.26367980e-01f, 1.69469565e-01f, -1.19053267e-01f, 2.87936386e-02f, -9.36820637e-03f, -1.99493021e-01f, -1.39162675e-01f, -2.34349489e-01f,
  1.57793909e-01f, -2.70363912e-02f, 8.17777310e-03f, -1.47521183e-01f, -1.12152167e-01f, -8.30904618e-02f, -2.43946731e-01f, -8.56074318e-02f, -3.15885581e-02f, -5.26089501e-03f,
  -1.06456712e-01f, -1.18108734e-01f, -9.09772962e-02f, -8.24986100e-02f, 1.79575011e-01f, 2.13847220e-01f, -2.94443779e-02f, -2.76686437e-02f, 4.49050963e-02f, -1.16190828e-01f,
  -2.62913376e-01f, 7.00761199e-01f, -4.08753216e-01f, -1.08907916e-01f, -1.76029384e-01f, 1.11997828e-01f, 1.70651861e-02f, 2.09514812e-01f, -8.39904770e-02f, -3.88079882e-02f,
  -1.73121374e-02f, -1.57931179e-01f, -6.04464039e-02f, 3.61843973e-01f, -9.43124965e-02f, 1.05568752e-01f, -1.06828362e-01f, -1.56119257e-01f, 2.55185008e-01f, 2.90663298e-02f,
  -7.03531057e-02f, -6.51194096e-01f, -1.07590914e+00f, -2.70732522e-01f, -5.37682712e-01f, -5.42240202e-01f, -6.40304267e-01f, -4.30880696e-01f, -7.21294582e-01f, -1.20394683e+00f,
  2.92908818e-01f, 2.50282049e-01f, 7.73611426e-01f, -1.15996003e-01f, -1.90525979e-01f, -3.90587240e-01f, -5.03568292e-01f, -2.72682309e-01f, -1.14419661e-01f, 1.85016975e-01f,
  -1.88536540e-01f, -4.61735576e-01f, 5.24764024e-02f, -2.94571847e-01f, -2.16297179e-01f, 7.00450093e-02f, 2.62727141e-01f, 2.48540610e-01f, -3.59793186e-01f, -7.49828339e-01f,
  -6.30581915e-01f, -1.53008983e-01f, 1.44232243e-01f, 8.15532655e-02f, 3.46306413e-01f, -2.18588784e-01f, 6.66486740e-01f, 3.14395517e-01f, 3.08216572e-01f, 5.76482177e-01f,
  4.15145040e-01f, 5.49412668e-01f, -3.05401951e-01f, -1.03908129e-01f, 9.28467065e-02f, 6.41297176e-02f, -5.16364723e-02f, 4.41483557e-01f, 4.39897692e-03f, 2.70650029e-01f,
  -3.00317463e-02f, 4.80129197e-02f, -4.14718688e-02f, -2.57308662e-01f, -2.00157270e-01f, -3.90344143e-01f, 8.75345543e-02f, 1.21484935e-01f, 2.30223536e-01f, -9.51380376e-03f,
  -6.33841276e-01f, -1.58995256e-01f, 5.30248404e-01f, 5.94975613e-02f, 2.59653926e-01f, -2.48360962e-01f, 1.36945218e-01f, 1.90592363e-01f, 3.53037447e-01f, 4.48793948e-01f,
  -4.99434397e-02f, -3.76150198e-02f, -6.17495775e-02f, 1.21634647e-01f, -1.76933020e-01f, 1.49916902e-01f, 7.16676414e-02f, -7.15551674e-02f, 1.51388254e-02f, -3.83947161e-03f,
  1.24549307e-01f, 4.56445925e-02f, 1.31204024e-01f, 1.42657161e-01f, -6.23428896e-02f, 2.34464481e-02f, -1.00551680e-01f, 6.92608207e-02f, 1.29280582e-01f, 1.51622389e-02f,
  -1.02605119e-01f, 1.04526073e-01f, 2.30910838e-01f, -8.44548717e-02f, 1.70602188e-01f, 5.61680794e-02f, 5.90289868e-02f, -2.05315202e-02f, 2.88146846e-02f, -4.53969873e-02f,
  -4.58365858e-01f, -1.50470853e-01f, -1.24760665e-01f, -5.72468601e-02f, 8.46139994e-03f, 7.31560662e-02f, -1.49057955e-01f, -4.45361845e-02f, -1.03562130e-02f, -1.00937836e-01f,
  -9.37765166e-02f, -1.12874515e-01f, 2.82303393e-01f, -1.50084868e-01f, -4.60910499e-01f, -4.82217707e-02f, -2.42202729e-01f, -2.41429642e-01f, -2.81585693e-01f, -1.29541516e-01f,
  -2.27268025e-01f, -5.63762724e-01f, -6.09151781e-01f, -4.06732351e-01f, -1.25701830e-01f, -4.50518817e-01f, -1.77297756e-01f, -2.27226079e-01f, -4.30798501e-01f, -5.90121448e-01f,
  4.98183459e-01f, 2.12327108e-01f, 3.63700837e-01f, 3.29086006e-01f, 3.92794162e-01f, -4.81576085e-01f, -9.45511162e-01f, -7.56261647e-01f, 1.49427533e-01f, -1.68278486e-01f,
  2.84593403e-01f, 3.93211097e-01f, 3.54376882e-01f, -1.22778505e-01f, -9.26389039e-01f, -8.39704156e-01f, -6.70635283e-01f, -6.67608500e-01f, -7.39897549e-01f, -6.29249334e-01f,
  -9.20076594e-02f, 2.24479083e-02f, -3.67129892e-01f, -2.15850070e-01f, 4.20216382e-01f, 2.38621280e-01f, 1.91426069e-01f, 2.34310433e-01f, -2.81523615e-02f, 4.45029259e-01f,
  4.54400331e-01f, 1.32161513e-01f, -1.52859062e-01f, -5.65552600e-02f, 2.69007444e-01f, -1.72235116e-01f, -1.30621240e-01f, 3.21844853e-02f, -7.14443475e-02f, 7.85421208e-02f,
  3.30408424e-01f, -8.08420405e-02f, 1.71417028e-01f, 1.06246710e-01f, -5.22656962e-02f, 9.37945661e-05f, -1.82226196e-01f, -3.11982542e-01f, -7.76396394e-02f, 3.58682103e-03f,
  1.66302636e-01f, 2.13285387e-01f, 1.27322808e-01f, -3.37635487e-01f, -1.31910339e-01f, 1.72735363e-01f, 1.35276735e-01f, 1.51574880e-01f, -9.98978466e-02f, 6.61886251e-03f,
  -1.70548782e-01f, 1.23508275e-01f, 1.68476477e-02f, -6.32041171e-02f, -6.79711774e-02f, 1.38236701e-01f, -2.55017318e-02f, -8.95618498e-02f, -4.50802706e-02f, 3.35057862e-02f,
  6.18856996e-02f, 9.67125744e-02f, -3.74194048e-02f, -5.36722504e-02f, 8.28742310e-02f, 4.67367545e-02f, 1.46924824e-01f, -7.62236342e-02f, 4.69216295e-02f, -1.77590959e-02f,
  8.94912407e-02f, 1.12752952e-01f, 2.80787259e-01f, -6.86820000e-02f, -1.23573065e-01f, 3.72934490e-02f, 2.01258197e-01f, 1.16085097e-01f, 1.37113273e-01f, 2.54087985e-01f,
  3.44672114e-01f, -3.40295851e-01f, 1.63266227e-01f, -3.03381503e-01f, 1.68339815e-02f, 5.60827516e-02f, 1.31377056e-01f, -1.33640125e-01f, 2.66991496e-01f, 5.41730225e-02f,
  -2.33676527e-02f, -6.23299517e-02f, 1.43403366e-01f, -1.53669104e-01f, -1.80881470e-01f, 2.20526867e-02f, -1.93636820e-01f, 5.55996224e-02f, -1.17232956e-01f, 2.04929098e-01f,
  -6.10807873e-02f, -3.91811699e-01f, -1.48169845e-01f, -6.79096207e-02f, 4.99450713e-02f, 1.14932768e-01f, 5.14882058e-02f, 6.10233620e-02f, -1.97871387e-01f, -1.88531712e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.01267493e-01f, 4.94204670e-01f, 4.29138988e-01f, 7.29819715e-01f, 6.44268155e-01f, 7.59991527e-01f, 2.72617280e-01f, 2.73727924e-01f, 1.02861613e-01f, 5.68109214e-01f,
  3.98291975e-01f, 4.34202194e-01f, 4.05485481e-01f, 3.23142469e-01f, 4.29213613e-01f, 9.77057993e-01f, 4.64178503e-01f, 7.26060987e-01f, 5.86927652e-01f, 4.72495824e-01f,
  5.30013561e-01f, 8.26982260e-01f, 3.15226585e-01f, 4.14799720e-01f, 7.34374404e-01f, 3.42703998e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -5.13807774e-01f, 1.45238161e-01f, -1.22952014e-01f, -3.04125473e-02f, -1.84806719e-01f, -1.39858779e-02f, -2.91400980e-02f, -2.59202212e-01f, -1.30202979e-01f, 6.45688921e-02f,
  1.34118959e-01f, 9.53619108e-02f, 5.70929460e-02f, 8.54995772e-02f, 8.31788406e-02f, -6.05125017e-02f, -2.44859785e-01f, -2.40646943e-01f, 1.74069092e-01f, -2.33701497e-01f,
  1.24571465e-01f, 5.45835756e-02f, 1.30358532e-01f, -1.35256974e-02f, -3.61815155e-01f, -7.40180984e-02f, -5.53946018e-01f, 3.44874337e-02f, -3.77009094e-01f, 5.09133115e-02f,
  -2.21034348e-01f, 1.17530748e-01f, 5.93944341e-02f, -9.34531540e-02f, 2.00346604e-01f, -2.68208347e-02f, -1.26704231e-01f, -1.88275814e-01f, 5.47586232e-02f, -1.61851689e-01f,
  -3.73066515e-02f, 8.48477408e-02f, -9.90119874e-02f, -2.65408844e-01f, -4.31334674e-01f, 6.64714053e-02f, 4.90267761e-02f, 6.73177093e-02f, 7.43120909e-03f, -3.62397730e-01f,
  -1.04200486e-02f, -2.23462299e-01f, -7.24154487e-02f, 2.01013852e-02f, 7.69931525e-02f, 2.35450462e-01f, 5.28351925e-02f, 1.98897645e-01f, -2.20760360e-01f, 2.04159036e-01f,
  -2.30754271e-01f, -1.15502574e-01f, -1.52297020e-01f, -3.81551504e-01f, -1.40535131e-01f, 9.18055251e-02f, 2.09209234e-01f, -2.26523444e-01f, 3.23176920e-01f, -2.56547537e-02f,
  4.45435703e-01f, -1.93331838e-01f, 9.44247618e-02f, 1.02619201e-01f, 8.82477015e-02f, 1.79206014e-01f, -1.11423612e-01f, -8.91166329e-02f, -3.61217588e-01f, -2.48192742e-01f,
  1.15277804e-01f, 1.16445102e-01f, -1.48464471e-01f, -1.51236460e-01f, 1.41910300e-01f, -2.82791369e-02f, 7.27061927e-02f, 9.76743028e-02f, -2.57221222e-01f, 4.59640985e-04f,
  4.26078767e-01f, 6.65645227e-02f, -2.03869164e-01f, -1.86785460e-01f, -1.17409647e-01f, -1.32404044e-01f, -1.42229095e-01f, 7.13447295e-03f, -4.90462705e-02f, 3.31646591e-01f,
  2.35538661e-01f, 1.30935624e-01f, -6.55463636e-01f, 4.70147729e-01f, 2.50305206e-01f, -3.97624999e-01f, -5.36626816e-01f, 4.09975052e-01f, 3.45807672e-02f, -7.00112760e-01f,
  2.18535826e-01f, 3.32762748e-01f, 3.00163984e-01f, 3.24359685e-01f, -3.95803303e-01f, -2.62464106e-01f, -1.86318710e-01f, -2.42681548e-01f, -4.07713503e-01f, -6.70188189e-01f,
  -3.69771302e-01f, -5.92789710e-01f, -2.32566014e-01f, 4.22400028e-01f, 1.22668017e-02f, 1.30382359e-01f, -1.17815030e+00f, -2.55961448e-01f, -1.06342807e-01f, -8.28999206e-02f,
  -5.22562414e-02f, 2.53463630e-03f, 8.30548853e-02f, -2.71125287e-01f, -4.28053029e-02f, -3.23427804e-02f, 1.02052372e-02f, 2.85182465e-02f, -6.98482916e-02f, 5.46662956e-02f,
  -1.63806032e-03f, -1.38693854e-01f, 7.93094933e-02f, -3.48193586e-01f, -1.58813998e-01f, -4.88938875e-02f, -1.35995060e-01f, -9.18654650e-02f, -8.72395039e-02f, 9.12728161e-02f,
  -7.62051195e-02f, 6.06679507e-02f, -1.92211151e-01f, 7.20910951e-02f, -2.39867613e-01f, -1.22661464e-01f, -6.05543852e-02f, 2.37617572e-03f, 3.65295224e-02f, -4.91330773e-02f,
  1.59773856e-01f, 7.88389891e-02f, -4.26831879e-02f, -3.88443004e-03f, -2.83195168e-01f, 4.24591526e-02f, -2.29121875e-02f, -4.06701118e-02f, 1.27472341e-01f, -4.26319763e-02f,
  3.67516018e-02f, 6.47862554e-02f, 1.81402832e-01f, 2.74705477e-02f, 3.59083638e-02f, -8.71545002e-02f, -5.65564930e-02f, 1.41142160e-01f, 6.36551753e-02f, -2.92304993e-01f,
  2.22411215e-01f, 1.48346141e-01f, -1.11991286e-01f, -1.07657008e-01f, 5.90619482e-02f, -2.13048846e-01f, -4.21821512e-02f, -2.16816500e-01f, -1.95122525e-01f, 8.89997333e-02f,
  -3.49850237e-01f, -1.58960804e-01f, 5.43068409e-01f, -9.41527188e-02f, -5.58682368e-04f, -2.03636408e-01f, 2.33890757e-01f, 9.31473374e-02f, 4.26582754e-01f, -2.36313075e-01f,
  2.86383599e-01f, 1.37970254e-01f, 7.13776872e-02f, -2.64376346e-02f, 9.41220149e-02f, -5.14526814e-02f, -2.10024014e-01f, -1.57178447e-01f, 1.41795576e-01f, 2.73016721e-01f,
  1.57458767e-01f, -5.16142473e-02f, -2.08869189e-01f, -9.42084938e-02f, 1.78155929e-01f, -5.57289682e-02f, -5.68361320e-02f, -1.52914420e-01f, -1.21359453e-01f, -4.83831614e-02f,
  -4.80709225e-01f, 3.04812510e-02f, -4.46487516e-01f, 2.36514956e-01f, 6.01708330e-02f, 1.20565258e-01f, 3.41706932e-01f, 4.76332814e-01f, -3.56279090e-02f, -7.62619898e-02f,
  -3.38187329e-02f, 1.09835589e+00f, 6.09255321e-02f, -1.08540520e-01f, -6.61195993e-01f, -6.82215542e-02f, 1.28348231e-01f, -9.67906963e-04f, 2.46933531e-02f, -6.08240254e-02f,
  5.09221017e-01f, 3.74347776e-01f, -2.73018301e-01f, 3.88785183e-01f, -1.21436089e-01f, -6.49970397e-02f, 3.42414677e-02f, -1.60811141e-01f, -6.88476920e-01f, 5.31310558e-01f,
  5.58876097e-01f, -1.46663177e+00f, -9.58210111e-01f, -5.97217262e-01f, -1.24066985e+00f, 5.64672127e-02f, -2.24004760e-01f, 7.03354329e-02f, 6.91226646e-02f, 2.54510373e-01f,
  1.58300564e-01f, 4.39680219e-02f, 9.14373249e-02f, 1.62267499e-02f, -5.37808705e-03f, -3.79960015e-02f, 4.12789695e-02f, -1.42038390e-01f, 1.32547796e-01f, 1.54792994e-01f,
  1.45120740e-01f, 1.18684649e-01f, 1.31579250e-01f, 6.24007247e-02f, 3.49134170e-02f, -5.77237941e-02f, -7.97840431e-02f, -3.55572328e-02f, 1.48000317e-02f, 1.49198979e-01f,
  1.38078108e-01f, 1.25248730e-01f, 2.18952820e-01f, 3.44410166e-02f, 1.02186218e-01f, 9.03724879e-02f, 1.43704817e-01f, 6.81724492e-03f, 7.96240047e-02f, 1.52776212e-01f,
  3.57024092e-03f, 8.28476176e-02f, 3.61256212e-01f, -6.37920424e-02f, 6.14042813e-03f, -9.94874761e-02f, 1.42928734e-01f, -1.59001797e-02f, -2.42964491e-01f, 3.13814506e-02f,
  2.00708464e-01f, 1.80565462e-01f, 8.29633847e-02f, 1.66750312e-01f, -1.75123438e-01f, 2.76741590e-02f, 1.10099688e-01f, -2.69670218e-01f, 2.06857026e-01f, 2.78394103e-01f,
  -1.97825134e-02f, -2.66285777e-01f, -1.47020981e-01f, -3.41688156e-01f, 2.62710929e-01f, -2.20025271e-01f, -6.19628549e-01f, 9.72605497e-02f, -3.91368717e-01f, 1.04615994e-01f,
  2.21975520e-01f, -7.40640759e-02f, 2.90624171e-01f, 1.00865021e-01f, 1.27905294e-01f, -1.07051834e-01f, 3.40443254e-01f, 1.32311180e-01f, 4.45385605e-01f, -8.08906704e-02f,
  -2.58306563e-01f, -3.54775153e-02f, 9.87241119e-02f, -1.54833212e-01f, 1.90667152e-01f, -4.56290245e-02f, 1.08765148e-01f, -3.85953903e-01f, -1.47766098e-01f, -1.07442811e-01f,
  3.45315114e-02f, -2.75380015e-01f, 2.78424472e-01f, 1.33994713e-01f, 1.31481469e-01f, 6.98281080e-02f, 3.80301237e-01f, 6.89981431e-02f, -2.56633282e-01f, -3.96990269e-01f,
  2.05445766e-01f, -4.54107374e-01f, 1.60856750e-02f, -9.41416472e-02f, 4.40443791e-02f, 3.98007065e-01f, 4.09534097e-01f, 7.05069304e-02f, 1.55077547e-01f, 1.09354436e-01f,
  1.78478301e-01f, 2.72714123e-02f, -4.67676371e-01f, -1.51285201e-01f, 4.69709150e-02f, -5.00173867e-01f, 4.55862917e-02f, 2.14394927e-01f, 6.04935782e-03f, -2.85774201e-01f,
  -6.53578281e-01f, -4.05731171e-01f, 2.31006369e-01f, -1.08518946e+00f, -6.08292282e-01f, -2.80415028e-01f, 3.89336914e-01f, 4.76565212e-01f, 3.10122222e-02f, -9.96882856e-01f,
  -3.39315057e-01f, 6.83942497e-01f, 5.28768301e-01f, -5.12378037e-01f, 1.53238475e-01f, 7.19626248e-03f, -4.96885478e-02f, -1.96189225e-01f, -2.77149249e-02f, 3.31242770e-01f,
  -5.22422530e-02f, -4.16989904e-03f, -1.62339583e-01f, -4.05663736e-02f, -5.49238957e-02f, -3.02542627e-01f, -1.01670966e-01f, -7.06475303e-02f, -2.25610182e-01f, 9.37526450e-02f,
  1.43683795e-02f, -3.60355526e-01f, -6.26730993e-02f, -3.68800238e-02f, -1.49128094e-01f, 8.51657763e-02f, -2.37630475e-02f, 1.14703968e-01f, 2.26736248e-01f, -1.01079486e-01f,
  -1.64695039e-01f, -2.39940763e-01f, 2.10497662e-01f, 1.41823724e-01f, -1.82046145e-02f, 7.38321850e-03f, -1.26718923e-01f, -2.53141433e-01f, -4.14939910e-01f, 3.22692245e-02f,
  1.71668604e-01f, 2.09062234e-01f, -4.38490286e-02f, 4.41198908e-02f, -3.26503456e-01f, -5.08516794e-04f, -1.33099005e-01f, -2.13672251e-01f, 1.68143455e-02f, 2.05646932e-01f,
  -2.42733788e-02f, -1.05731793e-01f, -5.61344810e-02f, -1.12802433e-02f, -3.51355374e-01f, 2.88863212e-01f, -5.97385019e-02f, 6.10964783e-02f, -9.76580009e-02f, 1.45886436e-01f,
  -3.43606621e-02f, 4.98817004e-02f, -2.08376408e-01f, 1.31749675e-01f, -4.05490994e-01f, -4.59905177e-01f, 2.23274842e-01f, -2.43681446e-01f, -2.99033165e-01f, 7.68302262e-01f,
  -2.08594680e-01f, 5.66519378e-03f, -7.19734788e-01f, -1.77548304e-01f, 1.55309856e-01f, 1.81156561e-01f, 7.43895844e-02f, 1.25301942e-01f, -1.49252340e-01f, -1.58460587e-02f,
  -8.97801995e-01f, -2.45911419e-01f, 5.30298710e-01f, -1.45803005e-01f, 5.03750034e-02f, 1.03547737e-01f, -5.81924357e-02f, 5.05551934e-01f, 8.41924697e-02f, 4.52010483e-02f,
  1.46929547e-01f, 8.07729214e-02f, 2.41642848e-01f, 2.00020835e-01f, 2.09593073e-01f, 1.77330121e-01f, 3.14633727e-01f, -2.05722973e-01f, -1.97843090e-01f, 6.93738759e-01f,
  2.15842314e-02f, 5.86542562e-02f, 2.58691221e-01f, -2.52535105e-01f, 2.60041058e-01f, 3.21901530e-01f, -2.53046870e-01f, -5.46540380e-01f, -7.73460507e-01f, -1.85319841e-01f,
  6.56678259e-01f, -1.08053410e+00f, -4.26303416e-01f, -3.12476635e-01f, -4.55445170e-01f, 1.04624130e-01f, -1.08908176e+00f, 6.43169761e-01f, -7.88676858e-01f, -3.05894285e-01f,
  -4.39240813e-01f, -1.51453984e+00f, -2.65661448e-01f, -1.87094212e-01f, -4.53311689e-02f, -3.53264779e-01f, 3.33658338e-01f, 5.41063070e-01f, -3.11421119e-02f, 4.50284153e-01f,
  3.00040320e-02f, -8.82162809e-01f, 2.40204334e-01f, -1.38509706e-01f, 1.59978140e-02f, -1.03699096e-01f, -4.04937156e-02f, -3.22497368e-01f, -8.05498958e-02f, 3.16183940e-02f,
  -1.01647064e-01f, -1.67296699e-03f, 4.97995093e-02f, -6.62975907e-02f, -3.41933593e-03f, -6.82388768e-02f, 8.82918760e-02f, -6.20446391e-02f, 1.89484581e-01f, 1.92970097e-01f,
  -5.00375107e-02f, 1.26121134e-01f, 8.88373405e-02f, -3.76168638e-02f, 1.68411687e-01f, -6.45650625e-02f, -1.03366055e-01f, 1.82602450e-01f, 4.16053534e-01f, 2.00749785e-01f,
  1.01428390e-01f, -7.49677047e-02f, 1.99909955e-01f, -4.33761552e-02f, 9.77678373e-02f, -1.82229057e-01f, -6.91035092e-02f, -1.69997424e-01f, 1.16379619e-01f, -2.11779341e-01f,
  -2.05407053e-01f, 1.24118537e-01f, -2.71707535e-01f, -1.24434764e-02f, 8.76209363e-02f, 1.01152420e-01f, 1.13165684e-01f, -2.46746764e-02f, 6.02932498e-02f, 2.33670980e-01f,
  -1.01918608e-01f, 7.26775452e-02f, 8.89451280e-02f, -1.65644839e-01f, 5.78858890e-02f, -4.56462763e-02f, -2.45808572e-01f, 1.78105593e-01f, 1.00244313e-01f, 1.25875324e-01f,
  -1.21340744e-01f, 1.60479650e-01f, 9.42207947e-02f, 9.35759842e-02f, 4.64820638e-02f, 3.18491101e-01f, -6.20186813e-02f, -3.32260847e-01f, -1.71711862e-01f, 1.56844243e-01f,
  6.70408159e-02f, -1.37830913e-01f, -3.19921970e-01f, -5.22962771e-03f, 1.77161902e-01f, 1.51161943e-03f, 3.53476778e-02f, 2.20033601e-01f, 4.57836717e-01f, -2.25306954e-03f,
  -1.05834554e-03f, 1.11950794e-02f, 1.56647727e-01f, 8.40258505e-03f, -1.83920890e-01f, -2.51645148e-01f, 1.40362069e-01f, 2.58047402e-01f, 1.01869226e-01f, 9.40505862e-02f,
  -5.53979985e-02f, 7.64689893e-02f, -2.30649695e-01f, -1.00653723e-01f, -5.18070273e-02f, 2.22244337e-01f, -7.91965500e-02f, -2.14161783e-01f, 5.23359254e-02f, 1.89465150e-01f,
  -1.31076574e-01f, 3.59476246e-02f, 1.66726068e-01f, 3.07085752e-01f, 6.34699762e-02f, -4.82220292e-01f, -4.89570685e-02f, -2.68521011e-01f, 4.70400274e-01f, -3.62210780e-01f,
  9.68140811e-02f, 2.42011622e-01f, -2.49322504e-04f, -1.31441867e+00f, -6.81495607e-01f, -5.17152667e-01f, -1.08165547e-01f, -3.21627021e-01f, -1.22182079e-01f, 2.73113381e-02f,
  4.41392176e-02f, -2.52017736e-01f, -6.22899830e-01f, -5.30211329e-01f, -3.01987022e-01f, -5.22296652e-02f, 3.40099245e-01f, 2.40522057e-01f, 8.46704304e-01f, 6.25336051e-01f,
  3.23204249e-01f, 6.64899871e-02f, 1.53755760e-02f, 6.02350347e-02f, 3.85653451e-02f, 2.37616315e-01f, 1.61933333e-01f, 1.81727186e-01f, -1.66440636e-01f, -2.30316650e-02f,
  1.22776553e-01f, 7.68725500e-02f, 1.25235494e-03f, 4.14593965e-01f, -6.31696656e-02f, 1.65636972e-01f, 1.94405049e-01f, 1.06164038e-01f, 9.25845001e-03f, 1.83479220e-01f,
  -1.11188181e-01f, -7.97416270e-02f, -1.51172830e-02f, 1.25398293e-01f, -3.09725981e-02f, 2.05906093e-01f, -1.48257107e-01f, 1.03488870e-01f, -4.61336859e-02f, 1.62049290e-02f,
  -7.71593079e-02f, 1.19189233e-01f, -1.79311316e-02f, 4.52019647e-02f, -3.43188457e-03f, -4.66639996e-02f, 4.40694094e-02f, 9.88405570e-02f, 9.68222991e-02f, 2.06958000e-02f,
  3.11797023e-01f, 1.19258389e-01f, 8.11250061e-02f, 6.60945997e-02f, -8.46967772e-02f, 1.51973009e-01f, -9.16242450e-02f, 1.75691947e-01f, 2.61161998e-02f, -1.15381405e-02f,
  2.58870088e-02f, 2.77983099e-01f, -2.30488822e-01f, -3.11657101e-01f, 3.42935115e-01f, -1.15394071e-01f, -3.37592214e-02f, -2.01659858e-01f, 1.38230873e-02f, 2.72994697e-01f,
  3.44988316e-01f, -1.70971647e-01f, 5.75458944e-01f, 4.37685043e-01f, -2.92561084e-01f, -4.10855651e-01f, -2.87981153e-01f, -2.53277928e-01f, 2.10974246e-01f, 2.14589849e-01f,
  -6.60059869e-01f, -7.07503557e-02f, -4.38092113e-01f, -1.05028540e-01f, 1.82822302e-01f, -3.43079008e-02f, -1.62159473e-01f, -2.43914679e-01f, -2.70730674e-01f, -1.22443631e-01f,
  9.97107998e-02f, 2.29391307e-01f, 2.25889057e-01f, -3.67388964e-01f, -2.07588598e-01f, 1.96042940e-01f, -1.12446219e-01f, 1.55787677e-01f, -2.17693329e-01f, 2.54603233e-02f,
  -1.74512058e-01f, -2.28172526e-01f, 3.28696072e-01f, 2.99813688e-01f, 6.86100423e-02f, -4.58119094e-01f, -1.34765878e-01f, -7.45740309e-02f, 6.37430325e-02f, -5.33587754e-01f,
  -3.34611595e-01f, -1.82701617e-01f, -5.34406483e-01f, 6.65403390e-03f, -5.62944770e-01f, -1.97597906e-01f, 2.90015906e-01f, 4.38210189e-01f, 1.36299908e-01f, -2.99983174e-02f,
  1.36956155e-01f, 3.49205405e-01f, 2.79192656e-01f, -6.10280454e-01f, 8.40834677e-02f, -4.45438296e-01f, -2.57172465e-01f, 1.23288465e+00f, 5.55058718e-02f, -5.32830320e-03f,
  -2.75219411e-01f, -3.06483954e-01f, -2.54787773e-01f, -2.05699414e-01f, -5.62339485e-01f, -4.07956928e-01f, -1.14749825e+00f, -3.37427586e-01f, 1.71851702e-02f, 1.47371784e-01f,
  1.58988446e-01f, -3.57175916e-02f, -3.95447351e-02f, 2.07755908e-01f, 1.47296935e-01f, -1.79076567e-03f, 3.13375443e-02f, 9.80737805e-02f, -1.01505518e-01f, 1.20513327e-01f,
  -1.06250726e-01f, -6.18467703e-02f, 1.66577831e-01f, -2.12946519e-01f, -2.47493520e-01f, 2.65114456e-01f, 1.86500736e-02f, 1.86112914e-02f, 1.13448957e-02f, 1.51629582e-01f,
  -5.64534124e-03f, 8.83959234e-03f, 1.15568712e-01f, -1.41088441e-01f, 2.11319868e-02f, 5.23742922e-02f, -9.95457396e-02f, -9.89848375e-02f, -4.17815208e-01f, -1.04125990e-02f,
  -2.05132440e-01f, 2.88954098e-02f, 5.19597046e-02f, 1.18118534e-02f, -7.03989938e-02f, 3.15094888e-02f, 9.87853706e-02f, 1.94940403e-01f, -2.24797167e-02f, -1.01211429e-01f,
  1.67753801e-01f, -1.48177687e-02f, 1.11550532e-01f, -1.69945657e-01f, 2.00384744e-02f, -4.20425653e-01f, 9.84788835e-02f, -1.45967960e-01f, 1.22914463e-02f, -7.29614645e-02f,
  -7.96464086e-02f, -1.20473847e-01f, 1.93670020e-01f, -9.59519967e-02f, 1.56278566e-01f, -1.13463663e-01f, 1.79684401e-01f, -1.16891980e-01f, 1.65474370e-01f, 2.07673073e-01f,
  -1.16697423e-01f, 1.96336269e-01f, -9.69718769e-02f, -2.78626084e-01f, 3.35702419e-01f, 3.36103261e-01f, 5.71929701e-02f, 2.96708375e-01f, 1.27646789e-01f, -7.98763707e-02f,
  -1.74581319e-01f, -2.03139354e-02f, -1.33024707e-01f, -2.98193991e-01f, 2.33715102e-01f, 2.30321109e-01f, 1.65592171e-02f, 1.26388654e-01f, -2.51322716e-01f, -1.14122503e-01f,
  -2.52962887e-01f, -2.92819381e-01f, 2.41380379e-01f, -2.42151812e-01f, 3.96962836e-02f, -2.59632707e-01f, -1.81389064e-01f, -8.25844407e-02f, -4.04036716e-02f, 4.49075848e-01f,
  -2.66086787e-01f, 9.73589048e-02f, 1.69972643e-01f, 2.06112042e-01f, -3.29437494e-01f, -7.86868036e-02f, -2.06458494e-01f, -2.56988406e-02f, -2.50643969e-01f, -3.71529967e-01f,
  -8.00363272e-02f, -9.00787115e-01f, -4.68153954e-01f, -4.62275803e-01f, -6.44269347e-01f, -5.54539621e-01f, 7.88002685e-02f, -2.32250020e-01f, 1.31514385e-01f, -2.39263605e-02f,
  -1.71054229e-01f, -3.91497493e-01f, 6.99734449e-01f, 2.40685150e-01f, 2.42305145e-01f, 3.90196681e-01f, 1.21256419e-01f, -7.11263299e-01f, 5.46643674e-01f, -7.13378116e-02f,
  -3.18902999e-01f, -1.02683556e+00f, -1.27893543e+00f, -9.52303112e-01f, 8.01813304e-01f, -7.24454463e-01f, -1.53835177e-01f, -2.27834925e-01f, -3.50755528e-02f, -1.16518550e-01f,
  8.15650597e-02f, -3.36676598e-01f, -1.69393614e-01f, -5.67936599e-02f, 2.53894150e-01f, -8.32372159e-02f, 2.87210550e-02f, 1.44448327e-02f, -2.34307170e-01f, -8.52176398e-02f,
  4.65661660e-03f, -9.39124376e-02f, 1.06958859e-02f, -1.29802421e-01f, -6.13333322e-02f, -4.36171368e-02f, -6.08607866e-02f, -2.36320049e-01f, -1.55049905e-01f, 7.07675889e-02f,
  -1.42268106e-01f, -1.61052734e-01f, 8.63731876e-02f, -3.68806481e-01f, 3.84022668e-02f, -9.92020220e-03f, -5.24492711e-02f, -3.90067720e-03f, -5.15907444e-02f, -6.64566457e-02f,
  -6.93938881e-02f, -1.54517919e-01f, -2.38300450e-02f, 6.34303614e-02f, -3.62430774e-02f, -2.15756670e-01f, -4.59831841e-02f, -1.72358751e-01f, -1.63124025e-01f, 1.01693518e-01f,
  5.02954796e-02f, 1.34956941e-01f, 1.25213433e-03f, 5.00790030e-03f, -3.98347154e-02f, -7.07350001e-02f, -2.23037422e-01f, 2.06317082e-01f, -1.76641747e-01f, 2.21144766e-01f,
  1.00298248e-01f, -4.07934710e-02f, 7.06957132e-02f, 2.11662292e-01f, -2.27472745e-02f, -6.01413026e-02f, 3.50152478e-02f, -2.80735493e-01f, 4.43983167e-01f, 1.17039360e-01f,
  -2.63935298e-01f, -1.30824158e-02f, 1.52407348e-01f, 8.58657584e-02f, -2.13883981e-01f, 1.97684020e-01f, -2.27575302e-01f, 1.81410223e-01f, -7.64713287e-02f, -9.39772353e-02f,
  -9.89268199e-02f, -1.17234454e-01f, -4.17587668e-01f, -1.68049112e-01f, 1.80317074e-01f, 2.13381518e-02f, -1.13901004e-01f, -1.56023681e-01f, -1.03867613e-01f, 2.56493777e-01f,
  -9.16847363e-02f, -1.31595746e-01f, -9.05848593e-02f, -4.05704193e-02f, -1.17017932e-01f, 8.22815672e-02f, 2.21655086e-01f, -2.07680017e-01f, 2.08077550e-01f, -2.07892612e-01f,
  -1.90122798e-01f, 2.32512634e-02f, 5.91806099e-02f, -6.90710396e-02f, 2.92052597e-01f, -6.35253116e-02f, 2.34286152e-02f, 3.31007987e-01f, -6.72106631e-03f, -6.46954477e-01f,
  4.38843556e-02f, -3.30428839e-01f, 2.92375926e-02f, -3.60482007e-01f, -4.79422510e-03f, 3.24035883e-01f, -1.02275684e-01f, 7.05951899e-02f, -1.95412695e-01f, -8.44390810e-01f,
  2.74501354e-01f, -1.12302579e-01f, -5.45900166e-01f, -7.08694682e-02f, -1.66886911e-01f, 3.50940496e-01f, -3.93733770e-01f, -2.28525832e-01f, -4.67920095e-01f, -5.56858659e-01f,
  8.14604223e-01f, 2.32155830e-01f, -7.60810792e-01f, -5.14089048e-01f, 2.79652119e-01f, -1.40829340e-01f, -4.64332961e-02f, 5.27058206e-02f, 1.67732492e-01f, 2.29412794e-01f,
  -2.19005600e-01f, -1.52565530e-02f, 1.61884457e-01f, 3.43966857e-02f, -3.28814946e-02f, 1.47736937e-01f, -1.72010183e-01f, -2.08496422e-01f, 3.55473645e-02f, 1.23656757e-01f,
  -2.07704194e-02f, 1.25527054e-01f, 2.85529979e-02f, 1.07711479e-01f, -2.56159808e-04f, -5.50943352e-02f, 6.03418425e-02f, 2.82923132e-01f, 1.28414512e-01f, -1.48346536e-02f,
  2.83416480e-01f, -8.94478150e-03f, 3.65637064e-01f, -1.75340161e-01f, 2.42480621e-01f, 3.42366695e-02f, 6.89823255e-02f, -2.01203659e-01f, 3.51867408e-01f, -4.41094600e-02f,
  1.69190675e-01f, 1.63857654e-01f, -7.44912624e-02f, 1.22214355e-01f, -1.70281887e-01f, 6.74310625e-02f, -4.95589525e-02f, -6.35663271e-02f, 7.22867921e-02f, -1.19284257e-01f,
  5.82115166e-03f, 2.33933270e-01f, 2.55926967e-01f, 1.27161846e-01f, 3.88974659e-02f, 2.11006537e-01f, 7.84110371e-03f, -9.47616398e-02f, 1.41769305e-01f, -1.28304422e-01f,
  -9.40715596e-02f, -2.87508637e-01f, 4.91541356e-01f, -1.70561180e-01f, -2.60491103e-01f, 3.76945287e-01f, 5.05328923e-03f, -2.11313978e-01f, 2.85331190e-01f, 4.54347789e-01f,
  1.46585047e-01f, -6.49033710e-02f, -4.57537353e-01f, 7.19297975e-02f, -3.41305852e-01f, 1.20431900e-01f, -3.01483989e-01f, -1.78317010e-01f, 1.83213457e-01f, 1.52906766e-02f,
  -6.01464570e-01f, 2.46004939e-01f, -1.96096286e-01f, -4.20357674e-01f, -2.05412820e-01f, -7.45954812e-02f, 1.66367248e-01f, 3.71364534e-01f, -2.31720477e-01f, -2.54521161e-01f,
  -3.82507145e-01f, 3.17640126e-01f, 3.73925179e-01f, -1.95156991e-01f, -3.55526686e-01f, 3.96228701e-01f, 2.81363040e-01f, 1.57202795e-01f, 3.56282800e-01f, 3.82629275e-01f,
  3.70040536e-01f, -1.84320167e-01f, -2.32326947e-02f, -2.26833478e-01f, -1.69769064e-01f, -3.54831994e-01f, 3.48876834e-01f, -7.92160511e-01f, -2.75206506e-01f, 4.33461428e-01f,
  -9.11374331e-01f, 9.63107526e-01f, -5.37691951e-01f, -3.41786928e-02f, -2.46602925e-03f, -1.25615731e-01f, -1.84300989e-01f, -7.65587866e-01f, -1.58181265e-01f, -1.97091192e-01f,
  -5.02425194e-01f, -8.29373837e-01f, -3.31448436e-01f, 3.80808473e-01f, 4.34847549e-02f, 4.42267768e-02f, 3.00468057e-01f, -6.17895007e-01f, -2.45926514e-01f, -5.24823368e-01f,
  -2.91372597e-01f, -5.71096063e-01f, 1.46685228e-01f, 7.42080882e-02f, 9.14387479e-02f, -6.35870248e-02f, 9.27987769e-02f, -2.61624586e-02f, -1.27182573e-01f, 7.01820385e-03f,
  -4.36686613e-02f, 5.70743671e-03f, -1.18471660e-01f, -1.20754562e-01f, -9.32200924e-02f, 8.35101381e-02f, -1.40505791e-01f, 5.32220714e-02f, 9.89669710e-02f, -2.31099680e-01f,
  -2.58912463e-02f, 1.31305112e-02f, -7.24870712e-03f, 2.40561068e-01f, -5.38556352e-02f, -1.29144683e-01f, 4.62193154e-02f, 2.00926885e-02f, -1.72092468e-01f, 1.80525839e-01f,
  4.43396494e-02f, -1.69161424e-01f, 2.66617626e-01f, -2.36126661e-01f, 8.64381343e-02f, 3.70961726e-02f, -1.43229499e-01f, 1.50127769e-01f, 2.83287489e-03f, -1.71515197e-01f,
  -1.93384200e-01f, -1.19606212e-01f, 9.38232243e-02f, 3.02645862e-02f, 1.52697802e-01f, -4.68216576e-02f, -6.57895133e-02f, 7.96737336e-03f, -9.90869403e-02f, -1.94527924e-01f,
  1.56665295e-01f, 8.67689103e-02f, 2.29811653e-01f, -1.49505779e-01f, 1.26966059e-01f, 1.68932751e-01f, -1.06475003e-01f, 3.59208435e-01f, -1.86929386e-02f, 4.02664632e-01f,
  -7.98647106e-02f, 2.25724995e-01f, 5.40932059e-01f, 1.27401561e-01f, -3.76064420e-01f, 2.15365276e-01f, -5.62631339e-02f, -3.42174619e-01f, -2.88103133e-01f, 8.65462869e-02f,
  5.55616140e-01f, -1.80670202e-01f, 3.41514856e-01f, 2.46203765e-01f, -1.53475299e-01f, -1.11411206e-01f, -1.88317508e-01f, 2.83477753e-01f, 3.35993916e-01f, 2.32535750e-01f,
  2.08436415e-01f, -6.10156311e-03f, 2.38087654e-01f, -2.24087939e-01f, -4.13794369e-01f, -2.43946224e-01f, 1.96828797e-01f, -3.40044759e-02f, 1.25546530e-01f, -2.44704008e-01f,
  -8.16779286e-02f, 1.44397646e-01f, -8.85402784e-02f, -8.10994655e-02f, -4.31926221e-01f, -1.99380428e-01f, 2.54885375e-01f, -3.69516492e-01f, 2.04400912e-01f, -6.54733703e-02f,
  -5.35373032e-01f, 2.88937211e-01f, 2.75569558e-01f, -1.00432225e-01f, 3.49818319e-02f, -5.69535732e-01f, -1.03212349e-01f, -2.64171690e-01f, -5.90897739e-01f, -5.71038127e-01f,
  -4.91387993e-01f, -1.97113439e-01f, 2.39434335e-02f, 3.15498441e-01f, 3.58849347e-01f, -9.75491345e-01f, -7.61968642e-02f, -3.49771649e-01f, 4.90406603e-01f, 5.96045069e-02f,
  -6.00054860e-02f, -1.27063036e-01f, -3.94342899e-01f, 2.18031898e-01f, -3.58235657e-01f, -5.97787559e-01f, 7.88252413e-01f, -6.96970940e-01f, -1.13986395e-01f, 1.03593862e+00f,
  -9.78806764e-02f, 8.32663663e-03f, -1.54992389e-02f, -8.82838368e-02f, 6.12403564e-02f, 1.90143108e-01f, 1.48412064e-02f, 2.35693187e-01f, 2.03636870e-01f, 1.37612909e-01f,
  1.23908371e-01f, 1.75096750e-01f, 1.27950490e-01f, -1.72761217e-01f, 2.24963933e-01f, 5.51153235e-02f, -1.77983493e-01f, 3.26588899e-01f, 8.16970249e-04f, 2.79838927e-02f,
  1.19659826e-02f, 7.51151564e-03f, -1.11153066e-01f, -1.08772188e-01f, 8.39771777e-02f, 1.79166958e-01f, 4.06149477e-01f, 8.84514153e-02f, -2.19681948e-01f, 8.97923931e-02f,
  -2.62707323e-01f, -1.44237086e-01f, -1.35716453e-01f, 1.46480337e-01f, -4.10454534e-02f, 7.43029043e-02f, -3.28495353e-02f, 1.38158659e-02f, 9.45701152e-02f, 4.23826389e-02f,
  2.51274526e-01f, -1.19106926e-01f, 1.94971114e-02f, 1.19405657e-01f, 2.06168890e-01f, -9.34869051e-02f, -2.21407443e-01f, -1.47293523e-01f, 2.25125238e-01f, 2.00378016e-01f,
  9.46994871e-02f, 5.42798162e-01f, 1.66972101e-01f, 2.52790242e-01f, -8.05974901e-02f, 2.18915686e-01f, -7.02374801e-02f, 2.31102884e-01f, 4.10499096e-01f, 1.26153499e-01f,
  3.03454638e-01f, 8.18695053e-02f, -1.42807290e-02f, -3.23299356e-02f, 4.23493773e-01f, 1.52661860e-01f, 3.81148279e-01f, -2.39526525e-01f, -1.41144367e-02f, 2.91375697e-01f,
  -2.53784686e-01f, -1.47942975e-01f, 3.11218947e-01f, 1.47351995e-01f, -3.46936673e-01f, -2.69942611e-01f, -1.16019763e-01f, -1.09613441e-01f, -3.16790119e-02f, 4.00546908e-01f,
  -1.37593657e-01f, 2.92770714e-01f, 1.83137685e-01f, 4.48708951e-01f, 2.17778876e-01f, 2.02714622e-01f, -3.54690462e-01f, 2.49157339e-01f, 3.67408961e-01f, -1.79953687e-02f,
  1.47311121e-01f, -1.42029285e-01f, 2.51427919e-01f, 1.19442210e-01f, 1.99920550e-01f, -3.69121104e-01f, 2.08630487e-01f, 3.13540161e-01f, 2.24530041e-01f, -1.83432460e-01f,
  -4.23362792e-01f, -3.37618709e-01f, 7.46751428e-01f, -7.97927201e-01f, 4.56605554e-01f, -5.58334708e-01f, 1.97723448e-01f, -4.41476852e-01f, -2.45354250e-01f, -2.85303324e-01f,
  -4.93304819e-01f, -3.97831857e-01f, -4.82797533e-01f, 4.62369710e-01f, 4.19877172e-02f, -2.70974249e-01f, -3.31041783e-01f, -1.86079681e-01f, -3.60425770e-01f, 3.08309674e-01f,
  3.22303586e-02f, -3.16082239e-01f, -7.56830931e-01f, 9.39435214e-02f, -6.35741949e-01f, -1.07078779e+00f, -6.56384528e-01f, 4.44294661e-02f, -8.37205872e-02f, 4.55174521e-02f,
  -2.38524050e-01f, 9.63355228e-02f, -1.74008504e-01f, 6.72059832e-03f, 5.25264069e-02f, 1.26287088e-01f, -6.90568313e-02f, -4.21114787e-02f, -7.32628861e-03f, 1.33291125e-01f,
  1.54485814e-02f, -4.15541157e-02f, -5.33763086e-03f, 2.01771125e-01f, -1.76503897e-01f, -1.45312741e-01f, 1.83854476e-02f, -2.58318726e-02f, 6.69555971e-03f, -3.14624906e-02f,
  1.08736880e-01f, -7.12841302e-02f, 2.34649241e-01f, 6.76343590e-02f, -3.31488967e-01f, 8.65838304e-02f, -1.40665919e-01f, -3.61804776e-02f, 1.58746779e-01f, 9.57446694e-02f,
  2.37372771e-01f, 2.27730535e-02f, 2.37399265e-01f, 2.11301655e-01f, 8.29863474e-02f, 1.02031454e-01f, 2.06133574e-01f, 5.80209345e-02f, -9.67442915e-02f, 7.95346051e-02f,
  6.41578734e-02f, 1.31523341e-01f, -3.48971695e-01f, -1.20323757e-02f, 2.36038435e-02f, 1.18510239e-01f, -1.90360546e-01f, 7.70082027e-02f, -8.95025861e-03f, 2.95534045e-01f,
  -3.63519695e-03f, -1.68550566e-01f, -2.22669140e-01f, -2.56142676e-01f, -9.25826579e-02f, -1.58018142e-01f, -2.26565599e-01f, -1.82242602e-01f, -1.92751065e-01f, -1.42522827e-01f,
  2.67613113e-01f, -7.51202777e-02f, -4.15192872e-01f, 5.94758570e-01f, -2.51457125e-01f, 2.76112407e-01f, -4.30571824e-01f, 6.99527264e-02f, -1.17112689e-01f, 5.87032363e-02f,
  -2.70924896e-01f, 1.86243653e-01f, 6.30861044e-01f, 3.40919085e-02f, 4.94709909e-01f, 1.46563917e-01f, 2.33669370e-01f, 2.41575375e-01f, 1.41114779e-02f, -2.17167497e-01f,
  2.52519995e-01f, -3.58362757e-02f, -2.57167011e-01f, 2.41074592e-01f, 1.89796627e-01f, -3.65320444e-02f, -2.76169658e-01f, 1.13224816e-02f, -4.60736722e-01f, -3.84424359e-01f,
  4.63369302e-02f, 1.50198221e-01f, -3.70751143e-01f, 3.16190243e-01f, -2.82975942e-01f, -5.62307648e-02f, -2.59452969e-01f, -4.55420405e-01f, -1.09115258e-01f, 1.97578028e-01f,
  -4.46390599e-01f, -4.45037484e-01f, 1.72323495e-01f, 6.92356050e-01f, -2.34488353e-01f, -3.97849381e-01f, -1.36001110e-01f, -1.13860883e-01f, -4.56992179e-01f, -4.46729183e-01f,
  -3.22628736e-01f, -5.43286681e-01f, -1.00414798e-01f, 4.31438327e-01f, 5.83390892e-02f, -1.47277308e+00f, 5.46892822e-01f, -3.48408908e-01f, 3.09844553e-01f, -4.18239772e-01f,
  -2.69483626e-01f, 5.40512443e-01f, -3.14033985e-01f, -4.70028192e-01f, 2.83480614e-01f, 9.57645923e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.33806598e-02f, 2.99888477e-02f, -2.61004567e-02f, 5.62284291e-02f, -6.62115887e-02f, 9.56554487e-02f, 3.33805420e-02f, 1.28552377e-01f, 9.18449387e-02f, 1.54074905e-02f,
  -1.01226717e-01f, -2.51928344e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    