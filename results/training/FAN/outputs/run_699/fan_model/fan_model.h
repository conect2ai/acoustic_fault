/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.48938513e-01f, -2.52472818e-01f, -2.28446215e-01f, 6.19178042e-02f, -2.06173941e-01f, -2.08213374e-01f, -3.86650473e-01f, -9.51368711e-04f, 1.14646740e-01f, -1.03291228e-01f,
  -7.26155424e-03f, 2.04361752e-01f, 1.10432439e-01f, 1.40987277e-01f, 1.31267726e-01f, -3.93448472e-01f, -2.54087538e-01f, 1.06087923e-01f, 2.81072229e-01f, 1.51493639e-01f,
  -4.40010205e-02f, -4.69063036e-02f, 1.61166519e-01f, -1.34400174e-03f, -1.24966033e-01f, 6.56818673e-02f, -1.60218075e-01f, -1.37262255e-01f, -1.20913289e-01f, -2.25880012e-01f,
  2.28893477e-02f, 4.38228287e-02f, 1.22869918e-02f, -3.37714329e-02f, -1.63809672e-01f, 3.15947868e-02f, -1.19987674e-01f, -3.17392386e-02f, -9.50321928e-02f, -3.91915031e-02f,
  -5.48437648e-02f, -3.36891338e-02f, -1.61764920e-02f, -1.23315997e-01f, -4.48191073e-03f, 3.63852619e-03f, -8.20494667e-02f, -1.57326143e-02f, -1.31956771e-01f, -1.88843399e-01f,
  -2.42786974e-01f, -9.64007005e-02f, -1.49112180e-01f, -8.01452547e-02f, -1.24362139e-02f, 8.39945152e-02f, -9.65586081e-02f, -2.30774786e-02f, 1.53929312e-02f, -8.68056789e-02f,
  2.60718111e-02f, 7.64304306e-03f, 3.82928103e-02f, 4.17379178e-02f, 1.11242332e-01f, 8.42156112e-02f, 1.07933590e-02f, 1.65668335e-02f, 8.29906836e-02f, 1.00062631e-01f,
  1.11946985e-01f, 5.11913709e-02f, 4.14312817e-02f, 8.27911049e-02f, 6.93550035e-02f, 2.57701296e-02f, 1.12482384e-01f, 1.03428103e-01f, 2.03005373e-02f, 1.08863682e-01f,
  1.38673395e-01f, 2.00263590e-01f, 8.85758996e-02f, 7.02614784e-02f, 1.08076774e-01f, 1.33502394e-01f, 7.57815391e-02f, 6.24110177e-02f, 4.67677638e-02f, 6.36057779e-02f,
  -5.84787456e-03f, -2.06780471e-02f, -4.20890115e-02f, 1.55020086e-02f, -1.04166903e-01f, -1.02212824e-01f, 2.57315696e-03f, -4.77933399e-02f, -5.16760089e-02f, -7.47576952e-02f,
  3.36282067e-02f, -6.11544885e-02f, -9.21586826e-02f, -9.30856913e-02f, -7.33993482e-03f, -1.41383114e-03f, -1.45530000e-01f, 1.24499509e-02f, -2.47052647e-02f, -2.69213784e-02f,
  -1.40499741e-01f, -5.16948514e-02f, 4.80806426e-04f, -9.03665870e-02f, -6.22650757e-02f, -3.26250643e-02f, -8.41499493e-02f, -9.67444852e-02f, 4.94397581e-02f, -1.69334695e-01f,
  1.66293949e-01f, 5.70592331e-03f, 2.48665154e-01f, 2.11940318e-01f, 8.98520574e-02f, 2.07956731e-01f, 4.55547087e-02f, 8.90102088e-02f, 7.77150169e-02f, 2.02791899e-01f,
  5.41708656e-02f, 1.67631403e-01f, 1.72463566e-01f, 1.40048519e-01f, 8.01363960e-02f, 2.64576882e-01f, 2.19153717e-01f, 3.34846646e-01f, 2.48645991e-01f, 1.24399982e-01f,
  1.94958761e-01f, 1.50594845e-01f, 1.27813056e-01f, 6.94596693e-02f, 1.02810390e-01f, 2.24496841e-01f, 2.46358529e-01f, 1.49383888e-01f, 1.93581492e-01f, 2.51131386e-01f,
  4.24046665e-01f, 1.58304125e-01f, 9.94959399e-02f, 1.07527025e-01f, 9.65957195e-02f, 1.99172392e-01f, 1.86218157e-01f, 1.97324425e-01f, 1.72712892e-01f, 1.49944186e-01f,
  1.59659192e-01f, 1.21289760e-01f, 8.73703808e-02f, 5.70391156e-02f, 1.35651484e-01f, 1.91822395e-01f, 5.42175621e-02f, 6.24920763e-02f, 1.72404706e-01f, 8.24841261e-02f,
  1.97255999e-01f, 2.16185987e-01f, 2.25074172e-01f, 1.43174589e-01f, 1.33005887e-01f, 9.68257710e-02f, 9.27831382e-02f, 2.31452733e-01f, 1.74021035e-01f, 2.92251676e-01f,
  -9.78470519e-02f, -9.23320279e-02f, -9.20151696e-02f, -1.58733845e-01f, -9.79987159e-02f, -1.54474646e-01f, -1.08073667e-01f, -8.23285356e-02f, -7.74257332e-02f, -9.96914729e-02f,
  -1.56119049e-01f, -1.29913643e-01f, -1.22408792e-01f, -8.28239843e-02f, -1.75841033e-01f, -1.06797002e-01f, -7.98455626e-02f, -1.04113333e-01f, -1.51891664e-01f, -4.83402759e-02f,
  -1.17680386e-01f, -1.01072185e-01f, -6.61102459e-02f, -1.10220589e-01f, -1.09418854e-01f, -1.45694301e-01f, -1.29251897e-01f, -9.86791924e-02f, -1.74715266e-01f, -1.25500783e-01f,
  1.33938923e-01f, 1.80451706e-01f, 2.79715449e-01f, 1.81522250e-01f, 2.64755577e-01f, 7.75690451e-02f, 1.23261757e-01f, 2.26207450e-01f, 9.50557664e-02f, 2.15560690e-01f,
  7.67861232e-02f, 1.37026355e-01f, 1.00009546e-01f, 5.58737740e-02f, 1.49193600e-01f, 7.22552091e-02f, 1.67061895e-01f, 1.34588763e-01f, 6.56475350e-02f, 4.78590429e-02f,
  1.06451139e-02f, 1.65847242e-01f, 1.51929677e-01f, 1.88348219e-01f, 1.85256109e-01f, 1.46445230e-01f, 1.04716606e-01f, 2.66348153e-01f, 2.61655688e-01f, 2.21564442e-01f,
  -3.61762196e-01f, -2.19287667e-02f, -8.09130892e-02f, -2.12954521e-01f, 9.84631330e-02f, 3.89602110e-02f, 1.95056740e-02f, -1.00018635e-01f, -4.59629297e-02f, -8.55968893e-02f,
  1.53419793e-01f, 2.14905992e-01f, 1.90682366e-01f, 2.28548676e-01f, 1.62221968e-01f, -1.03692207e-02f, 5.85960820e-02f, 1.65444806e-01f, 1.53513372e-01f, 1.41116083e-01f,
  9.30276364e-02f, 2.82444675e-02f, -9.77129787e-02f, 2.57940795e-02f, -1.11611858e-01f, 1.33996516e-01f, -1.58988804e-01f, -5.05154356e-02f, 1.42205372e-01f, -2.42453888e-02f,
  8.30355957e-02f, -1.75340191e-01f, 4.93040644e-02f, 1.90305442e-01f, 6.83367252e-02f, -1.65567230e-02f, -4.62792534e-03f, -1.03937745e-01f, -5.22698909e-02f, 3.12553346e-02f,
  3.66508849e-02f, 8.98149386e-02f, 6.47108555e-02f, 6.10007644e-02f, 7.86132086e-03f, -1.08774398e-02f, -7.80199468e-02f, -4.38657627e-02f, -2.72962898e-02f, -4.02458347e-02f,
  1.17837526e-01f, 1.49723724e-01f, 5.00223716e-04f, -2.02335846e-02f, 6.77989796e-02f, 1.63010240e-01f, 8.27376032e-04f, 8.23309124e-02f, 6.15805201e-02f, -9.18875039e-02f,
  5.65057397e-02f, -4.10952196e-02f, -9.13839904e-05f, -7.90452138e-02f, -3.74156646e-02f, -7.52706528e-02f, 7.67970011e-02f, 5.83473500e-03f, 3.39382999e-02f, -2.51966976e-02f,
  1.76372379e-02f, 1.29448939e-02f, -6.47141561e-02f, 2.67699156e-02f, 7.81586990e-02f, -2.64121071e-02f, 6.39042854e-02f, -2.03766916e-02f, 2.02481803e-02f, 4.82127257e-03f,
  -4.25497629e-02f, 4.92812470e-02f, -1.27418816e-01f, 7.35771358e-02f, 3.93659621e-02f, 4.60355096e-02f, -6.62156008e-03f, -1.33826695e-02f, -8.28500316e-02f, 8.12613219e-03f,
  -7.24595413e-02f, 1.02524117e-01f, -8.51433426e-02f, -2.55481880e-02f, 1.77686345e-02f, 1.70160811e-02f, -1.49202077e-02f, -6.51031584e-02f, -3.40231159e-03f, 4.98708375e-02f,
  8.33910182e-02f, 1.30992616e-02f, 4.49816473e-02f, 4.92994785e-02f, 7.29437694e-02f, 7.34456629e-02f, -2.66344566e-02f, 6.02481030e-02f, 1.16095103e-01f, -4.62647947e-03f,
  4.50042412e-02f, -2.39673201e-02f, -3.89202428e-03f, 3.03325672e-02f, -2.41593830e-02f, 6.53015003e-02f, 4.05606888e-02f, -1.08977064e-01f, 1.06998168e-01f, -2.18524650e-01f,
  1.44969136e-01f, -1.41188800e-01f, -3.30797657e-02f, 6.42416850e-02f, -2.53945775e-02f, -1.27662927e-01f, -2.73460627e-01f, -6.94554821e-02f, -1.60617635e-01f, -2.31323466e-01f,
  -1.88423872e-01f, -1.54606730e-01f, -3.56590003e-02f, -9.32925642e-02f, -5.38515970e-02f, -1.02735244e-01f, -1.43999085e-01f, 1.38933793e-01f, -3.42609361e-02f, -2.24973321e-01f,
  -2.74364412e-01f, -3.49486768e-02f, 1.71920229e-02f, -3.42405289e-02f, -1.18088104e-01f, -2.22090930e-01f, -2.07171619e-01f, 3.98674719e-02f, -1.12547994e-01f, 2.34392378e-02f,
  -8.29028264e-02f, 2.27022711e-02f, -8.54803622e-02f, -1.41088307e-01f, -2.08420470e-01f, -2.01733083e-01f, -2.48020068e-01f, -9.62797254e-02f, -1.21452168e-01f, -1.39530987e-01f,
  -3.39343585e-02f, -1.84597224e-01f, -2.15066783e-03f, -1.86729833e-01f, -1.18210316e-01f, -1.78478718e-01f, -2.30022803e-01f, -4.93319845e-03f, -1.39731362e-01f, -1.41940102e-01f,
  -1.87692150e-01f, 2.66220327e-02f, -2.78048217e-03f, -1.32709667e-01f, -1.48260042e-01f, 1.12867476e-02f, -1.15497917e-01f, -8.34506452e-02f, -3.94813120e-02f, -2.79048026e-01f,
  -1.14758641e-01f, 9.26877856e-02f, -3.00399903e-02f, 6.78957673e-03f, 5.97671010e-02f, -3.27271149e-02f, 4.24378552e-02f, 7.93988630e-02f, 5.49486615e-02f, -3.07849851e-02f,
  5.10730734e-03f, 5.71504422e-02f, 9.79273245e-02f, 7.27788657e-02f, -1.03653325e-02f, 1.24362282e-01f, 8.81064683e-02f, 5.72801307e-02f, 1.54822066e-01f, 1.29456207e-01f,
  9.10532475e-02f, 1.28060922e-01f, 3.14758085e-02f, -2.20023599e-02f, 7.03119785e-02f, 1.23365611e-01f, 1.15343884e-01f, -3.98574844e-02f, 9.65077057e-02f, 1.24876924e-01f,
  -3.10443401e-01f, 3.57055441e-02f, -1.47674829e-01f, -8.68815407e-02f, -5.08524366e-02f, -5.07549718e-02f, -1.20739043e-01f, -1.12073541e-01f, -4.51734997e-02f, -1.69335827e-01f,
  -6.79129139e-02f, -5.56089580e-02f, -1.23516642e-01f, -1.63231418e-01f, -1.42402887e-01f, -1.65100709e-01f, -1.06910124e-01f, -1.53400406e-01f, -1.60276875e-01f, -1.40492171e-01f,
  -1.43559128e-01f, -1.36835769e-01f, -1.39046326e-01f, -9.94503573e-02f, -1.32351726e-01f, -1.39335424e-01f, -2.56652564e-01f, -1.34161323e-01f, -3.89165618e-02f, -3.46111029e-01f,
  1.54407710e-01f, 2.57278979e-01f, -1.01331167e-03f, 8.12571943e-02f, -5.05384170e-02f, -2.27307558e-01f, -2.44333535e-01f, -1.26668945e-01f, 1.09843031e-01f, 1.27260089e-01f,
  1.10916629e-01f, -9.14027616e-02f, 1.20896764e-01f, -1.10545084e-01f, -1.54235914e-01f, -2.03110687e-02f, 3.83771397e-02f, -1.48176238e-01f, -2.56563246e-01f, -2.95162827e-01f,
  -1.22022964e-01f, 5.84287271e-02f, 1.10203952e-01f, 5.88444434e-02f, 1.92918107e-02f, -1.41089320e-01f, 7.88460672e-02f, 6.36508465e-02f, 6.61245883e-02f, 1.74972296e-01f,
  -9.57333669e-02f, 1.31370082e-01f, -1.65069938e-01f, 5.31514874e-03f, 1.20957889e-01f, -5.71707040e-02f, -6.16710680e-03f, 9.77400169e-02f, -6.55133352e-02f, 2.60442682e-03f,
  -1.81190595e-02f, 2.85380166e-02f, -3.70157547e-02f, -3.83117422e-02f, -4.88030575e-02f, -7.82541558e-02f, -1.55354049e-02f, 3.01422570e-02f, 7.09603131e-02f, -3.24764550e-02f,
  -1.38301225e-02f, 4.65176813e-02f, 6.16921522e-02f, 4.77133542e-02f, -1.67267323e-02f, 2.46597566e-02f, 6.77580982e-02f, -6.54337555e-02f, -5.30275106e-02f, 1.52396122e-02f,
  -6.21924438e-02f, 3.62292528e-02f, 9.14576743e-03f, -1.80507470e-02f, -2.51767468e-02f, 8.90803710e-03f, -5.54345697e-02f, 2.07744576e-02f, -5.77335283e-02f, -7.10479021e-02f,
  1.97351109e-02f, 4.92020138e-02f, 9.96817462e-03f, -1.95656326e-02f, -6.25191405e-02f, -2.92088799e-02f, -3.18277255e-03f, 2.09691301e-02f, 1.80145696e-01f, 6.43378422e-02f,
  -3.36780176e-02f, 2.96355737e-03f, 2.03725975e-02f, -4.48913909e-02f, -1.34665789e-02f, -7.21870214e-02f, -2.30415221e-02f, -1.51214153e-02f, -3.37796137e-02f, 1.57003663e-02f,
  -1.23328529e-01f, -3.75320911e-02f, 2.26148479e-02f, -8.59283954e-02f, -7.01543316e-02f, -3.06118908e-03f, 1.21893417e-02f, 2.92185396e-02f, 4.69334684e-02f, 4.35481109e-02f,
  -3.92234735e-02f, -1.28982902e-01f, 5.77425882e-02f, 8.73648748e-03f, -1.55427217e-01f, -8.06837007e-02f, 8.63754228e-02f, -7.52197281e-02f, -5.24743833e-02f, 1.44058820e-02f,
  1.70099754e-02f, -2.97161825e-02f, -1.70994774e-01f, -6.66593388e-02f, -7.34695792e-02f, -1.75120965e-01f, -2.05184221e-01f, -9.77927595e-02f, -1.58111751e-01f, -4.90937606e-02f,
  -3.62463295e-01f, -1.18599810e-01f, -8.00530612e-02f, -2.32999444e-01f, -7.90639445e-02f, -2.72354960e-01f, -2.50784576e-01f, -1.00980923e-01f, -4.41360921e-02f, -2.15754863e-02f,
  8.98547471e-02f, 1.68283910e-01f, 1.06396198e-01f, 4.43197265e-02f, 1.05694421e-02f, -1.57273233e-01f, -1.65815860e-01f, -1.33662164e-01f, -3.86176631e-02f, -9.77574363e-02f,
  -1.47613689e-01f, -1.53439045e-01f, 2.32735500e-02f, -8.83298144e-02f, -5.20400777e-02f, -1.08242638e-01f, -8.61957446e-02f, -1.20449699e-02f, -2.07632370e-02f, -1.45712182e-01f,
  1.62151605e-01f, -6.83798864e-02f, 4.70054708e-02f, 3.58289853e-02f, -4.85463552e-02f, 6.13662833e-03f, -1.84425637e-02f, -6.69485107e-02f, -1.92566179e-02f, -2.87102684e-02f,
  9.93723720e-02f, 6.26133084e-02f, 1.93283334e-02f, -2.89316345e-02f, -1.42687157e-01f, -1.94172859e-02f, 1.52547145e-02f, -1.07612900e-01f, 2.52598245e-02f, 2.80181635e-02f,
  1.37525620e-02f, -5.22269197e-02f, 1.04359068e-01f, 9.80498046e-02f, 4.23129834e-02f, 1.34740219e-01f, 8.37662742e-02f, 1.05502553e-01f, 9.56972986e-02f, -9.23922956e-02f,
  1.64346548e-03f, 4.82955016e-02f, -3.89146991e-02f, -8.71049240e-02f, -3.13653015e-02f, -5.70033751e-02f, 2.97759306e-02f, -4.65954691e-02f, 1.35084977e-02f, -6.07989961e-03f,
  5.24422433e-03f, -8.56747851e-02f, 1.77154113e-02f, 2.90445797e-02f, 1.60114039e-02f, -5.01115024e-02f, -8.74095857e-02f, -6.68245703e-02f, -6.38032034e-02f, -1.70895644e-02f,
  -2.56477948e-02f, -3.63868326e-02f, -1.55738685e-02f, -1.18726768e-01f, -3.38218063e-02f, 7.92417582e-03f, -3.81157361e-02f, 4.95058782e-02f, -2.27278024e-02f, -7.53462762e-02f,
  1.27834186e-01f, 2.57115394e-01f, -1.20629095e-01f, 1.93963922e-03f, -7.26881698e-02f, 6.21597841e-02f, 2.94380207e-02f, -9.28119496e-02f, 9.24579508e-04f, -7.94955716e-02f,
  5.01482487e-02f, -6.95160180e-02f, -2.36484911e-02f, 1.83181148e-02f, -1.70987576e-01f, 1.90819670e-02f, -3.01758982e-02f, -5.03894389e-02f, 8.65102280e-04f, -1.78257227e-02f,
  5.04903402e-03f, -3.00697163e-02f, -7.32018054e-02f, 7.06392080e-02f, -4.62290272e-02f, -1.03357658e-02f, 2.05448549e-02f, -6.49092421e-02f, -1.41742388e-02f, -1.61628693e-01f,
  9.65418667e-02f, 1.01246566e-01f, 9.20655206e-02f, 1.45963989e-02f, 8.22901204e-02f, -1.26583762e-02f, -1.04719847e-01f, -2.53547933e-02f, 1.92545969e-02f, 3.30655314e-02f,
  4.12166491e-02f, -1.14239395e-01f, -4.86418745e-03f, 1.08772777e-02f, -1.24121346e-01f, -5.90698346e-02f, -3.98797654e-02f, 2.21188106e-02f, -5.80898672e-02f, 4.13234755e-02f,
  3.54247019e-02f, 2.09492698e-01f, 1.73371390e-01f, 1.26901701e-01f, 1.37333497e-01f, 1.35367066e-02f, 2.18101859e-01f, 2.53123760e-01f, 1.60202429e-01f, 3.77073586e-01f,
  8.83148462e-02f, -5.41835418e-03f, 1.07207850e-01f, 3.30477320e-02f, 8.94381329e-02f, -3.17140762e-03f, 1.60825595e-01f, 1.14590496e-01f, 1.16220377e-01f, 1.55050457e-01f,
  6.06793202e-02f, 1.20454662e-01f, 3.09141036e-02f, 4.58516106e-02f, 1.73699349e-01f, 1.23400249e-01f, 1.09160006e-01f, 4.10130024e-02f, 9.82300490e-02f, 1.04339600e-01f,
  -4.87891957e-03f, 9.91063491e-02f, 3.29748616e-02f, 2.10050661e-02f, -2.34590471e-02f, -5.17818294e-02f, 9.91783664e-02f, 6.61241487e-02f, 8.49105045e-02f, 2.57218570e-01f,
  -2.57983804e-02f, -2.92882212e-02f, -1.25871211e-01f, 2.62731276e-02f, -1.17725529e-01f, -2.00608596e-02f, -3.53057426e-03f, -5.63670956e-02f, -6.57163784e-02f, 4.19229344e-02f,
  9.28976573e-04f, -1.06085598e-01f, 5.61322980e-02f, 1.81442406e-02f, -2.52170675e-02f, 1.48938745e-02f, 2.68418863e-02f, 1.08551541e-02f, 3.11994571e-02f, -4.41520363e-02f,
  -3.35021168e-02f, -7.79795572e-02f, -2.78519653e-02f, 3.65696698e-02f, -1.43170711e-02f, -7.57539421e-02f, -1.00197107e-01f, -1.34510905e-01f, -2.40548663e-02f, -5.54534234e-02f,
  2.53468513e-01f, -1.00121126e-01f, 9.06944647e-02f, -4.12137620e-03f, 7.67265186e-02f, 2.23487448e-02f, -1.40910363e-02f, 3.51823643e-02f, 7.66397342e-02f, 9.31777954e-02f,
  1.07717626e-02f, -5.01233749e-02f, 7.21029565e-02f, -5.46770915e-03f, 4.44538565e-03f, 1.27972271e-02f, -3.04645789e-03f, 5.10474555e-02f, 1.53680528e-02f, -6.81839278e-03f,
  8.24933592e-03f, 1.05064787e-01f, -1.57875177e-02f, 6.88812733e-02f, -1.72780845e-02f, -1.56866722e-02f, -1.17811179e-02f, 3.50945890e-02f, -4.89629991e-02f, 1.92125499e-01f,
  -1.04986325e-01f, 8.08715969e-02f, -2.54397541e-01f, -3.52002271e-02f, -1.11685693e-01f, -9.99482721e-02f, -1.85481474e-01f, -3.21024172e-02f, 6.91995844e-02f, 4.40737791e-02f,
  1.38869584e-01f, 6.13386035e-02f, -1.68465299e-03f, 3.39818522e-02f, -1.66494578e-01f, -1.04995213e-01f, -1.48026794e-01f, -1.82047889e-01f, -1.27653480e-01f, 1.65055692e-02f,
  7.69510567e-02f, -6.83415383e-02f, -1.08175077e-01f, 5.18916920e-02f, 1.05909862e-01f, 3.52651142e-02f, 3.77896279e-02f, 3.68076600e-02f, -5.73931895e-02f, 9.78029892e-02f,
  8.49026963e-02f, -1.28656700e-02f, -8.18491653e-02f, 6.81374446e-02f, 1.35372125e-03f, -8.31642151e-02f, -9.79892164e-02f, -9.40484256e-02f, -7.24119693e-02f, 2.74983793e-02f,
  -1.47156864e-02f, 9.51484777e-03f, -9.79448333e-02f, -3.15796770e-02f, -1.55685648e-01f, -2.26444937e-02f, -5.42125814e-02f, -1.68799326e-01f, -1.55457482e-01f, 3.21825296e-02f,
  4.84698452e-02f, 1.90596562e-02f, -6.06511272e-02f, -1.38409421e-01f, -1.11396506e-01f, -1.40787557e-01f, -6.68784231e-02f, -2.76441593e-02f, -6.64650351e-02f, -3.93553302e-02f,
  -4.51873690e-02f, 2.27867588e-02f, 8.36153924e-02f, -2.62942109e-02f, 1.23493500e-01f, 9.98195484e-02f, 7.74534941e-02f, 6.33232668e-02f, 8.57903883e-02f, -1.76574085e-02f,
  3.43583636e-02f, 7.70751983e-02f, -1.31026777e-02f, 1.92079935e-02f, 1.33502156e-01f, 8.88914615e-02f, 9.41015556e-02f, 8.06681514e-02f, 5.20005189e-02f, 6.99181333e-02f,
  4.64522131e-02f, 7.96293393e-02f, 6.74831914e-03f, 6.14953898e-02f, 7.03444257e-02f, 6.47345930e-02f, 5.12529798e-02f, 1.10477343e-01f, 7.08715841e-02f, 1.18948415e-01f,
  1.63357377e-01f, -1.15343586e-01f, -4.00119647e-02f, 6.59134379e-03f, -8.45682845e-02f, -1.61464456e-02f, 1.32591957e-02f, -5.25942370e-02f, -2.13599298e-02f, -5.44742718e-02f,
  -1.42598832e-02f, -3.74024920e-02f, -9.22799110e-02f, -3.97571400e-02f, -4.27493900e-02f, -1.06557660e-01f, -4.06215014e-03f, -4.55234572e-02f, -1.37980014e-01f, 3.35102864e-02f,
  -1.12590022e-01f, -5.04178815e-02f, -1.33258775e-01f, 1.60610247e-02f, -7.58069828e-02f, -1.25877470e-01f, -1.28697619e-01f, -4.13703956e-02f, -1.19391292e-01f, 4.63170186e-02f,
  1.67150080e-01f, 2.86707133e-01f, 1.19851276e-01f, 7.79824257e-02f, -3.10247466e-02f, -1.72197983e-01f, -9.85012501e-02f, -1.22693978e-01f, -2.58118901e-02f, 1.92360789e-01f,
  1.05333313e-01f, -2.04798430e-01f, -1.17411509e-01f, -1.42645717e-01f, -1.12207569e-01f, -5.12244813e-02f, 8.40710402e-02f, -1.42618075e-01f, -4.33829010e-01f, -2.59735733e-01f,
  -1.51451632e-01f, 3.20119448e-02f, 5.37935123e-02f, -1.13040149e-01f, 1.18431441e-01f, -1.45554483e-01f, 9.91696343e-02f, 1.34050965e-01f, 1.02910131e-01f, 1.81820318e-01f,
  -4.80860211e-02f, 1.68181553e-01f, -2.29409307e-01f, -2.13941429e-02f, 2.26373523e-02f, -2.23846864e-02f, -7.83750974e-03f, 8.77090637e-03f, 2.83533409e-02f, 4.84896861e-02f,
  4.54740748e-02f, -3.82274762e-02f, -2.82525159e-02f, 6.66104779e-02f, -2.40850542e-02f, -7.05062300e-02f, 7.83656687e-02f, -5.20792380e-02f, -5.88165894e-02f, -3.16696353e-02f,
  8.15196633e-02f, 9.36331153e-02f, 1.73377857e-01f, -7.10391998e-02f, -8.60816762e-02f, -1.19090140e-01f, 1.19443052e-01f, -2.43619476e-02f, -4.41048667e-02f, 1.50102034e-01f,
  4.97424044e-02f, -1.01152454e-02f, 4.72303443e-02f, 3.33487205e-02f, 2.26074737e-02f, 3.55946869e-02f, 2.90848929e-02f, -3.63929011e-02f, -7.44189993e-02f, 7.85672963e-02f,
  -3.04763913e-02f, 3.59289944e-02f, -1.72019862e-02f, 5.37888147e-02f, 7.53974216e-03f, 1.11372769e-01f, -4.30570990e-02f, 3.99160571e-02f, 4.80379052e-02f, 6.51208535e-02f,
  -3.79389748e-02f, 4.63494398e-02f, 1.44325197e-01f, -6.06820099e-02f, 1.04749613e-01f, -4.94571030e-02f, -6.18538237e-04f, -2.86062006e-02f, -1.45678632e-02f, 7.51295015e-02f,
  1.73958987e-02f, -7.74754435e-02f, -1.69253349e-02f, -8.59086663e-02f, 5.14031127e-02f, 9.21147410e-03f, 9.02220085e-02f, 2.36614961e-02f, 1.65453013e-02f, -8.70592892e-02f,
  -5.69913983e-02f, -1.73448026e-02f, 8.33661035e-02f, -3.46634425e-02f, -6.58442602e-02f, -1.89289823e-02f, 2.48400979e-02f, 1.90838166e-02f, -2.71295439e-02f, -1.90949515e-02f,
  1.16325831e-02f, -3.50216329e-02f, -1.43365011e-01f, -1.13766663e-01f, -6.99494630e-02f, -1.08459562e-01f, -1.01535276e-01f, -7.43238032e-02f, -1.76617995e-01f, -5.20265810e-02f,
  -3.59842449e-01f, -7.78613985e-02f, 8.13021287e-02f, 1.67703570e-03f, 2.01179996e-01f, 3.38596143e-02f, -6.63391948e-02f, 2.52759159e-02f, 6.33887276e-02f, -1.08250357e-01f,
  1.15632676e-01f, 1.98413129e-03f, 8.80359858e-02f, -1.68003328e-02f, -1.07474692e-01f, -3.19836661e-02f, 4.70468886e-02f, -2.01704260e-02f, -5.96789233e-02f, -3.48286256e-02f,
  8.36656466e-02f, -3.01833935e-02f, -9.29142013e-02f, -9.77590159e-02f, -1.16683945e-01f, -9.82069597e-02f, -6.73464090e-02f, -5.88692427e-02f, -2.08149217e-02f, -1.90929204e-01f,
  -1.06155179e-01f, 2.14219955e-03f, -5.70949540e-02f, 7.90105760e-03f, 1.14287436e-01f, 3.52778062e-02f, -2.30480973e-02f, 7.48762712e-02f, 4.30052094e-02f, 6.55659735e-02f,
  9.43530630e-03f, -2.65124682e-02f, 3.05042546e-02f, 9.24168453e-02f, 3.41923274e-02f, 2.14302335e-02f, 1.10462949e-01f, 5.43755479e-02f, -2.71374546e-02f, 1.20827831e-01f,
  1.56779975e-01f, 6.60305172e-02f, 2.59937011e-02f, -3.53184505e-03f, -4.13164832e-02f, 8.96207094e-02f, -1.98361613e-02f, 1.96796991e-02f, -3.90369445e-02f, -1.85911104e-01f,
  -4.83696386e-02f, -6.41723489e-03f, -2.57433522e-02f, 7.13942796e-02f, -5.01179742e-03f, 2.83448249e-02f, 6.84905127e-02f, -1.74897425e-02f, -5.61557710e-02f, -2.95830760e-02f,
  -7.27454498e-02f, 1.77902244e-02f, -3.14508975e-02f, -9.79600474e-02f, -5.19799739e-02f, 6.92536589e-03f, 2.82400250e-02f, -8.81572589e-02f, 2.00276170e-02f, -1.36288991e-02f,
  -6.97911978e-02f, -3.39496844e-02f, -7.47693516e-03f, -1.18687771e-01f, -4.37323675e-02f, -4.58638668e-02f, -1.09578922e-01f, -9.95060708e-03f, -1.39859430e-02f, 5.38947340e-03f,
  -1.01380765e-01f, 8.21794793e-02f, -1.05670176e-01f, -1.72835693e-01f, 7.72628933e-03f, -6.60781637e-02f, -1.33965909e-01f, 1.19155431e-02f, -2.89628804e-02f, -2.45693866e-02f,
  -1.47580393e-02f, -1.32175192e-01f, 5.22055849e-03f, 5.90226194e-03f, -5.17155044e-02f, -4.38928679e-02f, 2.02214234e-02f, -4.75664139e-02f, 2.43068337e-02f, 1.42625319e-02f,
  2.58953813e-02f, -3.58381234e-02f, -1.28165573e-01f, -7.69028142e-02f, -1.03917150e-02f, -1.55838400e-01f, -7.35304877e-02f, -1.82658851e-01f, -2.17318982e-01f, -3.02673250e-01f,
  -2.73027241e-01f, -1.41898423e-01f, -2.07138956e-01f, 9.62038618e-03f, -5.24624698e-02f, -7.33433291e-02f, -3.29307854e-01f, -1.11674182e-01f, 9.56194922e-02f, -8.62130746e-02f,
  -4.85898741e-02f, 8.36588591e-02f, 2.21224576e-02f, 1.05988875e-01f, -1.86864585e-01f, -1.70038909e-01f, -1.52189434e-01f, -1.36563927e-01f, -7.82067701e-02f, -6.67568669e-02f,
  1.39750972e-01f, -1.14729321e-02f, -1.43599898e-01f, -5.43457381e-02f, 5.65603115e-02f, -3.58189642e-02f, -1.25433981e-01f, 3.01749092e-02f, -5.83471134e-02f, -4.67398465e-02f,
  -2.80696958e-01f, -9.47181657e-02f, -3.23799513e-02f, -3.82576548e-02f, -7.47831911e-02f, -7.32173100e-02f, -2.16840673e-02f, -1.32840887e-01f, -1.20439708e-01f, 1.29169933e-02f,
  1.19071119e-02f, -9.40054506e-02f, -3.72849889e-02f, -6.95634913e-03f, -9.03003886e-02f, 4.16399678e-03f, -7.79104605e-02f, -1.32218406e-01f, 6.04912965e-03f, -3.45738530e-02f,
  5.57038300e-02f, -9.03014764e-02f, -1.97957635e-01f, -7.31782317e-02f, -1.30909100e-01f, -3.32760997e-02f, -7.99769461e-02f, 4.90507856e-02f, -1.54683711e-02f, -3.14531215e-02f,
  6.38841093e-03f, 1.26281902e-02f, 3.74038406e-02f, 1.37834057e-01f, 4.08442244e-02f, 7.15041906e-02f, -2.90420800e-02f, 4.14726883e-02f, 4.33768779e-02f, 9.40130875e-02f,
  6.65217713e-02f, 3.85071188e-02f, -3.69234681e-02f, 4.49910313e-02f, 1.54152185e-01f, 3.31275389e-02f, -4.17232374e-03f, 4.57785651e-02f, 1.03926174e-01f, 1.93888228e-02f,
  1.10407934e-01f, 7.55982548e-02f, 1.35363480e-02f, 6.00665882e-02f, 1.16658747e-01f, 6.46750443e-03f, 2.97679808e-02f, 3.43208835e-02f, 1.46336809e-01f, 1.32024055e-02f,
  -1.01279803e-01f, -1.30550727e-01f, -1.15419842e-01f, -1.09813862e-01f, -1.43560082e-01f, 4.22745571e-03f, -1.24735169e-01f, -2.01343112e-02f, -6.17593192e-02f, -1.42221704e-01f,
  -1.74571678e-01f, -1.90137595e-01f, -1.25996724e-01f, -1.50241122e-01f, -1.21009104e-01f, -5.60285151e-02f, -2.00798525e-03f, -1.81044593e-01f, -1.16636947e-01f, -7.81787783e-02f,
  -5.21464422e-02f, -2.21160352e-01f, -1.07291371e-01f, -1.16041638e-01f, -9.15726647e-02f, -9.86571983e-02f, -1.72613963e-01f, -1.21723965e-01f, -2.61907101e-01f, -2.20320284e-01f,
  2.64043719e-01f, -3.69222686e-02f, -1.64938971e-01f, 2.37824246e-01f, -1.41677326e-02f, 5.23646846e-02f, -3.93599309e-02f, 1.73440918e-01f, 1.44387990e-01f, -1.40071884e-02f,
  -6.59477711e-02f, 9.51809734e-02f, -8.76194332e-04f, 1.19634137e-01f, 1.77030399e-01f, -2.74574626e-02f, 1.21880509e-01f, 5.79258464e-02f, 6.25728397e-03f, 1.16185009e-01f,
  6.57647699e-02f, 2.02991739e-01f, 2.18600452e-01f, 7.84680098e-02f, -8.17560107e-02f, -2.36786678e-02f, -5.23027964e-02f, 4.27473262e-02f, -4.80122268e-02f, -1.63733272e-03f,
  -2.38061994e-01f, -4.71993275e-02f, 1.44641891e-01f, 1.15964308e-01f, -5.10014743e-02f, 2.60671601e-02f, 8.25663581e-02f, -1.67672187e-02f, -7.52418786e-02f, 6.72196895e-02f,
  -6.88446015e-02f, 6.18071668e-02f, 8.48888084e-02f, 8.14503506e-02f, 7.06248730e-02f, -7.39553617e-03f, -2.72252019e-02f, 6.84052706e-02f, 2.53794640e-02f, -3.10748685e-02f,
  9.18501243e-02f, 5.47594167e-02f, -1.14494815e-01f, 1.05230045e-02f, -4.34978306e-02f, 1.85678937e-02f, -1.58361226e-01f, -5.36512472e-02f, -5.69252372e-02f, -2.92956810e-02f,
  -9.51224472e-03f, -1.25382915e-01f, -1.13611169e-01f, -8.95050354e-03f, -3.77069302e-02f, -4.61851247e-02f, -3.80347632e-02f, -1.98171716e-02f, 9.93123744e-03f, 2.31170934e-02f,
  -9.33916792e-02f, -1.19628586e-01f, 2.57220659e-02f, 1.62333045e-02f, -3.17957113e-03f, 2.73552015e-02f, 5.67370914e-02f, 3.66957262e-02f, 2.84591354e-02f, 4.97620218e-02f,
  -6.55603632e-02f, -8.24841261e-02f, -1.77101325e-02f, -8.37313384e-03f, 5.55409528e-02f, -1.24223148e-02f, 3.49584259e-02f, 7.52729774e-02f, 8.23635235e-02f, -8.43416750e-02f,
  -5.99399731e-02f, 8.23056251e-02f, 5.04383221e-02f, 3.65189724e-02f, -3.26260477e-02f, -5.59041724e-02f, 1.58262942e-02f, 3.23643871e-02f, -8.98004137e-03f, 6.10417454e-03f,
  2.43269075e-02f, 6.63192058e-03f, 2.05495730e-02f, 1.20914681e-02f, 4.47962731e-02f, 9.07157082e-04f, 6.52268156e-02f, 3.00552249e-02f, 2.52366997e-02f, 4.89471033e-02f,
  5.37766479e-02f, 1.08229265e-01f, 5.27091101e-02f, 2.76696421e-02f, 2.91759102e-03f, -3.56217586e-02f, -1.03322163e-01f, 1.23923616e-02f, -1.98043976e-02f, 7.19354302e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.42816007e-01f, -1.00599959e-01f, -1.74698338e-01f, 2.18078345e-01f, -6.36894852e-02f, -2.89051414e-01f, -3.83861721e-01f, -1.42857134e-01f, 1.99513748e-01f, 2.44901255e-02f,
  -8.04441422e-02f, 1.39836311e-01f, 9.42630544e-02f, -1.14671335e-01f, -2.81800896e-01f, -1.92742363e-01f, -2.37898603e-01f, -8.72378796e-02f, -1.28024518e-01f, -3.97529230e-02f,
  2.15237793e-02f, 6.88368753e-02f, 4.63025179e-03f, 1.32654356e-02f, 3.13710272e-01f, 4.34445255e-02f, -7.35354349e-02f, 2.13552583e-02f, -7.42464811e-02f, 3.28742087e-01f,
  2.30972588e-01f, 1.55585587e-01f, -3.62134837e-02f, 1.07110754e-01f, 7.28970999e-03f, -6.25662832e-03f, -6.68218136e-02f, 1.44376783e-02f, -4.71264012e-02f, 3.58886532e-02f,
  3.66587602e-02f, 7.86527991e-02f, 3.74356918e-02f, -1.27892926e-01f, -6.87084869e-02f, -7.64339119e-02f, -1.21101923e-01f, -6.77264333e-02f, -6.37304261e-02f, -7.98171386e-02f,
  1.07368588e-01f, 1.78022590e-02f, -1.02931328e-01f, -1.28212437e-01f, -1.14562735e-03f, -3.51530537e-02f, 6.64110808e-03f, 9.43646803e-02f, -6.88517988e-02f, 1.61260948e-01f,
  -7.55515471e-02f, 9.41302255e-02f, -5.49378693e-02f, -4.67952229e-02f, -4.29605581e-02f, 6.80011809e-02f, 2.54224259e-02f, 6.02383493e-03f, 1.10219628e-01f, -5.58485352e-02f,
  -5.23846708e-02f, 5.38596790e-03f, -1.47984279e-02f, 2.78915069e-03f, 2.53915526e-02f, 5.32644838e-02f, 6.69918284e-02f, -9.65343267e-02f, -6.65415004e-02f, -7.73169026e-02f,
  -1.08390108e-01f, 5.12552969e-02f, 2.31297743e-02f, 4.62669171e-02f, -6.42617494e-02f, 1.14944139e-02f, 8.47482681e-02f, -4.91917767e-02f, 6.76892027e-02f, -8.63603968e-03f,
  3.75496820e-02f, -3.87410998e-01f, 1.26401156e-01f, -9.02878270e-02f, 1.20441981e-01f, -2.42166780e-03f, 8.38333555e-03f, -8.24666917e-02f, 6.10006601e-02f, -5.43957278e-02f,
  -1.06773734e-01f, -3.70851494e-02f, 4.78566177e-02f, 5.78191876e-02f, -9.86404866e-02f, -4.68524545e-02f, -2.29875118e-01f, -1.01872921e-01f, -7.53463954e-02f, 6.52201697e-02f,
  -1.43076912e-01f, -1.23470455e-01f, -2.48572588e-01f, -8.86408687e-02f, 7.79336598e-03f, -1.73382804e-01f, -2.01471001e-01f, 5.08274771e-02f, -2.08237439e-01f, -2.91774005e-01f,
  -3.52947593e-01f, -1.23312540e-01f, 3.19348425e-01f, -2.33176693e-01f, -3.19709405e-02f, 2.40212344e-02f, -6.31047711e-02f, -1.39784142e-01f, -1.45480484e-01f, -8.77448022e-02f,
  -1.03408918e-01f, -3.56895983e-01f, -1.72545061e-01f, -9.41682979e-02f, 2.07424769e-03f, -2.99726333e-02f, 1.67914808e-01f, 1.82964832e-01f, -1.22194849e-01f, -2.03365684e-01f,
  -3.18644792e-01f, -1.27721950e-01f, 1.00972205e-01f, -3.73792760e-02f, -1.51529208e-01f, -1.58799246e-01f, 2.85438776e-01f, -2.01328527e-02f, 6.49538785e-02f, -1.87253430e-02f,
  8.38885382e-02f, 1.45008072e-01f, 1.58088997e-01f, -4.95473556e-02f, -4.28484082e-02f, 5.96237257e-02f, -1.86958209e-01f, 2.29074731e-01f, 1.58438832e-02f, 1.46371856e-01f,
  1.70460008e-02f, 2.52993628e-02f, -2.91864485e-01f, -9.84686092e-02f, -1.14097163e-01f, -1.91586375e-01f, 1.03282303e-01f, 3.65732871e-02f, 6.49712682e-02f, -2.95393802e-02f,
  -2.07285792e-01f, -1.40810445e-01f, -7.55900331e-03f, 7.66340792e-02f, 1.37246743e-01f, -2.22843071e-03f, 1.60239831e-01f, 7.99311399e-02f, 2.43740886e-01f, -6.28308952e-03f,
  5.28475381e-02f, 2.41485704e-02f, 3.07587609e-02f, 1.26373544e-01f, -1.53081594e-02f, 3.35033573e-02f, 1.04659326e-01f, 4.10243534e-02f, -1.19440220e-01f, -9.47766751e-02f,
  9.54733789e-02f, 4.47140709e-02f, -3.50772589e-02f, 7.34609291e-02f, 8.07379037e-02f, 2.92567406e-02f, -1.46260425e-01f, 1.32644951e-01f, 9.05389562e-02f, 1.57097653e-02f,
  -5.55928797e-02f, 1.70503873e-02f, -3.88867818e-02f, -6.60922229e-02f, 1.29217029e-01f, 3.35898027e-02f, -5.96320070e-02f, -1.53632358e-01f, -2.19329633e-03f, -5.47155291e-02f,
  -2.90438801e-01f, 3.09156418e-01f, -2.43210301e-01f, -1.10909138e-02f, -2.78422982e-02f, 2.65233070e-01f, 5.37530109e-02f, 4.27949652e-02f, 1.41626841e-03f, 2.34861057e-02f,
  -2.94813439e-02f, -1.19569764e-01f, 4.88743559e-02f, 6.24687932e-02f, -1.80103227e-01f, -4.31685485e-02f, -1.72962576e-01f, -1.20873645e-01f, -1.70327902e-01f, -2.30954349e-01f,
  -2.15085536e-01f, -2.75694907e-01f, -3.62847209e-01f, -1.93545505e-01f, -2.46850789e-01f, -2.50154942e-01f, -1.78575933e-01f, -2.56102413e-01f, -6.18762597e-02f, -4.27008122e-01f,
  -2.83901483e-01f, -3.03040445e-01f, -1.15801856e-01f, -3.19917530e-01f, -1.66080430e-01f, 7.61747807e-02f, -1.42843872e-01f, -4.80105691e-02f, -1.53003007e-01f, -2.31445119e-01f,
  -1.51977494e-01f, 7.75928944e-02f, -5.66100627e-02f, 1.63901553e-01f, 5.72960228e-02f, -3.56641918e-01f, -1.70162693e-01f, 1.20155819e-01f, 3.19666177e-01f, 1.94169939e-01f,
  2.10889801e-02f, -1.61460832e-01f, 1.31217211e-01f, 6.22818284e-02f, -3.31785500e-01f, -1.18443377e-01f, -1.55913576e-01f, 4.98334505e-02f, 3.76732573e-02f, -2.03126743e-01f,
  -3.98350924e-01f, -2.02224389e-01f, 1.52596340e-01f, 7.11907595e-02f, -1.66653082e-01f, 4.48435661e-04f, -4.07180563e-02f, -1.45931393e-01f, -2.17821542e-02f, -1.27537832e-01f,
  9.03237332e-03f, -3.83266471e-02f, -4.39866967e-02f, -7.11241886e-02f, -9.87881273e-02f, -7.98397698e-03f, -2.28042677e-02f, 7.18973279e-02f, 4.21819799e-02f, 1.77960005e-02f,
  9.46591347e-02f, -2.76745055e-02f, 7.23651648e-02f, 1.29929349e-01f, -1.02465972e-02f, -4.51523671e-03f, 1.05870562e-02f, 1.50368318e-01f, 2.73797244e-01f, -1.02672264e-01f,
  -2.60804724e-02f, -6.16644546e-02f, 1.40467277e-02f, -3.02042719e-02f, 3.79590169e-02f, 3.95070054e-02f, -3.80904935e-02f, -5.98803945e-02f, 7.20499381e-02f, -7.12327436e-02f,
  1.17698768e-02f, 5.96431142e-04f, 1.61307305e-03f, -8.23678821e-02f, -1.63400378e-02f, 8.52665603e-02f, -5.47871226e-03f, -1.69944353e-02f, -2.60830950e-02f, 6.76089525e-02f,
  3.80558148e-02f, 4.75556031e-02f, 6.12489656e-02f, 4.36315909e-02f, 3.93079333e-02f, -3.34865339e-02f, 2.03899592e-02f, 6.45004585e-02f, -2.47087497e-02f, 6.45492151e-02f,
  -4.19176251e-01f, 2.47507975e-01f, -2.50281036e-01f, 5.78052364e-02f, -7.54893273e-02f, 1.05449766e-01f, -1.00620210e-01f, -1.04331531e-01f, -8.45889300e-02f, -1.13742791e-01f,
  9.83667523e-02f, -5.59545159e-02f, -5.94226979e-02f, -1.75780132e-02f, 7.87304807e-03f, -1.55798886e-02f, 8.50383937e-02f, -9.66821611e-03f, 1.86649829e-01f, 1.21176630e-01f,
  1.11248545e-01f, -2.45226342e-02f, -1.55942604e-01f, 8.79396219e-03f, 1.40853420e-01f, 2.93680467e-03f, -4.13524918e-02f, 9.83722433e-02f, 1.24735206e-01f, -1.41346946e-01f,
  -2.82775402e-01f, -1.87916443e-01f, 2.96901278e-02f, -2.51163632e-01f, 9.05001611e-02f, 5.14115021e-03f, -1.24746427e-01f, -7.87000284e-02f, -6.49300963e-02f, -1.76697060e-01f,
  7.70505667e-02f, 1.65134415e-01f, -2.23541241e-02f, 7.21149072e-02f, 6.02115802e-02f, -1.45251572e-01f, -4.56550978e-02f, 5.14020957e-02f, 2.43635729e-01f, 1.82097390e-01f,
  1.20047163e-02f, 1.27551872e-02f, 1.29264100e-02f, 8.57627168e-02f, -2.23686367e-01f, 2.14111861e-02f, -8.88056681e-02f, -2.83400659e-02f, 2.57327780e-02f, -9.90682393e-02f,
  -1.13321938e-01f, -6.63196892e-02f, 1.50034621e-01f, 8.33742246e-02f, 3.06022656e-03f, -2.54124045e-01f, -1.89986706e-01f, 3.87897529e-02f, 1.10000465e-02f, -4.30548266e-02f,
  -9.06105414e-02f, 1.13702506e-01f, -9.39128473e-02f, 8.31808299e-02f, 2.00384520e-02f, -7.52097964e-02f, 1.98096372e-02f, 1.30919173e-01f, 5.09805195e-02f, 4.31163944e-02f,
  2.53839437e-02f, -1.74427591e-02f, -6.38156980e-02f, -4.63009402e-02f, -8.87994617e-02f, 1.48355126e-01f, 1.94477122e-02f, -4.72017080e-02f, -1.49432108e-01f, -3.04239243e-01f,
  1.86413318e-01f, 1.24630474e-01f, 1.00680977e-01f, -3.83140445e-02f, -1.76477730e-02f, 3.29708420e-02f, 4.92479876e-02f, 1.33624420e-01f, 9.63325277e-02f, -3.37025635e-02f,
  -1.37209345e-03f, 5.67385815e-02f, 8.09049383e-02f, 2.51285043e-02f, -3.20295198e-03f, -1.35008991e-01f, 1.36377076e-02f, -3.59794088e-02f, 6.96336897e-03f, -1.51207494e-02f,
  6.40177280e-02f, -6.03344254e-02f, 5.40506244e-02f, 5.10592163e-02f, -1.00696020e-01f, -7.58297816e-02f, -2.12479338e-01f, 2.76655126e-02f, -8.82293954e-02f, -5.56363128e-02f,
  -2.09337696e-01f, 1.72211677e-01f, -5.94596891e-03f, 6.83326572e-02f, 1.48746734e-02f, -3.13984766e-03f, -1.85026199e-01f, 6.67937547e-02f, 4.21681479e-02f, -9.80100185e-02f,
  -4.71962318e-02f, -5.88274226e-02f, -1.22057393e-01f, 2.01043829e-01f, 1.34701550e-01f, -1.28634736e-01f, 2.65662055e-02f, 1.65726077e-02f, 6.32517636e-02f, -1.04369342e-01f,
  -5.20102046e-02f, -6.90276846e-02f, -2.23281562e-01f, -1.56035542e-01f, -1.82590246e-01f, -2.38074753e-02f, -1.28533855e-01f, -8.86083469e-02f, -2.24707380e-01f, -4.43089545e-01f,
  3.34552795e-01f, -3.15132797e-01f, -3.05471450e-01f, 1.45093612e-02f, -1.31707579e-01f, -1.13764569e-01f, -2.60996044e-01f, 2.44431924e-02f, 7.90970325e-02f, -2.44203895e-01f,
  -5.03596179e-02f, 3.02468508e-01f, 8.78860578e-02f, 7.92768300e-02f, 3.54293617e-03f, -3.02697927e-01f, -2.21666932e-01f, 7.28449300e-02f, 3.23855549e-01f, 1.27241284e-01f,
  6.66356608e-02f, -3.55393393e-03f, 1.57570288e-01f, 3.61343217e-03f, -6.48594275e-02f, -2.36276500e-02f, -2.14690834e-01f, -1.39458358e-01f, -1.30914837e-01f, -2.37467036e-01f,
  -1.63370997e-01f, 6.88782260e-02f, 1.40357867e-01f, 1.33706301e-01f, -1.60152406e-01f, 5.17846681e-02f, 4.70013320e-02f, -1.13748185e-01f, 1.57681424e-02f, -1.76763162e-02f,
  9.55674797e-02f, 2.91477330e-02f, 9.73638743e-02f, 8.08571279e-03f, 3.91134853e-03f, -1.87721220e-03f, 3.81269604e-02f, -2.22612210e-02f, -5.98577261e-02f, -6.31892830e-02f,
  -1.33728072e-01f, 7.03470036e-02f, 8.36508200e-02f, -1.11368537e-01f, 5.66941202e-02f, 9.15895328e-02f, -4.80296984e-02f, -1.40559452e-03f, -6.13526022e-03f, -2.39539936e-01f,
  2.82937642e-02f, -3.96734960e-02f, -4.66887057e-02f, -5.71565330e-02f, 6.10606074e-02f, 1.72155667e-02f, 1.96413659e-02f, 1.01510555e-01f, 5.29879406e-02f, -6.90275803e-02f,
  -3.10005900e-02f, -7.63241202e-03f, 1.31280974e-01f, -5.42500988e-02f, -2.03180425e-02f, -3.61633487e-02f, 3.97750316e-03f, 5.46388850e-02f, -6.45933747e-02f, -5.03760912e-02f,
  1.35324165e-01f, 6.00246079e-02f, -5.66504598e-02f, 3.96414511e-02f, 1.85883790e-02f, 4.53185150e-03f, -2.48684436e-02f, 1.21345252e-01f, 8.78642648e-02f, 7.26826862e-02f,
  -1.09069142e-02f, -3.79253104e-02f, -8.58465657e-02f, 4.75317873e-02f, 9.73801538e-02f, 1.88927855e-02f, -8.26152340e-02f, 3.78021263e-02f, 2.59154718e-02f, -2.13474408e-02f,
  4.99292426e-02f, -1.26993936e-02f, -6.37165010e-02f, -4.44619395e-02f, 2.99170520e-02f, 3.58112305e-02f, -9.80818197e-02f, 1.56023666e-01f, -1.56475566e-02f, -4.71508950e-02f,
  -7.15730563e-02f, -2.31889840e-02f, 1.22649699e-01f, 7.48434588e-02f, -7.77017034e-04f, 5.36834300e-02f, -1.10292599e-01f, 7.27990642e-03f, -3.48285548e-02f, -2.82570958e-01f,
  4.96565610e-01f, -2.91762143e-01f, 5.61350659e-02f, 3.79294336e-01f, 3.07490259e-01f, 1.21328667e-01f, 1.16893873e-01f, 1.04013681e-01f, 1.27299085e-01f, 1.33070603e-01f,
  -1.39469225e-02f, 9.10562947e-02f, 1.20350257e-01f, 1.34422239e-02f, -8.27485812e-04f, 1.08768968e-02f, 5.63483052e-02f, 3.15045216e-03f, 9.06014442e-02f, 1.13618828e-01f,
  1.23407781e-01f, 3.83379012e-02f, -6.42133430e-02f, -8.82237256e-02f, -6.92901462e-02f, 2.24941388e-01f, 1.27515405e-01f, -9.54693183e-02f, -3.78675945e-03f, -1.13776714e-01f,
  -1.78714320e-01f, -9.26074162e-02f, 1.50309920e-01f, -1.55134303e-02f, -1.03820547e-01f, -2.30529979e-02f, 5.18901981e-02f, -6.85233697e-02f, 9.71136801e-03f, -4.74594869e-02f,
  2.49248911e-02f, -1.05429739e-01f, -1.60000056e-01f, -8.50339085e-02f, -6.10702783e-02f, 1.31356120e-02f, -1.11011930e-01f, -2.25760229e-02f, 5.04401848e-02f, -1.07587762e-01f,
  -1.23162873e-01f, -7.29334205e-02f, -1.46884471e-02f, 1.21083625e-01f, -6.41985312e-02f, 8.61249343e-02f, 3.62915955e-02f, -1.22809321e-01f, -1.59931481e-02f, 9.68930051e-02f,
  2.53221065e-01f, -4.56057899e-02f, -2.22595991e-03f, 8.50305557e-02f, 2.24502757e-02f, 3.13336290e-02f, 2.99569331e-02f, -4.53805998e-02f, 8.50877389e-02f, 3.52604128e-02f,
  3.59643139e-02f, 1.48064211e-01f, -3.06225698e-02f, 2.86811008e-03f, -8.20380263e-03f, -6.13921396e-02f, 2.49942597e-02f, 2.34989692e-02f, -1.37056289e-02f, -3.22765019e-03f,
  5.28341606e-02f, -4.65622433e-02f, -8.14463869e-02f, -1.06198199e-01f, -1.52713463e-01f, 7.69622549e-02f, -3.41492072e-02f, -9.45183411e-02f, -1.33361802e-01f, -2.63349041e-02f,
  -1.07480980e-01f, 1.71271011e-01f, 1.02848217e-01f, -1.76550493e-01f, 4.98187542e-02f, -1.28261909e-01f, -3.47483903e-02f, 8.41064826e-02f, 2.95117553e-02f, 1.35882765e-01f,
  6.23033494e-02f, -1.01480350e-01f, -4.69973348e-02f, -3.46329436e-02f, 1.66128963e-01f, 3.14917378e-02f, -3.28843556e-02f, 1.28110275e-01f, 8.32654387e-02f, -2.00083330e-02f,
  -1.10921636e-01f, 1.34787321e-01f, 2.00996935e-01f, 2.65636116e-01f, 1.22411713e-01f, 2.41034508e-01f, 6.79643545e-03f, 7.54513144e-02f, 4.32239063e-02f, 2.22853154e-01f,
  4.80753988e-01f, -3.19675773e-01f, -9.67349112e-02f, 2.75145262e-01f, 1.33829683e-01f, 2.74038821e-01f, 2.26381034e-01f, 1.86147109e-01f, 1.25211358e-01f, 4.38532494e-02f,
  -2.90644705e-01f, -3.96551937e-01f, -4.28211987e-01f, -3.37681323e-01f, -2.66837031e-01f, 1.87422082e-01f, 2.37825125e-01f, 6.56699389e-02f, 1.10295959e-01f, 6.34148568e-02f,
  1.21234201e-01f, 2.99523294e-01f, 1.79259598e-01f, -7.66036659e-02f, 4.04247157e-02f, -4.65195291e-02f, -1.28426012e-02f, -1.80013909e-03f, -2.51866579e-01f, -4.08406556e-02f,
  -2.83224553e-01f, -1.81164801e-01f, 6.35620877e-02f, -5.17694354e-02f, -8.67938399e-02f, 9.23499465e-02f, 2.51324363e-02f, -7.94794559e-02f, -9.07428488e-02f, 7.91663080e-02f,
  -1.36584476e-01f, -6.52141720e-02f, -1.78657025e-01f, 1.02566194e-03f, 9.47657675e-02f, 1.03804521e-01f, -3.43025625e-02f, -4.36046161e-03f, -1.48787513e-01f, -1.80751815e-01f,
  -1.72283664e-01f, 2.12645363e-02f, 9.87920072e-03f, -7.70717189e-02f, -1.29180312e-01f, -9.99686122e-02f, -1.38891146e-01f, -1.06386334e-01f, -7.96484575e-03f, 1.58593550e-01f,
  -1.66862458e-02f, 4.86021563e-02f, 5.71722835e-02f, 4.45222035e-02f, 2.37041619e-02f, -5.77600822e-02f, -1.49279311e-02f, -8.79687816e-02f, -7.67493993e-03f, 4.31505963e-02f,
  6.15417324e-02f, -9.33512859e-03f, 4.71155457e-02f, 7.03381281e-03f, -4.13011154e-03f, -3.94448526e-02f, 9.16095078e-02f, 7.07134511e-03f, -9.07467157e-02f, 1.66305274e-01f,
  -5.37947454e-02f, -1.02894558e-02f, 1.17225789e-01f, -1.25314489e-01f, -1.51493689e-02f, -8.70243609e-02f, 1.29905520e-02f, -1.25241369e-01f, 6.80432096e-02f, 5.23726679e-02f,
  6.22530729e-02f, -2.86557674e-01f, -3.07652820e-02f, -6.13454245e-02f, 2.81709566e-04f, -9.60892066e-02f, -1.35076746e-01f, -8.74649063e-02f, 2.19240878e-02f, 1.01835774e-02f,
  -6.18150644e-02f, -7.41510466e-02f, -1.07296735e-01f, 2.01694090e-02f, 1.16968170e-01f, 1.10088795e-01f, -3.70267630e-02f, -7.72153819e-03f, -1.10688442e-02f, 6.36288300e-02f,
  -2.79000401e-02f, 8.72033760e-02f, 1.50793716e-01f, 4.78393137e-02f, 2.67562140e-02f, 1.80290326e-01f, 2.94511449e-02f, 1.50563493e-01f, 3.38668376e-02f, 2.53036410e-01f,
  3.02358419e-01f, 2.38293037e-01f, 3.27707022e-01f, 1.49625093e-01f, 1.49828419e-01f, 2.63432622e-01f, 2.25374907e-01f, 3.54296714e-02f, -1.53899342e-01f, 8.56488571e-02f,
  9.45683867e-02f, -2.06640139e-01f, -1.37036249e-01f, -9.24185365e-02f, -6.36397675e-02f, 2.53531039e-02f, -6.12643287e-02f, 8.12937617e-02f, 7.79091287e-03f, -2.23022490e-03f,
  -8.62690210e-02f, 1.48133889e-01f, 1.99799478e-01f, 1.07776277e-01f, -1.34416390e-02f, -1.86007440e-01f, 7.82703459e-02f, 6.12393580e-02f, 1.70222312e-01f, -1.60991692e-03f,
  -8.26905444e-02f, 3.87003750e-01f, -2.09477887e-01f, -9.32603553e-02f, -1.18360864e-02f, -1.83247626e-01f, 2.17437744e-02f, -4.57772277e-02f, -2.40254160e-02f, -1.61310002e-01f,
  1.01365946e-01f, -3.10115721e-02f, 1.82125300e-01f, 4.88557592e-02f, 1.53177693e-01f, 1.12175971e-01f, 6.05789386e-02f, 4.30171229e-02f, -2.89228968e-02f, 1.06532767e-01f,
  7.14391991e-02f, 1.20089754e-01f, 1.17600873e-01f, -1.23562627e-02f, 9.36262384e-02f, -1.20752320e-01f, 9.85548124e-02f, 8.51079449e-02f, -1.36100557e-02f, 2.78117117e-02f,
  -2.43155777e-01f, -7.48574883e-02f, 1.58513919e-01f, -2.85145584e-02f, -4.48664092e-02f, -1.04698077e-01f, -3.97093333e-02f, 1.21239029e-01f, 7.19786063e-02f, 1.03065737e-01f,
  3.69198546e-02f, 8.08839202e-02f, 3.93323302e-02f, -2.27640700e-02f, 2.50571221e-03f, 1.63157567e-01f, 7.95077831e-02f, 8.47016871e-02f, 8.09212923e-02f, 4.41895202e-02f,
  -2.50314344e-02f, -2.20757388e-02f, -5.63886985e-02f, 4.06124070e-03f, -8.04357082e-02f, 1.35288388e-02f, -9.67615917e-02f, -3.26706842e-02f, 1.46107720e-02f, -2.39734026e-03f,
  -3.37066680e-01f, 1.08982474e-01f, -1.44287854e-01f, -1.62925020e-01f, 7.13772178e-02f, -7.40541741e-02f, 3.00255064e-02f, 4.14583534e-02f, -1.08265318e-01f, -3.53218168e-02f,
  8.66444036e-02f, -3.63094099e-02f, 1.06454082e-02f, -4.42053713e-02f, 1.34307733e-02f, -1.33997336e-01f, -1.27287328e-01f, -7.82397687e-02f, -7.19497427e-02f, -1.33244738e-01f,
  -2.02921266e-03f, -6.01190664e-02f, -1.26744108e-02f, -4.56635281e-02f, -3.68885733e-02f, -2.55551189e-01f, -8.76772869e-03f, -1.48389027e-01f, -1.06244400e-01f, -5.07138893e-02f,
  2.99674511e-01f, 2.08114117e-01f, 3.53735179e-01f, -3.28227095e-02f, -5.80138303e-02f, 1.19746846e-05f, 3.69387046e-02f, -3.16964984e-02f, -3.27290073e-02f, 1.19482085e-01f,
  2.20472246e-01f, 1.63831919e-01f, 1.91570371e-01f, 1.94604963e-01f, 3.34946439e-02f, -9.43121687e-02f, -5.49458601e-02f, 1.31891832e-01f, 2.95225829e-01f, 3.72952372e-02f,
  -8.22222456e-02f, 2.31465027e-02f, 6.30588159e-02f, 1.71660893e-02f, 1.79870445e-02f, 1.50156142e-02f, -8.82456377e-02f, -7.79446736e-02f, -1.04826419e-02f, -2.03697264e-01f,
  4.27247941e-01f, 2.43713900e-01f, 1.90272126e-02f, -1.88870113e-02f, 9.83815119e-02f, 5.78578450e-02f, 1.16096169e-01f, -5.97042358e-03f, -8.38626772e-02f, 1.01588346e-01f,
  -3.71797048e-02f, -3.46409567e-02f, -3.86381634e-02f, -6.98796511e-02f, 9.95396972e-02f, 5.81532046e-02f, 4.73854551e-03f, -3.21964025e-02f, 8.84795263e-02f, -5.19970199e-04f,
  7.03214407e-02f, 1.59846954e-02f, 1.75968736e-01f, 2.11689994e-02f, 4.76080365e-02f, 2.66648345e-02f, 1.88643888e-01f, 1.16979033e-01f, 1.75643370e-01f, 1.62665620e-01f,
  2.07037833e-02f, 1.03211872e-01f, 9.64504629e-02f, -6.77772425e-03f, 5.58277294e-02f, 4.85688001e-02f, 4.38451432e-02f, -1.21154241e-01f, -4.62209880e-02f, -6.55375645e-02f,
  -4.52994145e-02f, 1.56712815e-01f, 1.37784332e-01f, 7.17127174e-02f, 1.51591077e-01f, -4.89293821e-02f, 1.90172568e-02f, 1.45159155e-01f, 1.33597292e-03f, 9.04243737e-02f,
  3.03499643e-02f, -1.07942313e-01f, -7.01527297e-02f, 6.80621043e-02f, -1.87581014e-02f, 5.32812402e-02f, -3.31928208e-02f, -3.53398025e-02f, -3.18591483e-02f, -4.15872447e-02f,
  -2.88730077e-02f, 9.07591544e-03f, -2.88881436e-02f, -2.66362995e-01f, -1.71342239e-01f, -1.68325398e-02f, -4.62655872e-02f, -1.15818612e-01f, -6.80143312e-02f, 1.15594612e-02f,
  2.16983259e-02f, -4.05993126e-03f, -2.57305000e-02f, -1.94745079e-01f, -1.90435406e-02f, -4.40304652e-02f, -6.57125339e-02f, -1.00308008e-01f, -2.02690899e-01f, -1.05205700e-01f,
  -1.97161317e-01f, -3.83708961e-02f, 2.90819667e-02f, -5.61469421e-02f, -1.18954971e-01f, 8.40436742e-02f, -3.96551378e-02f, 2.35658400e-02f, -7.44439736e-02f, -1.57442186e-02f,
  -4.56302613e-01f, 6.43691123e-02f, -1.30181193e-01f, 1.15601882e-01f, 2.44131804e-01f, 4.27393243e-02f, 8.46968219e-02f, -4.15946022e-02f, 9.97777656e-02f, 8.71683471e-03f,
  8.49478394e-02f, -7.75854860e-04f, 1.86804589e-02f, -5.68862334e-02f, -4.56400253e-02f, 1.80471882e-01f, 2.10922271e-01f, -7.46391416e-02f, -7.27397501e-02f, 6.67934716e-02f,
  1.84798315e-01f, -1.60245262e-02f, -1.87097341e-01f, -1.03178330e-01f, 7.55763873e-02f, 1.74516067e-01f, 4.47933823e-02f, -6.00715540e-02f, 1.40951082e-01f, 1.66101426e-01f,
  -4.77350801e-02f, -2.50158846e-01f, 7.40735009e-02f, 7.71113262e-02f, 5.75088598e-02f, -4.52401973e-02f, -6.83321282e-02f, -1.60379827e-01f, -5.19253872e-03f, -6.14470653e-02f,
  6.44186735e-02f, -1.63502425e-01f, 3.00512444e-02f, -6.77604303e-02f, -9.08644274e-02f, -6.16472065e-02f, -1.73016578e-01f, -2.32028574e-01f, -2.66218632e-01f, -3.71296518e-02f,
  2.86819011e-01f, 1.04538202e-01f, -1.79987997e-01f, 1.14775309e-02f, 4.21177670e-02f, -6.50681630e-02f, -1.33618206e-01f, -1.09870024e-01f, -2.85357296e-01f, -3.07835609e-01f,
  -1.81747809e-01f, -2.60157641e-02f, -5.09629864e-03f, -7.58594200e-02f, 3.13860178e-02f, 8.98204371e-02f, 6.96201399e-02f, -2.62496062e-03f, 5.95562384e-02f, -3.63243446e-02f,
  4.04072516e-02f, -8.90186802e-03f, -1.30037656e-02f, -5.06304167e-02f, -4.24780708e-04f, 1.37936855e-02f, 1.05599552e-01f, -7.91140124e-02f, 5.86630497e-03f, 4.00635675e-02f,
  -1.07159056e-02f, -5.08666213e-04f, -7.34348595e-02f, -2.58391909e-02f, -1.64115354e-02f, 2.29857843e-02f, -2.65668593e-02f, -6.14596009e-02f, -5.76894432e-02f, -1.21700935e-01f,
  -1.17689401e-01f, 4.19218168e-02f, 2.44956408e-02f, -5.94381290e-03f, -1.18056998e-01f, 5.12539484e-02f, 1.00810081e-03f, -6.15386590e-02f, 1.34440456e-02f, 1.97526272e-02f,
  -1.28443003e-01f, -6.61347732e-02f, -5.26550859e-02f, -8.20298195e-02f, -7.69552588e-03f, 1.16880387e-01f, 6.45588338e-02f, 1.09738611e-01f, -4.59077442e-03f, 1.14238933e-02f,
  9.01260376e-02f, -1.11895978e-01f, -1.01557121e-01f, -3.21771614e-02f, 6.36768937e-02f, -4.31781486e-02f, -2.08799690e-01f, -9.54460949e-02f, -1.93943843e-01f, -6.70760795e-02f,
  3.96251455e-02f, -2.56460369e-01f, -2.66264141e-01f, 2.41301693e-02f, -1.61055073e-01f, -1.49758905e-01f, -2.75560021e-01f, 6.87848255e-02f, 2.31728908e-02f, -2.72500277e-01f,
  -1.22032374e-01f, 1.53677166e-01f, -1.92811363e-04f, 6.55553788e-02f, 4.68573980e-02f, -4.61739063e-01f, -3.56943607e-01f, 2.54329555e-02f, 2.39941031e-01f, 2.05743119e-01f,
  1.68651007e-02f, 5.86886285e-03f, 1.03509188e-01f, 1.68329403e-01f, -4.33656387e-02f, -7.29435822e-03f, -2.20505282e-01f, -1.14665823e-02f, -1.14472702e-01f, -3.09989333e-01f,
  -4.32813048e-01f, 2.46294830e-02f, 3.71627510e-02f, -4.84240763e-02f, -7.34414086e-02f, -5.14899790e-02f, -2.53722761e-02f, 4.26721163e-02f, 3.41216248e-04f, 1.06746871e-02f,
  1.64949205e-02f, 7.30128139e-02f, 9.26916003e-02f, 2.67769229e-02f, -2.00616028e-02f, 1.08435720e-01f, 7.61543363e-02f, 1.15367323e-01f, 2.84869485e-02f, -1.01812005e-01f,
  -1.94618516e-02f, 1.31248788e-03f, 4.37763743e-02f, 2.67049968e-02f, 1.07204981e-01f, 8.62891376e-02f, -3.30208577e-02f, 7.36916065e-03f, -2.99306922e-02f, -2.02279657e-01f,
  -1.34274140e-01f, -8.03982541e-02f, -2.67522577e-02f, -1.31640043e-02f, 2.48509999e-02f, -1.14218526e-01f, -1.62876665e-03f, 4.38667238e-02f, 6.09262846e-03f, 2.71141604e-02f,
  2.61679813e-02f, -7.58931413e-02f, 1.53776985e-02f, -6.28041029e-02f, -1.90911647e-02f, -1.41539369e-02f, -7.26995766e-02f, -9.29445215e-03f, -5.13987914e-02f, 4.01982255e-02f,
  9.78044793e-02f, 1.89928487e-02f, 2.72281766e-02f, 8.14334601e-02f, -7.25201070e-02f, 3.91030759e-02f, -9.39082429e-02f, -1.45505753e-03f, -1.27518037e-02f, 6.89463988e-02f,
  2.84208134e-02f, -1.03789106e-01f, -1.69332862e-01f, 7.03900233e-02f, 5.62927276e-02f, -7.91780874e-02f, -1.19240865e-01f, 1.01849370e-01f, -4.92698550e-02f, 1.01994224e-01f,
  2.15222705e-02f, -7.95387402e-02f, -6.94320425e-02f, -3.90590280e-02f, -1.63942892e-02f, 2.09870711e-02f, -9.33401361e-02f, -2.12161075e-02f, 6.05181931e-03f, 1.15421571e-01f,
  -7.16054365e-02f, 3.18200439e-02f, 1.80761591e-02f, -6.79048896e-02f, -4.75844108e-02f, -6.41501918e-02f, -1.71039939e-01f, 2.23578494e-02f, -1.18572570e-01f, -2.03478172e-01f,
  6.01918101e-01f, 1.74139366e-01f, -4.49378043e-01f, 2.10439757e-01f, -3.30818683e-01f, -2.65522510e-01f, -1.63996309e-01f, -3.09201404e-02f, 1.34595022e-01f, 1.19847395e-02f,
  -1.32931769e-01f, 8.61233380e-03f, -5.58588617e-02f, -1.09303698e-01f, -6.70538321e-02f, -1.49202287e-01f, -3.02378032e-02f, -1.34177506e-01f, -3.01418871e-01f, -7.71217644e-02f,
  1.60278067e-01f, 2.43992701e-01f, 2.41613299e-01f, -6.70170188e-02f, -7.28673264e-02f, -1.04576789e-01f, -5.08433022e-02f, -1.47475973e-02f, -1.57400891e-01f, 8.89789388e-02f,
  -2.87813485e-01f, 3.79623473e-02f, -1.57720089e-01f, 3.62551846e-02f, 7.32144117e-02f, 6.09186031e-02f, 3.33488993e-02f, -3.16524878e-02f, -1.37122208e-02f, 6.57185540e-02f,
  -1.28564551e-01f, 1.25174327e-02f, -6.58526346e-02f, -3.94814387e-02f, -7.42881298e-02f, -9.11239013e-02f, 4.29357886e-02f, -9.62893888e-02f, 4.05720733e-02f, -1.49648758e-02f,
  1.01047270e-01f, 6.09739125e-03f, -1.41234025e-01f, -9.15691257e-02f, -1.58631265e-01f, -2.09854338e-02f, -1.36116236e-01f, -9.96032953e-02f, -2.09913254e-01f, 5.42658381e-02f,
  5.03418669e-02f, -2.01838203e-02f, 6.51694462e-02f, 1.09776117e-01f, 9.88716632e-02f, 5.00195809e-02f, 1.11720227e-01f, 5.40413149e-02f, 5.99304549e-02f, 5.15237376e-02f,
  -8.63761678e-02f, -7.60634756e-03f, -7.11725093e-03f, 4.55022156e-02f, -4.43101712e-02f, -1.21097565e-02f, 1.69619247e-02f, 9.97957662e-02f, 3.06891482e-02f, 1.30441040e-01f,
  2.45790798e-02f, -4.58028801e-02f, 1.38592217e-02f, -3.53456214e-02f, -2.04208475e-02f, -2.46252702e-03f, -2.30343677e-02f, 9.29404143e-03f, 2.67744586e-02f, -7.37618953e-02f,
  1.45163285e-02f, -8.23512152e-02f, 8.44904408e-02f, -2.92638484e-02f, 3.54735069e-02f, 5.16330451e-02f, 1.25083551e-01f, 1.39944002e-01f, 7.35744536e-02f, 4.32569571e-02f,
  -2.96658510e-03f, -7.52821565e-02f, -6.76504895e-02f, 2.85466462e-02f, 1.62353367e-02f, -2.32058614e-02f, 1.30128011e-01f, -3.45273712e-03f, 8.51211429e-04f, -2.04961002e-02f,
  1.01382934e-01f, 6.75296411e-02f, 1.09436966e-01f, 7.90453795e-03f, 6.55461848e-02f, 1.96372047e-02f, 4.24864702e-02f, -1.35371275e-03f, -1.15614653e-01f, 2.55582422e-01f,
  -8.17278922e-02f, 6.01359503e-03f, 1.13822641e-02f, 1.45559549e-01f, 1.40506729e-01f, -8.78486666e-04f, -5.84271513e-02f, -3.44248153e-02f, -1.26967877e-02f, -4.56171446e-02f,
  -4.83749546e-02f, 3.46764252e-02f, -8.49896222e-02f, 4.05700086e-03f, 3.05121168e-02f, 6.15455471e-02f, 9.01700705e-02f, 9.06118080e-02f, 2.41180919e-02f, -1.87335946e-02f,
  -5.39994650e-02f, -6.79257959e-02f, 6.69794343e-03f, 6.29500672e-02f, -1.90860610e-02f, -6.03797473e-02f, 5.54965213e-02f, 2.20033545e-02f, 8.51449445e-02f, 2.23977789e-02f,
  -1.68605298e-01f, 1.24222273e-02f, -4.65379283e-02f, -1.46360160e-03f, 6.83340132e-02f, -1.69975072e-01f, -1.00995973e-02f, 1.54539570e-02f, -7.65450448e-02f, -3.38219963e-02f,
  4.54020649e-02f, -8.04919079e-02f, 7.28434250e-02f, -1.38763050e-02f, -6.89690486e-02f, -2.06953697e-02f, -1.38638448e-02f, -4.25423607e-02f, -4.51830402e-02f, -1.24855608e-01f,
  1.10782184e-01f, 6.76455721e-02f, -6.27730787e-02f, 8.33345577e-02f, 4.05731499e-02f, 5.08463942e-02f, 1.10363094e-02f, -9.57332179e-02f, 3.40364650e-02f, -6.11728430e-02f,
  1.47062823e-01f, 1.77633807e-01f, 1.99392870e-01f, 5.73525205e-02f, -1.12898992e-02f, 7.53765106e-02f, -1.79761127e-02f, 7.47308657e-02f, 1.23802736e-01f, 3.80226523e-02f,
  1.50188245e-02f, 8.60017985e-02f, -2.67030275e-03f, 6.76661283e-02f, 3.13681066e-02f, -4.60035019e-02f, -2.60384083e-02f, -3.99415083e-02f, -8.28717090e-03f, -5.78807071e-02f,
  2.84528378e-02f, 3.64750647e-03f, 2.24524792e-02f, 1.79453958e-02f, 5.21621816e-02f, 1.45529255e-01f, 6.30841628e-02f, -4.03631143e-02f, 9.01551452e-03f, -2.20015775e-02f,
  -2.39875272e-01f, 6.26306981e-02f, -5.50249480e-02f, -6.31744862e-02f, 1.91934854e-02f, -2.58751884e-02f, 5.07398769e-02f, -8.55601132e-02f, -1.63040355e-01f, -1.96924508e-01f,
  -3.44467983e-02f, -9.13355574e-02f, 8.93989205e-02f, -2.02381164e-02f, -7.91071728e-02f, -1.17616214e-01f, 7.07102492e-02f, 5.42432852e-02f, -1.23163216e-01f, -7.85807818e-02f,
  -7.61842355e-02f, -6.08191527e-02f, -4.87973504e-02f, -2.17845850e-02f, -8.45233425e-02f, -5.30744046e-02f, -5.48454858e-02f, -4.66323877e-03f, 4.27044742e-02f, -7.73045495e-02f,
  3.54383409e-01f, 8.68779868e-02f, 3.15269828e-01f, -1.46331474e-01f, -3.80473524e-01f, -1.42554998e-01f, -1.02483846e-01f, 3.15391980e-02f, -1.24266729e-01f, -1.90902084e-01f,
  -1.75980106e-01f, -2.44088307e-01f, -8.82821307e-02f, -4.46314663e-02f, 2.17940271e-01f, 1.02886774e-01f, 2.16675714e-01f, 4.02116537e-01f, 3.02830487e-01f, -1.04418963e-01f,
  -1.36234984e-01f, 6.86275512e-02f, 2.83484459e-01f, 2.57427096e-01f, -6.35634437e-02f, -9.79018062e-02f, 6.56810552e-02f, 1.05775625e-01f, -1.01369582e-01f, 1.76350802e-01f,
  1.22526795e-01f, 1.53643385e-01f, -1.41460955e-01f, 3.18413042e-02f, 8.42164457e-02f, 1.43442869e-01f, 4.08412702e-03f, 1.58311486e-01f, 1.99413449e-02f, -4.70887087e-02f,
  1.96657665e-02f, 7.45303258e-02f, 9.37355608e-02f, 1.32957712e-01f, 2.36429069e-02f, 1.26620650e-01f, 2.10632831e-01f, 2.32598484e-01f, 1.28594056e-01f, 5.82770072e-02f,
  -1.10293686e-01f, -1.63114846e-01f, 1.66495983e-03f, 4.55846153e-02f, 1.85885385e-01f, -8.13199356e-02f, 1.82529390e-02f, 7.21487626e-02f, 1.13187991e-01f, 6.89427257e-02f,
  -1.00351818e-01f, -3.85965370e-02f, -2.84259915e-02f, -8.91423449e-02f, 4.65272814e-02f, -5.20593934e-02f, -2.47290283e-02f, -1.26322940e-01f, 5.28331101e-02f, 1.23307183e-01f,
  -1.21410795e-01f, -5.81480376e-02f, 1.03006344e-02f, -1.01526072e-02f, 2.04909723e-02f, 1.38343394e-01f, 6.66262135e-02f, -1.15141146e-01f, -2.98184641e-02f, 6.26202952e-03f,
  3.64621803e-02f, -5.54456934e-02f, -5.81936352e-02f, 1.39513731e-01f, -6.12963326e-02f, 7.86555000e-03f, -8.27357024e-02f, -3.41529995e-02f, -1.07876258e-02f, -6.43630847e-02f,
  -8.91259685e-02f, -2.84206159e-02f, -1.33397430e-01f, 5.39313555e-02f, 2.06303932e-02f, 9.15859714e-02f, -1.61560982e-01f, -1.14908502e-01f, -5.89026436e-02f, -5.97183779e-02f,
  -4.55790572e-02f, -4.94723432e-02f, -5.54992221e-02f, 6.98811188e-02f, 6.96560135e-03f, -6.23188205e-02f, -5.90780899e-02f, -7.72133395e-02f, -2.16854289e-02f, -7.18550105e-03f,
  -2.20952909e-02f, -7.73128122e-02f, -1.81964129e-01f, -1.97672114e-01f, -9.72904265e-02f, -2.93890893e-01f, -1.10981695e-01f, -8.67405087e-02f, -1.45583376e-01f, -5.96247651e-02f,
  -3.71304862e-02f, 1.51489958e-01f, 1.92580938e-01f, 1.36560639e-02f, -2.68149018e-01f, -3.06689322e-01f, -2.88965881e-01f, -1.09825924e-01f, -3.97784170e-03f, -3.56336236e-02f,
  -6.10488467e-02f, -9.83615443e-02f, -1.16501354e-01f, 4.16577682e-02f, -3.42919603e-02f, 4.64614443e-02f, 9.57628191e-02f, 7.86126778e-02f, 2.29707975e-02f, -7.38922954e-02f,
  -2.55887620e-02f, 8.96015763e-02f, 1.54007360e-01f, 9.56163108e-02f, 1.45086020e-01f, -2.92291269e-02f, -1.04525760e-01f, 8.27519782e-03f, -1.51190516e-02f, 2.51120657e-01f,
  5.19832313e-01f, 1.38989419e-01f, 8.03982653e-03f, 7.04701617e-02f, 5.51543012e-02f, 8.95783082e-02f, 5.86821698e-02f, 1.24346346e-01f, 4.44600619e-02f, 1.00189961e-01f,
  9.75085199e-02f, 4.09242287e-02f, -5.40037043e-02f, -1.41727859e-02f, 3.15719098e-02f, 4.37103286e-02f, 7.34315962e-02f, 4.14028354e-02f, 1.66260940e-03f, 3.16488519e-02f,
  1.15344152e-01f, 3.38780358e-02f, 5.66811413e-02f, -3.62516940e-02f, -1.16218083e-01f, 2.20319964e-02f, 3.91922332e-02f, 5.39908446e-02f, 3.69829088e-02f, 7.39326514e-03f,
  2.52602454e-02f, 4.51527312e-02f, 4.25786264e-02f, -5.56728244e-02f, -1.54492900e-01f, -5.06934598e-02f, -6.82549104e-02f, -2.05926616e-02f, -1.85241997e-01f, -9.91996601e-02f,
  -3.54522392e-02f, -5.89560084e-02f, 3.78539674e-02f, 1.72866303e-02f, 9.34046507e-02f, 1.33884147e-01f, -7.39356829e-03f, 2.08910018e-01f, 1.43166646e-01f, 1.12251453e-01f,
  -6.28027618e-02f, 5.83249740e-02f, 8.98664817e-03f, 1.48895755e-01f, 1.58702254e-01f, 1.07960977e-01f, 5.99267483e-02f, -6.30245581e-02f, -1.23800568e-01f, 8.31999555e-02f,
  1.85489148e-01f, -5.57905845e-02f, 9.97598916e-02f, 1.20445460e-01f, 1.07057363e-01f, 1.36741608e-01f, 1.13326296e-01f, 1.67606637e-01f, 8.68933462e-03f, 2.27037296e-01f,
  1.14303410e-01f, 6.76084533e-02f, 4.12916280e-02f, 5.58940694e-02f, -3.09180226e-02f, 1.10080637e-01f, 6.88947216e-02f, 3.55777182e-02f, 1.80304244e-01f, 1.64909616e-01f,
  1.94237698e-02f, -1.46931261e-02f, 1.11273929e-01f, -1.21147431e-01f, -1.03765167e-01f, -1.35970116e-01f, -4.17367034e-02f, -3.90036963e-02f, -3.97526845e-02f, -1.22191086e-01f,
  -4.70695198e-01f, 3.94600034e-01f, 1.37953609e-01f, -1.18356869e-01f, 1.86107635e-01f, 2.58841425e-01f, 4.50679153e-01f, 6.96095005e-02f, -1.60669312e-01f, 1.07916288e-01f,
  2.08065324e-02f, -1.67236224e-01f, -2.04266369e-01f, -1.26049161e-01f, 1.82609279e-02f, 1.83321208e-01f, 2.51457363e-01f, -1.40273347e-01f, -2.72761047e-01f, -6.22692071e-02f,
  -3.84446494e-02f, -6.96398243e-02f, -3.09887409e-01f, -6.23295754e-02f, -6.45103604e-02f, -8.64392221e-02f, 1.25361130e-01f, -3.76971699e-02f, 9.64455307e-02f, 6.53161556e-02f,
  -1.81307778e-01f, 1.72998995e-01f, -4.27504107e-02f, -2.19481632e-01f, -3.96372145e-03f, -8.43123496e-02f, -3.75428062e-04f, -7.82775208e-02f, 3.98292802e-02f, 5.15093503e-04f,
  9.67590436e-02f, -3.59089719e-03f, -1.65994372e-02f, -2.69498043e-02f, 2.45888792e-02f, -5.96546195e-02f, -1.23154961e-01f, -1.07174322e-01f, -9.11208391e-02f, -4.91437595e-03f,
  1.46963358e-01f, 6.07214794e-02f, 1.05471134e-01f, 3.76735814e-02f, 6.94823936e-02f, -1.95113331e-01f, -1.44622615e-02f, -3.71498801e-02f, -1.01301067e-01f, -1.84418231e-01f,
  -5.00266105e-02f, 3.12020816e-03f, 9.40715447e-02f, -1.37807745e-02f, -6.31634071e-02f, 6.03671446e-02f, 1.03109919e-01f, 2.31872350e-02f, 3.97177041e-02f, -5.69305867e-02f,
  5.42157888e-02f, 1.24016823e-02f, -7.77384499e-03f, 3.53391692e-02f, -1.07272416e-02f, 6.43436685e-02f, 6.83626905e-02f, 5.40305413e-02f, -5.40911639e-03f, -3.73565927e-02f,
  -1.10914268e-01f, -3.76529507e-02f, -1.55923152e-02f, -6.97741657e-02f, 7.74397030e-02f, -3.31250243e-02f, 7.17805102e-02f, -8.70400742e-02f, 6.18232079e-02f, 4.44166809e-02f,
  -3.52695704e-01f, 3.11566126e-02f, -2.41964146e-01f, 1.57439020e-02f, -4.45272624e-02f, -9.71109234e-03f, 3.10703255e-02f, 9.42921191e-02f, 2.37714127e-02f, -7.41076991e-02f,
  3.95017453e-02f, 7.78819695e-02f, -1.26970802e-02f, -2.25896444e-02f, -4.17175330e-02f, 4.91411313e-02f, 6.33756220e-02f, 7.97764286e-02f, -8.78586434e-03f, -1.29284531e-01f,
  -1.12131163e-02f, -1.63295224e-01f, -2.79397011e-01f, -6.27601594e-02f, -7.46366158e-02f, -3.63342315e-01f, -2.86818057e-01f, -1.54979423e-01f, -2.11115226e-01f, -2.23009229e-01f,
  -2.59575903e-01f, -1.73017338e-01f, 1.24897167e-01f, 1.96874872e-01f, 2.11221308e-01f, 2.53743380e-01f, 2.87207812e-01f, 9.79058668e-02f, 9.93967280e-02f, -4.03729342e-02f,
  -1.44053861e-01f, -1.11249380e-01f, -2.56415725e-01f, -1.95141837e-01f, -6.47840276e-02f, 1.73707679e-01f, 1.99910849e-01f, 5.57741001e-02f, 1.65898696e-01f, 5.06115556e-02f,
  4.61507402e-02f, 4.04231250e-02f, -1.38989449e-01f, 4.20889482e-02f, 4.46397439e-02f, 7.78709128e-02f, 1.01839043e-01f, 1.51741892e-01f, 4.86469902e-02f, -6.79181190e-03f,
  -2.06814528e-01f, -9.77287814e-02f, -5.25467284e-02f, -2.30057180e-01f, -1.84238106e-01f, -1.78885624e-01f, -4.97959740e-02f, -9.31956321e-02f, -6.98866323e-02f, 7.75498943e-03f,
  -4.00677382e-05f, -1.61810532e-01f, -3.26341242e-02f, 4.88863513e-02f, 7.03047961e-02f, 6.99794758e-03f, -1.13383755e-01f, -2.86306087e-02f, -1.23082146e-01f, -1.71170577e-01f,
  -1.24753289e-01f, 7.75298402e-02f, 8.85251239e-02f, 9.59788561e-02f, -4.74662781e-02f, -4.80088256e-02f, -7.60696679e-02f, 5.94516937e-03f, 3.12784011e-03f, -1.08895134e-02f,
  -7.09820390e-02f, 1.92578901e-02f, -8.58766064e-02f, -5.14726806e-03f, 5.90846464e-02f, 1.16504565e-01f, 1.96069762e-01f, 1.31049111e-01f, 1.46716267e-01f, 1.74628600e-01f,
  9.25622955e-02f, 6.27532974e-02f, 7.32920468e-02f, 1.37921795e-01f, 2.63027637e-03f, 9.39435810e-02f, 1.43383946e-02f, -1.79693978e-02f, -4.13454545e-04f, 5.27240522e-02f,
  4.73225042e-02f, 1.08926788e-01f, 5.83932064e-02f, 4.54852991e-02f, -1.04967698e-01f, 5.13260029e-02f, 1.75557490e-02f, 7.01195968e-04f, 1.05554663e-01f, 4.47605290e-02f,
  1.46824554e-01f, 8.94208550e-02f, 4.09441702e-02f, -4.43629511e-02f, -2.14835373e-03f, -2.13310421e-02f, 6.40873611e-02f, -7.17377141e-02f, 9.09811351e-03f, 8.12516958e-02f,
  4.57669571e-02f, 4.19957452e-02f, -1.80323888e-02f, 1.25488281e-01f, 1.30374968e-01f, 6.45861635e-03f, -1.92129686e-01f, -7.48768914e-03f, -9.43638291e-03f, -1.87645964e-02f,
  9.61519871e-03f, 8.58818367e-02f, 6.38803840e-02f, 1.85311139e-01f, 1.34820029e-01f, 1.61673650e-01f, 2.13514492e-02f, 6.01242371e-02f, 8.11012238e-02f, 1.67171091e-01f,
  3.73754054e-01f, 1.93957537e-01f, -5.73651135e-01f, 1.63566977e-01f, -2.27663800e-01f, -1.52325109e-01f, -1.18672393e-01f, 2.15495482e-01f, 2.40652442e-01f, 1.50609031e-01f,
  5.16832098e-02f, 3.25578521e-03f, 4.90414724e-02f, -1.31815702e-01f, -9.25652236e-02f, -2.47659966e-01f, -1.65376872e-01f, -4.03486133e-01f, -4.09574866e-01f, -1.25277609e-01f,
  -5.93063124e-02f, -6.45246357e-02f, -9.17708129e-02f, -5.96088842e-02f, 8.41365755e-03f, -9.65668932e-02f, -3.14798504e-02f, -1.02160394e-01f, -2.72519052e-01f, -1.38647884e-01f,
  -5.24352849e-01f, -1.06070831e-01f, -5.62712066e-02f, 1.61459118e-01f, 2.25673299e-02f, 7.71542117e-02f, -6.87409192e-02f, -5.20155020e-03f, 2.13590980e-01f, 3.62937562e-02f,
  -5.77558484e-03f, -9.27958265e-02f, -5.27354069e-02f, -8.86147171e-02f, 1.86423026e-02f, -9.19534042e-02f, 1.03418611e-01f, 6.74686879e-02f, -2.84447744e-02f, 7.73491636e-02f,
  9.18096900e-02f, -6.42720088e-02f, -5.21535166e-02f, 1.53561339e-01f, -4.13630381e-02f, -6.96103051e-02f, 7.31031075e-02f, 4.52073514e-02f, -4.70687449e-03f, 2.71731913e-01f,
  4.65384778e-03f, 4.59337384e-02f, -3.96798402e-02f, 9.69541743e-02f, 1.18498310e-01f, -1.18692582e-02f, -3.58847827e-02f, 6.60596937e-02f, 1.01132296e-01f, 1.23741284e-01f,
  8.51834342e-02f, -7.73240179e-02f, 7.15017468e-02f, 5.15175201e-02f, -1.75135359e-01f, -5.60126863e-02f, 1.08496472e-02f, 4.09189500e-02f, -2.95770112e-02f, 7.26100709e-03f,
  4.64960635e-02f, -6.28897175e-03f, 3.02572865e-02f, 1.23721119e-02f, -1.01614341e-01f, -3.10326498e-02f, -3.71116884e-02f, 3.43263634e-02f, -1.22057309e-03f, -4.06645015e-02f,
  9.72913504e-02f, -3.14017057e-01f, 1.10142697e-02f, 6.64216354e-02f, -5.70370331e-02f, 1.32551640e-01f, -1.52406514e-01f, -8.98621138e-03f, -6.02985583e-02f, 9.01045091e-03f,
  -1.33936331e-01f, -3.45856254e-03f, -1.40490010e-01f, 4.01676744e-02f, 6.23051599e-02f, -8.61265734e-02f, 2.17642099e-01f, 7.59168388e-03f, 3.35687846e-02f, 7.71216601e-02f,
  1.60709873e-01f, 1.40443012e-01f, 1.71959326e-01f, 1.01365760e-01f, 1.59303814e-01f, 4.87023704e-02f, -7.72493705e-02f, 6.05729967e-02f, -5.91300577e-02f, 2.69412696e-01f,
  5.16589701e-01f, 9.64400396e-02f, 1.17343396e-01f, 1.29839435e-01f, 3.17821726e-02f, -4.44008373e-02f, -8.63097534e-02f, -2.58724727e-02f, 7.07802698e-02f, 1.65149868e-01f,
  8.21568817e-02f, 2.33660787e-01f, 7.07669631e-02f, 1.28960148e-01f, 7.11397007e-02f, 6.14327900e-02f, 9.71400067e-02f, 2.12229833e-01f, 4.47266810e-02f, 1.94678381e-01f,
  1.26305208e-01f, 3.47811058e-02f, 5.83477244e-02f, 1.63284898e-01f, 2.27059141e-01f, 1.70724228e-01f, 1.22253291e-01f, 9.80212912e-02f, 1.01335019e-01f, 1.71428770e-01f,
  -7.08412495e-04f, 2.83477962e-01f, -5.37871523e-03f, 7.36809522e-02f, -1.06049022e-02f, -7.69567396e-03f, -3.39212529e-02f, -6.27853647e-02f, -4.71833237e-02f, -1.28507420e-01f,
  1.33080734e-02f, -5.72802797e-02f, 9.32267830e-02f, -6.95034191e-02f, -7.38856494e-02f, -1.14940302e-02f, 4.52696458e-02f, -3.67717780e-02f, 3.68148088e-02f, -6.71659708e-02f,
  1.39777539e-02f, 1.23601453e-02f, -2.70894505e-02f, -1.13590851e-01f, -1.15389610e-02f, -4.99463454e-02f, 3.21487314e-03f, -2.96566188e-02f, -5.96086122e-02f, 1.36876017e-01f,
  2.34712914e-01f, -1.41397789e-02f, 9.48780030e-02f, 1.80878207e-01f, 1.60356179e-01f, 9.16444808e-02f, -2.59435028e-02f, 6.85702339e-02f, 4.84175459e-02f, -5.58441924e-03f,
  -6.72755763e-02f, -5.15412204e-02f, -8.80570859e-02f, 8.17384571e-02f, 6.90892935e-02f, -5.27228788e-02f, -8.64944533e-02f, -1.47724912e-01f, -7.20843747e-02f, -1.17580920e-01f,
  4.05302048e-02f, -1.08282439e-01f, 3.05239018e-02f, -9.46013548e-04f, -2.83287112e-02f, 1.18203185e-01f, 6.98471963e-02f, -2.22121980e-02f, -2.80963965e-02f, 4.15568165e-02f,
  -6.33426249e-01f, 3.97264361e-02f, 2.81344593e-01f, 6.80528209e-02f, 6.26716912e-02f, -7.18164891e-02f, 4.64562215e-02f, -4.64932211e-02f, -3.81350182e-02f, -1.13999888e-01f,
  -9.84515920e-02f, 5.06745353e-02f, -1.48358187e-02f, 1.92626584e-02f, -1.41244754e-02f, -1.74065873e-01f, 1.31755158e-01f, -8.21683779e-02f, -5.33156954e-02f, -1.25044957e-01f,
  -8.16569403e-02f, -1.97509661e-01f, -2.00123668e-01f, -1.66442111e-01f, 9.67940141e-04f, 2.43401006e-02f, -6.58574402e-02f, -1.14958510e-01f, -1.56246185e-01f, -8.58334750e-02f,
  3.17903280e-01f, -1.59204081e-01f, -2.51246899e-01f, 3.17728907e-01f, -8.82904604e-02f, -3.33879173e-01f, -4.45373297e-01f, -2.82006800e-01f, 2.59593837e-02f, 8.73121694e-02f,
  -1.29611110e-02f, 2.04373375e-01f, 1.00312300e-01f, -1.04424126e-01f, -1.96706787e-01f, -8.45764652e-02f, -1.38216153e-01f, -3.35086249e-02f, -2.24058613e-01f, -1.04859367e-01f,
  1.97860479e-01f, 1.71407551e-01f, 1.26632914e-01f, 3.62849236e-02f, 1.97980911e-01f, -2.49176961e-03f, 1.91705190e-02f, 1.74491331e-01f, -4.09950688e-02f, 1.72513902e-01f,
  5.52718935e-04f, -9.79427919e-02f, -2.24205121e-01f, 1.80991307e-01f, -9.39520895e-02f, -4.25925478e-02f, -1.89034864e-01f, -2.08081808e-02f, -4.39602509e-02f, -9.68715933e-04f,
  -1.01928029e-03f, 6.21830076e-02f, 2.20579170e-02f, 1.28060609e-01f, 7.77491853e-02f, -1.10601392e-02f, -3.92813236e-02f, -1.29690021e-01f, -2.02376872e-01f, -2.50265568e-01f,
  -8.13374370e-02f, -3.10812090e-02f, -1.06075116e-01f, -1.04983672e-01f, -2.19676897e-01f, 1.00328280e-02f, -1.53484985e-01f, -1.64962783e-01f, -1.11206830e-01f, 5.65717109e-02f,
  -1.17363214e-01f, -5.85989729e-02f, -2.17179693e-02f, 2.56435014e-02f, 3.96465650e-03f, 3.69399041e-02f, -8.95348564e-03f, -3.34678255e-02f, 3.89620699e-02f, -4.78839092e-02f,
  -6.97393194e-02f, 1.17289931e-01f, -1.36779444e-02f, 1.97346844e-02f, 1.06593125e-01f, -6.89604282e-02f, -4.52477448e-02f, -8.49824399e-02f, -4.25932854e-02f, -1.23348460e-02f,
  -1.23745441e-01f, -1.26102865e-01f, 1.89419184e-02f, -9.38976556e-02f, 5.00905737e-02f, -1.34866033e-02f, 2.26359386e-02f, -1.39295636e-02f, -2.24626921e-02f, 3.40519287e-02f,
  1.45375282e-01f, 1.76843908e-02f, 8.02830979e-03f, -1.28805771e-01f, -8.52705464e-02f, -8.19275379e-02f, -4.03743312e-02f, -1.30634695e-01f, 1.03201650e-01f, -3.52706797e-02f,
  -1.98819824e-02f, 4.17433791e-02f, 1.21798292e-01f, -4.05062810e-02f, 1.16964541e-01f, 6.28675222e-02f, 1.31326601e-01f, -4.32737432e-02f, 2.34160591e-02f, 2.54497640e-02f,
  5.55790849e-02f, -3.15572061e-02f, 1.28637766e-02f, -4.07913551e-02f, -1.42340064e-02f, 3.95707935e-02f, 4.86223251e-02f, -1.34645358e-01f, -2.03648716e-01f, 2.22606342e-02f,
  -4.08410490e-01f, -7.40186591e-03f, 6.90728193e-03f, 1.85462117e-01f, 1.70130894e-01f, 1.28194511e-01f, 7.86414966e-02f, -1.85268577e-02f, 1.91552922e-01f, 2.14359686e-02f,
  8.67340937e-02f, 9.03566182e-02f, 6.71418309e-02f, 4.47217785e-02f, 1.77487686e-01f, 3.05169731e-01f, 3.72189403e-01f, 3.03487889e-02f, 1.05338760e-01f, 1.79370299e-01f,
  2.22225159e-01f, 5.05517535e-02f, -1.41637221e-01f, 3.74135934e-02f, 1.65568620e-01f, 1.77822173e-01f, 1.10976867e-01f, 1.10553980e-01f, 1.74923912e-01f, 3.61428797e-01f,
  6.33082092e-02f, -1.20670237e-01f, 9.15335715e-02f, -1.06840909e-01f, -1.18366564e-02f, -2.65039593e-01f, -1.32803187e-01f, -2.51396671e-02f, -1.65668279e-01f, -8.70475471e-02f,
  3.89814153e-02f, 9.20416787e-03f, 3.84766869e-02f, 4.47518528e-02f, -1.32565066e-01f, -9.90410000e-02f, -3.71218920e-02f, 1.79516464e-01f, 1.02673583e-01f, -4.14760550e-03f,
  6.97743241e-03f, 3.83681105e-03f, 3.69363800e-02f, 1.56702399e-01f, 6.94367811e-02f, 1.45992208e-02f, 3.51634622e-02f, 9.54520330e-02f, -4.94482443e-02f, 1.46521460e-02f,
  2.64757186e-01f, 5.96811287e-02f, 8.17740858e-02f, 2.00528175e-01f, 9.09299552e-02f, 2.40875389e-02f, 1.12751298e-01f, 1.06843069e-01f, 1.35803998e-01f, -9.73294154e-02f,
  -1.93316620e-02f, 1.03466325e-01f, 1.01775683e-01f, 7.26666003e-02f, 2.84522846e-02f, 3.19808871e-02f, 5.44851571e-02f, -1.76939263e-03f, -7.84981847e-02f, -9.41063929e-03f,
  -3.48387025e-02f, -4.50214185e-03f, -1.70766771e-01f, 9.42173079e-02f, 3.80254537e-02f, -2.90923249e-02f, 9.02515948e-02f, -1.16875634e-01f, -1.03798389e-01f, -1.07186951e-01f,
  2.08247259e-01f, 1.06082827e-01f, 1.82960168e-01f, 1.79525048e-01f, -1.17801324e-01f, -1.16292708e-01f, 2.39192192e-02f, -1.15788907e-01f, -7.06126243e-02f, -2.77456623e-02f,
  -1.90221399e-01f, -9.37032253e-02f, -1.06654121e-02f, -5.96568920e-02f, -1.36507407e-01f, -7.50834271e-02f, 1.96587276e-02f, 1.41187921e-01f, 1.18181586e-01f, 3.48188020e-02f,
  2.32240725e-02f, 7.82728270e-02f, -4.02493179e-02f, 1.18298009e-02f, 1.16394684e-01f, 6.78340495e-02f, -1.15440212e-01f, -1.09203532e-01f, -1.74194440e-01f, -1.17394492e-01f,
  -3.20322663e-01f, 1.14416882e-01f, -4.75937337e-01f, -3.09004754e-01f, -4.09534395e-01f, -2.85374284e-01f, -5.62000796e-02f, -4.99257222e-02f, -1.81273684e-01f, -3.18605639e-02f,
  3.04889996e-02f, 2.10342538e-02f, 4.71150037e-03f, -3.63341346e-02f, 3.50156873e-02f, -5.99929951e-02f, -3.65468621e-01f, -3.17438841e-01f, -1.66314557e-01f, -3.35262530e-02f,
  6.13902090e-03f, -1.31114513e-01f, -2.21267775e-01f, -6.70625195e-02f, 1.77142560e-01f, 1.68692917e-01f, -7.89322704e-02f, -5.55378534e-02f, -3.08446735e-02f, -5.90971559e-02f,
  1.84425801e-01f, -1.45452723e-01f, -1.11081928e-01f, -1.22711249e-01f, -4.05258462e-02f, -1.42951518e-01f, -1.13033228e-01f, -3.91271301e-02f, -2.27611829e-02f, -1.55878067e-01f,
  -2.37245902e-01f, -9.80545022e-03f, -9.48805064e-02f, -1.38335720e-01f, -1.12124369e-01f, 8.99143890e-03f, -2.40077078e-02f, -9.27159488e-02f, -4.82282601e-02f, 5.76142408e-02f,
  -9.27068070e-02f, -2.00316608e-01f, -1.70187037e-02f, 9.18725729e-02f, 7.77937472e-02f, -1.08981907e-01f, 5.82690910e-02f, 1.80777418e-03f, -2.94464566e-02f, 1.95450917e-01f,
  2.90445164e-02f, 7.21952096e-02f, 3.38216312e-02f, -9.67907310e-02f, 9.82245132e-02f, -1.79758668e-02f, -3.13761272e-02f, 1.22100681e-01f, 5.06156906e-02f, 8.82708579e-02f,
  1.84084456e-02f, 1.95675902e-02f, 7.04005407e-03f, 7.81123415e-02f, -7.88512826e-02f, -2.92014834e-02f, -2.01134030e-02f, 1.12202652e-01f, 7.93773681e-02f, -1.75911888e-01f,
  -2.11266994e-01f, -8.10223147e-02f, -8.16252548e-03f, 4.89081666e-02f, -1.22828178e-01f, -3.05192396e-02f, -9.38821509e-02f, 1.27516478e-01f, -9.53888893e-03f, -1.63219288e-01f,
  3.10956419e-01f, -2.56831795e-01f, 5.70104271e-02f, 7.97124356e-02f, -1.39197692e-01f, -1.44392744e-01f, -4.22434509e-02f, -7.19930381e-02f, -4.20192517e-02f, -7.52432644e-02f,
  -1.42860830e-01f, -1.67795680e-02f, -2.53261141e-02f, 1.02802075e-01f, -4.98579396e-03f, -1.24041833e-01f, 1.38558997e-02f, 8.64196792e-02f, 8.77845213e-02f, 1.29105926e-01f,
  4.34582634e-03f, -4.65510935e-02f, 1.05594061e-01f, 1.36545107e-01f, 1.31938711e-01f, 4.55115959e-02f, 2.25507572e-01f, 7.69061372e-02f, 1.07066080e-01f, 2.78983235e-01f,
  -3.42466027e-01f, -2.19138395e-02f, -1.09808698e-01f, 2.16234669e-01f, 2.89885491e-01f, 1.11732066e-01f, 2.06476524e-01f, 2.00068459e-01f, 2.37924054e-01f, 1.10119134e-01f,
  1.55519545e-01f, 2.69386411e-01f, 1.95419967e-01f, 2.20009670e-01f, 6.96008727e-02f, 2.17444912e-01f, 2.72448093e-01f, 5.81782535e-02f, -8.42510816e-03f, 1.46974638e-01f,
  1.64298892e-01f, 1.16491906e-01f, -5.45292422e-02f, 4.03557606e-02f, 6.81462288e-02f, 1.82792917e-01f, 1.65130287e-01f, 4.84370403e-02f, 7.85069317e-02f, 7.58916289e-02f,
  -7.66157033e-03f, -1.19320676e-01f, 7.23742694e-02f, -5.97208552e-02f, -7.94565827e-02f, -7.17971846e-02f, -1.39359338e-02f, -6.95578456e-02f, -2.45945305e-02f, 2.62355786e-02f,
  -1.42210737e-01f, -5.42268306e-02f, -2.93159261e-02f, -5.15317246e-02f, -7.12887496e-02f, -2.79905535e-02f, 9.09843668e-02f, 1.37442946e-01f, 6.11489899e-02f, 1.12992972e-02f,
  1.78749189e-02f, 6.77263550e-03f, 1.36397049e-01f, 3.38184796e-02f, 5.83939329e-02f, 1.32888138e-01f, -4.03894149e-02f, 8.09522122e-02f, 3.87469046e-02f, 8.03291202e-02f,
  3.08876306e-01f, 7.02101067e-02f, -4.58442196e-02f, 2.20999811e-02f, 7.88375214e-02f, 1.09825209e-02f, 4.96776700e-02f, -2.40792874e-02f, 4.55959626e-02f, -2.11442523e-02f,
  -2.88570449e-02f, 3.70792262e-02f, 2.09911019e-02f, 3.41799967e-02f, -6.70135301e-03f, 6.27035126e-02f, -4.70895320e-02f, -2.42896359e-02f, -3.48204374e-02f, -1.26466259e-01f,
  2.12397911e-02f, 5.54952025e-02f, -1.26554966e-01f, -5.67063466e-02f, 5.46928421e-02f, -1.86867956e-02f, 5.66706695e-02f, 2.85675060e-02f, -6.88207075e-02f, -9.87884849e-02f,
  1.59995764e-01f, -6.03164434e-02f, -7.14019220e-03f, -9.72544402e-02f, -1.03705116e-01f, -1.46595865e-01f, -5.96633926e-02f, -2.48427410e-03f, -2.58032139e-02f, -6.08444810e-02f,
  -9.33664571e-03f, -2.13041008e-01f, -1.20144002e-01f, -9.26494598e-02f, -8.78983364e-02f, -1.02522150e-02f, -4.02714200e-02f, 8.78700912e-02f, 6.26061186e-02f, -1.38466274e-02f,
  -2.00282922e-03f, 1.65987700e-01f, 7.66195357e-02f, 9.15003121e-02f, 2.47267783e-02f, -2.71699168e-02f, 1.46677159e-02f, -9.93657559e-02f, -7.77363330e-02f, -1.29289493e-01f,
  -2.65497774e-01f, -1.77595079e-01f, -6.27827048e-02f, -4.78457566e-03f, 1.14372522e-01f, 1.66861713e-02f, -2.36708879e-01f, 3.36606726e-02f, 1.27731383e-01f, -3.15075591e-02f,
  -1.63322520e-02f, 8.31334665e-02f, -8.51222724e-02f, -1.68781728e-02f, -9.16853696e-02f, -3.30707550e-01f, -2.67423719e-01f, -1.50112167e-01f, 1.93807542e-01f, 1.50226131e-01f,
  3.88118881e-03f, -1.75534207e-02f, 3.29151452e-02f, -5.05443849e-02f, -8.61028507e-02f, 1.40664550e-02f, -1.63862303e-01f, -8.42669308e-02f, -2.16931283e-01f, -3.39348674e-01f,
  -9.74723995e-02f, -7.90252611e-02f, 5.24548627e-03f, -1.57867342e-01f, 2.07074545e-02f, -1.55794518e-02f, -7.40791485e-03f, 5.37869707e-02f, 3.93040711e-03f, 2.67433077e-02f,
  9.01298374e-02f, 8.87722895e-02f, -3.39728482e-02f, 2.29111835e-02f, 7.30430409e-02f, 3.44093479e-02f, 1.11417182e-01f, -3.58644826e-03f, -1.26600891e-01f, 2.13126242e-01f,
  -5.80497533e-02f, -2.56789327e-02f, -9.95667130e-02f, 6.40063062e-02f, 5.25826290e-02f, -2.26807203e-02f, 1.07425518e-01f, 1.39734760e-01f, -1.97027013e-01f, -2.62643099e-01f,
  -8.66607651e-02f, -1.85495876e-02f, 7.70899579e-02f, 1.01425471e-02f, -2.23181024e-03f, 2.37197056e-02f, -7.95377493e-02f, -1.11721195e-01f, 6.01419508e-02f, 1.33801654e-01f,
  -1.90322232e-02f, -4.48917923e-03f, -6.57644942e-02f, -6.15164079e-02f, 5.11275902e-02f, -2.16579437e-02f, -2.96913181e-02f, -2.08930783e-02f, 8.43437389e-03f, 1.04304224e-01f,
  3.72794904e-02f, 2.99808513e-02f, 8.60860944e-02f, -2.24716924e-02f, 8.27506650e-03f, -1.22706912e-01f, 5.19105196e-02f, 7.45089650e-02f, 1.80816233e-01f, 1.39480487e-01f,
  -1.30566478e-01f, -1.22781694e-01f, -2.63810128e-01f, 7.55036473e-02f, -3.88414902e-03f, 1.47054449e-01f, 8.13893788e-03f, 1.71209108e-02f, 1.54513307e-02f, -4.35082428e-02f,
  1.08591631e-01f, -1.12561963e-01f, -7.08064809e-02f, -2.59243157e-02f, 1.59485862e-02f, 9.43310708e-02f, -6.75675794e-02f, -1.31075606e-01f, 2.77464148e-02f, 1.38209417e-01f,
  6.91798851e-02f, 3.40260714e-02f, -1.36233419e-01f, -1.09996423e-01f, -8.30264241e-02f, -1.24628693e-01f, -1.69710279e-01f, -2.66552344e-02f, -2.96766073e-01f, -3.07514489e-01f,
  4.86272216e-01f, 2.25450128e-01f, 8.36212784e-02f, 1.38587162e-01f, 1.89602807e-01f, 9.22019780e-02f, 2.78849840e-01f, 1.23869836e-01f, -1.14293359e-01f, 8.24466441e-03f,
  1.64746284e-01f, -3.42193060e-02f, -2.70092897e-02f, -7.43377432e-02f, 9.85487103e-02f, 2.21981015e-02f, -1.32228449e-01f, -8.42826739e-02f, 7.11343065e-02f, 9.08402726e-02f,
  -1.77846644e-02f, 4.55981418e-02f, 5.80019169e-02f, -4.58293222e-02f, 3.07928603e-02f, 1.70401484e-03f, 8.02075937e-02f, 1.90768346e-01f, 6.51556626e-02f, 2.65318677e-02f,
  -6.23731874e-02f, 3.21119398e-01f, -1.30281910e-01f, -7.62018189e-02f, 1.04832724e-01f, -1.27439186e-01f, 4.27112840e-02f, -9.01599228e-02f, -9.88752842e-02f, -8.11214522e-02f,
  4.47096825e-02f, 4.66556922e-02f, 2.02325150e-01f, 1.24670990e-01f, 7.66824484e-02f, 6.89137122e-03f, 8.73692892e-03f, 8.03687572e-02f, 3.68256010e-02f, 9.27375481e-02f,
  9.17857420e-03f, 2.13072777e-01f, 3.19969356e-02f, 4.54993732e-02f, 1.29736274e-01f, 6.11436330e-02f, 1.10027358e-01f, 1.05520152e-01f, 4.87178750e-02f, 1.25165852e-02f,
  1.16874628e-01f, 1.54603153e-01f, 8.57821256e-02f, 1.47324698e-02f, 1.56847164e-01f, 5.50947012e-03f, 1.57064125e-01f, 8.86536166e-02f, 1.23061165e-01f, 2.07841918e-01f,
  1.80357903e-01f, 2.83643771e-02f, 9.06579047e-02f, 1.32510543e-01f, -1.43889869e-02f, 5.04402556e-02f, 2.39696000e-02f, 4.89836447e-02f, 2.22177282e-01f, 3.81958224e-02f,
  1.20030046e-01f, -2.47297995e-02f, 6.45431578e-02f, 5.63580245e-02f, 1.90400016e-02f, 2.11808115e-01f, 1.34623215e-01f, 5.60799874e-02f, 1.57297999e-01f, 7.20243827e-02f,
  -2.13319287e-01f, 1.42278790e-01f, -3.07684727e-02f, -6.83550239e-02f, 8.59799013e-02f, 8.92941803e-02f, 7.22324178e-02f, -1.56013723e-02f, -1.96880013e-01f, -1.02340505e-01f,
  -6.08753338e-02f, -7.24345492e-03f, 1.92959264e-01f, 4.77393940e-02f, 1.47068296e-02f, -7.38523975e-02f, 5.16959317e-02f, -6.23173229e-02f, -1.69520319e-01f, -1.68191463e-01f,
  -5.41127147e-03f, -7.69583359e-02f, -3.56553458e-02f, -6.50773272e-02f, 4.93230484e-03f, -1.19205534e-01f, -1.14651144e-01f, -1.19154125e-01f, -7.60497302e-02f, -1.34476781e-01f,
  1.96651965e-01f, -3.17933828e-01f, -2.23900359e-02f, 1.58922747e-01f, -1.14358426e-03f, 8.06512590e-03f, -3.19594681e-01f, -1.15333736e-01f, -2.69165612e-03f, -2.19857618e-01f,
  -5.69406301e-02f, 1.83916643e-01f, 4.75561470e-02f, 1.87785421e-02f, -1.30616397e-01f, -4.31570172e-01f, -3.24259907e-01f, 1.35828286e-01f, 3.26678574e-01f, 1.06855989e-01f,
  6.27573521e-04f, 3.95214595e-02f, 6.95996508e-02f, 9.13373753e-02f, -1.33833066e-01f, -1.49075163e-03f, -2.10832402e-01f, -1.36821687e-01f, -7.39567801e-02f, -3.06903362e-01f,
  -1.32852331e-01f, -8.67435336e-03f, 1.98639154e-01f, -1.61779691e-02f, 5.26823476e-02f, -1.52359838e-02f, 3.82696055e-02f, -4.67255078e-02f, -2.04344071e-03f, -5.06885350e-02f,
  1.38818786e-01f, -2.26060394e-03f, 2.91988607e-02f, -1.28472308e-02f, 1.15155466e-02f, 8.19814950e-02f, -4.01773639e-02f, 5.76242618e-02f, -3.63892615e-02f, -1.67308956e-01f,
  -4.96230125e-02f, -8.17533806e-02f, -3.18643488e-02f, -1.24709040e-01f, 1.14047460e-01f, 1.55620828e-01f, -2.99090184e-02f, -8.54931213e-03f, -7.63990059e-02f, -2.51876324e-01f,
  -6.85530305e-02f, 2.78925523e-02f, 3.84303816e-02f, -3.12892012e-02f, -7.40401074e-02f, -2.59295851e-02f, -4.10583280e-02f, -7.17932284e-02f, -2.55888738e-02f, -6.03428297e-02f,
  1.08402096e-01f, 6.04661927e-02f, -8.48838035e-03f, -1.31423026e-01f, -8.00241232e-02f, 3.48993205e-02f, 5.55752479e-02f, -9.41188559e-02f, -1.20197043e-01f, -2.78910957e-02f,
  1.17730856e-01f, 4.08622809e-02f, -6.33647367e-02f, -1.10972593e-04f, -3.06965783e-02f, 3.40171298e-03f, 2.69333813e-02f, 7.82054812e-02f, 5.89718521e-02f, -1.97608531e-01f,
  7.24961385e-02f, 1.33971348e-01f, -1.56888127e-01f, 6.14660904e-02f, -4.01142500e-02f, -4.65198085e-02f, 9.66223329e-03f, 1.36292577e-01f, 7.97812790e-02f, 6.45271838e-02f,
  3.53837013e-03f, 9.35190096e-02f, -1.01807353e-03f, -5.24757989e-02f, 5.14059849e-02f, -5.91234714e-02f, -1.82037279e-01f, 7.88359269e-02f, -1.03198729e-01f, -5.05528525e-02f,
  -1.27105284e-02f, -1.80010840e-01f, -4.62540658e-03f, -1.02343641e-01f, -3.88620086e-02f, 1.29163027e-01f, -3.29270884e-02f, -6.01224527e-02f, -3.37856300e-02f, -3.24746013e-01f,
  5.13261497e-01f, -4.36542928e-01f, -4.92821664e-01f, -5.03284745e-02f, -6.43558875e-02f, 7.34909177e-02f, -2.67693922e-02f, 1.70926973e-01f, 8.22311565e-02f, -8.28063488e-02f,
  -1.26436390e-02f, 2.10849702e-01f, 2.93453261e-02f, 3.80816311e-03f, 1.53637975e-01f, -4.94739413e-02f, -2.20433772e-01f, 7.58938259e-03f, 3.30660135e-01f, 2.14862525e-01f,
  1.14464149e-01f, -1.20377447e-02f, 1.91280946e-01f, -4.41310145e-02f, -2.33869374e-01f, 1.68267284e-02f, -3.85800391e-01f, -2.08988070e-01f, -1.76694259e-01f, -3.33493948e-01f,
  -2.69857883e-01f, -1.69513419e-01f, 1.42013282e-02f, 7.58048967e-02f, -8.33291486e-02f, 1.72797307e-01f, 1.32585779e-01f, -4.43554409e-02f, 8.95798504e-02f, -6.45605028e-02f,
  -8.46497715e-02f, -4.51693349e-02f, 6.78171888e-02f, 5.53803593e-02f, -4.41042241e-03f, 1.57619733e-02f, -1.08891532e-01f, -3.83887701e-02f, 1.17798097e-01f, -2.34036148e-02f,
  -9.84620899e-02f, -3.30396346e-03f, -7.91019052e-02f, -1.50336489e-01f, -1.26208276e-01f, -4.89196591e-02f, -1.84041008e-01f, -7.78944418e-02f, -1.33882165e-01f, -6.84846416e-02f,
  -1.01234250e-01f, 4.11421340e-03f, -6.93011135e-02f, 5.53574562e-02f, 8.22582617e-02f, 1.07200272e-01f, 8.94948095e-03f, 5.93238100e-02f, 5.48964776e-02f, -8.68512914e-02f,
  -6.89309239e-02f, -7.35525042e-04f, 4.21660952e-02f, -2.59304140e-02f, -6.93555400e-02f, 6.69833869e-02f, -9.97028663e-04f, -1.94605943e-02f, -1.61563605e-02f, 4.41732071e-02f,
  -2.71061007e-02f, -2.42833383e-02f, -5.63995913e-02f, -3.85614000e-02f, -6.42672926e-02f, -3.31102572e-02f, -1.47040904e-01f, -1.26776649e-02f, 5.06368652e-02f, 1.23310238e-02f,
  8.36102664e-02f, -2.43750978e-02f, 5.94567135e-02f, 3.32112098e-03f, 2.25723796e-02f, -3.42872180e-02f, -1.47561029e-01f, 1.05859537e-03f, 1.07295305e-01f, 1.45929083e-01f,
  -9.10104290e-02f, 2.55313311e-02f, 4.34553921e-02f, -1.54611364e-01f, 9.60478000e-03f, -3.15871350e-02f, 6.89265653e-02f, 8.26426372e-02f, 9.65858903e-03f, -1.08107179e-01f,
  -8.22273046e-02f, 1.23371489e-01f, 2.00474739e-01f, -1.08018125e-04f, 4.64943610e-02f, 1.71267644e-01f, -3.87614556e-02f, -1.10779919e-01f, 1.27755985e-01f, 1.21135943e-01f,
  -3.32017869e-01f, 5.44152558e-02f, -2.28650555e-01f, -1.38925314e-01f, -2.75967503e-03f, 2.01262876e-01f, 4.78349440e-02f, 1.81858018e-01f, 6.82025552e-02f, -3.03171594e-02f,
  -2.20840424e-02f, -4.83885854e-02f, -2.46092319e-01f, -9.58980098e-02f, -1.35060936e-01f, -1.98182151e-01f, -1.71398342e-01f, -2.20178559e-01f, 6.88472912e-02f, 2.60830134e-01f,
  8.57981946e-03f, -1.80206582e-01f, -8.63787681e-02f, -1.86300557e-02f, -1.80029243e-01f, -2.00103357e-01f, -2.82660663e-01f, -2.00881273e-01f, -1.65952131e-01f, -4.00959700e-01f,
  -2.46635720e-01f, -1.25985637e-01f, 9.93647203e-02f, -8.00494850e-03f, 5.22668660e-02f, 1.52339116e-01f, 1.71215221e-01f, 8.45287591e-02f, 1.40205294e-01f, -6.83513284e-02f,
  -7.44865090e-02f, 7.53335282e-02f, -1.57168999e-01f, 2.49218941e-02f, 4.22250703e-02f, 1.79858673e-02f, -7.24709686e-03f, -2.89934333e-02f, 5.18186577e-03f, 1.35098144e-01f,
  -5.99996012e-04f, -5.72819710e-02f, -1.69743702e-01f, -5.07387221e-02f, 8.74095187e-02f, -2.58245226e-02f, 1.39914928e-02f, 1.66795647e-03f, -5.59333758e-03f, -1.92292444e-02f,
  1.67699203e-01f, -5.94847873e-02f, -1.13682461e-03f, 7.28888959e-02f, 1.06694559e-02f, -3.45410071e-02f, -1.25345841e-01f, -1.10133022e-01f, -1.49832770e-01f, 4.40337509e-03f,
  1.24667317e-01f, -1.74798947e-02f, -2.85833119e-03f, -5.46650738e-02f, -1.73281282e-01f, 2.74838284e-02f, -5.30249029e-02f, 1.05222194e-02f, -4.90078814e-02f, -4.13905606e-02f,
  -1.02159932e-01f, -1.07999548e-01f, -7.99747333e-02f, -5.16031161e-02f, -1.09863617e-01f, 1.23335291e-02f, -1.02118149e-01f, 4.35813442e-02f, 5.83144538e-02f, -1.15150049e-01f,
  -1.36577159e-01f, -6.24438338e-02f, -1.85039356e-01f, 1.06378816e-01f, 3.77752958e-03f, 1.44670919e-01f, -8.53241608e-02f, 4.38074879e-02f, -5.22196442e-02f, 1.04820430e-01f,
  -8.11983123e-02f, -3.40284407e-02f, -8.55678618e-02f, 5.69259338e-02f, 4.06952910e-02f, -8.46727341e-02f, -9.09425877e-03f, -1.58499464e-01f, -6.79357126e-02f, 6.02914393e-02f,
  3.45400274e-02f, -7.47415349e-02f, -2.19890565e-01f, -8.71648714e-02f, -1.67102814e-02f, -7.29896203e-02f, -1.45919770e-01f, -8.80559012e-02f, -1.67171344e-01f, -9.72934365e-02f,
  3.28925520e-01f, 4.95976619e-02f, -1.25280663e-01f, 4.95337369e-03f, -3.56255621e-01f, -3.30102444e-01f, -2.91426718e-01f, 7.56306872e-02f, -8.14077444e-03f, -1.29149452e-01f,
  -1.66275710e-01f, 4.45794910e-02f, -6.27482757e-02f, 1.36049703e-01f, 2.97186226e-01f, -4.71221916e-02f, 1.09898113e-01f, 3.34742635e-01f, 3.51956427e-01f, 8.64979103e-02f,
  6.09510541e-02f, 2.89360821e-01f, 4.81150031e-01f, 2.14470655e-01f, 3.05196010e-02f, -3.30268703e-02f, -8.99148732e-02f, -3.10480781e-02f, -1.15816854e-01f, -7.72150680e-02f,
  -9.48863998e-02f, -1.20186605e-01f, -2.07309350e-01f, 2.48618722e-02f, 3.09077855e-02f, 1.13549285e-01f, 3.86303067e-02f, 4.21658941e-02f, -1.36401251e-01f, 4.39211279e-02f,
  -9.95495990e-02f, -1.28181567e-02f, -8.30228031e-02f, 4.87133563e-02f, 7.76069611e-02f, -3.82145494e-02f, 1.36427715e-01f, 1.07454047e-01f, 1.74073815e-01f, 8.28640256e-03f,
  -1.43658310e-01f, -1.78047121e-01f, -2.66267449e-01f, -1.53169200e-01f, -4.41361107e-02f, -7.80347139e-02f, -4.85862605e-02f, -7.23412633e-02f, 4.88097370e-02f, 1.46070316e-01f,
  -4.99740094e-02f, 4.03047539e-02f, -4.11699265e-02f, 3.73971872e-02f, 9.26249623e-02f, 1.81963313e-02f, 1.54422643e-02f, 6.76093474e-02f, 6.08684421e-02f, 1.95232823e-01f,
  2.50752140e-02f, 5.66524602e-02f, 9.32718217e-02f, -5.65590076e-02f, -1.22201025e-01f, -9.80730802e-02f, -3.37502509e-02f, 1.21785805e-01f, -1.95225689e-03f, 3.73047218e-02f,
  6.69774180e-03f, -1.72416851e-01f, -9.76298675e-02f, 1.00460880e-01f, -8.25927109e-02f, 7.89621994e-02f, 4.23150100e-02f, 3.88766304e-02f, -3.66699621e-02f, 7.85265490e-02f,
  1.40738040e-01f, -1.80705979e-01f, -1.16462074e-01f, 8.58516842e-02f, -5.65920211e-03f, -1.26678541e-01f, -4.77968454e-02f, -5.17094508e-02f, -2.52112865e-01f, 5.67273721e-02f,
  -7.63752982e-02f, -2.18226835e-02f, -7.65202567e-02f, -5.05286735e-03f, 3.38868797e-02f, -2.01199993e-01f, 2.80935019e-05f, -4.66968156e-02f, 6.37804046e-02f, -1.55365737e-02f,
  1.42573059e-01f, -4.95811291e-02f, -1.57639325e-01f, -1.64113209e-01f, -1.18330278e-01f, -2.11928502e-01f, -1.14300400e-01f, -1.07602224e-01f, -8.62224326e-02f, 1.10660702e-01f,
  8.74129832e-02f, -3.05570036e-01f, -2.38688394e-01f, -2.95312226e-01f, -1.18246637e-01f, -4.43537496e-02f, -6.39102459e-02f, -1.65813431e-01f, -2.03784272e-01f, -3.12243938e-01f,
  -1.39923230e-01f, 1.31145611e-01f, 1.19614054e-03f, -2.95729525e-02f, 1.03669159e-01f, -3.40636790e-01f, -3.34661454e-01f, 8.26438069e-02f, 2.96145827e-01f, 2.52298087e-01f,
  -6.90818876e-02f, -1.26613244e-01f, -7.24399164e-02f, -1.30992457e-01f, -2.95348018e-01f, -6.77156672e-02f, -2.88973123e-01f, -2.23408461e-01f, -5.05764261e-02f, -4.39078540e-01f,
  -2.86765862e-02f, 5.86209744e-02f, 7.40823448e-02f, 9.79065746e-02f, -5.38445376e-02f, 1.51430946e-02f, 1.14084631e-01f, -2.96863038e-02f, 3.46288867e-02f, -9.49299857e-02f,
  -4.90725599e-02f, -6.12187013e-02f, 2.72481088e-02f, -2.20149625e-02f, 6.59259483e-02f, 5.52843846e-02f, 5.40874489e-02f, 3.07005979e-02f, -3.05585144e-03f, 4.21954691e-03f,
  -1.94379557e-02f, 6.94543272e-02f, 1.67785630e-01f, 1.71661049e-01f, 1.02678552e-01f, 1.81187958e-01f, 1.96555942e-01f, 1.75372735e-01f, 2.11131945e-01f, 8.72718841e-02f,
  -8.68569016e-02f, 5.91177121e-02f, 1.82424530e-01f, 1.54341564e-01f, 6.49652556e-02f, 1.67565331e-01f, 4.47117463e-02f, 7.42480233e-02f, 9.69595984e-02f, -2.40403670e-03f,
  3.49957943e-02f, -4.14994732e-02f, 4.27463390e-02f, -7.75655732e-02f, -1.38444752e-01f, 3.23634595e-02f, 1.97442118e-02f, 2.43537594e-03f, 6.06047921e-02f, -9.48258489e-02f,
  1.19794704e-01f, -1.52720958e-01f, -1.19531795e-01f, 1.71706975e-02f, -7.88070560e-02f, -2.15276554e-02f, -1.88175384e-02f, 3.25330049e-02f, -7.55779147e-02f, -1.05863437e-01f,
  8.17323774e-02f, 1.75429344e-01f, -1.36566490e-01f, 2.19743289e-02f, -9.27247033e-02f, -1.72411472e-01f, 4.14873548e-02f, -1.34024262e-01f, -1.86062306e-01f, 5.45555763e-02f,
  2.64170356e-02f, 1.14373259e-01f, -3.41889858e-02f, 1.47980005e-02f, 4.36869115e-02f, 5.22746667e-02f, 9.14350897e-03f, -2.78695617e-02f, 4.83508110e-02f, -1.16783313e-01f,
  -1.65664077e-01f, 1.61653951e-01f, 1.36358723e-01f, 6.49797395e-02f, 5.38070649e-02f, 1.71307042e-01f, 1.60408229e-01f, 6.82938769e-02f, 1.88324854e-01f, 5.32628410e-02f,
  7.74425745e-01f, -2.13279352e-01f, 8.08244571e-02f, 1.56987488e-01f, 6.36001602e-02f, 1.08593106e-01f, -1.94670305e-01f, -4.46214154e-02f, 1.75607018e-03f, -1.29833713e-01f,
  6.24800362e-02f, 1.89956278e-01f, 1.65129855e-01f, 1.36155739e-01f, 3.16104963e-02f, -2.04434991e-01f, -1.72769070e-01f, 1.33213520e-01f, 3.06333274e-01f, -1.05916135e-01f,
  -1.04881838e-01f, -6.40219972e-02f, 2.07490399e-01f, -2.76550073e-02f, -3.06982696e-01f, -3.36956754e-02f, -1.02350295e-01f, -1.39395803e-01f, -1.47398531e-01f, -1.58881858e-01f,
  -2.12458093e-02f, 2.32094660e-01f, 4.42843400e-02f, -3.39824297e-02f, 6.40528649e-02f, -1.41242826e-02f, -1.53161818e-02f, -8.72807726e-02f, 4.25619073e-02f, -6.72861189e-02f,
  -7.56058469e-02f, -1.16285719e-01f, 7.79051483e-02f, -1.34772524e-01f, -4.45076302e-02f, -2.72105690e-02f, -1.68366656e-01f, -3.33024152e-02f, 4.92242649e-02f, -1.18096255e-01f,
  -9.12264585e-02f, 8.39226507e-03f, 1.15814023e-01f, -3.26221883e-02f, -2.09276080e-02f, 1.60766453e-01f, -7.46071339e-02f, -4.74147946e-02f, 7.24826902e-02f, -8.22383761e-02f,
  -5.30475788e-02f, -3.79123650e-02f, 9.47894976e-02f, -5.13616428e-02f, 9.31861103e-02f, 8.46932456e-02f, -1.12327291e-02f, 4.23550457e-02f, -7.79255927e-02f, -1.09734875e-03f,
  -1.14318356e-01f, 4.25757915e-02f, 4.30848412e-02f, 3.79473008e-02f, 4.01830338e-02f, -1.18517550e-02f, 6.07614629e-02f, -9.13611650e-02f, 1.46980155e-02f, 2.35373117e-02f,
  1.17581643e-01f, -6.18312098e-02f, -1.46071510e-02f, -6.10246137e-02f, -8.22623596e-02f, -6.89649433e-02f, 5.25283702e-02f, 5.07271290e-02f, -4.78448980e-02f, -8.45943540e-02f,
  -1.77825943e-01f, 3.00065488e-01f, 6.01589903e-02f, -9.44420174e-02f, 1.40339136e-02f, -2.21448438e-03f, 5.69531620e-02f, 2.43652631e-02f, 1.78808551e-02f, -1.10195749e-01f,
  -1.30752642e-02f, 1.12066448e-01f, -5.31716906e-02f, -8.34908187e-02f, -8.70904252e-02f, 7.40904585e-02f, 2.76914034e-02f, 3.28474827e-02f, -5.40806577e-02f, -1.04754448e-01f,
  -1.57107949e-01f, 5.84956370e-02f, 1.75526619e-01f, -1.17905606e-02f, -2.19682530e-02f, 2.68934667e-01f, -1.20922904e-02f, -4.95695509e-02f, 2.41937220e-01f, -6.53470084e-02f,
  1.40988290e-01f, 2.07830966e-03f, 1.43147960e-01f, 4.73057106e-02f, -1.80594385e-01f, -3.21314603e-01f, -1.82792276e-01f, -8.92418101e-02f, -1.34048223e-01f, -5.86530790e-02f,
  -2.04695567e-01f, -1.26282319e-01f, -6.77847341e-02f, 8.05064887e-02f, 6.69184998e-02f, 8.63869041e-02f, 3.26709747e-01f, 2.30024889e-01f, 1.63089365e-01f, 5.16852885e-02f,
  1.24107122e-01f, 1.20240964e-01f, 1.30016059e-01f, 1.18578598e-01f, 2.13021114e-01f, -1.00094499e-02f, 5.17979451e-02f, 1.45943329e-01f, 3.76249738e-02f, 3.49604547e-01f,
  7.38912076e-02f, 8.75482559e-02f, -7.38942157e-03f, -1.65908244e-02f, -1.45930812e-01f, 1.15797780e-01f, 5.31605817e-02f, 1.29409701e-01f, 6.10919744e-02f, 6.07371815e-02f,
  -3.99995334e-02f, 2.39682887e-02f, -5.01336679e-02f, -2.94010025e-02f, -1.28001459e-02f, -4.13799062e-02f, 3.55962571e-03f, 1.12051450e-01f, 5.94327897e-02f, 7.31003284e-02f,
  -3.28303017e-02f, -4.07874919e-02f, -1.49730191e-01f, -6.63486570e-02f, 6.18638806e-02f, 1.44435465e-03f, -1.22026920e-01f, 9.29790735e-03f, -8.00835267e-02f, 1.10819675e-01f,
  5.65944128e-02f, -7.37216920e-02f, -1.17667466e-02f, 3.49208228e-02f, -6.95536882e-02f, -1.53264832e-02f, 9.36935320e-02f, -2.93696392e-03f, 3.53240296e-02f, 1.31356210e-01f,
  5.00837453e-02f, -4.24869880e-02f, 9.82753709e-02f, -3.86465266e-02f, 3.24949599e-03f, 1.61208247e-03f, -1.36734336e-03f, -5.59554696e-02f, -6.52994635e-03f, -5.02264425e-02f,
  4.95921224e-02f, 4.48378548e-02f, -4.54857200e-02f, 1.07144706e-01f, -7.43027478e-02f, 8.69041309e-02f, 1.14104385e-02f, -2.24755406e-02f, 3.70321237e-02f, 6.51889518e-02f,
  -1.26677841e-01f, -3.35387290e-01f, 8.75500515e-02f, 2.65280697e-02f, -1.13558799e-01f, -1.06729321e-01f, -5.42420428e-03f, -3.24435794e-04f, -9.26043615e-02f, -1.10813126e-01f,
  -2.11144909e-02f, 2.84330323e-02f, -4.84550968e-02f, -5.01679033e-02f, -8.66386294e-03f, -5.88538162e-02f, -4.08062711e-02f, -6.33231327e-02f, -6.88848495e-02f, -6.91508129e-02f,
  8.00942164e-03f, -1.50796443e-01f, -2.31047377e-01f, -1.59153551e-01f, -9.47778523e-02f, -2.29634687e-01f, -1.64815649e-01f, -1.15301572e-01f, -3.34298640e-01f, -2.50732034e-01f,
  -5.25458276e-01f, -5.60175739e-02f, 2.12498039e-01f, -2.28908911e-01f, 1.02774136e-01f, 1.73512056e-01f, 2.59980410e-01f, 3.05005908e-02f, -1.47399172e-01f, 3.44297625e-02f,
  -2.53749043e-01f, -2.67536879e-01f, -2.03446284e-01f, -7.46531859e-02f, -8.99035037e-02f, 2.50955135e-01f, 3.33516210e-01f, 6.51340038e-02f, 1.96507648e-01f, 1.95834309e-01f,
  1.15275227e-01f, -1.15879565e-01f, -3.06813896e-01f, -1.56943440e-01f, -1.10066853e-01f, 5.01935370e-02f, -6.37067528e-03f, -7.29594603e-02f, -1.77730396e-02f, 7.06620812e-02f,
  1.82316244e-01f, -2.48760715e-01f, 1.03612073e-01f, -6.96892515e-02f, -1.18229449e-01f, -1.16524130e-01f, -1.68272126e-02f, -1.20533682e-01f, -1.45179123e-01f, -7.06614554e-02f,
  -1.12028249e-01f, -7.41138384e-02f, -1.56154484e-03f, -2.56547946e-02f, -5.11296615e-02f, -1.81627851e-02f, -4.20820266e-02f, -6.69787312e-03f, -1.21358581e-01f, 1.01607203e-01f,
  3.56819741e-02f, -1.05562009e-01f, 1.66416995e-03f, 5.57309911e-02f, -2.80770678e-02f, 1.62475165e-02f, -8.35036263e-02f, -1.17909089e-01f, -1.20477691e-01f, -9.40870959e-03f,
  -2.31800135e-02f, -7.26868957e-02f, 9.60199349e-03f, -7.74772242e-02f, 1.71070434e-02f, -6.96135536e-02f, -1.20525062e-01f, -1.99464746e-02f, 7.98853263e-02f, 3.26713882e-02f,
  -1.41569540e-01f, 4.11138721e-02f, 1.93303395e-02f, -9.32088494e-02f, -7.28672668e-02f, -2.64472552e-02f, 6.91643059e-02f, 1.89660769e-02f, -1.24478891e-01f, 3.70900370e-02f,
  -2.52351146e-02f, 1.66259911e-02f, -3.42250802e-02f, 7.45364651e-02f, 6.48202226e-02f, 2.97765993e-02f, 6.19921945e-02f, 8.43082443e-02f, -1.27073377e-02f, 3.69417161e-04f,
  3.87796834e-02f, -1.64759770e-01f, 1.40971303e-01f, -5.83378710e-02f, -1.08069624e-04f, -1.48318291e-01f, -2.24710647e-02f, -3.15691978e-02f, -1.49844915e-01f, -3.34533937e-02f,
  -9.34586152e-02f, 8.47121403e-02f, 6.81260927e-03f, 1.20306365e-01f, 9.96378958e-02f, 7.18987808e-02f, 2.15883106e-02f, 7.03219837e-03f, 4.54139411e-02f, 8.80111903e-02f,
  1.53269023e-01f, 1.62866950e-01f, 1.26657948e-01f, 2.89452653e-02f, -7.03500211e-02f, 1.25362828e-01f, 1.86018422e-01f, 1.51430860e-01f, 9.25347656e-02f, 1.76349595e-01f,
  -2.00908363e-01f, -3.57647657e-01f, 6.82174601e-03f, 3.69671136e-02f, 1.79627717e-01f, 5.05856611e-02f, 1.32293954e-01f, 1.88459791e-02f, 9.10757110e-02f, -8.27931762e-02f,
  -2.47856095e-01f, -2.35686436e-01f, -2.07385853e-01f, -9.46528167e-02f, -1.11305080e-01f, 9.04892385e-02f, 2.36354917e-01f, 1.33941278e-01f, 1.13216922e-01f, 9.59378630e-02f,
  1.38647482e-01f, 1.82807758e-01f, -2.42165271e-02f, 1.13655277e-01f, 6.74153641e-02f, 7.99465254e-02f, 4.04840112e-02f, 1.25917802e-02f, -1.26367092e-01f, 9.41539928e-02f,
  -2.88423538e-01f, -2.59146124e-01f, 7.74820615e-03f, -5.84063567e-02f, -7.93108717e-02f, -3.06746457e-02f, -1.91039704e-02f, -2.88491715e-02f, -4.42858785e-02f, 1.22831240e-01f,
  2.90039834e-02f, -8.06886405e-02f, -4.77200635e-02f, -5.63956946e-02f, 1.37863711e-01f, 7.88542852e-02f, -8.45859796e-02f, 4.57008891e-02f, -3.31713408e-02f, -9.61928591e-02f,
  -2.19265111e-02f, -3.92036885e-02f, -1.25325294e-02f, 6.86594769e-02f, -5.47584705e-03f, 6.28623515e-02f, -1.36583298e-01f, -4.17851582e-02f, -5.18923402e-02f, -3.70830894e-02f,
  -2.17541903e-02f, 1.33017257e-01f, -1.43494323e-01f, -1.62309483e-01f, -5.38887121e-02f, 1.54374763e-01f, 4.25533503e-02f, 1.73092075e-02f, -1.08665571e-01f, -8.47659111e-02f,
  8.17257818e-03f, -9.84273627e-02f, -1.55257642e-01f, 5.66874705e-02f, -1.55887797e-01f, -9.31390598e-02f, -4.04403210e-02f, -1.34426430e-01f, -2.67733991e-01f, -2.16910660e-01f,
  -1.20178439e-01f, 3.01407538e-02f, -6.73684850e-02f, -8.38462636e-02f, -2.01953739e-01f, -1.73167177e-02f, 2.50685737e-02f, -1.66745275e-01f, -2.11200281e-03f, -7.97358342e-03f,
  -1.01281339e-02f, -4.21052516e-01f, -8.60648975e-02f, -1.05004303e-01f, 6.45491555e-02f, -5.82594350e-02f, -2.69604832e-01f, -8.38195384e-02f, 1.51552215e-01f, 9.71946046e-02f,
  -5.39276749e-02f, -4.29659262e-02f, 6.85161067e-05f, -4.79946025e-02f, 1.08548082e-01f, 1.09978519e-01f, -8.99662375e-02f, 1.36573408e-02f, 7.20030889e-02f, -8.16144720e-02f,
  -3.51630822e-02f, 7.93363228e-02f, 4.45539989e-02f, -1.36872530e-02f, 1.19433016e-01f, 2.08749056e-01f, -2.38966774e-02f, 5.08935377e-02f, 1.43451542e-01f, 1.19065598e-01f,
  -3.09849381e-02f, 3.34092230e-01f, -1.00707904e-01f, 7.01407939e-02f, 3.10345590e-01f, 5.17546646e-02f, 7.06898868e-02f, -4.67234887e-02f, 9.80498083e-03f, -3.18419486e-02f,
  1.56016089e-02f, 6.53998628e-02f, 1.66482553e-02f, 1.41743794e-02f, -1.58449039e-01f, -4.79050502e-02f, 1.50379419e-01f, -5.85664622e-02f, -2.26502016e-01f, -1.42718166e-01f,
  1.86068237e-01f, 6.27009273e-02f, -8.37282687e-02f, -5.41939959e-02f, 2.68763423e-01f, -1.03359431e-01f, 6.43765032e-02f, 1.79651439e-01f, 1.54500529e-01f, 2.31306136e-01f,
  5.48515841e-02f, 1.24320805e-01f, -2.66801476e-01f, 1.32723972e-01f, 1.17213771e-01f, -9.70823839e-02f, -1.16369538e-01f, 2.80993320e-02f, 8.31865426e-03f, 5.62556460e-02f,
  2.08074555e-01f, 1.53354526e-01f, 2.74749458e-01f, 9.23686996e-02f, 3.17874812e-02f, -1.89777851e-01f, -1.50581107e-01f, -1.45260081e-01f, -2.57777780e-01f, -2.46958509e-02f,
  9.60093737e-02f, 2.15326518e-01f, 7.95267746e-02f, -1.01778582e-01f, -1.74655631e-01f, -3.72745320e-02f, 4.30055484e-02f, 3.44734415e-02f, -2.71367788e-01f, -3.13101918e-03f,
  -1.54423699e-01f, -7.56115690e-02f, 3.35781612e-02f, -2.66681146e-02f, 7.19871074e-02f, 7.17349201e-02f, -2.68457900e-03f, 1.29608974e-01f, -8.22162181e-02f, 5.19761443e-02f,
  -1.30249560e-01f, -2.36395329e-01f, -7.89576769e-02f, -1.06995389e-01f, -4.81194258e-02f, 1.62901208e-02f, -5.56873269e-02f, -1.24665007e-01f, -7.46769980e-02f, -3.59969446e-03f,
  -2.54784841e-02f, -8.06032717e-02f, -2.03069411e-02f, -3.17891911e-02f, -7.20626265e-02f, -1.37951016e-01f, -1.65686354e-01f, -6.12874627e-02f, 5.21836104e-04f, -1.91523973e-02f,
  1.50896665e-02f, -6.82717860e-02f, -1.17993698e-01f, -1.27542421e-01f, -1.18419947e-02f, 5.18327355e-02f, -9.66726337e-04f, -6.90307543e-02f, 3.56441387e-03f, -2.03590140e-01f,
  6.19679838e-02f, -2.00037241e-01f, 6.13280237e-02f, -5.93576245e-02f, -4.71652187e-02f, -3.46528403e-02f, 1.14323013e-02f, -5.05518354e-02f, -1.19597919e-01f, -8.46640468e-02f,
  -6.54326826e-02f, -8.61451775e-02f, -2.11432591e-01f, -2.03688413e-01f, -2.60029644e-01f, -2.72179723e-01f, -2.24810928e-01f, -9.70470980e-02f, -1.82008222e-01f, -1.92108303e-01f,
  7.45313942e-01f, 3.01244497e-01f, 1.96987867e-01f, 1.47670016e-01f, 1.09781772e-02f, -1.02731079e-01f, 1.23606205e-01f, 1.17339991e-01f, 5.68145402e-02f, 3.75584178e-02f,
  9.89980400e-02f, -2.16116570e-02f, 8.10212642e-02f, 5.73022515e-02f, 2.93873679e-02f, -2.55803913e-02f, -4.60273735e-02f, 2.07008794e-01f, 1.73833400e-01f, -3.52631265e-04f,
  -3.30886729e-02f, 2.81506088e-02f, 3.33442837e-01f, 4.56719175e-02f, -9.78467334e-03f, -5.96448407e-02f, -5.44148237e-02f, 7.65465945e-03f, -1.52926166e-02f, -3.37333158e-02f,
  3.89544480e-02f, 2.39262506e-01f, -1.41350895e-01f, 6.20322116e-02f, 6.47989288e-03f, 1.32156834e-01f, -1.03309867e-03f, 1.32844299e-01f, 1.13732070e-01f, 3.62508222e-02f,
  -7.01517798e-03f, -6.45738989e-02f, -3.59083153e-02f, 5.52853346e-02f, 6.48961589e-02f, 3.98145653e-02f, -1.17380684e-02f, 7.79864118e-02f, -9.62141901e-02f, 1.91208031e-02f,
  -2.66597625e-02f, 1.28159700e-02f, 1.11410040e-02f, -4.07889858e-02f, -1.50582701e-01f, -3.70391384e-02f, 9.14253294e-02f, 1.86482957e-03f, 6.60333037e-03f, 1.01321898e-01f,
  -1.20457061e-01f, 2.45005861e-02f, -4.14589979e-02f, -4.99605089e-02f, -2.05338895e-01f, -1.06145836e-01f, -8.52868631e-02f, -1.46926329e-01f, -2.10842788e-01f, -1.65696636e-01f,
  -3.80309485e-02f, -6.11071549e-02f, 1.32428342e-03f, -2.67265923e-02f, 1.86867770e-02f, 6.59773424e-02f, -4.39294204e-02f, -1.00669026e-01f, -1.47497594e-01f, -1.52127668e-02f,
  -5.58777712e-02f, -3.17512490e-02f, 1.46244869e-01f, 5.40379882e-02f, 7.70905390e-02f, 1.28292395e-02f, -6.68120086e-02f, -2.06233654e-02f, -3.42104286e-02f, -4.98115784e-03f,
  -2.38186553e-01f, -1.81140795e-01f, -1.21143699e-01f, -4.24067751e-02f, 9.67030972e-02f, 4.17547636e-02f, -1.33700341e-01f, 4.85434197e-02f, -3.07263155e-02f, -5.07141557e-03f,
  -6.21089563e-02f, 5.97663410e-02f, -3.62148061e-02f, -4.04904634e-02f, -1.47314191e-01f, -8.46291408e-02f, 6.08048439e-02f, 4.36785258e-02f, 3.11706830e-02f, -1.06010638e-01f,
  -3.84123065e-03f, -1.33087754e-01f, -1.65014863e-01f, -9.68071595e-02f, -1.80504009e-01f, -1.88713208e-01f, -8.21056291e-02f, -9.71134752e-02f, -1.10895313e-01f, -8.16533640e-02f,
  1.32592738e-01f, -1.70755669e-01f, -2.67331958e-01f, 1.35153130e-01f, 1.76511034e-01f, -5.11255413e-02f, -2.81253129e-01f, -2.64818594e-02f, 1.63568944e-01f, -9.05657485e-02f,
  -2.29009725e-02f, 1.74699649e-01f, 1.33237010e-02f, -1.29225641e-01f, -2.85294473e-01f, -3.12674701e-01f, -2.27237061e-01f, -2.24754259e-01f, -2.12012958e-02f, 5.97654507e-02f,
  2.11070225e-01f, 1.33630827e-01f, -2.27160053e-03f, -2.25338209e-02f, 1.82064041e-01f, 1.75825402e-01f, -5.39439097e-02f, 2.83653513e-02f, -1.93416879e-01f, -1.56770814e-02f,
  -2.18084782e-01f, 2.01794505e-03f, -2.23867465e-02f, 6.90140277e-02f, 8.59891772e-02f, 1.89494103e-01f, 8.94516110e-02f, 1.00065991e-01f, 1.73812807e-01f, 7.22180977e-02f,
  6.83194026e-02f, 1.12202212e-01f, 2.18397588e-01f, 9.70519930e-02f, 1.16778612e-01f, 6.76883534e-02f, -5.21150380e-02f, -1.92783862e-01f, -7.96300024e-02f, 2.06630658e-02f,
  1.02602504e-01f, 1.45868987e-01f, -2.18413278e-01f, -1.01389423e-01f, -6.41372129e-02f, -5.34299053e-02f, -6.60202205e-02f, 4.78244722e-02f, -1.68366268e-01f, -6.15396574e-02f,
  3.37295011e-02f, -5.65008782e-02f, -4.14408569e-04f, 7.62820318e-02f, 9.56862643e-02f, 2.49548219e-02f, -6.20269254e-02f, -1.78930581e-01f, -6.42311200e-02f, 5.58038354e-02f,
  5.84179908e-03f, -6.61768243e-02f, 7.32998969e-03f, -2.41201073e-02f, -5.34763299e-02f, 2.14144588e-02f, 6.42347336e-02f, -1.06179841e-01f, -1.79995626e-01f, 7.33707696e-02f,
  -8.56420211e-03f, -3.12188733e-02f, 9.08240303e-02f, 1.64637119e-02f, -6.01580516e-02f, -5.74824773e-02f, 1.10064745e-01f, 8.95767212e-02f, 4.95527983e-02f, 1.52133405e-01f,
  1.45313203e-01f, -2.99929250e-02f, -1.18529342e-01f, -7.70861059e-02f, -1.54352322e-01f, -6.58526197e-02f, 3.14671658e-02f, -1.06321841e-01f, 6.20069355e-02f, 1.77812018e-02f,
  -5.37148453e-02f, 1.05084321e-02f, -3.96426804e-02f, 1.07759377e-02f, 2.52029337e-02f, -4.98378426e-02f, -2.58100003e-01f, -1.22670308e-01f, -2.05675200e-01f, 6.06367476e-02f,
  -1.20713286e-01f, -8.79975781e-02f, -6.17689528e-02f, -1.45443648e-01f, 4.51070853e-02f, -3.74434814e-02f, -1.14432298e-01f, -6.35122284e-02f, -1.73634753e-01f, -1.30791456e-01f,
  -4.75880355e-02f, -2.96935290e-01f, -6.60705343e-02f, 4.64781858e-02f, 9.83483121e-02f, -2.11063430e-01f, -5.38948476e-01f, -3.31274390e-01f, -1.26305863e-01f, -2.43379980e-01f,
  -1.19849175e-01f, 5.49677946e-02f, -1.23507362e-02f, -3.58311832e-02f, -2.03819528e-01f, -2.48118296e-01f, -4.70949486e-02f, 1.39296606e-01f, 4.30818796e-02f, 1.17982827e-01f,
  1.54823944e-01f, 1.09077290e-01f, 1.72360286e-01f, 1.45234630e-01f, 2.31140777e-01f, 1.96558326e-01f, 1.77779973e-01f, 3.01506728e-01f, 2.20245019e-01f, 3.93854946e-01f,
  3.94345867e-03f, -5.28805666e-02f, 1.87447425e-02f, 4.37934399e-02f, 1.37866348e-01f, 6.91627199e-03f, -7.39004537e-02f, 8.74139965e-02f, 3.94523554e-02f, -7.93532655e-02f,
  1.05744362e-01f, 4.78371643e-02f, -1.93676725e-02f, 7.12019354e-02f, -1.18942456e-02f, -5.61792068e-02f, -5.39540350e-02f, -6.07585497e-02f, -2.52037980e-02f, -7.28384927e-02f,
  1.65333189e-02f, 2.52583362e-02f, -2.42164761e-01f, -1.39107913e-01f, -1.69192448e-01f, 3.26613486e-02f, 7.95896649e-02f, 1.43221498e-01f, 1.58400029e-01f, 1.26606464e-01f,
  1.53244268e-02f, 6.53406978e-02f, -2.22096462e-02f, -1.01365503e-02f, -9.88291427e-02f, -6.00278229e-02f, 8.52270052e-02f, 2.10907497e-02f, 1.43706650e-01f, -8.05998966e-02f,
  -7.49160051e-02f, 9.51297730e-02f, -9.42787039e-04f, 4.67756838e-02f, 1.88877061e-01f, 1.05013229e-01f, 1.31507143e-01f, 6.25806767e-03f, 7.22020268e-02f, 1.72523111e-02f,
  9.26492037e-04f, 2.36621499e-03f, -4.35452769e-03f, 2.77433377e-02f, -1.35028765e-01f, 8.14971253e-02f, 1.05407037e-01f, 3.60631235e-02f, 8.49111304e-02f, 2.50497200e-02f,
  -1.36079505e-01f, -7.83332735e-02f, -4.37035710e-02f, -2.34591886e-02f, 6.22487515e-02f, 1.62489489e-01f, 1.77072302e-01f, -2.53315642e-02f, 1.30470634e-01f, -1.06134340e-01f,
  1.54677778e-02f, -3.74775603e-02f, -6.25508726e-02f, -3.28373350e-02f, -1.06587680e-02f, -3.77980880e-02f, -1.39815658e-02f, -8.50247070e-02f, -7.45669231e-02f, 7.46464878e-02f,
  -7.25788996e-02f, -2.40860537e-01f, -3.37994397e-01f, -3.15537006e-01f, -2.67007444e-02f, -1.79681167e-01f, -4.51592132e-02f, 6.31077588e-02f, -1.25679836e-01f, -3.24974984e-01f,
  -3.72976065e-01f, -1.50954807e-02f, -8.92005190e-02f, 3.29982415e-02f, 2.45034948e-01f, 1.60913393e-01f, 1.99097395e-01f, 5.10909855e-02f, -1.47288747e-03f, 1.15779087e-01f,
  9.28333029e-02f, 1.56969681e-01f, 1.17019311e-01f, 1.11210890e-01f, -2.05300841e-02f, 9.15969759e-02f, 1.55857652e-01f, 6.74605183e-03f, -1.32917330e-01f, 5.51864915e-02f,
  1.04433842e-01f, -1.15526937e-01f, -2.91849792e-01f, -7.91538134e-02f, -4.99709956e-02f, 9.40506607e-02f, -3.10476702e-02f, -8.05023834e-02f, 7.28599206e-02f, 1.45989150e-01f,
  -1.79721087e-01f, -7.31705502e-02f, 5.22838272e-02f, 1.48690373e-01f, 7.78769329e-02f, -7.73836449e-02f, -8.34700316e-02f, -1.31777301e-01f, 6.98812539e-03f, -6.64006472e-02f,
  2.76511181e-02f, -5.79218790e-02f, 9.25521255e-02f, -2.76170410e-02f, -1.39109805e-01f, -2.21218877e-02f, -3.97754386e-02f, -2.37733766e-01f, -2.46104822e-01f, -1.87157437e-01f,
  2.18607292e-01f, 2.36919578e-02f, -2.36508653e-01f, -6.49423301e-02f, -1.17998697e-01f, -5.08066192e-02f, -1.00319766e-01f, -2.26495266e-01f, -1.53652772e-01f, -3.22539061e-01f,
  8.94176774e-03f, -1.51940649e-02f, 4.95791342e-03f, -8.51188451e-02f, -2.31721215e-02f, 1.14251181e-01f, -3.15496922e-02f, 4.94454615e-02f, -8.51413831e-02f, 1.48729924e-02f,
  3.08013353e-02f, 6.10046051e-02f, -6.44061789e-02f, -3.46060619e-02f, 9.97662693e-02f, -1.94264427e-02f, 4.80752997e-02f, 9.02580321e-02f, -2.74473988e-02f, 1.19275890e-01f,
  -2.29550097e-02f, -6.13986282e-03f, 2.50547496e-03f, 7.26355892e-03f, 4.28720638e-02f, 5.24674505e-02f, 3.69473472e-02f, 5.30574173e-02f, 4.39457484e-02f, -1.29057810e-01f,
  -1.51248351e-01f, 1.15992174e-01f, -1.41853755e-02f, 1.14367786e-03f, -1.10713337e-02f, 1.13792971e-01f, 8.45538527e-02f, 8.42180476e-02f, -8.89632676e-04f, -1.06058978e-01f,
  3.11065502e-02f, -1.71812940e-02f, 6.38609380e-02f, -6.18961677e-02f, -1.27607435e-01f, -2.26904564e-02f, 3.12277358e-02f, 2.81704403e-02f, -1.28791273e-01f, -9.58202183e-02f,
  9.23990011e-02f, -6.01251051e-02f, -2.40209788e-01f, -1.38226807e-01f, -2.05332369e-01f, -1.12792835e-01f, -9.96999890e-02f, -1.44778132e-01f, -1.34495288e-01f, -1.95662364e-01f,
  4.45480555e-01f, 2.91249812e-01f, 1.80128783e-01f, 4.45787869e-02f, -4.50752191e-02f, 5.36901318e-02f, 1.86787218e-01f, -2.77660135e-02f, -2.24999338e-02f, 9.39405262e-02f,
  2.10973516e-01f, 3.27965841e-02f, 3.90090197e-02f, -1.18878916e-01f, 5.02855517e-02f, -1.12215616e-01f, -1.24754645e-01f, -4.60192263e-02f, -4.19930518e-02f, -5.14202081e-02f,
  -5.06885909e-02f, 1.09753989e-01f, 2.02542350e-01f, -5.44106634e-03f, -1.52317993e-02f, -1.59396350e-01f, -9.78262052e-02f, -7.01718479e-02f, -4.65500467e-02f, -3.56874615e-02f,
  -1.32702664e-01f, 3.25206012e-01f, -1.68236792e-01f, 5.90295438e-03f, 9.12643522e-02f, 1.01716332e-01f, 1.31521681e-02f, 8.36290121e-02f, -1.11595258e-01f, -5.94757088e-02f,
  -9.07226056e-02f, -5.75543568e-02f, 5.91381043e-02f, 5.84619679e-02f, 5.13595045e-02f, -4.31558639e-02f, 9.50888544e-02f, -6.75051957e-02f, 6.44719228e-02f, -8.15391913e-02f,
  -8.18388760e-02f, 9.73481983e-02f, 9.48404893e-03f, 2.94005368e-02f, -6.58200830e-02f, 1.45211080e-02f, 7.22934380e-02f, 8.66585318e-03f, 1.08435594e-01f, 2.26992480e-02f,
  -3.84011455e-02f, 3.72082144e-02f, -2.96036620e-02f, -4.34911102e-02f, -1.54150084e-01f, -9.83379185e-02f, -1.48437053e-01f, 6.39411658e-02f, -1.96956210e-02f, -8.30726400e-02f,
  -2.61284523e-02f, -2.98874006e-02f, -6.06914274e-02f, 7.87956715e-02f, -8.57176408e-02f, -3.00656189e-04f, -5.50411418e-02f, 8.34672991e-03f, -1.56742595e-02f, -8.11483040e-02f,
  2.99072098e-02f, -3.69357504e-02f, 4.26732227e-02f, 2.99885683e-02f, 2.09155381e-02f, -5.87750003e-02f, -8.41837674e-02f, 2.65744869e-02f, 2.95569422e-03f, 7.32931949e-05f,
  -1.72256574e-01f, -4.79324423e-02f, -1.77442104e-01f, -1.26381278e-01f, 2.23070048e-02f, 8.56094211e-02f, -6.60829917e-02f, -6.49854690e-02f, -7.09931776e-02f, -4.95238379e-02f,
  1.38806039e-02f, -3.89837064e-02f, -1.94319978e-03f, 3.60320285e-02f, -7.48006776e-02f, 3.57767344e-02f, 5.48393428e-02f, -8.78749266e-02f, -4.72156294e-02f, -1.08866923e-01f,
  -1.38853759e-01f, -1.13005362e-01f, -4.47802767e-02f, -4.56574447e-02f, -6.10623248e-02f, -1.44398704e-01f, -7.49513358e-02f, -1.35935038e-01f, 4.55574095e-02f, -7.68904388e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -4.21520360e-02f, 2.70895153e-01f, 5.03759980e-02f, 1.00517146e-01f, 1.41398802e-01f, -1.81708828e-01f, 3.38997215e-01f, 1.27061412e-01f, 4.16157395e-02f, -5.89061342e-02f,
  5.71973585e-02f, 2.35966384e-01f, 8.75907615e-02f, 1.77324861e-01f, -1.40848875e-01f, 1.65773317e-01f, 4.20693606e-02f, 2.49545306e-01f, 2.68488735e-01f, 1.69836581e-01f,
  -5.95859066e-02f, 3.59724671e-01f, -2.11743131e-01f, 3.35884765e-02f, 1.33953959e-01f, 1.73141912e-01f, 1.61286801e-01f, 9.91090313e-02f, 3.41194868e-01f, -2.09652577e-02f,
  1.47184432e-01f, 1.57084726e-02f, 3.35861355e-01f, -2.30400637e-02f, 1.51558056e-01f, 5.02282418e-02f, -6.53696619e-03f, 6.08560815e-02f, 4.07429598e-02f, 1.49742335e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.74053963e-02f, 5.92329865e-03f, -1.22602269e-01f, 2.99857091e-02f, 8.11102167e-02f, 1.45338565e-01f, 3.70213501e-02f, -5.04740924e-02f, 1.73690632e-01f, -5.61734550e-02f,
  9.66226459e-02f, -4.79313321e-02f, 2.00015888e-01f, -8.72593299e-02f, -1.03658915e-01f, -1.40708610e-02f, 3.25916684e-04f, 4.73029502e-02f, -1.15336008e-01f, 3.52518745e-02f,
  -3.17593962e-02f, -1.06358118e-02f, -1.95928030e-02f, 9.24222767e-02f, -9.46276487e-05f, -2.36798570e-01f, 2.27917269e-01f, -9.95311514e-02f, 1.36810333e-01f, 5.19538075e-02f,
  -2.24370211e-01f, -5.13057150e-02f, -1.03639856e-01f, 4.48879302e-02f, 1.84532136e-01f, 7.91782588e-02f, 6.64649457e-02f, -1.37745172e-01f, -9.53395367e-02f, -2.60547221e-01f,
  -5.39873615e-02f, 2.25756854e-01f, 6.78369626e-02f, 2.09437460e-01f, -1.01214305e-01f, 1.63202792e-01f, -1.21122241e-01f, 1.09028585e-01f, -7.09163770e-03f, 8.42091441e-02f,
  2.31738314e-01f, 3.71312499e-02f, 1.45319998e-01f, -2.90038642e-02f, 1.33303434e-01f, -7.37811178e-02f, -1.06902897e-01f, -1.86047509e-01f, -7.04923794e-02f, -5.35314046e-02f,
  -5.56947216e-02f, -2.65363436e-02f, 6.07799515e-02f, -8.53573382e-02f, -2.52000093e-02f, 1.62627678e-02f, 1.21144593e-01f, -5.02354577e-02f, -2.32763328e-02f, 6.57492504e-02f,
  6.27653971e-02f, 5.23575582e-02f, -1.04042720e-02f, 3.91046982e-03f, 8.29138830e-02f, 1.44565916e-02f, 9.25489664e-02f, -1.14711620e-01f, -6.48304671e-02f, 1.00825898e-01f,
  -9.31340083e-02f, -8.87431875e-02f, -1.41613722e-01f, -2.07758516e-01f, 3.89211848e-02f, -4.89230044e-02f, 8.84256512e-02f, 5.79718873e-02f, -2.98399240e-01f, 2.13326544e-01f,
  1.55590042e-01f, -1.42865255e-01f, -6.68399185e-02f, -1.40710413e-01f, 2.65058547e-01f, 7.91624635e-02f, -1.23040527e-01f, 1.88723758e-01f, -1.86385110e-01f, -5.51602244e-02f,
  9.43766311e-02f, 1.73664577e-02f, -1.11675277e-01f, 2.35344231e-01f, -3.41344066e-03f, -1.68711077e-02f, -9.29753948e-03f, 6.83708116e-02f, -3.62225212e-02f, -1.09317884e-01f,
  -1.73250780e-01f, -3.24666202e-02f, 6.21020012e-02f, -7.80936852e-02f, 1.39260262e-01f, -1.50485821e-02f, 1.04160517e-01f, -1.01902047e-02f, 2.16392297e-02f, -5.35034165e-02f,
  3.64703871e-02f, -1.72941878e-01f, -4.06865478e-02f, -1.11693673e-01f, -1.09430969e-01f, -1.96726605e-01f, 6.00517839e-02f, -1.48726266e-03f, 4.49240021e-02f, -5.00469580e-02f,
  -2.77914908e-02f, 5.12989536e-02f, 6.20333031e-02f, 5.17059937e-02f, -7.00900331e-02f, -8.01986903e-02f, 7.57820457e-02f, 6.25595972e-02f, 6.20225593e-02f, -6.91156611e-02f,
  1.27826393e-01f, 9.44621023e-03f, -8.42152759e-02f, -6.43003508e-02f, -8.20122194e-03f, 1.41514957e-01f, 6.71649650e-02f, 1.15755416e-01f, -3.53326723e-02f, 1.84799135e-02f,
  5.82301691e-02f, 7.74677247e-02f, 3.08861971e-01f, -1.21251605e-01f, -1.86149418e-01f, -1.22124605e-01f, 5.15942425e-02f, 2.12844074e-01f, 1.79996356e-01f, -3.63556631e-02f,
  4.23032697e-03f, -5.00891097e-02f, 1.37980282e-01f, 3.41878951e-01f, -1.85738876e-01f, -3.16671193e-01f, 1.68966264e-01f, -2.15594471e-01f, 7.34411478e-02f, 9.91824940e-02f,
  4.33802092e-03f, 3.01769465e-01f, -1.91028163e-01f, 1.50149569e-01f, -5.35839908e-02f, 8.20482001e-02f, 8.95585213e-03f, 1.13641910e-01f, 1.12674706e-01f, -9.05876700e-03f,
  -1.24642819e-01f, -4.70825695e-02f, 1.14790730e-01f, -1.83549449e-01f, -2.21902847e-01f, -6.30697906e-02f, -1.91937608e-03f, -4.43480276e-02f, 3.02701950e-01f, 2.97917500e-02f,
  -8.21135566e-02f, -1.45985521e-02f, -2.93625385e-01f, -5.71528226e-02f, 5.66389710e-02f, 3.73142846e-02f, -2.46756356e-02f, -7.80082643e-02f, 3.14241130e-04f, -1.89624831e-01f,
  -9.87804309e-02f, -6.93510100e-02f, -1.31950751e-01f, -1.42171457e-01f, 1.41403303e-01f, 1.50206029e-01f, 1.60610408e-01f, 4.96149547e-02f, -2.55071074e-01f, -5.35692694e-03f,
  -6.95206458e-03f, -2.96200607e-02f, -2.78573126e-01f, 5.42562567e-02f, -1.62656963e-01f, 5.53159043e-02f, -9.71383080e-02f, -2.80313641e-01f, 1.34731904e-01f, -4.04474288e-02f,
  1.42471164e-01f, 1.75747499e-01f, -1.22640736e-01f, -2.77471423e-01f, -7.25345910e-02f, 3.28661948e-01f, 1.39135435e-01f, -3.09510261e-01f, 7.37102553e-02f, -7.32726902e-02f,
  7.33902678e-02f, 9.05332267e-02f, 4.79482040e-02f, -1.14124846e-02f, -1.16642796e-01f, -2.71251351e-01f, -2.03107158e-03f, -7.44163245e-02f, -1.12250760e-01f, 7.09439814e-02f,
  -8.40413049e-02f, 1.21571936e-01f, 2.02796400e-01f, -5.07070012e-02f, -4.00194712e-02f, 4.06866252e-01f, 6.95713833e-02f, 3.66637744e-02f, 1.98962130e-02f, 1.81698918e-01f,
  -4.65096235e-02f, -7.93049186e-02f, -8.13193992e-02f, -3.25260982e-02f, 2.18131229e-01f, 1.71549506e-02f, 4.61590663e-02f, -8.26001465e-02f, 1.91908870e-02f, 6.18121214e-02f,
  1.38063878e-01f, 1.13127030e-01f, -1.07059246e-02f, -2.44983728e-03f, 4.87767830e-02f, 3.20749804e-02f, 2.32820027e-02f, 2.39218306e-02f, 9.86172184e-02f, 4.82935347e-02f,
  -9.09551159e-02f, -2.60592662e-02f, 5.87403700e-02f, 1.80071592e-01f, 5.29970229e-02f, -1.74375642e-02f, -4.24051620e-02f, -8.18319842e-02f, 1.27003957e-02f, 3.80469598e-02f,
  -9.71948262e-03f, 2.63080411e-02f, 1.65605634e-01f, 1.48112327e-01f, 1.79974020e-01f, -2.01203480e-01f, -2.38669679e-01f, 5.06284572e-02f, 7.77763128e-02f, -2.31239930e-01f,
  3.30626041e-01f, 1.56460509e-01f, -9.55047756e-02f, 1.50487855e-01f, 1.41532436e-01f, -1.34958923e-01f, -1.23622745e-01f, -5.41332625e-02f, -3.79681238e-03f, 1.16794929e-01f,
  2.56595928e-02f, 6.41693175e-02f, -2.24627778e-02f, 8.86579677e-02f, 1.13927517e-02f, 1.88530274e-02f, 4.44024168e-02f, 3.83633003e-02f, 2.57203817e-01f, 1.19744197e-01f,
  -1.50892988e-01f, 1.66377142e-01f, -9.16398689e-02f, 2.15246789e-02f, -1.55172154e-01f, 7.63218924e-02f, -3.06181982e-02f, 2.08447233e-01f, -1.19276084e-01f, -7.06014270e-03f,
  9.92477909e-02f, -2.28619874e-02f, -1.36282984e-02f, 8.11661780e-02f, -1.57474220e-01f, -2.53851302e-02f, -4.11563665e-02f, 3.21538746e-02f, 3.11114714e-02f, -1.00635797e-01f,
  -9.26342234e-02f, -3.62514704e-02f, -2.85358965e-01f, -1.66739791e-03f, -1.33756667e-01f, 1.31282479e-01f, 2.70271957e-01f, -5.10904454e-02f, 3.47876139e-02f, -7.06289778e-04f,
  1.86537087e-01f, -2.61501055e-02f, -1.21778697e-02f, 1.50889177e-02f, 1.46846652e-01f, 1.72732532e-01f, -3.09528023e-01f, -6.58243820e-02f, -1.35887086e-01f, 1.52238593e-01f,
  1.48072153e-01f, 6.64514452e-02f, -1.56182218e-02f, 7.37604275e-02f, -2.84866244e-01f, 4.09342237e-02f, 1.89744085e-02f, 1.16975047e-01f, 7.22143427e-02f, 1.45069897e-01f,
  6.61022142e-02f, -1.20458424e-01f, 9.00156349e-02f, 5.65219596e-02f, 1.00402907e-01f, -7.59764090e-02f, 3.75140645e-02f, -7.70334452e-02f, 3.86880599e-02f, -1.89477175e-01f,
  -3.42329949e-01f, -1.57589242e-01f, -3.51067662e-01f, -1.48839265e-01f, -1.35056935e-02f, 1.60409063e-01f, 1.09650783e-01f, 1.41523123e-01f, -5.61555848e-02f, 9.97217000e-02f,
  -1.45230368e-01f, -9.26548243e-03f, 7.20669106e-02f, -1.54172154e-02f, 7.44044269e-03f, 7.21012205e-02f, -6.76468387e-02f, -1.75863713e-01f, -1.75825670e-01f, -1.50376916e-01f,
  -1.84751973e-02f, -5.42613678e-02f, -9.20865536e-02f, -2.19095107e-02f, -3.23297381e-02f, -1.16295643e-01f, -4.52298582e-01f, -6.91364557e-02f, 1.19309286e-02f, 1.04416553e-02f,
  -8.54956508e-02f, -2.71922983e-02f, -1.36055380e-01f, 1.14075772e-01f, 6.06179610e-02f, 8.25206190e-02f, -9.24555287e-02f, -2.22033828e-01f, -7.44356439e-02f, 5.88243268e-02f,
  -9.93960202e-02f, -5.64975813e-02f, -1.51719064e-01f, 2.38242090e-01f, 6.66043907e-02f, 8.18174705e-02f, -1.45973684e-02f, 1.86731070e-01f, -1.79366633e-01f, -1.45777687e-01f,
  2.16078348e-02f, -4.55980152e-02f, 1.96596305e-03f, 2.91266948e-01f, 2.51132518e-01f, -2.33333722e-01f, -8.40416700e-02f, -1.46320611e-01f, 2.08843201e-02f, -9.68255624e-02f,
  6.86715320e-02f, -1.80613220e-01f, 1.75367936e-01f, -3.28866728e-02f, -3.32998097e-01f, -1.07407525e-01f, -3.69094461e-01f, 7.42930695e-02f, 6.76850826e-02f, -2.38388348e-02f,
  1.13135867e-01f, 1.31774262e-01f, -5.06689120e-03f, -2.23758072e-01f, -3.58128101e-02f, -1.56413630e-01f, 1.48679480e-01f, 9.73785855e-03f, 1.20796464e-01f, -4.58923355e-02f,
  6.82044849e-02f, 1.11079805e-01f, -8.68316740e-02f, 1.23622857e-01f, 5.23392158e-03f, 1.54995948e-01f, 4.10052687e-02f, 1.06606871e-01f, 8.05520564e-02f, 1.35374054e-01f,
  -4.01999690e-02f, -1.26412168e-01f, -8.31843242e-02f, -1.31621853e-01f, 4.18592244e-02f, -1.09511413e-01f, -1.03654144e-02f, -4.51137945e-02f, 1.07703716e-01f, -3.15291695e-02f,
  -3.69800776e-02f, -4.93579432e-02f, 1.47039872e-02f, -9.59375352e-02f, -1.93493038e-01f, -1.47929803e-01f, -1.85737982e-02f, 2.41870821e-01f, 2.17025280e-01f, 2.97061261e-02f,
  1.28227010e-01f, 1.89917818e-01f, -1.11684620e-01f, 1.45548791e-01f, -5.21729961e-02f, -2.02840790e-01f, 1.03112742e-01f, -5.42904958e-02f, 2.58549750e-02f, 3.33266407e-02f,
  -7.71783218e-02f, 2.28047118e-01f, -9.46663842e-02f, -3.51697132e-02f, 1.30677596e-01f, -1.88106090e-01f, -2.90212650e-02f, -1.34982556e-01f, 1.14950970e-01f, -1.59151599e-01f,
  -1.23679684e-02f, 2.95233615e-02f, 5.40940911e-02f, -1.53645590e-01f, -1.40517116e-01f, 4.36845087e-02f, -2.37045381e-02f, -6.18728586e-02f, -8.43608752e-02f, -1.37166873e-01f,
  -1.17840003e-02f, -2.91131288e-02f, -3.62098366e-02f, 5.73516265e-02f, 1.01788513e-01f, 5.73434867e-03f, 1.20965734e-01f, -8.96782801e-02f, -3.01307347e-02f, 1.18547818e-02f,
  -1.00168005e-01f, 1.56322457e-02f, -6.99418504e-03f, 4.47362987e-03f, 1.92365237e-02f, 6.71560690e-02f, 1.99293233e-02f, 8.34054202e-02f, -6.61747083e-02f, 1.27412289e-01f,
  5.83655797e-02f, -9.24993157e-02f, -1.54394388e-01f, -1.11056402e-01f, -1.40193909e-01f, -9.71241295e-02f, -2.01278523e-01f, 1.64925769e-01f, 8.84279907e-02f, -1.16928183e-01f,
  -1.74903676e-01f, -1.52836461e-02f, 7.54804611e-02f, 2.71946713e-02f, 3.25668156e-02f, -1.93248913e-01f, -7.17347711e-02f, -1.97666809e-01f, 8.87840837e-02f, 1.94905415e-01f,
  8.81638564e-03f, 6.42958060e-02f, 1.36727672e-02f, -2.63164967e-01f, 4.42558900e-02f, -2.76598126e-01f, -1.79161265e-01f, -1.26536369e-01f, -1.54134080e-01f, -1.88056245e-01f,
  -2.56810244e-02f, -3.40844318e-02f, 8.82738754e-02f, -2.35315561e-02f, 2.83309400e-01f, 1.87744185e-01f, -8.70826766e-02f, 1.66795969e-01f, 1.19001500e-01f, 5.75008988e-02f,
  -1.58107296e-01f, -5.37623651e-02f, -1.59889579e-01f, -1.65282622e-01f, -1.60826042e-01f, -1.15263700e-01f, -2.03292742e-01f, 3.07083502e-02f, -1.39013663e-01f, -7.64093697e-02f,
  -5.70672229e-02f, 5.35402447e-02f, -2.37754621e-02f, -2.90998593e-02f, -1.74935013e-01f, 9.46377143e-02f, 5.27034290e-02f, -1.54233605e-01f, -1.84453711e-01f, 1.80775090e-03f,
  2.05458254e-01f, -3.71487578e-03f, -3.26822959e-02f, 4.07389663e-02f, -1.38795614e-01f, 1.21066734e-01f, 2.58640528e-01f, 5.57566918e-02f, -1.61063507e-01f, -7.30592310e-02f,
  -2.20425174e-01f, -4.06476203e-03f, 9.50246826e-02f, 4.47604209e-02f, -1.18587837e-01f, -1.27136782e-01f, -3.34365219e-01f, 7.18387216e-02f, -1.37970177e-02f, 1.45138443e-01f,
  -1.98594615e-01f, -1.06208846e-01f, 1.18633263e-01f, -1.68400258e-01f, -1.49301484e-01f, 2.36552164e-01f, -3.26684080e-02f, 8.91413018e-02f, -4.27881815e-02f, 3.73407900e-02f,
  6.31598234e-02f, -2.47325692e-02f, -4.18279804e-02f, -4.38250266e-02f, 1.73854738e-01f, -6.42580464e-02f, -1.32911921e-01f, -2.14360673e-02f, -3.44553262e-01f, -5.50875627e-02f,
  5.65276332e-02f, -1.98493093e-01f, -7.66917691e-03f, -9.88876447e-02f, 2.50982374e-01f, 1.23145329e-02f, -1.14824899e-01f, -1.18956037e-01f, 2.80851364e-01f, 7.21699968e-02f,
  -6.67536333e-02f, -1.07629597e-01f, -5.73167242e-02f, 4.11701165e-02f, 4.47321571e-02f, -1.55311199e-02f, 7.92895183e-02f, 1.23448513e-01f, 7.27763548e-02f, 4.96135280e-02f,
  6.98102117e-02f, -4.19583023e-02f, 9.57061127e-02f, -7.68961161e-02f, 1.67205304e-01f, -9.07791480e-02f, -1.75463378e-01f, 8.26348290e-02f, 4.64948118e-02f, -7.45853260e-02f,
  -2.13267595e-01f, -1.21832527e-01f, -3.02897096e-02f, 2.56641060e-01f, -2.01316923e-01f, 1.04351580e-01f, 2.05276936e-01f, 2.10401624e-01f, 3.34891006e-02f, -1.79238282e-02f,
  2.07772870e-02f, -7.25884810e-02f, 2.28714682e-02f, -3.60336527e-02f, 2.42180347e-01f, -2.33481809e-01f, 1.21304067e-02f, -3.60043421e-02f, -5.53250983e-02f, -1.76387310e-01f,
  -3.27928774e-02f, -3.15845609e-02f, -1.13539480e-01f, -3.41556482e-02f, -1.64116412e-01f, 2.71214042e-02f, 7.59372720e-03f, 1.57602802e-01f, -2.18512509e-02f, 1.70460343e-01f,
  3.36941965e-02f, 7.09848180e-02f, 1.88033968e-01f, 3.27027857e-01f, 1.09397598e-01f, -1.02523141e-01f, -9.90860313e-02f, 5.81179447e-02f, -1.94170102e-01f, -4.45872620e-02f,
  3.83485667e-02f, -5.00788465e-02f, 1.80565678e-02f, -1.87315829e-02f, -1.32729197e-02f, 6.71195537e-02f, 1.99257791e-01f, -1.03604905e-01f, 6.00107573e-02f, -5.06750904e-02f,
  7.39946663e-02f, 1.60331093e-03f, -9.76371393e-02f, -5.97852096e-02f, 3.84048782e-02f, 2.39270851e-02f, -3.62184756e-02f, 1.03865854e-01f, -9.68320891e-02f, 2.32306924e-02f,
  -4.82605537e-04f, 3.57516669e-02f, -6.38713166e-02f, -1.08398750e-01f, -1.06561463e-02f, -1.97645053e-01f, -2.09952474e-01f, -1.31198257e-01f, -1.92635790e-01f, 1.27489835e-01f,
  9.49266702e-02f, -1.07714243e-01f, 8.80223364e-02f, 1.59186497e-01f, 1.24870501e-01f, -3.46973613e-02f, 5.36484569e-02f, -1.61203504e-01f, 5.25225839e-03f, 2.54409220e-02f,
  -1.66277271e-02f, -1.65068619e-02f, -5.10877855e-02f, -1.69954412e-02f, 6.70736060e-02f, -1.49481878e-01f, -1.25704736e-01f, -1.63061008e-01f, 2.46338621e-02f, 1.05548976e-02f,
  2.72798836e-02f, -1.21391058e-01f, -3.02217137e-02f, 2.71223150e-02f, 2.02563494e-01f, -1.33319616e-01f, 1.95628610e-02f, 3.63133773e-02f, 1.39031649e-01f, 7.26163620e-03f,
  2.07556579e-02f, -5.29611222e-02f, -2.06580430e-01f, 1.56126037e-01f, -1.56882465e-01f, -3.47904593e-01f, 6.24208152e-02f, -1.88231971e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.02347285e-02f, 2.64082495e-02f, 1.75271422e-01f, -7.30952397e-02f, 1.32214397e-01f, -1.00316085e-01f, 2.40981624e-01f, 4.70840186e-02f, -3.08669508e-02f, 2.43013993e-01f,
  -7.86182359e-02f, 1.00235239e-01f, 2.97494262e-01f, 7.23065063e-02f, -1.65335268e-01f, 1.34414718e-01f, -5.99313304e-02f, 1.17127933e-01f, 6.42376840e-02f, -2.17030644e-01f,
  -4.95085381e-02f, -5.72365411e-02f, -3.00707698e-01f, -1.55637935e-02f, -9.57803428e-02f, 7.12428540e-02f, 1.25763923e-01f, 1.06383599e-01f, 1.79790050e-01f, -2.84853783e-02f,
  -6.16086870e-02f, 3.42645019e-01f, 4.09308597e-02f, -2.97593772e-01f, 1.20752610e-01f, -1.92457289e-01f, 2.35492941e-02f, 2.56214976e-01f, -1.37977481e-01f, -9.80804022e-03f,
  -7.14929774e-02f, -3.57887268e-01f, 2.51842082e-01f, -1.49517089e-01f, -1.55537829e-01f, 8.83134380e-02f, -1.39042869e-01f, -6.51565492e-02f, 2.49653265e-01f, 2.07506001e-01f,
  1.87136367e-01f, -2.37693578e-01f, 9.85660702e-02f, 8.96664560e-02f, 2.40638509e-01f, 1.69233695e-01f, -2.25440726e-01f, -1.27013564e-01f, -1.46320686e-01f, 1.34372681e-01f,
  -2.57166237e-01f, -2.00271294e-01f, -3.31641138e-01f, 1.54187500e-01f, 5.90820648e-02f, 1.05311781e-01f, 4.50006276e-02f, 2.03433976e-01f, 3.01500619e-03f, 1.03438154e-01f,
  4.86147553e-02f, 1.25741303e-01f, 4.27394994e-02f, 1.32514000e-01f, 1.81516498e-01f, 9.25855786e-02f, -1.78041711e-01f, -1.27306700e-01f, 1.16252437e-01f, -1.96397603e-01f,
  -1.13642953e-01f, 1.85654894e-01f, 9.63565037e-02f, 6.05770200e-02f, 9.46042594e-03f, 4.92226444e-02f, 1.94028825e-01f, -1.39926180e-01f, -7.82630220e-02f, 2.20695242e-01f,
  1.05794534e-01f, 1.09943897e-01f, -1.08303828e-03f, -1.82607770e-02f, -3.07389021e-01f, -1.07866652e-01f, 3.08420151e-01f, 3.42742614e-02f, -1.71949372e-01f, -2.88326412e-01f,
  -8.05879161e-02f, 1.66445076e-01f, 4.47539873e-02f, 1.57196224e-01f, 4.27955091e-02f, -2.07728803e-01f, -2.25084171e-01f, -2.17277572e-01f, 1.52385160e-01f, 3.68015140e-01f,
  1.21064775e-01f, -9.00304469e-04f, -1.70850798e-01f, -2.82895798e-03f, -2.70981431e-01f, 1.48288727e-01f, -5.03561497e-02f, -1.20793745e-01f, -2.79403150e-01f, 4.35761549e-02f,
  2.32747257e-01f, -1.78404346e-01f, 6.46138862e-02f, 2.25775652e-02f, -5.77225573e-02f, 1.42727360e-01f, 8.46817940e-02f, 7.79836497e-04f, 2.71694511e-01f, 6.91215470e-02f,
  7.07800612e-02f, 2.77127372e-04f, -1.79626257e-03f, 1.70217380e-01f, 6.01031445e-02f, 2.02267498e-01f, 2.91568249e-01f, 1.70818478e-01f, 2.01403052e-01f, 1.65997401e-01f,
  -5.63239753e-02f, -1.30174547e-01f, -7.72321075e-02f, -1.12287119e-01f, -6.68465570e-02f, -1.30395353e-01f, -9.51721147e-02f, 1.85401857e-01f, -7.20626712e-02f, -1.48334622e-01f,
  -1.39791369e-02f, 2.62299236e-02f, -2.12247238e-01f, 1.16241656e-01f, 3.06652244e-02f, -6.49480671e-02f, -1.80629134e-01f, -8.24601948e-02f, 1.94136411e-01f, -5.43420911e-02f,
  -9.26273502e-03f, 1.40631180e-02f, -1.82564154e-01f, 1.34956285e-01f, -1.13193803e-01f, -1.13307700e-01f, -9.05433372e-02f, -4.80372533e-02f, 6.48957714e-02f, 4.96535301e-02f,
  -8.69988427e-02f, 5.18175997e-02f, -5.56562357e-02f, 1.19395778e-01f, -1.18970737e-01f, -3.34588997e-02f, -7.31078759e-02f, -1.18570745e-01f, 1.12188980e-01f, 1.03509970e-01f,
  2.86140651e-01f, -4.89857197e-02f, -2.80194938e-01f, -1.27574816e-01f, 4.17623997e-01f, -1.46607786e-01f, -5.11360727e-02f, -1.35596275e-01f, -1.35146111e-01f, -1.49288043e-01f,
  5.54389581e-02f, 1.14643597e-03f, 2.36893773e-01f, 1.31740347e-01f, 1.51675284e-01f, 4.17593494e-03f, 1.14543028e-01f, 1.03375174e-01f, 1.24305703e-01f, 7.71079287e-02f,
  1.28364965e-01f, 1.36418894e-01f, 1.15322292e-01f, 1.61701694e-01f, 8.62566605e-02f, -9.18755829e-02f, -2.77993172e-01f, 2.15880722e-02f, 5.39881364e-02f, -2.40138307e-01f,
  9.30093825e-02f, -6.47798702e-02f, 2.67422259e-01f, 1.44302651e-01f, 1.02223285e-01f, 1.45538926e-01f, 7.87894502e-02f, 3.34270209e-01f, -1.61587700e-01f, 5.20628728e-02f,
  8.35341364e-02f, -2.83951372e-01f, -3.94226015e-02f, 1.32002458e-01f, -1.58970311e-01f, -2.53035665e-01f, 9.60036442e-02f, 1.19952254e-01f, 7.55911693e-02f, 2.53938109e-01f,
  8.93758610e-03f, -1.17967620e-01f, -3.69679220e-02f, 2.48785421e-01f, 1.30819485e-01f, 3.12383473e-01f, -1.40115485e-01f, 7.31979907e-02f, -2.17178781e-02f, 2.12382413e-02f,
  1.50087863e-01f, 1.40287802e-01f, -2.10149392e-01f, 2.67362177e-01f, 1.92024931e-01f, -1.87573522e-01f, -2.89545506e-01f, 1.61521554e-01f, -1.44199684e-01f, -3.00856568e-02f,
  2.40991682e-01f, 1.60273671e-01f, 1.68127179e-01f, 4.00699288e-01f, -1.09309822e-01f, 1.76623076e-01f, 1.92163840e-01f, 1.02703581e-02f, 1.14017814e-01f, 1.83552578e-01f,
  2.42411256e-01f, 2.80044675e-01f, -9.04723164e-03f, 6.10275567e-02f, 1.56396508e-01f, 1.45138830e-01f, 1.00045726e-01f, 2.23446283e-02f, 1.99078202e-01f, 3.44073959e-03f,
  2.81313807e-01f, -8.84698108e-02f, -1.99388266e-01f, -3.57647031e-03f, 6.95355609e-02f, 1.56477764e-01f, -4.31972980e-01f, -6.06818311e-03f, 1.01836488e-01f, -1.66086573e-02f,
  -4.08571698e-02f, 1.04481347e-01f, 1.68024600e-01f, 2.01465696e-01f, 1.00421719e-01f, 1.37004936e-02f, 1.84081569e-01f, -4.86839563e-02f, 1.96108863e-01f, -1.66506425e-01f,
  2.14267805e-01f, -2.08783433e-01f, -5.95705248e-02f, 1.11842275e-01f, -1.81106597e-01f, -9.88504291e-02f, -1.54388370e-02f, -1.60722926e-01f, -9.06706005e-02f, -1.29473105e-01f,
  -8.33603516e-02f, 2.60579348e-01f, -6.49567768e-02f, 5.36124595e-02f, -2.12678701e-01f, 1.20162763e-01f, 3.49258840e-01f, 2.39228249e-01f, 1.94260702e-01f, 2.71945685e-01f,
  -2.16380730e-01f, -1.50464773e-02f, 2.32672572e-01f, -3.71477343e-02f, -2.89465100e-01f, -5.89955859e-02f, 2.02282101e-01f, 2.51690820e-02f, 4.56103327e-04f, -2.02632174e-02f,
  -3.83129939e-02f, 5.64195476e-02f, 5.83224967e-02f, 1.03875637e-01f, 1.71523198e-01f, 1.17483549e-01f, 1.44338399e-01f, -1.04247192e-02f, 8.68518800e-02f, 4.01114188e-02f,
  6.79291710e-02f, 1.19945139e-01f, 3.08965653e-01f, -2.46178098e-02f, 2.30888918e-01f, -1.58665515e-02f, -1.22337379e-01f, 1.78411305e-01f, -3.58515307e-02f, 8.40259045e-02f,
  -1.05047010e-01f, -3.85202444e-03f, -1.81065295e-02f, 1.00840241e-01f, -9.44373459e-02f, 4.23701480e-02f, 2.67518193e-01f, 2.47458532e-01f, 1.21837065e-01f, -6.58454895e-02f,
  -5.57837449e-02f, 5.07276580e-02f, 2.04274103e-01f, -1.34307921e-01f, 7.55714700e-02f, 5.74808195e-02f, 1.76780391e-02f, 2.39538297e-01f, -2.67682914e-02f, -1.90570608e-01f,
  -2.10475177e-01f, -8.50407556e-02f, 2.47719631e-01f, 6.19870164e-02f, -7.58083463e-02f, -1.15700625e-01f, -1.32985845e-01f, -1.44393714e-02f, 1.62589043e-01f, 2.03201890e-01f,
  1.80650294e-01f, 1.42055705e-01f, 2.89150000e-01f, 4.85609509e-02f, 4.50658286e-03f, 1.43660679e-01f, -1.85642481e-01f, -2.40560234e-01f, -1.04753911e-01f, 3.16927396e-02f,
  6.40349463e-02f, 1.38639092e-01f, -5.28219268e-02f, -7.94213042e-02f, -3.86983044e-02f, 1.30006269e-01f, 2.66517520e-01f, 4.14314978e-02f, 4.85246591e-02f, 1.54648006e-01f,
  1.73313126e-01f, 7.88756162e-02f, 3.50678526e-02f, 2.21046120e-01f, 7.21813068e-02f, 2.97009274e-02f, 2.26581916e-01f, -1.46742156e-02f, 1.08742654e-01f, 1.38141543e-01f,
  8.78883377e-02f, -3.46278809e-02f, 4.18130830e-02f, 3.15509699e-02f, -9.46287140e-02f, -1.69526979e-01f, -1.36539772e-01f, 1.24694467e-01f, -4.64142449e-02f, -2.57438332e-01f,
  5.47286235e-02f, -9.56925303e-02f, 2.53864944e-01f, -6.57795668e-02f, -1.30144566e-01f, 7.64517412e-02f, 4.61441912e-02f, 8.39481205e-02f, 1.22101471e-01f, 2.19637856e-01f,
  1.85677424e-01f, 3.29357237e-02f, -1.60825968e-01f, -3.76376092e-01f, -7.73117989e-02f, -2.73831673e-02f, 3.76879692e-01f, 4.72800910e-01f, 6.79489877e-03f, 1.22833394e-01f,
  1.84980053e-02f, -1.68976292e-01f, 1.21396519e-01f, 1.46610796e-01f, 2.89754003e-01f, -1.11630514e-01f, 3.26826513e-01f, 3.55975479e-02f, 1.09263726e-01f, 7.79162794e-02f,
  -2.25233473e-02f, -1.41782790e-01f, 4.03455161e-02f, 9.54290926e-02f, -5.40570505e-02f, -2.53356814e-01f, -8.28902870e-02f, 1.23767033e-01f, -8.03784505e-02f, -2.36944646e-01f,
  6.15993999e-02f, -6.26148731e-02f, 2.06301436e-01f, 1.87099595e-02f, -1.65651657e-03f, 1.31999925e-01f, 4.49596383e-02f, -1.63759068e-02f, 1.40555635e-01f, 1.51405945e-01f,
  2.18756199e-01f, -4.26623523e-02f, 2.17120394e-01f, -1.33717703e-02f, -2.22225130e-01f, 4.14451025e-02f, -1.42305046e-01f, -1.00413159e-01f, -4.23186392e-01f, -9.46852267e-02f,
  8.25331509e-02f, 6.32951409e-02f, -1.30237028e-01f, 7.52562508e-02f, 2.63971180e-01f, 1.60561547e-01f, 1.26622424e-01f, -6.06884249e-02f, -6.32967651e-02f, -1.68360546e-01f,
  1.18129395e-01f, 1.29089415e-01f, 1.94252476e-01f, -1.67236298e-01f, 5.21458164e-02f, 5.35065169e-03f, -6.80754855e-02f, 1.75891846e-01f, -2.72597373e-02f, -1.01041883e-01f,
  5.70109300e-03f, -1.70581460e-01f, -1.38736367e-01f, -7.13027194e-02f, -9.33467075e-02f, 1.81092411e-01f, -1.30484000e-01f, 5.18045165e-02f, 2.57599741e-01f, 1.07904039e-01f,
  1.72725081e-01f, 8.76534209e-02f, 1.97045386e-01f, -1.05647109e-01f, 1.41309574e-01f, -7.03378022e-03f, -3.13314237e-02f, -1.35009393e-01f, -2.97358129e-02f, 7.61328861e-02f,
  1.35832965e-01f, -5.04845269e-02f, -1.90684155e-01f, -1.20106272e-01f, 9.32640508e-02f, -1.01853140e-01f, 1.11717381e-01f, -6.64202124e-02f, 2.32382938e-01f, 1.42578378e-01f,
  1.28340526e-02f, -1.11857593e-01f, -4.07816060e-02f, 1.00038666e-02f, 2.13094249e-01f, 7.44581372e-02f, -6.06047809e-02f, 1.15863137e-01f, -1.07714467e-01f, 3.35455406e-03f,
  -3.62846740e-02f, -8.84098709e-02f, -1.57126650e-01f, -9.89670604e-02f, -9.24935415e-02f, 8.10855404e-02f, 9.77549236e-03f, -2.62275517e-01f, 4.85091545e-02f, -5.80187663e-02f,
  3.18886638e-01f, 1.19109958e-01f, 8.10512453e-02f, 1.40659392e-01f, 1.25777915e-01f, 1.75317392e-01f, 1.88948750e-01f, 1.08067900e-01f, -3.97019833e-02f, 1.96489379e-01f,
  -6.72109937e-03f, -1.34323284e-01f, -1.10572308e-01f, -8.38992223e-02f, 3.22170377e-01f, 8.27668235e-02f, 1.75795317e-01f, 5.00864945e-02f, 1.30959570e-01f, 2.24455483e-02f,
  -2.93450914e-02f, 1.96701318e-01f, 2.97588557e-01f, 3.99751253e-02f, 1.25058115e-01f, 2.53506303e-01f, 7.11059123e-02f, 3.17327864e-02f, -2.16326602e-02f, -1.61663145e-01f,
  -1.28222078e-01f, -6.82142237e-03f, 5.45373112e-02f, -9.65557620e-02f, -5.33000454e-02f, -3.63600738e-02f, -1.59719922e-02f, 1.68342113e-01f, -1.95411071e-01f, -9.60690156e-03f,
  -4.31828462e-02f, -5.28525114e-02f, 3.39712761e-02f, -3.01825237e-02f, 1.75155059e-01f, 1.08109623e-01f, -3.99031192e-02f, 2.64436053e-03f, -1.35894954e-01f, -4.39337008e-02f,
  1.78129300e-01f, 8.95162765e-03f, -7.99427703e-02f, -7.75830597e-02f, -1.18271923e-02f, -6.12359531e-02f, -1.25632703e-01f, 1.42147332e-01f, 1.83581829e-01f, 2.36016557e-01f,
  -9.18907747e-02f, 6.13429211e-02f, 2.33075112e-01f, 2.91141391e-01f, -3.84317413e-02f, -1.19328186e-01f, -2.24008877e-02f, -1.63226098e-01f, -2.48235464e-01f, 2.61553943e-01f,
  1.81058675e-01f, -6.59304261e-02f, 8.85941386e-02f, -3.54246236e-03f, 5.67059889e-02f, 1.75349131e-01f, 1.55052900e-01f, -3.23686004e-02f, 1.87063627e-02f, 3.80101614e-02f,
  3.31528544e-01f, -8.68379548e-02f, 1.33090317e-01f, 2.17071950e-01f, -1.93061382e-01f, 9.60554481e-02f, -1.83140993e-01f, 2.08495513e-01f, 1.77486435e-01f, -1.67337179e-01f,
  -1.70199513e-01f, 1.05390079e-01f, 2.75478840e-01f, 1.37708530e-01f, 9.26854014e-02f, -3.33507001e-01f, 3.76194939e-02f, 1.19368747e-01f, 3.47155005e-01f, -1.68892294e-01f,
  7.91574642e-02f, 4.82356176e-02f, -3.45432758e-02f, 5.78781590e-02f, 1.62042797e-01f, -4.71916329e-03f, 1.30125597e-01f, 2.76836663e-01f, 1.94190025e-01f, 1.41931787e-01f,
  1.47471055e-01f, 2.12153807e-01f, -2.05102786e-01f, 8.98027197e-02f, 1.51891887e-01f, 1.24193527e-01f, 1.53319299e-01f, 1.25740603e-01f, -9.96825546e-02f, -2.59971946e-01f,
  1.14117816e-01f, 3.11113656e-01f, 1.41195834e-01f, -1.38629070e-02f, -3.14520895e-01f, 3.60141844e-01f, 2.76988089e-01f, 1.56431407e-01f, -1.05034120e-01f, -2.19822247e-02f,
  -2.85541207e-01f, 1.57098342e-02f, -1.94092751e-01f, 7.60226399e-02f, -1.27798259e-01f, -2.77572304e-01f, -5.67419268e-03f, 8.63663852e-02f, -1.31843641e-01f, 4.30566072e-01f,
  1.02491930e-01f, -4.92460690e-02f, 6.26549721e-02f, -1.67227555e-02f, 3.05752885e-02f, -9.71113145e-02f, -2.42565088e-02f, 1.41996071e-01f, -8.91379490e-02f, 1.78900108e-01f,
  -4.02747601e-01f, 4.01528142e-02f, 1.63764417e-01f, -5.13295904e-02f, -1.98040530e-01f, 3.24847214e-02f, 1.28677323e-01f, 1.32801738e-02f, 5.00561893e-02f, 8.87928754e-02f,
  -1.63307771e-01f, 1.32193819e-01f, 1.48623243e-01f, 6.69595897e-02f, 8.16123635e-02f, 1.32055402e-01f, 3.06057762e-02f, -1.13173433e-01f, 2.25222819e-02f, 1.12779476e-02f,
  4.09663692e-02f, 3.15556303e-02f, -1.87465549e-02f, 1.07803778e-03f, 2.70627793e-02f, 1.47888258e-01f, 1.95433453e-01f, -1.44825563e-01f, -1.30749181e-01f, 4.99413349e-03f,
  -6.53394833e-02f, -6.63696080e-02f, -1.31652132e-01f, 7.96751454e-02f, 5.71619794e-02f, -1.59134328e-01f, 9.53892916e-02f, 1.65202931e-01f, 1.86139628e-01f, -1.64802417e-01f,
  -1.70193747e-01f, -9.72216576e-02f, 6.82339743e-02f, 8.45275298e-02f, 2.85155684e-01f, -2.65537918e-01f, -1.30492285e-01f, -7.05785677e-02f, 2.37297773e-01f, 3.62328708e-01f,
  -7.72432089e-02f, -1.00054190e-01f, 4.55409475e-03f, -1.66601852e-01f, -7.72547051e-02f, 4.10715044e-01f, -1.34540396e-02f, 3.11997384e-01f, -1.60404369e-01f, 3.74775566e-02f,
  3.29025760e-02f, 8.80463943e-02f, -1.94533870e-01f, 1.44048840e-01f, 2.72786260e-01f, 5.39894626e-02f, 1.02371074e-01f, 1.05994880e-01f, 5.49160205e-02f, -1.45264834e-01f,
  -2.26563692e-01f, 1.64323702e-01f, 1.06097929e-01f, 1.67522579e-01f, 2.44592845e-01f, -9.66336951e-02f, -6.20758273e-02f, 4.17766608e-02f, 2.51529247e-01f, 1.52703553e-01f,
  1.13823138e-01f, 3.17507945e-02f, -1.56035200e-01f, -1.83742478e-01f, 7.67528862e-02f, -9.97766200e-03f, 7.97852874e-02f, 4.21594083e-02f, 8.98161530e-02f, 4.85092774e-02f,
  -7.03557655e-02f, 9.38809291e-02f, 1.65914744e-01f, 3.11752185e-02f, -2.54579425e-01f, -9.06562582e-02f, 1.55212417e-01f, 1.72771290e-02f, -2.96691269e-01f, -1.24381088e-01f,
  -1.35725275e-01f, -8.99669826e-02f, 1.52773365e-01f, -1.03379190e-01f, -3.78076255e-01f, -1.87796891e-01f, -1.86312363e-01f, -5.68460971e-02f, 3.66646260e-01f, 4.48121876e-02f,
  -3.80680077e-02f, 1.12288132e-01f, -3.13166119e-02f, -1.63994819e-01f, 1.05722837e-01f, -2.89503019e-02f, -1.50216058e-01f, 1.13411479e-01f, 1.15264855e-01f, -3.68118882e-01f,
  6.90677436e-03f, -3.09946328e-01f, 7.42370263e-02f, 4.78858836e-02f, -1.84425801e-01f, -1.22037701e-01f, -1.74098626e-01f, -3.13133478e-01f, -3.45600732e-02f, -2.12114617e-01f,
  1.28596738e-01f, 2.03942627e-01f, 3.43368426e-02f, 2.88264126e-01f, 4.54191118e-01f, 2.50940144e-01f, -1.26867471e-02f, -8.48847404e-02f, -1.02204479e-01f, -2.85081938e-03f,
  2.55864114e-02f, -2.11013779e-01f, 1.24618188e-01f, 2.59868354e-02f, 1.15645356e-01f, 7.03839865e-03f, 1.43971235e-01f, 1.34467751e-01f, 9.70819592e-02f, 1.71457112e-01f,
  1.83543667e-01f, 6.98537081e-02f, 1.59698278e-01f, 1.88245729e-01f, -2.38238513e-01f, -9.00017843e-02f, 2.57051755e-02f, -1.24776997e-01f, -3.83525644e-03f, 5.30299395e-02f,
  -9.80322734e-02f, 1.44604102e-01f, 5.97007498e-02f, -1.19543031e-01f, 6.20717295e-02f, -5.98647371e-02f, -4.24215570e-03f, 2.57220149e-01f, -8.93057883e-02f, -4.78221476e-02f,
  -9.01682973e-02f, 1.63011197e-02f, -9.03574601e-02f, -1.66763783e-01f, -5.79201281e-02f, -7.69743323e-02f, -1.38237298e-01f, -9.52743925e-03f, -2.08916869e-02f, -8.16744044e-02f,
  9.16844010e-02f, 8.85341391e-02f, -1.96463093e-01f, 3.11552823e-01f, -5.75437816e-03f, -5.10168560e-02f, -2.23787189e-01f, 3.28420162e-01f, -4.63162847e-02f, 2.63307765e-02f,
  -1.26385912e-01f, -1.58300728e-01f, 5.15954308e-02f, 6.18085936e-02f, 2.92480290e-02f, 1.54131815e-01f, -2.57299036e-01f, -1.79357305e-01f, 2.02362344e-01f, -1.71400681e-01f,
  -1.43061996e-01f, -1.66664153e-01f, -3.81619930e-02f, -3.31350951e-03f, 7.89230466e-02f, -9.84473526e-02f, -1.61722258e-01f, -1.81303583e-02f, -6.06417879e-02f, 1.71259064e-02f,
  -1.98356248e-03f, 8.86521861e-02f, 9.24229398e-02f, -1.11207571e-02f, -3.46734524e-02f, 3.60046700e-02f, -1.42144531e-01f, 2.92045367e-03f, 1.78736910e-01f, 3.80828492e-02f,
  -7.70084485e-02f, 3.35741006e-02f, -6.34832904e-02f, 1.13961086e-01f, 1.07784858e-02f, -1.35232672e-01f, -1.60129026e-01f, 1.01940453e-01f, 3.73044307e-03f, 5.88372489e-03f,
  -8.53931978e-02f, -5.01785986e-03f, 2.26532131e-01f, -5.23450300e-02f, 2.01171011e-01f, 1.75569966e-01f, -1.38988450e-01f, 1.38866315e-02f, 2.00237200e-01f, -1.32844388e-01f,
  1.76187679e-01f, -1.48178935e-01f, -4.29955311e-02f, 1.60559714e-01f, 1.31341547e-01f, -3.10227752e-01f, -1.57720089e-01f, 3.23165283e-02f, -2.40369048e-02f, 5.27623519e-02f,
  -8.10708702e-02f, -5.86889349e-02f, 1.17601939e-02f, 1.76617682e-01f, 2.79668416e-03f, 2.90634900e-01f, 8.66651386e-02f, -5.95797263e-02f, 1.46615684e-01f, 2.32276499e-01f,
  2.38294274e-01f, 1.29299626e-01f, -2.96556324e-01f, 4.14962135e-02f, -4.32750344e-01f, 2.12715305e-02f, -5.34571521e-02f, -8.81518796e-02f, 4.34158631e-02f, 2.65815351e-02f,
  2.38842204e-01f, 5.91151789e-02f, 1.92479685e-01f, 1.64100781e-01f, 6.67967126e-02f, -8.30012746e-03f, 1.80580094e-01f, 5.23901917e-02f, 6.59223720e-02f, 9.15433243e-02f,
  4.32103835e-02f, 5.89846782e-02f, -1.67783037e-01f, -1.51803121e-01f, -2.77534604e-01f, -4.41002659e-02f, 1.46192029e-01f, 2.43508723e-02f, 3.10152844e-02f, -2.88337842e-02f,
  8.37522298e-02f, -1.21367574e-01f, -1.58505708e-01f, -7.89353475e-02f, -1.78801149e-01f, 1.14954360e-01f, -3.01380485e-01f, -3.01119328e-01f, -1.06090233e-01f, 7.65195414e-02f,
  2.85425514e-01f, 2.32467055e-01f, 1.33506089e-01f, -1.43655926e-01f, -2.75758095e-02f, 1.56559840e-01f, -1.65201370e-02f, 3.22485238e-01f, -1.19093053e-01f, -4.54821438e-02f,
  1.60674423e-01f, 2.58232921e-01f, 1.33537129e-01f, -7.21327886e-02f, -7.88834244e-02f, 3.09135556e-01f, 6.51605576e-02f, -8.37039649e-02f, 2.30857357e-01f, -1.97244957e-01f,
  7.60538876e-02f, -2.57237777e-02f, 1.39332741e-01f, 1.73231820e-03f, 9.01195109e-02f, -3.74811999e-02f, -2.20202710e-02f, 6.28715977e-02f, 1.14864446e-02f, 2.28744954e-01f,
  1.59002990e-01f, -3.43885094e-01f, -2.81171858e-01f, 2.53426611e-01f, 2.74753217e-02f, 1.20900743e-01f, 3.02415341e-02f, -5.33492751e-02f, 4.68882173e-02f, -2.42611114e-02f,
  1.18761167e-01f, 4.23003547e-02f, 2.14741454e-01f, 2.30717123e-01f, 7.12008402e-02f, 1.35866135e-01f, 2.86388509e-02f, 6.94077462e-02f, -1.60678297e-01f, 5.31392694e-02f,
  -5.18047251e-02f, -1.16808554e-02f, 9.17771310e-02f, -2.70472407e-01f, 3.90726030e-02f, -1.45022914e-01f, 8.96098986e-02f, 1.82807609e-01f, -1.19899370e-01f, 2.17393681e-01f,
  -2.29506698e-02f, 1.78017933e-02f, 8.97239968e-02f, -2.92679518e-01f, 6.44622669e-02f, 6.72434941e-02f, -2.08241343e-01f, -1.30377993e-01f, 6.93660006e-02f, 3.21426578e-02f,
  7.61037767e-02f, 2.73133934e-01f, -7.51280189e-02f, 2.07685500e-01f, 1.20904585e-02f, -2.00138450e-01f, 1.16146490e-01f, -2.06035584e-01f, 6.72361925e-02f, -3.03837985e-01f,
  -1.26269624e-01f, -2.66498893e-01f, -7.85811804e-03f, -1.57765344e-01f, -2.37491235e-01f, -1.70364723e-01f, 3.38887751e-01f, -5.50094340e-03f, -1.67516664e-01f, 2.41728812e-01f,
  -2.29311008e-02f, 3.03994920e-02f, 9.95365828e-02f, 5.97886089e-03f, -2.19386905e-01f, -2.98904385e-02f, -4.61212061e-02f, 3.98703329e-02f, 2.61500120e-01f, 7.53899571e-03f,
  2.59018205e-02f, 1.60940409e-01f, 2.84489971e-02f, 2.20189258e-01f, 1.62801400e-01f, 1.48763478e-01f, 2.00132951e-01f, 1.71017557e-01f, 1.33593589e-01f, 6.07667118e-02f,
  -2.20126361e-01f, -5.73890731e-02f, -1.21467039e-01f, 3.59580331e-02f, -3.22032757e-02f, -1.63639411e-01f, 1.88176498e-01f, 1.14994198e-01f, 2.18193412e-01f, -1.79592282e-01f,
  -7.93514550e-02f, 1.00427888e-01f, 1.05037846e-01f, -2.70033121e-01f, -4.38837469e-01f, -2.21462652e-01f, -1.37958512e-01f, -1.76682115e-01f, 2.96514630e-01f, 1.37646049e-01f,
  -9.49495882e-02f, 7.81237856e-02f, -1.45440027e-01f, 2.36115366e-01f, -2.70534512e-02f, 1.15722612e-01f, 1.12098493e-02f, 1.64777964e-01f, 2.19482526e-01f, 1.24291077e-01f,
  -3.44109014e-02f, 9.00166780e-02f, 3.72467116e-02f, 3.96606177e-02f, -9.66384113e-02f, -1.44354194e-01f, 2.07214966e-01f, -3.46661359e-01f, 3.56163718e-02f, -3.79548408e-02f,
  2.33864933e-02f, -6.15502372e-02f, -6.25401735e-02f, 1.70989126e-01f, 1.75522760e-01f, 9.00320038e-02f, 3.78681451e-01f, -2.80848704e-02f, 2.87171006e-01f, -5.44849783e-02f,
  1.06315807e-01f, 1.52210295e-01f, 2.53041554e-02f, 1.39387930e-02f, 8.78734961e-02f, 7.56632164e-02f, 1.81105956e-02f, 1.46722704e-01f, -1.98095053e-01f, -4.04323824e-03f,
  6.61648288e-02f, 1.48058102e-01f, 4.04355042e-02f, 7.76393116e-02f, -6.45672977e-02f, 4.55101989e-02f, -2.08823398e-01f, 1.02410339e-01f, 6.17851838e-02f, -3.82443964e-02f,
  1.00596778e-01f, 1.13247726e-02f, 8.92619118e-02f, -1.17074475e-01f, 7.16070384e-02f, -2.11761482e-02f, 1.14567757e-01f, 1.03613846e-01f, -3.06707583e-02f, -8.76517594e-02f,
  1.83585733e-02f, -1.30072415e-01f, 9.14561376e-02f, 2.55435240e-02f, 2.35597640e-02f, -7.63550103e-02f, -1.42803103e-01f, 1.69835433e-01f, -1.64614081e-01f, 1.27599448e-01f,
  3.12438071e-01f, 2.58444920e-02f, -2.02399537e-01f, -1.30000934e-01f, -2.18689814e-01f, 5.13063408e-02f, -2.22306266e-01f, -1.93178609e-01f, -5.18687218e-02f, -3.34531456e-01f,
  -2.41918843e-02f, -2.11036712e-01f, -5.31443506e-02f, -2.72918135e-01f, 3.30515563e-01f, -1.82615653e-01f, 1.05264753e-01f, 3.08845729e-01f, -2.07980610e-02f, 3.72366272e-02f,
  4.02138494e-02f, 2.20969647e-01f, -1.53421104e-01f, 1.44657984e-01f, -9.18661356e-02f, 6.10056445e-02f, -2.92617958e-02f, 8.59944448e-02f, 1.81141883e-01f, 3.50002423e-02f,
  2.63071507e-01f, 1.69992685e-01f, 3.47278677e-02f, 8.11790451e-02f, 1.59217611e-01f, 1.32602990e-01f, 1.78244784e-01f, 7.74641559e-02f, 5.12421206e-02f, -3.55006643e-02f,
  1.71903566e-01f, 4.11513634e-02f, -5.07865064e-02f, 9.82763916e-02f, -8.23353650e-04f, -1.01624072e-01f, -1.89183414e-01f, 4.17537205e-02f, -1.03641964e-01f, 2.03074533e-02f,
  -3.82413983e-01f, 4.80015464e-02f, 3.75304163e-01f, 1.79491773e-01f, 1.77419484e-02f, -8.12563300e-02f, -1.75600871e-01f, 3.35629284e-01f, 2.46196643e-01f, -2.09758710e-02f,
  8.52394700e-02f, -1.02953017e-01f, 6.89915866e-02f, 1.37985334e-01f, -5.27577242e-03f, 3.36861551e-01f, -2.19963565e-02f, -1.70332547e-02f, -1.63952127e-01f, -1.87144473e-01f,
  -2.45087534e-01f, -1.04733864e-02f, -1.53831333e-01f, 4.87746038e-02f, 1.93322673e-01f, 1.55006677e-01f, 7.07991198e-02f, 9.29194763e-02f, -4.09371741e-02f, 3.72145444e-01f,
  8.80356431e-02f, -2.04574704e-01f, 9.34743695e-03f, -1.14386655e-01f, 6.51903749e-02f, 5.97379059e-02f, -9.33717638e-02f, 3.74425873e-02f, -4.70706746e-02f, 1.45387396e-01f,
  1.12674735e-01f, 2.93895882e-02f, 2.23755781e-02f, 8.94942507e-02f, -5.99155389e-03f, 1.92226186e-01f, -3.14572453e-02f, -2.11958662e-02f, 8.86489153e-02f, -5.79791889e-02f,
  1.62350714e-01f, 1.58115551e-01f, -9.04972553e-02f, -1.69668108e-01f, -4.56208661e-02f, -1.39476165e-01f, 1.84971601e-01f, -4.20715809e-02f, -5.10973968e-02f, 1.46940082e-01f,
  1.84044585e-01f, 1.28596768e-01f, 2.27882802e-01f, -1.35761648e-01f, 1.31746709e-01f, 1.60099879e-01f, -1.74165055e-01f, 1.94545791e-01f, 1.06180400e-01f, 2.92315260e-02f,
  6.83201104e-02f, -1.23120673e-01f, -1.51228219e-01f, 2.48803198e-01f, -5.95030114e-02f, 2.41079945e-02f, 1.86481819e-01f, -2.46805370e-01f, -3.15243453e-02f, 9.69596133e-02f,
  1.55553132e-01f, 2.65103102e-01f, 9.56938490e-02f, 2.35503018e-01f, -1.12558557e-02f, 1.29812554e-01f, 1.33680673e-02f, 1.90675423e-01f, 2.14134246e-01f, 1.15958817e-01f,
  -3.80212814e-02f, 1.96163312e-01f, -1.31864548e-01f, -1.90274015e-01f, -2.64125943e-01f, -8.87065753e-02f, -1.98698699e-01f, 3.74764986e-02f, 2.90121973e-01f, -1.18277699e-01f,
  2.55430341e-01f, 3.45913410e-01f, 2.27203622e-01f, 8.72043148e-02f, -1.13406666e-01f, -5.42074814e-02f, -1.83426682e-02f, -2.12284755e-02f, 6.96554640e-03f, 2.06912588e-02f,
  6.77011311e-02f, 7.35915303e-02f, 8.51877555e-02f, -7.41517991e-02f, -5.56803588e-03f, -1.36870325e-01f, 1.09177649e-01f, 1.78924412e-01f, 7.73177147e-02f, 1.27892137e-01f,
  -2.95478087e-02f, -5.25367260e-02f, 1.11258656e-01f, -8.45382165e-04f, -1.29913330e-01f, 2.46184086e-03f, 8.86507407e-02f, 1.07321084e-01f, 1.23412088e-01f, -1.46641836e-01f,
  -1.80146694e-01f, -9.91109982e-02f, -2.95954108e-01f, 1.76162109e-01f, 6.07447661e-02f, 5.28580882e-02f, 5.42046614e-02f, 1.51152313e-01f, -5.71473576e-02f, 6.82746693e-02f,
  1.12301141e-01f, -1.29037529e-01f, -3.90664227e-02f, -2.78040208e-02f, -7.07190856e-02f, -1.20831914e-01f, 3.22102070e-01f, 1.11018665e-01f, 3.61465842e-01f, -1.87043816e-01f,
  2.57891476e-01f, -9.80173275e-02f, -6.53631464e-02f, 8.06187466e-02f, -1.01807795e-01f, 7.39675239e-02f, -1.21460564e-01f, -1.65479928e-01f, -2.71891020e-02f, 1.81222484e-01f,
  1.19956784e-01f, -3.60208675e-02f, -3.09037566e-02f, 7.96044990e-02f, 1.08359940e-01f, 1.11428965e-02f, 7.79653117e-02f, -4.24644388e-02f, -3.48101370e-02f, -2.91140261e-03f,
  2.25488357e-02f, 7.13184848e-02f, 2.74679698e-02f, 9.80773196e-02f, -5.10472618e-02f, 1.38235226e-01f, 4.92131636e-02f, -3.61074917e-02f, -5.54132462e-02f, -1.80718061e-02f,
  6.54436573e-02f, 2.80399583e-02f, -2.69454084e-02f, 1.00229867e-01f, -1.68784991e-01f, -1.02571547e-01f, -3.45300734e-02f, -1.56063259e-01f, -3.32472473e-02f, 5.92777990e-02f,
  -8.52029994e-02f, 7.43913651e-02f, -2.13162079e-02f, 2.17438489e-02f, -1.22359283e-01f, -7.03356713e-02f, -4.31717858e-02f, 7.19262287e-02f, 3.98096770e-01f, -1.27482796e-02f,
  -7.69494846e-02f, 5.44370823e-02f, -1.13873646e-01f, 2.22842526e-02f, 1.25390291e-01f, -3.35680991e-02f, -6.00950501e-04f, 1.89113498e-01f, 3.30350548e-01f, -1.09254017e-01f,
  -3.16341631e-02f, -1.61813289e-01f, 4.67833094e-02f, -2.90042818e-01f, 1.14807799e-01f, -2.10550576e-02f, 2.22696289e-01f, -1.50058065e-02f, 1.28176823e-01f, 3.74329500e-02f,
  -3.31076235e-01f, -2.01872841e-01f, 1.28932789e-01f, -7.24499056e-04f, 1.25231579e-01f, 2.47828722e-01f, -2.66088033e-03f, -1.07301548e-01f, 8.23007077e-02f, -1.50429547e-01f,
  2.66947418e-01f, -7.59818852e-02f, -9.51380134e-02f, 5.98731264e-02f, 1.41837433e-01f, 2.15346649e-01f, 1.71288222e-01f, 4.60219197e-02f, 1.19208194e-01f, 5.02892137e-02f,
  6.53153211e-02f, 2.70970106e-01f, 1.33510157e-01f, 2.37413302e-01f, -1.10654965e-01f, 8.98207948e-02f, 1.14924572e-01f, 2.49206185e-01f, -1.21836394e-01f, -1.18670192e-04f,
  1.77760273e-01f, -1.15908422e-01f, 1.40684322e-01f, 9.84787568e-02f, -1.75141558e-01f, -1.88215915e-02f, 2.18968615e-02f, -1.32803693e-01f, 6.16451800e-02f, 1.09491892e-01f,
  1.81589574e-01f, -2.31885970e-01f, 4.20976393e-02f, 3.07801306e-01f, -9.42996293e-02f, 9.67360884e-02f, 1.14858150e-01f, 1.47179708e-01f, 8.68540108e-02f, 1.01607524e-01f,
  -3.92722897e-02f, 2.38056645e-01f, -3.73947471e-02f, -1.19420104e-01f, -1.02910146e-01f, 1.73840910e-01f, -4.44202637e-03f, -1.50829136e-01f, -7.60474280e-02f, -2.40918264e-01f,
  2.70354956e-01f, 1.85088187e-01f, 1.71135608e-02f, -2.09219530e-01f, -5.57964221e-02f, 5.65024279e-02f, 1.49614990e-01f, 1.56051144e-01f, -6.12581521e-03f, -5.96404299e-02f,
  4.01519030e-01f, -8.75549838e-02f, 2.49160212e-02f, 2.13677898e-01f, 1.28047973e-01f, -6.27142861e-02f, 1.20866045e-01f, 1.49557695e-01f, 1.01192392e-01f, 1.85393319e-01f,
  1.72304824e-01f, 3.01168293e-01f, 1.11167431e-01f, 9.07795653e-02f, 1.74456060e-01f, 1.00829057e-01f, -5.85493445e-02f, 3.16244885e-02f, 1.55035719e-01f, 2.26915199e-02f,
  1.16236039e-01f, 8.67137313e-02f, 1.45856515e-01f, 8.65940377e-02f, 1.27806431e-02f, 2.72615440e-02f, 6.76623061e-02f, 1.45521820e-01f, 4.98906337e-02f, 7.17841014e-02f,
  1.67478924e-03f, -1.00432569e-02f, 2.68115669e-01f, 2.71716088e-01f, 2.41913289e-01f, 2.06097975e-01f, -6.53700978e-02f, -2.02231944e-01f, -2.10362226e-01f, 1.30413994e-01f,
  2.20926568e-01f, 1.62424251e-01f, 1.26824483e-01f, -6.98914528e-02f, -2.31127627e-02f, -7.69603178e-02f, -1.25371888e-01f, 2.73661137e-01f, 2.52749234e-01f, 1.93983316e-01f,
  1.06635533e-01f, -9.84270722e-02f, -3.61286812e-02f, 5.95093630e-02f, 2.09549796e-02f, 2.81291693e-01f, 2.00159699e-02f, 4.71664183e-02f, 1.08989239e-01f, 1.70282051e-01f,
  3.50811109e-02f, 5.28714247e-02f, -1.61664531e-01f, 3.08358241e-02f, 2.51050740e-02f, -6.78071156e-02f, 2.00367838e-01f, 3.38310301e-01f, 1.72486499e-01f, -8.35348368e-02f,
  1.14954822e-01f, 2.86393762e-02f, 3.98773775e-02f, -1.25216693e-01f, 7.30654374e-02f, 1.86430737e-01f, -3.47878560e-02f, 1.28584266e-01f, 2.31029421e-01f, 1.86721846e-01f,
  1.08859912e-01f, 1.91951305e-01f, 3.18614602e-01f, -6.58721924e-02f, -2.10298941e-01f, 2.68831514e-02f, 4.41834256e-02f, -5.80430999e-02f, 4.70943302e-02f, -4.85995673e-02f,
  1.86183512e-01f, 2.66931579e-02f, 2.09743038e-01f, 4.14814986e-02f, 3.98787528e-01f, 3.44459042e-02f, -9.70083252e-02f, -4.77390029e-02f, 8.92719030e-02f, -9.04484186e-03f,
  1.66928947e-01f, -6.68587759e-02f, -1.19557545e-01f, -1.20737225e-01f, 8.38461891e-02f, 3.35820705e-01f, 7.18857124e-02f, 1.22268543e-01f, 1.94269493e-02f, -1.92257434e-01f,
  -2.12703526e-01f, 1.72519267e-01f, 9.62104127e-02f, 3.91598284e-01f, 4.85380106e-02f, 7.26417406e-03f, -1.29432395e-01f, -4.97883484e-02f, 2.69396715e-02f, 5.69110662e-02f,
  -8.82371739e-02f, -2.11739726e-02f, 3.59206647e-01f, -1.78828329e-01f, -3.24456185e-01f, 3.59647602e-01f, -6.41442761e-02f, 4.92953248e-02f, 3.38428803e-02f, -3.18005565e-03f,
  8.98525417e-02f, 3.80762458e-01f, -1.72562554e-01f, -5.48613183e-02f, -1.97465960e-02f, 2.02720705e-02f, 6.23291060e-02f, -2.02354062e-02f, 7.97839388e-02f, 7.10360333e-02f,
  1.09353915e-01f, -3.07151536e-03f, -3.07850353e-02f, -1.12569161e-01f, -2.73360908e-02f, -1.08681060e-01f, -1.68993011e-01f, 1.95514068e-01f, -8.77393186e-02f, -7.15841800e-02f,
  1.66970521e-01f, 1.49523705e-01f, -1.24962516e-01f, -7.37110451e-02f, 9.44733247e-02f, 1.18882554e-02f, 3.17246728e-02f, -3.24547999e-02f, -2.30099574e-01f, 2.59409577e-01f,
  3.18902820e-01f, 1.53594658e-01f, 6.77467212e-02f, -9.87438709e-02f, -1.14772975e-01f, 1.64785177e-01f, 3.49903330e-02f, -1.08901062e-03f, -7.39155784e-02f, -1.32444799e-01f,
  7.16561228e-02f, 2.15908396e-03f, -3.40376562e-03f, -8.71191099e-02f, -1.20779730e-01f, 4.52852279e-01f, 2.51746893e-01f, -1.42509893e-01f, -2.48865746e-02f, 2.16105029e-01f,
  9.76905376e-02f, 1.82629123e-01f, 5.70681430e-02f, 7.11493641e-02f, -5.59213711e-03f, 1.22662671e-01f, -1.46769553e-01f, 4.09923941e-01f, 1.22743240e-02f, -2.76213050e-01f,
  5.64404391e-02f, -2.26721555e-01f, -2.45269448e-01f, 3.81427631e-02f, -2.96850433e-03f, 1.52177084e-02f, 9.61122438e-02f, 9.71925855e-02f, 8.95051584e-02f, 5.49995787e-02f,
  -1.13804787e-02f, 1.48404762e-01f, -1.58387125e-01f, 1.24167828e-02f, -5.51943593e-02f, 1.32064242e-02f, 6.37121797e-02f, -4.60528731e-02f, -4.00122581e-03f, 1.23501524e-01f,
  -3.22245806e-01f, -8.16810578e-02f, 7.70961791e-02f, -2.02652678e-01f, -8.80994275e-02f, 2.59904325e-01f, 1.83406584e-02f, -3.20382006e-02f, -2.40449160e-02f, 1.91995278e-01f,
  5.34244254e-02f, -2.39735365e-01f, 1.68428496e-01f, 2.17228457e-01f, 5.92308268e-02f, 1.68737471e-01f, -6.57997355e-02f, -2.29616046e-01f, -2.69321442e-01f, -8.94221477e-03f,
  1.22896440e-01f, -1.74969986e-01f, 6.69062063e-02f, -3.70926440e-01f, 6.85196221e-02f, -1.54685870e-01f, 1.14659525e-01f, 2.07790613e-01f, -1.76434200e-02f, -6.92083165e-02f,
  -1.41874880e-01f, -2.35105351e-01f, -2.47309327e-01f, 3.46557170e-01f, -1.32992953e-01f, 3.21368784e-01f, -2.40276992e-01f, 9.88777131e-02f, -1.64827153e-01f, 9.82379690e-02f,
  -2.56721824e-01f, 2.26052672e-01f, -3.07463467e-01f, -7.28736073e-02f, 1.88024789e-01f, -5.90041913e-02f, -1.06823503e-03f, -1.35717392e-01f, 5.46394698e-02f, 1.66078553e-01f,
  1.35901153e-01f, -4.93152179e-02f, 1.66337952e-01f, 1.62726134e-01f, 4.06078584e-02f, 1.71908975e-01f, 6.11953773e-02f, 8.12759921e-02f, 1.89742610e-01f, 9.15566646e-03f,
  1.19568244e-01f, -2.71614082e-02f, 2.84013208e-02f, 1.75174803e-01f, -2.74382755e-02f, -2.08735056e-02f, -5.46865463e-02f, 2.79679894e-03f, 2.22530827e-01f, 1.26806468e-01f,
  5.73629104e-02f, 7.18487799e-02f, 2.44102359e-01f, 1.33085921e-01f, 5.34836426e-02f, -2.97004223e-01f, 3.38349283e-01f, 1.38193026e-01f, 3.75723988e-02f, 1.84151888e-01f,
  2.10086200e-02f, -1.40742049e-01f, -2.65079468e-01f, -7.18618184e-02f, -1.10292986e-01f, 1.39550716e-01f, 9.48558003e-02f, -1.13837503e-01f, 9.43409204e-02f, -1.88339293e-01f,
  1.33957267e-01f, -8.76333639e-02f, -7.79711828e-02f, 9.23772976e-02f, -6.22897893e-02f, 5.34148738e-02f, -1.32264614e-01f, 1.97582528e-01f, -3.05326376e-02f, 2.96992660e-01f,
  -1.50194779e-01f, 2.15414196e-01f, -2.63274103e-01f, 9.08072367e-02f, -1.14838958e-01f, 1.91246048e-01f, -3.14250663e-02f, -1.23549439e-01f, -1.74131125e-01f, -2.68323243e-01f,
  1.80222288e-01f, -2.36540571e-01f, 2.45620459e-01f, 2.94056922e-01f, 1.40811309e-01f, -2.43644789e-02f, 2.95942396e-01f, -4.53438945e-02f, 1.81015894e-01f, 4.01620977e-02f,
  1.29766464e-01f, 1.39314041e-01f, -3.21816243e-02f, 5.05504571e-02f, 1.23700269e-01f, 1.19560078e-01f, 4.42368090e-02f, 5.19502163e-02f, -7.55661875e-02f, 5.37585579e-02f,
  -5.44575676e-02f, -1.51271999e-01f, -4.91706021e-02f, 2.39732824e-02f, -1.52041897e-01f, 2.35847570e-03f, -8.90452117e-02f, 3.93346548e-02f, 1.95461780e-01f, 2.90786959e-02f,
  -7.31241331e-02f, 2.55416065e-01f, 8.42740834e-02f, 1.03955314e-01f, 1.80986430e-02f, 1.43722259e-02f, 1.37829483e-01f, -3.16512473e-02f, -3.05117164e-02f, 1.66432440e-01f,
  -1.58836976e-01f, 2.65783295e-02f, -2.60391291e-02f, 5.67714160e-04f, -6.70523569e-02f, 2.46973872e-01f, 4.97910790e-02f, 1.89214006e-01f, -2.14081198e-01f, 5.14187999e-02f,
  1.76308647e-01f, 2.64454186e-01f, 1.60370722e-01f, 1.04546875e-01f, -2.39891797e-01f, -1.12153091e-01f, -1.75603360e-01f, 2.22624972e-01f, 2.72835158e-02f, -1.31092727e-01f,
  -3.71209264e-01f, 2.60767713e-03f, 2.98792660e-01f, 2.09829316e-01f, -4.23549078e-02f, 4.25609387e-03f, 1.72796488e-01f, 1.21711753e-01f, 2.03073561e-01f, -2.22562719e-02f,
  9.85065475e-02f, 1.11626029e-01f, 1.76727042e-01f, 7.14271888e-02f, -1.88804306e-02f, -8.99663102e-03f, 1.89244263e-02f, 1.12604611e-01f, 1.39854342e-01f, 1.11047968e-01f,
  3.60658579e-02f, -8.50119367e-02f, 3.27872038e-02f, 1.62251806e-03f, 5.48926648e-03f, -1.38863593e-01f, -6.58553392e-02f, 4.11843229e-03f, 1.21790826e-01f, 1.85073674e-01f,
  -3.02482605e-01f, -1.16337523e-01f, -1.17320389e-01f, 3.76276895e-02f, 2.68282499e-02f, -1.27321362e-01f, -2.48135641e-01f, -6.26979321e-02f, -8.91717821e-02f, -1.61262415e-02f,
  2.77404785e-01f, 6.37438297e-02f, 7.10355043e-02f, 5.92588298e-02f, -4.70965430e-02f, 6.24332316e-02f, 4.51320671e-02f, 7.44612515e-03f, -1.38771281e-01f, 1.32987291e-01f,
  1.21153727e-01f, -2.11833611e-01f, 2.31887437e-02f, -1.64534107e-01f, 6.55452907e-02f, 2.46690199e-01f, -1.38826996e-01f, 7.84404129e-02f, -1.68606237e-01f, -1.18728444e-01f,
  9.81485322e-02f, 1.47294372e-01f, 1.03608571e-01f, 2.49231875e-01f, -1.40523689e-03f, 2.84991530e-03f, 3.72511923e-01f, 1.78647503e-01f, -2.18137428e-01f, -7.17101095e-04f,
  -3.72857228e-03f, -2.23826364e-01f, 7.95835406e-02f, -2.36696318e-01f, 1.82779834e-01f, -3.58528122e-02f, 1.81438670e-01f, 4.21231575e-02f, 2.22353876e-01f, 1.63376629e-01f,
  -3.11074289e-03f, 9.81425047e-02f, 1.87753350e-01f, 1.09273069e-01f, 1.95391431e-01f, 8.31218809e-02f, 1.73885733e-01f, -1.34028926e-01f, -1.48937523e-01f, -2.04438135e-01f,
  -1.94915444e-01f, -1.73853904e-01f, -1.48776576e-01f, 5.89996912e-02f, -3.36524725e-01f, -2.50482142e-01f, -1.29093930e-01f, 1.45513132e-01f, -2.30909124e-01f, -1.90978408e-01f,
  -1.30486742e-01f, -2.39207819e-01f, 7.58678168e-02f, 1.49289563e-01f, 4.13541198e-01f, -9.94869843e-02f, -8.85948539e-03f, -5.38057126e-02f, -4.76951413e-02f, 3.18684846e-01f,
  -1.16970420e-01f, -1.80165231e-01f, -1.93280935e-01f, -3.44721168e-01f, 1.44984871e-01f, 2.23985747e-01f, -3.14985253e-02f, 1.73032850e-01f, -2.17304483e-01f, 1.84533715e-01f,
  2.45605055e-02f, 1.12706479e-02f, -1.14414908e-01f, -1.03180580e-01f, 3.30012143e-01f, -2.02447046e-02f, 1.91439778e-01f, 2.04495359e-02f, -8.22649226e-02f, -5.76096773e-02f,
  9.88519862e-02f, 1.83695033e-01f, -5.75749427e-02f, -3.55566405e-02f, 4.09697704e-02f, -4.12582695e-01f, 2.01770738e-01f, -4.66569699e-02f, 1.11141399e-01f, 4.46922816e-02f,
  4.23196666e-02f, 1.30127859e-03f, 1.28937677e-01f, 8.03063139e-02f, 1.61186591e-01f, 2.65708625e-01f, -5.79893440e-02f, 5.89571614e-03f, -5.29051572e-02f, 1.98090360e-01f,
  6.35391399e-02f, -5.59516698e-02f, 9.86887440e-02f, 1.14872962e-01f, 1.14639439e-01f, 3.49059291e-02f, 1.46379601e-02f, -3.51400115e-02f, 1.33612633e-01f, 5.29025160e-02f,
  1.48463428e-01f, -6.37486354e-02f, 4.83030640e-02f, 2.95374811e-01f, 1.86601490e-01f, 2.47004077e-01f, 9.40959230e-02f, -1.45754367e-01f, -7.56453164e-03f, 1.67760864e-01f,
  1.63624033e-01f, -5.80936298e-02f, 1.40299439e-01f, 7.11042061e-02f, 1.29600152e-01f, 2.87232995e-01f, 7.83588067e-02f, -2.63191164e-01f, 3.90849151e-02f, -1.38553202e-01f,
  2.09092051e-01f, 1.95272833e-01f, -4.62294668e-02f, -7.99343958e-02f, -2.10913748e-01f, 5.66337854e-02f, 1.32816195e-01f, 2.21204743e-01f, -7.59219527e-02f, -1.05210118e-01f,
  2.31044173e-01f, -1.07132390e-01f, 7.48849511e-02f, 3.72399837e-02f, -1.06213547e-01f, -8.10836405e-02f, -1.48775317e-02f, 6.65667430e-02f, 8.16001929e-03f, 3.19712818e-01f,
  -1.62664294e-01f, -1.01217344e-01f, 2.15264127e-01f, -7.34027177e-02f, 1.65392354e-01f, 2.35029384e-01f, -1.73192900e-02f, -1.04595020e-01f, -8.79220515e-02f, 6.87601641e-02f,
  1.78072900e-01f, -1.09971836e-01f, 6.63776919e-02f, 2.78144907e-02f, -6.58722967e-02f, 1.67127652e-03f, -5.31054474e-02f, -3.74544784e-02f, -2.54308462e-01f, 3.43008935e-02f,
  -3.20487395e-02f, 2.24253505e-01f, -3.13507289e-01f, -1.46487467e-02f, -3.44474502e-02f, -9.18702483e-02f, 5.03363982e-02f, -1.07022887e-02f, 1.76073965e-02f, -2.35415548e-02f,
  -2.16621603e-03f, 7.11785853e-02f, 3.02193552e-01f, -8.94440189e-02f, 5.06473370e-02f, -2.14060172e-02f, 2.96067089e-01f, -2.08016545e-01f, -9.26073715e-02f, -1.01707637e-01f,
  -2.19088167e-01f, 3.14532928e-02f, 2.71761596e-01f, 8.16422105e-02f, -1.37495890e-03f, -2.79770732e-01f, 2.26254538e-02f, 2.39215702e-01f, -3.27626280e-02f, 3.05208981e-01f,
  -1.10506371e-01f, 1.22059949e-01f, 2.97748446e-01f, 2.04275250e-01f, 1.45107685e-02f, 9.22850892e-02f, -1.71323031e-01f, -3.98994610e-02f, 2.64671355e-01f, 9.02655050e-02f,
  -9.44725424e-02f, -9.78691429e-02f, 5.81604876e-02f, 1.17831565e-01f, 4.37490307e-02f, -1.01125188e-01f, -1.94670454e-01f, 6.54821619e-02f, 4.41725366e-02f, 7.78469294e-02f,
  -2.26703398e-02f, 5.87477721e-02f, -6.73205452e-03f, 4.71341051e-02f, 7.32780024e-02f, 1.50044233e-01f, 8.74695182e-02f, 1.22473575e-01f, -1.29903302e-01f, -2.45959219e-02f,
  1.63858995e-01f, 8.53675753e-02f, -1.09901831e-01f, 1.08318619e-01f, -1.34418132e-02f, -3.85904405e-03f, 2.37203799e-02f, 2.66229331e-01f, 1.30613633e-02f, -1.32796049e-01f,
  -9.97316837e-02f, -2.56692730e-02f, 1.98031753e-01f, -2.93374732e-02f, -1.90149769e-02f, 1.28944160e-03f, -8.33698511e-02f, 4.24801968e-02f, -2.15348732e-02f, 2.51112700e-01f,
  -7.90960789e-02f, -8.51652324e-02f, 5.03047295e-02f, 8.41412344e-04f, 3.09875291e-02f, 3.77967030e-01f, 2.00482551e-02f, 1.87114086e-02f, -1.72655120e-01f, -2.52566963e-01f,
  2.23739281e-01f, 3.04681472e-02f, 2.00775415e-01f, 1.11750081e-01f, 1.02331024e-02f, -8.91277492e-02f, -1.35121569e-01f, 1.30374283e-01f, -3.27940047e-01f, 1.00364737e-01f,
  2.53430977e-02f, 6.53910138e-06f, 9.57294479e-02f, -1.80348113e-01f, 1.49646699e-01f, -4.74939938e-04f, -1.31527528e-01f, -3.81232612e-02f, 2.41751328e-01f, -4.24879715e-02f,
  8.31969455e-03f, 9.13717896e-02f, 1.26245460e-02f, -4.28914540e-02f, 9.74271968e-02f, 1.27766788e-01f, -4.28888910e-02f, 8.60890150e-02f, 1.65787444e-01f, 5.82803749e-02f,
  -3.23393792e-02f, 2.01327562e-01f, -1.53244019e-01f, 1.53395412e-02f, 1.20153435e-01f, 4.09762226e-02f, -4.29955423e-02f, 6.30757064e-02f, -1.58945277e-01f, -2.13725463e-01f,
  -1.98123455e-01f, 1.06568009e-01f, 1.70396358e-01f, -3.74872871e-02f, -3.36594433e-01f, 1.86036825e-01f, 3.97359520e-01f, 2.87249982e-01f, -5.04705533e-02f, -1.08887747e-01f,
  -1.18299089e-01f, 1.03845894e-01f, -3.18672389e-01f, 1.22757562e-01f, -3.87059897e-02f, -2.80325621e-01f, -7.34226964e-03f, 9.54986587e-02f, -1.81598425e-01f, 4.51711565e-01f,
  1.41387284e-01f, 9.63950977e-02f, -1.25415912e-02f, -3.20386559e-01f, 5.88905253e-02f, -2.01008096e-02f, 1.05110191e-01f, 3.84933688e-02f, -1.44337073e-01f, 9.00849327e-02f,
  -1.32154465e-01f, 2.41519779e-01f, -3.22570838e-02f, -2.46203411e-03f, -2.20982254e-01f, -2.25830339e-02f, 2.10402504e-01f, 1.05528697e-01f, 1.63559437e-01f, -1.35192230e-01f,
  -1.26036098e-02f, 2.61636436e-01f, 2.72263378e-01f, -5.87055683e-02f, -2.71024346e-01f, -6.88599199e-02f, 7.44486675e-02f, 2.30488796e-02f, 1.34062290e-01f, -4.43200544e-02f,
  -3.27181518e-02f, 6.79631308e-02f, 1.44044027e-01f, 2.20510498e-01f, -8.33838060e-02f, 8.25946108e-02f, 1.16195306e-01f, -5.17389849e-02f, 1.26608238e-01f, 1.50942490e-01f,
  4.53517921e-02f, 9.47248787e-02f, -2.47868359e-01f, -2.47777462e-01f, -3.87089187e-03f, -3.45357507e-02f, -1.16399989e-01f, -1.11604989e-01f, -4.40397024e-01f, 1.25353694e-01f,
  4.31322068e-01f, 8.38150233e-02f, 2.39342809e-01f, -4.03780900e-02f, -1.16638750e-01f, 2.39402115e-01f, 6.18050471e-02f, 1.62256137e-01f, 2.96640880e-02f, 1.05469022e-02f,
  9.36335102e-02f, 6.50302172e-02f, -2.39603937e-01f, 2.34649986e-01f, 3.78027819e-02f, -8.49381313e-02f, 2.71423459e-01f, -3.45461443e-02f, 1.41427532e-01f, -4.37894613e-02f,
  3.81767936e-02f, -4.87111099e-02f, 9.54797417e-02f, 5.21026291e-02f, 2.74960726e-01f, -6.48043081e-02f, -2.40434647e-01f, 1.24810673e-01f, 3.16525251e-02f, -2.50047237e-01f,
  1.22487336e-01f, 6.70415536e-02f, 6.71891272e-02f, 7.34431949e-03f, -1.75292164e-01f, -2.96263903e-01f, 2.32254133e-01f, 4.38667387e-02f, -4.25426513e-02f, -4.71754596e-02f,
  1.06540509e-01f, 8.55774283e-02f, 1.28817931e-01f, -5.76221459e-02f, 1.58510149e-01f, -2.02005077e-02f, 3.48869711e-02f, 1.31224006e-01f, 4.32392806e-02f, 9.91372317e-02f,
  9.89266858e-02f, 7.22996742e-02f, 6.70322850e-02f, 1.93336576e-01f, 6.68977275e-02f, -7.04186456e-03f, -2.25555301e-01f, -3.96984518e-02f, 1.32753536e-01f, 6.25837296e-02f,
  -1.83875844e-01f, -1.86035290e-01f, -2.15816557e-01f, -1.13526076e-01f, 1.45232081e-01f, -7.27719963e-02f, 1.47950917e-01f, -4.79280129e-02f, 1.43212127e-02f, 3.17852378e-01f,
  -2.52405275e-02f, 1.23920061e-01f, 1.95950363e-02f, -9.54848900e-02f, 1.01978749e-01f, 4.66428744e-03f, -1.28074259e-01f, 3.09217304e-01f, 1.71435535e-01f, 8.42902344e-03f,
  1.57938644e-01f, -4.75334600e-02f, -5.06176241e-03f, -2.32178103e-02f, -4.92727384e-02f, -1.56344682e-01f, 3.64961386e-01f, 1.10752888e-01f, 1.85003668e-01f, -2.63824105e-01f,
  -4.19336975e-01f, -4.72151116e-02f, 1.84649572e-01f, -2.80134022e-01f, -6.41767820e-03f, -7.63492510e-02f, 2.81976581e-01f, 6.57045916e-02f, -1.49304584e-01f, -1.51840821e-01f,
  -3.08632664e-02f, 2.21668273e-01f, -1.79841638e-01f, 3.78468484e-02f, -6.81151217e-03f, 9.21509787e-02f, 6.79308251e-02f, -6.55652806e-02f, 1.00464873e-01f, -4.82985154e-02f,
  -8.02826360e-02f, -1.15697585e-01f, -1.34737611e-01f, -6.63934946e-02f, 1.85989767e-01f, 5.49165951e-03f, -4.47564013e-02f, -2.72885635e-02f, -1.80710509e-01f, 6.70917109e-02f,
  -8.33064318e-02f, 9.89027470e-02f, -1.18292958e-01f, 6.15834333e-02f, 1.61640458e-02f, -7.02556744e-02f, 2.15471417e-01f, -1.10142328e-01f, 2.33946383e-01f, -7.38618597e-02f,
  1.52222127e-01f, -1.91667620e-02f, -1.35959789e-01f, -1.49009690e-01f, 1.32399527e-02f, 1.72128841e-01f, 3.22461247e-01f, 1.38927773e-01f, -4.90851179e-02f, -1.81730777e-01f,
  -1.13230281e-01f, 6.78081065e-02f, -6.52444214e-02f, 4.86851260e-02f, 2.32593596e-01f, 1.06573902e-01f, 2.40586281e-01f, 7.11935908e-02f, 1.30930856e-01f, 1.52322307e-01f,
  9.40358639e-02f, 2.56818026e-01f, 1.79820061e-01f, -4.70659323e-02f, -1.80731654e-01f, 1.88350469e-01f, 8.60250518e-02f, 2.21539494e-02f, -2.71112114e-01f, -1.31964739e-02f,
  -2.22977605e-02f, 4.05935338e-03f, 1.58849716e-01f, -4.60678712e-02f, 1.80370390e-01f, -1.42771518e-02f, 7.27290809e-02f, 9.12573934e-03f, -4.49268799e-03f, 5.55277914e-02f,
  1.80263534e-01f, -5.54847606e-02f, 1.89718679e-02f, 8.55214372e-02f, 1.12152062e-01f, -5.41448081e-03f, 4.30034138e-02f, 2.88247205e-02f, 4.12254743e-02f, 1.48177356e-01f,
  -1.65380444e-02f, 6.53062714e-03f, 1.56252965e-01f, -1.29238069e-01f, 1.50048792e-01f, 1.43646568e-01f, 6.82905465e-02f, 8.06170180e-02f, 1.02998942e-01f, -1.96972758e-01f,
  4.56243426e-01f, -1.01715453e-01f, -1.44122792e-02f, 9.44701135e-02f, 1.26128599e-01f, -5.35727292e-02f, -2.28997260e-01f, -4.61834408e-02f, 7.73083419e-02f, 1.03339635e-01f,
  5.84097840e-02f, 1.01728640e-01f, 3.29638124e-02f, -5.43734021e-02f, 1.79477558e-01f, -1.29146516e-01f, -2.32555717e-01f, 1.10614905e-02f, 2.08358735e-01f, 2.20085219e-01f,
  7.64853433e-02f, 2.77896468e-02f, -8.91936384e-03f, 1.84737310e-01f, -4.83727045e-02f, 5.93498088e-02f, -1.05484150e-01f, 8.99202079e-02f, 4.53781374e-02f, -1.32671878e-01f,
  -9.92938410e-04f, 3.07233781e-01f, -1.94939882e-01f, -1.70922920e-01f, 1.51886001e-01f, 2.28257746e-01f, 1.78016275e-01f, 3.72723997e-01f, 6.31476939e-02f, 2.06054077e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.59706050e-01f, 1.30867109e-01f, 1.98545560e-01f, 3.05659294e-01f, 2.72232056e-01f, -2.81059160e-03f, 2.05518112e-01f, -5.43151908e-02f, -8.40802789e-02f, 1.06395476e-01f,
  1.04773358e-01f, 4.16034423e-02f, 2.96306223e-01f, 9.29961875e-02f, 2.01710016e-02f, 7.40563199e-02f, 2.20032334e-01f, 2.74083555e-01f, 8.62683356e-03f, 1.29509112e-02f,
  5.43463752e-02f, 9.60615054e-02f, -5.20192683e-02f, 9.30775627e-02f, 2.27068573e-01f, 2.68922579e-02f, 1.32770061e-01f, 1.39712393e-01f, 1.96388289e-01f, 2.93716431e-01f,
  1.16107464e-01f, 8.56292173e-02f, 2.27809399e-01f, 1.57400936e-01f, 2.93673817e-02f, 5.13569713e-02f, 2.48821765e-01f, 2.49159127e-01f, 9.30899084e-02f, 6.24532625e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.58901647e-01f, 4.64598723e-02f, 2.17282958e-03f, 1.67599291e-01f, 1.41164139e-01f, 2.41470441e-01f, 4.31416184e-02f, 6.50015622e-02f, 7.49561265e-02f, 1.60485566e-01f,
  -1.02926880e-01f, 1.65730014e-01f, 1.61986485e-01f, -3.46225500e-02f, 5.99119179e-02f, -2.48112157e-01f, 1.15644149e-01f, -2.67144889e-01f, -4.01135385e-02f, 1.91020854e-02f,
  1.63849909e-03f, 1.85158119e-01f, 1.46272525e-01f, -1.56399831e-01f, 1.32076889e-01f, 2.32353639e-02f, 1.19164541e-01f, 4.73287143e-02f, -3.53563651e-02f, -5.05244508e-02f,
  -8.71813148e-02f, -1.22348808e-01f, -1.80108529e-02f, -3.38430345e-01f, 6.33299947e-02f, -5.40747307e-02f, -1.69634342e-01f, 1.00091696e-02f, 9.58976224e-02f, 3.06022048e-01f,
  -1.59442946e-01f, 4.99803573e-02f, -1.34663388e-01f, 1.73065260e-01f, 3.28740515e-02f, -6.75763190e-02f, 1.31942108e-01f, -1.25558957e-01f, -9.42429602e-02f, -5.21346219e-02f,
  1.51457638e-01f, 1.28399236e-02f, 7.48431534e-02f, 2.23302975e-01f, 8.74865428e-02f, 1.85100466e-01f, -2.64575984e-02f, 5.42598628e-02f, 6.87754601e-02f, 6.28755242e-02f,
  1.89866405e-02f, 2.68921349e-02f, 6.60485551e-02f, -1.74370319e-01f, -2.75220256e-02f, -3.10570858e-02f, -2.69808263e-01f, -1.37971744e-01f, -8.02235529e-02f, -1.38275549e-01f,
  1.53211486e-02f, 1.50823906e-01f, -8.38864371e-02f, 2.35050365e-01f, -1.50806410e-02f, 9.08047368e-04f, -2.99621448e-02f, -6.73837438e-02f, 5.52043952e-02f, 1.08521871e-01f,
  -6.43489361e-02f, 1.21094309e-01f, 4.99839969e-02f, -7.20368624e-02f, -5.50582679e-03f, 1.29653007e-01f, -1.36124864e-01f, 2.19279811e-01f, -5.03768772e-02f, 5.93487062e-02f,
  -1.58925086e-01f, -7.93516040e-02f, -2.07911640e-01f, -5.41569479e-02f, 1.14746176e-01f, -4.62161005e-02f, 7.33279213e-02f, 1.10592373e-01f, -1.95084915e-01f, 1.75901502e-01f,
  -1.04797848e-01f, -2.01283433e-02f, 2.55877763e-01f, -6.38975129e-02f, -6.57945499e-02f, 1.17302798e-01f, 1.42851964e-01f, 4.64453697e-02f, 7.52692297e-02f, -1.42781228e-01f,
  3.03076785e-02f, 9.74963903e-02f, 5.70634380e-02f, -8.85695126e-03f, -3.26627493e-02f, 2.95465551e-02f, 3.95345762e-02f, -8.59719142e-02f, -3.96953188e-02f, -1.78769052e-01f,
  -9.12198238e-03f, -1.24816477e-01f, 1.68994561e-01f, -1.49461284e-01f, -6.34006336e-02f, 1.14148013e-01f, -2.33851443e-03f, 5.52266790e-03f, -1.19524144e-01f, -7.67216682e-02f,
  -3.21986735e-01f, -6.91808155e-03f, 7.57313371e-02f, 2.01786891e-01f, -4.15348560e-02f, 1.80623442e-01f, -5.64172911e-03f, 1.05079729e-02f, 1.65266935e-02f, -6.80366755e-02f,
  1.29019678e-01f, -8.89284387e-02f, 2.32518837e-01f, -2.15663224e-01f, 9.96991023e-02f, -8.92120972e-02f, 1.08786523e-02f, 4.05052379e-02f, -1.48211405e-01f, -1.43715246e-02f,
  -1.33850262e-01f, -2.44720027e-01f, -2.54930049e-01f, -8.82215623e-04f, 1.26805037e-01f, 1.32156387e-01f, -1.95844576e-01f, -6.64609149e-02f, -8.70817378e-02f, -2.18110144e-01f,
  1.70186888e-02f, 7.88599402e-02f, -8.59266445e-02f, 1.55132994e-01f, -1.29426911e-01f, 6.04700204e-03f, -1.25906631e-01f, -7.96211809e-02f, -1.36143453e-02f, 1.18866511e-01f,
  -6.49984479e-02f, -8.70614126e-02f, 8.38059634e-02f, 9.59474370e-02f, 4.09954786e-02f, 2.30400003e-02f, 9.08903778e-03f, 4.96404395e-02f, -1.52376622e-01f, -1.34673312e-01f,
  -1.22027911e-01f, 1.26624048e-01f, 1.34639284e-02f, 3.94884981e-02f, -2.31090859e-02f, 2.92300305e-04f, 9.46702994e-03f, -1.19474940e-01f, 1.07127512e-02f, -1.53414562e-01f,
  -3.54260579e-02f, 8.67970139e-02f, 2.09166296e-03f, -2.18017086e-01f, -7.50269964e-02f, -1.12249941e-01f, -6.46957532e-02f, -5.93576580e-02f, -2.17691481e-01f, 1.49240177e-02f,
  -3.55346352e-02f, -1.35743424e-01f, -1.72969788e-01f, -2.03974098e-01f, 9.26939771e-02f, -1.48662969e-01f, 2.50307083e-01f, 1.50440231e-01f, -2.72123724e-01f, 6.51513711e-02f,
  1.41170010e-01f, 1.40133530e-01f, -5.45711489e-03f, 2.05703918e-02f, 2.06396766e-02f, 1.09992541e-01f, -8.25633630e-02f, -9.54076499e-02f, -4.29483019e-02f, -9.50041264e-02f,
  1.03750862e-02f, 2.90582944e-02f, 2.47469507e-02f, -1.25382179e-02f, -1.66387055e-02f, 1.03911899e-01f, -5.01636639e-02f, -5.48626147e-02f, 1.03606313e-01f, -8.35076198e-02f,
  -1.17694862e-01f, -1.54181868e-01f, -1.58690855e-01f, -1.54405804e-02f, -2.97961384e-01f, 3.26582640e-02f, 7.93161243e-02f, 9.91037637e-02f, 3.57734971e-02f, 6.13595247e-02f,
  9.74696651e-02f, -6.24400228e-02f, -1.35537043e-01f, -7.32144192e-02f, 4.64661084e-02f, 6.90652281e-02f, 9.23255533e-02f, 3.56204784e-03f, -1.32159621e-01f, 1.72961041e-01f,
  1.08569361e-01f, -1.99882928e-02f, -1.18660496e-03f, 1.11361936e-01f, 1.08574241e-01f, -4.17991020e-02f, -1.83837146e-01f, -7.54563557e-03f, 5.59945479e-02f, 1.16679579e-01f,
  -9.63006541e-02f, -5.87235838e-02f, 7.65172243e-02f, 2.28481293e-01f, -1.02029704e-01f, 6.47067800e-02f, -1.45886034e-01f, 5.49608096e-02f, -1.02629118e-01f, 4.11421694e-02f,
  -1.61354423e-01f, 1.41521975e-01f, -4.60485630e-02f, -2.39541456e-02f, 3.64754125e-02f, -1.73215777e-01f, 3.59387174e-02f, 1.61337659e-01f, -2.00292289e-01f, -1.38471007e-01f,
  2.72908479e-01f, -2.27894820e-02f, -5.79565205e-02f, -8.21240842e-02f, -4.58328687e-02f, -1.14353411e-02f, 1.22423097e-01f, 6.43381923e-02f, 1.67236611e-01f, 1.91594493e-02f,
  3.11078150e-02f, -8.40544850e-02f, -7.70706981e-02f, 2.90827788e-02f, 2.23813336e-02f, 1.48503602e-01f, 4.83917184e-02f, -4.59629782e-02f, -1.65496990e-02f, 2.84602225e-01f,
  -2.14818671e-01f, 1.05962500e-01f, 4.76328172e-02f, 1.25752613e-01f, -9.74255204e-02f, 4.61965054e-02f, 9.41931456e-02f, -9.67517644e-02f, -1.91034362e-01f, -1.71192825e-01f,
  3.85879502e-02f, -1.77035511e-01f, -7.90969729e-02f, -1.33663476e-01f, 1.66512698e-01f, 3.74630047e-03f, 6.41615987e-02f, 9.24972966e-02f, -8.25803801e-02f, -3.27143967e-02f,
  -1.44393861e-01f, 1.43222466e-01f, -6.79730922e-02f, -7.02358782e-02f, -7.61433095e-02f, 1.38516963e-01f, -1.31411582e-01f, 1.25964448e-01f, 8.21501762e-02f, 6.04246780e-02f,
  2.12762848e-01f, 4.93925717e-03f, -5.14477082e-02f, -2.09460050e-01f, -8.99307430e-02f, 1.27751350e-01f, 1.35296702e-01f, -1.24408357e-01f, -5.68530560e-02f, -2.66920269e-01f,
  7.54987076e-02f, 4.75511188e-03f, -4.31133807e-02f, 9.15631875e-02f, -3.20811830e-02f, -1.69721302e-02f, -1.83116868e-01f, 1.44503951e-01f, -6.47406429e-02f, 6.90677240e-02f,
  -2.67154187e-01f, -7.44476961e-03f, 2.85749473e-02f, 2.88695633e-01f, 1.88107610e-01f, 5.07590175e-02f, -1.53889209e-01f, -3.84915397e-02f, 4.43434715e-02f, -1.30789638e-01f,
  7.16565251e-02f, -2.19026402e-01f, 2.96362251e-01f, -6.12959787e-02f, -8.60612001e-03f, -2.45751608e-02f, 1.33841991e-01f, 7.15652108e-02f, 5.17017841e-02f, -9.28223357e-02f,
  -5.82331046e-02f, 4.27443460e-02f, 1.24809809e-01f, 6.61149696e-02f, -2.14750871e-01f, -2.39544973e-01f, 9.38922316e-02f, -1.30235218e-02f, 1.13941938e-01f, 1.26027748e-01f,
  -6.59287199e-02f, 1.67288315e-02f, -9.61129963e-02f, -4.62352931e-02f, -1.81812029e-02f, -1.17509820e-01f, -2.21613169e-01f, -1.16503671e-01f, -1.42146096e-01f, -2.84573764e-01f,
  1.80639893e-01f, -2.72014409e-01f, -7.82490650e-04f, -1.67943388e-01f, -1.19819632e-02f, 1.58372015e-01f, -1.69811770e-01f, 3.70549381e-01f, 1.72622800e-01f, 3.85518331e-04f,
  -1.23432159e-01f, 2.99315363e-01f, 1.84171900e-01f, 2.78800845e-01f, 1.71612486e-01f, -5.73033430e-02f, 1.84196997e-02f, 1.83769554e-01f, 1.02053620e-01f, -2.04163700e-01f,
  3.78520451e-02f, 2.85615195e-02f, -1.48846045e-01f, -2.56479122e-02f, 5.57071604e-02f, -1.24453746e-01f, 4.39240150e-02f, -2.73107380e-01f, -1.35239616e-01f, 1.40869424e-01f,
  -2.02189852e-03f, 2.22533479e-01f, 1.63742438e-01f, 1.86534017e-01f, 1.31592020e-01f, 1.54646203e-01f, 2.50896841e-01f, 1.10573933e-01f, -1.11362301e-01f, -8.23506787e-02f,
  -5.22407517e-02f, 4.01817188e-02f, -9.30911973e-02f, -1.26711786e-01f, -3.68185788e-02f, 7.98607096e-02f, -1.24937586e-01f, -2.14946061e-01f, 9.05192569e-02f, 1.28528163e-01f,
  1.28607498e-02f, -1.70464106e-02f, -9.09112841e-02f, -9.83275175e-02f, -3.22697274e-02f, 5.58689013e-02f, -1.32503837e-01f, -1.56379327e-01f, -1.59122035e-01f, 4.94919047e-02f,
  9.52719599e-02f, 1.92076325e-01f, 1.79051712e-01f, -1.01069892e-02f, 8.33436325e-02f, 1.95335764e-02f, -1.56778954e-02f, -2.46165842e-02f, 1.75971314e-01f, 2.12622676e-02f,
  1.31190762e-01f, 1.86359197e-01f, -5.98941259e-02f, -6.46406189e-02f, -8.82805958e-02f, -6.87304931e-03f, -1.68464184e-01f, 1.05018280e-01f, -3.61744724e-02f, 1.48197785e-01f,
  -1.02764897e-01f, 3.11334133e-02f, -4.22090180e-02f, -9.09915119e-02f, 1.81533977e-01f, -3.25367600e-02f, -1.42536461e-01f, -6.02317639e-02f, 1.10882789e-01f, -1.12043116e-02f,
  -1.23718426e-01f, -1.59334436e-01f, 1.51249573e-01f, 1.27995938e-01f, -2.38090456e-01f, -4.00764197e-02f, -6.36147112e-02f, -3.80581035e-03f, -1.69367656e-01f, 1.04956977e-01f,
  -2.24131212e-01f, 3.18322927e-02f, 1.42224476e-01f, 8.23578313e-02f, 2.64333095e-02f, -8.85088891e-02f, -1.07294932e-01f, -9.12530497e-02f, -2.44538728e-02f, -8.97786021e-02f,
  -1.74099848e-01f, 7.57157952e-02f, -1.58681393e-01f, 1.04717471e-01f, -1.60367474e-01f, 7.79835060e-02f, -5.20845577e-02f, -1.75031535e-02f, 1.67173490e-01f, 2.37934012e-02f,
  5.60999196e-03f, -1.05406037e-02f, -8.54278654e-02f, -5.09809423e-03f, 7.12201074e-02f, -1.13716841e-01f, -8.08534399e-02f, -8.59532803e-02f, 7.56607298e-03f, 2.23381191e-01f,
  -7.69468211e-03f, 1.19012967e-01f, 1.74972098e-02f, -1.31671205e-01f, -2.03783944e-01f, -1.46545067e-01f, -8.57090694e-04f, 2.09755450e-01f, 3.45689729e-02f, 8.59301090e-02f,
  -2.28417087e-02f, -2.26870209e-01f, 6.21176139e-02f, 4.53000516e-02f, -8.63550790e-03f, 1.46466553e-01f, 1.92774430e-01f, 4.13294137e-02f, 3.31714489e-02f, -1.12399548e-01f,
  3.21772024e-02f, 1.29708782e-01f, -1.54562285e-02f, 1.94686335e-02f, 2.17569321e-01f, -2.54529923e-01f, -1.45076603e-01f, -7.29354396e-02f, 5.52577749e-02f, -1.32386267e-01f,
  2.11662620e-01f, 1.00305602e-01f, 1.25773549e-01f, -3.14319842e-02f, 2.80814558e-01f, 9.65113640e-02f, -2.24314168e-01f, -5.46942651e-02f, 8.93514827e-02f, 1.67300738e-02f,
  -3.98140401e-03f, -3.99900526e-02f, -4.92935553e-02f, 1.10461101e-01f, -3.70193496e-02f, -1.16069481e-01f, 1.25197200e-02f, -7.33171031e-02f, 1.80552617e-01f, -1.33383736e-01f,
  3.24887857e-02f, -2.17795894e-01f, -1.60667285e-01f, 1.30199343e-01f, 2.39593815e-02f, 1.07431054e-01f, -2.60648668e-01f, 5.00812791e-02f, 7.28267431e-02f, 1.23837009e-01f,
  -1.53054535e-01f, -1.17321387e-01f, -9.99989882e-02f, -6.72453046e-02f, -1.28726829e-02f, 1.98328689e-01f, -2.11959496e-01f, 1.45924911e-01f, -1.46835214e-02f, -7.45205060e-02f,
  -4.10569251e-01f, -1.39202744e-01f, -8.07139054e-02f, 4.11338285e-02f, -1.51130408e-01f, -2.29348496e-01f, -4.15376015e-02f, 7.19713047e-02f, -4.66252230e-02f, -1.89129055e-01f,
  -1.38834240e-02f, -9.27307904e-02f, 1.10194154e-01f, 1.70794740e-01f, -3.24570350e-02f, 1.65579394e-01f, -6.19896464e-02f, 1.95838884e-01f, -1.86623354e-02f, -1.01110399e-01f,
  -2.97901896e-03f, 3.50382775e-02f, -1.84412301e-01f, 1.99069362e-02f, -3.27151529e-02f, 2.49767601e-02f, 2.22565085e-01f, -1.29340470e-01f, 1.44091547e-01f, 1.73768044e-01f,
  -5.91789708e-02f, -1.17818810e-01f, -6.59238687e-03f, -1.28500700e-01f, -6.29379898e-02f, -3.95976417e-02f, 1.15420744e-01f, 1.78621665e-01f, -8.66576880e-02f, 1.29644275e-01f,
  -1.11102320e-01f, -3.68522033e-02f, -1.00055099e-01f, 4.27312392e-04f, -3.60399783e-02f, 1.02319784e-01f, -8.90231356e-02f, 6.74012527e-02f, -3.07418071e-02f, -7.10998429e-03f,
  4.79186364e-02f, -1.36019841e-01f, -1.86885312e-01f, -6.82458356e-02f, 1.78694613e-02f, 4.95960750e-02f, -1.37231514e-01f, -8.34896863e-02f, 1.51210949e-02f, -3.45765263e-01f,
  1.70891732e-01f, -8.29234645e-02f, -2.43802041e-01f, -6.54543638e-02f, 1.84723660e-02f, -1.36532605e-01f, 2.64614493e-01f, -2.29732934e-02f, -1.27938509e-01f, -6.15561642e-02f,
  1.81585714e-01f, -1.66122526e-01f, -7.24536628e-02f, -1.13486916e-01f, -1.15172967e-01f, 9.75720733e-02f, 2.25916319e-02f, 3.11544627e-01f, -1.23049663e-02f, 5.27138822e-02f,
  5.24734147e-02f, -3.72739322e-02f, 2.20336355e-02f, -3.92660424e-02f, -4.58845533e-02f, 1.25073552e-01f, 2.18591571e-01f, -9.47506502e-02f, -1.95564821e-01f, -4.86477092e-02f,
  1.06908068e-01f, 4.39684689e-02f, 1.25090210e-02f, -2.36290455e-01f, 6.45509064e-02f, -5.97182214e-02f, 8.98877066e-03f, -2.08317749e-02f, 2.47458164e-02f, 1.82452321e-01f,
  -1.55167475e-01f, 8.70134756e-02f, -1.01717621e-01f, 1.02914289e-01f, 1.88691914e-01f, 4.98894714e-02f, 1.78253978e-01f, 1.84159875e-01f, -2.09794313e-01f, 2.54502390e-02f,
  9.22020525e-02f, -1.27543882e-01f, -1.36524990e-01f, 8.14475045e-02f, 8.39638244e-03f, -4.26999526e-03f, -1.21596605e-01f, -1.00576989e-02f, 1.13907918e-01f, 1.43033609e-01f,
  -1.77513026e-02f, -1.98619254e-03f, 1.45450551e-02f, 1.73414141e-01f, 2.50309587e-01f, 5.82358837e-02f, 4.02665287e-02f, -8.75851065e-02f, -4.59059700e-02f, -9.63576231e-03f,
  5.43925278e-02f, -2.78082311e-01f, -2.28010193e-01f, -1.74855098e-01f, 6.05631024e-02f, -2.50702709e-01f, 1.97510719e-01f, -2.51767952e-02f, -2.27010742e-01f, -7.22873658e-02f,
  2.79014139e-03f, 5.57867019e-03f, -8.86568204e-02f, -6.82071745e-02f, -3.29001807e-02f, -1.72887415e-01f, -1.97511241e-01f, 2.64399886e-01f, 2.61024714e-01f, -2.11654673e-03f,
  -2.03301534e-01f, 2.41437573e-02f, -9.40843835e-04f, -1.42190773e-02f, -9.70152300e-03f, -2.24568978e-01f, -1.20707899e-01f, -1.04973301e-01f, 5.62212318e-02f, -2.04567790e-01f,
  -9.48850438e-02f, -4.89483178e-02f, 1.20631360e-01f, 1.10264480e-01f, 1.34725064e-01f, 1.29935801e-01f, -1.08237192e-02f, 3.08468547e-02f, -2.86744833e-01f, -1.46732077e-01f,
  -9.52772275e-02f, -6.70410320e-02f, -1.05968080e-01f, 7.10630938e-02f, -1.82226021e-02f, 3.84280155e-03f, -2.27626249e-01f, -4.94882502e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.34451926e-01f, 2.00382203e-01f, 1.22040226e-04f, 1.48086995e-01f, 2.52157927e-01f, 2.27742970e-01f, 8.24680775e-02f, 1.82962805e-01f, -1.22673929e-01f, 2.17869282e-01f,
  3.48900050e-01f, -1.37762018e-02f, 7.14579783e-03f, 3.85584384e-02f, 1.70339286e-01f, -4.94849712e-01f, 8.79848525e-02f, -1.16682783e-01f, -2.01806054e-01f, 1.28549829e-01f,
  -2.78467327e-01f, -1.35703444e-01f, -1.54519975e-01f, -2.69887507e-01f, -1.63371995e-01f, -8.90971795e-02f, 2.17686594e-01f, 2.72971690e-01f, 3.43832932e-02f, -1.50003567e-01f,
  -1.72379211e-01f, -2.95570284e-01f, -1.14271432e-01f, -1.87353909e-01f, -4.45165001e-02f, 4.57247682e-02f, -8.01333785e-02f, 1.59850270e-01f, -2.62082964e-01f, 2.73309946e-01f,
  -1.61930710e-01f, 3.59553009e-01f, -2.56828427e-01f, 4.88232858e-02f, 1.54873565e-01f, -1.07192680e-01f, 1.48627833e-01f, 1.88185811e-01f, -5.38240522e-02f, -4.43731733e-02f,
  1.45371631e-01f, -7.97022656e-02f, 6.68781698e-02f, 3.18664871e-02f, -7.64553621e-02f, 1.96026802e-01f, -2.37940792e-02f, 1.54432496e-02f, -4.14830958e-03f, -9.93059278e-02f,
  -2.60956883e-02f, 2.92777479e-01f, -6.38002083e-02f, 4.71314639e-02f, -1.47918910e-01f, 1.34682775e-01f, 2.83263307e-02f, -8.74566883e-02f, -5.91303930e-02f, -1.29216701e-01f,
  -1.02885135e-01f, 1.37094438e-01f, -1.73498653e-02f, -3.07052583e-01f, -5.96595556e-02f, -8.95511806e-02f, -1.83930546e-01f, 2.38148361e-01f, 3.19661759e-02f, 1.93146765e-01f,
  -6.69178963e-02f, 3.74731375e-03f, 1.69176921e-01f, 1.35597214e-01f, -1.34995684e-01f, -2.65964597e-01f, -4.53976318e-02f, 4.42026518e-02f, -1.02168131e-04f, -1.80516392e-01f,
  -5.23607843e-02f, 5.10471500e-02f, -5.56042083e-02f, -8.95498320e-02f, 3.75302359e-02f, 7.94890746e-02f, 1.19210832e-01f, 3.82831752e-01f, 8.16841647e-02f, 4.33022119e-02f,
  3.81940216e-01f, -2.13657856e-01f, 1.05929241e-01f, 6.41896352e-02f, 1.36150524e-01f, 1.73665404e-01f, -1.03608212e-02f, -2.51605600e-01f, 6.07983954e-02f, 3.24175268e-01f,
  3.06441128e-01f, 1.31854609e-01f, 5.82159013e-02f, 1.31322101e-01f, -2.19783455e-01f, -3.22951704e-01f, -1.48451433e-01f, 5.64087033e-02f, 7.14039057e-02f, 3.30987960e-01f,
  -3.51538137e-02f, 2.49772444e-01f, 1.17800713e-01f, 1.09357774e-01f, 2.35634241e-02f, -1.93686818e-03f, 2.13409334e-01f, 1.27985731e-01f, 1.02550626e-01f, -4.66155484e-02f,
  8.02906789e-03f, 4.18133698e-02f, 1.07901320e-01f, -5.87882921e-02f, 9.26175937e-02f, 2.93150749e-02f, 1.60068676e-01f, 2.32757673e-01f, 1.34378880e-01f, -1.77917983e-02f,
  -2.14099988e-01f, -3.22042644e-01f, 1.94907904e-01f, 1.02574922e-01f, 4.70752530e-02f, 2.04873249e-01f, -6.54482543e-02f, 1.94123149e-01f, -1.50554433e-01f, -1.89586744e-01f,
  -1.67479306e-01f, 1.65661812e-01f, 2.24407598e-01f, -2.68537670e-01f, -6.49770051e-02f, 1.96986362e-01f, 1.71170980e-01f, 2.63885498e-01f, 2.78259933e-01f, 1.16963275e-02f,
  1.36222050e-01f, -3.16824466e-01f, -1.60213351e-01f, 1.59673169e-01f, -3.21774811e-01f, 1.99100599e-01f, -7.51387551e-02f, -3.00269555e-02f, 5.51125966e-02f, 8.42351913e-02f,
  7.51384944e-02f, 5.70625402e-02f, 5.29006422e-02f, -1.53708279e-01f, -2.07411543e-01f, 8.17789957e-02f, 1.81572244e-01f, 1.47778347e-01f, 2.10920915e-01f, -1.69463048e-03f,
  2.49494657e-01f, -7.96479881e-02f, -1.95816547e-01f, -6.85867295e-02f, 7.21879825e-02f, 5.81157170e-02f, -8.73164162e-02f, -9.33060199e-02f, -1.69176736e-03f, 1.13218181e-01f,
  2.52947044e-02f, 2.40321815e-01f, 5.42727038e-02f, 1.56718999e-01f, -2.13172621e-04f, 9.06421989e-02f, 2.02631608e-01f, 2.44199157e-01f, 4.01185714e-02f, 1.43844351e-01f,
  1.36268005e-01f, 2.01736450e-01f, 7.17716888e-02f, 1.80946272e-02f, -4.47778814e-02f, -2.17929538e-02f, -1.53695300e-01f, -3.37725013e-01f, 1.74177244e-01f, -2.57262401e-02f,
  -1.56082243e-01f, -3.09963018e-01f, -1.14527069e-01f, 1.33339062e-01f, -1.98690757e-01f, -2.56067574e-01f, -3.32985744e-02f, 2.58400629e-04f, 2.09244117e-02f, 2.43896544e-01f,
  -1.60254419e-01f, 1.13589115e-01f, -3.57788689e-02f, 1.36156874e-02f, -2.93456137e-01f, 1.90615848e-01f, 4.03714299e-01f, -2.26721570e-01f, -1.76468119e-01f, -8.25232416e-02f,
  -1.33427769e-01f, -3.25092976e-03f, 9.38134715e-02f, 1.74333021e-01f, -8.98971334e-02f, 2.35183150e-01f, 1.38872698e-01f, -8.52048099e-02f, -2.29800418e-02f, 2.56034553e-01f,
  1.02153569e-01f, 1.08632974e-01f, 2.22122315e-02f, 2.94729620e-02f, 1.08348250e-01f, 3.62350531e-02f, -6.25625700e-02f, -1.81340992e-01f, 1.70413539e-01f, -1.73966467e-01f,
  -2.17111222e-02f, 3.26942295e-01f, 1.88459735e-02f, 5.64800501e-02f, -1.42083883e-01f, -1.50372133e-01f, -1.42300492e-02f, 1.75302997e-01f, 4.54975277e-01f, -9.01915971e-03f,
  -5.68386689e-02f, -5.92618110e-03f, 1.54191265e-02f, 2.70479292e-01f, 3.31908822e-01f, -8.26508775e-02f, 2.55457461e-01f, 4.35054839e-01f, -2.68950492e-01f, 2.18550004e-02f,
  -2.09146619e-01f, -1.36135355e-01f, 1.25970826e-01f, 1.92863435e-01f, -1.75747246e-01f, -9.19201523e-02f, 3.36124986e-01f, -2.09181860e-01f, 5.28428257e-02f, 2.98353173e-02f,
  3.97405893e-01f, 1.26076549e-01f, 2.42122710e-01f, 2.98326850e-01f, 2.43181065e-01f, 2.22071514e-01f, 1.39636025e-01f, -9.03589576e-02f, -6.17336407e-02f, -2.58046180e-01f,
  7.79596940e-02f, -3.15474719e-01f, 5.09513497e-01f, -1.48298025e-01f, -1.85327176e-02f, 2.54665703e-01f, 2.81668723e-01f, 2.20754802e-01f, 9.01036933e-02f, 2.18000546e-01f,
  -2.47187808e-01f, -2.50776082e-01f, 5.84040396e-02f, 1.56813115e-01f, -1.57385245e-01f, 1.43786669e-01f, -1.34369791e-01f, 1.70395926e-01f, -1.24933384e-01f, 9.72349942e-02f,
  3.51157308e-01f, 9.97200795e-03f, 2.49236688e-01f, 8.44763517e-02f, -1.51346117e-01f, -2.03890562e-01f, -1.58906281e-01f, -6.44675642e-02f, -2.79773653e-01f, -1.41578868e-01f,
  8.30990598e-02f, -2.24296302e-02f, 7.26571083e-02f, -7.94191957e-02f, -4.90952097e-02f, -2.53742069e-01f, -4.73798439e-02f, -2.65892684e-01f, 4.48963456e-02f, -8.65921378e-02f,
  -1.45345226e-01f, -9.16805863e-02f, -3.40239890e-02f, -1.35844558e-01f, 1.12056509e-02f, 3.65590215e-01f, 2.44900100e-02f, 1.84596315e-01f, -1.39200389e-01f, -9.22863558e-02f,
  -2.20159646e-02f, -1.39393330e-01f, -1.40171707e-01f, 3.21036801e-02f, 9.44534391e-02f, -3.21524553e-02f, -2.48779252e-01f, 7.85834268e-02f, 1.45765901e-01f, 2.29500681e-01f,
  1.93972111e-01f, 7.02446699e-02f, 2.45166928e-01f, 3.98972541e-01f, 4.56347317e-02f, -7.91393314e-03f, -4.87799458e-02f, -9.42576677e-02f, 1.51149601e-01f, -3.39819938e-01f,
  8.67315456e-02f, -1.99399907e-02f, 1.91729054e-01f, 7.70404353e-04f, 3.10203377e-02f, -6.82982057e-02f, -4.94793877e-02f, 9.03536603e-02f, 1.27506807e-01f, 2.71865070e-01f,
  -5.30018359e-02f, 1.57854632e-01f, 8.51944089e-02f, -8.79517570e-02f, -5.75599372e-02f, -7.29039311e-02f, 2.37152100e-01f, 9.01447386e-02f, -7.20240101e-02f, 3.35048512e-02f,
  1.25480473e-01f, -1.54274955e-01f, 1.26253650e-01f, 2.00078219e-01f, -6.41498268e-02f, -6.58124089e-02f, 1.38522744e-01f, -4.06165533e-02f, -1.45698145e-01f, 1.08952276e-01f,
  -1.06172629e-01f, -9.55671072e-03f, 1.31637946e-01f, 1.31678476e-04f, 1.55820444e-01f, 6.45607784e-02f, 2.13791817e-01f, 1.86149672e-01f, -1.35659456e-01f, -9.69783142e-02f,
  8.23730826e-02f, -2.04864994e-01f, -2.95624524e-01f, -1.26685858e-01f, 7.11522698e-02f, 4.32483898e-03f, 2.74618626e-01f, -1.70489013e-01f, -5.14335968e-02f, 1.78631976e-01f,
  -1.40834585e-01f, 1.99548110e-01f, 7.33851343e-02f, 2.36130580e-01f, -1.96103364e-01f, 9.70997214e-02f, -1.89180434e-01f, 2.28228286e-01f, 3.84793669e-01f, -2.14269713e-01f,
  -3.59846741e-01f, 1.48901924e-01f, 5.22144437e-02f, -1.55756608e-01f, 3.59448157e-02f, -3.66865814e-01f, 2.35508233e-02f, 2.56445110e-01f, 1.47375852e-01f, -4.41691130e-01f,
  -1.75387695e-01f, -1.77321598e-01f, 1.07867584e-01f, -6.44858032e-02f, 1.02508910e-01f, 1.68097913e-01f, 1.74679503e-01f, 1.82635218e-01f, -2.44186521e-01f, -2.85208106e-01f,
  2.88665742e-01f, 7.36771971e-02f, 1.75158635e-01f, 3.38393331e-01f, -2.97004692e-02f, -2.42289722e-01f, -3.73846889e-02f, 1.85123041e-01f, 2.97294199e-01f, 5.40418923e-02f,
  -1.83928069e-02f, -2.30795034e-04f, 6.98065236e-02f, 3.54659617e-01f, -3.82404029e-02f, 2.59380247e-02f, -1.19659185e-01f, 2.40969419e-01f, 2.01015890e-01f, -2.74584591e-01f,
  4.02144194e-02f, -2.36699000e-01f, 2.04566687e-01f, -2.85530001e-01f, 3.45962614e-01f, -2.44923726e-01f, -3.75768751e-01f, -2.52758652e-01f, -5.51118404e-02f, -1.63494051e-01f,
  5.10084704e-02f, -1.46410868e-01f, -1.32201210e-01f, 4.46329899e-02f, -9.37410444e-02f, 1.84264705e-01f, -7.77420774e-02f, -2.62309574e-02f, 2.72887703e-02f, -1.53970093e-01f,
  -1.89924479e-01f, 9.46187153e-02f, 2.93561164e-02f, 2.98662614e-02f, -1.71624213e-01f, -2.29792632e-02f, -1.21709011e-01f, -2.44979545e-01f, -8.75558257e-02f, -2.19881348e-02f,
  -1.41887158e-01f, -1.50861263e-01f, 1.10840648e-01f, -2.83239745e-02f, -1.15058534e-01f, 4.40298952e-02f, 1.65430337e-01f, 1.84844360e-01f, -2.72507500e-02f, -4.08560671e-02f,
  2.28193536e-01f, 4.76388112e-02f, -3.04857880e-01f, -3.49757969e-01f, 5.21573648e-02f, -1.99346438e-01f, 4.27673124e-02f, -1.09599777e-01f, 3.09830140e-02f, -1.07581995e-01f,
  -6.91559836e-02f, 2.37788156e-01f, 9.73616242e-02f, 6.16490617e-02f, -3.11089829e-02f, 1.64054558e-02f, 6.16254173e-02f, -3.11575904e-02f, -9.19486061e-02f, -2.19791830e-01f,
  -7.90714771e-02f, -2.36564577e-01f, -7.40753487e-02f, -2.33350564e-02f, -4.41989675e-02f, -2.22266372e-02f, 6.49321526e-02f, 8.12882483e-02f, -1.51248217e-01f, -6.23006709e-02f,
  2.40681067e-01f, -2.36865416e-01f, 2.56253518e-02f, -2.13774741e-01f, 1.87786222e-01f, -7.82981738e-02f, -2.06790864e-01f, 2.45427802e-01f, 1.69049039e-01f, -1.18424706e-01f,
  1.63230181e-01f, -1.07151300e-01f, -2.11341918e-01f, 1.01404570e-01f, 4.32810746e-02f, 3.02457154e-01f, 1.67526975e-02f, -1.48088848e-02f, 3.86000901e-01f, 4.97921258e-02f,
  1.08910315e-02f, 7.04825073e-02f, 5.14131114e-02f, 2.14788809e-01f, -1.32893622e-02f, -5.69407567e-02f, 1.88853294e-01f, 2.87941881e-02f, 2.52666026e-01f, 2.48248894e-02f,
  3.22229788e-02f, 1.72937952e-03f, 4.98076119e-02f, 2.40782842e-01f, 1.01803854e-01f, 2.31681496e-01f, 2.25195348e-01f, 2.25923657e-01f, 1.41773904e-02f, 3.34857821e-01f,
  2.65085176e-02f, 2.43526235e-01f, -2.34769732e-01f, -3.71269807e-02f, 3.45782377e-02f, -1.36442892e-02f, 9.49662253e-02f, 3.33796889e-02f, -1.66252747e-01f, -1.58455163e-01f,
  2.65931450e-02f, 2.24670082e-01f, -2.49524862e-01f, 8.87782797e-02f, -1.34192985e-02f, -2.67438851e-02f, 2.21013591e-01f, -5.19774109e-02f, 8.55999589e-02f, -3.29252988e-01f,
  3.66947711e-01f, -9.39765722e-02f, 2.13570356e-01f, 3.29070687e-02f, 7.84738269e-03f, -1.78950727e-01f, -2.42259037e-02f, -1.14577465e-01f, -7.31885284e-02f, -2.18669847e-01f,
  -2.58541673e-01f, 5.68725653e-02f, -1.73634067e-02f, 1.02271579e-01f, -1.19579174e-01f, 6.07077498e-04f, 5.81394620e-02f, -1.51251424e-02f, -1.91456079e-02f, 1.59909382e-01f,
  -1.04573756e-01f, 3.52256775e-01f, 1.06618576e-01f, 8.48002061e-02f, 1.16321638e-01f, 9.56441760e-02f, 8.74230489e-02f, 1.03308633e-01f, 1.91087663e-01f, -1.33111894e-01f,
  2.31027920e-02f, 1.84633195e-01f, 1.22156821e-01f, 7.49227628e-02f, 1.38914555e-01f, 3.42903912e-01f, -1.46752924e-01f, 1.79870669e-02f, 2.04195976e-01f, 1.50169879e-01f,
  -3.07943728e-02f, 5.71780652e-02f, 1.90628588e-01f, -1.92943718e-02f, -7.13165849e-02f, -2.57934015e-02f, -3.15400988e-01f, -2.61525869e-01f, 1.74774647e-01f, 3.01781386e-01f,
  2.40607306e-01f, 2.26415116e-02f, 2.34843925e-01f, 1.77708223e-01f, -1.30363405e-02f, 1.51139557e-01f, 6.19149134e-02f, 1.22074090e-01f, -1.43646285e-01f, 1.26995623e-01f,
  -9.69398171e-02f, 1.77745540e-02f, 2.75431603e-01f, -4.12575424e-01f, 1.04523122e-01f, 2.90838238e-02f, -1.76741034e-01f, -2.68314600e-01f, 7.26480335e-02f, -1.37203023e-01f,
  -1.95725560e-01f, -1.35957778e-01f, 1.16003960e-01f, -7.25017861e-02f, 1.68474317e-01f, 2.94042170e-01f, -3.74278799e-02f, -1.68187525e-02f, 2.83924341e-01f, -3.99679765e-02f,
  -7.49294534e-02f, 1.35380492e-01f, 1.58579320e-01f, -1.66399498e-02f, -1.48897618e-01f, -1.09257579e-01f, -1.84372868e-02f, 1.92138478e-01f, 1.39660195e-01f, 1.76620647e-01f,
  -2.16501415e-01f, -1.43457621e-01f, -1.39965400e-01f, 1.75551891e-01f, -3.91466655e-02f, 4.50943932e-02f, -1.60393432e-01f, -2.79058814e-01f, 1.90242864e-02f, -1.58314764e-01f,
  9.16840062e-02f, 4.46005493e-01f, 2.95416951e-01f, 8.41196105e-02f, 1.17848292e-02f, -1.08578809e-01f, 4.34758961e-02f, 6.19811304e-02f, 1.54910058e-01f, -2.93660499e-02f,
  7.68011734e-02f, -1.52477548e-01f, 8.40162262e-02f, 2.36750111e-01f, -1.70039102e-01f, 1.08091041e-01f, -7.01094232e-03f, -4.64496166e-02f, 3.24945487e-02f, -2.12728813e-01f,
  6.34118989e-02f, -4.02817838e-02f, 6.26614597e-03f, 1.20383695e-01f, -2.20743433e-01f, 6.21398352e-02f, -1.39555946e-01f, 4.95318472e-02f, 6.00047186e-02f, 2.40278140e-01f,
  -1.24023519e-01f, 2.99746335e-01f, 8.31524804e-02f, -3.59907486e-02f, -2.79221058e-01f, -1.95874929e-01f, -3.86108518e-01f, -6.29139021e-02f, 1.20047018e-01f, -4.88803834e-02f,
  -1.98127657e-01f, 9.37137157e-02f, 3.98440883e-02f, 1.04969800e-01f, 8.76646042e-02f, -5.62587492e-02f, 8.88996944e-02f, 3.45141739e-02f, -3.40659991e-02f, 1.03628404e-01f,
  -8.02735165e-02f, -9.16889086e-02f, 8.10199007e-02f, -1.73514530e-01f, 1.55774862e-01f, 9.73102674e-02f, 4.40330207e-02f, 1.65158659e-01f, 1.48564130e-01f, -6.12061471e-02f,
  2.04179473e-02f, 1.19037636e-01f, 7.22212493e-02f, 1.03984483e-01f, 5.48641430e-03f, -6.85683712e-02f, 2.21692309e-01f, -3.26497033e-02f, -2.39335299e-01f, -1.22513674e-01f,
  9.11492333e-02f, 5.86918481e-02f, 9.74752530e-02f, 1.09861054e-01f, 1.05604669e-02f, 1.46594848e-02f, 6.65211901e-02f, 2.03895539e-01f, -9.26166028e-02f, 1.43249974e-01f,
  1.47145078e-01f, 1.96895093e-01f, 8.50272104e-02f, -5.78280911e-02f, -1.57498568e-01f, -1.02377534e-01f, -1.26690716e-01f, 6.06471114e-02f, -3.73752578e-03f, 1.91606998e-01f,
  2.38539860e-01f, 2.51816720e-01f, -8.65825489e-02f, -4.81017455e-02f, -2.33623996e-01f, -7.17691556e-02f, -1.07723273e-01f, -1.75215080e-02f, -2.08172262e-01f, 8.25326815e-02f,
  8.30682926e-03f, -3.23499888e-02f, 6.36607269e-03f, 1.57905474e-01f, 5.93832359e-02f, 1.90405637e-01f, 2.06919879e-01f, 5.56069836e-02f, 1.88551359e-02f, 2.41032094e-01f,
  7.38876611e-02f, 2.49430954e-01f, 2.42475331e-01f, 1.20189711e-01f, -3.29820186e-01f, 2.95086294e-01f, 2.40959167e-01f, 1.64537355e-01f, 3.82775776e-02f, -5.14257774e-02f,
  -8.15613866e-02f, 3.61892790e-01f, 7.28265569e-02f, -1.14357531e-01f, -2.56014969e-02f, -2.59542733e-01f, 4.81779687e-02f, -1.79482073e-01f, 1.61987111e-01f, 2.06816837e-01f,
  2.28067935e-01f, 3.21264088e-01f, -2.20736787e-01f, 2.26711690e-01f, -9.77927074e-02f, 1.85268298e-01f, 9.16367173e-02f, 1.99475825e-01f, 8.07392746e-02f, -1.11181945e-01f,
  -1.06964838e-02f, -1.13992453e-01f, 5.43304496e-02f, -4.50509973e-02f, 9.16761234e-02f, 6.22893404e-03f, 7.60604218e-02f, 1.26260743e-01f, -2.17647757e-02f, -6.07497841e-02f,
  -1.42866045e-01f, 4.10663001e-02f, -1.69869021e-01f, 1.99107695e-02f, 2.41973437e-02f, -1.46775514e-01f, 8.31716582e-02f, 1.07613012e-01f, 1.12777531e-01f, -8.26981571e-03f,
  -2.83586383e-02f, -2.16633871e-01f, -2.58294582e-01f, -1.75793953e-02f, -9.63314474e-02f, -2.43359774e-01f, -3.97111624e-01f, 3.05717349e-01f, -2.47318950e-02f, 1.24347128e-01f,
  1.02022767e-01f, 9.68735591e-02f, -1.19182877e-01f, 1.65287092e-01f, -2.26061535e-03f, 4.34525132e-01f, 3.59571785e-01f, -3.23349118e-01f, -4.38913889e-02f, 1.54655976e-02f,
  -8.52244049e-02f, -3.12739670e-01f, -1.73575312e-01f, -4.16457020e-02f, -1.05568126e-01f, 4.18752357e-02f, 3.65219682e-01f, 1.46122440e-03f, 2.50979979e-02f, 1.23389974e-01f,
  1.87498331e-01f, -9.81757417e-03f, -1.49849057e-01f, 1.85701028e-01f, 2.55266815e-01f, 3.61345291e-01f, -1.22407161e-01f, -2.12096676e-01f, 1.16874300e-01f, 1.16968721e-01f,
  2.00140819e-01f, 5.05711257e-01f, 1.21261157e-01f, 2.60505397e-02f, -8.41168920e-04f, 1.15633585e-01f, -8.71457532e-02f, -1.97847113e-02f, 2.87112445e-01f, 1.03219971e-01f,
  3.67322117e-02f, -5.03945500e-02f, 2.65338451e-01f, 1.57319158e-01f, 2.37116605e-01f, 3.05694342e-03f, 8.78566056e-02f, 3.27414244e-01f, -2.20747843e-01f, 2.62143821e-01f,
  -2.06275493e-01f, 5.85891083e-02f, -1.97180703e-01f, 1.07280672e-01f, 3.07629496e-01f, 2.83567667e-01f, -1.16719291e-01f, -7.36690238e-02f, -8.24366361e-02f, 1.65911645e-01f,
  9.65933725e-02f, 1.03970811e-01f, 2.14869186e-01f, -5.01026027e-02f, 2.77980149e-01f, -1.81949556e-01f, 2.05219328e-01f, -1.02278672e-01f, 1.05699502e-01f, 8.12864155e-02f,
  2.74413377e-02f, -1.96984410e-01f, 2.07992226e-01f, 1.10554829e-01f, -4.61684465e-02f, 2.50973463e-01f, 1.72115371e-01f, 2.46090546e-01f, -2.43661627e-01f, 2.77031958e-01f,
  -3.55563238e-02f, 4.63936739e-02f, 7.08397524e-03f, 9.20129344e-02f, 2.42857877e-02f, -4.22067046e-02f, -7.17390627e-02f, -9.45401564e-02f, -6.30006241e-03f, 2.35966101e-01f,
  2.96815455e-01f, 2.61554420e-01f, -1.21407717e-01f, 2.09659740e-01f, 1.07936651e-01f, 1.61651284e-01f, 2.52288252e-01f, 2.85191208e-01f, 9.34846476e-02f, -2.37583518e-01f,
  -2.11688168e-02f, -1.04925029e-01f, 5.50947078e-02f, 1.47981063e-01f, -2.29823869e-02f, -1.35617435e-01f, 1.28021151e-01f, -1.62644953e-01f, -6.61936449e-03f, -4.74436916e-02f,
  -5.24071557e-03f, -2.40802363e-01f, 2.40158988e-03f, 1.92976013e-01f, 1.60178408e-01f, 2.51138896e-01f, -2.87050515e-01f, 1.55583173e-01f, 2.60780036e-01f, 2.23261058e-01f,
  7.48731270e-02f, -3.51744264e-01f, 2.53498107e-01f, 2.13119775e-01f, 4.41140383e-02f, -4.46645558e-01f, 1.02135688e-01f, 1.53468940e-02f, 1.35093093e-01f, 1.27875283e-01f,
  5.63235991e-02f, 2.21578494e-01f, 6.06483556e-02f, -1.54317111e-01f, -3.91984522e-01f, 2.32091770e-01f, -5.89645701e-03f, -1.73151538e-01f, 2.25049187e-03f, 6.89182803e-02f,
  -6.74528927e-02f, -3.64326723e-02f, -7.80716687e-02f, 1.77650124e-01f, 4.40940261e-02f, 5.06968163e-02f, 1.53187022e-01f, 1.54465839e-01f, 7.52432346e-02f, -4.22061831e-02f,
  6.66093379e-02f, -1.57571256e-01f, 1.36906400e-01f, -2.47824058e-01f, 1.77659050e-01f, 1.48911506e-01f, 1.81518987e-01f, 2.11962134e-01f, -2.91056726e-02f, -8.31398889e-02f,
  7.99916685e-02f, 2.38745853e-01f, 1.77233130e-01f, 7.03265369e-02f, -1.98992016e-03f, 1.41761184e-01f, 1.10406376e-01f, 3.79874185e-02f, 7.69473985e-02f, 2.57178605e-01f,
  1.77217163e-02f, 2.76070654e-01f, -5.76694310e-02f, 2.65306115e-01f, 2.75318027e-01f, 8.82012993e-02f, -3.40639912e-02f, -2.98934162e-01f, 2.68098682e-01f, -6.95199966e-02f,
  2.56941855e-01f, -8.21544044e-03f, -3.75994742e-01f, 1.65561795e-01f, -2.41320074e-01f, -2.63567120e-01f, -5.69247156e-02f, -2.04320904e-02f, 1.47864714e-01f, -2.39425614e-01f,
  -8.08289722e-02f, 3.71794492e-01f, -1.17378913e-01f, 1.67444572e-01f, 2.88136393e-01f, -6.39626160e-02f, 1.52582407e-01f, -2.36608118e-01f, -1.18998833e-01f, 3.83019567e-01f,
  -3.46058041e-01f, 4.78594974e-02f, 9.06786919e-02f, 1.69813305e-01f, -3.05198133e-02f, -1.63037404e-02f, 9.42400023e-02f, 8.82360712e-03f, -3.83053273e-02f, 8.06116760e-02f,
  5.13470694e-02f, -5.24112023e-03f, 1.35944471e-01f, 2.11631760e-01f, 1.28306761e-01f, 3.34610678e-02f, 1.34247869e-01f, -1.31460264e-01f, -1.63877249e-01f, -9.59154442e-02f,
  3.15804958e-01f, -3.93648371e-02f, -1.77603334e-01f, -1.37046590e-01f, -2.19654217e-02f, 1.19249016e-01f, 1.98997810e-01f, 2.50197560e-01f, 4.72728014e-02f, -1.07160002e-01f,
  1.17942229e-01f, 2.62226522e-01f, 5.11692278e-02f, 1.94461584e-01f, 5.48110604e-02f, 3.97311486e-02f, -2.08198532e-01f, 1.34292722e-01f, 1.04894362e-01f, -3.17598991e-02f,
  4.78931591e-02f, -3.73653233e-01f, 4.50119972e-01f, 6.39352649e-02f, -1.51757881e-01f, -8.58936459e-02f, 1.07972771e-01f, 2.14654043e-01f, 3.48810165e-04f, -3.97593945e-01f,
  -4.03652936e-02f, 7.39612654e-02f, -1.71033442e-01f, -6.36742413e-02f, 6.38084561e-02f, -2.78516728e-02f, 2.42841065e-01f, 1.75522044e-02f, 1.27800241e-01f, -1.04619004e-01f,
  1.46294758e-01f, -2.27166995e-01f, -3.19617450e-01f, 3.07441145e-01f, 2.27950796e-01f, 2.06125990e-01f, -7.41702924e-03f, 2.89264977e-01f, -2.50900328e-01f, 2.04117522e-02f,
  -1.91548303e-01f, -1.20029978e-01f, 9.60573629e-02f, 2.04761133e-01f, -4.38548848e-02f, -1.25615492e-01f, 1.00648314e-01f, 9.33659449e-02f, 1.84601143e-01f, 7.73394830e-04f,
  2.16013297e-01f, 1.76768363e-01f, 9.47735459e-02f, 2.90028840e-01f, -8.59103948e-02f, 2.88727820e-01f, 1.26315475e-01f, -3.17763597e-01f, -6.68961033e-02f, -3.24263126e-02f,
  2.46863246e-01f, 2.05309451e-01f, 1.32721946e-01f, 2.50308104e-02f, 2.61475176e-01f, 8.07897896e-02f, 1.19708814e-01f, 1.28639698e-01f, 4.03054446e-01f, 7.77975693e-02f,
  2.19453514e-01f, 2.97081411e-01f, 1.06033221e-01f, 2.25371599e-01f, -1.04469553e-01f, -9.69156846e-02f, -4.13021833e-01f, -2.51402948e-02f, 2.37747371e-01f, -1.28491983e-01f,
  3.98746785e-03f, -2.40640774e-01f, 9.53125060e-02f, 1.86853275e-01f, 1.80613130e-01f, -1.69326022e-01f, 1.98627695e-01f, 3.24178427e-01f, 2.44416893e-01f, 5.52733466e-02f,
  5.08794114e-02f, 6.50765002e-02f, -4.74690013e-02f, 3.62945944e-02f, -2.09461093e-01f, 5.89356832e-02f, 1.29673973e-01f, -3.11563373e-01f, 2.06546873e-01f, 3.11831951e-01f,
  -1.30814224e-01f, 3.79232951e-02f, 9.54326987e-03f, 1.83641128e-02f, 9.62597728e-02f, 1.82037964e-01f, 1.26790744e-03f, -3.37586671e-01f, -1.97224393e-01f, 1.25267103e-01f,
  1.38210002e-02f, -2.08836183e-01f, 1.85100123e-01f, 3.91058475e-01f, 1.18480504e-01f, 1.08776629e-01f, 1.44185081e-01f, -8.55710581e-02f, -4.32833880e-02f, 2.35359594e-01f,
  1.53352544e-01f, 2.47789755e-01f, 1.65143326e-01f, 8.22905824e-02f, -8.87034908e-02f, 9.40492228e-02f, -1.38450190e-01f, -8.56898874e-02f, 2.70178597e-02f, 3.44339833e-02f,
  1.98391140e-01f, -1.65052578e-01f, 9.70518142e-02f, 9.65287723e-03f, 1.57395080e-02f, 8.84785876e-02f, -1.91021115e-02f, -7.14195222e-02f, -9.43079533e-04f, 4.09934893e-02f,
  1.96117595e-01f, 2.01104626e-01f, -8.84173363e-02f, 2.30255440e-01f, 1.52658567e-01f, 7.99363479e-02f, -3.50472659e-01f, -1.26458630e-01f, -2.84063578e-01f, 1.33016899e-01f,
  1.01415709e-01f, -1.11321740e-01f, -1.16178922e-01f, 3.42864245e-02f, -6.11532107e-02f, 9.92605230e-04f, 2.22376928e-01f, 1.35153696e-01f, 7.39909783e-02f, 2.19639599e-01f,
  2.77674161e-02f, -7.05012903e-02f, -2.71202564e-01f, 3.73619199e-02f, -3.68820913e-02f, -1.94046989e-01f, -1.34038925e-01f, -3.03727817e-02f, -1.17287211e-01f, 1.80397809e-01f,
  -1.10548595e-02f, 1.91530421e-01f, 9.69120488e-02f, 1.42635882e-01f, 2.53609359e-01f, -2.05703065e-01f, 1.03110351e-01f, -7.52086937e-02f, 1.70438066e-01f, 2.67326366e-02f,
  -1.26500413e-01f, -1.19638769e-02f, -1.82723641e-01f, 8.75384584e-02f, 2.52511889e-01f, 1.30986989e-01f, 3.40214461e-01f, 1.27250165e-01f, 1.61009386e-01f, 2.28283525e-01f,
  1.39741506e-02f, -5.84917422e-03f, 1.13842942e-01f, 2.64345556e-01f, -2.01378375e-01f, -1.52729973e-01f, -1.97067097e-01f, -1.58685178e-01f, 3.25725004e-02f, -8.22925270e-02f,
  4.03259844e-02f, -2.46988297e-01f, -1.01077475e-01f, 4.03342575e-01f, -6.83139190e-02f, 1.73292652e-01f, -1.62512764e-01f, 2.83273429e-01f, 2.63141513e-01f, 8.46743807e-02f,
  3.51617515e-01f, -2.68058836e-01f, 4.29316372e-01f, 2.84008235e-01f, 3.07606041e-01f, -3.90232652e-01f, -4.87911478e-02f, -4.97184172e-02f, 2.48068735e-01f, 1.47295952e-01f,
  1.24023408e-01f, 3.32681715e-01f, 2.00109646e-01f, -1.23974465e-01f, -2.35252380e-01f, 1.85424238e-01f, 2.90565908e-01f, -1.73861846e-01f, 1.83303460e-01f, 8.57013538e-02f,
  -7.27126747e-02f, -8.79040211e-02f, -1.79563582e-01f, 1.43214390e-01f, 2.49745301e-03f, -1.12412944e-01f, 2.03245983e-01f, 6.27895594e-02f, 2.67617285e-01f, 2.40718238e-02f,
  -9.39292554e-03f, -1.90928102e-01f, -1.58840567e-02f, -1.40047610e-01f, 1.50217703e-02f, 2.39020780e-01f, 9.97760445e-02f, 2.45636463e-01f, -1.19104058e-01f, -4.63875156e-04f,
  1.61857158e-01f, 2.35225454e-01f, 3.35040055e-02f, -7.58104399e-02f, -2.12645024e-01f, 1.56582311e-01f, -7.03956410e-02f, -1.28700867e-01f, 6.05312139e-02f, -3.10273230e-01f,
  -1.22768380e-01f, -2.06275299e-01f, 2.56654382e-01f, 2.34543271e-02f, -7.03551769e-02f, 1.43130571e-01f, -8.46920256e-03f, 2.33753636e-01f, -2.58098334e-01f, 2.85015047e-01f,
  -6.86342940e-02f, 2.40215242e-01f, 2.66520977e-02f, -1.33471355e-01f, -2.03254580e-01f, 1.23847820e-01f, -8.47911555e-03f, 5.56947216e-02f, 1.86805785e-01f, 1.33632153e-01f,
  -1.24954013e-02f, 6.58307076e-02f, 1.05193995e-01f, 1.22074798e-01f, 4.39301971e-03f, 1.78466320e-01f, -3.96618024e-02f, 1.05995163e-01f, 3.30965191e-01f, -8.27560946e-02f,
  -2.10322946e-01f, 9.30998698e-02f, 3.02135758e-02f, -2.22619295e-01f, 1.08063832e-01f, -2.58109033e-01f, 1.51860893e-01f, 3.99692953e-01f, -1.65894348e-02f, -2.49890372e-01f,
  -8.22961051e-03f, 1.81760386e-01f, 1.14917368e-01f, -1.69148654e-01f, 1.67930067e-01f, 1.40439570e-02f, -3.12475748e-02f, -3.71029526e-02f, -5.98461255e-02f, -1.45131975e-01f,
  1.36942342e-01f, 1.01364134e-02f, 2.06081346e-01f, 2.16140896e-01f, 1.77482352e-01f, 1.40869126e-01f, 7.51855373e-02f, 1.01908259e-02f, -3.37656513e-02f, 4.77773435e-02f,
  2.00534567e-01f, -3.19735408e-02f, 9.99259576e-02f, 6.79818764e-02f, 1.06271684e-01f, 1.36338145e-01f, 1.84431374e-01f, 2.35439911e-02f, 9.60428640e-02f, 5.08484803e-02f,
  -1.61322698e-01f, 2.64618397e-01f, -7.03020394e-02f, 2.81607267e-02f, 1.31418854e-01f, 3.50264646e-02f, -1.62869796e-01f, 2.93873399e-01f, -3.40170115e-02f, 8.34000409e-02f,
  -1.47416115e-01f, 2.07975626e-01f, 1.22457579e-01f, 3.10850404e-02f, -6.27294108e-02f, -5.46493754e-02f, -1.48205012e-01f, 3.22238915e-02f, -5.40104974e-03f, 1.35700256e-01f,
  1.43542632e-01f, -1.21046424e-01f, 1.46250606e-01f, -4.25185375e-02f, -3.52698117e-01f, -2.12089662e-02f, 6.94976002e-02f, 1.41613886e-01f, 1.84107739e-02f, 3.50024849e-02f,
  -2.13580467e-02f, 7.33019784e-02f, -1.42356381e-01f, 2.90488273e-01f, 5.41711487e-02f, 2.17985332e-01f, 1.08870603e-01f, -1.52204305e-01f, 1.11236908e-01f, -9.38839167e-02f,
  -1.42540168e-02f, 8.03574803e-04f, -2.08751351e-01f, -2.16098249e-01f, 8.57013315e-02f, 1.29255233e-02f, 8.72120038e-02f, 2.05947280e-01f, 3.78710538e-01f, 3.05592477e-01f,
  1.06858380e-01f, -8.44198838e-02f, -1.54948846e-01f, 7.31760859e-02f, -7.26602972e-02f, -1.84323117e-01f, 1.95596918e-01f, 6.42775223e-02f, 1.42942861e-01f, 2.51480527e-02f,
  3.20764363e-01f, 9.44483206e-02f, 3.73627245e-01f, 1.38116911e-01f, -2.03491151e-01f, -8.01189467e-02f, -2.04978153e-01f, -2.84569561e-01f, 3.49853516e-01f, 2.54725635e-01f,
  -1.64171737e-02f, -4.75712009e-02f, -9.99115333e-02f, 6.35407269e-02f, -2.44614348e-01f, -1.48404047e-01f, 1.66996047e-01f, -5.76195791e-02f, 1.87861901e-02f, 2.80087143e-01f,
  -8.90723243e-02f, 2.88191497e-01f, 2.31627926e-01f, -2.44312122e-01f, -9.54912454e-02f, -2.67020226e-01f, 1.68760568e-01f, 9.19539202e-03f, -1.44570112e-01f, -1.24179251e-01f,
  -1.19688906e-01f, 1.98168769e-01f, 1.10081851e-01f, 2.90652037e-01f, 4.20308203e-01f, 1.82011932e-01f, 1.00505225e-01f, -1.40016735e-01f, -1.28648683e-01f, 2.65806407e-01f,
  2.27073431e-01f, 2.04525277e-01f, -1.57974437e-01f, -2.95351356e-01f, -1.50714338e-01f, -1.06538221e-01f, -1.59569979e-01f, -8.18696395e-02f, 2.15448380e-01f, -2.04390407e-01f,
  -1.38009816e-01f, -3.48085500e-02f, 8.12814459e-02f, 1.71416759e-01f, -3.05081844e-01f, 2.26324320e-01f, 1.43393233e-01f, 6.39793277e-02f, 1.56698555e-01f, 1.40828833e-01f,
  2.44584382e-01f, 2.09509984e-01f, 1.45255074e-01f, 1.57631487e-01f, 5.47142513e-02f, 4.71984744e-02f, 2.03781694e-01f, 1.51150495e-01f, 1.96920753e-01f, -1.75798267e-01f,
  2.72873957e-02f, 2.74606366e-02f, 2.44643867e-01f, -3.68015289e-01f, -1.82730794e-01f, -7.73351640e-02f, -1.13528751e-01f, -1.62701622e-01f, 2.55263537e-01f, -1.16896540e-01f,
  -1.60159707e-01f, 2.10111812e-01f, 2.24028766e-01f, 1.58464223e-01f, 1.58762947e-01f, -1.75077334e-01f, -5.87757863e-02f, 5.55571616e-02f, -3.34366918e-01f, 5.25182486e-02f,
  -9.16448515e-03f, -4.05245647e-02f, 1.29499119e-02f, 3.37749869e-01f, -1.22399084e-01f, 1.07853167e-01f, -2.38110512e-01f, 4.83913273e-02f, 4.09084521e-02f, 7.17716441e-02f,
  1.86984360e-01f, -3.86303812e-01f, -3.43491942e-01f, -3.85954767e-01f, 5.44172674e-02f, -2.12923855e-01f, 1.91460863e-01f, 2.18016312e-01f, 1.91106051e-01f, 2.16266274e-01f,
  1.06911138e-01f, 9.79478657e-02f, -2.68523633e-01f, 2.18972936e-01f, 1.65850580e-01f, 8.66652876e-02f, -9.83375832e-02f, -1.53370023e-01f, -2.06077080e-02f, 2.48349691e-03f,
  1.50047066e-02f, 3.98911573e-02f, 7.47487843e-02f, 1.77018464e-01f, 2.11095631e-01f, 2.41179273e-01f, 1.45163462e-01f, 4.57692891e-02f, 1.30452678e-01f, -7.60578960e-02f,
  2.26215377e-01f, 7.62385949e-02f, -7.18606934e-02f, 1.48802608e-01f, 1.17174312e-01f, -4.09891196e-02f, -4.26874757e-02f, -9.00700390e-02f, 2.01714650e-01f, 2.54106402e-01f,
  7.87153989e-02f, -1.61055490e-01f, 9.93154198e-02f, 1.79513767e-01f, 1.92520842e-01f, -1.92225814e-01f, 1.10666364e-01f, -8.20132941e-02f, 7.60870874e-02f, -5.25048040e-02f,
  2.71131217e-01f, 2.28075553e-02f, 1.08194895e-01f, -3.12374651e-01f, -3.15372854e-01f, 1.55703753e-01f, 2.12560996e-01f, 1.05796732e-01f, -7.66340569e-02f, 1.79536492e-01f,
  -2.22839817e-01f, 1.95221722e-01f, -2.93477863e-01f, 8.91231969e-02f, 1.67427361e-02f, 5.41318394e-03f, 2.34721854e-01f, 1.24061473e-01f, 1.56199373e-02f, -1.45875677e-01f,
  -8.03492442e-02f, -1.54623896e-01f, -1.48224747e-02f, -3.13587636e-02f, 2.39880592e-01f, 3.47466290e-01f, -1.23298150e-02f, 1.13402456e-01f, -4.20779735e-02f, -3.49284321e-01f,
  2.27877364e-01f, 1.75231799e-01f, 7.49419560e-04f, -1.72408596e-01f, 2.74271760e-02f, -7.15792133e-03f, -1.08088784e-01f, 8.21529999e-02f, -9.61292721e-03f, 1.39885977e-01f,
  -1.19583607e-01f, 5.98296113e-02f, -3.71986926e-02f, 4.86911908e-02f, 5.83045669e-02f, -1.08328022e-01f, 1.59320995e-01f, -4.15275604e-01f, 2.81537831e-01f, -3.81717868e-02f,
  -1.09733649e-01f, 2.62281355e-02f, 5.77482134e-02f, 4.05141525e-02f, -1.87601373e-01f, -3.07278931e-01f, -1.42869338e-01f, 1.71046369e-02f, -1.46417364e-01f, -2.37966433e-01f,
  -4.88418862e-02f, 2.10508481e-01f, 1.25362799e-01f, 3.08734141e-02f, 2.01603062e-02f, 5.09507880e-02f, 6.25010878e-02f, -8.74050409e-02f, -3.20256650e-01f, 3.07466626e-01f,
  -3.26033294e-01f, 1.67713523e-01f, 7.62780607e-02f, 1.12782307e-01f, 8.32632631e-02f, 1.55785024e-01f, 1.10406242e-01f, -1.30774826e-01f, 1.82704985e-01f, 1.02680683e-01f,
  -8.61906409e-02f, -3.47972661e-02f, 1.53409645e-01f, 3.46333236e-01f, 1.15468122e-01f, 1.23954639e-01f, 1.27908006e-01f, 4.62182611e-02f, -2.18148425e-01f, 1.29294991e-01f,
  -2.22970545e-02f, 1.00446858e-01f, -7.47949332e-02f, -1.59446895e-01f, -2.15535522e-01f, -2.98150387e-02f, 2.27029622e-01f, 6.52213097e-02f, 2.45155692e-01f, 1.42511763e-02f,
  3.72970313e-01f, 5.01184799e-02f, 2.26132721e-02f, -1.56471804e-01f, 5.23107052e-02f, 7.83479959e-02f, 2.05981031e-01f, 8.91106501e-02f, -1.47225976e-01f, 1.41266227e-01f,
  -1.47118131e-02f, -3.16937789e-02f, -1.58075869e-01f, 3.65303457e-01f, -1.08235091e-01f, 4.34824079e-02f, 1.28957167e-01f, 7.86493048e-02f, 1.06327519e-01f, 2.80580390e-02f,
  2.18308181e-01f, 3.06100339e-01f, 8.10959116e-02f, 1.52297556e-01f, 5.82206137e-02f, -3.24293435e-01f, 3.34739298e-01f, 5.52961305e-02f, 3.25750798e-01f, 2.83104390e-01f,
  2.91563012e-02f, 3.49641740e-01f, 7.70395482e-03f, -1.96817040e-01f, 3.73870015e-01f, 8.24003220e-02f, 1.87069997e-02f, -1.40997231e-01f, -1.37234718e-01f, -1.42813221e-01f,
  -3.89785528e-01f, 7.79219344e-02f, -1.50295943e-01f, 9.83938500e-02f, 4.93346937e-02f, -3.61650134e-03f, 9.01604146e-02f, -3.27113122e-01f, 1.70803852e-02f, -4.93474351e-03f,
  -6.71052337e-02f, 2.13844091e-01f, 3.26154858e-01f, 7.71926269e-02f, -2.21762992e-02f, 9.72814187e-02f, 1.29878879e-01f, 1.79984719e-01f, 2.93197274e-01f, -2.45081130e-02f,
  9.49430540e-02f, -1.30099609e-01f, 5.62772974e-02f, 2.04969674e-01f, -1.98592111e-01f, 2.14309350e-01f, -5.02582341e-02f, 1.78517416e-01f, -3.04674417e-01f, -6.07816093e-02f,
  7.80605152e-03f, -9.28764716e-02f, 1.03080884e-01f, 1.13566704e-01f, -9.82161686e-02f, 1.05944246e-01f, -3.02701760e-02f, -1.98971078e-01f, 1.82105124e-01f, -2.90771842e-01f,
  -1.34669110e-01f, 1.29265279e-01f, -7.13929608e-02f, -1.07413173e-01f, 2.52430946e-01f, -1.06567331e-01f, 1.98302623e-02f, -2.99254470e-02f, 9.61979181e-02f, 1.15965314e-01f,
  9.87682566e-02f, 3.81254666e-02f, 8.36298764e-02f, -1.09082215e-01f, -7.99854621e-02f, 2.83681732e-02f, 1.15687154e-01f, 2.16588572e-01f, -2.23375693e-01f, 5.28016239e-02f,
  1.21249355e-01f, -5.57846837e-02f, -5.37994988e-02f, -1.26914725e-01f, -2.58084029e-01f, -2.32985038e-02f, -1.34298176e-01f, 7.60813281e-02f, 4.72855940e-02f, -7.17009529e-02f,
  2.02196866e-01f, 1.34483710e-01f, -2.99613811e-02f, -2.26204440e-01f, -7.03767240e-02f, 1.92437455e-01f, -4.38930281e-02f, 2.70241946e-01f, 3.62545624e-02f, -2.09083319e-01f,
  -2.41827846e-01f, -1.00611746e-01f, -4.32573110e-02f, -5.10619804e-02f, -1.72735691e-01f, -2.27370098e-01f, 3.35676223e-02f, 6.05570385e-03f, 1.28351435e-01f, 2.23642550e-02f,
  -1.07804827e-01f, 7.46764690e-02f, -8.20392277e-03f, 7.25782588e-02f, 3.27098928e-02f, 2.22865477e-01f, 6.10938072e-02f, 4.16386947e-02f, 1.05270319e-01f, -5.44128679e-02f,
  7.83503577e-02f, 7.93081075e-02f, 1.27654210e-01f, -5.48912510e-02f, -1.33460939e-01f, -9.97411907e-02f, 3.84651348e-02f, 3.83432693e-04f, 1.01058103e-01f, -1.38484538e-01f,
  1.40936270e-01f, -4.13765796e-02f, -1.20539196e-01f, 1.49453297e-01f, -7.14421719e-02f, -3.67177017e-02f, -2.15324670e-01f, -6.42303973e-02f, -1.95021108e-01f, 2.83660114e-01f,
  1.87634438e-01f, -5.57681583e-02f, -1.56279325e-01f, 2.01435946e-03f, 8.15983489e-02f, -1.60854101e-01f, -1.20696746e-01f, -1.29182011e-01f, -8.71395543e-02f, 7.38620088e-02f,
  1.46345317e-01f, -2.27857709e-01f, -6.84011355e-02f, 1.45070121e-01f, 1.56505153e-01f, -5.25683677e-03f, 1.03784166e-01f, 5.52995950e-02f, 3.33090663e-01f, 1.59853138e-02f,
  -2.50942826e-01f, -2.37255618e-01f, 1.09497480e-01f, 2.47171726e-02f, -5.55024063e-03f, 1.85837120e-01f, -9.57762897e-02f, 1.57737866e-01f, 2.03524873e-01f, 1.89362153e-01f,
  2.70936638e-01f, 1.72407597e-01f, 2.07216486e-01f, -2.77437679e-02f, 8.24456364e-02f, 1.08258091e-01f, -4.59460579e-02f, 2.13586286e-01f, 1.09432839e-01f, 2.51641214e-01f,
  2.04811677e-01f, 3.65894809e-02f, 1.35165274e-01f, -5.05578890e-02f, 1.46502435e-01f, -4.57325391e-02f, 1.52082473e-01f, -6.69899583e-02f, -4.19185996e-01f, 8.32956880e-02f,
  -1.38814762e-01f, -1.92157209e-01f, 1.80080775e-02f, 7.62829036e-02f, 3.71844262e-01f, -1.33099034e-01f, -6.00255504e-02f, 7.90877640e-02f, -8.89242291e-02f, 4.77827489e-02f,
  1.43734008e-01f, -7.65292868e-02f, -6.73125684e-02f, -1.99420556e-01f, 1.58150256e-01f, -6.29320443e-02f, -2.55376786e-01f, -6.64763525e-02f, 2.90537011e-02f, -9.37341005e-02f,
  -2.21248958e-02f, 3.43786851e-02f, -1.22116409e-01f, 4.63704877e-02f, 9.55240205e-02f, 1.14476569e-02f, -8.83846134e-02f, 1.97711065e-01f, 1.29187003e-01f, 1.53261930e-01f,
  -1.96942240e-02f, -1.88238714e-02f, 1.61977857e-01f, -1.90310050e-02f, -2.33048290e-01f, -8.47295374e-02f, 1.86052769e-01f, -1.77388161e-01f, -5.71629070e-02f, -6.78019077e-02f,
  9.85964537e-02f, 5.17808348e-02f, 9.71422121e-02f, 6.15503266e-02f, 1.91608489e-01f, 7.65636340e-02f, 2.77262241e-01f, 1.73834756e-01f, -4.47044671e-02f, 1.93353705e-02f,
  -3.71802822e-02f, -1.07937669e-02f, 3.18205990e-02f, 1.89180389e-01f, -1.89927053e-02f, -1.13390520e-01f, 2.15512127e-01f, 3.56096067e-02f, 2.98663042e-02f, 1.73104003e-01f,
  8.78166128e-03f, -2.35064447e-01f, -2.88219124e-01f, 1.48494244e-02f, -5.84846511e-02f, 7.82618523e-02f, 2.69520193e-01f, 1.72854275e-01f, 2.30940431e-01f, 1.09260105e-01f,
  -6.60768747e-02f, -2.23283228e-02f, -1.03214169e-02f, 7.40677938e-02f, -1.55617567e-02f, 1.50521412e-01f, 2.08556563e-01f, -8.00300390e-02f, 1.26149520e-01f, -1.11868106e-01f,
  -3.12397093e-01f, -6.31514192e-02f, 2.23401472e-01f, 8.94375369e-02f, -1.14365257e-01f, -2.98566461e-01f, -1.69513300e-01f, 1.98196083e-01f, -5.56157418e-02f, -1.27549376e-02f,
  -6.21895976e-02f, -4.26800363e-02f, 1.34878844e-01f, -1.06835708e-01f, 2.47178867e-01f, 1.76771149e-01f, 1.30465299e-01f, 5.57283945e-02f, -1.88886851e-01f, -6.86265435e-03f,
  8.16147551e-02f, -5.82611887e-03f, 1.07105300e-01f, 1.00717060e-01f, 7.85590112e-02f, 7.27357864e-02f, 5.05320244e-02f, 1.64984521e-02f, -5.74627966e-02f, -3.13201621e-02f,
  -7.67579079e-02f, 1.14299044e-01f, -6.01988845e-02f, -1.30052716e-01f, -1.02270499e-01f, 5.07001206e-03f, -4.47085723e-02f, 1.38788298e-01f, 3.84350419e-02f, 1.46879712e-02f,
  1.15920834e-01f, 1.38173267e-01f, -4.44046669e-02f, -2.78214123e-02f, -3.85696590e-02f, 8.27961266e-02f, -9.42829847e-02f, 1.99954242e-01f, -1.76816583e-01f, 2.28330418e-02f,
  2.54577845e-01f, 2.69382775e-01f, -1.27602313e-02f, 4.52276506e-02f, 1.52715176e-01f, -2.93930639e-02f, 1.25080213e-01f, 2.56256610e-01f, 3.00827920e-01f, 2.40461215e-01f,
  5.20360172e-02f, -5.84469996e-02f, 8.91443575e-04f, 1.61308989e-01f, -3.25213075e-01f, 1.52071983e-01f, -4.28607129e-02f, -5.63409850e-02f, -1.81613773e-01f, -1.71570107e-01f,
  -4.72037401e-03f, 1.56340331e-01f, 2.93025468e-02f, 2.39070039e-02f, -4.30778451e-02f, -1.38803653e-03f, 9.05384645e-02f, -8.93975794e-02f, 2.02260539e-01f, -2.26200372e-02f,
  6.83929957e-03f, 2.10325886e-02f, -5.11398911e-02f, 2.82654971e-01f, 2.04320684e-01f, -9.28887650e-02f, -4.75319773e-02f, 1.17068090e-01f, 1.83477938e-01f, 2.84636896e-02f,
  5.39726764e-02f, -1.03597291e-01f, 1.45279139e-01f, 1.06523141e-01f, 1.29292965e-01f, 1.30198225e-01f, 1.60429493e-01f, 2.16020226e-01f, 1.28986463e-02f, 2.99840588e-02f,
  -3.07343025e-02f, 2.52233535e-01f, 2.57794172e-01f, 1.21802688e-01f, 1.61147758e-01f, 1.33979350e-01f, 1.71525672e-01f, -2.59767354e-01f, 1.03972740e-01f, -2.70246416e-01f,
  -1.66152000e-01f, 1.00001937e-03f, -1.25061333e-01f, -5.29247038e-02f, 2.18923137e-01f, 1.28192112e-01f, -8.45019370e-02f, 1.70542784e-02f, 8.04352835e-02f, 3.06259990e-02f,
  1.86119769e-02f, 7.55455866e-02f, 1.69519559e-01f, 1.35539016e-02f, -4.99876700e-02f, -4.01675291e-02f, 1.95352361e-01f, -3.96483280e-02f, -7.59907588e-02f, 7.43628293e-02f,
  -1.56553939e-01f, 1.20384641e-01f, -5.39085045e-02f, 2.83380225e-02f, -2.01757208e-01f, 3.35398093e-02f, 1.58068404e-01f, -2.75169127e-02f, 6.45406991e-02f, -1.94575973e-02f,
  8.46924186e-02f, -7.23211910e-04f, 6.76221251e-02f, -1.25414759e-01f, 6.05541058e-02f, 1.38229616e-02f, -1.70785084e-01f, 8.40597525e-02f, 1.74017504e-01f, -1.15986122e-02f,
  -5.18666804e-02f, -7.05870837e-02f, 4.84708361e-02f, 6.41619414e-02f, -1.42891318e-01f, -1.36417717e-01f, -1.57358944e-01f, 1.63433596e-01f, -2.77650151e-02f, -2.81840265e-02f,
  1.16601378e-01f, -1.03478506e-01f, 5.00078574e-02f, 1.09787479e-01f, 1.88110769e-01f, -3.67507935e-02f, 1.50620505e-01f, 1.46234706e-01f, -3.21200460e-01f, 2.41047859e-01f,
  -1.90401375e-01f, 8.44645407e-03f, 1.99766085e-01f, 1.79904819e-01f, -2.16131061e-01f, 4.76646721e-02f, -2.11661622e-01f, 6.46685138e-02f, -2.43786752e-01f, 1.49903625e-01f,
  6.23074099e-02f, -1.46665610e-02f, 8.90798345e-02f, 1.42276943e-01f, 3.95479649e-02f, 1.74191579e-01f, 1.85202271e-01f, -5.76639036e-03f, -2.61337794e-02f, 1.13576911e-01f,
  1.66072801e-01f, -7.52578024e-03f, -2.90535599e-01f, 1.89882684e-02f, -1.15061188e-02f, 4.07480337e-02f, 2.49455884e-01f, 1.03911631e-01f, 8.59727040e-02f, 3.42398398e-02f,
  -1.68855041e-01f, 8.46969187e-02f, -4.78822589e-02f, 8.99814665e-02f, 5.83662614e-02f, 1.17773645e-01f, 3.32197174e-02f, -1.52901456e-01f, -2.18160704e-01f, 8.75006691e-02f,
  -4.25712997e-03f, 1.42077640e-01f, 1.09968275e-01f, -1.01167217e-01f, -8.99477750e-02f, 2.60815829e-01f, 2.12399289e-01f, 8.40494335e-02f, 1.16610073e-03f, 1.48469925e-01f,
  1.98207021e-01f, 3.58193628e-02f, 1.14490616e-03f, 1.04972824e-01f, 3.55676621e-01f, 2.89059579e-01f, 3.64764109e-02f, 2.16725543e-01f, -9.88282785e-02f, 3.33645731e-01f,
  9.21106189e-02f, 1.28422320e-01f, 1.47937700e-01f, -7.83150643e-02f, 1.87437534e-01f, -3.13151002e-01f, 2.56687969e-01f, -1.56695917e-01f, -2.81205624e-01f, -7.26635456e-02f,
  -1.91470757e-01f, -8.74348059e-02f, 1.90126896e-02f, -3.11595351e-02f, -2.84523845e-01f, 2.50784487e-01f, 1.96029916e-01f, 1.23587109e-01f, 2.27730647e-01f, 9.46222097e-02f,
  1.98096961e-01f, -1.23407640e-01f, -1.69953138e-01f, -8.69765058e-02f, -9.72923115e-02f, 1.43180877e-01f, -1.35376006e-01f, 3.15993905e-01f, -2.48729661e-01f, 5.57245724e-02f,
  -2.36721247e-01f, 1.82486009e-02f, -1.11366928e-01f, 1.39451042e-01f, 3.00817549e-01f, 7.25255886e-05f, -2.61645555e-01f, -8.62041265e-02f, 1.21733896e-01f, 9.89643931e-02f,
  2.72507221e-01f, 1.56183511e-01f, 3.09213668e-01f, 8.95844325e-02f, -5.13350684e-03f, 2.66132057e-01f, -1.09955356e-01f, 1.00168027e-01f, 1.18561268e-01f, -4.39523645e-02f,
  -8.95111337e-02f, -2.27592252e-02f, 1.35166913e-01f, 1.55613288e-01f, -2.06817582e-01f, -8.79503489e-02f, -9.57713425e-02f, 1.82563365e-01f, 7.91151896e-02f, -3.22775066e-01f,
  1.69898253e-02f, -2.69798994e-01f, 1.23377606e-01f, 5.95770450e-03f, -6.55669533e-03f, 4.95894589e-02f, -1.89680457e-01f, 3.73676986e-01f, -1.43031001e-01f, 2.27762625e-01f,
  -2.28700399e-01f, 4.62973893e-01f, 2.01953903e-01f, 2.89250582e-01f, -1.93604708e-01f, -1.79117154e-02f, 8.13643262e-03f, 2.70478874e-01f, 5.13512231e-02f, -1.22835629e-01f,
  1.43542185e-01f, -4.80150357e-02f, 8.51920322e-02f, 1.80607975e-01f, 9.82282534e-02f, 1.11974791e-01f, 1.02165610e-01f, 2.09322691e-01f, 2.38423813e-02f, 9.37208310e-02f,
  -1.51701391e-01f, -7.46942237e-02f, 1.77240923e-01f, 2.71162689e-02f, -1.12619102e-01f, -2.61978991e-02f, -1.70039937e-01f, 3.36481988e-01f, -3.05216033e-02f, -3.06970300e-03f,
  1.42867416e-01f, 2.34376609e-01f, 2.82108724e-01f, -4.97479327e-02f, 1.97329715e-01f, -1.33786798e-01f, 8.07559192e-02f, -1.33925816e-02f, -2.10349541e-02f, 1.46784052e-01f,
  5.39988540e-02f, -1.43928239e-02f, 3.63727771e-02f, 1.26947671e-01f, 3.24266493e-01f, 1.64384454e-01f, 1.86898023e-01f, -1.63231298e-01f, 5.93284294e-02f, 2.37586707e-01f,
  1.72437906e-01f, 4.26840037e-02f, 1.77793264e-01f, 1.96453631e-01f, 1.50503904e-01f, 7.61518180e-02f, 1.64248690e-01f, 6.55739158e-02f, 2.33770907e-01f, 3.19518983e-01f,
  -7.81363398e-02f, -2.70735063e-02f, -1.61655158e-01f, -3.45435083e-01f, 1.87036812e-01f, -1.31503260e-02f, -2.72542328e-01f, -8.65096673e-02f, -7.07768351e-02f, -6.90135583e-02f,
  -1.72488764e-01f, -3.02512854e-01f, -3.42759453e-02f, 1.81660742e-01f, 2.52782047e-01f, 2.53955752e-01f, 8.61805454e-02f, -3.51892561e-02f, 9.08792987e-02f, -8.71764719e-02f,
  -1.13672242e-01f, -2.52335489e-01f, 1.01065949e-01f, -3.13513912e-02f, 1.20009348e-01f, 1.48090407e-01f, -1.66832000e-01f, 2.51499325e-01f, 3.03201914e-01f, 1.88634858e-01f,
  2.87158430e-01f, -2.66754301e-03f, 1.58294097e-01f, -1.29253060e-01f, -4.51283082e-02f, 3.41608818e-03f, 1.76221564e-01f, 1.53227046e-01f, -9.10898671e-02f, -3.48206498e-02f,
  -5.94922863e-02f, 1.66713744e-01f, -4.00418676e-02f, 1.47495970e-01f, 2.53297269e-01f, 4.15623598e-02f, -4.63850126e-02f, 1.48396686e-01f, -6.73646927e-02f, -4.02348712e-02f,
  -3.10867429e-01f, 1.51255518e-01f, -1.66230306e-01f, 1.32638559e-01f, 7.11729825e-02f, 8.53932798e-02f, -2.00639039e-01f, -1.09601043e-01f, -2.88052201e-01f, 1.08729675e-01f,
  5.83084375e-02f, -6.64282888e-02f, 1.36700645e-01f, 1.71257764e-01f, 1.18795060e-01f, 2.06475303e-01f, -2.29150876e-01f, -4.32694182e-02f, -2.99249347e-02f, -1.48400038e-01f,
  -2.11275175e-01f, -3.44624743e-02f, -3.20198126e-02f, -8.55493024e-02f, 1.42591074e-01f, -7.52667487e-02f, 9.22701955e-02f, -3.59559059e-02f, 2.16441602e-01f, 2.07710579e-01f,
  1.77801147e-01f, 2.10085839e-01f, 1.38157099e-01f, 2.15808481e-01f, 7.88578913e-02f, 1.12282842e-01f, 3.37333791e-02f, 3.50275964e-01f, -2.22524494e-01f, 1.12207562e-01f,
  1.52722791e-01f, 3.64537127e-02f, 2.57951260e-01f, -9.64092314e-02f, 1.78686291e-01f, -4.00400274e-02f, -1.67230681e-01f, -1.25792280e-01f, 7.70586962e-03f, -2.00575963e-01f,
  1.47994176e-01f, 2.63195366e-01f, 7.88289607e-02f, -6.26927540e-02f, -1.71838656e-01f, 1.01901822e-01f, 1.02641918e-01f, 2.49098673e-01f, 8.18573534e-02f, -6.57260567e-02f,
  -2.66682237e-01f, -3.03255208e-02f, -9.78554189e-02f, -2.01734185e-01f, -6.12831712e-02f, -9.33866724e-02f, 1.39833391e-01f, 1.07546248e-01f, 1.08800717e-02f, 1.94548309e-01f,
  1.73168346e-01f, 9.48358420e-03f, -3.26562375e-02f, 6.36954531e-02f, 1.20846361e-01f, 2.93581963e-01f, 2.53240854e-01f, 8.40638354e-02f, 2.24745750e-01f, -2.45463416e-01f,
  1.35732204e-01f, 8.25088937e-03f, 9.92653985e-03f, -2.72965372e-01f, -3.40335220e-01f, -1.30358925e-02f, -2.50831991e-01f, -2.60438442e-01f, 2.75718659e-01f, 2.31767774e-01f,
  1.01023413e-01f, 9.17741843e-03f, 1.27690688e-01f, -5.13996370e-02f, 1.95717830e-02f, 1.33737996e-01f, 2.03424037e-01f, -4.10449952e-02f, -7.87747726e-02f, -1.83200873e-02f,
  -6.21203594e-02f, -8.74082372e-03f, -2.03377619e-01f, 1.73524722e-01f, -6.87841093e-03f, 7.52354339e-02f, -1.73280895e-01f, -8.53953734e-02f, -2.46815443e-01f, -6.68152049e-02f,
  3.63208354e-02f, 2.43823797e-01f, -1.87392145e-01f, -1.42325908e-01f, 7.69466385e-02f, -7.52902552e-02f, 7.58387521e-02f, 7.58389607e-02f, -1.86926927e-02f, -1.11584999e-01f,
  6.71166414e-03f, 8.14064816e-02f, 1.36582360e-01f, -4.41362746e-02f, -1.63133424e-02f, -1.33234918e-01f, 1.72372773e-01f, 8.07918832e-02f, 5.10771479e-03f, -3.91617455e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  6.32932037e-02f, 1.63231075e-01f, 3.35857421e-02f, 1.19287014e-01f, 2.20508948e-01f, -3.61612365e-02f, -1.20722149e-02f, 7.46638179e-02f, 8.88395458e-02f, 1.33270979e-01f,
  -6.35714158e-02f, 1.53296262e-01f, -5.27750887e-02f, -1.44357979e-02f, 2.05494151e-01f, -4.49009314e-02f, 1.82883218e-01f, 1.19455829e-01f, 1.95586577e-01f, 1.77399173e-01f,
  -2.78233690e-03f, 8.47621933e-02f, 1.05453521e-01f, 1.97525859e-01f, 8.00158232e-02f, 1.21100426e-01f, -1.21290557e-01f, 2.96487510e-02f, 1.66900262e-01f, 5.19923307e-02f,
  6.60629645e-02f, 1.91659495e-01f, 1.33722974e-03f, 6.41606823e-02f, 5.34224659e-02f, 8.81416500e-02f, 5.09461761e-02f, 1.73627421e-01f, 1.64686032e-02f, 1.08223401e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.49776263e-02f, 3.18588287e-01f, -2.63458401e-01f, -1.37588248e-01f, -1.59523755e-01f, -3.36169861e-02f, -9.95558426e-02f, -2.53290445e-01f, 9.68783796e-02f, -4.00510103e-01f,
  -1.37781156e-02f, 1.53063118e-01f, -2.26531371e-01f, -1.80982634e-01f, 6.96802838e-03f, 3.92177075e-01f, -1.57458454e-01f, -1.11356266e-02f, -3.23822677e-01f, 1.20864078e-01f,
  -2.75253534e-01f, -6.84921443e-02f, 2.76420832e-01f, -5.13188057e-02f, -2.64329672e-01f, -2.32876733e-01f, 1.62652522e-01f, -3.37035656e-01f, -1.45138815e-01f, 1.58754691e-01f,
  1.01702869e-01f, -2.52941698e-01f, 1.08587600e-01f, -2.66504157e-02f, 1.50643289e-01f, 1.26530930e-01f, 1.56270131e-01f, 1.62508681e-01f, -2.08058730e-01f, 1.09059550e-01f,
  -5.65123931e-02f, 1.21164575e-01f, -1.34569570e-01f, 5.08804433e-02f, 7.74756223e-02f, 1.53385505e-01f, -2.81833529e-01f, -2.67860383e-01f, -1.85585096e-02f, -2.84272611e-01f,
  1.70659631e-01f, -7.20375553e-02f, -2.66504526e-01f, 1.47621587e-01f, -7.54747689e-02f, -2.34850477e-02f, 1.26041591e-01f, -2.36872599e-01f, -1.94405839e-01f, 1.81898549e-02f,
  6.60657436e-02f, -2.99641609e-01f, 6.95630163e-02f, -5.24665639e-02f, 1.60403624e-01f, 4.18749712e-02f, -5.99503778e-02f, 1.53686717e-01f, 1.83257312e-02f, 2.13266522e-01f,
  2.24769548e-01f, 5.48096932e-02f, -6.67938031e-03f, 1.12674713e-01f, -9.59808081e-02f, -1.26054049e-01f, 6.77670315e-02f, 7.66131803e-02f, -2.60950059e-01f, -2.91942172e-02f,
  4.06457841e-01f, -2.57843941e-01f, -9.78926420e-02f, 3.78610641e-02f, 3.86698872e-01f, -1.50742635e-01f, -3.27503860e-01f, -1.08116612e-01f, -3.12807649e-01f, 3.39620225e-02f,
  8.78210887e-02f, -3.52685213e-01f, -1.42482847e-01f, 1.83813218e-02f, -3.53368938e-01f, -2.37955406e-01f, -2.34504133e-01f, -2.08904982e-01f, -3.00211851e-02f, 1.55550323e-03f,
  4.61788215e-02f, -3.67241561e-01f, 1.26842549e-02f, 2.05862358e-01f, 2.02455327e-01f, 1.06045119e-01f, -4.59293306e-01f, 1.48149565e-01f, 1.82507560e-01f, -5.45898490e-02f,
  1.47378132e-01f, -1.88765720e-01f, -2.80814499e-01f, 8.79578441e-02f, -2.12928653e-02f, 1.97402537e-01f, 6.84425607e-02f, -1.48400098e-01f, 1.13265969e-01f, 2.01474160e-01f,
  2.01879725e-01f, 7.77274519e-02f, 4.93734665e-02f, -1.87470969e-02f, 1.40377998e-01f, -3.10036302e-01f, 1.91874951e-02f, 2.27349073e-01f, 2.54530221e-01f, -1.77537233e-01f,
  -1.10628486e-01f, -1.47642329e-01f, 5.36953919e-02f, 1.76329899e-03f, -3.33190531e-01f, -1.78165004e-01f, 6.87146410e-02f, 6.09668940e-02f, 1.22191459e-01f, -2.16376060e-03f,
  3.24529670e-02f, -1.94860265e-01f, -2.57943749e-01f, -1.66098580e-01f, -2.11255737e-02f, 2.31704235e-01f, -6.90351650e-02f, -1.35891020e-01f, 5.07930294e-02f, 3.00074399e-01f,
  -1.00607209e-01f, 2.30128586e-01f, -3.23218733e-01f, -1.47822618e-01f, -8.02992210e-02f, 1.45914569e-01f, 1.71770394e-01f, 1.30195960e-01f, 3.49936813e-01f, 1.22564107e-01f,
  5.10033825e-03f, 1.82488803e-02f, -9.79425460e-02f, -1.50373941e-02f, 7.05654845e-02f, 1.35341197e-01f, -3.00116152e-01f, -5.81033751e-02f, -3.08977347e-02f, -4.82277006e-01f,
  -1.25461325e-01f, -2.13326618e-01f, 1.61228120e-01f, 2.04517186e-01f, -1.13897569e-01f, 5.18878810e-02f, -4.67577070e-01f, -2.48436689e-01f, -2.37865388e-01f, -6.37142733e-02f,
  3.65244836e-01f, 1.35111600e-01f, 1.39676377e-01f, 1.06332898e-01f, 1.53606355e-01f, 1.95012048e-01f, 4.31980100e-03f, -1.55785546e-01f, 6.27889708e-02f, 4.45605852e-02f,
  2.65763044e-01f, 6.65088221e-02f, -1.19763203e-01f, -2.61785537e-01f, -1.78699493e-01f, 1.39006928e-01f, 3.41428854e-02f, 3.52913253e-02f, -5.00314273e-02f, 1.44817993e-01f,
  -2.13798154e-02f, -1.29651949e-01f, -8.01177099e-02f, -3.74663100e-02f, -1.27435729e-01f, -5.44804111e-02f, -2.05457777e-01f, -1.47627229e-02f, -7.43791163e-02f, -1.88678615e-02f,
  -2.14984976e-02f, 1.90777138e-01f, -1.56141490e-01f, 2.18870372e-01f, 7.17979074e-02f, 2.49223039e-01f, -6.90861940e-02f, -3.29150945e-01f, -1.24771394e-01f, 1.10881060e-01f,
  -4.05406892e-01f, -1.60609365e-01f, 2.50380456e-01f, -1.25661612e-01f, 5.55670541e-03f, -4.47423756e-01f, 4.02749218e-02f, -2.72058308e-01f, 1.64996147e-01f, 2.18925685e-01f,
  -3.95845212e-02f, -2.68976092e-01f, -5.47426343e-01f, -1.66805714e-01f, 2.40889460e-01f, 2.09093206e-02f, -2.31894717e-01f, 2.33909503e-01f, 7.97735155e-02f, -2.25879222e-01f,
  1.96833625e-01f, -2.37795293e-01f, -2.60732412e-01f, 2.25260347e-01f, -2.13128343e-01f, -4.43998910e-02f, -1.32977471e-01f, 1.47364393e-01f, 1.80170134e-01f, 3.36823612e-02f,
  5.93696348e-02f, 8.90955329e-02f, -8.83097053e-02f, 3.95885408e-02f, -1.65219679e-01f, 3.90409604e-02f, -1.82061959e-02f, 1.22424319e-01f, 1.38412580e-01f, 2.44055003e-01f,
  -2.20668301e-01f, -3.24541554e-02f, -6.43587038e-02f, -5.17708324e-02f, -1.67098880e-01f, 9.67542529e-02f, -5.93433157e-02f, -1.99859023e-01f, 2.57149160e-01f, 3.33858142e-03f,
  2.72121370e-01f, -1.03415705e-01f, -6.24820590e-02f, 2.68800288e-01f, 1.07110990e-02f, -1.06666528e-01f, -1.57077610e-01f, -8.00930634e-02f, -2.56385803e-01f, 5.60187876e-01f,
  2.74814606e-01f, -4.72191162e-02f, -3.14725451e-02f, -4.00060974e-03f, -2.12997273e-01f, -1.00690976e-01f, 1.77832440e-01f, 2.44729042e-01f, 7.62910843e-02f, 1.51425913e-01f,
  1.93067521e-01f, -2.11487822e-02f, 3.84507291e-02f, 1.19747326e-01f, -3.11552256e-01f, -2.82965839e-01f, 1.54805362e-01f, 1.62642971e-01f, -1.03107356e-02f, 1.22148162e-02f,
  -5.00559509e-01f, -2.10044742e-01f, 1.27393547e-02f, -3.93680692e-01f, 1.83806926e-01f, -1.77539304e-01f, 1.04378656e-01f, -3.67811322e-01f, -1.20826781e-01f, 2.17454538e-01f,
  1.38785943e-01f, 1.45304590e-01f, -1.51085600e-01f, 6.65890798e-02f, -1.93524688e-01f, 1.07191212e-01f, -3.13722908e-01f, -1.89823434e-02f, -1.93427384e-01f, 1.67651623e-01f,
  -7.80316144e-02f, -1.62050817e-02f, 9.65902805e-02f, 5.77895045e-02f, 2.46777050e-02f, -1.42595500e-01f, 4.47028652e-02f, -7.51554668e-02f, -4.33264561e-02f, 1.48909418e-02f,
  1.24139361e-01f, 1.87970042e-01f, 5.33470474e-02f, -1.74800605e-01f, 3.96177679e-01f, -1.24173112e-01f, -1.99262530e-01f, -1.74417943e-01f, 1.75661996e-01f, 3.23000431e-01f,
  -3.41139346e-01f, 4.30861674e-02f, 1.06166296e-01f, -9.56436321e-02f, 3.72215658e-01f, 4.29481976e-02f, -1.98798743e-03f, -1.50900543e-01f, -1.60076067e-01f, -2.59230912e-01f,
  -2.95998842e-01f, -1.86859965e-01f, -2.86098546e-03f, 1.60152584e-01f, -1.54001221e-01f, -1.39710501e-01f, 9.12268162e-02f, -2.52616882e-01f, -2.66141593e-02f, -3.25432755e-02f,
  1.45777062e-01f, 1.79971978e-01f, -3.95747840e-01f, -1.01626858e-01f, -1.55415729e-01f, -5.37632108e-01f, -1.73626423e-01f, 4.90672141e-02f, 8.24348107e-02f, 1.36272460e-01f,
  1.61899582e-01f, -3.65385085e-01f, 2.36513659e-01f, -3.83602351e-01f, -1.06248796e-01f, -2.09597066e-01f, 1.62955329e-01f, 1.97478667e-01f, 4.01290581e-02f, 2.38040224e-01f,
  -6.12884015e-02f, 1.93882078e-01f, 2.49151453e-01f, 1.67100146e-01f, 1.71439797e-01f, 1.31100774e-01f, 2.34411374e-01f, -3.46667171e-01f, 1.50040150e-01f, -4.72411886e-02f,
  2.66299784e-01f, -1.77452359e-02f, -3.03075522e-01f, 1.03797071e-01f, -2.80571789e-01f, -7.45274201e-02f, -2.65105188e-01f, -1.45463515e-02f, -2.27483665e-03f, 3.14473242e-01f,
  2.81197011e-01f, -4.12004627e-02f, 1.44131362e-01f, -1.22082628e-01f, 6.45753518e-02f, 4.66853887e-01f, 1.49991572e-01f, -8.73175114e-02f, -3.92487884e-01f, 1.10474259e-01f,
  1.19367681e-01f, 2.17439886e-02f, 3.71890813e-01f, 1.41265094e-01f, -2.45056838e-01f, -1.30359337e-01f, -2.60461867e-01f, 1.17606729e-01f, -2.87885159e-01f, 6.19907230e-02f,
  -3.54770929e-01f, -5.49907327e-01f, -1.55095339e-01f, -1.65499017e-01f, 2.29522228e-01f, -2.52177417e-01f, -1.50390163e-01f, -1.26432955e-01f, -2.12917596e-01f, -9.06758979e-02f,
  -6.97342008e-02f, 2.80947119e-01f, 2.62653101e-02f, -3.53083491e-01f, 5.92208430e-02f, -2.52866726e-02f, -1.93908602e-01f, -2.76469201e-01f, 7.77949840e-02f, -3.80670875e-01f,
  -3.83409947e-01f, -3.30151409e-01f, 2.37201020e-01f, -6.11699283e-01f, -3.18859935e-01f, 2.75636494e-01f, 2.49758631e-01f, -1.38331741e-01f, 2.79467404e-02f, 1.83901563e-02f,
  1.77314058e-01f, 3.94523218e-02f, -8.11884701e-02f, 1.41418040e-01f, 6.40227869e-02f, 1.89568609e-01f, -1.00003250e-01f, -3.03489026e-02f, 1.77321225e-01f, -2.21215077e-02f,
  -3.26527297e-01f, 2.90499657e-01f, 3.01960200e-01f, 2.69834604e-02f, 7.46949315e-02f, 2.50516117e-01f, -5.72779812e-02f, -1.69265509e-01f, -1.49633750e-01f, -2.07864538e-01f,
  -2.51361042e-01f, -4.10668030e-02f, -1.77872106e-01f, 2.82907367e-01f, -4.22867179e-01f, 6.06908575e-02f, -3.48214120e-01f, 7.37227127e-02f, -2.67802566e-01f, -1.18956573e-01f,
  1.42661601e-01f, -1.53598096e-02f, -8.68662447e-02f, 1.06996566e-01f, 1.99035257e-02f, 3.04997832e-01f, 1.44466832e-01f, -1.45203561e-01f, -3.08653295e-01f, -2.85069365e-02f,
  -9.75728929e-02f, 1.78708985e-01f, -2.11435497e-01f, 8.60693008e-02f, 5.60647883e-02f, -7.48335347e-02f, -2.61350781e-01f, -1.95794508e-01f, -1.69036373e-01f, 2.77227372e-01f,
  -1.28855109e-01f, 6.87948838e-02f, -8.59953687e-02f, -1.79573491e-01f, -1.66994512e-01f, -2.41647288e-01f, 1.14117496e-01f, -2.64840454e-01f, 1.24579713e-01f, -1.85533330e-01f,
  -3.52152884e-01f, -2.64877409e-01f, 5.66414185e-02f, 9.88149419e-02f, -5.79852723e-02f, 7.46424273e-02f, 1.81803241e-01f, -7.59198666e-02f, -4.68450300e-02f, 1.20635577e-01f,
  1.61650747e-01f, -1.78020969e-01f, 8.40414688e-02f, -4.28863913e-02f, 1.77508965e-01f, -2.89765179e-01f, -1.49364486e-01f, 1.31161228e-01f, -3.53537768e-01f, -2.34845981e-01f,
  1.32137075e-01f, -1.66714806e-02f, 1.47141695e-01f, -8.94793570e-02f, 4.69424993e-01f, -7.62813240e-02f, 1.44972399e-01f, 2.47774839e-01f, -4.62955654e-01f, -2.20130518e-01f,
  2.47531667e-01f, -3.41419131e-01f, -6.04185313e-02f, -7.52535602e-03f, 3.27656388e-01f, -1.32519782e-01f, -3.13062906e-01f, -1.87968060e-01f, -1.93905219e-01f, -6.57298937e-02f,
  1.49528265e-01f, 3.36262584e-01f, -2.58194983e-01f, 1.59765303e-01f, -2.33930290e-01f, -1.48855284e-01f, 4.57342416e-01f, -1.69563696e-01f, -1.01590432e-01f, -2.20630690e-01f,
  -2.45704591e-01f, 3.00125539e-01f, -1.36560693e-01f, 1.22422449e-01f, -8.33040252e-02f, 1.51814544e-03f, -3.21348459e-01f, -2.59652227e-01f, -1.70778304e-01f, 3.93103398e-02f,
  -1.91595912e-01f, -4.20626909e-01f, 5.40399216e-02f, 4.15656250e-03f, -1.34714738e-01f, -4.50254947e-01f, 6.85134828e-02f, -9.77748409e-02f, -8.98172855e-02f, 2.79202342e-01f,
  5.17502539e-02f, 1.25595808e-01f, -3.37220937e-01f, -3.37513834e-02f, 4.31633443e-02f, 1.29132524e-01f, 8.05292726e-02f, 3.24642211e-01f, -3.79438460e-01f, 3.43492538e-01f,
  1.34926572e-01f, -3.77510816e-01f, -2.82554418e-01f, 2.21904963e-01f, -2.16455564e-01f, -3.48409563e-01f, 2.84515649e-01f, -3.09787214e-01f, 2.89351791e-01f, -2.66147643e-01f,
  1.64713889e-01f, -1.04155995e-01f, 2.22883791e-01f, 1.66697681e-01f, -2.64886707e-01f, 2.36031801e-01f, -1.68042779e-01f, 3.51579219e-01f, -1.92025080e-01f, 2.05767080e-01f,
  -3.76383007e-01f, 6.32542968e-02f, -7.35412657e-01f, 1.92688137e-01f, -3.00662637e-01f, 1.05612203e-01f, 1.61002696e-01f, -2.34767012e-02f, -2.52791822e-01f, 6.85973763e-02f,
  -1.71050951e-01f, -7.79577196e-02f, -7.82195702e-02f, 1.98388085e-01f, -5.29467762e-01f, -2.56338894e-01f, 7.33964965e-02f, -6.44802675e-02f, -2.21406311e-01f, 8.71294588e-02f,
  1.27338797e-01f, -4.70890403e-01f, -9.49255824e-02f, -8.43106024e-03f, 5.33229560e-02f, 1.73681378e-01f, 5.80705842e-03f, 4.31488007e-02f, -3.55269551e-01f, -1.71446458e-01f,
  -1.02161817e-01f, 1.06701411e-01f, 1.11144960e-04f, 8.35205093e-02f, 1.13983586e-01f, -2.00277031e-03f, 9.40590538e-03f, 6.43523559e-02f, 1.31844640e-01f, 1.61437526e-01f,
  1.57571360e-01f, -1.57405492e-02f, 1.19295619e-01f, -9.74712446e-02f, -1.68188915e-01f, -1.37548745e-01f, -1.76900089e-01f, -1.96013898e-01f, -3.20649326e-01f, -1.47936016e-01f,
  1.06669255e-01f, -1.48492053e-01f, 3.47141661e-02f, -1.04839325e-01f, 1.33946622e-02f, -3.38300705e-01f, -1.14988357e-01f, -3.10037047e-01f, 2.75161564e-01f, -1.51041880e-01f,
  -3.65534067e-01f, -5.87822497e-02f, 1.09372377e-01f, -2.04747945e-01f, 2.96598017e-01f, -2.63598621e-01f, -1.69182476e-02f, -5.40866666e-02f, 1.62781492e-01f, -3.12628716e-01f,
  -3.12083453e-01f, 1.78994253e-01f, 3.56302530e-01f, -3.87481779e-01f, -1.65460616e-01f, -3.62450868e-01f, -2.97616750e-01f, -1.41409457e-01f, 2.54184186e-01f, 1.04039982e-01f,
  -3.89681429e-01f, 2.93285757e-01f, -1.15058057e-01f, -2.71542966e-01f, -2.84773529e-01f, -2.41509527e-02f, -5.41572422e-02f, 1.34504354e-02f, -3.53373319e-01f, 2.29023501e-01f,
  -5.09966910e-01f, 9.45168436e-02f, -1.49400949e-01f, 1.53745323e-01f, -2.27277830e-01f, 1.31133750e-01f, 1.36518419e-01f, -2.32124269e-01f, -1.97506085e-01f, 8.54404345e-02f,
  2.06354454e-01f, 1.69996917e-01f, -3.70677076e-02f, 1.24148034e-01f, 1.19524263e-01f, -1.15820996e-01f, 3.62016469e-01f, 9.04315710e-02f, -1.93773434e-01f, -2.11001843e-01f,
  -7.44433701e-02f, 2.44576950e-03f, 2.43642002e-01f, 9.67746302e-02f, 6.87703043e-02f, 1.13487005e-01f, 1.39159828e-01f, 4.94228713e-02f, 3.66076052e-01f, -1.93658084e-01f,
  3.29142027e-02f, 1.65836811e-01f, 2.29932293e-01f, -3.74972224e-01f, -1.55013636e-01f, -2.14450285e-01f, -4.80830938e-01f, -4.87152845e-01f, -3.36227089e-01f, 6.25935495e-02f,
  -1.81821007e-02f, -2.02824697e-01f, 2.07778007e-01f, -5.80228493e-02f, 5.42727262e-02f, -3.79561037e-01f, 7.43818805e-02f, 5.73966429e-02f, -8.14503208e-02f, 1.58943415e-01f,
  1.68148845e-01f, 3.29711854e-01f, -1.22966155e-01f, 3.31871174e-02f, -4.00210500e-01f, -2.91997910e-01f, -1.48530826e-01f, 1.15604743e-01f, 1.10515587e-01f, -1.82697162e-01f,
  -1.29572093e-01f, 5.91128953e-02f, 1.34913042e-01f, -1.47304386e-01f, 1.20996445e-01f, 1.57295942e-01f, -3.83719981e-01f, -2.44075775e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.39458308e-01f, -5.41402027e-02f, 1.02263168e-01f, -1.41781464e-01f, 7.48825371e-02f, -5.64273223e-02f, 6.41151816e-02f, 8.95212963e-02f, -3.13545167e-02f, 1.05669536e-01f,
  1.67613812e-02f, -6.75427467e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    