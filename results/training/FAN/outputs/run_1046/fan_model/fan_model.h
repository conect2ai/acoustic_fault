/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.77480829e-01f, 1.71782970e-01f, -1.11526243e-01f, -9.48959216e-02f, -5.46366833e-02f, -1.23224810e-01f, -1.82110369e-01f, 3.81171405e-02f, 1.41756326e-01f, -5.88800833e-02f,
  1.20278187e-01f, 2.13483557e-01f, 1.90030620e-01f, 1.78965256e-01f, -6.25506043e-02f, -1.30338505e-01f, -2.19467342e-01f, -2.65417576e-01f, -2.19263345e-01f, -2.02967197e-01f,
  3.66967842e-02f, 1.50461840e-02f, -3.20479274e-02f, 1.49839193e-01f, 5.56167997e-02f, 5.39476871e-02f, 1.96448311e-01f, -3.07648871e-02f, 1.20174266e-01f, -1.88925445e-01f,
  -3.23798358e-01f, -2.82765865e-01f, -3.08363978e-03f, -4.38677706e-02f, 5.44319041e-02f, -7.70557448e-02f, -3.78231667e-02f, -1.12769812e-01f, 1.03002898e-02f, -2.49686111e-02f,
  -1.31449193e-01f, -5.82939126e-02f, -1.09849535e-01f, -8.81841853e-02f, -1.04249947e-01f, -2.31479913e-01f, -3.77024449e-02f, -3.18852849e-02f, -7.86816422e-03f, -1.25915809e-02f,
  -4.18366939e-02f, -8.22786465e-02f, -8.27771425e-02f, -1.01816982e-01f, -5.00283092e-02f, -1.06400132e-01f, -1.64294634e-02f, -1.59230039e-01f, -5.40558249e-02f, -8.48390236e-02f,
  7.76458979e-02f, -6.33709133e-02f, -3.30999829e-02f, 4.55915481e-02f, 1.14332251e-02f, 3.14301923e-02f, 2.65406072e-02f, -1.98654346e-02f, -8.24916959e-02f, 2.17634141e-02f,
  2.77415961e-02f, -2.15537343e-02f, 2.15704013e-02f, -6.94292709e-02f, 1.44545168e-01f, -3.39481793e-02f, -5.02353609e-02f, 5.86759858e-02f, -2.03144178e-02f, 4.55996990e-02f,
  2.69499328e-02f, 1.67763239e-04f, 2.29607970e-02f, 6.85037998e-03f, 1.67279728e-02f, 1.22978874e-02f, 4.45078649e-02f, 5.10782972e-02f, 8.69759619e-02f, -1.85688995e-02f,
  1.46194056e-01f, -9.39720795e-02f, -1.73547134e-01f, 7.27948472e-02f, -8.26873258e-02f, 3.84350261e-03f, -6.05841018e-02f, -4.51462120e-02f, -8.78478307e-03f, -1.31484523e-01f,
  -4.76808250e-02f, -8.30745623e-02f, -6.69564903e-02f, -1.04598828e-01f, -2.44394213e-01f, -1.04219913e-01f, 3.43247689e-02f, -1.24382041e-01f, -9.16524902e-02f, -2.37926785e-02f,
  -4.88239788e-02f, -9.66775864e-02f, -1.72691986e-01f, -6.52561709e-02f, -1.59036815e-01f, -1.80960432e-01f, -1.20202243e-01f, -4.72596325e-02f, -1.42119825e-01f, 7.00968057e-02f,
  -6.03569806e-01f, 6.59248084e-02f, 3.78071293e-02f, -2.00504899e-01f, 2.72019327e-01f, 1.07370563e-01f, 2.44826362e-01f, -1.30091369e-01f, -5.98172098e-02f, 8.61435086e-02f,
  1.39609426e-01f, 6.27692714e-02f, -8.63534361e-02f, -1.02270000e-01f, -1.88282788e-01f, 2.51119751e-02f, 1.09545536e-01f, -2.22618207e-01f, -2.89428562e-01f, 4.27603312e-02f,
  1.34902239e-01f, -3.48764621e-02f, -2.09536254e-01f, -1.48474440e-01f, 1.33037508e-01f, -1.24385804e-02f, 3.36647704e-02f, -2.14199070e-02f, 1.53764978e-01f, 7.00721517e-02f,
  -6.80094734e-02f, -3.71463671e-02f, 8.59725699e-02f, 1.00020297e-01f, 9.05585811e-02f, -1.14480518e-01f, -4.54970375e-02f, 1.92846060e-02f, 2.96464711e-02f, -9.56558436e-02f,
  1.46314859e-01f, 7.37875141e-03f, 6.71686605e-02f, 1.03349332e-02f, -4.77905795e-02f, -5.80425784e-02f, -8.53966251e-02f, -1.10118814e-01f, -8.21063891e-02f, -2.63273921e-02f,
  7.60050640e-02f, 1.65217862e-01f, 3.76763977e-02f, 6.53656721e-02f, -8.98684636e-02f, 5.96877225e-02f, 1.77322701e-02f, 3.56053486e-02f, 9.16263089e-02f, -3.18370610e-02f,
  -1.97051316e-02f, 4.72421944e-02f, 1.57962497e-02f, 4.34522592e-02f, -4.85392734e-02f, 5.72199970e-02f, -1.28122736e-02f, -3.19553018e-02f, -2.47859992e-02f, -6.73732907e-02f,
  7.25544542e-02f, 6.51260614e-02f, 2.38983370e-02f, -9.26170684e-03f, 3.00011430e-02f, -4.61434796e-02f, -2.67254058e-02f, -8.12267438e-02f, -1.51869515e-02f, -1.01511076e-01f,
  -9.95636210e-02f, -5.61582036e-02f, -4.89282049e-02f, -1.29850417e-01f, -1.77622661e-02f, -1.64062902e-01f, -3.96906398e-02f, 2.64534410e-02f, -6.10733144e-02f, 1.31225958e-01f,
  -1.68669343e-01f, 1.49295926e-01f, -5.27463406e-02f, 7.99056739e-02f, 7.51101375e-02f, -3.52104777e-03f, 1.45149797e-01f, 2.89159012e-03f, -5.23469448e-02f, 9.02264342e-02f,
  1.31953247e-02f, 4.47381474e-02f, 3.30962166e-02f, -3.84823494e-02f, 7.03134537e-02f, 1.65254325e-02f, 6.93792403e-02f, 2.43751220e-02f, -9.42498967e-02f, -3.49704176e-02f,
  -2.58083269e-03f, -8.64889398e-02f, -6.29081354e-02f, -5.96998772e-03f, 1.69991236e-02f, -1.21846609e-01f, 4.57763523e-02f, -1.98173784e-02f, -1.08971046e-02f, -1.26307905e-01f,
  -7.61503130e-02f, 3.82670350e-02f, -3.05015240e-02f, 1.53917456e-02f, 2.49376297e-02f, 6.23246394e-02f, 2.61182129e-01f, 1.90144524e-01f, 1.53357058e-03f, 1.94538802e-01f,
  9.19474475e-03f, 6.23170622e-02f, -5.30694909e-02f, 1.65591743e-02f, 1.23589784e-01f, 3.65067333e-01f, 5.85219003e-02f, -1.43255489e-02f, 1.82191759e-01f, 4.23919976e-01f,
  2.26603106e-01f, 2.85131752e-01f, -2.26279479e-02f, 9.10447016e-02f, 1.30882531e-01f, 1.66461527e-01f, -3.99199836e-02f, -1.79890379e-01f, -1.22044384e-02f, -1.01919748e-01f,
  -1.26615241e-01f, -3.94905329e-01f, 8.82971585e-02f, -2.55772229e-02f, -8.65663216e-02f, 3.13492753e-02f, 7.68469423e-02f, -2.90657151e-02f, 6.35384545e-02f, -1.01977941e-02f,
  -7.40852058e-02f, -4.43777293e-02f, -9.66639072e-02f, -4.67209071e-02f, 5.56504680e-03f, 5.98713905e-02f, 9.16510820e-03f, 5.42810969e-02f, -1.70876589e-02f, 8.51947162e-03f,
  -1.53968437e-02f, -1.09741203e-01f, -1.27356619e-01f, -8.44318420e-02f, -7.24463388e-02f, -1.03194147e-01f, -1.15301333e-01f, -1.29357532e-01f, -1.53472334e-01f, 1.74361482e-01f,
  1.41861904e-02f, 4.02775109e-02f, 8.67713988e-03f, 1.15601823e-01f, 7.92345256e-02f, -9.66797397e-02f, -2.96221748e-02f, 1.63977128e-02f, 7.71762729e-02f, 5.77761866e-02f,
  4.30680402e-02f, 1.03106461e-02f, -4.67453571e-03f, -7.48872757e-02f, -4.10581008e-02f, 5.10011911e-02f, 1.37316853e-01f, 1.67147487e-01f, -1.03517473e-01f, -8.30844641e-02f,
  4.02663760e-02f, -2.13232227e-02f, 2.22294834e-02f, 2.30269898e-02f, -4.11053374e-02f, 3.69006246e-02f, 1.88906770e-02f, 7.58681521e-02f, 8.29486698e-02f, 7.15924203e-02f,
  3.15654457e-01f, -1.46820188e-01f, 1.18681699e-01f, 1.48560986e-01f, -2.66356748e-02f, 6.33121580e-02f, -6.54791656e-04f, 2.30283942e-02f, -1.30163971e-02f, 7.09876493e-02f,
  3.13382130e-03f, 1.74359962e-01f, 8.38970765e-02f, 2.35443525e-02f, 2.69088130e-02f, 5.28419837e-02f, 1.23249464e-01f, 2.22243875e-01f, 4.55316938e-02f, 8.15722048e-02f,
  1.42882958e-01f, 1.78736120e-01f, 2.91680992e-01f, 1.03600822e-01f, 3.16228047e-02f, 1.18600562e-01f, 1.78257570e-01f, 9.52319205e-02f, 1.80881336e-01f, 3.91319782e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.13611388e-01f, -4.11763430e-01f, -5.33495128e-01f, 1.66881874e-01f, -2.56465882e-01f, -7.58162737e-02f, -3.27228189e-01f, 1.17921270e-01f, 2.69853026e-01f, -4.77461159e-01f,
  -2.38963231e-01f, 1.72273695e-01f, 1.14767477e-01f, -4.73869964e-02f, 1.11007616e-01f, -3.51936013e-01f, -2.55893260e-01f, -8.10753182e-02f, 1.12857886e-01f, 5.62408194e-02f,
  1.09628169e-02f, 8.30693692e-02f, 2.27358565e-01f, 3.28309871e-02f, -2.95600951e-01f, -3.64803299e-02f, -4.34232533e-01f, -1.23030640e-01f, -1.45291269e-01f, -4.86135721e-01f,
  -4.01446253e-01f, -1.70760173e-02f, 3.14244144e-02f, 1.30063862e-01f, -3.39559674e-01f, 2.57864855e-02f, 4.20805700e-02f, -8.79488289e-02f, 4.02501598e-02f, -4.45405841e-02f,
  -5.84105067e-02f, -2.43571084e-02f, 3.10876910e-02f, 2.27678195e-02f, -2.84169447e-02f, 3.44888568e-02f, -1.12866692e-01f, 1.71921160e-02f, -2.09628493e-01f, -1.19001336e-01f,
  -3.77437994e-02f, -5.12580536e-02f, 3.68752331e-02f, 1.06126383e-01f, 8.79089981e-02f, 1.25376284e-01f, -9.73602235e-02f, -1.11428015e-01f, -8.61582085e-02f, -3.30169708e-01f,
  -2.69063395e-02f, -4.82992493e-02f, 5.90614229e-02f, 2.76187845e-02f, -4.36942875e-02f, 1.04320213e-01f, -4.36374396e-02f, -3.76923345e-02f, 5.79064488e-02f, 7.10844621e-02f,
  -6.41607493e-02f, -1.45350009e-01f, -2.49988437e-02f, -5.36839291e-02f, -8.47542882e-02f, 6.67209104e-02f, -5.32258600e-02f, -4.11520302e-02f, 2.40632687e-02f, -7.78564662e-02f,
  -2.55071148e-02f, 2.03838833e-02f, -2.13577989e-02f, 2.79392358e-02f, -8.66524526e-04f, 9.57411155e-03f, 6.35980144e-02f, 6.92753540e-03f, 2.38862820e-02f, 4.19722199e-02f,
  1.69354156e-02f, -7.15110302e-02f, -4.57446687e-02f, 2.72719320e-02f, -1.16217071e-02f, -1.34846792e-01f, 3.43004055e-02f, -1.41716465e-01f, -2.99102720e-02f, -5.94933778e-02f,
  1.50531670e-02f, 4.14741337e-02f, -1.18786789e-01f, -8.23336914e-02f, 4.90688439e-03f, 8.23680758e-02f, -1.16688773e-01f, 1.78294387e-02f, 4.40030210e-02f, -9.05590877e-02f,
  3.81733254e-02f, 4.88463081e-02f, 2.03980461e-01f, 8.84611681e-02f, 9.08358768e-02f, 1.87312663e-01f, -4.38004211e-02f, 9.59276557e-02f, 1.16658956e-01f, 2.31655445e-02f,
  -8.24896395e-01f, 1.07140362e-01f, -4.08592373e-02f, -4.84216690e-01f, -3.50553662e-01f, -1.35057986e-01f, 2.15358287e-03f, 3.40647586e-02f, -6.74524158e-03f, 2.76127309e-01f,
  9.49200913e-02f, -7.74552226e-02f, -1.74082145e-01f, -1.43959194e-01f, -3.16010684e-01f, -5.74359484e-02f, -2.85843968e-01f, -5.57212055e-01f, -5.68755627e-01f, -3.09640974e-01f,
  -2.28806570e-01f, -3.98119152e-01f, -5.46361804e-01f, -1.92459375e-01f, 6.00476600e-02f, -5.26618138e-02f, 7.08697662e-02f, -2.33773455e-01f, 5.17009478e-03f, -9.53194723e-02f,
  6.56368211e-02f, -1.83602840e-01f, -2.13595822e-01f, -4.15085554e-02f, -6.11018911e-02f, 6.18203878e-02f, -1.28002837e-01f, 8.03759973e-03f, -3.53018045e-02f, 9.73645449e-02f,
  -1.05511278e-01f, -4.02292162e-02f, -3.81728671e-02f, -4.47631851e-02f, -1.53626785e-01f, -2.05810228e-03f, 4.48809117e-02f, 3.56162153e-03f, 2.71745957e-02f, 2.11294323e-01f,
  1.06207609e-01f, -4.44631428e-02f, -2.64927658e-04f, 1.70518860e-01f, 2.46429518e-02f, -1.88169330e-01f, 1.22524269e-01f, 8.05239007e-02f, 9.72586349e-02f, 2.49078825e-01f,
  6.83112219e-02f, 9.89118516e-02f, -1.06076151e-01f, 1.01978935e-01f, 1.49815559e-01f, 2.78876517e-02f, -4.19704337e-03f, -3.42159234e-02f, 3.93841742e-03f, 1.71355698e-02f,
  5.07591292e-02f, -4.31184433e-02f, 8.89210552e-02f, 4.18554656e-02f, 1.35087715e-02f, -4.30316702e-02f, -1.55655190e-01f, 1.16112046e-01f, 5.05201668e-02f, -3.71299870e-02f,
  -5.12264706e-02f, 3.39128561e-02f, 5.02129197e-02f, 1.17506728e-01f, -5.26906550e-02f, -4.24310043e-02f, -3.93265225e-02f, 2.74862424e-02f, -7.43537210e-03f, -8.35126117e-02f,
  2.38204405e-01f, -3.58579904e-01f, -1.27453446e-01f, 1.65523484e-01f, -2.73726732e-02f, 7.58221224e-02f, -9.60059837e-03f, 2.82781851e-02f, -1.91235710e-02f, 2.16131918e-02f,
  1.94210652e-02f, -7.81121850e-03f, 9.99916121e-02f, 9.27180499e-02f, -1.46190777e-01f, -8.93682986e-02f, 1.57167032e-01f, 7.77820009e-04f, 1.29940033e-01f, 1.48817763e-01f,
  1.95687100e-01f, 2.25307167e-01f, -1.91209987e-02f, 8.43287185e-02f, 1.31253183e-01f, -7.34889731e-02f, 6.09434620e-02f, 1.56859785e-01f, -2.66527887e-02f, 1.50017828e-01f,
  4.43503737e-01f, -1.58971339e-01f, -5.45914829e-01f, 2.27185100e-01f, -2.38852307e-01f, -9.58477333e-02f, -5.97107932e-02f, 1.24949507e-01f, 1.78290337e-01f, -2.07871526e-01f,
  9.22958180e-02f, 2.97030717e-01f, 1.43376470e-01f, -5.82235642e-02f, 6.37158081e-02f, -1.90322816e-01f, -1.34214014e-01f, -6.50751889e-02f, 2.09714726e-01f, 1.40040919e-01f,
  -9.18037351e-03f, 3.83746512e-02f, 2.02295274e-01f, 1.38140962e-01f, -1.05990969e-01f, -7.50818327e-02f, -2.29574651e-01f, -2.32183725e-01f, -2.00563565e-01f, -4.52048063e-01f,
  -2.86460757e-01f, -2.39806905e-01f, 1.05767190e-01f, 1.08864643e-01f, -1.43241659e-01f, 1.09025665e-01f, 7.06203952e-02f, 8.45126715e-03f, 5.36709353e-02f, 3.36038768e-02f,
  -3.38197611e-02f, -8.62999558e-02f, -3.94372717e-02f, 4.03394587e-02f, -5.65568823e-03f, 5.13675697e-02f, -1.34431180e-02f, -4.62581106e-02f, -7.65389279e-02f, -5.72190769e-02f,
  -9.00339242e-03f, 1.57041401e-02f, -1.15844153e-01f, -6.58298433e-02f, -2.11668257e-02f, -6.85213581e-02f, -6.06724583e-02f, -7.26977214e-02f, -4.20275843e-03f, -8.20363760e-02f,
  2.03158930e-02f, -2.58037057e-02f, 1.58133030e-01f, 1.31071657e-01f, 1.35600463e-01f, 1.25736788e-01f, -7.01354519e-02f, 1.41438216e-01f, -6.61531137e-03f, -4.84744869e-02f,
  1.75914317e-02f, 3.30007747e-02f, 2.45778239e-03f, 9.77628306e-02f, 5.84164783e-02f, 2.07058936e-02f, -9.53389704e-02f, 6.59850091e-02f, 5.57464957e-02f, 5.56596667e-02f,
  -7.49610290e-02f, -9.24439058e-02f, -2.39817724e-02f, 9.27848443e-02f, -1.23758815e-01f, -6.75582066e-02f, -4.31951880e-03f, 1.25700971e-02f, -9.64834243e-02f, -3.84023190e-02f,
  2.78045923e-01f, 1.73919294e-02f, 1.17234839e-02f, 7.48792887e-02f, -9.32143405e-02f, -2.87862290e-02f, 3.54466476e-02f, -8.05205852e-02f, 4.09556599e-03f, 7.57364416e-03f,
  -2.58908831e-02f, 1.93329621e-03f, 3.01556643e-02f, -1.01960404e-02f, -7.43114501e-02f, -1.83824019e-03f, -2.37727165e-02f, -2.04243157e-02f, 4.26524766e-02f, -5.41018769e-02f,
  -9.07517876e-03f, 1.91617191e-01f, 7.02963471e-02f, 2.02373043e-02f, 5.24144098e-02f, 7.55561292e-02f, 8.28823000e-02f, 2.33012047e-02f, -2.62965839e-02f, 2.12203786e-01f,
  -1.01211779e-01f, 1.24608405e-01f, -2.33142763e-01f, 3.98116559e-02f, -2.63513982e-01f, -4.64612059e-02f, 8.70601274e-03f, 3.07849497e-01f, 1.90255865e-01f, -8.63188207e-02f,
  1.08248726e-01f, 3.72115597e-02f, -6.81056753e-02f, -1.96868196e-01f, -1.80745140e-01f, -5.95468655e-02f, -3.15773159e-01f, -2.14674860e-01f, -1.53035671e-01f, 3.95445451e-02f,
  -2.78408024e-02f, 2.17353273e-02f, -8.74520615e-02f, 1.29737183e-01f, -1.63331516e-02f, -1.26163617e-01f, -1.73591867e-01f, -3.18497092e-01f, -3.84007037e-01f, -5.67007124e-01f,
  -1.79610088e-01f, 4.63912599e-02f, -1.92746341e-01f, -7.95594305e-02f, -3.60765345e-02f, -5.21721058e-02f, 1.08855180e-02f, -4.70807739e-02f, -7.23805232e-03f, -2.83503141e-02f,
  1.22609511e-01f, 9.29653421e-02f, -6.84335232e-02f, 2.66829301e-02f, -1.10858649e-01f, 1.36269592e-02f, -8.82604122e-02f, -2.74228305e-01f, -2.74907291e-01f, -8.02063849e-03f,
  -1.70154512e-01f, -2.17743859e-01f, -2.02524528e-01f, -1.70199841e-01f, 4.88990694e-02f, -1.91606745e-01f, -1.60210222e-01f, 4.08883840e-02f, -3.09199274e-01f, -1.83178142e-01f,
  -1.44431861e-02f, -1.53090814e-02f, 1.17679365e-01f, 5.97067140e-02f, -3.23718451e-02f, 1.17689356e-01f, 1.17422910e-02f, -1.11420818e-01f, 1.34457983e-02f, 3.57048064e-02f,
  9.39261541e-02f, 1.02879088e-02f, -2.37832405e-02f, -5.74502312e-02f, -1.39190122e-01f, -4.36991900e-02f, 1.23150401e-01f, -8.37756321e-02f, -1.20822415e-01f, -7.66498446e-02f,
  6.92397058e-02f, 7.91458189e-02f, 1.40906246e-02f, 8.04067999e-02f, 2.38444675e-02f, -1.23978369e-01f, -9.98124853e-02f, 7.36897066e-02f, 7.45623857e-02f, 1.32924616e-01f,
  1.17330991e-01f, -1.91197887e-01f, 1.94284111e-01f, -3.54720242e-02f, -1.15552351e-01f, -1.15477063e-01f, 4.97624166e-02f, 2.24450812e-01f, 8.87694880e-02f, 1.21851210e-02f,
  1.15155615e-01f, 1.92820668e-01f, -1.98730770e-02f, 6.19597221e-03f, 3.16408346e-03f, -1.71291623e-02f, -1.37787759e-01f, -2.87732072e-02f, -1.33468390e-01f, 1.43564925e-01f,
  1.43192604e-01f, -1.30021414e-02f, -9.94259268e-02f, -1.61071122e-01f, -3.67046632e-02f, -1.66978657e-01f, -1.14200816e-01f, 8.52607265e-02f, 3.54439951e-02f, 9.10111815e-02f,
  8.28330815e-02f, -3.37177038e-01f, 1.82408705e-01f, 3.96533579e-01f, 4.32557404e-01f, 4.61651862e-01f, 4.91314113e-01f, 4.16949093e-01f, 1.82414502e-01f, 1.53922752e-01f,
  -2.03777522e-01f, -4.70783800e-01f, -5.12608230e-01f, -4.30884957e-01f, -3.70448828e-02f, 3.23437959e-01f, 3.62249285e-01f, -1.10721355e-02f, 1.18620098e-01f, 5.30814789e-02f,
  1.25961453e-01f, 8.91552791e-02f, -1.72042549e-02f, -2.34068707e-01f, 1.03736348e-01f, 5.81978559e-02f, 1.44043580e-01f, -9.68649536e-02f, -2.33820900e-01f, -1.48686528e-01f,
  -5.86889327e-01f, -1.35528594e-01f, 1.54424116e-01f, -1.18293211e-01f, 1.90065839e-04f, 3.41742556e-03f, 2.88361479e-02f, -1.79438144e-01f, -1.13174617e-01f, -9.22545642e-02f,
  -1.32094264e-01f, -2.60110676e-01f, -1.87163770e-01f, -1.69422194e-01f, -3.27862166e-02f, 1.04863979e-01f, -8.61403495e-02f, -2.54884809e-01f, -1.81064218e-01f, -3.98221046e-01f,
  -2.68537045e-01f, -1.05041444e-01f, -1.41645059e-01f, -1.07034981e-01f, -1.32623985e-01f, -2.49880683e-02f, -1.29162624e-01f, -2.39898905e-01f, -2.07013398e-01f, -2.17340305e-01f,
  -5.28439544e-02f, -3.58624011e-02f, -1.26510626e-02f, -3.69913839e-02f, 1.04012467e-01f, 1.25612738e-02f, -1.10449769e-01f, -1.57340080e-01f, 1.90375056e-02f, 1.33398712e-01f,
  -1.33639768e-01f, -4.06349823e-02f, -1.35042980e-01f, -3.34318168e-02f, 5.70414923e-02f, 3.23585756e-02f, 5.93726970e-02f, 6.65454790e-02f, -1.27305733e-02f, 1.10914879e-01f,
  4.33430821e-02f, -6.16725907e-02f, 3.86280403e-03f, -1.48490518e-02f, -2.47730967e-02f, -3.98249850e-02f, 3.34813334e-02f, -9.12432671e-02f, 1.89131498e-02f, 3.74899991e-02f,
  -9.65038165e-02f, -2.57205904e-01f, -2.98228301e-02f, -9.26487744e-02f, 2.01685224e-02f, -1.91636588e-02f, -7.49548711e-03f, -2.19396576e-01f, -2.28163111e-03f, -8.89933929e-02f,
  -1.56750813e-01f, -1.49217799e-01f, -5.72583377e-02f, 1.20930418e-01f, 1.31139487e-01f, 4.84752133e-02f, 5.94767928e-02f, 1.58744186e-01f, 6.35176711e-03f, 8.88597686e-03f,
  1.36222064e-01f, 2.65374035e-01f, 1.92220032e-01f, 1.05788581e-01f, 6.42750487e-02f, 1.82836488e-01f, 1.38110638e-01f, 1.98501125e-01f, -6.78283023e-03f, 2.78023958e-01f,
  -7.47920871e-01f, -1.80051222e-01f, 7.15446323e-02f, -2.86441654e-01f, -1.25520542e-01f, -3.17129679e-02f, 1.75300330e-01f, -1.67932108e-01f, -1.41172588e-01f, -2.05315296e-02f,
  -1.95324793e-01f, -1.10026695e-01f, 2.73906570e-02f, 6.30644187e-02f, -1.75864756e-01f, 3.75935853e-01f, -3.77003178e-02f, 4.58276235e-02f, 9.05527771e-02f, 3.86198871e-02f,
  6.00753836e-02f, 2.61483043e-02f, -3.47448200e-01f, -1.50324196e-01f, 3.99781726e-02f, 9.28343683e-02f, 9.30899009e-02f, -1.25794813e-01f, -9.41759273e-02f, -8.42181519e-02f,
  3.78059834e-01f, -3.66563499e-01f, 2.84478236e-02f, -2.72343993e-01f, -9.63698775e-02f, -2.41012424e-01f, 8.07143748e-02f, -4.75392379e-02f, -8.02120045e-02f, -9.26395413e-03f,
  -1.31744593e-01f, 2.01136107e-03f, 4.07512533e-03f, 2.49732826e-02f, 1.09023429e-01f, 8.44498537e-03f, -2.85066832e-02f, -1.97911128e-01f, -1.25944912e-01f, 8.63367692e-02f,
  -1.41680285e-01f, -8.39962363e-02f, 2.57973112e-02f, 6.36200309e-02f, -1.96369186e-01f, -4.06252891e-02f, -9.45853442e-02f, -1.70796245e-01f, -1.47713363e-01f, 3.81231382e-02f,
  -6.30819201e-02f, -2.47318461e-03f, -3.10013965e-02f, -3.00919246e-02f, -7.38429800e-02f, 1.28744453e-01f, 7.07593039e-02f, 7.11336136e-02f, 8.68967697e-02f, -4.07760479e-02f,
  -7.48892948e-02f, 7.80651197e-02f, -4.11910284e-03f, -1.96277704e-02f, -3.16639021e-02f, -1.56116545e-01f, -4.15443927e-02f, 4.99830022e-02f, -1.21774919e-01f, -1.03458673e-01f,
  -1.11739293e-01f, -1.86980754e-01f, 1.73250604e-02f, 5.58220781e-02f, -1.65437877e-01f, -6.16597719e-02f, -5.88582233e-02f, -1.42156333e-01f, -1.90677289e-02f, -1.08840935e-01f,
  4.29377258e-01f, -2.18867943e-01f, 2.90074676e-01f, 2.56522279e-03f, -6.22282811e-02f, -1.99985564e-01f, -3.05961948e-02f, -9.57314000e-02f, -5.35305068e-02f, -2.15724036e-02f,
  -9.19955820e-02f, 6.44415244e-02f, 7.08311945e-02f, -5.92399482e-03f, 7.90334567e-02f, -8.42000470e-02f, -5.63449189e-02f, 9.56597645e-03f, 4.29840945e-02f, 2.87706014e-02f,
  1.48026850e-02f, 5.76394014e-02f, -1.58016998e-02f, 8.54466781e-02f, 6.95070401e-02f, 2.19345033e-01f, 1.47684053e-01f, 8.74549747e-02f, 3.84820439e-02f, 3.96289170e-01f,
  4.47272003e-01f, 3.52558583e-01f, 2.26872228e-02f, 3.43772382e-01f, 5.05756140e-01f, 2.07063302e-01f, 8.65572095e-02f, -1.67574584e-02f, 4.23918329e-02f, 1.58715606e-01f,
  2.57223785e-01f, 2.81394511e-01f, 6.33597225e-02f, 5.01538925e-02f, -1.23156913e-01f, -8.19792449e-02f, -7.82885849e-02f, 1.91465095e-02f, -4.23780158e-02f, -1.46497565e-03f,
  3.10226113e-01f, 1.55087456e-01f, 6.63884729e-02f, -8.24000910e-02f, 1.63429141e-01f, 8.44545439e-02f, -1.09927036e-01f, 2.93936312e-01f, 2.41184875e-01f, 3.67218465e-01f,
  1.14214599e-01f, 3.96556733e-03f, -1.25831380e-01f, 1.27847701e-01f, 1.42061025e-01f, -1.44592330e-01f, -9.30332914e-02f, -1.40928179e-01f, 2.89823133e-02f, -2.39835054e-01f,
  -1.06170261e-02f, 5.11026233e-02f, 1.52053237e-01f, 2.33276915e-02f, -3.58465910e-02f, -9.81978923e-02f, -2.45022967e-01f, -1.28465816e-01f, -2.12940723e-01f, -1.50452286e-01f,
  1.39151901e-01f, 1.87615454e-01f, 8.32820609e-02f, -2.32462108e-01f, -2.13211570e-02f, 1.45584345e-01f, -4.88816760e-03f, 4.25346149e-03f, -2.45832086e-01f, -1.44300058e-01f,
  -1.12674713e-01f, 9.76512432e-02f, 1.15073927e-01f, -1.39339104e-01f, -2.49481872e-02f, -7.23814080e-03f, -3.81798148e-02f, 1.46294132e-01f, -2.93444060e-02f, 4.26600873e-02f,
  -1.62773699e-01f, -1.53249010e-01f, -7.66300410e-02f, -1.38694331e-01f, 1.97123233e-02f, 5.09440340e-02f, 3.00860256e-02f, -2.15742588e-02f, 6.37016594e-02f, 2.66300682e-02f,
  -8.39629918e-02f, 3.35953720e-02f, -1.60174295e-02f, -9.04430822e-03f, 2.42491458e-02f, 4.86601070e-02f, -3.44253518e-03f, -1.19354829e-01f, 9.21174418e-03f, -1.03391938e-01f,
  -1.12724259e-01f, -2.53523071e-03f, 6.65257946e-02f, -6.85955733e-02f, 7.33901262e-02f, 2.78555099e-02f, 1.50056571e-01f, 3.24691716e-03f, 2.22407077e-02f, 2.74320301e-02f,
  1.37739470e-02f, -5.00111803e-02f, -8.28261450e-02f, 2.45521236e-02f, -9.31426361e-02f, -8.63841772e-02f, 1.19131528e-01f, -5.39474599e-02f, -1.81020945e-01f, -8.52399990e-02f,
  -8.52972269e-02f, -1.35262802e-01f, -1.61908954e-01f, -2.90078402e-01f, -8.03685784e-02f, -5.24431802e-02f, -5.62892705e-02f, -6.81856871e-02f, -1.55590668e-01f, -2.11152807e-01f,
  -1.42166734e-01f, -2.15310186e-01f, 3.33209306e-01f, 1.91613957e-01f, 1.10597372e-01f, 2.36169279e-01f, 1.45400256e-01f, 9.50439647e-02f, 2.27833241e-02f, 1.31894117e-02f,
  3.78074534e-02f, 9.21042785e-02f, 6.58335537e-02f, 9.78452861e-02f, -6.45359559e-03f, 8.76572505e-02f, 1.18724659e-01f, 4.21946384e-02f, 3.10212880e-01f, 2.25965112e-01f,
  -2.22994331e-02f, -3.08726970e-02f, 4.94153872e-02f, -4.59662192e-02f, -9.49900970e-02f, 1.00943439e-01f, -3.67415627e-03f, -5.38413078e-02f, -1.97688732e-02f, -1.43722713e-01f,
  4.53165501e-01f, -1.98805690e-01f, 2.40259185e-01f, -4.59827743e-02f, -1.14054650e-01f, 5.22004925e-02f, 4.11600731e-02f, 8.68930202e-03f, 1.33929830e-02f, 8.58210698e-02f,
  -5.88074699e-03f, -1.34953838e-02f, -9.68825817e-02f, -9.48570892e-02f, -5.70664322e-03f, 6.01424500e-02f, -2.15057060e-01f, -2.68209353e-02f, 5.31517938e-02f, 1.59664303e-02f,
  -8.03126097e-02f, 1.22683877e-02f, 1.06340714e-01f, 5.77677414e-02f, -2.19801351e-01f, -4.48407345e-02f, -1.17030695e-01f, -2.06906006e-01f, -3.25533152e-02f, -1.35843664e-01f,
  7.52783567e-02f, -3.35896970e-03f, -1.47116510e-02f, -3.41919214e-02f, -7.13705318e-03f, -4.38261917e-03f, 3.74520454e-03f, -2.59510446e-02f, 1.09574229e-01f, -5.32942675e-02f,
  4.36319187e-02f, -2.19762363e-02f, -3.40657644e-02f, 1.03332743e-01f, 3.45622115e-02f, 4.39178869e-02f, 3.04990672e-02f, 8.42288509e-02f, 4.81654936e-03f, -1.86449885e-01f,
  -6.54190257e-02f, 8.91107917e-02f, 9.24590509e-03f, -1.39074966e-01f, -1.37072606e-02f, -2.34936513e-02f, 2.98775043e-02f, -8.43369737e-02f, -1.78069044e-02f, 1.04843281e-01f,
  2.30656624e-01f, -3.60884555e-02f, 2.03215361e-01f, -1.64590880e-01f, -5.02091385e-02f, -7.87750036e-02f, -1.27444640e-01f, 7.50204995e-02f, 4.16425057e-02f, 2.04968736e-01f,
  8.82726535e-03f, 2.47253701e-02f, 7.80573348e-03f, 2.80990219e-03f, 1.52110428e-01f, 2.08919987e-01f, -1.97207317e-01f, 2.30405807e-01f, 6.28002733e-02f, 8.50524157e-02f,
  6.94577070e-03f, 2.46873602e-01f, 2.68958896e-01f, 2.12136194e-01f, 7.79254958e-02f, 2.01077715e-01f, 2.29151040e-01f, 7.54780695e-02f, 1.49014294e-01f, 2.11017087e-01f,
  6.91994190e-01f, 3.85536283e-01f, 2.52643526e-01f, 7.28478953e-02f, -3.99387300e-01f, -3.68969798e-01f, -1.04511157e-01f, -2.60620825e-02f, -1.87138274e-01f, 1.36579517e-02f,
  -1.39047250e-01f, -1.04566678e-01f, -8.63716602e-02f, 1.21979468e-01f, 1.06912777e-01f, 1.26023144e-01f, 7.52790123e-02f, 3.28229010e-01f, -5.27848955e-03f, -6.38698861e-02f,
  6.57176897e-02f, 7.44085535e-02f, 2.74568826e-01f, 6.13211766e-02f, 1.88339084e-01f, -1.14050008e-01f, -7.10315444e-03f, 2.00255532e-02f, 4.68613915e-02f, 4.06105101e-01f,
  2.60456353e-01f, 2.80110389e-01f, -1.68391153e-01f, -6.07223064e-03f, 3.47471647e-02f, 8.80247578e-02f, -4.68895137e-02f, 8.59754905e-02f, 4.21185084e-02f, -3.94717529e-02f,
  -8.69810805e-02f, 5.81072196e-02f, -6.00574017e-02f, -1.66896023e-02f, -2.92532984e-02f, 9.52745881e-03f, 6.79593459e-02f, 5.47244139e-02f, -9.13191289e-02f, 3.65710780e-02f,
  4.45170961e-02f, -5.84276672e-03f, -1.28095657e-01f, -2.43796945e-01f, 1.86792128e-02f, -2.06563070e-01f, -8.63217860e-02f, 6.14875508e-03f, -8.99308696e-02f, 1.16093650e-01f,
  -5.03317676e-02f, 5.75201474e-02f, -4.46196645e-02f, -7.55880550e-02f, -9.14949179e-02f, -1.40605137e-01f, -4.03255969e-03f, -1.52564690e-01f, -8.38917866e-02f, 8.23121052e-03f,
  -1.67847484e-01f, -5.53194992e-02f, -5.37369661e-02f, -6.31684661e-02f, -7.09489584e-02f, -2.30534729e-02f, -1.57902390e-02f, 4.54402678e-02f, -9.85655189e-03f, 4.59603965e-02f,
  -3.69449742e-02f, -3.52093503e-02f, 3.59984227e-02f, -6.52232720e-03f, 6.14275932e-02f, -1.10330969e-01f, 2.53728479e-02f, -7.94679597e-02f, -6.31160364e-02f, 5.80890104e-02f,
  -2.93571383e-01f, -2.80229777e-01f, 2.31437489e-01f, 2.42281124e-01f, 1.97749004e-01f, 1.21475160e-01f, 2.09049746e-01f, 9.79011357e-02f, 1.90135445e-02f, -4.05255072e-02f,
  1.41859790e-02f, 1.92648157e-01f, 6.97704628e-02f, 3.41303647e-02f, -4.63166349e-02f, -1.14902981e-01f, 7.70219564e-02f, 8.25484022e-02f, 2.60056201e-02f, -1.24109961e-01f,
  2.39438973e-02f, -2.01398939e-01f, -1.69994354e-01f, -2.11944669e-01f, -9.70810354e-02f, -2.41013929e-01f, -5.00505306e-02f, 2.45770570e-02f, -4.13913056e-02f, -1.35792032e-01f,
  7.80695155e-02f, 2.61351258e-01f, -3.60185243e-02f, -6.07574657e-02f, 1.09649315e-01f, 3.78513783e-01f, 5.02492368e-01f, 2.51878619e-01f, -1.07475765e-01f, 6.76663443e-02f,
  2.42218688e-01f, 4.28298488e-02f, 2.38623247e-02f, -8.46941210e-03f, 1.70922335e-02f, -5.82234226e-02f, -1.36900425e-01f, -1.84143290e-01f, -1.42188370e-01f, -2.03700606e-02f,
  -2.33480200e-01f, -2.59926349e-01f, -2.86733717e-01f, -3.24176580e-01f, -3.16864669e-01f, -3.83946955e-01f, -1.05280913e-01f, -1.11495890e-01f, 9.94441751e-03f, -4.07281756e-01f,
  3.70693356e-02f, 4.07714903e-01f, -9.95048583e-02f, 1.91875342e-02f, 2.10763887e-01f, -8.14659074e-02f, 5.46245389e-02f, -9.45131481e-02f, -5.17903566e-02f, -9.08600166e-02f,
  7.43911266e-02f, -1.28088042e-01f, -5.31936949e-03f, -7.18067363e-02f, 1.52807981e-01f, 1.19753756e-01f, 2.01610625e-02f, 4.55213748e-02f, 5.76704480e-02f, 6.01512603e-02f,
  7.64721557e-02f, 1.07396461e-01f, 2.29650065e-01f, 2.63254642e-01f, 1.50614515e-01f, 5.31673096e-02f, 1.60013601e-01f, 1.24004886e-01f, 2.22226858e-01f, 1.15474306e-01f,
  1.43157348e-01f, -7.80387670e-02f, 1.25590250e-01f, -1.30671328e-02f, 6.53390959e-02f, 1.46735075e-03f, -9.20143649e-02f, 3.28690410e-02f, 3.20957713e-02f, -9.48182270e-02f,
  -6.75796811e-03f, 1.60966530e-01f, 1.07476324e-01f, 1.58668999e-02f, -6.77063465e-02f, -1.11963786e-01f, -6.53146803e-02f, 7.70696402e-02f, 1.30953975e-02f, 2.41698977e-02f,
  3.90971266e-02f, -1.02057695e-01f, -1.23870052e-01f, 1.24828398e-01f, 7.16125146e-02f, 7.31604872e-03f, 2.45163664e-02f, 3.90675180e-02f, -1.30803213e-01f, -2.00670227e-01f,
  -9.91100147e-02f, 4.01914269e-01f, -1.11067034e-01f, -4.00890335e-02f, -6.37773797e-02f, -2.68520992e-02f, 1.34824544e-01f, -1.14555478e-01f, -1.38711184e-02f, -4.48833853e-02f,
  6.15877658e-02f, -1.56189010e-01f, -7.24423453e-02f, 2.26832535e-02f, -1.06040403e-01f, 1.12553798e-01f, 1.58972889e-01f, 2.19497979e-02f, 1.11798961e-02f, -1.05677238e-02f,
  -7.63519257e-02f, 9.94719267e-02f, 3.31402831e-02f, -8.80454406e-02f, 6.58438308e-04f, -7.43574351e-02f, -5.21262921e-02f, -5.25844470e-02f, 5.54133253e-03f, -7.91495293e-02f,
  -3.67576838e-01f, -1.56172007e-01f, 4.74049896e-01f, -2.65597403e-01f, 1.05205789e-01f, -3.64273507e-03f, -2.03922033e-01f, -8.20722431e-02f, -6.06433935e-02f, -2.67632514e-01f,
  -1.49619386e-01f, -1.20151013e-01f, 1.60721189e-03f, -7.37755001e-02f, -1.22131847e-01f, -7.22646061e-03f, 1.22954659e-01f, 1.28224447e-01f, 1.05259195e-02f, -1.22805499e-01f,
  -6.51999936e-02f, -9.53938589e-02f, -1.51683927e-01f, -7.92441219e-02f, -2.58621126e-01f, -2.32513875e-01f, 9.62532908e-02f, -1.83001891e-01f, -1.16703518e-01f, -2.27203265e-01f,
  9.53262858e-03f, -6.31367415e-02f, 3.12465608e-01f, -2.73697376e-01f, -6.01500086e-02f, -1.26779616e-01f, -5.85647412e-02f, 6.60480559e-02f, 2.42799819e-02f, -8.10362920e-02f,
  -8.44290629e-02f, 5.06117642e-02f, -1.04061939e-01f, -3.40800360e-02f, -1.33377865e-01f, -7.67443106e-02f, 1.81303516e-01f, 1.49190381e-01f, 3.48634906e-02f, -1.84173554e-01f,
  -9.21469256e-02f, -1.62800416e-01f, -2.10330233e-01f, 1.32389721e-02f, -1.72078912e-03f, 3.73140089e-02f, -1.09400012e-01f, -1.67905927e-01f, 5.01516499e-02f, -2.83793956e-01f,
  -1.18076475e-02f, -9.95438024e-02f, 6.35794923e-02f, 1.94775797e-02f, -6.91850260e-02f, 9.05079842e-02f, 2.14873329e-02f, -4.75522466e-02f, -1.84191186e-02f, -1.02189101e-01f,
  -1.25103984e-02f, -5.01481257e-03f, 8.25763494e-02f, -4.81609851e-02f, 9.80117470e-02f, 6.28191978e-02f, -1.12630799e-01f, -3.08369305e-02f, -5.84564283e-02f, 1.24709316e-01f,
  -1.33642927e-01f, -9.12077352e-02f, -2.05812743e-03f, -4.52075899e-02f, 8.95573422e-02f, 1.22063622e-01f, 9.52011626e-03f, -6.27041161e-02f, 8.05588439e-02f, 1.16927870e-01f,
  -9.23529938e-02f, 3.11339855e-01f, -2.38616522e-02f, -7.40121976e-02f, -1.70569897e-01f, 1.22168526e-01f, 7.42300972e-03f, 1.13737034e-02f, 1.98045447e-02f, -1.87616304e-01f,
  -7.64440671e-02f, -7.52965212e-02f, -2.68063974e-02f, 7.50159770e-02f, -1.52381420e-01f, -9.02852044e-02f, -1.66643918e-01f, -1.01394013e-01f, 2.67214552e-02f, -1.41500399e-01f,
  -6.74927533e-02f, -3.14155847e-01f, -5.68289936e-01f, -2.00894147e-01f, -3.22045952e-01f, -2.87335753e-01f, -2.08007216e-01f, -7.82429576e-02f, -2.59669900e-01f, -5.42419255e-01f,
  -1.37171403e-01f, 1.79297104e-01f, -3.58886242e-01f, -8.11621174e-02f, -3.79141331e-01f, -2.38346666e-01f, 7.77037218e-02f, 1.71296850e-01f, 3.25448699e-02f, -8.57454026e-04f,
  4.26120013e-02f, 1.56974256e-01f, 1.82415843e-01f, 1.82267964e-01f, 2.41969377e-01f, -9.40920413e-02f, -3.18920821e-01f, -7.77873099e-02f, 2.11684704e-02f, -3.71182896e-02f,
  5.84937893e-02f, 6.37882277e-02f, 6.14803135e-02f, 1.12210490e-01f, -2.64445066e-01f, -3.11582088e-01f, -3.69719148e-01f, -1.83255896e-01f, -4.43624705e-02f, -3.63330424e-01f,
  -1.82472020e-01f, -2.63481528e-01f, -8.80901590e-02f, 7.12625980e-02f, -3.34051430e-01f, 4.71466295e-02f, 8.15015845e-03f, -2.38205776e-01f, 5.32404408e-02f, -1.51933115e-02f,
  3.38098630e-02f, 6.87093958e-02f, -9.30379480e-02f, -6.57117143e-02f, -4.72918414e-02f, -1.00584272e-02f, -1.63791273e-02f, 7.03857839e-02f, 7.08071142e-02f, 6.88964352e-02f,
  1.04568549e-03f, -1.42674237e-01f, -1.62940502e-01f, -1.47259995e-01f, -1.71811938e-01f, -1.78473532e-01f, -1.28078103e-01f, -3.03892761e-01f, -1.07515752e-01f, -2.24227514e-02f,
  -8.19677934e-02f, -2.05667689e-02f, 2.38220766e-02f, -1.10690212e-02f, 1.41235426e-01f, -8.39454085e-02f, -1.33041576e-01f, 2.42734272e-02f, 1.18010208e-01f, 4.51094797e-03f,
  -2.45671310e-02f, -6.23319820e-02f, 5.67679480e-03f, -1.01091422e-01f, -5.22851944e-02f, 2.61122175e-02f, -4.58171032e-02f, 4.24607433e-02f, 6.65842509e-03f, 5.72867924e-03f,
  5.84828444e-02f, -1.18369527e-01f, 4.78716940e-02f, 1.15858158e-02f, -1.17180422e-01f, 5.27412072e-02f, 5.47010191e-02f, 1.68050379e-01f, 1.16621561e-01f, 6.00353703e-02f,
  1.63974538e-01f, -8.47284868e-02f, 4.24167253e-02f, 2.23264977e-01f, -1.10004559e-01f, -1.20335929e-02f, -1.19642690e-01f, -8.55508819e-03f, -1.04009777e-01f, 6.83955401e-02f,
  3.18591967e-02f, 6.59150945e-04f, 8.90611857e-03f, 1.93711165e-02f, 7.77182635e-03f, 2.30007619e-01f, -8.91254842e-02f, -7.15207588e-03f, 6.38861060e-02f, 1.02343939e-01f,
  1.48032159e-01f, 1.38564453e-01f, -1.74862836e-02f, 1.15426265e-01f, -6.61142766e-02f, -5.70524000e-02f, 7.02792704e-02f, -5.25317378e-02f, 1.71693176e-01f, 4.32302386e-01f,
  -6.33365870e-01f, -1.07228525e-01f, -1.29869625e-01f, 1.16844974e-01f, 2.59965688e-01f, 3.52018744e-01f, 4.62358296e-01f, 3.29300076e-01f, 9.72883850e-02f, 1.63345098e-01f,
  -4.96499948e-02f, 4.61675078e-02f, 8.37455466e-02f, 1.76956579e-01f, 2.09537566e-01f, 2.60442913e-01f, 3.84701669e-01f, -8.29077065e-02f, -7.69096464e-02f, 8.07352066e-02f,
  1.53186262e-01f, -9.77811664e-02f, -2.55906314e-01f, -3.51229534e-02f, 4.36502770e-02f, 1.27409287e-02f, 4.61627916e-02f, 1.35819748e-01f, 2.22233199e-02f, 1.88569084e-01f,
  -6.25931844e-02f, -2.03185812e-01f, -1.96834095e-03f, -7.58039057e-02f, -1.05565861e-01f, -2.79518723e-01f, -8.88692141e-02f, -7.23044053e-02f, -1.10788248e-01f, -9.32815745e-02f,
  -2.30686497e-02f, -6.08853549e-02f, -2.08655358e-04f, -6.83181733e-03f, -1.32762892e-02f, -8.59774500e-02f, -6.24966286e-02f, 2.91270353e-02f, 2.33026639e-01f, 9.78958756e-02f,
  1.64642617e-01f, 5.48697710e-02f, 1.42224416e-01f, 1.69435412e-01f, 1.37287050e-01f, 8.12511295e-02f, -5.84674347e-03f, -4.27242257e-02f, -3.86899672e-02f, -3.31021398e-02f,
  1.76946938e-01f, 4.82100919e-02f, 2.46851314e-02f, 9.30750668e-02f, -1.32489502e-02f, -6.45544380e-02f, 1.13618612e-01f, 1.71892941e-01f, 8.17079693e-02f, -1.38310552e-01f,
  -2.88583152e-03f, 1.70819923e-01f, 1.66389063e-01f, 4.33678776e-02f, 6.81004766e-03f, 4.00827155e-02f, -7.12831095e-02f, -9.60535407e-02f, -1.62826240e-01f, -7.38629922e-02f,
  -1.97491162e-02f, 1.03405043e-02f, -1.15943752e-01f, 1.27721503e-01f, -9.99211892e-03f, 7.32981646e-03f, 6.23987578e-02f, -3.49942669e-02f, 8.74648243e-02f, -8.32707882e-02f,
  2.98927248e-01f, 9.80731994e-02f, 5.45659177e-02f, -1.77942403e-02f, -6.50914833e-02f, -2.02782169e-01f, -6.21035583e-02f, -1.29529312e-01f, 3.69727351e-02f, 5.57936132e-02f,
  -5.46084829e-02f, -9.63697433e-02f, -1.39327511e-01f, -1.17696762e-01f, -1.58905268e-01f, -1.43260464e-01f, -8.37842152e-02f, 1.46235079e-01f, 8.84150639e-02f, 5.27426079e-02f,
  9.81545895e-02f, 5.04098646e-02f, 1.59449950e-02f, 4.49215621e-02f, 1.10213578e-01f, 1.36041015e-01f, 8.62021074e-02f, 4.68257926e-02f, 1.62158515e-02f, -1.72876358e-01f,
  -3.46643120e-01f, -9.86230448e-02f, 1.71175331e-01f, -2.59180635e-01f, 1.75072819e-01f, 1.33021757e-01f, 1.85354620e-01f, -1.63801163e-02f, 2.71588918e-02f, 8.22502598e-02f,
  4.00529839e-02f, 2.45300066e-02f, 1.91185728e-01f, 2.70850718e-01f, 1.04819566e-01f, 8.94162208e-02f, 1.29526868e-01f, 1.04578190e-01f, 1.47828972e-02f, 4.34533171e-02f,
  5.00710011e-02f, -3.82200815e-02f, -1.32175833e-01f, -1.44345269e-01f, -7.08684102e-02f, -1.61030844e-01f, 4.78778146e-02f, -1.49380118e-01f, -8.62708539e-02f, -5.64442016e-02f,
  8.80200639e-02f, -1.85492158e-01f, 1.91583395e-01f, -7.77048692e-02f, -2.92857904e-02f, -9.53915939e-02f, 4.38614897e-02f, 1.28746346e-01f, 4.38152812e-02f, 5.24340123e-02f,
  2.03404874e-02f, -2.62992270e-02f, 6.42884523e-02f, -5.10941334e-02f, -3.29884477e-02f, -1.77679747e-01f, -4.09984961e-02f, 5.06692417e-02f, 1.15939360e-02f, -2.06876040e-01f,
  5.19311838e-02f, 4.76326607e-02f, -7.14755058e-02f, 3.04619707e-02f, -9.20759365e-02f, -7.56727578e-03f, -1.66710228e-01f, -1.81615636e-01f, 4.94230725e-03f, -2.96346575e-01f,
  3.97888981e-02f, -2.94544827e-02f, -4.45148945e-02f, -1.43859461e-01f, -1.07212096e-01f, -7.49749169e-02f, -1.01103578e-02f, -1.11048492e-02f, 3.20240855e-02f, -4.13232483e-02f,
  1.34902552e-01f, -1.10774606e-01f, -1.00651920e-01f, -5.07687628e-02f, -7.27343336e-02f, -5.26325107e-02f, 1.99373979e-02f, -1.86236188e-01f, -4.31288183e-02f, -1.35026306e-01f,
  -1.40743544e-02f, -1.24733970e-01f, 2.25929599e-02f, -3.51940319e-02f, -9.40840468e-02f, -1.51030496e-01f, -5.36973067e-02f, -8.57852846e-02f, -5.22498004e-02f, 4.97999638e-02f,
  -2.97696382e-01f, 4.21601862e-01f, -1.20494202e-01f, -5.09167723e-02f, -6.22634869e-03f, -7.32872542e-03f, -1.49699599e-01f, 5.19600920e-02f, -5.56105264e-02f, -1.53446183e-01f,
  -3.36096846e-02f, -2.04653904e-01f, -4.95594479e-02f, 2.32603475e-02f, -9.34579372e-02f, -9.22015123e-03f, -1.65849507e-01f, -8.79028141e-02f, 1.23778088e-02f, -2.12942764e-01f,
  -2.82384437e-02f, -2.65598178e-01f, -2.54955739e-01f, 1.05225286e-02f, -1.55188143e-01f, -2.71277398e-01f, -1.57336086e-01f, -2.10367050e-02f, -5.91678172e-02f, -1.81868657e-01f,
  6.42541111e-01f, -1.26021117e-01f, -5.31006336e-01f, 1.61380351e-01f, -2.82099038e-01f, 3.28978933e-02f, -6.49466962e-02f, 1.91436291e-01f, 1.13517128e-01f, -1.97506979e-01f,
  1.76014472e-02f, 2.85222173e-01f, 1.82721898e-01f, 2.73023676e-02f, 2.11167321e-01f, -2.42843091e-01f, -2.37554327e-01f, 5.25453500e-02f, 2.47196093e-01f, -3.40132043e-02f,
  7.69036647e-04f, 8.21544379e-02f, 1.51627392e-01f, 1.30840093e-01f, -2.46825427e-01f, 1.74031239e-02f, -3.96317661e-01f, -1.76529318e-01f, -1.59503952e-01f, -3.37867498e-01f,
  -9.61603597e-02f, -1.50902778e-01f, -2.65956242e-02f, 2.11507175e-02f, -1.45282909e-01f, 1.43014550e-01f, 9.66021717e-02f, -1.05062596e-01f, -3.99019718e-02f, -8.11113417e-03f,
  -1.16716728e-01f, -1.37472063e-01f, 4.50723544e-02f, -1.09332941e-01f, -3.71302702e-02f, 2.72633880e-03f, -7.22681731e-02f, -1.48990259e-01f, -8.46892372e-02f, -9.55099389e-02f,
  -4.03737463e-02f, -8.59648082e-03f, -1.62647590e-01f, -7.15182871e-02f, -3.86835113e-02f, 5.04375771e-02f, -2.64109969e-01f, -1.22287214e-01f, -1.10406287e-01f, -6.11104704e-02f,
  1.09121082e-02f, 1.19480053e-02f, -1.77843012e-02f, 1.86522901e-02f, -3.53519805e-02f, 1.27995417e-01f, -9.88229290e-02f, 9.40069631e-02f, 5.77778183e-02f, 6.14233576e-02f,
  -1.69880060e-03f, -6.19979165e-02f, -1.35143707e-02f, 7.71098211e-02f, -1.80009857e-03f, 5.08591672e-03f, -8.64324253e-03f, 3.03815417e-02f, 4.55457009e-02f, 1.12933382e-01f,
  1.07879072e-01f, -6.45962283e-02f, -8.18864331e-02f, 5.79061219e-03f, -7.59858564e-02f, 2.58778059e-03f, -1.14067785e-01f, -5.69759086e-02f, 3.53383981e-02f, 2.44870540e-02f,
  3.16328853e-01f, 8.93490296e-03f, 1.41089380e-01f, 6.22669458e-02f, -7.18962401e-02f, 8.89506638e-02f, 3.39099169e-02f, 6.83078691e-02f, 1.48757631e-02f, -4.04200405e-02f,
  -7.00610653e-02f, 5.12326248e-02f, -7.92876258e-03f, -6.48889020e-02f, -3.23078521e-02f, -3.35920826e-02f, 8.39043632e-02f, 1.23651169e-01f, 1.29499331e-01f, -1.47716835e-01f,
  1.40597701e-01f, 9.16469172e-02f, 2.92885363e-01f, 1.01229370e-01f, -4.27640369e-03f, 9.76852104e-02f, 4.58313189e-02f, 4.88828197e-02f, 1.06285267e-01f, 2.85791904e-01f,
  9.28635836e-01f, 5.02931714e-01f, 6.25254631e-01f, 1.92146420e-01f, 1.34496570e-01f, 3.03731501e-01f, 5.91371238e-01f, 3.50365728e-01f, 2.17830315e-02f, 1.79356232e-01f,
  9.98209324e-03f, -2.88741440e-01f, -1.44418567e-01f, -1.28490850e-01f, 1.24901526e-01f, 1.45840034e-01f, 3.64925228e-02f, 7.31567293e-02f, 1.23343989e-01f, -5.65776043e-02f,
  -3.13780069e-01f, -7.08637908e-02f, 1.03643954e-01f, 4.55030873e-02f, -1.41227841e-01f, -1.87981874e-01f, 1.29319385e-01f, 6.64408281e-02f, 4.47895611e-03f, -1.16707690e-01f,
  -8.79092962e-02f, 4.70616490e-01f, -3.36117715e-01f, -3.30288559e-01f, -1.31662205e-01f, -7.43721128e-02f, -2.54103597e-02f, -1.11233391e-01f, -4.79909033e-02f, -1.75754398e-01f,
  -7.29973316e-02f, -7.85387084e-02f, 2.75063352e-03f, -1.50812166e-02f, 7.37794861e-02f, 2.52462886e-02f, 8.54647905e-02f, 1.75469384e-01f, 2.32606009e-02f, -1.09521151e-02f,
  -2.38736235e-02f, 1.51584119e-01f, 2.27312148e-01f, 7.71325007e-02f, 3.61084379e-02f, -1.66720003e-01f, 1.68419898e-01f, 5.90723287e-03f, 1.36811376e-01f, -7.39270002e-02f,
  -1.79404184e-01f, 2.31854580e-02f, -7.95865059e-02f, 9.52821225e-02f, 9.49449837e-02f, 1.35045141e-01f, 9.57452357e-02f, 7.23850578e-02f, 7.13488534e-02f, 1.11335143e-01f,
  1.69115663e-02f, 1.38548380e-02f, 2.03101188e-01f, 4.47608940e-02f, -6.09028637e-02f, 9.13395882e-02f, 5.00971340e-02f, -1.21036144e-02f, 6.90936157e-03f, -9.88060161e-02f,
  1.78857371e-01f, 9.28375274e-02f, 5.35379946e-02f, 9.18017104e-02f, 1.61209777e-02f, 7.33590424e-02f, -8.55763778e-02f, -7.79772401e-02f, 6.96537346e-02f, 5.47302403e-02f,
  -5.54100692e-01f, 1.66990414e-01f, -5.85637279e-02f, -2.25104958e-01f, 6.11109696e-02f, -2.03940384e-02f, -2.19930708e-02f, -1.20913595e-01f, -1.93300009e-01f, -2.48660333e-02f,
  8.81697610e-02f, 5.04202843e-02f, 1.94869652e-01f, 1.20007679e-01f, 2.70932466e-02f, -1.18006608e-02f, -1.06839724e-01f, 5.19700572e-02f, -1.62510887e-01f, -1.41808257e-01f,
  6.71357056e-03f, -1.11359581e-01f, -4.55875695e-03f, 2.16826163e-02f, -1.61708876e-01f, -1.50460184e-01f, -1.64389014e-02f, -7.55326003e-02f, 9.39099714e-02f, 6.81741629e-03f,
  -4.61575478e-01f, 1.16787493e-01f, -2.59413403e-02f, -1.63377285e-01f, 2.97419399e-01f, 1.77299052e-01f, 1.13309421e-01f, -1.37410954e-01f, -1.72028750e-01f, 3.01024839e-02f,
  6.58447146e-02f, 1.86790330e-05f, 1.08399704e-01f, 1.33672297e-01f, -8.99066031e-02f, 1.04863338e-01f, 6.39496744e-02f, 3.62345278e-02f, -1.43793166e-01f, -1.74478531e-01f,
  1.90668359e-01f, -1.46510229e-01f, -1.92245111e-01f, -8.09761435e-02f, -1.32378647e-02f, -4.88409474e-02f, 8.34856927e-03f, 1.72282550e-02f, 8.52314085e-02f, 2.61992633e-01f,
  1.41470551e-01f, 4.51959185e-02f, -4.49186638e-02f, -2.36271873e-01f, -5.84628917e-02f, -1.62331402e-01f, 6.48077875e-02f, 3.76027514e-04f, -3.32400613e-02f, -4.46600690e-02f,
  8.72388631e-02f, 1.53205425e-01f, -2.31782589e-02f, 1.67786717e-01f, -9.90154445e-02f, -2.07084846e-02f, -1.49449065e-01f, -1.38851747e-01f, -2.57164955e-01f, -2.86432266e-01f,
  1.22419260e-01f, 3.79202291e-02f, -9.60332155e-02f, -1.66105673e-01f, -1.78614914e-01f, 4.91724536e-02f, -1.34727329e-01f, -5.71650453e-02f, -2.01560110e-02f, -1.06805317e-01f,
  1.10484466e-01f, 4.89535443e-02f, 5.60661107e-02f, 1.21970482e-01f, 2.49783713e-02f, -1.89031735e-02f, 1.51063427e-01f, 1.34902626e-01f, -2.54985355e-02f, 2.25477796e-02f,
  1.37675717e-01f, 1.06560044e-01f, -1.53353550e-02f, -2.44286936e-02f, 1.26968041e-01f, 8.18253830e-02f, 1.84559133e-02f, 2.30454933e-02f, 1.24283016e-01f, -1.16253272e-02f,
  -5.98012097e-02f, -1.61307961e-01f, -1.37166986e-02f, -1.68161482e-01f, 4.13849577e-02f, 7.72464499e-02f, 6.91963965e-03f, 9.81140584e-02f, 1.33627847e-01f, 9.82168689e-02f,
  -3.07770997e-01f, 3.06424707e-01f, 3.54232127e-03f, -1.52434140e-01f, 9.17899050e-03f, 2.31892895e-02f, 6.36761039e-02f, 1.02714740e-01f, 1.95979755e-02f, -1.37626559e-01f,
  -8.12050402e-02f, -2.94037275e-02f, -1.40357792e-01f, -2.16804259e-02f, -1.99029639e-01f, -1.79092342e-03f, 9.64281410e-02f, -1.18148185e-01f, -1.45296231e-01f, -9.48784277e-02f,
  -2.54080951e-01f, -7.47831464e-02f, -2.23927468e-01f, -1.75599054e-01f, -7.74037614e-02f, 1.64630767e-02f, 1.40428338e-02f, -8.86355042e-02f, -2.75631826e-02f, -1.70141816e-01f,
  -8.49023402e-01f, 6.04941063e-02f, -7.02478811e-02f, -4.86129552e-01f, 2.87321001e-01f, 5.12782156e-01f, 5.91824651e-01f, 2.47445017e-01f, -4.15388532e-02f, 1.16156070e-02f,
  7.00184852e-02f, -2.09759939e-02f, 1.81256235e-02f, 2.66410410e-01f, 2.63715237e-01f, 2.52321929e-01f, 1.22045591e-01f, -1.23276763e-01f, -1.60310224e-01f, -5.27813472e-03f,
  2.03525931e-01f, -2.20522404e-01f, -2.93485373e-01f, -2.33276829e-01f, -1.32520720e-01f, -2.31158137e-01f, 1.27130123e-02f, -1.25864550e-01f, 1.14847325e-01f, -1.04570486e-01f,
  -7.84082785e-02f, -7.92342499e-02f, 2.39230037e-01f, -1.55392930e-01f, -1.69292584e-01f, -1.51946321e-01f, -1.44102583e-02f, -1.12791598e-01f, 7.03095086e-03f, 1.48546258e-02f,
  -1.07542843e-01f, -1.46451062e-02f, -5.68766743e-02f, -1.27942830e-01f, -5.04898690e-02f, 8.83770827e-03f, -1.33726120e-01f, 3.94215882e-02f, 1.05259076e-01f, 8.35547969e-02f,
  1.03775203e-01f, -2.80742478e-02f, 1.45580471e-01f, 3.17308724e-01f, 1.36734352e-01f, -4.72781807e-02f, 4.28695977e-02f, -1.38594091e-01f, 1.06928468e-01f, -1.50846899e-01f,
  6.94025531e-02f, -8.69782083e-03f, -4.69038785e-02f, -9.89697129e-02f, 9.44564678e-03f, 1.08165445e-03f, 1.60513818e-01f, 4.80395444e-02f, 4.72975010e-03f, -5.48182577e-02f,
  7.95326754e-02f, 1.43800437e-01f, 4.43753749e-02f, -1.08003952e-01f, -3.77934277e-02f, 1.93272308e-02f, 7.69437179e-02f, 5.21262689e-03f, 1.47270011e-02f, -2.36628614e-02f,
  -5.69041586e-03f, -5.06794676e-02f, -3.78458165e-02f, 1.35593107e-02f, 4.53868462e-03f, -5.89800589e-02f, 3.25590745e-02f, -6.68081716e-02f, -2.09536273e-02f, 1.70567378e-01f,
  -2.90830344e-01f, 4.66173291e-01f, -1.41000956e-01f, 1.28170609e-01f, 1.53598376e-02f, -5.81358522e-02f, -7.30198845e-02f, 8.14855769e-02f, 1.27500430e-01f, 4.07888517e-02f,
  -2.00645179e-02f, -8.17598775e-02f, -2.58873384e-02f, 7.49738216e-02f, -5.77947982e-02f, -1.16754532e-01f, -6.70607090e-02f, -4.59231511e-02f, 2.31546551e-01f, -3.74904573e-02f,
  1.13378592e-01f, 1.98688526e-02f, -6.56295754e-03f, 1.39787674e-01f, 1.18925720e-01f, -9.74739045e-02f, -9.33546796e-02f, -6.07508756e-02f, 1.05142929e-01f, -2.59322286e-01f,
  -3.20365071e-01f, 2.01175809e-01f, 4.10577953e-02f, -2.42238611e-01f, 2.41426289e-01f, 1.95530027e-01f, 3.26426834e-01f, -4.16435860e-03f, -1.40783027e-01f, 1.74063325e-01f,
  9.69402418e-02f, -1.17601566e-01f, -1.10964395e-01f, 1.86490994e-02f, -1.09698571e-01f, 1.53609499e-01f, 1.31960019e-01f, -1.59616023e-01f, -2.31774271e-01f, 1.74667814e-03f,
  1.57546997e-01f, 3.78795825e-02f, -1.78241432e-01f, -1.77713215e-01f, 3.82040627e-02f, -1.73293084e-01f, -8.68104622e-02f, -3.88974920e-02f, 1.65423706e-01f, 6.38542548e-02f,
  -1.72871858e-01f, -2.73923725e-01f, -6.79089641e-03f, 7.36352950e-02f, 9.50412080e-02f, -2.41558284e-01f, 1.30263895e-01f, -2.89765030e-01f, -1.25716373e-01f, -1.71435475e-01f,
  1.34880602e-01f, 1.66687876e-01f, 4.92729731e-02f, -1.42088071e-01f, -1.51685625e-01f, -7.40777105e-02f, -2.37937659e-01f, -2.37878576e-01f, -6.57374635e-02f, -1.30839869e-01f,
  2.94666588e-01f, 1.65921912e-01f, -4.71008457e-02f, -5.14934696e-02f, -4.67257611e-02f, -1.18879220e-02f, 8.04005116e-02f, -2.10143737e-02f, -1.26209244e-01f, 6.62603742e-03f,
  8.37585516e-03f, 1.82010457e-02f, 6.31244406e-02f, 4.77493517e-02f, 2.75666313e-03f, -4.52309772e-02f, -1.40246242e-01f, -2.76712235e-02f, -4.28026468e-02f, -1.74153388e-01f,
  -6.60536587e-02f, -6.15499057e-02f, -1.47973984e-01f, -6.24511354e-02f, -1.59290954e-01f, 8.60131830e-02f, 1.12198539e-01f, 4.68746275e-02f, -2.61156429e-02f, 5.51036671e-02f,
  -2.50902381e-02f, -3.15976776e-02f, 5.02275443e-03f, 6.75791055e-02f, 1.00620583e-01f, -4.43525910e-02f, -2.83601023e-02f, -2.98217442e-02f, -4.95776869e-02f, 5.11163063e-02f,
  -2.30539992e-01f, 1.10728946e-02f, -1.01940185e-01f, 4.40029651e-02f, -1.75630361e-01f, -5.49688712e-02f, -6.67835176e-02f, 8.32839496e-03f, -1.40001280e-02f, -1.38593778e-01f,
  -6.54266700e-02f, -1.83674201e-01f, -2.29621101e-02f, -1.09995380e-01f, -1.11826152e-01f, 1.54559975e-02f, 1.41028808e-02f, -9.48865935e-02f, 1.30734146e-01f, -7.97050074e-02f,
  1.03351727e-01f, 1.24008954e-01f, -8.17458183e-02f, -7.27525773e-03f, -1.38007015e-01f, -3.42003852e-02f, 2.19352618e-02f, -1.18301496e-01f, 6.17419407e-02f, 5.54410517e-02f,
  2.34772831e-01f, 1.50814414e-01f, -3.58421594e-01f, 1.33089736e-01f, 1.22248314e-01f, -8.74123499e-02f, -1.66899234e-01f, -2.53974617e-01f, 2.55142944e-03f, 8.82739499e-02f,
  -1.20760009e-01f, 1.48164153e-01f, 7.45033026e-02f, 4.94843163e-02f, -8.72087479e-02f, 1.54447049e-01f, 1.80339336e-01f, 5.98866418e-02f, -1.44514084e-01f, 5.06452248e-02f,
  2.39679620e-01f, 1.64081186e-01f, -1.33277312e-01f, -4.69084531e-02f, 3.07750225e-01f, 5.96194193e-02f, -7.73612931e-02f, 1.24392107e-01f, 3.34992893e-02f, 5.75192153e-01f,
  3.73294204e-03f, -1.54693529e-01f, -2.10759547e-02f, 7.33796656e-02f, -3.02515924e-02f, 1.14399970e-01f, 8.43937099e-02f, -6.58440357e-03f, 8.18927959e-02f, 2.21660063e-02f,
  2.32201472e-01f, -7.18340045e-03f, 2.54860390e-02f, -7.45975040e-03f, -9.85392109e-02f, 1.47183063e-02f, -3.41785811e-02f, 2.38759369e-02f, -1.32075110e-02f, 2.65849777e-03f,
  2.73861885e-01f, -2.28371304e-02f, -2.73486167e-01f, -1.36400372e-01f, -3.13948467e-02f, -1.47442237e-01f, -1.22578807e-01f, -4.65950146e-02f, -1.97055906e-01f, 8.19490850e-02f,
  -1.36613503e-01f, -3.16062756e-02f, 2.06121262e-02f, 9.76958051e-02f, 1.94011211e-01f, 9.60262343e-02f, 8.86320919e-02f, 1.23889223e-01f, 2.81784199e-02f, 5.63957170e-02f,
  -8.50007311e-02f, -5.34909293e-02f, 1.32026086e-02f, 3.01197506e-02f, -4.94194180e-02f, 6.79236203e-02f, 5.66919483e-02f, 5.45908585e-02f, -1.21374361e-01f, -1.17176905e-01f,
  1.24221474e-01f, 1.32283881e-01f, -7.71035701e-02f, 8.47348198e-02f, 2.80065332e-02f, -5.57368398e-02f, 1.67650148e-01f, 3.90037475e-03f, 4.70138155e-02f, -6.27187043e-02f,
  -1.33992881e-01f, -4.72721815e-01f, 7.99854323e-02f, -2.44139750e-02f, -1.83454260e-01f, -4.47688736e-02f, 1.94208454e-02f, -4.15685810e-02f, 8.09095278e-02f, -5.37411682e-03f,
  -2.63410863e-02f, -4.96714711e-02f, -3.02300155e-02f, -7.74758756e-02f, 1.38223963e-02f, 6.22277195e-03f, 1.58206761e-01f, -2.48288512e-02f, -8.54109153e-02f, -1.43180592e-02f,
  3.04024983e-02f, -1.08605146e-01f, -6.69670627e-02f, -1.09208539e-01f, 1.01824617e-02f, -1.66177839e-01f, -4.77121621e-02f, -8.24072883e-02f, -2.40373194e-01f, -9.45077837e-02f,
  4.03780371e-01f, 4.76838857e-01f, 4.77649033e-01f, 1.31338045e-01f, -5.08760335e-03f, 1.87152922e-01f, 5.01460016e-01f, 1.82602003e-01f, -3.20428088e-02f, 1.40281722e-01f,
  8.07571337e-02f, -2.22875804e-01f, -1.59209400e-01f, 3.76798585e-02f, 1.84919029e-01f, 2.48568296e-01f, 1.19017631e-01f, 5.88482469e-02f, 3.23978439e-02f, 1.16616813e-02f,
  -1.67750731e-01f, -8.46285596e-02f, 5.12170903e-02f, -6.96201324e-02f, -1.25413630e-02f, -2.14449570e-01f, 1.41302720e-02f, 7.49374330e-02f, 8.33053812e-02f, 9.11728442e-02f,
  2.58487821e-01f, 5.09296656e-01f, -2.24741817e-01f, -1.27991894e-02f, -2.85638515e-02f, -1.21564284e-01f, 9.58620384e-02f, -4.19766083e-02f, -1.30104556e-04f, 3.61196324e-02f,
  2.00945698e-02f, 6.50319606e-02f, -2.28717644e-02f, -5.74375987e-02f, 1.76016055e-02f, 7.92277697e-03f, 2.01606918e-02f, 1.59332469e-01f, 1.65543020e-01f, 1.34065241e-01f,
  -1.95566870e-04f, 4.83151376e-02f, 8.89590159e-02f, 3.96690033e-02f, 1.88589934e-02f, -1.05454586e-01f, 9.56078470e-02f, 8.85579064e-02f, 3.83259989e-02f, 1.28557697e-01f,
  -1.38492092e-01f, 1.10144772e-01f, 2.05813330e-02f, 6.98502138e-02f, -7.58159906e-02f, -9.74147543e-02f, -7.78603274e-03f, 1.45650342e-01f, 7.23024979e-02f, -6.27924800e-02f,
  -1.35952190e-01f, 4.77490053e-02f, 4.22029234e-02f, 3.07542980e-02f, -1.06095515e-01f, 1.07664816e-01f, 1.16045877e-01f, 1.54038295e-02f, 6.20748922e-02f, -7.16705201e-03f,
  1.80682037e-02f, -2.99782865e-02f, -9.75871086e-03f, 2.12584971e-03f, -2.25215126e-02f, -4.59501334e-02f, 5.58450446e-02f, -5.65434918e-02f, -1.62283376e-01f, -1.00386754e-01f,
  -2.95080692e-01f, -1.10459477e-01f, -4.37511057e-02f, 3.32506299e-02f, -8.27846825e-02f, -5.84766753e-02f, 1.08950444e-01f, -7.48546273e-02f, 3.37978378e-02f, 3.27163264e-02f,
  6.74072355e-02f, 8.91038030e-02f, 8.39920640e-02f, -3.30705754e-02f, -1.00590639e-01f, -1.35782644e-01f, -4.59800139e-02f, 1.73597038e-02f, 6.12034239e-02f, -6.37133494e-02f,
  -7.21447691e-02f, -7.12866709e-03f, -4.19304185e-02f, -7.08904788e-02f, -2.02588931e-01f, -3.20709676e-01f, -1.81246432e-03f, -6.85159713e-02f, -1.65729478e-01f, -3.57184321e-01f,
  6.00156449e-02f, -1.54750988e-01f, -1.84640035e-01f, 9.96853970e-03f, 1.89889207e-01f, -2.10902125e-01f, -4.10473585e-01f, -4.09795642e-01f, -2.79990733e-02f, 9.60351080e-02f,
  1.24469385e-01f, 2.86523491e-01f, 2.17469633e-01f, 8.34224001e-02f, -1.85540810e-01f, -1.57234043e-01f, 1.27948344e-01f, -3.96389253e-02f, -8.39520171e-02f, -1.32986177e-02f,
  3.49911779e-01f, 2.69477487e-01f, 5.81234740e-03f, -5.63081307e-03f, 1.68874443e-01f, 2.06954837e-01f, 1.05125822e-01f, 1.93331242e-01f, 8.21117908e-02f, 4.18128520e-01f,
  4.81621400e-02f, -2.31719434e-01f, -1.38176322e-01f, 1.58826131e-02f, 5.73142432e-03f, 8.64901766e-02f, 6.88046291e-02f, -6.44141436e-02f, 1.70645475e-01f, -6.52864156e-03f,
  1.93052202e-01f, 1.65263768e-02f, 8.76907632e-02f, -7.86645859e-02f, 9.11668595e-03f, 4.21211543e-03f, 2.89653111e-02f, -1.02521129e-01f, -1.57026470e-01f, -6.39385656e-02f,
  3.58830005e-01f, 1.21667273e-01f, -6.13762625e-02f, -2.49512136e-01f, -2.01061323e-01f, 5.04271947e-02f, -1.74582541e-01f, -2.20844582e-01f, -2.34587833e-01f, 6.97104726e-03f,
  7.78870052e-03f, -2.38856170e-02f, -1.04495957e-01f, -1.23546990e-02f, 1.50387809e-02f, 1.10077336e-01f, 2.62341965e-02f, -1.01958225e-02f, 4.28480171e-02f, 6.67638630e-02f,
  -5.24896383e-02f, -5.33488728e-02f, -2.32814495e-02f, -1.95526127e-02f, 2.30528682e-01f, 1.12580664e-01f, -1.06518716e-03f, 8.14231411e-02f, -9.43646058e-02f, 1.24509737e-01f,
  1.53763577e-01f, 4.64891084e-02f, 1.65135443e-01f, -5.34575693e-02f, 7.63576254e-02f, 1.01619605e-02f, 2.47961618e-02f, 6.86519966e-02f, 6.45504892e-02f, 1.51663601e-01f,
  7.41392598e-02f, -1.21633217e-01f, 5.11861891e-02f, -2.25049078e-01f, 5.13366908e-02f, 1.89351529e-01f, 6.05661422e-02f, -3.80474180e-02f, -4.92212065e-02f, -6.79982454e-02f,
  -1.53549155e-02f, -4.65500690e-02f, -6.10058047e-02f, -2.39211097e-02f, 5.99145554e-02f, 4.94835302e-02f, 2.57929228e-02f, -1.94019116e-02f, -3.21016759e-02f, 4.61410098e-02f,
  -2.07493842e-01f, -4.43230234e-02f, -1.03812031e-01f, -1.91522017e-01f, -7.39282221e-02f, -8.04121140e-03f, -1.00917974e-02f, -1.88489407e-02f, -2.27696121e-01f, -1.99990079e-01f,
  3.64724606e-01f, -5.07529914e-01f, -2.85778284e-01f, 2.92348802e-01f, -3.09863687e-01f, -1.11945421e-01f, -5.09498417e-01f, 7.76410326e-02f, 1.93265498e-01f, -3.66560519e-01f,
  -2.90277414e-02f, 3.35267276e-01f, 1.82765722e-01f, 2.56084472e-01f, 1.90109700e-01f, -3.57906848e-01f, -3.32825184e-01f, 2.74380177e-01f, 3.86316329e-01f, 1.93068877e-01f,
  -1.44197449e-01f, -1.53506426e-02f, 2.58353323e-01f, 2.99503505e-01f, -2.09659576e-01f, 4.92061563e-02f, -2.59009033e-01f, -8.31004903e-02f, -2.33068049e-01f, -5.99676192e-01f,
  -1.34195819e-01f, -3.70398052e-02f, 1.24143757e-01f, 8.34785849e-02f, -1.52163357e-01f, -7.13807344e-02f, -7.07737431e-02f, -9.53477025e-02f, -6.37087524e-02f, -3.86142917e-02f,
  2.23989300e-02f, 5.77545688e-02f, 7.96265081e-02f, 1.58972747e-03f, -7.01502189e-02f, 1.04679847e-02f, 6.85161073e-03f, 1.18207701e-01f, 4.11244109e-02f, -5.87207302e-02f,
  -1.65642098e-01f, -1.55235171e-01f, -1.20961696e-01f, -1.88811515e-02f, 6.04548268e-02f, 1.30352512e-01f, -7.68780112e-02f, -5.01138344e-02f, 2.94501018e-02f, -3.63601744e-01f,
  -3.16135027e-02f, -2.49215146e-03f, -4.81223017e-02f, -8.66629854e-02f, -1.35413622e-02f, -1.61408838e-02f, -5.79221966e-03f, 2.70120800e-02f, -5.35189454e-03f, -7.99691454e-02f,
  4.19815257e-02f, 5.78430593e-02f, -3.93861858e-03f, -3.57136391e-02f, 3.64370383e-02f, -3.95112075e-02f, 1.50139807e-02f, -1.60313267e-02f, 4.90399674e-02f, -1.72370579e-02f,
  -5.21482229e-02f, -6.35673255e-02f, -1.12450473e-01f, 3.81359160e-02f, -2.22352892e-02f, 5.47197387e-02f, 5.96174411e-02f, 1.62113160e-02f, 9.64630097e-02f, -5.77334985e-02f,
  8.66878852e-02f, 1.56591147e-01f, -4.74538915e-02f, 1.41620450e-02f, -1.21214231e-02f, -3.51329823e-03f, -3.74892913e-02f, 3.56785990e-02f, 5.93204126e-02f, -8.46143886e-02f,
  -6.13735802e-02f, 1.24884151e-01f, -5.96323870e-02f, -4.97648604e-02f, 1.00774564e-01f, 1.75298378e-03f, -4.64384034e-02f, -4.01226617e-02f, 1.20177224e-01f, -1.69690140e-02f,
  -1.02717996e-01f, -8.17332864e-02f, 1.05370553e-02f, -9.26467404e-02f, 1.51658328e-02f, 3.17454897e-02f, -2.69940030e-02f, -6.84028715e-02f, 1.06907010e-01f, -3.40751737e-01f,
  6.40476465e-01f, -2.00399254e-02f, 1.04206182e-01f, 3.50499362e-01f, -8.77665281e-02f, 9.84242335e-02f, -6.20388389e-02f, 1.00510746e-01f, 3.34637612e-01f, 2.86047101e-01f,
  2.20028102e-01f, 3.74916732e-01f, 4.00056243e-01f, 1.87218845e-01f, 2.63823688e-01f, 1.85847208e-01f, 2.29305431e-01f, 3.15280437e-01f, 2.04182774e-01f, 2.27870330e-01f,
  1.40289292e-01f, -5.62834404e-02f, 2.29643360e-01f, 1.30160302e-01f, -7.40147606e-02f, 1.14580095e-01f, -8.82965233e-03f, -6.86980560e-02f, 1.05709724e-01f, 2.49597728e-02f,
  5.39394133e-02f, 5.00720777e-02f, 1.88990712e-01f, -2.90520191e-02f, -1.37304172e-01f, 5.93585474e-03f, 1.18529722e-01f, -1.24077059e-01f, -7.59121850e-02f, 1.07615255e-02f,
  -2.14210674e-01f, -4.57524247e-02f, -1.75106198e-01f, -2.11666316e-01f, -1.86603755e-01f, -7.23842382e-02f, -9.70752239e-02f, 2.64969859e-02f, 1.89908832e-01f, 4.40195091e-02f,
  -5.70946746e-02f, -1.58271372e-01f, -2.53307987e-02f, -7.28896409e-02f, -1.33688096e-02f, 2.41326634e-02f, -1.05845265e-01f, -5.99239282e-02f, 5.33809103e-02f, -1.71963759e-02f,
  4.57838297e-01f, 1.59894302e-01f, -3.90401622e-03f, 1.17581584e-01f, 5.96241057e-02f, 2.08605137e-02f, -1.01550736e-01f, -1.30768627e-01f, 5.57893626e-02f, -1.88180611e-01f,
  2.38343943e-02f, 5.47664315e-02f, 2.56859399e-02f, 1.13207571e-01f, 2.69506089e-02f, -6.53270483e-02f, -1.69689342e-01f, -1.26171067e-01f, -8.33584592e-02f, -4.19112109e-03f,
  3.70473824e-02f, -1.16388902e-01f, -8.03704858e-02f, -1.35238618e-01f, 9.49656665e-02f, 1.05589084e-01f, -1.07454322e-03f, -5.46863563e-02f, -3.74083631e-02f, 1.03377126e-01f,
  -3.94715309e-01f, 2.28054568e-01f, 3.09320867e-01f, 1.09905399e-01f, -1.04048640e-01f, -5.18384092e-02f, 1.21120542e-01f, -7.83717930e-02f, -1.28967509e-01f, 1.95144117e-02f,
  -9.20666382e-02f, -9.54569727e-02f, -9.80066359e-02f, -1.03417106e-01f, -2.01589644e-01f, -1.40085384e-01f, -6.55074045e-02f, 1.02164283e-01f, 1.04573369e-01f, -1.42728359e-01f,
  -2.40805447e-02f, -4.48092893e-02f, 1.42531708e-01f, 1.43493161e-01f, -9.10921320e-02f, 1.50377378e-01f, -5.68153188e-02f, -4.97927070e-02f, -1.04862861e-02f, 7.30376318e-02f,
  -6.67376876e-01f, -4.91382569e-01f, -1.47056207e-01f, -1.79066688e-01f, -2.34845355e-02f, 3.23415935e-01f, -7.23342225e-02f, -4.57370691e-02f, -6.20221198e-02f, -3.73593301e-01f,
  -1.07279889e-01f, -1.20419964e-01f, -1.63679898e-01f, 2.62455028e-02f, -2.12481786e-02f, -4.17063981e-01f, -2.16623291e-01f, -1.06644891e-02f, 3.32069635e-01f, 3.75356555e-01f,
  1.58201233e-01f, 2.44355332e-02f, 1.48739576e-01f, 1.25560373e-01f, -2.77790248e-01f, -1.91538334e-02f, -2.83016741e-01f, -7.39869252e-02f, -1.50904385e-02f, -3.32452834e-01f,
  -1.44806504e-01f, -9.52917039e-02f, 2.82043248e-01f, 6.66702762e-02f, 6.00955216e-03f, 8.24221745e-02f, 6.05263337e-02f, -3.18886377e-02f, -4.17731218e-02f, 7.27564543e-02f,
  4.59659174e-02f, 4.94643003e-02f, -5.50296567e-02f, 2.81645078e-02f, 7.17034787e-02f, 7.76333436e-02f, -4.07580137e-02f, 6.57223687e-02f, -1.11179292e-01f, -6.40810579e-02f,
  5.61366379e-02f, 1.35087401e-01f, 1.31690353e-01f, 8.46963301e-02f, 1.33996084e-02f, 8.26610848e-02f, 2.33392537e-01f, 2.17313945e-01f, 1.64918020e-01f, -4.41065878e-01f,
  1.02232970e-01f, -1.96324244e-01f, 3.46351117e-02f, 6.34824261e-02f, 9.52795520e-02f, -1.10494457e-01f, 1.14993425e-02f, -1.17301876e-02f, 5.89725748e-03f, -7.60700032e-02f,
  6.31979033e-02f, -1.23838902e-01f, -3.81554887e-02f, -3.84396873e-02f, 1.94325112e-02f, 8.25629458e-02f, -1.67311821e-02f, 3.12947519e-02f, 5.17922826e-02f, 1.82364676e-02f,
  1.22086488e-01f, 2.51827657e-01f, -9.28198323e-02f, 1.34946823e-01f, -4.35591191e-02f, -1.11556865e-01f, -1.54685313e-02f, -1.80258974e-02f, -1.41511306e-01f, 3.57082151e-02f,
  -2.85107613e-01f, 1.85555115e-01f, -3.30861419e-01f, 2.03168560e-02f, 5.70978709e-02f, -1.25567592e-03f, -1.74902454e-02f, 8.27731192e-02f, -1.41429469e-01f, 6.74572736e-02f,
  1.69291109e-01f, -5.62821142e-02f, -6.02023164e-03f, -4.74059582e-02f, 1.30099118e-01f, 1.44310430e-01f, -3.45437066e-03f, 3.41510326e-02f, 7.73848146e-02f, 7.86279663e-02f,
  -3.66157182e-02f, -9.93470699e-02f, -3.37364525e-01f, -2.29289949e-01f, -2.03449175e-01f, -1.02633312e-01f, -1.16523877e-01f, -1.74063176e-01f, -2.39914402e-01f, -7.62099624e-01f,
  -2.48804584e-01f, -2.19612598e-01f, -1.04056478e-01f, -2.00055793e-01f, 2.47767493e-01f, 1.08729000e-03f, -5.87227717e-02f, -1.12664625e-01f, -1.15729883e-01f, -4.64734249e-02f,
  -2.00968571e-02f, 6.45296350e-02f, 1.54239625e-01f, 2.33305931e-01f, -3.39011028e-02f, 6.12567812e-02f, 1.42475367e-01f, 1.08033955e-01f, 7.40960333e-03f, -1.15232496e-02f,
  2.20796302e-01f, 1.10312112e-01f, 1.71756241e-02f, -1.86423715e-02f, -3.65592986e-02f, 4.76226471e-02f, 1.23303719e-02f, 1.04422487e-01f, 1.22920051e-01f, 1.98408306e-01f,
  7.42181391e-02f, -3.70757341e-01f, -3.81125472e-02f, 4.30935062e-02f, 6.23307340e-02f, -2.71079838e-01f, -1.55271545e-01f, -1.36858761e-01f, 3.72630805e-02f, -4.69202548e-02f,
  -2.62357034e-02f, 7.87842274e-02f, -3.98853980e-02f, 2.18649041e-02f, -5.66403419e-02f, 8.10143165e-03f, 4.37157154e-02f, -2.47127116e-02f, 2.74094120e-02f, -3.67730409e-02f,
  2.18657404e-01f, 2.05282629e-01f, 3.59132178e-02f, 8.06618258e-02f, -1.82898536e-01f, 1.00403525e-01f, -1.56904325e-01f, -3.97129282e-02f, -1.53872147e-01f, -1.07649520e-01f,
  1.21907219e-01f, 1.98057573e-02f, 4.02783342e-02f, -1.73602868e-02f, 5.44205382e-02f, 8.69517475e-02f, 6.20589592e-02f, 6.23582304e-02f, 3.63231599e-02f, 2.41614338e-02f,
  8.95875394e-02f, -6.88726455e-02f, 8.75759274e-02f, 1.05986618e-01f, 1.22469828e-01f, -1.04184039e-01f, -1.34799615e-01f, -3.34927700e-02f, 7.35446438e-02f, -1.02356844e-01f,
  7.57171661e-02f, 7.40064457e-02f, 2.39602048e-02f, 2.55821049e-02f, -1.33278593e-01f, -1.49140120e-01f, -2.81525373e-01f, -2.03879431e-01f, -6.01106212e-02f, 9.01239887e-02f,
  -4.26446944e-02f, 2.36856550e-01f, -1.79826930e-01f, -1.04354121e-01f, -2.95374300e-02f, 4.59614843e-02f, -9.83221307e-02f, -2.41478328e-02f, -9.21980850e-03f, -7.65479654e-02f,
  -1.66688278e-01f, -2.26658564e-02f, -8.83879885e-03f, 7.10796043e-02f, 4.32744920e-02f, -1.11937992e-01f, 2.31338859e-01f, -3.55413891e-02f, 4.28522006e-02f, 9.75881219e-02f,
  -1.15838554e-02f, -2.07631867e-02f, 1.20590841e-02f, 5.34955598e-02f, 4.21274528e-02f, -8.14335793e-02f, -9.48926955e-02f, -2.07377598e-01f, -1.99954391e-01f, -1.50557965e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.59720201e-02f, 2.27394432e-01f, 3.60875949e-02f, 6.03654422e-02f, 3.05390000e-01f, 1.85553282e-01f, 1.75049692e-01f, -1.48413837e-01f, 9.22433585e-02f, -5.72019489e-03f,
  1.73445985e-01f, 1.68475017e-01f, -9.99443233e-02f, 1.76955864e-01f, 1.16384678e-01f, 2.47257948e-01f, 1.02078073e-01f, 3.70305270e-01f, 2.00500324e-01f, 1.43095732e-01f,
  -7.08983541e-02f, 9.44300815e-02f, 2.26757392e-01f, 2.28309810e-01f, 2.60944068e-01f, 7.00426921e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.17256409e-03f, -6.33685067e-02f, 4.06543501e-02f, -3.26091237e-02f, -2.24300027e-01f, 2.02747919e-02f, 1.23414863e-02f, -7.42998123e-02f, -1.02838643e-01f, 1.12337731e-01f,
  9.30361524e-02f, 3.05940002e-01f, -1.56287327e-01f, 5.12351617e-02f, 2.17570618e-01f, -1.99945152e-01f, -1.16364054e-01f, 1.13173418e-01f, -8.83922726e-02f, 1.23461902e-01f,
  2.39719659e-01f, -9.07937735e-02f, 1.63301468e-01f, -3.10050219e-01f, -2.58912921e-01f, 1.66317448e-01f, -2.16973186e-01f, -1.74440665e-03f, 1.16692632e-01f, -3.32280472e-02f,
  -3.10288608e-01f, -6.46117404e-02f, 3.85919213e-03f, -4.11340818e-02f, 2.29567960e-02f, -1.26004919e-01f, -2.63608485e-01f, -1.63731456e-01f, 2.47596219e-01f, -2.72204369e-01f,
  1.91820055e-01f, -9.44782700e-03f, -9.64776874e-02f, -9.40027609e-02f, 7.36528486e-02f, 1.82537567e-02f, -7.02647194e-02f, 6.63612261e-02f, -6.91203866e-03f, -1.51689306e-01f,
  7.92636871e-02f, 7.06353458e-03f, 2.24399194e-01f, 1.13709077e-01f, -1.01949990e-01f, -1.09833665e-01f, -5.09720109e-02f, -2.77232349e-01f, -3.46593857e-02f, -1.88117489e-01f,
  4.40174520e-01f, 5.97245693e-02f, 2.23231599e-01f, 1.57772209e-02f, -3.64165530e-02f, -6.37863278e-02f, 6.03943458e-03f, -1.14583813e-01f, 3.91985849e-03f, -1.26621261e-01f,
  3.34093481e-01f, -2.98200380e-02f, 6.01490811e-02f, 1.22929543e-01f, 7.16979951e-02f, 6.14654757e-02f, -2.00071812e-01f, 1.79013144e-02f, -5.87931834e-02f, -1.94731161e-01f,
  -2.33832225e-01f, 5.44556379e-02f, -1.98800191e-01f, -2.09711995e-02f, 2.01214060e-01f, -1.12508863e-01f, -8.81670266e-02f, -6.44677505e-02f, -3.57317239e-01f, -3.62743326e-02f,
  7.74540231e-02f, 7.75526837e-02f, 2.60355532e-01f, 1.60759568e-01f, 3.28244746e-01f, -1.76033109e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.97313055e-01f, 3.23750242e-03f, 4.17744368e-02f, -6.37454912e-02f, 4.42736089e-01f, 5.77709526e-02f, 3.56719978e-02f, -7.79858455e-02f, -1.30053356e-01f, -1.31413147e-01f,
  1.69869348e-01f, 2.66944226e-02f, 2.97234833e-01f, -2.17143372e-01f, -1.67371314e-02f, 1.16690181e-01f, 6.93142787e-02f, 1.46377444e-01f, 2.17627406e-01f, 4.16890197e-02f,
  -3.72430325e-01f, -2.33690776e-02f, 9.47270617e-02f, 6.48636341e-01f, 3.56098175e-01f, -2.18144506e-01f, 1.23928059e-02f, -1.41872257e-01f, -4.31931406e-01f, -1.43848881e-01f,
  3.99191558e-01f, 9.47026238e-02f, 6.22979254e-02f, 1.59922361e-01f, 1.01566635e-01f, 1.52358860e-01f, 1.11736590e-02f, -6.78739510e-03f, -3.01359564e-01f, 2.92527527e-01f,
  2.47900456e-01f, 1.28439115e-02f, 2.13985473e-01f, 2.83630937e-01f, -2.74173826e-01f, 3.41698855e-01f, -1.30255610e-01f, 1.70385346e-01f, 1.54562131e-01f, 4.10076641e-02f,
  1.15294695e-01f, 2.47618899e-01f, -3.90456058e-02f, -2.51387954e-01f, 1.55788148e-02f, 2.90053040e-01f, -5.25582209e-02f, -5.69372512e-02f, 1.19467238e-02f, 2.74918228e-01f,
  1.67253852e-01f, 1.31130934e-01f, -1.80755537e-02f, 1.16699323e-01f, 1.27688006e-01f, -9.94978379e-03f, -1.13404155e-01f, -3.08922268e-02f, -9.13429335e-02f, -1.03238449e-01f,
  6.51348196e-03f, -5.35919785e-01f, -9.79631543e-02f, -3.42774838e-01f, 1.17654866e-02f, -1.26859933e-01f, 1.50695369e-01f, -3.36592823e-01f, -1.02395646e-01f, -2.67574966e-01f,
  -2.71046604e-03f, -1.86173245e-01f, 2.71588355e-01f, 2.06458896e-01f, -1.28416851e-01f, -2.11689457e-01f, 1.92491338e-01f, 1.47128195e-01f, 1.37026757e-01f, 4.22432810e-01f,
  -1.70788273e-01f, 2.87367433e-01f, 2.11869121e-01f, -1.07330166e-01f, 1.10905334e-01f, 3.94773126e-01f, -3.65698040e-02f, 1.95220187e-01f, 1.44117147e-01f, -2.25570619e-01f,
  -7.27575785e-03f, 8.88173506e-02f, 1.17510691e-01f, -5.07804453e-02f, -1.25308171e-01f, 9.00750011e-02f, 5.99054277e-01f, 4.86928791e-01f, -1.93150267e-02f, -4.34487080e-03f,
  -2.69805938e-01f, -6.44579828e-02f, 2.54425313e-02f, -1.35900810e-01f, 3.99933428e-01f, 2.15793513e-02f, 6.17539436e-02f, 3.21598589e-01f, 1.06602296e-01f, 5.76816976e-01f,
  7.10968450e-02f, -9.91649255e-02f, 1.08360298e-01f, -2.17067450e-01f, -5.44219673e-01f, 3.41568366e-02f, 1.01323994e-02f, -1.92188755e-01f, 3.12522292e-01f, 6.21522367e-01f,
  1.70239687e-01f, 5.78487098e-01f, 6.19850457e-02f, 1.30399391e-01f, -2.34656379e-01f, 3.82710338e-01f, 1.16611039e-03f, 1.76849708e-01f, 3.09950411e-01f, 2.90336400e-01f,
  -1.41041040e-01f, -2.75093496e-01f, -5.13385003e-03f, 5.66630915e-04f, 4.03270662e-01f, -1.74292158e-02f, -2.72449821e-01f, 1.17959365e-01f, 2.40228474e-02f, 3.48638564e-01f,
  1.57418981e-01f, -2.19804958e-01f, 2.93692112e-01f, -3.28228235e-01f, -2.21705407e-01f, -8.95243585e-02f, 1.31739257e-02f, -2.32175440e-02f, 8.61804634e-02f, 9.68769416e-02f,
  2.02389136e-01f, 1.77530393e-01f, 1.45164266e-01f, 7.78389648e-02f, -2.83659637e-01f, 1.59185171e-01f, -6.81863874e-02f, -6.77624717e-02f, 1.81138545e-01f, 2.05111369e-01f,
  3.22591692e-01f, 6.47671282e-01f, -5.17885797e-02f, 6.29169717e-02f, -2.21094579e-01f, -2.11338215e-02f, -3.29512984e-01f, 2.92908847e-01f, 4.33202624e-01f, 4.80720699e-02f,
  2.13264152e-01f, -6.94406107e-02f, -1.39611647e-01f, -1.83340371e-01f, 8.34811032e-02f, 2.67083347e-01f, 7.18182698e-02f, 7.64078945e-02f, -1.72738180e-01f, 3.56330216e-01f,
  -7.85379529e-01f, 5.37965335e-02f, 4.47348058e-02f, 8.05345029e-02f, 1.90441728e-01f, -3.92517867e-03f, 3.14834788e-02f, 3.51059921e-02f, 1.33217290e-01f, -3.84019703e-01f,
  -2.38516122e-01f, -1.74113289e-01f, -8.15014914e-02f, -1.59658492e-01f, 2.32187301e-01f, -4.04261053e-01f, 2.72915989e-01f, -4.85461920e-01f, -2.53929198e-01f, 1.27649829e-02f,
  3.56612690e-02f, 7.81908333e-02f, -3.46538983e-02f, -2.64898360e-01f, 2.43194029e-01f, 2.13812083e-01f, 1.49873346e-01f, 4.16029274e-01f, -4.61802520e-02f, 2.78326124e-01f,
  -3.22040588e-01f, -5.56606278e-02f, 1.06538646e-02f, 1.21684931e-01f, 3.06473911e-01f, 1.55379534e-01f, 1.81385785e-01f, 7.80546069e-02f, -2.92724401e-01f, -1.01299964e-01f,
  -2.11944550e-01f, -4.89916354e-01f, 3.18683982e-02f, -4.91686493e-01f, -5.81219792e-01f, -2.03690246e-01f, 3.99127789e-02f, 1.01510398e-01f, 3.89796138e-01f, -2.60113448e-01f,
  2.07795039e-01f, -4.20999750e-02f, -6.65706620e-02f, -1.76287875e-01f, -2.56439447e-01f, -8.81675556e-02f, 1.31726488e-01f, -2.25597724e-01f, -2.03001633e-01f, 2.48921603e-01f,
  2.99953252e-01f, 2.63160706e-01f, 1.36416769e-02f, 2.71424860e-01f, 7.77651556e-03f, 2.43102647e-02f, 3.33458126e-01f, 2.12979373e-02f, 8.37622359e-02f, 8.68763849e-02f,
  3.57440263e-01f, -3.25928330e-02f, -2.88864553e-01f, 1.37122497e-01f, -2.47590125e-01f, -4.17024381e-02f, -2.81954080e-01f, 3.58313024e-01f, 2.67250687e-01f, 1.30286753e-01f,
  -2.44828478e-01f, 9.28586628e-03f, -7.40287900e-02f, 1.78584099e-01f, 2.07345679e-01f, 3.57327402e-01f, -1.16989784e-01f, -7.29232848e-01f, 2.78572381e-01f, 4.57218289e-01f,
  2.16821253e-01f, 5.34430631e-02f, -7.56734088e-02f, 3.10698599e-01f, -3.54037464e-01f, 3.41777131e-02f, -3.48497145e-02f, 2.23849371e-01f, 3.06815743e-01f, 3.20854545e-01f,
  2.96316564e-01f, 4.84401256e-01f, -5.86627461e-02f, 2.22751915e-01f, -6.74034879e-02f, 3.83345008e-01f, 1.93615884e-01f, 3.85386556e-01f, 2.93383241e-01f, 3.52311432e-01f,
  -1.80102795e-01f, -3.05174679e-01f, -7.19177723e-02f, -3.55176590e-02f, 9.56715494e-02f, 3.02635521e-01f, -9.73661914e-02f, -1.85458325e-02f, 2.37211645e-01f, 6.36598170e-02f,
  -1.26055121e-01f, 4.71959524e-02f, 3.14508438e-01f, -7.32888877e-02f, 2.80187484e-02f, 5.96801117e-02f, -9.33590084e-02f, -1.31835580e-01f, -9.15532261e-02f, -1.38646752e-01f,
  2.33860880e-01f, 3.97547334e-01f, 1.09100364e-01f, 2.01782554e-01f, 1.93106100e-01f, -8.81717429e-02f, 4.30738300e-01f, 2.60462165e-01f, 2.32541218e-01f, 2.59107620e-01f,
  -2.86248952e-01f, -1.64713174e-01f, 3.52251291e-01f, -1.03268929e-01f, -2.05323651e-01f, -1.39764220e-01f, 1.19066052e-01f, 2.91042358e-01f, 8.72118026e-03f, 5.74727617e-02f,
  2.31571794e-02f, -1.77554693e-02f, 2.91912287e-01f, 2.58406878e-01f, 6.17795698e-02f, -2.66485345e-02f, -1.56681076e-01f, 2.17881024e-01f, 4.20069307e-01f, -1.38291903e-02f,
  6.45426571e-01f, 1.88857898e-01f, 1.14990711e-01f, -6.28534332e-02f, 5.25095640e-03f, -9.31097493e-02f, 1.11617953e-01f, -6.58062473e-02f, -5.50081395e-02f, 1.48170441e-01f,
  -2.91070968e-01f, -1.69853754e-02f, 1.31226080e-02f, 1.93401333e-02f, 1.81689933e-01f, -1.81977823e-01f, -1.89392820e-01f, 1.80110820e-02f, 1.46522954e-01f, -1.44552633e-01f,
  2.52984822e-01f, 3.06434155e-01f, -2.72482008e-01f, -4.72379804e-01f, 3.91664356e-01f, 3.08372498e-01f, 1.69302166e-01f, 2.08701700e-01f, -2.16313228e-01f, 1.23201258e-01f,
  -1.66545913e-01f, -9.35224630e-03f, 3.89468260e-02f, 1.18627317e-01f, 5.19249998e-02f, -4.19355109e-02f, 2.29717836e-01f, -2.50963628e-01f, 1.19395614e-01f, -1.08927086e-01f,
  6.28435612e-02f, -2.57892251e-01f, -2.81822264e-01f, -2.92686820e-01f, 4.68517125e-01f, 1.46817699e-01f, -1.13904066e-01f, -8.21083784e-02f, 7.65233412e-02f, 2.26904210e-02f,
  -1.51066808e-02f, -3.86461258e-01f, 2.09324867e-01f, 2.04467084e-02f, -1.23860069e-01f, 1.60789922e-01f, -1.20456688e-01f, 1.57156378e-01f, 1.22469723e-01f, 2.70257175e-01f,
  1.59638703e-01f, -2.12614372e-01f, -2.75163680e-01f, -8.69531110e-02f, 5.13474345e-02f, -3.03113414e-03f, 4.14897501e-01f, -4.27573510e-02f, 5.05928040e-01f, -2.95948479e-02f,
  3.06778222e-01f, 6.74979314e-02f, -8.09545964e-02f, -2.01314747e-01f, -1.30670592e-01f, -3.37681398e-02f, -1.23922527e-01f, -1.53589100e-01f, 1.90707266e-01f, -3.62949997e-01f,
  6.48811162e-02f, 4.99296933e-02f, 2.92389635e-02f, 2.93259360e-02f, -1.79819316e-01f, 9.59875286e-02f, -2.53052831e-01f, -7.78500214e-02f, 4.23060477e-01f, 3.60982567e-01f,
  3.06749195e-01f, 1.52053401e-01f, -9.62024406e-02f, 3.24274689e-01f, -2.83685982e-01f, -4.83725667e-02f, 1.23729430e-01f, 2.11062238e-01f, -2.02061027e-01f, -1.29903093e-01f,
  -6.93973452e-02f, 3.80934700e-02f, 1.56407863e-01f, -9.46277902e-02f, -2.22712476e-02f, -4.66432124e-01f, -2.54701406e-01f, -3.06167275e-01f, 2.35669926e-01f, 2.22442165e-01f,
  -1.28234267e-01f, -1.52201071e-01f, -6.06322624e-02f, 3.11612189e-01f, 6.70369938e-02f, -2.23908246e-01f, 2.89904982e-01f, 2.40316521e-02f, -3.49625088e-02f, 1.92323506e-01f,
  1.04651958e-01f, -5.70711754e-02f, 3.00929636e-01f, 1.09729692e-01f, -7.47719854e-02f, -6.95106834e-02f, -2.96364397e-01f, 4.73005027e-02f, 9.88903716e-02f, -7.85996392e-02f,
  1.03918776e-01f, -8.68642051e-03f, -4.63678539e-02f, 1.67396918e-01f, -1.83332026e-01f, -9.82982200e-03f, 5.49078047e-01f, 6.36546388e-02f, 4.20585543e-01f, 3.14854309e-02f,
  1.23858184e-01f, -7.06003979e-02f, 2.15387970e-01f, -2.03736395e-01f, -2.04840750e-01f, 4.83707786e-02f, -3.76771659e-01f, 3.17765564e-01f, -3.95413265e-02f, -2.01032370e-01f,
  6.09869123e-01f, 2.18641445e-01f, -2.41240069e-01f, -5.15356846e-02f, 6.45026611e-03f, 2.33405173e-01f, -1.92390323e-01f, 1.78381000e-02f, 4.55795169e-01f, 4.53578472e-01f,
  -1.11709915e-01f, 3.41573693e-02f, 4.65960860e-01f, 2.17142865e-01f, 1.38035253e-01f, 5.63871302e-02f, 8.22375938e-02f, 7.39596188e-02f, 3.43653500e-01f, 1.68956199e-03f,
  4.65102531e-02f, 7.60005414e-02f, -2.31685877e-01f, -2.66052127e-01f, 1.54375508e-01f, -2.12778628e-01f, 3.80302012e-01f, 2.90459744e-03f, 6.88879890e-03f, 7.84588326e-03f,
  1.97131392e-02f, -2.12940760e-02f, 3.23789120e-01f, 2.03464851e-01f, 1.15948550e-01f, -1.16505735e-01f, 1.07309952e-01f, 2.63456523e-01f, 2.12084558e-02f, 3.64315987e-01f,
  2.61883110e-01f, 1.51572600e-01f, 3.58969122e-01f, 2.04131067e-01f, 2.18370751e-01f, 7.26323053e-02f, 2.09450066e-01f, -3.63213092e-01f, -3.66601199e-01f, -3.59410763e-01f,
  8.28080773e-02f, -2.38372639e-01f, -2.33629391e-01f, -1.47272632e-01f, -4.93108124e-01f, -1.80827454e-01f, 1.62954077e-01f, -1.85366750e-01f, 2.71555632e-01f, -7.11901067e-03f,
  -7.03502595e-02f, -7.20452741e-02f, -4.75085229e-02f, -6.03690743e-02f, 1.41488761e-01f, 3.74531262e-02f, 3.27670455e-01f, -2.85377920e-01f, -1.50278836e-01f, 3.56677771e-01f,
  -8.04537162e-02f, 5.17852083e-02f, 2.53544658e-01f, 2.01815769e-01f, -1.12470105e-01f, -6.97032036e-03f, 1.91200823e-01f, 1.76711157e-01f, 5.48502088e-01f, -1.56523511e-02f,
  -3.52264076e-01f, -1.54630706e-01f, -3.37067842e-01f, -4.56876099e-01f, -2.48552650e-01f, -4.23785508e-01f, -3.47428888e-01f, -2.32900649e-01f, 6.83182850e-02f, -1.95489854e-01f,
  5.61009586e-01f, -3.02525938e-01f, 2.87537307e-01f, -3.29252303e-01f, 9.03212279e-02f, 1.01800278e-01f, -1.93954423e-01f, 2.14881256e-01f, 1.24014318e-01f, 1.39354467e-01f,
  -1.41467690e-01f, -2.68096663e-02f, 1.83374416e-02f, 2.11688112e-02f, 1.91317752e-01f, -8.64775553e-02f, 1.46199182e-01f, 4.43836242e-01f, 3.37867737e-01f, 2.65578479e-01f,
  9.71546471e-02f, 2.34428778e-01f, -5.06254211e-02f, 7.61052668e-02f, 2.92147130e-01f, 4.45782781e-01f, 9.74367931e-02f, 1.00830831e-01f, -4.48537141e-01f, -1.58542190e-02f,
  -4.08964306e-01f, -1.08717941e-01f, -3.26370262e-02f, -6.97548762e-02f, 4.44396257e-01f, 2.97762096e-01f, -3.14283371e-01f, 3.73427540e-01f, 2.06707880e-01f, -8.58004317e-02f,
  1.08392313e-02f, 1.98236197e-01f, -1.23410396e-01f, -3.56611401e-01f, -4.14091408e-01f, -5.38339689e-02f, 5.91251016e-01f, 2.38486618e-01f, 4.16797996e-01f, 1.31662086e-01f,
  -4.03166443e-01f, 1.89325504e-03f, -4.08204980e-02f, -2.13978559e-01f, -1.92455426e-02f, -3.83737795e-02f, 1.07308999e-01f, -3.24941635e-01f, -1.18502099e-02f, -2.97223389e-01f,
  5.90305924e-01f, 3.88265327e-02f, -1.93380609e-01f, 3.39319557e-01f, 5.37566803e-02f, 3.13764252e-02f, 1.89876750e-01f, -4.26946968e-01f, -1.81217626e-01f, -6.86850920e-02f,
  -1.83603495e-01f, 2.81351894e-01f, -2.37419978e-02f, -1.32501364e-01f, -1.11262895e-01f, 7.08424076e-02f, -5.14550917e-02f, -6.22113794e-02f, -9.26665217e-02f, -1.23278268e-01f,
  8.76701064e-03f, -2.02524200e-01f, 1.99518621e-01f, -8.08033422e-02f, -8.30124244e-02f, -2.44872123e-01f, 4.70440499e-02f, -4.75877002e-02f, -3.52278650e-01f, -5.34812808e-01f,
  -1.27088949e-01f, -3.00640404e-01f, 1.09902648e-02f, -5.14189620e-03f, 1.69042781e-01f, 4.30767909e-02f, 2.26839662e-01f, 1.12913929e-01f, 2.41301373e-01f, -2.07622617e-01f,
  3.06424767e-01f, -6.28134981e-02f, 1.87314749e-01f, 1.40659645e-01f, 8.43722224e-02f, 2.46819615e-01f, -3.96130718e-02f, 1.47801995e-01f, 5.69958016e-02f, -2.70232577e-02f,
  2.04479337e-01f, 4.14289653e-01f, -9.49838832e-02f, -2.92497128e-02f, 1.86207816e-01f, 1.40571624e-01f, 5.53494580e-02f, 7.67660141e-02f, 4.79172677e-01f, -2.81329423e-01f,
  4.19786833e-02f, 4.37180221e-01f, -3.19702953e-01f, 2.92824566e-01f, -5.38434565e-01f, -4.71069552e-02f, 3.67929518e-01f, -6.88121468e-02f, -1.50458053e-01f, -5.69448955e-02f,
  2.64641196e-01f, 1.83008555e-02f, -1.83141187e-01f, 2.16074407e-01f, -5.22191048e-01f, -4.09105361e-01f, 1.17650740e-01f, 1.01405539e-01f, 2.35060036e-01f, 2.40107789e-03f,
  -4.67010528e-01f, 3.72022063e-01f, 6.54746965e-02f, -7.45295212e-02f, 3.13824087e-01f, 2.11081833e-01f, 8.63630176e-02f, 4.23891842e-01f, 1.49275675e-01f, -1.32056594e-01f,
  -2.79538542e-01f, 3.81034374e-01f, 1.78834125e-01f, 1.01260133e-01f, 1.49642959e-01f, 3.48555557e-02f, 7.49540865e-01f, 4.55144167e-01f, 3.31442840e-02f, 9.51047167e-02f,
  -5.37522212e-02f, -4.52953666e-01f, -1.78062335e-01f, 2.30411768e-01f, -1.31375879e-01f, -7.16787130e-02f, 3.32701176e-01f, -7.67205954e-02f, -7.48482824e-04f, -3.13803494e-01f,
  2.65232444e-01f, 1.37631625e-01f, -3.49234492e-01f, 5.47534265e-02f, -3.06208313e-01f, -9.42094699e-02f, -3.49475026e-01f, 4.57610562e-02f, 1.77390039e-01f, 6.43627122e-02f,
  2.58741528e-01f, -1.42783970e-01f, 4.32441622e-01f, 3.97367962e-03f, -5.57737015e-02f, 1.49048837e-02f, -4.04223621e-01f, -5.95125109e-02f, 1.77628264e-01f, -8.32965598e-02f,
  2.73219794e-01f, -3.74053866e-01f, 4.53623645e-02f, 1.88649163e-01f, -9.30278152e-02f, 1.41355217e-01f, -2.47219726e-02f, 2.41689399e-01f, -4.80647922e-01f, 2.64280587e-01f,
  1.73391789e-01f, 3.91136616e-01f, 3.98241699e-01f, 3.35064940e-02f, 2.89037406e-01f, -1.75981030e-01f, -1.97190583e-01f, -3.18760276e-01f, 8.95480514e-02f, 1.91359311e-01f,
  1.46340474e-01f, 1.93559855e-01f, 3.28057230e-01f, -2.79291987e-01f, -3.11129063e-01f, -1.68731421e-01f, 4.29783195e-01f, -1.84521616e-01f, 1.28273875e-01f, 1.30599225e-02f,
  -1.40479699e-01f, -2.75413394e-01f, 2.76775032e-01f, 4.77182493e-02f, 1.56335294e-01f, 3.57169449e-01f, -1.04050457e-01f, 1.15919299e-01f, -2.62055159e-01f, 1.01018310e-01f,
  3.35485727e-01f, 4.09598529e-01f, -2.64449656e-01f, -5.05125597e-02f, 1.57775395e-02f, -2.55856365e-01f, 3.47566068e-01f, -3.78867596e-01f, 6.56117797e-01f, 5.17245196e-02f,
  4.23849910e-01f, 1.63598813e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.08370325e-03f, 7.18884021e-02f, 3.30193192e-01f, 1.73672572e-01f, 5.36542356e-01f, 1.37884468e-01f, 2.04159275e-01f, 2.54464835e-01f, -3.24324667e-02f, 3.08319360e-01f,
  3.69266778e-01f, 1.59199178e-01f, 1.80239081e-01f, 1.61297649e-01f, 1.17926687e-01f, 6.78974437e-03f, 5.09064317e-01f, 1.27916217e-01f, 3.95389378e-01f, 2.24109754e-01f,
  -1.30656719e-01f, 1.66063104e-02f, 4.11626577e-01f, 4.01362330e-01f, -4.63969447e-03f, 2.63553590e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.55899480e-01f, 6.10863082e-02f, 2.14956164e-01f, 1.35596365e-01f, -1.25479117e-01f, 8.22616518e-02f, -3.40784639e-01f, 3.08210164e-01f, -1.77298859e-01f, -3.36620182e-01f,
  5.34990802e-02f, 9.83311385e-02f, -2.11012647e-01f, 1.83026314e-01f, -2.76888847e-01f, 5.26985899e-02f, -3.25192362e-02f, 1.58363953e-02f, -1.92296132e-02f, -5.33110462e-02f,
  -1.98967949e-01f, -7.54304454e-02f, -6.52009770e-02f, -7.54969544e-04f, 4.21415716e-02f, 2.26292044e-01f, -1.35708293e-02f, 1.10752471e-01f, -2.54366487e-01f, -3.89748276e-03f,
  -1.39606729e-01f, 1.24405451e-01f, -1.62247956e-01f, -2.23340809e-01f, -5.98971806e-02f, 9.85228345e-02f, -7.95679465e-02f, -5.76520525e-02f, -9.17264745e-02f, 3.33158106e-01f,
  1.82403903e-02f, -1.06754877e-01f, -1.50844390e-02f, 5.18942485e-03f, 2.23069131e-01f, -6.21020123e-02f, 2.30361477e-01f, 1.45022854e-01f, 1.14761204e-01f, 7.93102011e-02f,
  -2.17915833e-01f, 1.84316620e-01f, -7.74548575e-02f, -1.05221719e-01f, -8.65622386e-02f, -1.18908569e-01f, -1.98295459e-01f, -8.37658644e-02f, 1.27179161e-01f, 2.03200653e-02f,
  2.07685307e-01f, 2.15181969e-02f, -1.06720716e-01f, 7.91009218e-02f, 7.62732176e-04f, 2.14571096e-02f, -8.48500282e-02f, -1.65558338e-01f, -3.07982355e-01f, -3.35529186e-02f,
  -1.60900485e-02f, -1.35701835e-01f, 2.11514235e-01f, 8.17250982e-02f, -2.37445861e-01f, -5.96839041e-02f, 3.35630834e-01f, -5.86826205e-02f, 1.20595254e-01f, -1.29072666e-01f,
  -1.11892745e-01f, 2.28419453e-02f, 2.81181894e-02f, -4.38515916e-02f, 7.47406036e-02f, 1.81658283e-01f, 9.63797495e-02f, 2.24151656e-01f, -2.25572288e-02f, -3.28152962e-02f,
  1.23281948e-01f, -1.93629041e-01f, 5.31775057e-02f, 1.76291332e-01f, -2.48658523e-01f, -2.33665049e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.28994003e-01f, -8.77128839e-02f, 7.99584985e-02f, -6.22326434e-02f, 1.88027501e-01f, -2.11816672e-02f, 1.07545920e-01f, 1.11523354e-02f, 1.86073452e-01f, -3.00505366e-02f,
  -5.15559375e-01f, 5.51063791e-02f, 5.64994156e-01f, 3.45335513e-01f, 3.70057166e-01f, -3.71641725e-01f, 4.02144110e-03f, 1.42235503e-01f, 6.48046806e-02f, 4.44716867e-03f,
  -5.98001927e-02f, -1.44414185e-02f, 1.68862730e-01f, 6.31719157e-02f, -2.03032121e-02f, -5.42209208e-01f, -1.97881058e-01f, 9.40751210e-02f, 3.01210731e-01f, -1.66206528e-02f,
  -2.05484495e-01f, -1.05465628e-01f, 7.47253418e-01f, 6.01452410e-01f, 9.10814166e-01f, -2.91550070e-01f, 2.81571656e-01f, -2.10671127e-01f, -3.24257642e-01f, 1.07854865e-01f,
  -6.54028952e-02f, -5.39365888e-01f, -4.84680943e-02f, 3.49469446e-02f, 1.91359207e-01f, 3.28580141e-01f, 1.15387179e-01f, 2.70844419e-02f, 7.25725852e-03f, 2.62815148e-01f,
  -4.17418152e-01f, 3.24718565e-01f, -3.76965433e-01f, 1.52781844e-01f, 1.47131681e-02f, 4.26331192e-01f, 3.76044400e-02f, -8.75094980e-02f, 4.86597568e-02f, 1.56037375e-01f,
  1.31166399e-01f, 1.16053946e-01f, -2.18514875e-01f, -1.16052710e-01f, 1.55905873e-01f, 4.00186956e-01f, 5.71913362e-01f, -5.78803234e-02f, -1.46434724e-03f, -3.20692748e-01f,
  -1.20857917e-01f, -3.64611268e-01f, 1.14226319e-01f, -2.82357603e-01f, -8.96995068e-02f, -2.71107376e-01f, 2.59992808e-01f, 3.11682165e-01f, 2.43549883e-01f, -1.14198616e-02f,
  3.15125883e-01f, 1.39419705e-01f, 5.84074184e-02f, 3.28288376e-01f, -1.32421851e-01f, -3.60803992e-01f, 1.20407470e-01f, 2.50458688e-01f, 3.69227767e-01f, -3.13473605e-02f,
  -2.41458550e-01f, -1.02404147e-01f, 3.21962506e-01f, -2.79014021e-01f, 2.42677465e-01f, 1.12962887e-01f, -4.95460182e-01f, -2.71450222e-01f, -6.60800040e-01f, -1.60978958e-01f,
  4.70860034e-01f, -5.10838144e-02f, 2.27924123e-01f, -1.33399799e-01f, 2.23250538e-01f, 3.78149487e-02f, -8.72006342e-02f, -3.83280575e-01f, 6.13677315e-02f, -1.64690971e-01f,
  5.36282510e-02f, -3.88134681e-02f, 3.25884104e-01f, -2.12761620e-03f, 1.47955269e-01f, 2.83030212e-01f, 3.86277251e-02f, 3.81547123e-01f, 9.85059366e-02f, -8.50357860e-02f,
  1.32041037e-01f, 1.44836769e-01f, -9.73263290e-03f, -3.91988195e-02f, -1.53963059e-01f, -1.04220934e-01f, 4.88397211e-01f, 3.47764283e-01f, 9.25712585e-02f, 5.53708434e-01f,
  3.24801445e-01f, 2.01099932e-01f, -5.90672433e-01f, 1.16212726e-01f, -1.21345229e-01f, 7.38618597e-02f, -7.99656749e-01f, 1.42670110e-01f, 4.64160740e-01f, 4.23006833e-01f,
  -4.72329259e-01f, -6.87230706e-01f, 9.45658982e-02f, 2.11148053e-01f, 1.18572094e-01f, -9.97301489e-02f, -1.56965349e-02f, -7.16188923e-02f, -3.19358975e-01f, 9.71447825e-02f,
  -1.38307447e-02f, -6.31922603e-01f, -4.58639681e-01f, 8.09073895e-02f, -6.70065463e-01f, -6.28401279e-01f, 1.81258887e-01f, 1.05124690e-01f, -2.53804743e-01f, -4.84577030e-01f,
  4.30707365e-01f, 4.53778267e-01f, 2.54904360e-01f, 1.59797492e-03f, 3.76596779e-01f, 2.30137706e-01f, -5.30928791e-01f, -1.10265471e-01f, -5.37321389e-01f, -2.26553246e-01f,
  2.04958767e-01f, 2.00512901e-01f, -1.75229669e-01f, -3.16621363e-01f, -4.99950647e-01f, 1.84088528e-01f, 2.78695911e-01f, -3.40189636e-01f, -5.57980478e-01f, -3.09145093e-01f,
  -3.11309874e-01f, 5.42474806e-01f, 2.97626257e-01f, -3.10048252e-01f, -5.02426028e-01f, 2.56155580e-01f, -5.03502786e-01f, -2.23200545e-01f, -9.96850580e-02f, 3.24726701e-01f,
  -2.53800333e-01f, 2.01227337e-01f, -1.91980243e-01f, -2.93415844e-01f, -1.59932941e-01f, -2.59328157e-01f, 1.10940330e-01f, 7.83518329e-02f, 2.62119561e-01f, 8.97856951e-02f,
  -5.74683361e-02f, 1.91314101e-01f, -5.82350157e-02f, 3.22766125e-01f, -5.03681451e-02f, 4.78504300e-02f, -2.27586225e-01f, -3.27005565e-01f, -2.49398023e-01f, 2.31846832e-02f,
  2.53079832e-01f, -1.26814052e-01f, 4.86649871e-01f, 1.46792993e-01f, -6.28024265e-02f, 2.87161946e-01f, 2.85155505e-01f, -1.64517984e-01f, 1.59110621e-01f, 3.64588231e-01f,
  -2.38992304e-01f, -4.45419438e-02f, 2.36819789e-01f, -4.03248752e-03f, 2.67691344e-01f, 4.99801695e-01f, 4.04441744e-01f, -1.41266093e-01f, 1.07244954e-01f, -4.73925680e-01f,
  -2.01237276e-01f, -2.65467465e-01f, 1.66427359e-01f, -4.28848654e-01f, 1.08857945e-01f, -1.91499174e-01f, 2.52457738e-01f, 4.88464773e-01f, -2.36694932e-01f, -2.64351517e-01f,
  9.37628374e-02f, -1.70218050e-01f, -8.11433569e-02f, 2.82193601e-01f, 5.77946240e-03f, -3.71916682e-01f, 4.07242715e-01f, 3.38256657e-01f, 5.31961143e-01f, -6.93558455e-02f,
  1.01019032e-01f, 4.69686873e-02f, -9.33643058e-02f, -2.62462407e-01f, 5.19898050e-02f, 1.44856438e-01f, 7.59972855e-02f, 2.78916694e-02f, 2.04411875e-02f, -3.55433315e-01f,
  4.00472432e-01f, -4.85566735e-01f, 3.34961861e-01f, 7.41392598e-02f, 2.98765421e-01f, 9.10469219e-02f, -2.08298758e-01f, 1.04072951e-01f, 3.83002847e-01f, -1.01176947e-02f,
  2.60858089e-01f, -2.15220498e-03f, -5.87851219e-02f, 7.73930550e-02f, -9.52859074e-02f, 1.99796647e-01f, 2.81200528e-01f, -3.55938822e-02f, 9.66000855e-02f, 1.46174982e-01f,
  -1.67687312e-01f, -1.40212834e-01f, -1.82452068e-01f, 2.29917243e-01f, 2.04745591e-01f, -2.64772385e-01f, 2.13683143e-01f, -2.45828792e-01f, 3.99330705e-02f, 5.81231892e-01f,
  3.52137357e-01f, 2.72846103e-01f, -3.98625910e-01f, 1.23142242e-01f, -3.03316563e-01f, 1.00030592e-02f, -5.95256269e-01f, 4.77997437e-02f, 2.99218506e-01f, 1.27048254e-01f,
  -4.00211602e-01f, -2.57470399e-01f, -2.95009881e-01f, 3.34492713e-01f, 2.47870069e-02f, -2.80421138e-01f, 9.72466096e-02f, -7.15635791e-02f, -1.77256256e-01f, 1.39710642e-02f,
  6.58922791e-02f, -6.48497403e-01f, -3.59708816e-01f, -1.08523615e-01f, 7.03826845e-02f, -1.29502326e-01f, 2.47081853e-02f, 3.03487629e-01f, -2.38896087e-01f, -2.33675286e-01f,
  -1.74846813e-01f, 2.99568266e-01f, 2.08829731e-01f, -7.20665336e-01f, 7.34029189e-02f, -1.26260012e-01f, 4.89317596e-01f, 5.75583093e-02f, -3.03559780e-01f, -3.20790000e-02f,
  3.68574291e-01f, -4.49041814e-01f, -4.39539611e-01f, -2.92074382e-01f, -6.12499118e-02f, -2.18175203e-02f, 3.16484898e-01f, -5.43726906e-02f, 2.69449819e-02f, 2.34924611e-02f,
  1.16690204e-01f, -2.50798583e-01f, 1.18409216e-01f, -1.98648442e-02f, 1.30230308e-01f, 2.81618923e-01f, -2.98944898e-02f, -1.24618486e-01f, 3.87788951e-01f, -3.28837395e-01f,
  4.87486184e-01f, 3.26554090e-01f, 2.12079704e-01f, 3.44954312e-01f, 2.44704545e-01f, -5.73166311e-01f, -4.57017213e-01f, -2.24543720e-01f, -9.93389115e-02f, 1.01659849e-01f,
  -4.02010143e-01f, -2.10094318e-01f, 2.91178115e-02f, -6.43054008e-01f, 2.89547071e-03f, -3.10968935e-01f, -1.08923919e-01f, 1.27248511e-01f, 1.92596316e-01f, 4.78869975e-02f,
  2.86813080e-01f, -2.07943376e-03f, -2.09069744e-01f, -2.08024710e-01f, 2.56935567e-01f, -3.38592082e-01f, 1.17261797e-01f, 2.13308573e-01f, -1.26896232e-01f, -1.17267288e-01f,
  3.86025757e-01f, -3.65797698e-01f, 8.60675722e-02f, -2.43238777e-01f, 3.95888805e-01f, 1.62108868e-01f, 4.85085011e-01f, -2.77283221e-01f, -2.33578533e-01f, -1.08115718e-01f,
  -2.11509511e-01f, -9.86981690e-02f, 3.10755730e-01f, -6.20401263e-01f, 3.54566187e-01f, -4.77767438e-01f, 2.44898647e-01f, 4.31871742e-01f, -2.82535851e-01f, 1.53116912e-01f,
  9.21301618e-02f, 2.16378383e-02f, 5.18255122e-02f, 1.47972271e-01f, -2.89913863e-01f, -3.85171711e-01f, 1.86118297e-02f, 3.06424499e-02f, 4.87942845e-01f, 1.79706350e-01f,
  -2.40253687e-01f, -8.45139846e-02f, 3.40543330e-01f, -3.51892620e-01f, 8.36706609e-02f, 3.85563783e-02f, -2.13642731e-01f, -2.16972083e-01f, -4.36485946e-01f, 2.43217237e-02f,
  -1.23760067e-01f, 4.46755946e-01f, 3.39229405e-02f, 1.20387755e-01f, 2.31113106e-01f, 3.85387033e-01f, -2.16593727e-01f, 1.18523590e-01f, 2.74636060e-01f, 1.44965231e-01f,
  -2.05796398e-03f, -1.46402419e-01f, -1.87965184e-01f, 1.50813222e-01f, 2.52092719e-01f, 1.33724362e-01f, 3.43303978e-01f, -2.22255483e-01f, 1.44892186e-01f, 8.43668506e-02f,
  8.55530202e-02f, -3.77778888e-01f, -9.54486951e-02f, 2.15615690e-01f, -3.84105027e-01f, 7.41778761e-02f, -5.13876900e-02f, 1.85429260e-01f, -2.34754652e-01f, -7.57803693e-02f,
  -2.11102590e-01f, -2.72634953e-01f, 3.00614890e-02f, -2.53425270e-01f, 2.25460038e-01f, -1.79779500e-01f, 5.96718252e-01f, -5.88708296e-02f, -1.06742062e-01f, 2.71661971e-02f,
  3.42565775e-01f, -2.04337060e-01f, 3.79358321e-01f, 8.01972821e-02f, 1.55094907e-01f, 4.23332483e-01f, 2.31550392e-02f, 6.72082901e-02f, 8.93015489e-02f, -9.11356509e-02f,
  1.14653781e-01f, -2.47309776e-03f, 5.40300794e-02f, 2.03556865e-01f, -1.85605615e-01f, -9.76153538e-02f, 1.88190378e-02f, -1.17003925e-01f, 1.52817726e-01f, -4.50275928e-01f,
  -2.10313443e-02f, -2.05482423e-01f, -1.17843762e-01f, -3.81814152e-01f, 4.58656639e-01f, 7.38041848e-02f, 1.57115787e-01f, 1.18221484e-01f, 1.49169108e-02f, -2.66675144e-01f,
  1.10118523e-01f, -4.02638800e-02f, -3.35418522e-01f, -3.48224826e-02f, 7.68844187e-02f, 1.84409454e-01f, 3.02079111e-01f, -2.64116912e-03f, -3.33329231e-01f, 3.54834944e-02f,
  8.80871564e-02f, 4.27893043e-01f, 1.50364339e-01f, -4.96947914e-02f, -8.60861912e-02f, 4.65106785e-01f, 6.20571934e-02f, -5.51484376e-02f, 1.58729330e-01f, -6.86607659e-02f,
  -1.31548136e-01f, 4.96811360e-01f, 1.99331596e-01f, 3.38812172e-01f, 3.52538764e-01f, -3.79228532e-01f, -3.43365431e-01f, -7.42500499e-02f, 1.43958166e-01f, 1.68892026e-01f,
  2.29631841e-01f, 1.81098916e-02f, 2.08020344e-01f, 1.52054831e-01f, 1.70678571e-01f, 3.10425293e-02f, 6.03849769e-01f, -1.05001656e-02f, 3.05419147e-01f, 4.06458139e-01f,
  1.23094143e-02f, 3.55960310e-01f, 1.48363772e-03f, -4.48711514e-02f, 6.17450662e-03f, -2.08659144e-03f, -2.04825640e-01f, 2.23771676e-01f, -2.66035825e-01f, -1.02673784e-01f,
  2.19483152e-01f, 6.37406483e-02f, 1.85433283e-01f, -5.31459510e-01f, 3.23174059e-01f, 8.76399875e-03f, 1.42476842e-01f, -5.72279133e-02f, 1.01862229e-01f, -7.75039867e-02f,
  1.34519652e-01f, 4.05284911e-01f, 6.77171396e-03f, -1.92864925e-01f, 2.14250281e-01f, 1.22353166e-01f, -2.55623788e-01f, -7.42772222e-02f, 3.54641736e-01f, 4.17124152e-01f,
  4.19997394e-01f, 3.76654267e-01f, -3.42561662e-01f, 4.33477946e-02f, -2.68232346e-01f, 2.77221173e-01f, 6.70777336e-02f, 3.51402462e-02f, 1.09426439e-01f, 4.95110691e-01f,
  -3.50720018e-01f, 8.26318562e-03f, 4.45523232e-01f, 1.20893717e-01f, -2.31040835e-01f, -1.88758776e-01f, 2.61596560e-01f, 6.78701373e-03f, -5.28478444e-01f, 8.98227990e-02f,
  6.80095434e-01f, 2.40450829e-01f, -7.44463280e-02f, -2.45141946e-02f, -1.63828582e-01f, -5.28597273e-02f, 8.13400745e-02f, -6.21068478e-02f, -4.98922020e-01f, -2.70928264e-01f,
  -4.42988157e-01f, 3.36336792e-02f, 2.40303665e-01f, 4.24404107e-02f, -1.02508105e-01f, -2.10889027e-01f, -7.90165141e-02f, 5.02983332e-01f, 3.03636789e-01f, 5.42600676e-02f,
  -5.47590017e-01f, 1.44092187e-01f, -2.90914655e-01f, 2.17778638e-01f, -1.00461826e-01f, 1.88444197e-01f, -4.38971400e-01f, 3.77429396e-01f, -4.54261759e-03f, 1.50238559e-01f,
  3.54992747e-01f, -2.35660553e-01f, -4.41783875e-01f, -3.49941105e-02f, 2.18314260e-01f, 3.11964929e-01f, 2.48851463e-01f, 1.27871102e-02f, 3.10870677e-01f, -2.08905968e-03f,
  -7.16055483e-02f, -4.29725535e-02f, 3.25424314e-01f, 1.51767433e-01f, 2.47855484e-01f, 1.62101448e-01f, -1.36780292e-01f, -9.45486948e-02f, -3.21342200e-01f, -1.32064030e-01f,
  1.57005057e-01f, -7.63829276e-02f, 2.43262649e-01f, 3.69945854e-01f, -5.76112986e-01f, -3.84577096e-01f, 4.14828032e-01f, 1.38313696e-01f, 7.08642155e-02f, -3.24367285e-01f,
  2.47694224e-01f, 2.26305425e-01f, 4.22220320e-01f, -1.97531302e-02f, 6.03449106e-01f, 9.57137067e-03f, -1.44428149e-01f, -3.96074384e-01f, -2.30115622e-01f, 2.03783840e-01f,
  -5.15280701e-02f, 7.00506493e-02f, -1.67122573e-01f, 2.07471728e-01f, -7.07605898e-01f, 2.47497171e-01f, 1.71136409e-01f, 1.05533324e-01f, 2.07142234e-01f, 8.94374773e-03f,
  1.81402136e-02f, 4.29762065e-01f, 3.73939127e-01f, 2.87751168e-01f, 2.74386436e-01f, 9.97807607e-02f, -3.33152473e-01f, 1.17922872e-01f, 2.28879992e-02f, 1.92296594e-01f,
  -1.50480658e-01f, 2.28048280e-01f, -3.33396643e-02f, 1.64244264e-01f, 9.20245349e-02f, -1.62638575e-01f, 2.93845125e-02f, 7.19581451e-03f, 1.79792121e-02f, -1.36896700e-01f,
  4.89535749e-01f, -7.20629469e-02f, 5.01401722e-02f, -4.45089310e-01f, 2.34335572e-01f, 9.44738612e-02f, 1.34106487e-01f, -1.40762394e-02f, 3.50288481e-01f, 2.10733056e-01f,
  1.63818300e-01f, 1.12471491e-01f, 5.89147769e-02f, -1.31084651e-01f, 7.11354837e-02f, 6.11506552e-02f, 3.46900254e-01f, 1.91521138e-01f, -2.69624501e-01f, -1.34131834e-01f,
  2.73795038e-01f, -2.75411099e-01f, -4.30772193e-02f, -3.47891033e-01f, -4.35682535e-01f, 4.40925471e-02f, 1.25381825e-02f, -1.18353859e-01f, 1.10942118e-01f, -9.88554731e-02f,
  4.19925541e-01f, -1.65293977e-01f, 1.91441681e-02f, 3.63492697e-01f, -1.62638724e-02f, -2.46745706e-01f, 1.31777987e-01f, 1.05023667e-01f, 3.42969388e-01f, 1.82260200e-01f,
  1.96969911e-01f, 2.67165780e-01f, 3.20951462e-01f, 2.23249808e-01f, 7.87118301e-02f, -2.12177224e-02f, -9.74433869e-03f, 2.53782630e-01f, 1.12854317e-02f, -2.15229958e-01f,
  -1.93891555e-01f, 9.60329026e-02f, -1.02950819e-01f, -3.32984358e-01f, 2.84051657e-01f, 3.67389806e-02f, 8.70992197e-04f, 2.68978029e-01f, 1.51540199e-02f, -1.91726446e-01f,
  1.33452654e-01f, -4.30775732e-01f, 1.14165850e-01f, -4.62212503e-01f, 8.40909258e-02f, -1.99573673e-02f, -1.39309391e-01f, -1.75689653e-01f, 3.59188884e-01f, 5.54526225e-02f,
  -1.30661353e-01f, -1.58407643e-01f, 4.40176129e-02f, 1.44955128e-01f, 1.76748946e-01f, 1.67818680e-01f, 1.89864084e-01f, -9.03118402e-02f, 1.30490139e-01f, 1.17157139e-01f,
  3.30468208e-01f, -5.90595067e-01f, -1.19312130e-01f, -3.71454507e-02f, -3.10248621e-02f, -2.37897843e-01f, 4.30016905e-01f, -4.35919128e-02f, 4.00646091e-01f, 4.62547243e-01f,
  2.84262180e-01f, 4.69714493e-01f, 1.79840982e-01f, 4.20727849e-01f, 9.35477614e-02f, 8.79330263e-02f, -3.32381368e-01f, 3.72417957e-01f, 3.44600827e-01f, -3.68396826e-02f,
  -2.24443555e-01f, -5.10158122e-01f, -3.51367623e-01f, 2.20336974e-01f, -2.99958616e-01f, 2.69984063e-02f, 3.81716073e-01f, 1.28277484e-02f, 9.08629131e-03f, 1.53445676e-02f,
  -1.19190477e-01f, -1.69488132e-01f, -2.99833119e-01f, -2.54446864e-01f, 1.90055788e-01f, -1.24008030e-01f, -1.31914809e-01f, 5.84950805e-01f, 1.43935084e-01f, -8.28063637e-02f,
  2.02719674e-01f, 7.36386836e-01f, 7.79877782e-01f, 3.75172883e-01f, -4.03789401e-01f, 1.84065685e-01f, -2.27421578e-02f, 6.55959696e-02f, -2.64794439e-01f, 3.63265783e-01f,
  3.29046726e-01f, 2.32498989e-01f, 4.93092649e-02f, -4.39513363e-02f, 1.35107204e-01f, 2.55190641e-01f, -1.46765590e-01f, -2.20467504e-02f, 1.09983748e-03f, 1.87546119e-01f,
  1.03743628e-01f, -3.24709862e-02f, -2.84059886e-02f, -2.52004862e-01f, -4.77786183e-01f, -6.49120286e-02f, 1.08968325e-01f, -1.37176767e-01f, -1.35231540e-02f, 4.98316646e-01f,
  -1.96689397e-01f, -2.66631633e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.25840451e-02f, 3.27659428e-01f, 1.62213892e-01f, 5.51917627e-02f, 2.43268102e-01f, 3.51204097e-01f, 2.43462309e-01f, 4.65632409e-01f, 1.41408041e-01f, 3.52540165e-01f,
  2.60886818e-01f, 1.87109351e-01f, 3.17598969e-01f, -1.19175240e-01f, -4.08532247e-02f, 2.65432894e-01f, 1.56057775e-01f, 2.38825589e-01f, -6.67335987e-02f, 2.59189636e-01f,
  4.58829969e-01f, 1.36715723e-02f, 7.55019486e-02f, 3.76647800e-01f, 6.81548417e-02f, 2.80982465e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.32084608e-01f, -3.05916425e-02f, -1.66243955e-01f, 2.49139130e-01f, 3.05453092e-01f, -5.56106418e-02f, 4.40682173e-02f, -3.07210296e-01f, 3.83259216e-03f, 5.66846319e-03f,
  9.39318910e-02f, -1.49240628e-01f, 5.90329096e-02f, 1.32372722e-01f, 1.61200494e-01f, -5.86064830e-02f, -1.90483719e-01f, -7.44400024e-02f, 1.47636801e-01f, -3.62001993e-02f,
  3.29146953e-03f, -1.86355770e-01f, -1.30247027e-01f, -1.00969017e-01f, -4.33676727e-02f, 1.64846480e-01f, -3.08669489e-02f, 2.17091516e-01f, 1.18628312e-02f, 2.58626968e-01f,
  1.45339176e-01f, 1.91412896e-01f, 5.34157641e-02f, -3.09145153e-01f, -2.23674595e-01f, 2.48330534e-01f, -2.89800227e-01f, -2.15852633e-01f, -1.48573339e-01f, -8.21642503e-02f,
  -5.54342009e-03f, 2.04630703e-01f, -8.46210420e-02f, 3.39944698e-02f, -8.56353343e-02f, 1.47092804e-01f, -1.45759121e-01f, 1.29936278e-01f, 8.76647979e-02f, 1.78393424e-02f,
  1.42250717e-01f, -7.43106976e-02f, -1.00021986e-02f, 4.08025160e-02f, -2.01791510e-01f, 6.34936318e-02f, 3.70782077e-01f, -1.10662512e-01f, 7.63795599e-02f, 1.48055270e-01f,
  1.78406864e-01f, -1.56838465e-02f, -2.22066134e-01f, -9.12280381e-02f, -3.55722159e-02f, -1.05492845e-02f, -1.81592658e-01f, -6.61443025e-02f, -2.52422929e-01f, -8.90886702e-04f,
  1.95535198e-01f, 2.68268049e-01f, 2.04899952e-01f, -1.22434698e-01f, -1.33041024e-01f, 1.36292979e-01f, 2.02189058e-01f, -2.21289527e-02f, -3.65133323e-02f, -7.01765344e-02f,
  -9.68758464e-02f, -5.41226380e-02f, 1.40981749e-01f, 2.72500992e-01f, 1.51878698e-02f, 1.25674665e-01f, 4.18097600e-02f, -1.18615918e-01f, -4.94651981e-02f, -1.34931728e-01f,
  1.99416894e-02f, 1.61381781e-01f, -2.62131602e-01f, 9.87899229e-02f, -8.09908062e-02f, -1.34063259e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.86136916e-01f, 2.52391458e-01f, 2.16944247e-01f, 3.09895873e-01f, 4.06374335e-01f, -1.27101228e-01f, 7.89341480e-02f, 3.55014652e-01f, -9.02756229e-02f, -4.52154577e-02f,
  1.85942248e-01f, 3.33636969e-01f, -2.79706847e-02f, 4.78777252e-02f, 1.71316564e-01f, 1.73727259e-01f, -1.23675287e-01f, -8.10517147e-02f, -2.77800292e-01f, -1.44944400e-01f,
  -2.52580017e-01f, 2.93120086e-01f, -1.00689925e-01f, 1.95844457e-01f, 3.91135275e-01f, 1.18698254e-01f, 4.21058267e-01f, -3.32124352e-01f, -1.59649611e-01f, -2.94665128e-01f,
  -2.67978579e-01f, 6.08821101e-02f, 3.32129210e-01f, 1.64381504e-01f, -1.40816525e-01f, 5.08903563e-01f, -2.38286555e-01f, -4.56365347e-01f, 4.23965082e-02f, -4.86317240e-02f,
  -1.24081314e-01f, 4.88882899e-01f, 3.26575339e-02f, 3.82335365e-01f, 9.63239446e-02f, 1.44544899e-01f, -1.78444341e-01f, 5.43233566e-02f, 2.83281624e-01f, -3.24399136e-02f,
  2.31281102e-01f, 1.09801210e-01f, -3.83543611e-01f, 3.25760633e-01f, -2.57870942e-01f, 2.54181534e-01f, 4.88335371e-01f, -2.53247637e-02f, 5.22602737e-01f, 8.58503506e-02f,
  -1.00785427e-01f, -1.36372462e-01f, -1.81635439e-01f, -4.44135934e-01f, 3.79491709e-02f, 4.36015427e-01f, 3.37029457e-01f, 4.27338928e-01f, 4.11520228e-02f, -2.80774951e-01f,
  2.22919479e-01f, 1.92269329e-02f, 2.38239512e-01f, 8.73709768e-02f, -1.06440775e-01f, -2.28497550e-01f, 1.90357566e-01f, 3.22948426e-01f, 4.30792212e-01f, -1.37305394e-01f,
  -2.22834617e-01f, -5.53966463e-01f, 3.70637663e-02f, 1.55572802e-01f, -4.93258573e-02f, -4.03011054e-01f, 1.82363838e-01f, -2.55133063e-01f, 7.28606507e-02f, -2.76483178e-01f,
  4.11813289e-01f, 1.95529774e-01f, 2.68597603e-01f, 2.80774474e-01f, 3.63579363e-01f, 1.98768795e-01f, 3.07612091e-01f, 6.60077631e-01f, 3.76979679e-01f, 5.63071012e-01f,
  3.82270426e-01f, -3.26658338e-01f, -1.72257587e-01f, 1.08272567e-01f, -5.61924577e-01f, -2.50899523e-01f, -4.37929705e-02f, 2.59114027e-01f, 7.33089298e-02f, -5.11404872e-02f,
  1.30264029e-01f, 9.16571543e-02f, -1.68007478e-01f, -1.33990794e-01f, -4.52812284e-01f, -7.14301690e-02f, -3.10609132e-01f, 1.63384199e-01f, -1.74717903e-01f, -5.46144210e-02f,
  4.09340471e-01f, -2.56177664e-01f, 2.48778105e-01f, -4.08405721e-01f, -5.83335906e-02f, -5.68801820e-01f, 4.28263724e-01f, 1.36260539e-01f, -7.07883537e-02f, -3.54963273e-01f,
  -9.05491933e-02f, 4.58050847e-01f, -6.50553554e-02f, 1.66244060e-01f, 3.24968435e-02f, 2.73140132e-01f, -6.11937717e-02f, 1.54410467e-01f, -1.98674604e-01f, 8.83506611e-02f,
  1.12033121e-01f, 2.53841311e-01f, 8.17522481e-02f, 1.65438190e-01f, -5.06865501e-01f, -8.89270902e-02f, 1.80395737e-01f, -1.70279164e-02f, 2.98755795e-01f, -3.29205990e-01f,
  2.44318500e-01f, -1.05972044e-01f, 5.85749336e-02f, -3.39349598e-01f, -2.00092897e-01f, 2.94222206e-01f, -2.91197505e-02f, 1.88216493e-01f, 2.18348533e-01f, 2.31279016e-01f,
  2.97164857e-01f, -1.54367629e-02f, -6.50799721e-02f, -3.09914410e-01f, -2.10620865e-01f, 1.54516166e-02f, 1.80642694e-01f, 4.12271023e-01f, 3.76669407e-01f, 6.25622943e-02f,
  -2.60303468e-01f, 1.27951396e-04f, -1.78422645e-01f, 2.60233432e-01f, 2.42749587e-01f, -2.21754119e-01f, 1.01693012e-01f, -3.17057043e-01f, 2.89435267e-01f, -2.89694387e-02f,
  3.07607830e-01f, -6.10893779e-02f, 8.47122073e-02f, -9.64011103e-02f, -3.76889855e-01f, -5.97501546e-02f, -4.63532843e-02f, 1.13428339e-01f, 3.43967672e-03f, 2.81121224e-01f,
  -2.97331572e-01f, -1.03862621e-02f, 6.65146261e-02f, 3.72839630e-01f, 2.46077463e-01f, 2.13996604e-01f, 2.50145793e-01f, -5.31779462e-03f, 1.69935271e-01f, 5.32657385e-01f,
  3.11757445e-01f, -2.62834132e-01f, -1.09755337e-01f, -4.22164738e-01f, 2.10374936e-01f, 5.23368537e-01f, 1.87848747e-01f, -2.13101655e-01f, 9.18394479e-04f, 4.61760052e-02f,
  3.61787140e-01f, -1.49760842e-01f, -2.02308789e-01f, 1.62200123e-01f, -4.33032736e-02f, 1.37176424e-01f, -3.44183147e-01f, 2.96094120e-02f, 2.58362889e-01f, 4.57352810e-02f,
  -9.09889564e-02f, -1.09770283e-01f, -1.35633409e-01f, -2.89048344e-01f, 2.45026290e-01f, -2.26896882e-01f, -1.65323466e-01f, 6.51954636e-02f, 9.25952345e-02f, 6.30315617e-02f,
  -1.38119027e-01f, -3.80377173e-01f, -1.65613875e-01f, 1.04140148e-01f, 2.96734273e-01f, 1.56258702e-01f, -1.68498993e-01f, -2.26689801e-01f, -3.13993990e-01f, 4.17059779e-01f,
  -6.82876259e-02f, 4.24781628e-03f, 4.26075868e-02f, 7.83602819e-02f, -2.47071981e-01f, 1.84495166e-01f, -2.55701765e-02f, -5.23619428e-02f, 3.74348938e-01f, 1.40641138e-01f,
  -1.72546878e-02f, -2.36391023e-01f, -2.51574069e-01f, -2.41332352e-01f, 2.85715014e-01f, 2.35663936e-01f, -1.20007411e-01f, 1.65143907e-01f, 1.57969609e-01f, -6.95770979e-02f,
  -4.45709288e-01f, -2.24498674e-01f, -3.12447809e-02f, -1.80528656e-01f, 1.03558905e-01f, 8.99155438e-02f, 6.08668327e-02f, 2.58631147e-02f, 1.25450984e-01f, -1.98448911e-01f,
  -8.60687159e-03f, 2.41329335e-02f, 2.11042106e-01f, 1.05090372e-01f, 2.40420282e-01f, 2.64544040e-01f, -2.39872858e-02f, -1.42441571e-01f, 7.24016875e-02f, -2.34556701e-02f,
  -1.30260706e-01f, 1.34432495e-01f, -7.36456290e-02f, -5.36100827e-02f, 9.26941633e-02f, 5.25919311e-02f, -3.37855101e-01f, -1.01745009e-01f, 3.13032240e-01f, 2.18649060e-01f,
  1.52902350e-01f, -1.15553610e-01f, 8.72069076e-02f, -2.02965200e-01f, -3.30979884e-01f, 9.89136659e-03f, 3.03335309e-01f, -3.31302524e-01f, 4.06315744e-01f, 1.50003910e-01f,
  -5.85748315e-01f, -2.34984513e-02f, -3.39666992e-01f, 1.43517956e-01f, 3.78734171e-01f, 3.06796849e-01f, 5.23531735e-01f, -5.77486396e-01f, 6.44040108e-02f, 1.59123346e-01f,
  2.46043533e-01f, 2.86872119e-01f, 1.19154146e-02f, 3.38925660e-01f, 2.49219984e-01f, 2.36150458e-01f, -3.57759535e-01f, -2.70980746e-02f, -1.74999341e-01f, -8.45861435e-02f,
  2.66910166e-01f, 6.08660989e-02f, 1.68837413e-01f, 5.64960018e-02f, 4.84860539e-01f, -1.82814454e-03f, -7.49903768e-02f, -6.12568110e-02f, -1.74120471e-01f, -4.59400624e-01f,
  2.53120244e-01f, 1.40025809e-01f, -2.59090364e-01f, -4.77628201e-01f, -2.45622903e-01f, 2.33957142e-01f, 4.11405951e-01f, 5.77969730e-01f, -7.62945339e-02f, -2.91615337e-01f,
  1.75302997e-02f, 2.48382818e-02f, 2.03643143e-01f, -2.79920474e-02f, -6.60226569e-02f, 1.37795046e-01f, -1.12342304e-02f, -1.00328559e-02f, -1.15067750e-01f, -4.19827729e-01f,
  4.80425298e-01f, 4.88140732e-01f, -3.71897846e-01f, -3.52829188e-01f, -2.73659766e-01f, -4.79750000e-02f, -2.32282698e-01f, 4.30075943e-01f, 1.44485325e-01f, -3.33133608e-01f,
  1.79603428e-01f, 3.93126249e-01f, 5.49045838e-02f, 9.06028077e-02f, -1.24614745e-01f, 9.56279039e-02f, 8.44265223e-02f, -1.10281773e-01f, 8.44688788e-02f, 1.37835383e-01f,
  1.27801970e-01f, 1.47360742e-01f, 4.92096901e-01f, 3.11544654e-03f, 2.23019630e-01f, 1.67196214e-01f, -2.50187144e-02f, 1.63744792e-01f, -3.59891474e-01f, 2.03600943e-01f,
  7.76101425e-02f, -3.55557017e-02f, -3.33168536e-01f, -4.18355018e-01f, 4.15409682e-03f, 2.55151093e-01f, -6.94047287e-02f, -7.39607573e-01f, -7.11812377e-01f, -2.48728588e-01f,
  -3.19863647e-01f, -3.04170936e-01f, 5.24079353e-02f, 5.25870323e-01f, 8.91887248e-02f, -1.96416110e-01f, 9.19371247e-02f, 7.73230121e-02f, 8.69381055e-02f, -3.18530440e-01f,
  6.49957120e-01f, -8.11110064e-02f, -4.80181165e-02f, -1.34166017e-01f, 8.63816887e-02f, 1.20887563e-01f, -1.01655297e-01f, 7.55914748e-02f, 1.35969650e-02f, -1.12062581e-01f,
  1.54403612e-01f, -6.97626695e-02f, 1.78609401e-01f, 3.35149437e-01f, 3.35336268e-01f, -2.34687299e-01f, -1.63567826e-01f, 1.58003852e-01f, -2.71050245e-01f, -3.62192303e-01f,
  2.07039863e-02f, -8.72579068e-02f, 3.90245646e-01f, 9.83624905e-02f, 1.43340871e-01f, 1.32303268e-01f, -2.13515028e-01f, -1.95409507e-01f, 4.39546816e-02f, -1.69199124e-01f,
  2.41923064e-01f, -7.07373098e-02f, 8.57383907e-02f, 5.94618954e-02f, 9.05191302e-02f, -1.19971581e-01f, 1.75431356e-01f, -2.78404392e-02f, 3.11371475e-01f, 1.24447696e-01f,
  -3.74080002e-01f, 4.05442789e-02f, -3.44953895e-01f, 3.12564433e-01f, 3.21533978e-01f, 2.16916323e-01f, -1.71185702e-01f, 8.81474912e-02f, 4.08363461e-01f, 2.49831062e-02f,
  2.40760982e-01f, -4.58900005e-01f, -7.42124617e-01f, 3.90431941e-01f, 1.72531813e-01f, 1.75844565e-01f, 1.94299549e-01f, 8.75549242e-02f, -3.61599252e-02f, 2.15452641e-01f,
  1.29031196e-01f, 3.22000504e-01f, 2.20575795e-01f, 3.02669674e-01f, -2.73816317e-01f, -2.38999322e-01f, 1.20140009e-01f, 2.65410453e-01f, 7.95643553e-02f, -1.92446992e-01f,
  -1.44020349e-01f, -3.74047220e-01f, 4.02971031e-03f, -5.11656463e-01f, 1.83933645e-01f, -2.14626919e-03f, 4.65459943e-01f, 1.77390188e-01f, 5.28447986e-01f, 3.82219017e-01f,
  3.53407443e-01f, 2.05700532e-01f, 4.79495451e-02f, 2.54471488e-02f, 7.27279007e-01f, -2.56280750e-01f, -1.69174939e-01f, 4.92538631e-01f, -3.55675034e-02f, -3.49265754e-01f,
  3.75382751e-01f, 6.11865111e-02f, -4.57992762e-01f, 2.68450320e-01f, 9.57033262e-02f, 2.47438058e-01f, 1.20391503e-01f, 1.57570973e-01f, 3.58018517e-01f, -3.75213176e-01f,
  5.27997408e-03f, -1.24557622e-01f, 3.66214365e-01f, 1.59933031e-01f, -1.61669850e-01f, 3.20015848e-01f, -1.60179548e-02f, -5.81972953e-03f, -2.23838359e-01f, -1.78280532e-01f,
  2.11941317e-01f, 2.57635117e-01f, 2.51168698e-01f, 1.18659265e-01f, 2.98405647e-01f, 2.43772641e-01f, 6.24753907e-02f, -2.40352556e-01f, -1.42910346e-01f, 1.09494992e-01f,
  -3.60216834e-02f, -1.43983722e-01f, -5.97462244e-02f, 2.21565798e-01f, 3.56464148e-01f, -1.30392209e-01f, 8.99670795e-02f, 3.36067826e-02f, 2.31759578e-01f, 3.40761751e-01f,
  3.23492974e-01f, 1.61346212e-01f, -3.47802520e-01f, 1.26763165e-01f, -6.24149852e-02f, -1.32646948e-01f, 1.87854543e-01f, 9.91028734e-03f, 4.30577040e-01f, 5.90520725e-02f,
  -1.19642921e-01f, -2.22494468e-01f, 2.60335326e-01f, -3.94135118e-02f, 2.47780472e-01f, 3.46073121e-01f, 2.73177445e-01f, 5.42853653e-01f, 3.40832978e-01f, -2.17500240e-01f,
  1.86487466e-01f, 5.30438542e-01f, -2.12204784e-01f, -1.35479793e-01f, 1.32001698e-01f, 4.10367578e-01f, -8.28438327e-02f, -2.26601973e-01f, 5.26436754e-02f, 1.62716582e-01f,
  -1.83579981e-01f, -3.01736832e-01f, -3.76897901e-01f, -4.85686697e-02f, -2.67502008e-04f, -7.53094777e-02f, 2.35700399e-01f, 5.80428215e-03f, 1.06030144e-01f, -1.31880984e-01f,
  2.53070086e-01f, -5.39980173e-01f, 4.90179844e-02f, -1.87170431e-01f, 1.99172214e-01f, 4.02745306e-01f, -9.24735516e-02f, 4.05970722e-01f, 2.83483982e-01f, -1.01789214e-01f,
  1.78824797e-01f, 6.55231923e-02f, 1.80194154e-01f, 1.50980428e-01f, 2.52675176e-01f, -2.78889835e-01f, 3.30090970e-01f, -2.12587733e-02f, -3.73216003e-01f, 3.33577126e-01f,
  -4.64347564e-02f, 1.20451167e-01f, -5.74993268e-02f, -5.10956161e-02f, 1.21764332e-01f, -2.28138432e-01f, 1.15265265e-01f, -5.87849766e-02f, 3.15407157e-01f, 2.52036124e-01f,
  -2.63274193e-01f, 1.34485722e-01f, 5.97034246e-02f, 6.62221685e-02f, 1.50958702e-01f, 3.01956329e-02f, 1.19931079e-01f, 5.79114437e-01f, 1.25659972e-01f, 1.25307903e-01f,
  5.31276643e-01f, 5.04103541e-01f, -1.75123796e-01f, -1.46436512e-01f, 1.07433185e-01f, 2.88246751e-01f, 1.91815943e-01f, -2.42259398e-01f, -7.61249363e-02f, -4.46495302e-02f,
  -5.30716404e-02f, 3.78044933e-01f, -1.57036811e-01f, 2.12120041e-02f, -7.78631449e-01f, -4.17331249e-01f, 2.61017084e-01f, 7.25100860e-02f, -4.51425314e-01f, -5.92856824e-01f,
  -4.98478681e-01f, -7.28734851e-01f, 1.60446227e-01f, -9.23131466e-01f, 3.27896863e-01f, 7.18631372e-02f, -3.91909620e-03f, 2.16318563e-01f, 1.50457859e-01f, 1.34847686e-01f,
  -1.81946993e-01f, 3.26909795e-02f, 1.78094938e-01f, -2.55512863e-01f, -5.81385255e-01f, -2.98780382e-01f, -2.14013040e-01f, 1.93022445e-01f, -4.57492024e-02f, 4.74937201e-01f,
  -3.23471755e-01f, -4.28126693e-01f, -7.87392631e-02f, 2.60045141e-01f, 8.16311315e-02f, -5.89786172e-01f, 1.14908375e-01f, -2.25439936e-01f, 7.82448500e-02f, -1.66197956e-01f,
  2.57088482e-01f, 5.97357713e-02f, 3.09393555e-02f, 2.08052486e-01f, -3.55297834e-01f, 1.94268405e-01f, -6.62482828e-02f, 2.57735252e-01f, 2.59098500e-01f, 1.07747421e-01f,
  3.83437909e-02f, -1.81657761e-01f, -1.82227999e-01f, -2.40303412e-01f, 9.58554894e-02f, 2.94829577e-01f, -1.70013234e-01f, 2.58821815e-01f, 1.71732068e-01f, -1.56846315e-01f,
  -1.50839135e-01f, -5.35854660e-02f, 4.19901133e-01f, -7.20691010e-02f, 3.04578066e-01f, -4.91883963e-01f, 2.32931182e-01f, -2.53233500e-02f, 1.59644987e-02f, 3.45730007e-01f,
  -7.90513828e-02f, 3.29014063e-01f, 3.63408178e-01f, 1.06449455e-01f, 3.06455493e-01f, 3.95363033e-01f, -1.66600734e-01f, 2.27497533e-01f, -1.45972461e-01f, 1.16222903e-01f,
  -8.13842565e-02f, -4.79321554e-02f, -2.00620964e-01f, 1.33934200e-01f, 4.96385902e-01f, -3.86446826e-02f, 2.87708044e-01f, -4.51623090e-02f, 1.22336179e-01f, 1.77095711e-01f,
  -3.01217008e-02f, 2.12255150e-01f, 1.37973592e-01f, -1.50313526e-01f, 2.94647008e-01f, 3.40033695e-02f, -1.09252058e-01f, 1.24654591e-01f, -1.22929402e-01f, 3.73665571e-01f,
  -4.81678732e-03f, -3.79971772e-01f, -2.21449453e-02f, -1.22140020e-01f, -2.53210306e-01f, -2.02572271e-01f, 1.04068264e-01f, -2.90141523e-01f, 1.28354549e-01f, -1.99926719e-01f,
  9.02199671e-02f, -1.01455279e-01f, 5.95348217e-02f, 1.74442038e-01f, 6.13746703e-01f, 4.23479348e-01f, 3.64069082e-02f, 5.31150639e-01f, 1.72904447e-01f, 8.76993593e-03f,
  1.38469711e-01f, -2.88860500e-01f, -1.33055851e-01f, 6.09806888e-02f, 4.03630873e-03f, 4.59737509e-01f, -5.00189029e-02f, 1.54416546e-01f, 1.40150800e-01f, -1.19305491e-01f,
  1.01331308e-01f, -1.77794337e-01f, 2.77799934e-01f, 1.58427879e-01f, 8.03172886e-02f, -6.91013038e-02f, -1.92695938e-03f, 3.08459193e-01f, 6.13105334e-02f, 2.58804023e-01f,
  1.75129101e-01f, -5.77096641e-02f, 1.17037587e-01f, -8.72229636e-02f, 1.47654742e-01f, -1.36276349e-01f, -1.84986576e-01f, -4.71029431e-01f, 6.30950257e-02f, 2.02859163e-01f,
  2.38140330e-01f, 8.80652368e-02f, 3.53988320e-01f, -4.83816862e-01f, -2.77650505e-01f, -8.67646337e-02f, 2.00834721e-01f, -3.73411208e-01f, 2.83781916e-01f, -8.70022625e-02f,
  -1.80290729e-01f, 2.25354508e-01f, -2.93009281e-01f, 2.82106102e-01f, -2.71476340e-02f, -1.42602652e-01f, 3.36470187e-01f, -1.82817191e-01f, 8.16837847e-02f, 7.65603483e-02f,
  2.85874717e-02f, 2.36918315e-01f, -3.60630721e-01f, 2.11793676e-01f, -9.82855782e-02f, 1.27748191e-01f, -2.23088562e-01f, -2.58825988e-01f, 3.02463263e-01f, 5.47962844e-01f,
  -3.50638658e-01f, 2.15685517e-01f, 1.48020968e-01f, 3.51759762e-01f, 1.67024702e-01f, -2.87884921e-01f, 9.24232826e-02f, -1.28482625e-01f, -1.82756588e-01f, 3.60833615e-01f,
  3.72516140e-02f, 2.34508231e-01f, 1.67733520e-01f, -2.11542010e-01f, 2.61506289e-01f, -7.64322355e-02f, -2.48779163e-01f, -5.41471988e-02f, -3.60273451e-01f, 2.17749938e-01f,
  1.23561345e-01f, 1.34615049e-01f, -1.34475723e-01f, 2.69227058e-01f, 3.68518084e-01f, 1.50072083e-01f, 1.36782676e-01f, -1.87253281e-01f, 2.69522458e-01f, -2.06363890e-02f,
  -1.23721242e-01f, -2.90465742e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -4.88963015e-02f, 2.59351641e-01f, 2.91657120e-01f, 2.92966604e-01f, 1.35136440e-01f, 3.76387596e-01f, 3.41233671e-01f, 2.86045056e-02f, -5.44351041e-02f, 1.34692833e-01f,
  2.54415542e-01f, -2.75120325e-02f, -1.45745814e-01f, -5.30811734e-02f, 3.14817280e-01f, 3.71918857e-01f, 8.49522576e-02f, 3.43146145e-01f, 1.09667525e-01f, 2.83642877e-02f,
  -7.69255385e-02f, -4.69354466e-02f, 1.60992444e-01f, 1.35282412e-01f, 5.17857894e-02f, 1.13996968e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.47800326e-01f, -3.58595960e-02f, -2.09110036e-01f, -3.71656239e-01f, 1.63783371e-01f, 1.41087756e-01f, 1.93398283e-03f, 3.54229659e-01f, -5.57579279e-01f, -4.53166604e-01f,
  -2.01683208e-01f, -3.08277220e-01f, -5.39464235e-01f, 1.79637998e-01f, 8.39570630e-03f, 1.65170386e-01f, 8.90590847e-02f, 1.89261645e-01f, 3.33278030e-01f, -3.87319565e-01f,
  -5.36230206e-01f, -1.05402730e-01f, 1.22962430e-01f, -4.72800195e-01f, -2.60126263e-01f, 1.60109450e-03f, -2.28005741e-02f, 7.28425682e-02f, 4.64263521e-02f, 1.03966266e-01f,
  -3.14843327e-01f, 1.26225129e-01f, -5.25129586e-02f, -1.49923563e-01f, 6.61399215e-02f, 2.00497523e-01f, -1.07651442e-01f, -1.58716831e-02f, 2.61043996e-01f, 2.54637599e-01f,
  2.10963219e-01f, 3.37090671e-01f, -1.68758214e-01f, -2.62680143e-01f, 1.59121081e-01f, -1.51595660e-02f, 3.42577286e-02f, -1.56000361e-01f, -2.82774478e-01f, -2.61584848e-01f,
  -2.53964782e-01f, 6.36366606e-02f, -7.59670809e-02f, -7.98697472e-01f, 1.36483371e-01f, 2.10060209e-01f, -8.60841811e-01f, 9.70998779e-02f, -3.32111180e-01f, -1.34050742e-01f,
  -5.99778414e-01f, 2.54208148e-01f, -8.53790879e-01f, 3.43341768e-01f, 1.64121926e-01f, 3.91522110e-01f, 7.87554309e-02f, -2.25750491e-01f, 1.28598228e-01f, 6.10989571e-01f,
  -5.03853820e-02f, 3.94605935e-01f, -2.83356816e-01f, -8.38463157e-02f, -2.49054879e-01f, 8.96589272e-03f, 2.73781419e-01f, -5.32666922e-01f, -8.38523805e-02f, 1.74042508e-01f,
  -6.85670316e-01f, 1.01651214e-01f, -1.11540638e-01f, -6.71771914e-02f, -8.80262971e-01f, 4.13303934e-02f, 2.27120012e-01f, -3.90408218e-01f, 2.57835537e-02f, -6.60725594e-01f,
  3.15570921e-01f, -3.46179545e-01f, -6.56212687e-01f, 5.20711429e-02f, 3.58782947e-01f, 4.33735959e-02f, -1.34660020e-01f, -5.94900548e-02f, -2.98546031e-02f, 1.98522136e-01f,
  1.39408052e-01f, 2.94510096e-01f, -3.77601445e-01f, -3.20996463e-01f, -5.46849906e-01f, -2.88682461e-01f, -4.51547056e-01f, -4.61196184e-01f, -1.43774778e-01f, -2.80452013e-01f,
  2.46076107e-01f, 1.33091748e-01f, 1.08132958e-01f, 2.30977491e-01f, 1.70022532e-01f, 2.37157553e-01f, -3.65353554e-01f, -4.36397977e-02f, -3.24548364e-01f, -2.52201170e-01f,
  2.49251455e-01f, -8.49391147e-02f, 1.99784726e-01f, 1.78618640e-01f, 9.01125818e-02f, 7.43469819e-02f, -4.84954678e-02f, -1.86314173e-02f, -1.08336225e-01f, -4.78691369e-01f,
  7.90586248e-02f, 1.17475793e-01f, -3.94195706e-01f, -7.83465207e-01f, -1.41972080e-01f, -8.28242972e-02f, 5.81056520e-04f, -3.12906653e-01f, -1.00058012e-01f, -2.35879347e-01f,
  -4.41465937e-02f, -4.17016782e-02f, 2.03413263e-01f, 2.59379953e-01f, 2.02602461e-01f, -4.26474549e-02f, -4.30271357e-01f, -1.31895524e-02f, 2.64066100e-01f, 2.18792900e-01f,
  2.22749621e-01f, -5.57464778e-01f, 1.39894187e-01f, -1.04066983e-01f, -6.14526212e-01f, 1.46424830e-01f, -4.18030113e-01f, 3.08396406e-02f, 8.86492953e-02f, -6.28334954e-02f,
  -2.69413531e-01f, 2.69456595e-01f, -6.22993894e-02f, -6.84247494e-01f, -3.18175048e-01f, -3.94711941e-01f, 3.00428510e-01f, 6.31828159e-02f, -2.45838761e-01f, 1.79901481e-01f,
  -2.66705174e-02f, 1.91690251e-01f, 1.11292474e-01f, 8.04111809e-02f, -2.88094759e-01f, -3.37134227e-02f, 3.45379293e-01f, -2.19066665e-01f, -4.33196843e-01f, 2.49246970e-01f,
  1.47536978e-01f, 6.78866282e-02f, 9.50636435e-03f, 3.55964452e-01f, -4.18539643e-02f, -5.81309736e-01f, 4.83114421e-02f, -6.28655106e-02f, -4.04926874e-02f, -7.21713081e-02f,
  -2.15770632e-01f, -7.00019524e-02f, -7.49645904e-02f, -1.43045262e-01f, -1.54902965e-01f, 1.20492712e-01f, 2.29381412e-01f, 9.32797119e-02f, -5.62189408e-02f, 1.08541280e-01f,
  1.67910546e-01f, -4.46903378e-01f, 1.49285957e-01f, 1.66165844e-01f, 2.39736393e-01f, -1.86892644e-01f, 1.44828316e-02f, -2.02683210e-01f, -2.58635402e-01f, -7.67799020e-02f,
  -3.45819205e-01f, -2.77106464e-01f, 2.83893883e-01f, -3.67831558e-01f, 8.13922659e-02f, -2.71854103e-01f, -6.22902997e-03f, 5.63533902e-01f, -7.79707059e-02f, -3.55722845e-01f,
  3.95294368e-01f, -3.16023350e-01f, -4.04923260e-01f, -4.36253965e-01f, -4.11393553e-01f, -1.99004963e-01f, 8.46982077e-02f, 3.20904493e-01f, -5.17592877e-02f, 8.89241770e-02f,
  -1.70697659e-01f, -1.23186931e-01f, 2.14098498e-01f, -1.25925422e-01f, 2.79717594e-01f, 1.70323670e-01f, -2.25297585e-01f, -3.89955938e-02f, 9.89802107e-02f, -3.36350620e-01f,
  -2.06211016e-01f, 2.54748523e-01f, -2.48433545e-01f, 2.14733705e-01f, 1.16545729e-01f, -3.96877170e-01f, -3.10376406e-01f, 2.26015449e-02f, -1.69628665e-01f, -1.54846698e-01f,
  6.83511496e-02f, 3.13659966e-01f, -4.10998948e-02f, -1.12880804e-01f, -3.92498106e-01f, 1.60059147e-02f, 2.22106352e-01f, -3.41654494e-02f, 2.36618862e-01f, 2.92217046e-01f,
  -1.47300497e-01f, -2.65379697e-01f, -1.76347330e-01f, -6.37077868e-01f, 1.39283165e-01f, 2.77081817e-01f, 1.28815174e-01f, -1.46039993e-01f, -3.13216507e-01f, 8.86635929e-02f,
  -1.37699664e-01f, -7.20938325e-01f, 2.75792450e-01f, -1.34612396e-01f, 5.38745821e-02f, -1.93710104e-01f, 3.66923183e-01f, -1.39119759e-01f, 2.42346019e-01f, 1.67904243e-01f,
  -1.45976320e-01f, 2.08882198e-01f, -2.41887897e-01f, -2.03959212e-01f, 4.42774683e-01f, -2.63103068e-01f, 9.23598558e-02f, -2.04059690e-01f, 4.56337392e-01f, 3.07602495e-01f,
  7.09686056e-02f, 1.74392983e-01f, -7.22452486e-03f, 2.11749658e-01f, -1.02628224e-01f, -3.14201266e-01f, 1.98239639e-01f, 1.70241773e-01f, 2.06841505e-03f, 2.93159366e-01f,
  2.85842419e-01f, -2.94758171e-01f, -1.80794090e-01f, -2.30182223e-02f, -1.86034650e-01f, 1.54788628e-01f, -2.73588061e-01f, 2.73950726e-01f, 3.50508578e-02f, 1.08194619e-01f,
  -3.20645481e-01f, -4.04184125e-03f, 2.99445987e-01f, -2.27848664e-01f, 4.56797425e-03f, -6.52021646e-01f, 1.30943377e-02f, -1.04424255e-02f, 1.39301838e-02f, -5.26753724e-01f,
  -1.00091442e-01f, -2.99471945e-01f, -4.00066197e-01f, -6.68342337e-02f, 1.20453678e-01f, 1.03126587e-02f, 4.23549116e-02f, -6.77987635e-01f, -4.12947506e-01f, -1.43664315e-01f,
  -3.18799704e-01f, -1.78295225e-01f, -5.94615936e-01f, 1.76959828e-01f, -2.15120077e-01f, -1.36619851e-01f, 1.12926602e-01f, -1.31668374e-01f, 1.46544367e-01f, -2.71565199e-01f,
  -4.39380109e-01f, 1.69066668e-01f, -5.30572474e-01f, 6.13173917e-02f, 4.81678396e-01f, -2.75673181e-01f, -3.28830540e-01f, 2.58649170e-01f, 5.07593863e-02f, -7.19769418e-01f,
  4.19719636e-01f, 3.12371738e-02f, 6.07404783e-02f, -1.52802303e-01f, 2.02823132e-01f, 2.03135490e-01f, 1.64094374e-01f, 1.28686905e-01f, -3.84229779e-01f, 2.19404012e-01f,
  2.25211263e-01f, -3.61431420e-01f, -4.15166438e-01f, 1.46278977e-01f, -5.40909953e-02f, -3.00932229e-01f, 2.26670757e-01f, -3.23525995e-01f, 1.99150033e-02f, -2.19386667e-01f,
  7.07202017e-01f, 3.03294268e-02f, 2.64392048e-01f, -5.80941737e-01f, -6.09609410e-02f, -4.19643193e-01f, -5.60949266e-01f, -1.26552701e-01f, 2.19304353e-01f, -7.71505475e-01f,
  9.36627388e-02f, 7.95637444e-02f, 7.91524630e-03f, -2.01568425e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.13600440e-01f, -1.91607505e-01f, 2.49625016e-02f, -2.45741606e-01f, 3.32445949e-02f, 2.37207755e-01f, -1.54923275e-01f, -1.92142472e-01f, 1.48175463e-01f, 2.20723793e-01f,
  -1.32613763e-01f, -9.24299508e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    