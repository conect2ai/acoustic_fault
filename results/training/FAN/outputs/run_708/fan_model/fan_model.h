/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.79302514e-01f, 2.40747884e-01f, 8.77013355e-02f, 1.79145187e-01f, -2.38020904e-02f, -1.95755184e-01f, -5.57170808e-02f, -7.68595040e-02f, 4.73334491e-02f, 1.45729363e-01f,
  3.90997641e-02f, -2.07301587e-01f, 1.07710445e-02f, -1.51464865e-01f, -1.99679971e-01f, 1.90169767e-01f, 1.05788492e-01f, -2.41582822e-02f, -2.04352394e-01f, -1.32945687e-01f,
  -5.83349764e-02f, 5.09129576e-02f, 9.57259461e-02f, -7.49899969e-02f, 3.57550755e-02f, -1.81480777e-02f, 1.71372935e-01f, 1.55518934e-01f, -8.65944549e-02f, 1.84174240e-01f,
  1.09649338e-02f, -1.83821023e-02f, -1.07977077e-01f, -9.48346704e-02f, -1.15308957e-02f, -4.78856675e-02f, -7.15577416e-03f, 4.17769849e-02f, -6.89894035e-02f, -1.17164794e-02f,
  -9.92191657e-02f, -9.25271884e-02f, -1.14823438e-01f, -7.00954907e-03f, -9.20336023e-02f, -3.52555625e-02f, 3.41599109e-03f, -9.98315141e-02f, 3.32118347e-02f, -8.87228698e-02f,
  -1.35241905e-02f, 1.40661830e-02f, -2.96520069e-02f, -9.69942957e-02f, -3.12598497e-02f, -8.50940943e-02f, -5.72838485e-02f, -5.37488870e-02f, -9.29741636e-02f, 4.71167676e-02f,
  7.83059299e-02f, 1.50274813e-01f, 6.15036897e-02f, 1.84884425e-02f, 6.15491532e-02f, 8.37331563e-02f, 1.27051994e-01f, 3.37213725e-02f, 2.53177993e-02f, 6.73802942e-02f,
  7.53775910e-02f, 7.51821548e-02f, 7.02800900e-02f, 7.68796057e-02f, 1.50197605e-02f, 8.81816745e-02f, 9.23144221e-02f, 1.58945143e-01f, 8.06047544e-02f, 7.42698507e-03f,
  1.38565987e-01f, 2.72437315e-02f, 5.33399060e-02f, 3.27518955e-02f, 9.13830996e-02f, 7.22806603e-02f, 1.20323608e-02f, 7.29690716e-02f, 1.53688610e-01f, 7.54389912e-02f,
  2.11859718e-01f, -1.65716588e-01f, -2.22145785e-02f, -3.41442265e-02f, -3.60370241e-02f, -4.65679429e-02f, -5.66425212e-02f, -4.59619835e-02f, -4.44290154e-02f, -9.30362269e-02f,
  -8.81141648e-02f, -6.04204461e-02f, -6.97505474e-02f, -8.66903216e-02f, -2.13717446e-01f, -8.63883048e-02f, -5.66396900e-02f, -3.21063362e-02f, -1.15762793e-01f, -7.31848031e-02f,
  -6.74985722e-02f, 3.78698893e-02f, -2.08000541e-02f, -1.15570892e-02f, 2.80778799e-02f, -6.67017847e-02f, -8.96975920e-02f, 3.87359336e-02f, -9.49108079e-02f, 1.46682486e-01f,
  -3.77689421e-01f, 1.47757873e-01f, -3.64222266e-02f, -9.28997472e-02f, 3.24481934e-01f, 3.17216188e-01f, 3.55953425e-01f, -5.71542978e-03f, -6.41838908e-02f, -2.54517477e-02f,
  1.52868122e-01f, 5.43453135e-02f, -1.26862243e-01f, 3.06137856e-02f, -1.03106990e-01f, 1.01318471e-02f, 3.79254892e-02f, -2.34135360e-01f, 1.85977127e-02f, 5.25563471e-02f,
  9.72639769e-02f, -4.30523157e-02f, -2.60950238e-01f, -1.12539753e-01f, -1.29978642e-01f, 4.82585398e-04f, -1.42293558e-01f, -1.12644166e-01f, 1.89584970e-01f, 1.47765810e-02f,
  -1.90590307e-01f, -4.22834931e-03f, -2.76756976e-02f, -9.86257643e-02f, 2.56998371e-03f, -1.50579304e-01f, -8.25964510e-02f, -1.94021180e-01f, -1.17777228e-01f, -1.16335027e-01f,
  -7.67602026e-02f, -4.66483161e-02f, 2.39629811e-03f, -1.07902437e-01f, -1.13637872e-01f, -9.57792401e-02f, -7.61693567e-02f, -1.32672340e-01f, -1.68424666e-01f, 9.39792302e-03f,
  2.60595176e-02f, 4.37047370e-02f, -8.31073523e-02f, 4.37622778e-02f, -6.83596358e-02f, 5.09321354e-02f, -6.82977587e-02f, 3.85128409e-02f, 2.71515939e-02f, -2.02776179e-01f,
  -1.00965258e-02f, 1.48452371e-01f, 8.98070186e-02f, 6.95171300e-03f, 5.84376603e-02f, 1.20117433e-01f, 3.64653021e-02f, 2.00588666e-02f, 4.24394533e-02f, -6.30717576e-02f,
  5.73416017e-02f, 1.05432600e-01f, 7.76680512e-03f, 3.96328121e-02f, 2.69335676e-02f, 1.14438355e-01f, 6.70754611e-02f, 1.09804235e-01f, 7.12957904e-02f, 3.06699909e-02f,
  1.90286431e-02f, -5.46007045e-02f, -1.64395720e-02f, 1.16092153e-03f, 1.17405549e-01f, 7.26092830e-02f, 3.74840163e-02f, 1.22011499e-02f, 5.70196286e-02f, 9.78726149e-02f,
  -2.46627912e-01f, 1.00820236e-01f, -1.41592249e-01f, -4.77528721e-02f, -5.05248755e-02f, 3.68791893e-02f, -3.45291831e-02f, -1.63977332e-02f, -4.34465818e-02f, -2.01179143e-02f,
  -7.79372975e-02f, -9.44541395e-02f, -1.54079437e-01f, 1.14124538e-02f, 1.93387605e-02f, -1.11669768e-02f, 3.83556820e-02f, 2.46019121e-02f, -1.08645797e-01f, -4.68231738e-02f,
  -1.05479639e-02f, -4.49734703e-02f, -8.59397203e-02f, 2.61356831e-02f, 4.71976623e-02f, -5.02365343e-02f, -8.27458501e-02f, -1.29825681e-01f, -4.08100374e-02f, -1.91435426e-01f,
  2.68754333e-01f, 3.89711410e-02f, 1.55494465e-02f, 8.44046474e-02f, -1.17061183e-01f, -2.96859264e-01f, -2.72510231e-01f, -1.04908459e-02f, 7.39711821e-02f, -2.87884963e-03f,
  -3.26257795e-02f, 4.48702462e-03f, 2.41997615e-02f, -2.95533054e-02f, 2.91758738e-02f, -2.27766305e-01f, -1.53793246e-01f, 4.09559272e-02f, -4.75852415e-02f, -1.08862273e-01f,
  4.09773961e-02f, 1.60313696e-01f, 3.00149262e-01f, 2.50036661e-02f, -8.26024159e-04f, -1.19064607e-01f, -4.57135327e-02f, -3.50424498e-02f, -1.22123003e-01f, -5.62652685e-02f,
  3.81803550e-02f, 3.82309295e-02f, -2.01606173e-02f, -8.99459198e-02f, -8.39157477e-02f, -9.54127610e-02f, -8.34415406e-02f, -3.89623791e-02f, -2.67498698e-02f, -1.73580069e-02f,
  -1.38562336e-03f, -5.75574450e-02f, -1.26915663e-01f, 2.01259684e-02f, -1.32994592e-01f, -1.61899999e-01f, -9.10248328e-03f, -2.74419338e-02f, -7.52358884e-02f, -1.32086292e-01f,
  -1.84625477e-01f, -1.16631515e-01f, -1.45075202e-01f, -1.18118681e-01f, -1.45563826e-01f, -1.06317699e-01f, 1.40641769e-02f, -4.20549996e-02f, -3.47516946e-02f, -1.43743027e-02f,
  -7.50818029e-02f, 5.31410612e-02f, -2.82727480e-02f, 3.52065004e-02f, 4.78084199e-02f, 5.52102663e-02f, 3.24875675e-02f, 3.39540094e-02f, 8.95799696e-03f, 2.74935868e-02f,
  3.65118757e-02f, 1.04283944e-01f, 1.71723396e-01f, 1.44961715e-01f, 6.48375601e-02f, -1.85244996e-02f, 5.03321998e-02f, 3.59346122e-02f, 6.03260919e-02f, 2.56731585e-02f,
  3.91789526e-02f, 5.93849085e-02f, -4.84488346e-02f, -1.09989680e-02f, 8.73864666e-02f, 2.10669134e-02f, 4.14158814e-02f, 7.09964633e-02f, 2.80599315e-02f, 1.76310260e-02f,
  -2.14339700e-02f, -9.03524011e-02f, -5.05666025e-02f, -1.49312327e-02f, -5.66420741e-02f, -1.79118086e-02f, -1.08924873e-01f, 8.20366945e-03f, -1.64880715e-02f, 1.83905363e-02f,
  -1.02706529e-01f, -1.79420114e-02f, -1.02216847e-01f, 2.11465117e-02f, -3.06190085e-02f, -1.28426671e-01f, -1.26095489e-01f, -1.81435179e-02f, -8.27382132e-02f, -1.50386384e-02f,
  -1.61261875e-02f, -2.21434832e-01f, -1.01672411e-01f, -3.93149890e-02f, -1.60278082e-01f, -1.45169750e-01f, -2.07273945e-01f, -1.25051215e-01f, -2.06484839e-01f, -1.33250967e-01f,
  5.73141873e-01f, 1.31395176e-01f, -1.96109951e-01f, 1.50814995e-01f, -2.15928257e-01f, -1.55766532e-01f, -5.29572964e-02f, -4.63590808e-02f, -6.47866279e-02f, -3.20835635e-02f,
  -1.91422358e-01f, -2.19240531e-01f, -4.32909951e-02f, -9.07185003e-02f, -1.02897152e-01f, 6.81731477e-02f, 7.40920678e-02f, 7.34907314e-02f, -2.38089368e-01f, -2.67949522e-01f,
  -6.93413243e-02f, 1.65410727e-01f, 2.65542299e-01f, 1.57408770e-02f, 1.17753774e-01f, -1.44913465e-01f, 1.46328628e-01f, 1.95142075e-01f, 7.99686611e-02f, 2.51093537e-01f,
  -9.52071324e-02f, 1.63349599e-01f, -2.06270248e-01f, -1.44310314e-02f, -7.57232532e-02f, -4.22980115e-02f, -4.07570340e-02f, 6.15869388e-02f, -1.43297184e-02f, 2.98103020e-02f,
  -1.51291251e-01f, -6.09694868e-02f, 3.40708606e-02f, 3.80974561e-02f, 2.49020439e-02f, -2.12378446e-02f, 7.72688016e-02f, 1.26465186e-01f, -2.07695793e-02f, 1.41729480e-02f,
  -5.81893697e-02f, -6.16431013e-02f, 4.83284481e-02f, -7.79174119e-02f, 3.59452367e-02f, -5.13615832e-02f, -4.54724953e-02f, -2.23749243e-02f, -5.83129115e-02f, 8.32843333e-02f,
  5.92943281e-02f, 1.64249837e-02f, 4.37082089e-02f, 3.72104123e-02f, 4.30314541e-02f, -1.04815410e-02f, 2.34770551e-02f, 4.94474955e-02f, -5.86043857e-02f, 8.10489282e-02f,
  3.10333520e-02f, -1.23022320e-02f, -1.30950671e-03f, 1.21762797e-01f, 3.73960473e-03f, 7.08131269e-02f, 5.92595562e-02f, 3.34045291e-02f, 3.85888033e-02f, 1.48299262e-01f,
  7.98774734e-02f, -5.39170066e-03f, 2.33052969e-02f, -1.22447461e-02f, -2.60387640e-03f, 1.08455000e-02f, 8.15419033e-02f, -5.53803667e-02f, 5.14696017e-02f, 8.78602415e-02f,
  4.13310118e-02f, -1.00034930e-01f, -6.96053822e-03f, -1.34731114e-01f, -1.50595620e-01f, 2.16790196e-02f, -6.12757094e-02f, -2.52143946e-02f, -3.40929814e-02f, -1.42705783e-01f,
  -9.02252793e-02f, -1.17348559e-01f, -7.69114420e-02f, -1.41807913e-03f, 1.68397371e-02f, -7.00732917e-02f, -1.02276601e-01f, -1.47267148e-01f, -4.63741086e-02f, -9.35169756e-02f,
  -5.32460436e-02f, -1.45774439e-01f, 4.27284501e-02f, -2.51750648e-02f, -9.01106521e-02f, -1.75796580e-02f, -4.89487350e-02f, -2.29425672e-02f, -9.61792935e-03f, 6.52524680e-02f,
  -5.96796572e-02f, 1.70014888e-01f, -1.07241616e-01f, 6.89820126e-02f, 8.20204318e-02f, -5.97013161e-02f, 7.76701421e-02f, -4.57152352e-02f, -1.26428023e-01f, 4.06692065e-02f,
  -1.30892709e-01f, -2.72914171e-01f, -1.76900148e-01f, -2.75104642e-01f, -1.86960667e-01f, 1.02798849e-01f, 1.06104948e-01f, -1.76330999e-01f, -3.21362764e-01f, -9.59095582e-02f,
  1.77057534e-01f, 6.88796639e-02f, 7.21403062e-02f, -8.03335849e-03f, 1.63099483e-01f, -5.33405095e-02f, 1.14767917e-01f, 1.43470004e-01f, 7.87405819e-02f, 2.24605605e-01f,
  -2.18813822e-01f, -1.28275350e-01f, -5.77553660e-02f, -1.04856327e-01f, -6.06993139e-02f, -1.23698547e-01f, -1.07340224e-01f, -6.76661730e-02f, -1.83014184e-01f, -1.09117560e-01f,
  -2.10950449e-01f, -2.74156258e-02f, -9.42824185e-02f, -8.83666128e-02f, -9.01008397e-02f, -1.42703846e-01f, 3.06671634e-02f, -9.96919628e-03f, -1.66675970e-01f, -6.09418638e-02f,
  2.44988464e-02f, -3.83452908e-03f, -8.79739374e-02f, 5.88792302e-02f, -8.79025087e-02f, -3.55863273e-02f, 1.23674767e-02f, -6.37234449e-02f, -5.66893704e-02f, -4.16168347e-02f,
  1.22817576e-01f, 9.83279571e-02f, 7.78082907e-02f, 1.31235242e-01f, 2.49036849e-02f, 2.69127470e-02f, 2.35412810e-02f, 1.01661272e-01f, -2.14874614e-02f, -1.63263478e-03f,
  -1.20497823e-01f, -7.13507831e-02f, 3.49979773e-02f, -7.53999862e-04f, 6.03576824e-02f, -5.24888672e-02f, 2.97074043e-03f, 6.26419187e-02f, 1.15791904e-02f, 3.59334312e-02f,
  5.73014095e-02f, -1.48796886e-02f, -2.04973370e-02f, -8.18664357e-02f, 1.28178343e-01f, 7.21091405e-02f, 5.57304174e-02f, 4.19337638e-02f, 1.00658201e-01f, 4.93615046e-02f,
  -1.01075418e-01f, 1.91542655e-02f, -1.21297412e-01f, -1.25410512e-01f, 2.32257918e-02f, -6.57087192e-02f, -7.53776059e-02f, -9.30174589e-02f, -2.79614907e-02f, -9.69557986e-02f,
  -6.63497820e-02f, -1.47459999e-01f, -1.31693959e-01f, 7.06138760e-02f, -1.67938262e-01f, 5.22304773e-02f, 8.37121606e-02f, -3.21716219e-02f, -4.92609292e-02f, 5.47782332e-02f,
  3.62469964e-02f, 9.03101936e-02f, -1.06738344e-01f, -4.67709452e-02f, -9.59629342e-02f, -1.20080717e-01f, -1.65399417e-01f, 4.07579243e-02f, -7.81084821e-02f, 1.01192622e-03f,
  -3.85076225e-01f, -2.74265170e-01f, 2.32965369e-02f, -8.02157596e-02f, -5.97061105e-02f, -7.78169408e-02f, -2.27515787e-01f, -1.24503836e-01f, 3.88374552e-02f, -1.23373240e-01f,
  2.10892819e-02f, 2.79549956e-01f, 1.62520215e-01f, 1.30547136e-01f, -3.58257331e-02f, -2.68091798e-01f, -2.73796558e-01f, -3.88187133e-02f, 4.41044234e-02f, -4.61379737e-02f,
  -1.22530684e-01f, -5.81141300e-02f, 3.21446657e-02f, 2.02233549e-02f, -7.31253028e-02f, 2.48803981e-02f, -6.07687756e-02f, 5.92496106e-03f, 8.29160064e-02f, -2.50518501e-01f,
  1.33418083e-01f, -1.54308066e-01f, -1.96238197e-02f, -2.86778379e-02f, 1.02145471e-01f, 3.12392060e-02f, -1.15669472e-02f, 4.16003056e-02f, 3.04982476e-02f, -1.35449141e-01f,
  2.95970254e-02f, 6.53309077e-02f, -1.20177949e-02f, 4.90613095e-02f, 2.12024041e-02f, 4.24740985e-02f, 3.41607742e-02f, 4.08959799e-02f, -1.21118752e-02f, -3.24104577e-02f,
  -3.78953703e-02f, -4.49019298e-02f, -1.34717911e-01f, -6.91986606e-02f, 4.78802025e-02f, 4.31127427e-03f, 6.12243712e-02f, -3.40820141e-02f, 2.66522467e-02f, -2.04223827e-01f,
  -2.31083836e-02f, -1.35678779e-02f, 4.98307161e-02f, -5.63944168e-02f, 1.16426304e-01f, 9.84440744e-02f, 2.70231757e-02f, 3.93667780e-02f, 7.15957507e-02f, -7.77926017e-03f,
  6.58737496e-02f, 7.13014379e-02f, 3.20612043e-02f, 8.69501457e-02f, -7.62711372e-03f, 4.71807569e-02f, 8.05606470e-02f, 1.03475302e-01f, 5.42622618e-02f, 2.15862691e-02f,
  1.13164626e-01f, -2.67673861e-02f, 6.80988431e-02f, 1.40893891e-01f, 3.08489706e-02f, 7.56228268e-02f, -1.87091343e-02f, 7.43763596e-02f, 5.43742850e-02f, 2.58493540e-03f,
  1.58519953e-01f, 9.48935971e-02f, -1.37328701e-02f, -8.36226419e-02f, 1.07756245e-03f, -7.39766508e-02f, -2.95818020e-02f, -3.63774337e-02f, -1.07597895e-01f, -2.06496678e-02f,
  -3.53382528e-02f, -1.39555382e-02f, 6.67091981e-02f, -1.94780193e-02f, -3.02215386e-02f, -9.91929974e-03f, -5.60220256e-02f, -3.24436016e-02f, -2.55724862e-02f, -8.92548114e-02f,
  -1.02678925e-01f, -1.42507643e-01f, -1.36905819e-01f, -1.19191289e-01f, -1.12546841e-03f, -4.82323095e-02f, -6.33440316e-02f, 1.10381423e-02f, -6.75509274e-02f, -1.29212186e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.67143542e-01f, -2.33494379e-02f, 2.44886786e-01f, 1.16654485e-02f, 5.42690530e-02f, -1.33120343e-01f, -3.34425718e-01f, -1.52685449e-01f, -2.32365332e-03f, -1.37014553e-01f,
  -1.11382447e-01f, 1.83299229e-01f, 1.07731059e-01f, 1.04301266e-01f, -3.45842570e-01f, -2.41721168e-01f, -1.41448632e-01f, -1.34997264e-01f, -1.22924708e-01f, -3.89148891e-01f,
  -9.65574980e-02f, -1.16600648e-01f, 4.28989381e-02f, 8.08896944e-02f, 2.81882398e-02f, 9.87755433e-02f, 1.87918082e-01f, 5.34896590e-02f, 1.37606785e-01f, -1.95703544e-02f,
  -9.84597355e-02f, 1.69832609e-03f, -6.57566935e-02f, -1.21545762e-01f, -4.52858396e-02f, -5.00284657e-02f, -9.60012600e-02f, -1.15422554e-01f, 5.41695729e-02f, -1.20220557e-01f,
  -1.04008898e-01f, -8.91837031e-02f, 7.49103948e-02f, 4.21631411e-02f, -1.15259312e-01f, -2.14821234e-01f, -1.72866751e-02f, -1.21297032e-01f, -8.81405324e-02f, -1.19263440e-01f,
  -1.12881802e-01f, -6.82465434e-02f, -7.72946179e-02f, 9.78721455e-02f, 7.37676769e-03f, 4.24824245e-02f, -2.19405554e-02f, 9.17520225e-02f, 1.15088999e-01f, -7.85913989e-02f,
  -2.34662797e-02f, 1.88698638e-02f, 7.12463539e-03f, -8.52080528e-03f, -4.91687581e-02f, -2.10872456e-03f, -2.50055678e-02f, -1.97709147e-02f, -7.04804761e-03f, -8.08935761e-02f,
  -1.70081183e-02f, -6.50325716e-02f, -2.45072953e-02f, 1.13385851e-02f, 2.05031149e-02f, 2.92470604e-02f, -7.91511536e-02f, -9.08485278e-02f, 2.40615197e-02f, 6.41455650e-02f,
  -1.05902143e-01f, 7.96452165e-02f, -5.75032979e-02f, 2.08590217e-02f, -1.39939442e-01f, -9.69872326e-02f, 1.14245517e-02f, -5.63244671e-02f, 1.34392694e-01f, -1.04595989e-01f,
  -6.11648895e-02f, 8.35300460e-02f, 1.27181718e-02f, -4.99741845e-02f, 1.10728368e-01f, 3.65859903e-02f, 4.01685275e-02f, -1.29261762e-01f, -1.41721383e-01f, -1.08984485e-01f,
  -1.09603763e-01f, 5.36858439e-02f, -1.94508173e-02f, -6.17073476e-02f, -1.75062433e-01f, -6.65899590e-02f, -1.57950252e-01f, 3.83326001e-02f, -1.28365248e-01f, 1.22890867e-01f,
  6.20992929e-02f, -2.79667497e-01f, 7.88132288e-03f, 1.46884248e-02f, 1.24597726e-02f, -6.39997050e-02f, 1.30215019e-01f, 1.71682574e-02f, -2.36374512e-02f, -3.92530411e-02f,
  -6.55239642e-01f, 5.44916764e-02f, 5.86237833e-02f, -5.68499148e-01f, -8.12035650e-02f, 1.35603012e-03f, 2.48712912e-01f, -4.34196442e-02f, -3.24009150e-01f, 2.71421764e-02f,
  7.07932785e-02f, -2.94899177e-02f, -1.22217894e-01f, 1.75807565e-01f, 1.32643655e-01f, 1.27505839e-01f, -1.22559637e-01f, -1.09638579e-01f, 2.04039603e-01f, 2.85300821e-01f,
  -7.20811635e-03f, -2.81677783e-01f, -2.42590487e-01f, -1.98662028e-01f, -1.61841065e-01f, -4.43178695e-04f, -5.53551987e-02f, -1.88807875e-01f, 1.35292605e-01f, -1.70229629e-01f,
  3.93436760e-01f, -6.78847432e-02f, -4.17240597e-02f, -1.76662236e-01f, 1.05860122e-01f, -4.49904725e-02f, 6.70032799e-02f, -3.85348052e-02f, -8.35458934e-02f, -6.29778281e-02f,
  -1.03434414e-01f, -1.46821421e-02f, -9.95799452e-02f, 3.21295904e-03f, -4.27330844e-02f, -2.42538434e-02f, -1.64187942e-02f, -6.86009824e-02f, 2.02990901e-02f, 6.46462217e-02f,
  1.14385441e-01f, -3.13030258e-02f, -5.62452674e-02f, 6.84987530e-02f, -6.40084669e-02f, -6.78941160e-02f, 6.59968108e-02f, -1.04591347e-01f, -1.08113803e-01f, -1.36512727e-01f,
  8.96191895e-02f, -3.69339213e-02f, 3.58533598e-02f, -3.64057980e-02f, -7.57401716e-03f, 5.00150099e-02f, 2.21158620e-02f, 4.04182747e-02f, 5.87485544e-02f, -8.72565582e-02f,
  5.63372448e-02f, 1.05159648e-01f, -5.18668182e-02f, -1.16788909e-01f, 1.37107605e-02f, -9.42310095e-02f, 2.28177160e-02f, -4.38485071e-02f, 1.25877222e-03f, -1.13154143e-01f,
  -1.63539648e-02f, -1.61732419e-03f, -9.81296450e-02f, -1.77820344e-02f, 3.46514955e-02f, -5.89782111e-02f, -8.41272846e-02f, 1.36808129e-02f, 7.79918209e-03f, 2.46653855e-02f,
  9.72332247e-03f, 5.31982295e-02f, -3.23082064e-03f, -6.06347807e-02f, -7.66502023e-02f, -8.96250382e-02f, -1.78174242e-01f, -6.94952011e-02f, -2.74517182e-02f, -2.91487090e-02f,
  -3.51287574e-02f, 2.60237940e-02f, 2.36229803e-02f, 3.88342105e-02f, -4.51772986e-03f, -5.05782329e-02f, 2.15592002e-03f, 9.52912718e-02f, -3.72354575e-02f, 1.41758416e-02f,
  8.29557478e-02f, 6.24517947e-02f, -2.98416466e-02f, 1.22154532e-02f, 2.74907867e-03f, 1.28251210e-01f, 1.99408427e-01f, 8.79221931e-02f, 1.21135049e-01f, -1.99646000e-02f,
  6.12256527e-01f, -2.99844444e-01f, -2.14778557e-01f, 1.06352538e-01f, -1.22260936e-01f, -8.33688006e-02f, -7.80768469e-02f, 9.82944667e-02f, 1.18548147e-01f, -2.20004559e-01f,
  -2.20600873e-01f, 7.72821084e-02f, 9.21707302e-02f, -8.30959901e-02f, -3.23566161e-02f, -5.66207357e-02f, -1.06159344e-01f, 1.10719912e-01f, 9.96768549e-02f, -1.81753948e-01f,
  -1.04499876e-01f, -1.19364537e-01f, 5.12955189e-02f, -5.78749888e-02f, -2.82931179e-01f, -3.59667512e-03f, -1.09541677e-01f, -2.90012825e-02f, -2.23068193e-01f, -1.08377062e-01f,
  -3.13901855e-03f, 6.96587265e-02f, -8.89289752e-02f, -3.99575755e-03f, 1.60408001e-02f, 5.75843081e-02f, 2.22817715e-02f, -1.02901667e-01f, 3.67033966e-02f, -3.96477841e-02f,
  -2.75428370e-02f, 6.18496835e-02f, 1.09587453e-01f, -1.48557901e-01f, -4.35221903e-02f, 5.27187362e-02f, -2.23228578e-02f, -1.41458195e-02f, -2.11113747e-02f, 1.48086827e-02f,
  -1.27896100e-01f, 2.86288112e-02f, 4.52888347e-02f, -1.92169298e-03f, -1.45319685e-01f, 9.58645251e-03f, -1.03213847e-01f, -9.10899416e-02f, -1.85200542e-01f, -3.69703490e-03f,
  3.48759107e-02f, 5.83423413e-02f, -9.23275668e-03f, -7.28583857e-02f, 7.21057579e-02f, -8.02292302e-03f, 2.08600879e-01f, 2.53488123e-02f, 5.74435778e-02f, -6.22068793e-02f,
  -1.08001819e-02f, -2.89295521e-03f, -4.19345014e-02f, 1.44048572e-01f, 6.60340348e-03f, 5.17181382e-02f, 8.14721212e-02f, 4.26427349e-02f, -6.19381703e-02f, -7.76830241e-02f,
  -4.55478057e-02f, 3.35424729e-02f, 1.30540766e-02f, -3.74082327e-02f, -1.60268862e-02f, 3.31937261e-02f, 5.85226901e-03f, 7.16362381e-03f, 1.18306801e-01f, -1.34477522e-02f,
  4.65713994e-04f, 4.19029072e-02f, -1.82411564e-03f, -2.37276983e-02f, 8.89395177e-02f, 2.95861829e-02f, 3.37251648e-02f, 2.96991542e-02f, 7.69434962e-03f, -2.92434171e-02f,
  -1.12876883e-02f, -3.33521254e-02f, 1.90473571e-02f, -7.33972788e-02f, -3.83383734e-03f, -6.83414117e-02f, -9.83329564e-02f, 6.24106498e-03f, -6.42035529e-02f, -4.42298409e-03f,
  8.68551955e-02f, 1.47540867e-01f, 1.56937405e-01f, 9.19818133e-02f, -8.49052966e-02f, 2.25328445e-01f, -2.80206278e-03f, -8.26106742e-02f, 6.38707727e-02f, 4.36636806e-02f,
  -6.38108373e-01f, -1.76371634e-01f, 9.66342613e-02f, 7.88684934e-02f, 4.12781119e-01f, 2.50851184e-01f, 2.93221325e-01f, 1.23241596e-01f, 1.06919743e-01f, 9.75121632e-02f,
  -1.69272318e-01f, -6.28972203e-02f, -5.22639789e-02f, -1.09189883e-01f, -7.18160644e-02f, 2.69435763e-01f, 2.77975380e-01f, 4.85328250e-02f, 1.53912440e-01f, 1.50011808e-01f,
  2.56937623e-01f, 4.96251844e-02f, -1.96295232e-01f, -1.65167619e-02f, 1.13550536e-01f, 1.97964504e-01f, 9.42807496e-02f, -1.20651640e-03f, 9.60638970e-02f, 4.66849469e-02f,
  9.58531871e-02f, -3.47775787e-01f, 3.06634773e-02f, -1.52298287e-01f, -2.02592239e-01f, -2.38096341e-01f, -9.56281647e-02f, -1.16938725e-01f, 5.08624129e-02f, 1.37106732e-01f,
  -8.12368318e-02f, -9.54572111e-02f, 1.09846126e-02f, 7.86676407e-02f, 8.66521075e-02f, -1.00950509e-01f, 1.01002995e-02f, 3.90760712e-02f, 7.80944899e-02f, 2.88266484e-02f,
  -6.13280833e-02f, 7.04228207e-02f, 1.89019531e-01f, 4.53801677e-02f, 6.52603805e-02f, -1.17892744e-02f, 3.12137473e-02f, -4.48583402e-02f, 4.58786339e-02f, -1.15608223e-01f,
  6.13466389e-02f, 5.14835492e-02f, -7.75971562e-02f, 2.73577571e-02f, -4.41640848e-03f, 6.42283335e-02f, 1.10656001e-01f, 2.06743870e-02f, -6.67795464e-02f, -2.41756029e-02f,
  8.76053870e-02f, -1.04128055e-01f, -3.26916575e-02f, 4.80687544e-02f, -4.91086505e-02f, 5.88485189e-02f, 5.20525314e-02f, -7.63853565e-02f, -2.35791713e-01f, -8.84010941e-02f,
  -1.81637719e-01f, -1.29988929e-02f, -1.21334970e-01f, 2.96656378e-02f, -6.68379143e-02f, 4.86137941e-02f, 5.76224625e-02f, -7.85088614e-02f, -1.19616903e-01f, 5.30990772e-02f,
  2.79622763e-01f, -2.03066543e-01f, 2.98291240e-02f, -8.22139084e-02f, -7.21380487e-02f, -2.84243286e-01f, -1.92185760e-01f, 1.23327235e-02f, 7.92262107e-02f, 4.96306689e-03f,
  -1.49270326e-01f, -8.33251923e-02f, -5.08205593e-02f, 1.76343098e-02f, 1.66819841e-02f, -9.81216878e-02f, -1.36288270e-01f, 1.84933349e-01f, 7.98081160e-02f, 5.29223084e-02f,
  4.41571549e-02f, 9.52732563e-02f, 1.31770268e-01f, 2.09626690e-01f, 1.36539951e-01f, 1.70668647e-01f, 1.19856805e-01f, 7.26929605e-02f, 2.01739799e-02f, 5.24654165e-02f,
  -1.41058132e-01f, 1.53238609e-01f, -3.19593810e-02f, 4.91819493e-02f, 1.75457895e-01f, -7.02817589e-02f, -6.09707460e-02f, -1.14101015e-01f, 9.44579765e-02f, 9.22046676e-02f,
  3.58173586e-02f, 3.22442092e-02f, 1.39237583e-01f, -1.35812715e-01f, -4.83657829e-02f, 1.05428107e-01f, 2.45063350e-01f, -1.71780273e-01f, -5.24706662e-01f, -3.15801352e-01f,
  7.80657604e-02f, -1.13372229e-01f, -2.16947272e-01f, -6.15452789e-02f, 1.58054501e-01f, -2.26367963e-03f, 1.04399323e-01f, -7.59231970e-02f, -1.32141143e-01f, 3.46343964e-01f,
  -4.12688628e-02f, -9.01704282e-02f, -1.42114252e-01f, 1.89333148e-02f, 9.81429219e-03f, -6.05573766e-02f, -6.15283810e-02f, 6.87328652e-02f, -6.24458268e-02f, -8.81165937e-02f,
  1.22513168e-01f, 6.03992790e-02f, 1.31722882e-01f, 3.05547658e-02f, 2.05172561e-02f, -4.19903211e-02f, 1.04976945e-01f, 7.21760616e-02f, -1.07986614e-01f, -3.43295038e-02f,
  1.18728764e-01f, 8.03044736e-02f, -1.53396443e-01f, -1.13202341e-01f, -2.33181402e-01f, -1.50491342e-01f, -1.49094939e-01f, -2.66136508e-02f, -1.29990622e-01f, -1.16675319e-02f,
  -1.63670510e-01f, -2.26254985e-02f, -9.59004685e-02f, -1.03509352e-01f, -7.87838697e-02f, 1.09586008e-02f, -1.13311864e-01f, -7.71612898e-02f, -9.90291387e-02f, -1.54577866e-01f,
  1.77309383e-02f, -8.68903995e-02f, -1.23877689e-01f, -3.79266627e-02f, -3.34102213e-02f, 5.13042547e-02f, -4.79740985e-02f, -1.20387532e-01f, -1.08309619e-01f, -1.00416727e-01f,
  -5.13471514e-02f, -7.92577043e-02f, 5.29978536e-02f, -8.74726102e-02f, 2.54639350e-02f, -1.28923893e-01f, -5.37736788e-02f, -9.38669592e-02f, -9.27617401e-02f, 2.08702628e-02f,
  1.65948629e-01f, -1.55545115e-01f, 7.71923363e-02f, 7.48562664e-02f, -1.81866921e-02f, 1.06519267e-01f, -1.47921950e-01f, -1.91114265e-02f, -1.57880574e-01f, -1.94329470e-01f,
  -1.15958273e-01f, -2.29640290e-01f, 1.16120622e-01f, 5.53826168e-02f, -3.96703556e-03f, -1.05155647e-01f, 9.06195343e-02f, 5.16705066e-02f, 8.39832947e-02f, 1.45243406e-01f,
  6.08078428e-02f, -1.98159572e-02f, -1.81492418e-01f, -3.00007174e-04f, -4.00053188e-02f, -1.15780629e-01f, -3.88686433e-02f, -1.08878575e-02f, -2.14269742e-01f, -5.30710556e-02f,
  8.98326859e-02f, -8.37916508e-02f, 1.00340888e-01f, 1.62113354e-01f, 3.43476757e-02f, 4.24930677e-02f, -1.17514946e-01f, 1.52371466e-01f, 2.22412512e-01f, -1.81203857e-01f,
  4.11055498e-02f, 8.13759416e-02f, 2.81838272e-02f, 4.19991985e-02f, -6.53388649e-02f, -1.14369400e-01f, -2.74341047e-01f, -4.61367927e-02f, 1.18538350e-01f, 8.11991021e-02f,
  -1.48357812e-03f, -2.38276199e-02f, 1.66791990e-01f, 1.11571640e-01f, -2.37897769e-01f, -1.15194224e-01f, -2.73648798e-01f, -8.96164700e-02f, -2.54944116e-01f, -3.61615717e-01f,
  -1.21233948e-01f, -1.34473100e-01f, -2.79418528e-02f, -1.43551677e-01f, -8.38901401e-02f, -2.54633534e-03f, -6.74329847e-02f, -1.90400645e-01f, -1.20429531e-01f, 1.41903721e-02f,
  -1.02039658e-01f, 5.66793419e-02f, -3.18367444e-02f, 5.21786045e-03f, -6.01665955e-03f, -3.69399674e-02f, -4.94629219e-02f, -2.70078387e-02f, -1.14544943e-01f, 5.04611842e-02f,
  -1.36629432e-01f, -1.73721552e-01f, -1.78120732e-01f, 1.09989615e-02f, 4.75339778e-02f, 1.06684759e-01f, -7.43032172e-02f, -4.35813591e-02f, -5.63904755e-02f, -2.39081785e-01f,
  -6.79591224e-02f, 5.95701374e-02f, -7.39042312e-02f, -3.65740433e-02f, 9.72495526e-02f, 6.99284254e-03f, -5.96246868e-02f, 2.90648500e-03f, 3.30901928e-02f, 7.28532160e-03f,
  -5.52251488e-02f, -1.53314499e-02f, 2.94264872e-02f, -1.13780260e-01f, -2.04791069e-01f, -1.28905758e-01f, -1.53353671e-02f, -2.17587590e-01f, -4.74795103e-02f, 4.10158522e-02f,
  -5.92893437e-02f, 4.70834672e-02f, 8.38812720e-03f, -7.72646964e-02f, -2.82721277e-02f, -5.03286459e-02f, -2.35728025e-02f, 1.00009695e-01f, 2.75810007e-02f, -3.31225954e-02f,
  1.19508050e-01f, -7.14017777e-03f, 2.59640301e-03f, -8.10381249e-02f, -7.69297034e-02f, -2.25424694e-04f, -1.62137598e-02f, 1.41464332e-02f, 7.00062560e-03f, 6.06335625e-02f,
  4.57269140e-02f, 2.46237200e-02f, -8.91817175e-03f, 4.70684990e-02f, -2.13468471e-03f, -5.21036908e-02f, -9.47016776e-02f, -1.20834652e-02f, 8.82842951e-03f, 5.74635677e-02f,
  -8.91921371e-02f, -7.13534802e-02f, -1.08769853e-02f, -7.13732690e-02f, 3.06921583e-02f, 1.82405226e-02f, -2.07391873e-01f, -1.28734872e-01f, -1.44380331e-01f, -2.45279610e-01f,
  9.81650800e-02f, 1.81927755e-01f, -6.21865457e-03f, 9.91090909e-02f, 1.90064330e-02f, 7.68200979e-02f, 3.20222914e-01f, 2.25336716e-01f, 2.21388042e-02f, 3.42478454e-02f,
  -8.04831088e-02f, -1.06458694e-01f, -8.81244019e-02f, 2.72317752e-02f, 1.75817207e-01f, 2.16373786e-01f, 1.51232079e-01f, 1.39960255e-02f, -3.50165777e-02f, 1.08408608e-01f,
  -2.77467351e-02f, 1.43687809e-02f, -4.66013812e-02f, 6.04719520e-02f, 5.01294583e-02f, -1.25703782e-01f, 1.74941048e-02f, -4.12966907e-02f, 7.00612217e-02f, 1.18913472e-01f,
  -2.80923564e-02f, 1.42496854e-01f, -1.14504851e-01f, -2.07969189e-01f, -1.49445206e-01f, -3.81643847e-02f, 4.15171012e-02f, -2.58840192e-02f, -1.98697671e-01f, -1.21786021e-01f,
  1.68039296e-02f, -5.69614135e-02f, 1.48391649e-02f, 7.17163160e-02f, 2.61867791e-03f, 5.40668704e-02f, 1.53956473e-01f, 4.07290198e-02f, 3.46721858e-02f, -1.48954540e-02f,
  8.49902779e-02f, -1.24601834e-01f, 3.98539603e-02f, -1.64088886e-03f, 1.26351282e-01f, -3.91243659e-02f, 4.02991027e-02f, -2.38676444e-02f, 7.54696280e-02f, 6.67888075e-02f,
  -1.76087722e-01f, -6.05749004e-02f, 8.25530440e-02f, -3.08567043e-02f, -4.37865146e-02f, -5.81567325e-02f, 9.57764164e-02f, 5.64186461e-02f, 1.29720997e-02f, -7.35571794e-03f,
  -1.20283246e-01f, -5.75436279e-02f, 1.39350938e-02f, 7.44695961e-02f, -6.69717342e-02f, -3.20508070e-02f, 1.74102843e-01f, 1.22318015e-01f, -2.26986278e-02f, -9.49878618e-02f,
  -4.85376641e-02f, 4.06963332e-03f, 6.34418754e-03f, 1.17045492e-01f, -9.22582522e-02f, 6.10253867e-03f, -5.60705774e-02f, 4.52372544e-02f, -6.05868883e-02f, -2.60205436e-02f,
  -3.00952233e-02f, -1.39691129e-01f, -4.52125743e-02f, -1.30699083e-01f, -5.02514802e-02f, -1.67289436e-01f, 1.16647920e-03f, -1.68967292e-01f, -1.64173558e-01f, -1.47612751e-01f,
  -1.38039235e-02f, -5.05601354e-02f, 7.19094798e-02f, 9.50127468e-02f, -5.72358370e-02f, -2.42430866e-02f, -6.61203191e-02f, 4.75749113e-02f, -2.55164094e-02f, -1.75603151e-01f,
  2.70787720e-02f, 6.87924260e-03f, -1.34549290e-01f, 3.46378647e-02f, -6.15431592e-02f, -1.94571689e-01f, -1.65645391e-01f, -9.36906859e-02f, -1.80893078e-01f, -1.11265620e-02f,
  -2.72459328e-01f, -4.31333780e-02f, 1.47096395e-01f, 1.17456213e-01f, 2.43196353e-01f, 2.12555602e-01f, 3.26966971e-01f, 1.12140842e-01f, -6.50872216e-02f, -9.24412068e-03f,
  -2.45917700e-02f, -1.58305019e-01f, -8.80194753e-02f, -8.41789246e-02f, -1.24864824e-01f, 2.09297508e-01f, 1.98242724e-01f, -5.10627367e-02f, 5.84738255e-02f, 1.16191655e-01f,
  9.21545699e-02f, -1.46948472e-01f, -2.45605722e-01f, -1.47237346e-01f, 1.27983019e-01f, 5.98667227e-02f, 7.99868181e-02f, -1.43540308e-01f, -6.58013150e-02f, 2.00100560e-02f,
  -1.57027051e-01f, -1.93866253e-01f, 1.79151654e-01f, -1.33556724e-02f, -9.66911837e-02f, -1.14356928e-01f, -6.14373796e-02f, 4.33327407e-02f, -1.71976000e-01f, -2.17686951e-01f,
  2.23002266e-02f, -8.25680047e-02f, -2.53442638e-02f, -9.81931314e-02f, -1.24223404e-01f, 5.88915423e-02f, -1.45946085e-01f, -1.66374937e-01f, -1.02002054e-01f, -2.82417983e-01f,
  2.35635955e-02f, -6.01162128e-02f, -1.70052916e-01f, -3.27751711e-02f, -6.04467988e-02f, -1.03421241e-01f, -2.57752538e-02f, -1.57065421e-01f, -8.03639088e-03f, -1.05775319e-01f,
  -5.14285378e-02f, -3.33187170e-02f, -1.12203220e-02f, 1.06250755e-01f, -2.46974118e-02f, 5.31788021e-02f, -7.85544217e-02f, -4.20709476e-02f, 6.38919249e-02f, 2.76122941e-03f,
  4.62585427e-02f, -1.43965617e-01f, -7.36028925e-02f, -2.95858085e-02f, -2.54996642e-02f, -4.00231145e-02f, -5.89335933e-02f, 1.33234352e-01f, 5.72241098e-02f, -1.34477377e-01f,
  -6.47188649e-02f, 3.65245156e-02f, 8.40466321e-02f, -6.08069934e-02f, 5.67187145e-02f, -1.26541294e-02f, 3.70451175e-02f, -1.57685541e-02f, 1.62543952e-02f, 8.35606363e-03f,
  -2.07451880e-01f, -7.99498055e-03f, -5.67189269e-02f, -3.84382270e-02f, 5.64638264e-02f, -9.29725841e-02f, -4.78421859e-02f, -2.09027492e-02f, -8.66594166e-02f, -4.40606140e-02f,
  5.63737638e-02f, -2.26815995e-02f, 3.11613828e-02f, 6.75898418e-02f, 4.65227924e-02f, -3.47759984e-02f, -7.88980126e-02f, 1.11702420e-01f, 2.71225460e-02f, 2.73397099e-02f,
  1.23353869e-01f, 4.53715175e-02f, 4.23207879e-02f, -3.64723280e-02f, -9.87352580e-02f, 9.98045225e-03f, 1.32958293e-01f, 1.47342030e-02f, 1.36817068e-01f, 1.35661200e-01f,
  1.60763681e-01f, 9.02389362e-02f, -1.48023590e-01f, 1.08395860e-01f, -1.10625751e-01f, -1.59180596e-01f, 2.07823575e-01f, 1.21382037e-02f, -2.27167960e-02f, 2.54358560e-01f,
  -3.38273644e-02f, -2.18491450e-01f, -1.80865988e-01f, -2.11014405e-01f, -2.05023468e-01f, 1.00999467e-01f, 2.10075323e-02f, -7.82284588e-02f, -2.75895655e-01f, -1.85275182e-01f,
  3.99788767e-02f, 6.80612549e-02f, 5.88318668e-02f, -7.00168163e-02f, -5.08345552e-02f, 3.45883798e-03f, 1.91259533e-02f, 2.31397450e-02f, -2.15972021e-01f, 8.98832269e-03f,
  6.07301034e-02f, -2.81154245e-01f, -1.87057152e-01f, -1.98196694e-01f, -1.32353315e-02f, -1.17972478e-01f, -1.34315789e-01f, -1.85324699e-01f, -7.18239099e-02f, -5.95124774e-02f,
  -1.71364039e-01f, -1.05057042e-02f, -1.35128543e-01f, -1.57085687e-01f, -1.29558340e-01f, -1.64824471e-01f, -9.50410441e-02f, -1.75902501e-01f, -1.50027618e-01f, -9.31215286e-02f,
  -1.33660674e-01f, -2.59805471e-02f, -2.08647712e-03f, -1.91752450e-03f, -8.96173045e-02f, -2.42056116e-01f, -1.02783874e-01f, -1.26833141e-01f, -4.52527478e-02f, 3.03780466e-01f,
  9.22519565e-02f, 5.54866791e-02f, 1.39961569e-02f, 9.89638716e-02f, 1.55791834e-01f, 7.24783316e-02f, 7.25378767e-02f, 1.97182953e-01f, -1.33930030e-03f, 4.89591919e-02f,
  1.04479671e-01f, -7.97612071e-02f, 1.57113597e-02f, -2.25782022e-02f, 1.07302237e-02f, -1.31296203e-01f, -4.91290865e-03f, 1.97124884e-01f, 7.00342376e-03f, 4.44999002e-02f,
  -1.01682089e-01f, -9.97317433e-02f, -9.00324211e-02f, 2.01641340e-02f, -2.95268577e-02f, -5.04244193e-02f, -9.65964049e-02f, -1.39961271e-02f, -7.74956644e-02f, -5.75593114e-02f,
  2.79287070e-01f, -2.66970634e-01f, 8.30120295e-02f, -8.80280789e-03f, -5.61211444e-02f, -1.73757046e-01f, 4.69598249e-02f, -1.53865993e-01f, 8.68388340e-02f, 1.13510944e-01f,
  -2.77092233e-02f, 6.11325502e-02f, 8.05448070e-02f, -7.09095523e-02f, -4.86755334e-02f, -2.29301676e-02f, 3.85944657e-02f, 2.46883947e-02f, -2.81234439e-02f, -3.21598239e-02f,
  1.20235935e-01f, 1.40415147e-01f, 2.39755124e-01f, 1.28841281e-01f, -2.13361606e-02f, 3.71190272e-02f, 1.12997249e-01f, 1.72675420e-02f, 1.24364331e-01f, 3.79551917e-01f,
  1.93177238e-01f, -2.32878029e-01f, -4.50475095e-03f, -7.26814047e-02f, 3.24502438e-02f, 1.75035596e-01f, 1.92789063e-01f, -4.29409035e-02f, -1.85167372e-01f, -1.54430404e-01f,
  -2.69584823e-02f, 5.05996272e-02f, -3.71405259e-02f, -6.26239553e-03f, -6.46071732e-02f, 2.87752002e-02f, -3.88627388e-02f, 5.74309416e-02f, 2.95202374e-01f, 9.51320902e-02f,
  -5.74935190e-02f, -3.53778824e-02f, -1.05369454e-02f, -1.38507307e-01f, -1.69885382e-01f, 8.75237733e-02f, 1.04422811e-02f, -8.26190561e-02f, -1.35824516e-01f, -1.42759293e-01f,
  2.21327454e-01f, -3.41139495e-01f, 9.58332717e-02f, -6.31424636e-02f, 6.16705753e-02f, -8.63770917e-02f, 1.10030763e-01f, -3.46051645e-03f, -5.31097502e-02f, 1.67318899e-02f,
  -3.34066898e-02f, -1.96740404e-01f, 5.24900481e-02f, -1.53388098e-01f, -4.70490046e-02f, -1.41885564e-01f, -1.42057255e-01f, -1.44750655e-01f, -1.73856989e-01f, -3.36151905e-02f,
  -2.75351703e-01f, -4.05692942e-02f, 3.74923716e-03f, -5.56408092e-02f, 1.17156806e-03f, -1.06811235e-02f, -1.92051604e-01f, -1.23552449e-01f, -1.49858177e-01f, 2.03140639e-02f,
  -7.54068270e-02f, 7.86381066e-02f, 6.49544075e-02f, 7.26046562e-02f, -2.36382466e-02f, 1.15648203e-01f, 6.27825921e-03f, -8.78694654e-02f, -4.24203370e-03f, 1.12716995e-01f,
  4.95069660e-02f, -1.17305024e-02f, 1.59246072e-01f, 9.97893661e-02f, 8.90680477e-02f, 1.09151110e-01f, 3.18369865e-02f, -8.54979232e-02f, 9.84511059e-03f, 9.60765779e-02f,
  1.60631552e-01f, 1.11085005e-01f, 3.87802087e-02f, 1.53769612e-01f, 3.59554123e-03f, 1.23199329e-01f, 1.03584915e-01f, -5.55805229e-02f, 3.35527249e-02f, -5.36965206e-02f,
  2.14159295e-01f, -1.75046042e-01f, 1.97621509e-01f, 5.67537211e-02f, 1.32744178e-01f, 2.90157385e-02f, 6.48132414e-02f, 7.44206756e-02f, 6.16798736e-02f, 1.06580578e-01f,
  -7.61514828e-02f, -3.80877825e-03f, 3.76749709e-02f, 3.56852077e-02f, 1.40310973e-01f, 4.26339731e-02f, 3.64077799e-02f, -1.51287233e-02f, -1.06184378e-01f, 1.47652905e-02f,
  -8.47367384e-03f, 1.09811157e-01f, 2.45379791e-01f, 2.09327713e-01f, 1.56327114e-02f, 1.33538529e-01f, 5.14827073e-02f, 6.53473586e-02f, 7.52209350e-02f, 2.10087389e-01f,
  1.08988017e-01f, 1.14833146e-01f, -1.45025134e-01f, 2.87328362e-01f, 1.07778274e-01f, -7.76733039e-03f, -1.85950249e-01f, -2.72709310e-01f, 1.07834429e-01f, 1.08880967e-01f,
  1.77647695e-01f, 8.01116228e-02f, 9.92012247e-02f, -2.73426503e-01f, -5.46597719e-01f, -2.05360845e-01f, -1.20360844e-01f, -1.72623679e-01f, -5.05131781e-01f, -3.11676353e-01f,
  -3.82505101e-03f, -4.93870340e-02f, -1.34907305e-01f, -1.39643446e-01f, 8.19428787e-02f, -1.05598932e-02f, 1.38516054e-01f, -3.39775309e-02f, -2.33719796e-02f, 9.88276899e-02f,
  -7.43205026e-02f, -3.39217074e-02f, -5.84214553e-02f, -1.45298953e-03f, 1.22388594e-01f, -6.70725433e-03f, 2.79037245e-02f, -9.73203331e-02f, 2.23537207e-01f, -6.70889243e-02f,
  8.70948136e-02f, 9.11082104e-02f, 5.81903495e-02f, 1.96112350e-01f, -1.65312160e-02f, 6.92796409e-02f, -8.37356225e-02f, -2.51682818e-01f, -1.50865838e-01f, -4.36667912e-02f,
  5.46684079e-02f, 1.02663219e-01f, -6.39907271e-02f, -4.89246063e-02f, -1.58140033e-01f, -2.29114182e-02f, -2.11819977e-01f, -2.02552304e-01f, -2.16041148e-01f, 2.14745011e-02f,
  1.40883341e-01f, 4.44534495e-02f, -1.74985956e-02f, -2.13068090e-02f, 1.04495674e-01f, -3.06800380e-02f, -7.26207718e-02f, 1.76351573e-02f, 6.08522296e-02f, 1.92848891e-02f,
  1.04707211e-01f, 9.15310457e-02f, 5.24992384e-02f, 5.06139733e-02f, -9.68371853e-02f, 6.51366869e-03f, -4.88390494e-03f, 6.03430765e-03f, -1.22604713e-01f, 3.43917608e-02f,
  -1.08922563e-01f, -7.78180882e-02f, 2.03245319e-02f, -1.20195411e-01f, -2.41847020e-02f, 2.43458208e-02f, 9.82180759e-02f, -1.26591265e-01f, -3.89741808e-02f, -2.99373753e-02f,
  8.09555724e-02f, -9.00729001e-02f, 3.34033258e-02f, -6.32219575e-03f, -1.51229817e-02f, -4.32897843e-02f, 1.15879223e-01f, 1.73835817e-03f, 1.78522542e-01f, 9.07149985e-02f,
  -1.35768466e-02f, 1.21197827e-01f, 9.86813530e-02f, 7.43613988e-02f, -1.08707704e-01f, -4.48491387e-02f, 1.21854037e-01f, -7.30902851e-02f, -1.81860045e-01f, 1.50071293e-01f,
  5.51233478e-02f, -7.24501833e-02f, 1.98973678e-02f, 6.01385115e-03f, 4.53357212e-02f, -1.23935051e-01f, -4.14092615e-02f, -1.31981581e-01f, -1.96220428e-01f, 1.07065842e-01f,
  -4.23962235e-01f, -2.55038589e-01f, -9.34012681e-02f, -2.74006486e-01f, 4.56611589e-02f, 1.21200942e-01f, -2.08138041e-02f, -2.04150807e-02f, -9.00791064e-02f, -1.20201722e-01f,
  7.75156394e-02f, 3.91364330e-03f, 3.68162654e-02f, 2.73762364e-02f, 1.59463733e-01f, -1.16306819e-01f, 2.89549045e-02f, 7.93341249e-02f, 3.12690705e-01f, 2.18376368e-01f,
  5.59701137e-02f, 1.34742679e-02f, -2.21509691e-02f, 9.09474939e-02f, -2.52660185e-01f, 1.99552644e-02f, -1.44163340e-01f, -8.45985040e-02f, -6.64802343e-02f, -2.81584531e-01f,
  -2.33502731e-01f, -1.47251606e-01f, 1.92264035e-01f, 9.48678777e-02f, -4.46400046e-02f, -3.90876085e-02f, -3.40442955e-02f, 1.43724177e-02f, -5.15723275e-03f, 7.63445050e-02f,
  -4.40988131e-02f, 6.36153370e-02f, 1.37851965e-02f, -4.16966667e-03f, -3.09922863e-02f, -6.91941679e-02f, 2.59209014e-02f, -4.68332656e-02f, -1.61387604e-02f, -1.55501887e-01f,
  2.01910194e-02f, -5.31985983e-02f, -4.57181670e-02f, -1.00167301e-02f, -1.58498630e-01f, 3.14068631e-03f, -8.88407007e-02f, 2.48279907e-02f, -1.10656186e-03f, -2.34315664e-01f,
  6.91287890e-02f, 7.11718798e-02f, 4.38010097e-02f, -2.71421182e-03f, -7.74025023e-02f, 1.28176481e-01f, 2.74921693e-02f, 9.17894840e-02f, 6.50427211e-03f, -1.86553709e-02f,
  -2.95140557e-02f, 6.65141344e-02f, 1.04028635e-01f, -5.60137257e-03f, -6.26345426e-02f, 1.56983584e-02f, 1.67222749e-02f, 1.58878285e-02f, -2.87601352e-03f, -1.40511533e-02f,
  -1.94144025e-02f, 7.65934214e-03f, 3.03759631e-02f, 3.27867121e-02f, 1.58632956e-02f, 2.74540228e-03f, -7.67362043e-02f, -8.94161221e-03f, 9.31946095e-03f, -8.55857134e-02f,
  -1.94740310e-01f, 1.48661822e-01f, -3.95800062e-02f, -9.06363204e-02f, -1.33008948e-02f, 3.97706521e-04f, -1.05931409e-01f, 2.24976353e-02f, -5.59933297e-02f, -3.41151729e-02f,
  -9.66187492e-02f, -1.74905465e-03f, -1.37178600e-01f, 6.82587475e-02f, 2.54589282e-02f, -1.03356987e-01f, 4.42138128e-02f, 9.56089422e-02f, 1.22072725e-02f, -1.45046607e-01f,
  -8.11287239e-02f, -4.09947224e-02f, -1.19942978e-01f, -9.00355801e-02f, -2.28548199e-01f, -2.48994958e-02f, -2.91814264e-02f, -1.45534530e-01f, -1.22841805e-01f, -1.97607309e-01f,
  -5.19159377e-01f, 1.44836772e-02f, -1.30727232e-01f, -3.61542910e-01f, -1.49362937e-01f, -1.04863860e-01f, -7.96344280e-02f, 3.59795615e-03f, -8.57774727e-03f, -2.87624776e-01f,
  -7.23237097e-02f, -2.30238829e-02f, -9.07059351e-04f, -1.07510788e-02f, 5.08543737e-02f, -1.92146912e-01f, -3.30641747e-01f, -1.71154439e-01f, 8.28105211e-02f, 2.72057168e-02f,
  -1.63954809e-01f, -1.23106338e-01f, -5.15589789e-02f, -2.07290472e-03f, -6.63861558e-02f, 1.10826947e-01f, -1.20748758e-01f, -6.93514869e-02f, 1.05004951e-01f, -9.33699012e-02f,
  -1.88216195e-01f, 2.73588225e-02f, 2.05910560e-02f, 4.43841927e-02f, -5.55222072e-02f, 2.84917727e-02f, -1.78051308e-01f, -1.41146228e-01f, 1.79572012e-02f, 7.08699180e-03f,
  -1.55961871e-01f, 2.79353429e-02f, -7.86709860e-02f, -3.34963650e-02f, -1.55962884e-01f, -7.67873973e-02f, -8.76989439e-02f, 1.09894183e-02f, -4.07625623e-02f, 6.20535463e-02f,
  3.39431874e-03f, 3.18245366e-02f, 9.28697661e-02f, 1.60489455e-01f, 1.21035568e-01f, -7.17552006e-02f, 4.16937992e-02f, 2.38127425e-01f, 1.24465697e-01f, 9.57048237e-02f,
  -9.22808424e-02f, 1.04016319e-01f, -4.40330990e-02f, 1.60502009e-02f, 2.85379160e-02f, 1.15434183e-02f, -5.45837209e-02f, -2.22291443e-02f, -4.19195518e-02f, -8.95068794e-02f,
  -8.14363286e-02f, -1.01911537e-01f, 1.46050937e-02f, 9.30015405e-04f, -2.53597014e-02f, 8.38099327e-03f, -8.15839022e-02f, 3.08867618e-02f, -1.25575997e-02f, -6.00846335e-02f,
  1.12735480e-01f, 1.14208020e-01f, -1.35889184e-02f, 8.73538181e-02f, -6.51445836e-02f, -5.02783954e-02f, -2.76341550e-02f, 5.89800477e-02f, 1.33071840e-02f, -5.60072921e-02f,
  -2.29479402e-01f, -6.62490800e-02f, -1.88500673e-01f, 2.24796496e-02f, -7.80268386e-02f, 6.81522535e-03f, 5.55513129e-02f, 4.07163352e-02f, -1.40202001e-01f, -3.97839956e-02f,
  6.54448047e-02f, -1.31942511e-01f, 2.02937960e-03f, 3.65501344e-02f, -8.29026476e-02f, 1.07134143e-02f, 3.07144374e-02f, -5.63636757e-02f, 1.39773890e-01f, 1.17436767e-01f,
  1.82929039e-01f, 5.76825552e-02f, -4.63413596e-02f, -5.00389561e-02f, 1.56259596e-01f, 2.51463521e-02f, -3.46656106e-02f, 1.25846937e-01f, 9.28563252e-03f, -4.11563516e-02f,
  -2.26058215e-01f, -2.45072618e-01f, 1.77655853e-02f, -1.24923415e-01f, -2.26431966e-01f, -6.46157563e-02f, -1.78972974e-01f, -4.42810394e-02f, -1.19632697e-02f, -2.86463618e-01f,
  -1.63455740e-01f, -5.09472415e-02f, -9.47868749e-02f, 5.49764372e-02f, 4.43745516e-02f, -2.57742971e-01f, -2.08047971e-01f, 5.04366355e-03f, 2.22982302e-01f, 1.21400923e-01f,
  -1.49382623e-02f, 1.06015235e-01f, 1.43373474e-01f, 2.04220265e-01f, -1.75734028e-01f, 1.33372664e-01f, -2.83777192e-02f, 7.62124881e-02f, -4.42534275e-02f, -3.03074449e-01f,
  -2.85369545e-01f, -2.36177310e-01f, 6.79742359e-03f, -1.02613486e-01f, -2.19636727e-02f, -1.00718975e-01f, -4.47964109e-02f, -1.07562076e-02f, 4.78026755e-02f, -5.75270206e-02f,
  -6.61794320e-02f, -1.73487142e-02f, 2.20867693e-02f, -4.65014130e-02f, -2.37420537e-02f, -4.97610159e-02f, 1.07309684e-01f, 1.56615824e-02f, 3.41533385e-02f, -1.28474414e-01f,
  -2.33002380e-02f, -1.35748491e-01f, 1.75091531e-02f, 1.52366504e-01f, 1.18348822e-01f, 4.89628799e-02f, 5.11940755e-02f, 1.02271788e-01f, 1.89174443e-01f, -1.76401913e-01f,
  -2.44737919e-02f, 2.41442807e-02f, 6.87527517e-03f, -2.29482190e-03f, -9.11322385e-02f, 7.35961273e-03f, -3.45708840e-02f, -5.18772602e-02f, 1.08250730e-01f, 1.04395933e-02f,
  2.83069871e-02f, -7.61714950e-03f, -2.36332584e-02f, -2.35441010e-02f, 9.24469680e-02f, -5.03223948e-02f, 5.34148104e-02f, 4.84284051e-02f, 8.70845765e-02f, 3.82155702e-02f,
  5.08011058e-02f, -5.35706850e-03f, 6.92251548e-02f, 1.21358164e-01f, -1.00772232e-01f, -7.63238221e-02f, -5.65832667e-02f, -8.40414688e-02f, -5.11660092e-02f, -8.88359025e-02f,
  -3.84325869e-02f, 1.83519289e-01f, -1.33143365e-01f, -4.67053689e-02f, -2.23224647e-02f, -3.61508876e-03f, -9.52172279e-02f, 4.96146921e-03f, -6.01565540e-02f, -3.27407382e-02f,
  -6.55659661e-02f, -4.51293066e-02f, -2.63161585e-02f, 8.48654956e-02f, 7.08544478e-02f, -2.73497384e-02f, -7.34405443e-02f, -4.12170477e-02f, 7.83191249e-03f, -4.72817793e-02f,
  1.37261286e-01f, -1.08011000e-01f, -8.58153179e-02f, -1.06399082e-01f, 6.01437362e-03f, -4.24101204e-02f, -1.42251834e-01f, 2.43226793e-02f, -4.38846573e-02f, -2.75292009e-01f,
  -2.40687102e-01f, 2.23419338e-01f, -1.96085349e-02f, 1.72303721e-01f, -2.06068922e-02f, -2.85126001e-01f, -9.15955193e-03f, -5.04225567e-02f, 1.08517297e-01f, 2.76479393e-01f,
  1.07971720e-01f, -2.35203728e-02f, -3.01598571e-02f, -1.57176599e-01f, -2.31082022e-01f, 2.37707198e-02f, -1.37361847e-02f, -3.54797691e-01f, -5.66688657e-01f, -3.51802528e-01f,
  -2.69530207e-01f, -2.47455508e-01f, -1.61022663e-01f, -1.71454504e-01f, 4.39568870e-02f, -2.10788444e-01f, -5.27710654e-03f, -5.66642508e-02f, -3.38953197e-01f, 2.70644762e-02f,
  1.15749098e-01f, -1.32728994e-01f, -1.38876632e-01f, -2.15567186e-01f, 1.14768825e-01f, -7.61946589e-02f, -6.30660430e-02f, 1.00849569e-01f, 7.60881454e-02f, 2.80234180e-02f,
  6.13558991e-03f, -6.62157731e-03f, 8.31180438e-02f, 8.35591555e-02f, -6.43668845e-02f, -4.03599590e-02f, 6.68179318e-02f, -8.97304527e-03f, 4.13425975e-02f, 1.90369964e-01f,
  2.29666308e-02f, -2.35055029e-01f, -8.09201524e-02f, -7.14122057e-02f, -6.00652061e-02f, -1.02899663e-01f, -9.77873281e-02f, -1.92445125e-02f, -5.53275384e-02f, 6.58482388e-02f,
  -1.63588636e-02f, 4.70755622e-02f, 6.07749373e-02f, -3.35376412e-02f, 9.70239565e-02f, 5.77885611e-03f, 7.52647221e-02f, 1.23339379e-03f, 5.63299023e-02f, 7.68611357e-02f,
  3.20236944e-02f, -9.62750167e-02f, 8.04598778e-02f, 3.27754989e-02f, -2.61958987e-02f, -3.24001126e-02f, -4.81121317e-02f, 1.28115833e-01f, -6.03236780e-02f, 6.75966442e-02f,
  1.63368303e-02f, 3.24030034e-02f, 3.39864306e-02f, 3.92802153e-03f, -1.24912091e-01f, 1.04433201e-01f, -4.19344604e-02f, -7.69385099e-02f, 6.72359914e-02f, 1.05312414e-01f,
  1.27892166e-01f, -3.89847279e-01f, 3.56714651e-02f, -1.35940686e-01f, 3.50926332e-02f, 5.69639616e-02f, 4.94242422e-02f, -5.32650948e-03f, 1.03839949e-01f, 9.06136408e-02f,
  5.98040856e-02f, 8.80093202e-02f, 1.27752870e-01f, 4.28970158e-02f, 3.80327329e-02f, -1.24590613e-01f, 1.45854428e-01f, 6.08797334e-02f, -2.05299705e-02f, 2.65278816e-01f,
  2.60076493e-01f, 8.43168348e-02f, 2.17356998e-02f, 3.55614051e-02f, 1.09193269e-02f, -1.21698655e-01f, -1.36064983e-03f, 4.10217494e-02f, -1.42559275e-01f, 1.93900838e-01f,
  -1.15516283e-01f, 9.93106142e-02f, 1.65351126e-02f, 6.18795641e-02f, 3.43099922e-01f, 8.83829892e-02f, 2.47582980e-02f, -2.17809185e-01f, -5.17957248e-02f, 9.76913124e-02f,
  1.41289636e-01f, 7.18662441e-02f, -6.65782467e-02f, -4.00100015e-02f, -2.69518256e-01f, 8.59801378e-03f, 2.40992978e-01f, -8.52723718e-02f, -2.14000404e-01f, -5.76480478e-03f,
  9.05792937e-02f, -2.84981634e-02f, -1.18244670e-01f, -1.74467623e-01f, 1.47453189e-01f, 9.63897482e-02f, 7.11187422e-02f, 1.40067279e-01f, 1.21752955e-01f, 3.25423777e-01f,
  -3.15442681e-02f, -1.13963209e-01f, 1.05271610e-02f, -2.55440883e-02f, 1.09903194e-01f, -5.59402853e-02f, -1.31402254e-01f, -2.36640692e-01f, 9.78439301e-02f, -7.29553252e-02f,
  1.07195966e-01f, -3.30159590e-02f, 8.30880702e-02f, -6.92749023e-02f, -3.80662121e-02f, -5.02346866e-02f, -1.63569123e-01f, -1.77342847e-01f, -1.76274061e-01f, -1.18892983e-01f,
  6.95065856e-02f, 1.83553919e-01f, -1.79998055e-02f, -1.00118518e-01f, -1.37390658e-01f, -7.99431279e-02f, -1.16509221e-01f, -6.18512854e-02f, -1.22427084e-01f, -1.60165370e-01f,
  -1.80602804e-01f, 1.35415152e-01f, 1.36440724e-01f, -6.92435354e-02f, 1.15892909e-01f, 1.59998640e-01f, -1.49404886e-03f, 5.87904863e-02f, 1.14101797e-01f, 1.04953520e-01f,
  9.88753978e-03f, 6.33124709e-02f, -8.31265897e-02f, -1.83995053e-01f, -1.01616398e-01f, 7.82914236e-02f, -9.71608832e-02f, -1.30596086e-01f, -1.45782217e-01f, -1.16961546e-01f,
  1.23727873e-01f, 5.71347140e-02f, -1.01157241e-01f, -5.13741449e-02f, -1.40862927e-01f, -1.03293017e-01f, -1.64337326e-02f, 4.98603098e-03f, -1.47800669e-01f, -3.25773694e-02f,
  -2.35527426e-01f, -1.38652846e-01f, -3.36317755e-02f, -6.92081749e-02f, 8.98960456e-02f, -3.77636440e-02f, 7.86454752e-02f, -3.88992690e-02f, -7.08104856e-03f, -3.91981900e-02f,
  -8.62221420e-02f, -5.56833707e-02f, 1.26170116e-02f, -1.46257281e-01f, -2.30084360e-02f, -1.13933273e-02f, 6.30098805e-02f, 8.01809877e-02f, 2.87192035e-03f, 6.53792312e-03f,
  1.14216030e-01f, -5.50498329e-02f, 6.03589974e-02f, 1.30841229e-02f, 1.70427021e-02f, -7.73251727e-02f, 1.84834395e-02f, -3.26558985e-02f, -2.18896434e-01f, -1.07490569e-01f,
  -6.39221445e-02f, -2.68164836e-03f, 8.68302211e-02f, 1.09798685e-01f, 1.03970505e-01f, -1.98676318e-01f, -2.70325482e-01f, -1.15080416e-01f, -1.07141718e-01f, -1.01709150e-01f,
  6.15495183e-02f, 1.42389894e-01f, 2.34985389e-02f, 5.48801050e-02f, -7.13765398e-02f, 8.42268392e-02f, 2.46606365e-01f, 6.63301572e-02f, -1.21410608e-01f, -1.25221729e-01f,
  1.74774796e-01f, -1.78476505e-03f, 1.56029994e-02f, -6.00254871e-02f, 1.10463738e-01f, 8.85751322e-02f, 7.69277140e-02f, 9.83450338e-02f, 4.18249629e-02f, 4.26854879e-01f,
  8.66331160e-02f, -1.70978576e-01f, -6.82464391e-02f, -1.51849449e-01f, -1.01027988e-01f, 8.71061161e-02f, -5.18287607e-02f, -4.14104313e-02f, -1.74149796e-02f, 2.23848000e-02f,
  4.54068817e-02f, -3.58491614e-02f, 3.09028081e-03f, -1.02552049e-01f, -1.58438608e-01f, -2.06441686e-01f, -5.44787683e-02f, 6.01039529e-02f, -4.89122830e-02f, -8.38098079e-02f,
  2.43303001e-01f, 2.67921817e-02f, -9.63763371e-02f, -4.25033234e-02f, 5.03770225e-02f, 7.94907138e-02f, -1.22978754e-01f, 1.35776065e-02f, -1.72469601e-01f, 5.97551093e-02f,
  5.24528436e-02f, -6.34686053e-02f, 3.32391914e-03f, -2.38732919e-02f, 7.19995648e-02f, 3.09059992e-02f, 1.54188499e-01f, 3.45616117e-02f, 7.81736299e-02f, 7.52544999e-02f,
  6.01969697e-02f, 1.05306514e-01f, 3.29547934e-02f, -6.21411838e-02f, 1.21988229e-01f, 7.31386915e-02f, -8.66467133e-02f, -8.75301585e-02f, 3.73837277e-02f, 5.79694007e-03f,
  -1.16643377e-01f, -8.75850320e-02f, 1.55142453e-02f, 1.77162234e-03f, 1.04647048e-01f, -6.72490671e-02f, 3.37314494e-02f, -1.16380982e-01f, -5.64156771e-02f, -3.51058058e-02f,
  -1.24865860e-01f, -4.98867296e-02f, -3.38591374e-02f, 3.41162854e-03f, -6.05702884e-02f, 6.49636760e-02f, 1.77688584e-01f, 5.87456999e-03f, -1.19829141e-01f, -1.93795785e-01f,
  -1.39144361e-01f, 1.13094077e-01f, -1.74871892e-01f, 2.56573479e-03f, -6.81285709e-02f, -2.84303483e-02f, -5.46833351e-02f, -8.57313126e-02f, -5.01330616e-03f, -6.64235950e-02f,
  6.78932592e-02f, -1.75758138e-01f, -9.33424756e-02f, -8.62584934e-02f, -5.02240099e-02f, -1.68105930e-01f, -1.07833140e-01f, -1.00802064e-01f, -2.09966719e-01f, -2.85738468e-01f,
  5.87967001e-02f, -2.11212218e-01f, -1.87583901e-02f, 2.34865457e-01f, 3.83379906e-01f, 1.42024606e-01f, -8.88116136e-02f, 3.09621617e-02f, 5.70251904e-02f, 5.44640385e-02f,
  8.85325968e-02f, 2.56057531e-01f, 2.57776320e-01f, 8.32700059e-02f, 2.76461635e-02f, -8.85375193e-04f, 1.71352863e-01f, 1.17497213e-01f, 4.35364358e-02f, 6.59437105e-02f,
  4.56147976e-02f, -1.63229182e-01f, -1.59885079e-01f, -1.63541234e-03f, -1.08926930e-01f, 1.24162540e-01f, -1.93851404e-02f, -1.02506094e-01f, -4.82337177e-02f, 3.09756398e-02f,
  1.75643563e-01f, -9.34435725e-02f, -4.22333926e-03f, -2.88082345e-04f, -1.43792659e-01f, -9.01963115e-02f, -6.70916438e-02f, -1.19380921e-01f, -9.17254165e-02f, -9.52841789e-02f,
  -5.96457422e-02f, -9.45492536e-02f, 2.86131748e-03f, 1.24510769e-02f, -1.28276289e-01f, -1.96233287e-01f, -1.74772397e-01f, -7.94440955e-02f, 1.27053931e-01f, 2.74728471e-03f,
  1.43420860e-01f, 6.14340939e-02f, 4.00190391e-02f, 5.29618710e-02f, 1.30706001e-02f, 1.32873282e-01f, 4.83918935e-02f, -1.05484881e-01f, 2.53683552e-02f, -7.03349188e-02f,
  1.34301171e-01f, 1.01916805e-01f, 3.10705714e-02f, 3.60829174e-03f, -1.57581363e-02f, 6.83536613e-03f, 7.86558613e-02f, 1.33256704e-01f, 6.69456497e-02f, -2.13720262e-01f,
  -2.22836267e-02f, 1.90374225e-01f, 1.08890980e-01f, -1.12409234e-01f, 5.71864359e-02f, 8.73374492e-02f, 3.73214744e-02f, -3.38721089e-02f, 1.33322282e-02f, -8.10211003e-02f,
  -9.58567336e-02f, -1.05734728e-01f, -2.25022547e-02f, -6.09064177e-02f, -2.36867857e-03f, 1.92911044e-01f, 1.50068760e-01f, -7.68953636e-02f, -3.50185558e-02f, -2.72695720e-01f,
  8.78443047e-02f, 8.16684589e-02f, 1.36436731e-01f, 3.41116227e-02f, -1.33733496e-01f, -1.32004485e-01f, -1.71820708e-02f, -6.85085282e-02f, 4.66491915e-02f, -6.62575290e-02f,
  -1.80372000e-01f, -7.36339539e-02f, -1.11895546e-01f, -3.47918868e-02f, -1.38216719e-01f, -1.75564453e-01f, -3.97592708e-02f, 1.68543026e-01f, 1.35208350e-02f, 5.94298430e-02f,
  -1.89381372e-02f, -1.31382225e-02f, 8.58582482e-02f, 4.50315914e-04f, 8.13960508e-02f, 1.71957627e-01f, -3.07867918e-02f, -3.00055444e-02f, 8.98123195e-04f, -1.26378372e-01f,
  2.86951572e-01f, 1.06299959e-01f, 1.00193582e-01f, 1.34438977e-01f, -1.62383810e-01f, 2.92055774e-02f, 6.00938462e-02f, 1.52786389e-01f, 1.16832696e-01f, 3.11054047e-02f,
  5.22932485e-02f, 2.24448368e-02f, -2.59118993e-02f, 7.48912320e-02f, 2.65863806e-01f, 1.13328166e-01f, 2.32360050e-01f, 1.78615704e-01f, 2.28359804e-01f, 1.76604524e-01f,
  4.08974551e-02f, 6.31963685e-02f, 7.29095042e-02f, 7.91493580e-02f, 8.74325633e-02f, 5.45022897e-02f, 5.71972467e-02f, -1.10490099e-02f, 8.37933421e-02f, 1.69530660e-01f,
  4.22469042e-02f, 1.81694582e-01f, -1.15526095e-01f, -9.70967561e-02f, -4.55080681e-02f, -3.58698405e-02f, -6.51829690e-02f, 3.17479149e-02f, -1.44835189e-01f, -1.61811128e-01f,
  -1.29865691e-01f, -1.45534314e-02f, -8.42076764e-02f, 1.55799575e-02f, -3.37598808e-02f, -6.21615502e-04f, 6.10905178e-02f, 2.43014589e-01f, 1.53729334e-01f, -2.37567630e-02f,
  -7.68378824e-02f, 1.58020612e-02f, -8.17970708e-02f, -1.12879612e-02f, 1.89116761e-01f, -3.36651839e-02f, -5.44498535e-03f, 5.99363744e-02f, 1.23834163e-01f, 4.67787459e-02f,
  1.84467062e-01f, 2.32818890e-02f, 1.27811134e-01f, 3.40494402e-02f, 7.39124119e-02f, 1.71186298e-01f, 8.44188258e-02f, 1.98861025e-02f, -9.38668789e-04f, -1.40355655e-03f,
  -9.08849239e-02f, -2.01915787e-03f, 1.06588237e-01f, 9.96363685e-02f, -8.72145295e-02f, 3.37804034e-02f, -2.55824775e-02f, -3.30225681e-03f, -1.09564271e-02f, -5.52451685e-02f,
  1.30993444e-02f, 1.41320694e-02f, -4.95245904e-02f, 4.58192686e-03f, 1.36164114e-01f, 1.27083391e-01f, -3.83736975e-02f, -1.13310125e-02f, 5.31743653e-02f, 5.91229685e-02f,
  -4.63323534e-01f, -1.08663402e-01f, 1.55647442e-01f, 8.32688361e-02f, -4.37313132e-02f, -2.59990264e-02f, -3.85571048e-02f, -1.85466826e-01f, -1.83707774e-01f, -7.70098269e-02f,
  -1.30998075e-01f, -1.90971233e-02f, 7.85835534e-02f, -4.89293784e-02f, -1.27711417e-02f, 1.26891835e-02f, 3.92889902e-02f, -3.74545008e-02f, 2.11075097e-02f, -2.01750025e-01f,
  -7.35973120e-02f, -8.63944367e-02f, -9.66332480e-02f, -1.09938812e-02f, -1.02207601e-01f, -1.12632684e-01f, -6.04292154e-02f, 1.55216260e-02f, 2.83014141e-02f, -6.96224123e-02f,
  -1.80383027e-01f, -2.69455850e-01f, 3.21766138e-02f, -1.64516997e-02f, 1.80587396e-01f, -1.82780437e-02f, -3.47092330e-01f, -2.23329067e-02f, 7.58754686e-02f, -2.03364700e-01f,
  -2.08525043e-02f, 7.39592910e-02f, -7.47544738e-03f, 7.85702989e-02f, -1.33292258e-01f, -2.72794038e-01f, -1.89662814e-01f, 1.26094706e-02f, 1.38429403e-01f, 1.20704070e-01f,
  -7.20014274e-02f, 1.04813345e-01f, 1.39564976e-01f, 1.61947548e-01f, -1.03502870e-01f, -5.24609610e-02f, 3.79593149e-02f, -6.37489632e-02f, 3.19902636e-02f, -1.71349153e-01f,
  -5.22537231e-02f, -7.35812411e-02f, -4.39249575e-02f, 3.53437625e-02f, -6.90656155e-02f, 3.36385285e-03f, -1.84226602e-01f, -7.04500005e-02f, 3.83185074e-02f, 1.49865486e-02f,
  -6.72378540e-02f, 5.63033186e-02f, 1.11671411e-01f, 2.77136546e-02f, -5.18974550e-02f, -2.36170664e-02f, 8.07470735e-03f, -4.82600443e-02f, -1.62198842e-02f, -8.68556276e-02f,
  2.36747824e-02f, -1.71913132e-02f, -7.11705536e-02f, -3.16445678e-02f, -1.47639483e-01f, -1.11510297e-02f, 9.16346833e-02f, -3.04742958e-02f, 8.59480351e-02f, -1.69977859e-01f,
  -5.76779537e-04f, 4.52262238e-02f, -1.49773015e-02f, -2.43071225e-02f, 6.22792616e-02f, 9.79873687e-02f, -6.31881431e-02f, 1.13328792e-01f, 8.30209032e-02f, -3.70218046e-02f,
  -2.08644681e-02f, 5.30485734e-02f, -7.89543018e-02f, 8.20759237e-02f, 1.50326118e-01f, 2.33158167e-03f, -4.54415791e-02f, 2.81777401e-02f, 2.51988564e-02f, 1.04447700e-01f,
  7.26007670e-02f, 5.26665635e-02f, -3.15755010e-02f, 7.21441209e-02f, 7.35384673e-02f, -7.87915941e-03f, 1.54404854e-02f, 8.67554173e-03f, 1.12680338e-01f, 1.13537729e-01f,
  1.42465336e-02f, 1.94819719e-01f, -2.52926469e-01f, -1.90328974e-02f, -6.87598996e-03f, -2.07977500e-02f, 3.64918374e-02f, 3.30164060e-02f, -6.49210364e-02f, -1.75229162e-01f,
  -8.19400027e-02f, -2.69194897e-02f, -1.55668491e-02f, 7.75466487e-02f, 2.79470673e-03f, 1.58646125e-02f, -6.28411844e-02f, 1.18235685e-03f, 7.37514347e-02f, -1.02566421e-01f,
  -8.11164379e-02f, -1.40453234e-01f, -1.49312899e-01f, -1.43007696e-01f, -1.76698789e-01f, -1.60018831e-01f, 2.81878933e-02f, -1.12159677e-01f, -1.50388535e-02f, -1.86815366e-01f,
  -4.77843732e-01f, 1.59145445e-01f, 1.30224124e-01f, -1.47849560e-01f, -8.08128342e-03f, 7.87578300e-02f, 1.04498357e-01f, 1.66728690e-01f, 1.48038447e-01f, 1.99447066e-01f,
  2.11684227e-01f, -1.53285041e-01f, 4.52995002e-02f, -5.56386784e-02f, -1.96192801e-01f, 1.57076061e-01f, -2.38897167e-02f, -3.19611192e-01f, -3.79004061e-01f, -1.76082313e-01f,
  -1.94881007e-01f, -3.03103268e-01f, -2.46783301e-01f, -1.60737947e-01f, -5.12355641e-02f, -1.50139555e-01f, -9.29110125e-03f, -9.01469216e-02f, -8.46261010e-02f, 7.76552316e-03f,
  7.91980252e-02f, 5.68889938e-02f, -1.24445774e-01f, -1.79625943e-01f, -1.16837271e-01f, -1.51497507e-02f, -7.69712105e-02f, -2.22036447e-02f, -4.87026162e-02f, 1.04538254e-01f,
  -1.22010082e-01f, -9.83599853e-03f, -1.84294894e-01f, 1.37184709e-02f, -1.28865600e-01f, 3.81867774e-02f, 1.29157871e-01f, 6.83993995e-02f, 1.45073667e-01f, 6.69392943e-02f,
  9.51164439e-02f, 6.66420488e-03f, 7.60582928e-03f, 9.89746153e-02f, 1.39988482e-01f, 3.19665335e-02f, 1.34759154e-02f, 6.25852495e-02f, 5.81827888e-04f, 6.23527430e-02f,
  1.23677291e-02f, -1.11850739e-01f, 2.93107796e-02f, 7.49074295e-02f, -2.29346100e-02f, 1.20809458e-01f, -5.62729314e-02f, 2.12697200e-02f, -1.38757750e-01f, 7.84032941e-02f,
  2.56547667e-02f, -3.88002098e-02f, -3.28647383e-02f, 7.59984627e-02f, 1.12186201e-01f, 3.81132588e-02f, -9.99710858e-02f, 2.33712476e-02f, 2.56046038e-02f, 2.37088893e-02f,
  -6.54624179e-02f, 1.63488314e-02f, 1.29071455e-02f, -1.63754504e-02f, -7.54245073e-02f, 7.38453679e-03f, -4.23561819e-02f, -5.09574404e-03f, 4.14683931e-02f, -9.58441198e-03f,
  -2.22538963e-01f, -1.09711036e-01f, 7.73166567e-02f, -1.17470644e-01f, 7.69920764e-04f, 1.42600715e-01f, -1.35798857e-01f, 1.09938875e-01f, -1.71107706e-02f, -1.43800169e-01f,
  -9.68605503e-02f, -9.62465927e-02f, -1.24135539e-01f, 1.14943981e-01f, -1.12185828e-01f, 1.42206959e-02f, -5.71471602e-02f, -3.84533219e-02f, -3.91759351e-02f, 3.58631536e-02f,
  1.42644137e-01f, 7.38526359e-02f, -4.62542512e-02f, 5.44201806e-02f, 2.14699749e-02f, -9.94766131e-02f, 1.62413996e-02f, -1.14298714e-02f, 3.92341129e-02f, 1.89891860e-01f,
  -5.89260221e-01f, -1.26285285e-01f, -1.55173287e-01f, -3.72877896e-01f, -1.33565918e-01f, -4.49661128e-02f, 1.48789167e-01f, 4.63249199e-02f, -2.40145385e-01f, -1.05364978e-01f,
  5.61140068e-02f, -3.13244909e-02f, 1.32164229e-02f, 1.98872611e-01f, 5.44466136e-04f, -7.95147195e-02f, -9.69931111e-02f, -6.17315769e-02f, -2.34082993e-02f, 1.30705327e-01f,
  1.12630658e-01f, 7.07891881e-02f, -1.41512468e-01f, 2.37606745e-02f, 4.73156795e-02f, 2.09043756e-01f, 1.35287642e-01f, -3.23519930e-02f, 1.73909754e-01f, 2.22907756e-02f,
  2.41439402e-01f, -1.22690745e-01f, 1.24175427e-02f, -1.25693992e-01f, -7.25314617e-02f, -1.28857464e-01f, 7.09893554e-02f, -6.86034337e-02f, -1.40241191e-01f, 6.64375350e-02f,
  -8.80763456e-02f, 3.23065668e-02f, 1.39568793e-02f, 7.28107523e-03f, 3.24665830e-02f, -7.35964328e-02f, -1.00925185e-01f, -2.75773313e-02f, -5.69176078e-02f, 1.81265727e-01f,
  -8.10909718e-02f, -6.50468245e-02f, 2.19223276e-02f, 2.09690839e-01f, 1.01172641e-01f, -5.37969405e-03f, 5.48953824e-02f, 2.86912844e-02f, 5.61535992e-02f, 2.60893870e-02f,
  -9.83036961e-03f, 5.27736209e-02f, -2.92639267e-02f, 4.86721806e-02f, 1.93342194e-02f, 1.39623329e-01f, -2.97207423e-02f, 6.94182813e-02f, 1.34723131e-02f, 1.69429462e-02f,
  6.67377710e-02f, -7.14829937e-02f, 1.87177852e-01f, -4.85122241e-02f, 7.84869194e-02f, -7.52526820e-02f, -1.54134125e-01f, 9.68501866e-02f, 9.84884566e-04f, -2.60116905e-02f,
  -6.39490783e-02f, -7.23431036e-02f, -8.01456571e-02f, 1.51528776e-01f, -3.74127775e-02f, -2.94637140e-02f, -1.18909895e-01f, -3.69326919e-02f, -1.09834019e-02f, -8.61006901e-02f,
  1.12149574e-01f, -1.46816432e-01f, 8.62958003e-03f, -7.44731650e-02f, -8.39722753e-02f, -9.00182724e-02f, -1.13715984e-01f, -1.03441947e-04f, -1.40694275e-01f, 2.37355884e-02f,
  -9.83149931e-02f, 8.66525993e-02f, -4.53043468e-02f, -9.06886384e-02f, 9.16714817e-02f, -1.06466912e-01f, -8.82195681e-02f, -4.61438969e-02f, 2.24791840e-02f, 1.49316061e-02f,
  -1.12621352e-01f, -1.12303257e-01f, -7.86762387e-02f, 3.39157507e-02f, -1.62514485e-02f, 4.73915748e-02f, 1.08419850e-01f, -7.62429237e-02f, 7.02851564e-02f, 3.91557328e-02f,
  -6.61272407e-01f, 1.53283268e-01f, 1.21383913e-01f, -3.20622623e-01f, -1.19355612e-01f, -9.33617726e-02f, 5.27925901e-02f, -2.24707410e-01f, -3.27755988e-01f, -5.35545265e-03f,
  9.48603377e-02f, 7.29647949e-02f, 2.16626320e-02f, 1.28331333e-01f, 1.44421160e-01f, 8.53574947e-02f, -1.68059781e-01f, -7.29854777e-02f, 3.41788270e-02f, 6.54993057e-02f,
  3.76907028e-02f, -3.18308890e-01f, -3.36914033e-01f, -2.29906708e-01f, -2.32024163e-01f, 8.95598345e-03f, -1.05309159e-01f, -2.68752247e-01f, -7.45424069e-03f, -2.58240640e-01f,
  2.39088416e-01f, -7.25061968e-02f, -5.35839573e-02f, -5.07354327e-02f, -5.42526972e-03f, -4.73764949e-02f, 4.01154831e-02f, 1.41036715e-02f, -3.67552713e-02f, 6.70084953e-02f,
  -4.91820462e-02f, 7.31421858e-02f, -3.26768495e-02f, -5.31494357e-02f, -4.53727841e-02f, 6.21737279e-02f, -5.45243695e-02f, -9.14543644e-02f, -6.63016438e-02f, 1.02283895e-01f,
  -1.41911581e-01f, -1.02735028e-01f, 3.85944843e-02f, -9.69828889e-02f, -1.19863786e-01f, -2.53343862e-02f, -2.79912632e-02f, -1.28693521e-01f, 1.22617949e-02f, -5.47680147e-02f,
  -3.73184606e-02f, 6.09101029e-03f, 9.28753987e-02f, -2.73758452e-02f, 1.10356510e-01f, -3.81528437e-02f, 5.42503521e-02f, 5.07623218e-02f, -5.32315373e-02f, 7.27322698e-03f,
  6.80943802e-02f, 5.10477601e-03f, 9.90632996e-02f, -5.02102487e-02f, 3.95240039e-02f, -1.17940418e-02f, 2.88050976e-02f, 1.27431415e-02f, -6.72857165e-02f, -7.75093138e-02f,
  3.27394553e-03f, 1.65843833e-02f, -3.08977906e-02f, 8.19229893e-03f, 3.32325846e-02f, 3.01365741e-02f, -6.42325357e-02f, 4.91649397e-02f, 5.49441874e-02f, 1.18794683e-02f,
  -6.59617921e-03f, 9.29020941e-02f, 9.30964388e-03f, 6.55746385e-02f, -1.95526518e-02f, 3.90109867e-02f, -3.40295695e-02f, 1.71404973e-01f, 4.35707234e-02f, 1.01420805e-01f,
  -2.08432190e-02f, 2.04370078e-02f, -3.53897735e-02f, -1.29796693e-03f, 6.57720938e-02f, 7.46461153e-02f, 2.14472059e-02f, -6.44054823e-03f, -2.81613469e-02f, -1.13819614e-02f,
  6.83242604e-02f, -6.93108663e-02f, -8.54348950e-03f, 6.75958022e-02f, 3.07744998e-03f, 4.18557003e-02f, 1.97305545e-01f, -1.45882480e-02f, 1.11604244e-01f, 5.62589765e-02f,
  8.47238302e-01f, -5.81432767e-02f, -3.04409228e-02f, 1.55913249e-01f, -1.15653813e-01f, 2.10554563e-02f, 1.36388540e-01f, 1.28073752e-01f, 9.69683528e-02f, -2.57976889e-03f,
  1.78329289e-01f, 1.49810269e-01f, 8.05127099e-02f, -4.43132501e-03f, 3.70672680e-02f, -7.08957165e-02f, -2.41537109e-01f, -7.54961371e-03f, 3.91472727e-02f, 1.67231839e-02f,
  -6.61918744e-02f, -6.89158514e-02f, 9.98187289e-02f, 3.24367769e-02f, -1.78968549e-01f, -9.33475420e-02f, -1.39033675e-01f, -2.80797239e-02f, -1.64716661e-01f, -2.92990267e-01f,
  -2.52733171e-01f, 1.54055864e-01f, 6.01312183e-02f, 3.23838070e-02f, 1.58617366e-02f, 7.61891976e-02f, 1.25235105e-02f, 2.04287027e-03f, -1.45441908e-02f, -1.52926326e-01f,
  -1.45508036e-01f, 4.46347706e-02f, 1.41335770e-01f, -2.81085772e-03f, 1.82029493e-02f, 3.74545678e-02f, 9.50101465e-02f, 4.93466068e-05f, -5.01544401e-03f, 2.64971098e-03f,
  -4.89945803e-03f, 3.17998254e-03f, 5.52050136e-02f, 3.67961302e-02f, 1.41699865e-01f, -3.09789367e-03f, -4.58816029e-02f, 2.53455061e-02f, 1.45084679e-01f, 1.74914196e-01f,
  -1.36393473e-01f, 5.76964878e-02f, 3.23322117e-02f, 1.67066559e-01f, 2.07659528e-01f, 1.26060441e-01f, -7.38160983e-02f, 7.82385468e-02f, 1.93787783e-01f, 1.21600039e-01f,
  -2.30854452e-02f, 9.92150307e-02f, 4.12039347e-02f, 7.97647685e-02f, -3.24537307e-02f, 7.21965209e-02f, -1.42662853e-01f, -3.03732753e-02f, -4.48893644e-02f, -7.36729577e-02f,
  8.63897204e-02f, -5.14687933e-02f, -1.50282845e-01f, -1.98403135e-01f, -4.96545024e-02f, -9.30726528e-02f, -9.68526155e-02f, -2.98688058e-02f, -4.46411548e-03f, -6.04547113e-02f,
  -1.17316902e-01f, 1.33099571e-01f, 2.27635168e-02f, -4.94539253e-02f, -1.14381634e-01f, 1.74803741e-03f, 8.12294427e-03f, -1.93675533e-01f, -2.16070205e-01f, -2.02808276e-01f,
  -9.05517638e-02f, -2.21998263e-02f, 1.36649450e-02f, 3.53105068e-02f, 5.39124124e-02f, -2.86198780e-02f, 7.93832839e-02f, 9.35833976e-02f, -9.44375172e-02f, -9.98417735e-02f,
  -7.77040794e-02f, -2.57253684e-02f, 1.31995544e-01f, 8.96531343e-02f, 1.09663539e-01f, 4.20277044e-02f, 6.61312044e-02f, -8.45283568e-02f, 7.76413381e-02f, 1.30315945e-01f,
  -4.11564559e-01f, -1.85050085e-01f, 2.11291298e-01f, -2.41398185e-01f, -1.72411144e-01f, -4.32690680e-02f, -1.85146138e-01f, 3.85416858e-02f, -8.72896090e-02f, -2.28795424e-01f,
  -1.25883147e-01f, -2.85936799e-02f, -1.77833121e-02f, 7.00429231e-02f, -3.93792987e-02f, -3.26147705e-01f, -2.46256277e-01f, 1.02718780e-02f, 1.86407700e-01f, 1.58739497e-03f,
  -1.34523898e-01f, -1.28164187e-01f, -2.08281465e-02f, 1.55026406e-01f, -1.31428659e-01f, 1.81237102e-01f, 1.65080756e-01f, 2.35617198e-02f, 7.17877373e-02f, -7.07505271e-02f,
  -4.33045067e-03f, -1.45221487e-01f, 8.57441202e-02f, -4.59268987e-02f, -3.17477882e-02f, -1.02711402e-01f, 9.36336517e-02f, -4.71104383e-02f, 4.15864736e-02f, -1.12089373e-01f,
  -1.51989281e-01f, -4.66129705e-02f, 6.81125671e-02f, -2.46809702e-02f, -6.97459206e-02f, -1.38682104e-03f, 2.71655414e-02f, -1.10398531e-01f, 2.16062982e-02f, -9.28925946e-02f,
  -1.86255649e-01f, -1.13123439e-01f, -2.26009339e-02f, 1.46036178e-01f, 7.89917707e-02f, -4.24415767e-02f, 9.58732888e-02f, 1.13155305e-01f, 2.02188790e-01f, 9.39784944e-02f,
  -6.76072240e-02f, 4.45215255e-02f, 4.81190830e-02f, -1.28451794e-01f, -2.55925432e-02f, -1.34121830e-04f, 5.14047593e-02f, 2.70739617e-03f, 4.78366688e-02f, 5.00836857e-02f,
  2.07099635e-02f, 2.44026463e-02f, -3.56941894e-02f, -2.63701528e-02f, -6.58971816e-03f, 7.62393624e-02f, -7.76793854e-03f, 6.88473135e-02f, 8.66085365e-02f, -1.23552245e-03f,
  2.94730198e-02f, 5.76566383e-02f, 6.08070986e-03f, 8.07428062e-02f, 1.99343413e-02f, 2.88598146e-02f, -1.71851944e-02f, -8.43247697e-02f, 1.43474163e-02f, 2.32116152e-02f,
  6.84489682e-02f, 1.63523525e-01f, -1.45902947e-01f, 9.59803835e-02f, 1.82806142e-02f, -2.09769886e-02f, -3.73349600e-02f, -2.23943070e-02f, -7.91768134e-02f, 6.50103614e-02f,
  9.20033753e-02f, -4.56805862e-02f, 5.49771599e-02f, -4.54053804e-02f, 2.14811452e-02f, -8.09689015e-02f, -1.09365433e-01f, 3.45856650e-03f, 5.16741388e-02f, -1.27861485e-01f,
  -1.46160066e-01f, -7.98408315e-02f, -1.35075063e-01f, 4.67424802e-02f, -3.86149921e-02f, -1.70242473e-01f, -5.04327789e-02f, 5.35602234e-02f, -1.56247513e-02f, -6.96591847e-03f,
  1.72486603e-02f, -5.62874794e-01f, 1.30165473e-01f, 1.65396675e-01f, 3.87710482e-01f, 4.05608207e-01f, 3.54473948e-01f, 7.67732561e-02f, -4.42975610e-02f, -4.60379757e-02f,
  -1.64760277e-01f, -3.31409723e-01f, -3.58036816e-01f, -3.20199728e-01f, -1.65016457e-01f, 4.48663831e-02f, 1.54522225e-01f, -1.67151187e-02f, 3.23271155e-01f, 2.86761016e-01f,
  -1.54314525e-02f, -3.18320980e-03f, -1.17328621e-01f, -1.31595567e-01f, -8.08927119e-02f, -8.03961307e-02f, -1.19457431e-01f, -2.29522232e-02f, -1.25461057e-01f, -5.68192601e-02f,
  -1.09157100e-01f, -4.56896909e-02f, 9.50824618e-02f, -6.44818619e-02f, -1.07885078e-01f, -1.67222440e-01f, 5.14114983e-02f, 2.50044148e-02f, -5.41924983e-02f, -5.50029427e-02f,
  -6.77717105e-02f, 3.97779755e-02f, -4.73606661e-02f, -5.52887917e-02f, 1.02334879e-01f, 3.03113610e-02f, -1.87220022e-01f, -1.43062383e-01f, -1.68037236e-01f, -1.59061939e-01f,
  -1.45975575e-01f, 6.24440648e-02f, 1.90726444e-02f, 6.64139614e-02f, -7.06505030e-02f, 2.57142540e-02f, -6.31846339e-02f, 2.23433040e-02f, 4.10794572e-04f, -6.47413805e-02f,
  -1.13586066e-02f, -5.04949363e-03f, 1.55028300e-02f, 3.22644264e-02f, 3.14923264e-02f, 5.74708357e-02f, 4.73843925e-02f, -3.46905552e-02f, 5.64217344e-02f, -4.84706946e-02f,
  9.16771218e-03f, 1.46856522e-02f, -4.81953248e-02f, -4.82813604e-02f, -1.29687637e-01f, -9.69723836e-02f, 5.55351414e-02f, -1.07997738e-01f, -8.08482021e-02f, 1.13012707e-02f,
  -1.20934278e-01f, 4.46584122e-03f, 7.39213824e-02f, -2.89087463e-03f, -1.15387470e-01f, -3.84003557e-02f, -7.04387352e-02f, -9.15548950e-02f, 4.78791669e-02f, -8.19690078e-02f,
  -2.33765364e-01f, 2.87772603e-02f, -2.54439004e-02f, -1.02137305e-01f, 1.55139893e-01f, -8.13007057e-02f, -3.22942585e-02f, 4.80298772e-02f, -7.30137378e-02f, -5.54753607e-03f,
  6.94520921e-02f, -2.85981800e-02f, 2.17142813e-02f, -4.43718806e-02f, 1.96653858e-01f, 4.21715677e-02f, -1.05598748e-01f, -6.25526085e-02f, -1.62928551e-02f, -1.42789245e-01f,
  -1.25415325e-01f, 1.48848832e-01f, -9.26252862e-04f, 1.65334176e-02f, 5.17366678e-02f, 2.22946495e-01f, 3.93016310e-03f, 1.28717318e-01f, 1.11414753e-01f, 7.42215142e-02f,
  -2.30844319e-01f, -1.18495733e-01f, 4.37792093e-02f, -5.97189441e-02f, 4.17504683e-02f, 2.38380637e-02f, -2.00902343e-01f, 2.52875946e-02f, 5.85327893e-02f, -1.83146298e-01f,
  -9.83832926e-02f, 1.07470609e-01f, -8.69624689e-02f, -1.48476530e-02f, -1.52600601e-01f, -2.81061053e-01f, -1.09042354e-01f, -1.03399558e-02f, 1.96629316e-01f, 2.02860430e-01f,
  1.70248505e-02f, -3.72544006e-02f, 1.12954356e-01f, 1.64423548e-02f, -1.05039969e-01f, 4.39212881e-02f, -2.24833101e-01f, -3.82467061e-02f, -3.81801347e-03f, -2.93198943e-01f,
  -1.34175479e-01f, -1.54682890e-01f, 7.04981163e-02f, -7.76536018e-02f, -8.54914561e-02f, -4.73239385e-02f, -6.94935247e-02f, -6.51001856e-02f, 7.32669234e-02f, 1.43263834e-02f,
  -2.25943420e-02f, 1.17443606e-01f, -1.08034827e-03f, 1.37558132e-01f, 1.15538239e-01f, -2.44873501e-02f, -7.29213580e-02f, 4.57110553e-04f, 2.50742305e-02f, -3.01765408e-02f,
  -1.04817227e-01f, -4.67278920e-02f, -8.85189921e-02f, -4.00755331e-02f, 3.77330631e-02f, 1.41140908e-01f, 2.04159524e-02f, 2.04646885e-02f, 7.47409696e-03f, -2.57157534e-01f,
  3.58345080e-03f, -1.91610493e-03f, -7.61327008e-03f, 2.93641016e-02f, 3.30782868e-02f, 4.60894667e-02f, -7.41663575e-02f, -6.76444620e-02f, 6.95296898e-02f, 4.33679903e-03f,
  1.94923067e-03f, -1.50857307e-02f, 1.65174007e-02f, -3.93599682e-02f, -1.40443265e-01f, -2.25312971e-02f, -5.45779914e-02f, -1.05786555e-01f, -8.68149474e-03f, -1.10891931e-01f,
  8.29449296e-02f, 3.02655306e-02f, 1.87034197e-02f, 5.72585799e-02f, -3.47350128e-02f, 8.11261609e-02f, -1.18680596e-01f, 1.36989402e-02f, -1.48200646e-01f, -1.09997571e-01f,
  -4.70906124e-02f, 1.51867092e-01f, -6.20558597e-02f, 4.25364356e-03f, -1.38922617e-01f, -5.38995042e-02f, 2.93141436e-02f, 8.23023617e-02f, -3.98115739e-02f, 4.01486941e-02f,
  -5.38214929e-02f, -9.68137085e-02f, -1.87289953e-01f, 1.34716690e-01f, 5.55493347e-02f, -1.42662764e-01f, -1.78931773e-01f, 2.55367849e-02f, 3.24822441e-02f, -1.90018006e-02f,
  -1.94132067e-02f, -6.27116263e-02f, -8.45039338e-02f, -1.39712915e-01f, -3.33122052e-02f, -1.30622074e-01f, -1.89203113e-01f, -6.28015101e-02f, -1.48453429e-01f, -2.40855351e-01f,
  -2.93960899e-01f, -3.39654654e-01f, 5.12881652e-02f, -5.77291623e-02f, 1.50299128e-02f, -6.64320290e-02f, -3.58808637e-01f, -4.01907593e-01f, -7.12623373e-02f, -1.01577275e-01f,
  -1.30938366e-01f, 8.89097378e-02f, 3.38622369e-02f, 1.12932429e-01f, 1.00120388e-01f, -8.74015912e-02f, 1.66433081e-01f, 2.23184362e-01f, 9.46951807e-02f, 8.54266584e-02f,
  6.76585883e-02f, 5.33192009e-02f, 7.96837881e-02f, 1.31820291e-01f, 5.69370622e-03f, 8.86162519e-02f, 7.42520764e-02f, 1.80087052e-02f, 5.57773374e-02f, 1.59414575e-01f,
  5.36265932e-02f, -1.46054089e-01f, 1.54886112e-01f, 1.58793360e-01f, 1.18965693e-01f, -1.04634866e-01f, -2.39214480e-01f, 9.87929776e-02f, 5.78702129e-02f, 4.72049899e-02f,
  -5.73727116e-02f, 8.52748845e-03f, -5.91860227e-02f, 8.01633745e-02f, 8.07496086e-02f, 4.23191600e-02f, 4.06924263e-03f, 2.70209163e-02f, 2.89757550e-02f, -7.66592249e-02f,
  -9.51156486e-03f, -4.07549960e-04f, -6.33740649e-02f, 2.87209321e-02f, 9.96968988e-03f, 1.06358990e-01f, -5.04957661e-02f, -3.53311710e-02f, -8.33410248e-02f, -1.79285824e-01f,
  1.10493876e-01f, 1.08344913e-01f, 1.34366944e-01f, 2.80595478e-03f, 2.61723506e-03f, -7.98389018e-02f, 1.46961108e-01f, 1.41223278e-02f, 2.01959778e-02f, -5.59172109e-02f,
  5.33719696e-02f, 1.20620638e-01f, 4.55630422e-02f, 2.56308466e-02f, 8.64143819e-02f, 1.04752546e-02f, 5.41010424e-02f, 5.86007573e-02f, -1.48765440e-03f, -7.95781463e-02f,
  3.90344150e-02f, 3.43696922e-02f, -1.64905842e-02f, -3.09823398e-02f, -3.91082577e-02f, 1.52468219e-01f, -4.58554439e-02f, 3.27676488e-03f, -1.63400453e-02f, -2.47701369e-02f,
  -2.62396872e-01f, 1.25445366e-01f, 3.87299396e-02f, 3.89585048e-02f, 1.54800806e-02f, 5.00260778e-02f, -5.61947376e-02f, -1.30543420e-02f, 8.26085061e-02f, -2.10832767e-02f,
  -1.17667928e-01f, 1.07043926e-02f, -2.36972481e-01f, 8.82487744e-02f, -6.17002770e-02f, -2.31460040e-03f, 1.23995617e-01f, -2.68988498e-03f, 1.31931886e-01f, -2.41688471e-02f,
  -1.55741438e-01f, -2.33988047e-01f, -8.06025639e-02f, -1.90611660e-01f, -1.84446257e-02f, -9.62692499e-02f, -4.80174460e-02f, -1.70067459e-01f, -1.27064019e-01f, -4.53501791e-01f,
  5.43289363e-01f, 2.82642305e-01f, 2.31227010e-01f, 1.50129780e-01f, 1.38021052e-01f, 1.14037104e-01f, 1.99999809e-01f, 7.44195729e-02f, 4.18074289e-03f, 1.19736426e-01f,
  1.37961596e-01f, 1.61387876e-01f, 1.08705666e-02f, 6.89069629e-02f, 2.86554005e-02f, -2.26109717e-02f, 6.00756891e-02f, 1.78332999e-01f, 1.67785838e-01f, 7.14659169e-02f,
  7.09717721e-02f, -3.81805077e-02f, 1.47492826e-01f, 8.49527642e-02f, 2.99946573e-02f, 1.62193403e-02f, -6.58658147e-02f, 1.53836146e-01f, 5.42230345e-02f, 1.41825303e-01f,
  8.77887756e-02f, 1.18285008e-01f, -3.45406570e-02f, -4.86846864e-02f, -4.37496928e-03f, 8.58791545e-03f, 6.84206784e-02f, -1.01537332e-01f, -6.10535257e-02f, -8.84937942e-02f,
  -6.41070530e-02f, -3.94448871e-03f, 4.35631350e-02f, 7.05147758e-02f, -4.74903472e-02f, -4.92819957e-02f, -4.02562544e-02f, -1.71907041e-02f, 8.87910426e-02f, 9.65689719e-02f,
  1.20095089e-01f, -1.71373691e-02f, 3.98892388e-02f, -5.03863916e-02f, 4.76617180e-02f, 1.22119747e-02f, 5.02178632e-02f, 1.03649788e-01f, -2.33412124e-02f, 1.29890591e-01f,
  8.97474065e-02f, 8.87286440e-02f, 4.07813266e-02f, 2.28370979e-01f, 1.08528227e-01f, 6.98016211e-02f, 6.90590218e-02f, -2.40482092e-02f, 5.63048571e-02f, 1.35471076e-01f,
  -2.73568016e-02f, 1.06947184e-01f, 4.43821289e-02f, 3.28999162e-02f, 7.87040740e-02f, -7.06012361e-03f, -2.76963525e-02f, -7.57207498e-02f, -7.83898011e-02f, -8.08534324e-02f,
  1.44259669e-02f, 4.65127192e-02f, 6.14542887e-02f, -9.17755533e-03f, 6.09439798e-03f, 1.19565204e-02f, -1.30720772e-02f, 3.09012644e-02f, -3.04053370e-02f, -2.97755897e-02f,
  -4.98538017e-01f, -6.13982566e-02f, -7.72497291e-03f, -1.63826555e-01f, 1.93124805e-02f, 4.42808047e-02f, 2.40380958e-01f, -6.43580556e-02f, -1.65306911e-01f, -6.25720248e-02f,
  6.16670698e-02f, 2.92572323e-02f, -8.34289864e-02f, -1.15701836e-02f, -3.91368978e-02f, -1.31838083e-01f, 8.91453698e-02f, -7.60616502e-03f, -4.83510979e-02f, -2.46097166e-02f,
  -2.58569755e-02f, -1.86900809e-01f, -1.35975659e-01f, -5.64791150e-02f, -1.20539539e-01f, -1.33787319e-01f, -9.28448439e-02f, -1.29040718e-01f, -1.89349696e-01f, -1.01758935e-01f,
  3.53829205e-01f, -2.94817835e-01f, 6.74348474e-02f, 2.38203913e-01f, 2.00423092e-01f, 2.18936726e-01f, 1.86087668e-01f, 2.58532222e-02f, 1.91602722e-01f, 1.59451783e-01f,
  -7.27141574e-02f, -1.70558747e-02f, -2.11181473e-02f, -1.59812588e-02f, -1.07383102e-01f, -4.62973937e-02f, 4.07654271e-02f, 4.15735766e-02f, 2.19307184e-01f, 1.60886168e-01f,
  -3.47770266e-02f, 1.37336692e-02f, -1.53971612e-02f, -5.80630600e-02f, -9.92666110e-02f, 1.35645643e-01f, 2.93117743e-02f, -1.85760289e-01f, -8.83963406e-02f, -3.23295742e-01f,
  -6.31947890e-02f, -1.47828773e-01f, 1.51389077e-01f, -1.60042141e-02f, -4.78250049e-02f, 1.13326646e-01f, 7.08370134e-02f, -3.37185748e-02f, 1.33340731e-02f, 8.35578144e-02f,
  -8.92549381e-02f, -5.71231283e-02f, -7.40671679e-02f, -8.05391893e-02f, -1.12613156e-01f, -4.64940481e-02f, -3.85374688e-02f, -1.68783337e-01f, -6.74351156e-02f, -1.05289198e-01f,
  -9.35558826e-02f, -7.13011697e-02f, -6.04017898e-02f, 4.52746488e-02f, -1.14576973e-01f, -6.28256351e-02f, -1.56469554e-01f, -1.15872920e-02f, -1.03264093e-01f, -4.34387382e-03f,
  -7.32540525e-03f, 3.31716575e-02f, -2.02141441e-02f, 1.31303892e-01f, 6.01338483e-02f, 5.90159781e-02f, -3.37423645e-02f, 1.20288692e-01f, 9.71971750e-02f, 7.39071369e-02f,
  -3.54524478e-02f, -5.91100268e-02f, -8.91434774e-02f, 7.63817802e-02f, 3.15760709e-02f, -6.81239888e-02f, -8.61840546e-02f, -4.53562811e-02f, -8.13377798e-02f, 5.10780662e-02f,
  2.74624340e-02f, -9.10832137e-02f, -1.33819044e-01f, -1.59063235e-01f, -1.91955134e-01f, -2.13879533e-02f, -5.32423146e-02f, -1.18026007e-02f, 3.22583951e-02f, -1.60155166e-02f,
  4.04310264e-02f, -9.16498080e-02f, 1.05826564e-01f, -1.52343303e-01f, -1.35913312e-01f, -6.07664473e-02f, -8.69155154e-02f, -8.85784328e-02f, -2.98593938e-02f, -4.71764579e-02f,
  -7.21273869e-02f, -5.25783189e-02f, -3.27886716e-02f, -8.64040554e-02f, 1.45416170e-01f, -4.20805328e-02f, -1.87287658e-01f, 5.14127314e-02f, -1.51625752e-01f, -1.84527785e-01f,
  -3.17002982e-02f, 8.77965391e-02f, 1.43525004e-01f, 1.17589012e-01f, -4.64258157e-02f, 2.30016246e-01f, 6.87593222e-02f, 9.06168073e-02f, 4.12041396e-02f, 1.71049446e-01f,
  4.63467747e-01f, 3.15081537e-01f, 9.73593146e-02f, 1.23978175e-01f, -6.30393624e-02f, 2.76577957e-02f, 1.64592534e-01f, 1.56482592e-01f, -2.62189489e-02f, 6.18372485e-02f,
  6.82910085e-02f, -9.10830945e-02f, -4.00358625e-02f, -3.25902477e-02f, 6.90608248e-02f, -1.14475079e-02f, 1.90498233e-02f, -1.12409806e-02f, -4.22596820e-02f, -7.57333916e-03f,
  2.85443887e-02f, -3.68559398e-02f, 8.32678527e-02f, -4.79760543e-02f, 5.75845800e-02f, -1.03916727e-01f, 9.25774127e-03f, 8.10217783e-02f, 1.20857719e-03f, -6.69056457e-03f,
  -1.62088379e-01f, 1.67585820e-01f, -1.36983663e-01f, -5.62018901e-02f, -1.77234644e-03f, -1.11195080e-01f, 4.84287553e-02f, -3.86458300e-02f, -7.15429261e-02f, -2.78976746e-04f,
  -9.96641293e-02f, -4.49047014e-02f, 2.54324954e-02f, 1.25717804e-01f, 9.00689662e-02f, 4.81291004e-02f, 7.33259991e-02f, 5.14902174e-02f, 9.88538116e-02f, 2.05836631e-02f,
  4.31024544e-02f, 2.68974006e-02f, 9.15444270e-02f, 1.08718581e-01f, 1.94721311e-01f, 6.21399134e-02f, 3.12014967e-02f, 5.36637940e-02f, 2.34677419e-02f, 4.30337675e-02f,
  -2.10559532e-01f, -4.50009145e-02f, 4.25191782e-02f, 5.77380992e-02f, 1.04626559e-01f, -7.86347538e-02f, -1.00565486e-01f, 5.06318249e-02f, 3.67376916e-02f, 8.89742076e-02f,
  -9.18950364e-02f, 1.31423781e-02f, -6.39630156e-03f, -1.42892096e-02f, 7.28594512e-02f, 1.33102998e-01f, -5.26864342e-02f, 8.22355524e-02f, 3.33502516e-02f, -5.86040551e-03f,
  -1.23526506e-01f, -8.47865120e-02f, -1.07129373e-01f, 2.32172161e-02f, 6.30079433e-02f, -2.61421148e-02f, -3.90606262e-02f, 1.32820189e-01f, 3.84975746e-02f, -8.75487179e-02f,
  -3.15316230e-01f, -4.94238026e-02f, -1.06655406e-02f, -2.29587518e-02f, -6.23483658e-02f, -1.30304381e-01f, -1.00991547e-01f, -6.28305152e-02f, -1.26112267e-01f, -1.98699400e-01f,
  -6.07740283e-02f, -8.60344246e-02f, 1.39904991e-01f, 8.09730217e-02f, -6.34191409e-02f, -1.62588149e-01f, -9.55191553e-02f, -1.04176000e-01f, -7.24530593e-03f, -1.71925858e-01f,
  -1.52275339e-01f, -9.05156583e-02f, -1.77683875e-01f, -8.48378241e-02f, -4.26938534e-02f, -1.41570851e-01f, -1.31139793e-02f, 5.14082098e-03f, -8.49878266e-02f, 1.44877248e-02f,
  3.30798745e-01f, -1.48089007e-01f, -4.62232709e-01f, -6.41693100e-02f, -1.97740778e-01f, -2.52513736e-01f, -3.15582842e-01f, 1.53865993e-01f, 9.75901932e-02f, -1.52251050e-01f,
  -1.04583777e-01f, 2.52566755e-01f, 7.79592097e-02f, 6.64427951e-02f, 2.61372745e-01f, -2.09051177e-01f, -2.49896139e-01f, 5.75249724e-04f, 1.75653562e-01f, 4.29511676e-03f,
  -4.85653616e-02f, 1.59964710e-01f, 9.06245261e-02f, 8.91037434e-02f, -1.76180005e-01f, 9.64388438e-03f, -3.05918425e-01f, -1.71603441e-01f, -2.14835480e-01f, -3.54127675e-01f,
  -2.64351964e-01f, -1.80282772e-01f, -1.39152348e-01f, 8.43836665e-02f, -1.67004228e-01f, -1.48249287e-02f, 1.40172821e-02f, -1.20520396e-02f, -5.06905578e-02f, -1.28316939e-01f,
  -7.75776431e-02f, 8.72295648e-02f, 2.43976817e-01f, 4.74342555e-02f, -6.85985833e-02f, 9.95542854e-02f, 5.61316982e-02f, -4.94874865e-02f, -1.46690961e-02f, -8.16721022e-02f,
  1.48851601e-02f, -7.24606076e-03f, -1.08500794e-01f, -2.25510314e-01f, -3.40873487e-02f, 6.12355256e-03f, -1.26824647e-01f, -1.08336546e-01f, -7.41916746e-02f, -1.64411485e-01f,
  -3.39257605e-02f, -1.17916293e-01f, -2.97922287e-02f, 1.08094729e-01f, 3.89802270e-02f, -9.53755807e-03f, 2.76178177e-02f, 8.81447867e-02f, 3.07964832e-02f, -2.11762469e-02f,
  -2.08958387e-02f, -1.19476117e-01f, -8.54148641e-02f, -3.24871130e-02f, -2.27682409e-03f, 6.34987280e-02f, 2.27465294e-02f, -1.98227540e-02f, -6.73532393e-03f, -6.49383739e-02f,
  -1.16536580e-02f, -1.20219365e-02f, -1.10326633e-01f, 5.46777546e-02f, -5.58714867e-02f, 8.58923271e-02f, 1.35986437e-03f, -4.99873376e-03f, 8.97067040e-02f, -8.23887810e-02f,
  1.88116178e-01f, -1.79476440e-01f, -3.31197381e-02f, 1.65485933e-01f, -1.11242160e-01f, -2.02898413e-01f, -1.14915259e-01f, -6.70416951e-02f, 1.05325155e-01f, -3.62267829e-02f,
  -1.45415321e-01f, -3.88807207e-02f, -2.56993324e-02f, -7.21286684e-02f, -2.48927195e-02f, 1.24856886e-02f, 1.05130926e-01f, 2.75493469e-02f, 6.21694475e-02f, -9.14678499e-02f,
  2.47517210e-02f, 9.91453975e-02f, 1.68891773e-01f, -1.53689543e-02f, 2.64527146e-02f, 1.42330408e-01f, -8.24667513e-02f, -6.82298541e-02f, 3.76772769e-02f, 1.95557028e-01f,
  -4.64518130e-01f, -1.60967484e-02f, 1.46872662e-02f, 2.42358223e-01f, 1.06759846e-01f, 7.29481950e-02f, 1.10786267e-01f, 8.78268406e-02f, 1.23154528e-01f, 4.77103889e-02f,
  1.22750334e-01f, 2.08739981e-01f, 1.52041271e-01f, 2.30629548e-01f, 2.37213865e-01f, 1.86834782e-01f, 2.33394831e-01f, 9.06426385e-02f, -1.29661709e-01f, 2.54626255e-02f,
  1.15866683e-01f, -1.92633141e-02f, -2.11157262e-01f, 1.02326259e-01f, 1.24674946e-01f, 4.43863198e-02f, 6.91220984e-02f, 1.60663038e-01f, 1.15841754e-01f, 3.01685274e-01f,
  3.75136570e-03f, 3.92689481e-02f, -2.46472731e-02f, -1.02723464e-01f, -3.63135673e-02f, -1.96931079e-01f, -4.63356487e-02f, -1.43950447e-01f, -1.21430926e-01f, -3.70278843e-02f,
  -4.97712903e-02f, -1.46261364e-01f, -1.03005394e-02f, -5.80418669e-02f, -1.50427341e-01f, -7.75474533e-02f, -1.51758403e-01f, 1.10205479e-01f, 2.14330375e-01f, -3.49866599e-02f,
  1.08076230e-01f, 6.06115349e-02f, 2.44549774e-02f, -2.05022078e-02f, -7.28616640e-02f, 1.29414825e-02f, 1.91406235e-02f, 8.36221054e-02f, 1.17407583e-01f, 4.77649719e-02f,
  1.38822854e-01f, -5.97850196e-02f, 1.21338211e-01f, 1.16392421e-02f, -7.26120919e-02f, -1.21099383e-01f, 3.43451239e-02f, -2.95945648e-02f, -5.11169550e-04f, -1.83628127e-01f,
  -3.58752050e-02f, 1.40433565e-01f, 4.75725941e-02f, 1.03180245e-01f, -2.96311043e-02f, 1.75693370e-02f, -8.08630064e-02f, -2.27462710e-03f, -4.18220982e-02f, 6.82878047e-02f,
  -5.80139533e-02f, 3.20081972e-02f, -7.84493424e-03f, 8.41673836e-02f, 7.90350810e-02f, 4.92823496e-03f, 9.85022355e-03f, -2.97759138e-02f, -5.09231649e-02f, 2.99569294e-02f,
  7.48180747e-02f, 1.26477987e-01f, -2.76477430e-02f, 1.67861864e-01f, 4.27843817e-02f, -8.10677782e-02f, 1.59215331e-01f, 1.78555444e-01f, 1.16516173e-01f, 3.80462483e-02f,
  -5.31986207e-02f, -1.05598480e-01f, -1.22201487e-01f, -6.49921075e-02f, -1.37296855e-01f, -7.65839368e-02f, 8.81374776e-02f, 1.24011986e-01f, 1.68772385e-01f, 4.98900376e-02f,
  -7.33498810e-03f, -4.11608033e-02f, 4.96186800e-02f, -2.97297898e-04f, 1.52157713e-02f, -1.03772171e-02f, 3.50729795e-03f, -5.37589528e-02f, -3.11122201e-02f, -1.68773204e-01f,
  6.39453709e-01f, -3.43484253e-01f, 1.86964452e-01f, 2.10498214e-01f, 1.06443511e-03f, 1.77090988e-01f, 2.65640789e-03f, 1.00141242e-01f, 1.17582440e-01f, -6.46434724e-02f,
  -7.62725547e-02f, 1.97221264e-02f, -5.27383387e-03f, -1.38748891e-03f, 9.18112993e-02f, -1.26296595e-01f, -3.78929302e-02f, 1.08308233e-01f, 2.63452023e-01f, 4.91223447e-02f,
  -1.51092872e-01f, 2.22295541e-02f, 9.40848142e-02f, -2.23101266e-02f, -2.51327872e-01f, -2.15282030e-02f, -1.54340610e-01f, -9.31533650e-02f, -2.38129869e-02f, -2.23147362e-01f,
  1.28754005e-02f, 1.58460021e-01f, 7.02463323e-03f, -3.38476636e-02f, -9.03464481e-02f, -5.92520740e-03f, -3.76037993e-02f, -4.61162105e-02f, -1.18273333e-01f, 3.83530855e-02f,
  6.86761886e-02f, -1.16680123e-01f, 3.46585177e-02f, -5.06603830e-02f, -1.01279952e-01f, -6.01772554e-02f, -2.25071937e-01f, -1.79946989e-01f, -1.11792609e-01f, -9.25922114e-03f,
  -1.94835514e-01f, -6.16702214e-02f, 8.62332508e-02f, 1.39520466e-02f, -5.85352769e-03f, 1.91346973e-01f, -3.63814682e-02f, -1.72410876e-01f, -1.01440819e-02f, -2.05203697e-01f,
  7.19381217e-03f, 1.37914628e-01f, 3.25793885e-02f, -6.62727728e-02f, 6.28621830e-03f, -6.95743486e-02f, -4.32985425e-02f, -1.01412736e-01f, -1.09939970e-01f, -8.26968178e-02f,
  -3.98546606e-02f, 3.21200788e-02f, 1.19146310e-01f, 8.33264217e-02f, -3.17083299e-03f, 4.42521237e-02f, 1.31817162e-02f, -5.41944616e-02f, -4.97042313e-02f, -4.83586416e-02f,
  3.21177505e-02f, 2.55785752e-02f, 4.09044139e-02f, -2.14577559e-02f, -1.07894288e-02f, 7.48684555e-02f, -2.81429384e-02f, -3.30774039e-02f, 3.66482548e-02f, 3.43476757e-02f,
  -8.91543180e-02f, 1.73142746e-01f, 1.75434053e-02f, -1.10980153e-01f, -3.67688835e-02f, 3.44461314e-02f, 7.13297203e-02f, -2.44253371e-02f, 6.80566505e-02f, 7.54188448e-02f,
  -3.28264385e-03f, 9.41308364e-02f, -4.60029393e-03f, -1.90185569e-02f, 1.20610729e-01f, 1.30098183e-02f, -9.36113819e-02f, 1.25198022e-01f, 4.31782193e-02f, 1.70337427e-02f,
  -1.43483162e-01f, 8.79801586e-02f, 1.00020215e-01f, 1.04155861e-01f, 4.78582121e-02f, 1.67439401e-01f, -5.80773540e-02f, -1.41122434e-02f, 1.52352273e-01f, -6.97762296e-02f,
  2.84535617e-01f, 1.30981341e-01f, 1.40960425e-01f, 1.30946264e-01f, -6.10589720e-02f, -3.30224425e-01f, -1.76265955e-01f, -2.11019814e-01f, -1.48132771e-01f, 1.04919419e-01f,
  -2.90498938e-02f, -8.95974040e-02f, 1.28002405e-01f, -1.09231248e-01f, -2.21368954e-01f, 6.93122074e-02f, 6.69183135e-02f, -1.49276545e-02f, -2.63776809e-01f, -3.15504253e-01f,
  -3.15107182e-02f, 9.36951637e-02f, 1.34131938e-01f, -1.96093228e-02f, 1.28093809e-01f, -6.60687452e-03f, 6.87309280e-02f, 7.58431628e-02f, 1.24464026e-02f, 3.13046217e-01f,
  3.28424901e-01f, 1.04524963e-01f, -1.21398248e-01f, -1.11075252e-01f, -2.15310976e-01f, 2.40291525e-02f, -2.19577774e-01f, 1.00364149e-01f, -1.13277659e-01f, 1.61703341e-02f,
  -9.48584229e-02f, -1.65038556e-01f, -1.46714881e-01f, -9.36390162e-02f, -1.03153124e-01f, -2.39177272e-01f, -6.82565495e-02f, 1.06038347e-01f, 4.61951084e-02f, -9.75830853e-02f,
  -7.32828211e-03f, -2.57350653e-02f, -1.45035759e-01f, -6.53109252e-02f, -6.23737685e-02f, -6.06963411e-02f, -2.53574289e-02f, -4.39465931e-03f, -1.58686906e-01f, 1.15515590e-01f,
  -9.56294686e-02f, -8.01004171e-02f, 1.23487925e-02f, -2.04102788e-02f, -6.45160824e-02f, -6.98642712e-03f, -8.11608955e-02f, -4.08406146e-02f, -1.13539100e-01f, -3.58515009e-02f,
  -5.49204051e-02f, 9.23322812e-02f, 5.25139049e-02f, 2.92217284e-02f, -1.46160116e-02f, -4.16206643e-02f, -7.85139203e-02f, 1.48244664e-01f, 1.60015807e-01f, 1.28225153e-02f,
  2.25414615e-03f, 1.02019861e-01f, -6.97496906e-02f, -6.66937158e-02f, 6.01642504e-02f, -1.19106814e-01f, -2.42588446e-02f, -1.11617006e-01f, 1.02994584e-01f, 7.12822452e-02f,
  4.04475220e-02f, -1.57123193e-01f, 1.18830372e-02f, -1.63593739e-01f, 4.87935320e-02f, -7.72217661e-02f, -1.60164550e-01f, -7.45937675e-02f, 5.43751344e-02f, -9.53029916e-02f,
  -1.98854119e-01f, -6.52727038e-02f, 5.99431694e-02f, -4.86454889e-02f, -9.71017629e-02f, -1.13427423e-01f, 3.74098197e-02f, -1.30999591e-02f, 1.25443228e-02f, -1.27692958e-02f,
  1.52571155e-02f, -9.36663076e-02f, -1.04567604e-02f, -4.11128327e-02f, 1.09536327e-01f, -8.94059613e-02f, -4.75738011e-02f, -1.74822643e-01f, -1.83593541e-01f, 2.17014495e-02f,
  -8.34855139e-02f, -9.76205692e-02f, -3.59386578e-02f, 2.25329101e-01f, 1.32382929e-01f, 1.94932565e-01f, 2.55707592e-01f, 9.32662636e-02f, 8.51724669e-02f, 1.39437810e-01f,
  -5.84800579e-02f, -1.26417920e-01f, -1.13773964e-01f, -1.88217521e-01f, -1.41357780e-01f, 3.71786915e-02f, 1.40675157e-01f, -7.26095662e-02f, 5.77897663e-05f, 7.76848942e-02f,
  1.37000948e-01f, 6.35570064e-02f, -8.68563503e-02f, 4.47129942e-02f, 8.61288607e-03f, 4.74015027e-02f, -3.10550723e-02f, -7.82777146e-02f, -1.32978540e-02f, 5.65955862e-02f,
  -2.75999278e-01f, -1.80150464e-01f, 1.10784449e-01f, -8.50795419e-04f, -1.16917521e-01f, 2.13542078e-02f, -6.67112991e-02f, -1.03351854e-01f, -8.99646282e-02f, 4.57665361e-02f,
  -8.71026143e-02f, -1.30898267e-01f, 3.24628390e-02f, -1.19400618e-03f, 3.03192586e-02f, -3.28357704e-02f, -1.91541657e-01f, -5.16004562e-02f, 3.08555085e-02f, -1.83183312e-01f,
  1.27643952e-02f, -2.97735669e-02f, -1.27649084e-01f, 8.83654952e-02f, -1.15321673e-01f, -3.35388482e-02f, -8.15961361e-02f, -1.72718689e-01f, -1.48892393e-02f, -1.03499629e-01f,
  -1.85100049e-01f, 6.70231879e-02f, 3.68073173e-02f, 9.54902023e-02f, 6.88623935e-02f, 1.69351190e-01f, 7.64972270e-02f, -5.62029108e-02f, 3.51673588e-02f, -3.07126828e-02f,
  1.35075763e-01f, 8.58581886e-02f, 1.21270537e-01f, 1.03204131e-01f, -1.58960838e-02f, -5.66442730e-03f, -7.79005140e-02f, -3.44018452e-02f, 6.55137599e-02f, 2.53297597e-01f,
  1.74893439e-01f, 6.51145428e-02f, 4.11355384e-02f, 1.12002827e-01f, -1.04931311e-03f, 5.19634746e-02f, 7.74414986e-02f, 7.40396827e-02f, 9.28388163e-03f, -7.47878551e-02f,
  -2.09039953e-02f, -1.08077593e-01f, 1.10376865e-01f, 8.02635550e-02f, 2.09794082e-02f, -3.93718593e-02f, -6.85368776e-02f, -1.82875097e-02f, 8.55861828e-02f, 5.83493523e-02f,
  -1.83776077e-02f, -7.90162534e-02f, 7.59018883e-02f, 2.37021483e-02f, 8.95368829e-02f, 1.21058658e-01f, -1.04620695e-01f, 6.71604276e-02f, 8.75254441e-03f, 1.79260317e-02f,
  2.15804037e-02f, 6.60377070e-02f, 3.58826071e-02f, 7.20378980e-02f, -4.34931666e-02f, 1.04732409e-01f, -1.05159469e-02f, -4.82396176e-03f, 8.65262076e-02f, 1.80690154e-01f,
  -1.23377651e-01f, -8.48243833e-02f, 1.34098321e-01f, 2.11940438e-01f, 1.67254612e-01f, -1.20584130e-01f, -3.60515594e-01f, -3.58581185e-01f, -1.90211888e-02f, 2.10564025e-02f,
  3.12884301e-02f, 9.74855646e-02f, 8.36386606e-02f, 5.21560572e-02f, -3.29653412e-01f, -1.64535761e-01f, 1.05536722e-01f, -3.17200460e-02f, -2.85773814e-01f, -3.10733289e-01f,
  2.24499647e-02f, 4.58981143e-03f, -1.05545096e-01f, -1.05032697e-01f, 2.58686066e-01f, 1.72146693e-01f, 2.08576292e-01f, 4.17294204e-02f, 3.74320634e-02f, 4.30481970e-01f,
  2.44980633e-01f, 5.82860298e-02f, -3.81617388e-03f, 7.91115612e-02f, 1.45784587e-01f, 9.84570011e-02f, -1.46101816e-02f, 2.36585569e-02f, -9.79513489e-03f, -2.61152145e-02f,
  1.36979774e-01f, 1.00347340e-01f, -6.59652799e-02f, 1.13802820e-01f, -3.65342163e-02f, -4.27050330e-02f, 7.72231519e-02f, -1.46643132e-01f, 6.82455376e-02f, 1.11125512e-02f,
  7.99894035e-02f, 3.07244454e-02f, -1.81135058e-01f, -1.08237557e-01f, -9.23594385e-02f, 1.38304338e-01f, 1.89647917e-02f, 1.64631959e-02f, -7.14666247e-02f, -5.90664782e-02f,
  5.71385026e-02f, -3.76568250e-02f, 5.88421337e-02f, 8.90352577e-02f, -1.25638163e-02f, 6.96226358e-02f, 1.42937332e-01f, 4.18457389e-02f, -5.81967458e-02f, -4.10472117e-02f,
  -7.24294037e-02f, 4.20191959e-02f, -4.20831703e-02f, -5.74562885e-02f, 8.86351243e-03f, 1.79172024e-01f, 1.37116075e-01f, 6.18001670e-02f, 8.01191433e-08f, 3.81148569e-02f,
  7.54249245e-02f, -1.50757981e-02f, 5.38998768e-02f, -2.69587338e-02f, 1.73514721e-03f, 1.83489889e-01f, 1.65737256e-01f, -3.08256075e-02f, -5.58498735e-03f, 9.60601196e-02f,
  -6.70855120e-02f, -9.44063440e-03f, 5.79287224e-02f, -8.81526172e-02f, -5.98663576e-02f, 5.10516800e-02f, 2.12554350e-01f, 6.26984611e-02f, 3.21912766e-02f, -4.03004996e-02f,
  -4.05543409e-02f, 1.13734551e-01f, -1.21410377e-02f, 7.97265247e-02f, -7.12523386e-02f, 1.15224592e-01f, -2.82270610e-02f, -9.73667856e-03f, -1.04542159e-01f, -1.64165664e-02f,
  -1.24501050e-01f, -2.15949491e-01f, -2.24177733e-01f, -2.84834474e-01f, -5.93468025e-02f, -1.00658908e-01f, 6.20603515e-03f, 4.67972644e-03f, -1.37042880e-01f, -2.71742225e-01f,
  -1.26435012e-01f, -2.34475926e-01f, -1.57434851e-01f, -2.21813634e-01f, -1.96187809e-01f, 9.83627811e-02f, -6.27194867e-02f, -1.59415696e-02f, -8.32332894e-02f, -2.52688974e-01f,
  5.67620210e-02f, 2.08659321e-01f, 2.43910830e-02f, 1.39743462e-01f, 1.89117268e-01f, -2.10453242e-01f, -1.33730218e-01f, -4.62390715e-03f, 2.41466314e-01f, 1.61003232e-01f,
  -5.66327758e-02f, -1.42886519e-01f, 8.64616185e-02f, 2.84265224e-02f, -2.67845452e-01f, -8.95919204e-02f, -3.09787929e-01f, -1.71116069e-01f, -9.03997049e-02f, -2.79462844e-01f,
  -2.56776541e-01f, -2.40749680e-02f, 1.00640610e-01f, 1.20522916e-01f, -2.16345280e-01f, 3.86242382e-02f, -6.60434663e-02f, -1.78789094e-01f, 5.56199066e-03f, -7.53465220e-02f,
  -5.11031412e-02f, 4.41653579e-02f, 4.49669473e-02f, 7.54426932e-03f, -1.91420652e-02f, -2.64949873e-02f, -3.45535725e-02f, -6.72259927e-02f, 9.30865668e-03f, 6.58213422e-02f,
  3.11913602e-02f, 1.11092683e-02f, 1.10319585e-01f, 8.40623006e-02f, 7.05618337e-02f, 1.79011419e-01f, 2.11717561e-02f, 1.74348742e-01f, 5.72739579e-02f, -2.60177195e-01f,
  -1.27650887e-01f, 2.99609918e-02f, -1.14480462e-02f, 7.92588815e-02f, -1.61770638e-03f, 2.47221589e-02f, 1.81046613e-02f, -3.36007811e-02f, 1.42037310e-02f, 1.34141399e-02f,
  -3.38726081e-02f, 2.45106053e-02f, -6.75018923e-03f, -1.00798421e-01f, 4.06465679e-02f, 6.53643385e-02f, -8.84174407e-02f, -7.62910172e-02f, 5.92868738e-02f, 1.49121070e-02f,
  8.42838511e-02f, -2.20241230e-02f, 4.97081503e-02f, -4.44358476e-02f, 1.01885395e-02f, -5.55739664e-02f, 1.26931891e-01f, 6.25571087e-02f, 6.83890283e-02f, 9.45179909e-02f,
  -3.04315776e-01f, 1.07643984e-01f, -9.14071426e-02f, 1.08675137e-01f, -1.07385010e-01f, 7.54127726e-02f, -6.44371845e-03f, -8.16527605e-02f, -9.69076008e-02f, -3.19102742e-02f,
  -3.94557044e-02f, 3.77489142e-02f, -1.27586007e-01f, -6.20685853e-02f, -8.87880698e-02f, 1.38395563e-01f, 3.09933051e-02f, 2.55060196e-02f, 1.20848693e-01f, -6.51835576e-02f,
  -5.35923149e-03f, 2.35180464e-02f, 1.06160985e-02f, -4.96802963e-02f, 4.44212183e-02f, 1.56331122e-01f, -4.09894623e-02f, -1.76759511e-02f, 7.31957182e-02f, -3.15779239e-01f,
  -3.97423118e-01f, 3.05388659e-01f, 1.30521715e-01f, -1.12072118e-01f, 1.02594987e-01f, 4.16516215e-02f, 2.09632277e-01f, -3.29124518e-02f, -1.58308089e-01f, 2.05421969e-01f,
  1.59421172e-02f, -1.88900366e-01f, 1.66990533e-02f, 6.95008561e-02f, -5.67170158e-02f, 2.42091283e-01f, 2.22142503e-01f, -7.76859373e-02f, -3.74415547e-01f, -3.07882220e-01f,
  -6.35595098e-02f, -1.68860242e-01f, -3.49584818e-01f, -1.56858042e-01f, 1.28356248e-01f, -7.48675391e-02f, 2.04300523e-01f, 9.47596207e-02f, 1.33989928e-02f, 2.71698594e-01f,
  1.83105022e-01f, 1.55288085e-01f, -7.13610426e-02f, -2.50561059e-01f, 4.30019163e-02f, -8.26125741e-02f, 1.60880417e-01f, -8.46841000e-03f, 4.32735905e-02f, 5.35428636e-02f,
  2.55710036e-02f, 6.39346316e-02f, -7.96234906e-02f, -7.33826533e-02f, -2.00110421e-01f, -1.67724863e-01f, -7.42227510e-02f, -1.33722737e-01f, -1.28795907e-01f, -1.61994293e-01f,
  3.13463211e-02f, 5.40749989e-02f, 1.41369458e-02f, 4.75693680e-02f, -5.73590063e-02f, -6.28909469e-02f, -1.04409359e-01f, -6.86301142e-02f, -1.42749339e-01f, -5.82440384e-02f,
  4.41470332e-02f, 3.22159342e-02f, 7.93363005e-02f, -1.11555262e-02f, -5.40172830e-02f, 6.65244535e-02f, 1.12477362e-01f, 1.81505345e-02f, 4.03155275e-02f, -8.89928788e-02f,
  -1.04062781e-02f, 9.08415690e-02f, -2.86335647e-02f, 2.49841642e-02f, -2.02909159e-03f, -6.32082252e-03f, -1.44172655e-02f, -1.08312473e-01f, 7.91124031e-02f, 1.10861637e-01f,
  -7.46297687e-02f, 1.08708702e-01f, 3.89314815e-02f, -7.06036314e-02f, 1.08571835e-01f, 3.74868773e-02f, 2.54296586e-02f, 7.70921633e-03f, -4.39526886e-02f, -2.76386701e-02f,
  -1.85230836e-01f, 1.60406753e-01f, 1.54031619e-01f, -2.85957083e-02f, 8.53818357e-02f, -3.05297263e-02f, 3.38119678e-02f, -3.93646359e-02f, 6.41258657e-02f, -3.90060022e-02f,
  -4.19375114e-02f, 1.52776629e-01f, -6.42410759e-03f, -1.03202470e-01f, -1.65011540e-01f, -7.87862241e-02f, -7.25159496e-02f, -1.15435317e-01f, -7.80716445e-03f, -7.21290708e-02f,
  -1.23860873e-01f, -1.52661845e-01f, -2.48474509e-01f, -7.25061744e-02f, 6.51510432e-02f, -8.57820734e-02f, -1.68178268e-02f, -3.63758616e-02f, -1.16987705e-01f, -1.94992900e-01f,
  -3.65456700e-01f, -2.62002945e-01f, -2.71175563e-01f, -1.91247329e-01f, -1.37124345e-01f, -3.29638571e-02f, -2.55297542e-01f, -7.92490020e-02f, -1.20904446e-01f, -2.44838089e-01f,
  -1.69351250e-01f, -6.06390461e-02f, -2.73510605e-01f, -2.11111426e-01f, -2.23494947e-01f, -4.15702850e-01f, -2.50581324e-01f, -1.84352100e-01f, 7.17378482e-02f, 1.09412074e-01f,
  -1.41325280e-01f, -1.38460591e-01f, -2.18595922e-01f, -1.29182776e-02f, -1.70986265e-01f, -1.98044196e-01f, -3.16640288e-01f, -1.87939465e-01f, -1.12318769e-01f, -3.46765578e-01f,
  -2.50888526e-01f, 5.69872335e-02f, 1.11290678e-01f, -5.84817231e-02f, -3.27852108e-02f, 1.92336403e-02f, -1.49957374e-01f, -1.08630825e-02f, 6.16450757e-02f, 8.68691318e-03f,
  7.86798671e-02f, -6.16617920e-03f, -1.59372017e-02f, 9.65126529e-02f, -1.01263607e-02f, 1.29378140e-01f, 1.70592144e-01f, 2.22688131e-02f, 6.63419962e-02f, -4.62884782e-03f,
  1.39514491e-01f, 1.12051718e-01f, 8.20597112e-02f, 1.41320139e-01f, 1.33575723e-01f, 1.76596105e-01f, 5.21572959e-03f, 1.21781915e-01f, 1.20261252e-01f, 4.66082320e-02f,
  3.53103094e-02f, -2.12182123e-02f, -6.80601597e-03f, 9.05934907e-03f, 7.16888756e-02f, 1.05112806e-01f, -9.26808417e-02f, -2.56839897e-02f, 3.30049545e-02f, 9.99240763e-03f,
  -4.07271571e-02f, 2.83542741e-02f, -3.15611325e-02f, -3.85624729e-02f, -7.77482614e-02f, 1.40210334e-02f, -5.44397607e-02f, -6.54749498e-02f, 1.44896239e-01f, 1.14082191e-02f,
  8.24215040e-02f, 1.23212881e-01f, 1.13401981e-02f, 7.12386565e-03f, 1.21637546e-01f, 1.35086209e-01f, 1.14915058e-01f, 7.45177343e-02f, -3.16009186e-02f, -1.16290646e-02f,
  -1.73149645e-01f, 4.40883972e-02f, -1.33964851e-01f, 9.93969813e-02f, -6.86000511e-02f, 9.11726209e-04f, -5.13718277e-02f, 9.47054476e-03f, -8.12355578e-02f, 1.20155156e-01f,
  6.54678792e-02f, -1.16552956e-01f, -1.07866518e-01f, 9.04928893e-02f, -7.68305585e-02f, 2.01322380e-02f, -8.35693441e-03f, 2.91391369e-02f, 1.29497454e-01f, 5.66454567e-02f,
  5.54527491e-02f, 4.47149985e-02f, -1.04609936e-01f, -5.42669073e-02f, 7.61030847e-03f, -1.57597765e-01f, -8.07284787e-02f, -2.23877672e-02f, -8.00200030e-02f, -1.71743035e-01f,
  2.29906216e-02f, 2.94365525e-01f, 2.85437107e-01f, 2.97128148e-02f, 1.86884865e-01f, 3.69909316e-01f, 4.82287198e-01f, 1.77015558e-01f, -1.72621161e-01f, -3.50775793e-02f,
  1.25953928e-03f, -1.96426526e-01f, -2.72242397e-01f, -1.78476378e-01f, -5.29559441e-02f, 1.98139653e-01f, 8.51932913e-02f, -1.14922494e-01f, -8.71296972e-02f, 4.57665063e-02f,
  -5.52119836e-02f, -1.11104280e-01f, -2.42049545e-01f, -2.36732721e-01f, -1.63343951e-01f, -1.71224728e-01f, -6.67224899e-02f, 9.82719734e-02f, 1.23666890e-03f, -2.16409087e-01f,
  3.05454582e-01f, 3.78576756e-01f, -6.74247295e-02f, -1.27653107e-01f, 4.87308465e-02f, -1.24803908e-01f, -9.90426615e-02f, -7.81198144e-02f, 5.51873147e-02f, 1.64347142e-01f,
  5.99999875e-02f, -8.87888148e-02f, 1.28907606e-01f, -1.38274189e-02f, 1.42868280e-01f, 9.14224610e-03f, 4.81824875e-02f, 2.58270264e-01f, 9.85883325e-02f, -1.41936017e-03f,
  1.12423167e-01f, 1.61234856e-01f, 3.27248752e-01f, 1.92555994e-01f, 1.26058802e-01f, 7.64984936e-02f, 1.83727846e-01f, 1.48675188e-01f, 1.30375147e-01f, 6.34223446e-02f,
  -1.01794340e-01f, 2.94630975e-02f, 1.48034975e-01f, 3.81757598e-03f, 7.15712667e-04f, 2.19271872e-02f, 8.47907271e-03f, -5.29176369e-03f, -7.80207515e-02f, -2.07671806e-01f,
  -1.51000842e-02f, 1.96620315e-01f, 1.02911875e-01f, -3.27711999e-02f, -3.27207264e-03f, 1.29802763e-01f, 6.99114501e-02f, 5.59573509e-02f, 5.39275818e-02f, 9.62401703e-02f,
  1.02854989e-01f, 5.33107556e-02f, -5.78351989e-02f, 2.49313693e-02f, 9.70832780e-02f, 1.79434419e-01f, -3.74989398e-02f, -3.30205336e-02f, -1.84516430e-01f, -9.49755087e-02f,
  1.33039236e-01f, 2.88783193e-01f, -7.86666796e-02f, -2.11739123e-01f, -1.05974779e-01f, -9.05377194e-02f, -1.30287319e-01f, 2.86128302e-03f, -1.85690057e-02f, 1.04642205e-01f,
  8.60108361e-02f, -9.67427865e-02f, -4.73119356e-02f, -6.83588237e-02f, -2.37089857e-01f, -1.07556120e-01f, -5.04606143e-02f, -6.81356490e-02f, 5.76707125e-02f, -3.58268246e-02f,
  4.52062264e-02f, 7.13286847e-02f, -1.12559777e-02f, -1.65473267e-01f, -1.70990899e-01f, -2.34887570e-01f, -2.77403891e-02f, -1.17062829e-01f, 1.81044322e-02f, -2.03394368e-01f,
  9.00009155e-01f, 8.32984671e-02f, 1.98891938e-01f, 1.84614006e-02f, -2.26103276e-01f, -3.34301740e-02f, -7.07385913e-02f, -5.39363921e-02f, -4.23809402e-02f, 4.00372455e-03f,
  2.19822645e-01f, 2.34732464e-01f, 2.03399912e-01f, 4.42469977e-02f, 1.77327529e-01f, -6.95848763e-02f, -2.06173390e-01f, 1.51739255e-01f, 1.57690451e-01f, -4.84180227e-02f,
  -1.06303506e-01f, -1.06234893e-01f, 1.12866268e-01f, -7.74923787e-02f, -1.60542741e-01f, -1.13550454e-01f, -1.05569795e-01f, -1.29574478e-01f, -1.02934219e-01f, -3.41086984e-01f,
  1.98799614e-02f, 3.11125547e-01f, -1.46479800e-03f, -2.19908962e-03f, 1.19118299e-02f, 1.19521037e-01f, 2.12253574e-02f, 6.40493408e-02f, 9.27470066e-03f, -1.61979198e-02f,
  -7.85113052e-02f, -9.62345004e-02f, -2.00689547e-02f, -3.31042558e-02f, -4.03930142e-04f, 1.04109585e-01f, -8.36771261e-03f, 6.90155104e-02f, -3.82287148e-03f, -9.04211923e-02f,
  -1.54458582e-01f, 5.19466139e-02f, 1.89667325e-02f, 6.22762181e-02f, 8.20819587e-02f, 4.37248275e-02f, 1.52780533e-01f, 9.13930684e-02f, 1.58708304e-01f, 9.76631492e-02f,
  -4.99276370e-02f, -9.13421251e-03f, 2.40842625e-02f, 1.20077252e-01f, -2.65657413e-03f, 3.81399579e-02f, -1.55686941e-02f, 4.59135845e-02f, -4.24034670e-02f, -6.28106520e-02f,
  -3.23708393e-02f, 2.92881858e-02f, 6.34324178e-02f, 9.44006741e-02f, -1.40976412e-02f, -1.25214279e-01f, -3.12487152e-03f, -2.35137101e-02f, 2.31546294e-02f, -1.01306543e-01f,
  6.22682199e-02f, -5.29386401e-02f, -8.00586566e-02f, -1.52653567e-02f, -6.64455295e-02f, 8.25304016e-02f, -4.11950797e-02f, -3.03091854e-02f, -1.76354125e-01f, -9.76393446e-02f,
  -2.64393389e-01f, 3.45644683e-01f, -6.42777188e-03f, -1.39607280e-01f, 3.79562229e-02f, 1.58128086e-02f, 1.48868516e-01f, -6.43687248e-02f, -2.23388895e-02f, 6.33220747e-02f,
  7.01657087e-02f, 1.13412872e-01f, 7.58422771e-03f, -1.44412085e-01f, -5.22440672e-02f, 3.21514010e-02f, 9.16525871e-02f, 6.17584810e-02f, -2.84016691e-02f, -2.28715852e-01f,
  -2.12299734e-01f, 4.21935916e-02f, 1.18960112e-01f, 3.97573560e-02f, 3.65450494e-02f, 1.48180738e-01f, -1.00965098e-01f, -6.54461533e-02f, 1.04519717e-01f, -6.39027879e-02f,
  6.13152720e-02f, 2.33879872e-02f, -3.27794664e-02f, 7.75143132e-02f, 1.84339166e-01f, 2.19599262e-01f, 1.31101176e-01f, 1.63947478e-01f, 1.15803845e-01f, -9.48209688e-02f,
  1.98047414e-01f, 1.03887290e-01f, -3.74664292e-02f, -1.22721404e-01f, -1.31242439e-01f, -2.59553194e-01f, -3.61051947e-01f, -2.39100531e-01f, 4.27912036e-03f, 2.02892318e-01f,
  7.88002647e-03f, -8.13800991e-02f, 1.17642414e-02f, 8.48246366e-03f, -2.09610939e-01f, -2.20529199e-01f, -2.08999231e-01f, -9.70914140e-02f, -1.48717612e-01f, -3.04540813e-01f,
  9.99583490e-03f, 3.19825679e-01f, -2.78206058e-02f, -1.69917166e-01f, -2.14753058e-02f, -7.61994272e-02f, 1.95471365e-02f, -6.86032698e-02f, -3.27285491e-02f, 7.03364313e-02f,
  -2.53872722e-02f, -2.58150660e-02f, -4.41673063e-02f, 2.62863338e-02f, -4.78462316e-03f, 9.89718363e-02f, 1.70494050e-01f, 5.49144037e-02f, -1.49316430e-01f, 6.34028763e-02f,
  -9.20399353e-02f, 1.46883711e-01f, 1.27827123e-01f, 2.92362701e-02f, 9.46104825e-02f, -6.44565001e-02f, 8.61428678e-02f, 1.07491538e-01f, -5.38579794e-03f, -3.38290036e-01f,
  -2.03551096e-03f, -4.95584086e-02f, 6.75545111e-02f, 5.67245074e-02f, -4.42270946e-04f, 7.44578391e-02f, -3.13685536e-02f, 2.85061598e-02f, 7.82134198e-03f, -7.08254203e-02f,
  1.35405585e-01f, -3.94291393e-02f, 4.63342778e-02f, -1.01118833e-02f, -1.28590137e-01f, 2.77725924e-02f, 2.92545184e-03f, -1.58051744e-01f, -2.25619823e-02f, 4.33567837e-02f,
  1.57884024e-02f, -2.54475288e-02f, 1.77858296e-04f, -1.44698881e-02f, 2.32301615e-02f, -2.10505396e-01f, -6.44772649e-02f, 1.14866689e-01f, 1.81766152e-01f, 4.02700715e-02f,
  2.26281323e-02f, -1.96547508e-02f, -2.21301168e-01f, 1.01121210e-01f, -1.14267208e-02f, 7.77788162e-02f, 9.87961292e-02f, 6.31356146e-03f, -7.12750331e-02f, -1.97325163e-02f,
  7.23179057e-02f, 1.65149302e-03f, -3.89070553e-03f, 5.06475084e-02f, 5.29593863e-02f, 6.24092817e-02f, 1.50529623e-01f, -7.23364130e-02f, -4.58021425e-02f, 1.04649939e-01f,
  -1.23699099e-01f, -4.86110337e-02f, -9.99473594e-03f, -1.24477074e-01f, -1.60313949e-01f, -1.79263920e-01f, -9.91510525e-02f, -1.10666767e-01f, -2.62009859e-01f, -4.06935453e-01f,
  -7.24685863e-02f, 4.97895539e-01f, 9.26938877e-02f, -1.82131693e-01f, 2.64166534e-01f, 2.96802372e-01f, 5.33118427e-01f, 1.18741123e-02f, -2.55596280e-01f, 1.84820458e-01f,
  1.61404192e-01f, -2.48819754e-01f, -1.36166871e-01f, -4.83575054e-02f, 2.96110883e-02f, 2.09788725e-01f, 5.78163862e-02f, -2.00121313e-01f, -2.85613120e-01f, -1.14979453e-01f,
  -7.55297095e-02f, -6.06288649e-02f, -1.81579202e-01f, -8.28279927e-02f, 1.38396904e-01f, -1.87506601e-01f, -5.04523003e-03f, 9.31896046e-02f, 9.95311737e-02f, 1.26953200e-01f,
  8.16765204e-02f, 2.57163405e-01f, -3.23893994e-01f, -8.65879655e-02f, -4.29233238e-02f, -8.02794695e-02f, 5.09417355e-02f, -1.16335832e-01f, 2.99169626e-02f, 1.06420517e-01f,
  3.37983929e-02f, 1.51171669e-01f, 7.93145075e-02f, 8.31199363e-02f, 2.33820211e-02f, 3.14212926e-02f, -9.81391072e-02f, 6.19425923e-02f, -7.48485774e-02f, 9.45365231e-04f,
  2.93096192e-02f, 1.09895453e-01f, 2.08820075e-01f, 6.67380765e-02f, 3.39955017e-02f, -9.31900814e-02f, 1.47320181e-01f, 7.16280639e-02f, -4.14739624e-02f, -1.12433426e-01f,
  6.17081448e-02f, 2.32776534e-02f, 6.03299029e-02f, 2.06035003e-02f, -1.21225357e-01f, 4.28485610e-02f, -1.82300638e-02f, 1.03387542e-01f, 2.86789723e-02f, 1.01781845e-01f,
  -2.02053562e-02f, -3.00858300e-02f, -7.53881857e-02f, 2.17542443e-02f, -9.53222364e-02f, -6.71461299e-02f, 2.06477642e-02f, 1.32605761e-01f, -6.70230528e-03f, 7.15967193e-02f,
  -1.31851714e-02f, 1.96933616e-02f, 2.85936482e-02f, 2.38957535e-02f, -9.99982804e-02f, -8.35415050e-02f, -6.65858164e-02f, -1.68441273e-02f, 3.31620239e-02f, 6.17680848e-02f,
  -3.73376995e-01f, 9.52399895e-02f, -2.42780060e-01f, -7.13971332e-02f, 2.02146739e-01f, 7.28667751e-02f, 1.53462917e-01f, 4.77281064e-02f, 2.05913469e-01f, -2.91354991e-02f,
  -7.25586042e-02f, -1.37155011e-01f, -8.01386312e-02f, -4.78754304e-02f, -1.36604995e-01f, -3.39328125e-02f, 9.53342095e-02f, -2.11513303e-02f, -1.35728613e-01f, -9.43537429e-02f,
  -1.23243690e-01f, -2.68703908e-01f, -7.11165071e-02f, 6.83825091e-02f, -1.33746505e-01f, -3.20213288e-01f, -1.40076786e-01f, -1.42499715e-01f, -1.55677944e-01f, -2.76735723e-01f,
  -5.86762130e-01f, -9.97942835e-02f, -2.24411711e-01f, -1.50867715e-01f, 2.89816052e-01f, 2.33718887e-01f, 1.39041245e-01f, 5.39522804e-02f, 2.03130785e-02f, -1.67738479e-02f,
  1.37205482e-01f, 1.78733692e-01f, 9.57192928e-02f, 1.03424393e-01f, -3.90785299e-02f, 2.28497058e-01f, 2.33663157e-01f, -4.42847721e-02f, -7.15324730e-02f, 1.22712493e-01f,
  2.57207453e-01f, -1.26392066e-01f, -3.08657676e-01f, 2.08300613e-02f, 8.06914717e-02f, -4.49603088e-02f, -1.78302918e-02f, -1.60558283e-01f, 1.07161395e-01f, -1.91177204e-02f,
  -1.80277705e-01f, -3.09591413e-01f, 8.28498323e-03f, -6.32524304e-03f, -2.40043942e-02f, -1.69080302e-01f, -7.05226585e-02f, -1.72478572e-01f, 5.31336153e-03f, -1.35286659e-01f,
  -7.35674948e-02f, -4.45224121e-02f, 8.34124163e-02f, 1.07025616e-01f, -1.19226426e-01f, 4.56625000e-02f, -2.37447489e-02f, -2.16439337e-01f, -1.01578601e-01f, -1.45170107e-01f,
  2.61049271e-01f, 2.23232761e-01f, -1.62705570e-01f, -3.26412953e-02f, 7.58087784e-02f, -2.23756023e-02f, -1.49978235e-01f, -9.13856924e-02f, -1.85621068e-01f, -2.63984919e-01f,
  -1.19793164e-02f, 1.81657175e-04f, 2.22655406e-04f, 4.84204851e-02f, 1.73820555e-03f, 4.10022885e-02f, 7.79940933e-03f, 1.26618683e-01f, 3.58851850e-02f, -7.00344443e-02f,
  -6.65331408e-02f, 9.31093693e-02f, -2.78620627e-02f, -4.63496447e-02f, 5.76949306e-02f, -4.35468741e-02f, 5.83505258e-02f, -1.01389006e-01f, -2.87886001e-02f, -9.83062387e-02f,
  5.19723296e-02f, -6.26880750e-02f, 4.93999310e-02f, -1.01173423e-01f, 2.77308207e-02f, -2.98619550e-02f, 1.11884736e-01f, 3.13445665e-02f, 4.44352105e-02f, -1.20225228e-01f,
  -2.59957165e-01f, 4.11982127e-02f, -8.84707272e-02f, 5.22494130e-02f, -5.62564097e-02f, 1.61576029e-02f, -1.90859437e-02f, -3.26205455e-02f, -8.79388824e-02f, -6.95340037e-02f,
  -4.84886467e-02f, -1.59495231e-02f, -2.34257113e-02f, -3.87493297e-02f, -1.42551243e-01f, -2.45791432e-02f, 9.59113911e-02f, 4.37252177e-03f, 2.63418984e-02f, 2.50047743e-02f,
  -5.39898686e-02f, -5.12790866e-04f, -5.93491010e-02f, -1.05553478e-01f, -8.25869218e-02f, -9.53679308e-02f, -2.10032657e-01f, -1.00238070e-01f, -2.00087577e-01f, -3.14600736e-01f,
  3.59402150e-01f, -9.60460976e-02f, 6.91646785e-02f, 1.99443609e-01f, 3.12742561e-01f, 2.99848706e-01f, 2.06466943e-01f, 2.22250029e-01f, 1.49026752e-01f, 1.34340331e-01f,
  1.73128963e-01f, 3.58353168e-01f, 3.32109302e-01f, 2.05520704e-01f, 8.81368220e-02f, -3.07464842e-02f, -7.74997547e-02f, 5.18092103e-02f, 3.29906903e-02f, 8.59110802e-02f,
  -8.83961655e-03f, -3.51619795e-02f, -8.79732240e-03f, 5.25032356e-02f, -1.64395094e-01f, 1.48947835e-01f, 1.57600939e-02f, -8.67541507e-02f, -8.44226256e-02f, -2.90349334e-01f,
  -2.24867478e-01f, 1.30579576e-01f, -7.32541382e-02f, 1.01263337e-01f, -3.73540781e-02f, -3.81910913e-02f, 1.13709294e-03f, -1.06778100e-01f, -2.53648441e-02f, -1.03958145e-01f,
  -1.05136380e-01f, -1.70920789e-01f, -6.95910901e-02f, 5.83402328e-02f, -1.09438812e-02f, -1.25053778e-01f, -1.26147583e-01f, -5.06812632e-02f, 2.02786438e-02f, -4.65602688e-02f,
  2.93225469e-03f, 4.90207486e-02f, -9.87910181e-02f, 9.99974757e-02f, 3.51714413e-03f, 2.53479257e-02f, 7.84804896e-02f, -5.09400740e-02f, -1.27247125e-01f, -1.56785697e-01f,
  1.61475241e-01f, -5.50622605e-02f, -5.24929841e-04f, -4.26339656e-02f, 5.05038351e-02f, -1.42414831e-02f, -1.25333622e-01f, -1.23435445e-01f, -5.48542552e-02f, -2.37635635e-02f,
  -2.94270739e-02f, 1.34852789e-02f, -2.56317165e-02f, 1.43968395e-03f, 1.26766354e-01f, -9.57539454e-02f, -1.03739724e-01f, 1.20517425e-02f, 2.87124189e-03f, 1.21701851e-01f,
  1.08747698e-01f, -2.21056137e-02f, 3.35745886e-02f, -6.49899915e-02f, -7.18832687e-02f, -2.39233230e-03f, 4.17492874e-02f, -3.57042961e-02f, 3.86137031e-02f, 4.39469032e-02f,
  -1.15029104e-01f, 3.45309943e-01f, 6.24339143e-03f, -1.50696948e-01f, -1.89819276e-01f, 5.55269681e-02f, 8.34965184e-02f, -1.05614483e-01f, -9.48500857e-02f, -6.55561835e-02f,
  -4.33247685e-02f, -4.08232249e-02f, 4.30020578e-02f, -1.24563336e-01f, -8.71371403e-02f, 5.08452728e-02f, 4.46050093e-02f, -3.80485579e-02f, -4.02044170e-02f, -1.41268998e-01f,
  -6.68558031e-02f, 2.72617321e-02f, -1.90536767e-01f, -8.43256190e-02f, -9.46256667e-02f, -4.81079146e-02f, 5.88447973e-02f, -1.15489788e-01f, -6.40838593e-02f, 5.55393770e-02f,
  2.63309807e-01f, -4.49567623e-02f, 2.56293625e-01f, 1.53289929e-01f, 9.75752920e-02f, 1.69267029e-01f, 2.31504709e-01f, 1.47882015e-01f, -8.81860927e-02f, -8.50120857e-02f,
  -2.81775326e-01f, -2.91070342e-01f, -2.61806130e-01f, -3.08541596e-01f, -1.54182240e-02f, 1.26584142e-01f, 8.34318325e-02f, 8.62181708e-02f, 1.83582023e-01f, 1.37124389e-01f,
  -7.97579288e-02f, -9.75349993e-02f, -2.26119161e-02f, -3.98878232e-02f, 9.79111269e-02f, -4.67737205e-02f, 4.34937514e-02f, -3.76259200e-02f, -9.57355835e-03f, 6.17807731e-02f,
  7.38411844e-02f, 8.84793624e-02f, 5.55745838e-03f, -2.46571198e-01f, -2.75096837e-02f, -3.63374837e-02f, 1.34511618e-02f, -5.07425331e-02f, -9.26347449e-02f, -7.59456307e-03f,
  -1.26948282e-01f, 8.67239535e-02f, 8.61931667e-02f, -3.29399183e-02f, 4.82173972e-02f, -1.19213834e-02f, 5.86810037e-02f, -1.45332878e-02f, -1.03015453e-02f, 2.90114572e-03f,
  -8.92120451e-02f, 1.96192693e-02f, 3.49316485e-02f, 4.25827391e-02f, 2.08562613e-01f, 6.02073446e-02f, -3.03317159e-02f, 7.98103139e-02f, 8.76696067e-05f, 8.92870203e-02f,
  -2.79359259e-02f, 8.91060978e-02f, 1.15592524e-01f, 3.99089381e-02f, 1.73826113e-01f, 5.07459566e-02f, 1.36953577e-01f, 1.03931772e-02f, 1.70074522e-01f, 1.03447653e-01f,
  9.91087407e-02f, 1.38742000e-01f, 1.35967866e-01f, 1.07410051e-01f, 1.43289091e-02f, 1.39352858e-01f, -2.99731735e-02f, 3.23186889e-02f, 1.02090903e-01f, 7.90118426e-02f,
  3.08761876e-02f, 7.40601495e-03f, 3.42162512e-02f, 6.38296008e-02f, 7.83659071e-02f, 3.57536227e-02f, 3.24448496e-02f, 4.20877971e-02f, 9.60858613e-02f, 1.05322674e-01f,
  -1.83107719e-01f, -4.93720621e-02f, -9.33612958e-02f, -1.93502054e-01f, 8.33485052e-02f, -4.44239471e-04f, -8.26148093e-02f, -1.09977700e-01f, -6.06121123e-02f, 2.92734466e-02f,
  -9.14966017e-02f, -7.57781265e-04f, 2.98102349e-02f, 1.19104169e-01f, 1.90798208e-01f, -4.58398983e-02f, -9.18467641e-02f, -1.87139176e-02f, -1.89382061e-01f, -1.98863611e-01f,
  -3.61088626e-02f, 4.85792235e-02f, 6.75905496e-02f, -2.59574316e-02f, 7.61043951e-02f, 7.00336173e-02f, 3.76026928e-02f, 9.84676853e-02f, 3.83341797e-02f, 1.21296411e-02f,
  2.12186366e-01f, 2.17881337e-01f, 1.14304423e-01f, 5.43362349e-02f, -5.64402491e-02f, -1.85074896e-01f, -1.80086255e-01f, -1.63614690e-01f, 5.86038735e-03f, 1.28746917e-03f,
  -5.29902503e-02f, 4.75078337e-02f, 1.29810482e-01f, -2.53193397e-02f, -1.34792300e-02f, 8.12653750e-02f, 2.16059685e-01f, 1.83676207e-03f, -8.45977589e-02f, -7.71408603e-02f,
  8.63686427e-02f, 3.05106286e-02f, -9.06141102e-02f, 3.06255929e-03f, 1.64223358e-01f, -1.13177970e-01f, -6.57522529e-02f, 1.17538743e-01f, 7.31303915e-02f, 4.10079628e-01f,
  2.09695742e-01f, 1.11240081e-01f, -2.13692561e-01f, -9.75773036e-02f, 5.57998009e-03f, 3.16207414e-03f, -1.38998199e-02f, 1.20148122e-01f, 1.33050755e-02f, -4.83669527e-03f,
  2.14323238e-01f, 9.33205113e-02f, 1.12328589e-01f, -8.81646946e-02f, -5.82306050e-02f, -1.58656389e-01f, 4.59063128e-02f, 4.06937003e-02f, -2.71816719e-02f, -8.85655954e-02f,
  1.47863671e-01f, 1.33440286e-01f, -7.60570988e-02f, -2.08367273e-01f, -7.64713734e-02f, -7.97624663e-02f, -5.76708056e-02f, 7.62728378e-02f, -1.30382016e-01f, 3.96915860e-02f,
  -1.62983835e-01f, -6.19729832e-02f, 9.02273431e-02f, 4.41132747e-02f, -4.75398563e-02f, 1.36022702e-01f, 4.53834310e-02f, 3.78149264e-02f, -3.58670205e-02f, 1.09127291e-01f,
  -1.63484171e-01f, -4.03873287e-02f, -1.60175674e-02f, 7.12270662e-03f, -7.47091770e-02f, 1.62858069e-02f, -9.03029218e-02f, -6.87318295e-02f, -5.91512397e-02f, 2.39402317e-02f,
  3.61603312e-02f, 7.94006586e-02f, 4.82065789e-02f, 5.42760082e-03f, 6.72660349e-03f, 9.22854096e-02f, 1.05500463e-02f, -9.64867845e-02f, -1.00745834e-01f, 8.30172375e-02f,
  -1.02923596e-02f, -2.32467189e-01f, 1.21180490e-02f, 3.53213735e-02f, -5.08938683e-03f, 2.27624439e-02f, -4.12538946e-02f, 1.39420095e-03f, -4.43503894e-02f, 1.55199589e-02f,
  9.67296064e-02f, -7.53915263e-03f, 6.30307421e-02f, 2.24016272e-02f, -4.60667461e-02f, -7.46516231e-03f, -9.80228186e-02f, -1.23487256e-01f, -8.05875584e-02f, 3.19035091e-02f,
  -1.69128031e-02f, -3.24954838e-02f, -1.12661287e-01f, -1.07531741e-01f, -7.74178058e-02f, -5.90223782e-02f, -7.12427944e-02f, -2.99084205e-02f, -3.40442598e-01f, -2.70569861e-01f,
  -2.32043847e-01f, 2.17720911e-01f, -3.41957837e-01f, -9.78092328e-02f, -1.40345261e-01f, -1.39168173e-01f, 1.12277895e-01f, 8.09696019e-02f, -2.67714206e-02f, -3.77468690e-02f,
  6.27082912e-03f, 5.38646318e-02f, -7.65349865e-02f, -5.68266101e-02f, -1.44501433e-01f, -1.35524035e-01f, -1.82174742e-01f, -2.47273088e-01f, 8.68013278e-02f, 1.53307602e-01f,
  1.43058091e-01f, 6.76728338e-02f, 2.68393587e-02f, 1.70703843e-01f, 1.27931878e-01f, 1.29949212e-01f, 4.21826132e-02f, -8.12126622e-02f, 5.63706234e-02f, -5.33154011e-02f,
  5.48430905e-02f, -1.51608661e-01f, -1.66801974e-01f, 2.27400847e-03f, 2.69689579e-02f, -1.42634541e-01f, 3.13155651e-02f, -6.67910576e-02f, -1.61829948e-01f, 1.73105877e-02f,
  -1.14926584e-01f, -1.31785814e-02f, -1.21509314e-01f, -1.64838303e-02f, 9.03229937e-02f, -1.74015644e-04f, -1.50714144e-01f, -2.26918623e-01f, -1.66216657e-01f, -1.78045452e-01f,
  -1.79010481e-01f, -1.32411852e-01f, -9.21700522e-02f, 5.07789403e-02f, -9.24952850e-02f, -2.38048658e-01f, 2.59890594e-02f, -6.96732700e-02f, 2.26631649e-02f, 1.21253014e-01f,
  -2.57265177e-02f, -3.64448950e-02f, -6.92521706e-02f, -2.04131324e-02f, 7.78823420e-02f, -2.42357906e-02f, -6.57344162e-02f, 1.34222537e-01f, -3.04785334e-02f, -4.15172540e-02f,
  -6.17465004e-02f, -9.21286494e-02f, 7.10282614e-03f, -5.51117882e-02f, -8.23251810e-03f, -6.36176988e-02f, -4.93086390e-02f, 4.26619351e-02f, 2.99140345e-03f, 8.34962875e-02f,
  5.38026579e-02f, -2.26203501e-02f, 1.02378964e-01f, 3.66645679e-02f, 2.91934479e-02f, 6.43487722e-02f, -4.09437940e-02f, 2.71433666e-02f, 6.89633563e-03f, -1.58675104e-01f,
  2.50828803e-01f, -2.12083250e-01f, -7.01569244e-02f, 1.91508010e-01f, 1.37512475e-01f, -1.62500888e-01f, 1.01546451e-01f, 1.14150427e-01f, -1.15446270e-01f, 4.88213785e-02f,
  -7.08760694e-02f, 1.13432324e-02f, 9.41791460e-02f, 8.49353895e-02f, 3.48614231e-02f, 5.33890128e-02f, 5.54310577e-03f, -4.05096114e-02f, 2.33669095e-02f, 1.22141493e-02f,
  6.27570553e-03f, 9.05514657e-02f, 1.61520652e-02f, 4.78736237e-02f, 6.03256859e-02f, -3.37330140e-02f, 1.83497891e-01f, 1.39970332e-01f, 9.74412411e-02f, 2.46517256e-01f,
  -1.58328876e-01f, -1.71196759e-01f, 4.93414849e-02f, 2.69880652e-01f, 3.63046169e-01f, -7.84041509e-02f, -2.05721185e-01f, -3.58896762e-01f, -8.36776271e-02f, 5.93596213e-02f,
  1.99019611e-01f, 1.75710902e-01f, 5.72777539e-02f, 8.85362457e-03f, -4.90123302e-01f, -1.38673291e-01f, 4.37936857e-02f, -6.25735074e-02f, -3.74068558e-01f, -2.04001620e-01f,
  6.36537224e-02f, 2.93512549e-02f, -1.10291123e-01f, -1.64975286e-01f, 1.88700229e-01f, 1.41554013e-01f, 1.64445356e-01f, 1.76066145e-01f, 1.04743458e-01f, 3.06745231e-01f,
  8.35469216e-02f, -9.90728959e-02f, -5.39582968e-02f, 1.12439260e-01f, 5.20297214e-02f, -9.96195823e-02f, -9.00150612e-02f, -3.82430595e-03f, 9.87434164e-02f, -5.62489331e-02f,
  2.12080359e-01f, -1.22636341e-01f, 1.49742961e-01f, 3.83057222e-02f, -1.69202372e-01f, -1.06751882e-01f, -2.42115334e-01f, -1.53341115e-01f, -2.89681613e-01f, -3.27063173e-01f,
  1.07263565e-01f, 1.07017152e-01f, 1.35035485e-01f, -1.77943874e-02f, -1.99735940e-01f, 6.88452199e-02f, 7.86082372e-02f, 1.18648507e-01f, -1.55422345e-01f, 6.75315112e-02f,
  -1.30498067e-01f, -6.46805316e-02f, -3.97470184e-02f, 7.52857421e-03f, 3.38032818e-03f, 3.67480814e-02f, 1.08229555e-01f, 1.87990963e-02f, 4.42291833e-02f, 5.37778623e-02f,
  2.31759623e-02f, -3.21989395e-02f, 3.37993093e-02f, -1.56172767e-01f, 6.50829449e-02f, 2.66333595e-02f, -5.38053922e-02f, -8.69143456e-02f, 1.98534094e-02f, 3.60365398e-02f,
  -1.00796195e-02f, 6.14268556e-02f, -6.84736520e-02f, -1.32753998e-01f, -4.36315984e-02f, 1.01852911e-02f, -3.87295000e-02f, -4.11055535e-02f, 9.65439975e-02f, 8.58970582e-02f,
  3.33782323e-02f, 1.47023171e-01f, -1.20016420e-02f, -6.06435351e-02f, 6.35401756e-02f, 9.45702847e-03f, 3.63456458e-02f, -8.64123851e-02f, 1.40580833e-02f, -1.98408946e-01f,
  -1.05226874e-01f, 5.97984344e-03f, 7.44462237e-02f, 4.10346314e-02f, -1.43081114e-01f, -2.19905097e-02f, -3.74332629e-02f, -1.98630076e-02f, -5.92532083e-02f, 3.78442891e-02f,
  -2.67263316e-02f, -2.10532099e-01f, -6.40233532e-02f, 5.08729406e-02f, 7.48902606e-03f, -9.07109529e-02f, -1.32970540e-02f, 9.26856175e-02f, -1.32026091e-01f, -2.02927932e-01f,
  7.81757459e-02f, -5.05628586e-01f, -1.16485193e-01f, 2.38496363e-02f, -2.31528237e-01f, -2.08458856e-01f, -5.61506331e-01f, -1.30002454e-01f, 1.10424019e-01f, -4.50037450e-01f,
  -2.75666475e-01f, 2.31720150e-01f, 2.09125757e-01f, 1.59937888e-01f, 1.19158715e-01f, -3.61999154e-01f, -2.46272311e-01f, 2.20501885e-01f, 3.34305078e-01f, -5.16381003e-02f,
  -2.44364604e-01f, 3.95734720e-02f, 2.35379979e-01f, 9.36637670e-02f, -2.01569349e-01f, 7.21717998e-02f, -1.10256523e-01f, -7.49132633e-02f, -1.53974250e-01f, -4.12925392e-01f,
  6.82487413e-02f, -5.53005971e-02f, 1.44030705e-01f, -2.75059901e-02f, -3.07907797e-02f, 5.19503169e-02f, -8.82105753e-02f, 9.61378589e-02f, -9.28084552e-02f, -2.89070187e-03f,
  5.70414551e-02f, 8.16309154e-02f, 2.36741632e-01f, -2.37274636e-02f, -4.35198694e-02f, -1.76403105e-01f, -9.75159556e-03f, 8.53575915e-02f, -4.91986284e-03f, -1.42611817e-01f,
  -1.17701456e-01f, -1.00831404e-01f, 1.00051895e-01f, -7.48621440e-03f, 6.76964894e-02f, 1.43436387e-01f, -1.59944296e-01f, -1.19347520e-01f, -3.29338536e-02f, -3.15120101e-01f,
  -8.44518915e-02f, -2.94071939e-02f, -6.20878972e-02f, 1.37282191e-02f, 1.99659215e-03f, -2.17564553e-02f, 7.64028504e-02f, 1.88611206e-02f, 3.92964184e-02f, 1.83357000e-02f,
  9.39942226e-02f, -4.49730791e-02f, 1.35152429e-01f, -4.47292887e-02f, -4.01871949e-02f, -4.76435013e-02f, 1.39338905e-02f, -6.43333122e-02f, -7.75516778e-02f, -3.19620408e-02f,
  2.48868130e-02f, -1.11099415e-01f, -1.04164012e-01f, 5.53730875e-03f, 3.95216197e-02f, 4.98465262e-02f, -1.17998458e-02f, 6.63857460e-02f, 4.38271314e-02f, 2.46145334e-02f,
  2.58326769e-01f, 8.19339976e-02f, -7.49674886e-02f, 3.21854390e-02f, -1.09014422e-01f, -1.31506547e-02f, -5.19450791e-02f, -4.61026430e-02f, 7.74757564e-02f, -1.20480388e-01f,
  -6.22562468e-02f, 1.61228597e-01f, 1.22063465e-01f, -9.72417668e-02f, -6.71958402e-02f, 4.98142745e-03f, -1.37737736e-01f, 1.01326704e-01f, -4.10595909e-02f, -6.23080172e-02f,
  -5.49410544e-02f, -1.42144546e-01f, 8.31879526e-02f, 4.57088426e-02f, -4.69046980e-02f, 1.73015758e-01f, -5.50892130e-02f, -1.64078787e-01f, 4.87143323e-02f, -2.24603325e-01f,
  1.39175355e-01f, 2.22723201e-01f, 2.23918587e-01f, 5.05031534e-02f, -3.40541303e-02f, 1.83907971e-01f, 4.35113162e-01f, 1.24845535e-01f, -1.94585875e-01f, -2.39348342e-03f,
  -8.90030041e-02f, -2.52523929e-01f, -1.98313117e-01f, -1.16496608e-01f, 2.06146106e-01f, 1.35246232e-01f, 1.47821292e-01f, -1.53648760e-02f, 6.33989200e-02f, 1.30708918e-01f,
  -4.83793952e-02f, 6.67567700e-02f, 5.68967909e-02f, -1.11324482e-01f, 3.60461399e-02f, -2.14557990e-01f, 4.91327494e-02f, 2.39418112e-02f, 8.52506533e-02f, 1.20727815e-01f,
  1.55556142e-01f, 1.36039570e-01f, -2.36198112e-01f, -1.92364439e-01f, 1.91845987e-02f, -5.74288927e-02f, -2.06163693e-02f, 3.44405957e-02f, -6.17175959e-02f, 1.94906406e-02f,
  6.65646791e-02f, 7.10667968e-02f, 3.70168723e-02f, 6.63952231e-02f, 5.72619103e-02f, -3.70799974e-02f, 1.09809488e-01f, 2.66104490e-02f, -1.86005905e-02f, 4.24221382e-02f,
  8.59015882e-02f, -6.56173453e-02f, 8.72113332e-02f, 1.72197185e-02f, 9.70700905e-02f, -9.19681489e-02f, 8.32798034e-02f, 8.42990056e-02f, 4.96168137e-02f, 2.36364119e-02f,
  -1.12067930e-01f, 4.62422371e-02f, -3.23742852e-02f, 6.28799126e-02f, -5.28757200e-02f, -5.13597876e-02f, -5.19473702e-02f, 5.09385355e-02f, 6.31924272e-02f, 3.07471976e-02f,
  -4.20112200e-02f, 1.58433768e-03f, 1.10514708e-01f, 4.06428948e-02f, -1.44404080e-03f, 1.69683006e-02f, 8.17535743e-02f, 2.80645788e-02f, 6.46887161e-03f, -3.26397782e-03f,
  -1.29615786e-02f, 1.87754873e-02f, -4.16842103e-02f, 4.29806300e-03f, 3.66299902e-03f, -9.58620310e-02f, -5.27093224e-02f, 4.64695953e-02f, -3.98852900e-02f, -3.23495381e-02f,
  -2.49246210e-01f, -1.14165008e-01f, -2.03836367e-01f, -7.82676339e-02f, 3.73113491e-02f, -3.64424996e-02f, 1.45607749e-02f, 1.57808643e-02f, 9.50385258e-02f, -1.45156570e-02f,
  -7.65411109e-02f, -5.73802665e-02f, -3.63132060e-02f, 1.98020246e-02f, 7.53998430e-03f, -8.24007168e-02f, -1.49393484e-01f, 2.26305183e-02f, -8.39783847e-02f, -8.14837888e-02f,
  2.94334861e-03f, -4.51188274e-02f, -4.91894744e-02f, -1.88348100e-01f, -1.64071500e-01f, -1.74107999e-01f, -9.29594487e-02f, -1.11142501e-01f, -2.39981730e-02f, -3.63557972e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.01548322e-01f, 4.73399609e-02f, 5.95225953e-02f, 1.06819779e-01f, 1.03678741e-01f, -1.15538180e-01f, 3.40368925e-03f, -3.87014523e-02f, 1.15643255e-01f, 6.99410215e-02f,
  2.12536603e-01f, 3.31652910e-02f, -6.99811205e-02f, 4.23536971e-02f, 1.90259576e-01f, 7.32767358e-02f, 1.24560453e-01f, 1.09995112e-01f, 1.45317605e-02f, 5.27308658e-02f,
  1.43833846e-01f, -3.13197114e-02f, 1.59677237e-01f, 3.38441372e-01f, 9.55786258e-02f, 5.98826520e-02f, -3.63618620e-02f, -5.24892919e-02f, 9.90040600e-03f, 1.28025562e-01f,
  1.51144592e-02f, -6.90292343e-02f, -1.19064368e-01f, 1.43049970e-01f, 1.65485233e-01f, -6.24063835e-02f, 3.07303723e-02f, 2.26949826e-02f, 1.95118576e-01f, -5.09311259e-02f,
  -4.07646261e-02f, 1.27934575e-01f, 4.56807651e-02f, 1.46295130e-01f, 1.48664638e-01f, 1.92523211e-01f, 3.95245329e-02f, 5.67652099e-02f, 5.70947379e-02f, 1.03384361e-01f,
  1.68104425e-01f, 4.66323756e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -5.64237963e-03f, -7.00146481e-02f, -6.83957487e-02f, -4.64341603e-02f, -5.26545802e-03f, -5.88589050e-02f, -4.91319336e-02f, 5.59039861e-02f, -7.88569599e-02f, 2.43905902e-01f,
  1.10202402e-01f, -7.86405802e-02f, -8.93905684e-02f, -3.09776604e-01f, 2.18784571e-01f, 1.08766310e-01f, 7.48024508e-02f, -1.34409470e-02f, 4.99004358e-03f, 7.71310329e-02f,
  -2.95793507e-02f, -5.58929853e-02f, -3.75825390e-02f, -2.13894680e-01f, -9.41844955e-02f, -1.40513912e-01f, 1.32806052e-03f, 5.15867732e-02f, 8.23939890e-02f, -1.35611728e-01f,
  -4.68725190e-02f, -1.10074751e-01f, -1.32176057e-01f, -4.51558232e-02f, -1.77103758e-01f, 4.28718403e-02f, -1.68214262e-01f, 7.45978253e-03f, -8.48008972e-03f, -6.88230991e-02f,
  7.42816329e-02f, -8.27979445e-02f, 1.17036372e-01f, -6.54013604e-02f, 1.87509265e-02f, -7.04064593e-02f, 3.42440046e-02f, -3.07701863e-02f, 1.83800250e-01f, -1.43210784e-01f,
  1.35280758e-01f, 3.40228039e-03f, 7.32581243e-02f, 1.74858809e-01f, -9.83229354e-02f, 9.36549306e-02f, -1.25099152e-01f, -2.17551991e-01f, -4.68332283e-02f, 1.77102283e-01f,
  7.77622638e-03f, 1.01672970e-01f, 6.02432601e-02f, 9.77786407e-02f, -1.59219831e-01f, -3.23048085e-02f, 1.79100167e-02f, -4.22091074e-02f, 7.17661083e-02f, -1.02131389e-01f,
  7.11588785e-02f, -9.92838293e-02f, -6.58799708e-02f, 5.61370067e-02f, 4.99447063e-02f, -5.03640017e-03f, -1.24811620e-01f, -2.18417183e-01f, -2.33225320e-02f, 1.84572771e-01f,
  -6.89493492e-02f, -7.30916634e-02f, 6.53139362e-03f, 2.10619755e-02f, 1.30555466e-01f, 5.66800125e-02f, -1.01077639e-01f, 1.55412391e-01f, -9.51370597e-02f, 5.24319038e-02f,
  -2.03215316e-01f, 4.73056454e-03f, 8.28427300e-02f, 7.44687766e-02f, 8.05095360e-02f, -1.56045593e-02f, -1.29253000e-01f, -2.10256696e-01f, -7.88761079e-02f, -2.83829793e-02f,
  -8.51302594e-02f, 4.29829024e-02f, 1.10446051e-01f, 3.78996544e-02f, 1.55674025e-01f, 1.48167804e-01f, -8.00737441e-02f, 1.62056789e-01f, 2.80528013e-02f, 2.68750861e-02f,
  -5.52742369e-02f, -7.27653876e-02f, 3.13954763e-02f, -4.24836278e-02f, -1.54496834e-01f, -2.96608180e-01f, -1.77218556e-01f, 9.86837074e-02f, -2.27390423e-01f, -2.90844798e-01f,
  -1.55325621e-01f, 7.06129847e-03f, 1.37274787e-01f, 1.46929666e-01f, -1.28819838e-01f, -1.26243323e-01f, -7.39231780e-02f, -9.73653421e-02f, 7.61991143e-02f, -1.24532646e-02f,
  -2.87343394e-02f, 8.33556429e-02f, -2.09606159e-02f, -3.53159122e-02f, 4.78748940e-02f, -6.13623895e-02f, 1.76873319e-02f, -5.06958738e-02f, -2.04696000e-01f, 8.82213116e-02f,
  6.99858293e-02f, -1.92501560e-01f, 1.71931414e-03f, -1.59780830e-01f, -2.36773595e-01f, 1.35803863e-01f, -1.69557929e-02f, -9.34980065e-02f, -1.89922959e-01f, 6.04766719e-02f,
  -1.53855145e-01f, 1.44826382e-01f, 1.85573399e-01f, 5.84832989e-02f, -3.45617943e-02f, -9.82856974e-02f, -1.21965714e-01f, 2.19538081e-02f, 1.49818569e-01f, 1.57532319e-01f,
  5.60792675e-03f, -6.21169433e-02f, -7.69330561e-02f, 2.27900743e-02f, 1.20608971e-01f, -1.96895227e-01f, 1.89350665e-01f, 1.39074534e-01f, -2.02981778e-03f, -3.23825778e-04f,
  -1.63309723e-01f, 2.02506930e-01f, 1.22935638e-01f, 5.65568358e-02f, -9.75959823e-02f, -5.35585321e-02f, -8.36610347e-02f, 1.30272761e-01f, -3.08529198e-01f, 4.02603857e-02f,
  1.02309948e-02f, 1.72580242e-01f, 3.68417613e-02f, -1.90686449e-01f, -1.12734765e-01f, 1.21090442e-01f, -3.95721607e-02f, -1.60453960e-01f, -1.25816753e-02f, -2.03513857e-02f,
  2.24629730e-01f, -1.39859885e-01f, 1.22077100e-01f, 3.44741605e-02f, -1.10586241e-01f, -4.55135703e-02f, -1.88204035e-01f, -1.36282742e-01f, 1.77343823e-02f, -2.10026309e-01f,
  8.34480003e-02f, 1.52867764e-01f, -1.12674497e-01f, 1.24472622e-02f, -7.02799708e-02f, -2.63574392e-01f, 7.32918158e-02f, -5.78176742e-03f, -2.03791946e-01f, -7.03286799e-03f,
  -5.21475822e-02f, -7.38045201e-02f, -4.60655205e-02f, 2.71744311e-01f, -8.76111388e-02f, -2.64151618e-02f, -1.51447549e-01f, 7.38560557e-02f, -9.13410932e-02f, 1.03265634e-02f,
  -1.51943378e-02f, 1.03623830e-01f, -4.78939414e-02f, 1.75649207e-03f, 1.09165907e-02f, -5.54731153e-02f, -1.03332363e-01f, -1.80636406e-01f, 9.79238003e-02f, 8.94419402e-02f,
  3.43268365e-02f, -1.03311859e-01f, 4.10673842e-02f, 5.92927635e-02f, -7.76912272e-02f, 9.80372354e-02f, 3.49102467e-02f, 2.44903922e-01f, 5.73818758e-02f, -9.81088504e-02f,
  -1.61856443e-01f, -1.01699762e-01f, -1.56288460e-01f, -3.46525051e-02f, 1.77512094e-01f, 2.03266278e-01f, -7.52274916e-02f, -7.38066584e-02f, -1.57871798e-01f, -1.71841308e-01f,
  1.53584536e-02f, 5.19167855e-02f, -9.69857350e-02f, -2.48006925e-01f, 2.85079211e-01f, 1.89287029e-02f, 4.50635478e-02f, -5.42933531e-02f, -1.35962278e-01f, 2.93031223e-02f,
  -1.71843931e-01f, 7.90818110e-02f, 3.91543172e-02f, 1.04919866e-01f, 5.57795875e-02f, -1.89338788e-01f, -1.46323100e-01f, 2.21116662e-01f, 1.11607850e-01f, 2.54717082e-01f,
  9.53416005e-02f, 1.20057106e-01f, -1.71987876e-01f, 1.31862298e-01f, -7.27514178e-02f, 8.55821222e-02f, -6.75688162e-02f, 5.51190153e-02f, -1.83381662e-01f, 2.24453304e-02f,
  1.11861192e-01f, 6.72635734e-02f, -1.05608419e-01f, -1.74494699e-01f, -1.16279833e-01f, 8.97649527e-02f, -2.22091712e-02f, 1.89733699e-01f, -3.97922434e-02f, 3.80637869e-02f,
  1.12765893e-01f, -2.08103165e-01f, 3.89388502e-02f, 1.18688531e-01f, 1.07765384e-01f, -1.39777824e-01f, -6.47716597e-02f, -2.35044677e-03f, -1.93433791e-01f, -5.25453873e-02f,
  1.77172214e-01f, 1.46928936e-01f, -1.54528722e-01f, -4.62201387e-02f, -1.54146671e-01f, 4.67191711e-02f, -3.10600102e-02f, -1.15769334e-01f, -1.37492716e-01f, 1.58222929e-01f,
  1.70720264e-01f, -1.04244374e-01f, -3.63926701e-02f, -6.75520897e-02f, -2.89613437e-02f, -1.27286851e-01f, -5.12871929e-02f, -1.27556771e-01f, 1.82124287e-01f, 9.03777126e-03f,
  5.69500700e-02f, -1.24930320e-02f, 7.21683577e-02f, 3.43710184e-02f, 2.69401632e-02f, 2.04576435e-03f, 1.46569565e-01f, 4.10201624e-02f, -9.35712531e-02f, -1.52527198e-01f,
  -4.85278368e-02f, -1.22910224e-01f, -9.89187658e-02f, 2.73900390e-01f, -1.09075874e-01f, -4.92389426e-02f, 2.35558212e-01f, -1.75677747e-01f, -1.05050644e-02f, -2.40428913e-02f,
  1.83148310e-01f, -1.25427410e-01f, -5.43530285e-02f, -1.51127815e-01f, 1.16942555e-01f, -1.67029366e-01f, 6.45228550e-02f, 1.96987405e-01f, -5.62122352e-02f, -3.70260775e-02f,
  4.48231809e-02f, 2.35812319e-03f, 1.20077871e-01f, 2.82919616e-03f, 6.34764135e-02f, -1.35556450e-02f, -1.77095104e-02f, 3.47808115e-02f, -1.74359500e-01f, -1.16568923e-01f,
  4.58205156e-02f, -8.26779846e-03f, 6.58096895e-02f, -1.67669475e-01f, -1.10088237e-01f, -1.25808343e-01f, 1.41172260e-01f, -7.42867216e-02f, 1.12056106e-01f, -2.14686722e-01f,
  4.01457578e-01f, -2.08022390e-02f, 2.74373665e-02f, -1.98597714e-01f, -7.88820013e-02f, 3.57791573e-01f, -1.10119812e-01f, 6.56772107e-02f, -2.82181017e-02f, -1.58001315e-02f,
  -1.55690853e-02f, 2.57211745e-01f, -2.05248669e-01f, 1.28367972e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.22974274e-02f, 3.81148122e-02f, 1.73358664e-01f, 1.19625904e-01f, 1.76286876e-01f, 2.05737010e-01f, -1.48662701e-02f, -1.88139826e-01f, -5.80747351e-02f, 8.95852968e-02f,
  -2.01092780e-01f, -1.73911955e-02f, 1.63008213e-01f, -1.63474008e-01f, 4.59064841e-02f, -2.18828708e-01f, -1.50873080e-01f, -1.53315486e-02f, 2.04204574e-01f, -9.95935649e-02f,
  -2.09354162e-01f, 5.03604300e-02f, -2.76276231e-01f, 2.23846838e-01f, -8.94024223e-02f, 2.22951576e-01f, -1.59819126e-01f, -1.01104319e-01f, 2.00730547e-01f, 3.42480019e-02f,
  2.96138525e-01f, 5.47885038e-02f, -8.44282061e-02f, -1.58889562e-01f, 7.62112141e-02f, 2.39293799e-01f, 1.51518255e-01f, -2.53535271e-01f, -2.51086405e-03f, 8.75803754e-02f,
  1.17939435e-01f, 4.13867645e-02f, 1.65209278e-01f, 3.52477655e-02f, 9.04981606e-03f, 1.24681041e-01f, 1.67279616e-01f, 5.51244505e-02f, -1.04859628e-01f, 1.03591181e-01f,
  -1.21412970e-01f, -1.08496659e-01f, -9.49599147e-02f, 3.02486345e-02f, -2.38567591e-01f, -2.44013779e-02f, -2.63154835e-01f, 2.40193099e-01f, 2.55013313e-02f, 1.30679041e-01f,
  -2.90072888e-01f, -3.68928790e-01f, 4.26367551e-01f, 1.62943140e-01f, -4.61502932e-02f, 1.10181540e-01f, -3.49414907e-02f, 2.79034283e-02f, 3.78044620e-02f, 1.13308661e-01f,
  1.24614071e-02f, -3.89418080e-02f, 8.80896375e-02f, 1.33985151e-02f, -3.97528969e-02f, 5.63898236e-02f, 1.05233029e-01f, -1.14965044e-01f, -1.97108448e-01f, 2.85731535e-02f,
  1.18779363e-02f, 5.60085252e-02f, -4.15528268e-02f, 1.20165922e-01f, -2.61265248e-01f, -6.88426197e-02f, 1.98433071e-01f, 1.02575317e-01f, -5.20870313e-02f, 2.24545207e-02f,
  -3.07419896e-01f, 1.35048240e-01f, 1.63877413e-01f, 2.27216542e-01f, 1.04660451e-01f, 1.07802466e-01f, -7.06209987e-02f, 4.60815150e-03f, -2.29536276e-02f, -1.36784092e-02f,
  -5.05351238e-02f, -5.21742329e-02f, 1.33956999e-01f, 2.94428021e-01f, 8.64991471e-02f, -1.07651301e-01f, -7.67573565e-02f, -9.62135270e-02f, 1.75104678e-01f, -1.61929965e-01f,
  -4.88658324e-02f, 2.74461433e-02f, 1.11639939e-01f, 9.03752446e-02f, -1.07069321e-01f, -1.57910228e-01f, 1.23763748e-01f, -1.03971995e-01f, -1.48606896e-01f, -7.63938203e-02f,
  2.60933101e-01f, -1.02590658e-01f, -5.78693897e-02f, 2.26843745e-01f, -1.10114187e-01f, 8.65847543e-02f, 2.60275714e-02f, -4.16650698e-02f, 2.36844733e-01f, 1.64178431e-01f,
  1.14574440e-01f, 8.84727836e-02f, -7.06835911e-02f, -4.30247001e-02f, 2.02028695e-02f, -7.59239122e-02f, -6.82221875e-02f, -2.30635151e-01f, -4.30445224e-01f, 6.56169206e-02f,
  4.47729677e-02f, 3.26744944e-01f, -8.09082016e-03f, 5.07790111e-02f, -2.64390975e-01f, -1.11254230e-01f, -1.48348257e-01f, 1.40892759e-01f, 5.21476567e-02f, 1.69982374e-01f,
  -3.38457003e-02f, -5.88439256e-02f, -1.01021178e-01f, -2.86446989e-01f, -1.21919408e-01f, 1.35021910e-01f, -1.52293012e-01f, 1.68258518e-01f, 1.82757843e-02f, -1.94469377e-01f,
  -1.55055001e-01f, 2.77116120e-01f, 3.21125925e-01f, -7.06907129e-03f, 1.81836411e-01f, 1.67599201e-01f, -3.88215214e-01f, -2.54247397e-01f, 4.54953313e-02f, 1.26564533e-01f,
  4.55349833e-02f, -1.22918904e-01f, -1.41439945e-01f, 6.11302778e-02f, -1.30121529e-01f, 1.77616552e-01f, -4.61380407e-02f, -1.62412878e-02f, -1.03366472e-01f, -3.16881239e-01f,
  -6.94024861e-02f, -3.88421230e-02f, -3.77512693e-01f, -3.25542897e-01f, -2.66983658e-01f, 1.27491474e-01f, 5.40570319e-02f, -8.08432028e-02f, 3.09030861e-02f, 1.18054233e-01f,
  3.18765223e-01f, 4.03815694e-02f, 9.92819574e-03f, 8.63575861e-02f, 1.03235677e-01f, -8.18053335e-02f, -2.67886929e-02f, -1.17154963e-01f, 8.59279111e-02f, 1.43780140e-02f,
  1.56452820e-01f, -4.14677942e-03f, 5.19198030e-02f, 2.41657615e-01f, 9.92879570e-02f, -1.67745411e-01f, -1.04927897e-01f, 1.37916639e-01f, 3.10003888e-02f, 4.87038642e-02f,
  1.17692305e-02f, 2.78637111e-02f, -1.08415848e-02f, -2.39797886e-02f, -1.15828313e-01f, 1.93049852e-02f, 8.26464519e-02f, 1.47534579e-01f, 6.02718517e-02f, -6.36084154e-02f,
  -4.81879003e-02f, 3.26587185e-02f, 7.03054070e-02f, 7.31200576e-02f, 5.27218282e-02f, 1.03647672e-01f, -1.89014435e-01f, 3.12364966e-01f, 1.73524112e-01f, -2.40808483e-02f,
  -1.16709173e-01f, -1.95517875e-02f, 1.06542371e-01f, 9.17021409e-02f, 1.39715850e-01f, 1.45814136e-01f, 2.94085741e-02f, 4.65829065e-03f, -3.83905321e-02f, -1.10325053e-01f,
  -4.02471423e-02f, 4.83495854e-02f, -2.77786613e-01f, 1.15252296e-02f, -7.51256645e-02f, 3.03355772e-02f, 7.37541392e-02f, -1.24905713e-01f, 2.07628473e-03f, 1.60364956e-01f,
  -1.35283679e-01f, -1.94766954e-01f, 6.54622912e-02f, -3.69788706e-02f, 2.53413796e-01f, 6.35591075e-02f, -7.78979957e-02f, 6.21078871e-05f, 4.37641554e-02f, -5.49250655e-02f,
  -5.98040596e-02f, -2.68715732e-02f, 8.09049681e-02f, 5.75163849e-02f, -2.79213618e-02f, 1.13221511e-01f, -1.00203209e-01f, 1.41276807e-01f, 1.42104790e-01f, -6.02114536e-02f,
  -4.15188186e-02f, -4.70221341e-02f, 1.80677965e-01f, 7.33739510e-02f, -1.02589644e-01f, -4.90851179e-02f, -1.44027799e-01f, -1.40824839e-01f, 1.37551740e-01f, -1.71115831e-01f,
  -2.16165856e-02f, -3.70375626e-02f, 9.42810550e-02f, 2.24380299e-01f, 1.59434676e-01f, -5.04322536e-02f, 3.19991373e-02f, -1.15768105e-01f, -2.52226554e-02f, 1.44879371e-02f,
  4.07693675e-04f, -1.01397373e-01f, -9.22512114e-02f, -9.78200808e-02f, -5.51266596e-02f, 1.51336700e-01f, 1.77719712e-01f, -4.18471135e-02f, 9.09577534e-02f, -1.88638881e-01f,
  1.56668991e-01f, 5.96214086e-03f, 2.55776286e-01f, -7.38428831e-02f, 3.64879489e-01f, -1.21814430e-01f, 1.05442099e-01f, -3.41342613e-02f, -4.57597375e-01f, -4.61469032e-02f,
  3.15113482e-03f, -2.07838900e-02f, -3.32746543e-02f, -2.14225173e-01f, 1.70091912e-01f, 2.27267206e-01f, -1.46671236e-01f, 3.32899332e-01f, 2.97860503e-02f, -8.65776241e-02f,
  -1.96081549e-01f, -1.23904422e-01f, -6.35030866e-02f, -2.22876713e-01f, 1.08383998e-01f, 6.86252415e-02f, 4.76195663e-02f, 7.84829631e-02f, -1.08351104e-01f, 4.96390834e-02f,
  4.59196121e-02f, 1.09928109e-01f, -2.27376670e-02f, 2.46368825e-01f, 6.84740022e-02f, -1.28780037e-01f, -1.98259935e-01f, 1.30379975e-01f, -3.57365720e-02f, -9.14129838e-02f,
  -1.28145710e-01f, -1.63402200e-01f, -4.10233595e-04f, 3.82434018e-02f, 2.87102282e-01f, 1.09798603e-01f, 4.08400893e-02f, 1.17800375e-02f, 3.03712413e-02f, -2.27229938e-01f,
  -2.03154534e-01f, 3.30738164e-02f, 1.37509003e-01f, 8.52571975e-05f, 2.27105930e-01f, 8.19649249e-02f, 5.77558242e-02f, -2.58111227e-02f, 1.93343759e-01f, -6.93350136e-02f,
  -1.68044209e-01f, -1.41946375e-01f, -3.02630886e-02f, -8.46347287e-02f, -1.44982830e-01f, -2.48906314e-02f, -1.91154733e-01f, -1.72409147e-01f, -1.05251009e-02f, 1.09405443e-01f,
  2.43198842e-01f, 4.99853678e-03f, 1.14479974e-01f, 8.42888579e-02f, 2.55492300e-01f, 2.52127230e-01f, 8.18188265e-02f, 1.07269594e-03f, 7.79162943e-02f, -1.80943068e-02f,
  -7.32907504e-02f, -2.83245221e-02f, -1.07874624e-01f, 1.28339052e-01f, 1.34845570e-01f, 6.13178574e-02f, 1.23732358e-01f, 1.69125255e-02f, 1.83202624e-02f, -7.67018646e-02f,
  -1.18813559e-01f, 3.30654578e-03f, 1.59070808e-02f, -4.56174947e-02f, 6.05692826e-02f, -9.62563418e-03f, -1.29671946e-01f, 3.06780171e-02f, -1.70246940e-02f, 1.31911173e-01f,
  1.35824434e-04f, 2.17882842e-02f, 5.16906381e-02f, -9.83407442e-03f, -8.13868493e-02f, 1.07308023e-01f, -4.69049066e-03f, 9.77737233e-02f, -3.05754840e-01f, -1.58864006e-01f,
  1.46377613e-04f, 7.59880245e-02f, 1.54881909e-01f, 1.12847380e-01f, -2.23989785e-01f, 4.52678204e-02f, -1.32736355e-01f, 4.71851937e-02f, -2.10037470e-01f, 4.52578301e-03f,
  -2.43048579e-01f, 2.71495581e-01f, -1.14587620e-01f, -1.07315481e-01f, -5.25628552e-02f, -8.88139606e-02f, 8.77239108e-02f, -2.48051569e-01f, -2.04236060e-02f, 1.82790041e-01f,
  1.17413066e-01f, 5.54475151e-02f, 1.26548246e-01f, -2.68791318e-01f, 1.39185831e-01f, -1.43811047e-01f, 3.02150160e-01f, -9.09001753e-02f, 1.50106713e-01f, 4.08404142e-01f,
  1.67587876e-01f, 6.61563799e-02f, -9.97768790e-02f, -1.25602663e-01f, 8.37576911e-02f, 2.20378891e-01f, -1.67152390e-01f, 1.94901884e-01f, 1.97481811e-01f, 1.49088964e-01f,
  5.93652539e-02f, -3.38888116e-04f, 4.75811139e-02f, 4.72366549e-02f, -2.28520390e-02f, -6.64112568e-02f, -7.56238401e-02f, 5.15295826e-02f, 2.62370314e-02f, -9.22649279e-02f,
  -2.53627542e-02f, 3.85862254e-02f, -1.47163328e-02f, 1.00482330e-01f, 1.75178483e-01f, -1.85309052e-01f, 5.69601730e-02f, 4.75440770e-02f, 6.61301985e-02f, 4.75499518e-02f,
  -3.52074131e-02f, 8.30168575e-02f, -1.43422604e-01f, -2.30974749e-01f, -1.16491867e-02f, 2.85883900e-02f, 1.51775092e-01f, 2.02089176e-01f, -5.91304451e-02f, -8.59029666e-02f,
  1.34646297e-01f, 1.18208103e-01f, 2.03798562e-01f, -2.94594616e-01f, 6.85615018e-02f, 1.05338156e-01f, 9.06844810e-02f, -7.08566839e-03f, 4.38977443e-02f, -1.69386119e-01f,
  -1.27215937e-01f, -3.92348170e-02f, 2.01326177e-01f, -1.41397314e-02f, -2.04064529e-02f, 1.96881313e-02f, 2.24461317e-01f, -8.96358490e-02f, 2.29459509e-01f, -6.10769726e-02f,
  9.21747386e-02f, -2.15724155e-01f, -2.47099623e-01f, -5.07316813e-02f, 1.87735647e-01f, -2.19740286e-01f, -1.57827869e-01f, 5.09117991e-02f, -1.20658949e-01f, 2.02827230e-02f,
  -2.19423860e-01f, -2.51235589e-02f, 4.64368574e-02f, 2.00093791e-01f, 6.15284778e-02f, 2.64010966e-01f, 2.19525218e-01f, 2.05979288e-01f, 8.59068632e-02f, -9.24298614e-02f,
  1.97904930e-02f, 1.39992610e-01f, 2.51158364e-02f, 5.10795489e-02f, 1.45034477e-01f, -1.67617857e-01f, 1.18356735e-01f, -4.01077241e-01f, 2.03491718e-01f, -1.15244880e-01f,
  1.39063880e-01f, -2.82450438e-01f, 7.59002790e-02f, 1.58540942e-02f, 2.16735512e-01f, -1.00348160e-01f, -7.23005608e-02f, -5.85167184e-02f, 6.11460805e-02f, 3.23206186e-02f,
  6.09630952e-03f, -7.75926709e-02f, 3.77009735e-02f, 6.99592382e-02f, -2.93160847e-05f, -1.71182662e-01f, -1.34280413e-01f, 1.14945494e-01f, 5.57975844e-02f, -2.41037101e-01f,
  -5.01964125e-04f, 1.83107033e-01f, 1.95671365e-01f, -1.90807581e-01f, 1.15374044e-01f, -6.07441925e-02f, -7.63067044e-03f, 1.91105887e-01f, 2.68082380e-01f, -2.07507506e-01f,
  2.07024127e-01f, -1.50569469e-01f, 7.17892051e-02f, -2.52672076e-01f, 6.50358424e-02f, 2.04537008e-02f, 1.67138830e-01f, 1.55384928e-01f, -2.74598628e-01f, -1.31458819e-01f,
  6.37501478e-02f, 2.57790029e-01f, -1.49713054e-01f, 2.16528907e-01f, 1.93893075e-01f, 1.71049654e-01f, 1.07912898e-01f, -1.16455279e-01f, 1.85729653e-01f, 1.71429902e-01f,
  4.61705178e-02f, 1.18743792e-01f, 8.69895518e-02f, 3.31163913e-01f, -1.78970993e-01f, 2.62461245e-01f, 6.18904009e-02f, -1.82103574e-01f, 5.10008633e-02f, 9.56955701e-02f,
  1.90445110e-01f, -9.36676115e-02f, 7.39213303e-02f, 1.25379907e-02f, 9.84625984e-03f, 9.38585326e-02f, 2.49875002e-02f, -8.94956142e-02f, 8.64627436e-02f, -9.65768471e-02f,
  -1.61640659e-01f, -1.97104216e-01f, 6.81637377e-02f, 3.18237573e-01f, 6.43524341e-03f, -1.10595807e-01f, -4.34710197e-02f, -1.42545998e-01f, 1.26436576e-01f, -1.06186979e-01f,
  1.07549243e-01f, 7.07117543e-02f, -5.61894141e-02f, 1.69036284e-01f, -5.97788319e-02f, -1.12629488e-01f, 9.89952162e-02f, 4.81719570e-03f, -5.68065792e-02f, -1.55650213e-01f,
  -1.96577340e-01f, 2.07378775e-01f, 6.82359785e-02f, 7.38299936e-02f, 2.24404454e-01f, -3.56631428e-02f, 2.82559305e-01f, -7.44616762e-02f, 1.38636738e-01f, -2.17563421e-01f,
  -5.75207323e-02f, 4.57750052e-01f, 1.88577268e-02f, 4.35984917e-02f, 9.67220590e-02f, 1.67380452e-01f, -4.76545468e-02f, 1.70743302e-01f, -9.47244912e-02f, 9.20149758e-02f,
  1.47285968e-01f, 2.10555106e-01f, 4.65820506e-02f, 2.36970872e-01f, 1.57763183e-01f, -1.19112125e-02f, 2.43828416e-01f, -2.10831210e-01f, 9.43054557e-02f, 1.35478854e-01f,
  1.22070409e-01f, -1.05910480e-01f, 1.19057581e-01f, -2.68282574e-02f, 6.74133003e-03f, -6.30226508e-02f, 1.44732013e-01f, -7.58798346e-02f, 1.66257292e-01f, 9.71256718e-02f,
  1.54439628e-01f, 7.56142382e-03f, 1.23231515e-01f, -1.96215674e-01f, -7.07257390e-02f, -6.70500398e-02f, 2.44630292e-01f, -6.70955479e-02f, 1.72671512e-01f, 1.28015187e-02f,
  1.14294708e-01f, 1.02627732e-01f, 1.03563778e-01f, -2.45963931e-02f, -1.25374114e-02f, 4.88960892e-02f, -1.03942819e-01f, -1.27021819e-02f, -1.47906333e-01f, 2.57967301e-02f,
  1.70688227e-01f, 7.91566446e-03f, -9.34838131e-03f, 1.29248977e-01f, -1.10912152e-01f, -5.99935702e-05f, 2.81602472e-01f, 2.29445547e-02f, 1.56307042e-01f, -2.54416555e-01f,
  3.39380205e-02f, -1.44023865e-01f, -2.42798880e-01f, -2.23176032e-01f, -6.77212924e-02f, -3.32001112e-02f, -1.28820628e-01f, 1.83443815e-01f, -6.96584210e-02f, 1.33834526e-01f,
  1.91370040e-01f, -2.48512384e-02f, -6.04734011e-02f, 1.12602584e-01f, 1.46781635e-02f, -1.11338183e-01f, -1.33138336e-02f, 8.98157209e-02f, -7.78794959e-02f, 4.97106574e-02f,
  -1.76046088e-01f, -5.41044511e-02f, 4.63821087e-03f, 2.61409003e-02f, -4.07986760e-01f, 2.50073135e-01f, 3.76050398e-02f, -2.04063430e-01f, 2.56743282e-01f, -4.17200983e-01f,
  -2.34438404e-01f, 6.99024200e-02f, -7.04175094e-03f, -9.09645110e-02f, -2.05645084e-01f, 4.47759638e-04f, -1.59462448e-02f, 1.14225708e-01f, 1.54946417e-01f, 1.10469259e-01f,
  -2.13400647e-01f, -1.48317903e-01f, 1.00306369e-01f, 2.73728281e-01f, 9.81629416e-02f, 1.68618057e-02f, -1.94081306e-01f, -4.70844619e-02f, 4.75567579e-02f, 3.85159887e-02f,
  1.10232808e-01f, -6.54583378e-03f, 1.00127064e-01f, -1.15609787e-01f, 2.82482892e-01f, -6.31071702e-02f, -1.64627463e-01f, 2.63670474e-01f, -1.05904520e-01f, 2.81444162e-01f,
  -2.35637337e-01f, -6.29989954e-04f, -1.80855200e-01f, 2.49695644e-01f, -5.61807096e-01f, 2.02610716e-01f, -2.88041264e-01f, 1.34218723e-01f, 1.67146903e-02f, -3.76255810e-01f,
  1.00007830e-02f, 1.67549968e-01f, -1.46166652e-01f, -1.28514782e-01f, -9.91997123e-02f, -2.33476117e-01f, 3.82127434e-01f, -8.05260092e-02f, -4.47280966e-02f, -7.56732449e-02f,
  -7.51073146e-03f, -8.36958066e-02f, -2.36960202e-02f, -1.05026029e-01f, -2.35035926e-01f, 2.07267538e-01f, 9.53740925e-02f, -1.73642322e-01f, -7.99220428e-03f, 4.05798703e-02f,
  -9.93687734e-02f, 1.25372589e-01f, -1.46702537e-02f, 9.69365165e-02f, 4.44210395e-02f, 9.24421027e-02f, -1.04139097e-01f, 1.82443634e-01f, -6.66292086e-02f, -7.29119405e-02f,
  2.36545131e-02f, 1.16176724e-01f, -9.13135558e-02f, 2.49193590e-02f, -2.66637579e-02f, 1.27579467e-02f, 1.14952791e-02f, -5.64191416e-02f, 6.09721802e-02f, -3.36210020e-02f,
  1.10517941e-01f, 1.20203728e-02f, 1.02111407e-01f, -8.78948867e-02f, -1.16085723e-01f, -6.20798282e-02f, 5.12102768e-02f, -1.56456575e-01f, -1.46124482e-01f, -1.15402982e-01f,
  6.69967756e-02f, -1.59788027e-01f, 1.18724421e-01f, -1.71487868e-01f, -1.37104124e-01f, -6.61879480e-02f, -3.15332711e-02f, 1.06669180e-01f, 2.33102009e-01f, -1.49576843e-01f,
  2.39386082e-01f, -1.77477583e-01f, -4.76757027e-02f, 2.38819316e-01f, 1.13771044e-01f, -3.19064669e-02f, 1.09002683e-02f, 5.04103582e-03f, -1.23810805e-01f, -1.79460663e-02f,
  -1.50588349e-01f, 6.15585856e-02f, 2.58594584e-02f, 1.45018101e-01f, 1.10900097e-01f, 1.57244876e-01f, -5.59811778e-02f, 1.96283460e-02f, 2.41080984e-01f, -3.62716988e-02f,
  1.62708312e-01f, -6.15998395e-02f, 8.40596929e-02f, 6.28523082e-02f, -8.31989478e-03f, -3.89619023e-02f, -1.36431322e-01f, 9.24296603e-02f, 7.63036087e-02f, 5.33012487e-03f,
  7.29916766e-02f, 6.48275465e-02f, 7.24122375e-02f, 2.65635923e-02f, -1.61423367e-02f, -7.64440149e-02f, 1.29667073e-01f, 4.58917813e-03f, 2.07262501e-01f, -7.53294080e-02f,
  9.31733381e-03f, -1.89970378e-02f, -9.93000437e-03f, -2.60474253e-02f, -3.93068530e-02f, 1.15166977e-01f, 1.09384529e-01f, 1.05323158e-01f, 3.55929062e-02f, -8.01064223e-02f,
  3.51496711e-02f, -1.26414582e-01f, 8.97851586e-02f, 3.61717008e-02f, -1.39708901e-02f, 1.79557323e-01f, 3.93412299e-02f, -1.39403507e-01f, -1.98049396e-01f, 1.03206560e-01f,
  -9.77484956e-02f, -1.94975495e-01f, -1.78509921e-01f, 7.42186373e-03f, -2.39287362e-01f, 4.26357873e-02f, -2.82506440e-02f, -3.00006300e-01f, 1.03511438e-01f, 8.96741450e-02f,
  -1.67602658e-01f, -1.15907945e-01f, 1.56564429e-01f, 2.05949377e-02f, 1.46854386e-01f, -1.63789645e-01f, 1.84750944e-01f, 2.80480742e-01f, 1.88195452e-01f, 1.71907336e-01f,
  9.77003053e-02f, -1.18103111e-02f, 2.85563827e-01f, -1.76474214e-01f, 9.09922495e-02f, -1.07264310e-01f, -3.69994603e-02f, 7.00027868e-02f, 1.58956274e-01f, 3.62656005e-02f,
  1.16630517e-01f, 1.12726197e-01f, 8.07998106e-02f, 2.38039624e-02f, 1.84121414e-03f, 7.62863755e-02f, 1.26668036e-01f, 1.01923481e-01f, 1.01831526e-01f, -3.27620775e-01f,
  5.06651355e-03f, -1.92641929e-01f, 3.05804700e-01f, 2.23274692e-03f, -2.37596184e-01f, -9.49589685e-02f, -6.88798577e-02f, 4.10258916e-04f, 3.58451270e-02f, 6.18010089e-02f,
  1.81176499e-01f, 1.94654450e-01f, 3.26529630e-02f, 1.48199037e-01f, -2.29175419e-01f, -3.30391228e-01f, -1.01097092e-01f, 8.23314711e-02f, -1.22085966e-01f, 2.23048985e-01f,
  -2.72712469e-01f, 1.56580523e-01f, 2.56296229e-02f, 1.50405690e-01f, -7.67149031e-02f, -2.19578564e-01f, -6.66041523e-02f, 1.32352710e-01f, -1.29144013e-01f, -1.65315688e-01f,
  -2.07343847e-01f, -2.40597576e-01f, -1.36564121e-01f, 2.93897659e-01f, -1.01414159e-01f, -7.89847821e-02f, 2.31045499e-01f, 5.55520654e-02f, -8.44304562e-02f, -1.63835123e-01f,
  -9.37128514e-02f, 1.22440651e-01f, -1.05957545e-01f, 8.39802250e-03f, -7.41938502e-02f, 3.61716636e-02f, 2.89660729e-02f, -3.97172896e-03f, 1.02999881e-01f, -2.48732548e-02f,
  -1.69245191e-02f, 1.51115403e-01f, 1.39022600e-02f, -2.85413623e-01f, 1.68041587e-02f, -3.58127028e-01f, 1.04421481e-01f, 1.72226876e-01f, -5.10498770e-02f, -1.11033157e-01f,
  -1.97693199e-01f, -2.59151965e-01f, 1.26373172e-01f, 6.37100860e-02f, 6.41602725e-02f, -1.03783540e-01f, 2.05151424e-01f, 1.11410931e-01f, 1.22583650e-01f, -7.53070563e-02f,
  -1.53832182e-01f, 1.43703625e-01f, 9.18395594e-02f, -2.85820174e-03f, 1.83048677e-02f, -4.32641059e-02f, 7.74167031e-02f, 2.12454781e-01f, 2.81280167e-02f, 2.46487092e-02f,
  -1.19747512e-01f, -6.23474307e-02f, -4.27148566e-02f, -1.86647117e-01f, -2.09252551e-01f, -7.07510766e-03f, 5.76905236e-02f, -4.88686748e-02f, 1.08399466e-01f, 1.15783788e-01f,
  8.05102289e-02f, 2.34669298e-01f, -6.15503863e-02f, -1.89391762e-01f, 3.44676256e-01f, 1.08375989e-01f, -2.49172617e-02f, 4.67948355e-02f, -9.24673229e-02f, -2.76574772e-02f,
  9.65439081e-02f, 2.56820828e-01f, 8.33597779e-02f, -1.48231715e-01f, 8.62960815e-02f, 7.12594315e-02f, 1.65406331e-01f, -6.20189011e-02f, 1.28880665e-01f, -2.46543810e-02f,
  -5.73088676e-02f, 2.63333201e-01f, -1.48548678e-01f, -2.89435774e-01f, -1.31076711e-04f, 4.59787846e-02f, -2.35931538e-02f, 4.02125388e-01f, -1.46368578e-01f, 1.86040863e-01f,
  -2.47563161e-02f, -2.21753657e-01f, 7.84730837e-02f, 1.92383960e-01f, -1.21012824e-02f, 2.24918634e-01f, -1.06917508e-01f, 1.89623877e-01f, -2.21252907e-02f, -2.26158015e-02f,
  5.93297780e-02f, 1.66643441e-01f, -2.08059028e-02f, 5.22287749e-02f, 6.58273324e-02f, -1.69292152e-01f, 7.30577931e-02f, 1.48209542e-01f, 3.29302251e-01f, -2.33804643e-01f,
  4.15727049e-02f, 3.77710074e-01f, -1.04995213e-01f, -1.79150030e-01f, -4.39001545e-02f, 1.49733290e-01f, -8.70263055e-02f, -3.35843861e-01f, 9.04091150e-02f, -4.14237566e-02f,
  -2.38696396e-01f, 7.61954933e-02f, -1.49029732e-01f, 1.83945652e-02f, 2.29663312e-01f, -1.66703969e-01f, 5.59464619e-02f, -2.58842885e-01f, -2.75837749e-01f, 1.31885172e-03f,
  3.25638652e-01f, -1.81003049e-01f, -1.13944793e-02f, 3.35371196e-02f, 5.83727248e-02f, -5.59544116e-02f, -2.01011121e-01f, -6.33184658e-03f, -1.30003229e-01f, -3.87225375e-02f,
  5.78412041e-02f, -1.03820823e-01f, 4.20034975e-02f, -3.25428322e-02f, 1.40048400e-01f, 5.35311624e-02f, -1.01735637e-01f, 7.49565139e-02f, -6.72738859e-03f, -3.12271854e-03f,
  1.43279836e-01f, 1.02886684e-01f, -8.16441048e-03f, 5.54954223e-02f, -8.63817185e-02f, 3.99972452e-03f, -1.30467147e-01f, 4.54589128e-02f, -6.69330060e-02f, -2.36944444e-02f,
  1.11937217e-01f, 1.62536204e-02f, 5.01591153e-02f, 8.91438350e-02f, 5.99355660e-02f, -3.43587883e-02f, -2.10359022e-01f, -3.84229943e-02f, 3.01127173e-02f, -4.83182339e-05f,
  1.45809008e-02f, 6.77955225e-02f, 6.19636215e-02f, 1.71565294e-01f, 1.02425940e-01f, -6.88880309e-02f, 9.58111510e-02f, -2.31355697e-01f, 1.20239191e-01f, -5.51495291e-02f,
  1.51800871e-01f, -1.13972731e-01f, -1.24863282e-01f, 9.30335969e-02f, -1.60963804e-01f, 6.37173429e-02f, -2.72037182e-02f, -6.37888685e-02f, 9.50493887e-02f, 4.07495797e-02f,
  1.56648427e-01f, 1.21870348e-02f, 1.69599101e-01f, 1.77568451e-01f, -3.78481187e-02f, 9.09899771e-02f, -1.82315130e-02f, -8.41682181e-02f, 1.19545437e-01f, 3.19264382e-02f,
  -7.20846206e-02f, 1.41732737e-01f, 8.77233297e-02f, 5.40180840e-02f, 1.53485283e-01f, -8.56277719e-03f, 6.74165436e-04f, 1.37275249e-01f, -1.32472485e-01f, 1.85282841e-01f,
  1.46854028e-01f, 2.41738111e-01f, 1.20066874e-01f, 7.99418613e-02f, 2.50738654e-02f, -2.09754646e-01f, -6.06129430e-02f, -1.81181520e-01f, -1.01295233e-01f, 2.51517892e-01f,
  1.50013223e-01f, -1.20077627e-02f, 2.05130711e-01f, -2.26982832e-01f, 3.07620168e-01f, 1.97374597e-02f, 2.36908104e-02f, 1.81166008e-01f, 7.58100394e-03f, -1.11445390e-01f,
  -2.36425847e-01f, 5.50695844e-02f, 8.73397163e-04f, 9.29948613e-02f, 1.16554037e-01f, -1.98688209e-02f, -8.16421360e-02f, 3.48146886e-01f, -1.04803547e-01f, -1.74399897e-01f,
  1.87518761e-01f, -2.17839658e-01f, 1.49551198e-01f, -3.62840220e-02f, 8.59340951e-02f, 3.53255570e-01f, -6.84176311e-02f, 8.44413042e-03f, -1.44833565e-01f, -6.65183291e-02f,
  -1.69953778e-01f, 1.14502467e-01f, -1.86018631e-01f, 1.99386969e-01f, 2.49486893e-01f, 5.65136857e-02f, 3.18127155e-01f, 3.88260394e-01f, -3.46225277e-02f, 3.15912783e-01f,
  -2.03961898e-02f, -1.54206112e-01f, 6.46360293e-02f, -1.11563273e-01f, 1.99044317e-01f, 1.69084713e-01f, 1.81478471e-01f, 1.45183459e-01f, 1.94833860e-01f, 1.96280956e-01f,
  2.89518803e-01f, 3.79522592e-02f, 1.12133652e-01f, -8.05158019e-02f, 1.69532984e-01f, 1.64004803e-01f, 2.00980604e-01f, -6.01824261e-02f, 3.94633934e-02f, -2.05662459e-01f,
  1.78713411e-01f, -4.24248502e-02f, 8.44653025e-02f, 8.49751309e-02f, -3.04140430e-02f, -3.66059281e-02f, 2.63946980e-01f, -8.50196835e-03f, 1.68052092e-01f, -2.45748103e-01f,
  -7.24472702e-02f, -1.66926265e-01f, 3.04883033e-01f, 8.16046745e-02f, -2.43465565e-02f, -1.17958309e-02f, 1.73020318e-01f, -8.61176923e-02f, 1.20690428e-01f, 4.98921843e-04f,
  -9.11076367e-02f, -1.01249501e-01f, 8.35794359e-02f, -1.18774466e-01f, -7.59591758e-02f, -7.70816877e-02f, -5.99773265e-02f, 2.11699642e-02f, 1.21767618e-01f, 1.65085256e-01f,
  -1.19674884e-01f, -6.61236942e-02f, 2.48873264e-01f, 1.89726695e-01f, 2.59793073e-01f, -2.67012894e-01f, -1.22876950e-01f, -2.22814262e-01f, -3.21811169e-01f, -2.78721988e-01f,
  -6.49505947e-03f, -1.78909570e-01f, 2.34614853e-02f, 1.70017213e-01f, -1.84627064e-02f, 5.74725196e-02f, 2.11378351e-01f, 1.53508693e-01f, 2.79085077e-02f, -1.08029366e-01f,
  1.51036143e-01f, 1.13801658e-01f, 1.34704635e-01f, 1.51842237e-01f, -9.22734514e-02f, -4.55462411e-02f, 1.77060824e-03f, 4.78176661e-02f, -4.13638428e-02f, 6.98774680e-02f,
  -2.11457938e-01f, 4.32069376e-02f, 6.79800063e-02f, -6.68819100e-02f, 1.44629017e-01f, 3.88522521e-02f, -4.67871837e-02f, -1.36885181e-01f, -5.55127896e-02f, 7.22483546e-02f,
  -1.31795168e-01f, 2.12590724e-01f, -1.67169973e-01f, -6.51401654e-02f, -1.27676606e-01f, -4.65262197e-02f, -1.39717609e-01f, 6.24177419e-02f, -1.39580369e-01f, 5.48298247e-02f,
  4.21719514e-02f, -1.34609938e-01f, -2.64211506e-01f, -2.84470320e-02f, 8.33491683e-02f, 4.84992377e-02f, 3.51007804e-02f, 3.89870524e-01f, -1.06949277e-01f, -2.21213654e-01f,
  4.50035520e-02f, 9.70526561e-02f, -2.20764265e-03f, 1.05110183e-01f, -1.67056248e-01f, 3.41757745e-01f, -1.35359034e-01f, 2.21422121e-01f, -1.75117686e-01f, 5.07493056e-02f,
  -2.12060404e-03f, 2.62599252e-02f, 1.73463926e-01f, -4.83362786e-02f, -1.18656226e-01f, -1.34472013e-01f, 1.11863449e-01f, -1.42274186e-01f, 3.49768549e-01f, -1.07174501e-01f,
  -1.54816091e-01f, -1.63397919e-02f, 1.17370114e-01f, 1.64044306e-01f, -2.60201544e-02f, -2.41634008e-02f, -1.41680483e-02f, 2.13097483e-02f, 6.01401702e-02f, 3.67490086e-03f,
  1.08797930e-01f, 7.51745850e-02f, -2.12944672e-01f, -3.86503302e-02f, -2.70214938e-02f, 4.90879118e-02f, -2.05545515e-01f, -1.33959409e-02f, -3.69403362e-02f, -1.08233886e-02f,
  8.97728428e-02f, -4.97762524e-02f, 6.88222572e-02f, 3.99823897e-02f, -2.42084507e-02f, 1.21638842e-01f, -9.35486406e-02f, -1.18845934e-02f, -2.74822503e-01f, -7.40299141e-03f,
  -1.10284276e-01f, 6.16719387e-02f, -2.04452395e-01f, -7.14964867e-02f, 6.77977949e-02f, -8.08995217e-02f, -3.32898311e-02f, -7.09865019e-02f, -2.50581224e-02f, -4.79710009e-03f,
  -2.44258419e-01f, 2.07113966e-01f, -1.08436920e-01f, -8.94654393e-02f, 1.00541160e-01f, -5.74586019e-02f, 9.87347811e-02f, -2.54534602e-01f, 2.55533196e-02f, 2.47204542e-01f,
  -9.59606245e-02f, -4.56191972e-02f, -1.59442022e-01f, -3.32494408e-01f, 1.36278406e-01f, 8.14679638e-02f, 1.15093902e-01f, -1.37433961e-01f, 3.20754051e-01f, 3.52109730e-01f,
  -2.86185175e-01f, 1.39484584e-01f, 2.01654807e-01f, -5.82941138e-05f, -7.25412592e-02f, -1.08891845e-01f, -1.83580041e-01f, 1.92731664e-01f, 1.03479430e-01f, 9.14174616e-02f,
  1.45346642e-01f, 1.21620186e-01f, -9.59288701e-03f, 1.38885200e-01f, 4.78184149e-02f, -3.52681540e-02f, -7.81575218e-02f, -9.37474817e-02f, -1.68678105e-01f, 1.48837313e-01f,
  1.01591416e-01f, 1.32267699e-01f, 7.55591178e-03f, 1.53801829e-01f, 2.13075895e-03f, -7.07860440e-02f, 1.03008054e-01f, 1.45220309e-01f, 6.92045242e-02f, 1.48823068e-01f,
  1.80784389e-01f, -2.25568086e-01f, -1.06749251e-01f, -2.19962057e-02f, -1.15168117e-01f, 7.60690942e-02f, -2.35873714e-01f, 1.99167699e-01f, -1.45183772e-01f, -5.52098304e-02f,
  -5.98469041e-02f, -1.68633293e-02f, 2.66206525e-02f, 1.93820983e-01f, -4.19051312e-02f, 2.32124239e-01f, -1.07437082e-01f, -4.53520626e-01f, -2.64467224e-02f, 1.64943442e-01f,
  -5.79413250e-02f, 6.84370548e-02f, -1.39797390e-01f, 1.42415479e-01f, -7.21230134e-02f, 1.62241936e-01f, -1.84050843e-01f, -4.58059385e-02f, -4.29748267e-01f, 1.11858912e-01f,
  -2.46797174e-01f, 8.71189237e-02f, -2.04890184e-02f, -2.87592947e-01f, 1.92338042e-02f, 1.88172162e-01f, -6.32874668e-02f, -2.15504304e-01f, 1.71294063e-01f, -8.07073489e-02f,
  3.07070762e-01f, -2.03546479e-01f, 1.66584377e-03f, -8.15022290e-02f, 2.99532473e-01f, -1.39885247e-01f, 1.51044615e-02f, 2.01391540e-02f, -7.03244284e-02f, 1.46615074e-03f,
  5.28706014e-02f, -2.35204846e-01f, -1.57191232e-01f, 3.84960398e-02f, 1.00718550e-01f, 2.75213569e-01f, -1.11800559e-01f, 2.37319976e-01f, -1.96224943e-01f, -3.77459489e-02f,
  -6.05996996e-02f, 1.42308280e-01f, -1.11138746e-01f, 1.22939967e-01f, 6.89405426e-02f, -1.56008720e-03f, 1.50934294e-01f, 5.28521724e-02f, -1.14728883e-01f, 1.26116425e-01f,
  -7.84348026e-02f, 1.59510225e-02f, -6.00488223e-02f, 2.15293318e-02f, 1.18870638e-01f, 1.55142501e-01f, 2.06618249e-01f, -1.62994582e-02f, 3.37953791e-02f, 1.18318222e-01f,
  1.34042352e-01f, -1.12633906e-01f, -1.70259714e-01f, -6.49606287e-02f, 7.94642325e-03f, 4.79822867e-02f, 8.39688629e-02f, -9.62202325e-02f, -1.80807680e-01f, 1.55376688e-01f,
  -1.56399652e-01f, -2.05581505e-02f, -1.32075936e-01f, -1.60642527e-02f, -1.56687036e-01f, -2.08169177e-01f, 6.54960126e-02f, -6.74486235e-02f, 2.30829492e-01f, -3.98971848e-02f,
  5.10681011e-02f, -4.72678542e-02f, 1.85528666e-01f, -2.09138125e-01f, 9.46493000e-02f, -4.21836786e-02f, 7.05135241e-02f, -2.47681160e-02f, 1.76861703e-01f, 8.22051466e-02f,
  -1.30220298e-02f, 8.69099051e-02f, 3.49159837e-02f, 1.58572406e-01f, -4.58361991e-02f, -4.64674272e-02f, 6.10494651e-02f, 7.01858923e-02f, 1.06188543e-01f, -3.23191360e-02f,
  -1.51490599e-01f, 1.76951140e-02f, 1.08986711e-02f, -2.64392328e-03f, -1.17738195e-01f, 1.00790272e-02f, 1.24284491e-01f, -8.63309726e-02f, 1.27522007e-01f, -1.29489340e-02f,
  1.74322709e-01f, -2.52292398e-02f, 2.31554806e-01f, 7.49462396e-02f, 4.25914824e-02f, 7.63510764e-02f, -6.65683951e-03f, 6.30920976e-02f, 1.27801940e-01f, 4.17925697e-03f,
  -1.71216559e-02f, -1.29357383e-01f, 6.52812719e-02f, -2.18945384e-01f, 4.81046364e-02f, 1.13920376e-01f, -9.78126824e-02f, 3.78744081e-02f, -3.03006824e-02f, 3.41096446e-02f,
  -2.00627185e-02f, -2.07316559e-02f, 1.50092710e-02f, 3.71620506e-02f, 2.07316354e-01f, -6.94127157e-02f, 1.00197263e-01f, 4.49267998e-02f, -2.01036140e-01f, -1.64110363e-01f,
  -1.16188321e-02f, -2.93474179e-02f, 1.08093053e-01f, 1.87982604e-01f, -1.33331671e-01f, 3.24966246e-03f, 3.88042331e-02f, 1.50154144e-01f, -2.02836558e-01f, -1.30628467e-01f,
  1.56424552e-01f, 7.32828602e-02f, 8.36429670e-02f, 3.38485576e-02f, 1.83431327e-01f, 2.41192174e-03f, 3.16598974e-02f, 2.95333490e-02f, 2.62436777e-01f, 2.05639556e-01f,
  2.31877968e-01f, -5.13635054e-02f, -3.77939790e-02f, -1.74516842e-01f, 2.35056236e-01f, 9.98930633e-02f, -5.26227392e-02f, -2.42977291e-02f, -4.13497947e-02f, 9.25642699e-02f,
  1.72193855e-01f, 1.09411523e-01f, 1.92396775e-01f, -1.19426727e-01f, -1.19317383e-01f, 1.58830881e-01f, 9.03464034e-02f, -8.75819325e-02f, -4.37028371e-02f, 1.55141177e-02f,
  1.17957711e-01f, 1.20730050e-01f, 6.83371499e-02f, -2.53210068e-01f, -5.28410636e-02f, 2.42485985e-01f, -1.49030173e-02f, 2.57226855e-01f, -4.64186557e-02f, -1.74828634e-01f,
  4.26333696e-02f, 2.18043834e-01f, 2.08264403e-02f, 2.26385906e-01f, -1.16840504e-01f, 9.66252908e-02f, 1.43048748e-01f, 1.74570709e-01f, -2.02687725e-01f, 8.42955895e-03f,
  -1.80104747e-01f, -6.41417922e-03f, -9.99470204e-02f, -7.19717517e-02f, -1.69128433e-01f, -2.41342127e-01f, -2.27984905e-01f, 6.20204620e-02f, 1.35619104e-01f, -2.01879069e-02f,
  1.28641039e-01f, -2.99288422e-01f, 1.38738826e-01f, -7.08281575e-03f, 8.92376602e-02f, -9.20138974e-03f, 1.89811647e-01f, 5.38942888e-02f, 6.76276386e-02f, 1.03959091e-01f,
  3.71048041e-02f, 3.80665734e-02f, 1.06414482e-01f, 5.40415198e-02f, -7.00402781e-02f, -8.57831240e-02f, -8.33165497e-02f, -2.88879294e-02f, -1.60202250e-01f, -5.92214949e-02f,
  8.45037103e-02f, -1.19101517e-01f, 6.55967146e-02f, -1.36740714e-01f, -6.04580902e-02f, -5.46346419e-02f, -1.67515963e-01f, 1.18117398e-02f, -2.67176241e-01f, -9.74569395e-02f,
  -9.53878835e-02f, 6.59726337e-02f, 1.62404627e-01f, -1.39103532e-01f, -7.32841119e-02f, 5.38931713e-02f, -2.77371258e-01f, -1.29572451e-01f, -1.55241191e-01f, -2.69131325e-02f,
  -1.43101349e-01f, -9.66195241e-02f, -1.32024750e-01f, 4.47958428e-03f, 9.07169357e-02f, -1.56317204e-02f, 1.42398685e-01f, 2.50861757e-02f, -1.32562533e-01f, 4.29371521e-02f,
  2.48380169e-01f, -3.84347960e-02f, -4.74660322e-02f, -1.43242225e-01f, 1.00246660e-01f, -2.34955009e-02f, 2.08776966e-01f, -2.40965858e-02f, 2.20183954e-01f, 3.53879273e-01f,
  -2.63739109e-01f, 2.36682165e-02f, 1.81444794e-01f, 2.07542866e-01f, -1.30764857e-01f, -1.12316705e-01f, 1.50016239e-02f, 1.84839696e-01f, -5.43032587e-02f, 8.45431257e-03f,
  5.51268458e-02f, 1.85242705e-02f, -4.52061743e-03f, 9.62557569e-02f, -1.63813487e-01f, 3.06920767e-01f, -5.39181493e-02f, -1.27975896e-01f, 3.13904621e-02f, -5.90780191e-02f,
  -7.47484863e-02f, 8.06136727e-02f, 7.89808556e-02f, 9.90321189e-02f, -5.90501428e-02f, 8.70254636e-02f, -1.12004049e-01f, -5.14508598e-02f, -2.25534782e-01f, 2.43052170e-02f,
  1.57388709e-02f, 4.02434841e-02f, 1.59367427e-01f, -7.36730918e-02f, 1.02948332e-02f, 8.02825391e-02f, -1.15141377e-01f, 2.65792519e-01f, 1.29850553e-02f, 5.27707338e-02f,
  -9.19286907e-03f, -1.29503146e-01f, 5.49857281e-02f, 1.87692121e-01f, -1.43753409e-01f, -7.30869398e-02f, 8.05269554e-02f, -5.04639708e-02f, 1.49127752e-01f, -6.21804409e-02f,
  1.47235036e-01f, -9.22350064e-02f, 6.69209212e-02f, 6.50930107e-02f, -2.19399244e-01f, 7.14172935e-03f, -2.50297934e-02f, 2.63950408e-01f, 9.08201262e-02f, 1.41532019e-01f,
  3.21059257e-01f, 2.59329546e-02f, 2.34207720e-01f, 2.31438354e-01f, 3.62778306e-01f, 2.00558782e-01f, -5.85316271e-02f, -1.67186558e-01f, -6.63729236e-02f, -4.26427871e-02f,
  1.14734970e-01f, 7.28554949e-02f, 3.78484726e-02f, 1.12804681e-01f, 1.56902552e-01f, 7.12313736e-03f, -1.31346844e-02f, -3.72781828e-02f, 6.02033027e-02f, -1.77442133e-01f,
  9.38622504e-02f, 1.27392516e-01f, -1.09451778e-01f, 2.18408299e-03f, 6.07596040e-02f, -1.81709066e-01f, -1.09975096e-02f, -5.47215790e-02f, 8.54720771e-02f, -7.02487752e-02f,
  1.25032023e-01f, -7.68194795e-02f, -1.61318511e-01f, -5.06386273e-02f, 4.24577435e-03f, -7.81694129e-02f, -8.52771252e-02f, 1.80543095e-04f, 1.37635767e-01f, 8.00812766e-02f,
  2.59097338e-01f, 1.46410987e-02f, 4.36409675e-02f, 8.58200341e-02f, -2.35404279e-02f, 8.58168900e-02f, 8.80727470e-02f, -1.99113220e-01f, 5.40111698e-02f, -2.20040604e-01f,
  8.47571120e-02f, 3.08870286e-01f, -1.42343407e-02f, -9.34989974e-02f, 4.87695821e-02f, -2.56331176e-01f, 6.20142706e-02f, -1.49304211e-01f, 2.86962032e-01f, 3.43690328e-02f,
  2.19180927e-01f, -5.38335368e-02f, 1.87022045e-01f, 3.57204042e-02f, -3.38435382e-01f, 5.75183257e-02f, -3.60545516e-02f, 6.00572228e-02f, 2.45058537e-02f, -1.55608699e-01f,
  1.11549146e-01f, 2.55744666e-01f, -1.73779473e-01f, 1.25609368e-01f, 1.34372506e-02f, 5.15229069e-02f, 1.75369140e-02f, 1.52951822e-01f, 1.70377165e-01f, -1.55974431e-02f,
  7.71291852e-02f, 1.32940197e-02f, 9.19719860e-02f, -6.34864196e-02f, 5.40809780e-02f, 2.02044379e-02f, 8.85476097e-02f, 9.56894979e-02f, 1.18141651e-01f, 3.20368484e-02f,
  -1.20506957e-01f, 7.40331486e-02f, 3.22577469e-02f, 4.08554450e-02f, -7.90988132e-02f, -5.96788228e-02f, -1.08487532e-01f, -7.25876614e-02f, -6.35021031e-02f, 1.05918691e-01f,
  1.76912755e-01f, 1.43600091e-01f, 2.55197082e-02f, -1.72794014e-01f, -9.13277566e-02f, 6.91500381e-02f, 6.63647754e-03f, -1.92537215e-02f, 8.11681077e-02f, 4.71934974e-02f,
  8.13534111e-03f, 3.92283425e-02f, 8.03187415e-02f, -8.24053138e-02f, 9.24817100e-02f, -2.47715376e-02f, -8.04450512e-02f, -1.31983057e-01f, -3.72209996e-02f, -1.62450746e-01f,
  -1.19308427e-01f, -8.50600377e-02f, -5.17897354e-03f, 5.20284288e-02f, 1.17880449e-01f, 2.76890155e-02f, -1.03276849e-01f, 8.95154104e-02f, -1.32730961e-01f, -1.56881079e-01f,
  8.96150470e-02f, -1.13984630e-01f, 9.39185172e-02f, 1.64607123e-01f, -1.94281504e-01f, -9.84842703e-02f, 2.70177200e-02f, -9.40943882e-02f, -6.03303611e-02f, 4.04971913e-02f,
  1.66553333e-01f, 2.96984911e-01f, 7.33297393e-02f, 1.01353653e-01f, 1.52036518e-01f, -2.24600397e-02f, -6.06886297e-02f, -3.13112915e-01f, 2.36458942e-01f, 2.06514910e-01f,
  4.02712822e-02f, -1.47574302e-02f, 1.03739873e-01f, -4.19304043e-01f, 2.07069770e-01f, -2.62378365e-01f, 1.32838294e-01f, 1.57627076e-01f, -2.88220253e-02f, -6.61908165e-02f,
  1.24519214e-01f, -8.21588933e-02f, 1.48380280e-01f, -1.09155148e-01f, 1.25356853e-01f, 2.07082599e-01f, 1.05240708e-02f, -1.14331104e-01f, 3.56818326e-02f, 1.21998966e-01f,
  -1.90593023e-02f, 1.72667325e-01f, 9.55717862e-02f, -1.89348325e-01f, -1.35232627e-01f, 3.04131228e-02f, 5.74430451e-02f, -2.16939583e-01f, 1.11947149e-01f, 2.24275619e-01f,
  -1.83325540e-02f, 1.91477537e-01f, 7.28645399e-02f, 1.47217795e-01f, -1.69460222e-01f, 1.52434230e-01f, 2.59185851e-01f, 5.28747216e-02f, 9.57657292e-04f, 3.99955586e-02f,
  -8.23106710e-03f, 6.17174171e-02f, -3.45274061e-01f, 2.68668924e-02f, -6.52266517e-02f, -1.08770773e-01f, -6.97373450e-02f, 3.51826906e-01f, -2.83984751e-01f, -2.35142112e-02f,
  -1.29967770e-02f, 3.95956896e-02f, 2.67942429e-01f, -1.91906497e-01f, -1.83891729e-02f, 4.89068478e-02f, 1.84881613e-01f, 2.37669095e-01f, 2.69267820e-02f, 9.08102617e-02f,
  -1.24935202e-01f, 2.36689486e-02f, 1.63524210e-01f, -5.61340749e-02f, 1.83500245e-01f, 1.19114429e-01f, 1.02369545e-03f, 1.54294781e-02f, -2.70531029e-01f, -5.24088368e-02f,
  -1.50010334e-02f, 1.62614331e-01f, -2.04968929e-01f, -5.24870865e-02f, -2.39071578e-01f, -2.87456214e-01f, 5.22777773e-02f, 2.07772836e-01f, 2.46641159e-01f, 2.55389541e-01f,
  -2.10009962e-01f, -6.01477809e-02f, -1.05809337e-02f, -2.77722348e-03f, -7.72638526e-03f, 1.64262220e-01f, 1.81128353e-01f, 8.83674473e-02f, -1.29574701e-01f, -1.29692137e-01f,
  7.53453001e-02f, 7.35468045e-02f, 1.71047524e-01f, 1.78597137e-01f, -9.76876020e-02f, -1.32970124e-01f, -3.92245091e-02f, -1.13147736e-01f, -1.94503888e-01f, -4.71563190e-02f,
  -4.75778058e-02f, -9.08955038e-02f, 1.90109476e-01f, -2.41725128e-02f, -1.85870286e-02f, 1.55914128e-01f, 3.03686764e-02f, -2.45997965e-01f, 2.63747305e-01f, 6.37247786e-02f,
  1.78466067e-01f, 1.23718726e-02f, -1.46938507e-02f, -4.27000821e-02f, -7.20589086e-02f, 6.97184876e-02f, 1.08290151e-01f, -3.72590609e-02f, -1.06514692e-01f, 1.18197724e-01f,
  1.26613006e-01f, 1.62051916e-01f, 3.52203548e-02f, -1.65450182e-02f, 5.09801507e-02f, 2.28294432e-01f, -9.48714092e-02f, -9.18424055e-02f, -2.92193592e-02f, 1.99863464e-01f,
  1.96727946e-01f, -2.31730100e-02f, -2.02946857e-01f, 1.49942547e-01f, 1.91108823e-01f, -3.84766199e-02f, 4.06717733e-02f, 5.22868447e-02f, -2.71175832e-01f, -1.95794418e-01f,
  2.08599139e-02f, 1.25628546e-01f, 2.66477048e-01f, 2.31319722e-02f, 6.20975755e-02f, 2.24969834e-01f, 2.28868172e-01f, 1.16119042e-01f, -9.63762105e-02f, 1.07855007e-01f,
  2.37080559e-01f, 5.58750145e-03f, -3.73312831e-02f, -1.81087032e-01f, 2.61306483e-02f, 1.77827347e-02f, 1.22923784e-01f, 8.24705362e-02f, -2.48786546e-02f, -2.56556094e-01f,
  -9.04789045e-02f, -3.18720281e-01f, 1.34195447e-01f, -2.04114288e-01f, 2.49040890e-02f, 5.94484583e-02f, 2.10354999e-01f, 2.42598057e-01f, 2.73833394e-01f, 1.45768821e-01f,
  -2.21911799e-02f, -3.61362398e-01f, -3.22047435e-03f, 1.42027050e-01f, 3.51695299e-01f, 3.30978185e-02f, -4.06420976e-02f, 1.45741716e-01f, -9.63944271e-02f, 3.78921479e-01f,
  -1.07151188e-01f, -1.63754508e-01f, 8.75345469e-02f, -4.67391647e-02f, 3.01380921e-02f, -3.13959531e-02f, 1.72827482e-01f, 5.73395640e-02f, 1.58151448e-01f, -2.97101196e-02f,
  1.35928899e-01f, 9.32370201e-02f, 1.08436383e-02f, -1.61718309e-01f, -3.32313985e-01f, -2.17155144e-02f, -1.47331923e-01f, 2.70041555e-01f, -1.96814060e-01f, -4.96318042e-02f,
  1.12199724e-01f, 1.83592394e-01f, 2.19627414e-02f, 1.26587436e-01f, -2.11310998e-01f, 6.59587383e-02f, -2.77426213e-01f, -9.47622489e-03f, -2.45887503e-01f, 1.62320495e-01f,
  -5.36081307e-02f, -4.26867381e-02f, 2.30875954e-01f, -2.32576519e-01f, -1.08118206e-01f, -3.31051312e-02f, -3.29674512e-01f, 9.46096033e-02f, -2.48028953e-02f, 2.80698776e-01f,
  -3.47403809e-02f, 4.21167538e-02f, 1.67640641e-01f, 1.43121511e-01f, 5.54527082e-02f, -3.16045910e-01f, 1.64016441e-01f, 2.41731629e-01f, 2.97672190e-02f, 1.39041618e-01f,
  -7.34657198e-02f, -2.67472476e-01f, 1.58193499e-01f, -3.64274681e-01f, 6.85321465e-02f, -6.86127394e-02f, -1.51735425e-01f, -7.46909678e-02f, -1.00642301e-01f, -7.18297288e-02f,
  1.81307003e-01f, -6.26342883e-03f, -9.62002352e-02f, -1.71350226e-01f, -2.62459725e-01f, 7.16890721e-03f, 9.15578306e-02f, 3.76134776e-02f, 1.06799878e-01f, 4.66479063e-02f,
  -1.99714065e-01f, -2.75369175e-02f, -1.53210983e-01f, -8.63580480e-02f, 6.40991405e-02f, 4.38280627e-02f, -1.33311674e-01f, 8.50581974e-02f, 1.15490071e-02f, 2.15284243e-01f,
  -1.96826994e-01f, 2.16725320e-01f, -2.10066631e-01f, 1.01509996e-01f, 7.85627495e-03f, -1.55314878e-01f, 4.88016456e-02f, 5.44653200e-02f, -1.55620314e-02f, 1.13858357e-01f,
  -4.98904586e-02f, 1.51825890e-01f, -4.52919416e-02f, -1.57690674e-01f, 1.83597617e-02f, 2.68420782e-02f, -6.49092942e-02f, -4.93597016e-02f, -6.26129424e-03f, 1.03237852e-01f,
  4.02773134e-02f, -1.26109481e-01f, 3.52015831e-02f, 4.57903445e-02f, 1.77111372e-01f, 2.74635032e-02f, 2.14834437e-02f, -1.90330192e-01f, -9.05366838e-02f, 2.33224407e-01f,
  -7.22598657e-02f, -1.41742885e-01f, -2.47400492e-01f, -3.49492617e-02f, -2.26193234e-01f, 1.85106650e-01f, -3.34887296e-01f, 3.17778625e-02f, 2.65822690e-02f, 5.54655725e-03f,
  1.59176454e-01f, -2.51806617e-01f, 5.48995696e-02f, 9.89698619e-03f, -9.85682607e-02f, -1.93820715e-01f, 2.07632616e-01f, -1.97413683e-01f, 1.49411798e-01f, -4.45900895e-02f,
  -2.63458099e-02f, -1.26337722e-01f, 3.95722352e-02f, -7.10329711e-02f, -4.56311256e-02f, -8.77126977e-02f, -8.30514953e-02f, 2.47557506e-01f, -5.41222095e-02f, -1.26544818e-01f,
  2.84472876e-03f, 6.75974116e-02f, 1.06012069e-01f, 2.76673466e-01f, -1.57911375e-01f, 1.89567924e-01f, -2.75634062e-02f, -7.40831420e-02f, 4.59359214e-02f, 6.27641454e-02f,
  -9.42737162e-02f, 1.46422544e-02f, 6.25406429e-02f, 1.51278943e-01f, 1.43568695e-01f, -7.81617016e-02f, -1.27949983e-01f, 4.15519392e-03f, 8.37672502e-02f, 1.38337761e-01f,
  6.83045536e-02f, 1.76461972e-02f, 1.00756556e-01f, -2.54909098e-02f, 1.36000812e-01f, -2.98855692e-01f, 1.05006166e-01f, -6.20394051e-02f, 3.11122406e-02f, 7.80189584e-04f,
  -1.32854611e-01f, -1.94279492e-01f, 2.45861337e-02f, -2.34727442e-01f, 2.02161223e-01f, -9.78753865e-02f, -1.75532103e-01f, 1.60866201e-01f, -1.07006729e-01f, -4.05121886e-04f,
  1.71647638e-01f, -8.48539770e-02f, 1.03865445e-01f, -1.41689762e-01f, -8.64177346e-02f, 5.20054810e-02f, 1.85436577e-01f, -2.12983683e-01f, -5.91301024e-02f, -4.95806970e-02f,
  -1.29910737e-01f, -8.53431299e-02f, -1.19956926e-01f, 7.09732845e-02f, 1.60605580e-01f, 1.91982731e-01f, 1.34240761e-01f, 2.73560937e-02f, 1.65426806e-01f, -2.03352664e-02f,
  7.23598376e-02f, -1.82927519e-01f, 8.33898876e-03f, 2.19723731e-02f, 7.43570924e-02f, 1.59057155e-01f, 1.51970208e-01f, -2.76760310e-01f, 8.85783881e-02f, 1.43655911e-02f,
  2.46008486e-02f, 1.49627954e-01f, -1.45804316e-01f, -9.62753221e-02f, 1.68570161e-01f, -5.08840904e-02f, 7.30901212e-02f, 1.22613788e-01f, 2.10028365e-01f, 1.11044466e-01f,
  3.59760195e-01f, -4.38402668e-02f, 1.20203488e-01f, -2.37109847e-02f, -1.48327470e-01f, 1.35533944e-01f, 1.49351582e-01f, -7.82995373e-02f, 1.20641939e-01f, -1.03017777e-01f,
  1.31167576e-01f, -3.17803979e-01f, -7.51678745e-05f, 5.37824929e-02f, -5.83353750e-02f, 4.91320528e-02f, 1.60307586e-02f, 9.11469162e-02f, -8.64722878e-02f, 2.65697613e-02f,
  1.96873453e-02f, -1.02142803e-01f, 6.05747551e-02f, -1.45696759e-01f, 3.21755931e-02f, 9.32972953e-02f, -9.82628241e-02f, -3.79626416e-02f, 1.81543991e-01f, -1.25110760e-01f,
  3.09104449e-03f, 1.94977552e-01f, -1.57911479e-01f, 3.01424805e-02f, 1.35577291e-01f, 1.77801251e-01f, 1.39121115e-01f, -2.29752615e-01f, 8.78121853e-02f, 9.10438690e-03f,
  4.59553413e-02f, 1.43280953e-01f, -1.01262815e-01f, 1.42798066e-01f, 6.43722862e-02f, 8.35164785e-02f, -1.01371847e-01f, -2.64952332e-01f, -9.73368809e-02f, 2.12210879e-01f,
  1.18210457e-01f, 3.26776803e-01f, -3.55618417e-01f, -1.06990393e-02f, 6.86907545e-02f, -1.72863640e-02f, 3.40657197e-02f, 2.36914903e-02f, -1.06161296e-01f, -7.25004226e-02f,
  6.54781982e-02f, 1.07404232e-01f, 2.32496440e-01f, 7.88158700e-02f, 1.85431615e-01f, 7.12366626e-02f, 1.49323456e-02f, -4.93890047e-02f, -8.59403703e-03f, -1.05205746e-02f,
  2.09917307e-01f, 1.80654332e-01f, 2.39535555e-01f, -3.38824600e-01f, 1.39381424e-01f, -1.78222314e-01f, -6.74172863e-02f, 1.51674166e-01f, -3.28893214e-02f, -4.66091558e-02f,
  -7.47157410e-02f, -2.31802881e-01f, 4.95173708e-02f, -8.94221887e-02f, 9.35464799e-02f, -2.83403578e-03f, 1.23849325e-01f, -1.66101195e-03f, 2.95353860e-01f, 1.89324275e-01f,
  -2.09533468e-01f, -3.27184230e-01f, 1.24210723e-01f, 1.47859663e-01f, 1.21531658e-01f, -4.21317108e-02f, -1.11760855e-01f, -5.12561575e-02f, 1.18213542e-01f, 1.16494760e-01f,
  -9.74335941e-04f, 5.82596399e-02f, 1.37351372e-03f, 6.85461015e-02f, 4.74194624e-02f, 9.15590376e-02f, -8.62711668e-02f, 8.10754448e-02f, 1.56560048e-01f, 7.69868568e-02f,
  -5.14530800e-02f, 1.43818255e-03f, 2.35751912e-01f, -4.15279455e-02f, -1.27786249e-01f, -1.07318610e-01f, 8.12566355e-02f, 1.74128130e-01f, 3.50393318e-02f, -1.18561395e-01f,
  1.21729687e-01f, 2.49399439e-01f, 7.86233991e-02f, 1.40256956e-01f, -1.85079038e-01f, 8.87715742e-02f, -3.33952904e-01f, 2.87055001e-02f, -7.24308612e-03f, 1.88450947e-01f,
  5.14869578e-02f, 8.34919661e-02f, -2.46504694e-02f, -1.59710810e-01f, -1.69346094e-01f, -3.03174276e-02f, -2.94561088e-01f, 3.40970010e-02f, -2.19569504e-01f, 3.50712121e-01f,
  -1.57666475e-01f, -7.66717792e-02f, -1.38676509e-01f, 1.28578305e-01f, -5.20964339e-02f, -4.43487875e-02f, -3.43991304e-03f, 2.33767375e-01f, -1.10547826e-01f, 2.07546189e-01f,
  -5.49739897e-02f, -1.95199475e-01f, 1.09686963e-01f, 1.64644212e-01f, -1.02863237e-02f, -2.27289394e-01f, -3.90208215e-01f, -1.41013518e-01f, 3.31297189e-01f, -5.29659837e-02f,
  8.97827521e-02f, -8.15955848e-02f, 2.85341684e-02f, 2.40653846e-02f, -2.79958010e-01f, 1.72202550e-02f, -1.00683123e-01f, -1.19955512e-02f, 4.72465269e-02f, -3.13252695e-02f,
  4.32308614e-02f, -7.91493058e-02f, -1.29214466e-01f, 1.26371920e-01f, 1.23693869e-01f, -5.32517731e-02f, -1.42154157e-01f, -5.47869876e-02f, 8.64219666e-02f, 1.70597702e-01f,
  -1.33554533e-01f, -7.04592466e-03f, -1.00600515e-02f, 6.83535263e-02f, -3.44823860e-03f, -7.22809285e-02f, -2.07275897e-01f, -1.07932352e-01f, -2.88673230e-02f, 2.48172194e-01f,
  -3.30241601e-04f, 3.41842994e-02f, 6.19136505e-02f, 2.08260473e-02f, -4.66256514e-02f, 5.32472767e-02f, 3.31116617e-02f, 1.79157436e-01f, -2.35751234e-02f, -1.47527635e-01f,
  1.32886440e-01f, -2.40470380e-01f, 2.41973251e-02f, 6.43101186e-02f, 2.42207453e-01f, 1.37230784e-01f, -1.39130130e-01f, -8.21715966e-02f, -1.34101540e-01f, -1.31307349e-01f,
  5.98494522e-02f, -3.71934846e-02f, -2.33902503e-02f, -1.80898711e-01f, -1.28013313e-01f, 1.11367382e-01f, 1.72517300e-01f, 1.52121440e-01f, 4.53384876e-01f, 1.66978855e-02f,
  9.09952819e-02f, 2.02133749e-02f, 2.28578195e-01f, -4.58647646e-02f, -1.27863005e-01f, 3.57312560e-02f, -1.36176990e-02f, -1.26216605e-01f, -4.84515540e-02f, 1.18530355e-02f,
  6.88101500e-02f, -4.35175896e-02f, -9.05417204e-02f, 8.97749960e-02f, -1.99463516e-01f, -1.02179743e-01f, 1.34455012e-02f, 1.27060357e-02f, -1.69540033e-01f, -8.41610413e-03f,
  -2.07663462e-01f, 1.73468739e-01f, 1.64518893e-01f, -8.51601537e-04f, 1.25162512e-01f, -1.17988795e-01f, 1.39469951e-02f, 1.32833347e-02f, 1.08846337e-01f, 2.28256546e-02f,
  -2.35560656e-01f, -8.63007903e-02f, -1.23022478e-02f, -6.52383417e-02f, 1.65186062e-01f, 2.49496079e-04f, -2.42539234e-02f, -7.52742738e-02f, -2.17524141e-01f, 2.65502185e-01f,
  1.61398977e-01f, 1.39725246e-02f, -1.40932932e-01f, -2.65128016e-02f, 3.04111689e-02f, 2.27371708e-01f, 1.63675562e-01f, -3.54511142e-02f, -1.35344356e-01f, -8.53456333e-02f,
  2.96227098e-01f, -3.58744077e-02f, 1.07359864e-01f, 1.65228248e-01f, 3.46063189e-02f, 9.47628692e-02f, -5.69819659e-02f, 5.76981977e-02f, -1.64002210e-01f, 1.71122164e-01f,
  -1.51668340e-01f, -1.36885405e-01f, -1.79324031e-01f, 1.28301650e-01f, -1.59898356e-01f, -1.26819193e-01f, -8.12528133e-02f, 1.61017329e-01f, -1.98190217e-03f, -1.12453543e-01f,
  -1.30456433e-01f, -2.14626446e-01f, 4.07399684e-01f, -8.80770981e-02f, 1.35692269e-01f, 1.26734808e-01f, 1.31970406e-01f, 4.90574539e-02f, 2.85490528e-02f, 4.19055521e-02f,
  1.04965337e-01f, -2.36740932e-02f, -7.69016668e-02f, 4.25249152e-02f, 1.44289047e-01f, -1.01068400e-01f, -8.90599340e-02f, 1.50885612e-01f, 8.22909847e-02f, 1.90138102e-01f,
  1.15747727e-01f, -1.69525519e-01f, 4.87687178e-02f, 1.44420505e-01f, -2.63137389e-02f, 1.06598660e-01f, 4.78794724e-02f, -1.73325211e-01f, -1.96041048e-01f, -3.86650749e-02f,
  1.33521631e-01f, 6.84476867e-02f, -1.08471952e-01f, -4.30176482e-02f, -9.96578485e-02f, -2.92242435e-03f, 1.66831966e-02f, 1.21457398e-01f, 4.62406948e-02f, -1.00560866e-01f,
  -2.26108059e-02f, 2.88399279e-01f, -1.52623132e-01f, -1.06007062e-01f, -7.99855366e-02f, 2.16869384e-01f, -8.31383094e-02f, -6.34397939e-02f, -2.93554097e-01f, 5.39760552e-02f,
  3.23287062e-02f, -9.32845578e-04f, -2.50831321e-02f, -4.00018692e-02f, 1.32139966e-01f, -1.19737342e-01f, 9.80984718e-02f, -1.28340378e-01f, -2.24953666e-01f, -1.77024386e-03f,
  4.26410958e-02f, 4.91044335e-02f, 1.14124857e-01f, 3.09375823e-02f, 9.75162834e-02f, 5.92025854e-02f, -2.05694944e-01f, 7.34650269e-02f, 1.09383062e-01f, 1.51309773e-01f,
  6.01338930e-02f, -1.43968277e-02f, -2.22330783e-02f, -9.82403383e-02f, 7.13379756e-02f, -4.90626618e-02f, 1.06016695e-01f, 3.72649431e-02f, 8.87891743e-03f, 2.83873137e-02f,
  -2.53056854e-01f, -1.65232480e-01f, -5.41096367e-02f, 1.52316287e-01f, 1.98054284e-01f, -1.64410368e-01f, 1.76968321e-01f, 1.76365107e-01f, -8.34437236e-02f, 1.20382801e-01f,
  1.83454752e-01f, -1.01332545e-01f, -2.83483684e-01f, -2.29180291e-01f, -2.54879773e-01f, 2.06687719e-01f, 1.80768907e-01f, 1.25703037e-01f, 9.91714187e-03f, -1.04115568e-01f,
  -1.34622976e-01f, 3.22953761e-02f, -2.64966846e-01f, -1.01671457e-01f, -3.44571710e-01f, -6.30207807e-02f, -2.17001233e-02f, -9.67892185e-02f, 2.63958294e-02f, 2.58769318e-02f,
  -3.16137187e-02f, -3.90127972e-02f, 6.65398240e-02f, 1.27199236e-02f, 1.29218474e-01f, -2.60763485e-02f, 1.02984339e-01f, -2.08615199e-01f, 9.37443450e-02f, -2.36929804e-01f,
  1.07519843e-01f, -8.90550837e-02f, -2.18314696e-02f, 2.78935313e-01f, 2.83193827e-01f, 4.89287125e-03f, -1.74386561e-01f, 5.48157841e-02f, 1.20718107e-01f, 1.59103855e-01f,
  -1.03694089e-01f, 2.91528963e-02f, 3.25841494e-02f, 1.51411369e-01f, 1.64669529e-01f, 2.05282137e-01f, 1.29198834e-01f, 2.60526776e-01f, -1.00237923e-02f, 8.62809718e-02f,
  -9.53916088e-02f, 1.04082286e-01f, -1.02404098e-03f, 6.35904297e-02f, -1.64580047e-01f, 8.35749060e-02f, 2.41021678e-01f, 2.47622617e-02f, -1.55185219e-02f, -1.73122305e-02f,
  8.71461183e-02f, 2.84360573e-02f, 1.05059959e-01f, -6.05777316e-02f, 1.57316908e-01f, -6.95032477e-02f, -4.15907986e-02f, -1.23763904e-01f, 6.78442046e-02f, 8.82163718e-02f,
  -3.86372977e-03f, 6.34397864e-02f, -2.92649381e-02f, -9.26302820e-02f, -1.11723617e-01f, -9.94345099e-02f, 4.53466065e-02f, 1.32287264e-01f, -2.41442442e-01f, 6.65566921e-02f,
  -5.64362444e-02f, -3.97363126e-01f, -2.31768209e-02f, 6.59963712e-02f, 6.86216876e-02f, 2.97781855e-01f, -1.57677799e-01f, 1.93121508e-01f, -1.72824606e-01f, -3.90456349e-04f,
  -1.87081903e-01f, 2.36395095e-02f, -1.18214019e-01f, -1.45699516e-01f, 6.11535721e-02f, -1.07938379e-01f, -9.17919949e-02f, 2.56516814e-01f, 1.49023429e-01f, 2.94977605e-01f,
  1.25841079e-02f, -1.25954032e-01f, 2.32666805e-02f, 2.63272747e-02f, 9.89552662e-02f, 1.59756079e-01f, -8.65218192e-02f, 6.28323406e-02f, 8.40364303e-03f, 1.45455390e-01f,
  1.01428412e-01f, 2.37316955e-02f, -4.48383484e-03f, 1.14815831e-01f, 7.03578070e-02f, -9.24964249e-02f, 1.09108008e-01f, 7.50802606e-02f, 5.39620109e-02f, -1.43011600e-01f,
  -1.61602885e-01f, -1.63251609e-01f, -4.09510918e-02f, 1.53989866e-01f, -1.57076597e-01f, -9.55542326e-02f, 5.96572459e-02f, -2.15158343e-01f, 1.30980298e-01f, 9.96028259e-02f,
  5.02451099e-02f, 1.72131136e-01f, 1.01498310e-02f, 1.64025411e-01f, 8.97494853e-02f, 1.10317364e-01f, -9.77782160e-02f, 1.20918952e-01f, 7.15358034e-02f, -3.42060216e-02f,
  -1.46172568e-01f, 1.34739578e-02f, 9.90405530e-02f, 1.35416135e-01f, 1.80651516e-01f, 1.52647302e-01f, 8.14115480e-02f, -3.04259285e-02f, -1.16949797e-01f, 1.37761891e-01f,
  -5.23378104e-02f, -8.78192708e-02f, 3.98816876e-02f, 3.47882286e-02f, 1.54210433e-01f, 1.08608007e-01f, -2.45409027e-01f, 1.22305952e-01f, -2.06300944e-01f, -2.16403365e-01f,
  1.18227944e-01f, -1.12635642e-01f, 2.18428329e-01f, 2.78327912e-02f, -7.83526450e-02f, 8.02534167e-03f, 1.50563598e-01f, 1.82394966e-01f, -1.60951894e-02f, 7.40639120e-03f,
  -1.87934563e-02f, 1.13283165e-01f, 1.47890627e-01f, 1.63648903e-01f, 1.71410158e-01f, 2.18461119e-02f, -1.45348636e-02f, 1.03727821e-02f, 1.56869829e-01f, -7.78922886e-02f,
  1.55244440e-01f, 2.85928369e-01f, 2.46867985e-01f, -3.20060074e-01f, -9.77107510e-02f, -1.95954382e-01f, 5.88604398e-02f, 2.19828874e-01f, -1.93000585e-01f, -2.38916576e-01f,
  -5.08916453e-02f, -2.53166765e-01f, 6.07380867e-02f, 1.55912176e-01f, -4.51371782e-02f, 2.46926561e-01f, 3.13480385e-02f, 1.32434860e-01f, 1.47134170e-01f, 1.08712584e-01f,
  -8.04345906e-02f, 2.71626621e-01f, 1.56720132e-01f, -1.05350360e-01f, -2.48977289e-01f, -2.01855958e-01f, 1.76930338e-01f, -6.40759058e-03f, 1.27688736e-01f, 2.20410392e-01f,
  -1.48511186e-01f, 2.78342851e-02f, -1.55946851e-01f, -1.50581568e-01f, -1.26406044e-01f, 4.43192571e-02f, 6.78080842e-02f, -2.63730019e-01f, 1.37592986e-01f, -8.48774239e-02f,
  -7.59183709e-03f, -4.18855138e-02f, -1.96300343e-01f, -2.62158006e-01f, 1.75263673e-01f, -9.18032899e-02f, 1.34556830e-01f, 4.19908725e-02f, -6.53689876e-02f, 1.02095120e-01f,
  -1.90414190e-01f, 3.48248392e-01f, 2.13713288e-01f, -1.75371140e-01f, 1.52292475e-01f, 1.01249315e-01f, 2.20321994e-02f, 6.53270781e-02f, 1.16623580e-01f, 8.93156230e-02f,
  7.94244371e-03f, -2.11736500e-01f, 8.53683800e-02f, 6.42060265e-02f, 9.60414782e-02f, 1.83909371e-01f, 1.25550464e-01f, -2.24341854e-01f, -1.56509683e-01f, -9.83615965e-02f,
  2.47865558e-01f, 7.97366630e-03f, 4.29557078e-02f, 2.03910023e-02f, -1.63248628e-01f, -1.08160555e-01f, 1.13226138e-01f, 1.79132260e-02f, -4.11379896e-02f, -1.01719014e-02f,
  8.85192826e-02f, 8.65377337e-02f, 2.03889161e-01f, 2.13404998e-01f, 1.70731574e-01f, 2.95249466e-02f, -2.39992775e-02f, -5.75371310e-02f, 1.22492202e-02f, -1.82366222e-01f,
  3.37601145e-04f, -2.84724385e-01f, 1.19173229e-01f, 3.07479501e-01f, 6.74866736e-02f, -1.05377711e-01f, -9.41145197e-02f, -3.33017766e-01f, 7.76305720e-02f, -1.24460580e-02f,
  1.00167565e-01f, -8.65221620e-02f, 4.06975657e-01f, -5.04292250e-02f, 5.08855134e-02f, -1.01408273e-01f, -3.62734169e-01f, -1.65099427e-01f, -1.13933392e-01f, -4.24183235e-02f,
  1.85019210e-01f, 6.58332719e-04f, 4.30203453e-02f, 2.30622604e-01f, -2.34393463e-01f, 3.02486509e-01f, 1.57015994e-01f, -8.56937319e-02f, 1.40139788e-01f, 5.64711988e-02f,
  6.00972623e-02f, 1.59580126e-01f, 6.28062114e-02f, 6.89997226e-02f, -5.71851633e-05f, -1.63274288e-01f, -1.19272582e-02f, 2.48134248e-02f, -1.14700414e-01f, 7.42147639e-02f,
  1.03491753e-01f, 2.22375412e-02f, -1.14653274e-01f, -3.20930146e-02f, 2.61020400e-02f, 1.90555334e-01f, -7.39758536e-02f, 6.91553727e-02f, 2.05913410e-01f, 6.69181347e-02f,
  -4.06374596e-02f, 8.91167969e-02f, 9.33711529e-02f, 6.04091100e-02f, 2.25116491e-01f, -7.10266456e-02f, -4.12456580e-02f, -2.22384840e-01f, -7.12374672e-02f, -3.74650247e-02f,
  1.34599864e-01f, 2.30335519e-01f, 1.34058610e-01f, -3.21356654e-02f, 2.34002784e-01f, -9.78553817e-02f, -9.89411771e-02f, -8.15981328e-02f, -1.01831406e-01f, -8.73383060e-02f,
  8.76247808e-02f, 1.70048043e-01f, -1.01615191e-01f, -8.18997398e-02f, 3.14192586e-02f, -1.03392132e-01f, -1.82239562e-02f, 3.12351510e-02f, 9.39097777e-02f, -2.87387930e-02f,
  -2.20735610e-01f, -1.83536366e-01f, -6.82299212e-02f, -6.89624771e-02f, 2.77950801e-02f, 1.12713888e-01f, -8.00643638e-02f, -5.97005785e-02f, 1.80766076e-01f, -8.69007483e-02f,
  1.06473655e-01f, -1.26801699e-01f, 5.97128905e-02f, -1.06057830e-01f, -2.32212730e-02f, -4.02219743e-02f, 1.64964125e-01f, 5.19950055e-02f, 9.11064446e-02f, 1.26614599e-02f,
  -1.19044036e-01f, 1.96935669e-01f, -5.16035706e-02f, -7.39241242e-02f, -8.58614892e-02f, -4.93310690e-02f, 9.37848613e-02f, -6.75144419e-02f, 1.09327286e-01f, -1.75806686e-01f,
  1.18379280e-01f, 4.00357023e-02f, 1.19530611e-01f, -4.55466099e-02f, 1.60038412e-01f, 1.40113413e-01f, -1.45898506e-01f, -5.11575751e-02f, -4.66355234e-02f, 1.72529623e-01f,
  2.24720880e-01f, 9.02207866e-02f, 2.41098106e-02f, 1.01600982e-01f, -2.71400027e-02f, -1.00754656e-01f, -8.04448724e-02f, -7.86713883e-02f, -1.56344280e-01f, -7.11343363e-02f,
  7.51024783e-02f, 1.21514596e-01f, 8.44232664e-02f, -7.06541389e-02f, 1.10240549e-01f, -1.23180442e-01f, 1.11077785e-01f, -1.41732439e-01f, 5.82823753e-02f, -9.29892659e-02f,
  8.28605890e-02f, 1.02511548e-01f, -2.12246869e-02f, -1.49702787e-01f, -2.55525231e-01f, -1.21536385e-02f, -1.26124844e-01f, 3.24627049e-02f, 1.98221430e-02f, -4.40000147e-02f,
  -1.30956784e-01f, 2.23603636e-01f, -8.34758580e-02f, 3.26989815e-02f, 8.60435739e-02f, 7.09660649e-02f, 5.58265811e-03f, -1.18035667e-01f, -7.73263276e-02f, -1.31987948e-02f,
  -1.04659237e-01f, -1.60617322e-01f, 2.62752324e-01f, -3.15948308e-01f, 2.38688871e-01f, 1.74526826e-01f, 4.91711162e-02f, -1.63482398e-01f, -2.60511130e-01f, 1.28285410e-02f,
  -1.91908762e-01f, -2.85857439e-01f, 1.92638099e-01f, 8.30407371e-04f, 1.68529153e-01f, -1.32446542e-01f, -3.65890935e-02f, -2.03219578e-01f, -2.56003439e-01f, -2.69901335e-01f,
  -1.64864331e-01f, -9.29877236e-02f, -6.91802427e-02f, -2.08485633e-01f, 1.25007346e-01f, -5.94146177e-02f, 2.01856717e-01f, -7.88643733e-02f, 8.46975073e-02f, -1.29223466e-01f,
  -1.09229967e-01f, -1.61822941e-02f, -1.47972256e-01f, -2.03692049e-01f, -2.49279648e-01f, -5.80808632e-02f, 1.22101389e-01f, -1.83866307e-01f, 1.00043178e-01f, 5.11910953e-02f,
  -1.42894406e-02f, 3.23745683e-02f, 2.59571850e-01f, -1.26508651e-02f, -6.25031963e-02f, -3.21665615e-01f, 3.94718982e-02f, -1.28021061e-01f, -1.24517726e-02f, 3.10235284e-02f,
  -1.02689132e-01f, 1.73224196e-01f, -3.89689833e-01f, -1.13523543e-01f, 1.32372782e-01f, 1.00015119e-01f, -1.06336728e-01f, -2.80943036e-01f, -1.31953269e-01f, 1.46294400e-01f,
  1.43084347e-01f, 1.34591281e-01f, 1.37811154e-01f, 1.24233775e-01f, 1.82511255e-01f, 1.28270626e-01f, -6.08301498e-02f, 8.31089094e-02f, 1.21467479e-01f, 1.99641407e-01f,
  1.37537554e-01f, -1.52827635e-01f, 9.60840657e-02f, -2.64569312e-01f, 1.28414676e-01f, -3.66803020e-01f, 2.88723260e-02f, 2.39009187e-02f, 4.29745764e-02f, -1.36351645e-01f,
  2.76976138e-01f, -3.99205126e-02f, 1.49429962e-01f, -1.39959559e-01f, -8.06818232e-02f, 4.87970337e-02f, 1.74313396e-01f, -4.26701941e-02f, -7.09454864e-02f, -3.26864980e-02f,
  -1.06099091e-01f, -4.90980968e-02f, -2.40797456e-02f, -8.14572498e-02f, -1.51320696e-01f, 1.08075783e-01f, -1.04523502e-01f, -3.89989503e-02f, 2.60629207e-02f, 1.68060623e-02f,
  4.30804454e-02f, -6.24458306e-03f, 3.04526538e-02f, 6.46587508e-03f, 1.24008665e-02f, -1.03218436e-01f, 2.46080130e-01f, 3.44646792e-03f, 2.99387611e-02f, -1.02469221e-01f,
  1.30553832e-02f, -2.08504602e-01f, 4.52763513e-02f, -2.75514629e-02f, 1.28849640e-01f, 1.14601560e-01f, -1.08453721e-01f, 9.04252157e-02f, 8.60513076e-02f, 5.21893725e-02f,
  -1.28581494e-01f, 4.33546752e-02f, -3.47614437e-02f, -1.77512318e-02f, -3.72262113e-02f, 6.97592497e-02f, 1.55619262e-02f, 4.69505340e-02f, 2.45070960e-02f, -1.27224321e-03f,
  -6.52575493e-02f, 2.26719305e-02f, -1.30667537e-02f, -1.78692326e-01f, 3.33781466e-02f, 1.09902136e-01f, 1.44293504e-02f, -5.83932474e-02f, 6.93058595e-02f, -2.22233996e-01f,
  -1.59618229e-01f, 1.82059407e-01f, 2.36971881e-02f, 8.70860144e-02f, -1.06885552e-01f, -5.38876317e-02f, -6.71557486e-02f, 1.70854598e-01f, 4.83069289e-03f, 2.87307411e-01f,
  -2.07516983e-01f, -4.74633649e-03f, -3.20378393e-02f, 1.08831920e-01f, 1.35469146e-03f, 2.36351922e-01f, -1.70549393e-01f, -6.55018678e-03f, -3.43483575e-02f, 2.20267117e-01f,
  -3.50286695e-03f, -1.60599619e-01f, 2.18241468e-01f, 2.85758197e-01f, 1.04443438e-01f, 4.37479690e-02f, 5.27615733e-02f, 1.40719488e-02f, -2.57182531e-02f, -3.14388494e-03f,
  -6.47421926e-02f, -8.02265108e-02f, 5.49496152e-02f, -1.75633910e-03f, -3.86542559e-01f, 1.10998087e-01f, 1.89784676e-01f, 2.61505336e-01f, 1.67191878e-01f, -1.55541688e-01f,
  3.34908515e-02f, 1.17389411e-02f, 6.20021224e-02f, -4.85623516e-02f, 5.00250887e-03f, 1.07626431e-01f, 3.26935709e-01f, 2.05991670e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -1.10680247e-02f, 1.69212431e-01f, 3.06099653e-02f, -1.39278814e-01f, 6.09541088e-02f, -1.21924885e-01f, 1.34083092e-01f, 2.13590950e-01f, 2.59494156e-01f, 1.76703140e-01f,
  2.55374700e-01f, -1.86144590e-01f, 6.11889027e-02f, -1.15685221e-02f, 2.64431298e-01f, 5.88600747e-02f, 1.04336902e-01f, -4.88497689e-02f, 1.53300673e-01f, 1.69797331e-01f,
  3.30787823e-02f, 9.34972428e-03f, 2.83748545e-02f, 3.71373482e-02f, 1.73364699e-01f, 2.25692898e-01f, 1.87996462e-01f, -1.44687176e-01f, 6.29608557e-02f, 4.17871475e-02f,
  1.12869032e-01f, 1.13977734e-02f, 3.04244794e-02f, -2.76737679e-02f, -1.20845780e-01f, 5.53189479e-02f, 5.83099239e-02f, 1.41515866e-01f, 1.09235689e-01f, -1.35985836e-01f,
  -1.63510844e-01f, 1.45040154e-01f, 2.11960956e-01f, 2.77173698e-01f, 2.64705531e-02f, 3.32443677e-02f, 6.61920905e-02f, 1.20672464e-01f, 1.38711259e-01f, -7.78650567e-02f,
  9.39283073e-02f, 4.21486348e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.25971560e-02f, 1.07139774e-01f, -1.83723420e-01f, 3.07422481e-03f, 4.69130650e-02f, 1.72554180e-02f, -1.21890828e-02f, 2.69893646e-01f, -1.62185326e-01f, 6.48701563e-02f,
  4.06870134e-02f, -8.79570320e-02f, 1.95322167e-02f, 9.57787111e-02f, 3.58357327e-03f, 1.11941360e-01f, -6.95385784e-02f, -1.16605259e-01f, 7.61549771e-02f, 1.63505003e-02f,
  -1.20774396e-01f, 6.40534237e-02f, -1.06631063e-01f, 2.50900537e-01f, 9.75312814e-02f, 7.99326412e-03f, -1.18760765e-01f, -1.60106823e-01f, 2.91587263e-02f, -9.34456661e-02f,
  5.10776117e-02f, -1.97064564e-01f, 1.13303229e-01f, -3.38762701e-02f, 1.23714760e-01f, -1.57639161e-01f, -1.35535255e-01f, 5.17215952e-02f, 1.28260434e-01f, 6.80477321e-02f,
  -4.88889851e-02f, -7.87880123e-02f, 3.11247911e-02f, -7.90322274e-02f, -2.38616373e-02f, 1.65047064e-01f, -1.86396092e-01f, -1.13776863e-01f, -1.02963604e-01f, -1.36997938e-01f,
  2.33625442e-01f, 2.00169563e-01f, 3.80936861e-02f, 8.18278715e-02f, 1.91250294e-01f, -1.37036398e-01f, -1.09754972e-01f, -1.70556605e-01f, -7.84998666e-03f, -1.83363959e-01f,
  9.61862355e-02f, 4.15082484e-01f, -1.25945464e-01f, 6.83104247e-02f, 2.92387381e-02f, -7.78693780e-02f, -1.80820778e-01f, 1.94069259e-02f, 5.54894246e-02f, 9.36171263e-02f,
  -4.25763726e-02f, 1.80258989e-01f, 1.53942689e-01f, 8.00466463e-02f, 2.62378454e-01f, -3.72870862e-01f, 6.07444420e-02f, 1.55354366e-01f, 1.08867019e-01f, -1.91201717e-02f,
  5.81321754e-02f, 6.36314834e-03f, -7.88202137e-02f, 1.61850095e-01f, -1.30823299e-01f, 3.15704420e-02f, -1.62057996e-01f, 3.59599769e-01f, -4.59536426e-02f, 2.07175791e-01f,
  -5.16767725e-02f, 9.89432111e-02f, 2.67032653e-01f, -4.91204821e-02f, -3.20943408e-02f, 9.17760096e-03f, 7.00648725e-02f, -1.64172605e-01f, 1.46038562e-01f, 1.91768989e-01f,
  1.44245028e-01f, 5.30615523e-02f, -2.38745391e-01f, 1.16978772e-01f, 6.42026262e-03f, 2.15294864e-02f, -5.46567999e-02f, 2.70036440e-02f, 1.14306882e-01f, 1.33824497e-01f,
  2.91071516e-02f, -3.55903991e-02f, 8.09859410e-02f, 1.14019416e-01f, 2.01071173e-01f, -1.39062330e-01f, -1.03788383e-01f, 3.39336805e-02f, -2.78272983e-02f, -9.06080380e-02f,
  5.79143725e-02f, 1.41594842e-01f, 1.84771910e-01f, 1.58496443e-02f, -1.38229519e-01f, -1.52453706e-01f, -6.36806861e-02f, -1.96326319e-02f, -1.50344163e-01f, 2.69146059e-02f,
  5.85558042e-02f, 1.64462417e-01f, -1.68145031e-01f, -1.21492237e-01f, -2.22102314e-01f, 1.49369473e-02f, -4.25855555e-02f, 1.31688908e-01f, -1.27942264e-02f, -2.03749895e-01f,
  4.45618108e-03f, -1.50215551e-01f, 2.79913038e-01f, -5.93334436e-02f, -6.61749840e-02f, -5.03880084e-02f, 2.87039503e-02f, 7.59252831e-02f, -1.58020660e-01f, -4.69950810e-02f,
  1.46746397e-01f, 1.14865102e-01f, -1.40195370e-01f, 1.32255062e-01f, 1.37456372e-01f, -5.16210385e-02f, 2.81744972e-02f, -1.70566440e-01f, -2.37626806e-02f, -8.42661539e-04f,
  1.54753923e-02f, 1.10568264e-02f, 1.93917781e-01f, 4.18609232e-02f, -1.45914324e-04f, 1.16267666e-01f, 8.11795816e-02f, -2.47280285e-01f, 8.35784972e-02f, 6.58774190e-03f,
  -2.17556693e-02f, -1.31005690e-01f, -1.88702583e-01f, -1.12697601e-01f, 2.30437830e-01f, -9.10469145e-02f, -8.05032104e-02f, -7.52308592e-02f, 1.16792418e-01f, -7.54154399e-02f,
  -1.37857810e-01f, 1.68959975e-01f, -8.22845101e-02f, 1.11344486e-01f, 4.71881218e-02f, -1.50062695e-01f, -1.78423688e-01f, 1.96148664e-01f, 1.23394327e-02f, 2.90630668e-01f,
  6.63176104e-02f, -4.70592603e-02f, 1.88252211e-01f, -1.77072302e-01f, -1.82026196e-02f, -9.25761685e-02f, -3.25928181e-02f, 2.18311429e-01f, 4.42618206e-02f, -1.43925278e-02f,
  -2.03950377e-03f, 1.09047540e-01f, -1.42603800e-01f, 1.17126197e-01f, -5.67712076e-02f, -5.76286018e-02f, -1.63237423e-01f, -4.02829237e-02f, 1.35278702e-01f, -9.89720877e-03f,
  1.50944427e-01f, 3.78891602e-02f, 7.88099766e-02f, 2.05833614e-01f, -5.42728119e-02f, -1.61287919e-01f, 2.19687317e-02f, -7.01563433e-02f, -1.01513967e-01f, -1.12911299e-01f,
  7.07515404e-02f, -1.19395636e-01f, 4.15015370e-02f, -3.51622328e-02f, 1.73622090e-02f, 9.53955799e-02f, -6.94526061e-02f, -4.24361415e-02f, -3.77004556e-02f, -3.05110426e-03f,
  -7.02915639e-02f, 3.68880406e-02f, -1.26860524e-02f, -1.45332217e-01f, 6.21004961e-02f, -8.81895423e-02f, -2.12499294e-02f, -3.42494920e-02f, -9.88874808e-02f, 1.08593285e-01f,
  -5.27442992e-02f, -1.00244686e-01f, 1.02444544e-01f, -1.75109506e-01f, -7.66050071e-02f, 4.54451935e-03f, 1.22616932e-01f, 9.77640748e-02f, -1.02312341e-01f, -7.63784572e-02f,
  -4.31687199e-03f, -1.12386957e-01f, 3.70588973e-02f, -1.11038707e-01f, 9.59647298e-02f, -2.69443005e-01f, -1.33321241e-01f, -9.94759351e-02f, -1.00016393e-01f, -4.23008110e-03f,
  -1.05092481e-01f, -4.91952002e-02f, -9.20253992e-02f, -3.42403382e-01f, 1.94175809e-03f, -2.31482327e-01f, -1.10793486e-01f, 1.18708119e-01f, 8.26590732e-02f, -1.14580661e-01f,
  -3.80627811e-02f, 6.64043427e-02f, -1.08139567e-01f, 3.60755040e-03f, -1.96655840e-02f, -1.68924138e-01f, -1.46420952e-02f, 3.76690775e-02f, -1.35563821e-01f, 3.65207046e-01f,
  -8.10034797e-02f, 6.34041727e-02f, -1.43779954e-03f, -1.76078007e-01f, -9.62868109e-02f, -1.17920324e-01f, 1.43250227e-01f, 1.01993084e-02f, 1.58436134e-01f, 6.69207126e-02f,
  1.23603567e-01f, -3.95157896e-02f, -8.22356343e-02f, 9.23175663e-02f, 1.58489615e-01f, -5.99397309e-02f, -1.19943485e-01f, -1.46340309e-02f, 5.24061285e-02f, 7.73839951e-02f,
  -1.58729628e-01f, -6.35439605e-02f, 1.80752024e-01f, -1.14044897e-01f, -1.17245212e-01f, -1.31789250e-02f, 2.87759583e-02f, -5.15704639e-02f, -5.13236709e-02f, -6.96638376e-02f,
  1.39655331e-02f, 1.75652012e-01f, 1.08960003e-01f, -1.71898827e-02f, -1.93495959e-01f, 5.43546341e-02f, -1.14788361e-01f, 2.23190844e-01f, -2.11977679e-02f, 1.66770145e-01f,
  -2.98879966e-02f, -1.39721528e-01f, -1.14665620e-01f, 9.17150900e-02f, 1.12730160e-01f, 4.27736156e-02f, -2.46856473e-02f, -7.44583905e-02f, 4.99844849e-02f, -1.24505041e-02f,
  -3.37200701e-01f, -1.04171216e-01f, 5.90403713e-02f, -2.88125183e-02f, 8.69724751e-02f, 1.73153579e-01f, -1.03342477e-02f, -3.26876163e-01f, -1.09475777e-01f, 1.11735374e-01f,
  -1.06238760e-01f, 1.02419779e-01f, 1.59124300e-01f, 1.03365950e-01f, -6.83633015e-02f, 2.19073743e-01f, 2.15556175e-01f, -2.53923178e-01f, 1.43104225e-01f, -5.42247705e-02f,
  8.01146105e-02f, 1.30093664e-01f, -7.72228092e-02f, 8.02482367e-02f, 1.99647784e-01f, 6.18849397e-02f, -6.06739111e-02f, 1.74844354e-01f, -3.93031836e-02f, -4.04591747e-02f,
  -1.62001744e-01f, -6.82665929e-02f, -1.46392388e-02f, -2.34974250e-01f, -2.31650174e-01f, 1.62519932e-01f, 5.54974601e-02f, -3.05795167e-02f, -6.82806447e-02f, -1.02337457e-01f,
  5.41450791e-02f, -2.83358306e-01f, 9.65012833e-02f, 1.66057885e-01f, 1.34685263e-01f, 1.46182448e-01f, -1.79001480e-01f, -2.71092802e-01f, -1.09257445e-01f, 8.72124955e-02f,
  -4.16633561e-02f, 2.24656209e-01f, 6.56226575e-02f, -2.35386655e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  3.09563100e-01f, 1.47708520e-01f, 1.37723520e-01f, 2.00366735e-01f, -6.99966997e-02f, 2.28425071e-01f, 3.84589702e-01f, -5.18250205e-02f, -2.07597688e-01f, -2.25768425e-02f,
  -8.35229643e-03f, 5.75793311e-02f, -1.75778329e-01f, 1.10704131e-01f, -7.43122399e-02f, -1.39643073e-01f, 1.31288141e-01f, -2.28598267e-01f, 2.68393338e-01f, -3.78156714e-02f,
  2.48510927e-01f, 2.36974791e-01f, 1.74722135e-01f, -3.51715744e-01f, 7.93338791e-02f, -7.34398291e-02f, 3.81426327e-02f, -1.72088459e-01f, 2.41972189e-02f, 9.21430159e-03f,
  -6.94334209e-02f, 1.25612751e-01f, 2.12877691e-01f, 3.71063799e-02f, 3.71284224e-02f, 5.20904665e-04f, -4.47168611e-02f, 5.96127920e-02f, 1.67393908e-01f, -7.10756937e-03f,
  1.17625579e-01f, -1.63694814e-01f, 3.29465233e-02f, -2.06489936e-01f, -9.42939967e-02f, -8.38789195e-02f, -1.08038299e-01f, -7.21157119e-02f, -2.26898149e-01f, -3.24371368e-01f,
  2.37994522e-01f, 5.63532002e-02f, -2.84331441e-01f, 2.40244865e-01f, 1.48793563e-01f, 1.83315143e-01f, -7.63247628e-03f, -4.69824374e-02f, 7.70267695e-02f, -2.99279004e-01f,
  5.64329699e-02f, 3.26413400e-02f, -2.71486081e-02f, -2.49243844e-02f, 3.17558013e-02f, 6.47888184e-02f, 2.68385798e-01f, 6.09072782e-02f, -1.17354114e-02f, 2.36858532e-01f,
  -1.09897189e-01f, -8.34978297e-02f, -1.18487589e-01f, -1.99020341e-01f, -1.33694023e-01f, -1.35035649e-01f, -5.50768748e-02f, 9.52867419e-02f, -3.42154562e-01f, -3.13891051e-03f,
  6.09955797e-03f, -3.19668613e-02f, 7.14041516e-02f, -1.07633404e-01f, 3.67464982e-02f, 1.02250196e-01f, 1.61779895e-01f, -2.38032907e-01f, 3.69032770e-02f, -1.23842523e-01f,
  7.93013647e-02f, -8.56139138e-02f, -9.55155343e-02f, -5.91470115e-02f, 5.15762903e-02f, 7.69270435e-02f, -2.16388896e-01f, 1.16281994e-01f, -1.05156181e-02f, -8.03819671e-02f,
  1.36863470e-01f, 1.19142748e-01f, -1.75805718e-01f, -1.20789051e-01f, -7.81922936e-02f, -3.62215154e-02f, 1.05362356e-01f, -3.17963399e-02f, 3.49241644e-02f, -2.19421834e-01f,
  -2.17767939e-01f, -1.69006735e-02f, 8.81129131e-02f, -9.85894427e-02f, 8.09270144e-02f, -1.84554487e-01f, -1.09666049e-01f, -2.86264755e-02f, 9.38712433e-02f, 1.45747915e-01f,
  9.59675238e-02f, 2.86034364e-02f, -2.46616043e-02f, 4.16212603e-02f, -3.16046886e-02f, -3.48284721e-01f, 1.68885529e-01f, -5.44151366e-02f, -6.33034110e-02f, -3.35694924e-02f,
  1.04217328e-01f, 7.80769885e-02f, 1.05726779e-01f, 6.73037916e-02f, -4.98722047e-02f, 1.02936536e-01f, 2.36415979e-03f, -1.18558966e-01f, -1.15509510e-01f, -2.70935781e-02f,
  -9.14227217e-02f, -2.00712681e-02f, -4.35825497e-01f, -2.04404872e-02f, -4.84635383e-02f, 1.89934939e-01f, -5.61073534e-02f, 3.14773023e-02f, 6.60131127e-02f, 2.00987563e-01f,
  -8.98753703e-02f, -2.55372915e-02f, -8.12624767e-02f, -2.12532520e-01f, -2.34819323e-01f, 8.64990130e-02f, 1.05546787e-01f, 4.26738448e-02f, 8.46246183e-02f, -6.83645904e-02f,
  1.39224172e-01f, -6.97147381e-03f, -1.78230241e-01f, 4.20756899e-02f, -7.20322505e-02f, -6.10897923e-03f, 4.86632399e-02f, 1.47200108e-01f, -6.33003786e-02f, 7.53644481e-02f,
  9.17780772e-02f, 3.35453838e-01f, 2.22414404e-01f, -1.65598348e-01f, 8.90813917e-02f, 2.68870387e-02f, 7.92827457e-02f, 1.46598116e-01f, -8.72425064e-02f, 1.76153362e-01f,
  -2.33228236e-01f, 2.43040118e-02f, -1.91393122e-01f, 1.49718270e-01f, 2.27860913e-01f, 1.56321183e-01f, 1.56902120e-01f, 8.62513855e-02f, -2.21673269e-02f, -4.64275107e-02f,
  9.81212556e-02f, 6.03739321e-02f, 1.66074440e-01f, 1.65698811e-01f, 1.57178864e-01f, 1.95207715e-01f, 1.32391885e-01f, 1.34022295e-01f, 1.07945405e-01f, -3.87653947e-01f,
  -2.30173603e-01f, 4.52680103e-02f, -1.85470745e-01f, 8.47722068e-02f, -2.08350108e-03f, -4.66012619e-02f, 3.80640179e-02f, -8.38525593e-02f, 2.47239824e-02f, -2.93881506e-01f,
  3.53565931e-01f, 1.37347773e-01f, -6.78786784e-02f, 1.70199648e-01f, 1.51619181e-01f, -1.05398022e-01f, 8.53900015e-02f, 8.09574127e-02f, 2.62031138e-01f, -2.20704153e-01f,
  1.99099183e-01f, 8.94004926e-02f, 1.49204433e-01f, 5.30137867e-02f, 2.41538823e-01f, 2.56990194e-01f, 1.84631854e-01f, 1.66503519e-01f, 4.93332595e-02f, 1.78526014e-01f,
  2.02254429e-01f, 3.64697091e-02f, -1.08307622e-01f, -9.47936065e-03f, 1.55179396e-01f, -2.61438042e-01f, -2.34341785e-01f, 1.21032685e-01f, 1.03424981e-01f, -8.08009356e-02f,
  -6.92777336e-02f, -1.79307550e-01f, 4.04834390e-01f, -1.43408507e-01f, -1.41433552e-01f, 2.29610607e-01f, 1.48064524e-01f, 1.34945974e-01f, 1.53816165e-02f, -2.08581313e-01f,
  -1.51434541e-01f, -4.04795259e-02f, 7.40342662e-02f, -1.12911001e-01f, 1.45882085e-01f, -1.93463460e-01f, -1.05276546e-02f, 8.54598209e-02f, -5.40404506e-02f, 1.67405739e-01f,
  4.84905094e-02f, -7.67330080e-02f, -1.15567930e-01f, -6.61752224e-02f, 5.35972081e-02f, 1.79200292e-01f, -1.05674006e-01f, -1.44067556e-01f, 1.12517759e-01f, 3.95457074e-02f,
  -7.99175873e-02f, 1.02615602e-01f, -4.39031869e-01f, -2.41496954e-02f, 1.89001009e-01f, -2.06319258e-01f, -7.64807966e-03f, -8.86197537e-02f, -9.19986051e-03f, 3.29658866e-01f,
  1.69090703e-02f, -1.91548336e-02f, 3.08729755e-03f, 1.06678240e-01f, -1.18408680e-01f, -2.81405374e-02f, 2.66939461e-01f, -3.44069414e-02f, 1.48761436e-01f, 9.86012071e-02f,
  2.20508710e-01f, 1.42337039e-01f, -8.00324231e-02f, 2.26612002e-01f, 9.18943137e-02f, 1.75257295e-01f, -2.66372889e-01f, 1.09664738e-01f, 3.12653750e-01f, -3.60198170e-02f,
  -2.69099206e-01f, -8.48819762e-02f, 2.65189588e-01f, -1.30126610e-01f, 5.39013408e-02f, -7.43719041e-02f, 5.26577383e-02f, -2.30630487e-01f, 4.81584370e-02f, 4.64616269e-02f,
  4.52633761e-02f, 2.29388028e-01f, 1.84116229e-01f, 1.12019330e-01f, -2.50843167e-01f, 5.92530444e-02f, -1.95845336e-01f, -5.50034456e-02f, 4.07724380e-02f, 9.61450860e-02f,
  5.72919399e-02f, 2.83033997e-02f, -1.63828209e-01f, 1.28777489e-01f, 2.72767484e-01f, -6.01949468e-02f, -2.23697841e-01f, -4.66158576e-02f, 1.39365718e-01f, 1.13587491e-01f,
  -2.86388453e-02f, 1.30209997e-01f, 3.17340821e-01f, 5.58544174e-02f, -2.22216472e-02f, 2.30951577e-01f, -1.93277001e-01f, -9.55839455e-02f, 8.71950090e-02f, -5.25740683e-02f,
  1.53558910e-01f, -1.47893280e-01f, 2.64405236e-02f, 4.71917868e-01f, -8.58167559e-02f, 2.26595595e-01f, -7.14635849e-02f, 4.26548580e-03f, -2.25227118e-01f, 1.65991515e-01f,
  1.13171563e-01f, 4.33792435e-02f, -3.46744992e-02f, 1.00977540e-01f, 1.69498399e-01f, -6.93718866e-02f, -5.84526844e-02f, 4.08608653e-03f, 1.21736996e-01f, 1.33208305e-01f,
  6.51741475e-02f, 2.52713729e-02f, 2.71580935e-01f, 9.01473910e-02f, -1.52536273e-01f, -5.31269461e-02f, 9.33083799e-03f, -1.34854242e-01f, 1.85243845e-01f, -1.00966692e-01f,
  -2.13855222e-01f, 3.30133252e-02f, 3.27970356e-01f, -5.82521893e-02f, -9.99985561e-02f, 1.53308257e-01f, 6.68567885e-03f, 6.75306767e-02f, 9.38383490e-02f, 1.21672764e-01f,
  -1.71467122e-02f, 2.20108807e-01f, -3.86271998e-02f, 3.21226388e-01f, -8.04622620e-02f, 1.17927222e-02f, -8.58524665e-02f, -1.61710367e-01f, -1.96682379e-01f, -1.32748455e-01f,
  -1.30821243e-02f, -1.65827826e-01f, -2.13215604e-01f, -3.09460253e-01f, -1.11551166e-01f, 1.54473513e-01f, -2.26471812e-01f, -5.30606210e-02f, -2.65977114e-01f, -1.25645928e-03f,
  -1.57801993e-02f, 1.56406686e-01f, 3.47861260e-01f, 3.68896574e-02f, -9.54663604e-02f, 2.78056860e-01f, -1.44339114e-01f, -4.66893837e-02f, 1.56026468e-01f, -1.81921363e-01f,
  -7.76310489e-02f, 1.82971835e-01f, 7.07948059e-02f, 1.15687892e-01f, 2.22733125e-01f, -1.29721919e-02f, 5.42464294e-02f, 2.65321806e-02f, -2.00479954e-01f, 1.74550086e-01f,
  9.66915563e-02f, 6.22394010e-02f, 1.71874806e-01f, 1.23372875e-01f, -3.79230827e-02f, -1.50685115e-02f, -6.04210608e-02f, 9.14294645e-02f, 2.05657989e-01f, 1.35045782e-01f,
  9.81735289e-02f, 2.54276603e-01f, 3.79181877e-02f, 1.18343972e-01f, 1.86738804e-01f, 2.25921318e-01f, -1.81349590e-01f, 9.54040885e-03f, 1.94465160e-01f, 1.37760028e-01f,
  2.51797795e-01f, -4.82639223e-02f, -7.88911358e-02f, -5.42162033e-03f, 1.39144957e-01f, -2.71054983e-01f, 1.87688041e-02f, -1.86794754e-02f, 1.23465113e-01f, 4.01029773e-02f,
  -4.78354320e-02f, 1.75807834e-01f, -4.56613377e-02f, -2.10866705e-02f, -5.93433194e-02f, -2.38086656e-02f, -1.34025827e-01f, 1.61965057e-01f, 1.11826725e-01f, 6.71799406e-02f,
  2.37659007e-01f, 8.07335451e-02f, 3.19580525e-01f, -5.82175963e-02f, 3.45927961e-02f, -1.08018108e-01f, -5.20352367e-03f, 4.07145731e-02f, 7.25371167e-02f, 3.86474431e-02f,
  1.43754885e-01f, 2.66450614e-01f, 7.43818134e-02f, 1.31922984e-03f, 1.93640500e-01f, -2.17768952e-01f, 2.31894255e-01f, 8.76414869e-03f, -2.48361960e-01f, 1.59860283e-01f,
  2.81031042e-01f, 7.05747679e-02f, 1.68100685e-01f, 1.33754224e-01f, -9.68061388e-02f, 2.02435672e-01f, -8.60713571e-02f, -1.80792361e-01f, 3.47781181e-02f, 3.79206948e-02f,
  -4.73343469e-02f, -4.07455027e-01f, 5.16761001e-03f, 2.46071666e-01f, 2.43345752e-01f, 1.52006283e-01f, -5.18288575e-02f, 8.06303844e-02f, 1.65524989e-01f, -1.12670802e-01f,
  1.01234123e-01f, 1.61789596e-01f, 1.16302490e-01f, 1.31474510e-01f, -3.01630914e-01f, -3.24163914e-01f, -1.16295107e-01f, 3.40496190e-02f, 1.11162961e-01f, 1.47180259e-01f,
  1.61957815e-02f, -2.43551895e-01f, 1.21297643e-01f, 2.26353765e-01f, 1.29120156e-01f, -3.13147157e-02f, -1.14812016e-01f, 1.90055639e-01f, 2.50033170e-01f, -2.11534083e-01f,
  -5.48685603e-02f, -3.47037464e-02f, -1.61360353e-01f, 9.38370079e-02f, 1.02410771e-01f, 4.21370715e-02f, -1.02150545e-01f, -1.44422799e-01f, 1.09554529e-01f, -3.45647156e-01f,
  1.14299268e-01f, 8.87075588e-02f, 4.96695563e-02f, 1.82059810e-01f, 1.42093435e-01f, -8.12853724e-02f, 6.91602528e-02f, -2.09143177e-01f, -3.64579767e-01f, 4.14911173e-02f,
  9.16472301e-02f, -1.89641297e-01f, -6.46448806e-02f, 5.90451434e-02f, -1.16636485e-01f, -5.47885075e-02f, -1.24612443e-01f, 3.18490118e-02f, 2.88901627e-02f, -1.89760491e-01f,
  1.33355364e-01f, 7.92043880e-02f, 1.73889235e-01f, -1.77843615e-01f, 6.19801600e-03f, -1.99922517e-01f, 1.90947339e-01f, -3.37179713e-02f, 3.07170656e-02f, -3.69172223e-04f,
  -1.87099934e-01f, -8.35010409e-02f, -2.35809069e-02f, -4.58203107e-02f, 5.65135479e-03f, -3.60246561e-02f, 1.96886733e-01f, 1.43810853e-01f, -2.99094361e-04f, -2.65497155e-02f,
  7.89144915e-03f, -1.74808845e-01f, 3.53101362e-03f, 6.19337969e-02f, 9.37817618e-02f, -6.29532188e-02f, 2.95921773e-01f, 7.65314884e-03f, 2.76330352e-01f, 6.51473030e-02f,
  -4.28423332e-03f, 3.58226061e-01f, 1.32379889e-01f, -2.11097777e-01f, -8.95444676e-02f, -2.83883572e-01f, -1.99985445e-01f, 1.84874296e-01f, -1.32437393e-01f, 1.43809142e-02f,
  -1.74579605e-01f, -2.13424824e-02f, 1.71310768e-01f, 3.13954763e-02f, 1.74575895e-01f, 1.37088627e-01f, 9.79812443e-02f, 1.95017770e-01f, 1.59187093e-01f, -3.32632631e-01f,
  1.17699884e-01f, -1.05939753e-01f, -3.02269962e-02f, 3.74394059e-02f, 1.61024734e-01f, -2.64339950e-02f, 1.66126013e-01f, 1.26046479e-01f, -9.88724977e-02f, 1.00016922e-01f,
  -1.18356813e-02f, -3.29742767e-02f, 3.68394679e-03f, 4.48566563e-02f, 1.12057567e-01f, 6.01962442e-03f, 3.09247505e-02f, -5.79526473e-04f, -7.51250014e-02f, -9.25203189e-02f,
  2.64639199e-01f, -2.03428954e-01f, -5.58590852e-02f, 1.65955834e-02f, 1.23004682e-01f, -6.96905553e-02f, 1.20850332e-01f, 3.07842507e-03f, -1.99447080e-01f, 4.79465462e-02f,
  1.33458614e-01f, 2.12357700e-01f, -2.80928537e-02f, -8.04746896e-02f, 4.07295637e-02f, 3.05300225e-02f, 8.20860267e-02f, -2.17720017e-01f, 1.05289571e-01f, -5.81809022e-02f,
  1.75779641e-01f, 6.24111742e-02f, -8.44634622e-02f, 6.92655817e-02f, 8.00083485e-03f, 8.15370306e-02f, -3.17073166e-02f, 3.29178721e-01f, -5.45006851e-03f, 2.56794602e-01f,
  -8.20627157e-03f, -2.80967578e-02f, 1.79108426e-01f, 2.14588821e-01f, 2.18661830e-01f, 4.84123155e-02f, 6.66548535e-02f, -4.84571129e-01f, 4.75740805e-02f, 1.50859430e-01f,
  7.91888386e-02f, -9.31847899e-04f, -1.96711496e-02f, -1.22420177e-01f, 1.07319586e-01f, 2.03297120e-02f, -8.75298604e-02f, -2.20138490e-01f, 2.02231735e-01f, -3.32762152e-02f,
  -3.34993243e-01f, 6.28168955e-02f, 1.93361953e-01f, 6.84269220e-02f, 2.70427894e-02f, 9.48520228e-02f, -1.04399338e-01f, 1.85988434e-02f, 8.34538862e-02f, 1.50936559e-01f,
  -3.96373905e-02f, -6.40685633e-02f, -1.75047547e-01f, -1.92056701e-01f, -2.38558240e-02f, 3.48174393e-01f, -1.01305738e-01f, 3.42154168e-02f, -2.44985268e-01f, -2.14129150e-01f,
  3.03794503e-01f, 1.11129247e-01f, 9.73804519e-02f, 3.91218513e-02f, 2.55722217e-02f, -5.09078614e-03f, -1.17238626e-01f, -1.73275456e-01f, 2.06438601e-01f, -3.67257386e-01f,
  -1.02237230e-02f, 3.41553509e-01f, 1.80763714e-02f, -2.95033604e-02f, 5.61497547e-02f, 3.47603887e-01f, 7.21638277e-02f, 4.32106704e-02f, -9.88991708e-02f, 1.05691232e-01f,
  2.69784868e-01f, -1.66605875e-01f, -1.23431079e-01f, -1.86326221e-01f, -2.70833708e-02f, 6.10922426e-02f, -1.15156639e-02f, 9.04671699e-02f, -1.86763361e-01f, -1.97106704e-01f,
  3.95986959e-02f, -4.18740153e-01f, 2.19168052e-01f, 9.43775550e-02f, 1.86716750e-01f, 1.54951692e-01f, 1.50736094e-01f, -1.76254921e-02f, 1.40189633e-01f, -5.56437124e-04f,
  -1.47127643e-01f, -5.30811809e-02f, 8.27959999e-02f, -1.27183676e-01f, 7.34943971e-02f, 2.38110591e-02f, -6.38999864e-02f, -4.54672240e-02f, -1.23103350e-01f, -8.16595852e-02f,
  3.63878012e-02f, -2.74524484e-02f, -2.80071818e-03f, 1.01992346e-01f, 1.00435413e-01f, -1.26546234e-01f, -1.06024057e-01f, -1.32549763e-01f, 1.47502810e-01f, -1.78013161e-01f,
  -4.10044789e-02f, -1.41144514e-01f, -5.85682988e-02f, -1.58492893e-01f, -5.24730831e-02f, -3.12975496e-02f, -1.37176514e-01f, 2.27525495e-02f, 1.23755500e-01f, -1.33462832e-03f,
  1.44461334e-01f, -4.29532193e-02f, 6.56177402e-02f, -6.95846751e-02f, 1.96504563e-01f, -1.92221060e-01f, 1.54527098e-01f, -1.39398323e-02f, -1.74406335e-01f, 9.84789357e-02f,
  -2.37528026e-01f, 8.74147564e-02f, -1.65256821e-02f, -2.56090254e-01f, -1.41685233e-01f, -7.24129602e-02f, 1.08222030e-01f, -1.85000047e-01f, 3.42193712e-03f, -4.71008196e-02f,
  -7.48156160e-02f, 7.70218074e-02f, -5.20358002e-03f, -2.62617171e-02f, -9.60111171e-02f, 4.97171134e-02f, 1.66711390e-01f, -1.92122072e-01f, -1.03790455e-01f, -1.20985359e-01f,
  -6.10256568e-02f, 1.26357362e-01f, -9.49576795e-02f, -9.39718559e-02f, -1.70077428e-01f, -3.94254029e-02f, -1.57916874e-01f, -2.18983237e-02f, 3.56000699e-02f, -1.13749422e-01f,
  -3.55025828e-02f, 3.34822237e-02f, -6.02429779e-03f, 1.21467270e-01f, 2.23369449e-02f, -3.03933490e-02f, 2.15087414e-01f, -2.78484765e-02f, -1.88032001e-01f, -5.81793338e-02f,
  6.58012554e-02f, 2.30048820e-01f, -2.31823754e-02f, -9.56682935e-02f, 2.15101331e-01f, 8.01707283e-02f, 3.89936045e-02f, -5.74948192e-02f, 1.50278836e-01f, 2.07662255e-01f,
  -1.27293631e-01f, -1.66993767e-01f, 1.53177034e-03f, -1.83558296e-02f, 1.98325321e-01f, 1.55789778e-01f, -1.65709257e-02f, 1.43800914e-01f, -2.15820894e-02f, 4.87883501e-02f,
  6.91733211e-02f, 1.30552888e-01f, 3.86467390e-02f, -1.82229541e-02f, 1.23001657e-01f, 2.47399509e-02f, 3.43797728e-02f, -1.09466324e-02f, -8.62569362e-02f, -1.23055704e-01f,
  -5.14560752e-02f, -2.49398515e-01f, -1.33860558e-01f, 5.08667119e-02f, -8.41839761e-02f, 8.90664980e-02f, -1.17496587e-01f, -2.23621423e-03f, 4.30913828e-02f, 2.37032492e-02f,
  3.13900895e-02f, -5.86732775e-02f, -1.18396066e-01f, 7.14788437e-02f, 2.64159516e-02f, -1.58957705e-01f, -9.36280638e-02f, 7.11945742e-02f, -3.66243720e-03f, 2.64658093e-01f,
  -1.87974870e-01f, 8.27607065e-02f, 2.50715703e-01f, 2.15312630e-01f, 4.71904650e-02f, -1.27131134e-01f, -1.41973495e-01f, 7.49084651e-02f, 1.86779335e-01f, 6.14905031e-03f,
  -4.53596329e-03f, 1.33304998e-01f, -1.38342559e-01f, -1.54724345e-02f, 1.62255093e-01f, -2.99586449e-02f, 2.47411028e-01f, -1.80246741e-01f, 9.24873054e-02f, -8.21075886e-02f,
  5.17932288e-02f, 1.19269773e-01f, 6.87353760e-02f, 5.57370558e-02f, -2.14770436e-01f, 1.36286272e-02f, -6.47636801e-02f, 1.22226223e-01f, 2.24689201e-01f, 2.26620033e-01f,
  1.02378465e-01f, -4.48193178e-02f, -6.31901100e-02f, -2.36174256e-01f, 1.55909792e-01f, 2.14918524e-01f, 1.98781013e-01f, -1.80390045e-01f, 3.12964231e-01f, -3.56148556e-02f,
  7.06668273e-02f, 1.51203141e-01f, -2.19667763e-01f, 1.24586388e-01f, -3.48533355e-02f, -1.35884201e-03f, 1.12463860e-02f, -1.03477135e-01f, 4.00414802e-02f, -1.60768069e-02f,
  2.18557958e-02f, 5.38651273e-02f, 2.21222132e-01f, -8.31234455e-02f, -1.16372839e-01f, 3.04727685e-02f, 2.16884926e-01f, 1.06377520e-01f, 8.74991268e-02f, -1.08135797e-01f,
  -1.14969045e-01f, 1.72874212e-01f, 1.10110037e-01f, 1.58797204e-01f, -1.64884672e-01f, -5.63329197e-02f, 1.52693894e-02f, 1.58994541e-01f, -1.04054503e-01f, 4.54355590e-02f,
  1.77954108e-01f, -3.86338681e-02f, -4.97093461e-02f, 1.27572343e-01f, 5.84465824e-03f, -1.43871769e-01f, 7.02106254e-03f, -8.91725495e-02f, 2.02417165e-01f, -3.44630070e-02f,
  -1.25659525e-01f, 3.88547294e-02f, -1.07412510e-01f, -2.14056671e-01f, 8.30203444e-02f, 2.45636702e-02f, -9.58457440e-02f, 1.41148819e-02f, 1.59200840e-02f, 2.17194799e-02f,
  -6.04187213e-02f, -3.01160086e-02f, 9.29088891e-02f, -3.74326408e-02f, 7.93475136e-02f, 3.67424637e-02f, 4.38612476e-02f, 1.32721951e-02f, 1.65018797e-01f, -9.27072689e-02f,
  2.11956635e-01f, 1.80681497e-01f, -2.86566708e-02f, -2.64290050e-02f, 1.67924896e-01f, 2.68940479e-01f, -2.30757482e-02f, -9.40789655e-02f, 1.12284809e-01f, 1.42338917e-01f,
  1.09595463e-01f, -8.16030428e-02f, 2.02065662e-01f, 1.63094461e-01f, 2.10558832e-01f, 1.06205173e-01f, 1.13049731e-01f, 1.13391228e-01f, 1.11148082e-01f, 8.13324526e-02f,
  -1.34212554e-01f, 1.22465499e-01f, -6.81859180e-02f, 4.76712912e-01f, 1.57193154e-01f, -2.72761304e-02f, -1.78423584e-01f, -1.25200316e-01f, 2.39476129e-01f, 1.24645457e-01f,
  -2.68226024e-02f, -1.57794192e-01f, 3.72508690e-02f, -3.90368365e-02f, 7.00390637e-02f, 9.54289287e-02f, 3.35003529e-03f, -1.89807098e-02f, -2.80318819e-02f, 2.80809011e-02f,
  -7.47284740e-02f, 9.41770803e-03f, -1.17530860e-01f, -6.63871765e-02f, 1.36756331e-01f, 6.33504242e-02f, 1.02697693e-01f, 1.85556635e-01f, -1.28771737e-01f, 1.92601979e-01f,
  -6.31854460e-02f, -4.16294746e-02f, 1.73019439e-01f, 7.87473470e-02f, 1.29970744e-01f, 1.77870855e-01f, -1.23961717e-01f, -2.88194388e-01f, -1.31915212e-01f, 5.32074384e-02f,
  -1.40931576e-01f, -3.11689060e-02f, -1.67477369e-01f, -3.99168022e-02f, 2.50108480e-01f, -2.55932771e-02f, 3.11195761e-01f, -1.59262657e-01f, 1.16079874e-01f, 9.27474946e-02f,
  3.23275588e-02f, -1.08879544e-02f, -1.15924001e-01f, 1.35615207e-02f, -2.65666371e-04f, 5.70947193e-02f, -1.97354048e-01f, -1.03594214e-02f, -1.13252051e-01f, -1.59308203e-02f,
  2.17067059e-02f, -4.49246839e-02f, 6.41805306e-02f, 1.09163411e-01f, -6.29009083e-02f, 1.66956559e-01f, -8.62621982e-03f, -1.93169013e-01f, 3.73866856e-02f, -1.49096623e-01f,
  1.28867909e-01f, 2.60058790e-01f, 1.82503551e-01f, 1.49345044e-02f, -1.27232522e-01f, 2.26845458e-01f, 7.63287395e-03f, -4.26792279e-02f, 4.41243574e-02f, 1.07906111e-01f,
  1.23456873e-01f, -9.78844911e-02f, -1.65362716e-01f, 1.66447461e-01f, 1.03374623e-01f, 1.15177572e-01f, 1.08957969e-01f, 1.14231169e-01f, 3.05124402e-01f, -7.13095963e-02f,
  -1.80536970e-01f, 2.15365052e-01f, -8.19285400e-03f, 2.18293712e-01f, 1.00700751e-01f, 1.51194662e-01f, 2.43430547e-02f, 9.41798836e-02f, -1.10569209e-01f, 1.34285718e-01f,
  6.67136014e-02f, 1.61237419e-01f, 1.97952971e-01f, -8.08307156e-02f, -5.55833941e-03f, -2.46134177e-01f, -3.53785641e-02f, -2.71823913e-01f, 1.69894591e-01f, 1.39842793e-01f,
  -1.47700533e-01f, -7.68071339e-02f, 2.37157181e-01f, 5.69591485e-02f, -2.31113672e-01f, -8.52494538e-02f, 1.94043413e-01f, 7.01648742e-02f, 1.30958185e-01f, -1.80948436e-01f,
  2.15729669e-01f, 1.68362558e-01f, -1.52974814e-01f, -2.36225557e-02f, -8.83255750e-02f, 5.92159480e-02f, 2.12721065e-01f, 1.66744485e-01f, -1.39064953e-01f, 3.27935703e-02f,
  -2.26069152e-01f, 3.39654744e-01f, 1.07187428e-01f, -8.71794522e-02f, -2.63626605e-01f, -1.26123711e-01f, 7.20154122e-02f, 2.47866125e-03f, 2.00497270e-01f, -1.71307355e-01f,
  -7.78475553e-02f, -5.46459071e-02f, -3.14565450e-02f, 1.00818790e-01f, 9.49489996e-02f, -3.91266569e-02f, 2.70662848e-02f, 2.59144872e-01f, -4.95132618e-02f, 7.22668841e-02f,
  5.73280044e-02f, 9.36956704e-02f, 2.21588194e-01f, 7.55057260e-02f, -1.47412019e-02f, 6.23616241e-02f, -7.87565112e-02f, 5.63002564e-02f, -1.68876275e-02f, 2.02246457e-01f,
  8.89795199e-02f, -5.50681241e-02f, -1.86402425e-02f, 1.37466520e-01f, -6.24802001e-02f, 2.36286581e-01f, -3.13481353e-02f, 6.50842953e-03f, 9.11271572e-02f, -5.33471406e-02f,
  4.71799634e-02f, 1.36765420e-01f, 2.66882051e-02f, -3.95871997e-02f, -1.83612928e-01f, 6.29285574e-02f, -1.05943196e-01f, 5.15761338e-02f, -1.76726293e-03f, 7.69867599e-02f,
  -3.68219316e-02f, 1.83376759e-01f, 1.31247699e-01f, 4.18662727e-02f, 4.31363508e-02f, 1.83881611e-01f, 9.92090777e-02f, 1.87141478e-01f, 2.55951881e-02f, -2.75497794e-01f,
  1.26304314e-01f, -2.62661232e-03f, -1.48970023e-01f, -8.40413347e-02f, -3.08826808e-02f, 1.76971167e-01f, 1.70548081e-01f, -4.02869238e-03f, -1.15049846e-01f, -6.43115938e-02f,
  1.50626069e-02f, 4.76118401e-02f, -4.47386242e-02f, -3.22664678e-02f, -8.02901760e-03f, 8.19891989e-02f, 1.06407508e-01f, -1.06463164e-01f, -1.26134589e-01f, 1.12252384e-01f,
  -7.67403767e-02f, 8.34694654e-02f, -1.44398168e-01f, -1.16492845e-01f, 1.82379082e-01f, -2.05031395e-01f, 1.64297253e-01f, 2.77727872e-01f, -2.38243602e-02f, 1.27383739e-01f,
  1.52966855e-02f, -1.26444012e-01f, 1.84784785e-01f, -2.02585533e-02f, 3.51843648e-02f, 4.35196646e-02f, 2.41666511e-01f, 1.99050475e-02f, -1.18217967e-01f, -2.66351074e-01f,
  -6.58805203e-03f, -2.10455433e-02f, 5.56761734e-02f, -1.71539355e-02f, -3.94259356e-02f, 9.90747511e-02f, 1.11763932e-01f, 1.50199622e-01f, 1.48427144e-01f, 1.77342847e-01f,
  1.91145688e-01f, 1.95203394e-01f, 2.70777881e-01f, -1.62640378e-01f, -1.44549385e-01f, -1.43637270e-01f, -2.30550811e-01f, 1.88350856e-01f, 1.99799240e-01f, 1.71424314e-01f,
  -1.01542167e-01f, 3.05651873e-02f, 3.46758403e-03f, -1.86443090e-01f, -2.79772282e-02f, -2.91008409e-02f, 2.22890332e-01f, 8.08471963e-02f, 1.90637171e-01f, -2.20838100e-01f,
  -1.01487532e-01f, -1.01164475e-01f, -8.83909985e-02f, -5.50738797e-02f, -8.41145441e-02f, 1.26651540e-01f, 9.06619355e-02f, 1.11315794e-01f, -1.12929344e-01f, 1.27797738e-01f,
  -1.53106898e-01f, -1.60788983e-01f, -5.44969551e-02f, 5.16591929e-02f, 1.87618151e-01f, -4.59362939e-02f, 7.57077411e-02f, 6.13822490e-02f, 1.67299181e-01f, 1.06930457e-01f,
  -6.36131987e-02f, -1.56138139e-02f, -1.71220347e-01f, -2.08560869e-01f, -7.01007098e-02f, 1.00434003e-02f, -2.06616044e-01f, -1.59712285e-01f, 6.22871071e-02f, 2.93353107e-02f,
  1.84436545e-01f, 1.27050593e-01f, 4.73428257e-02f, 1.69476479e-01f, 9.59338546e-02f, -2.54113469e-02f, 1.65298000e-01f, 2.09370121e-01f, 1.57817110e-01f, -7.37414509e-03f,
  1.17010474e-01f, 2.48291362e-02f, 1.78393647e-02f, 1.56500012e-01f, 1.85608611e-01f, 1.93427369e-01f, -2.43751392e-01f, -7.05596209e-02f, -3.24705690e-02f, -1.33732155e-01f,
  6.69683702e-03f, 3.44259068e-02f, -2.71269623e-02f, -1.71661183e-01f, 1.76062882e-01f, 1.91296563e-02f, -1.60427868e-01f, 8.80430453e-03f, -1.34058520e-01f, 1.23484358e-02f,
  -3.35147567e-02f, -2.16491874e-02f, 2.32194737e-01f, -1.49479255e-01f, -1.42951645e-02f, 9.17104557e-02f, 1.04182787e-01f, -9.66147259e-02f, -2.87798643e-02f, -6.09281026e-02f,
  -4.39988337e-02f, 2.12416381e-01f, -2.23213080e-02f, 7.21269920e-02f, 7.33745992e-02f, 5.93690434e-03f, 1.04232337e-02f, 1.80008024e-01f, 3.53166424e-02f, -2.53419787e-01f,
  5.73388673e-02f, 3.48528773e-02f, 1.42135307e-01f, 5.51948976e-03f, -1.08909316e-01f, -1.15480162e-01f, -9.48433727e-02f, -3.72156352e-02f, 9.65367854e-02f, 2.40076035e-02f,
  2.24726588e-01f, -4.57036234e-02f, -9.17110667e-02f, 1.27100155e-01f, -2.23760456e-02f, 9.50231329e-02f, 2.79437676e-02f, -1.24322981e-01f, 8.38112980e-02f, 1.22167312e-01f,
  -1.13344207e-01f, 8.04515779e-02f, 1.02452636e-01f, 4.75668674e-03f, 5.74966744e-02f, -8.19016099e-02f, 9.64063480e-02f, 1.78931117e-01f, 2.07287684e-01f, 1.57125950e-01f,
  -3.78886789e-01f, -6.73880205e-02f, 1.97894126e-01f, -1.24716938e-01f, 1.25414670e-01f, 2.16333747e-01f, 1.25409499e-01f, -7.58846924e-02f, 1.03289053e-01f, 3.07683498e-02f,
  -1.11661088e-02f, 6.38207942e-02f, -1.36808604e-01f, -1.29450560e-01f, -2.65865656e-05f, 2.15900630e-01f, -1.85557585e-02f, 2.89329421e-02f, 7.11501241e-02f, 5.38998358e-02f,
  1.09466717e-01f, 1.87655374e-01f, -1.08398870e-01f, 1.80556998e-01f, 1.67261034e-01f, -1.52545907e-02f, -7.40205869e-02f, -1.76660612e-01f, -1.01182731e-02f, -1.50301931e-02f,
  1.30475968e-01f, -1.42563462e-01f, -4.99985889e-02f, 2.05840617e-01f, 6.55050874e-02f, 9.52295959e-02f, 1.42025024e-01f, 7.20937997e-02f, 1.17831193e-01f, -1.38712868e-01f,
  -1.85274094e-01f, 3.05571984e-02f, 1.49217531e-01f, 1.28011689e-01f, -2.35673904e-01f, 5.01024649e-02f, 2.65578926e-01f, 1.36925176e-01f, -1.16232634e-01f, 3.58127058e-02f,
  -1.30699962e-01f, 7.63137713e-02f, 6.71418384e-02f, 2.08254233e-01f, -6.36339858e-02f, -2.31697351e-01f, -3.25981863e-02f, -5.08690402e-02f, 1.43116459e-01f, 2.90347070e-01f,
  6.84518963e-02f, 2.61650026e-01f, 9.37981829e-02f, 1.02980375e-01f, 1.88819230e-01f, -5.58214672e-02f, -9.88757685e-02f, -1.47813439e-01f, -5.05892634e-02f, 2.29432672e-01f,
  2.64300674e-01f, 1.40400171e-01f, -5.91896996e-02f, 7.28612170e-02f, 1.25389069e-01f, -3.47482204e-01f, 4.45882864e-02f, -8.40787068e-02f, 2.34766573e-01f, 5.78765832e-02f,
  9.69660208e-02f, -3.66706327e-02f, 1.38011491e-02f, -1.97673976e-01f, -4.05975640e-01f, 5.36306715e-03f, -1.38243183e-01f, -6.63160756e-02f, 4.23893780e-02f, -9.40563157e-02f,
  -5.56625500e-02f, 4.01514061e-02f, -1.76336572e-01f, 1.59592349e-02f, -1.23875506e-01f, -1.27252892e-01f, 1.28162116e-01f, -2.25127503e-01f, 1.57542214e-01f, -1.63987428e-02f,
  2.18633637e-02f, 5.03773764e-02f, -5.95065467e-02f, 2.58960892e-02f, 2.71236580e-02f, -1.22221418e-01f, -5.93037009e-02f, -2.88758516e-01f, -2.02234685e-01f, -1.45632982e-01f,
  2.69790329e-02f, 6.54737949e-02f, 1.15055833e-02f, -1.25346631e-01f, 3.44584212e-02f, 1.18143447e-01f, 1.30073830e-01f, -1.37149855e-01f, 6.15387037e-02f, 4.02640730e-01f,
  8.82682651e-02f, 7.27349818e-02f, -5.91888614e-02f, 2.15191618e-01f, -1.20551258e-01f, -2.36280352e-01f, -2.67432295e-02f, 4.34834696e-02f, -2.52386238e-02f, -2.12304100e-01f,
  -3.38244848e-02f, -3.46598625e-02f, 2.32935429e-01f, 4.97115031e-02f, -2.24806014e-02f, 1.43720672e-01f, -8.50059837e-02f, 5.05421236e-02f, -2.03918979e-01f, 1.44959033e-01f,
  1.73881069e-01f, 2.80267835e-01f, -4.42524046e-01f, 1.75088663e-02f, -1.14089966e-01f, 1.24697842e-01f, 9.57985744e-02f, 4.33719046e-02f, -1.40149921e-01f, -1.15576252e-01f,
  3.35466087e-01f, -1.53542340e-01f, -4.89476435e-02f, -1.26699656e-01f, -1.27537474e-01f, -1.68081880e-01f, -2.00764120e-01f, 2.95123070e-01f, 1.38596058e-01f, -1.89836025e-01f,
  6.46100789e-02f, -1.11805145e-02f, -1.07154429e-01f, 8.39840770e-02f, -2.34557554e-01f, 1.48178294e-01f, 1.53145164e-01f, -1.27869621e-01f, 2.31417254e-01f, 8.56416151e-02f,
  -1.34204566e-01f, 1.36340514e-01f, 7.16067776e-02f, 1.85953841e-01f, 3.41032841e-03f, 4.39558737e-02f, 9.02359039e-02f, 9.40729603e-02f, 4.42480706e-02f, 7.15002243e-04f,
  -9.58268866e-02f, 2.75037717e-02f, -4.86758314e-02f, -2.86047626e-02f, -2.09777415e-01f, -1.54909596e-01f, 1.29873231e-01f, 2.54062295e-01f, 2.73042858e-01f, 2.84745872e-01f,
  1.52926132e-01f, 3.33653629e-01f, -1.15525804e-01f, 1.19610980e-01f, -8.82838219e-02f, -3.05802554e-01f, -1.59570545e-01f, 1.82109386e-01f, 1.09341390e-01f, 3.33863273e-02f,
  -2.87564874e-01f, 6.73710033e-02f, 2.04588234e-01f, -9.18403864e-02f, -2.74642974e-01f, 2.58932002e-02f, 1.66332424e-01f, -5.51408567e-02f, 3.21616143e-01f, -4.41022843e-01f,
  -1.17425613e-01f, 1.84456363e-01f, 8.31311345e-02f, 1.09308325e-01f, -3.13218504e-01f, 7.08132191e-03f, -1.71027966e-02f, 2.15862170e-01f, -2.69500792e-01f, -7.65999556e-02f,
  -9.10896733e-02f, -1.06209658e-01f, 1.02868527e-01f, 2.45689332e-01f, 3.64203267e-02f, -2.69815922e-01f, 2.02430815e-01f, 1.01641282e-01f, 2.60603666e-01f, -2.13927086e-02f,
  -6.79501072e-02f, -2.59692706e-02f, -1.06220990e-01f, -1.42456040e-01f, 1.74847662e-01f, 6.07219189e-02f, -1.12288877e-01f, -1.50753677e-01f, -1.20195329e-01f, 2.59959102e-02f,
  -1.60720289e-01f, -4.21637557e-02f, -4.24245559e-02f, 1.56422287e-01f, 9.83785614e-02f, 9.26683694e-02f, 1.30084455e-01f, 1.12048745e-01f, 1.82961449e-01f, 1.61506739e-02f,
  -3.33980173e-01f, -3.50986011e-02f, -3.39023530e-01f, -8.41595307e-02f, -3.60495776e-01f, -5.82661390e-01f, -8.89237747e-02f, 1.35732651e-01f, 6.53399825e-02f, -1.66872069e-01f,
  -1.74862459e-01f, 1.37417153e-01f, -2.80710787e-01f, -3.85213159e-02f, -5.25822826e-02f, 1.29520535e-01f, -9.72081721e-02f, -6.19461983e-02f, 4.09464724e-02f, -2.34124854e-01f,
  -2.39575058e-01f, -2.15160474e-01f, -1.61826476e-01f, 2.54525930e-01f, -1.44963905e-01f, 2.10751384e-01f, -1.07768059e-01f, 1.62172973e-01f, -2.01462284e-01f, 3.75974067e-02f,
  9.17360634e-02f, 3.58089693e-02f, -1.12439789e-01f, -9.72701088e-02f, 3.66627648e-02f, 1.06847972e-01f, 3.38677764e-02f, 6.82396442e-02f, 3.92752327e-02f, 2.90850550e-02f,
  -1.65242225e-01f, 9.94871110e-02f, -5.33278286e-02f, 9.52632651e-02f, 6.62103593e-02f, 1.54530741e-02f, 1.42292082e-01f, -5.93252596e-04f, -3.26355174e-02f, -5.29242828e-02f,
  1.46024287e-01f, -2.07788814e-02f, -3.44563313e-02f, -9.23599750e-02f, 7.38572283e-03f, -4.37115468e-02f, 1.64659709e-01f, -3.16943936e-02f, -9.67829898e-02f, 2.91502029e-02f,
  -1.14971213e-02f, 8.56459364e-02f, -9.01359767e-02f, 2.03660682e-01f, 2.70941764e-01f, 1.60155624e-01f, 2.60307044e-01f, 1.45709351e-01f, 2.12232187e-01f, 2.83950090e-01f,
  2.51189619e-01f, -1.48436457e-01f, -1.40124019e-02f, 3.04277003e-01f, -6.33644611e-02f, -1.00611016e-01f, 2.37844273e-01f, 6.81940988e-02f, 6.66280165e-02f, -7.17369781e-04f,
  -6.60958290e-02f, 7.80160502e-02f, 8.47575143e-02f, -2.10311413e-01f, 3.43689770e-01f, 1.53995603e-01f, -2.14470699e-02f, 2.50011712e-01f, -3.23287025e-02f, -7.62039647e-02f,
  1.27844512e-01f, -4.85416651e-02f, -2.31589243e-01f, 6.21823892e-02f, 2.79455721e-01f, 5.43530360e-02f, 5.50393127e-02f, 2.53503740e-01f, 2.80914064e-02f, -1.47705629e-01f,
  -6.29462004e-02f, 1.77554622e-01f, 3.61746810e-02f, 9.30298790e-02f, -7.78521821e-02f, 1.97915863e-02f, 1.90889046e-01f, -1.22313075e-01f, -8.74483958e-02f, 6.14936184e-03f,
  -1.68125063e-01f, -1.44894436e-01f, 1.33046493e-01f, -1.46787107e-01f, -2.19513088e-01f, 7.93262944e-03f, 8.04822594e-02f, -2.45092642e-02f, -5.81042767e-02f, 3.47943865e-02f,
  1.80972777e-02f, 9.01300088e-02f, -1.44926794e-02f, -2.39174236e-02f, -2.39377543e-02f, 1.67619899e-01f, 9.96485949e-02f, 3.75889465e-02f, 5.87906726e-02f, 9.08682570e-02f,
  1.12607867e-01f, -2.84606945e-02f, 4.49510366e-02f, -3.24444287e-02f, 5.75428866e-02f, 1.70753926e-01f, 2.14267895e-01f, -3.42954323e-02f, 1.60680607e-01f, -8.41175541e-02f,
  7.78717548e-02f, 2.71137625e-01f, -2.47142658e-01f, 1.57406673e-01f, 1.14212900e-01f, 1.94853302e-02f, -4.63539036e-03f, 5.45998812e-02f, 1.88844413e-01f, 3.17649134e-02f,
  1.92568406e-01f, -3.34073663e-01f, -9.22876373e-02f, 1.40914053e-01f, -5.78099601e-02f, 1.98812097e-01f, 5.08648381e-02f, -1.61462754e-01f, -6.30089864e-02f, 2.77512103e-01f,
  -3.40079784e-01f, -2.20709696e-01f, -2.81674042e-02f, -9.30300727e-02f, 1.68847084e-01f, -8.09730887e-02f, -1.14557417e-02f, -3.61239947e-02f, 2.25939795e-01f, -7.15307295e-02f,
  1.43629491e-01f, 2.06730768e-01f, 2.73019046e-01f, 1.12112928e-02f, -8.29914864e-03f, 1.26557827e-01f, 1.58310130e-01f, 1.89405695e-01f, 7.20860064e-02f, 8.63976181e-02f,
  -7.91367143e-02f, -2.17960924e-01f, 1.33331403e-01f, -1.30484417e-01f, 1.57980368e-01f, 3.17143947e-01f, 2.68247068e-01f, -2.33396478e-02f, 1.06266797e-01f, -1.32397845e-01f,
  6.95058471e-03f, -3.46561670e-02f, 9.69168842e-02f, 1.31734731e-02f, 1.76561013e-01f, 1.56514168e-01f, 1.32934228e-01f, -1.34295240e-01f, -3.44422489e-01f, -1.17315352e-01f,
  -3.11033949e-02f, -2.16004834e-01f, -9.25476924e-02f, -4.58650663e-03f, -7.02163577e-02f, 2.86676344e-02f, -1.52235627e-01f, 1.15813456e-01f, -1.02218360e-01f, -1.40210584e-01f,
  1.78675607e-01f, 1.50080383e-01f, 2.02193744e-02f, -9.52569917e-02f, -1.79369766e-02f, -1.37463436e-01f, -9.89962965e-02f, 1.62257493e-01f, -4.23083417e-02f, 8.57604891e-02f,
  -1.39521375e-01f, 4.32536267e-02f, 1.38801068e-01f, 2.43483528e-01f, -2.85269618e-01f, -2.17028499e-01f, 1.76012769e-01f, 1.29312873e-01f, 1.12463415e-01f, 8.71631354e-02f,
  -4.69534248e-02f, 2.41324365e-01f, -4.08613384e-02f, 1.23356860e-02f, 1.69625252e-01f, 1.11464165e-01f, 2.77581722e-01f, -5.40918708e-02f, 2.59284489e-02f, 2.84157898e-02f,
  9.38068107e-02f, 8.73181671e-02f, -7.09322020e-02f, 1.51007399e-01f, -2.36990541e-01f, 7.84488842e-02f, 9.91395712e-02f, -1.96967777e-02f, 2.16604665e-01f, 2.46303946e-01f,
  5.95800057e-02f, 1.92609593e-01f, -3.81272659e-02f, -3.95975590e-01f, 1.04232855e-01f, 1.54343084e-01f, -1.23540744e-01f, 4.80814725e-02f, 7.91895539e-02f, 1.79273233e-01f,
  -7.32574239e-02f, -1.25969440e-01f, -9.91040841e-02f, -1.88002791e-02f, 1.12275422e-01f, -7.90848280e-04f, 6.07228316e-02f, -9.16119851e-03f, -2.46052407e-02f, 6.41495809e-02f,
  1.65235981e-01f, 1.53264239e-01f, -2.69075096e-01f, -7.99900368e-02f, 1.04524218e-01f, -3.29230838e-02f, -1.38737261e-01f, -2.04026669e-01f, 1.05547026e-01f, 5.38028553e-02f,
  -1.33805484e-01f, -1.12283099e-02f, 1.78593293e-01f, 1.12650335e-01f, -1.05941221e-01f, -1.13567738e-02f, -6.71876073e-02f, 1.13987345e-02f, 9.12158489e-02f, -1.06188424e-01f,
  2.53946334e-01f, 1.14026450e-01f, -6.26534969e-02f, 1.54368699e-01f, 1.34838354e-02f, -1.22957863e-01f, -8.13129023e-02f, 2.60447804e-02f, -4.64055762e-02f, 1.50158107e-01f,
  9.26643163e-02f, -2.11400185e-02f, 3.07509005e-01f, -1.54818138e-02f, 1.06861867e-01f, -1.03743918e-01f, 2.19704345e-01f, 1.14464343e-01f, -8.48032236e-02f, 1.28070116e-01f,
  -3.81043777e-02f, 1.24705374e-01f, 8.11678320e-02f, 1.09889083e-01f, -1.19666094e-02f, -2.15831809e-02f, -3.59633043e-02f, -9.34108123e-02f, -6.67618364e-02f, 8.57678577e-02f,
  2.64493823e-01f, 9.77206081e-02f, 2.28718460e-01f, 2.99186558e-01f, 2.01613784e-01f, 3.54587287e-01f, 8.47947821e-02f, -1.15184650e-01f, -2.81984925e-01f, -1.90657496e-01f,
  -2.54903674e-01f, 2.02784494e-01f, 2.05487553e-02f, -2.82701194e-01f, -2.06264198e-01f, -5.45739606e-02f, -1.52203307e-01f, -5.89938201e-02f, 2.08374068e-01f, 3.35056856e-02f,
  9.62374266e-03f, 1.62016898e-01f, 5.83715625e-02f, -3.66931707e-01f, 3.89683619e-02f, -1.42083377e-01f, 2.29056403e-01f, -2.92207301e-01f, 1.23278750e-02f, 8.95164721e-03f,
  1.98040426e-01f, 2.10904196e-01f, -1.36520490e-02f, 1.27177849e-01f, -1.65320002e-02f, -1.91184118e-01f, 2.63524521e-02f, 1.29711911e-01f, 1.99444428e-01f, -5.81441820e-02f,
  3.48170986e-03f, -1.14278113e-02f, -5.39676659e-03f, -2.22040057e-01f, -2.65716523e-01f, 2.31903493e-02f, -1.68352902e-01f, -2.96724349e-01f, -1.35486752e-01f, -3.02346945e-01f,
  1.88189790e-01f, -1.65814698e-01f, -2.54390776e-01f, 8.26092437e-02f, 3.71807776e-02f, 2.31085077e-01f, 1.74246524e-02f, -2.67206460e-01f, -1.49215147e-01f, 5.62558940e-04f,
  -1.49688236e-02f, 2.08859667e-01f, 1.39061064e-01f, -1.93854600e-01f, 1.93878070e-01f, 3.39502573e-01f, 7.63979480e-02f, 1.04969546e-01f, 7.31222928e-02f, 5.07628396e-02f,
  3.71004313e-01f, -1.49130255e-01f, 6.78226873e-02f, 2.99636740e-03f, -1.65738866e-01f, -3.45019065e-03f, 9.87855121e-02f, 1.50249392e-01f, -1.50677934e-01f, -2.01264083e-01f,
  1.10747293e-01f, -2.23052561e-01f, 1.23136677e-01f, 1.97749496e-01f, 2.31187940e-01f, -4.04498354e-02f, 1.86320003e-02f, -2.75084339e-02f, -6.67638630e-02f, -1.63950503e-01f,
  -4.28287596e-01f, -2.00686574e-01f, 1.36291519e-01f, -1.93877801e-01f, 7.52891079e-02f, 2.80581471e-02f, 5.94960935e-02f, 1.28065392e-01f, -4.10850376e-01f, 6.69674128e-02f,
  -2.08269209e-01f, -1.82555199e-01f, 2.25922123e-01f, -4.74744290e-02f, 1.48577422e-01f, -9.84043702e-02f, 1.52109638e-02f, 1.72258839e-02f, -1.67317055e-02f, -1.60687104e-01f,
  5.12989946e-02f, 4.02407162e-02f, -2.12392896e-01f, -1.30825751e-02f, -5.00954054e-02f, 2.22320303e-01f, -6.77179918e-02f, -3.29437200e-03f, 7.12070540e-02f, -4.84323874e-03f,
  1.23205692e-01f, 7.19399676e-02f, 2.12218076e-01f, -1.47294462e-01f, 1.74646854e-01f, 2.25157782e-01f, 5.95944412e-02f, 2.80613303e-01f, 5.87598346e-02f, -8.36032070e-03f,
  1.61474451e-01f, -1.75621942e-01f, 8.04614201e-02f, 1.03118159e-01f, -8.63469392e-02f, -1.50888234e-01f, -7.97512084e-02f, -4.86982130e-02f, 5.68514094e-02f, 2.30240569e-01f,
  -1.02139406e-01f, 1.37075102e-02f, -1.01722933e-01f, -2.22890843e-02f, 7.80682042e-02f, 2.74290307e-03f, 1.96489424e-01f, 1.95473030e-01f, -6.59390464e-02f, 6.33478537e-02f,
  -1.06566727e-01f, -1.81134194e-01f, 1.28581852e-01f, -1.01328246e-01f, -8.06622431e-02f, 2.15550408e-01f, 8.40159506e-02f, 8.37678835e-02f, 1.18279703e-01f, -1.26331924e-02f,
  -2.23883867e-01f, -6.71852753e-03f, -2.04767764e-01f, 1.22965053e-01f, 1.82178952e-02f, -2.86364466e-01f, 1.09952457e-01f, 1.00114241e-01f, 7.20527843e-02f, 2.94392984e-02f,
  -1.01959169e-01f, 1.33504540e-01f, 2.53438532e-01f, -9.72136706e-02f, -1.00601487e-01f, 1.77418634e-01f, -4.21219878e-03f, 1.88866742e-02f, -8.34297016e-03f, 1.02731876e-01f,
  -4.39497977e-02f, 1.32351249e-01f, 1.87824562e-01f, 2.20936283e-01f, -2.38207355e-02f, 3.16169374e-02f, -4.55966927e-02f, 7.84447938e-02f, -2.55641993e-02f, -1.29197553e-01f,
  3.03196572e-02f, -1.00542039e-01f, 2.67402008e-02f, 1.63448244e-01f, 1.69439867e-01f, 4.37024683e-02f, 1.61836743e-01f, 1.60528988e-01f, 7.78224990e-02f, -2.54034884e-02f,
  3.39163810e-01f, 3.73535715e-02f, -1.09886698e-01f, -1.91184655e-01f, 3.28206629e-01f, 6.28961623e-02f, -1.72317982e-01f, 4.76184152e-02f, 5.16580697e-03f, -2.04940572e-01f,
  -3.86206284e-02f, -9.34462622e-02f, 1.05739027e-01f, -1.59239516e-01f, 7.93732256e-02f, 1.82095975e-01f, -2.04912908e-02f, -2.14070063e-02f, -1.03168584e-01f, -1.12679571e-01f,
  -2.21608207e-01f, -1.58084944e-01f, 1.00414693e-01f, 1.56019703e-01f, -9.05575901e-02f, -4.19043824e-02f, -5.84691167e-02f, -8.00753906e-02f, 1.35141209e-01f, 1.74942762e-01f,
  1.09690372e-02f, -1.27959281e-01f, 1.29429594e-01f, 9.46077611e-03f, 2.76076823e-01f, 6.50696829e-02f, 2.59081982e-02f, -1.09290205e-01f, -6.33170009e-02f, -1.21362612e-01f,
  1.05577424e-01f, -1.03021242e-01f, -2.14393914e-01f, -6.28504306e-02f, 4.12176661e-02f, 1.84298158e-02f, -8.69951248e-02f, -1.15175702e-01f, 8.63268599e-02f, 2.00706914e-01f,
  2.52057254e-01f, -2.58300286e-02f, 1.60474598e-01f, 9.11509693e-02f, 1.24473728e-01f, 1.69708937e-01f, 1.63185000e-01f, -1.45705976e-02f, 1.26433104e-01f, 6.16142750e-02f,
  2.32414156e-01f, 2.38887593e-01f, -1.66127533e-01f, 3.96171063e-02f, -1.76839352e-01f, -2.30026841e-01f, -2.59273201e-02f, 9.47807506e-02f, -8.33434314e-02f, -2.49551743e-01f,
  3.47471535e-01f, 1.13836706e-01f, -3.21506038e-02f, -2.58560717e-01f, -8.49219859e-02f, 1.80068463e-01f, -3.83705199e-02f, -6.05934486e-03f, 1.29106268e-01f, -5.21219969e-01f,
  -6.74985945e-02f, -4.96167801e-02f, 1.92386985e-01f, -1.59152538e-01f, 2.36204132e-01f, 5.30759506e-02f, -9.30601880e-02f, 1.87992036e-01f, 2.49208901e-02f, -7.23577440e-02f,
  1.13177687e-01f, 2.26464588e-02f, 1.37759566e-01f, 1.81425080e-01f, 9.27972049e-02f, -3.42491299e-01f, -2.76989378e-02f, -1.18077639e-02f, -2.50458289e-02f, -1.80926532e-01f,
  3.16088065e-03f, -6.38540834e-02f, 5.08108959e-02f, -8.42500031e-02f, 1.51897809e-02f, 1.56251982e-01f, 2.34451890e-01f, -2.45741636e-01f, -3.82821932e-02f, 1.62391871e-01f,
  -9.41026881e-02f, 9.72066000e-02f, -1.02341294e-01f, -1.86674088e-01f, 7.36500099e-02f, 2.01994359e-01f, -1.23790741e-01f, -2.22779140e-01f, -1.72427800e-02f, -2.03493401e-01f,
  -4.96741198e-02f, 4.15161431e-01f, 1.64817214e-01f, -3.79675142e-02f, -2.24674374e-01f, 1.70769706e-01f, 3.63888055e-01f, 2.35348240e-01f, 1.52897835e-01f, 1.44240959e-02f,
  1.35094851e-01f, -1.06897652e-01f, -1.03225507e-01f, 1.81881249e-01f, -9.99099687e-02f, -2.93387979e-01f, 1.04136661e-01f, -4.00841057e-01f, -5.46040423e-02f, 2.36744702e-01f,
  9.55327749e-02f, 5.22908233e-02f, 1.35089517e-01f, -1.58666193e-01f, 2.38237418e-02f, 1.29706999e-02f, -1.53013259e-01f, -1.35448039e-01f, 1.99325293e-01f, -1.94564983e-01f,
  -2.04976089e-02f, 1.02180086e-01f, -1.32782221e-01f, -1.35707080e-01f, -1.29695728e-01f, 7.16702119e-02f, -6.15204349e-02f, -1.75052032e-01f, 7.09435791e-02f, -2.70207115e-02f,
  1.17508866e-01f, -1.23040706e-01f, -9.20332298e-02f, -4.72575203e-02f, 1.96136117e-01f, -7.46167600e-02f, -1.88407581e-02f, 1.16923548e-01f, -8.75358880e-02f, -6.56355023e-02f,
  1.27839878e-01f, -5.34804128e-02f, 4.16005626e-02f, -1.02952272e-01f, 1.00963779e-01f, -4.37531322e-02f, 8.41699839e-02f, -7.91174546e-02f, 6.07397594e-02f, -2.10002303e-01f,
  2.04302788e-01f, 2.38101602e-01f, -8.26953799e-02f, 2.10593157e-02f, 1.79005519e-01f, 4.16378640e-02f, 2.43893445e-01f, 2.15952709e-01f, 1.93560541e-01f, 2.48867139e-01f,
  2.69393474e-02f, 7.77527392e-02f, 2.09272467e-02f, -3.04887325e-01f, -7.20197633e-02f, 3.11728884e-02f, -4.86116894e-02f, -6.20074309e-02f, 2.37077177e-02f, -6.79368302e-02f,
  1.31896347e-01f, -1.14223368e-01f, -2.16860026e-01f, 4.07445095e-02f, -4.11035456e-02f, -6.81163296e-02f, 1.90248474e-01f, -4.06675845e-01f, -1.29564498e-02f, -1.36107178e-02f,
  2.06053317e-01f, 6.61883457e-03f, 5.44446707e-02f, 8.86040106e-02f, -5.02384603e-02f, 1.85133502e-01f, 3.94293964e-02f, -1.34711429e-01f, -8.58602300e-02f, 3.59847322e-02f,
  9.29628760e-02f, 3.17884348e-02f, -2.19077822e-02f, -1.90952659e-01f, 1.65797755e-01f, 2.47822944e-02f, -3.35678458e-02f, -7.70137161e-02f, 1.59172162e-01f, -8.89257789e-02f,
  -2.23671481e-01f, -2.15996038e-02f, 1.64996728e-01f, 4.76547331e-02f, 1.54222250e-01f, -1.30658001e-01f, -7.59167001e-02f, 5.57763539e-02f, 6.42012730e-02f, 1.42755836e-01f,
  6.57159090e-02f, -9.41379741e-02f, 2.18196705e-01f, 4.18378115e-02f, 8.53710920e-02f, 5.91308549e-02f, 8.92465115e-02f, -1.74505293e-01f, -2.72782683e-01f, -1.80080324e-01f,
  -2.32862428e-01f, -3.08589518e-01f, -3.72911751e-01f, -1.73215166e-01f, -8.94861147e-02f, 2.14697644e-02f, 1.01841591e-01f, -9.85989049e-02f, -8.33215043e-02f, 1.45957649e-01f,
  1.81756336e-02f, 1.36118159e-01f, -7.63292750e-03f, 1.97861269e-01f, -2.22037416e-02f, -2.70694107e-01f, 8.09655413e-02f, 9.91175026e-02f, -1.02151096e-01f, 1.72161367e-02f,
  1.20146561e-03f, -3.23683117e-03f, 1.30535886e-01f, 2.04045296e-01f, -2.16717914e-01f, -1.65462792e-01f, 7.28703216e-02f, -1.48231432e-01f, -5.25787063e-02f, -1.05027147e-01f,
  -2.23661765e-01f, -1.22235730e-01f, 4.60621044e-02f, -6.52509183e-02f, -1.04273424e-01f, -7.86124691e-02f, 5.34844212e-02f, 7.49293417e-02f, 1.65261850e-01f, 4.07455862e-02f,
  -5.65114729e-02f, -5.45789450e-02f, 3.42042595e-02f, 1.27357915e-01f, -3.89172584e-02f, 1.65691808e-01f, -9.49983001e-02f, -2.72591598e-02f, 1.18457392e-01f, -4.15782854e-02f,
  -1.26364529e-02f, 1.93712525e-02f, 2.97704279e-01f, 7.61502907e-02f, -1.13710081e-02f, -1.81103542e-01f, 4.41378355e-02f, -1.18417352e-01f, 1.20918214e-01f, 1.03331834e-01f,
  7.87753537e-02f, -1.32911965e-01f, -3.48324142e-02f, 1.43849105e-01f, -7.73774385e-02f, -6.67942315e-02f, 7.10637867e-02f, -2.32749358e-01f, 2.21347973e-01f, -3.63291763e-02f,
  2.70469815e-01f, 1.33234307e-01f, 2.33650371e-01f, -2.91660458e-01f, 2.46833354e-01f, 2.85354666e-02f, 2.58597117e-02f, -7.03143403e-02f, 1.66836962e-01f, 6.52168989e-02f,
  1.17141586e-02f, 7.29118511e-02f, -2.64930055e-02f, -1.66091636e-01f, 3.15090343e-02f, 2.89742380e-01f, -4.17908251e-01f, -1.04624234e-01f, -7.87931532e-02f, -1.21762812e-01f,
  -1.18982486e-01f, 3.17427889e-02f, -8.14822316e-02f, -1.97807210e-03f, 1.28761008e-01f, 5.19683491e-03f, -2.62079705e-02f, -1.45758353e-02f, 2.17449050e-02f, -1.84614927e-01f,
  1.26980990e-01f, -1.69730946e-01f, 1.11334234e-01f, 3.66710871e-02f, 8.45826492e-02f, 1.15410328e-01f, 1.05886906e-01f, -1.78147122e-01f, 9.56986323e-02f, -1.02120511e-01f,
  -1.56568326e-02f, -1.13130912e-01f, -8.87461901e-02f, 1.50506660e-01f, -1.90765142e-01f, -1.80352151e-01f, -6.11119531e-03f, -4.75504547e-02f, 1.39167547e-01f, 2.75148869e-01f,
  1.36063054e-01f, 2.38753092e-02f, 1.74993306e-01f, 4.26075906e-02f, 5.96032664e-02f, 3.94111365e-01f, -7.66071528e-02f, 3.78852971e-02f, -2.80661136e-01f, 1.57094225e-01f,
  3.52424592e-01f, -1.88221350e-01f, -1.85652852e-01f, -3.07585090e-01f, 4.31687795e-02f, -1.34950697e-01f, -6.41060174e-02f, 7.74059743e-02f, 1.70720935e-01f, -9.54878479e-02f,
  1.53435603e-01f, 1.98724329e-01f, -1.37899980e-01f, -6.64188787e-02f, -1.13229617e-01f, 3.51605751e-02f, -7.53018409e-02f, -3.20194840e-01f, 7.60698738e-03f, 2.75606602e-01f,
  2.66473129e-04f, 1.35901943e-01f, 1.25104055e-01f, 8.34307671e-02f, -5.10406010e-02f, -9.36729684e-02f, 1.31536558e-01f, 8.54163095e-02f, -1.15939483e-01f, 7.96541497e-02f,
  6.13537394e-02f, 2.06710696e-02f, 1.17381727e-02f, -7.02799186e-02f, -3.49862427e-02f, -8.48760363e-03f, -1.24312434e-02f, 1.04615122e-01f, 2.60133684e-01f, 2.74461824e-02f,
  -1.35049284e-01f, -4.69772667e-02f, 7.45410621e-02f, -1.00040123e-01f, 2.09030256e-01f, 1.03034740e-02f, -5.86101301e-02f, -1.47215486e-01f, 7.37804323e-02f, 1.32678943e-02f,
  3.90045345e-02f, 7.87294656e-02f, -2.76166685e-02f, -2.12092372e-03f, -7.09689260e-02f, -1.25481347e-02f, -1.48920104e-01f, -1.29798055e-01f, -6.85171485e-02f, 8.55941176e-02f,
  6.64978102e-02f, 2.02899039e-01f, 2.02531993e-01f, 3.16321908e-04f, 1.53404728e-01f, 3.24170664e-02f, -8.03658813e-02f, 5.56244291e-02f, 9.00899246e-02f, -2.53712595e-01f,
  -1.90457162e-02f, 7.55612478e-02f, -4.30582799e-02f, 3.87273878e-02f, -3.55801046e-01f, -1.44426115e-02f, 6.30823746e-02f, 1.30805612e-01f, -1.75600760e-02f, -6.57917187e-02f,
  -4.91389669e-02f, 1.52671441e-01f, 6.14106953e-02f, -3.23865712e-01f, -1.09411001e-01f, 1.39242345e-02f, 6.34607151e-02f, 9.13889632e-02f, -1.68409914e-01f, 1.78759947e-01f,
  2.43364304e-01f, 1.14862248e-01f, -5.95994294e-03f, -1.34970471e-02f, 4.18720581e-03f, -2.99789514e-02f, 1.54997453e-01f, -5.04443012e-02f, -1.63285900e-02f, 1.62965074e-01f,
  -7.27791265e-02f, 1.45117298e-01f, 4.83723404e-03f, 1.99058279e-01f, 3.01175267e-02f, -2.55139172e-01f, -7.30319992e-02f, 3.31630222e-02f, 1.83674008e-01f, 9.72856581e-02f,
  -1.01318374e-01f, 2.33984560e-01f, -2.62931406e-01f, 1.83899440e-02f, -5.73678166e-02f, 2.23143637e-01f, 2.43530214e-01f, 2.04241812e-01f, 1.00607844e-02f, 1.06236324e-01f,
  -1.41192615e-01f, -2.28036031e-01f, 2.00534821e-01f, 7.03738211e-03f, -1.46268040e-01f, -1.44101918e-01f, 3.14247638e-01f, -1.32382996e-02f, 2.78698485e-02f, -5.26776388e-02f,
  -7.06376731e-02f, -1.55253887e-01f, -1.49444882e-02f, -1.09269400e-04f, -1.55369967e-01f, 2.52900392e-01f, -1.61501750e-01f, -7.83908591e-02f, 2.23383680e-01f, 1.13056846e-01f,
  -1.43772857e-02f, -2.86255851e-02f, -5.57162650e-02f, -5.25043011e-02f, -2.43145391e-01f, 1.62057459e-01f, 1.51691169e-01f, -2.99098283e-01f, 1.62321888e-02f, 1.74975514e-01f,
  2.61765212e-01f, 5.48276938e-02f, 2.77167320e-01f, 7.96094537e-02f, 1.69268642e-02f, 1.43417299e-01f, -1.43202931e-01f, 2.70236470e-02f, 2.16373235e-01f, 2.41786271e-01f,
  8.36105347e-02f, 8.33321586e-02f, -1.44049317e-01f, -9.17475298e-02f, -3.90131064e-02f, 1.07416362e-01f, -4.52307984e-02f, -1.80342067e-02f, -1.53592101e-03f, 7.85885751e-02f,
  2.25984290e-01f, 7.68319666e-02f, 1.56189978e-01f, 2.52723724e-01f, -4.92827594e-02f, 5.74932806e-03f, -1.09694906e-01f, 9.42436457e-02f, 5.25652315e-04f, -5.99093735e-03f,
  1.00514561e-01f, -7.91517943e-02f, -5.64918742e-02f, 2.27454916e-01f, -1.36068285e-01f, -1.60102725e-01f, -4.69799675e-02f, -2.35422865e-01f, 1.90773517e-01f, 2.08439678e-01f,
  1.94600999e-01f, -1.01477616e-01f, 3.58988345e-03f, 3.00522298e-01f, -6.45126104e-02f, -3.80321927e-02f, -5.47778932e-03f, 2.05240771e-02f, 1.40846502e-02f, -5.21250330e-02f,
  4.25958708e-02f, 1.62081763e-01f, -3.10291499e-01f, -1.01905912e-01f, 2.21864626e-01f, 2.43834015e-02f, 5.01448251e-02f, 1.82940230e-01f, 1.08524993e-01f, 1.11878835e-01f,
  1.78236514e-01f, -2.89631575e-01f, -1.19734637e-01f, 1.16904201e-02f, 7.37588704e-02f, 5.87399155e-02f, -2.58866213e-02f, -1.44057363e-01f, -4.89328876e-02f, 1.78818926e-01f,
  -6.84673637e-02f, -2.00998768e-01f, -2.41572499e-01f, -1.45634040e-01f, 8.40487406e-02f, 5.70802130e-02f, 2.68667415e-02f, 3.60822752e-02f, 1.79966003e-01f, 1.28218457e-02f,
  1.00418314e-01f, 4.82886704e-03f, 2.15355933e-01f, -1.39990926e-01f, -2.45335311e-01f, -5.82343936e-02f, 9.85628143e-02f, -2.15458032e-02f, 2.31054619e-01f, -1.39830813e-01f,
  7.21110106e-02f, -5.88409752e-02f, 1.03402562e-01f, 8.78382027e-02f, 1.84332728e-02f, 1.57672763e-01f, 2.46788889e-01f, 6.05455637e-02f, 1.79806828e-01f, -3.30866307e-01f,
  1.18415102e-01f, -1.76599160e-01f, -1.81576207e-01f, -3.13302934e-01f, 1.12026587e-01f, -1.05321836e-02f, -1.63870156e-01f, -1.46531627e-01f, -3.49817932e-01f, 2.63484083e-02f,
  -9.80339199e-02f, -2.26364985e-01f, 1.37038246e-01f, 2.16224790e-01f, -1.50122240e-01f, -3.65427807e-02f, 1.75439700e-01f, 9.23220888e-02f, -7.06520528e-02f, 4.19857688e-02f,
  2.23724870e-03f, -3.69211547e-02f, -1.13696165e-01f, 9.47554186e-02f, -5.60133494e-02f, -2.38151222e-01f, -4.78112102e-02f, -4.40213867e-02f, 1.71567023e-01f, 8.57583955e-02f,
  1.75545499e-01f, 9.78786424e-02f, 2.55126934e-02f, 1.02999993e-01f, -9.27705169e-02f, -1.42286912e-01f, -7.50754867e-03f, 2.00929880e-01f, 2.19259318e-03f, -3.10907345e-02f,
  -3.96637060e-02f, 1.41814113e-01f, 7.82439858e-02f, 7.32570328e-03f, 1.07710756e-01f, -3.48770283e-02f, 1.66001335e-01f, 8.59542191e-02f, 1.52372003e-01f, 2.25341737e-01f,
  -2.37336993e-04f, 1.75612167e-01f, -1.54150411e-01f, 9.02102366e-02f, -2.06473805e-02f, 1.51215969e-02f, -1.20671354e-02f, -7.18355328e-02f, -6.94981068e-02f, -7.53033981e-02f,
  -1.16308428e-01f, 1.18570417e-01f, -1.02846816e-01f, -6.36648983e-02f, -5.19987904e-02f, -1.12461358e-01f, 3.37030470e-01f, 3.61780524e-02f, 3.34365755e-01f, 8.66208598e-02f,
  1.56781211e-01f, 1.49087355e-01f, -1.88296229e-01f, 3.06095183e-02f, 7.43700340e-02f, -1.97980806e-01f, -1.82112321e-01f, 4.85824421e-02f, 1.69245020e-01f, 1.18728320e-04f,
  5.60839847e-02f, 7.10551664e-02f, 1.63805142e-01f, -9.08624977e-02f, -3.30711812e-01f, 3.50860506e-02f, 2.69043833e-01f, -7.37761054e-03f, 2.57034391e-01f, -4.23872232e-01f,
  -7.25899637e-02f, 8.31645653e-02f, 1.61821917e-01f, 1.04321301e-01f, -2.69922793e-01f, 3.54502201e-02f, -9.22784358e-02f, 8.27853754e-02f, -1.06200591e-01f, -2.14181036e-01f,
  -1.03825852e-02f, -8.38239193e-02f, 8.45158026e-02f, -1.37549609e-01f, 8.91339872e-03f, -1.43758148e-01f, 2.23866761e-01f, 8.99013951e-02f, 1.49378419e-01f, -4.06344384e-02f,
  5.07699661e-02f, -1.32759482e-01f, -2.28424922e-01f, -4.57701720e-02f, 1.43917367e-01f, 1.40410170e-01f, -2.45077148e-01f, 9.24343020e-02f, -7.27300718e-02f, -5.58273047e-02f,
  -1.35724070e-02f, 9.19601880e-03f, -4.57908884e-02f, 1.73754096e-01f, 2.89461985e-02f, -5.48418276e-02f, -6.51089028e-02f, -2.21179679e-01f, 5.05124917e-03f, -9.81129184e-02f,
  8.43860656e-02f, -9.78253484e-02f, -2.61304155e-02f, -7.36073125e-04f, 2.10673243e-01f, 1.55813973e-02f, -2.96661258e-01f, -1.13474019e-01f, 5.36105931e-02f, 1.71713084e-02f,
  -3.59679945e-02f, 5.48074096e-02f, 1.06923312e-01f, -5.19851185e-02f, 8.86165723e-02f, 1.85854957e-01f, -7.52930120e-02f, -9.68267769e-03f, 1.27299204e-01f, -5.40644825e-02f,
  1.43777534e-01f, 9.02817771e-02f, -6.89293444e-02f, 2.49105781e-01f, 2.87205894e-02f, -1.09496824e-01f, 6.01383150e-02f, 2.26590902e-01f, -1.87815651e-01f, 1.49178863e-01f,
  2.78252006e-01f, -1.57717913e-01f, -7.41134351e-03f, -1.73760820e-02f, 8.89013782e-02f, -1.47084877e-01f, 1.01807483e-01f, -4.30119485e-02f, 9.82955247e-02f, 2.23093554e-01f,
  -1.51996389e-01f, -1.60334930e-02f, 2.31053494e-02f, -1.21732362e-01f, 2.50260867e-02f, 1.51170373e-01f, -1.62316263e-01f, -1.79684609e-01f, 6.22658171e-02f, -3.83197553e-02f,
  -2.98822790e-01f, 4.33641672e-02f, 1.62807330e-01f, -9.96183977e-02f, 1.37493148e-01f, 1.59008920e-01f, 9.10714939e-02f, 1.43800387e-02f, -8.30976442e-02f, 1.45826593e-01f,
  -1.49147674e-01f, -1.51584625e-01f, -2.89216954e-02f, 2.48205677e-01f, 2.10144117e-01f, 1.89685762e-01f, 9.11165103e-02f, 1.85326368e-01f, 1.20615937e-01f, 1.31308585e-01f,
  -3.69204551e-01f, 1.35282418e-02f, -2.23044977e-02f, -1.78118479e-02f, 2.10533038e-01f, -3.34346816e-02f, -1.87323578e-02f, -1.69287756e-01f, 4.14023817e-01f, -1.78977493e-02f,
  -8.34238902e-02f, -1.86559454e-01f, -7.11780414e-03f, -3.03343055e-03f, -2.54126936e-01f, 8.69785175e-02f, 2.04972461e-01f, 2.00241670e-01f, -1.06521875e-01f, -3.51347104e-02f,
  2.87521422e-01f, -4.10670005e-02f, 1.50089383e-01f, -1.31804422e-01f, -6.87621683e-02f, 2.79435605e-01f, 2.84262300e-01f, -8.62750858e-02f, 2.12654158e-01f, 3.78211625e-02f,
  4.95831855e-02f, 2.30254024e-01f, -1.31588936e-01f, -2.22941726e-01f, -3.23501438e-01f, -3.39315534e-02f, 2.57355103e-04f, -2.07666114e-01f, -2.60888934e-01f, -7.58086815e-02f,
  1.60632595e-01f, -2.71443605e-01f, -5.93128055e-02f, -1.03551038e-02f, 6.76210076e-02f, -1.46774232e-01f, 8.68612528e-02f, 2.05992714e-01f, -3.08490749e-02f, 2.63980269e-01f,
  -1.34428695e-01f, -2.24656805e-01f, -5.57394214e-02f, 1.85689881e-01f, 7.42293149e-03f, -2.51157373e-01f, -8.07733610e-02f, -2.44442761e-01f, 9.70355421e-02f, -7.22950250e-02f,
  1.14192456e-01f, 3.75614762e-02f, 1.90127209e-01f, 1.05770208e-01f, -2.67190158e-01f, -1.23617537e-01f, 2.09050760e-01f, -1.57776520e-01f, -2.27617752e-02f, 9.36995521e-02f,
  3.31076607e-02f, -6.12579696e-02f, 8.69221613e-02f, 3.14182565e-02f, 4.08420227e-02f, -1.62237853e-01f, 9.44778398e-02f, -6.10219361e-03f, 7.81257227e-02f, 5.68101257e-02f,
  1.95081592e-01f, -3.98900121e-01f, -1.77420363e-01f, -3.42237623e-03f, 2.29702339e-01f, 3.57870683e-02f, -2.09363490e-01f, 4.46426049e-02f, 1.66171610e-01f, 2.26536945e-01f,
  -2.28171051e-01f, -2.40336061e-01f, 4.75065485e-02f, -1.16630197e-01f, 6.49149865e-02f, -2.31874399e-02f, -4.84778956e-02f, 3.07011195e-02f, 6.67402893e-02f, 5.08576352e-03f,
  -1.60788484e-02f, 1.32464375e-02f, 5.26291467e-02f, -3.49018276e-01f, 4.35746759e-02f, -1.20349631e-01f, 4.85517420e-02f, 1.52373374e-01f, -4.85800169e-02f, -1.19735943e-02f,
  -1.26823142e-01f, 9.83552188e-02f, -2.28647590e-01f, -4.02065143e-02f, -6.81140833e-03f, 1.73632219e-01f, 4.41330709e-02f, 7.69533515e-02f, -5.63718565e-02f, -3.59499365e-01f,
  -7.45591372e-02f, 1.19825169e-01f, 1.96048021e-01f, -5.51337600e-02f, 5.94617017e-02f, 1.10974982e-01f, 8.05525407e-02f, 1.03811465e-01f, -1.43832520e-01f, -2.14732051e-01f,
  -1.93245754e-01f, -1.60625562e-01f, -6.09000623e-02f, 2.96095699e-01f, -1.62918419e-01f, -2.25942247e-02f, 5.78189939e-02f, 1.36379316e-01f, -1.73308179e-02f, -5.93761168e-02f,
  1.16396509e-01f, -1.58876568e-01f, 6.80993032e-03f, 1.26257718e-01f, 5.60932346e-02f, 1.03104442e-01f, -7.58473277e-02f, 7.03017190e-02f, 1.17187373e-01f, 1.36949763e-01f,
  2.50451211e-02f, -5.70544526e-02f, 1.50204927e-01f, 9.96314585e-02f, -2.73004565e-02f, 1.00061677e-01f, -2.45171338e-02f, 4.78629991e-02f, 1.77898835e-02f, -1.84821904e-01f,
  -1.27381608e-01f, -3.25761214e-02f, -8.80445614e-02f, 6.23854958e-02f, 1.31918699e-01f, -3.68054584e-02f, 1.08047329e-01f, -1.10916413e-01f, 9.60144177e-02f, -1.45647541e-01f,
  -6.03945181e-02f, 1.61061555e-01f, 2.12590974e-02f, 6.37129918e-02f, 7.59953866e-03f, 2.24919096e-02f, 9.02211592e-02f, 1.09514378e-01f, 6.95402846e-02f, 7.59051666e-02f,
  -8.00507329e-03f, 1.00562699e-01f, -3.58682638e-03f, -2.66072720e-01f, 8.29634666e-02f, -8.75909850e-02f, 1.32955745e-01f, -4.81526740e-02f, -4.62587029e-02f, 6.09788708e-02f,
  1.26030207e-01f, 5.21145412e-04f, -2.10777864e-01f, -7.11990595e-02f, 3.43786366e-02f, -7.68850297e-02f, -1.64492533e-01f, -1.76439770e-02f, -4.42129783e-02f, 9.07413810e-02f,
  -2.14668915e-01f, -3.18915099e-02f, 2.17133582e-01f, -4.04785052e-02f, -9.79428738e-02f, 3.82625647e-02f, -3.90860774e-02f, -1.27468416e-02f, -8.74197334e-02f, -1.77766662e-02f,
  -8.93890485e-02f, -1.70941025e-01f, -1.66701704e-01f, 2.65275091e-01f, -7.69506535e-03f, -3.96838374e-02f, -7.60180056e-02f, 1.45425322e-02f, 2.86806859e-02f, -9.88200009e-02f,
  -2.65762776e-01f, 7.41899908e-02f, 4.12583239e-02f, -1.43800005e-01f, 1.18257880e-01f, 1.31179303e-01f, 4.20740731e-02f, 1.17776543e-01f, 1.71523318e-01f, 1.49416059e-01f,
  2.10555464e-01f, -1.65387586e-01f, -1.02281824e-01f, 7.75402412e-02f, 1.15131989e-01f, 1.59260958e-01f, 3.25991772e-02f, 1.41441703e-01f, -8.16763267e-02f, -5.19158877e-03f,
  -1.05536550e-01f, 6.75369725e-02f, 1.98561609e-01f, 1.92811057e-01f, 2.33505011e-01f, 1.07731130e-02f, -7.32712224e-02f, -4.10187036e-01f, 4.54732478e-02f, 2.09617734e-01f,
  -3.31925303e-01f, -7.58202327e-03f, -2.56542534e-01f, 7.05897436e-02f, 5.84660806e-02f, -1.15164243e-01f, -5.69468625e-02f, -1.28936902e-01f, -4.76152599e-02f, -1.72141835e-01f,
  1.21987082e-01f, 2.03718126e-01f, -1.42109647e-01f, 3.38441767e-02f, 4.32973713e-01f, -8.54785368e-02f, -2.58160383e-01f, -2.11463147e-03f, -1.96979702e-01f, 1.50495127e-01f,
  -1.89125597e-01f, -1.58484221e-01f, -8.35040957e-02f, 7.02188239e-02f, -4.76615950e-02f, 8.99073705e-02f, 1.39610142e-01f, -2.18909979e-02f, 3.91584188e-01f, -3.13216937e-03f,
  1.56702831e-01f, -6.66196924e-03f, -1.35006905e-01f, -1.37153387e-01f, 1.26642883e-01f, 9.00361985e-02f, 8.25778395e-02f, -9.65071768e-02f, -1.51906207e-01f, -9.73243266e-02f,
  -1.88994214e-01f, 1.39983252e-01f, -8.64271969e-02f, 5.19089922e-02f, -5.02646081e-02f, -2.52382517e-01f, 2.61905223e-01f, 1.05385303e-01f, 2.87676919e-02f, 1.99065998e-01f,
  -1.01763286e-01f, -6.62655905e-02f, -7.85775632e-02f, -6.74390942e-02f, -8.09429884e-02f, -6.50366247e-02f, -4.74797413e-02f, -5.93581647e-02f, -1.61188796e-01f, 1.71730667e-02f,
  -1.58311829e-01f, 1.17440060e-01f, -1.51209980e-01f, 4.47857417e-02f, 2.79755205e-01f, 6.40047267e-02f, 1.22215979e-01f, 1.36925504e-01f, 3.36538672e-01f, 1.03260219e-01f,
  -1.48586363e-01f, -3.58524621e-01f, 1.79442793e-01f, -1.31982222e-01f, 2.61729285e-02f, 1.76828429e-02f, 1.13631919e-01f, -6.23952113e-02f, -6.54665157e-02f, -4.20008115e-02f,
  -1.98729753e-01f, -1.01047188e-01f, -1.30700869e-02f, -7.18375593e-02f, 1.75974905e-01f, 9.24624577e-02f, 1.22573592e-01f, -1.61689222e-02f, -1.37722358e-01f, -9.24753584e-03f,
  -3.33662070e-02f, -5.20408228e-02f, -2.39216551e-01f, -5.28057776e-02f, 2.38529086e-01f, 1.11184455e-01f, 1.57438312e-02f, 9.64739546e-02f, -5.69351502e-02f, -1.37034878e-02f,
  7.56628811e-02f, 4.29320373e-02f, 1.68778583e-01f, 2.24780086e-02f, -5.75585514e-02f, -5.59743680e-02f, 1.27017260e-01f, -6.09361306e-02f, -1.72199737e-02f, -4.53656949e-02f,
  1.48020042e-02f, -2.34830722e-01f, 1.36818886e-01f, -8.94565955e-02f, -2.79631734e-01f, -9.18555632e-03f, 1.28771693e-01f, -1.01365022e-01f, -1.04303226e-01f, 1.15890361e-01f,
  -6.68644384e-02f, 6.08423613e-02f, 9.57655534e-02f, 1.66012108e-01f, -1.55026466e-01f, -2.48229787e-01f, 1.18059412e-01f, 3.46641499e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.76380143e-01f, 6.35705143e-02f, -9.22692865e-02f, 8.64114836e-02f, 4.37138565e-02f, 5.98791465e-02f, 1.22182406e-01f, 6.51473626e-02f, 2.09276826e-04f, 1.11433804e-01f,
  -8.34641084e-02f, 1.61190763e-01f, 2.10391823e-03f, -2.96907574e-02f, 8.71835742e-03f, -1.13407701e-01f, 3.63893211e-02f, -5.75567000e-02f, 1.09874485e-02f, 1.06293753e-01f,
  1.47747755e-01f, 1.05266824e-01f, 2.06195757e-01f, -3.34318131e-02f, 4.84009311e-02f, -8.36305972e-03f, 6.32244796e-02f, 1.73382342e-01f, 9.05099213e-02f, -5.35145178e-02f,
  2.82618552e-01f, 1.47742882e-01f, 6.17006831e-02f, 2.41891772e-01f, 1.50364116e-01f, 1.58319876e-01f, 2.17787191e-01f, 3.93282361e-02f, 7.83772990e-02f, 4.63531651e-02f,
  1.83026865e-01f, 8.48882645e-02f, 2.04391673e-01f, 1.13460347e-01f, 1.39786586e-01f, 2.80283857e-02f, 4.64659669e-02f, 1.64180070e-01f, 4.30717953e-02f, -1.18687160e-01f,
  -8.32591280e-02f, 1.94850132e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  6.45397231e-02f, -1.12808861e-01f, 7.97648504e-02f, 1.13105878e-01f, -9.21630859e-02f, -7.94374198e-02f, 1.55288920e-01f, 3.12492579e-01f, 2.09156260e-01f, -2.36059204e-02f,
  4.59650010e-02f, 2.20556363e-01f, -7.16519728e-02f, 2.15913802e-02f, -1.49985135e-01f, -5.14450520e-02f, 6.85748383e-02f, -1.20520219e-01f, -6.85641244e-02f, 1.94057047e-01f,
  -2.54983962e-01f, -1.91747695e-02f, 1.71536967e-01f, -2.15937823e-01f, -1.75444260e-01f, -9.92015079e-02f, 6.87175319e-02f, 1.51934057e-01f, -7.58809149e-02f, -7.94870872e-03f,
  1.05147369e-01f, -1.03182286e-01f, 3.07804476e-02f, -3.82159501e-02f, -1.43192545e-01f, 2.71064676e-02f, -2.12807432e-01f, -3.23339999e-01f, 4.12022732e-02f, -1.52227953e-01f,
  -1.17757373e-01f, -9.60084572e-02f, 7.48905316e-02f, -8.45019370e-02f, -1.28641486e-01f, 1.35846864e-02f, -7.79286176e-02f, -4.97319829e-03f, 2.78147738e-02f, -1.25979975e-01f,
  -1.99326694e-01f, -6.69701621e-02f, -5.83369769e-02f, -5.56683615e-02f, -1.37465507e-01f, -4.04714048e-02f, -2.09402829e-01f, 3.90714034e-02f, 2.01320395e-01f, -1.19873069e-01f,
  -3.41220275e-02f, -1.79987159e-02f, -2.50617534e-01f, -1.33386225e-01f, -1.43196762e-01f, 7.14357793e-02f, -1.80704519e-01f, 7.14861974e-02f, -2.92163379e-02f, -1.19878934e-03f,
  -8.97163525e-02f, -8.75985424e-04f, 7.96942879e-03f, -1.46099165e-01f, 1.66684523e-01f, -1.42751411e-01f, -2.40844533e-01f, 4.95223445e-04f, 9.25419480e-03f, 1.09313882e-03f,
  -3.88681144e-02f, 1.58232793e-01f, 8.91554132e-02f, -1.08060814e-01f, 6.19566301e-03f, -1.54953703e-01f, -1.24443896e-01f, -1.78192526e-01f, 1.83991226e-03f, 4.23051938e-02f,
  1.33769186e-02f, 3.05027273e-02f, -7.13781193e-02f, 1.60186172e-01f, -7.49944225e-02f, -5.81618175e-02f, 1.45549044e-01f, 1.59763545e-01f, -2.26920366e-01f, -1.41653717e-01f,
  7.24372640e-02f, 1.80168718e-01f, -1.26021042e-01f, 4.99575362e-02f, 5.60986996e-02f, -8.94035324e-02f, -1.44982532e-01f, -1.94017768e-01f, -2.62722317e-02f, -3.96499550e-03f,
  9.26380903e-02f, 3.37259774e-03f, 9.02279187e-03f, 1.00959547e-01f, -1.21683888e-01f, 2.25534245e-01f, -3.28444391e-02f, -6.57648519e-02f, 1.05836298e-02f, 1.37653440e-01f,
  1.70228079e-01f, 7.38579854e-02f, 1.15524471e-01f, 1.06157333e-01f, -4.48728986e-02f, 3.53708938e-02f, 1.34542450e-01f, 1.18946515e-01f, -1.56152681e-01f, -2.98657129e-03f,
  -8.03455338e-02f, -5.34326732e-02f, -1.11035496e-01f, 7.18577057e-02f, 4.03791703e-02f, 3.13649625e-02f, -1.42663598e-01f, 1.76920816e-01f, -7.42196962e-02f, -1.09128892e-01f,
  -1.02067903e-01f, 5.12990318e-02f, -3.24156657e-02f, -6.64378926e-02f, 1.22829929e-01f, 4.24363427e-02f, 1.97751239e-01f, -4.01535518e-02f, 7.03002363e-02f, 9.22394395e-02f,
  1.40860215e-01f, 1.30903363e-01f, -1.98093671e-02f, 5.45480736e-02f, 5.28689548e-02f, 8.39310512e-02f, 6.25842512e-02f, 2.02934414e-01f, 4.22102064e-02f, 7.77614042e-02f,
  -5.82439043e-02f, 1.46995246e-01f, -3.68822701e-02f, 9.93516948e-03f, -1.52914509e-01f, 2.25923155e-02f, 1.13544315e-01f, -7.33103752e-02f, -5.59862284e-03f, -1.31771848e-01f,
  -1.99690312e-01f, 2.71649379e-03f, 1.49356008e-01f, -6.92657009e-02f, -2.09509984e-01f, -9.82585736e-03f, -1.15859747e-01f, 4.23904024e-02f, 6.89197928e-02f, 1.28311902e-01f,
  7.62500912e-02f, -1.71730034e-02f, -1.22447647e-01f, 1.88870877e-02f, -7.60841221e-02f, 1.48182750e-01f, -1.47078231e-01f, -2.77281906e-02f, -5.19586876e-02f, 7.85098523e-02f,
  9.30629596e-02f, 7.88705274e-02f, -1.18585579e-01f, -3.95902712e-03f, -1.51077034e-02f, 6.97707757e-02f, 2.44660978e-03f, 9.47890803e-02f, 2.26695687e-01f, -1.93263739e-01f,
  9.02824923e-02f, 1.93767220e-01f, 6.76341206e-02f, 9.37050954e-02f, 6.00390956e-02f, 3.98826525e-02f, -8.97100344e-02f, 1.21041387e-01f, 1.37654394e-01f, 1.76028565e-01f,
  1.70125395e-01f, 1.29656956e-01f, -1.08034853e-02f, 1.93232428e-02f, 1.72683865e-01f, 3.99384275e-02f, 1.22644097e-01f, 5.48761524e-02f, 6.32101148e-02f, 1.07313477e-01f,
  -1.37295425e-01f, 8.99407491e-02f, 1.96298018e-01f, 3.26442569e-02f, 9.19979513e-02f, -1.36325464e-01f, 1.40314937e-01f, -7.50039145e-02f, -1.78262908e-02f, 2.87180036e-01f,
  1.50882229e-01f, -1.49324670e-01f, -7.06406683e-02f, -1.86586827e-02f, 2.19159916e-01f, -5.31185977e-02f, -5.11727855e-03f, 5.15381210e-02f, -1.52683808e-02f, -5.09653911e-02f,
  7.19866231e-02f, 1.52916074e-01f, -3.60339694e-02f, 5.87039515e-02f, -1.07182741e-01f, 4.99596000e-02f, -1.28249407e-01f, 1.95082322e-01f, -1.05794646e-01f, 9.19396952e-02f,
  6.93989396e-02f, -1.28481746e-01f, 3.74228619e-02f, -1.47556826e-01f, 1.05133571e-01f, -9.26797688e-02f, 8.03865790e-02f, -1.71796437e-02f, 1.19930372e-01f, 5.87776937e-02f,
  -6.08862489e-02f, 8.37804303e-02f, 2.51759440e-01f, -1.33850977e-01f, -1.70651730e-02f, -8.26123729e-03f, -2.63762891e-01f, -3.18768546e-02f, 5.96529506e-02f, 1.51438713e-01f,
  1.17607877e-01f, 9.10380781e-02f, -9.35164541e-02f, -8.03886205e-02f, 2.27513388e-02f, 7.03787208e-02f, 1.24106191e-01f, 3.42875570e-02f, 4.87628169e-02f, 8.75455365e-02f,
  -1.24147296e-01f, -3.32868919e-02f, 1.35579169e-01f, -2.43574511e-02f, 7.23307580e-02f, -1.49848148e-01f, 5.07760309e-02f, 1.98529512e-01f, -1.46502659e-01f, -5.62392324e-02f,
  2.26883680e-01f, 2.22885888e-02f, 1.31193370e-01f, -3.06288540e-01f, 1.73257127e-01f, 1.61809638e-01f, -9.84997302e-02f, -4.72301394e-02f, 2.62826029e-02f, 3.19773592e-02f,
  4.18828726e-02f, -3.91195938e-02f, -1.23421937e-01f, 1.34629279e-01f, 1.50706530e-01f, -2.98522916e-02f, -8.99836421e-02f, -1.99274853e-01f, 5.90691604e-02f, 6.63167015e-02f,
  4.57451902e-02f, -8.85864943e-02f, 8.74067098e-02f, -1.26131192e-01f, -1.99532926e-01f, -5.80870882e-02f, 2.82537956e-02f, -5.13206422e-02f, -4.55944315e-02f, -5.81615604e-02f,
  1.32861331e-01f, -1.01347372e-01f, 1.25574440e-01f, -9.86052826e-02f, -6.98947534e-02f, -1.81921571e-01f, 1.68423995e-01f, 5.21932095e-02f, 1.15748957e-01f, 6.89859465e-02f,
  1.34783685e-01f, 2.48311907e-01f, -1.81662619e-01f, -1.73960328e-01f, 4.71684374e-02f, -1.11190706e-01f, 1.15201369e-01f, 1.79889634e-01f, 3.64404656e-02f, 1.89947411e-01f,
  -3.96741740e-02f, -1.13273591e-01f, 1.74749941e-01f, -6.02765866e-02f, 5.17268740e-02f, -5.82235828e-02f, 5.48238168e-03f, 1.08428687e-01f, -1.10789262e-01f, 1.12781655e-02f,
  1.61091641e-01f, -1.55264676e-01f, -1.04801707e-01f, -7.20677599e-02f, -6.85713142e-02f, 9.53723490e-02f, -3.19665223e-01f, 2.27344811e-01f, -1.63019955e-01f, 6.60422370e-02f,
  6.14817021e-03f, 1.03826977e-01f, -1.21292487e-01f, -6.36245757e-02f, -2.61549260e-02f, 4.88335267e-02f, 3.71101424e-02f, -2.24514231e-02f, -1.81350201e-01f, 3.04704934e-01f,
  -7.93540571e-03f, 1.77619149e-04f, -4.97863255e-02f, 1.62114739e-01f, -1.83868170e-01f, 1.92091912e-01f, -2.09697902e-01f, 7.59004578e-02f, -1.89871073e-03f, -1.06024772e-01f,
  -2.95116454e-02f, 1.01379544e-01f, -1.53177911e-02f, -1.81780860e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.48314416e-01f, -2.34746113e-02f, -1.04210429e-01f, -1.18244052e-01f, 2.43445076e-02f, 5.63483536e-02f, -8.29785392e-02f, -9.39402953e-02f, -1.15419626e-01f, -2.56303828e-02f,
  -1.17243312e-01f, -2.03643486e-01f, -2.43407264e-01f, -5.51555194e-02f, 1.01969250e-01f, -1.99601308e-01f, -8.92696306e-02f, -7.47375488e-02f, 1.14681341e-01f, -9.89818871e-02f,
  -2.47683004e-02f, -1.52007163e-01f, 7.96786547e-02f, -9.49300453e-02f, 1.62058473e-01f, 6.07527383e-02f, -4.91748750e-02f, -3.60653624e-02f, 1.84728161e-01f, 1.82673097e-01f,
  -2.90317871e-02f, -9.24337655e-02f, -9.11533982e-02f, 2.17601821e-01f, -1.38615295e-01f, 5.66962697e-02f, -4.81331870e-02f, 1.74728315e-02f, -1.51654422e-01f, 1.03571385e-01f,
  1.96250796e-01f, -6.07435703e-02f, -1.21260785e-01f, -3.41618583e-02f, 5.55919670e-02f, -1.79992422e-01f, 7.74143860e-02f, -6.44664913e-02f, 6.86039627e-02f, 1.00569604e-02f,
  8.70855227e-02f, 7.79525414e-02f, 1.25462621e-01f, 1.94566280e-01f, -5.99076739e-03f, 2.45257542e-01f, 9.34484228e-02f, 1.44053847e-01f, -6.35909885e-02f, 2.05912858e-01f,
  1.66853443e-01f, 1.72364265e-01f, 7.93382674e-02f, 3.55977714e-02f, 2.62723137e-02f, 1.77605480e-01f, -4.68136482e-02f, 1.75493553e-01f, -3.21679283e-03f, -5.82603142e-02f,
  8.86455625e-02f, 1.88004464e-01f, 5.66111356e-02f, 4.42375168e-02f, 6.77914396e-02f, 3.44501287e-01f, -3.21755446e-02f, 4.76134419e-02f, -2.43769810e-01f, 1.85775459e-01f,
  2.15398803e-01f, 2.06429705e-01f, -7.47510493e-02f, 1.25344411e-01f, -1.74534440e-01f, 1.39228061e-01f, 8.07939470e-02f, -2.09688872e-01f, -1.31970122e-01f, 2.60120211e-03f,
  2.20601931e-01f, 9.90572348e-02f, 1.08109266e-01f, -1.21472530e-01f, 1.10643424e-01f, -4.60888408e-02f, 2.78985977e-01f, 1.40721574e-01f, -6.96245879e-02f, -3.23572099e-01f,
  7.01213256e-02f, 1.69611588e-01f, -7.83069152e-03f, -2.20103450e-02f, 6.10584281e-02f, 1.00499272e-01f, -2.93503366e-02f, -1.95334554e-01f, -1.17145609e-02f, -1.82624925e-02f,
  1.12610474e-01f, -3.12301636e-01f, 5.55676641e-03f, 1.82367146e-01f, -3.23055148e-01f, 1.52325451e-01f, -1.42400905e-01f, 2.18929172e-01f, -2.03012321e-02f, 4.25812379e-02f,
  1.32192701e-01f, 1.74266234e-01f, 2.96433926e-01f, 2.03903526e-01f, 1.24048717e-01f, -1.98647052e-01f, 1.57681331e-01f, 1.75193489e-01f, -5.62417433e-02f, 6.78383857e-02f,
  -4.80865501e-02f, 6.54009134e-02f, 1.18386544e-01f, -1.14735417e-01f, -4.85477597e-01f, 9.69143957e-02f, -6.73495233e-02f, -1.32429274e-02f, 1.80683896e-01f, -2.16873083e-02f,
  3.02854087e-02f, 1.92509755e-01f, 1.27822578e-01f, -2.07840316e-02f, 7.84813836e-02f, 2.83451658e-02f, 1.76752865e-01f, -3.88181917e-02f, -6.67224750e-02f, 8.75078216e-02f,
  -3.20354640e-01f, 1.02060027e-01f, 1.05546474e-01f, 1.52674928e-01f, 9.33321789e-02f, -4.36531156e-02f, 1.73367441e-01f, 1.18355259e-01f, -2.00752646e-01f, -7.61786401e-02f,
  6.09662868e-02f, 5.51029593e-02f, 1.02682754e-01f, 7.65533894e-02f, -4.50321883e-02f, 1.41427172e-02f, -3.62699665e-02f, -1.71233562e-03f, 1.67291462e-01f, 3.50110233e-02f,
  -5.26393652e-02f, -1.14758603e-01f, 8.40837359e-02f, 8.63233060e-02f, -6.24898961e-03f, -1.20865647e-02f, 1.01660408e-01f, -1.05716810e-01f, -3.77300642e-02f, -1.78307697e-01f,
  2.01127738e-01f, 7.08238035e-02f, 1.50942370e-01f, 8.28939453e-02f, -2.05598660e-02f, -2.74216924e-02f, 4.05780524e-02f, 7.43885785e-02f, 1.20129503e-01f, 1.30363747e-01f,
  2.02758536e-01f, 1.63292214e-01f, 2.06759740e-02f, 1.58904225e-01f, 1.27943456e-01f, 7.47370124e-02f, 1.93429932e-01f, 1.02266364e-01f, 1.89544838e-02f, -6.22726381e-02f,
  -2.17260271e-02f, -1.21155165e-01f, -9.07870382e-02f, 2.13377904e-02f, -1.04629286e-01f, -9.65917110e-03f, 3.17135975e-02f, -4.84100431e-02f, 2.39157360e-02f, -1.58161342e-01f,
  -3.23575325e-02f, 6.70300126e-02f, -1.87804401e-01f, -1.77319627e-02f, -5.26635088e-02f, -8.07878152e-02f, -1.64547831e-01f, 1.54582158e-01f, 1.84081420e-01f, -1.14360832e-01f,
  1.19560257e-01f, -2.16343760e-01f, -1.23805262e-01f, -4.28204201e-02f, 9.77276545e-03f, 1.19407587e-01f, -3.63085449e-01f, -2.41074666e-01f, 7.61383921e-02f, -6.59669712e-02f,
  -8.39632452e-02f, -2.83009596e-02f, 1.07917115e-01f, 5.46865724e-03f, 2.35947490e-01f, -4.81441706e-01f, 3.41732726e-02f, -8.38957913e-03f, 3.01521391e-01f, -3.36823463e-01f,
  2.41285026e-01f, 6.06037453e-02f, -2.59732097e-01f, 4.97414581e-02f, 7.97174126e-02f, 2.39649534e-01f, 2.12135762e-02f, 2.51332790e-01f, 2.41650522e-01f, 2.87330076e-02f,
  6.55309483e-02f, 2.41986915e-01f, -8.63145106e-03f, 1.06297828e-01f, -2.69527100e-02f, 1.87821891e-02f, -1.49181737e-02f, 6.08922914e-02f, 1.38610512e-01f, -5.00421748e-02f,
  9.74998325e-02f, 4.96229306e-02f, 2.81488568e-01f, -2.91901886e-01f, 3.63913067e-02f, 5.26545271e-02f, 3.45492773e-02f, 1.27864152e-01f, 9.84983891e-02f, -1.41291693e-01f,
  -1.96515605e-01f, 1.19406715e-01f, -1.28159612e-01f, -6.24460876e-02f, -1.16325200e-01f, 1.95404217e-01f, 1.02467455e-01f, 2.87667718e-02f, 1.43569455e-01f, 1.06943823e-01f,
  -1.29523491e-02f, -3.89351100e-01f, -1.16767131e-01f, 9.77327079e-02f, -3.67627352e-01f, -1.86178058e-01f, -5.83924800e-02f, 1.64635047e-01f, 1.96776345e-01f, -1.46754801e-01f,
  1.43075675e-01f, -1.74434185e-01f, 1.34160951e-01f, 2.43443236e-01f, 2.53136642e-02f, -4.50233184e-02f, -4.94474322e-01f, 1.14389379e-02f, 1.77082151e-01f, 5.42408228e-02f,
  -1.11983649e-01f, -2.28327028e-02f, 2.25854516e-02f, -5.17852530e-02f, -5.98197766e-02f, 8.47872421e-02f, 2.74347495e-02f, -2.74356045e-02f, -3.53161424e-01f, 6.97140917e-02f,
  7.31166303e-02f, 7.12237507e-02f, 8.29235092e-03f, 5.39112976e-03f, 3.51510011e-02f, -2.04837844e-01f, -1.70582086e-01f, -2.96941489e-01f, -4.13131490e-02f, 8.03669319e-02f,
  1.31830424e-01f, 2.07254782e-01f, 1.51366293e-01f, 3.57993186e-01f, 5.94904497e-02f, 2.24671841e-01f, -1.36287466e-01f, 3.38214397e-01f, 2.03675196e-01f, -7.35094324e-02f,
  -2.81742364e-01f, 6.01259731e-02f, 2.63824239e-02f, -3.65038887e-02f, -9.37334150e-02f, 8.37484449e-02f, -7.93812945e-02f, -8.87111500e-02f, -1.88750047e-02f, 5.44360727e-02f,
  -8.47554728e-02f, 1.04503214e-01f, 2.23211914e-01f, -2.37272419e-02f, -1.19553812e-01f, 1.64669994e-02f, 2.42701843e-01f, 9.66719724e-03f, 6.40665963e-02f, -1.00176275e-01f,
  -8.91679712e-03f, 8.29605088e-02f, -1.08548822e-02f, -2.23927223e-03f, 4.98653390e-02f, -1.87862247e-01f, 1.23115443e-01f, -1.56970397e-01f, 5.71239106e-02f, 4.89924848e-02f,
  -1.48553625e-01f, -7.70138353e-02f, -1.59449518e-01f, -1.05877623e-01f, 2.20204201e-02f, -2.78157601e-03f, 1.91609815e-01f, 8.78210142e-02f, 1.71373457e-01f, -9.00820643e-02f,
  -9.95104462e-02f, -2.74142444e-01f, 8.81772563e-02f, 1.58865884e-01f, 9.21934023e-02f, -4.15660553e-02f, 2.54509151e-01f, -8.87853876e-02f, 2.54382133e-01f, -8.78504664e-03f,
  7.67538399e-02f, -3.17234024e-02f, -2.45396402e-02f, -7.81157762e-02f, 1.77108720e-01f, 2.60332018e-01f, -3.87438573e-02f, 2.79442444e-02f, 2.46829540e-01f, -6.79338574e-02f,
  9.53343511e-02f, -4.60364074e-02f, -5.48542067e-02f, 8.14598203e-02f, -1.71110570e-01f, -4.48386632e-02f, 9.09686536e-02f, 2.01192394e-01f, 1.64427489e-01f, 1.25315681e-01f,
  -1.42190740e-01f, -3.63149084e-02f, -9.62165147e-02f, -6.09662151e-03f, 2.59391423e-02f, 1.45429626e-01f, 5.37843890e-02f, 1.68521509e-01f, -7.22674206e-02f, 1.18997149e-01f,
  6.59863427e-02f, -1.18198581e-01f, 1.38844391e-02f, 2.96395011e-02f, -1.84095278e-02f, 7.40562603e-02f, 3.37615237e-02f, -9.73718911e-02f, 3.87644768e-02f, -1.40180171e-01f,
  2.86121070e-01f, -2.58518487e-01f, 3.04435380e-02f, 1.62231579e-01f, -4.30846959e-02f, -6.28601536e-02f, 1.16251342e-01f, 2.30950892e-01f, 4.80631031e-02f, 1.21476844e-01f,
  5.89363277e-02f, 1.58535704e-01f, 6.27789721e-02f, -1.09655522e-01f, 1.46718755e-01f, -7.85481483e-02f, 5.79415727e-03f, -9.93609875e-02f, 2.45622411e-01f, -1.49332777e-01f,
  1.44805253e-01f, -6.19639158e-02f, 2.23268494e-02f, 6.29322082e-02f, 4.86654975e-02f, 1.66021079e-01f, -1.02439500e-01f, 1.82346597e-01f, 3.02933872e-01f, 2.27830350e-01f,
  5.28577939e-02f, 1.20247692e-01f, 2.61476692e-02f, 2.76031196e-01f, 9.55337435e-02f, -1.90025523e-01f, -3.43590789e-02f, 4.24867496e-02f, -4.42804471e-02f, -1.03349194e-01f,
  1.48556516e-01f, 6.64995238e-02f, -4.31982949e-02f, -4.43995669e-02f, -1.30591810e-01f, -9.91683155e-02f, -1.62709858e-02f, -5.86098656e-02f, 1.38293996e-01f, 1.44632235e-01f,
  -1.87730007e-02f, 9.83836651e-02f, -1.01661484e-03f, -3.64200287e-02f, 2.11524796e-02f, 4.37907837e-02f, -4.66560908e-02f, -2.23736297e-02f, 8.12448338e-02f, -1.43134343e-02f,
  -8.43652636e-02f, -1.95842937e-01f, 1.81230828e-01f, 1.39130428e-01f, 1.70277432e-01f, 7.09612146e-02f, -7.22589996e-03f, 1.41544193e-01f, -1.57576844e-01f, -1.04918435e-01f,
  -1.82359181e-02f, 2.40881890e-01f, 7.34216475e-04f, 2.03832522e-01f, 4.11083028e-02f, 3.51274520e-01f, 8.62353146e-02f, 2.26552840e-02f, 5.05606048e-02f, 1.82468202e-02f,
  -1.13597579e-01f, -9.75158066e-02f, 8.45373794e-02f, -1.36606500e-01f, -1.73140168e-02f, -1.59579739e-01f, -4.55976129e-02f, -1.07671723e-01f, -2.22120415e-02f, -1.86563246e-02f,
  2.48041637e-02f, 2.98818201e-02f, 1.62244380e-01f, 1.40659004e-01f, -5.57348989e-02f, 1.79210573e-01f, -9.75447744e-02f, 1.90313876e-01f, 5.53520881e-02f, 6.30940050e-02f,
  -6.20060675e-02f, 3.58164916e-03f, -1.51336834e-01f, -3.04819405e-01f, 2.37109840e-01f, 6.32041544e-02f, -1.07472660e-02f, -1.31373718e-01f, -3.00208449e-01f, -4.08777952e-01f,
  6.83616251e-02f, -3.38792615e-02f, 7.22972155e-02f, 2.11327553e-01f, 1.15083326e-02f, 6.84351027e-02f, -1.06133685e-01f, 1.28405765e-01f, 5.14829941e-02f, 1.49593815e-01f,
  2.74556041e-01f, -7.01635629e-02f, -5.14608920e-02f, -2.83404533e-02f, -9.21801839e-04f, 6.03053011e-02f, 1.32355466e-01f, 3.06679785e-01f, 1.45441527e-02f, -1.73401147e-01f,
  -6.05793260e-02f, 2.74228722e-01f, 3.29942927e-02f, -6.93226606e-02f, -1.95517644e-01f, 2.19890118e-01f, 1.35739177e-01f, -5.28253429e-02f, 1.07832044e-01f, 2.55320042e-01f,
  2.39175752e-01f, 7.56623596e-02f, 6.03814470e-03f, -2.37738580e-01f, 9.01801512e-02f, 1.37841120e-01f, 1.55124128e-01f, 1.19192541e-01f, 4.85134311e-02f, -3.82137336e-02f,
  -1.58869267e-01f, -8.38192105e-02f, 2.06430629e-02f, 1.22743674e-01f, 6.99263439e-02f, -1.20867394e-01f, 2.49424636e-01f, 2.54942983e-01f, 1.14724360e-01f, 2.58023977e-01f,
  1.78296074e-01f, 3.50824893e-02f, -1.53864473e-01f, 1.15791775e-01f, -2.27672085e-01f, -1.94383278e-01f, -2.78799862e-01f, -1.03142649e-01f, 7.67083392e-02f, 9.52636972e-02f,
  -5.43826446e-02f, -1.47295222e-01f, -6.21887445e-02f, -6.01643547e-02f, -2.96353132e-01f, -1.31067082e-01f, 1.10942401e-01f, 2.52479799e-02f, -1.92732900e-01f, 6.74058273e-02f,
  -1.80150375e-01f, 1.49815097e-01f, 4.00581546e-02f, -2.05074534e-01f, -3.87879647e-02f, -2.06956699e-01f, -8.70828554e-02f, 7.35216588e-02f, 9.49494988e-02f, 1.25735059e-01f,
  9.19992924e-02f, -1.65158764e-01f, 3.56257349e-01f, -2.52311289e-01f, 2.12582752e-01f, 2.79626697e-01f, 2.05466256e-01f, -8.76236409e-02f, -3.40994969e-02f, 8.14420134e-02f,
  -1.37607709e-01f, 2.24680319e-01f, 3.46738696e-02f, 7.58675858e-02f, 2.17203408e-01f, -1.49489492e-01f, 1.26640111e-01f, 7.48955533e-02f, 7.71311671e-02f, 1.25595957e-01f,
  1.04895145e-01f, -1.18881077e-01f, 3.02943766e-01f, -2.12740544e-02f, -6.36516809e-02f, 1.89482853e-01f, 1.12690583e-01f, 1.01914391e-01f, -2.05200225e-01f, 2.40868196e-01f,
  -2.03894436e-01f, -7.63619393e-02f, -5.98802371e-03f, 6.27390966e-02f, 3.18168662e-02f, -1.65006354e-01f, -8.74878839e-02f, -1.37444017e-02f, -1.03597224e-01f, -6.80908486e-02f,
  1.57837242e-01f, -5.55050969e-02f, -1.96283981e-01f, -4.70212176e-02f, 1.83348507e-01f, -1.24122277e-01f, 9.13743079e-02f, -3.10045443e-02f, 2.69764438e-02f, -1.70412153e-01f,
  -1.09874584e-01f, -2.53049433e-02f, -2.16392308e-01f, -1.39871344e-01f, 1.98946357e-01f, 2.07874775e-01f, -1.11139357e-01f, -9.01919231e-02f, 7.40079163e-03f, 1.63918942e-01f,
  -1.81271464e-01f, 4.85080592e-02f, -6.66039437e-02f, 1.34210497e-01f, 6.62440062e-02f, 2.35741302e-01f, -6.44161254e-02f, 8.35658908e-02f, -8.74765515e-02f, 1.26185700e-01f,
  1.37677953e-01f, 1.54885963e-01f, -1.34110777e-02f, 8.43342245e-02f, 1.67069152e-01f, -1.81015134e-02f, -9.33164433e-02f, -1.37451231e-01f, -3.87777835e-02f, -7.29594156e-02f,
  -5.56050315e-02f, -4.01843414e-02f, 2.76266843e-01f, 5.65891787e-02f, -1.28107533e-01f, 1.35743126e-01f, -1.04459263e-02f, -7.44890869e-02f, -1.47351608e-01f, 5.32382876e-02f,
  -7.41663873e-02f, 2.10776869e-02f, -6.29072711e-02f, 3.15202475e-02f, -2.09683478e-02f, -1.53700769e-01f, -2.95790117e-02f, 2.86679640e-02f, -8.67745131e-02f, 1.68321416e-01f,
  1.20590739e-01f, 1.15255788e-01f, -7.41187260e-02f, -8.32798034e-02f, -1.55594856e-01f, -4.09030318e-02f, -2.25684255e-01f, 8.62093121e-02f, 1.82682216e-01f, -5.01333512e-02f,
  2.26170272e-02f, -9.40950811e-02f, 3.22279841e-01f, 6.58426881e-02f, -2.59545930e-02f, 7.70942569e-02f, -4.80356999e-02f, -4.86316532e-02f, 7.53532723e-02f, 2.34144200e-02f,
  -5.37500903e-02f, 4.53816541e-02f, 2.18582913e-01f, 5.65855615e-02f, 6.71564266e-02f, -2.18417525e-01f, -5.10575213e-02f, 1.64336115e-01f, -2.83543587e-01f, 3.09908211e-01f,
  -1.32040933e-01f, 1.36042356e-01f, -8.56769457e-02f, 8.39168951e-02f, 6.78095743e-02f, 5.60544617e-03f, 5.20747975e-02f, -2.34504446e-01f, 2.86502391e-01f, -5.58459572e-02f,
  6.61728680e-02f, -9.85311642e-02f, 1.26985133e-01f, 2.14807943e-01f, -2.71377027e-01f, -6.58582449e-02f, 7.68959224e-02f, 2.32955515e-01f, -3.52692120e-02f, 1.34448305e-01f,
  1.04025520e-01f, 1.72803193e-01f, -1.80839166e-01f, 1.66512445e-01f, 1.75394699e-01f, 4.63209637e-02f, 1.69253245e-01f, -9.88207087e-02f, 1.30428011e-02f, -2.42766105e-02f,
  1.72336817e-01f, 6.83882833e-02f, 1.69978768e-01f, -1.00115836e-01f, 1.43750444e-01f, -7.68460706e-03f, -2.83831388e-01f, -5.01099648e-03f, -1.01800829e-01f, 2.21688509e-01f,
  1.87083870e-01f, -1.10300377e-01f, -3.17425251e-01f, 3.89356315e-02f, -5.60698658e-02f, 2.01886877e-01f, -2.04284683e-01f, 2.00550407e-01f, 1.29450171e-03f, 1.85471609e-01f,
  1.42972991e-01f, -7.49724507e-02f, 4.39228304e-02f, -3.61796677e-01f, -5.40048294e-02f, -7.20415041e-02f, -2.06689760e-01f, 1.38344821e-02f, 1.09915130e-01f, 1.92882478e-01f,
  -4.95045558e-02f, -1.82350904e-01f, 8.03720802e-02f, -1.06206611e-02f, -4.23291931e-03f, 2.41344377e-01f, 3.11992448e-02f, 7.36721791e-03f, -2.68974453e-01f, -1.28573447e-01f,
  2.21521422e-01f, 1.80589288e-01f, -1.20014757e-01f, 1.50423869e-02f, 1.21026868e-02f, -1.53009864e-02f, 9.51942131e-02f, 3.96146961e-02f, -8.32532793e-02f, 2.11090356e-01f,
  -4.72368121e-01f, -6.13369159e-02f, -1.09577395e-01f, -1.69184208e-01f, -7.84132704e-02f, -7.43099749e-02f, -3.35793430e-03f, -3.04837883e-01f, -1.72540769e-01f, -1.94499731e-01f,
  -6.74881935e-02f, -2.46165227e-02f, 2.46265694e-01f, -2.82721873e-02f, 1.04072444e-01f, 2.19202340e-01f, 6.08454421e-02f, -1.90728590e-01f, 6.31118715e-02f, 1.67808205e-01f,
  -2.40678087e-01f, -4.18657735e-02f, -9.83038843e-02f, -1.88037857e-01f, -1.71351749e-02f, -1.54009178e-01f, 1.05278850e-01f, -9.93039226e-04f, 6.21444024e-02f, -1.79657996e-01f,
  2.65136436e-02f, 8.34165290e-02f, 1.96382627e-01f, -7.62262382e-03f, 1.37771675e-02f, 1.51371360e-01f, 9.03378278e-02f, -3.85194868e-02f, -2.55713016e-01f, 1.21311016e-01f,
  -4.95879576e-02f, 1.33410886e-01f, -1.34222388e-01f, 2.14944147e-02f, -2.91317403e-01f, -8.99129286e-02f, -5.12141660e-02f, 3.06196988e-01f, -3.12155008e-01f, 6.74913526e-02f,
  -1.63781911e-01f, 1.30518705e-01f, 5.48766404e-02f, 5.25374934e-02f, -1.11889817e-01f, 2.75733978e-01f, 1.07661061e-01f, 8.20498168e-02f, -1.03130415e-01f, 3.96348298e-01f,
  9.90767479e-02f, -2.75983047e-02f, 1.96527123e-01f, -7.86896516e-03f, -4.70611267e-02f, 1.08046100e-01f, 1.15296960e-01f, 2.51788516e-02f, -1.90485045e-01f, -8.64811912e-02f,
  -7.95413330e-02f, -1.53360916e-02f, 9.88346711e-02f, 3.31281163e-02f, 1.87225655e-01f, -2.70309895e-01f, -1.73639268e-01f, -4.94795926e-02f, -2.97963284e-02f, 1.03365891e-01f,
  1.12821683e-01f, 3.05843890e-01f, 2.63942450e-01f, -2.45310724e-01f, -1.16942786e-01f, 1.66720990e-02f, -1.80404902e-01f, 8.51064697e-02f, 1.64665058e-01f, 3.37157808e-02f,
  -1.81155562e-01f, 1.70255050e-01f, 3.15714697e-03f, -1.52491359e-02f, 1.60147443e-01f, -1.49691746e-01f, 2.15107203e-01f, 2.11560383e-01f, 4.26372476e-02f, 2.31726348e-01f,
  -1.10893436e-01f, -6.62207380e-02f, -7.35194609e-02f, 1.36399284e-01f, -1.25144467e-01f, -8.53303522e-02f, 1.19479582e-01f, 2.23316595e-01f, -2.41154283e-01f, -5.64467721e-02f,
  2.10955352e-01f, -8.47026631e-02f, -4.30102162e-02f, 5.56269698e-02f, -2.09128819e-02f, -2.15629153e-02f, -8.93521234e-02f, -3.15560967e-01f, 1.45508900e-01f, 2.13055253e-01f,
  1.38458312e-01f, 6.58359528e-02f, -2.92081505e-01f, 1.34289727e-01f, -4.76436466e-02f, 2.29626164e-01f, -1.49913996e-01f, 7.86659941e-02f, -9.01251733e-02f, -3.34774673e-01f,
  7.58918300e-02f, 4.03833948e-02f, -1.24092519e-01f, 1.48592204e-01f, -1.29146904e-01f, -2.13969111e-01f, 8.89233425e-02f, -1.62352040e-01f, -7.71144181e-02f, 1.40265405e-01f,
  4.30403113e-01f, 2.69392580e-01f, 7.93200806e-02f, 1.87693223e-01f, 2.65590340e-01f, 1.38782188e-01f, -1.60136178e-01f, 9.80021060e-02f, -1.87759623e-01f, -1.75916880e-01f,
  -1.39087304e-01f, 5.31322733e-02f, 2.97331866e-02f, 2.49669012e-02f, -7.94193819e-02f, -1.55935243e-01f, -1.59624368e-01f, 7.48492628e-02f, -2.68517971e-01f, 8.72764289e-02f,
  6.33887351e-02f, 1.28737733e-01f, -6.87012970e-02f, 1.17631555e-01f, -8.57663453e-02f, 7.95521885e-02f, 3.73299494e-02f, -2.44416833e-01f, -4.22408096e-02f, -1.85775589e-02f,
  -8.14946964e-02f, 1.57100230e-01f, 7.29436576e-02f, -3.91814634e-02f, 1.61998510e-01f, -1.04677998e-01f, 3.14178079e-01f, -1.09126978e-01f, 6.44725189e-02f, 1.64363727e-01f,
  -1.82180982e-02f, 2.25184504e-02f, -2.53287349e-02f, 1.64625049e-01f, -1.57767639e-01f, 1.63328901e-01f, 1.51196584e-01f, 2.30373427e-01f, 7.45550990e-02f, 1.30858108e-01f,
  2.52893895e-01f, 6.52247891e-02f, 1.88658684e-01f, -1.88195277e-02f, 1.14595398e-01f, 2.36191992e-02f, 3.25001359e-01f, -2.14997202e-01f, -3.35057452e-02f, 6.46444038e-02f,
  -1.04258843e-01f, 4.51508984e-02f, -2.03431115e-01f, 3.51457782e-02f, -2.01966032e-01f, -2.21029110e-03f, 1.70824409e-01f, -6.39399588e-02f, -3.54270115e-02f, -2.75053173e-01f,
  -1.31992832e-01f, -9.57810208e-02f, 1.49938345e-01f, 2.03956932e-01f, 1.75998464e-01f, 1.36679441e-01f, -4.11226079e-02f, 7.65177533e-02f, 9.83736664e-02f, 1.89480484e-01f,
  5.52698337e-02f, -1.26018047e-01f, 1.07457049e-01f, 8.23048949e-02f, 1.57946140e-01f, 5.42197488e-02f, -7.75296018e-02f, 1.62437394e-01f, 9.94876996e-02f, 1.96189098e-02f,
  -1.05623804e-01f, 6.86684698e-02f, 1.29293010e-01f, -2.95726862e-02f, -1.37512677e-03f, -2.29153614e-02f, 1.93561204e-02f, 2.89710723e-02f, -1.71931952e-01f, 2.27834195e-01f,
  1.57099739e-02f, 2.32256472e-01f, -1.67706609e-01f, -2.66563836e-02f, 1.07511424e-01f, 1.88250482e-01f, 2.65071169e-02f, 6.58994121e-03f, 1.01632558e-01f, -1.02301560e-01f,
  2.29733393e-01f, 6.98018596e-02f, 1.30237699e-01f, 7.25626871e-02f, 2.79382784e-02f, 6.42844066e-02f, -8.66414513e-03f, 1.92030981e-01f, -8.60211477e-02f, -4.47314084e-02f,
  -1.50003895e-01f, -2.94304756e-03f, 3.46755348e-02f, 1.70932785e-02f, 2.87221652e-02f, 4.19668015e-03f, 2.28160441e-01f, -7.34400675e-02f, 1.14588343e-01f, -1.78275034e-01f,
  -5.75282127e-02f, -1.14809349e-02f, -7.44421557e-02f, 1.32761732e-01f, 9.54589918e-02f, -5.95795549e-03f, -9.18844640e-02f, 1.40430070e-02f, 1.21835291e-01f, 1.32082671e-01f,
  1.50078222e-01f, -9.80093777e-02f, 2.08779022e-01f, 1.10027008e-01f, 1.06236354e-01f, 3.72972712e-02f, 2.60858119e-01f, 1.48933768e-01f, 1.05664767e-01f, 6.00910224e-02f,
  4.13777567e-02f, -1.81333069e-02f, -5.10957725e-02f, -6.50518341e-03f, -1.34425029e-01f, 1.77867845e-01f, 1.31305024e-01f, 2.41697952e-01f, 1.34181648e-01f, 3.26504111e-02f,
  -5.53861856e-02f, 3.17716636e-02f, 3.28366160e-02f, -3.77357863e-02f, -4.87180024e-01f, -2.75887519e-01f, 2.46471316e-01f, -1.90240368e-01f, -4.20819186e-02f, 3.61991511e-03f,
  1.91450328e-01f, -7.09143281e-02f, 1.12221554e-01f, -6.60724491e-02f, -9.35313776e-02f, -4.96652015e-02f, -2.07306921e-01f, -9.21450630e-02f, -1.32603690e-01f, -1.09799653e-01f,
  -9.29096714e-02f, -1.55238017e-01f, -5.32274917e-02f, 1.07389987e-02f, -2.28931963e-01f, 1.57037497e-01f, 3.41759436e-02f, -1.65188268e-01f, 1.18730746e-01f, -6.15591742e-03f,
  -1.73161820e-01f, -1.15057923e-01f, -1.67270020e-01f, -9.20645595e-02f, 1.84277609e-01f, 1.10851768e-02f, 1.51020750e-01f, 7.44308531e-02f, -3.43888491e-01f, 5.62767200e-02f,
  -1.85306184e-02f, -1.26529142e-01f, 2.84580700e-02f, -5.32354936e-02f, -1.19406417e-01f, -1.24205433e-01f, 1.76654048e-02f, -2.55605001e-02f, -2.86394376e-02f, -2.17441067e-01f,
  1.50293009e-02f, -1.21129649e-02f, -1.03700012e-01f, 1.79002900e-02f, -3.98737639e-01f, -7.43978694e-02f, 3.91363204e-02f, 1.33967936e-01f, -1.85143873e-02f, 1.41265631e-01f,
  5.69023564e-02f, -4.25555520e-02f, -1.17599972e-01f, -8.74028355e-02f, -9.68765616e-02f, 9.49602127e-02f, -2.82722502e-03f, 3.41266364e-01f, -1.84008852e-01f, -2.97884550e-02f,
  -1.79271385e-01f, -5.39399944e-02f, -3.14146541e-02f, 4.11599949e-02f, 1.41073242e-01f, -1.44637018e-01f, -2.89434660e-02f, -8.18813443e-02f, 2.28618830e-01f, -3.19521576e-02f,
  -7.89208338e-02f, -2.12933168e-01f, -1.98233221e-02f, -5.31179905e-02f, 1.39847875e-01f, 1.77327827e-01f, -1.29638538e-01f, 4.67940494e-02f, 2.30526254e-02f, -5.81648536e-02f,
  7.82022774e-02f, -2.68707499e-02f, 1.09265074e-01f, -1.36199212e-02f, 2.07410440e-01f, -1.75729394e-01f, -3.91119532e-02f, -2.04322800e-01f, -1.47484660e-01f, 6.31242618e-02f,
  8.85758102e-02f, 1.73123911e-01f, -5.81316575e-02f, 3.74972254e-01f, -1.14992835e-01f, -2.58165568e-01f, -6.58178926e-02f, 9.25976560e-02f, -1.27579495e-01f, 7.19914585e-03f,
  1.16430417e-01f, -4.94228601e-02f, 1.83762386e-01f, 1.45925060e-01f, -1.40802473e-01f, -3.85592058e-02f, 3.01944036e-02f, -1.27823099e-01f, -3.19779515e-02f, -1.64406791e-01f,
  4.40947674e-02f, 4.63262312e-02f, -3.99595052e-02f, 1.46770820e-01f, 9.88255139e-04f, 7.89137706e-02f, 4.54169773e-02f, -4.02884707e-02f, -1.31881356e-01f, 3.32638547e-02f,
  3.61561514e-02f, -5.12921736e-02f, -2.79437035e-01f, -1.60786897e-01f, 2.47612596e-01f, -7.31691644e-02f, -9.69631076e-02f, 1.34171592e-02f, -3.11935991e-01f, -4.00377922e-02f,
  -9.21571478e-02f, 1.60709947e-01f, -1.95371106e-01f, -1.62264407e-01f, -1.90992653e-01f, 2.14070338e-03f, 1.26488104e-01f, -8.70254263e-02f, -1.73816964e-01f, -7.41007924e-02f,
  -4.89736497e-02f, -2.61209980e-02f, -3.74757983e-02f, 6.16659084e-03f, 2.31888145e-01f, -1.12026684e-01f, -9.95915309e-02f, -4.33448777e-02f, -1.42103225e-01f, -4.58853953e-02f,
  -1.03678055e-01f, 6.31451793e-03f, -1.47981077e-01f, 8.06069747e-03f, 2.33077034e-02f, -1.08704917e-01f, -3.33098531e-01f, 1.32699952e-01f, -1.70628168e-02f, 1.53938979e-01f,
  1.78375661e-01f, -2.15733528e-01f, 6.59589916e-02f, -5.98760508e-03f, 2.20879585e-01f, -1.93133771e-01f, 1.12162881e-01f, -1.31561831e-01f, 2.34872892e-01f, -2.89212018e-01f,
  1.78441107e-01f, 1.42212749e-01f, -1.50601521e-01f, 2.60499399e-02f, 1.85244292e-01f, 9.79462862e-02f, 1.02748200e-01f, -1.12923607e-01f, 1.66124374e-01f, 1.34690851e-01f,
  -1.34583741e-01f, 4.31164317e-02f, -1.59396231e-01f, -4.15268764e-02f, 7.04026967e-02f, 1.74466427e-02f, -1.01059936e-01f, 1.03732310e-02f, -6.84487075e-02f, 1.36559099e-01f,
  6.77575916e-02f, 7.34775839e-03f, -3.23442310e-01f, 1.41073063e-01f, 1.32398307e-01f, 1.24868438e-01f, -9.06279609e-02f, 1.16459765e-01f, -1.15630232e-01f, -1.33616641e-01f,
  3.56759764e-02f, -1.11141481e-01f, 2.33551487e-01f, -3.97076160e-02f, 4.73758206e-02f, -5.40308096e-02f, 1.69658940e-02f, 3.58486213e-02f, -1.33033246e-01f, 1.43084645e-01f,
  1.70236170e-01f, 2.08496958e-01f, -9.46788397e-03f, 6.94780946e-02f, 2.55334005e-02f, 2.94106632e-01f, -2.18285178e-03f, 1.57588020e-01f, -2.23569591e-02f, 6.39199093e-02f,
  -1.74555138e-01f, 8.56673643e-02f, 2.14699954e-01f, -1.45851716e-01f, 1.68572031e-02f, 4.96652760e-02f, 1.37487590e-01f, 1.05710909e-01f, -1.84716831e-03f, 2.03006074e-01f,
  -1.57624438e-01f, -3.88971828e-02f, -3.69033702e-02f, -3.95098515e-03f, -5.56241013e-02f, 2.52985090e-01f, -1.77123860e-01f, -6.17957814e-03f, -2.10667700e-01f, 1.82522073e-01f,
  -7.25789443e-02f, -1.98093295e-01f, 1.41410530e-01f, -2.28425190e-01f, -1.21817023e-01f, 1.36309713e-01f, 1.06405653e-01f, 9.66482311e-02f, -2.26204246e-01f, -8.21146145e-02f,
  3.07440042e-01f, -1.87084049e-01f, 2.30813259e-03f, 3.00252438e-02f, 5.28215766e-02f, 4.71948683e-02f, 8.41684714e-02f, -2.42291525e-01f, 1.65683061e-01f, -1.34851024e-01f,
  2.39099458e-01f, -1.89589575e-01f, 1.57002002e-01f, -1.50964633e-01f, -1.54584065e-01f, 2.72640809e-02f, 2.45129555e-01f, 1.05049171e-01f, 1.45368680e-01f, 6.01810664e-02f,
  2.96783209e-01f, -1.21851057e-01f, 1.73897937e-01f, 7.50898644e-02f, 8.65988955e-02f, 1.77299343e-02f, -3.37772034e-02f, -3.95431854e-02f, 1.88522771e-01f, -1.10565163e-02f,
  -8.55308026e-02f, 1.80246364e-02f, 7.98403695e-02f, 9.06710997e-02f, 2.27995187e-01f, 8.82676020e-02f, -1.44605055e-01f, -9.84420851e-02f, -2.14327782e-01f, -8.88098702e-02f,
  -9.22733247e-02f, 1.13281988e-01f, -5.64237535e-02f, 8.90236720e-02f, 1.62127733e-01f, 2.28778556e-01f, -1.08895972e-01f, -6.67459220e-02f, 2.54839454e-02f, 1.01088420e-01f,
  1.45664200e-01f, -1.45215750e-01f, 5.60550950e-02f, 3.72572546e-03f, -6.31667627e-03f, 1.89840913e-01f, 5.97313158e-02f, 8.79032090e-02f, 1.66135445e-01f, 1.14997685e-01f,
  5.73769622e-02f, 1.14455141e-01f, -4.62745316e-02f, -1.96046293e-01f, 5.33643365e-02f, -2.16194302e-01f, 2.25850657e-01f, 1.03453487e-01f, 4.84595783e-02f, 2.69207619e-02f,
  -2.03666347e-03f, 4.54669371e-02f, 1.28450647e-01f, 1.40394330e-01f, -1.82945445e-01f, -1.10438071e-01f, -1.55979730e-02f, 5.33915497e-02f, -4.02220554e-04f, -1.16177453e-02f,
  -7.72413015e-02f, -1.57319099e-01f, 1.71935186e-02f, -1.62892371e-01f, 1.84237704e-01f, 1.50336370e-01f, -2.20696665e-02f, 7.06184357e-02f, 1.21075541e-01f, 7.25237653e-02f,
  -2.64012367e-01f, 1.83855385e-01f, -6.45071268e-02f, -1.65667618e-03f, -5.32408878e-02f, 1.05319142e-01f, 4.86460718e-04f, 1.81045249e-01f, 2.75195576e-02f, -2.58903578e-02f,
  -1.39145136e-01f, -4.62147035e-02f, 4.81263436e-02f, -1.55912980e-01f, -9.71179307e-02f, -1.09535649e-01f, 1.71451539e-01f, -1.80431649e-01f, -2.79038474e-02f, -5.29485047e-02f,
  2.24127337e-01f, -4.56553131e-01f, 7.43184984e-03f, 7.23956749e-02f, -6.85048699e-02f, -1.12336084e-01f, -6.36563152e-02f, 8.00502952e-03f, 1.77697852e-01f, 3.55939865e-02f,
  1.45219624e-01f, 4.08806726e-02f, 1.03466364e-03f, -1.81072801e-01f, -2.06219435e-01f, 2.76921183e-01f, -2.00642154e-01f, 1.54525474e-01f, 3.03681474e-02f, 1.23600662e-02f,
  -1.90079123e-01f, 1.27908522e-02f, 6.38656542e-02f, 9.92087573e-02f, -1.39639869e-01f, -4.10308897e-01f, 2.01631542e-02f, -6.90404251e-02f, -1.29033834e-01f, -2.04950273e-01f,
  2.62711681e-02f, -7.46411309e-02f, -2.29967415e-01f, -7.49635771e-02f, 1.58529744e-01f, 3.27089839e-02f, 4.13717702e-02f, 2.17853040e-01f, 1.63380682e-01f, 6.75878003e-02f,
  -3.43213677e-01f, -1.60631072e-02f, 1.68417752e-01f, 7.55009428e-02f, -4.96081933e-02f, 2.10142694e-02f, -1.33601367e-01f, 9.33748856e-02f, -3.33276272e-01f, 1.33853316e-01f,
  -4.74436954e-02f, 8.32690969e-02f, -4.44250815e-02f, 3.15361977e-01f, -3.06064129e-01f, -3.52443531e-02f, -2.38356218e-02f, -3.33071798e-01f, 1.38526812e-01f, -2.85228863e-02f,
  1.77422091e-01f, -7.63843134e-02f, -1.52716398e-01f, -1.93810672e-01f, 3.06334794e-01f, -1.77222908e-01f, 2.27317233e-02f, 2.01093674e-01f, 2.76707914e-02f, 1.68882921e-01f,
  -1.17854692e-01f, 1.57299489e-01f, 2.59435792e-02f, 5.98188266e-02f, 1.03261657e-01f, 1.31168902e-01f, -1.95639906e-03f, 4.38495204e-02f, -2.13897482e-01f, 1.67620420e-01f,
  -1.66256070e-01f, 3.71993221e-02f, -4.24098149e-02f, -1.30977929e-01f, 3.28144059e-02f, 1.53604910e-01f, 2.30160225e-02f, -1.41569361e-01f, 6.70254081e-02f, -4.22775038e-02f,
  2.39021465e-01f, 4.38104458e-02f, -9.11195204e-02f, -9.23651159e-02f, 8.57948046e-03f, -3.44945937e-02f, 7.48252645e-02f, -2.61709481e-01f, 6.77633733e-02f, -2.93118265e-02f,
  8.03697854e-02f, 8.80956501e-02f, 1.76220447e-01f, 2.49927402e-01f, -5.14819801e-01f, 1.24906167e-01f, 4.43505980e-02f, 1.32760420e-01f, -2.53482193e-01f, -6.36176765e-02f,
  -1.07469030e-01f, 8.67343799e-04f, 6.03660718e-02f, 4.43238951e-02f, 1.57228723e-01f, 3.63549031e-02f, 7.30236620e-02f, -3.01665843e-01f, 3.33218247e-01f, 1.46993950e-01f,
  1.86598718e-01f, 3.95848840e-01f, 9.09245908e-02f, 5.44126928e-02f, -1.11814499e-01f, 3.28874320e-01f, 1.36057496e-01f, -2.65891198e-02f, 1.59022942e-01f, 1.73387021e-01f,
  -1.92927614e-01f, 1.71774402e-01f, -9.42480564e-02f, 1.09934904e-01f, 5.82848564e-02f, 1.10238545e-01f, 8.72127861e-02f, -1.16228104e-01f, -8.72863159e-02f, -8.97660106e-02f,
  6.84545934e-03f, -1.06765302e-02f, 4.23530303e-02f, -9.40224305e-02f, -1.46861881e-01f, -9.98583063e-02f, 2.45941412e-02f, -1.04309142e-01f, 8.12135115e-02f, -1.63628891e-01f,
  1.21408880e-01f, 9.86247584e-02f, 3.50354075e-01f, -8.00947472e-02f, -1.10916071e-01f, -3.71211134e-02f, 2.51204908e-01f, -2.10165665e-01f, -5.20386919e-02f, -5.72323799e-02f,
  -2.07381442e-01f, 7.54548907e-02f, 6.03156053e-02f, 2.52771825e-01f, -6.98175281e-02f, 1.65613785e-01f, -1.27432644e-01f, 4.52314354e-02f, 2.12987542e-01f, 8.66764188e-02f,
  1.63755313e-01f, 7.44460803e-03f, -8.50804746e-02f, 1.94633752e-02f, 5.19359261e-02f, -8.10069218e-03f, -6.08406402e-02f, 2.06147864e-01f, -6.43419102e-02f, 3.79958637e-02f,
  4.36458401e-02f, 2.99182326e-01f, -5.53005561e-02f, -2.57931978e-01f, -3.00379336e-01f, 9.62481797e-02f, -7.52588958e-02f, 1.49752840e-01f, -8.47501680e-02f, -5.93291223e-02f,
  -1.13555774e-01f, -1.22762688e-01f, 1.48376629e-01f, -4.05304767e-02f, 9.85510275e-02f, 9.04097408e-02f, 3.26316878e-02f, 1.33590207e-01f, -1.35423407e-01f, -9.27485079e-02f,
  -1.09878086e-01f, 1.05014428e-01f, -1.90399773e-02f, -2.94866841e-02f, 9.49456915e-02f, 9.71301943e-02f, -4.38736975e-02f, 1.24495551e-01f, -9.38510895e-02f, 4.87787537e-02f,
  5.33144213e-02f, -2.46290669e-01f, -8.28392133e-02f, 1.38996124e-01f, 1.34329915e-01f, 7.00599002e-03f, -2.07691386e-01f, -8.61798003e-02f, 1.98950142e-01f, -9.81709361e-02f,
  3.75314429e-02f, 1.85928583e-01f, 1.26621187e-01f, 2.68354625e-01f, -1.15518942e-01f, -1.65679857e-01f, -1.22677526e-02f, 6.13118336e-02f, 2.33224690e-01f, 1.00537367e-01f,
  2.17308804e-01f, 3.37460376e-02f, -1.16661273e-01f, 3.99600156e-02f, 1.41099557e-01f, 1.17720775e-02f, -1.02886848e-01f, -5.75506128e-02f, 1.49973916e-04f, 9.95728597e-02f,
  3.01167428e-01f, 1.25643641e-01f, 8.43779743e-02f, -1.65299714e-01f, 2.27040857e-01f, -1.12715073e-01f, 2.75259048e-01f, 2.45208606e-01f, 1.19047605e-01f, 3.07816565e-01f,
  2.22341135e-01f, 1.99101821e-01f, -1.10680342e-01f, 1.87789470e-01f, 7.16237947e-02f, -1.63868323e-01f, 8.92470032e-02f, -1.63218230e-02f, 4.93893884e-02f, -3.50542068e-02f,
  8.88670310e-02f, 9.95836630e-02f, 9.45815966e-02f, -8.58446285e-02f, 1.48959979e-01f, -2.02841431e-01f, 8.26944336e-02f, -1.97474241e-01f, -1.97739173e-02f, 1.46009892e-01f,
  2.02660471e-01f, -1.35062501e-01f, 1.07655302e-01f, -1.14979491e-01f, 6.99959919e-02f, 1.97598502e-01f, 7.86768124e-02f, -1.44303171e-02f, -7.10688680e-02f, 1.10169351e-01f,
  3.09037805e-01f, 7.29085729e-02f, -2.24427074e-01f, -3.70419510e-02f, 6.38819858e-02f, 5.38026355e-02f, 7.23203719e-02f, 1.17902584e-01f, -1.43480152e-01f, -1.78451359e-01f,
  5.01165949e-02f, 4.17570136e-02f, 5.01228534e-02f, 1.34592354e-01f, -1.50924087e-01f, -1.51183143e-01f, 8.65610167e-02f, -1.07276902e-01f, 8.06243196e-02f, -1.63795888e-01f,
  -6.17123321e-02f, 1.44662067e-01f, 2.90205926e-01f, 8.85465369e-02f, 3.40731174e-01f, 3.01299933e-02f, 2.53768712e-01f, 2.71904264e-02f, -1.38118798e-02f, -1.22678064e-01f,
  -2.64051110e-01f, -1.05608709e-01f, 1.50546879e-01f, -3.35968658e-02f, -1.24326814e-02f, 4.03591953e-02f, 1.21197201e-01f, 9.38556567e-02f, 2.42907807e-01f, 3.54877591e-01f,
  -5.77185787e-02f, -3.69144902e-02f, -1.01445563e-01f, 3.68402824e-02f, -8.84706303e-02f, -7.52127767e-02f, 1.37533545e-01f, 1.05452493e-01f, 1.93866432e-01f, -1.75060868e-01f,
  1.13999732e-02f, -2.19523292e-02f, -1.24076746e-01f, 1.71814218e-01f, -3.85020599e-02f, 1.16803259e-01f, 2.46316478e-01f, -2.22324684e-01f, 2.18269259e-01f, 2.87120342e-01f,
  2.59802043e-01f, 3.65381576e-02f, 2.52552461e-02f, 5.10206930e-02f, 1.49616659e-01f, 2.12279961e-01f, 5.74941151e-02f, 3.79207194e-01f, -2.29899228e-01f, 6.61486834e-02f,
  -2.79189926e-02f, 1.73667744e-02f, 2.61885673e-01f, 2.31267005e-01f, 8.23070332e-02f, -7.95351863e-02f, -5.20739444e-02f, -6.64336756e-02f, -8.19185302e-02f, 1.83276430e-01f,
  -9.45186540e-02f, 1.21702559e-01f, 1.44298539e-01f, 1.02858637e-02f, 2.14965884e-02f, 2.90915400e-01f, -1.13978133e-01f, -1.00148749e-02f, 2.64480594e-03f, -1.41655669e-01f,
  -1.97336644e-01f, -1.17035781e-03f, 6.46717101e-02f, 7.26458281e-02f, 5.95639572e-02f, 3.01367138e-02f, -4.92311688e-03f, 7.68555179e-02f, -1.57179423e-02f, 1.64065026e-02f,
  -6.42184839e-02f, 1.27773181e-01f, -3.95595981e-03f, 6.20015115e-02f, 3.86090912e-02f, 2.15286881e-01f, 1.84295878e-01f, -4.17249873e-02f, 6.03595488e-02f, 1.51574001e-01f,
  1.48680985e-01f, 1.32264048e-01f, -9.94681939e-02f, 1.18808918e-01f, 9.65424404e-02f, -3.48917471e-04f, 9.73547846e-02f, -9.06149521e-02f, 8.77598599e-02f, 9.81169641e-02f,
  -1.31656170e-01f, 1.90621883e-01f, -1.72876358e-01f, 1.72640428e-01f, -1.34324774e-01f, -2.47027744e-02f, 8.78500789e-02f, 1.67342037e-01f, -2.05955923e-01f, -1.05574816e-01f,
  3.44489375e-03f, -4.13084365e-02f, 1.83240384e-01f, 1.32243022e-01f, 4.56293346e-03f, -5.32876067e-02f, -1.09313272e-01f, 9.60464254e-02f, -4.12623100e-02f, 2.06880137e-01f,
  -1.64388075e-01f, 1.58906624e-01f, -1.22106560e-01f, 1.34130910e-01f, 3.48234683e-01f, -3.41797210e-02f, 1.46606222e-01f, 4.09446331e-03f, 2.80026495e-01f, -5.01735806e-02f,
  -1.16293900e-01f, 1.95845947e-01f, -2.83693880e-01f, -1.82742015e-01f, -2.48501465e-01f, -1.76967785e-01f, 3.59546803e-02f, 1.35135585e-02f, -4.85507306e-03f, 2.03612819e-01f,
  -2.73784492e-02f, -4.89490181e-02f, 1.20446339e-01f, 1.62601739e-01f, -2.25103963e-02f, 6.32808805e-02f, 1.32555157e-01f, 1.44208148e-02f, 2.32574284e-01f, 1.09884134e-02f,
  1.09240524e-02f, -3.58072948e-03f, 1.70201033e-01f, 1.14045069e-01f, 2.94279307e-02f, 1.98536664e-01f, 1.16961360e-01f, -4.89540361e-02f, 1.10147864e-01f, 3.60563472e-02f,
  1.85321674e-01f, -1.29988432e-01f, 3.84454168e-02f, -1.20224342e-01f, -1.41613111e-01f, -3.58117782e-02f, -8.29455331e-02f, 1.38627753e-01f, -1.54976696e-02f, 3.17917131e-02f,
  1.74259812e-01f, 5.74227348e-02f, -4.79822978e-02f, 4.40959409e-02f, -8.19116086e-02f, -5.55404909e-02f, 1.83839574e-02f, 9.79776382e-02f, 4.47191596e-02f, 1.35611266e-01f,
  -3.43304239e-02f, 6.33469364e-03f, -3.26219536e-02f, -1.06711239e-01f, 1.46964371e-01f, -9.63562867e-04f, -1.23997733e-01f, -3.95259325e-04f, -6.13764338e-02f, -3.48475352e-02f,
  -2.49869898e-02f, 1.99844837e-02f, -8.91777277e-02f, 3.70598398e-02f, 1.88771367e-01f, 6.11860976e-02f, 5.92887495e-03f, 4.41857576e-02f, 1.37531489e-01f, -6.82371184e-02f,
  -1.32512361e-01f, -4.09649819e-01f, -9.84189138e-02f, 5.89344874e-02f, 1.80741832e-01f, -6.49245456e-02f, 1.21265471e-01f, 3.92052084e-02f, 5.12080379e-02f, -4.17748746e-03f,
  3.81109416e-02f, 2.26880554e-02f, -1.12700444e-02f, 3.69366165e-03f, -6.70437217e-02f, 1.86974537e-02f, -8.59462693e-02f, 1.82073757e-01f, 1.52384281e-01f, 9.35996696e-02f,
  -5.67989796e-02f, -1.09088458e-01f, -1.72303498e-01f, -9.77701158e-04f, -6.35353327e-02f, 1.36286626e-02f, 7.49156326e-02f, -1.22188814e-01f, 1.51645869e-01f, 4.33386825e-02f,
  1.94181889e-01f, 1.40657842e-01f, 1.49613336e-01f, -3.80564220e-02f, 1.74879413e-02f, -3.24795023e-02f, 2.80174196e-01f, 3.10107023e-01f, 7.55477250e-02f, 1.38673112e-02f,
  -5.55979013e-02f, -1.04621937e-02f, 1.63374562e-02f, 5.12198023e-02f, -1.53039331e-02f, 9.25606396e-03f, 1.17861912e-01f, -2.00834364e-01f, -5.80359176e-02f, -1.82757109e-01f,
  4.33402695e-02f, 2.19772309e-02f, -1.87734604e-01f, 7.68730715e-02f, 1.38714630e-02f, -5.00269979e-02f, -2.09903687e-01f, 7.25298896e-02f, 4.92506055e-03f, 4.74396460e-02f,
  -1.27952829e-01f, -1.91737548e-01f, 3.97228263e-02f, -1.76567495e-01f, -1.80784598e-01f, 2.16318294e-02f, -6.09445013e-02f, 3.48935015e-02f, -1.40139386e-01f, -2.32320294e-01f,
  -1.92534670e-01f, -9.43059102e-02f, 1.31608754e-01f, -1.22976929e-01f, -2.58545503e-02f, 1.43033057e-01f, 1.56150073e-01f, 1.59532875e-02f, -1.60218566e-03f, 4.25525904e-02f,
  -4.37563285e-02f, -2.01791935e-02f, 2.13524893e-01f, 1.39528468e-01f, 2.63275634e-02f, -9.14333761e-02f, -6.04455471e-02f, 5.82896248e-02f, 5.51902875e-02f, 3.51320282e-02f,
  6.49664924e-02f, 5.11688925e-02f, -4.77218777e-02f, -1.48114245e-02f, -1.25985779e-02f, 2.18487307e-02f, -5.40800244e-02f, 2.14172706e-01f, 9.17621404e-02f, 1.36735648e-01f,
  -5.60824983e-02f, 8.15362930e-02f, -5.32238074e-02f, -1.13161758e-01f, 3.14065292e-02f, -1.13147005e-01f, -1.11992238e-02f, -1.14867315e-01f, 1.47623241e-01f, 7.59547725e-02f,
  5.59034310e-02f, 4.88524586e-02f, 1.03303529e-01f, 1.03924952e-01f, 1.62439421e-01f, 8.05963129e-02f, -5.85600249e-02f, 1.89148024e-01f, 1.49629101e-01f, 2.05537215e-01f,
  1.41445011e-01f, 7.20988959e-02f, -7.28352414e-03f, 6.98458999e-02f, 6.18312135e-02f, 2.79495180e-01f, 6.53651431e-02f, -4.30012420e-02f, -1.01154447e-01f, 1.39240265e-01f,
  -8.11160877e-02f, -1.56455189e-01f, -4.09696735e-02f, 1.64140791e-01f, -1.44995481e-01f, 2.57970452e-01f, 4.55898866e-02f, -1.01939015e-01f, -8.23190901e-03f, -1.32782325e-01f,
  7.96065852e-02f, -6.17618747e-02f, -6.33836165e-02f, 1.72567353e-01f, -1.10026048e-02f, -1.49783539e-02f, -4.83325794e-02f, 8.69163126e-02f, 1.06838822e-01f, -7.92419687e-02f,
  1.39201910e-03f, -3.18468362e-03f, 1.03911176e-01f, 4.52437997e-02f, 9.67379212e-02f, 9.30768251e-02f, -2.14777768e-01f, 2.43348524e-01f, 1.18409112e-01f, -2.27065384e-02f,
  -1.80898994e-01f, 1.65782243e-01f, 1.10241517e-01f, 2.30621006e-02f, 1.15499772e-01f, -2.11150438e-01f, 1.79989427e-01f, 1.08412094e-01f, 1.45320445e-01f, 1.77681297e-02f,
  1.93830147e-01f, 1.78012952e-01f, -2.30076194e-01f, -1.42148674e-01f, 8.48371089e-02f, 1.95981368e-01f, 2.39577889e-01f, 1.77031413e-01f, 8.78497884e-02f, -1.03371382e-01f,
  -2.19851881e-02f, 8.52329582e-02f, 1.32220361e-04f, 6.78130006e-03f, -4.18436565e-02f, 1.21793792e-01f, -4.72315587e-02f, -6.62443340e-02f, 6.69606552e-02f, -1.92243546e-01f,
  -1.34557530e-01f, -1.41364381e-01f, 6.17302023e-02f, 4.14371751e-02f, -8.14016461e-02f, 1.78452507e-01f, 6.88199252e-02f, 1.88278198e-01f, 2.18045980e-01f, 1.34432361e-01f,
  -1.82725370e-01f, 2.64478207e-01f, 2.39386752e-01f, -1.99376158e-02f, 7.69442245e-02f, 1.80347666e-01f, 1.30493283e-01f, 5.96521534e-02f, -1.67034734e-02f, -1.12341819e-02f,
  -9.59241241e-02f, 5.06157577e-02f, -8.05150494e-02f, 1.16223112e-01f, -2.95422021e-02f, 1.23332322e-01f, -3.46484333e-02f, -3.65700051e-02f, 5.20471111e-02f, -6.04967121e-03f,
  -1.76746562e-01f, 1.21269830e-01f, -3.98414940e-01f, -1.44597748e-03f, 1.47149995e-01f, -2.41065562e-01f, 1.24626927e-01f, 4.49504405e-02f, 2.47521382e-02f, 1.23073898e-01f,
  3.85506786e-02f, -3.50418128e-02f, -3.33970860e-02f, 1.05229393e-01f, -8.18577036e-02f, 1.32411793e-01f, -1.10918514e-01f, 3.06084692e-01f, -6.86622560e-02f, 7.47656971e-02f,
  -2.06569582e-02f, -5.27952611e-02f, -2.75326639e-01f, 3.42226811e-02f, 1.82689190e-01f, 3.81560773e-02f, 1.29262850e-01f, -5.25471605e-02f, 1.78381160e-01f, 1.26674965e-01f,
  1.25364929e-01f, 4.02536750e-01f, 1.13140099e-01f, 2.71896750e-01f, 1.81294680e-01f, 1.39039800e-01f, 1.23626940e-01f, 1.80829629e-01f, -1.33266196e-01f, 9.73578095e-02f,
  -5.03411554e-02f, -1.21757984e-01f, 5.92877008e-02f, 1.31848738e-01f, -1.46955969e-02f, -5.70199750e-02f, 1.90403506e-01f, 4.50825214e-01f, -1.07917815e-01f, 1.79634113e-02f,
  -2.74669733e-02f, -6.35821447e-02f, 3.05847544e-03f, 3.29184085e-02f, 7.19097406e-02f, 1.08763933e-01f, 3.06662738e-01f, -1.63581580e-01f, -1.08198345e-01f, -5.14301732e-02f,
  1.03593692e-01f, 1.00926355e-01f, 1.17593035e-01f, 9.15860906e-02f, 2.15512365e-02f, -2.43091792e-01f, 2.66969025e-01f, 2.21865058e-01f, 3.60019684e-01f, 2.16994673e-01f,
  9.60747823e-02f, 1.97906539e-01f, -7.86854699e-02f, -9.68931690e-02f, -1.53580219e-01f, 3.60239625e-01f, -1.29093423e-01f, 7.27843270e-02f, 1.02904111e-01f, 1.03422329e-01f,
  1.73247144e-01f, 2.23887146e-01f, -1.88918621e-03f, -6.01919480e-02f, 3.14774364e-02f, -8.96959305e-02f, 7.60510787e-02f, 2.28204697e-01f, -5.07068709e-02f, -3.97298969e-02f,
  1.61589131e-01f, 9.42740664e-02f, -1.77835420e-01f, 8.53707939e-02f, 1.42650306e-02f, 3.81796993e-02f, 1.48752987e-01f, 1.00538628e-02f, 1.05177924e-01f, -1.13355294e-01f,
  7.66598359e-02f, 2.04146653e-01f, -1.42168373e-01f, -8.20642784e-02f, 4.65044603e-02f, 5.47398813e-02f, -3.24966729e-01f, 3.83575670e-02f, 8.25922862e-02f, -7.65720308e-02f,
  2.79723108e-01f, 2.74650514e-01f, -1.17715716e-01f, -1.96018532e-01f, -2.60481894e-01f, -2.00573668e-01f, 6.61838204e-02f, -1.30173624e-01f, 9.92885232e-02f, 1.17158711e-01f,
  9.28173959e-02f, -2.14505956e-01f, 1.05811670e-01f, -1.63997170e-02f, 6.79651722e-02f, -9.06593129e-02f, 1.20137349e-01f, -3.23274322e-02f, -2.43350714e-01f, -1.56522933e-02f,
  8.39552805e-02f, 3.81495386e-01f, 1.41537413e-01f, 8.40604529e-02f, 1.76208839e-01f, 1.98592424e-01f, 1.83960684e-02f, -1.55757293e-01f, -7.02608228e-02f, 1.68311492e-01f,
  7.74082169e-02f, -2.84301132e-01f, 3.00829317e-02f, 6.82980493e-02f, 3.81609350e-02f, 2.94900864e-01f, 1.03047967e-01f, -2.08003633e-02f, -2.40481808e-03f, 5.87996989e-02f,
  1.25089148e-02f, 1.01141080e-01f, 8.38801488e-02f, 2.08558112e-01f, -1.13204695e-01f, -2.00166255e-02f, -1.79061353e-01f, 1.27168328e-01f, -4.39466126e-02f, -4.84074019e-02f,
  -4.27085459e-02f, -4.60865833e-02f, 6.86729401e-02f, 7.81676397e-02f, -8.56778547e-02f, 2.55319864e-01f, -1.07942082e-01f, -6.51823580e-02f, -1.30081505e-01f, -1.38820425e-01f,
  -2.06999153e-01f, -8.77678022e-03f, -4.22861539e-02f, 5.84101118e-03f, 1.54308572e-01f, 2.99884707e-01f, -1.71024486e-01f, 9.16408598e-02f, -1.74290419e-01f, -8.74759480e-02f,
  -6.34843782e-02f, -3.30308042e-02f, 4.98131812e-02f, -6.42676465e-03f, 1.80134743e-01f, 1.22923523e-01f, -4.73531261e-02f, 2.01437145e-01f, 4.33852859e-02f, 4.95336354e-02f,
  1.68529361e-01f, 9.54664722e-02f, -1.52797937e-01f, -2.35322565e-01f, 1.73453614e-01f, -8.07446167e-02f, 3.52220647e-02f, 1.53550968e-01f, 8.70089009e-02f, 1.14824995e-01f,
  -2.61648029e-01f, -2.03430369e-01f, -5.57948090e-02f, 1.90918759e-01f, 1.15379676e-01f, -8.24720785e-02f, 1.20351493e-01f, -3.14902961e-02f, 1.95138931e-01f, 1.24584377e-01f,
  -2.15603417e-04f, 1.00561112e-01f, 1.39488876e-01f, 6.06766306e-02f, 1.62116036e-01f, 2.36245543e-01f, -4.16929126e-02f, 1.36139646e-01f, 1.00662328e-01f, 1.01154745e-01f,
  -1.15861244e-01f, 1.44186214e-01f, -5.63787995e-03f, 1.09140307e-01f, 2.06277356e-01f, 2.07229063e-01f, 2.00843334e-01f, 2.56849974e-02f, 1.24514639e-01f, -6.06626309e-02f,
  8.80189613e-02f, 4.80197743e-02f, -1.03942221e-02f, 3.27085167e-01f, 2.03174606e-01f, 2.22490534e-01f, 8.29204265e-03f, 2.75657773e-01f, 4.17372473e-02f, -2.06343099e-01f,
  1.58603996e-01f, -8.62075314e-02f, -1.10804275e-01f, 1.12127014e-01f, 3.44248079e-02f, 5.15886992e-02f, -8.11713040e-02f, 2.97988188e-02f, 8.66181869e-03f, -1.97899379e-02f,
  1.10158786e-01f, -4.28517163e-02f, 1.22659236e-01f, 8.10795277e-02f, -1.00938464e-02f, -1.87947512e-01f, 1.77262370e-02f, -2.70189613e-01f, 1.83334202e-01f, -7.94284940e-02f,
  9.54308808e-02f, -4.46865708e-02f, -8.22411105e-02f, 3.20169255e-02f, 2.80056447e-01f, -8.78704563e-02f, -4.74892147e-02f, 6.25431910e-02f, 1.00867994e-01f, -1.53343290e-01f,
  -3.28213014e-02f, 1.84918404e-01f, -3.08330894e-01f, -5.60148619e-02f, 9.41045657e-02f, 9.76621136e-02f, 1.40435472e-01f, 7.20481277e-02f, -1.15672462e-01f, 6.93436787e-02f,
  7.38245994e-02f, 4.09288295e-02f, -1.05060890e-01f, -9.19823721e-02f, -1.65006995e-01f, 1.02794401e-01f, 3.57864797e-01f, -3.30988988e-02f, 1.38523489e-01f, 1.81406394e-01f,
  1.54130787e-01f, 2.47487321e-01f, 2.62387812e-01f, 3.72125417e-01f, -9.36851352e-02f, -1.26156092e-01f, -9.88253132e-02f, 2.31193855e-01f, 1.46404013e-01f, 1.64544880e-01f,
  6.16389401e-02f, 1.06006205e-01f, 7.02723935e-02f, 3.00721712e-02f, -1.04731627e-01f, 9.17674135e-03f, 2.96957996e-02f, 9.77620296e-03f, 2.04210415e-01f, 8.29768032e-02f,
  -1.73126712e-01f, -6.62740786e-03f, 4.22925167e-02f, 6.78130537e-02f, 1.02044679e-01f, 1.46526337e-01f, 2.80496210e-01f, 8.10969546e-02f, -1.04730941e-01f, -1.24905907e-01f,
  -9.50990468e-02f, -8.62223953e-02f, 2.36189812e-02f, -1.92604586e-01f, 1.95473745e-01f, 9.07271951e-02f, -1.68685485e-02f, -1.42718935e-02f, -1.04696214e-01f, 1.10052191e-02f,
  -1.52572021e-01f, 1.51238427e-01f, 5.19263046e-03f, 2.58337587e-01f, -6.61209645e-03f, 2.21735880e-01f, 5.12177981e-02f, 7.75606781e-02f, -7.88002387e-02f, -1.25533134e-01f,
  3.92996855e-02f, -1.02717981e-01f, 2.24128570e-02f, 5.85700944e-02f, 6.30221218e-02f, -9.52719450e-02f, 3.19834915e-03f, -2.35982556e-02f, -1.74257204e-01f, -4.94981632e-02f,
  -6.42916048e-03f, 1.19571641e-01f, 4.85119596e-02f, -1.87868401e-02f, 2.47521207e-01f, 1.41722811e-02f, -2.42389724e-01f, 1.29791319e-01f, 2.50919878e-01f, -1.37828320e-01f,
  3.78521681e-02f, 1.79461241e-01f, -3.91393229e-02f, 2.13005081e-01f, 2.36097425e-02f, 1.45456687e-01f, 7.65029564e-02f, -1.14634223e-01f, -1.30270377e-01f, 1.21044591e-01f,
  -1.65550888e-01f, 4.80047474e-03f, -1.34833023e-01f, -7.29633942e-02f, -2.90719718e-02f, -2.39474308e-02f, -1.77786127e-02f, -1.01264298e-01f, 1.32513614e-02f, 9.11359861e-02f,
  4.38745730e-02f, -1.06998116e-01f, 1.71630383e-01f, -3.43846269e-02f, -1.39580294e-01f, 1.15920238e-01f, 1.82169184e-01f, -8.95243958e-02f, -1.08338766e-01f, -1.74198169e-02f,
  4.24009226e-02f, 2.39236414e-01f, 1.99712947e-01f, -1.81952387e-01f, -1.47459982e-02f, 5.54142818e-02f, 3.14273804e-01f, -2.28650525e-01f, 2.21311405e-01f, -8.55778009e-02f,
  -2.83285491e-02f, 9.14096527e-05f, 1.63183302e-01f, 3.09563816e-01f, -1.59246696e-03f, 7.26183504e-02f, 5.41141815e-02f, -2.53168363e-02f, 2.39046738e-01f, 1.30823642e-01f,
  -3.34900580e-02f, 5.40176593e-02f, 6.13586903e-02f, 8.07146891e-04f, -2.11045668e-01f, -7.04099312e-02f, -9.72952843e-02f, -1.34553134e-01f, 1.36356845e-01f, -3.13577726e-02f,
  4.93479483e-02f, 7.82342702e-02f, 2.94930726e-01f, -4.92251068e-02f, -4.87893783e-02f, -5.55453729e-03f, -6.42039115e-03f, -1.96391404e-01f, -3.68207633e-01f, 6.08709045e-02f,
  -9.15583819e-02f, 3.15035204e-03f, -3.03287990e-02f, 2.84415096e-01f, 2.63798963e-02f, -1.53846040e-01f, 1.04352884e-01f, -8.82983133e-02f, -5.90197630e-02f, -3.48351039e-02f,
  7.42906779e-02f, 1.31603673e-01f, 4.06443775e-02f, -1.44042308e-02f, -7.02699125e-02f, -1.38497949e-01f, 5.64517789e-02f, -5.97258098e-03f, -7.84215555e-02f, 1.32832631e-01f,
  -2.03999490e-01f, -2.63697833e-01f, -9.48461816e-02f, -1.93606988e-01f, -1.67105079e-01f, 2.43687436e-01f, -1.03076495e-01f, -6.82559833e-02f, -8.16117823e-02f, -2.07035482e-01f,
  1.92603841e-01f, 8.48688856e-02f, 8.06669146e-02f, -7.08192438e-02f, 3.25950742e-01f, 2.13606060e-02f, -3.33831012e-01f, -1.51416752e-02f, -1.06213413e-01f, 8.90675783e-02f,
  -1.58925429e-01f, -1.22283481e-01f, 2.93699265e-01f, -6.60584420e-02f, 8.11375976e-02f, -8.77444372e-02f, 2.81106323e-01f, 2.00338084e-02f, -5.43106608e-02f, 6.72031865e-02f,
  5.51096164e-02f, 3.68391201e-02f, -5.63034043e-02f, 3.86365764e-02f, 1.79917231e-01f, 2.70680189e-02f, 1.06017560e-01f, 1.44372985e-01f, 1.81487948e-01f, 2.66868263e-01f,
  1.46185786e-01f, 3.07604056e-02f, -1.35691777e-01f, 1.53387740e-01f, 2.15206414e-01f, 1.71954080e-01f, -2.10642710e-01f, 1.33722544e-01f, 3.96309327e-03f, 1.27512679e-01f,
  1.51451364e-01f, -3.82013246e-02f, -1.15278944e-01f, 6.23904169e-02f, -1.93639211e-02f, 1.06863499e-01f, -1.49186896e-02f, -1.18592113e-01f, 1.23143405e-01f, 6.11382462e-02f,
  6.39413372e-02f, 2.54021101e-02f, 1.32203195e-02f, -9.20938551e-02f, -9.21900421e-02f, -1.38855293e-01f, 6.79462776e-02f, -1.27501830e-01f, -9.75468680e-02f, 2.01254357e-02f,
  1.22457273e-01f, 2.33862661e-02f, 3.43932211e-02f, -4.48004168e-04f, 1.95492595e-01f, -5.19075692e-02f, 2.27568951e-02f, -2.54261494e-02f, -2.03409120e-01f, 2.32127249e-01f,
  -1.11446872e-01f, 1.45571768e-01f, -1.51328191e-01f, 6.04804344e-02f, -7.65347555e-02f, 1.62614770e-02f, 2.27659389e-01f, 3.90913263e-02f, 1.04298986e-01f, -8.28568488e-02f,
  7.78804943e-02f, 2.10639656e-01f, 1.43603876e-01f, 1.43035457e-01f, -5.27724251e-02f, 2.45243266e-01f, -2.58423761e-02f, 1.65249780e-01f, -1.15238503e-02f, 2.84216404e-01f,
  -8.64548329e-03f, -1.89902872e-01f, -1.56821832e-01f, 2.19841320e-02f, -1.30345032e-01f, 8.61034393e-02f, -1.62739679e-02f, -1.97255760e-02f, -1.80118084e-02f, 1.81380600e-01f,
  -1.77403122e-01f, 1.36079356e-01f, -1.44804135e-01f, 8.55163857e-02f, 2.23025933e-01f, -1.37620121e-01f, -1.88437894e-01f, -1.04649708e-01f, 2.02771202e-01f, 3.30143720e-02f,
  1.04902677e-01f, 1.19971268e-01f, 1.57320470e-01f, 9.83923450e-02f, 5.66080064e-02f, 1.29584923e-01f, -8.77365395e-02f, -2.97412485e-01f, 1.66571021e-01f, -2.33255550e-01f,
  1.72260925e-01f, 6.46189414e-03f, 3.93409133e-02f, 1.00100666e-01f, -1.67440936e-01f, -1.34446055e-01f, -9.17279255e-03f, 1.71466827e-01f, 2.31837034e-02f, -1.18759371e-01f,
  1.07100233e-01f, -7.44926482e-02f, -3.93062420e-02f, -4.03601974e-02f, -1.17326602e-01f, -8.75311792e-02f, 1.02514192e-01f, 8.30947049e-03f, 2.43859187e-01f, 1.16511792e-01f,
  8.66862312e-02f, -2.76301727e-02f, -9.25430581e-02f, 4.63315547e-02f, -1.19054809e-01f, 3.84569950e-02f, -3.69997807e-02f, -3.91062498e-02f, 1.44741729e-01f, 2.70635150e-02f,
  2.30780736e-01f, -4.82896827e-02f, 1.17085278e-01f, 1.79724932e-01f, 2.07918540e-01f, -1.78473383e-01f, 1.41363204e-01f, 1.62881777e-01f, 1.25386864e-01f, 1.57684032e-02f,
  -6.45619035e-02f, 1.10145353e-01f, 1.69045687e-01f, 7.01986626e-02f, -1.09084532e-01f, 1.01073375e-02f, -3.60177197e-02f, -7.87490755e-02f, -1.13423854e-01f, 5.07913753e-02f,
  6.38774037e-02f, -1.45256013e-01f, 1.10184744e-01f, -9.21284482e-02f, 9.78617743e-03f, -1.63157761e-01f, -4.96187843e-02f, 4.93744276e-02f, 5.59153631e-02f, -4.12223525e-02f,
  -5.64874448e-02f, 3.56341392e-04f, -7.08700269e-02f, 1.02049083e-01f, 2.27058530e-02f, 2.08798274e-02f, -8.97414833e-02f, 1.79584697e-01f, 6.43425584e-02f, -2.92160194e-02f,
  -2.67661866e-02f, -1.91269480e-02f, 1.91156939e-01f, -8.13961178e-02f, 1.06090501e-01f, -1.17660478e-01f, 7.06510022e-02f, 1.19706569e-03f, -8.64521712e-02f, 1.42432898e-01f,
  -9.20159593e-02f, 9.67725068e-02f, -6.88685700e-02f, 8.53414461e-02f, 3.39905500e-01f, 9.27889347e-03f, 2.23621875e-02f, -8.80845077e-03f, 2.23841965e-01f, 1.03115700e-01f,
  -3.00881080e-02f, 1.38917163e-01f, -1.44955903e-01f, 5.37405945e-02f, 6.97190091e-02f, 1.77897215e-01f, 2.86292553e-01f, 2.69961674e-02f, 2.21388578e-01f, 2.10638672e-01f,
  -1.97824109e-02f, 1.73452252e-03f, 1.97841644e-01f, 2.98464410e-02f, -3.27321179e-02f, 1.27492743e-02f, -8.36082920e-02f, -1.95421979e-01f, 7.43218213e-02f, 1.08912826e-01f,
  1.10833570e-01f, 6.79178461e-02f, 2.06705093e-01f, 8.47931579e-02f, -3.92117910e-02f, 5.01074828e-02f, 9.04919505e-02f, -5.50746098e-02f, -7.93897361e-03f, -2.92874426e-01f,
  -3.18981223e-02f, 8.74496698e-02f, 3.60778384e-02f, -2.31518924e-01f, 5.31426966e-02f, -3.25874016e-02f, -4.13353331e-02f, 4.60213656e-03f, 8.53701588e-03f, 3.33083095e-03f,
  -2.64284313e-01f, -5.99776320e-02f, 3.66510823e-02f, 1.98780179e-01f, -5.26816025e-02f, 2.56326725e-03f, 3.33207957e-02f, 7.37458095e-02f, 8.53637904e-02f, -8.70769545e-02f,
  -1.65740382e-02f, -3.60865921e-01f, -9.42199007e-02f, -8.97902325e-02f, 1.82138696e-01f, -9.89676341e-02f, 2.54553165e-02f, -1.21840738e-01f, 2.91770846e-02f, -5.95829003e-02f,
  -6.68674111e-02f, 3.32572311e-02f, -3.01863756e-02f, -1.55807599e-01f, 1.21813782e-01f, 1.29162133e-01f, 2.82882228e-02f, 2.14708485e-02f, 1.97588712e-01f, -5.59513383e-02f,
  -2.65860766e-01f, 3.78386974e-02f, -5.56416437e-02f, -1.02035969e-01f, -1.74569175e-01f, 1.29982941e-02f, 1.87487438e-01f, 8.89792517e-02f, -1.37881492e-03f, 8.06679577e-02f,
  -1.21147282e-01f, -5.09627461e-02f, 2.45413417e-03f, -1.14637174e-01f, 1.60213858e-01f, 6.19387813e-02f, -9.11908895e-02f, 1.61362186e-01f, 2.00113997e-01f, -5.10224029e-02f,
  -5.09703420e-02f, -3.19738500e-02f, -8.46807063e-02f, -1.14679605e-01f, -1.97378397e-02f, 2.51593739e-01f, 6.43899068e-02f, -2.03564749e-04f, 2.74721086e-01f, -8.29414055e-02f,
  2.35319987e-01f, -2.01548800e-01f, -1.17301457e-02f, 1.81439579e-01f, 1.79330379e-01f, 5.68164065e-02f, 6.92542866e-02f, 2.37003475e-01f, -1.68486670e-01f, 2.07718000e-01f,
  -7.12578595e-02f, 2.33393803e-01f, 2.01045796e-01f, -6.34240508e-02f, 1.68585137e-01f, -7.74887726e-02f, -4.05486301e-02f, -7.03481957e-03f, 2.14745715e-01f, -1.61987752e-01f,
  7.04344213e-02f, -6.53640106e-02f, -6.12738207e-02f, 1.49264365e-01f, -3.47660147e-02f, 1.46803379e-01f, -2.00173140e-01f, 1.59621656e-01f, -1.39299378e-01f, -6.06971867e-02f,
  -1.03473626e-01f, -6.43978491e-02f, -6.07914329e-02f, 6.10738434e-02f, 2.46546984e-01f, 7.85235539e-02f, -2.10892588e-01f, 1.43968374e-01f, -7.70116895e-02f, 8.13702196e-02f,
  1.35728806e-01f, 8.18966553e-02f, -6.35715015e-03f, -4.23739627e-02f, -1.20584153e-01f, -1.82958189e-02f, 1.21386968e-01f, -1.31369799e-01f, 1.10918626e-01f, 2.08507195e-01f,
  3.19128931e-02f, 2.09300399e-01f, -1.27117425e-01f, 3.40451337e-02f, -1.87034428e-01f, 1.38432696e-01f, 4.61619459e-02f, 3.95470113e-03f, 1.26871541e-01f, 1.84915990e-01f,
  -1.28461182e-01f, 4.67308164e-02f, -7.65708089e-02f, 1.62337035e-01f, -2.21336409e-01f, 3.74925733e-02f, -8.40845890e-03f, 9.79247764e-02f, 5.91491237e-02f, -1.57419220e-01f,
  -6.54945988e-03f, -2.12981738e-03f, 9.65029150e-02f, -1.20712265e-01f, -2.00596586e-01f, 3.55883837e-02f, -4.36756723e-02f, 1.49040952e-01f, -1.75401747e-01f, -1.27024353e-01f,
  4.32736352e-02f, 7.14275688e-02f, 1.49836585e-01f, -7.95513839e-02f, -8.11399668e-02f, 8.18834454e-02f, -1.01773880e-01f, 2.55277995e-02f, 1.05836421e-01f, 9.09114555e-02f,
  -8.14912394e-02f, -8.63889977e-02f, 1.00541994e-01f, 1.93173364e-01f, 1.33465379e-01f, -6.38530552e-02f, 1.87965900e-01f, -7.79969469e-02f, 2.45706718e-02f, -5.68358541e-01f,
  -7.28195682e-02f, 1.98775217e-01f, 2.16736104e-02f, 2.46336117e-01f, 1.03099138e-01f, 7.21454173e-02f, -1.66396759e-02f, 1.67239502e-01f, 1.07017308e-02f, 7.40444660e-02f,
  7.33835250e-02f, -1.90382935e-02f, 1.99647099e-01f, 1.42973572e-01f, -6.62470162e-02f, 2.25377306e-02f, 8.02185684e-02f, -1.10346429e-01f, 2.31356382e-01f, -9.45984349e-02f,
  -2.84026951e-01f, -2.05801651e-01f, -2.01017335e-01f, 2.00569332e-01f, 4.19898666e-02f, -1.23332791e-01f, 3.21166843e-01f, -2.22628504e-01f, 2.12095916e-01f, 1.79856773e-02f,
  1.21384330e-01f, -1.74089894e-01f, -2.00321674e-01f, -1.98611934e-02f, 3.41838866e-01f, 1.49534464e-01f, -3.20054777e-02f, 1.47868663e-01f, 1.31483123e-01f, 1.36306539e-01f,
  8.91550109e-02f, -3.94123383e-02f, -1.38308525e-01f, 1.80605915e-03f, 7.04464987e-02f, -1.98650975e-02f, -7.96456933e-02f, 2.85978541e-02f, 8.35798979e-02f, -1.54585987e-01f,
  -8.80489275e-02f, -8.90767798e-02f, -3.59742306e-02f, -2.22270295e-01f, 7.80226663e-02f, 6.49244636e-02f, 8.37596729e-02f, -1.06864050e-02f, 9.88202319e-02f, -6.58909604e-02f,
  -3.05195712e-02f, 6.94192154e-03f, 8.46835896e-02f, -2.87633896e-01f, 1.82951242e-01f, 2.73989469e-01f, 1.26289338e-01f, 3.81353796e-01f, 1.67426407e-01f, 7.27706552e-02f,
  -1.45451352e-01f, 2.85776317e-01f, 1.10537000e-01f, 7.61982501e-02f, 1.23349853e-01f, 2.55314678e-01f, 7.52103925e-02f, 4.17803787e-02f, 1.72075137e-01f, 1.43529892e-01f,
  -6.66236356e-02f, -4.45721932e-02f, -2.42346711e-03f, 2.03480437e-01f, 2.16098316e-02f, -9.97425541e-02f, 8.65429938e-02f, 1.84621423e-01f, 6.33582994e-02f, -4.51592170e-02f,
  1.16698660e-01f, -2.39044353e-01f, 3.63700725e-02f, -1.26504377e-01f, 2.26901978e-01f, -8.33424255e-02f, 3.19024697e-02f, -5.41688949e-02f, 2.81699061e-01f, -1.69489458e-02f,
  1.19645782e-02f, 9.07394066e-02f, -3.66240740e-02f, 2.43587364e-02f, -3.17021981e-02f, 4.28488664e-02f, -1.39964312e-01f, 1.10895775e-01f, -1.93740904e-01f, 8.87257829e-02f,
  3.89939360e-02f, -2.53452230e-02f, -1.55616030e-01f, -5.18317260e-02f, 1.63155481e-01f, -1.22868456e-01f, 7.73974657e-02f, -4.09874767e-02f, 5.90809155e-03f, 1.14820383e-01f,
  -1.31806403e-01f, 1.51334733e-01f, -8.20728987e-02f, 9.67679322e-02f, 5.49148582e-02f, -1.10162906e-01f, 2.46729895e-01f, 6.92144632e-02f, 1.36477888e-01f, 6.15861602e-02f,
  -1.79889247e-01f, 6.95946440e-02f, 2.16959551e-01f, -5.80134690e-02f, -2.01112539e-01f, 1.20744497e-01f, -1.12085000e-01f, -5.03783524e-02f, 5.68883792e-02f, 8.68244618e-02f,
  1.61280811e-01f, 7.23744929e-02f, 1.74306333e-01f, 2.70498218e-04f, 2.30623215e-01f, 9.89275170e-04f, -2.96969563e-02f, 2.49650562e-03f, 1.13027722e-01f, 5.29466495e-02f,
  1.98746383e-01f, -8.88388753e-02f, 1.77401185e-01f, -3.29221874e-01f, -1.58058899e-03f, 2.05560505e-01f, 1.33424550e-01f, 1.72045186e-01f, -1.46562591e-01f, 1.63828060e-01f,
  -2.67397743e-02f, 6.91136345e-02f, 3.07145324e-02f, 1.97290674e-01f, -1.53483329e-02f, -7.80079812e-02f, 7.38319904e-02f, 1.43334299e-01f, 1.55094087e-01f, 1.33202285e-01f,
  4.33049686e-02f, -2.89408505e-01f, -1.44058570e-01f, -1.21176966e-01f, 1.99802667e-01f, -2.16960032e-02f, -1.42305166e-01f, -1.27965823e-01f, 1.99854627e-01f, -2.87032068e-01f,
  -1.67037562e-01f, 4.99557480e-02f, -2.27928191e-01f, -2.14880362e-01f, 1.59953400e-01f, 1.02904672e-02f, 6.91492036e-02f, -1.20422639e-01f, -1.87505558e-01f, -1.14882244e-02f,
  2.83523370e-03f, 3.96280922e-03f, -1.70038030e-01f, 1.24662682e-01f, 2.97301531e-01f, -7.72763565e-02f, 3.52054625e-03f, -4.98509966e-02f, 5.39026372e-02f, 2.47362033e-02f,
  1.33982718e-01f, 2.62678504e-01f, 1.53571546e-01f, -1.55219778e-01f, 1.36229098e-01f, -2.10980717e-02f, -1.19718775e-01f, -1.00502325e-02f, 6.03010654e-02f, 2.52328008e-01f,
  -5.70301227e-02f, 3.33138108e-02f, 7.35390633e-02f, 2.17742264e-01f, -4.58864979e-02f, 1.80341557e-01f, 2.15531737e-02f, 2.06307575e-01f, -6.29787371e-02f, -8.90002549e-02f,
  -2.69616574e-01f, 4.28118072e-02f, 3.33851516e-01f, -5.46724461e-02f, 1.36092007e-01f, 1.20499052e-01f, -5.35205752e-02f, 6.30970374e-02f, 2.03013614e-01f, 4.48151454e-02f,
  -1.64014801e-01f, -2.19260603e-02f, -9.91625637e-02f, -1.49490684e-01f, 2.21139178e-01f, 2.14439780e-01f, 1.35202125e-01f, 8.29011016e-03f, -3.82477045e-02f, -8.45866725e-02f,
  -1.24609709e-01f, 2.31500208e-01f, 1.57744333e-03f, -9.43572670e-02f, 5.09066507e-03f, 2.34113127e-01f, -5.30650504e-02f, 2.21120566e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -9.99682210e-03f, 6.76331148e-02f, 9.99163836e-03f, -2.24540401e-02f, 9.02434066e-02f, 4.56484547e-03f, 4.70965505e-02f, 2.49080122e-01f, 2.25093022e-01f, 1.12337112e-01f,
  2.63022315e-02f, -6.40958101e-02f, -8.89888406e-03f, 1.46825880e-01f, 1.34465531e-01f, 2.59958386e-01f, 1.85421612e-02f, -1.14642538e-01f, -2.63697864e-03f, -5.86199239e-02f,
  -7.85566866e-02f, -2.90508810e-02f, 1.30815521e-01f, -9.27944407e-02f, 4.54311296e-02f, 1.44024238e-01f, 1.69440418e-01f, 3.70057449e-02f, 1.54929105e-02f, -1.56515405e-01f,
  -1.60852835e-01f, -3.43359001e-02f, 3.29123363e-02f, 5.25974557e-02f, 8.26248154e-02f, 2.55020678e-01f, 7.55216032e-02f, -4.78596650e-02f, 1.88999623e-01f, 1.69813797e-01f,
  4.73547690e-02f, 4.42889482e-02f, 9.12439972e-02f, 1.22721627e-01f, 1.47367939e-01f, -4.68851812e-02f, 3.34104188e-02f, -1.10613443e-01f, -3.16022411e-02f, -4.54805493e-02f,
  1.32015228e-01f, 1.01601519e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.70604312e-01f, 5.89290867e-03f, 7.02609420e-02f, -7.42591023e-02f, 4.92304564e-02f, -6.02701977e-02f, 3.97243574e-02f, -4.39945422e-03f, -1.23381741e-01f, 4.74575758e-02f,
  1.62997171e-01f, 1.32564247e-01f, 1.12797350e-01f, -4.20974381e-02f, 7.20089376e-02f, -1.57345012e-02f, 1.55177824e-02f, -1.92505896e-01f, -2.15365857e-01f, -2.95393970e-02f,
  -1.50668502e-01f, 3.04067787e-03f, 1.78861454e-01f, 6.69487566e-02f, -4.57912117e-01f, 1.57125251e-04f, -4.39491838e-01f, -2.77634978e-01f, 1.24490395e-01f, 4.41750102e-02f,
  1.99702475e-02f, -1.53265279e-02f, 1.12573214e-01f, -1.41808420e-01f, -6.59561977e-02f, 1.25856688e-02f, -7.84866437e-02f, -6.33199438e-02f, -3.39011014e-01f, -4.38685492e-02f,
  1.67321220e-01f, 1.20206274e-01f, 1.96723595e-01f, 1.38794193e-02f, 1.57459259e-01f, -8.61151218e-02f, 1.56264827e-02f, 1.49582073e-01f, 1.46907821e-01f, 7.57393241e-02f,
  -2.39565566e-01f, -2.48276398e-01f, -7.47408252e-03f, -1.13069780e-01f, -1.58845082e-01f, -1.73003957e-01f, -1.31391838e-01f, 1.37856334e-01f, -1.97015002e-01f, -5.31215109e-02f,
  9.34401751e-02f, -2.16735765e-01f, -3.37056220e-01f, 1.34168416e-01f, -4.53070514e-02f, -7.46600330e-02f, -1.56861469e-02f, -9.83080268e-02f, -7.03432932e-02f, -5.36331423e-02f,
  1.05468303e-01f, 1.35463551e-01f, 3.91618609e-01f, 2.11694408e-02f, 5.05119227e-02f, 2.95866668e-01f, -1.18379533e-01f, 1.61138952e-01f, -3.58055048e-02f, -3.35044950e-01f,
  -1.97699249e-01f, -5.57483116e-04f, -1.32733315e-01f, -2.33896151e-01f, 4.38379012e-02f, -1.28628314e-01f, -2.44196609e-01f, -2.12859690e-01f, 1.40343800e-01f, -5.37321530e-02f,
  -6.18052389e-03f, -2.82748163e-01f, -1.05007380e-01f, 1.36058763e-01f, -1.24400392e-01f, 2.60039091e-01f, -4.10352200e-01f, -3.35534126e-01f, 1.59320131e-01f, -1.12786897e-01f,
  -2.16565862e-01f, -4.71041165e-02f, -4.98607010e-03f, -1.48268759e-01f, 7.08118975e-02f, 5.28327711e-02f, 1.79881528e-02f, -2.32280850e-01f, -4.26396951e-02f, -9.85613316e-02f,
  1.39576018e-01f, 1.05792426e-01f, 1.20369077e-01f, 1.62886500e-01f, 6.11839700e-04f, 6.67673126e-02f, -7.19912425e-02f, -2.54038014e-02f, 1.23891130e-01f, 1.90017715e-01f,
  1.58123262e-02f, -5.48220202e-02f, -2.75900930e-01f, 5.44379205e-02f, -1.33855283e-01f, 1.13091350e-01f, -1.96705922e-01f, 2.05078363e-01f, -6.50445595e-02f, 3.63692194e-02f,
  1.23064496e-01f, 1.09879620e-01f, 1.41940966e-01f, 6.51233271e-02f, -1.99789703e-01f, 2.91340411e-01f, 2.38777086e-01f, 1.06465518e-02f, -1.58986256e-01f, -2.74793189e-02f,
  -1.09597892e-01f, -2.56991953e-01f, 1.35041207e-01f, -4.86887842e-01f, -1.63952067e-01f, -1.24573722e-01f, 7.51409531e-02f, -5.87742403e-03f, -1.20399535e-01f, 1.67206973e-01f,
  8.67414996e-02f, -4.16081160e-01f, -1.91604361e-01f, 6.32147714e-02f, -3.49613577e-01f, 1.47437856e-01f, -2.34069049e-01f, -8.43574181e-02f, -5.49885035e-02f, 7.43354261e-02f,
  1.57995112e-02f, -1.74886435e-01f, 1.67658955e-01f, -3.58493507e-01f, -1.84345767e-02f, -4.66281295e-01f, -5.93311489e-02f, -4.32624906e-01f, 2.12163761e-01f, -5.01118720e-01f,
  -1.42128319e-01f, 4.84113246e-02f, 1.12222932e-01f, 1.64993815e-02f, -1.89254165e-01f, 1.18494980e-01f, 1.14100099e-01f, 1.51678950e-01f, -1.94388330e-01f, -1.08685046e-02f,
  4.37651621e-03f, 9.71077662e-03f, -2.31043994e-01f, 1.30209237e-01f, 1.41556635e-02f, -3.94219190e-01f, 1.51719272e-01f, -3.24479520e-01f, -4.30047423e-01f, -3.05782706e-01f,
  -5.62788963e-01f, 1.07910804e-01f, 1.04119398e-01f, -1.16550542e-01f, -7.51623809e-02f, 1.24186926e-01f, -1.38268769e-01f, 5.36222160e-02f, 2.07433980e-02f, 1.80937618e-01f,
  -9.04966593e-02f, -1.99834004e-01f, -7.31589124e-02f, -1.99663922e-01f, 1.07018277e-01f, -2.42217347e-01f, 1.44617930e-01f, 3.08514666e-02f, -2.60606818e-02f, 2.27643251e-02f,
  -3.49316001e-01f, -2.71571815e-01f, 1.57133311e-01f, -7.20947683e-02f, 1.71496615e-01f, 2.18578398e-01f, -6.77395761e-02f, 8.38309228e-02f, -3.43387991e-01f, -3.73430312e-01f,
  1.11171149e-01f, 1.57207355e-01f, 1.82427019e-01f, 4.75061499e-02f, 1.25402078e-01f, 4.49922085e-02f, -3.72071862e-01f, 1.83518037e-01f, 1.25084952e-01f, -1.38124868e-01f,
  1.19202146e-02f, 4.46176762e-03f, -2.02472687e-01f, 8.68414342e-02f, -6.63042814e-02f, -8.92407298e-02f, 4.00891900e-02f, 1.13628879e-01f, -1.90784633e-02f, -6.16335094e-01f,
  -4.37980331e-02f, -8.11241269e-02f, -1.43128857e-01f, -3.17945510e-01f, 2.93344427e-02f, -1.07860669e-01f, -5.70963994e-02f, -2.03620285e-01f, -9.29519825e-04f, -1.42164722e-01f,
  -3.22148710e-01f, 5.93778528e-02f, 2.63160486e-02f, -1.69217482e-01f, -5.37863970e-01f, 2.36922540e-02f, -5.67823425e-02f, -1.85598254e-01f, -1.08316310e-01f, 8.32496434e-02f,
  -1.35424718e-01f, -2.69256860e-01f, -7.82684460e-02f, 7.81133994e-02f, -1.30265811e-02f, -4.45350558e-01f, -1.39751539e-01f, -2.00323641e-01f, 1.06313519e-01f, -6.70864293e-03f,
  -2.05599517e-02f, 1.36392057e-01f, -3.10263544e-01f, 1.22693211e-01f, 1.63632892e-02f, -1.30008832e-01f, 6.39874488e-02f, 1.13950767e-01f, 2.53967941e-02f, 1.34254143e-01f,
  -8.62321854e-02f, -3.67568225e-01f, 2.40993295e-02f, -3.59109193e-02f, -9.66549069e-02f, 2.21053753e-02f, -3.77222970e-02f, -2.74275783e-02f, -1.85277127e-02f, 1.56889841e-01f,
  9.85140502e-02f, 7.20446110e-02f, 1.31728113e-01f, -1.21972844e-01f, 1.23067185e-01f, -2.49052182e-01f, -4.10986878e-02f, -6.98932111e-02f, 1.24010839e-01f, -1.63278222e-01f,
  1.06405787e-01f, 8.93186852e-02f, -1.30870223e-01f, 1.23487040e-02f, 7.43386671e-02f, 1.24835163e-01f, 1.56130614e-02f, -8.83591101e-02f, -1.70798693e-02f, -1.16905489e-03f,
  -1.87492400e-01f, 1.26006976e-01f, -3.42106223e-01f, 4.37889211e-02f, -1.03040017e-01f, 9.04793572e-03f, -1.00314319e-01f, -2.33378574e-01f, 3.68049070e-02f, -2.49500331e-02f,
  2.92245924e-01f, 2.43328467e-01f, 2.40949631e-01f, -2.37266526e-01f, 8.52320269e-02f, -2.86339223e-01f, 1.64849773e-01f, 6.38412759e-02f, 8.16021301e-03f, 2.67128736e-01f,
  -8.40911195e-02f, -3.42961609e-01f, -1.93841636e-01f, 1.71740323e-01f, 1.09070808e-01f, 3.20043713e-02f, -8.91371146e-02f, 3.74509394e-02f, 2.54914984e-02f, -1.23357572e-01f,
  -3.32842410e-01f, 5.05760871e-02f, -2.85238735e-02f, 2.62194691e-04f, 1.24314493e-02f, 7.81261101e-02f, -1.17523588e-01f, -2.96569020e-02f, 1.31209821e-01f, -2.17348292e-01f,
  -6.89772069e-02f, -1.62843287e-01f, -1.29435807e-01f, 1.95169672e-01f, -4.32584658e-02f, -2.72346705e-01f, -3.73243421e-01f, 2.02353835e-01f, 7.23076910e-02f, 1.79750606e-01f,
  4.66146320e-03f, -4.42461483e-02f, 4.10374291e-02f, -3.79777588e-02f, -1.12218060e-01f, 1.95803031e-01f, 2.95291447e-05f, 4.69250642e-02f, 1.50696486e-01f, -7.13248476e-02f,
  2.23001897e-01f, 1.52392257e-02f, 1.74951524e-01f, -2.49771371e-01f, 4.91292439e-02f, 2.54778247e-02f, 5.25760697e-03f, -2.77069062e-01f, -1.14662889e-02f, -2.98076645e-02f,
  7.49956742e-02f, 9.56843048e-02f, -4.13077511e-02f, -1.28249854e-01f, -5.47515713e-02f, 2.40356214e-02f, 1.46701604e-01f, 8.21388662e-02f, 8.24373364e-02f, -2.41449594e-01f,
  -1.83436990e-01f, 5.08384481e-02f, -1.48863912e-01f, 3.12437057e-01f, -5.90573177e-02f, 3.98817845e-02f, -2.05032244e-01f, 7.18535203e-03f, -3.93781453e-01f, -1.07766405e-01f,
  3.00000429e-01f, 3.59052680e-02f, 6.22756109e-02f, 1.71343029e-01f, 5.53091839e-02f, 2.51380857e-02f, -1.11755736e-01f, 1.22610919e-01f, 3.01108152e-01f, 2.52672322e-02f,
  5.47659323e-02f, 1.89318791e-01f, -2.71892995e-01f, -3.16924930e-01f, -2.53745983e-03f, 3.93635109e-02f, -2.56959558e-01f, -2.44725257e-01f, -5.45091443e-02f, -9.20345634e-03f,
  -3.00235033e-01f, -2.92115122e-01f, -7.92407542e-02f, 1.26569182e-01f, 1.08474910e-01f, -2.07240537e-01f, -2.52500445e-01f, 5.71130849e-02f, -3.65867704e-01f, -1.46092355e-01f,
  -3.34639400e-01f, 2.12321788e-01f, 3.98722328e-02f, -2.33087823e-01f, -1.10247945e-02f, 1.54247945e-02f, -3.29333931e-01f, -1.53580338e-01f, -1.21761032e-03f, 2.69451202e-03f,
  -8.97052959e-02f, 1.20088480e-01f, 1.58603221e-01f, -1.36076421e-01f, 2.83667773e-01f, 6.17063977e-02f, 6.81017637e-02f, -2.66182929e-01f, 8.00414160e-02f, -7.91880488e-02f,
  -1.69222981e-01f, 9.92154181e-02f, -7.03783706e-02f, 1.01557925e-01f, 1.43962249e-01f, -4.80003953e-02f, 4.42002714e-02f, 1.45887241e-01f, -1.77124646e-02f, 2.13526025e-01f,
  2.04947628e-02f, -1.51769549e-01f, -7.54279494e-02f, -3.00006211e-01f, 7.53590986e-02f, -1.41808018e-01f, 2.47688200e-02f, 5.08251265e-02f, 2.31580764e-01f, -3.14183027e-01f,
  -9.32194944e-03f, 1.05345763e-01f, 5.86610511e-02f, 1.85332924e-01f, -1.26607371e-02f, -1.35642394e-01f, 1.42743349e-01f, 2.85698306e-02f, -3.75355661e-01f, -6.33684322e-02f,
  -7.83282742e-02f, 1.24373976e-02f, -7.73768220e-03f, -8.05725306e-02f, 1.25264719e-01f, -1.14232495e-01f, 1.50399342e-01f, 1.25078466e-02f, -2.77532220e-01f, 5.65949865e-02f,
  1.62553757e-01f, -7.00781196e-02f, -9.64074803e-04f, 5.60423881e-02f, 7.80669823e-02f, -2.20958978e-01f, -4.80400510e-02f, -1.79714262e-01f, -6.27005547e-02f, -1.06152929e-02f,
  -2.21073180e-01f, 3.60350832e-02f, -1.85952298e-02f, -7.39858523e-02f, -2.07473159e-01f, 5.00110015e-02f, 2.95677991e-03f, 1.38716772e-01f, -1.49510920e-01f, 4.24942039e-02f,
  1.95354834e-01f, -1.56645514e-02f, -4.06474739e-01f, -2.04872303e-02f, 7.28767514e-02f, 9.21422690e-02f, 1.78965136e-01f, 2.77051151e-01f, 1.71611533e-01f, -3.10962498e-01f,
  -4.44514215e-01f, -2.36989129e-02f, -6.51468337e-03f, 1.45752296e-01f, -8.13177973e-02f, 9.29225609e-02f, -3.61100256e-01f, -1.46823540e-01f, 1.18627980e-01f, 1.69398800e-01f,
  2.35656723e-02f, -1.97939292e-01f, -1.48119479e-01f, -4.69351619e-01f, 4.10996713e-02f, -1.28046259e-01f, 2.83991229e-02f, -2.05694482e-01f, -1.40225247e-01f, -3.03914130e-01f,
  6.46504983e-02f, 1.53417185e-01f, -3.52365375e-01f, 2.35187486e-02f, 4.73684035e-02f, 1.97693389e-02f, -1.15294252e-02f, -5.56512401e-02f, -7.05398098e-02f, 1.64506108e-01f,
  -1.90551743e-01f, 2.35946149e-01f, -4.14631128e-01f, 9.98331457e-02f, 1.22394934e-01f, -2.83065975e-01f, -2.65224099e-01f, -3.52326155e-01f, 4.37193364e-02f, -1.51039623e-02f,
  -2.04757065e-01f, -1.79549411e-01f, 1.18576601e-01f, 6.55775936e-03f, 9.37584341e-02f, 3.10407102e-01f, 1.36646509e-01f, 1.49727970e-01f, 9.74949375e-02f, 1.91330969e-01f,
  -1.29747480e-01f, -1.90360174e-01f, 3.90882678e-02f, 1.25063300e-01f, 3.04848373e-01f, -3.68349880e-01f, 1.82636023e-01f, 4.74613719e-02f, 1.59321740e-01f, 2.77112991e-01f,
  2.76128240e-02f, 2.85474718e-01f, 1.64864480e-01f, -4.46529120e-01f, 6.51937095e-04f, -1.95708320e-01f, 3.65828902e-01f, -4.44487855e-02f, -4.45286214e-01f, -4.04340029e-01f,
  8.44117925e-02f, -2.47502372e-01f, -1.81067526e-01f, 1.42118141e-01f, 7.86146373e-02f, 2.05191210e-01f, 2.11224467e-01f, 1.29659176e-01f, -2.26206407e-01f, -3.70360374e-01f,
  -1.98050275e-01f, 1.30596280e-01f, 1.03899641e-02f, 8.15537050e-02f, -1.72073498e-01f, -3.39289874e-01f, -2.44452178e-01f, -1.67104617e-01f, 1.72644809e-01f, -3.57828811e-02f,
  1.44449004e-03f, -2.88318187e-01f, 5.59457727e-02f, -1.80823788e-01f, 1.34046212e-01f, -1.58610508e-01f, 1.55302137e-02f, -3.05005074e-01f, -7.39518553e-04f, 1.68122165e-02f,
  -1.37245029e-01f, -5.33154421e-03f, -4.04316068e-01f, 1.50459066e-01f, -3.68097663e-01f, -1.18289165e-01f, 4.77013625e-02f, 6.51011840e-02f, -2.42959097e-01f, -1.34454831e-01f,
  -1.49297684e-01f, 7.75349438e-02f, -1.39064595e-01f, 9.76086035e-02f, 1.67821035e-01f, 1.33074569e-02f, -1.23099312e-01f, -4.50423099e-02f, 1.56826749e-02f, -2.16170517e-03f,
  1.02375999e-01f, -6.71423674e-02f, 7.42772669e-02f, -3.92805971e-02f, -1.31952733e-01f, 6.06039800e-02f, 2.10658927e-02f, 1.43344089e-01f, -1.94408193e-01f, -1.95136033e-02f,
  -6.87111542e-02f, 2.19312370e-01f, 8.26065093e-02f, 1.93477601e-01f, 3.54457349e-02f, 1.63261980e-01f, -1.81564152e-01f, 1.37942016e-01f, -1.89705163e-01f, -9.57637727e-02f,
  1.53196424e-01f, 2.37221085e-02f, -5.86692654e-02f, 7.46355578e-02f, -3.27296764e-01f, -7.76793510e-02f, -1.32581502e-01f, -5.77485338e-02f, 2.16761157e-01f, -3.67428958e-01f,
  1.37878984e-01f, -1.86966091e-01f, -2.74370700e-01f, 2.09415182e-01f, -3.01610738e-01f, -1.50552690e-01f, -1.71020508e-01f, 1.44450337e-01f, 6.21940158e-02f, -2.52353787e-01f,
  -4.47060198e-01f, 2.40469411e-01f, -3.38884532e-01f, 1.19749699e-02f, 6.58711717e-02f, 1.95911285e-02f, 4.88353111e-02f, -4.78254050e-01f, -6.04121536e-02f, 8.46235901e-02f,
  -1.35967270e-01f, -4.62645233e-01f, 1.75699711e-01f, 4.25004870e-01f, 1.01423703e-01f, -1.65508129e-02f, 1.44440085e-01f, -1.51770473e-01f, -6.60445243e-02f, -9.54316258e-02f,
  -1.13979638e-01f, -1.14749409e-01f, -1.09033361e-01f, -4.09294307e-01f, 1.23637117e-01f, -2.08551809e-01f, -6.46778494e-02f, -1.12234697e-01f, -1.03343792e-01f, 7.46230185e-02f,
  -1.57848909e-01f, -5.20603210e-02f, 1.76727340e-01f, -1.19721867e-01f, 3.21300954e-01f, -7.74777830e-02f, -2.43929818e-01f, -7.42892474e-02f, 4.79477718e-02f, -1.48666069e-01f,
  4.64655161e-02f, -4.72416669e-01f, 1.60473585e-02f, 7.39583746e-03f, -5.25255203e-02f, -2.10192636e-01f, -6.27756491e-02f, -2.62184381e-01f, 7.73190856e-02f, -1.95432752e-01f,
  2.11452484e-01f, -2.14639485e-01f, -6.20064959e-02f, 2.53756166e-01f, 3.30216773e-02f, -3.69094998e-01f, -7.00113252e-02f, -2.77331561e-01f, 1.21530376e-01f, -6.65818751e-02f,
  7.59410411e-02f, 2.70620406e-01f, -1.38772160e-01f, 4.14413325e-02f, 1.73440009e-01f, -1.78550139e-01f, -7.78972432e-02f, 1.47913188e-01f, -8.54189247e-02f, -2.76359260e-01f,
  1.84101030e-01f, -1.14501163e-01f, -3.78553927e-01f, -3.50994974e-01f, 1.30685344e-01f, -1.04548797e-01f, -3.29158783e-01f, -1.45439371e-01f, 1.26994699e-01f, -1.62710190e-01f,
  -2.33797971e-02f, 2.26685777e-02f, 6.38880767e-03f, 1.12209946e-01f, 2.44361818e-01f, 1.87371328e-01f, -2.32361734e-01f, 2.42745429e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.43869047e-02f, 6.76890984e-02f, 1.61517814e-01f, -1.14040717e-01f, -1.70338415e-02f, -4.79223952e-02f, -1.15956133e-03f, -7.59609044e-02f, -1.26940861e-01f, 5.30186333e-02f,
  -1.02330826e-01f, 4.96074185e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    