/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.68493420e-01f, -4.50545475e-02f, 1.66852891e-01f, -3.27245668e-02f, -1.42909706e-01f, 4.35674638e-02f, 1.72637358e-01f, -2.72113252e-02f, -1.37245022e-02f, 2.90939007e-02f,
  -1.53879464e-01f, -1.63176078e-02f, 4.51231897e-02f, -1.02576956e-01f, 1.85809806e-01f, 3.71758230e-02f, 2.48456281e-02f, 7.08418116e-02f, 2.23121911e-01f, -1.90192424e-02f,
  -6.48784041e-02f, -8.66369635e-04f, 1.29462212e-01f, 7.85849914e-02f, -7.77159706e-02f, -2.36876551e-02f, -5.67604266e-02f, 1.56315379e-02f, -1.26971886e-01f, -5.62059321e-02f,
  7.77084455e-02f, -8.28941166e-02f, 8.06916729e-02f, -1.23400211e-01f, -4.04354520e-02f, -6.01608306e-02f, 2.53579533e-03f, 3.61080281e-02f, 2.81950715e-03f, 8.82096961e-02f,
  -3.53406966e-02f, -1.81045607e-02f, -1.88170152e-03f, -5.92303015e-02f, 6.61619902e-02f, 1.46156475e-01f, -2.90930225e-03f, 8.24244767e-02f, 6.21576309e-02f, -1.77966878e-02f,
  -1.21936746e-01f, -5.00098765e-02f, 1.90893501e-01f, -5.70131689e-02f, -4.27100547e-02f, 3.63268778e-02f, -5.71038201e-02f, -1.15093840e-02f, 1.93584245e-02f, 1.41249642e-01f,
  -2.12901421e-02f, -9.59816873e-02f, -5.92206977e-03f, -8.65550153e-03f, -2.03041174e-02f, 5.71452454e-03f, 3.57212052e-02f, 7.13005140e-02f, 7.81420432e-03f, 1.35681003e-01f,
  -2.63471399e-02f, 9.08619314e-02f, -8.96866545e-02f, 3.54929976e-02f, -5.24987392e-02f, 5.78030869e-02f, 4.50397357e-02f, 8.22517369e-03f, 7.58628622e-02f, 3.25783230e-02f,
  1.67470109e-02f, 3.12575623e-02f, -6.98085278e-02f, 2.36592982e-02f, -3.47435400e-02f, 2.67849229e-02f, -1.76243968e-02f, 5.49597926e-02f, 3.00248470e-02f, -1.10748922e-02f,
  1.37694642e-01f, -1.27877682e-01f, -5.81141561e-03f, 5.52684739e-02f, -3.40497419e-02f, 6.06342480e-02f, -7.86249414e-02f, -3.95994745e-02f, -1.24482647e-01f, 2.88909040e-02f,
  -7.39653856e-02f, 6.35428121e-03f, 3.99951488e-02f, 3.63909230e-02f, -7.17531331e-03f, -2.32415311e-02f, 1.02400161e-01f, -3.76894884e-02f, 7.95595348e-02f, 1.03317283e-01f,
  8.60108212e-02f, 1.50040343e-01f, 2.01659292e-01f, 1.50615245e-01f, -2.45100800e-02f, 9.78905633e-02f, 1.68557987e-01f, 7.72200972e-02f, 1.30739450e-01f, 2.47269556e-01f,
  -1.61564618e-01f, -6.01412095e-02f, -1.22625969e-01f, -6.63929582e-02f, 1.27920866e-01f, 2.42325634e-01f, 2.78536171e-01f, 1.55620113e-01f, -2.08786153e-03f, -2.24456489e-02f,
  5.29967435e-02f, 1.74494624e-01f, 3.41425203e-02f, 1.01968259e-01f, 1.87798962e-01f, 8.42164233e-02f, -1.03682145e-01f, -8.23168755e-02f, 8.58944058e-02f, 6.13773428e-02f,
  9.76577327e-02f, 3.68920676e-02f, -1.16846524e-01f, 3.78029794e-02f, -1.04433328e-01f, 7.49195591e-02f, -1.08494878e-01f, -5.26180156e-02f, -6.19315319e-02f, -2.06033796e-01f,
  6.88668862e-02f, -1.79903090e-01f, 8.03133771e-02f, 1.25295091e-02f, -3.11966687e-02f, -2.29840167e-02f, -1.94695368e-02f, -2.83565912e-02f, -6.34483695e-02f, 3.96464504e-02f,
  -1.89784840e-02f, 6.15309142e-02f, 7.84502178e-03f, -3.49545293e-02f, -4.78681996e-02f, 4.06894796e-02f, -6.88281804e-02f, -4.65766713e-02f, -1.03384644e-01f, -1.09105287e-02f,
  9.79512706e-02f, -3.45318727e-02f, -1.12649761e-01f, -5.50087914e-02f, -3.21785733e-02f, 4.45615798e-02f, -4.72344495e-02f, -8.21701139e-02f, -3.60684916e-02f, -4.26957197e-02f,
  -2.74581220e-02f, 2.59262422e-04f, -1.97022632e-02f, 4.81633050e-03f, 5.67007959e-02f, 1.90794710e-02f, 6.93194792e-02f, 1.99795049e-02f, 5.14369048e-02f, 3.55673879e-02f,
  -8.93590320e-03f, 2.94161811e-02f, 5.67438342e-02f, -2.89998986e-02f, 4.90395725e-02f, -1.01179928e-01f, 2.19151704e-03f, 4.69943434e-02f, -6.90454021e-02f, -4.38361764e-02f,
  -1.84674039e-02f, -1.16508245e-03f, -6.69193789e-02f, 8.86639878e-02f, -1.07293397e-01f, 2.83846352e-02f, 1.42127918e-02f, 3.73828262e-02f, 9.44707822e-03f, -1.25204593e-01f,
  1.34475723e-01f, -7.85439238e-02f, 2.80900188e-02f, 9.75299776e-02f, 1.97935011e-02f, -4.99030482e-03f, -3.51462252e-02f, -2.50095706e-02f, -3.50698605e-02f, -2.89532859e-02f,
  7.34826699e-02f, -1.03712676e-03f, 7.26736784e-02f, -3.94030623e-02f, 1.13046877e-01f, 5.66378944e-02f, 4.55574691e-02f, 5.05794138e-02f, 2.05019098e-02f, 6.69512302e-02f,
  2.65650731e-02f, -5.80844888e-03f, 4.03820388e-02f, 1.27865314e-01f, -4.21308633e-03f, 2.32699942e-02f, -5.06161386e-03f, -7.98077323e-04f, 1.03852443e-01f, 1.51024923e-01f,
  -2.79670835e-01f, -2.44416744e-01f, 3.32181063e-03f, -1.83654279e-01f, -3.59269492e-02f, -1.51804583e-02f, -5.32058701e-02f, 1.00641221e-01f, 9.91284754e-03f, -1.58637785e-03f,
  -1.03098840e-01f, 9.14261937e-02f, 1.75645184e-02f, 8.91509429e-02f, -1.18139281e-03f, -5.25113707e-03f, 1.10530667e-02f, -1.59676950e-02f, 9.40095335e-02f, 5.20297363e-02f,
  1.57539063e-04f, -9.75986570e-02f, -4.27266629e-03f, 3.53478156e-02f, -7.12750554e-02f, -3.36685367e-02f, -1.11808576e-01f, -1.25937104e-01f, -3.38380001e-02f, -1.81493074e-01f,
  1.27746165e-01f, -2.10535318e-01f, 1.32883832e-01f, -3.92412357e-02f, -3.23816873e-02f, -5.56620471e-02f, -7.44784921e-02f, 3.66490707e-02f, -2.72030924e-02f, -1.57801074e-03f,
  -5.54827303e-02f, -7.76677802e-02f, -7.34924152e-02f, 5.58316708e-02f, -4.14751098e-02f, -2.46371236e-02f, -5.65388650e-02f, -8.44163820e-02f, 1.05493218e-01f, -1.41061107e-02f,
  -1.48387283e-01f, -1.31992981e-01f, 4.40384150e-02f, -8.75753164e-03f, 7.91482404e-02f, 1.40465954e-02f, 8.16381648e-02f, 1.18799927e-02f, -1.65020991e-02f, 3.25169638e-02f,
  -1.92681439e-02f, 6.96840696e-03f, -6.37421291e-03f, 2.44628247e-02f, 2.61654183e-02f, 1.05661352e-03f, -2.66196802e-02f, 4.16905107e-03f, 9.08601880e-02f, -1.99932028e-02f,
  -9.10452288e-03f, -2.15606415e-03f, 3.73107195e-02f, -5.19705899e-02f, 1.03567829e-02f, 2.40265466e-02f, 4.83408533e-02f, -6.14593597e-03f, -3.24844979e-02f, -4.06905590e-03f,
  1.12925088e-02f, 8.16905499e-02f, -9.63250622e-02f, 7.18176924e-03f, 2.38609556e-02f, -2.37139426e-02f, 6.54631183e-02f, -1.02246977e-01f, -1.03342896e-02f, -2.31034923e-02f,
  1.12995729e-01f, 8.43584985e-02f, -3.77127202e-03f, -7.24869221e-02f, 7.30609670e-02f, 5.36323227e-02f, 3.08505129e-02f, -4.99345958e-02f, 5.29415831e-02f, -4.57576513e-02f,
  -2.01395322e-02f, -5.93172237e-02f, -9.44172218e-03f, 2.01863833e-02f, 4.99157682e-02f, -4.46424000e-02f, 6.60779253e-02f, 5.08811586e-02f, -3.84121086e-03f, -8.45185071e-02f,
  4.35861945e-02f, 1.35947987e-01f, 1.16171308e-01f, -7.83938356e-03f, 1.73206069e-02f, 9.73395035e-02f, 1.38185784e-01f, 3.34268138e-02f, 1.04800947e-01f, 9.44810063e-02f,
  -2.66347200e-01f, -1.39529213e-01f, -5.76191768e-02f, 1.68442503e-02f, 2.10886505e-02f, 1.42922336e-02f, 5.43742590e-02f, 1.20395288e-01f, 5.66988029e-02f, -2.10384671e-02f,
  -4.96363305e-02f, -1.19570950e-02f, 2.52205953e-02f, 9.84994248e-02f, 5.30789308e-02f, -2.06463877e-02f, 1.85304061e-02f, 4.44053598e-02f, 9.73549709e-02f, 4.88018468e-02f,
  1.75954103e-02f, 2.05973070e-02f, 2.50047632e-02f, -2.68005505e-02f, -2.06802636e-02f, 7.76460802e-04f, -1.17596552e-01f, -7.54682198e-02f, -4.98767979e-02f, -1.75952286e-01f,
  -7.71450847e-02f, -1.43914342e-01f, 1.97381340e-02f, -2.89528854e-02f, -6.04911372e-02f, 4.30748463e-02f, 3.62814888e-02f, -3.42305307e-03f, -1.71056762e-02f, -3.80061045e-02f,
  -4.03795913e-02f, 7.02370182e-02f, -2.30623223e-02f, 4.55316901e-02f, 8.01812578e-03f, -1.70615576e-02f, 3.26338261e-02f, 1.77369248e-02f, -4.37580794e-02f, 4.63331528e-02f,
  -7.69387418e-03f, 4.19119485e-02f, -7.55608156e-02f, 7.59181157e-02f, -3.92279625e-02f, -6.38976395e-02f, 5.04284501e-02f, -8.36316049e-02f, 1.87886618e-02f, -1.32268921e-01f,
  4.84123938e-02f, -9.74381343e-02f, -5.68162799e-02f, -7.47972801e-02f, -3.83122042e-02f, 4.64751609e-02f, 3.66266705e-02f, 7.25916699e-02f, 6.45756572e-02f, -1.82814356e-02f,
  -6.41385317e-02f, -7.06578791e-02f, -2.44222973e-02f, -5.26378229e-02f, 4.71187755e-02f, -7.42565095e-02f, -5.66870794e-02f, -6.19254410e-02f, 7.71152526e-02f, 8.88172165e-03f,
  -4.98842932e-02f, 4.97161448e-02f, -1.11192884e-02f, 5.94176129e-02f, -4.85390685e-02f, -1.80798676e-02f, 5.90593666e-02f, 6.55414015e-02f, 3.29341018e-03f, -6.27082437e-02f,
  -2.60676518e-02f, -7.69479722e-02f, -1.11811057e-01f, 2.71786172e-02f, -9.85628739e-03f, 8.44637975e-02f, -9.29947421e-02f, -1.50916027e-02f, 5.73844723e-02f, 9.27272364e-02f,
  4.32764255e-02f, 2.34165192e-02f, -8.91084000e-02f, 1.62385404e-02f, -1.56155070e-02f, 9.55087021e-02f, 4.26950417e-02f, -3.05497162e-02f, -1.35367760e-03f, 3.98737006e-02f,
  -4.40471899e-03f, 5.61950635e-03f, -2.21611876e-02f, -6.22209944e-02f, 7.00724646e-02f, 4.42322306e-02f, -5.54947443e-02f, -5.78644536e-02f, -6.03692494e-02f, -9.19227377e-02f,
  -6.50991052e-02f, 5.60863167e-02f, 4.97782342e-02f, -2.06999518e-02f, -1.04508370e-01f, -1.40924379e-01f, 7.52737895e-02f, -4.19286871e-03f, -1.63821280e-02f, -5.61475866e-02f,
  -9.99119207e-02f, 3.06087714e-02f, 6.34529209e-03f, 1.31995538e-02f, -2.80207414e-02f, 2.27057077e-02f, 4.22382578e-02f, 6.54628093e-05f, 6.93744123e-02f, 7.91378021e-02f,
  3.95679008e-03f, -1.44284042e-02f, -4.08301279e-02f, 7.29258135e-02f, 6.80388808e-02f, 2.74622124e-02f, 3.66590358e-02f, -6.56584352e-02f, 9.69465226e-02f, -1.51218437e-02f,
  8.41832086e-02f, -1.68360308e-01f, -8.79134983e-02f, -8.94941948e-03f, 4.34284396e-02f, 2.47496739e-02f, 8.07157233e-02f, -5.49372919e-02f, 9.00552701e-03f, -3.69644631e-03f,
  -2.92750336e-02f, 6.78643212e-02f, -5.82309887e-02f, 3.86426188e-02f, -5.23280762e-02f, -6.55898899e-02f, -6.85162023e-02f, -7.50931799e-02f, -2.77562272e-02f, 5.34579381e-02f,
  7.15132132e-02f, -1.29952639e-01f, -1.25049189e-01f, -2.31578760e-02f, -7.45306164e-02f, -6.03492260e-02f, 5.98822385e-02f, 2.30877679e-02f, -6.92046583e-02f, -1.61251146e-02f,
  -3.23058777e-02f, -1.31176552e-02f, 6.19930439e-02f, -7.03286007e-02f, 1.23362709e-02f, -3.06357667e-02f, 6.44066706e-02f, 5.16328886e-02f, -1.61153581e-02f, -1.05154309e-02f,
  1.10371727e-02f, -2.68955585e-02f, 9.63553563e-02f, 5.13058491e-02f, 3.40516083e-02f, 9.05247312e-03f, -4.58342694e-02f, -4.16941307e-02f, 2.90337764e-02f, -3.21074873e-02f,
  4.35638130e-02f, -5.51964045e-02f, -2.63761245e-02f, -2.37870477e-02f, 1.97140165e-02f, 2.90933307e-02f, -7.14652166e-02f, -1.46466326e-02f, -3.24556045e-02f, -9.27680507e-02f,
  1.79201216e-01f, -9.72467363e-02f, 4.42922823e-02f, 1.08974606e-01f, -3.79306376e-02f, 5.49850315e-02f, -8.02759007e-02f, 6.95925578e-02f, 4.26838920e-02f, 5.93034318e-03f,
  2.94047091e-02f, 2.33007204e-02f, -1.05734374e-02f, -6.60379156e-02f, 5.61499521e-02f, -4.16173190e-02f, 1.40854800e-02f, 1.09290918e-02f, 4.51855026e-02f, 2.86488198e-02f,
  9.14488733e-03f, -6.95013069e-03f, 3.18558216e-02f, -1.98419834e-03f, -3.46540250e-02f, -2.38432828e-02f, 6.60958737e-02f, 3.94236520e-02f, -3.97713250e-03f, 1.20332330e-01f,
  3.08492750e-01f, -2.07621321e-01f, -1.83077399e-02f, 2.23154828e-01f, -1.19966455e-01f, -1.90038294e-01f, -2.88542330e-01f, 5.00871241e-02f, 1.39242962e-01f, -6.37041107e-02f,
  4.74231727e-02f, 1.81212217e-01f, 9.70813558e-02f, 6.95327222e-02f, 2.74743028e-02f, -1.41786844e-01f, 1.83908604e-02f, -4.23158146e-03f, -5.11333486e-03f, -1.00277059e-01f,
  -1.26735121e-01f, -7.22933784e-02f, 2.60301474e-02f, 2.98521686e-02f, 6.24447465e-02f, 9.18772295e-02f, 3.32238115e-02f, 6.99947774e-02f, -4.31465693e-02f, -4.47176658e-02f,
  6.89791888e-02f, 1.97326746e-02f, 8.78216028e-02f, 5.22881821e-02f, 3.34446691e-02f, -7.89060965e-02f, 4.41077054e-02f, 1.76221656e-03f, -6.07178994e-02f, 4.99198362e-02f,
  7.00571984e-02f, -6.24664836e-02f, 2.69468408e-02f, 3.28891017e-02f, 4.05663848e-02f, 3.97571065e-02f, -5.82760163e-02f, -3.26198116e-02f, 6.35321662e-02f, -8.51787478e-02f,
  -7.10481079e-03f, -2.45828722e-02f, 2.22303122e-02f, 1.84763931e-02f, 6.10221364e-02f, -3.40420716e-02f, -4.44306508e-02f, 1.29813608e-02f, 4.12577130e-02f, -4.86072153e-02f,
  5.55231469e-03f, 7.42354915e-02f, -6.98099658e-02f, -2.41533145e-02f, -8.59843288e-03f, 2.67667081e-02f, 9.24294889e-02f, -3.92682366e-02f, -7.88047984e-02f, -5.72243612e-03f,
  -7.10621327e-02f, -3.23869963e-03f, -5.94615415e-02f, 3.53703797e-02f, 2.87630446e-02f, -6.05185293e-02f, -6.38403222e-02f, 7.42925331e-02f, -1.56224454e-02f, -9.10909288e-03f,
  -3.23188095e-03f, -3.26902866e-02f, 8.66753906e-02f, -1.08363852e-02f, 5.50799929e-02f, 2.11164448e-02f, 4.17599156e-02f, -7.72424117e-02f, 1.76242888e-02f, -2.24431162e-03f,
  1.22839391e-01f, -3.09528206e-02f, 1.17329247e-01f, -1.96279399e-02f, -7.37683754e-03f, 2.37969067e-02f, 7.75989816e-02f, -6.80018729e-03f, -1.47761703e-02f, -1.06863892e-02f,
  -4.32322621e-02f, -3.91508937e-02f, 1.25126718e-02f, -9.29886401e-02f, 6.14094548e-02f, -5.44901565e-02f, -7.33827055e-02f, 1.11366786e-01f, 1.06291091e-02f, 8.49457011e-02f,
  -6.06942810e-02f, 7.65730292e-02f, 1.10355027e-01f, 5.32620549e-02f, -1.89634529e-03f, -4.62804083e-03f, -1.14661651e-02f, -1.26651525e-02f, 8.23776275e-02f, -6.04516491e-02f,
  3.23209353e-02f, -7.36393849e-04f, 1.13358565e-01f, 2.25858260e-02f, -1.23820253e-01f, -2.35582486e-01f, -2.68633664e-01f, -1.85506970e-01f, -1.15162283e-01f, -5.53620867e-02f,
  5.25834858e-02f, 8.24055076e-03f, 1.16388440e-01f, 1.18612256e-02f, -4.20122705e-02f, -8.47994685e-02f, 1.38110323e-02f, 5.45562804e-02f, 1.70051157e-02f, -6.16888814e-02f,
  -5.47339171e-02f, -5.81337400e-02f, 8.30670968e-02f, 5.89185059e-02f, 1.56246558e-01f, -1.98687892e-02f, 1.54499933e-01f, 6.47637025e-02f, 4.35035303e-02f, 2.69369930e-01f,
  3.74001592e-01f, -1.61744971e-02f, -9.34062749e-02f, -1.76103208e-02f, 1.39719516e-01f, -2.98531335e-02f, 7.82182068e-02f, 1.10469177e-01f, 1.50106084e-02f, 1.10394143e-01f,
  2.36014016e-02f, 5.70821576e-02f, 7.93953165e-02f, 5.86226285e-02f, 1.29433759e-02f, 8.87828171e-02f, 2.06804723e-02f, 1.84024069e-02f, 1.71854440e-02f, 7.80781284e-02f,
  -8.24186429e-02f, 9.23437402e-02f, 4.37651239e-02f, -5.68095818e-02f, -8.79017077e-03f, 7.15472996e-02f, 7.51742395e-03f, 6.14336953e-02f, 4.13497537e-02f, 1.43908262e-01f,
  -8.90180282e-03f, 6.84015900e-02f, -5.50568216e-02f, -7.33308122e-03f, 2.44588032e-03f, -4.51010577e-02f, 1.77677423e-02f, -3.15689482e-02f, 4.67020720e-02f, -6.48964942e-02f,
  6.69252127e-04f, 2.94508729e-02f, 7.26794302e-02f, 2.24937424e-02f, 5.01315342e-03f, 1.95176899e-02f, -1.96446106e-03f, 3.39077190e-02f, 6.19172398e-03f, 6.38054684e-02f,
  4.00680071e-03f, 5.49937300e-02f, -8.53902195e-03f, 1.27979659e-03f, -6.31393045e-02f, 3.11937463e-02f, -9.42704827e-03f, -7.75839090e-02f, -8.56693462e-02f, 2.25580093e-02f,
  1.00800507e-01f, -1.52075738e-01f, 1.55765295e-01f, -1.93692613e-02f, -3.14110667e-02f, 6.69267550e-02f, 2.81071402e-02f, -5.09025194e-02f, 4.07008789e-02f, -4.72847968e-02f,
  -7.69794453e-03f, -2.36524325e-02f, -3.94659638e-02f, -5.36020100e-03f, -1.06850795e-01f, -8.08821619e-02f, 6.15015393e-03f, 9.27652139e-03f, -6.40413314e-02f, 2.71547865e-02f,
  -9.58330408e-02f, -1.26143038e-01f, -8.74326974e-02f, -1.06882900e-01f, -7.87645504e-02f, -7.51588419e-02f, 5.76578453e-02f, -8.57025385e-02f, -1.28779020e-02f, -1.11559853e-01f,
  1.85293883e-01f, 2.47887373e-01f, -2.20955480e-02f, 1.12573117e-01f, 7.90785719e-03f, -9.17651411e-03f, 1.41363025e-01f, 1.11540772e-01f, 1.10993385e-01f, 6.93026036e-02f,
  6.58249334e-02f, 2.63553951e-02f, -6.36171773e-02f, -1.21145998e-03f, 6.20926321e-02f, 2.16168985e-01f, 1.56254083e-01f, -7.82056302e-02f, -1.88382164e-01f, -6.36679446e-03f,
  4.62727733e-02f, 6.48204684e-02f, -1.98045783e-02f, 2.99255960e-02f, 1.13422945e-01f, -9.24725235e-02f, 9.71051231e-02f, -7.71946236e-02f, 5.37324362e-02f, 1.53896958e-01f,
  1.16850100e-01f, -1.66613236e-03f, -8.23384151e-02f, -9.76182073e-02f, -5.94259659e-03f, 5.42081669e-02f, 9.49330721e-03f, 8.09472799e-03f, -4.26959507e-02f, -5.27216904e-02f,
  -1.04170829e-01f, 1.66087598e-03f, 4.11606254e-03f, -6.64821416e-02f, 1.38690579e-03f, 3.38232890e-02f, -1.07112028e-01f, 3.04263434e-03f, -8.23298171e-02f, -1.25300735e-02f,
  4.61138934e-02f, -7.87786841e-02f, -6.24000803e-02f, -2.96559744e-02f, -8.76655430e-02f, 5.22410199e-02f, 6.56641126e-02f, -4.05110717e-02f, 5.91899268e-02f, 2.14558214e-01f,
  -1.91878267e-02f, -1.03443367e-02f, -1.30911283e-02f, 2.89605577e-02f, 9.87147018e-02f, -1.39939468e-02f, -3.90224457e-02f, 6.39699772e-02f, 1.56826060e-02f, -4.15960141e-03f,
  -5.31130657e-02f, -3.59650585e-04f, -4.70675388e-03f, 1.10127620e-01f, 6.06414638e-02f, -2.23632227e-03f, -2.47962344e-02f, 3.89792100e-02f, -3.73604223e-02f, -2.56270263e-02f,
  2.01130542e-03f, -1.15703098e-01f, -9.45435464e-02f, -5.52850217e-02f, 4.14770767e-02f, -4.21964750e-02f, 6.71576336e-02f, 5.51324338e-02f, 8.79791453e-02f, -3.26741324e-03f,
  9.34579298e-02f, -1.05050378e-01f, 1.28761515e-01f, 6.07389882e-02f, 3.39732715e-03f, -3.73796821e-02f, -3.07782236e-02f, -1.41325938e-02f, -9.28884074e-02f, 3.37074734e-02f,
  -4.43058759e-02f, -3.51240151e-02f, 9.12583098e-02f, -9.75686684e-03f, -3.20104733e-02f, 4.66240644e-02f, 9.72244143e-02f, -8.31221640e-02f, -8.16544518e-02f, -3.64544392e-02f,
  -1.18860044e-02f, 2.76498925e-02f, 7.59600699e-02f, 6.34500086e-02f, 5.47264889e-02f, 4.68190052e-02f, 8.63838121e-02f, -1.74797270e-02f, 1.45375103e-01f, 3.27617615e-01f,
  3.92687500e-01f, 5.20291105e-02f, -1.60953015e-01f, 1.03447773e-01f, -1.61036327e-02f, -1.60689935e-01f, -6.69146180e-02f, 4.97856922e-02f, 5.94619289e-02f, 1.84129942e-02f,
  -7.06542060e-02f, 2.64715366e-02f, 1.02227628e-02f, 1.06769688e-01f, 2.21906751e-02f, -1.73575744e-01f, -1.09314315e-01f, 9.03184041e-02f, 1.59047738e-01f, 4.43659723e-02f,
  -1.06386676e-01f, 6.27020448e-02f, 1.21671401e-01f, 8.13822374e-02f, -1.18083984e-01f, -4.30366322e-02f, -1.15221873e-01f, -3.06973793e-02f, 3.13321315e-02f, -2.74292752e-02f,
  -1.53215811e-01f, 1.19514778e-01f, 1.36943134e-02f, 3.71959731e-02f, -8.85984674e-02f, 1.14844842e-02f, -5.01082838e-02f, 3.52928229e-02f, -3.39335129e-02f, -1.23948492e-02f,
  -2.86134295e-02f, -2.05193255e-02f, -4.39131334e-02f, -8.45632106e-02f, 1.44431116e-02f, 2.15210114e-02f, -1.55877648e-02f, 1.11429408e-01f, 7.14640170e-02f, 1.74538009e-02f,
  -5.36701567e-02f, 6.67002052e-02f, -2.93188710e-02f, -9.64379236e-02f, -5.36499694e-02f, 1.76248569e-02f, -1.05086856e-01f, 4.68038097e-02f, 5.30781001e-02f, 4.05148268e-02f,
  -6.72430098e-02f, 7.63099417e-02f, 8.84743931e-04f, -5.48998937e-02f, 2.72233374e-02f, 4.84612808e-02f, -2.29766443e-02f, 1.89781617e-02f, 5.42986318e-02f, -6.60813926e-03f,
  -4.20069695e-02f, 3.02738175e-02f, -4.40881401e-02f, 7.78673217e-02f, -2.59145368e-02f, 1.07678096e-03f, 4.83496748e-02f, 3.89858782e-02f, -8.61254930e-02f, 6.39815629e-02f,
  1.10244239e-02f, -6.50448054e-02f, -8.97341967e-02f, 2.02358700e-02f, -5.31352684e-02f, 6.85247630e-02f, 3.41533720e-02f, -2.73198728e-02f, -2.98073795e-02f, -9.92930960e-03f,
  -7.50975683e-02f, 9.66250971e-02f, -5.07594682e-02f, 7.31358975e-02f, -3.33050489e-02f, 6.82106763e-02f, -1.03674699e-02f, 4.17400189e-02f, 4.38855253e-02f, -1.11140590e-02f,
  -4.38800976e-02f, 6.85251355e-02f, -4.95619178e-02f, 5.42302988e-02f, 1.16887968e-02f, -3.66288200e-02f, 5.61297312e-02f, 3.04624010e-02f, -3.18785049e-02f, -4.26995531e-02f,
  -3.42986993e-02f, 3.24181579e-02f, 6.82678893e-02f, 1.21379197e-02f, -6.99067041e-02f, 6.27074093e-02f, -9.86700132e-02f, 2.52687465e-02f, -2.45412961e-02f, -8.02033395e-02f,
  -3.30219656e-01f, 6.59714453e-03f, 1.34665787e-01f, -1.31058380e-01f, -6.35279939e-02f, 9.69477817e-02f, 1.03548713e-01f, 3.83154452e-02f, -9.39007699e-02f, 2.40373015e-02f,
  -2.15095896e-02f, -2.43943054e-02f, 8.07267949e-02f, 3.60449776e-02f, 1.84513718e-01f, 1.91552550e-01f, 1.43904641e-01f, 1.40096948e-01f, 9.20784101e-02f, -3.61416750e-02f,
  -6.48536980e-02f, -7.50893578e-02f, -1.47217914e-01f, 3.25304866e-02f, -1.15056835e-01f, 1.54892104e-02f, 6.81980187e-03f, -1.16986051e-01f, 4.42197584e-02f, 8.70928541e-02f,
  1.22834608e-01f, -1.29221916e-01f, 8.85208324e-02f, -1.38681710e-01f, -6.39866740e-02f, -3.39635499e-02f, 1.38827658e-03f, 3.69437598e-02f, -4.59916778e-02f, -2.39410177e-02f,
  -1.10493647e-02f, -6.06798530e-02f, -2.19550245e-02f, -7.08734170e-02f, 4.89687696e-02f, -5.96512221e-02f, -1.81685854e-02f, 7.87249729e-02f, 6.47967756e-02f, -9.52015724e-03f,
  4.34420258e-02f, -2.02590413e-02f, -2.93063018e-02f, 1.00662179e-01f, 1.01870216e-01f, -4.50414605e-02f, 4.30783369e-02f, 2.84430049e-02f, 6.43724352e-02f, -5.04549928e-02f,
  -4.61374084e-03f, 3.57177928e-02f, 4.73439619e-02f, 1.56284254e-02f, 1.07711526e-02f, -4.67687100e-02f, 1.38324182e-02f, 9.17830914e-02f, -7.88975507e-02f, 2.41672751e-02f,
  8.38092808e-03f, -3.67871784e-02f, 5.50622381e-02f, -1.40801230e-02f, 8.20736823e-05f, 3.67139950e-02f, 3.89178731e-02f, 4.17391956e-02f, -1.24697471e-02f, -5.22613116e-02f,
  2.37088148e-02f, -5.63546941e-02f, 7.94094242e-03f, -7.39699090e-03f, -4.67434851e-03f, 1.59479082e-02f, -1.39745595e-02f, 6.13732748e-02f, 5.13376715e-03f, -7.35086054e-02f,
  -4.25611846e-02f, 9.56330150e-02f, -6.32775426e-02f, 8.31465051e-02f, -4.11723182e-02f, 2.11790614e-02f, -4.12802137e-02f, 1.89146213e-02f, 3.26047540e-02f, -1.37032690e-02f,
  -2.37170998e-02f, 1.03620224e-01f, 2.45791133e-02f, 7.53798410e-02f, -5.43521419e-02f, -3.34736295e-02f, -6.04674630e-02f, -7.14087039e-02f, 3.48257013e-02f, 5.22284098e-02f,
  -6.27785772e-02f, -9.83520970e-02f, 1.88831761e-02f, 2.88052522e-02f, -2.72293333e-02f, -3.86032127e-02f, 6.48661107e-02f, 1.51810027e-05f, -4.33676839e-02f, -6.36325702e-02f,
  1.46475673e-01f, -2.42670938e-01f, -7.22976401e-02f, 1.02674656e-01f, -3.32678221e-02f, 2.13986672e-02f, -1.87557712e-02f, 3.85096148e-02f, 6.29252801e-03f, -1.22910857e-01f,
  -5.43606393e-02f, 1.63241059e-01f, 1.76850539e-02f, 1.25692099e-01f, 1.53121293e-01f, -5.37265986e-02f, -1.33242244e-02f, 1.38470024e-01f, 2.82856852e-01f, 4.57635485e-02f,
  5.15549667e-02f, 3.19605246e-02f, -7.59050995e-03f, 3.99756283e-02f, -1.31491378e-01f, -3.75703536e-02f, -5.36223985e-02f, -3.61703411e-02f, -1.51320055e-01f, -2.05670670e-01f,
  -1.26143485e-01f, -2.46079825e-02f, 4.17262763e-02f, -1.32818576e-02f, 4.67947125e-02f, 6.34447113e-02f, -4.66759875e-02f, -3.05293761e-02f, 5.47257587e-02f, -6.16109408e-02f,
  3.74733806e-02f, -1.66476332e-02f, -1.73877808e-03f, 7.47224092e-02f, -1.18380688e-01f, -5.03550321e-02f, 2.71427073e-02f, -1.32929767e-02f, 7.20305741e-02f, -1.20613188e-01f,
  -8.46275911e-02f, -1.16845325e-01f, -5.30410372e-03f, 6.97305752e-03f, -6.68145046e-02f, 1.16573356e-01f, -1.49285030e-02f, -6.95331395e-02f, 3.00649311e-02f, -7.22099468e-02f,
  4.19565029e-02f, 2.00702585e-02f, -1.01338392e-02f, -2.71693170e-02f, 1.85228605e-02f, -1.96853857e-02f, -7.00482577e-02f, 7.39929751e-02f, 1.47391101e-02f, -1.47935320e-02f,
  7.22443908e-02f, -1.40013732e-02f, 1.96240786e-02f, 1.17037632e-02f, 4.75985371e-02f, -6.78089634e-02f, 3.55081670e-02f, -3.54462266e-02f, 8.39671772e-03f, -8.46588910e-02f,
  5.50151765e-02f, 3.76917869e-02f, -1.22069426e-01f, -6.03135414e-02f, -6.56640902e-02f, -4.40766253e-02f, -5.92237860e-02f, 9.54079330e-02f, 6.52783066e-02f, 7.36061186e-02f,
  7.03157159e-03f, 1.43429741e-01f, 3.93215492e-02f, 6.38027042e-02f, -3.68470848e-02f, -6.48104176e-02f, -4.60685045e-02f, -4.66000251e-02f, -2.25080568e-02f, 5.54695912e-02f,
  5.23906872e-02f, 3.38848643e-02f, -4.24991585e-02f, -8.59416723e-02f, 9.59655456e-03f, 5.43616824e-02f, -8.60456228e-02f, 6.04040325e-02f, 1.68824978e-02f, -6.62432387e-02f,
  -6.60845339e-02f, 1.38404910e-02f, 8.78551453e-02f, -1.12629281e-02f, -5.98918274e-02f, 1.42778143e-01f, -7.16911256e-02f, 9.03540924e-02f, 1.00533828e-01f, 2.73652654e-02f,
  -1.34904727e-01f, 2.61991397e-02f, 2.29063630e-01f, -9.24409032e-02f, 7.39847943e-02f, 1.29283488e-01f, 2.40490869e-01f, 5.54688536e-02f, -1.36031643e-01f, -5.41606471e-02f,
  -1.31068632e-01f, -1.09628223e-01f, -1.57125115e-01f, -1.65533021e-01f, 1.31547556e-03f, 1.37531787e-01f, 2.25628302e-01f, 4.39888947e-02f, -1.39553323e-01f, -1.07368305e-01f,
  -6.62500262e-02f, -2.88730450e-02f, -5.75451031e-02f, -8.98299515e-02f, 7.21329078e-02f, -1.21727787e-01f, 9.40908939e-02f, 1.39197633e-02f, 8.71838406e-02f, 1.87691018e-01f,
  -9.41205621e-02f, 4.65146638e-02f, 2.58289129e-02f, -9.66068208e-02f, 1.04759537e-01f, -8.02886486e-02f, -1.00135498e-01f, 3.05266082e-02f, -2.62768436e-02f, -5.76569326e-02f,
  2.92400736e-02f, 3.02649848e-02f, 5.01725264e-02f, -2.87258103e-02f, -3.68128419e-02f, 8.86422321e-02f, 1.77749246e-02f, -5.67838028e-02f, 9.61736962e-02f, -1.09895356e-02f,
  1.27693683e-01f, 7.24224448e-02f, 1.18532054e-01f, -5.78280948e-02f, -3.59876342e-02f, -1.81372333e-02f, 7.91191906e-02f, 7.06410185e-02f, 6.80280626e-02f, 4.15953866e-04f,
  -4.77858223e-02f, -1.90006588e-02f, 7.20099732e-02f, 3.07484157e-02f, -2.57271845e-02f, 5.13679273e-02f, 1.14891017e-02f, 3.09214126e-02f, -3.75975333e-02f, 4.67783362e-02f,
  -4.24844176e-02f, 3.99375483e-02f, -6.01893961e-02f, 3.55255157e-02f, -1.42260846e-02f, -3.29829603e-02f, 6.75267130e-02f, -3.93436849e-02f, 3.63786556e-02f, -3.56839448e-02f,
  -5.93497464e-03f, 5.77038042e-02f, 2.96683442e-02f, 3.48746330e-02f, 2.42169723e-02f, 4.18323018e-02f, -6.53553233e-02f, 3.21919732e-02f, 4.55819368e-02f, -3.95531729e-02f,
  -2.77966619e-01f, 6.29652292e-02f, -1.09094374e-01f, -1.13169290e-01f, 3.49088795e-02f, -1.65970493e-02f, -4.93112579e-03f, -4.16302793e-02f, -4.63406295e-02f, 1.48770781e-02f,
  -4.52481322e-02f, -4.27536331e-02f, 2.97789890e-02f, 8.53551850e-02f, -4.70001511e-02f, -3.75761166e-02f, 1.18406527e-02f, 7.16728047e-02f, -2.81856935e-02f, -2.23403499e-02f,
  1.32268900e-02f, -3.29881273e-02f, -1.93757370e-01f, -9.09790769e-02f, -3.23843062e-02f, -9.89284664e-02f, -1.33096322e-01f, 2.88783442e-02f, -5.93959652e-02f, -1.60619184e-01f,
  -7.48963952e-02f, -1.31395504e-01f, -2.16480419e-01f, 6.94788173e-02f, 1.16099708e-01f, -5.08040376e-02f, -1.74652681e-01f, 7.01788161e-03f, 1.45151109e-01f, -1.18622491e-02f,
  -4.78387065e-03f, 2.04132587e-01f, 4.86186631e-02f, -1.31658120e-02f, -1.00194380e-01f, -1.79916024e-01f, -1.08529963e-01f, -1.29456803e-01f, -6.98822588e-02f, 5.42450324e-02f,
  2.85631791e-02f, -7.71826878e-02f, -3.99208367e-02f, 2.50913366e-03f, 1.06069088e-01f, 1.38190493e-01f, 1.45231131e-02f, -5.53939827e-02f, -2.21170411e-02f, -4.39109094e-03f,
  5.12059107e-02f, 4.26085666e-02f, 1.10409819e-01f, 5.07080287e-04f, -3.20850126e-02f, -9.14643705e-02f, -9.72184241e-02f, -6.31106598e-03f, -2.21333671e-02f, -5.94240353e-02f,
  1.18739471e-01f, -6.97661424e-03f, -8.33426975e-03f, 6.12286553e-02f, 3.05031356e-03f, -7.12362751e-02f, -2.86879065e-03f, -1.43586481e-02f, -6.62159398e-02f, -4.59843278e-02f,
  5.65923341e-02f, 4.45263274e-02f, -6.12402149e-02f, -3.30520459e-02f, -1.05170436e-01f, 6.72216192e-02f, -1.69356540e-02f, 3.71423326e-02f, -9.23173055e-02f, 1.54391266e-02f,
  -1.98608600e-02f, -6.62355497e-02f, 8.12426284e-02f, 6.46244064e-02f, -4.21915315e-02f, -1.22859186e-04f, 4.90003377e-02f, -1.72963012e-02f, 1.08506709e-01f, -1.65315904e-02f,
  -4.55567874e-02f, 1.17589626e-02f, -8.76337662e-02f, -3.31465900e-02f, -2.44055651e-02f, -5.57254953e-03f, -4.10546176e-02f, -7.31941983e-02f, 7.63357058e-02f, 7.62016103e-02f,
  1.01968333e-01f, 1.22976182e-02f, -1.75725464e-02f, -4.29778360e-02f, 4.40733917e-02f, -1.48911858e-02f, -5.28152771e-02f, 3.07596498e-03f, -2.43009385e-02f, 4.69503365e-02f,
  -3.75175439e-02f, -5.68149760e-02f, 1.06099725e-01f, 7.33898906e-03f, 1.09324746e-01f, 7.69101754e-02f, 2.98492797e-03f, 4.70157154e-02f, 5.12454808e-02f, -7.72343203e-02f,
  -3.21345516e-02f, -5.61213866e-02f, -4.96043600e-02f, 1.01608215e-02f, 1.70693044e-02f, 7.53644630e-02f, 4.16243151e-02f, -5.96977510e-02f, 9.78632122e-02f, -8.86134990e-03f,
  -3.46027873e-02f, 3.19900066e-02f, -5.48833758e-02f, 1.82970706e-02f, 6.60261065e-02f, 5.41594960e-02f, 9.54714138e-03f, -4.36986610e-02f, -6.58544898e-02f, -9.25326645e-02f,
  -1.33698732e-01f, 8.20803791e-02f, -1.75136458e-02f, 7.64492229e-02f, 7.37324581e-02f, 4.73716892e-02f, 1.39961913e-01f, -1.57405101e-02f, 5.27798459e-02f, -5.22436984e-02f,
  2.87699439e-02f, -1.77713409e-02f, -1.03996865e-01f, -1.01990424e-01f, 3.69763486e-02f, 1.49604559e-01f, 1.32949859e-01f, -3.73820923e-02f, -1.29771322e-01f, 4.25143503e-02f,
  1.26716331e-01f, 1.09647840e-01f, -7.29535893e-02f, -4.85555194e-02f, -2.26255078e-02f, 2.35566869e-02f, 5.50066605e-02f, 1.00681931e-01f, 1.11499056e-01f, 1.38171360e-01f,
  -6.32368550e-02f, -5.70288226e-02f, -3.01351603e-02f, 4.12907898e-02f, -5.77607751e-02f, -5.74203115e-03f, 5.24183363e-02f, -1.05595089e-01f, 9.87872761e-03f, 2.91507002e-02f,
  -5.07408567e-02f, -8.18087682e-02f, 2.50083860e-02f, 3.78504233e-03f, 4.19925489e-02f, -1.87225780e-03f, -6.01167716e-02f, -5.63373715e-02f, 6.91016465e-02f, -9.01227370e-02f,
  7.50172213e-02f, 1.07414886e-01f, 4.40961961e-03f, 7.34611973e-02f, 9.19709578e-02f, 2.90933214e-02f, -4.62690443e-02f, -2.06168462e-02f, 9.65092331e-02f, 1.39514983e-01f,
  -3.79278623e-02f, -4.01715711e-02f, -1.13517558e-02f, -3.43781300e-02f, 5.99182919e-02f, 2.08985191e-02f, -3.51021141e-02f, -2.81734038e-02f, 2.00827643e-02f, -2.39939485e-02f,
  -4.06383090e-02f, -6.19007237e-02f, -3.20712961e-02f, 3.38532776e-02f, 2.40517445e-02f, -5.96130602e-02f, -3.59437056e-02f, 6.66925833e-02f, 7.75547698e-02f, 1.15025416e-02f,
  -1.53813288e-02f, -5.24894893e-02f, 4.94155381e-03f, -1.66841812e-04f, 1.37374522e-02f, 1.63683724e-02f, 2.07017548e-02f, 5.74981421e-02f, 4.16122489e-02f, 1.01972641e-02f,
  -3.68281193e-02f, -1.04515620e-01f, 5.15954904e-02f, -3.09238918e-02f, -1.97414178e-02f, -6.16490878e-02f, 3.13717127e-02f, -7.69551098e-02f, -1.23383902e-01f, -1.09655457e-02f,
  -1.22527361e-01f, -3.26864794e-02f, -1.02296196e-01f, -6.35322854e-02f, 7.08227605e-02f, -4.11358625e-02f, 5.99099509e-03f, 1.02147989e-01f, 1.02445528e-01f, 3.78306210e-02f,
  1.62196755e-02f, 6.69054464e-02f, 2.22852565e-02f, 4.55886461e-02f, -4.08046581e-02f, 5.35107851e-02f, 8.40293467e-02f, -2.77932473e-02f, 1.02189079e-01f, 2.24759087e-01f,
  1.13665745e-01f, -3.11569184e-01f, -2.39019752e-01f, -9.59875733e-02f, -3.57260113e-03f, -5.42679653e-02f, -2.06222370e-01f, 1.34132365e-02f, 1.58129215e-01f, -1.47007629e-01f,
  -1.68941453e-01f, 8.58371183e-02f, 1.35907888e-01f, 1.17684424e-01f, 1.30765021e-01f, -6.32673278e-02f, -8.34661350e-02f, 2.23305933e-02f, 2.91676253e-01f, 9.59223658e-02f,
  2.25501154e-02f, 2.16533188e-02f, 1.50904492e-01f, -3.51670734e-03f, -1.22428965e-02f, 4.09974754e-02f, -1.29481778e-01f, -5.72980940e-02f, -1.83249101e-01f, -1.28543809e-01f,
  -4.21151109e-02f, -1.77864864e-01f, 1.30096763e-01f, 7.12890029e-02f, -1.06284477e-01f, 7.98110068e-02f, 3.08625102e-02f, -7.09467055e-03f, -1.13756306e-01f, -4.58437838e-02f,
  -1.40085490e-02f, -3.68443690e-03f, -2.67816298e-02f, -5.62380105e-02f, -1.79272667e-02f, -6.73787072e-02f, -8.32429156e-02f, -2.34775003e-02f, 2.62764804e-02f, -2.63702497e-02f,
  1.54137388e-02f, -7.82914162e-02f, -6.84990957e-02f, 6.68516606e-02f, -4.47425768e-02f, 4.82197963e-02f, -5.31050041e-02f, -8.02580714e-02f, 8.77910703e-02f, 1.80873238e-02f,
  7.53030833e-03f, -1.03768043e-03f, 1.59924664e-02f, 6.33483566e-03f, 2.91768517e-02f, -1.86743680e-03f, -4.30581458e-02f, -4.90583247e-03f, 8.20287168e-02f, -9.21305493e-02f,
  -3.75551928e-04f, -1.20066248e-01f, -5.23901843e-02f, -2.96990611e-02f, -2.98997909e-02f, 7.98484660e-04f, -2.77986769e-02f, -4.38544676e-02f, 8.73707682e-02f, -5.06857596e-02f,
  5.68138622e-02f, 1.43840620e-02f, 4.46546786e-02f, -7.48512242e-03f, 2.42233463e-02f, -7.99596235e-02f, 1.37531552e-02f, -6.23831861e-02f, -3.56957130e-02f, -4.24033962e-02f,
  1.42868564e-01f, 1.33817699e-02f, 2.70198435e-02f, 7.17677400e-02f, 5.68237193e-02f, 3.51214446e-02f, -5.71709275e-02f, 7.40862563e-02f, 2.62546521e-02f, 2.82105617e-02f,
  -7.67190903e-02f, 2.74102148e-02f, -3.84292975e-02f, 7.25056827e-02f, 5.32630347e-02f, 3.60794924e-02f, 2.43586693e-02f, -6.91642426e-03f, 1.11903548e-01f, 7.23592425e-03f,
  2.65453253e-02f, 1.46292716e-01f, 1.78197280e-01f, 1.01316020e-01f, 2.65282542e-02f, 1.68831676e-01f, -3.91199114e-03f, 5.26379310e-02f, 9.30732489e-02f, 2.10824862e-01f,
  7.33771035e-03f, 3.52423005e-02f, 6.23934306e-02f, 1.27314031e-01f, -1.04693651e-01f, -5.53807765e-02f, -8.74930099e-02f, -7.56734684e-02f, 6.29877066e-03f, -8.27203616e-02f,
  2.63176113e-02f, -4.01538275e-02f, 9.76520926e-02f, 2.20443197e-02f, 7.67493695e-02f, 1.07267760e-01f, 1.38910249e-01f, 4.34733257e-02f, 9.11880732e-02f, -2.32614856e-02f,
  -1.54325003e-02f, 6.20547086e-02f, 7.86239430e-02f, 6.65552542e-02f, 5.96514679e-02f, -5.85996062e-02f, 9.40438826e-03f, -1.71814021e-02f, 2.19708681e-02f, 1.48126349e-01f,
  -1.76869392e-01f, -1.18307553e-01f, 1.83863603e-02f, 5.18309996e-02f, -6.15622289e-02f, 4.29062471e-02f, 2.06876416e-02f, -1.91073567e-02f, 4.40130755e-02f, -5.79473078e-02f,
  6.48634732e-02f, 3.07204016e-02f, -7.32568512e-03f, -1.91952288e-02f, -4.28596139e-02f, 5.17663620e-02f, -5.85340559e-02f, 5.18122688e-03f, 2.88237929e-02f, 2.36219410e-02f,
  3.76321003e-02f, -3.49681005e-02f, -1.08870499e-01f, -9.07879621e-02f, 7.17754811e-02f, 2.64209379e-02f, -3.82304303e-02f, -5.07014580e-02f, -5.89504205e-02f, -6.14031740e-02f,
  2.58724783e-02f, -6.41615018e-02f, 8.77152197e-03f, -2.32475773e-02f, 6.23337273e-03f, 5.46551459e-02f, 6.09361827e-02f, -9.54749715e-03f, -8.31540488e-03f, 1.83714218e-02f,
  -1.89563129e-02f, -2.10316535e-02f, -4.31188531e-02f, -7.53864944e-02f, 6.93990737e-02f, 1.59986168e-02f, 2.49179713e-02f, -4.24970910e-02f, 5.83816804e-02f, 1.03337578e-02f,
  2.11052597e-02f, 1.71492547e-02f, 2.80369092e-02f, 5.06360345e-02f, -6.50287569e-02f, 1.16875686e-01f, 4.79380824e-02f, -1.10436767e-01f, 6.05823621e-02f, 5.21077625e-02f,
  -1.69817865e-01f, 3.41609530e-02f, -2.88264100e-02f, 1.38740167e-02f, -9.19305757e-02f, 5.16540483e-02f, -4.77357544e-02f, -6.34520054e-02f, -3.24140899e-02f, -3.85147557e-02f,
  6.29154220e-02f, 2.35312972e-02f, -2.84097698e-02f, 2.62035821e-02f, -2.90824287e-03f, -4.50302511e-02f, -2.13712435e-02f, 9.56518129e-02f, -8.55531171e-02f, -2.93452516e-02f,
  2.21736114e-02f, -5.18846959e-02f, 1.97216589e-02f, -8.27076584e-02f, 4.08909805e-02f, -5.49226627e-03f, -7.69305928e-03f, -1.33055389e-01f, -5.80296293e-02f, -4.15947922e-02f,
  2.70440221e-01f, 3.30228396e-02f, 1.85990885e-01f, 4.21055742e-02f, -1.78511307e-01f, -2.15641737e-01f, -8.50632787e-02f, -9.30768177e-02f, 3.05136107e-02f, -8.62426087e-02f,
  -1.60558030e-01f, -1.01410365e-02f, 9.46823135e-02f, -1.01970267e-02f, -4.19719294e-02f, 4.05931398e-02f, 1.34792514e-02f, 1.89616501e-01f, 5.34918811e-03f, -5.98817393e-02f,
  -5.86969852e-02f, 1.11368485e-01f, 1.53013870e-01f, -5.76115632e-03f, 1.54964710e-02f, -6.33960888e-02f, 7.81109408e-02f, -7.71488324e-02f, -2.10146885e-02f, 3.76983806e-02f,
  1.19682334e-01f, -1.02028243e-01f, 1.86460912e-02f, 3.63458768e-02f, 1.36621678e-02f, -1.69972628e-02f, -1.26096923e-02f, 5.97289670e-03f, -8.74152258e-02f, -3.30978706e-02f,
  -9.56356153e-02f, -4.61915545e-02f, 3.51328552e-02f, -4.32483591e-02f, 1.46887070e-02f, -4.39709350e-02f, 4.51974720e-02f, 6.85939491e-02f, 9.11212415e-02f, 4.77974601e-02f,
  1.92188006e-02f, -6.94282129e-02f, -7.91682750e-02f, -1.23805702e-01f, 4.10143062e-02f, 2.21953951e-02f, -1.02040730e-02f, 2.89567914e-02f, 8.52726549e-02f, 6.73724562e-02f,
  -3.25423479e-02f, -7.77011961e-02f, 1.78570580e-02f, 2.34473404e-02f, -2.87955925e-02f, 6.45831674e-02f, -4.57319058e-03f, 2.35669818e-02f, -1.88094880e-02f, -9.96970478e-03f,
  -6.89394353e-03f, 9.00765434e-02f, 3.64611447e-02f, -2.61774994e-02f, -1.37105631e-02f, 2.05734242e-02f, -8.76790136e-02f, 5.75094372e-02f, 3.19700353e-02f, 5.64193875e-02f,
  2.60657761e-02f, -5.96448630e-02f, -3.86667289e-02f, 2.59849634e-02f, -2.38634981e-02f, 1.10316075e-01f, 1.12909107e-02f, -7.30511546e-02f, 8.12540855e-03f, 2.04640832e-02f,
  -1.19152032e-02f, -9.36937705e-03f, 1.11489058e-01f, 6.26624748e-02f, -6.26854412e-03f, 6.06919825e-02f, 1.55198947e-02f, -2.24391557e-02f, 3.62915918e-02f, 4.83157635e-02f,
  -1.23379007e-01f, -1.00046312e-02f, 5.80091681e-03f, 6.92029819e-02f, -1.70624144e-02f, 4.43048179e-02f, 6.08220650e-03f, -2.65694857e-02f, 1.15378166e-03f, -4.13880646e-02f,
  3.50669697e-02f, 1.76541358e-02f, -4.42845263e-02f, 6.88751712e-02f, -5.43478914e-02f, 5.64867333e-02f, -6.46179542e-02f, 7.00930208e-02f, 4.44304757e-03f, 1.75464228e-02f,
  1.86436251e-01f, 1.53962702e-01f, 5.71879521e-02f, 1.47893112e-02f, -3.00374292e-02f, 2.11205870e-01f, 3.40681851e-01f, 1.21633016e-01f, 3.25317238e-03f, 5.69620728e-02f,
  -5.16514741e-02f, 2.83708656e-03f, 3.37315053e-02f, 5.46334358e-03f, 7.01925308e-02f, -1.76859982e-02f, -3.53405415e-03f, 6.13099672e-02f, 1.25273485e-02f, 9.68576968e-02f,
  -8.07536393e-02f, 4.43228371e-02f, -8.40222612e-02f, -1.14956208e-01f, -1.13040395e-01f, -1.20367371e-01f, -1.68984383e-02f, -5.70406951e-02f, -1.07740350e-01f, -1.57776728e-01f,
  -8.44806135e-02f, 7.94449449e-02f, -2.32108384e-02f, 5.13895527e-02f, -2.14575604e-03f, -4.46473695e-02f, 3.24980877e-02f, -5.81419617e-02f, 1.13925785e-01f, -4.23456728e-02f,
  -6.16850890e-02f, 2.17744280e-02f, -6.24739416e-02f, -4.12017480e-02f, 4.82294932e-02f, 1.16047405e-01f, 3.36263701e-02f, -5.23280092e-02f, 5.54396994e-02f, 5.17167803e-03f,
  8.11986700e-02f, 1.38822988e-01f, 1.73192516e-01f, -3.41369547e-02f, 4.67765778e-02f, 4.86835279e-03f, 8.06751847e-02f, 3.41051407e-02f, 6.77513778e-02f, -1.17592394e-01f,
  7.00433031e-02f, 1.27483774e-02f, -1.46376407e-02f, 1.81107037e-02f, 7.50695765e-02f, -9.85024869e-02f, -2.03977153e-02f, -7.62824193e-02f, -1.09853502e-03f, -4.57295366e-02f,
  3.49705070e-02f, 3.64529826e-02f, -1.39636351e-02f, 4.68995385e-02f, 9.12427320e-04f, 7.69279823e-02f, 5.88151403e-02f, -5.49676530e-02f, 3.93319130e-02f, 5.76332211e-02f,
  2.56578233e-02f, 1.75959244e-02f, -8.41828585e-02f, -7.11520985e-02f, 7.38849789e-02f, 9.79067758e-03f, -7.16552287e-02f, -1.91242788e-02f, 1.56827681e-02f, 7.72456974e-02f,
  -1.42947987e-01f, 7.53126964e-02f, 6.19500130e-03f, 3.20732817e-02f, 9.46391821e-02f, -1.49346860e-02f, 5.92076741e-02f, -2.01080162e-02f, -3.81362438e-03f, 1.05205186e-01f,
  -1.45015307e-02f, -5.60357757e-02f, 6.05106913e-02f, -1.14309248e-02f, -7.13145509e-02f, -1.68149062e-02f, 7.26712197e-02f, 1.24858273e-02f, -7.27402866e-02f, 3.97097915e-02f,
  1.67186372e-02f, 1.40030265e-01f, 1.31103233e-01f, 1.31872455e-02f, -4.31288406e-02f, 6.11192221e-03f, -2.31378656e-02f, -4.73341122e-02f, 5.59625290e-02f, 4.00243849e-02f,
  1.17752925e-01f, -1.04235739e-01f, 1.85726359e-01f, 3.74001525e-02f, 1.13432959e-01f, 1.62692487e-01f, 1.76956028e-01f, 8.39570984e-02f, 4.31547090e-02f, -8.99508446e-02f,
  -3.97586934e-02f, -8.80084652e-03f, 5.59348986e-02f, 6.26360402e-02f, 1.29615724e-01f, 6.04007728e-02f, 1.37638927e-01f, 5.70824817e-02f, 2.36903682e-01f, 7.30915740e-02f,
  -2.74783988e-02f, 8.67335573e-02f, 1.43035874e-01f, 8.22791830e-02f, -7.86025524e-02f, -8.02731514e-02f, 8.90922546e-02f, 8.95799175e-02f, 3.06223389e-02f, -7.64555708e-02f,
  9.35753882e-02f, -1.79656707e-02f, 4.41402942e-02f, -3.98677066e-02f, -1.66976750e-02f, 5.31260204e-03f, 2.08993088e-02f, 3.52540314e-02f, 4.59599271e-02f, -7.80362356e-03f,
  3.29451077e-02f, -8.28294456e-02f, 3.29814106e-02f, -7.47898445e-02f, -2.24604271e-02f, 5.47104254e-02f, 4.96903621e-02f, 1.05815165e-01f, -4.66114795e-03f, 7.21785650e-02f,
  2.71639731e-02f, 2.17302870e-02f, 1.26947552e-01f, 1.17807155e-02f, 1.12233259e-01f, -3.57527509e-02f, -5.54781370e-02f, 9.94844288e-02f, 1.35480970e-01f, -2.57036313e-02f,
  1.60629805e-02f, -1.93194486e-02f, -6.82098642e-02f, 9.92923509e-03f, 6.76791295e-02f, 1.25492280e-02f, 8.02265629e-02f, -4.98114899e-02f, 1.06830243e-02f, 2.06962880e-02f,
  -2.25675907e-02f, -4.52775992e-02f, -3.40572149e-02f, 7.54210800e-02f, -1.88967753e-02f, 3.30338976e-03f, 7.31173307e-02f, -6.80246949e-02f, 6.03108704e-02f, 9.53187272e-02f,
  -3.33410874e-02f, -6.60794750e-02f, 6.65669888e-02f, -5.38998656e-03f, 6.81109130e-02f, 7.52554908e-02f, -7.88584948e-02f, 5.99992648e-02f, 5.27236313e-02f, 3.10419290e-03f,
  2.68330183e-02f, -4.15068306e-03f, -6.43977672e-02f, 7.94382244e-02f, -1.48325609e-02f, 3.80771165e-03f, 2.93852445e-02f, -5.30507788e-02f, 3.81631814e-02f, 8.86194780e-03f,
  7.19186245e-03f, 4.94659394e-02f, 5.53207286e-02f, 3.82021852e-02f, 6.61019012e-02f, 1.27344579e-01f, -2.86919959e-02f, 6.93424866e-02f, -4.25035506e-02f, 3.92010994e-02f,
  5.72450273e-03f, 1.98610984e-02f, 8.83032680e-02f, -6.62535951e-02f, 8.07068720e-02f, -3.03143263e-02f, 1.05065778e-01f, 8.05092081e-02f, 4.67734747e-02f, 6.86538452e-03f,
  5.80362827e-02f, 2.41875052e-01f, -8.25331882e-02f, 1.39177918e-01f, 1.47408783e-01f, 7.94671997e-02f, 1.89222544e-01f, 4.83691059e-02f, 4.46050800e-02f, 1.39770672e-01f,
  1.23243600e-01f, 2.04781890e-02f, 2.21513156e-02f, -1.04106508e-01f, -1.93720296e-01f, 1.18089728e-01f, -4.19442020e-02f, -1.68643504e-01f, -2.99968004e-01f, -1.09277572e-02f,
  2.38412339e-03f, -4.50050086e-02f, -8.58111158e-02f, -1.02550462e-01f, 1.92709982e-01f, 2.42992416e-02f, 4.54689711e-02f, 1.05049185e-01f, -2.40523368e-02f, 1.25048265e-01f,
  -4.79489416e-02f, 9.52670351e-03f, -1.44371688e-01f, 1.19605754e-02f, 3.33635672e-03f, -9.91268829e-02f, 3.53190899e-02f, -3.76502238e-02f, -1.31443713e-03f, 3.51101831e-02f,
  2.05944628e-02f, 3.38866040e-02f, -7.18118809e-03f, -1.84617005e-02f, 8.27684104e-02f, -1.60323381e-02f, -6.12451173e-02f, -1.32574931e-01f, -5.58121763e-02f, -6.05385788e-02f,
  5.81461564e-02f, 1.10303462e-01f, -3.93991135e-02f, 1.27160950e-02f, -1.41219348e-01f, -7.57876560e-02f, 1.27545826e-03f, 5.96691892e-02f, -9.14915949e-02f, 1.22747086e-01f,
  1.19165229e-02f, 7.90306646e-03f, -1.51507696e-02f, 2.47634333e-02f, 4.55162339e-02f, -6.68503635e-04f, -2.18694955e-02f, -1.27144093e-02f, -7.24715218e-02f, 4.63826768e-02f,
  3.78137194e-02f, -5.21941073e-02f, -6.09304905e-02f, 1.35362586e-02f, 1.54701518e-02f, 1.48267867e-02f, -8.43420997e-02f, -2.17054063e-03f, -8.01566988e-02f, -5.12171090e-02f,
  2.88918149e-02f, -2.37734690e-02f, 6.79415539e-02f, -7.96982050e-02f, 1.04182316e-02f, 2.32394263e-02f, 1.17001310e-02f, 4.60051699e-03f, 2.64215656e-02f, -1.25221945e-02f,
  1.17461234e-01f, -1.84537396e-01f, -1.18509717e-02f, -2.00479496e-02f, 3.12098842e-02f, -9.90490778e-04f, 1.70391146e-02f, 8.05014744e-03f, -2.77529415e-02f, 9.25068185e-03f,
  3.11614983e-02f, -5.33358492e-02f, 3.21795456e-02f, -5.97230457e-02f, -7.31331035e-02f, -6.92031980e-02f, 3.65079939e-03f, -2.87158992e-02f, -1.02372840e-01f, 5.95498495e-02f,
  -5.64061897e-03f, -3.99032049e-02f, 1.05001301e-01f, -8.42235424e-03f, 4.76316474e-02f, 1.87460333e-02f, 3.94943394e-02f, 1.01872254e-03f, 3.83627154e-02f, 1.77203283e-01f,
  6.32833987e-02f, 6.40396327e-02f, 5.54175079e-02f, 5.27278706e-03f, 5.52452542e-02f, 1.09549478e-01f, 2.13828608e-01f, 4.90634106e-02f, -1.03097230e-01f, -2.44426765e-02f,
  -2.38518436e-02f, -1.66121975e-01f, -1.43699527e-01f, -1.43359542e-01f, 1.20360225e-01f, 7.11943358e-02f, 1.72643378e-01f, 1.19962089e-01f, 2.37838570e-02f, -4.85313050e-02f,
  -1.06671892e-01f, 3.01122367e-02f, 1.06815010e-01f, -2.24109702e-02f, -1.03853136e-01f, -1.47736311e-01f, -2.16149185e-02f, -5.28452024e-02f, 9.36153531e-02f, -4.04555835e-02f,
  -1.99733004e-01f, 1.87089652e-01f, -2.11685766e-02f, 3.88292521e-02f, -4.18025302e-03f, 2.80707311e-02f, 3.08994707e-02f, 7.89155141e-02f, -7.11379051e-02f, -4.34018448e-02f,
  -7.85506368e-02f, 2.47494914e-02f, 4.67839241e-02f, 3.00235581e-02f, 6.00444414e-02f, -1.86195765e-02f, 8.21164176e-02f, 1.50742814e-01f, 7.38597736e-02f, 1.33690750e-02f,
  -8.52817371e-02f, 8.50017294e-02f, 3.55920219e-03f, -3.70298289e-02f, 4.57720570e-02f, -4.26303223e-03f, 8.81634951e-02f, -2.78579164e-02f, 1.20264463e-01f, 5.25056086e-02f,
  -7.17178509e-02f, -2.67876815e-02f, -1.56215029e-02f, 4.54727672e-02f, 4.35838662e-02f, -7.65003487e-02f, -1.30438339e-02f, -3.17362733e-02f, 2.66040880e-02f, -2.34558266e-02f,
  -1.89933628e-02f, 1.02863498e-02f, -1.47027178e-02f, -3.16395089e-02f, -9.64232683e-02f, 7.91299120e-02f, -1.58230066e-02f, -5.26215583e-02f, 4.57460843e-02f, 3.23722884e-02f,
  1.93640832e-02f, 6.45177588e-02f, 8.02006479e-03f, -4.02091816e-03f, -9.74469353e-03f, 1.83955673e-02f, 1.32051585e-02f, -3.84535491e-02f, 4.59731519e-02f, -1.90165211e-02f,
  -3.23388875e-01f, 1.16818555e-01f, -1.43872947e-01f, -1.18444655e-02f, 3.96756940e-02f, -4.85882722e-02f, -6.97052060e-03f, -4.77087870e-02f, -5.88018410e-02f, 6.56720251e-02f,
  4.40238118e-02f, 4.97929864e-02f, -1.07077554e-01f, -4.37236875e-02f, -4.86007845e-03f, -3.38753052e-02f, 2.87507717e-02f, -6.75906911e-02f, -5.06310677e-03f, -4.75340933e-02f,
  4.56273332e-02f, -1.57273300e-02f, -3.14041823e-02f, -2.00510416e-02f, 3.78443338e-02f, -7.22059160e-02f, -9.82010290e-02f, -1.02060817e-01f, 3.57331075e-02f, -7.50069395e-02f,
  -1.79275237e-02f, -9.83055905e-02f, 1.01312339e-01f, 1.55964270e-02f, -1.80741474e-02f, 6.78016394e-02f, 5.68322018e-02f, -8.60566460e-03f, -8.91467184e-02f, -2.01426875e-02f,
  6.42170236e-02f, -6.28648847e-02f, -1.02159433e-01f, -7.23132491e-02f, -2.72019934e-02f, 4.55151163e-02f, 4.76754718e-02f, 8.67919847e-02f, 2.16014739e-02f, -3.75367366e-02f,
  -4.57583740e-03f, -3.86952050e-02f, 5.55334389e-02f, 4.03688475e-03f, -3.48695554e-02f, -3.32233822e-03f, 2.46686488e-02f, 5.80546930e-02f, 6.36279210e-02f, 1.50133342e-01f,
  5.93670160e-02f, 1.37355611e-01f, -5.08294590e-02f, 3.34297158e-02f, 5.07462770e-02f, -6.16439097e-02f, -6.79463744e-02f, 4.81621362e-02f, -1.49502914e-04f, -8.94131139e-02f,
  9.14744884e-02f, 6.68649897e-02f, 6.15294874e-02f, -2.22885422e-02f, 5.21196686e-02f, -7.93588161e-02f, -6.94466978e-02f, 2.01701056e-02f, -6.09247573e-02f, -2.60779150e-02f,
  9.95970145e-02f, 2.20830198e-02f, -7.41808582e-03f, -2.30871253e-02f, -5.71971163e-02f, 6.59670830e-02f, -4.76943649e-04f, 2.06081234e-02f, 2.80304649e-03f, -1.18526302e-01f,
  -8.45619664e-02f, -8.87344331e-02f, 5.43509871e-02f, -1.01307519e-01f, 4.63287793e-02f, 1.07530840e-02f, 3.69227529e-02f, -4.22029756e-03f, -5.25940806e-02f, -2.64352802e-02f,
  9.70663689e-03f, -6.39629737e-02f, -4.26767170e-02f, -3.54488790e-02f, -1.86032355e-02f, -3.00572477e-02f, -1.95281319e-02f, 7.27330102e-03f, -4.84381132e-02f, 3.09364423e-02f,
  -1.07437884e-02f, 1.53327556e-02f, 7.18096793e-02f, 3.81913558e-02f, -5.41373864e-02f, -6.18445165e-02f, 8.11260119e-02f, 1.48502272e-02f, -7.59479254e-02f, 3.89530398e-02f,
  -1.39161259e-01f, 5.30993827e-02f, -2.15463042e-02f, 9.57181677e-03f, 9.50699225e-02f, 2.55903341e-02f, -3.11728772e-02f, 1.68547314e-03f, 6.91706762e-02f, -4.54053693e-02f,
  1.08622901e-01f, -3.52661051e-02f, -4.47549708e-02f, 3.58698927e-02f, 4.87124827e-03f, -6.26405999e-02f, -5.93215879e-03f, 8.92550945e-02f, -4.23285030e-02f, 1.12697696e-02f,
  -9.72864926e-02f, 3.69084217e-02f, 6.82674423e-02f, -7.59169683e-02f, 8.59353915e-02f, -6.26881467e-03f, -8.65046605e-02f, -4.04794551e-02f, -1.47146443e-02f, -8.67448077e-02f,
  -3.53204876e-01f, 5.66598848e-02f, -7.88130388e-02f, -8.76411945e-02f, 1.33654267e-01f, 7.81194344e-02f, 4.57831509e-02f, -7.87121207e-02f, 2.04277914e-02f, -5.06037138e-02f,
  2.06585582e-02f, 5.38213998e-02f, 9.60122421e-02f, 2.65625399e-02f, 3.57106999e-02f, -1.36404857e-01f, -9.85283181e-02f, -1.65255994e-01f, -1.03528194e-01f, 2.25529168e-02f,
  1.08007476e-01f, -6.73029721e-02f, -1.58955790e-02f, -4.00309935e-02f, 4.80389483e-02f, -6.48404518e-03f, -4.26401645e-02f, 1.05020367e-01f, -1.55750075e-02f, -1.33384569e-02f,
  1.66561827e-02f, 2.49739736e-02f, 7.43222386e-02f, 7.79944882e-02f, 1.02932326e-01f, -4.20640297e-02f, 7.74377817e-03f, 3.01361047e-02f, 6.50612712e-02f, -6.61366433e-02f,
  5.77019202e-03f, 7.29616135e-02f, -3.72312665e-02f, 5.83457155e-03f, 2.23048218e-03f, -3.62858064e-02f, -7.77739063e-02f, -1.43700615e-01f, -8.63615572e-02f, -5.88125549e-02f,
  1.34178415e-01f, 1.37900710e-01f, 1.08217886e-02f, -3.50165740e-02f, 6.38685375e-02f, 1.02949897e-02f, -1.24012539e-02f, 7.08818808e-02f, 3.58232297e-02f, -6.97680637e-02f,
  1.63163822e-02f, -5.06593697e-02f, 7.69424886e-02f, -1.68115534e-02f, 3.63239162e-02f, -6.86516613e-03f, 5.12849391e-02f, 7.86412284e-02f, 4.63699661e-02f, -3.70889306e-02f,
  2.93485168e-02f, -2.12910883e-02f, -3.38932909e-02f, -1.62574537e-02f, 1.76357329e-02f, 4.10225876e-02f, 1.08664222e-02f, 2.94107143e-02f, -3.93059887e-02f, -7.19065368e-02f,
  6.76919892e-02f, -2.59339111e-03f, -4.31086347e-02f, 7.98216462e-02f, 7.64962956e-02f, -2.58199051e-02f, 1.78101461e-03f, 4.89353873e-02f, -6.35642037e-02f, -3.75969857e-02f,
  -1.22433685e-01f, 5.91442585e-02f, -6.79493248e-02f, -1.27448782e-01f, 5.97515516e-02f, -7.32962191e-02f, -4.44313139e-02f, -4.30009626e-02f, -3.58676873e-02f, -5.09567112e-02f,
  -3.61240506e-02f, -1.10437058e-01f, -4.58530039e-02f, -4.77820858e-02f, 2.60915849e-02f, 3.07416748e-02f, -1.36346921e-01f, -9.04392675e-02f, 3.15122008e-02f, -5.12408502e-02f,
  -7.03466609e-02f, -1.02550916e-01f, -1.56266287e-01f, -1.25614956e-01f, 6.78182170e-02f, -2.39472277e-02f, -2.34255590e-03f, -1.10632800e-01f, -3.96525487e-02f, -2.65545547e-01f,
  3.42406660e-01f, 1.27223670e-01f, 7.60684982e-02f, 2.50629991e-01f, 1.90754414e-01f, 1.86906621e-01f, 1.55461386e-01f, 5.75372577e-03f, 4.74961139e-02f, 1.23114549e-01f,
  1.74207315e-02f, -4.39626276e-02f, -1.31506518e-01f, -1.02690347e-01f, -6.85129017e-02f, 1.95750937e-01f, 2.08607748e-01f, -3.21297236e-02f, -2.24117935e-02f, 2.02784017e-02f,
  1.27879739e-01f, 2.79011391e-02f, 9.85440612e-02f, 4.56861891e-02f, 4.98868041e-02f, -2.51854938e-02f, 3.47989015e-02f, -1.61286462e-02f, -3.55448499e-02f, 1.63312361e-01f,
  -2.90985405e-02f, 2.30323784e-02f, 3.94054441e-05f, -3.64312232e-02f, -3.03815166e-03f, 2.95049744e-03f, -5.52686080e-02f, -8.63210205e-03f, 3.22988778e-02f, 1.60644650e-02f,
  1.20408051e-02f, -7.90683925e-02f, 2.64381263e-02f, -7.58147910e-02f, -3.30579057e-02f, 4.92686108e-02f, 1.42459781e-03f, -4.41571772e-02f, -1.01196459e-02f, -1.16278477e-01f,
  -2.01563276e-02f, 1.18549667e-01f, 8.31040461e-03f, -1.30658686e-01f, -9.30438563e-02f, -7.17762113e-02f, -6.23232014e-02f, -6.44988716e-02f, 1.14428308e-02f, 5.57426624e-02f,
  4.89069857e-02f, 1.92749184e-02f, -8.74853879e-02f, 6.25971705e-02f, -2.89406814e-02f, -3.65247354e-02f, -1.44178867e-02f, 2.18609478e-02f, 7.49826953e-02f, 3.81586589e-02f,
  2.16539148e-02f, -5.62340580e-02f, 2.33420525e-02f, 6.62934557e-02f, -4.55367826e-02f, 3.02613433e-03f, 1.60828698e-02f, 7.56010413e-03f, 1.85600426e-02f, -8.40001777e-02f,
  -2.04450749e-02f, -1.56460050e-02f, 2.37870496e-02f, -7.49095976e-02f, -4.41446528e-02f, 7.88686052e-02f, -6.38798103e-02f, -7.16398582e-02f, 1.91216450e-03f, 3.74068357e-02f,
  -1.33453412e-02f, -2.69458979e-01f, 1.97665691e-02f, -3.04886512e-03f, 3.72243188e-02f, 3.87182608e-02f, 1.72894932e-02f, -1.23974960e-02f, 5.96136898e-02f, 1.20476335e-02f,
  -4.30853553e-02f, -3.06779891e-02f, -6.73696697e-02f, 3.08037475e-02f, 1.17798455e-01f, -2.94410419e-02f, 7.77012184e-02f, 1.02725811e-01f, -3.69920768e-02f, 7.59745110e-03f,
  4.99191172e-02f, -1.28932633e-02f, 1.57051887e-02f, 1.42022511e-02f, -4.13163891e-03f, 8.55543688e-02f, -1.71084199e-02f, 7.88740665e-02f, -8.07857290e-02f, 1.25394151e-01f,
  -9.67146754e-02f, -8.69427919e-02f, 1.28789330e-02f, -3.28102224e-02f, -8.26281384e-02f, 3.22658420e-02f, 7.56689534e-02f, 1.70955881e-01f, 7.18584433e-02f, 3.00994907e-02f,
  -9.96108949e-02f, 2.90132109e-02f, 1.00539714e-01f, 5.12642600e-02f, 1.73700809e-01f, 1.25444993e-01f, 1.41970932e-01f, 2.22946852e-01f, 1.54683828e-01f, 1.74412914e-02f,
  1.08333550e-01f, -3.37103866e-02f, 6.70453683e-02f, 7.43185505e-02f, -3.04869749e-02f, -4.62895550e-04f, -1.98572017e-02f, -7.63853490e-02f, 5.07813655e-02f, 4.98909056e-02f,
  -7.06369653e-02f, 1.37163261e-02f, 1.14138737e-01f, 5.89642823e-02f, 1.68415215e-02f, -6.77337125e-02f, 5.18986173e-02f, 4.81039174e-02f, -3.37525792e-02f, 5.00748213e-03f,
  -4.17756289e-02f, 4.44554575e-02f, -1.02889553e-01f, 4.39984091e-02f, 5.36465049e-02f, -5.83223067e-02f, 9.09950025e-03f, 6.74340650e-02f, 2.58202665e-02f, 2.34776363e-02f,
  -3.37665007e-02f, -7.91362021e-03f, -1.07633740e-01f, 7.98817575e-02f, 1.00928508e-01f, -6.82325959e-02f, -9.46697518e-02f, 1.02335690e-02f, 8.81145820e-02f, 5.02426364e-02f,
  6.61886781e-02f, -2.69587394e-02f, -2.35767625e-02f, -8.47006962e-02f, -9.21597406e-02f, 4.65541333e-03f, 3.76538411e-02f, -8.87977555e-02f, 5.02514876e-02f, -6.90896064e-02f,
  -4.45900746e-02f, 3.67534198e-02f, 3.25316750e-02f, -8.54998734e-03f, 5.38932011e-02f, -1.93365552e-02f, 3.38366106e-02f, 1.61708056e-04f, -8.30188170e-02f, 4.13924754e-02f,
  -8.82490352e-03f, -6.92407712e-02f, -1.08496651e-01f, 1.12864941e-01f, -2.64070481e-02f, -6.75177842e-04f, 9.59498286e-02f, -5.15277088e-02f, 5.12187183e-02f, -6.39745891e-02f,
  -2.39087090e-01f, -1.16401734e-02f, -1.12793133e-01f, 6.44601062e-02f, -3.87221761e-03f, 3.52033488e-02f, 2.61402298e-02f, -2.00148560e-02f, -1.14723094e-01f, 3.75032127e-02f,
  -6.43809587e-02f, -9.44169164e-02f, 7.99020752e-03f, 5.36303744e-02f, -4.24738973e-03f, -2.27941927e-02f, -4.57786210e-02f, -5.41096590e-02f, 8.18658322e-02f, -6.53081462e-02f,
  -1.77723216e-03f, -5.81991151e-02f, 6.30309656e-02f, -1.78286918e-02f, -1.03533283e-01f, 3.49257588e-02f, -6.29094318e-02f, -2.34463885e-02f, 6.40520677e-02f, -5.26186340e-02f,
  3.17997299e-02f, 5.53250052e-02f, -2.75416166e-01f, -8.28665644e-02f, 9.75805242e-03f, -1.45420045e-01f, -1.55668586e-01f, 1.44724865e-02f, 3.87916937e-02f, -9.33747515e-02f,
  9.79225039e-02f, 1.44082978e-02f, -1.88894179e-02f, -5.33568580e-03f, -6.89423829e-02f, -6.03804700e-02f, -1.96493611e-01f, -1.48656785e-01f, 5.17847836e-02f, 1.18515193e-01f,
  6.15523644e-02f, 5.50872609e-02f, -1.29290354e-02f, 2.11466923e-02f, -6.12218790e-02f, -3.24742869e-02f, -6.72516087e-03f, -1.48010040e-02f, -5.15121631e-02f, -1.86862722e-01f,
  -2.47519478e-01f, 4.30509411e-02f, 4.58647087e-02f, 3.09501402e-02f, 6.94221258e-03f, -4.56846729e-02f, 7.11436197e-02f, -1.99051406e-02f, 1.03276007e-01f, 7.42894039e-02f,
  -4.37776633e-02f, 8.54848176e-02f, 4.97457981e-02f, -2.51822826e-02f, 8.09532925e-02f, -1.15241278e-02f, 6.48736581e-02f, 6.54536188e-02f, -4.47647348e-02f, -7.04721129e-03f,
  -5.12521192e-02f, -6.40924349e-02f, -5.06192558e-02f, -4.95329164e-02f, -1.03590056e-01f, -1.78031567e-02f, -7.21588777e-03f, -7.38084614e-02f, -4.06361371e-02f, -3.22764367e-02f,
  -8.83123949e-02f, -6.49349764e-02f, -6.24617487e-02f, 7.18115941e-02f, 4.70095165e-02f, -5.73833436e-02f, -5.06955257e-04f, -8.17394853e-02f, -4.09874283e-02f, -8.19346607e-02f,
  4.84141409e-02f, -8.12564120e-02f, 8.04818794e-02f, -5.96143901e-02f, -6.14703447e-02f, -7.48549104e-02f, 2.41587423e-02f, 4.90939170e-02f, 4.26317900e-02f, 3.93283330e-02f,
  -6.10547848e-02f, -6.93893358e-02f, -8.57729614e-02f, 3.10177933e-02f, -1.02690510e-01f, 5.44591062e-03f, 5.82004189e-02f, -2.65466217e-02f, 1.10622779e-01f, 9.14383307e-02f,
  -1.23911845e-02f, -2.78813429e-02f, -3.19949463e-02f, 3.18041965e-02f, -3.09560969e-02f, -9.93475541e-02f, -4.05455381e-02f, 5.07581346e-02f, 2.49145236e-02f, 4.81782742e-02f,
  2.33843047e-02f, 7.77786523e-02f, -3.64391692e-02f, -8.44586343e-02f, 6.15341403e-02f, 4.64814492e-02f, 8.30607116e-02f, -8.20193719e-03f, 1.69923599e-03f, 1.75713915e-02f,
  8.96134228e-02f, -7.93697461e-02f, 8.22894052e-02f, -1.64428330e-03f, 5.01568094e-02f, 2.83538029e-02f, -1.53517490e-03f, 4.75765467e-02f, 5.33930548e-02f, -1.59776006e-02f,
  -2.01541483e-01f, 8.99569094e-02f, -5.28415181e-02f, -2.32507046e-02f, 1.38517082e-01f, -2.62138862e-02f, -4.52199727e-02f, -4.51154560e-02f, 7.20117092e-02f, 4.53835726e-02f,
  1.61030933e-01f, 1.32752553e-01f, -2.33535208e-02f, -4.25260104e-02f, 5.16022891e-02f, -6.55763447e-02f, 1.88667071e-03f, -8.88069421e-02f, -1.08820526e-02f, -5.66702373e-02f,
  7.73152784e-02f, 9.14796591e-02f, -1.28697306e-01f, -4.37129401e-02f, 9.15570632e-02f, -3.90198827e-02f, 1.95674542e-02f, 1.11639775e-01f, 1.94809921e-02f, 2.56814454e-02f,
  -3.96915376e-02f, -2.13465877e-02f, -9.06295851e-02f, -2.15808172e-02f, -2.46168990e-02f, -8.90206620e-02f, -3.32830939e-03f, 5.62574156e-02f, 8.26763362e-02f, 4.62587848e-02f,
  6.47467226e-02f, -6.16540238e-02f, 8.01775977e-02f, -1.49911912e-02f, 8.39530677e-02f, 5.33568338e-02f, -9.82182994e-02f, -4.40933667e-02f, 7.50078037e-02f, -5.95589988e-02f,
  8.87314603e-02f, 8.31079111e-02f, -2.80251764e-02f, 3.54353786e-02f, -3.84497978e-02f, -8.39629676e-03f, 7.36350045e-02f, -2.07562689e-02f, 3.14032733e-02f, 5.47852814e-02f,
  -2.17310339e-03f, 6.30703643e-02f, 2.15095095e-03f, -3.19613256e-02f, -4.43877913e-02f, -5.43593913e-02f, -6.38606921e-02f, 5.86908609e-02f, 5.71516678e-02f, 4.90891412e-02f,
  7.60861263e-02f, -3.88599141e-03f, -4.36141007e-02f, -5.54136895e-02f, -4.03568856e-02f, -1.57572124e-02f, -3.05841584e-02f, 6.83848560e-02f, 5.29984422e-02f, -7.10923318e-03f,
  7.96142444e-02f, 2.45083589e-03f, -1.55151803e-02f, -2.08840258e-02f, 6.71196207e-02f, 1.87357794e-02f, -5.74821904e-02f, 9.80848521e-02f, 3.40661369e-02f, -7.33492076e-02f,
  3.96382511e-02f, 9.92697254e-02f, -4.83085662e-02f, -5.84820025e-02f, -4.66121221e-03f, -2.41649989e-02f, 4.22543325e-02f, 1.04160318e-02f, -5.60054742e-02f, 2.89033428e-02f,
  1.61175355e-02f, -3.18654999e-02f, 3.53034660e-02f, 7.12808147e-02f, -2.07076519e-04f, -5.06048761e-02f, 6.89040273e-02f, 5.15398383e-02f, 6.74892813e-02f, -2.69930735e-02f,
  2.50130482e-02f, -3.07205804e-02f, -1.27896830e-01f, 1.08963717e-02f, 7.62196332e-02f, -7.64463246e-02f, -7.27913082e-02f, -7.66041726e-02f, -1.47025093e-01f, -7.88715035e-02f,
  3.05497944e-01f, 8.86201859e-02f, 4.47261855e-02f, 2.04155535e-01f, 2.01849431e-01f, 4.12671044e-02f, 7.83112552e-03f, 4.84723896e-02f, 1.37379486e-02f, 6.63263127e-02f,
  7.81743228e-02f, 1.56708226e-01f, 2.08124910e-02f, 1.06705099e-01f, 3.90630635e-03f, 5.93761057e-02f, 8.55805203e-02f, 9.31277424e-02f, 1.23318739e-01f, 1.22442633e-01f,
  1.63036108e-01f, 2.09726498e-01f, 1.25669464e-01f, 1.02753155e-02f, 6.15538508e-02f, -1.63546484e-02f, 2.59862170e-02f, -3.61252879e-03f, 8.64926949e-02f, 2.13715971e-01f,
  1.95875004e-01f, -5.58834635e-02f, 4.51193117e-02f, -3.92886363e-02f, -2.58949697e-02f, -9.61701386e-03f, -5.06988652e-02f, -1.01893447e-01f, -5.10238260e-02f, 7.22066537e-02f,
  5.02998866e-02f, -2.78393598e-03f, -3.33477557e-02f, 9.83514115e-02f, -4.76425514e-03f, -1.13637252e-02f, 3.32564563e-02f, -6.66533411e-02f, 2.35173926e-02f, -1.37863858e-02f,
  -1.92572130e-03f, 7.30886459e-02f, -1.09873682e-01f, -1.52252719e-01f, -1.09621607e-01f, -5.80457039e-02f, -1.15091763e-01f, -8.03477317e-02f, -1.33164957e-01f, 6.47320300e-02f,
  5.28765656e-02f, -5.63686974e-02f, 3.13322023e-02f, -2.51816176e-02f, 9.39831063e-02f, -2.86732521e-02f, 1.36571795e-01f, 5.11712069e-03f, 4.83958572e-02f, -3.95107754e-02f,
  4.95653972e-02f, 4.21269331e-03f, -5.99441268e-02f, 2.00169384e-02f, 6.54612258e-02f, -2.38353722e-02f, -5.87271042e-02f, 1.02272302e-01f, -6.97419122e-02f, -2.06366461e-02f,
  6.41625151e-02f, -4.82803509e-02f, 2.19697189e-02f, -5.64293675e-02f, 1.44277874e-03f, 6.08208962e-02f, 4.63328771e-02f, -2.19790898e-02f, -6.93983212e-02f, 9.10600647e-03f,
  2.00156286e-01f, -1.59388930e-01f, 1.18994728e-01f, 1.06260076e-03f, 9.03537646e-02f, -2.45825592e-02f, 6.19428530e-02f, -5.51904961e-02f, 4.02304530e-03f, -3.31165157e-02f,
  -2.69756708e-02f, 6.24280982e-02f, 7.61009082e-02f, 2.29635127e-02f, 2.52669584e-02f, 7.43047372e-02f, 8.91842693e-02f, 5.19811437e-02f, -7.65244476e-03f, -2.53196042e-02f,
  -3.05710919e-02f, 8.41121450e-02f, 2.56609954e-02f, -3.03573739e-02f, -8.42029378e-02f, 1.25814602e-01f, -4.54126447e-02f, -6.08018711e-02f, 2.47393511e-02f, -4.25259992e-02f,
  3.02188575e-01f, -2.02487960e-01f, -5.53679466e-02f, 4.63063605e-02f, -7.65038431e-02f, -8.48340243e-02f, -8.51602703e-02f, -2.75161657e-02f, 7.64842108e-02f, -1.01800837e-01f,
  -1.41870752e-01f, -6.28536940e-03f, 1.48097202e-02f, 1.03398389e-03f, 1.57713056e-01f, -1.00499988e-02f, 1.00499630e-01f, 2.29701728e-01f, 1.42833024e-01f, 9.32694506e-03f,
  6.61007687e-02f, -3.36065479e-02f, 1.87980399e-01f, 1.53080180e-01f, -7.29221702e-02f, 6.11816570e-02f, 3.51137593e-02f, -8.53234082e-02f, 3.77171226e-02f, 1.22600593e-01f,
  -2.18187079e-01f, -5.32468818e-02f, 2.14536581e-02f, -4.72381487e-02f, -1.05988428e-01f, 3.58417518e-02f, -6.19507879e-02f, 7.20078871e-03f, 4.02812921e-02f, 7.57394955e-02f,
  -2.18051728e-02f, -4.93525201e-03f, -2.50495430e-02f, -6.81199832e-03f, 7.66206905e-02f, 3.83679233e-02f, 3.77860516e-02f, 5.48931025e-03f, 8.55984390e-02f, -8.65670964e-02f,
  5.82954064e-02f, 2.06272956e-02f, -8.55640788e-03f, -1.01318449e-01f, 1.12314557e-03f, 3.08505762e-02f, -8.89735594e-02f, -6.05049804e-02f, -9.36457217e-02f, -6.38886765e-02f,
  3.98673452e-02f, -2.73903161e-02f, 6.32058755e-02f, -6.02207370e-02f, 9.72717628e-02f, -5.89576066e-02f, 2.23661866e-02f, 2.21193917e-02f, 5.42801246e-02f, -6.27124682e-02f,
  8.74706805e-02f, -8.53371248e-02f, -3.08307204e-02f, -1.88273296e-03f, -4.66594007e-03f, -1.89677216e-02f, -2.29153521e-02f, -5.38937338e-02f, -5.54596679e-03f, 1.34538105e-02f,
  7.69180432e-02f, 3.84687744e-02f, -5.42982034e-02f, 1.82225369e-02f, 3.73542234e-02f, -2.43103169e-02f, 7.79617727e-02f, -3.78878228e-02f, 1.93205811e-02f, 4.88433652e-02f,
  -1.80408880e-01f, 1.55030740e-02f, -2.77750399e-02f, 1.09817691e-01f, 5.65969348e-02f, -2.68681371e-03f, -5.84904999e-02f, -1.50507828e-02f, -4.18337397e-02f, -7.34970123e-02f,
  -2.53358693e-03f, -2.54205149e-02f, 6.52026152e-03f, -5.73582724e-02f, 5.32321073e-02f, 5.09912111e-02f, -3.18713933e-02f, 8.33704472e-02f, 3.77565548e-02f, -6.93272939e-03f,
  -4.13992181e-02f, 7.63797909e-02f, -8.57684314e-02f, -5.87426499e-02f, 5.66703901e-02f, 5.83448075e-03f, -9.69874710e-02f, -1.08440377e-01f, 3.00052650e-02f, -4.88648862e-02f,
  -1.57550514e-01f, 2.47948706e-01f, 3.23857181e-02f, -2.97412053e-02f, -5.47259971e-02f, 2.76012719e-02f, 1.64443836e-01f, 8.92995074e-02f, 2.29987297e-02f, 1.07647873e-01f,
  1.66471377e-01f, -2.84544565e-02f, 3.08976434e-02f, 4.64866199e-02f, -1.55416578e-02f, 9.28563625e-02f, 6.91528572e-03f, -2.91464645e-02f, -2.28265613e-01f, -5.67298662e-03f,
  7.86061678e-03f, -8.01511705e-02f, -5.74805308e-03f, -8.63104984e-02f, 2.11154465e-02f, -5.07697649e-02f, 1.24637187e-01f, 9.61747617e-02f, 7.47134862e-03f, 1.13576524e-01f,
  -1.35969400e-01f, 1.61217630e-01f, -8.36493224e-02f, -1.61424950e-02f, -2.35514957e-02f, -5.56282476e-02f, 1.93072166e-02f, -6.56828955e-02f, 1.06300926e-02f, -5.88388294e-02f,
  5.50962351e-02f, 1.61049590e-02f, 6.62093014e-02f, 2.69913338e-02f, -6.96437210e-02f, -1.59337707e-02f, 8.69021863e-02f, -5.32668307e-02f, -4.49002162e-02f, 2.75720214e-03f,
  1.35494173e-01f, 4.33509387e-02f, -7.85260051e-02f, 1.16572618e-01f, 3.64790969e-02f, -7.75633529e-02f, 7.02668354e-02f, 3.60075273e-02f, 5.29853888e-02f, 4.56086174e-02f,
  -6.71733767e-02f, -5.37337251e-02f, 8.48817974e-02f, 8.56783539e-02f, -5.45795858e-02f, 5.71127534e-02f, 5.94569184e-02f, 6.90207481e-02f, -4.23447862e-02f, 1.34123135e-02f,
  -3.54123637e-02f, 1.25598703e-02f, -9.24184918e-03f, -3.12846154e-02f, 2.74988823e-02f, -3.59178074e-02f, 7.28364140e-02f, -6.31817877e-02f, 3.69855613e-02f, 5.59348799e-02f,
  -5.79725429e-02f, -1.53963687e-02f, 6.15004525e-02f, -6.66921437e-02f, 5.49881943e-02f, 4.30609658e-02f, -6.72191605e-02f, -1.42614488e-02f, -4.36033756e-02f, 2.90477872e-02f,
  -1.58995420e-01f, 1.66541025e-01f, -8.52856636e-02f, -2.40102597e-02f, -7.53456578e-02f, -5.82588799e-02f, 3.83195840e-02f, 3.05949431e-02f, 4.93858457e-02f, -1.07219569e-01f,
  7.92307556e-02f, -9.36523601e-02f, 5.42901456e-02f, 2.08973568e-02f, -4.99523021e-02f, 1.63721777e-02f, -5.51723540e-02f, -2.79533435e-02f, 4.59893830e-02f, 3.00008748e-02f,
  -1.09373823e-01f, -8.06587860e-02f, -6.31885305e-02f, -1.28928676e-01f, -1.14515409e-01f, -2.03977883e-01f, -1.69700697e-01f, -1.25859588e-01f, -2.01883405e-01f, -1.72954530e-01f,
  1.91327911e-02f, 2.72907734e-01f, 3.76204960e-02f, 9.66534838e-02f, -1.68866734e-03f, -2.83834767e-02f, -5.28739616e-02f, -7.66098648e-02f, -4.97715436e-02f, 7.32273459e-02f,
  6.63657635e-02f, -9.00534093e-02f, 3.78275290e-02f, -2.84906905e-02f, -6.01397967e-03f, 1.66159961e-02f, 1.07616171e-01f, 1.57220848e-02f, -2.04409689e-01f, -1.53820068e-01f,
  -3.19457287e-03f, 5.08981198e-02f, 1.57308802e-02f, -6.56062365e-02f, 9.23089907e-02f, -3.92350815e-02f, 1.19704232e-01f, 9.43295658e-02f, 3.42620201e-02f, 2.03510478e-01f,
  7.14057386e-02f, 1.32500798e-01f, -1.19294003e-01f, 5.74741550e-02f, -8.91455822e-03f, -1.13052735e-02f, -9.65179354e-02f, -2.63861325e-02f, -4.28036451e-02f, 8.07551444e-02f,
  -1.64619610e-02f, 4.76846881e-02f, 4.82810698e-02f, 6.89563975e-02f, -1.19409813e-02f, -1.92180835e-02f, 1.37509212e-01f, 3.36911120e-02f, 3.21015082e-02f, 1.29592866e-01f,
  2.12149322e-02f, 1.13680474e-01f, 2.04110853e-02f, 2.15369333e-02f, -6.09577559e-02f, -6.51483843e-03f, 2.70585660e-02f, -4.57282364e-02f, -1.56917088e-02f, 8.98312218e-03f,
  9.84821934e-03f, -8.02522376e-02f, 4.22020517e-02f, -2.67764069e-02f, -4.16614339e-02f, 2.52318531e-02f, 5.40174954e-02f, -6.67014271e-02f, -1.89034268e-02f, 5.06088994e-02f,
  -5.79733588e-02f, 6.78806901e-02f, -4.21441197e-02f, -8.03486258e-02f, 6.71469048e-02f, -8.44450295e-02f, 2.42595337e-02f, 5.80054112e-02f, 3.52046941e-03f, -4.47630845e-02f,
  1.95092428e-02f, 1.70145165e-02f, -4.40163985e-02f, -3.42159206e-03f, -4.58960570e-02f, -8.95662885e-03f, 6.85234293e-02f, -4.95377406e-02f, 2.33251527e-02f, 7.75003135e-02f,
  -2.71156169e-02f, -1.02712683e-01f, -7.01430067e-03f, -9.56920385e-02f, 6.70129731e-02f, 8.11245516e-02f, 9.58466679e-02f, -1.22827822e-02f, 4.20385189e-02f, -1.88623313e-02f,
  -3.40902321e-02f, 4.55597602e-02f, 5.00372835e-02f, -7.97657575e-03f, -1.21172078e-01f, -1.97419543e-02f, 3.82236019e-02f, 3.79520692e-02f, 1.90318767e-02f, 5.69656417e-02f,
  8.36166143e-02f, -1.34012043e-01f, -1.10850140e-01f, -1.34713590e-01f, -1.45119820e-02f, -1.96482837e-01f, -7.92087764e-02f, -1.33169457e-01f, -1.12427257e-01f, -7.12454766e-02f,
  4.12812158e-02f, 1.00866370e-01f, -1.44798949e-01f, -2.04246547e-02f, -6.69522136e-02f, -1.35041952e-01f, -1.96092967e-02f, -1.60389487e-02f, 7.09732017e-03f, -7.51874074e-02f,
  -7.77483806e-02f, -7.58765033e-03f, -1.70331851e-01f, -1.16740122e-01f, -1.84845448e-01f, -3.46674658e-02f, -1.81736633e-01f, -2.02731848e-01f, -1.60376206e-01f, -1.66877136e-01f,
  -1.06844775e-01f, -4.45839241e-02f, 2.59287134e-02f, -6.35331124e-02f, 3.17811370e-02f, 1.29835242e-02f, 2.97854897e-02f, -1.22906104e-01f, -1.12095037e-02f, -4.80836704e-02f,
  -1.77552149e-01f, -3.18941846e-02f, -5.85043617e-02f, 1.02421053e-01f, -8.06257129e-03f, -6.07694760e-02f, -1.21373005e-01f, -6.28754683e-03f, 4.95438538e-02f, -8.86144340e-02f,
  -6.95149526e-02f, 1.22649223e-02f, 2.33911388e-02f, 6.42008753e-03f, 1.67250391e-02f, 3.98687646e-02f, 1.07441343e-01f, -7.43832737e-02f, 8.20484087e-02f, 3.03029027e-02f,
  3.82902585e-02f, 5.95835894e-02f, -9.37806666e-02f, -5.24201151e-03f, 7.00940341e-02f, -4.66227328e-04f, 8.39971900e-02f, 7.36677796e-02f, -9.22679603e-02f, 9.84252542e-02f,
  6.06098510e-02f, -9.92338061e-02f, -9.16492790e-02f, -1.59822535e-02f, 7.01985434e-02f, 3.11624650e-02f, 5.56193143e-02f, 3.95224430e-02f, 9.00853649e-02f, 4.03445633e-03f,
  2.83540711e-02f, 3.08868475e-02f, 3.88434567e-02f, -5.00432663e-02f, -3.03943437e-02f, -1.12125948e-02f, 7.33271688e-02f, 2.58351900e-02f, 7.25455433e-02f, 4.97575924e-02f,
  2.28399914e-02f, 9.14645102e-03f, -1.34544577e-02f, 1.20724738e-02f, 3.68090831e-02f, -2.28847060e-02f, -5.49134687e-02f, -6.44720942e-02f, 6.02408126e-03f, -4.91685569e-02f,
  -4.57810387e-02f, -3.73234525e-02f, -3.33523145e-03f, -5.11475243e-02f, 3.43025625e-02f, 1.51133597e-01f, -4.92346585e-02f, 9.58995596e-02f, -5.30546196e-02f, 2.81446092e-02f,
  -6.58082170e-03f, 2.79568303e-02f, -9.10029784e-02f, 6.11532666e-02f, -3.43141444e-02f, -9.55870450e-02f, 1.17649354e-01f, 3.07757426e-02f, -3.65260541e-02f, 1.28010556e-01f,
  1.47746935e-01f, -2.08142176e-02f, 2.11767629e-02f, 5.84501363e-02f, 1.99598223e-02f, -4.99312021e-02f, -2.35099513e-02f, 6.81590661e-02f, -1.04368612e-01f, 1.04651853e-01f,
  -9.60026756e-02f, -2.85422243e-02f, -2.46967360e-01f, 3.68982889e-02f, 4.51356247e-02f, -2.15171382e-01f, -1.29213884e-01f, -6.15704767e-02f, -2.75290143e-02f, 8.11361372e-02f,
  1.23627126e-01f, 2.30226249e-01f, 1.95019752e-01f, 1.21734001e-01f, -4.32035699e-02f, -3.64896841e-02f, -2.72236634e-02f, -2.99934484e-03f, -8.99752378e-02f, 5.27891181e-02f,
  2.39975844e-02f, -5.25426529e-02f, 1.66809596e-02f, -1.95931527e-03f, 4.23985682e-02f, 5.43587701e-03f, 6.43875003e-02f, 2.98444573e-02f, -2.23630238e-02f, 5.87349609e-02f,
  -5.53833880e-02f, -2.44372282e-02f, 4.10434604e-02f, 1.26837596e-01f, -6.58097789e-02f, 5.90601005e-02f, -4.70920503e-02f, 5.30417040e-02f, -6.12450205e-02f, -2.58608311e-02f,
  -3.28715816e-02f, 1.08856879e-01f, -6.79946039e-03f, 6.12514839e-02f, -8.21674988e-02f, -1.86220631e-02f, 1.85814947e-02f, -5.46390526e-02f, -1.38843236e-02f, 7.59044215e-02f,
  6.96237758e-02f, 4.26925272e-02f, -1.14206210e-01f, -1.02208368e-01f, 3.39090973e-02f, 1.12416837e-02f, -9.10968035e-02f, 1.01706229e-01f, 1.10665904e-02f, -7.89427385e-02f,
  -4.04440127e-02f, 3.30095924e-02f, -6.04051948e-02f, -3.81393991e-02f, 1.90271325e-02f, -6.23322651e-03f, -4.05816622e-02f, 3.31576318e-02f, 1.57417022e-02f, -3.47958580e-02f,
  -2.88732965e-02f, -4.15552072e-02f, 2.35443469e-03f, 1.80799060e-03f, 8.15547034e-02f, -7.82185942e-02f, -1.47199910e-02f, -4.02235352e-02f, -3.26457918e-02f, 2.79545248e-03f,
  5.95930144e-02f, -2.72798706e-02f, 5.84194511e-02f, 2.67551560e-02f, 2.58899704e-02f, -7.55006587e-03f, 9.65653174e-03f, -2.81413663e-02f, 8.84288847e-02f, -8.64553601e-02f,
  8.15464556e-02f, -6.49864823e-02f, -9.59742535e-03f, 1.61743369e-02f, -1.64100882e-02f, 4.00786586e-02f, 7.85686970e-02f, 4.37041111e-02f, 4.00097556e-02f, -2.63518363e-04f,
  -6.27739877e-02f, -5.30787893e-02f, 7.89427608e-02f, 1.86015815e-02f, -6.41603246e-02f, 2.63061561e-02f, 5.79803735e-02f, -2.95153875e-02f, -4.71184440e-02f, 7.64254630e-02f,
  9.68205929e-02f, -8.36925488e-03f, 4.52382267e-02f, -3.62361223e-02f, -7.16571063e-02f, -1.10534821e-02f, -3.87603268e-02f, -8.95062983e-02f, -7.51288608e-02f, -7.03041106e-02f,
  5.10404110e-01f, 2.00341120e-01f, 5.15309535e-02f, 1.21533811e-01f, 1.05845153e-01f, 9.16414559e-02f, 2.87094355e-01f, 9.97775346e-02f, 5.71638756e-02f, 1.23150937e-01f,
  -4.84774336e-02f, -1.88834995e-01f, -1.05401061e-01f, -2.33732805e-01f, -2.23784167e-02f, -1.37916142e-02f, 7.59484246e-02f, 2.09443574e-03f, -1.47876213e-03f, -2.56167315e-02f,
  -9.85676516e-03f, 9.60749909e-02f, 5.11229150e-02f, 2.56999061e-02f, -8.87163281e-02f, -1.54051825e-01f, -2.88838223e-02f, -1.00217527e-02f, -1.25274628e-01f, -1.64188117e-01f,
  -1.13444544e-01f, 1.45833790e-01f, -6.52725846e-02f, -4.42128554e-02f, -9.10346105e-04f, -3.04267295e-02f, 6.29006103e-02f, -2.37684995e-02f, -8.22871104e-02f, 6.50901645e-02f,
  -2.45825946e-02f, -1.11160621e-01f, -4.88608442e-02f, -5.67760058e-02f, 1.04208969e-01f, -7.15289414e-02f, 4.25684676e-02f, 4.30933945e-02f, 8.68652947e-03f, -4.01876792e-02f,
  -1.14031911e-01f, 7.44013488e-02f, 7.57680982e-02f, 2.81943493e-02f, -9.54658017e-02f, -1.17465377e-01f, 6.94455504e-02f, -2.53160335e-02f, -6.03898950e-02f, 1.53330505e-01f,
  -2.67955847e-02f, -1.89986397e-02f, -3.12439911e-02f, -2.05195285e-02f, -1.45846810e-02f, -4.32693213e-02f, -4.85170558e-02f, -3.11823580e-02f, 2.41045710e-02f, -1.04172872e-02f,
  -5.31990714e-02f, 5.52801266e-02f, 3.95626910e-02f, 2.98511107e-02f, -5.91476336e-02f, -2.47449931e-02f, 4.19739783e-02f, -5.93346469e-02f, 5.11703454e-02f, -4.43527848e-02f,
  -2.52535008e-02f, 6.03608489e-02f, 6.60059005e-02f, -7.67914858e-03f, -4.32579778e-02f, -2.66482644e-02f, 1.56389978e-02f, -1.01644672e-01f, -6.80587664e-02f, 1.92795098e-02f,
  7.08906800e-02f, -5.30043133e-02f, 1.93667281e-02f, -7.22047389e-02f, 3.02016083e-02f, -6.60560094e-03f, -1.34969922e-03f, 3.99182290e-02f, 3.63333821e-02f, -2.27664746e-02f,
  8.54969993e-02f, 3.23429480e-02f, 1.05736449e-01f, -2.02262327e-02f, 7.17864931e-02f, 1.15582831e-01f, 5.23544801e-03f, -2.03739363e-03f, -2.98364181e-02f, 7.66151398e-02f,
  3.21354493e-02f, 1.95055425e-01f, 6.34212121e-02f, 3.81532870e-02f, 1.01615004e-01f, 1.24376133e-01f, 7.53350137e-03f, 8.88274312e-02f, 8.60902220e-02f, 2.76804328e-01f,
  9.31680016e-03f, -4.79301065e-02f, 1.78933233e-01f, -3.57616059e-02f, -7.85618648e-02f, -8.88688117e-02f, 3.84125933e-02f, -3.30009833e-02f, -1.66720320e-02f, -7.25834444e-02f,
  -1.08033225e-01f, -5.10619842e-02f, -6.19474538e-02f, -8.90724808e-02f, 1.79437324e-02f, 4.39705737e-02f, 1.59166986e-03f, 3.39649506e-02f, -1.29766800e-02f, -1.55065492e-01f,
  -1.04147479e-01f, -1.48646673e-02f, -6.23690262e-02f, 4.95288521e-02f, 7.34784380e-02f, 2.88264193e-02f, 1.31155908e-01f, 1.15002915e-01f, 4.31020856e-02f, 6.78509623e-02f,
  1.63615778e-01f, 1.54464170e-01f, -9.15369317e-02f, -1.47292748e-01f, 9.43657756e-02f, -2.40292493e-02f, 5.81732765e-02f, 7.50167668e-02f, -5.11515066e-02f, -2.07922235e-02f,
  -3.35263126e-02f, -8.44542310e-02f, 2.71683075e-02f, -9.70316082e-02f, 4.56794463e-02f, -3.46044414e-02f, -1.73007231e-02f, 3.85763384e-02f, 4.35349718e-02f, -6.41567633e-02f,
  -9.29990709e-02f, 7.73977116e-02f, 3.45274657e-02f, 1.54034961e-02f, 2.78354506e-03f, 7.17056021e-02f, 3.19052748e-02f, 3.25868092e-02f, -4.22592610e-02f, 1.31366551e-01f,
  -5.59730493e-02f, -2.06634123e-02f, -6.61025271e-02f, -5.75564504e-02f, -7.52916783e-02f, -6.97022751e-02f, -6.44610152e-02f, 8.06109011e-02f, -4.32816520e-02f, -6.95008039e-02f,
  1.13598965e-02f, -7.19403625e-02f, -4.79071997e-02f, 1.47979986e-02f, -4.90410067e-02f, 8.95790830e-02f, 2.88005453e-03f, -3.60025303e-03f, -6.52785320e-03f, 1.34731606e-02f,
  6.63071200e-02f, 7.31949732e-02f, 3.42719667e-02f, 7.31037483e-02f, -6.39996231e-02f, 5.89247197e-02f, -8.46397057e-02f, -1.33449420e-01f, 2.36584786e-02f, -6.38758913e-02f,
  -8.79937131e-03f, 1.95198320e-02f, 5.61757572e-02f, 7.90237915e-03f, 8.10702443e-02f, -3.11432965e-02f, 9.10408329e-03f, 8.01931173e-02f, 9.58714262e-02f, -2.05139685e-02f,
  -2.27495339e-02f, -6.93902969e-02f, -3.64563018e-02f, 1.08508088e-01f, 2.72221994e-02f, 8.95391684e-03f, -6.25336915e-02f, 9.90068093e-02f, -4.69630212e-02f, -7.65228868e-02f,
  -1.11759696e-02f, -4.50089797e-02f, -7.87540898e-02f, -4.83435728e-02f, -6.05028011e-02f, -5.78893796e-02f, 3.64266150e-02f, -5.88547327e-02f, -6.04403578e-02f, 9.52999815e-02f,
  1.00524791e-01f, 7.70019069e-02f, 1.01831861e-01f, 3.20578486e-01f, 2.12200075e-01f, 1.40301630e-01f, 1.15575027e-02f, 4.96670883e-03f, 1.97103340e-02f, -3.31145674e-02f,
  -6.07667267e-02f, 1.77506749e-02f, 4.74973880e-02f, -8.23104084e-02f, 9.79483575e-02f, 1.04073487e-01f, 2.06029072e-01f, 2.06151754e-01f, 3.52435373e-02f, 1.08500868e-01f,
  7.37283453e-02f, 8.32702145e-02f, 3.99791375e-02f, 1.21594787e-01f, 7.12691694e-02f, -3.13125961e-02f, 3.86513360e-02f, 1.55873194e-01f, 7.95304552e-02f, 1.62393153e-01f,
  2.12903116e-02f, 8.56574029e-02f, -7.52616972e-02f, -1.46294842e-02f, -5.38763814e-02f, -1.20328031e-01f, -1.02887303e-01f, -5.79153337e-02f, 1.88738536e-02f, 2.24063974e-02f,
  2.35184133e-02f, -5.84886409e-02f, -2.04051435e-02f, -5.23814326e-03f, 1.01628657e-02f, 4.16648053e-02f, 5.69100082e-02f, -1.54084796e-02f, 2.93969028e-02f, 1.44846654e-02f,
  -6.37688786e-02f, 4.80233179e-03f, 8.82975524e-04f, -3.91139574e-02f, -1.10540837e-01f, 7.33257309e-02f, -6.58183843e-02f, 4.01873104e-02f, -1.26516148e-01f, -2.71990746e-02f,
  -8.86933655e-02f, -6.88900873e-02f, -3.31071205e-02f, 7.26149417e-03f, -7.30452612e-02f, -7.65364841e-02f, -4.91278432e-03f, 3.25245336e-02f, 3.42252403e-02f, -2.45778058e-02f,
  -1.75889581e-02f, 2.69519798e-02f, 1.65400691e-02f, -1.70299504e-02f, 4.43188846e-02f, 1.96132325e-02f, -1.12343915e-01f, -9.76761058e-02f, -3.72065715e-02f, 1.16653100e-03f,
  2.95327306e-02f, 5.55878878e-02f, 4.20356430e-02f, 2.74668518e-03f, -2.54401620e-02f, -6.56424314e-02f, -2.82307081e-02f, 1.51249226e-02f, -2.67674271e-02f, 1.07373763e-02f,
  -5.26176989e-02f, -6.22150637e-02f, -1.44736404e-02f, 1.72991790e-02f, 5.35084419e-02f, 1.74412373e-02f, -4.15725261e-02f, 6.61095679e-02f, -2.07116082e-02f, -3.16577516e-02f,
  -9.59209949e-02f, 5.79036362e-02f, 4.32443107e-04f, -7.89021850e-02f, 2.36252155e-02f, -5.77319898e-02f, -1.34963047e-05f, 5.51098622e-02f, -4.31053750e-02f, 1.77939422e-03f,
  -1.02693617e-01f, 9.46093276e-02f, -8.30505881e-03f, 3.73010971e-02f, -4.54735607e-02f, 5.59868626e-02f, -1.12698600e-01f, -2.09682519e-04f, -3.46588116e-04f, 1.42123946e-03f,
  2.53966004e-01f, 1.08467825e-01f, 6.52612671e-02f, 1.63702384e-01f, 1.31066084e-01f, 7.48408213e-02f, 1.37338117e-01f, 5.39571680e-02f, 2.19505019e-02f, 5.54230958e-02f,
  1.39051333e-01f, -4.93152905e-03f, -3.36253420e-02f, 1.09970190e-01f, -2.45054774e-02f, -3.82980295e-02f, 4.63405577e-03f, 4.64766733e-02f, 1.42341286e-01f, 1.73178241e-01f,
  1.07103437e-01f, 1.74353540e-01f, 1.79382667e-01f, 1.41523212e-01f, 1.65926173e-01f, 1.23327725e-01f, 1.16262674e-01f, 3.77634056e-02f, 8.02768767e-02f, 1.69475839e-01f,
  6.69566840e-02f, 1.82726637e-01f, -6.13098033e-02f, -1.64995436e-02f, 3.81295918e-03f, 5.40542565e-02f, -1.17159365e-02f, 3.87207940e-02f, -8.75876546e-02f, 1.35366088e-02f,
  1.03205420e-01f, -4.85420832e-03f, 1.72597487e-02f, -1.11303339e-02f, 1.20610937e-01f, 4.81002256e-02f, 2.74212826e-02f, 1.02068838e-02f, 2.70949025e-02f, -8.44237953e-03f,
  4.75425441e-05f, 7.14104846e-02f, 2.07929593e-02f, -1.20922036e-01f, -1.08795494e-01f, -7.18089566e-03f, 3.02079432e-02f, 6.47193613e-03f, -8.28848928e-02f, -9.78513882e-02f,
  -1.62483975e-02f, -5.34507185e-02f, -8.84618834e-02f, 2.26264521e-02f, -6.30680658e-03f, 1.60069205e-02f, -2.29981095e-02f, -1.71894152e-02f, 4.67364341e-02f, 5.47381975e-02f,
  -9.83009040e-02f, -9.11257323e-03f, 2.87597626e-02f, 5.57392882e-03f, -6.56124428e-02f, 5.20129986e-02f, -1.71511825e-02f, 1.99088994e-02f, -5.00166491e-02f, 6.07821792e-02f,
  2.30623670e-02f, -4.24761660e-02f, 3.76430526e-02f, -1.06449723e-01f, -8.98928940e-03f, -1.71304438e-02f, 3.34615596e-02f, 3.54983881e-02f, 5.96161000e-02f, -2.69242525e-02f,
  -1.86032727e-02f, -3.07216682e-02f, 1.97457001e-02f, 3.46812755e-02f, -1.02723472e-01f, -1.07798725e-01f, 2.09853891e-03f, -1.34447724e-01f, -2.40363386e-02f, 9.43445265e-02f,
  2.15681884e-02f, 2.81791808e-03f, 2.56280471e-02f, 1.11311488e-03f, 1.19922936e-01f, -3.03328764e-02f, -1.06729873e-01f, 1.17983418e-02f, -4.13193218e-02f, -1.65947285e-02f,
  -5.59809543e-02f, -6.11048676e-02f, 8.21688958e-03f, -8.01745281e-02f, -4.40092050e-02f, 3.78692104e-03f, -1.75080746e-02f, -6.10776292e-03f, -1.42640635e-01f, -1.08602822e-01f,
  -5.82539678e-01f, 1.80446595e-01f, 8.37932974e-02f, -2.09349304e-01f, 2.14702457e-01f, 2.67547697e-01f, 3.47208828e-01f, -3.59087735e-02f, -2.31046136e-02f, 8.62266496e-02f,
  -3.39385122e-02f, -2.24900693e-01f, -2.08766744e-01f, -6.10953160e-02f, -4.35086014e-03f, 2.71791458e-01f, 1.90538615e-01f, -1.57965213e-01f, -1.82444930e-01f, -7.98703358e-02f,
  9.29580107e-02f, -1.33201271e-01f, -1.56575799e-01f, -1.38605803e-01f, 9.39254388e-02f, 1.83714647e-02f, 1.37588516e-01f, 8.23063999e-02f, 1.47222340e-01f, 1.52409747e-01f,
  3.91969420e-02f, -1.39167711e-01f, -1.54005354e-02f, -1.47085667e-01f, -2.05506515e-02f, -1.80636812e-02f, 4.67853341e-03f, 3.79245169e-02f, -8.89846906e-02f, 7.34609962e-02f,
  2.70710159e-02f, 3.02219354e-02f, -9.40938815e-02f, 3.85545716e-02f, -4.26187925e-03f, 4.79720831e-02f, 1.12206186e-03f, -1.12362392e-01f, -8.79902318e-02f, 7.06619471e-02f,
  -3.05060986e-02f, -8.99023004e-03f, -3.61048477e-03f, 1.00970641e-01f, -5.76259382e-02f, -9.56559107e-02f, 9.43261385e-03f, -4.29509692e-02f, -4.15867269e-02f, 6.27001971e-02f,
  2.45874356e-02f, -2.93877423e-02f, -1.44708212e-02f, -4.04905900e-02f, 2.01869961e-02f, -2.24557612e-02f, 4.68509719e-02f, 2.00384036e-02f, 1.80430654e-02f, 7.50857126e-03f,
  -6.41691014e-02f, 4.36022393e-02f, -2.57487930e-02f, 4.71697636e-02f, -6.46284968e-02f, -2.88086794e-02f, -8.08077585e-03f, -5.19637540e-02f, -1.53332651e-02f, 4.98891585e-02f,
  -7.70124421e-02f, 1.06705660e-02f, -2.01137215e-02f, 3.40017304e-02f, 4.68345433e-02f, 4.63941395e-02f, 3.36598381e-02f, 2.24563777e-02f, -7.90286958e-02f, -6.14184551e-02f,
  -4.62959781e-02f, -6.44716294e-03f, 7.16299638e-02f, -3.65501717e-02f, -2.91538220e-02f, 1.22623723e-02f, -7.07426965e-02f, -5.84666990e-02f, 1.94103699e-02f, -1.91610642e-02f,
  -4.68221791e-02f, -2.06661336e-02f, -2.96308845e-02f, -8.33033025e-03f, 3.70860286e-02f, 9.70298052e-03f, 2.81294398e-02f, -5.21033742e-02f, 6.61677495e-02f, 2.68803481e-02f,
  4.81806360e-02f, 1.31622344e-01f, -6.55170679e-02f, 7.71152079e-02f, -2.73871720e-02f, -4.67147343e-02f, 4.73010838e-02f, 1.18583038e-01f, 5.93715459e-02f, 1.08084902e-01f,
  -1.06557749e-01f, 1.45571247e-01f, -3.45206589e-01f, 7.90265016e-03f, 1.40016824e-01f, 4.80649702e-04f, 7.35805780e-02f, 1.02073051e-01f, 1.26070678e-01f, 8.84761661e-02f,
  1.58258334e-01f, 1.58916950e-01f, -6.48703473e-03f, -3.10556702e-02f, -1.12276919e-01f, -1.28580168e-01f, -1.03840269e-01f, -1.77299470e-01f, -2.43071154e-01f, -5.43805063e-02f,
  8.08336809e-02f, 1.95131116e-02f, 2.11120117e-02f, -1.90384127e-02f, 6.34666393e-03f, 5.72502054e-02f, -1.02711201e-01f, 6.54555252e-03f, 8.73381793e-02f, -1.15115561e-01f,
  -2.45110348e-01f, -5.49738184e-02f, 1.72742922e-02f, 1.23535387e-01f, 8.10396448e-02f, -1.22336999e-01f, 3.10764089e-02f, -6.80909455e-02f, -4.58267964e-02f, -1.05871290e-01f,
  -3.48130427e-02f, 2.81640738e-02f, 5.37628308e-02f, 2.31425595e-02f, -2.66882684e-02f, -3.71075189e-03f, -1.12113804e-01f, -2.09848315e-01f, -1.55207500e-01f, -9.25011188e-02f,
  1.19685210e-01f, 9.58508998e-03f, -6.70248643e-02f, -5.70203811e-02f, -1.01246849e-01f, 6.55627158e-03f, -7.80613497e-02f, -6.18976960e-03f, -6.03512377e-02f, -9.98762250e-02f,
  5.54569177e-02f, -1.89975407e-02f, 4.20158319e-02f, 5.54713868e-02f, 1.84650801e-03f, -3.88769731e-02f, -6.45172969e-02f, 2.99517531e-02f, -1.98220480e-02f, -6.96099922e-02f,
  -7.78646171e-02f, 4.02085017e-03f, 5.41738123e-02f, -9.61437263e-03f, 4.85825092e-02f, 2.30593178e-02f, 1.94182713e-02f, -5.65211475e-02f, -1.17964465e-02f, 4.94626500e-02f,
  3.61670516e-02f, -9.47363302e-02f, 7.32614771e-02f, -8.22483152e-02f, -2.03247294e-02f, -4.49162759e-02f, -6.70210719e-02f, -4.18820530e-02f, -1.67060420e-02f, 3.34115047e-03f,
  -1.53079424e-02f, 1.37721747e-02f, -2.54119281e-02f, 4.53931578e-02f, -2.60978751e-03f, 3.63485366e-02f, 2.23802216e-02f, -4.59776856e-02f, -5.03021926e-02f, -4.06789929e-02f,
  4.37376685e-02f, -2.95576900e-02f, 5.85902520e-02f, -2.61994209e-02f, 8.60313624e-02f, 3.93023826e-02f, 9.28592756e-02f, -6.80083036e-02f, -4.72763777e-02f, 2.93305591e-02f,
  4.03760858e-02f, -5.99186160e-02f, -5.45886606e-02f, -1.90221984e-02f, -1.88747030e-02f, -3.83434705e-02f, -1.22847170e-01f, -6.03167601e-02f, -2.80978363e-02f, 4.43703420e-02f,
  1.95211232e-01f, 4.88547049e-02f, -7.17750657e-03f, 1.79008633e-01f, 1.10864013e-01f, 8.34804773e-02f, -8.89714342e-03f, 3.84042747e-02f, 1.40224516e-01f, 4.95950617e-02f,
  5.52206710e-02f, 1.56359803e-02f, 8.48841742e-02f, -1.97661873e-02f, 8.96600485e-02f, 9.22382176e-02f, 3.94244380e-02f, 9.81247276e-02f, 6.96807131e-02f, -8.55052471e-02f,
  7.27549344e-02f, 1.02504417e-01f, 1.26095951e-01f, 7.00837225e-02f, -6.73750639e-02f, -5.65470643e-02f, 5.75196370e-02f, -7.77652413e-02f, 1.36546735e-02f, 3.78792062e-02f,
  6.15605190e-02f, -1.25309937e-02f, -1.59249306e-02f, 3.88537832e-02f, -6.57651201e-02f, -2.59953961e-02f, -4.61588893e-03f, 3.90296243e-02f, -8.06717202e-03f, 5.51602617e-02f,
  -1.08679712e-01f, 3.86561342e-02f, -2.95138303e-02f, -2.59146858e-02f, -3.37914079e-02f, -5.72679341e-02f, -2.47172248e-02f, 5.62629662e-02f, -8.67835954e-02f, 2.05337983e-02f,
  -5.36941774e-02f, -9.77536216e-02f, 4.85278815e-02f, -1.09669313e-01f, -4.86973748e-02f, -5.89998923e-02f, -1.09360497e-02f, 4.36504148e-02f, 2.78944820e-02f, 3.71109247e-02f,
  7.76190311e-02f, -5.68782128e-02f, 5.89052364e-02f, -2.76194159e-02f, -1.55553687e-02f, -1.53312273e-02f, -1.19783753e-03f, 6.46680817e-02f, 8.58446285e-02f, -3.13402414e-02f,
  -5.95682748e-02f, 1.31511566e-04f, -4.52689044e-02f, 1.04407042e-01f, -2.80808713e-02f, -6.91599846e-02f, 5.74181369e-03f, 7.68976435e-02f, 5.74829020e-02f, -7.63543248e-02f,
  -5.14427237e-02f, 6.36473596e-02f, 2.85189990e-02f, 5.80273457e-02f, -6.46498948e-02f, -1.07082212e-02f, -3.50099951e-02f, 4.01517823e-02f, -7.14159235e-02f, -9.77440923e-02f,
  1.34873703e-01f, -1.13729723e-01f, 2.02554222e-02f, 9.22281742e-02f, 6.51322380e-02f, 7.31552318e-02f, 3.79793011e-02f, -3.08991838e-02f, -2.77375784e-02f, -3.87161821e-02f,
  5.27977124e-02f, 9.24227908e-02f, 8.59012529e-02f, -7.58743212e-02f, -4.19744179e-02f, -2.24667378e-02f, -2.22552866e-02f, 4.06215228e-02f, 9.59555339e-03f, 1.04101831e-02f,
  -4.05088961e-02f, 2.83140615e-02f, 7.11888745e-02f, 2.86761299e-02f, 2.09019855e-02f, -4.88712452e-02f, -3.79357883e-03f, -3.59961577e-02f, 5.55055887e-02f, 1.13643341e-01f,
  -7.80264959e-02f, 7.71098435e-02f, 8.03453326e-02f, -2.26377830e-01f, -6.98832348e-02f, 1.39418095e-01f, 1.72951192e-01f, 4.10871208e-02f, -1.59478202e-01f, 1.16630830e-02f,
  -3.26318741e-02f, -1.07278675e-01f, 3.63171175e-02f, 5.71413785e-02f, 9.69147831e-02f, -4.81641479e-02f, -5.12965582e-02f, 3.88713144e-02f, 2.73639504e-02f, -7.74294510e-03f,
  -1.28834009e-01f, -1.61113009e-01f, -2.57940311e-02f, -1.02445148e-01f, -1.69744968e-01f, -1.38688803e-01f, 3.57795693e-02f, -1.93827208e-02f, -7.97700211e-02f, -2.46600896e-01f,
  3.52218747e-02f, 1.13791458e-01f, 2.44155843e-02f, -1.43868953e-01f, 3.74432132e-02f, -4.25917841e-02f, -4.21927609e-02f, -4.14639711e-02f, -5.51042482e-02f, 3.47796753e-02f,
  -3.14231068e-02f, -5.93181513e-02f, -1.09115191e-01f, 1.87838469e-02f, 1.66898593e-04f, 4.76983115e-02f, 9.77323875e-02f, 6.03948012e-02f, 6.30235747e-02f, -2.16731559e-02f,
  -1.56833246e-01f, 5.10310344e-02f, -8.84418376e-03f, 1.26489639e-01f, 1.15118176e-01f, -7.88126215e-02f, 3.19887847e-02f, -5.41608110e-02f, 1.17667556e-01f, 1.94278266e-02f,
  2.86147110e-02f, 4.83106226e-02f, -1.59915630e-02f, -4.15924527e-02f, 2.28343029e-02f, 4.34251986e-02f, -7.80626833e-02f, 2.40217689e-02f, 5.77276200e-02f, 3.07913795e-02f,
  2.62186248e-02f, 9.55019966e-02f, -5.30528799e-02f, -3.82510982e-02f, 4.20736633e-02f, -1.70727428e-02f, -6.46355674e-02f, 4.40579541e-02f, -5.36164828e-02f, 4.91575561e-02f,
  1.11599332e-02f, -2.36753165e-03f, 1.09466789e-02f, -4.84791249e-02f, -1.13021955e-02f, -6.68735802e-02f, 4.95133661e-02f, 1.20136263e-02f, 9.81159136e-03f, -8.25826749e-02f,
  -8.15110207e-02f, 1.38309836e-01f, -1.81423482e-02f, -1.11394394e-02f, -7.99021795e-02f, 6.69038389e-03f, 3.34615037e-02f, -6.03970475e-02f, -3.00183930e-02f, -6.80204332e-02f,
  6.83536157e-02f, -2.71344390e-02f, 7.71741718e-02f, 3.55102890e-03f, 3.32219154e-02f, -5.22911325e-02f, -4.04476225e-02f, -4.92469184e-02f, -3.68374549e-02f, -9.47159529e-02f,
  -3.32811661e-02f, 7.56658381e-03f, 2.78799105e-02f, 5.47081009e-02f, -3.17572393e-02f, -3.23694572e-02f, 2.61526648e-02f, 8.53474513e-02f, 1.23767458e-01f, 1.31710526e-02f,
  -2.93585867e-01f, 2.00973108e-01f, 1.31398037e-01f, -4.94661182e-02f, -1.54041860e-03f, -6.61947504e-02f, 9.96410195e-03f, -5.27522191e-02f, -1.23497397e-01f, 2.26559560e-03f,
  -1.93385817e-02f, 1.61794797e-02f, -1.12262247e-02f, 2.50659678e-02f, -1.13960601e-01f, 1.80876464e-01f, 1.85683414e-01f, -4.24277373e-02f, -1.55566916e-01f, -1.30776733e-01f,
  -2.82242279e-02f, 4.30506282e-02f, -7.76111186e-02f, 3.58893834e-02f, 1.14646710e-01f, -7.46054277e-02f, 1.87893897e-01f, -5.59875835e-03f, -3.28579335e-03f, 2.34732613e-01f,
  1.08844042e-01f, 1.00460434e-02f, -7.66201392e-02f, 2.84075795e-04f, 3.30819152e-02f, -3.58573608e-02f, -2.35794764e-02f, -2.51854509e-02f, -4.93602036e-03f, -1.75820980e-02f,
  4.23744246e-02f, -2.76513267e-02f, -3.73460874e-02f, 5.28522283e-02f, -6.15160353e-03f, -3.71669196e-02f, 1.44048370e-02f, 3.28629687e-02f, 1.11295320e-01f, 9.78301242e-02f,
  -7.96999782e-03f, -4.11613733e-02f, -7.14579672e-02f, 4.95975241e-02f, -5.47289401e-02f, -3.56575996e-02f, 1.03277273e-01f, 3.38292070e-04f, -1.05211986e-02f, 9.57703069e-02f,
  -3.44869345e-02f, -6.40510535e-03f, 1.33998776e-02f, 3.89246121e-02f, -6.30791858e-02f, 4.65865359e-02f, -2.74148677e-03f, 3.26176956e-02f, -6.78172186e-02f, -5.95068038e-02f,
  -2.05433206e-03f, -8.02468136e-03f, -5.71328797e-04f, -1.55994333e-02f, 5.39614260e-02f, 7.73843974e-02f, -9.40121338e-02f, 4.09594849e-02f, -6.38453588e-02f, -3.17248106e-02f,
  2.55120136e-02f, 1.39052775e-02f, -3.56148779e-02f, 5.23263589e-02f, 8.19945708e-02f, -9.15327459e-04f, -4.73008938e-02f, -6.48598596e-02f, 6.11242987e-02f, 4.11181971e-02f,
  3.44139151e-02f, -2.57970933e-02f, -5.91229834e-02f, 4.23461832e-02f, 8.19206610e-02f, 2.15808898e-02f, -2.36561149e-02f, 7.57596567e-02f, 4.26639281e-02f, 4.92549539e-02f,
  -7.53829777e-02f, 4.11028005e-02f, 2.78642420e-02f, 5.27840592e-02f, -2.75351796e-02f, 8.19952227e-03f, 5.08594401e-02f, 1.26754446e-02f, -6.18317574e-02f, 9.20064673e-02f,
  -1.28901405e-02f, -1.33941814e-01f, -1.31211266e-01f, -3.75998951e-02f, -5.07248677e-02f, -5.20325527e-02f, -5.75497234e-03f, -4.66470271e-02f, -1.56454161e-01f, 8.62302352e-03f,
  2.13116199e-01f, 3.15286405e-02f, 2.31998768e-02f, 1.08235754e-01f, 5.00240847e-02f, -1.88409314e-01f, -1.91573381e-01f, -1.21850930e-01f, -1.02119125e-01f, 3.22876237e-02f,
  5.89497834e-02f, 6.81535453e-02f, -1.79513488e-02f, 5.46341501e-02f, -3.05272290e-04f, -3.14381942e-02f, 9.68258381e-02f, -1.89858004e-02f, 3.20655182e-02f, -1.17620274e-01f,
  8.21614452e-03f, 1.64142281e-01f, 1.48272142e-01f, 8.97010565e-02f, 4.89627980e-02f, 5.87961599e-02f, 1.21874377e-01f, 7.91868791e-02f, 8.03332180e-02f, 1.24884017e-01f,
  6.21252395e-02f, 9.53324735e-02f, -4.90679266e-03f, 7.24929124e-02f, -2.50143986e-02f, -2.39459332e-02f, 8.50090384e-02f, 1.62015464e-02f, 4.18452807e-02f, -2.67700814e-02f,
  8.54770169e-02f, -5.27778938e-02f, 7.00734556e-02f, -3.97582129e-02f, -5.51385805e-02f, -8.76845419e-02f, -5.33634983e-02f, 3.44129242e-02f, 1.72886085e-02f, -2.64832079e-02f,
  4.27425094e-03f, 1.40316963e-01f, 8.51957127e-02f, -1.21662095e-01f, -1.36845574e-01f, 5.99804223e-02f, 7.39976997e-03f, -5.94975501e-02f, -2.75349561e-02f, 6.47887364e-02f,
  3.21175642e-02f, 9.09425616e-02f, -6.59080967e-02f, 2.75462847e-02f, 3.22435913e-03f, 3.27950902e-02f, 8.87033418e-02f, 3.50971818e-02f, 2.49803830e-02f, -1.21710042e-03f,
  3.28079388e-02f, -1.28421895e-02f, 5.69660701e-02f, 3.63256335e-02f, -3.45005281e-02f, -8.40833969e-03f, 7.07353055e-02f, -1.40952680e-03f, -2.27855183e-02f, 6.17228486e-02f,
  -7.11380988e-02f, -5.47912307e-02f, 5.79778152e-03f, 2.36467626e-02f, 5.97190410e-02f, -8.16398710e-02f, -4.85296808e-02f, 1.46332942e-03f, -8.69634077e-02f, -8.74550417e-02f,
  -2.10510474e-03f, -8.24834928e-02f, 1.45988939e-02f, 9.83291790e-02f, 8.91656056e-02f, 5.55886552e-02f, 8.97853598e-02f, 6.87322319e-02f, 5.39675914e-02f, 1.30785098e-02f,
  -7.62092173e-02f, -2.93791089e-02f, 9.52023081e-03f, -6.34322390e-02f, 3.31974551e-02f, -3.78167047e-03f, 1.26799092e-01f, -4.96399663e-02f, 2.54318640e-02f, -7.81364068e-02f,
  5.78139201e-02f, 2.51319781e-02f, -6.67328611e-02f, -5.43198735e-02f, -9.73436050e-03f, 2.57471651e-02f, -9.77594256e-02f, -2.15933006e-03f, -6.08784612e-03f, 3.22096422e-02f,
  -1.21876178e-02f, -8.51415917e-02f, -1.95168257e-01f, -4.49248813e-02f, 3.24963443e-02f, -8.10515732e-02f, -1.33715615e-01f, -5.46311541e-03f, 2.25222241e-02f, -7.94269815e-02f,
  1.16327507e-02f, 7.32504353e-02f, -3.07651819e-03f, 6.55232277e-03f, -8.24875981e-02f, -1.36503711e-01f, -1.11323766e-01f, -2.55260859e-02f, 3.00989635e-02f, 9.74040329e-02f,
  4.92538773e-02f, 1.01776414e-01f, 7.95846805e-04f, 9.28822905e-02f, -6.89400211e-02f, -2.33734660e-02f, 8.93724859e-02f, 3.67707424e-02f, -7.39441589e-02f, -1.28830910e-01f,
  -2.11284220e-01f, -1.49490923e-01f, -2.18777135e-02f, 2.78478973e-02f, 2.91757639e-02f, -5.15821353e-02f, -8.44904557e-02f, 4.61698212e-02f, -2.38677636e-02f, -6.18427023e-02f,
  -2.25800509e-03f, -7.05521181e-02f, 6.69199005e-02f, -1.42707769e-03f, -3.34837213e-02f, -5.21648377e-02f, 1.21712014e-01f, 9.42740496e-03f, -7.30616897e-02f, 4.15672688e-03f,
  2.29544193e-02f, 3.16531118e-03f, -9.13860127e-02f, 4.02714610e-02f, 3.03996354e-02f, -1.65793300e-02f, 3.41871046e-02f, 2.58382000e-02f, 1.07585706e-01f, 5.35869673e-02f,
  -5.26567660e-02f, -2.53565293e-02f, 7.32661337e-02f, 2.82957498e-02f, 8.01946968e-02f, -1.04258256e-02f, -4.28943820e-02f, -4.94606644e-02f, -2.22739428e-02f, 8.50191936e-02f,
  5.39030470e-02f, 5.01878839e-03f, -2.77806409e-02f, 1.67126022e-02f, 6.60894737e-02f, -2.14448795e-02f, 3.92016582e-02f, 7.49744894e-03f, -3.21694873e-02f, 3.71026732e-02f,
  4.34574746e-02f, 3.06781530e-02f, 2.83702184e-02f, 5.62072061e-02f, -3.69767547e-02f, 1.70109910e-03f, -9.64094140e-03f, -4.77521084e-02f, 4.30616736e-02f, -6.54264390e-02f,
  1.27689376e-01f, 3.73763070e-02f, -1.32020593e-01f, -6.27976432e-02f, 4.77272794e-02f, 8.45428109e-02f, -5.80620356e-02f, 4.44307663e-02f, -7.47321695e-02f, -2.83479225e-02f,
  -6.88238367e-02f, -3.47015709e-02f, 1.14925988e-02f, -5.46768457e-02f, 7.08922893e-02f, 5.23048379e-02f, 1.60221942e-02f, 1.77603774e-02f, -6.24912232e-03f, 5.52714877e-02f,
  -5.70192523e-02f, 1.59642089e-03f, 2.36045253e-02f, -6.33917153e-02f, -3.73357936e-04f, -1.27021432e-01f, -7.42169470e-02f, -8.42492841e-03f, -5.13218492e-02f, 1.03993624e-01f,
  -1.47657856e-01f, -4.71251681e-02f, 2.40079816e-02f, 8.81698951e-02f, -6.56310515e-03f, -4.65977415e-02f, -1.48106560e-01f, -8.68554488e-02f, 2.60050390e-02f, -8.09870809e-02f,
  -1.96787685e-01f, -4.81386408e-02f, 1.58833824e-02f, 1.18109033e-01f, 1.39871612e-01f, 9.59313884e-02f, 9.03363749e-02f, 1.49047285e-01f, 7.04497024e-02f, 1.21185467e-01f,
  7.17976093e-02f, -2.91046277e-02f, 9.94911268e-02f, 6.82578310e-02f, 6.30025119e-02f, 9.79296118e-02f, 3.74185517e-02f, 6.24715351e-02f, 6.48797974e-02f, 1.77669570e-01f,
  -1.37116000e-01f, -1.60538062e-01f, -6.90043205e-03f, 7.97001272e-02f, -9.67511013e-02f, -4.96745892e-02f, -5.33480085e-02f, 7.30298972e-03f, 6.48381114e-02f, -6.61706850e-02f,
  -1.04838870e-01f, 2.39463523e-02f, 5.60860969e-02f, -3.37964557e-02f, -5.23358025e-02f, -5.38475066e-02f, 4.99978364e-02f, 1.14949010e-02f, 1.85634177e-02f, 4.62652855e-02f,
  -3.27290110e-02f, -1.76545158e-02f, -5.21271750e-02f, -5.48337288e-02f, 1.73141304e-02f, 3.11914086e-02f, -1.71229959e-01f, 1.00270566e-02f, -3.97746488e-02f, -1.61806270e-02f,
  6.15319274e-02f, 6.11376315e-02f, -4.15195748e-02f, 5.01623824e-02f, -4.66784164e-02f, 6.62127212e-02f, -1.30056422e-02f, 8.38886201e-03f, 6.62217140e-02f, -2.63203252e-02f,
  -3.66305783e-02f, 1.22420620e-02f, 1.01849539e-02f, 2.22570002e-02f, -3.37151848e-02f, 1.00504039e-02f, 7.76336417e-02f, 7.73503631e-02f, -1.02923093e-02f, -6.40873164e-02f,
  6.43872842e-02f, -4.44127284e-02f, -4.81951162e-02f, 4.51274179e-02f, -3.63780186e-02f, 6.26984835e-02f, -5.24602309e-02f, 3.62431854e-02f, -7.95486756e-03f, -3.78914960e-02f,
  -1.78845257e-01f, 1.94311123e-02f, 5.38191311e-02f, -1.61076039e-02f, -1.41925109e-03f, -3.44229974e-02f, -3.72416191e-02f, 4.09250408e-02f, 1.92903541e-02f, 3.09651215e-02f,
  -9.40737054e-02f, -7.08023235e-02f, 1.70352049e-02f, -2.84537120e-04f, 2.05220208e-02f, -6.89566061e-02f, -3.50123011e-02f, 2.38993615e-02f, 4.39287722e-02f, -1.00863397e-01f,
  2.79668085e-02f, -6.23594150e-02f, -1.36089325e-01f, -1.21731259e-01f, 8.83376924e-04f, -8.37316811e-02f, -7.17191696e-02f, -9.59268585e-02f, -2.23572895e-01f, -2.14864463e-01f,
  -1.48870334e-01f, -8.12420920e-02f, 2.02317268e-01f, -1.80908050e-02f, 1.39063401e-02f, 1.36275008e-01f, 6.65393379e-03f, -1.97603535e-02f, -4.15118411e-02f, -1.06977478e-01f,
  -1.79944456e-01f, -5.64537235e-02f, 2.49220766e-02f, 1.37852337e-02f, 5.78229921e-03f, 1.38661638e-01f, 4.33958061e-02f, 2.11861804e-01f, 1.29155368e-01f, -4.53640819e-02f,
  -2.56818184e-03f, 1.71660464e-02f, 9.51744616e-03f, -6.74536228e-02f, -1.30882457e-01f, -4.84134555e-02f, 8.51116180e-02f, -4.92623970e-02f, 6.89464062e-02f, -1.35169839e-02f,
  -1.31572608e-03f, -8.84997398e-02f, 6.83291554e-02f, -4.73603532e-02f, -5.45687042e-02f, -4.12298106e-02f, -4.79829460e-02f, -4.71622124e-03f, -7.30383843e-02f, -3.70656885e-02f,
  7.48851383e-03f, -2.83699017e-02f, -5.22022136e-02f, -6.12282753e-03f, 4.49749045e-02f, 1.06897708e-02f, 5.71326129e-02f, -3.95352617e-02f, -5.43416254e-02f, 2.46236473e-02f,
  -1.00247435e-01f, -1.11096703e-01f, 6.60915971e-02f, 8.58616605e-02f, 2.14075819e-02f, 1.08270481e-01f, 6.86853826e-02f, -1.72260422e-02f, -1.44686298e-02f, -2.85957474e-02f,
  3.77109908e-02f, -3.81507352e-02f, 1.76294837e-02f, 1.85331572e-02f, 1.74422339e-02f, -3.38555947e-02f, 6.81332052e-02f, -3.21158022e-02f, 3.65521833e-02f, 3.25306058e-02f,
  3.94112570e-03f, -1.81565136e-02f, -1.60878059e-02f, 1.75585970e-02f, -8.74584466e-02f, 6.01160377e-02f, -5.53960204e-02f, 3.61602567e-02f, -2.23903172e-02f, 5.18866330e-02f,
  1.62792858e-02f, 8.21495727e-02f, 2.42291810e-03f, 7.72834942e-02f, -1.72526985e-02f, -3.09128370e-02f, -4.94887028e-03f, -2.23737340e-02f, -3.39278430e-02f, -1.02942083e-02f,
  -1.47869915e-01f, 1.41416758e-01f, -2.78555509e-03f, 2.57835332e-02f, 9.43941399e-02f, 2.26320904e-02f, -4.33610566e-03f, 1.09747890e-02f, -2.64386702e-02f, 3.21066827e-02f,
  -1.08305281e-02f, -3.22020799e-02f, 1.54921282e-02f, -5.93385734e-02f, 2.18334217e-02f, -3.71432528e-02f, -6.69925436e-02f, 8.29010382e-02f, 1.24525018e-02f, -2.79540438e-02f,
  5.98897524e-02f, -5.35798967e-02f, 6.77484721e-02f, -4.04431783e-02f, 2.90710595e-03f, 8.57585371e-02f, 6.14149980e-02f, 3.25517766e-02f, 7.74441436e-02f, -1.05027966e-01f,
  -2.01111492e-02f, 1.15198158e-01f, -2.06537649e-01f, 1.04760431e-01f, -5.79758957e-02f, -5.33457585e-02f, -1.73665822e-01f, -1.28733844e-01f, 3.58184017e-02f, 5.83415814e-02f,
  6.58452511e-02f, 3.83963287e-02f, 4.11402956e-02f, -3.41772623e-02f, -1.98647708e-01f, 2.95446999e-02f, -1.27757370e-01f, -1.67544544e-01f, -1.53491288e-01f, 1.11514833e-02f,
  1.35507792e-01f, -5.68227954e-02f, 3.06465533e-02f, -2.90671457e-02f, 4.47922684e-02f, -8.22688490e-02f, -5.26657626e-02f, -8.47910792e-02f, -1.01208769e-01f, 1.14759140e-01f,
  -1.63064197e-01f, -8.21794719e-02f, -4.99822013e-02f, 6.50813282e-02f, 2.92156693e-02f, -5.43114655e-02f, 4.62711677e-02f, 5.85110150e-02f, 8.78227651e-02f, -7.04656355e-03f,
  -1.90865379e-02f, 9.53219235e-02f, 4.15924303e-02f, -5.38457744e-02f, 3.51912044e-02f, -5.85753024e-02f, -1.24204345e-02f, -2.24762261e-02f, -1.20368518e-01f, 5.19016050e-02f,
  8.29197019e-02f, -4.07397486e-02f, 1.02379732e-02f, -1.16335846e-01f, -1.36005795e-02f, -1.01508841e-01f, -9.39074755e-02f, -1.30902857e-01f, -1.87632561e-01f, 7.69357905e-02f,
  7.48173818e-02f, 5.90931997e-02f, 9.13366303e-03f, -5.81075847e-02f, 1.71756800e-02f, 3.39932144e-02f, -5.34041552e-04f, 8.43783468e-02f, -3.76223512e-02f, -5.61492741e-02f,
  5.10102250e-02f, -4.52431701e-02f, -4.67746891e-02f, -3.10340971e-02f, 2.19730288e-02f, -8.53609480e-03f, 5.61246984e-02f, 7.76245818e-02f, 4.51693386e-02f, -5.75471222e-02f,
  1.13030104e-02f, -1.75721925e-02f, -3.90913077e-02f, 4.49400097e-02f, -3.05451769e-02f, -9.65368748e-02f, -3.01453229e-02f, 6.40672352e-03f, 9.71172377e-02f, 5.91596998e-02f,
  3.98850553e-02f, -1.24095969e-01f, 8.47619697e-02f, -3.80277634e-02f, 2.64239521e-03f, 9.23706964e-03f, 4.63395938e-03f, 1.16832601e-02f, 3.63707244e-02f, 4.81788293e-02f,
  -2.12737415e-02f, -6.51666224e-02f, -2.42859796e-02f, 3.91219147e-02f, 3.31420228e-02f, 2.47569643e-02f, 8.04367587e-02f, 4.92604915e-03f, 3.29962820e-02f, 1.14471838e-02f,
  4.71360087e-02f, 5.65876141e-02f, -6.35605901e-02f, -8.83825272e-02f, -9.33078676e-02f, -1.24862067e-01f, -6.16834778e-03f, -9.26730633e-02f, -1.45922765e-01f, -4.42015156e-02f,
  -1.93164244e-01f, 1.40420586e-01f, -9.99057479e-03f, -6.11815825e-02f, 1.64438784e-01f, -7.42122978e-02f, 1.34891048e-02f, 4.63021956e-02f, 1.53442835e-02f, 1.22801498e-01f,
  2.14574650e-01f, 7.01688156e-02f, 1.01666478e-03f, -4.54079881e-02f, -1.83792070e-01f, 3.94830368e-02f, -1.09383002e-01f, -1.65394858e-01f, -2.50603706e-01f, -6.48499951e-02f,
  -5.33697987e-03f, 1.18591245e-02f, -1.42349377e-01f, -7.57558718e-02f, 7.72995129e-02f, -5.63554913e-02f, -6.20057620e-03f, 1.09127700e-01f, 1.13540433e-01f, 1.17546385e-02f,
  1.05552912e-01f, 1.10443838e-01f, -4.69669439e-02f, 3.09300907e-02f, 6.25832453e-02f, -4.29008268e-02f, 4.11488414e-02f, -5.50403185e-02f, 1.31654926e-02f, -1.56113571e-02f,
  8.27158466e-02f, -6.06148466e-02f, -5.41397333e-02f, 5.87299978e-03f, -5.33164740e-02f, -2.87135225e-02f, 3.80436033e-02f, -5.28485328e-02f, -5.42261899e-02f, 8.47736150e-02f,
  1.80356130e-01f, 5.20355292e-02f, 9.34207998e-03f, -4.62656580e-02f, -2.18209904e-02f, 1.69559140e-02f, 9.04169008e-02f, -1.32523384e-02f, -3.55527773e-02f, 8.24144483e-02f,
  -2.17337180e-02f, 6.27104416e-02f, -3.69742662e-02f, -2.99404077e-02f, 4.62499410e-02f, 6.59431098e-03f, 4.80663516e-02f, -1.03746569e-02f, 3.65578160e-02f, 4.53114361e-02f,
  -4.50457148e-02f, -4.48636040e-02f, -2.93902885e-02f, -5.28898137e-03f, -1.62933383e-03f, -2.90697683e-02f, -6.92218021e-02f, 2.23381054e-02f, -3.93377393e-02f, 1.14624478e-01f,
  -6.37949929e-02f, 2.20597386e-02f, 5.41198961e-02f, -3.17737088e-02f, -5.46735246e-03f, -7.36634880e-02f, 6.99085230e-03f, 1.44335730e-02f, 3.87694541e-04f, 5.35060018e-02f,
  9.53886881e-02f, -3.29992138e-02f, -1.93774719e-02f, -1.00893797e-02f, 4.77979816e-02f, 1.22861601e-01f, 4.55469415e-02f, 1.27417305e-02f, 7.76192695e-02f, 3.43754962e-02f,
  -1.51453381e-02f, -4.76748087e-02f, 9.92445499e-02f, 3.97965983e-02f, -4.55627218e-02f, -5.40062748e-02f, -1.71079542e-02f, -6.75004423e-02f, 5.01103625e-02f, 4.83922400e-02f,
  6.99625388e-02f, -8.79063085e-02f, -8.30644146e-02f, -4.56799567e-02f, -7.39949942e-02f, -5.95638454e-02f, -3.28190923e-02f, -3.28388624e-02f, -1.79525658e-01f, -4.18586209e-02f,
  -3.81764740e-01f, 1.71224624e-01f, 1.86269388e-01f, -1.64157793e-01f, 3.99229815e-03f, 9.64765251e-02f, 3.50673318e-01f, 8.36045388e-03f, -1.47228226e-01f, 1.15319170e-01f,
  -5.20956935e-03f, -2.62617886e-01f, -1.43147707e-01f, -1.05763219e-01f, 3.84056903e-02f, 3.07516903e-01f, 2.20091879e-01f, 6.28615320e-02f, -6.77431673e-02f, -9.94309708e-02f,
  -1.66322943e-03f, -1.35328576e-01f, -1.43284574e-01f, 2.68772691e-02f, 4.92274202e-02f, -1.32055506e-01f, 7.09002092e-02f, 4.23226990e-02f, 1.42979454e-02f, 7.08517730e-02f,
  9.15784687e-02f, -3.73453205e-03f, 5.86550757e-02f, -1.09464496e-01f, 5.43640405e-02f, -4.35813516e-02f, 5.59837148e-02f, 5.24066798e-02f, -8.23245868e-02f, 6.93422183e-02f,
  -5.37927300e-02f, -8.72384310e-02f, -7.98913389e-02f, 2.18429007e-02f, 1.16650807e-02f, 4.75796647e-02f, 7.22436840e-03f, -2.22996585e-02f, 6.74339533e-02f, -3.44999097e-02f,
  2.29301602e-02f, 8.82671922e-02f, 9.19909850e-02f, 1.05460688e-01f, 1.42345294e-01f, -4.46983054e-02f, 4.78096902e-02f, 1.07222213e-03f, 1.37903392e-02f, 6.44434988e-02f,
  1.25778951e-02f, 6.42899871e-02f, -3.50181498e-02f, -2.44997535e-02f, 5.45273460e-02f, 4.33680192e-02f, -1.06205372e-02f, -3.42708826e-03f, 5.95864765e-02f, -2.30477955e-02f,
  4.74054404e-02f, -2.60090381e-02f, 1.59576014e-02f, 1.56434681e-02f, -6.21896330e-03f, -9.88607481e-03f, -2.07312386e-02f, 4.48383652e-02f, -9.61860269e-03f, -1.89507362e-02f,
  1.59239775e-04f, 1.49931256e-02f, -2.84839496e-02f, -1.81909353e-02f, -1.78570952e-02f, -6.65927585e-03f, 3.53040919e-03f, -1.09167427e-01f, 2.84818485e-02f, 6.60780771e-03f,
  -2.12850943e-01f, 4.89165373e-02f, 4.18590009e-02f, 3.77098005e-03f, -3.87692600e-02f, 6.53844848e-02f, -1.12226326e-03f, 1.04190139e-02f, -8.04003850e-02f, 5.61070181e-02f,
  -4.78211865e-02f, -4.87676486e-02f, -4.62563299e-02f, -4.64698263e-02f, 1.64517872e-02f, -1.13111706e-02f, 7.42055178e-02f, -4.52036824e-04f, -2.64509413e-02f, -3.14184800e-02f,
  4.76831682e-02f, 2.44941339e-02f, 4.67462977e-03f, -4.89575788e-02f, -7.71076679e-02f, -1.34073675e-01f, 3.61758471e-02f, 1.56583963e-03f, 5.17126620e-02f, 2.45025549e-02f,
  3.24280590e-01f, -1.52108222e-01f, 7.22237304e-02f, -1.29312370e-02f, -7.85075128e-02f, -5.00679985e-02f, -2.39046931e-01f, -7.05496222e-02f, -2.21474934e-02f, -2.36757193e-02f,
  -1.08545631e-01f, 3.39179561e-02f, 4.70036268e-02f, 1.37964105e-02f, 1.61252916e-01f, -1.62681222e-01f, -1.21446513e-01f, 9.43668708e-02f, 2.05013007e-01f, 4.49718013e-02f,
  -7.28529617e-02f, 5.73794656e-02f, 7.18588755e-02f, 9.96294320e-02f, -6.74704686e-02f, -2.04417910e-02f, -1.89910755e-02f, -9.63384435e-02f, -5.16736545e-02f, 2.82115676e-03f,
  2.40732320e-02f, 2.56383158e-02f, 9.00645852e-02f, -5.74760698e-02f, -5.61620519e-02f, 9.75234807e-02f, -3.91304567e-02f, -5.15825525e-02f, -1.78610422e-02f, 2.98898923e-03f,
  -2.98567228e-02f, 3.48005258e-02f, -1.62286330e-02f, 6.69387281e-02f, 3.01009486e-03f, -4.86604869e-02f, -2.97080050e-03f, -2.03410555e-02f, 5.19815795e-02f, -4.80977027e-03f,
  -1.39547303e-01f, -1.45302285e-02f, 6.16386868e-02f, 1.28293214e-02f, -4.24995422e-02f, 3.02241314e-02f, -9.96507779e-02f, -4.57410067e-02f, 7.02080280e-02f, 2.37747058e-02f,
  -5.53799979e-02f, 2.32768171e-02f, -5.93022853e-02f, 1.04487324e-02f, -3.53754647e-02f, -5.53949326e-02f, 4.28588167e-02f, 1.33106969e-02f, 3.63593474e-02f, 6.20269179e-02f,
  -1.75503995e-02f, -2.62502879e-02f, 7.41147902e-03f, 1.17713530e-02f, 8.74793231e-02f, -6.34663850e-02f, 3.14704925e-02f, 3.71411964e-02f, 2.16251984e-03f, 3.10495421e-02f,
  -5.60211949e-02f, 4.36719097e-02f, -2.31688675e-02f, 6.72172979e-02f, -7.22661689e-02f, -4.45238920e-03f, 3.67742330e-02f, -5.08448109e-02f, 1.78030673e-02f, -3.96879017e-02f,
  -5.37629984e-02f, 1.33183882e-01f, 1.17394719e-02f, 8.48387107e-02f, 2.98049040e-02f, -1.33395556e-03f, 4.50065099e-02f, -5.54673327e-03f, -2.64287926e-03f, 6.47622570e-02f,
  4.76249643e-02f, 1.06047601e-01f, -4.49748076e-02f, 6.38000742e-02f, 6.46327436e-02f, 5.60005680e-02f, -9.88731906e-02f, 6.20289817e-02f, 3.87315489e-02f, -7.62788802e-02f,
  -8.23825598e-02f, -6.52275700e-03f, 5.80436131e-03f, -8.34079608e-02f, -4.80314642e-02f, 8.34280401e-02f, -5.28147332e-02f, 8.70421305e-02f, 1.11919269e-02f, -1.01674758e-01f,
  -6.72776699e-02f, -3.95354740e-02f, -8.14186260e-02f, 1.71476722e-01f, 2.57283263e-02f, -9.91651881e-03f, -7.38990232e-02f, -7.70722562e-03f, -3.11182495e-02f, 1.35807663e-01f,
  -2.23425925e-02f, 1.21617943e-01f, 1.39472678e-01f, -8.69526062e-03f, -9.30205286e-02f, 1.28768235e-01f, 1.67331979e-01f, -2.24714112e-02f, -1.11928172e-02f, 8.21790323e-02f,
  9.58381072e-02f, -1.22064371e-02f, 3.54256071e-02f, 7.81073347e-02f, 1.57337531e-01f, 1.64898470e-01f, 1.17088042e-01f, 4.63529974e-02f, -1.48233036e-02f, 1.46623850e-01f,
  1.99316189e-01f, -1.49465501e-01f, 5.86377196e-02f, -1.37536703e-02f, 7.51491860e-02f, -7.35129267e-02f, -1.85943972e-02f, -1.25163481e-01f, -6.19062297e-02f, 5.06810434e-02f,
  8.36588517e-02f, -2.06275657e-02f, 8.65502954e-02f, 6.44506514e-02f, -5.64550906e-02f, -9.01685730e-02f, -6.57700151e-02f, -5.38071878e-02f, -5.63923866e-02f, -8.96236822e-02f,
  -1.24123357e-02f, 1.56228319e-02f, 2.43801181e-03f, -7.17692301e-02f, -5.56824282e-02f, 6.58243969e-02f, 4.15455876e-03f, -7.39781410e-02f, -1.84105247e-01f, 2.58229412e-02f,
  1.61147490e-02f, -4.11925018e-02f, -1.03728948e-02f, 2.09341906e-02f, -4.83350754e-02f, -1.03169605e-02f, 6.05090261e-02f, -1.55257266e-02f, 5.01145497e-02f, -5.85409440e-02f,
  6.43075779e-02f, 7.95495883e-03f, 1.11798026e-01f, 1.86362378e-02f, 1.03836343e-01f, 1.89971514e-02f, 6.89640716e-02f, -4.45572436e-02f, 9.42857042e-02f, -1.55107677e-02f,
  -4.44423743e-02f, -1.54689262e-02f, -5.69206811e-02f, 3.59794758e-02f, -7.52507821e-02f, 1.07566610e-01f, 3.52116488e-02f, -9.64800268e-02f, -7.29473382e-02f, -5.65526038e-02f,
  6.17438741e-02f, -1.79253295e-01f, 1.53294057e-01f, -5.09600639e-02f, 6.59005865e-02f, -7.93117732e-02f, 1.04907803e-01f, 3.77472267e-02f, -4.49584015e-02f, -1.54803814e-02f,
  1.94005463e-02f, -2.81057768e-02f, 9.96241644e-02f, 9.13483649e-03f, -4.05825898e-02f, 1.03049148e-02f, 2.82946089e-03f, 1.15711823e-01f, -7.03569502e-02f, -5.00914082e-02f,
  5.90469576e-02f, -4.30204980e-02f, -5.18023036e-02f, 2.11024862e-02f, 5.70192672e-02f, 1.06286459e-01f, -2.53351461e-02f, -9.46015771e-03f, -1.15503304e-01f, 4.07297276e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.82913631e-01f, 3.80805284e-02f, 1.48309879e-02f, -6.07196763e-02f, 1.16022211e-02f, 6.34544194e-02f, 1.03702441e-01f, -7.00883865e-02f, -3.98229659e-02f, 1.74142327e-02f,
  4.56612417e-03f, 3.63135412e-02f, 4.60924059e-02f, 5.92626166e-03f, 4.91236225e-02f, 3.62921320e-02f, -3.78835835e-02f, -1.02794163e-01f, -6.69565201e-02f, -4.09077555e-02f,
  -1.46114556e-02f, -5.17288893e-02f, -1.37033328e-01f, -7.82503858e-02f, 3.14101316e-02f, 3.55736054e-02f, -6.63430523e-03f, 2.53976730e-04f, 1.08065866e-01f, -7.02617094e-02f,
  -9.87666249e-02f, -9.70532596e-02f, 2.64130738e-02f, 6.12089373e-02f, 4.41434653e-03f, 7.04950746e-03f, 2.64737047e-02f, 5.66024845e-03f, 1.04473040e-01f, 1.02405325e-01f,
  6.12947941e-02f, -5.22602536e-02f, -3.33041907e-03f, 5.96238114e-02f, -2.35417373e-02f, 3.96637022e-02f, -2.62299180e-02f, -5.85455447e-02f, 1.51077295e-02f, 1.09411269e-01f,
  7.10616857e-02f, -2.74737068e-02f, -4.61632684e-02f, -4.20976244e-02f, 9.69441310e-02f, -1.24521432e-02f, 4.04241867e-02f, -7.16081336e-02f, 4.68579903e-02f, 2.61742529e-03f,
  -4.21885885e-02f, 7.43036419e-02f, 9.68334451e-02f, 1.26672285e-02f, -5.91447465e-02f, 8.32106471e-02f, -2.24412773e-02f, 6.10610060e-02f, 9.08624455e-02f, -8.83127600e-02f,
  7.19932243e-02f, 4.39926721e-02f, 6.63074851e-02f, -5.18964566e-02f, 6.89107031e-02f, -2.33951621e-02f, 9.65567827e-02f, 7.56807625e-02f, 7.42269903e-02f, -1.29686818e-02f,
  -5.88212274e-02f, 1.25183016e-02f, -2.61102710e-02f, -1.23051135e-02f, -4.13831621e-02f, 1.37861609e-03f, 7.37717673e-02f, 6.58338889e-02f, 1.08578935e-01f, 7.31227174e-02f,
  -4.94647436e-02f, -3.38902399e-02f, -4.65158969e-02f, -5.06451577e-02f, 7.71375597e-02f, 2.49061603e-02f, 7.23881871e-02f, 3.49858291e-02f, 1.05961815e-01f, 8.87692422e-02f,
  7.14785382e-02f, 3.27613391e-02f, -8.45138207e-02f, 8.09283704e-02f, -7.45328665e-02f, 1.02764159e-01f, -4.88472022e-02f, 7.23922104e-02f, -4.75748405e-02f, -1.02037722e-02f,
  -6.83667511e-02f, 6.55801147e-02f, -9.80201215e-02f, 5.75820804e-02f, 5.52298501e-02f, -3.74291204e-02f, -2.32139751e-02f, 7.01399520e-02f, 6.55022413e-02f, -4.85568531e-02f,
  -1.28911454e-02f, -7.31526315e-02f, -3.55808772e-02f, -4.78342362e-02f, 1.35212719e-01f, 6.96271881e-02f, 1.52508259e-01f, 6.16873465e-02f, -8.16077217e-02f, 5.91942333e-02f,
  1.37820214e-04f, -8.39593038e-02f, 3.96994501e-02f, 4.72305231e-02f, 8.55572075e-02f, -2.46499889e-02f, -8.00051168e-03f, 9.61472560e-03f, -7.20894933e-02f, 3.20309624e-02f,
  -5.58062866e-02f, 5.00632077e-02f, -7.12081864e-02f, 7.21861422e-02f, 8.21188763e-02f, 1.46412151e-03f, 8.89434665e-02f, -8.24514925e-02f, 9.05677751e-02f, -9.81118083e-02f,
  -1.31741911e-01f, 4.40463908e-02f, 1.33936433e-02f, -2.23080963e-02f, 5.02852947e-02f, -4.35877405e-02f, -4.64683138e-02f, -1.98747013e-02f, -3.78174037e-02f, 5.09653315e-02f,
  7.38610653e-03f, 3.99492979e-02f, 5.22539504e-02f, -5.92778958e-02f, -7.62299150e-02f, -4.69236113e-02f, -3.65056843e-02f, -4.63415831e-02f, 1.11973053e-02f, -3.97499371e-03f,
  1.64397545e-02f, 7.78143778e-02f, 5.46327829e-02f, -4.73129265e-02f, -5.43041620e-04f, -9.12967175e-02f, -5.71928322e-02f, 5.51428385e-02f, -1.01188280e-01f, -7.19247609e-02f,
  2.50504091e-02f, 7.57570565e-02f, -2.00999435e-02f, -8.83784052e-03f, -7.26456270e-02f, 3.24710123e-02f, -1.94615256e-02f, 8.34743008e-02f, -8.01367611e-02f, 1.19620049e-02f,
  3.13679501e-02f, 7.82037824e-02f, -5.26199639e-02f, 3.91758718e-02f, 7.77091160e-02f, -8.53095390e-03f, 7.57204071e-02f, 2.92679258e-02f, -8.69398415e-02f, 6.02396727e-02f,
  7.45105222e-02f, 8.34489614e-02f, 2.08655875e-02f, 2.56006569e-02f, -3.27720642e-02f, 6.22945726e-02f, 6.25230446e-02f, -7.01522157e-02f, -2.67066471e-02f, -8.70146379e-02f,
  -1.21734012e-02f, 1.10784337e-01f, -4.68885936e-02f, -8.38165209e-02f, -5.41344460e-04f, -2.60653980e-02f, 2.56731757e-03f, 7.52709806e-02f, -3.35219465e-02f, -6.98294714e-02f,
  1.69345234e-02f, 1.39770834e-02f, 6.50833994e-02f, 3.40524167e-02f, -6.47802744e-03f, 7.28561580e-02f, -4.56492938e-02f, -9.86291319e-02f, -6.85193483e-03f, 1.04077598e-02f,
  -8.51097777e-02f, -2.52050087e-02f, -6.30073249e-02f, -5.61185740e-02f, -9.27085727e-02f, -1.06535037e-03f, -1.31598022e-03f, -4.21455353e-02f, -6.38556331e-02f, 3.23533192e-02f,
  4.66602631e-02f, -6.48603356e-03f, 3.04020196e-02f, 5.75972088e-02f, -4.92403843e-03f, 1.19005173e-01f, 4.30245697e-02f, 6.79607270e-03f, 9.32578668e-02f, 8.51755366e-02f,
  3.18275914e-02f, 3.22290473e-02f, 7.35204518e-02f, -1.14974063e-02f, 2.92472187e-02f, -4.71228883e-02f, 8.46567228e-02f, 6.13268688e-02f, 8.30227882e-02f, -6.77705407e-02f,
  -6.09932281e-02f, 5.29893152e-02f, -4.85633351e-02f, -2.35409923e-02f, -8.50203484e-02f, -2.33239960e-02f, -7.38126785e-02f, -1.46996544e-03f, 2.67589744e-02f, 2.40756795e-02f,
  -2.85907649e-02f, 2.72588637e-02f, 1.21121228e-01f, -1.60965677e-02f, -2.45401952e-02f, -3.37298866e-03f, 5.11469953e-02f, -5.50365262e-02f, 8.78260955e-02f, 9.50525478e-02f,
  -9.99572128e-02f, 2.76178140e-02f, 5.83316907e-02f, 1.46830510e-02f, -5.50624654e-02f, 3.97196449e-02f, 1.96231548e-02f, -1.02629056e-02f, -2.20944397e-02f, -4.88915928e-02f,
  -7.56913722e-02f, 3.30425501e-02f, 1.05792359e-01f, 1.97438486e-02f, -4.65020128e-02f, 1.15707144e-01f, 9.90472455e-03f, -1.87811088e-02f, 3.39753293e-02f, 5.98083399e-02f,
  -3.13174762e-02f, 7.62616992e-02f, -7.78292418e-02f, -2.90745199e-02f, -1.89744905e-02f, 7.56236091e-02f, 7.82828480e-02f, -1.32922335e-02f, -6.97902218e-02f, -4.41085584e-02f,
  -5.99623732e-02f, 7.28458464e-02f, -1.22327982e-02f, -5.24645038e-02f, -7.61330454e-03f, -3.22177783e-02f, 3.18863951e-02f, -4.45898771e-02f, -6.93208650e-02f, -1.57365073e-02f,
  -5.58182560e-02f, -5.94134293e-02f, -1.00783348e-01f, -1.08679552e-02f, -4.44297977e-02f, 3.55922244e-02f, -4.71546352e-02f, -3.56078148e-02f, -5.46886884e-02f, -2.85632093e-03f,
  -5.85230161e-03f, 1.42934203e-01f, 1.22606374e-01f, -7.12867156e-02f, 6.84668571e-02f, -2.53899749e-02f, -3.15282643e-02f, -1.42152924e-02f, -3.48270647e-02f, -3.65359187e-02f,
  -4.11370993e-02f, 8.51393938e-02f, 7.41991475e-02f, -5.22563383e-02f, 3.13261226e-02f, 8.26522112e-02f, 4.80542779e-02f, -2.66086217e-02f, -5.18633761e-02f, 6.98394105e-02f,
  -7.74369687e-02f, -1.65254045e-02f, 1.22557513e-01f, 1.32879660e-01f, 7.30466321e-02f, 1.00714274e-01f, -1.49977114e-02f, 1.80709697e-02f, 5.44688776e-02f, -4.73395362e-02f,
  6.05572015e-02f, -6.80020005e-02f, 5.88780381e-02f, -3.33245285e-02f, 5.53085795e-03f, 5.06161042e-02f, 9.81440842e-02f, 1.90110784e-02f, -3.68538033e-03f, 6.02376536e-02f,
  6.89966753e-02f, -6.29398152e-02f, -9.51618981e-03f, -3.66593748e-02f, 1.61352046e-02f, -3.92819420e-02f, -2.51716636e-02f, 3.43581177e-02f, 2.73471978e-02f, -9.55135655e-03f,
  -5.13839833e-02f, -4.04428169e-02f, 1.74812786e-02f, 7.55526684e-03f, 6.55032918e-02f, -4.51897271e-03f, -3.60169187e-02f, 8.30311179e-02f, -5.10160588e-02f, 6.87067583e-02f,
  -7.06409365e-02f, 9.37652439e-02f, 2.18422171e-02f, 7.43918791e-02f, 6.62911460e-02f, -4.26474698e-02f, 3.87462564e-02f, -5.77946454e-02f, 8.05581957e-02f, -7.52555281e-02f,
  7.03167096e-02f, -6.03429452e-02f, -3.77882794e-02f, -8.68119150e-02f, -3.40097547e-02f, -8.33596662e-03f, -6.70734420e-02f, -5.92143722e-02f, -1.75203048e-02f, 7.27885067e-02f,
  8.89026560e-03f, -5.73069900e-02f, 7.41892308e-02f, 7.55042583e-02f, -3.75211379e-03f, -2.53337193e-02f, -4.70624715e-02f, 3.90260965e-02f, -7.17894733e-02f, 2.65007894e-02f,
  -6.46771565e-02f, 4.47598659e-02f, -4.07467857e-02f, 4.83516306e-02f, 5.14620282e-02f, 8.02573934e-02f, -6.88748881e-02f, -1.02172187e-02f, -1.79174673e-02f, -2.14776769e-02f,
  -4.26731296e-02f, 1.28563177e-02f, -7.21381698e-03f, 5.66617250e-02f, 6.11486919e-02f, 5.71831949e-02f, 6.38598427e-02f, -2.69637890e-02f, -8.90792441e-03f, 5.85112758e-02f,
  -5.10768220e-02f, -4.03353217e-04f, 6.72828928e-02f, -4.51560132e-02f, 8.70636404e-02f, 3.08073238e-02f, -2.32544765e-02f, -7.54619837e-02f, -8.26430917e-02f, 1.13214478e-02f,
  -5.72634675e-02f, -3.13985795e-02f, 7.00137839e-02f, -5.73520772e-02f, -1.53129064e-02f, -8.43084827e-02f, -7.73801059e-02f, -7.48531893e-02f, 1.38711501e-02f, 6.28526583e-02f,
  5.88776134e-02f, 8.40187818e-02f, 2.35547200e-02f, 6.19349442e-03f, -7.56668076e-02f, 7.89403468e-02f, -7.68645480e-02f, -1.30727468e-02f, -3.75770777e-02f, -5.40355742e-02f,
  4.36117388e-02f, 7.75553938e-03f, 6.66879937e-02f, 3.62203158e-02f, 7.99179152e-02f, -5.11558950e-02f, -8.30963627e-02f, -1.89034715e-02f, -7.74834231e-02f, -9.29648951e-02f,
  -4.33146954e-04f, 4.58096154e-02f, 3.35200243e-02f, 4.93832491e-02f, 1.11305401e-01f, 1.21360771e-01f, -3.81674878e-02f, -4.13852595e-02f, -6.59306124e-02f, -3.78476195e-02f,
  3.18633392e-02f, -5.17649055e-02f, -1.53246671e-02f, 1.99539680e-02f, -3.92352976e-02f, -7.40969926e-02f, -2.14502495e-02f, 4.95047234e-02f, -4.27027559e-03f, -9.24488753e-02f,
  7.67962784e-02f, 4.17813957e-02f, -6.20966628e-02f, -2.90940348e-02f, -6.04731515e-02f, -9.19360593e-02f, 2.24865116e-02f, -1.06340582e-02f, -6.55941293e-03f, 7.38323703e-02f,
  1.15259990e-01f, 1.48529470e-01f, 2.60974895e-02f, -2.01109368e-02f, 3.43884937e-02f, 8.50460213e-03f, -7.55690336e-02f, -4.58193757e-02f, 8.65886956e-02f, 9.31798965e-02f,
  2.13793218e-02f, -1.06022013e-02f, 5.78021491e-03f, -6.78511783e-02f, 7.84643516e-02f, -4.58356254e-02f, -7.52402619e-02f, -4.28213291e-02f, -6.35672063e-02f, 7.86824450e-02f,
  5.69974035e-02f, 6.92855120e-02f, 1.17400981e-01f, 1.46522569e-02f, -2.91723013e-02f, -5.22223413e-02f, 5.94138987e-02f, -7.62242526e-02f, 4.55808342e-02f, 2.46634558e-02f,
  -9.88988727e-02f, 9.95518081e-03f, -7.24107549e-02f, -2.62980536e-02f, 5.98601997e-02f, 1.48080010e-02f, 2.55206171e-02f, 2.62813736e-02f, -8.47613588e-02f, 6.83056414e-02f,
  -4.94102575e-03f, -9.94723476e-03f, 4.51853033e-03f, -2.44934708e-02f, -1.47912931e-02f, 1.97066311e-02f, 1.10979546e-02f, -1.00016445e-01f, 4.53123171e-03f, 8.62439796e-02f,
  -8.71572718e-02f, 4.78657745e-02f, -1.07296649e-02f, -5.78822158e-02f, 3.61931734e-02f, 9.59349126e-02f, -7.57291764e-02f, -4.43999879e-02f, -8.95609632e-02f, 2.52681766e-02f,
  -7.43110180e-02f, 3.69737074e-02f, -2.22230260e-03f, 6.15163110e-02f, 5.69807738e-02f, 4.49065380e-02f, -6.47367761e-02f, -3.24393697e-02f, -2.45824233e-02f, 9.84189287e-02f,
  6.55884668e-02f, -7.62260929e-02f, 2.41241455e-02f, 2.75503844e-03f, 2.39377543e-02f, 2.96908394e-02f, -7.54032508e-02f, -8.33195299e-02f, -7.04591274e-02f, 8.18405673e-02f,
  7.81704113e-03f, 2.19184570e-02f, 7.70951733e-02f, 1.27368625e-02f, -5.46942428e-02f, 4.14390415e-02f, 4.22425717e-02f, 9.14665759e-02f, -6.90241605e-02f, 4.40321080e-02f,
  2.23128989e-01f, 4.62473631e-02f, 2.87576709e-02f, -8.68107285e-03f, -8.32484812e-02f, -5.44535145e-02f, 6.13721721e-02f, 3.98452692e-02f, -2.31333543e-02f, 2.22293492e-02f,
  1.83483995e-02f, 1.71016413e-03f, 7.45188072e-02f, 1.50398910e-01f, 1.08315215e-01f, 5.68080805e-02f, 2.59351172e-02f, 1.24364883e-01f, 6.11208417e-02f, 8.73159990e-02f,
  1.30005535e-02f, 3.22447345e-02f, 1.27776086e-01f, 3.27542275e-02f, 9.57690775e-02f, -5.44467121e-02f, -9.33480933e-02f, -3.74778137e-02f, -7.94449225e-02f, 6.96151704e-02f,
  8.80158767e-02f, 3.68073524e-04f, 7.57882372e-02f, 6.57778680e-02f, -1.29700657e-02f, -1.26709510e-02f, 9.20991376e-02f, 4.50227074e-02f, 8.26629326e-02f, -1.50579279e-02f,
  1.49563141e-02f, 7.71508664e-02f, 2.58399714e-02f, -5.58175333e-02f, 3.35242152e-02f, 7.48870820e-02f, 9.89849493e-02f, -1.96926482e-02f, 1.17944345e-01f, 3.15702707e-02f,
  6.82424828e-02f, -6.73732534e-02f, -1.56539783e-03f, 2.70531978e-02f, 9.42960531e-02f, -7.70849064e-02f, -7.14468351e-03f, 2.14971006e-02f, 7.62068853e-02f, -3.01918201e-02f,
  -4.78684753e-02f, -5.89780770e-02f, 5.50427772e-02f, 8.99887830e-02f, -5.12686186e-02f, -2.72403955e-02f, 4.97764759e-02f, -4.33099903e-02f, -8.82196501e-02f, -7.28220940e-02f,
  -5.06050177e-02f, 5.50657287e-02f, 8.47609490e-02f, 2.82691326e-02f, -6.59279376e-02f, -7.20780715e-02f, -2.96491869e-02f, -1.99987944e-02f, 2.65571736e-02f, -9.09654275e-02f,
  6.73941970e-02f, -1.07345106e-02f, 7.21218362e-02f, -2.61564576e-03f, 6.51985556e-02f, 4.56818454e-02f, -7.70238414e-02f, 5.53626604e-02f, -3.57501842e-02f, -6.69753477e-02f,
  7.54079074e-02f, -5.38574494e-02f, 1.05173148e-01f, -4.33569588e-02f, -6.57704547e-02f, 5.15651591e-02f, -4.61110063e-02f, 3.98923084e-02f, 7.17050731e-02f, -1.66009087e-02f,
  9.42026824e-02f, -4.35938910e-02f, -3.49382646e-02f, 4.26846966e-02f, -8.28974247e-02f, 5.85917383e-03f, -8.06255545e-03f, -5.12119569e-02f, -6.93951771e-02f, 3.16979736e-03f,
  1.23806763e-02f, 1.43479975e-02f, -4.45611216e-02f, 8.64556804e-02f, 8.05786550e-02f, 1.79453157e-02f, -2.47801244e-02f, 2.65670419e-02f, 2.25825177e-04f, -7.66651146e-03f,
  -2.25834876e-01f, -7.91939050e-02f, -4.78947125e-02f, -2.12710723e-01f, -1.18740974e-02f, 1.20012730e-01f, 7.41601884e-02f, 1.00250743e-01f, 6.43581674e-02f, -1.80428438e-02f,
  3.22136581e-02f, -4.01554219e-02f, -1.40822046e-02f, -6.51244298e-02f, 1.29161298e-01f, 9.41925794e-02f, -1.10183179e-01f, -1.06847160e-01f, 3.11908242e-03f, 1.30517766e-01f,
  7.56651014e-02f, -1.12696938e-01f, -1.34020358e-01f, -8.09316412e-02f, -1.08262859e-02f, -1.20384060e-01f, -1.68537702e-02f, -1.35173395e-01f, 4.17474471e-02f, -1.50628433e-01f,
  -6.50216416e-02f, -1.64764017e-01f, 3.82145420e-02f, -4.23265249e-02f, 1.61149669e-02f, -8.97283945e-03f, 1.89348999e-02f, -8.13940316e-02f, -2.78550666e-02f, -1.14580458e-02f,
  -8.90519321e-02f, -4.90268953e-02f, 1.77598819e-02f, 5.15742190e-02f, -3.60005647e-02f, -2.30445154e-02f, -7.72626698e-02f, -7.69844651e-02f, -8.10728669e-02f, 6.11775331e-02f,
  4.98168617e-02f, -9.77863744e-02f, -5.54593056e-02f, -7.91195109e-02f, -5.94970435e-02f, -5.94765283e-02f, -1.99692734e-02f, 3.35400403e-02f, -3.02614402e-02f, -1.23115644e-01f,
  6.25906363e-02f, -2.70873085e-02f, -7.44050071e-02f, -2.38979980e-02f, -7.27939829e-02f, -9.81613621e-02f, -6.41376944e-03f, -2.63098963e-02f, 1.76831963e-03f, -8.73504952e-02f,
  2.40901634e-02f, 4.61860262e-02f, 3.31218541e-03f, 2.56612916e-02f, -9.29747969e-02f, 5.19984476e-02f, 6.96279332e-02f, 9.13876370e-02f, 7.48343254e-03f, 3.86351496e-02f,
  -7.81450644e-02f, 6.38380423e-02f, -4.61988114e-02f, 8.00578017e-03f, 4.79658432e-02f, -4.63597178e-02f, -5.00099994e-02f, -2.21462492e-02f, 4.22916710e-02f, 4.44832146e-02f,
  -5.40017039e-02f, 8.98706838e-02f, -5.21011390e-02f, -7.85739869e-02f, -1.45492861e-02f, 9.79396105e-02f, -6.59442171e-02f, -3.81632335e-02f, 1.27971340e-02f, -3.88984680e-02f,
  -2.97471741e-03f, -8.64869654e-02f, -5.31790257e-02f, -3.10900379e-02f, 3.88140865e-02f, 2.64895260e-02f, -2.18352154e-02f, -1.08680269e-02f, -3.41120251e-02f, -4.91562188e-02f,
  2.53589377e-02f, 2.87399963e-02f, -1.09085940e-01f, -1.01671636e-01f, -1.21512804e-02f, -1.25830024e-01f, -3.61084864e-02f, -7.91679043e-03f, 1.64237078e-02f, 4.57355678e-02f,
  -1.22199088e-01f, -1.44967377e-01f, -1.42500058e-01f, -8.26140493e-02f, -9.49891657e-02f, -6.31480366e-02f, 8.40399240e-04f, 4.47578765e-02f, 8.84289891e-02f, 7.70664662e-02f,
  1.35744419e-02f, 1.22453891e-01f, 1.03902452e-01f, 5.51580489e-02f, -5.84887415e-02f, -3.06628440e-02f, -1.10635489e-01f, 3.44884209e-02f, 2.57980265e-02f, 8.47103000e-02f,
  1.01422602e-02f, 9.11270753e-02f, 4.81854193e-03f, -6.71493709e-02f, 7.13119879e-02f, -4.20350581e-02f, -1.86376479e-02f, 7.62258917e-02f, -5.21698259e-02f, 3.50170881e-02f,
  9.60796885e-03f, 4.82489057e-02f, -3.03566754e-02f, 7.07899407e-02f, -2.46328041e-02f, -9.44260731e-02f, -6.37210160e-02f, 7.10623786e-02f, 7.73198530e-02f, 2.11479906e-02f,
  5.64776957e-02f, -6.50289804e-02f, 4.45298888e-02f, 2.84829419e-02f, 2.41282247e-02f, -2.87657082e-02f, 3.34871886e-03f, -2.52907649e-02f, -6.94588199e-02f, 9.33826193e-02f,
  9.41479579e-02f, 7.81242251e-02f, 1.80228762e-02f, 5.31535260e-02f, 7.26651847e-02f, 7.52833262e-02f, 5.15046194e-02f, 3.61487865e-02f, -3.59921902e-02f, -7.39544183e-02f,
  -7.32552558e-02f, 7.71223083e-02f, -6.55630827e-02f, -8.58422294e-02f, -7.64471851e-03f, -2.08412725e-02f, 4.56946231e-02f, -6.50782213e-02f, 2.64239125e-02f, 6.19109496e-02f,
  -3.38674039e-02f, 3.30160954e-03f, 1.51996566e-02f, 2.79975943e-02f, 4.94238213e-02f, 2.81876344e-02f, 1.48023237e-02f, 6.98361322e-02f, 7.21698999e-02f, 4.57615145e-02f,
  -8.70362744e-02f, 6.35284856e-02f, -4.88455221e-03f, -5.97215407e-02f, 3.26546058e-02f, -2.02027746e-02f, 4.50402796e-02f, 5.84162809e-02f, -6.62871054e-04f, -5.13840914e-02f,
  1.24061547e-01f, 2.15064101e-02f, 6.64188638e-02f, 6.58156816e-03f, 6.41119853e-02f, 3.50587070e-02f, -4.72434834e-02f, -3.84203345e-03f, -7.91534316e-03f, 1.00317717e-01f,
  5.08403964e-02f, -6.32265806e-02f, 8.82577002e-02f, 5.72387688e-03f, -6.74953451e-03f, 4.99986559e-02f, 9.09925178e-02f, -3.01958732e-02f, 9.43586156e-02f, 2.94768177e-02f,
  -4.55750488e-02f, 2.60701142e-02f, -2.74515301e-02f, -7.99188670e-03f, 8.72988105e-02f, 6.70197234e-03f, -6.27192184e-02f, -5.07310070e-02f, -4.92226612e-03f, -6.95813540e-03f,
  -8.99255574e-02f, -1.04419187e-01f, -1.55133337e-01f, -5.64112775e-02f, 3.74279357e-02f, -3.92479934e-02f, -9.94930193e-02f, 7.41876960e-02f, -8.31213072e-02f, -2.12758556e-02f,
  4.13121330e-03f, -2.38621458e-02f, -8.40935018e-03f, 1.23923361e-01f, 4.04200330e-03f, 1.97733026e-02f, -8.96291882e-02f, 4.73648869e-02f, 1.76527828e-01f, 4.60159034e-02f,
  -4.98259589e-02f, 4.44389023e-02f, -1.11099984e-02f, 7.00510368e-02f, -6.96796328e-02f, -6.42789528e-02f, 3.62116937e-03f, -1.10548124e-01f, -2.45046206e-02f, -1.39234737e-01f,
  1.17571451e-01f, -1.51227843e-02f, 3.57777104e-02f, -2.39648279e-02f, 2.21789745e-03f, -7.53634721e-02f, 7.29053915e-02f, 6.48230687e-02f, 5.28696664e-02f, 6.01204075e-02f,
  -5.18196225e-02f, -6.89279586e-02f, -3.02741304e-02f, -5.64408079e-02f, -8.25722516e-02f, -2.76853777e-02f, -9.13872644e-02f, -1.31896941e-03f, -3.53899486e-02f, 2.43618060e-02f,
  -6.77442774e-02f, 6.17468208e-02f, 2.57010497e-02f, 3.18856426e-02f, 5.16185872e-02f, 1.16502373e-02f, -8.11347514e-02f, -5.35586439e-02f, -5.17388284e-02f, -1.05024323e-01f,
  -7.38079548e-02f, -1.22537380e-02f, -2.25247927e-02f, 5.97692318e-02f, -4.62231226e-02f, 4.08064649e-02f, -1.02654388e-02f, -3.14683579e-02f, 9.50243399e-02f, -8.20916817e-02f,
  -1.87964179e-02f, -6.41424060e-02f, 1.23629323e-03f, -2.21248474e-02f, 7.66498083e-03f, 3.91643643e-02f, -5.63745536e-02f, 4.82618473e-02f, -8.84161443e-02f, 2.83646248e-02f,
  7.92089552e-02f, 6.03217930e-02f, 8.77934135e-03f, -7.66736716e-02f, -1.24017261e-02f, -2.74407435e-02f, 6.31760284e-02f, 5.98481148e-02f, 3.75546291e-02f, -5.89454360e-02f,
  5.79813644e-02f, -1.68653317e-02f, 4.16519046e-02f, 3.08508929e-02f, -2.33815871e-02f, -8.39960128e-02f, 7.82807637e-03f, 4.93694469e-02f, -1.81040093e-02f, -5.51495664e-02f,
  1.65992964e-03f, 1.14742137e-01f, -7.41188675e-02f, 3.77241112e-02f, 9.27729253e-03f, -2.63039228e-02f, -5.98330703e-03f, -4.31523211e-02f, -2.33498141e-02f, 6.04798552e-03f,
  -9.15241987e-02f, 8.50951020e-03f, 8.93430784e-02f, -6.23621009e-02f, 6.60843104e-02f, 7.97670707e-02f, -2.93235499e-02f, -3.33862677e-02f, 1.19916111e-01f, 5.92129081e-02f,
  4.03568111e-02f, -1.95454769e-02f, 1.21584468e-01f, -3.16391774e-02f, 6.21065944e-02f, -1.72294471e-02f, 9.25837830e-02f, -6.46874011e-02f, 8.60030130e-02f, 3.32244225e-02f,
  -1.91795398e-02f, 4.14476730e-02f, 4.54058982e-02f, 8.63786507e-03f, 8.53879899e-02f, -4.75811698e-02f, -3.09719164e-02f, 6.99807554e-02f, 1.02689955e-02f, 8.23540613e-02f,
  7.57504925e-02f, 3.64240967e-02f, 1.01956345e-01f, 2.09631212e-03f, 8.51367339e-02f, -7.33480379e-02f, -1.45646986e-02f, -7.91256651e-02f, -5.11190295e-02f, 6.36211708e-02f,
  -3.45295318e-03f, 1.04672099e-02f, -1.03281796e-01f, 2.90810447e-02f, -7.43389204e-02f, -8.10501426e-02f, 1.32544385e-02f, 9.04219151e-02f, 1.49959861e-03f, 2.28418540e-02f,
  -5.55294380e-02f, 5.99791519e-02f, -7.58909667e-03f, -7.19464384e-03f, 3.73551734e-02f, 2.10662782e-02f, 2.10301187e-02f, 1.62637513e-02f, 3.20760682e-02f, 2.72915270e-02f,
  -1.14978246e-01f, -6.09111525e-02f, -6.68740198e-02f, 9.09006223e-03f, 5.38513809e-02f, -7.45788366e-02f, 6.73554093e-02f, 4.61949930e-02f, 6.00481741e-02f, 9.39417183e-02f,
  -5.03372326e-02f, -6.64669424e-02f, 9.04647484e-02f, 8.57986584e-02f, -7.78391361e-02f, -1.21788692e-03f, 1.43218255e-02f, -6.33013621e-02f, -2.16331556e-02f, 7.98565522e-02f,
  -7.10323155e-02f, -4.33832072e-02f, 7.62924552e-02f, -7.74911121e-02f, 1.95113383e-02f, -7.09570497e-02f, 8.66353661e-02f, -8.25148001e-02f, -6.80334717e-02f, 6.00529136e-03f,
  7.33417720e-02f, 2.06475779e-02f, 6.06659465e-02f, 7.13088810e-02f, -4.21277732e-02f, 7.15094730e-02f, 6.75647855e-02f, 2.48211306e-02f, 2.31303945e-02f, -1.45598948e-02f,
  5.95242623e-03f, -3.22485492e-02f, -3.93540673e-02f, -8.60007331e-02f, -8.39273334e-02f, -2.98116859e-02f, -9.31550786e-02f, 7.99146742e-02f, 7.18540046e-03f, 4.73860279e-02f,
  -4.88484949e-02f, -1.62213352e-02f, -4.47068438e-02f, -3.44586559e-02f, -3.58469337e-02f, 8.47221240e-02f, 8.17982946e-03f, -8.80355015e-02f, -7.80006172e-03f, 5.27907116e-03f,
  -4.50773388e-02f, 5.95120192e-02f, 3.76490969e-03f, 1.91059597e-02f, -1.00740932e-01f, -3.62058617e-02f, 2.86828019e-02f, 6.61853775e-02f, 1.23813730e-02f, -5.15081026e-02f,
  -8.22815523e-02f, 1.35442093e-01f, -7.58250281e-02f, -9.39579606e-02f, 8.04436877e-02f, 1.19833566e-01f, 1.05121888e-01f, 6.57749176e-02f, -8.76471251e-02f, -9.04980674e-03f,
  1.72490031e-02f, -9.37836170e-02f, 2.44830325e-02f, 2.96838805e-02f, 4.56983894e-02f, 1.17984273e-01f, 1.09812312e-01f, -8.53370801e-02f, -7.63463695e-03f, -5.17495871e-02f,
  1.36433002e-02f, 3.14879790e-02f, -1.35498017e-01f, -1.21036567e-01f, -1.07132085e-02f, -9.90784094e-02f, -1.95001124e-03f, 1.12703741e-02f, 1.15097091e-01f, 6.86638802e-02f,
  3.96960489e-02f, 2.07716059e-02f, 5.02981059e-02f, -8.06991830e-02f, 3.31792533e-02f, 2.45180652e-02f, 5.10793701e-02f, -9.12571251e-02f, -6.45974651e-02f, -6.61835000e-02f,
  9.25338641e-03f, 6.43694177e-02f, -4.04367894e-02f, 2.88771223e-02f, -1.92054063e-02f, -1.58718713e-02f, -7.60140494e-02f, 3.33258994e-02f, 6.55697659e-02f, 5.21710254e-02f,
  8.35794676e-03f, 1.00624152e-01f, 6.01356477e-03f, 1.21131755e-01f, 7.45971426e-02f, 2.44361954e-03f, 2.37639192e-02f, 5.21271788e-02f, 2.72696260e-02f, -1.05238862e-01f,
  -7.59853944e-02f, 2.68567130e-02f, -6.43023625e-02f, -9.00828242e-02f, -7.43155852e-02f, 4.60238531e-02f, 7.67435953e-02f, 4.38290536e-02f, -2.82154921e-02f, -6.56578690e-02f,
  8.63348693e-02f, -6.64578229e-02f, 5.27062640e-02f, -6.12240918e-02f, 8.74157064e-03f, -1.71603579e-02f, 3.22173573e-02f, 5.21948487e-02f, 7.15667456e-02f, 3.17571871e-03f,
  4.19731550e-02f, 5.39443158e-02f, 7.10791051e-02f, 2.43301541e-02f, 3.79089154e-02f, -3.71909607e-03f, 6.71951519e-03f, -3.89016159e-02f, -7.26710111e-02f, -9.14566368e-02f,
  -6.24876991e-02f, 1.41895205e-01f, -6.65455163e-02f, 7.44188353e-02f, -2.12510619e-02f, 4.91419733e-02f, -2.69328319e-02f, -8.58685002e-02f, 3.73425558e-02f, 3.73534532e-03f,
  -1.99493530e-04f, 9.13555641e-03f, 3.69159654e-02f, -7.71039501e-02f, -9.47625712e-02f, -2.66786255e-02f, 6.86601028e-02f, 5.92059121e-02f, 1.20690607e-01f, -5.52877448e-02f,
  3.54760289e-02f, -8.09168350e-03f, -8.99938345e-02f, -4.47146185e-02f, 7.38149956e-02f, -2.92467978e-02f, -7.23245740e-02f, -2.32941862e-02f, -7.00136051e-02f, -5.24618924e-02f,
  1.18662484e-01f, -3.56295742e-02f, -1.78972408e-01f, 3.81053574e-02f, 2.02829782e-02f, -5.83718568e-02f, -4.56915647e-02f, -2.43141241e-02f, 5.21721281e-02f, -5.45826778e-02f,
  -3.34681869e-02f, 1.42972684e-02f, -1.01945527e-01f, -1.60401687e-02f, -9.43594202e-02f, -1.09263420e-01f, -1.37174919e-01f, 3.42005491e-02f, -1.80630833e-02f, 3.69365960e-02f,
  -5.72324879e-02f, 5.24696596e-02f, -4.37844954e-02f, 2.77555231e-02f, 1.40751470e-02f, 3.88941094e-02f, -1.21518999e-01f, -4.08070534e-02f, -7.66801313e-02f, -8.20230991e-02f,
  -1.65694490e-01f, 4.24969643e-02f, -9.44363028e-02f, 4.80620526e-02f, -9.42653492e-02f, -3.83675657e-02f, -6.13265075e-02f, -6.60815760e-02f, -7.49627175e-03f, -1.12397298e-04f,
  -7.03253224e-02f, 2.83752177e-02f, 6.15347959e-02f, -8.11027139e-02f, -8.50999448e-03f, 8.82279687e-03f, 8.23285058e-02f, -4.37475182e-02f, -6.96099177e-02f, -1.95614179e-03f,
  1.17410384e-02f, -1.07953772e-01f, -1.22748531e-01f, -4.35616635e-02f, 3.97179462e-02f, -6.56001791e-02f, 5.62272891e-02f, -9.71058086e-02f, 3.21753509e-02f, 2.71008853e-02f,
  5.31080626e-02f, -1.07798584e-01f, 1.60308424e-02f, 2.18490809e-02f, 5.30201942e-02f, 4.66794111e-02f, 6.16847910e-02f, 1.28885731e-02f, -1.61658376e-02f, 2.96587124e-02f,
  6.36482164e-02f, -9.06888843e-02f, -1.38350949e-02f, 8.07719082e-02f, 2.97838412e-02f, -3.37124318e-02f, -5.72166406e-02f, -4.09952663e-02f, -7.83166587e-02f, -7.96700120e-02f,
  -7.64817446e-02f, 3.64559442e-02f, 4.93532754e-02f, -8.25504884e-02f, 3.50609235e-02f, 7.68108442e-02f, -1.57443918e-02f, 2.17052829e-02f, 5.81839569e-02f, 4.72947061e-02f,
  6.10365383e-02f, -1.60097033e-02f, -1.79481283e-02f, 7.32600614e-02f, -8.72741453e-03f, 5.14438562e-02f, -3.70040424e-02f, -8.79507884e-02f, 4.27698456e-02f, -3.12479213e-02f,
  1.75600573e-02f, 5.36815263e-02f, 7.43791685e-02f, 2.18375158e-02f, -5.62219284e-02f, 8.10093433e-02f, -2.40262151e-02f, -7.24424049e-02f, 4.52454798e-02f, -3.14748697e-02f,
  9.21695605e-02f, 1.91485435e-02f, 2.82894131e-02f, -2.22956892e-02f, -2.07897071e-02f, -3.68122384e-02f, 2.02401392e-02f, -9.24647152e-02f, -4.17951262e-03f, 1.34570569e-01f,
  -2.05362365e-01f, -9.04704854e-02f, -1.58227071e-01f, -1.78768203e-01f, -2.87386682e-02f, 3.43690328e-02f, -1.28325209e-01f, -6.61639646e-02f, 5.35132457e-03f, -1.61838353e-01f,
  -5.37525602e-02f, 2.74813436e-02f, 4.32454757e-02f, -3.98799814e-02f, 1.55241257e-02f, -2.06731190e-03f, -5.20054214e-02f, -2.73254439e-02f, 5.90965450e-02f, 1.46106139e-01f,
  -1.46494983e-02f, -9.50693861e-02f, 4.35561314e-02f, -8.90941098e-02f, -7.36287832e-02f, -6.31250814e-02f, -1.31265998e-01f, -7.47979283e-02f, -1.55143226e-02f, -2.67907232e-02f,
  1.46986628e-02f, -8.60945601e-03f, 7.92099610e-02f, -5.18522747e-02f, -1.41573288e-02f, -1.02860928e-02f, -2.37859283e-02f, 3.97658274e-02f, 1.85295846e-02f, 7.29391202e-02f,
  -1.29148122e-02f, 4.84711416e-02f, 3.01954541e-02f, 1.02975979e-01f, -1.58700626e-02f, 3.29200439e-02f, -1.80333424e-02f, -5.17070387e-03f, -3.02420557e-03f, 3.66926268e-02f,
  8.36800709e-02f, -7.40235671e-02f, 5.45932464e-02f, -4.38908897e-02f, -3.83360162e-02f, 7.53451288e-02f, 4.86745723e-02f, 8.18138346e-02f, 2.73221973e-02f, -7.25914612e-02f,
  1.64165217e-02f, -7.63216764e-02f, 7.69575387e-02f, 1.49377482e-03f, 1.48458015e-02f, -6.34641796e-02f, -6.48149103e-02f, -4.06657197e-02f, 1.56202130e-02f, 1.38462046e-02f,
  1.03110634e-02f, 4.97493707e-02f, 5.89940958e-02f, -1.20099612e-01f, -4.64383960e-02f, -3.18945125e-02f, -9.55449641e-02f, 4.97220084e-02f, -8.85545015e-02f, -6.60041766e-03f,
  -8.65031704e-02f, 1.90210808e-02f, -2.07955558e-02f, -4.07524258e-02f, 7.59125650e-02f, 1.09346835e-02f, 2.25995630e-02f, -2.17691697e-02f, 8.35377797e-02f, 1.47662014e-02f,
  3.83903645e-02f, 4.72168773e-02f, 1.60962716e-02f, 5.22469543e-02f, -5.44707477e-02f, -8.93076882e-02f, -4.76664267e-02f, 8.48946348e-02f, -3.86795551e-02f, 1.00353017e-01f,
  1.01102784e-01f, -5.46359308e-02f, -3.28050107e-02f, 7.13207871e-02f, 4.78085279e-02f, 7.38970712e-02f, -6.14326037e-02f, -8.10809284e-02f, 9.23737884e-02f, 7.84409046e-02f,
  -9.59222615e-02f, 6.82379156e-02f, -3.39427590e-02f, -7.85043463e-02f, -4.42436375e-02f, -1.91922579e-02f, 2.31523272e-02f, 1.13493279e-02f, -4.35378626e-02f, -7.03918040e-02f,
  -8.85709189e-03f, -5.81454411e-02f, -3.99033092e-02f, -1.29505675e-02f, -5.53975590e-02f, -9.56006646e-02f, -1.57520235e-01f, -8.11948553e-02f, 2.45259125e-02f, -1.82610436e-03f,
  -2.10704762e-04f, 3.63089480e-02f, 3.14380452e-02f, 5.14317080e-02f, 3.53820361e-02f, -6.21609539e-02f, -1.98772438e-02f, -5.23036271e-02f, -5.81331328e-02f, -1.27119394e-02f,
  -7.21094310e-02f, -5.98970950e-02f, 4.21907902e-02f, -1.24802794e-02f, 5.60411811e-02f, 2.59809624e-02f, -3.92730162e-02f, 2.44410988e-03f, -9.05359089e-02f, -8.37887377e-02f,
  -5.46966419e-02f, 6.78426772e-02f, -1.48393391e-02f, 6.30067708e-03f, -8.16464797e-02f, -8.87324661e-02f, 9.42674465e-03f, 3.49301659e-02f, -4.24234234e-02f, 2.59532034e-02f,
  9.66762472e-03f, -5.23091741e-02f, -6.01539314e-02f, 9.79057420e-03f, -5.23349224e-03f, 4.16072793e-02f, -9.66495648e-02f, 1.34018082e-02f, 5.64963706e-02f, -9.65428073e-03f,
  -6.88351691e-02f, -9.17119831e-02f, -5.25316596e-02f, -1.02411769e-02f, 3.55765894e-02f, 2.42819265e-03f, 6.40470013e-02f, 1.11435547e-01f, 5.74484840e-02f, 6.32524788e-02f,
  4.71769571e-02f, -7.45633319e-02f, -5.11881821e-02f, -4.59189527e-02f, -5.13076149e-02f, -6.83235675e-02f, 4.44041507e-04f, 2.32215622e-03f, -1.64038818e-02f, 1.42147942e-02f,
  -6.90567568e-02f, 3.19762598e-03f, -7.33003542e-02f, -7.43545145e-02f, 2.97481269e-02f, 5.42897210e-02f, -3.97310592e-02f, 3.30133736e-02f, -3.18589732e-02f, -3.07198558e-02f,
  8.42781067e-02f, 9.61899310e-02f, 9.10459384e-02f, 5.95132411e-02f, -2.23802011e-02f, 2.55755186e-02f, -6.53315187e-02f, -7.91753083e-02f, 6.18671663e-02f, -5.29560857e-02f,
  6.86859488e-02f, 7.31379143e-04f, 3.31112258e-02f, 6.49739988e-03f, -1.85321551e-02f, 7.70665929e-02f, 1.53823923e-02f, -8.89457986e-02f, -6.12303503e-02f, 5.49451672e-02f,
  -7.47540891e-02f, -6.72781989e-02f, -6.18678257e-02f, -1.95848327e-02f, 4.26675230e-02f, -2.23561376e-03f, -3.36329713e-02f, -8.93738791e-02f, 4.29639295e-02f, 9.71810054e-03f,
  2.55092438e-02f, -6.98910579e-02f, 5.41193690e-03f, -2.47362852e-02f, 6.22678660e-02f, -1.15537375e-01f, -2.68160016e-03f, 4.61515114e-02f, 4.66750078e-02f, 4.55268426e-04f,
  -9.49739441e-02f, -3.03024184e-02f, -5.46877161e-02f, -8.24751854e-02f, -5.84733076e-02f, 1.13302417e-01f, 8.15428868e-02f, 7.86661655e-02f, 1.29259046e-04f, 1.48935663e-02f,
  4.20939922e-02f, 9.99272615e-02f, 6.78516850e-02f, -6.07171394e-02f, 1.08068325e-02f, 8.41806233e-02f, -5.47626838e-02f, 9.41975415e-03f, -4.71306331e-02f, 9.51342061e-02f,
  3.61600332e-02f, -7.61165023e-02f, -7.67633738e-03f, 6.30290732e-02f, -1.54689867e-02f, 1.12820789e-02f, -7.89315253e-03f, -8.36968273e-02f, -3.47297937e-02f, -6.25524595e-02f,
  -2.33919919e-02f, -1.31028116e-01f, -3.60980518e-02f, 2.30855718e-02f, 2.09547933e-02f, -3.07008643e-02f, -6.32112985e-03f, -2.09794026e-02f, -1.85471643e-02f, -1.88915078e-02f,
  4.30381708e-02f, -5.92411943e-02f, -3.50272395e-02f, -6.22703694e-02f, -7.19489977e-02f, 6.93656206e-02f, 6.88156486e-02f, 3.73601988e-02f, 5.31425737e-02f, 6.62903022e-03f,
  -5.24083991e-03f, -5.94361387e-02f, 6.42637983e-02f, 6.09636232e-02f, -6.39062673e-02f, 6.64722919e-02f, 5.14704920e-02f, -5.49340844e-02f, -2.71798037e-02f, 3.75072099e-02f,
  -1.96526609e-02f, -1.99387092e-02f, -1.89371849e-03f, -5.43115996e-02f, 3.01381405e-02f, -1.45223876e-02f, -7.56793097e-02f, 5.69950230e-02f, 2.25313082e-02f, -7.47775510e-02f,
  -1.39455711e-02f, -1.64460335e-02f, 3.61875352e-03f, -1.39402580e-02f, -1.50973639e-02f, 3.77606750e-02f, 6.96732178e-02f, -5.28172515e-02f, -2.99070892e-03f, -3.38373780e-02f,
  4.48007919e-02f, -1.18841548e-02f, -3.11306044e-02f, -8.65026843e-03f, 7.53364861e-02f, 1.96610875e-02f, -6.09901324e-02f, -7.26858526e-02f, 1.31613072e-02f, 7.07556158e-02f,
  8.08881000e-02f, -8.10836479e-02f, -2.94669420e-02f, 9.70410779e-02f, 2.92801149e-02f, 6.91915751e-02f, -3.56065407e-02f, 5.33395223e-02f, -3.72416303e-02f, -4.82110539e-03f,
  1.30040990e-02f, 6.89225569e-02f, -6.87973946e-02f, -4.98884991e-02f, -1.85514409e-02f, 5.20198829e-02f, -5.11081479e-02f, -1.58816241e-02f, 1.70310773e-02f, -3.51749063e-02f,
  7.45467916e-02f, 9.93961617e-02f, -5.68841733e-02f, 1.05043262e-01f, 1.09206490e-01f, -3.19209509e-02f, 7.86409676e-02f, 5.66622317e-02f, -5.44669591e-02f, -5.23855872e-02f,
  -8.89436454e-02f, -1.39801041e-03f, 4.19262722e-02f, -5.36547266e-02f, -5.33054918e-02f, 5.78136556e-02f, -5.57215810e-02f, 1.06609631e-02f, -3.67074721e-02f, 7.89362565e-02f,
  5.11069186e-02f, -7.64947608e-02f, -5.15753776e-02f, -4.06770408e-02f, -3.73206176e-02f, 1.00710616e-01f, 1.24035090e-01f, -6.96894154e-02f, 1.49758775e-02f, -4.71421853e-02f,
  -3.54374349e-02f, 3.34325768e-02f, 7.35668838e-02f, 6.31233826e-02f, 3.18696313e-02f, 2.46879775e-02f, 7.25106597e-02f, -4.90901899e-03f, 6.78634122e-02f, 3.17404158e-02f,
  -2.42692027e-02f, -7.00084344e-02f, 6.73252046e-02f, -8.29420686e-02f, -9.43785254e-03f, 7.72511512e-02f, -3.87289003e-02f, 6.66218400e-02f, 6.52583167e-02f, -5.23346625e-02f,
  -5.54409027e-02f, -5.23713976e-02f, 5.08595780e-02f, 5.03089204e-02f, 4.78387019e-03f, -1.34967538e-02f, 5.58738820e-02f, 7.32900649e-02f, -7.66441748e-02f, -1.53096532e-02f,
  1.00042000e-01f, -7.17132837e-02f, -6.25735372e-02f, -1.35027908e-03f, 8.41329247e-03f, -5.96643947e-02f, 3.65147479e-02f, -1.61157437e-02f, 2.19086558e-02f, -7.55125433e-02f,
  4.71394807e-02f, 3.37938480e-02f, 2.20837910e-02f, -8.53496939e-02f, 1.76673606e-02f, -5.56726716e-02f, 8.25269669e-02f, -4.72552665e-02f, -3.12198345e-02f, 6.05621375e-02f,
  6.05835393e-02f, 4.67236117e-02f, 5.26942648e-02f, -3.27561162e-02f, -6.21656589e-02f, 4.07881103e-02f, -4.91872057e-03f, -5.37008606e-02f, 3.91210280e-02f, 7.27637559e-02f,
  5.02468413e-03f, 8.69957358e-02f, 2.99896300e-02f, -7.73013309e-02f, 5.99055588e-02f, -4.87524793e-02f, 7.08534643e-02f, 1.41135035e-02f, -5.98435886e-02f, -7.77201578e-02f,
  -1.82983931e-02f, -7.55378678e-02f, -5.87233901e-02f, -5.14330678e-02f, 2.45829001e-02f, -2.67218072e-02f, 8.47022012e-02f, -3.62013467e-02f, -5.03415093e-02f, 8.88138078e-03f,
  1.70345437e-02f, -6.86532706e-02f, -3.09132272e-03f, -9.34389755e-02f, -4.11593132e-02f, -3.72690614e-03f, -3.52218896e-02f, -8.02715272e-02f, -3.41077223e-02f, -8.55625123e-02f,
  8.31347778e-02f, -9.91933197e-02f, -7.74475262e-02f, -4.55189720e-02f, -6.18391261e-02f, -1.28514906e-02f, -3.44783440e-02f, -2.76128389e-02f, -8.32150728e-02f, -6.70037866e-02f,
  9.77037624e-02f, 1.54867442e-02f, 5.30725047e-02f, 2.53714323e-02f, -9.76018906e-02f, -1.24933340e-01f, -1.13073654e-01f, -9.15775895e-02f, -3.69451456e-02f, -3.38723883e-02f,
  1.49175916e-02f, -1.07075639e-01f, -8.53598118e-02f, -9.36713293e-02f, -1.26091748e-01f, 1.01491651e-02f, 7.49237314e-02f, 2.63201743e-02f, -1.42666578e-01f, -5.41215055e-02f,
  -7.22806603e-02f, 3.41585316e-02f, 2.79630013e-02f, -3.23771052e-02f, -2.69690026e-02f, 8.12468061e-04f, 8.14836845e-02f, 5.60577027e-02f, -4.96897995e-02f, 2.91862693e-02f,
  -8.84077176e-02f, 6.66657388e-02f, -6.59121051e-02f, -3.37084159e-02f, 8.02264512e-02f, -6.21977486e-02f, 5.94958290e-03f, 1.05214743e-02f, 7.26685300e-02f, 1.03054726e-02f,
  -3.18129696e-02f, 2.79452018e-02f, -3.73325944e-02f, -8.31509084e-02f, -1.60438605e-02f, 2.12454312e-02f, 8.78677070e-02f, 5.77248074e-02f, -6.51714876e-02f, -6.39301166e-02f,
  3.61075141e-02f, 1.98731702e-02f, 1.69255771e-02f, 6.09243400e-02f, -7.36388266e-02f, 2.63680331e-02f, -9.40271690e-02f, -3.89535762e-02f, -2.65078992e-02f, 7.89365098e-02f,
  6.16015233e-02f, 3.79581451e-02f, -5.84121980e-02f, 2.38281321e-02f, 9.32704136e-02f, -3.28566991e-02f, 9.46850851e-02f, -1.46422368e-02f, 3.02084684e-02f, -3.03473305e-02f,
  7.62055442e-02f, -7.17754848e-03f, -6.68136925e-02f, 7.06505105e-02f, 7.31504485e-02f, 9.06469114e-03f, -6.82984106e-03f, 8.60578939e-02f, 5.60007151e-03f, 1.03680424e-01f,
  1.13976048e-02f, 7.70981982e-02f, -5.89868128e-02f, -7.57431015e-02f, 2.01313980e-02f, 6.03899732e-02f, -3.91171463e-02f, 1.00022294e-01f, 6.67372942e-02f, 4.61937673e-02f,
  2.69461628e-02f, -9.08849314e-02f, -8.48880559e-02f, 4.39769998e-02f, 8.17709193e-02f, -1.95905846e-02f, -5.83063252e-02f, 2.51942109e-02f, -1.99330822e-02f, 1.72839407e-02f,
  -2.22337106e-03f, 6.98970631e-02f, -7.04814792e-02f, 5.69209084e-02f, 5.79370372e-02f, -3.60761881e-02f, 1.91518143e-02f, 1.98822320e-02f, -8.21083784e-02f, -7.29990155e-02f,
  -5.08014075e-02f, -2.38310825e-02f, -2.71038190e-02f, 8.24897457e-03f, 2.03981381e-02f, -1.20197974e-01f, -9.18644816e-02f, 3.51138376e-02f, 6.13155700e-02f, -3.07324156e-02f,
  5.53770997e-02f, 1.00768603e-01f, 1.30290926e-01f, 5.89729808e-02f, -1.30196333e-01f, -1.32889971e-02f, 5.09052910e-02f, -2.45905481e-02f, 3.06483638e-02f, -4.59801778e-02f,
  -9.24219713e-02f, -6.40736446e-02f, -1.21603888e-02f, -2.97709908e-02f, 9.98516828e-02f, 4.49097790e-02f, 3.19660753e-02f, 1.11156978e-01f, 4.24669720e-02f, -9.20440033e-02f,
  -7.93916509e-02f, -1.23684006e-02f, 8.08298960e-02f, -2.54285056e-02f, -5.44422194e-02f, -1.53720966e-02f, -3.45337316e-02f, 2.97012199e-02f, -9.93783623e-02f, -1.53103033e-02f,
  -3.02002206e-02f, -9.48701147e-03f, 2.85837222e-02f, -6.94974000e-03f, 5.88946678e-02f, 1.12775825e-01f, -3.81716378e-02f, -3.64905894e-02f, -2.57792789e-02f, 1.76771022e-02f,
  -7.91716874e-02f, -7.08017945e-02f, 3.94846238e-02f, 6.55975938e-02f, -5.12059517e-02f, 2.97000986e-02f, 1.16833914e-02f, 8.23481157e-02f, -6.73442632e-02f, -9.30624157e-02f,
  -7.10802823e-02f, -2.88868858e-03f, 5.42241707e-02f, 4.91142422e-02f, 5.87619841e-02f, -1.17492519e-01f, 6.30609915e-02f, -5.00551425e-03f, -5.06701134e-03f, -1.77689828e-02f,
  1.04544900e-01f, -7.54466206e-02f, -2.77459994e-02f, -6.12753928e-02f, -1.00736544e-02f, -8.40207934e-03f, 5.76233342e-02f, -4.31272835e-02f, -5.46238050e-02f, -7.03293532e-02f,
  3.32847424e-02f, -5.31061403e-02f, -4.79108799e-04f, 9.07200202e-02f, -2.37931255e-02f, -4.00654785e-02f, -9.59129632e-02f, -5.68333222e-03f, 3.81377339e-02f, -8.54579583e-02f,
  -4.25614789e-02f, 1.68995075e-02f, 9.79103241e-03f, 1.37098404e-02f, -2.34366003e-02f, -1.83938704e-02f, -5.39323278e-02f, -2.19326783e-02f, -5.39680524e-03f, -1.44228956e-03f,
  9.60881710e-02f, 6.10499568e-02f, -3.89318839e-02f, 9.71122552e-03f, 9.30753257e-03f, -1.28437066e-03f, 1.32861361e-02f, 1.29373431e-01f, 7.42911622e-02f, -1.54063134e-02f,
  -2.93886731e-03f, -2.26832200e-02f, 7.12569728e-02f, -1.66783743e-02f, 9.29494724e-02f, -2.57066805e-02f, 3.58208874e-03f, -5.20538911e-03f, 3.56986001e-02f, 7.06271380e-02f,
  -1.32861324e-02f, -1.27458442e-02f, -4.05451581e-02f, -8.33893381e-03f, 1.53519819e-02f, -7.78411999e-02f, 5.67575134e-02f, -7.37004401e-03f, 1.08250000e-01f, 6.98423609e-02f,
  2.31551766e-01f, 1.52319878e-01f, 4.14024368e-02f, 6.25408962e-02f, -4.54193279e-02f, -1.77861139e-01f, -1.88118353e-01f, 5.93316462e-03f, -2.26130411e-02f, -2.28080340e-02f,
  -3.61567773e-02f, 2.63308547e-02f, -2.14138422e-02f, 8.13844241e-03f, -4.33970690e-02f, 3.96089219e-02f, 8.10800269e-02f, 1.32323727e-01f, 3.08600590e-02f, -1.02881052e-01f,
  -8.47586244e-02f, -3.74435186e-02f, 1.51373014e-01f, 2.52430085e-02f, -1.72260329e-02f, -2.81521473e-02f, -2.75917398e-03f, 8.85617211e-02f, 7.25648850e-02f, 1.41003326e-01f,
  1.50285065e-01f, 1.07005835e-01f, -1.32269368e-01f, 6.24809265e-02f, 7.61370882e-02f, 1.20188348e-01f, -2.64271665e-02f, 8.44646245e-02f, -6.70978874e-02f, -2.27353238e-02f,
  5.43576889e-02f, 1.07534111e-01f, 8.47002044e-02f, 6.58697635e-02f, -3.84006910e-02f, 8.07112008e-02f, 1.45037606e-01f, 1.38621435e-01f, -5.81248961e-02f, 1.05513349e-01f,
  -1.22657921e-02f, -1.16066210e-01f, 2.89669558e-02f, -3.80642861e-02f, 8.72712210e-02f, 5.57193272e-02f, -6.03163764e-02f, 6.03665859e-02f, 4.41430928e-03f, -3.46615762e-02f,
  -8.38643312e-02f, -6.41244948e-02f, -3.71410623e-02f, -5.60716279e-02f, -2.83209551e-02f, -7.69507140e-02f, -7.73932412e-02f, 1.92287285e-02f, -2.26222314e-02f, 6.26535118e-02f,
  -3.27625051e-02f, -1.51159829e-02f, 1.87592991e-02f, 1.04938317e-02f, 4.94573303e-02f, 3.79512534e-02f, -5.56267891e-03f, -1.30874207e-02f, 6.59040660e-02f, 3.20959575e-02f,
  -7.78949037e-02f, 6.03664480e-02f, -2.09733291e-04f, -4.72602323e-02f, 4.32308130e-02f, 3.00453529e-02f, 6.27262741e-02f, -7.43733719e-02f, -2.60637868e-02f, -8.81681144e-02f,
  -1.14695221e-01f, 5.20540252e-02f, 6.71423376e-02f, 2.56220102e-02f, 9.78585258e-02f, 8.92249718e-02f, -4.39743213e-02f, 3.94458510e-02f, -8.37776810e-02f, 2.05195416e-02f,
  -2.04221718e-02f, 9.50833783e-02f, 6.01725057e-02f, -8.16153809e-02f, 5.35079278e-03f, -1.05893910e-01f, -6.15017582e-03f, 7.38595203e-02f, -8.44174549e-02f, 4.26787287e-02f,
  4.07588072e-02f, -2.00170074e-02f, -1.35900259e-01f, -1.54550940e-01f, -1.10792868e-01f, -1.64112672e-01f, -6.91250116e-02f, 2.07765885e-02f, -5.20512126e-02f, -1.24255642e-01f,
  1.56346649e-01f, 3.01517025e-02f, -8.27199314e-03f, 3.73040549e-02f, -2.28054896e-02f, -1.13837518e-01f, -5.18094189e-02f, -6.21187501e-02f, -5.80338910e-02f, 5.83075359e-02f,
  -6.62640184e-02f, 5.13540283e-02f, -4.50664153e-03f, -4.05619629e-02f, -3.77218276e-02f, 8.68215319e-03f, 4.61955480e-02f, -1.35327196e-02f, -9.93468612e-02f, -6.02668989e-03f,
  8.16073120e-02f, 9.99545306e-02f, 1.28602320e-02f, -6.36104941e-02f, 8.92656446e-02f, 1.10219428e-02f, 1.02577033e-02f, -3.44300903e-02f, -4.13521752e-03f, 9.00227875e-02f,
  8.77162889e-02f, 1.11897387e-01f, -9.25547034e-02f, 5.07649854e-02f, 5.13446778e-02f, 3.92972492e-03f, 2.85699349e-02f, -3.01926918e-02f, -8.28414187e-02f, 2.67060082e-02f,
  8.20229575e-02f, -4.15514410e-02f, 4.75010276e-02f, -6.51708394e-02f, -7.12597510e-03f, 5.20981513e-02f, 6.79361150e-02f, -7.73738995e-02f, -6.43376857e-02f, -1.77998450e-02f,
  2.82626576e-03f, -3.20537798e-02f, 3.97519134e-02f, -3.67068942e-03f, -8.42569098e-02f, -5.47590740e-02f, -2.17928533e-02f, -8.08280632e-02f, 3.53137497e-03f, 1.27585381e-01f,
  8.39223638e-02f, 4.29479405e-03f, -4.12536133e-03f, 7.63149783e-02f, 4.50231358e-02f, -5.98663762e-02f, -4.39505018e-02f, -1.16614001e-02f, -2.96122045e-03f, 9.06339213e-02f,
  5.51814493e-03f, -7.43080601e-02f, 8.75042826e-02f, 6.51786551e-02f, 2.06491277e-02f, 4.97972406e-02f, -5.53059019e-02f, -7.10505014e-03f, 6.47641718e-03f, 1.78927705e-02f,
  -4.37220326e-03f, 7.46879820e-03f, -5.87945208e-02f, -2.00757943e-02f, 7.67547861e-02f, 4.56319861e-02f, -5.77289723e-02f, -2.57860832e-02f, 6.07505068e-02f, 7.30103180e-02f,
  3.57175432e-02f, -1.25401805e-03f, -7.69180655e-02f, 5.69751021e-04f, -6.57190382e-02f, 7.57863447e-02f, -5.76005578e-02f, 1.65805537e-02f, -1.78132858e-02f, -3.70193087e-02f,
  -9.42652393e-03f, -7.05257729e-02f, 1.69321299e-02f, -3.38756926e-02f, -3.55044454e-02f, 4.69403043e-02f, 1.59007702e-02f, -9.85507518e-02f, -1.27300331e-02f, 1.63910594e-02f,
  -1.90087855e-02f, -5.34568243e-02f, -1.24012791e-01f, 4.04877290e-02f, -1.13137655e-01f, -2.80826148e-02f, -4.63702455e-02f, -7.86175504e-02f, -6.71247914e-02f, -4.84056138e-02f,
  3.82445961e-01f, 8.66722241e-02f, 7.34163597e-02f, 1.51246592e-01f, 1.50271416e-01f, 4.10979204e-02f, 1.27486676e-01f, 1.04292758e-01f, -2.39502862e-02f, 1.45541698e-01f,
  1.34215400e-01f, 1.76660139e-02f, 1.16004221e-01f, 3.50717567e-02f, 7.23387599e-02f, 4.55632210e-02f, 2.88793277e-02f, 4.69980054e-02f, 1.20137535e-01f, 8.07359889e-02f,
  -1.25249967e-01f, 1.03109377e-02f, 3.50694917e-02f, -3.26705724e-02f, -9.43165645e-02f, -5.88433556e-02f, -1.96993072e-02f, 7.00242538e-03f, -1.58756971e-02f, -1.44238800e-01f,
  7.22762942e-03f, 2.07608879e-01f, -3.52871306e-02f, -2.24245479e-03f, -1.35883596e-03f, 8.54346976e-02f, 1.08894557e-01f, 1.88346468e-02f, -4.80731167e-02f, -6.94378689e-02f,
  2.99034431e-03f, 7.25125223e-02f, 3.51068489e-02f, -4.36033905e-02f, 7.79617280e-02f, 5.53613007e-02f, -4.51565869e-02f, -7.09253922e-02f, 6.89973980e-02f, -5.58419153e-02f,
  -9.77212489e-02f, 2.36707758e-02f, -5.41208917e-03f, 7.20729232e-02f, 6.54437626e-03f, 8.01252052e-02f, 3.11725810e-02f, 5.28082959e-02f, 9.50897560e-02f, -5.39966440e-03f,
  6.17820024e-02f, 8.54279250e-02f, -3.36329900e-02f, 7.78870732e-02f, 2.78174132e-02f, 9.71864164e-03f, 1.61169674e-02f, -3.93807702e-02f, 2.08151732e-02f, -5.39959706e-02f,
  1.00069046e-01f, -2.23720148e-02f, -5.89912087e-02f, -1.02988789e-02f, -8.13387334e-03f, 3.05342078e-02f, 1.65851619e-02f, 4.86229472e-02f, 7.56206140e-02f, 8.64754766e-02f,
  7.02783987e-02f, 1.08205810e-01f, 3.48463096e-02f, -5.00106290e-02f, 2.97112875e-02f, 6.14398383e-02f, 6.00042418e-02f, -3.75255160e-02f, 5.80847375e-02f, 2.64144968e-02f,
  -4.99240705e-05f, 1.22521371e-01f, -1.50084849e-02f, -1.03543021e-01f, 7.98600167e-02f, -6.94246888e-02f, 1.13754913e-01f, -1.89323202e-02f, 7.14024678e-02f, 3.74717116e-02f,
  -5.47108874e-02f, -3.81398909e-02f, -4.54571620e-02f, 2.30707265e-02f, 1.61451730e-03f, 7.82061964e-02f, -2.06882674e-02f, -1.89149398e-02f, 3.28564085e-02f, 2.51316577e-02f,
  -6.26144111e-02f, 3.46317627e-02f, 1.23220414e-01f, 1.81997530e-02f, -9.08530876e-02f, -3.28380950e-02f, 7.47917220e-02f, 1.82425603e-02f, -5.21483310e-02f, 1.08164586e-01f,
  4.16916572e-02f, 3.59501429e-02f, 9.72651988e-02f, 5.57649992e-02f, -7.16679394e-02f, -1.01070426e-01f, 8.58352333e-03f, 5.69400564e-02f, 4.28350829e-02f, 7.90702354e-04f,
  4.11458574e-02f, -5.86289950e-02f, 7.14428723e-02f, 8.10949951e-02f, 7.93591607e-03f, -7.02964002e-03f, 7.47171640e-02f, 8.86865184e-02f, 6.53001219e-02f, 8.55491906e-02f,
  7.81465508e-03f, 7.83477798e-02f, 1.24770030e-01f, 5.58093470e-03f, 2.62184851e-02f, -5.09071834e-02f, 7.78271705e-02f, 9.29476172e-02f, 2.32076123e-02f, -4.01232839e-02f,
  -9.01213959e-02f, 3.25223245e-02f, 7.42710307e-02f, 4.30951081e-02f, 5.26636392e-02f, 1.97394378e-02f, 2.93276347e-02f, -3.54010845e-03f, 1.69571936e-02f, -2.26798002e-03f,
  4.81944680e-02f, -4.62880470e-02f, -4.98782136e-02f, 7.48972744e-02f, -9.71268937e-02f, -5.54837883e-02f, -1.73358861e-02f, 9.87734422e-02f, 7.05618858e-02f, 7.07440078e-03f,
  5.41254394e-02f, -5.71349300e-02f, 4.56283018e-02f, -1.07971124e-01f, 2.90837660e-02f, 4.58681071e-03f, -9.43077877e-02f, -2.36747172e-02f, -5.93371540e-02f, 8.59607384e-02f,
  6.09048046e-02f, -2.25202721e-02f, -1.60137750e-02f, 2.38657016e-02f, -2.62857303e-02f, 1.92295797e-02f, 5.57951257e-02f, 3.59253329e-03f, 8.14782679e-02f, -3.42146456e-02f,
  -4.28846404e-02f, 2.02123616e-02f, 5.13807349e-02f, -2.43374202e-02f, 8.79291166e-03f, 8.32162390e-04f, 8.01290572e-02f, -8.76010060e-02f, -5.54077104e-02f, 1.56164393e-02f,
  -7.05509540e-03f, 4.75405082e-02f, -7.83421844e-02f, 8.02034438e-02f, 5.89236766e-02f, -9.01240855e-03f, 4.68637682e-02f, -1.02928512e-01f, 6.15858585e-02f, -3.39110829e-02f,
  -8.81497711e-02f, -1.46702230e-02f, 1.02264240e-01f, 7.37244785e-02f, -2.54308782e-03f, -9.39499736e-02f, -4.54041548e-02f, -6.71508759e-02f, 2.79294290e-02f, 1.28822541e-02f,
  2.90926453e-02f, -7.36790001e-02f, -6.16444759e-02f, -9.10541266e-02f, -1.14646200e-02f, 7.25698918e-02f, -2.84626391e-02f, -3.75220925e-02f, 4.46137227e-02f, 7.83047751e-02f,
  -5.46057299e-02f, -3.44987214e-02f, -1.82249993e-02f, -6.40336573e-02f, -5.53939603e-02f, 7.71220773e-02f, 3.51270400e-02f, 4.75890301e-02f, 3.66784446e-02f, 4.69124652e-02f,
  1.02103585e-02f, 1.62142154e-03f, -3.23891677e-02f, 1.10266954e-01f, 1.48072690e-02f, 7.19190538e-02f, -2.78059654e-02f, 6.52530119e-02f, -8.81068967e-03f, 3.12113017e-02f,
  -5.61271273e-02f, -1.02002516e-01f, -8.98642987e-02f, 5.78887463e-02f, -1.22954078e-01f, -7.96537027e-02f, -5.47577552e-02f, -1.88326184e-03f, -1.48277834e-01f, -3.53559293e-02f,
  1.50921568e-02f, -2.11218372e-02f, 7.08740354e-02f, -3.57307531e-02f, -4.16132063e-02f, -5.47149293e-02f, -4.42408118e-03f, -4.57540061e-03f, -8.94277394e-02f, 6.68515861e-02f,
  -1.42296568e-01f, 6.78385049e-03f, -3.53068374e-02f, 6.63936883e-02f, -1.59564223e-02f, 5.41995130e-02f, -6.42673224e-02f, -4.52095382e-02f, 4.68431860e-02f, 7.42632970e-02f,
  3.60589586e-02f, 1.83319189e-02f, 3.06091085e-02f, 6.04752116e-02f, 2.34661549e-02f, -6.03288924e-03f, 1.43231116e-02f, -3.24106254e-02f, 2.96674594e-02f, 1.02828369e-01f,
  -4.27717082e-02f, -5.92751764e-02f, 5.59647568e-02f, -3.82810980e-02f, -1.90411210e-02f, -7.87348747e-02f, -1.88828446e-02f, 1.06755262e-02f, -9.15874466e-02f, 9.98921171e-02f,
  1.79838222e-02f, 2.59432606e-02f, -9.08967778e-02f, -5.05508222e-02f, -5.58564290e-02f, -1.89260915e-02f, -1.45350201e-02f, 5.43352552e-02f, -5.03594652e-02f, -2.65284218e-02f,
  -7.43423179e-02f, 4.40483866e-03f, -2.52998173e-02f, -8.02031010e-02f, -3.95245962e-02f, 1.47808716e-02f, -3.34643461e-02f, 1.84022505e-02f, -2.01670919e-02f, -5.60736060e-02f,
  3.08610220e-03f, -3.36573198e-02f, -1.26635563e-02f, 5.66549823e-02f, -5.51785193e-02f, -2.16354150e-02f, -9.53320712e-02f, 2.31886879e-02f, 8.44175741e-02f, 3.21322796e-03f,
  -5.16020358e-02f, -1.08892120e-01f, -7.30106756e-02f, 3.33706588e-02f, 8.93180594e-02f, 7.54583776e-02f, -2.05833535e-03f, -4.14119009e-03f, 4.06421199e-02f, 7.73313791e-02f,
  3.42054926e-02f, -3.10327876e-02f, 1.81293562e-02f, -4.53126580e-02f, -8.59984290e-03f, 5.57676004e-03f, 9.39225331e-02f, -2.82305852e-03f, 5.21281138e-02f, 1.95864029e-02f,
  4.35145125e-02f, 6.84086457e-02f, 5.46753220e-02f, 3.16861458e-02f, 5.63266799e-02f, -1.02240399e-01f, -6.47300631e-02f, -7.20472559e-02f, -9.55393091e-02f, 5.71673810e-02f,
  -2.12101415e-01f, -6.23664893e-02f, 6.16922155e-02f, 2.86756419e-02f, 2.07146946e-02f, 6.07920326e-02f, 8.44023153e-02f, -6.22489750e-02f, 4.86900136e-02f, 3.77479233e-02f,
  -2.53894385e-02f, -6.54445495e-03f, 1.00818887e-01f, 1.06732443e-01f, -3.81926447e-02f, 2.73634791e-02f, 9.70247164e-02f, -1.06134303e-01f, -8.92023966e-02f, 4.50641438e-02f,
  5.08104227e-02f, -9.21127722e-02f, -1.34490684e-01f, 3.89100686e-02f, -9.03378204e-02f, 3.03869098e-02f, -3.09436712e-02f, -4.82324064e-02f, -7.00072199e-02f, -9.40789841e-03f,
  6.53262362e-02f, 5.22901341e-02f, -2.24783123e-02f, -2.70684548e-02f, -5.03742658e-02f, -5.62948175e-03f, -2.37094797e-02f, -8.59366059e-02f, 4.49212231e-02f, -9.25451443e-02f,
  8.45500901e-02f, -3.08938008e-02f, 5.73795140e-02f, -8.04626197e-02f, -1.53142316e-02f, 1.16168559e-02f, -6.39174208e-02f, 5.85469864e-02f, 1.69721432e-02f, -5.73902056e-02f,
  5.44596203e-02f, -1.51969939e-02f, -1.09995358e-01f, -7.09561035e-02f, 3.22503373e-02f, 2.12736428e-02f, -2.91436519e-02f, 2.72976290e-02f, -4.21860814e-03f, -1.16832703e-01f,
  1.07627781e-02f, 8.41319710e-02f, 1.94648653e-02f, 6.14662562e-03f, -5.87307289e-03f, 1.45805290e-03f, -5.50602116e-02f, -7.46040931e-03f, -5.12352772e-02f, 3.63649949e-02f,
  7.37595558e-02f, -2.05370653e-02f, -9.13006961e-02f, 1.54702906e-02f, -4.08695079e-02f, -6.35295734e-02f, -3.48572135e-02f, -3.74738760e-02f, -1.00317791e-01f, -8.66055116e-02f,
  -8.20138231e-02f, 2.31400691e-02f, -7.15052933e-02f, -7.41301477e-03f, 7.85220936e-02f, -8.97646099e-02f, -8.60935077e-02f, 1.48090739e-02f, 1.59251988e-02f, -1.26801357e-02f,
  -5.08917831e-02f, -6.30989075e-02f, -9.06175673e-02f, 8.47632512e-02f, -8.43399465e-02f, -1.40190739e-02f, -8.74131098e-02f, -1.56954378e-02f, 1.67823490e-02f, -7.13484213e-02f,
  -6.20600991e-02f, -2.65353732e-02f, 1.56551749e-02f, 3.94961797e-02f, 2.56455690e-02f, -8.13482609e-03f, 6.90257475e-02f, 8.45219493e-02f, 1.64842904e-02f, -2.80015301e-02f,
  2.39366721e-02f, -4.50497344e-02f, -4.18623984e-02f, -3.99466380e-02f, 2.11674850e-02f, -9.26333591e-02f, 2.18251962e-02f, -6.47751316e-02f, 8.91202129e-03f, 2.91345082e-02f,
  -7.40122274e-02f, -3.84656303e-02f, -1.48292735e-01f, -1.58184357e-02f, -5.99004468e-03f, -1.56814352e-01f, -2.49188974e-01f, -4.14975137e-02f, 8.45709965e-02f, -5.12059731e-03f,
  -9.26100835e-02f, 1.12231478e-01f, 5.72951883e-02f, -1.34975184e-02f, -1.33310214e-01f, -2.46461764e-01f, -2.43316442e-01f, -8.03277865e-02f, -5.29059097e-02f, -9.77475420e-02f,
  -5.13757952e-02f, -2.11120211e-02f, -3.00537944e-02f, -5.61160408e-02f, 9.68224853e-02f, 1.89918298e-02f, -5.26347607e-02f, 1.96170304e-02f, -1.07629839e-02f, -5.77925006e-03f,
  -8.07809532e-02f, 2.73185186e-02f, -1.37859341e-02f, 3.42916287e-02f, 2.65020039e-02f, 3.38031389e-02f, -7.71736056e-02f, -4.86423448e-02f, 6.74467236e-02f, 1.14482641e-02f,
  -4.09734435e-02f, -7.32527003e-02f, 7.36357737e-03f, 3.10185067e-02f, -2.42515523e-02f, -7.65000358e-02f, -5.38198538e-02f, 4.48194370e-02f, 5.08381091e-02f, -6.21447526e-02f,
  -1.07107952e-01f, -1.28819734e-01f, -1.08013570e-01f, 1.25883585e-02f, 2.72188596e-02f, -3.86222303e-02f, 1.15805328e-01f, 6.80008158e-03f, -1.37542263e-02f, -5.93260862e-02f,
  -6.25875220e-02f, -6.88122511e-02f, 4.86376882e-02f, -3.24528255e-02f, 5.67881279e-02f, 8.69480520e-02f, 4.59931158e-02f, 6.34763166e-02f, -6.62908629e-02f, 2.67379228e-02f,
  6.46608546e-02f, 3.94951552e-02f, -9.49234143e-03f, 5.63148893e-02f, -4.36550193e-03f, 4.53235656e-02f, 1.53871132e-02f, -2.12420579e-02f, -1.25411386e-02f, 2.09110491e-02f,
  -5.81586361e-02f, 5.06275333e-03f, -1.89077724e-02f, 6.09838590e-02f, -3.13829370e-02f, -7.88930878e-02f, 8.55709687e-02f, 6.15414828e-02f, 3.94241735e-02f, -5.75942174e-02f,
  1.79152280e-01f, -1.85523666e-02f, -1.31566435e-01f, -9.28102434e-02f, 6.91628009e-02f, 3.61182801e-02f, 4.53230888e-02f, 1.99193954e-02f, -5.24841845e-02f, -1.04823433e-01f,
  -8.17741305e-02f, -1.06466766e-02f, 2.82467138e-02f, -9.42053273e-02f, -6.16671517e-03f, -8.24950263e-02f, 6.55395025e-03f, -2.52905972e-02f, -9.36864987e-02f, -4.31002527e-02f,
  -2.09864993e-02f, -1.09751076e-01f, -7.64062926e-02f, -2.16214284e-02f, 9.43152681e-02f, 1.47524914e-02f, 2.49907933e-02f, 7.24857897e-02f, -1.04430392e-01f, 4.18988019e-02f,
  -2.22122893e-02f, 3.52352113e-02f, -6.73935115e-02f, 1.19461775e-01f, -3.01858075e-02f, 2.21061427e-02f, -9.21583027e-02f, -3.35131995e-02f, 7.04217032e-02f, 3.37701216e-02f,
  -5.28376885e-02f, 3.58567610e-02f, 8.57689232e-02f, 3.55472006e-02f, -1.51726427e-02f, 2.74617057e-02f, 5.16014174e-02f, 7.73762017e-02f, -3.35322320e-02f, 3.67072187e-02f,
  -4.22262512e-02f, 5.31147160e-02f, 9.43217203e-02f, 6.85735047e-02f, 1.10996872e-01f, 1.42209819e-02f, 9.11833495e-02f, 2.60281339e-02f, -4.19375412e-02f, 9.72053856e-02f,
  1.60342947e-01f, -7.13753849e-02f, 5.15690632e-02f, -1.40556344e-03f, -6.10924363e-02f, -7.58963525e-02f, 1.04506966e-02f, -9.06478465e-02f, 6.02435432e-02f, 2.35868003e-02f,
  -2.33168378e-02f, 5.19422628e-02f, 5.76788783e-02f, -2.04746947e-02f, -3.84375304e-02f, 8.09360892e-02f, -4.71953936e-02f, -2.43431120e-03f, 2.78541241e-02f, -4.27464396e-02f,
  5.19033708e-02f, -7.53139704e-02f, 3.68627124e-02f, 1.54366309e-04f, 3.52075994e-02f, 7.82992467e-02f, 8.72053206e-02f, -5.51737472e-02f, -2.18827855e-02f, 9.31947455e-02f,
  -6.19639596e-03f, -7.16090053e-02f, 6.70102462e-02f, 4.70631570e-02f, -6.83619753e-02f, -5.97558394e-02f, -2.02349350e-02f, 4.27980721e-02f, -3.55755612e-02f, 2.57553607e-02f,
  -2.58575547e-02f, -2.68100612e-02f, 7.68859535e-02f, -1.40071828e-02f, 9.70270112e-03f, 4.50694654e-03f, 5.38534224e-02f, 1.42844412e-02f, -3.69189940e-02f, -1.50136724e-02f,
  -6.77557662e-02f, 1.64154861e-02f, 3.81824560e-02f, -6.46550730e-02f, -9.02192369e-02f, 8.10145512e-02f, -3.56629640e-02f, 7.01907203e-02f, 2.27978062e-02f, -1.88193042e-02f,
  -1.40277231e-02f, -5.19088842e-02f, 7.17179254e-02f, 2.29075197e-02f, 2.95521095e-02f, -4.43371609e-02f, 4.35176380e-02f, 6.82919519e-03f, -1.11475706e-01f, 4.53752875e-02f,
  6.01317808e-02f, 3.59559916e-02f, -9.49333012e-02f, -6.00328371e-02f, -5.51312929e-03f, -3.05383597e-02f, 1.72658432e-02f, -3.09907328e-02f, -6.90305009e-02f, -8.94449186e-04f,
  5.54160364e-02f, -8.54193345e-02f, 2.66647693e-02f, -9.50343609e-02f, -3.37849818e-02f, -8.31454545e-02f, -8.44758451e-02f, 7.47459829e-02f, 6.76536337e-02f, -3.62745747e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.08684926e-02f, -5.63292764e-02f, 9.50614512e-02f, -4.57913838e-02f, 2.73573063e-02f, 7.90306106e-02f, 8.20159316e-02f, 4.34939638e-02f, 9.09253284e-02f, -5.22826836e-02f,
  1.26103416e-01f, -2.95728110e-02f, 1.30400106e-01f, 2.46303044e-02f, 7.74561008e-03f, 3.69142853e-02f, -2.78321505e-02f, 5.70950210e-02f, 1.18084662e-01f, 1.17913559e-01f,
  1.74839273e-01f, -5.91101162e-02f, -9.32041183e-03f, -5.96845374e-02f, 1.10321894e-01f, -2.54755542e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  4.33464237e-02f, 7.79604092e-02f, 3.46515514e-02f, -2.42276732e-02f, -1.50445076e-02f, 7.96065405e-02f, -7.10140839e-02f, -1.28126800e-01f, 1.06946453e-01f, -6.96693808e-02f,
  -6.54253364e-02f, -3.55692357e-02f, -5.82393818e-02f, 3.55268717e-02f, 1.00480072e-01f, 7.02387393e-02f, -7.61213675e-02f, 2.15300154e-02f, 7.77019039e-02f, 2.91529344e-03f,
  1.31548539e-01f, 3.96141894e-02f, 1.49789704e-02f, 5.56577370e-02f, -6.20082580e-02f, -7.18858615e-02f, 8.77218470e-02f, -1.04808167e-01f, 1.88134946e-02f, 1.58753261e-01f,
  7.12024942e-02f, -7.01413974e-02f, 8.23889300e-02f, -1.14376331e-03f, -3.13359350e-02f, 7.00412830e-03f, -1.04742631e-01f, 2.98377723e-02f, 2.89051905e-02f, -6.91381991e-02f,
  -8.95508826e-02f, -6.80449083e-02f, -2.40082461e-02f, -1.14891477e-01f, 6.14059120e-02f, 1.22246044e-02f, -2.82786880e-02f, -6.22639023e-02f, -1.12720579e-01f, 9.56807956e-02f,
  2.43663546e-02f, -6.75837994e-02f, -1.43290553e-02f, -1.81764103e-02f, -1.74923558e-02f, 2.43282598e-02f, 1.71917036e-01f, -4.64756042e-03f, -4.89458302e-03f, 1.89904675e-01f,
  -1.32664964e-01f, 1.36116892e-01f, -1.97673485e-01f, 4.39786948e-02f, -1.06131554e-01f, 8.86558071e-02f, 7.09619597e-02f, 3.20255719e-02f, -7.50069916e-02f, -2.84792706e-02f,
  6.75013929e-04f, -1.82146002e-02f, 5.55937761e-04f, -3.92723195e-02f, 4.89317067e-03f, 7.81680197e-02f, 1.39760807e-01f, -2.93088127e-02f, 7.78947100e-02f, 1.06017679e-01f,
  -1.27118528e-01f, -9.70660746e-02f, -3.43999378e-02f, 1.39534354e-01f, 3.54008116e-02f, -1.14076696e-01f, -8.51030275e-02f, 4.30360585e-02f, -2.93500483e-01f, 8.56862143e-02f,
  8.16710815e-02f, -1.75824091e-01f, -5.63242920e-02f, 2.37211883e-02f, 6.74185976e-02f, 2.98481248e-02f, -7.12827072e-02f, 1.62156463e-01f, -6.90002218e-02f, -2.78842241e-01f,
  6.71772659e-02f, 4.12228368e-02f, -1.26045555e-01f, 9.56751592e-03f, -2.84860972e-02f, 5.52117191e-02f, -3.09037250e-02f, 8.38426948e-02f, -4.87466566e-02f, 4.00996841e-02f,
  -7.12610409e-03f, -4.30057198e-02f, -7.48990178e-02f, 1.30707875e-01f, 8.52685198e-02f, 4.73274700e-02f, -5.08969203e-02f, 1.65452976e-02f, -3.67017314e-02f, -3.72834429e-02f,
  6.20929897e-02f, 3.52494456e-02f, 3.16915922e-02f, 3.97221260e-02f, 1.09463654e-01f, -1.24379538e-01f, -1.99458506e-02f, -2.14099064e-02f, -7.49442428e-02f, 3.45773138e-02f,
  9.23604593e-02f, 3.73014249e-02f, -2.19553113e-02f, -6.14756495e-02f, -5.88114783e-02f, -1.11090630e-01f, 1.09001882e-01f, 1.04810037e-01f, 1.12098292e-01f, 1.22046851e-01f,
  9.87964347e-02f, -8.78143236e-02f, 1.10727765e-01f, -1.49865933e-02f, -3.28064077e-02f, 7.62269553e-03f, -9.74396542e-02f, -3.89269069e-02f, 5.39489947e-02f, 4.59264144e-02f,
  2.07474865e-02f, -3.30636092e-02f, 1.05736025e-01f, -3.67804319e-02f, 7.30612203e-02f, 1.04012899e-03f, 8.81946608e-02f, 3.82144861e-02f, 6.60458654e-02f, -7.30703473e-02f,
  -9.50002372e-02f, -9.07132328e-02f, -5.73165379e-02f, 8.90868381e-02f, 9.03940275e-02f, 8.17213655e-02f, -9.76159573e-02f, 5.03943302e-02f, -8.23262855e-02f, 8.35169181e-02f,
  -6.54711435e-03f, -9.44337398e-02f, 2.79070600e-03f, 6.27766550e-02f, -8.75469521e-02f, -7.30819032e-02f, 6.81153238e-02f, -3.81305739e-02f, -1.53834065e-02f, -1.41031057e-01f,
  -2.64459755e-02f, -1.08013162e-02f, 1.48768589e-01f, 6.18501231e-02f, -1.09719753e-01f, -1.52786657e-01f, -2.26876996e-02f, 2.86706723e-02f, 1.55458329e-02f, 3.08902320e-02f,
  4.78271395e-02f, 1.60915777e-02f, 8.77767429e-02f, 8.44619498e-02f, -1.42990174e-02f, 1.22581162e-02f, -1.03337161e-01f, 4.87253144e-02f, -1.16760895e-01f, 1.62002414e-01f,
  -6.30530668e-03f, -5.75407334e-02f, 1.41082108e-02f, 1.05056532e-01f, -7.36593157e-02f, -7.33068734e-02f, -3.79314423e-02f, 5.69606535e-02f, -8.58947858e-02f, -1.12830050e-01f,
  2.91714985e-02f, -8.78385603e-02f, -2.49348991e-02f, -5.04851826e-02f, 8.79991204e-02f, -6.04058132e-02f, 2.13075191e-01f, -4.49278727e-02f, -6.47059875e-03f, -9.41600278e-03f,
  2.30061207e-02f, -9.52635333e-02f, 1.11464635e-01f, 1.63501844e-01f, 6.45394772e-02f, 4.22391668e-03f, -1.36682704e-01f, 5.74901663e-02f, 4.16778177e-02f, -5.27822338e-02f,
  7.33360276e-02f, -2.29460150e-02f, -2.46002525e-02f, 4.82151993e-02f, 2.18839590e-02f, -1.44606501e-01f, 1.35777384e-01f, -7.53941163e-02f, -6.25674799e-02f, 5.70060983e-02f,
  -1.43072149e-02f, 7.91710019e-02f, 1.16716765e-01f, 5.16257472e-02f, 7.28669285e-04f, 7.90550485e-02f, -5.29684052e-02f, 1.29774548e-02f, -9.88053903e-02f, -8.42754170e-02f,
  -2.18580127e-01f, 6.69029355e-02f, 1.62540451e-02f, 9.44536179e-03f, -5.27871475e-02f, 7.27175400e-02f, 6.89511597e-02f, 4.30199951e-02f, -9.58844572e-02f, -6.43361956e-02f,
  -1.32206930e-02f, 2.36816648e-02f, -2.65082233e-02f, -1.04564004e-01f, -2.82090101e-02f, 5.30388542e-02f, -1.17164694e-01f, 3.50410193e-02f, 1.59708466e-02f, -8.78265500e-02f,
  -2.32977457e-02f, 6.11361898e-02f, -7.83368275e-02f, 4.57414007e-03f, -4.37139310e-02f, -1.97918694e-02f, 1.29264891e-02f, 6.99676797e-02f, 8.81480332e-03f, -4.34511863e-02f,
  6.28723651e-02f, 3.01708542e-02f, -2.15154700e-02f, -2.90253805e-03f, -1.57452188e-02f, 3.19313146e-02f, 8.57444331e-02f, -1.09342812e-02f, 6.56257197e-02f, 7.81564415e-02f,
  4.37231548e-02f, 6.87426329e-03f, 2.74331290e-02f, -2.58640572e-02f, -8.64630193e-02f, -1.00477777e-01f, 4.07324135e-02f, 4.27110791e-02f, -1.03962407e-01f, -4.84513976e-02f,
  -4.31094095e-02f, -5.69422208e-02f, 1.18226819e-02f, 2.50885426e-03f, 3.58123407e-02f, 2.54887491e-02f, -2.29566991e-02f, 1.25628799e-01f, 1.28253266e-01f, 8.93095508e-02f,
  1.15708649e-01f, 5.28847463e-02f, -3.59790958e-02f, 6.51255846e-02f, -5.84114296e-03f, -5.89522207e-03f, -3.41541134e-02f, -5.49596623e-02f, -1.16901122e-01f, 2.73112915e-02f,
  -3.66442241e-02f, 8.49397555e-02f, -3.03434357e-02f, -7.89457560e-02f, -9.35852230e-02f, -3.28248106e-02f, -9.30679590e-02f, -7.52852410e-02f, -1.51111081e-01f, 3.50302681e-02f,
  -1.92357630e-01f, -4.64475453e-02f, 1.16471447e-01f, -4.16002348e-02f, -1.43250972e-01f, -7.04209432e-02f, 2.46198997e-02f, -1.51126921e-01f, 2.16590129e-02f, 7.43974000e-02f,
  -6.14101551e-02f, -1.07240751e-01f, -1.21870302e-01f, -1.33674204e-01f, 6.50575757e-02f, 6.81180432e-02f, -1.98745225e-02f, -7.56765803e-05f, -1.81986429e-02f, -1.01221658e-01f,
  -1.06279468e-02f, 3.07683479e-02f, -5.83005100e-02f, 2.89817639e-02f, -8.37973319e-04f, 3.11193578e-02f, 7.43312836e-02f, -6.23447672e-02f, 4.12730128e-02f, -2.99944840e-02f,
  -1.32339187e-02f, -1.04007557e-01f, 7.36690359e-03f, 5.53058721e-02f, 1.11649446e-01f, 3.10068484e-02f, 9.68761146e-02f, -1.06793465e-02f, -2.54162531e-02f, 8.32619518e-02f,
  1.46578640e-01f, 8.56099799e-02f, 2.24861521e-02f, -8.55375361e-03f, -1.00376688e-01f, 3.55394259e-02f, -8.64857733e-02f, -1.10891931e-01f, -1.35476515e-01f, -2.22981293e-02f,
  -1.58189312e-02f, -3.07076145e-02f, -6.61319308e-03f, 4.18468341e-02f, 3.33967656e-02f, 3.77250947e-02f, -1.20257728e-01f, 6.92995964e-03f, -6.42941743e-02f, 1.08405232e-01f,
  4.04718965e-02f, 1.54813483e-01f, -8.35695639e-02f, -6.00019246e-02f, 4.34028469e-02f, 9.85459909e-02f, 4.09397949e-03f, 1.12231374e-01f, -5.27528487e-03f, 3.75129245e-02f,
  7.07984269e-02f, -2.29081046e-02f, 1.06777713e-01f, 1.08760148e-01f, -6.03318699e-02f, -2.01629568e-02f, 1.29395097e-01f, 9.69103426e-02f, -8.39289650e-02f, 1.21307842e-01f,
  -3.06810047e-02f, 1.51991755e-01f, -5.12129329e-02f, -5.98384514e-02f, 4.80458364e-02f, 1.01173319e-01f, 1.57623794e-02f, 6.58296049e-02f, 1.60229001e-02f, -2.19997223e-02f,
  4.36726138e-02f, 2.52597351e-02f, 4.35550790e-03f, 1.07880861e-01f, 5.49179055e-02f, -1.73457656e-02f, 1.67035498e-02f, -5.38570620e-02f, -8.91184062e-03f, -6.98770732e-02f,
  4.85535599e-02f, 1.93135571e-02f, 1.34866416e-01f, 6.39605243e-03f, 1.81562170e-01f, 1.46370173e-01f, -1.07693724e-01f, -2.26529501e-03f, -1.06063254e-01f, 1.19493432e-01f,
  2.82132830e-02f, 1.94122002e-01f, 1.43240675e-01f, 1.00420482e-01f, -6.00515865e-02f, -3.85133661e-02f, -4.55252454e-02f, -1.72751084e-01f, -7.91590884e-02f, 1.05881862e-01f,
  9.81216431e-02f, 8.82593691e-02f, -2.55410485e-02f, 1.22660084e-03f, -5.35475798e-02f, 4.85353991e-02f, -1.70424227e-02f, -6.53351322e-02f, 1.19407952e-01f, -1.82501189e-02f,
  6.10267371e-02f, -1.63059175e-01f, 5.38566858e-02f, 7.24388361e-02f, -8.14851820e-02f, 2.74192300e-02f, 8.01112503e-02f, -1.84757542e-02f, 1.06766455e-01f, 1.07494138e-01f,
  1.33860528e-01f, 6.81596771e-02f, -2.21101828e-02f, -1.77129492e-01f, 1.23525098e-01f, 1.73090417e-02f, -2.33153664e-02f, 1.65528223e-01f, 4.70534340e-02f, -7.11052567e-02f,
  1.57928932e-03f, -6.48753121e-02f, -4.28946503e-02f, 2.03295834e-02f, -2.27859449e-02f, 2.71499064e-02f, -1.57451347e-01f, 7.28217186e-03f, -7.22300410e-02f, -8.50692838e-02f,
  -4.11189906e-02f, 9.63203609e-02f, -1.44795924e-01f, -5.87752648e-02f, -7.92839304e-02f, 3.24182026e-02f, -6.78318813e-02f, 7.56621882e-02f, -4.80519831e-02f, -7.01393411e-02f,
  -1.00810789e-01f, 1.50539298e-02f, 1.02210334e-02f, 1.38380840e-01f, 1.07989140e-01f, -2.31317361e-03f, 1.72607917e-02f, -4.89173643e-03f, -3.25935334e-02f, -2.66260616e-02f,
  -9.85088199e-02f, 7.25240111e-02f, 3.12642045e-02f, -2.15967372e-02f, -3.66491899e-02f, -2.90147290e-02f, 7.30426908e-02f, -1.52866798e-03f, -6.11298112e-03f, -8.78346637e-02f,
  2.45680213e-02f, -3.01761907e-02f, 8.37054290e-03f, 8.28399509e-02f, 2.15994660e-02f, -4.26932983e-03f, 3.82861570e-02f, 1.28473109e-02f, -5.41180000e-02f, 6.29122090e-03f,
  4.95023727e-02f, -1.56615712e-02f, 5.98029904e-02f, 2.23718472e-02f, -3.17593552e-02f, 9.48476270e-02f, -2.17673890e-02f, 1.10749304e-01f, 1.00771867e-01f, -4.98240143e-02f,
  -1.46688551e-01f, 6.03152700e-02f, -1.79584175e-02f, 1.67877510e-01f, 1.32607073e-01f, 8.45866352e-02f, 1.93828177e-02f, -1.91345643e-02f, 4.76622880e-02f, 9.85810012e-02f,
  1.68578830e-02f, -9.79013965e-02f, 5.82001135e-02f, 8.36237371e-02f, -7.19817504e-02f, 7.43074203e-03f, -3.81896719e-02f, 1.15858778e-01f, 8.81641731e-02f, -1.14147747e-02f,
  1.65122688e-01f, -1.07234269e-02f, -5.66540146e-03f, -1.42162293e-01f, -5.21159433e-02f, -9.61045735e-03f, 9.90852118e-02f, -1.00932345e-02f, -6.46332605e-03f, 2.13289797e-01f,
  -9.95120630e-02f, -4.10912372e-02f, 2.11418509e-01f, -1.19461700e-01f, 8.60027894e-02f, -3.60406935e-02f, -1.25758678e-01f, -9.28163528e-02f, -9.20336414e-03f, 7.00400919e-02f,
  -1.49835795e-01f, 9.16606002e-03f, -1.42762288e-01f, 3.61715741e-02f, -8.89304504e-02f, 6.62447661e-02f, -1.88580230e-01f, 8.97643939e-02f, 1.56554836e-03f, 1.14574268e-01f,
  -1.05711386e-01f, -3.58070545e-02f, 1.28007829e-01f, 1.08727708e-01f, 5.04862294e-02f, -4.62727509e-02f, -2.88463235e-01f, 9.76179913e-02f, 2.00267006e-02f, -1.02887191e-01f,
  1.46641806e-01f, -3.69519964e-02f, -9.52559635e-02f, 8.80371556e-02f, 2.52419710e-01f, 2.40450893e-02f, 8.35331604e-02f, 1.35350347e-01f, 9.17802900e-02f, 2.43714591e-03f,
  1.36431903e-01f, 1.62021875e-01f, -3.05494536e-02f, 7.94368889e-03f, 3.56655009e-02f, -7.59021044e-02f, -5.87220956e-03f, -1.11965187e-01f, -3.02517544e-02f, 1.87068339e-02f,
  -2.23116130e-02f, 4.60117497e-02f, -2.32419148e-02f, 7.27260709e-02f, 1.07624203e-01f, -1.32461652e-01f, 2.19605304e-02f, -3.58337983e-02f, 3.47570404e-02f, 5.13669401e-02f,
  7.60448575e-02f, 8.65333155e-02f, 1.61604896e-01f, -4.76401523e-02f, -1.37206316e-01f, -1.01131156e-01f, -8.47283378e-02f, 1.95289217e-02f, 8.56788307e-02f, -7.47351423e-02f,
  -3.78838442e-02f, 7.75461271e-03f, 5.52955158e-02f, -2.74346359e-02f, -1.07137747e-02f, 2.27125492e-02f, -8.39912072e-02f, 7.63299018e-02f, 1.08294301e-02f, 7.55741522e-02f,
  -1.21862674e-02f, 9.55928862e-02f, -9.77477357e-02f, 8.85681883e-02f, 4.20685969e-02f, 5.75879849e-02f, 2.76887156e-02f, 3.83507423e-02f, 5.40821999e-02f, 3.28490548e-02f,
  6.49946332e-02f, -1.31816305e-02f, -2.59091631e-02f, -3.54601517e-02f, -5.99079132e-02f, 5.54109104e-02f, -3.35006006e-02f, -2.46544811e-03f, 9.04564634e-02f, -4.62476313e-02f,
  6.69280291e-02f, -5.39520718e-02f, 2.79014707e-02f, -7.87143931e-02f, -2.96334196e-02f, 1.18337058e-01f, -5.54399751e-02f, 5.54565266e-02f, -3.59851532e-02f, 7.95562491e-02f,
  6.67551383e-02f, -2.55943858e-03f, 6.75674900e-02f, -8.47923309e-02f, -3.11174132e-02f, 4.51206602e-02f, -2.70045605e-02f, -2.76532713e-02f, 4.58479859e-02f, 7.61200041e-02f,
  1.05832696e-01f, 2.46603303e-02f, -3.70949833e-03f, -1.47648677e-02f, 2.43914826e-03f, 4.47095558e-02f, 6.06362559e-02f, 1.29272550e-01f, 5.06105386e-02f, 1.37333170e-01f,
  -6.52490929e-02f, 5.85694984e-02f, -1.24281138e-01f, -3.12737077e-02f, 4.23985310e-02f, -2.75668688e-02f, -3.35498378e-02f, 2.40976978e-02f, 5.12264557e-02f, 8.55265930e-02f,
  4.03105579e-02f, 5.92458770e-02f, -4.85202074e-02f, -1.47637814e-01f, -1.22220516e-02f, -1.18112542e-01f, 9.05525610e-02f, -8.18534940e-02f, 1.28665030e-01f, -9.24683525e-04f,
  2.95858011e-02f, 7.62735233e-02f, -2.67277248e-02f, -7.60188885e-03f, 1.00611046e-01f, 1.30817881e-02f, 6.97546825e-02f, 5.47425449e-02f, -1.85838699e-01f, -9.09335166e-02f,
  -3.09121534e-02f, 3.06701604e-02f, -2.77409684e-02f, 8.97179022e-02f, 5.72415553e-02f, -1.07226878e-01f, 3.82944457e-02f, -8.55010096e-03f, -2.73711011e-02f, -8.13733637e-02f,
  6.98946118e-02f, 4.22607735e-02f, -1.28411949e-01f, 1.83108654e-02f, -8.86119530e-02f, 8.09192434e-02f, 6.06959052e-02f, -2.56515685e-02f, -9.97230560e-02f, -1.03414953e-02f,
  2.53712889e-02f, 2.00248081e-02f, 2.10719183e-02f, 7.87701383e-02f, -5.35186790e-02f, 7.71998391e-02f, 3.91771160e-02f, 4.42483835e-02f, 1.23489067e-01f, 1.01905853e-01f,
  1.42188832e-01f, 3.03659830e-02f, -3.46544641e-03f, 5.98271899e-02f, -3.08257923e-03f, -1.24875531e-01f, 2.67680846e-02f, -3.81985940e-02f, -5.04970066e-02f, -2.03867909e-02f,
  -8.64802022e-03f, 1.59030426e-02f, -7.63872862e-02f, 2.61820927e-02f, -3.84683115e-03f, 8.84385407e-03f, 6.99481666e-02f, 6.13267273e-02f, 7.70469084e-02f, 4.81867939e-02f,
  -3.57952341e-02f, 5.70776165e-02f, -3.53406370e-03f, 3.67967337e-02f, 6.77933395e-02f, 3.72459665e-02f, -4.95625138e-02f, -4.02512550e-02f, 1.47421546e-02f, -5.13311923e-02f,
  7.33654127e-02f, 1.56261213e-02f, -1.05012186e-01f, 1.30969435e-01f, 7.88010508e-02f, -3.08559509e-04f, -2.14527044e-02f, 9.31791589e-03f, -4.05654274e-02f, -5.67777306e-02f,
  2.78082043e-02f, -7.20345378e-02f, 6.50849715e-02f, 5.02762534e-02f, -3.65331136e-02f, 4.57356870e-02f, -6.60337061e-02f, -5.45130968e-02f, -3.10541913e-02f, -1.68141872e-02f,
  6.51374161e-02f, -2.09568680e-04f, 3.82107012e-02f, -7.48450458e-02f, -2.53813323e-02f, -6.25502765e-02f, -2.21854150e-02f, 1.06141515e-01f, 1.36190295e-01f, 8.68321061e-02f,
  -8.59339163e-02f, -2.09263369e-01f, -7.00741336e-02f, -1.13628998e-01f, 5.45380935e-02f, 4.28182110e-02f, 1.95955977e-01f, -1.16595505e-02f, -5.29518388e-02f, -1.38240993e-01f,
  6.80050552e-02f, -1.58338584e-02f, -2.91232821e-02f, -1.66191533e-01f, 5.05502224e-02f, 9.82239563e-03f, 1.72298744e-01f, -5.68006337e-02f, 1.78176254e-01f, 1.68719187e-01f,
  1.13342395e-02f, -1.66012477e-02f, 2.47720361e-01f, 5.03791794e-02f, -1.08248040e-01f, 3.58777903e-02f, 2.41033539e-01f, 4.47515063e-02f, 1.55485496e-01f, 1.44949734e-01f,
  -6.16747402e-02f, -3.44334729e-02f, 2.40994498e-01f, 6.70370683e-02f, 2.14958712e-01f, 2.27243513e-01f, -1.35204280e-02f, -2.57079042e-02f, 1.25237450e-01f, 4.26823311e-02f,
  1.24463961e-01f, 6.43475950e-02f, -1.14571944e-01f, -1.10360477e-02f, -6.61840662e-02f, 9.47491545e-03f, 3.00028976e-02f, 5.71635477e-02f, -2.20819768e-02f, 6.60279915e-02f,
  -8.56537074e-02f, -7.65976831e-02f, 5.46908304e-02f, -4.98384982e-02f, 6.29734620e-02f, 8.24717507e-02f, -9.56647992e-02f, -3.89672108e-02f, -5.23125492e-02f, -4.23803106e-02f,
  5.70703484e-02f, 6.46713376e-02f, -1.63304538e-01f, -7.41348714e-02f, -1.20270558e-01f, 6.20670468e-02f, 8.44632611e-02f, -8.78490880e-03f, 1.01698607e-01f, 2.63629202e-02f,
  1.94475293e-01f, -1.72923841e-02f, -4.39702906e-02f, -7.87549987e-02f, -1.13924481e-01f, 6.54236898e-02f, -1.40102115e-02f, 6.87343115e-03f, 1.10346235e-01f, 5.15034944e-02f,
  3.88907604e-02f, 2.22848430e-02f, -1.86477620e-02f, -3.11633665e-02f, 1.18034929e-01f, 4.71547283e-02f, -5.08729229e-03f, 1.28088683e-01f, 7.34475022e-03f, 9.64818615e-03f,
  -3.59979011e-02f, -2.45667323e-02f, -1.84082938e-03f, -9.85629931e-02f, -3.15830857e-03f, -1.00888476e-01f, 7.97472801e-03f, 5.80807216e-02f, 4.13851207e-03f, -4.77299765e-02f,
  -1.23531101e-02f, -1.56187313e-02f, -2.55501065e-02f, -2.06286050e-02f, 6.62594289e-02f, 8.51907581e-02f, 7.38234445e-02f, -8.93584713e-02f, -6.55379817e-02f, 3.51673625e-02f,
  -5.32629862e-02f, -7.79569289e-03f, 4.31273803e-02f, -3.30903791e-02f, 4.79773358e-02f, 7.76911750e-02f, 3.16852257e-02f, -1.83002595e-02f, -6.72035143e-02f, -9.43491086e-02f,
  1.10322647e-01f, -8.08552653e-02f, -2.18865578e-03f, -2.10017543e-02f, -7.45145380e-02f, 7.48448968e-02f, 9.92906764e-02f, 6.31731823e-02f, -1.61737978e-01f, -5.32633886e-02f,
  1.01745939e-02f, -1.12247124e-01f, 1.32385328e-01f, -7.36700445e-02f, -1.47223603e-02f, 2.22615302e-01f, -1.91403702e-01f, 9.92464949e-04f, 3.07739060e-02f, 6.58459216e-02f,
  -1.05578236e-01f, -7.47841317e-03f, -7.55140930e-03f, 4.84566167e-02f, 1.97425034e-04f, 4.33074869e-02f, -1.08529761e-01f, 9.39875916e-02f, 8.86669382e-02f, -3.11137270e-02f,
  -2.99946666e-02f, -5.93261570e-02f, 1.27632618e-01f, 6.20986745e-02f, 3.52576301e-02f, 1.64362401e-01f, -2.84793787e-02f, 5.27861230e-02f, 3.47504392e-02f, -3.42850876e-03f,
  6.18294962e-02f, -6.61597326e-02f, -3.89562808e-02f, 1.98342651e-02f, -2.35053390e-01f, 5.40577136e-02f, 5.39474748e-02f, 4.52399477e-02f, -1.67771488e-01f, 9.05942991e-02f,
  1.41106054e-01f, -2.89732143e-02f, 9.15607810e-03f, 8.93845856e-02f, -4.09582108e-02f, -1.40584737e-01f, 1.51387051e-01f, -9.02835429e-02f, -5.83166443e-02f, 2.62407884e-02f,
  -2.51736399e-02f, 9.42047760e-02f, -4.82559837e-02f, 2.92051975e-02f, -9.76302549e-02f, -2.86359005e-02f, -2.77501903e-02f, 2.13893671e-02f, -1.20994575e-01f, 3.95043641e-02f,
  -7.14880824e-02f, -1.40663618e-02f, 1.17928889e-02f, -6.52533621e-02f, 4.61246781e-02f, 2.93862633e-02f, 1.13211073e-01f, 1.87844597e-02f, 3.58630307e-02f, 6.05614670e-03f,
  3.90222408e-02f, -1.45865930e-02f, 5.61185405e-02f, -9.73493382e-02f, 1.18356245e-02f, -6.03133179e-02f, 6.08904362e-02f, 7.07686841e-02f, 6.80316612e-02f, 6.60936311e-02f,
  5.09225726e-02f, 4.05485108e-02f, 7.00878203e-02f, 2.77345558e-03f, 7.02264486e-03f, -3.53925750e-02f, -3.10776588e-02f, -3.60605828e-02f, 5.35598807e-02f, 6.64332360e-02f,
  3.32767591e-02f, 3.20078284e-02f, -2.43770611e-02f, 1.95883717e-02f, 5.60056195e-02f, 2.56273728e-02f, 1.09945610e-01f, 4.87371385e-02f, -3.82125042e-02f, 3.28612216e-02f,
  -4.38667983e-02f, -9.24015939e-02f, -5.15010059e-02f, 1.22004254e-02f, -9.65616629e-02f, 5.49990162e-02f, 9.72362515e-03f, 2.00226512e-02f, -5.35111465e-02f, 3.36466916e-02f,
  7.03067183e-02f, -2.62732129e-03f, 1.08458139e-01f, 5.91822201e-03f, -9.61226895e-02f, -3.64037305e-02f, -3.71846184e-02f, -8.95516761e-03f, -5.95489554e-02f, 7.70065635e-02f,
  8.53109211e-02f, 3.97731848e-02f, 2.55418755e-02f, 4.45956439e-02f, -8.88569579e-02f, 5.48827229e-03f, -2.79892534e-02f, 1.60335049e-01f, -3.63384597e-02f, 5.05577847e-02f,
  1.57396078e-01f, 3.44273783e-02f, -1.20941482e-01f, 5.72819542e-03f, -1.12210467e-01f, 8.22408125e-02f, -2.19441265e-01f, 2.12185189e-01f, -1.30601242e-01f, 1.99482813e-01f,
  -1.03508243e-02f, 1.07142357e-02f, 1.37950294e-03f, -7.17369244e-02f, -2.05223393e-02f, -2.73003936e-01f, 2.85401964e-03f, 2.74272766e-02f, -8.13807100e-02f, -8.97860453e-02f,
  1.38171405e-01f, 7.94838276e-03f, -2.78624762e-02f, -9.60368365e-02f, -1.43012896e-01f, -1.25840202e-01f, 1.79392211e-02f, 8.01850781e-02f, -8.36208835e-02f, -3.19197425e-03f,
  -1.55677035e-01f, -1.24718413e-01f, -9.00613070e-02f, 3.00286449e-02f, -7.81925470e-02f, 1.88055094e-02f, -5.66226281e-02f, 4.67576459e-02f, -6.88858842e-03f, -7.98536018e-02f,
  -4.68840171e-03f, 3.58177200e-02f, 6.94052204e-02f, -2.52825648e-01f, 9.17117447e-02f, -2.09647585e-02f, 4.90091704e-02f, -7.96304271e-02f, -2.93359514e-02f, -8.20398852e-02f,
  -7.70275816e-02f, -3.54668847e-03f, -4.05605063e-02f, 7.84262046e-02f, 6.10832917e-03f, -1.62274670e-03f, -1.08660996e-01f, 2.29645632e-02f, -1.64877903e-02f, -2.36331299e-02f,
  -1.18316943e-02f, -7.99143463e-02f, 3.24086472e-02f, 2.14009713e-02f, -1.26001894e-01f, -3.95637080e-02f, -6.16787337e-02f, -1.45383850e-02f, -6.37903959e-02f, -2.61853938e-03f,
  1.53186738e-01f, -4.00348380e-02f, -3.47609743e-02f, 3.90940830e-02f, -4.35083658e-02f, -3.27679068e-02f, 8.92683640e-02f, 4.68899384e-02f, -4.67267707e-02f, -1.04712080e-02f,
  -3.14435177e-02f, 3.19749713e-02f, -4.11450043e-02f, 4.87953164e-02f, 4.78918627e-02f, -1.93260461e-02f, -3.70405950e-02f, 2.94125713e-02f, 9.69659910e-03f, -1.32923484e-01f,
  -1.86037533e-02f, -7.90463313e-02f, 3.16389948e-02f, -6.81040064e-02f, -5.70888110e-02f, -3.21370065e-02f, 9.40947682e-02f, 4.37399931e-03f, 9.37282220e-02f, -1.40222916e-02f,
  5.16170077e-03f, 2.21335236e-02f, 9.66931507e-02f, 8.29105601e-02f, -2.38751415e-02f, 2.13001445e-02f, -6.69639483e-02f, 1.23868480e-01f, -7.86021948e-02f, 1.18256971e-01f,
  -1.51238581e-02f, -9.93330684e-03f, 7.52208456e-02f, 8.08730572e-02f, -5.71219102e-02f, 1.85744930e-02f, 1.49043605e-01f, -7.73629472e-02f, 3.00448146e-02f, -7.55710751e-02f,
  6.32786378e-02f, 2.88094636e-02f, -9.47099831e-03f, 1.36158783e-02f, -9.06099081e-02f, -3.13562602e-02f, -3.22058983e-02f, -1.03554450e-01f, -5.26748560e-02f, 3.82393897e-02f,
  -7.84525871e-02f, 7.02441782e-02f, -1.42642125e-01f, -2.67610373e-03f, -7.48324171e-02f, 3.74539234e-02f, -1.16668448e-01f, 1.43716754e-02f, -9.59158838e-02f, -6.41092658e-02f,
  -2.76331063e-02f, -8.42972696e-02f, -4.70521189e-02f, -6.74268976e-02f, 7.89377913e-02f, 3.98811363e-02f, -1.06688486e-02f, -1.50304154e-01f, 1.64476499e-01f, -5.73757440e-02f,
  -2.11657122e-01f, -1.42378047e-01f, 4.38900553e-02f, -3.85344215e-02f, 1.54137090e-01f, -2.56481282e-02f, 1.01989433e-01f, 3.41474898e-02f, -1.97923645e-01f, -1.68124408e-01f,
  -1.24409385e-01f, 1.00700893e-01f, -2.46372335e-02f, 9.27851573e-02f, -7.60466680e-02f, -1.02630854e-01f, 3.32419798e-02f, -6.78758174e-02f, 1.65659916e-02f, 1.01511240e-01f,
  1.21312469e-01f, -1.06310971e-01f, -5.29758520e-02f, -1.74312443e-01f, 1.11282021e-01f, 1.00557394e-01f, -4.70852153e-03f, -6.68726489e-02f, 6.06423914e-02f, -9.74517390e-02f,
  7.45095536e-02f, -6.51194677e-02f, 1.78129263e-02f, -7.70524442e-02f, -2.91495435e-02f, -5.38268983e-02f, -3.25157121e-02f, 7.42871165e-02f, -9.54895988e-02f, 5.84356003e-02f,
  1.10683434e-01f, 6.82135522e-02f, -1.88179929e-02f, -1.34968758e-02f, 1.61373392e-02f, -1.07364431e-01f, 8.18723291e-02f, 4.02251780e-02f, 1.52775899e-01f, -9.77951810e-02f,
  -7.95851946e-02f, -2.17724759e-02f, -1.28848553e-01f, -4.31830138e-02f, 3.92511971e-02f, 1.13242932e-01f, -6.37772679e-02f, 1.16087280e-01f, -1.45054106e-02f, 6.31065369e-02f,
  3.95222306e-02f, 6.96172342e-02f, 1.22220024e-01f, -1.83249470e-02f, 2.45963130e-02f, -1.00924492e-01f, 6.69371635e-02f, 4.35097553e-02f, -1.06304837e-02f, 7.45797306e-02f,
  -6.86603412e-03f, -3.66517417e-02f, 7.95726553e-02f, 5.41556701e-02f, 7.89568499e-02f, 7.01590031e-02f, 2.56438926e-02f, 5.13478322e-03f, -3.52398753e-02f, -1.36108071e-01f,
  5.50403222e-02f, -2.84786876e-02f, 5.10356613e-02f, -1.06419194e-02f, 5.86286746e-03f, 1.73753016e-02f, 4.69473265e-02f, -3.17684673e-02f, -1.54185137e-02f, 1.02458641e-01f,
  -2.87467651e-02f, 8.12871754e-02f, -4.70972918e-02f, 9.87899378e-02f, 7.26084933e-02f, 4.91819307e-02f, 5.32425903e-02f, 4.89035398e-02f, 1.07200108e-01f, -3.17955166e-02f,
  -6.82506710e-03f, 6.14418685e-02f, -8.68680328e-02f, -6.89437240e-02f, 4.37801853e-02f, 1.12275727e-01f, 2.38505937e-03f, 4.37257476e-02f, 9.43706110e-02f, -1.93166122e-01f,
  7.56787732e-02f, -8.60448331e-02f, 1.47475302e-01f, -9.52934995e-02f, 4.81300838e-02f, -1.25297725e-01f, -7.70031959e-02f, -2.62378864e-02f, -6.00964241e-02f, 9.43576023e-02f,
  1.62974671e-01f, 9.52247083e-02f, -2.50096526e-03f, -1.03913307e-01f, 7.27937967e-02f, -9.92600545e-02f, -2.14162804e-02f, 5.00039011e-02f, 9.64914709e-02f, -3.03853247e-02f,
  -1.55050512e-02f, 3.15096676e-02f, 3.19850370e-02f, -1.00423187e-01f, 1.06573351e-01f, 1.53584182e-01f, 1.00819878e-01f, -4.11993451e-02f, 1.76097095e-01f, -7.01468363e-02f,
  -8.06455463e-02f, -2.72065378e-03f, 1.15945198e-01f, 6.25331551e-02f, 1.38471054e-03f, -8.27998389e-03f, 2.28697918e-02f, -5.02455980e-02f, 9.40707140e-03f, 1.01183541e-01f,
  -1.41654477e-01f, 2.56196912e-02f, -1.23983733e-02f, -6.39714599e-02f, -6.15115697e-03f, 4.15279567e-02f, 7.12609217e-02f, 1.13371629e-02f, -5.14096916e-02f, 3.16188484e-02f,
  6.78419098e-02f, 3.15137580e-02f, 1.17633278e-02f, 3.33681479e-02f, -9.69757512e-02f, 7.53173232e-02f, 5.73115163e-02f, 2.12842803e-02f, 9.42374542e-02f, -4.24937122e-02f,
  7.90515840e-02f, 8.99193063e-02f, -1.06053501e-01f, -5.72677478e-02f, -4.04071584e-02f, 3.73405218e-02f, 3.33916992e-02f, 6.24612942e-02f, -3.02105434e-02f, -1.93719869e-03f,
  -6.81558624e-02f, 7.25162849e-02f, 8.51553380e-02f, -7.94475451e-02f, 3.94283459e-02f, 8.05646330e-02f, -6.31365255e-02f, -6.17323630e-02f, -8.18796605e-02f, -7.86621124e-02f,
  -5.59192821e-02f, 1.73607916e-02f, -9.79406759e-02f, -3.22332382e-02f, -2.34554685e-03f, 4.80818264e-02f, -3.17552835e-02f, 1.01792179e-01f, 8.91362429e-02f, -5.87746464e-02f,
  6.89539313e-02f, -4.20843028e-02f, 5.07658012e-02f, -3.68881822e-02f, 4.57814224e-02f, 1.13002464e-01f, -1.13271084e-02f, -8.90810788e-02f, -2.72805896e-02f, 4.78740633e-02f,
  -6.18463475e-03f, 1.23410076e-01f, -6.85096234e-02f, -3.86162326e-02f, -1.79101750e-02f, -6.55685738e-02f, 5.69740534e-02f, 4.16201875e-02f, 9.06969607e-02f, 6.39668703e-02f,
  1.07610963e-01f, -3.74455489e-02f, 9.27010700e-02f, 3.45900506e-02f, 1.24351336e-02f, 2.96005178e-02f, -7.42994472e-02f, 6.84333965e-02f, -2.16428805e-02f, 2.35771388e-01f,
  4.90069166e-02f, 1.52027503e-01f, -6.10549748e-02f, 7.08404183e-02f, 4.24168482e-02f, -6.89106807e-02f, 8.82953107e-02f, 6.55099005e-02f, 2.19570417e-02f, 4.74336147e-02f,
  -6.43570945e-02f, -1.13767512e-01f, -2.30335426e-02f, 9.73315388e-02f, -1.31656723e-02f, 9.90909338e-02f, 3.81020047e-02f, 5.69931790e-02f, -2.32643448e-02f, 4.73800823e-02f,
  -5.92488199e-02f, -1.87273636e-01f, 4.24446762e-02f, 1.11248307e-02f, -6.57288730e-02f, -1.16485290e-01f, 1.42930478e-01f, 1.12369657e-01f, -6.96382001e-02f, -9.17784795e-02f,
  -9.26184952e-02f, -5.43491058e-02f, 1.76105574e-01f, 2.33536568e-02f, 8.46973211e-02f, 1.08038925e-03f, -1.82325125e-01f, -2.07526296e-01f, 8.73147845e-02f, 9.93947499e-03f,
  -4.63833101e-02f, 3.09073590e-02f, 3.17895599e-02f, -9.11856827e-04f, 1.27050370e-01f, -8.23817253e-02f, -2.27609143e-01f, 4.84450767e-03f, 1.82143509e-01f, -1.07498944e-01f,
  4.98016030e-02f, 2.68975869e-02f, 1.14900105e-01f, -6.05552457e-02f, 8.75742361e-02f, 1.44383058e-01f, 1.82503089e-02f, 1.94029417e-02f, 1.08967230e-01f, 6.02438413e-02f,
  -6.62560090e-02f, 4.87093851e-02f, -5.79127390e-03f, -7.70147294e-02f, -7.88006485e-02f, -6.13507964e-02f, 1.52107216e-02f, 1.45365924e-01f, 4.28231247e-02f, 7.87720736e-03f,
  1.43241152e-01f, 2.34033410e-02f, -8.40966180e-02f, -1.00730263e-01f, -8.23178515e-02f, -5.39203174e-02f, -1.09617688e-01f, -8.62387642e-02f, 4.73894039e-03f, 9.18737240e-03f,
  4.45033871e-02f, 6.55070320e-02f, 6.06059842e-02f, 2.90695056e-02f, -1.88650712e-02f, -3.02009936e-02f, 4.16279323e-02f, 6.76557829e-04f, 4.40151021e-02f, 4.21747006e-02f,
  -4.10090983e-02f, 2.86612865e-02f, 6.18841015e-02f, -5.41731305e-02f, -1.40836798e-02f, 2.31303144e-04f, -1.59100026e-01f, 6.52104467e-02f, 4.32041241e-03f, -7.69156516e-02f,
  -5.29508516e-02f, 4.20874953e-02f, -7.92185292e-02f, 5.03655523e-03f, -3.11580710e-02f, -1.16583854e-01f, -6.32432699e-02f, 3.42909060e-02f, -8.71004537e-02f, -4.69811028e-03f,
  2.07999945e-02f, -6.09343722e-02f, -8.80480558e-02f, -3.21837179e-02f, -2.05366053e-02f, -2.56147534e-02f, -3.65291759e-02f, 6.87684938e-02f, 9.25125647e-03f, -5.07347360e-02f,
  5.61008453e-02f, 5.30312546e-02f, -8.12173709e-02f, -9.03980583e-02f, -8.09709132e-02f, 6.68796226e-02f, 7.88504332e-02f, -6.12591393e-02f, 1.10959508e-01f, -3.23814228e-02f,
  -6.85081333e-02f, -7.74710672e-03f, 4.84395400e-02f, 4.18212228e-02f, 1.21626399e-01f, -8.50911532e-03f, -6.17992133e-02f, -1.24729946e-01f, -4.61176112e-02f, 1.13312833e-01f,
  -5.69882467e-02f, -2.52343304e-02f, -1.71825781e-01f, -1.58742338e-01f, 2.22606380e-02f, -1.94112826e-02f, 2.18547240e-01f, -9.42517668e-02f, -7.27203339e-02f, 1.14819132e-01f,
  3.10936593e-03f, -1.36201411e-01f, -3.58683690e-02f, -3.26894373e-02f, 1.25814481e-02f, -1.82643548e-01f, 9.08644591e-03f, 1.40589643e-02f, 4.88908738e-02f, -8.06333050e-02f,
  1.07308209e-01f, -2.61600805e-03f, -8.00794065e-02f, -1.58089940e-02f, 1.11706771e-01f, 8.43850523e-02f, 9.89099313e-03f, 9.83741730e-02f, 8.22025631e-03f, -1.45493761e-01f,
  -8.81818011e-02f, -1.38141990e-01f, -5.96187487e-02f, -4.52063717e-02f, 1.72561392e-01f, 6.06513284e-02f, -1.18818581e-01f, 5.53653166e-02f, 1.68778971e-02f, -3.24104261e-03f,
  5.11806495e-02f, 6.89021498e-02f, -1.75157487e-02f, -9.35560390e-02f, -2.31299773e-02f, 4.21080925e-02f, 5.20306565e-02f, 5.93773685e-02f, 1.97884478e-02f, -3.06146909e-02f,
  5.19949794e-02f, 6.35420457e-02f, -1.57653317e-02f, -3.22979540e-02f, 1.52607765e-02f, -9.46735293e-02f, -6.96763769e-02f, -2.66784262e-02f, -3.08289216e-03f, -9.58161131e-02f,
  -1.17803039e-02f, 2.43051406e-02f, 1.12223729e-01f, 7.15922713e-02f, 1.16679631e-01f, -5.98348025e-03f, 6.75222576e-02f, -5.02706952e-02f, -5.82957603e-02f, -6.90856799e-02f,
  6.93185031e-02f, -1.04902936e-02f, 7.88539201e-02f, 6.66874573e-02f, -5.93202971e-02f, -9.24386904e-02f, -9.12983343e-02f, 2.03779228e-02f, -1.04341052e-01f, 4.87530679e-02f,
  8.65541697e-02f, -6.72599450e-02f, 4.13213447e-02f, -3.28000933e-02f, -1.15278438e-01f, -3.02096512e-02f, 9.39721689e-02f, -1.76494773e-02f, 8.31787586e-02f, -6.60913512e-02f,
  -6.03838786e-02f, -8.42927489e-03f, -3.07343677e-02f, 5.29418886e-02f, 7.93744400e-02f, -1.26710221e-01f, -9.71999485e-03f, 1.19280152e-01f, -2.69671492e-02f, 6.76415563e-02f,
  6.04890510e-02f, -7.18981996e-02f, -1.12948669e-02f, -1.64333042e-02f, 1.62586883e-01f, 5.50877266e-02f, 1.67848885e-01f, -1.15262397e-01f, 1.06050231e-01f, -7.78126046e-02f,
  6.18860126e-02f, -2.18710452e-02f, -1.18854120e-01f, 6.57529524e-03f, -3.36786360e-02f, 1.59111038e-01f, 5.40564209e-02f, 7.34126121e-02f, 1.18176024e-02f, -5.56098530e-03f,
  1.34299338e-01f, -5.80834113e-02f, -5.32854274e-02f, 1.39592588e-01f, 5.22594340e-02f, 1.43526167e-01f, -1.76953822e-01f, -8.37081596e-02f, -1.45425409e-01f, 1.91290095e-01f,
  -2.68020909e-02f, -1.62878018e-02f, 2.89228391e-02f, 4.14339788e-02f, 3.16296257e-02f, -1.07078232e-01f, -1.27631426e-01f, -1.16054833e-01f, -1.57939330e-01f, -7.66491815e-02f,
  1.38010502e-01f, 3.90471774e-03f, -1.60667792e-01f, 2.41657738e-02f, -1.10142436e-02f, -3.46782655e-02f, 4.68716659e-02f, -4.59298044e-02f, 1.04644462e-01f, -4.77287993e-02f,
  -1.51809424e-01f, -1.59884840e-01f, -1.33395508e-01f, 1.92399009e-03f, 7.88031891e-02f, 1.37913242e-01f, -1.32984981e-01f, -8.34501386e-02f, 7.37802610e-02f, -1.14846081e-01f,
  3.06969304e-02f, -1.53345779e-01f, -9.88811702e-02f, -1.67297229e-01f, 3.31286453e-02f, -1.14820234e-01f, -5.45675270e-02f, -5.71362488e-02f, 5.81858233e-02f, -6.39666244e-02f,
  -7.12539628e-02f, 3.34401727e-02f, -1.18121698e-01f, 7.44928941e-02f, 6.32643625e-02f, 2.89237145e-02f, -2.41794661e-02f, 9.32194367e-02f, 5.33410609e-02f, 2.09104586e-02f,
  3.21346149e-02f, -1.07016519e-01f, -3.44474278e-02f, 6.53815493e-02f, -6.12211376e-02f, -7.25013986e-02f, 1.89578861e-01f, -5.19183278e-03f, -8.62874165e-02f, -1.10397600e-02f,
  1.53216228e-01f, 2.90231612e-02f, 3.48599218e-02f, 8.34130347e-02f, 1.62209556e-01f, -3.70197706e-02f, 6.25646412e-02f, -4.16062288e-02f, 1.18929576e-02f, -6.73758313e-02f,
  3.65301371e-02f, 7.12901801e-02f, -5.07633276e-02f, 4.03382145e-02f, -5.19675165e-02f, -3.36254537e-02f, -7.26189539e-02f, 9.03391019e-02f, -6.05495609e-02f, 1.18734099e-01f,
  -4.50317897e-02f, -6.09847978e-02f, 1.07234493e-01f, 3.69592523e-03f, -4.85872403e-02f, -3.38161066e-02f, 1.73233431e-02f, -8.20366144e-02f, 4.95238975e-02f, -1.31926224e-01f,
  9.32493210e-02f, -5.63719310e-02f, -7.75550529e-02f, 4.25319709e-02f, -7.36706480e-02f, -7.66428337e-02f, 9.93446931e-02f, -3.03899776e-03f, 3.52840461e-02f, -6.71350062e-02f,
  7.88274258e-02f, -8.58891103e-03f, -4.95745661e-03f, 2.89078336e-02f, 6.05559982e-02f, -8.71244296e-02f, 2.53610946e-02f, -1.84224267e-02f, -3.96573776e-03f, -5.22843525e-02f,
  -5.13080135e-02f, -5.07183485e-02f, -1.50911957e-01f, 1.20978747e-02f, 1.41580924e-01f, 5.99465780e-02f, 3.72249149e-02f, -8.33230540e-02f, 1.04078829e-01f, -1.63669154e-01f,
  -1.18882515e-01f, 1.48482010e-01f, -3.03820875e-02f, 2.11307988e-01f, 4.77371886e-02f, 9.75889191e-02f, -7.59864897e-02f, 1.82959676e-01f, -2.51045581e-02f, -8.72662440e-02f,
  1.36357442e-01f, 7.18416348e-02f, -1.74590006e-01f, 1.05881929e-01f, -1.10786408e-02f, -1.03859855e-02f, -3.40048410e-02f, 1.59151554e-01f, 3.75265256e-02f, -6.30817935e-02f,
  -3.33778299e-02f, 6.39265403e-02f, -8.50534067e-02f, -2.09177971e-01f, -8.56367499e-02f, -3.87283452e-02f, -8.27290565e-02f, -1.21359639e-01f, 4.26105447e-02f, -1.84966624e-02f,
  -9.86373127e-02f, 8.15805346e-02f, -5.05692847e-02f, -9.87765491e-02f, -1.77870080e-01f, -5.74798100e-02f, 1.03456154e-02f, 3.66401002e-02f, 1.01163730e-01f, -8.25847015e-02f,
  -1.68304369e-01f, -1.34340348e-02f, 5.34630381e-02f, 5.13065979e-02f, -9.43599194e-02f, 7.00941980e-02f, 5.81745543e-02f, 1.12779336e-02f, 6.86744452e-02f, -3.17734256e-02f,
  1.43229552e-02f, -3.87904160e-02f, 7.96690360e-02f, 4.82299067e-02f, 5.19767180e-02f, 2.25115586e-02f, 1.05050681e-02f, -7.13592470e-02f, 4.49141115e-02f, 7.55196288e-02f,
  -1.87822543e-02f, -8.65627974e-02f, -3.38977240e-02f, -8.27792808e-02f, 1.16530523e-01f, 3.38487513e-02f, -8.97519886e-02f, 1.05184997e-02f, -5.20360954e-02f, 2.29822397e-02f,
  3.07181273e-02f, -6.14712648e-02f, 6.53529540e-02f, -4.27715434e-03f, -8.40348080e-02f, -6.01578504e-02f, 5.13642170e-02f, 1.26276519e-02f, 5.95930815e-02f, -1.14486687e-01f,
  -8.60181078e-02f, 2.74983533e-02f, 6.86196284e-03f, 2.38622669e-02f, 3.44398282e-02f, -7.37250224e-02f, -7.33197555e-02f, -6.57456666e-02f, 7.10545704e-02f, -5.67227267e-02f,
  9.94032845e-02f, 5.16578779e-02f, -6.87550381e-02f, -4.93091792e-02f, -4.06253152e-02f, -1.46645114e-01f, 4.05751690e-02f, -1.58044890e-01f, 9.07069296e-02f, 3.54541168e-02f,
  1.42644094e-02f, -1.38442159e-01f, 6.84271976e-02f, 1.40653133e-01f, -1.31983301e-02f, 5.79806557e-03f, -6.27893507e-02f, 2.49276012e-02f, -9.09552649e-02f, 2.98093073e-02f,
  1.12142958e-01f, -3.87013108e-02f, 3.17373537e-02f, -8.18805993e-02f, 1.29114747e-01f, 2.24687438e-02f, -4.75828201e-02f, 1.92833710e-02f, -1.20882750e-01f, 8.75517055e-02f,
  3.63182835e-02f, 7.94130638e-02f, -2.75807716e-02f, -6.93945661e-02f, 6.81972178e-03f, -1.37943318e-02f, 8.41057152e-02f, -4.16376181e-02f, 6.75240979e-02f, 1.74837247e-01f,
  -1.35714144e-01f, 1.89765632e-01f, -2.29910776e-01f, -1.72102228e-02f, -1.41344592e-01f, 1.62747830e-01f, 2.93904101e-03f, 6.08879216e-02f, -6.76960051e-02f, -5.15379161e-02f,
  -1.26932830e-01f, -5.37524745e-02f, -9.16999355e-02f, -5.38344309e-02f, -7.86212757e-02f, 3.84697542e-02f, 8.53579119e-02f, -1.35000482e-01f, 4.60078046e-02f, 3.32709495e-03f,
  -1.76224634e-01f, -7.48280287e-02f, 4.17670235e-02f, 2.22164188e-02f, 4.67691906e-02f, -6.46601021e-02f, -4.00236063e-03f, 1.49760563e-02f, -1.62623107e-01f, -2.14432720e-02f,
  4.46121097e-02f, 2.83147208e-02f, -1.37887761e-01f, -4.99287210e-02f, 2.68231742e-02f, 3.62437852e-02f, -9.31016579e-02f, -5.48503883e-02f, -1.07676454e-01f, -2.23844469e-01f,
  1.96914166e-01f, -7.67581835e-02f, -3.02674640e-02f, -1.02152824e-01f, 8.05486590e-02f, 2.08187345e-02f, -1.20357603e-01f, 8.35435167e-02f, 2.06831507e-02f, -3.49049345e-02f,
  8.09645355e-02f, -2.99605057e-02f, -1.30459636e-01f, 9.32329074e-02f, -2.48881541e-02f, 6.96267709e-02f, 9.82710812e-03f, -9.93932858e-02f, 8.31772238e-02f, -1.06381327e-02f,
  -4.95903529e-02f, 4.03354988e-02f, 1.40130624e-01f, 8.04026437e-04f, -7.93142542e-02f, -8.51046219e-02f, -4.48612347e-02f, 8.37922841e-02f, 4.51942394e-03f, -8.85791406e-02f,
  -5.57076000e-02f, 3.32614128e-03f, 1.46692172e-02f, -2.94311289e-02f, -1.76953431e-02f, -2.61733844e-03f, -6.84208497e-02f, -3.64680514e-02f, 5.68090826e-02f, -7.36371428e-03f,
  7.80938268e-02f, 6.98596239e-02f, 8.13222080e-02f, -1.53885838e-02f, -4.22096737e-02f, -7.09746853e-02f, -6.58778995e-02f, -6.22664094e-02f, -6.46360070e-02f, 5.35108633e-02f,
  8.29992164e-03f, -3.03713065e-02f, -6.69852272e-02f, 1.18365727e-01f, 8.87600929e-02f, 4.67083268e-02f, 6.41970932e-02f, 4.31784950e-02f, 7.75694400e-02f, -2.55690403e-02f,
  -7.31607080e-02f, 3.82538922e-02f, -3.07580531e-02f, 1.28241032e-01f, -1.65814701e-02f, 7.74692670e-02f, 9.40406546e-02f, 1.88075565e-02f, 8.67090598e-02f, 7.01539740e-02f,
  8.80453289e-02f, -4.58162799e-02f, 3.45469117e-02f, -4.40971665e-02f, 1.81805473e-02f, -9.25051123e-02f, 1.01320244e-01f, -3.65767255e-02f, 1.36900678e-01f, 1.28441587e-01f,
  -1.64156094e-01f, -9.15288702e-02f, -1.09160051e-01f, 6.00889809e-02f, 1.26618281e-01f, 6.76058903e-02f, -1.44827254e-02f, -1.33915739e-02f, -1.19935319e-01f, -6.90213079e-03f,
  -8.81149098e-02f, -7.52336532e-02f, -1.11533478e-01f, 4.48659919e-02f, -4.85798642e-02f, 1.06790990e-01f, -7.97164217e-02f, 8.86513889e-02f, -7.63935149e-02f, 4.54343632e-02f,
  -4.31395210e-02f, -7.44767711e-02f, 1.06847957e-01f, -9.03305709e-02f, -7.22674876e-02f, -1.02383113e-02f, -1.25888875e-03f, 6.57919347e-02f, 1.66726261e-02f, 9.20579955e-02f,
  1.44840814e-02f, -4.25930098e-02f, 6.01891279e-02f, 8.62988904e-02f, -5.04534952e-02f, -7.50870705e-02f, -6.29447624e-02f, -1.55526459e-01f, 8.24297592e-02f, -7.66866654e-02f,
  1.43908607e-02f, 8.08515400e-02f, -1.82454921e-02f, 1.12253474e-02f, -1.01745903e-01f, -5.63462973e-02f, -6.78219497e-02f, -1.03088304e-01f, 4.96671768e-04f, -4.73771095e-02f,
  -3.25658582e-02f, -1.09802328e-01f, -2.94991434e-02f, -8.04086253e-02f, 5.10399193e-02f, 8.88267756e-02f, -1.35041550e-01f, -6.52061701e-02f, -6.98928908e-03f, 7.18569234e-02f,
  -1.26919597e-01f, 8.31560642e-02f, -3.51117291e-02f, 5.86210005e-02f, -1.17512874e-01f, 1.51015166e-02f, 1.13327384e-01f, -7.21933437e-04f, 1.14930637e-01f, 5.36192432e-02f,
  5.33547401e-02f, 5.84558956e-02f, -5.67422155e-03f, -2.25696974e-02f, 9.76312384e-02f, 8.05977583e-02f, -2.00855788e-02f, -1.45931095e-02f, 8.88347253e-02f, -9.76849869e-02f,
  7.19227642e-02f, -1.02029137e-01f, -8.74082297e-02f, -3.53757106e-03f, -8.44099596e-02f, -2.66960915e-02f, -4.41467129e-02f, 1.15891650e-01f, 4.03526723e-02f, 4.59798165e-02f,
  -5.93922921e-02f, -2.22088154e-02f, -2.65390966e-02f, 3.77543196e-02f, -4.28794585e-02f, -8.37443210e-03f, -3.32521945e-02f, -1.05321901e-02f, -2.00370047e-02f, 1.80618782e-02f,
  -5.20624556e-02f, 3.64179723e-02f, 6.72985911e-02f, -1.46560408e-02f, -3.31931710e-02f, 1.02997907e-02f, -5.36292903e-02f, 7.50539154e-02f, 5.92352226e-02f, 5.14977537e-02f,
  -2.94106677e-02f, 9.42890253e-03f, 2.91973967e-02f, 5.50054461e-02f, 3.37833837e-02f, -5.16214631e-02f, -3.25141624e-02f, 2.93241851e-02f, -7.35518038e-02f, 5.83303981e-02f,
  4.06263918e-02f, 8.77844263e-03f, 6.70393705e-02f, 4.53268513e-02f, -5.88778406e-02f, -2.39260178e-02f, 6.70282766e-02f, -1.05217822e-01f, -2.58859992e-01f, -1.91446528e-01f,
  -1.17270209e-01f, 2.47491766e-02f, 1.16602041e-01f, 2.46429801e-01f, -1.19093470e-01f, 1.20664932e-01f, -8.94173309e-02f, 4.94743511e-02f, 6.13497496e-02f, 2.22704709e-02f,
  -1.32190168e-01f, -1.45792514e-01f, 1.33996299e-02f, 7.94283822e-02f, -8.25801119e-02f, -8.19169916e-03f, -2.00529009e-01f, 1.25439256e-01f, 1.40586458e-02f, 1.04241095e-01f,
  -1.01077646e-01f, 3.54860760e-02f, -2.28334335e-03f, -1.88632123e-02f, -2.69852094e-02f, 1.42063260e-01f, 1.47836283e-01f, 2.26417795e-01f, -8.42139032e-03f, 7.49558881e-02f,
  -1.90916676e-02f, 4.84497845e-02f, 1.33603346e-03f, 1.19264416e-01f, -3.10474515e-01f, -1.13493264e-01f, -8.94762576e-02f, -9.04574022e-02f, -3.59632894e-02f, 1.69670448e-01f,
  -1.09225929e-01f, 6.26519769e-02f, -7.07683414e-02f, -3.80973332e-02f, -1.34996530e-02f, -1.56590432e-01f, 1.97476655e-01f, -7.60714561e-02f, 1.44059816e-03f, -3.07323691e-02f,
  -3.59106287e-02f, 9.95396376e-02f, 1.79694612e-02f, 2.10651923e-02f, -1.55040056e-01f, -3.94488759e-02f, 4.79908660e-02f, -5.00488654e-02f, 3.98280025e-02f, 7.43249897e-03f,
  -1.07588805e-02f, 8.72178972e-02f, -1.11059129e-01f, -2.63986904e-02f, 1.25654578e-01f, 2.86245290e-02f, 2.20874622e-01f, 1.16888650e-01f, -1.10310325e-02f, 6.66615516e-02f,
  5.79238646e-02f, -7.41857663e-02f, 1.35736342e-03f, -3.44508290e-02f, -7.38325790e-02f, -3.79328504e-02f, -9.66892317e-02f, -1.04750907e-02f, -1.26990285e-02f, 1.20354872e-02f,
  -5.69586754e-02f, 1.23203479e-01f, 9.01863500e-02f, -4.35881503e-02f, 7.03484342e-02f, 4.04139906e-02f, -3.88711095e-02f, 7.59317502e-02f, 6.29337803e-02f, 7.89816305e-02f,
  9.74907130e-02f, -7.90453237e-03f, -8.89496878e-03f, 1.35950640e-01f, -9.64991935e-03f, -4.62967567e-02f, 1.09770052e-01f, 5.18127009e-02f, -8.55916291e-02f, -5.57961389e-02f,
  5.57175316e-02f, -6.11320399e-02f, 4.54866625e-02f, 6.83959499e-02f, -6.58999756e-02f, 2.95614954e-02f, 8.18033516e-02f, 8.66848677e-02f, -7.94195384e-02f, -1.34408725e-02f,
  -7.71161616e-02f, 1.09054200e-01f, 1.58627648e-02f, 1.00199379e-01f, -4.82568666e-02f, -3.56034674e-02f, -5.52543327e-02f, -8.80757794e-02f, 4.49862853e-02f, -5.33100255e-02f,
  -5.29741384e-02f, -7.33990297e-02f, 4.55668978e-02f, -2.24544201e-02f, 8.23222194e-03f, 5.90240099e-02f, 4.27814312e-02f, -1.30568981e-01f, -2.37469226e-02f, 5.77253327e-02f,
  1.25271961e-01f, 1.57793537e-01f, 3.22947688e-02f, 5.12133725e-02f, -1.09306902e-01f, -5.40460609e-02f, -1.48062810e-01f, -2.17568651e-02f, 9.58981663e-02f, 1.96530502e-02f,
  -4.26662229e-02f, 1.06231526e-01f, -5.81866950e-02f, 3.96765396e-02f, 1.89262897e-01f, -1.07875153e-01f, 2.39087306e-02f, -9.09091905e-02f, 3.12717929e-02f, -8.65057334e-02f,
  -6.55342489e-02f, 2.69281697e-02f, -8.20342358e-03f, -7.40735829e-02f, -7.53530636e-02f, 1.05708398e-01f, -6.19115047e-02f, 4.32931036e-02f, 5.75721078e-02f, 1.26149189e-02f,
  -2.50506103e-02f, -2.55168825e-02f, 3.63850221e-02f, -1.64893847e-02f, 5.90067320e-02f, -1.16405562e-01f, -2.70978436e-02f, -1.17520653e-02f, -6.66143373e-02f, -7.25767538e-02f,
  3.87182203e-03f, 1.24666266e-01f, -3.71141955e-02f, -5.64215332e-02f, -6.85959384e-02f, 1.73727125e-01f, -5.41029498e-02f, -9.34544951e-02f, 2.83001512e-02f, -5.49588725e-02f,
  -9.18660834e-02f, 2.62598898e-02f, -4.22283225e-02f, 2.24417709e-02f, 6.86665848e-02f, -1.24673666e-02f, -9.58882123e-02f, -3.45986560e-02f, -1.08121961e-01f, 8.80378634e-02f,
  2.76450533e-03f, 1.82667691e-02f, -1.14716832e-02f, -8.22789297e-02f, 5.28164729e-02f, 9.12024528e-02f, 6.25137091e-02f, -5.56240492e-02f, -4.21487540e-02f, -9.10520405e-02f,
  1.07149504e-01f, 6.85539022e-02f, 8.66321921e-02f, 5.47376228e-03f, -7.02821240e-02f, 1.15306042e-02f, 2.34633312e-02f, 3.50441635e-02f, 5.85070774e-02f, -5.59330510e-05f,
  -5.21941371e-02f, -1.66770332e-02f, 5.51159605e-02f, -1.03618637e-01f, -5.75324446e-02f, 1.39755486e-02f, -3.89114060e-02f, -7.77166858e-02f, -5.67483120e-02f, 7.39206672e-02f,
  7.00278878e-02f, 7.13896006e-02f, -1.56847328e-01f, -7.34063312e-02f, -5.54000884e-02f, -5.26407473e-02f, 3.11311078e-03f, -6.90636188e-02f, 6.61403090e-02f, 1.37078077e-01f,
  -4.92476895e-02f, -1.20122798e-01f, -3.65510723e-03f, 5.44784963e-02f, 2.38861353e-03f, -7.04625845e-02f, -4.32984307e-02f, -6.05704673e-02f, 7.26736337e-02f, 1.93351693e-02f,
  -5.37476949e-02f, 5.29055484e-02f, -3.84807065e-02f, -5.20096794e-02f, -2.36461079e-03f, -1.00137800e-01f, -5.33822402e-02f, -1.44447153e-03f, 5.99293523e-02f, 9.28550959e-03f,
  -4.81246337e-02f, -6.52848650e-03f, -1.20759010e-02f, 1.83570817e-01f, 2.08305597e-01f, 6.47921413e-02f, -6.38733059e-02f, 1.19069189e-01f, -1.64015189e-01f, -1.31409839e-01f,
  1.62387654e-01f, -8.61078650e-02f, 3.60178128e-02f, 1.12092718e-01f, -7.19115138e-02f, -1.35960087e-01f, 9.72550288e-02f, 1.95383281e-02f, -8.06930959e-02f, -9.58796311e-03f,
  8.99042338e-02f, 1.24173544e-01f, 4.31502499e-02f, -8.58612880e-02f, -9.75415930e-02f, -2.91823670e-02f, 1.10225394e-01f, 1.74757168e-02f, -5.90443313e-02f, -8.09961706e-02f,
  1.12427428e-01f, -1.02295235e-01f, -4.80914526e-02f, -1.32908851e-01f, -1.41949579e-01f, -2.88954973e-02f, 1.85351685e-01f, -8.72922018e-02f, -3.67243513e-02f, 4.72623967e-02f,
  2.14000209e-03f, -3.72617017e-03f, 3.09192128e-02f, -5.17981593e-04f, -6.21022172e-02f, -1.38242960e-01f, 1.85224265e-02f, -1.29674196e-01f, -7.17178062e-02f, -5.16681150e-02f,
  2.80048158e-02f, 1.38676971e-01f, -1.83924288e-02f, -1.14673600e-02f, -2.15772316e-02f, 3.54932994e-02f, -3.38310227e-02f, -6.51731566e-02f, -5.42735718e-02f, 8.73689074e-03f,
  1.14361584e-01f, -1.13387536e-02f, 7.62698501e-02f, -4.98657934e-02f, -4.39769924e-02f, -5.47446460e-02f, 9.16497186e-02f, -3.45583186e-02f, 3.52768525e-02f, -9.78418142e-02f,
  -9.34274569e-02f, -8.01387578e-02f, -6.99323639e-02f, -9.31777060e-02f, -1.95568986e-02f, -3.35315429e-02f, -1.42232282e-02f, -6.28518388e-02f, -2.43666917e-02f, -4.59941151e-03f,
  -1.89023446e-02f, 7.27672130e-02f, -1.70745868e-02f, 3.46891992e-02f, 8.42754692e-02f, 2.45893467e-03f, -1.09278224e-01f, -6.43037260e-03f, 1.98860355e-02f, 3.69096873e-03f,
  7.07325935e-02f, 3.66032943e-02f, 7.39692897e-03f, -1.03640392e-01f, -2.87141725e-02f, -1.21557852e-02f, 6.10673502e-02f, 3.76145765e-02f, -5.87541088e-02f, -6.56722998e-03f,
  1.38053149e-01f, -7.94182047e-02f, -2.88628750e-02f, -2.10444210e-03f, 2.48897709e-02f, -3.24216522e-02f, 4.83766645e-02f, -1.56899646e-01f, 1.00504719e-01f, 7.30332434e-02f,
  6.58448879e-03f, -1.42496184e-01f, -1.42320106e-03f, -2.57858876e-02f, -3.76346633e-02f, -2.54026502e-02f, -4.89843562e-02f, -2.08348688e-02f, -8.32451805e-02f, 1.90373044e-02f,
  5.01884222e-02f, -3.05752214e-02f, -5.20783011e-03f, 2.28843167e-02f, 4.84340712e-02f, -6.55523688e-02f, -1.02288306e-01f, -6.47828132e-02f, -5.99838980e-02f, 1.09551130e-02f,
  -1.42536864e-01f, -2.51613893e-02f, -3.63698751e-02f, -1.91120896e-02f, 7.30201825e-02f, -1.37320030e-02f, 9.48961079e-02f, -4.34114307e-04f, 4.81073335e-02f, 1.73179537e-01f,
  -1.61594182e-01f, 5.48253283e-02f, -8.78032520e-02f, 1.30204216e-01f, -3.01633496e-02f, 1.60595387e-01f, 2.83199605e-02f, 9.37000569e-03f, -9.71599892e-02f, -6.58483654e-02f,
  9.25410166e-02f, 1.47271948e-03f, -8.06881487e-03f, -1.22497946e-01f, 1.23992145e-01f, -6.76123947e-02f, 1.06481798e-01f, -1.09042265e-02f, 9.85648260e-02f, 1.30271927e-01f,
  -1.09493874e-01f, -1.12001695e-01f, -2.61745304e-02f, 9.05355886e-02f, 9.06685516e-02f, -7.89259523e-02f, 1.47689376e-02f, -3.71663012e-02f, -1.60186797e-01f, 6.12208545e-02f,
  9.09089297e-02f, -1.71639666e-01f, -1.58557966e-01f, -4.32118922e-02f, 1.22644559e-01f, -5.91348633e-02f, -1.07848369e-01f, 2.65337359e-02f, 2.47106366e-02f, -1.30181015e-01f,
  1.08771063e-02f, 2.30892319e-02f, -7.96581432e-02f, 6.32109866e-03f, 1.43096000e-02f, 8.22699368e-02f, -6.01810738e-02f, 6.59691691e-02f, 2.68507209e-02f, 4.40166667e-02f,
  -3.53575721e-02f, -3.69593268e-03f, -1.15989730e-01f, 7.63011277e-02f, -2.41041090e-02f, 3.23947668e-02f, 2.87857018e-02f, -8.01962391e-02f, 6.46786168e-02f, -6.06018454e-02f,
  2.17077918e-02f, 5.56078926e-02f, -5.81079982e-02f, 9.67350453e-02f, 6.28281385e-02f, -3.12211588e-02f, -4.68884856e-02f, 7.58986920e-02f, 1.53068465e-03f, 1.14092916e-01f,
  1.56190917e-01f, 1.04862517e-02f, 1.10973425e-01f, -2.29412001e-02f, -5.74706122e-02f, -2.44985316e-02f, 4.40808758e-02f, 4.86528641e-03f, 6.79001212e-02f, -3.67111415e-02f,
  -8.39794725e-02f, -4.00785469e-02f, 2.71704867e-02f, -5.44673130e-02f, 1.57158251e-03f, 7.93784857e-02f, -9.92324799e-02f, 9.47609097e-02f, 1.47825494e-01f, 1.30290575e-02f,
  5.46446890e-02f, -1.21432707e-01f, 1.05673902e-01f, -7.46556267e-04f, -3.96898091e-02f, -1.11256823e-01f, 4.85058203e-02f, 2.75223311e-02f, 3.41113796e-03f, -4.88017537e-02f,
  -4.80726212e-02f, -5.63901365e-02f, 8.08459073e-02f, -4.00114208e-02f, -3.52754705e-02f, -7.49288127e-02f, -8.96221325e-02f, -7.18296021e-02f, -1.61610674e-02f, 2.15227455e-02f,
  -7.06448331e-02f, -7.40505159e-02f, 1.22484371e-01f, -3.90662393e-03f, 6.04981668e-02f, 7.02136531e-02f, 2.55046561e-02f, -7.73379430e-02f, -7.87895247e-02f, -1.57072712e-02f,
  1.30344540e-01f, 1.36210307e-01f, 1.60945088e-01f, -4.10062410e-02f, -2.39387969e-03f, -1.60004914e-01f, -9.37455967e-02f, -5.33909583e-03f, -1.53119773e-01f, 1.67635366e-01f,
  -1.47538722e-01f, 5.01521155e-02f, 6.31040484e-02f, 1.52893275e-01f, -4.64821560e-03f, -8.62340853e-02f, 4.39177640e-02f, -2.67793350e-02f, -4.07291800e-02f, -7.81914294e-02f,
  -7.78078139e-02f, -5.89136109e-02f, 3.16077210e-02f, -7.62608051e-02f, 1.91677794e-01f, -1.57128088e-02f, -3.10180616e-02f, 2.61052940e-02f, 3.34590115e-02f, -2.20769569e-01f,
  5.32131605e-02f, 3.48630361e-03f, 7.32710138e-02f, -5.96850403e-02f, -5.12223616e-02f, -1.89615190e-01f, 1.19743478e-02f, 1.37791619e-01f, -1.67397447e-02f, 1.08770490e-01f,
  -1.27167419e-01f, -3.10021713e-02f, 1.21655390e-01f, -1.06205130e-02f, 3.20842899e-02f, 1.10106252e-01f, -1.12288155e-01f, -2.53800061e-02f, -5.87641373e-02f, -5.06222062e-02f,
  1.00842603e-01f, -5.13538308e-02f, 1.78560521e-02f, -3.87366451e-02f, -9.93651897e-02f, -8.58040974e-02f, 7.56082416e-04f, 1.06368266e-01f, 6.24388680e-02f, -8.20213109e-02f,
  -6.52060732e-02f, 9.92476121e-02f, 1.18303306e-01f, 1.45027488e-02f, -6.46790266e-02f, -1.19146332e-02f, -6.66390881e-02f, -4.17588316e-02f, -1.57473400e-01f, -5.68479560e-02f,
  8.08916148e-03f, -5.48068732e-02f, 1.02624319e-01f, -3.68196070e-02f, 4.23123203e-02f, -5.73861077e-02f, -9.13046896e-02f, 7.18849078e-02f, -4.91657108e-02f, 3.60315889e-02f,
  5.12999445e-02f, -4.91330512e-02f, 4.19574901e-02f, 6.35397658e-02f, 2.88285111e-04f, -5.64132407e-02f, 6.44328296e-02f, -6.63538426e-02f, -5.42653613e-02f, 5.36671057e-02f,
  2.26717759e-02f, -4.00705040e-02f, -5.39218560e-02f, 3.19566391e-02f, 3.49764526e-02f, 5.60364574e-02f, 6.55258521e-02f, -5.33017181e-02f, -2.01266594e-02f, 7.12417159e-03f,
  4.13658321e-02f, -9.98135284e-02f, 6.21481948e-02f, -9.54150781e-02f, -1.86125021e-02f, 1.19661950e-01f, 6.71249628e-02f, -1.11807659e-01f, -1.02265745e-01f, -6.19444959e-02f,
  -1.00452125e-01f, 7.83852264e-02f, 5.37292399e-02f, 8.73361826e-02f, -5.31745255e-02f, -2.00059433e-02f, -2.37009004e-02f, 8.07408392e-02f, -9.00065899e-03f, 2.56512221e-02f,
  4.71994393e-02f, -7.11240768e-02f, -9.52548012e-02f, 1.04468517e-01f, -7.19802156e-02f, 1.80729199e-02f, -7.05647916e-02f, -3.38681266e-02f, 1.48495510e-01f, -2.94385739e-02f,
  6.56359419e-02f, 6.99315667e-02f, 5.75587638e-02f, 6.15458824e-02f, 1.02744482e-01f, -2.39311643e-02f, -1.90353096e-01f, 4.33021337e-02f, -1.28886163e-01f, 1.28226429e-01f,
  4.46625911e-02f, 1.33112907e-01f, 6.78259693e-03f, 2.34976020e-02f, -1.23562172e-01f, -2.56767161e-02f, 1.67122379e-01f, -2.28628695e-01f, -4.55047749e-02f, 1.92828570e-02f,
  3.38047883e-03f, -1.51665092e-01f, 1.33898184e-01f, 4.62706611e-02f, 4.24521901e-02f, 3.25412303e-02f, -6.61162809e-02f, -1.03329673e-01f, 8.66270065e-02f, 4.09962982e-02f,
  7.02787414e-02f, -7.80160502e-02f, -8.87250826e-02f, -1.23320445e-02f, -1.83369994e-01f, 1.27662033e-01f, -2.12046411e-02f, -1.10761477e-02f, -1.02014109e-01f, 4.85782884e-02f,
  4.21461686e-02f, -1.22958504e-01f, -1.48920938e-01f, 1.37132689e-01f, 4.33140481e-03f, -1.75151080e-01f, 4.63186838e-02f, 8.89341906e-02f, 2.30818875e-02f, 3.76478620e-02f,
  -7.72414207e-02f, -3.44111323e-02f, 4.48485240e-02f, -1.00519527e-02f, -6.00339100e-02f, 2.51495913e-02f, 9.55792367e-02f, -2.80488711e-02f, -4.75203842e-02f, 1.07847117e-01f,
  -2.33973898e-02f, 4.42620255e-02f, 3.12484298e-02f, -1.15742564e-01f, -6.79543018e-02f, -6.92984313e-02f, -1.21087462e-01f, 3.12476326e-02f, -1.48719689e-03f, 2.86565907e-02f,
  1.86534524e-02f, 1.55266328e-02f, 9.85529944e-02f, 8.61077681e-02f, 3.04781105e-02f, -8.24811384e-02f, -7.63880461e-03f, -4.93138433e-02f, 3.76828872e-02f, -1.38472365e-02f,
  2.00776774e-02f, 1.43443048e-02f, -1.07543707e-01f, 5.48610911e-02f, -8.55813771e-02f, 1.25099942e-02f, -3.54523920e-02f, 6.34980798e-02f, -1.25428170e-01f, -1.43926702e-02f,
  -8.08783900e-03f, 5.23538701e-02f, -2.32680906e-02f, -1.20503403e-01f, -2.31263563e-02f, 6.80282712e-02f, -7.05598071e-02f, -1.33050293e-01f, -6.53508976e-02f, -2.90540401e-02f,
  1.59087591e-02f, -9.77467671e-02f, 2.22383328e-02f, -3.27317193e-02f, 6.89304173e-02f, 3.87230739e-02f, -5.68914739e-03f, 3.97117212e-02f, -1.36779835e-02f, -1.33513749e-01f,
  -6.77568316e-02f, -1.57623634e-01f, 1.23914452e-02f, -2.04747468e-02f, -6.28548115e-02f, -6.04356676e-02f, 2.88745034e-02f, -4.50684354e-02f, -1.18071727e-01f, 1.02540627e-01f,
  1.12995885e-01f, -6.12195134e-02f, 4.09705788e-02f, -1.36882633e-01f, -4.45193686e-02f, -3.18844952e-02f, 8.48919526e-02f, -5.17207012e-02f, 1.00412801e-01f, -1.98880322e-02f,
  -4.55358252e-03f, -1.28155768e-01f, -1.60116583e-01f, -3.31189185e-02f, 2.07451448e-01f, 1.02904089e-01f, 1.55993909e-01f, -9.60675851e-02f, -8.46301392e-02f, -8.65195990e-02f,
  7.08615109e-02f, 1.09924451e-02f, 4.50881310e-02f, 8.37061405e-02f, -1.27566338e-01f, 3.48290093e-02f, 1.05644412e-01f, 3.52899358e-02f, -6.96902350e-02f, 7.60582089e-02f,
  -7.27382600e-02f, 2.45148484e-02f, -7.19786808e-02f, 2.19166111e-02f, 3.42579633e-02f, 1.22665446e-02f, -1.22333147e-01f, 3.96114960e-02f, -1.80672571e-01f, 2.44431049e-02f,
  1.49667868e-02f, -3.18195060e-04f, 7.86889717e-03f, -2.30578016e-02f, -3.53656337e-03f, 5.76491840e-02f, 4.31256965e-02f, -1.20512858e-01f, -7.23227412e-02f, 7.45171830e-02f,
  8.06945339e-02f, -1.32872373e-01f, 1.16255712e-02f, 1.24938861e-01f, -5.99843413e-02f, -1.53702339e-02f, 1.02496020e-01f, 9.97223854e-02f, -1.47221740e-02f, -7.02602789e-02f,
  -2.24164166e-02f, -3.72017957e-02f, 7.26170316e-02f, -3.98072936e-02f, 1.58966507e-03f, -6.45805523e-02f, 1.10330746e-01f, -1.16931714e-01f, 2.07897983e-02f, 5.28176278e-02f,
  7.43128881e-02f, -2.47709919e-02f, -5.39504401e-02f, -5.45902513e-02f, 8.77692699e-02f, -1.18536159e-01f, -6.63268343e-02f, 2.04291977e-02f, -1.63660070e-03f, -2.25680191e-02f,
  -1.00225560e-01f, 2.40345858e-02f, -3.68766719e-04f, 4.06700633e-02f, -3.79635319e-02f, -7.74450749e-02f, -4.92081940e-02f, 6.99892873e-03f, -3.57511849e-03f, 5.06745279e-02f,
  -2.56146044e-02f, 9.24648046e-02f, -8.01477879e-02f, 2.22742967e-02f, 5.44178113e-02f, 1.68793485e-03f, 9.44593996e-02f, 3.44726956e-03f, 9.01941732e-02f, 3.14438231e-02f,
  -3.63465957e-02f, -4.49807979e-02f, 4.19596490e-03f, 6.86011314e-02f, 2.99883634e-02f, 1.64211653e-02f, -5.25833480e-02f, 6.54098690e-02f, 5.07531874e-02f, -7.29273781e-02f,
  -1.18915424e-01f, 8.34999979e-02f, -1.82063989e-02f, 3.21692936e-02f, 1.82047691e-02f, -2.52019279e-02f, 1.33666731e-02f, 5.97236343e-02f, 7.58622289e-02f, 6.96240738e-02f,
  -8.37575570e-02f, -8.89146179e-02f, -3.04346383e-02f, 2.47711521e-02f, 1.29642906e-02f, -1.67928692e-02f, -5.49395084e-02f, 6.02222532e-02f, -2.35107094e-02f, -8.01916644e-02f,
  4.49214987e-02f, -1.85044445e-02f, -2.64306571e-02f, 6.23595761e-03f, -2.10139453e-02f, 1.17994491e-02f, 7.31904656e-02f, 2.22047083e-02f, 8.94391090e-02f, 2.26869926e-01f,
  2.01277081e-02f, -1.04059473e-01f, 4.02297191e-02f, -7.39550665e-02f, -7.32944161e-02f, 1.15063131e-01f, -5.09791262e-02f, -4.72582094e-02f, -7.76805356e-02f, 1.89805590e-02f,
  -9.24006775e-02f, -6.45752847e-02f, -4.93825413e-02f, -1.16273351e-01f, -3.93511802e-02f, 1.00690663e-01f, -1.21939451e-01f, -4.87316772e-02f, -9.22917351e-02f, 1.58069693e-02f,
  -1.25370175e-01f, -1.36027664e-01f, 4.96827587e-02f, -5.51587865e-02f, -6.50133565e-02f, 8.81906152e-02f, -9.14670154e-02f, -1.06809000e-02f, -1.05496438e-03f, -1.75440796e-02f,
  8.83835331e-02f, -7.78110698e-02f, -9.97435898e-02f, 1.05329759e-01f, 5.46231009e-02f, -5.74775822e-02f, 2.71663778e-02f, -6.46280646e-02f, -6.48918003e-02f, 4.87699024e-02f,
  4.96051423e-02f, 4.37019655e-04f, 1.48587562e-02f, -3.78922969e-02f, -1.49455527e-02f, -6.82935789e-02f, -8.67508128e-02f, -1.35548776e-02f, 1.58723742e-02f, -5.36487810e-02f,
  2.77996045e-02f, 8.49468783e-02f, 1.98297091e-02f, -5.74189983e-03f, 7.30329305e-02f, -1.12584472e-01f, 1.09843850e-01f, 7.59318173e-02f, -5.64506985e-02f, -2.89738290e-02f,
  -6.42131716e-02f, -1.18236477e-02f, 9.29182097e-02f, 1.21954409e-02f, -4.11350578e-02f, 1.87211018e-02f, -8.88410211e-02f, 5.90648763e-02f, 8.69175196e-02f, 9.37283337e-02f,
  -3.00790612e-02f, 4.80914786e-02f, -1.79351456e-02f, -1.24711156e-01f, 8.58694874e-03f, 4.30843281e-03f, -3.85720432e-02f, -8.63392204e-02f, 9.21625495e-02f, -2.61142757e-02f,
  -1.97068825e-02f, 4.66532856e-02f, 8.91573902e-04f, -1.03891566e-01f, -7.36413673e-02f, 4.85166255e-03f, -2.90972479e-02f, 4.36961986e-02f, -9.61224083e-03f, 2.16357689e-02f,
  4.61356193e-02f, 6.94068521e-02f, -5.31436503e-02f, 2.17733812e-02f, -1.75036769e-02f, -2.36144755e-03f, -8.47539231e-02f, 3.88471014e-03f, -4.15896438e-02f, -3.75953503e-02f,
  -4.80061173e-02f, -1.22400500e-01f, -5.32889217e-02f, -8.69956613e-02f, 3.24590094e-02f, -1.05849586e-01f, -8.76428261e-02f, 8.14823285e-02f, 6.91152066e-02f, -8.35820213e-02f,
  7.97979832e-02f, -8.27919692e-02f, 7.61715025e-02f, -8.54002386e-02f, 1.18845776e-01f, -8.91172588e-02f, -1.74787622e-02f, -2.00008433e-02f, -1.33905411e-01f, 7.46116862e-02f,
  6.00786135e-02f, 7.59403631e-02f, 1.53220192e-01f, 1.04320467e-01f, 1.10829182e-01f, -4.04375121e-02f, 2.71839425e-02f, -1.49498373e-01f, 2.35081017e-02f, -2.48552896e-02f,
  -2.10588463e-02f, 1.05103500e-01f, 9.99071635e-04f, 3.89493583e-03f, -5.74687608e-02f, -1.28612958e-03f, -5.38702607e-02f, -1.57892376e-01f, 7.18244985e-02f, -3.13239507e-02f,
  8.94244909e-02f, 8.98031443e-02f, -7.95387570e-03f, -7.07634492e-03f, -7.99294785e-02f, -9.41509977e-02f, 4.02003974e-02f, 4.47060466e-02f, -1.31213754e-01f, -6.78435937e-02f,
  8.42012167e-02f, -1.19786546e-01f, 5.50056286e-02f, -3.88314240e-02f, 1.37277395e-01f, -8.20207819e-02f, 2.41733696e-02f, -5.91595434e-02f, -2.92728953e-02f, 1.37654200e-01f,
  -1.77277997e-02f, 1.02788165e-01f, -1.11109488e-01f, -8.87649953e-02f, 9.13994983e-02f, -1.62237555e-01f, -1.00008786e-01f, 6.67275414e-02f, 4.46075089e-02f, -7.04395548e-02f,
  1.35604860e-02f, -1.59886286e-01f, 4.94510531e-02f, -4.95751724e-02f, -4.21180241e-02f, 8.61940458e-02f, 2.51504947e-02f, 2.17124354e-02f, 1.38016343e-01f, 6.84877411e-02f,
  -1.19575504e-02f, 8.98274034e-03f, 6.29743636e-02f, 9.83545557e-02f, -9.45822150e-03f, 4.79127727e-02f, 9.36845541e-02f, -8.04466084e-02f, 2.75550201e-03f, -4.92769517e-02f,
  1.01884361e-03f, -2.87920572e-02f, 8.85937065e-02f, -3.60659440e-03f, -6.55743256e-02f, 1.52608072e-02f, 1.19170710e-01f, -9.70174074e-02f, -1.16634145e-02f, 1.72313896e-03f,
  -4.58304472e-02f, -4.19205017e-02f, -7.71611333e-02f, 6.15933239e-02f, -3.12571116e-02f, -1.30247355e-01f, -1.67757738e-02f, -1.08724885e-01f, -2.84659374e-03f, -8.58986825e-02f,
  5.65828606e-02f, -7.98583925e-02f, -1.20210061e-02f, 4.92415987e-02f, 5.35121225e-02f, 5.03471633e-03f, 4.39793058e-02f, -6.62983954e-03f, -7.57964253e-02f, 1.05209365e-01f,
  -8.42716545e-02f, -6.65344894e-02f, -5.37658706e-02f, -1.64875463e-01f, 3.62245888e-02f, -1.20934002e-01f, -4.90063392e-02f, 6.33959770e-02f, -3.08121350e-02f, -1.23450182e-01f,
  6.67471662e-02f, 9.20142084e-02f, 5.93427867e-02f, -1.14129014e-01f, 8.74765515e-02f, -4.98678349e-03f, 2.45908033e-02f, 4.42396104e-02f, 9.53086913e-02f, 2.84380652e-03f,
  3.91628258e-02f, -1.81472150e-03f, 7.10857883e-02f, -1.23255318e-02f, -3.85312662e-02f, 1.01623766e-01f, -1.02984615e-01f, -6.45784363e-02f, -5.26715778e-02f, 2.70652608e-03f,
  1.76714644e-01f, 7.03347987e-03f, 1.50747105e-01f, 2.22905586e-03f, 2.33647861e-02f, -4.79147173e-02f, -7.17308819e-02f, -2.67051179e-02f, -3.17266062e-02f, 8.15875903e-02f,
  -1.30231783e-01f, 8.16666633e-02f, -2.21576765e-02f, 8.40895995e-02f, -1.06681243e-01f, -1.33272663e-01f, -9.09279510e-02f, -5.99000510e-03f, 4.13272455e-02f, -1.21036261e-01f,
  -3.55934352e-02f, 1.45796046e-01f, -1.22368813e-01f, 4.43275608e-02f, 1.54172495e-01f, 1.47287771e-01f, -1.48622185e-01f, -9.79279578e-02f, 1.20015384e-03f, -9.57892686e-02f,
  -1.84362842e-04f, 1.18507132e-01f, -3.15106586e-02f, -1.51506796e-01f, -1.83896974e-01f, -1.20772824e-01f, -1.35116987e-02f, 1.40253171e-01f, 2.29615923e-02f, 2.57856995e-02f,
  3.16710323e-02f, -3.89980040e-02f, 1.15319587e-01f, -3.99752334e-03f, -7.92988166e-02f, -7.17248535e-03f, 2.80767772e-03f, -1.62370726e-01f, -1.35689997e-03f, -4.21873517e-02f,
  8.78304988e-02f, 6.89608743e-03f, 6.13762178e-02f, 7.22302049e-02f, -4.82953042e-02f, 5.78595214e-02f, -1.00672944e-02f, 1.15017675e-01f, -1.10252658e-02f, -5.47966957e-02f,
  -6.05798373e-03f, 9.65007171e-02f, 7.16556609e-02f, 4.96056629e-03f, 1.19693361e-01f, -3.55404317e-02f, 3.46131064e-02f, -2.87788231e-02f, -1.43974662e-01f, 2.39896210e-04f,
  1.11505073e-02f, -7.08129406e-02f, -9.10053700e-02f, 1.78245958e-02f, 7.09416941e-02f, 6.45969957e-02f, -8.12801942e-02f, 6.98727742e-02f, 5.86842634e-02f, 4.50629666e-02f,
  1.88683327e-02f, 3.20976637e-02f, 7.67036283e-04f, -2.92182099e-02f, -3.03948559e-02f, -6.75316304e-02f, -2.85319872e-02f, -4.11663912e-02f, 3.71238515e-02f, -3.97087112e-02f,
  -1.30205855e-01f, 2.66561750e-02f, 6.76573766e-03f, -7.74476454e-02f, -4.14772853e-02f, -6.90260530e-02f, -4.87128608e-02f, -3.49903628e-02f, 1.32337045e-02f, -1.07210070e-01f,
  9.84644890e-02f, 4.26511876e-02f, -2.34863181e-02f, -6.86194226e-02f, 4.88252845e-03f, -2.43107993e-02f, -5.27498610e-02f, -6.39491379e-02f, 4.31073047e-02f, -1.06783040e-01f,
  7.38656148e-02f, -3.43088363e-03f, 1.64224636e-02f, 3.76319923e-02f, -3.33184637e-02f, -1.03427134e-01f, -3.81238647e-02f, -4.67143469e-02f, -5.57156131e-02f, -8.17651227e-02f,
  8.95673335e-02f, 2.32724100e-02f, 5.25036864e-02f, 6.37151077e-02f, -9.98846665e-02f, 2.00928133e-02f, -1.00448728e-01f, -4.15923744e-02f, 4.24895547e-02f, 4.47667241e-02f,
  -2.90456298e-03f, -1.24979988e-01f, 3.76325175e-02f, -1.75065607e-01f, 2.75414041e-03f, 1.46964982e-01f, -1.36589199e-01f, 2.53353640e-02f, 7.00113624e-02f, 4.00312804e-02f,
  -8.27060640e-02f, 5.85094802e-02f, -2.39078272e-02f, 4.17574830e-02f, 1.58025727e-01f, 1.16323596e-02f, 5.51429391e-02f, 4.24890444e-02f, -2.63165012e-02f, 1.95351103e-03f,
  -4.21490185e-02f, -7.88325369e-02f, -2.99654454e-02f, 3.25657018e-02f, 4.32013758e-02f, -2.39557214e-02f, -1.01636596e-01f, -7.69321248e-02f, -8.58124942e-02f, -3.47099975e-02f,
  6.47868812e-02f, -7.91229829e-02f, 4.11611982e-02f, 1.07164599e-01f, -5.66908680e-02f, -2.02074386e-02f, -5.07047996e-02f, 2.85529019e-03f, -1.30246118e-01f, -6.10547140e-03f,
  7.53211901e-02f, -5.03683425e-02f, -1.72786713e-02f, -1.13233358e-01f, -4.16723229e-02f, -1.94329061e-02f, 1.20232508e-01f, -1.20441221e-01f, -1.38544356e-02f, 6.86823344e-03f,
  -1.23480177e-02f, -8.37323163e-03f, -1.48342643e-02f, -4.47687134e-02f, -3.31285857e-02f, 4.81845587e-02f, -6.90172166e-02f, -4.71581705e-02f, -7.87071064e-02f, 2.75322236e-02f,
  -5.96981384e-02f, -7.47907832e-02f, 5.57417655e-03f, -9.09562930e-02f, -7.21326768e-02f, 4.92312536e-02f, -6.29238784e-02f, 2.91873179e-02f, 8.94143879e-02f, 3.68613116e-02f,
  -9.12853777e-02f, 1.76118147e-02f, 1.38134211e-02f, -2.97482125e-02f, -7.53163919e-02f, -7.02500269e-02f, -1.70003567e-02f, -9.98274758e-02f, -4.43211496e-02f, 9.36032832e-02f,
  -7.23648071e-02f, -2.53529642e-02f, 8.32338631e-02f, 4.88792174e-03f, 2.62345392e-02f, -5.69754168e-02f, -6.92377388e-02f, -3.65369907e-03f, 2.04774402e-02f, 6.73810244e-02f,
  7.15442598e-02f, 1.05489425e-01f, -2.05870159e-02f, 2.71111988e-02f, 1.16499655e-01f, 6.55394867e-02f, -7.56932721e-02f, -8.66634026e-02f, -4.22874503e-02f, -2.14895383e-02f,
  -2.42870245e-02f, -9.40708816e-02f, 9.01475840e-04f, 2.38458961e-02f, -7.82471895e-02f, 9.01931152e-02f, 6.23950586e-02f, 6.73452020e-02f, 6.51982725e-02f, -1.08504985e-02f,
  9.09689963e-02f, -1.02732405e-01f, 1.31109739e-02f, 4.21908125e-02f, 1.67670436e-02f, -7.30230585e-02f, -1.15916230e-01f, -6.81350306e-02f, 1.29121216e-02f, 9.84204859e-02f,
  -5.37010049e-03f, -6.71183616e-02f, 2.76718270e-02f, -1.84105430e-02f, -1.50479019e-01f, 6.47124201e-02f, 1.56087562e-01f, 9.01623592e-02f, 4.77514081e-02f, 1.86470710e-02f,
  1.46931604e-01f, 1.12001151e-01f, -6.10459708e-02f, -4.63544801e-02f, 3.76017182e-03f, 1.56018212e-01f, -4.34305780e-02f, 1.40101194e-01f, -3.23331868e-03f, 9.96229500e-02f,
  -5.84711581e-02f, 9.91216768e-03f, -1.23904064e-01f, 2.44627558e-02f, -1.13143988e-01f, -9.73283127e-02f, 2.30206959e-02f, 8.94526690e-02f, -1.77197233e-01f, 2.20918190e-02f,
  -4.76641580e-03f, 6.88311458e-02f, 1.08936932e-02f, 7.46755674e-02f, -1.08564898e-01f, -5.06386794e-02f, -1.46993235e-01f, 1.30720571e-01f, -2.52233535e-01f, 2.58675916e-03f,
  -9.79338065e-02f, 1.68497264e-02f, -6.34406134e-02f, 2.39391886e-02f, 3.44645455e-02f, -8.74875560e-02f, -9.76767316e-02f, -1.24919027e-01f, -2.55940203e-02f, -5.53565435e-02f,
  1.71416234e-02f, -4.13057394e-02f, -4.90255766e-02f, -1.91768780e-01f, 4.88746911e-03f, 1.55775189e-01f, -4.94469181e-02f, 6.04409873e-02f, 9.01852623e-02f, -5.38032539e-02f,
  3.95337343e-02f, 6.52733678e-03f, -2.86068358e-02f, -2.02590730e-02f, 1.02303490e-01f, -6.85827881e-02f, 1.62081663e-02f, 1.16131809e-02f, 1.70445427e-01f, 2.43428163e-02f,
  -2.69910283e-02f, -5.50266691e-02f, -1.04370013e-01f, -1.09802037e-01f, -8.67308527e-02f, -3.44229080e-02f, 1.28633417e-02f, -2.57169753e-02f, -4.48574871e-02f, 4.77261916e-02f,
  9.62183699e-02f, 6.65867925e-02f, -5.02738319e-02f, 2.28006113e-02f, 4.02080566e-02f, -1.28690213e-01f, -1.21928461e-01f, 4.04052399e-02f, 7.14027211e-02f, -1.02282964e-01f,
  1.09856222e-02f, -7.18891695e-02f, 4.73443791e-02f, 1.40033802e-02f, -8.35214481e-02f, -6.95217922e-02f, -8.37311298e-02f, -9.10556242e-02f, -7.21706524e-02f, -5.24512120e-02f,
  7.34646320e-02f, -8.95442665e-02f, -2.85140108e-02f, 4.50300090e-02f, -3.27768698e-02f, -7.11974949e-02f, -1.86438654e-02f, 9.80154518e-03f, -2.61833947e-02f, -9.15998071e-02f,
  -6.07531667e-02f, 4.53365706e-02f, -6.00068904e-02f, -1.72632486e-02f, 7.12309107e-02f, 7.47606233e-02f, -4.72457297e-02f, -1.16461396e-01f, -5.48063591e-03f, -1.52475193e-01f,
  -2.64702328e-02f, -7.72606861e-03f, -1.03127278e-01f, 1.49584580e-02f, -7.09657967e-02f, 4.84451540e-02f, 1.48621462e-02f, 1.95994414e-02f, -1.89561164e-04f, -5.08664064e-02f,
  -7.06794187e-02f, -1.27532929e-01f, -1.53466225e-01f, -6.62589222e-02f, 2.15178147e-01f, 8.22479203e-02f, 1.14078782e-01f, 1.08457789e-01f, -1.30713329e-01f, -1.78065807e-01f,
  4.32161894e-03f, -2.41082124e-02f, 1.34886816e-01f, -1.45538598e-02f, -1.41196862e-01f, 1.73645858e-02f, -4.77472432e-02f, 8.94565582e-02f, -1.32304460e-01f, -1.17073528e-01f,
  -4.40579187e-03f, -2.34102346e-02f, -9.30835679e-03f, -9.43481252e-02f, -4.70407568e-02f, 1.83815897e-01f, -1.79936260e-01f, -3.26087885e-02f, 2.78733037e-02f, 5.05775325e-02f,
  -3.22755389e-02f, -8.04312900e-02f, 1.74384005e-02f, -6.10389113e-02f, 7.47197354e-03f, 7.39535913e-02f, -1.58600509e-01f, -9.65450555e-02f, -1.47672370e-01f, -4.22450937e-02f,
  1.63451642e-01f, 1.55750677e-01f, -6.08902313e-02f, 3.87393795e-02f, -6.22934997e-02f, -1.24425799e-01f, 4.83179688e-02f, -1.06114931e-01f, -8.76329541e-02f, -3.36614475e-02f,
  1.34607002e-01f, 2.24102079e-03f, -4.63656634e-02f, 9.03706551e-02f, 2.05903444e-02f, 4.08639945e-02f, 2.79967915e-02f, 5.51586971e-02f, 3.59876677e-02f, 4.10693623e-02f,
  1.46365926e-01f, 1.99076086e-02f, 6.03203960e-02f, -9.40354317e-02f, 8.49338248e-03f, 4.91757803e-02f, -4.85473638e-03f, 4.68355231e-03f, 1.03410721e-01f, 1.81689765e-02f,
  -1.29228309e-01f, 3.64881195e-02f, -8.22594613e-02f, -1.09877929e-01f, -9.56917405e-02f, -1.12586655e-01f, -7.71273226e-02f, 9.21286419e-02f, 1.08249234e-02f, -7.92751908e-02f,
  2.82726996e-03f, 5.08807693e-03f, -2.92468742e-02f, -8.16444680e-02f, -9.18179601e-02f, -2.33537182e-02f, -5.28671704e-02f, -2.73689348e-02f, -2.84990687e-02f, -5.87047860e-02f,
  -6.68269843e-02f, 4.10494115e-03f, 2.30472758e-02f, -2.11832346e-03f, -5.24235256e-02f, 3.43896188e-02f, -3.69280912e-02f, -4.32735868e-03f, -7.81479571e-03f, -1.24465022e-02f,
  -5.44161052e-02f, 4.08607163e-02f, -8.40155706e-02f, 4.03300002e-02f, 5.59385605e-02f, -2.38741897e-02f, -4.09134105e-02f, -1.50274746e-02f, -5.14549874e-02f, -4.14349735e-02f,
  2.27782670e-02f, -1.11581378e-01f, -3.21728475e-02f, 4.13270220e-02f, 2.53500417e-02f, -7.29140937e-02f, -1.13086149e-01f, -3.96492369e-02f, 3.26904990e-02f, -8.58377814e-02f,
  1.86016224e-02f, 1.15864922e-03f, -1.01817541e-01f, 3.36876623e-02f, -6.64157718e-02f, 3.03258235e-03f, -9.76412222e-02f, 3.89372669e-02f, -7.90523216e-02f, -1.02096885e-01f,
  1.81211717e-02f, -8.58210847e-02f, 1.20770507e-01f, -1.77969292e-01f, -1.74933895e-02f, -5.50271794e-02f, -5.11176065e-02f, -1.06847100e-01f, 1.18769079e-01f, 3.57154844e-04f,
  -2.25329585e-02f, -1.22850478e-01f, 2.13834662e-02f, -3.26810358e-03f, 3.34915742e-02f, -1.40145421e-01f, 1.05692312e-01f, -6.62057102e-02f, -4.10784362e-03f, -1.02482490e-01f,
  6.30025938e-02f, 5.32993451e-02f, 2.75580082e-02f, 4.22639698e-02f, 1.76560104e-01f, 5.16256168e-02f, 1.74582526e-02f, 7.80384466e-02f, 3.11254151e-02f, 1.75744630e-02f,
  6.29555583e-02f, 1.07799277e-01f, -3.36907096e-02f, 3.73347625e-02f, -1.52609590e-02f, -7.43773952e-03f, 1.59978554e-01f, 1.90271333e-01f, 7.58233294e-02f, 1.50526688e-01f,
  9.24462080e-02f, -1.00240432e-01f, -6.44320622e-02f, -3.01014557e-02f, -1.21971987e-01f, 6.07324839e-02f, -1.00566335e-01f, 4.20746766e-03f, 1.19285524e-01f, 1.61595047e-01f,
  -1.48176566e-01f, 6.65923953e-02f, 1.27899632e-01f, 5.72206415e-02f, -3.59540223e-03f, 4.86136824e-02f, 6.72421083e-02f, 8.42787176e-02f, 1.18457817e-01f, -9.52921901e-03f,
  -4.09412198e-02f, -6.46935925e-02f, 7.24834353e-02f, -7.70354718e-02f, -1.53621556e-02f, -6.73683435e-02f, -7.45123997e-02f, 2.29742611e-03f, 1.78574286e-02f, -5.91302291e-02f,
  -7.88416937e-02f, 8.87066275e-02f, 1.16091967e-01f, 1.00474380e-01f, -2.20058430e-02f, -2.50672400e-02f, -1.12534843e-01f, -2.40929704e-02f, 1.83424335e-02f, -7.46113136e-02f,
  1.82806812e-02f, 2.58702375e-02f, 2.44933069e-02f, -1.65465102e-02f, 5.00366613e-02f, 6.64130375e-02f, -8.01491365e-02f, -2.83541083e-02f, -1.02611721e-01f, -1.19976439e-01f,
  6.43965155e-02f, 4.91724089e-02f, -1.09027565e-01f, 6.57138228e-02f, -5.09659387e-02f, -8.24557543e-02f, -3.94724160e-02f, 4.26804740e-03f, 3.96206491e-02f, -5.92415370e-02f,
  1.03533171e-01f, -7.40193650e-02f, 2.73547731e-02f, 4.37814966e-02f, -6.22800924e-02f, -7.41690909e-03f, -2.15859078e-02f, -5.90262637e-02f, 4.48268205e-02f, 4.58036773e-02f,
  3.43576968e-02f, 7.08584487e-02f, -2.52332874e-02f, 3.45775820e-02f, -1.04335949e-01f, -9.48611274e-02f, 2.78176684e-02f, -1.25672100e-02f, 9.50493477e-03f, 1.45691708e-02f,
  6.28398880e-02f, 6.86298311e-02f, -4.78370152e-02f, 6.88744336e-02f, 1.53501956e-02f, -9.38932300e-02f, -3.60626429e-02f, -1.84651949e-02f, 3.86371762e-02f, 1.69127196e-01f,
  -1.92802045e-02f, 1.52917905e-02f, -4.36899066e-02f, -8.22509304e-02f, 1.07238196e-01f, -4.54243645e-02f, -2.83096340e-02f, -2.50021536e-02f, -2.83489041e-02f, -3.63765694e-02f,
  7.50862993e-04f, -3.75318788e-02f, -3.86515297e-02f, -8.51129964e-02f, 1.73771940e-02f, 5.33922240e-02f, 6.97364211e-02f, 6.66943043e-02f, -2.22386308e-02f, 6.55056834e-02f,
  4.59462367e-02f, -3.40811461e-02f, 1.01176992e-01f, -1.87382400e-02f, 1.31807150e-02f, -8.02666396e-02f, 1.09645389e-01f, 1.08944476e-01f, 6.69338778e-02f, 4.28001210e-02f,
  -2.44260784e-02f, 3.33361477e-02f, 1.74207985e-01f, 8.44643116e-02f, 2.44446285e-02f, -2.70044804e-02f, -1.01070181e-01f, -6.49225116e-02f, 8.49950537e-02f, 6.42598197e-02f,
  -9.27628800e-02f, -1.91681106e-02f, -1.48643062e-01f, -5.02071306e-02f, -1.64038539e-02f, -1.56751215e-01f, -2.32854895e-02f, 1.26609616e-02f, 3.13983969e-02f, -1.93180563e-03f,
  -4.94284928e-02f, -4.42479998e-02f, 8.33841190e-02f, -2.10473929e-02f, 9.24624205e-02f, 7.00232685e-02f, -1.12828575e-01f, 3.14528011e-02f, -8.65802839e-02f, 4.48060818e-02f,
  5.44685014e-02f, -1.72497742e-02f, -1.39578640e-01f, 5.30250650e-03f, -1.31485667e-02f, 2.49046590e-02f, -3.19485031e-02f, 8.65062326e-02f, -3.48284915e-02f, 4.08621505e-02f,
  1.35250181e-01f, 4.03501764e-02f, -5.50052198e-03f, -7.70349950e-02f, -7.92106986e-02f, -7.94466138e-02f, 1.69046540e-02f, -8.28272253e-02f, 1.05852678e-01f, -6.56235516e-02f,
  -3.15905549e-02f, -7.88748190e-02f, -8.39510858e-02f, -1.11671768e-01f, 4.49092649e-02f, -3.04940101e-02f, 2.54644826e-02f, 4.49661314e-02f, 2.24105995e-02f, 6.36343658e-02f,
  4.01569381e-02f, -4.53346297e-02f, 8.29627961e-02f, 7.04041421e-02f, 3.95550430e-02f, -5.59160160e-03f, -7.22637475e-02f, 2.89370399e-02f, 8.54863450e-02f, 1.37359025e-02f,
  -3.37282345e-02f, -1.04265362e-01f, 8.01661685e-02f, 7.30859265e-02f, 2.27937922e-02f, 4.36561145e-02f, -4.29534540e-02f, -9.47255343e-02f, -9.29949582e-02f, 3.84361632e-02f,
  5.80724068e-02f, 8.73257071e-02f, 6.33266866e-02f, -6.26904517e-02f, 4.12968546e-02f, 4.27859649e-02f, -4.43772115e-02f, -4.62598763e-02f, 3.89913991e-02f, 5.91587052e-02f,
  -2.05698386e-02f, 1.00831280e-03f, -5.48400683e-03f, -3.50605510e-02f, -9.45597813e-02f, 1.55314086e-02f, -1.21624716e-01f, 7.27526052e-03f, -3.20149399e-02f, 2.69030780e-02f,
  9.34597999e-02f, -9.82409418e-02f, 1.20223969e-01f, 4.41371575e-02f, -6.16875924e-02f, 1.19965799e-01f, -6.45029694e-02f, -4.52083200e-02f, -7.64873922e-02f, 4.47799405e-03f,
  -3.12068537e-02f, -4.08377200e-02f, 7.07952753e-02f, -3.28307087e-03f, -5.59404977e-02f, -6.34847730e-02f, -9.12015066e-02f, 2.14242633e-03f, 2.26629097e-02f, 1.34044245e-01f,
  1.67895202e-02f, -1.98035669e-02f, 2.23425347e-02f, 8.39720815e-02f, -3.57539468e-02f, 6.61117136e-02f, 3.65205035e-02f, 3.75578478e-02f, 2.40085088e-03f, 3.62809449e-02f,
  -7.90080503e-02f, -4.39379876e-03f, 1.49301272e-02f, 6.48845509e-02f, -8.33065733e-02f, 2.96690073e-02f, 1.90571081e-02f, 3.46332863e-02f, -8.68063793e-02f, -2.06835177e-02f,
  6.98330179e-02f, 1.46384286e-02f, -4.68092337e-02f, 8.53368491e-02f, 3.23563628e-02f, -1.72624096e-01f, 1.22570582e-02f, 4.63073216e-02f, -7.70368129e-02f, -3.08421496e-02f,
  -7.34531283e-02f, 7.79581293e-02f, 6.16438575e-02f, 5.22997975e-02f, -8.70764777e-02f, 1.17471598e-01f, 4.87684421e-02f, 5.18344007e-02f, -7.74171203e-02f, 4.70740721e-03f,
  4.83105108e-02f, 5.57279289e-02f, -6.16708770e-02f, -7.13053197e-02f, -1.39835114e-02f, 1.28692035e-02f, -7.51861781e-02f, 7.83139840e-02f, -5.61379790e-02f, 4.67645600e-02f,
  -1.21369306e-02f, 4.73424718e-02f, 8.37600753e-02f, -4.96933348e-02f, -2.86959540e-02f, -1.64271202e-02f, -1.65335655e-01f, -1.46548562e-02f, -5.53482175e-02f, -4.55278084e-02f,
  9.26528871e-02f, 8.83828327e-02f, -3.25067565e-02f, -1.88572593e-02f, 2.83349697e-02f, -1.14588663e-01f, -2.51001175e-02f, 1.15531452e-01f, -1.70406535e-01f, -4.98663560e-02f,
  2.50308756e-02f, 3.13284360e-02f, 3.63103114e-02f, 9.87191424e-02f, -1.28634647e-01f, -1.59147400e-02f, 7.92287663e-02f, -3.44880149e-02f, -4.30548191e-02f, -8.42769444e-03f,
  1.26174288e-02f, -4.63953707e-03f, 3.54083627e-02f, -1.07123196e-01f, -1.02379993e-01f, 7.06769153e-02f, 9.24207792e-02f, 1.08364493e-01f, -2.28601554e-03f, 3.70153375e-02f,
  -1.38445184e-01f, -1.14374131e-01f, -2.88001765e-02f, -6.34985119e-02f, -8.45754296e-02f, -4.10188027e-02f, 9.98010635e-02f, -4.24161702e-02f, 4.09864672e-02f, 9.30961072e-02f,
  -4.06132266e-02f, 2.35633161e-02f, 4.18418795e-02f, -5.54062761e-02f, 4.71443236e-02f, 1.73880339e-01f, 1.05752654e-01f, -6.11263029e-02f, -2.80751977e-02f, 1.64198480e-03f,
  4.03621346e-02f, 5.44756576e-02f, 1.03815019e-01f, 5.77165522e-02f, 1.02385439e-01f, 9.35232416e-02f, 5.57199214e-03f, 6.21857774e-03f, -9.34779420e-02f, -8.73694420e-02f,
  -1.02871634e-01f, -9.72863361e-02f, 1.98633000e-01f, 1.09285973e-01f, -1.83614939e-02f, -9.06487405e-02f, 2.47493070e-02f, -7.69437999e-02f, -5.28416708e-02f, -1.08131357e-01f,
  -1.03845678e-01f, -2.89139408e-03f, 8.30438808e-02f, -7.12016225e-02f, -3.89789604e-02f, 7.34056383e-02f, -1.34825274e-01f, -7.64426216e-02f, 9.73972827e-02f, 5.00130318e-02f,
  -5.49848936e-02f, 2.69142026e-03f, -6.86301142e-02f, -5.55831566e-02f, -2.63561644e-02f, 6.82815686e-02f, -4.24687713e-02f, 1.14584090e-02f, -7.21600428e-02f, -1.47485986e-01f,
  1.17098764e-02f, -9.29084718e-02f, -9.37310383e-02f, -3.40940021e-02f, 7.40620121e-02f, -2.54985020e-02f, -4.28018235e-02f, -2.09583510e-02f, 1.49000138e-01f, 9.46284756e-02f,
  -2.90102675e-03f, 1.14086352e-01f, -4.04210798e-02f, -2.60444600e-02f, 2.91216299e-02f, -8.53215456e-02f, 3.95165337e-03f, -9.60315466e-02f, -1.61366463e-02f, -8.40836838e-02f,
  8.89395922e-02f, -1.60930399e-02f, -3.57189327e-02f, 8.10527802e-02f, 4.40604202e-02f, -4.32805484e-03f, 1.63927868e-01f, -5.92698976e-02f, -8.70117769e-02f, -5.26961163e-02f,
  -1.23862512e-01f, -1.39223028e-03f, 8.02769735e-02f, 5.07007800e-02f, -7.73715302e-02f, 6.32227492e-03f, -8.39445218e-02f, 7.17642456e-02f, 9.98634323e-02f, 1.27934322e-01f,
  -6.67945594e-02f, -2.65507810e-02f, 1.68179329e-02f, -4.60949093e-02f, 5.78936115e-02f, 8.22053328e-02f, 2.08397098e-02f, -2.42560785e-02f, -1.19058024e-02f, 4.52170931e-02f,
  -1.16354357e-02f, -3.48906405e-02f, 9.29984450e-03f, -8.20085853e-02f, 8.58167410e-02f, 3.09953485e-02f, -1.14664346e-01f, 8.90383963e-03f, 9.90907778e-04f, 2.90552061e-02f,
  -2.65776645e-03f, 3.46401297e-02f, 3.02015748e-02f, -2.06702705e-02f, -6.86119646e-02f, -2.57783895e-03f, 4.71724235e-02f, -8.39042142e-02f, -2.79555898e-02f, 6.62524998e-02f,
  6.05849512e-02f, 6.16489723e-02f, 1.30719513e-01f, 8.01965073e-02f, 1.39696687e-01f, 9.81216319e-03f, -2.10130922e-02f, -6.96384981e-02f, 2.26956140e-02f, 8.01273361e-02f,
  -2.80986028e-03f, 8.32354575e-02f, 1.40557572e-01f, 1.71642721e-01f, 7.58522972e-02f, -1.09979577e-01f, -7.65498281e-02f, -2.74364557e-03f, 1.07737400e-01f, 1.06790826e-01f,
  1.81517571e-01f, 2.25883462e-02f, 2.03279164e-02f, 1.67932790e-02f, 2.28825845e-02f, -1.29389584e-01f, -7.40101933e-03f, 4.56423173e-03f, 8.04051682e-02f, 8.46408755e-02f,
  7.47933984e-02f, 1.22608535e-01f, 1.97506800e-01f, -1.05023809e-01f, -9.02384520e-02f, -1.49471298e-01f, 1.96417376e-01f, -2.14650631e-02f, -1.76261425e-01f, -2.22975039e-03f,
  2.41048068e-01f, 2.64607575e-02f, -1.08144201e-01f, 4.11022594e-03f, -1.54271796e-01f, -5.87356165e-02f, 1.51023135e-01f, 9.29405466e-02f, 1.60773814e-01f, 1.61626220e-01f,
  1.38277123e-02f, -4.08186726e-02f, 1.58090085e-01f, -1.27899453e-01f, 1.81540439e-03f, 1.05163187e-01f, -1.32939100e-01f, -1.04378134e-01f, -9.44582596e-02f, 3.23051289e-02f,
  7.83889294e-02f, -2.32173689e-02f, -9.40062627e-02f, 2.67977864e-02f, -9.99776646e-02f, -3.77129838e-02f, 6.35178462e-02f, 3.81843038e-02f, 8.96036327e-02f, 3.12812887e-02f,
  -1.48589432e-01f, -1.33504316e-01f, -2.88366154e-02f, 2.27600932e-02f, 5.64632639e-02f, -3.06810420e-02f, -1.35748893e-01f, -5.62316403e-02f, 2.38159560e-02f, -5.24502620e-02f,
  4.75712083e-02f, 6.99905753e-02f, 9.01553556e-02f, -4.33158316e-02f, 1.31963417e-01f, 6.32800385e-02f, -3.05927042e-02f, 4.79328632e-02f, -9.48740914e-03f, 2.26993263e-02f,
  -7.33110234e-02f, -1.06895308e-03f, -2.04570852e-02f, 9.22727734e-02f, 6.00312874e-02f, 2.43857224e-02f, 1.88906714e-02f, 1.43757304e-02f, 4.00406048e-02f, 5.37607521e-02f,
  -3.68930250e-02f, 3.39687876e-02f, 8.16881582e-02f, 1.37865532e-03f, 7.95357376e-02f, -6.63219765e-02f, -9.32299253e-03f, -7.87565559e-02f, 2.26813331e-02f, -9.04104263e-02f,
  5.52896149e-02f, -4.09285054e-02f, 2.96092145e-02f, 9.06244069e-02f, -8.32335129e-02f, 1.60263553e-02f, 6.06468953e-02f, -1.65385287e-02f, 1.18247746e-02f, 8.53559002e-02f,
  -7.27033094e-02f, -2.50925422e-02f, -5.27496003e-02f, 1.31628975e-01f, 1.74225378e-03f, -4.85865138e-02f, 2.94866953e-02f, -1.43570369e-02f, 7.41993263e-02f, -3.84447798e-02f,
  -7.65158683e-02f, -7.57156909e-02f, 1.82875469e-02f, -1.07929343e-02f, -8.25928301e-02f, -5.28992116e-02f, -5.89060318e-03f, -1.04018562e-01f, -3.98954935e-02f, -2.46018786e-02f,
  -4.89346758e-02f, -1.12086935e-02f, -1.96456462e-02f, -8.57810974e-02f, -5.31383464e-03f, 1.42965997e-02f, 1.52623385e-01f, 2.13815972e-01f, -1.46254808e-01f, 3.82206328e-02f,
  -7.12151602e-02f, 8.80720839e-02f, -8.67486447e-02f, 1.01074919e-01f, -7.94729963e-02f, 3.42471828e-03f, 6.10972941e-02f, 1.74041376e-01f, -1.10975169e-01f, -5.45769110e-02f,
  -7.74824470e-02f, -2.00059831e-01f, 1.03817597e-01f, -4.60981131e-02f, -1.68609377e-02f, -8.61040056e-02f, -6.11355677e-02f, -8.25912505e-02f, 8.99165645e-02f, 2.87859496e-02f,
  -2.36919392e-02f, -2.43888665e-02f, -4.25202698e-02f, 1.36429444e-01f, -1.38663605e-01f, -1.57109406e-02f, 5.27211353e-02f, 7.80598596e-02f, -2.92760670e-01f, -9.02318358e-02f,
  3.75563055e-02f, -2.01617047e-01f, -5.23854326e-03f, 1.91594362e-01f, -2.96644662e-02f, 1.32568896e-01f, -6.01258576e-02f, 2.63174176e-02f, -8.98050293e-02f, -2.39589348e-01f,
  1.69709012e-01f, 1.58661425e-01f, -2.82953884e-02f, -1.65345594e-02f, 4.44806665e-02f, -5.89887612e-03f, 3.99737507e-02f, -1.09975841e-02f, -2.03030974e-01f, 1.06108755e-01f,
  -3.43772396e-02f, -7.74049163e-02f, -1.61216587e-01f, -6.50864989e-02f, -3.74058373e-02f, 4.13678102e-02f, -1.15140729e-01f, 9.23690051e-02f, 9.71864238e-02f, -4.59015705e-02f,
  1.02602504e-01f, 1.23037491e-02f, -4.03432176e-02f, 6.54368028e-02f, -3.06280795e-02f, -2.68207397e-03f, 1.20819174e-01f, 1.07393034e-01f, -7.71488473e-02f, 4.45071757e-02f,
  -3.11393235e-02f, -1.30405113e-01f, 3.02436296e-02f, 7.48448372e-02f, -1.12108653e-02f, -8.45182762e-02f, 1.97417382e-02f, 5.77643663e-02f, 3.83155830e-02f, 5.00631146e-02f,
  -8.60183127e-03f, -1.27696469e-01f, 8.15641806e-02f, 4.13966700e-02f, 4.14049998e-02f, -1.81245208e-02f, -6.74549192e-02f, -1.03452824e-01f, -2.32920758e-02f, 4.55188230e-02f,
  6.27056211e-02f, -9.20304358e-02f, -1.70783456e-02f, -6.61629811e-02f, -1.16610667e-02f, -7.85480216e-02f, 1.37029234e-02f, 7.73214325e-02f, 4.71690223e-02f, -2.47057732e-02f,
  -3.08275614e-02f, -9.33923051e-02f, 1.94368195e-02f, -8.63486528e-02f, 2.03333292e-02f, -4.46668081e-02f, 2.29028221e-02f, -4.01879149e-03f, -6.14290424e-02f, 3.30829136e-02f,
  2.17218767e-03f, -1.53456163e-02f, 4.86526415e-02f, 1.34089487e-02f, -4.28464226e-02f, 1.05734384e-02f, -2.83144992e-02f, -5.69614507e-02f, -1.46225775e-02f, -2.56611612e-02f,
  1.98407639e-02f, 9.18279514e-02f, 6.90954179e-02f, -9.73316841e-03f, 9.85790715e-02f, -6.85770437e-02f, -1.61542043e-01f, 6.67340215e-03f, -8.74481797e-02f, 5.08421920e-02f,
  -1.65099517e-01f, 1.00052617e-01f, -8.82958546e-02f, -8.04950856e-03f, -4.84370515e-02f, -1.31103531e-01f, -3.29773165e-02f, 1.97203830e-02f, 7.88431466e-02f, -2.73398608e-02f,
  -5.40645532e-02f, 1.17272861e-01f, -6.55081794e-02f, -3.01966891e-02f, 4.49464135e-02f, 1.01184316e-01f, -1.81545824e-01f, 1.00705056e-02f, -3.01866047e-02f, -8.84615332e-02f,
  1.03144713e-01f, 8.92279372e-02f, -5.36252856e-02f, -8.46002623e-02f, -1.72506645e-01f, -7.04422072e-02f, -7.34314322e-02f, 6.87529296e-02f, -2.05526669e-02f, 2.91371513e-02f,
  1.16110500e-02f, -1.17063895e-02f, 8.30013305e-02f, -7.07941502e-02f, -6.86867014e-02f, 4.14114259e-02f, 1.37470201e-01f, -4.56162505e-02f, -6.53019920e-03f, -8.86178464e-02f,
  1.02703497e-02f, -7.41355643e-02f, 5.34890220e-02f, -2.25131810e-02f, 3.04663088e-02f, -7.51747936e-02f, 3.78077962e-02f, 5.05610220e-02f, -5.75992465e-02f, -2.29692683e-02f,
  -5.99773191e-02f, 9.56100821e-02f, 2.64672749e-02f, 8.91922265e-02f, -4.30259518e-02f, 5.56517504e-02f, 5.40012121e-02f, 6.67215958e-02f, 3.86178084e-02f, 3.12296092e-04f,
  -1.22126630e-02f, 2.40870155e-02f, 7.92177022e-02f, 3.62604298e-02f, 1.57205448e-01f, -2.75406111e-02f, -3.60477008e-02f, 6.88695163e-02f, 9.12470296e-02f, -2.58476678e-02f,
  2.16497332e-02f, 5.29639376e-03f, 4.63454090e-02f, -8.56537968e-02f, -4.35462072e-02f, 3.77562791e-02f, -4.44148928e-02f, 2.23205499e-02f, 2.01112647e-02f, 3.11779361e-02f,
  3.84025685e-02f, -4.80043106e-02f, -2.54569668e-02f, 3.13217426e-03f, 6.41768649e-02f, -4.81664576e-02f, 5.88908978e-03f, -5.87873496e-02f, 6.13414645e-02f, -9.41189677e-02f,
  -8.27466697e-02f, 1.80496965e-02f, -5.97193763e-02f, 4.20533605e-02f, -6.28486201e-02f, -2.46284381e-02f, 8.01875070e-02f, 1.13330167e-02f, -3.89879569e-02f, 1.03741502e-02f,
  -4.68074121e-02f, -2.05443818e-02f, 6.46942575e-03f, 1.91232413e-02f, -9.01088044e-02f, -1.16216494e-02f, -9.38707776e-03f, 2.30281465e-02f, 7.02929171e-03f, -7.46149197e-02f,
  -6.41730428e-02f, 2.14490388e-02f, 2.40729726e-03f, -6.74143583e-02f, 1.30436588e-02f, 6.08128421e-02f, -7.02141086e-03f, -2.97184493e-02f, 1.12177998e-01f, 1.15588658e-01f,
  1.10814743e-01f, 1.35974539e-02f, 1.59837771e-03f, -6.84106648e-02f, 1.12658165e-01f, -1.63391605e-02f, -2.12184861e-02f, 2.88297497e-02f, 3.50194424e-02f, 5.57719506e-02f,
  -2.01358665e-02f, 1.11380823e-01f, 7.31333718e-02f, -3.99681879e-03f, -1.03656938e-02f, 2.58313436e-02f, -6.35330752e-02f, -4.03858572e-02f, -6.41300529e-02f, -2.58354787e-02f,
  6.12554625e-02f, 4.32941020e-02f, -6.36642054e-02f, -6.00973219e-02f, 9.57429558e-02f, 2.74345595e-02f, -1.21262074e-01f, -8.92596841e-02f, 8.50320328e-03f, -1.12568326e-02f,
  -9.09863263e-02f, -6.99355304e-02f, 7.24973455e-02f, -9.24798250e-02f, 1.00104585e-01f, 2.52240035e-03f, 6.76593706e-02f, 3.41184041e-03f, 6.60644025e-02f, -8.23506117e-02f,
  1.39597505e-02f, -5.49224317e-02f, 1.50671871e-02f, 4.59984355e-02f, -2.46544406e-02f, 9.45881829e-02f, -8.05537254e-02f, 1.51739158e-02f, 6.63173422e-02f, 4.90577370e-02f,
  9.08393934e-02f, 6.14246577e-02f, 3.40590952e-03f, -6.05559908e-02f, -2.79192701e-02f, 9.10852700e-02f, -2.27082781e-02f, -2.09050309e-02f, -5.02263121e-02f, -8.09138119e-02f,
  2.61967108e-02f, -5.67012758e-04f, 3.85050885e-02f, 7.47301755e-03f, -5.62869199e-02f, 8.60879868e-02f, -9.30339992e-02f, 3.55008133e-02f, -3.47947441e-02f, -1.18307220e-02f,
  -3.45819630e-02f, 1.36826616e-02f, -1.03143208e-01f, 2.74291970e-02f, 6.34320974e-02f, -6.35583028e-02f, -2.24742610e-02f, 8.06630626e-02f, -9.50422958e-02f, -6.20120438e-03f,
  3.88033576e-02f, 8.71133432e-02f, -4.24116664e-02f, 5.89457564e-02f, 3.30763049e-02f, -2.00291164e-02f, 7.68363178e-02f, 1.38982430e-01f, -8.10863599e-02f, 5.02767041e-03f,
  -4.41185907e-02f, 1.05168484e-01f, 1.65505946e-01f, -9.51290503e-03f, -9.19501930e-02f, 7.97828436e-02f, 5.61102368e-02f, -6.49513816e-03f, 9.49004814e-02f, 5.98954968e-03f,
  7.64679164e-02f, 1.07312106e-01f, 7.84206390e-03f, -8.34314898e-02f, -5.34895137e-02f, 2.94242725e-02f, -5.09372838e-02f, 6.64337054e-02f, 9.00246575e-02f, 5.09421015e-03f,
  8.11573491e-02f, -1.31397729e-03f, -2.35612169e-02f, -2.67453697e-02f, 9.05435011e-02f, 1.27372332e-02f, 7.65725970e-02f, -9.59123001e-02f, 8.14524665e-02f, 2.79501476e-03f,
  8.95317718e-02f, 1.18162856e-01f, -6.79820552e-02f, 1.03036687e-01f, 5.28798066e-02f, 1.77203119e-01f, 1.95164949e-01f, 1.57057479e-01f, 9.33713615e-02f, 6.13985732e-02f,
  -6.29136339e-03f, -1.75551876e-01f, 4.55937646e-02f, 1.50530696e-01f, 4.69349651e-03f, 1.44100025e-01f, -1.67009085e-01f, -4.94538173e-02f, -1.01593599e-01f, 2.58235842e-01f,
  -5.44479191e-02f, -5.93382120e-02f, -2.00861841e-02f, 2.49768626e-02f, -1.10095963e-01f, -2.35539861e-02f, -7.57677108e-02f, -6.87003732e-02f, -4.75118086e-02f, 8.81062299e-02f,
  9.78094265e-02f, -4.79742847e-02f, -1.88210066e-02f, -5.94176017e-02f, -1.20589256e-01f, -1.20015733e-01f, -1.14298999e-01f, -1.01162083e-01f, 1.45520121e-01f, -5.56032062e-02f,
  -8.09234083e-02f, -6.20766059e-02f, -9.00343955e-02f, -4.28812429e-02f, 1.00538312e-02f, 1.67292580e-01f, -8.33379775e-02f, 3.70165855e-02f, 8.79618675e-02f, -5.30331221e-04f,
  5.68443500e-02f, -1.29988194e-01f, -1.48467556e-01f, -1.48196325e-01f, 1.45576328e-01f, 3.26850358e-03f, -6.27475791e-04f, 4.70302254e-02f, -8.76837447e-02f, -2.35187579e-02f,
  -7.48524144e-02f, -5.53551018e-02f, 3.00674289e-02f, -2.83489600e-02f, 1.12691030e-01f, -3.78552079e-02f, 3.16287465e-02f, 1.90221649e-02f, 7.74667561e-02f, 1.06436806e-02f,
  9.38012451e-03f, 3.75234485e-02f, 1.73923410e-02f, 6.82545528e-02f, -1.16248764e-01f, -4.65305559e-02f, -1.05518982e-01f, 1.16844254e-03f, -7.07953889e-03f, -2.12337337e-02f,
  8.45145136e-02f, -6.31070212e-02f, -4.47767898e-02f, 3.40697728e-03f, -1.00699039e-02f, 9.01951343e-02f, -4.68690693e-02f, -2.63798963e-02f, -3.07804476e-02f, 1.08067647e-01f,
  6.27129301e-02f, 5.57703562e-02f, 7.45175406e-02f, -2.19300319e-03f, -5.29630631e-02f, 5.49516641e-02f, 9.14858282e-03f, 9.31242630e-02f, 5.30364513e-02f, -1.71062589e-01f,
  -1.29436985e-01f, -6.36947667e-03f, -1.74919367e-01f, -1.19060196e-01f, 3.32718082e-02f, 9.81233865e-02f, 3.47024240e-02f, 8.43150914e-03f, 5.34528494e-02f, 9.76015925e-02f,
  -6.39579818e-02f, 2.48569231e-02f, 9.18237045e-02f, -4.05964591e-02f, -1.09619603e-01f, -1.27978981e-01f, -4.91040200e-03f, 1.10869221e-01f, 3.65053378e-02f, 1.91246927e-01f,
  -6.43546656e-02f, 7.81651121e-03f, 7.97266886e-02f, 8.48954096e-02f, -7.09238648e-02f, -5.27633652e-02f, 1.26039580e-01f, 4.29816730e-02f, -1.09935924e-01f, 5.96591551e-03f,
  4.59964052e-02f, 7.47707188e-02f, 1.68184102e-01f, 3.29801030e-02f, 5.23281693e-02f, -1.30361896e-02f, -2.17747521e-02f, 9.71617270e-03f, -1.15144283e-01f, 3.61627191e-02f,
  5.40946890e-03f, -1.54564977e-01f, -1.38019353e-01f, -1.23987488e-01f, 6.29210472e-02f, -5.74533008e-02f, 4.16273922e-02f, -1.02144793e-01f, -1.50304526e-01f, -4.06404324e-02f,
  -8.41347780e-03f, -5.51609248e-02f, 1.96026444e-01f, -1.30043924e-01f, 8.31706356e-03f, -1.00842454e-01f, 1.39916092e-01f, -2.04851851e-01f, -4.59860498e-03f, 6.81856321e-03f,
  -3.99865434e-02f, -1.89437181e-01f, 3.80289108e-02f, 1.90134719e-02f, 1.53453961e-01f, -8.07690993e-03f, 1.87575385e-01f, 7.22402260e-02f, -2.52100336e-03f, 3.51872593e-02f,
  1.47231311e-01f, 1.37376368e-01f, 6.56216731e-03f, 6.58915341e-02f, 8.31789300e-02f, -4.97939959e-02f, 5.71600422e-02f, -1.91196114e-01f, -1.67274788e-01f, 2.67822780e-02f,
  2.14863256e-01f, -2.74704043e-02f, -1.36108428e-01f, -2.77356543e-02f, 6.42850250e-02f, -1.13129420e-02f, -9.25853774e-02f, -4.16308194e-02f, 2.45963782e-02f, -6.81049526e-02f,
  -6.43360689e-02f, 6.01143427e-02f, -3.24443053e-03f, 6.78951815e-02f, -1.10536531e-01f, 1.00908251e-02f, -1.11960538e-01f, -7.51557574e-02f, -8.72259885e-02f, 7.11371889e-03f,
  1.18556432e-01f, 4.08745147e-02f, -3.45147923e-02f, 7.16266558e-02f, 8.55293199e-02f, -8.83557200e-02f, 8.36285874e-02f, 3.71185243e-02f, -1.26613425e-02f, -2.92210691e-02f,
  1.23561233e-01f, 4.10131551e-02f, -4.54039350e-02f, -8.51518288e-02f, 8.04535896e-02f, -9.95507836e-02f, -4.85819913e-02f, -3.93212307e-03f, -4.26871181e-02f, -9.91410688e-02f,
  -3.19303423e-02f, -6.37321323e-02f, 8.74345973e-02f, 1.01641022e-01f, -6.43909425e-02f, 1.11445464e-01f, 5.37821874e-02f, 1.27782365e-02f, -4.44679596e-02f, -1.57963559e-02f,
  -5.55029176e-02f, -5.07992879e-02f, -4.61230911e-02f, 2.49920357e-02f, 7.79405311e-02f, -7.80833289e-02f, -2.94119511e-02f, -9.77957025e-02f, 1.62559479e-01f, -7.73659497e-02f,
  1.81800500e-02f, -1.18080735e-01f, -3.78176607e-02f, 6.99192807e-02f, -7.56895319e-02f, -7.96819404e-02f, 6.05494203e-03f, 3.02516595e-02f, 1.13440081e-02f, -1.02326209e-02f,
  -8.42634737e-02f, 6.79555535e-02f, 4.57068272e-02f, 7.80095533e-02f, 6.01713359e-03f, 9.97016355e-02f, 1.81511007e-02f, 9.15471315e-02f, -9.51059684e-02f, -6.82466477e-02f,
  -1.57119498e-01f, -1.30414933e-01f, 9.37119871e-02f, -9.52047631e-02f, -5.54283224e-02f, -3.26627903e-02f, -1.36676744e-01f, -2.14486599e-01f, 3.07064671e-02f, 1.40675709e-01f,
  -2.15164348e-02f, -8.02471070e-04f, -2.52494104e-02f, 6.83240667e-02f, 1.20785221e-01f, -3.59392241e-02f, 3.98643985e-02f, -6.28062859e-02f, 1.62100554e-01f, -2.10073888e-01f,
  2.36867219e-01f, 4.14421335e-02f, -1.03755914e-01f, 1.24974817e-01f, 1.23276122e-01f, -1.17101505e-01f, 7.51960874e-02f, 2.14233659e-02f, -8.15507546e-02f, -3.60856652e-02f,
  2.09007561e-01f, 3.08655612e-02f, 1.47355586e-01f, 1.18502304e-01f, 8.67437869e-02f, -1.99730664e-01f, -5.93226850e-02f, 1.63128022e-02f, -8.72058142e-03f, 3.45188469e-01f,
  -8.71649161e-02f, 3.93713854e-04f, -7.01451674e-02f, 7.66042247e-02f, -8.53239074e-02f, -1.39814690e-01f, -1.73174649e-01f, 1.91819027e-01f, 1.90011576e-01f, 6.32308796e-03f,
  -1.84735283e-01f, -2.95571014e-02f, -2.68817395e-02f, 1.15207739e-01f, 1.39056332e-02f, -8.51785857e-03f, 2.76776310e-02f, -4.68072519e-02f, 6.40079845e-03f, -8.88619479e-03f,
  -3.82598042e-02f, 1.74607672e-02f, 1.17182724e-01f, 3.40320580e-02f, -1.09729782e-01f, -7.62209892e-02f, 3.81691493e-02f, -9.99970734e-02f, 3.35260555e-02f, -8.07936341e-02f,
  -6.97397888e-02f, -4.26175408e-02f, 9.23093259e-02f, 5.98020479e-02f, 6.12210445e-02f, 8.77385587e-02f, 5.91632165e-02f, -9.23822224e-02f, -1.14513688e-01f, 7.55997524e-02f,
  -8.43034014e-02f, -1.01286300e-01f, -4.82737124e-02f, -9.26444158e-02f, 7.15117306e-02f, 7.32428394e-03f, 8.31912458e-02f, -8.63949675e-03f, -8.61873180e-02f, -4.82096672e-02f,
  4.71323095e-02f, -3.95083688e-02f, -1.26459181e-01f, 5.47505915e-02f, 2.14039814e-02f, 3.25309783e-02f, -2.12174095e-02f, -4.91478071e-02f, 2.70324312e-02f, 4.36515920e-03f,
  2.65249647e-02f, -1.46599442e-01f, -3.44819613e-02f, 5.90242408e-02f, -1.96013786e-02f, -8.37473944e-02f, 6.94927424e-02f, -7.20445160e-03f, -5.46780527e-02f, 1.09500378e-01f,
  -5.98476194e-02f, -9.54167694e-02f, -1.76727492e-02f, -5.92212901e-02f, 6.59427196e-02f, -1.04535080e-01f, 2.84060147e-02f, -9.51071233e-02f, -1.07433625e-01f, -8.31700340e-02f,
  -8.50289762e-02f, 1.18573099e-01f, -9.08154398e-02f, 5.36800139e-02f, -8.55441093e-02f, -4.39629890e-02f, -1.19622208e-01f, 2.73787905e-03f, -7.15488568e-02f, -1.51812330e-01f,
  5.18466160e-02f, 1.10446796e-01f, -6.24829764e-03f, -9.94492695e-02f, -5.65015972e-02f, -1.09778628e-01f, -1.24014132e-01f, -3.61369103e-02f, -1.72618497e-02f, -2.50510219e-02f,
  1.47682354e-01f, 6.68862835e-02f, -2.23565474e-02f, -2.36170515e-02f, 5.84864356e-02f, -1.49560869e-01f, 6.33798027e-03f, 9.73023623e-02f, 6.29256538e-04f, -1.93976648e-02f,
  1.01832129e-01f, 1.49824247e-01f, -1.21247573e-02f, -8.30912776e-03f, -5.19888662e-02f, 9.32541024e-03f, 9.60742496e-03f, -7.25797638e-02f, 1.36259317e-01f, -7.07579479e-02f,
  -1.48712531e-01f, -1.17629632e-01f, 3.56684090e-03f, -7.74090365e-02f, 7.57227764e-02f, 9.58754197e-02f, 1.85694426e-01f, 2.43212432e-02f, -2.63804849e-02f, 4.41534966e-02f,
  -4.01192671e-03f, -1.04497910e-01f, -3.76653001e-02f, -1.91554856e-02f, 1.27119541e-01f, -8.27947259e-02f, 6.16075099e-02f, 6.89929426e-02f, -4.91258986e-02f, 1.16378032e-02f,
  1.15644280e-02f, 4.66641821e-02f, 4.67927158e-02f, 4.69982214e-02f, 9.92979333e-02f, -1.02258600e-01f, 5.32678738e-02f, 6.82528391e-02f, 9.05015096e-02f, -4.21408974e-02f,
  1.34134769e-01f, -1.17581040e-01f, 1.16603881e-01f, -8.76205415e-02f, -4.19205427e-02f, -2.43846010e-02f, -1.24402344e-01f, -1.16286866e-01f, -1.10848755e-01f, -4.51084338e-02f,
  3.47638577e-02f, -3.30656134e-02f, -5.65688908e-02f, 1.24233864e-01f, -7.45981261e-02f, -7.11211003e-03f, -7.53216892e-02f, 7.75632486e-02f, -5.11859916e-02f, -4.72663604e-02f,
  9.68734547e-03f, 1.53664956e-02f, 2.27334797e-02f, -1.05103567e-01f, 2.14699842e-02f, -3.91669869e-02f, -1.22519501e-01f, -3.89887393e-02f, -7.52241164e-02f, -2.21031085e-02f,
  7.26791993e-02f, 4.19858545e-02f, 8.86643305e-02f, -7.26954490e-02f, 4.06204984e-02f, -8.14539641e-02f, -4.09147143e-02f, 2.94715595e-02f, -3.15476209e-02f, -3.80215384e-02f,
  -3.96295637e-03f, -1.46547884e-01f, 1.00617334e-01f, -1.39196098e-01f, -1.06707670e-01f, 3.73632200e-02f, -6.06424399e-02f, -5.91345504e-02f, 5.39811775e-02f, 1.57445576e-02f,
  7.78136551e-02f, 5.26254531e-03f, 1.34294108e-02f, -1.17420681e-01f, 7.45527446e-02f, -8.93982723e-02f, 7.13245422e-02f, 8.87190836e-05f, -9.75653455e-02f, 5.35119027e-02f,
  -8.51585530e-03f, 4.86871488e-02f, 7.03707039e-02f, -5.62675297e-02f, -6.76869005e-02f, 6.02458864e-02f, -1.28196090e-01f, 2.75858715e-02f, 2.50924919e-02f, 9.91669223e-02f,
  1.18187703e-01f, -6.51702210e-02f, 1.58645093e-01f, 9.96050313e-02f, -6.08509891e-02f, 1.81161873e-02f, 2.24609636e-02f, 9.64273661e-02f, -2.17028424e-01f, 1.16387680e-01f,
  -9.96009335e-02f, 1.56815335e-01f, 6.15993701e-02f, 9.50400997e-03f, -1.16820648e-01f, -8.77118036e-02f, -7.28118792e-02f, -1.44294664e-01f, 2.93510710e-03f, 1.38906792e-01f,
  -1.75120518e-01f, -3.45885344e-02f, 8.03166851e-02f, -2.15614028e-02f, -5.17412052e-02f, 1.00148469e-01f, -1.40173838e-01f, -1.14915684e-01f, 1.27212247e-02f, -9.95190721e-03f,
  -1.79021016e-01f, -1.14756040e-01f, -1.71684846e-01f, 1.41326319e-02f, -2.55378693e-01f, 5.83697893e-02f, -9.86790508e-02f, 2.94505371e-05f, -1.58061236e-01f, -2.28143688e-02f,
  9.81472954e-02f, -2.43835952e-02f, -8.99646897e-03f, -9.28553343e-02f, -1.97800640e-02f, -1.31701142e-01f, 6.99788183e-02f, 4.80676778e-02f, -8.49622414e-02f, -7.55957291e-02f,
  7.09239542e-02f, -8.61756727e-02f, 1.24076018e-02f, 4.99476828e-02f, -2.91068424e-02f, 5.98603450e-02f, 1.32600263e-01f, -1.28368684e-03f, 1.06463553e-02f, -5.26151322e-02f,
  8.37765560e-02f, 7.82356691e-03f, -2.03744322e-02f, -2.26020608e-02f, -3.18008736e-02f, -9.19067711e-02f, 7.85063282e-02f, -4.19714376e-02f, -3.39884795e-02f, -5.98706827e-02f,
  9.71392635e-03f, -7.68935755e-02f, 1.37994930e-01f, 6.02424368e-02f, 2.86273174e-02f, 9.55407880e-03f, -7.18768537e-02f, -3.12396921e-02f, 6.82629496e-02f, -6.81052208e-02f,
  5.59989810e-02f, 3.67187932e-02f, -1.57073382e-02f, -7.96643645e-02f, 3.93763259e-02f, -1.58597324e-02f, 1.67497583e-02f, 9.52693447e-02f, -5.46813831e-02f, 8.98808092e-02f,
  -7.76223987e-02f, -3.45232501e-03f, -3.80861685e-02f, 1.01911761e-02f, 1.18970580e-01f, 8.57831091e-02f, 2.93195397e-02f, -3.56911495e-02f, -2.74968687e-02f, 1.57788675e-02f,
  -5.32571413e-02f, -8.56105611e-02f, 9.30161998e-02f, -5.26338257e-02f, -1.71677470e-02f, -8.58998299e-02f, -5.97598925e-02f, 1.33564817e-02f, 2.27457155e-02f, -5.20882942e-02f,
  -4.13540453e-02f, 2.48009097e-02f, -7.94688016e-02f, 4.44050170e-02f, 2.06156969e-02f, 6.55169189e-02f, -7.70635679e-02f, 4.52251360e-02f, -2.30177604e-02f, -1.93866808e-02f,
  -2.19108915e-04f, 8.52551833e-02f, -7.57254362e-02f, 6.05194494e-02f, -7.88227469e-02f, -1.03964068e-01f, -1.12537444e-01f, -2.32632801e-01f, -7.10633248e-02f, -1.42140482e-02f,
  2.94017866e-02f, -4.08760384e-02f, -2.32425015e-02f, 1.08051613e-01f, -1.31919816e-01f, -1.47168383e-01f, 1.09650761e-01f, 7.54473917e-03f, -7.46046975e-02f, -3.30314450e-02f,
  2.87196003e-02f, -4.94923666e-02f, 5.89308478e-02f, -3.25437076e-02f, -4.54125032e-02f, 1.53752103e-01f, 1.24103107e-01f, 4.64507425e-03f, 1.40031785e-01f, 2.59277429e-02f,
  -6.97150454e-02f, 7.24482536e-02f, 7.30056465e-02f, 1.43031493e-01f, 1.84544563e-01f, 1.66960493e-01f, -3.06248274e-02f, 1.06852405e-01f, 3.88986766e-02f, 4.67551202e-02f,
  1.41470939e-01f, 1.58068165e-01f, -1.25845060e-01f, 7.60819241e-02f, 3.14179924e-03f, -3.34269903e-03f, 1.03981987e-01f, 1.70367375e-01f, 6.21797843e-03f, -3.38017680e-02f,
  -3.18035409e-02f, 1.02419324e-01f, -4.18437272e-02f, -3.87087762e-02f, 3.98930609e-02f, 6.65504262e-02f, 3.67812887e-02f, -3.97378542e-02f, -1.19328452e-02f, 3.02351220e-03f,
  4.07661870e-02f, 8.43599718e-03f, -8.57865959e-02f, 9.91021618e-02f, -1.00896701e-01f, -5.49848713e-02f, 9.07308329e-03f, 9.68933776e-02f, 2.48044301e-02f, -9.23444182e-02f,
  -1.98211279e-02f, 1.86653063e-02f, 2.26558056e-02f, -8.64063203e-02f, 1.72877282e-01f, 9.83495563e-02f, 5.81342652e-02f, 5.60727715e-02f, 7.40023032e-02f, 2.19677924e-03f,
  -7.52348006e-02f, 6.73932768e-03f, -9.38336477e-02f, -3.54966111e-02f, -7.47838244e-02f, 1.41213769e-02f, 3.01421378e-02f, -8.21386427e-02f, -1.35275066e-01f, 7.59569788e-03f,
  -1.10831317e-02f, 1.35402428e-04f, -5.26143126e-02f, -1.29790097e-01f, -2.76254881e-02f, -8.66884179e-03f, 6.41383380e-02f, -1.33922085e-01f, -1.01296762e-02f, 3.77872586e-02f,
  8.56786519e-02f, -3.22404690e-02f, -7.01410249e-02f, 2.01041605e-02f, 2.88403798e-02f, 4.28941175e-02f, -1.32358342e-01f, 3.67534459e-02f, -4.05416563e-02f, 1.27492724e-02f,
  -9.71705317e-02f, -8.69187713e-02f, 3.50711495e-02f, 2.08614301e-02f, -8.91586617e-02f, 9.38052237e-02f, 5.31663038e-02f, 4.88309935e-02f, -9.26408358e-03f, 6.41273148e-03f,
  -9.87759829e-02f, 4.40983213e-02f, -5.75284511e-02f, 7.34385997e-02f, 5.63816503e-02f, 5.79331219e-02f, -1.66949868e-01f, 2.82950383e-02f, -7.10520297e-02f, -7.11189210e-02f,
  1.76690752e-03f, -5.76473726e-03f, -6.13938235e-02f, 5.42980656e-02f, 1.39728740e-01f, -8.93549323e-02f, 4.79325186e-03f, 1.21258043e-01f, 8.66852477e-02f, 7.79069290e-02f,
  1.54063404e-01f, -4.69933227e-02f, 1.07422650e-01f, -1.05100758e-01f, 8.94662440e-02f, -5.16412482e-02f, 2.21643317e-02f, -8.35794583e-02f, -5.14069013e-02f, 3.47913094e-02f,
  -9.74307060e-02f, -2.51715127e-02f, 1.34322181e-01f, 3.06307396e-04f, -4.65585589e-02f, 7.43702054e-02f, 1.24597818e-01f, 5.07007912e-03f, -3.03185675e-02f, 8.40044916e-02f,
  1.96447030e-01f, -6.35240451e-02f, 8.56993124e-02f, 1.07324138e-01f, -1.53187141e-01f, 5.53364120e-02f, -1.34210885e-01f, -2.54526976e-02f, 1.35345250e-01f, 1.14685930e-01f,
  1.14252992e-01f, -1.40376210e-01f, 1.33537084e-01f, -5.64261302e-02f, 1.71559095e-01f, 1.63934287e-02f, -1.00984238e-01f, 4.14065318e-03f, 2.27268264e-02f, -3.63172404e-02f,
  1.66729838e-02f, 1.72564998e-01f, -1.58651769e-01f, 2.25025564e-01f, 6.10660911e-02f, -3.31303962e-02f, -1.77380107e-02f, 5.46525344e-02f, -5.25261201e-02f, 1.35191485e-01f,
  5.59453405e-02f, 9.67700481e-02f, 3.97229567e-02f, 2.23334525e-02f, -2.39907065e-03f, 3.85323237e-03f, -1.00923575e-01f, 2.98360977e-02f, 2.33997703e-02f, -6.57621445e-03f,
  -4.43578698e-02f, -8.71758834e-02f, 6.01219907e-02f, 1.13470620e-02f, -4.25358340e-02f, 6.59639984e-02f, 1.13302246e-02f, 1.91212725e-02f, -1.29542381e-01f, -4.34220843e-02f,
  -2.39121802e-02f, 7.84613099e-03f, -1.15974076e-01f, 5.47919907e-02f, -3.84380892e-02f, 3.77788730e-02f, -1.06442913e-01f, -8.16225186e-02f, -7.49573903e-03f, 5.09075820e-02f,
  5.73252104e-02f, -3.61568891e-02f, 9.71276090e-02f, -6.48288950e-02f, -6.07727841e-02f, -9.44983065e-02f, -3.82001773e-02f, 1.54822454e-01f, 2.16229688e-02f, -2.64253486e-02f,
  -7.18703568e-02f, 3.32385898e-02f, -7.25429282e-02f, -1.06781140e-01f, 3.49743688e-03f, -2.12570895e-02f, 4.87050451e-02f, -3.78798274e-03f, -1.32360592e-01f, -1.07975006e-01f,
  -1.04835130e-01f, 9.25709829e-02f, 3.76047683e-03f, 2.33213454e-02f, 2.97526456e-02f, -3.39465262e-03f, -1.66742355e-02f, -1.79946676e-01f, -1.11782467e-02f, 4.86769490e-02f,
  -1.91054106e-01f, -6.34940565e-02f, -6.58980338e-03f, -6.72620907e-02f, -1.87842503e-01f, 6.11951165e-02f, 8.89078677e-02f, -3.14021967e-02f, -8.37145299e-02f, 9.73424315e-03f,
  -1.04512945e-01f, -1.75517928e-02f, -1.39557505e-02f, -2.84023881e-02f, 5.39821535e-02f, 4.42634374e-02f, -9.93390903e-02f, 4.75946181e-02f, -4.33278121e-02f, -1.30941421e-02f,
  1.69168770e-01f, 6.15821045e-04f, 1.38619319e-01f, -1.25736166e-02f, 1.00905105e-01f, -2.56214589e-02f, 3.92277539e-02f, -7.72314593e-02f, -1.00288555e-01f, -5.46147265e-02f,
  -1.40283674e-01f, 5.83152212e-02f, 1.10793762e-01f, 9.22031850e-02f, 6.70990124e-02f, 1.34394199e-01f, -1.22773394e-01f, 8.58641788e-02f, 1.57062337e-01f, 1.57815531e-01f,
  4.51901034e-02f, 5.42746969e-02f, -8.58968794e-02f, 1.07024357e-01f, -2.63070196e-01f, -7.42240548e-02f, 9.55156311e-02f, 1.52065486e-01f, 1.08761668e-01f, -3.80364843e-02f,
  -5.10897534e-03f, -2.90511698e-02f, 7.09527954e-02f, 5.54872677e-02f, -1.08398013e-01f, 1.01698436e-01f, -2.11730395e-02f, 2.53289938e-02f, 5.51569201e-02f, 1.18785501e-01f,
  -8.78628045e-02f, 1.59392715e-01f, 2.49606743e-02f, -1.84770264e-02f, -1.66181803e-01f, -7.53932819e-02f, -1.10318817e-01f, -4.90680970e-02f, -2.52752602e-02f, 6.46172985e-02f,
  6.01630658e-02f, -5.67125417e-02f, 2.22737510e-02f, 8.19522887e-03f, 1.36242971e-01f, -4.73358519e-02f, 4.10481244e-02f, 1.10917397e-01f, -7.84861743e-02f, -1.49078548e-01f,
  2.62317006e-02f, 4.63723354e-02f, -2.04784095e-01f, 5.57494164e-02f, -1.14812292e-02f, 1.04903422e-01f, -1.31035671e-01f, 8.51134583e-02f, -6.18745852e-03f, -4.58111018e-02f,
  1.24146035e-02f, -5.94701692e-02f, -5.75876310e-02f, 4.16985042e-02f, -6.96929991e-02f, -1.94592364e-02f, -3.09575745e-03f, 2.55461894e-02f, 9.13094655e-02f, 1.96827110e-02f,
  -4.57598045e-02f, -6.02310412e-02f, -3.93650085e-02f, -6.20680191e-02f, 5.86305894e-02f, -1.37299836e-01f, -6.68836087e-02f, -5.31371683e-02f, -3.67256254e-02f, 1.54263629e-02f,
  -5.98203717e-03f, 1.22448057e-01f, 7.49195665e-02f, 7.92127382e-03f, 2.17922069e-02f, 2.89087966e-02f, -7.98816830e-02f, -1.95997171e-02f, 3.17919441e-02f, 9.69372839e-02f,
  -3.09579056e-02f, 6.12225197e-02f, -6.84566498e-02f, 9.14787408e-03f, 7.36122020e-03f, 4.64052334e-02f, 7.26982728e-02f, 4.35442403e-02f, -4.45788763e-02f, 1.43278474e-02f,
  -2.75294725e-02f, -2.71562319e-02f, -8.31479952e-02f, 4.30277772e-02f, 2.60744710e-03f, 1.12326024e-02f, 9.88213569e-02f, 5.49664237e-02f, -3.92695181e-02f, -1.44975305e-01f,
  -8.85773152e-02f, -6.36001080e-02f, -1.06533639e-01f, 1.77594405e-02f, 7.65381530e-02f, 1.32184491e-01f, -7.31270015e-02f, -1.31124675e-01f, -4.19570617e-02f, -1.12529039e-01f,
  -6.58541247e-02f, -2.31092051e-02f, 7.40957782e-02f, -1.99308679e-01f, -1.43637485e-03f, -7.48018548e-02f, -1.01086520e-01f, -1.02088727e-01f, 1.31958917e-01f, -1.04058899e-01f,
  6.53046998e-04f, 1.06835492e-01f, -8.12444910e-02f, -1.44329056e-01f, -7.90321454e-02f, 1.66951835e-01f, -6.69882726e-03f, -1.41431049e-01f, 4.94892597e-02f, 1.22495756e-01f,
  -3.54301892e-02f, 1.30102023e-01f, -1.11613028e-01f, 7.63628483e-02f, -1.07942574e-01f, 6.79990202e-02f, 3.57857086e-02f, 1.65536791e-01f, 2.36877408e-02f, -6.63723871e-02f,
  1.69634789e-01f, 3.07733528e-02f, 2.48532929e-02f, -1.26594961e-01f, -1.19711310e-01f, 7.86222965e-02f, 2.07088023e-01f, -1.64841451e-02f, -9.15441588e-02f, 7.33419061e-02f,
  1.08548462e-01f, 1.41608315e-02f, -1.10740941e-02f, -2.67450176e-02f, 9.90348868e-04f, -4.04036790e-02f, -7.98149481e-02f, -3.89461480e-02f, -1.01335049e-01f, -5.39076701e-02f,
  5.64216636e-02f, -3.41464020e-02f, 5.88665307e-02f, -2.30588205e-02f, -1.51243405e-02f, -5.02200089e-02f, 2.17785202e-02f, -9.98939127e-02f, 4.88254018e-02f, -1.76169095e-03f,
  4.49568480e-02f, -1.01600595e-01f, 1.55754620e-02f, 3.05873901e-02f, 1.05544306e-01f, 4.05885130e-02f, 2.15532314e-02f, 8.44732001e-02f, 2.69294251e-02f, 6.95271119e-02f,
  3.28010209e-02f, -8.49625468e-02f, 8.88373405e-02f, -7.09871354e-04f, -6.09193966e-02f, 4.84965332e-02f, 2.55658086e-02f, 4.43539163e-03f, 1.02229111e-01f, 8.74519870e-02f,
  -5.04587218e-02f, 5.57692684e-02f, -3.45945209e-02f, 1.55748472e-01f, 1.06957043e-03f, -2.18793992e-02f, 5.95602766e-02f, 2.53950022e-02f, 5.37361503e-02f, -3.54034007e-02f,
  -4.83846180e-02f, 7.65077621e-02f, -5.26766814e-02f, 9.85012427e-02f, -8.20901766e-02f, -9.57202390e-02f, 5.67225479e-02f, 9.43077058e-02f, 5.49476296e-02f, 1.54341385e-02f,
  1.06485464e-01f, -5.32221384e-02f, 1.53140556e-02f, -4.05692197e-02f, 5.05154878e-02f, 5.24492376e-02f, -9.64325108e-03f, 7.09811598e-03f, 2.94679124e-02f, -8.37161264e-04f,
  9.69713368e-03f, 3.09521221e-02f, 2.10207123e-02f, 8.74507651e-02f, 1.76079702e-02f, 4.08737883e-02f, 6.43988028e-02f, 1.44006699e-01f, 8.79765451e-02f, 8.54490623e-02f,
  -4.81867269e-02f, 3.60178500e-02f, -8.17701519e-02f, -1.25964239e-01f, -3.33276764e-02f, 2.05913335e-02f, 1.26759171e-01f, 3.49136293e-02f, -2.85897404e-02f, -1.39868572e-01f,
  3.47683430e-02f, 1.77154705e-01f, -4.52787392e-02f, 8.55001360e-02f, -1.58652733e-03f, 3.32594588e-02f, -7.01173395e-02f, -6.44354895e-03f, -1.12869693e-02f, -1.14858948e-01f,
  -4.59448919e-02f, 9.75886658e-02f, -7.95804188e-02f, 3.91993411e-02f, 5.99103905e-02f, 8.87545496e-02f, -9.30094570e-02f, -4.41897251e-02f, -1.19281963e-01f, -1.11655615e-01f,
  -6.79957271e-02f, -7.98943918e-03f, 4.97615002e-02f, 2.74450309e-03f, 1.27781853e-01f, -9.67607542e-04f, 2.45326571e-02f, -1.68974791e-02f, -3.52433026e-02f, -1.72672160e-02f,
  8.78537372e-02f, -4.82230559e-02f, 1.25844538e-01f, 3.44434604e-02f, -1.27925590e-01f, 5.90420067e-02f, 2.00016201e-02f, 3.90904136e-02f, -1.42094642e-02f, -5.08627854e-02f,
  8.37180763e-02f, -8.15812051e-02f, -9.51622054e-03f, -5.12194224e-02f, 1.28515571e-01f, 7.07753673e-02f, 7.52295479e-02f, -6.95414916e-02f, 8.75364244e-02f, -5.82679473e-02f,
  -5.99827543e-02f, 4.82314080e-02f, 7.72979856e-02f, 5.91676198e-02f, 4.84006368e-02f, 1.08602576e-01f, -8.58448595e-02f, -5.82165979e-02f, -1.24710485e-01f, -1.49487434e-02f,
  3.31678130e-02f, 6.59931004e-02f, -3.04837041e-02f, -9.58988965e-02f, 3.36922966e-02f, -5.04762717e-02f, 3.20732631e-02f, -3.74079756e-02f, 4.50087152e-02f, -7.25269839e-02f,
  -7.83744678e-02f, -1.36439279e-01f, -6.37360141e-02f, -1.91176366e-02f, -9.46791023e-02f, 4.97368015e-02f, -6.08564317e-02f, 4.66354638e-02f, -6.58128485e-02f, 6.70162663e-02f,
  7.15512782e-02f, -9.34510231e-02f, 3.05119399e-02f, -2.94335298e-02f, 5.79438731e-03f, -5.34689948e-02f, -3.48859578e-02f, 2.04811674e-02f, -5.21682389e-02f, -6.79441169e-02f,
  3.51868942e-02f, -9.94000062e-02f, -1.05486885e-01f, 3.20092477e-02f, -5.69904372e-02f, -1.05095105e-02f, -1.33745950e-02f, 1.19878165e-01f, -3.44799124e-02f, -3.55872996e-02f,
  -4.13360074e-02f, -1.28058875e-02f, -2.98165139e-02f, -4.18561660e-02f, -1.42823830e-01f, 3.98018435e-02f, -5.33053018e-02f, 7.65370056e-02f, -4.88665588e-02f, -5.71543574e-02f,
  -1.31082477e-03f, 6.84341118e-02f, 8.72568265e-02f, 5.72694317e-02f, -4.62957360e-02f, -1.59453198e-01f, -9.13498625e-02f, -6.35180175e-02f, -7.82873183e-02f, -8.19535404e-02f,
  1.06606126e-01f, 1.65436953e-01f, -4.77292612e-02f, 1.17475495e-01f, 3.53256874e-02f, -1.14216462e-01f, -1.18660562e-01f, 5.61777912e-02f, -1.59005284e-01f, -7.91841596e-02f,
  4.00921442e-02f, 2.45386809e-02f, -1.11314908e-01f, -2.96107642e-02f, -6.76640030e-03f, -1.54653350e-02f, 5.24801910e-02f, 2.17622947e-02f, -4.50750291e-02f, -1.01267183e-02f,
  6.70084655e-02f, 8.49253982e-02f, -1.29036522e-02f, -5.77412285e-02f, -5.11752814e-02f, 8.06672424e-02f, 1.45082310e-01f, 1.51903003e-01f, -1.74307585e-01f, -6.35088608e-02f,
  -8.04208443e-02f, 2.04348639e-02f, -1.56656697e-01f, 1.03588834e-01f, -7.81729221e-02f, -4.94586118e-02f, 3.40525173e-02f, -3.70915607e-02f, -2.04750653e-02f, -1.92581397e-02f,
  -8.24495107e-02f, 1.17581196e-01f, 1.06935322e-01f, -9.35993418e-02f, 1.14864215e-01f, 1.63877346e-02f, -7.83187300e-02f, -1.11781627e-01f, 8.42080079e-03f, -8.33408162e-02f,
  -7.13461787e-02f, 4.45337370e-02f, 1.82621125e-02f, -2.83851679e-02f, -9.43491980e-03f, -5.94395064e-02f, -8.38701520e-03f, -1.57297533e-02f, 1.14565417e-01f, 9.30620804e-02f,
  -4.43698689e-02f, 2.04744376e-03f, -5.71509749e-02f, -1.06463559e-01f, 1.13170490e-01f, 5.25662787e-02f, 1.40479226e-02f, -2.35276874e-02f, -5.79606481e-02f, 8.31240788e-02f,
  5.78709990e-02f, 7.53738135e-02f, -1.26750469e-01f, 2.90779732e-02f, 7.60919228e-02f, -6.38155267e-02f, 5.92163019e-02f, 7.57435337e-02f, -2.47210208e-02f, -9.26639214e-02f,
  -6.09304337e-03f, 5.54927140e-02f, 3.53081115e-02f, 8.29949901e-02f, -3.45414989e-02f, -8.37828442e-02f, 4.98562381e-02f, -5.91291301e-02f, -4.89864722e-02f, -8.76486376e-02f,
  -6.07556254e-02f, -3.74277160e-02f, 7.56927654e-02f, -1.01256259e-02f, -3.35538872e-02f, -2.03224849e-02f, 4.38801609e-02f, 8.83475244e-02f, -1.00779869e-02f, -4.97931801e-02f,
  2.33123582e-02f, -2.11697374e-03f, 1.17718816e-01f, -8.42745677e-02f, -5.06418124e-02f, -7.45593905e-02f, 8.71710386e-03f, 3.17519307e-02f, 2.95906868e-02f, 8.46007243e-02f,
  -7.87078589e-02f, -3.69106047e-02f, -1.14735588e-02f, 1.21768408e-01f, -4.92501557e-02f, 1.04124751e-02f, -6.63735047e-02f, -4.67231274e-02f, -6.62008673e-02f, -7.53983557e-02f,
  -4.87195365e-02f, 6.61602393e-02f, 5.06324694e-02f, -2.50277668e-01f, -1.15608573e-01f, -1.80467561e-01f, -4.22829688e-02f, -8.68372712e-03f, -3.50404754e-02f, -3.48125584e-02f,
  -2.94527337e-02f, -5.58410957e-02f, -1.68854408e-02f, -1.41474664e-01f, 1.22156151e-01f, 6.43010065e-02f, -5.19029424e-02f, -1.65816650e-01f, 4.98301424e-02f, -9.13050771e-02f,
  -5.30273989e-02f, -1.72822997e-01f, 1.49194017e-01f, -1.26545727e-02f, 4.83346619e-02f, 1.52288705e-01f, -5.51289618e-02f, -8.66552666e-02f, 7.80044571e-02f, 9.05207396e-02f,
  -2.30840780e-02f, -1.44958675e-01f, 2.21199229e-01f, 1.93561316e-01f, 1.04506053e-01f, 1.72574837e-02f, 8.08258168e-03f, 8.13964102e-03f, 3.25741060e-02f, 8.23675618e-02f,
  1.26262650e-01f, 1.04939468e-01f, 2.50764638e-02f, -1.07682087e-01f, 1.50015831e-01f, 4.64051850e-02f, 7.82757178e-02f, -7.79665709e-02f, -2.31469702e-02f, 1.70222104e-01f,
  1.71794564e-01f, 9.35143828e-02f, -1.89086616e-01f, -1.11531988e-01f, 7.74903372e-02f, 7.60844573e-02f, -9.31613520e-02f, -5.61675616e-02f, 2.24568546e-02f, 7.25107789e-02f,
  1.08360015e-02f, -3.96942385e-02f, -1.11726463e-01f, -2.87379473e-02f, 1.25237361e-01f, 4.60208207e-02f, -2.97183618e-02f, -5.78356832e-02f, -6.30131438e-02f, 1.10324956e-01f,
  -5.90633228e-03f, -6.53406680e-02f, 4.06564958e-02f, 1.29181191e-01f, -9.14315134e-02f, 3.89076136e-02f, 3.59226391e-02f, 4.44945432e-02f, -3.97066660e-02f, -1.11936368e-02f,
  1.04904033e-01f, 4.62235734e-02f, 6.42437413e-02f, -1.01199992e-01f, 4.10620421e-02f, 1.15162075e-01f, -3.83874513e-02f, -1.02559187e-01f, 1.11856431e-01f, -6.72596693e-02f,
  -2.49796547e-02f, -7.80122727e-02f, 6.62567541e-02f, 5.38485078e-03f, 1.53987661e-01f, -1.52155422e-02f, 7.38493279e-02f, 8.60008672e-02f, 6.05247095e-02f, 5.31255379e-02f,
  -1.41052976e-02f, 1.68450195e-02f, 5.03841750e-02f, 7.68733248e-02f, -4.01793271e-02f, -6.22874387e-02f, -3.57617512e-02f, -5.59096150e-02f, 7.59288892e-02f, 5.52950948e-02f,
  9.11445022e-02f, -6.39804751e-02f, 8.31782073e-02f, -2.27309447e-02f, -1.72802135e-02f, -4.35995795e-02f, -4.42383923e-02f, 3.58663499e-02f, -8.97284448e-02f, -1.35469148e-02f,
  1.16212526e-02f, 5.49151860e-02f, 1.41835529e-02f, 2.71010585e-02f, 4.64936811e-03f, 5.96253946e-02f, 5.30555770e-02f, 9.65384915e-02f, 2.62579229e-02f, -3.09085846e-03f,
  -4.30747569e-02f, -4.79383133e-02f, 1.77801907e-01f, -1.55909844e-02f, 1.41928226e-01f, 1.12326473e-01f, 8.91825557e-02f, -9.28738043e-02f, -2.57976074e-02f, -4.83817682e-02f,
  -7.12355180e-03f, 8.04940686e-02f, -1.84085742e-01f, 1.30186871e-01f, 6.80887699e-02f, 1.79609209e-01f, 7.70896226e-02f, 3.59777757e-03f, -9.88905430e-02f, -7.63719082e-02f,
  -5.41341156e-02f, -7.87985697e-02f, -1.71650976e-01f, 1.90989468e-02f, -1.51742667e-01f, 3.49691994e-02f, 9.82005298e-02f, 1.32785141e-01f, -1.15048043e-01f, -5.29922806e-02f,
  -2.91536320e-02f, -3.23027559e-02f, 7.12753683e-02f, 1.66003138e-01f, -1.03408918e-01f, -3.71962301e-02f, -3.16876895e-03f, -5.83737306e-02f, -8.75370502e-02f, 1.79353386e-01f,
  3.99518237e-02f, -2.21834872e-02f, 7.89909100e-04f, 3.37750069e-03f, 7.48194531e-02f, 2.49225181e-02f, -1.12247206e-01f, 1.11928165e-01f, 1.11962706e-01f, -5.33971526e-02f,
  -5.81492074e-02f, 5.95212430e-02f, -5.11735603e-02f, 4.94231507e-02f, -8.22288617e-02f, 6.34854718e-04f, -1.16665021e-01f, -6.72193915e-02f, 1.48225874e-01f, 8.27933401e-02f,
  -2.38479786e-02f, 8.48845392e-02f, 6.71447366e-02f, 8.03540945e-02f, 2.84013674e-02f, 3.94887058e-03f, -2.01909281e-02f, -3.46673019e-02f, 4.56327535e-02f, 2.20524445e-02f,
  -6.27567023e-02f, -3.39345410e-02f, -1.85416341e-02f, 5.66243194e-02f, 9.08572376e-02f, -6.72984123e-03f, 3.04810070e-02f, 3.60189714e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  6.53815344e-02f, 1.92586780e-02f, -3.91785614e-02f, -6.71190694e-02f, -5.06481901e-02f, -5.93551435e-02f, -2.22882796e-02f, 7.27734119e-02f, 1.70686450e-02f, -1.97461173e-02f,
  -2.78595998e-03f, -2.02735700e-02f, 1.18963895e-02f, 2.71881558e-02f, 3.93418185e-02f, -8.88615176e-02f, 2.70476900e-02f, 3.19975130e-02f, 8.70885700e-02f, -7.08193034e-02f,
  5.82465045e-02f, 8.25052559e-02f, -1.16165699e-02f, 2.67853532e-02f, 5.32497764e-02f, 6.32255673e-02f, -1.35714952e-02f, 6.57541677e-02f, 3.44503596e-02f, -5.03350645e-02f,
  -1.29703637e-02f, -4.72460240e-02f, -4.96499985e-02f, -3.01710740e-02f, 5.77959232e-02f, 1.06074708e-02f, -3.37560773e-02f, 7.99487382e-02f, -4.80624698e-02f, -1.52871013e-02f,
  2.52625160e-02f, 4.86019207e-03f, 9.55114514e-02f, 1.88815407e-02f, 7.19211251e-02f, -5.59945405e-02f, 7.51023879e-03f, 2.48470102e-02f, -3.31915207e-02f, 2.58863103e-02f,
  -2.35556755e-02f, -2.08265167e-02f, -7.93322101e-02f, -9.04990137e-02f, -2.43116301e-02f, -4.03506979e-02f, -7.76548311e-02f, -3.68341617e-02f, -2.45947931e-02f, -8.40928331e-02f,
  -6.17863089e-02f, 6.83133304e-02f, -7.58977234e-02f, -5.72451577e-02f, 8.67442116e-02f, 4.36474048e-02f, 9.19964463e-02f, -7.91731924e-02f, 6.62681460e-02f, 2.32531726e-02f,
  6.50084764e-02f, 1.05272084e-01f, 2.99488474e-02f, -3.51427197e-02f, 4.44004349e-02f, -1.51735721e-02f, 4.51941416e-02f, 9.85329002e-02f, 6.70720115e-02f, 5.15384153e-02f,
  -4.50899452e-02f, -5.26675656e-02f, 2.40382012e-02f, 7.92321488e-02f, -9.18682069e-02f, 7.39025623e-02f, 6.39422983e-02f, 4.48269211e-02f, 6.05712533e-02f, -5.65400347e-02f,
  -6.56099692e-02f, -4.43676934e-02f, 3.49615663e-02f, -7.59040639e-02f, -6.17862493e-02f, 6.85410341e-03f, 9.95428674e-03f, 9.44223627e-03f, -1.94295440e-02f, 5.14261089e-02f,
  -6.96666315e-02f, 8.83995742e-02f, 1.70597229e-02f, 6.91545606e-02f, 4.51084636e-02f, -8.45354348e-02f, -1.18188653e-02f, 1.11364841e-01f, 1.25020202e-02f, -1.12523539e-02f,
  -5.66073172e-02f, 8.69491622e-02f, 1.16956737e-02f, -2.25184150e-02f, -5.75829856e-02f, 4.49235253e-02f, -2.07828097e-02f, -2.78854072e-02f, 2.26924270e-02f, 8.26513395e-02f,
  -4.62657623e-02f, -7.03382194e-02f, -6.49449974e-02f, 1.35673070e-02f, 4.34514321e-02f, 8.50490779e-02f, 4.09257151e-02f, 8.11071917e-02f, 5.31250574e-02f, -1.62088796e-02f,
  -4.77613769e-02f, 1.05678022e-01f, -6.51844963e-02f, 2.85675898e-02f, 1.85026880e-02f, 1.05718665e-01f, 1.08688824e-01f, -1.59513596e-02f, 1.05476901e-01f, -9.71318223e-03f,
  5.06474636e-02f, 5.16574420e-02f, 7.34995976e-02f, 5.05298562e-02f, 8.45372751e-02f, -7.30386153e-02f, -1.40963420e-02f, 1.07337676e-01f, 1.77265741e-02f, 7.35630170e-02f,
  5.69376722e-02f, 4.67714183e-02f, 1.90788489e-02f, 9.31586176e-02f, 4.42569368e-02f, -3.03692017e-02f, 1.75110213e-02f, 1.05257347e-01f, 7.28414953e-02f, -9.62076243e-03f,
  1.10742599e-01f, 1.06483638e-01f, 9.34555084e-02f, 1.73513796e-02f, -1.12467416e-01f, -7.68348062e-03f, 5.23286164e-02f, -1.34921195e-02f, -8.19043070e-02f, -4.88556996e-02f,
  8.44735950e-02f, -4.42747436e-02f, 5.63471951e-02f, 7.55439922e-02f, -1.41133470e-02f, 3.57806101e-03f, 1.02605438e-02f, 1.06230155e-01f, 9.12387148e-02f, 2.70311590e-02f,
  -6.99004009e-02f, -1.07736193e-01f, -8.19840878e-02f, -1.01909246e-02f, 2.48904712e-02f, -6.23479821e-02f, 9.59045216e-02f, 9.23850015e-02f, -6.30231053e-02f, -6.20910972e-02f,
  -9.19254422e-02f, 4.12591472e-02f, 8.35816786e-02f, -2.23434940e-02f, -3.60402986e-02f, 6.56291768e-02f, 8.58501941e-02f, -5.38720153e-02f, 1.43385872e-01f, 4.03265469e-02f,
  4.14571399e-03f, -3.77533510e-02f, 1.17160745e-01f, -5.33980643e-03f, 4.17339467e-02f, 2.89966334e-02f, 4.72210981e-02f, -1.11477114e-02f, -3.09951566e-02f, 6.64914399e-02f,
  2.03075223e-02f, -7.42017031e-02f, 1.52506649e-01f, -1.86676607e-02f, -7.50682279e-02f, -1.43690202e-02f, -8.20515230e-02f, 4.63597178e-02f, -2.81620044e-02f, 2.03207582e-02f,
  -8.77712443e-02f, 8.32544360e-03f, 2.35933196e-02f, -9.06045288e-02f, -1.07275680e-01f, -2.84606647e-02f, -5.91652803e-02f, 6.08655214e-02f, -1.66814793e-02f, 7.21532677e-04f,
  -5.43567501e-02f, -1.40335578e-02f, -9.13416443e-04f, -4.56167832e-02f, -6.45280257e-02f, -6.10398303e-04f, -5.34315500e-03f, -1.00701340e-01f, -7.07472637e-02f, -5.86585794e-03f,
  -7.39463512e-03f, 6.60744905e-02f, -3.33695672e-02f, -9.24108997e-02f, 5.76985069e-02f, -1.59682129e-02f, -1.92484632e-02f, -8.20762943e-03f, 7.84844533e-02f, 4.47737202e-02f,
  1.11068875e-01f, -1.97708644e-02f, 4.59785312e-02f, -7.04932064e-02f, -4.30953950e-02f, 5.63103938e-03f, 5.67034110e-02f, -5.96900731e-02f, 1.12259790e-01f, -1.75432749e-02f,
  -3.32645178e-02f, 1.11670941e-01f, -8.85492340e-02f, -4.18446325e-02f, 1.18058652e-01f, -5.71323670e-02f, 1.19463086e-01f, 1.20459430e-01f, 1.22747660e-01f, 2.19104439e-02f,
  -6.42972952e-03f, -1.86646376e-02f, -2.18308177e-02f, 8.67490247e-02f, 4.40343320e-02f, -5.20531498e-02f, 2.39504296e-02f, 5.43125607e-02f, 6.99030161e-02f, 2.67703384e-02f,
  6.24286048e-02f, 1.32252350e-01f, 5.37472144e-02f, -2.94665452e-02f, -2.80022547e-02f, 9.61076654e-03f, 9.13541466e-02f, 7.86999390e-02f, 3.66588049e-02f, 6.38255849e-02f,
  8.67068022e-02f, 4.69244607e-02f, 8.04671273e-02f, 6.92177787e-02f, 6.12396635e-02f, 5.20318449e-02f, -2.82428488e-02f, 1.90973151e-02f, 3.39267775e-02f, 1.11398056e-01f,
  -1.16416000e-01f, -4.21242602e-02f, 7.84135833e-02f, 5.43069579e-02f, 1.21766575e-01f, 2.27761004e-04f, 2.44734250e-02f, -1.56312600e-01f, -6.73483387e-02f, -1.40055776e-01f,
  -6.28986582e-02f, -1.09891510e-02f, 3.70340608e-02f, 1.50373474e-01f, -6.31925091e-02f, -2.72546560e-02f, -1.84325445e-02f, 1.63979437e-02f, 7.09889904e-02f, 9.93280858e-02f,
  1.10989856e-02f, 9.26569384e-03f, 1.63186550e-01f, 4.48250100e-02f, -1.95722550e-01f, -1.29441112e-01f, -1.37613133e-01f, -9.95752364e-02f, 6.03224663e-03f, 2.49275994e-02f,
  -2.79022623e-02f, -5.73470853e-02f, -3.75025235e-02f, 1.22724779e-01f, 9.95368809e-02f, 6.71845302e-02f, 6.18916526e-02f, 1.83380380e-01f, -9.06454623e-02f, 1.50759980e-01f,
  -2.55985081e-01f, 3.94130461e-02f, -2.99086161e-02f, 1.15490936e-01f, -1.45549819e-01f, -7.00500607e-02f, -1.47457346e-02f, -1.60979047e-01f, 1.52242228e-01f, 1.46209866e-01f,
  1.42409243e-02f, 1.89116016e-01f, -4.57287300e-03f, -5.78471785e-03f, 1.16749853e-01f, -2.68094577e-02f, -1.89285446e-02f, 5.48663214e-02f, 3.37957665e-02f, -1.02188058e-01f,
  1.99290626e-02f, 3.08457091e-02f, 2.45507564e-02f, -3.63065861e-02f, -5.52524906e-03f, -7.22461240e-03f, -3.31534742e-04f, 4.67787590e-03f, -1.02277230e-02f, 1.63371209e-02f,
  -6.11346364e-02f, -7.20443875e-02f, -1.48887234e-02f, 8.86161104e-02f, 2.95955557e-02f, -3.10985874e-02f, 6.67885765e-02f, 6.82968646e-02f, -1.18709512e-01f, 1.11580025e-02f,
  2.50754901e-03f, 3.13799046e-02f, 5.67436963e-02f, 1.21974230e-01f, 8.03281665e-02f, 1.44869283e-01f, 6.71748668e-02f, 3.55567150e-02f, -4.45050262e-02f, 2.40610093e-02f,
  7.15525895e-02f, -1.82575698e-03f, 1.41481474e-01f, 9.88820568e-02f, -4.69023511e-02f, 2.14461517e-02f, 2.78978571e-02f, 8.72990116e-02f, 4.99108471e-02f, 1.08662628e-01f,
  -6.35897182e-03f, -3.93426307e-02f, 1.88424382e-02f, 9.60533097e-02f, 1.03202676e-02f, 8.78358036e-02f, 1.21207587e-01f, 6.56647012e-02f, -2.41676588e-02f, 2.75654979e-02f,
  7.83230066e-02f, 6.80042207e-02f, 1.63219556e-01f, 1.14707880e-01f, 3.26391645e-02f, 5.43722138e-03f, -5.35942242e-02f, 1.19920028e-02f, 2.43857242e-02f, -4.94595207e-02f,
  7.11200908e-02f, 7.39689097e-02f, -2.97480598e-02f, 2.11775023e-02f, 3.87628116e-02f, -2.47150082e-02f, 6.30853176e-02f, -3.19032520e-02f, 1.46643994e-02f, 1.99246332e-02f,
  -1.50553836e-02f, 3.60832028e-02f, -4.40874472e-02f, 1.12384491e-01f, -5.76893389e-02f, 6.50300980e-02f, -1.13349929e-02f, 7.01941922e-02f, -6.03514165e-02f, -3.84962335e-02f,
  8.88926759e-02f, -1.32204339e-01f, 8.42847228e-02f, 1.13014184e-01f, -1.42403871e-01f, 3.65762077e-02f, -1.55004352e-01f, 1.13764554e-01f, -7.34082907e-02f, 1.01048559e-01f,
  -4.73812558e-02f, -6.86812773e-02f, 1.00176089e-01f, 6.84871897e-02f, 1.59012944e-01f, -1.24074452e-01f, -7.06750751e-02f, -7.91220665e-02f, -3.71083413e-04f, 3.08408518e-03f,
  1.24884970e-01f, -6.36288598e-02f, -1.05324045e-01f, 5.46691976e-02f, -1.05656855e-01f, -4.16952483e-02f, 6.23479560e-02f, -5.47043495e-02f, 1.33578390e-01f, -1.19757630e-01f,
  -8.24987441e-02f, 5.97074255e-03f, 5.07402010e-02f, 3.88118699e-02f, 6.24480508e-02f, 1.32210981e-02f, -1.49366692e-01f, -5.35581121e-03f, -2.23530829e-02f, -1.10103875e-01f,
  2.86712907e-02f, 1.00378357e-01f, 1.36169568e-02f, -9.50411558e-02f, -8.35304707e-03f, -6.48504719e-02f, 2.99156294e-03f, -4.24887575e-02f, 1.07932776e-01f, -5.23737073e-02f,
  5.09305522e-02f, 6.78342730e-02f, -4.85221781e-02f, -4.35392149e-02f, -1.21897617e-02f, 2.32673753e-02f, 3.64047177e-02f, 1.95152815e-02f, -1.62559524e-02f, 5.80958165e-02f,
  -2.73724943e-02f, 4.90992814e-02f, 6.43676817e-02f, 4.23683673e-02f, -3.94034833e-02f, -7.20513389e-02f, 6.32063672e-02f, -5.79369217e-02f, 8.47207084e-02f, 1.54750682e-02f,
  3.65627818e-02f, -1.92409716e-04f, -2.35763434e-02f, 8.76799375e-02f, 2.74882615e-02f, -4.95127290e-02f, 1.03638098e-01f, 8.76827165e-03f, -1.39550259e-02f, 5.17231487e-02f,
  -3.00406720e-02f, -1.63670033e-02f, 4.69543561e-02f, 1.04504555e-01f, 3.88432965e-02f, -1.19724181e-02f, 2.55574156e-02f, -4.40728106e-02f, -5.60529456e-02f, 1.01822458e-01f,
  7.57856220e-02f, 1.54219130e-02f, -3.19754742e-02f, -3.10713835e-02f, 1.15031749e-02f, -5.04850484e-02f, 8.15293640e-02f, 9.32739154e-02f, 1.01178221e-01f, -2.80112084e-02f,
  -7.06145316e-02f, 2.82311533e-02f, -6.09570891e-02f, 1.46521321e-02f, 1.74474567e-02f, 4.15660739e-02f, -6.52217641e-02f, 9.72213522e-02f, -5.54096363e-02f, -4.57267873e-02f,
  6.02159277e-02f, -5.61018623e-02f, -6.66690022e-02f, 8.34467188e-02f, -3.42804044e-02f, 5.44078741e-03f, 9.20109898e-02f, -3.72264832e-02f, -2.91187521e-02f, 4.50082235e-02f,
  1.00329779e-01f, 7.52353594e-02f, -2.60163639e-02f, -3.28089260e-02f, -5.47701009e-02f, -6.14011325e-02f, -4.53036278e-02f, -6.54949993e-02f, -8.31890479e-02f, -5.67320269e-03f,
  -9.72167682e-03f, -6.88350201e-02f, 5.05015776e-02f, -9.76619571e-02f, 1.00597553e-01f, -6.76299504e-04f, -1.02859996e-01f, -1.98022965e-02f, 5.32693113e-04f, 8.53666291e-02f,
  6.85834363e-02f, -1.56221986e-02f, -7.90091138e-03f, -2.66812909e-02f, 1.73107032e-02f, 3.22844763e-03f, 5.65739647e-02f, 4.46350910e-02f, -1.02853728e-02f, 6.09435141e-02f,
  7.89392292e-02f, 5.44016063e-02f, 9.14641321e-02f, 5.69228716e-02f, 5.74779697e-02f, -6.14198744e-02f, -3.59974876e-02f, -1.02223188e-03f, 6.53775483e-02f, 3.97514756e-04f,
  6.05588928e-02f, -8.59564841e-02f, 7.50082657e-02f, 7.34016066e-03f, 9.68511477e-02f, 8.96293297e-02f, -7.61516392e-02f, -5.21711037e-02f, 2.63825562e-02f, -6.24595657e-02f,
  3.58375274e-02f, 8.39084312e-02f, -4.40626666e-02f, -1.62588321e-02f, -7.65909776e-02f, 3.84782143e-02f, 2.37893295e-02f, -2.86181737e-02f, 5.76374345e-02f, -7.69412220e-02f,
  -3.47787701e-02f, -3.89890447e-02f, 7.69885480e-02f, 9.41494107e-03f, 6.40247390e-02f, -4.69373874e-02f, -2.68131662e-02f, -5.49394041e-02f, -5.58275022e-02f, -2.38664728e-02f,
  7.01074973e-02f, 3.90370004e-02f, -3.09130270e-02f, 7.32938806e-03f, -2.97712311e-02f, -1.75309498e-02f, 3.39361317e-02f, -3.54831666e-02f, -7.77608380e-02f, -6.11384679e-03f,
  -6.23315014e-02f, -3.06949429e-02f, -5.26249111e-02f, -1.34994453e-02f, 1.40021639e-02f, 9.91460532e-02f, -4.23843674e-02f, -1.92221440e-02f, 6.25584880e-03f, 4.91254143e-02f,
  -2.18249690e-02f, -9.06671025e-03f, -2.17065006e-03f, 2.25272365e-02f, 5.18085808e-02f, 4.73545194e-02f, -3.80838439e-02f, 6.89435303e-02f, -9.00751799e-02f, -4.99599017e-02f,
  -4.93358001e-02f, 9.44712013e-02f, 2.85411887e-02f, -7.60445744e-02f, -6.33880869e-02f, 8.43839645e-02f, 9.71836075e-02f, 6.79177269e-02f, -7.79529810e-02f, 4.50455286e-02f,
  4.34988737e-03f, 1.07484482e-01f, -1.27600757e-02f, -9.46245342e-02f, 9.83276591e-03f, 5.76611646e-02f, -3.23876888e-02f, 8.29904526e-02f, -3.03919837e-02f, 9.79316756e-02f,
  7.76536763e-02f, 1.66172143e-02f, -6.35118634e-02f, -3.38098295e-02f, -1.24761723e-02f, -4.38148044e-02f, -2.57416349e-02f, 5.70529550e-02f, 1.15458548e-01f, 4.77759400e-03f,
  5.76015189e-02f, 1.91534758e-02f, -7.28970841e-02f, -3.50888111e-02f, 2.02980414e-02f, -4.43445370e-02f, 3.97081077e-02f, 3.90245356e-02f, -7.93959647e-02f, -3.77708301e-02f,
  9.28992182e-02f, 8.44404027e-02f, 1.04625905e-02f, 1.80348996e-02f, -7.54330605e-02f, 2.53085177e-02f, -8.37639440e-03f, -5.16577950e-03f, 1.19612366e-02f, 3.79834808e-02f,
  6.59311488e-02f, 4.66586389e-02f, -6.52557760e-02f, -1.29626691e-02f, 7.54464790e-02f, -8.88322592e-02f, -6.53758347e-02f, -6.61070719e-02f, 3.60949300e-02f, 4.65320647e-02f,
  -7.48562440e-02f, -9.46097076e-02f, -5.77096455e-03f, -3.15458849e-02f, 7.37990886e-02f, 3.92122706e-03f, -9.09885317e-02f, 2.76154149e-02f, 1.78009532e-02f, -1.29018694e-01f,
  2.59063281e-02f, 3.72695811e-02f, -6.92743948e-03f, -8.78495947e-02f, -3.34063359e-02f, -6.50825873e-02f, 2.90022697e-02f, -1.65245067e-02f, -7.98396096e-02f, -3.21585946e-02f,
  -5.96547388e-02f, -3.92838456e-02f, 2.42127273e-02f, 5.51512577e-02f, -3.16128172e-02f, 4.81263809e-02f, 7.67994300e-02f, -6.01882376e-02f, -7.78759122e-02f, 1.65490415e-02f,
  -6.58788383e-02f, 1.74714122e-02f, -4.53394949e-02f, -6.59856573e-02f, 1.48190968e-02f, 1.00669498e-02f, 7.53445029e-02f, -6.38510147e-03f, -8.90935734e-02f, -6.04446791e-02f,
  -6.70068944e-03f, -8.24836791e-02f, -4.39159982e-02f, 9.74624697e-03f, -1.13923205e-02f, -2.18412951e-02f, 4.65222858e-02f, 4.19539250e-02f, -8.21588114e-02f, 4.43318300e-02f,
  7.87445456e-02f, 1.86670665e-02f, -2.11157482e-02f, 1.23349972e-01f, 9.03872102e-02f, 2.11478304e-02f, 5.35259582e-02f, 1.42759055e-01f, 6.95297718e-02f, 6.48464933e-02f,
  -2.47656256e-02f, -4.06275913e-02f, 7.12385625e-02f, 8.29782709e-03f, -6.78443257e-03f, 1.19235799e-01f, -1.68083124e-02f, 3.83304581e-02f, 1.33293988e-02f, 7.84413740e-02f,
  -4.40421477e-02f, -7.63487071e-02f, 6.33753613e-02f, 8.25157985e-02f, 1.36865199e-01f, 6.38254872e-03f, 4.19891104e-02f, -2.33681034e-02f, 1.36645716e-02f, 1.57037526e-01f,
  3.08131762e-02f, -3.07535287e-02f, -2.16385219e-02f, 7.00407475e-02f, 4.95114513e-02f, 1.61522930e-03f, 1.05190776e-01f, 2.23734099e-02f, -5.45725003e-02f, 9.36836451e-02f,
  -3.33869979e-02f, 1.29627079e-01f, 6.07556179e-02f, -8.42004642e-03f, 4.43281196e-02f, 9.40383971e-02f, 7.54122734e-02f, 1.17650226e-01f, -1.24603207e-03f, 2.24428577e-03f,
  1.14061840e-01f, 1.00550801e-01f, 1.09716751e-01f, -2.58066449e-02f, -1.66665658e-01f, -1.30841732e-01f, 3.94866057e-02f, -1.26610100e-01f, 7.53637999e-02f, 8.35035145e-02f,
  1.39936596e-01f, -6.82770461e-02f, -6.02843054e-02f, -5.01827672e-02f, -9.31200832e-02f, -1.37900919e-01f, 7.89408609e-02f, 6.10228954e-03f, -8.38942304e-02f, 1.25028834e-01f,
  4.73904200e-02f, 8.26368183e-02f, 2.58184895e-02f, 5.05711772e-02f, 5.05887531e-02f, 1.72156785e-02f, -6.13666996e-02f, -4.85386401e-02f, 5.33987656e-02f, -1.18998379e-01f,
  -7.69364834e-02f, -1.71150416e-02f, 5.51015958e-02f, -6.79728165e-02f, 4.31635343e-02f, -2.70938184e-02f, 1.55852035e-01f, -7.15053603e-02f, -8.56659338e-02f, 1.14351101e-01f,
  -8.76601413e-02f, -8.78811330e-02f, -9.68525279e-03f, -5.66262491e-02f, 1.39518932e-01f, -4.45555858e-02f, -3.70262489e-02f, 7.39220232e-02f, -5.75097725e-02f, 3.37688960e-02f,
  2.63950061e-02f, 5.34377173e-02f, 3.02514713e-02f, -1.68059506e-02f, 4.79046144e-02f, -5.44769876e-02f, 2.95251291e-02f, 6.65596575e-02f, -1.01183569e-02f, 6.33161962e-02f,
  6.17691502e-02f, -9.66099724e-02f, 6.81466796e-03f, 2.15020943e-02f, 3.73148173e-02f, 4.25826311e-02f, 1.34298543e-03f, 2.86160735e-03f, 1.91485435e-02f, -5.54006658e-02f,
  -5.79596907e-02f, 6.18987493e-02f, -6.81488812e-02f, 4.54522818e-02f, -9.67890099e-02f, -9.70386118e-02f, -5.27206175e-02f, 7.77480826e-02f, 6.64918125e-02f, 4.13321853e-02f,
  5.37598692e-02f, 1.39338002e-01f, -7.51676457e-03f, -1.15623333e-01f, 1.34950444e-01f, 1.03263251e-01f, 3.51151871e-03f, 9.84801576e-02f, 5.38232625e-02f, 2.88252309e-02f,
  1.37019157e-01f, 9.90284383e-02f, 2.27028020e-02f, -1.44595625e-02f, -4.97129634e-02f, 8.39976370e-02f, 3.20362709e-02f, 5.01795523e-02f, 8.20582584e-02f, 5.07328212e-02f,
  5.38975932e-03f, 1.02554904e-02f, 1.16080828e-01f, -8.34783912e-02f, 1.08899578e-01f, 1.26544714e-01f, 1.17182493e-01f, -1.26652867e-02f, 4.97498401e-02f, 5.22856452e-02f,
  -1.29166031e-02f, 1.24369562e-01f, 1.00486225e-03f, 1.45961866e-01f, 9.45075080e-02f, -9.74494591e-03f, 1.98648330e-02f, -1.62262917e-02f, -3.68642770e-02f, 3.51956673e-02f,
  4.69055623e-02f, 1.02309972e-01f, -5.89577444e-02f, 7.44753927e-02f, 7.41029605e-02f, 1.38640612e-01f, 3.84920798e-02f, -1.73952967e-01f, -4.67616431e-02f, -8.45994055e-03f,
  8.63302797e-02f, -2.23659575e-02f, 1.11387216e-01f, 6.68282993e-03f, -1.14007235e-01f, -7.17130955e-03f, -6.61132783e-02f, -9.28433761e-02f, 1.25070773e-02f, 8.83574039e-02f,
  -9.21867341e-02f, -1.24451883e-01f, -7.64415637e-02f, 7.49953240e-02f, -1.49805084e-01f, -1.64949894e-01f, 9.20573622e-02f, -1.55470982e-01f, -8.83151218e-02f, 6.23617247e-02f,
  -8.27160850e-02f, -1.27653986e-01f, 5.42321987e-02f, 9.79055166e-02f, -1.13305643e-01f, -3.30338650e-03f, 6.67064562e-02f, 7.50463679e-02f, 1.36829928e-01f, 1.06580786e-01f,
  -1.48006901e-01f, -1.29202604e-01f, -5.13558127e-02f, -8.42599198e-03f, -1.83788329e-01f, 2.03940555e-01f, -6.79344535e-02f, -1.24129504e-01f, 3.97248380e-02f, 6.32740138e-03f,
  1.13900930e-01f, 9.66993626e-03f, -8.91264752e-02f, 1.94085717e-01f, 9.58241150e-02f, -2.06510991e-01f, 2.13728491e-02f, 2.38662498e-04f, 1.23647386e-02f, 3.35169286e-02f,
  3.08346599e-02f, -8.07950273e-02f, -2.57366039e-02f, 8.07214901e-02f, 5.64536937e-02f, 9.71762538e-02f, -9.78459194e-02f, -6.40086606e-02f, -1.09540582e-01f, 2.42005251e-02f,
  -7.18120337e-02f, 1.08836748e-01f, -3.63603830e-02f, -4.97041121e-02f, 9.85945389e-02f, -6.10449091e-02f, 7.91066736e-02f, 9.40457806e-02f, -9.56312381e-03f, 6.11167820e-03f,
  1.19501650e-01f, -9.10333470e-02f, 1.83204472e-01f, 2.85727587e-02f, -3.25034857e-02f, 7.52862841e-02f, 5.79788238e-02f, 5.60939591e-03f, 6.37015849e-02f, 4.34309617e-02f,
  4.28521112e-02f, 1.68544482e-02f, 9.54831168e-02f, 6.92087114e-02f, 9.81647745e-02f, 7.25176036e-02f, 3.18906037e-04f, 9.90105569e-02f, -1.98605992e-02f, 2.04555392e-02f,
  5.87212741e-02f, 4.02884744e-02f, -8.88206735e-02f, -3.75803225e-02f, 2.33036038e-02f, 2.74967961e-02f, -6.01752400e-02f, 5.07309027e-02f, 4.52320054e-02f, 7.19994679e-02f,
  -6.19426928e-02f, 1.12476505e-01f, 7.78801367e-02f, 4.59150523e-02f, -2.20209435e-02f, -4.64903302e-02f, -1.31080989e-02f, -1.13122366e-01f, -4.13394012e-02f, -4.41080099e-03f,
  1.26050115e-01f, 1.18326306e-01f, 6.77098781e-02f, 1.86320283e-02f, 8.19356441e-02f, -1.74897742e-02f, 9.57306623e-02f, 2.52460199e-03f, 3.96479927e-02f, 4.97909151e-02f,
  4.16438244e-02f, 5.68306930e-02f, 1.02376238e-01f, 6.17554691e-03f, 1.22235246e-01f, 5.73319979e-02f, 3.03646810e-02f, 5.79676591e-02f, 2.72290572e-03f, -9.14940313e-02f,
  3.26323137e-02f, -5.17743379e-02f, -4.76019792e-02f, 1.65799167e-02f, -5.50695742e-03f, 8.54855254e-02f, -7.38562644e-03f, 1.62096918e-02f, 4.30521257e-02f, 6.99975193e-02f,
  6.71551749e-02f, -5.40835261e-02f, 5.41064963e-02f, 7.22290352e-02f, -4.73627970e-02f, 5.42890057e-02f, 1.25123426e-01f, 4.48608119e-03f, 6.60168901e-02f, -2.32503889e-03f,
  -1.02278426e-01f, 4.15201858e-02f, -1.13016041e-03f, 4.25441116e-02f, -8.78361985e-02f, -6.34433106e-02f, -2.44937632e-02f, -6.28937110e-02f, 1.76411211e-01f, 1.18772738e-01f,
  9.27275494e-02f, 1.33812586e-02f, 1.03433840e-01f, 4.84575853e-02f, 4.55363356e-02f, -3.63242812e-03f, 3.49748321e-02f, 6.91993013e-02f, -7.79885352e-02f, -3.98632176e-02f,
  1.02994293e-01f, -4.56146337e-02f, 1.49025815e-02f, -1.32801998e-02f, -6.54651150e-02f, 3.37089114e-02f, -3.47114280e-02f, 5.79145551e-02f, 9.41178650e-02f, -5.20722084e-02f,
  3.82334879e-03f, -9.36523676e-02f, 1.70910861e-02f, -1.10891342e-01f, -4.70004342e-02f, 1.11890500e-02f, -2.90639438e-02f, -9.39374864e-02f, -5.20484149e-02f, -7.66172111e-02f,
  -8.14973786e-02f, -1.37653332e-02f, 6.85493350e-02f, 5.46234213e-02f, 9.02860984e-03f, -1.87189560e-02f, 5.93857504e-02f, 3.37988175e-02f, 8.76458287e-02f, -8.97617266e-02f,
  -3.15279625e-02f, -8.93213078e-02f, -2.83757560e-02f, 9.38670635e-02f, -1.64506249e-02f, -8.27378221e-03f, -6.66469708e-02f, 4.60386975e-03f, -3.29685882e-02f, 5.67096323e-02f,
  -1.26650576e-02f, -1.10637117e-02f, -4.64974940e-02f, -5.39475493e-02f, 2.70223208e-02f, 1.00275546e-01f, 5.83524965e-02f, -1.62710585e-02f, -7.79988393e-02f, 7.53911212e-02f,
  -4.33373861e-02f, 2.78806239e-02f, -7.59846792e-02f, 4.75932285e-02f, -4.78735901e-02f, 2.90636886e-02f, 7.65791312e-02f, 5.43244258e-02f, -7.27707241e-03f, 1.45947402e-02f,
  5.89059293e-03f, 7.42109045e-02f, 1.38997026e-02f, -7.10898116e-02f, -2.98167989e-02f, -8.40685964e-02f, -9.75573249e-03f, 3.84050421e-02f, 1.78069551e-03f, 3.82852089e-03f,
  -7.81151652e-02f, -5.64712938e-03f, -7.37756267e-02f, 6.25734329e-02f, -5.09521067e-02f, -6.30919263e-02f, -5.84224332e-03f, 8.04842860e-02f, 4.91704978e-02f, 3.95957567e-02f,
  -5.37540298e-03f, -6.18104748e-02f, -2.74511334e-02f, 4.52374145e-02f, 1.83441378e-02f, -4.78591844e-02f, 5.44100814e-02f, -8.23506862e-02f, 1.61934998e-02f, 6.60481602e-02f,
  1.65466368e-02f, 7.65762627e-02f, -7.67912343e-02f, -1.12424484e-02f, 3.62702422e-02f, -2.60030758e-02f, 1.60796735e-02f, -4.83381189e-02f, -7.90083632e-02f, 6.04202636e-02f,
  1.49035286e-02f, -5.68176946e-03f, 4.53215726e-02f, 8.53466690e-02f, 2.65288781e-02f, -1.03842616e-01f, 4.58790027e-02f, -6.64055068e-03f, 6.78971335e-02f, 2.77400594e-02f,
  4.24968340e-02f, -6.19795136e-02f, 5.18151261e-02f, 1.70229319e-02f, -6.98293746e-02f, 6.71449453e-02f, 5.88760078e-02f, -3.39763314e-02f, -3.46137956e-02f, -1.67528484e-02f,
  -3.22193801e-02f, -4.80511971e-02f, 3.11549529e-02f, 4.66128252e-02f, -6.13883138e-02f, -9.64118354e-03f, 6.39974847e-02f, -8.57878029e-02f, 2.33545601e-02f, -1.00139193e-02f,
  -4.59757894e-02f, -4.89450246e-03f, -2.94263847e-02f, -3.29130478e-02f, -6.09194450e-02f, -3.53296660e-02f, 4.98340689e-02f, 3.88297066e-02f, 3.14563736e-02f, -8.06893408e-02f,
  -8.65724832e-02f, -4.16346937e-02f, 7.82400817e-02f, 5.68785854e-02f, 8.13360661e-02f, 5.68779036e-02f, 7.72568733e-02f, 9.55486391e-03f, -8.53515342e-02f, 3.75583023e-02f,
  2.26755701e-02f, 3.78695354e-02f, 7.13319182e-02f, 1.82017256e-02f, -2.09591296e-02f, -6.21082261e-02f, -7.38763586e-02f, 1.26593616e-02f, -8.14495888e-03f, -1.62793621e-02f,
  5.34157827e-03f, 7.64221251e-02f, -7.18447240e-03f, -1.78257115e-02f, 2.60264669e-02f, 6.39197743e-03f, -5.22799119e-02f, -3.41728181e-02f, -2.14924887e-02f, 9.02100429e-02f,
  9.89376660e-03f, 8.31312686e-02f, 1.67533513e-02f, 6.85653389e-02f, -7.87568241e-02f, 8.21740106e-02f, 9.64892879e-02f, 4.11751047e-02f, 9.55305248e-03f, -5.25817089e-02f,
  -6.51623234e-02f, 1.66788232e-02f, -5.74872345e-02f, 8.55294168e-02f, 3.50957327e-02f, 7.99232423e-02f, 3.84129472e-02f, 6.26500919e-02f, 8.53703171e-02f, -3.39133032e-02f,
  -5.80044426e-02f, -6.51360396e-03f, 3.25011127e-02f, -8.58026184e-03f, 4.75505814e-02f, -2.33126320e-02f, 1.94558036e-02f, -1.25072489e-03f, -6.83910474e-02f, -1.23917023e-02f,
  3.90055999e-02f, 8.45741257e-02f, 4.17054892e-02f, -3.88544239e-02f, 2.35484783e-02f, -6.32881001e-02f, 4.69233580e-02f, -5.23646772e-02f, 5.31708300e-02f, 6.28948212e-02f,
  -1.13163097e-02f, 6.03298545e-02f, 9.90723222e-02f, -3.94537486e-02f, -4.13488485e-02f, -2.44356170e-02f, 2.52406243e-02f, 7.57135749e-02f, -3.99050564e-02f, -4.38770317e-02f,
  7.80543685e-02f, -6.94712698e-02f, -8.83179829e-02f, 6.19257614e-02f, -4.27570939e-02f, -4.95069735e-02f, -1.14548616e-01f, 1.06984284e-02f, 6.79458976e-02f, 1.38272628e-01f,
  2.62939613e-02f, 5.44760786e-02f, -6.01882152e-02f, -1.06138833e-01f, -6.67009354e-02f, 2.69593801e-02f, -7.99779370e-02f, -7.43979886e-02f, 6.29771948e-02f, -1.96795072e-02f,
  -1.31251188e-02f, -3.34769078e-02f, -6.71823472e-02f, -2.42850855e-02f, 8.25084373e-02f, -4.66291569e-02f, -4.94429469e-02f, 6.38110414e-02f, 2.95097269e-02f, -1.43027887e-01f,
  4.34803441e-02f, -3.10045797e-02f, -4.27783951e-02f, 1.79248881e-02f, 3.45047005e-02f, -9.31668803e-02f, -9.30360239e-03f, 3.74239050e-02f, -8.84128362e-02f, 7.74441734e-02f,
  9.50903445e-02f, 4.50764336e-02f, 6.14387542e-02f, 7.51063526e-02f, 4.63975295e-02f, -3.16261984e-02f, -3.29316445e-02f, 8.47340152e-02f, 2.17138045e-02f, -5.97779788e-02f,
  5.78215718e-02f, 4.11637649e-02f, -3.69470268e-02f, 1.02262087e-02f, 4.33047824e-02f, -6.43702671e-02f, 6.48527592e-02f, 1.93114877e-02f, -9.76461079e-03f, -9.23850909e-02f,
  2.13643871e-02f, 3.33326720e-02f, 3.16976309e-02f, -5.86743001e-03f, 6.69487892e-03f, -8.07879940e-02f, -6.64221868e-02f, 6.93315566e-02f, 6.68943971e-02f, -4.82759215e-02f,
  -3.63517180e-02f, 2.95640738e-03f, 5.64462617e-02f, 2.82316096e-02f, 1.25523791e-01f, -4.73530404e-03f, 1.12361766e-01f, 3.59941386e-02f, 9.12176222e-02f, 5.57518080e-02f,
  3.41551714e-02f, -9.72765556e-04f, -7.34821036e-02f, 1.08734453e-02f, 3.10151633e-02f, 3.25774811e-02f, 4.97975014e-02f, 4.28481326e-02f, -4.01186012e-02f, 7.09261671e-02f,
  3.78613137e-02f, 8.48452188e-03f, -5.70244435e-03f, -2.27491762e-02f, 1.49931777e-02f, 4.21941988e-02f, 1.03049934e-01f, 8.87911171e-02f, -7.28585720e-02f, -8.35133996e-03f,
  -4.35573943e-02f, -6.58165440e-02f, 7.76069164e-02f, 3.79001871e-02f, 4.02549207e-02f, -2.70625595e-02f, -5.24338596e-02f, -3.39093730e-02f, 6.69120997e-02f, -3.85642797e-02f,
  1.23585695e-02f, 4.36705500e-02f, -4.20212969e-02f, 7.31435791e-02f, 3.69150713e-02f, -2.82176286e-02f, -4.20750231e-02f, 1.01458877e-01f, 7.34755769e-02f, 2.81686001e-02f,
  -8.81557092e-02f, 5.27921356e-02f, -9.55594238e-03f, -5.93117066e-02f, 7.42189437e-02f, -6.43728953e-03f, -4.04506084e-03f, 1.11140832e-01f, -3.63649763e-02f, 5.38174286e-02f,
  7.74808377e-02f, -1.02365715e-02f, -7.22860396e-02f, -5.38735911e-02f, -6.19254522e-02f, -7.54241422e-02f, -1.49031822e-02f, 3.34370602e-03f, -6.49825186e-02f, 1.35562286e-01f,
  -5.43033294e-02f, 4.73040808e-03f, -7.41896629e-02f, -7.68999755e-02f, -7.83526003e-02f, 2.24893242e-02f, 4.78148228e-03f, -4.14069928e-03f, -3.18437926e-02f, -4.76426408e-02f,
  -7.33014420e-02f, -6.25005886e-02f, 9.36480612e-02f, 4.64081727e-02f, 4.45347354e-02f, 8.03562254e-02f, -9.50913280e-02f, -1.05681114e-01f, 4.33023199e-02f, 1.61314029e-02f,
  2.77092122e-02f, -7.86784664e-03f, 3.63753811e-02f, -9.28842276e-02f, 6.32517487e-02f, -1.35089412e-01f, 3.17792036e-02f, -5.57935312e-02f, 4.07980941e-02f, -8.88288245e-02f,
  4.72945757e-02f, 9.62154865e-02f, 2.23493669e-02f, 6.28449097e-02f, -3.05459853e-02f, 4.18383107e-02f, 5.54781333e-02f, -3.85424346e-02f, 1.63603965e-02f, 7.01712519e-02f,
  -4.16264012e-02f, -4.72454028e-03f, 9.06862989e-02f, 7.66104907e-02f, -6.10136315e-02f, -2.56426446e-02f, -2.27598175e-02f, -2.92691253e-02f, 9.92117599e-02f, 2.62937285e-02f,
  9.59691480e-02f, 5.80769666e-02f, -4.81209494e-02f, -7.86285028e-02f, -4.77389097e-02f, -4.17697839e-02f, -3.02413013e-02f, -1.62986591e-02f, -7.42873922e-02f, 1.06400214e-02f,
  4.62314039e-02f, -3.78935374e-02f, 8.24411307e-03f, 8.67940709e-02f, -2.93472912e-02f, 3.83002684e-02f, 6.04699031e-02f, -7.02661648e-02f, 4.33162451e-02f, -7.82828405e-02f,
  -4.43524010e-02f, 2.93009970e-02f, -2.79301237e-02f, 7.06517100e-02f, -2.80597322e-02f, -3.36262882e-02f, -2.77763475e-02f, -6.82016239e-02f, -3.29920426e-02f, -7.62306899e-02f,
  -3.60904098e-03f, -2.84683984e-02f, -5.65308183e-02f, -8.90798494e-02f, 3.34446020e-02f, 3.95408869e-02f, -3.59543180e-03f, 2.62555443e-02f, 2.00326853e-02f, -6.85807690e-02f,
  2.74309795e-02f, -8.76916200e-02f, -5.30626550e-02f, 1.85344983e-02f, 7.56299049e-02f, 9.86246541e-02f, 7.71283805e-02f, -2.92412024e-02f, -6.02050237e-02f, 1.73825864e-02f,
  5.25140278e-02f, 6.99534118e-02f, 8.45654588e-03f, -5.92433400e-02f, -7.98009634e-02f, 1.07561657e-02f, -7.80424625e-02f, -5.93886822e-02f, -5.85269295e-02f, -1.83925722e-02f,
  2.48491522e-02f, -2.46129576e-02f, -8.78667980e-02f, -8.13603178e-02f, 5.69627807e-02f, -2.07378175e-02f, 9.54754725e-02f, 5.28609529e-02f, 1.10260457e-01f, 4.40728813e-02f,
  6.64563552e-02f, -1.11554511e-01f, -7.89138600e-02f, -3.51857767e-02f, -3.18591744e-02f, -4.90774177e-02f, -2.29263175e-02f, 1.36434324e-02f, -1.35234920e-02f, 8.08018744e-02f,
  6.11807278e-04f, -4.27489653e-02f, -3.31521556e-02f, 8.29905644e-03f, 8.01335946e-02f, 5.42228222e-02f, -2.64096223e-02f, 8.65896717e-02f, -6.91257790e-02f, 5.71990572e-02f,
  -5.61505295e-02f, -8.35971087e-02f, -2.14730147e-02f, 8.12852308e-02f, 8.77463445e-02f, 7.54456893e-02f, -6.86430708e-02f, -3.75216529e-02f, 6.95080683e-02f, 7.59047121e-02f,
  -3.71138752e-02f, -5.70127368e-03f, 2.32782103e-02f, -6.38673380e-02f, -4.30141389e-02f, -3.01549602e-02f, -3.86691280e-02f, 8.93285275e-02f, -8.55290610e-03f, -5.86561076e-02f,
  1.93684790e-02f, -5.80695346e-02f, -1.13832979e-02f, 2.45402604e-02f, -4.24980149e-02f, -3.78981940e-02f, 1.54184131e-02f, -2.92997733e-02f, -3.27234305e-02f, -2.84361076e-02f,
  9.10139922e-03f, -3.30345742e-02f, -2.00128537e-02f, -5.03354855e-02f, 1.21501293e-02f, -2.12400015e-02f, -4.51900810e-02f, -8.07307512e-02f, 5.96681386e-02f, 6.25065342e-02f,
  -5.37679642e-02f, -2.86054369e-02f, 6.96246475e-02f, 6.47130311e-02f, 3.86165967e-03f, 1.58797558e-02f, -6.32741153e-02f, 8.07819888e-02f, 6.95602223e-02f, -1.73283350e-02f,
  7.44843930e-02f, 3.69258388e-03f, 5.88473417e-02f, -9.13769603e-02f, 9.74723995e-02f, 3.17148827e-02f, 1.04479104e-01f, 5.43693267e-02f, 7.34993517e-02f, -7.05145523e-02f,
  1.74235180e-02f, 5.71666323e-02f, -4.60834950e-02f, 5.17957732e-02f, 8.26869234e-02f, -5.99383600e-02f, 2.23956946e-02f, 9.01710913e-02f, 3.09905466e-02f, 2.66136881e-02f,
  5.31787872e-02f, -5.67769706e-02f, 1.03616357e-01f, -7.99804851e-02f, 5.18275760e-02f, -1.77259538e-02f, 6.31885901e-02f, 4.82407585e-02f, 1.07420981e-01f, -3.39109497e-03f,
  1.91831740e-03f, -7.57403532e-03f, 1.06655635e-01f, -5.61114177e-02f, -6.90903217e-02f, 6.85927197e-02f, -7.39293322e-02f, 3.24891247e-02f, -6.25321865e-02f, -6.31971434e-02f,
  1.27826231e-02f, -3.45116071e-02f, -5.94861135e-02f, -3.53488810e-02f, -1.10363103e-01f, -9.70269262e-04f, 5.16422242e-02f, -7.98732787e-03f, -1.33982049e-02f, 8.66850391e-02f,
  -2.60622296e-02f, -2.92885918e-02f, -5.67293540e-02f, -1.02992505e-01f, 7.21062720e-02f, -7.53761083e-02f, 4.91816439e-02f, -2.08735745e-02f, 1.01816177e-01f, -5.07806540e-02f,
  4.21070866e-02f, -7.98543766e-02f, -2.62874048e-02f, 5.16293151e-03f, 5.52300774e-02f, -1.88853182e-02f, 5.04508661e-03f, -3.24472114e-02f, 1.13876656e-01f, 6.89467788e-02f,
  5.56322113e-02f, 3.66163030e-02f, 3.91970091e-02f, -5.96656688e-02f, 1.06128920e-02f, -4.46951538e-02f, -4.74178791e-02f, 6.33264035e-02f, -3.74946296e-02f, -4.47176583e-03f,
  8.95313919e-02f, -1.65043548e-02f, -6.72559813e-02f, 1.60933614e-01f, 3.52607593e-02f, -9.16738808e-02f, -4.03209664e-02f, -4.85272408e-02f, 4.06216383e-02f, -2.67940499e-02f,
  2.05994472e-02f, 8.27862248e-02f, 2.28242874e-02f, 7.59553770e-03f, -8.57948288e-02f, 9.92894173e-02f, -6.08997308e-02f, 6.48887828e-02f, 1.11749895e-01f, -8.11236054e-02f,
  1.93503238e-02f, 4.69153337e-02f, -7.95809552e-02f, -3.31493467e-02f, 4.27083485e-02f, -7.24668801e-02f, -7.26777362e-04f, 7.62335882e-02f, 1.00696767e-02f, -1.19788153e-02f,
  -3.28745656e-02f, 1.85145007e-03f, -3.46657448e-02f, 4.44020107e-02f, 1.64828729e-02f, 7.64100701e-02f, -4.39119972e-02f, 8.84926543e-02f, -2.12519243e-02f, 8.58504325e-02f,
  -5.61435590e-05f, 9.40252915e-02f, -8.58732834e-02f, -4.94355746e-02f, -4.40419950e-02f, 3.73895206e-02f, -5.21731414e-02f, -5.26875108e-02f, -3.45131010e-02f, 4.87492569e-02f,
  1.29268058e-02f, -5.40970750e-02f, 1.47116994e-02f, 4.29650173e-02f, -1.07093398e-02f, -1.33773033e-02f, 2.79808446e-04f, 6.27321601e-02f, 1.22209350e-02f, 2.55718566e-02f,
  -8.53510499e-02f, 4.07353044e-02f, -5.85674159e-02f, -7.74844317e-03f, -9.36454441e-03f, 5.49087264e-02f, 3.29151819e-03f, -5.56947775e-02f, -5.56925796e-02f, -6.55050576e-03f,
  3.12057510e-02f, -1.22119789e-03f, 8.30830447e-03f, 4.18443382e-02f, 8.96038786e-02f, 1.91106349e-02f, 4.39958051e-02f, 1.72531232e-02f, 6.96592405e-02f, -3.51812914e-02f,
  6.20539449e-02f, -2.31173951e-02f, -6.96145371e-02f, 1.52452607e-02f, -2.59784516e-02f, -6.49585575e-02f, 7.27733746e-02f, 7.40214214e-02f, 1.30860787e-02f, -3.05281319e-02f,
  -5.56853227e-02f, -4.77592740e-03f, 7.58117884e-02f, 5.22436760e-03f, 3.77384014e-02f, 2.51484253e-02f, -5.29658347e-02f, -3.44101191e-02f, -7.18404949e-02f, -1.11238249e-01f,
  -1.77159291e-02f, -7.56898150e-02f, -8.29674676e-02f, 2.22882554e-02f, 6.32338151e-02f, 6.85495958e-02f, 6.56798556e-02f, -2.51348112e-02f, -7.98990205e-03f, -6.45038635e-02f,
  4.56060432e-02f, -5.12607731e-02f, 3.13066393e-02f, 9.38854814e-02f, -2.23363973e-02f, 2.40927767e-02f, -5.54008745e-02f, 7.87901059e-02f, 1.66764501e-02f, 4.84492928e-02f,
  -1.67113449e-02f, -8.18213746e-02f, -5.10714799e-02f, -4.65849377e-02f, -4.59161922e-02f, -8.39822441e-02f, -5.16491942e-02f, 2.55968440e-02f, 3.46716866e-02f, -2.10934281e-02f,
  3.00200526e-02f, 9.79435518e-02f, -8.37185383e-02f, -6.36298163e-03f, -7.05909207e-02f, -3.83617133e-02f, -4.91404049e-02f, -9.68040451e-02f, -3.42550837e-02f, -3.59263085e-02f,
  -3.43523249e-02f, 5.08514978e-02f, -1.83758028e-02f, -4.08838466e-02f, -5.53545058e-02f, -5.50631583e-02f, -1.25560807e-02f, -7.32436329e-02f, -1.85736008e-02f, 4.15552817e-02f,
  -7.08972365e-02f, 1.00531885e-02f, -8.67878646e-02f, 3.88894193e-02f, 9.28063020e-02f, -7.81339034e-02f, 6.37427205e-03f, 3.24750319e-02f, -2.88160169e-04f, 7.58679584e-02f,
  -4.33025211e-02f, -2.72338577e-02f, 2.58548446e-02f, 5.50997667e-02f, 5.56557514e-02f, 4.77647148e-02f, 2.80526876e-02f, 6.46281093e-02f, -6.07377402e-02f, -3.15982327e-02f,
  -5.14163300e-02f, 5.36755025e-02f, 1.10683493e-01f, -4.55989949e-02f, 4.98953126e-02f, 5.20231836e-02f, 1.97716895e-02f, -4.03086506e-02f, 6.90818578e-02f, 2.22347304e-02f,
  -3.93369794e-02f, -3.91186923e-02f, 4.82484773e-02f, 7.79675469e-02f, 8.35612565e-02f, 6.85676560e-02f, 5.57014048e-02f, 3.20552215e-02f, 1.74123496e-02f, -3.46263871e-02f,
  -1.83584727e-02f, 7.31086507e-02f, 8.43034014e-02f, -4.67884466e-02f, -6.64793700e-02f, 6.63197041e-02f, 2.77115349e-02f, -4.79286946e-02f, 9.26677287e-02f, 1.03405744e-01f,
  5.47289290e-02f, -3.97470817e-02f, 7.98911601e-02f, -1.62033960e-02f, 3.20190229e-02f, 6.29886761e-02f, 2.36014389e-02f, 2.19459869e-02f, 7.80747458e-02f, 3.40820588e-02f,
  6.45879582e-02f, 1.79806203e-02f, 8.43969584e-02f, 4.47825193e-02f, -7.48318210e-02f, 8.71305540e-02f, -5.26519641e-02f, 1.06425233e-01f, 9.70694348e-02f, 9.61789042e-02f,
  9.40639339e-03f, -8.19978043e-02f, -1.02633238e-01f, 3.08665652e-02f, 2.19061244e-02f, -4.58309613e-02f, -1.00213401e-01f, 7.20635876e-02f, -2.05888394e-02f, 2.56562680e-02f,
  9.85978767e-02f, -1.03540659e-01f, 1.17466904e-01f, 2.66436972e-02f, 4.06363793e-02f, -1.04720987e-01f, 1.98927652e-02f, -8.79184976e-02f, -6.98489100e-02f, 1.15753654e-02f,
  -1.55831967e-02f, -5.57314120e-02f, 5.82432933e-02f, 8.76387358e-02f, -9.53779593e-02f, -7.26668909e-02f, -4.12140712e-02f, 8.07161331e-02f, -1.33593604e-01f, -1.23750806e-01f,
  1.31192923e-01f, -2.30801553e-02f, 1.30957708e-01f, 6.17671907e-02f, -8.70933756e-02f, -1.94860101e-02f, -9.25122797e-02f, -8.73202235e-02f, 1.29924625e-01f, 1.20955668e-01f,
  -1.02259248e-01f, 3.33375633e-02f, 5.23357056e-02f, -3.50357592e-02f, 6.16079122e-02f, -2.72047762e-02f, 6.18550628e-02f, -6.76904898e-03f, 7.65493512e-02f, -7.68047245e-03f,
  -1.20850980e-01f, -1.03062831e-01f, -1.92912780e-02f, 7.13480935e-02f, -7.67844310e-03f, -7.97304213e-02f, 6.77798837e-02f, 6.81157857e-02f, 1.08952671e-01f, 1.04963243e-01f,
  -1.49892708e-02f, -9.13063660e-02f, 3.28659043e-02f, 6.27072379e-02f, -1.32406573e-03f, 2.65078172e-02f, -1.95908989e-03f, 1.05915301e-01f, 2.56385431e-02f, 8.98957998e-02f,
  7.74215236e-02f, 3.42227332e-02f, -3.63898464e-02f, -2.83461940e-02f, -4.41071913e-02f, 7.91980922e-02f, 4.90321480e-02f, 7.29919448e-02f, 1.66384414e-01f, 9.29226577e-02f,
  4.27597687e-02f, -4.97221276e-02f, 2.99475938e-02f, 1.03357203e-01f, -4.70764227e-02f, -4.37723547e-02f, 1.24529034e-01f, 1.11034103e-01f, 3.17585841e-02f, -1.68680158e-02f,
  -2.47248095e-02f, -6.82546496e-02f, -2.89740395e-02f, -2.54305732e-02f, -4.07125317e-02f, 9.42389220e-02f, 5.56022786e-02f, -4.02625301e-04f, 7.61932135e-02f, -3.62505503e-02f,
  1.16189845e-01f, 8.52838531e-02f, 8.05964991e-02f, -4.81376275e-02f, 1.05273128e-01f, 7.33200868e-04f, 1.25035569e-01f, 1.24748386e-01f, 3.45291160e-02f, 1.14973448e-02f,
  2.57448815e-02f, 7.13659897e-02f, 5.26923761e-02f, 1.68442458e-03f, 3.29406448e-02f, 3.06748562e-02f, -2.89073512e-02f, 2.65797563e-02f, 9.37119424e-02f, 7.47009367e-02f,
  -5.27555496e-02f, 7.67927244e-02f, 3.53632458e-02f, 1.01218022e-01f, 8.19342509e-02f, 8.07327181e-02f, -4.61860821e-02f, 9.59783047e-02f, 2.40479764e-02f, -6.35438263e-02f,
  -1.17218159e-01f, -1.06532052e-01f, -3.52077708e-02f, 1.23034604e-02f, 1.06904484e-01f, 4.28434787e-03f, 2.48942971e-02f, 1.51807398e-01f, -9.55556259e-02f, 7.52836242e-02f,
  -1.24635443e-01f, -8.35739076e-02f, -8.27244595e-02f, 6.80935383e-02f, -1.84226828e-03f, 1.61551889e-02f, -1.21142045e-01f, -1.02624819e-01f, -1.20416172e-01f, 8.97158906e-02f,
  -8.52818787e-02f, -3.42545435e-02f, 2.72578727e-02f, 1.04446113e-01f, 8.62550810e-02f, 1.69866998e-03f, -8.41722824e-03f, 1.45564452e-01f, 4.80235331e-02f, -3.34532596e-02f,
  1.25490516e-01f, 8.83186609e-02f, -3.10264737e-03f, -4.23103049e-02f, 1.19454099e-03f, 4.02123444e-02f, -2.42646024e-01f, 1.12372391e-01f, 3.82810570e-02f, 7.95443729e-03f,
  -1.05004586e-01f, -1.24366041e-02f, 1.62366420e-01f, 6.25405461e-02f, -1.27925962e-01f, -5.34549728e-03f, -7.70844594e-02f, -1.00309364e-01f, -1.62529163e-02f, -6.95313839e-03f,
  -9.95773524e-02f, -4.35256287e-02f, -2.07425188e-02f, -2.04725675e-02f, -7.77188763e-02f, 4.33410034e-02f, -9.08905938e-02f, 5.87860905e-02f, 7.66290426e-02f, 1.67809278e-02f,
  -1.59601755e-02f, 2.62143593e-02f, 2.27987897e-02f, 1.10645123e-01f, 6.50415421e-02f, -1.50044644e-02f, 1.10270977e-01f, 6.69010058e-02f, 1.06188208e-02f, 8.07980224e-02f,
  -1.83812100e-02f, -7.92618003e-03f, -1.79752931e-02f, 6.67149127e-02f, 9.96167213e-02f, -5.78861497e-02f, -6.49373680e-02f, 7.85725042e-02f, 6.52126670e-02f, 2.01611258e-02f,
  -7.16043115e-02f, 5.45686819e-02f, -1.23454453e-02f, -2.10035760e-02f, 2.39746626e-02f, -1.04567073e-02f, 3.33019644e-02f, 6.96181878e-02f, 3.87272462e-02f, -8.11908841e-02f,
  -4.76197451e-02f, -7.00444207e-02f, -7.12551251e-02f, -5.73406890e-02f, 6.38287067e-02f, 4.19457257e-02f, -6.81102425e-02f, 8.18776116e-02f, -6.03136308e-02f, -6.89062104e-02f,
  6.59026280e-02f, 1.00494558e-02f, 8.09885636e-02f, -4.05973904e-02f, -6.08991422e-02f, -8.24236795e-02f, -2.23513395e-02f, 9.27851722e-02f, 4.34273243e-04f, 2.29701418e-02f,
  1.38364201e-02f, 2.30759420e-02f, -5.87661825e-02f, 6.69900421e-03f, -4.55438718e-02f, 5.32680303e-02f, -3.39858071e-03f, -3.02383807e-02f, 9.56652537e-02f, 9.59598273e-02f,
  2.85904650e-02f, 8.21879208e-02f, 9.46592912e-02f, -8.04047193e-03f, -6.19126158e-03f, -2.68324986e-02f, 2.36787666e-02f, 6.60448801e-03f, -7.47682750e-02f, -3.60167623e-02f,
  -8.51403624e-02f, 6.12812862e-02f, 6.08538417e-03f, 4.83919829e-02f, 4.96623851e-02f, -3.88099439e-02f, -4.61184559e-03f, -4.71708663e-02f, 8.35632160e-02f, 2.67175809e-02f,
  3.87275964e-02f, -6.71933070e-02f, -3.46020237e-02f, 5.03479801e-02f, 2.17974093e-02f, 6.07143119e-02f, -6.12724423e-02f, 1.36916619e-03f, -8.47773626e-02f, 2.29502395e-02f,
  -1.85560323e-02f, 1.60529800e-02f, 3.04226782e-02f, -2.87595205e-02f, -7.17447922e-02f, -7.90588930e-02f, -4.65301163e-02f, 5.28694056e-02f, -6.33095950e-02f, -2.60379948e-02f,
  -5.92355244e-02f, -4.76229750e-02f, -5.90630844e-02f, 1.62054207e-02f, -1.87177844e-02f, 1.26379810e-03f, -5.99300899e-02f, 6.54685944e-02f, 1.01901792e-01f, 3.00292577e-05f,
  -7.78321919e-06f, 2.69885194e-02f, 4.92985584e-02f, -2.23214217e-02f, 9.05192457e-03f, 7.93843567e-02f, -4.34507541e-02f, 9.89655778e-02f, -1.15599260e-02f, -6.42456040e-02f,
  4.58571389e-02f, -5.70017584e-02f, 1.80742294e-02f, 3.39873545e-02f, -8.28304142e-02f, 8.08350816e-02f, 5.90887927e-02f, -5.86456843e-02f, -4.97164503e-02f, -7.57811219e-02f,
  2.68864483e-02f, -9.51278117e-03f, -5.00244834e-02f, -2.68844571e-02f, 1.30524067e-02f, 6.69398680e-02f, -7.01310560e-02f, -7.18829930e-02f, 1.22372154e-02f, 7.58593902e-02f,
  3.75350192e-02f, 3.30143422e-02f, 9.18161571e-02f, -6.59077764e-02f, 6.97205141e-02f, -1.15925295e-03f, -1.03927217e-02f, -2.07872689e-02f, 1.45076308e-02f, 6.07244149e-02f,
  -3.37236263e-02f, 4.47709113e-02f, 3.26914601e-02f, -7.24505410e-02f, 3.60536240e-02f, 2.64816266e-02f, 9.22430679e-02f, -4.56162319e-02f, 8.46859217e-02f, 6.29328191e-02f,
  6.70057759e-02f, -5.59637044e-03f, 6.03346676e-02f, 2.43706219e-02f, -1.51683856e-02f, -6.28551245e-02f, 1.69077437e-04f, 4.98838499e-02f, -2.02545673e-02f, -4.53177951e-02f,
  3.45319347e-03f, -6.75055087e-02f, 4.37136032e-02f, -7.31469095e-02f, 3.52497287e-02f, 2.72216741e-02f, -4.63596545e-02f, 5.39410785e-02f, 1.90664195e-02f, -7.86092281e-02f,
  -5.60828857e-02f, 5.70213906e-02f, 4.80851566e-04f, 6.33451492e-02f, -7.55523369e-02f, -1.31079284e-02f, -2.57893056e-02f, 1.03581939e-02f, -6.31105155e-02f, -6.28245175e-02f,
  -7.68436864e-02f, 8.51784423e-02f, 8.98284465e-02f, 9.17917415e-02f, 3.46535631e-02f, 3.00936960e-03f, -9.18536726e-03f, -3.21865231e-02f, 6.58978894e-02f, -7.93098509e-02f,
  -7.81169608e-02f, -4.03274782e-02f, 5.86596392e-02f, 8.55135769e-02f, -4.32620943e-02f, -9.74044576e-03f, 1.07392721e-01f, 1.02074863e-02f, -3.49537618e-02f, -9.39258039e-02f,
  7.59204924e-02f, 5.69402725e-02f, -2.47710627e-02f, 4.12049890e-02f, 7.74625540e-02f, -6.78601190e-02f, -7.98640028e-03f, 5.20874448e-02f, 1.08857922e-01f, -5.05605713e-02f,
  -7.38673210e-02f, 3.04534542e-03f, 2.18568575e-02f, 1.30813522e-02f, 2.80365311e-02f, 1.01553567e-01f, 6.46167323e-02f, 6.65720105e-02f, 1.14909131e-02f, -6.21266775e-02f,
  -4.30603847e-02f, 2.41299509e-04f, 4.65672612e-02f, -2.40247082e-02f, 8.70858505e-02f, -3.05051799e-03f, 9.87867936e-02f, 1.08179010e-01f, -8.71858150e-02f, -3.99240889e-02f,
  -3.26694027e-02f, -2.26436257e-02f, 5.56416735e-02f, 2.12832671e-02f, 2.96936072e-02f, 1.08200595e-01f, 1.49539076e-02f, 3.30693997e-03f, -8.99020582e-03f, -1.87923796e-02f,
  7.49498308e-02f, -3.60881723e-02f, -5.09871431e-02f, -6.46439120e-02f, 1.08275888e-03f, -6.53235894e-03f, -7.49196708e-02f, 1.10360608e-03f, -6.87668566e-03f, -8.57610255e-02f,
  -7.34703019e-02f, 9.87937227e-02f, 8.01309124e-02f, -6.90582544e-02f, 9.21455845e-02f, -4.32408787e-02f, 1.97639074e-02f, -5.03478646e-02f, 8.49847421e-02f, -3.48865204e-02f,
  -8.76708850e-02f, -5.19147553e-02f, 2.09354281e-01f, 5.59097938e-02f, -1.32225659e-02f, 7.75915608e-02f, 2.95148157e-02f, 6.16767481e-02f, 1.07665621e-01f, 6.59522936e-02f,
  -3.91800664e-02f, 1.20142974e-01f, 4.64170687e-02f, -3.66121903e-02f, 1.10875256e-02f, 1.26630530e-01f, 9.58332717e-02f, 8.60925615e-02f, 3.90769206e-02f, 4.63895239e-02f,
  1.92620650e-01f, 7.26542920e-02f, 4.28288281e-02f, -2.97688879e-02f, 2.39360631e-02f, -2.21138541e-02f, 8.66271649e-03f, 3.61470766e-02f, 4.99665104e-02f, 1.39498055e-01f,
  -5.75181283e-03f, 7.23375231e-02f, -3.58643569e-02f, 1.40897170e-01f, 9.11628306e-02f, 1.50978625e-01f, 1.95111688e-02f, 1.07552066e-01f, 9.34179202e-02f, -3.98456827e-02f,
  7.36756921e-02f, 1.39892602e-03f, 1.15039900e-01f, -2.09887209e-03f, 3.87752540e-02f, -6.14034943e-02f, -4.93392497e-02f, 4.68802378e-02f, 1.54567987e-01f, 1.02811627e-01f,
  1.25226572e-01f, -2.88343728e-02f, 1.66047096e-01f, 1.95137456e-01f, 5.33557832e-02f, -1.75619218e-02f, -5.60662970e-02f, 2.07804721e-02f, 2.45883968e-02f, 1.42214537e-01f,
  -1.06080115e-01f, 8.95912498e-02f, 4.68656309e-02f, 1.44439444e-01f, -5.25599681e-02f, -1.81348965e-01f, -3.14984396e-02f, 1.01672478e-01f, 6.40771687e-02f, 1.91768453e-01f,
  -3.32185365e-02f, 6.74958974e-02f, -1.22330353e-01f, -4.07331251e-02f, -1.39295189e-02f, -9.30313468e-02f, -5.85243031e-02f, 1.05209425e-01f, -6.18258119e-02f, -1.61221653e-01f,
  4.70919441e-03f, 9.86039117e-02f, -5.88712245e-02f, -6.15828075e-02f, -1.40128240e-01f, 1.58071017e-03f, -4.94128652e-02f, 4.96199168e-02f, 5.72330244e-02f, -5.79162240e-02f,
  -2.66142398e-01f, -2.81419128e-01f, 4.86732610e-02f, 7.96566010e-02f, -5.55468202e-02f, 6.32048212e-03f, -9.12716687e-02f, 1.24655575e-01f, 1.03607953e-01f, -6.65074065e-02f,
  -9.27818194e-02f, -7.28405640e-02f, 1.39493868e-01f, 6.52171613e-04f, -1.71783999e-01f, -1.48580018e-02f, 9.46821552e-03f, -5.64425327e-02f, -7.37871155e-02f, 1.34288922e-01f,
  -5.77600189e-02f, 5.46958297e-04f, 4.41415571e-02f, 6.42906949e-02f, -8.63159373e-02f, -4.17675897e-02f, -3.95030715e-02f, -2.72009596e-02f, -1.08293034e-01f, -2.20411122e-02f,
  -6.38517961e-02f, 1.98149476e-02f, 2.05014795e-01f, 6.97609708e-02f, 1.00057416e-01f, 1.39888540e-01f, -1.29725933e-01f, 5.69274686e-02f, -3.17561775e-02f, 7.34970495e-02f,
  4.30243723e-02f, 1.25403464e-01f, -7.76372775e-02f, 1.29425034e-01f, 2.33546887e-02f, 8.24525058e-02f, 1.07795984e-01f, 1.05732292e-01f, 1.09819956e-01f, 6.78744586e-03f,
  5.64474910e-02f, -6.22796640e-02f, -7.77706224e-03f, -1.21201323e-02f, -5.81910312e-02f, 1.12953208e-01f, 1.13835551e-01f, 6.65838718e-02f, 6.33966774e-02f, 9.64667425e-02f,
  6.07998781e-02f, 1.03319295e-01f, 5.72517961e-02f, 4.13389057e-02f, -9.21823736e-03f, 7.54190832e-02f, 7.56877065e-02f, 1.11748144e-01f, 3.88192721e-02f, -6.66550919e-02f,
  -1.12954061e-02f, -2.61008609e-02f, 8.50603953e-02f, 3.70861813e-02f, 7.35316649e-02f, -5.02622314e-02f, -8.38532299e-02f, 4.43839356e-02f, 2.13532262e-02f, 9.22989771e-02f,
  -5.46614341e-02f, 1.17038965e-01f, 5.99333867e-02f, 3.03557348e-02f, 1.68431103e-02f, -3.50425206e-02f, 7.99390152e-02f, 3.24234515e-02f, 5.41265160e-02f, -2.64407918e-02f,
  1.17489249e-01f, -9.11371689e-03f, 5.06330328e-03f, 1.07205845e-01f, 1.61051862e-02f, 1.61966700e-02f, -1.59761861e-01f, 2.63895132e-02f, 5.48994206e-02f, -1.03659503e-01f,
  3.02129015e-02f, -5.69665842e-02f, 1.04793627e-02f, -7.33728334e-02f, 6.81572407e-02f, -9.30688996e-03f, -7.25036487e-03f, 3.08684912e-02f, 2.25955453e-02f, 4.85377833e-02f,
  -8.60838499e-03f, 8.94491076e-02f, 4.40257564e-02f, -8.42579529e-02f, 7.31187984e-02f, 2.02204753e-02f, 4.99477759e-02f, 6.95278570e-02f, -4.36718995e-03f, -1.12896368e-01f,
  6.35342151e-02f, 4.38583381e-02f, 4.14880216e-02f, -8.43542293e-02f, 1.58838943e-01f, -1.69367646e-03f, 5.51528297e-02f, -6.53717816e-02f, 1.41495019e-01f, 4.38422039e-02f,
  -3.33095603e-02f, 1.71512231e-01f, 7.82809034e-02f, -4.41300832e-02f, -1.09323964e-01f, 3.28285657e-02f, -5.00886701e-02f, -3.24615510e-03f, -3.10097169e-02f, 1.43844277e-01f,
  -1.30328357e-01f, -8.70297253e-02f, -1.70797892e-02f, 4.15926687e-02f, -3.54376971e-03f, -3.64902709e-03f, 2.52497829e-02f, -6.61600232e-02f, 3.46401744e-02f, -4.46530804e-02f,
  -4.94383574e-02f, -4.74171229e-02f, 5.93884438e-02f, -5.62151615e-03f, 4.05301452e-02f, -1.20189609e-02f, 5.07359207e-02f, 5.44914789e-03f, -1.25813531e-02f, 8.47110301e-02f,
  -1.72229130e-02f, 6.83012456e-02f, 8.71410370e-02f, -5.94497984e-03f, 3.80646028e-02f, -6.76450580e-02f, -7.36991838e-02f, -3.78248841e-02f, -1.38294445e-02f, 1.08762905e-01f,
  -5.95510043e-02f, -9.96687668e-05f, 5.36956191e-02f, -1.12214284e-02f, 1.05318628e-01f, -3.75993848e-02f, -2.36360729e-02f, 2.36290377e-02f, 1.02197513e-01f, -1.19736907e-03f,
  3.21166329e-02f, -7.00198114e-02f, 3.77405547e-02f, -3.41992043e-02f, -6.10358454e-02f, 2.88264621e-02f, 4.26745340e-02f, -5.09770252e-02f, 1.13412134e-01f, 1.06679879e-01f,
  -3.00509594e-02f, -5.81473820e-02f, -3.03270947e-02f, 6.13508634e-02f, -3.26528139e-02f, 2.46708747e-02f, -8.35064054e-03f, -7.12720752e-02f, -2.94688810e-02f, -7.63019081e-03f,
  1.15503855e-02f, 1.43221822e-02f, -2.42802482e-02f, -6.54503256e-02f, -7.17736557e-02f, 2.95439400e-02f, 7.58391023e-02f, -2.68574134e-02f, 6.32723346e-02f, 1.45175192e-03f,
  2.41300128e-02f, 1.06881177e-02f, -3.70457061e-02f, 7.32759759e-02f, 1.04415976e-01f, -2.58041043e-02f, 4.48919497e-02f, 6.08594753e-02f, 7.80103449e-03f, -3.67291383e-02f,
  -6.78982288e-02f, 4.07609269e-02f, 6.59313723e-02f, -6.71882406e-02f, -6.14348352e-02f, -5.58800697e-02f, -3.09565896e-03f, 2.80563701e-02f, 4.37550135e-02f, -6.81311563e-02f,
  1.00625731e-01f, 1.29899085e-02f, 5.09618632e-02f, -9.25105810e-02f, 4.67160009e-02f, -3.90327163e-02f, 5.95375672e-02f, 4.38984744e-02f, 2.21855044e-02f, -4.14962806e-02f,
  6.02460206e-02f, 6.90998510e-02f, -3.15162875e-02f, 4.95829284e-02f, 2.64062416e-02f, -7.21796229e-03f, -7.19906837e-02f, -1.17036533e-02f, 1.04180388e-01f, 3.37089933e-02f,
  5.90776242e-02f, 9.37959850e-02f, -1.41162664e-01f, -4.97307116e-03f, 5.75208524e-03f, -5.02714701e-02f, 1.56023443e-01f, 7.46549368e-02f, -7.65268281e-02f, -6.84537590e-02f,
  3.40472199e-02f, -8.13283473e-02f, 8.29264149e-02f, 1.14132866e-01f, 4.79493756e-03f, -5.57674877e-02f, -6.06442913e-02f, 1.23277612e-01f, -1.22846223e-01f, 8.24594125e-03f,
  -4.28830087e-03f, -5.89471869e-02f, -1.35430163e-02f, -4.50708382e-02f, 2.84168739e-02f, -3.23274061e-02f, 1.10319130e-01f, -2.81877909e-02f, -4.89979833e-02f, 2.90212687e-02f,
  7.57168531e-02f, 4.05041128e-02f, 6.17043078e-02f, 6.07208535e-02f, -5.76679073e-02f, 7.79428184e-02f, -7.49079213e-02f, 8.15958679e-02f, -4.42020707e-02f, -6.07305691e-02f,
  -4.10664156e-02f, -3.06951795e-02f, -7.39400415e-03f, 5.42431660e-02f, -1.87636819e-02f, -3.12221260e-03f, 8.17076936e-02f, 7.23070139e-03f, -4.81165834e-02f, 9.66878757e-02f,
  4.27334607e-02f, 9.45652574e-02f, 6.92495778e-02f, -1.08831795e-02f, 4.21613529e-02f, -7.75487870e-02f, 8.88524354e-02f, -6.44440651e-02f, -4.79327366e-02f, 7.25506544e-02f,
  3.31018046e-02f, -7.33671859e-02f, -6.86421394e-02f, -4.76375222e-02f, -2.65415031e-02f, -1.03301555e-02f, -2.65804753e-02f, -4.16330621e-02f, -3.52843665e-02f, 1.03051914e-02f,
  -1.23805897e-02f, 7.05412328e-02f, 5.06359860e-02f, 5.32665662e-02f, 4.79130149e-02f, -2.08022222e-02f, 3.98056619e-02f, 2.85220798e-03f, -5.31917289e-02f, 7.96340480e-02f,
  1.46541381e-02f, 8.71950611e-02f, 6.61132708e-02f, 8.89646411e-02f, 3.16626877e-02f, -8.39369651e-03f, 8.43861848e-02f, -3.11589483e-02f, 5.37834242e-02f, 7.05544697e-03f,
  4.75732721e-02f, 7.15272874e-02f, -4.30358127e-02f, 9.36233774e-02f, 1.03430897e-01f, -1.16842389e-02f, 8.61532763e-02f, 1.10319525e-01f, 1.20369755e-01f, 5.00139557e-02f,
  4.74506728e-02f, 6.90399632e-02f, -9.33169276e-02f, 7.34059736e-02f, 1.34377986e-01f, -5.47676198e-02f, -2.14913450e-02f, -7.83914998e-02f, -1.69976465e-02f, 2.03923844e-02f,
  5.88332154e-02f, 3.36610191e-02f, -3.51851992e-02f, -4.60851230e-02f, -1.11105315e-01f, -1.06148735e-01f, 1.18631348e-01f, -1.07143179e-01f, -9.04939249e-02f, -7.81082213e-02f,
  4.32060584e-02f, 2.27628443e-02f, 5.78446649e-02f, 1.25842476e-02f, 6.08730689e-02f, 1.55230341e-02f, 6.00742064e-02f, -9.41227674e-02f, 2.52572671e-02f, 6.51373714e-02f,
  9.99851990e-03f, 5.59131391e-02f, 3.46503854e-02f, -1.80641115e-02f, 5.23416065e-02f, 7.69027025e-02f, 8.57347623e-02f, 6.28466606e-02f, 1.13867922e-02f, 3.53231840e-02f,
  9.24089625e-02f, -6.75440580e-02f, 2.12316252e-02f, 9.56298411e-03f, -5.12365066e-02f, 5.48407212e-02f, 1.15552228e-02f, -4.14572395e-02f, -3.45606580e-02f, 1.64137445e-02f,
  -6.65176436e-02f, 4.74981405e-02f, -5.16824536e-02f, -4.82793413e-02f, 8.50910768e-02f, -2.12869849e-02f, -3.78080457e-02f, -2.42139790e-02f, 1.22910598e-02f, 6.89965710e-02f,
  -5.18328063e-02f, 9.10802395e-04f, 7.72477239e-02f, -7.24345297e-02f, -5.14266156e-02f, -7.51705617e-02f, -9.87960547e-02f, 1.52125908e-02f, -5.81170619e-02f, -2.21123379e-02f,
  -2.87002735e-02f, 2.70399991e-02f, 9.81986523e-02f, 8.92993584e-02f, -2.58500241e-02f, 5.78006580e-02f, -3.58539969e-02f, 9.88073573e-02f, 1.99157093e-02f, 9.87899303e-02f,
  3.45736928e-02f, -2.37389207e-02f, -3.62765826e-02f, 8.33300967e-03f, 7.29406029e-02f, -2.65129432e-02f, 3.44138406e-02f, 1.29149437e-01f, -6.04464523e-02f, 3.04232873e-02f,
  1.00675471e-01f, -2.27366369e-02f, -2.61268988e-02f, 6.25777170e-02f, 2.94764843e-02f, 8.17130730e-02f, 6.27716109e-02f, -4.84654158e-02f, 9.08363760e-02f, 3.38619687e-02f,
  5.87572753e-02f, 1.15942970e-01f, 3.71526442e-02f, 6.02293871e-02f, 8.69904384e-02f, -2.06433032e-02f, 8.70343596e-02f, 2.12046616e-02f, 2.93110404e-02f, -7.44830584e-03f,
  9.10311118e-02f, 8.56851563e-02f, 3.85080390e-02f, 1.38474509e-01f, -1.41757755e-02f, 4.00004126e-02f, 7.52585977e-02f, -3.15807834e-02f, -1.08166775e-02f, 2.49402859e-04f,
  -7.45969191e-02f, 7.69960061e-02f, 9.14524719e-02f, 1.71687081e-02f, 7.39173666e-02f, -1.68079380e-02f, -6.41585141e-02f, -1.47623450e-01f, -3.77992578e-02f, 5.84656373e-02f,
  -3.10635734e-02f, 3.57437432e-02f, 1.05302952e-01f, 8.16948712e-02f, -1.64315373e-01f, -1.32122815e-01f, -6.81656748e-02f, -4.13942635e-02f, -6.91139698e-02f, -1.16147622e-01f,
  -3.39067914e-02f, -9.06141698e-02f, 3.28996330e-02f, -1.22346357e-02f, 1.07165515e-01f, 2.26927642e-02f, -1.54752070e-02f, 7.33895153e-02f, 1.62303448e-01f, -1.65114179e-01f,
  5.54451086e-02f, 9.64677185e-02f, -1.98361780e-02f, -1.13810793e-01f, 3.81098948e-02f, 9.60684419e-02f, 1.05784852e-02f, 2.17027846e-03f, 4.54478851e-03f, 7.29113817e-02f,
  4.12023291e-02f, 1.45363972e-01f, 2.99499854e-02f, 1.65858194e-01f, -6.29883558e-02f, -1.13180108e-01f, 1.01226375e-01f, 5.56850061e-02f, 7.16042221e-02f, -5.73248900e-02f,
  -7.37090930e-02f, 2.52074227e-02f, 1.73698246e-01f, -1.09403618e-01f, -2.10692808e-02f, 9.71396565e-02f, -5.26087098e-02f, -4.45650592e-02f, -7.28418753e-02f, 2.97662709e-02f,
  6.47066981e-02f, -2.15440504e-02f, -7.77279139e-02f, 1.14800438e-01f, -9.41010192e-02f, 1.52916731e-02f, 1.86155364e-02f, 3.23359147e-02f, -1.40403528e-02f, 6.40008375e-02f,
  1.41473562e-02f, 5.42207435e-02f, -2.25953367e-02f, -1.85001455e-03f, -2.22321134e-03f, 5.75125823e-03f, 3.19310427e-02f, -1.14235766e-02f, 4.80955653e-02f, 8.51349812e-03f,
  -6.07589744e-02f, 1.98754463e-02f, 2.75447760e-02f, -2.43715979e-02f, 5.49657904e-02f, 4.69709411e-02f, -3.02022602e-02f, 2.33314801e-02f, -4.85528111e-02f, 3.88684683e-02f,
  8.47661644e-02f, -3.25110890e-02f, 7.98639953e-02f, -5.54153509e-02f, -2.36887094e-02f, -7.92135671e-02f, -2.06311513e-02f, 3.59897725e-02f, 8.30529034e-02f, 1.81385688e-02f,
  9.02208313e-02f, 1.66662410e-02f, 4.18318026e-02f, 6.74883882e-03f, 3.71266417e-02f, 9.14456148e-04f, -4.48588245e-02f, 2.68001016e-02f, -9.41302907e-03f, 3.48394997e-02f,
  1.49449455e-02f, 3.57817784e-02f, 9.50257853e-03f, 1.53329559e-02f, -3.66969146e-02f, 7.55699351e-02f, 1.76638067e-02f, -2.03311872e-02f, 3.68568413e-02f, -7.83404186e-02f,
  -5.59794977e-02f, -2.59950645e-02f, 5.70507199e-02f, 1.28359664e-02f, -5.56880087e-02f, 2.38210633e-02f, 4.70849387e-02f, 4.24605832e-02f, 6.98072836e-02f, 1.10241398e-03f,
  -4.73159514e-02f, -6.93849921e-02f, -8.94180685e-02f, -9.39945430e-02f, 4.81890282e-03f, -6.70602992e-02f, 2.42854860e-02f, -2.61478834e-02f, -5.49854077e-02f, -4.72512729e-02f,
  -2.59196162e-02f, -8.16912856e-03f, 2.62898915e-02f, 8.39868113e-02f, -1.05327651e-01f, 4.80741411e-02f, -1.67515632e-02f, 8.29428807e-02f, 6.76186290e-03f, -7.60908052e-02f,
  1.19511895e-02f, -7.08032027e-03f, -7.86108747e-02f, -9.95705649e-02f, -7.21191168e-02f, 1.86596420e-02f, 5.74160367e-02f, 5.85886016e-02f, 1.12565735e-03f, -3.25237811e-02f,
  1.65909734e-02f, 6.64612278e-02f, -1.58397132e-03f, -9.40758809e-02f, 1.66531894e-02f, -3.18451896e-02f, -1.36543393e-01f, 8.25459212e-02f, -6.32851645e-02f, -3.29477824e-02f,
  -9.65017360e-03f, -8.19360316e-02f, 6.89932257e-02f, -5.44118807e-02f, -3.09766941e-02f, 5.86036332e-02f, -1.75967719e-03f, -3.96219781e-03f, 3.66126336e-02f, -4.33700122e-02f,
  7.13890838e-03f, -5.96053004e-02f, -5.64323328e-02f, 9.12996754e-02f, -3.54680791e-03f, 3.76556329e-02f, 2.09185183e-02f, -4.89656888e-02f, 6.67093620e-02f, 9.38739255e-02f,
  -1.27486167e-02f, -5.53341992e-02f, 7.39400238e-02f, 6.75510010e-03f, -5.60416654e-02f, 6.81645945e-02f, 8.89609158e-02f, -4.95867133e-02f, -1.86716001e-02f, 3.68003771e-02f,
  2.29609795e-02f, -2.35299524e-02f, 8.79750326e-02f, 4.37450521e-02f, 7.32695386e-02f, -2.25439481e-02f, -6.61769835e-03f, -5.40286750e-02f, 2.59946175e-02f, 8.50523412e-02f,
  1.14701264e-01f, 1.34632904e-02f, 3.63421813e-02f, 5.99068478e-02f, 1.70917679e-02f, 9.85739902e-02f, 1.19807065e-01f, -6.17608540e-02f, 1.26832239e-02f, 7.15602264e-02f,
  5.42157702e-02f, 9.82356369e-02f, 2.18273941e-02f, -3.23110037e-02f, 5.13636954e-02f, -2.01973319e-02f, -2.33402029e-02f, 2.63757389e-02f, -2.63648592e-02f, 4.18154113e-02f,
  1.32609457e-01f, 1.12329021e-01f, -4.47444618e-02f, 6.12388328e-02f, 4.66143340e-02f, -5.94549403e-02f, 4.85459603e-02f, 4.58140485e-02f, 5.87360635e-02f, -4.26710062e-02f,
  6.91641048e-02f, -3.80195715e-02f, 8.09720531e-02f, 4.50736992e-02f, 3.52544710e-02f, 7.67709985e-02f, 2.66622566e-02f, -2.35440582e-03f, 1.32849393e-02f, -4.61199395e-02f,
  -5.14325388e-02f, -3.98089550e-02f, -5.97508065e-02f, 6.30165562e-02f, -5.26732765e-04f, -4.12623361e-02f, 8.20697919e-02f, 9.94904041e-02f, -7.26283863e-02f, 6.40497431e-02f,
  -3.99310887e-02f, -6.48993775e-02f, -8.05591494e-02f, 8.89128894e-02f, 1.07223630e-01f, -6.03133738e-02f, -3.27878632e-02f, -1.13084346e-01f, -7.38579407e-02f, 5.22360839e-02f,
  8.26573223e-02f, 9.39630046e-02f, -6.78630173e-02f, -5.29125445e-02f, -4.77648377e-02f, 5.88299148e-02f, 7.35303462e-02f, 3.33708972e-02f, -5.36625944e-02f, -8.83441269e-02f,
  -1.50477231e-01f, 1.23299688e-01f, -5.18914163e-02f, -4.72669192e-02f, -1.10302605e-01f, -3.15948613e-02f, -3.27775925e-02f, 4.55696583e-02f, 4.02782857e-03f, 1.54666826e-01f,
  -6.48432365e-03f, -1.00714706e-01f, -6.19797893e-02f, 2.27681194e-02f, -7.26771355e-02f, -1.80571936e-02f, 7.30486736e-02f, 5.65019809e-02f, -1.08232088e-01f, -3.34119536e-02f,
  1.50112277e-02f, -1.14060249e-02f, -7.47900084e-02f, 4.72898930e-02f, 2.33022422e-02f, -5.15790284e-02f, 6.68212995e-02f, -3.25898975e-02f, -1.11239091e-01f, -6.64049089e-02f,
  1.30784526e-01f, -1.57120638e-02f, -2.30401289e-02f, -5.77289015e-02f, -2.56387498e-02f, 5.08212857e-02f, -4.87262337e-03f, 1.16057120e-01f, 4.96922322e-02f, -1.82854719e-02f,
  9.50697958e-02f, 9.36274603e-02f, -1.86042637e-02f, 9.68579501e-02f, 3.86502221e-02f, -3.80439870e-02f, -9.08176154e-02f, -8.70827399e-03f, -3.45328934e-02f, 6.25141114e-02f,
  7.06528053e-02f, -9.16369930e-02f, 1.14062697e-01f, -3.68150175e-02f, -2.29395237e-02f, -6.63456321e-02f, 6.65929914e-02f, 5.00702709e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -8.08507651e-02f, 2.49985177e-02f, 1.48089258e-02f, 4.99908328e-02f, 2.07146071e-03f, -6.30590916e-02f, 8.72125551e-02f, 6.67019784e-02f, -3.38258706e-02f, -5.24339750e-02f,
  -6.92788288e-02f, 3.23571451e-02f, 8.85787904e-02f, 9.22408253e-02f, 8.36581588e-02f, 8.78586620e-02f, 1.10310977e-02f, -8.72679427e-03f, 1.79061703e-02f, 1.16957180e-01f,
  7.19963983e-02f, 2.03530584e-02f, 3.78289931e-02f, 6.29594177e-02f, 8.57312307e-02f, -4.06175852e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -2.82200873e-01f, -1.12100169e-01f, -1.81663901e-01f, -8.66304338e-02f, 1.63070604e-01f, 9.85260829e-02f, -2.85305768e-01f, -6.12234473e-02f, -1.79400101e-01f, 1.11491354e-02f,
  -3.02074384e-02f, 7.80559331e-03f, 7.83360079e-02f, -2.44431552e-02f, 2.39409786e-02f, -1.54596567e-01f, -2.00760458e-02f, 3.71311069e-03f, 9.90477800e-02f, 1.23760499e-01f,
  -6.92514732e-05f, -3.04578990e-01f, -1.47471264e-01f, -4.01065387e-02f, 6.83195665e-02f, -1.48109496e-01f, -2.47490495e-01f, 5.92294410e-02f, -1.48385853e-01f, 4.42255437e-02f,
  -3.22986878e-02f, -1.84237510e-01f, -1.63833089e-02f, -1.83635861e-01f, -3.15075189e-01f, -9.74174738e-02f, -2.12571651e-01f, -5.77288270e-02f, -1.29932016e-01f, 1.58444434e-01f,
  4.94589517e-03f, 1.01703607e-01f, -3.60319257e-01f, 1.05939452e-02f, -1.80074230e-01f, 2.50657704e-02f, 6.56116679e-02f, 1.25395834e-01f, -3.57616087e-03f, 7.83113539e-02f,
  -2.94756204e-01f, 2.29513347e-01f, 1.39469177e-01f, 2.16540247e-01f, -3.14510226e-01f, 1.64829135e-01f, -7.23231351e-04f, -5.95370121e-02f, 2.15578929e-01f, 1.37120575e-01f,
  1.40397012e-01f, -3.38664770e-01f, -6.52347878e-02f, 3.45963351e-02f, 2.43634596e-01f, 2.22642139e-01f, 3.04528415e-01f, -2.06932500e-01f, -2.89723575e-02f, -1.73124760e-01f,
  -7.53698573e-02f, 3.53370845e-01f, 2.14991299e-03f, 2.44443476e-01f, 1.86410472e-02f, 1.02551840e-01f, 9.12209973e-02f, 2.70520121e-01f, 1.51010543e-01f, 2.81661540e-01f,
  3.44028383e-01f, -9.83406603e-02f, -1.70497626e-01f, 2.12232739e-01f, -1.96351528e-01f, -2.08726287e-01f, -5.72943687e-02f, 2.03292117e-01f, 3.87414619e-02f, 1.98716059e-01f,
  -1.55097485e-01f, 2.28917506e-02f, -5.11600077e-02f, 2.66841531e-01f, -5.03534600e-02f, 3.81844416e-02f, -2.39772070e-02f, -9.04115587e-02f, -6.73497245e-02f, 2.02637523e-01f,
  -1.75678656e-02f, -1.17584048e-02f, -2.56939903e-02f, -1.32903710e-01f, -4.31037545e-02f, 1.47813991e-01f, -1.48193866e-01f, 3.47533561e-02f, 9.05775353e-02f, 2.84569442e-01f,
  -1.49745435e-01f, -3.03714573e-02f, -9.01184231e-02f, 7.67089278e-02f, -2.75362767e-02f, -8.48619267e-03f, 2.43215915e-02f, 2.91707851e-02f, 2.93801278e-01f, -9.87127796e-02f,
  -7.65987337e-02f, -1.63674384e-01f, -2.18272343e-01f, -8.14291909e-02f, 2.34001363e-03f, 2.26654280e-02f, 1.32964343e-01f, 1.76205799e-01f, -1.13081194e-01f, 6.72683269e-02f,
  2.02114675e-02f, 1.27162099e-01f, 3.01907837e-01f, 3.43271494e-02f, -2.57722080e-01f, -1.94392577e-02f, -2.81439185e-01f, -1.65735632e-01f, 1.08578585e-01f, -2.39866272e-01f,
  1.12083845e-01f, -3.60520124e-01f, -2.07086831e-01f, -2.95843422e-01f, 2.14988813e-02f, 2.38751277e-01f, -1.33986529e-02f, 9.26387385e-02f, 9.29212868e-02f, -1.34276733e-01f,
  -3.45311756e-03f, 1.80130333e-01f, 1.78922892e-01f, 8.98330659e-02f, 1.40172437e-01f, 1.59440532e-01f, 4.14843112e-02f, 1.62274137e-01f, -1.12109281e-01f, 1.16438597e-01f,
  8.99813995e-02f, -4.55007330e-03f, -3.96065041e-02f, 6.56951964e-02f, 6.93421885e-02f, 3.91484946e-02f, -1.66826785e-01f, 1.01875171e-01f, 1.77017763e-01f, 6.67808652e-02f,
  -1.14393279e-01f, 1.04394808e-01f, -1.51587412e-01f, -1.75840273e-01f, 1.82046276e-02f, -5.16404165e-03f, 9.84072462e-02f, -3.06071043e-01f, 1.81578919e-01f, 3.57708275e-01f,
  -2.73347944e-01f, 2.39017513e-02f, 6.14550859e-02f, -3.21478486e-01f, 1.08263537e-01f, 3.14979404e-02f, 1.26906753e-01f, -7.33473431e-03f, -1.03817903e-01f, -3.04537892e-01f,
  4.15717095e-01f, -8.25854167e-02f, 1.70853555e-01f, 4.49543148e-01f, 3.71915013e-01f, 4.19475473e-02f, 1.26871482e-01f, 5.23752347e-02f, -8.97013918e-02f, 2.11296782e-01f,
  8.49424601e-02f, 5.02408668e-02f, -8.57553631e-02f, -7.15726912e-02f, 7.80430585e-02f, 1.90310061e-01f, 2.76046723e-01f, 2.94421911e-01f, -2.30252743e-01f, 2.25098878e-01f,
  3.05888146e-01f, 7.26170912e-02f, 3.80084991e-01f, -1.54905438e-01f, 2.62587130e-01f, 1.00416973e-01f, -8.37027654e-02f, -2.60524638e-02f, -4.17153895e-01f, 7.73990601e-02f,
  -1.04203537e-01f, 3.43716741e-01f, -1.07404357e-02f, 1.34217039e-01f, -1.26442537e-01f, -2.65664488e-01f, 9.13682729e-02f, 3.05277836e-02f, -2.50743777e-01f, 2.00960815e-01f,
  -5.13126627e-02f, 8.99368972e-02f, -1.56650871e-01f, 2.29643583e-01f, -2.12886259e-02f, -9.64521393e-02f, -9.66198146e-02f, -1.27496779e-01f, -3.73788886e-02f, 5.50474301e-02f,
  7.75263160e-02f, 1.21136732e-01f, -3.85648347e-02f, -9.17427316e-02f, 3.64790931e-02f, -1.72889218e-01f, 5.64618595e-02f, -6.43835366e-02f, -5.31704016e-02f, 3.72597665e-01f,
  -1.86834872e-01f, -1.51531145e-01f, -1.56933218e-01f, -1.84065491e-01f, 8.88627395e-02f, 1.62727207e-01f, 7.73960203e-02f, -1.18104406e-01f, 1.47823945e-01f, -9.87168700e-02f,
  -3.47691506e-01f, -2.19912603e-02f, 3.61315548e-01f, -2.56682560e-02f, 1.23260863e-01f, 8.48538950e-02f, 7.94891268e-02f, 1.26682192e-01f, -3.62810075e-01f, 2.51251578e-01f,
  -6.73126429e-02f, 2.16871146e-02f, -1.21965371e-01f, -1.50568888e-01f, 4.47798111e-02f, -2.21555769e-01f, -3.09571475e-02f, 1.70306981e-01f, 1.55064864e-02f, 1.47172570e-01f,
  1.10638656e-01f, -1.81777105e-02f, 9.06367749e-02f, -9.02243853e-02f, -4.50031571e-02f, -1.44392014e-01f, -2.64447302e-01f, 3.67637463e-02f, -8.00048709e-02f, -1.58449471e-01f,
  3.84383827e-01f, 3.08304615e-02f, 8.55304003e-02f, 5.24839647e-02f, -4.11271378e-02f, -6.45992458e-02f, -2.76822329e-01f, -1.05272479e-01f, 1.62670910e-01f, 2.17404023e-01f,
  -5.62265441e-02f, 6.81621805e-02f, 6.07639663e-02f, -1.53816834e-01f, -2.97729634e-02f, 1.20374300e-01f, -7.07489252e-02f, 3.50819305e-02f, 1.53384849e-01f, -1.05312013e-03f,
  1.31686747e-01f, 2.00404838e-01f, 2.48273354e-05f, -1.80611938e-01f, 1.42351493e-01f, 1.17569268e-01f, 2.41252966e-03f, -8.27606246e-02f, 5.16087078e-02f, -2.57818490e-01f,
  1.06240928e-01f, 8.47633183e-02f, -2.07890347e-02f, 6.51013553e-02f, 3.48870277e-01f, -2.79186636e-01f, -2.58031279e-01f, -1.38450488e-01f, -1.21472210e-01f, -2.29698509e-01f,
  5.62526472e-02f, 6.00087941e-02f, -1.53999448e-01f, -1.24262981e-01f, 1.77032501e-02f, -1.86379403e-02f, -1.41550735e-01f, -2.38650620e-01f, -9.82495993e-02f, 9.66317877e-02f,
  -1.99973062e-01f, -1.32462248e-01f, 2.54817873e-01f, 4.15257886e-02f, -5.26400171e-02f, 2.55957276e-01f, -2.52133757e-01f, -3.63995939e-01f, -9.27193835e-02f, 1.10682301e-01f,
  -5.67414835e-02f, -1.12262890e-01f, -1.98983662e-02f, -1.15898028e-02f, 1.23459697e-01f, -4.35854122e-02f, -6.94811791e-02f, 4.06993479e-02f, 6.55063316e-02f, -2.17739433e-01f,
  2.81870216e-01f, -2.22492635e-01f, -4.54791188e-02f, 8.74320269e-02f, 1.46896746e-02f, 1.25234788e-02f, 8.11348185e-02f, -5.56714423e-02f, -1.25686064e-01f, 1.30083442e-01f,
  -1.16211958e-01f, -7.87657872e-02f, -3.21563557e-02f, 9.46889445e-02f, 1.49560601e-01f, -6.03423594e-03f, -9.51825082e-02f, 3.40896577e-01f, -1.14523962e-01f, 9.06454921e-02f,
  -1.34737939e-01f, -2.04421699e-01f, 5.69563545e-02f, 2.01635435e-01f, 1.20172106e-01f, -1.25804320e-01f, 5.61335403e-03f, -7.98009634e-02f, -2.88958997e-01f, -2.63257716e-02f,
  7.84852579e-02f, 2.84334291e-02f, 3.21855545e-01f, 4.45913114e-02f, -1.26044247e-02f, -3.54661010e-02f, 1.07757196e-01f, 9.14106965e-02f, 3.64940725e-02f, 6.18924350e-02f,
  -1.27567828e-01f, -6.08982220e-02f, -4.26957123e-02f, -2.06206776e-02f, 6.17073067e-02f, -1.71053708e-02f, 1.91748127e-01f, 1.53105691e-01f, 1.10366046e-02f, 6.98791966e-02f,
  1.97405249e-01f, -3.20062228e-02f, 1.29645884e-01f, 9.48387682e-02f, 2.22739130e-01f, -9.14478451e-02f, -2.62964400e-03f, 2.94249412e-02f, -2.10360289e-01f, -3.42162579e-01f,
  5.91715463e-02f, 3.56264636e-02f, 1.09143861e-01f, 4.46646661e-02f, -8.00526049e-03f, 1.09557897e-01f, 2.20323324e-01f, 1.09215669e-01f, 8.70592743e-02f, 2.77800113e-01f,
  1.00112058e-01f, -3.44173834e-02f, -8.02507158e-03f, 5.60162924e-02f, 2.31934320e-02f, -2.77049780e-01f, 2.69866049e-01f, 3.06070000e-01f, -2.52007961e-01f, 1.20498218e-01f,
  -1.86614990e-01f, -3.11624378e-01f, -2.51170874e-01f, -2.47961171e-02f, 2.69489616e-01f, -1.05512189e-02f, -2.51756161e-01f, 3.61319482e-02f, -2.52825797e-01f, 1.07218930e-02f,
  -2.38666326e-01f, -3.32389712e-01f, -1.34841189e-01f, -2.94029176e-01f, -1.33188218e-01f, -2.21969888e-01f, 2.25867271e-01f, -2.42834777e-01f, 2.01975212e-01f, 2.44063020e-01f,
  5.76466024e-02f, 8.47788006e-02f, 2.31753942e-02f, -5.20883724e-02f, 3.12095433e-01f, 1.13442251e-02f, -9.87638310e-02f, -1.73870906e-01f, -1.98593080e-01f, -3.74983102e-01f,
  -3.46333802e-01f, 1.57888621e-01f, 4.40040082e-02f, -4.36687469e-02f, 1.91839132e-02f, 2.06077218e-01f, 2.50107557e-01f, -5.58651909e-02f, -2.53256679e-01f, -2.68562645e-01f,
  -2.28059688e-03f, 3.69896516e-02f, 1.48166984e-01f, 1.81535222e-02f, 1.98699296e-01f, 1.30746171e-01f, -8.70361626e-02f, 1.84078086e-02f, -1.45148605e-01f, -7.28780106e-02f,
  7.32746869e-02f, -1.04727726e-02f, 3.02216083e-01f, -8.38879943e-02f, -1.12927847e-01f, 3.21903341e-02f, -1.60037596e-02f, -3.10216993e-02f, 2.81715374e-02f, -8.43369141e-02f,
  1.13506973e-01f, 1.95823476e-01f, -2.47596025e-01f, -5.60158379e-02f, -4.31158729e-02f, -2.36795306e-01f, 1.82998776e-01f, 1.82792753e-01f, -4.50249063e-03f, -2.00229988e-01f,
  -1.03059962e-01f, -2.73736864e-02f, 1.72483832e-01f, 4.71840240e-02f, 1.22552179e-01f, 2.20391631e-01f, -2.60854006e-01f, 1.25499070e-01f, 2.17688978e-01f, 1.53806612e-01f,
  -9.30804685e-02f, -1.79660678e-01f, -6.09349944e-02f, -1.81616277e-01f, 1.24107644e-01f, 1.58796132e-01f, 1.99403195e-03f, 1.05759926e-01f, 1.12363599e-01f, 6.35699406e-02f,
  4.01314870e-02f, -3.07362825e-01f, 1.21563874e-01f, 8.82593468e-02f, 1.06041439e-01f, -1.09235779e-03f, -1.71875462e-01f, 2.07245469e-01f, 1.64787531e-01f, -6.64268285e-02f,
  9.61161852e-02f, 1.48530081e-01f, -9.95470583e-02f, -2.24518180e-02f, 8.45576376e-02f, -1.67735279e-01f, 1.03086144e-01f, 2.68990606e-01f, -1.83460534e-01f, -4.89322916e-02f,
  3.33475411e-01f, -1.51197419e-01f, -4.44315560e-02f, 9.12118480e-02f, 8.70998576e-02f, -4.42168210e-03f, 1.39649119e-02f, -2.69249201e-01f, -1.91576317e-01f, 9.23552364e-02f,
  -7.96902180e-02f, -8.95267799e-02f, -9.37198289e-04f, -7.95343369e-02f, 1.57455746e-02f, 1.04566678e-01f, -2.79381722e-01f, 1.84719875e-01f, 2.96889860e-02f, -1.14715829e-01f,
  1.67504549e-02f, 3.89511064e-02f, 1.11787417e-03f, 1.19077481e-01f, -2.43235916e-01f, 2.56135136e-01f, 1.06238455e-01f, -3.04281563e-01f, -1.06050052e-01f, 1.90303519e-01f,
  1.62631243e-01f, 1.09705403e-01f, -1.12125397e-01f, 1.07147347e-03f, 1.53062597e-01f, 9.33081508e-02f, -1.30444109e-01f, 1.71466559e-01f, 3.12502123e-02f, 2.57704735e-01f,
  -8.41907412e-02f, -1.21314293e-02f, -4.90050502e-02f, -7.13115260e-02f, -8.87295678e-02f, 3.91956493e-02f, -1.97851881e-01f, -4.03809279e-01f, 2.22590156e-02f, 2.43764117e-01f,
  -1.17539659e-01f, -2.85397232e-01f, 3.07752967e-01f, -1.34421855e-01f, -2.28155911e-01f, 1.63769156e-01f, -5.28966151e-02f, 7.07630126e-04f, -1.86509982e-01f, 4.02597040e-01f,
  -3.18144023e-01f, 1.75517067e-01f, 3.32410127e-01f, 1.29626960e-01f, -6.65428489e-02f, -4.81599942e-02f, 5.31993881e-02f, 1.22008882e-02f, -6.47011250e-02f, 9.69284400e-02f,
  -1.40059158e-01f, 4.07603115e-01f, 3.88578139e-02f, 1.63711216e-02f, 2.00207867e-02f, -9.96246841e-03f, 3.84320430e-02f, -1.07500866e-01f, 1.66309681e-02f, 2.42870361e-01f,
  -1.03567056e-01f, 9.18624476e-02f, 4.45866361e-02f, -3.45048696e-01f, -1.46606565e-01f, -2.12533865e-02f, -5.56662455e-02f, 7.55061954e-02f, -1.69200152e-02f, -2.02563792e-01f,
  1.05543982e-03f, -1.61746684e-02f, 8.16654488e-02f, -3.51508297e-02f, 2.24731162e-01f, -1.24229297e-01f, 2.48831257e-01f, 7.07798228e-02f, 3.80873680e-02f, 4.11949828e-02f,
  1.33419886e-01f, 1.46642819e-01f, 1.39286608e-01f, -1.38074961e-02f, 1.77019328e-01f, 2.71643270e-02f, -7.97756836e-02f, 1.42165616e-01f, 2.57617943e-02f, 1.22092813e-01f,
  2.87074596e-02f, -8.81727561e-02f, -1.74071506e-01f, -3.53843957e-01f, 1.08033624e-02f, 9.19976160e-02f, 2.18394324e-01f, -1.49732772e-02f, 6.58863857e-02f, 4.80574667e-02f,
  6.72836825e-02f, 8.11530650e-02f, 7.41194561e-02f, 3.00585572e-02f, 2.18701988e-01f, 5.51115386e-02f, 1.56766891e-01f, -2.57682838e-02f, -8.72728378e-02f, -9.86300483e-02f,
  1.25371590e-01f, -3.71080905e-01f, 1.83364227e-01f, 1.03883743e-01f, -3.88992690e-02f, -3.24761480e-01f, 1.24940276e-01f, -2.66067740e-02f, 3.40499915e-02f, 3.76597285e-01f,
  -2.28578135e-01f, 2.82668054e-01f, 2.52585299e-02f, 4.96038049e-02f, 1.25237212e-01f, -2.26044044e-01f, 7.66472593e-02f, 5.32874651e-02f, 1.23691991e-01f, 1.92860976e-01f,
  2.37610087e-01f, -1.47510925e-02f, 1.41700864e-01f, -1.15646776e-02f, 2.63608396e-01f, -1.33647323e-01f, 3.07787746e-01f, 4.74632196e-02f, -3.29599023e-01f, 2.01380745e-01f,
  8.65225643e-02f, 3.03323537e-01f, 2.08473817e-01f, 2.41566017e-01f, -1.01764999e-01f, -1.77857891e-01f, 1.87423646e-01f, 9.96929854e-02f, 4.16056905e-03f, -3.07577908e-01f,
  -1.85435280e-01f, 3.42011228e-02f, -8.75151083e-02f, -2.12197341e-02f, -1.64314121e-01f, 1.65513858e-01f, -1.72527432e-01f, 1.58325881e-01f, 2.26562656e-02f, 2.49074221e-01f,
  3.98807555e-01f, 4.10746336e-01f, -1.06086224e-01f, -1.32010907e-01f, -1.39050767e-01f, -1.65945411e-01f, 1.92072112e-02f, -6.13694787e-02f, 4.31998968e-02f, -1.51245058e-01f,
  -9.68518183e-02f, 1.79519609e-01f, 5.21280952e-02f, 2.32593641e-01f, -1.51100606e-01f, 3.12800646e-01f, -6.13831058e-02f, -1.14014387e-01f, -1.79862291e-01f, 1.62075788e-01f,
  2.32437029e-02f, 1.03585713e-01f, -9.50852633e-02f, -8.30457360e-02f, -8.21004212e-02f, 9.24005955e-02f, -2.01231707e-02f, -3.78425769e-03f, 1.69280544e-01f, -1.27184853e-01f,
  1.37681821e-02f, -1.97008476e-01f, 1.05452001e-01f, -3.16831172e-02f, 1.75043002e-01f, 1.13048181e-01f, -9.29033533e-02f, -9.87070203e-02f, 2.93843844e-03f, 1.37151703e-02f,
  -2.78246403e-02f, -4.82623756e-01f, -1.35727301e-01f, -1.48570284e-01f, -3.42456996e-01f, -2.39236262e-02f, -3.38346697e-02f, -5.83179034e-02f, -7.60654286e-02f, -2.17892881e-02f,
  -2.44760543e-01f, -1.98959365e-01f, -1.20472178e-01f, 6.72826916e-02f, -2.16081738e-01f, -3.47274572e-01f, -3.09001971e-02f, -1.61978289e-01f, -5.03277630e-02f, -2.36758560e-01f,
  -1.37456045e-01f, 2.21274439e-02f, 7.52381980e-02f, -2.70067155e-01f, -3.85242105e-01f, -1.06564060e-01f, -1.59496330e-02f, -3.38532954e-01f, 1.16481647e-01f, -5.66391684e-02f,
  4.46471060e-03f, 9.61911529e-02f, -1.67697176e-01f, -4.45563793e-02f, -2.87120849e-01f, -3.42176333e-02f, 3.44750658e-02f, -3.13895456e-02f, -1.38336554e-01f, -2.63266593e-01f,
  -1.10897496e-01f, -1.38911948e-01f, 5.88568896e-02f, 2.19349265e-01f, -5.48175711e-04f, 7.24615380e-02f, 8.43774900e-02f, 1.08484969e-01f, 1.34663299e-01f, 1.33073539e-01f,
  -4.14136238e-02f, -1.17369108e-01f, 5.97510524e-02f, 1.88057944e-01f, 1.76455528e-01f, 2.07846522e-01f, 4.82152551e-02f, -3.24978769e-01f, -3.20800722e-01f, 1.95731208e-01f,
  2.79186338e-01f, -1.44226313e-01f, -2.51920581e-01f, -2.35604227e-01f, 5.49397841e-02f, 2.15156272e-01f, 2.35677078e-01f, 1.25187203e-01f, -4.73147221e-02f, 4.00657393e-02f,
  -1.46575034e-01f, -1.98168382e-01f, -6.76871762e-02f, -4.65466604e-02f, -1.21505126e-01f, -1.73764572e-01f, -1.78314775e-01f, -1.71305463e-01f, 1.82928592e-01f, 1.68008506e-02f,
  1.27760649e-01f, -7.36031532e-02f, 3.16321254e-02f, 1.78872406e-01f, 2.57645607e-01f, -1.25064984e-01f, -6.69653788e-02f, -1.11419015e-01f, -1.84709728e-01f, -3.00854653e-01f,
  -1.12894729e-01f, -2.26375967e-01f, 1.98963612e-01f, 2.89333493e-01f, 2.32054755e-01f, -1.37916669e-01f, 8.62810463e-02f, 1.24800049e-01f, -7.77634904e-02f, -2.34598085e-01f,
  3.18172313e-02f, 9.42004994e-02f, 1.80030555e-01f, -1.78663537e-01f, 1.43632457e-01f, -4.96482998e-02f, -1.22233458e-01f, -2.12628514e-01f, -1.27238348e-01f, 2.88129039e-02f,
  4.33880314e-02f, -8.38662405e-03f, -6.57729954e-02f, -1.41438842e-01f, -1.02714092e-01f, -1.51158333e-01f, 1.67565092e-01f, 1.57204848e-02f, 9.46551412e-02f, 4.31719303e-01f,
  -2.96042617e-02f, -3.87858450e-02f, 8.62054061e-03f, -2.30216165e-03f, 7.03314878e-03f, 1.77357402e-02f, 9.19715464e-02f, 5.79352677e-02f, 7.27624865e-03f, 1.66465208e-01f,
  8.51586554e-03f, 6.38346523e-02f, -5.28569566e-03f, -1.86530888e-01f, -6.62763491e-02f, -3.44661891e-01f, -8.69602636e-02f, 4.84695435e-02f, 1.11343905e-01f, -2.81169742e-01f,
  4.27751467e-02f, -3.07651132e-01f, 5.36417514e-02f, 5.98743111e-02f, 1.54942647e-01f, -1.73280779e-02f, 1.28659522e-02f, 8.62532258e-02f, -1.04041897e-01f, 1.83390882e-02f,
  -9.35574435e-03f, -7.42747039e-02f, 3.89995649e-02f, -7.80201182e-02f, 6.66146874e-02f, 3.00032556e-01f, 9.34096053e-03f, 8.79130810e-02f, 1.09761007e-01f, 2.69918959e-03f,
  5.84787019e-02f, 1.49614200e-01f, 5.73081756e-03f, -1.13374973e-02f, -4.87996005e-02f, 1.70362983e-02f, -2.92687360e-02f, 1.39487028e-01f, -1.32663891e-01f, -8.68391769e-04f,
  -2.46155024e-01f, -1.87541798e-01f, 2.46037059e-02f, 1.00776888e-02f, 7.64793856e-03f, -2.71463320e-02f, 1.79738440e-02f, -2.87109524e-01f, 1.20031692e-01f, -1.71387136e-01f,
  -1.75403833e-01f, 1.52637824e-01f, -3.03372473e-01f, 7.84494430e-02f, -2.71341681e-01f, -3.32964838e-01f, -2.96460658e-01f, 1.51021644e-01f, -2.07293525e-01f, -9.33520943e-02f,
  -1.62525907e-01f, 7.92248249e-02f, -2.68161267e-01f, -3.05871874e-01f, -2.75519431e-01f, -8.50398615e-02f, 3.67215015e-02f, -1.25268951e-01f, -1.38135761e-01f, -1.76228866e-01f,
  3.40348750e-01f, -1.28531039e-01f, -9.11844000e-02f, 5.23698330e-02f, -1.16434224e-01f, 2.30880454e-02f, -2.19754223e-03f, 3.49353135e-01f, -7.48770908e-02f, -2.71821674e-02f,
  -1.62978515e-01f, 1.66342080e-01f, -1.94569990e-01f, -2.11495459e-01f, 1.38935819e-01f, -1.86542451e-01f, -3.10334116e-01f, 3.14450383e-01f, 3.04884553e-01f, -1.30255401e-01f,
  2.21523136e-01f, 3.73540729e-01f, 4.26823944e-01f, 1.33120582e-01f, 1.27044395e-01f, -8.81983191e-02f, 1.96428388e-01f, 2.15853769e-02f, 1.27679512e-01f, -1.22463219e-01f,
  1.91724196e-01f, -1.44567102e-01f, 1.94189604e-02f, -6.89158663e-02f, 1.47983134e-01f, -1.20709226e-01f, -6.35042563e-02f, -1.03513137e-01f, -7.89461210e-02f, -1.02726743e-01f,
  1.46467105e-01f, 1.76782995e-01f, 2.51704976e-02f, 1.11745901e-01f, -8.00171867e-02f, 7.61487409e-02f, 9.21883062e-02f, -1.94189683e-01f, 3.36241238e-02f, 2.09860921e-01f,
  4.96773943e-02f, 5.02995364e-02f, 9.39821228e-02f, 7.81852985e-04f, 1.26929834e-01f, -1.91437695e-02f, 7.47189997e-03f, -1.58301041e-01f, -1.36928903e-02f, -5.04463352e-02f,
  3.30421999e-02f, 5.44318557e-02f, 1.24478318e-01f, 7.08873346e-02f, -9.60686281e-02f, -2.78947085e-01f, -6.29988164e-02f, 2.07439601e-01f, -7.81458393e-02f, 9.50026214e-02f,
  1.27491038e-02f, -8.66523758e-02f, -2.49880347e-02f, 6.15062229e-02f, 1.54705584e-01f, 1.39512345e-01f, 3.83472443e-03f, -1.13956198e-01f, 6.97909221e-02f, -4.98971790e-02f,
  -9.88493338e-02f, 4.69425805e-02f, 5.68067729e-02f, -2.43266717e-01f, -5.96871302e-02f, 6.44370308e-03f, 2.19276361e-02f, 1.12061597e-01f, -1.09254718e-01f, 9.67394635e-02f,
  -7.17597874e-03f, 6.30431026e-02f, -7.76247494e-03f, -2.92272121e-02f, -1.51449561e-01f, 1.63494945e-01f, -2.26535033e-02f, 6.05007671e-02f, 6.14556894e-02f, -8.56874958e-02f,
  -1.34885699e-01f, -1.50731891e-01f, -4.19406056e-01f, -1.14085130e-01f, 1.53092876e-01f, -1.57651454e-01f, 3.84901792e-01f, -2.48229831e-01f, 2.86511499e-02f, -3.89252573e-01f,
  5.33313714e-02f, 2.04669386e-01f, -1.50257554e-02f, -2.66294391e-03f, -1.03547417e-01f, 2.00807244e-01f, 2.18337506e-01f, 1.30982008e-02f, -7.74726942e-02f, 2.64784187e-01f,
  -3.72486636e-02f, 6.04417026e-02f, -3.02294075e-01f, -1.79824606e-02f, 2.32013091e-01f, 8.47136602e-02f, 1.78196847e-01f, -1.32359073e-01f, -9.83201489e-02f, -2.32094422e-01f,
  -8.53002220e-02f, -2.93765098e-01f, 1.51326671e-01f, -6.02784380e-02f, -1.81115970e-01f, -8.63697305e-02f, 8.64966437e-02f, -1.98903963e-01f, 1.13862127e-01f, 1.73526794e-01f,
  -1.15916349e-01f, -2.47778803e-01f, 1.77712098e-01f, 1.44128293e-01f, 3.44275273e-02f, -3.12299043e-01f, 1.04619063e-01f, -2.96160847e-01f, -2.08048820e-01f, -3.33325490e-02f,
  -1.10622704e-01f, -4.33194876e-01f, 1.48061454e-01f, -1.81440786e-01f, -2.47821689e-01f, -3.76826763e-01f, -1.20702926e-02f, -7.48589821e-03f, -2.32847631e-01f, 1.43283427e-01f,
  -4.48256265e-03f, 1.61001250e-01f, 2.21917152e-01f, -4.37657475e-01f, 3.27006191e-01f, 7.57300183e-02f, 1.30764678e-01f, 1.17924303e-01f, -2.28719972e-03f, -2.95090880e-02f,
  1.02929734e-01f, -2.23235756e-01f, -2.57329464e-01f, -2.36360654e-02f, 1.00820772e-02f, 8.79051536e-03f, 4.92419265e-02f, -7.93022662e-02f, -2.70901658e-02f, -1.02836169e-01f,
  -3.06614791e-03f, -2.34449357e-02f, -1.37995437e-01f, 5.73563203e-02f, -1.19853839e-02f, 1.61912255e-02f, 6.53481707e-02f, -5.03313320e-04f, 1.63609415e-01f, -4.01502177e-02f,
  1.79992363e-01f, 1.21296749e-01f, 1.08364828e-01f, 1.23687916e-01f, 4.90673818e-03f, -2.30272785e-01f, 4.91113216e-02f, -4.93449755e-02f, 9.60299969e-02f, -2.04730645e-01f,
  -1.45370618e-01f, -2.96958178e-01f, 2.77978126e-02f, 1.36124447e-01f, 1.19927876e-01f, -1.58809260e-01f, -1.54209407e-02f, -1.50211975e-01f, 1.89069062e-02f, -2.87746871e-03f,
  1.20814107e-01f, -1.28854990e-01f, 2.20913455e-01f, -3.33596580e-02f, -4.00538743e-02f, 1.96441971e-02f, 2.14332685e-01f, -2.65958577e-01f, 8.30174237e-02f, -8.60616118e-02f,
  8.44317768e-03f, -7.38069266e-02f, 1.80892855e-01f, 9.22496915e-02f, 1.53394550e-01f, -1.59917697e-01f, 9.45116803e-02f, 7.51663521e-02f, -2.01858893e-01f, 4.67681251e-02f,
  4.53688018e-02f, -1.03969283e-01f, 7.32560605e-02f, 2.13698387e-01f, -1.46809146e-01f, -1.52080297e-01f, 1.59691080e-01f, 8.95608440e-02f, 7.45084435e-02f, 3.69460255e-01f,
  8.23319610e-03f, 2.41932601e-01f, 2.75772121e-02f, 8.54543447e-02f, -3.25670332e-01f, 4.17369371e-03f, -3.08216482e-01f, -1.78580239e-01f, -1.15386948e-01f, -5.21355600e-04f,
  2.98635513e-01f, 1.63076594e-01f, -1.66343346e-01f, 1.95388377e-01f, -1.97885960e-01f, 2.81104147e-01f, -1.05233900e-01f, 7.07560405e-02f, -2.02692255e-01f, -8.18393677e-02f,
  -4.42206487e-02f, 1.65289104e-01f, -2.30262280e-01f, 1.32260084e-01f, -1.12791464e-01f, 1.75923422e-01f, -1.74833000e-01f, 1.70493767e-01f, 3.99563611e-01f, -4.22403216e-02f,
  -2.24374980e-02f, -3.23172003e-01f, 1.10457517e-01f, 1.96843937e-01f, -4.41420153e-02f, 4.15979400e-02f, 2.84100980e-01f, 9.93137658e-02f, 2.28577346e-01f, 3.85154843e-01f,
  -1.97916284e-01f, 3.50027531e-01f, 2.16491953e-01f, 4.73815501e-02f, -5.08517027e-02f, 3.51460278e-02f, 4.26685601e-01f, -4.90586720e-02f, 5.69120571e-02f, -5.61152622e-02f,
  -1.51131034e-01f, 2.94429362e-01f, -4.68482971e-02f, -3.23122963e-02f, -6.40793666e-02f, -1.39658019e-01f, 3.54707018e-02f, 1.28591627e-01f, 2.38070041e-02f, -4.64852564e-02f,
  -1.00190938e-02f, -6.09971583e-02f, 1.36561543e-01f, -2.14971483e-01f, -2.02646106e-01f, -3.53987166e-03f, -3.61369736e-02f, 2.66646653e-01f, 3.71288285e-02f, -5.94697595e-02f,
  5.61178774e-02f, 5.90888434e-04f, -7.96891674e-02f, -3.04568317e-02f, -4.46072109e-02f, 1.12099789e-01f, 8.59770775e-02f, -1.89826444e-01f, -1.66143253e-01f, 1.18115388e-01f,
  -8.51777866e-02f, 8.56049657e-02f, 3.09049282e-02f, 1.05419591e-01f, -6.08285405e-02f, 1.25005111e-01f, 3.14236097e-02f, -1.63394213e-01f, -4.93195876e-02f, 5.68758734e-02f,
  -2.15653442e-02f, 1.26555935e-01f, 4.76763807e-02f, 8.66752267e-02f, -6.76780269e-02f, 5.61755663e-03f, 8.84226635e-02f, -4.88974303e-02f, -4.55357619e-02f, 1.80051178e-01f,
  -1.61022723e-01f, 1.01658829e-01f, 1.87170394e-02f, 1.06281482e-01f, 1.81819737e-01f, 1.14602476e-01f, 2.50881016e-02f, 9.70685296e-03f, -2.95511127e-01f, -1.38139382e-01f,
  -7.47221857e-02f, -4.01493162e-02f, 1.81747191e-02f, -3.13626170e-01f, 2.15715721e-01f, 1.34638920e-01f, 1.56327531e-01f, -1.66116029e-01f, 3.49664055e-02f, -8.31414908e-02f,
  5.62328398e-02f, -2.42450431e-01f, -1.73820451e-01f, 2.36768812e-01f, 1.68327898e-01f, 2.23145083e-01f, -5.16901910e-03f, -3.46130550e-01f, -3.71843904e-01f, 1.66262180e-01f,
  -4.85916482e-03f, 1.59847826e-01f, 1.17008053e-01f, 3.33453625e-01f, 2.51401514e-01f, -3.04434299e-01f, -9.53023285e-02f, -3.78531590e-02f, -3.14298868e-01f, 1.16586074e-01f,
  4.61777449e-01f, -2.55164653e-01f, -6.58778176e-02f, 1.34388536e-01f, -1.59225911e-01f, 3.09447259e-01f, -7.47000352e-02f, 2.01995924e-01f, -1.55649886e-01f, 2.33902380e-01f,
  1.73877895e-01f, -7.30622932e-02f, -1.77843809e-01f, -4.68647629e-02f, 2.53736556e-01f, 1.76737607e-01f, -7.90706575e-02f, 5.05401380e-02f, 6.74049705e-02f, 1.87188521e-01f,
  1.76876456e-01f, -3.62903118e-01f, -5.36309183e-02f, 1.39353529e-01f, -3.36607993e-01f, 1.45658791e-01f, -1.25979871e-01f, 1.50638223e-01f, 1.32156506e-01f, -1.17581382e-01f,
  -2.76698351e-01f, 1.56936571e-01f, 3.18522030e-03f, -6.85302243e-02f, -1.39619305e-03f, -2.40571629e-02f, -5.18332608e-03f, 1.11819491e-01f, 1.19142443e-01f, -1.80875629e-01f,
  -9.79095772e-02f, 1.03471912e-02f, 9.89055410e-02f, -4.30406630e-02f, -7.12504238e-02f, -1.37956077e-02f, -5.46451285e-02f, 5.67635070e-05f, -2.20616817e-01f, 7.90759921e-02f,
  -6.14812784e-02f, 1.63919702e-01f, 1.11488178e-01f, -6.37190491e-02f, 1.51235417e-01f, 2.70488374e-02f, 4.14048582e-02f, -1.70633659e-01f, -3.72793674e-02f, -5.58219431e-03f,
  -1.03153981e-01f, -1.12597749e-01f, 1.93903327e-01f, 7.83110932e-02f, -2.51205504e-01f, 3.00714131e-02f, -1.42758623e-01f, 2.46904626e-01f, -9.90852490e-02f, 3.80037837e-02f,
  1.06806524e-01f, 1.48516342e-01f, 3.33119147e-02f, -5.13578840e-02f, 6.67378008e-02f, 1.80685192e-01f, 1.56530254e-02f, 1.03010781e-01f, -1.35040388e-01f, -4.61983085e-02f,
  -1.06274322e-01f, 3.02399490e-02f, -2.08215769e-02f, 1.72181025e-01f, -1.23558007e-01f, 6.98464289e-02f, -2.94400781e-01f, -1.34453148e-01f, 1.23043738e-01f, -4.15972658e-02f,
  -7.47231841e-02f, -2.24304255e-02f, -1.67070869e-02f, -4.67767902e-02f, -3.40070352e-02f, -9.55131799e-02f, 1.21709123e-01f, -1.40381962e-01f, 3.82534675e-02f, 5.06339744e-02f,
  -3.35997194e-01f, -9.32933465e-02f, 1.80216774e-01f, 1.48351684e-01f, 1.01509914e-01f, 8.75994787e-02f, 7.97181670e-03f, 1.39769271e-01f, 9.09237191e-02f, -3.09513479e-01f,
  -2.46346638e-01f, -2.54606456e-01f, 3.17374989e-02f, -1.74531881e-02f, 1.65442467e-01f, 1.44757628e-01f, 7.15456083e-02f, -2.54464567e-01f, 6.83610588e-02f, 9.77941826e-02f,
  4.53937538e-02f, 1.64023772e-01f, -1.63842320e-01f, -1.87372580e-01f, -2.94688612e-01f, -2.09695417e-02f, 2.23146752e-01f, -1.20551899e-01f, 7.65475929e-02f, -2.58281410e-01f,
  -1.88936979e-01f, -1.75710663e-01f, 3.92278433e-02f, -1.28523096e-01f, 4.91290167e-02f, -1.56819806e-01f, 1.45235777e-01f, -2.50423998e-01f, -1.26188964e-01f, 1.54381186e-01f,
  1.48316041e-01f, -1.33441035e-02f, 2.61028141e-01f, 9.89789292e-02f, -3.23558539e-01f, -1.38901919e-01f, -1.84190199e-01f, 1.51256882e-02f, 3.75671655e-01f, 2.88686097e-01f,
  1.45915329e-01f, -1.81952164e-01f, 1.50084063e-01f, -5.97877800e-02f, -2.44309425e-01f, 1.12136379e-01f, -7.15897977e-02f, -2.36267298e-01f, 2.26105124e-01f, -3.49186480e-01f,
  2.15319488e-02f, 1.43500492e-01f, -1.70966879e-01f, -9.08486173e-03f, 1.35333851e-01f, 4.68159057e-02f, 1.56375200e-01f, -1.70327276e-01f, 1.33447409e-01f, 6.42473847e-02f,
  1.28633101e-02f, 2.08172917e-01f, 4.69489507e-02f, -1.10018305e-01f, 1.01304717e-01f, 3.10006589e-02f, -8.56921002e-02f, -7.17252344e-02f, 5.96494712e-02f, -6.47232533e-02f,
  2.54705310e-01f, -1.60037912e-02f, -8.78541097e-02f, 2.73451239e-01f, -1.14733271e-01f, -4.58525531e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.70981940e-03f, -2.55670231e-02f, -1.22292385e-01f, -1.54412528e-02f, 7.37390146e-02f, 2.06851922e-02f, -1.33156702e-02f, 5.75972125e-02f, 8.52592364e-02f, 3.44202970e-03f,
  1.07874265e-02f, -6.00048378e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    