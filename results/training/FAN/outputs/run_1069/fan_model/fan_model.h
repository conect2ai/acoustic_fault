/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.65493369e-01f, -3.51010293e-01f, 7.43684545e-02f, 7.75446519e-02f, 1.14840060e-01f, -1.60358295e-01f, -1.26533404e-01f, -4.33274508e-02f, 3.45313214e-02f, -8.50015208e-02f,
  -1.03566028e-01f, 8.41709599e-02f, -1.21869026e-02f, -8.86911340e-03f, -2.97179390e-02f, -3.67960595e-02f, 1.13773197e-01f, 1.50482088e-01f, 1.99418649e-01f, 2.05652528e-02f,
  9.27800760e-02f, 4.26081270e-02f, 1.05271988e-01f, 5.68201132e-02f, -5.57288863e-02f, 1.60985980e-02f, 1.15163745e-02f, -6.44941926e-02f, -1.74277335e-01f, 6.63960800e-02f,
  5.59312291e-02f, -1.36758521e-01f, 1.96616352e-02f, -4.95483987e-02f, -6.30025417e-02f, -1.51105627e-01f, -1.01888500e-01f, -1.13297857e-01f, -6.94930777e-02f, -6.21391274e-02f,
  -2.03409344e-02f, -1.04415640e-01f, -3.65806036e-02f, 1.80682279e-02f, 4.09277380e-02f, -1.06786482e-01f, -1.33589298e-01f, 1.04876701e-02f, -1.36944547e-01f, -1.72355473e-01f,
  -4.73639295e-02f, -2.05857139e-02f, -7.08540529e-02f, -8.05026367e-02f, -1.69116184e-01f, -7.40805343e-02f, -1.41200632e-01f, -1.54483050e-01f, -8.61087516e-02f, -1.40010536e-01f,
  1.16058633e-01f, 9.32047814e-02f, 1.32109731e-01f, 1.56438544e-01f, 1.14415079e-01f, 6.05036542e-02f, 2.06246510e-01f, 7.97590390e-02f, 1.77476689e-01f, 4.02660891e-02f,
  8.19163471e-02f, 1.26794904e-01f, 1.99486718e-01f, 6.55372888e-02f, 1.90163031e-01f, 8.79531801e-02f, 6.51469231e-02f, 1.57239944e-01f, 1.24512158e-01f, 2.07099676e-01f,
  7.50804842e-02f, 3.20326239e-02f, 1.50895298e-01f, 1.43446222e-01f, 1.03184246e-01f, 1.66800737e-01f, 1.81675792e-01f, 1.47741362e-01f, 1.77310959e-01f, 1.25561848e-01f,
  -1.38794586e-01f, -1.18337899e-01f, -1.36156335e-01f, -1.17202148e-01f, -1.71228886e-01f, -1.51807994e-01f, -6.46639168e-02f, -1.42580733e-01f, -1.44705802e-01f, -1.10553592e-01f,
  -1.23127699e-01f, -6.93401396e-02f, -1.34198129e-01f, -1.62891805e-01f, -9.98559222e-02f, -6.41697571e-02f, -1.47745073e-01f, -7.33708218e-02f, -1.94288984e-01f, -1.54428422e-01f,
  -1.03799097e-01f, -1.12791196e-01f, -1.80280298e-01f, -1.89988330e-01f, -1.10605210e-01f, -2.48410646e-03f, -1.88403726e-01f, -1.09591834e-01f, -2.30080500e-01f, -1.85709581e-01f,
  -1.17872566e-01f, 8.48986395e-03f, 3.81851792e-02f, -2.60113403e-02f, -2.05155537e-01f, -2.54892707e-01f, -2.83396930e-01f, -1.45360395e-01f, 3.10671348e-02f, -6.38865381e-02f,
  -2.60932539e-02f, 7.01105827e-03f, 1.38100544e-02f, 1.04793228e-01f, -6.90503046e-02f, -9.16550215e-03f, 7.39791542e-02f, 7.10869133e-02f, -2.44264621e-02f, 6.68889144e-03f,
  -2.25623213e-02f, 1.16409905e-01f, 1.02576204e-02f, 1.50966600e-01f, 2.44768038e-01f, 1.30825609e-01f, 1.86086968e-01f, 1.17505170e-01f, 7.84006119e-02f, 1.79780111e-01f,
  7.88176656e-02f, -3.34577113e-02f, -7.36479764e-04f, 1.20151462e-02f, 1.01407349e-01f, 7.37584755e-02f, 1.10655382e-01f, 1.25063747e-01f, 1.85979493e-02f, 7.50293583e-02f,
  1.46185309e-02f, -9.07096453e-03f, 1.13399103e-01f, 1.28992766e-01f, 2.23141592e-02f, 9.08757225e-02f, 3.75417285e-02f, 3.84316705e-02f, 5.84511124e-02f, 4.48721908e-02f,
  3.52672189e-02f, -1.67163648e-02f, -6.29249141e-02f, -9.40305460e-03f, -5.09652644e-02f, 6.64120167e-02f, 1.11827701e-01f, 7.85954967e-02f, -1.10097844e-02f, 1.95977643e-01f,
  -8.00002217e-02f, -2.69260015e-02f, -8.87296870e-02f, -5.24538234e-02f, 7.18663866e-03f, -6.65166751e-02f, -8.30560252e-02f, -2.95923054e-02f, -2.81028934e-02f, -3.98156159e-02f,
  -6.39582425e-02f, -1.37627780e-01f, -1.32912572e-03f, -5.59258983e-02f, -8.42633937e-03f, -3.41337509e-02f, 2.66814176e-02f, -1.01772636e-01f, 2.76610032e-02f, -3.89004126e-02f,
  -5.79606742e-02f, -5.86474016e-02f, -7.56814629e-02f, 6.08317666e-02f, -2.17382852e-02f, -2.28007883e-02f, 4.22549807e-03f, -1.08605931e-02f, -5.32680191e-02f, -1.60623938e-01f,
  -4.72355634e-02f, -1.77810133e-01f, -4.16392609e-02f, -1.62288193e-02f, 5.01179323e-02f, 4.70455661e-02f, -6.86759176e-03f, 5.43970242e-02f, 5.80615783e-03f, 6.91274777e-02f,
  -7.03489315e-03f, -3.15346606e-02f, 4.57898378e-02f, 1.27163650e-02f, -6.00805171e-02f, -6.21376224e-02f, -1.02625499e-02f, -9.31774732e-03f, -1.76144894e-02f, 2.43087970e-02f,
  -4.55720276e-02f, -2.50477139e-02f, -1.37409270e-01f, -8.21306258e-02f, 5.62017225e-03f, -1.02520414e-01f, 1.39828669e-04f, -6.89121187e-02f, -1.02522448e-01f, -3.74233313e-02f,
  1.45864606e-01f, 7.28338286e-02f, 8.02412704e-02f, 6.24345914e-02f, 9.31945369e-02f, 9.23162624e-02f, 1.04853243e-01f, -1.00170271e-02f, 4.92788404e-02f, 9.05406848e-02f,
  -1.68470532e-01f, -2.73418248e-01f, -1.80748954e-01f, -2.27683306e-01f, -2.91904688e-01f, 1.27741814e-01f, 1.01190962e-01f, -8.03887919e-02f, -1.73404038e-01f, -1.47562730e-03f,
  2.81656962e-02f, 9.24832746e-02f, -6.00492284e-02f, -5.25420792e-02f, 1.38736159e-01f, -1.83871854e-02f, -2.20061745e-02f, 9.24792588e-02f, 1.35924798e-02f, 2.77115554e-01f,
  -1.02676906e-01f, -5.13226949e-02f, -9.14909169e-02f, -5.69748953e-02f, -6.85881302e-02f, -1.17096342e-01f, -7.79535770e-02f, -8.01840723e-02f, -2.49079131e-02f, -8.29519778e-02f,
  -5.57763167e-02f, -1.31582558e-01f, -1.48042768e-01f, -2.48140935e-02f, -8.42314493e-03f, -6.19052071e-03f, -3.07718441e-02f, -7.00076073e-02f, -2.24906430e-02f, -7.58594647e-02f,
  -4.37955707e-02f, 6.49383888e-02f, 6.46948069e-03f, -1.22106433e-01f, -2.26124674e-02f, -1.72165379e-01f, -4.56519313e-02f, -9.38820019e-02f, -1.73658901e-03f, 7.05028400e-02f,
  -2.72326469e-02f, -1.61463749e-02f, -4.09567542e-03f, 9.83999670e-02f, 8.81224945e-02f, 5.57392724e-02f, 7.74397105e-02f, -1.54807642e-02f, 1.26919433e-01f, 3.51877734e-02f,
  7.68124238e-02f, -1.87372044e-02f, 4.52766903e-02f, 1.51107013e-01f, 7.47576728e-02f, 6.91854209e-02f, 1.09237701e-01f, 4.44230363e-02f, 6.46622181e-02f, 1.28740683e-01f,
  3.36097218e-02f, 5.28510399e-02f, 1.47608995e-01f, -1.49125205e-02f, 7.75175765e-02f, 9.74441022e-02f, 1.27642602e-01f, -2.21262611e-02f, 2.00634003e-02f, 1.16884090e-01f,
  -1.37283385e-01f, -1.22070186e-01f, 1.64086446e-02f, -5.70147894e-02f, -3.85792996e-03f, -6.33634031e-02f, -1.28981322e-02f, -6.82605505e-02f, 2.43034940e-02f, -4.05920185e-02f,
  -1.11266799e-01f, -8.68263245e-02f, -1.02122881e-01f, 5.71470521e-03f, -9.72440019e-02f, -3.96787114e-02f, -9.84079763e-02f, 2.58807484e-02f, -1.04118057e-01f, -1.42034087e-02f,
  -7.10501894e-02f, -5.34882993e-02f, -4.37834673e-02f, -6.67039007e-02f, -1.20844662e-01f, -2.83248816e-02f, -5.47238998e-02f, -9.47037488e-02f, -4.34694812e-02f, -1.91473775e-02f,
  1.46677587e-02f, 1.37102798e-01f, 1.15109988e-01f, 8.51673931e-02f, 7.56074563e-02f, -1.38261065e-01f, -3.10905017e-02f, -6.94082379e-02f, 6.27643429e-03f, -2.72857398e-02f,
  -1.56132594e-01f, -1.98093832e-01f, -2.17345685e-01f, -2.10796267e-01f, -9.44230258e-02f, 8.92742723e-02f, 1.30057722e-01f, 3.66197079e-02f, -2.63876766e-01f, -1.52293602e-02f,
  -3.56941260e-02f, 1.03831299e-01f, 5.82810603e-02f, 4.86822501e-02f, 8.26097652e-02f, -3.40669928e-03f, 7.23138601e-02f, 2.53038611e-02f, -2.67379377e-02f, 7.98621997e-02f,
  -6.07532896e-02f, 1.27153024e-01f, -3.89609411e-02f, -8.50318447e-02f, -3.67466733e-02f, -3.22514586e-02f, -4.24072109e-02f, -1.14334933e-02f, 8.15615430e-02f, 1.83170859e-03f,
  1.82948224e-02f, 3.28987092e-02f, 3.90804149e-02f, 6.18467368e-02f, 7.27886111e-02f, 1.01325167e-02f, 1.20694436e-01f, 4.36492190e-02f, -8.71958584e-02f, -3.37736197e-02f,
  3.14481631e-02f, -2.08749343e-02f, 1.22638438e-02f, -2.63081565e-02f, -7.49315172e-02f, 2.72498541e-02f, -3.72866876e-02f, 1.03759104e-02f, -1.39406577e-01f, 3.56668904e-02f,
  -1.31281033e-01f, -9.09503698e-02f, -1.30248085e-01f, -1.17934644e-01f, -7.86096826e-02f, -4.98146228e-02f, -4.66442816e-02f, -2.84106676e-02f, -4.01365496e-02f, -1.14840657e-01f,
  -1.91764291e-02f, -9.31141526e-02f, -1.25490755e-01f, -8.52840096e-02f, -9.50834602e-02f, -8.15600604e-02f, -7.07232654e-02f, -8.92294794e-02f, -1.91673432e-02f, -1.21268496e-01f,
  -9.46701095e-02f, -3.58584337e-02f, -8.56823940e-03f, -1.64818764e-01f, -1.51082158e-01f, -6.67122826e-02f, -1.22413151e-01f, -1.55882806e-01f, -1.30891994e-01f, -1.21136643e-01f,
  -1.17521815e-01f, -2.30719984e-01f, -9.77019034e-03f, 8.28956962e-02f, 1.03887245e-01f, 4.88915183e-02f, 3.59870084e-02f, -3.72040160e-02f, 2.04753019e-02f, -2.75438316e-02f,
  -1.87485514e-03f, -3.77364829e-02f, -9.10134092e-02f, -1.15979640e-02f, 3.64199537e-03f, 2.83550266e-02f, 1.04045331e-01f, 2.10865960e-02f, -2.01388169e-02f, 1.24419801e-01f,
  9.48435068e-02f, -3.53517421e-02f, 8.67907424e-03f, 1.56002457e-03f, -1.15190186e-02f, -1.31091982e-01f, -1.22985661e-01f, -1.01935767e-01f, -1.91697672e-01f, 6.03004955e-02f,
  -4.85309422e-01f, -1.65887833e-01f, -1.42902181e-01f, -2.42145300e-01f, 5.04729263e-02f, 1.24660105e-01f, 1.47980198e-01f, -8.55320171e-02f, -3.58590037e-02f, -1.38629943e-01f,
  -2.29286477e-01f, -8.50439370e-02f, -5.66917546e-02f, -1.56310166e-03f, -5.71484119e-03f, 5.28749190e-02f, -3.09938416e-02f, -3.35820429e-02f, 4.45060804e-02f, 6.24690093e-02f,
  6.97886571e-02f, -1.82890385e-01f, -2.07382843e-01f, -1.80193305e-01f, -1.83228433e-01f, 2.44708322e-02f, -1.81804597e-01f, -2.01584950e-01f, -5.71783930e-02f, -1.26146063e-01f,
  -1.39097929e-01f, -2.45454729e-01f, 8.23956951e-02f, -1.64073244e-01f, -1.44991174e-01f, -1.98046342e-02f, -4.10426222e-02f, -9.87861529e-02f, -1.05450451e-01f, -5.77920005e-02f,
  -1.13678247e-01f, -1.29598036e-01f, -1.42707705e-01f, 1.90400530e-03f, -2.28852686e-02f, -6.23176433e-02f, -1.84173182e-01f, -9.87420753e-02f, -7.05591142e-02f, -1.20973594e-01f,
  2.50800345e-02f, -2.27488607e-01f, -2.44496807e-01f, 3.27081466e-03f, -1.24415115e-01f, -9.79283974e-02f, -1.18308961e-01f, -6.26353770e-02f, -1.38609648e-01f, -1.84593126e-01f,
  -1.27303833e-02f, -1.39217973e-01f, -9.94552001e-02f, -1.52463630e-01f, -5.36417477e-02f, -1.00126207e-01f, -1.66598752e-01f, -2.08071217e-01f, -5.34440093e-02f, -1.00552596e-01f,
  -1.06193535e-01f, -1.04409508e-01f, -5.54390326e-02f, -2.18590498e-01f, -1.04705572e-01f, -2.03351498e-01f, -1.01810165e-01f, -8.65931138e-02f, -1.48122281e-01f, -1.75083697e-01f,
  -2.21530840e-01f, -1.75864935e-01f, -1.55593827e-01f, -1.12413846e-01f, -2.01929405e-01f, -1.54098928e-01f, -1.03529774e-01f, -1.46310836e-01f, -5.57959080e-02f, -6.71572983e-02f,
  4.30549718e-02f, -1.70768946e-02f, -2.97260918e-02f, -1.29260113e-02f, -6.90452084e-02f, -8.29352736e-02f, -9.78651717e-02f, 2.89307744e-03f, -4.30399403e-02f, -4.64272276e-02f,
  -3.62451859e-02f, -1.28672168e-01f, -7.21986638e-03f, -8.49624574e-02f, -7.00655058e-02f, -3.77046615e-02f, 2.95295361e-02f, -1.31774470e-01f, 2.57281922e-02f, -1.23004103e-02f,
  2.76045669e-02f, -5.89900799e-02f, -1.73318386e-02f, 6.33684248e-02f, 6.46383986e-02f, 2.44635902e-02f, 7.98381567e-02f, 4.93820086e-02f, -3.01016159e-02f, -1.32283969e-02f,
  -4.00709838e-01f, -4.17545475e-02f, 6.87033385e-02f, -1.98361591e-01f, -7.28444532e-02f, -5.15178777e-02f, -1.46998465e-01f, -2.32230484e-01f, -2.15929687e-01f, -2.02748820e-01f,
  -6.38611540e-02f, -4.45607752e-02f, -6.00036383e-02f, 4.49017994e-03f, -2.04343528e-01f, 1.15410099e-02f, 1.33073851e-01f, -1.68828461e-02f, -2.00155601e-01f, -1.04129560e-01f,
  -3.06514222e-02f, -2.40250692e-01f, -2.28420854e-01f, -7.11724460e-02f, -4.86926883e-02f, 2.01979745e-02f, 4.65998054e-02f, -8.92329514e-02f, -3.57170515e-02f, 3.06100994e-02f,
  -3.70666534e-02f, -4.08721529e-02f, -8.58804733e-02f, -1.64310083e-01f, -6.85377270e-02f, -1.11080535e-01f, -7.26048499e-02f, -3.21665965e-02f, -1.45533979e-01f, -5.13835140e-02f,
  -1.91035420e-01f, -6.06849417e-02f, -2.96373647e-02f, -1.30156830e-01f, -6.76495880e-02f, -1.03783809e-01f, -1.56247959e-01f, -1.53787762e-01f, -1.24962414e-02f, -1.20780878e-01f,
  -4.58808951e-02f, -1.49905100e-01f, -1.73880264e-01f, -9.50234830e-02f, -1.11026473e-01f, -1.88133061e-01f, -1.03403993e-01f, -1.20495953e-01f, -2.05554888e-01f, -1.20158039e-01f,
  7.04780370e-02f, 6.29524067e-02f, 5.27071021e-02f, 1.40770540e-01f, 4.87020835e-02f, 1.02573179e-01f, 1.45659536e-01f, 7.70434663e-02f, 6.90093637e-02f, -2.05169357e-02f,
  4.05179374e-02f, 3.74413515e-03f, 3.78604867e-02f, 1.65847056e-02f, 2.61258073e-02f, 3.80530804e-02f, 9.03054625e-02f, 1.09833576e-01f, -1.05802258e-02f, 1.06744189e-02f,
  8.66152123e-02f, 4.04363275e-02f, -4.37527709e-03f, 9.24421102e-02f, 1.20898753e-01f, 8.31099004e-02f, 7.08838999e-02f, 8.90656337e-02f, 5.51464967e-02f, 4.47666235e-02f,
  -2.51271099e-01f, -1.13971077e-01f, -3.03423908e-02f, -1.35383770e-01f, -7.92996883e-02f, -1.41254589e-01f, -9.77462232e-02f, -1.11067258e-01f, -1.60658006e-02f, -8.68911818e-02f,
  -8.69325995e-02f, -1.07311472e-01f, -8.51959139e-02f, -3.27249616e-02f, -1.96201012e-01f, -1.97693929e-01f, -1.74004719e-01f, -1.52419597e-01f, -1.84324421e-02f, -1.38734132e-01f,
  -1.52967751e-01f, -1.87917143e-01f, -2.47971520e-01f, -1.08002223e-01f, -1.45145640e-01f, -2.23255515e-01f, -2.04998091e-01f, -1.95049345e-01f, -1.86365575e-01f, -2.90032178e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.04082339e-01f, -1.77750960e-01f, -5.44044495e-01f, -3.15764010e-01f, -1.80573180e-01f, 1.03191271e-01f, 2.20376343e-01f, 2.02000096e-01f, -4.68741171e-02f, 1.87618919e-02f,
  3.69119793e-02f, -1.10931955e-02f, -1.98429659e-01f, -7.16715902e-02f, 2.86625445e-01f, -6.12454303e-03f, -2.00050950e-01f, -4.33988608e-02f, 5.71343824e-02f, 3.56965840e-01f,
  2.35474825e-01f, 5.53020043e-03f, 1.01896428e-01f, 2.89969668e-02f, -2.52995700e-01f, 4.21437342e-03f, -2.56261140e-01f, -1.67689532e-01f, -8.67369398e-02f, -3.67539167e-01f,
  -3.27216983e-02f, -3.28336686e-01f, 9.33084264e-02f, -2.04515085e-02f, -1.80523813e-01f, 1.43130943e-01f, 1.75089359e-01f, -1.24880917e-01f, -9.66918319e-02f, -4.44337679e-03f,
  -1.78741828e-01f, -9.33842957e-02f, -8.36366788e-02f, 4.11579162e-02f, -6.35961443e-02f, 9.21761915e-02f, -1.69291124e-01f, -1.38405725e-01f, -1.36941656e-01f, -1.49247870e-01f,
  -1.91843733e-01f, -1.63246110e-01f, -2.50469029e-01f, 9.45668947e-03f, -1.35013700e-01f, -1.60161093e-01f, -1.55243516e-01f, -2.81579405e-01f, -5.94013296e-02f, -1.50814250e-01f,
  2.22823117e-02f, -4.00561560e-03f, -3.39549333e-02f, 4.06439528e-02f, 7.60955811e-02f, -6.61469698e-02f, -1.26633629e-01f, 6.29079342e-02f, -5.50892688e-02f, -3.88922319e-02f,
  -4.08383645e-02f, -6.35088161e-02f, -6.09062538e-02f, -6.04104474e-02f, -5.85295148e-02f, -6.67867362e-02f, 4.41218540e-03f, 1.22213796e-01f, 9.18950289e-02f, 7.15122223e-02f,
  5.19165583e-02f, -5.16207889e-02f, -8.42180327e-02f, 8.65682065e-02f, -2.10894737e-02f, 1.87993925e-02f, 1.73295945e-01f, 1.33340195e-01f, 1.07877344e-01f, 9.63539705e-02f,
  4.03693557e-01f, -2.27229688e-02f, 8.86215791e-02f, -5.58517277e-02f, -1.19200023e-02f, -4.34293859e-02f, -1.38408644e-02f, 2.46566534e-03f, -1.36397243e-01f, -4.24468610e-03f,
  1.10644866e-02f, 5.65551035e-02f, -1.58992186e-02f, 6.44149631e-02f, 4.35349382e-02f, -7.33980490e-03f, 2.11578026e-01f, -1.19812988e-01f, 2.15391200e-02f, 1.14020973e-01f,
  -2.79766992e-02f, 5.77002391e-02f, 1.90493286e-01f, 3.56134288e-02f, 4.73564677e-02f, 1.48588613e-01f, 2.03478843e-01f, 3.06069423e-02f, 9.93850231e-02f, 4.04429555e-01f,
  6.95694506e-01f, -1.80171520e-01f, -5.47312915e-01f, -2.09206715e-02f, -2.02903122e-01f, -2.33754501e-01f, -1.25245944e-01f, 8.12007487e-03f, 3.86737324e-02f, -1.85021609e-01f,
  -1.25597626e-01f, 9.60666239e-02f, -7.20484108e-02f, 4.02509421e-02f, -4.78126807e-03f, -2.27731347e-01f, -3.27860445e-01f, -1.38652831e-01f, 1.10112719e-01f, 6.68041408e-02f,
  -2.07091426e-03f, 1.07616641e-01f, 5.30065373e-02f, 3.42643037e-02f, -2.61617601e-01f, -7.38140419e-02f, -2.58563638e-01f, -1.93118677e-01f, -2.01784715e-01f, -4.16426599e-01f,
  -5.09765744e-01f, -1.81491017e-01f, -4.01081853e-02f, 1.64814755e-01f, -2.74355821e-02f, 1.95393845e-01f, 2.14224514e-02f, 5.30005656e-02f, 7.95824230e-02f, -6.12505618e-03f,
  -1.88959613e-01f, -4.96484479e-03f, 7.91506283e-03f, 9.04950034e-03f, 6.84796646e-02f, -3.77802216e-02f, -6.14969507e-02f, -7.07759038e-02f, -7.61028705e-03f, -8.83010402e-02f,
  3.20647843e-02f, -3.92967053e-02f, -1.64058115e-02f, 1.99156138e-03f, -5.16671650e-02f, -1.10773101e-01f, -1.02553248e-01f, -1.39499247e-01f, -1.22075990e-01f, -3.13021690e-02f,
  -8.97940174e-02f, 6.49999231e-02f, 8.06534514e-02f, 1.73685253e-01f, 1.76248029e-01f, 4.98077534e-02f, 7.46817663e-02f, 1.17797777e-01f, 3.57611589e-02f, 1.05939381e-01f,
  -2.33416613e-02f, -2.39718687e-02f, 2.96749286e-02f, 3.33607346e-02f, 3.04702148e-02f, 7.41951689e-02f, -4.93356138e-02f, 6.62138835e-02f, 8.54590088e-02f, 2.15251923e-01f,
  2.29186416e-02f, 1.86404176e-02f, 1.83445364e-01f, 5.15382253e-02f, -1.89711023e-02f, -6.66485801e-02f, -1.91502217e-02f, 1.58317372e-01f, -9.27817076e-03f, -3.97375748e-02f,
  1.23239376e-01f, -1.37684047e-01f, -5.48448674e-02f, 1.77152436e-02f, -9.29256261e-04f, 3.61091420e-02f, -5.62069714e-02f, 1.05667554e-01f, 8.86969492e-02f, -1.26136793e-02f,
  -6.39802590e-02f, -3.41043025e-02f, -1.22146368e-01f, 2.45993584e-02f, 1.03464194e-01f, -3.34152728e-02f, 3.21024880e-02f, 1.28698051e-01f, 4.23223153e-02f, -1.17920235e-01f,
  2.21847724e-02f, 1.33325964e-01f, 2.16216087e-01f, 3.34466286e-02f, -7.65743107e-02f, 2.36589927e-02f, -5.63602597e-02f, 5.04482426e-02f, 1.34545505e-01f, 1.71240449e-01f,
  -1.22314066e-01f, -1.66088417e-02f, -2.39767991e-02f, -5.86034507e-02f, 7.84582794e-02f, -1.42147290e-02f, -6.02264479e-02f, 2.20339015e-01f, 2.74101973e-01f, -2.34415397e-01f,
  8.93586949e-02f, 1.26028406e-02f, -4.85919490e-02f, -5.88300861e-02f, -4.08820182e-01f, -3.32981050e-01f, -3.27226967e-01f, -2.35243186e-01f, -5.98416328e-02f, 4.48867045e-02f,
  2.80210134e-02f, -3.86664271e-02f, -1.87758937e-01f, -7.04954937e-02f, -2.74838842e-02f, -3.28030996e-02f, -1.87902123e-01f, -1.07636206e-01f, -1.97019771e-01f, -3.00568312e-01f,
  -2.37983074e-02f, 1.30642071e-01f, 2.94699576e-02f, -1.76920697e-01f, -1.27362171e-02f, 4.53747697e-02f, -9.59960073e-02f, 1.42460139e-02f, 5.14979698e-02f, 9.58053693e-02f,
  3.42485569e-02f, 8.00087899e-02f, -1.72084849e-02f, 1.84420973e-01f, 1.41488433e-01f, 3.49705145e-02f, -2.05711480e-02f, -2.69131106e-03f, 1.25961741e-02f, 9.00108665e-02f,
  -1.28882363e-01f, -1.65444791e-01f, -1.01402991e-01f, -2.80015711e-02f, 1.12318769e-01f, 2.68095378e-02f, 1.41744822e-01f, 1.05568305e-01f, -8.89408216e-02f, -4.34602425e-02f,
  6.83604553e-02f, 3.55225354e-02f, 5.46648987e-02f, -6.95572421e-03f, -1.38681121e-02f, 7.11561879e-03f, -3.04267537e-02f, -9.04437676e-02f, 3.96903753e-02f, 2.09245384e-01f,
  2.09627926e-01f, 9.74864513e-02f, 7.46572688e-02f, -4.78650443e-02f, -1.53414384e-01f, -3.07877474e-02f, -1.23927861e-01f, -7.76873156e-02f, -2.26811752e-01f, -3.56799029e-02f,
  7.36478195e-02f, 2.58774199e-02f, 6.36542886e-02f, -6.99001029e-02f, -1.02565745e-02f, -1.18480377e-01f, 8.96153748e-02f, 1.01487190e-01f, 2.02155977e-01f, 3.16490456e-02f,
  7.92153701e-02f, -2.39798293e-01f, -1.48409709e-01f, 1.19933048e-02f, 7.76570961e-02f, 1.30066216e-01f, -1.32972747e-01f, -1.61197428e-02f, 7.01469481e-02f, 4.63482179e-02f,
  1.06622763e-01f, -5.31519093e-02f, -8.90329555e-02f, 5.85331097e-02f, 1.09926023e-01f, 2.80035734e-02f, -1.60876691e-01f, -2.22189903e-01f, -1.84909686e-01f, 1.05407983e-01f,
  -1.62191391e-01f, -2.81060070e-01f, -2.88800597e-01f, -1.82990283e-01f, -7.38788769e-02f, -3.23935032e-01f, -2.43469670e-01f, -1.65652335e-01f, -3.36404830e-01f, -4.23459768e-01f,
  2.05436513e-01f, -8.06873888e-02f, 1.51653484e-01f, 6.98446110e-02f, 7.21029192e-02f, -6.83697090e-02f, 6.68598935e-02f, 2.89408080e-02f, -4.35189642e-02f, -9.19824373e-03f,
  -3.95659566e-01f, -2.72947013e-01f, -3.14579964e-01f, -3.13340217e-01f, -2.36157209e-01f, 8.11841786e-02f, 1.84688121e-01f, 1.19689249e-01f, 1.98531434e-01f, 1.30177230e-01f,
  2.15119183e-01f, 3.52123052e-01f, 2.80609608e-01f, 2.81219631e-02f, 7.17152059e-02f, 4.22020094e-05f, 2.50014998e-02f, -2.33303476e-03f, -5.53883091e-02f, 1.96847036e-01f,
  5.47705926e-02f, -2.60511786e-01f, 4.11186069e-02f, -1.06073722e-01f, -5.68282753e-02f, -1.31615341e-01f, -9.64187831e-02f, 3.96778919e-02f, -5.64976819e-02f, 3.23489383e-02f,
  -3.90265323e-02f, 1.04967570e-02f, -2.50835747e-01f, -3.31478529e-02f, 4.77004200e-02f, 5.66145889e-02f, 8.02440718e-02f, 2.99328528e-02f, -9.74353626e-02f, -1.16509318e-01f,
  -7.45330676e-02f, -7.80984312e-02f, -3.80781293e-02f, -2.19177976e-01f, -1.55866876e-01f, -2.08795264e-01f, -7.72233531e-02f, -8.69657919e-02f, -7.39928111e-02f, 7.73695558e-02f,
  -2.90633030e-02f, -6.04563244e-02f, -1.02699079e-01f, -7.08878264e-02f, -1.53833032e-01f, 3.10711167e-03f, 1.22317664e-01f, -2.51939818e-02f, -1.23579241e-01f, -1.36544004e-01f,
  -5.16946614e-02f, -9.07386988e-02f, -1.70693234e-01f, 3.99298556e-02f, 1.88888609e-02f, -1.26009911e-01f, -7.69350603e-02f, -1.03180021e-01f, -6.09601215e-02f, -2.37683505e-01f,
  -1.16767690e-01f, 9.70072746e-02f, 9.26674977e-02f, 1.20432861e-01f, 1.21414289e-02f, -4.68467474e-02f, -4.51329835e-02f, -1.64513335e-01f, 9.62892845e-02f, 2.55664159e-02f,
  2.55389465e-03f, -4.32010055e-01f, 1.53674539e-02f, -8.00019354e-02f, -5.23807853e-03f, -5.38534708e-02f, -2.53773838e-01f, 1.15238428e-01f, 7.69487172e-02f, 6.46146163e-02f,
  -1.44157887e-01f, 7.73505960e-03f, -1.25782251e-01f, -9.75474790e-02f, 1.12549648e-01f, 9.45972502e-02f, -3.45108062e-02f, 8.60711113e-02f, 4.79364321e-02f, 4.16740030e-02f,
  4.05400135e-02f, 2.09721059e-01f, 9.57787335e-02f, 4.30188328e-02f, -9.04408544e-02f, 1.71524122e-01f, 1.57849446e-01f, 1.81275323e-01f, 1.84560120e-01f, 3.87418658e-01f,
  -4.03805077e-01f, -2.28294387e-01f, 1.57588676e-01f, -2.33726650e-01f, -8.93953294e-02f, -2.33510569e-01f, -1.14218816e-01f, -2.03375459e-01f, -2.09837630e-01f, 4.57886048e-02f,
  -7.93778598e-02f, -1.47890836e-01f, 1.70678139e-01f, 3.31344865e-02f, -2.37715513e-01f, 1.02530338e-01f, -6.10625185e-03f, -1.01831488e-01f, -2.23108068e-01f, -2.67269820e-01f,
  -2.13478640e-01f, 1.47365630e-02f, -1.66885287e-01f, -1.67203888e-01f, 1.21697478e-01f, 2.09917188e-01f, 2.89807886e-01f, -8.12477767e-02f, 4.18854272e-03f, 9.48764733e-04f,
  3.76049817e-01f, -2.92394519e-01f, 3.76328304e-02f, -2.26432875e-01f, -4.26911041e-02f, -1.65257141e-01f, -1.18101880e-01f, -3.46172042e-03f, -5.70822284e-02f, 4.44563292e-02f,
  -1.72248945e-01f, -2.64595896e-01f, -1.16384424e-01f, -7.09298104e-02f, -5.45941107e-02f, -5.52239791e-02f, -3.76923159e-02f, -3.69665883e-02f, -5.40204085e-02f, -4.04250957e-02f,
  5.33526344e-03f, -1.46512970e-01f, 1.90915950e-02f, 9.13928971e-02f, -2.50306650e-04f, -4.39537503e-02f, -3.49403024e-02f, -1.05576582e-01f, -7.22645819e-02f, 2.63872683e-01f,
  -2.39251077e-01f, 1.59978554e-01f, -7.53220767e-02f, 7.59291351e-02f, -3.54167111e-02f, 1.86660081e-01f, 7.20459074e-02f, 1.13784172e-01f, -2.59449445e-02f, 9.14790258e-02f,
  -4.29535285e-02f, -1.05875805e-01f, -1.13357618e-01f, 3.38223167e-02f, -5.58777191e-02f, -1.21952929e-01f, -8.02961290e-02f, -2.88112890e-02f, -6.73479065e-02f, -6.77561387e-02f,
  -9.03254002e-02f, -5.91076054e-02f, -9.78480279e-02f, 4.18140925e-02f, -1.41549632e-01f, -1.20613754e-01f, -2.11065099e-01f, -8.89042616e-02f, -8.39975625e-02f, -1.23280123e-01f,
  3.17065388e-01f, -1.52450144e-01f, 9.95784327e-02f, 4.50270213e-02f, 5.13348989e-02f, -6.37254417e-02f, -4.33194116e-02f, -1.16053015e-01f, -4.30094413e-02f, -1.10185541e-01f,
  -3.67135525e-01f, -6.76952749e-02f, 3.63251902e-02f, 2.61171721e-02f, 4.75712633e-03f, 1.75784044e-02f, -7.54488483e-02f, 9.75637585e-02f, 3.71508561e-02f, -1.06222391e-01f,
  -8.84530172e-02f, -1.36170490e-03f, 1.56503513e-01f, 2.32901871e-01f, 3.00455634e-02f, 1.69398007e-03f, 1.84632093e-01f, 1.17291987e-01f, 1.47743449e-01f, 2.95179129e-01f,
  -8.19051564e-02f, -3.41368139e-01f, 7.03267008e-02f, -1.94694519e-01f, -1.80876747e-01f, 1.12841062e-01f, 7.96793774e-02f, -1.40722826e-01f, -1.54085532e-01f, -1.92190539e-02f,
  -3.00525483e-02f, 1.27657980e-01f, 7.62564242e-02f, 1.37470469e-01f, 2.77003318e-01f, 1.06215850e-01f, 1.91742890e-02f, 2.00392544e-01f, 2.92147785e-01f, -3.10486034e-02f,
  -8.90515596e-02f, -3.62712443e-02f, -8.55365172e-02f, -9.47201699e-02f, -3.05023521e-01f, 5.90173118e-02f, -7.95996115e-02f, -2.08755046e-01f, -1.19534671e-01f, -2.48604342e-01f,
  3.76684994e-01f, -3.18599045e-01f, -4.80883121e-02f, -1.32656917e-01f, 3.40487510e-02f, 4.97993603e-02f, 3.55266929e-02f, -1.08751886e-01f, -9.80485156e-02f, -1.32481679e-01f,
  -2.29185805e-01f, -1.79334264e-02f, 7.35035306e-03f, 2.41001416e-02f, -1.14483140e-01f, 1.22569734e-02f, -3.16685326e-02f, -2.58928269e-01f, -1.70886725e-01f, -7.24562928e-02f,
  -6.72801211e-02f, -1.71649158e-01f, 7.94123858e-02f, 7.06115812e-02f, -1.85073987e-01f, 3.88446450e-02f, -1.06753603e-01f, -2.14529335e-01f, -1.44148856e-01f, -1.36631995e-01f,
  1.21708468e-01f, 2.07936034e-01f, 4.39359620e-02f, 4.22568433e-03f, 4.12928611e-02f, 1.86226536e-02f, -5.69351837e-02f, -6.85514733e-02f, 3.31733073e-03f, 1.29809216e-01f,
  -1.68727979e-01f, -7.36119822e-02f, 8.40973482e-02f, 3.66246589e-02f, -6.16203528e-03f, -2.83849463e-02f, 1.60563529e-01f, -8.74762014e-02f, -2.31554974e-02f, 9.49007645e-02f,
  -5.40754609e-02f, -1.32446736e-01f, -1.51463881e-01f, 1.15077402e-02f, -3.40098776e-02f, 2.05584578e-02f, 5.13512492e-02f, 1.09124146e-01f, 6.42224029e-02f, -1.40475770e-02f,
  2.63938189e-01f, -4.79918979e-02f, 2.53264666e-01f, -1.14414111e-01f, 1.07465209e-02f, -1.88498981e-02f, 8.97884890e-02f, -3.60240899e-02f, 3.83184780e-03f, 4.91647841e-03f,
  -1.30132690e-01f, -1.35209551e-02f, 5.67063950e-02f, -2.68666595e-02f, -3.98964696e-02f, 3.91760506e-02f, -7.28772432e-02f, 6.43756911e-02f, -1.99219003e-01f, 9.09775589e-03f,
  -5.97087517e-02f, -6.79286569e-02f, 3.10232043e-01f, 2.17711404e-01f, -2.98349969e-02f, 2.45408058e-01f, 1.03225760e-01f, 8.05618092e-02f, 1.67243257e-01f, 3.01558882e-01f,
  -4.08623666e-01f, 2.47472137e-01f, -4.47352044e-02f, -2.69859374e-01f, 3.29018906e-02f, 1.45151585e-01f, 2.08171591e-01f, -1.69175953e-01f, -8.42531994e-02f, 2.25704685e-01f,
  2.07140356e-01f, 1.29061975e-02f, 7.60642588e-02f, 1.85449440e-02f, -2.43161827e-01f, 1.12471886e-01f, 8.89495760e-02f, -2.11393848e-01f, -4.11393076e-01f, -2.17791602e-01f,
  7.63506964e-02f, -2.18745083e-01f, -3.81165802e-01f, -3.38206351e-01f, -5.66880368e-02f, -1.44524023e-01f, 8.89684409e-02f, -5.01013100e-02f, 7.76675269e-02f, 1.99177936e-01f,
  4.66842316e-02f, -3.12844478e-02f, -1.66801959e-02f, -4.85880598e-02f, 1.10509656e-01f, -1.16664872e-01f, 5.88607043e-03f, -1.50292292e-01f, 9.20591354e-02f, -4.82498184e-02f,
  -3.86539251e-02f, -5.16841523e-02f, 1.07420176e-01f, 1.56369023e-02f, -1.91237390e-01f, -3.81125174e-02f, -7.16621280e-02f, -2.12083519e-01f, -9.59723070e-02f, 4.02660631e-02f,
  3.47423911e-01f, 1.50726020e-01f, -1.72031000e-02f, -2.50417050e-02f, 1.05089188e-01f, -7.91828260e-02f, -9.44467112e-02f, -9.61388424e-02f, -1.81206595e-02f, -1.98815212e-01f,
  -3.42139751e-02f, -7.36881495e-02f, -1.74162239e-02f, -8.88263062e-03f, -7.83613995e-02f, 1.79514550e-02f, -8.10808875e-03f, -1.53131068e-01f, -3.83649394e-02f, -5.74782863e-02f,
  4.04780656e-02f, -2.76440084e-02f, -1.12064511e-01f, -8.10732041e-03f, -1.15137942e-01f, -1.20410129e-01f, -5.86675778e-02f, -7.82928914e-02f, -6.08547479e-02f, 4.82277088e-02f,
  -1.22791246e-01f, 4.96773496e-02f, 2.19247537e-03f, -1.08452894e-01f, 4.23065349e-02f, -1.66207597e-01f, 4.93001007e-02f, -4.07261737e-02f, 4.31391448e-02f, -1.55354232e-01f,
  -3.23125124e-01f, 2.89450027e-03f, 8.16210173e-03f, -1.17617786e-01f, -1.73021927e-02f, 9.19044912e-02f, 1.23789951e-01f, -1.40992209e-01f, -4.89128791e-02f, -7.33200759e-02f,
  -9.82892737e-02f, -6.74735606e-02f, 3.80183607e-02f, 7.79129490e-02f, -1.92530245e-01f, -8.33993107e-02f, 1.04942910e-01f, -1.42630488e-01f, 9.88228843e-02f, 9.88847986e-02f,
  6.04649149e-02f, -3.62921581e-02f, -1.14820391e-01f, -1.04802929e-01f, 4.26597381e-03f, -1.47108689e-01f, -6.49672672e-02f, -1.58842653e-01f, -1.78524807e-01f, -2.44426027e-01f,
  5.12522757e-01f, -6.79047525e-01f, -9.16049406e-02f, -1.70951620e-01f, -4.51949611e-02f, -7.58778006e-02f, -3.50235820e-01f, -1.19476557e-01f, -2.46597752e-02f, -4.25404608e-01f,
  -1.80894345e-01f, 3.71027917e-01f, 2.83307999e-01f, 1.51230544e-01f, 3.06665003e-01f, -3.40967089e-01f, -9.98323932e-02f, 4.39865083e-01f, 5.13774872e-01f, 3.11394744e-02f,
  -1.86046332e-01f, -9.39969420e-02f, 3.06084603e-01f, 8.45233798e-02f, -3.17630053e-01f, 4.15416546e-02f, -2.34869674e-01f, -7.66982734e-02f, -1.97309449e-01f, -3.65072906e-01f,
  -6.11404181e-02f, -1.00667961e-01f, 1.29450157e-01f, 1.04132637e-01f, -1.33817926e-01f, 4.11611125e-02f, -1.34447113e-01f, -3.87386680e-02f, 7.27291256e-02f, -9.80881527e-02f,
  -6.95870519e-02f, 8.27930123e-02f, -1.81295967e-03f, 3.06433383e-02f, -9.33688283e-02f, -6.14058860e-02f, -1.12281675e-02f, 6.81912526e-02f, 2.10446917e-04f, -2.14139417e-01f,
  -3.06992590e-01f, -1.27593979e-01f, 1.38847083e-01f, 1.62261967e-02f, 1.07193239e-01f, 2.61341572e-01f, -1.19377121e-01f, -2.55821459e-02f, 1.38111874e-01f, -2.82751501e-01f,
  -1.20366789e-01f, -6.74822479e-02f, -9.46100131e-02f, -3.88911460e-03f, -1.60037223e-02f, -1.94857232e-02f, -8.54520053e-02f, 1.09891288e-01f, -4.18526120e-02f, -1.35651953e-03f,
  -1.75350066e-03f, -4.40591015e-02f, 6.91964328e-02f, -1.00189961e-01f, -7.33383670e-02f, 7.86603987e-03f, 5.68921827e-02f, -6.35100901e-03f, 1.99983604e-02f, 3.20601091e-02f,
  1.10228077e-01f, 2.37230323e-02f, 1.09275177e-01f, 2.57178117e-02f, 2.12028250e-02f, 7.54660219e-02f, 8.63550305e-02f, 4.22960073e-02f, 2.58301152e-03f, -9.53403562e-02f,
  -1.83943845e-03f, 1.86503097e-01f, -9.88162979e-02f, 6.10631853e-02f, -5.95775805e-02f, 3.67590524e-02f, -4.07995656e-02f, -7.78443292e-02f, 9.85944420e-02f, -7.29371905e-02f,
  6.47590379e-04f, 7.12225661e-02f, -8.16464424e-02f, 2.18532570e-02f, 1.49941386e-03f, -5.23021165e-03f, -1.16971903e-01f, 2.91790757e-02f, -3.28835985e-03f, -1.90785512e-01f,
  -1.93614960e-01f, 3.53357717e-02f, 9.04502198e-02f, -8.73770565e-03f, -9.95860323e-02f, 1.93529800e-01f, 3.12561877e-02f, -9.96100157e-02f, 2.06587389e-01f, -2.39935905e-01f,
  1.13993697e-01f, 2.66508222e-01f, -4.35111634e-02f, 1.57105014e-01f, 1.24353133e-01f, 3.11250448e-01f, 3.04658532e-01f, 1.90550774e-01f, 1.07395791e-01f, 1.90686539e-01f,
  1.36688173e-01f, 1.05965361e-01f, 4.87005860e-02f, 8.66218656e-02f, 1.71370767e-02f, 8.91477764e-02f, 1.05456851e-01f, -2.77517531e-02f, -1.40505984e-01f, 7.26361945e-02f,
  1.53873920e-01f, 3.54390368e-02f, -1.95563659e-02f, 6.24434724e-02f, 4.19781096e-02f, -1.39885014e-02f, 1.34365469e-01f, 1.40872702e-01f, 2.24945903e-01f, -7.26552308e-02f,
  -1.80229798e-01f, 5.92499860e-02f, -3.42180252e-01f, -7.96343461e-02f, -1.07388437e-01f, -1.61450908e-01f, -3.87052558e-02f, -1.08621031e-01f, 3.51179764e-02f, -5.02707250e-03f,
  3.59448306e-02f, 4.96227620e-03f, 6.41906410e-02f, 2.14763843e-02f, -5.78266904e-02f, -1.30611137e-01f, 2.22139340e-02f, -3.57358940e-02f, -4.18706052e-02f, -1.10977359e-01f,
  6.17568120e-02f, 6.65840432e-02f, 7.92122632e-02f, -1.16979908e-02f, 4.55957875e-02f, -9.00870413e-02f, -6.68557137e-02f, -6.60372525e-03f, -5.68407811e-02f, -7.25178868e-02f,
  -1.74130574e-01f, 1.94398575e-02f, 9.26388055e-02f, 9.03347973e-03f, 1.59636755e-02f, -1.02458604e-01f, -7.95618892e-02f, 3.01418416e-02f, -3.36499587e-02f, -5.76154627e-02f,
  -4.80336621e-02f, -2.44068634e-02f, -1.02560714e-01f, -4.31642719e-02f, 8.69992897e-02f, 5.07765543e-03f, 1.02014346e-02f, -2.88118515e-02f, 1.88633781e-02f, -1.22731570e-02f,
  5.73820015e-03f, -1.62577212e-01f, -4.49431986e-02f, -1.36883007e-02f, -1.24075763e-01f, -1.59687608e-01f, 2.78965272e-02f, -9.27441195e-02f, 7.76441172e-02f, 6.46538846e-03f,
  -2.34298527e-01f, -4.30617556e-02f, -2.28279129e-01f, -1.69911534e-01f, -1.10905126e-01f, -2.49620639e-02f, -1.43817425e-01f, -2.72715129e-02f, 4.70714681e-02f, -1.48244962e-01f,
  -4.61237356e-02f, -8.71274397e-02f, -5.44891357e-02f, -2.41649617e-02f, -1.17422014e-01f, -8.74990746e-02f, -6.38808981e-02f, -9.78111178e-02f, -3.45203504e-02f, -2.08118409e-01f,
  -2.95359101e-02f, -2.04232857e-01f, -1.59937054e-01f, -2.05834553e-01f, -8.15679878e-02f, -9.86590907e-02f, -2.29205072e-01f, -1.21269792e-01f, -1.30575374e-01f, -8.83400254e-03f,
  3.13019663e-01f, 2.31613040e-01f, -4.39329863e-01f, 1.77912042e-01f, -2.07046211e-01f, -3.05267274e-01f, 5.26229925e-02f, 1.79446876e-01f, 2.73822278e-01f, 1.25530452e-01f,
  -7.27476478e-02f, -1.26583546e-01f, -1.78070709e-01f, -1.95839301e-01f, -3.03772241e-01f, -1.62537366e-01f, -2.70460218e-01f, -5.14381707e-01f, -5.92296004e-01f, -1.50612637e-01f,
  5.57018891e-02f, -2.56559998e-02f, 2.73699220e-02f, -1.55427918e-01f, 1.99008100e-02f, -2.15659365e-01f, -1.51282921e-01f, -1.96527600e-01f, -3.48366171e-01f, -1.92846745e-01f,
  -2.09756345e-01f, -7.32594579e-02f, -2.83421129e-01f, -1.14883166e-02f, -1.47137225e-01f, -3.44470255e-02f, -2.22670853e-01f, 6.19404390e-03f, 9.72651169e-02f, 5.64861335e-02f,
  -1.80780247e-01f, -8.30395371e-02f, -1.29101709e-01f, -1.24313265e-01f, -2.50900574e-02f, -2.13787630e-01f, 4.03615274e-02f, -1.85727701e-01f, 1.84519608e-02f, -3.97072807e-02f,
  2.48548053e-02f, -3.72343302e-01f, -2.23795310e-01f, -3.57291885e-02f, -1.30353197e-01f, -3.02313417e-01f, -7.99851716e-02f, -1.77228227e-01f, -3.42131197e-01f, 2.51852512e-01f,
  1.08911827e-01f, 3.23870704e-02f, -1.19883396e-01f, 8.52521136e-02f, 1.71360284e-01f, -3.37692052e-02f, -5.19586131e-02f, -3.25919315e-02f, 1.12718448e-01f, 8.41899440e-02f,
  6.31145984e-02f, -7.43443798e-03f, 8.73042792e-02f, 9.52024013e-02f, -2.09704880e-02f, -9.80075002e-02f, -6.25350922e-02f, 2.16856435e-01f, 1.05565377e-02f, -1.69386230e-02f,
  -8.43212903e-02f, -6.10208921e-02f, 2.75037028e-02f, 3.04893721e-02f, -4.91548739e-02f, -1.01425566e-01f, 8.64521880e-03f, -6.22364059e-02f, -6.65747970e-02f, -1.46964109e-02f,
  3.76039863e-01f, -1.63928136e-01f, 2.01912627e-01f, 7.86254369e-03f, -1.05347387e-01f, -3.14853527e-02f, -2.36860067e-02f, 5.56776021e-03f, 6.05691411e-02f, -6.06839173e-02f,
  -9.70482361e-03f, 9.77173224e-02f, -4.59868573e-02f, 7.47295767e-02f, -1.30152956e-01f, -8.98428783e-02f, 8.55815560e-02f, -8.51388946e-02f, -1.34851336e-01f, 4.97324318e-02f,
  2.00257182e-01f, 1.16193607e-01f, 9.55692530e-02f, 1.17790543e-01f, -6.51249960e-02f, -9.10808891e-02f, 7.12921098e-02f, 9.52273086e-02f, -8.30105767e-02f, 5.07750571e-01f,
  -7.47666787e-03f, 9.08897296e-02f, -1.68834120e-01f, -8.57681856e-02f, -1.19794212e-01f, -6.59807865e-03f, 3.11326925e-02f, 1.55778423e-01f, 3.36807035e-02f, 1.96086496e-01f,
  -2.19578366e-03f, -1.66677594e-01f, -9.65999290e-02f, -3.19146901e-01f, -3.38803738e-01f, -9.68436301e-02f, -1.55473888e-01f, -2.31035590e-01f, -3.86225879e-01f, -1.13514967e-01f,
  5.68302758e-02f, -1.18454434e-01f, -1.35619044e-01f, -1.26780584e-01f, -7.85301998e-02f, -1.64484009e-01f, -3.44882421e-02f, -1.82715937e-01f, -1.25403330e-01f, -1.92463517e-01f,
  -2.05636799e-01f, 7.59133026e-02f, 1.52787924e-01f, 6.46278486e-02f, 4.31652702e-02f, 1.35819942e-01f, 1.48379624e-01f, 9.31539685e-02f, 2.69260388e-02f, 8.44891593e-02f,
  -6.14885949e-02f, 1.40375141e-02f, 1.43698037e-01f, 8.41340952e-05f, -1.47099569e-01f, -2.00445980e-01f, -9.46616307e-02f, 4.90699615e-03f, -6.15507104e-02f, -3.62672545e-02f,
  9.09267068e-02f, -5.33469990e-02f, -1.50039852e-01f, -2.12713838e-01f, -1.34902269e-01f, -1.51987031e-01f, -9.10289511e-02f, 2.19852980e-02f, -2.04623982e-01f, -1.43413976e-01f,
  9.48542506e-02f, 1.40057459e-01f, -1.11650564e-01f, -4.50644381e-02f, 6.79387301e-02f, 1.86687075e-02f, -9.84365121e-02f, 1.07732989e-01f, 8.40273872e-02f, -1.96515054e-01f,
  -4.58274335e-02f, 1.48109064e-01f, 6.10979125e-02f, 1.99252311e-02f, -1.34224936e-01f, -5.53103127e-02f, -7.63797089e-02f, 2.96892878e-02f, 4.26833332e-02f, -9.63853002e-02f,
  -3.37569565e-02f, -2.00767741e-02f, 3.57800513e-03f, -3.06857582e-02f, 9.03559029e-02f, -7.38765150e-02f, 2.34350166e-03f, -9.61978063e-02f, 1.62161868e-02f, -2.89963651e-02f,
  -1.84370801e-01f, 2.22354338e-01f, 9.48634371e-02f, -6.09249026e-02f, 2.77900174e-02f, -9.54882242e-03f, 1.95239373e-02f, 9.53894034e-02f, -1.34253532e-01f, -6.86582774e-02f,
  -8.23639929e-02f, 5.00955479e-03f, 1.06707267e-01f, 6.68304861e-02f, -2.74007628e-03f, -9.25954506e-02f, -1.99220628e-01f, -9.98471454e-02f, -7.21825063e-02f, 9.15462524e-02f,
  1.86563693e-02f, -1.70759186e-01f, -2.07417771e-01f, -2.08016112e-01f, -4.75140102e-02f, -1.39652014e-01f, -2.20490664e-01f, -1.34277210e-01f, -1.45752370e-01f, -1.38276190e-01f,
  -5.70694685e-01f, -4.57980216e-01f, 1.33896306e-01f, -9.09122527e-02f, 2.88713217e-01f, 2.75037467e-01f, 1.21909581e-01f, 3.27350385e-02f, 4.18866277e-02f, 2.37911064e-02f,
  -9.81170014e-02f, -8.40603858e-02f, -2.61323769e-02f, -1.18603492e-02f, -5.88177145e-02f, 1.21906459e-01f, 3.19547176e-01f, 1.10052519e-01f, 2.64739990e-01f, 2.23976731e-01f,
  1.68726906e-01f, 8.66111889e-02f, -1.39613613e-01f, 7.86667094e-02f, 1.22693539e-01f, 2.54456252e-01f, 6.72815591e-02f, 1.04710549e-01f, 8.72608721e-02f, 2.03629926e-01f,
  2.32170284e-01f, -3.84499818e-01f, 6.89929957e-03f, -1.81606457e-01f, -7.60454014e-02f, -1.21004127e-01f, -6.79001659e-02f, -1.56313732e-01f, -3.71246636e-02f, 4.58539091e-03f,
  -8.30188096e-02f, -1.40417129e-01f, -1.52245343e-01f, -1.35323014e-02f, -4.73529398e-02f, -7.61492476e-02f, -1.78128168e-01f, -9.67300236e-02f, -1.18137049e-02f, -1.69195041e-01f,
  -7.65909776e-02f, 3.94747034e-02f, 9.03554261e-02f, 7.46094212e-02f, 2.92263012e-02f, 2.95144673e-02f, -1.26854572e-02f, -1.24933128e-03f, -2.28766389e-02f, -8.22229311e-02f,
  8.29735622e-02f, -7.71804526e-02f, 9.27312300e-03f, -1.87911429e-02f, 6.22989126e-02f, 2.32827403e-02f, 1.52770326e-01f, 2.75715552e-02f, 1.65832430e-01f, 2.79733315e-02f,
  3.10331210e-02f, 6.16874769e-02f, 4.96999025e-02f, 7.20969737e-02f, 7.00771660e-02f, -7.45011047e-02f, -5.54771461e-02f, -5.42312637e-02f, -4.48615924e-02f, 7.90522918e-02f,
  2.81726699e-02f, 1.25412494e-01f, -1.36026129e-01f, 1.02797173e-01f, -2.81235520e-02f, -9.81568992e-02f, 1.28612686e-02f, -1.99606121e-02f, -5.74256852e-02f, -3.10182404e-02f,
  4.34103668e-01f, -1.15985833e-01f, 5.55657074e-02f, -2.01160628e-02f, -5.96629009e-02f, -1.54802352e-01f, 2.45018415e-02f, -3.48696262e-02f, 1.07555399e-02f, 1.15289070e-01f,
  -5.81212230e-02f, 3.97052877e-02f, -5.73956743e-02f, -5.94950989e-02f, 1.64566442e-01f, 2.37623304e-02f, -1.55323759e-01f, 2.22746022e-02f, -4.84767072e-02f, -1.04927994e-01f,
  -9.64495689e-02f, 1.29073173e-01f, 8.57634842e-02f, 2.00495258e-01f, 1.33579999e-01f, 1.04623288e-01f, 6.03011698e-02f, 6.12369552e-02f, 1.21527828e-01f, 9.14353952e-02f,
  2.94122368e-01f, -1.84908867e-01f, -5.31533957e-01f, -9.27897617e-02f, -3.98151159e-01f, -2.54614025e-01f, -3.96089405e-01f, 2.71097366e-02f, 5.50122410e-02f, -4.81933653e-01f,
  -2.24858403e-01f, 8.58975276e-02f, -2.09982023e-01f, -2.77619492e-02f, -1.39523327e-01f, -5.44718146e-01f, -5.33670247e-01f, -2.71872044e-01f, -9.36658084e-02f, -9.79037806e-02f,
  -2.01478198e-01f, -1.13388501e-01f, -4.26036213e-03f, -2.58079376e-02f, -2.15529855e-02f, 1.19872622e-01f, -3.49455178e-01f, -9.07492116e-02f, 1.67131498e-02f, -1.31405741e-01f,
  -2.06078589e-01f, -4.00154442e-02f, -8.94274339e-02f, 1.32692203e-01f, -6.00514188e-02f, 1.39889166e-01f, -9.26615298e-02f, 3.65039520e-02f, 6.33751228e-02f, -9.11431834e-02f,
  -5.77765591e-02f, 1.49779776e-02f, -4.88414951e-02f, -4.79134731e-02f, -6.88644999e-04f, 2.77206339e-02f, -1.89592272e-01f, -1.36104837e-01f, -8.14770162e-02f, -1.49727210e-01f,
  -1.85358182e-01f, -1.15547672e-01f, -4.80370084e-03f, -3.80599089e-02f, 5.99357449e-02f, 4.33746204e-02f, 1.06339511e-02f, 1.14429347e-01f, 2.51037925e-01f, 9.38293859e-02f,
  -1.74347594e-01f, -2.19995193e-02f, -3.40937525e-02f, -4.07732986e-02f, -3.91164124e-02f, -3.01415883e-02f, 4.25080732e-02f, 1.33387186e-02f, 5.13806939e-02f, -1.72052868e-02f,
  -5.45744374e-02f, 2.84784455e-02f, -4.52576159e-03f, -1.75139401e-02f, -1.74206495e-02f, -6.44629896e-02f, -1.17620096e-01f, -1.19892351e-01f, -1.47741688e-02f, -5.10051623e-02f,
  -1.15562551e-01f, 1.09865725e-01f, -4.15387657e-03f, 9.05450359e-02f, -1.03767797e-01f, -6.72783330e-02f, -1.00342128e-02f, -5.65601811e-02f, 2.46763434e-02f, -9.03242920e-03f,
  4.17584926e-02f, -2.18247488e-01f, -2.23721579e-01f, -2.17084195e-02f, -6.01408035e-02f, -1.56049997e-01f, -1.58648059e-01f, 2.80575771e-02f, 1.27704233e-01f, -1.93591908e-01f,
  1.84175596e-02f, -8.60825181e-02f, -1.77786097e-01f, -1.17501214e-01f, -1.43538371e-01f, -9.94578525e-02f, -6.50005117e-02f, -4.02044412e-03f, -2.03789733e-02f, -7.53925294e-02f,
  -1.82083115e-01f, -4.79589142e-02f, 5.08288890e-02f, 3.49719822e-02f, 1.05711326e-01f, 3.54532562e-02f, -6.83665052e-02f, 6.07299097e-02f, 1.12057731e-01f, -1.73772369e-02f,
  7.07475007e-01f, -3.99591833e-01f, -4.56573702e-02f, 9.16272253e-02f, -4.80724004e-04f, 8.31133407e-03f, -1.61518812e-01f, -4.66328189e-02f, 5.81804067e-02f, -1.57101527e-01f,
  -1.72413558e-01f, -1.53167648e-02f, -3.91214155e-02f, -1.43414378e-01f, -1.26285199e-02f, -1.46587670e-01f, 4.23314795e-02f, 1.69422597e-01f, 3.00425619e-01f, -1.52285201e-02f,
  -1.33027658e-01f, 1.79107502e-01f, 2.29726896e-01f, -1.23372814e-02f, -3.07688773e-01f, -7.37723187e-02f, -1.40563667e-01f, -4.32738848e-03f, -2.33221620e-01f, -3.35560679e-01f,
  -3.48651826e-01f, -1.06647141e-01f, 3.69600989e-02f, -1.04193561e-01f, -8.53041112e-02f, 5.89298829e-02f, -1.08705265e-02f, -7.64175653e-02f, -1.47175789e-02f, -7.69205540e-02f,
  -3.14988084e-02f, 5.77358156e-02f, 7.52793625e-02f, -6.03635870e-02f, -1.01589806e-01f, -9.18940455e-03f, 5.67160174e-02f, 5.66847362e-02f, -8.03874359e-02f, -1.61075816e-01f,
  -1.46947503e-01f, 1.21369809e-02f, -3.25844362e-02f, 3.64222452e-02f, 2.06626784e-02f, 1.89711988e-01f, -6.74968660e-02f, 7.14473501e-02f, 1.52549982e-01f, 7.12599903e-02f,
  9.68558937e-02f, -9.64934006e-02f, 7.70490915e-02f, 1.61196843e-01f, 1.55997306e-01f, 7.12847635e-02f, 8.22448079e-03f, 5.64865619e-02f, 1.41348481e-01f, 4.03013229e-02f,
  -4.17868234e-02f, 2.15290356e-02f, 6.75156862e-02f, 8.60298425e-02f, -8.74241143e-02f, -8.40263739e-02f, 1.12654723e-01f, -9.94513407e-02f, -3.81911248e-02f, -4.03727666e-02f,
  7.71039203e-02f, -1.03922069e-01f, -5.97775280e-02f, -2.07114354e-01f, -9.82962921e-02f, -3.70604843e-02f, -5.71695194e-02f, -5.84285893e-02f, -2.41973214e-02f, -6.11574091e-02f,
  -2.55242914e-01f, 2.62727082e-01f, 3.96527350e-02f, -2.97446526e-03f, -4.62544113e-02f, -3.41856219e-02f, 6.05021138e-03f, -1.01317607e-01f, -1.42270476e-01f, -2.00248566e-02f,
  -1.20058633e-01f, -2.46080477e-03f, 3.93274985e-02f, -2.55322829e-02f, 1.62756786e-01f, 1.54646039e-01f, 1.35196775e-01f, 5.65910749e-02f, -3.97359766e-02f, -2.28304937e-01f,
  -3.01572420e-02f, 2.21779197e-01f, 2.07636237e-01f, 2.23263726e-01f, 2.32872903e-01f, 3.03372771e-01f, 7.15832785e-02f, 9.85578001e-02f, 1.25182360e-01f, 1.92553267e-01f,
  -2.88557023e-01f, -1.50711939e-01f, 3.47835809e-01f, -1.09643713e-01f, 7.49183372e-02f, -6.41052565e-03f, -4.10919130e-01f, -3.52080554e-01f, -1.87883615e-01f, -2.81439990e-01f,
  -3.32477875e-02f, 1.74779117e-01f, 7.36813024e-02f, 2.74269935e-02f, -2.60339499e-01f, -3.83480847e-01f, -1.20787829e-01f, 1.21481091e-01f, 1.16877504e-01f, -6.39401078e-02f,
  -1.78775564e-01f, -9.88989025e-02f, -4.14893962e-02f, 5.27496338e-02f, -1.14312775e-01f, 2.11912140e-01f, 1.59549281e-01f, 1.12607844e-01f, 2.03666300e-01f, 5.85392192e-02f,
  -1.03084497e-01f, -1.69026583e-01f, 1.17415577e-01f, -1.83197223e-02f, 7.49868676e-02f, -1.30232424e-01f, -1.04968529e-02f, 1.14743248e-01f, -8.60573947e-02f, -1.24814380e-02f,
  8.81889090e-02f, -1.46948695e-01f, -1.53909111e-02f, -1.06116375e-02f, -3.42690647e-01f, -1.59564883e-01f, -1.11253269e-01f, -1.74361810e-01f, -1.44606560e-01f, -1.99837029e-01f,
  -8.45850930e-02f, -5.20963483e-02f, -7.49358116e-03f, 3.99749391e-02f, -7.15824664e-02f, 4.38490920e-02f, 2.10257322e-01f, 7.66594484e-02f, 1.31576151e-01f, -4.47632466e-03f,
  6.45269901e-02f, 1.13228828e-01f, 7.10804462e-02f, -6.75482899e-02f, -1.36769339e-01f, -3.20626125e-02f, -1.41356392e-02f, -1.07391521e-01f, -2.14234777e-02f, -1.45968243e-01f,
  -1.37748957e-01f, -1.56821847e-01f, -3.74212973e-02f, -3.87177393e-02f, 1.32015362e-01f, -8.27455800e-03f, -3.85147370e-02f, 1.87918032e-03f, 3.42469141e-02f, 2.18524057e-02f,
  -3.75097208e-02f, 7.41771311e-02f, -7.01284185e-02f, 6.68126112e-03f, -6.88281283e-03f, -9.35744420e-02f, -7.95421153e-02f, 1.62462994e-01f, -5.31045087e-02f, -1.13504902e-01f,
  -1.56865343e-01f, 3.17775548e-01f, -8.01246613e-02f, -4.88887057e-02f, -9.72334743e-02f, 2.08303064e-01f, 4.42544930e-02f, -2.76153851e-02f, 8.99441615e-02f, 6.96580634e-02f,
  -1.29294889e-02f, -3.94233093e-02f, -5.25853224e-02f, 8.59971866e-02f, -1.49657637e-01f, 5.99115295e-03f, -1.47247255e-01f, 4.90077883e-02f, -7.38487765e-02f, -9.38646216e-03f,
  -4.01410228e-03f, -2.38417223e-01f, -2.77831435e-01f, -1.02829494e-01f, -7.58622661e-02f, -1.09758101e-01f, -1.52336620e-02f, 1.39699340e-01f, -1.99531913e-02f, -2.41421878e-01f,
  7.67654240e-01f, 2.70456642e-01f, 1.58682987e-02f, -8.83085355e-02f, -4.29166555e-01f, -3.85241240e-01f, -8.47866759e-02f, 7.68640339e-02f, -1.45699188e-01f, -1.40837997e-01f,
  -1.91699132e-01f, -7.10224062e-02f, -3.20169590e-02f, -4.94822487e-02f, 8.03602114e-02f, 6.05800608e-03f, -6.30688891e-02f, 7.58955032e-02f, -1.71853527e-02f, -1.59067273e-01f,
  -1.66151583e-01f, 8.69798139e-02f, 3.28193367e-01f, 1.38324633e-01f, -3.09061445e-03f, -1.90630004e-01f, 7.43604898e-02f, -3.45999710e-02f, -1.02464572e-01f, -1.01617128e-01f,
  6.03888482e-02f, 3.68451595e-01f, -3.84096146e-01f, -1.56605747e-02f, -3.57848972e-01f, 1.59755182e-02f, -1.11249983e-01f, 4.26399484e-02f, -1.94171339e-01f, 5.03137335e-03f,
  -2.75142878e-01f, -1.77539825e-01f, -1.18050098e-01f, -1.07274570e-01f, -7.32581541e-02f, -2.59798229e-01f, 5.55777699e-02f, 2.20209718e-01f, 1.07309699e-01f, 1.13551907e-01f,
  -2.53509432e-01f, -1.18831798e-01f, 6.18934259e-02f, -1.36293083e-01f, -5.83374165e-02f, -7.84356594e-02f, -9.74498317e-02f, -1.07512131e-01f, 1.99485458e-02f, 1.11787103e-01f,
  -9.10640974e-03f, 1.39208091e-02f, -5.55299260e-02f, 1.79362327e-01f, 8.53833091e-03f, -8.15162435e-02f, 4.08261120e-02f, 1.69578921e-02f, -1.80411823e-02f, 4.38141152e-02f,
  -1.23705283e-01f, -3.85137536e-02f, 2.79097427e-02f, 2.00913046e-02f, -2.01275572e-02f, 4.56839763e-02f, -2.26845816e-01f, 2.52592587e-03f, 2.06660796e-02f, 9.80284065e-02f,
  -4.40679863e-02f, -9.92441624e-02f, -3.78128029e-02f, 1.23176210e-01f, 3.22335176e-02f, -1.23522572e-01f, -2.51722727e-02f, -1.03980973e-01f, 2.07395237e-02f, 7.82615766e-02f,
  1.09036349e-01f, -3.21460813e-02f, 1.30711436e-01f, -2.55399328e-02f, 1.70050021e-02f, -9.59408507e-02f, -9.11234096e-02f, -1.56117767e-01f, -3.02339904e-02f, -6.04982823e-02f,
  -1.23613693e-01f, -2.55991835e-02f, 1.70089588e-01f, -1.64092243e-01f, -1.42668545e-01f, -8.08707327e-02f, -1.78451419e-01f, -2.09485903e-01f, -2.06412315e-01f, -3.96078452e-02f,
  -1.72184244e-01f, -7.82998651e-02f, 1.00608297e-01f, -7.19033107e-02f, -8.63227770e-02f, -1.77857757e-01f, -6.82811216e-02f, -2.47970209e-01f, -1.29587948e-01f, 1.45275801e-01f,
  6.01280868e-01f, 1.25575230e-01f, 2.55010128e-01f, 3.31431121e-01f, 3.03151578e-01f, 3.17673326e-01f, 2.66938388e-01f, 1.20640762e-01f, 1.32193953e-01f, 9.00912061e-02f,
  1.36885747e-01f, 1.30447850e-01f, 1.18306644e-01f, -4.43220064e-02f, -8.68524164e-02f, -4.71598208e-02f, -8.98279399e-02f, 2.83835288e-02f, 9.91012082e-02f, 1.47825599e-01f,
  9.83508304e-02f, -2.47551352e-02f, 6.36094734e-02f, 1.19112141e-01f, -5.53698242e-02f, -5.26294000e-02f, 2.48577003e-03f, 9.79881268e-03f, 1.23847261e-01f, -1.68368191e-01f,
  -1.07375078e-01f, 1.46181658e-01f, 1.63573232e-02f, -1.33497760e-01f, 8.46675038e-02f, -3.50778587e-02f, 9.27315000e-03f, -1.21631391e-01f, -8.62859935e-02f, -1.35551438e-01f,
  -1.43526327e-02f, -4.81352918e-02f, -2.51979399e-02f, -6.49770126e-02f, -8.87458324e-02f, -8.01335424e-02f, 8.57702643e-03f, 1.03769368e-02f, -8.46853480e-02f, -2.47625709e-02f,
  -2.17841733e-02f, 5.85989282e-02f, -3.02003697e-02f, 1.05921067e-01f, 1.38386011e-01f, -3.98332477e-02f, 1.22455619e-01f, -3.39235067e-02f, 1.38536409e-01f, 1.09538622e-02f,
  7.14847744e-02f, 2.36169383e-01f, 3.01662058e-01f, 5.41765690e-02f, 1.24498822e-01f, 1.35987043e-01f, -1.09635137e-01f, -1.20066449e-01f, 7.09924400e-02f, 1.58698130e-02f,
  -1.24041162e-01f, 7.61734471e-02f, 3.08664851e-02f, 1.32496143e-02f, 2.20145270e-01f, 8.07159208e-03f, -2.16127802e-02f, -4.65429090e-02f, 7.47627020e-02f, -5.14277816e-02f,
  7.83402696e-02f, -9.97824520e-02f, -1.50209919e-01f, -2.01010376e-01f, -5.75514175e-02f, 9.80742723e-02f, -3.54463840e-03f, 2.79912893e-02f, 4.34937179e-02f, 2.03207806e-02f,
  -5.55514038e-01f, 2.84245968e-01f, 6.02948517e-02f, -1.86614960e-01f, -1.11602442e-02f, -4.84995879e-02f, 2.14346498e-02f, -9.36817825e-02f, -2.03024283e-01f, -1.72008589e-01f,
  -4.68257954e-03f, -1.11820525e-03f, 6.84936345e-03f, -6.32990003e-02f, -3.50869671e-02f, 9.98191317e-05f, 3.02032847e-02f, -9.55869853e-02f, -1.68176085e-01f, -1.79880112e-01f,
  -4.10310030e-02f, 9.48664993e-02f, -5.27200140e-02f, 9.10713077e-02f, 1.35166466e-01f, 1.75902341e-02f, 7.17443079e-02f, 5.52696735e-02f, 6.44744188e-03f, -1.52213033e-02f,
  1.88006371e-01f, -3.19139063e-01f, -1.01095937e-01f, 1.62306175e-01f, 3.31565082e-01f, 2.35562086e-01f, 3.54357153e-01f, 2.34707877e-01f, 2.89094627e-01f, 9.41996574e-02f,
  -1.04422472e-01f, -3.14035892e-01f, -2.20815316e-01f, -2.85913736e-01f, -1.32319242e-01f, 5.79669848e-02f, 1.32857025e-01f, -9.95153934e-02f, -4.35888814e-03f, 2.04834282e-01f,
  2.10519493e-01f, 1.57347262e-01f, 2.38479022e-03f, 4.38200384e-02f, 2.76113581e-02f, 4.92733438e-03f, 9.10245581e-04f, -6.13993742e-02f, -1.51132971e-01f, -2.08928838e-01f,
  -4.07541752e-01f, -3.02381903e-01f, 1.51934251e-01f, -3.25109847e-02f, -9.39599350e-02f, 5.36084250e-02f, 5.29437661e-02f, 4.14875187e-02f, 2.69635487e-02f, 1.61784202e-01f,
  -2.40618340e-03f, 1.98504087e-02f, -3.65629233e-02f, 5.94312102e-02f, 3.69248986e-02f, 1.10473437e-02f, 2.75376136e-03f, -3.20517011e-02f, -6.91489428e-02f, -1.36297554e-01f,
  -1.67614266e-01f, 2.99041457e-02f, 4.28394675e-02f, -5.05648665e-02f, -2.11505532e-01f, 9.16541070e-02f, -3.79296802e-02f, -6.32208437e-02f, -1.68351173e-01f, 6.35038735e-03f,
  1.53921902e-01f, 6.32303432e-02f, -1.66410238e-01f, -1.85238138e-01f, -2.64673419e-02f, -2.22199094e-02f, -5.33492155e-02f, -4.40481082e-02f, -2.15203762e-02f, 1.84927005e-02f,
  6.75054044e-02f, -1.03234336e-01f, -1.65868387e-01f, 4.77046631e-02f, -1.85075551e-01f, -3.45537364e-02f, 1.11659430e-02f, -1.35576531e-01f, -1.91857412e-01f, -3.38752940e-02f,
  -1.40094385e-01f, 1.18933000e-01f, 9.62985400e-03f, -9.68789384e-02f, -3.88665753e-03f, -6.71660081e-02f, 3.13786007e-02f, -3.26342657e-02f, -7.92161189e-03f, 2.24112153e-01f,
  -9.84863639e-02f, -3.97959024e-01f, -2.72537805e-02f, -1.35802776e-01f, -2.82300711e-02f, 7.08595384e-03f, -3.06427538e-01f, -1.65879488e-01f, 6.66229054e-02f, -5.90401404e-02f,
  -1.48567453e-01f, -1.30857512e-01f, -1.04821503e-01f, 2.54212017e-03f, 2.17463240e-01f, 1.46237593e-02f, -4.13849652e-02f, 5.57837859e-02f, -3.98433805e-02f, -2.86274143e-02f,
  2.07741596e-02f, 1.82716578e-01f, 1.63915679e-01f, 4.66454215e-02f, 1.03087194e-01f, 1.43940032e-01f, 1.05665237e-01f, 1.24675773e-01f, 3.36439395e-03f, 3.03839326e-01f,
  1.25686169e-01f, 1.38989389e-01f, 1.10425584e-01f, 2.43744835e-01f, 2.06097052e-01f, 2.06080109e-01f, 1.76945448e-01f, 1.57192163e-02f, 4.99142669e-02f, 2.19268903e-01f,
  1.84086621e-01f, 2.01291397e-01f, 4.36785109e-02f, 6.50824085e-02f, 9.97512490e-02f, -1.12917917e-02f, 1.47201166e-01f, 6.87334836e-02f, -8.02597031e-02f, 1.18973814e-01f,
  2.04967663e-01f, 1.77876934e-01f, 8.56408700e-02f, -4.03667651e-02f, 7.83502758e-02f, 1.52602851e-01f, 1.85467318e-01f, 2.64343917e-01f, 1.96557909e-01f, 1.80647224e-01f,
  1.68257192e-01f, 6.23227060e-02f, -1.00675501e-01f, -1.39417127e-01f, -8.04994330e-02f, -1.39672473e-01f, -1.34898618e-01f, -7.73892105e-02f, -6.81753308e-02f, -2.12372124e-01f,
  -1.49435103e-01f, -1.74230896e-02f, 1.36198970e-02f, -1.44535694e-02f, -1.89086735e-01f, -1.35571778e-01f, -4.74614799e-02f, 2.59646997e-02f, 1.60316639e-02f, -5.56480214e-02f,
  -9.76066813e-02f, 8.79110992e-02f, 6.58904091e-02f, -1.33776993e-01f, -5.53479977e-02f, -2.64014746e-03f, -1.19850792e-01f, -1.17450252e-01f, -8.06926098e-03f, 6.92514051e-03f,
  -4.96560987e-03f, -5.53947221e-03f, 5.96484914e-02f, 5.50967045e-02f, -7.35950246e-02f, -4.10492569e-02f, 7.20185041e-03f, 6.01052456e-02f, 1.21051054e-02f, -4.83024307e-02f,
  -1.25486515e-02f, 9.30108279e-02f, -1.98284909e-02f, 5.63609488e-02f, 4.67879418e-03f, 5.84969893e-02f, -6.38043508e-03f, -8.81606862e-02f, -2.13039014e-02f, -3.74181159e-02f,
  -9.23212022e-02f, -5.08260168e-02f, -6.43425062e-02f, -2.82393140e-03f, -4.18307744e-02f, -3.49626783e-03f, -3.16426121e-02f, -9.24613178e-02f, -1.84380844e-01f, -1.03071302e-01f,
  2.87853986e-01f, 8.94802362e-02f, 1.70646030e-02f, 5.34351058e-02f, 1.58765092e-02f, -3.69971395e-02f, 1.57318383e-01f, 6.10917881e-02f, 4.30435240e-02f, 2.54396871e-02f,
  -7.33237118e-02f, -9.78007317e-02f, 1.81647688e-02f, -2.81165745e-02f, -6.86566904e-02f, -5.25672957e-02f, -2.45768744e-02f, 1.55820727e-01f, 1.04331069e-01f, 8.68805721e-02f,
  -8.69720876e-02f, 7.12311491e-02f, 5.41910939e-02f, 8.70371610e-02f, 7.61276633e-02f, 1.29259422e-01f, -6.38662055e-02f, -9.35228094e-02f, -3.98838334e-02f, -6.40330464e-02f,
  -6.05944097e-01f, -2.12181717e-01f, -1.47571027e-01f, -2.21677825e-01f, -1.71242893e-01f, -2.82626122e-01f, -2.17194661e-01f, -1.10162929e-01f, -2.43732542e-01f, -2.80607808e-02f,
  -3.04441266e-02f, -1.81909323e-01f, -1.22719519e-01f, -2.72396147e-01f, -3.67945939e-01f, -2.80260921e-01f, -3.28536063e-01f, -4.38292831e-01f, -3.25579047e-01f, -3.10875654e-01f,
  -3.67799491e-01f, -4.40062553e-01f, -4.05784816e-01f, -3.30559731e-01f, -6.77522123e-02f, -1.61810309e-01f, -2.18955293e-01f, -2.08353728e-01f, -9.09609273e-02f, -8.36676434e-02f,
  1.97362229e-01f, 2.43392102e-02f, -4.20108158e-03f, -9.15768463e-03f, 4.83760387e-02f, -4.53764684e-02f, -1.27071545e-01f, 1.27432019e-01f, 4.96140569e-02f, 1.72560811e-01f,
  -5.36911301e-02f, -1.05257921e-01f, -5.70541844e-02f, 1.18455313e-01f, 1.06808633e-01f, 5.13464734e-02f, 2.06295937e-01f, 7.92191178e-02f, 1.60113275e-01f, 2.02005774e-01f,
  1.42368823e-01f, 7.74067491e-02f, 2.27820314e-02f, 1.61309227e-01f, 1.40518442e-01f, 1.55786127e-02f, 2.25848973e-01f, 2.31366858e-01f, 3.40373181e-02f, 7.75980875e-02f,
  -1.08780526e-01f, 8.23232869e-04f, 4.48400937e-02f, 6.26246780e-02f, 1.01619065e-01f, 2.31313147e-02f, 2.93039307e-02f, -8.21682289e-02f, -8.61106962e-02f, -2.55431589e-02f,
  4.10866067e-02f, 9.76109728e-02f, -4.95979749e-02f, -5.38801253e-02f, -9.36322361e-02f, -5.61523624e-03f, -4.02925871e-02f, -7.69166555e-03f, 7.12404177e-02f, 5.64076789e-02f,
  7.12760091e-02f, 5.45562357e-02f, -1.17122456e-01f, 6.14546314e-02f, 9.25673991e-02f, 2.40126457e-02f, 3.20741683e-02f, -1.30813895e-02f, -1.24890462e-01f, -6.42141998e-02f,
  2.46488854e-01f, -1.80341944e-01f, -4.99774404e-02f, -3.47044840e-02f, -1.55785866e-02f, 7.93600306e-02f, 1.66063204e-01f, 2.41782442e-02f, -2.69717537e-02f, 3.14316154e-02f,
  7.01508150e-02f, 3.45817059e-02f, 8.79165679e-02f, 1.09341957e-01f, -4.90866825e-02f, 2.11445205e-02f, 1.31661743e-01f, -1.90196559e-02f, -3.25793065e-02f, 9.74707305e-02f,
  9.67949256e-02f, -1.15088020e-02f, 5.93268080e-03f, 7.26563707e-02f, 6.89019356e-03f, -1.69523880e-01f, 2.04069242e-02f, 1.19764738e-01f, -4.53022830e-02f, 1.25053287e-01f,
  -4.20631438e-01f, 1.17590488e-03f, 3.35783511e-01f, -2.56538123e-01f, 9.32719633e-02f, 1.94306254e-01f, 1.46865547e-01f, -6.96287071e-03f, -1.40991092e-01f, 2.63779098e-03f,
  -6.05890565e-02f, -4.12286550e-01f, -3.49841088e-01f, -3.46243918e-01f, -1.79139957e-01f, 1.05385266e-01f, 1.66447937e-01f, -2.01407839e-02f, -1.72669381e-01f, -2.40487114e-01f,
  -2.64288068e-01f, -1.45797104e-01f, -2.02553228e-01f, -2.34959945e-01f, -4.29140180e-02f, -1.09905846e-01f, 1.66473106e-01f, -9.52825174e-02f, -1.06650274e-02f, 5.67477532e-02f,
  3.08285803e-01f, 8.01011473e-02f, -1.02302015e-01f, -2.45993361e-01f, 1.57259256e-02f, -1.98301207e-02f, -3.35457213e-02f, -6.39346940e-03f, -4.54824306e-02f, 1.13496684e-01f,
  -3.02169044e-02f, -5.78614660e-02f, -8.02868232e-02f, 2.55151000e-02f, 3.47408466e-02f, 3.98468636e-02f, 2.50593014e-02f, -7.58339390e-02f, -2.12168917e-02f, 1.06149189e-01f,
  -7.39040077e-02f, -4.76311035e-02f, 1.89550653e-01f, -1.30695952e-02f, -3.12219039e-02f, 1.34522356e-02f, 1.18999369e-01f, -1.03343457e-01f, 8.94982666e-02f, -5.33028506e-03f,
  3.27450149e-02f, 3.05443276e-02f, 2.74048764e-02f, 8.15667212e-02f, 1.38902247e-01f, 2.06007943e-01f, 1.60831809e-01f, 1.56168565e-01f, 1.10721603e-01f, 6.25165105e-02f,
  1.65188342e-01f, 1.30264953e-01f, 2.23027706e-01f, 2.33138606e-01f, 5.54045774e-02f, 1.03198022e-01f, 8.59891251e-02f, 8.82398933e-02f, 1.22500725e-01f, 6.15054481e-02f,
  -7.53180403e-03f, 6.82575107e-02f, 1.88061386e-01f, 1.74298182e-01f, 1.34474486e-01f, 2.17316244e-02f, 2.14868467e-02f, 1.09625280e-01f, 9.91165265e-02f, 1.32629544e-01f,
  1.75148703e-03f, -9.99409854e-02f, 1.34087875e-01f, -1.10646024e-01f, 5.00354022e-02f, 3.29975002e-02f, -5.88126704e-02f, 6.29160479e-02f, 2.10834993e-03f, 1.76791072e-01f,
  3.60675156e-02f, 9.34903882e-03f, 3.57216671e-02f, 1.55935213e-02f, 1.14652514e-01f, 8.82860944e-02f, -4.25625183e-02f, -7.64167123e-03f, -8.35131630e-02f, 3.03299306e-03f,
  -6.77578747e-02f, 5.79313673e-02f, 2.98972018e-02f, 2.51762811e-02f, 2.55300738e-02f, 1.20848686e-01f, 4.34053689e-02f, -3.96036431e-02f, 6.62472006e-03f, -4.63156169e-03f,
  2.02653050e-01f, -4.08732623e-01f, 4.40505780e-02f, 6.54051676e-02f, 1.33602722e-02f, 1.02786765e-01f, 3.90359536e-02f, 6.69585913e-02f, 8.50285068e-02f, 2.67088246e-02f,
  -3.76077788e-03f, 1.42010838e-01f, 1.85902342e-01f, 6.73006102e-02f, 4.47979569e-03f, 9.73254666e-02f, 4.22990508e-02f, 1.70126677e-01f, 1.68468326e-01f, 6.99419454e-02f,
  5.54877445e-02f, 4.54475768e-02f, -9.38773714e-03f, 1.63339183e-01f, 1.02737099e-01f, 4.36720364e-02f, 7.02962130e-02f, 2.01783609e-02f, 4.17804904e-02f, -4.92200963e-02f,
  -1.03119902e-01f, -9.47702155e-02f, -1.48691842e-03f, -1.06541283e-01f, -4.95995693e-02f, -6.92588091e-02f, -1.54137500e-02f, -5.32300062e-02f, -5.93531132e-02f, -1.16583884e-01f,
  -4.00977097e-02f, -1.94792554e-01f, -1.68066043e-02f, -1.42649472e-01f, -9.07891244e-02f, -1.72868162e-01f, -2.12330986e-02f, 7.68245161e-02f, 1.12649374e-01f, -1.11772984e-01f,
  -4.99924347e-02f, -1.30054981e-01f, -1.03418864e-01f, 5.19429184e-02f, 7.86617920e-02f, 3.53631079e-02f, -2.81527340e-02f, 6.63319677e-02f, -9.44867451e-03f, -3.20109795e-03f,
  1.66671813e-01f, -2.82632615e-02f, 1.15595311e-01f, 1.15495414e-01f, 7.85059631e-02f, 1.94035470e-01f, -3.86258364e-02f, -9.30210128e-02f, 1.71336204e-01f, -4.30179499e-02f,
  -1.56135280e-02f, 6.92705810e-02f, -4.02177200e-02f, -7.77563453e-02f, -1.89374536e-02f, -1.37274995e-01f, -2.05085222e-02f, 3.76133411e-03f, 6.87525570e-02f, 6.75380323e-03f,
  5.05416654e-02f, 6.52291924e-02f, 4.47602868e-02f, 1.00825101e-01f, -7.40150511e-02f, 8.65271240e-02f, -7.05846623e-02f, -1.14518113e-01f, -3.73866968e-02f, -1.72772378e-01f,
  -3.92383426e-01f, 2.50305742e-01f, 1.33509353e-01f, 2.37175114e-02f, -2.01349333e-01f, -9.68796909e-02f, 1.35481492e-01f, -1.81782544e-01f, -5.09582013e-02f, -9.53817442e-02f,
  -8.86004865e-02f, 1.31710470e-02f, 1.58108547e-02f, -3.28821987e-02f, 1.05118994e-02f, -1.29061118e-01f, -1.20806471e-01f, -1.85015071e-02f, -1.24232378e-02f, -3.26540209e-02f,
  -1.95571240e-02f, -1.05753966e-01f, -1.33815825e-01f, 4.35315482e-02f, 1.12831676e-02f, 3.24858762e-02f, 4.50043119e-02f, -1.59162115e-02f, -4.94375126e-03f, -8.21853951e-02f,
  -4.03111875e-01f, 5.26521504e-01f, 1.62042603e-01f, -4.34315652e-01f, 2.13386834e-01f, 4.23730731e-01f, 6.19803488e-01f, 1.25981078e-01f, -3.17096204e-01f, 2.81190127e-01f,
  2.90423512e-01f, -2.92367518e-01f, -1.35470897e-01f, -7.49540702e-02f, 2.14860998e-02f, 3.72653902e-01f, 4.33351233e-04f, -1.94021225e-01f, -3.87541503e-01f, 4.42086952e-03f,
  -5.57511970e-02f, -1.95627481e-01f, -3.43278974e-01f, -2.16636375e-01f, -2.98338272e-02f, -1.83705911e-01f, 1.18995912e-01f, 5.93844093e-02f, 2.98914701e-01f, -1.47284314e-01f,
  1.41590342e-01f, 1.81492999e-01f, -2.03015193e-01f, -1.32196024e-01f, 1.14142105e-01f, -1.96073100e-01f, -1.06848538e-01f, -1.34919077e-01f, -1.35796040e-01f, -1.23524681e-01f,
  1.44537082e-02f, 3.98275517e-02f, -3.75682983e-04f, -7.40434453e-02f, 8.95830395e-04f, 8.58659390e-03f, 1.83828045e-02f, -1.49168655e-01f, -7.50542060e-02f, 3.52310538e-02f,
  1.13935769e-01f, 1.71898827e-01f, 1.03201054e-01f, 1.34624720e-01f, 2.80726869e-02f, -1.78770468e-01f, 1.71874151e-01f, 2.99656317e-02f, 3.68693136e-02f, -1.88027278e-01f,
  7.03211920e-03f, 3.92665043e-02f, 4.25901413e-02f, -2.31712200e-02f, -7.45807821e-03f, -1.36032207e-02f, -5.35434159e-03f, 4.62029167e-02f, 4.13628668e-02f, -4.89392690e-02f,
  -3.52776237e-02f, 7.87866563e-02f, 1.80892716e-03f, 1.13073895e-02f, -1.34514019e-01f, -5.85260764e-02f, -4.02017124e-02f, -1.01569965e-01f, 7.55083784e-02f, 3.31796287e-03f,
  6.57019988e-02f, 3.66850570e-02f, 1.75356641e-02f, 6.49936497e-03f, 9.00544822e-02f, -2.44193971e-02f, -1.12564921e-01f, 6.93839788e-02f, -3.07237338e-02f, 1.69510096e-02f,
  -2.12039843e-01f, 2.41806239e-01f, -1.26834869e-01f, 6.72282651e-02f, 1.60738118e-02f, -6.98996857e-02f, -1.47502609e-02f, -1.48815038e-02f, 1.12542570e-01f, 1.17707262e-02f,
  -1.49601232e-02f, -9.68991965e-02f, 8.99121016e-02f, 1.17278270e-01f, -1.84929296e-01f, -1.32761583e-01f, 1.61207169e-01f, -8.92414972e-02f, -8.99940506e-02f, 5.98395169e-02f,
  2.35160161e-02f, 4.50794958e-02f, -1.78004906e-01f, -2.81923525e-02f, 2.02221163e-02f, -1.23793058e-01f, 6.54661506e-02f, -9.21005905e-02f, 5.03131002e-02f, -5.11265807e-02f,
  7.46042728e-02f, -2.00563967e-01f, -3.94796252e-01f, 2.02256456e-01f, 2.20892206e-01f, -2.27075756e-01f, -4.06942487e-01f, -2.88369954e-01f, 1.49853438e-01f, -1.45022236e-02f,
  1.52939260e-01f, 2.66221970e-01f, -1.02278788e-03f, -2.01238561e-02f, -4.51094627e-01f, -4.72479641e-01f, -3.17392379e-01f, -2.50864387e-01f, -1.19791411e-01f, 7.65102431e-02f,
  1.46456167e-01f, 1.05369180e-01f, 1.09068975e-02f, -4.74769250e-02f, 2.06649393e-01f, 4.60271835e-02f, -1.68613642e-01f, 4.71715331e-02f, -1.03852294e-01f, 3.09628248e-02f,
  -7.14227483e-02f, 3.39889526e-02f, -1.48540512e-01f, 1.12068221e-01f, 1.03101082e-01f, -1.06533088e-01f, -1.05714634e-01f, -1.20694786e-01f, 2.96983998e-02f, -6.40396699e-02f,
  2.01944172e-01f, 6.21989816e-02f, 3.55704501e-02f, 7.81487748e-02f, 2.36308500e-01f, -9.70408767e-02f, -1.48013994e-01f, -1.92146823e-01f, -2.36776918e-01f, -1.10112801e-02f,
  2.33120218e-01f, 1.88796312e-01f, -1.63156822e-01f, -1.62608996e-01f, -1.23754129e-01f, 3.61750349e-02f, -5.65646589e-02f, -3.19430977e-02f, -3.95495176e-01f, -3.54957134e-01f,
  3.67886461e-02f, -1.13833910e-02f, 5.91065437e-02f, -5.17462753e-02f, 1.18592367e-01f, 1.61344334e-01f, -7.46366277e-04f, 5.15849330e-02f, 9.39879715e-02f, 7.95002803e-02f,
  9.69449282e-02f, -7.33729675e-02f, -2.31906958e-02f, -1.27625078e-01f, -1.88881774e-02f, 4.08641808e-02f, 8.20262581e-02f, -9.59097669e-02f, -8.45991820e-02f, 1.79687794e-02f,
  3.71035449e-02f, 7.18828812e-02f, 9.78993028e-02f, -9.46204551e-03f, -1.23465069e-01f, -2.07639396e-01f, -5.61567431e-04f, -5.29069938e-02f, -2.48599555e-02f, -8.76070708e-02f,
  2.71290511e-01f, -4.01093103e-02f, -4.10437658e-02f, -1.50083974e-01f, 1.71485633e-01f, 8.24974850e-02f, 3.52569707e-02f, -9.70079452e-02f, 1.74160048e-01f, -7.71555454e-02f,
  8.93053934e-02f, -9.96118505e-03f, 5.31642027e-02f, 2.10665688e-02f, 5.94716594e-02f, -6.54928535e-02f, -2.19748661e-01f, -8.28426778e-02f, -1.78518787e-01f, 1.47523820e-01f,
  -7.78150335e-02f, -5.02075106e-02f, -1.66083854e-02f, -2.49187216e-01f, -8.81244019e-02f, -1.81517869e-01f, -2.63060302e-01f, -1.29785374e-01f, -3.31464291e-01f, -2.81781644e-01f,
  -3.09691519e-01f, -2.85669208e-01f, -1.53518111e-01f, -3.65942508e-01f, -3.06810439e-01f, -3.33938152e-02f, -2.04531997e-01f, 2.98197325e-02f, -1.97208792e-01f, -2.40659729e-01f,
  5.44813052e-02f, -3.55851017e-02f, -2.65952796e-01f, -5.20319901e-02f, 1.12453274e-01f, -4.04933840e-01f, -4.21698272e-01f, -2.03343213e-01f, 8.08311626e-02f, 1.89095467e-01f,
  -1.47745356e-01f, -2.36265764e-01f, -5.50984927e-02f, 4.45257267e-03f, -3.62060726e-01f, -2.11845219e-01f, -3.76665771e-01f, -9.56251398e-02f, -1.14615068e-01f, -2.74619788e-01f,
  -2.33031988e-01f, -9.81736742e-03f, 1.61644220e-01f, 1.34061545e-01f, -2.82613307e-01f, 5.47007099e-02f, 4.28818818e-03f, -2.98399348e-02f, -1.68595240e-02f, -9.29644406e-02f,
  8.63061771e-02f, 9.50640962e-02f, -1.04898112e-02f, 2.94029396e-02f, -1.07644431e-01f, 5.05340807e-02f, -1.09480351e-01f, -3.39787826e-02f, -5.04141077e-02f, -1.31151788e-02f,
  -1.28300386e-02f, 3.69430482e-02f, -1.07295170e-01f, 7.48927966e-02f, 7.32259378e-02f, 1.88287068e-02f, -2.82836799e-02f, 1.35159150e-01f, 2.64974058e-01f, -3.19250047e-01f,
  -1.83661804e-02f, -7.89229572e-02f, -5.15252464e-02f, 1.26804747e-02f, 5.72224101e-03f, 8.18583090e-03f, 7.30278390e-03f, -4.17311676e-02f, 5.62416390e-02f, 3.06247510e-02f,
  -4.06297147e-02f, 1.42747506e-01f, 4.79887836e-02f, -6.56923428e-02f, -7.62824193e-02f, -3.92210856e-02f, -3.22407857e-02f, -2.22787298e-02f, 7.92021491e-03f, 2.17711814e-02f,
  -7.51158036e-03f, -4.57205549e-02f, -1.13303870e-01f, -3.44570950e-02f, -6.92446232e-02f, 3.95155232e-03f, 9.64730084e-02f, -2.15365272e-02f, -6.05893023e-02f, 3.61095481e-02f,
  -2.25887299e-01f, 9.34905931e-02f, -3.83442253e-01f, 6.32239580e-02f, -6.00659810e-02f, -5.57337189e-03f, -1.69457868e-01f, -3.79993096e-02f, -4.92972061e-02f, -1.58221826e-01f,
  2.17062049e-02f, -9.27078128e-02f, -1.50543660e-01f, 9.00602117e-02f, 1.03208229e-01f, 3.91748585e-02f, 7.66519806e-04f, -2.26840094e-01f, 1.42931432e-01f, 1.12264521e-01f,
  -7.86072984e-02f, 7.76340663e-02f, -7.61450306e-02f, -1.52614815e-02f, 1.72870532e-02f, -1.36462478e-02f, -1.63100615e-01f, 1.83221642e-02f, 1.50559515e-01f, -2.68408328e-01f,
  -5.42353928e-01f, 3.47723775e-02f, 1.93891287e-01f, -2.13190243e-01f, 1.58067375e-01f, 2.03716308e-01f, 1.25675812e-01f, 1.77500839e-03f, -3.50771495e-03f, 7.93820173e-02f,
  2.32391879e-01f, 9.30378065e-02f, 2.56845392e-02f, 3.81436124e-02f, -8.62403214e-02f, 9.06658322e-02f, 1.95917085e-01f, -1.62605867e-01f, -1.80343524e-01f, -1.93153873e-01f,
  9.62434262e-02f, -2.55493999e-01f, -3.45977068e-01f, -2.45481625e-01f, -6.28878623e-02f, -9.67680290e-03f, -5.48782647e-02f, -1.00852646e-01f, 9.62443128e-02f, 1.12443060e-01f,
  -7.36983344e-02f, -9.17188451e-02f, 6.10627681e-02f, -7.05498457e-02f, 1.74737990e-01f, -1.59509033e-01f, -3.57384197e-02f, -4.71033901e-02f, -4.65184115e-02f, -2.97138747e-02f,
  6.87741563e-02f, 1.09258153e-01f, -2.72796452e-02f, -1.56982854e-01f, -2.58120418e-01f, -4.18969765e-02f, -7.45794773e-02f, -8.80380869e-02f, -3.46608497e-02f, -5.05916998e-02f,
  1.94269419e-01f, -2.81860307e-02f, -1.86163381e-01f, 4.28554229e-02f, 6.43987805e-02f, 1.01999976e-02f, -4.71079722e-02f, -1.05374813e-01f, -1.11458935e-01f, -3.04838806e-01f,
  -7.24368542e-02f, -8.51100590e-03f, -4.58640466e-03f, 2.77520418e-02f, 2.65898369e-02f, 1.37155518e-01f, 5.31299300e-02f, 2.13086065e-02f, 2.68268418e-02f, -1.68731883e-01f,
  1.23927228e-01f, 6.03085570e-02f, 5.60100526e-02f, -5.28694578e-02f, 7.28491098e-02f, -7.10161775e-02f, -9.12273526e-02f, -1.47449389e-01f, -1.01547919e-01f, -4.13821600e-02f,
  3.68971750e-02f, -3.43240798e-02f, -6.45874515e-02f, -7.04619242e-03f, -3.89954634e-02f, -1.31298989e-01f, 3.40721831e-02f, -4.06817682e-02f, -5.75490557e-02f, -3.04512270e-02f,
  -2.74597645e-01f, 1.44182667e-01f, -2.30330586e-01f, -5.94142005e-02f, -3.76871787e-02f, 1.55958822e-02f, 6.74438430e-03f, -6.25381544e-02f, 1.71829332e-02f, -4.13484648e-02f,
  -1.94559004e-02f, -6.32230192e-02f, -2.50723884e-02f, 1.27225593e-01f, -1.24516457e-01f, -1.81147717e-02f, -4.52558994e-02f, -9.95379761e-02f, 2.06871480e-02f, -1.78271458e-02f,
  1.05287351e-01f, -2.16953531e-01f, -3.06860507e-01f, -1.50632575e-01f, -2.27424037e-02f, -2.07940936e-01f, -2.56555915e-01f, -9.25611779e-02f, -2.04475030e-01f, -5.28705895e-01f,
  -1.93846494e-01f, -2.57876635e-01f, 1.21315591e-01f, 1.67850748e-01f, 1.84800878e-01f, 2.16681823e-01f, 8.10401589e-02f, 5.50064035e-02f, -1.74775124e-02f, 1.83798894e-02f,
  -4.62533310e-02f, 7.89212156e-03f, 3.60997319e-02f, -9.75951105e-02f, 3.95061970e-02f, 5.71810119e-02f, 2.05660507e-01f, 1.50854111e-01f, 1.70403868e-02f, 5.32463379e-02f,
  9.92226303e-02f, 2.10450329e-02f, -9.32823494e-02f, -1.11094164e-02f, -1.36675179e-01f, 4.21592221e-02f, 4.24810313e-02f, 5.31822406e-02f, -3.41540575e-02f, -1.84509289e-02f,
  8.06681439e-02f, 4.14428450e-02f, 1.39925450e-01f, -4.52399552e-02f, -5.18452227e-02f, -1.50334924e-01f, 4.55532596e-02f, -2.41219141e-02f, -4.96294349e-02f, 5.01674693e-03f,
  3.00681628e-02f, -1.52588904e-01f, 8.98127258e-02f, -6.75527705e-03f, -3.20850648e-02f, 8.52905735e-02f, -5.77022992e-02f, -5.24900556e-02f, 9.87787470e-02f, -2.06314251e-02f,
  -6.82277605e-02f, 2.02644497e-01f, 2.07938224e-01f, 1.24697544e-01f, 2.31025055e-01f, 2.21750259e-01f, 1.43076092e-01f, 1.44581318e-01f, 9.74548757e-02f, 1.16600588e-01f,
  2.06316888e-01f, 7.54310787e-02f, 1.49594575e-01f, 1.35469839e-01f, 5.10360785e-02f, 4.62151766e-02f, -1.99184706e-03f, 5.07399021e-03f, 8.28535855e-02f, 4.84169200e-02f,
  5.60837984e-02f, 1.60852104e-01f, 6.79104105e-02f, 1.78334080e-02f, -8.16316344e-03f, -3.79900187e-02f, 6.88384846e-02f, 3.91288148e-03f, 1.27720147e-01f, 7.44301453e-02f,
  6.32774010e-02f, -3.65170129e-02f, -1.88142717e-01f, 2.63286643e-02f, 3.93343158e-02f, 1.21933289e-01f, 1.27446711e-01f, 3.71212363e-02f, -9.32568610e-02f, -9.35710371e-02f,
  5.07223494e-02f, 2.46496394e-01f, -6.92936480e-02f, -6.92753717e-02f, -1.04253069e-01f, -1.73576966e-01f, 7.36480877e-02f, -1.89708903e-01f, -1.69762135e-01f, 3.17368247e-02f,
  -1.97135750e-02f, -1.37763813e-01f, -1.33140817e-01f, -4.72811610e-02f, -4.88103554e-03f, -3.08269970e-02f, -9.29972231e-02f, 5.84720029e-03f, -8.38623047e-02f, -3.74939963e-02f,
  -1.01396538e-01f, 2.90076062e-02f, 1.37856588e-01f, 1.53618380e-01f, 1.70504987e-01f, 5.10722771e-02f, 9.95338801e-03f, 1.07679173e-01f, 1.54627711e-01f, -2.93536652e-02f,
  5.60595155e-01f, 1.93660930e-01f, 3.07360858e-01f, -6.09628148e-02f, -9.97757539e-02f, 1.40634090e-01f, 2.14817554e-01f, 1.32368296e-01f, -1.15732953e-01f, -5.02811931e-02f,
  -1.35800332e-01f, -1.98107719e-01f, -1.68346390e-01f, -1.20514840e-01f, 1.76875368e-01f, -1.08733056e-02f, -9.62807983e-02f, 1.77016914e-01f, 6.49296567e-02f, 4.75177206e-02f,
  -1.06497966e-01f, 1.05434485e-01f, 2.44629070e-01f, 1.16234533e-01f, -2.80578695e-02f, -1.48849726e-01f, -2.71955486e-02f, 9.14448872e-02f, 8.19807202e-02f, -1.43286124e-01f,
  3.38303931e-02f, 2.96416342e-01f, -3.05286765e-01f, -5.11094071e-02f, 7.70699158e-02f, -3.94396633e-02f, -7.02060983e-02f, -5.53161278e-02f, -1.23583421e-01f, -7.90437385e-02f,
  -4.40244004e-03f, 6.40107170e-02f, 4.04957682e-02f, -4.75387909e-02f, 9.89637747e-02f, -8.77300501e-02f, 1.51984217e-02f, 4.30698581e-02f, 6.20108955e-02f, 1.17286943e-01f,
  -1.82873368e-01f, -7.66685754e-02f, 1.22192390e-01f, -2.48349383e-02f, 5.09074442e-02f, -1.82630911e-01f, 1.18902512e-01f, -2.61899293e-03f, 1.13151319e-01f, 9.67912078e-02f,
  -1.85688123e-01f, 1.26973867e-01f, 2.39587203e-02f, -2.07954738e-02f, -7.36985281e-02f, -7.98628405e-02f, 1.11153638e-02f, 1.03316687e-01f, 5.17704003e-02f, 6.14667647e-02f,
  -9.05878246e-02f, -5.85158495e-03f, 4.72379625e-02f, -7.85096809e-02f, -1.75417215e-01f, -3.01913116e-02f, -9.09998640e-02f, -1.27437264e-01f, 6.76450133e-02f, 3.06950435e-02f,
  5.10160811e-02f, -4.62763943e-02f, -3.44296098e-02f, 1.12964600e-01f, -9.67919156e-02f, -1.54491598e-02f, -7.93211684e-02f, -6.62846118e-02f, -1.12380929e-01f, -7.59821311e-02f,
  -2.32859448e-01f, 7.00325221e-02f, -3.95336524e-02f, 3.15068029e-02f, 3.12289931e-02f, 5.32268807e-02f, -8.24181885e-02f, -5.48757352e-02f, 4.14180718e-02f, -8.60220119e-02f,
  2.89441943e-02f, -1.16920277e-01f, 7.65718594e-02f, -2.25532521e-02f, -5.14039695e-02f, -1.40296295e-01f, -5.40122464e-02f, -3.60685885e-02f, -2.40997300e-02f, -7.56233409e-02f,
  -8.34131017e-02f, -6.77810162e-02f, -2.08622649e-01f, -2.39970356e-01f, -1.44829750e-01f, -3.33754957e-01f, -1.83933992e-02f, -1.29777819e-01f, -5.75738735e-02f, -1.41089991e-01f,
  -2.95765787e-01f, 1.81747869e-01f, -9.71180871e-02f, -5.29372096e-01f, -3.40890139e-01f, -3.15334275e-02f, 2.02899128e-01f, -3.97888385e-02f, -2.44339317e-01f, 1.02865450e-01f,
  1.57020718e-01f, -7.01742545e-02f, 2.62755863e-02f, 4.93949875e-02f, 2.12594628e-01f, 1.66335523e-01f, -1.66989341e-01f, -7.60700628e-02f, -2.25034192e-01f, -2.16808870e-01f,
  -6.81008771e-02f, -1.56500265e-01f, -2.18615934e-01f, -2.30857864e-01f, -3.77914608e-01f, -2.52234310e-01f, -1.79800868e-01f, -1.33368567e-01f, 6.33240268e-02f, -1.64811552e-01f,
  1.81655198e-01f, -1.77866399e-01f, 4.36649472e-02f, -1.37704266e-02f, -1.47165611e-01f, 1.49566634e-02f, 1.27662579e-02f, -2.03264594e-01f, -1.89694092e-01f, -4.32527997e-02f,
  -1.52875975e-01f, 7.97623694e-02f, -1.18176647e-01f, -1.39009118e-01f, -1.72962233e-01f, -1.18016645e-01f, -2.10608125e-01f, -1.08112894e-01f, 3.80592644e-02f, 3.42571996e-02f,
  7.82233998e-02f, 7.79523924e-02f, 1.20256260e-01f, 2.11569205e-01f, 1.76676083e-02f, -1.75004546e-02f, 1.98354512e-01f, -2.36511342e-02f, 4.36507612e-02f, -1.91617920e-03f,
  5.59979044e-02f, 8.45420882e-02f, -1.84673071e-02f, -6.19770475e-02f, -2.31171437e-02f, 6.07055761e-02f, -1.13355488e-01f, 1.24098703e-01f, 2.05481146e-02f, -7.69419000e-02f,
  -6.56473935e-02f, 1.55604556e-01f, 7.01526478e-02f, -7.75325671e-02f, -1.99146811e-02f, 3.94103862e-02f, 1.44365340e-01f, 1.33458033e-01f, 7.67955333e-02f, -2.20864080e-02f,
  5.73462434e-02f, 1.26679480e-01f, -1.09383855e-02f, 1.72572151e-01f, 2.04211175e-01f, 1.18037105e-01f, 1.49398714e-01f, 1.23452559e-01f, 1.12697616e-01f, 7.83627778e-02f,
  -4.35078330e-02f, 1.69758335e-01f, 1.07235119e-01f, -6.76190108e-02f, -1.95377216e-01f, -1.24813952e-02f, -7.15990588e-02f, 1.61081105e-02f, -1.25233546e-01f, -1.91045143e-02f,
  -2.68131047e-02f, 2.18408071e-02f, 8.22901651e-02f, -4.78045307e-02f, -5.69733903e-02f, -1.57662347e-01f, 1.25486627e-01f, -5.61304353e-02f, 2.55526751e-01f, 4.50129323e-02f,
  1.41699776e-01f, 1.39882118e-01f, 5.74995317e-02f, 6.86016381e-02f, 4.88581024e-02f, 1.91048443e-01f, 2.87096739e-01f, 2.37698168e-01f, 2.27529645e-01f, 2.06771642e-01f,
  5.16254306e-01f, 2.64445841e-01f, 9.26904902e-02f, 2.13186219e-01f, 1.34195060e-01f, -1.81888836e-03f, -3.83339189e-02f, -6.01593703e-02f, 7.28362277e-02f, 6.30558506e-02f,
  7.10862204e-02f, -2.04515345e-02f, 3.51481475e-02f, 4.75532375e-02f, 1.12765254e-02f, -2.04104558e-02f, 1.24845706e-01f, 7.14352280e-02f, -4.85747941e-02f, -3.32443193e-02f,
  7.70434737e-02f, 7.05789551e-02f, 9.11097378e-02f, 1.00229934e-01f, 2.24546835e-01f, 1.13383569e-01f, 1.02426633e-01f, 1.39447287e-01f, 4.19845358e-02f, 2.06072524e-01f,
  -4.41852063e-02f, 2.75123417e-01f, -1.50346220e-01f, 4.90141921e-02f, 1.64822175e-03f, -3.33991647e-02f, -9.71074700e-02f, -1.31334990e-01f, -7.88642559e-03f, -5.62745035e-02f,
  8.80755782e-02f, -9.03244317e-02f, 9.00343806e-02f, -9.18757468e-02f, -3.28206904e-02f, -1.24291807e-01f, -1.21799149e-01f, -1.33626401e-01f, -6.90547451e-02f, -1.05416790e-01f,
  5.37543669e-02f, -7.19911829e-02f, -1.32251799e-01f, -2.31757075e-01f, -1.73455715e-01f, -2.48862147e-01f, -6.85649291e-02f, -4.73534763e-02f, -2.36079305e-01f, -1.94545239e-01f,
  -4.56021845e-01f, -1.81670919e-01f, -1.01718202e-01f, -8.37464631e-02f, -1.63459957e-01f, -5.29363565e-02f, -9.93334800e-02f, -1.70212552e-01f, -1.07743047e-01f, -7.14405403e-02f,
  -1.00366585e-01f, -1.20858647e-01f, -4.59398292e-02f, -2.03551114e-01f, -1.68406084e-01f, -8.70604217e-02f, -8.20221305e-02f, -1.38421655e-01f, -1.65045813e-01f, 2.10503563e-02f,
  5.51431254e-02f, -1.34013250e-01f, -1.36210367e-01f, -1.03870124e-01f, -1.66101158e-01f, -2.53600061e-01f, -2.13591769e-01f, -1.00693457e-01f, -3.72622684e-02f, -2.42301710e-02f,
  -8.27534050e-02f, -2.03390755e-02f, -1.95714273e-02f, 2.74533898e-01f, 2.79518187e-01f, 1.80375710e-01f, 1.51383713e-01f, 5.46443202e-02f, 3.65516767e-02f, -9.89988223e-02f,
  3.78047302e-02f, 4.74579893e-02f, 2.57516559e-02f, 9.13290456e-02f, -6.80582449e-02f, -2.62334831e-02f, 1.31136313e-01f, 1.32411510e-01f, -5.25690503e-02f, 4.84283939e-02f,
  2.52401270e-02f, -2.58597553e-01f, -2.14456499e-01f, -1.35177851e-01f, -1.12811431e-01f, -2.44471714e-01f, -2.07199767e-01f, -1.52372614e-01f, -3.14454943e-01f, -2.69634306e-01f,
  -3.77682805e-01f, 3.83540034e-01f, 2.81591475e-01f, -1.60671026e-01f, 2.45353565e-01f, 1.98372766e-01f, 2.95749307e-01f, 4.71230410e-02f, -1.20406494e-01f, 3.08361679e-01f,
  2.72075027e-01f, -1.14488550e-01f, 9.67216119e-02f, -8.44050944e-02f, -2.32599258e-01f, 2.45027691e-01f, 1.96613804e-01f, -1.48133874e-01f, -4.64963049e-01f, -3.99046659e-01f,
  -1.03366591e-01f, -1.72382653e-01f, -2.86093563e-01f, -1.92125484e-01f, 3.86639088e-02f, -1.78208545e-01f, 1.37583196e-01f, -1.01060420e-01f, 1.40018659e-02f, 8.93375836e-03f,
  -1.20037407e-01f, 1.54649496e-01f, -9.41886157e-02f, -2.08939239e-01f, 1.06896311e-01f, -2.12366015e-01f, -9.93377436e-03f, 4.33857068e-02f, 4.77557303e-04f, 7.24248663e-02f,
  2.89416045e-01f, 9.85337645e-02f, 1.18324719e-01f, -1.60565272e-01f, -1.64234772e-01f, -7.35538527e-02f, -6.42263796e-04f, -2.28269920e-01f, -1.65224433e-01f, -1.46577731e-01f,
  1.69929843e-02f, 1.41607625e-02f, 8.05188194e-02f, -2.00242121e-02f, -6.11870773e-02f, -8.59244466e-02f, 1.55052301e-02f, -2.12278739e-01f, -4.00805622e-02f, -3.12048316e-01f,
  8.00155699e-02f, 1.97273660e-02f, 1.17125213e-01f, 4.10267711e-02f, -3.86887826e-02f, 8.90691802e-02f, 8.00790563e-02f, 6.58840835e-02f, -1.34130374e-01f, -1.44587889e-01f,
  9.77518409e-02f, 8.80391628e-04f, 3.20319533e-02f, 1.68403581e-01f, 9.23574250e-03f, 8.18672404e-02f, -3.92763615e-02f, -1.24960840e-01f, 2.32007932e-02f, -1.45024627e-01f,
  -4.90471348e-02f, 6.02918044e-02f, 1.31494597e-01f, -1.14024326e-01f, 1.97453648e-01f, -6.66221678e-02f, 2.16855630e-02f, -1.17983557e-01f, -2.93256510e-02f, 1.22669667e-01f,
  -2.35819623e-01f, 6.40490651e-02f, 2.16075778e-02f, -9.73515362e-02f, 1.59212753e-01f, -8.72025639e-02f, 1.47753641e-01f, 1.17775686e-01f, 7.95154944e-02f, -4.88476865e-02f,
  3.93239409e-03f, 1.42456278e-01f, 1.37903482e-01f, -5.28424904e-02f, -1.51098594e-01f, 5.42521477e-02f, -7.90576916e-03f, 1.49468044e-02f, -1.50450662e-01f, -8.36350247e-02f,
  -4.28863727e-02f, -3.00278604e-01f, -2.57417560e-01f, -6.47094771e-02f, -9.86041725e-02f, -2.16873273e-01f, -2.11426288e-01f, -3.06061745e-01f, -1.83137968e-01f, -3.19550544e-01f,
  9.01886374e-02f, -3.61058027e-01f, 1.31291756e-02f, 2.65106320e-01f, 5.53095341e-03f, -4.09185201e-01f, -6.31217778e-01f, -3.75043273e-01f, 1.22262128e-01f, -1.52063370e-01f,
  -4.26238775e-02f, 5.51556014e-02f, 2.61898655e-02f, 7.26114511e-02f, -2.24404126e-01f, -1.19787417e-01f, 1.18841149e-01f, 6.94975257e-02f, -1.47600725e-01f, -1.85483679e-01f,
  2.40438953e-02f, 1.58356324e-01f, 2.55563945e-01f, -4.26229574e-02f, 1.70241952e-01f, -5.26222549e-02f, 1.11293964e-01f, 2.22537220e-01f, 4.49221879e-02f, 1.08729742e-01f,
  1.29560590e-01f, -7.12643936e-02f, -1.81748614e-01f, 9.43494812e-02f, 7.83216581e-02f, -2.86813855e-01f, -3.71214032e-01f, 1.15077525e-01f, -8.78440514e-02f, -7.07463771e-02f,
  -2.47584935e-02f, -2.00976640e-01f, 1.07829101e-01f, -3.13393064e-02f, -1.56087682e-01f, -3.81596506e-01f, -7.80802667e-02f, -1.55338243e-01f, -1.66784167e-01f, -2.05434442e-01f,
  -6.31353445e-03f, -1.50513619e-01f, -4.91850413e-02f, -2.04391837e-01f, -7.87158608e-02f, 1.40464276e-01f, -4.21663225e-02f, -2.98664328e-02f, -9.96613503e-02f, -1.23231940e-01f,
  5.14793135e-02f, 1.86653078e-01f, -7.29990900e-02f, 3.82943917e-03f, -2.59735674e-01f, 6.25131428e-02f, -3.87486853e-02f, -8.34965557e-02f, -2.10144334e-02f, 1.57580990e-02f,
  2.90503097e-03f, 6.89003766e-02f, 9.00111869e-02f, -1.23232892e-02f, 1.04089662e-01f, 4.76184301e-02f, -5.10198399e-02f, -1.03167901e-02f, 1.13657534e-01f, 2.69635655e-02f,
  -4.01077084e-02f, -3.09512746e-02f, 3.50989252e-02f, -2.72619817e-02f, -4.02485281e-02f, 2.84770764e-02f, -6.35984987e-02f, -4.05074693e-02f, 6.88998029e-02f, 1.01758696e-01f,
  5.68879722e-03f, 1.40453205e-01f, -1.16793051e-01f, -1.14356935e-01f, -9.95076299e-02f, -1.06694758e-01f, -1.05912492e-01f, -1.04685538e-01f, -2.05656197e-02f, -2.33727574e-01f,
  -3.56745124e-01f, -1.21631615e-01f, 3.13700646e-01f, 1.04991816e-01f, -8.44550878e-02f, 2.61877235e-02f, -1.17964722e-01f, -7.99570978e-02f, -5.05438354e-03f, -3.95395085e-02f,
  4.49699908e-02f, -1.27450943e-01f, -1.06577493e-01f, -1.34045959e-01f, -1.60880536e-02f, -8.75375941e-02f, -2.61186790e-02f, -1.63322285e-01f, -2.20437601e-01f, -3.00410002e-01f,
  -6.59040809e-01f, -3.18824917e-01f, 1.34518206e-01f, -6.07422650e-01f, -5.00128269e-02f, 1.38867676e-01f, -4.02998105e-02f, -1.27626762e-01f, -3.50382268e-01f, -1.45666376e-01f,
  -7.77920485e-02f, -2.98105091e-01f, -2.69248486e-01f, 3.64122242e-02f, 1.04187980e-01f, -1.33464620e-01f, -1.34191766e-01f, -1.87002029e-02f, 1.75867990e-01f, 1.83052778e-01f,
  1.21907219e-01f, -1.22328147e-01f, -9.74158943e-02f, -2.41889674e-02f, -3.52075964e-01f, -1.83567286e-01f, 2.60918662e-02f, -5.44630401e-02f, 9.30284057e-03f, -2.76900619e-01f,
  -1.29429922e-01f, -1.59249008e-01f, 2.42330000e-01f, 7.38974148e-03f, 1.91034693e-02f, -7.37642869e-02f, -8.06280747e-02f, -3.60241719e-02f, -1.40042111e-01f, -1.42833563e-02f,
  -3.36605348e-02f, -2.54865624e-02f, -1.67644083e-01f, 3.01488433e-02f, -1.34025171e-01f, 2.29122657e-02f, 6.49421588e-02f, 1.31120786e-01f, 8.35688189e-02f, -3.24483402e-02f,
  7.25482553e-02f, -1.10745020e-01f, -8.03717878e-03f, 1.53163224e-01f, 7.18836263e-02f, 2.28420645e-02f, 1.91039577e-01f, 1.51095554e-01f, 1.85042948e-01f, -1.68386281e-01f,
  7.35917538e-02f, 1.23731621e-01f, 1.26236916e-01f, -1.27840806e-02f, 1.25177102e-02f, -3.25759016e-02f, -1.13527067e-02f, -2.31725164e-02f, 1.03604294e-01f, 6.39976608e-03f,
  -3.45211104e-02f, 1.23174191e-01f, 7.66134635e-02f, -1.18456949e-02f, -3.31007279e-02f, 5.21302689e-03f, -9.19940323e-02f, -1.97492409e-02f, 1.34584242e-02f, -5.25628366e-02f,
  1.18073575e-01f, 6.16353042e-02f, -3.08587272e-02f, -6.16470492e-03f, 1.07096173e-01f, 8.25011507e-02f, 1.22618906e-01f, 1.76574841e-01f, 5.59284836e-02f, 1.70074061e-01f,
  -3.70770782e-01f, 2.11341441e-01f, -3.88311654e-01f, 9.29767918e-03f, -1.46278813e-01f, 1.05746277e-01f, -1.43535018e-01f, 6.99530775e-03f, -2.36985251e-01f, -1.00628637e-01f,
  1.26859188e-01f, -1.36138305e-01f, -1.66101009e-01f, 8.32850039e-02f, 4.89299605e-03f, -5.01711220e-02f, 5.16357226e-03f, -9.71070677e-02f, 1.10740185e-01f, -2.80326069e-03f,
  3.81812416e-02f, -1.38709784e-01f, -2.17616886e-01f, -1.83778122e-01f, -1.35129213e-01f, -1.08804040e-01f, -4.98289950e-02f, -1.34671941e-01f, -9.55352336e-02f, -2.81982690e-01f,
  -5.51266134e-01f, -3.23883206e-01f, -4.15484488e-01f, -2.71982163e-01f, 1.45805821e-01f, 1.86363280e-01f, 2.61529624e-01f, 1.62004992e-01f, 3.71070653e-02f, -1.73598155e-01f,
  -5.26410379e-02f, 3.02350540e-02f, -5.15334383e-02f, 9.13341567e-02f, 1.14119910e-01f, 1.33863136e-01f, 1.58303022e-01f, 8.85801464e-02f, 3.12239558e-01f, 3.09057027e-01f,
  2.77192354e-01f, 2.83020753e-02f, -5.52846119e-02f, 1.80941999e-01f, 1.17407022e-02f, 1.25452913e-02f, -1.22377977e-01f, -9.28204879e-02f, -5.01818620e-02f, -2.04257429e-01f,
  -4.94053930e-01f, -2.60989994e-01f, 2.76876539e-01f, -1.02056280e-01f, -9.24374685e-02f, -1.24855349e-02f, 8.67239982e-02f, -1.10802859e-01f, 1.23182898e-02f, -5.31421825e-02f,
  -3.80337350e-02f, 3.35161015e-02f, -4.12763804e-02f, -5.69421910e-02f, -8.33833143e-02f, 6.78365603e-02f, 8.71543884e-02f, -6.98617399e-02f, -1.62263066e-02f, -9.04704034e-02f,
  1.92173541e-01f, -4.34895642e-02f, -3.90069962e-01f, 7.53104612e-02f, -3.71561535e-02f, -4.75762971e-02f, -5.56134097e-02f, 2.67048143e-02f, -1.33664101e-01f, -3.74277353e-01f,
  -2.60775797e-02f, -4.12284322e-02f, -5.15177511e-02f, 4.91414294e-02f, 3.76160033e-02f, -1.65768545e-02f, -3.98016758e-02f, 2.68029422e-02f, -3.01979799e-02f, -1.29446043e-02f,
  -3.36697400e-02f, -1.21965691e-01f, -4.10655476e-02f, -8.67279395e-02f, 4.04671393e-02f, 7.31113076e-04f, 1.44293215e-02f, 1.15141742e-01f, 5.13715334e-02f, -6.61865156e-03f,
  -2.02669069e-01f, -5.15368134e-02f, -1.76344320e-01f, 7.37697780e-02f, 1.92323439e-02f, 8.87266826e-03f, 4.03640196e-02f, 2.31870692e-02f, 3.58519368e-02f, -1.01345658e-01f,
  -3.13629776e-01f, 1.26924917e-01f, -2.33371422e-01f, -1.24758542e-01f, 2.79725492e-02f, -3.52917276e-02f, 1.07251303e-02f, 4.39771684e-03f, -2.59167194e-01f, 2.03399081e-02f,
  9.88422800e-03f, -2.79358588e-02f, -1.26617804e-01f, -5.02217971e-02f, 1.50405049e-01f, -9.44395922e-03f, -1.70048196e-02f, 2.05414817e-02f, 1.04708403e-01f, 7.96121359e-02f,
  -1.06634550e-01f, 3.04050669e-02f, -3.07368696e-01f, -4.78912771e-05f, -6.69042096e-02f, -3.69935147e-02f, -1.14048153e-01f, -1.42572641e-01f, -1.80404797e-01f, -2.09448338e-01f,
  4.44388509e-01f, 1.91219553e-01f, 3.61011922e-02f, 1.47302598e-01f, -8.73213708e-02f, -2.55313396e-01f, -3.86261821e-01f, -1.65331289e-01f, 5.42452559e-02f, 6.97779134e-02f,
  1.57911390e-01f, 2.37639427e-01f, 1.77847698e-01f, 1.66700691e-01f, 3.65928784e-02f, -6.93562850e-02f, -1.87057391e-01f, 9.34438258e-02f, 3.15865092e-02f, 8.50970149e-02f,
  -1.35854064e-02f, 1.36551797e-01f, 1.46225780e-01f, 1.40392020e-01f, 9.23697501e-02f, 9.61280763e-02f, 5.24508208e-02f, -6.15226896e-03f, -8.33301470e-02f, 2.08216816e-01f,
  3.93898487e-01f, 2.50023425e-01f, 7.86364228e-02f, 1.01208575e-01f, 1.36998832e-01f, 1.55365661e-01f, 3.11856642e-02f, 2.25365572e-02f, 8.59224424e-03f, -2.66158059e-02f,
  1.01866131e-03f, 5.32613844e-02f, -5.17095588e-02f, 1.94772575e-02f, -6.72660396e-02f, 1.25116989e-01f, 4.41441312e-02f, -9.28611774e-03f, -1.68707922e-01f, 2.00487003e-02f,
  2.20438410e-02f, -4.62404788e-02f, -5.36003299e-02f, -1.78142175e-01f, -1.33036003e-01f, 1.07090719e-01f, -3.81255299e-02f, 6.99340105e-02f, 4.26365547e-02f, 1.33745093e-02f,
  2.23515201e-02f, -2.51825731e-02f, 1.16695557e-02f, -7.62020051e-02f, -5.74506931e-02f, -1.25623803e-04f, -1.21211201e-01f, -2.00369492e-01f, -1.04098111e-01f, -1.08495422e-01f,
  -5.43811508e-02f, -1.67473853e-02f, -2.05338262e-02f, 1.37652941e-02f, 1.71332002e-01f, -3.79984640e-02f, -9.25059095e-02f, 8.65529999e-02f, -6.76400438e-02f, -1.43147230e-01f,
  -1.02824487e-01f, -1.53840333e-01f, 1.20887920e-01f, 2.94370838e-02f, 6.46564662e-02f, 6.40273765e-02f, -8.37770943e-03f, -3.42131732e-03f, 1.50222816e-02f, -1.08292975e-01f,
  2.51872949e-02f, -7.87905231e-03f, 9.40423310e-02f, -8.67590457e-02f, -5.50902542e-03f, 1.12281546e-01f, 1.17057890e-01f, 9.25351083e-02f, 7.12768582e-04f, -8.20030794e-02f,
  -4.41765226e-02f, 1.35315314e-01f, -3.89956273e-02f, -1.54136568e-01f, 6.81033870e-03f, 2.78857555e-02f, 1.64655223e-02f, 3.29127759e-02f, -2.05197372e-02f, -2.65342034e-02f,
  -8.99722576e-02f, -1.79478433e-02f, -1.53484613e-01f, -7.20842928e-03f, -9.38627794e-02f, -3.66838239e-02f, -3.57165793e-03f, 2.68256869e-02f, 1.30033819e-02f, -8.20666403e-02f,
  2.46791467e-01f, 2.37870961e-01f, 3.12314838e-01f, 8.19481611e-02f, 8.71411264e-02f, 2.58785099e-01f, 4.76330876e-01f, 2.26527244e-01f, -1.58565849e-01f, 1.15757987e-01f,
  -1.20272540e-01f, -3.61351430e-01f, -2.54783332e-01f, -1.65788904e-01f, 1.60346538e-01f, 7.35675693e-02f, -2.93238182e-03f, 3.34419683e-02f, 1.10878803e-01f, 8.76763687e-02f,
  -4.05834913e-02f, 3.25496122e-02f, 2.14758396e-01f, 8.74699131e-02f, -6.32065535e-02f, -2.66835719e-01f, 1.46059558e-01f, 1.38232201e-01f, 4.09475714e-02f, -1.87198341e-01f,
  6.27126098e-02f, 3.05741042e-01f, -3.22036654e-01f, -2.61061072e-01f, 9.87197012e-02f, -1.41349472e-02f, 2.05034763e-02f, -2.96447743e-02f, -4.74326909e-02f, 6.75486997e-02f,
  5.28909713e-02f, 1.96024403e-02f, 9.99464542e-02f, 1.12455286e-01f, 2.15745270e-01f, 7.81590641e-02f, 6.40371963e-02f, 2.03523207e-02f, 7.10038096e-02f, 6.04017684e-03f,
  -1.40162870e-01f, -1.79469697e-02f, 1.16786212e-01f, 9.75949988e-02f, 3.45597304e-02f, -8.05929527e-02f, 6.31245673e-02f, -3.60237993e-03f, 3.41411456e-02f, 6.59456104e-02f,
  -6.66188821e-02f, 1.02386184e-01f, 1.09461322e-02f, 4.15804386e-02f, 8.28756317e-02f, 1.08544752e-01f, -7.50813354e-03f, 5.20627759e-02f, 1.32547423e-01f, 1.44922271e-01f,
  1.11718588e-01f, 1.17711835e-01f, 1.07924446e-01f, 8.70351717e-02f, -5.99878728e-02f, -5.91555126e-02f, 1.54682130e-01f, 4.91513722e-02f, 8.03353041e-02f, 7.22756088e-02f,
  1.43106222e-01f, 1.53755516e-01f, 7.13737905e-02f, 9.91361961e-02f, -4.87194508e-02f, 7.76050240e-02f, 6.49887472e-02f, -4.40717563e-02f, -2.47516781e-02f, 6.96726292e-02f,
  -1.47053242e-01f, 1.25775570e-02f, -1.72434926e-01f, -1.37145460e-01f, -1.00661125e-02f, -1.17877446e-01f, -5.59275635e-02f, -1.49500474e-01f, -1.93066485e-02f, -6.52610138e-03f,
  2.11268403e-02f, -5.08967526e-02f, 7.74916634e-02f, 9.14120302e-02f, 6.27781227e-02f, -1.09922305e-01f, -1.39398649e-01f, -7.35872835e-02f, -1.01169676e-01f, -1.19302049e-01f,
  -1.09339260e-01f, 3.35388184e-02f, 3.07041928e-02f, -1.42255291e-01f, -1.14961863e-01f, -2.62572080e-01f, -3.76071371e-02f, -2.07095072e-02f, 1.57140661e-02f, -3.34776752e-02f,
  -4.78984207e-01f, 1.10173775e-02f, 3.07422578e-01f, -3.14540356e-01f, 2.01547012e-01f, 1.70598522e-01f, 4.14928585e-01f, 7.84986690e-02f, -1.58291712e-01f, 1.23899207e-02f,
  1.69113591e-01f, -1.33549467e-01f, 3.69468294e-02f, 3.38452533e-02f, 1.22181384e-03f, 2.31188744e-01f, 2.48473987e-01f, 7.14291558e-02f, 3.93398479e-02f, -5.24670333e-02f,
  -5.97648323e-03f, -1.70329809e-01f, -2.69074887e-01f, -5.37176318e-02f, -1.44429639e-01f, -9.57516506e-02f, 3.28114927e-02f, -3.96977365e-02f, 1.93942279e-01f, -6.05127141e-02f,
  -3.36837292e-01f, -1.99975088e-01f, 1.23275548e-01f, -3.36337686e-02f, 1.13678224e-01f, -1.99807972e-01f, 2.32408531e-02f, -5.19229658e-02f, 5.46384528e-02f, 1.18244141e-02f,
  -6.49802759e-02f, -1.28628151e-03f, -3.40905935e-02f, -1.25858456e-01f, -2.82660037e-01f, 1.74450427e-02f, 1.63206793e-02f, 1.82235241e-02f, -3.97173688e-02f, -1.49784327e-01f,
  2.11663321e-01f, -9.73156095e-02f, -1.25878319e-01f, 5.84907569e-02f, -4.68340367e-02f, -6.94466308e-02f, -1.53508618e-01f, -1.11415707e-01f, 5.35682254e-02f, -3.22292328e-01f,
  -4.39957306e-02f, 2.30601374e-02f, 6.00023158e-02f, 6.84602261e-02f, 1.21024000e-02f, 4.49232683e-02f, -7.28838518e-03f, 1.45693431e-02f, 3.17205414e-02f, -1.25427395e-01f,
  -5.55008538e-02f, 2.91952724e-03f, -2.92971022e-02f, 2.94665131e-03f, -5.70473708e-02f, 3.61332037e-02f, 8.78390819e-02f, 1.95445597e-01f, -8.68739262e-02f, 3.44361030e-02f,
  -1.63274273e-01f, 4.97973077e-02f, -2.10071877e-02f, -1.19639382e-01f, 1.06987275e-01f, 1.23529278e-01f, -1.47360116e-01f, -6.14627339e-02f, 4.19908464e-02f, -6.23862632e-02f,
  -3.38342726e-01f, 1.61004245e-01f, -2.90488482e-01f, 1.19764097e-02f, -2.58458164e-02f, 5.00114635e-02f, 2.45178565e-02f, 8.61843303e-02f, -5.96495792e-02f, -9.91732776e-02f,
  5.65151162e-02f, 2.24961843e-02f, -1.39785618e-01f, 1.93541578e-03f, -1.82005659e-01f, -1.20682746e-01f, -6.93209469e-03f, -4.64911386e-02f, -1.18511124e-02f, -1.56806931e-02f,
  3.98096964e-02f, -1.48733661e-01f, -3.42998028e-01f, -1.08120263e-01f, -2.16288343e-01f, -1.79659963e-01f, -8.05662200e-02f, -1.47195205e-01f, 8.18066858e-03f, -2.55584776e-01f,
  8.46939608e-02f, -2.13461250e-01f, -6.34905696e-01f, 2.79443413e-01f, 1.61576152e-01f, -1.07605696e-01f, -2.53428370e-01f, -4.03838083e-02f, 2.38863155e-01f, -1.26606241e-01f,
  -5.12000313e-03f, 2.62134641e-01f, 3.17531899e-02f, 7.43926875e-03f, -1.94449291e-01f, -3.82000923e-01f, -3.17157477e-01f, -2.73028135e-01f, -3.37590501e-02f, 2.27047771e-01f,
  4.29816455e-01f, 3.26696366e-01f, 1.01243168e-01f, 1.25048399e-01f, 1.89859286e-01f, 1.07183665e-01f, -7.29224011e-02f, 1.13310188e-01f, -9.10577700e-02f, -2.09760711e-01f,
  -1.35153934e-01f, -1.30849361e-01f, -1.09641448e-01f, 1.96873367e-01f, 6.13221526e-03f, 3.64920520e-03f, -3.43308300e-02f, -3.34738120e-02f, -2.62609944e-02f, -7.31250122e-02f,
  -1.02683842e-01f, 4.24181744e-02f, 2.50233375e-02f, 4.74133193e-02f, 1.67244717e-01f, 2.94270776e-02f, -1.68035418e-01f, -1.82270527e-01f, -3.44604075e-01f, -4.18581627e-02f,
  1.08302027e-01f, -1.89751089e-02f, -2.11232021e-01f, -1.43880650e-01f, -2.09993348e-01f, -4.07873131e-02f, -1.71345845e-01f, -1.09159850e-01f, -3.15326780e-01f, -1.54779449e-01f,
  -8.13711658e-02f, 1.78485308e-02f, -5.41928448e-02f, -3.82481841e-04f, 8.23437721e-02f, -1.18283041e-01f, -1.18470140e-01f, 1.44728124e-01f, -7.71898823e-03f, -1.13465153e-01f,
  -7.56832631e-03f, 2.40347625e-04f, -9.58907455e-02f, -1.92139298e-01f, -1.93065777e-02f, -5.01961820e-02f, -6.10049209e-03f, -2.91866213e-02f, -5.39515982e-04f, 3.25990580e-02f,
  8.56116191e-02f, 7.82586262e-02f, 1.18155286e-01f, -2.68654320e-02f, -4.96912040e-02f, -2.46537343e-01f, 7.42174825e-03f, 1.29917637e-01f, -3.99986394e-02f, 5.94847575e-02f,
  3.62040460e-01f, -9.23711881e-02f, -7.92369545e-02f, -2.59377155e-02f, -6.09723851e-02f, 6.22866265e-02f, -2.94283056e-03f, -2.63521783e-02f, 2.63038976e-03f, -2.68343631e-02f,
  1.45275611e-02f, -1.82834435e-02f, -1.34408311e-03f, -1.10847047e-02f, 1.29109383e-01f, 6.98235407e-02f, 1.26783013e-01f, -5.08225821e-02f, -6.08092472e-02f, 1.20782144e-01f,
  -4.23520096e-02f, -1.26093730e-01f, -3.43444385e-03f, -8.66130814e-02f, 2.65386030e-02f, 6.93751732e-03f, -1.00183643e-01f, -1.92740902e-01f, -2.08082482e-01f, -6.71586469e-02f,
  6.68147504e-01f, -2.94823378e-01f, -2.65828788e-01f, 5.22560813e-02f, -1.27994880e-01f, -4.17151768e-03f, -2.13562265e-01f, -5.41021004e-02f, 7.98222944e-02f, -2.02552870e-01f,
  1.06095314e-01f, 4.03556526e-01f, 3.15703779e-01f, 2.67427981e-01f, 2.15438738e-01f, -4.11919504e-01f, -3.84708107e-01f, 1.36744589e-01f, 3.26910675e-01f, 2.28406698e-01f,
  4.99562062e-02f, -2.22192481e-02f, 5.61978109e-02f, 1.79890252e-04f, -2.85839736e-01f, 3.72396410e-02f, -4.78867590e-01f, -2.88898915e-01f, -1.35356650e-01f, -4.20199752e-01f,
  1.64752770e-02f, 8.49773586e-02f, 1.72361746e-01f, 1.63149029e-01f, -1.99516863e-01f, -2.54367273e-02f, -2.04046397e-03f, -1.25762776e-01f, 5.62591963e-02f, -2.23083586e-01f,
  -3.71122397e-02f, -3.88297960e-02f, 3.73091362e-02f, -4.09902148e-02f, -4.85093845e-03f, 1.26918452e-02f, -1.37321159e-01f, -7.28526413e-02f, -1.65674672e-01f, 4.24201600e-02f,
  -2.98930742e-02f, 1.18722595e-01f, 4.04723696e-02f, -1.20846696e-01f, -6.75797313e-02f, 9.20800567e-02f, -1.70851901e-01f, 1.17193107e-02f, 9.42423791e-02f, -3.38559210e-01f,
  -2.19529811e-02f, -3.21544781e-02f, -6.24997690e-02f, -1.09583624e-01f, -2.74180807e-02f, 3.77002805e-02f, 8.85035247e-02f, 3.67891043e-02f, 3.82539108e-02f, -1.20327011e-01f,
  1.68802440e-01f, 7.37928897e-02f, 4.82021533e-02f, 3.94949876e-02f, 4.49807569e-02f, -8.53159232e-04f, -8.78534168e-02f, -6.80191368e-02f, -1.16639361e-02f, -1.67831108e-02f,
  1.74096912e-01f, 1.93728879e-02f, -2.57478729e-02f, 5.75746372e-02f, -7.58398324e-02f, 1.11780046e-02f, -8.65118057e-02f, 7.64597440e-03f, -1.48085743e-01f, -1.72432020e-01f,
  7.43493959e-02f, 1.65636018e-01f, 1.23108841e-01f, 7.60053471e-02f, -2.29026526e-02f, -6.91921338e-02f, -5.74022233e-02f, 8.06841478e-02f, 5.57581447e-02f, 8.24692026e-02f,
  8.26480091e-02f, 1.55272588e-01f, -1.14827361e-02f, -9.29938257e-02f, 4.60651591e-02f, 5.62470825e-03f, -2.24513877e-02f, 1.71791822e-01f, -5.38291447e-02f, -1.51933849e-01f,
  -2.46437088e-01f, -1.73164103e-02f, 1.24255337e-01f, -3.83814462e-02f, -1.01002850e-01f, 1.39646843e-01f, -1.72653317e-01f, -2.55551804e-02f, 1.01822473e-01f, -2.18936875e-01f,
  2.40757644e-01f, -5.91246635e-02f, 1.58819273e-01f, 2.78446972e-01f, 1.85420260e-01f, 2.78469920e-01f, 2.30151206e-01f, 1.63482741e-01f, 5.21836206e-02f, 1.37943074e-01f,
  1.98173121e-01f, 1.73123181e-01f, -3.49496230e-02f, -7.29250759e-02f, -3.91553864e-02f, -4.04722095e-02f, 9.25167184e-03f, -7.67613277e-02f, 1.16676494e-01f, 1.73818320e-01f,
  -5.49161807e-02f, 5.25508150e-02f, 1.46907903e-02f, -7.43290260e-02f, -1.29888907e-01f, 1.17207922e-01f, -1.06763849e-02f, 7.66118476e-03f, -7.40681216e-02f, -1.85213357e-01f,
  -1.00226887e-01f, 7.57711679e-02f, 6.66928664e-02f, -4.41247411e-03f, -6.51966557e-02f, -3.04616932e-02f, 1.80797670e-02f, -1.25851363e-01f, -1.35694340e-01f, -1.54836535e-01f,
  -8.95794407e-02f, -1.80830076e-01f, 1.57945175e-02f, -1.45748639e-02f, -1.00045532e-01f, 4.25238311e-02f, -1.17494844e-01f, -1.03589088e-01f, -1.16064258e-01f, -6.86351955e-02f,
  -6.58375844e-02f, -2.29742564e-03f, -5.05265966e-02f, -1.48983644e-02f, -1.19513478e-02f, 6.16761036e-02f, 1.95510946e-02f, -1.28960103e-01f, -6.28188476e-02f, -6.67012110e-02f,
  2.21616417e-01f, 8.75658914e-02f, -6.10829005e-03f, 6.04112260e-03f, 9.12167653e-02f, 4.00527827e-02f, -3.27359401e-02f, 1.57466233e-02f, 1.05340689e-01f, -1.05401324e-02f,
  -6.94731399e-02f, 1.24824159e-01f, -4.77110632e-02f, 1.24530688e-01f, 1.20118603e-01f, -4.80535030e-02f, -4.34248559e-02f, 1.42861763e-02f, -3.09242308e-02f, -1.54725453e-02f,
  6.87247440e-02f, 2.62755342e-02f, 8.50785896e-02f, -1.23615153e-01f, 1.64849274e-02f, 2.45888885e-02f, 1.23263448e-01f, 1.07356220e-01f, 1.42747864e-01f, 1.58329502e-01f,
  -1.25260353e-01f, 1.67031989e-01f, 4.29299253e-04f, -7.39896372e-02f, -3.38178687e-02f, -6.48611262e-02f, 3.70593891e-02f, -8.60283598e-02f, -1.51938662e-01f, -1.00719593e-01f,
  6.30249036e-03f, -5.29250018e-02f, 4.61908951e-02f, -6.75993562e-02f, -2.06776299e-02f, -8.33393037e-02f, -1.05629906e-01f, 5.06373309e-02f, -4.10181731e-02f, -9.02578831e-02f,
  -4.74788547e-02f, -3.25087197e-02f, -5.16647995e-02f, -3.31172422e-02f, 4.93591838e-03f, 1.41322732e-01f, 4.44249064e-02f, 2.79484279e-02f, 8.25083908e-03f, -7.35441316e-03f,
  -4.74666715e-01f, -6.41582131e-01f, 2.09478274e-01f, -2.59329170e-01f, 1.39391154e-01f, 3.83653939e-01f, 1.64947256e-01f, -2.00255234e-02f, -8.38586465e-02f, -1.62722394e-01f,
  -3.76098484e-01f, -3.66779089e-01f, -2.99649149e-01f, -2.24425808e-01f, -3.60070653e-02f, 1.55911341e-01f, 2.50850409e-01f, 2.14342013e-01f, 3.49617064e-01f, 2.75070220e-01f,
  1.74163692e-02f, -5.66370822e-02f, -2.30909482e-01f, -2.31306851e-01f, -2.57658273e-01f, -7.65768215e-02f, -5.83842173e-02f, -1.57798961e-01f, -7.03034922e-02f, -2.18175769e-01f,
  3.26455504e-01f, -1.78506970e-01f, 9.91322026e-02f, -1.15668505e-01f, -1.32933453e-01f, -1.38758644e-01f, 5.44196181e-02f, -5.74124232e-02f, -1.98486403e-01f, 1.74078289e-02f,
  -1.27462104e-01f, -1.28514264e-02f, 3.25936526e-02f, -1.68473981e-02f, 7.27027506e-02f, -2.64243279e-02f, -1.29963607e-01f, -2.06760719e-01f, -1.64676771e-01f, 9.27911978e-03f,
  -9.21359435e-02f, -6.24521226e-02f, 6.49159551e-02f, -9.80753917e-03f, -2.53937300e-02f, 7.21494667e-03f, -1.93674639e-01f, -1.50444031e-01f, -9.90220904e-02f, -9.64826569e-02f,
  1.90140441e-01f, -1.38937598e-02f, -5.33563308e-02f, 1.55008142e-03f, -5.62509010e-03f, 4.39351201e-02f, -3.54870856e-02f, -1.41467880e-02f, -6.14643544e-02f, 4.49600667e-02f,
  -1.07688293e-01f, -4.38467078e-02f, 1.13647636e-02f, -7.57601559e-02f, -6.55138269e-02f, -8.44971836e-02f, -5.57451770e-02f, -7.60051385e-02f, -1.10786729e-01f, -1.20091848e-01f,
  -5.50946891e-02f, -7.90555552e-02f, -4.78765368e-02f, -4.53532338e-02f, -1.44726977e-01f, 1.89212468e-02f, 9.47349425e-03f, -1.72147024e-02f, -3.93138528e-02f, -1.07410066e-02f,
  6.34410158e-02f, 1.14486910e-01f, 1.23867907e-01f, -6.89009810e-03f, 8.32024030e-03f, -6.18982837e-02f, -7.50532523e-02f, 2.46648993e-02f, -1.10565454e-01f, 4.54880521e-02f,
  8.43386427e-02f, 1.06942646e-01f, -4.94529270e-02f, -1.32888600e-01f, 1.79160520e-01f, 3.59797478e-02f, -1.56645179e-01f, -1.33749498e-02f, -5.66571839e-02f, 1.64709259e-02f,
  -2.74520256e-02f, 1.37054801e-01f, 2.27346286e-01f, 9.71400738e-02f, -2.68986449e-04f, 8.94897059e-02f, 1.37824014e-01f, 1.40255660e-01f, 1.58913240e-01f, 2.20804706e-01f,
  -4.27363783e-01f, 5.43404073e-02f, 1.93820938e-01f, 7.73385018e-02f, 8.18555281e-02f, 1.25129342e-01f, 9.06276703e-02f, 1.60547778e-01f, 1.60914168e-01f, 1.88485280e-01f,
  1.90508068e-01f, 3.33569258e-01f, 2.98816383e-01f, 2.19320267e-01f, 1.85173303e-01f, 2.48851910e-01f, 2.28391960e-01f, 1.14608826e-02f, 1.22676305e-01f, 1.20588668e-01f,
  1.85409993e-01f, 9.69704688e-02f, -1.58626705e-01f, -2.34574657e-02f, 6.78021237e-02f, 2.51719236e-01f, 1.30741969e-01f, 1.82677850e-01f, 1.14128470e-01f, 1.35451257e-01f,
  1.25872299e-01f, -7.19745308e-02f, 3.63747180e-02f, -7.97796156e-03f, -1.90512210e-01f, -1.59785107e-01f, -8.60806182e-02f, -3.80265191e-02f, -2.24874523e-02f, 3.62845063e-02f,
  -4.89169955e-02f, -2.03435630e-01f, -5.92194609e-02f, -7.09358882e-03f, 5.59430989e-03f, -5.54625690e-02f, -6.19259775e-02f, 1.46277875e-01f, 2.21850559e-01f, 8.47792700e-02f,
  -4.77324873e-02f, 1.24441914e-03f, 8.75617862e-02f, -1.95408873e-02f, -1.08791776e-01f, 3.78181078e-02f, 7.74917156e-02f, 6.24618307e-02f, -1.28363883e-02f, 1.81680557e-03f,
  3.51258874e-01f, 1.20606221e-01f, 1.81482045e-03f, 7.61196464e-02f, 2.30441000e-02f, 2.35211458e-02f, 4.75534052e-02f, 1.19036809e-02f, 9.76577960e-03f, -8.46814588e-02f,
  2.00772118e-02f, 1.82336763e-01f, -3.17990445e-02f, -3.98436114e-02f, -7.74446055e-02f, -1.14001110e-02f, -1.22151248e-01f, -9.98165384e-02f, -4.10543345e-02f, -6.83649108e-02f,
  -1.66399509e-01f, 1.60887167e-02f, -6.94595203e-02f, -1.54754817e-02f, 5.66961318e-02f, -5.96324354e-02f, -2.04141028e-02f, 5.66845462e-02f, -9.85764787e-02f, -9.44538713e-02f,
  3.60243857e-01f, -9.88638848e-02f, -8.11349005e-02f, 8.04641377e-03f, -1.44293025e-01f, -1.84116289e-01f, 1.26922010e-02f, -1.66081935e-01f, -4.55163456e-02f, 2.63799261e-02f,
  -1.21772446e-01f, -2.26214468e-01f, -5.86600490e-02f, -8.00811797e-02f, -2.21380055e-01f, -2.65930146e-02f, -1.93876982e-01f, -2.01968234e-02f, 1.26053348e-01f, 7.79660344e-02f,
  -7.80238435e-02f, 9.34162587e-02f, 2.24815026e-01f, 1.25540510e-01f, 3.58134583e-02f, -6.35731360e-03f, 5.81615651e-03f, -2.18669008e-02f, 1.22988835e-01f, 1.01194866e-02f,
  6.59568131e-01f, -6.25623716e-03f, 3.18627149e-01f, 1.91239521e-01f, -1.24463804e-01f, -5.85835390e-02f, -1.39515057e-01f, -6.66946173e-02f, 9.88382474e-02f, 4.51513976e-02f,
  -4.53258306e-02f, 1.33623943e-01f, 3.47744003e-02f, 9.04877931e-02f, 1.66818753e-01f, 9.25904661e-02f, 1.93474397e-01f, 3.75511467e-01f, 3.33630770e-01f, 1.20281428e-01f,
  1.12808578e-01f, 8.02259445e-02f, 2.90051877e-01f, 5.53450957e-02f, 1.03457011e-02f, -2.90215053e-02f, 7.79749528e-02f, 8.39944556e-02f, 8.84997845e-02f, 1.57169282e-01f,
  1.03507899e-01f, 1.67551801e-01f, -7.31113851e-02f, -6.54824600e-02f, -1.03770068e-03f, -4.59652878e-02f, -2.39754412e-02f, 5.18132709e-02f, -5.79232201e-02f, 4.65173982e-02f,
  8.40728637e-03f, 7.73448870e-02f, 1.68552157e-02f, 2.75994726e-02f, -8.36691409e-02f, -6.67267442e-02f, 5.90837114e-02f, 9.81061831e-02f, 3.79091986e-02f, -3.20875607e-02f,
  -2.23676991e-02f, -6.81885481e-02f, -6.40434250e-02f, -7.54233748e-02f, 6.18240535e-02f, 7.29178786e-02f, -6.58333302e-02f, 2.32000332e-02f, 4.06342521e-02f, 4.45817560e-02f,
  1.93319753e-01f, 1.69577226e-01f, 2.79625893e-01f, 2.20831394e-01f, 1.73757479e-01f, 2.26046611e-02f, 4.16990817e-02f, -4.56385761e-02f, 9.54339653e-02f, 1.51540145e-01f,
  1.41391149e-02f, 1.49554655e-01f, 8.76668170e-02f, -1.46291759e-02f, 5.48345745e-02f, 8.28354508e-02f, 8.37133452e-02f, -2.82397699e-02f, 7.35423714e-02f, 1.08148642e-02f,
  1.99836567e-01f, 1.05527565e-01f, 1.81391746e-01f, 1.39025092e-01f, 3.43800820e-02f, 1.52095959e-01f, 1.61502600e-01f, 9.53246281e-02f, -4.43549827e-02f, 7.14387074e-02f,
  -3.06197792e-01f, -1.45566463e-01f, 1.98665947e-01f, -2.93922536e-02f, -6.81583658e-02f, -5.20743057e-03f, -8.75244942e-03f, -1.00017421e-01f, -2.54751444e-01f, -1.36149317e-01f,
  -1.78676456e-01f, -1.74927264e-02f, -9.59255844e-02f, 5.34148365e-02f, -6.23280928e-03f, -4.34315391e-03f, -3.50197926e-02f, -1.04623243e-01f, -1.56212553e-01f, -6.57404587e-02f,
  -4.39451914e-03f, -2.06284150e-02f, -1.85698330e-01f, -1.09888375e-01f, -9.52286497e-02f, -1.07373693e-03f, -8.64630491e-02f, -1.66318025e-02f, -6.70544524e-03f, -7.73852691e-02f,
  3.62803102e-01f, 1.55117542e-01f, -4.89448458e-01f, 4.04820889e-01f, -2.48724315e-02f, -2.86141694e-01f, -3.07639807e-01f, 4.96725813e-02f, 3.83486420e-01f, -2.21902095e-02f,
  -8.13214853e-02f, -1.81029588e-01f, -7.83145279e-02f, -3.03341359e-01f, -4.88468379e-01f, -3.31635237e-01f, -3.47819269e-01f, -4.63040352e-01f, -5.48554838e-01f, -2.60557771e-01f,
  5.35949953e-02f, 2.67930031e-02f, 2.79394835e-02f, -1.38646916e-01f, 2.54603148e-01f, -5.98603673e-02f, 1.46923307e-02f, -4.35977243e-02f, -1.61286578e-01f, -6.51011616e-02f,
  -3.02726716e-01f, -2.51563452e-02f, -1.45151094e-01f, -1.53319061e-01f, 5.20391166e-02f, 2.74584275e-02f, -2.12882578e-01f, 2.26010587e-02f, 4.90481332e-02f, -1.82493508e-01f,
  -2.33909041e-01f, -2.13973016e-01f, -1.31126583e-01f, 3.44315171e-02f, -1.13927685e-01f, -2.26042971e-01f, 3.28225113e-04f, -1.04131669e-01f, -9.94606838e-02f, -1.92821622e-01f,
  -4.29365505e-03f, -9.95878652e-02f, -2.18306974e-01f, 5.36518283e-02f, -2.03422010e-01f, -1.47581905e-01f, -1.64490283e-01f, -6.65589198e-02f, -1.44946948e-01f, 2.81691730e-01f,
  3.61701921e-02f, -3.02945785e-02f, 1.34830236e-01f, 1.23823039e-01f, 1.78822368e-01f, 2.56082658e-02f, 1.16118379e-02f, -9.07045230e-02f, -5.97025529e-02f, 1.50611937e-01f,
  3.99920866e-02f, -3.72720696e-02f, -8.75969976e-02f, -1.07642286e-03f, -4.46508415e-02f, -3.73370759e-02f, -1.03061557e-01f, 4.63096052e-02f, -9.36909299e-03f, -2.67415904e-02f,
  1.73395481e-02f, -4.72686859e-03f, 1.04949109e-01f, -1.68764535e-02f, -8.67778361e-02f, -2.19624229e-02f, -9.92766172e-02f, -1.70966253e-01f, -1.83473721e-01f, -1.61224321e-01f,
  2.83191562e-01f, -1.51317254e-01f, 3.69420089e-02f, -1.93799123e-01f, -2.37216707e-02f, 5.52365109e-02f, 5.14260419e-02f, -1.07407972e-01f, 8.07899400e-04f, -9.64756832e-02f,
  -2.37574726e-01f, -1.29727870e-01f, -4.30679806e-02f, 3.70630762e-04f, -5.92693016e-02f, -1.32143432e-02f, 1.37769923e-01f, -2.53706835e-02f, -1.06147073e-01f, 2.36074030e-02f,
  1.77167192e-01f, 9.64516588e-03f, 4.81982864e-02f, 6.67453632e-02f, -6.93418905e-02f, -5.02939261e-02f, -1.60342112e-01f, -1.09744377e-01f, -1.20462403e-01f, 3.62508208e-01f,
  -5.43982208e-01f, -3.44144583e-01f, -1.03500850e-01f, -3.41049433e-01f, -2.72387922e-01f, -1.71162397e-01f, -3.14219534e-01f, -6.26264736e-02f, -2.05485776e-01f, -4.32575613e-01f,
  -1.10991672e-01f, 2.51158446e-01f, 1.02516644e-01f, 2.16604143e-01f, 3.26413289e-02f, -3.46828640e-01f, -3.61742586e-01f, -1.23208433e-01f, 3.98285836e-01f, 2.01686472e-01f,
  5.95508553e-02f, -1.51421772e-02f, 2.22242512e-02f, 3.20148468e-02f, -2.80004591e-02f, 2.90930197e-02f, -1.59603611e-01f, -1.24258690e-01f, -3.45010459e-02f, -4.04672652e-01f,
  1.81018218e-01f, -1.53876737e-01f, 1.29396975e-01f, -5.43383472e-02f, -1.80612653e-02f, -6.90971389e-02f, -1.89829860e-02f, 1.54771563e-02f, -7.86770284e-02f, -1.30277261e-01f,
  -7.67119005e-02f, 1.58119708e-01f, 1.30178228e-01f, -3.70358536e-03f, -2.61827987e-02f, 2.92428154e-02f, 5.36767431e-02f, -9.08238739e-02f, -6.14055023e-02f, -5.99922836e-02f,
  -8.43995884e-02f, -1.34099856e-01f, -1.35711664e-02f, 3.64518873e-02f, 2.14668289e-01f, 9.92422923e-02f, 9.41924825e-02f, 4.51611318e-02f, -8.78391266e-02f, -2.85598308e-01f,
  -1.68586537e-01f, -2.18415763e-02f, -1.33654714e-01f, 1.38330758e-01f, -1.03090983e-02f, -7.33532310e-02f, -4.08482142e-02f, 9.56423283e-02f, 4.44431193e-02f, 7.25405365e-02f,
  -3.17067206e-02f, -1.69756692e-02f, 2.14225799e-03f, 3.87699418e-02f, -3.73682240e-03f, -5.00174314e-02f, 5.02637923e-02f, -5.15025817e-02f, 5.49301133e-02f, -1.37866527e-01f,
  -5.05243950e-02f, -6.95582032e-02f, -3.76583710e-02f, -1.15422800e-01f, -1.27725378e-01f, -1.47974029e-01f, -1.54761430e-02f, 2.05912024e-01f, 1.63822636e-01f, 3.81593369e-02f,
  2.99255580e-01f, -1.99471563e-01f, -6.82500526e-02f, 5.45022264e-02f, -1.36836067e-01f, 2.61851083e-02f, -6.22448847e-02f, 1.13729024e-02f, 6.45027012e-02f, 9.14079230e-03f,
  9.33367107e-03f, -1.95099600e-03f, -9.66721252e-02f, 4.27481271e-02f, -4.94833291e-02f, -2.51210239e-02f, -1.92965612e-01f, -7.62117803e-02f, -1.93667278e-01f, -4.89968732e-02f,
  -1.87182724e-01f, -3.10585707e-01f, 2.54244689e-04f, -3.25778611e-02f, 1.15460448e-01f, -7.12925643e-02f, 2.61235386e-01f, 1.13676473e-01f, -5.64715676e-02f, -2.11478323e-01f,
  -3.30125570e-01f, 3.44074480e-02f, -4.05105144e-01f, 4.64321598e-02f, 2.80368358e-01f, -1.88837945e-02f, -3.73844313e-03f, -2.00054258e-01f, 1.61151290e-01f, 2.07566321e-01f,
  1.67607337e-01f, 3.19678575e-01f, 6.32425174e-02f, 5.36241904e-02f, -1.13557808e-01f, 8.80805776e-02f, 9.38163549e-02f, -1.22030757e-01f, -1.68601289e-01f, 1.58235252e-01f,
  4.10558283e-01f, 1.46325588e-01f, -1.06207341e-01f, 2.26592459e-02f, 8.90585333e-02f, 6.32703900e-02f, 6.95618913e-02f, 1.72408044e-01f, 2.35409170e-01f, 2.90420830e-01f,
  -1.95575550e-01f, -2.39359051e-01f, -4.62915823e-02f, 1.36822924e-01f, 4.41355705e-02f, -1.29701078e-01f, -7.55285695e-02f, -1.38790905e-01f, -9.92402900e-03f, -7.96318799e-02f,
  2.25662485e-01f, -3.48808430e-02f, 5.66270351e-02f, -1.01748273e-01f, -3.62580642e-02f, -4.52965014e-02f, -2.07229838e-01f, -3.09331745e-01f, -4.05859441e-01f, -1.36068389e-01f,
  3.67560863e-01f, 3.39686275e-01f, -2.37048641e-01f, -1.05323754e-01f, -2.82870620e-01f, -1.18037509e-02f, -3.94126564e-01f, -2.78378189e-01f, -3.16967160e-01f, -1.97313577e-01f,
  -2.35648267e-02f, 8.33098814e-02f, 5.99754229e-02f, 1.94562636e-02f, 4.94394638e-02f, 6.91381842e-02f, 2.17375115e-01f, 1.41546890e-01f, 1.02856219e-01f, -1.22405514e-01f,
  -3.21871564e-02f, -6.31457865e-02f, -1.80468261e-02f, -1.48381814e-01f, 3.92891578e-02f, 9.55070630e-02f, 1.00113027e-01f, -2.53050104e-02f, 3.16647664e-02f, -8.04055333e-02f,
  3.38004604e-02f, -2.02917103e-02f, 4.38095853e-02f, -4.78099734e-02f, -3.24938409e-02f, 1.20356493e-02f, 1.60162717e-01f, 7.41084442e-02f, -2.29804851e-02f, 1.30660057e-01f,
  -9.21251252e-02f, 2.45294962e-02f, -2.20351703e-02f, -1.04693159e-01f, -3.52296904e-02f, 7.06928670e-02f, 8.89343303e-03f, -7.88123682e-02f, 7.32189864e-02f, -7.08115473e-02f,
  2.79906485e-02f, -1.03098094e-01f, 1.33410171e-01f, -5.84048294e-02f, -3.55582908e-02f, -7.09555373e-02f, 1.34341255e-01f, -1.94482338e-02f, -3.59347761e-02f, -3.34699005e-02f,
  -1.53382495e-02f, -1.02445818e-01f, -1.23243205e-01f, -1.88615948e-01f, -3.04525271e-02f, 6.17662929e-02f, -1.07864477e-01f, -5.70053495e-02f, -1.88223049e-01f, -3.33095819e-01f,
  6.87221169e-01f, 1.97565034e-01f, 1.89390928e-02f, 6.95933774e-02f, 5.04992343e-02f, 2.34992374e-02f, 2.36285567e-01f, 9.68576670e-02f, 1.05400540e-01f, 1.09777085e-01f,
  1.25262856e-01f, -6.84863478e-02f, 1.83753595e-02f, 2.95136664e-02f, 4.43236977e-02f, -5.93093075e-02f, -1.38153195e-01f, -1.03347413e-02f, -1.95045955e-02f, 1.36162154e-02f,
  -3.90971266e-02f, 4.57601547e-02f, 1.55150414e-01f, 1.24573536e-01f, -1.24694631e-01f, -1.16453774e-01f, -2.43729241e-02f, 4.64808717e-02f, 2.49323552e-03f, -1.46420360e-01f,
  -5.04026055e-01f, 2.10391253e-01f, -8.55634436e-02f, -3.16531095e-03f, 4.83154990e-02f, 1.43302664e-01f, -1.68017372e-02f, 1.32700643e-02f, 1.48519322e-01f, -1.19429022e-01f,
  -3.82251740e-02f, 1.70286000e-02f, -6.52773976e-02f, -7.37119392e-02f, -2.34605484e-02f, -1.86983626e-02f, 1.05398759e-01f, -4.61738743e-02f, -1.56731904e-01f, -1.41944820e-02f,
  -8.28206018e-02f, 8.69946778e-02f, 9.80444252e-02f, -3.40987481e-02f, -2.96094324e-02f, 5.00888526e-02f, -1.20835854e-02f, 3.63433920e-02f, 7.57406326e-03f, 3.76117080e-02f,
  -1.53889120e-01f, 8.25554058e-02f, -5.50647974e-02f, 3.07556316e-02f, 1.09445430e-01f, -7.50892386e-02f, 2.88517424e-03f, -5.76673709e-02f, 1.55684397e-01f, 2.86059342e-02f,
  2.07346820e-04f, -9.08385366e-02f, 9.49856942e-04f, -8.22326839e-02f, -2.35063389e-01f, -6.23414256e-02f, -1.48662161e-02f, -1.92942634e-01f, -8.94290656e-02f, 3.92178595e-02f,
  -6.77959397e-02f, -6.54614642e-02f, -3.86285633e-02f, -1.24191321e-01f, -2.16721818e-01f, -1.54301792e-01f, -1.82527900e-01f, -2.05893605e-03f, 1.05055876e-01f, 8.55326653e-02f,
  -3.86129171e-01f, -7.07700774e-02f, -1.68754861e-01f, 2.28211917e-02f, 6.37395075e-04f, 1.40353367e-01f, 6.00921586e-02f, 6.30343482e-02f, 4.80952859e-02f, -6.78231940e-02f,
  2.57909726e-02f, -8.17863271e-02f, -5.44449054e-02f, 1.60374157e-02f, 5.68550304e-02f, -1.61404498e-02f, 5.53227477e-02f, -1.61510054e-02f, -1.11035079e-01f, -1.35875404e-01f,
  -8.39707926e-02f, -2.25419104e-02f, 8.88345242e-02f, -1.27329472e-02f, -7.17315404e-03f, -6.90061599e-02f, -1.43759459e-01f, -9.40138549e-02f, -2.39883959e-02f, 1.09166674e-01f,
  3.68345261e-01f, -3.73712480e-02f, -6.54237092e-01f, 1.01562329e-01f, -2.18333721e-01f, -1.41779408e-01f, -9.70616043e-02f, 8.76964778e-02f, 5.30972555e-02f, -1.11132070e-01f,
  -2.97538154e-02f, 9.79357585e-02f, -1.26135960e-01f, 5.70207238e-02f, 8.86148959e-02f, -3.00009400e-01f, -3.34595799e-01f, -1.05031252e-01f, 1.03109017e-01f, 2.35347942e-01f,
  2.26971522e-01f, 1.91877782e-01f, 2.12642610e-01f, 4.05673776e-03f, -5.02328621e-04f, 1.45816559e-03f, -1.27323136e-01f, -1.14923649e-01f, -9.14117545e-02f, -2.45971173e-01f,
  -2.32994050e-01f, -1.28168106e-01f, -1.42289788e-01f, 1.38937891e-01f, -3.25912654e-01f, -1.30459011e-01f, -1.70466095e-01f, -1.79171130e-01f, 1.18156619e-01f, -5.21347038e-02f,
  -1.69583052e-01f, 1.66694596e-02f, 2.40115710e-02f, 8.37220997e-02f, 1.18063085e-01f, -7.15014935e-02f, -1.27481565e-01f, -1.11539349e-01f, -1.02354169e-01f, -9.60082468e-03f,
  -6.84739053e-02f, -1.46581575e-01f, -2.73449242e-01f, -2.24435791e-01f, -1.11083180e-01f, -1.05325267e-01f, -2.24535540e-01f, -2.85167098e-01f, -1.74283549e-01f, -3.27484384e-02f,
  3.30057777e-02f, -3.46009955e-02f, -1.15967281e-01f, 6.40208945e-02f, 1.12572387e-01f, -2.49389112e-02f, 6.66907951e-02f, 1.30822375e-01f, 1.02463126e-01f, 2.08160430e-02f,
  -2.20921151e-02f, 3.04100290e-03f, 8.53593200e-02f, 7.17734471e-02f, 1.94132011e-02f, -3.69101837e-02f, 7.74050057e-02f, 1.21273786e-01f, 7.71103948e-02f, 3.71584259e-02f,
  -6.84712157e-02f, -4.61180061e-02f, -6.20984919e-02f, 2.78224498e-02f, -2.64741987e-01f, 1.30084120e-02f, 1.39251081e-02f, 5.33542670e-02f, 6.99967518e-02f, -1.21401228e-01f,
  5.32643259e-01f, -5.93884364e-02f, 2.13610176e-02f, -3.79344337e-02f, 1.90153960e-02f, -3.50432983e-03f, -6.94638565e-02f, 9.79731325e-03f, -4.91172560e-02f, -1.63284969e-02f,
  1.31703809e-01f, 5.47291860e-02f, 1.17799088e-01f, 7.37321824e-02f, 1.43369466e-01f, 3.60135883e-02f, -2.67579556e-02f, -4.07949798e-02f, 1.48148730e-01f, -1.46344095e-01f,
  2.94700675e-02f, 2.00386137e-01f, 1.43431678e-01f, 1.36611257e-02f, 8.40959251e-02f, 1.11665718e-01f, -4.09433618e-02f, 2.22284738e-02f, 2.70949770e-03f, 4.76729333e-01f,
  5.59654236e-01f, 2.37662360e-01f, 3.32588553e-01f, 1.47834036e-03f, -3.12055260e-01f, -2.97372460e-01f, -2.78875619e-01f, -6.89964518e-02f, -7.55936876e-02f, 1.04956619e-01f,
  -2.10968524e-01f, -2.14077786e-01f, 6.44882545e-02f, -1.15959696e-01f, -3.32026072e-02f, -2.01221462e-03f, 1.69357792e-01f, 1.20131075e-01f, -1.44781291e-01f, -1.29878163e-01f,
  -2.70436049e-01f, 1.15775011e-01f, 3.10759366e-01f, 1.23112194e-01f, 1.04956292e-01f, -1.21573441e-01f, 1.36058941e-01f, 2.23602384e-01f, -4.73926440e-02f, 2.00985849e-01f,
  2.77227879e-01f, 9.93971527e-02f, -3.76258731e-01f, -1.68491960e-01f, 9.75918993e-02f, 8.07794034e-02f, 4.38332334e-02f, 3.63343954e-01f, 7.69490972e-02f, -4.67208354e-03f,
  -1.57528520e-02f, 1.66264057e-01f, -6.22393377e-02f, -9.58923101e-02f, -1.23379230e-01f, -1.62669569e-01f, 5.63790910e-02f, 1.76098764e-01f, 1.91116959e-01f, 5.05245030e-02f,
  -1.43623829e-01f, -6.25536814e-02f, 3.08200605e-02f, -1.27012566e-01f, 1.25892133e-01f, -1.27968013e-01f, -4.47117873e-02f, -6.77337050e-02f, 3.49243060e-02f, 2.65661687e-01f,
  2.26334818e-02f, -3.39821614e-02f, -9.11239833e-02f, 2.16172338e-02f, -8.46896991e-02f, -9.42711812e-03f, -8.70644599e-02f, -5.22891479e-03f, 1.68595705e-02f, 3.91235277e-02f,
  4.94176447e-02f, 1.07323118e-01f, 4.96120076e-04f, 3.23183811e-03f, -1.34571299e-01f, 1.99732278e-03f, 2.02554185e-02f, 1.23753875e-01f, 5.80819473e-02f, 3.52211902e-03f,
  -8.41028169e-02f, 9.71333236e-02f, 1.28636807e-01f, 8.54959637e-02f, 1.55927353e-02f, 8.24446045e-03f, 1.24040328e-01f, -3.85512672e-02f, 2.84767672e-02f, 4.31868620e-02f,
  -1.44520760e-01f, -4.09437507e-01f, 3.76427248e-02f, 8.59250352e-02f, -2.43427008e-02f, -1.12440750e-01f, -3.23146116e-04f, -1.29616586e-02f, 5.64516298e-02f, 1.37349609e-02f,
  -7.53464699e-02f, -1.45970052e-02f, 1.33716315e-01f, -6.33231401e-02f, -1.58087581e-01f, -8.28575939e-02f, -8.54177475e-02f, -1.63230941e-01f, -2.31291726e-01f, -1.50420032e-02f,
  -4.32336442e-02f, -1.72465444e-01f, -2.74601698e-01f, -1.29276767e-01f, -1.14235304e-01f, -4.24550444e-01f, -2.77611971e-01f, -1.83042079e-01f, -3.22265595e-01f, 8.50895327e-03f,
  -5.54859340e-01f, 1.37635186e-01f, 9.61658508e-02f, -1.39141679e-01f, 2.50595570e-01f, 2.07709655e-01f, 3.84938091e-01f, 6.13890104e-02f, -1.92769155e-01f, 3.80020104e-02f,
  1.81564735e-03f, -8.75965059e-02f, 5.85954115e-02f, -2.64547113e-02f, 1.42061830e-01f, 1.18631557e-01f, 2.45677397e-01f, -6.17178194e-02f, -1.39004186e-01f, -5.85764013e-02f,
  1.14281245e-01f, -8.78621116e-02f, -2.77281344e-01f, -1.48016876e-02f, 3.66053656e-02f, -2.80497316e-02f, 6.68286160e-02f, -1.78337228e-02f, 1.97616741e-01f, 7.86413103e-02f,
  -3.94123226e-01f, -2.32057303e-01f, 9.58933234e-02f, -1.71263069e-01f, -1.88074216e-01f, -9.95149836e-02f, -6.73633590e-02f, -3.03437591e-01f, -3.20542715e-02f, -1.51680291e-01f,
  1.71465576e-02f, 3.74101959e-02f, -1.03537969e-01f, 2.90559139e-03f, -3.90525274e-02f, 7.79985040e-02f, 1.09549880e-01f, 1.00605503e-01f, -2.02703387e-01f, -2.51912302e-03f,
  2.92150617e-01f, -7.50065520e-02f, -2.45121926e-01f, 1.96160480e-01f, 6.74333498e-02f, -1.43493906e-01f, -8.90479088e-02f, -1.51108578e-01f, -1.89576551e-01f, -3.25529635e-01f,
  -5.17615303e-03f, 9.50940326e-02f, 1.78696617e-01f, 9.24840346e-02f, 5.33249974e-02f, 5.10237962e-02f, 1.94080815e-01f, 1.78901210e-01f, 4.35862355e-02f, -2.31335908e-02f,
  -5.23038432e-02f, -1.78344712e-01f, 5.45801073e-02f, -1.21050544e-01f, -1.35775283e-01f, -3.29392925e-02f, 1.43565133e-01f, -4.98208366e-02f, -1.15040187e-02f, -1.59403056e-01f,
  -8.89311507e-02f, -3.88501100e-02f, -7.23878741e-02f, -4.97641694e-03f, 1.22873440e-01f, -6.98595727e-03f, -7.56148398e-02f, 1.45640585e-03f, 2.04877034e-02f, 3.67623232e-02f,
  -3.43448371e-01f, 2.89783597e-01f, -1.80983543e-01f, -2.43327972e-02f, -8.71906355e-02f, -1.18709803e-01f, -7.64827579e-02f, -1.33117601e-01f, -1.17221428e-02f, -6.79259524e-02f,
  -5.11503667e-02f, -1.01039648e-01f, -4.29953262e-02f, -4.40665986e-03f, -1.28940657e-01f, -8.46577734e-02f, 1.19432069e-01f, 6.94398656e-02f, 5.49294762e-02f, 1.56283993e-02f,
  1.34576848e-02f, -7.52992630e-02f, -2.75068432e-01f, 6.52803481e-02f, 3.42405438e-02f, -1.45823106e-01f, -6.77291304e-02f, -1.27931491e-01f, -1.20013744e-01f, -2.59911388e-01f,
  -4.06501591e-01f, -4.21476692e-01f, 3.79493356e-01f, -1.71458453e-01f, -1.35925725e-01f, -2.54188418e-01f, -5.43293834e-01f, -3.07633787e-01f, -2.00636429e-03f, -4.52084452e-01f,
  -4.15187865e-01f, 6.35545626e-02f, 9.71528292e-02f, 1.53595746e-01f, -1.91263229e-01f, -4.07410800e-01f, -1.33709311e-01f, 3.27306837e-01f, 3.71626943e-01f, 1.32852606e-02f,
  -1.78486630e-01f, 1.13318257e-01f, 2.70841062e-01f, 2.26107940e-01f, -2.97959536e-01f, 1.47573695e-01f, 8.09587315e-02f, 2.85818502e-02f, -6.05358221e-02f, -5.39777353e-02f,
  -9.67293009e-02f, -2.13420421e-01f, 1.60862222e-01f, 8.88253301e-02f, -8.77799187e-03f, 7.41328746e-02f, -1.50550023e-01f, 3.55748869e-02f, 1.22775704e-01f, -6.18604617e-03f,
  -9.62960050e-02f, -1.95805669e-01f, -7.42279962e-02f, -1.08474270e-02f, -8.08339342e-02f, -2.40578040e-01f, -2.94998772e-02f, 2.92834546e-02f, 1.23312928e-01f, -1.86307535e-01f,
  -1.33975446e-01f, -1.37396857e-01f, 1.26429899e-02f, 4.06889757e-03f, -1.21510968e-01f, 1.74679905e-01f, -8.35721120e-02f, -1.20738976e-01f, -4.41026725e-02f, -1.89708039e-01f,
  9.02551474e-05f, 8.78551528e-02f, 1.51730031e-01f, -3.89877521e-02f, -1.63143545e-01f, 8.76675695e-02f, 2.99027227e-02f, 9.49834660e-02f, 1.19168513e-01f, 8.80437940e-02f,
  1.13378681e-01f, -4.11885642e-02f, 2.36298330e-02f, -1.31224543e-02f, 1.81075603e-01f, 3.49417701e-02f, 8.62056315e-02f, 1.15601592e-01f, 8.18190202e-02f, 9.74818617e-02f,
  1.20080456e-01f, 4.08254415e-02f, 2.23109841e-01f, 9.72037297e-03f, -1.04077309e-01f, -4.40194570e-02f, 4.14540060e-02f, 2.67406795e-02f, -1.34220114e-02f, -8.79249573e-02f,
  2.92125996e-02f, 2.80568242e-01f, -1.81323811e-01f, -6.77824095e-02f, -1.81227311e-01f, 2.48529285e-01f, -1.03947975e-01f, -1.41503999e-03f, 1.03986509e-01f, 5.78275137e-03f,
  -1.27728105e-01f, -2.74437845e-01f, -8.34431499e-02f, 9.44811627e-02f, -9.37841311e-02f, -8.20032787e-03f, -2.39103019e-01f, -2.40062573e-03f, -8.06068480e-02f, -2.03277975e-01f,
  9.39950421e-02f, -2.65776187e-01f, -8.18530321e-02f, -7.70701393e-02f, -1.36548489e-01f, -7.23699629e-02f, -1.28037244e-01f, -2.41623864e-01f, -1.32862613e-01f, -4.95017678e-01f,
  1.40620202e-01f, -1.55723959e-01f, 7.10585639e-02f, 3.07924211e-01f, 6.79318383e-02f, -3.58242124e-01f, -6.21791482e-01f, -4.04969782e-01f, -1.34603688e-02f, -2.31580902e-02f,
  1.39335871e-01f, 1.95598856e-01f, 4.50221822e-02f, 4.38728509e-03f, -2.66705841e-01f, -2.01688230e-01f, -3.86311077e-02f, -6.76909164e-02f, -2.93788522e-01f, -2.66058087e-01f,
  2.70183645e-02f, -2.60501746e-02f, 1.01960478e-02f, -8.61087516e-02f, 3.43200356e-01f, 2.34084442e-01f, 1.73858762e-01f, 1.79024890e-01f, 1.04091622e-01f, 4.08182979e-01f,
  3.08044285e-01f, 4.06768322e-02f, -2.37096921e-01f, 1.86455786e-01f, 1.16575599e-01f, 2.35040532e-03f, 6.55962387e-03f, 9.54461545e-02f, -2.72841118e-02f, 1.63736232e-02f,
  2.31738180e-01f, 2.07079500e-02f, 8.44190046e-02f, -3.61172110e-02f, -1.07004359e-01f, -9.97388065e-02f, -7.48554021e-02f, -1.14918351e-01f, -3.64441760e-02f, 3.33621330e-03f,
  1.28608063e-01f, 6.15501553e-02f, 2.97397114e-02f, -1.39087424e-01f, -1.58666670e-01f, 1.77765071e-01f, -1.19738430e-02f, 2.71970816e-02f, -5.11356518e-02f, 1.11287311e-02f,
  7.23201956e-04f, 5.39425947e-02f, 2.24745087e-02f, 1.19961262e-01f, 4.31711935e-02f, 3.42533290e-02f, 1.11170538e-01f, 2.44054589e-02f, 3.33131589e-02f, 5.44415377e-02f,
  -3.96984369e-02f, 7.26477206e-02f, -1.44782275e-01f, 4.02080826e-02f, 1.70398027e-01f, 8.54529366e-02f, 2.72243060e-02f, -8.51499587e-02f, -2.59592547e-03f, 1.16228253e-01f,
  -2.45386530e-02f, -5.33544309e-02f, 7.36092776e-02f, -1.14248842e-01f, 6.95172846e-02f, 4.64050323e-02f, 7.41318911e-02f, 1.47865172e-02f, -4.10341397e-02f, 1.59646630e-01f,
  -7.99743682e-02f, -2.61056572e-01f, 7.74736106e-02f, -1.16285533e-01f, 1.53280243e-01f, 9.69532728e-02f, 2.09032968e-01f, 3.96320596e-02f, 1.78660303e-01f, -1.74313635e-02f,
  8.87848660e-02f, 3.13502513e-02f, 7.70564526e-02f, -5.76301478e-02f, -8.56625512e-02f, 7.77348951e-02f, 1.22308813e-01f, -6.49355426e-02f, -1.37583017e-01f, 3.60819325e-02f,
  2.84760818e-02f, -3.03075850e-01f, -1.72072828e-01f, -2.85280854e-01f, 1.08100297e-02f, -1.50431201e-01f, 2.27733469e-03f, 1.37605984e-02f, -2.24681020e-01f, -2.71912217e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.57929975e-01f, 1.59368768e-01f, -5.13267517e-02f, 4.19185013e-01f, 4.38560545e-01f, 3.70870024e-01f, 2.75956631e-01f, 2.16629863e-01f, 2.39062265e-01f, 4.37154800e-01f,
  2.23827422e-01f, 2.29224116e-01f, 1.99898183e-02f, 3.05199564e-01f, 3.02260160e-01f, 5.47714353e-01f, 3.42303008e-01f, 2.94034004e-01f, 1.60550654e-01f, 1.34203240e-01f,
  4.45546955e-01f, 3.01444203e-01f, 4.42995071e-01f, 1.24955550e-01f, 1.62333295e-01f, 1.69198796e-01f, -1.54475477e-02f, 2.49937996e-01f, 3.19804043e-01f, 3.48579884e-01f,
  1.48313582e-01f, 9.66636762e-02f, 2.66058922e-01f, 2.10429907e-01f, -2.58464497e-02f, 3.37822646e-01f, 2.05071434e-01f, 2.36814022e-01f, 2.35554925e-03f, 1.83393732e-01f,
  6.30431712e-01f, 8.39120299e-02f, 3.73276711e-01f, 3.35614920e-01f, 2.15855733e-01f, 1.28869906e-01f, 2.06846416e-01f, 1.99491233e-01f, 4.38824505e-01f, 1.60551056e-01f,
  2.57330984e-01f, 3.28959942e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  3.09436545e-02f, -1.88768536e-01f, -4.33008373e-02f, 1.16277650e-01f, 1.16835490e-01f, 6.45303950e-02f, 2.56016552e-01f, -1.59712195e-01f, 1.03901580e-01f, -8.66148993e-02f,
  -1.02844737e-01f, -7.91564435e-02f, 1.62255213e-01f, 1.81520209e-01f, 3.40835340e-02f, -2.39354283e-01f, -2.53009647e-01f, -8.06675234e-04f, -3.01603347e-01f, 2.00438589e-01f,
  5.37157394e-02f, -9.22573283e-02f, -4.10817862e-02f, -2.38922045e-01f, 2.68371105e-01f, 1.93495631e-01f, -1.01009317e-01f, 1.82336852e-01f, 7.93479457e-02f, 1.70817137e-01f,
  -5.91406710e-02f, 8.14999565e-02f, -2.09916636e-01f, 2.39146546e-01f, -3.27735394e-01f, 4.37093973e-02f, 9.69220623e-02f, -1.78162649e-01f, 9.44957584e-02f, 4.65160981e-02f,
  -1.43139690e-01f, -2.14424625e-01f, -1.07828461e-01f, 1.01924036e-02f, -1.49178043e-01f, 1.25254124e-01f, -3.71847972e-02f, 3.01787257e-01f, -3.80648747e-02f, 2.20649853e-01f,
  1.75225869e-01f, 7.11544305e-02f, -1.29832998e-01f, -1.10741012e-01f, 2.58856833e-01f, 1.88898757e-01f, -5.02811782e-02f, -8.60947147e-02f, 1.26764789e-01f, 1.76397189e-01f,
  -3.81533168e-02f, -2.34510019e-01f, 3.50313149e-02f, -1.40537411e-01f, -6.30541891e-02f, 2.07178388e-02f, -9.04475302e-02f, -4.70023863e-02f, 9.20731053e-02f, 1.65625125e-01f,
  1.68017015e-01f, 2.48114578e-02f, 6.36979863e-02f, 5.42372800e-02f, 1.27735540e-01f, 4.17642593e-02f, 8.23867321e-02f, -1.22045487e-01f, 1.81392595e-01f, 1.44627970e-03f,
  -3.92290540e-02f, -3.43881138e-02f, -1.64547995e-01f, 4.92464826e-02f, -8.46772045e-02f, -5.25770411e-02f, -1.43100977e-01f, 1.05773933e-01f, -2.24844124e-02f, -1.52144462e-01f,
  2.85628527e-01f, -1.89352810e-01f, 1.71876192e-01f, -1.40847132e-01f, -5.71558364e-02f, 2.10853532e-01f, -1.11732744e-01f, 1.68136343e-01f, 8.63660127e-02f, -2.43309028e-02f,
  8.61319825e-02f, 4.24116962e-02f, 8.83535519e-02f, -8.80810618e-02f, 9.11762714e-02f, -6.08032495e-02f, -2.77513444e-01f, -1.18113533e-01f, 8.25276524e-02f, 4.44479674e-01f,
  7.30438605e-02f, -2.30360389e-01f, 2.22344980e-01f, 9.62054133e-02f, 1.68997839e-01f, -1.09306604e-01f, -6.35809079e-02f, 2.53380775e-01f, -9.23459604e-02f, -2.39906982e-01f,
  2.44820416e-01f, -3.86689976e-03f, -1.05698265e-01f, 1.26509920e-01f, -2.13966087e-01f, 1.43770769e-01f, 1.31233245e-01f, -2.80513406e-01f, 3.42281312e-02f, -1.99190248e-02f,
  4.19672951e-02f, -8.18765548e-04f, 1.48715585e-01f, 1.61130756e-01f, -3.75920422e-02f, 2.90759563e-01f, -1.58554856e-02f, -4.64002341e-02f, -1.05964504e-01f, -5.49428202e-02f,
  -3.54403667e-02f, -5.43009453e-02f, -1.25586510e-01f, 1.49932891e-01f, -3.41482282e-01f, -1.77519575e-01f, -1.61098510e-01f, 2.38718037e-02f, 5.21749556e-02f, -5.85799515e-02f,
  -3.23481895e-02f, -5.07441685e-02f, -1.71285793e-01f, -2.62316857e-02f, -6.67652562e-02f, 1.53429378e-02f, -9.51393023e-02f, -8.80293548e-02f, -1.51331678e-01f, 9.17817652e-02f,
  -1.70556411e-01f, 3.73366363e-02f, -2.97213256e-01f, -4.30728458e-02f, -1.56207860e-01f, -5.10159582e-02f, -1.53923556e-02f, -1.20620035e-01f, -2.70821810e-01f, 3.19666043e-02f,
  -2.50546217e-01f, 1.33200884e-01f, -1.15527757e-01f, 3.60433728e-01f, 1.04051933e-01f, -1.34183869e-01f, -4.81186733e-02f, 1.22695923e-01f, 1.64833426e-01f, 1.11711342e-02f,
  -2.19233289e-01f, -9.36522782e-02f, 2.28451639e-01f, 6.24156334e-02f, 2.81120595e-02f, 1.99712694e-01f, -1.99728131e-01f, -2.36486848e-02f, 4.87137102e-02f, 1.45092815e-01f,
  9.00133103e-02f, 2.25062221e-01f, -7.04092085e-02f, 6.49750680e-02f, -1.48750013e-02f, -1.13171592e-01f, 8.70886967e-02f, -2.03527063e-02f, 3.02978605e-02f, -1.29202427e-02f,
  4.34457995e-02f, 4.65349257e-02f, 1.47537917e-01f, -2.48577818e-02f, -7.32101947e-02f, 9.02955532e-02f, 1.40329048e-01f, -1.61700726e-01f, -1.31475195e-01f, -2.93877274e-01f,
  8.43532383e-02f, -2.62913465e-01f, 2.38548517e-02f, 2.00653896e-01f, 3.02915685e-02f, -1.05807461e-01f, -2.24927347e-02f, 1.33730114e-01f, -8.00954476e-02f, 8.51858035e-02f,
  -1.90360084e-01f, 3.73271741e-02f, 1.12717345e-01f, 1.25901818e-01f, -4.98755798e-02f, -8.80219713e-02f, 1.75194234e-01f, 1.67343438e-01f, 9.48901922e-02f, 1.04794100e-01f,
  7.16043487e-02f, -9.09357071e-02f, 2.21508164e-02f, -1.08951084e-01f, -1.01975635e-01f, -8.88068900e-02f, 2.36856058e-01f, 2.00884119e-01f, 8.23906511e-02f, -1.78942636e-01f,
  1.05532050e-01f, 2.38522425e-01f, -1.18880197e-02f, 3.76258530e-02f, -2.71862507e-01f, 1.61217824e-02f, -1.26554430e-01f, -2.60081161e-02f, -1.80951168e-03f, 7.65480101e-02f,
  5.26593253e-02f, 1.60491467e-01f, -1.17028333e-01f, 1.48185641e-01f, 4.34216857e-03f, -1.83225930e-01f, 4.15155143e-02f, 1.57199249e-01f, 1.17464036e-01f, -1.77754462e-02f,
  -9.45503190e-02f, 1.45734906e-01f, 1.79015264e-01f, 3.24050784e-02f, -3.46529894e-02f, 1.51419669e-01f, 2.15592403e-02f, 1.59815297e-01f, -1.54022202e-01f, -1.60104603e-01f,
  -1.42332986e-01f, -1.32654584e-03f, -3.44468877e-02f, -5.16341366e-02f, -1.01126671e-01f, -4.09522802e-02f, -6.03679679e-02f, -2.29560006e-02f, -1.89607404e-02f, -2.68658370e-01f,
  -2.04466656e-01f, 1.42889535e-02f, -7.86056817e-02f, 2.89726704e-01f, -2.06786692e-01f, -1.69940740e-01f, -8.30930173e-02f, -1.66445691e-02f, -1.42356113e-01f, -6.29716441e-02f,
  -1.50701459e-02f, 9.63847190e-02f, 6.90464047e-04f, -6.09049834e-02f, 8.75203982e-02f, 2.05295131e-01f, -2.38351133e-02f, 1.02385879e-01f, 1.47861624e-02f, 3.00053537e-01f,
  -2.30708674e-01f, -3.65771890e-01f, 1.12859502e-01f, 1.91156089e-01f, -4.21715640e-02f, -1.47633731e-01f, -2.24563181e-02f, -6.58484399e-02f, -1.66726366e-01f, -1.14767499e-01f,
  1.16846621e-01f, 6.77249357e-02f, -7.97235593e-02f, -4.18573655e-02f, 1.35737434e-01f, 4.44001332e-02f, 3.16279650e-01f, -1.12685598e-01f, 2.63773352e-01f, -4.61560348e-03f,
  -2.20457222e-02f, 1.23949744e-01f, -1.26030415e-01f, 1.00602463e-01f, 2.18627322e-02f, -1.41780615e-01f, 1.76652763e-02f, -1.83465987e-01f, 1.05052374e-01f, -1.27206758e-01f,
  2.60058641e-01f, -1.22716852e-01f, 1.27521560e-01f, 6.56875670e-02f, -1.24675862e-01f, 1.61651000e-01f, 3.01264465e-01f, 2.26888344e-01f, 5.94487004e-02f, -2.10657820e-01f,
  5.17047942e-02f, 8.30452982e-03f, 8.92629996e-02f, 4.92959619e-02f, -2.18494684e-01f, 7.46031117e-04f, -7.82338306e-02f, -8.50705616e-03f, -5.41477688e-02f, 2.64343977e-01f,
  -4.52894419e-02f, -7.36020654e-02f, 8.66267681e-02f, -1.30040467e-01f, 3.29595983e-01f, -1.05436563e-01f, -1.56728953e-01f, -1.37293059e-02f, -6.93979338e-02f, 3.07362825e-01f,
  2.79804580e-02f, -8.50953162e-03f, 2.54143536e-01f, -1.60008669e-01f, 2.67333537e-02f, 1.45915836e-01f, -1.60097495e-01f, 2.32457757e-01f, 7.31584653e-02f, -6.79917121e-03f,
  -4.29472297e-01f, 7.67454579e-02f, 2.61753500e-01f, -4.57652025e-02f, -1.40312389e-01f, 4.67434376e-02f, -7.60258222e-03f, -4.31839265e-02f, 3.03296908e-03f, 7.65594468e-02f,
  3.99739519e-02f, 3.07737023e-01f, -1.14218436e-01f, -2.16827542e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.41896708e-02f, 5.48109002e-02f, -7.62930661e-02f, 1.86498329e-01f, 6.56168396e-03f, 1.09323442e-01f, 3.07419062e-01f, 2.99298707e-02f, 8.02046433e-02f, -4.44265641e-02f,
  4.05271687e-02f, -4.24811430e-02f, -1.00875273e-01f, 1.89147562e-01f, 3.33358571e-02f, -9.55742151e-02f, -8.03115293e-02f, -8.62754658e-02f, 2.19858333e-01f, 9.10636485e-02f,
  1.17870644e-01f, -2.44953424e-01f, -3.86768311e-01f, 2.26678416e-01f, 5.89595363e-02f, -8.65886733e-03f, -2.35309660e-01f, -3.90265435e-01f, 1.42513528e-01f, 4.17262642e-03f,
  1.44097015e-01f, -3.90396655e-01f, -1.13879278e-01f, 2.00254545e-01f, 1.16193779e-01f, 3.14332768e-02f, -2.72056520e-01f, 2.79426754e-01f, 9.57615152e-02f, -1.13839388e-01f,
  -3.52876246e-01f, -1.12326592e-01f, 2.74765253e-01f, -1.69187978e-01f, -2.99327243e-02f, 3.36072206e-01f, -1.18174851e-02f, 3.50634903e-02f, 1.33161798e-01f, 3.47729176e-02f,
  2.69356102e-01f, 4.83783260e-02f, 3.44185919e-01f, 4.42419618e-01f, -5.15940264e-02f, 2.07474321e-01f, -5.87420166e-01f, 1.36863992e-01f, -1.60551563e-01f, -6.89281002e-02f,
  -1.84973061e-01f, 3.14357132e-01f, -3.27062786e-01f, 4.87408750e-02f, 2.14132041e-01f, -9.08905715e-02f, -7.23347813e-02f, 6.20070137e-02f, 2.34826684e-01f, 1.03653155e-01f,
  7.35549703e-02f, 2.47249031e-03f, -8.65872875e-02f, -1.25070885e-01f, 1.07172050e-01f, -1.48000062e-01f, 1.34460196e-01f, 5.28668687e-02f, 9.13467780e-02f, 1.67468086e-01f,
  -9.30333510e-02f, 4.33687232e-02f, -2.74714231e-01f, 6.00719810e-01f, -1.56094417e-01f, -1.20420612e-01f, 3.21804099e-02f, 1.21901698e-01f, 1.63439929e-01f, 1.82754740e-01f,
  1.70430355e-02f, 1.99642926e-01f, 2.05220833e-01f, 2.39910409e-02f, -3.90490443e-02f, 7.00396895e-02f, -2.53843814e-01f, 2.05355823e-01f, -5.86643338e-01f, -1.35590792e-01f,
  2.05613136e-01f, -1.12576857e-02f, 9.13865194e-02f, 2.01407284e-01f, -1.45970449e-01f, 4.30869721e-02f, -3.27474594e-01f, -3.91802378e-02f, 7.40587711e-02f, 1.24729216e-01f,
  1.01257905e-01f, 2.73178160e-01f, 1.29135475e-01f, -8.61961544e-02f, 4.55214500e-01f, 1.08138375e-01f, 1.98407978e-01f, -2.22878069e-01f, 3.84944052e-01f, -1.50827706e-01f,
  2.18862116e-01f, -3.23817372e-01f, 4.82010543e-02f, 1.05936892e-01f, 2.38176197e-01f, -1.86981872e-01f, 3.95281225e-01f, -2.46955410e-01f, 2.35678852e-01f, 8.41962248e-02f,
  1.83079377e-01f, 6.75159320e-02f, 8.96892138e-03f, 1.96597919e-01f, -2.93198135e-02f, -1.11661658e-01f, 4.15234007e-02f, -4.38052937e-02f, 9.97361913e-02f, 6.13596998e-02f,
  4.74384874e-01f, 2.45355904e-01f, -2.66931295e-01f, 4.92431633e-02f, 7.06070438e-02f, 3.85987908e-01f, -1.19404025e-01f, 1.28796399e-01f, 1.29046962e-01f, 1.55877694e-01f,
  -2.59596072e-02f, 7.12583736e-02f, 5.25581427e-02f, 1.15568236e-01f, -2.92486280e-01f, 3.85246634e-01f, 1.08459786e-01f, 8.04333240e-02f, -7.25483447e-02f, -1.41656578e-01f,
  -1.39569920e-02f, 6.60473108e-02f, 4.82156835e-02f, -2.21253633e-01f, 5.42405061e-02f, -3.18102151e-01f, 5.24753258e-02f, 1.55718118e-01f, 2.95566767e-01f, 1.34377688e-01f,
  -2.70169467e-01f, -1.90450713e-01f, -3.22613239e-01f, -2.57667929e-01f, 1.15013383e-01f, 2.77551830e-01f, -7.30936527e-02f, -6.52399436e-02f, 2.25755066e-01f, 1.67278573e-01f,
  -1.23314492e-01f, 5.84734865e-02f, 1.50767431e-01f, 7.80730322e-02f, -8.78185704e-02f, -1.80101156e-01f, 1.39426529e-01f, 3.49794000e-01f, 1.10448264e-01f, -2.16845587e-01f,
  -2.48675585e-01f, -3.60862941e-01f, -9.65173468e-02f, 2.09938064e-01f, 1.10774234e-01f, 9.67940241e-02f, -1.93802878e-01f, -3.43021029e-03f, -1.33493260e-01f, 1.86068684e-01f,
  -3.62808667e-02f, 1.14508227e-01f, -1.19364345e-02f, 2.30781913e-01f, -4.73473966e-01f, 8.76764134e-02f, 1.29282191e-01f, 1.08500354e-01f, -3.04885656e-01f, -7.83219635e-02f,
  1.67892605e-01f, -1.59130126e-01f, 2.00284575e-03f, 1.50206657e-02f, -1.86069719e-02f, 1.53596982e-01f, -8.08508247e-02f, 4.23175804e-02f, 9.34761390e-02f, 1.12460122e-01f,
  5.35792932e-02f, -3.06053519e-01f, 2.09937587e-01f, -1.78695545e-01f, 8.51863027e-02f, -2.34565455e-02f, 1.28184110e-01f, 3.35022032e-01f, -1.75365627e-01f, 1.21107034e-01f,
  2.21061725e-02f, -8.26524496e-02f, 4.20641042e-02f, 2.88263023e-01f, 1.23071000e-01f, -2.37737373e-02f, -3.58607858e-01f, -6.17262907e-02f, 3.90129350e-02f, 6.17314279e-02f,
  8.95271525e-02f, 1.03737608e-01f, 6.29821047e-02f, 1.46496028e-01f, -1.64423630e-01f, -2.84063611e-02f, 1.57824457e-02f, 2.62140352e-02f, -2.68803746e-01f, 3.11838806e-01f,
  -1.69725284e-01f, -1.00456864e-01f, 3.02442312e-02f, 1.76254317e-01f, -3.03599238e-01f, 4.38067257e-01f, 1.50789395e-01f, 1.44542992e-01f, 1.23366460e-01f, 3.87621298e-02f,
  -3.61689515e-02f, 1.28520191e-01f, -2.35609245e-02f, 6.91419691e-02f, 1.57780368e-02f, 2.00838968e-01f, -2.26546869e-01f, 2.18738526e-01f, -2.98841894e-01f, 2.64105247e-03f,
  -8.26628208e-02f, 3.09950970e-02f, -2.08550721e-01f, -6.03495613e-02f, -4.15399335e-02f, 1.07399918e-01f, -3.27729923e-03f, -1.74158737e-01f, -2.94005811e-01f, -1.21619105e-01f,
  -2.52008170e-01f, -1.25656500e-01f, -2.89113764e-02f, 3.50008756e-01f, -1.60131633e-01f, -2.14863196e-01f, -9.38152242e-03f, -1.23888813e-01f, 4.41861562e-02f, 6.14033174e-03f,
  1.36437789e-01f, 1.82366177e-01f, -2.41997465e-01f, 6.40202016e-02f, 6.27844334e-02f, 6.61901087e-02f, 1.20225541e-01f, 1.93825245e-01f, 3.90095962e-03f, 3.82821381e-01f,
  -6.03220500e-02f, 3.90693508e-02f, 2.11441875e-01f, 2.45945275e-01f, 1.58655345e-02f, 6.58327714e-02f, 1.26753509e-01f, -6.89930702e-03f, -1.58250675e-01f, -1.32769182e-01f,
  2.46918611e-02f, -1.65248066e-01f, -7.53739625e-02f, 8.74218419e-02f, -7.69023895e-02f, 3.87246497e-02f, 4.69970316e-01f, 2.90618867e-01f, 1.93678677e-01f, 2.23710597e-01f,
  9.15448647e-03f, 1.88724428e-01f, 1.41701683e-01f, 5.46088926e-02f, -1.33152306e-01f, 5.76776527e-02f, -1.65610984e-01f, -3.69632930e-01f, -8.99212435e-02f, -4.15805764e-02f,
  -7.23656788e-02f, -1.46967381e-01f, 1.97705984e-01f, 1.54971004e-01f, -1.14738561e-01f, -1.38061181e-01f, 3.95299941e-01f, 2.24097133e-01f, 1.08144797e-01f, 5.79856560e-02f,
  2.96531290e-01f, 1.20433509e-01f, 7.30231255e-02f, -1.91923812e-01f, 7.52256960e-02f, 6.11925311e-02f, -2.23258525e-01f, 3.49096060e-02f, 3.30515862e-01f, 7.89757296e-02f,
  5.80738939e-04f, 8.23780894e-02f, 2.35972703e-01f, 1.35386838e-02f, 6.27056241e-01f, -2.10914224e-01f, 2.74696082e-01f, 9.54694673e-02f, -1.06825627e-01f, 1.39967203e-01f,
  4.70080823e-01f, 1.36832416e-01f, 5.07055461e-01f, -1.11317798e-01f, -7.90851712e-02f, -4.50803548e-01f, -1.97056219e-01f, 3.14414561e-01f, 1.84139386e-01f, -1.72494277e-01f,
  3.42896670e-01f, 2.20828876e-01f, -8.18341076e-02f, -2.21386869e-02f, 4.48483601e-02f, 1.30250499e-01f, -7.12400069e-03f, -1.94184333e-01f, 2.99188614e-01f, 6.45179898e-02f,
  -1.61998317e-01f, -1.36615470e-01f, -1.97480410e-01f, -1.78581521e-01f, -1.76435150e-02f, 6.24151602e-02f, 3.15648727e-02f, 3.33048254e-02f, -5.78934215e-02f, 2.16645580e-02f,
  3.27435620e-02f, -1.16875172e-01f, -8.46792683e-02f, 2.70948913e-02f, 9.30995680e-03f, -5.22520393e-02f, 1.59789935e-01f, 3.45317185e-01f, 2.28286356e-01f, -2.48741165e-01f,
  5.37291095e-02f, -9.87117067e-02f, 9.22430083e-02f, -1.28982976e-01f, 1.60764068e-01f, 3.81130099e-01f, 5.17881848e-02f, -2.63619125e-01f, 3.66750658e-01f, -6.68346230e-03f,
  -3.17186024e-03f, 1.34632528e-01f, 1.27230197e-01f, 1.30093768e-01f, -1.81234688e-01f, 4.50899184e-01f, 1.21815659e-01f, -6.35422245e-02f, -1.43747583e-01f, 2.29673281e-01f,
  -3.75553407e-02f, -1.01967715e-01f, -4.19443026e-02f, -2.43272647e-01f, -4.20752019e-02f, -5.66942915e-02f, -1.56727433e-01f, 2.29792714e-01f, -9.69908088e-02f, 6.74910620e-02f,
  -1.39489010e-01f, -5.74093894e-04f, -3.36418450e-01f, 4.04347152e-01f, -2.02000551e-02f, 3.31847399e-01f, -3.22463721e-01f, -5.82834809e-06f, -5.03695272e-02f, 4.86759603e-01f,
  3.81094180e-02f, 2.05993950e-01f, 1.02774963e-01f, 4.06211525e-01f, -1.19077004e-02f, -3.15684974e-01f, 8.23847076e-04f, 6.94704130e-02f, 2.97851544e-02f, 3.38907123e-01f,
  1.80960372e-01f, 2.12929636e-01f, 2.44000077e-01f, 9.88052338e-02f, -1.19872853e-01f, 1.35065660e-01f, -3.28898460e-01f, -9.10101160e-02f, 1.37175405e-02f, -6.07513562e-02f,
  -6.61151484e-02f, -4.15572934e-02f, -1.23403646e-01f, 1.72264040e-01f, 2.43354529e-01f, 4.86732334e-01f, -2.43853945e-02f, 6.31206751e-01f, -1.01564497e-01f, -1.21564038e-01f,
  -2.56380975e-01f, 1.88031569e-01f, -2.93155491e-01f, 1.65164977e-01f, 3.14129442e-01f, -7.48499334e-02f, -8.56200382e-02f, -1.33754313e-01f, -2.20918298e-01f, -4.84581366e-02f,
  1.26114964e-01f, -7.29954392e-02f, -1.18422076e-01f, -1.03448167e-01f, -2.37337619e-01f, -6.86682910e-02f, -3.36073071e-01f, -4.94504198e-02f, 1.48046494e-01f, -1.54361771e-02f,
  -2.03929931e-01f, 2.95417577e-01f, 7.33635500e-02f, -4.26318720e-02f, -4.77658436e-02f, -3.42411436e-02f, 2.46168464e-01f, -5.41602373e-02f, -2.31525842e-02f, 7.22245649e-02f,
  3.84274811e-01f, 3.21968310e-02f, 9.97957140e-02f, -3.08471471e-01f, 2.42794335e-01f, -8.57718736e-02f, 5.98845482e-02f, -1.78126432e-02f, -1.71066433e-01f, -1.66190881e-02f,
  4.38598096e-01f, 2.48337433e-01f, 6.24805763e-02f, 2.12581843e-01f, 2.28110179e-01f, 1.12258136e-01f, 1.42038077e-01f, -6.60889074e-02f, -7.29860440e-02f, -1.63918018e-01f,
  3.77027132e-02f, -2.79381964e-02f, -1.05668403e-01f, -2.30767757e-01f, 5.93722519e-03f, 1.34848058e-01f, 6.83657825e-02f, -2.35789865e-01f, 6.52836263e-03f, -1.98886171e-01f,
  3.32128465e-01f, -3.24464321e-01f, 1.31446555e-01f, 4.47184861e-01f, 3.76914352e-01f, -3.21696490e-01f, -3.61358337e-02f, -2.04084888e-01f, 1.06758192e-01f, 4.15204205e-02f,
  5.84075181e-03f, 1.77790701e-01f, -4.76265028e-02f, 5.19618876e-02f, 2.73379296e-01f, -1.42686367e-01f, 5.20461380e-01f, 3.41424584e-01f, 2.76936647e-02f, 1.42417043e-01f,
  -1.33736566e-01f, 1.40148327e-01f, 6.99808896e-02f, 1.51395071e-02f, 2.52919018e-01f, 2.80256033e-01f, 1.66888624e-01f, -1.75230559e-02f, -1.20952852e-01f, 1.49565279e-01f,
  4.71781082e-02f, 2.17214510e-01f, 4.44631726e-02f, 7.99860582e-02f, -3.18306714e-01f, -2.09912047e-01f, -4.58727181e-02f, 4.08737659e-01f, -1.18182167e-01f, 1.20094977e-01f,
  2.33240083e-01f, 2.67262578e-01f, 4.63063642e-02f, 4.47731428e-02f, -5.63728139e-02f, 2.80345112e-01f, 1.58374250e-01f, 2.14993153e-02f, 1.22870229e-01f, 1.06118843e-01f,
  8.49616155e-02f, 6.85304925e-02f, 1.17403470e-01f, 3.44797485e-02f, 1.49414435e-01f, 6.42893538e-02f, -1.08703032e-01f, -1.25427507e-02f, 2.12918848e-01f, 4.33647335e-01f,
  -1.60317108e-01f, 3.62469107e-01f, 8.39678571e-02f, 5.52655011e-02f, -1.34344056e-01f, -2.16136351e-01f, -1.88571587e-02f, 3.29820603e-01f, 8.70955065e-02f, -5.07738665e-02f,
  7.69535452e-03f, 2.21521452e-01f, -4.67799306e-01f, 4.90755498e-01f, 1.85918175e-02f, 2.59186715e-01f, -7.80683057e-03f, -2.81509727e-01f, 3.65954012e-01f, -9.72019061e-02f,
  -3.96087199e-01f, 2.44562224e-01f, -1.79406673e-01f, -2.97076255e-01f, -1.25373393e-01f, -1.93163962e-03f, -9.36218444e-03f, 2.06475377e-01f, -3.73228163e-01f, 9.05518755e-02f,
  -5.48158348e-01f, -1.94368482e-01f, 1.01090759e-01f, 1.20751806e-01f, -3.02479088e-01f, 2.73818225e-01f, -1.32395655e-01f, 1.40397266e-01f, 1.71823516e-01f, -2.43496403e-01f,
  3.85676086e-01f, 2.47913048e-01f, -4.47377443e-01f, 1.84884876e-01f, -4.77980785e-02f, 1.42963991e-01f, 2.56324947e-01f, -1.22492768e-01f, -3.53241473e-01f, 2.26147160e-01f,
  -8.62391591e-02f, -8.03458691e-02f, -1.31551415e-01f, 2.03231256e-02f, 1.69899493e-01f, -2.33732499e-02f, -2.08996441e-02f, -6.94938526e-02f, 6.77186400e-02f, 1.51786670e-01f,
  -4.12653713e-03f, -1.19174793e-01f, -1.64383296e-02f, -1.52160197e-01f, 5.51036559e-03f, -1.35300756e-01f, -2.78689057e-01f, 2.82728858e-02f, 2.72432417e-02f, 3.58699113e-01f,
  1.49509400e-01f, -1.30535632e-01f, -4.22367230e-02f, -1.12596005e-01f, 1.31901816e-01f, 2.18839031e-02f, 2.04394117e-01f, 1.00448513e-02f, 1.04738131e-01f, -1.10986784e-01f,
  -5.18954098e-02f, 6.67480975e-02f, 3.00272964e-02f, 1.24308042e-01f, 4.64031935e-01f, -1.60537899e-01f, 3.61862391e-01f, 2.85243064e-01f, 9.08541754e-02f, 2.00310290e-01f,
  1.81583405e-01f, -1.36435866e-01f, 2.59664178e-01f, -1.56635925e-01f, 4.79203820e-01f, 6.68755174e-02f, 1.23605505e-01f, 1.12509996e-01f, 2.69050717e-01f, -1.28762856e-01f,
  3.92460316e-01f, 1.40814260e-01f, 7.18524531e-02f, -1.29248530e-01f, 1.62382126e-01f, -2.14866206e-01f, 3.06757390e-01f, -2.82854527e-01f, 1.15059122e-01f, -9.63339508e-02f,
  3.43917720e-02f, 4.79307063e-02f, 4.04629141e-01f, -3.64603311e-01f, 3.47575136e-02f, 2.38396361e-01f, 2.91726198e-02f, 1.45700544e-01f, 1.32020146e-01f, 3.64770018e-03f,
  -2.02167816e-02f, 1.74736995e-02f, -1.01616532e-01f, 1.07983366e-01f, -3.69468071e-02f, 1.53899133e-01f, 1.89362705e-01f, -1.43885553e-01f, 1.39669046e-01f, 1.46451727e-01f,
  3.66993725e-01f, 1.07800655e-01f, 2.78287053e-01f, -5.56847990e-01f, 2.22481862e-02f, 1.64805993e-01f, 1.36840299e-01f, 2.47424871e-01f, -9.85605717e-02f, -1.44449100e-01f,
  1.98309449e-03f, -9.13967565e-02f, -1.83413938e-01f, 1.74220771e-01f, 6.94521517e-02f, 1.59875944e-01f, 1.42612338e-01f, 6.01239949e-02f, 4.87909257e-01f, 7.87940100e-02f,
  5.14610596e-02f, 2.55491495e-01f, 7.89316185e-03f, -1.44137770e-01f, 2.23438501e-01f, -4.18958738e-02f, 4.35124159e-01f, 9.96989906e-02f, 2.86752164e-01f, 1.89628646e-01f,
  -3.75789404e-02f, -1.06896564e-01f, 3.26724768e-01f, 1.81292638e-01f, -4.22030866e-01f, -1.45323545e-01f, 1.63461968e-01f, 2.83786893e-01f, -2.05138624e-01f, 2.07759693e-01f,
  1.67022571e-02f, 3.96511197e-01f, -4.82463837e-02f, 1.34592593e-01f, -2.77613968e-01f, 4.45706457e-01f, 3.67666557e-02f, -7.79922530e-02f, 1.07579380e-01f, -6.44361973e-02f,
  9.81447622e-02f, 9.19634625e-02f, 1.29549026e-01f, 6.50835559e-02f, 1.57862037e-01f, 7.02959076e-02f, -6.36585057e-02f, 3.03598139e-02f, -9.02116746e-02f, -1.62550285e-01f,
  3.53153311e-02f, 1.52674004e-01f, 1.53823778e-01f, -3.68195444e-01f, -1.30340802e-02f, -4.90289181e-02f, -2.17964619e-01f, 2.84480125e-01f, 8.39872509e-02f, 7.13054389e-02f,
  1.05907008e-01f, -2.09720537e-01f, 3.03212464e-01f, 2.45023265e-01f, 1.32897720e-01f, 1.62313640e-01f, 4.02242690e-01f, -2.53508300e-01f, 4.41269241e-02f, 3.51980656e-01f,
  -1.08055472e-01f, 3.61411250e-03f, 1.95765421e-02f, 2.19398335e-01f, 3.81667912e-02f, 1.18008517e-02f, 1.16812326e-02f, 1.89671576e-01f, -2.77217012e-02f, 1.70387208e-01f,
  -1.06208660e-01f, 2.25897636e-02f, 1.20111890e-01f, -1.83197603e-01f, -2.63920408e-02f, 2.18774572e-01f, -5.51657714e-02f, 9.63098481e-02f, 4.78788853e-01f, 1.49986401e-01f,
  -3.48454028e-01f, 6.34185821e-02f, 5.23242028e-03f, 9.43761766e-02f, 2.89018750e-01f, -1.70227453e-01f, 1.53971627e-01f, 3.01678002e-01f, -1.73467770e-01f, -3.93824100e-01f,
  1.00655623e-01f, 6.36391155e-03f, -1.06388591e-01f, -1.18505850e-01f, -8.89729634e-02f, 7.56115019e-02f, 1.59638956e-01f, 1.00147709e-01f, 5.11164032e-02f, 1.10305715e-02f,
  7.77306780e-03f, -1.28957346e-01f, -4.67233695e-02f, -1.64965123e-01f, -2.83172820e-02f, -6.27620965e-02f, 1.53440222e-01f, -8.76603797e-02f, 1.18538275e-01f, 1.60324067e-01f,
  -2.00259462e-01f, 3.72009128e-01f, 2.86725182e-02f, -2.98803806e-01f, -1.62646510e-02f, 7.97147378e-02f, 1.13178432e-01f, 7.69692883e-02f, 2.66968310e-01f, 8.78054053e-02f,
  2.30215043e-01f, -1.82121158e-01f, -6.87761884e-03f, 9.47674289e-02f, -3.85624841e-02f, 4.37979177e-02f, 2.01315433e-01f, -5.69564961e-02f, 2.88592458e-01f, 2.38655880e-03f,
  7.31387436e-02f, 5.99682517e-02f, 1.10888228e-01f, -3.41863520e-02f, -5.47607914e-02f, -8.40693563e-02f, 1.92381471e-01f, 4.14559022e-02f, -1.62723828e-02f, 3.71108145e-01f,
  1.51079357e-01f, -8.26049596e-02f, 3.89207959e-01f, 5.89291975e-02f, 2.20507935e-01f, -1.48187697e-01f, 1.92164823e-01f, -3.80525023e-01f, 3.33910555e-01f, -2.92450011e-01f,
  6.75391115e-04f, -9.56628546e-02f, 1.14521407e-01f, -9.81663913e-02f, 2.72231191e-01f, -2.48388976e-01f, 1.37990415e-01f, 1.61318660e-01f, 1.62636772e-01f, 8.47048312e-02f,
  8.48084018e-02f, 1.34329796e-02f, 1.39508739e-01f, -2.24772498e-01f, 7.90744498e-02f, 2.92560339e-01f, -1.71167165e-01f, -1.55111358e-01f, 1.68046728e-01f, 2.60418713e-01f,
  3.26633900e-02f, 2.96328068e-01f, 2.58285757e-02f, 7.38713518e-02f, -3.31087201e-03f, -1.00767851e-01f, 1.99705273e-01f, 3.12208146e-01f, 2.00369149e-01f, -1.69294745e-01f,
  -8.34679082e-02f, 1.67878225e-01f, -1.90543011e-01f, 3.22200894e-01f, 1.00061171e-01f, 3.34690571e-01f, 1.59986123e-01f, -2.00413167e-01f, 1.92975625e-01f, -9.51506197e-02f,
  4.06052405e-03f, 2.15858489e-01f, -2.19575897e-01f, -2.65959829e-01f, -6.01651222e-02f, 2.08740413e-01f, -1.23877577e-01f, 3.22837442e-01f, 1.29338607e-01f, 2.26792261e-01f,
  -3.10363621e-01f, -4.47522998e-01f, -2.68191262e-03f, 2.40138605e-01f, -1.68021560e-01f, 1.86203852e-01f, -2.07994789e-01f, 1.33190170e-01f, 1.41077533e-01f, -8.60157516e-03f,
  5.86043596e-02f, 4.14603829e-01f, -2.39063457e-01f, 5.98981827e-02f, 2.97715783e-01f, 1.90590248e-01f, 2.76408732e-01f, -1.99028298e-01f, -2.40851313e-01f, 2.95695275e-01f,
  -9.05197766e-03f, 1.39348465e-03f, 6.06250092e-02f, 9.27329361e-02f, 2.92974323e-01f, -1.14488341e-02f, -9.61696208e-02f, -3.01559679e-02f, -8.58855173e-02f, -4.22124863e-02f,
  1.42482482e-02f, -1.01897232e-02f, 2.08662659e-01f, -3.31646204e-01f, 9.37464461e-02f, -1.43779263e-01f, 2.33429879e-01f, 8.95116776e-02f, 1.23829871e-01f, 3.34048033e-01f,
  -1.80804074e-01f, -8.39596912e-02f, 1.41150922e-01f, -2.02148240e-02f, 4.13949862e-02f, 3.97392139e-02f, 3.18778425e-01f, 7.30827153e-02f, -1.78081870e-01f, -3.60069335e-01f,
  -4.21944141e-01f, 3.85267317e-01f, 2.47305166e-03f, -2.39696223e-02f, 3.55614394e-01f, 5.65993451e-02f, 2.74568766e-01f, 2.84928143e-01f, 1.01878770e-01f, 6.90277591e-02f,
  2.95648456e-01f, -3.12665164e-01f, -1.67980492e-01f, 3.26976553e-02f, 4.84415352e-01f, 5.37254751e-01f, 1.34895772e-01f, -2.89647430e-01f, 2.48814121e-01f, 2.00807787e-02f,
  2.66553491e-01f, -2.31026068e-01f, 2.40259200e-01f, -7.71985203e-02f, -2.67675077e-03f, -1.16523489e-01f, 3.82873565e-01f, -4.71211597e-02f, -5.10673895e-02f, -2.60978770e-02f,
  -1.82253674e-01f, 1.57719463e-01f, 3.63979876e-01f, -2.85897851e-01f, -2.22377367e-02f, 1.41751841e-01f, 6.15127161e-02f, 1.20348465e-02f, -3.00075840e-02f, -7.87788723e-03f,
  -1.78976715e-01f, -1.03536151e-01f, 2.57280078e-02f, 1.52402923e-01f, 6.02908954e-02f, 1.42195314e-01f, -3.08125287e-01f, -3.55278730e-01f, 1.47113249e-01f, -1.52690500e-01f,
  -6.75514638e-02f, -4.53156739e-01f, 3.86537850e-01f, -3.26676816e-01f, 2.06235692e-01f, 2.85028201e-02f, 2.51439810e-01f, -2.02049941e-01f, 1.33233750e-02f, -2.77046800e-01f,
  2.28451550e-01f, -6.40831366e-02f, -1.27482742e-01f, -1.02001742e-01f, 2.36541331e-02f, 1.83895722e-01f, 4.87501353e-01f, -1.01698324e-01f, 5.50027013e-01f, 1.94463328e-01f,
  1.79998532e-01f, 4.14711386e-01f, -1.10585615e-01f, 1.91946536e-01f, 1.44182533e-01f, 2.04550073e-01f, 6.57114446e-01f, 6.66403538e-03f, 3.94599259e-01f, 1.32324472e-01f,
  -1.86754316e-01f, 2.04743937e-01f, 5.14095664e-01f, -1.65151030e-01f, -1.47460565e-01f, -1.22463731e-02f, 2.45839786e-02f, -1.02759972e-01f, 3.07051502e-02f, 1.04724407e-01f,
  5.51259369e-02f, 8.41110200e-02f, 2.94333301e-03f, -1.65399462e-01f, 4.80777174e-02f, 3.01597744e-01f, 1.83007091e-01f, 2.37041935e-01f, -1.02763191e-01f, 1.11460369e-02f,
  1.27705693e-01f, 3.05178128e-02f, 1.38088852e-01f, 1.14636496e-01f, -9.80885178e-02f, -1.04935968e-03f, -2.41148681e-03f, 9.91559252e-02f, -1.69952344e-02f, -1.91385131e-02f,
  3.55547220e-01f, 3.33060831e-01f, -3.00907902e-02f, 1.35635436e-01f, -2.64349878e-01f, 1.16987266e-01f, -1.92980483e-01f, 4.30304497e-01f, -7.21106827e-02f, 1.77351803e-01f,
  1.23217478e-01f, -5.83759770e-02f, 1.87849075e-01f, 3.23218733e-01f, 2.18177922e-02f, -4.83701788e-02f, 1.59001559e-01f, 2.33778492e-01f, -5.44056185e-02f, 9.53656510e-02f,
  -2.25119606e-01f, 9.26176608e-02f, -2.58462340e-01f, 1.83678374e-01f, 3.13507110e-01f, -8.49892721e-02f, -5.28086536e-02f, -1.18756965e-01f, 1.84703574e-01f, -9.35054198e-02f,
  -3.75080109e-01f, 2.96148747e-01f, 1.49975672e-01f, 3.16472113e-01f, 1.27312958e-01f, -3.03775430e-01f, 2.15600012e-03f, 3.31672430e-01f, 3.36546630e-01f, 2.07018271e-01f,
  -2.42936224e-01f, -9.92361605e-02f, 1.78392589e-01f, 1.87564135e-01f, -9.61190313e-02f, 1.75049156e-01f, 7.20321760e-02f, 3.78850996e-01f, -3.09062660e-01f, -1.55566126e-01f,
  2.92728186e-01f, -8.16459358e-02f, 5.28945774e-02f, 9.45938472e-03f, -1.13064550e-01f, 2.17587933e-01f, 1.69877950e-02f, 1.43702412e-02f, 3.69559154e-02f, -6.05739430e-02f,
  -2.08013901e-03f, -1.07618853e-01f, 5.26544899e-02f, 1.95004679e-02f, 2.81970650e-01f, 2.26869777e-01f, -8.71036872e-02f, -6.16290383e-02f, -1.69154868e-01f, 3.18214893e-02f,
  5.13934232e-02f, 1.26881033e-01f, 2.60422230e-01f, -3.68562266e-02f, 1.56438768e-01f, 1.38425216e-01f, 1.99681580e-01f, 3.01200241e-01f, -1.08293677e-02f, 1.28175830e-03f,
  1.46668315e-01f, -1.80798378e-02f, 1.19288631e-01f, 1.19792357e-01f, -1.58117443e-01f, -4.21041250e-02f, 2.64180899e-01f, 3.93984206e-02f, 1.59083962e-01f, -5.71346171e-02f,
  -2.32833028e-02f, -4.31906618e-02f, 3.24775845e-01f, 7.91079849e-02f, 9.48893093e-03f, -2.72702307e-01f, 1.27405658e-01f, 1.82324141e-01f, -1.45507627e-03f, 8.50165635e-02f,
  1.32811859e-01f, 2.39577293e-01f, 4.97101963e-01f, 2.22578615e-01f, -1.78447008e-01f, 7.23903552e-02f, -9.05630961e-02f, -4.98659350e-03f, 1.45775527e-01f, 2.66455978e-01f,
  -6.74120486e-02f, 2.71300852e-01f, -4.18911725e-01f, 2.26095811e-01f, -1.45472527e-01f, -2.77502716e-01f, 2.02893063e-01f, 2.07139835e-01f, 6.09244630e-02f, 8.27610046e-02f,
  2.60153174e-01f, 1.24792211e-01f, 1.38439938e-01f, 4.43470366e-02f, 1.13729285e-02f, 1.04329670e-02f, 1.20373942e-01f, 2.31960951e-03f, 2.98064891e-02f, -1.34837851e-01f,
  -5.50484098e-02f, 3.43576610e-01f, 2.81933904e-01f, 2.78762102e-01f, 1.80980675e-02f, 4.85173851e-01f, 8.65730718e-02f, -3.79337817e-01f, -4.59799245e-02f, 5.00112064e-02f,
  -8.39669704e-02f, 2.25711823e-01f, 1.01196997e-01f, 4.04464379e-02f, -2.13397164e-02f, 9.37751904e-02f, -5.43623120e-02f, -1.25308707e-01f, 3.50260973e-01f, 6.25794530e-02f,
  5.41900337e-01f, -2.44901597e-01f, -1.43862388e-03f, 1.17677905e-01f, 7.91567415e-02f, 2.07267031e-01f, -4.91086356e-02f, 6.72867894e-02f, 1.72425807e-01f, -1.45673975e-01f,
  2.82791167e-01f, 2.92111278e-01f, -1.73496515e-01f, 1.33612618e-01f, 4.13808793e-01f, -3.25056821e-01f, -9.64227095e-02f, -1.69831261e-01f, 5.00894666e-01f, 5.13366498e-02f,
  -1.81894284e-02f, -3.09756547e-01f, 5.90129085e-02f, -1.79314077e-01f, 3.16307545e-02f, -1.17715940e-01f, 2.64693648e-01f, 3.46168399e-01f, 1.50246233e-01f, -2.00759143e-01f,
  2.83537041e-02f, -6.46516564e-04f, 1.96255401e-01f, 1.47896141e-01f, 3.27220522e-02f, 4.98156250e-02f, 3.64469215e-02f, 1.63540021e-01f, 1.89145263e-02f, 1.29061369e-02f,
  -5.53209893e-02f, 6.97521344e-02f, 2.55822748e-01f, 1.54711515e-01f, 2.07739547e-01f, 1.22252796e-02f, 1.16214402e-01f, 9.43237990e-02f, -2.91145816e-02f, -2.63182878e-01f,
  1.07654803e-01f, 3.40463787e-01f, 6.16265200e-02f, -1.13785051e-01f, -7.26531520e-02f, -7.89249837e-02f, 4.14094441e-02f, 1.91464707e-01f, 1.59848835e-02f, -6.21707477e-02f,
  -7.08041489e-02f, 3.16244304e-01f, 2.95444578e-02f, -3.77909541e-02f, 2.09869355e-01f, 3.28479201e-01f, -2.05236629e-01f, -2.26387575e-01f, -1.15339868e-01f, 8.74868706e-02f,
  3.47689301e-01f, -2.90459208e-02f, -2.78011203e-01f, 9.97820199e-02f, 2.83200592e-02f, -2.53972501e-01f, 1.41316310e-01f, 6.32073283e-02f, -3.13028604e-01f, 3.81227344e-01f,
  1.35134580e-02f, 9.16137695e-02f, -1.87546402e-01f, -8.40396993e-03f, 5.03262766e-02f, 1.20534673e-01f, 2.07466006e-01f, 1.63039669e-01f, 4.20557633e-02f, 2.00346053e-01f,
  1.83777303e-01f, -2.29933262e-01f, -1.33727759e-01f, 2.20386580e-01f, 1.40892029e-01f, 4.40749824e-02f, 5.92431687e-02f, 1.19648926e-01f, -6.40598312e-02f, 7.82947466e-02f,
  2.03714132e-01f, 2.55969882e-01f, -4.52928953e-02f, -4.76211570e-02f, 1.63737714e-01f, 2.56996006e-01f, -3.56176883e-01f, -1.98828697e-01f, -1.95778027e-01f, -2.47975923e-02f,
  -3.61072809e-01f, -1.13258898e-01f, 2.48504095e-02f, -6.08711392e-02f, 1.87810212e-01f, -3.08217146e-02f, -3.30493510e-01f, 2.71420717e-01f, -9.91409123e-02f, 2.26642517e-03f,
  -1.13053344e-01f, -1.88881561e-01f, 2.23962497e-02f, 4.72365394e-02f, 3.07573140e-01f, -1.25683799e-01f, -2.54447192e-01f, 3.81003097e-02f, -7.31379613e-02f, 1.06681019e-01f,
  -3.03611994e-01f, 2.50519723e-01f, 5.70516624e-02f, -7.53276423e-02f, -3.81892323e-01f, 1.35666817e-01f, 2.93922216e-01f, -1.43982172e-01f, -9.04925093e-02f, 9.02170986e-02f,
  -3.89779322e-02f, -9.47733074e-02f, 2.00326368e-01f, 2.70396560e-01f, 2.61277765e-01f, 9.03426036e-02f, -5.49733676e-02f, 3.52538049e-01f, -1.01384260e-01f, 9.36480612e-02f,
  -2.74837554e-01f, 1.67555705e-01f, -2.44777516e-01f, 1.37069181e-01f, -4.01646763e-01f, 3.19902956e-01f, -1.73586249e-01f, -9.93603542e-02f, 8.38624164e-02f, 1.89141408e-01f,
  1.68319389e-01f, 1.66078031e-01f, 1.64212599e-01f, 1.59506336e-01f, 1.32951826e-01f, 1.15457281e-01f, -7.55735040e-02f, 1.11096412e-01f, 7.47569725e-02f, 3.03218570e-02f,
  2.30786085e-01f, 2.34091595e-01f, 1.02183722e-01f, 3.55954826e-01f, 1.67208165e-01f, 1.99840292e-01f, -1.31517351e-01f, -5.16957454e-02f, -3.97733562e-02f, 1.95883662e-01f,
  -1.13329226e-02f, 2.26860702e-01f, -1.45058662e-01f, -3.78062227e-03f, 1.29550114e-01f, -1.96161017e-01f, -4.03878838e-03f, 1.58307597e-01f, 7.31532928e-03f, 5.02183251e-02f,
  1.28484532e-01f, -2.11403593e-02f, -2.21259773e-01f, 2.55593777e-01f, -1.94184348e-01f, -1.31340921e-01f, -1.03231445e-01f, -1.57879606e-01f, 5.13828453e-03f, 1.03405692e-01f,
  -3.35124224e-01f, 1.12032332e-01f, 3.02735399e-02f, 2.87748337e-01f, -3.90784442e-02f, -1.17697410e-01f, -8.56260136e-02f, 2.63752550e-01f, -2.80986786e-01f, 1.36270970e-01f,
  2.87979692e-01f, -7.92324021e-02f, -3.13343853e-02f, 2.77155101e-01f, -5.50176110e-03f, 2.13269770e-01f, -1.85404807e-01f, 2.12004930e-01f, -1.05394796e-02f, 5.81651218e-02f,
  1.32879898e-01f, 4.12869751e-01f, -9.48490351e-02f, -3.26195508e-02f, -1.32456040e-02f, -6.12490289e-02f, 1.51037186e-01f, 4.65804338e-02f, 6.44146279e-02f, -5.21588139e-02f,
  1.62027746e-01f, -5.11644445e-02f, -1.28572986e-01f, -4.51063067e-02f, -9.75486562e-02f, -5.82299344e-02f, 8.74023959e-02f, -8.81089792e-02f, -4.38434677e-03f, -1.64376780e-01f,
  1.25882864e-01f, 6.42210767e-02f, 2.22316831e-02f, 1.44248173e-01f, 2.21738294e-01f, 6.35469705e-02f, 2.29448900e-01f, 3.92145030e-02f, 6.30519912e-02f, -2.72909850e-01f,
  2.23167509e-01f, 2.60226596e-02f, 1.04291409e-01f, 2.60353703e-02f, -1.20218083e-01f, -5.74001372e-02f, 4.68675867e-02f, 3.33786756e-01f, 2.62239993e-01f, 2.56083280e-01f,
  6.79919347e-02f, -1.16025992e-01f, 1.13679335e-01f, 4.17004861e-02f, 3.43353391e-01f, 1.87252089e-01f, -4.25805673e-02f, -1.89631864e-01f, -1.09432731e-02f, -1.50109723e-01f,
  -3.78641859e-02f, 1.92883745e-01f, 2.56214559e-01f, 3.19800258e-01f, -3.44839424e-01f, 1.52883098e-01f, 9.32350904e-02f, 2.28062853e-01f, 4.15130779e-02f, 4.53775749e-02f,
  -1.79095063e-02f, -4.07725759e-02f, -3.43712896e-01f, -9.77173224e-02f, 1.50277466e-01f, 2.41658330e-01f, -1.76146291e-02f, 5.85510442e-03f, 8.16888958e-02f, 7.82225877e-02f,
  3.04915786e-01f, 1.78654760e-01f, 1.39174983e-01f, 5.13006561e-02f, 6.23941701e-03f, -4.56747524e-02f, 5.96112460e-02f, 3.06439400e-02f, 1.86496556e-01f, 1.82438031e-01f,
  4.33629788e-02f, 7.48157203e-02f, 1.07611321e-01f, 1.48428664e-01f, -1.62728265e-01f, 3.82785887e-01f, -3.29314284e-02f, 1.57854840e-01f, 1.24131655e-02f, 1.47429124e-01f,
  2.16194510e-01f, 2.30381981e-01f, 1.48883581e-01f, -3.64570762e-03f, 2.17333063e-01f, 1.65873975e-01f, -1.62423048e-02f, 1.71734795e-01f, -1.24532208e-01f, 8.27800930e-02f,
  -5.58402479e-01f, 1.66676655e-01f, 1.08212419e-01f, -1.12171568e-01f, 5.19238524e-02f, -2.13051096e-01f, 1.25009462e-01f, -4.26554680e-02f, -4.35007095e-01f, 2.11733982e-01f,
  -1.04580075e-01f, -9.63707119e-02f, -1.40138241e-02f, -1.15420468e-01f, -2.49123812e-01f, 2.33994335e-01f, 1.87279224e-01f, 1.05184868e-01f, 7.74293095e-02f, 4.04433236e-02f,
  2.26765037e-01f, 2.30730057e-01f, 2.02238575e-01f, 4.45050709e-02f, 1.85285453e-02f, 2.36909583e-01f, 2.10433751e-02f, -1.04505457e-01f, 3.08879972e-01f, 8.34498480e-02f,
  1.69339538e-01f, 8.01887084e-03f, -3.23644429e-02f, 8.09727833e-02f, -5.61217591e-02f, 2.12782755e-01f, 1.19748339e-01f, -5.53658567e-02f, -6.85104132e-02f, 3.37990874e-04f,
  -9.90527645e-02f, -2.62189955e-02f, 3.57762665e-01f, 2.65156925e-01f, 7.23293126e-02f, -9.12994593e-02f, 1.67397782e-01f, 2.08918646e-01f, -1.35475591e-01f, 2.56716549e-01f,
  2.63313532e-01f, 1.50196880e-01f, -6.71862438e-02f, -9.97532308e-02f, 2.62458414e-01f, 7.99100921e-02f, -2.17447028e-01f, 3.11299473e-01f, 2.43340105e-01f, 4.37285472e-03f,
  5.41886874e-02f, -1.00699998e-01f, -2.36358400e-02f, 1.46380335e-01f, -2.71083042e-02f, -1.31918639e-01f, -3.16349342e-02f, -2.68632084e-01f, -1.64760828e-01f, 3.05714458e-01f,
  2.23175123e-01f, 1.45939261e-01f, -2.75732279e-01f, -1.06321506e-01f, -2.42638424e-01f, -9.38448608e-02f, -1.05903633e-01f, 4.79204565e-01f, -2.91939616e-01f, 4.34949137e-02f,
  3.27649862e-01f, 1.88634787e-02f, -1.43073767e-01f, -6.74971100e-03f, 2.60893136e-01f, 1.36395231e-01f, 2.43724152e-01f, -3.33716571e-01f, 2.14964837e-01f, 4.39279348e-01f,
  1.60489723e-01f, -2.32078791e-01f, -9.91573334e-02f, -2.44062975e-01f, 1.71261325e-01f, 1.25313222e-01f, -1.41308501e-01f, -9.20045972e-02f, 9.16378647e-02f, 1.92397028e-01f,
  1.06380664e-01f, -1.33599520e-01f, -2.24523917e-01f, -1.06490225e-01f, -2.37196147e-01f, -5.34768440e-02f, -1.29239755e-02f, 1.08287953e-01f, 1.51515976e-01f, -2.40061969e-01f,
  -3.13288480e-01f, 1.73265841e-02f, -1.79168954e-01f, 5.32443404e-01f, 1.05747372e-01f, -7.82797858e-02f, -4.44058552e-02f, -2.40147337e-01f, 2.60033101e-01f, 8.08782354e-02f,
  -1.40772182e-02f, 8.86298809e-03f, 2.63071656e-01f, -7.16406330e-02f, 1.58261597e-01f, -1.57475844e-01f, -1.55358389e-01f, 1.79395780e-01f, 1.21680588e-01f, 2.61100773e-02f,
  2.37219959e-01f, -8.04723352e-02f, -1.44683272e-01f, 3.58768314e-01f, -9.48324725e-02f, 1.36619240e-01f, -7.14751240e-03f, 1.52211951e-03f, 2.25516811e-01f, 1.46440580e-01f,
  -6.31486624e-02f, 3.00363183e-01f, 2.39333406e-01f, 1.56514242e-01f, 4.74703550e-01f, -8.18479247e-03f, 8.40324610e-02f, -6.69110268e-02f, -6.06475770e-02f, -9.51980054e-02f,
  1.42358601e-01f, -2.24309742e-01f, 1.96903810e-01f, 1.36147603e-01f, -1.28476858e-01f, 1.62395120e-01f, 6.13816194e-02f, -2.96890408e-01f, 1.80131327e-02f, -5.22657782e-02f,
  7.23617151e-02f, 1.18265167e-01f, -3.09946705e-02f, 6.48324862e-02f, 2.36132786e-01f, 4.11498658e-02f, 3.24583292e-01f, 1.89242974e-01f, 3.25754844e-02f, 8.07810389e-03f,
  2.53312379e-01f, 8.44874829e-02f, -4.20856401e-02f, 1.65507361e-01f, -1.08769491e-01f, -9.92485788e-03f, 1.37849953e-02f, -1.49223343e-01f, 1.18422814e-01f, 4.34590459e-01f,
  -2.29669526e-01f, -2.62446105e-01f, -8.91675353e-02f, -1.30897626e-01f, -1.93035096e-01f, 5.99486589e-01f, -7.74290645e-03f, -2.01003045e-01f, 9.13335532e-02f, -4.24789637e-01f,
  -3.43042612e-02f, 1.66975901e-01f, 7.39996880e-02f, -3.84360887e-02f, -1.57674849e-01f, -2.38451168e-01f, -3.69659871e-01f, 2.19626516e-01f, 1.76858023e-01f, 2.23568678e-01f,
  -1.78613633e-01f, 4.17589433e-02f, -3.26059073e-01f, -7.41290003e-02f, 1.85253680e-01f, 2.97725320e-01f, 1.30857881e-02f, -8.41930285e-02f, 1.59548804e-01f, -1.46280840e-01f,
  -2.05211863e-01f, -6.69555366e-02f, 3.41118962e-01f, -6.05268776e-03f, -1.37750238e-01f, 2.80849822e-03f, 9.37207267e-02f, 1.88521877e-01f, 5.16860068e-01f, -4.06677388e-02f,
  -1.31414697e-01f, 2.75417984e-01f, -4.78915907e-02f, -1.11880982e-02f, -1.55844420e-01f, -8.17105100e-02f, -1.27156779e-01f, -5.64084575e-02f, 2.24127099e-01f, -1.88102499e-01f,
  1.34225115e-01f, 1.86534122e-01f, 8.39460641e-03f, -7.86383972e-02f, -1.66419461e-01f, -8.66430812e-03f, -1.48482993e-01f, -6.80899769e-02f, -3.27787310e-01f, -9.46638286e-02f,
  6.68450892e-02f, -2.75301069e-01f, 6.09439947e-02f, 2.30537400e-01f, -1.64826989e-01f, -9.93704647e-02f, -2.70334501e-02f, 3.08846608e-02f, -4.82486695e-01f, -2.12115776e-02f,
  -1.90983206e-01f, 2.79672921e-01f, 9.27581117e-02f, -4.65639293e-01f, -2.61817157e-01f, 8.92371908e-02f, 3.81540060e-02f, -8.18906054e-02f, -2.64459196e-02f, 1.69548213e-01f,
  1.85684577e-01f, -1.69292033e-01f, -2.19168305e-01f, 1.72199812e-02f, 1.64339125e-01f, -3.22664797e-01f, 6.94845468e-02f, 2.29820102e-01f, 1.54122114e-01f, -3.49428877e-02f,
  4.56704274e-02f, 3.38764280e-01f, -2.59166472e-02f, -3.82113941e-02f, -2.66076654e-01f, 2.59875298e-01f, -3.40009630e-01f, 3.96085024e-01f, -2.25220591e-01f, 2.25775272e-01f,
  1.46536395e-01f, 4.00835216e-01f, -4.96363312e-01f, 3.33507836e-01f, -7.95692578e-02f, -2.52486646e-01f, -4.28355969e-02f, -6.60699531e-02f, -8.54087844e-02f, -8.77683237e-03f,
  7.47060925e-02f, 2.40917336e-02f, -2.55130768e-01f, -7.80573040e-02f, -1.64371505e-01f, -4.84167710e-02f, 3.92261846e-03f, 2.54712492e-01f, -1.43476561e-01f, -1.46318987e-01f,
  4.85399552e-02f, -1.35256067e-01f, 3.75180006e-01f, 2.04291970e-01f, -6.59940392e-02f, 2.14136496e-01f, -2.04267614e-02f, 6.08110279e-02f, 1.47842661e-01f, 1.73492938e-01f,
  1.80177107e-01f, -1.93304524e-01f, 2.29659170e-01f, 6.09963275e-02f, -1.86662063e-01f, -2.49986947e-01f, -2.81621486e-01f, 1.73078731e-01f, 1.58711016e-01f, 1.04894966e-01f,
  -3.03132478e-02f, -1.94763311e-03f, 1.91367254e-01f, 1.78727180e-01f, -1.18531756e-01f, -3.23277898e-02f, 1.23475706e-02f, -1.94616079e-01f, 2.67466813e-01f, 4.52689193e-02f,
  9.81132034e-03f, -2.59389997e-01f, -1.04471214e-01f, -3.27830791e-01f, -9.28952533e-04f, 4.90711653e-04f, 2.60626763e-01f, -7.98024759e-02f, -2.89145522e-02f, 2.76184343e-02f,
  -1.88489541e-01f, -2.12089461e-03f, 2.68477261e-01f, -4.58998643e-02f, -1.10818662e-01f, -3.62363160e-02f, 1.69147551e-01f, -8.10839608e-02f, 2.10382923e-01f, 1.69291228e-01f,
  -1.39574140e-01f, 7.00926408e-02f, 5.24586327e-02f, 1.20513298e-01f, -7.03796372e-02f, 1.42039463e-01f, 5.04771695e-02f, 1.38277367e-01f, -3.71032320e-02f, -1.42093346e-01f,
  6.15359657e-02f, 1.10435218e-01f, -4.63506818e-01f, -1.63290396e-01f, 1.97237030e-01f, 9.63054523e-02f, -1.45116940e-01f, -9.78846103e-02f, 6.93908036e-02f, -1.61629111e-01f,
  -3.63351367e-02f, 7.27620423e-02f, -1.06910639e-01f, 3.11880738e-01f, -2.76790053e-01f, -1.68176457e-01f, -1.82477653e-01f, 8.55852664e-02f, 1.18946947e-01f, -1.69661269e-01f,
  -2.92177517e-02f, -1.20328367e-01f, 3.65991401e-03f, 2.27072239e-01f, -3.91681612e-01f, 3.49146515e-01f, -1.27381310e-01f, 1.56940013e-01f, -1.14061356e-01f, -1.01493940e-01f,
  -4.51666005e-02f, 1.44472465e-01f, -1.96321815e-01f, 8.33262503e-02f, -2.35210776e-01f, 3.89736146e-02f, 1.02871142e-01f, -4.71713990e-02f, -8.77047181e-02f, 1.20151721e-01f,
  4.63459753e-02f, 4.24432084e-02f, 1.70727804e-01f, 6.18388467e-02f, 3.93556207e-01f, 1.41948238e-01f, -2.54910260e-01f, 2.77983904e-01f, -1.83590382e-01f, -1.97301388e-01f,
  1.53306350e-01f, 1.56712770e-01f, -2.87307024e-01f, 5.11414349e-01f, 2.55304188e-01f, 2.00567961e-01f, 1.49273023e-01f, -3.60470600e-02f, 6.07370026e-02f, -1.16884767e-03f,
  8.11288506e-02f, 8.26125741e-02f, -5.63336648e-02f, -1.94448516e-01f, 5.79743199e-02f, 1.26217023e-01f, -2.61804581e-01f, -1.70717984e-01f, 3.66823599e-02f, -2.63643954e-02f,
  4.73812044e-01f, 1.15805663e-01f, 2.59227008e-01f, 9.03411955e-02f, 6.04558773e-02f, -4.06927541e-02f, 9.13998708e-02f, 2.52887398e-01f, -9.15758461e-02f, -2.01965451e-01f,
  2.23023638e-01f, -1.48036093e-01f, -6.21331632e-02f, -5.01245186e-02f, 4.21359539e-02f, -1.53695107e-01f, 3.16361576e-01f, 1.17762163e-01f, 4.19017941e-01f, -1.33084238e-01f,
  -1.80708587e-01f, 3.37337255e-01f, 1.68666035e-01f, -9.03939363e-03f, 1.27454966e-01f, -1.11653224e-01f, 5.37254155e-01f, -3.59613299e-02f, 2.35203460e-01f, 1.16349310e-01f,
  -1.28637969e-01f, -1.15427680e-01f, 4.53231484e-01f, -1.99519947e-01f, -3.03324431e-01f, 5.67328483e-02f, 3.04364234e-01f, 2.39349410e-01f, -1.98529437e-01f, -8.81375372e-02f,
  5.32284528e-02f, 1.46621838e-01f, -4.29220088e-02f, -2.76052564e-01f, -1.38845639e-02f, 3.53045315e-01f, 1.42945543e-01f, 1.66413903e-01f, 1.09005840e-02f, -1.08243056e-01f,
  -4.65420447e-02f, 1.06394954e-01f, 1.29702449e-01f, 2.61280499e-02f, -6.36554882e-02f, 1.86526209e-01f, -3.63549055e-03f, 4.06791233e-02f, 1.70541346e-01f, 8.37714821e-02f,
  -1.02757789e-01f, -1.35104964e-03f, 2.29557529e-01f, 3.05604730e-02f, -2.39358738e-01f, -2.20885515e-01f, 2.26373866e-01f, 1.94921702e-01f, 1.35687977e-01f, -5.70117980e-02f,
  1.37681633e-01f, 1.18276076e-02f, 2.36865520e-01f, 2.44034976e-02f, 2.47524410e-01f, -1.64273918e-01f, 1.76345244e-01f, -5.18629178e-02f, 1.43219799e-01f, 3.97868395e-01f,
  -1.70715109e-01f, 4.53908592e-02f, 1.26470253e-02f, 3.62098128e-01f, 2.93492138e-01f, 3.42031330e-01f, 1.09012946e-01f, -1.12664290e-01f, 2.98852641e-02f, -6.20344803e-02f,
  1.24276504e-01f, 1.57405823e-01f, 2.94411987e-01f, 2.85363853e-01f, -4.35389392e-02f, -3.43267024e-01f, 1.11589089e-01f, 6.10861517e-02f, 3.17720741e-01f, 2.97089703e-02f,
  -1.78204417e-01f, 2.12861374e-01f, -1.70629531e-01f, 1.17031015e-01f, -6.16264790e-02f, 3.01045299e-01f, -1.29864827e-01f, 7.71502499e-03f, -2.88066685e-01f, 1.00023255e-01f,
  3.02520424e-01f, 9.08607021e-02f, -1.61068007e-01f, 8.44832286e-02f, 2.76092410e-01f, 5.63672669e-02f, 2.88451284e-01f, 5.63030653e-02f, -9.10355300e-02f, 2.00304180e-01f,
  -1.33073866e-01f, 6.59058839e-02f, -2.17216060e-01f, 1.21438012e-01f, -2.92887121e-01f, -1.84506848e-01f, 1.57531537e-02f, 7.11990753e-03f, 1.09404109e-01f, -5.04170284e-02f,
  1.24715216e-01f, 3.37198228e-01f, -3.60551919e-03f, -8.44723806e-02f, -2.81077251e-02f, -1.69400096e-01f, 1.84985906e-01f, 4.85286228e-02f, 2.92647362e-01f, 9.73484218e-02f,
  2.66993612e-01f, -2.93349296e-01f, 2.23632172e-01f, 1.55037209e-01f, 1.52457133e-01f, 1.40201775e-02f, -2.65939087e-01f, 3.47024873e-02f, -3.26575190e-02f, 2.42464051e-01f,
  -8.86729509e-02f, 7.58240372e-02f, -4.80713584e-02f, 3.24073583e-01f, 1.83482185e-01f, 3.22818786e-01f, 1.09550186e-01f, -4.60489690e-01f, 8.40760544e-02f, -4.50088605e-02f,
  -1.17870234e-02f, -1.63073242e-01f, 1.50003254e-01f, -3.22316363e-02f, -2.41130918e-01f, 8.11242610e-02f, 3.30258965e-01f, 4.05611917e-02f, -1.06009282e-02f, -6.54705912e-02f,
  -5.85165899e-03f, -2.54735440e-01f, 5.18449724e-01f, -1.55155629e-01f, 1.57399267e-01f, 3.43131155e-01f, 1.35035455e-01f, 1.98803812e-01f, 6.24350123e-02f, 7.05486760e-02f,
  4.56230566e-02f, 1.10298097e-01f, 7.58817792e-03f, -2.00670674e-01f, 1.30576372e-01f, -2.44998723e-01f, 1.13682844e-01f, -1.99910849e-01f, 3.29453170e-01f, 1.30517662e-01f,
  1.70173675e-01f, 1.10255517e-01f, 2.85658360e-01f, 2.78077185e-01f, 4.12949435e-02f, -2.38867521e-01f, 9.11176354e-02f, 2.90423781e-01f, -3.92450579e-02f, 1.75719917e-01f,
  -1.44268677e-01f, -1.68016717e-01f, -1.30168080e-01f, -1.42090946e-01f, -1.58842225e-02f, 3.19384754e-01f, -1.47762075e-01f, 1.02676854e-01f, 1.52750686e-01f, 1.05349533e-02f,
  -1.59610540e-01f, 2.45114103e-01f, -1.75189748e-01f, -6.49264529e-02f, -1.80833966e-01f, 7.77610904e-03f, -1.47936538e-01f, 2.10903957e-02f, -2.73288429e-01f, -4.51969020e-02f,
  1.73439588e-02f, 4.81744915e-01f, -1.36130199e-01f, 2.02733293e-01f, -2.24449858e-01f, 2.07535893e-01f, -1.67721078e-01f, 3.19594830e-01f, 2.82788396e-01f, -1.30628943e-01f,
  -1.30370557e-01f, 3.03899974e-01f, 2.64404804e-01f, 1.44843012e-01f, 3.14286165e-02f, 3.48822832e-01f, -3.14114131e-02f, -6.65973276e-02f, -2.40409553e-01f, -1.42287031e-01f,
  -2.25858480e-01f, 6.50090538e-03f, 6.77889362e-02f, -1.59372892e-02f, 1.08069219e-01f, -7.73961470e-02f, 3.83413993e-02f, 1.76099986e-01f, 3.41306329e-02f, 9.48867798e-02f,
  -4.72740233e-02f, -5.24803959e-02f, -2.38580912e-01f, 8.29272345e-02f, 2.24402830e-01f, -8.33501816e-02f, -2.33394161e-01f, -6.00210667e-01f, 1.00715637e-01f, -1.30932882e-01f,
  -2.10100953e-02f, -6.56659901e-02f, 9.96640995e-02f, 3.79302241e-02f, 4.86956015e-02f, -1.96245626e-01f, 2.35868499e-01f, -5.63303232e-02f, -1.73536628e-01f, -1.65606350e-01f,
  -5.44188470e-02f, 1.98417336e-01f, 1.53791621e-01f, 1.19496584e-02f, -1.44652918e-01f, 3.40687186e-01f, 9.91110131e-03f, 2.99429864e-01f, 1.78893790e-01f, -9.76562276e-02f,
  -2.40115792e-01f, 8.89907777e-02f, -5.30023351e-02f, 3.64373326e-01f, 2.39186287e-01f, 3.52192700e-01f, 1.23899497e-01f, -9.12629142e-02f, 4.26793285e-02f, 2.46474087e-01f,
  6.03533499e-02f, -1.61984459e-01f, -6.69137910e-02f, -1.48930266e-01f, 9.03013498e-02f, 2.58034408e-01f, 1.06865153e-01f, 3.80648673e-01f, -6.09170683e-02f, 8.32436047e-03f,
  4.52926934e-01f, 7.28969127e-02f, 3.42359364e-01f, 3.44529629e-01f, -1.36672100e-02f, 2.46631250e-01f, 2.04397008e-01f, -3.38868704e-03f, 1.78127781e-01f, 1.53033614e-01f,
  -9.88176242e-02f, 8.43007937e-02f, 1.77021809e-02f, 4.56619039e-02f, 1.31104514e-01f, -9.66389477e-02f, 1.12823240e-01f, 2.70318687e-01f, -4.34392914e-02f, 2.46493548e-01f,
  3.91093403e-01f, 1.96874961e-01f, -6.22240268e-02f, -2.57368028e-01f, 2.28096396e-01f, 3.26699406e-01f, -4.07259576e-02f, 3.44748385e-02f, 3.03615304e-03f, -2.66117871e-01f,
  -1.15731761e-01f, 3.82822126e-01f, -1.02803379e-01f, 1.93347558e-01f, -2.14802161e-01f, 1.05914079e-01f, 1.34725213e-01f, 5.43854013e-02f, 3.62990610e-02f, -1.20216878e-02f,
  -2.92517126e-01f, -4.56347503e-02f, -1.98487833e-01f, 2.51441777e-01f, -6.51474157e-03f, 2.36535653e-01f, -1.01625184e-02f, 2.45017841e-01f, -2.16777623e-01f, -1.40717953e-01f,
  -2.98100650e-01f, 3.55846375e-01f, -1.52431190e-01f, 7.32252598e-02f, -4.68287617e-01f, 1.77318752e-01f, -2.89033353e-02f, -1.07894547e-01f, 5.25774248e-02f, 2.42401063e-01f,
  -7.07926825e-02f, 3.65594178e-02f, 9.82916206e-02f, 1.62019387e-01f, 5.18495798e-01f, -3.06796767e-02f, -1.16103724e-01f, 1.20150641e-01f, -3.29086073e-02f, -4.91942279e-02f,
  2.38317698e-01f, 1.08648553e-01f, -2.45516356e-02f, 1.02526784e-01f, -3.41803767e-02f, 5.77167347e-02f, 6.87893555e-02f, 1.20211191e-01f, -1.53709859e-01f, 1.01306245e-01f,
  8.50085840e-02f, 1.05925560e-01f, 2.39013627e-01f, 2.29956821e-01f, -2.26034746e-02f, -2.49709472e-01f, 3.39070022e-01f, -3.79318923e-01f, -7.80108273e-02f, 3.82030219e-01f,
  2.56410927e-01f, -1.23726122e-01f, 3.05121932e-02f, -1.79249108e-01f, -3.10806185e-02f, 1.16503865e-01f, 4.68946435e-03f, 3.77447009e-02f, 5.94779328e-02f, -1.81972384e-01f,
  2.81220883e-01f, -7.92012215e-02f, -8.25656578e-02f, 2.44402587e-01f, -9.43822637e-02f, 1.53491944e-01f, -1.10938765e-01f, -2.66229510e-01f, 1.67828109e-02f, -8.20481312e-03f,
  6.70901835e-02f, 3.07977587e-01f, 1.47692487e-01f, -1.35815619e-02f, 1.17633022e-01f, -1.55686229e-01f, 5.88100143e-02f, 2.80984551e-01f, -1.29631728e-01f, -1.67019218e-01f,
  -1.97316706e-01f, 1.50050446e-02f, -4.14044373e-02f, 2.34799802e-01f, -3.49433906e-02f, 2.76714832e-01f, -2.36488551e-01f, 2.07741991e-01f, 2.45364636e-01f, 1.48240536e-01f,
  -2.41720695e-02f, 3.13156426e-01f, 2.83016175e-01f, 2.23397955e-01f, 8.32680389e-02f, -8.71525109e-02f, 1.06631033e-01f, -9.78611410e-04f, -1.71069339e-01f, -2.64108032e-01f,
  -8.13257322e-02f, -1.07957914e-01f, 1.24495886e-01f, -7.90162086e-02f, 9.77064744e-02f, -7.35051334e-02f, -4.92717437e-02f, 1.63944721e-01f, 5.54411292e-01f, 2.73084730e-01f,
  3.67841899e-01f, -1.49283826e-01f, 1.85874533e-02f, 8.47147778e-02f, 1.19967933e-03f, 1.95712686e-01f, -1.50576562e-01f, -1.78453028e-01f, 8.46097618e-03f, 1.02619283e-01f,
  -2.33070794e-02f, 3.29451784e-02f, 6.54222369e-02f, 2.09245548e-01f, 4.99064684e-01f, -1.57688290e-01f, 6.24861300e-01f, -1.32084876e-01f, -1.92132518e-01f, 1.97973952e-01f,
  -5.84999509e-02f, 3.40929687e-01f, 4.06498602e-03f, 2.40607843e-01f, 6.11916900e-01f, -2.21621141e-01f, 6.75101876e-02f, -2.41311923e-01f, -3.36433828e-01f, 3.12353879e-01f,
  3.60961497e-01f, -2.55333692e-01f, -4.12305743e-01f, 9.50658396e-02f, 2.90116161e-01f, -1.91324905e-01f, -1.32763281e-01f, -5.42348772e-02f, 1.68311566e-01f, 1.15047716e-01f,
  2.27980345e-01f, -1.06388137e-01f, 4.23342735e-02f, 3.20443034e-01f, -2.21946016e-01f, -1.17410555e-01f, 4.36064869e-01f, 2.19210654e-01f, 3.93656082e-02f, -9.79481041e-02f,
  -1.23593569e-01f, 1.65354103e-01f, -1.73040748e-01f, 1.05798859e-02f, -4.30538028e-01f, 1.38035668e-02f, 5.36169447e-02f, 1.09099790e-01f, 2.16742218e-01f, 1.21115625e-01f,
  -2.96390623e-01f, -1.41502291e-01f, 5.77982903e-01f, 5.61053395e-01f, -9.28782523e-02f, 4.15776670e-01f, -1.13238089e-01f, -3.78397740e-02f, -1.22190699e-01f, 7.87066445e-02f,
  -2.29622439e-01f, -1.95602536e-01f, 2.34280705e-01f, 2.94605553e-01f, -2.75814027e-01f, -2.67858118e-01f, -2.35110402e-01f, 1.66397870e-01f, 1.06700890e-01f, -2.37357184e-01f,
  -7.60969818e-02f, -2.88940631e-02f, -3.42368811e-01f, -2.69316107e-01f, -2.35679135e-01f, -1.74192376e-02f, 1.10222302e-01f, 1.83467194e-01f, -1.37769669e-01f, 2.97630906e-01f,
  -1.67782828e-01f, -7.91785896e-01f, 3.11909616e-02f, -2.62730837e-01f, -3.27956200e-01f, 5.98631091e-02f, 4.26585346e-01f, -3.79777074e-01f, 1.05619669e-01f, -8.15599263e-02f,
  1.54223695e-01f, -1.67844698e-01f, 5.66452980e-01f, -9.69584063e-02f, 1.41986221e-01f, 1.22609556e-01f, 3.10078740e-01f, -2.43390307e-01f, 9.37965233e-03f, 2.99188048e-01f,
  1.17229268e-01f, 2.45991543e-01f, 2.06493005e-01f, 7.65360817e-02f, 1.02790646e-01f, 7.12482408e-02f, 4.91140075e-02f, 1.07065151e-02f, 5.51975444e-02f, 2.13027656e-01f,
  -2.70542532e-01f, -5.84682971e-02f, -3.21653962e-01f, 2.51764022e-02f, -3.92908826e-02f, 2.69035548e-01f, -6.60987720e-02f, 7.18655437e-02f, -1.65978730e-01f, 1.95376799e-01f,
  1.68014750e-01f, -2.79607385e-01f, -2.46094853e-01f, -1.02065369e-01f, -3.50115508e-01f, 2.72559047e-01f, 2.70005494e-01f, 5.32815993e-01f, 1.04021758e-01f, -3.21477860e-01f,
  -5.07176332e-02f, -1.79355621e-01f, 1.27385911e-02f, 6.48993179e-02f, 7.90075809e-02f, -1.69298410e-01f, -4.06987779e-02f, -6.46748915e-02f, -1.70409039e-01f, 2.77854562e-01f,
  -5.83196990e-02f, 2.83342838e-01f, 1.72580220e-02f, 2.64537096e-01f, 2.65362620e-01f, -6.69246912e-02f, -1.29234418e-01f, 3.58807445e-01f, 2.48989239e-01f, -1.03586249e-01f,
  1.27366558e-01f, -1.75422281e-01f, -5.37025444e-02f, -2.86894500e-01f, 2.62633383e-01f, -2.50815094e-01f, -1.32781133e-01f, 3.95440310e-02f, 2.07380310e-01f, -7.11069629e-02f,
  5.09359360e-01f, 4.42196801e-02f, 4.51029211e-01f, 1.72469005e-01f, 8.45366716e-02f, 5.59992976e-02f, 1.30126446e-01f, 1.32190764e-01f, 7.27255866e-02f, 7.58791566e-02f,
  1.31761730e-01f, 2.37939388e-01f, 6.33128285e-02f, 1.96584001e-01f, -1.47494242e-01f, 2.98181385e-01f, -3.92947525e-01f, -9.43315625e-02f, 8.11048076e-02f, 6.12537712e-02f,
  1.14572823e-01f, -1.83470815e-01f, 1.32669657e-01f, 1.81408286e-01f, 2.01329082e-01f, -1.10968962e-01f, 1.06101789e-01f, -8.23656097e-02f, -6.70389459e-02f, -6.33964017e-02f,
  3.52361321e-01f, 1.61919266e-01f, -1.59332186e-01f, -4.81605560e-01f, -2.44780928e-02f, -2.29962543e-02f, 8.84056613e-02f, 7.02083856e-02f, -3.28536868e-01f, 2.82111228e-01f,
  -1.34246230e-01f, 1.00767680e-01f, -3.28743190e-01f, 7.09984750e-02f, -1.27938643e-01f, 1.27809733e-01f, 1.07739218e-01f, 3.25793236e-01f, -1.14287689e-01f, -1.56066522e-01f,
  7.53021017e-02f, -4.96278480e-02f, 1.46281570e-01f, 5.50476685e-02f, -2.52016395e-01f, -1.81085482e-01f, -1.66100323e-01f, -1.87027320e-01f, 4.14496541e-01f, 2.26167783e-01f,
  -4.92775254e-02f, 3.72090727e-01f, -2.02223063e-01f, -1.21532731e-01f, 3.40308011e-01f, 1.98876262e-01f, 2.36161605e-01f, 6.07304931e-01f, 1.44933954e-01f, -3.61291915e-02f,
  1.14744008e-01f, 1.38282850e-01f, 2.28668809e-01f, 1.56176001e-01f, 2.05146715e-01f, -1.37802679e-02f, 1.81914061e-01f, 1.32155433e-01f, -5.83505593e-02f, 1.11807220e-01f,
  1.99814677e-01f, 4.07625437e-01f, 1.47695303e-01f, 2.64126092e-01f, -1.60697460e-01f, -2.63083875e-02f, -2.17745528e-01f, 3.58230203e-01f, 1.56466663e-02f, 1.01914883e-01f,
  1.06740750e-01f, 1.51906595e-01f, 2.46591210e-01f, 2.80258119e-01f, 1.34346679e-01f, -8.56975093e-02f, 2.07713351e-01f, 3.05716366e-01f, -5.69383577e-02f, 3.21280956e-01f,
  -1.08841576e-01f, 4.31433581e-02f, -4.55671787e-01f, 3.92422289e-01f, 1.15761250e-01f, -8.03527385e-02f, 1.68044269e-01f, -2.85132051e-01f, -1.07069746e-01f, -9.48842764e-02f,
  -4.14274126e-01f, 1.56073973e-01f, 1.73069686e-02f, 3.65772694e-01f, -2.09389273e-02f, -1.73288718e-01f, -5.35738990e-02f, 2.46822640e-01f, 3.90265673e-01f, 2.77586162e-01f,
  -1.40673459e-01f, -9.40447822e-02f, 1.02330364e-01f, 3.24917287e-01f, 8.77844542e-02f, 3.19744051e-01f, 1.15260437e-01f, 3.65737081e-01f, -3.16846251e-01f, -1.66188627e-01f,
  1.02234177e-01f, 2.01557636e-01f, -1.70257054e-02f, -1.70812801e-01f, 5.53790890e-02f, 4.17466499e-02f, -4.88051586e-03f, 1.85526758e-01f, -1.30938277e-01f, -5.61239161e-02f,
  -8.69531650e-03f, -4.76156808e-02f, 7.27816597e-02f, 1.48403300e-02f, 7.72126317e-02f, 8.68450776e-02f, 2.96719700e-01f, -1.55569389e-01f, -2.31278427e-02f, -4.61854897e-02f,
  2.25505725e-01f, 9.89404619e-02f, 1.36379063e-01f, 4.71559167e-02f, 1.90143287e-01f, -1.41844274e-02f, 2.71806091e-01f, -1.78085023e-03f, 1.83490410e-01f, -2.13521272e-01f,
  2.15568617e-01f, -2.76304156e-01f, 1.33434668e-01f, 4.21891004e-01f, 1.89541474e-01f, 7.99406841e-02f, 2.59132296e-01f, 2.67575592e-01f, 2.61716306e-01f, 2.11311594e-01f,
  -1.28017157e-01f, -5.03045358e-02f, 4.06787068e-01f, 1.88785810e-02f, 1.47104487e-01f, -5.12193628e-02f, 1.87649295e-01f, -1.81550682e-01f, -4.92163673e-02f, -1.77921683e-01f,
  -1.63828209e-01f, 1.61527187e-01f, 5.02592862e-01f, 2.11138323e-01f, -2.23979026e-01f, -8.65908116e-02f, 6.69857953e-03f, 1.38760328e-01f, 2.51316607e-01f, 2.71701872e-01f,
  7.53435353e-03f, 1.28730521e-01f, -1.86099574e-01f, -1.94462717e-01f, -1.24924719e-01f, 1.47524059e-01f, 5.28585576e-02f, 8.54239464e-02f, 1.91410586e-01f, 1.90463234e-02f,
  3.20566446e-01f, 3.61350700e-02f, 1.35172969e-02f, 1.70679510e-01f, -2.28054728e-02f, 7.85042197e-02f, -1.73416123e-01f, -5.15557118e-02f, -2.62011886e-01f, 1.13591533e-02f,
  -4.15419638e-02f, -1.49170712e-01f, 2.05243215e-01f, 2.21253335e-02f, -1.49571806e-01f, 4.09690380e-01f, -5.01554161e-02f, -1.19342819e-01f, -1.93570722e-02f, -2.70198047e-01f,
  2.60135412e-01f, 1.16300266e-02f, 1.23037733e-01f, 3.42158854e-01f, 9.34943259e-02f, -3.47532660e-01f, 1.81551892e-02f, 8.69403854e-02f, 2.51969956e-02f, 1.41006276e-01f,
  -3.52230817e-01f, 1.25575766e-01f, -1.00048810e-01f, 4.03713621e-02f, -9.13953260e-02f, 2.30198920e-01f, 3.52822579e-02f, 3.08683336e-01f, 6.77200705e-02f, 2.91025490e-01f,
  7.47158825e-02f, -3.27429175e-01f, 1.74925342e-01f, -3.33809219e-02f, -7.97553137e-02f, 1.43202962e-02f, 1.72770098e-01f, -4.22246940e-02f, -2.47007489e-01f, -1.49064451e-01f,
  2.74039686e-01f, 1.60388812e-01f, 1.25234425e-01f, -1.51482165e-01f, 8.64611045e-02f, -1.20602533e-01f, 5.36075592e-01f, -2.65733004e-01f, 3.82215172e-01f, 2.59164572e-01f,
  8.28963965e-02f, -5.76045997e-02f, -7.40868524e-02f, 7.36801252e-02f, 2.58913785e-01f, -2.85159238e-02f, 1.13217793e-01f, -1.42590597e-01f, 1.48570150e-01f, -6.17709830e-02f,
  1.18740946e-01f, -5.37569039e-02f, -7.01345084e-03f, 8.27124901e-03f, -1.98888883e-01f, 1.51780903e-01f, -8.22587237e-02f, 2.35511288e-01f, 1.91159219e-01f, 4.41727757e-01f,
  -9.26056653e-02f, -3.47616911e-01f, 1.21754277e-02f, 2.28879124e-01f, 4.02486185e-03f, 3.67661893e-01f, -2.76387911e-02f, -2.80558884e-01f, 9.09179598e-02f, 2.03034475e-01f,
  1.92140453e-02f, -1.94155961e-01f, 3.39887947e-01f, 1.97709769e-01f, 5.37025295e-02f, -5.58902472e-02f, 1.05121680e-01f, 2.47292653e-01f, -7.67079815e-02f, -2.14532971e-01f,
  5.40030114e-02f, 1.96344554e-01f, -2.31230091e-02f, -1.04355805e-01f, 1.74076229e-01f, 3.54245037e-01f, -8.85119289e-02f, 6.81264559e-03f, 2.87462652e-01f, -3.65056954e-02f,
  1.26513675e-01f, -7.48106465e-03f, 4.97130334e-01f, -8.25985298e-02f, 2.22788975e-01f, -1.01768702e-01f, -2.00479120e-01f, 7.00228363e-02f, -2.19438836e-01f, -1.08354867e-01f,
  -2.24019811e-02f, 2.46672571e-01f, 3.03470463e-01f, 1.52259260e-01f, 1.23986185e-01f, 7.05752075e-02f, -5.41093852e-03f, 1.90134402e-02f, -8.94605815e-02f, 9.01618302e-02f,
  -1.30312145e-01f, 2.13016480e-01f, -2.06190690e-01f, -8.72682706e-02f, 2.39579111e-01f, 1.77268445e-01f, 1.35607675e-01f, -9.85648483e-02f, 2.24141911e-01f, 1.12731241e-01f,
  1.36884317e-01f, 1.51487485e-01f, 1.39115125e-01f, -3.22423935e-01f, 7.18046874e-02f, 6.65355995e-02f, 1.11952811e-01f, 9.10831764e-02f, -1.16185039e-01f, -2.16077715e-01f,
  2.26145104e-01f, -1.06358126e-01f, -2.81598479e-01f, -1.54621154e-01f, 9.14225802e-02f, 1.42793164e-01f, 6.77464753e-02f, 8.36862624e-02f, 4.06737804e-01f, -6.55130818e-02f,
  7.21384361e-02f, 2.42356822e-01f, 2.40321793e-02f, -1.01871118e-01f, 1.35446355e-01f, -2.53119439e-01f, 1.60050482e-01f, -5.42350970e-02f, 3.62264574e-01f, 4.62322950e-01f,
  1.47571430e-01f, -2.21722305e-01f, 3.70989799e-01f, 1.37330487e-01f, -2.94099778e-01f, -1.81498840e-01f, 2.29471356e-01f, 1.76301628e-01f, -3.04125816e-01f, -1.03318803e-01f,
  2.08365321e-01f, 2.31580034e-01f, -1.94245979e-01f, -1.16632007e-01f, -1.76210515e-03f, 3.21025789e-01f, 1.60720989e-01f, -2.01030150e-01f, 7.68109411e-02f, 2.53826529e-02f,
  -7.33550712e-02f, 1.62382990e-01f, 2.24066507e-02f, 1.33332148e-01f, -6.98225275e-02f, -1.11572005e-01f, 6.07038289e-02f, -1.19625770e-01f, -1.87107161e-01f, -1.23356119e-01f,
  8.78996179e-02f, 1.49427861e-01f, -3.22111070e-01f, 1.53902071e-02f, 9.92379040e-02f, 1.98003083e-01f, -1.90707505e-01f, 4.74698752e-01f, 8.78697410e-02f, -2.30629593e-01f,
  -1.39008299e-01f, 5.71731776e-02f, 1.47900775e-01f, 2.79483825e-01f, -2.30468567e-02f, 1.73768952e-01f, 3.09957653e-01f, 5.17936982e-02f, 8.14718008e-02f, -2.58397251e-01f,
  2.76487917e-01f, 7.72104114e-02f, 1.16696067e-01f, -1.31276965e-01f, 4.61303256e-02f, -3.12824756e-01f, 6.68558180e-02f, 2.96239138e-01f, -2.87864991e-02f, 2.44582728e-01f,
  -1.27299160e-01f, -6.24132082e-02f, -2.06482664e-01f, -4.08073306e-01f, -6.94060400e-02f, 4.57695633e-01f, -4.45061512e-02f, -2.46373326e-01f, 3.76555055e-01f, 1.90859884e-01f,
  -1.12796240e-02f, -6.28342852e-02f, 3.82380337e-01f, -5.69471642e-02f, 1.47622488e-02f, -4.42927718e-01f, 6.28793314e-02f, 1.46084055e-01f, 2.12371066e-01f, -2.31591940e-01f,
  -3.56741995e-02f, -8.07666555e-02f, 1.77309170e-01f, 2.22975127e-02f, -2.45607719e-02f, 1.95292924e-02f, 3.66407633e-02f, 1.61690295e-01f, 1.56680513e-02f, -2.79793590e-01f,
  2.04022884e-01f, 2.19983608e-03f, 1.08701706e-01f, 3.41991824e-03f, -1.65484790e-02f, -8.36989805e-02f, 1.72715932e-01f, 2.12560698e-01f, 4.51761454e-01f, 9.83309895e-02f,
  1.89742833e-01f, -9.71303210e-02f, -2.28433609e-02f, 3.37168649e-02f, -3.28591838e-02f, 1.17214970e-01f, -3.32509354e-02f, -2.81573888e-02f, 1.11776069e-01f, 1.44238248e-01f,
  4.54479344e-02f, 6.65009543e-02f, -8.94298255e-02f, 1.64019123e-01f, 4.71628159e-01f, -2.60486770e-02f, 5.14163136e-01f, -2.23591283e-01f, -1.57862410e-01f, 3.34617257e-01f,
  3.87229286e-02f, 1.46202698e-01f, 1.35804787e-01f, -3.14274877e-02f, 4.71175581e-01f, -1.79042891e-01f, 7.04597235e-02f, -8.20009857e-02f, -3.79583359e-01f, 3.46909821e-01f,
  2.39347801e-01f, -2.70235091e-01f, -2.94021577e-01f, -2.28044000e-02f, 1.77700147e-01f, -1.14917688e-01f, 2.72652078e-02f, -3.02123129e-02f, -6.54761270e-02f, -1.29313454e-01f,
  1.16652988e-01f, -8.61038938e-02f, 2.24201009e-01f, 8.63296911e-02f, -6.77269697e-03f, -2.23830238e-01f, 8.05144534e-02f, 9.85553302e-03f, 6.46922663e-02f, -2.26944443e-02f,
  -7.35807046e-02f, 5.18393815e-02f, 3.59053835e-02f, -6.30982742e-02f, -7.50284940e-02f, 3.13499831e-02f, -1.38218150e-01f, -9.20682177e-02f, 4.42837775e-01f, 4.96427298e-01f,
  -1.98120624e-01f, -1.26546025e-01f, -7.97465742e-02f, 2.09941745e-01f, -3.08703959e-01f, 5.20655572e-01f, 2.76709676e-01f, 1.94227874e-01f, -1.22803142e-02f, -3.15826088e-01f,
  3.78879964e-01f, 2.79833823e-01f, -2.63238341e-01f, 2.67242551e-01f, -3.27328295e-01f, -9.06375945e-02f, -2.50590861e-01f, -9.62372646e-02f, -4.36030895e-01f, -3.53533208e-01f,
  -4.33642358e-01f, -3.57157625e-02f, 2.32534915e-01f, -2.99466252e-01f, -3.52219552e-01f, 1.12537451e-01f, -2.14490537e-02f, -5.31139039e-02f, -4.87437516e-01f, -3.15994862e-03f,
  -1.24002784e-01f, 2.75734484e-01f, -5.50034754e-02f, -2.80226827e-01f, -4.48604286e-01f, 2.23397732e-01f, 5.94759464e-01f, -6.12929761e-02f, -2.99278319e-01f, -2.85624087e-01f,
  -3.11321821e-02f, 1.96058843e-02f, 1.34881064e-01f, 2.80741546e-02f, 1.99587330e-01f, 4.28777605e-01f, -2.18508363e-01f, -2.46858686e-01f, -1.37202322e-01f, -1.30378693e-01f,
  5.79536222e-02f, 2.08272282e-02f, 2.58502245e-01f, -4.41311486e-02f, 2.05499738e-01f, -6.34784997e-02f, 8.80378783e-02f, 1.61632255e-01f, 9.92246717e-02f, 1.46462753e-01f,
  -1.91098645e-01f, -1.60644844e-01f, -1.27642021e-01f, 4.99374568e-02f, 8.15337077e-02f, 1.05190471e-01f, 1.95446312e-01f, -1.65622234e-01f, -1.72033738e-02f, -1.87798083e-01f,
  -1.28228933e-01f, 2.80084997e-01f, 2.09810212e-02f, -3.57734635e-02f, 1.68594301e-01f, -7.85789937e-02f, -1.32478615e-02f, 1.80973411e-01f, 5.57707064e-02f, 1.15601256e-01f,
  1.25433803e-01f, 1.56440943e-01f, 2.62132939e-02f, -1.05577178e-01f, -4.46749330e-01f, 1.76294014e-01f, -1.05393007e-02f, 4.96433601e-02f, -1.42433837e-01f, -6.85689971e-02f,
  -1.34458542e-01f, 1.85776010e-01f, -9.22121555e-02f, 2.65606642e-01f, 4.15690690e-02f, -1.19479328e-01f, 1.21415332e-01f, -2.07972929e-01f, -2.53194451e-01f, 2.22627968e-01f,
  -2.18191221e-01f, 1.36524349e-01f, -4.63512212e-01f, 1.48142099e-01f, 5.89431301e-02f, 3.89038116e-01f, -2.14902926e-02f, 1.09236419e-01f, 1.19633742e-01f, 2.33529910e-01f,
  3.21801871e-01f, -2.77385086e-01f, 6.45810291e-02f, 4.86274302e-01f, 7.53084496e-02f, -8.70786533e-02f, -1.60468608e-01f, 2.34294072e-01f, -5.22039793e-02f, -7.38385543e-02f,
  -1.68916330e-01f, -4.18020692e-03f, -2.48567909e-02f, -1.55589551e-01f, 3.30569297e-01f, 9.84905064e-02f, 2.72720098e-01f, 2.69511878e-01f, -5.12204394e-02f, 2.18903497e-01f,
  -1.99966967e-01f, 5.19140670e-03f, 1.18172243e-01f, 2.61816382e-01f, 1.65540606e-01f, -9.93405432e-02f, -1.11554647e-02f, 2.52263784e-01f, 2.03550264e-01f, 2.05978841e-01f,
  -1.89167622e-03f, -1.66830048e-01f, 1.16509460e-01f, 1.16555922e-01f, 9.92605537e-02f, -1.47390902e-01f, 7.83251449e-02f, 1.66328564e-01f, 3.14595193e-01f, 6.73760474e-02f,
  1.16356432e-01f, 7.24264085e-02f, 3.56477201e-02f, -3.94011997e-02f, 1.49356470e-01f, 1.46552414e-01f, -2.62559559e-02f, -2.83056229e-01f, 1.89059541e-01f, 5.05144656e-01f,
  -1.62986577e-01f, 1.09386869e-01f, 3.19394231e-01f, 7.33561143e-02f, 1.77132741e-01f, 3.52839530e-02f, 3.70744556e-01f, 9.86185484e-03f, 2.11898059e-01f, -1.07592434e-01f,
  8.76739472e-02f, 1.86961442e-01f, -1.06733531e-01f, 5.26611954e-02f, -4.05664653e-01f, 3.54700208e-01f, -8.28538314e-02f, -2.20918238e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.05314679e-01f, 1.14163809e-01f, 1.45749599e-01f, 1.51810184e-01f, 1.91281453e-01f, 1.75229565e-03f, 1.81596458e-01f, 5.33241704e-02f, 2.18163460e-01f, 2.67433554e-01f,
  4.23173718e-02f, -2.96749119e-02f, 1.28601775e-01f, 6.69868812e-02f, 9.68683586e-02f, 1.10672070e-02f, 4.24160510e-02f, 2.40861624e-01f, 5.92588894e-02f, 1.32959217e-01f,
  7.14462250e-02f, -3.08914930e-02f, 1.09510750e-01f, -1.22905947e-01f, 8.99270102e-02f, 1.81286812e-01f, -4.00844254e-02f, 2.09667787e-01f, -1.85092002e-01f, 8.47652927e-03f,
  2.19235405e-01f, 1.03899777e-01f, -2.06340905e-02f, 7.34440684e-02f, 1.08794637e-01f, 1.41832337e-01f, 3.22544605e-01f, 1.17262192e-01f, 1.21104285e-01f, 7.81241804e-02f,
  9.36412346e-03f, 1.12593465e-01f, 5.53500913e-02f, -4.13344987e-02f, 2.94076800e-01f, 2.47512981e-02f, 5.35601266e-02f, 1.69675931e-01f, 7.95448944e-02f, 1.34699211e-01f,
  -3.86510417e-02f, -3.93825024e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.43367696e-01f, -4.52642113e-01f, -2.81890720e-01f, -1.61305472e-01f, -6.89951703e-02f, -2.09090874e-01f, 1.21615268e-01f, 3.83939967e-02f, 3.79683711e-02f, -2.95920908e-01f,
  1.36166364e-01f, -5.75487800e-02f, -3.95160437e-01f, 1.98810175e-01f, -1.42877176e-01f, -6.86587811e-01f, -1.50749370e-01f, -3.13200444e-01f, 2.09992722e-01f, -3.21938664e-01f,
  2.01692581e-02f, -4.07755196e-01f, 7.89337233e-02f, 6.14897069e-03f, 2.13726372e-01f, 9.81134325e-02f, -3.39541346e-01f, 1.98242903e-01f, -9.84790996e-02f, 1.19837612e-01f,
  1.67984307e-01f, -1.89663127e-01f, 1.13452539e-01f, -1.22829005e-01f, 2.71550491e-02f, 8.81753489e-02f, 1.54414967e-01f, 3.59487906e-02f, 3.09540272e-01f, -5.57988822e-01f,
  -2.69008905e-01f, -4.03303700e-03f, -3.41538638e-01f, -3.10670346e-01f, 1.48126513e-01f, -2.66102314e-01f, 1.11874767e-01f, 1.18399516e-01f, -2.89193869e-01f, -7.64642982e-03f,
  -5.42420745e-01f, -4.71021056e-01f, -3.58164370e-01f, -3.23561728e-01f, 2.87946582e-01f, 1.40689939e-01f, -1.59189671e-01f, -2.59960443e-01f, 3.81719023e-02f, -3.86591762e-01f,
  -1.20153457e-01f, 8.12237784e-02f, 6.51592761e-02f, 2.00066283e-01f, -1.08478643e-01f, 1.42137215e-01f, 6.28275126e-02f, 1.45997420e-01f, 4.27988656e-02f, 1.33224294e-01f,
  2.13863105e-01f, 2.08257541e-01f, -1.70434862e-01f, -1.30460113e-01f, -2.40268663e-01f, -3.76425713e-01f, 8.47203881e-02f, 2.01620281e-01f, 1.70523077e-01f, -3.17368954e-02f,
  -6.59620166e-02f, 1.89315900e-01f, -9.92488116e-02f, -3.69015820e-02f, -2.62622476e-01f, -1.48594394e-01f, 9.46299732e-02f, -2.13004321e-01f, 2.26581275e-01f, 1.21276066e-01f,
  -1.05385073e-01f, 7.38670379e-02f, -6.02821290e-01f, 1.91157922e-01f, 2.26172209e-01f, -8.96775424e-02f, -1.98812857e-02f, 1.26712009e-01f, -3.10692072e-01f, 1.17004588e-01f,
  1.41679853e-01f, 2.22739458e-01f, 2.84893870e-01f, -1.21811315e-01f, -8.88927877e-02f, 1.66569501e-01f, 2.12267376e-02f, -1.81357190e-01f, 5.04807904e-02f, 4.83412258e-02f,
  -5.18108249e-01f, -3.28610688e-01f, -3.78448009e-01f, -4.31020766e-01f, -3.89522731e-01f, 1.01268597e-01f, -2.00087547e-01f, -3.87197614e-01f, 1.31365046e-01f, 1.74665511e-01f,
  6.13358319e-02f, -8.67137164e-02f, -3.37623894e-01f, 1.63149953e-01f, -1.58345193e-01f, 4.39803213e-01f, -9.82258022e-02f, 7.48363510e-02f, 2.66729295e-01f, 1.07436396e-01f,
  -4.16892245e-02f, 7.34128505e-02f, 5.43963276e-02f, -3.63683477e-02f, 1.76953718e-01f, 1.64897382e-01f, 4.27327782e-01f, 4.21929270e-01f, 3.79121929e-01f, -3.57556313e-01f,
  -4.68387991e-01f, 3.44887406e-01f, -1.10206343e-01f, -3.15732419e-01f, 1.93989024e-01f, -4.02301610e-01f, -4.88551646e-01f, 4.15908426e-01f, 7.99007621e-03f, -1.74673721e-01f,
  2.33787909e-01f, -1.01077341e-01f, -3.84334587e-02f, 1.00662038e-01f, -1.77211627e-01f, 2.97177881e-01f, -1.02767445e-01f, 2.58972794e-01f, -1.78320646e-01f, 2.82372534e-01f,
  1.53811276e-02f, -4.88840878e-01f, 1.51013553e-01f, -1.41842604e-01f, 1.51414081e-01f, -3.17558259e-01f, 1.39856562e-01f, -3.99422169e-01f, -1.56588410e-03f, -1.12602614e-01f,
  -2.06147447e-01f, 1.63644046e-01f, 6.71049859e-03f, 2.37409193e-02f, -5.26497781e-01f, 2.14616656e-01f, -1.31176189e-01f, -7.82382488e-02f, -4.95704502e-01f, -2.07312524e-01f,
  2.58958399e-01f, 1.62167430e-01f, 1.24456219e-01f, -3.34068000e-01f, 2.39089534e-01f, 2.30508521e-01f, 1.93102345e-01f, -6.79962412e-02f, -1.98854476e-01f, -3.36193852e-02f,
  -9.94528532e-02f, -4.73285466e-02f, -2.33892813e-01f, -1.05328798e-01f, -1.74456954e-01f, -3.75180840e-02f, -3.37955505e-01f, -1.87000498e-01f, -2.62547672e-01f, 2.37746000e-01f,
  -2.71522999e-01f, -9.48872417e-02f, -4.25651819e-02f, 1.90442547e-01f, -4.00542349e-01f, -3.32697451e-01f, -1.55358195e-01f, -5.45696259e-01f, -3.85774374e-01f, 1.23531029e-01f,
  -2.22821206e-01f, -3.18930179e-01f, 1.99883282e-02f, -3.60781580e-01f, 2.53142416e-01f, 2.51919359e-01f, -2.52857029e-01f, 8.38866234e-02f, -5.38693309e-01f, 1.92463338e-01f,
  2.56665319e-01f, -6.01948351e-02f, 1.35705084e-01f, 1.14697583e-01f, -3.07733696e-02f, -4.45074528e-01f, -1.72037184e-01f, 7.24880323e-02f, -1.51813984e-01f, -4.47226852e-01f,
  -1.39266908e-01f, -4.01693463e-01f, -8.33417594e-01f, -1.52927218e-02f, -8.79084945e-01f, 2.45106146e-01f, 1.39841527e-01f, -1.56231523e-01f, -1.89752892e-01f, -1.04980774e-01f,
  -3.96885753e-01f, 9.14366543e-02f, 1.11330986e-01f, -1.08631182e+00f, -2.68997610e-01f, -2.91117579e-01f, -1.93339258e-01f, 1.51165932e-01f, -6.11916006e-01f, 6.39781356e-03f,
  2.68418252e-01f, -2.75193363e-01f, 1.96718559e-01f, -3.12174171e-01f, -4.31149662e-01f, 2.37504750e-01f, 3.27262014e-01f, 1.73352122e-01f, -2.19746768e-01f, -1.67892218e-01f,
  2.12778762e-01f, 9.00356621e-02f, -1.17659286e-01f, -2.02724397e-01f, -2.47307513e-02f, 2.19975039e-01f, -4.99895960e-01f, 2.87424424e-03f, 2.16062009e-01f, -1.84782654e-01f,
  -2.05814019e-01f, -1.62323356e-01f, -2.10772529e-01f, -3.79360542e-02f, 2.31853262e-01f, -1.26022190e-01f, 5.38314246e-02f, -4.59642202e-01f, 1.10398270e-02f, 7.00963214e-02f,
  1.21653505e-01f, -3.98086309e-02f, 3.37289385e-02f, -3.87632214e-02f, 2.19367370e-01f, -9.46095735e-02f, -1.13452233e-01f, -2.35193580e-01f, 3.00041996e-02f, 1.81383174e-02f,
  -5.53371124e-02f, 1.94556236e-01f, 7.71331042e-02f, -1.89382777e-01f, -2.16190606e-01f, -6.11961782e-01f, 1.45525515e-01f, 2.63706744e-01f, -9.35204700e-02f, 1.00626163e-01f,
  6.17708974e-02f, 2.11500406e-01f, -2.25027893e-02f, 9.69359353e-02f, 1.98829979e-01f, 9.08907279e-02f, 9.27299112e-02f, -4.71034832e-02f, -4.31094855e-01f, 1.74083248e-01f,
  -3.54034430e-03f, 6.14210851e-02f, 1.47302255e-01f, -4.51248676e-01f, -5.09704687e-02f, -5.73031381e-02f, 1.20086372e-01f, -4.50579166e-01f, 2.69369930e-01f, -5.10845780e-01f,
  -1.35692128e-03f, 1.69586703e-01f, 1.98085576e-01f, 3.26562561e-02f, 7.64704868e-02f, 1.83871627e-01f, 3.47364604e-01f, -1.98499903e-01f, -2.05715820e-02f, 5.13929904e-01f,
  -1.31579801e-01f, 3.52572262e-01f, -1.09688282e-01f, -2.12773725e-01f, 1.90567344e-01f, -9.39755365e-02f, -4.48864922e-02f, 7.01954812e-02f, 3.27477127e-01f, -3.05888236e-01f,
  2.13768497e-01f, 2.09576905e-01f, -1.81253120e-01f, 1.02670603e-01f, -8.36836025e-02f, -5.39961100e-01f, 2.80318022e-01f, -1.45444304e-01f, -2.81131029e-01f, 1.88271239e-01f,
  9.75036249e-02f, -2.46101364e-01f, 1.31788552e-01f, 7.00030848e-02f, 9.91751626e-02f, -6.21918729e-03f, 8.47021565e-02f, 9.78164524e-02f, -3.12212437e-01f, -7.60670006e-02f,
  7.86094889e-02f, -2.54863441e-01f, -1.04688272e-01f, -2.44101122e-01f, -1.00703269e-01f, -3.94807637e-01f, 1.73575923e-01f, -2.34351844e-01f, 3.67850184e-01f, 2.02238485e-01f,
  -1.51761591e-01f, -1.79100364e-01f, -4.00811404e-01f, -3.44491720e-01f, 1.29849300e-01f, -2.66406871e-02f, -2.39710838e-01f, -2.62290627e-01f, -5.74765727e-02f, -1.26367331e-01f,
  -1.63124688e-02f, 1.44173771e-01f, 1.75530493e-01f, -1.03759766e-01f, 1.64372876e-01f, -5.59896529e-02f, 1.18473828e-01f, -1.22789383e-01f, -1.57560721e-01f, 1.11997418e-01f,
  -2.41024187e-03f, -2.89563298e-01f, 3.15473646e-01f, -2.97746539e-01f, 7.20251501e-02f, -1.23175539e-01f, -3.02355051e-01f, 1.84244961e-01f, 6.36837408e-02f, 7.88221508e-02f,
  2.50676364e-01f, -3.87356967e-01f, -5.40261269e-01f, -2.72413403e-01f, -2.28373393e-01f, 2.97008723e-01f, -1.15189679e-01f, -5.15964091e-01f, -1.97157577e-01f, 4.85681333e-02f,
  1.84127435e-01f, -3.37624460e-01f, -2.22237885e-01f, -2.65531838e-01f, -3.77784789e-01f, -5.33916801e-02f, 4.98890020e-02f, -2.48123899e-01f, -2.86638260e-01f, -4.17784333e-01f,
  -1.76139697e-01f, 2.02725559e-01f, -1.46486446e-01f, 4.34232920e-01f, 2.75982320e-02f, -4.73047197e-01f, 1.72902793e-01f, -5.69991171e-01f, -4.70613092e-01f, 1.44677490e-01f,
  -3.73186141e-01f, 4.26217020e-02f, 2.35898599e-01f, 6.80461004e-02f, -2.82490373e-01f, -4.45447583e-03f, 3.10331225e-01f, 2.57189393e-01f, -4.05035019e-01f, -6.62730634e-01f,
  2.21123457e-01f, -5.40832542e-02f, -1.78408608e-01f, 1.15427673e-01f, -1.57856137e-01f, -2.24379823e-01f, 1.14099465e-01f, -2.65919477e-01f, -1.68232664e-01f, 5.39672561e-02f,
  1.93393886e-01f, 2.06199959e-01f, -1.00480050e-01f, 1.03615209e-01f, -2.00189024e-01f, 3.07096362e-01f, 1.83287803e-02f, 3.24202985e-01f, -7.43629187e-02f, -9.73512307e-02f,
  3.53988558e-01f, -2.61149973e-01f, -1.83340043e-01f, 7.82091841e-02f, 4.75060716e-02f, -1.97656825e-01f, -2.38863260e-01f, -5.49126007e-02f, -1.61742449e-01f, -2.92223096e-01f,
  -5.21575585e-02f, 1.50768772e-01f, -3.82015765e-01f, -1.84502378e-01f, -2.40366161e-01f, -1.74904138e-01f, 1.12223059e-01f, -2.84895092e-01f, 1.09305032e-01f, 5.80629110e-02f,
  -3.16039205e-01f, 3.06846142e-01f, -1.73497573e-01f, -2.92757852e-03f, -1.98029816e-01f, -2.67125666e-01f, 1.70819927e-02f, -1.85892507e-01f, 4.65758983e-03f, -4.59030747e-01f,
  3.04472558e-02f, 2.52379119e-01f, 1.45415947e-01f, -8.97320881e-02f, -2.07914889e-01f, 1.84124615e-02f, -1.25995344e-02f, -1.50913745e-01f, 5.88696264e-02f, -2.06024453e-01f,
  -6.16510585e-02f, 1.05955407e-01f, -1.72582299e-01f, -2.01914921e-01f, -2.24502981e-01f, 2.25116670e-01f, 2.57044613e-01f, -1.45316660e-01f, -1.70879036e-01f, -1.05446115e-01f,
  -1.83883354e-01f, 1.96098804e-01f, 1.65465921e-01f, 1.63880941e-02f, 1.00067705e-01f, -1.40237227e-01f, -1.64889425e-01f, -1.93882421e-01f, 2.55560398e-01f, -2.63302773e-01f,
  -2.66406953e-01f, -4.04978067e-01f, -1.34631380e-01f, 3.90389085e-01f, 5.63756786e-02f, 2.42095053e-01f, 1.00047871e-01f, -2.34347969e-01f, -1.44371077e-01f, 1.64396204e-02f,
  -4.02513415e-01f, 3.22469547e-02f, -4.12521988e-01f, 2.61290759e-01f, -3.57284583e-02f, -1.12746961e-01f, -5.43904364e-01f, -1.00048399e-02f, 2.40236625e-01f, -2.39909470e-01f,
  -2.93121397e-01f, -6.85503334e-02f, -9.04476419e-02f, 2.62194812e-01f, -3.12550724e-01f, -2.19408751e-01f, 1.05692983e-01f, -8.39784369e-02f, 5.30009381e-02f, -2.98279971e-02f,
  -1.41047761e-01f, -2.58446783e-01f, -3.60433012e-01f, -3.99614096e-01f, 6.30811602e-02f, 1.46042019e-01f, -3.29277217e-01f, -2.73769617e-01f, 3.03111881e-01f, -1.85570538e-01f,
  1.19831383e-01f, -2.66349763e-01f, 2.08166093e-01f, -4.51081038e-01f, -1.28115267e-01f, -2.62320340e-01f, 9.57485512e-02f, -3.75130117e-01f, -2.08948374e-01f, 3.77964884e-01f,
  -4.37265873e-01f, 1.74951687e-01f, 2.44339973e-01f, -3.37550640e-01f, -3.63089174e-01f, 2.09839210e-01f, -8.90526474e-02f, -4.59914617e-02f, -1.37443230e-01f, 1.64876342e-01f,
  9.24105644e-02f, -1.74063891e-01f, -3.89832348e-01f, -7.96521083e-02f, 2.35523969e-01f, 2.70879250e-02f, 4.70208198e-01f, -2.78271854e-01f, -1.23588100e-01f, -3.95827949e-01f,
  -4.61394250e-01f, 2.96684235e-01f, 1.54646695e-01f, -4.28915650e-01f, -4.35581394e-02f, -9.90373790e-02f, 2.25156918e-01f, 2.16977805e-01f, -3.85392696e-01f, -1.17262580e-01f,
  -3.01294699e-02f, -1.65340155e-01f, 8.05856138e-02f, -4.32511240e-01f, 2.83664949e-02f, 7.57376999e-02f, -6.84634671e-02f, -4.97529984e-01f, 1.99713245e-01f, -2.52954420e-02f,
  2.87286848e-01f, 1.46381408e-01f, 6.67420700e-02f, -3.99189353e-01f, -3.84411335e-01f, -5.90296313e-02f, -6.86256826e-01f, -6.98669136e-01f, 2.77090520e-01f, -1.16887249e-01f,
  1.22960716e-01f, 1.12749316e-01f, -3.12227994e-01f, 2.25642681e-01f, -5.95938601e-02f, 3.17237645e-01f, -4.47708964e-01f, -8.37594941e-02f, -4.66519706e-02f, 3.77011925e-01f,
  1.53042629e-01f, 2.46630415e-01f, 7.87882432e-02f, 4.57814336e-02f, -6.35085180e-02f, -9.94465947e-02f, -4.30773050e-01f, -3.10139626e-01f, 1.94900721e-01f, -6.86228499e-02f,
  -2.27367282e-01f, -2.49560177e-01f, -1.37861133e-01f, 2.30024960e-02f, -7.65250772e-02f, -9.36363414e-02f, -2.01045722e-01f, 2.86398917e-01f, -5.71869127e-02f, -4.17069823e-01f,
  -6.52827471e-02f, 2.27515280e-01f, -5.25458157e-01f, -1.76490650e-01f, 8.46338794e-02f, -3.79843533e-01f, -1.80024385e-01f, -7.49107823e-02f, -2.15057001e-01f, 3.95926386e-01f,
  -2.79871434e-01f, -4.23993051e-01f, -2.15913132e-01f, 1.83093607e-01f, -1.49801329e-01f, 8.17580149e-02f, -3.69900763e-01f, 2.20631525e-01f, -3.39617461e-01f, -3.51176083e-01f,
  -1.02465458e-01f, 3.39211933e-02f, 2.43983939e-01f, -2.81433314e-01f, 1.62359431e-01f, -3.00807476e-01f, 1.57490909e-01f, 1.38830498e-01f, -2.73969412e-01f, -2.40030572e-01f,
  -3.59909147e-01f, 2.30458990e-01f, -3.13960075e-01f, 2.30659530e-01f, -4.06071216e-01f, -3.21468621e-01f, 2.94373453e-01f, -5.30451417e-01f, 1.64654940e-01f, -2.63944298e-01f,
  2.45301515e-01f, 8.31478119e-01f, -2.24893540e-01f, -8.15244243e-02f, -2.97545791e-01f, -1.37288366e-02f, -1.83012381e-01f, -2.79517889e-01f, 3.15514386e-01f, -1.81419209e-01f,
  1.15848631e-01f, -3.79532337e-01f, -1.31987542e-01f, -2.79764980e-01f, -1.12391658e-01f, 7.69119896e-03f, -1.04819506e-01f, 1.20311892e-02f, 1.24749884e-01f, -5.33850677e-02f,
  -2.11584498e-03f, -2.50451595e-01f, -3.13126177e-01f, 5.59805483e-02f, 4.25704151e-01f, 3.81834656e-01f, -1.93466872e-01f, -1.98724851e-01f, 6.74812645e-02f, -3.53662111e-02f,
  1.16551243e-01f, 3.68605584e-01f, -1.73466101e-01f, -3.60197008e-01f, 2.53271341e-01f, -4.82471734e-02f, 7.45639205e-02f, -1.69170603e-01f, 1.36425957e-01f, 9.29254293e-02f,
  2.23471731e-01f, -2.31450245e-01f, 2.32130811e-01f, -4.78116333e-01f, -2.00535096e-02f, 4.77755815e-02f, 2.09187828e-02f, -1.08342431e-01f, -4.38464761e-01f, -1.43460482e-01f,
  -4.86226380e-01f, 2.02815056e-01f, 3.03309172e-01f, 2.60554198e-02f, -9.46528018e-02f, -1.76700518e-01f, -4.04529214e-01f, -6.80224001e-02f, -3.33050907e-01f, -1.60743088e-01f,
  -3.03361267e-01f, -2.62898445e-01f, 1.24366306e-01f, -2.97735125e-01f, 3.74660075e-01f, -3.46510619e-01f, 2.23615915e-01f, -2.33083233e-01f, -5.67793190e-01f, -8.95723403e-02f,
  -2.33338941e-02f, -2.36140624e-01f, -3.41523141e-01f, 1.67047143e-01f, 2.14767918e-01f, -3.52087647e-01f, -2.45799452e-01f, -8.17728713e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.49913952e-01f, -2.17813104e-02f, 7.58538395e-02f, -1.21362880e-01f, 2.57031992e-02f, 1.42582893e-01f, 3.99755910e-02f, 1.09859526e-01f, 4.96033989e-02f, 2.79049333e-02f,
  -4.14856756e-03f, -9.80326459e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    