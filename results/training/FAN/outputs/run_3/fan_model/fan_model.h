/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.08264911e-02f, 3.63384411e-02f, -1.45752475e-01f, 1.37818590e-01f, -6.08627908e-02f, 5.16097069e-01f, 3.42596531e-01f, -7.98162371e-02f, 9.35828090e-02f, 1.26510307e-01f,
  3.32887203e-01f, 2.99384678e-03f, 1.98997572e-01f, 3.97493124e-01f, 2.10719436e-01f, 3.94587159e-01f, 1.32154912e-01f, 1.18632600e-01f, -1.16881184e-01f, 4.50826883e-02f,
  -2.01475597e-03f, 1.68355390e-01f, 1.17467918e-01f, -2.12519586e-01f, 2.68645763e-01f, -3.21922690e-01f, 4.28492203e-02f, -6.69011995e-02f, -2.66546123e-02f, -1.00257825e-02f,
  -9.72896516e-02f, -2.25310698e-01f, -5.92361204e-02f, 2.29725279e-02f, -1.26520004e-02f, 3.28938328e-02f, -1.79579277e-02f, -4.95059378e-02f, 6.51704967e-02f, -1.22280687e-01f,
  -3.91601119e-03f, -1.38560355e-01f, -9.65982303e-02f, 1.32838234e-01f, 1.04689628e-01f, -3.75284255e-03f, 3.82368453e-02f, 8.64071473e-02f, -1.15724318e-01f, 2.72109527e-02f,
  7.64371902e-02f, 1.24216460e-01f, 1.69540182e-01f, 2.64790729e-02f, -4.89435531e-02f, 1.45438965e-02f, -1.12302244e-01f, 7.09306896e-02f, 1.05381273e-02f, -8.53219256e-02f,
  3.64678502e-02f, -2.21483372e-02f, 3.38388085e-02f, 3.67557816e-02f, -4.05254327e-02f, -8.37033987e-02f, 1.38584718e-01f, -5.24690673e-02f, -2.84206774e-02f, 7.80947879e-02f,
  3.47519554e-02f, -3.47407088e-02f, -1.65254548e-02f, 1.41690671e-01f, 4.36050743e-02f, -2.65067462e-02f, 4.37333733e-02f, 8.56407732e-02f, 9.36881546e-03f, 7.71324113e-02f,
  4.43109386e-02f, 6.12082072e-02f, 2.93569732e-02f, 1.39725313e-01f, 1.71614867e-02f, 9.81468856e-02f, 2.33812928e-02f, 2.78794412e-02f, -2.48963535e-02f, -1.54861817e-02f,
  1.31314127e-02f, -1.70387626e-01f, -6.47536665e-02f, 3.56534049e-02f, -3.49849388e-02f, -2.18619369e-02f, 8.20382833e-02f, -2.52312440e-02f, -9.25133973e-02f, 2.29427721e-02f,
  -1.40902484e-02f, -1.87288597e-02f, 1.69527214e-02f, 6.33582175e-02f, 4.59107570e-02f, 6.33549392e-02f, -3.33731063e-02f, -1.12277873e-01f, 4.59124446e-02f, 3.24825682e-02f,
  -2.05593705e-02f, -5.31444466e-03f, -1.99528620e-01f, -8.06852579e-02f, 3.71682905e-02f, -1.25968782e-02f, 5.46796545e-02f, -3.92546318e-02f, -1.88021492e-02f, -3.51162069e-02f,
  -1.65574268e-01f, 4.34449285e-01f, -1.60535738e-01f, -8.50634277e-02f, -1.29261836e-01f, 4.67993110e-01f, 2.68739253e-01f, -5.27401548e-03f, -1.69580325e-01f, 3.17417979e-01f,
  5.47517017e-02f, -5.82282059e-02f, 1.76665723e-01f, 1.69645950e-01f, -5.01830518e-01f, 3.68337750e-01f, 1.10918678e-01f, 2.59699494e-01f, -9.12232772e-02f, 5.55695184e-02f,
  -2.33728021e-01f, 1.49606809e-01f, 1.29802024e-03f, 1.19278297e-01f, -4.63063866e-02f, -7.37683102e-02f, -1.29772916e-01f, -4.59154062e-02f, 4.09760512e-02f, 4.11765277e-02f,
  1.14276364e-01f, 1.00435987e-01f, -8.08010697e-02f, 4.32664603e-02f, -2.83113476e-02f, 1.33987978e-01f, -4.57718968e-02f, -7.34307840e-02f, -2.23311350e-01f, 1.51964221e-02f,
  5.47872782e-02f, -5.72874630e-03f, -1.74550340e-02f, -6.96893185e-02f, 3.35820094e-02f, -1.00893363e-01f, -2.27852147e-02f, 4.25292701e-02f, 7.60103390e-02f, 5.53914495e-02f,
  -3.03054620e-02f, 4.56043007e-03f, -6.31699413e-02f, 6.78171366e-02f, -5.92605770e-02f, -7.86005035e-02f, 1.15168281e-02f, 8.73969961e-03f, 3.81518863e-02f, -3.28104980e-02f,
  1.38389379e-01f, 4.40475121e-02f, 4.52309847e-02f, -1.31380120e-02f, 5.23881754e-03f, 4.31925431e-02f, -9.07464046e-03f, 5.50972968e-02f, -1.27311379e-01f, 7.19312206e-02f,
  -3.25752534e-02f, -7.59121925e-02f, 4.42089066e-02f, -1.30346548e-02f, 1.14058312e-02f, 3.95335294e-02f, -8.17210879e-03f, 1.03037126e-01f, 1.38880201e-02f, -6.90029413e-02f,
  4.32889871e-02f, -4.33132984e-02f, 6.11528791e-02f, 7.71454349e-02f, 9.62483659e-02f, -1.14884928e-01f, -2.41020937e-02f, 2.35954039e-02f, 1.86736062e-02f, -3.04246899e-02f,
  1.15690403e-01f, 1.18036091e-01f, 8.02150518e-02f, -6.16466030e-02f, 4.58619818e-02f, -1.25209346e-01f, 1.45162940e-02f, -5.78812417e-03f, 2.31047142e-02f, 1.19651342e-02f,
  -2.11466476e-02f, -1.04687149e-02f, -4.44729952e-03f, -1.58119034e-02f, -5.75505719e-02f, 1.18367523e-01f, 2.56397370e-02f, -1.71961054e-01f, -1.31507874e-01f, -7.79013056e-03f,
  -4.74992357e-02f, -4.35747914e-02f, -1.40222386e-02f, 5.41441329e-02f, 2.66968478e-02f, 8.91349465e-02f, -9.53545719e-02f, 3.91376391e-02f, 1.36216581e-02f, 2.29243673e-02f,
  -1.54763728e-01f, -8.67494494e-02f, -2.80254662e-01f, -2.58623153e-01f, -2.79758155e-01f, 2.16524601e-01f, 3.49294245e-01f, -3.73954475e-01f, -6.02974482e-02f, 1.66821271e-01f,
  -7.31645077e-02f, 2.30867058e-01f, 1.77040756e-01f, -3.31281215e-01f, 8.21235627e-02f, -1.22541375e-01f, -8.66340399e-02f, 3.93684544e-02f, -1.41917676e-01f, -9.09613371e-02f,
  -2.16768086e-01f, -2.94502139e-01f, -4.87052947e-01f, -1.63294017e-01f, -1.66675806e-01f, -7.95470104e-02f, 3.26992087e-02f, -3.17212939e-02f, 7.67230615e-02f, 1.95617989e-01f,
  9.49352141e-03f, -2.47659355e-01f, -1.57469898e-01f, -5.77120390e-03f, -1.07704863e-01f, 9.77806374e-02f, 1.00819983e-01f, 1.41578745e-02f, -7.62493461e-02f, -1.61598790e-02f,
  1.47754341e-01f, -1.96978748e-01f, 9.58969891e-02f, 7.12643787e-02f, 2.18022522e-02f, -7.13910982e-02f, -1.17549568e-01f, -8.34276378e-02f, -2.45637284e-03f, -1.24132104e-01f,
  -5.35848327e-02f, -1.22565918e-01f, -7.70056099e-02f, 2.13867929e-02f, -5.78478500e-02f, 4.88093607e-02f, 2.38877628e-02f, 4.26797792e-02f, -3.78278159e-02f, -9.74981487e-02f,
  3.76833566e-02f, 9.86395553e-02f, -1.11799650e-01f, -5.04572764e-02f, 9.70069915e-02f, -1.30485341e-01f, 1.18506871e-01f, -6.30898774e-02f, -5.04985899e-02f, -7.06778094e-02f,
  -3.20773311e-02f, 1.94909357e-04f, -2.67758481e-02f, 5.38329557e-02f, -6.12222329e-02f, 8.19225609e-02f, -3.87475360e-03f, 8.81747976e-02f, -5.02140447e-02f, 1.96712464e-02f,
  -1.95478741e-03f, 8.14667046e-02f, 5.34543954e-02f, -6.91022053e-02f, 1.63248599e-01f, 5.88093959e-02f, -1.42046526e-01f, 6.93257600e-02f, 4.69478033e-02f, 1.58373360e-02f,
  2.76190311e-01f, 2.49945015e-01f, 2.42247209e-02f, -1.46547211e-02f, 6.19286038e-02f, -1.62514806e-01f, 6.03990071e-03f, -1.14782751e-01f, 1.25203505e-01f, 1.90930068e-03f,
  -7.66518414e-02f, 1.45794630e-01f, -3.57617550e-02f, -4.37192433e-02f, -4.07848544e-02f, 7.86406267e-03f, 1.70945331e-01f, 1.03688173e-01f, -9.51649025e-02f, 2.12175231e-02f,
  -1.27655417e-02f, -5.13781619e-04f, 1.90437213e-02f, -5.26368096e-02f, -1.66500937e-02f, -6.12876303e-02f, 9.00322050e-02f, 3.68650258e-03f, 3.89389470e-02f, 4.00295407e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.87953889e-01f, 3.69340092e-01f, -1.32429093e-01f, -6.40589356e-01f, 5.94749033e-01f, -2.32806817e-01f, -3.09991181e-01f, 1.89725146e-01f, -2.80881554e-01f, 6.33800268e-01f,
  -2.19781622e-01f, 3.76999825e-02f, -2.75568485e-01f, -9.83300388e-01f, -1.60770905e+00f, -1.15413535e+00f, -1.05559182e+00f, -3.98666978e-01f, -3.22440147e-01f, -1.26898229e-01f,
  -4.93120193e-01f, -5.35652399e-01f, -8.67080390e-01f, 5.91030121e-01f, 5.96779406e-01f, 7.36443341e-01f, 1.49647146e-01f, 7.41510451e-01f, 1.95885018e-01f, -2.07270890e-01f,
  -8.75760987e-02f, -1.47931904e-01f, 2.63446331e-01f, 2.26404313e-02f, -8.34609345e-02f, 2.52639800e-01f, 2.02924639e-01f, -1.19722702e-01f, -9.92857143e-02f, -5.05132452e-02f,
  3.19459498e-01f, 6.20156899e-02f, -1.41140640e-01f, 5.70392609e-02f, 4.78820831e-01f, 1.56115353e-01f, -1.30066842e-01f, 3.27723414e-01f, 7.93349743e-02f, -2.62891091e-02f,
  -1.45980731e-01f, 7.35295862e-02f, 1.25214592e-01f, -1.63125947e-01f, -6.59713969e-02f, 1.06845036e-01f, -2.02025529e-02f, 1.64942741e-01f, 2.02880561e-01f, -6.37427419e-02f,
  -1.41954109e-01f, 8.85736570e-02f, -7.98847824e-02f, 7.47884586e-02f, -7.44512528e-02f, 1.96157634e-01f, -1.29044026e-01f, 1.25468906e-03f, -1.08324373e-02f, 2.29536787e-01f,
  -3.68557088e-02f, -1.06387131e-01f, -9.94417295e-02f, 1.17593236e-01f, -1.05707347e-01f, -1.04957961e-01f, 6.38687164e-02f, 1.02504097e-01f, -7.89912939e-02f, -1.06712217e-02f,
  6.89513758e-02f, 1.92509014e-02f, -5.91875203e-02f, 2.29372218e-01f, -1.44310415e-01f, 6.02279268e-02f, 2.71490574e-01f, 1.81407835e-02f, -1.10022612e-01f, -4.69620526e-03f,
  6.31442815e-02f, -3.61035407e-01f, -9.69810709e-02f, 9.87866074e-02f, -1.62583411e-01f, -8.40680525e-02f, -2.50920534e-01f, 1.34316951e-01f, -3.04447394e-02f, -2.83882227e-02f,
  5.62859178e-02f, 1.24245130e-01f, 1.48663417e-01f, -4.69660275e-02f, -1.23884924e-01f, -2.02951767e-02f, -1.89908847e-01f, -2.91912816e-02f, -6.30531684e-02f, 1.19201556e-01f,
  2.63322920e-01f, -6.54856041e-02f, -4.46961969e-02f, 4.21985909e-02f, 1.50690809e-01f, 2.38470450e-01f, 9.60597545e-02f, 3.65777425e-02f, -5.42384014e-02f, 5.23763299e-02f,
  1.00162935e+00f, -9.91002917e-02f, -1.28396988e-01f, -1.68566883e-01f, -3.68363976e-01f, -6.04762137e-01f, -2.80209661e-01f, -5.30480444e-01f, 2.63102740e-01f, -2.35468090e-01f,
  -2.92083621e-01f, 4.71582085e-01f, 2.17428170e-02f, -3.13568830e-01f, -1.45178750e-01f, -2.49903593e-02f, -4.03117567e-01f, 1.68080684e-02f, 3.47960532e-01f, -1.04260013e-01f,
  2.05414712e-01f, -5.40977895e-01f, -1.57435611e-01f, -6.26620829e-01f, 1.06275104e-01f, 5.69785945e-02f, -3.90956938e-01f, -1.28573895e-01f, -1.77280888e-01f, -1.42843723e-01f,
  5.00166118e-02f, 2.15196460e-01f, -1.54424369e-01f, 1.42486423e-01f, -4.35621254e-02f, 1.27307072e-01f, 9.53234062e-02f, -3.08233887e-01f, 1.98949561e-01f, 1.18583731e-01f,
  2.69547880e-01f, 2.63993204e-01f, 1.79571752e-02f, -1.12771623e-01f, 2.36111686e-01f, 9.12782773e-02f, 9.45574120e-02f, 3.31540495e-01f, -1.09858140e-01f, 1.49366364e-01f,
  1.40681833e-01f, 2.75073618e-01f, 2.79886663e-01f, 9.58806127e-02f, 1.45130768e-01f, 8.79869834e-02f, 2.06853911e-01f, 1.33445412e-01f, 1.77078947e-01f, 2.81435907e-01f,
  1.32202744e-01f, 2.45301679e-01f, -8.93337280e-02f, 6.83562132e-03f, -6.48364127e-02f, 4.67057116e-02f, 2.88841128e-02f, 1.00996852e-01f, 6.04657419e-02f, -2.15435997e-01f,
  -8.29573274e-02f, -1.42732114e-01f, -3.89590301e-02f, 1.14381596e-01f, -2.31011678e-03f, 2.96440423e-01f, -2.55711414e-02f, -1.60381049e-01f, -3.52475159e-02f, -1.59064308e-01f,
  -5.96178770e-02f, 7.69512057e-02f, -3.02784622e-01f, -7.41090402e-02f, -9.57821086e-02f, -2.33302757e-01f, 2.75442123e-01f, 7.80875012e-02f, 1.35377971e-02f, -1.22619033e-01f,
  -1.90103441e-01f, -3.34766239e-01f, -6.20694831e-02f, -1.10948175e-01f, 1.19919134e-02f, -1.03693306e-02f, -5.34405112e-02f, -2.74173915e-01f, -2.49550231e-02f, -1.89451296e-02f,
  -1.56457663e-01f, -1.89754382e-01f, 2.97322839e-01f, 1.08719885e-01f, -3.72474752e-02f, -4.28340197e-01f, 1.54690161e-01f, 8.05868804e-02f, 2.24549025e-02f, 2.95122899e-02f,
  -9.54573452e-02f, 1.34027317e-01f, 1.62634626e-01f, -2.32402608e-02f, -3.78206256e-03f, 1.20431155e-01f, -5.17330766e-02f, 1.36705771e-01f, 7.78092220e-02f, -8.21793377e-02f,
  -3.14183354e-01f, -3.14484626e-01f, 2.31409132e-01f, -6.24540746e-01f, 2.45680317e-01f, 1.20427862e-01f, 1.78166360e-01f, -5.21887720e-01f, -6.71392441e-01f, -6.66442275e-01f,
  -2.17056885e-01f, 2.97940254e-01f, 7.35261142e-01f, -8.85354221e-01f, 1.06179702e+00f, 5.41983426e-01f, -8.12152803e-01f, -3.78934801e-01f, -1.19178258e-01f, -5.28846920e-01f,
  -1.51546180e-01f, -6.57326579e-01f, 2.55728513e-01f, -5.86654365e-01f, -4.43428874e-01f, -5.23441434e-01f, 1.99888572e-01f, 3.74561161e-01f, -7.03053415e-01f, 3.01173121e-01f,
  -4.01051827e-02f, -6.29901767e-01f, 6.94208518e-02f, -1.48169342e-02f, -1.58540115e-01f, 1.47617921e-01f, 1.65431932e-01f, 4.85523760e-01f, 1.30116537e-01f, -2.70920731e-02f,
  1.21591739e-01f, 9.72836614e-02f, -3.95863205e-01f, 1.71775237e-01f, -2.69313514e-01f, -9.40593556e-02f, -5.23434095e-02f, -1.23570316e-01f, -7.25519210e-02f, 1.06282949e-01f,
  3.42445672e-02f, 2.08582655e-01f, -2.03973472e-01f, -3.77478264e-02f, 1.15664802e-01f, -2.01257974e-01f, -4.10320312e-02f, 3.34040314e-01f, -8.02675784e-02f, -2.02153608e-01f,
  -5.03533147e-02f, -2.04057425e-01f, 1.16830222e-01f, -1.19018912e-01f, -1.21231608e-01f, -5.09646162e-02f, -1.77702587e-02f, -7.97925666e-02f, 1.60019342e-02f, -4.63503134e-03f,
  -1.30608395e-01f, -3.00215539e-02f, -1.02076232e-01f, -5.91963381e-02f, -1.04205228e-01f, -3.25097531e-01f, 2.99813211e-01f, -4.90562469e-02f, -1.53762668e-01f, -2.52830945e-02f,
  1.04747087e-01f, 9.16659948e-04f, -9.19532552e-02f, 9.22294930e-02f, -3.60743403e-02f, 2.51813054e-01f, -5.71951754e-02f, 8.09119344e-02f, -1.12459950e-01f, 1.79674298e-01f,
  -1.55225426e-01f, -6.95215940e-01f, -1.69563711e-01f, -8.28889459e-02f, 1.05965249e-01f, 1.11963049e-01f, -2.62805466e-02f, -1.59303278e-01f, -3.14522907e-02f, -1.20681837e-01f,
  -4.62959483e-02f, 6.60652816e-02f, -1.33579373e-01f, -7.70634487e-02f, 9.71754733e-03f, -1.60257757e-01f, -3.82614769e-02f, 1.10494737e-02f, -3.75383347e-02f, -5.30244596e-02f,
  -7.63377100e-02f, -1.10009179e-01f, 2.15202868e-01f, -2.30494961e-01f, -2.42492080e-01f, 3.06388531e-02f, -1.03909194e-01f, -1.69670917e-02f, 1.03487246e-01f, 3.03426012e-02f,
  1.42797482e+00f, -5.55234075e-01f, -4.59943056e-01f, 5.38069129e-01f, 4.67927605e-01f, 1.34289384e+00f, 1.11362183e+00f, 7.67886341e-02f, 4.27915782e-01f, -3.68955672e-01f,
  1.42702669e-01f, -1.98309079e-01f, -5.95585585e-01f, 7.11262465e-01f, 9.78433907e-01f, -1.93241134e-01f, 7.18887091e-01f, 5.12173414e-01f, -7.77269853e-03f, 6.34239614e-02f,
  9.17468518e-02f, 6.78946793e-01f, -5.09184122e-01f, -8.66293088e-02f, 4.09366816e-01f, -2.77274847e-01f, -3.78011018e-01f, -5.75705945e-01f, 7.77518973e-02f, 3.94568622e-01f,
  1.15801431e-01f, 4.74406742e-02f, 1.42370565e-02f, -6.72336966e-02f, -5.10597378e-02f, -1.62103977e-02f, -9.58403572e-02f, 2.20102832e-01f, -2.26577315e-02f, -3.39650363e-02f,
  -1.09556675e-01f, 1.51928112e-01f, 1.24006681e-01f, 8.91810879e-02f, 2.19402358e-01f, 2.57032388e-03f, -1.13124967e-01f, -1.70189053e-01f, -2.67682791e-01f, -2.99507640e-02f,
  7.25846216e-02f, -1.23679824e-01f, 6.88125864e-02f, -1.29430249e-01f, -1.15786456e-01f, 1.31774500e-01f, 2.11476162e-02f, -5.38305677e-02f, -1.38606414e-01f, 2.34991729e-01f,
  1.76760666e-02f, -1.33983297e-02f, 6.69787377e-02f, 2.20432300e-02f, 9.86082032e-02f, -2.08047349e-02f, 3.99008021e-02f, -1.32035032e-01f, -7.48632997e-02f, 3.44830304e-02f,
  -5.61043248e-02f, 5.87572902e-02f, -5.58316633e-02f, 5.44998422e-02f, -1.23087004e-01f, -8.70715082e-02f, 2.34064274e-02f, 1.71217846e-03f, -6.94907010e-02f, 5.83201945e-02f,
  -3.54237929e-02f, 9.96863842e-02f, -5.96836694e-02f, -1.21587753e-01f, 7.70420879e-02f, 8.40056315e-02f, 1.20087098e-02f, 5.88643178e-03f, -1.36280552e-01f, -4.08081822e-02f,
  -1.00166239e-01f, -5.43783188e-01f, -1.38956979e-01f, -6.49858862e-02f, -1.37132019e-01f, -1.95444338e-02f, -9.11509693e-02f, 2.43523464e-01f, 2.60241646e-02f, 5.99889904e-02f,
  1.20450139e-01f, -5.38966917e-02f, -1.11562833e-01f, 1.10270120e-01f, -4.46683317e-02f, 2.76240930e-02f, -2.80018330e-01f, 9.68390256e-02f, 8.71998966e-02f, -1.43417016e-01f,
  -1.75341442e-01f, 2.12615833e-01f, 1.41824093e-02f, 1.44200057e-01f, 9.15787593e-02f, -9.82771292e-02f, 1.25001684e-01f, -9.59226787e-02f, -1.03519790e-01f, -6.23625815e-02f,
  1.36197135e-01f, -3.01654369e-01f, -4.28614169e-01f, -1.15293125e-03f, -2.05712259e-01f, -1.30373865e-01f, -6.31007314e-01f, 3.94456744e-01f, -6.31280124e-01f, 2.19917744e-01f,
  5.34550786e-01f, -3.24398100e-01f, -1.48789182e-01f, 7.71406829e-01f, 5.61513066e-01f, 5.20863757e-02f, 8.37463617e-01f, 3.61003935e-01f, 1.08383950e-02f, 5.34516513e-01f,
  6.02020800e-01f, 8.40709090e-01f, 6.25216424e-01f, 7.92054892e-01f, 2.79140025e-01f, 3.79811257e-01f, 7.89377689e-01f, 2.49080494e-01f, 1.02196968e+00f, 1.92674354e-01f,
  -2.11985588e-01f, 1.49932439e-02f, -2.20760614e-01f, -2.82753289e-01f, 2.62815088e-01f, 2.14319259e-01f, -1.06002137e-01f, -8.86763483e-02f, -1.46403834e-01f, 6.40132371e-03f,
  -2.60741949e-01f, 3.53850126e-02f, -3.25036161e-02f, -3.96521091e-02f, -6.28245175e-02f, -1.11813180e-01f, 5.94266094e-02f, -1.80053078e-02f, -2.17719212e-01f, 6.70745745e-02f,
  -1.35518402e-01f, 2.60330420e-02f, 7.16951489e-02f, 1.13739252e-01f, -7.12244362e-02f, -1.88845962e-01f, -1.76235422e-01f, -6.67292699e-02f, -1.80115744e-01f, 1.52639270e-01f,
  2.07298383e-01f, 6.53714407e-04f, -5.37024699e-02f, -1.51606649e-01f, 6.91092387e-02f, -5.92042096e-02f, 3.52844298e-02f, 4.00852114e-02f, -6.71902895e-02f, 3.29719484e-02f,
  -1.17928095e-01f, -1.20907381e-01f, 1.32808253e-01f, 6.54372796e-02f, 2.02995449e-01f, -8.26171935e-02f, -2.34448630e-02f, 4.79742251e-02f, 1.26990490e-03f, -1.71622392e-02f,
  -5.72962500e-02f, 3.17425914e-02f, -3.52793327e-03f, 1.31495059e-01f, -2.24547267e-01f, 1.52405873e-01f, 1.81381032e-01f, 2.67215371e-01f, -3.21413204e-02f, -5.41051961e-02f,
  1.93406135e-01f, 5.58849394e-01f, -1.52849168e-01f, -1.98205575e-01f, -1.07306302e-01f, 7.52038658e-02f, 3.71369272e-02f, 1.63596317e-01f, 1.75257981e-01f, 1.34394288e-01f,
  4.24547076e-01f, -2.26304457e-02f, 1.38502672e-01f, 5.19007780e-02f, -7.21996184e-03f, 3.08122694e-01f, 1.41871244e-01f, -1.28594756e-01f, 1.02905601e-01f, 3.09996456e-01f,
  1.26320139e-01f, 1.08961966e-02f, 2.71725822e-02f, -3.59099299e-01f, -8.16245824e-02f, 1.94323078e-01f, -7.78665096e-02f, -1.10677809e-01f, 1.16513424e-01f, 6.00250475e-02f,
  9.88339901e-01f, -1.94032386e-01f, 9.82584536e-01f, 7.75435507e-01f, 2.84317493e-01f, 3.49560350e-01f, 7.03898311e-01f, 1.84983760e-01f, 9.79283035e-01f, -5.42363048e-01f,
  -7.09184587e-01f, 3.22435558e-01f, -1.93622727e-02f, -3.90623540e-01f, 2.28125900e-01f, -1.29893729e-02f, 8.94680992e-02f, 3.33376345e-04f, 1.34282574e-01f, -6.02785870e-02f,
  1.41633868e-01f, -7.34005630e-01f, 1.72176585e-01f, -7.98341751e-01f, 2.21428707e-01f, 4.77838106e-02f, -8.43169987e-01f, 6.31447658e-02f, -3.70597303e-01f, -3.55120659e-01f,
  2.95541808e-02f, -2.03997232e-02f, 3.18192430e-02f, 1.72576476e-02f, 1.69401646e-01f, 1.29265308e-01f, 3.41158696e-02f, 9.25629213e-03f, 2.43673787e-01f, 1.64889202e-01f,
  -3.13382298e-02f, -1.05547689e-01f, -1.20533019e-01f, 1.04145408e-02f, 2.40816429e-01f, 1.94930211e-01f, 1.43355012e-01f, 7.37292096e-02f, 1.12150274e-01f, 4.04334515e-01f,
  2.89545000e-01f, 2.22805172e-01f, 2.21749648e-01f, -2.34242938e-02f, 6.17868491e-02f, 2.80343276e-02f, 1.16955601e-01f, 7.62934089e-02f, -4.72947322e-02f, 1.34300321e-01f,
  -4.76298071e-02f, -9.06095952e-02f, -2.71904767e-02f, -1.85681760e-01f, -1.00641541e-01f, 4.59286086e-02f, 4.41350378e-02f, -1.80785060e-01f, 6.03886135e-02f, 5.30869653e-03f,
  -1.93573296e-01f, -8.12848732e-02f, 4.62007001e-02f, 2.73519129e-01f, 1.23048201e-02f, 9.61357653e-02f, -9.94209498e-02f, 8.42233971e-02f, -6.11992627e-02f, 6.99812844e-02f,
  2.91304477e-02f, -2.73796041e-02f, -1.44662127e-01f, 1.90237254e-01f, 7.54303336e-02f, 1.48673847e-01f, -6.26065880e-02f, 2.48017445e-01f, 6.23952262e-02f, -8.54172856e-02f,
  -4.44460124e-01f, -7.08818436e-01f, -2.88778812e-01f, -1.37497276e-01f, -6.97726533e-02f, -3.48346144e-01f, -3.29746269e-02f, 1.95995178e-02f, -1.14145368e-01f, 1.64706130e-02f,
  4.57647704e-02f, 3.36392112e-02f, -8.54788050e-02f, 7.02923983e-02f, -1.43888623e-01f, 1.18104942e-01f, -4.65226112e-05f, -3.19147527e-01f, -2.73235828e-01f, -2.00614840e-01f,
  -1.35895476e-01f, -1.63469419e-01f, 2.08723664e-01f, -1.11840770e-01f, -1.55792370e-01f, -7.13067055e-02f, 3.77318673e-02f, -3.86778340e-02f, -2.32568786e-01f, 8.51575658e-03f,
  -1.21104765e+00f, 1.02630854e+00f, 7.61098862e-01f, 8.74716134e-05f, -5.89347005e-01f, 4.03018832e-01f, 6.73268914e-01f, 2.32608840e-02f, -3.49842943e-02f, 7.56018579e-01f,
  -2.87000332e-02f, 5.25905967e-01f, 1.08935416e-01f, 6.64598882e-01f, -5.51632524e-01f, 1.59680739e-01f, 1.24050014e-01f, 3.60448837e-01f, 5.97592033e-02f, -3.57544303e-01f,
  -2.52160192e-01f, -3.95770133e-01f, 1.96453929e-01f, -5.21593392e-01f, 1.79507941e-01f, -2.43033562e-02f, -6.18304431e-01f, -5.56019880e-02f, 4.04426962e-01f, 1.31239846e-01f,
  -1.84947103e-02f, -8.70770290e-02f, 2.04764023e-01f, -1.28001114e-02f, 2.66365800e-03f, 5.63020520e-02f, 2.61892173e-02f, 2.17181787e-01f, -7.03528970e-02f, 9.05747339e-02f,
  -1.24231592e-01f, -9.91312489e-02f, 9.53867882e-02f, -3.03544067e-02f, 3.10083535e-02f, 2.12376729e-01f, 3.03667057e-02f, 2.12675497e-01f, 2.71091214e-03f, 2.13936701e-01f,
  3.68887812e-01f, 3.69866431e-01f, 5.12914322e-02f, 9.42760259e-02f, -1.47671383e-02f, 1.86725929e-01f, 2.37921700e-01f, 6.84911907e-02f, 7.30540305e-02f, 8.06241184e-02f,
  -1.77108139e-01f, 9.18943509e-02f, 1.77717000e-01f, -1.41177494e-02f, 6.00711629e-02f, -1.27413571e-02f, -4.20980826e-02f, -1.11735500e-02f, 7.12694079e-02f, -7.18876645e-02f,
  -1.77443936e-01f, -8.06310922e-02f, -1.68617070e-01f, -8.92232805e-02f, -1.77297860e-01f, -2.06491025e-03f, -6.84419181e-03f, -8.82393643e-02f, 5.48411906e-02f, -7.55334795e-02f,
  -4.34927642e-02f, -1.15628857e-02f, -1.24641759e-02f, -1.26748860e-01f, 4.56847176e-02f, 7.66234696e-02f, 4.58544865e-02f, -3.43815982e-03f, 1.98318250e-02f, -1.45634711e-01f,
  -7.50360072e-01f, -8.61971676e-01f, -6.55861199e-02f, 1.16502114e-01f, -5.45657091e-02f, 1.37544256e-02f, -5.31181432e-02f, 8.77566859e-02f, -2.80728377e-02f, -1.93192214e-01f,
  -2.60205753e-02f, 6.14243234e-03f, -2.05869764e-01f, 1.75817981e-01f, 2.53203008e-02f, -1.03568554e-01f, -2.95539081e-01f, -1.78551197e-01f, -1.95313960e-01f, -6.98910579e-02f,
  -9.29611027e-02f, -2.20158383e-01f, 9.48155075e-02f, -6.24657646e-02f, -1.96949858e-02f, 4.93628196e-02f, -1.34518147e-01f, 1.90172240e-01f, -1.47075251e-01f, -3.27737629e-02f,
  -1.29598510e+00f, 1.06385422e+00f, 4.66434181e-01f, -6.40457690e-01f, 6.44028366e-01f, 5.66550553e-01f, -4.23506320e-01f, 4.08905983e-01f, 5.83462059e-01f, -3.54029715e-01f,
  -5.03127813e-01f, -8.23797882e-02f, 5.72336093e-02f, -4.11596328e-01f, 3.42682928e-01f, 5.87832093e-01f, -2.06076205e-01f, -4.56516147e-01f, 7.46826947e-01f, -8.36252794e-02f,
  2.14488387e-01f, -4.73771095e-01f, -6.23594783e-02f, 2.48608053e-01f, -2.33103678e-01f, 2.42642360e-03f, -6.69842899e-01f, 4.33706760e-01f, -3.68067414e-01f, 2.29978785e-01f,
  1.13569334e-01f, 8.62472057e-02f, -2.16290221e-01f, 2.28470460e-01f, -1.40940994e-01f, -3.06950174e-02f, -1.24525256e-01f, 4.82743569e-02f, 2.12785210e-02f, 1.91776399e-02f,
  -1.64753541e-01f, 7.84694105e-02f, 3.06208991e-02f, 8.44983235e-02f, 3.64708751e-01f, 1.72947660e-01f, 1.29262537e-01f, -4.11327481e-02f, 1.14633627e-01f, 1.76123351e-01f,
  -2.74514947e-02f, 1.25259668e-01f, 4.73771170e-02f, 1.96830794e-01f, 9.12146643e-02f, 1.84268191e-01f, 2.32937261e-02f, 5.72862849e-02f, 1.06648505e-01f, 1.10668957e-01f,
  1.14692606e-01f, 2.43142933e-01f, -6.67281002e-02f, 8.43174104e-03f, 7.19736814e-02f, -6.91711009e-02f, 8.27895664e-03f, -1.09539799e-01f, -5.46002351e-02f, -1.66034684e-01f,
  -2.18956739e-01f, -1.75013900e-01f, 7.17117265e-02f, 3.23257968e-02f, -1.64283454e-01f, -1.44877166e-01f, -6.78072199e-02f, -1.83139667e-01f, 6.78668320e-02f, -1.06996698e-02f,
  5.00384606e-02f, 1.19106643e-01f, -1.29802018e-01f, -1.18107848e-01f, 5.41614220e-02f, 2.91074626e-03f, 4.68647704e-02f, 5.17583154e-02f, -9.55936536e-02f, -1.70918666e-02f,
  4.22774792e-01f, 4.60492522e-01f, 1.25810727e-01f, -1.91156909e-01f, -4.79527228e-02f, 4.42260550e-03f, 1.50114417e-01f, 1.94777343e-02f, 3.89106899e-01f, -9.61742774e-02f,
  -4.96125259e-02f, -2.31030777e-01f, -2.77866647e-02f, 8.40474740e-02f, 6.56253994e-02f, 4.78030890e-02f, -3.31712544e-01f, 1.32634148e-01f, -1.53773993e-01f, 1.93183587e-05f,
  -1.96538776e-01f, 1.34939114e-02f, -6.89857081e-02f, -1.58344209e-01f, -1.71791688e-01f, -1.72715858e-01f, -6.60007000e-02f, 1.16047546e-01f, -9.52382684e-02f, 1.23134784e-01f,
  -1.37853456e+00f, -1.07984030e+00f, 5.32156706e-01f, -4.93766963e-01f, 1.02655202e-01f, 1.34401932e-01f, 1.18030638e-01f, -7.38337636e-02f, -4.09038544e-01f, -8.24072957e-01f,
  -9.58507657e-02f, -4.05245632e-01f, -1.19979471e-01f, 6.22058846e-02f, 5.49913883e-01f, -5.19205257e-02f, -5.65492772e-02f, -1.77457869e-01f, 3.68815474e-02f, -3.99689078e-01f,
  -1.00061707e-01f, 2.38731265e-01f, 3.64358485e-01f, 4.42920811e-02f, -2.00366266e-02f, -1.51416153e-01f, -1.02721736e-01f, 1.09103046e-01f, 2.23546818e-01f, 3.26239079e-01f,
  -1.92202449e-01f, -4.25974518e-01f, -1.83028765e-02f, 2.76005995e-02f, -1.69080950e-03f, -2.36692484e-02f, 4.85263914e-02f, 1.58448309e-01f, 4.85168323e-02f, 1.82255190e-02f,
  -6.21372201e-02f, 1.06273688e-01f, 6.52615800e-02f, 3.27204354e-02f, -1.29222825e-01f, 5.68207912e-02f, -6.79471670e-03f, 1.75495595e-01f, -2.53370702e-02f, 2.26465799e-02f,
  -5.81083409e-02f, 8.12653005e-02f, -3.65255121e-03f, -4.50919569e-02f, 9.29191858e-02f, 5.64599922e-03f, 1.46666095e-01f, 4.83926125e-02f, -1.70672953e-01f, 3.87137430e-03f,
  2.01467350e-01f, 4.71115410e-02f, -1.15448125e-01f, -6.48914278e-03f, -1.27548343e-02f, 8.84278119e-02f, -6.78137764e-02f, 1.01814426e-01f, -1.19564883e-01f, -8.51529464e-02f,
  3.12094316e-02f, -1.27939343e-01f, 5.43281473e-02f, -7.06706522e-03f, -8.81057680e-02f, 5.06566428e-02f, 5.95647953e-02f, 1.02586463e-01f, -8.37895274e-02f, 7.75031894e-02f,
  -1.83965806e-02f, 6.00002124e-04f, -9.93076116e-02f, 3.83805409e-02f, -4.76270989e-02f, -3.93522792e-02f, -2.61845533e-03f, -9.24031134e-04f, 4.65329029e-02f, 4.47363630e-02f,
  -1.47491026e+00f, -1.04943490e+00f, -1.55523062e-01f, -9.11997855e-02f, -7.11943209e-02f, -2.36429408e-01f, -8.71367846e-03f, -6.25053495e-02f, -1.38899148e-01f, -7.38366768e-02f,
  -1.57053113e-01f, 4.60791923e-02f, 1.72992889e-02f, 4.50118892e-02f, 1.73554108e-01f, -1.36657596e-01f, -3.64962127e-03f, -1.58111125e-01f, -3.09196915e-02f, -7.99699873e-02f,
  -4.19008993e-02f, 1.26859322e-02f, 1.86009675e-01f, -8.37160833e-03f, 7.03755161e-03f, -1.43256653e-02f, -1.26027405e-01f, -5.30534163e-02f, 1.15100689e-01f, -5.85093815e-03f,
  -1.26332712e+00f, 2.44487658e-01f, -7.69401670e-01f, -5.57867112e-03f, -9.57866549e-01f, -9.03853893e-01f, -7.49834776e-02f, -9.69395563e-02f, 4.01853144e-01f, 6.54529989e-01f,
  1.40520632e-01f, 3.46817017e-01f, 8.06486726e-01f, -2.14898586e-02f, -5.15529990e-01f, 8.06540847e-01f, -7.02010274e-01f, -5.01008406e-02f, 5.69663867e-02f, -2.87679672e-01f,
  -3.85475278e-01f, -4.33772989e-02f, -4.65529203e-01f, 7.33823627e-02f, -8.51801038e-01f, -3.05058748e-01f, -3.83688033e-01f, 2.35040542e-02f, -8.28289270e-01f, -2.97587812e-01f,
  -6.15750313e-01f, 3.84833962e-01f, -1.74268439e-01f, -3.50251943e-02f, -4.06287968e-01f, -3.37927967e-01f, -3.26515704e-01f, 1.62632674e-01f, 7.79872909e-02f, 5.12653030e-02f,
  8.36227685e-02f, 3.56392413e-02f, 5.13521880e-02f, 2.53103614e-01f, -3.19164470e-02f, -9.14124325e-02f, -1.00588381e-01f, -3.29427361e-01f, 1.11437798e-01f, -3.26360054e-02f,
  -1.58338159e-01f, -8.68808776e-02f, -1.91179469e-01f, -2.32180506e-02f, -4.17180121e-01f, -5.01490198e-02f, 2.04387736e-02f, -1.49792163e-02f, -2.87300825e-01f, -7.16229677e-02f,
  -1.29079774e-01f, -1.46398380e-01f, 2.48032242e-01f, 7.50935525e-02f, 9.17707980e-02f, -1.42533541e-01f, 1.61522061e-01f, -3.06617981e-03f, -3.57082263e-02f, -9.52574983e-02f,
  -6.08286932e-02f, 5.47560826e-02f, 5.16760275e-02f, -7.36522004e-02f, -3.32665667e-02f, 1.74390525e-01f, 9.21914354e-02f, -2.76944842e-02f, 1.09960278e-02f, -1.28344521e-01f,
  2.48146698e-01f, -5.68200946e-02f, 8.13163538e-03f, 2.01920955e-03f, -7.24419802e-02f, 1.66138828e-01f, 2.57185046e-02f, -1.22490211e-03f, -4.82445350e-03f, -1.92176357e-01f,
  -1.00186408e+00f, -2.41078869e-01f, 2.19000906e-01f, -7.89294541e-02f, -3.31255868e-02f, -8.18420723e-02f, 1.16100088e-01f, -4.66808259e-01f, -7.35738352e-02f, -6.01447672e-02f,
  2.40787547e-02f, 1.51976570e-01f, -3.17861259e-01f, 3.69586088e-02f, 9.08330306e-02f, -3.40655632e-02f, 4.44221310e-02f, 4.75890078e-02f, -2.48268843e-01f, -3.07608366e-01f,
  2.91783400e-02f, 1.99780643e-01f, 3.40800248e-02f, -2.62789205e-02f, 8.13141689e-02f, -1.06017828e-01f, -1.47731796e-01f, 2.99475323e-02f, -1.63902175e-02f, 4.30229194e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.54963303e+00f, 7.24542677e-01f, 3.47823948e-01f, 1.27836263e+00f, 9.38744664e-01f, 1.23636711e+00f, 1.06502581e+00f, 7.63455153e-01f, 1.18747973e+00f, 3.67265761e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.67083728e+00f, -1.71879053e+00f, 4.63380992e-01f, 7.82002658e-02f, 6.35356665e-01f, 4.66317028e-01f, -1.08413732e+00f, -1.14138234e+00f, -8.83237839e-01f, -9.06126499e-01f,
  2.58146614e-01f, -8.89265537e-01f, 1.13100874e+00f, -1.06515920e+00f, 5.29604554e-01f, 7.96123564e-01f, -1.44512844e+00f, -2.57040799e-01f, 8.43324780e-01f, 1.43298435e+00f,
  1.76540458e+00f, -4.26256120e-01f, -9.13659453e-01f, 4.74105507e-01f, -3.80162477e-01f, 9.34602797e-01f, 5.90925694e-01f, -1.47172880e+00f, -3.20178777e-01f, -5.29536128e-01f,
  -1.53167295e+00f, -1.05005383e+00f, 8.26708555e-01f, -6.10275805e-01f, -1.81720510e-01f, -5.24417162e-01f, -1.35470188e+00f, -1.24968983e-01f, 4.05171514e-02f, -5.01543999e-01f,
  -8.55239749e-01f, 7.32583404e-01f, 5.37275821e-02f, -1.26576102e+00f, -1.46725106e+00f, -1.23495650e+00f, 1.16988647e+00f, -6.57592654e-01f, -2.89104491e-01f, -2.19613519e-02f,
  -4.16550219e-01f, -8.76286685e-01f, 1.06482673e-02f, -7.12727308e-01f, 6.19477451e-01f, -1.10694778e+00f, -4.72216338e-01f, -9.55241263e-01f, -1.17585576e+00f, -1.41668439e+00f,
  -2.66755790e-01f, 3.96931887e-01f, 2.47323602e-01f, 1.22325766e+00f, 1.43723238e+00f, 5.03540814e-01f, -6.93071723e-01f, 6.48075163e-01f, 9.77557838e-01f, -1.21843755e+00f,
  -3.92543286e-01f, -1.35994434e+00f, 4.00685996e-01f, -1.85255861e+00f, -8.58068913e-02f, 1.59996554e-01f, 6.37657285e-01f, 9.83300984e-01f, 9.66361225e-01f, -4.45181340e-01f,
  1.12688375e+00f, 9.47016418e-01f, 5.26496530e-01f, 1.03849244e+00f, 1.07637668e+00f, 1.77841866e+00f, -1.64420068e+00f, 1.82585061e-01f, -1.16661453e+00f, 2.39487872e-01f,
  -8.14859986e-01f, 5.88258326e-01f, -2.88635403e-01f, 1.13334656e+00f, -1.47177315e+00f, 7.19360113e-01f, 1.03549808e-02f, -5.06160259e-01f, -4.44393605e-01f, -4.02597785e-01f,
  -9.21935499e-01f, -1.60367227e+00f, -3.75621051e-01f, 3.75064909e-01f, -1.27384090e+00f, 8.06298435e-01f, -1.63010907e+00f, 1.16632295e+00f, -1.42220473e+00f, -3.34303051e-01f,
  -8.93808305e-02f, -9.39658403e-01f, -5.44366539e-01f, 1.66790366e-01f, -5.61927378e-01f, -7.67234325e-01f, -3.67905825e-01f, 9.88830179e-02f, -6.95151687e-01f, 9.38851297e-01f,
  1.03144121e+00f, -1.13379323e+00f, -5.47979295e-01f, -5.34695268e-01f, -1.01886678e+00f, 9.42498744e-02f, -3.08851659e-01f, 5.11400878e-01f, 1.16560102e-01f, 4.84862626e-01f,
  -7.45852053e-01f, -8.35737824e-01f, -1.70859647e+00f, -9.76421118e-01f, -6.30008638e-01f, -2.35715240e-01f, -6.60575509e-01f, -1.21734905e+00f, 1.12957215e+00f, -3.00939620e-01f,
  -2.15676740e-01f, 5.81665002e-02f, -8.09366822e-01f, -4.57555860e-01f, 1.36448711e-01f, 1.07188813e-01f, 1.93797916e-01f, 5.96129596e-01f, -8.53724718e-01f, 1.00385475e+00f,
  -1.10507154e+00f, -1.81914136e-01f, 1.47482526e+00f, -2.79944509e-01f, -4.50102061e-01f, 3.55008841e-01f, 3.76376659e-02f, -1.26684177e+00f, 6.50841832e-01f, -1.11937392e+00f,
  3.17683071e-01f, 8.86130691e-01f, 3.89680773e-01f, -8.17715645e-01f, 4.55973223e-02f, 1.25284922e+00f, 1.30555034e+00f, -3.19327682e-01f, -5.31981409e-01f, -9.31598425e-01f,
  -1.32204488e-01f, -8.50154817e-01f, -1.96772039e+00f, -6.40479207e-01f, -4.29258734e-01f, -7.36535668e-01f, 3.94454151e-02f, 1.74953174e-02f, 5.15463710e-01f, -5.66962659e-01f,
  -3.18586566e-02f, -5.68216264e-01f, 4.01451856e-01f, 5.19678295e-01f, -9.01752651e-01f, -9.54061925e-01f, -1.10122848e+00f, 8.38050783e-01f, 9.89956856e-01f, -5.17436206e-01f,
  -1.07445633e+00f, -1.14185286e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.73737347e-01f, -1.70126930e-01f, -6.53137505e-01f, -7.30378091e-01f, 2.77938008e-01f, 5.84060133e-01f, -1.39917463e-01f, -4.38805401e-01f, 6.80085942e-02f, -3.31819057e-01f,
  2.78097719e-01f, -2.70215631e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    