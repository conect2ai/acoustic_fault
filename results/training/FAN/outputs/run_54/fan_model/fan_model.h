/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.53734505e-01f, -4.07714210e-02f, 4.41811621e-01f, 1.95811577e-02f, -4.36668396e-02f, -8.72410610e-02f, 3.76539305e-02f, -8.73012526e-04f, 2.01811895e-01f, -5.86300716e-02f,
  -1.47864893e-01f, 1.25175387e-01f, 1.31706923e-01f, -4.59246010e-01f, 9.65618938e-02f, -1.42241701e-01f, -5.79417683e-02f, 4.90862019e-02f, -4.35306281e-02f, 1.30446717e-01f,
  3.67491618e-02f, -4.40064132e-01f, 5.82222156e-02f, -1.27069324e-01f, 7.66050369e-02f, 1.09076314e-01f, 8.21403693e-03f, 1.16157942e-01f, -1.72139645e-01f, -7.09523484e-02f,
  -2.85425019e-02f, 1.13711074e-01f, 6.56351671e-02f, 1.19479448e-01f, 1.02318928e-01f, 4.00869846e-02f, 1.53562665e-01f, 6.31272420e-02f, 4.48012352e-02f, 7.27230217e-03f,
  4.85361479e-02f, 4.03906778e-03f, -5.77501021e-02f, -1.21664843e-02f, 7.75252134e-02f, 1.03878066e-01f, -6.90253153e-02f, -1.17599621e-01f, -2.57810615e-02f, -1.90424696e-02f,
  -4.80847843e-02f, -4.86867949e-02f, 8.44440907e-02f, 2.49144062e-02f, 1.19424857e-01f, -2.10641325e-02f, 8.16426426e-03f, 9.13765188e-03f, 5.68812676e-02f, 8.81048888e-02f,
  -2.08138637e-02f, 4.33325209e-02f, -1.60029307e-02f, -3.97044867e-02f, 2.82440819e-02f, 3.30881141e-02f, 6.37523085e-02f, -1.02569368e-02f, 1.21436253e-01f, 2.80515533e-02f,
  -3.20846960e-02f, 3.74922678e-02f, 4.49465960e-03f, 7.28422683e-03f, -1.54635916e-02f, 3.64842378e-02f, -3.29341181e-02f, -2.27555763e-02f, -1.16763553e-02f, 1.35354716e-02f,
  7.91433919e-03f, 2.90115513e-02f, -1.53402295e-02f, -2.53117085e-02f, -3.82358134e-02f, 8.33892915e-03f, -1.53753720e-02f, 2.23953798e-02f, 2.61806510e-03f, 3.84587049e-02f,
  1.33187220e-01f, 3.67598563e-01f, -7.68954530e-02f, 3.72814499e-02f, -2.12201253e-02f, -3.62603404e-02f, -4.92399186e-02f, -3.06541566e-02f, -7.00841006e-03f, 3.67255583e-02f,
  8.71506054e-04f, 2.20431983e-02f, 5.05645759e-02f, -2.59984732e-02f, -7.46690482e-02f, -7.16257021e-02f, -4.38757334e-03f, 1.14748023e-01f, 7.67912418e-02f, -1.35800326e-02f,
  8.48738030e-02f, 7.27302581e-02f, 3.94433290e-02f, 2.53316257e-02f, -3.54334130e-03f, -8.58342722e-02f, 6.00268580e-02f, 2.69598537e-03f, -5.04774926e-03f, -3.23306117e-03f,
  -3.33567083e-01f, 1.68365300e-01f, -3.20682257e-01f, -2.21040294e-01f, -3.15889865e-02f, 3.24682593e-01f, 1.54291928e-01f, 3.06225028e-02f, 2.54354044e-03f, 3.33300263e-01f,
  2.05179676e-01f, -3.71159166e-01f, 4.14718419e-01f, -2.53946297e-02f, -2.77122080e-01f, 2.59114116e-01f, -1.37425676e-01f, -8.06795955e-02f, -2.91505028e-02f, -2.40280535e-02f,
  -1.88057050e-01f, 1.90634668e-01f, -2.11456716e-01f, 5.84529415e-02f, -1.67179614e-01f, -1.51599646e-01f, -2.93990374e-02f, -3.65940183e-02f, -5.84070235e-02f, -6.62490949e-02f,
  2.30543450e-01f, -5.99177778e-02f, -1.07323490e-01f, -9.32799745e-03f, 6.41065016e-02f, 3.11706271e-02f, -3.66336550e-03f, 3.37366574e-03f, -1.06750242e-01f, 3.48122939e-02f,
  1.99819487e-02f, -5.82468277e-03f, -2.90940329e-03f, 2.77273115e-02f, 1.01630352e-02f, 2.26334315e-02f, -6.81346506e-02f, -1.69790182e-02f, 2.42563542e-02f, -8.16758256e-03f,
  -1.53359501e-02f, 2.68368912e-03f, -2.40787193e-02f, 5.34698851e-02f, -3.30829434e-02f, 6.87148273e-02f, -4.19020876e-02f, -6.78749457e-02f, 1.18267275e-02f, -1.65585931e-02f,
  -4.93252948e-02f, 1.20029561e-01f, -2.07311008e-02f, 1.05478890e-01f, -1.37899572e-03f, 2.99619436e-02f, 5.58348745e-03f, 2.72804815e-02f, -8.16230103e-02f, 1.05225950e-01f,
  -1.80972703e-02f, -9.10962522e-02f, 3.06818057e-02f, 3.00055905e-03f, 1.22570861e-02f, -3.60555351e-02f, -5.84906824e-02f, 1.06870137e-01f, 2.12652031e-02f, 2.48949882e-02f,
  -1.00449128e-02f, 5.70170619e-02f, -9.07996949e-03f, 5.68247810e-02f, 4.26696502e-02f, -4.90387827e-02f, 4.19268534e-02f, -1.99078899e-02f, 9.75125805e-02f, -1.47938952e-02f,
  3.96968514e-01f, 8.05705115e-02f, 9.02284235e-02f, 1.86258964e-02f, -4.43329401e-02f, 1.72073918e-03f, -3.22496810e-04f, -5.77408187e-02f, 7.01419860e-02f, 3.75478044e-02f,
  5.29141650e-02f, 3.87302740e-03f, -9.42727365e-03f, -1.67335931e-03f, -4.19305079e-02f, 7.27724507e-02f, 1.56902568e-03f, -7.02755973e-02f, -2.63977703e-02f, 2.94963899e-03f,
  -3.73378135e-02f, 7.74201984e-03f, -6.16867393e-02f, 2.98085753e-02f, -3.70843150e-02f, -1.82603169e-02f, -3.18012647e-02f, -2.70025968e-03f, -3.22944894e-02f, -2.42407806e-02f,
  -7.61437938e-02f, 1.67917550e-01f, -6.12701289e-02f, 1.43149078e-01f, -1.65866222e-02f, -4.97316182e-01f, -4.52401578e-01f, -4.23012003e-02f, 1.71233520e-01f, -1.27350688e-01f,
  -9.78377238e-02f, 4.19800818e-01f, -2.77658165e-01f, 2.37120405e-01f, -2.13011876e-01f, -8.42271298e-02f, -1.81050226e-01f, -4.15595844e-02f, 1.70163885e-01f, -6.30346835e-02f,
  -4.39522229e-02f, 1.42902657e-01f, -7.43707642e-02f, 1.41830519e-01f, 3.82399894e-02f, 2.09866151e-01f, -1.68438330e-01f, 1.74709968e-02f, 1.13987617e-01f, 1.57253802e-01f,
  -4.30469252e-02f, 1.89859152e-01f, 1.11800022e-01f, 5.22068441e-02f, -1.99095041e-01f, -2.34872662e-02f, -1.44568577e-01f, 1.63096562e-01f, 8.55078399e-02f, -1.30081037e-02f,
  2.43201163e-02f, 2.45325100e-02f, 1.09103113e-01f, 7.72180557e-02f, -1.31825253e-03f, 1.76773801e-01f, 2.97714882e-02f, -7.29558840e-02f, -1.26525173e-02f, 9.62872580e-02f,
  1.94149353e-02f, -4.33659134e-03f, -1.44156322e-01f, 2.68898048e-02f, 3.69608477e-02f, 1.52081102e-01f, 2.19173706e-03f, -4.35262099e-02f, 5.70363514e-02f, 6.07785359e-02f,
  -5.20909168e-02f, 4.12905961e-02f, 1.21121317e-01f, 8.38713720e-02f, 1.99453551e-02f, 2.61332430e-02f, -2.52990965e-02f, -4.16531116e-02f, 4.90657389e-02f, -1.19609937e-01f,
  -4.90451306e-02f, 2.97323763e-02f, -2.88845003e-02f, -1.76388007e-02f, 6.95459470e-02f, 3.46502103e-02f, -6.53451979e-02f, 8.86870399e-02f, -8.10431764e-02f, 3.92183699e-02f,
  8.40829834e-02f, -6.83784932e-02f, -1.64274103e-03f, -1.72822565e-01f, -1.46318793e-01f, 5.53124994e-02f, -5.13580209e-03f, 2.10759882e-02f, -7.57225603e-02f, -9.36350226e-02f,
  -1.83916017e-01f, 1.96620096e-02f, 2.56251860e-02f, -7.12134391e-02f, 8.05554017e-02f, -1.58568807e-02f, 8.67529586e-02f, 1.45646743e-02f, 1.71842985e-02f, -2.60624290e-02f,
  -2.84519512e-02f, -6.67446572e-03f, -9.35943201e-02f, -2.58593895e-02f, -6.90625980e-02f, -3.25086452e-02f, -1.28810275e-02f, -9.15770233e-02f, -1.47693440e-01f, -3.50222811e-02f,
  2.32106913e-02f, -4.20515127e-02f, 5.96007034e-02f, -3.64514403e-02f, -8.38135555e-02f, -2.81821992e-02f, 9.73030254e-02f, 4.72761616e-02f, -4.41718064e-02f, 1.50521593e-02f,
  -4.94832724e-01f, 2.50367016e-01f, 2.76146680e-01f, -3.33059311e-01f, -2.63895363e-01f, 2.01116484e-02f, -1.82409719e-01f, -3.47161724e-04f, -1.30982563e-01f, 2.92481422e-01f,
  -2.09741101e-01f, 1.16988771e-01f, -1.92057136e-02f, -9.13508013e-02f, -6.10676765e-01f, 1.94712132e-02f, -6.64177462e-02f, -7.69206956e-02f, 1.08196884e-01f, -1.46459490e-01f,
  -8.68842229e-02f, -2.76476115e-01f, -1.57671515e-04f, 2.42580771e-01f, -5.68440296e-02f, 1.58655047e-01f, 2.53345910e-02f, 2.42007554e-01f, -8.15666653e-03f, -5.27475476e-02f,
  -4.04708460e-02f, -7.23877624e-02f, 2.30487324e-02f, 1.08151227e-01f, -4.22779061e-02f, -6.30762894e-03f, 7.92452879e-03f, 8.64222050e-02f, -5.19739278e-02f, 6.88307807e-02f,
  5.60596921e-02f, -3.25365514e-02f, 1.51174832e-02f, 8.60961378e-02f, -2.84101255e-02f, 3.51221748e-02f, -3.31282765e-02f, 1.15828551e-01f, 1.38386218e-02f, -1.11880422e-01f,
  3.55199985e-02f, 2.72629950e-02f, 6.00875802e-02f, 8.31549615e-02f, -1.24152731e-02f, 5.76547114e-03f, 3.51361074e-02f, 2.10169721e-02f, -1.72402654e-02f, -4.87110689e-02f,
  1.10101506e-01f, 6.78920769e-04f, -1.71791352e-02f, 2.31621154e-02f, -1.67263160e-03f, -5.11978287e-03f, 6.09787442e-02f, 5.85110951e-03f, 7.98639283e-02f, -1.30600482e-01f,
  4.73988662e-03f, -1.70309514e-01f, -2.60345470e-02f, 7.91032612e-02f, -3.62135321e-02f, -4.34670113e-02f, 7.04001263e-02f, 3.93037871e-02f, 3.51148704e-03f, -5.32373637e-02f,
  -1.76525861e-02f, -2.67666075e-02f, 5.32111488e-02f, -7.79604539e-02f, 9.10853818e-02f, 1.82853676e-02f, 9.99484435e-02f, 6.80949315e-02f, 5.80041297e-02f, -7.23369718e-02f,
  -2.55263686e-01f, -1.04062758e-01f, -6.37041479e-02f, -8.44277591e-02f, 7.94853717e-02f, 6.69958144e-02f, 3.73522826e-02f, 2.54095644e-02f, 1.90361410e-01f, -4.57493812e-02f,
  3.57289091e-02f, -2.42825709e-02f, 2.59076227e-02f, -1.06770108e-02f, 3.18079367e-02f, -1.28486171e-01f, 3.35042514e-02f, 7.75093883e-02f, -8.40594992e-02f, -9.60946782e-04f,
  3.84533070e-02f, 4.53927517e-02f, -5.93241639e-02f, -5.54378070e-02f, 1.38701242e-03f, -3.97193758e-03f, -2.98550893e-02f, 4.40571271e-02f, -1.00245001e-02f, 6.98706210e-02f,
  -7.75594115e-02f, 4.22542207e-02f, -5.66136800e-02f, -1.56026438e-01f, 9.67707336e-02f, -2.25505084e-01f, -3.96617055e-01f, 1.49660513e-01f, -1.83915377e-01f, 6.09161593e-02f,
  -3.07780743e-01f, 2.78150976e-01f, -1.72108576e-01f, -3.95798683e-01f, -1.28040522e-01f, -3.73237491e-01f, -6.85022026e-02f, -1.43957824e-01f, 2.42134538e-02f, 8.64706188e-02f,
  -1.91866644e-02f, 8.14263448e-02f, -2.24522442e-01f, 2.98626453e-01f, 1.87374912e-02f, 2.92361349e-01f, 1.34429246e-01f, 5.78575395e-02f, 1.44205153e-01f, 6.41518310e-02f,
  -1.72315359e-01f, -1.80440307e-01f, -5.67231849e-02f, 5.26456833e-02f, -4.12949733e-03f, 3.79176885e-02f, 2.43238658e-02f, 2.69984342e-02f, -7.95775205e-02f, 2.18897257e-02f,
  -7.03277290e-02f, 7.06314519e-02f, 2.34987419e-02f, 1.01921894e-01f, 3.59649844e-02f, 6.94219209e-03f, -3.26507166e-02f, -8.17791000e-03f, 7.40690529e-03f, -7.18629584e-02f,
  -1.28894016e-01f, -5.98041303e-02f, 1.25967581e-02f, 1.01554364e-01f, 3.74527685e-02f, -5.89617062e-03f, 3.32889846e-03f, 5.69515713e-02f, 3.89053673e-02f, 3.70503552e-02f,
  6.51419237e-02f, -3.18118148e-02f, -4.69049625e-02f, -5.05978949e-02f, -3.19458470e-02f, -2.33266242e-02f, 2.53214780e-02f, 7.28138816e-03f, 5.20880930e-02f, -2.57663080e-03f,
  -7.70067889e-03f, 4.44108061e-03f, -3.87226902e-02f, 7.09832786e-03f, 2.23785099e-02f, -1.10200899e-05f, 2.64202133e-02f, 1.27181590e-01f, -1.15480714e-01f, -1.23764435e-02f,
  -6.47327080e-02f, 3.85842705e-03f, -1.46680502e-02f, -1.05612241e-01f, -3.78503427e-02f, -5.15001342e-02f, 1.79955959e-02f, 3.17035131e-02f, -2.02194974e-02f, -2.66457554e-02f,
  2.73402669e-02f, 3.25692564e-01f, 2.25202646e-02f, 5.55079617e-02f, 5.25601916e-02f, 3.71502861e-02f, 3.68450209e-02f, 9.74235032e-03f, 1.07462250e-01f, -1.98265668e-02f,
  1.02362260e-01f, -3.46328989e-02f, 7.41503313e-02f, 7.21371360e-03f, 2.26933770e-02f, -6.53904974e-02f, -5.18282468e-04f, 6.31465241e-02f, 1.99378505e-01f, 7.45902359e-02f,
  3.35393436e-02f, -1.00030592e-02f, 6.80889562e-02f, -1.00468554e-01f, 3.59857343e-02f, 9.25481971e-03f, 4.90438305e-02f, -6.79055676e-02f, 5.37728108e-02f, -1.28486231e-02f,
  -2.35262349e-01f, -1.24395393e-01f, 2.60860443e-01f, -7.53642470e-02f, 2.46393397e-01f, -1.27884466e-02f, 1.42206609e-01f, -1.57221049e-01f, -4.04330939e-01f, -2.76358187e-01f,
  -9.80791375e-02f, 5.63993268e-02f, -1.80708412e-02f, -1.00080714e-01f, -1.41038552e-01f, -3.17941517e-01f, -1.51025355e-01f, -2.45468095e-01f, -3.38259339e-02f, 1.02709398e-01f,
  -4.51672077e-02f, -1.12550408e-01f, 2.06472620e-01f, 1.25702545e-01f, 8.65019783e-02f, 2.02285811e-01f, 6.85798377e-02f, 2.68468589e-01f, 2.35231984e-02f, 7.68524557e-02f,
  -6.65786266e-02f, -8.24687928e-02f, -5.95880523e-02f, 4.40794788e-02f, 5.37382700e-02f, 6.87473193e-02f, 4.24672514e-02f, 4.78314571e-02f, 4.50202636e-02f, 2.75411159e-02f,
  -6.03775606e-02f, -5.12472838e-02f, -1.17171928e-02f, 6.39210492e-02f, -4.84946296e-02f, 5.54102622e-02f, -5.72162531e-02f, -4.50238474e-02f, -6.51759887e-03f, 2.80180592e-02f,
  -4.45977263e-02f, 1.10018894e-01f, 9.65915620e-02f, 8.67941231e-02f, 7.63290823e-02f, -1.54495239e-02f, 1.19285539e-01f, 1.50751993e-01f, -4.31980677e-02f, -1.66658804e-01f,
  -1.43827558e-01f, 9.98616815e-02f, 6.88843951e-02f, -7.48523232e-03f, 6.58592358e-02f, 1.65880978e-01f, 3.49461958e-02f, 4.82635200e-03f, 1.13042966e-02f, -4.29346375e-02f,
  -8.08336139e-02f, 2.45576240e-02f, 1.02972914e-03f, -5.70043921e-02f, -5.56623749e-02f, -1.05033346e-01f, 6.02978542e-02f, 5.37959337e-02f, -8.28271732e-02f, 9.27770603e-03f,
  -1.88610181e-02f, -3.14025618e-02f, -4.32099514e-02f, 7.43021742e-02f, -9.31758806e-02f, 4.17759530e-02f, 5.20078503e-02f, -5.59836179e-02f, -4.79569426e-03f, -1.49535621e-03f,
  -4.67814282e-02f, -1.43839300e-01f, -1.61332451e-02f, -8.88651535e-02f, 9.86026004e-02f, -1.82391211e-01f, -1.05223320e-02f, -5.30901626e-02f, -1.24939978e-01f, 7.93450885e-03f,
  3.08192950e-02f, 2.68995706e-02f, 8.47535804e-02f, 3.67993414e-02f, 1.36988044e-01f, -1.06266148e-01f, 2.54975017e-02f, -6.58425642e-03f, 1.09906949e-01f, 2.89695729e-02f,
  3.50271463e-02f, 6.14960399e-03f, 8.89666006e-02f, -5.61765470e-02f, 5.57879135e-02f, -2.34397445e-02f, -3.58677097e-02f, -9.10528675e-02f, 1.03661925e-01f, 1.04647502e-01f,
  4.47110057e-01f, 1.94506124e-01f, -1.67398348e-01f, 3.98523450e-01f, -4.99081127e-02f, -3.57561521e-02f, -5.72944209e-02f, 2.45216072e-01f, 2.40043681e-02f, 2.84284770e-01f,
  -6.66996697e-03f, 1.72472745e-01f, -2.86655992e-01f, 3.68225574e-01f, -2.42258102e-01f, -3.35983872e-01f, 2.81506091e-01f, 2.12100744e-01f, -1.86571002e-01f, 2.64272153e-01f,
  4.48567048e-02f, 2.33876616e-01f, -3.37138884e-02f, -5.51387146e-02f, 2.77543962e-01f, 2.28667129e-02f, 1.21401869e-01f, -1.90935448e-01f, 1.69226661e-01f, -7.51788914e-02f,
  6.93684816e-03f, 9.54587981e-02f, 6.03514537e-03f, -1.65093653e-02f, 1.26464382e-01f, -4.53891940e-02f, 6.92219213e-02f, -2.41340443e-01f, -1.50277361e-01f, -4.23559621e-02f,
  6.41023219e-02f, 5.29173799e-02f, 2.16562953e-02f, -1.00820787e-01f, 8.63199607e-02f, -3.28136608e-02f, -1.53042218e-02f, 7.14577809e-02f, -5.97348288e-02f, -1.12389520e-01f,
  1.68026872e-02f, 2.72945203e-02f, 2.70085186e-02f, 7.03628734e-02f, -1.07708581e-01f, -1.32550910e-01f, -1.60240289e-02f, -3.04855667e-02f, 6.65396452e-02f, 6.34039044e-02f,
  -6.79221824e-02f, -3.52038816e-02f, 1.74758118e-02f, -3.13727297e-02f, 3.08972709e-02f, 8.92478600e-02f, -8.24057534e-02f, 7.26412702e-03f, 1.13891223e-02f, 2.35394444e-02f,
  9.43992510e-02f, 1.25205740e-01f, 1.47312820e-01f, 2.34374288e-03f, 4.22919691e-02f, 1.64880008e-02f, 1.59795061e-02f, 4.39432487e-02f, 1.51226491e-01f, -3.25381086e-04f,
  4.21488918e-02f, 3.14597711e-02f, 1.01925433e-01f, 5.85142113e-02f, -1.74541096e-03f, -6.02372773e-02f, 1.02514632e-01f, 6.08486608e-02f, -7.48986602e-02f, -3.79819386e-02f,
  2.15987429e-01f, 3.27057719e-01f, -9.26755965e-02f, 8.47435817e-02f, 1.80031452e-02f, 1.74816791e-02f, -1.52923092e-01f, 3.46523523e-02f, -3.07128709e-02f, 8.28875154e-02f,
  -5.15304394e-02f, 5.73392175e-02f, 1.47861317e-01f, 7.16820033e-03f, -5.87229095e-02f, 4.42414209e-02f, 5.89713380e-02f, -3.04667410e-02f, 7.76614994e-02f, 2.97398418e-02f,
  7.26446882e-02f, -6.29215837e-02f, -1.51733920e-01f, 1.00134782e-01f, -5.73005639e-02f, 5.24870977e-02f, 1.31887674e-01f, -4.69931886e-02f, -7.56362602e-02f, 5.53034283e-02f,
  3.46296161e-01f, -8.05895329e-02f, -2.87080575e-02f, 2.13447466e-01f, -3.58587146e-01f, 5.75631596e-02f, -1.19397737e-01f, -1.88289076e-01f, 1.44398466e-01f, 7.91910738e-02f,
  1.20429777e-01f, 3.15792561e-01f, 4.00702022e-02f, 1.39202982e-01f, 4.84494001e-01f, 2.67343402e-01f, 2.35423267e-01f, 2.54865676e-01f, 2.10617021e-01f, 3.63466218e-02f,
  1.28988609e-01f, -1.06709741e-01f, -3.04709524e-01f, -3.02007556e-01f, -3.40732366e-01f, -1.67660356e-01f, -1.27270743e-01f, -1.47989690e-01f, 3.73478569e-02f, 6.14852794e-02f,
  -8.99592936e-02f, 1.31999757e-02f, -6.83377534e-02f, -7.22484738e-02f, 1.55023308e-02f, -3.92184258e-02f, 6.51307330e-02f, -1.11331092e-02f, -1.68501232e-02f, -1.57023706e-02f,
  2.95374040e-02f, 4.50792769e-03f, 7.90555179e-02f, 6.35528862e-02f, -1.71874598e-01f, 4.31403778e-02f, 6.65219799e-02f, -2.95747817e-03f, -8.47770497e-02f, -4.21483740e-02f,
  5.97885810e-02f, 4.86620627e-02f, 2.28699427e-02f, 1.84932902e-01f, -2.89200828e-03f, 5.89391328e-02f, -6.90439418e-02f, -7.19368979e-02f, 6.48053437e-02f, 4.37397994e-02f,
  1.01820007e-01f, -9.55409631e-02f, -5.94130456e-02f, 9.56512429e-03f, -1.63637698e-02f, -2.81849355e-02f, 2.36612968e-02f, -3.73903662e-02f, -1.49955619e-02f, -3.29952542e-04f,
  8.18137601e-02f, -7.85039440e-02f, -4.89042886e-02f, 7.85530545e-03f, 3.43545452e-02f, -9.93771106e-02f, -2.79159993e-02f, 1.15856327e-01f, -8.74474347e-02f, -5.94879240e-02f,
  -2.55507659e-02f, -5.80416322e-02f, 1.65521353e-02f, -1.23185948e-01f, 2.55888551e-02f, -9.36389342e-03f, -9.06534791e-02f, -8.27618241e-02f, -7.27953762e-02f, -2.27107871e-02f,
  2.43652478e-01f, 1.77321672e-01f, -3.47528942e-02f, 5.71112521e-03f, 2.83454005e-02f, 1.27232313e-01f, 3.80925015e-02f, -2.84992736e-02f, 7.60930404e-02f, 6.78620413e-02f,
  -6.67325556e-02f, -5.19925132e-02f, -2.03338061e-02f, 6.02853261e-02f, -4.27136989e-03f, 1.06284795e-02f, 1.10097177e-01f, -1.64209530e-02f, 4.35428396e-02f, 5.04487008e-02f,
  -5.64695075e-02f, 5.42392209e-03f, -1.02824144e-01f, -1.44888207e-01f, 2.32340507e-02f, 2.99828164e-02f, 4.35370356e-02f, -7.49810459e-03f, -4.96743843e-02f, 2.08405908e-02f,
  -9.84828398e-02f, -1.38777923e-02f, 2.73251921e-01f, 8.09420794e-02f, 9.54522844e-03f, 1.61508173e-01f, 1.27168000e-01f, 3.35723422e-02f, 4.11515385e-02f, -6.43424690e-02f,
  -3.96153145e-02f, -1.23429492e-01f, 4.13236581e-03f, 1.31443724e-01f, -3.26511264e-01f, 1.97287977e-01f, -1.79032795e-02f, -5.40717915e-02f, 9.80176479e-02f, -1.21383592e-01f,
  2.24606898e-02f, -1.24328151e-01f, 2.79553115e-01f, -9.81746018e-02f, 2.72717983e-01f, 4.91044149e-02f, -2.77528316e-01f, 6.11043870e-02f, -1.45577222e-01f, -1.46777174e-02f,
  7.43059441e-02f, 1.46627411e-01f, 2.27908030e-01f, -1.12724276e-02f, -1.15868719e-02f, -5.05009145e-02f, 1.84997916e-02f, 1.03937373e-01f, 1.68526974e-02f, 2.86788885e-02f,
  -2.50782613e-02f, -9.37585756e-02f, -5.46813682e-02f, -3.90963182e-02f, 4.64859381e-02f, 1.99654214e-02f, 1.63579419e-01f, 1.13124736e-01f, 5.81497326e-02f, 1.75255805e-01f,
  1.37722656e-01f, 4.44149561e-02f, 2.90128924e-02f, -8.05687308e-02f, -2.39966512e-02f, -2.89890748e-02f, -9.68490634e-03f, -2.11826786e-02f, 2.10548863e-02f, -4.11195308e-02f,
  -6.48641810e-02f, -6.04566820e-02f, 8.32070932e-02f, -2.69450489e-02f, -7.04257339e-02f, 5.78890629e-02f, -7.54758418e-02f, -3.36791687e-02f, 5.05936146e-02f, 9.68016591e-03f,
  -2.73847803e-02f, -1.66877881e-02f, 6.88904673e-02f, 1.48875429e-03f, 2.50824774e-03f, -2.97292229e-02f, 1.05347242e-02f, -5.85041232e-02f, 2.21686549e-02f, 1.14385076e-01f,
  3.55273001e-02f, -3.59490849e-02f, 6.41078800e-02f, -4.43663932e-02f, -1.32624194e-01f, 6.93631098e-02f, 2.38632802e-02f, 7.15226755e-02f, 1.29070029e-01f, -4.85945120e-02f,
  -4.39955264e-01f, -6.07966840e-01f, -3.73872034e-02f, -2.96194069e-02f, 4.33191396e-02f, 8.96089748e-02f, -9.32274293e-03f, 5.61927222e-02f, -1.18651800e-03f, 5.81415719e-04f,
  -3.74140160e-04f, 1.03518754e-01f, -1.60859898e-01f, 9.73337144e-02f, -2.17465311e-02f, 5.25577031e-02f, -7.40884170e-02f, -6.01648204e-02f, -1.63060352e-01f, -1.05083637e-01f,
  -1.71227574e-01f, -8.44280422e-02f, -3.87755185e-02f, 3.00752204e-02f, -4.67096940e-02f, -6.66756034e-02f, -1.09757394e-01f, 1.82435252e-02f, -1.03753820e-01f, -2.42448710e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.09829381e-01f, -3.40307802e-01f, -7.47449815e-01f, -4.12461489e-01f, 9.42881182e-02f, -8.70442331e-01f, -5.69354534e-01f, -1.46719992e-01f, 1.73034042e-01f, 2.58597046e-01f,
  5.60113713e-02f, -1.35709718e-01f, 3.89720917e-01f, -7.10117280e-01f, -6.28718197e-01f, -5.93180768e-02f, -8.43510926e-01f, -5.84826291e-01f, 2.36237928e-01f, -3.60409439e-01f,
  -1.28515273e-01f, -3.38533074e-02f, -5.18438160e-01f, 3.70867372e-01f, -2.60169357e-01f, 9.01440904e-02f, 4.65580761e-01f, 2.55885631e-01f, -4.59965229e-01f, -3.90396155e-02f,
  -3.09793085e-01f, 2.36265481e-01f, -1.30256668e-01f, -5.97944520e-02f, -2.43837759e-01f, 7.27898851e-02f, -1.08856834e-01f, -3.05491909e-02f, 8.14600512e-02f, -3.35781742e-03f,
  3.38650905e-02f, 1.71562895e-01f, -1.59283906e-01f, 2.52185911e-01f, 1.12937354e-01f, 2.06321627e-02f, -5.41251153e-02f, -7.53531754e-02f, 4.30611484e-02f, -1.25105143e-01f,
  -2.28593960e-01f, -9.96093005e-02f, -5.55383936e-02f, 1.76044845e-03f, -6.02316717e-03f, 5.92231564e-02f, -2.12874204e-01f, -1.46115929e-01f, -3.31903212e-02f, 5.27535826e-02f,
  5.89396320e-02f, 1.93873778e-01f, 1.11122625e-02f, 9.48546380e-02f, -2.05837656e-02f, 1.50297105e-03f, 7.26692453e-02f, 2.26079039e-02f, 1.59633338e-01f, -1.07110299e-01f,
  -3.88020165e-02f, 2.98732822e-03f, 1.05329253e-01f, -1.18396841e-01f, -9.86495540e-02f, 6.05305582e-02f, -7.04389531e-03f, 5.03308214e-02f, -1.58108532e-01f, -1.23305634e-01f,
  2.79771894e-01f, -2.14937981e-02f, 2.19936557e-02f, 4.79331166e-02f, -3.63307595e-02f, 1.57363936e-01f, 2.72682220e-01f, -8.87149498e-02f, 2.07125340e-02f, -6.20186739e-02f,
  -2.03090459e-01f, 1.73931625e-02f, -6.87184278e-03f, 8.28996003e-02f, -3.93012948e-02f, -7.38188475e-02f, -1.74488544e-01f, -1.69896051e-01f, -1.13823253e-03f, 1.32339284e-01f,
  -8.40288773e-02f, -5.93932271e-02f, 3.62398406e-03f, 2.37091631e-02f, -8.23522639e-03f, -9.17467624e-02f, 7.03431889e-02f, 1.00822918e-01f, -8.49262625e-02f, -8.09861049e-02f,
  7.47629404e-02f, 6.79570958e-02f, -5.21060172e-03f, 2.25966740e-02f, 3.46983671e-02f, -1.43657001e-02f, 2.48388611e-02f, -4.29806449e-02f, 7.38500953e-02f, -5.52972332e-02f,
  -1.06780398e+00f, 6.10943437e-01f, 2.13824332e-01f, -5.21751225e-01f, 2.60166436e-01f, 5.53146042e-02f, -2.56758839e-01f, 3.50160092e-01f, -2.92840868e-01f, 3.97093475e-01f,
  7.63396034e-03f, 2.70268042e-02f, 1.68443352e-01f, -3.87757033e-01f, -8.68516386e-01f, -5.58701336e-01f, -5.10829866e-01f, -1.59900442e-01f, -1.79155678e-01f, -1.02280816e-02f,
  -3.23992163e-01f, -3.86635661e-01f, -3.14917654e-01f, 3.69143069e-01f, 2.49937877e-01f, 4.05372441e-01f, -1.08707093e-01f, 5.36153734e-01f, 1.35043219e-01f, -1.39273494e-01f,
  -1.79087222e-02f, 1.29841223e-01f, 2.28976652e-01f, 2.35744212e-02f, -8.12321305e-02f, 1.08042903e-01f, 1.65555358e-01f, -3.15214396e-02f, -8.65656286e-02f, -4.35824618e-02f,
  4.98959981e-02f, -4.80395230e-03f, -1.18706189e-01f, 1.93921085e-02f, 1.41607344e-01f, 2.45873466e-01f, 1.58911735e-01f, 1.56126931e-01f, 1.45951435e-01f, 9.26599577e-02f,
  1.45105630e-01f, 8.72498229e-02f, -3.67387049e-02f, -3.14216129e-02f, -1.60259847e-02f, 1.77123040e-01f, -1.19072706e-01f, 7.81311989e-02f, 6.59283996e-02f, 3.81238349e-02f,
  -1.45781130e-01f, -1.28856927e-01f, -4.30784076e-02f, -3.22693251e-02f, -4.46045585e-02f, 1.08648941e-01f, -9.82011259e-02f, 4.47687134e-02f, -3.42286155e-02f, 4.70861979e-02f,
  -3.54640558e-02f, 7.91224244e-04f, 2.06617778e-03f, -6.41633868e-02f, -2.87336688e-02f, -1.18806079e-01f, -2.90001463e-02f, 6.37047812e-02f, -4.86305505e-02f, -6.95607290e-02f,
  3.47432569e-02f, -7.49816746e-02f, -6.57272935e-02f, 1.01633305e-02f, -1.03279203e-01f, -4.46702577e-02f, 7.08116964e-02f, 1.99194029e-02f, -1.06330968e-01f, 3.81958634e-02f,
  1.32596074e-02f, 5.91220558e-02f, 1.62535477e-02f, 8.73144418e-02f, 8.19007307e-02f, 1.00146636e-01f, -1.48618892e-01f, 6.58702552e-02f, -1.22990698e-01f, -1.39185831e-01f,
  1.14818372e-01f, 2.25557573e-02f, 7.78326541e-02f, -1.94237474e-02f, -1.32302955e-01f, -6.85310587e-02f, -2.49239127e-03f, -4.04694788e-02f, -3.21727470e-02f, 1.32149532e-01f,
  1.81901947e-01f, 5.00802211e-02f, -1.05343938e-01f, 3.82099040e-02f, -8.72343853e-02f, 4.85121831e-02f, -8.10620114e-02f, 3.12937573e-02f, 6.25516698e-02f, 5.23004495e-02f,
  4.21718329e-01f, -4.57545817e-01f, 2.67136306e-01f, 9.66500640e-01f, 3.11398834e-01f, -6.22405350e-01f, -1.17368177e-01f, 2.20822483e-01f, 5.39589107e-01f, -7.29626596e-01f,
  1.16625182e-01f, -5.12870491e-01f, -4.88961458e-01f, 2.27498308e-01f, 3.06759566e-01f, -2.63760537e-01f, 3.17791134e-01f, -1.75875321e-01f, 3.04100543e-01f, 8.20081159e-02f,
  4.97908950e-01f, 1.98688015e-01f, 2.78230786e-01f, 8.92577693e-02f, 3.12080294e-01f, 3.34302336e-01f, 4.11318809e-01f, -1.14089318e-01f, 5.50459847e-02f, -6.98862690e-03f,
  -1.82203531e-01f, 2.52599627e-01f, 9.45488140e-02f, -1.80791721e-01f, 1.88636884e-01f, -2.20943224e-02f, -5.59306033e-02f, -1.44049570e-01f, 1.06615946e-01f, -5.15052453e-02f,
  -1.48671597e-01f, -9.29840803e-02f, 1.10671751e-01f, 1.54168988e-02f, 3.56595628e-02f, 9.05761495e-02f, 5.08018471e-02f, 8.95828288e-03f, 2.20656898e-02f, -1.05982229e-01f,
  1.14850542e-02f, 3.99863385e-02f, 1.25280470e-01f, 1.80547293e-02f, 1.49463266e-01f, 2.16588467e-01f, 6.24734499e-02f, -2.21650731e-02f, -2.39023082e-02f, 2.37246022e-01f,
  -1.04392454e-01f, 6.42481074e-02f, -5.08019850e-02f, 4.72963825e-02f, -1.53209567e-02f, 2.17802420e-01f, -1.77551992e-02f, -4.16843109e-02f, 4.34836298e-02f, -1.01404898e-02f,
  9.72191840e-02f, 5.02871647e-02f, 1.31604373e-01f, 1.14021301e-01f, 6.56764656e-02f, 7.56449327e-02f, -6.32739589e-02f, -8.51167366e-03f, 1.21207565e-01f, 8.52590874e-02f,
  1.99055430e-02f, 8.24019685e-03f, -1.33842736e-01f, -3.77054401e-02f, 1.22495862e-02f, 1.89110450e-02f, 9.54192802e-02f, -5.41108511e-02f, 1.98757686e-02f, -1.46956807e-02f,
  -2.84361839e-01f, 2.07004562e-01f, -5.09827351e-03f, -9.79894251e-02f, -9.12676156e-02f, -5.08533604e-02f, -1.81799252e-02f, -8.14773515e-02f, 4.40704413e-02f, 2.35018856e-03f,
  1.65432296e-03f, -5.59764393e-02f, -4.61795479e-02f, -6.80711307e-03f, -9.60245878e-02f, 1.72447003e-02f, 4.62375581e-02f, 7.68821761e-02f, 1.24830246e-01f, 2.48420164e-02f,
  3.57857309e-02f, -2.01864377e-01f, 4.37724357e-03f, 5.62059134e-02f, -1.66026074e-02f, -6.04819134e-02f, 1.21465615e-04f, 4.62461226e-02f, 3.13502736e-02f, 9.72101837e-03f,
  -6.74739718e-01f, -2.16797590e-01f, 1.75789759e-01f, -1.53340831e-01f, 1.40081286e-01f, -2.51664609e-01f, -7.33245909e-01f, 3.25998098e-01f, -3.28816801e-01f, -5.33638954e-01f,
  -3.32277954e-01f, -4.34448540e-01f, -3.44345182e-01f, -8.78188610e-02f, 3.61253589e-01f, -2.47204751e-01f, 5.06457210e-01f, -2.17794832e-02f, 2.87669718e-01f, 1.66927263e-01f,
  3.72462541e-01f, 9.86990929e-02f, 6.42454088e-01f, 8.27573538e-01f, 7.95315653e-02f, 3.68682384e-01f, 3.44007134e-01f, 2.67379552e-01f, 4.95171249e-01f, 3.16588655e-02f,
  -8.87932554e-02f, -3.05211246e-01f, -4.69997972e-02f, 2.34361097e-01f, 8.31117928e-02f, -1.01144142e-01f, 1.28486216e-01f, -1.13553107e-01f, 9.73128602e-02f, 1.06421962e-01f,
  -1.19247712e-01f, 1.86118126e-01f, 1.00885397e-02f, 1.06111534e-01f, 5.00056148e-02f, 1.37797654e-01f, 1.52422205e-01f, 3.84297743e-02f, 1.07906997e-01f, -1.42774716e-01f,
  -6.60348460e-02f, -6.40876144e-02f, -1.14955336e-01f, -5.07270321e-02f, -5.91925392e-03f, -5.36613688e-02f, 4.16756421e-03f, -3.12905982e-02f, -2.54820217e-03f, -3.74095589e-02f,
  -2.44453549e-02f, -6.59065023e-02f, 4.09433804e-02f, -9.61164683e-02f, -9.74549949e-02f, -3.90340164e-02f, -6.66136071e-02f, 4.27949019e-02f, -3.26745398e-02f, -6.90259635e-02f,
  7.93867745e-03f, 9.14335344e-03f, -3.28362063e-02f, 5.65075353e-02f, -9.77635831e-02f, -2.29276940e-02f, 2.28256118e-02f, 9.74050686e-02f, 8.59468710e-03f, 6.61132559e-02f,
  -9.35611129e-03f, 1.39632717e-01f, 5.60733378e-02f, 8.75642374e-02f, -1.16196685e-02f, -3.69677059e-02f, 5.33545157e-03f, -1.63884126e-02f, 7.61654973e-02f, 1.11784562e-01f,
  -6.74331635e-02f, -4.16872650e-02f, 7.75878830e-03f, 5.93135282e-02f, 7.14233592e-02f, -2.19762083e-02f, 1.89282876e-02f, 2.22606156e-02f, 1.09362423e-01f, -7.17540681e-02f,
  1.17445052e-01f, 1.40788108e-01f, -1.12788200e-01f, -2.62881927e-02f, 1.59901991e-01f, -6.38432428e-02f, -1.98834226e-01f, -4.28780243e-02f, 8.22699144e-02f, 2.45899454e-01f,
  1.88282672e-02f, -8.26985091e-02f, 7.43615404e-02f, 1.60678938e-01f, -2.80678533e-02f, -9.86343473e-02f, -1.48591949e-02f, -4.16082405e-02f, 1.01775192e-01f, 7.83133972e-03f,
  -1.22577798e+00f, 7.31619596e-01f, -7.24550989e-03f, -2.37392917e-01f, -1.16579749e-01f, -4.95028406e-01f, -2.69382864e-01f, -2.93213930e-02f, -2.55408376e-01f, 2.97579467e-01f,
  -6.20631464e-02f, 2.30911989e-02f, 1.19164489e-01f, -4.83464040e-02f, -5.63844323e-01f, 7.72013441e-02f, -2.68720746e-01f, -8.66453797e-02f, -7.25540295e-02f, -3.17232788e-01f,
  -1.81634769e-01f, -1.90694645e-01f, 6.15442805e-02f, 1.39042348e-01f, -1.47075117e-01f, 4.32484038e-03f, -6.42732158e-02f, 1.56360909e-01f, -2.37361025e-02f, 9.73152146e-02f,
  -3.33127260e-01f, 3.10117360e-02f, -9.33413580e-02f, 3.88423838e-02f, -1.18424587e-01f, -8.06686208e-02f, -1.17840901e-01f, -4.15193662e-02f, -1.09404258e-01f, -2.68739797e-02f,
  -3.70166004e-02f, -7.78835965e-03f, -1.61060184e-01f, -1.48778092e-02f, 3.90868858e-02f, 1.26788437e-01f, 8.39299634e-02f, 2.86433361e-02f, 1.03997998e-02f, 8.65779147e-02f,
  1.47816181e-01f, 8.99954587e-02f, -1.01431245e-02f, 1.03820093e-01f, 8.39617848e-03f, 5.02766930e-02f, 4.55748513e-02f, 1.08790912e-01f, -6.56799003e-02f, -5.63106835e-02f,
  1.84389293e-01f, -2.39904761e-01f, 8.10897276e-02f, 2.55192015e-02f, 7.37448186e-02f, 9.35907289e-02f, 1.47116475e-03f, -8.11580755e-03f, -2.03871485e-02f, -1.02228168e-02f,
  -7.87262153e-03f, 1.12955719e-01f, -6.08795919e-02f, 1.24227349e-02f, -2.16218401e-02f, -3.17302383e-02f, -1.40133291e-01f, 7.64867803e-03f, -1.71777815e-01f, 4.49648090e-02f,
  -4.27986607e-02f, -1.07702764e-03f, 1.18107192e-01f, -1.27782747e-01f, 2.17547473e-02f, 1.49767017e-02f, -6.38638958e-02f, 1.30531967e-01f, -2.25059465e-02f, -2.15342537e-01f,
  -7.45196581e-01f, -5.62751830e-01f, -2.42554486e-01f, 6.84166746e-03f, -4.01454754e-02f, -8.56973678e-02f, -1.20211482e-01f, -5.99320047e-03f, -9.28511396e-02f, -1.23324014e-01f,
  -6.59539029e-02f, -1.72930956e-02f, -1.77340388e-01f, -1.28423542e-01f, -1.98589236e-01f, -9.98773724e-02f, -8.76449943e-02f, -4.00230549e-02f, -2.58569330e-01f, -1.44410342e-01f,
  -5.67833474e-03f, -1.38190806e-01f, -3.70797664e-02f, -6.47929087e-02f, -1.60276312e-02f, -1.51806131e-01f, -1.04410417e-01f, 1.27094179e-01f, 1.51058566e-02f, 8.98475274e-02f,
  1.20741940e+00f, -1.81582198e-01f, 4.72706109e-02f, 5.90188742e-01f, 2.13643312e-01f, 1.46627218e-01f, 2.18104050e-01f, 1.23276189e-01f, 6.47033870e-01f, -2.21277624e-01f,
  -1.63454235e-01f, 2.55366802e-01f, -3.72876853e-01f, 3.52931231e-01f, -4.24144834e-01f, -5.00628114e-01f, 2.15911075e-01f, 2.75358856e-01f, 1.22567929e-01f, 4.17233914e-01f,
  2.49363884e-01f, -2.80711316e-02f, -2.97815919e-01f, -9.24787819e-02f, 3.47413391e-01f, 1.53374940e-01f, -6.05700970e-01f, -2.79230714e-01f, 7.95078576e-02f, -1.47771299e-01f,
  1.84251100e-01f, 1.84613094e-01f, -1.31744065e-03f, -8.88330415e-02f, 4.07800153e-02f, 1.58261918e-02f, -7.06130862e-02f, -1.47817418e-01f, 8.72314945e-02f, 1.06013805e-01f,
  8.21419246e-03f, -3.24931853e-02f, 9.56683382e-02f, -3.85791846e-02f, 2.30095565e-01f, 8.25313255e-02f, 1.56796411e-01f, 5.00153415e-02f, 5.88986836e-02f, 7.41524324e-02f,
  1.93996206e-01f, 5.14447950e-02f, 1.05216965e-01f, -5.02244234e-02f, -1.25429258e-01f, 7.30561316e-02f, -7.78703466e-02f, -1.38135985e-01f, -3.37369181e-02f, 3.87319177e-02f,
  -8.76458213e-02f, -1.88042790e-01f, 6.48203492e-03f, 4.19978499e-02f, 1.01673134e-01f, 1.85508095e-02f, 7.88287595e-02f, -2.13840343e-02f, 7.31957778e-02f, -3.02320328e-02f,
  5.58446534e-02f, 1.25563279e-01f, 2.59128865e-02f, 3.90717238e-02f, 1.78115536e-02f, 8.34011361e-02f, -1.27864122e-01f, 2.66567636e-02f, -6.00347295e-02f, 2.44268104e-02f,
  1.93998124e-02f, 1.08986488e-03f, -2.75841821e-03f, -1.68418568e-02f, -7.91443586e-02f, -7.19650686e-02f, -4.27942835e-02f, 1.53948963e-01f, -5.49235828e-02f, -1.58588551e-02f,
  -3.08195144e-01f, -6.97066009e-01f, -1.29742607e-01f, 1.16886050e-01f, 1.33485543e-02f, -2.02018097e-02f, 1.08606875e-01f, 1.51300624e-01f, -2.18087673e-01f, -1.60678830e-02f,
  -7.90280998e-02f, 1.53615296e-01f, -8.13303441e-02f, 7.94877559e-02f, -2.32614893e-02f, -5.84108904e-02f, -1.49045289e-01f, -9.15417597e-02f, -2.44509265e-01f, -1.37597203e-01f,
  3.73255834e-03f, 1.60354465e-01f, 7.93709140e-03f, 8.99398234e-03f, -3.30486596e-02f, -1.50300235e-01f, 6.43305779e-02f, -4.06859666e-02f, -2.09758759e-01f, -1.27160281e-01f,
  -3.65819514e-01f, -8.99432540e-01f, 1.46554053e-01f, -3.81910712e-01f, -2.16319099e-01f, 1.12133421e-01f, 3.37918758e-01f, -5.46466053e-01f, -6.43631160e-01f, -6.23170078e-01f,
  -1.58822358e-01f, -4.10839953e-02f, 4.18301612e-01f, -2.34340027e-01f, 9.53846097e-01f, 3.92652929e-01f, -3.77228521e-02f, 1.21903576e-01f, -4.37306166e-02f, -3.61364156e-01f,
  -1.37646899e-01f, -3.15311521e-01f, 4.15047944e-01f, -5.79801440e-01f, -3.47333372e-01f, -3.44565213e-01f, 1.50447860e-01f, 2.16577694e-01f, -2.23782003e-01f, 3.72716695e-01f,
  -1.54644549e-01f, -6.77228153e-01f, -1.43258587e-01f, -5.98887987e-02f, -8.22883174e-02f, 6.64829314e-02f, 1.80765778e-01f, 4.00751710e-01f, 8.35295767e-02f, 1.83758792e-02f,
  7.34886229e-02f, -2.43335473e-03f, -2.11745769e-01f, 9.64466929e-02f, -1.87790781e-01f, -1.83028743e-01f, 7.63749145e-03f, 3.07212677e-02f, -1.54144615e-01f, 1.24871522e-01f,
  6.32858425e-02f, -2.43034437e-02f, -2.73808129e-02f, -2.50462145e-02f, 4.79979701e-02f, -1.08534284e-01f, 1.42612875e-01f, 2.27440387e-01f, -1.30166531e-01f, -7.65215233e-02f,
  -5.75356558e-02f, 1.42487288e-02f, -3.99406552e-02f, -1.53010711e-02f, -7.70014226e-02f, -4.95802648e-02f, -9.74854361e-03f, 1.40576467e-01f, 2.42046155e-02f, -6.92169294e-02f,
  -3.31617631e-02f, -7.85733685e-02f, -6.87880516e-02f, -3.10874339e-02f, -7.73915276e-02f, -6.03451431e-02f, 1.81438506e-01f, 2.66723577e-02f, -5.27908802e-02f, 7.31433555e-02f,
  4.55327332e-02f, -1.59458518e-02f, 2.49655414e-02f, 1.18675195e-02f, -4.25938256e-02f, 1.28422678e-01f, -1.32467493e-01f, 1.46014513e-02f, -2.62724273e-02f, 2.03473136e-01f,
  -4.14844275e-01f, -7.58283019e-01f, -1.23440325e-01f, -8.85381401e-02f, 2.17676046e-03f, -8.12779069e-02f, -3.34699154e-02f, -1.94744885e-01f, -5.76375201e-02f, -1.45282730e-01f,
  -1.18328378e-01f, 4.81443852e-02f, -1.68690056e-01f, 6.43162653e-02f, 5.26600890e-03f, -8.04342479e-02f, 6.20956859e-03f, -5.36241569e-02f, 8.70221294e-03f, -1.35896951e-01f,
  -7.12508857e-02f, -5.08702733e-02f, 1.20056503e-01f, -1.35288149e-01f, -1.69034928e-01f, 6.93694875e-02f, -1.69432431e-01f, 2.11796537e-03f, 3.65162045e-02f, -7.37121841e-03f,
  4.90481585e-01f, 3.68729949e-01f, -9.55541432e-02f, -1.42928094e-01f, -3.08444172e-01f, -2.52869368e-01f, -3.87633890e-01f, 1.30543336e-01f, -3.00895900e-01f, 9.04704034e-02f,
  1.78138867e-01f, -1.20351091e-01f, 4.19742584e-01f, 5.27691185e-01f, 1.69370323e-01f, 4.86622095e-01f, 2.86038935e-01f, 1.40010163e-01f, 3.21996838e-01f, 4.13531691e-01f,
  2.93720961e-01f, 3.31723809e-01f, 5.62460780e-01f, 3.74229908e-01f, 4.31725293e-01f, 8.08689818e-02f, 2.98738956e-01f, 2.58351192e-02f, 1.21523388e-01f, -5.77591769e-02f,
  4.49990258e-02f, 2.16389164e-01f, -2.50514634e-02f, -1.87555775e-01f, 2.15649888e-01f, 1.88189093e-02f, -6.72440827e-02f, -4.96390574e-02f, -2.19959751e-01f, -2.85596680e-02f,
  -1.89670786e-01f, -3.77200581e-02f, -1.17955133e-01f, -1.03539340e-01f, -7.54506737e-02f, -1.53856635e-01f, 1.19801722e-02f, -3.39872949e-02f, -1.43688992e-01f, 2.68863559e-01f,
  9.43767559e-03f, 2.51545943e-02f, -5.88087849e-02f, 1.61159094e-02f, -1.18235283e-01f, -1.33051917e-01f, -1.35713160e-01f, 3.73280112e-04f, -5.87755591e-02f, 4.13237028e-02f,
  6.19378239e-02f, -2.65039690e-02f, 1.76531095e-02f, -1.41543165e-01f, 1.35819569e-01f, 3.24676409e-02f, -1.24313951e-01f, 3.40032205e-02f, 6.61545666e-04f, 7.99324661e-02f,
  -6.26869351e-02f, 3.54368314e-02f, -7.62130469e-02f, -1.30886525e-01f, 9.03725922e-02f, 2.79987976e-02f, -3.45724113e-02f, -4.58820462e-02f, -1.16842903e-01f, -8.99972767e-02f,
  7.01159313e-02f, 3.60618010e-02f, 2.41256710e-02f, -5.10575669e-03f, -2.00896226e-02f, 1.86802503e-02f, 1.77383780e-01f, 1.65823415e-01f, 8.65459889e-02f, -9.46787819e-02f,
  9.11586285e-02f, 4.27421749e-01f, -9.51872617e-02f, -2.43693843e-01f, -5.16149998e-02f, 1.26324773e-01f, 3.42084803e-02f, 1.26378695e-02f, -3.65539305e-02f, 2.16228664e-01f,
  -1.13376863e-02f, -1.70181572e-01f, -1.78744178e-02f, 5.88818006e-02f, -1.87318221e-01f, 8.22411329e-02f, 4.24499027e-02f, -1.86550304e-01f, -1.07896350e-01f, 1.43488705e-01f,
  4.40369546e-02f, -1.01006068e-01f, -9.35257897e-02f, -2.17485219e-01f, -1.28524795e-01f, 4.03435528e-02f, -1.62102673e-02f, -1.35192022e-01f, 4.47326563e-02f, -3.14761773e-02f,
  -1.03792943e-01f, 1.23385680e+00f, 2.31501400e-01f, 7.21340537e-01f, -4.05261636e-01f, 8.42157826e-02f, 4.24885243e-01f, 2.00592697e-01f, 8.98110121e-02f, 6.47754669e-01f,
  -9.44736600e-02f, 5.07851601e-01f, -1.70501638e-02f, 6.61272049e-01f, -4.50232029e-01f, 9.69526917e-02f, 7.09521353e-01f, 5.19831955e-01f, -7.41311759e-02f, 2.94298261e-01f,
  -9.35153067e-02f, 1.99976757e-01f, 1.49572685e-01f, -1.56912893e-01f, 1.74442202e-01f, 1.15980670e-01f, 5.88769168e-02f, -2.89568514e-01f, 4.35846537e-01f, -6.27475753e-02f,
  1.41070038e-02f, 2.50123084e-01f, 5.59182875e-02f, 1.48395821e-02f, 1.30739259e-02f, 6.14025630e-03f, 7.02521428e-02f, -1.28491312e-01f, -1.36168107e-01f, 9.58296359e-02f,
  9.71415192e-02f, -8.05114433e-02f, 9.25973132e-02f, -7.84392282e-02f, 3.95308472e-02f, 1.03886858e-01f, -9.15553495e-02f, 1.12454938e-02f, 1.81762040e-01f, 5.31212948e-02f,
  5.49766682e-02f, 1.04859322e-01f, 4.48868312e-02f, 2.48122588e-01f, -1.01356164e-01f, 1.38893664e-01f, 1.31046638e-01f, -3.36782890e-03f, 1.84927225e-01f, 7.87912086e-02f,
  3.60342711e-02f, 6.19427264e-02f, 2.82946900e-02f, -3.60154845e-02f, -8.18140879e-02f, -8.72710869e-02f, -2.11978015e-02f, -3.64119373e-02f, 1.49036630e-03f, 4.83707488e-02f,
  -9.05012339e-02f, 2.54720692e-02f, 5.61369918e-02f, 3.82485278e-02f, 5.75459003e-02f, 7.04145730e-02f, -9.22464132e-02f, 6.32859468e-02f, 7.35561475e-02f, -7.58229801e-03f,
  4.47130166e-02f, 2.25011464e-02f, -4.46145050e-03f, -5.82145760e-03f, -8.77763145e-03f, 3.94215435e-02f, 6.99523836e-02f, 2.15364415e-02f, 7.57638291e-02f, -7.98054859e-02f,
  4.28707987e-01f, 6.26038074e-01f, 4.94350903e-02f, 1.08962364e-01f, 4.11335900e-02f, -4.20206785e-02f, 3.53306457e-02f, 7.98137337e-02f, 1.65005133e-01f, 6.86258376e-02f,
  -2.21563056e-02f, 3.46958055e-03f, -4.91349362e-02f, -6.14673644e-02f, -4.80642468e-02f, 1.09258510e-01f, 1.41612068e-01f, 3.53125222e-02f, -1.22201163e-02f, 1.76609550e-02f,
  2.90125553e-02f, 7.05549791e-02f, -4.00991067e-02f, 6.89341361e-03f, 6.10788092e-02f, 5.97469099e-02f, 2.67923977e-02f, 4.89623174e-02f, 3.06812022e-02f, 1.01572521e-01f,
  -8.09358776e-01f, -1.49194926e-01f, -7.81092823e-01f, -8.78155529e-02f, 4.50900972e-01f, 7.12999284e-01f, -4.14832644e-02f, 2.70769894e-01f, -5.36559880e-01f, 3.99933875e-01f,
  3.82458359e-01f, -4.11582351e-01f, -3.76515180e-01f, 7.79233813e-01f, 1.42457917e-01f, -2.99606426e-03f, 5.11539817e-01f, 1.58117279e-01f, -1.13289028e-01f, -2.62713432e-01f,
  -2.22165957e-01f, 7.40012050e-01f, -1.00011706e-01f, 4.11782175e-01f, 1.68997347e-01f, -4.29076910e-01f, 1.94406077e-01f, -5.32432675e-01f, 6.28186524e-01f, 3.60837698e-01f,
  1.69629246e-01f, -5.12975216e-01f, -1.40498146e-01f, -2.40631953e-01f, -8.31619203e-02f, -1.32261962e-01f, -1.13047846e-01f, -1.22843206e-01f, -7.77687207e-02f, 3.22927199e-02f,
  -2.34717265e-01f, -9.77282450e-02f, 9.24113393e-02f, -9.07673389e-02f, -6.82778731e-02f, 9.82827842e-02f, 1.04698554e-01f, 3.70602161e-02f, 2.85301004e-02f, -2.36064047e-02f,
  -1.73406214e-01f, 1.40370548e-01f, 7.92166740e-02f, 1.53581977e-01f, 3.19120451e-03f, 9.22013745e-02f, -3.40136252e-02f, -2.04191074e-01f, 2.26475477e-01f, 1.04645729e-01f,
  2.51024350e-04f, -1.27195686e-01f, -7.10579043e-04f, 1.60560429e-01f, -1.13152355e-01f, 2.08417758e-01f, 1.04763038e-01f, 1.75403759e-01f, -7.54474849e-02f, 5.80281503e-02f,
  -2.70302631e-02f, -1.95029043e-02f, -8.12032223e-02f, 3.84769253e-02f, 1.13486446e-01f, 1.99385826e-02f, -8.77605230e-02f, 8.72033834e-02f, -1.22279093e-01f, 2.63157696e-01f,
  -1.35536641e-01f, -4.82004322e-02f, -1.08029231e-01f, -5.75168198e-03f, 5.35841286e-02f, -6.25003949e-02f, 2.43699588e-02f, 2.74610538e-02f, -8.09839293e-02f, -5.79744950e-02f,
  1.35130227e-01f, -4.01960552e-01f, 3.04111522e-02f, 2.30836436e-01f, 5.22657968e-02f, 1.71026796e-01f, 1.07256249e-01f, 1.32070273e-01f, -4.52494452e-04f, 2.45371796e-02f,
  -1.06684998e-01f, -2.39311412e-01f, 9.75823216e-03f, 5.15888296e-02f, 1.04444847e-01f, -9.62730274e-02f, -1.59303397e-01f, -4.64564972e-02f, 2.17485443e-01f, 1.36154830e-01f,
  -5.62534891e-02f, -6.46439865e-02f, 7.95293450e-02f, 8.49802867e-02f, 1.40002787e-01f, 4.94259894e-02f, -1.57792075e-03f, -1.29994333e-01f, 2.03389406e-01f, 1.12255728e-02f,
  5.25094688e-01f, 3.41188341e-01f, 4.29914623e-01f, 1.57505393e-01f, -1.76134989e-01f, -3.37742120e-01f, -4.69958037e-01f, 1.24392711e-01f, 3.74804407e-01f, 3.48871946e-02f,
  -5.17915606e-01f, 3.73226941e-01f, -1.69415221e-01f, -1.57354072e-01f, -3.67696732e-02f, -1.32863313e-01f, -2.29888886e-01f, -3.77509952e-01f, 1.06957421e-01f, -3.29294652e-01f,
  -6.18334152e-02f, -7.56244361e-01f, -9.76923630e-02f, -5.40525794e-01f, -1.77344471e-01f, 2.18198597e-01f, -3.38008344e-01f, -3.68190676e-01f, -4.17916849e-02f, -2.16027543e-01f,
  6.06505685e-02f, -2.05090772e-02f, 1.56765819e-01f, 4.30635409e-03f, -4.13006395e-02f, -6.36973232e-02f, -3.66687868e-03f, -1.35744542e-01f, -6.10999502e-02f, 6.78057522e-02f,
  7.71284923e-02f, 9.12288129e-02f, -3.38494554e-02f, -1.07294574e-01f, 1.50063306e-01f, 1.73303738e-01f, 1.46043748e-01f, 2.34218121e-01f, 3.20402272e-02f, 2.82154322e-01f,
  5.99379800e-02f, 2.72398561e-01f, 1.63300067e-01f, 5.85806631e-02f, 1.85341746e-01f, 1.27112120e-01f, 1.36245722e-02f, 3.71595547e-02f, 1.13977693e-01f, 1.70063749e-01f,
  1.22203603e-02f, 7.00418092e-03f, -1.55960143e-01f, 9.55326930e-02f, -2.73133904e-01f, -6.25786558e-02f, -1.76754579e-01f, -1.77756865e-02f, -9.52516347e-02f, -8.00896361e-02f,
  -1.47416130e-01f, 1.24895267e-01f, -1.66224688e-01f, -6.64873347e-02f, -4.71970104e-02f, 8.03372115e-02f, -8.38272125e-02f, -3.16547900e-02f, 1.91462472e-01f, 5.80753013e-02f,
  -2.55488336e-01f, -2.41237897e-02f, -1.32862762e-01f, -6.98193908e-02f, -1.41563401e-01f, 5.23480326e-02f, 2.45095313e-01f, 1.49324268e-01f, 1.33360904e-02f, -1.63325757e-01f,
  -1.96756080e-01f, -4.83708322e-01f, 3.95144522e-02f, -5.70882447e-02f, -2.52322257e-01f, 5.74119799e-02f, -5.53977527e-02f, 1.51855752e-01f, -2.10689083e-01f, -1.25128821e-01f,
  7.19283894e-02f, -1.18042968e-01f, -2.81392876e-02f, 1.15879782e-01f, -9.76547599e-03f, -7.39199817e-02f, -1.68511108e-01f, -6.98303897e-03f, -6.15420006e-02f, 6.92583174e-02f,
  -3.07977647e-02f, -6.86333179e-02f, -1.72383133e-02f, -2.14108732e-04f, 4.09634858e-02f, 9.58030224e-02f, 7.75848776e-02f, 1.28224730e-01f, -1.64072812e-01f, -8.80223233e-03f,
  -1.17318869e+00f, 4.24784213e-01f, -1.60227433e-01f, -1.05375528e-01f, -6.28253162e-01f, 9.48637351e-02f, 2.32758418e-01f, 2.38658786e-01f, 1.93006992e-01f, 6.78571522e-01f,
  3.46018896e-02f, 2.17624739e-01f, 5.56286633e-01f, 2.56363720e-01f, -5.01412213e-01f, 6.16061926e-01f, -1.01445466e-02f, 2.46203989e-01f, -3.11564729e-02f, 9.87934470e-02f,
  -1.80804849e-01f, 2.57509425e-02f, -1.22427434e-01f, 1.81650639e-01f, -5.65256238e-01f, -2.27157786e-01f, -2.95038640e-01f, -6.79301172e-02f, -4.48137790e-01f, -3.46421629e-01f,
  -6.67768657e-01f, -1.39741674e-01f, -1.81787670e-01f, -1.94688752e-01f, -3.03512216e-01f, -6.50732592e-02f, -6.77418783e-02f, 3.55288424e-02f, -3.64885330e-02f, -7.12705776e-02f,
  1.24422632e-01f, 2.95123421e-02f, 4.27075010e-03f, 6.99104518e-02f, -7.61064664e-02f, -1.74407326e-02f, -1.48393095e-01f, -1.85564995e-01f, 8.46636221e-02f, -1.20842807e-01f,
  6.32804707e-02f, -1.49793748e-03f, -1.15633890e-01f, 2.50993762e-02f, -3.25906038e-01f, -1.12494998e-01f, 1.23520382e-01f, -1.20682053e-01f, -8.74943808e-02f, -2.41742119e-01f,
  -1.15643181e-02f, 1.37213618e-01f, 8.00243691e-02f, 3.03595327e-02f, 8.48374143e-02f, -7.18057305e-02f, 8.09822883e-03f, -4.89101037e-02f, -7.63276368e-02f, -9.59256850e-03f,
  -6.15249015e-02f, -7.12468252e-02f, -7.64660016e-02f, -5.24548665e-02f, 3.14331800e-02f, 3.87400091e-02f, 8.91907141e-02f, -4.18456122e-02f, 4.11060043e-02f, -1.77889496e-01f,
  2.87442897e-02f, -2.98822448e-02f, -1.58298202e-02f, -7.69024566e-02f, -1.22321241e-01f, -5.02740070e-02f, 1.23374490e-02f, 8.57844800e-02f, 8.92017707e-02f, -2.22295493e-01f,
  -5.97261846e-01f, -2.61773616e-01f, -1.54488236e-02f, -1.30127966e-01f, -5.63466623e-02f, -2.46006660e-02f, 9.08740312e-02f, -1.68200061e-01f, -1.86285466e-01f, 4.29320112e-02f,
  7.20060542e-02f, -4.92706196e-03f, -1.42488748e-01f, 9.56811104e-03f, 2.40228251e-01f, 1.78025384e-02f, 1.16167013e-02f, 4.08899300e-02f, -1.11384720e-01f, -3.21666151e-02f,
  1.95644591e-02f, 1.42671302e-01f, 1.52634919e-01f, 8.82054772e-03f, 8.00002739e-02f, -5.77236079e-02f, -1.20225921e-01f, -3.50791379e-03f, -3.57056022e-01f, 1.20181739e-01f,
  3.55244577e-01f, -4.59596366e-01f, -7.61547148e-01f, -1.65971458e-01f, 5.77356458e-01f, 6.68244600e-01f, -1.14196643e-01f, 1.73502415e-01f, -5.49613595e-01f, 2.02927455e-01f,
  3.56457382e-01f, -3.20315272e-01f, -4.27639455e-01f, 5.65565862e-02f, -6.16231300e-02f, -6.78025186e-01f, 3.26345474e-01f, 8.97382796e-02f, -4.09249812e-01f, 3.93851668e-01f,
  1.10925063e-02f, 5.04803061e-01f, -1.79072663e-01f, 5.19647360e-01f, 4.65222776e-01f, 1.65057987e-01f, 6.64017260e-01f, 7.06963167e-02f, 4.08703625e-01f, 6.30293414e-02f,
  -2.12186296e-02f, -2.59823859e-01f, -4.23650108e-02f, -1.28016621e-01f, 1.66468084e-01f, 3.41593236e-01f, 1.38273343e-01f, 8.00964162e-02f, -8.87900442e-02f, -1.43999934e-01f,
  1.13309495e-01f, 9.99011397e-02f, -7.86063373e-02f, -6.38199644e-03f, 1.49223059e-01f, -9.17967223e-03f, -1.89981505e-01f, -3.25381160e-02f, -3.37794721e-01f, -3.41426209e-02f,
  -1.91581160e-01f, 7.36193918e-03f, 4.11018133e-02f, 9.34760552e-03f, -1.32816777e-01f, -1.53283598e-02f, -7.38516301e-02f, 9.76708159e-02f, -1.19317710e-01f, 1.17164873e-01f,
  9.09051970e-02f, 1.86754912e-01f, 8.37984160e-02f, -1.72538027e-01f, -3.92261147e-02f, -1.74369141e-02f, -9.04865414e-02f, -1.04581609e-01f, -1.51904777e-01f, 3.06700394e-02f,
  4.36007540e-04f, -8.16783682e-02f, -3.75287868e-02f, 2.05553129e-01f, 1.76988214e-01f, -1.03692040e-01f, -9.86301806e-03f, -4.49969023e-02f, 7.79425129e-02f, -1.42868444e-01f,
  -9.08384323e-02f, 8.92136544e-02f, 9.15740877e-02f, 2.60402914e-02f, -1.42003924e-01f, 9.53457654e-02f, 2.03355044e-01f, -8.21651076e-04f, 8.07610750e-02f, 4.93549444e-02f,
  6.46804459e-03f, 1.31328508e-01f, -1.81297302e-01f, -1.63608342e-01f, -2.10271314e-01f, 2.16539696e-01f, -1.43971696e-01f, -1.89810824e-02f, 1.03471078e-01f, -4.45682071e-02f,
  4.79090750e-01f, 6.86011761e-02f, 7.44028687e-02f, 8.42570066e-02f, -1.03924178e-01f, 2.16390312e-01f, 7.85761699e-02f, 6.55736178e-02f, 1.22847773e-01f, -8.65635183e-03f,
  2.15913862e-01f, 1.60188943e-01f, -6.23750314e-02f, 2.45929044e-02f, 1.14150211e-01f, 1.37409950e-02f, 2.10114986e-01f, 2.45445464e-02f, -4.99810502e-02f, -7.68403187e-02f,
  -2.42290169e-01f, 3.54672164e-01f, 6.49714470e-01f, -1.54579610e-01f, 7.13513613e-01f, 1.09005487e+00f, 2.42407948e-01f, 5.77067077e-01f, 7.77288616e-01f, -3.43355924e-01f,
  -5.00184476e-01f, -3.95472914e-01f, -1.75528377e-01f, -3.01327854e-01f, 5.76290488e-01f, 4.79248047e-01f, 3.43305022e-01f, -1.21991858e-01f, 4.72794026e-01f, -1.63457066e-01f,
  8.54712874e-02f, -3.46357197e-01f, -3.07976961e-01f, -1.74075469e-01f, -2.81966537e-01f, -1.90712854e-01f, -7.20213890e-01f, 6.84994310e-02f, -4.47127491e-01f, 2.10596815e-01f,
  6.06512055e-02f, -1.55036449e-01f, -3.04916054e-01f, 1.43002182e-01f, 4.18394953e-02f, -1.01646921e-02f, -1.52159140e-01f, 2.27699406e-03f, -6.59799110e-03f, 8.22574943e-02f,
  -2.00327963e-01f, -3.94127145e-03f, -7.94651732e-02f, 7.20743602e-03f, 1.21206447e-01f, -2.83874664e-02f, 1.59342661e-01f, 2.04669554e-02f, 7.97908846e-03f, 2.83472002e-01f,
  1.31558506e-02f, 1.47521585e-01f, 6.73325080e-03f, 1.36172175e-01f, 2.15370394e-02f, 9.03698951e-02f, 1.45337388e-01f, -1.62881508e-03f, 3.33249755e-02f, 1.92656189e-01f,
  -4.18136157e-02f, 2.88750857e-01f, 5.65733425e-02f, -5.88719510e-02f, -3.30690481e-02f, 7.50171393e-02f, -1.27718691e-03f, -7.51832575e-02f, 1.23514935e-01f, -6.35923967e-02f,
  -2.81961914e-02f, -6.03142828e-02f, 1.48371547e-01f, 6.68669492e-02f, -8.53293017e-02f, -1.23936832e-01f, -7.42001235e-02f, -2.75274925e-02f, 8.92163366e-02f, -2.58221515e-02f,
  3.59394215e-03f, 1.29941031e-01f, -2.57346127e-02f, 4.93113138e-02f, 7.11467490e-02f, 6.14541396e-03f, -3.03765256e-02f, 2.50904951e-02f, -6.81967065e-02f, -2.71970816e-02f,
  4.40861762e-01f, 2.37634227e-01f, -9.24131200e-02f, -1.55219421e-01f, 2.75903884e-02f, -6.93053380e-02f, 7.12794140e-02f, 1.59476131e-01f, 1.78441837e-01f, 6.06118236e-03f,
  -4.75049727e-02f, -1.44986108e-01f, 1.36576369e-02f, -4.93251979e-02f, 6.54750410e-03f, 1.86212257e-01f, -6.16177246e-02f, 4.59070913e-02f, 9.53772850e-03f, -6.25933483e-02f,
  -2.65269041e-01f, -4.08794545e-02f, -2.30645458e-03f, -2.75291000e-02f, -2.09684581e-01f, -7.79259801e-02f, 7.60505497e-02f, 5.34961885e-03f, 2.84382869e-02f, 1.48943976e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.07354438e-01f, 9.38528180e-01f, 4.43506628e-01f, 4.95097011e-01f, 6.65244639e-01f, 8.84899437e-01f, 7.49867737e-01f, 2.90938228e-01f, 7.66830862e-01f, 3.39688271e-01f,
  6.36328638e-01f, 2.76845485e-01f, 6.81430280e-01f, 7.63683259e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -9.06083286e-01f, -4.15373355e-01f, -4.65724438e-01f, 2.17345595e-01f, -8.99420977e-01f, -7.68037662e-02f, 5.55467188e-01f, 6.27979785e-02f, -6.01471439e-02f, -3.48461866e-01f,
  5.13471663e-01f, -1.46123737e-01f, 5.74447274e-01f, -3.71567786e-01f, -4.36987996e-01f, 1.25301890e-02f, 1.55244812e-01f, 6.38318896e-01f, -4.86791104e-01f, -4.63026464e-01f,
  -3.05778146e-01f, -7.39193022e-01f, 4.05511260e-01f, -8.51920605e-01f, 1.63052186e-01f, 2.10025817e-01f, 6.71224713e-01f, 4.74518657e-01f, -6.74917161e-01f, 7.84284651e-01f,
  -6.54474914e-01f, -1.02336347e+00f, -2.04312235e-01f, 2.23443195e-01f, 3.18717122e-01f, -8.66820395e-01f, 3.90380740e-01f, -4.21419144e-01f, -4.90359128e-01f, 3.32511961e-02f,
  -3.90187018e-02f, -6.88291669e-01f, 9.68859911e-01f, -6.54816926e-01f, -6.64197743e-01f, -2.07613364e-01f, -5.91680467e-01f, 7.43821502e-01f, 3.64355892e-01f, -5.20499468e-01f,
  -4.61957268e-02f, -9.45005953e-01f, -8.73148501e-01f, -8.07714641e-01f, -8.94353509e-01f, -3.73632042e-03f, -4.18541193e-01f, 5.11680007e-01f, 2.99357206e-01f, 8.04072797e-01f,
  -6.84087336e-01f, -7.74160087e-01f, 9.19170141e-01f, -1.75950736e-01f, -3.47548813e-01f, -5.74895501e-01f, -1.68337613e-01f, -2.64366090e-01f, -6.32060543e-02f, -2.94853449e-01f,
  -5.49752004e-02f, -3.49182904e-01f, 2.71027181e-02f, -5.38504720e-01f, -5.40641308e-01f, 6.72926247e-01f, 1.64591596e-01f, 3.33689541e-01f, 1.98472783e-01f, 2.98210263e-01f,
  4.08973880e-02f, -2.72995740e-01f, -5.89274943e-01f, -5.98844230e-01f, 4.47906792e-01f, 7.73558259e-01f, -4.70225275e-01f, 1.50498062e-01f, 1.86789095e-01f, -8.73175442e-01f,
  -6.85533106e-01f, 6.87079549e-01f, -4.80340332e-01f, -4.58225906e-01f, 5.88494778e-01f, -9.50037599e-01f, -3.68082345e-01f, -1.56277046e-01f, -2.02328160e-01f, -3.63901883e-01f,
  -2.61588246e-02f, 3.99762280e-02f, -1.58027694e-01f, -2.97219485e-01f, 2.07298115e-01f, -5.30840456e-01f, 3.42330933e-01f, 1.05104089e+00f, -1.12476178e-01f, 4.02143449e-01f,
  2.62988806e-01f, -6.44063592e-01f, -2.55355030e-01f, 1.19967654e-01f, 6.95888042e-01f, 6.49439454e-01f, -1.67942882e-01f, -5.26015759e-01f, 6.98490977e-01f, -1.58064440e-01f,
  -1.03707981e+00f, -7.20737815e-01f, -2.68050790e-01f, -5.69457233e-01f, -7.09111929e-01f, 5.70130527e-01f, -9.76089358e-01f, -7.41157711e-01f, 2.30182424e-01f, 1.84718862e-01f,
  1.99443534e-01f, 5.81998490e-02f, 6.83365822e-01f, 3.53735119e-01f, -6.44032001e-01f, 3.00279021e-01f, -5.37330091e-01f, -6.91134751e-01f, 1.50190871e-02f, -3.38327378e-01f,
  1.06794977e+00f, -5.94547391e-01f, 3.52728069e-01f, -6.32617891e-01f, -7.73173451e-01f, 5.87100565e-01f, -9.04736936e-01f, 3.47606331e-01f, -7.61311948e-01f, 7.59415150e-01f,
  4.70432162e-01f, -9.23633635e-01f, 3.45457084e-02f, 4.45499837e-01f, -9.70376730e-01f, 3.45019787e-03f, 2.11852327e-01f, 6.00915924e-02f, -6.12293720e-01f, 6.14289224e-01f,
  7.37183154e-01f, 2.58293778e-01f, 3.35376114e-01f, 8.02167594e-01f, 7.42036700e-01f, -3.24067235e-01f, 4.57111388e-01f, -4.43475902e-01f, 3.09794247e-01f, 7.01996684e-01f,
  3.39280128e-01f, -1.11645207e-01f, -3.78238589e-01f, -1.12513594e-01f, -6.25869989e-01f, -7.76178241e-02f, 8.92643809e-01f, -8.34922016e-01f, -5.76682568e-01f, -8.86471331e-01f,
  -6.60567135e-02f, -6.02819741e-01f, -1.03628516e+00f, -7.04192817e-02f, -7.03989089e-01f, -3.23027670e-01f, 6.15944803e-01f, -8.47347796e-01f, -3.42551976e-01f, 8.43285441e-01f,
  -7.91375279e-01f, 9.16179001e-01f, 1.21360078e-01f, 1.97817594e-01f, 2.77299821e-01f, -3.92782837e-01f, -5.61591744e-01f, 2.64754802e-01f, 5.73774576e-01f, -2.89009720e-01f,
  -2.34814271e-01f, 4.25170183e-01f, -2.49660119e-01f, -4.45429951e-01f, -2.30599016e-01f, -2.30411455e-01f, -4.37809408e-01f, -5.00041470e-02f, -7.37200081e-01f, 4.93271321e-01f,
  -1.24151334e-01f, -8.82645130e-01f, 9.61505890e-01f, 1.04799554e-01f, -4.85387474e-01f, 1.07182682e+00f, -6.97895646e-01f, -6.11686051e-01f, -1.38953972e+00f, -8.48033011e-01f,
  2.77947426e-01f, -5.60226023e-01f, -8.46137479e-02f, 4.42029297e-01f, -2.05672309e-01f, -4.11907464e-01f, -5.00206828e-01f, 2.87779748e-01f, -1.19147435e-01f, -3.24089289e-01f,
  -2.52802551e-01f, -3.41956705e-01f, 9.16736424e-02f, 4.38894629e-01f, -2.87806481e-01f, 2.43188411e-01f, -6.34566396e-02f, 3.90167087e-01f, -4.24011499e-01f, 1.46312892e-01f,
  2.82238960e-01f, -4.48249280e-01f, 7.71635652e-01f, -6.73643470e-01f, -3.31201285e-01f, -5.67912012e-02f, 2.18231708e-01f, -7.59169281e-01f, 3.44374716e-01f, 1.01656780e-01f,
  -5.87042093e-01f, -4.21556383e-01f, 6.13398194e-01f, -1.69403642e-01f, -4.60510910e-01f, -3.11058722e-02f, 1.06045827e-01f, -1.94514543e-01f, -2.13105634e-01f, 1.80155516e-01f,
  -4.78637397e-01f, 2.49767348e-01f, -3.05802912e-01f, 3.33964497e-01f, -2.90756494e-01f, 6.12315178e-01f, -5.77282906e-01f, 6.81309760e-01f, 1.13112390e-01f, 4.19937253e-01f,
  3.74833554e-01f, 2.36716256e-01f, -2.27470592e-01f, -3.73139828e-01f, -4.43344086e-01f, -4.91262347e-01f, 7.62956798e-01f, 5.88955343e-01f, -2.22347528e-01f, -8.08681250e-01f,
  -6.10938668e-01f, 4.79221076e-01f, 4.09430295e-01f, -6.89917505e-01f, -2.60675281e-01f, -1.90775454e-01f, -3.24768163e-02f, -6.07990444e-01f, 3.27311277e-01f, 9.76256803e-02f,
  -1.28129363e-01f, 6.12980267e-03f, -1.49692386e-01f, 3.95666599e-01f, -3.33274186e-01f, 6.85342491e-01f, 4.15371895e-01f, 5.73790669e-01f, -7.49365091e-01f, -4.14386600e-01f,
  -7.22292185e-01f, -5.46061575e-01f, 7.38500714e-01f, -7.31330872e-01f, 3.76535207e-01f, 5.71182072e-01f, -5.53178370e-01f, -3.86989057e-01f, -4.09340054e-01f, -7.86266148e-01f,
  -7.33184874e-01f, -3.61669809e-01f, 1.42140067e+00f, -2.69836932e-01f, -4.88738984e-01f, -6.66131854e-01f, -5.32773614e-01f, -6.44852042e-01f, 4.26830798e-02f, -2.66210418e-02f,
  3.58624101e-01f, 1.99347913e-01f, 2.68011928e-01f, 8.14403072e-02f, -2.54545093e-01f, 8.76596794e-02f, 5.46269536e-01f, 1.97700448e-02f, -5.22444118e-03f, 6.27387762e-01f,
  7.42787838e-01f, -8.06640923e-01f, 4.77626503e-01f, 6.22837543e-01f, 6.28633857e-01f, 6.57681167e-01f, -4.90772158e-01f, -7.82563090e-01f, 1.99189603e-01f, 5.84721446e-01f,
  -6.09017313e-01f, 1.74072087e-01f, -1.95506796e-01f, -6.62678719e-01f, -6.56125546e-01f, -6.31913066e-01f, -4.61522847e-01f, 1.09986275e-01f, -2.62195110e-01f, -7.75431991e-01f,
  9.90099311e-01f, -3.84539306e-01f, -2.92386025e-01f, -2.11527675e-01f, -9.71014351e-02f, -1.54168665e-01f, 1.37385383e-01f, 1.09622486e-01f, 1.12330183e-01f, 3.30729723e-01f,
  2.74403114e-02f, 4.01166290e-01f, -5.98744035e-01f, 3.88355255e-01f, 4.14104015e-01f, 3.34956557e-01f, 4.43998814e-01f, 5.22293568e-01f, -2.00457558e-01f, 4.99429435e-01f,
  -7.17060983e-01f, 3.24463278e-01f, -5.85826337e-01f, -2.78070033e-01f, 4.20842201e-01f, 7.72704065e-01f, -6.28445327e-01f, -3.00714254e-01f, 4.76307034e-01f, -5.67293465e-01f,
  8.33893180e-01f, -5.71167350e-01f, -4.37068582e-01f, -6.53937280e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.61056054e-02f, -6.84774816e-02f, -1.24125585e-01f, -2.77853668e-01f, 2.10228339e-01f, 4.46850955e-01f, -7.24876486e-03f, -2.02356592e-01f, -1.09107554e-01f, 4.16945338e-01f,
  2.36474648e-02f, -2.20775604e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    