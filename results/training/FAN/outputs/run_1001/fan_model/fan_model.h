/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.62164056e-01f, 7.65696466e-01f, -9.77509916e-02f, 2.54945695e-01f, 2.05577895e-01f, -6.13050461e-02f, 2.71299273e-01f, 2.40109041e-01f, 6.59717992e-02f, 1.71054691e-01f,
  1.85931012e-01f, 1.21760741e-01f, 3.29193734e-02f, 1.47947490e-01f, 7.24362268e-04f, 2.31605411e-01f, 2.24723667e-01f, -1.95927396e-01f, -3.52587819e-01f, 1.28960431e-01f,
  2.87544221e-01f, 3.03592850e-02f, -2.98777193e-01f, -8.29933956e-03f, 2.60335535e-01f, 1.78208664e-01f, 2.18085840e-01f, -3.28905582e-02f, 7.49893337e-02f, 3.38227212e-01f,
  -3.21417391e-01f, 4.87731807e-02f, 1.06058165e-01f, 1.19113617e-01f, 2.33607382e-01f, 7.98370540e-02f, 9.16356966e-02f, 1.06627345e-01f, 5.59808686e-02f, 1.58274114e-01f,
  1.97240636e-01f, 1.23532683e-01f, 9.83422250e-02f, 1.81768626e-01f, 1.30839199e-01f, 4.90784012e-02f, 7.02550784e-02f, 3.23566385e-02f, 2.35693362e-02f, 4.86607999e-02f,
  1.70390293e-01f, 1.11564651e-01f, 4.03757170e-02f, 1.64268896e-01f, 6.01907112e-02f, 1.10365693e-02f, 2.24056691e-01f, 8.27967748e-02f, -6.32559732e-02f, 2.07863703e-01f,
  3.06131858e-02f, -1.15594506e-01f, -2.53692716e-02f, 8.26608948e-03f, 2.84928605e-02f, 5.64678721e-02f, -7.90807605e-02f, 5.33451922e-02f, 6.84878826e-02f, -8.07843283e-02f,
  3.27715762e-02f, -7.95566570e-03f, 2.69771516e-02f, -7.08325356e-02f, -2.62337513e-02f, -5.25321662e-02f, -2.13456713e-02f, -4.27727774e-03f, -3.41177024e-02f, -1.17263244e-02f,
  -1.50046423e-02f, 4.54402231e-02f, -9.69501063e-02f, 1.04914689e-02f, -5.87295964e-02f, -1.00027531e-01f, -4.98687439e-02f, -1.85132548e-02f, -7.25618973e-02f, -9.66732502e-02f,
  1.69925287e-01f, 3.58368456e-02f, 1.60863459e-01f, 9.97430161e-02f, 4.77548987e-02f, -2.49816868e-02f, 2.07143761e-02f, 8.81388560e-02f, 4.02967818e-02f, 1.53248176e-01f,
  3.92138585e-02f, 6.87440066e-03f, 1.31617472e-01f, 4.34022024e-02f, 8.28551725e-02f, 1.15307324e-01f, 8.73077437e-02f, 8.75390172e-02f, 9.02304575e-02f, 4.79255244e-02f,
  1.47165760e-01f, 1.15935951e-01f, 8.80782455e-02f, 1.59654766e-01f, 8.25097784e-02f, -1.44570358e-02f, 1.04026452e-01f, 1.00661919e-01f, 7.86517560e-02f, 3.51810247e-01f,
  4.86776918e-01f, 9.24060121e-02f, 2.09675491e-01f, -2.29462564e-01f, -2.30240226e-01f, -9.19182673e-02f, 1.96045905e-01f, -1.07930370e-01f, -1.89820126e-01f, 2.44581588e-02f,
  -1.09354936e-01f, -1.68235585e-01f, -3.59592913e-03f, -8.09071586e-02f, 1.96098179e-01f, 9.67198908e-02f, 2.39781942e-02f, 1.93291619e-01f, 2.16144755e-01f, -6.22543395e-02f,
  -1.66887820e-01f, 3.58329602e-02f, 1.79010466e-01f, 1.35158733e-01f, -6.90978114e-03f, -1.06185884e-03f, -3.66990641e-02f, -7.03735501e-02f, -3.17758694e-02f, 1.83677836e-03f,
  2.39494428e-01f, 5.86965941e-02f, 1.25474274e-01f, 6.92430213e-02f, 3.64794135e-02f, 1.15807906e-01f, 5.70703112e-02f, 6.61295801e-02f, 9.59762037e-02f, 1.43653050e-01f,
  1.47096701e-02f, 8.66819024e-02f, 1.63943902e-01f, 5.91094159e-02f, 1.39358789e-01f, 9.32618529e-02f, 1.77257080e-02f, 1.41931966e-01f, 9.50295702e-02f, 2.60995291e-02f,
  -8.31214413e-02f, 2.94398367e-02f, 5.83750531e-02f, 2.95624211e-02f, 3.15885320e-02f, 4.20600846e-02f, -1.26095982e-02f, -3.97702828e-02f, 9.59731042e-02f, -9.15230289e-02f,
  1.16213076e-02f, 7.26613849e-02f, -6.94950968e-02f, 7.71000907e-02f, -1.39785092e-02f, -6.70477152e-02f, -4.28360365e-02f, -1.01155899e-01f, -3.55421042e-04f, 4.43032347e-02f,
  1.71149727e-02f, 3.00245248e-02f, 3.92530672e-02f, -3.36095840e-02f, -7.68933222e-02f, 3.01686469e-02f, 3.29084806e-02f, 7.96362236e-02f, -2.12040525e-02f, 1.07373096e-01f,
  -5.12783835e-03f, 4.66241688e-02f, 2.56441068e-02f, 5.19274920e-02f, -7.45757297e-02f, 3.12023461e-02f, 6.29250705e-02f, -2.58817151e-02f, 4.80476916e-02f, -2.65361592e-02f,
  -1.05937980e-01f, -5.35422266e-02f, 1.34399742e-01f, 1.14558302e-01f, 2.04038639e-02f, 1.04100527e-02f, 1.42079815e-02f, 1.01197004e-01f, 1.06416546e-01f, 8.35027993e-02f,
  -4.31669094e-02f, 9.06730518e-02f, 6.77165240e-02f, 5.93071580e-02f, 2.96558067e-02f, 2.17807852e-02f, 2.42092181e-02f, 6.19579926e-02f, -2.54039507e-04f, 1.11013621e-01f,
  6.32856488e-02f, -5.95138706e-02f, -6.48737997e-02f, 7.74172693e-02f, 1.26357470e-02f, 5.31241123e-04f, 9.70275626e-02f, -3.19010229e-03f, 1.98197812e-01f, 6.79878891e-02f,
  -4.34416085e-01f, 1.18130215e-01f, -3.09072763e-01f, 1.17336035e-01f, 2.04069182e-01f, 5.19198589e-02f, -1.32941846e-02f, 5.04450388e-02f, -7.53513537e-03f, -7.72388503e-02f,
  1.50527835e-01f, 1.80425942e-01f, -2.79025850e-03f, -2.10292935e-02f, -2.80788451e-01f, -1.92442715e-01f, -3.74430746e-01f, -4.38934237e-01f, -1.36420056e-01f, 2.77557988e-02f,
  1.03787519e-01f, -2.98746318e-01f, -3.36546659e-01f, -3.22606303e-02f, 1.33546695e-01f, 2.29374766e-01f, -2.15075165e-01f, -1.36388376e-01f, -3.02941334e-02f, -9.70748067e-02f,
  -1.76822856e-01f, -5.85965849e-02f, 7.38664046e-02f, 7.92986080e-02f, 5.58388419e-02f, -2.87868995e-02f, -1.61281377e-02f, -1.66756641e-02f, 8.61044154e-02f, -7.85728395e-02f,
  2.86855735e-02f, 8.99033342e-03f, 2.56305244e-02f, 1.80447660e-02f, -8.28442052e-02f, -1.75482463e-02f, -3.25857401e-02f, -6.55530766e-02f, -9.02000815e-03f, -3.33606489e-02f,
  1.09944269e-01f, -5.62257208e-02f, -8.62966999e-02f, 8.24385583e-02f, 4.82616089e-02f, 6.83669001e-02f, -1.67309865e-02f, 5.21026812e-02f, 5.38114225e-03f, 9.88109317e-03f,
  -4.38006818e-02f, -1.67677179e-01f, -3.01778987e-02f, -1.47521095e-02f, 5.27109802e-02f, 8.61403421e-02f, -5.63654080e-02f, -7.61325136e-02f, 3.93556766e-02f, -2.38182601e-02f,
  2.52720788e-02f, -6.85866363e-03f, -3.75919864e-02f, 5.36559289e-03f, 4.01342995e-02f, -1.00327805e-01f, -1.17598372e-02f, 1.56037323e-02f, 5.51436320e-02f, -4.24410924e-02f,
  5.41898385e-02f, 4.50762501e-03f, -9.28771496e-02f, -3.00250202e-02f, 7.06698522e-02f, 5.89029305e-02f, -4.67002280e-02f, 2.92649399e-02f, 4.66411300e-02f, -1.06455870e-01f,
  1.57089382e-01f, 3.01136691e-02f, -3.55095137e-03f, -1.81248446e-03f, -5.59206819e-03f, 7.96199664e-02f, 1.23911448e-01f, 7.10466057e-02f, 6.05034567e-02f, 1.89900309e-01f,
  9.64042917e-02f, 8.88102129e-02f, 5.69557846e-02f, 5.31491777e-03f, 3.58359218e-02f, 8.69549215e-02f, 6.38249665e-02f, 4.93723936e-02f, -4.09097224e-02f, 6.56684637e-02f,
  4.44859378e-02f, -9.31706578e-02f, -4.61374633e-02f, 3.97149101e-02f, -1.25204329e-03f, 7.36900344e-02f, -6.42814636e-02f, 1.55213634e-02f, -9.37322602e-02f, 1.56926095e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.86454010e-01f, 2.30606914e-01f, -1.17633975e+00f, -2.62205750e-01f, -8.24811220e-01f, -5.43919027e-01f, -4.77394611e-01f, -9.41145569e-02f, -1.11889523e-02f, -3.57449092e-02f,
  2.93930590e-01f, 5.28512239e-01f, 4.62492287e-01f, 9.93149802e-02f, 2.26665791e-02f, -4.62113947e-01f, -7.19968796e-01f, -5.32439232e-01f, -4.07090187e-01f, -4.21612591e-01f,
  -1.14606977e-01f, -2.48123482e-01f, -1.44911081e-01f, -5.08591719e-02f, -1.84725493e-01f, 1.96310788e-01f, -2.05166146e-01f, -3.80577564e-01f, -2.50308782e-01f, -6.68273151e-01f,
  -1.35370091e-01f, -3.77118647e-01f, -5.93428575e-02f, 7.62714297e-02f, -4.82777581e-02f, 1.43606097e-01f, 1.46300467e-02f, 2.86213728e-03f, 1.85814828e-01f, 1.04391642e-01f,
  2.69106645e-02f, 9.14049987e-03f, 1.61411949e-02f, -3.30275521e-02f, -7.42658153e-02f, 4.73830998e-02f, 5.17304987e-02f, -1.43279448e-01f, -9.42120552e-02f, 1.74857676e-01f,
  -8.62175971e-03f, -1.50366858e-01f, -6.41265735e-02f, 6.00667335e-02f, 6.27794564e-02f, -8.54579732e-02f, 1.18427925e-01f, -5.37567213e-02f, -1.89259890e-02f, 1.25405967e-01f,
  -1.12787642e-01f, -1.00759193e-02f, -7.24492744e-02f, 3.05282529e-02f, 1.50656670e-01f, -6.80955453e-03f, -3.14365849e-02f, -6.49911612e-02f, 3.07288463e-03f, 6.86279088e-02f,
  8.54286700e-02f, 4.86123674e-02f, 5.70745245e-02f, -3.80654149e-02f, -9.54953879e-02f, 5.95965423e-03f, -6.21443987e-02f, -1.85784150e-03f, 3.24235074e-02f, 9.15707126e-02f,
  5.79419658e-02f, 2.77201310e-02f, -4.42100242e-02f, -2.00715289e-02f, -2.91601300e-01f, -3.53413709e-02f, -8.02778825e-02f, 9.25562680e-02f, 1.04943044e-01f, 2.07841434e-02f,
  4.90178347e-01f, -2.11057752e-01f, -2.69035604e-02f, 1.60210058e-01f, -1.47407606e-01f, 4.41075340e-02f, 3.49898338e-02f, 1.00364663e-01f, -6.94855675e-02f, -7.93694109e-02f,
  -9.61212665e-02f, 5.27581163e-02f, -3.34393643e-02f, 1.09825663e-01f, 4.71493155e-02f, -6.35226518e-02f, 7.75872394e-02f, -1.11712046e-01f, -3.47147626e-03f, -4.40449938e-02f,
  7.98009261e-02f, -2.79545691e-02f, 1.69841707e-01f, 2.14799419e-01f, 4.74755503e-02f, -4.70816754e-02f, 7.31025338e-02f, -1.07896671e-01f, 5.73719554e-02f, 2.56506890e-01f,
  -1.56300608e-02f, -2.45302886e-01f, 1.73222329e-02f, 6.50466144e-01f, 4.19381946e-01f, 3.31214726e-01f, 3.32729399e-01f, 3.45652491e-01f, 3.48522574e-01f, 1.88468814e-01f,
  1.66232958e-01f, 2.68370688e-01f, 2.97781497e-01f, 2.53150254e-01f, 8.62277374e-02f, 2.50694931e-01f, 3.12761456e-01f, 5.66578954e-02f, 1.61803395e-01f, 2.38188356e-01f,
  3.21203470e-01f, 4.76950444e-02f, -2.20580786e-01f, 1.82368595e-03f, 1.85741410e-01f, 4.16424096e-01f, 1.34341866e-01f, 5.83832711e-02f, 1.06129698e-01f, 4.36669469e-01f,
  -2.83341348e-01f, -1.06826782e-01f, 1.19384952e-01f, -1.00909159e-01f, -1.97209746e-01f, -1.26844615e-01f, 9.13147721e-03f, -1.70301124e-01f, -5.40050827e-02f, -2.82554440e-02f,
  -8.71951357e-02f, 1.15042806e-01f, 8.29005316e-02f, -1.20979203e-02f, -1.93982825e-01f, -1.33276492e-01f, -5.42177595e-02f, 3.30207646e-02f, 1.39306426e-01f, -7.68617168e-02f,
  2.38230258e-01f, -4.47467007e-02f, -2.34574378e-01f, 4.46940167e-03f, 2.00255178e-02f, 4.16046567e-02f, -1.07523449e-01f, 5.90049438e-02f, 9.80405062e-02f, 2.45598815e-02f,
  2.55697191e-01f, -1.12584263e-01f, 7.48600857e-03f, -5.16280648e-04f, -4.10057493e-02f, -1.06348537e-01f, 3.06414273e-02f, -8.41026232e-02f, 1.41501054e-01f, -1.21635459e-01f,
  -1.46828080e-03f, 2.89552715e-02f, -9.68049467e-02f, 1.31101012e-01f, 9.38863233e-02f, -3.49598601e-02f, 2.86893826e-03f, -1.17971553e-02f, -3.50923747e-01f, -1.54997110e-01f,
  -1.44664183e-01f, 5.43353036e-02f, -1.17464006e-01f, -9.57667679e-02f, 6.65230826e-02f, 6.54313713e-02f, 1.36905655e-01f, -6.38541207e-03f, 2.24909130e-02f, -1.35432289e-03f,
  1.01273753e-01f, 1.21947110e-01f, 1.00049585e-01f, 5.90857379e-02f, 9.24663097e-02f, -1.45504847e-01f, 1.37488008e-01f, -1.46045731e-02f, -1.43928409e-01f, -1.72681227e-01f,
  -1.12930231e-01f, 5.40526249e-02f, -1.10336952e-01f, -1.39367774e-01f, 1.26802397e-03f, 3.67111340e-02f, 3.97930592e-02f, 1.27822295e-01f, 2.69573051e-02f, -1.41028315e-01f,
  3.08114700e-02f, 5.61473258e-02f, -1.78745762e-01f, -6.74886107e-02f, 3.90549861e-02f, -3.12087685e-02f, -1.69512078e-01f, -2.89533194e-02f, -3.33812982e-02f, 1.76458005e-02f,
  -1.30976379e+00f, 2.52521336e-01f, 2.70506054e-01f, -5.78465760e-01f, 1.13842092e-01f, 1.37950674e-01f, 2.73226857e-01f, -1.21409232e-02f, -1.90208316e-01f, -1.24115637e-02f,
  -3.04663857e-03f, -2.28935167e-01f, -7.13931248e-02f, -1.12298504e-02f, 5.63260987e-02f, 9.35227424e-02f, -1.67392194e-01f, -3.09921980e-01f, -1.39595941e-01f, 1.80661574e-01f,
  6.04728062e-04f, -4.18584228e-01f, -5.37789583e-01f, 1.60962656e-01f, 2.15694100e-01f, -2.21837223e-01f, -1.95111837e-02f, -1.67011663e-01f, 2.09743455e-01f, -1.85930118e-01f,
  1.68293819e-01f, -1.37942314e-01f, -1.07114017e-01f, -1.15824081e-01f, 5.91135956e-02f, -1.58248674e-02f, -5.85463010e-02f, -1.08478948e-01f, -5.88613637e-02f, 3.52868414e-03f,
  -1.07088737e-01f, 4.12603766e-02f, -1.58061519e-01f, 1.03523470e-01f, -1.68422937e-01f, -2.91321129e-02f, -5.30477762e-02f, -4.87405807e-02f, -3.07891220e-02f, 2.82431751e-01f,
  1.77095726e-01f, 2.86976080e-02f, 5.96793033e-02f, 2.04705864e-01f, 1.51505157e-01f, -1.72421843e-01f, 1.92871124e-01f, 2.92230844e-02f, 1.33558720e-01f, 8.56281668e-02f,
  -2.33287185e-01f, 4.05452028e-02f, 4.53347899e-02f, -5.94046079e-02f, -5.93658313e-02f, -7.25290403e-02f, -7.20400065e-02f, 1.15501287e-03f, 1.29390648e-02f, -2.35408247e-02f,
  -5.02169952e-02f, 4.32704538e-02f, 9.97843295e-02f, -4.10106815e-02f, 1.74171869e-02f, 2.38236338e-02f, -7.16398284e-02f, 7.17637762e-02f, 1.16239175e-01f, -1.20181739e-01f,
  5.10085896e-02f, 9.69917029e-02f, -3.59964967e-02f, 4.78915162e-02f, -7.10648596e-02f, 1.24518445e-03f, 8.29203129e-02f, 4.51098122e-02f, 3.39714698e-02f, 3.59035097e-02f,
  -3.58517796e-01f, -1.50458708e-01f, -1.15420282e-01f, 8.51964131e-02f, 2.55752951e-02f, 1.14870816e-02f, 3.44265401e-02f, 5.11608757e-02f, -9.84852836e-02f, -4.57861312e-02f,
  6.07358292e-02f, -1.49567034e-02f, -5.08740284e-02f, 8.09212681e-03f, -6.85006082e-02f, -4.67950255e-02f, -2.33160667e-02f, -8.77353549e-02f, 1.53752074e-01f, 1.50863752e-01f,
  1.27042353e-01f, 2.04326957e-02f, 2.10414995e-02f, 7.59075657e-02f, 1.12050787e-01f, -1.45107225e-01f, 2.72500962e-02f, 1.46237433e-01f, 4.98890728e-02f, 1.00211911e-01f,
  -5.62311590e-01f, -2.05248259e-02f, 1.93304390e-01f, 3.67173762e-03f, 7.32948720e-01f, 5.42277217e-01f, 8.46372426e-01f, 2.16406539e-01f, 9.44855064e-03f, 1.28343105e-01f,
  4.69615459e-02f, -4.51671928e-01f, -2.39437580e-01f, -3.87329847e-01f, -3.06830723e-02f, 4.98795420e-01f, 4.67016667e-01f, -2.08251059e-01f, -1.15542620e-01f, 6.43812642e-02f,
  6.78318888e-02f, 1.02969624e-01f, -4.17985946e-01f, -1.70937896e-01f, 3.33680958e-01f, -2.22022329e-02f, 7.77860805e-02f, 1.92216396e-01f, 6.04914017e-02f, 2.10999697e-01f,
  3.43662314e-02f, 2.02159464e-01f, -1.23929102e-02f, -2.02269062e-01f, 9.59682614e-02f, -2.73579091e-01f, -1.13734424e-01f, -2.29279503e-01f, -1.46886483e-01f, 1.06284246e-01f,
  8.00863355e-02f, -1.72093943e-01f, 1.29236713e-01f, -6.99908286e-02f, 5.60859628e-02f, -6.57407194e-02f, -1.66591808e-01f, -2.60783643e-01f, -1.27404898e-01f, -7.50318840e-02f,
  -8.42764378e-02f, 1.15137689e-01f, 2.74214387e-01f, 1.28365621e-01f, -4.19368455e-03f, -1.24620184e-01f, 3.36943455e-02f, -7.90440887e-02f, -1.12054974e-01f, -2.75607526e-01f,
  -1.64071977e-01f, 9.74898413e-02f, 5.43393642e-02f, -5.94867095e-02f, -1.12630716e-02f, 9.64908022e-03f, 1.52564406e-01f, 5.00907376e-02f, -9.51568931e-02f, -1.43640414e-01f,
  -8.75431672e-02f, -7.01862806e-03f, 2.05761511e-02f, -7.30016679e-02f, -1.65066905e-02f, 3.19840498e-02f, 6.46463856e-02f, -8.09611287e-03f, -1.00582302e-01f, -4.11971211e-02f,
  -5.88308498e-02f, 7.42282718e-02f, -1.98006518e-02f, 5.56999408e-02f, -4.46572974e-02f, -1.56345163e-02f, -1.25820786e-01f, -2.13364497e-01f, -1.61663994e-01f, 6.90347254e-02f,
  -2.08585382e-01f, -1.36241361e-01f, 4.53841873e-02f, 2.41111796e-02f, 3.18862535e-02f, -1.96178362e-01f, 3.80133130e-02f, 8.46117139e-02f, 1.24208890e-01f, 1.35908648e-01f,
  1.48071304e-01f, 2.78214943e-02f, 2.79513430e-02f, -4.22562510e-02f, -1.02425270e-01f, 3.30288112e-02f, -1.43599182e-01f, 1.09835863e-01f, 1.16558842e-01f, 4.99146618e-02f,
  6.53089350e-03f, 8.78413096e-02f, -1.66302882e-02f, 2.79408582e-02f, 1.91056710e-02f, 9.56659764e-02f, -6.83832588e-03f, -1.31942602e-02f, 6.47614971e-02f, -2.77647972e-01f,
  -8.19237769e-01f, 3.13295931e-01f, 1.79668009e-01f, -8.67097616e-01f, 6.40698895e-02f, 9.51988623e-02f, 6.26387119e-01f, -4.89229448e-02f, -4.83735174e-01f, 4.30712044e-01f,
  4.73741114e-01f, 5.40043712e-02f, 1.65587500e-01f, 5.50211370e-02f, -5.49681559e-02f, 2.41366699e-01f, -2.09488779e-01f, -2.71410972e-01f, -1.65962711e-01f, -8.06188136e-02f,
  6.78500114e-03f, -3.48239243e-01f, -6.40041709e-01f, -1.94420412e-01f, 8.31540748e-02f, 3.41222137e-01f, 1.44677565e-01f, -2.33131930e-01f, 1.84137240e-01f, -1.02029644e-01f,
  4.74173754e-01f, -7.64285997e-02f, -4.44134176e-02f, -3.01454842e-01f, 1.17389865e-01f, -2.18089223e-01f, -4.06579077e-02f, -8.23738351e-02f, 9.59191397e-02f, -2.08077095e-02f,
  -1.38744593e-01f, -1.09375622e-02f, -2.49260485e-01f, 5.06802946e-02f, -5.07803969e-02f, -1.34938926e-01f, -1.19286954e-01f, -1.10059932e-01f, -5.59418313e-02f, 5.07037997e-01f,
  1.19523942e-01f, 6.57654479e-02f, -2.75321677e-02f, 8.86586308e-02f, -1.53248116e-01f, -9.65318903e-02f, 1.25389650e-01f, -2.07461610e-01f, -2.92786472e-02f, 6.26180694e-02f,
  1.15963407e-01f, 3.38270403e-02f, 7.60239810e-02f, -3.99717223e-03f, -8.69161487e-02f, 6.10207692e-02f, 8.02376568e-02f, 7.12742880e-02f, 9.25222319e-03f, 1.30003437e-01f,
  1.76969077e-02f, 8.54383335e-02f, 1.04348809e-01f, -5.71519770e-02f, 8.36757421e-02f, 6.86103702e-02f, 6.15631230e-02f, 3.37870345e-02f, -5.25173359e-02f, -3.81126907e-03f,
  -2.30875537e-02f, -1.93619847e-01f, -4.42709774e-02f, -3.14291380e-02f, -1.19139291e-01f, -1.40811175e-01f, 7.55580962e-02f, -2.85452269e-02f, -2.64048018e-03f, -1.27468571e-01f,
  1.35087669e-01f, -3.65809277e-02f, 4.83338647e-02f, 3.11506726e-02f, 2.40598824e-02f, 2.85770763e-02f, 1.40576093e-02f, -4.54927832e-02f, 6.41627163e-02f, 6.74572140e-02f,
  4.81685065e-03f, -1.12015698e-02f, 6.64910302e-02f, 2.38110527e-01f, 6.83332980e-02f, -9.16181058e-02f, -4.05586287e-02f, -2.64858920e-02f, -1.83317006e-01f, -1.73856542e-01f,
  -1.32081658e-01f, -8.27529207e-02f, -1.30924463e-01f, -4.53390256e-02f, -3.95078324e-02f, 1.19809315e-01f, 1.05841190e-01f, -7.96691626e-02f, 3.39026824e-02f, 2.07609132e-01f,
  1.14477118e-02f, 9.32474881e-02f, 5.70270240e-01f, -1.54692270e-02f, 6.52765453e-01f, 7.97738552e-01f, 9.53090310e-01f, 3.59006107e-01f, 1.02306725e-02f, 5.00824526e-02f,
  -5.96095137e-02f, -4.73212659e-01f, -5.03221333e-01f, -5.08151710e-01f, -1.09031327e-01f, 1.73478782e-01f, 1.18950650e-01f, -6.60932884e-02f, 2.17918027e-02f, 3.69600713e-01f,
  -8.00518245e-02f, 1.87802210e-01f, -4.47930433e-02f, -6.66420981e-02f, 1.81895554e-01f, -2.73723513e-01f, 9.04049650e-02f, 2.24520013e-01f, -1.50155142e-01f, -1.80579722e-01f,
  -1.72334507e-01f, 3.04028928e-01f, -9.90205035e-02f, -3.52704883e-01f, 5.48935346e-02f, -5.04970513e-02f, 6.14208132e-02f, -2.46556420e-02f, -1.48126528e-01f, -3.86679396e-02f,
  1.94649491e-02f, -5.78248240e-02f, 6.12219013e-02f, 4.60225791e-02f, 2.26614773e-01f, 5.55251911e-02f, -3.28689814e-02f, 2.91969124e-02f, -4.32980806e-02f, -1.01693109e-01f,
  -6.85941055e-02f, 9.03237611e-02f, 2.11964160e-01f, 2.22501487e-01f, 7.79331550e-02f, -1.73418298e-01f, 4.72774878e-02f, 2.30053775e-02f, 3.40012647e-02f, -2.55502075e-01f,
  1.12802591e-02f, 3.32156452e-03f, 6.75556064e-02f, -2.20311861e-02f, 3.39077823e-02f, -9.62451100e-02f, 9.99240801e-02f, -4.24241088e-02f, 8.31476152e-02f, 1.76182508e-01f,
  7.89084062e-02f, 1.81230307e-02f, 6.26591146e-02f, 1.74543872e-01f, -6.03200756e-02f, 1.91190198e-01f, 6.75738528e-02f, -1.02029145e-01f, 2.42569614e-02f, -4.29528058e-02f,
  -8.01569689e-03f, 9.19456184e-02f, 9.35180634e-02f, 1.93086356e-01f, -4.36979495e-02f, -1.21701747e-01f, -4.89786938e-02f, -1.85773950e-02f, 1.59814134e-02f, 1.00010507e-01f,
  -1.73832461e-01f, 1.09332874e-01f, -1.67391598e-01f, -1.01282619e-01f, 1.08131438e-01f, -8.10232237e-02f, 1.92034878e-02f, -6.79335818e-02f, -1.34810403e-01f, 1.16319088e-02f,
  -1.37811489e-02f, 4.28397916e-02f, 4.76183556e-02f, 7.48202130e-02f, 8.87480974e-02f, 7.59940371e-02f, -2.47235168e-02f, -1.69767495e-02f, -1.89118162e-01f, -3.08895279e-02f,
  -4.60062250e-02f, -1.96507038e-03f, 7.07371607e-02f, 6.28685206e-02f, -2.86702625e-03f, -1.89321771e-01f, -4.43941765e-02f, -1.01401329e-01f, 1.31462112e-01f, -2.56981552e-01f,
  7.70293295e-01f, 4.86468762e-01f, -6.64418042e-02f, 1.38594676e-02f, -1.08353607e-01f, -2.56763518e-01f, -1.05163500e-01f, -1.06341995e-01f, -4.50293496e-02f, 2.55308837e-01f,
  2.20879793e-01f, -4.13966849e-02f, -1.67735681e-01f, -1.92187309e-01f, -2.09643126e-01f, -1.99576635e-02f, -2.17304807e-02f, -2.17188016e-01f, -5.43462873e-01f, -1.24693260e-01f,
  -1.61720186e-01f, 5.22331670e-02f, -8.96603614e-03f, -2.31812000e-01f, 3.37274402e-01f, -1.71681747e-01f, -3.53922322e-02f, 3.94790888e-01f, 1.97343513e-01f, 6.24353230e-01f,
  6.10266507e-01f, 4.44560707e-01f, -4.22143996e-01f, 1.13819237e-03f, 1.52136043e-01f, 1.15250483e-01f, 1.10016070e-01f, 1.05395347e-01f, 1.60505064e-02f, 1.46973561e-02f,
  2.18078271e-01f, 6.25459552e-02f, 5.80724254e-02f, 4.20047827e-02f, 2.95171794e-02f, -2.02225506e-01f, -8.56902599e-02f, -5.32479957e-02f, -2.62107074e-01f, 8.22748989e-03f,
  -4.16443758e-02f, 2.65635282e-01f, 3.37939560e-02f, -2.14327395e-01f, -8.80619735e-02f, -2.54663348e-01f, 2.07577273e-02f, 1.18903294e-01f, -1.67588487e-01f, 3.91575605e-01f,
  -1.42412901e-01f, 1.56317562e-01f, 1.93103775e-02f, 8.32451694e-03f, -4.10596393e-02f, -4.75939782e-03f, 9.48736146e-02f, -2.48531923e-02f, -6.56788945e-02f, 1.55661022e-02f,
  -2.18611583e-02f, 7.36426637e-02f, 1.16540618e-01f, -1.00496046e-01f, -6.82649901e-03f, 4.20207679e-02f, 3.17458659e-02f, 3.98143791e-02f, -8.66081193e-03f, 3.41000557e-02f,
  -9.83589441e-02f, 8.40043053e-02f, 1.57562703e-01f, -2.80200187e-02f, -9.16082412e-02f, -3.08035836e-02f, -6.19417503e-02f, 6.22804873e-02f, -9.65851769e-02f, 2.39671841e-02f,
  -2.83846289e-01f, -5.12762308e-01f, 1.57121778e-01f, 1.37006491e-01f, 1.82630152e-01f, -9.96524766e-02f, 1.17569618e-01f, -2.44793724e-02f, 1.08703680e-01f, 1.02134019e-01f,
  -1.23469211e-01f, 2.94143055e-02f, 7.31013492e-02f, -7.41006881e-02f, -8.00613016e-02f, -4.86601703e-02f, 7.28204027e-02f, -5.55018671e-02f, -1.25408605e-01f, 2.82440279e-02f,
  -4.67055365e-02f, -2.15921536e-01f, -2.86673725e-01f, -1.26931101e-01f, -2.62763947e-02f, -1.97433606e-01f, -1.41244188e-01f, -2.88264547e-02f, -2.70340353e-01f, -2.63391167e-01f,
  1.69370875e-01f, -3.65041524e-01f, -6.57391727e-01f, 1.35195896e-01f, 2.21055984e-01f, 1.31122932e-01f, -5.01972973e-01f, -9.27446224e-03f, 2.17027038e-01f, -4.32802469e-01f,
  5.81150874e-02f, 5.57245135e-01f, -3.49797085e-02f, 6.87872842e-02f, -1.97393984e-01f, -5.57515204e-01f, -4.10637021e-01f, -1.86181635e-01f, 3.77875298e-01f, 5.08287132e-01f,
  5.74465632e-01f, 8.05826932e-02f, 1.67807713e-01f, 9.29384083e-02f, -7.31105432e-02f, 2.09544495e-01f, -4.94180560e-01f, 1.78005062e-02f, -1.67541194e-03f, -3.06262560e-02f,
  5.48506044e-02f, -1.20139755e-01f, 1.63293481e-01f, 1.14326261e-01f, 1.72497295e-02f, -2.07772210e-01f, -1.31009862e-01f, -9.83256251e-02f, 1.16893776e-01f, -1.29627064e-01f,
  8.97468403e-02f, 4.58962284e-02f, 1.60789471e-02f, 2.10344255e-01f, 1.10416673e-01f, 1.23403519e-01f, -2.26653680e-01f, -1.65297449e-01f, -2.28137359e-01f, -1.49433389e-01f,
  1.08436629e-01f, 2.91334301e-01f, -7.32779354e-02f, -1.21307999e-01f, -3.57875198e-01f, 1.33473441e-01f, -8.16997290e-02f, 1.49318203e-01f, -2.43725330e-01f, -1.71053573e-01f,
  1.54851936e-02f, 1.43759489e-01f, 4.25803848e-02f, -9.36571211e-02f, 2.83363741e-04f, 4.18453515e-02f, -5.37143387e-02f, 1.28704473e-01f, 1.13880672e-01f, -1.73695505e-01f,
  6.94379508e-02f, 1.08500952e-02f, 1.49004078e-02f, -3.35779674e-02f, 1.76508352e-01f, 1.70160029e-02f, 1.12988971e-01f, 6.47185929e-03f, 1.31962702e-01f, 3.74268880e-03f,
  6.01367317e-02f, -8.33470374e-02f, 4.86713834e-02f, 1.06205754e-01f, -6.24493659e-02f, -9.97060016e-02f, 1.29569292e-01f, -5.93549311e-02f, -5.23631386e-02f, -8.34128633e-02f,
  1.18991345e-01f, -4.60704565e-02f, 3.16253230e-02f, -4.52955961e-02f, 7.53367767e-02f, 1.10485524e-01f, 1.05801746e-01f, 9.94825959e-02f, 8.75349715e-02f, 3.05868722e-02f,
  3.19412984e-02f, -3.67693044e-02f, -1.38267621e-01f, -9.18202009e-03f, 1.38579430e-02f, -5.93791865e-02f, 1.83403473e-02f, 6.32463768e-02f, 4.25752029e-02f, -3.17057818e-02f,
  -1.94894090e-01f, -5.07289022e-02f, -1.25963286e-01f, -1.42981261e-01f, 1.00114800e-01f, 1.94362462e-01f, -2.15828925e-01f, 2.59091146e-03f, -4.08228338e-02f, -5.37641346e-01f,
  9.51649547e-01f, -9.91629422e-01f, 1.38955593e-01f, 2.54250497e-01f, 2.81544954e-01f, 3.73985857e-01f, -7.03561213e-03f, -7.32787978e-03f, 4.53204028e-02f, -8.13874304e-02f,
  -2.39808001e-02f, 2.41239637e-01f, 2.47242734e-01f, -2.66647469e-02f, 9.93116945e-02f, -1.10535044e-03f, 8.52960944e-02f, 1.99375734e-01f, 4.12110090e-01f, 1.33340895e-01f,
  -2.07679302e-01f, -3.22325528e-01f, -9.22895968e-02f, -1.10571422e-01f, -3.52710843e-01f, 3.52647930e-01f, -2.20768690e-01f, -3.76059681e-01f, -2.92578757e-01f, -5.46075761e-01f,
  3.05363815e-02f, -1.13998972e-01f, 1.42303348e-01f, -1.57157287e-01f, -4.19604965e-02f, -4.35539708e-02f, 3.38481367e-02f, -1.60491258e-01f, -6.07451145e-03f, -1.23811467e-02f,
  -4.82797287e-02f, -3.70930545e-02f, 5.65247610e-02f, 7.48087605e-03f, -1.42282978e-01f, -8.95328671e-02f, -1.09601915e-01f, -7.94307441e-02f, -5.58498316e-02f, -1.09999977e-01f,
  -9.34598297e-02f, 1.87463313e-02f, 2.03507170e-02f, -2.63984669e-02f, 7.40190297e-02f, 2.40562275e-01f, -8.57809409e-02f, -4.14998755e-02f, 6.11968376e-02f, -1.77394688e-01f,
  -3.92474681e-02f, 9.81165469e-03f, 2.33075276e-04f, -8.47110078e-02f, -2.15094648e-02f, 2.22496931e-02f, 7.90908858e-02f, -8.53668340e-03f, 1.01252563e-01f, -9.94554386e-02f,
  -7.81767070e-02f, 1.18310399e-01f, 1.31562212e-02f, 7.01581780e-03f, -6.14215881e-02f, 3.97215923e-03f, -1.10867359e-02f, -5.62693253e-02f, -2.54961587e-02f, 5.99699207e-02f,
  2.90366448e-03f, 6.80848584e-03f, -1.05238006e-01f, -6.48645610e-02f, -6.54175580e-02f, -7.32233822e-02f, 3.20283957e-02f, -3.41370478e-02f, 6.23571314e-02f, -7.66551774e-03f,
  -4.14341569e-01f, 3.36354882e-01f, 1.88854709e-02f, 4.84512893e-05f, 3.12080607e-02f, -1.64945990e-01f, 9.23619792e-02f, -8.68035778e-02f, -1.09255336e-01f, -3.02446689e-02f,
  1.73090249e-02f, 9.67131462e-03f, -1.60079151e-01f, -8.90163407e-02f, 7.85241276e-02f, 3.59665975e-02f, -7.05820248e-02f, 1.25023291e-01f, 8.04543670e-04f, -1.79874703e-01f,
  -1.31448269e-01f, 7.99834132e-02f, 2.12271348e-01f, 1.59640133e-01f, 1.29981756e-01f, 3.30426216e-01f, 1.10571139e-01f, 1.02494642e-01f, 2.29633987e-01f, -1.23631291e-01f,
  -6.50523484e-01f, 2.89481580e-02f, -3.58186103e-02f, -3.88606399e-01f, 1.96628258e-01f, 3.54835391e-01f, 1.30711138e-01f, 2.80145407e-01f, 2.19139472e-01f, -4.59717475e-02f,
  -1.77921318e-02f, -6.02120236e-02f, -1.24967285e-01f, 7.69810192e-03f, -1.83730841e-01f, -5.98622188e-02f, -3.72979492e-01f, -3.23941231e-01f, 1.23874560e-01f, 4.63763624e-01f,
  2.82148700e-02f, -3.54100019e-01f, -3.58364403e-01f, -1.26613915e-01f, -1.94436267e-01f, -2.69562215e-01f, -4.99245763e-01f, -3.87125343e-01f, -9.17665139e-02f, -5.40940166e-01f,
  -2.33351812e-02f, 7.73325861e-02f, 1.53386921e-01f, -2.28182763e-01f, -7.39528760e-02f, 8.95358920e-02f, 7.65473023e-02f, 4.15726267e-02f, 6.66308627e-02f, -3.68637182e-02f,
  -1.32511437e-01f, 2.54108310e-01f, -3.67217474e-02f, -6.72102789e-04f, -6.20617606e-02f, 1.95390522e-01f, 8.83931518e-02f, -4.05559829e-03f, 1.74442343e-02f, 1.88153923e-01f,
  -1.72745958e-01f, 1.86340685e-03f, 5.60242645e-02f, 3.62191021e-01f, 3.19426566e-01f, -2.57021617e-02f, 2.15551153e-01f, 2.83916444e-01f, 8.96843448e-02f, -1.55653030e-01f,
  5.88071384e-02f, -1.10501043e-01f, 1.13569818e-01f, 1.42671481e-01f, -1.57201990e-01f, 2.17842296e-01f, -8.03817436e-02f, -3.57426964e-02f, -1.00233883e-03f, -7.06925094e-02f,
  3.91124338e-02f, 4.66813669e-02f, -1.25614898e-02f, -9.06526446e-02f, -1.73763201e-01f, 4.35172953e-02f, -1.21827029e-01f, -8.16234052e-02f, -6.30052760e-02f, 1.14193276e-01f,
  -3.98145914e-02f, 2.70159598e-02f, 8.84307455e-03f, -9.53839794e-02f, -1.26722939e-02f, -5.87313473e-02f, 3.04262750e-02f, 1.17674559e-01f, 1.04220845e-01f, 3.94821204e-02f,
  -2.98487842e-01f, 1.96719915e-01f, -3.29945505e-01f, 4.97429520e-02f, -1.01099595e-01f, -8.54129940e-02f, -1.77389175e-01f, -6.51367307e-02f, -2.26845995e-01f, -5.52434772e-02f,
  1.07461318e-01f, -1.84790134e-01f, -6.85709342e-02f, 1.64761856e-01f, -8.95860568e-02f, -4.98845130e-02f, -4.14036773e-02f, -2.45658994e-01f, 1.60741191e-02f, 1.39038200e-02f,
  -7.62670189e-02f, -1.59310833e-01f, -2.79910862e-01f, -4.78724539e-02f, -5.59636466e-02f, -2.69203842e-01f, -2.25982487e-01f, -1.41648322e-01f, -5.24435379e-02f, -5.98120570e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  9.55844879e-01f, 1.11530554e-02f, 1.03950508e-01f, 5.39795309e-02f, 4.51963723e-01f, -1.23378992e-01f, 1.85430646e-01f, 1.80535585e-01f, 2.79186994e-01f, -4.98321652e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.56109026e-02f, -1.83425009e-01f, -9.59787443e-02f, -1.52047584e-02f, -1.46080971e-01f, 2.32659400e-01f, 4.73327488e-02f, 1.37541056e-01f, 1.06704384e-01f, -1.95701778e-01f,
  -2.97862887e-01f, 1.27065599e-01f, 3.05362701e-01f, -7.57605731e-02f, -1.17894948e-01f, 2.78617740e-01f, -2.43439138e-01f, -1.08830333e-01f, 8.03824663e-02f, -2.46176776e-02f,
  -3.53904694e-01f, 2.12052539e-01f, 1.67404205e-01f, 1.39038280e-01f, 2.64919758e-01f, 8.00317749e-02f, -6.78928494e-02f, -2.78530270e-01f, -3.29484135e-01f, 8.45118940e-01f,
  1.47052258e-01f, -1.68082595e-01f, -9.75020155e-02f, 8.33769049e-03f, 1.23221897e-01f, 7.84055796e-03f, 4.05599475e-02f, 2.13439211e-01f, -3.42463106e-01f, 6.30570874e-02f,
  -1.20761141e-01f, 3.04187864e-01f, 1.85511127e-01f, -1.53748542e-01f, 6.31095946e-01f, -1.51481166e-01f, -2.45939076e-01f, -2.41177961e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.00024408e-02f, 2.33214095e-01f, -4.50739898e-02f, -6.50262237e-02f, 9.48993955e-03f, -8.07511881e-02f, -1.30479828e-01f, -6.50605321e-01f, 5.76644599e-01f, -1.14590563e-01f,
  3.94159049e-01f, -2.14285016e-01f, -1.06787694e+00f, 5.36766469e-01f, -4.41977605e-02f, 6.96075022e-01f, -1.34096649e-02f, 3.41543794e-01f, 5.34072459e-01f, 2.70738393e-01f,
  -1.38392553e-01f, 2.41808981e-01f, 8.46288383e-01f, 4.40717310e-01f, 1.42454684e-01f, 1.00742258e-01f, 2.64724284e-01f, -1.64724141e-01f, -1.48781493e-01f, 3.75643283e-01f,
  2.02308849e-01f, -4.78811681e-01f, 2.71399826e-01f, 3.95978689e-01f, 3.46540749e-01f, 5.95127977e-02f, -4.44642156e-01f, 1.61376014e-01f, 4.79779214e-01f, -9.70303193e-02f,
  1.07356951e-01f, 2.90568676e-02f, -2.48370409e-01f, -3.84139061e-01f, 9.97548997e-02f, 1.07149446e+00f, -1.84158713e-01f, 5.60608149e-01f, -1.68663338e-01f, -2.25623623e-01f,
  1.98352695e-01f, 2.90412486e-01f, -1.68900579e-01f, 6.98988199e-01f, 1.04302868e-01f, -8.42807472e-01f, 7.77534604e-01f, -4.34389621e-01f, 7.81606138e-01f, -4.68512356e-01f,
  6.26780167e-02f, 7.55259320e-02f, -2.14256510e-01f, 5.73377728e-01f, 4.33800608e-01f, 3.11009258e-01f, 4.95594561e-01f, 4.34648186e-01f, -4.14195806e-01f, 1.31503463e-01f,
  1.44952551e-01f, -2.25263968e-01f, 1.55511826e-01f, -4.18976545e-01f, 5.54110050e-01f, -3.25816125e-01f, 1.90213799e-01f, -3.23560655e-01f, -1.55228674e-01f, -2.83885896e-01f,
  3.71768653e-01f, 5.11887610e-01f, 4.51689690e-01f, 1.21806979e-01f, -3.07769507e-01f, -3.86424512e-01f, 1.19548757e-02f, 1.88066624e-02f, 5.39983273e-01f, -2.92380810e-01f,
  2.49027293e-02f, -1.83217265e-02f, -6.15046322e-01f, 2.29186952e-01f, -6.14690296e-02f, 2.91990757e-01f, -1.95994928e-01f, 2.75015295e-01f, 6.83018506e-01f, 6.22226074e-02f,
  -4.22060072e-01f, 5.85816614e-02f, 1.94221854e-01f, -1.06112204e-01f, 9.03326422e-02f, 5.62024295e-01f, 3.90752971e-01f, 6.17166579e-01f, -1.08909622e-01f, -4.36497480e-01f,
  4.91879284e-01f, -2.48041525e-01f, 2.09893301e-01f, -6.19492820e-03f, 9.04853195e-02f, -1.38226137e-01f, 4.86254603e-01f, 2.03850418e-01f, 3.45721483e-01f, 2.59733886e-01f,
  -1.39328957e-01f, -1.89751759e-01f, -6.59317803e-03f, 2.30428025e-01f, -7.15403676e-01f, -1.73923060e-01f, 1.08963537e+00f, -7.93715417e-01f, 4.43328351e-01f, 4.70419914e-01f,
  1.33482978e-01f, 2.60079414e-01f, -2.48158097e-01f, 3.27541590e-01f, 2.75303990e-01f, -4.61159021e-01f, 4.29475754e-01f, -3.85973483e-01f, 8.46352518e-01f, -8.24797630e-01f,
  -4.50669713e-02f, -7.71333516e-01f, -4.73740429e-01f, 5.57647198e-02f, 1.49760991e-01f, 6.76267207e-01f, 6.36222303e-01f, -5.44291846e-02f, 3.30448329e-01f, -2.48280674e-01f,
  3.09836984e-01f, 1.52210012e-01f, -5.70645273e-01f, 6.01915181e-01f, -9.16464068e-03f, 7.13861644e-01f, 2.67120272e-01f, 2.97905877e-02f, 1.92448527e-01f, -1.28808200e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.27470596e-02f, 3.64202261e-01f, 1.10430084e-01f, 1.37712047e-01f, 4.57402110e-01f, -1.99577540e-01f, 3.31899583e-01f, -1.82307050e-01f, 1.88654229e-01f, 6.40732229e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.40724379e-01f, 3.45304161e-01f, 3.18771988e-01f, 3.91480625e-01f, 3.06929499e-01f, 1.25279784e-01f, 5.02774864e-02f, 2.57646412e-01f, -4.89269048e-01f, 3.40528727e-01f,
  3.56275678e-01f, 1.52448237e-01f, -2.63516992e-01f, -9.97741669e-02f, 4.67832349e-02f, -1.44615918e-01f, -2.75583118e-01f, 9.14720297e-02f, 1.85672745e-01f, 1.40727282e-01f,
  -3.35553765e-01f, -3.65294576e-01f, 2.77934343e-01f, 2.79369116e-01f, 1.98479295e-01f, 5.09382635e-02f, 6.16203286e-02f, 2.32216343e-01f, -4.41624582e-01f, 3.37256253e-01f,
  1.79183036e-01f, -5.05022854e-02f, -7.55771846e-02f, -4.07092869e-01f, -2.13091061e-01f, 3.46508771e-02f, 2.76378859e-02f, -2.49680787e-01f, -3.32353622e-01f, 3.37187469e-01f,
  -2.55312055e-01f, 6.96569532e-02f, 1.51855648e-01f, -3.68336618e-01f, 1.64400652e-01f, 7.04719946e-02f, 1.14438698e-01f, 9.21816453e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.48863548e-01f, 9.15479600e-01f, 5.12945950e-01f, -1.01933110e+00f, 1.05194859e-01f, -8.09043467e-01f, 6.18712246e-01f, -7.71663338e-02f, 3.30054713e-03f, 3.34325463e-01f,
  4.73787010e-01f, 5.10803103e-01f, 3.34271230e-02f, -1.04227059e-01f, 5.72327673e-01f, 8.63457173e-02f, 6.29070044e-01f, 5.94191141e-02f, 2.69478768e-01f, -5.23621261e-01f,
  4.92042631e-01f, 3.28297377e-01f, -4.17203903e-01f, 4.05166000e-01f, 2.15807527e-01f, -4.25028741e-01f, -3.78276587e-01f, -3.88453215e-01f, 3.62606734e-01f, 5.31265438e-01f,
  -5.15371740e-01f, 6.24290466e-01f, -1.31595239e-01f, -1.66388795e-01f, -1.28970876e-01f, -2.55032539e-01f, 9.61141661e-03f, -9.99695808e-02f, 9.42891538e-01f, 4.89865802e-02f,
  1.01410381e-01f, 8.52598071e-01f, 2.95123488e-01f, 4.41269189e-01f, 2.74144471e-01f, -1.94195345e-01f, 3.32863122e-01f, -6.61697686e-01f, 6.69621646e-01f, 5.45201480e-01f,
  6.12200350e-02f, 4.36535358e-01f, 1.15268648e+00f, -5.41864216e-01f, -6.97268367e-01f, 3.47804487e-01f, 4.53447104e-01f, 4.24195260e-01f, 7.64809012e-01f, -1.09934360e-01f,
  3.73118341e-01f, 2.88908303e-01f, 6.86694622e-01f, -6.40177205e-02f, 1.21014483e-01f, -6.08351380e-02f, -3.17617387e-01f, 1.13032722e+00f, -4.80507046e-01f, 8.86559725e-01f,
  2.94537693e-01f, -1.29554331e-01f, 7.05941737e-01f, 4.36939538e-01f, 1.11173511e-01f, 6.11175820e-02f, -8.48582208e-01f, -4.70931828e-01f, 6.61906153e-02f, 1.42661378e-01f,
  7.99176395e-01f, 5.98400176e-01f, -2.00290963e-01f, 6.43228114e-01f, 4.83233094e-01f, 4.28426802e-01f, 5.47454506e-02f, 3.16771753e-02f, 5.87213457e-01f, 1.13844275e-01f,
  2.78237820e-01f, 2.06013292e-01f, 2.70598173e-01f, -6.53479576e-01f, -1.68789059e-01f, 2.56878644e-01f, 1.60881519e-01f, -1.16834685e-01f, -1.19341761e-01f, -5.43407090e-02f,
  -1.05043042e+00f, 1.18177652e+00f, -4.97723401e-01f, -4.51822013e-01f, -1.36255956e+00f, -6.52897120e-01f, -3.42091359e-02f, -8.11740041e-01f, 5.02094030e-01f, 2.87214637e-01f,
  -3.87851298e-01f, 6.24438822e-01f, 4.24746782e-01f, -6.46794662e-02f, -2.51635700e-01f, 8.81767452e-01f, -5.29327035e-01f, 6.91612780e-01f, 7.89173067e-01f, -1.30845904e-01f,
  4.72969592e-01f, 5.86481512e-01f, -2.43206725e-01f, 4.64085698e-01f, -2.63684362e-01f, -5.38955033e-01f, -1.00952722e-01f, -3.28484118e-01f, 2.62726039e-01f, -3.57248427e-05f,
  4.81568240e-02f, -3.59636843e-01f, 8.03112745e-01f, -9.22306716e-01f, -2.06322595e-01f, 7.20514238e-01f, 2.53965884e-01f, 4.81172591e-01f, 7.82567322e-01f, 1.08354673e-01f,
  3.54490727e-01f, 4.26740050e-01f, 6.32756531e-01f, 2.58027226e-01f, 3.07267338e-01f, 1.86963350e-01f, -6.39285624e-01f, 1.17489040e+00f, -2.92181164e-01f, 7.59883404e-01f,
  -2.35147104e-01f, 5.11151791e-01f, 3.04966033e-01f, -9.50540751e-02f, 2.73866747e-02f, -1.95432276e-01f, -7.18306527e-02f, -2.83807099e-01f, 1.96783915e-02f, 3.05159956e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.12546879e-01f, 2.77553976e-01f, -3.71621668e-01f, 2.57918507e-01f, 8.25194921e-03f, 1.69637740e-01f, 5.96435428e-01f, -7.13829473e-02f, 3.59083802e-01f, 5.36285043e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.69748828e-01f, 2.59557605e-01f, 1.29108205e-01f, 3.39505732e-01f, 3.07559688e-03f, -3.68590951e-01f, 3.17100644e-01f, -2.70203769e-01f, 6.63817376e-02f, 1.90865561e-01f,
  -6.32987171e-02f, 2.08690524e-01f, 1.65498272e-01f, 1.27081022e-01f, -4.64561254e-01f, 3.34161609e-01f, -4.93093580e-01f, -4.21199203e-01f, 9.99863967e-02f, 1.54397175e-01f,
  -7.65961885e-01f, 2.01486200e-02f, -8.94183591e-02f, -7.90736377e-02f, -1.23131178e-01f, 5.07760607e-02f, 1.95625007e-01f, 3.91866326e-01f, 2.72126347e-01f, 2.09833056e-01f,
  -2.97789931e-01f, 2.90399231e-02f, 1.95474789e-01f, 1.69841811e-01f, -3.08013946e-01f, -1.78191870e-01f, 8.88240755e-01f, -8.03268254e-02f, 2.74568677e-01f, -1.93338051e-01f,
  3.35682705e-02f, 2.36099325e-02f, 2.48647615e-01f, 5.16723357e-02f, -2.83396780e-01f, 9.92269069e-02f, -1.23121448e-01f, 1.47724703e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -5.23249686e-01f, 9.53389645e-01f, 2.05456808e-01f, -1.20335293e+00f, -3.32155019e-01f, -6.98350012e-01f, 8.28976095e-01f, 2.65788615e-01f, 3.67450476e-01f, -9.78564918e-02f,
  -3.80648136e-01f, -1.57906920e-01f, 2.77724683e-01f, 1.84237882e-01f, 1.12832181e-01f, -1.52306712e+00f, 5.81585944e-01f, 6.55227840e-01f, 8.17945004e-01f, 6.22779548e-01f,
  2.60036647e-01f, -9.42768335e-01f, 2.17896670e-01f, -1.69612303e-01f, 4.41021174e-01f, 2.64624450e-02f, 1.39163959e+00f, 6.37730360e-01f, 3.90739977e-01f, 1.23751724e+00f,
  1.54297560e-01f, 9.11795259e-01f, -2.34681129e-01f, 8.33027661e-02f, 5.52987099e-01f, -3.00037265e-01f, -4.21245486e-01f, 4.53444839e-01f, -7.27821052e-01f, -9.69000533e-02f,
  -2.65979886e-01f, -1.21079063e+00f, 5.80166951e-02f, -1.19719759e-01f, 9.31205213e-01f, -4.07774933e-02f, -5.06802201e-01f, 5.19160867e-01f, -3.24627727e-01f, -4.98200625e-01f,
  -5.60057759e-01f, -3.02325726e-01f, -3.95513088e-01f, 9.42541778e-01f, -3.86953093e-02f, 1.79690912e-01f, 2.69335032e-01f, 4.30156171e-01f, -2.75064521e-02f, -4.94566947e-01f,
  4.08277303e-01f, -2.45523185e-01f, 4.83073324e-01f, -4.96501148e-01f, 8.63074422e-01f, 4.50476855e-01f, 3.55442107e-01f, -6.66916788e-01f, -1.61841154e-01f, 1.88727379e-02f,
  1.50633499e-01f, 4.12115008e-01f, -8.01355064e-01f, 4.49949771e-01f, -9.66769010e-02f, 8.61914158e-01f, -3.09076369e-01f, -4.71923172e-01f, 3.77596349e-01f, 9.99079272e-02f,
  -2.47134000e-01f, -4.07975793e-01f, 2.61494607e-01f, 9.67043042e-01f, -2.78714120e-01f, 5.72026670e-01f, 1.01503193e+00f, -7.14672327e-01f, 7.98084915e-01f, 3.42614800e-01f,
  -1.85291842e-02f, 2.87646413e-01f, 4.03190702e-01f, 2.87684798e-01f, 3.73130381e-01f, -5.21050632e-01f, -1.08576812e-01f, -7.32647955e-01f, 9.53530893e-03f, 5.25205135e-01f,
  1.09545422e+00f, -2.66496599e-01f, 5.31725466e-01f, 9.71889123e-02f, 7.77045935e-02f, 5.67508936e-01f, -3.07753026e-01f, -4.36096668e-01f, -7.77665824e-02f, -1.60602421e-01f,
  5.96067131e-01f, -7.79072046e-01f, -4.29862142e-01f, -1.32754415e-01f, 1.91661529e-02f, -1.53647423e-01f, -1.38535523e+00f, 7.23140895e-01f, -6.07833445e-01f, 3.85054618e-01f,
  -5.63988268e-01f, -1.83965694e-02f, -1.40407550e+00f, 3.09750259e-01f, 7.05329359e-01f, -7.26716399e-01f, 1.20310999e-01f, 1.99362069e-01f, -6.07629478e-01f, 1.94130704e-01f,
  1.94194481e-01f, 1.50578380e-01f, -1.49640158e-01f, 7.88022995e-01f, 1.32823184e-01f, 3.53094190e-01f, -2.77360737e-01f, -2.95049638e-01f, -6.39881551e-01f, -7.65425265e-01f,
  8.09492528e-01f, -4.04607892e-01f, -1.03595592e-02f, -6.69520497e-01f, 6.50520623e-01f, 9.67890024e-01f, 7.35260844e-01f, -3.17657620e-01f, 7.00247109e-01f, 3.70674551e-01f,
  4.57366616e-01f, 1.41503081e-01f, -7.73025095e-01f, -4.70313132e-02f, -5.01287639e-01f, -2.29302496e-01f, 3.48146617e-01f, 5.41660301e-02f, 5.60111329e-02f, -4.19725776e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  6.77945912e-02f, 4.27031368e-01f, 8.90582129e-02f, -3.82081568e-01f, 2.80925244e-01f, 1.66114151e-01f, 3.69923323e-01f, 2.29219124e-01f, 8.78995582e-02f, 7.89281130e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.57301649e-01f, 2.99107671e-01f, 3.41236025e-01f, -9.36389789e-02f, -3.32342178e-01f, -1.18036345e-01f, -4.54621106e-01f, 5.64219177e-01f, -9.37603533e-01f, -6.76388621e-01f,
  -2.36439899e-01f, 1.40311450e-01f, -3.96839857e-01f, -1.50109623e-02f, -2.56487820e-02f, 4.99336421e-01f, 3.75645816e-01f, -2.73511726e-02f, 1.14913844e-01f, 8.44183087e-01f,
  -7.48775378e-02f, -6.03748918e-01f, -4.31825370e-01f, -6.39848650e-01f, 2.13153720e-01f, 3.08486611e-01f, 3.35389405e-01f, -1.02311528e+00f, 3.67999792e-01f, 7.13788942e-02f,
  1.60734460e-01f, 5.63269621e-03f, 3.92789662e-01f, 1.38792291e-01f, 1.27479568e-01f, -5.64892948e-01f, -3.62434328e-01f, 2.61745960e-01f, 1.03039956e+00f, -2.97104239e-01f,
  -2.27594197e-01f, -9.15450752e-01f, 4.06329691e-01f, -2.27773279e-01f, 1.12144612e-01f, -6.53476119e-01f, -6.39626026e-01f, 6.41542435e-01f, -8.94321740e-01f, -7.19617367e-01f,
  -3.83517832e-01f, 3.44169676e-01f, -4.27613288e-01f, -6.06728315e-01f, 8.89614105e-01f, 3.00060779e-01f, -2.07422346e-01f, -3.20750624e-01f, -9.89133656e-01f, 9.82349366e-02f,
  1.65867612e-01f, -2.22104371e-01f, 3.40787560e-01f, -6.18307829e-01f, 4.24679577e-01f, 6.17357314e-01f, -1.21329200e+00f, 8.78110409e-01f, -4.13938612e-01f, 6.19796515e-01f,
  -8.47035289e-01f, 2.34522894e-01f, -1.83899790e-01f, -5.67722209e-02f, -3.70601386e-01f, 3.75110537e-01f, 3.11286569e-01f, 2.41783008e-01f, -2.25187451e-01f, -4.99677300e-01f,
  -1.27809012e+00f, -5.03590643e-01f, 4.25778717e-01f, -4.50784475e-01f, -1.91203982e-01f, 6.93014741e-01f, -1.00154960e+00f, -1.27983928e-01f, -1.17713816e-01f, 6.26027882e-02f,
  3.57403666e-01f, 3.05714250e-01f, 1.52632311e-01f, -2.56471336e-01f, -2.91366488e-01f, 1.05898231e-01f, 2.11011544e-02f, -1.12244934e-01f, 8.33380878e-01f, 5.51796734e-01f,
  4.35782701e-01f, -8.88500392e-01f, -8.42513680e-01f, 4.59056407e-01f, 7.14839399e-01f, -8.30222890e-02f, -2.86430359e-01f, -5.96234977e-01f, -1.05898544e-01f, 2.77487412e-02f,
  -7.49464393e-01f, 2.70963758e-01f, -1.86584666e-01f, 4.88843799e-01f, -5.81644058e-01f, -4.95372802e-01f, 1.24109042e+00f, 4.05108958e-01f, -1.15057957e+00f, -2.45172977e-01f,
  -7.92678833e-01f, 1.12073729e-02f, 3.60685557e-01f, -3.28551114e-01f, -7.02410638e-01f, 5.87994277e-01f, -5.45395315e-01f, -2.42755145e-01f, -5.91093183e-01f, 5.50726175e-01f,
  -1.80211857e-01f, -5.17295539e-01f, 3.06979030e-01f, -4.93508838e-02f, 8.98646474e-01f, -5.81640422e-01f, -4.01685625e-01f, 3.21933568e-01f, -1.28830135e-01f, -2.64755208e-02f,
  -3.25408727e-01f, 2.49002025e-01f, 6.48743391e-01f, 4.41479415e-01f, 5.73264778e-01f, 3.18156987e-01f, 1.17935948e-01f, 5.33980489e-01f, 6.99861825e-01f, 7.44210660e-01f,
  -5.26769519e-01f, 5.19976377e-01f, -1.12149298e+00f, -9.58483279e-01f, 4.83826429e-01f, -9.02653813e-01f, -8.19024861e-01f, -4.73624200e-01f, 2.47531325e-01f, -7.48765469e-01f,
  5.15025735e-01f, -2.58695483e-01f, 3.08905512e-01f, -6.44171536e-01f, 6.25607073e-01f, 2.48628795e-01f, 7.40310431e-01f, -4.46045101e-01f, 1.28142938e-01f, 2.62354672e-01f,
  -4.02176678e-01f, 3.48802179e-01f, 3.55198532e-01f, -1.02159441e+00f, -1.44486073e-02f, -7.42516041e-01f, 3.41213793e-01f, -2.80097306e-01f, -6.97440803e-01f, -6.75422788e-01f,
  -4.97625202e-01f, -4.06809986e-01f, -3.05346876e-01f, -8.62022564e-02f, 8.01456571e-01f, -1.90102562e-01f, -2.57226050e-01f, -3.33728373e-01f, -6.68984294e-01f, 6.24940336e-01f,
  5.93024850e-01f, 1.66510731e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.45678474e-02f, 7.36300871e-02f, 3.72015238e-01f, -1.05760045e-01f, 1.02701284e-01f, -1.68472439e-01f, 2.53039926e-01f, -2.07440838e-01f, -3.66829902e-01f, 6.84956908e-02f,
  -1.73856527e-01f, 1.03847824e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    