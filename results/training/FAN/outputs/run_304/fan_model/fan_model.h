/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.00983893e-02f, 2.53717303e-01f, -1.14640057e-01f, 4.91059087e-02f, -1.85975701e-01f, 7.04488996e-03f, 1.13381660e-02f, 2.63945442e-02f, -9.06781033e-02f, 7.62109533e-02f,
  -6.01043887e-02f, 9.67444927e-02f, -2.26197788e-03f, 1.25368819e-01f, -2.48486437e-02f, 1.36553138e-01f, 2.39992440e-01f, 9.06755701e-02f, -6.16127066e-02f, 5.38140014e-02f,
  8.70869830e-02f, 7.09569827e-02f, 3.32997926e-02f, -6.63208077e-03f, -1.29124271e-02f, 3.32744457e-02f, -2.42759474e-03f, -1.64187536e-01f, 2.47918516e-02f, -3.21196429e-02f,
  1.19887300e-01f, 3.99785787e-02f, 1.45641848e-01f, -1.48232616e-02f, -6.51305076e-03f, -6.93231598e-02f, 5.08053601e-02f, -5.57475202e-02f, 2.36485619e-03f, -4.12902534e-02f,
  -1.42051019e-02f, -6.61773756e-02f, -5.03649302e-02f, -7.95036107e-02f, 5.27760945e-02f, -1.37190633e-02f, -6.71401694e-02f, 3.44322100e-02f, 1.77255068e-02f, -1.93521976e-02f,
  3.59847695e-02f, 7.42455944e-02f, 5.62384911e-02f, -7.89582729e-03f, 6.21090867e-02f, -4.80091684e-02f, -4.57454249e-02f, 4.70429985e-03f, -5.55167301e-03f, -1.32286400e-02f,
  -1.98160065e-03f, 4.28753980e-02f, -2.07341854e-02f, 2.95468178e-02f, 1.69167686e-02f, -1.77302305e-02f, 1.84081309e-02f, 4.95013632e-02f, -4.02569212e-03f, 5.33282682e-02f,
  4.92816344e-02f, -2.87064277e-02f, 6.54692799e-02f, 3.53068300e-02f, 4.36371788e-02f, 5.03512323e-02f, 2.95194015e-02f, -2.02505626e-02f, 5.65895587e-02f, 6.42898530e-02f,
  4.46599126e-02f, -7.73484213e-03f, -2.71653812e-02f, -2.13458389e-02f, 5.99598512e-02f, -2.81465724e-02f, 1.00998878e-02f, -5.43200299e-02f, 5.81764709e-03f, -5.70225678e-02f,
  2.49146864e-01f, 1.68160617e-01f, 8.58002603e-02f, 3.83491553e-02f, 2.80664898e-02f, 9.30087715e-02f, -5.09662461e-03f, 2.94469316e-02f, 8.23217332e-02f, -5.69177493e-02f,
  7.11039733e-03f, 4.47006617e-03f, -2.39279289e-02f, 6.52081845e-03f, 3.71799134e-02f, 4.29904880e-03f, 6.41725212e-02f, 4.99091260e-02f, 1.70942079e-02f, 1.33254239e-02f,
  1.20401392e-02f, -6.34636357e-02f, 4.97170351e-03f, 1.52902650e-02f, -2.16235481e-02f, -3.18171866e-02f, 4.07361016e-02f, 5.11308461e-02f, -4.57540667e-03f, 3.00941560e-02f,
  1.82034716e-01f, -1.97398692e-01f, 1.44758105e-01f, -5.57946339e-02f, 9.94796157e-02f, 8.92461911e-02f, 6.07346147e-02f, -7.21543431e-02f, -1.07301153e-01f, -2.80302018e-01f,
  -1.90551117e-01f, 4.50747050e-02f, -1.63054258e-01f, -1.56682998e-01f, 2.49256760e-01f, -9.03679654e-02f, 2.14085933e-02f, -3.32206748e-02f, -6.94728864e-04f, 6.01835698e-02f,
  1.39051557e-01f, -1.96853191e-01f, 1.50790855e-01f, 3.17987576e-02f, 1.74978405e-01f, 1.11042328e-01f, -5.82385026e-02f, 4.49899845e-02f, -5.04002795e-02f, 7.97524825e-02f,
  1.29552707e-02f, -1.23517573e-01f, -3.85728963e-02f, 3.28588374e-02f, 9.16618928e-02f, 7.10362792e-02f, 2.04142574e-02f, 5.53326346e-02f, 5.53744249e-02f, 3.02465204e-02f,
  6.55100867e-02f, 5.60457967e-02f, -5.58079258e-02f, -3.04567683e-02f, 6.30566254e-02f, -2.49917153e-02f, 9.24006328e-02f, 9.47700627e-03f, 6.35922654e-03f, 8.36478844e-02f,
  4.98265810e-02f, 5.35537489e-02f, 3.29596177e-02f, 5.44020608e-02f, 1.30835518e-01f, 2.81444304e-02f, -1.97243858e-02f, 5.82300611e-02f, -4.03163098e-02f, -5.41375615e-02f,
  -1.15904771e-02f, -2.75740419e-02f, 2.64532864e-02f, -6.03810623e-02f, -7.95647278e-02f, 2.00802609e-02f, -6.99602813e-02f, 3.16595612e-03f, 1.90109722e-02f, 3.17994133e-03f,
  -2.53025722e-02f, 1.65695287e-02f, -2.42810957e-02f, -4.53213975e-03f, 3.61896418e-02f, -3.26853469e-02f, 1.59683824e-02f, -6.98515475e-02f, 4.88513783e-02f, -1.67899635e-02f,
  -3.69045436e-02f, -2.46506874e-02f, -4.12071645e-02f, -4.14211489e-02f, -3.14156376e-02f, 3.51978056e-02f, 9.26443096e-03f, -3.41593362e-02f, 4.72967327e-02f, 5.46175018e-02f,
  -1.13947161e-01f, -2.61032313e-01f, -7.27482364e-02f, 1.73973441e-02f, -5.59790879e-02f, -3.77472839e-03f, 9.07859672e-03f, 1.48508942e-03f, -4.72129919e-02f, -1.07530842e-03f,
  -2.33166423e-02f, 1.70491021e-02f, 3.89701501e-02f, -8.41853675e-03f, 2.24523228e-02f, -1.23303058e-02f, -4.76314202e-02f, -3.36032733e-02f, 3.16546559e-02f, 3.76155898e-02f,
  -2.75266822e-02f, 1.95363518e-02f, 6.54503098e-03f, -1.77416985e-03f, -2.85975114e-02f, -9.35855694e-03f, -5.77710336e-03f, -2.09464580e-02f, -1.46816112e-03f, -1.25169789e-03f,
  8.48097503e-02f, 3.38063948e-02f, 1.32960796e-01f, 1.83597192e-01f, -9.89328101e-02f, 2.56733242e-02f, 6.91322982e-02f, 4.37562428e-02f, 1.53349429e-01f, 4.49016578e-02f,
  7.87516998e-04f, 6.73723361e-03f, 8.09297189e-02f, 2.35183567e-01f, 9.17978212e-02f, 1.68698296e-01f, 1.46175265e-01f, 2.19491031e-02f, 5.91213144e-02f, 5.24512157e-02f,
  -9.50864330e-03f, 1.41653702e-01f, 8.11050907e-02f, -2.66450960e-02f, 7.07385615e-02f, -4.75482941e-02f, -4.79239784e-02f, -8.82959291e-02f, -5.09248823e-02f, -7.06323907e-02f,
  -4.91940267e-02f, 1.21105768e-01f, 4.12761383e-02f, -1.33426432e-02f, 7.94069767e-02f, -1.47428727e-02f, 5.16595878e-03f, -1.22444602e-02f, 1.85966697e-02f, 4.06057313e-02f,
  -7.36984238e-02f, -1.60969198e-02f, 1.05295472e-01f, 1.43644465e-02f, 2.87037827e-02f, 1.14555275e-02f, 3.94417457e-02f, -7.41299838e-02f, 7.02360347e-02f, 1.76952165e-02f,
  7.55511746e-02f, 4.59745340e-02f, 4.41063680e-02f, 1.58852283e-02f, -2.90562790e-02f, -3.74349989e-02f, 4.21500728e-02f, -3.32711940e-03f, 1.15838954e-02f, 5.08870650e-03f,
  -4.61823270e-02f, -5.05746119e-02f, 2.76002884e-02f, -3.01022604e-02f, -2.64417697e-02f, 1.65791821e-03f, -8.65429174e-03f, -4.96128015e-02f, 2.66232342e-02f, -3.79099287e-02f,
  -5.62254749e-02f, 2.36149039e-02f, -5.60313910e-02f, -2.10468862e-02f, 3.06494031e-02f, -3.34503278e-02f, -4.51887958e-02f, -2.80101467e-02f, 5.23971766e-02f, -2.16241907e-02f,
  -1.25613892e-02f, -2.93744821e-03f, -2.35586166e-02f, 2.67496351e-02f, 1.16913849e-02f, -1.57595798e-02f, -2.03188509e-02f, 1.28128286e-02f, 2.51018144e-02f, -2.21680384e-02f,
  4.99921553e-02f, -8.15460645e-03f, 5.14579378e-02f, -3.68992612e-03f, -7.31933936e-02f, -5.85156046e-02f, 3.69084477e-02f, 2.22696736e-02f, 9.51690320e-03f, 1.67326760e-02f,
  -5.99618349e-03f, 4.57994454e-02f, -8.89751166e-02f, -3.07488814e-02f, -1.08663542e-02f, 2.88771223e-02f, 2.69474480e-02f, 3.21860984e-02f, -6.04896769e-02f, -4.99300584e-02f,
  3.86423897e-04f, -4.12213355e-02f, 3.00008152e-02f, -2.38715820e-02f, -5.68105541e-02f, 5.19871153e-02f, 1.72225833e-02f, -3.64476554e-02f, -7.43371099e-02f, -1.59502833e-03f,
  1.22882992e-01f, -5.16436279e-01f, 1.38676045e-02f, -2.75581390e-01f, 7.43797049e-02f, -3.61900814e-02f, -4.22041826e-02f, -4.94441800e-02f, -1.02990717e-01f, -2.64051855e-01f,
  9.22467443e-04f, -1.55606106e-01f, -1.02519728e-01f, -2.84004271e-01f, 1.75760388e-01f, -4.39868383e-02f, -1.10158183e-01f, -1.51651606e-01f, -1.15163801e-02f, -1.65424794e-01f,
  3.83390114e-02f, -1.68142989e-01f, 3.97796109e-02f, -7.44794542e-03f, -5.60367294e-02f, 8.18164423e-02f, 6.19972721e-02f, 1.68920472e-01f, -5.26686870e-02f, 7.43803754e-02f,
  -3.07498872e-02f, -1.14816099e-01f, 1.35510624e-03f, 3.51021960e-02f, -1.35917729e-02f, -2.47883517e-02f, 3.27239893e-02f, 3.18342037e-02f, 6.40319213e-02f, 1.27580883e-02f,
  -7.52562657e-02f, -3.16249616e-02f, 1.87027976e-02f, -1.39708016e-02f, 1.72881298e-02f, 2.71923188e-02f, 2.66402587e-02f, -1.17214741e-02f, -3.18439603e-02f, -4.84885555e-03f,
  -4.14033420e-02f, -2.11037509e-02f, -4.60636988e-02f, -2.03623567e-02f, 1.77427139e-02f, -4.12048362e-02f, -9.30742174e-02f, 3.73636372e-02f, -3.07154134e-02f, -7.09501430e-02f,
  -1.12619800e-02f, 8.51002987e-03f, 2.54171959e-04f, 5.19715026e-02f, -1.15299951e-02f, -1.00901537e-02f, -1.84958503e-02f, 3.30152288e-02f, 8.68817605e-03f, -6.03148639e-02f,
  -4.88576433e-03f, -3.61757725e-02f, 2.69958889e-03f, -4.11783665e-04f, -1.38496317e-03f, -8.55026990e-02f, 7.17310086e-02f, 6.60585565e-03f, 5.39330989e-02f, 4.69341725e-02f,
  -2.36479770e-02f, -1.15606170e-02f, 7.48270657e-03f, 5.06457277e-02f, -1.08488686e-02f, 3.00284438e-02f, -1.23340068e-02f, -4.77410853e-02f, -2.12856922e-02f, 2.38252133e-02f,
  -9.79872048e-02f, -1.60633236e-01f, 2.31399760e-02f, 2.78506689e-02f, -8.21728539e-03f, 8.35572258e-02f, -4.30212356e-02f, 1.95357613e-02f, 7.46953720e-03f, -1.55351683e-02f,
  1.68477353e-02f, -9.05277394e-03f, -1.48173748e-02f, 1.36324745e-02f, 1.16868047e-02f, -1.39444582e-02f, -3.01005207e-02f, 3.71587859e-03f, 1.44475251e-02f, -1.99349243e-02f,
  8.56616534e-03f, 9.46595613e-03f, 5.66833578e-02f, 1.73571967e-02f, 2.02043774e-03f, 1.43613284e-02f, -1.97508801e-02f, -1.48031693e-02f, 4.69363667e-02f, 1.97503418e-02f,
  -1.28110573e-01f, 3.30233663e-01f, 2.35515699e-01f, -6.43118694e-02f, -3.10410976e-01f, 4.82664071e-02f, 9.62128118e-03f, -5.35338782e-02f, 1.70882806e-01f, 1.62826508e-01f,
  -2.14428917e-01f, 1.13490619e-01f, -1.28561119e-02f, -9.91464686e-03f, -2.32275520e-02f, 1.31198466e-01f, -8.14512745e-02f, 4.97044325e-02f, 3.17514166e-02f, -8.74542296e-02f,
  -4.56072837e-02f, -2.20110014e-01f, -3.56678516e-02f, -1.97218657e-02f, -1.77052796e-01f, -2.80344523e-02f, -1.29443020e-01f, 2.89175734e-02f, -8.73334855e-02f, 6.84506223e-02f,
  -1.53345406e-01f, 7.07385247e-04f, 1.27712800e-03f, 3.59068997e-02f, -9.19626877e-02f, -5.57750799e-02f, -3.43518239e-03f, -1.69229489e-02f, -1.62411612e-02f, 2.37128679e-02f,
  3.94361950e-02f, -6.34579659e-02f, 8.42566192e-02f, 6.49642795e-02f, -1.54490210e-02f, 3.82195376e-02f, -3.28829102e-02f, -1.19003626e-02f, 3.02089527e-02f, -1.55166844e-02f,
  3.48623358e-02f, -2.59683095e-03f, -1.59523003e-02f, 3.77133526e-02f, 1.04978671e-02f, -2.14055050e-02f, 5.75468317e-02f, -7.17871413e-02f, 7.40502477e-02f, -4.74970117e-02f,
  -8.61868076e-03f, 2.64087506e-02f, -3.98567244e-02f, 1.72250811e-02f, -2.55344389e-03f, -4.43580821e-02f, 4.10044566e-02f, 3.95303592e-03f, 2.31943489e-03f, 1.42878303e-02f,
  -6.10365011e-02f, -1.09532094e-02f, 2.95310430e-02f, 1.35283656e-02f, -4.29372117e-02f, 4.81338724e-02f, -4.23157997e-02f, -1.45605495e-02f, -5.83047345e-02f, -5.24635380e-03f,
  7.12402314e-02f, 4.44972962e-02f, -4.81302571e-03f, -6.86617643e-02f, 6.33435026e-02f, 2.85348818e-02f, 2.20925435e-02f, 2.81889960e-02f, -1.93638187e-02f, 1.38211977e-02f,
  -5.44481911e-02f, 1.50253503e-02f, -6.84514046e-02f, -4.53862809e-02f, 3.83941196e-02f, 2.63377698e-03f, 7.17119128e-02f, 1.57750975e-02f, 4.29529324e-02f, 1.95547156e-02f,
  -6.74761459e-02f, 1.66400205e-02f, -2.20466461e-02f, -1.70391519e-02f, 2.52436977e-02f, -3.58955339e-02f, 7.07772654e-03f, 2.90366379e-03f, -5.96389100e-02f, -5.45030385e-02f,
  -4.72204238e-02f, -4.14846539e-02f, 3.20097059e-02f, -1.01145320e-01f, -2.70530749e-02f, 1.78866815e-02f, -8.33289325e-02f, 5.14807329e-02f, -6.77796602e-02f, 2.53473558e-02f,
  6.94894567e-02f, -2.11569980e-01f, -1.65234149e-01f, 4.66419905e-02f, -7.78077776e-03f, 2.43719593e-01f, 1.33719355e-01f, -8.95248279e-02f, -3.44749168e-02f, -1.53103933e-01f,
  3.07366885e-02f, -4.31642216e-03f, -1.14997655e-01f, 2.26689838e-02f, 1.52939409e-01f, -9.58730876e-02f, 5.83798476e-02f, -4.85432297e-02f, -6.13166280e-02f, -4.67423908e-02f,
  2.17873808e-02f, 8.71732980e-02f, -2.28777658e-02f, -1.10900979e-02f, -6.31822646e-02f, -3.90736312e-02f, -4.26317975e-02f, -2.54169516e-02f, 1.78247280e-02f, -1.17229000e-02f,
  7.34624788e-02f, -1.53888958e-02f, -3.25275958e-02f, -8.83727670e-02f, 5.63653484e-02f, -1.82654131e-02f, 7.70531744e-02f, -3.65848243e-02f, 7.03991428e-02f, -4.22364771e-02f,
  -6.74223304e-02f, -3.89233157e-02f, 3.48879360e-02f, -6.77068606e-02f, -5.41684702e-02f, 4.15313616e-03f, -5.91858849e-02f, 6.95881322e-02f, 2.61740685e-02f, -5.35958037e-02f,
  -1.05418498e-02f, -8.04880783e-02f, 2.09145676e-02f, 5.21061756e-02f, 2.00519506e-02f, -2.42575742e-02f, 7.63203353e-02f, -3.85579281e-02f, 6.73221201e-02f, 6.55940473e-02f,
  1.45273302e-02f, 1.11645468e-01f, -3.78034078e-02f, 9.99344699e-03f, 2.12536007e-02f, 3.43267769e-02f, 4.78700399e-02f, 3.69228944e-02f, 3.56551707e-02f, 1.10144122e-02f,
  7.59985372e-02f, -3.13057862e-02f, -8.28926712e-02f, 5.20980209e-02f, 4.40712757e-02f, -1.83347166e-02f, 2.27294341e-02f, -4.74825948e-02f, 3.77777740e-02f, 4.73364163e-03f,
  2.40549240e-02f, -4.82836030e-02f, 2.77373064e-02f, -1.48569876e-02f, 4.12938111e-02f, 5.42701513e-04f, -7.91367292e-02f, -7.17353402e-03f, 2.41796598e-02f, 8.06619450e-02f,
  5.59053011e-02f, -2.72764843e-02f, 6.70918450e-02f, -5.06134219e-02f, 5.67306727e-02f, 7.17066880e-03f, -1.72079019e-02f, -5.04532121e-02f, -4.89145145e-03f, 1.06259827e-02f,
  -4.17787954e-02f, 1.27617083e-02f, 6.75746873e-02f, -3.33645716e-02f, 9.65244174e-02f, -6.41723946e-02f, 6.52639940e-02f, -9.69477557e-03f, 6.59463182e-02f, 1.26872510e-02f,
  -1.44175871e-03f, 6.34373054e-02f, 2.96432488e-02f, 4.59310189e-02f, 3.94189265e-03f, 3.82018574e-02f, 4.86497581e-02f, -4.24219072e-02f, 2.67631188e-02f, 8.05175491e-03f,
  1.81763421e-03f, 2.49309298e-02f, -3.09488326e-01f, -5.67411408e-02f, 1.64404392e-01f, -5.00030592e-02f, -1.06328391e-01f, 5.74922860e-02f, -1.47468626e-01f, 1.16351791e-01f,
  1.44489378e-01f, -1.84968799e-01f, -7.22569525e-02f, -2.57784803e-03f, -2.06530094e-01f, -1.60666719e-01f, 9.92145203e-03f, -2.52088532e-03f, -9.03887749e-02f, 1.03900820e-01f,
  -1.41278684e-01f, 2.63965964e-01f, -1.51243344e-01f, 1.83349863e-01f, 1.11784495e-01f, -8.58835280e-02f, 2.39079267e-01f, -4.38803341e-03f, 1.83464900e-01f, 1.75325722e-02f,
  4.37727943e-02f, -4.07032780e-02f, -3.90601493e-02f, -9.14408788e-02f, 3.67558189e-02f, 2.22532805e-02f, -2.45047989e-03f, -8.53015557e-02f, 4.20247437e-03f, 2.74303202e-02f,
  -6.99126124e-02f, 7.02033425e-03f, 2.31484585e-02f, -4.73857187e-02f, -3.33003327e-02f, -3.56866121e-02f, -1.98846851e-02f, -2.38242256e-03f, -4.64750342e-02f, -5.50497808e-02f,
  -1.15591198e-01f, -3.69374938e-02f, -7.28956908e-02f, -1.87755469e-02f, -2.99440529e-02f, -4.16096188e-02f, -7.96793960e-03f, -4.12249416e-02f, 1.54126817e-02f, -3.19708027e-02f,
  -8.20714906e-02f, -3.21311504e-02f, 3.33936303e-04f, 2.67389987e-04f, -7.13745924e-03f, 4.03417386e-02f, -4.32339823e-03f, 1.48125971e-02f, 1.19238896e-02f, 3.42724919e-02f,
  2.21857000e-02f, -1.52564906e-02f, 4.97016460e-02f, -3.74916792e-02f, 3.79436240e-02f, 1.98975094e-02f, -5.52577563e-02f, 9.52514708e-02f, 4.87496667e-02f, -3.04592960e-02f,
  -4.25535329e-02f, 5.96138574e-02f, 6.30607642e-03f, 4.94226404e-02f, -8.51151627e-03f, -2.88840029e-02f, 6.88384548e-02f, -6.79760501e-02f, -4.21897732e-02f, 3.00311688e-02f,
  2.68986881e-01f, 1.10910222e-01f, 2.70042699e-02f, 5.71828149e-02f, 1.37494560e-02f, -2.12788768e-02f, -5.27453981e-02f, 1.66770108e-02f, -2.04333533e-02f, -1.03782564e-02f,
  4.50136550e-02f, 2.06862250e-03f, 3.29809892e-03f, 4.66677137e-02f, -2.58175004e-02f, 3.43862884e-02f, 3.27725671e-02f, 2.73365565e-02f, 6.25475049e-02f, 1.47261377e-02f,
  4.39216867e-02f, 2.01402139e-02f, -1.77410301e-02f, 1.70483477e-02f, 3.15259770e-02f, 6.48404192e-03f, -2.36466099e-02f, -7.71198943e-02f, -5.30401897e-03f, -2.40323357e-02f,
  -3.17610770e-01f, 3.08280170e-01f, 4.50809188e-02f, 5.46946451e-02f, -1.16817489e-01f, 2.97781508e-02f, 6.45177737e-02f, 1.11359552e-01f, 6.26120791e-02f, 1.05313249e-01f,
  6.56043068e-02f, -1.65949211e-01f, 9.29871425e-02f, 1.45538628e-01f, -5.88025860e-02f, 2.50245214e-01f, 7.17743188e-02f, -3.68195660e-02f, 5.58735691e-02f, -1.30527709e-02f,
  8.72533098e-02f, 1.00891083e-01f, 2.13766471e-01f, 1.42844602e-01f, 4.31507081e-02f, 6.46231184e-03f, -6.89266156e-03f, -2.39942819e-02f, -1.72289927e-02f, -3.41020189e-02f,
  -1.34739920e-01f, 6.65437356e-02f, -8.13355967e-02f, -8.48716125e-02f, -1.21676639e-01f, -1.03091411e-01f, -2.91545875e-02f, 1.18742324e-03f, 1.54649261e-02f, 2.18473375e-02f,
  4.31392007e-02f, 1.37346881e-02f, -3.82114737e-03f, 3.64229344e-02f, 1.38091063e-03f, 4.55212332e-02f, 6.48013130e-02f, 1.09911606e-01f, -1.35005796e-02f, 6.64622188e-02f,
  5.18172570e-02f, -6.62908703e-03f, -3.73427523e-04f, 7.30021223e-02f, 1.74729936e-02f, -3.31186354e-02f, -3.68924178e-02f, -1.99775342e-02f, -3.62834185e-02f, -3.97919230e-02f,
  8.21301043e-02f, -2.91991550e-02f, 5.19808494e-02f, -7.80336782e-02f, 4.46579680e-02f, 3.69626209e-02f, -3.78751047e-02f, 1.74460828e-03f, -2.31153853e-02f, 2.64585279e-02f,
  -3.07307243e-02f, -7.81801268e-02f, 5.59243672e-02f, 8.85469653e-03f, 1.38505502e-02f, 3.21158953e-02f, -3.91992778e-02f, -1.33474423e-02f, 1.60032846e-02f, 3.33520025e-02f,
  -3.21217664e-02f, -3.11334431e-02f, 3.70259658e-02f, 1.38707142e-02f, -2.72244494e-02f, -2.67272592e-02f, 2.25276947e-02f, 7.69551918e-02f, 1.64633244e-02f, 4.06503910e-03f,
  -1.30297795e-01f, -4.50690649e-02f, 1.14117280e-01f, 4.12099585e-02f, 3.87725830e-02f, 2.29041837e-02f, -1.82348136e-02f, -2.94147208e-02f, -1.04655046e-02f, -1.58550814e-02f,
  -9.92294028e-02f, -4.42257933e-02f, -6.92383647e-02f, -2.94704270e-02f, 1.40704354e-02f, 6.45309165e-02f, -3.86278182e-02f, -1.03349030e-01f, 1.58983581e-02f, 5.30554308e-03f,
  -3.73298451e-02f, 1.72175225e-02f, 4.82290238e-02f, -3.03432606e-02f, -7.74028758e-03f, -1.15456749e-02f, -2.69708056e-02f, 3.15676816e-02f, -6.01410260e-03f, 2.44091861e-02f,
  -2.30253816e-01f, 4.53306176e-02f, -6.07904941e-02f, 3.75373811e-02f, 8.45115110e-02f, 2.51067072e-01f, 3.15944344e-01f, 8.73665363e-02f, 6.19898997e-02f, 1.57347664e-01f,
  8.72843266e-02f, -1.46433935e-01f, 1.14328936e-01f, 8.83591697e-02f, -2.94703282e-02f, 2.62094378e-01f, -1.17026214e-02f, -6.72227591e-02f, 6.66774716e-03f, -1.24238487e-02f,
  1.79636125e-02f, 1.05048474e-02f, 2.84186434e-02f, -4.46917787e-02f, -3.67178209e-02f, -1.44342884e-01f, -1.39407530e-01f, 7.00167716e-02f, -1.91626489e-01f, 4.00585793e-02f,
  -3.88203524e-02f, -1.82668254e-01f, -9.22065601e-02f, -1.41706973e-01f, -1.47231817e-01f, -7.24480897e-02f, -4.83089834e-02f, 1.65798701e-02f, -3.48779447e-02f, -9.63335410e-02f,
  1.61809921e-02f, -8.55416954e-02f, -2.39037015e-02f, 5.57633974e-02f, 1.48435142e-02f, -3.54092233e-02f, 1.13852769e-02f, 2.10352838e-02f, 3.47963013e-02f, -2.65199784e-02f,
  -2.10577417e-02f, -6.72389865e-02f, -4.67097089e-02f, -4.73906361e-02f, 3.55586223e-02f, 5.40218726e-02f, -2.53495239e-02f, 5.89663573e-02f, -1.94253512e-02f, -1.10490117e-02f,
  3.49806133e-03f, 5.21411635e-02f, 1.98193006e-02f, 3.04495916e-02f, -5.11606522e-02f, -1.00333756e-02f, -2.39416230e-02f, -7.31397420e-02f, -5.71872815e-02f, 6.80931658e-02f,
  -2.08831802e-02f, -1.49845786e-03f, -6.90261945e-02f, 2.07329206e-02f, -4.98426184e-02f, -4.26181033e-02f, -5.93350567e-02f, 9.43762064e-03f, -1.59940626e-02f, -1.41195767e-02f,
  7.43392557e-02f, -3.68547514e-02f, 7.45239779e-02f, -3.07872780e-02f, 3.25719640e-02f, 5.00516668e-02f, -5.49552590e-02f, 2.64647584e-02f, 2.17851456e-02f, 3.77211012e-02f,
  -4.21404801e-02f, -2.04580903e-01f, 6.68996871e-02f, -1.03372119e-01f, 2.30976380e-02f, 3.55008096e-02f, 2.72650365e-02f, 7.67548904e-02f, 7.41589367e-02f, 2.29502507e-02f,
  -5.34175634e-02f, 1.90352965e-02f, -6.27393723e-02f, 4.73700128e-02f, 7.11169094e-02f, 5.51299863e-02f, 2.48477999e-02f, -5.13578914e-02f, -2.27071531e-02f, -5.69390915e-02f,
  -3.39037590e-02f, -3.84924933e-02f, 1.79279002e-03f, 5.69180101e-02f, -5.33747934e-02f, -3.60919274e-02f, -3.87937389e-02f, 1.21747330e-02f, 7.46330200e-03f, -5.64683937e-02f,
  3.76953185e-03f, 1.75851092e-01f, 4.27250154e-02f, 6.32123500e-02f, 9.99966562e-02f, 1.24143928e-01f, -8.36793780e-02f, 2.35869065e-01f, -1.04911767e-01f, 1.23274095e-01f,
  -1.20316334e-02f, -1.53918639e-01f, -1.47516966e-01f, 1.49620846e-01f, -2.48712480e-01f, -1.72711641e-01f, 1.74695656e-01f, 3.20882425e-02f, 1.61772259e-02f, 1.02692083e-01f,
  7.76818469e-02f, 6.73457161e-02f, 2.93507315e-02f, 2.60916561e-01f, 5.26799187e-02f, 1.11858606e-01f, -3.71269546e-02f, -8.21330324e-02f, 2.29125991e-01f, -8.44076574e-02f,
  -5.01359254e-03f, -6.20843172e-02f, 7.04146177e-02f, 4.72009741e-02f, 6.17308766e-02f, 4.65798788e-02f, -4.46648896e-02f, -9.55598801e-03f, -2.15746686e-02f, 1.09149739e-02f,
  -5.69606423e-02f, -3.73295285e-02f, 5.83031625e-02f, 9.42394324e-03f, 5.98193444e-02f, 4.01917659e-02f, 3.79793122e-02f, 4.34368066e-02f, 6.38988540e-02f, 1.33832935e-02f,
  -9.27858893e-03f, -1.90821979e-02f, 4.06479463e-02f, -3.39251608e-02f, -2.83442792e-02f, -1.61265619e-02f, 2.40554214e-02f, 6.22057263e-03f, -3.54114883e-02f, 1.08005285e-01f,
  8.76859650e-02f, 4.35781293e-02f, -4.20313776e-02f, 3.98424156e-02f, -2.06063930e-02f, 6.95093423e-02f, 3.98684107e-02f, -6.86929747e-02f, -5.71986567e-03f, 7.07883611e-02f,
  1.00449538e-02f, 7.66739389e-03f, -4.63604322e-03f, 1.35770729e-02f, 4.48238067e-02f, -2.95708738e-02f, -7.95823410e-02f, 1.42962132e-02f, 1.66775137e-02f, 2.55685803e-02f,
  -9.64158622e-04f, -4.63639051e-02f, 4.39624153e-02f, -5.66256642e-02f, -5.69308810e-02f, -3.35676149e-02f, -1.77632011e-02f, 6.28688931e-03f, -5.33972494e-02f, 4.25820425e-03f,
  5.87379672e-02f, 3.28006037e-03f, 2.86975522e-02f, -7.75480829e-03f, -2.51439735e-02f, -5.09834141e-02f, 2.48023793e-02f, -2.84676924e-02f, -5.92961758e-02f, 2.04826184e-02f,
  3.17195281e-02f, 3.39533761e-03f, -3.51875275e-02f, -4.57676649e-02f, -2.98777483e-02f, 2.36421898e-02f, -1.05318666e-01f, -3.36692184e-02f, -3.18679363e-02f, 8.87769610e-02f,
  7.43503496e-02f, 3.94072942e-03f, -5.41253686e-02f, 3.47362123e-02f, 1.99911725e-02f, -2.30257735e-02f, 4.19282466e-02f, -2.55000107e-02f, -3.16107534e-02f, -6.38342649e-02f,
  3.85571688e-01f, -1.35892674e-01f, -2.39838064e-01f, 5.84447337e-03f, 9.99616981e-02f, 2.70304441e-01f, 2.58539647e-01f, -3.36290486e-02f, 1.15224071e-01f, -9.00968909e-03f,
  6.43334165e-03f, -1.02469325e-01f, -1.25923082e-01f, 8.18395838e-02f, 2.45974898e-01f, 4.56915237e-03f, 1.63639560e-01f, 6.88709021e-02f, 1.69477717e-03f, 5.51301762e-02f,
  -1.33586973e-02f, 7.84399956e-02f, -9.22425911e-02f, -8.75633955e-02f, -7.08110183e-02f, -1.52116358e-01f, -7.39616081e-02f, -1.52792975e-01f, -1.27268583e-01f, 3.18872631e-02f,
  -1.82761028e-02f, 4.37529897e-03f, -8.06193501e-02f, 1.77323520e-02f, 4.81241420e-02f, 4.47635613e-02f, -9.65951942e-03f, -3.42746079e-02f, -1.92512572e-02f, 1.59151983e-02f,
  -2.03126185e-02f, 3.03686298e-02f, -1.12553388e-02f, 1.17417304e-02f, 3.80423442e-02f, -9.97505337e-02f, -1.89508740e-02f, -6.42625093e-02f, -4.21627387e-02f, -1.32291177e-02f,
  -7.82733560e-02f, -4.80954796e-02f, 4.48535895e-03f, 3.85969784e-03f, -2.09400374e-02f, 4.02263477e-02f, 4.14652079e-02f, -4.03607488e-02f, 2.92179976e-02f, 1.12025514e-01f,
  1.11647695e-01f, -1.39828483e-02f, -5.85670695e-02f, -9.40881819e-02f, 3.13312188e-02f, -1.00835152e-02f, 7.72479251e-02f, 1.09227765e-02f, -4.67635430e-02f, 2.53865942e-02f,
  8.33833823e-04f, 9.30361729e-03f, -3.80264199e-03f, 3.59574221e-02f, -1.32339704e-03f, 6.46307543e-02f, -3.57323401e-02f, 1.10743176e-05f, 2.03009173e-02f, 1.81711074e-02f,
  -4.99866530e-02f, 4.31020185e-02f, -3.78256738e-02f, 1.99956307e-03f, 1.72617957e-02f, -4.89093997e-02f, 7.02779694e-03f, -3.99275795e-02f, -2.93200258e-02f, 2.46761814e-02f,
  6.04312830e-02f, 1.45124318e-02f, -2.73197535e-02f, -2.39198767e-02f, -1.44746285e-02f, 1.05509823e-02f, 3.77635844e-03f, -2.84668859e-02f, 6.61437213e-02f, 7.24204928e-02f,
  -2.81393323e-02f, 7.59051414e-03f, 6.37709163e-03f, 2.20097285e-02f, -2.51356009e-02f, 4.52562608e-02f, -6.84934668e-03f, 6.02759197e-02f, 5.36868386e-02f, -7.86973760e-02f,
  2.08933279e-02f, -2.68619927e-03f, 2.15001665e-02f, -3.13501358e-02f, 5.94876893e-02f, 3.13926414e-02f, 7.77708963e-02f, 5.19285984e-02f, 4.20336649e-02f, -9.51945260e-02f,
  3.61505412e-02f, -1.97962880e-01f, -9.43607315e-02f, 2.04275876e-01f, 1.06683932e-01f, -1.46275923e-01f, -1.29764631e-01f, 4.05207947e-02f, -6.66296333e-02f, -1.36500280e-02f,
  1.81055382e-01f, -2.73914725e-01f, -8.64545032e-02f, 3.18991542e-01f, 4.19039950e-02f, 2.70437915e-02f, 2.75923669e-01f, 2.89488174e-02f, -1.32627070e-01f, 4.88147400e-02f,
  7.85604939e-02f, 2.71861076e-01f, 8.39546248e-02f, 1.44582778e-01f, -4.19802181e-02f, -3.16474102e-02f, 1.97327197e-01f, -8.97963494e-02f, 8.58777910e-02f, -3.31907012e-02f,
  7.07885697e-02f, 1.70800984e-02f, -5.98745830e-02f, -6.44094646e-02f, -5.26675358e-02f, -2.17309929e-02f, -4.16726731e-02f, -5.31084351e-02f, -6.61909729e-02f, -2.35378253e-03f,
  -1.57753229e-02f, -2.34130882e-02f, 3.75097878e-02f, 1.36498259e-02f, 1.18055660e-02f, -1.96781773e-02f, 6.14535920e-02f, 1.38729047e-02f, -4.83943559e-02f, 1.49470223e-02f,
  -3.76415215e-02f, 2.68236827e-02f, 4.55636159e-02f, 1.90882571e-02f, 5.31336777e-02f, -4.27230932e-02f, 1.66989285e-02f, -7.03069270e-02f, -1.13774585e-02f, -7.85653219e-02f,
  -3.27648260e-02f, -3.36730964e-02f, -1.05852429e-02f, 8.28330368e-02f, 9.59643454e-04f, -1.57550760e-02f, 4.60807122e-02f, 4.59808521e-02f, -5.33258691e-02f, -3.14557813e-02f,
  -3.90044823e-02f, 4.03390080e-02f, 1.62270479e-02f, 8.80632550e-02f, -3.45612806e-03f, -5.60683152e-03f, -5.29909246e-02f, 5.74226007e-02f, -6.27281144e-03f, 4.43727151e-02f,
  1.46713331e-02f, -5.28933518e-02f, 1.94390379e-02f, 6.54327050e-02f, 3.53638418e-02f, 1.80406291e-02f, 7.18995258e-02f, -5.78655824e-02f, -6.15939572e-02f, -1.96243580e-02f,
  -1.00099659e-02f, 6.07542470e-02f, -2.65358724e-02f, 2.88414080e-02f, 3.21377590e-02f, 3.65311429e-02f, -1.42117068e-02f, 2.37059761e-02f, 1.12188421e-02f, -5.10224663e-02f,
  5.05708763e-03f, 8.51831362e-02f, 2.46430817e-03f, -3.72418575e-02f, 8.03363323e-03f, -2.99952719e-02f, -4.72772941e-02f, -2.28801053e-02f, 6.40756190e-02f, -2.66510323e-02f,
  5.14613800e-02f, 3.75365876e-02f, 3.80257331e-02f, 1.57307833e-02f, 4.94895838e-02f, 1.69311650e-02f, -3.26328129e-02f, 1.72604015e-03f, 4.45503654e-04f, -2.09993217e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.56935567e-01f, -3.42730433e-01f, 2.09300935e-01f, 3.57714474e-01f, 1.38050765e-01f, 7.12982342e-02f, 2.69120067e-01f, 8.13999996e-02f, 2.67225504e-01f, -2.06970319e-01f,
  -9.01595876e-02f, -1.36557803e-01f, -1.19247086e-01f, -5.45573309e-02f, 1.81846917e-01f, -6.45265356e-02f, -4.36134301e-02f, 2.07216311e-02f, 1.84378624e-02f, 8.86461139e-02f,
  1.21511392e-01f, -3.33953723e-02f, -4.25262302e-02f, -2.09179386e-01f, -5.66245541e-02f, 6.36316882e-03f, -8.28298479e-02f, 2.42892299e-02f, -1.37317747e-01f, -3.74863744e-02f,
  -4.79770377e-02f, 7.03818304e-03f, 6.50372282e-02f, -1.08585395e-01f, -1.01587944e-01f, -8.51359591e-02f, 4.44825739e-02f, 5.82369342e-02f, 5.79223186e-02f, 2.98160799e-02f,
  -4.63943593e-02f, -1.34847527e-02f, 9.54362527e-02f, 2.24551503e-02f, -1.77446548e-02f, -2.90764701e-02f, 3.68890241e-02f, 2.61607915e-02f, -5.78061678e-02f, -2.33212747e-02f,
  -1.98524911e-02f, 5.89831790e-04f, 1.88989248e-02f, -9.05818194e-02f, 9.99290869e-02f, -4.53238599e-02f, -1.84095725e-02f, 7.22617209e-02f, -6.60195500e-02f, 3.19042727e-02f,
  -8.31900612e-02f, -4.81721833e-02f, -1.63981486e-02f, -4.58482467e-02f, -2.89777983e-02f, 8.61747712e-02f, -5.61246835e-03f, 3.54568847e-02f, 5.83637469e-02f, 1.01622589e-01f,
  -2.31344905e-02f, -6.82365298e-02f, 8.16537663e-02f, -1.97825599e-02f, -2.65357085e-02f, 5.51594831e-02f, -2.41935272e-02f, -4.64334302e-02f, 5.62719628e-03f, 1.57138761e-02f,
  4.35279198e-02f, 9.66646243e-03f, -1.16014473e-01f, -4.29811962e-02f, -1.36677530e-02f, 1.46448063e-02f, -4.62876372e-02f, 2.48359460e-02f, 8.11095312e-02f, -3.66223305e-02f,
  -2.26571158e-01f, -2.30949372e-01f, -9.39405262e-02f, 2.97361128e-02f, 2.11806083e-03f, -7.54294097e-02f, -6.09573908e-02f, -3.77999991e-02f, -1.03202783e-01f, -1.16132662e-01f,
  -2.64832545e-02f, 4.63128574e-02f, -5.53431176e-02f, 5.73275425e-02f, -4.67299670e-02f, -9.30761248e-02f, -5.10746688e-02f, -7.91962519e-02f, 3.52871493e-02f, -4.14865389e-02f,
  -5.58062829e-02f, -7.72816315e-02f, 1.20911384e-02f, -7.04840422e-02f, -3.53035927e-02f, -7.13039413e-02f, -7.33145475e-02f, -3.31712291e-02f, -2.28321105e-02f, 2.60184589e-03f,
  -8.72918684e-03f, 1.18514270e-01f, 1.48961514e-01f, 1.27823755e-01f, -7.94559643e-02f, -2.33694822e-01f, -1.49362534e-01f, 1.79604832e-02f, -4.87232208e-02f, 1.24779515e-01f,
  -1.48072809e-01f, 1.57846585e-01f, -9.33911875e-02f, -1.66047812e-02f, -2.97953367e-01f, -2.23630577e-01f, -1.37802675e-01f, -2.64723022e-02f, 3.39336810e-03f, 1.25860661e-01f,
  -8.51604063e-03f, -1.53915495e-01f, -5.89745566e-02f, 2.76407134e-02f, 7.48123676e-02f, 1.98348939e-01f, 8.56789052e-02f, -1.79263152e-05f, 9.45854262e-02f, -2.71488614e-02f,
  -8.50193501e-02f, 1.26786634e-01f, 5.01596183e-02f, 4.26589921e-02f, 3.52739692e-02f, -2.84135658e-02f, 6.95107654e-02f, 6.12391010e-02f, -6.05117343e-02f, 1.88196416e-03f,
  3.89935635e-02f, -5.85165806e-04f, 1.36628719e-02f, -3.98033783e-02f, -2.61195581e-02f, 7.14973286e-02f, -3.43374275e-02f, 6.11224659e-02f, 7.08149225e-02f, 2.27929186e-02f,
  1.24669364e-02f, 3.58831580e-03f, 7.25546405e-02f, 3.04108839e-02f, -4.92326878e-02f, 1.26131037e-02f, -3.19953449e-02f, 9.52895060e-02f, 5.95378652e-02f, 6.24635816e-02f,
  -1.94962844e-02f, -5.45586273e-02f, -3.64631861e-02f, -2.85392329e-02f, -6.80818185e-02f, 5.83576895e-02f, 6.19010851e-02f, -5.91124482e-02f, 6.69368953e-02f, 2.20448840e-02f,
  -3.15318704e-02f, -4.59654927e-02f, -6.20749481e-02f, -9.11442749e-03f, 1.74320079e-02f, 6.13544248e-02f, 1.60880219e-02f, -2.37259194e-02f, 7.06270039e-02f, -4.06108834e-02f,
  1.30984224e-02f, 7.54505396e-04f, 4.54303138e-02f, 7.40017891e-02f, -1.22973092e-01f, 2.55043078e-02f, 2.71534789e-02f, 2.52619982e-02f, -1.52002613e-03f, -5.46029136e-02f,
  -5.12042223e-03f, 8.41227174e-02f, 2.45328527e-03f, -1.20279519e-02f, -6.27498403e-02f, 3.49159278e-02f, -8.11992139e-02f, 5.38996011e-02f, 5.24884388e-02f, -8.58520940e-02f,
  -2.01306976e-02f, 6.05092272e-02f, 6.82674572e-02f, -4.42321002e-02f, 1.28738144e-02f, -1.43330740e-02f, 7.79415667e-02f, 3.55745852e-02f, -2.03423314e-02f, 7.44326646e-03f,
  1.21531889e-01f, -2.58191526e-02f, -6.59863185e-03f, 3.31304744e-02f, -3.72276902e-02f, -1.85731407e-02f, -5.30428737e-02f, 3.38211283e-02f, 4.40430194e-02f, -3.16740163e-02f,
  4.79787439e-02f, 1.33236423e-02f, -1.07472576e-01f, 3.59481052e-02f, -1.70886785e-01f, 1.46308653e-02f, 1.10792175e-01f, 2.79535223e-02f, -7.79100275e-03f, 1.36775553e-01f,
  1.18849752e-03f, -6.34423196e-02f, 1.07622243e-01f, 8.38214830e-02f, -1.79443676e-02f, 2.01777846e-01f, 7.36422986e-02f, 6.15793876e-02f, 7.64815286e-02f, 7.78719559e-02f,
  2.32056454e-02f, 1.96008924e-02f, 1.88443176e-02f, 2.99315061e-02f, -2.49094074e-03f, 1.62251946e-02f, -1.87067054e-02f, -8.42675269e-02f, 4.75586876e-02f, -1.23131789e-01f,
  3.05991601e-02f, 1.30977616e-01f, 6.84854016e-02f, 2.11946219e-02f, 5.57919368e-02f, -2.39574444e-02f, 2.98624672e-02f, -2.42047831e-02f, 3.74849178e-02f, -7.87736923e-02f,
  -8.57603773e-02f, -1.74791608e-02f, -1.46715436e-02f, 6.73629940e-02f, -7.91263580e-02f, 1.46119297e-02f, -3.74064855e-02f, -8.81829634e-02f, -8.60694200e-02f, -2.59625893e-02f,
  -1.00226417e-01f, -2.93418523e-02f, -5.07988147e-02f, 8.20927322e-02f, 1.84228178e-02f, 2.88284570e-02f, 9.89623591e-02f, -1.20509872e-02f, -1.67242102e-02f, -8.35491624e-03f,
  -8.66127834e-02f, 9.26503167e-03f, 9.52020229e-04f, -7.73214921e-02f, -1.99891441e-02f, -7.09746853e-02f, 3.13493945e-02f, -4.36410680e-02f, 2.56596301e-02f, 5.88787794e-02f,
  -2.76737250e-02f, -8.74606818e-02f, -2.08976530e-02f, -7.62645528e-02f, -1.65145677e-02f, 3.28662917e-02f, -5.39854728e-03f, 3.65300626e-02f, -3.79438475e-02f, -3.54574062e-02f,
  5.12315519e-02f, 6.49233982e-02f, -4.39797118e-02f, 1.58410072e-02f, 9.32138879e-03f, 4.53098193e-02f, 9.25775170e-02f, -4.59719114e-02f, -8.35713372e-02f, -6.55760542e-02f,
  -1.77603848e-02f, 7.81759247e-02f, 4.07099426e-02f, -1.17094852e-02f, -9.17642415e-02f, 1.42441586e-01f, 6.69942200e-02f, -9.97901056e-03f, -2.09997175e-03f, 5.52985854e-02f,
  1.78790409e-02f, -8.01188275e-02f, -3.14061716e-02f, -6.42603114e-02f, -5.96256927e-02f, 4.68882034e-03f, 8.05156380e-02f, -1.10274874e-01f, 5.38547756e-03f, 2.56456956e-02f,
  -5.27318455e-02f, -6.08528368e-02f, 6.03748718e-03f, -6.95359558e-02f, -5.38669992e-03f, 8.78598988e-02f, 4.95197810e-02f, -1.27106765e-02f, -2.74107070e-03f, -1.09070924e-03f,
  4.30079788e-01f, 6.48901090e-02f, -1.26825809e-01f, 1.01796567e-01f, 8.13832432e-02f, 3.24955016e-01f, 2.85888970e-01f, 1.47161350e-01f, 4.57403898e-01f, 6.86396658e-02f,
  -9.60922763e-02f, 1.07885912e-01f, -7.24952966e-02f, -1.57229099e-02f, 1.10088922e-01f, -5.60641335e-03f, 2.04452083e-01f, 1.28240764e-01f, 1.62142053e-01f, 7.74718598e-02f,
  1.89890489e-01f, 1.00744635e-01f, -2.83641756e-01f, -1.35709479e-01f, 4.69096825e-02f, -4.31126691e-02f, -2.42475212e-01f, -1.24977022e-01f, -2.02230737e-01f, -2.48357486e-02f,
  -1.35283358e-03f, 7.09418533e-03f, -1.07358001e-01f, 5.90069257e-02f, -5.42586762e-03f, -3.29309292e-02f, -1.25771776e-01f, -1.24907747e-01f, 2.49818270e-03f, 9.25613418e-02f,
  7.50568658e-02f, -9.09180045e-02f, 5.12139872e-02f, -2.66797673e-02f, 1.29610792e-01f, -3.40167694e-02f, -2.65468489e-02f, 3.18768527e-03f, -8.99066627e-02f, 4.87184897e-02f,
  -4.59917672e-02f, 5.55468164e-03f, 5.54957660e-03f, -6.33503124e-03f, 3.74711901e-02f, 6.49132133e-02f, -4.50526290e-02f, -1.06464282e-01f, 4.86167446e-02f, 4.70243879e-02f,
  1.16886668e-01f, 1.21583603e-02f, 5.79358526e-02f, -3.14949937e-02f, 1.33569632e-02f, -6.97934628e-02f, -5.82352504e-02f, -6.68894127e-02f, 3.18332016e-02f, -3.94666195e-02f,
  2.18950231e-02f, -2.97493488e-02f, 2.39905249e-02f, 4.59299162e-02f, 1.60669144e-02f, 3.41452099e-02f, 2.01218259e-02f, 3.86829348e-03f, 5.93739487e-02f, -9.18283910e-02f,
  1.16367852e-02f, 4.60162498e-02f, -5.31425793e-03f, -1.34013267e-02f, -7.99870118e-02f, 2.87596490e-02f, 2.23074276e-02f, 1.60131287e-02f, -6.44863844e-02f, -5.09481020e-02f,
  1.00965597e-01f, 2.86915153e-01f, 4.50528003e-02f, -6.84002833e-03f, -2.98558604e-02f, -2.61951145e-02f, -2.24748831e-02f, 1.47665739e-01f, 9.17805079e-03f, 1.07291840e-01f,
  -2.56035663e-02f, 1.57788035e-03f, 8.64368230e-02f, -7.78866857e-02f, -9.10267606e-02f, 5.31349704e-02f, 7.01922029e-02f, -6.26437971e-03f, 2.11898871e-02f, -9.36198607e-02f,
  -6.39461875e-02f, 1.24101058e-01f, 5.39253578e-02f, 7.19198659e-02f, 5.88352047e-02f, -9.08302441e-02f, 6.88510090e-02f, -5.81065007e-02f, -4.90775704e-02f, 2.66224388e-02f,
  -8.11222643e-02f, 9.10850242e-02f, -2.29914203e-01f, -1.12944134e-01f, 1.84632942e-01f, -1.05413295e-01f, -4.75890934e-02f, 4.81109098e-02f, 4.81240591e-03f, 1.39182433e-01f,
  4.12436500e-02f, -1.63611010e-01f, 1.21359676e-01f, -1.61280692e-01f, -2.72523284e-01f, -1.76792532e-01f, -1.64802298e-01f, -1.48025692e-01f, 8.59772600e-03f, -2.08011139e-02f,
  -1.41326115e-01f, 8.78940988e-03f, -2.39747271e-01f, 1.10950202e-01f, 5.84768457e-03f, 9.08425599e-02f, 1.25327632e-01f, 2.27731645e-01f, -1.01632185e-01f, 6.18604086e-02f,
  -2.89693419e-02f, -5.67811951e-02f, -4.41034436e-02f, -4.34543565e-02f, 2.77423002e-02f, 7.94282649e-03f, 2.91798841e-02f, -3.15626785e-02f, 1.43600302e-02f, 5.05885407e-02f,
  -2.79544890e-02f, 4.99522723e-02f, 4.60848175e-02f, 9.78662893e-02f, 4.99457456e-02f, -1.75808296e-02f, 4.63445969e-02f, -2.63492223e-02f, 4.96750558e-03f, -8.67403969e-02f,
  -2.26972927e-03f, -3.22287977e-02f, -9.32107270e-02f, -2.66896989e-02f, 1.56260747e-02f, 4.48300838e-02f, 5.11535211e-03f, -4.51208688e-02f, -3.69247544e-04f, 1.82995740e-02f,
  8.11004415e-02f, 8.08297321e-02f, -9.92245413e-03f, 9.91122518e-03f, 6.02716692e-02f, 3.24746221e-02f, 2.84496732e-02f, 5.85458092e-02f, 5.64381182e-02f, 9.81979892e-02f,
  -1.50785372e-02f, 4.56206538e-02f, -3.10507677e-02f, 4.26689349e-02f, -2.72259917e-02f, -4.31530513e-02f, -6.55485988e-02f, 2.39794664e-02f, -9.44729373e-02f, -1.07069071e-02f,
  4.68766131e-02f, -6.75202385e-02f, 1.23245427e-02f, 6.01110160e-02f, -2.76480243e-02f, 8.03272519e-03f, 1.62178669e-02f, -1.07193580e-02f, 6.96806684e-02f, -5.01504019e-02f,
  -7.36506283e-02f, 7.24515393e-02f, 3.97499837e-02f, 6.17016889e-02f, 3.17207165e-02f, -4.90722507e-02f, 3.44607532e-02f, -7.92482421e-02f, 1.98878609e-02f, -1.45308478e-02f,
  9.90849361e-03f, 3.28995362e-02f, 2.87020882e-03f, -6.49309382e-02f, -2.80838907e-02f, -5.11274189e-02f, -2.23629624e-02f, 3.54069285e-02f, -3.78520489e-02f, 4.89959419e-02f,
  8.59906971e-02f, -3.74674089e-02f, 2.13324837e-02f, 7.31896833e-02f, 1.40611548e-02f, 8.23487714e-02f, 3.69921327e-02f, -2.66141966e-02f, -4.36976887e-02f, -3.16929556e-02f,
  3.06832016e-01f, -1.44742072e-01f, 1.74926057e-01f, 2.70559222e-01f, -1.48757752e-02f, -5.44559993e-02f, 7.10859569e-03f, -1.98743157e-02f, 6.09136336e-02f, -1.80137441e-01f,
  -3.29233073e-02f, 1.55909300e-01f, -1.21522233e-01f, -2.47159693e-02f, 1.03620276e-01f, -2.12217629e-01f, -4.43178080e-02f, 3.95179354e-02f, -5.64291924e-02f, 4.13652956e-02f,
  7.32806772e-02f, 1.28000583e-02f, 7.99100474e-02f, -1.54254079e-01f, 1.37053996e-01f, 5.52608781e-02f, 1.69217940e-02f, 3.22700776e-02f, 4.21683602e-02f, -1.14578165e-01f,
  -3.61487903e-02f, 2.24924106e-02f, 6.13538548e-03f, -5.46872206e-02f, -4.69304062e-02f, -2.09754173e-04f, 3.04898806e-02f, -8.55223611e-02f, -1.86753180e-02f, -4.53160927e-02f,
  3.15343216e-02f, 9.66315717e-02f, 6.12145402e-02f, 3.08593572e-03f, 4.85117435e-02f, 2.50727870e-02f, 8.20681080e-02f, 6.25549108e-02f, 2.18419190e-02f, -6.16922863e-02f,
  4.06351648e-02f, 3.80033962e-02f, 2.44828817e-02f, 6.04563504e-02f, -4.06093709e-02f, 1.12581336e-04f, 2.88051572e-02f, 5.91064952e-02f, -1.85811687e-02f, -2.26453077e-02f,
  -5.57643510e-02f, -7.19775110e-02f, -5.49130980e-03f, 4.14624736e-02f, 9.61494967e-02f, 2.34007444e-02f, -4.95150732e-03f, -5.33464737e-02f, 1.02876276e-01f, 3.50160822e-02f,
  5.80275096e-02f, 6.02820627e-02f, -7.79474005e-02f, -5.08230068e-02f, 7.98291042e-02f, 5.44193722e-02f, -2.00340636e-02f, -2.08507366e-02f, 5.94122931e-02f, -6.64356491e-03f,
  -9.31404829e-02f, 1.38383247e-02f, 9.24944803e-02f, -3.78161892e-02f, 5.16774654e-02f, 5.39165288e-02f, 7.19067156e-02f, -2.35062167e-02f, 3.74835990e-02f, 4.35041226e-02f,
  2.34369561e-02f, -6.06287457e-02f, 1.23018376e-03f, 3.49501194e-03f, 2.87645385e-02f, -1.01438962e-01f, -1.28571196e-02f, 7.81388432e-02f, -8.35476592e-02f, -9.05675627e-03f,
  -1.37953641e-04f, -9.68496781e-03f, 2.70188320e-02f, 8.43629241e-02f, -9.29546878e-02f, 5.21903532e-03f, 7.66859651e-02f, -1.59707274e-02f, 6.85822293e-02f, -3.21254954e-02f,
  5.77214547e-02f, 7.84049928e-02f, -2.93974038e-02f, -2.72356477e-02f, -7.96640366e-02f, 2.50930563e-02f, 4.53440566e-03f, -4.91952673e-02f, -2.85877322e-04f, 1.72678251e-02f,
  -1.92950573e-02f, 4.02318761e-02f, -7.10370690e-02f, -1.07413836e-01f, 6.59803208e-03f, -1.98233068e-01f, -9.31687653e-02f, 4.02202681e-02f, 6.72489703e-02f, 1.80505533e-02f,
  -9.36833173e-02f, 2.02523009e-03f, 3.94082889e-02f, -7.54513666e-02f, 9.07044485e-03f, 3.44598219e-02f, -1.42714277e-01f, -1.28552824e-01f, 5.27238362e-02f, -1.58071995e-01f,
  -3.91809940e-02f, -2.68371645e-02f, -6.59426078e-02f, -4.09537926e-02f, -1.26400366e-01f, -6.12049177e-02f, 2.15193862e-03f, -8.17357376e-02f, 1.07355034e-02f, -3.35063450e-02f,
  -2.05205996e-02f, -2.83361152e-02f, -9.97698586e-03f, -7.50770327e-03f, 4.70464537e-03f, -4.88407686e-02f, 1.30402362e-02f, -2.17297319e-02f, 8.89332965e-03f, -3.16485600e-03f,
  6.88785017e-02f, 6.25525555e-03f, 5.67078590e-03f, 3.31119187e-02f, -2.84230849e-03f, -4.15397584e-02f, 2.14960873e-02f, 7.61555228e-03f, 5.65798283e-02f, -3.90797146e-02f,
  6.39071614e-02f, 6.31904975e-02f, -6.43590540e-02f, -8.25226400e-03f, 1.95124503e-02f, -4.91265468e-02f, 5.09071746e-04f, -6.45126402e-02f, -8.51958692e-02f, -6.14169911e-02f,
  -3.77096161e-02f, -3.38174291e-02f, -7.45847821e-02f, -3.17810215e-02f, 5.70687316e-02f, -3.88539843e-02f, 5.88892549e-02f, -6.44483194e-02f, -6.39258325e-02f, 6.81746528e-02f,
  -1.73230562e-02f, -2.28817370e-02f, 2.31441017e-02f, -5.48244976e-02f, -9.59489942e-02f, 7.50029236e-02f, -6.23495504e-02f, 1.66635104e-02f, -1.08234487e-01f, 4.54021208e-02f,
  -3.76663320e-02f, -2.18927078e-02f, -7.49462619e-02f, -1.13792717e-01f, -6.14008158e-02f, 5.90196550e-02f, -2.32142699e-03f, -5.17773181e-02f, -3.33309658e-02f, 5.41288741e-02f,
  -7.03739747e-02f, 8.01141635e-02f, 7.37827048e-02f, 8.24369416e-02f, 1.93677749e-02f, -5.15684150e-02f, 2.84339837e-03f, 1.53559232e-02f, 5.90613410e-02f, -1.04352050e-02f,
  -4.75171208e-03f, -3.17721143e-02f, 4.16999459e-02f, 2.66232956e-02f, 9.91754681e-02f, 5.28105311e-02f, 1.68265030e-02f, 5.80748878e-02f, -7.05783069e-02f, -1.87165067e-02f,
  -4.44701687e-03f, -5.58354668e-02f, -5.23061641e-02f, -5.97745134e-03f, -1.02211900e-01f, 4.01634499e-02f, 1.95453875e-02f, -1.95686854e-02f, 5.05743437e-02f, 5.14848270e-02f,
  7.04448819e-02f, 4.31201756e-02f, -3.42354327e-02f, 5.17255291e-02f, 1.25944465e-01f, -1.18799672e-01f, 6.01432808e-02f, -1.67900790e-02f, 1.58530205e-01f, -1.10239625e-01f,
  -1.09586500e-01f, -8.83679837e-02f, -7.62712806e-02f, -5.02020903e-02f, -1.52464546e-02f, -1.00916125e-01f, -1.00177102e-01f, -1.40375584e-01f, -4.44425792e-02f, -6.15398064e-02f,
  2.02779137e-02f, -1.17606513e-01f, 5.01899756e-02f, 7.41176382e-02f, -4.84485105e-02f, 6.54720739e-02f, -1.38614655e-01f, -6.77469894e-02f, 4.87539917e-02f, -8.47957209e-02f,
  -2.74048131e-02f, 1.26317546e-01f, -1.12335896e-02f, 1.33370563e-01f, 7.85555318e-02f, -9.24196914e-02f, -4.05011047e-03f, -3.61366570e-02f, 6.58046156e-02f, -1.04625784e-02f,
  -8.89752954e-02f, 2.43551005e-02f, -1.77666415e-02f, 5.02459258e-02f, 7.40396306e-02f, 5.64343333e-02f, 6.43587112e-02f, 3.29296701e-02f, 1.99872479e-02f, -1.04236929e-02f,
  9.45726112e-02f, -8.39158222e-02f, 9.80873220e-03f, -3.04780272e-03f, -4.86530475e-02f, 6.87091192e-03f, -2.42245905e-02f, -5.51737733e-02f, 7.99869467e-03f, 8.31483752e-02f,
  -6.45491332e-02f, 7.45048421e-03f, 5.13683865e-03f, -1.59915015e-02f, 3.33711244e-02f, -2.98237652e-02f, 3.42050567e-02f, 8.19364339e-02f, -4.70919088e-02f, -7.87011627e-03f,
  1.58845037e-02f, 8.99815857e-02f, 3.19768637e-02f, 1.63729154e-02f, -2.84761451e-02f, 1.88166238e-02f, -5.88337146e-02f, -4.17731553e-02f, 8.38708952e-02f, -7.60093629e-02f,
  6.21756613e-02f, -3.40986662e-02f, -6.00604676e-02f, -1.36002339e-02f, 2.29247939e-02f, -3.40237319e-02f, 4.27853642e-03f, 1.29346708e-02f, -5.41801155e-02f, -8.89699906e-02f,
  -3.38722654e-02f, 5.55236824e-02f, -5.61374798e-02f, -3.34625947e-03f, -8.55551288e-02f, -8.45827907e-02f, -3.43214758e-02f, -8.49989876e-02f, 7.19824061e-02f, 6.59485385e-02f,
  -6.89988136e-02f, 5.88956401e-02f, -4.57361341e-03f, -8.40645432e-02f, -2.40489282e-02f, 1.08208200e-02f, -9.25032794e-03f, -1.98276918e-02f, -4.72082347e-02f, -1.71951223e-02f,
  -8.06080252e-02f, -4.65229265e-02f, 7.14883059e-02f, 7.60127371e-03f, -9.34262387e-03f, 2.16327310e-02f, -8.69033784e-02f, -6.77385777e-02f, -1.54664107e-02f, 5.43563925e-02f,
  -1.64908797e-01f, 1.60601139e-02f, 5.84135763e-02f, -2.03158811e-01f, -3.30895260e-02f, -1.56612143e-01f, -1.46123812e-01f, 7.98698142e-02f, 4.74509075e-02f, -8.06603357e-02f,
  -5.83112128e-02f, -1.06682301e-01f, 5.84452040e-02f, -1.77079350e-01f, 5.82474982e-03f, 2.75921281e-02f, -1.70856193e-01f, -1.44862875e-01f, 2.80891489e-02f, -1.78761315e-02f,
  6.09482899e-02f, -1.43931195e-01f, 8.19213316e-02f, 6.02255315e-02f, 4.79536457e-03f, -5.13230674e-02f, 5.73490076e-02f, 1.94546685e-01f, -1.31928891e-01f, -3.55270866e-04f,
  -1.34804666e-01f, -2.51035206e-02f, -5.08461297e-02f, 4.32921620e-03f, -9.49906930e-03f, -1.74878687e-02f, -8.05174634e-02f, 8.72138049e-03f, -4.84632328e-02f, -8.12379941e-02f,
  1.98682230e-02f, -7.15853348e-02f, -4.22381163e-02f, 5.65311275e-02f, -5.87520283e-03f, 6.67742938e-02f, 2.06135903e-02f, -2.76742168e-02f, 7.86218420e-02f, -1.11548684e-03f,
  -5.76971658e-02f, 3.28900181e-02f, 4.68323082e-02f, -2.01211609e-02f, 8.06980729e-02f, -3.48566733e-02f, 2.38940213e-02f, 3.73600870e-02f, 6.99080005e-02f, -8.29804242e-02f,
  2.76593417e-02f, -1.03900298e-01f, -2.72200685e-02f, -6.48920750e-03f, 6.14355169e-02f, -2.92083621e-02f, 3.43139172e-02f, -1.93685517e-02f, 5.77033460e-02f, -3.56732793e-02f,
  -1.00773893e-01f, 2.41285302e-02f, -3.51921991e-02f, -2.16673594e-02f, -5.18748201e-02f, 7.73847401e-02f, -6.52681515e-02f, 5.03083505e-02f, 2.10821372e-03f, 7.22837746e-02f,
  4.19765003e-02f, -2.01875642e-02f, 3.49405780e-02f, -2.80655473e-02f, 6.99194372e-02f, -1.93289127e-02f, -2.11832430e-02f, -6.75606132e-02f, -7.60964397e-03f, 1.21641578e-02f,
  -1.07615046e-01f, -3.06903366e-02f, -3.82082202e-02f, -3.78457159e-02f, -1.06356420e-01f, -3.03755570e-02f, -4.34713475e-02f, 2.12399047e-02f, -1.15659088e-01f, 4.73822132e-02f,
  -8.70176256e-02f, 2.12621968e-02f, -6.24667555e-02f, -7.55178109e-02f, -5.60507923e-02f, -1.03827208e-01f, -2.31782682e-02f, 9.01394710e-03f, -5.26295267e-02f, -5.50900772e-02f,
  -1.70389086e-03f, -3.35112633e-03f, 1.80660356e-02f, 5.35831880e-03f, -6.11913130e-02f, -5.05972654e-02f, 6.48427308e-02f, -2.17224490e-02f, -9.46391374e-03f, -1.12401061e-02f,
  -1.60762325e-01f, -6.89143734e-03f, -1.32945791e-01f, -1.24465980e-01f, 1.14902161e-01f, -3.04498840e-02f, -9.66318622e-02f, 6.75736070e-02f, -3.55264619e-02f, 7.05568865e-02f,
  -3.34166624e-02f, -3.07741109e-02f, -7.86736608e-03f, -1.93978325e-01f, -2.39719629e-01f, -1.32755160e-01f, -1.37378678e-01f, -8.83235261e-02f, -1.45054702e-02f, -2.34346744e-02f,
  -1.23662256e-01f, 7.84693360e-02f, -1.48691207e-01f, 4.76087332e-02f, 3.18827406e-02f, 4.16512378e-02f, -2.03534681e-02f, 1.88965321e-01f, -5.33335619e-02f, 3.01442761e-02f,
  -1.25822678e-01f, 1.07316792e-01f, 3.26936096e-02f, -1.30135491e-02f, 3.32211033e-02f, 1.73502471e-02f, 6.69821352e-02f, -5.46286590e-02f, -7.83878639e-02f, 7.42281377e-02f,
  -6.92400038e-02f, -3.69578339e-02f, -2.84940680e-03f, -4.14515957e-02f, 2.42866538e-02f, 2.76015103e-02f, 4.53875139e-02f, -4.54000346e-02f, -4.86301584e-03f, 1.98372006e-02f,
  -7.25820959e-02f, 3.84687670e-02f, -3.56281288e-02f, -2.01001540e-02f, -3.51379551e-02f, 1.52801406e-02f, -3.37398574e-02f, -6.19630776e-02f, -8.35657716e-02f, -8.47510323e-02f,
  2.07313299e-02f, 6.83607310e-02f, 3.82152162e-02f, 8.63022208e-02f, -4.99305502e-02f, -3.44624743e-02f, 7.42777586e-02f, 4.56880638e-03f, -4.07938361e-02f, 1.25353429e-02f,
  6.46308810e-02f, 4.84209545e-02f, 8.84121582e-02f, -2.48368550e-02f, 1.44402003e-02f, 4.02844176e-02f, -3.30491960e-02f, -7.45927691e-02f, -3.10452189e-04f, -4.68605310e-02f,
  6.99686036e-02f, -4.07128409e-02f, 1.28474226e-03f, -8.70586038e-02f, 7.36662745e-02f, 1.75546817e-02f, 6.64049610e-02f, 3.79800461e-02f, 3.44648398e-02f, -2.07937276e-03f,
  -1.30481189e-02f, 4.95266020e-02f, 9.65773538e-02f, -3.07226437e-03f, -2.52525648e-03f, -1.50337903e-04f, -2.95588970e-02f, 9.84505983e-04f, 2.09945217e-02f, -7.55382515e-03f,
  8.68556947e-02f, -1.49241136e-02f, -1.12906862e-02f, -1.53612299e-02f, 4.17775027e-02f, 6.26551360e-02f, 6.15410097e-02f, -3.30676027e-02f, 5.36807813e-02f, 4.43690568e-02f,
  6.00650944e-02f, 1.22212162e-02f, 1.01259630e-02f, -3.63204479e-02f, 2.89366022e-02f, 6.64301962e-02f, 6.64912760e-02f, 1.10323988e-02f, 2.03083046e-02f, 9.29131638e-03f,
  -1.97529420e-01f, 1.81579277e-01f, -4.13971432e-02f, 3.63406865e-03f, 7.87004754e-02f, -2.00644404e-01f, -1.32278219e-01f, 1.16824463e-01f, -1.61154047e-01f, 2.57453416e-02f,
  1.21006921e-01f, -7.02130869e-02f, 9.80466828e-02f, 8.80108029e-02f, -8.41793269e-02f, 6.46541193e-02f, -1.58689022e-01f, -1.42339721e-01f, 9.44575444e-02f, -9.64907464e-03f,
  -6.97697103e-02f, 5.39108366e-02f, 8.58120769e-02f, 2.03828350e-01f, -8.48770365e-02f, -6.43190136e-03f, -4.43408079e-02f, 1.70570895e-01f, -1.02444574e-01f, 1.28075201e-03f,
  -8.73138011e-02f, 8.33487362e-02f, -7.86018521e-02f, 2.88643893e-02f, -6.39505731e-03f, -1.77624777e-01f, -6.07218780e-02f, -3.15095372e-02f, 9.21365339e-03f, -5.99513873e-02f,
  -4.43540923e-02f, 8.99235830e-02f, 2.44942922e-02f, -2.41228286e-02f, -5.02019860e-02f, 4.18283902e-02f, 2.69101583e-03f, -1.86754018e-02f, -4.11010273e-02f, 2.57134177e-02f,
  -4.71831532e-03f, 1.52486013e-02f, 3.43070030e-02f, -9.00217146e-02f, -3.09126545e-02f, 1.15621395e-01f, -6.06661215e-02f, -9.09219682e-02f, 1.66336745e-02f, 4.27270168e-03f,
  5.20212129e-02f, -6.95528015e-02f, 9.06722546e-02f, -6.18354268e-02f, 3.41865607e-02f, -3.66946273e-02f, 9.80711542e-03f, 4.86391373e-02f, 3.18713742e-03f, 9.54913497e-02f,
  -1.82408616e-02f, -7.69094471e-03f, -4.97387536e-02f, -2.73580812e-02f, 6.15209006e-02f, -1.09920420e-01f, 6.06155843e-02f, -6.02343641e-02f, 1.69288218e-02f, -2.93271411e-02f,
  4.61535901e-02f, 1.81054994e-02f, -1.92441959e-02f, -4.64693643e-02f, 6.77823601e-03f, 4.03075740e-02f, -6.72525242e-02f, -2.32328847e-02f, -6.10154681e-02f, -9.25931260e-02f,
  -2.03214690e-01f, 4.71090712e-02f, -3.73484828e-02f, -1.10000953e-01f, 6.52202070e-02f, -2.25809067e-02f, -6.02561887e-03f, -7.57899284e-02f, 5.22087291e-02f, 1.60400197e-02f,
  -6.31719679e-02f, -6.51781783e-02f, -9.38336030e-02f, 4.87495884e-02f, 1.93179976e-02f, -7.98135698e-02f, 8.18906426e-02f, -1.04446359e-01f, -6.85416628e-03f, -2.44490821e-02f,
  -8.02915543e-03f, -8.48492421e-03f, -8.10285658e-02f, -7.62995481e-02f, 1.48335267e-02f, -8.20600614e-02f, -9.47086811e-02f, 1.47964880e-02f, 5.18155135e-02f, -6.14559203e-02f,
  2.01640591e-01f, -1.13624372e-01f, -9.18579474e-02f, 5.78886382e-02f, -1.54624404e-02f, 5.94520234e-02f, 2.02497728e-02f, -4.88737449e-02f, -5.99600822e-02f, -2.32044943e-02f,
  -3.56663093e-02f, -5.50106615e-02f, -1.57193050e-01f, 4.71027568e-02f, 6.84775338e-02f, 4.74012420e-02f, 1.68782249e-02f, 4.33004163e-02f, 1.73457467e-03f, -8.76771361e-02f,
  8.59952047e-02f, 2.16170773e-01f, -2.49283668e-02f, 7.68815875e-02f, 1.17732123e-01f, -4.46820669e-02f, -3.33007909e-02f, -3.81801389e-02f, -3.03042326e-02f, 7.14392439e-02f,
  9.15224925e-02f, -7.38215744e-02f, 3.86320539e-02f, -4.11558747e-02f, 6.08363785e-02f, 6.07875101e-02f, -7.95922279e-02f, -1.34635158e-02f, 2.09642621e-03f, 2.56681312e-02f,
  3.49892043e-02f, -5.13052307e-02f, 2.00705267e-02f, 2.97433939e-02f, 3.03325020e-02f, 2.11900268e-02f, 2.24139728e-02f, -3.24965874e-03f, -2.07814272e-03f, -6.17545657e-02f,
  -4.43443470e-02f, -7.25537390e-02f, -9.76041779e-02f, 6.64696544e-02f, -4.23476659e-03f, 3.40698734e-02f, 8.01225193e-03f, -4.60661435e-03f, 1.33416187e-02f, 8.84759277e-02f,
  1.43313606e-04f, -4.18920256e-02f, 4.08596508e-02f, 1.43144019e-02f, 2.41117552e-02f, 6.33252859e-02f, -4.99284118e-02f, 6.07620031e-02f, 2.50002854e-02f, 5.59255034e-02f,
  5.90905845e-02f, 5.84730841e-02f, -4.44140360e-02f, 6.11365028e-02f, 7.15436414e-02f, -1.95910991e-03f, 1.72212645e-02f, -3.85978594e-02f, -1.07097700e-02f, -4.41767052e-02f,
  -7.87349120e-02f, -4.57951315e-02f, 8.29288960e-02f, -9.70050767e-02f, 3.48136239e-02f, 1.33128895e-03f, 5.23372814e-02f, 1.41683838e-03f, -6.21944182e-02f, 2.81874985e-02f,
  -8.75815302e-02f, 1.54831056e-02f, -4.28282619e-02f, 7.74856331e-03f, 3.34183499e-02f, 2.46644877e-02f, 2.21441705e-02f, -4.53551449e-02f, 4.14584875e-02f, 2.65459041e-03f,
  -9.10222679e-02f, -2.20565777e-02f, 6.50864393e-02f, -7.79534578e-02f, -5.12708388e-02f, -7.47675961e-03f, -4.84130308e-02f, 4.44403142e-02f, -6.56432807e-02f, 8.17394108e-02f,
  -6.80061877e-02f, -1.05115637e-01f, 5.57729565e-02f, 1.27008406e-03f, -5.12452647e-02f, -8.94417688e-02f, 3.68342809e-02f, 2.13365797e-02f, 1.64114460e-02f, -2.71221157e-02f,
  4.48376834e-02f, 2.29437202e-01f, 2.65955895e-01f, -1.42559007e-01f, -8.79196152e-02f, 6.87720925e-02f, -1.46579491e-02f, 9.32398215e-02f, 4.77169119e-02f, 6.48655444e-02f,
  -1.14502691e-01f, -1.57865714e-02f, -6.11347668e-02f, -8.97618383e-02f, -2.15382442e-01f, -1.00010186e-01f, -1.57349244e-01f, -1.33163795e-01f, -3.98678100e-03f, -3.08275409e-02f,
  -1.91039406e-02f, -1.85733333e-01f, -3.66727039e-02f, 8.24255869e-02f, 2.17379685e-02f, 1.28076509e-01f, -1.58277616e-01f, -3.77873564e-03f, 4.51342948e-03f, -8.44274089e-02f,
  6.46509901e-02f, 3.22271027e-02f, 1.39118545e-02f, 8.18726867e-02f, -7.46530890e-02f, -1.18125286e-02f, 4.03739288e-02f, -5.85987419e-02f, -8.11527073e-02f, 4.40959539e-03f,
  -6.27913103e-02f, 3.81482281e-02f, 2.92970100e-03f, -1.08393701e-02f, 3.46614607e-02f, 5.49791940e-02f, 1.67522784e-02f, 8.42540562e-02f, -2.25276966e-02f, 1.16162106e-01f,
  1.22555301e-01f, 2.50505209e-02f, 2.41577229e-03f, 3.68334278e-02f, -5.52202798e-02f, 1.83704775e-03f, 4.45714369e-02f, 3.55365574e-02f, -6.88819727e-03f, 4.71727997e-02f,
  9.80457142e-02f, -5.57854846e-02f, 9.65232588e-03f, 3.52234393e-02f, 2.13903841e-02f, 6.23649061e-02f, -3.18469992e-03f, 7.19546750e-02f, -4.77201231e-02f, -8.42564180e-02f,
  4.94036525e-02f, -4.93759885e-02f, 6.68390095e-02f, -2.57071592e-02f, -6.46405369e-02f, -7.90458694e-02f, -4.34587784e-02f, 1.83277335e-02f, -7.42075220e-02f, 1.03241518e-01f,
  5.10664657e-02f, -5.24025783e-02f, -6.90420764e-03f, -3.46515700e-02f, 5.26116677e-02f, 2.53821835e-02f, -8.06893408e-02f, -9.38037317e-03f, -3.55163701e-02f, 2.08957735e-02f,
  6.32011443e-02f, -6.10969700e-02f, 9.25438628e-02f, 1.22591583e-02f, -6.45559505e-02f, -8.98583326e-03f, -5.60812391e-02f, -3.76814716e-02f, -8.22419152e-02f, -3.90217341e-02f,
  -6.50490224e-02f, -9.36475620e-02f, 1.62679348e-02f, -1.90594941e-02f, -8.30046162e-02f, 2.92614438e-02f, -7.70131871e-02f, 3.76222446e-03f, -1.91077916e-03f, 3.55230551e-03f,
  7.50514716e-02f, -2.92282123e-02f, 4.10404662e-03f, -8.80816504e-02f, -4.82078120e-02f, -3.59499715e-02f, 1.03590693e-02f, -5.02406359e-02f, 3.03263105e-02f, -7.09712282e-02f,
  6.10234290e-02f, -3.09284702e-02f, -9.36593208e-03f, 2.11592019e-01f, -1.35430932e-01f, -3.93910557e-01f, -4.04396653e-01f, -9.43953171e-03f, -1.02138259e-01f, -1.46997690e-01f,
  -6.84376806e-02f, 5.03703952e-02f, -4.64549549e-02f, 8.62886831e-02f, 2.50873566e-01f, 1.03546672e-01f, 1.95043579e-01f, -3.00962236e-02f, 1.86187789e-01f, 1.53059736e-01f,
  3.03249598e-01f, 2.69132078e-01f, 2.43718237e-01f, 5.51776625e-02f, 5.71561791e-02f, 1.90373048e-01f, 2.86478162e-01f, 1.06129358e-02f, 1.52312100e-01f, 7.53855333e-02f,
  -5.85855395e-02f, 1.41863540e-01f, -6.42186925e-02f, 1.40385404e-02f, -5.33770099e-02f, -2.04655379e-02f, -9.95770991e-02f, -1.84671748e-02f, 1.02843037e-02f, 2.91064456e-02f,
  5.32432757e-02f, 5.37094474e-03f, 9.71622241e-04f, 4.77370694e-02f, -3.83882932e-02f, -6.88100755e-02f, 8.98825098e-03f, -5.46781272e-02f, -8.09063539e-02f, 7.19025433e-02f,
  -1.69069115e-02f, -9.28602647e-03f, -4.46255505e-02f, 1.70009285e-02f, 3.78930531e-02f, -6.71611652e-02f, -4.49488163e-02f, 2.77543571e-02f, 9.39443707e-03f, 2.86487192e-02f,
  9.53239575e-02f, 2.48320661e-02f, -1.03118502e-01f, 4.41756248e-02f, -4.26142942e-03f, 5.77198714e-02f, 4.29263897e-02f, 1.28948444e-03f, 5.77351265e-02f, -1.29706343e-03f,
  1.12218168e-02f, 1.22761284e-03f, 6.66917413e-02f, -1.78900976e-02f, 3.16787176e-02f, 8.07968155e-03f, -5.05782515e-02f, -3.84018831e-02f, -4.02714573e-02f, 3.90591659e-02f,
  -5.37841022e-02f, 1.24414135e-02f, 5.51517308e-02f, -7.48955458e-02f, -6.23027571e-02f, 4.95986529e-02f, 8.53188410e-02f, -6.47956505e-03f, 5.68393506e-02f, 5.88342957e-02f,
  5.51913045e-02f, 2.89548397e-01f, -7.27991015e-02f, -8.96178335e-02f, 5.32108434e-02f, -3.71979661e-02f, 1.81280822e-02f, 1.03818275e-01f, 9.49773937e-02f, 3.45106907e-02f,
  1.68165434e-02f, -7.14593008e-02f, 6.65397495e-02f, 4.84361276e-02f, -3.05910017e-02f, 1.12756327e-01f, -4.86474149e-02f, -4.35416214e-03f, 4.59787697e-02f, 9.19128805e-02f,
  -1.46222236e-02f, 2.83904504e-02f, 5.76358959e-02f, -1.09993219e-02f, 7.22751068e-03f, -5.15245199e-02f, -4.22102548e-02f, -4.99616638e-02f, 1.15317062e-01f, 9.35830250e-02f,
  2.78588030e-02f, -6.39612004e-02f, -1.70517005e-02f, -1.05764322e-01f, -3.93782891e-02f, -2.25764349e-01f, -1.28256902e-01f, -5.12132235e-02f, -1.13612637e-01f, -6.98891133e-02f,
  -5.70642725e-02f, 2.53872387e-02f, 9.00072381e-02f, -2.46985897e-01f, 1.44758463e-01f, 1.62597880e-01f, -1.85585707e-01f, -1.24649435e-01f, -7.53013641e-02f, 1.34219723e-02f,
  -2.95207389e-02f, -1.09314442e-01f, -7.28391483e-02f, 3.32466476e-02f, -6.26410469e-02f, -8.65325257e-02f, 7.45646507e-02f, -2.54255831e-02f, -1.40357077e-01f, 2.57389713e-03f,
  -9.70503613e-02f, -4.54572737e-02f, -8.76316279e-02f, -1.09886907e-01f, -5.01287691e-02f, 3.02711818e-02f, -1.25759766e-01f, -1.42547917e-02f, 2.67758053e-02f, 5.57844006e-02f,
  3.58153204e-03f, -4.80826246e-03f, -2.44046394e-02f, -6.28276393e-02f, -6.21764846e-02f, -3.51875760e-02f, 2.20304113e-02f, 3.96286063e-02f, -4.90655228e-02f, 1.93827879e-02f,
  2.35745441e-02f, -4.89969589e-02f, -2.29139719e-02f, -5.07631637e-02f, -4.52304035e-02f, -6.47623166e-02f, 2.71794759e-02f, -5.78450486e-02f, -5.58727942e-02f, 4.43259776e-02f,
  -9.45337489e-02f, -5.03185242e-02f, -9.64700207e-02f, -2.25528684e-02f, -1.40585611e-02f, -2.12931782e-02f, -8.02037423e-04f, 1.86413005e-02f, 6.51545376e-02f, -2.95266267e-02f,
  4.36698273e-02f, -3.67915630e-02f, -3.12004052e-02f, -9.74796638e-02f, 8.40972587e-02f, -4.86948304e-02f, -4.01443578e-02f, -4.95201349e-03f, 2.51597036e-02f, 2.09368728e-02f,
  2.30015330e-02f, -4.90655825e-02f, -4.91826013e-02f, -3.21161076e-02f, -5.99591918e-02f, -3.50573771e-02f, -4.61612158e-02f, -3.84504981e-02f, -6.57845512e-02f, 6.19887523e-02f,
  -5.42073336e-04f, 2.62377001e-02f, -6.79271743e-02f, 7.16093555e-02f, -4.18695509e-02f, -7.07907379e-02f, 5.35639115e-02f, -6.58330396e-02f, -8.85473639e-02f, 9.01238099e-02f,
  -6.23381361e-02f, -4.47078682e-02f, -6.04941789e-03f, 3.87278311e-02f, 2.91628391e-02f, 4.99742143e-02f, 2.65319832e-02f, -3.06706671e-02f, -1.14190802e-02f, 7.15065077e-02f,
  2.94973627e-02f, 4.70066257e-02f, 3.35513754e-03f, -9.59846452e-02f, 3.90747562e-02f, -2.75594741e-02f, -3.89976543e-03f, 2.58068927e-02f, -2.65519936e-02f, 6.08299300e-02f,
  -5.39857224e-02f, 7.70520940e-02f, -8.54925066e-02f, -5.54371476e-02f, 1.09044639e-02f, -1.05038881e-01f, -2.63084602e-02f, 5.05216718e-02f, -1.34839773e-01f, 9.85100344e-02f,
  4.24240716e-03f, 1.06523894e-01f, -8.21441710e-02f, -1.04023263e-01f, -2.47743025e-01f, -2.29153186e-01f, -1.06111452e-01f, 1.19754802e-02f, -3.58369350e-02f, 1.04302809e-01f,
  -5.58694154e-02f, 2.84664072e-02f, 5.52009679e-02f, 8.68765786e-02f, -3.55880633e-02f, 1.50904968e-01f, 2.35832244e-01f, 1.08649500e-01f, 1.68770999e-01f, 3.51349041e-02f,
  -7.73713514e-02f, -2.08193101e-02f, -4.47526798e-02f, -5.21243550e-02f, -5.63581884e-02f, 2.13859826e-02f, 6.68886155e-02f, -8.00159276e-02f, 5.83416075e-02f, 5.90364337e-02f,
  2.24250015e-02f, -5.52434139e-02f, 2.48400196e-02f, -1.84685690e-03f, 8.43907222e-02f, 7.04693794e-02f, -5.52382134e-02f, -1.51970144e-02f, 5.28369844e-02f, 8.47022515e-03f,
  -8.24878812e-02f, -6.26091659e-02f, 6.90557435e-02f, -1.02154180e-01f, 1.01784291e-02f, -5.41504249e-02f, 2.32735593e-02f, -7.04325316e-03f, 2.91196466e-03f, 8.74830633e-02f,
  -4.38492559e-02f, -4.27956171e-02f, 3.06287576e-02f, -7.53723085e-02f, 6.13695150e-03f, -3.66720185e-02f, 1.06507447e-03f, 4.43431847e-02f, 7.35211596e-02f, -5.27651124e-02f,
  -3.70329544e-02f, -1.74025316e-02f, 4.46377620e-02f, -3.80382761e-02f, -7.04728365e-02f, -1.36045013e-02f, -4.31165705e-03f, -7.36482395e-03f, -3.30458358e-02f, -5.37428968e-02f,
  -5.16847260e-02f, -7.07912520e-02f, 3.84662184e-03f, 4.27670106e-02f, 3.83962132e-02f, 1.75092015e-02f, -7.92651717e-03f, 8.66623446e-02f, 3.18470299e-02f, -4.87860665e-02f,
  2.21515577e-02f, 5.20173497e-02f, -1.47712347e-03f, -3.98907997e-02f, -3.17716529e-03f, 5.04438952e-02f, -1.42771993e-02f, -8.56296122e-02f, 5.17330244e-02f, 7.41007477e-02f,
  6.19163103e-02f, 8.61932039e-02f, -4.36498821e-02f, 1.16703836e-02f, 7.25100264e-02f, -1.12018980e-01f, 1.02242857e-01f, 1.34871416e-02f, -3.78706604e-02f, 4.00286727e-03f,
  -2.06854232e-02f, 2.12362800e-02f, -1.01565141e-02f, -1.11227948e-02f, -1.63459219e-02f, -6.97038248e-02f, -4.34584729e-02f, 1.11070372e-01f, -3.14376280e-02f, 9.73328575e-02f,
  -7.68403336e-02f, -1.08003765e-02f, 3.74231599e-02f, 7.14600831e-02f, -6.70547113e-02f, -7.36426488e-02f, -8.42373222e-02f, 7.62752146e-02f, -4.59812880e-02f, -1.54229894e-01f,
  -1.23383127e-01f, 6.36712015e-02f, -4.35851626e-02f, -7.13940188e-02f, 9.91964266e-02f, -1.31110447e-02f, 4.52748872e-02f, -7.16271624e-02f, 1.00706287e-01f, -7.42663722e-03f,
  1.79435443e-02f, 5.45610525e-02f, 1.38797149e-01f, 4.86205071e-02f, -4.86992933e-02f, 8.94575119e-02f, 4.55636065e-03f, 5.71061149e-02f, -2.25606766e-02f, -8.00983328e-03f,
  -3.75898071e-02f, -3.40035483e-02f, 6.23626225e-02f, 7.20848516e-02f, 7.13938251e-02f, 2.40417458e-02f, -3.86187769e-02f, -6.90123215e-02f, -3.83499153e-02f, 3.66014615e-02f,
  2.54344027e-02f, 6.53494075e-02f, 7.00274929e-02f, 2.50214040e-02f, 3.58094871e-02f, 2.21528932e-02f, -1.90539955e-04f, -2.24807709e-02f, 5.65147512e-02f, 4.45680767e-02f,
  9.25715938e-02f, 1.02571240e-02f, -7.68015385e-02f, 2.18256637e-02f, 1.37537345e-02f, 2.90990509e-02f, -3.75155695e-02f, -2.99916640e-02f, 2.17265505e-02f, -1.88123416e-02f,
  4.11380865e-02f, -6.61673993e-02f, -6.35479912e-02f, -3.36069800e-02f, -4.16778289e-02f, -7.46975467e-02f, 2.02911403e-02f, -8.12420994e-02f, -8.42721537e-02f, 1.26397598e-03f,
  -9.63264555e-02f, 7.22390693e-03f, -7.83617049e-02f, 4.90681045e-02f, 2.51970310e-02f, -3.60306613e-02f, -3.42581817e-03f, -4.30067442e-03f, 2.05311328e-02f, -5.35173528e-02f,
  9.05811880e-03f, -9.91476625e-02f, -4.81944624e-03f, 1.61003806e-02f, -4.96323258e-02f, 6.68147132e-02f, 5.02439104e-02f, 1.09598555e-01f, -7.56576583e-02f, -3.62999924e-03f,
  8.97719245e-03f, 5.73425628e-02f, -4.25760075e-02f, 4.21476215e-02f, -5.94494417e-02f, -3.50280963e-02f, 8.07277039e-02f, -8.13467130e-02f, 9.16964784e-02f, -7.60743842e-02f,
  -2.33638622e-02f, 6.68695047e-02f, -5.56558259e-02f, 2.52610538e-02f, 7.05420156e-04f, 8.85818992e-03f, 8.49584788e-02f, -6.14209175e-02f, -8.10408145e-02f, -4.18499485e-02f,
  1.08990687e-04f, 6.09980188e-02f, 2.77651884e-02f, 1.50682516e-02f, 7.62477368e-02f, 5.62493578e-02f, -5.11662811e-02f, 8.86737481e-02f, 4.69346866e-02f, -6.78666756e-02f,
  1.95538059e-01f, -2.22080976e-01f, -2.01094791e-01f, 1.86696365e-01f, 2.19340861e-01f, 2.56527551e-02f, -1.41459838e-01f, 1.32596329e-01f, -2.96478458e-02f, -1.42878667e-01f,
  -1.46528808e-02f, -8.62100050e-02f, -3.20631802e-01f, 1.36777326e-01f, 2.52777249e-01f, -2.36028433e-01f, 2.36058578e-01f, -5.33045754e-02f, 7.54609853e-02f, 5.92077076e-02f,
  1.68708250e-01f, 2.70130724e-01f, 9.03697386e-02f, 1.99728057e-01f, 1.58179134e-01f, 7.12521598e-02f, 2.36932300e-02f, -2.15182215e-01f, 1.93896860e-01f, 8.85199606e-02f,
  4.18610834e-02f, 3.36374901e-02f, -4.80198972e-02f, -6.04134751e-04f, -7.66594484e-02f, 6.44150451e-02f, -7.03224493e-03f, 6.50258809e-02f, -2.37142909e-02f, -9.44577679e-02f,
  -2.86889169e-02f, 2.66572926e-02f, -4.13490720e-02f, -6.82740426e-03f, 1.86447967e-02f, 2.38012685e-03f, 1.66726373e-02f, 2.24660486e-02f, -4.10984308e-02f, 4.90769930e-02f,
  -3.95443961e-02f, -4.38402891e-02f, -1.98087469e-02f, 3.69184501e-02f, -1.66443903e-02f, 2.42410731e-02f, -1.17324047e-01f, -2.88737267e-02f, -3.62794623e-02f, 5.82410023e-02f,
  -8.35655406e-02f, 8.15863162e-03f, -5.02900481e-02f, 5.82869500e-02f, -5.68386838e-02f, 4.02088687e-02f, 5.82942255e-02f, -4.81988750e-02f, -7.14455917e-02f, -8.10005423e-03f,
  5.76306246e-02f, -2.88539845e-02f, 2.87653436e-03f, -2.56070886e-02f, -5.22356778e-02f, 6.62929043e-02f, -2.99287830e-02f, 2.69348547e-02f, -2.25694943e-02f, -2.80003753e-02f,
  1.15056820e-02f, 3.04477382e-02f, -8.95800740e-02f, 5.85090891e-02f, -1.61131807e-02f, -5.48730642e-02f, -5.77414222e-02f, -6.63137063e-02f, 5.07990457e-03f, 2.80101987e-04f,
  -9.21056569e-02f, -1.22588433e-01f, -5.03886305e-02f, 9.30389315e-02f, -2.62955055e-02f, 1.46218091e-02f, 1.61786154e-02f, -2.29879189e-02f, 1.85603779e-02f, -2.34673657e-02f,
  -1.42956832e-02f, 1.99752096e-02f, -8.37316513e-02f, 4.95577641e-02f, 7.11098611e-02f, 4.96241935e-02f, 3.18645947e-02f, -6.80356994e-02f, -1.99927129e-02f, 2.85473559e-02f,
  -3.33481319e-02f, -1.14022017e-01f, 1.62807666e-02f, -2.21739560e-02f, 1.72966085e-02f, -2.80912668e-02f, -7.95126706e-02f, -6.05331473e-02f, -9.75163803e-02f, -3.16569060e-02f,
  2.85209984e-01f, 2.79910177e-01f, 3.47144574e-01f, 1.22395732e-01f, 1.51955185e-03f, -1.00066736e-01f, -7.02501461e-03f, 4.88396846e-02f, 1.39629319e-01f, 8.08828771e-02f,
  -1.67082101e-01f, 2.71637022e-01f, -1.87000632e-01f, 7.89908171e-02f, -2.48448208e-01f, -2.56718189e-01f, 8.38256814e-03f, 5.71767800e-02f, -8.52713082e-03f, -4.15238477e-02f,
  -2.92338319e-02f, -2.95367956e-01f, -3.27150412e-02f, -1.89938426e-01f, 8.42704177e-02f, 1.07496530e-01f, -1.96390674e-01f, -5.64897880e-02f, 1.32802129e-01f, -7.03243241e-02f,
  8.89553428e-02f, -1.57755874e-02f, 1.52089313e-01f, 9.18151662e-02f, 8.61996263e-02f, 5.97170219e-02f, -3.07134762e-02f, -9.74768251e-02f, 3.21753928e-03f, -4.25264193e-03f,
  5.78332134e-02f, -7.29170591e-02f, 4.39359294e-03f, -5.91845512e-02f, 5.72816879e-02f, 9.74065140e-02f, 1.35065064e-01f, 9.43359509e-02f, 1.18680842e-01f, 1.17380604e-01f,
  1.42743155e-01f, 1.40690312e-01f, -3.45332213e-02f, -4.57996316e-02f, 7.88232014e-02f, 3.09816226e-02f, 4.51837108e-02f, 8.98398608e-02f, 8.46394375e-02f, 4.38653342e-02f,
  -3.96454632e-02f, -7.32164085e-02f, -9.49122757e-02f, 8.01210627e-02f, -1.62767544e-02f, -9.00804158e-03f, -3.59695069e-02f, -3.80909885e-03f, -2.66988836e-02f, 9.57030151e-03f,
  -9.44011509e-02f, 9.92048606e-02f, -6.73338771e-02f, -4.17422429e-02f, -4.21633199e-02f, 2.41618957e-02f, -4.88163857e-03f, -4.90017645e-02f, 1.52212456e-02f, -6.40594590e-05f,
  -1.22047201e-01f, -6.79729879e-02f, -5.10947593e-02f, 2.93931197e-02f, 7.22703431e-03f, -2.46126181e-03f, -2.82177292e-02f, 6.99556246e-02f, -3.70828770e-02f, -1.27630800e-01f,
  -6.48352504e-02f, -1.09080203e-01f, -6.53702542e-02f, 1.07445463e-03f, 1.83042348e-03f, 3.86349577e-03f, 2.44986359e-03f, 9.03459638e-03f, 2.48152725e-02f, -4.43757772e-02f,
  5.92113137e-02f, -6.32674107e-03f, -3.85598205e-02f, 2.56528705e-02f, 2.03473121e-02f, -9.85264033e-02f, -7.84542412e-02f, -5.06905876e-02f, -8.56514871e-02f, -2.38027032e-02f,
  -3.91916744e-03f, -9.18418989e-02f, 3.86815630e-02f, 7.01982304e-02f, -9.17190593e-03f, 6.48557991e-02f, -1.30940937e-02f, 3.02130729e-02f, 3.59417573e-02f, -3.62760350e-02f,
  2.55788360e-02f, 1.86894778e-02f, 6.89417347e-02f, 3.37782092e-02f, 5.69195114e-03f, 1.45278960e-01f, 7.12760389e-02f, 1.65301189e-01f, 4.96506738e-03f, -5.62682142e-03f,
  -6.37103543e-02f, -9.34015960e-02f, 3.96153219e-02f, -1.23358192e-02f, -1.29832491e-01f, 5.51581234e-02f, 9.44845155e-02f, 1.04924247e-01f, 5.25974520e-02f, -8.12270045e-02f,
  -5.05349226e-02f, -6.37184381e-02f, 2.98303925e-02f, -6.04535080e-03f, 7.45134056e-02f, 4.19955701e-02f, -9.61394161e-02f, -8.93519968e-02f, -1.92570891e-02f, 1.79292820e-02f,
  -8.37342590e-02f, 8.35033786e-03f, -1.66244674e-02f, 1.07706614e-01f, -1.85162909e-02f, -1.25497254e-02f, -4.23876792e-02f, -4.07138355e-02f, 5.07346727e-02f, 1.63375586e-02f,
  -5.82161322e-02f, 5.25235794e-02f, -6.02508299e-02f, -7.85053149e-03f, -4.73954808e-03f, -1.71605926e-02f, 5.39301336e-02f, 1.00791164e-01f, -3.23353335e-02f, 2.43592523e-02f,
  -3.75722088e-02f, 2.83055510e-02f, 2.24747825e-02f, -2.09896546e-02f, -1.65686887e-02f, 5.77082336e-02f, 3.13573442e-02f, -4.70817685e-02f, -4.55883855e-04f, -1.88361539e-03f,
  6.10222518e-02f, -2.55654100e-02f, 5.06736897e-02f, 8.16351399e-02f, -4.95033488e-02f, 7.52720516e-03f, 7.09462836e-02f, -4.76633795e-02f, -2.32166760e-02f, -5.35986573e-02f,
  -6.41553327e-02f, 5.62260300e-02f, -2.91023273e-02f, 2.12217253e-02f, -2.13022195e-02f, -1.45656867e-02f, 6.81299716e-02f, 4.74064983e-02f, 4.06087413e-02f, -3.37542109e-02f,
  3.53348181e-02f, -8.44864473e-02f, 4.41101566e-02f, -2.42487667e-03f, 5.82685182e-03f, -4.56181131e-02f, 5.53779341e-02f, -8.31946451e-03f, 6.36165440e-02f, -9.37254056e-02f,
  -3.81896161e-02f, 4.45732549e-02f, 5.73920086e-02f, 2.48056427e-02f, -1.27472598e-02f, 4.88700047e-02f, 1.90750491e-02f, -5.05870990e-02f, -7.48111606e-02f, 9.12382007e-02f,
  5.09180240e-02f, -2.34593470e-02f, 1.41440704e-02f, -7.02392496e-03f, 1.67735014e-02f, -5.69951646e-02f, -8.27326775e-02f, 3.09615955e-02f, -5.45603856e-02f, -2.78394595e-02f,
  7.50491694e-02f, -5.28189205e-02f, -3.60729955e-02f, 3.57097574e-02f, -2.68057305e-02f, -1.05965957e-01f, 7.15128630e-02f, 5.95797636e-02f, 4.69573028e-02f, 7.09984824e-02f,
  -9.04522762e-02f, 5.90738840e-02f, -2.31318511e-02f, -2.84765102e-02f, 2.40817089e-02f, -1.09001063e-01f, -8.68542120e-03f, -2.83211563e-02f, 4.61716205e-02f, 6.72629401e-02f,
  -5.87626770e-02f, 1.28056481e-01f, 9.41844732e-02f, -1.19934618e-01f, -2.48605430e-01f, -2.60909311e-02f, -8.83655772e-02f, -7.44812340e-02f, -2.06676479e-02f, -3.52275185e-02f,
  -1.29467055e-01f, -2.99949329e-02f, -9.18023288e-02f, -4.48223799e-02f, 7.38186091e-02f, 7.81423599e-02f, 1.21476771e-02f, 1.94174459e-03f, 5.37103601e-02f, -2.09653564e-02f,
  -3.94151639e-03f, 7.07364231e-02f, 5.19240461e-02f, -4.16452847e-02f, -7.23301619e-02f, 4.01153490e-02f, -4.81472956e-03f, -6.30562901e-02f, -1.57032860e-03f, -5.59322350e-03f,
  2.00509485e-02f, -1.79391783e-02f, -2.81879548e-02f, 4.52306010e-02f, 4.44931388e-02f, 4.32108454e-02f, -4.02560271e-02f, -7.91649669e-02f, 5.08252643e-02f, 7.08985375e-03f,
  -2.26675812e-02f, 2.06873268e-02f, -1.02300368e-01f, 4.06596921e-02f, -4.07477701e-03f, 1.18675344e-02f, 6.15178011e-02f, 8.68477449e-02f, -5.65553717e-02f, -8.00805688e-02f,
  5.10725267e-02f, -5.79157770e-02f, 7.32891401e-03f, -2.18915977e-02f, -7.13628903e-02f, 8.45203996e-02f, 6.68538287e-02f, -1.39377071e-02f, 6.00061268e-02f, 3.56352516e-02f,
  -5.84833249e-02f, 6.95903040e-03f, -3.68887093e-03f, 2.24393215e-02f, 6.59826025e-02f, -2.24446673e-02f, 1.15699379e-03f, 4.35796455e-02f, -8.91636983e-02f, -9.25001577e-02f,
  4.62763896e-03f, -4.80165668e-02f, -2.18685679e-02f, -5.23077771e-02f, 7.89004341e-02f, -4.15706374e-02f, 8.18332806e-02f, -1.75308604e-02f, 5.99794462e-02f, -6.25212938e-02f,
  -2.73575983e-03f, -1.61742251e-02f, 5.41325770e-02f, 2.35854778e-02f, -6.71097264e-02f, 3.29153403e-03f, -1.18497536e-02f, 6.03331923e-02f, 1.05458731e-02f, -7.74953589e-02f,
  -8.00517723e-02f, 6.85446933e-02f, 1.97088588e-02f, -6.65948838e-02f, -1.78287588e-02f, -1.61150377e-02f, -5.33209890e-02f, -1.74820051e-02f, -2.69023031e-02f, 2.67916080e-02f,
  -3.95069905e-02f, 8.96011740e-02f, 6.65789694e-02f, -2.43939850e-02f, -6.02777340e-02f, -2.47519389e-02f, -1.48290908e-02f, 5.06561808e-02f, 4.61577326e-02f, -8.94722156e-03f,
  1.24982344e-02f, 1.42528534e-01f, -1.09741539e-01f, -1.06008939e-01f, 7.04516619e-02f, -3.29121739e-01f, -2.27797955e-01f, 8.05557221e-02f, 9.17280838e-02f, 1.32021114e-01f,
  -1.03257634e-01f, 5.75994551e-02f, -5.95940370e-03f, -2.96340108e-01f, -3.37610960e-01f, 6.09245058e-03f, -3.28408390e-01f, -1.74336717e-01f, -1.49486745e-02f, -4.99816537e-02f,
  -7.30310529e-02f, -1.86343879e-01f, -2.35180289e-01f, 1.51239829e-02f, -1.70627192e-01f, -3.45986523e-02f, -2.29801964e-02f, -5.79254888e-02f, -1.97975770e-01f, -9.36719403e-02f,
  -2.30624489e-02f, 8.48168600e-03f, -6.46856576e-02f, 5.41631542e-02f, -2.68247854e-02f, -1.11615226e-01f, -2.60290504e-02f, -1.00734435e-01f, 5.91643564e-02f, -7.13744685e-02f,
  -1.57171711e-02f, 2.57189460e-02f, -3.47037502e-02f, -3.71373780e-02f, 2.71177888e-02f, -4.48516943e-02f, -6.89282268e-02f, -6.12142682e-02f, 6.14315318e-03f, -1.69526357e-02f,
  -8.37654769e-02f, 1.51032293e-02f, 5.96572198e-02f, 8.90703648e-02f, 4.81731398e-03f, -6.56147599e-02f, 2.46012434e-02f, 1.11825054e-03f, -1.00578591e-01f, -1.85781699e-02f,
  7.69082755e-02f, -2.68464498e-02f, 7.29923509e-03f, -9.35287215e-03f, 2.60515083e-02f, 6.90593123e-02f, -5.93816526e-02f, 1.26731945e-02f, -3.65453139e-02f, -6.82494268e-02f,
  5.61427064e-02f, 1.14041185e-02f, 6.91852197e-02f, -3.56528535e-02f, -1.63156260e-02f, -1.76209863e-02f, -5.82756288e-03f, 6.58941418e-02f, -1.75896995e-02f, 4.72018681e-02f,
  -1.71626697e-03f, -5.07219844e-02f, 9.04668346e-02f, -4.81594428e-02f, -5.34037463e-02f, 6.17117016e-03f, 7.97309726e-02f, 5.34196049e-02f, 7.33625442e-02f, -9.56121162e-02f,
  -1.09756887e-01f, 3.60241719e-02f, -3.73684503e-02f, 1.84000228e-02f, 6.13777973e-02f, -1.08565316e-02f, -1.16951473e-01f, -1.43068982e-02f, -7.31924921e-03f, -3.57659459e-02f,
  -2.27967948e-02f, -2.24411618e-02f, 2.16619810e-03f, 6.59493059e-02f, 4.24709804e-02f, 1.67549925e-03f, -9.43049267e-02f, 8.22482631e-02f, -7.25218281e-03f, -1.33232307e-02f,
  9.14674699e-02f, 3.71117406e-02f, 7.84575045e-02f, 3.28114219e-02f, 4.72368672e-02f, 7.80907273e-02f, 2.56753638e-02f, -1.02529777e-02f, 6.11668192e-02f, -7.64572397e-02f,
  -3.28315705e-01f, -2.09042549e-01f, 1.99447975e-01f, -3.97975951e-01f, -6.39563019e-04f, 7.94862956e-02f, 1.67243674e-01f, -2.14735046e-01f, -3.04586530e-01f, -1.44787103e-01f,
  -3.01929750e-02f, -6.73973486e-02f, 3.46928239e-01f, -1.02000393e-01f, 2.68346608e-01f, 3.68013620e-01f, -3.53643671e-02f, 9.83223915e-02f, -8.55128840e-02f, -2.94262946e-01f,
  -4.78155725e-02f, -8.07611272e-02f, 2.45602906e-01f, -1.33576974e-01f, -1.48788616e-01f, -2.57065564e-01f, 6.43743873e-02f, 1.18239425e-01f, -3.41478065e-02f, 9.01654437e-02f,
  -1.96830422e-01f, -2.09608108e-01f, -8.36940389e-03f, 8.08306132e-03f, 2.55189128e-02f, 5.19799143e-02f, 2.40571555e-02f, 9.70740914e-02f, 6.11943752e-03f, 4.86976802e-02f,
  2.19755620e-02f, -5.97226992e-02f, -6.02344833e-02f, -2.43544746e-02f, -5.12000248e-02f, -1.09139252e-02f, -4.65590460e-03f, -3.02912723e-02f, -8.91167205e-03f, 3.79401632e-02f,
  -2.74097454e-03f, -3.83977429e-03f, -3.82787883e-02f, -5.02929837e-03f, 7.33799711e-02f, -5.61015569e-02f, 3.13386670e-03f, 8.13315436e-02f, -4.11890298e-02f, -9.63808969e-02f,
  1.00293495e-01f, -1.42302737e-02f, -4.63138707e-03f, 1.72994509e-02f, -5.09126857e-02f, 1.94837712e-02f, -6.06503859e-02f, -1.62750930e-02f, -4.36516814e-02f, 2.86856815e-02f,
  -1.05156954e-02f, -8.26262161e-02f, -2.91609019e-02f, 8.94518476e-03f, -3.23165208e-02f, 1.16871437e-03f, 3.63544771e-03f, -1.18071986e-02f, 2.52012983e-02f, -3.93679626e-02f,
  -4.15907279e-02f, -1.86822284e-02f, 1.73796471e-02f, 7.79390782e-02f, -1.80110186e-02f, 1.46008618e-02f, -6.77189603e-02f, 6.30558059e-02f, -2.02105641e-02f, 3.45607176e-02f,
  -2.93851405e-01f, -2.59986907e-01f, -8.62170383e-02f, -4.12140489e-02f, -3.84572037e-02f, 4.79435455e-03f, 1.30149694e-02f, -9.79471654e-02f, -6.98071197e-02f, -4.44967812e-03f,
  -2.50134878e-02f, 4.67718579e-03f, -4.98395897e-02f, -3.09636313e-02f, 3.60728800e-02f, -4.37962748e-02f, -6.42068684e-02f, 1.62562393e-02f, -6.28681257e-02f, -6.80893213e-02f,
  9.45481937e-03f, -1.43249473e-02f, 5.78137562e-02f, -4.82956581e-02f, 5.27140163e-02f, 1.68880681e-04f, -4.32392396e-02f, -2.78194901e-02f, 7.79385716e-02f, -4.95349616e-02f,
  6.80948272e-02f, 1.10453233e-01f, 1.97476551e-01f, 2.21480727e-01f, -5.65559696e-03f, -1.68522522e-01f, 5.28398678e-02f, 1.01647437e-01f, 2.86682814e-01f, -1.96323037e-01f,
  -1.48927227e-01f, -9.41509083e-02f, -1.50534019e-01f, -1.06104324e-02f, 1.45214677e-01f, -1.49406893e-02f, 3.19513753e-02f, -5.00139855e-02f, 1.48953170e-01f, 1.45676389e-01f,
  8.95437300e-02f, -6.96754158e-02f, 5.36034591e-02f, 2.48028506e-02f, -3.66011332e-03f, 9.12397355e-02f, 7.43035153e-02f, -8.92073195e-03f, -8.22884738e-02f, 6.03099354e-02f,
  -5.38996086e-02f, 6.98402151e-02f, -2.95210108e-02f, -1.83936711e-02f, 3.45510133e-02f, -4.94801663e-02f, -5.94021147e-03f, -9.69419815e-03f, 5.83580248e-02f, 4.95801307e-02f,
  -1.06817822e-03f, -6.11046553e-02f, 7.16906413e-02f, 5.15689068e-02f, 1.33610636e-01f, 1.20136738e-01f, -1.08856289e-02f, 2.06990447e-02f, 5.38543388e-02f, -3.18397470e-02f,
  6.46471679e-02f, -7.05677737e-03f, 2.21083257e-02f, -2.80622877e-02f, 1.18148811e-01f, -9.65101458e-03f, 7.12213526e-03f, 4.84296557e-04f, 4.23989929e-02f, 8.16005096e-02f,
  3.91811579e-02f, 1.04535498e-01f, 3.00077256e-02f, -1.95856392e-02f, 1.44838216e-02f, 6.82111755e-02f, 7.85372220e-03f, -6.47093505e-02f, 5.96599765e-02f, -5.35499901e-02f,
  1.05313301e-01f, 8.23298097e-02f, 7.88033456e-02f, 6.77116066e-02f, 9.01403576e-02f, -6.62460774e-02f, -7.31136426e-02f, 3.32517251e-02f, 1.18112341e-01f, 5.42890243e-02f,
  1.05572626e-01f, -6.25921413e-03f, -5.32103591e-02f, 5.78764752e-02f, 6.30967692e-02f, -2.53877081e-02f, 7.45345280e-02f, -5.96753173e-02f, 2.35116761e-02f, 4.08306979e-02f,
  -2.19709259e-02f, 2.23802969e-01f, 5.81715517e-02f, -1.12135857e-02f, -6.13772217e-03f, -1.10265184e-02f, 8.57297033e-02f, 3.67466919e-02f, 7.16001764e-02f, 2.48251669e-02f,
  -2.77308282e-02f, -4.26032431e-02f, -3.91906761e-02f, 6.10966654e-03f, 2.99397763e-02f, 9.01874228e-05f, -3.18422578e-02f, 9.48622599e-02f, 3.81886028e-02f, -1.66700669e-02f,
  4.35975380e-02f, -6.68393299e-02f, 3.56699042e-02f, 4.78245802e-02f, -8.47231373e-02f, -8.40184391e-02f, -2.54894197e-02f, 1.10886283e-02f, 3.20321950e-03f, -1.23535069e-02f,
  -5.56536056e-02f, 3.19389887e-02f, -8.70871171e-03f, -5.88903688e-02f, -1.54571915e-02f, 1.83891863e-01f, 2.58565433e-02f, 1.07598931e-01f, 1.38730139e-01f, 1.59176990e-01f,
  3.87013279e-04f, -1.17318563e-01f, 1.02052771e-01f, 1.46231845e-01f, -9.75950714e-03f, 6.32607937e-02f, 1.76066190e-01f, -3.29662934e-02f, 5.01129664e-02f, 8.06231201e-02f,
  2.40421249e-03f, 1.57478489e-02f, -2.05524955e-02f, -1.13497399e-01f, -1.75468270e-02f, -1.01709463e-01f, -1.17597707e-01f, -5.65822721e-02f, 5.60600776e-03f, 5.33100329e-02f,
  9.89873633e-02f, 7.63888732e-02f, -5.78072332e-02f, 2.02814993e-02f, -1.97105072e-02f, -5.79442009e-02f, 8.43089074e-03f, -1.16988689e-01f, -7.80665800e-02f, 5.96743403e-03f,
  2.39658002e-02f, 7.17661344e-03f, -4.14768979e-02f, -3.67780253e-02f, -5.57826869e-02f, -1.08030327e-02f, -4.49644998e-02f, -7.00180084e-02f, 1.64569970e-02f, -3.28548886e-02f,
  -1.59313846e-02f, -1.66407377e-02f, 1.96179114e-02f, -6.12883903e-02f, 3.70623842e-02f, 4.20160480e-02f, 2.01796857e-03f, -5.04380912e-02f, -1.24979038e-02f, 4.32555974e-02f,
  -2.94366106e-02f, -7.43664578e-02f, -6.98001981e-02f, -4.54878584e-02f, 6.79919943e-02f, -4.59775291e-02f, -6.69925362e-02f, -3.47474590e-02f, -2.55796891e-02f, -2.83735618e-02f,
  1.27829220e-02f, -6.46379814e-02f, 5.40164225e-02f, 8.55481848e-02f, 8.40672925e-02f, -6.75413087e-02f, -1.38369575e-02f, 4.66793887e-02f, 6.78979009e-02f, -4.98361625e-02f,
  5.72042800e-02f, 6.44829050e-02f, -3.82545702e-02f, -6.79484233e-02f, -9.78967268e-03f, -1.87268145e-02f, -4.35103849e-02f, 8.46062135e-03f, 7.54098073e-02f, -3.88236232e-02f,
  -2.39570569e-02f, -8.43158513e-02f, 1.15547478e-02f, 1.43256746e-02f, -2.61274166e-03f, -4.59656455e-02f, 2.58028228e-02f, -5.01769260e-02f, 4.91636470e-02f, 3.66200297e-03f,
  7.43463263e-02f, 1.51816942e-02f, 6.75336719e-02f, 3.35189737e-02f, -4.18113545e-03f, -2.21820939e-02f, 8.98887590e-02f, 3.74386236e-02f, 2.91272104e-02f, 6.19898625e-02f,
  3.13831381e-02f, 3.24780867e-02f, -1.04390912e-01f, 2.34299283e-02f, -4.54025790e-02f, -4.03806269e-02f, 3.87353450e-02f, -1.09041641e-02f, -4.76475060e-02f, 4.81689498e-02f,
  -8.35979655e-02f, 1.03008449e-01f, -3.40800174e-02f, -1.68301970e-01f, -5.52184246e-02f, -3.73176322e-03f, -6.46763965e-02f, -9.47279632e-02f, 9.05739367e-02f, -1.74240336e-01f,
  -1.74934357e-01f, 9.89384353e-02f, 5.67744561e-02f, -2.33126834e-01f, 2.60542065e-01f, 1.16091296e-01f, -1.43719047e-01f, -7.35202506e-02f, -1.53730232e-02f, -2.10988507e-01f,
  -1.75076239e-02f, -2.14271754e-01f, -5.54656163e-02f, -1.52946874e-01f, -2.85649180e-01f, -1.33768007e-01f, -3.90293188e-02f, -8.86896700e-02f, -9.18757617e-02f, -7.75820762e-02f,
  -2.10943795e-03f, -1.89482003e-01f, -7.13053569e-02f, -6.59382269e-02f, -1.61975473e-02f, -4.15673666e-02f, 1.82048567e-02f, 6.32982329e-02f, -4.82760444e-02f, 3.30038741e-02f,
  3.95197123e-02f, -1.33682322e-02f, 2.29810718e-02f, -1.17864031e-02f, -8.05967897e-02f, -5.32216132e-02f, 2.42048055e-02f, -3.12115401e-02f, -1.08532449e-02f, -7.11007193e-02f,
  -4.07513380e-02f, 2.81779114e-02f, -9.49434936e-02f, -4.00939658e-02f, 3.78994606e-02f, -6.59915879e-02f, 1.25219047e-01f, 5.67964762e-02f, -4.09832736e-03f, 1.08134814e-01f,
  -5.07852435e-02f, 8.14380646e-02f, -3.45109440e-02f, 1.72433089e-02f, -1.86277833e-02f, -2.03123800e-02f, 8.57700109e-02f, -2.10815798e-02f, 3.82093340e-02f, 1.94985904e-02f,
  -5.88525757e-02f, -1.21013030e-01f, 8.32553301e-03f, 4.64099646e-02f, -3.89756300e-02f, 7.10928738e-02f, -7.21572340e-02f, 6.78611472e-02f, 5.11601456e-02f, -8.92228782e-02f,
  2.15633232e-02f, 5.67363687e-02f, -1.83244329e-02f, -1.10322470e-02f, -1.78316310e-02f, -2.51172371e-02f, 3.72961536e-02f, -4.25505489e-02f, -7.06907436e-02f, -2.58097947e-02f,
  -3.09120715e-02f, -7.13631744e-03f, -4.14222740e-02f, -1.22732736e-01f, 4.16895598e-02f, -7.10192323e-02f, -1.31800342e-02f, 7.22606927e-02f, 9.51883644e-02f, -1.21611156e-01f,
  1.20329177e-02f, -3.51714902e-02f, -2.31367294e-02f, 5.27953841e-02f, 3.39432284e-02f, -5.49302101e-02f, -9.36610531e-03f, -3.73299383e-02f, 8.49317089e-02f, -4.18781415e-02f,
  -5.94947636e-02f, 2.83028986e-02f, -2.76099164e-02f, -1.50848832e-02f, -1.14294991e-01f, 2.44498588e-02f, 1.91069748e-02f, -9.30337235e-04f, -9.09542814e-02f, 1.68547239e-02f,
  1.85206056e-01f, -2.62085587e-01f, 5.24006337e-02f, -8.93661939e-03f, 2.57642809e-02f, 8.28072056e-02f, 1.89603105e-01f, -3.01851481e-01f, -1.96473852e-01f, -2.25068524e-01f,
  1.62690058e-02f, 7.24785179e-02f, 3.62918600e-02f, -7.09804371e-02f, 2.88143247e-01f, -5.03734648e-02f, -7.37835690e-02f, 2.34033931e-02f, -8.69308785e-02f, -2.73604575e-03f,
  -3.05400696e-02f, -1.29467800e-01f, -6.39096275e-02f, -1.67338401e-01f, -6.02969415e-02f, -5.61553650e-02f, 2.42966078e-02f, 2.00453281e-01f, -1.15496702e-01f, 1.31394476e-01f,
  -8.52403268e-02f, -9.78199095e-02f, -1.66285578e-02f, 6.19686730e-02f, -3.72209586e-02f, -8.53299722e-03f, 1.28704369e-01f, 1.47073895e-01f, 6.58393139e-03f, -2.72056479e-02f,
  1.08356208e-01f, -1.63173564e-02f, -5.71399815e-02f, 4.30790856e-02f, 1.87645499e-02f, 1.96530204e-02f, 4.26433571e-02f, 4.03449424e-02f, -9.05286819e-02f, -2.80633941e-02f,
  -2.40069441e-02f, 1.08371899e-02f, -1.81667283e-02f, -1.48373954e-02f, -5.53497896e-02f, 3.58553156e-02f, 2.46282276e-02f, 1.60721294e-03f, 1.99283892e-03f, 4.02545892e-02f,
  -2.49724966e-02f, 3.11648827e-02f, 3.77735868e-02f, -8.58425256e-03f, -4.35017515e-03f, -3.07887215e-02f, 8.32760986e-03f, 2.20431592e-02f, 6.80720434e-02f, 5.44391610e-02f,
  8.60832108e-04f, 2.15605162e-02f, 1.17134135e-02f, 4.74710986e-02f, 6.79588914e-02f, -7.52774999e-02f, 2.05895547e-02f, -1.65219512e-02f, 3.80526595e-02f, 6.34222105e-03f,
  4.68085892e-02f, 5.15120514e-02f, 5.14872856e-02f, 7.04981610e-02f, 1.59276966e-02f, -4.24019061e-02f, 1.37216804e-04f, -2.44348235e-02f, 4.48318198e-02f, -2.85664555e-02f,
  8.54799990e-03f, -3.05526853e-02f, 6.88743368e-02f, 6.00269809e-03f, -1.01767294e-02f, -8.19689706e-02f, 6.94349259e-02f, -7.34669343e-02f, 5.87469339e-02f, -8.56190100e-02f,
  -6.57009706e-02f, 9.84610915e-02f, -5.01441546e-02f, -6.04824349e-02f, -5.56732230e-02f, -4.03406285e-02f, -1.78043395e-02f, 5.95803447e-02f, 2.71344520e-02f, -1.24784512e-02f,
  7.95617178e-02f, -1.49529856e-02f, 4.32264619e-02f, 3.50596644e-02f, -7.05731586e-02f, -3.55762355e-02f, 2.35952344e-02f, 9.74891335e-02f, 1.89026967e-02f, 2.79329754e-02f,
  2.50923455e-01f, -3.48440826e-01f, 2.67558664e-01f, 2.38554612e-01f, 2.36660659e-01f, 9.65596586e-02f, 2.28837222e-01f, 2.31563114e-02f, 2.02630639e-01f, -3.15411329e-01f,
  -9.73775387e-02f, -7.99841583e-02f, 3.57763469e-02f, -1.15339085e-01f, 7.34143555e-02f, -1.92049630e-02f, 6.69351313e-03f, -1.03734411e-01f, 1.10568367e-01f, 6.77543553e-03f,
  5.04799150e-02f, -5.56632839e-02f, 1.06897414e-01f, -1.54825613e-01f, 1.48633510e-01f, -5.21950126e-02f, -6.58168346e-02f, -2.89919265e-02f, -5.38267829e-02f, 6.76040864e-03f,
  1.94261726e-02f, -5.91922216e-02f, 2.45417058e-02f, -3.07739787e-02f, 5.35643399e-02f, -1.00100942e-01f, -7.12297559e-02f, -3.37912813e-02f, 3.39224413e-02f, -1.14313990e-03f,
  -1.46906273e-02f, -5.67233600e-02f, -3.71137857e-02f, 9.51933190e-02f, 8.00039023e-02f, 2.20348146e-02f, -3.40404324e-02f, -4.40769792e-02f, -3.19875106e-02f, 1.39384985e-01f,
  9.66365114e-02f, 2.37718201e-03f, 8.24281201e-02f, -1.13586985e-01f, -2.04753578e-02f, -5.55749461e-02f, 6.29668012e-02f, 4.50393036e-02f, -5.46932733e-03f, -1.01581626e-01f,
  2.52768602e-02f, 3.04536108e-04f, -1.31719308e-02f, 6.26167729e-02f, 6.31266460e-02f, 5.85982800e-02f, 6.90644085e-02f, 1.25943497e-02f, -2.53501274e-02f, 1.96653465e-03f,
  5.63697368e-02f, -4.33358252e-02f, 6.59686700e-02f, 5.89850657e-02f, -1.45211967e-03f, -2.79446598e-02f, -6.15253346e-03f, 4.02768962e-02f, -4.16900441e-02f, 2.24325601e-02f,
  5.31775653e-02f, 6.80487379e-02f, 1.61769763e-02f, -3.56799066e-02f, -4.32622060e-02f, 6.06328659e-02f, -6.48862720e-02f, 8.16781819e-03f, -3.78079782e-03f, 3.20606828e-02f,
  -1.54663727e-01f, -2.52831519e-01f, -8.58424604e-02f, -1.08566992e-01f, -8.95647779e-02f, -2.48166844e-02f, -6.54793857e-03f, -1.14484103e-02f, -5.71468025e-02f, 5.19384034e-02f,
  2.60421503e-02f, 5.70460595e-03f, -7.56362975e-02f, -2.85031274e-02f, -5.97014390e-02f, -2.99039464e-02f, -3.75008956e-02f, -8.13918859e-02f, -9.96167958e-02f, -5.54683506e-02f,
  -3.22689377e-02f, 6.81834668e-02f, 2.85259094e-02f, 6.61789998e-02f, -1.27465865e-02f, 4.04970646e-02f, -5.81638515e-02f, -1.34924324e-02f, -8.46309662e-02f, -4.22094800e-02f,
  -4.32769582e-02f, -3.12954821e-02f, -1.37621341e-02f, 9.28896442e-02f, -1.17485501e-01f, -1.20543912e-01f, -1.74220994e-01f, -7.25883171e-02f, -8.71719122e-02f, -4.71986122e-02f,
  3.65723334e-02f, -2.24328451e-02f, -1.27933741e-01f, 9.83826965e-02f, 1.36886507e-01f, 6.26205131e-02f, 2.79597994e-02f, 5.26493229e-02f, -1.84808411e-02f, 3.59770991e-02f,
  1.37547940e-01f, 4.38726991e-02f, 1.64576069e-01f, 1.36674091e-01f, 6.07306883e-02f, 1.23169787e-01f, 2.35169441e-01f, -5.42872287e-02f, 1.74173713e-01f, 9.58753377e-02f,
  -1.06579736e-01f, 1.99371064e-03f, 2.59398371e-02f, -8.35637450e-02f, 3.29101607e-02f, -4.60920967e-02f, 4.62338440e-02f, 6.93355575e-02f, 4.94753309e-02f, 7.09191114e-02f,
  5.64653426e-04f, 4.38407436e-02f, 4.70209010e-02f, -7.91792050e-02f, -5.40971756e-02f, -3.08057875e-03f, -3.97297218e-02f, -4.75902520e-02f, -6.37546852e-02f, -2.73040150e-05f,
  -8.63963664e-02f, -6.36588316e-03f, 4.90591824e-02f, 6.62900656e-02f, 7.09991753e-02f, 8.10969621e-02f, 3.07864249e-02f, 8.86299536e-02f, -1.70346573e-02f, -1.78725249e-03f,
  5.14043346e-02f, -1.12853916e-02f, 4.89843730e-03f, -3.36335152e-02f, -2.87658777e-02f, -2.68297009e-02f, -1.16217332e-02f, 6.94888458e-02f, 2.35879445e-03f, 5.35852835e-02f,
  4.87446487e-02f, 2.40322649e-02f, 6.08525984e-02f, -6.00601956e-02f, 4.21789177e-02f, 3.88643034e-02f, 4.58622761e-02f, 1.70609448e-02f, 5.09303361e-02f, 6.08198196e-02f,
  -5.62191606e-02f, -2.66142283e-02f, -7.05055669e-02f, -6.40493780e-02f, 2.22558528e-02f, -1.98127069e-02f, -8.27962533e-03f, -2.14609057e-02f, -5.76000698e-02f, -8.24052468e-02f,
  2.51464900e-02f, 8.78249481e-02f, 4.89145033e-02f, -7.51700858e-03f, 4.26937118e-02f, -1.63591199e-03f, -4.58944542e-03f, -1.08058546e-02f, 4.82470393e-02f, 8.15172642e-02f,
  3.25689726e-02f, 3.52798104e-02f, 6.51691481e-02f, 6.99123219e-02f, 8.52061734e-02f, -2.43143030e-02f, 7.73669034e-02f, -3.77070680e-02f, 8.11955184e-02f, 3.00988313e-02f,
  -2.06284020e-02f, -8.32276940e-02f, -7.90153630e-03f, -7.36872330e-02f, 8.49784240e-02f, 6.81821704e-02f, 1.05660371e-01f, -1.02521675e-02f, -1.04964506e-02f, 3.73633914e-02f,
  5.77710234e-02f, -2.30397493e-01f, -3.73048365e-01f, -3.45729366e-02f, 2.82361627e-01f, 1.73501596e-01f, -2.09277086e-02f, 7.34743178e-02f, -2.00519621e-01f, 8.80349651e-02f,
  1.62245214e-01f, -1.81596741e-01f, -2.16124952e-01f, 1.93138178e-02f, 6.40442129e-03f, -1.73661187e-01f, 1.57001123e-01f, 8.63779113e-02f, -1.53755128e-01f, -3.21641564e-02f,
  -1.27947824e-02f, 2.35734344e-01f, -1.72325328e-01f, 1.25173599e-01f, 1.43845677e-01f, -1.25501990e-01f, 2.72941262e-01f, -3.91907245e-02f, 2.45461568e-01f, 9.25406963e-02f,
  7.83830509e-02f, -1.34517431e-01f, -3.79433706e-02f, -1.04998313e-02f, 7.61613995e-02f, 4.52133194e-02f, 2.40643276e-03f, 2.11996846e-02f, -6.02930188e-02f, -8.76492634e-02f,
  5.25491759e-02f, 2.03078426e-02f, 2.86480524e-02f, 1.43402638e-02f, 7.95505494e-02f, 4.25512530e-02f, -8.89423117e-02f, 2.62648370e-02f, -7.57807866e-02f, -8.54473263e-02f,
  -7.03135207e-02f, -2.79014366e-05f, 5.32308072e-02f, -5.79487458e-02f, -7.86571875e-02f, -4.05716300e-02f, 2.98563913e-02f, -8.25201795e-02f, 1.07108705e-01f, -5.08224703e-02f,
  8.93045962e-02f, -1.96853187e-02f, 4.89977151e-02f, -5.39547578e-02f, 4.97820675e-02f, -2.09647603e-02f, 4.77343500e-02f, -2.24378668e-02f, 3.86682828e-03f, -4.97531220e-02f,
  4.26853150e-02f, -4.07709219e-02f, 4.62303758e-02f, 5.02106138e-02f, 4.19575684e-02f, -1.01986239e-02f, -1.68004185e-02f, -2.24885996e-02f, -8.76009092e-02f, -6.42747432e-03f,
  4.53630462e-02f, 7.18414858e-02f, -3.62303816e-02f, 4.11725119e-02f, 4.30265442e-02f, -7.04946220e-02f, 1.00482583e-01f, -3.99172679e-02f, -1.56586443e-03f, 4.64957580e-02f,
  8.18932131e-02f, -2.33792253e-02f, -1.07097670e-01f, -5.12739830e-02f, -9.39838439e-02f, 8.17515999e-02f, -1.29339276e-02f, 5.19060344e-02f, -2.34267805e-04f, 2.32584756e-02f,
  4.01444770e-02f, 2.95595955e-02f, 1.10256456e-01f, 4.05202135e-02f, 4.77721468e-02f, 8.45297147e-03f, -7.02093542e-02f, -2.12561488e-02f, 9.50347185e-02f, 3.21648978e-02f,
  4.47457992e-02f, 7.77315572e-02f, 1.49700120e-02f, 1.27098672e-02f, 5.67586720e-02f, 4.97169271e-02f, 6.62339106e-02f, 6.11031204e-02f, 6.25744313e-02f, -4.31805514e-02f,
  -2.97095448e-01f, 6.64327219e-02f, -1.34880647e-01f, -1.41743779e-01f, -6.94764629e-02f, 8.12922567e-02f, 9.48004127e-02f, -1.17371492e-01f, 9.10091121e-03f, 3.38464767e-01f,
  1.77132010e-01f, -1.13982655e-01f, 2.39261299e-01f, 1.05371341e-01f, -8.01120847e-02f, 5.72209246e-02f, 4.06918451e-02f, 1.67711496e-01f, -1.29417777e-01f, -1.25159711e-01f,
  -1.84132606e-01f, 1.62139490e-01f, -2.11001281e-03f, 2.46129297e-02f, -4.62195724e-02f, -1.22326821e-01f, -1.23443697e-02f, -6.49095625e-02f, 1.11486226e-01f, 5.88784404e-02f,
  -7.72130489e-02f, -1.55295804e-01f, -4.91091534e-02f, 3.36286463e-02f, 3.37981842e-02f, -5.24988212e-02f, -7.22392499e-02f, 5.80713712e-02f, -8.34072158e-02f, -2.32486031e-03f,
  -8.34461153e-02f, -4.06864882e-02f, -5.82014807e-02f, 9.00373459e-02f, -4.09368277e-02f, -7.25377128e-02f, -5.80710359e-02f, 5.18679954e-02f, 6.22264342e-03f, 3.45462486e-02f,
  -3.08222193e-02f, 4.85166395e-03f, -3.19443457e-02f, 1.10371135e-01f, -7.75331780e-02f, -3.57833654e-02f, 3.50469351e-02f, -6.72982335e-02f, -9.58089083e-02f, -5.15811481e-02f,
  -4.24011424e-03f, 7.52374679e-02f, 2.72438321e-02f, -1.64126717e-02f, -4.93051205e-03f, 3.46238352e-02f, 5.30738607e-02f, 3.26697901e-02f, 4.31833118e-02f, -3.54594961e-02f,
  4.16911542e-02f, 4.86902669e-02f, -9.00215954e-02f, 2.59964112e-02f, -5.10142520e-02f, 3.30314524e-02f, 3.51006426e-02f, -1.72764547e-02f, 1.01281792e-01f, -7.90523961e-02f,
  6.92312280e-03f, -5.03946654e-02f, 1.85683686e-02f, -2.45228074e-02f, -2.95090899e-02f, 5.18377684e-02f, 4.21478450e-02f, -9.72406119e-02f, 9.84475762e-02f, -4.94692549e-02f,
  -8.84679630e-02f, -2.31007203e-01f, -7.37909600e-02f, -1.71523681e-03f, 1.13875242e-02f, -6.45317957e-02f, -6.57444894e-02f, -5.14917523e-02f, -2.03589350e-03f, -1.96977369e-02f,
  -6.95944652e-02f, -4.91354316e-02f, -4.87340689e-02f, -8.76566842e-02f, 3.09171509e-02f, -4.76853736e-02f, -4.34878282e-02f, -1.17875874e-01f, 6.93537518e-02f, 2.56855264e-02f,
  -7.46288300e-02f, 2.82694548e-02f, -2.63230130e-03f, 5.36413789e-02f, 1.98754272e-03f, -4.09748852e-02f, -1.47380918e-01f, 1.61620062e-02f, -1.23380668e-01f, 5.43985479e-02f,
  1.54010773e-01f, -9.15148631e-02f, -2.39605740e-01f, -1.14688538e-01f, 2.70997304e-02f, 4.32007797e-02f, -2.12410409e-02f, 7.33070001e-02f, -1.97241172e-01f, 6.40211105e-02f,
  1.40202165e-01f, -1.27500698e-01f, -4.23779041e-02f, -7.22837523e-02f, -8.79650116e-02f, -1.56173646e-01f, 1.04880834e-03f, 7.64347985e-02f, -7.33225122e-02f, 1.52907774e-01f,
  2.54916102e-02f, 3.55291888e-02f, -7.88122043e-03f, 1.22583978e-01f, 1.37617454e-01f, 1.05163768e-01f, 2.09787875e-01f, -1.71318627e-03f, 2.11705416e-01f, -1.87805165e-02f,
  2.45559178e-02f, 2.00447105e-02f, -4.81520407e-02f, -1.95403602e-02f, 1.40707180e-01f, 1.11909293e-01f, 2.51667500e-02f, -7.44239688e-02f, -7.73598254e-02f, -8.59578550e-02f,
  -1.75817050e-02f, -5.96334636e-02f, -5.67158461e-02f, 2.11156216e-02f, -8.60593691e-02f, 7.45633543e-02f, -9.64359287e-03f, -3.96292321e-02f, -2.59914584e-02f, 5.76063879e-02f,
  9.68672219e-04f, 1.36675807e-02f, -5.49749956e-02f, 7.68934330e-03f, 9.08352085e-04f, -2.67883111e-02f, 1.54515198e-02f, 5.57178892e-02f, 1.57587696e-02f, 3.52080772e-03f,
  9.79711413e-02f, 7.33055454e-03f, -2.96346527e-02f, -4.26765643e-02f, -4.42977659e-02f, 7.59410560e-02f, -9.81129259e-02f, -3.99746932e-02f, 3.85745242e-02f, 1.14524283e-01f,
  1.56142423e-02f, -1.18705574e-02f, -1.07688094e-02f, 3.92541364e-02f, 6.80455938e-02f, -5.42952828e-02f, 7.95964822e-02f, 4.66854833e-02f, -2.60134949e-03f, -2.94054719e-03f,
  2.71263570e-02f, 8.70014727e-02f, 7.38502368e-02f, 2.82085072e-02f, -6.82928637e-02f, 9.16921198e-02f, -6.35557398e-02f, 2.04553846e-02f, -1.36345660e-03f, 5.82109317e-02f,
  2.94490587e-02f, 1.38443887e-01f, -1.01991996e-01f, -1.07493989e-01f, -4.90967603e-03f, 5.95027022e-02f, 4.93680537e-02f, 5.06842695e-03f, 8.50820616e-02f, 6.18767478e-02f,
  9.05553252e-02f, 1.87707916e-02f, 7.60775357e-02f, -1.58946309e-02f, -6.52329177e-02f, -6.66755158e-03f, -4.27499355e-04f, 7.62019586e-03f, 6.55498132e-02f, 1.82361081e-02f,
  1.17062166e-01f, -4.02907655e-02f, 1.79629885e-02f, -3.02416980e-02f, -5.69157489e-02f, 8.19068998e-02f, -2.56357621e-02f, 7.89375827e-02f, -2.32505668e-02f, -6.96681887e-02f,
  -2.52471685e-01f, 1.42174840e-01f, 2.07305282e-01f, -1.96467370e-01f, 2.44036347e-01f, 2.40347371e-01f, 2.11263988e-02f, 2.16464132e-01f, 9.36508328e-02f, -1.39072672e-01f,
  -2.75765937e-02f, -1.58686206e-01f, 1.23640057e-02f, -1.18203714e-01f, -2.70397421e-02f, 6.33332804e-02f, 8.35298598e-02f, -1.05990402e-01f, 8.68387669e-02f, 6.51698187e-02f,
  5.16360998e-02f, -7.83063173e-02f, 1.64703965e-01f, 5.56694269e-02f, -2.14108694e-02f, -1.65484603e-02f, -5.35951145e-02f, 9.44366157e-02f, -1.46681562e-01f, -2.34339032e-02f,
  1.11412250e-01f, -9.95934606e-02f, -6.44015893e-02f, 9.52122435e-02f, -3.34396176e-02f, -7.89367855e-02f, -2.86678709e-02f, -7.05397055e-02f, -4.11068685e-02f, 3.75225544e-02f,
  -1.28829971e-01f, 5.19249961e-02f, -7.23019540e-02f, -2.17876583e-02f, 4.99793775e-02f, -3.25296484e-02f, 4.85208668e-02f, 8.62017572e-02f, 7.00671077e-02f, 1.17817372e-01f,
  2.32633315e-02f, 5.76797351e-02f, 6.03048736e-03f, 5.08729070e-02f, 3.20529193e-02f, 5.85978944e-03f, 2.38857344e-02f, -3.13004851e-02f, -9.15742770e-04f, 5.83718382e-02f,
  -2.76364926e-02f, -2.16473090e-05f, 4.95367087e-02f, -3.19860280e-02f, 5.52256480e-02f, -4.90029231e-02f, -6.17190683e-03f, -2.48300750e-03f, 3.95815521e-02f, -5.89607731e-02f,
  -8.55309702e-03f, -3.53037700e-04f, 2.78049391e-02f, 5.25034964e-02f, -8.85568932e-02f, 2.12190971e-02f, 1.77988466e-02f, -8.56077224e-02f, 5.48380911e-02f, -7.17924312e-02f,
  -9.86115169e-03f, -7.05992570e-03f, -3.53311114e-02f, 4.37310152e-03f, -4.64110896e-02f, -3.72517034e-02f, -4.41034622e-02f, 1.62445679e-02f, -7.93534592e-02f, -4.18750420e-02f,
  -5.28483093e-03f, -1.40541136e-01f, 4.56798486e-02f, -1.43665094e-02f, 7.69415274e-02f, 1.37659367e-02f, 5.84359877e-02f, 8.11994001e-02f, -5.32573201e-02f, -6.04426414e-02f,
  2.81179771e-02f, -6.04217350e-02f, -7.73546286e-03f, -8.16973485e-03f, -5.47622554e-02f, -3.28523703e-02f, -3.72794755e-02f, -1.43547440e-02f, -6.98609650e-02f, 5.29623590e-02f,
  4.05719653e-02f, -3.70462537e-02f, -6.18050024e-02f, -1.27800358e-02f, -8.32125768e-02f, -1.04015976e-01f, 4.97081950e-02f, 2.30054893e-02f, -3.35322842e-02f, 5.28839454e-02f,
  -1.22457154e-01f, -5.65165021e-02f, 1.19330212e-02f, -5.80301359e-02f, 3.47055420e-02f, 1.90665871e-02f, -6.08396381e-02f, -1.77975907e-03f, -3.75177749e-02f, 7.88291618e-02f,
  -1.07640643e-02f, 7.02962093e-03f, -1.79772731e-02f, -5.26429247e-03f, 9.39248651e-02f, -7.48571157e-02f, 2.38334481e-02f, -9.14470945e-03f, 4.23499718e-02f, 2.75731366e-02f,
  -6.92776814e-02f, 1.92073807e-02f, 1.10802755e-01f, 7.39744827e-02f, -4.25959798e-03f, -1.97475646e-02f, 1.81109328e-02f, -2.73520071e-02f, 1.85168330e-02f, -9.57915839e-03f,
  -3.15060765e-02f, -4.68458347e-02f, 5.19821234e-02f, 2.82762516e-02f, -7.65945241e-02f, -7.06577227e-02f, 5.42141944e-02f, 4.19905186e-02f, -5.50556637e-04f, 8.08171481e-02f,
  2.58520432e-02f, -3.03373337e-02f, 9.80821177e-02f, 4.77376878e-02f, -9.30341855e-02f, -7.48289526e-02f, 5.46262525e-02f, 5.03398180e-02f, 3.35826129e-02f, -2.54156962e-02f,
  4.17119488e-02f, 4.98079471e-02f, -8.08069855e-02f, -7.67432302e-02f, 7.62352869e-02f, 8.76081213e-02f, -3.32614779e-03f, -8.01728070e-02f, -5.85853495e-02f, 1.88043322e-02f,
  3.90175395e-02f, -1.03448406e-01f, 4.74049784e-02f, 8.52373317e-02f, -2.99265888e-02f, 5.78266941e-03f, -5.67396991e-02f, -4.71220762e-02f, 2.59480607e-02f, 8.50747675e-02f,
  2.35933391e-03f, -5.01690656e-02f, -6.37400746e-02f, -8.28603730e-02f, 7.85056036e-03f, 7.12078959e-02f, -2.68523078e-02f, 1.14130555e-02f, 7.89673775e-02f, 3.01813651e-02f,
  -3.77561525e-02f, -9.94832255e-03f, -1.63418911e-02f, 5.63146621e-02f, -8.16054083e-03f, 7.11349100e-02f, -8.24476331e-02f, -4.90962677e-02f, 6.34626523e-02f, 7.46896043e-02f,
  2.06512045e-02f, -1.31670386e-01f, 1.96479186e-02f, -5.41646369e-02f, 5.89202791e-02f, 6.58265278e-02f, -2.30922066e-02f, -4.00540642e-02f, -1.92347943e-04f, 7.08231032e-02f,
  -3.19096558e-02f, -5.16283140e-02f, -4.67777923e-02f, 6.38609827e-02f, -8.00628811e-02f, 1.89200193e-02f, 6.08088262e-02f, -2.39860844e-02f, -7.92988166e-02f, -5.65576926e-02f,
  3.77399311e-03f, 1.58898477e-02f, -1.11899972e-01f, 6.41612411e-02f, -4.91914041e-02f, 3.64408158e-02f, -1.59449466e-02f, -1.70866940e-02f, 4.16315310e-02f, -6.73866123e-02f,
  -2.68752854e-02f, -1.14849910e-01f, -2.37948418e-01f, -1.17588520e-01f, -2.08273649e-01f, 2.92168409e-02f, -2.66355909e-02f, 2.44225208e-02f, -7.21005797e-02f, 1.81650758e-01f,
  -2.43067872e-02f, 1.33443415e-01f, 9.44445580e-02f, 5.83533011e-02f, -1.39123589e-01f, 1.18685409e-01f, 7.55309826e-03f, 5.27984202e-02f, 2.98677478e-02f, 2.84883368e-04f,
  -5.77551648e-02f, 8.04792941e-02f, -1.26507103e-01f, 6.55043721e-02f, -7.92756528e-02f, 7.75398267e-03f, 2.71335207e-02f, -1.59467325e-01f, -2.62915753e-02f, -1.92425889e-03f,
  7.81299770e-02f, 9.94647965e-02f, -9.07796472e-02f, 3.97620387e-02f, -9.36651230e-02f, 6.13069423e-02f, 6.77839965e-02f, -6.13756999e-02f, -1.29152253e-01f, 1.24927796e-02f,
  8.84464607e-02f, -5.63949645e-02f, -2.41654105e-02f, -3.95662077e-02f, -2.16728752e-03f, -9.33368132e-02f, -3.90385427e-02f, -4.67329957e-02f, -2.49835160e-02f, 1.56307798e-02f,
  9.49340500e-03f, -4.67035510e-02f, -8.19412693e-02f, -2.83863228e-02f, -1.98121574e-02f, -5.40686622e-02f, -2.07578787e-03f, 2.86594778e-02f, -7.90214986e-02f, 5.50720952e-02f,
  4.74096797e-02f, 3.30645740e-02f, 7.16289356e-02f, -8.19120333e-02f, 4.86370847e-02f, 3.71836089e-02f, 7.27574602e-02f, -4.96444814e-02f, 2.69413907e-02f, 6.52363971e-02f,
  6.22690916e-02f, -8.18991512e-02f, -8.60057957e-03f, -1.48273492e-02f, 2.72331033e-02f, 8.11486393e-02f, 5.01494855e-02f, -1.43855186e-02f, -2.37974226e-02f, -1.47601619e-01f,
  5.52418344e-02f, 5.54530509e-02f, 6.31315485e-02f, -2.69109989e-03f, -6.00398937e-03f, -5.92511557e-02f, 4.21804376e-02f, -9.73351207e-03f, -5.44888563e-02f, 4.51488644e-02f,
  -4.51646410e-02f, -3.40011939e-02f, 4.80765663e-03f, -4.71800938e-02f, 1.62649974e-02f, 5.11018969e-02f, 3.46583165e-02f, 3.03093400e-02f, 3.41235772e-02f, -3.53386477e-02f,
  -7.34885484e-02f, 8.36629048e-03f, 2.38083638e-02f, 2.62986217e-02f, 1.54427011e-02f, 5.81573285e-02f, -3.00080609e-02f, 5.19592464e-02f, -1.47406859e-02f, -2.57839579e-02f,
  -4.40887734e-03f, -6.46691769e-02f, 7.97054693e-02f, -1.76394992e-02f, -6.31772950e-02f, 8.87856111e-02f, -4.66132425e-02f, 3.23993638e-02f, 4.46119532e-02f, -1.04935626e-02f,
  7.31994212e-02f, -1.76629387e-02f, -1.44068062e-01f, -1.95348129e-01f, -1.05236880e-01f, -1.42994225e-01f, -1.97407365e-01f, -9.37406197e-02f, -9.47738513e-02f, -1.11004204e-01f,
  -8.21440890e-02f, -1.39781997e-01f, 9.82367545e-02f, -2.37884864e-01f, 3.21730506e-03f, 4.81189564e-02f, -9.76389498e-02f, -2.35640295e-02f, 8.53246748e-02f, -1.09034494e-01f,
  -6.56985585e-03f, -1.32640228e-01f, -2.31801625e-02f, 2.33576056e-02f, -1.70675412e-01f, -2.84903292e-02f, -6.20679930e-02f, 1.82148684e-02f, -1.66284546e-01f, -1.05441056e-01f,
  8.13137293e-02f, -2.85206474e-02f, 1.06685638e-01f, 7.05791637e-02f, 4.16320190e-02f, 4.50510979e-02f, -5.30507304e-02f, 4.61394638e-02f, 3.99549082e-02f, 1.89449359e-02f,
  1.47049138e-02f, 1.37726190e-02f, -1.12903446e-01f, 9.40119401e-02f, -1.65431648e-02f, 6.41601309e-02f, 6.73828423e-02f, 1.56144844e-02f, -8.66378099e-03f, 1.24499723e-01f,
  -4.39301990e-02f, 4.32413928e-02f, -4.35195900e-02f, -1.04182465e-02f, -9.35193822e-02f, 7.20641240e-02f, -1.10572077e-01f, 7.37327558e-04f, -3.57186794e-02f, 5.56179583e-02f,
  9.16935969e-03f, 3.53444740e-02f, 3.47046927e-02f, 3.14776078e-02f, 1.87306143e-02f, 7.50678852e-02f, -7.71521255e-02f, 4.35249023e-02f, 2.58874334e-02f, -5.99854887e-02f,
  4.77921218e-02f, 5.08783534e-02f, 4.49370034e-03f, 4.93256934e-02f, 2.12456826e-02f, 1.03073299e-03f, 9.67956930e-02f, -1.92377847e-02f, -4.50124107e-02f, -1.01483241e-02f,
  3.07004936e-02f, 6.89080507e-02f, -3.28664971e-03f, 7.97571093e-02f, -5.46001308e-02f, 3.53395306e-02f, 8.30941200e-02f, -4.83838638e-04f, 7.44815990e-02f, -1.02013826e-01f,
  -5.62761836e-02f, -5.90252466e-02f, 4.52157371e-02f, 1.05967313e-01f, -2.93779187e-02f, 7.24439770e-02f, -1.94619838e-02f, -6.60029100e-03f, 3.58912833e-02f, -8.35396051e-02f,
  4.33206297e-02f, 7.87492916e-02f, 8.26640874e-02f, 6.44240677e-02f, -2.82846093e-02f, -8.78181309e-03f, -6.05557226e-02f, -9.88474935e-02f, -5.13259135e-02f, 6.19622543e-02f,
  -9.61472839e-02f, -5.87721728e-02f, 4.44176234e-02f, 3.87610048e-02f, -5.45075275e-02f, 3.22559550e-02f, -7.93078765e-02f, -1.30445128e-02f, -3.37933972e-02f, -1.89610031e-02f,
  1.11759892e-02f, -2.12303579e-01f, 8.97028446e-02f, 1.06970519e-01f, 8.12943131e-02f, 2.29296908e-02f, -7.97984749e-03f, -7.05392435e-02f, -6.20995602e-03f, -1.39473006e-01f,
  -5.71091585e-02f, 3.16629447e-02f, -8.90223123e-03f, 7.47233629e-03f, 1.14740930e-01f, -4.88705374e-02f, -1.12464845e-01f, 5.23950011e-02f, -1.84761994e-02f, 4.91030738e-02f,
  1.11728616e-01f, 3.58350016e-02f, 4.97758053e-02f, -8.33110809e-02f, -1.05276033e-02f, 6.95620328e-02f, 7.05374917e-03f, -5.61955967e-04f, -3.66289504e-02f, -9.35912412e-03f,
  1.78480148e-02f, -4.40035090e-02f, -4.15971242e-02f, 5.97788543e-02f, -2.00811848e-02f, 7.90197626e-02f, 4.73030470e-02f, 9.69730988e-02f, -2.81141531e-02f, 6.88519776e-02f,
  6.33596722e-03f, -4.96607348e-02f, -6.56478256e-02f, -3.91856804e-02f, -1.24341659e-02f, -5.84822940e-03f, 4.20701224e-03f, 9.03458893e-02f, -5.52521087e-02f, -5.88668250e-02f,
  -1.33559657e-02f, 2.52810344e-02f, 7.64806494e-02f, -5.89218922e-02f, 4.18306850e-02f, 3.60116586e-02f, 3.67291421e-02f, -4.09027003e-02f, -6.18295670e-02f, 4.41971272e-02f,
  5.48513196e-02f, 2.15081275e-02f, 1.66267455e-02f, -9.04449448e-02f, 3.13174091e-02f, -7.45974481e-02f, -8.79629552e-02f, 2.57892278e-03f, -8.06435496e-02f, -5.04920445e-02f,
  -8.72632787e-02f, 6.39842302e-02f, -3.49382199e-02f, 3.88891958e-02f, -6.88725114e-02f, 2.43462548e-02f, 4.95724156e-02f, -1.21274078e-02f, 8.19217414e-02f, -6.24056682e-02f,
  4.52247560e-02f, 3.43435258e-02f, -8.02526623e-02f, -4.51333169e-03f, 6.85016811e-02f, -2.17476804e-02f, 2.96941996e-02f, -3.02568730e-03f, 5.24863638e-02f, 2.81301385e-04f,
  -1.51496038e-01f, -9.98930112e-02f, -4.74578887e-02f, -9.65468958e-02f, -3.48847993e-02f, -6.44789860e-02f, -3.62445451e-02f, 6.86768908e-03f, 6.68421015e-02f, 2.14940459e-02f,
  -8.43397621e-03f, 9.70618799e-02f, -6.06197491e-02f, -1.31943552e-02f, -4.87292036e-02f, -2.34311055e-02f, 5.75383753e-02f, 2.45278645e-02f, -7.48325661e-02f, -4.31622826e-02f,
  -1.09610995e-02f, -4.79651615e-02f, 2.77194493e-02f, 1.19643779e-02f, -5.69837652e-02f, -6.18934026e-03f, 8.62374529e-02f, -6.14428930e-02f, 6.80438802e-02f, -5.17725125e-02f,
  6.28154948e-02f, 3.08346748e-03f, 7.04135671e-02f, 1.37374595e-01f, -4.51796688e-02f, -1.22175902e-01f, 3.38408351e-03f, 1.18266039e-01f, -1.58390924e-02f, -1.36709027e-02f,
  -1.05076097e-02f, 1.05662674e-01f, -6.31911084e-02f, 1.50365546e-01f, 1.72350388e-02f, -9.93738025e-02f, 1.17415018e-01f, -1.24492953e-02f, -5.47800288e-02f, 7.20424205e-02f,
  1.21179491e-01f, 9.16942284e-02f, -3.23652029e-02f, -5.02544269e-02f, 1.52237177e-01f, 5.14933355e-02f, 1.81883816e-02f, -6.43945038e-02f, 6.81504840e-03f, -3.25371251e-02f,
  -3.13326269e-02f, -3.51106301e-02f, 1.03193708e-02f, -4.74856868e-02f, 4.04904261e-02f, -5.22023328e-02f, 1.27409324e-02f, -1.08078167e-01f, 3.82433273e-02f, -7.54952803e-02f,
  7.31794089e-02f, 6.17303289e-02f, 5.02009094e-02f, -9.86909121e-02f, -9.56714526e-03f, -2.13021077e-02f, 9.55715254e-02f, 2.11699749e-03f, 1.08807636e-02f, 6.45101890e-02f,
  4.79824133e-02f, 6.03865413e-03f, 8.65276381e-02f, -8.02172199e-02f, 7.59070814e-02f, 9.66276303e-02f, -2.52081472e-02f, -2.59314049e-02f, -3.68012227e-02f, 4.81601804e-02f,
  -2.89385263e-02f, -5.95517755e-02f, -2.80760154e-02f, 7.60243684e-02f, -5.56843467e-02f, -7.57279694e-02f, -5.13779670e-02f, -3.64807285e-02f, -5.62130660e-02f, 6.61266148e-02f,
  2.45729648e-02f, -4.21333767e-04f, -7.79295936e-02f, -7.64544979e-02f, 2.94875726e-02f, 2.82354709e-02f, -3.65691036e-02f, 7.46724457e-02f, -2.94535290e-02f, 6.94022402e-02f,
  -3.97075200e-03f, 3.70165408e-02f, -4.38117348e-02f, 5.39784245e-02f, -3.59958000e-02f, -5.46889193e-02f, 1.74505953e-02f, 4.75890003e-02f, 1.02595724e-02f, 1.74911525e-02f,
  -5.99717312e-02f, -2.26795916e-02f, -8.28725547e-02f, 2.81840861e-02f, -9.69012640e-03f, -2.50884537e-02f, -1.77098867e-02f, -3.68134379e-02f, -7.25959847e-03f, -3.67538631e-02f,
  -7.90863484e-02f, -5.93281724e-02f, -1.59481298e-02f, -5.69261499e-02f, -5.55494651e-02f, -7.09668994e-02f, 7.83029944e-02f, 9.05745178e-02f, 8.58823955e-03f, 7.25997612e-02f,
  8.07159767e-02f, -3.09775714e-02f, 8.54380429e-02f, 9.46010128e-02f, -2.30217520e-02f, -1.87177975e-02f, 2.00776923e-02f, 4.49082069e-02f, 6.09922223e-02f, 4.20783311e-02f,
  1.46082193e-01f, -5.95186763e-02f, 8.12234133e-02f, -7.14494288e-02f, -2.71791797e-02f, -5.37279621e-02f, -9.39524993e-02f, -4.26420756e-02f, 6.92639351e-02f, -1.10551819e-01f,
  -8.76776651e-02f, 1.41692692e-02f, 1.10023811e-01f, 1.42587414e-02f, -1.63262226e-02f, -5.01058176e-02f, 3.64086553e-02f, -6.27972409e-02f, 8.90100896e-02f, 6.20272383e-02f,
  2.00261194e-02f, -1.30139142e-02f, 2.96688695e-02f, 1.33495077e-01f, 9.05236453e-02f, -3.62748429e-02f, -1.38776097e-02f, -3.41136567e-02f, -1.05522275e-01f, -8.61220956e-02f,
  4.74943519e-02f, 1.25551775e-01f, 4.38085422e-02f, -5.20327501e-02f, 4.47364822e-02f, 1.60005260e-02f, 7.67298928e-03f, -3.36965919e-02f, -6.83051795e-02f, -3.10201012e-02f,
  -4.34813052e-02f, 4.52479050e-02f, 3.76873538e-02f, 6.15784638e-02f, -8.62972531e-03f, 4.76999953e-02f, 9.05249491e-02f, -3.61501314e-02f, -5.90019673e-02f, 7.35425204e-02f,
  -6.78475648e-02f, -2.33790260e-02f, -5.83370030e-02f, 2.26298831e-02f, -9.29896906e-02f, -1.02873653e-01f, 8.22282955e-03f, 5.72105907e-02f, 2.97697186e-02f, 5.10013252e-02f,
  2.99763475e-02f, -8.05442482e-02f, 9.84838158e-02f, 5.46215065e-02f, -6.59513101e-02f, -3.68153043e-02f, 5.07565588e-02f, -3.63357961e-02f, -1.17430147e-02f, -2.95471959e-02f,
  -5.69848605e-02f, -1.01525366e-01f, -5.54902852e-03f, -8.51133168e-02f, -6.68917224e-02f, 2.83502974e-02f, 7.31186057e-03f, 3.71198840e-02f, 4.57284488e-02f, 3.91561463e-02f,
  -5.04290462e-02f, -3.95879596e-02f, 6.86150938e-02f, 3.42656597e-02f, -6.20175116e-02f, -5.71011528e-02f, 2.52969209e-02f, 7.72289708e-02f, 4.00930829e-02f, 8.62038974e-03f,
  1.86724996e-03f, 1.14339039e-01f, -7.71246627e-02f, -4.51094992e-02f, -5.03826961e-02f, 1.68289635e-02f, -5.57988025e-02f, 1.29656820e-02f, 3.78642231e-02f, 1.02290303e-01f,
  -3.47073115e-02f, 7.09157065e-02f, 2.17899345e-02f, -9.64643210e-02f, 1.07326759e-02f, -6.51928559e-02f, 2.36639511e-02f, -1.09357208e-01f, -3.77754942e-02f, 5.95084950e-02f,
  -6.97925463e-02f, -6.13982491e-02f, 1.37911504e-02f, 2.04253662e-02f, 4.28640284e-03f, -9.28247999e-03f, -7.21249282e-02f, -1.59135833e-02f, -7.80816451e-02f, 3.12830918e-02f,
  -2.62125283e-01f, 9.92473587e-02f, -1.04742743e-01f, -9.57734063e-02f, -1.36022896e-01f, -8.42746422e-02f, -6.12382963e-02f, -4.35809828e-02f, -1.12063877e-01f, 5.01515381e-02f,
  -7.15229511e-02f, -3.39152552e-02f, -6.13650009e-02f, 1.50252119e-01f, -7.06756487e-02f, 3.89816053e-02f, 1.47417992e-01f, 5.60312830e-02f, 6.59021065e-02f, -1.29788145e-01f,
  1.11772820e-01f, -4.43615578e-02f, 1.07230261e-01f, 2.42313952e-03f, -8.15940723e-02f, -9.71391797e-03f, 6.40298128e-02f, -6.51359484e-02f, 4.03535478e-02f, 7.10295662e-02f,
  -4.34616432e-02f, -1.88436344e-01f, 1.01432679e-02f, 2.54679788e-02f, -7.80722573e-02f, 1.95111185e-02f, -6.63765743e-02f, 3.54148634e-02f, -1.02179646e-01f, -5.41446395e-02f,
  3.64889130e-02f, 4.57914174e-02f, 6.93212524e-02f, 3.73802111e-02f, -7.11226389e-02f, -4.04611602e-02f, 6.81962222e-02f, -6.75035790e-02f, -9.30680633e-02f, -8.45225602e-02f,
  1.45462863e-02f, -5.32926433e-02f, 7.96878859e-02f, 9.80516449e-02f, 5.50154001e-02f, -3.18552852e-02f, 3.59523818e-02f, 3.35632786e-02f, -2.38285065e-02f, 1.48049723e-02f,
  3.53161693e-02f, -5.49845211e-02f, -6.21018149e-02f, 1.95569303e-02f, -3.70841585e-02f, 3.90207879e-02f, -7.98105169e-03f, 6.44171834e-02f, 5.41876182e-02f, 5.88851199e-02f,
  1.84447300e-02f, -5.32800183e-02f, -4.53342013e-02f, 8.16941857e-02f, 5.18180057e-02f, -7.99738467e-02f, -5.08559495e-02f, 9.35914088e-03f, -4.03247811e-02f, 9.59815532e-02f,
  3.21423635e-02f, 7.35000893e-02f, 3.75608355e-02f, 5.24434866e-03f, -8.36138725e-02f, -5.65526150e-02f, -6.21828623e-02f, 9.89247486e-03f, 2.35408824e-03f, -8.02634209e-02f,
  -1.81839243e-01f, -1.72553599e-01f, -1.96618978e-02f, -9.15225670e-02f, 1.54051110e-02f, -2.95922905e-02f, 2.45435033e-02f, 6.51034787e-02f, 1.39433388e-02f, -5.56281805e-02f,
  -6.55747652e-02f, -5.55767352e-03f, -4.27287482e-02f, -6.05025701e-03f, -6.40159696e-02f, -2.08116397e-02f, -3.67677361e-02f, 7.29912445e-02f, -1.15484521e-01f, 2.25307774e-02f,
  4.14457656e-02f, -7.58479834e-02f, 7.24069998e-02f, -2.45576520e-02f, 5.26021793e-02f, -7.43546709e-02f, 9.20089334e-03f, 3.41816507e-02f, -4.31035124e-02f, 7.77316689e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.34769851e-01f, 2.19862521e-01f, 8.78227726e-02f, 3.38860691e-01f, 3.02057303e-02f, 2.72931278e-01f, -3.82142402e-02f, 6.72020987e-02f, 1.35182485e-01f, -3.29165608e-02f,
  1.93195209e-01f, 9.96096581e-02f, 1.66487053e-01f, 1.10021964e-01f, 2.06576809e-01f, 7.05200732e-02f, 7.00629354e-02f, 9.64487791e-02f, 1.63994461e-01f, -4.52533588e-02f,
  -2.72818413e-02f, 2.06651136e-01f, 2.49053657e-01f, 2.37581342e-01f, 1.79583296e-01f, 2.12578490e-01f, 2.07926616e-01f, 2.34117582e-01f, 6.03568368e-02f, 1.77047282e-01f,
  1.04686998e-01f, 6.63369149e-02f, 8.36727023e-02f, 3.67075652e-02f, 1.21683605e-01f, 1.08728409e-01f, 6.27588630e-02f, 3.80914882e-02f, -1.74640492e-02f, 8.32286701e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.30456921e-03f, -5.91517948e-02f, 1.91018909e-01f, -3.78135629e-02f, -4.52595316e-02f, 1.43506855e-01f, 6.89530373e-02f, -8.30915645e-02f, 4.70818952e-02f, 1.11372665e-01f,
  1.90165550e-01f, -1.05647326e-01f, 1.04712538e-01f, 5.50072044e-02f, 6.17909990e-02f, 1.34100154e-01f, -2.04619572e-01f, 1.73945889e-01f, -3.94747034e-02f, 1.09622546e-01f,
  1.53396428e-01f, 4.90938723e-02f, -8.35999772e-02f, 1.64370522e-01f, 4.97994944e-02f, -1.37870297e-01f, 1.16481975e-01f, -1.69821158e-01f, -2.01606944e-01f, 7.06520006e-02f,
  -1.33252397e-01f, -1.61852762e-01f, 2.92457771e-02f, -1.06985703e-01f, 9.13027301e-02f, -1.60725806e-02f, -1.05668627e-01f, 2.67873019e-01f, -3.34726982e-02f, -1.33533239e-01f,
  1.19727701e-01f, 5.01515493e-02f, -1.99811071e-01f, -4.14514691e-02f, -1.68718338e-01f, -2.64921874e-01f, 2.95122236e-01f, -1.28800273e-01f, -7.64443353e-02f, 5.18340059e-02f,
  4.12656739e-02f, 3.05810627e-02f, 1.42324492e-01f, 1.39130667e-01f, 2.45465562e-01f, 9.33913812e-02f, 8.35973546e-02f, -1.63487960e-02f, -1.05093889e-01f, 8.55221301e-02f,
  5.17006554e-02f, 4.03575189e-02f, 8.45875219e-03f, -4.03949022e-02f, -1.82158977e-01f, -1.79006845e-01f, 1.04864344e-01f, -4.36924957e-02f, -1.49831638e-01f, -6.85703754e-03f,
  1.52474374e-01f, -9.00035277e-02f, -2.08867565e-01f, -2.64078495e-03f, 1.68975875e-01f, 8.63917470e-02f, -4.12379466e-02f, 2.50373688e-02f, 1.63916185e-01f, -9.10264999e-02f,
  8.28678384e-02f, -9.63500813e-02f, -2.94966429e-01f, 2.45939285e-01f, 2.32437164e-01f, -7.25362897e-02f, -1.55378744e-01f, -1.14616364e-01f, 8.45791996e-02f, -1.67215854e-01f,
  9.18015540e-02f, -1.76359594e-01f, -1.37997568e-01f, -3.64096984e-02f, -5.06084524e-02f, 5.36389649e-02f, -2.32175682e-02f, -7.26366788e-03f, 5.02035618e-02f, 4.82518598e-02f,
  9.64705199e-02f, 1.01298451e-01f, -6.74487557e-03f, -2.27793813e-01f, 1.25144929e-01f, -1.54470295e-01f, 6.36244342e-02f, 9.69997123e-02f, -6.11666888e-02f, -6.94078431e-02f,
  2.45941311e-01f, -5.39912470e-03f, 7.08354786e-02f, 1.23163462e-01f, -1.05704524e-01f, 8.42372850e-02f, -1.87252518e-02f, -2.46528268e-01f, 2.18430579e-01f, -1.89193979e-01f,
  1.96375437e-02f, 8.80208164e-02f, -1.81693733e-02f, 1.74045160e-01f, -8.71575177e-02f, -2.05797981e-02f, 4.13168184e-02f, 1.97178647e-01f, 3.27491835e-02f, 4.38422197e-04f,
  -5.52592203e-02f, 5.32086119e-02f, 5.93802556e-02f, -9.75002199e-02f, -8.43121707e-02f, 3.23753394e-02f, 6.59537362e-03f, -1.79714710e-01f, -6.29317984e-02f, -1.55443788e-01f,
  -1.66679278e-01f, 1.17404297e-01f, -3.14116061e-01f, 2.23439366e-01f, -4.86002490e-02f, 5.04781865e-03f, 1.07865229e-01f, -1.88991785e-01f, -1.76790610e-01f, -6.34259805e-02f,
  -3.26731384e-01f, -1.75166994e-01f, -7.23865107e-02f, 1.89744189e-01f, -1.61380604e-01f, -2.66227514e-01f, 1.82077631e-01f, -1.01241656e-01f, -4.16123755e-02f, -1.05508804e-01f,
  2.00745255e-01f, 1.68111458e-01f, 1.12911001e-01f, -1.17499821e-01f, 1.02812603e-01f, -1.03411034e-01f, 9.36011225e-02f, 1.64443359e-01f, 9.83557329e-02f, 1.09979048e-01f,
  -1.23686291e-01f, -3.54995541e-02f, 1.33632809e-01f, 2.54687846e-01f, 2.35971600e-01f, -1.31938726e-01f, -1.57906547e-01f, -2.48548184e-02f, 9.77408886e-02f, 1.52457692e-02f,
  -1.47639038e-02f, 2.10013404e-01f, -2.09093280e-02f, -9.13165659e-02f, -1.71510741e-01f, 3.14755850e-02f, -5.63175827e-02f, 1.90459993e-02f, 9.20849890e-02f, 2.72181127e-02f,
  -3.46725099e-02f, 5.64287081e-02f, 7.22891092e-02f, 9.75509360e-02f, 4.71642539e-02f, 1.22301981e-01f, -7.78844655e-02f, -4.01772708e-02f, -4.66379486e-02f, 7.23671680e-03f,
  -3.00961342e-02f, 7.80966803e-02f, -1.04571125e-02f, 1.48447111e-01f, -2.94029526e-02f, 9.38770995e-02f, 6.85170814e-02f, 1.05881728e-01f, 1.48651123e-01f, 1.96193010e-01f,
  -3.57776701e-01f, 6.91807792e-02f, 6.41830564e-02f, -8.28213692e-02f, 2.75594771e-01f, 1.51357725e-02f, 2.92314202e-01f, -1.12987772e-01f, -3.37525457e-02f, 1.09106675e-01f,
  -1.57903701e-01f, 2.80731115e-02f, -1.05013885e-03f, 7.65330791e-02f, -1.40507922e-01f, -1.61236569e-01f, -1.65641621e-01f, 7.08639026e-02f, -1.28907979e-01f, -7.83788860e-02f,
  -8.69959667e-02f, -2.14516327e-01f, -7.45006353e-02f, 6.66918606e-02f, 2.49540992e-02f, 1.07574888e-01f, -1.13684669e-01f, -7.65792206e-02f, -1.57135166e-02f, -4.35616709e-02f,
  4.66863476e-02f, 1.87388524e-01f, -4.03745973e-04f, 2.24748686e-01f, -3.13673206e-02f, -1.22022592e-01f, -9.00196433e-02f, -1.46614060e-01f, 5.34561388e-02f, 9.13290605e-02f,
  3.27886268e-02f, 1.82009980e-01f, -1.48439799e-02f, 3.61824892e-02f, -5.38201295e-02f, 7.53819570e-02f, -1.24334004e-02f, 1.13235243e-01f, 9.82546732e-02f, -6.42805994e-02f,
  -4.20137867e-02f, -3.87420096e-02f, 2.58889962e-02f, -3.80234532e-02f, -4.84146811e-02f, 2.32487410e-01f, 1.40324190e-01f, 7.09270313e-02f, 1.99221019e-02f, -1.89535022e-02f,
  2.49889329e-01f, -2.44665593e-01f, 2.31187530e-02f, 1.00454450e-01f, 1.10053560e-02f, 1.00156128e-01f, 1.16569541e-01f, 2.57726640e-01f, 1.37807593e-01f, 1.64061010e-01f,
  1.75751269e-01f, -5.57519868e-02f, 6.83211312e-02f, 1.20196134e-01f, -1.68413892e-01f, 1.84945739e-03f, -1.35106802e-01f, 1.13062756e-02f, -9.51331854e-02f, -9.86135453e-02f,
  1.07098033e-03f, 8.95314217e-02f, 7.78128505e-02f, -9.16066840e-02f, -2.16643527e-01f, -9.19960961e-02f, -9.29045081e-02f, 2.42987007e-01f, 1.68436736e-01f, 1.22230358e-01f,
  -1.21945083e-01f, -1.70746103e-01f, -1.11942634e-01f, 1.94180869e-02f, 1.79406032e-01f, -1.74097717e-01f, -2.43438289e-01f, 1.22825205e-01f, 6.06292151e-02f, 2.14421809e-01f,
  1.83069319e-01f, -1.63149391e-03f, 5.25102094e-02f, 2.23570820e-02f, -8.60038400e-02f, -8.09200481e-02f, -1.18340272e-03f, 1.88429996e-01f, -1.03803627e-01f, 2.54929159e-02f,
  -6.71863407e-02f, 1.33585498e-01f, 2.04532444e-02f, 2.25149672e-02f, 3.07666268e-02f, -4.48001586e-02f, -2.90190969e-02f, -3.85026564e-03f, 1.15232140e-01f, 1.93946213e-01f,
  8.88869073e-03f, 2.27720112e-01f, 1.59765780e-01f, 8.60650986e-02f, 6.65190518e-02f, -2.35521197e-01f, 7.67469127e-03f, -4.41864580e-02f, -1.43544808e-01f, -8.54279026e-02f,
  9.18542594e-02f, -3.17382440e-02f, 2.30590940e-01f, -9.49097946e-02f, 2.99728401e-02f, 6.65825456e-02f, -2.48873364e-02f, 3.62629086e-01f, -1.43215522e-01f, 8.70134383e-02f,
  -6.85258731e-02f, 1.71063170e-02f, -5.10717817e-02f, -7.85514265e-02f, -2.50500500e-01f, -4.65805084e-02f, -8.78066581e-04f, -2.86533266e-01f, -4.08862419e-02f, -3.96116339e-02f,
  -1.06365547e-01f, -1.86316267e-01f, 1.73309475e-01f, 1.58221990e-01f, -3.79251689e-02f, -1.13394201e-01f, -1.83888912e-01f, 1.20869584e-01f, 4.85410430e-02f, 6.24027736e-02f,
  1.04408525e-02f, 1.75837114e-01f, -1.64942011e-01f, -1.72667846e-01f, -8.23683515e-02f, 6.51654825e-02f, 1.24728885e-02f, -5.56419306e-02f, 6.93107620e-02f, 1.37882065e-02f,
  -1.01753086e-01f, -3.72038446e-02f, 2.90564038e-02f, -4.47115190e-02f, -1.03975177e-01f, -2.51234788e-03f, 4.15660515e-02f, 3.99517789e-02f, 1.24851659e-01f, 3.85570526e-02f,
  -2.66302843e-02f, -2.98269391e-02f, 1.16819985e-01f, 7.08410740e-02f, -4.51846421e-02f, 8.86453390e-02f, -2.12523453e-02f, -1.87905982e-01f, 1.35086909e-01f, -7.67245963e-02f,
  3.90818268e-02f, 8.45168345e-03f, -5.64912800e-03f, 1.17612690e-01f, 1.91995770e-01f, -7.87026435e-02f, 1.64451182e-01f, 7.51976073e-02f, 7.62340799e-02f, -1.69232413e-01f,
  2.52586156e-02f, 2.53219396e-01f, 3.98271345e-03f, 8.42645690e-02f, 8.94135423e-03f, -2.70053186e-02f, 5.49452342e-02f, 1.09436959e-01f, -3.35348062e-02f, 8.69581401e-02f,
  -1.33877560e-01f, -1.83263496e-01f, -1.60910003e-02f, -1.35638610e-01f, -2.27327719e-02f, -6.33407980e-02f, -1.39860928e-01f, -3.43643613e-02f, 2.93880422e-02f, -1.33239985e-01f,
  -1.35171250e-01f, -4.99647781e-02f, -2.19423175e-02f, -1.71506613e-01f, 1.66253373e-01f, 1.43370613e-01f, -4.58514690e-02f, 4.20568846e-02f, 5.82584180e-02f, -4.61786911e-02f,
  3.95141393e-02f, -2.42208596e-02f, -5.31116351e-02f, -8.10723677e-02f, 1.24705575e-01f, 9.35832504e-03f, 6.99211583e-02f, -1.40968218e-01f, 6.36357367e-02f, -1.77353442e-01f,
  3.30378041e-02f, -1.78843411e-03f, 1.63416751e-02f, -1.24361157e-01f, -5.81085728e-03f, -3.12992893e-02f, 5.43592758e-02f, 1.41431332e-01f, 9.25643556e-03f, -1.18499696e-01f,
  -1.11489020e-01f, 2.44433228e-02f, 5.69433011e-02f, -3.37659381e-02f, -2.02551261e-01f, -3.06727551e-02f, 2.25486353e-01f, 5.09478450e-02f, 8.80708098e-02f, 1.43822774e-01f,
  -1.46891028e-01f, 2.65969455e-01f, 1.51770040e-01f, 9.45605263e-02f, -3.63516472e-02f, -1.68813363e-01f, 7.33566955e-02f, 1.96099415e-01f, 4.56198491e-02f, 7.24095106e-02f,
  -2.13341303e-02f, -1.40566062e-02f, 1.15043640e-01f, 8.61701444e-02f, -1.29579231e-01f, -1.18375339e-01f, -1.80948302e-01f, 1.00680761e-01f, -2.81885583e-02f, 1.26195684e-01f,
  -1.82025395e-02f, -9.42033306e-02f, 9.25595034e-03f, -8.30021780e-03f, -6.92173988e-02f, -2.03460343e-02f, 8.17680284e-02f, -2.56734371e-01f, -1.39540210e-01f, 2.56118607e-02f,
  -5.73653057e-02f, 2.65293159e-02f, 1.69568107e-01f, 1.95514038e-03f, -1.89525843e-01f, 5.74240088e-02f, -7.72706196e-02f, -1.63797900e-01f, 2.02758219e-02f, 2.42963843e-02f,
  -1.64489374e-01f, 1.56822756e-01f, -1.42787083e-03f, 4.86380421e-02f, -9.39071365e-03f, 6.34869188e-02f, 8.03639297e-04f, 1.77512407e-01f, 6.44989908e-02f, -6.56987801e-02f,
  4.53224033e-03f, 1.58370540e-01f, 1.06099822e-01f, 1.84879318e-01f, -1.80884376e-02f, -2.04600006e-01f, 1.26673505e-01f, -2.13762522e-01f, -1.28384456e-01f, 1.59439027e-01f,
  2.12647378e-01f, 7.71981999e-02f, 1.98346421e-01f, 2.47424226e-02f, 2.60984182e-01f, 6.77911863e-02f, -9.67570394e-02f, -1.07129671e-01f, -8.90016370e-03f, 1.54802129e-01f,
  1.56086296e-01f, -3.91672067e-02f, -1.41905665e-01f, -1.25078350e-01f, -1.31486148e-01f, 8.34165066e-02f, -1.33807555e-01f, -6.99639618e-02f, -1.72546878e-01f, -2.50031978e-01f,
  -1.31919220e-01f, 1.37590736e-01f, 3.44636291e-02f, -1.22746497e-01f, -1.93834767e-01f, 1.23188905e-01f, -8.57191905e-02f, 1.07284198e-02f, -1.69442460e-01f, -1.49158850e-01f,
  3.94750899e-03f, -1.35086253e-01f, 3.14915515e-02f, -2.10347131e-01f, 3.18540521e-02f, 1.47585526e-01f, 1.99095741e-01f, 2.10598022e-01f, 8.34226608e-02f, 6.33287579e-02f,
  7.34637380e-02f, -1.81327894e-01f, -1.50352195e-01f, -4.42282334e-02f, -4.19722609e-02f, -7.07578361e-02f, 2.38095224e-02f, -4.66801114e-02f, 1.63377866e-01f, 1.11005515e-01f,
  3.27775031e-02f, 2.06152946e-02f, 4.36661616e-02f, -6.72391057e-02f, -4.61031348e-02f, 2.54296035e-01f, 1.06247067e-01f, 1.51211128e-01f, 1.79104656e-01f, -3.15482579e-02f,
  1.10857084e-01f, -1.38030156e-01f, 5.12401015e-02f, -7.23918527e-02f, 1.46016032e-01f, 9.69843045e-02f, -3.46270623e-03f, 2.26803049e-01f, -1.61948681e-01f, -1.15764119e-01f,
  -1.06405020e-01f, 1.05843201e-01f, 1.47751957e-01f, 1.28564283e-01f, 1.11397952e-01f, -6.40804321e-02f, -3.97003554e-02f, -9.22525709e-04f, 9.16580409e-02f, -1.46938665e-02f,
  1.63878679e-01f, -1.30570114e-01f, 2.14503735e-01f, -3.09244525e-02f, -7.47239962e-02f, 5.46230413e-02f, -3.12633859e-03f, -1.76435322e-01f, 2.73209184e-01f, 1.47895083e-01f,
  8.48346949e-02f, 1.92318279e-02f, -1.78904846e-01f, 8.57951641e-02f, -3.14836344e-03f, -2.64627151e-02f, -2.09776655e-01f, -1.41704962e-01f, -1.47762030e-01f, -1.94468215e-01f,
  1.60307080e-01f, 5.90597652e-02f, 1.58206195e-01f, -7.84132630e-02f, 1.06885619e-01f, -1.66042503e-02f, -6.29458353e-02f, 7.25521594e-02f, 9.16663855e-02f, -7.71488026e-02f,
  9.66071561e-02f, 2.32049618e-02f, 2.36548316e-02f, 7.70221949e-02f, 8.07129070e-02f, -1.00732505e-01f, 8.50241072e-03f, -5.14727691e-03f, 4.94231060e-02f, -1.44360185e-01f,
  -6.21107817e-02f, -3.79651412e-02f, -5.09208255e-02f, 1.69415716e-02f, -2.42971256e-02f, -1.34561537e-02f, 1.51421115e-01f, -2.79952283e-03f, 1.34555832e-01f, -3.47148329e-02f,
  -3.14244837e-01f, 2.38719299e-01f, -2.44175971e-01f, -1.66895762e-01f, -2.30894253e-01f, 2.52240360e-01f, -1.09028935e-01f, -1.62458077e-01f, 5.09306006e-02f, -1.28434356e-02f,
  3.59615423e-02f, 3.16533558e-02f, 7.32079521e-02f, 9.95046496e-02f, -7.83413127e-02f, 3.35193016e-02f, 1.37215585e-01f, 1.85266003e-01f, -3.34972795e-03f, 1.75465673e-01f,
  1.19705051e-01f, -3.92520130e-02f, 1.85774818e-01f, 1.09859124e-01f, 7.90494978e-02f, 2.32275113e-01f, -2.00398266e-01f, -3.80891226e-02f, -1.02943964e-01f, 9.51795131e-02f,
  -1.34998625e-02f, -2.09721029e-01f, 1.60030261e-01f, 4.49394509e-02f, -4.49731201e-03f, -2.95647271e-02f, -8.69934931e-02f, -6.13006614e-02f, 6.75610378e-02f, -1.47672310e-01f,
  -4.89606671e-02f, 8.37032348e-02f, -4.37109992e-02f, 1.43357113e-01f, 5.10524772e-03f, 3.09439935e-02f, -7.74820819e-02f, -1.02342471e-01f, -1.84114009e-01f, -1.81719646e-01f,
  3.66211720e-02f, -2.70933770e-02f, -8.26590955e-02f, -1.41297290e-02f, -2.87785865e-02f, -8.79677236e-02f, -1.30265623e-01f, 1.75220132e-01f, 1.14651635e-01f, 2.85488874e-01f,
  2.04968434e-02f, -1.30073562e-01f, -1.19376540e-01f, 1.50973856e-01f, -7.52867460e-02f, 1.25614733e-01f, -1.43599987e-01f, 6.71035796e-02f, 1.40792772e-01f, 3.89402211e-02f,
  -5.92329800e-02f, -2.01997533e-01f, -8.30391720e-02f, 1.29483957e-02f, 5.98535948e-02f, 1.18308365e-01f, -3.34701687e-02f, -3.61894593e-02f, 4.40185070e-02f, 6.24208450e-02f,
  -1.27304599e-01f, 2.33478963e-01f, -2.64878711e-03f, 2.06987448e-02f, 7.19617233e-02f, 2.65161455e-01f, -1.03863992e-01f, -3.42989631e-04f, -1.46084726e-01f, -1.47350729e-01f,
  -3.21743079e-02f, 1.15249604e-01f, -5.52528072e-03f, -7.86208957e-02f, -1.66998476e-01f, 4.44525816e-02f, 3.18667553e-02f, -1.31950201e-02f, -2.10404336e-01f, -1.11752339e-02f,
  -1.59606114e-02f, 1.67028662e-02f, -7.76209980e-02f, -1.74623847e-01f, 7.03654140e-02f, 1.52761936e-01f, 6.79644942e-02f, 9.45898443e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.74980080e-02f, 2.46101264e-02f, -5.58703579e-02f, 2.28555836e-02f, 1.09439678e-01f, 6.42144307e-02f, 1.81361780e-01f, 1.13445386e-01f, 1.10326642e-02f, 7.82377794e-02f,
  1.54432088e-01f, 1.42224744e-01f, 1.78149059e-01f, -9.77729633e-02f, 1.39476925e-01f, -2.08195180e-01f, 1.13737345e-01f, 1.56946048e-01f, 8.01706538e-02f, 2.17096526e-02f,
  5.34708947e-02f, 8.36278945e-02f, 8.73978510e-02f, 1.96227849e-01f, -7.62965828e-02f, -7.97028914e-02f, 3.22676376e-02f, 1.64287105e-01f, 1.20404258e-01f, -2.91118417e-02f,
  -8.15983303e-03f, 9.32379887e-02f, -9.48072746e-02f, -5.42138703e-02f, 1.25382438e-01f, 1.27470151e-01f, -7.07367510e-02f, 1.36147663e-01f, -1.06101312e-01f, -1.14576347e-01f,
  -1.16468087e-01f, -7.47282803e-02f, -1.78451553e-01f, -1.26802782e-02f, 1.10607110e-01f, -4.23887148e-02f, 1.86293777e-02f, 9.70227420e-02f, -1.62149388e-02f, -1.80532169e-02f,
  3.26556079e-02f, -1.97704419e-01f, -1.91180836e-02f, 6.21254668e-02f, 2.23868579e-01f, 1.27013460e-01f, -1.17178150e-01f, 9.16838869e-02f, -1.66914298e-03f, 2.58980058e-02f,
  -3.47025655e-02f, -3.21139470e-02f, -4.69789654e-02f, 9.55941454e-02f, 7.35164583e-02f, 4.52848561e-02f, -8.76323059e-02f, 1.26062065e-01f, -1.39976963e-02f, 7.02503622e-02f,
  -7.76888207e-02f, 1.35029510e-01f, -3.98814641e-02f, 1.35040730e-01f, 3.85123119e-02f, -3.67848910e-02f, 8.32539648e-02f, 8.95122811e-02f, -1.08737640e-01f, 1.22346804e-01f,
  -7.25912750e-02f, -1.11743718e-01f, 1.65124848e-01f, 1.38466330e-02f, -1.71983570e-01f, -1.06940947e-01f, 7.11146370e-02f, -8.53104964e-02f, -8.44608471e-02f, 1.55701205e-01f,
  -3.33631486e-02f, 6.60495088e-02f, 7.33433440e-02f, 7.37464353e-02f, 5.02787158e-02f, 7.22081214e-02f, -7.22097084e-02f, -4.11471613e-02f, 1.31879807e-01f, -5.25060948e-03f,
  -8.98873508e-02f, 1.07948616e-01f, 1.64160937e-01f, -3.19772772e-02f, 1.34796977e-01f, 1.11293662e-02f, 1.09700719e-02f, -9.33342651e-02f, -1.51028717e-02f, 9.08822268e-02f,
  -5.75727485e-02f, -3.43153216e-02f, -2.95073055e-02f, 7.30213821e-02f, 7.19162673e-02f, -1.13678008e-01f, 8.89991038e-03f, 1.07160129e-01f, 4.42048796e-02f, 3.02326772e-03f,
  -1.36505246e-01f, -9.61492211e-02f, 7.65097961e-02f, -2.18472406e-02f, 5.03302785e-03f, 6.44857064e-02f, 1.69931923e-03f, 4.81183454e-02f, -3.19377631e-02f, 2.27890298e-04f,
  -7.76257515e-02f, -9.13079083e-02f, 9.84092057e-02f, 2.64504850e-02f, -8.23943764e-02f, 2.59367074e-03f, 6.40479103e-02f, 3.70944999e-02f, -7.96225816e-02f, -1.01500802e-01f,
  -3.93959284e-02f, 8.68588313e-02f, -6.04471564e-02f, -1.72254488e-01f, -2.11379677e-02f, 4.24949266e-02f, -1.39073178e-01f, 2.54772473e-02f, -5.49884960e-02f, 1.35572910e-01f,
  -2.18463894e-02f, -4.38327231e-02f, -8.48149806e-02f, 1.31252080e-01f, 1.32697120e-01f, 8.42763707e-02f, 9.73020867e-02f, 1.24902576e-01f, -9.67829898e-02f, -7.80803338e-02f,
  1.20586663e-01f, -8.48279819e-02f, 1.43801821e-02f, 1.64532233e-02f, 1.33186057e-01f, 1.12269841e-01f, 1.60723906e-02f, -9.07166153e-02f, 1.05929747e-01f, -3.49488854e-02f,
  2.65336603e-01f, 1.12856049e-02f, 7.94329420e-02f, 1.34371454e-02f, -6.58465549e-02f, -2.50459816e-02f, -6.97950870e-02f, -1.16534807e-01f, 9.09981802e-02f, 9.08259228e-02f,
  -4.39187512e-02f, 1.61476117e-02f, 1.28873035e-01f, -3.77945718e-03f, -1.77859738e-02f, 6.31784648e-02f, -4.66978289e-02f, 3.20101529e-02f, -2.08325740e-02f, 3.07958350e-02f,
  1.06981046e-01f, 2.25540977e-02f, 5.96013665e-02f, 7.28236660e-02f, 6.78034052e-02f, 4.78038415e-02f, 1.26752615e-01f, 2.13047743e-01f, -1.58226285e-02f, 9.70098004e-02f,
  -2.30660457e-02f, 1.16371043e-01f, 1.07026316e-01f, 5.31879365e-02f, 2.92692482e-01f, -4.17186432e-02f, 1.21872135e-01f, -2.01555595e-01f, -2.03856438e-01f, 1.07056648e-01f,
  8.74569193e-02f, 1.31973829e-02f, 2.01172591e-03f, 1.39613762e-01f, 9.71933305e-02f, 2.63747334e-01f, -1.17138043e-01f, -1.89496204e-02f, 1.84582233e-01f, 1.00726388e-01f,
  -1.10836029e-02f, -2.68203728e-02f, -1.15544572e-01f, -1.36469584e-02f, -9.37326625e-02f, -1.11369178e-01f, 1.55427471e-01f, 1.50116771e-01f, -3.55093740e-02f, 2.70181239e-01f,
  1.43985644e-01f, -7.30442852e-02f, 5.09544201e-02f, 2.11801797e-01f, -2.18081236e-01f, -4.20160815e-02f, 7.03859096e-03f, -1.24241114e-01f, -7.33038336e-02f, 2.68080160e-02f,
  1.17470510e-01f, 8.85943621e-02f, 2.75827870e-02f, -5.85222840e-02f, 2.19327867e-01f, 7.67826512e-02f, 3.27444784e-02f, 2.49672249e-01f, -2.92383078e-02f, -6.43716604e-02f,
  1.56183437e-01f, 3.07222325e-02f, -1.22570954e-01f, -6.78308383e-02f, -5.03613800e-02f, -5.05970493e-02f, 1.40604421e-01f, -6.21552095e-02f, -5.06365346e-03f, -1.00165680e-01f,
  -2.91687790e-02f, -3.13832611e-03f, -8.96460265e-02f, 8.01089481e-02f, -8.84402767e-02f, -2.26353649e-02f, -4.89981137e-02f, 8.70916620e-02f, -1.69938076e-02f, 4.59176153e-02f,
  4.57929447e-02f, -1.88697204e-02f, 5.01139276e-03f, 6.87273405e-03f, 1.62385479e-02f, 1.10826805e-01f, -4.39724252e-02f, 9.11215916e-02f, 1.34282231e-01f, -1.26199331e-02f,
  -1.12664744e-01f, 1.58461314e-02f, 1.03016309e-02f, 1.26170218e-01f, -1.10974520e-01f, -4.85226233e-03f, 6.78980798e-02f, -1.12756513e-01f, -1.79683473e-02f, 4.42247242e-02f,
  1.38317803e-02f, -2.40276381e-02f, 6.10386245e-02f, 5.33811487e-02f, -1.99071709e-02f, -2.22746097e-02f, -2.03901716e-02f, -3.40974033e-02f, 8.62611085e-02f, -6.70872256e-02f,
  -8.18925872e-02f, 1.76561046e-02f, -6.43719435e-02f, -1.04567379e-01f, 1.27434269e-01f, 8.64676163e-02f, -7.45844468e-02f, 2.92334948e-02f, -6.38252050e-02f, 8.34698528e-02f,
  4.01068255e-02f, -6.25875816e-02f, -1.01701654e-01f, 6.28668591e-02f, -3.13419029e-02f, -3.81708220e-02f, -7.75879472e-02f, 1.23050168e-01f, -9.85510722e-02f, -1.22814655e-01f,
  1.05793789e-01f, 2.00690664e-02f, 1.46774814e-01f, -1.91977490e-02f, -2.26353314e-02f, 6.02336861e-02f, -7.70588964e-02f, -7.47326016e-02f, 1.07418425e-01f, -5.89754283e-02f,
  -5.48740337e-03f, 4.15631086e-02f, 1.19574621e-01f, -1.22671828e-01f, -1.09595142e-01f, -2.06722021e-02f, -7.85925835e-02f, 5.79505265e-02f, -3.75107154e-02f, 7.01559186e-02f,
  4.70193326e-02f, 1.64157435e-01f, -3.30863446e-02f, -4.98124659e-02f, 6.60883859e-02f, -9.77103561e-02f, -1.81693844e-02f, 3.83735225e-02f, -6.70838207e-02f, 1.98013876e-02f,
  1.17914323e-02f, 2.14046780e-02f, 9.60940346e-02f, -2.25891862e-02f, 3.78794260e-02f, 7.84179345e-02f, 4.62082215e-02f, 1.28560439e-01f, -1.23871700e-03f, -1.18672974e-01f,
  1.01598643e-01f, -1.24951480e-02f, -5.15504479e-02f, -9.90456641e-02f, -8.10635835e-02f, -7.36456588e-02f, 1.19341649e-01f, -8.86435136e-02f, 1.61034241e-01f, -5.72891496e-02f,
  -2.48961672e-02f, -3.59536782e-02f, 9.72738564e-02f, -3.87931764e-02f, 2.96266694e-02f, 8.61654878e-02f, 1.48941860e-01f, -3.88797447e-02f, 4.05742377e-02f, 3.69671471e-02f,
  -6.84266165e-02f, 7.20953792e-02f, 8.78111944e-02f, 8.95842388e-02f, -5.94603047e-02f, 4.14264351e-02f, 8.34864080e-02f, 1.38445571e-01f, 1.45372674e-01f, -8.26784819e-02f,
  -6.93219155e-02f, -6.02226481e-02f, -3.71982493e-02f, -6.55099936e-03f, 5.72215803e-02f, -7.41587207e-02f, 1.15505062e-01f, 1.06078453e-01f, 1.27251819e-01f, 1.94750261e-02f,
  -1.41805962e-01f, -8.53870660e-02f, -2.83003747e-02f, -1.28577009e-01f, -3.94883193e-02f, 1.47042856e-01f, 1.17413096e-01f, 3.68058309e-02f, 5.11028580e-02f, -1.10775270e-01f,
  -8.69152397e-02f, -7.23906830e-02f, -7.38403499e-02f, 1.49873868e-01f, -6.07464798e-02f, -6.54338524e-02f, 1.15832813e-01f, -1.16315469e-01f, 3.59940752e-02f, -5.80651425e-02f,
  -4.22274247e-02f, 1.28968388e-01f, -7.74930045e-02f, -1.28352651e-02f, 5.37149608e-02f, 1.30551839e-02f, -4.15434726e-02f, 1.62231997e-02f, -1.23541079e-01f, -1.08257920e-01f,
  -1.35498419e-01f, 1.31008118e-01f, -8.37159082e-02f, -1.00518204e-02f, 6.01007789e-02f, 4.72142287e-02f, 7.69334510e-02f, 1.01185657e-01f, 5.25159761e-02f, 7.26284683e-02f,
  -2.31847633e-02f, 3.65169980e-02f, 8.52397904e-02f, -1.04930766e-01f, -6.74024150e-02f, 1.50273308e-01f, 8.76779482e-02f, 5.20163067e-02f, 4.42738980e-02f, -3.67497168e-02f,
  -5.47885336e-03f, 9.55614075e-02f, -9.88073274e-02f, 2.11779755e-02f, 1.39731467e-01f, -5.71660325e-02f, -1.19212091e-01f, 1.96831331e-01f, 1.64768502e-01f, -7.31424466e-02f,
  -1.62020549e-02f, 1.31023405e-02f, -4.89331707e-02f, 4.53884201e-03f, 7.12587908e-02f, 3.23421657e-02f, -3.15826014e-02f, 8.82869065e-02f, 1.52456850e-01f, 9.33406204e-02f,
  -5.66708781e-02f, 3.87286767e-02f, -1.37323841e-01f, -1.14250176e-01f, 7.45359585e-02f, -1.80150658e-01f, -5.77257462e-02f, -9.07058269e-02f, -1.00000888e-01f, 9.24555585e-02f,
  -2.42796522e-02f, -8.71211588e-02f, 9.97853056e-02f, 6.49679005e-02f, 1.57025442e-01f, -7.16296360e-02f, -1.30361527e-01f, 1.12441175e-01f, 8.80994052e-02f, 5.14607765e-02f,
  2.41826661e-02f, -1.43313445e-02f, 1.24856986e-01f, 7.17156827e-02f, 1.03252411e-01f, 7.62886321e-03f, 8.92609730e-02f, 5.08583002e-02f, 8.53456259e-02f, 5.47047332e-02f,
  -8.82093310e-02f, -7.90266618e-02f, 1.18768826e-01f, -3.10204551e-02f, -1.22902095e-02f, 1.08806239e-02f, -2.35161297e-02f, 2.75922827e-02f, 9.31870863e-02f, 1.00580066e-01f,
  -1.06583312e-01f, 1.31036043e-01f, 1.08191580e-01f, 1.30253032e-01f, 1.59787223e-01f, 1.45146102e-01f, 1.75518572e-01f, 1.90868042e-02f, -3.14716175e-02f, 9.09356698e-02f,
  3.61388922e-02f, 8.61808062e-02f, 3.66174877e-02f, -1.51829636e-02f, 1.41267151e-01f, -9.07323733e-02f, -4.35992479e-02f, -1.76439926e-01f, -2.72811174e-01f, 1.45359337e-01f,
  3.01704705e-01f, 6.39214087e-03f, -2.09805369e-01f, 1.19451866e-01f, 2.48127609e-01f, 3.32637727e-01f, -5.15203252e-02f, 3.59443910e-02f, 1.28231049e-01f, 2.11260408e-01f,
  -6.00696588e-03f, 1.82470635e-01f, -7.47775435e-02f, -4.87881526e-02f, -4.10089362e-03f, -3.91634516e-02f, -3.74588324e-03f, 2.60126173e-01f, -1.22461952e-01f, 4.31873977e-01f,
  1.69614293e-02f, 1.91483244e-01f, -7.15497881e-02f, 4.59742665e-01f, -1.28443360e-01f, -7.25592971e-02f, -2.59391461e-02f, 7.52819404e-02f, -2.14934185e-01f, -1.70491403e-03f,
  4.92596207e-03f, -1.24858946e-01f, 2.41960306e-02f, -1.18743658e-01f, 2.03976154e-01f, 3.93992692e-01f, -9.10933018e-02f, 1.72176570e-01f, -1.53460830e-01f, 1.08318277e-01f,
  1.73812181e-01f, 7.25402385e-02f, -3.80679546e-03f, 2.42297173e-01f, 8.31210092e-02f, 1.39889523e-01f, -2.28703395e-02f, 1.66422769e-01f, 6.36901781e-02f, 9.99251083e-02f,
  3.83086912e-02f, 9.64715183e-02f, 1.70945898e-01f, 1.65080130e-01f, 8.77364874e-02f, 1.51001453e-01f, -2.96765682e-03f, 3.27944234e-02f, 3.91272828e-02f, -9.08597112e-02f,
  1.64738998e-01f, -9.31603182e-03f, 4.58053946e-02f, 2.41985414e-02f, -3.48134860e-02f, -8.32552388e-02f, -1.07041508e-01f, -8.67782682e-02f, 1.27522469e-01f, 1.03104673e-02f,
  2.17636093e-01f, -8.94974768e-02f, -3.05904616e-02f, 3.04940999e-01f, 7.11295530e-02f, -6.15046173e-02f, 4.21294607e-02f, 1.27713904e-01f, -1.13938011e-01f, 5.54779507e-02f,
  -8.58190507e-02f, -8.98707435e-02f, -5.49376681e-02f, 5.29591665e-02f, -6.46942258e-02f, -2.68303659e-02f, 9.07807350e-02f, -4.38836478e-02f, 7.83742443e-02f, -1.71847511e-02f,
  9.28917974e-02f, 1.21756447e-02f, -2.10953474e-01f, 1.66715771e-01f, -1.05324117e-02f, 1.93573818e-01f, -3.13811116e-02f, 2.08280385e-01f, -1.37354150e-01f, -1.86615974e-01f,
  -1.37280360e-01f, -8.39044452e-02f, 9.44222137e-02f, -4.13518511e-02f, -4.87288199e-02f, 2.14356910e-02f, -1.07041024e-01f, -3.22123058e-02f, -1.41327847e-02f, -1.18250929e-01f,
  -3.63095850e-02f, -9.99711752e-02f, 8.95425770e-03f, 1.93722144e-01f, 1.92806050e-01f, 7.35809952e-02f, 1.26678631e-01f, -1.94943678e-02f, 7.06664398e-02f, 1.21563219e-01f,
  5.94698749e-02f, 3.04457508e-02f, -1.12092905e-01f, -1.31104395e-01f, 9.46655422e-02f, -6.67206794e-02f, -1.04899287e-01f, -1.96021959e-01f, 4.99932654e-02f, 3.45592618e-01f,
  2.08392560e-01f, -1.66735600e-03f, -3.52241755e-01f, 5.81766032e-02f, -1.48782492e-01f, 7.31856227e-02f, -2.35964898e-02f, -8.78959224e-02f, 1.93763509e-01f, -1.30839229e-01f,
  7.68396854e-02f, 1.57736138e-01f, 2.50577271e-01f, 1.58951730e-02f, 3.35563749e-01f, -1.26454070e-01f, 2.67779589e-01f, 2.96619534e-01f, 4.82167676e-02f, 1.35610355e-02f,
  8.09451342e-02f, 1.33953139e-01f, -4.73732874e-02f, 1.38263598e-01f, 1.24119647e-01f, 9.93845314e-02f, 9.99057144e-02f, 1.07303433e-01f, -1.40338566e-03f, -5.27759939e-02f,
  -2.38029853e-01f, -5.71922734e-02f, -1.65934432e-02f, -1.20160483e-01f, 5.56022488e-02f, 7.74398819e-02f, 3.40059221e-01f, 1.27060577e-01f, -1.39567554e-01f, 6.10779487e-02f,
  1.70591306e-02f, 2.36131791e-02f, 1.48876816e-01f, -6.06200993e-02f, 1.17862664e-01f, -8.85331035e-02f, 5.93340471e-02f, 1.85572788e-01f, 1.17743872e-01f, 6.42208606e-02f,
  2.02019572e-01f, 2.54802480e-02f, -2.61553805e-02f, 2.07233101e-01f, 2.00211823e-01f, 2.95987166e-02f, 1.58657338e-02f, -1.41290575e-01f, 5.07197902e-02f, -2.86186095e-02f,
  2.08972424e-01f, -1.61203876e-01f, -2.06619009e-01f, 1.68074280e-01f, 2.01847136e-01f, -7.26988986e-02f, -2.03730702e-01f, 3.46557274e-02f, -9.48346853e-02f, -1.00801639e-01f,
  1.51331946e-01f, -8.31193775e-02f, -7.12700337e-02f, -5.11976071e-02f, 1.54779941e-01f, 1.14752047e-01f, 7.87367970e-02f, 8.18856880e-02f, 8.37387964e-02f, -3.62953544e-02f,
  9.62123126e-02f, -1.21481657e-01f, -1.43103593e-03f, -8.37987214e-02f, -3.88455228e-03f, -1.36898592e-01f, -6.45149685e-03f, 4.13419269e-02f, 1.88956633e-01f, 2.00579435e-01f,
  3.22603613e-01f, -1.27539665e-01f, 1.14353366e-01f, 1.73387364e-01f, 4.43760566e-02f, -1.31862998e-01f, -6.90572262e-02f, -7.40049258e-02f, 1.67822480e-01f, -3.64934467e-02f,
  -2.16357168e-02f, 4.34624366e-02f, 1.76941618e-01f, 3.97153459e-02f, -7.65363127e-02f, 7.92228580e-02f, -4.37843613e-02f, 2.03902125e-01f, 3.77145521e-02f, -2.52085272e-02f,
  1.54423431e-01f, 1.16110623e-01f, 1.66187868e-01f, -2.58863997e-02f, 1.08729243e-01f, -3.51710580e-02f, -2.40028165e-02f, -1.27796113e-01f, 1.98190585e-01f, 9.35450271e-02f,
  -2.10357338e-01f, 1.38772894e-02f, -4.27829027e-02f, 3.38202268e-01f, -1.81412235e-01f, -9.12157521e-02f, -7.45275337e-03f, -1.58145294e-01f, 2.82084569e-02f, -8.90797898e-02f,
  -8.00616518e-02f, 1.27887890e-01f, 1.92978904e-01f, -1.50650041e-02f, 8.15405175e-02f, -1.51920259e-01f, 7.77936950e-02f, -4.86434922e-02f, 1.32748649e-01f, 2.03380790e-02f,
  1.68283775e-01f, 1.92509532e-01f, -9.94112492e-02f, -1.10223508e-02f, 1.35858744e-01f, -8.76369700e-02f, 1.65313303e-01f, 9.95710939e-02f, 2.52583940e-02f, 1.40075430e-01f,
  -2.71317400e-02f, -9.09301043e-02f, -2.66447589e-02f, 2.42911607e-01f, 3.25638026e-01f, -5.64107373e-02f, 1.10078529e-01f, 1.90827265e-01f, 3.38966660e-02f, 4.26142775e-02f,
  -1.89064760e-02f, 1.09657891e-01f, 2.08093524e-01f, 4.51421551e-02f, -1.44231077e-02f, 2.18486842e-02f, 6.66159466e-02f, 1.93089634e-01f, 1.83788240e-01f, 2.30839327e-02f,
  -8.73783305e-02f, 2.54253466e-02f, 1.62014470e-01f, 1.14898168e-01f, 1.61702245e-01f, 3.93110439e-02f, 4.84152101e-02f, 1.53373688e-01f, 1.51465029e-01f, 1.12540714e-01f,
  8.59221146e-02f, 1.24304049e-01f, -1.49826221e-02f, 1.78654492e-01f, -7.08155409e-02f, -3.35600257e-01f, -1.86882257e-01f, -1.22826360e-01f, 1.50613040e-01f, -1.22635588e-01f,
  1.97921410e-01f, -5.44685088e-02f, 2.50676662e-01f, -2.94713245e-04f, 5.73217720e-02f, -4.99070734e-02f, -1.82495505e-01f, 8.20034742e-03f, 1.40651152e-01f, 2.27420256e-01f,
  3.29828233e-01f, -2.19366178e-01f, 1.33545026e-01f, 2.61929613e-02f, 1.20860927e-01f, 7.82671422e-02f, 2.94236988e-01f, 7.24709854e-02f, 1.94669981e-02f, -6.51689852e-03f,
  2.32210889e-01f, 3.36811692e-02f, -2.91596279e-02f, -1.09569795e-01f, -2.43562952e-01f, -7.13330433e-02f, 2.19607558e-02f, 3.89281452e-01f, 7.02641010e-02f, -7.25815743e-02f,
  1.15044959e-01f, 2.62258708e-01f, -1.31101981e-01f, -2.31764972e-01f, -8.03486481e-02f, 1.19973183e-01f, 1.91192746e-01f, 4.88217622e-02f, 5.32381888e-03f, 1.21917864e-02f,
  1.77384257e-01f, 2.59538740e-01f, -5.55405468e-02f, -1.91156387e-01f, 1.02095738e-01f, 1.46484748e-01f, -1.09768376e-01f, -1.13391995e-01f, -1.73291762e-03f, -4.38976102e-02f,
  -1.29043753e-03f, 1.45687265e-02f, -1.16878249e-01f, -1.01658709e-01f, -1.20235100e-01f, -9.47506651e-02f, 6.81223813e-04f, 2.24866197e-02f, 4.19213297e-03f, 4.77220714e-02f,
  3.78717817e-02f, 1.34271815e-01f, -3.37014273e-02f, -1.04675703e-01f, 5.16188815e-02f, 8.29497874e-02f, 6.40595471e-03f, -3.64223379e-04f, 1.04915142e-01f, -7.24349543e-02f,
  6.20074011e-02f, 1.74279548e-02f, 1.24939725e-01f, 7.46629015e-02f, 1.87968016e-02f, -1.22795224e-01f, 3.17059197e-02f, 7.80126005e-02f, 1.34603977e-02f, 4.38291430e-02f,
  7.03917742e-02f, -4.12048735e-02f, 2.89332774e-02f, 3.75751080e-03f, 1.34903476e-01f, 5.97133674e-02f, 1.62341855e-02f, -5.98777533e-02f, 1.10020012e-01f, -1.22897923e-02f,
  -2.79723126e-02f, 8.73724371e-02f, 1.06924400e-01f, 8.42802227e-02f, -4.13250588e-02f, 1.16484903e-01f, 6.41276315e-02f, -9.97030511e-02f, -1.59558225e-02f, -9.18993610e-04f,
  -1.18351012e-01f, 7.54488036e-02f, -7.86447525e-02f, 9.69841555e-02f, 1.20277449e-01f, 7.14642927e-02f, -5.49701825e-02f, -1.63684543e-02f, 6.09620363e-02f, -8.53303000e-02f,
  1.11459540e-02f, 1.64975151e-01f, -2.24391036e-02f, -2.17577275e-02f, 2.06944793e-02f, 3.51908766e-02f, -1.03242017e-01f, 3.74250929e-03f, -7.09413067e-02f, 2.79067308e-02f,
  1.76162887e-02f, -1.81975290e-02f, -5.11028767e-02f, -1.32398054e-01f, -1.10070214e-01f, -3.84180881e-02f, -1.43278599e-01f, 1.54314702e-02f, 7.99992457e-02f, -5.32550886e-02f,
  -6.43112184e-03f, 1.10198930e-01f, -2.91435756e-02f, 1.12368822e-01f, -2.44596284e-02f, -5.85248172e-02f, 1.44164503e-01f, 1.17369890e-01f, 7.02658370e-02f, -1.24251828e-01f,
  -7.00852275e-02f, 1.15754670e-02f, -4.76586781e-02f, 1.61724299e-01f, 1.03522979e-01f, 4.71097566e-02f, 8.20804238e-02f, -1.09269314e-01f, -4.65571322e-02f, -6.42071478e-03f,
  -1.66742448e-02f, 1.15955614e-01f, 1.14045389e-01f, 1.13664111e-02f, 8.37000608e-02f, -5.35090677e-02f, 2.85060164e-02f, -4.01849635e-02f, 7.42760226e-02f, -9.20359641e-02f,
  5.78318872e-02f, -2.91111544e-02f, 6.52717650e-02f, 1.99663267e-01f, 4.92462032e-02f, 4.21775226e-03f, -1.09184124e-01f, -9.28366855e-02f, 4.40302528e-02f, -3.92655171e-02f,
  -4.47914116e-02f, 4.25273702e-02f, -6.49333671e-02f, 1.45614251e-01f, 9.21425223e-02f, 2.33381674e-01f, 1.08315609e-01f, 1.10934256e-02f, 9.59580243e-02f, 2.29201436e-01f,
  8.22612643e-02f, 1.35780483e-01f, 9.03157704e-03f, 9.78486389e-02f, -5.36616519e-02f, -2.79926658e-02f, 2.12190062e-01f, -9.92461815e-02f, 1.17384769e-01f, -2.76632845e-01f,
  -7.48199522e-02f, 2.04439950e-03f, 1.44326106e-01f, 5.73734753e-02f, -3.68117355e-02f, 2.77446896e-01f, 3.32673080e-02f, 7.38100382e-03f, 1.64886951e-01f, 2.97593866e-02f,
  1.24831513e-01f, 3.68398935e-01f, -4.46131118e-02f, 1.98113963e-01f, -6.92682061e-03f, 1.04261540e-01f, -7.31953084e-02f, 2.10489389e-02f, -8.75661373e-02f, -6.32949769e-02f,
  2.22410783e-02f, 2.56708413e-01f, -6.06857426e-02f, 1.39670879e-01f, 1.59304559e-01f, 2.07489774e-01f, 2.88940161e-01f, 1.69818610e-01f, -4.05469798e-02f, 5.41457459e-02f,
  -3.08791310e-01f, 3.74042034e-01f, 1.74923792e-01f, -9.27839279e-02f, -1.69820815e-01f, 1.73546355e-02f, 9.81402695e-02f, 9.42315981e-02f, -1.82294011e-01f, 8.36128518e-02f,
  -4.15051095e-02f, 7.67395422e-02f, -1.40606314e-01f, -3.92719805e-02f, -4.94744889e-02f, 1.15135640e-01f, 1.28391102e-01f, -8.41455907e-02f, -5.00151590e-02f, -7.36049488e-02f,
  -4.81051840e-02f, 6.71069473e-02f, 3.57882455e-02f, 1.20647505e-01f, 7.98099488e-03f, 9.77796093e-02f, 1.25896916e-01f, 1.70747951e-01f, -8.71897936e-02f, -4.81970608e-02f,
  -3.71940397e-02f, -2.27058336e-01f, -1.44954511e-05f, 9.47719887e-02f, -1.15383647e-01f, -8.00410733e-02f, 2.63300966e-02f, 1.25951573e-01f, 1.14862487e-01f, -4.44396138e-02f,
  -1.17888495e-01f, 1.00718141e-01f, -4.12245430e-02f, 1.04118854e-01f, -7.89393485e-02f, -5.62032983e-02f, 1.51369855e-01f, -6.85903504e-02f, -9.84130949e-02f, -6.71327934e-02f,
  1.67345241e-01f, 1.56555504e-01f, 1.56195402e-01f, -4.41152938e-02f, -3.91993523e-02f, -5.78840682e-03f, 3.74280438e-02f, 8.96000713e-02f, 6.17279671e-02f, 8.34455490e-02f,
  -6.42313883e-02f, -9.04526040e-02f, 1.04541503e-01f, 1.63990036e-01f, -7.13170692e-02f, 7.72535577e-02f, -9.18500274e-02f, -1.83907859e-02f, -9.92781296e-02f, -1.38767898e-01f,
  1.12612031e-01f, -3.98831852e-02f, 1.27718210e-01f, 8.10854211e-02f, 9.04577225e-02f, 6.62801638e-02f, 3.73576097e-02f, -4.16214280e-02f, 1.23986201e-02f, 6.60799816e-02f,
  -7.05070719e-02f, 1.04324996e-01f, -5.62226251e-02f, 6.83376193e-02f, -6.03250638e-02f, -7.45922849e-02f, -1.17775574e-01f, -7.02248514e-02f, -8.33472684e-02f, -7.91061223e-02f,
  2.99468078e-02f, 1.09439038e-01f, 8.80413689e-03f, 5.78946481e-03f, 1.57333724e-02f, 6.49789199e-02f, 8.02150145e-02f, 8.06349441e-02f, -5.08980192e-02f, 7.52285421e-02f,
  7.15473741e-02f, 1.01237029e-01f, 2.57523917e-02f, 2.69959774e-02f, 1.08656861e-01f, 1.04029551e-01f, 1.12409353e-01f, 9.45368968e-03f, 6.97711259e-02f, -8.15455168e-02f,
  -1.23585038e-01f, 6.31352887e-02f, 2.49458011e-02f, -4.01494727e-02f, -4.93731871e-02f, -2.86996597e-04f, 6.10436127e-03f, -1.26918450e-01f, -5.11825085e-02f, 6.07117340e-02f,
  -6.03399724e-02f, 5.26709035e-02f, -3.27870511e-02f, -1.07758015e-01f, 3.15468684e-02f, -6.59552813e-02f, -1.24177903e-01f, 1.00714497e-01f, -4.60911654e-02f, -8.20793509e-02f,
  -9.21604633e-02f, 9.99517143e-02f, -1.08580679e-01f, -1.19475350e-01f, -2.20972821e-02f, -3.96814495e-02f, -4.07145470e-02f, -2.56966390e-02f, 2.49345950e-03f, 5.48198707e-02f,
  -7.56441131e-02f, -2.13693511e-02f, 9.73865837e-02f, 1.10861883e-02f, 5.32094352e-02f, 6.12543821e-02f, -6.54200986e-02f, 1.05731025e-01f, -4.56853807e-02f, 1.26802295e-01f,
  -2.35893186e-02f, 8.36563483e-02f, -4.33922075e-02f, -1.56617556e-02f, 3.02109588e-02f, 1.87045224e-02f, 1.29456237e-01f, 7.46713802e-02f, 5.68306185e-02f, -1.06849320e-01f,
  2.04358064e-02f, 3.61624756e-03f, 1.31629407e-01f, 3.16230468e-02f, -6.08136691e-02f, 1.31875560e-01f, 8.55960846e-02f, -1.29368708e-01f, -3.52200828e-02f, -1.50611788e-01f,
  -8.75335783e-02f, -1.46852672e-01f, -4.25664671e-02f, 8.65544751e-02f, 4.53906134e-02f, -1.38066396e-01f, 1.12616748e-01f, -4.45019081e-02f, 7.23555163e-02f, 1.01957940e-01f,
  1.30724728e-01f, -1.32853203e-02f, 1.13708235e-01f, 1.51395321e-01f, 3.90662886e-02f, -2.44399402e-02f, 1.08147271e-01f, 4.13585603e-02f, -7.74442330e-02f, 4.94961366e-02f,
  -2.24746335e-02f, 4.91459388e-03f, 2.42344901e-01f, 7.50530139e-02f, 6.53377920e-02f, 1.96628734e-01f, -1.55256867e-01f, -1.21537216e-01f, -9.26119909e-02f, 4.63214703e-03f,
  9.50835049e-02f, -1.08205304e-02f, 1.68254867e-01f, 3.46933976e-02f, 1.43217906e-01f, 1.94359213e-01f, 4.88849655e-02f, -6.60174489e-02f, 1.20074570e-01f, 1.16905063e-01f,
  5.24127744e-02f, 5.01801223e-02f, -2.24540308e-02f, -3.71436141e-02f, -2.70717647e-02f, 4.30302955e-02f, 1.00678928e-01f, 2.11960003e-01f, 6.33139685e-02f, 9.35813263e-02f,
  5.58195524e-02f, -5.14869355e-02f, -4.69653234e-02f, -9.96098965e-02f, -3.98365147e-02f, -5.06478027e-02f, 1.45500943e-01f, -2.07101375e-01f, 1.62814349e-01f, -4.33508940e-02f,
  3.21092680e-02f, -5.34144305e-02f, -2.68343300e-01f, -1.08654285e-02f, 2.23700814e-02f, 2.89627731e-01f, 4.71950024e-02f, 2.36543249e-02f, 1.00653775e-01f, -1.17146755e-02f,
  1.58231065e-01f, 1.39599189e-01f, 1.72282368e-01f, 2.94260941e-02f, 1.40862629e-01f, -1.23814799e-01f, 2.64057163e-02f, 4.07832488e-02f, 2.31287226e-01f, -2.05079447e-02f,
  2.74304915e-02f, -1.26632765e-01f, 1.99141309e-01f, -4.44120057e-02f, 1.55792907e-01f, 3.33570987e-01f, -8.17246437e-02f, 2.95758881e-02f, -4.15567160e-02f, 8.49148184e-02f,
  3.54582779e-02f, -7.85873160e-02f, -7.58343488e-02f, -2.98656356e-02f, 1.50966346e-01f, 3.48310508e-02f, -4.54172753e-02f, 1.37508988e-01f, 1.42588750e-01f, 1.89834893e-01f,
  -4.53294180e-02f, 1.47697419e-01f, 1.71179343e-02f, -1.71896089e-02f, 3.44327800e-02f, -1.35346159e-01f, 3.76004651e-02f, -1.46490246e-01f, 9.80304703e-02f, -5.83708808e-02f,
  6.41473234e-02f, -4.64601219e-02f, -2.59378622e-03f, -2.00152740e-01f, -7.27677718e-02f, -8.93648714e-02f, -4.23400849e-02f, -2.23638341e-01f, 1.54021323e-01f, -1.49201736e-01f,
  9.47487578e-02f, -1.47225291e-01f, 8.64222869e-02f, 4.08863835e-03f, -6.64995983e-03f, -2.09699228e-01f, -6.75395429e-02f, 2.76056230e-02f, -7.10980445e-02f, 8.44971165e-02f,
  1.31577939e-01f, 4.29628193e-02f, 1.13880813e-01f, 1.43747360e-01f, 1.53641030e-01f, 1.24229446e-01f, 1.81491479e-01f, 6.53303936e-02f, 8.72345120e-02f, 1.10787444e-01f,
  -1.72058165e-01f, 2.17132136e-01f, 1.34942800e-01f, -3.45837213e-02f, -3.18781473e-02f, 5.28038740e-02f, -2.13440299e-01f, -4.26113941e-02f, -2.84591410e-02f, 2.04565138e-01f,
  1.47689044e-01f, 1.21051520e-01f, -7.34738959e-03f, 2.43595362e-01f, -3.83627531e-03f, -8.18976015e-02f, 9.03709531e-02f, -2.79742945e-02f, -2.08516475e-02f, -2.41589546e-02f,
  -1.06949322e-01f, -6.02104664e-02f, 1.43065557e-01f, 1.00332007e-01f, -9.26705226e-02f, 7.81629384e-02f, -4.69258381e-03f, 1.22636937e-01f, 1.08508222e-01f, 2.14435142e-02f,
  -3.80323157e-02f, 5.60419448e-03f, 1.32639166e-02f, 1.71547309e-01f, -5.69152087e-02f, 1.64796472e-01f, 4.05840725e-02f, -7.88871944e-02f, 1.09978274e-01f, -6.83894157e-02f,
  1.01280846e-01f, 1.07904404e-01f, 9.91684422e-02f, 9.72579569e-02f, -6.43290579e-02f, -7.12061152e-02f, -1.58995688e-01f, -1.95476696e-01f, 6.90724179e-02f, -1.36038050e-01f,
  9.71232355e-02f, -1.31916478e-01f, 9.79213342e-02f, 9.69277322e-02f, -1.05799347e-01f, -4.71794754e-02f, -9.62717608e-02f, 1.77492991e-01f, 1.53820977e-01f, -8.64859894e-02f,
  -5.77713959e-02f, -1.41714916e-01f, 6.68594837e-02f, -4.95567545e-02f, -1.34836391e-01f, 5.95024340e-02f, 1.82577610e-01f, 8.66056085e-02f, -8.31457600e-02f, -1.23865664e-01f,
  1.02949604e-01f, -1.25857517e-01f, 9.74068344e-02f, 8.53349194e-02f, 1.86234713e-01f, 2.15641167e-02f, -6.08964227e-02f, 8.51029009e-02f, 2.16462970e-01f, -4.25533466e-02f,
  2.78825257e-02f, -5.86293675e-02f, -1.09228723e-01f, -2.35825069e-02f, -1.26115203e-01f, 2.35379003e-02f, -1.12394551e-02f, 6.70764297e-02f, -5.48409745e-02f, -8.89083669e-02f,
  -3.55849974e-03f, 2.75617335e-02f, 1.55703589e-01f, 1.02661587e-01f, 1.06356688e-01f, 2.27594674e-01f, 7.20668733e-02f, 4.25972790e-02f, -4.78655584e-02f, 1.97153941e-01f,
  7.33216405e-02f, 4.88151573e-02f, 2.04207569e-01f, 5.28169572e-02f, -2.77809411e-01f, 3.39561880e-01f, -1.53915554e-01f, 4.08008188e-01f, 8.77525434e-02f, 1.66624591e-01f,
  -1.60335988e-01f, -1.04197949e-01f, 8.21642578e-02f, -8.44810456e-02f, 1.18478216e-01f, -2.57121861e-01f, 2.78701454e-01f, 5.47520183e-02f, -6.16024099e-02f, 1.20600402e-01f,
  9.82958004e-02f, -4.23131101e-02f, 2.85258163e-02f, -1.98085960e-02f, 2.25634590e-01f, -4.71492447e-02f, -5.72880991e-02f, 5.49229681e-02f, -4.43732664e-02f, -2.72465032e-02f,
  1.63093597e-01f, 1.52424360e-02f, 1.54199274e-02f, 6.66871369e-02f, 4.83081080e-02f, -2.39549149e-02f, -1.11596629e-01f, 5.93565591e-02f, 3.21848333e-01f, 2.55338520e-01f,
  6.94693578e-03f, 2.70236969e-01f, 2.45717227e-01f, 3.61503214e-01f, -5.75567111e-02f, -1.09218918e-01f, 1.19166132e-02f, -4.76282500e-02f, 3.23699415e-01f, -3.18346769e-02f,
  -1.26659527e-01f, 1.10235140e-01f, 6.37415126e-02f, 1.95817836e-02f, 6.35118186e-02f, 2.40940740e-03f, 2.09449649e-01f, 2.27690473e-01f, 1.39417604e-01f, 2.85768490e-02f,
  1.22431256e-01f, 1.40629396e-01f, -6.97017312e-02f, 1.23350807e-01f, 5.16307317e-02f, 1.81028200e-03f, -5.55333942e-02f, 1.12874940e-01f, 1.52463555e-01f, 6.84629893e-04f,
  -1.30850688e-01f, -2.64247239e-01f, -1.78775057e-01f, -4.25866991e-02f, 2.70607263e-01f, -5.57768010e-02f, -1.18836522e-01f, 7.55010173e-03f, 3.67994234e-02f, 6.79670498e-02f,
  -1.87930375e-01f, 1.40759543e-01f, 2.14898009e-02f, 1.36725560e-01f, 2.42183656e-02f, 8.66506621e-02f, -1.09020129e-01f, -1.24749318e-01f, 5.56818992e-02f, -7.61563852e-02f,
  -1.14084929e-01f, -1.27822515e-02f, 1.50267139e-01f, 7.86689967e-02f, 3.23600918e-02f, 1.40898079e-01f, 1.14455083e-02f, -1.28067493e-01f, 1.76778227e-01f, -2.25502886e-02f,
  -3.16452514e-03f, 8.73618294e-04f, 4.03175270e-03f, -1.32753164e-01f, 2.69188453e-02f, -1.42835990e-01f, -9.87456888e-02f, -1.82066426e-01f, 5.59753105e-02f, 1.07846282e-01f,
  4.05660421e-02f, 2.69127637e-01f, -1.30060002e-01f, -9.86463502e-02f, 8.52976069e-02f, -1.63665600e-02f, 9.30058286e-02f, 1.70693785e-01f, 1.44266278e-01f, -7.87894353e-02f,
  2.50091385e-02f, 1.97763577e-01f, 1.78042352e-01f, 6.18676357e-02f, 1.45660609e-01f, 3.08788251e-02f, 8.78892243e-02f, 2.47891158e-01f, 1.35256350e-01f, -4.08256352e-02f,
  1.26213208e-01f, 1.12519264e-01f, -9.72634926e-02f, 1.08646736e-01f, 1.15249306e-01f, 2.62734145e-02f, 2.07168818e-01f, 3.37785255e-04f, -2.83548594e-01f, -1.56095192e-01f,
  -1.35842100e-01f, -2.03471124e-01f, 7.72453249e-02f, -3.30743343e-01f, 2.52976626e-01f, 3.70020866e-02f, 6.43674433e-02f, 4.27129924e-01f, -9.30024683e-02f, 2.39193767e-01f,
  1.27420379e-02f, 9.65381563e-02f, -3.32201901e-03f, -1.50216103e-01f, -1.38364628e-01f, 5.24930703e-03f, 1.13282070e-01f, 7.14024454e-02f, 1.12210520e-01f, -1.15901716e-01f,
  1.33876309e-01f, -1.50094390e-01f, 1.24168277e-01f, -8.75605792e-02f, 2.04415387e-03f, 7.40133077e-02f, -7.25129545e-02f, 3.48625511e-01f, 8.77642632e-02f, 1.87590003e-01f,
  1.17198445e-01f, 1.74936622e-01f, 5.17200530e-02f, -2.30647162e-01f, -1.42739281e-01f, -1.67443648e-01f, 6.30568061e-03f, -1.46866590e-01f, -1.24864005e-01f, -4.50949334e-02f,
  1.22333877e-01f, 1.29410937e-01f, 6.90159425e-02f, -1.32711381e-01f, -6.70519322e-02f, 9.92079601e-02f, 1.46117076e-01f, 7.26745948e-02f, 5.83543815e-02f, -3.68771367e-02f,
  4.72348966e-02f, 1.39936373e-01f, -1.00497641e-01f, 8.17100629e-02f, 4.78546172e-02f, -5.12397923e-02f, -7.56175667e-02f, 5.52495755e-02f, 1.25755340e-01f, 1.25796661e-01f,
  -1.33663967e-01f, 4.93418202e-02f, 4.15659882e-02f, 1.49187773e-01f, 9.61140990e-02f, 4.82282825e-02f, 1.82629928e-01f, 2.55068064e-01f, 3.32459331e-01f, 2.64297463e-02f,
  -4.84272055e-02f, 3.18012014e-02f, -6.73331693e-02f, 2.23566771e-01f, -1.30839899e-01f, 1.17511414e-01f, 6.53337091e-02f, 2.95351539e-02f, -4.82112579e-02f, 5.30424416e-02f,
  -7.68499374e-02f, 1.01685133e-02f, -2.91146711e-02f, -1.13411985e-01f, 5.42437844e-02f, 1.65498838e-01f, -1.06508903e-01f, -2.49805804e-02f, 8.41127243e-03f, 2.27784086e-02f,
  -2.25235447e-02f, 1.34731948e-01f, -8.22929591e-02f, -1.30962610e-01f, 2.21793409e-02f, 2.04582810e-01f, 1.00118574e-02f, 6.24455772e-02f, -5.08498400e-02f, -8.72057453e-02f,
  -5.87254949e-02f, 5.46161048e-02f, -1.18249118e-01f, -4.64075543e-02f, 1.78406775e-01f, -4.85658273e-03f, 1.20782971e-01f, 6.87693432e-02f, -1.20175704e-01f, 2.51300037e-02f,
  -1.51971402e-02f, 2.58299019e-02f, -1.02483332e-01f, -6.59813359e-02f, 5.54778194e-03f, -1.46992225e-02f, -1.06383204e-01f, 7.68414289e-02f, -1.06792293e-01f, -1.16728358e-01f,
  -1.29413590e-01f, -5.68496122e-04f, 1.14089958e-01f, -7.85367563e-02f, 5.18071000e-03f, -8.73175859e-02f, 1.41797019e-02f, 2.02396791e-02f, 1.65644810e-02f, -9.01813507e-02f,
  -9.30388495e-02f, -1.23976588e-01f, -5.23693562e-02f, 8.51444434e-03f, -2.96305791e-02f, -5.80491126e-02f, 2.33370438e-02f, 8.44632313e-02f, 4.39971276e-02f, -7.76264146e-02f,
  4.17287350e-02f, 4.96474355e-02f, -1.76653564e-02f, -9.52001140e-02f, 2.92087197e-02f, 3.99439223e-02f, 3.97491790e-02f, 1.24956898e-01f, 7.16204848e-03f, -1.22214682e-01f,
  -1.09170891e-01f, -6.38328418e-02f, -4.29351404e-02f, -3.40763703e-02f, -8.84243101e-02f, -6.27699047e-02f, -1.03647180e-01f, -9.82340127e-02f, -1.05311528e-01f, -1.07438266e-01f,
  -7.52817765e-02f, -1.82492211e-02f, 5.72693907e-02f, -4.41652052e-02f, -5.09604327e-02f, 1.02383412e-01f, -9.17570014e-03f, 4.93954159e-02f, -1.18132003e-01f, 1.08584473e-02f,
  -5.79906330e-02f, -1.20120734e-01f, 4.58073877e-02f, -9.94151924e-03f, 1.58357114e-01f, 1.39148325e-01f, 1.41247839e-01f, 1.76284820e-01f, 1.97322935e-01f, 5.83402179e-02f,
  1.94164187e-01f, 1.57335594e-01f, 1.41427934e-01f, 2.34236136e-01f, 5.37395105e-02f, -1.97898567e-01f, 2.46557921e-01f, -2.61675239e-01f, 2.85019010e-01f, 8.50551948e-02f,
  -2.34487429e-01f, 1.53602958e-01f, 5.51590063e-02f, -9.81318057e-02f, 1.02556027e-01f, -1.46171495e-01f, 1.43011153e-01f, 7.61896446e-02f, 1.87182158e-01f, 2.14706585e-01f,
  -5.89437895e-02f, 4.49261405e-02f, -4.85135578e-02f, -1.11244194e-01f, -1.69863448e-01f, -3.11195031e-02f, 6.56045824e-02f, -6.21254668e-02f, -1.04584232e-01f, -1.22846570e-02f,
  -5.16368859e-02f, -3.36233266e-02f, -3.66927721e-02f, -1.29107842e-02f, 1.38950557e-01f, -6.04381263e-02f, 3.41272391e-02f, -3.79006453e-02f, 1.08136021e-01f, 2.99982540e-03f,
  9.89948362e-02f, 3.78171867e-03f, -2.00335868e-02f, 3.92093137e-02f, -1.18023083e-01f, -6.14392832e-02f, 1.31908029e-01f, -1.48409173e-01f, -1.30625799e-01f, -7.23763183e-02f,
  8.73250738e-02f, -8.02976340e-02f, 5.24004363e-03f, 1.90393273e-02f, -2.08102260e-02f, 9.14992839e-02f, 1.59669966e-01f, 1.53174639e-01f, 1.24975845e-01f, 2.47042537e-01f,
  1.60556853e-01f, 8.07795897e-02f, -6.06282102e-03f, 2.58642048e-01f, 2.70741403e-01f, 1.31316170e-01f, 1.17758356e-01f, 1.15322024e-01f, -5.06658293e-02f, 2.09771559e-01f,
  -1.34346575e-01f, 3.93124849e-01f, -4.33734983e-01f, 2.88359702e-01f, 1.89829484e-01f, -2.40468338e-01f, -8.61691311e-02f, 2.14880202e-02f, 1.98458195e-01f, 1.34267271e-01f,
  3.94509435e-01f, 1.23771809e-01f, -3.66789810e-02f, 1.29333913e-01f, 2.48415321e-01f, 2.13373616e-01f, -1.51403612e-02f, -5.99922575e-02f, -1.10673055e-01f, 6.41317144e-02f,
  -2.60211509e-02f, 2.22644201e-04f, -6.79218099e-02f, -1.30094096e-01f, -4.51372080e-02f, 9.58596095e-02f, 1.52490987e-02f, 3.15004647e-01f, -2.45046429e-02f, -1.00105770e-01f,
  5.51220365e-02f, -1.01837851e-01f, -1.71691418e-01f, -6.02514017e-03f, 4.21035849e-02f, -1.39804572e-01f, 2.49653950e-01f, 3.40806365e-01f, -6.50242493e-02f, 4.73317772e-01f,
  1.66071691e-02f, 2.83506870e-01f, -1.13492094e-01f, 2.78046113e-02f, -6.84138387e-02f, -4.49551120e-02f, 2.23437414e-01f, -3.75622325e-03f, -1.25245959e-01f, -1.16285421e-01f,
  5.02950884e-02f, 5.27519584e-02f, 1.25140384e-01f, -2.27701180e-02f, -1.23881490e-03f, -1.36153623e-02f, -1.08723179e-01f, -6.35653064e-02f, 9.68750287e-03f, 3.63788679e-02f,
  3.88416313e-02f, 1.17259044e-02f, -1.37548327e-01f, -4.94126007e-02f, 7.18408963e-03f, -1.08971018e-02f, -6.84743449e-02f, -1.49074778e-01f, 4.96242940e-02f, 9.47449431e-02f,
  4.53415699e-03f, -4.57574986e-03f, -1.54176667e-01f, -5.35046458e-02f, -1.00682214e-01f, -3.11600361e-02f, -7.67605379e-02f, 1.75301265e-02f, 1.46089971e-01f, -1.33224368e-01f,
  1.29798770e-01f, -2.37116851e-02f, -4.22753803e-02f, -7.51140267e-02f, 1.29607737e-01f, 1.26558598e-02f, 6.77388022e-03f, 1.70642212e-01f, 8.21661949e-02f, -1.67477895e-02f,
  -8.84267986e-02f, -9.79942828e-02f, -4.97145280e-02f, 2.98598856e-02f, -7.26822540e-02f, 9.68106911e-02f, 1.57062545e-01f, 7.80268088e-02f, 9.41784531e-02f, -7.80124590e-02f,
  8.91857073e-02f, 6.51567057e-02f, -2.55349092e-02f, -1.24289684e-01f, 3.99741679e-02f, 4.43816371e-02f, -3.09903827e-02f, 8.14213008e-02f, -9.33214426e-02f, -7.56669343e-02f,
  1.14351347e-01f, -1.11742578e-01f, -9.86174420e-02f, 1.16469808e-01f, 1.20624937e-01f, 9.96197090e-02f, 1.81802347e-01f, 8.24429169e-02f, 7.39594921e-02f, 8.83602053e-02f,
  2.65541263e-02f, 1.90918073e-01f, 1.06833428e-02f, 1.03299469e-01f, -1.52502852e-02f, 1.23162670e-02f, 8.29692408e-02f, -2.18680408e-02f, 2.18451455e-01f, -1.91830471e-01f,
  7.33052567e-02f, 5.76605983e-02f, -4.82749008e-02f, 2.66391058e-02f, -6.70439973e-02f, 8.84467438e-02f, 3.29138368e-01f, -4.17358987e-03f, -3.72197106e-02f, -6.02110587e-02f,
  3.18614691e-02f, 1.79862291e-01f, 2.99574882e-02f, -2.93490272e-02f, -4.69533503e-02f, 4.74727564e-02f, -1.16911523e-01f, -1.78279176e-01f, -1.50366321e-01f, 1.54342785e-01f,
  -1.27738804e-01f, -1.62119508e-01f, -1.28816143e-01f, 4.60681729e-02f, 7.32590854e-02f, 2.84492493e-01f, 7.05407793e-03f, 4.40997258e-02f, -1.25237465e-01f, -5.32648265e-02f,
  -2.25232184e-01f, 3.24003585e-02f, 1.05088033e-01f, 3.84252854e-02f, -8.03776011e-02f, -6.39096946e-02f, -3.61702107e-02f, 2.34449834e-01f, 5.54601550e-02f, 3.53006050e-02f,
  -1.41278416e-01f, 9.96810347e-02f, 1.74499035e-01f, -9.21208560e-02f, -5.29034212e-02f, 2.20355224e-02f, -9.41113904e-02f, 1.27143845e-01f, -6.80839345e-02f, -2.40640417e-02f,
  -1.08262874e-01f, 1.52277341e-02f, 2.18042172e-02f, -8.20391178e-02f, 1.37456968e-01f, -9.07669291e-02f, 4.53849584e-02f, -7.58773014e-02f, -7.47812353e-03f, -6.62151426e-02f,
  -2.23474745e-02f, 6.58945143e-02f, 1.37663437e-02f, -1.19742736e-01f, 4.31931987e-02f, -9.52481106e-02f, 6.76502511e-02f, 8.72045532e-02f, 1.12871461e-01f, -7.21738189e-02f,
  1.23944677e-01f, 9.79933813e-02f, 3.80435959e-02f, -3.36846686e-03f, 8.41961578e-02f, -8.93314034e-02f, -2.23887712e-02f, -5.66411503e-02f, -1.14469357e-01f, -7.26674274e-02f,
  5.09658456e-02f, 6.49605393e-02f, -1.03172347e-01f, 2.53212824e-02f, -5.05482294e-02f, -4.31135334e-02f, -1.30622489e-02f, 9.45762396e-02f, -4.83821668e-02f, -1.16155997e-01f,
  2.77750921e-02f, -7.89898187e-02f, -5.61838560e-02f, 1.06347121e-01f, 9.32641327e-02f, 6.76727518e-02f, 1.04266569e-01f, 1.14537366e-01f, 9.41631794e-02f, -9.39921960e-02f,
  6.07521124e-02f, 1.10470392e-01f, 1.66310728e-01f, 1.85069572e-02f, -6.13236092e-02f, -4.97165620e-02f, 1.63705554e-02f, -7.16056526e-02f, 1.86790302e-02f, 1.33915301e-02f,
  8.87204558e-02f, 7.09402338e-02f, -1.59369968e-02f, 8.44254866e-02f, 1.63199767e-01f, 1.49506077e-01f, 1.90169975e-01f, 8.94710608e-03f, 2.35849380e-01f, -7.62260100e-03f,
  7.14515820e-02f, 2.54070997e-01f, 1.35199446e-03f, 2.19096273e-01f, 1.97675359e-02f, -1.30120546e-01f, 2.16261297e-01f, -3.15751076e-01f, 1.63676023e-01f, -1.07177012e-01f,
  1.68221258e-02f, 3.60607505e-01f, 4.19791520e-01f, -1.05559893e-01f, 2.21748173e-01f, -3.98170725e-02f, 1.23671323e-01f, -4.27143313e-02f, 2.09969848e-01f, 1.63828924e-01f,
  1.10555060e-01f, -1.47221029e-01f, -6.77568167e-02f, -3.53210755e-02f, -8.64978805e-02f, 1.12875901e-01f, 1.47577584e-01f, 1.48979366e-01f, -8.97072256e-02f, -7.94824064e-02f,
  3.40132043e-02f, -2.53821835e-02f, -1.43990353e-01f, -1.18938416e-01f, -1.10696390e-01f, 1.83414191e-01f, 6.43414585e-03f, -1.92617819e-01f, 2.39415109e-01f, -1.44597813e-01f,
  2.74607658e-01f, -7.53427274e-04f, 8.72223452e-02f, -5.74682746e-03f, -1.27505630e-01f, 6.74906000e-02f, 3.09439719e-01f, -1.03778183e-01f, 8.98505673e-02f, 5.62685095e-02f,
  1.96822256e-01f, -1.05362445e-01f, -1.15537629e-01f, 6.74271658e-02f, 1.14656843e-01f, 1.69710919e-01f, -2.11159308e-02f, 1.75537735e-01f, 1.58781499e-01f, 6.92751259e-02f,
  1.28766716e-01f, 1.73283964e-01f, 8.53400603e-02f, 1.58300668e-01f, -9.14787780e-03f, 3.88772413e-03f, 1.61055923e-01f, 1.08536996e-01f, -2.38080055e-01f, 3.60749781e-01f,
  2.14905571e-02f, 1.42002106e-01f, -1.73263997e-01f, -4.05055396e-02f, -2.44059324e-01f, -1.73803061e-01f, 7.48163611e-02f, 5.98322675e-02f, -3.53118107e-02f, -1.82664692e-01f,
  2.38026515e-01f, 9.83044878e-02f, -8.57269242e-02f, -5.62457331e-02f, -4.50861566e-02f, 1.83541313e-01f, 8.72962996e-02f, 1.31218672e-01f, 1.37954384e-01f, -1.07737109e-01f,
  8.94328356e-02f, 1.66341946e-01f, 7.20920116e-02f, -8.13157186e-02f, 2.08606273e-02f, -1.38950765e-01f, 1.59558266e-01f, 1.15961120e-01f, 3.16655934e-01f, 3.47497524e-03f,
  1.91284670e-03f, 4.98219877e-02f, 1.58197388e-01f, -6.95705041e-02f, 7.48732779e-03f, 1.11842193e-01f, 3.03473979e-01f, 3.51386249e-01f, -1.51571840e-01f, -4.20218818e-02f,
  -9.83454213e-02f, -4.47609052e-02f, 1.22108087e-01f, 5.27956598e-02f, -1.72165573e-01f, 1.00918956e-01f, 2.13169884e-02f, 4.16120887e-02f, 6.81284070e-02f, 2.20753998e-02f,
  2.15412546e-02f, 7.09152147e-02f, 2.27697179e-01f, 1.38068482e-01f, 2.01805294e-01f, 1.81701351e-02f, 1.83865711e-01f, 9.26564261e-02f, 1.40292933e-02f, 2.18637928e-01f,
  8.81022736e-02f, 1.34460330e-01f, 8.12418684e-02f, -1.57886490e-01f, -2.22319216e-02f, -1.99655846e-01f, 2.66749203e-01f, -2.33352661e-01f, -2.50046700e-02f, 2.44361058e-01f,
  -8.27227384e-02f, 2.44708717e-01f, -2.90480405e-01f, 3.16164829e-02f, -6.93273172e-03f, 3.00284475e-01f, 1.02331363e-01f, -1.70734171e-02f, -8.45219046e-02f, 1.47252306e-01f,
  -2.67352201e-02f, 9.84331518e-02f, 1.27609164e-01f, 1.49093792e-01f, 1.94033965e-01f, -9.11722407e-02f, 3.34656805e-01f, 4.03125696e-02f, -6.37241751e-02f, 1.63183272e-01f,
  -2.91913785e-02f, -1.25087634e-01f, 4.04017001e-01f, 1.06345728e-01f, -2.74839886e-02f, 1.83493882e-01f, 7.42929280e-02f, 1.16409734e-01f, 3.20603023e-03f, 1.58606078e-02f,
  -1.97979152e-01f, -9.21102539e-02f, -7.29513727e-03f, -2.24063516e-01f, 7.12799281e-02f, 9.78004262e-02f, 1.16687022e-01f, -2.44343351e-03f, -3.23281065e-02f, 1.54938325e-01f,
  6.44596666e-02f, 4.85777147e-02f, -3.39198746e-02f, 1.89174712e-01f, -7.64372051e-02f, 6.05030321e-02f, -7.00304806e-02f, 6.53254390e-02f, 2.44340934e-02f, 8.05504713e-03f,
  9.98737887e-02f, 1.11864610e-02f, 1.59331322e-01f, 6.01680204e-02f, -8.18370730e-02f, 1.18472621e-01f, -6.19062893e-02f, 1.62786692e-01f, 2.32133698e-02f, 4.05518487e-02f,
  -1.88840434e-01f, 1.29022092e-01f, -3.18347360e-03f, -4.24742661e-02f, 3.89952697e-02f, 9.08464193e-03f, 2.02215523e-01f, 6.12074174e-02f, 2.61777908e-01f, -9.21253173e-04f,
  7.40900710e-02f, 1.88817114e-01f, 1.25072047e-01f, 1.40403450e-01f, 3.50149311e-02f, 1.45246357e-01f, 9.97980535e-02f, 1.05280384e-01f, 7.76494369e-02f, -1.25080235e-02f,
  -4.68028672e-02f, 1.54821547e-02f, 1.02392873e-02f, 4.96855602e-02f, 2.12290585e-02f, 1.96215793e-01f, -7.54385740e-02f, 7.24588484e-02f, 8.57706927e-03f, 1.20884955e-01f,
  -1.63718238e-01f, 1.50763676e-01f, -5.96232191e-02f, -8.06292221e-02f, -5.17689586e-02f, 6.48426190e-02f, 4.85109203e-02f, 1.45091951e-01f, 7.73267150e-02f, -4.03935798e-02f,
  3.54457125e-02f, 1.28673360e-01f, 6.49804901e-03f, -1.08860424e-02f, 9.39995572e-02f, -4.82316650e-02f, 8.00518394e-02f, -1.48681834e-01f, 3.38444370e-03f, -1.67354569e-02f,
  -9.23869610e-02f, -1.23804423e-03f, -8.47938657e-02f, 5.82870878e-02f, 2.35571805e-02f, 8.18542317e-02f, -1.12270974e-02f, 1.22205414e-01f, -5.54295555e-02f, -8.81998017e-02f,
  1.11167707e-01f, -1.14982858e-01f, -5.77813983e-02f, -5.74927591e-02f, -2.67848372e-02f, 1.98623035e-02f, 8.11286718e-02f, 5.19339368e-02f, -1.63869202e-01f, 5.64768277e-02f,
  -1.38675764e-01f, 1.34063084e-02f, 1.07909732e-01f, 1.27387479e-01f, 6.86132610e-02f, -7.08742812e-02f, -7.62939379e-02f, -3.84839671e-03f, -2.90994123e-02f, -1.26810372e-01f,
  1.30697280e-01f, 1.04492838e-02f, 1.64692998e-02f, -9.06713586e-03f, -5.70487939e-02f, 1.41413793e-01f, 9.61589292e-02f, 7.98218399e-02f, 7.41879195e-02f, -7.91804567e-02f,
  -7.84984976e-02f, 1.99080054e-02f, 8.96296501e-02f, 4.85059768e-02f, -1.16568327e-01f, 7.06994832e-02f, -7.47313276e-02f, -5.99350445e-02f, -1.97693855e-02f, -9.93913859e-02f,
  9.40578505e-02f, -1.25229850e-01f, -1.99052617e-02f, 1.36241153e-01f, -8.68080184e-02f, 6.48845360e-02f, -1.97619423e-02f, -1.48115177e-02f, -1.42316325e-02f, 1.44066587e-01f,
  -8.94793216e-03f, 3.06523740e-02f, 9.28432569e-02f, -1.00634284e-01f, -3.93016562e-02f, 1.37458235e-01f, -7.63069019e-02f, 3.56367193e-02f, 7.92991221e-02f, -6.29734173e-02f,
  -9.09200832e-02f, -8.80353153e-03f, 1.03158494e-02f, -5.94868176e-02f, -1.34384543e-01f, 9.97455120e-02f, -6.13368377e-02f, 1.80025455e-02f, -2.45382302e-02f, 3.65329273e-02f,
  -1.05646349e-01f, 8.77753422e-02f, -1.38550056e-02f, -1.26261324e-01f, 3.93555909e-02f, -6.22151867e-02f, 1.56571358e-01f, 8.05405229e-02f, -3.01004592e-02f, -1.96925364e-02f,
  -5.85605763e-02f, 1.00507013e-01f, 7.27850869e-02f, -5.05831558e-03f, 1.05479456e-01f, -1.33290952e-02f, -3.39073315e-02f, -6.35493323e-02f, 1.22068256e-01f, 1.02029659e-01f,
  8.92868564e-02f, 5.90704866e-02f, 8.31893682e-02f, -3.87981720e-02f, 9.49647427e-02f, -5.82992136e-02f, 8.42509512e-03f, -1.19398274e-01f, 2.02750717e-03f, -2.31812913e-02f,
  -3.45074236e-02f, -8.10491517e-02f, -6.39717653e-02f, -1.15007721e-02f, 1.27890021e-01f, 1.08214818e-01f, 6.01605810e-02f, -2.82635186e-02f, -1.04495563e-01f, 6.27236664e-02f,
  -7.81696588e-02f, -1.10622332e-01f, 2.30969233e-03f, 2.40125619e-02f, 1.20679311e-01f, -2.78715063e-02f, 1.29003868e-01f, 1.31669179e-01f, 1.80212498e-01f, 5.79683445e-02f,
  1.16706707e-01f, 1.55122325e-01f, 2.15782046e-01f, 6.41728714e-02f, -1.31494939e-01f, 1.03612915e-01f, 1.70907348e-01f, 6.66898713e-02f, 9.87668931e-02f, 3.38650458e-02f,
  8.99642631e-02f, -5.01540303e-02f, 2.63879806e-01f, 7.27676377e-02f, -3.38806331e-01f, 1.32226437e-01f, 1.87882558e-02f, -1.73495561e-01f, -2.66832054e-01f, 1.26542756e-02f,
  5.95241152e-02f, 1.61078081e-01f, -2.06290595e-02f, -1.51017427e-01f, -1.62777513e-01f, 4.99132127e-02f, 9.23746303e-02f, -3.14066820e-02f, 3.55821028e-02f, -2.29258075e-01f,
  1.51899412e-01f, -1.62605137e-01f, -2.35130806e-02f, 4.23065364e-01f, 1.46652997e-01f, -1.09072141e-02f, 1.51480794e-01f, -5.90954423e-02f, 2.57305093e-02f, -7.70268440e-02f,
  3.54956873e-02f, 1.95467733e-02f, 5.24013698e-01f, 1.96180806e-01f, -5.95622919e-02f, 1.49823993e-01f, 1.99302360e-01f, -5.83329760e-02f, 2.86180884e-01f, -2.45786145e-01f,
  2.02537924e-01f, -1.52185708e-01f, -1.39161739e-02f, 7.45237172e-02f, -4.64369617e-02f, -8.22635461e-03f, 1.17686130e-01f, -8.66903886e-02f, -4.43950966e-02f, 2.58411378e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  3.96530516e-03f, 4.59481776e-02f, 3.86269651e-02f, 1.03846021e-01f, -1.01050846e-02f, -2.78786235e-02f, -6.16455637e-02f, 8.72759223e-02f, 5.30677475e-02f, 7.42165223e-02f,
  8.19030479e-02f, 7.50465915e-02f, 4.01149802e-02f, 2.23980606e-01f, -1.27006263e-01f, 1.02671951e-01f, 2.19147161e-01f, 3.67366746e-02f, -7.02282861e-02f, -6.93085976e-03f,
  -3.96209629e-03f, 1.01711862e-01f, -4.86719161e-02f, 2.71303058e-01f, 5.95873296e-02f, 1.85264885e-01f, 7.26466328e-02f, -7.02239275e-02f, 3.57336700e-02f, 2.16324423e-02f,
  3.94542329e-02f, 1.50417328e-01f, -8.38924572e-02f, 6.52252361e-02f, 4.79514003e-02f, 1.34211704e-01f, -1.83041580e-02f, -9.07014385e-02f, -5.42821698e-02f, 1.58780858e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.57256171e-01f, -1.66761205e-01f, 9.29401140e-04f, 3.39157730e-02f, -1.46939084e-01f, 1.84083983e-01f, -2.16470826e-02f, 2.24649906e-01f, 3.91373746e-02f, 3.00634187e-02f,
  4.93854620e-02f, 4.34758840e-03f, 3.21065873e-01f, 3.77717495e-01f, -4.84480143e-01f, 1.48236394e-01f, 4.24568772e-01f, 9.43223611e-02f, 6.64551854e-02f, 2.55260587e-01f,
  3.59641671e-01f, 1.78528488e-01f, -2.14874581e-01f, -1.02286093e-01f, 3.13141108e-01f, -1.34954482e-01f, 1.69675425e-02f, 1.00249045e-01f, 1.95601303e-02f, 5.68937361e-02f,
  -7.24839196e-02f, 1.75007790e-01f, -1.49448335e-01f, -3.32974225e-01f, -8.29397980e-03f, 4.60732967e-01f, 6.11353852e-02f, 8.14056695e-02f, -4.36312072e-02f, 1.40273899e-01f,
  -2.14633167e-01f, -1.99180841e-02f, -6.86312513e-03f, 8.78588781e-02f, -7.10503608e-02f, 1.50576249e-01f, -4.30511124e-02f, -4.90028977e-01f, -1.65425427e-02f, -4.79121149e-01f,
  1.81902722e-02f, -1.91139337e-02f, 3.50465775e-01f, -4.23214167e-01f, -1.85406990e-02f, 5.20329177e-02f, 1.93843961e-01f, 6.54435396e-01f, -4.76153642e-01f, 1.65999770e-01f,
  -2.58675009e-01f, -1.64166495e-01f, -1.15713693e-01f, 2.67420232e-01f, 1.82160884e-02f, 9.62379351e-02f, -1.99756213e-02f, 2.43107736e-01f, -3.10579300e-01f, 1.98526576e-01f,
  1.52319549e-02f, -9.81923938e-02f, -2.22577259e-01f, 4.30183969e-02f, 2.16235772e-01f, 3.20753679e-02f, 1.91220075e-01f, -4.11223501e-01f, -5.03784955e-01f, -6.34727702e-02f,
  1.24371678e-01f, 1.05036527e-01f, 1.94552243e-01f, -4.70600836e-02f, 2.44089618e-01f, 9.72706883e-04f, -2.20268682e-01f, -2.68763840e-01f, 2.47442260e-01f, -1.45445168e-02f,
  8.19137394e-02f, 5.08064985e-01f, 1.31730944e-01f, 1.26458481e-01f, 9.53129679e-02f, 4.11202498e-02f, 6.38356090e-01f, -6.61096051e-02f, -8.59394148e-02f, -2.51126587e-01f,
  -3.39779526e-01f, 2.38860324e-01f, 1.85732409e-01f, 1.67529151e-01f, 1.83460757e-01f, -9.31211635e-02f, -1.07267186e-01f, -5.24322204e-02f, -1.67271793e-01f, -1.01813748e-01f,
  -1.15139425e-01f, -4.41331953e-01f, 3.91393781e-01f, -3.70278656e-01f, -1.66835655e-02f, -6.15292825e-02f, 4.93761674e-02f, 9.64000374e-02f, 5.07946201e-02f, 3.83147180e-01f,
  -9.82854888e-03f, 2.80003756e-01f, -1.48356304e-01f, -3.41929674e-01f, 1.07608363e-01f, -1.40335530e-01f, -1.69112414e-01f, -6.42170012e-01f, -1.82436690e-01f, -3.90693657e-02f,
  8.42037722e-02f, 1.03536300e-01f, -1.39850080e-01f, -1.24238089e-01f, 1.34495094e-01f, -3.04075982e-02f, 1.57006323e-01f, -1.34167343e-01f, 2.17668995e-01f, -1.02627061e-01f,
  1.29577383e-01f, -3.67338568e-01f, 1.83771163e-01f, 6.31698221e-02f, 3.37051809e-01f, -4.88855869e-01f, -1.53203979e-01f, 3.89858395e-01f, -1.16302773e-01f, -5.04618168e-01f,
  1.76200449e-01f, 5.02670348e-01f, -2.95484215e-02f, 1.42157143e-02f, -1.45036221e-01f, 1.61420688e-01f, -2.18158457e-02f, -6.78347871e-02f, 2.10689828e-01f, 4.97368239e-02f,
  5.03876805e-01f, -1.71276391e-01f, -2.88528949e-01f, -2.00323775e-01f, 1.16883934e-01f, -3.47895145e-01f, 8.52420852e-02f, 8.95868167e-02f, 1.13456203e-02f, 3.55537515e-03f,
  -6.00380227e-02f, -1.24694251e-01f, -3.22246820e-01f, -4.94552813e-02f, 4.16994607e-03f, 1.09909154e-01f, -1.93250328e-01f, -1.70219213e-01f, 3.00254047e-01f, -7.96812996e-02f,
  -2.66798884e-01f, 6.01277351e-01f, 6.21156208e-02f, 2.65456527e-01f, -1.74822528e-02f, -3.86859804e-01f, 6.75185993e-02f, -4.30542856e-01f, 2.68705308e-01f, -1.73658609e-01f,
  -1.45830121e-03f, -1.61931306e-01f, -5.33796139e-02f, 3.31941575e-01f, -2.60609597e-01f, -1.77372634e-01f, -4.91457544e-02f, -8.58631581e-02f, -6.34650467e-03f, 1.35798007e-01f,
  1.62529394e-01f, -2.41563559e-01f, -8.08811858e-02f, -1.04579903e-01f, -2.80913919e-01f, -5.73359653e-02f, 4.68956679e-01f, -3.08641762e-01f, -5.30094028e-01f, -2.52629161e-01f,
  9.02550668e-02f, 1.71821088e-01f, -1.07126929e-01f, 9.86661389e-02f, 1.36073604e-01f, -6.45162612e-02f, -1.47833116e-02f, 2.12418884e-02f, -4.91084205e-03f, -3.00680220e-01f,
  4.55040634e-02f, -2.06656575e-01f, 8.00437108e-02f, 1.60924103e-02f, -3.08580071e-01f, -1.03997797e-01f, 5.12285888e-01f, 3.29818040e-01f, 4.11727875e-02f, 6.05745196e-01f,
  -6.77275956e-02f, -3.51502909e-03f, -2.59314924e-01f, 4.08435106e-01f, -4.74332608e-02f, 1.57153327e-02f, 4.11545485e-01f, 2.30190784e-01f, -2.11035624e-01f, -1.42580926e-01f,
  -1.20353878e-01f, -2.80334145e-01f, -4.62081768e-02f, 1.09795474e-01f, -9.08669084e-02f, -3.83021861e-01f, 1.46674260e-01f, -2.32488364e-01f, -2.92403474e-02f, 1.72166303e-01f,
  -2.70951897e-01f, 2.28618547e-01f, 3.18531953e-02f, -8.30476061e-02f, 1.12058753e-02f, -1.80096358e-01f, -5.42189665e-02f, -9.05083641e-02f, 3.31501216e-01f, 3.16660404e-01f,
  4.13088381e-01f, 1.83737472e-01f, 2.61014313e-01f, -9.38153639e-02f, 2.05107838e-01f, 7.84876943e-02f, 2.95051634e-01f, 2.05432534e-01f, 1.34348407e-01f, 5.01038015e-01f,
  3.67514938e-02f, 2.54349381e-01f, 1.00575602e-02f, -4.56645899e-03f, -1.91922188e-01f, -2.90747046e-01f, -2.60109186e-01f, 2.52866536e-01f, -5.69263436e-02f, 1.30736113e-01f,
  -1.79076359e-01f, -2.16894373e-01f, 6.13531433e-02f, -6.57151565e-02f, 5.65508716e-02f, 1.04424462e-01f, -9.36871842e-02f, 2.85405159e-01f, -3.63984823e-01f, -6.95962235e-02f,
  4.37597245e-01f, 2.21142620e-01f, 9.38836858e-02f, 9.09557119e-02f, -3.93341929e-02f, -9.59928185e-02f, -2.20260248e-01f, -4.49493565e-02f, -1.02230161e-02f, 3.05512220e-01f,
  -1.05782978e-01f, -3.47106129e-01f, -1.84835628e-01f, 5.08236170e-01f, -3.24907780e-01f, -1.23145409e-01f, -5.40190265e-02f, -1.11885078e-01f, -9.84954014e-02f, -3.77143443e-01f,
  1.71378717e-01f, -2.93318003e-01f, -1.10906184e-01f, 1.89307109e-01f, 3.59213173e-01f, 2.61972785e-01f, -1.49129272e-01f, -6.20899871e-02f, -2.91892309e-02f, 2.68293262e-01f,
  2.21426025e-01f, 1.39287740e-01f, -3.18294078e-01f, -2.06831228e-02f, 1.74137488e-01f, -3.29242557e-01f, 1.66756064e-02f, -1.20652877e-01f, 2.39153370e-01f, 1.30521990e-02f,
  1.72090799e-01f, -1.80588409e-01f, -3.08478862e-01f, -5.97474463e-02f, -4.46372628e-01f, 3.83413285e-01f, 1.66651711e-01f, 4.36653644e-01f, 2.06085369e-01f, -4.40402269e-01f,
  2.90267706e-01f, 8.58229473e-02f, -9.70754698e-02f, -1.67586088e-01f, 1.88024357e-01f, -3.41140814e-02f, -7.52920508e-02f, 8.35017487e-02f, 1.03144594e-01f, -4.44950648e-02f,
  4.21915054e-02f, -1.78814843e-01f, -1.88915804e-01f, 4.00458187e-01f, -3.43285799e-01f, 2.96477992e-02f, -4.11853433e-01f, 1.87698320e-01f, -9.68704969e-02f, -3.73795293e-02f,
  2.60933548e-01f, -1.25027552e-01f, -8.96451250e-02f, 1.01098880e-01f, -1.12664104e-01f, 6.93099126e-02f, 5.01241572e-02f, 1.33560359e-01f, -1.27381518e-01f, 6.14115417e-01f,
  -1.30755201e-01f, -4.47753519e-02f, 4.97600287e-01f, -2.95288593e-01f, -1.40998587e-01f, 3.04787487e-01f, -2.78871693e-02f, 3.16078931e-01f, -2.04309627e-01f, -5.14490083e-02f,
  3.73180397e-02f, 1.18560428e-02f, 1.42163243e-02f, 3.07197887e-02f, 2.08451524e-01f, 1.49243027e-01f, -1.04340859e-01f, -2.28598043e-01f, -2.78735399e-01f, -9.97445062e-02f,
  -1.01560049e-01f, -1.20485155e-02f, 6.74865544e-02f, 1.79483593e-01f, -1.62165835e-01f, 7.86217079e-02f, -1.00374766e-01f, -6.59850091e-02f, -3.42945218e-01f, 1.61153242e-01f,
  3.09737593e-01f, 3.07415068e-01f, 2.64829755e-01f, 1.37541398e-01f, -7.11307228e-02f, -1.45638421e-01f, -3.17651123e-01f, 2.24931091e-01f, -2.66111732e-01f, -4.12630513e-02f,
  9.45267156e-02f, -1.92429647e-01f, 1.20818624e-02f, -4.30569537e-02f, 7.01974630e-02f, -1.44067764e-01f, -1.46341026e-01f, 2.98318893e-01f, -1.97648983e-02f, -3.67688745e-01f,
  7.20285475e-02f, -3.89116168e-01f, -9.14729685e-02f, -6.42922968e-02f, 2.36444488e-01f, -1.91408783e-01f, 1.14436604e-01f, -2.24892780e-01f, -1.27266377e-01f, 4.17869501e-02f,
  -2.03469470e-01f, 3.18244994e-01f, -2.71455675e-01f, 4.07247126e-01f, 4.60179865e-01f, 5.93457557e-02f, -3.78266163e-02f, 4.81941998e-01f, -5.40444925e-02f, -3.81720252e-02f,
  8.36401433e-02f, -7.31470296e-03f, 3.61015469e-01f, -2.64967889e-01f, 4.08448845e-01f, 2.05791090e-02f, 1.01619564e-01f, -5.14255762e-01f, 5.42401224e-02f, -9.24816132e-02f,
  -3.07743281e-01f, -1.12237623e-02f, -4.63207304e-01f, -9.81982872e-02f, -1.88188747e-01f, -4.42815602e-01f, -5.42817950e-01f, 1.41381146e-03f, -6.84216991e-02f, -4.10354547e-02f,
  -1.17728069e-01f, 1.35962591e-01f, 2.23741621e-01f, 1.18933484e-01f, -2.66045243e-01f, -1.72948256e-01f, -2.77465254e-01f, -1.37243956e-01f, -2.66444951e-01f, -2.23854557e-01f,
  1.08537823e-01f, 5.44530787e-02f, -7.10178763e-02f, 8.73916224e-02f, -1.08092003e-01f, -3.67334373e-02f, -5.84474532e-03f, -4.37415950e-02f, -5.13075925e-02f, -7.48941228e-02f,
  1.08356915e-01f, -7.06012398e-02f, -1.10643402e-01f, 1.55043855e-01f, 3.99536967e-01f, 3.35653991e-01f, 1.04588740e-01f, -1.14983670e-01f, -2.60466963e-01f, -1.68980911e-01f,
  2.43485328e-02f, 2.78301865e-01f, 2.93742180e-01f, 4.64487314e-01f, 2.39940226e-01f, 2.01320872e-01f, 4.43544984e-03f, 1.27353504e-01f, -9.80373770e-02f, 3.89255472e-02f,
  -2.40643740e-01f, -4.36401248e-01f, 7.83462450e-02f, -2.16711819e-01f, 6.55871108e-02f, -3.71349037e-01f, 6.57301024e-02f, -6.33642301e-02f, -2.85468865e-02f, -1.12736315e-01f,
  -7.97164887e-02f, 3.27006847e-01f, -1.06701411e-01f, -7.68795609e-02f, -2.08510924e-03f, -1.45157129e-01f, 3.92904952e-02f, -1.80270135e-01f, 7.14270445e-03f, -3.72653231e-02f,
  -7.74807334e-02f, -9.63213369e-02f, -5.54323718e-02f, -1.42397627e-01f, 1.60415947e-01f, -9.75080058e-02f, -5.72435781e-02f, -3.50258827e-01f, 8.27777982e-02f, -3.56058598e-01f,
  -9.22034979e-02f, 1.12644695e-01f, -2.26702780e-01f, 9.29458514e-02f, 1.56982794e-01f, 4.19797599e-01f, 2.61059757e-02f, 1.06813438e-01f, 6.41437620e-02f, 3.43829900e-01f,
  -3.33043225e-02f, 6.89995196e-03f, 1.37003005e-01f, -4.82049696e-02f, 4.27538693e-01f, -4.75694947e-02f, 3.97505462e-01f, -2.69050002e-01f, -2.80063808e-01f, -3.04605573e-01f,
  -1.41551092e-01f, -1.53095573e-01f, 4.95064169e-01f, 7.10632429e-02f, -1.03557669e-01f, -1.30597338e-01f, -8.12129602e-02f, 2.26144552e-01f, 1.89997349e-02f, -3.35811198e-01f,
  1.45637393e-01f, -2.52429172e-02f, 8.84865299e-02f, 8.56048092e-02f, -1.59864664e-01f, -2.69932121e-01f, 8.33432004e-02f, -2.33643115e-01f, 3.43832485e-02f, -2.14170828e-01f,
  -2.27520570e-01f, 2.03050509e-01f, -9.52800140e-02f, 2.55168200e-01f, 3.38655175e-03f, 3.45936239e-01f, -2.08728954e-01f, 9.13164765e-02f, 2.82490373e-01f, 7.02512413e-02f,
  1.98278695e-01f, 2.43859366e-01f, 1.00030020e-01f, 6.77218363e-02f, 6.26912937e-02f, -1.21191427e-01f, -1.54428229e-01f, 1.16105810e-01f, 3.50822300e-01f, 9.76584479e-02f,
  2.85294920e-01f, 1.90073445e-01f, -2.47981846e-01f, 7.16773644e-02f, 1.98084354e-01f, -1.38611764e-01f, -1.33120462e-01f, -5.37346363e-01f, -3.56748343e-01f, -7.07053021e-02f,
  -2.09050953e-01f, -2.35564145e-03f, -1.04071170e-01f, -1.72884673e-01f, 2.57623065e-02f, -1.08047679e-01f, -4.27961797e-02f, -7.79528320e-02f, -4.17659581e-01f, -1.20376714e-01f,
  -4.62749630e-01f, -7.43487244e-03f, 2.54633546e-01f, -3.77793521e-01f, -9.85218734e-02f, -1.43458605e-01f, -6.50561869e-01f, -9.07260999e-02f, -5.69538139e-02f, -1.92661896e-01f,
  -2.70585507e-01f, -3.82424071e-02f, 3.33712220e-01f, 5.97893834e-01f, -2.31358726e-02f, 2.77454793e-01f, 1.28736988e-01f, -3.36931646e-02f, 1.36061832e-01f, 3.40795815e-01f,
  2.45899917e-03f, -2.81569123e-01f, 9.40951332e-02f, 1.19916931e-01f, 4.68089670e-01f, -5.04966617e-01f, -3.62691991e-02f, -1.26736403e-01f, 1.33852780e-01f, 3.26688379e-01f,
  2.68755198e-01f, -3.83504599e-01f, -1.58015445e-01f, -4.62953858e-02f, 2.77145207e-01f, 2.25487202e-01f, -7.18138088e-03f, 2.98328996e-01f, 5.82246520e-02f, 1.08970486e-01f,
  2.43386254e-02f, 5.55853732e-02f, -3.39846760e-01f, -4.99191165e-01f, 6.47124290e-01f, -5.11941254e-01f, -2.42853463e-01f, -1.61357671e-01f, -1.00447670e-01f, 5.21743409e-02f,
  3.61950189e-01f, 2.03004822e-01f, 4.79265541e-01f, -2.40012154e-01f, 2.41534542e-02f, 1.94204122e-01f, -8.54155272e-02f, -2.65675684e-04f, -1.05215676e-01f, -4.19862941e-02f,
  -7.99490977e-03f, -1.01295412e-01f, 2.06272706e-01f, -1.60299629e-01f, -7.93882757e-02f, -1.72793463e-01f, 2.76483059e-01f, 3.36935759e-01f, 1.45111727e-02f, 2.33660623e-01f,
  5.06721474e-02f, 1.23092853e-01f, -1.67034641e-02f, -8.03528428e-02f, 8.17989334e-02f, -1.35332182e-01f, -1.05415009e-01f, -5.34138875e-03f, 3.68052840e-01f, -1.65148512e-01f,
  -2.86393017e-01f, 4.80844500e-03f, -3.68372291e-01f, 5.21477044e-01f, 2.00984143e-02f, -1.16370507e-01f, 4.04172428e-02f, -3.22557002e-01f, -1.12665929e-01f, 6.89636590e-03f,
  8.00225362e-02f, -3.34606948e-03f, -9.11584720e-02f, -4.23090219e-01f, 6.51957393e-02f, 1.93726838e-01f, 2.58861959e-01f, 2.53282279e-01f, 1.34950384e-01f, 3.73011641e-02f,
  -6.53348044e-02f, 1.40734941e-01f, -3.59589532e-02f, -2.39421621e-01f, -2.46270284e-01f, 1.22384675e-01f, -4.74786639e-01f, -6.55708015e-02f, 2.88988531e-01f, -1.13436259e-01f,
  1.14191175e-01f, 3.32110852e-01f, -2.37705171e-01f, -2.64259018e-02f, -3.20624530e-01f, 2.37076879e-01f, 4.38599706e-01f, -9.56920460e-02f, -2.30487913e-01f, 1.99501496e-02f,
  2.79275179e-01f, -3.70281100e-01f, 7.93866217e-02f, -1.38878971e-01f, -1.34277776e-01f, 4.25310209e-02f, -1.50328830e-01f, 1.38716493e-02f, -1.25452802e-01f, 3.62009071e-02f,
  -2.31113359e-01f, -3.45682114e-01f, -6.23805039e-02f, 4.46525589e-02f, 2.33926371e-01f, -2.38835439e-01f, 2.22676788e-02f, -2.50407755e-01f, 3.13106537e-01f, -2.52005786e-01f,
  1.38296530e-01f, -9.87589434e-02f, 3.20177853e-01f, 3.17874610e-01f, -1.53353274e-01f, -8.59394744e-02f, 1.68338060e-01f, -1.34090111e-01f, -1.56572565e-01f, 5.47272637e-02f,
  8.55720788e-02f, -2.42685094e-01f, 3.59805584e-01f, 5.91605067e-01f, -1.45408273e-01f, -1.17651835e-01f, 1.45248761e-02f, 1.05803341e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.39484346e-01f, -2.72506457e-02f, -9.91270915e-02f, -1.12889983e-01f, 9.65902582e-03f, 4.01391042e-03f, 1.11948699e-02f, -4.78232056e-02f, -3.99168767e-03f, -2.82830521e-02f,
  1.00690380e-01f, 1.38776556e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    