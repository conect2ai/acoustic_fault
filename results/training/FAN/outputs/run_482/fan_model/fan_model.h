/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.22388816e-01f, -2.55343705e-01f, 7.13995174e-02f, 1.90684944e-01f, 2.64493883e-01f, 1.98187605e-01f, 1.22367494e-01f, 3.51648382e-03f, 3.03412080e-02f, -3.12761158e-01f,
  -2.27158945e-02f, -4.10363711e-02f, -1.99868470e-01f, 1.15222834e-01f, 3.86471152e-01f, -2.61734188e-01f, 2.37292871e-01f, 2.00751424e-02f, -6.65873438e-02f, 2.31744926e-02f,
  6.82506859e-02f, 1.72669873e-01f, 1.48854762e-01f, -5.76940067e-02f, 2.66744971e-01f, -8.45467672e-02f, 2.71388516e-03f, -3.44967097e-02f, 9.60924327e-02f, 1.39819801e-01f,
  2.46457309e-02f, -1.31913811e-01f, 2.85700597e-02f, -2.77895834e-02f, -1.36233037e-02f, 2.29509249e-02f, 1.72918420e-02f, 4.41461988e-02f, 9.18452814e-02f, -3.04295346e-02f,
  -4.44994168e-03f, 1.60189085e-02f, -5.34568653e-02f, -2.66293474e-02f, 6.02906421e-02f, 6.98183328e-02f, 7.03083642e-04f, 6.90877065e-02f, 4.97863889e-02f, 5.52587993e-02f,
  -2.52259504e-02f, 3.46931024e-03f, 9.39439610e-02f, -9.52757746e-02f, 5.44612296e-02f, 1.28040509e-02f, -3.93939614e-02f, 6.00096397e-02f, 7.49824615e-03f, 2.03344189e-02f,
  -2.88362559e-02f, -9.05158371e-02f, 4.57020439e-02f, -4.57829013e-02f, 8.65950808e-02f, -1.36295510e-02f, 3.00416928e-02f, -3.09491586e-02f, 2.33067665e-02f, 2.27276323e-05f,
  -1.83264297e-02f, 5.43111712e-02f, -2.11204886e-02f, 2.45608892e-02f, 4.80922908e-02f, 1.00520514e-02f, 5.12356311e-02f, -3.64598483e-02f, 4.68037128e-02f, 5.49188294e-02f,
  -6.34893551e-02f, 2.98996083e-02f, -6.73425645e-02f, -2.68851873e-02f, 1.75178666e-02f, 2.42023282e-02f, -8.04928616e-02f, 1.26750860e-02f, 5.75678749e-03f, 9.63560119e-02f,
  -3.00981756e-02f, -1.93619788e-01f, -9.40892100e-02f, -6.29157666e-03f, -5.51017001e-02f, 1.31146051e-02f, -8.65535904e-03f, -4.17202637e-02f, -4.58626747e-02f, -2.72692367e-02f,
  1.18612777e-02f, 4.51182164e-02f, -1.57042462e-02f, 7.76609406e-02f, 4.50778231e-02f, -1.51523584e-02f, -5.38906194e-02f, -7.44279027e-02f, 1.00635644e-02f, -1.64340008e-02f,
  2.14007851e-02f, -3.13358605e-02f, -2.45624986e-02f, 9.75495949e-02f, -9.75235086e-03f, -2.18717474e-02f, 6.54373989e-02f, -5.21064401e-02f, -1.98965427e-02f, -9.12578702e-02f,
  9.36772823e-02f, 6.83953380e-03f, 4.46500853e-02f, 2.97270805e-01f, 1.90975368e-01f, -3.57198715e-01f, -1.51344225e-01f, 2.54108757e-01f, 1.70569628e-01f, -9.88237187e-02f,
  -3.87696661e-02f, -1.72007710e-01f, -2.13801146e-01f, -1.31230086e-01f, -3.78787667e-01f, -4.10010397e-01f, -2.63287038e-01f, -1.91651195e-01f, -2.17209291e-02f, 6.66269213e-02f,
  9.30326805e-03f, 4.55277078e-02f, -1.53453257e-02f, 2.75214016e-01f, 3.48525286e-01f, 2.61263490e-01f, 2.12348893e-01f, 1.06417134e-01f, 3.08158658e-02f, -1.59954652e-01f,
  -2.07926199e-01f, 1.59926265e-01f, 1.07502818e-01f, -3.35927866e-02f, 1.84606705e-02f, -4.93374728e-02f, -1.19415045e-01f, -2.50923131e-02f, -1.90972793e-03f, -9.00147930e-02f,
  -1.86747946e-02f, -1.09755583e-01f, 1.01394363e-01f, 1.07864335e-01f, 2.50042211e-02f, 6.43562060e-03f, -3.14280801e-02f, -4.94347773e-02f, 5.71643077e-02f, 1.98908709e-02f,
  1.43241696e-02f, -1.64500415e-01f, -1.09963551e-01f, -1.23472258e-01f, -8.03808495e-02f, -4.13063578e-02f, 1.48788691e-02f, -9.27019194e-02f, -2.09849291e-02f, 8.20132867e-02f,
  -1.72178745e-02f, 2.81221420e-02f, 4.50443812e-02f, 2.05848347e-02f, 1.12206731e-02f, 8.38908330e-02f, 2.18995730e-03f, -4.67655323e-02f, -2.10935269e-02f, -1.07514160e-02f,
  -9.20191966e-03f, 1.75374094e-02f, 2.61205938e-02f, 8.48874003e-02f, -2.90339300e-03f, 8.64841789e-02f, -7.00002462e-02f, -5.56294136e-02f, 9.76361558e-02f, 9.76943504e-03f,
  4.48437966e-02f, -5.85110411e-02f, 5.08845188e-02f, -5.23909256e-02f, -5.99726178e-02f, 5.95075339e-02f, 3.89385596e-02f, 2.20975764e-02f, 4.36843149e-02f, 2.21876632e-02f,
  -2.56158412e-01f, 9.85816643e-02f, 4.63452376e-02f, 3.02269422e-02f, -5.45951836e-02f, 2.77931597e-02f, -4.74393368e-02f, 7.65202520e-03f, -7.88305551e-02f, 7.17525408e-02f,
  -9.07822885e-03f, 1.28227785e-01f, -9.19698328e-02f, -3.28772925e-02f, -1.68323331e-03f, -5.66519201e-02f, -6.13465123e-02f, 7.76627809e-02f, 4.06027958e-02f, 1.19556554e-01f,
  6.34658560e-02f, 2.55553313e-02f, 7.92276040e-02f, 5.84537862e-03f, 2.81585082e-02f, -2.69741956e-02f, 5.76556521e-03f, 1.20036684e-01f, -1.36831347e-02f, -4.60562073e-02f,
  4.88930680e-02f, 2.89686590e-01f, -1.71608225e-01f, 1.03170127e-02f, -2.46839747e-02f, -1.76179662e-01f, -1.49662599e-01f, 1.81636144e-03f, 4.03656691e-01f, 8.03433061e-02f,
  -5.92197105e-02f, 4.51274961e-02f, 2.73727566e-01f, -4.11771350e-02f, -9.97327417e-02f, 3.28019351e-01f, -1.88721865e-01f, -9.47919562e-02f, 1.90278172e-01f, 2.65578795e-02f,
  1.91196240e-02f, 9.00284648e-02f, -7.32239112e-02f, 1.87517688e-01f, -1.05115153e-01f, -1.88020784e-02f, -9.95013416e-02f, 1.06514506e-01f, -1.90419793e-01f, -1.33544415e-01f,
  6.35178462e-02f, 1.53291836e-01f, -4.15081978e-02f, 4.73138988e-02f, -1.25130087e-01f, -1.30370945e-01f, -1.14848837e-01f, -3.25078443e-02f, 5.22896498e-02f, -3.51468138e-02f,
  -4.70657870e-02f, 1.77145712e-02f, -1.11367768e-02f, 8.80705044e-02f, 4.91825342e-02f, 2.12597996e-02f, 4.66881208e-02f, -1.38906196e-01f, 1.26124904e-01f, -5.42073362e-02f,
  -2.97879074e-02f, -8.48936215e-02f, -1.10158406e-01f, -6.95134625e-02f, -8.35254937e-02f, 6.17608568e-03f, -1.68230027e-01f, -6.43175989e-02f, -6.54789731e-02f, 7.69254491e-02f,
  -4.64052856e-02f, 4.40751575e-02f, -6.41336944e-03f, 1.10937597e-03f, 1.04585938e-01f, -1.25273302e-01f, 9.44718271e-02f, -1.23152118e-02f, -6.84772618e-03f, 1.13944367e-01f,
  1.95942316e-02f, -3.71808968e-02f, 9.28204954e-02f, -5.90585992e-02f, -5.31031042e-02f, -6.53681979e-02f, -1.19486593e-01f, -2.30130665e-02f, -5.55229522e-02f, -1.60582677e-01f,
  7.68949389e-02f, 2.24031545e-02f, 7.50665292e-02f, 5.47874533e-03f, 5.96495830e-02f, -1.28264083e-02f, 3.94512862e-02f, -6.10205382e-02f, 6.20790534e-02f, -9.71146002e-02f,
  5.70500121e-02f, 9.15165097e-02f, -5.22407005e-03f, 1.03611564e-02f, -2.34097466e-02f, -5.38864685e-03f, -3.01238596e-02f, -2.74076629e-02f, 1.35482043e-01f, 7.54833892e-02f,
  -7.15439841e-02f, -6.58577532e-02f, -1.21857068e-02f, -4.35452312e-02f, -4.23696972e-02f, -4.11582403e-02f, -2.24572551e-02f, 6.02068454e-02f, -1.63164496e-01f, -8.94604102e-02f,
  -5.91478199e-02f, -8.45348388e-02f, -9.53634679e-02f, 2.29889285e-02f, -7.35464841e-02f, 1.47278514e-02f, 1.54643878e-02f, 6.73462525e-02f, -1.39479131e-01f, -4.67226803e-02f,
  3.31015468e-01f, 5.63713275e-02f, -4.79033627e-02f, 9.69073698e-02f, -1.31879300e-01f, 8.91617015e-02f, 4.46965665e-01f, -1.94964975e-01f, 3.17689747e-01f, 6.37274310e-02f,
  -1.22840285e-01f, 3.11303198e-01f, 1.25657946e-01f, -1.72712162e-01f, 8.17341730e-02f, 1.77392259e-01f, -1.46029845e-01f, 9.91231725e-02f, 1.93739384e-01f, -1.06058851e-01f,
  -2.16070618e-02f, -1.40539721e-01f, -1.47555113e-01f, -2.59907752e-01f, -6.99192509e-02f, 1.00642592e-02f, -1.73323795e-01f, 7.29633635e-03f, -1.67228103e-01f, 7.04484135e-02f,
  7.82795250e-02f, -3.53987631e-03f, -1.39327105e-02f, 3.86771709e-02f, -7.74481054e-03f, -1.07588004e-02f, -3.21795023e-03f, 1.64487418e-02f, 7.68046975e-02f, 1.06331512e-01f,
  1.20496154e-01f, -7.73811862e-02f, 2.30146032e-02f, 3.39250900e-02f, 1.49808880e-02f, -4.85282429e-02f, -3.01576685e-02f, 8.42901820e-04f, -5.64202247e-03f, 2.91739739e-02f,
  -3.00953370e-02f, 1.06177032e-02f, 4.04681824e-02f, 8.50979239e-03f, 8.08490068e-03f, 5.34698553e-02f, 1.00816883e-01f, -4.33044555e-03f, 1.37292715e-02f, -3.51373069e-02f,
  -4.14083824e-02f, 5.05194925e-02f, 9.96525865e-03f, 4.16966900e-02f, 3.54751311e-02f, -1.54317664e-02f, -9.70922504e-03f, -7.37256780e-02f, 5.13348356e-02f, -1.26233203e-02f,
  -7.52781108e-02f, -1.20708114e-02f, -5.17743174e-03f, -7.68309012e-02f, 4.44717519e-02f, 9.90343988e-02f, 1.24573736e-02f, -7.93432519e-02f, 2.13265959e-02f, -3.02195698e-02f,
  -1.68328788e-02f, 1.69050805e-02f, 5.12643196e-02f, -4.98940274e-02f, 4.70693968e-02f, 1.61858559e-01f, -1.16322041e-01f, 3.09351832e-02f, -4.78941537e-02f, -1.33433668e-02f,
  -1.04420699e-01f, -1.71600744e-01f, 2.53378395e-02f, 9.21022147e-03f, -3.89071144e-02f, -8.58482532e-03f, -3.13523039e-02f, 9.98788141e-03f, 2.40381304e-02f, -4.10077870e-02f,
  -1.06841236e-01f, -1.35803455e-02f, -6.71191886e-02f, 1.06404293e-02f, 9.30053089e-03f, -3.87140736e-02f, 8.24490655e-03f, 6.94236979e-02f, -4.77111414e-02f, -6.20359667e-02f,
  -7.55014122e-02f, -2.96195806e-03f, 6.64502606e-02f, 8.29316378e-02f, -3.37395966e-02f, 6.95848614e-02f, 3.86663638e-02f, -2.98118647e-02f, -3.83322127e-02f, 7.44930748e-03f,
  -1.46956250e-01f, 3.16269130e-01f, -1.31508615e-02f, -2.01133430e-01f, 1.82660803e-01f, -1.59652323e-01f, -2.79803693e-01f, 3.28421682e-01f, 7.53915161e-02f, 1.04727246e-01f,
  -2.33340889e-01f, -2.21568830e-02f, 1.14402033e-01f, -4.37351048e-01f, -1.52551934e-01f, -7.75938034e-02f, -3.38429242e-01f, -3.01456392e-01f, 1.29613698e-01f, 4.46108095e-02f,
  5.01147844e-02f, -1.61831453e-01f, 6.39615133e-02f, 3.56725365e-01f, -9.99401063e-02f, 2.12322295e-01f, 2.35707849e-01f, 2.02960566e-01f, -1.31087556e-01f, -1.74782231e-01f,
  -8.02507848e-02f, 4.52526920e-02f, 5.17713465e-03f, 8.15061256e-02f, -7.46927783e-02f, -7.11683333e-02f, 3.28832259e-03f, 2.71008946e-02f, 3.66754346e-02f, 6.14939071e-02f,
  -5.53452447e-02f, 7.78676122e-02f, -4.59183976e-02f, -4.53021303e-02f, 6.82403625e-04f, 1.12168275e-01f, 5.49441727e-04f, 1.72805656e-02f, 7.08601475e-02f, 9.48666781e-03f,
  5.09962030e-02f, -1.36224493e-01f, -1.01194136e-01f, -1.14481691e-02f, 7.87514523e-02f, -9.03727785e-02f, -6.44793035e-03f, -5.63294478e-02f, 7.68523067e-02f, 7.01954365e-02f,
  -7.56084174e-02f, 1.72485486e-02f, 1.21404715e-02f, 6.44723251e-02f, -3.98547836e-02f, 9.63597558e-03f, -3.21645266e-03f, 3.81557434e-03f, 7.17362389e-02f, 4.03462276e-02f,
  1.85425133e-02f, -6.09973446e-02f, 3.59849408e-02f, -6.78954795e-02f, -1.07286029e-01f, -8.15941859e-03f, -5.23541197e-02f, -4.33094203e-02f, -7.24327639e-02f, 5.36816977e-02f,
  2.86051054e-02f, -1.04979709e-01f, 1.09264087e-02f, 5.59944473e-02f, 6.44865781e-02f, 1.00597031e-01f, 1.96132157e-02f, -4.21421453e-02f, 1.65043790e-02f, -8.41286704e-02f,
  1.71865046e-01f, 2.20745027e-01f, 1.14714794e-01f, 6.45743608e-02f, 1.50561193e-02f, 1.07348543e-02f, -6.00219890e-02f, -4.75109257e-02f, 1.56828657e-01f, -1.20055147e-01f,
  3.35189179e-02f, -6.45873174e-02f, 4.17504348e-02f, -5.89094348e-02f, -1.93241760e-02f, -2.42308266e-02f, -1.13460809e-01f, -1.04660317e-01f, 1.43524278e-02f, 6.84436038e-02f,
  -1.93119477e-02f, 3.94583261e-03f, 6.22774176e-02f, 8.37366655e-02f, -3.89362611e-02f, 4.86354344e-02f, -4.99207862e-02f, 9.44070593e-02f, 4.84982543e-02f, -9.04114265e-03f,
  2.14959726e-01f, 1.96225300e-01f, -1.77194983e-01f, 1.01912782e-01f, 7.99972042e-02f, -1.63754746e-01f, -4.26958650e-01f, 1.16473511e-01f, -1.01969697e-01f, -1.67066734e-02f,
  -6.18721657e-02f, 1.83120176e-01f, -3.61627042e-01f, 2.10311726e-01f, -1.38574407e-01f, -2.75360167e-01f, 1.22694820e-01f, 1.26309782e-01f, -2.40541995e-02f, 2.54646778e-01f,
  1.88679132e-03f, 2.01871231e-01f, -3.73601317e-02f, 1.16043590e-01f, 1.82280466e-01f, 1.60665050e-01f, 8.22039172e-02f, -7.36502558e-02f, 1.74630493e-01f, 9.32740271e-02f,
  1.52435958e-01f, 8.54837820e-02f, 2.51051574e-03f, -1.53518021e-01f, 2.79583950e-02f, -4.07695733e-02f, -1.94534678e-02f, -4.87389304e-02f, -9.70303663e-04f, -7.67279696e-03f,
  -4.73177433e-02f, 8.11407156e-03f, 1.69715747e-01f, -9.88579914e-02f, -3.02898344e-02f, -8.77351910e-02f, 8.88091046e-03f, -1.32385306e-02f, -1.27211958e-02f, -8.63720775e-02f,
  -1.01694956e-01f, 9.32164583e-03f, -1.07004315e-01f, 3.17055522e-03f, 6.95081102e-03f, -6.94328919e-02f, 1.18711805e-02f, -6.49221316e-02f, 5.44406381e-03f, -2.53409967e-02f,
  -8.93455092e-03f, 2.79349321e-03f, -5.82422428e-02f, 4.83236350e-02f, 1.77578982e-02f, -1.02489116e-02f, -8.76843184e-03f, 2.53217984e-02f, -2.18979307e-02f, 3.33284587e-02f,
  1.13078959e-01f, 6.03726320e-02f, 5.84418401e-02f, -2.96157468e-02f, -3.73625793e-02f, 6.05899980e-03f, -3.91259454e-02f, 1.32316291e-01f, 2.46300101e-02f, 4.07195054e-02f,
  -3.85811366e-02f, -5.20787239e-02f, -1.80540013e-03f, 1.39729902e-02f, -1.93923824e-02f, -1.62858497e-02f, 5.15975878e-02f, -3.31703350e-02f, -5.53992670e-03f, 1.51031706e-02f,
  1.39184102e-01f, 7.91050941e-02f, -9.66565907e-02f, -1.63961097e-03f, 4.01930511e-02f, -9.24573746e-03f, -7.10836872e-02f, 6.37680367e-02f, -7.43754879e-02f, 3.79891694e-02f,
  3.82031687e-03f, 3.12401652e-02f, 1.04403690e-01f, 3.19465436e-02f, 5.81076648e-03f, -5.10447770e-02f, 2.98419837e-02f, -9.09833424e-03f, -1.66915506e-02f, 1.40061811e-01f,
  8.59513059e-02f, 6.17685094e-02f, -3.44070792e-02f, 3.64640132e-02f, 1.61282271e-02f, 9.43899900e-02f, 1.82559099e-02f, -4.96472865e-02f, 2.56388411e-02f, -8.11231136e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.32555878e-02f, 8.03205073e-02f, 1.73046291e-01f, -4.57856022e-02f, -3.43033850e-01f, -1.46329731e-01f, -4.53682505e-02f, -1.17619000e-01f, 4.33851838e-01f, -7.80940875e-02f,
  -4.50620055e-01f, 3.84722233e-01f, -1.88035116e-01f, -2.75375754e-01f, 5.35783887e-01f, 5.46397924e-01f, 1.70593243e-02f, 2.56128162e-02f, 7.32297897e-02f, -1.04199238e-01f,
  8.71167555e-02f, -3.28791529e-01f, -1.65427223e-01f, -1.92887664e-01f, -4.97977763e-01f, 6.18536137e-02f, -1.94328353e-01f, -7.85403252e-02f, -2.14855328e-01f, -2.06427015e-02f,
  -1.01375304e-01f, -1.21796541e-01f, -2.37247467e-01f, -9.29380860e-03f, -9.42384899e-02f, -3.45557705e-02f, 8.97726938e-02f, -3.46742235e-02f, -6.02397062e-02f, 4.67333570e-02f,
  2.91452929e-02f, 1.98167726e-01f, 1.64131224e-01f, 4.33945432e-02f, -8.94094110e-02f, 1.04215398e-01f, -6.00719750e-02f, -2.86488146e-01f, 6.85811862e-02f, -1.31773949e-01f,
  -1.57685131e-01f, -1.39819592e-01f, -1.72333598e-01f, 2.18009830e-01f, -2.61198319e-02f, -7.19213635e-02f, 1.24576591e-01f, 1.07514776e-01f, 8.53818879e-02f, 9.90235433e-02f,
  -4.61986884e-02f, 1.30218789e-02f, 6.79218248e-02f, 8.94216597e-02f, -6.39650226e-02f, -7.85848126e-02f, -1.18915237e-01f, -1.05026342e-01f, 5.01185544e-02f, -7.65347928e-02f,
  4.81513441e-02f, 3.92413959e-02f, -2.74679512e-02f, -7.58365691e-02f, -8.31308030e-03f, 1.85415477e-01f, 1.00693822e-01f, 9.98115353e-03f, -4.69438657e-02f, -1.92652224e-03f,
  8.61474648e-02f, -1.59950107e-02f, 5.44806651e-04f, -5.90635613e-02f, 1.15794376e-01f, 9.77953523e-02f, -3.54130194e-02f, 7.88395926e-02f, 1.58689637e-02f, -1.14451684e-01f,
  3.78761999e-02f, 3.48512322e-01f, -2.97002830e-02f, -6.08529560e-02f, 1.74701020e-01f, -1.70169696e-02f, 5.36460765e-02f, 3.98102701e-02f, 9.81403664e-02f, -2.09818501e-02f,
  -2.02845350e-01f, -8.88988227e-02f, -1.31175655e-03f, -3.84717323e-02f, 7.62493163e-02f, 1.74918268e-02f, 2.13404477e-01f, 8.42532814e-02f, -6.67812601e-02f, -1.00231342e-01f,
  -1.36481285e-01f, 3.80939431e-02f, 9.44753513e-02f, -1.82169816e-03f, -4.63698432e-02f, -8.96843076e-02f, 5.43937869e-02f, 1.71080902e-02f, 2.69114990e-02f, 1.29974768e-01f,
  -8.01408052e-01f, -2.23449409e-01f, -3.98585796e-01f, -1.50336191e-01f, 4.65624668e-02f, 5.36174834e-01f, 2.19957352e-01f, -1.41398311e-01f, -3.27867925e-01f, 6.01159362e-03f,
  1.94961488e-01f, -1.92086205e-01f, -1.94966987e-01f, 4.19639736e-01f, 4.42145109e-01f, 2.54574895e-01f, 3.89682174e-01f, 2.95617878e-01f, 5.48070595e-02f, -1.07897773e-01f,
  7.74809346e-02f, 4.19632345e-01f, 2.37188742e-01f, 3.19238752e-01f, 2.42571607e-01f, -1.54359043e-01f, 1.17371026e-02f, -4.22838107e-02f, 4.45051670e-01f, 3.41445267e-01f,
  -5.84641397e-02f, -4.12528634e-01f, -9.47409496e-02f, -4.76730280e-02f, 5.27900346e-02f, 9.05749202e-03f, -3.31636481e-02f, -1.91896744e-02f, -7.30147734e-02f, 4.36045378e-02f,
  -5.56618646e-02f, -2.92450562e-03f, 5.86684868e-02f, -3.90909240e-03f, -1.49968714e-01f, 4.79722172e-02f, -2.12662406e-02f, 1.01491973e-01f, 1.03625776e-02f, -1.30718157e-01f,
  -1.42629102e-01f, 3.12701017e-02f, -3.68798897e-02f, 2.59308368e-01f, -1.56293865e-02f, -5.03160805e-02f, -2.43206471e-02f, 2.93638110e-02f, 3.15811895e-02f, 8.70738626e-02f,
  4.70671877e-02f, -8.89484733e-02f, -1.05460376e-01f, 4.22997847e-02f, -3.57975140e-02f, 1.03544898e-01f, 6.53901547e-02f, 1.20168574e-01f, -7.53370821e-02f, 6.34680316e-02f,
  2.44223513e-02f, -9.55200493e-02f, -1.14877209e-01f, -7.78670087e-02f, 2.04276666e-03f, -2.55943239e-02f, -3.70109566e-02f, 5.60431145e-02f, 8.28534663e-02f, 9.20554623e-02f,
  -1.33788735e-01f, 7.87318647e-02f, -2.81111151e-02f, 1.43572418e-02f, -5.94968982e-02f, -2.45065521e-02f, -1.99594889e-02f, -1.42969489e-02f, -2.35061757e-02f, -1.73304956e-02f,
  -1.67953506e-01f, -4.79440212e-01f, 4.91389260e-02f, -1.01680579e-02f, 4.96807732e-02f, 9.12857205e-02f, 4.93666232e-02f, -2.89868992e-02f, -9.42153856e-02f, 1.18010188e-03f,
  -6.80858418e-02f, 2.48908326e-02f, -8.08607563e-02f, 6.55975863e-02f, 1.56107470e-01f, -8.99152905e-02f, -2.17052158e-02f, -6.30017966e-02f, 3.58529761e-02f, 2.79117711e-02f,
  -4.67010252e-02f, -4.30000760e-02f, 7.47070312e-02f, 1.35136485e-01f, 3.82222570e-02f, -1.21789631e-02f, -8.61491784e-02f, -9.44941491e-02f, 1.45702600e-01f, 9.82169583e-02f,
  -8.12141180e-01f, 2.70114809e-01f, 6.84072137e-01f, -3.16438675e-01f, -1.16979904e-01f, 6.51157498e-01f, 4.61222231e-01f, -3.91361490e-02f, -4.26993556e-02f, 2.09392399e-01f,
  -1.97587311e-01f, -1.75656036e-01f, 4.18207884e-01f, 1.61046490e-01f, 5.02689838e-01f, 5.20613551e-01f, 2.70889878e-01f, 1.83445886e-01f, -3.17301080e-02f, -3.68582278e-01f,
  -1.25514701e-01f, -2.41845787e-01f, 3.32032740e-01f, -2.50263155e-01f, -2.00674921e-01f, -3.42005670e-01f, -2.96111822e-01f, 2.23797739e-01f, -7.73179457e-02f, 9.87216905e-02f,
  -3.39588821e-01f, -4.21845257e-01f, -2.96210438e-01f, -1.69961751e-02f, -1.55685171e-01f, -3.87178399e-02f, 2.89252140e-02f, 9.55639780e-02f, -5.51354252e-02f, -3.39907855e-02f,
  -8.68980959e-02f, -3.35296169e-02f, -2.34564796e-01f, 6.77815527e-02f, -1.12271056e-01f, -3.76113392e-02f, 1.50696829e-01f, -2.74567842e-03f, 5.06163165e-02f, 1.37314960e-01f,
  2.07548305e-01f, 8.23529586e-02f, -3.04375449e-03f, 9.41830575e-02f, -1.47043737e-02f, -7.06342310e-02f, 1.40140027e-01f, 1.07773446e-01f, -4.76053916e-02f, -3.80803924e-03f,
  1.67579606e-01f, 1.82353467e-01f, 1.38474563e-02f, -3.60132270e-02f, -2.16861442e-02f, -7.18180463e-02f, 3.94635126e-02f, 4.42190282e-02f, 2.51293965e-02f, 1.84581634e-02f,
  -1.95506111e-01f, -4.77905758e-03f, -7.00030997e-02f, 5.30254915e-02f, -1.96242947e-02f, -1.10935785e-01f, -1.48513829e-02f, -1.31032407e-01f, -1.19883725e-02f, -8.70757177e-02f,
  1.82140488e-02f, -4.81264964e-02f, 4.96447505e-03f, -6.65274858e-02f, 1.01112068e-01f, 1.01612940e-01f, -7.67698586e-02f, 6.62381351e-02f, -1.16949948e-02f, -3.83916381e-03f,
  -5.12668416e-02f, -6.69287592e-02f, -1.11883529e-01f, -2.33335376e-01f, -4.07327153e-02f, -1.27363103e-02f, 1.95720196e-02f, -2.03849196e-01f, 1.22570451e-02f, -4.94326316e-02f,
  -1.01310462e-01f, 9.63480771e-03f, -1.74455121e-01f, 3.18165943e-02f, 2.28805140e-01f, 1.02531604e-01f, -3.74442302e-02f, -1.23511821e-01f, 7.90217742e-02f, -1.32806338e-02f,
  -1.59373119e-01f, -8.55467469e-02f, 1.47588864e-01f, -1.76942706e-01f, -8.04082118e-03f, 4.40879667e-04f, -1.57293707e-01f, -4.61515784e-02f, 6.10103551e-03f, 2.14595608e-02f,
  -2.68906564e-01f, 3.09579581e-01f, -6.64437115e-01f, -2.96031445e-01f, 4.02248502e-01f, 2.54598469e-01f, 2.17349634e-01f, 2.19405934e-01f, -4.08503227e-02f, 5.69351792e-01f,
  4.37438846e-01f, -1.11917242e-01f, 3.30840796e-01f, 3.64014924e-01f, -3.77272695e-01f, 1.41749367e-01f, 9.01818201e-02f, 8.75903592e-02f, -1.08386360e-01f, 5.33764288e-02f,
  -3.12817872e-01f, 4.03424561e-01f, -1.91441923e-01f, 1.45809352e-01f, 2.80524105e-01f, -4.05799836e-01f, 1.32137209e-01f, -1.49805427e-01f, 1.72029007e-02f, 1.19705565e-01f,
  5.36003523e-02f, 7.40315616e-02f, 2.07057968e-02f, -1.43098995e-01f, -2.01941207e-01f, -4.15116772e-02f, -1.47711396e-01f, -1.18801832e-01f, -4.70624082e-02f, -5.23730963e-02f,
  -1.94656141e-02f, 1.71212815e-02f, 4.47633639e-02f, 6.98780939e-02f, 8.93534049e-02f, -3.29673141e-02f, -6.51508709e-03f, 1.25019616e-02f, 1.78315982e-01f, 1.77325960e-02f,
  -5.34620732e-02f, -9.31483507e-02f, -2.89061498e-02f, 1.28432056e-02f, -8.63311719e-03f, 5.80764003e-02f, -1.14138782e-01f, -6.12374805e-02f, -6.05767295e-02f, -3.58767025e-02f,
  5.02909124e-02f, -1.24599755e-01f, 1.06587522e-01f, 2.69417241e-02f, 5.01753725e-02f, 1.22330181e-01f, 9.81498137e-02f, 6.53303787e-02f, -7.47229457e-02f, 1.09552577e-01f,
  2.49512251e-02f, 4.35972959e-02f, 9.62650925e-02f, -3.28695513e-02f, 5.99873092e-05f, -3.05636637e-02f, -1.15543835e-01f, 5.56472726e-02f, -9.07052308e-02f, -4.41730022e-02f,
  8.63815770e-02f, -8.97233002e-03f, 5.58936745e-02f, 4.92846668e-02f, 3.24576683e-02f, 2.66548116e-02f, 4.20854166e-02f, 2.31884867e-02f, -3.04017346e-02f, 1.15178982e-02f,
  1.25494480e-01f, 8.33090693e-02f, 1.08118467e-02f, 7.74215609e-02f, -8.49726126e-02f, 1.40339704e-02f, -3.78580913e-02f, -4.41192538e-02f, 1.26609216e-02f, 7.75296390e-02f,
  -8.33032578e-02f, -1.67454977e-03f, -1.11812435e-01f, 5.13523370e-02f, -7.97240883e-02f, 1.56582281e-01f, 8.99615139e-02f, -1.02256499e-01f, 4.63784076e-02f, -2.69664675e-02f,
  -5.65222390e-02f, -1.91900264e-02f, -1.06845096e-01f, 7.74590373e-02f, 1.25165179e-01f, 8.58906209e-02f, 1.69556409e-01f, -8.43527690e-02f, -1.01651242e-02f, 1.35555835e-02f,
  3.40455770e-01f, -6.26949370e-02f, -2.89065503e-02f, 3.66975777e-02f, 9.17717293e-02f, 3.18167843e-02f, -7.98382461e-02f, -7.48379827e-02f, -4.27686155e-01f, -1.04882404e-01f,
  2.40728855e-01f, -7.20074251e-02f, 2.00990178e-02f, 3.44459891e-01f, 4.18155819e-01f, 1.73506692e-01f, 4.11101699e-01f, 2.71514971e-02f, -5.63937500e-02f, 1.91349879e-01f,
  2.92744450e-02f, 4.31809485e-01f, 3.26865435e-01f, 7.39860758e-02f, 2.68560469e-01f, -1.89602971e-01f, 6.74689412e-02f, -7.41463080e-02f, 8.03543553e-02f, 1.53426185e-01f,
  -5.34393638e-02f, 7.65398145e-02f, 6.49231076e-02f, -7.60625303e-02f, 1.26137719e-01f, 2.45083310e-02f, -5.21155111e-02f, 9.65169966e-02f, -1.47824094e-01f, -9.25587490e-03f,
  -2.45768800e-02f, 6.47411775e-03f, 1.06273964e-02f, 5.69109768e-02f, -3.57547239e-03f, -1.73083339e-02f, -1.19551487e-01f, -2.07230642e-01f, -8.32889378e-02f, 1.82781503e-01f,
  2.91537158e-02f, -1.31604066e-02f, 7.19005167e-02f, -1.02845818e-01f, -1.10974818e-01f, -8.38226154e-02f, -9.65131298e-02f, 1.03869126e-03f, -4.44561541e-02f, 5.74273095e-02f,
  1.29215464e-01f, -2.99407169e-02f, 1.44800115e-02f, -5.79798594e-02f, 8.89862850e-02f, -5.04513904e-02f, -6.68828934e-02f, 5.39293438e-02f, -3.66743281e-03f, 1.60900831e-01f,
  1.27383349e-02f, 5.60560636e-02f, -3.52213606e-02f, 4.37144302e-02f, 1.24062799e-01f, 4.46793400e-02f, 1.42641932e-01f, 4.26485129e-02f, -7.32819885e-02f, -5.09712892e-03f,
  -3.00538316e-02f, -7.56162405e-03f, 5.84322773e-03f, -8.02715346e-02f, -6.63320255e-03f, 7.25908950e-02f, -1.48032857e-02f, 3.81831191e-02f, -1.09711438e-01f, 8.11542757e-03f,
  -3.00956853e-02f, 2.06823632e-01f, -2.14196462e-02f, -3.55120599e-02f, -2.25054380e-03f, 1.54426783e-01f, 9.92155597e-02f, 5.85792214e-02f, 2.12049726e-02f, 7.13951141e-02f,
  6.62149712e-02f, -9.74612832e-02f, -2.33885460e-03f, -5.22361975e-03f, -9.96744931e-02f, 1.08896561e-01f, -6.53519258e-02f, -1.58525392e-01f, 5.59889413e-02f, 6.41234890e-02f,
  1.27039388e-01f, 6.75400645e-02f, -6.02664910e-02f, -1.85759589e-01f, -9.57216918e-02f, -2.65873782e-03f, -2.32559424e-02f, -1.37752235e-01f, 9.12847221e-02f, -6.30960986e-02f,
  -2.25156754e-01f, 5.15003681e-01f, 5.66263974e-01f, -3.41689229e-01f, -7.86707327e-02f, -1.84228882e-01f, -1.43151388e-01f, -1.03189170e-01f, -1.54914036e-01f, -2.49098063e-01f,
  -1.00285426e-01f, 3.97602260e-01f, 2.04227850e-01f, -2.92960972e-01f, -3.53003651e-01f, -1.41313644e-02f, -3.05347592e-01f, -3.08005154e-01f, -6.84847217e-03f, -1.69230282e-01f,
  -1.92286536e-01f, -4.81330663e-01f, 6.62360415e-02f, -4.97113392e-02f, -1.08848915e-01f, 1.95650652e-01f, -4.93029803e-01f, 4.07532394e-01f, -1.81605935e-01f, 1.03180043e-01f,
  -7.56361783e-02f, -1.13790669e-01f, 5.48880994e-02f, -1.32906334e-02f, -1.18948206e-01f, -6.50570244e-02f, 1.05875861e-02f, 6.69722706e-02f, -9.20504630e-02f, -9.01859850e-02f,
  -3.67848412e-03f, -1.51637627e-03f, -2.75148489e-02f, 9.66320485e-02f, -1.15907826e-01f, 1.25614747e-01f, 2.09735692e-01f, 4.47264351e-02f, 1.36888027e-01f, 1.55817330e-01f,
  1.63503677e-01f, 9.37518179e-02f, 5.11645414e-02f, -6.28492096e-03f, 1.55647367e-01f, -4.09083404e-02f, 8.44212919e-02f, 2.25224167e-01f, 5.16723320e-02f, -6.32147193e-02f,
  -1.57594591e-01f, -1.35941401e-01f, 1.64936468e-01f, -4.70875688e-02f, -3.72771882e-02f, 9.95811075e-02f, 2.89426167e-02f, 1.30995303e-01f, 1.33113176e-01f, -8.34072083e-02f,
  -8.33480284e-02f, 1.07134215e-03f, -5.07005453e-02f, -1.63526952e-01f, -5.46233244e-02f, -8.08448642e-02f, 4.65905480e-02f, 3.00393794e-02f, -1.36085585e-01f, 4.65178080e-02f,
  -5.33032194e-02f, 1.96872726e-02f, 4.35230471e-02f, -2.80436538e-02f, 2.50434037e-02f, -3.05452049e-02f, 1.24733754e-01f, 8.42189267e-02f, 2.60907616e-02f, 1.37271071e-02f,
  -5.24842143e-01f, -4.47945207e-01f, -1.59824312e-01f, -2.46917158e-02f, -1.34434059e-01f, -5.84816001e-02f, 4.89921421e-02f, -2.19311416e-02f, -1.95653155e-01f, -1.25417531e-01f,
  -8.65162760e-02f, -1.17139205e-01f, -1.21930383e-01f, -5.98705709e-02f, -1.15804998e-02f, -1.04762418e-02f, -8.97219554e-02f, -4.93357629e-02f, -1.94403112e-01f, -3.99215035e-02f,
  2.80309357e-02f, -2.77304333e-02f, 4.30560075e-02f, 6.41609170e-03f, -1.29288137e-01f, -2.68205013e-02f, -8.13082531e-02f, 6.99119568e-02f, -4.20754440e-02f, -1.09776638e-01f,
  1.38564691e-01f, -5.66761136e-01f, -9.01140645e-02f, 9.18636471e-02f, -1.42924994e-01f, -2.90150046e-01f, -1.61178768e-01f, -3.11425537e-01f, 1.88177690e-01f, -3.91075760e-01f,
  1.36782810e-01f, 9.88969579e-03f, 2.60368794e-01f, -1.50358155e-01f, 4.86890793e-01f, 3.24845701e-01f, -1.99104398e-01f, 4.79425900e-02f, 2.53499448e-01f, -2.37297475e-01f,
  1.30232140e-01f, -1.63347498e-01f, -2.88768411e-02f, -5.79185367e-01f, -2.90064365e-01f, -2.99231142e-01f, 1.59027621e-01f, -1.14253968e-01f, -2.54618943e-01f, 9.03094858e-02f,
  -3.72199118e-01f, -1.46152511e-01f, -6.64012581e-02f, -6.85638711e-02f, -9.73703861e-02f, -3.43852490e-02f, 2.19108965e-02f, 1.31671458e-01f, -1.65829249e-02f, -7.81689361e-02f,
  3.20721492e-02f, -2.11496539e-02f, -1.54156893e-01f, 8.66904110e-02f, -1.15836427e-01f, -1.85288981e-01f, -6.93287253e-02f, 5.67776375e-02f, -1.32342383e-01f, 1.04556300e-01f,
  -1.25866503e-01f, 2.25140546e-02f, 3.62106152e-02f, 6.41628504e-02f, 1.88574910e-01f, 5.53615838e-02f, 1.26944408e-01f, 1.38682812e-01f, -1.25758916e-01f, -2.26306040e-02f,
  1.80813968e-02f, 1.14883065e-01f, -2.43539922e-02f, -6.56739250e-02f, -1.55013660e-02f, -1.66932610e-03f, -1.78255253e-02f, 1.06832519e-01f, 8.85428637e-02f, 4.79176815e-04f,
  -8.58969912e-02f, 5.89861497e-02f, -9.54785943e-02f, -2.67568566e-02f, 1.23406582e-01f, 2.71126553e-02f, 4.56381477e-02f, -8.40778872e-02f, 1.46526948e-01f, 3.14832889e-02f,
  -9.84862596e-02f, -6.91024661e-02f, -6.04930744e-02f, 4.80234958e-02f, 1.26009770e-02f, 2.04537079e-01f, -9.96430665e-02f, -1.00408912e-01f, -2.85678059e-02f, -7.02579096e-02f,
  -4.94200379e-01f, -5.78644753e-01f, -1.05217174e-01f, -2.56656297e-02f, -4.25226092e-02f, -6.70279637e-02f, 1.26203373e-01f, 8.16968083e-02f, -2.47034401e-01f, -3.55719551e-02f,
  -1.31867111e-01f, -6.50054775e-03f, -6.39428943e-02f, 5.54770827e-02f, -9.78710577e-02f, -6.68391492e-03f, 1.17664672e-01f, 6.01686016e-02f, 6.01448938e-02f, -8.12019855e-02f,
  -9.25121531e-02f, -1.31681934e-02f, 6.33025030e-03f, -1.39228120e-01f, 4.63126116e-02f, 2.06781384e-02f, -8.85800198e-02f, 3.21010649e-02f, -1.75188389e-03f, 6.82567828e-04f,
  -5.39795816e-01f, 4.59681392e-01f, 5.03202736e-01f, -4.70694810e-01f, 6.24811910e-02f, 4.71734524e-01f, -2.52908319e-01f, 1.47495940e-01f, -1.91019282e-01f, -1.50585100e-01f,
  -3.05583566e-01f, 3.45822275e-01f, 1.49552330e-01f, -8.18592533e-02f, -1.46916047e-01f, -1.23573784e-02f, -2.75770396e-01f, -1.18899316e-01f, 1.45412698e-01f, -1.22450948e-01f,
  -7.03619123e-02f, -4.62699592e-01f, 1.84719548e-01f, 2.39018686e-02f, 1.54936746e-01f, 7.83781111e-02f, -4.06723082e-01f, 9.52588171e-02f, 6.73025861e-05f, 5.74025027e-02f,
  9.96044427e-02f, -3.33572388e-01f, 1.53441966e-01f, 1.45381555e-01f, -1.75609831e-02f, 6.09200448e-02f, 9.69006270e-02f, 8.13879352e-03f, -1.31245842e-02f, -9.22672264e-03f,
  4.10971045e-02f, 1.33067399e-01f, -3.22626568e-02f, -5.26575446e-02f, 1.98677853e-02f, 1.52434528e-01f, 2.33576208e-01f, 1.33601204e-01f, 9.19735432e-02f, 1.64740011e-01f,
  2.23560005e-01f, 2.33985215e-01f, 1.44814730e-01f, -5.89752980e-02f, 3.31041776e-02f, -2.45034806e-02f, -6.99039102e-02f, 6.39381185e-02f, 2.02860683e-01f, -2.82740146e-02f,
  -1.12170219e-01f, -9.48532447e-02f, 3.50737828e-03f, 3.35504152e-02f, -4.47570905e-02f, -1.89684778e-02f, 8.05645138e-02f, -4.12507355e-02f, 2.38351617e-02f, -2.23532785e-02f,
  -5.88004887e-02f, -1.16747255e-02f, -5.02793603e-02f, -7.19289705e-02f, -8.36969614e-02f, -5.94232082e-02f, 1.70250926e-02f, 1.20977640e-01f, 1.08565055e-01f, -2.49612797e-02f,
  -4.63908799e-02f, 1.14554036e-02f, -4.71279211e-02f, -2.76734643e-02f, 2.62057781e-02f, 7.76894912e-02f, 2.20517181e-02f, 1.21153913e-01f, -1.16619065e-01f, -5.60656860e-02f,
  -1.74278498e-01f, -3.20716143e-01f, 4.13835086e-02f, 5.68678081e-02f, 5.32564968e-02f, 1.78227015e-02f, 6.56635454e-03f, 6.75964579e-02f, -4.73042689e-02f, -8.01720992e-02f,
  -8.66451708e-04f, -1.38911977e-01f, 1.30314650e-02f, -3.04317717e-02f, 6.87088147e-02f, 5.00524454e-02f, -1.36318669e-01f, -1.61463022e-01f, -2.88535673e-02f, 9.02424194e-03f,
  6.89308867e-02f, -6.64366558e-02f, 3.53559852e-03f, -1.01069041e-01f, -1.76441953e-01f, -7.61423782e-02f, -1.17902063e-01f, 1.02331236e-01f, -8.24810266e-02f, 6.55014664e-02f,
  -8.26461256e-01f, 5.45815945e-01f, 2.70192772e-01f, -3.93212497e-01f, -3.70316803e-01f, 9.15467814e-02f, -2.28040829e-01f, 9.32702571e-02f, 7.48229921e-02f, 4.18875784e-01f,
  -2.86533177e-01f, 3.60028237e-01f, 3.76344115e-01f, 3.46565880e-02f, -2.47614816e-01f, 3.55308533e-01f, -1.34166092e-01f, -3.97608392e-02f, 1.18614130e-01f, -1.16324022e-01f,
  -1.10962354e-01f, -3.26271653e-01f, -9.07683596e-02f, 5.45653291e-02f, -1.92921713e-01f, -6.48726001e-02f, -3.98394436e-01f, -1.93589702e-01f, -1.31432280e-01f, -1.90255493e-01f,
  -1.92555189e-01f, -1.36844277e-01f, 1.27166823e-01f, 2.12725893e-01f, 5.25709726e-02f, 4.04385030e-02f, -1.28587499e-01f, -5.90092205e-02f, 9.14853532e-03f, 7.32623786e-02f,
  1.13116175e-01f, 1.36641786e-02f, 3.72753590e-02f, 3.45663391e-02f, -2.62751672e-02f, 2.48301532e-02f, 4.90823351e-02f, 7.21156225e-02f, 4.91123013e-02f, 2.50364728e-02f,
  1.09622426e-01f, 1.59606799e-01f, 1.51292337e-02f, 5.57965040e-02f, -4.61825542e-02f, 4.31073420e-02f, 1.21337865e-02f, -8.96672010e-02f, -1.73930936e-02f, -3.79299670e-02f,
  5.22025414e-02f, 2.93955952e-02f, 2.75601242e-02f, -1.19336452e-02f, -2.33530570e-02f, -9.23994705e-02f, -6.40594438e-02f, -1.79260552e-01f, 8.60942528e-02f, -6.34921566e-02f,
  -1.30188927e-01f, 9.25707258e-03f, -8.93069655e-02f, 8.96762162e-02f, -7.41572753e-02f, 1.55581906e-01f, 2.75164507e-02f, 3.76154459e-03f, -4.71364781e-02f, 7.44739994e-02f,
  3.61481160e-02f, -4.11259420e-02f, -4.76104505e-02f, -1.60873637e-01f, -3.11575364e-02f, 3.07555497e-02f, -5.53249605e-02f, 7.24222809e-02f, 1.68186221e-02f, -1.79174617e-01f,
  -4.46022838e-01f, -4.45657164e-01f, 6.11656085e-02f, -5.09543233e-02f, 1.21095069e-01f, 1.94992777e-02f, -5.48853874e-02f, 4.49417569e-02f, -7.70211220e-02f, 5.38159460e-02f,
  4.38710414e-02f, -1.22764474e-02f, -8.24934915e-02f, -1.19328938e-01f, 9.34341252e-02f, 9.60425287e-03f, -1.06240779e-01f, -8.34533130e-04f, -2.11515248e-01f, -7.05352873e-02f,
  -2.29002088e-02f, 2.84787342e-02f, 7.07784444e-02f, -1.65876076e-02f, -5.97295575e-02f, -5.71157485e-02f, -1.20760798e-01f, 8.67065117e-02f, -6.81901947e-02f, -2.25262996e-03f,
  2.76500881e-01f, -6.74397886e-01f, 2.77361214e-01f, 3.86273861e-01f, 3.96302372e-01f, 9.69148353e-02f, 3.38387370e-01f, -1.15177408e-01f, 8.36978927e-02f, -6.00695431e-01f,
  -2.24488363e-01f, -1.56725213e-01f, -3.23471457e-01f, 1.10513806e-01f, 3.54871273e-01f, -1.89135090e-01f, 6.34383261e-02f, -1.58473447e-01f, 2.44425312e-01f, 1.37770981e-01f,
  2.75835603e-01f, 2.14147300e-01f, 2.44393662e-01f, -6.24593943e-02f, 7.99588114e-02f, 6.87475279e-02f, -2.45357275e-01f, 1.46676704e-01f, -1.27790108e-01f, 1.34446785e-01f,
  -2.54022062e-01f, 1.00500010e-01f, 1.55015245e-01f, -1.46736139e-02f, -8.02587867e-02f, -5.29411770e-02f, -3.13670710e-02f, 7.05798939e-02f, 2.65696526e-01f, -4.17422801e-02f,
  -1.60681099e-01f, -2.76141707e-03f, 1.37618676e-01f, -4.23510745e-02f, 1.37704968e-01f, 5.95852584e-02f, 5.68062365e-02f, -2.92971656e-02f, 9.89728887e-03f, -1.25902817e-02f,
  6.01167493e-02f, -1.21771559e-01f, 1.13596983e-01f, -2.04224572e-01f, 6.78542778e-02f, 8.42742398e-02f, 1.41245633e-01f, -1.33107295e-02f, -9.69714522e-02f, 9.37799513e-02f,
  1.81412116e-01f, 1.58377990e-01f, 3.26383160e-03f, -3.08726933e-02f, -6.69545829e-02f, -4.44241464e-02f, -1.64802205e-02f, 8.80563725e-03f, -5.40326536e-02f, -7.54576847e-02f,
  -5.09827547e-02f, 5.12295440e-02f, 1.84355214e-01f, -3.75838354e-02f, 8.68203118e-02f, 6.90144300e-02f, 4.62918431e-02f, -1.45662054e-01f, 2.60277763e-02f, 4.09700051e-02f,
  4.82547656e-02f, 1.02693457e-02f, -4.52928990e-02f, 2.17914619e-02f, -3.04995403e-02f, -2.82945298e-02f, -6.18056729e-02f, -6.23865128e-02f, 1.40741989e-01f, 9.01056454e-02f,
  -5.74971378e-01f, -5.23208857e-01f, -6.05403781e-02f, -6.40849397e-02f, -8.08654651e-02f, -1.24309212e-01f, 1.69250555e-02f, -1.42344991e-02f, -1.15978539e-01f, -4.76414301e-02f,
  -1.37758896e-01f, -1.22924581e-01f, -1.20159216e-01f, 3.56917307e-02f, -4.20793742e-02f, -7.11817145e-02f, -8.22380856e-02f, -2.38819063e-01f, -6.82398900e-02f, -2.13706300e-01f,
  -1.07113108e-01f, 1.37986625e-02f, 9.25394967e-02f, 9.55853835e-02f, -5.40702119e-02f, -3.16281095e-02f, -2.99536381e-02f, -9.16919559e-02f, -4.54957969e-02f, -8.51474032e-02f,
  -1.90497607e-01f, -3.12146306e-01f, -4.51294363e-01f, 3.33803296e-02f, -9.85198766e-02f, -2.70919621e-01f, -4.35960829e-01f, 4.15403247e-02f, -3.28731030e-01f, 1.13020271e-01f,
  2.14283332e-01f, -2.38176249e-02f, -3.05977613e-01f, 5.27707279e-01f, 3.58480155e-01f, 4.77443375e-02f, 5.22754848e-01f, 3.16155136e-01f, 5.47986403e-02f, 4.80604172e-02f,
  3.12384814e-01f, 4.48720127e-01f, 3.25801790e-01f, 3.20010245e-01f, 1.59662321e-01f, 1.50613829e-01f, 3.13312382e-01f, -1.30084038e-01f, 4.75979775e-01f, 2.63648570e-01f,
  1.42979175e-01f, -8.15650895e-02f, -1.17775932e-01f, -1.26978504e-02f, -4.17117551e-02f, -3.96921374e-02f, 1.24499528e-02f, -2.54489500e-02f, -2.13755947e-02f, -5.13730049e-02f,
  -9.18298140e-02f, 2.17294842e-01f, 1.63736612e-01f, -8.75239819e-02f, -8.74378309e-02f, 9.98420757e-04f, 3.77771556e-02f, 5.42388633e-02f, -1.11206636e-01f, -7.63936713e-02f,
  -1.99037775e-01f, 3.10095642e-02f, 2.59528179e-02f, -3.57630253e-02f, -1.83076441e-01f, -1.60929665e-01f, 9.35324356e-02f, -8.86538252e-02f, 9.16176811e-02f, 2.58762557e-02f,
  -4.39539365e-03f, -3.36435288e-02f, -4.49360535e-02f, -5.87243028e-02f, -8.13521743e-02f, -3.70915458e-02f, 6.72236457e-02f, 5.11247925e-02f, -1.16846137e-01f, 5.62803149e-02f,
  -7.63014518e-03f, -5.82623370e-02f, 5.63852936e-02f, -1.36168282e-02f, 1.29670218e-01f, 1.21768843e-03f, -2.27757059e-02f, 1.02909476e-01f, -1.66390970e-01f, -3.49132977e-02f,
  7.61009380e-02f, -6.59497604e-02f, -1.36843190e-01f, 1.55670270e-01f, 1.38146803e-01f, -1.05729118e-01f, 1.32781684e-01f, -3.55642401e-02f, 3.18916664e-02f, 2.19597239e-02f,
  9.97916311e-02f, 1.10515647e-01f, 2.31302576e-03f, -1.31512862e-02f, -3.84056149e-03f, 5.39534949e-02f, 7.18960315e-02f, -1.78422909e-02f, 7.18127936e-02f, -6.12089671e-02f,
  3.77085060e-02f, -2.18287632e-02f, -2.44822731e-04f, -1.37548437e-02f, 4.64096703e-02f, -8.64149705e-02f, -6.54371977e-02f, 5.43086529e-02f, -1.87236499e-02f, 1.71895966e-01f,
  -1.92319583e-02f, -9.02857259e-02f, 7.96321407e-02f, -1.95036352e-01f, 1.76708978e-02f, 7.51439258e-02f, -4.97612469e-02f, 1.58842299e-02f, 5.53947799e-02f, 8.16437528e-02f,
  2.88338605e-02f, 5.56405425e-01f, 4.20902938e-01f, 2.41039589e-01f, -4.89270121e-01f, 1.95131287e-01f, 4.63513881e-01f, -1.59395069e-01f, 2.10686833e-01f, 2.83596128e-01f,
  -3.47973794e-01f, 5.23393095e-01f, -4.02090214e-02f, -7.54472194e-03f, -3.41404289e-01f, -1.14104494e-01f, 1.38888836e-01f, 3.65231246e-01f, 1.70530915e-01f, 2.08935454e-01f,
  -2.42255613e-01f, -2.96780288e-01f, -2.26920068e-01f, -1.82957530e-01f, 8.62476602e-02f, 2.15168610e-01f, -4.14311171e-01f, 9.51225981e-02f, 1.61522731e-01f, -1.04674735e-04f,
  -1.18342124e-01f, 1.65181056e-01f, 1.15190081e-01f, 2.31464729e-01f, -1.29893541e-01f, -8.15199167e-02f, 1.07524402e-01f, -7.41933733e-02f, -4.45948020e-02f, 8.72358307e-02f,
  2.13519529e-01f, 2.39609852e-02f, 1.63232386e-01f, -5.71766943e-02f, 1.04007185e-01f, 1.74268882e-03f, -7.59621616e-03f, 8.35767165e-02f, 1.15971178e-01f, 1.92424078e-02f,
  1.59726813e-01f, -7.53980177e-03f, -1.19080499e-01f, 7.86630437e-02f, 3.13453004e-02f, 1.45488992e-01f, 1.61528438e-01f, 1.23526774e-01f, 1.30844072e-01f, 6.08451590e-02f,
  -1.14526805e-02f, -6.49659410e-02f, -1.82070229e-02f, -9.97292548e-02f, -9.46504325e-02f, -6.25359360e-03f, 6.54574856e-02f, -1.70507431e-01f, -6.84492588e-02f, -4.46358249e-02f,
  5.46539128e-02f, 1.49104863e-01f, -2.31830943e-02f, 9.21867043e-02f, -2.09135786e-02f, 5.61344102e-02f, -1.55705705e-01f, 1.15249090e-01f, 3.01656183e-02f, 4.21488192e-03f,
  -7.66565502e-02f, 7.64844492e-02f, 4.68797842e-03f, -2.15584189e-02f, 3.85560431e-02f, -5.09580001e-02f, 4.95534390e-02f, -9.21587460e-03f, -8.12273994e-02f, 6.29916936e-02f,
  1.55457079e-01f, 3.20193201e-01f, 2.16264613e-02f, 1.17081374e-01f, 8.79447460e-02f, 5.76222837e-02f, 5.97989261e-02f, -3.42790335e-02f, 5.21670133e-02f, 3.37470658e-02f,
  3.35802250e-02f, 6.87443465e-02f, 3.28444988e-02f, -1.21013835e-01f, 5.67504577e-02f, -1.01758473e-01f, -8.13781843e-02f, 1.41591057e-01f, -5.98022155e-02f, 1.59692410e-02f,
  -5.95320538e-02f, 2.97529064e-02f, 3.27845337e-03f, 3.82860638e-02f, 1.97704397e-02f, -9.62326117e-03f, -5.45119494e-03f, -3.19471769e-02f, 6.30995259e-02f, -7.58727491e-02f,
  1.96960405e-01f, -3.99743527e-01f, -2.74934679e-01f, -2.37176821e-01f, 2.60661960e-01f, 1.84152126e-01f, -7.41345901e-03f, -2.55657017e-01f, -6.25864446e-01f, -3.04551154e-01f,
  -9.01681334e-02f, 1.33044317e-01f, -2.25149885e-01f, 2.71722049e-01f, 6.27963006e-01f, -7.96256214e-02f, 1.46333382e-01f, 3.45264047e-01f, -3.20851542e-02f, -1.79681122e-01f,
  4.42088880e-02f, 3.85315686e-01f, 2.15892047e-02f, 8.73119459e-02f, 1.65119484e-01f, -1.41706854e-01f, 2.75700748e-01f, -9.96700227e-02f, 2.89989889e-01f, 2.15250582e-01f,
  2.07441002e-02f, -1.81095183e-01f, -1.18907526e-01f, -1.28359189e-02f, -5.98153733e-02f, -1.45365566e-03f, 1.40137851e-01f, 2.20619395e-01f, 3.73146534e-02f, 8.52517933e-02f,
  1.69528231e-01f, 1.74438283e-01f, 1.88958808e-03f, 1.05715267e-01f, -5.19663468e-02f, -1.38386950e-01f, -1.47000074e-01f, -1.10446326e-01f, -5.52369282e-02f, -2.14636282e-04f,
  -1.11219876e-01f, -5.19389100e-02f, -8.00265521e-02f, 4.41832654e-02f, -5.66560365e-02f, -7.88332000e-02f, -6.31076172e-02f, 1.26153594e-02f, 6.93560988e-02f, -2.89560780e-02f,
  9.70418379e-02f, 5.02988100e-02f, 7.75821134e-02f, -1.37199145e-02f, 1.18577899e-03f, 8.23378935e-03f, 1.43511295e-01f, 7.55449310e-02f, -1.30878398e-02f, -8.76904503e-02f,
  -8.57811645e-02f, 1.00273388e-02f, -4.60133404e-02f, -3.37613523e-02f, -3.83467302e-02f, -2.74460614e-02f, 3.46500799e-02f, -6.71553006e-03f, -2.10777521e-01f, -8.33094195e-02f,
  8.05878721e-04f, -1.38383424e-02f, -1.36458576e-01f, -4.62079607e-02f, -3.51690367e-04f, -1.02637194e-01f, -7.65553191e-02f, -1.56257614e-01f, -1.52478978e-01f, 1.43240318e-01f,
  2.40052380e-02f, -1.25008121e-01f, -1.63988009e-01f, 9.28702801e-02f, -7.89942592e-03f, 1.28837183e-01f, -1.41131580e-02f, -1.42433727e-02f, -4.87864465e-02f, -4.90553491e-02f,
  9.33096260e-02f, -3.82334925e-02f, -7.28291878e-03f, -7.74895921e-02f, 1.21398672e-01f, -1.22910120e-01f, -3.24552022e-02f, -1.32728610e-02f, 4.70768139e-02f, 5.27259009e-03f,
  -7.51145929e-02f, -4.85036634e-02f, -1.23221828e-02f, -1.27632365e-01f, 4.92669120e-02f, 6.98615983e-02f, 8.02656636e-02f, -1.01858176e-01f, 1.96962595e-01f, -1.50645286e-01f,
  -1.04657426e-01f, 5.86263061e-01f, -1.27162794e-02f, 3.65664333e-01f, -4.39592451e-01f, 4.41240072e-01f, 5.70727587e-01f, -1.45224646e-01f, -1.44965351e-02f, 5.73880792e-01f,
  4.86273989e-02f, 1.15382604e-01f, 2.87492245e-01f, 5.37963033e-01f, -9.55445617e-02f, 2.72955149e-01f, 6.27499640e-01f, 3.55551958e-01f, -2.32967407e-01f, 3.11875969e-01f,
  -4.66937311e-02f, 4.53748912e-01f, 6.71420991e-02f, -8.77034813e-02f, 1.31811306e-01f, -6.01755120e-02f, 2.91380752e-02f, -4.16460961e-01f, 2.92667717e-01f, -1.16547249e-01f,
  1.09384261e-01f, 8.21566656e-02f, -6.55641109e-02f, 7.20303506e-02f, 1.33616954e-01f, -8.06182399e-02f, 1.07250124e-01f, 1.99105423e-02f, -2.30573446e-01f, 5.15730716e-02f,
  4.02154960e-02f, -5.65243103e-02f, 1.28807828e-01f, -2.98591945e-02f, -4.08534892e-02f, -8.08543190e-02f, 2.34715845e-02f, 3.69192734e-02f, 9.06963572e-02f, -1.18363118e-02f,
  7.13187382e-02f, 2.78907306e-02f, -3.59254144e-02f, 1.50983483e-01f, -8.74450654e-02f, 3.60961333e-02f, 1.43828601e-01f, 1.01813339e-01f, 4.06359620e-02f, 6.37114979e-04f,
  -4.97471914e-02f, 1.71510518e-01f, 3.13295573e-02f, 1.94893070e-02f, -9.05055776e-02f, -1.49107322e-01f, 7.09370524e-02f, 4.11460847e-02f, -1.28344476e-01f, 5.87944537e-02f,
  -3.33252698e-02f, -1.00182965e-01f, 3.95885408e-02f, 9.73620191e-02f, -2.61340961e-02f, 1.36471257e-01f, -2.17695478e-02f, -1.00398436e-01f, 6.79756254e-02f, -9.34634507e-02f,
  -5.91653660e-02f, -7.05648400e-03f, 1.18889347e-01f, 3.53464000e-02f, 6.42459616e-02f, -3.04805953e-02f, 1.60799921e-01f, -9.38833281e-02f, -1.88231423e-01f, -5.06530926e-02f,
  1.83262616e-01f, 3.15074891e-01f, -4.70582619e-02f, 5.15569411e-02f, 1.26394808e-01f, 9.80841964e-02f, 5.11697792e-02f, 5.94657324e-02f, 1.00652002e-01f, 5.52839860e-02f,
  4.42247875e-02f, 2.22202949e-02f, 7.70732835e-02f, -1.66268528e-01f, -1.51688740e-01f, 1.82284221e-01f, 2.51378894e-01f, 5.23520112e-02f, 4.44764458e-02f, -1.11531734e-01f,
  4.16360572e-02f, -1.30788814e-02f, -4.83204145e-03f, -4.63111922e-02f, 1.43506870e-01f, 1.21145174e-01f, -6.34954423e-02f, -1.45322591e-01f, -4.25124764e-02f, 1.46288052e-01f,
  4.99882028e-02f, -2.66889781e-01f, -1.56422898e-01f, -6.20656610e-01f, -1.14499040e-01f, 1.05503269e-01f, -3.99473190e-01f, -1.11966178e-01f, -2.49236360e-01f, 2.96266582e-02f,
  -1.93031341e-01f, -3.78347397e-01f, -2.29236245e-01f, -4.80702460e-01f, -3.27983722e-02f, -8.39266554e-02f, -2.31661737e-01f, -3.68753046e-01f, -1.72454759e-01f, -3.68735850e-01f,
  -1.78321898e-01f, -4.50865924e-01f, -2.80322105e-01f, 8.28169845e-03f, -3.32528651e-01f, 9.25603788e-03f, 3.64619553e-01f, -1.44602761e-01f, -1.48011506e-01f, -4.17727344e-02f,
  2.47977413e-02f, -1.45122528e-01f, 3.71287391e-02f, 2.16074139e-02f, 1.19052313e-01f, 1.01900943e-01f, 5.99730648e-02f, -9.27684307e-02f, -9.88762379e-02f, -8.49919617e-02f,
  3.39827538e-02f, -2.49819551e-02f, -1.12225004e-01f, -1.31165579e-01f, -1.17381014e-01f, -7.89545029e-02f, -1.51131302e-01f, 1.49468526e-01f, -1.74438491e-01f, 8.50510523e-02f,
  -2.83840209e-01f, 6.57422617e-02f, 1.33214787e-01f, -4.51474674e-02f, -1.19472750e-01f, -6.13847338e-02f, 1.58775508e-01f, -6.46257624e-02f, 2.40900610e-02f, -1.22360336e-02f,
  4.17915508e-02f, 2.76261792e-02f, 3.30232829e-02f, -1.34637550e-01f, -5.94103932e-02f, 1.27708212e-01f, -1.16509730e-02f, -5.97374439e-02f, -1.82675309e-02f, -9.86262411e-03f,
  -9.24099833e-02f, -1.45463005e-01f, 9.58401151e-03f, -1.37562547e-02f, -2.61860788e-02f, 7.64926150e-02f, 9.14037973e-03f, -6.50718063e-02f, -2.39945590e-01f, 2.41166666e-01f,
  -1.17810108e-01f, -6.87887818e-02f, -1.50104657e-01f, -3.02290879e-02f, 1.06013440e-01f, 1.01395207e-03f, 3.44611034e-02f, -7.58822784e-02f, 1.02139637e-02f, 1.39552793e-02f,
  1.19442925e-01f, 6.90649077e-02f, 3.86415385e-02f, 2.58389814e-03f, -2.30007060e-02f, 3.33303288e-02f, 7.20644742e-02f, -1.09212808e-01f, -1.35907531e-01f, -4.06817719e-02f,
  1.83642477e-01f, -1.37407392e-01f, 3.00309896e-01f, 2.71439776e-02f, -6.66689500e-02f, 6.45406097e-02f, -6.11527264e-03f, 7.42434338e-02f, 7.71030188e-02f, 1.11784838e-01f,
  1.80181619e-02f, 3.69742177e-02f, 1.23701394e-02f, -1.02344537e-02f, 3.36020105e-02f, 1.99412648e-02f, 2.17362642e-01f, -1.28256410e-01f, 7.40698399e-03f, 2.71619055e-02f,
  4.54328090e-01f, -4.64830846e-01f, -1.97601989e-01f, -2.62527645e-01f, -2.56577507e-02f, 6.72044531e-02f, 1.92507789e-01f, -3.27337474e-01f, -1.13298167e-02f, -2.31282875e-01f,
  -1.89605445e-01f, 1.62012771e-01f, 5.06256521e-01f, -3.70449305e-01f, 5.93222618e-01f, 3.42576146e-01f, -1.36208087e-01f, -4.62192819e-02f, 5.16368411e-02f, -1.59379736e-01f,
  1.14290774e-01f, -1.72868490e-01f, -9.44544524e-02f, -4.98669803e-01f, -2.29797646e-01f, -3.89453948e-01f, -1.95147857e-01f, -4.13967818e-02f, -3.93580317e-01f, -3.50073688e-02f,
  -1.01392500e-01f, -2.68984921e-02f, 9.16694198e-03f, 4.38662879e-02f, -1.63677782e-01f, -7.01816827e-02f, -9.25258249e-02f, 6.70128912e-02f, 7.26449266e-02f, 1.01739220e-01f,
  6.97518513e-02f, 1.60763577e-01f, -1.75098315e-01f, 1.17778428e-01f, -5.31829335e-02f, -1.51395038e-01f, 3.46972123e-02f, -7.30812997e-02f, -6.37086406e-02f, 7.83469304e-02f,
  1.19868010e-01f, 3.91038582e-02f, -9.26507711e-02f, -4.48842086e-02f, -3.45385005e-03f, -4.66933101e-02f, -1.37892962e-02f, 1.03404857e-01f, -6.37369230e-03f, -3.96074466e-02f,
  -1.19570836e-01f, 2.08152621e-03f, 1.63467284e-02f, -1.07916683e-01f, 8.87289867e-02f, -6.35394379e-02f, -1.35451946e-02f, -8.97193775e-02f, -3.92652862e-02f, -7.59076420e-03f,
  6.77690580e-02f, -5.68012968e-02f, -2.49709077e-02f, 5.71849979e-02f, -1.83202699e-02f, 4.49318364e-02f, 7.11729750e-02f, 7.86670744e-02f, -7.35920742e-02f, 6.33664429e-03f,
  4.82535884e-02f, 2.60366164e-02f, 1.15743339e-01f, -8.08471516e-02f, -1.22645304e-01f, 1.55577958e-01f, -7.30841160e-02f, -7.49549493e-02f, -6.47987276e-02f, 2.27473050e-01f,
  -4.11019772e-02f, -2.97199398e-01f, 4.31907140e-02f, -3.76992933e-02f, -1.15955107e-01f, -1.17540330e-01f, -1.13013238e-01f, -1.76498771e-01f, -1.10871062e-01f, 5.14703244e-02f,
  -2.17709988e-01f, -9.18367431e-02f, -4.51623052e-02f, -7.90121630e-02f, 2.23576427e-02f, -1.81266323e-01f, 2.70110145e-02f, 4.21047099e-02f, -4.62596714e-02f, -1.70261357e-02f,
  -3.09840590e-02f, 4.65261117e-02f, 9.10601318e-02f, -1.06749728e-01f, -6.05685078e-02f, -7.00193420e-02f, 6.96998313e-02f, 5.40073775e-02f, 8.25140551e-02f, -7.02013299e-02f,
  2.81809438e-02f, -3.25140953e-01f, 5.56498766e-01f, 5.63940346e-01f, -2.41245002e-01f, -2.95970410e-01f, 3.63690048e-01f, -3.35855722e-01f, -2.25268990e-01f, -3.54717940e-01f,
  6.87038666e-03f, 3.46229076e-01f, 1.71272337e-01f, 1.99649543e-01f, 5.75485170e-01f, 1.44932449e-01f, -4.88478243e-02f, 1.30921006e-01f, -1.07384361e-01f, 4.33110893e-02f,
  3.21984217e-02f, 1.09008662e-01f, 4.27650899e-01f, -2.84289271e-01f, 4.75491807e-02f, 1.49218589e-01f, 4.04571027e-01f, 2.77206719e-01f, 1.91223189e-01f, 1.41893432e-01f,
  -3.39589119e-01f, 2.72919964e-02f, -4.31388170e-02f, -1.40354604e-01f, -1.40136555e-01f, -8.68658349e-02f, 1.60261244e-01f, 2.76592225e-01f, 1.92529678e-01f, -1.01922499e-02f,
  -4.72401939e-02f, -4.51122262e-02f, -4.20655943e-02f, 6.59899637e-02f, -9.49309170e-02f, -1.12522617e-02f, -1.53252646e-01f, -8.26257840e-02f, 2.85752341e-02f, -4.37241755e-02f,
  6.12025745e-02f, -7.35850930e-02f, 3.66626680e-02f, 4.49703634e-02f, 6.81252256e-02f, -5.86449243e-02f, 7.31557757e-02f, 6.49734139e-02f, -3.74461198e-03f, -7.61005469e-03f,
  2.82642078e-02f, 1.85406918e-03f, -5.86088467e-03f, -1.43148249e-03f, 7.84970298e-02f, 9.15155336e-02f, 3.79797444e-02f, 4.53932434e-02f, 8.38797837e-02f, 3.83315491e-03f,
  -7.01582953e-02f, -3.57028912e-03f, -1.04355790e-01f, -1.26227498e-01f, 6.59069121e-02f, -9.63540450e-02f, 7.14256689e-02f, -1.14374846e-01f, -8.70851129e-02f, -1.61028001e-02f,
  5.15315756e-02f, 8.57852120e-03f, 4.90509756e-02f, 1.27694523e-02f, -6.50807023e-02f, 2.69237650e-03f, 5.01858480e-02f, 8.53506569e-03f, 5.58282025e-02f, 1.65816799e-01f,
  -1.39878646e-01f, 3.37070197e-01f, -7.48831546e-03f, -1.94105834e-01f, 1.35154733e-02f, -1.54736444e-01f, 7.75408223e-02f, -1.92817941e-01f, 1.14352442e-01f, -9.41819921e-02f,
  -1.91662043e-01f, -4.69851494e-02f, -7.08116442e-02f, 1.10203156e-03f, -3.95517498e-02f, 4.72681858e-02f, 1.95197821e-01f, 3.75155658e-02f, 8.89930967e-03f, 2.68351641e-02f,
  6.85058534e-02f, 5.28708138e-02f, 3.16853411e-02f, -1.42802373e-01f, -4.50684726e-02f, 1.26998816e-02f, -3.73866372e-02f, -7.10230842e-02f, -4.75051207e-03f, 3.84944938e-02f,
  5.26667237e-01f, -6.84587136e-02f, 3.47901285e-01f, 4.63216633e-01f, 9.29327086e-02f, -3.75169039e-01f, -2.94283219e-02f, 1.90347079e-02f, 3.19845468e-01f, -2.83424735e-01f,
  -2.93788463e-01f, 3.54310185e-01f, -4.61341918e-01f, 2.16836169e-01f, -3.20033967e-01f, -3.80512238e-01f, 9.12928507e-02f, 1.66060522e-01f, -8.78800871e-04f, 9.07793343e-02f,
  1.14950731e-01f, -4.05879647e-01f, 7.69835487e-02f, -2.54770637e-01f, 1.71586052e-01f, 3.31432074e-01f, -3.39335024e-01f, -1.37853473e-01f, 1.94026768e-01f, -2.83837933e-02f,
  1.08821467e-02f, 1.41370982e-01f, 1.43524826e-01f, -2.15624310e-02f, -4.12422791e-02f, -3.59163359e-02f, 1.56084433e-01f, 5.47553636e-02f, 3.96644399e-02f, 1.34209737e-01f,
  1.14848614e-01f, 1.65845882e-02f, 1.51544884e-01f, 3.40434201e-02f, 6.26054406e-02f, 1.25456259e-01f, 1.45334587e-01f, 6.22516982e-02f, 1.56970099e-02f, 2.04344645e-01f,
  3.87874953e-02f, 1.30892172e-01f, 2.74580307e-02f, 4.58892919e-02f, 1.40392736e-01f, 3.02598383e-02f, 1.44690007e-01f, 2.10836856e-03f, -3.76172513e-02f, 9.51731205e-02f,
  -2.94177942e-02f, -1.07370421e-01f, -8.86376947e-02f, -1.65591296e-03f, -1.13378480e-01f, 4.76528937e-03f, -8.22401568e-02f, -5.84309781e-03f, 9.11845565e-02f, -8.21114853e-02f,
  -1.16063185e-01f, 9.95575786e-02f, -2.15989370e-02f, -3.98577936e-02f, -3.22094467e-03f, 1.86298966e-01f, 3.46466750e-02f, 7.55431429e-02f, 6.17098510e-02f, 1.21851601e-01f,
  -4.81121913e-02f, 8.35412927e-03f, 1.27761271e-02f, 2.97358539e-02f, -6.11014143e-02f, -5.27565368e-02f, 3.73684280e-02f, 1.33961707e-01f, -9.67113394e-03f, -1.76931560e-01f,
  -6.36108398e-01f, -5.43195605e-01f, -1.14437282e-01f, -2.38128919e-02f, -1.28696337e-01f, -3.84977013e-02f, 4.87324335e-02f, 8.76732841e-02f, -2.42806748e-01f, -1.02253228e-01f,
  2.23023295e-02f, 1.04504839e-01f, -5.85712306e-03f, 1.68465413e-02f, -1.66964829e-01f, -4.94147837e-02f, -1.02483489e-01f, -5.30140512e-02f, -1.47152722e-01f, -3.15479413e-02f,
  -1.45643800e-02f, -6.89322948e-02f, 1.74218565e-02f, 1.02883287e-01f, 2.69127004e-02f, -2.55519524e-02f, 8.63822401e-02f, 3.91500816e-02f, -3.28949615e-02f, -3.69766951e-02f,
  -4.11686212e-01f, -5.38522661e-01f, -4.95047659e-01f, -2.57358313e-01f, 3.66098046e-01f, 2.66544014e-01f, 1.23931840e-02f, -2.38584086e-01f, -4.23483402e-01f, 8.07083696e-02f,
  2.06637353e-01f, -2.84843832e-01f, -3.02056044e-01f, -3.66498053e-01f, -4.08309937e-01f, -3.87112290e-01f, -3.60063344e-01f, -2.11272940e-01f, -3.93878549e-01f, -4.61681783e-02f,
  -1.37520626e-01f, 1.50929868e-01f, -2.45216966e-01f, 3.27508807e-01f, 1.75928876e-01f, 2.51073778e-01f, 3.42090279e-01f, 3.28292936e-01f, 3.48086953e-01f, 1.26504555e-01f,
  -1.66507438e-01f, -3.24670613e-01f, -9.16397497e-02f, -5.66083081e-02f, -5.74066024e-03f, 1.97586834e-01f, 1.08289175e-01f, 4.67001423e-02f, 6.19282164e-02f, -8.09172317e-02f,
  1.59514397e-01f, 8.31341743e-02f, 1.85598880e-02f, -6.25404790e-02f, -1.76152159e-02f, 1.08869702e-01f, -8.69009718e-02f, -4.62673977e-02f, -3.82394455e-02f, -9.11177620e-02f,
  -2.51149893e-01f, -1.06995832e-02f, -7.32711852e-02f, -4.85748164e-02f, -3.54459099e-02f, 1.03892930e-01f, 8.45639035e-02f, 1.30978972e-01f, -1.68429062e-01f, -7.88328797e-02f,
  -1.68618672e-02f, 1.01938874e-01f, -9.24755707e-02f, -1.54080480e-01f, 9.50368214e-03f, -5.04397862e-02f, -1.11928672e-01f, -1.10628232e-02f, -1.63672455e-02f, 7.50566460e-03f,
  6.74042255e-02f, -9.03923661e-02f, 2.53864061e-02f, 3.51841822e-02f, -2.69776266e-02f, -5.77956028e-02f, 1.57994567e-03f, 1.57759339e-01f, 9.28190276e-02f, -7.53980651e-02f,
  -4.57865782e-02f, -1.56860556e-02f, 1.40114069e-01f, -8.26855823e-02f, -1.32919475e-01f, 1.09170832e-01f, 1.61627457e-01f, -1.41965330e-01f, -3.69525589e-02f, 1.24206804e-01f,
  3.60944010e-02f, -1.77580621e-02f, -3.33644822e-02f, 1.57861426e-01f, -1.10494509e-01f, 1.02795996e-01f, -1.60859510e-01f, -2.66000722e-02f, 5.02918847e-02f, -1.05981670e-01f,
  1.11945339e-01f, 1.04233488e-01f, 5.94836585e-02f, -8.96252617e-02f, 6.56907111e-02f, -2.67287996e-02f, 2.03237653e-01f, 1.83806196e-01f, 3.43582295e-02f, 1.03190199e-01f,
  1.75093770e-01f, 2.45475411e-01f, -1.22548761e-02f, 1.09168127e-01f, 1.36383548e-01f, 8.65151584e-02f, 4.68316376e-02f, 8.33420604e-02f, -1.71922613e-02f, 8.42192210e-03f,
  5.76907098e-01f, 2.58203536e-01f, -1.69080034e-01f, 1.05135059e-02f, -4.97945137e-02f, -6.11420989e-01f, -9.02435109e-02f, -9.82146263e-02f, -9.39205661e-03f, 2.21348554e-01f,
  -9.94847193e-02f, 4.69579190e-01f, 1.90758914e-01f, -9.01425350e-03f, -6.95039392e-01f, -1.63710341e-01f, -4.70314234e-01f, 3.16751599e-02f, 1.42130777e-01f, -1.00269087e-01f,
  -2.19815537e-01f, -2.12344289e-01f, -1.51946291e-01f, 5.24409153e-02f, 3.55526298e-01f, 2.04119295e-01f, -2.56723046e-01f, 2.21981406e-01f, -5.91157861e-02f, -4.50600404e-03f,
  1.25015840e-01f, 2.69063354e-01f, 1.34952977e-01f, -1.07922582e-02f, -2.19584942e-01f, 1.25500560e-01f, 1.31210208e-01f, -4.03733738e-03f, 9.23831910e-02f, 5.31376041e-02f,
  1.62865102e-01f, 1.44037217e-01f, -6.60501048e-02f, 3.39432657e-02f, 2.78191626e-01f, 9.43508931e-03f, 6.92989007e-02f, -7.35597685e-02f, 1.72310412e-01f, 8.10704827e-02f,
  1.62187263e-01f, 5.20074591e-02f, -2.51770355e-02f, 4.64069322e-02f, -1.18110694e-01f, 5.30923763e-03f, -7.28518367e-02f, -7.00746328e-02f, -6.14069588e-03f, 9.60934907e-02f,
  1.63891017e-01f, 4.11951095e-02f, 9.06699523e-02f, 1.64289311e-01f, -1.00569785e-01f, 1.38638943e-01f, -9.77059733e-03f, -5.18453419e-02f, 6.65128976e-02f, 2.55620964e-02f,
  -1.18720971e-01f, 6.55686408e-02f, 1.08169354e-01f, -5.24411462e-02f, -9.52092465e-03f, 1.15400590e-01f, 3.21863517e-02f, 2.32574698e-02f, -2.18114048e-01f, 1.05332732e-02f,
  1.07595257e-01f, -1.26781777e-01f, 4.80603948e-02f, 1.87816452e-02f, -8.69133249e-02f, -4.62755337e-02f, 2.58844681e-02f, -1.13478675e-02f, -6.82239756e-02f, -1.87807843e-01f,
  -4.40013945e-01f, -2.42313892e-01f, -9.99491848e-03f, 3.23724747e-02f, 2.29740585e-03f, -7.68980235e-02f, 2.96858065e-02f, -5.64282238e-02f, -3.06045320e-02f, -7.33207390e-02f,
  -6.03261739e-02f, 1.10297851e-01f, -1.42866328e-01f, 7.26075694e-02f, -5.91322444e-02f, -2.03402191e-01f, -1.61693860e-02f, 3.19807269e-02f, -2.05111325e-01f, -3.10326684e-02f,
  -3.05582453e-02f, 1.00098796e-01f, -6.41142577e-02f, -6.24301322e-02f, -1.94610041e-02f, -2.80192140e-02f, -9.51579884e-02f, 8.82086009e-02f, -8.33156109e-02f, -1.08674370e-01f,
  4.01705325e-01f, -5.13131730e-02f, -2.89441437e-01f, 3.52116019e-01f, 5.26198223e-02f, 2.51941562e-01f, 3.64122510e-01f, 2.64681846e-01f, 4.07496154e-01f, 1.74893588e-01f,
  2.54454553e-01f, -1.53632730e-01f, -1.05567835e-01f, 3.57605964e-01f, 2.53045261e-01f, -5.16019948e-02f, 5.23035347e-01f, 1.58478528e-01f, 6.28762841e-02f, 3.05824906e-01f,
  2.59746850e-01f, 4.45017278e-01f, -2.77175307e-01f, -1.26335248e-02f, 1.80798143e-01f, -1.38144433e-01f, -1.64269313e-01f, -4.18103456e-01f, -2.17306986e-01f, -2.19939157e-01f,
  3.92835438e-02f, 1.81372449e-01f, -2.15744767e-02f, -1.54958159e-01f, 7.31424093e-02f, 5.14200293e-02f, -1.95915103e-01f, -1.60547137e-01f, -8.47532153e-02f, 3.63199040e-02f,
  -3.03776539e-03f, 2.04247497e-02f, 9.97594073e-02f, -9.77887884e-02f, 9.99417081e-02f, -2.48664338e-02f, 5.67761734e-02f, -2.04110965e-02f, -1.63572744e-01f, -6.72462508e-02f,
  2.41517592e-02f, 2.55266912e-02f, 1.92104712e-01f, -5.15685119e-02f, 3.17177810e-02f, 1.13898851e-01f, -3.20294239e-02f, -7.95077533e-02f, -6.10905997e-02f, 7.12995306e-02f,
  1.54579282e-02f, 2.28393916e-02f, 9.20894742e-02f, 8.60916749e-02f, -2.81029530e-02f, 6.65921345e-03f, 3.34349386e-02f, -1.08831905e-01f, 1.03532009e-01f, 5.48321009e-03f,
  -7.49937817e-03f, -4.99253795e-02f, 1.17004886e-01f, -2.24968400e-02f, 1.01655662e-01f, -2.91822478e-02f, -9.13631320e-02f, -6.18577488e-02f, 1.09581299e-01f, 2.45199427e-02f,
  -9.90723297e-02f, -1.96033195e-02f, 7.25341439e-02f, -9.08083245e-02f, -9.44804028e-02f, -4.59856056e-02f, 7.57844970e-02f, 1.19962335e-01f, 5.73283574e-03f, -1.59378015e-02f,
  1.50086746e-01f, 5.59189022e-02f, 4.63195816e-02f, -1.95469305e-01f, -1.12891048e-01f, 1.64423242e-01f, -3.17384638e-02f, -2.67705582e-02f, -6.65319860e-02f, 7.68460184e-02f,
  2.37614855e-01f, -8.05034339e-02f, 1.14732258e-01f, -1.11880414e-02f, -5.85042238e-02f, 2.66873449e-01f, -5.76946698e-02f, -1.28258383e-02f, 4.48575243e-02f, -4.29711118e-02f,
  -1.04330301e-01f, 2.06650719e-01f, 1.31536856e-01f, 2.90190540e-02f, -8.30667764e-02f, 1.08194612e-02f, 6.44366443e-02f, 4.41418327e-02f, 4.29676939e-03f, -8.11610892e-02f,
  4.56583768e-01f, -4.81899202e-01f, 1.17768452e-01f, -1.07829280e-01f, 1.98727012e-01f, -2.18496859e-01f, 2.32223030e-02f, -3.62406999e-01f, -1.59711186e-02f, -4.92866814e-01f,
  -1.57489657e-01f, 5.99629804e-02f, 1.93613753e-01f, -4.18083310e-01f, 5.03600597e-01f, 2.00230107e-01f, -3.17228734e-01f, -3.56240392e-01f, 1.56145602e-01f, -2.89682746e-01f,
  4.39845845e-02f, -4.81602669e-01f, 5.43179214e-02f, -6.00257337e-01f, -1.58680007e-01f, -2.25696087e-01f, -1.66013300e-01f, -1.07621513e-01f, -4.28121030e-01f, 7.51037300e-02f,
  5.95639758e-02f, -3.61439586e-02f, 1.12647610e-02f, 5.13681062e-02f, -2.10863836e-02f, 6.10146625e-03f, 2.42107362e-03f, 2.52694208e-02f, 1.38113126e-01f, 1.68735497e-02f,
  -8.16608295e-02f, -2.66746096e-02f, -1.51936814e-01f, -1.08599462e-01f, -1.97966676e-02f, -5.08198328e-02f, 2.88845580e-02f, 1.17792509e-01f, -1.10127099e-01f, 2.80908912e-01f,
  1.20954350e-01f, 1.69922024e-01f, 1.57037109e-01f, -4.86299628e-03f, 1.04103170e-01f, -2.03513224e-02f, -2.92119160e-02f, 1.49884522e-01f, -1.14988588e-01f, 6.79821894e-03f,
  -1.67771474e-01f, 6.48576170e-02f, 6.41114786e-02f, 6.44237921e-02f, 3.46975178e-02f, -1.15662059e-02f, -1.30106196e-01f, -5.38571663e-02f, 6.93897158e-02f, 5.74187897e-02f,
  9.80891567e-03f, 5.61758392e-02f, -2.55377889e-02f, -3.68748046e-02f, -8.39459943e-04f, 8.99864659e-02f, 9.55575705e-03f, -1.39196947e-01f, 1.54289365e-01f, 7.73483738e-02f,
  2.02166885e-02f, -9.70678180e-02f, 3.88541631e-02f, 3.87378633e-02f, -9.08381864e-02f, 7.54598901e-02f, -2.43226573e-01f, 2.01068036e-02f, 2.48285849e-02f, 2.59744525e-02f,
  -1.06153153e-01f, -6.52017951e-01f, -1.15344018e-01f, -9.71501246e-02f, 3.45332548e-02f, 1.68728039e-01f, -8.89281109e-02f, -1.08173169e-01f, -7.73927569e-03f, -2.19972834e-01f,
  -1.29546940e-01f, -1.10833153e-01f, 3.61230597e-03f, 6.93006217e-02f, -1.09112203e-01f, -1.91156819e-01f, -1.77354887e-01f, -1.50211649e-02f, -6.14449270e-02f, -1.19165145e-01f,
  -2.06185207e-01f, -1.85737401e-01f, -2.10695211e-02f, -4.17139865e-02f, -1.50160193e-01f, 3.28316614e-02f, 7.54841231e-03f, 6.67206496e-02f, 5.04656583e-02f, -1.10539377e-01f,
  1.25866085e-01f, 4.39530194e-01f, -3.31040710e-01f, 4.52491850e-01f, -5.98482341e-02f, 7.03136802e-01f, 6.10340416e-01f, 2.28025559e-02f, 3.41158271e-01f, 4.16893333e-01f,
  2.10628599e-01f, -1.38510957e-01f, -8.38112552e-03f, 6.13185525e-01f, 1.30297408e-01f, 4.27756876e-01f, 4.55259264e-01f, 3.44670922e-01f, 4.24819216e-02f, 2.99223542e-01f,
  2.52167489e-02f, 4.71194416e-01f, -4.45674688e-01f, -1.58779368e-01f, 1.04477100e-01f, -4.11921829e-01f, -3.46631467e-01f, -4.97078836e-01f, -1.65647015e-01f, -1.09161705e-01f,
  -2.08116788e-02f, 5.57130314e-02f, -1.97839096e-01f, -7.23029524e-02f, 4.53487597e-02f, -1.78807564e-02f, -1.05304457e-02f, -2.14334294e-01f, -1.44910708e-01f, -1.26443148e-01f,
  1.27549633e-01f, -1.21812299e-01f, 7.81403258e-02f, -1.34294957e-01f, 2.10117688e-03f, 1.14071853e-02f, 3.76786408e-03f, -1.88621301e-02f, -8.43383521e-02f, -1.33485764e-01f,
  6.21031672e-02f, 4.03042696e-02f, 1.28824174e-01f, 5.53225279e-02f, -1.29691169e-01f, -1.89111773e-02f, 8.92966166e-02f, -8.62976238e-02f, 1.70544028e-01f, 1.35566546e-02f,
  -4.89834324e-02f, 1.54556781e-01f, -3.99626270e-02f, -8.01392719e-02f, 4.32157889e-02f, -5.60112707e-02f, 4.40057553e-02f, 9.86272842e-03f, 1.99882090e-02f, 8.09789374e-02f,
  4.34061922e-02f, -4.23446596e-02f, -1.05476379e-01f, -1.24150356e-02f, 1.48470446e-01f, 6.28859103e-02f, -8.59385356e-02f, -1.16043892e-02f, 6.90837130e-02f, -5.92568405e-02f,
  -1.06415354e-01f, 1.80905238e-01f, -1.42135516e-01f, -1.06229179e-01f, 1.36767894e-01f, -8.85168985e-02f, 1.30828604e-01f, -8.13220218e-02f, 3.69854039e-03f, 2.71854568e-02f,
  2.99062043e-01f, 3.47958177e-01f, 4.83627543e-02f, 5.32897338e-02f, 1.01091661e-01f, -2.58259545e-03f, 1.99051321e-01f, 8.40898901e-02f, -5.83007187e-02f, 6.52675554e-02f,
  6.68900833e-02f, 7.30880648e-02f, 2.48725742e-01f, -1.43350855e-01f, 6.38039112e-02f, 7.31808469e-02f, 1.45274788e-01f, -3.82195115e-02f, 1.43536717e-01f, -5.59660140e-03f,
  -3.13693248e-02f, 1.82213932e-01f, 1.45543367e-01f, 3.03858649e-02f, 1.52795270e-01f, 1.16680115e-02f, 1.31759688e-01f, -1.23267137e-01f, -1.42137120e-02f, 2.28282697e-02f,
  7.76317418e-01f, -3.66876394e-01f, 2.55244106e-01f, 4.78282005e-01f, 3.45493376e-01f, 1.47805512e-01f, 1.17610209e-01f, 2.80875057e-01f, 2.12858766e-01f, -3.94172728e-01f,
  -9.74962786e-02f, 9.69345123e-02f, -4.39611644e-01f, 2.32000530e-01f, -8.88348520e-02f, -3.77355486e-01f, 1.56213596e-01f, -1.68172672e-01f, 3.81118134e-02f, 1.30128697e-01f,
  2.43797362e-01f, -2.12852359e-01f, 6.05529407e-03f, -1.15555920e-01f, 3.27558458e-01f, 1.78579599e-01f, -2.35247314e-01f, -2.26281315e-01f, 6.51738271e-02f, -2.32134685e-02f,
  -3.83454226e-02f, 1.25417948e-01f, 9.73424595e-03f, -5.70728853e-02f, 1.06892800e-02f, -3.93419750e-02f, 9.16870832e-02f, -1.11011781e-01f, 5.28727174e-02f, 5.39915003e-02f,
  -1.76100116e-02f, 1.23115338e-01f, 5.89135326e-02f, -1.23204142e-02f, 1.49113789e-01f, 2.04019994e-01f, 1.25734359e-01f, 7.22997189e-02f, 4.21542004e-02f, 2.06366688e-01f,
  1.28492653e-01f, 1.14910387e-01f, 1.67771161e-01f, -4.18462008e-02f, -2.60477737e-02f, 1.07083485e-01f, 1.09866321e-01f, -5.93194291e-02f, 5.47634549e-02f, 1.28073737e-01f,
  -1.86603665e-01f, -1.19604476e-01f, 1.13799475e-01f, 1.61543697e-01f, 7.57829053e-03f, 6.43487200e-02f, 1.89929586e-02f, 1.64178689e-03f, 2.12478470e-02f, -8.77413377e-02f,
  8.86372551e-02f, 7.35276118e-02f, -9.31147859e-03f, 3.10989469e-02f, -8.20979883e-04f, 1.25053013e-02f, 6.58970177e-02f, -3.55579033e-02f, -3.43827880e-04f, 2.97660809e-02f,
  -1.35978302e-02f, -2.70073954e-02f, -5.28226756e-02f, 2.01966271e-01f, -1.09505676e-01f, -1.29760712e-01f, 5.82173280e-02f, 5.37281334e-02f, -5.54470681e-02f, -1.41099870e-01f,
  -6.41000271e-01f, -6.47425890e-01f, -2.63150930e-01f, -1.75933968e-02f, -1.71312705e-01f, -1.08958758e-01f, -5.13267219e-02f, 1.50143504e-01f, -2.73594528e-01f, -6.69240020e-03f,
  -5.15966862e-02f, 7.40012303e-02f, -1.55416906e-01f, -4.13593650e-02f, -1.53105170e-01f, -8.00872128e-03f, -2.88371071e-02f, -1.86602414e-01f, -1.37902528e-01f, 2.47054733e-02f,
  -6.02048971e-02f, -1.01080284e-01f, 2.88493540e-02f, 1.00281194e-01f, 4.82903905e-02f, -1.57946780e-01f, -8.99378732e-02f, 8.95629823e-02f, 3.57463732e-02f, -1.58279762e-01f,
  -8.46898556e-01f, 4.32535470e-01f, -2.74344883e-03f, -4.22913700e-01f, 3.19336578e-02f, -3.16785187e-01f, -2.62883812e-01f, 1.26940742e-01f, -1.70795366e-01f, 1.52351722e-01f,
  1.29963621e-01f, -1.80998206e-01f, 3.92678797e-01f, -5.76950759e-02f, -2.43742317e-01f, 2.40350172e-01f, -3.44555587e-01f, -3.36332560e-01f, 3.68959382e-02f, -3.25903684e-01f,
  -2.02098891e-01f, -1.60188273e-01f, -6.94041252e-02f, 2.60299861e-01f, -2.42791697e-01f, -9.76078138e-02f, -1.15705252e-01f, 2.95683414e-01f, -2.33248487e-01f, 5.38619608e-02f,
  -3.28915775e-01f, 8.88467534e-04f, -1.39519334e-01f, 3.44189554e-02f, -1.88210964e-01f, -1.49863333e-01f, -1.49845496e-01f, 8.74081685e-04f, 8.97197612e-03f, 1.68837048e-02f,
  -1.42785892e-01f, 6.53264374e-02f, 2.00559348e-02f, 1.56172588e-01f, -9.60389338e-03f, 2.14319918e-02f, 1.39300540e-01f, -2.23795790e-02f, 4.84218728e-03f, -2.04148199e-02f,
  3.43536884e-02f, -5.22813275e-02f, -1.04348980e-01f, 3.83370258e-02f, -4.91453670e-02f, -4.57455888e-02f, -3.87528092e-02f, -6.33910373e-02f, -6.82963729e-02f, -6.42670020e-02f,
  9.89759341e-02f, -1.71647333e-02f, 3.77913169e-03f, 8.74372348e-02f, -8.02009483e-04f, 3.71922962e-02f, 3.82367224e-02f, -4.92747873e-02f, 8.74410719e-02f, -1.07202437e-02f,
  -2.18463279e-02f, 7.70611456e-03f, -2.91549917e-02f, -1.02648385e-01f, -1.63452700e-01f, -1.05142668e-01f, -1.09152041e-01f, 5.22054657e-02f, -5.03317304e-02f, -5.23514636e-02f,
  -9.36391652e-02f, 6.95237741e-02f, 1.56831756e-01f, 5.86401150e-02f, -5.68715157e-03f, 2.10193433e-02f, -2.49061093e-04f, 6.95876265e-03f, 8.92522633e-02f, -5.21220230e-02f,
  -5.95126331e-01f, -3.42691123e-01f, -8.52395594e-02f, -2.52948329e-02f, -8.59427229e-02f, -1.01592578e-01f, -6.45625442e-02f, -3.60754766e-02f, 1.98986828e-02f, 1.18734138e-02f,
  -1.30828232e-01f, -1.15020432e-01f, -4.88856360e-02f, -2.74749077e-03f, -1.42765880e-01f, -5.12414537e-02f, -1.42522007e-01f, -1.04871586e-01f, -1.43982679e-01f, -5.63351735e-02f,
  -2.33823620e-02f, -7.73114637e-02f, 1.95773691e-02f, -1.18798725e-01f, -2.84537915e-02f, -4.02310900e-02f, -9.92481187e-02f, 8.55219215e-02f, -2.05866266e-02f, 3.34425680e-02f,
  2.40036279e-01f, 4.90766317e-02f, 1.87369868e-01f, -3.27164084e-01f, 1.49536654e-01f, 5.01219451e-01f, 3.80086958e-01f, 1.22633338e-01f, -1.78563625e-01f, -3.12915027e-01f,
  -1.10269211e-01f, -1.87923059e-01f, -4.01400700e-02f, 1.33061066e-01f, 4.15268213e-01f, 2.91076005e-01f, 2.13325784e-01f, -2.43547671e-02f, 9.07065421e-02f, -1.25252247e-01f,
  -3.36349271e-02f, -8.26855376e-03f, 6.23917095e-02f, -5.23486547e-02f, 6.75948197e-03f, -2.69071430e-01f, -3.62398356e-01f, -3.15180719e-02f, -2.82670707e-01f, 8.84325281e-02f,
  2.16061160e-01f, 8.26974809e-02f, 2.37241477e-01f, 6.56355694e-02f, 1.52796045e-01f, 1.41876638e-01f, -3.45244817e-02f, 1.58055782e-01f, 2.77543291e-02f, 3.17219943e-02f,
  -2.41159499e-01f, -5.71271293e-02f, 6.14221618e-02f, -6.46459777e-03f, -1.19155750e-01f, -1.51664406e-01f, 3.65581177e-02f, -3.83061655e-02f, -7.66164884e-02f, 1.02778018e-01f,
  1.70656405e-02f, 9.33364928e-02f, -1.87206015e-01f, -1.12101272e-01f, -4.36062440e-02f, -1.00953706e-01f, 7.01086596e-02f, -4.26194705e-02f, -7.98744336e-02f, 1.82466228e-02f,
  -1.09023288e-01f, 8.71559158e-02f, 1.27949804e-01f, -3.31773125e-02f, 1.38149604e-01f, -1.06421985e-01f, -4.48308922e-02f, -8.74671489e-02f, 2.19784081e-02f, -2.43718065e-02f,
  -1.09883577e-01f, -6.36222214e-02f, 8.84005874e-02f, 1.14693977e-01f, -5.37212454e-02f, -7.89927319e-02f, 1.17365822e-01f, -9.70145017e-02f, -7.35889971e-02f, 1.87557768e-02f,
  -4.95851077e-02f, 4.79521081e-02f, 1.16188660e-01f, -4.44570072e-02f, 1.31929323e-01f, 5.91293573e-02f, -6.29852116e-02f, -5.78013295e-03f, 3.77969146e-02f, 2.68294532e-02f,
  1.63505301e-01f, -1.00651108e-01f, 3.01427264e-02f, -4.61213402e-02f, 8.32205042e-02f, 1.39166579e-01f, 2.41411820e-01f, 2.20187847e-02f, 1.31874429e-02f, 6.03893921e-02f,
  -1.10357814e-01f, -6.57625124e-02f, 5.95457777e-02f, -1.51527505e-02f, -1.35149822e-01f, 3.80679555e-02f, -7.41602108e-02f, -7.17647001e-02f, -1.20178863e-01f, -1.57312036e-01f,
  -8.18985850e-02f, -3.38671468e-02f, -1.17559507e-01f, 3.24882418e-02f, -1.48349643e-01f, -3.18927467e-01f, 1.51727244e-01f, -1.94870662e-02f, -7.52728507e-02f, -7.08857477e-02f,
  2.44829491e-01f, 2.51818180e-01f, 5.24327755e-01f, 3.00185770e-01f, -1.49841718e-02f, 2.74537116e-01f, -3.16633761e-01f, 8.04877654e-02f, -1.40489347e-03f, 1.40295371e-01f,
  -2.78719157e-01f, 4.21060562e-01f, -3.79646391e-01f, 2.14292243e-01f, -2.81188637e-01f, -3.92207980e-01f, -6.51070252e-02f, -7.62484521e-02f, -3.60048264e-01f, -1.50539383e-01f,
  -1.23202063e-01f, -4.83627081e-01f, -5.00339456e-02f, -2.46341079e-01f, 2.04890221e-01f, 2.63425559e-01f, -3.32728058e-01f, -1.61326870e-01f, 2.26525933e-01f, 8.54711011e-02f,
  1.65611789e-01f, -1.71514004e-01f, 2.21719399e-01f, 1.86883256e-01f, 2.36375239e-02f, 4.61166427e-02f, 1.28112463e-02f, -4.73120138e-02f, -5.19697648e-03f, -5.25983199e-02f,
  3.38746123e-02f, 1.05555929e-01f, 8.37270170e-02f, -5.07351011e-02f, 4.38146144e-02f, 4.66396175e-02f, 1.38429761e-01f, 1.12645231e-01f, 1.51388660e-01f, 1.26747265e-01f,
  2.02646598e-01f, 3.44859362e-01f, 1.88872233e-01f, 1.42569477e-02f, 5.39797805e-02f, 1.06585830e-01f, 8.70573074e-02f, 3.36794138e-01f, 1.63150027e-01f, 2.54107684e-01f,
  -1.11955181e-01f, -1.68847889e-01f, -5.06187081e-02f, 1.87776033e-02f, -1.42055051e-02f, -2.95437183e-02f, -1.72154009e-01f, 9.64466184e-02f, 3.92798856e-02f, -8.56709201e-03f,
  -2.85550300e-02f, 3.77724459e-03f, -7.49336109e-02f, 4.84576039e-02f, -5.17297722e-02f, 1.15544632e-01f, 5.50942607e-02f, -7.55314603e-02f, 8.89333151e-03f, 1.03078289e-02f,
  -3.04252148e-01f, -1.12212457e-01f, -2.49202847e-02f, 3.27230208e-02f, -6.01256117e-02f, 8.26321915e-02f, -6.82863519e-02f, 1.51612967e-01f, -4.73456234e-02f, -1.92867070e-01f,
  -2.42116123e-01f, -4.13635403e-01f, -3.27828899e-03f, -3.38235497e-02f, -1.74164966e-01f, 6.99993297e-02f, -7.36825913e-02f, 1.20591715e-01f, -6.85192049e-02f, -1.36943385e-01f,
  5.59790581e-02f, -6.46610335e-02f, 5.91856688e-02f, -8.91986361e-04f, -8.98972973e-02f, -1.87450171e-01f, -1.57348245e-01f, -5.82522377e-02f, 2.46685464e-02f, 1.56153012e-02f,
  -6.06058612e-02f, -4.79792319e-02f, 1.16561269e-02f, -3.50669548e-02f, 2.99242940e-02f, 5.88239022e-02f, -4.99235131e-02f, 8.30116943e-02f, -7.62024522e-02f, 1.23750297e-02f,
  1.73033670e-01f, 6.58080056e-02f, -2.17649803e-01f, -2.24756852e-01f, 1.72689393e-01f, -2.60641754e-01f, -1.50162131e-01f, 1.25937583e-02f, -9.70145017e-02f, 9.82230380e-02f,
  -1.87052116e-01f, -3.97590667e-01f, -2.88009495e-01f, -5.36128938e-01f, -5.20642340e-01f, -5.07006586e-01f, -2.20530599e-01f, -2.34562159e-01f, -1.57913432e-01f, 4.02346998e-02f,
  -1.23479433e-01f, -3.92277032e-01f, -3.83738279e-01f, 2.10407630e-01f, 2.39656791e-01f, 3.67859721e-01f, 3.73405308e-01f, 1.67472050e-01f, 3.69324237e-02f, -2.88801938e-01f,
  -1.81873038e-01f, -2.11852670e-01f, -2.10657373e-01f, -7.20091760e-02f, 1.80477306e-01f, 2.98284709e-01f, 2.31973846e-02f, -1.51190206e-01f, 9.79019050e-03f, -1.05904087e-01f,
  1.12149201e-01f, -3.89641039e-02f, -2.04071552e-01f, -1.55396983e-01f, 2.67719746e-01f, 4.82980125e-02f, -4.51016054e-02f, 6.96451589e-02f, 9.60179940e-02f, -2.01924354e-01f,
  -7.43780956e-02f, 1.49655417e-01f, 1.81555480e-01f, -1.22456692e-01f, -5.08077517e-02f, -9.19627845e-02f, 4.32236716e-02f, 3.66548658e-03f, 1.93005174e-01f, -9.31441486e-02f,
  5.65692857e-02f, 1.10229343e-01f, -7.93861505e-03f, -2.70933583e-02f, -5.17427549e-02f, 1.04929700e-01f, 4.85779569e-02f, 8.26069564e-02f, 6.09931350e-02f, -2.86316592e-03f,
  1.36759698e-01f, -1.04901388e-01f, -1.01002276e-01f, 2.61925533e-02f, -6.43780455e-02f, 6.04830533e-02f, 1.32942079e-02f, 3.35666817e-03f, -7.81601965e-02f, -4.35119979e-02f,
  -5.80331720e-02f, 6.54117316e-02f, -7.61109823e-03f, 2.01030225e-01f, 6.39216683e-04f, -1.60380751e-02f, -1.38658509e-02f, -4.32301313e-02f, 1.10634632e-01f, 1.06791019e-01f,
  1.01824790e-01f, 3.28855179e-02f, -2.09672719e-01f, -7.14328215e-02f, 2.45300252e-02f, 1.22901663e-01f, -3.62650827e-02f, -9.01039615e-02f, -1.44727111e-01f, -2.11146269e-02f,
  1.10538512e-01f, 1.95734531e-01f, 1.88205987e-01f, -6.31278381e-02f, 8.21163654e-02f, -2.08294112e-02f, 2.27578375e-02f, 2.06768122e-02f, 1.29352316e-01f, 2.61652395e-02f,
  2.79539645e-01f, 1.98138908e-01f, 1.25669643e-01f, 4.68223952e-02f, 1.33611009e-01f, 1.19206784e-02f, 1.37812391e-01f, -1.80964228e-02f, 1.07043944e-01f, 5.19406907e-02f,
  -8.65685120e-02f, -5.53188324e-01f, -2.31368877e-02f, 2.94210374e-01f, 1.94098856e-02f, 1.48248091e-01f, 2.84103334e-01f, -1.74324870e-01f, 2.34632701e-01f, -4.45677608e-01f,
  -2.11089075e-01f, -2.32444793e-01f, -2.15583965e-01f, -2.12675363e-01f, 4.79596406e-01f, 4.37914319e-02f, 2.29529172e-01f, 3.28729637e-02f, 2.07862094e-01f, -1.52568027e-01f,
  3.93233933e-02f, -1.96870640e-01f, 8.10854882e-02f, -1.67589992e-01f, -3.72677177e-01f, -4.47600819e-02f, -1.46467730e-01f, 8.96333531e-02f, -6.57867715e-02f, 5.32248951e-02f,
  1.44159555e-01f, -1.39991403e-01f, -1.24682449e-01f, 2.15034693e-01f, 5.77036180e-02f, -2.98679564e-02f, 5.58162294e-02f, 1.09866083e-01f, 3.51726681e-01f, 9.43124592e-02f,
  -1.70069542e-02f, 2.33254537e-01f, 8.15048963e-02f, -8.27751607e-02f, 3.81128229e-02f, 1.22517027e-01f, 1.24030925e-01f, 1.33592591e-01f, -3.35257836e-02f, -1.62304401e-01f,
  -1.23240063e-02f, -9.14419070e-03f, 1.06585726e-01f, 1.55863956e-01f, 2.52505857e-02f, 2.13275969e-01f, 7.36418888e-02f, -1.32216632e-01f, 1.09846070e-01f, -8.72050971e-02f,
  -2.12739214e-01f, 2.76073907e-03f, -1.39398307e-01f, 1.48308456e-01f, 4.04659733e-02f, 2.00170964e-01f, 1.44851372e-01f, -5.46128526e-02f, 1.50525406e-01f, -1.75296608e-02f,
  2.15781480e-01f, -1.59231111e-01f, 1.53484583e-01f, 2.35083953e-01f, -9.52898562e-02f, -1.32381588e-01f, -4.74036075e-02f, 7.11657330e-02f, 5.81559800e-02f, -4.12025675e-03f,
  -8.98016244e-02f, 4.62124264e-03f, -7.47892559e-02f, 8.81576240e-02f, -1.64946746e-02f, 4.86718630e-03f, -2.71845758e-02f, -1.42467871e-01f, 2.59270798e-02f, 3.01237572e-02f,
  1.38920546e-01f, -1.69956326e-01f, 4.01975736e-02f, 1.83572859e-01f, 7.92183951e-02f, -2.98788458e-01f, -2.91470587e-02f, -1.26948997e-01f, 2.79119033e-02f, -1.02060743e-01f,
  -1.23239279e-01f, 2.51675606e-01f, 1.52154729e-01f, 4.02860343e-02f, 1.23155788e-01f, -6.23592995e-02f, 1.40672818e-01f, 8.45345035e-02f, 7.20195472e-02f, -2.08367303e-01f,
  3.89415808e-02f, 1.35908559e-01f, 4.91620153e-02f, 1.68959305e-01f, 7.04337880e-02f, -2.51038447e-02f, -1.13262564e-01f, -5.01468256e-02f, 1.22379713e-01f, 1.75060883e-01f,
  -1.45725608e-01f, 4.21127141e-01f, -3.15895379e-01f, -4.37920570e-01f, 2.30864473e-02f, 6.85341001e-01f, 4.02368307e-01f, -9.03847255e-03f, -4.39423412e-01f, 4.06851262e-01f,
  3.76113683e-01f, -2.77029574e-01f, 3.63678157e-01f, 3.34318310e-01f, -3.16758864e-02f, 4.42619532e-01f, 3.44963908e-01f, 2.27903426e-01f, -2.23580733e-01f, 1.02630286e-02f,
  -1.41276985e-01f, 3.51074517e-01f, 1.54284731e-01f, -3.02607846e-03f, 1.74508929e-01f, -3.87670010e-01f, -7.71655962e-02f, -1.84518412e-01f, 9.10078958e-02f, 1.52743980e-01f,
  2.24914014e-01f, -3.78701389e-02f, -8.52277316e-03f, 2.82100793e-02f, 1.42082676e-01f, -3.92065942e-02f, -2.76118852e-02f, 2.00205836e-02f, -2.36395583e-01f, -3.24996300e-02f,
  -1.01322792e-01f, -6.96124360e-02f, -1.21367730e-01f, -1.94854990e-01f, -6.91645071e-02f, -2.03802630e-01f, -7.54408017e-02f, -2.12061498e-02f, -1.45997569e-01f, 5.23002073e-02f,
  -3.83268408e-02f, 1.19933775e-02f, 3.20125856e-02f, -2.86460742e-02f, -5.20374347e-03f, 7.50655308e-02f, 4.26028706e-02f, 9.90414098e-02f, 9.83579922e-03f, -4.22919774e-03f,
  -7.25346878e-02f, 2.23312061e-02f, 1.19868129e-01f, 4.30235565e-02f, 5.75562008e-02f, 1.19579978e-01f, -3.49341184e-02f, 5.37392199e-02f, -1.33519962e-01f, 2.08601549e-01f,
  -9.80048329e-02f, -1.40091747e-01f, 4.79437336e-02f, 7.40552023e-02f, -2.23019738e-02f, 7.20633427e-03f, -2.72120759e-02f, -9.07980278e-03f, -9.00498480e-02f, 2.81855557e-02f,
  -8.21142048e-02f, -1.36891259e-02f, 5.28454147e-02f, 8.94219498e-04f, 9.97331738e-02f, -2.82726940e-02f, 8.46055374e-02f, 1.52309686e-01f, 1.36014611e-01f, -1.28358856e-01f,
  1.06096916e-01f, -1.07610896e-02f, -8.56725425e-02f, 6.17795028e-02f, 9.54387709e-03f, 7.39786550e-02f, 2.64847837e-03f, 5.81032112e-02f, 1.94603764e-02f, -3.86971310e-02f,
  -1.06879994e-01f, 1.75216459e-02f, 1.56278862e-03f, -9.90842804e-02f, -1.10120468e-01f, 2.00933456e-01f, 2.37675067e-02f, -9.16424096e-02f, -7.33318925e-02f, -3.87786552e-02f,
  9.67200671e-04f, -2.52773389e-02f, -1.24915518e-01f, -1.10898204e-01f, -1.23497643e-01f, 1.87616095e-01f, -7.34743997e-02f, -1.62180677e-01f, -3.92185748e-02f, -5.50668798e-02f,
  -5.26207536e-02f, -2.42641255e-01f, -6.12518251e-01f, -6.80920556e-02f, 2.02846244e-01f, -5.49603961e-02f, -1.45144433e-01f, -7.69040510e-02f, -1.67639002e-01f, 4.62869108e-01f,
  6.72816157e-01f, -2.14687318e-01f, -1.20211035e-01f, 7.26877034e-01f, -4.77047227e-02f, 2.05439895e-01f, 1.37883991e-01f, 1.42115206e-01f, -2.77820051e-01f, -3.19060743e-01f,
  -1.69976324e-01f, 7.15709329e-01f, -1.79510385e-01f, 9.60199758e-02f, 7.51210228e-02f, -3.87181580e-01f, 2.86088493e-02f, -8.17143694e-02f, 3.50227982e-01f, 2.04708129e-01f,
  2.26509109e-01f, 1.63812071e-01f, -1.58673763e-01f, -8.35302025e-02f, -1.42502621e-01f, -9.70295444e-02f, -2.13456467e-01f, -2.85156034e-02f, -2.93475259e-02f, -9.40420851e-02f,
  -1.31096184e-01f, 8.22604969e-02f, -5.02477679e-03f, 9.94984061e-02f, 3.76101285e-02f, -1.61171742e-02f, 4.96602207e-02f, -1.35360703e-01f, -1.29648969e-01f, -2.14823540e-02f,
  -5.91474697e-02f, -9.53419209e-02f, -1.29855499e-01f, -5.42921759e-02f, 1.03718955e-02f, 7.52860233e-02f, -2.27912605e-01f, -1.04273982e-01f, -5.06460853e-02f, -3.16656120e-02f,
  2.09107585e-02f, -4.97058257e-02f, 5.19641023e-03f, 1.29608378e-01f, -8.09897017e-03f, 1.04826562e-01f, 8.27929899e-02f, 7.40306526e-02f, -1.92551792e-01f, 2.60485522e-02f,
  -2.71928478e-02f, -2.81879865e-02f, 7.72465840e-02f, 5.19970506e-02f, 3.96587737e-02f, -7.83274844e-02f, -1.17229551e-01f, 9.24537778e-02f, -9.68994722e-02f, 2.64226422e-02f,
  2.53419671e-02f, -4.31917123e-02f, -9.79989488e-03f, -7.06194714e-02f, 7.94557035e-02f, 9.79790166e-02f, -1.69580132e-02f, 2.19692886e-02f, -7.01400936e-02f, 1.28941955e-02f,
  -1.45238534e-01f, -5.06913885e-02f, -2.06967127e-02f, 1.03616878e-01f, 4.58029052e-03f, 1.62033262e-04f, -2.32037958e-02f, -7.45405182e-02f, 6.42004386e-02f, 1.76773500e-02f,
  1.79166682e-02f, -3.94997932e-02f, -1.36565149e-01f, 7.59951472e-02f, -5.10666892e-02f, 9.65134576e-02f, -3.42617929e-02f, 2.95758024e-02f, 1.78153701e-02f, -9.60760638e-02f,
  5.37899919e-02f, 3.14943977e-02f, -1.71295300e-01f, 2.54818983e-02f, 1.31560536e-02f, -6.34795427e-03f, -2.07830276e-02f, -1.43200075e-02f, 1.26356691e-01f, -3.40851359e-02f,
  -5.28649867e-01f, 1.90130383e-01f, -2.79038042e-01f, -1.33729190e-01f, -5.15222251e-01f, -4.24947858e-01f, 6.03926033e-02f, -2.43793651e-01f, 6.52550831e-02f, 4.13265795e-01f,
  4.55001965e-02f, 5.85834356e-03f, 4.19598341e-01f, 2.77715288e-02f, -4.20963317e-01f, 4.00883287e-01f, -3.75653990e-02f, 1.92754790e-01f, -1.21248692e-01f, -1.37858704e-01f,
  -1.90462470e-01f, -1.78558767e-01f, -1.07699139e-02f, -2.45154008e-01f, -3.95622373e-01f, -2.51911342e-01f, -4.92018722e-02f, -1.12849906e-01f, -2.93634236e-01f, -1.87966809e-01f,
  -3.46965492e-01f, 5.06996969e-03f, 1.92257151e-01f, -6.83517903e-02f, -2.39587903e-01f, -3.54099385e-02f, -1.38238996e-01f, -2.44222172e-02f, -2.14192383e-02f, -3.29406261e-02f,
  4.60611656e-02f, -4.70948890e-02f, -9.21826926e-04f, 6.97230771e-02f, -2.69624367e-02f, -2.96750441e-02f, -1.59318820e-01f, -2.51662992e-02f, -1.07230335e-01f, -1.08262151e-01f,
  7.47032166e-02f, -1.30558079e-02f, -1.53333750e-02f, 2.30359454e-02f, -1.57115124e-02f, 3.01152770e-03f, -9.99838933e-02f, 1.44567834e-02f, -1.45751566e-01f, -1.97785854e-01f,
  8.52544047e-03f, -1.11059122e-01f, 1.05860151e-01f, -7.42167532e-02f, 1.20043969e-02f, 2.62651984e-02f, 1.41470373e-01f, 9.36737284e-03f, 3.13570648e-02f, -9.30715054e-02f,
  -7.04543665e-02f, 8.23798776e-02f, -2.25512777e-02f, 5.75198941e-02f, 1.53593551e-02f, 5.79498112e-02f, 2.83600669e-02f, -7.66170546e-02f, 6.85685650e-02f, -3.92054021e-02f,
  3.41401845e-02f, -1.52424797e-01f, 1.03102334e-01f, -3.39400358e-02f, 8.67422763e-03f, 1.87995564e-02f, 1.91495428e-03f, 9.72922444e-02f, 4.17788662e-02f, -4.36297506e-02f,
  -5.71931183e-01f, -2.55261987e-01f, 1.34807294e-02f, 8.97866264e-02f, 4.82118875e-02f, -4.41330262e-02f, -9.89766046e-02f, -1.58517525e-01f, -1.02469623e-01f, -5.67755289e-02f,
  1.01989396e-02f, 1.59089088e-01f, -1.57907695e-01f, -4.56991456e-02f, 5.39680943e-02f, -2.28287056e-01f, -6.60516173e-02f, -6.52662441e-02f, -9.42365006e-02f, -1.49803787e-01f,
  9.07208398e-02f, 1.14961863e-02f, 9.24090371e-02f, -1.42945033e-02f, 8.45654961e-03f, 6.71281293e-02f, -1.16339058e-01f, 2.19338257e-02f, -2.57034451e-01f, -7.14876642e-03f,
  -3.00481729e-02f, -1.94168821e-01f, 2.62919158e-01f, 8.11040550e-02f, -3.10785491e-02f, -3.06506723e-01f, -1.86889738e-01f, 3.40146810e-01f, -3.21053863e-01f, -1.15525723e-01f,
  1.57014638e-01f, -3.96214753e-01f, 1.24947160e-01f, -2.73294061e-01f, 1.88412964e-01f, -3.57605577e-01f, -4.27100025e-02f, -1.89159632e-01f, 6.73776716e-02f, 3.75274509e-01f,
  3.01662296e-01f, 5.97770512e-03f, 3.26194733e-01f, 3.52893919e-01f, 2.87048310e-01f, 4.25863296e-01f, 5.09450197e-01f, 3.12690258e-01f, 1.62327215e-01f, -2.89885640e-01f,
  -8.35120827e-02f, -1.89569835e-02f, 2.41453305e-01f, -1.94715440e-01f, 2.98073888e-01f, 8.72385800e-02f, 1.05791874e-01f, -1.13318488e-01f, 1.00177690e-01f, -7.58553715e-03f,
  2.68755220e-02f, -8.67961869e-02f, -7.98765793e-02f, -1.49189085e-01f, -8.95454809e-02f, -8.49056989e-03f, -2.83294376e-02f, 5.97736575e-02f, -1.73829556e-01f, 8.18428397e-02f,
  5.15474677e-02f, -1.72109261e-01f, -1.10251501e-01f, -8.90024975e-02f, -7.28241168e-03f, -3.52659486e-02f, -1.47794038e-01f, 1.49260491e-01f, -1.45703897e-01f, 9.42235738e-02f,
  1.06499270e-02f, -5.27921803e-02f, -8.25474262e-02f, -6.29936606e-02f, -6.46402454e-03f, -1.32699758e-01f, -6.27110600e-02f, -1.41523834e-02f, 8.79720822e-02f, 1.34364078e-02f,
  7.66895339e-02f, 1.20115437e-01f, -1.39297590e-01f, -4.54207845e-02f, 8.39175433e-02f, -1.80612981e-01f, 3.97718325e-02f, 6.33517839e-03f, 1.65901765e-01f, 1.27276048e-01f,
  -1.23844720e-01f, -5.35755642e-02f, 5.55094071e-02f, 1.02622487e-01f, -9.63477194e-02f, 1.21810541e-01f, 4.27039787e-02f, -1.20148011e-01f, 1.10489391e-01f, -6.71211025e-03f,
  1.40264034e-01f, 3.29027027e-01f, 1.66836932e-01f, -2.39633307e-01f, 7.16180652e-02f, 1.64457604e-01f, -4.83873859e-02f, -2.25269217e-02f, 7.36533552e-02f, 4.56108116e-02f,
  1.86351836e-01f, 1.37436807e-01f, 2.03336147e-03f, -6.87370896e-02f, -1.99371725e-02f, 2.58697212e-01f, -5.67713240e-03f, 1.09687662e-02f, 2.53075659e-02f, 1.52273476e-01f,
  8.78782943e-02f, 2.53569409e-02f, -9.86254811e-02f, -7.24242032e-02f, 1.29187582e-02f, 5.17995283e-02f, 1.17153190e-01f, 4.54153903e-02f, -1.25740588e-01f, -4.33220854e-03f,
  -5.52866220e-01f, -7.07763061e-02f, -1.72226638e-01f, 8.58582631e-02f, -5.99784493e-01f, 6.04115613e-02f, 2.43730173e-01f, -2.00703979e-01f, 3.23953539e-01f, 4.48624402e-01f,
  -3.99347069e-03f, -3.86380292e-02f, 2.68923938e-01f, 1.50694445e-01f, -1.82005301e-01f, 4.76295680e-01f, 2.48692155e-01f, 2.61014968e-01f, -1.04794636e-01f, -2.97224075e-01f,
  -1.91048712e-01f, -1.46252856e-01f, -8.40428993e-02f, -1.35781601e-01f, -3.53097528e-01f, -2.16022372e-01f, -5.20622730e-02f, -3.25660467e-01f, -7.44961202e-02f, -3.27044815e-01f,
  -3.14583272e-01f, -2.82686889e-01f, -2.02311173e-01f, -9.81143489e-02f, -2.25066841e-01f, -1.41220270e-02f, -6.10261485e-02f, -1.34367615e-01f, -3.05134300e-02f, -1.51718371e-02f,
  -6.79880679e-02f, -1.03053220e-01f, -4.75947857e-02f, 1.48925975e-01f, -1.53372690e-01f, -8.46074969e-02f, -1.85646251e-01f, -6.48625344e-02f, -4.81971465e-02f, -5.85704856e-03f,
  -5.81149869e-02f, -2.96449149e-03f, -3.50839533e-02f, 3.29057798e-02f, -2.00110391e-01f, -1.34584382e-01f, 1.30121857e-01f, -1.51307181e-01f, -1.54127851e-01f, -8.73486474e-02f,
  -4.81024384e-03f, 5.65608479e-02f, 1.28798217e-01f, 1.36765689e-01f, -5.47570698e-02f, -8.25809538e-02f, 2.83900425e-02f, 1.23664131e-02f, 2.34674662e-02f, -7.73234740e-02f,
  -6.14133440e-02f, -7.69848675e-02f, -1.27266705e-01f, -6.40960112e-02f, 1.78910978e-02f, 4.21536565e-02f, 2.26306869e-03f, 2.68766340e-02f, -1.29928114e-02f, -8.04364905e-02f,
  1.07867680e-01f, 1.03635617e-01f, -5.54394238e-02f, -2.25110166e-02f, -2.37464439e-02f, -1.55556813e-01f, 1.45223578e-02f, 6.57500103e-02f, 7.02611208e-02f, -6.14769086e-02f,
  -8.34244266e-02f, 4.82418984e-02f, -3.93541530e-02f, -1.90113351e-01f, -1.03563316e-01f, 3.09655350e-02f, 1.35593385e-01f, -3.53500210e-02f, -4.68553640e-02f, 9.56044421e-02f,
  -4.18498889e-02f, 5.62151968e-02f, -8.15591291e-02f, 8.11537057e-02f, 1.36848629e-01f, -4.07089964e-02f, -9.25240165e-04f, 2.75511518e-02f, -6.54128939e-02f, -1.42683163e-01f,
  1.04571721e-02f, 9.21235606e-03f, 7.02044228e-03f, -8.23079497e-02f, -6.50767908e-02f, -2.64134072e-02f, 3.40021303e-04f, -2.04741791e-01f, -1.71543837e-01f, 2.88257562e-02f,
  1.69060200e-01f, 5.15366495e-01f, 3.87291253e-01f, 6.40330076e-01f, -9.52758566e-02f, -2.02619374e-01f, -1.20262429e-01f, 2.63715923e-01f, 6.31176353e-01f, -2.55129099e-01f,
  -2.77625322e-01f, -3.04366089e-02f, -2.02189073e-01f, 3.52129638e-01f, 1.69096798e-01f, -1.18947141e-02f, 3.82849574e-01f, -1.68755893e-02f, 4.62290645e-01f, 2.72160560e-01f,
  5.06837666e-01f, -1.14690758e-01f, 8.24298337e-02f, -8.64068419e-02f, 1.17650807e-01f, 2.47089416e-01f, -1.18129306e-01f, 4.88945656e-02f, -1.19855605e-01f, -3.52433324e-02f,
  -1.70759577e-02f, 2.26725250e-01f, 9.18772817e-02f, 8.53792056e-02f, 9.19825062e-02f, -1.89682424e-01f, -1.29882038e-01f, -1.71163440e-01f, 2.63186395e-02f, -5.03235236e-02f,
  8.17519501e-02f, -1.09175757e-01f, 4.49985862e-02f, -1.99978314e-02f, 7.10408464e-02f, 1.22650914e-01f, 1.02528445e-01f, 1.29394993e-01f, -7.23196492e-02f, 7.74625316e-02f,
  1.39484489e-02f, 1.98068291e-01f, 1.29216477e-01f, 9.80562046e-02f, 2.25713074e-01f, 2.39681378e-01f, 2.79775001e-02f, 2.64237616e-02f, 1.01113677e-01f, 1.99667454e-01f,
  1.11980610e-01f, 8.88350010e-02f, -5.77153452e-02f, -2.15257376e-01f, 1.12075455e-01f, 1.99369282e-01f, 8.33788961e-02f, -1.47551998e-01f, 1.53003290e-01f, 3.47450972e-02f,
  -3.38991694e-02f, 3.27243134e-02f, 2.05105171e-01f, 6.61271885e-02f, 1.66410103e-01f, -7.66244307e-02f, -1.27557859e-01f, 1.80315729e-02f, 1.20591797e-01f, -1.03891246e-01f,
  -7.13157281e-02f, -8.99989083e-02f, -3.02244499e-02f, -1.71375632e-01f, -2.36334264e-01f, 5.13890311e-02f, 7.13050887e-02f, 6.80681318e-03f, -1.09217577e-01f, 2.58554295e-02f,
  1.22914568e-01f, 4.82203096e-01f, 1.41777813e-01f, 4.54565026e-02f, 4.11170945e-02f, -5.26606888e-02f, -6.38981089e-02f, 1.65094137e-01f, 1.17154002e-01f, -1.80017296e-02f,
  2.16828883e-02f, -3.21762413e-02f, -1.94413260e-01f, -7.89689273e-02f, -2.12187450e-02f, -5.63236475e-02f, 3.10606547e-02f, 1.15474708e-01f, 9.30493549e-02f, 1.52054653e-01f,
  -1.24789504e-02f, -1.29824355e-01f, 9.58663505e-03f, 5.30997030e-02f, -6.18662802e-04f, -3.78600098e-02f, -1.61034852e-01f, 4.66483273e-02f, -5.43200038e-02f, 3.56929936e-02f,
  5.26550412e-01f, -4.45121378e-01f, -4.53122735e-01f, 2.70529836e-01f, 4.16830450e-01f, 3.01688880e-01f, -8.92703161e-02f, 2.96540797e-01f, 1.80256769e-01f, -2.29029626e-01f,
  1.40008345e-01f, -4.19899255e-01f, -4.14062709e-01f, 2.14809269e-01f, 2.69295603e-01f, -3.51482213e-01f, 2.58702546e-01f, 5.68566211e-02f, 2.06112564e-01f, 3.65801975e-02f,
  3.16701353e-01f, 5.54349184e-01f, -2.46856421e-01f, 2.58340120e-01f, 2.48200431e-01f, -9.81047451e-02f, 1.13032144e-02f, -2.78793126e-01f, 1.78448886e-01f, 6.15529679e-02f,
  7.58836940e-02f, 8.00359771e-02f, 5.23420013e-02f, -5.25992699e-02f, 3.14400233e-02f, -7.76883364e-02f, -1.72279403e-01f, -8.75730067e-02f, 6.52484074e-02f, -7.71496296e-02f,
  -1.38816088e-01f, -2.70395782e-02f, 3.17819901e-02f, 4.50834781e-02f, 2.13501260e-01f, 8.64549503e-02f, 2.46888548e-02f, 7.80880731e-03f, -5.33625931e-02f, -1.47226468e-01f,
  -8.02904218e-02f, -1.21102162e-01f, -2.65314570e-03f, -4.21647206e-02f, -5.45001999e-02f, 5.52386977e-02f, -1.38992131e-01f, -1.28879040e-01f, -1.02858143e-02f, 1.28131956e-01f,
  1.54160000e-02f, -6.78972751e-02f, -3.96441706e-02f, 9.49839130e-03f, -6.09265175e-03f, 4.36943211e-02f, 1.15704469e-01f, 9.07705631e-03f, 1.06335454e-01f, -2.04372294e-02f,
  1.30185783e-01f, 9.78846326e-02f, 1.34716272e-01f, 2.97174286e-02f, 1.84130867e-03f, 9.30426419e-02f, -1.15477361e-01f, -6.79406226e-02f, 4.70954143e-02f, 1.71206295e-02f,
  -6.27218606e-03f, 6.75991699e-02f, -4.71646935e-02f, -1.01460218e-02f, 8.07355568e-02f, -5.88808991e-02f, 7.25874305e-02f, -6.81223795e-02f, -2.32124999e-02f, -8.86456519e-02f,
  -1.48596391e-01f, -3.77017677e-01f, 7.00070709e-03f, 1.47637799e-02f, -5.00340946e-03f, 1.77287251e-01f, 7.60963485e-02f, 1.28845824e-03f, -8.17157626e-02f, 5.97348884e-02f,
  -2.74229795e-02f, -1.04106059e-02f, 4.63121422e-02f, 6.09510206e-02f, 4.76277359e-02f, 6.40141219e-02f, -1.09282829e-01f, -1.46215558e-02f, 5.58247119e-02f, 9.11011472e-02f,
  -9.21899080e-02f, -1.00112557e-01f, 4.20848913e-02f, 8.58328268e-02f, 7.13780075e-02f, -5.74657992e-02f, -8.44857916e-02f, -6.13531619e-02f, -1.15534820e-01f, -1.51697397e-02f,
  3.18736732e-01f, -2.06940129e-01f, -5.03296971e-01f, -2.53958225e-01f, 2.94289529e-01f, 4.37416583e-01f, 1.08127251e-01f, 3.55767235e-02f, -2.91570634e-01f, 3.85729313e-01f,
  2.87385285e-01f, -2.27601707e-01f, -1.73931882e-01f, -9.29879919e-02f, -2.00494960e-01f, -2.42317632e-01f, 1.45354763e-01f, 1.56506643e-01f, -2.13345394e-01f, 2.38318309e-01f,
  -7.29875267e-02f, 3.17174882e-01f, -4.81354088e-01f, 1.88647538e-01f, 3.78897309e-01f, 9.67849195e-02f, 2.29945719e-01f, -1.19793132e-01f, 2.62369066e-01f, 2.38822345e-02f,
  7.95315858e-03f, -5.76083437e-02f, -9.35722813e-02f, 3.64740267e-02f, -4.78254780e-02f, 2.77860463e-01f, 9.00487453e-02f, -8.53880569e-02f, -8.41618478e-02f, -1.16993263e-01f,
  -3.69945355e-02f, -3.39762904e-02f, 9.03334767e-02f, 2.65122447e-02f, 2.11854488e-01f, 9.27169099e-02f, -6.02256991e-02f, 8.84786807e-03f, -5.34250634e-03f, -8.26525986e-02f,
  -2.33676638e-02f, -3.60423997e-02f, 5.70311472e-02f, -1.53025374e-01f, -1.53263703e-01f, -4.93245460e-02f, 3.01129720e-03f, -3.23246159e-02f, 1.33003632e-03f, -8.93783756e-03f,
  7.57285878e-02f, 6.61014169e-02f, 8.08181465e-02f, 2.02031806e-02f, -2.45552529e-02f, -1.23770431e-01f, 1.13276884e-01f, -1.01713613e-01f, -3.75884920e-02f, -6.29165471e-02f,
  -2.05498654e-02f, 7.75903463e-02f, 1.95630006e-02f, 6.09264188e-02f, 1.07805192e-01f, 2.10645515e-02f, 5.50230294e-02f, 1.03315264e-01f, 3.42590809e-02f, -6.54349998e-02f,
  2.15531066e-02f, -1.77419353e-02f, 9.50663835e-02f, 2.94121634e-02f, -5.46949804e-02f, -7.92559534e-02f, 1.67460427e-01f, 1.53184950e-01f, -1.64158404e-01f, 1.15921900e-01f,
  -7.61779696e-02f, -7.34591996e-03f, -8.82029254e-03f, -5.10735326e-02f, -1.36447757e-01f, 8.96012858e-02f, 2.84606088e-02f, -3.73056866e-02f, -1.16130553e-01f, 7.16696158e-02f,
  6.84206933e-02f, -2.99628060e-02f, 9.60564166e-02f, 2.86168884e-02f, -8.95784795e-02f, 1.67465106e-01f, 4.10210527e-02f, -4.36295234e-02f, 2.96461936e-02f, 5.91043048e-02f,
  7.21331909e-02f, 1.76824138e-01f, 2.81348340e-02f, 1.08513404e-02f, -2.43807957e-02f, 1.20588012e-01f, 4.27122675e-02f, -1.10330783e-01f, 1.35406464e-01f, -6.67138770e-02f,
  -9.35394108e-01f, 3.92767370e-01f, -5.77920377e-02f, -5.71692228e-01f, 3.85765195e-01f, 1.38190299e-01f, -1.54047266e-01f, 4.10359055e-02f, -3.76331568e-01f, 5.77878430e-02f,
  1.37716662e-02f, -4.27472144e-01f, 3.91430974e-01f, -4.17025268e-01f, -5.24863780e-01f, -1.54994493e-02f, -4.10031855e-01f, -4.67998922e-01f, -1.02033734e-01f, -2.03073859e-01f,
  -2.73590356e-01f, -5.22578210e-02f, -1.18596002e-01f, 4.12040263e-01f, -1.39069110e-01f, 3.95050906e-02f, -5.12107536e-02f, 4.14531708e-01f, -2.32478306e-01f, 1.07075296e-01f,
  -1.76607326e-01f, -1.97364122e-01f, 1.88332684e-02f, -2.77197249e-02f, -1.06574737e-01f, 3.38425748e-02f, -6.80096671e-02f, 6.40951023e-02f, -1.01614542e-01f, -3.28378379e-02f,
  -7.40932021e-03f, 5.84490374e-02f, -1.22262299e-01f, 4.16781530e-02f, 3.40081528e-02f, 4.65784967e-02f, 1.08414546e-01f, -3.61898653e-02f, 7.94904754e-02f, -5.40159643e-03f,
  -2.17927527e-02f, -1.22764474e-02f, 3.18805192e-04f, -9.55452546e-02f, 4.21100147e-02f, 1.02111638e-01f, 2.01018760e-03f, 1.09315008e-01f, 3.32824104e-02f, -8.28778893e-02f,
  -2.63201427e-02f, -5.07286843e-03f, 9.36556011e-02f, 9.33866054e-02f, -8.78491253e-02f, -6.81647658e-02f, -5.36965579e-03f, -1.18701264e-01f, -2.35901456e-02f, 3.72279584e-02f,
  -5.19912206e-02f, 6.38767332e-02f, 7.68551454e-02f, -2.48145428e-03f, -8.12577382e-02f, -1.67625789e-02f, 4.41941917e-02f, 3.45053431e-03f, -7.02189952e-02f, 4.48980480e-02f,
  -2.63093654e-02f, -3.53548378e-02f, -3.00272722e-02f, 1.82931386e-02f, 5.63072264e-02f, -5.42380176e-02f, 8.82842615e-02f, -3.83538082e-02f, 6.09079041e-02f, 3.89347002e-02f,
  -8.73366296e-02f, -1.22055233e-01f, 7.66428784e-02f, -1.96746774e-02f, -5.24203181e-02f, 2.05458216e-02f, 1.05772436e-01f, 2.57040132e-02f, -1.05056025e-01f, 2.21356321e-02f,
  -3.42365615e-02f, -2.84722447e-03f, 2.25104112e-02f, -1.10520028e-01f, -6.32957593e-02f, 6.01452515e-02f, -1.61168911e-02f, 3.08159683e-02f, -9.42347497e-02f, -9.09509044e-03f,
  -9.20052547e-03f, 1.36987353e-02f, 3.45537290e-02f, -3.23175155e-02f, 5.43355430e-03f, -3.71171627e-03f, 3.28437649e-02f, -3.79530676e-02f, 1.15756735e-01f, -1.71702839e-02f,
  -8.20945680e-01f, 3.67884636e-01f, -1.30427733e-01f, -4.10988182e-01f, 2.33637959e-01f, -3.22926491e-01f, -1.37101397e-01f, 2.23548487e-01f, -1.16701186e-01f, 2.44568646e-01f,
  1.64093584e-01f, -3.32494020e-01f, 3.15182090e-01f, -1.43697366e-01f, -4.82973307e-01f, -9.41839367e-02f, -5.14729083e-01f, -3.90171736e-01f, -5.76626137e-02f, -2.70315319e-01f,
  -2.70574152e-01f, 9.89037082e-02f, -2.11707994e-01f, 5.25985122e-01f, -7.33621195e-02f, 1.75967738e-02f, 6.69121072e-02f, 4.69574839e-01f, -1.77364439e-01f, 2.20564529e-01f,
  -1.09038204e-01f, 1.86305135e-01f, -1.32368878e-01f, -2.27803346e-02f, -1.68010086e-01f, -4.59078886e-02f, -5.65091185e-02f, 1.07328497e-01f, -1.45551637e-02f, -1.39385119e-01f,
  -2.18048543e-02f, 3.29395197e-02f, 1.42615037e-02f, 8.71473476e-02f, 3.75905000e-02f, 3.89543064e-02f, 5.31568155e-02f, -1.47884384e-01f, 5.77325784e-02f, -1.36213839e-01f,
  -4.65247370e-02f, 5.27626388e-02f, -9.97693986e-02f, -2.20531244e-02f, -6.07367083e-02f, 8.60357061e-02f, -7.14529231e-02f, -1.26353860e-01f, -8.85765031e-02f, -6.94857165e-02f,
  3.53879929e-02f, -6.53439984e-02f, 4.13958393e-02f, 4.15814780e-02f, 1.19456220e-02f, 7.24179894e-02f, -3.59917544e-02f, -7.69131705e-02f, 7.91053623e-02f, -4.47500162e-02f,
  4.42794040e-02f, 9.01377108e-03f, 6.48686336e-03f, -1.52029246e-01f, -7.00440779e-02f, -1.32554155e-02f, 8.32916889e-03f, -9.47525129e-02f, -1.31650165e-01f, -5.71428575e-02f,
  1.34611679e-02f, 2.87573673e-02f, 8.38687345e-02f, 6.08431250e-02f, 1.24157462e-02f, 1.51090436e-02f, 5.96757941e-02f, -3.00891586e-02f, -8.13147947e-02f, 7.57766515e-02f,
  -3.47007364e-01f, -5.40521890e-02f, 3.15229781e-02f, 1.24660417e-01f, -1.35636255e-02f, 1.33976219e-02f, 7.94648826e-02f, -8.85725990e-02f, -1.64916273e-02f, 6.99194670e-02f,
  -9.65636298e-02f, -8.98612142e-02f, -6.82278946e-02f, -1.43339112e-05f, -5.73149435e-02f, -2.89821043e-03f, -4.31080498e-02f, -8.13485458e-02f, -6.97171018e-02f, -5.66288531e-02f,
  7.79144466e-02f, 9.78910699e-02f, 7.07372278e-02f, 6.73409477e-02f, -5.08926138e-02f, -9.03098565e-03f, -8.96205157e-02f, 6.88169599e-02f, 4.71984819e-02f, 7.88957700e-02f,
  -2.78154880e-01f, -2.01953202e-01f, -8.79278183e-02f, 4.31124270e-01f, -2.03394666e-01f, -4.70828831e-01f, -5.41711748e-01f, -6.67319894e-02f, -9.59202126e-02f, -5.14453016e-02f,
  1.11910328e-01f, 2.37527862e-03f, -1.65479437e-01f, 5.13669431e-01f, 2.88283616e-01f, 1.91617489e-01f, 3.57226014e-01f, 8.95630717e-02f, 5.07206284e-02f, -4.06139391e-03f,
  3.80073637e-01f, 4.83237028e-01f, 3.79533380e-01f, 2.43094504e-01f, -9.81628895e-03f, 6.46884814e-02f, 3.23860437e-01f, -1.40034527e-01f, 4.47093487e-01f, 5.92647493e-02f,
  2.34019756e-02f, 1.85135528e-01f, -1.04034066e-01f, 1.43922448e-01f, 1.14583835e-01f, -5.33752255e-02f, 2.03791782e-02f, 2.04427913e-03f, 3.58633697e-02f, 4.09896709e-02f,
  -1.26213580e-01f, 1.13745689e-01f, 1.08827926e-01f, 5.91481365e-02f, -1.37604877e-01f, 4.16344032e-03f, 1.12442235e-02f, 4.18936573e-02f, -1.00239530e-01f, -2.82234922e-02f,
  -1.75356731e-01f, 1.39364555e-01f, -6.16519153e-02f, 9.85456482e-02f, 4.32806201e-02f, -7.50772282e-02f, 4.75788824e-02f, 2.45577027e-03f, -3.23579274e-02f, 1.07585840e-01f,
  -6.50129765e-02f, -6.22173212e-02f, -5.96193448e-02f, 5.95445298e-02f, 2.16623023e-02f, 1.50096849e-01f, -8.87346417e-02f, 3.27408537e-02f, -1.09106660e-01f, -4.74761985e-02f,
  1.85741290e-01f, -1.39426077e-02f, -4.77846228e-02f, -8.60780030e-02f, 1.39779299e-02f, 5.75136952e-02f, -3.66830267e-02f, 7.37003833e-02f, -7.40115019e-03f, 2.42113438e-03f,
  1.97520908e-02f, -4.89862561e-02f, -8.31123069e-02f, -4.20193747e-02f, 1.42527902e-02f, -4.07444984e-02f, 1.03376888e-01f, 6.10342436e-02f, -4.26808037e-02f, -7.97979683e-02f,
  1.65030569e-01f, 9.09425169e-02f, -2.35463753e-02f, -1.63468327e-02f, 1.24198928e-01f, -7.62245208e-02f, 1.25065327e-01f, 8.71953741e-03f, 3.01659442e-02f, -1.15651041e-01f,
  9.33701769e-02f, -3.90958600e-02f, 9.69935656e-02f, 1.17112383e-01f, 1.34573191e-01f, 2.55692452e-02f, 4.21232730e-02f, 6.37109205e-02f, 9.17167887e-02f, 9.82404649e-02f,
  2.78225988e-02f, -1.54280588e-01f, 1.19806699e-01f, -1.18396483e-01f, 5.70819266e-02f, 4.69665538e-04f, -1.66911259e-01f, -3.66503070e-03f, 5.19239232e-02f, 1.49636135e-01f,
  2.73092538e-01f, 3.73584598e-01f, 9.94181409e-02f, -8.79144818e-02f, -1.76956400e-01f, 5.39391875e-01f, 9.19897854e-02f, 3.33605170e-01f, 4.98851746e-01f, 2.80670375e-01f,
  -4.14825529e-01f, 5.53124547e-01f, -7.87107423e-02f, -1.31254137e-01f, 1.00013185e-02f, 1.42225549e-01f, -1.10157087e-01f, -2.60373764e-02f, 1.76873699e-01f, -4.25257646e-02f,
  -8.58341977e-02f, -2.73546547e-01f, -4.42673177e-01f, -9.58270356e-02f, -3.29071820e-01f, -7.92113096e-02f, -4.80280608e-01f, -2.14193121e-01f, -1.14755839e-01f, -1.02959558e-01f,
  -8.32817182e-02f, 1.44455239e-01f, -1.04829855e-02f, 1.08231694e-01f, 1.45281423e-02f, -3.24462242e-02f, -1.89527273e-02f, 1.29299061e-02f, 3.32687423e-02f, 5.69891520e-02f,
  2.70201359e-02f, 7.78200328e-02f, 1.20043918e-01f, 1.17256239e-01f, 1.38154954e-01f, 1.08600907e-01f, -2.71515474e-02f, -1.07300565e-01f, -5.61569519e-02f, 3.19808722e-02f,
  -5.36030903e-02f, 3.17886099e-02f, -1.09542226e-02f, -6.80736378e-02f, -1.19419582e-02f, 4.42884304e-02f, 1.32354319e-01f, -8.96671414e-02f, 2.01187488e-02f, 1.61484718e-01f,
  4.06868570e-03f, 9.76882353e-02f, -7.76698068e-03f, -1.71509665e-02f, 6.14711829e-02f, -3.70778069e-02f, -4.05026190e-02f, -9.03573409e-02f, 1.04350202e-01f, -9.33811441e-02f,
  6.81764819e-03f, 7.83491507e-03f, 3.09497081e-02f, 4.25481349e-02f, -3.53923552e-02f, 7.73099810e-02f, -1.05845354e-01f, 1.09743237e-01f, -1.39579857e-02f, -2.44114688e-03f,
  -4.02057990e-02f, 1.28871398e-02f, -4.33549434e-02f, -2.16251850e-01f, -1.83418006e-01f, 1.90884192e-02f, 7.16015995e-02f, -6.57364652e-02f, -5.67704737e-02f, -1.78450197e-01f,
  9.79784802e-02f, 3.29536587e-01f, 1.32520512e-01f, 5.35054803e-02f, -3.42410430e-03f, 4.05478217e-02f, -2.34557632e-02f, 1.65039554e-01f, 4.68293056e-02f, 2.12288186e-01f,
  -3.31579223e-02f, 3.91392000e-02f, 8.90479311e-02f, 2.17706859e-02f, -5.13216667e-02f, 1.42662585e-01f, -7.84300417e-02f, 1.36230178e-02f, -2.03920864e-02f, 1.27498722e-02f,
  -9.53249335e-02f, 5.26916347e-02f, -3.30252908e-02f, 4.59211916e-02f, -7.72001920e-03f, -6.51084557e-02f, 2.17454046e-01f, -7.98020139e-02f, -1.45588890e-01f, -2.72367802e-02f,
  -8.56490135e-01f, 6.15930200e-01f, 2.90944993e-01f, -3.17666024e-01f, 3.15242440e-01f, 3.80835533e-01f, -2.22110711e-02f, 3.14660311e-01f, 3.00238520e-01f, 2.03491032e-01f,
  -1.31023750e-01f, -6.55365118e-04f, 1.93708211e-01f, 2.98071913e-02f, -2.96859652e-01f, 1.81756943e-01f, -7.78564438e-02f, -2.32865646e-01f, 3.59581977e-01f, -2.91706938e-02f,
  1.34759292e-01f, -8.90377015e-02f, -9.47435573e-02f, 3.21837008e-01f, 1.68986712e-02f, -5.14882617e-02f, -4.64316010e-01f, 3.12831849e-01f, -2.68308699e-01f, 1.91637084e-01f,
  -5.31562865e-01f, -4.27436322e-01f, -4.52885300e-01f, -2.54457504e-01f, -2.74073273e-01f, -1.53006181e-01f, -1.92817584e-01f, -2.39411350e-02f, -1.24731973e-01f, 1.23490065e-01f,
  -1.19937427e-01f, -1.37266517e-02f, 4.38939147e-02f, 2.30300710e-01f, 8.08164701e-02f, -6.55142441e-02f, 1.06155789e-02f, -1.29015729e-01f, 9.89483893e-02f, 1.64884567e-01f,
  1.70541763e-01f, 1.77458709e-03f, -1.59293845e-01f, -1.30175516e-01f, -2.50069946e-02f, -5.09856530e-02f, 9.00305584e-02f, -1.63243979e-01f, -5.13770320e-02f, -5.60846552e-02f,
  9.63009223e-02f, -4.58582416e-02f, -4.36935909e-02f, -5.38673401e-02f, 2.03185171e-01f, 1.32216522e-02f, 6.84846789e-02f, -1.00319467e-01f, 1.97509639e-02f, -1.23783015e-01f,
  -8.44982788e-02f, -1.33083791e-01f, -1.07131064e-01f, -7.49557167e-02f, -2.59387437e-02f, -6.49585796e-04f, -1.13861285e-01f, 2.59550195e-02f, 1.19777933e-01f, -3.58835496e-02f,
  -3.61182215e-03f, -1.78353284e-02f, -1.36776075e-01f, 3.84657532e-02f, -6.66328222e-02f, 7.97608122e-02f, 9.68556702e-02f, 3.33040915e-02f, -1.07530057e-01f, -3.61926146e-02f,
  -5.25827348e-01f, -3.35856616e-01f, -1.51289627e-01f, -2.10155770e-01f, -4.06026170e-02f, -9.90757346e-02f, -2.64754426e-02f, -1.07426837e-01f, -1.02231696e-01f, 2.13561282e-02f,
  7.09525943e-02f, 1.41480528e-02f, -4.89818677e-02f, 7.23950192e-02f, 4.89626937e-02f, -8.59973356e-02f, -9.33534205e-02f, -4.14002575e-02f, -1.47975504e-01f, 5.32008037e-02f,
  -5.11313602e-02f, 9.25047696e-02f, -3.09303291e-02f, -1.04323566e-01f, -4.45872024e-02f, -2.79496342e-01f, -1.24853522e-01f, 3.24858762e-02f, -1.72129080e-01f, 1.35945693e-01f,
  3.34837109e-01f, -9.97068658e-02f, -1.94168434e-01f, 1.45091102e-01f, -2.82479703e-01f, -5.52031159e-01f, -5.48133910e-01f, -1.53721675e-01f, 2.16803342e-01f, -9.45185870e-02f,
  1.91442594e-01f, -9.80789289e-02f, 4.05628562e-01f, -1.00233287e-01f, 1.98220670e-01f, 4.05943483e-01f, -3.72080803e-01f, -3.82404655e-01f, 6.37988746e-02f, -2.27001976e-04f,
  2.41363302e-01f, 1.79850295e-01f, 1.82614788e-01f, -1.19314700e-01f, -6.83359802e-02f, 6.53364807e-02f, 2.59223729e-01f, -3.99590060e-02f, -2.00288981e-01f, -1.09373324e-01f,
  -1.05889559e-01f, 3.25396627e-01f, -1.12373933e-01f, 2.09571421e-02f, -2.30711624e-02f, -9.73960906e-02f, -1.24028236e-01f, -8.50083232e-02f, 1.54800201e-02f, -3.93504314e-02f,
  9.35497656e-02f, 1.05712168e-01f, -1.36322245e-01f, 1.07113719e-01f, -1.73839793e-01f, -1.43294949e-02f, -8.36820621e-03f, -9.93365124e-02f, -1.20568005e-02f, 4.95359078e-02f,
  -1.42428547e-03f, -2.38650683e-02f, 2.62788702e-02f, 5.75667731e-02f, 2.23407313e-01f, 1.35833859e-01f, -1.01420470e-01f, -1.18451901e-01f, 2.34217122e-02f, 6.98513091e-02f,
  1.74818054e-01f, 4.28066142e-02f, -1.66079309e-02f, -4.03178446e-02f, -7.38603771e-02f, -4.13067155e-02f, -1.08199716e-02f, -2.73440748e-01f, 1.90392956e-02f, -9.81953070e-02f,
  -2.92946458e-01f, 4.67983969e-02f, 1.73382953e-01f, 2.61298828e-02f, 1.65705204e-01f, 3.70146073e-02f, -1.36922956e-01f, -8.87619555e-02f, -7.26071820e-02f, -1.29095197e-01f,
  1.46503046e-01f, 6.17321720e-03f, 4.02728319e-02f, -7.94384256e-02f, -1.09537914e-01f, 1.03294179e-01f, 2.03343630e-01f, 1.66309327e-01f, -1.67550668e-01f, -8.70956630e-02f,
  -3.89761440e-02f, 3.67676169e-01f, -1.11629702e-02f, -9.29279812e-03f, -1.76332369e-01f, -1.85826309e-02f, -1.90263316e-02f, 2.69279759e-02f, 2.74877343e-02f, 8.32604095e-02f,
  -6.57812506e-02f, -6.33411631e-02f, -6.48129731e-02f, 1.80739954e-01f, -1.23443477e-01f, 4.66175526e-02f, 1.27553403e-01f, 2.71908138e-02f, 4.91897017e-02f, 7.48670399e-02f,
  -1.48677574e-02f, 4.55652066e-02f, 1.00509949e-01f, -1.87726036e-01f, -1.01517357e-01f, 9.36168134e-02f, 3.38123785e-03f, 5.31321205e-02f, 2.22153917e-01f, -1.56707600e-01f,
  -7.81577528e-01f, 3.47195089e-01f, -1.49797782e-01f, 8.46259147e-02f, -1.62378147e-01f, 1.06625699e-01f, -2.78183430e-01f, 1.17782839e-01f, -4.52639401e-01f, 1.77342921e-01f,
  4.57822494e-02f, -4.41444725e-01f, 4.23797555e-02f, 4.38267678e-01f, 3.03029656e-01f, 5.15846133e-01f, 5.78629076e-01f, 2.06451684e-01f, 2.68353343e-01f, 2.53106475e-01f,
  2.30613321e-01f, 5.17858803e-01f, 5.32200456e-01f, 4.39600378e-01f, 2.98558623e-01f, 3.93640995e-02f, 2.12647140e-01f, 8.90849531e-02f, 5.07160187e-01f, -4.60268110e-02f,
  -1.42656177e-01f, -1.90581486e-01f, -2.20573664e-01f, -3.08848709e-01f, -6.62722290e-02f, -1.34503677e-01f, 5.69756627e-02f, -5.61637729e-02f, -5.70451878e-02f, -1.10138707e-01f,
  -1.73153013e-01f, 1.14154756e-01f, 1.03597909e-01f, -9.43312943e-02f, -9.20993313e-02f, 3.68291885e-02f, 1.65319145e-01f, 1.38179243e-01f, 7.95529783e-02f, 5.57258241e-02f,
  1.13558121e-01f, 3.08736145e-01f, 1.98149934e-01f, 1.08942501e-01f, 5.05226515e-02f, 6.78958297e-02f, 8.66715163e-02f, -9.54498574e-02f, 7.29838908e-02f, -1.45965606e-01f,
  8.42977613e-02f, 2.04898175e-02f, 1.84904531e-01f, -4.89179827e-02f, -7.32408166e-02f, 9.49931741e-02f, 7.62938783e-02f, 8.09083506e-02f, -1.21193811e-01f, 1.13672778e-01f,
  9.82863307e-02f, 2.70675272e-02f, -1.10979855e-01f, -8.35684463e-02f, -1.08036838e-01f, -1.02418445e-01f, -1.28536969e-02f, -5.13660796e-02f, 6.26688302e-02f, 1.63195640e-01f,
  -8.45663548e-02f, -2.37424206e-03f, 1.62834659e-01f, -3.54271792e-02f, -4.99472395e-03f, -3.47709320e-02f, 2.87896637e-02f, 2.89783422e-02f, 4.64088880e-02f, 1.08362354e-01f,
  -2.69498587e-01f, -9.59913433e-02f, -8.37185979e-02f, -7.03554899e-02f, -8.94695148e-02f, -2.06799880e-02f, -5.72803151e-03f, 1.59143463e-01f, -1.83687191e-02f, -1.37879655e-01f,
  -2.37837005e-02f, 4.55380157e-02f, -1.21906452e-01f, -1.68674774e-02f, -1.21400144e-03f, -6.77203014e-02f, -1.24706626e-02f, -1.60831317e-01f, -1.40995800e-01f, 1.86924607e-01f,
  -1.75969582e-02f, 3.30240577e-02f, 1.38626680e-01f, 2.53136426e-01f, 1.36630088e-01f, -1.00498656e-02f, -1.49524286e-01f, -2.47139446e-02f, 2.40824014e-01f, 7.42845535e-02f,
  -4.54182655e-01f, -4.87331420e-01f, 1.11498609e-01f, -2.43967593e-01f, 7.29909316e-02f, 4.42505151e-01f, 3.75601798e-01f, -3.80849302e-01f, -5.17596483e-01f, 1.28064314e-02f,
  2.40146127e-02f, -2.64283568e-01f, 1.06809534e-01f, -1.23141445e-01f, 1.95319965e-01f, -4.97106872e-02f, 2.72478107e-02f, 1.80990681e-01f, -6.27667010e-02f, -2.09486678e-01f,
  -1.52605876e-01f, 2.67656762e-02f, 1.13821059e-01f, -5.98219112e-02f, -1.60031408e-01f, -1.07882269e-01f, 1.54248282e-01f, 2.85820335e-01f, 2.75842249e-01f, 1.57046109e-01f,
  -9.87583995e-02f, -2.37225339e-01f, -9.28013623e-02f, -6.65398762e-02f, -4.06977115e-03f, 8.85338634e-02f, 2.64347106e-01f, 1.57516554e-01f, -6.31008968e-02f, -7.63701722e-02f,
  1.07227646e-01f, -5.10536432e-02f, -1.03899300e-01f, 1.59193650e-01f, -3.10190581e-02f, -1.52268007e-01f, -1.35114014e-01f, -8.54370072e-02f, -1.03973567e-01f, -6.39938330e-03f,
  -1.23789027e-01f, -1.16629452e-01f, -1.56536791e-02f, 8.92198756e-02f, -1.10495109e-02f, 2.60125697e-02f, 6.67877048e-02f, 1.28574401e-01f, -6.68418109e-02f, 1.92981828e-02f,
  8.97999555e-02f, 1.51292339e-01f, -1.05084963e-01f, -8.32875893e-02f, -1.19757459e-01f, 3.63959260e-02f, 2.54290793e-02f, -3.97425108e-02f, 1.53951324e-03f, -2.43364759e-02f,
  -2.43994896e-03f, -5.38396724e-02f, -1.05515637e-01f, 7.04365224e-02f, -5.93177825e-02f, -8.59183297e-02f, 1.84104368e-01f, -1.28701434e-01f, 5.63051924e-02f, 2.86660809e-02f,
  1.38061522e-02f, 1.70301765e-01f, 1.02871530e-01f, 1.20723002e-01f, -1.16251096e-01f, 3.90016325e-02f, -6.34545684e-02f, 6.06478564e-02f, -1.32091999e-01f, 3.36328335e-02f,
  -1.86466035e-02f, -8.52151513e-02f, -3.51748653e-02f, -1.55814394e-01f, 5.97060807e-02f, 5.66253951e-03f, 6.78136125e-02f, -8.97197723e-02f, -1.35757113e-02f, -9.45595875e-02f,
  5.72360754e-02f, 6.72650263e-02f, -2.39516725e-03f, 6.44648895e-02f, 9.70240533e-02f, -1.79556001e-03f, 9.97515842e-02f, -9.80499759e-02f, 1.64682955e-01f, 7.55839273e-02f,
  -4.79839072e-02f, -8.38919356e-02f, -3.66072543e-02f, -5.39449900e-02f, 1.81815680e-02f, 3.95397022e-02f, -6.75851107e-02f, -1.25591889e-01f, 7.81295151e-02f, 1.35612398e-01f,
  -6.53090894e-01f, -1.14978002e-02f, -4.32694048e-01f, -1.09639712e-01f, -2.48030439e-01f, -3.94675463e-01f, 1.03283428e-01f, -2.25873291e-01f, -8.55686963e-02f, 4.21216816e-01f,
  3.69422466e-01f, -2.46341348e-01f, 3.50590587e-01f, -1.91436037e-02f, -6.95139170e-01f, 3.56579870e-01f, -1.65558726e-01f, 1.78030401e-01f, -1.30295735e-02f, -1.54039547e-01f,
  -2.68534750e-01f, -1.57343615e-02f, -7.70757794e-02f, -6.21834733e-02f, -3.33022743e-01f, -1.90978989e-01f, 2.61937529e-01f, 5.15284128e-02f, -1.61232218e-01f, -4.33056317e-02f,
  -4.12291646e-01f, 9.80659015e-03f, 1.55609235e-01f, -2.37653032e-02f, -1.57062069e-01f, 1.13652982e-01f, -3.01845130e-02f, 2.20195744e-02f, 1.62058815e-01f, -9.71946195e-02f,
  3.56441364e-02f, -1.23793513e-01f, -1.66719586e-01f, 3.63732465e-02f, -7.92990923e-02f, -1.20782152e-01f, -1.66814879e-01f, -6.85587972e-02f, -8.67656097e-02f, -9.28081721e-02f,
  -2.61974391e-02f, -7.91859776e-02f, -9.78340656e-02f, 1.11348927e-01f, -1.03371158e-01f, 7.21079335e-02f, 1.81327835e-02f, 9.20960214e-03f, -1.54520452e-01f, -1.86535805e-01f,
  -6.45633861e-02f, 7.77577609e-02f, 3.53768803e-02f, -4.16541360e-02f, 1.37514606e-01f, -7.03071132e-02f, 6.91636652e-02f, 1.63240671e-01f, 5.47871403e-02f, -5.02734780e-02f,
  -2.06770763e-01f, -5.75364381e-03f, 1.77499850e-03f, 9.05791949e-03f, -3.54495570e-02f, 9.90414545e-02f, 1.10841326e-01f, -3.60228419e-02f, -6.62568286e-02f, -7.07971454e-02f,
  8.31965208e-02f, -1.25042334e-01f, 8.60965811e-03f, 1.16601042e-01f, 4.37227935e-02f, 6.87323883e-02f, 7.95585588e-02f, -2.23129615e-03f, 4.99293767e-02f, -1.20556608e-01f,
  -5.07115722e-01f, -3.34394842e-01f, 1.27077296e-01f, -1.25988662e-01f, 1.23593800e-01f, -4.58409451e-02f, 2.88069248e-02f, -5.65007068e-02f, -1.30999103e-01f, -1.11447223e-01f,
  -1.13556489e-01f, -6.62620086e-03f, -1.53302401e-01f, -2.58366242e-02f, -9.29610655e-02f, 6.01242259e-02f, 7.86201004e-03f, -1.11769497e-01f, -8.12770575e-02f, -6.13417383e-03f,
  -2.49908641e-02f, 8.30826089e-02f, 1.14575714e-01f, 7.22553208e-02f, -2.49511823e-02f, 6.60947859e-02f, -1.24591775e-01f, 6.62368312e-02f, -2.12540850e-01f, 1.42561523e-02f,
  5.97692281e-02f, -7.52319023e-02f, -1.76787563e-02f, 6.90133035e-01f, -7.30021447e-02f, 5.36788292e-02f, 2.40922973e-01f, 1.61969423e-01f, 4.96526867e-01f, 2.17611760e-01f,
  2.38671005e-01f, -4.05257761e-01f, -2.23846540e-01f, 5.77014804e-01f, -5.53528845e-01f, 4.93943989e-02f, 3.22061688e-01f, 2.53488690e-01f, 2.12007351e-02f, -1.08631544e-01f,
  -1.53173238e-01f, -7.72853494e-02f, 1.46024134e-02f, -2.43717059e-01f, 2.86697984e-01f, 4.31522690e-02f, -1.97245032e-01f, -3.66749108e-01f, 1.76116765e-01f, -2.87166834e-01f,
  8.08462277e-02f, 9.88497809e-02f, 2.15231404e-01f, -4.27835807e-02f, -7.39855543e-02f, -1.94138603e-03f, -9.34720505e-03f, -1.55753762e-01f, -1.38768896e-01f, 5.48491850e-02f,
  -1.78396739e-02f, 1.34126768e-02f, -6.44704401e-02f, -1.06273562e-01f, 6.75631166e-02f, 5.44636231e-03f, 1.12191454e-01f, 1.73481107e-01f, 4.16299701e-02f, -9.85547621e-03f,
  1.15684003e-01f, 9.31683779e-02f, 1.55905589e-01f, 4.27986979e-02f, -4.31244560e-02f, 5.85639328e-02f, -3.77973840e-02f, -1.28472447e-01f, 2.26092171e-02f, 1.02222346e-01f,
  9.96419340e-02f, -7.79383779e-02f, -7.04998383e-03f, 1.71268042e-02f, -3.05829104e-02f, 6.37076125e-02f, -9.12353173e-02f, -1.69175684e-01f, -1.41108155e-01f, -6.62012920e-02f,
  4.03792001e-02f, 1.12560550e-02f, 1.00566834e-01f, -5.13109332e-03f, 1.20251581e-01f, 1.77031100e-01f, -1.42522216e-01f, -8.87500681e-03f, 9.56152678e-02f, 6.19609691e-02f,
  -3.43653038e-02f, -1.50671015e-02f, -3.04179396e-02f, -1.23158153e-02f, -1.14376336e-01f, -9.19322222e-02f, 2.41028816e-02f, 9.44671854e-02f, 5.65207899e-02f, -1.15491398e-01f,
  -4.74033803e-01f, -4.23180044e-01f, -7.22503290e-02f, -4.70920391e-02f, -1.20570362e-01f, -2.72992887e-02f, -8.59366730e-02f, -4.29357821e-03f, -2.13561594e-01f, 3.59679386e-03f,
  -5.80224767e-02f, 7.58311227e-02f, -1.47888795e-01f, -4.47434485e-02f, -8.81430209e-02f, -9.86808464e-02f, 1.78188253e-02f, -1.51170157e-02f, -1.28386989e-01f, -5.80970906e-02f,
  7.23378062e-02f, -3.32676470e-02f, -3.62930335e-02f, 9.14914683e-02f, 1.08713381e-01f, -1.26875475e-01f, -4.66642454e-02f, 2.08928622e-02f, 7.75835756e-03f, -1.67219173e-02f,
  1.00143850e-01f, -5.21544695e-01f, 4.17653352e-01f, 1.22732699e-01f, 3.48042578e-01f, 3.36086482e-01f, 2.97279179e-01f, 2.54462868e-01f, 4.91089933e-02f, -4.15755451e-01f,
  -9.22398269e-02f, -4.57844943e-01f, 4.05438058e-02f, -1.82523951e-01f, 3.45629960e-01f, 5.54444548e-03f, -1.44330844e-01f, -2.82360703e-01f, 3.15517604e-01f, 8.87570009e-02f,
  2.20133543e-01f, -1.82948291e-01f, 5.05620599e-01f, -1.25609949e-01f, 1.67462885e-01f, -2.96316314e-02f, -1.31386086e-01f, 2.24852994e-01f, -1.98444605e-01f, -2.48232782e-01f,
  1.56539828e-02f, -1.54253095e-02f, 5.12013771e-02f, 1.68550070e-02f, 2.04342589e-01f, 9.92649980e-03f, 6.53782906e-03f, 4.06435132e-02f, 1.51723251e-01f, 1.67375877e-02f,
  2.10570395e-02f, 1.29145041e-01f, -1.55101717e-01f, 3.45286392e-02f, 9.38360468e-02f, 1.28064007e-01f, 1.04756303e-01f, 3.04521769e-01f, 5.05539402e-02f, 1.93082437e-01f,
  2.63230532e-01f, 7.67916515e-02f, 3.61333899e-02f, -4.09190394e-02f, 1.51668563e-01f, 1.02990672e-01f, -1.03044614e-01f, 9.87746380e-03f, -7.12542087e-02f, -6.01543002e-02f,
  -2.53157727e-02f, 1.26727642e-02f, -2.27061305e-02f, 5.10599576e-02f, -1.79243833e-01f, 7.71775171e-02f, -4.54193652e-02f, -8.72305110e-02f, -7.74760544e-02f, -5.00020850e-03f,
  -6.82725385e-03f, -1.41250566e-02f, 1.36738727e-02f, -3.37190405e-02f, -2.51787435e-02f, -1.00715272e-01f, -6.37830198e-02f, -1.53566718e-01f, 2.44623292e-02f, 1.22707505e-02f,
  -8.70377570e-03f, 7.67913833e-02f, 5.18431328e-03f, 1.85242742e-02f, -2.48929467e-02f, 1.02257185e-01f, 3.28847393e-02f, 1.17700705e-02f, 1.22339807e-01f, -2.78414246e-02f,
  -4.01910067e-01f, -4.35139656e-01f, -9.63326618e-02f, -1.22863315e-01f, -2.46023148e-01f, 1.87420733e-02f, -1.20162722e-02f, -7.89849684e-02f, -2.18410436e-02f, 1.41757458e-01f,
  8.75917822e-02f, 1.17172144e-01f, -1.25331789e-01f, 2.48285439e-02f, -8.86417925e-02f, 1.00341208e-01f, -1.00278042e-01f, -1.29194364e-01f, -1.68300909e-03f, -8.23932588e-02f,
  4.11314294e-02f, -1.06180068e-02f, -5.06206676e-02f, 1.27124965e-01f, 3.12433578e-02f, -1.99308023e-02f, -1.83348984e-01f, -2.19405051e-02f, 5.08253500e-02f, -7.46901482e-02f,
  -2.41143301e-01f, 3.20142448e-01f, 1.47191400e-04f, 2.60397494e-02f, -1.09160729e-01f, -4.67451632e-01f, -3.76036704e-01f, -1.57718211e-01f, -5.68842702e-02f, 4.09284770e-01f,
  -2.48658419e-01f, 4.16044295e-01f, 3.89587805e-02f, -3.83849174e-01f, -6.27675712e-01f, -5.59853971e-01f, -1.76718965e-01f, -1.34542301e-01f, -1.73116010e-02f, 2.78895408e-01f,
  -1.44291282e-01f, -2.20088571e-01f, -1.90421402e-01f, 2.30080143e-01f, 1.14200383e-01f, 3.43008608e-01f, 3.97104084e-01f, 1.70285106e-01f, 1.91117570e-01f, -1.23992845e-01f,
  -5.04115559e-02f, 1.38629258e-01f, 1.39298020e-02f, -5.77083007e-02f, 1.01357527e-01f, 8.54060426e-03f, 5.98013923e-02f, -9.51076895e-02f, -1.05191516e-02f, 1.10077217e-01f,
  8.16255882e-02f, -6.94263130e-02f, -3.14282700e-02f, -4.48530056e-02f, -1.23966210e-01f, 1.23957284e-01f, 2.54934337e-02f, 2.39162873e-02f, 1.45634651e-01f, -4.68465835e-02f,
  7.23387152e-02f, 9.35343504e-02f, 1.32289246e-01f, 1.74523667e-01f, 2.63393857e-02f, -6.91427151e-03f, -8.98481384e-02f, 6.96451664e-02f, 2.15184525e-01f, 6.73747957e-02f,
  1.41276196e-02f, -1.23612897e-03f, -7.59416297e-02f, -3.70445326e-02f, -4.10392843e-02f, 2.95322072e-02f, -4.83153574e-02f, -1.59439463e-02f, 2.02346835e-02f, 4.13042270e-02f,
  4.18523252e-02f, 8.46049413e-02f, -4.32809629e-02f, 6.30337968e-02f, 1.00730926e-01f, -3.85994352e-02f, -1.22212186e-01f, 1.02110744e-01f, 7.71014169e-02f, -3.06387302e-02f,
  1.29567891e-01f, -1.20668456e-01f, 7.90974423e-02f, 2.70606093e-02f, -2.32430369e-01f, 6.54467493e-02f, 1.24003820e-01f, -1.03501424e-01f, 3.21328305e-02f, -1.47612812e-03f,
  1.85173020e-01f, 4.23777908e-01f, 1.17647864e-01f, 8.60469565e-02f, 5.83404861e-02f, -4.66814376e-02f, -1.79324463e-01f, -1.74592026e-02f, 3.22556235e-02f, -2.39225067e-02f,
  4.43665162e-02f, 9.19286683e-02f, 2.41433188e-01f, -9.18686986e-02f, 4.70176339e-03f, -8.47839564e-02f, 2.24040672e-01f, 8.13669041e-02f, 2.06297651e-01f, 1.11794166e-01f,
  2.85659999e-01f, 2.42965650e-02f, 4.96631451e-02f, 4.69670892e-02f, 1.92004144e-01f, 1.09032951e-01f, 1.16738603e-02f, -2.77614798e-02f, 1.16917066e-01f, 1.52600169e-01f,
  3.81559074e-01f, -3.95024002e-01f, -3.95357996e-01f, -9.23714340e-02f, 2.54305512e-01f, 3.11477423e-01f, 1.35691360e-01f, -1.08705446e-01f, -5.07321477e-01f, -1.57339364e-01f,
  2.39281610e-01f, -1.28751725e-01f, -1.16506658e-01f, -7.04662949e-02f, 2.78348446e-01f, -4.70837682e-01f, 8.23731199e-02f, 1.16130300e-01f, -2.87420422e-01f, 2.80626655e-01f,
  -3.23097315e-03f, 3.69081914e-01f, -9.28528309e-02f, 9.26122293e-02f, 3.71916413e-01f, 2.42162663e-02f, 4.55517590e-01f, 1.20225795e-01f, 2.64525652e-01f, 2.82893360e-01f,
  -4.92663942e-02f, -9.27745104e-02f, -1.09053247e-01f, -1.10370219e-01f, 4.83820774e-02f, 1.41159520e-01f, 1.68453753e-01f, 1.58221021e-01f, -6.66439533e-02f, -5.67664132e-02f,
  1.54009879e-01f, 1.27651364e-01f, -6.39820006e-03f, 9.96222869e-02f, 1.24231309e-01f, -7.94187561e-02f, -2.16565937e-01f, -1.12245910e-01f, -1.79544002e-01f, -1.56678574e-03f,
  -1.87684223e-02f, -5.32929376e-02f, 9.13041905e-02f, -4.49475162e-02f, 6.29486665e-02f, 1.50825782e-02f, 2.86762808e-02f, 2.04299822e-01f, -6.86862171e-02f, -2.82673333e-02f,
  1.61521852e-01f, 1.26301706e-01f, 1.32816985e-01f, -1.14345901e-01f, -1.70215666e-02f, -1.48281962e-01f, -1.16921574e-01f, -1.30497321e-01f, 1.38446158e-02f, -6.99390471e-02f,
  -8.76522344e-03f, -1.89017672e-02f, -1.24404803e-01f, 1.19707407e-02f, 1.92423955e-01f, 3.53292227e-02f, 1.96514055e-01f, 1.13965929e-01f, -9.04368237e-02f, -1.42656490e-01f,
  -1.98699370e-01f, 1.09313510e-01f, 2.80504599e-02f, 3.52639556e-02f, -8.41112882e-02f, 9.90681201e-02f, 8.21823925e-02f, 2.16606576e-02f, -3.09746340e-02f, 6.04260899e-02f,
  1.10748373e-01f, 8.12138841e-02f, -1.13742717e-01f, 4.23995964e-02f, -2.09562406e-01f, -7.83043206e-02f, -2.13472217e-01f, 4.57262471e-02f, 1.32610351e-01f, 1.21818632e-01f,
  1.98089808e-01f, 4.93604783e-03f, -5.55479862e-02f, -7.49891251e-02f, 1.06592849e-01f, 2.66080126e-02f, 1.52009726e-01f, 2.37538666e-03f, -3.63291912e-02f, -2.81022359e-02f,
  2.36727655e-01f, 1.25015184e-01f, 5.90763912e-02f, 1.14940561e-01f, -2.94029787e-02f, 9.60460678e-02f, 9.35180932e-02f, 1.09785758e-01f, -7.98011646e-02f, -9.60236415e-02f,
  4.82540041e-01f, -3.46358389e-01f, 3.66880774e-01f, 2.73164570e-01f, 2.53784031e-01f, 5.44906735e-01f, 5.28799117e-01f, 2.02099159e-02f, 6.87843204e-01f, -4.70644087e-01f,
  -2.77916104e-01f, -7.60999620e-02f, 1.95434406e-01f, -1.88092336e-01f, 5.73673189e-01f, 4.43774253e-01f, 1.82673246e-01f, 1.92078337e-01f, -1.33117801e-02f, -1.56151563e-01f,
  -3.40083465e-02f, -3.73165995e-01f, -9.77235138e-02f, -5.78129351e-01f, -3.29761475e-01f, -3.35818440e-01f, -3.77204478e-01f, 2.33804315e-01f, -5.29299200e-01f, 1.32879868e-01f,
  -2.10701630e-01f, -3.32970858e-01f, -9.03140157e-02f, -1.65744662e-01f, -1.15821920e-01f, 7.81773552e-02f, 8.81580859e-02f, 2.12866560e-01f, 1.60307303e-01f, -7.81952366e-02f,
  1.04805835e-01f, -8.04468095e-02f, -1.72417879e-01f, 9.96848792e-02f, 4.51416150e-02f, -2.04771236e-01f, -2.10009087e-02f, -8.23667496e-02f, 4.92073111e-02f, 9.68869925e-02f,
  -6.12743432e-04f, 2.57603452e-02f, -3.73178422e-02f, -1.50289446e-01f, 6.69079134e-04f, -1.06366631e-02f, -1.89619046e-02f, 7.27228448e-02f, -1.50586141e-03f, 1.17178805e-01f,
  -5.41071109e-02f, -3.03734075e-02f, -2.17841589e-03f, 4.86018434e-02f, 3.01277526e-02f, -8.39688554e-02f, 6.05918169e-02f, -4.86303233e-02f, 5.42454943e-02f, 2.02899929e-02f,
  1.01271927e-01f, -8.23874995e-02f, 5.36442846e-02f, 3.07237264e-02f, -1.36522591e-01f, 9.83172655e-02f, 1.11133203e-01f, 6.49600551e-02f, -3.40662245e-03f, -2.77485866e-02f,
  1.03777111e-01f, 4.39925976e-02f, -1.97841182e-01f, -4.81453650e-02f, -1.51892453e-02f, 5.15578389e-02f, -1.09581023e-01f, 1.27193436e-01f, -2.85034757e-02f, 1.07673846e-01f,
  -5.10698445e-02f, -1.82634801e-01f, -1.38708383e-01f, -2.31341526e-01f, -2.92759556e-02f, -1.02173395e-01f, 9.07480270e-02f, -1.27130404e-01f, 9.05980263e-03f, 2.46458054e-02f,
  -1.69257805e-01f, -4.21041995e-02f, -1.80167530e-03f, 4.33355896e-03f, -1.16043642e-01f, -6.03378192e-02f, 1.55046619e-02f, -1.25959560e-01f, 4.47126292e-02f, -1.42930448e-01f,
  -9.02996063e-02f, -1.60462931e-02f, 5.09502850e-02f, -2.01658189e-01f, -1.88100457e-01f, 5.06841019e-03f, -9.15275887e-02f, -4.06905413e-02f, -4.09165733e-02f, 2.03961432e-02f,
  2.46950209e-01f, 2.98862934e-01f, -2.68159062e-02f, 3.60895455e-01f, 6.10151589e-01f, 5.20770192e-01f, 2.12234974e-01f, 5.36858439e-01f, 6.74584150e-01f, -3.41377407e-01f,
  -1.24759011e-01f, 1.71075776e-01f, -5.55626094e-01f, 2.70855129e-01f, 1.36243060e-01f, -1.30455181e-01f, 6.46469653e-01f, 4.22696710e-01f, 4.38444346e-01f, 5.22871315e-02f,
  2.65782446e-01f, 3.58887985e-02f, -5.09628356e-01f, 1.24646090e-01f, -1.80589110e-02f, 5.13905920e-02f, -4.61523682e-01f, -1.89829841e-01f, -1.63117602e-01f, 3.67496908e-01f,
  1.23124160e-01f, 1.35417223e-01f, -1.03337042e-01f, -8.36654305e-02f, -1.30868524e-01f, -1.26154497e-01f, -1.11960679e-01f, -5.86624295e-02f, 1.28170967e-01f, -6.80421367e-02f,
  -8.84607211e-02f, -1.99829079e-02f, 1.90199143e-03f, -2.40242891e-02f, 2.13357598e-01f, -9.53693837e-02f, 3.37050483e-02f, 4.89568673e-02f, 1.23174936e-01f, -6.14629835e-02f,
  -1.01317868e-01f, 3.60190123e-02f, -2.01096069e-02f, 1.83235750e-01f, -7.50390973e-05f, 1.83161139e-01f, 5.00643626e-02f, -2.06463432e-04f, -6.42730594e-02f, 1.60755098e-01f,
  -5.97941838e-02f, 1.49859533e-01f, -1.57131687e-01f, -5.14354371e-02f, -1.14466711e-05f, 2.53949780e-02f, -3.99746560e-02f, -5.64930663e-02f, 1.35056814e-02f, -2.12597605e-02f,
  7.51024997e-03f, 7.18592014e-03f, 3.43252122e-02f, 1.12472981e-01f, -8.93418118e-03f, 9.30215046e-02f, -5.84214106e-02f, -2.30171289e-02f, 8.03125501e-02f, -1.07744761e-01f,
  -1.76062379e-02f, 1.16260901e-01f, -1.01400703e-01f, 5.25030494e-02f, 7.31869712e-02f, -7.27913156e-02f, -1.00323915e-01f, 5.26748970e-03f, -1.67541895e-02f, -3.59800570e-02f,
  1.59445927e-01f, 3.65707189e-01f, -7.18018338e-02f, -1.14012964e-01f, -1.03628278e-01f, -4.46256138e-02f, 8.34958330e-02f, 1.33672103e-01f, 1.69519618e-01f, -4.56181951e-02f,
  -4.18878719e-02f, -2.86728498e-02f, -3.22261713e-02f, -6.94168881e-02f, -1.62162576e-02f, -3.37909833e-02f, -1.46962509e-01f, 7.67685398e-02f, 7.61606917e-02f, -2.15987284e-02f,
  -1.19248100e-01f, 1.01427957e-02f, -4.41709012e-02f, 2.03649014e-01f, 3.03273760e-02f, -9.87569392e-02f, 1.00181051e-01f, 1.99852549e-02f, -1.59461617e-01f, 1.12558007e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.08311987e-01f, 2.39419937e-01f, 5.07962644e-01f, 4.44702029e-01f, 2.88319200e-01f, 5.50419271e-01f, 1.73279807e-01f, 5.59252143e-01f, 6.44264579e-01f, 5.26857316e-01f,
  3.40402991e-01f, 4.75338191e-01f, 4.29693967e-01f, 5.61050713e-01f, 4.74608839e-01f, 5.45940816e-01f, 4.40179199e-01f, 4.79945779e-01f, 5.04294693e-01f, 4.45884585e-01f,
  3.37810308e-01f, 5.45696437e-01f, 4.67736393e-01f, 4.06225979e-01f, 3.05593103e-01f, 5.09874940e-01f, 3.89899641e-01f, 4.83176082e-01f, 4.68048364e-01f, 4.17421073e-01f,
  2.32213676e-01f, 2.58631647e-01f, 3.95842850e-01f, 1.15523718e-01f, 4.75908518e-01f, 3.86988103e-01f, 3.91121119e-01f, 4.94658321e-01f, 4.53000516e-01f, 1.43424734e-01f,
  5.52033365e-01f, 3.45325649e-01f, 3.07455212e-01f, 3.90576154e-01f, 5.05290449e-01f, 2.20858470e-01f, 2.83903539e-01f, 5.07095575e-01f, 5.55360913e-01f, 6.23573065e-01f,
  5.30253530e-01f, 4.58843589e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.31800190e-01f, -2.70519614e-01f, -3.07267666e-01f, 9.55047160e-02f, -3.86526048e-01f, -1.79757372e-01f, -4.47497398e-01f, 4.31552455e-02f, -1.27651840e-01f, -4.40630689e-03f,
  -9.82660353e-02f, -3.10895920e-01f, -4.49774235e-01f, 2.57475704e-01f, 3.35311890e-01f, 2.86045641e-01f, -1.57819271e-01f, -4.44326162e-01f, 1.47825196e-01f, -3.79039437e-01f,
  2.27682382e-01f, -4.27838802e-01f, 1.47780418e-01f, -7.23129958e-02f, -5.08800805e-01f, 4.00479645e-01f, -2.16222540e-01f, -4.04484749e-01f, -1.02055751e-01f, -9.46575254e-02f,
  -3.22706401e-01f, -1.82220936e-01f, -6.98264763e-02f, -5.01491666e-01f, 2.53967762e-01f, -2.93241501e-01f, 6.95753098e-02f, 1.08146323e-02f, -3.51089209e-01f, -3.15670341e-01f,
  1.47783130e-01f, 4.85645831e-01f, 3.13467532e-01f, 4.65413183e-01f, -2.70693570e-01f, 4.92866755e-01f, -3.64403665e-01f, -5.69581151e-01f, -2.47229263e-01f, -1.98700458e-01f,
  -1.68228164e-01f, 3.21887106e-01f, -7.34819114e-01f, -1.05425626e-01f, -2.74196982e-01f, 3.27654421e-01f, 2.60673881e-01f, 6.03313208e-01f, 5.09674430e-01f, -2.82397538e-01f,
  -1.20027810e-01f, -6.06833398e-01f, -3.40641856e-01f, -7.21278429e-01f, 1.67429805e-01f, 7.15572536e-02f, 2.55546421e-01f, 1.53077975e-01f, 2.24599645e-01f, -3.12285013e-02f,
  4.62302506e-01f, -4.31642681e-01f, 4.98772599e-02f, -5.91922253e-02f, -3.17348063e-01f, 3.97020102e-01f, -6.73824549e-01f, 1.99232027e-01f, -2.34608501e-01f, 6.12395585e-01f,
  4.23930973e-01f, -3.21303159e-01f, -2.88533837e-01f, -2.92130202e-01f, -7.40423918e-01f, -8.13601315e-01f, 1.65934667e-01f, -2.70179689e-01f, 2.77931511e-01f, 2.31939495e-01f,
  2.44671926e-02f, 7.38836080e-02f, -6.42642021e-01f, -6.03389323e-01f, -3.34000945e-01f, 4.37949717e-01f, 3.19668144e-01f, -1.65705569e-02f, 4.31777596e-01f, -2.50098616e-01f,
  -2.78420508e-01f, 1.56665012e-01f, -3.22455972e-01f, 3.39639150e-02f, -6.57251894e-01f, 4.38644409e-01f, 5.36115706e-01f, -7.25121319e-01f, -3.04713786e-01f, -2.28382543e-01f,
  -2.14491606e-01f, 2.51682580e-01f, 5.98240912e-01f, -4.64867979e-01f, -4.76935476e-01f, -1.22407988e-01f, -6.06404208e-02f, -6.50274754e-01f, 1.91789597e-01f, 1.79937050e-01f,
  -1.62609294e-01f, -7.12955296e-01f, 1.07582507e-03f, -4.01543736e-01f, -5.42927146e-01f, 3.94858390e-01f, -2.79943049e-01f, 2.90175110e-01f, -3.88653338e-01f, -1.98564291e-01f,
  -3.04443806e-01f, -2.89955497e-01f, -6.82262927e-02f, -2.63938636e-01f, 2.16009498e-01f, 1.33962050e-01f, -2.23886460e-01f, -3.14350843e-01f, -2.10303023e-01f, 3.13333869e-01f,
  6.13646656e-02f, 4.88807410e-01f, -3.60292435e-01f, -2.56075859e-01f, 5.28338477e-02f, -3.28438342e-01f, 3.59968282e-02f, -3.33279520e-01f, -1.11825086e-01f, 3.03270221e-01f,
  4.09151733e-01f, -3.83530200e-01f, 5.17520010e-01f, -4.19169724e-01f, -5.59201911e-02f, -3.54191422e-01f, -5.35744727e-02f, 1.48191780e-01f, 2.82319218e-01f, -2.33293042e-01f,
  -2.28837267e-01f, -5.01133800e-01f, -5.22227228e-01f, 2.40404263e-01f, -2.42638260e-01f, -7.71539733e-02f, 2.16228172e-01f, -7.73950592e-02f, 3.73475790e-01f, -6.42937958e-01f,
  3.69009912e-01f, -2.44973361e-01f, -2.59959370e-01f, -2.04443410e-01f, -3.40027124e-01f, 4.71532702e-01f, 8.57941955e-02f, -2.22944200e-01f, -7.58712273e-03f, 4.07138705e-01f,
  -3.04117233e-01f, -4.74351943e-01f, -5.30018568e-01f, 1.83161303e-01f, 2.08586603e-01f, -3.07636857e-01f, -5.11290394e-02f, -3.08617890e-01f, -4.02780473e-01f, 3.46224755e-01f,
  -3.96772325e-01f, 1.24867871e-01f, -3.74872267e-01f, -1.76565945e-01f, -3.53271753e-01f, -1.25081375e-01f, -2.54677474e-01f, 2.22667664e-01f, -2.15882659e-01f, 3.75007600e-01f,
  4.71019536e-01f, 3.04166526e-02f, -2.25479193e-02f, -6.91351220e-02f, -2.05759972e-01f, -3.65418017e-01f, -5.84293425e-01f, 3.99340302e-01f, -1.55556481e-02f, 3.21812838e-01f,
  -1.93330094e-01f, 8.62904191e-02f, 2.97082633e-01f, -1.80766955e-02f, -3.78174514e-01f, 6.41501620e-02f, -2.28956550e-01f, -5.59975207e-01f, -2.42931783e-01f, -3.35749447e-01f,
  -7.10121691e-02f, -1.30561143e-01f, -8.75770748e-02f, 5.43174326e-01f, -2.78972924e-01f, -5.34875691e-01f, -6.41627491e-01f, -3.68596345e-01f, 4.59411561e-01f, -4.05150801e-01f,
  -6.80948019e-01f, -9.27262679e-02f, -4.42733586e-01f, -2.31961161e-01f, 4.67814088e-01f, 2.65764594e-01f, -5.80605686e-01f, -1.74346611e-01f, -1.77516043e-01f, -1.41414434e-01f,
  -1.59167111e-01f, 3.95543188e-01f, 5.95120311e-01f, -9.23823416e-02f, 6.91780373e-02f, 4.33057666e-01f, 2.15576828e-01f, -4.74199235e-01f, -1.36132866e-01f, 4.42947328e-01f,
  -1.40579194e-01f, -5.83566129e-01f, 2.51727104e-01f, -6.63371801e-01f, -7.52080441e-01f, -2.87134081e-01f, 3.51160556e-01f, 1.66681558e-01f, 2.31401786e-01f, 4.52255681e-02f,
  1.51992813e-01f, -1.76936716e-01f, -3.69760543e-01f, -4.38246012e-01f, 1.22708492e-01f, -2.20573768e-01f, 4.52223599e-01f, -2.46760160e-01f, 1.11998208e-02f, 2.79588550e-01f,
  5.71494043e-01f, -2.30686888e-01f, 1.01224795e-01f, 2.92587698e-01f, -4.37722355e-01f, 6.09861791e-01f, 4.04013842e-01f, 7.07934350e-02f, -3.93355414e-02f, -1.29314512e-01f,
  -5.65253086e-02f, -6.00630164e-01f, 2.98382461e-01f, -1.87821299e-01f, -5.24136901e-01f, -2.53177911e-01f, -3.75228822e-01f, -6.34831667e-01f, -4.23282892e-01f, -8.29562917e-02f,
  -5.82640290e-01f, -1.10284984e-01f, 2.89198130e-01f, 4.26584154e-01f, 2.40221262e-01f, -5.07308662e-01f, -8.87754709e-02f, 3.26169908e-01f, -3.59412700e-01f, -1.71594039e-01f,
  3.28914523e-01f, -1.55547678e-01f, -1.07093185e-01f, -1.63565025e-01f, -2.33181447e-01f, 2.99845219e-01f, 1.44048139e-01f, -2.51015723e-01f, 1.36525720e-01f, 5.03317535e-01f,
  -3.91866595e-01f, 5.04433334e-01f, 2.12793306e-01f, -2.93520421e-01f, -2.73481518e-01f, 3.95195484e-01f, -6.50923073e-01f, -4.01951671e-01f, -9.13056284e-02f, -1.80490285e-01f,
  1.47938117e-01f, 1.73800662e-01f, 2.49299526e-01f, 1.60024598e-01f, 2.96562105e-01f, 2.20997304e-01f, -2.44867951e-01f, -3.14086109e-01f, 3.90347213e-01f, 4.81366366e-01f,
  -3.14952910e-01f, -2.45658532e-01f, 6.54752851e-01f, -4.60583836e-01f, 2.64245212e-01f, -3.04353386e-01f, -2.62826353e-01f, -7.11719394e-01f, -5.29808819e-01f, -2.69959569e-01f,
  2.23591343e-01f, -2.14088947e-01f, -4.99884039e-01f, 5.61315060e-01f, -3.19298655e-01f, 2.99077153e-01f, -1.58504203e-01f, 6.12210743e-02f, 1.77730888e-01f, -4.88841802e-01f,
  -3.35756123e-01f, -4.17158365e-01f, 1.01173297e-01f, -7.10296810e-01f, 4.75436330e-01f, -3.82501453e-01f, -4.42918539e-01f, 1.02327146e-01f, -2.87223548e-01f, -5.13586402e-01f,
  2.20760599e-01f, -1.26689121e-01f, -8.20629478e-01f, 6.08891398e-02f, -6.50953650e-01f, 3.84936124e-01f, 5.22990823e-01f, -4.09218639e-01f, -2.11975366e-01f, -4.91416991e-01f,
  -4.90296155e-01f, -2.08173126e-01f, 5.08069515e-01f, 2.47801706e-01f, -3.03737018e-02f, -5.02127290e-01f, 3.27027962e-02f, -2.83025950e-01f, -7.22366124e-02f, -4.74495620e-01f,
  9.67043452e-04f, -1.61951244e-01f, 3.72657686e-01f, 6.07120037e-01f, -2.17788756e-01f, -1.90915257e-01f, 5.98367192e-02f, 3.52695510e-02f, -4.13362496e-02f, 2.12796122e-01f,
  2.99398124e-01f, 5.53508759e-01f, 1.21172957e-01f, 2.20620215e-01f, 2.74473131e-01f, -1.49646610e-01f, -1.48500890e-01f, -6.61049426e-01f, -7.17336237e-01f, -2.36742273e-01f,
  -1.61860302e-01f, -3.82271677e-01f, 1.21548139e-01f, -5.07413805e-01f, -4.88057047e-01f, 5.00482678e-01f, -6.57988548e-01f, -5.97147048e-01f, -6.13973558e-01f, -5.50556302e-01f,
  -2.00871572e-01f, 3.08163315e-02f, -3.05518538e-01f, 4.76512432e-01f, -3.45177531e-01f, 2.78201042e-04f, 3.87508512e-01f, 2.13290036e-01f, 1.69166967e-01f, 5.76274335e-01f,
  -2.55666912e-01f, 1.66214243e-01f, -3.45961601e-02f, 1.60660550e-01f, 3.11015248e-01f, -2.92313218e-01f, -2.37777516e-01f, -3.72869730e-01f, 1.55547202e-01f, -1.76233634e-01f,
  2.85298884e-01f, 5.56682587e-01f, 4.44592647e-02f, -2.98342615e-01f, -1.57890931e-01f, -3.33519608e-01f, -6.30319044e-02f, -1.80322215e-01f, 1.24689981e-01f, -3.11848313e-01f,
  -7.17070639e-01f, -3.15040082e-01f, 5.27769864e-01f, 5.35396278e-01f, -4.58230138e-01f, -1.29311800e-01f, 2.63848424e-01f, 3.20550472e-01f, -1.35807618e-01f, -3.09727658e-02f,
  -2.21041039e-01f, -2.33751997e-01f, -2.59399146e-01f, -2.79396266e-01f, -2.54202485e-01f, -1.55267268e-01f, 1.47283107e-01f, 2.02438027e-01f, 1.30452320e-01f, 8.74448661e-03f,
  6.05477691e-01f, -2.39266932e-01f, -2.95138597e-01f, -5.68009913e-01f, -3.38732809e-01f, 2.09125981e-01f, 5.31338036e-01f, -1.18724875e-01f, 2.09063634e-01f, -3.76917541e-01f,
  1.84208557e-01f, -4.98302341e-01f, 1.46779373e-01f, -3.61879081e-01f, 3.75688761e-01f, 3.62689883e-01f, -2.29410335e-01f, 7.89616108e-02f, -4.57546324e-01f, 3.68579216e-02f,
  -9.41751450e-02f, 3.79755825e-01f, -3.71235162e-01f, -2.94154406e-01f, 2.18069986e-01f, -2.33101547e-01f, -3.51708233e-01f, 5.05630448e-02f, 1.03880450e-01f, -4.37758684e-01f,
  -8.35421681e-02f, 2.94779897e-01f, -3.58857781e-01f, 1.33038819e-01f, -2.77320266e-01f, -2.15663239e-01f, -3.32003117e-01f, -7.86438119e-03f, -1.50962919e-01f, 3.15732002e-01f,
  1.20921411e-01f, -3.57726574e-01f, 3.29786718e-01f, -1.72482654e-01f, -2.47927606e-01f, 2.77414650e-01f, -4.21266139e-01f, -2.30979145e-01f, 1.02337591e-01f, -1.74322799e-01f,
  -2.95887776e-02f, -2.22551450e-01f, -2.84332521e-02f, 1.53658036e-02f, 7.65287802e-02f, -2.41728082e-01f, 7.78913721e-02f, -1.35445029e-01f, -2.16192771e-02f, 4.80323523e-01f,
  -9.88090709e-02f, -3.26477379e-01f, 3.42440218e-01f, 2.14860648e-01f, 5.75807393e-02f, -2.39230037e-01f, -2.72567123e-01f, -3.62336040e-01f, 3.58235121e-01f, -3.48329395e-02f,
  -2.42527261e-01f, -3.35358560e-01f, -2.18076155e-01f, -2.22229928e-01f, 2.62605727e-01f, -1.48722723e-01f, -2.21835375e-02f, 1.97492138e-01f, -3.05303633e-01f, -3.54461133e-01f,
  4.83019590e-01f, -2.03006864e-01f, -3.92383069e-01f, -4.18128103e-01f, 1.16676919e-01f, -3.70204061e-01f, -3.97265293e-02f, -2.04237923e-01f, -9.77741107e-02f, -4.53797728e-01f,
  -2.98749626e-01f, -1.01263806e-01f, -4.73026246e-01f, -4.80386555e-01f, -3.58812690e-01f, -3.44174296e-01f, 5.20287454e-01f, -2.50847131e-01f, 5.65078199e-01f, -2.99653769e-01f,
  -4.12614763e-01f, -4.22427893e-01f, -1.02539346e-01f, 5.33845723e-01f, -2.57169247e-01f, -3.10051292e-01f, 3.28916788e-01f, 4.41563576e-01f, -4.79304343e-01f, -2.73771435e-01f,
  -2.47730538e-01f, 1.32674158e-01f, 3.56686264e-01f, 2.15472311e-01f, -3.99172097e-01f, -2.15670153e-01f, -2.30846871e-02f, 1.02599375e-01f, -1.43772103e-02f, -3.55712362e-02f,
  -9.47121233e-02f, -7.46085420e-02f, 3.43553513e-01f, -4.37611818e-01f, -3.81873518e-01f, 3.65316570e-01f, -4.14659828e-01f, -3.33093882e-01f, 2.46953871e-02f, -2.25636903e-02f,
  3.46364826e-01f, -1.84594885e-01f, 9.65523720e-02f, 1.46274075e-01f, 3.83107722e-01f, -2.66104080e-02f, -4.45468098e-01f, 3.66090268e-01f, -4.64071423e-01f, 3.86302955e-02f,
  3.86511683e-01f, -2.49854147e-01f, -3.18401068e-01f, 4.97106373e-01f, 5.75464249e-01f, -1.29288957e-01f, 1.25954494e-01f, -2.10710451e-01f, -4.58464146e-01f, 3.48292112e-01f,
  -5.49015522e-01f, -3.73442620e-02f, -5.45630634e-01f, 2.01871559e-01f, -1.86873972e-01f, -4.26272184e-01f, 3.40869635e-01f, 1.88936032e-02f, -2.24561498e-01f, -3.46283466e-02f,
  -1.13280974e-01f, -2.50659078e-01f, -6.61976695e-01f, -5.55974185e-01f, -2.56375134e-01f, -2.65672386e-01f, -3.05856407e-01f, -4.46612149e-01f, -5.71700335e-01f, -3.62868369e-01f,
  -1.86086684e-01f, -5.46244800e-01f, 5.17832875e-01f, 1.23538613e-01f, -7.10439146e-01f, 2.71458954e-01f, -3.69112849e-01f, 3.58710170e-01f, 5.71604192e-01f, -7.87501037e-01f,
  1.42713532e-01f, 1.86542079e-01f, 2.18562797e-01f, 1.92461479e-02f, 4.89518084e-02f, 3.17616135e-01f, -4.29722816e-01f, 3.34810734e-01f, -2.63027221e-01f, -3.48055214e-01f,
  4.07318056e-01f, 3.50099921e-01f, -3.10310930e-01f, -3.88823152e-01f, -4.17373359e-01f, 1.66303292e-01f, -4.53994095e-01f, -3.49499077e-01f, -3.67493391e-01f, -2.24679485e-01f,
  -4.30782080e-01f, -4.47324961e-01f, -1.77045226e-01f, -2.81143486e-01f, -1.00696310e-01f, -1.49026170e-01f, 4.63115811e-01f, -3.65952402e-01f, -4.76195097e-01f, -4.14968103e-01f,
  5.27430058e-01f, -2.77271897e-01f, -1.84898172e-02f, -4.24746275e-01f, 5.18121757e-02f, -4.90358204e-01f, -2.28330448e-01f, -5.89018404e-01f, -2.36041740e-01f, 6.34885252e-01f,
  2.09695514e-04f, 1.15126364e-01f, -1.78959385e-01f, -4.00548548e-01f, 4.90604460e-01f, -1.36645928e-01f, -5.24728060e-01f, -8.78922269e-03f, 5.07651150e-01f, 3.71622980e-01f,
  1.92750573e-01f, -5.04728377e-01f, -2.08119169e-01f, -7.01818526e-01f, -4.84565884e-01f, -2.76867867e-01f, 4.74808007e-01f, -2.78622098e-02f, -9.64586958e-02f, 4.38732542e-02f,
  4.59210426e-01f, 4.90373015e-01f, -2.96352506e-01f, -2.41442353e-01f, 1.56812102e-01f, -2.51461659e-02f, 4.47044224e-02f, 1.59632131e-01f, 2.01534495e-01f, 8.37711915e-02f,
  -1.75019369e-01f, 1.74670458e-01f, -1.48209840e-01f, 2.32452840e-01f, 7.19685182e-02f, 3.03480625e-01f, -2.84271762e-02f, -3.00724268e-01f, -4.05748546e-01f, -4.57229227e-01f,
  -1.98336735e-01f, 4.48213309e-01f, -3.92263919e-01f, 4.21327680e-01f, 3.71609628e-01f, -3.17680389e-02f, -2.18196198e-01f, 5.48981965e-01f, -3.82131636e-01f, 1.04292929e-01f,
  -2.51188278e-01f, -3.86579096e-01f, -1.61154255e-01f, 6.03554845e-01f, -4.51344848e-01f, 5.54884553e-01f, -2.73079753e-01f, -1.52700031e-02f, -4.03559566e-01f, 4.18014199e-01f,
  -3.38135421e-01f, -2.75499791e-01f, 5.60545981e-01f, 2.21607834e-01f, -5.53527296e-01f, -3.43999118e-01f, -3.19806427e-01f, 1.33176982e-01f, -2.71797895e-01f, -3.35574925e-01f,
  1.72974676e-01f, -4.51247931e-01f, 8.59899372e-02f, -3.96027595e-01f, -4.73018348e-01f, -2.81124592e-01f, 2.02593297e-01f, -1.10778131e-01f, -4.58945483e-01f, -1.95175886e-01f,
  -3.30820292e-01f, -2.21938565e-01f, 3.47630382e-01f, -2.85119206e-01f, 3.20562452e-01f, -3.88682932e-01f, -4.64287400e-01f, 5.71502186e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.32534131e-01f, -1.92212593e-02f, -6.85770065e-02f, 7.66023900e-03f, 1.39016798e-02f, 1.32464126e-01f, -4.91211712e-02f, -1.75062582e-01f, -5.70352226e-02f, 1.27817541e-01f,
  5.86258918e-02f, -6.17101006e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    