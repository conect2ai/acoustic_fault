/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.90631068e-02f, 1.47012025e-01f, 3.85091722e-01f, 1.98117599e-01f, -1.12418853e-01f, -2.36207783e-01f, 4.52188887e-02f, -1.10279672e-01f, -2.13665575e-01f, -1.01342000e-01f,
  -4.14139219e-02f, 2.73201287e-01f, -6.90804375e-03f, 2.07363442e-01f, 2.23917454e-01f, 2.98961401e-02f, -1.07531296e-02f, 3.94128561e-02f, -4.04111557e-02f, -3.17568965e-02f,
  1.22853279e-01f, -1.14366017e-01f, 3.17489922e-01f, -7.73636028e-02f, 1.36349335e-01f, 9.90529954e-02f, 1.52185291e-01f, 1.15901008e-01f, 1.36832759e-01f, 1.30514547e-01f,
  7.23176077e-02f, -1.37926117e-01f, 1.41202360e-01f, -4.57124338e-02f, -2.37578489e-02f, -9.46431458e-02f, 5.28101772e-02f, 3.08737382e-02f, -2.88349818e-02f, 1.57185774e-02f,
  -6.23625442e-02f, -1.07606547e-02f, -7.74765867e-05f, -5.60480682e-03f, -2.85378117e-02f, 1.79416668e-02f, 4.69380766e-02f, 4.53744754e-02f, 8.35941955e-02f, -3.63947339e-02f,
  3.88540477e-02f, 4.74802814e-02f, -7.54323928e-03f, -2.45535970e-02f, 8.45977217e-02f, -1.75200552e-02f, 1.57998502e-02f, 1.00728929e-01f, 4.95647639e-02f, -1.00655414e-01f,
  -7.81103447e-02f, -6.95837736e-02f, -4.77908179e-02f, 4.28208187e-02f, -5.61228134e-02f, 4.14710082e-02f, -3.58856618e-02f, -3.87603529e-02f, -7.73355812e-02f, 1.63972024e-02f,
  -6.60415590e-02f, 1.55144685e-03f, -3.63426432e-02f, 3.30850817e-02f, -8.47727656e-02f, -3.14172134e-02f, -7.15251546e-03f, 1.04564298e-02f, -7.57113770e-02f, 6.28913417e-02f,
  -3.21937501e-02f, 1.83039550e-02f, 1.05801910e-01f, 1.59388706e-02f, 5.82150966e-02f, 4.70645390e-02f, -1.71236824e-02f, 1.23665035e-02f, 2.65045501e-02f, 2.01308541e-02f,
  -9.81369987e-03f, -5.62130027e-02f, -2.63601448e-02f, 4.39201035e-02f, 5.68711273e-02f, -2.24249940e-02f, -2.63584275e-02f, 3.65608484e-02f, -1.05137180e-03f, -4.18275632e-02f,
  1.12376474e-02f, -9.82645340e-03f, -3.94464172e-02f, 9.73253977e-03f, 1.09286457e-02f, 4.31274995e-02f, -2.19762102e-02f, 1.33661088e-02f, -7.05067366e-02f, 8.06412622e-02f,
  7.27783963e-02f, -1.57625705e-01f, -3.66775654e-02f, -1.12938257e-02f, -1.60023615e-01f, 4.87003401e-02f, 1.78336930e-02f, -6.68084435e-03f, 2.07400955e-02f, 1.79724302e-02f,
  -1.94681287e-01f, 2.82002062e-01f, 6.55667782e-02f, 4.39206697e-02f, -1.97353974e-01f, -4.01244104e-01f, -1.86603740e-01f, -5.82013205e-02f, 1.42434649e-02f, 1.20873317e-01f,
  -6.49932101e-02f, 9.79620889e-02f, 1.13416255e-01f, -1.44180253e-01f, -2.67618746e-01f, 8.23556259e-02f, -4.11912315e-02f, -2.47507617e-02f, -6.36827666e-03f, 8.35168064e-02f,
  -8.84483010e-02f, -2.10442424e-01f, -9.44247544e-02f, -4.25240248e-02f, 7.23662041e-03f, 2.23792419e-01f, 1.09923579e-01f, 4.86732423e-02f, 1.12904340e-01f, -2.06194799e-02f,
  -2.29008585e-01f, -2.17766892e-02f, 3.97382081e-02f, 6.88965544e-02f, 3.90625596e-02f, -1.23237865e-02f, 4.84514460e-02f, -2.99931467e-02f, -3.24696712e-02f, 6.08398914e-02f,
  5.90084270e-02f, -3.43209393e-02f, -4.60254811e-02f, -4.83573042e-02f, -7.73936287e-02f, -9.78968889e-02f, 1.74436793e-02f, 2.59276535e-02f, 1.26781510e-02f, -6.30765110e-02f,
  8.29463918e-03f, -2.87964270e-02f, -1.29993521e-02f, 8.02225992e-02f, 8.70313868e-02f, 3.11131179e-02f, 7.67278299e-03f, 4.48759506e-03f, 3.31897475e-02f, 1.82294473e-02f,
  1.04752537e-02f, 3.08440160e-03f, 3.25099491e-02f, -1.26383668e-02f, -3.20429951e-02f, -3.16803455e-02f, -1.29217263e-02f, 1.02731995e-02f, 1.61466710e-02f, -5.15671540e-03f,
  -7.53008411e-04f, -1.19089279e-02f, -8.67640506e-03f, -1.16903912e-02f, 6.67212578e-03f, -2.73517426e-02f, 4.47512604e-02f, -1.72628183e-02f, 2.42754705e-02f, -3.96401472e-02f,
  -1.17327534e-02f, -3.12512964e-02f, -1.34546161e-02f, -3.81152635e-03f, 2.97853705e-02f, -2.75815278e-03f, 1.06812138e-02f, 2.75559109e-02f, -1.64299365e-02f, 6.45234948e-03f,
  1.39684990e-01f, 3.26547921e-01f, -1.82906836e-02f, -2.84582861e-02f, -1.90790202e-02f, 1.29529461e-02f, -4.13326137e-02f, 1.07922796e-02f, 4.36782874e-02f, 3.12589342e-03f,
  -5.16790636e-02f, -5.38501795e-03f, 5.46796024e-02f, -1.68946013e-02f, 5.51284030e-02f, 5.92877604e-02f, 7.53110498e-02f, 5.73760048e-02f, -5.30868443e-03f, 6.58145919e-02f,
  3.45734879e-02f, 1.62765104e-02f, -1.25473235e-02f, -2.55998485e-02f, -9.57671739e-03f, -3.21077951e-03f, -1.57184936e-02f, -5.21450536e-03f, 4.45105992e-02f, 2.59391908e-02f,
  -6.88880503e-01f, -1.44727394e-01f, -2.95209408e-01f, -3.43649149e-01f, -1.12888612e-01f, -8.70421082e-02f, -1.65392980e-01f, -2.73592528e-02f, -4.17411387e-01f, 8.59166384e-02f,
  1.24425948e-01f, -2.63214618e-01f, 3.27515212e-04f, -6.15679324e-02f, -3.03068429e-01f, -1.10043637e-01f, -2.12400749e-01f, -2.04491597e-02f, -1.04117230e-01f, -4.36160676e-02f,
  -9.77431461e-02f, 1.11020245e-02f, -1.37689188e-01f, 1.24395072e-01f, -3.67346667e-02f, -9.70563591e-02f, 1.92284241e-01f, 7.53774866e-02f, 1.11789122e-01f, -2.46963520e-02f,
  8.76773447e-02f, -4.91781451e-04f, -1.13252671e-02f, 2.37860903e-02f, -1.23845367e-02f, 7.14292973e-02f, 9.57890823e-02f, 3.98126654e-02f, -3.50718088e-02f, -3.63246538e-02f,
  7.52932113e-03f, -1.77259147e-02f, 1.32974181e-02f, -1.94711909e-02f, -9.74031165e-03f, -3.91764455e-02f, -8.30989182e-02f, -4.93257791e-02f, -7.44287819e-02f, 9.88465361e-03f,
  -8.97678360e-02f, -4.01846021e-02f, 2.66649853e-02f, 2.79583074e-02f, -7.80065954e-02f, -3.92116681e-02f, -5.50170010e-03f, 4.26934380e-03f, -1.57558043e-02f, -1.32070975e-02f,
  5.82120242e-03f, -1.65996868e-02f, 8.77301861e-03f, 6.96408795e-03f, -4.65065353e-02f, 2.02931389e-02f, -6.79005543e-03f, 7.24254549e-02f, -6.77968413e-02f, 3.17420550e-02f,
  -3.35251540e-02f, -3.10897008e-02f, -3.76046225e-02f, -3.62385996e-02f, -1.31227786e-03f, -1.20105585e-02f, -2.81003881e-02f, -2.61617149e-03f, -3.21740210e-02f, -3.41353230e-02f,
  -1.49096847e-02f, 6.25008494e-02f, -1.61449797e-02f, 6.32877201e-02f, 6.26509963e-03f, -4.82860617e-02f, 1.49024613e-02f, -1.94455106e-02f, -1.62304975e-02f, -2.34655645e-02f,
  -3.07682250e-02f, 1.51844723e-02f, -4.97767935e-03f, -7.67055079e-02f, 3.91550474e-02f, 4.45587374e-03f, -6.36434704e-02f, -4.85971980e-02f, 3.06385551e-02f, 1.72480643e-02f,
  6.41299561e-02f, -6.70572091e-03f, 4.60884273e-02f, -4.34384756e-02f, -2.34404150e-02f, 3.14419940e-02f, 6.28148466e-02f, 1.54273314e-02f, 6.14515916e-02f, -1.30388774e-02f,
  6.30637780e-02f, 1.68746375e-02f, -1.05598774e-02f, 1.05153825e-02f, 9.17542577e-02f, 7.23982155e-02f, -3.51884868e-04f, -3.63287590e-02f, 2.95786485e-02f, 2.30548456e-02f,
  -2.83944488e-01f, -3.21733713e-01f, -2.24954206e-02f, -2.73131073e-01f, 6.85201287e-02f, -4.70945239e-03f, 1.31516486e-01f, -2.97988951e-01f, -1.56440333e-01f, -1.85692504e-01f,
  6.87329322e-02f, -2.65754104e-01f, 9.97350216e-02f, -1.04059614e-01f, 3.87028992e-01f, 1.76969722e-01f, 1.02223687e-01f, -1.73469394e-01f, -2.21577156e-02f, -1.17985576e-01f,
  -1.10802226e-01f, -1.47850700e-02f, 1.23661727e-01f, -2.14271024e-02f, -1.15811974e-01f, -2.03007773e-01f, 1.20818190e-01f, 3.94900925e-02f, 4.44584265e-02f, 1.08846888e-01f,
  4.67337929e-02f, -1.55047357e-01f, -2.78641633e-03f, -6.53918227e-03f, 3.39875434e-04f, 2.85196695e-02f, 9.46028978e-02f, 1.30318299e-01f, 1.02166040e-02f, 4.97209728e-02f,
  3.20361890e-02f, -7.14763626e-03f, -5.33586554e-02f, -2.90464181e-02f, -2.54432745e-02f, 2.14409679e-02f, 1.28288157e-02f, 6.99380552e-03f, -9.30479243e-02f, 5.74191436e-02f,
  2.66730972e-02f, -1.97083969e-02f, -3.02732792e-02f, 5.30890040e-02f, 3.40981372e-02f, 1.98134184e-02f, 3.69316377e-02f, 4.13005613e-02f, -4.95523098e-04f, -5.57871209e-03f,
  1.12338811e-01f, 3.34451869e-02f, 7.48463944e-02f, -1.53087480e-02f, 3.45526263e-02f, 3.17134708e-03f, 2.92763356e-02f, 2.83878464e-02f, 3.34014036e-02f, 9.42498446e-03f,
  -2.21710815e-03f, -1.13475546e-02f, -6.14926703e-02f, 2.16473714e-02f, -2.54313629e-02f, -5.40742390e-02f, 4.34635356e-02f, -2.70537417e-02f, 5.30011114e-03f, -1.56526491e-02f,
  2.05383431e-02f, 2.03891825e-02f, -1.03695169e-01f, 5.39090810e-03f, 2.66473796e-02f, 4.38762978e-02f, -3.21210385e-03f, 3.89743759e-03f, -1.90275032e-02f, 8.73437151e-02f,
  -1.58778355e-01f, -2.39826530e-01f, -4.98795696e-02f, -5.49218915e-02f, -5.33278771e-02f, 6.59279823e-02f, -5.19436412e-02f, -5.68048693e-02f, -8.04646593e-03f, 4.65316214e-02f,
  -2.70181568e-03f, -2.92987889e-03f, -5.84737305e-03f, 3.96395922e-02f, -6.20641687e-04f, -7.48004615e-02f, -9.92610306e-03f, 9.88156162e-03f, 3.24193873e-02f, -9.58522707e-02f,
  -2.79198922e-02f, 5.66066988e-02f, 8.62469077e-02f, -4.26037908e-02f, 1.05906710e-01f, -5.61196506e-02f, -1.29493102e-01f, -5.16998842e-02f, 1.03908174e-01f, 2.71885525e-02f,
  -4.25384074e-01f, 3.13947886e-01f, -7.79695809e-02f, 2.53167748e-01f, -3.06853235e-01f, -9.77182761e-03f, 1.25749692e-01f, -2.59209760e-02f, 1.25901297e-01f, 1.75330564e-01f,
  -1.05931200e-01f, -1.01165950e-01f, -1.16053578e-02f, 1.96218222e-01f, -1.81591451e-01f, 1.82515860e-01f, 1.24257661e-01f, 2.94384025e-02f, 7.66531974e-02f, -5.27540594e-02f,
  3.09153907e-02f, 6.53761625e-02f, -7.73028936e-03f, -5.55833355e-02f, -1.30352855e-01f, 5.04515544e-02f, 5.03196083e-02f, -1.15654647e-01f, -5.23298653e-03f, -9.42911208e-02f,
  -1.68325841e-01f, 9.35379043e-03f, -1.09619573e-01f, 5.21397740e-02f, -5.44701852e-02f, -7.47356042e-02f, -2.96293758e-02f, -3.44255678e-02f, -6.08641282e-02f, -1.37614633e-03f,
  -6.62950333e-03f, -5.58473766e-02f, 6.12106919e-03f, -8.61474499e-02f, 4.17724177e-02f, 1.07362391e-02f, -3.72000672e-02f, -5.95282540e-02f, 6.32063951e-03f, -2.64396844e-03f,
  -3.32680764e-03f, -9.31764196e-04f, 4.76979427e-02f, 4.75306675e-04f, -5.16874343e-02f, -1.14352293e-02f, -2.89788153e-02f, -1.05768420e-01f, -1.19686965e-02f, -4.10353579e-02f,
  -6.14710525e-02f, -7.69832656e-02f, -2.59200800e-02f, -7.79096484e-02f, 3.16068716e-02f, 1.00978967e-02f, 8.03001970e-03f, 9.64039471e-03f, -1.03419814e-02f, -1.96626107e-03f,
  -1.69790313e-02f, 1.64392423e-02f, -4.18994650e-02f, 2.35531311e-02f, -7.65783265e-02f, -1.07738525e-02f, -7.96901956e-02f, -1.24208594e-03f, -3.51655670e-03f, -1.14659341e-02f,
  4.47616633e-03f, 2.03032829e-02f, 6.89434214e-03f, 4.31300104e-02f, 5.29242717e-02f, 1.27279861e-02f, 6.92467019e-02f, -4.78706546e-02f, -2.14809235e-02f, -7.23495707e-02f,
  1.04845762e-01f, 1.47820443e-01f, 4.33942750e-02f, -9.07964036e-02f, 1.56618461e-01f, 1.37595600e-02f, 3.43134031e-02f, 5.44448616e-03f, 3.60009968e-02f, -2.14448059e-03f,
  3.50912809e-02f, -1.91225875e-02f, -4.36469261e-03f, -5.19867812e-04f, -1.35483658e-02f, 4.53494638e-02f, 3.15271243e-02f, 6.98382333e-02f, 3.11516486e-02f, 2.83491742e-02f,
  1.09298648e-02f, -9.31231454e-02f, 2.48311582e-04f, -7.46588483e-02f, 1.44428434e-02f, 1.41792949e-02f, -1.03660477e-02f, 6.15872853e-02f, 1.43801635e-02f, 6.45806938e-02f,
  2.44211957e-01f, 2.15251625e-01f, 2.55659550e-01f, 3.79089601e-02f, -2.47023761e-01f, 5.08387029e-01f, 4.96535748e-01f, -1.23981491e-01f, 1.93601400e-01f, 5.91223165e-02f,
  -2.49536753e-01f, 3.88398200e-01f, -4.27806750e-02f, 2.13528285e-03f, 1.37483270e-03f, 1.36143878e-01f, -1.06196441e-01f, 1.26572132e-01f, 1.08708255e-02f, -1.24016739e-01f,
  5.32365441e-02f, -2.48954743e-01f, -1.21583313e-01f, -1.16382256e-01f, -7.01724514e-02f, -1.00036841e-02f, -4.10135478e-01f, 1.01047464e-01f, -5.82185797e-02f, 3.82109806e-02f,
  -2.72928514e-02f, -1.07171953e-01f, 3.34290266e-02f, -6.12481323e-04f, -9.27512273e-02f, 1.44853145e-01f, 1.19503001e-02f, 9.86088663e-02f, 3.37333828e-02f, 1.54007436e-03f,
  4.66770716e-02f, 4.17427206e-03f, -3.54107283e-02f, 5.35690077e-02f, 6.23918548e-02f, 2.25694361e-03f, -5.48064709e-02f, -7.05217570e-02f, 5.41018583e-02f, -2.27884408e-02f,
  4.57648635e-02f, 1.16523448e-02f, -1.77619196e-02f, 8.87872558e-03f, -4.77088019e-02f, 6.86988607e-02f, 4.88764979e-02f, 2.69652177e-02f, 5.49817421e-02f, 5.25197648e-02f,
  -3.44874859e-02f, -1.18687768e-02f, -4.86399373e-03f, -5.22808246e-02f, -6.63027316e-02f, -4.38122302e-02f, -2.74695037e-03f, 1.16835972e-02f, 8.05158913e-02f, -3.81305963e-02f,
  -4.73127104e-02f, 8.56385846e-03f, 1.36976354e-02f, 5.56606846e-03f, 5.78704961e-02f, -1.65316928e-02f, -2.45711841e-02f, 5.93052283e-02f, 2.79220492e-02f, 1.48708215e-02f,
  -1.87001545e-02f, 2.54837330e-02f, -4.97083291e-02f, 1.47595839e-03f, -5.04656620e-02f, -1.40333613e-02f, 1.66176595e-02f, -6.91010896e-03f, -6.60129823e-03f, 1.06306782e-03f,
  -3.23980697e-03f, 4.12883908e-02f, -2.14670915e-02f, 4.81746159e-02f, 8.17879811e-02f, -8.29140767e-02f, 8.75435546e-02f, -6.38098866e-02f, 8.07816386e-02f, 6.36031944e-03f,
  -1.76761802e-02f, -3.05117108e-02f, 3.74840572e-02f, -6.89181760e-02f, -9.05463174e-02f, -4.42594588e-02f, 5.18902801e-02f, 1.27196992e-02f, 5.21161184e-02f, -5.13613112e-02f,
  -1.18249811e-01f, 1.51275322e-02f, 4.87462580e-02f, -1.03669375e-01f, -1.69936586e-02f, -1.56777930e-02f, 5.46478443e-02f, 1.75958555e-02f, -5.37231341e-02f, 2.35506743e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.96574521e-01f, 5.68432987e-01f, -3.60759676e-01f, 1.92147896e-01f, -3.83868814e-01f, 6.11555040e-01f, 8.47716630e-01f, -1.18840992e-01f, 5.98447882e-02f, 6.85499310e-01f,
  3.23459446e-01f, 1.34031266e-01f, 4.62475687e-01f, 6.14498377e-01f, 1.32679224e-01f, 7.01160967e-01f, 3.88961136e-01f, 3.91208470e-01f, -7.72563890e-02f, -1.89513676e-02f,
  -1.60968333e-01f, 4.03186470e-01f, 3.75561975e-02f, -1.57946325e-03f, 4.07305695e-02f, -1.93604514e-01f, -1.18856430e-01f, 4.63354327e-02f, 6.89013228e-02f, 1.14378326e-01f,
  3.03367287e-01f, 2.06046477e-02f, -1.44967616e-01f, 9.78018641e-02f, -2.11894084e-02f, -8.61736163e-02f, -5.90954646e-02f, -1.33332282e-01f, -2.20757589e-01f, 5.56166694e-02f,
  -1.07908074e-03f, -4.92017381e-02f, 3.56947556e-02f, -3.89821231e-02f, -5.93524426e-02f, -2.18218848e-01f, -1.00310303e-01f, -9.14901681e-03f, 8.07200894e-02f, 6.85624033e-02f,
  -2.83798091e-02f, -7.75645580e-03f, -1.14241607e-01f, 8.10330957e-02f, -4.79704104e-02f, 1.30570814e-01f, 2.92171359e-01f, -1.10092992e-02f, 6.79415762e-02f, -3.56892347e-02f,
  1.46125667e-02f, 5.30491918e-02f, 1.21851802e-01f, 8.00762847e-02f, -6.20419681e-02f, 7.76383094e-04f, 6.04765043e-02f, -5.93688041e-02f, -4.71618995e-02f, 7.29101002e-02f,
  -4.14007306e-02f, -9.64433998e-02f, 7.78991878e-02f, -2.39524525e-02f, 1.21381871e-01f, 1.62700295e-01f, -2.50218678e-02f, 1.25266999e-01f, 7.87038282e-02f, 1.32492473e-02f,
  5.93927652e-02f, -1.44999679e-02f, 8.30963850e-02f, -9.58982483e-03f, 5.75105511e-02f, -1.15065835e-01f, 9.37531963e-02f, 4.54790518e-02f, 2.93786987e-03f, 3.83652821e-02f,
  2.65983641e-01f, 2.31757000e-01f, 6.37143850e-02f, 1.19625062e-01f, 3.06468457e-02f, -7.51296012e-03f, 2.55522113e-02f, -9.01021808e-03f, 1.04764082e-01f, 4.38938774e-02f,
  -1.79540411e-01f, 1.03324696e-01f, -6.60483609e-04f, 2.85370126e-02f, -1.80058591e-02f, 1.23108812e-01f, 1.32237777e-01f, -4.78455622e-04f, -7.20916018e-02f, -9.65021476e-02f,
  -3.81231904e-02f, 1.15061104e-01f, -4.15029749e-02f, -9.23601352e-03f, -1.06863104e-01f, 8.76683369e-02f, -1.00584298e-01f, -1.37309909e-01f, -1.86436683e-01f, 1.99935250e-02f,
  -5.19298136e-01f, -1.09523490e-01f, -2.53876239e-01f, -8.84889886e-02f, -3.91920477e-01f, -5.41633606e-01f, -4.02052492e-01f, -1.94506556e-01f, 2.01915726e-01f, 4.01382148e-01f,
  -1.71953648e-01f, -1.76968351e-02f, 4.87802476e-01f, -3.91010135e-01f, 2.97647595e-01f, 7.23679304e-01f, -3.25227976e-01f, 1.73637286e-01f, 9.98594686e-02f, -4.57901865e-01f,
  -1.87475801e-01f, -1.83048576e-01f, 2.72102445e-01f, -2.04786181e-01f, -6.03250623e-01f, -2.37846211e-01f, 5.76206446e-02f, -2.33414218e-01f, -5.11365592e-01f, -7.08020926e-02f,
  -1.69193804e-01f, 7.82684386e-02f, -3.01147282e-01f, 6.84298500e-02f, -2.85776436e-01f, -1.08427361e-01f, -3.13924402e-01f, -7.49470890e-02f, 1.26274690e-01f, -1.29349053e-01f,
  3.46187726e-02f, -5.25661446e-02f, -8.26313123e-02f, 2.69625127e-01f, 3.11038531e-02f, -2.41870377e-02f, -7.41268024e-02f, -1.75141811e-01f, -1.41023234e-01f, 3.12788039e-02f,
  -1.34905368e-01f, -1.94367617e-02f, -1.80107653e-01f, 1.51400104e-01f, -2.14356631e-01f, -9.28036347e-02f, 2.02989444e-01f, -8.35532695e-02f, -1.94739252e-02f, -1.37467414e-01f,
  -7.12370574e-02f, -1.28005939e-02f, 3.45411934e-02f, 5.06507307e-02f, 1.12355817e-02f, 1.87177528e-02f, -6.89343289e-02f, -6.05590120e-02f, 4.64547537e-02f, -1.51737034e-01f,
  -1.51583001e-01f, 1.41247204e-02f, -5.00038303e-02f, -2.22531091e-02f, -1.92840584e-02f, 5.52346818e-02f, 4.27304991e-02f, -8.15428235e-03f, 1.58155186e-03f, -6.48201257e-02f,
  1.05700463e-01f, -4.01075510e-03f, 2.35708445e-01f, -3.63798365e-02f, -2.85648793e-01f, -1.39149372e-02f, -2.02449515e-01f, -1.70482770e-02f, -9.65171382e-02f, -1.58805281e-01f,
  -1.03291616e-01f, 2.54889317e-02f, 9.13850516e-02f, 1.89085491e-02f, 4.34054323e-02f, -1.21938691e-01f, 1.73840925e-01f, -1.52603192e-02f, -9.55486447e-02f, -1.14028744e-01f,
  -4.98021469e-02f, 1.20767713e-01f, -1.10146843e-01f, -3.34747275e-03f, 4.81825359e-02f, -8.09145197e-02f, -8.38482529e-02f, 9.21854377e-03f, -7.99862072e-02f, -8.62250179e-02f,
  -6.40358999e-02f, 8.28557834e-02f, 3.02018374e-01f, 5.16682789e-02f, 6.96041957e-02f, 1.18776225e-02f, -1.85196370e-01f, -2.27814391e-02f, -1.88991740e-01f, 1.53297819e-02f,
  -1.79126692e+00f, 2.55757928e-01f, 2.79989596e-02f, -7.34087229e-01f, 1.40436823e-02f, -3.50710362e-01f, -3.39974463e-01f, -7.09755495e-02f, -1.03402622e-01f, 1.87025785e-01f,
  -1.01571344e-01f, -1.25264376e-01f, 3.11365336e-01f, -2.68284053e-01f, -4.80042368e-01f, 1.96329057e-01f, -4.78964835e-01f, -3.74768704e-01f, 1.86884731e-01f, -4.67314422e-01f,
  -2.09796265e-01f, -6.67587221e-02f, -9.18354541e-02f, 4.18622494e-01f, -2.01947570e-01f, -7.43408352e-02f, -1.21979654e-01f, 2.24957064e-01f, -1.95129722e-01f, 8.23188499e-02f,
  3.93733894e-03f, 2.13664919e-01f, 6.11490160e-02f, 1.07609980e-01f, -2.95341853e-02f, -1.66279897e-01f, -2.04826087e-01f, 1.10818848e-01f, -5.54258712e-02f, -6.95125461e-02f,
  -9.75262523e-02f, 1.31535336e-01f, -9.19987261e-02f, 1.14851236e-01f, 7.67198252e-03f, 1.13834374e-01f, 1.65887311e-01f, -9.69298258e-02f, 1.73822775e-01f, 1.54713634e-02f,
  8.92917290e-02f, 2.00441666e-02f, -1.65047064e-01f, -6.02389202e-02f, 4.40926626e-02f, 1.36640891e-01f, -1.55822551e-02f, 1.20254615e-02f, -8.55967104e-02f, -2.97646616e-02f,
  -3.72553691e-02f, 1.01158534e-04f, -1.21630793e-02f, 1.00266621e-01f, -2.75512598e-02f, 6.87086508e-02f, 8.53119716e-02f, -2.23828405e-02f, -2.66820285e-02f, 2.27801427e-02f,
  -1.46414503e-01f, -6.62505701e-02f, 1.44910991e-01f, 1.34759732e-02f, -1.67695850e-01f, 5.20500205e-02f, -2.71729305e-02f, 4.17981148e-02f, -1.32482186e-01f, -2.09665447e-02f,
  2.57463753e-02f, -1.26008898e-01f, 3.08908019e-02f, -1.16962619e-01f, 1.07504480e-01f, 3.15178148e-02f, 1.09564990e-01f, 3.34357172e-02f, -2.57840510e-02f, -1.54184163e-01f,
  -4.89169717e-01f, -4.34023231e-01f, 3.24105583e-02f, 1.19518161e-01f, 2.87296027e-02f, -2.20524948e-02f, -2.94348644e-03f, -9.25928056e-02f, -7.14848042e-02f, -1.01159117e-03f,
  -1.15932420e-01f, -9.23690945e-02f, -2.04659969e-01f, 2.64652930e-02f, -7.08064809e-02f, -1.49576560e-01f, -1.42966777e-01f, -6.12509921e-02f, -1.57998681e-01f, -8.38444978e-02f,
  -5.53763844e-02f, 3.63402627e-02f, -2.71357112e-02f, -7.70102143e-02f, -1.27433941e-01f, -1.03873171e-01f, -1.42748341e-01f, 1.48939425e-02f, -5.68210110e-02f, -4.83123101e-02f,
  -1.54490635e-01f, -1.39059767e-01f, -4.23320562e-01f, 4.71195906e-01f, -1.10144019e-01f, 4.33437638e-02f, -4.92838770e-01f, 6.63397536e-02f, -3.62066120e-01f, 1.02101937e-01f,
  1.06518589e-01f, -4.34127480e-01f, -3.12726766e-01f, 4.29885089e-01f, 3.63422692e-01f, -1.36394233e-01f, 3.01542699e-01f, 4.50474434e-02f, -2.37363771e-01f, -6.29087836e-02f,
  2.51758724e-01f, 5.35714567e-01f, -6.61863312e-02f, 5.64597011e-01f, 2.29912531e-02f, 2.57666439e-01f, 7.52496600e-01f, -8.83875936e-02f, 7.09336162e-01f, 1.09808050e-01f,
  -1.63758546e-01f, -1.57345340e-01f, -6.13293275e-02f, -1.79024506e-02f, 1.34404255e-02f, 5.52198896e-03f, 6.29594922e-02f, -4.05036844e-02f, -8.67573470e-02f, -2.59117801e-02f,
  -4.49449681e-02f, -3.48119400e-02f, 5.45454882e-02f, -1.75042357e-02f, 8.47688317e-02f, -3.75316925e-02f, -3.73026021e-02f, -2.84204781e-01f, -1.11723408e-01f, -4.72331159e-02f,
  -2.06055865e-01f, -1.43613786e-01f, 1.77765209e-02f, 6.55665994e-02f, 2.26385165e-02f, -5.58454834e-04f, -4.61397180e-03f, -5.07405810e-02f, -1.59199964e-02f, 9.77238193e-02f,
  -7.97656365e-03f, -3.39697376e-02f, -1.43092657e-02f, 4.40502679e-03f, -8.73769745e-02f, 3.72142196e-02f, 2.06729397e-02f, 3.12368828e-03f, 4.40201312e-02f, 1.63747799e-02f,
  -2.32076086e-02f, 4.67828996e-02f, -8.60487577e-03f, -4.80255075e-02f, -6.49366155e-03f, -6.50035217e-02f, 7.12701827e-02f, -3.61389853e-03f, -3.10144052e-02f, -5.06292358e-02f,
  -1.30653000e-02f, 4.34070081e-02f, -2.54269075e-02f, 5.12045585e-02f, 8.50117132e-02f, -2.91651897e-02f, 8.62663090e-02f, -7.03420630e-03f, -2.27702692e-01f, -2.19655056e-02f,
  1.11805640e-01f, 5.30217171e-01f, -9.07346979e-02f, -2.30228342e-02f, 3.25857848e-02f, 4.71785553e-02f, -9.04167723e-03f, 4.70991321e-02f, 1.59751356e-01f, -2.14654803e-02f,
  7.78499767e-02f, 1.07098058e-01f, 6.78823739e-02f, 1.05121657e-01f, 1.36533707e-01f, 1.39300087e-02f, 7.17729926e-02f, 1.95819810e-01f, 1.99519500e-01f, 1.07033901e-01f,
  1.05297901e-01f, -2.42310558e-02f, 3.37212533e-02f, -3.09249070e-02f, 1.30693629e-01f, -1.19917495e-02f, 4.78665419e-02f, -4.90863658e-02f, 1.89256355e-01f, 3.36758383e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.37545124e-01f, 3.43109280e-01f, 5.65563858e-01f, 2.60315567e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.36572570e-01f, -5.13174273e-02f, 2.97811776e-01f, -2.25310907e-01f, -6.30771816e-01f, 1.57393530e-01f, 2.98481017e-01f, -3.87248576e-01f, 5.10920227e-01f, 4.54016447e-01f,
  -2.42098570e-01f, -6.27007782e-01f, 1.13787897e-01f, 2.43215442e-01f, -2.83585727e-01f, 2.46427953e-01f, -1.33955866e-01f, -4.16218311e-01f, -6.62460864e-01f, -2.39072721e-02f,
  9.26188171e-01f, -9.60944779e-03f, -2.19389156e-01f, 8.90618622e-01f, -5.21974206e-01f, -6.16183758e-01f, -4.44539547e-01f, 2.44777486e-01f, -3.61288607e-01f, 1.29185483e-01f,
  -5.18105254e-02f, -2.51170937e-02f, -1.11283794e-01f, 4.21652049e-02f, -1.35939807e-01f, -5.03526807e-01f, 4.49263364e-01f, -1.86257362e-01f, -6.90725520e-02f, 7.91951776e-01f,
  4.39443082e-01f, -2.73610026e-01f, 3.25967520e-02f, -7.90097378e-03f, -2.86195010e-01f, -6.64021149e-02f, 4.22202975e-01f, -3.41549486e-01f, -4.30617154e-01f, -3.39560091e-01f,
  5.05750179e-01f, -2.65244722e-01f, -1.05257057e-01f, -3.35861683e-01f, 3.42817396e-01f, 1.99788466e-01f, -8.82500529e-01f, 6.38985485e-02f, -1.66947275e-01f, 6.94530129e-01f,
  -1.23227328e-01f, 1.81341454e-01f, -5.57179272e-01f, 2.66577959e-01f, -2.41295815e-01f, 2.85924762e-01f, -6.89529181e-01f, -2.63420548e-02f, -3.00628364e-01f, -5.66165932e-02f,
  -2.61496067e-01f, 7.52639711e-01f, 7.39048660e-01f, 3.64492126e-02f, 3.21379125e-01f, -3.56479853e-01f, 1.61021546e-01f, 2.65875936e-01f, 4.29131091e-02f, -1.94000378e-01f,
  -4.90579933e-01f, -1.31990090e-01f, 5.90085506e-01f, -5.91922402e-01f, 1.81505114e-01f, -5.16516685e-01f, 7.91133419e-02f, 7.89278924e-01f, -4.28332865e-01f, -6.30565882e-01f,
  7.40724802e-02f, 5.60175953e-03f, -2.75945395e-01f, 1.12887688e-01f, 1.32617848e-02f, 5.56927780e-03f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.69186401e-01f, 5.46790600e-01f, 1.30585361e+00f, -1.12514293e+00f, 8.66514802e-01f, 2.74136007e-01f, 1.20638359e+00f, -6.58033669e-01f, -2.98525214e-01f, 1.26742840e+00f,
  -1.09464252e+00f, 5.85411251e-01f, -5.51589787e-01f, 7.63567269e-01f, 1.20773208e+00f, -9.09592271e-01f, -2.49584943e-01f, -2.38630071e-01f, -5.72113097e-01f, 2.61001617e-01f,
  5.41369081e-01f, 3.88611883e-01f, 1.10322297e-01f, 1.02038050e+00f, 6.30842149e-01f, -5.33328831e-01f, -5.48331797e-01f, -1.19510925e+00f, -1.25139320e+00f, 6.14450812e-01f,
  7.30625272e-01f, 1.34699786e+00f, 8.26738060e-01f, 1.49184763e-01f, -5.23867190e-01f, 1.35665703e+00f, 9.42145467e-01f, 1.28939545e+00f, -1.43048286e+00f, -1.53922093e+00f,
  7.71302104e-01f, -7.92192280e-01f, -7.23922074e-01f, -1.03683126e+00f, -3.99259478e-02f, -1.01531172e+00f, 9.64334011e-01f, 5.10123789e-01f, 4.90604430e-01f, 1.18000269e+00f,
  6.74577475e-01f, 9.06062186e-01f, -6.87710822e-01f, 2.32766300e-01f, -8.47690463e-01f, 2.18148708e-01f, 8.91234398e-01f, 2.29233310e-01f, 1.33711708e+00f, 1.33931369e-01f,
  1.11619091e+00f, 1.20932376e+00f, 1.18741131e+00f, 1.67659055e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.14595389e+00f, 5.40366054e-01f, 4.26934838e-01f, 5.02676368e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -5.95730543e-01f, -1.01423132e+00f, -1.60269633e-01f, -1.40643394e+00f, -3.83442402e-01f, -1.34596992e+00f, 1.04507339e+00f, 7.88407981e-01f, -6.68572545e-01f, -4.94736403e-01f,
  1.10740852e+00f, -3.88953686e-01f, -6.56820238e-01f, -8.98595989e-01f, -8.12389910e-01f, 9.39954340e-01f, 7.03312516e-01f, -1.24218404e+00f, -9.00527835e-01f, 9.15932596e-01f,
  5.89438558e-01f, 2.69540697e-02f, 1.45617867e+00f, -1.24762821e+00f, -1.14546321e-01f, -9.98847544e-01f, -1.10791588e+00f, -5.14124095e-01f, -1.62256777e+00f, -7.21147418e-01f,
  9.53490734e-01f, 2.20191091e-01f, -9.81478453e-01f, -2.51245379e-01f, -1.23970687e+00f, 3.78474027e-01f, -1.49857664e+00f, 2.08560452e-01f, 6.38496399e-01f, -1.39775097e+00f,
  4.34283942e-01f, 1.00284064e+00f, -1.00922793e-01f, -1.02528548e+00f, -6.67203903e-01f, 8.39964986e-01f, 5.47846854e-01f, -1.44635630e+00f, -9.47072148e-01f, 1.53772175e-01f,
  -1.08540940e+00f, -8.85653496e-02f, -1.06087995e+00f, 3.21104489e-02f, -5.73946595e-01f, 2.03538314e-01f, -3.92231733e-01f, 8.45346928e-01f, 8.66201162e-01f, 9.58596647e-01f,
  -1.59013465e-01f, 1.49283901e-01f, 9.56423283e-02f, 2.58840472e-01f, -3.41623694e-01f, -7.41188526e-02f, 6.86434209e-01f, -1.77816463e+00f, 1.03802502e+00f, 1.04153410e-01f,
  -5.40189743e-01f, -1.66864824e+00f, 1.42209291e+00f, -1.16742337e+00f, -3.24648082e-01f, -4.73681211e-01f, 6.96817458e-01f, -9.10693765e-01f, -6.15388751e-02f, 1.64924458e-01f,
  4.75611210e-01f, 1.29219949e+00f, 4.88769859e-01f, 1.24294841e+00f, 8.94904494e-01f, 1.46239758e+00f, -1.44768023e+00f, -9.63964581e-01f, -1.37329841e+00f, 1.06374907e+00f,
  -4.58904169e-02f, -6.07130766e-01f, -9.97677743e-01f, -1.57017481e+00f, -1.13904142e+00f, 7.99116373e-01f, 5.12445308e-02f, 7.32334077e-01f, 1.78077936e-01f, 6.91374362e-01f,
  -5.16901731e-01f, -6.00300968e-01f, -1.19220388e+00f, 1.32808745e+00f, -1.15507615e+00f, -9.72637832e-01f, -9.66893017e-01f, -1.06078398e+00f, 5.28463908e-02f, -7.58829415e-01f,
  1.10253942e+00f, -1.77512181e+00f, 8.38512629e-02f, -9.95059088e-02f, 4.44964319e-02f, 3.22267681e-01f, -4.09080684e-01f, -5.88163510e-02f, 1.60704136e+00f, 3.10312808e-01f,
  5.73370099e-01f, -5.24377406e-01f, 1.09807813e+00f, 1.01955795e+00f, 5.92975736e-01f, 2.15595290e-01f, -1.99652791e+00f, 1.14351481e-01f, 3.93992335e-01f, 5.78054488e-01f,
  -8.62461627e-02f, -5.36246657e-01f, 4.49489772e-01f, -2.87570208e-01f, 1.06625700e+00f, 1.09529984e+00f, -1.11225915e+00f, 9.51137364e-01f, -1.02658486e+00f, 1.30052745e+00f,
  -1.28208768e+00f, 1.21440601e+00f, -6.99379623e-01f, -6.74473405e-01f, 4.00362670e-01f, 5.22739530e-01f, -1.00238562e-01f, -1.18648112e-01f, -6.75252080e-01f, 4.68201488e-01f,
  1.11047685e+00f, -1.24705172e+00f, -9.43047941e-01f, 1.09453773e+00f, -6.11708879e-01f, -7.05964744e-01f, 1.42763662e+00f, -1.15710604e+00f, -1.63654053e+00f, -8.70390058e-01f,
  6.50408268e-01f, 2.63383567e-01f, 4.46694463e-01f, -1.42319083e+00f, 3.34906608e-01f, 3.57352383e-03f, -7.44728446e-01f, 1.05487716e+00f, 1.37395334e+00f, -7.55781174e-01f,
  1.51809180e+00f, -7.80301273e-01f, -1.47849095e+00f, 5.59284031e-01f, 8.25883031e-01f, -5.11758566e-01f, -6.40855551e-01f, -6.89422846e-01f, 6.80501938e-01f, 7.87683487e-01f,
  7.38673449e-01f, 1.04214296e-01f, -1.41607285e+00f, 1.39111304e+00f, 1.89234996e+00f, 7.96649992e-01f, -1.24248362e+00f, 1.88826609e+00f, 8.53273273e-01f, -2.98987955e-01f,
  -9.64795470e-01f, -8.84010077e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.84512493e-02f, -1.60400525e-01f, -5.14440477e-01f, -5.55108190e-01f, -3.97624344e-01f, 5.06898582e-01f, 5.90429604e-02f, -8.05439204e-02f, 2.32560009e-01f, 1.59926519e-01f,
  -3.40890378e-01f, 8.62664163e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    