/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.68954337e-01f, -4.29406554e-01f, -2.31535789e-02f, -3.59287202e-01f, 1.81104019e-01f, 1.98587611e-01f, 4.89850305e-02f, -9.67370868e-02f, -2.66498566e-01f, -1.54433146e-01f,
  8.21096003e-02f, -9.01694968e-02f, -1.53241470e-01f, -1.37375996e-01f, 1.62886336e-01f, -8.81664380e-02f, -2.11982891e-01f, -2.82549337e-02f, -8.34889412e-02f, -1.01912327e-01f,
  -5.71753941e-02f, -7.62260258e-02f, -2.60104947e-02f, -8.19279719e-03f, 1.05080493e-01f, -4.61710542e-02f, 5.84448241e-02f, 6.58527091e-02f, 9.58405733e-02f, 1.64927930e-01f,
  3.13717755e-03f, -4.97891828e-02f, -9.00905058e-02f, 9.26863775e-03f, 1.38975633e-02f, 7.22567504e-03f, 2.36126669e-02f, 1.77824363e-01f, 5.20774955e-03f, 8.24961141e-02f,
  8.53851158e-03f, -3.73260491e-02f, -8.74018949e-03f, 1.08086713e-01f, -4.14385907e-02f, -2.76207533e-02f, 5.56349047e-02f, -2.69546099e-02f, 6.25988096e-03f, 9.67427716e-02f,
  -5.44051677e-02f, 1.15131862e-01f, -2.51392256e-02f, 1.50696173e-01f, 4.59751785e-02f, 5.05462196e-03f, 5.71785681e-02f, 7.55105317e-02f, -1.46362651e-02f, 2.56296787e-02f,
  7.14243352e-02f, -7.03685032e-03f, 1.62189000e-03f, 3.57017703e-02f, -1.12689976e-02f, 5.88482805e-02f, -8.59290734e-02f, 3.79802324e-02f, 2.36628251e-03f, 4.34588157e-02f,
  -9.59755257e-02f, 2.56107636e-02f, 1.69509295e-02f, -6.71001971e-02f, -2.80671716e-02f, -1.98580120e-02f, -9.76318792e-02f, 1.08570203e-01f, 1.25396892e-03f, 3.54651213e-02f,
  -6.01960719e-02f, -5.39526306e-02f, -5.65942749e-03f, 7.81509206e-02f, -5.08148447e-02f, -5.20766340e-02f, -1.15098692e-01f, -5.04361503e-02f, -2.68048532e-02f, 5.57885971e-03f,
  -3.35474372e-01f, -2.34001964e-01f, -6.88482001e-02f, 2.90632676e-02f, -8.78061131e-02f, 1.95281301e-02f, -1.20765846e-02f, 1.86553746e-02f, -1.11063130e-01f, 1.14627918e-02f,
  3.39575671e-02f, -2.74746940e-02f, -1.56047316e-02f, -3.31896991e-02f, -7.37887099e-02f, -2.83336849e-03f, -1.38721228e-01f, -8.48576501e-02f, -9.27935466e-02f, 3.82990018e-02f,
  -5.54416068e-02f, -2.76722517e-02f, 8.83880816e-03f, 5.60629591e-02f, 2.11006869e-02f, 7.47076645e-02f, 8.73873383e-02f, 5.16882464e-02f, 7.71576613e-02f, -7.00222999e-02f,
  1.95373952e-01f, -2.70668924e-01f, -1.96980804e-01f, 1.25046536e-01f, 1.90361410e-01f, 3.35593671e-01f, -2.47439416e-03f, 3.16006392e-02f, -1.23601362e-01f, -8.66042003e-02f,
  3.45146120e-01f, -3.19552124e-01f, -1.64883837e-01f, -3.32493968e-02f, 2.17399776e-01f, -2.16538340e-01f, 1.30307868e-01f, 2.27827579e-01f, -1.53732598e-01f, 1.48549378e-01f,
  1.17977165e-01f, 1.27920359e-01f, -9.08711925e-02f, 8.49336572e-03f, 7.63742551e-02f, -1.15932040e-02f, 1.00459747e-01f, -1.40424818e-01f, 1.31929606e-01f, -9.51860994e-02f,
  -7.03165531e-02f, -1.31735951e-01f, -4.56213579e-02f, -2.12780237e-02f, 1.30003601e-01f, 1.56084850e-01f, -1.43043278e-03f, -4.55986336e-02f, 3.14280130e-02f, -1.21851461e-02f,
  -2.99598910e-02f, 3.38726453e-02f, -4.46463004e-02f, -9.80606489e-03f, 1.51252538e-01f, -1.53787946e-02f, -2.64402926e-02f, -1.51411276e-02f, -1.67380422e-01f, 3.08183003e-02f,
  -7.52377659e-02f, 7.52947852e-02f, 1.34474672e-02f, -4.75121960e-02f, 8.58702417e-03f, -3.42846364e-02f, -8.36031605e-03f, -2.18180865e-02f, 3.12565640e-02f, -3.00897770e-02f,
  -2.74258424e-02f, 5.36097363e-02f, 1.43538164e-02f, 6.07118830e-02f, 1.27309680e-01f, -1.39832161e-02f, -8.89725750e-04f, -2.85292622e-02f, -2.19952390e-02f, 1.04900956e-01f,
  -5.20295613e-02f, 8.65879282e-02f, 5.49247414e-02f, 3.09185330e-02f, 1.42184660e-01f, -1.47188129e-02f, 2.03267187e-02f, -1.26212335e-03f, -8.37549684e-04f, 4.92083877e-02f,
  -3.14563476e-02f, 5.61431274e-02f, 6.05828725e-02f, -4.51886840e-02f, 7.50302598e-02f, 1.60008483e-02f, -9.22876061e-04f, 4.16904176e-03f, -2.54307222e-02f, 1.69587731e-02f,
  -3.23679633e-02f, -1.40487373e-01f, -5.15775122e-02f, -3.62509824e-02f, -3.80435660e-02f, 1.01413041e-01f, -3.99259999e-02f, -3.42231710e-04f, 2.72809248e-02f, -5.81693500e-02f,
  1.00184798e-01f, 7.06713572e-02f, 8.25035498e-02f, 4.05626604e-03f, 8.91260281e-02f, 5.72966076e-02f, -1.72131211e-02f, -4.49416339e-02f, 3.45040602e-03f, 7.93859884e-02f,
  -2.83863842e-02f, -4.81247231e-02f, 1.00543257e-02f, -1.12642907e-01f, 2.01397724e-02f, 9.62264612e-02f, 4.93681878e-02f, 4.86922450e-03f, -5.32346703e-02f, -8.51210654e-02f,
  2.47458756e-01f, 3.00653309e-01f, 8.04421082e-02f, 2.69677311e-01f, 1.42747864e-01f, -1.26299560e-01f, 3.94865684e-02f, 2.32441038e-01f, 5.36834598e-01f, 6.85038194e-02f,
  2.12027207e-02f, -3.41196656e-02f, 7.64186727e-03f, 1.12560391e-01f, -4.69316125e-01f, -1.42638072e-01f, -1.28647640e-01f, -1.24225363e-01f, 7.12875556e-03f, 1.17419057e-01f,
  7.03406036e-02f, -8.09564888e-02f, -2.90738344e-01f, -4.75304388e-02f, 6.25818893e-02f, 1.60678193e-01f, -1.14876270e-01f, 1.88075751e-02f, -1.95075020e-01f, -1.06376953e-01f,
  -8.32496583e-02f, 1.27744451e-01f, -1.65100396e-02f, -7.86785334e-02f, -6.72996342e-02f, -4.81322519e-02f, -9.46946517e-02f, -1.03379712e-02f, 2.18769088e-02f, -3.81423272e-02f,
  2.26294249e-02f, 8.22840706e-02f, 3.71069200e-02f, -3.75910960e-02f, 1.11772060e-01f, 1.08833700e-01f, -2.42886022e-02f, 1.52764050e-02f, 6.55458681e-03f, 3.73318209e-03f,
  -4.65976307e-03f, 1.92081071e-02f, 9.23438836e-03f, 7.49588478e-03f, 3.06456182e-02f, 1.15902685e-01f, -9.38339997e-03f, 5.56764018e-04f, -7.52229709e-03f, 1.47615120e-01f,
  5.02377339e-02f, 1.13290772e-02f, -3.13867442e-02f, 7.00067580e-02f, -4.37987186e-02f, 1.34611428e-02f, -8.45565423e-02f, -1.22587569e-01f, -7.66109228e-02f, 3.13326083e-02f,
  5.68112284e-02f, 4.79346402e-02f, 1.10331275e-01f, 1.37620624e-02f, 6.70624152e-02f, 7.14173540e-02f, -1.96436350e-03f, 4.96899039e-02f, 7.11368695e-02f, 1.21134361e-02f,
  -3.78344283e-02f, 2.01809034e-02f, -2.06200918e-03f, 7.66071677e-02f, -8.38856250e-02f, 2.28793267e-03f, 6.72873333e-02f, 7.49659166e-02f, -6.35290146e-02f, -7.19096959e-02f,
  -1.01394244e-01f, 1.19760685e-01f, 1.66308191e-02f, -3.77615727e-03f, -4.91807871e-02f, -2.09369622e-02f, 8.41954425e-02f, -6.55612675e-04f, -5.86510189e-02f, -2.94055846e-02f,
  1.74761295e-01f, -3.68154831e-02f, -3.07102818e-02f, -1.39684847e-03f, -1.42402640e-02f, 3.49488691e-04f, -1.01588583e-02f, -1.35253534e-01f, -8.80702678e-03f, -1.07823260e-01f,
  -6.64974973e-02f, -6.78260177e-02f, -4.08268608e-02f, -3.53959948e-02f, -1.18799567e-01f, 6.18094020e-03f, 8.97084698e-02f, 4.86050174e-02f, -1.09315887e-01f, 1.48231238e-02f,
  2.11729817e-02f, 3.01688612e-02f, 2.02356130e-01f, -1.74490318e-01f, -3.69755365e-03f, 6.09217882e-02f, 2.93901801e-01f, -4.19233181e-02f, 2.51748621e-01f, -3.73831354e-02f,
  -2.75339812e-01f, 2.99743176e-01f, 1.70802936e-01f, -3.28728825e-01f, 8.12472180e-02f, 4.30817865e-02f, -2.62577057e-01f, -4.56410050e-02f, 2.55714923e-01f, -9.33325067e-02f,
  -1.04333691e-01f, -3.52221787e-01f, -8.83697495e-02f, -2.29138449e-01f, -1.42786540e-02f, -1.18555967e-02f, -8.47828686e-02f, 1.38231948e-01f, -4.04213369e-01f, -6.38338923e-02f,
  -2.60469392e-02f, -1.44821256e-01f, 3.40247639e-02f, 1.24789532e-02f, 6.72491500e-03f, -1.04458123e-01f, 9.88130495e-02f, 1.60784960e-01f, 8.23275894e-02f, 5.61450385e-02f,
  1.55634150e-01f, -4.99525182e-02f, -3.82966362e-02f, -6.78178295e-02f, 6.65187016e-02f, 3.09049692e-02f, 5.15910275e-02f, 7.61809424e-02f, 1.93514451e-02f, 3.97166461e-02f,
  2.81828176e-02f, -6.65053278e-02f, -2.11757515e-02f, -9.81581137e-02f, 9.27407965e-02f, 2.79935682e-03f, 6.83901384e-02f, 8.31969976e-02f, -2.12980323e-02f, 4.77567203e-02f,
  -7.14309141e-02f, 9.62682292e-02f, 7.22621828e-02f, 1.58124473e-02f, -1.17010362e-02f, -1.01096705e-01f, -3.03725004e-02f, -1.71813238e-02f, 8.11314881e-02f, -8.37777108e-02f,
  -1.08279295e-01f, -4.18493375e-02f, -2.64177639e-02f, 3.95793281e-03f, -4.50930186e-02f, -1.23487879e-02f, 7.33212009e-02f, -1.14545919e-01f, -1.49763292e-02f, -3.99954058e-02f,
  8.33022147e-02f, 1.03015359e-02f, 1.10973241e-02f, 2.05688030e-02f, 1.32931792e-03f, 3.11258435e-02f, 2.59597949e-03f, 3.63897756e-02f, 8.46098214e-02f, -6.76941499e-03f,
  -5.86049184e-02f, -3.01579654e-01f, 9.36069787e-02f, 7.29684457e-02f, -4.34449576e-02f, -1.28882721e-01f, 5.33028692e-02f, 2.97139157e-02f, -8.00780300e-03f, -8.51542279e-02f,
  6.88054971e-03f, -4.82194498e-03f, -4.15712781e-03f, -1.52796824e-02f, -3.01193260e-02f, -5.11939488e-02f, -7.66256973e-02f, -7.05022588e-02f, -6.10425882e-02f, -1.65996775e-02f,
  -4.95858938e-02f, 8.55231658e-02f, 2.22943667e-02f, 7.60814548e-02f, 1.45397549e-02f, 3.84902060e-02f, 1.97583940e-02f, -7.91080110e-03f, -1.07306048e-01f, 3.62040959e-02f,
  3.42462420e-01f, -1.23728570e-02f, 1.26038920e-02f, 2.78556883e-01f, 3.21625397e-02f, 2.86968738e-01f, 6.60770983e-02f, 1.06936999e-01f, -1.02190934e-01f, -2.48897653e-02f,
  2.11149663e-01f, 3.80004160e-02f, -1.44094616e-01f, 3.19637597e-01f, 1.99827492e-01f, -7.50115290e-02f, 2.38965705e-01f, 1.40146479e-01f, -1.53646380e-01f, 8.68716091e-02f,
  1.17691249e-01f, 2.49713197e-01f, 8.35506395e-02f, 8.13521743e-02f, 1.32550135e-01f, -6.07581511e-02f, -7.33852610e-02f, -3.24570574e-02f, 2.29415089e-01f, 1.29505813e-01f,
  3.48019712e-02f, -9.02506188e-02f, 6.65122345e-02f, 3.92031893e-02f, 3.55017744e-03f, -3.02723423e-02f, 4.39651497e-02f, 2.46515162e-02f, 2.89612543e-02f, -2.28901692e-02f,
  4.55140844e-02f, -4.77672601e-03f, 5.67115210e-02f, 6.26439368e-03f, -5.07209562e-02f, 6.28344854e-03f, -4.04030234e-02f, -6.10558391e-02f, -5.00138998e-02f, 3.36275585e-02f,
  -1.48590328e-02f, -8.15885589e-02f, -1.51389290e-03f, -2.81682182e-02f, 8.07839707e-02f, 5.05192652e-02f, -3.69503796e-02f, 1.10894563e-02f, -1.39312791e-02f, -2.84329820e-02f,
  4.38140742e-02f, -4.14465517e-02f, -3.78515683e-02f, 6.22983500e-02f, 4.63732071e-02f, -5.19078709e-02f, 9.13616717e-02f, 1.94349252e-02f, -8.58861767e-03f, 4.90999892e-02f,
  -4.43116166e-02f, 5.56490198e-02f, 2.63346508e-02f, 4.30449732e-02f, -2.33423430e-02f, -3.06195766e-02f, 4.51572388e-02f, -5.12448177e-02f, -2.52040382e-02f, 2.52328161e-02f,
  -2.35039573e-02f, -5.83844818e-03f, -8.01800117e-02f, 3.02617960e-02f, 1.75730716e-02f, 5.54964282e-02f, -4.08028774e-02f, -3.98076028e-02f, 7.65189715e-03f, 1.63355440e-01f,
  1.37887960e-02f, -8.62432420e-02f, 5.00276359e-03f, 4.42736335e-02f, -4.64045517e-02f, 3.19041461e-02f, 5.64721525e-02f, 7.77294040e-02f, 1.21093327e-02f, -6.46697506e-02f,
  2.97470167e-02f, 3.69710550e-02f, -1.35179564e-01f, 1.39119267e-01f, 5.88554069e-02f, 1.39189316e-02f, -8.85949563e-03f, 2.92650703e-02f, 7.90054649e-02f, 2.50986777e-02f,
  -1.02285910e-02f, -1.32794464e-02f, 4.48257588e-02f, 5.04269376e-02f, 3.96129936e-02f, -6.15083650e-02f, -1.68772191e-02f, 4.38307226e-03f, -1.04642168e-01f, -2.29460020e-02f,
  1.86082676e-01f, 1.17797174e-01f, -2.13295758e-01f, 1.44830361e-01f, -1.57322899e-01f, 1.20919295e-01f, 3.12111408e-01f, -4.18027900e-02f, -5.04396334e-02f, 3.15119267e-01f,
  1.49415098e-02f, -7.02589424e-03f, 8.22954103e-02f, -8.29254556e-03f, -2.12333538e-02f, 6.73578084e-02f, 1.30310938e-01f, 5.91743514e-02f, 1.26340718e-03f, 1.11400016e-01f,
  -1.93667859e-01f, 2.29036324e-02f, -9.64657590e-02f, -8.73130485e-02f, -7.53832385e-02f, -1.76343277e-01f, 1.05255641e-01f, -1.03884809e-01f, 3.62957567e-02f, -5.52008441e-03f,
  -4.37680073e-02f, 1.49384007e-01f, -1.04342081e-01f, -2.16479762e-03f, 7.98017010e-02f, -3.48717049e-02f, 4.39073751e-03f, -6.76510409e-02f, -3.03731337e-02f, 3.41214538e-02f,
  5.00152260e-02f, -7.48814195e-02f, -2.22590044e-02f, -1.21101953e-01f, -7.39459842e-02f, -5.89830941e-03f, -4.26108241e-02f, 3.16863023e-02f, -3.53476848e-03f, -8.52225050e-02f,
  -2.75119636e-02f, -2.67248601e-03f, -1.57384593e-02f, 1.05057910e-01f, -5.83938807e-02f, 1.02434848e-02f, 2.72934586e-02f, -3.13835107e-02f, -9.15953238e-03f, 1.98478252e-02f,
  1.34033650e-01f, -4.43040282e-02f, 1.22037272e-04f, -3.30996290e-02f, 8.86622891e-02f, 3.55424732e-02f, -2.26850132e-03f, -1.83550827e-02f, 4.43231389e-02f, 4.51663472e-02f,
  1.63998436e-02f, -7.27264434e-02f, -1.24438398e-01f, -1.93786342e-02f, 2.29012202e-02f, 5.82452640e-02f, -3.99634503e-02f, -1.25923064e-02f, -6.11365102e-02f, -8.59323423e-03f,
  1.23843424e-01f, -1.32649913e-02f, -1.34544531e-02f, 1.90784913e-02f, -2.25287937e-02f, -5.71110547e-02f, -9.08852741e-02f, 3.45208459e-02f, -9.26284641e-02f, -4.53194864e-02f,
  1.99890852e-01f, 3.57518107e-01f, 8.74960236e-03f, -4.39883061e-02f, 5.55136688e-02f, -1.48885418e-02f, 2.44742930e-02f, -7.46530667e-02f, 1.44591089e-02f, 8.13226625e-02f,
  -1.57238990e-01f, 6.05173185e-02f, 1.02673031e-01f, 4.21058983e-02f, 6.47973865e-02f, -3.88878919e-02f, 5.91879562e-02f, -3.67687643e-02f, -6.98615164e-02f, 2.70233396e-02f,
  -5.28443307e-02f, 9.16073322e-02f, -3.39801013e-02f, -4.60244417e-02f, -4.88402806e-02f, 1.40676443e-02f, 4.80866395e-02f, 8.74954388e-02f, -7.78151825e-02f, -2.99119186e-02f,
  -8.49981979e-03f, -5.10346472e-01f, -1.94289759e-01f, -2.09350824e-01f, 1.58681452e-01f, -3.27560812e-01f, -3.06735247e-01f, -1.21554568e-01f, 9.99743715e-02f, -2.33829707e-01f,
  -7.98906013e-02f, 2.26741005e-02f, -1.34806111e-01f, -2.55559355e-01f, 3.68405767e-02f, -1.38134062e-01f, -2.43443444e-01f, -2.39365146e-01f, 6.86039627e-02f, -6.99807480e-02f,
  -9.43546668e-02f, -1.17802672e-01f, -5.92381395e-02f, 2.30557453e-02f, -1.04469366e-01f, 8.44438151e-02f, 5.01620173e-02f, 7.61320293e-02f, 3.37160775e-04f, -4.44784313e-02f,
  -2.68654320e-02f, 1.62253790e-02f, -2.55474914e-02f, -1.49514778e-02f, -1.06853306e-01f, -5.98571897e-02f, -5.18332347e-02f, 7.16627464e-02f, 2.30894443e-02f, 3.83176655e-02f,
  -2.60981196e-03f, 9.06253140e-03f, -5.29371426e-02f, 5.38346656e-02f, 4.95215096e-02f, 4.29121479e-02f, 6.86661825e-02f, 4.47188271e-03f, -6.64194450e-02f, -7.72431418e-02f,
  -3.46964113e-02f, 5.40228840e-03f, -5.00540882e-02f, -7.58514255e-02f, 3.95951159e-02f, 4.87363804e-03f, -4.81247529e-03f, -1.32576488e-02f, -6.31013587e-02f, 2.85223164e-02f,
  -6.52252585e-02f, 5.77798858e-03f, -1.44551069e-01f, 3.62692364e-02f, -1.22953035e-01f, 6.46793842e-02f, -9.10262614e-02f, 3.44892964e-02f, 9.57318768e-02f, 2.65702722e-03f,
  1.54304117e-01f, -9.35972575e-03f, 4.84762900e-02f, -5.40383160e-02f, -1.06038116e-02f, -1.32112997e-02f, 3.93787548e-02f, -1.98120475e-02f, -5.89596480e-03f, 4.26620506e-02f,
  6.36707321e-02f, 1.34444004e-03f, -7.59061752e-03f, 2.00555995e-02f, 3.66931478e-03f, 5.64180277e-02f, -8.95549282e-02f, 1.11912226e-03f, 5.74303465e-03f, 2.18162057e-03f,
  -2.30334803e-01f, -1.64829865e-01f, 3.92856374e-02f, 4.39145416e-02f, 8.20551291e-02f, -2.68473011e-02f, 3.68956253e-02f, -2.95231845e-02f, 4.66101281e-02f, -1.70863420e-02f,
  1.46571612e-02f, 1.45987049e-02f, 1.52666972e-03f, -2.29044557e-02f, 5.38650081e-02f, -4.15474921e-02f, 2.11958820e-03f, 6.66988492e-02f, 3.64267342e-02f, 2.46575335e-03f,
  -8.24366435e-02f, 3.94720025e-02f, 9.39218029e-02f, -5.19451592e-03f, -8.92305449e-02f, -7.53396004e-02f, 1.42994719e-02f, 2.85492260e-02f, 8.20048805e-03f, -2.06621997e-02f,
  -2.55031079e-01f, 8.82909149e-02f, 2.43409052e-01f, -3.95507105e-02f, -1.99370697e-01f, 1.00911207e-01f, 5.01084685e-01f, -3.16810101e-01f, 4.23933007e-03f, 3.05348616e-02f,
  -1.27887368e-01f, 1.91200837e-01f, 2.52021819e-01f, -5.19364476e-02f, 1.02526031e-01f, 7.12695718e-02f, -5.56638129e-02f, -1.12702526e-01f, -1.55044109e-01f, -9.13973302e-02f,
  -2.10194618e-01f, -1.72381669e-01f, 1.17467597e-01f, -2.69038439e-01f, -1.18117288e-01f, -1.77993849e-01f, -2.44903252e-01f, 1.24735326e-01f, -4.04482149e-02f, 7.92191997e-02f,
  1.12646244e-01f, -4.70512584e-02f, 5.20358495e-02f, 5.30442456e-03f, -3.81637104e-02f, -6.30705012e-03f, 1.19047813e-01f, 1.58189580e-01f, -7.55979307e-03f, 4.73168194e-02f,
  3.72808217e-03f, 6.77531138e-02f, 1.85145289e-02f, -1.94151755e-02f, -4.20128852e-02f, -4.45839576e-02f, -1.83261503e-02f, 3.70883085e-02f, 1.62658170e-02f, 1.16285875e-01f,
  6.35722131e-02f, 2.80669294e-02f, -5.00125960e-02f, 7.58117437e-02f, 1.81826148e-02f, 1.38936015e-02f, 1.94054469e-02f, 7.84174278e-02f, -1.15939617e-01f, 4.55281697e-02f,
  -9.12786052e-02f, -3.55589353e-02f, -6.72152340e-02f, -5.87192327e-02f, 1.25004109e-02f, -7.86569342e-03f, -5.68742082e-02f, 4.03953679e-02f, -5.27583621e-02f, 1.19593963e-02f,
  -1.37864742e-02f, -6.23506382e-02f, -3.03824116e-02f, -1.34089962e-02f, 2.97586378e-02f, -3.71260531e-02f, 6.79028314e-03f, 4.52083237e-02f, -7.49111772e-02f, 3.00077368e-02f,
  7.49397045e-03f, 6.27178233e-03f, -5.44056064e-03f, -9.85784531e-02f, 1.45916762e-02f, 4.92247790e-02f, 6.29077991e-03f, -6.83478033e-03f, 1.56566706e-02f, -1.66090447e-02f,
  -8.33828896e-02f, 3.95751968e-02f, 1.77424084e-02f, 3.44964899e-02f, 5.73080294e-02f, -5.36607392e-02f, 3.90704460e-02f, -3.36365849e-02f, 3.65137756e-02f, 5.05680181e-02f,
  -1.56255803e-04f, -5.75819053e-03f, -1.15233794e-01f, 2.23695990e-02f, -9.01828185e-02f, 2.99291220e-02f, 2.30844179e-03f, 3.06224301e-02f, 4.26028781e-02f, -9.71288234e-03f,
  -1.33142283e-04f, -7.48742372e-02f, 3.83517682e-03f, -8.33875909e-02f, -2.81124953e-02f, -8.13501105e-02f, -6.17256761e-02f, -6.15651198e-02f, 7.25921243e-02f, -1.38434786e-02f,
  -5.49069107e-01f, 2.78036714e-01f, -1.01896673e-01f, -1.48696110e-01f, -8.64367783e-02f, 2.90945470e-01f, 2.25184411e-02f, 1.06270961e-01f, 1.43960357e-01f, 2.44724572e-01f,
  8.74502677e-03f, -1.80332642e-02f, -7.30454028e-02f, -5.39677143e-02f, 7.15989247e-02f, 2.35669062e-01f, 6.20155409e-03f, 5.75970896e-02f, -1.05660476e-01f, -1.81410015e-01f,
  1.04842475e-02f, 8.40326697e-02f, -1.96242675e-01f, 1.32000595e-01f, -1.85326204e-01f, -1.21721648e-01f, -9.74833816e-02f, 4.69670445e-02f, -8.66379961e-02f, 3.56169268e-02f,
  -1.13658823e-01f, -2.25112140e-02f, -1.70806959e-01f, -4.67976257e-02f, -1.58885300e-01f, -8.61535687e-03f, -5.03474027e-02f, 9.67615992e-02f, -1.16098188e-02f, -6.23651743e-02f,
  1.76561170e-03f, -2.15750616e-02f, -9.19009596e-02f, 3.69160883e-02f, 9.64619517e-02f, 3.16206887e-02f, 5.27714472e-03f, 5.49816107e-03f, 9.63543716e-04f, -1.98299307e-02f,
  -3.85114625e-02f, -4.33632582e-02f, -4.59373333e-02f, 4.40081174e-04f, -3.97194214e-02f, 4.87941550e-04f, 1.52368508e-02f, -6.25476427e-03f, -2.67880373e-02f, -6.26965705e-03f,
  -8.33783820e-02f, 2.97836922e-02f, -1.23372450e-02f, -8.05871934e-03f, 2.23349743e-02f, -2.80769356e-02f, 1.62469577e-02f, -1.18846767e-01f, 6.06377646e-02f, 1.35564774e-01f,
  -1.24455005e-01f, 2.93685216e-02f, 4.58142497e-02f, 5.47940023e-02f, 1.14655774e-02f, -5.19581549e-02f, -1.35853030e-02f, -7.84000009e-02f, 7.35431314e-02f, -2.64992993e-02f,
  -4.24141586e-02f, 2.50874888e-02f, 6.83261678e-02f, -4.14664038e-02f, -3.29724513e-02f, 1.06246315e-01f, -1.77524798e-02f, -3.13530676e-02f, -2.94520557e-02f, 2.18628272e-02f,
  6.56813607e-02f, 4.53937724e-02f, -1.17183849e-01f, 1.10643305e-01f, -2.06071902e-02f, 9.83429924e-02f, 6.68958062e-03f, 6.51082322e-02f, 8.98211449e-02f, -6.12958409e-02f,
  2.61501390e-02f, -1.08829789e-01f, 5.27855940e-03f, -2.45695245e-02f, 6.76021799e-02f, 2.82764472e-02f, 3.65170017e-02f, 7.53023103e-02f, 3.14894505e-02f, -1.92816146e-02f,
  -5.65327667e-02f, -8.80606398e-02f, 9.94960442e-02f, -1.16687894e-01f, -2.71227956e-02f, -1.01059198e-01f, -1.50197409e-02f, 3.28435153e-02f, 3.14505287e-02f, 5.49191087e-02f,
  -3.05294424e-01f, -1.58171952e-01f, -2.84861445e-01f, -3.36240262e-01f, -7.15242997e-02f, 2.47518197e-01f, -1.49447322e-01f, -1.77672267e-01f, -1.60475835e-01f, 1.65696174e-01f,
  -6.00403249e-02f, -1.15077890e-01f, 8.45970735e-02f, -1.73079818e-01f, -1.05800591e-02f, 2.12865278e-01f, -1.49575248e-01f, -8.71702209e-02f, -1.67425469e-01f, -2.41038352e-01f,
  -1.89785883e-01f, -7.24032614e-03f, -2.13840246e-01f, -9.20327306e-02f, -2.62303259e-02f, -2.02657245e-02f, 1.70457691e-01f, 1.43563762e-01f, -4.85785119e-02f, 4.41129580e-02f,
  3.82440910e-02f, -1.06034264e-01f, -7.88860470e-02f, 1.30178239e-02f, -5.69582060e-02f, 3.17694210e-02f, 8.97381529e-02f, 7.28257298e-02f, -4.67427354e-03f, -4.18618210e-02f,
  6.52588233e-02f, -6.75599352e-02f, -2.72212438e-02f, 6.59409836e-02f, 2.59214472e-02f, 4.64738533e-02f, -5.75183146e-02f, -2.68983748e-03f, -7.18589202e-02f, -8.87150615e-02f,
  -5.29767051e-02f, -1.98451579e-02f, -4.38134708e-02f, -3.29923176e-04f, 5.16934320e-02f, -9.56137944e-03f, 7.37279132e-02f, -4.01916169e-02f, 1.08333908e-01f, 2.63641104e-02f,
  8.08195546e-02f, 5.38781025e-02f, -7.44172698e-03f, -8.40184614e-02f, -7.20825717e-02f, -1.12205290e-03f, 7.25871744e-03f, -5.93340322e-02f, -8.53887051e-02f, -2.10025702e-02f,
  -5.46782836e-02f, -1.04267962e-01f, 3.82107543e-03f, -6.76289424e-02f, -6.14411682e-02f, 3.96528468e-02f, 6.16914518e-02f, 1.13600567e-01f, 4.96194186e-03f, -5.23683727e-02f,
  5.22586666e-02f, 2.88348924e-02f, -7.52093419e-02f, 9.04922858e-02f, 2.35592294e-02f, 5.40781878e-02f, 8.61362293e-02f, 7.69964838e-03f, -2.37967689e-02f, -7.18817906e-03f,
  1.26278564e-01f, 3.11997086e-02f, -9.78456736e-02f, 9.58979968e-03f, 4.69926000e-02f, 1.23306895e-02f, 4.80950363e-02f, -2.18077768e-02f, -5.64908087e-02f, -6.85214996e-02f,
  1.04320377e-01f, 1.86049882e-02f, 1.09380811e-01f, -2.03881394e-02f, 1.13256015e-02f, -5.60205579e-02f, 5.19971140e-02f, -1.37361251e-02f, 5.41374609e-02f, -3.85487080e-02f,
  6.45450056e-02f, 5.54320849e-02f, 1.11203436e-02f, 9.83614177e-02f, 4.98260232e-03f, 4.13986854e-03f, 5.98657168e-02f, -8.67162570e-02f, 1.12606838e-01f, 2.36330926e-02f,
  -5.27186692e-01f, -5.80355525e-03f, -2.39249095e-01f, -3.39880325e-02f, -7.85424560e-02f, -1.26280442e-01f, -3.04722544e-02f, -2.87305433e-02f, 1.84054926e-01f, 2.37334922e-01f,
  2.58632958e-01f, 9.09112766e-02f, 2.59301484e-01f, 1.42767623e-01f, 1.29505806e-02f, 1.56998873e-01f, -5.58488108e-02f, -1.13665886e-01f, 8.80296305e-02f, -5.95380478e-02f,
  -1.32559270e-01f, 3.27996388e-02f, -7.33417273e-02f, 3.00225299e-02f, -4.12550867e-02f, 6.48671612e-02f, -3.39324288e-02f, 8.77302960e-02f, -5.46956547e-02f, 1.18475176e-01f,
  5.32414168e-02f, 2.33256947e-02f, -7.25891143e-02f, 4.12133820e-02f, -1.23269334e-01f, -1.61735356e-01f, -3.21936272e-02f, 1.31132286e-02f, -7.06241205e-02f, 3.74030657e-02f,
  -2.26624887e-02f, -2.23837961e-02f, 8.80176574e-02f, 3.46463844e-02f, 2.84445267e-02f, 4.24061203e-03f, -9.57087353e-02f, 9.53697860e-02f, -5.94670996e-02f, 1.36029972e-02f,
  5.46110049e-02f, 1.01959743e-01f, -1.20217212e-01f, -1.76668738e-03f, 1.55422434e-01f, 5.94807491e-02f, 1.04081795e-01f, 7.07953647e-02f, -3.04392669e-02f, 6.90692943e-03f,
  -3.42249610e-02f, -1.54202655e-01f, -7.33134523e-02f, 2.84090433e-02f, -1.05944179e-01f, -2.98099536e-02f, 3.38656381e-02f, 1.02852006e-02f, 4.12503481e-02f, 6.48698583e-02f,
  2.09804880e-03f, -1.19555090e-02f, 1.35515228e-01f, 6.52309274e-03f, -6.70888424e-02f, -2.49356627e-02f, -1.06988568e-02f, 5.84151670e-02f, 9.06341448e-02f, 9.98789221e-02f,
  6.28809957e-03f, -3.70365903e-02f, -2.18733996e-02f, 1.60705000e-01f, 4.61803079e-02f, -7.33313859e-02f, 9.17519815e-03f, -2.02000681e-02f, -4.73311683e-03f, 6.84718117e-02f,
  4.71866243e-02f, 5.47190942e-03f, 1.57400668e-01f, 8.57270509e-02f, 5.97252846e-02f, -6.32962435e-02f, 2.73041576e-02f, 9.08655301e-03f, -1.38455182e-01f, -7.58131072e-02f,
  -2.63587218e-02f, 1.33045483e-02f, -6.15603663e-02f, -3.69190015e-02f, -3.87725048e-02f, 6.20900653e-02f, -8.13720524e-02f, 5.30017633e-03f, -2.16127038e-02f, 2.72092354e-02f,
  -1.71370246e-02f, 1.88852176e-01f, -1.09738834e-01f, 5.38033545e-02f, -5.61225638e-02f, 3.67701165e-02f, -3.41956839e-02f, 2.59359740e-02f, -3.43245678e-02f, 1.93175138e-03f,
  -1.67161256e-01f, 2.31377482e-01f, -2.03340784e-01f, -2.22767830e-01f, 2.48504523e-02f, 1.25481158e-01f, -1.48136213e-01f, 1.56708006e-02f, -5.98506145e-02f, 2.05385163e-01f,
  4.48154425e-03f, -4.79615778e-02f, -1.42051905e-01f, 1.23799279e-01f, -4.43259984e-01f, -3.04517932e-02f, -2.35077776e-02f, 1.28521636e-01f, -2.71999445e-02f, 1.43858120e-01f,
  -1.52020663e-01f, 1.64666131e-01f, -1.53243139e-01f, 1.75753996e-01f, 3.91843989e-02f, -1.22948745e-02f, 6.04001172e-02f, -8.52297619e-02f, 1.57303944e-01f, 4.17324789e-02f,
  -1.95878316e-02f, -3.30643058e-02f, -6.32852735e-03f, 1.22616068e-01f, 9.93080512e-02f, 2.25196197e-03f, 1.24724634e-01f, -3.54092456e-02f, -6.47124350e-02f, 4.05603200e-02f,
  1.26402704e-02f, 6.21983130e-03f, -3.08006201e-02f, 1.21109821e-02f, -1.96125079e-03f, -6.08314760e-02f, 4.90195490e-02f, 8.61591026e-02f, 2.17977334e-02f, -8.33105370e-02f,
  -1.18645698e-01f, 2.91686449e-02f, -4.08977754e-02f, 3.29216644e-02f, -1.10761873e-01f, 1.05039019e-03f, -4.64454899e-03f, -1.09862931e-01f, -6.80412501e-02f, -3.46226210e-04f,
  -2.15872154e-02f, 3.89481708e-02f, 1.21416368e-01f, -2.52468176e-02f, 8.91068280e-02f, 8.67322495e-04f, -4.58670361e-03f, 8.01156089e-02f, 1.37343665e-03f, 3.42709036e-03f,
  4.09678593e-02f, -7.52374902e-02f, -5.68530522e-02f, -1.85906831e-02f, 4.45522517e-02f, 1.33822281e-02f, 3.29631679e-02f, 6.69925287e-02f, -8.27506781e-02f, -1.87547971e-02f,
  -3.08257751e-02f, 2.98846867e-02f, 4.33837138e-02f, -3.62182558e-02f, 9.60995704e-02f, -3.56255844e-02f, -2.59780884e-02f, -4.48646210e-02f, 2.24168394e-02f, -4.95506003e-02f,
  1.96260571e-01f, 8.77619386e-02f, 1.57758042e-01f, 3.85624208e-02f, 7.48720542e-02f, 1.01703741e-02f, -2.09483914e-02f, 3.80705222e-02f, 5.47496453e-02f, 8.49885941e-02f,
  7.64657035e-02f, 4.48178351e-02f, -2.78500691e-02f, -3.10474057e-02f, -2.58048391e-03f, -3.29250433e-02f, 3.41942497e-02f, 5.99893108e-02f, -1.84416212e-02f, 4.21513170e-02f,
  5.84768988e-02f, -4.99519240e-03f, -8.33638310e-02f, -6.16982430e-02f, 7.31763169e-02f, -3.52332331e-02f, -6.82180673e-02f, 1.33519422e-03f, 2.89353449e-02f, -6.70296624e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.84058047e-03f, -5.03254011e-02f, 1.08290188e-01f, 2.01450408e-01f, -9.83463824e-02f, -2.96795815e-01f, -1.69504926e-01f, -2.42691534e-03f, -2.27847293e-01f, 4.12687995e-02f,
  -9.62095708e-02f, -6.06854297e-02f, -9.16694030e-02f, -1.11455522e-01f, 1.18799821e-01f, -4.93262887e-01f, 1.66539490e-01f, -1.14857711e-01f, -2.36767948e-01f, 1.74152181e-01f,
  -4.28575166e-02f, 2.60987401e-01f, 2.73746878e-01f, 4.94731635e-01f, 1.12285897e-01f, 3.26548487e-01f, 5.62473178e-01f, 1.65450096e-01f, 4.17972684e-01f, 1.54788658e-01f,
  -1.68066800e-01f, -1.88264981e-01f, 2.06602849e-02f, -5.24876155e-02f, 8.67194608e-02f, -7.98279792e-02f, 4.05710144e-03f, 1.94918048e-02f, 2.74280310e-02f, 5.49585111e-02f,
  -8.01337734e-02f, -6.14265129e-02f, 4.48641740e-02f, -1.30354345e-01f, -4.02124822e-02f, 5.35327569e-02f, -3.69536653e-02f, -3.02446317e-02f, -4.06854153e-02f, -6.40683994e-02f,
  -5.89310899e-02f, -9.30798203e-02f, 4.42301333e-02f, 2.78283432e-02f, 1.27999261e-01f, -2.67121345e-02f, 1.35553956e-01f, 1.12745829e-01f, 3.24994698e-02f, 1.76093783e-02f,
  -2.55811261e-03f, 2.83441767e-02f, 3.48158889e-02f, -1.60219762e-02f, -5.13392724e-02f, 5.99846579e-02f, -3.33020017e-02f, 3.34463902e-02f, 1.16384402e-01f, 2.26584375e-02f,
  4.01934385e-02f, 1.20657623e-01f, -5.86648434e-02f, -9.58700106e-02f, 4.59774770e-02f, -7.93581903e-02f, 4.15400676e-02f, 7.38756061e-02f, 6.14004061e-02f, -1.27967238e-01f,
  -5.74498735e-02f, 6.70695230e-02f, 2.53839344e-02f, 3.86462361e-02f, -4.25722711e-02f, 5.08322529e-02f, -3.42878625e-02f, -2.83834916e-02f, 1.35656670e-01f, -7.86935166e-02f,
  -6.07333966e-02f, 5.56818731e-02f, 8.76796152e-03f, -5.60333906e-03f, -4.60291170e-02f, -9.23784729e-03f, 3.80661376e-02f, 3.68760377e-02f, 2.53384244e-02f, -6.29043132e-02f,
  6.09823018e-02f, 5.27969152e-02f, -8.87219980e-02f, 3.72245945e-02f, 1.47860199e-01f, -1.65768974e-02f, 1.75925866e-02f, 9.17112976e-02f, 9.47839096e-02f, 7.19257817e-02f,
  2.45105121e-02f, -2.55740136e-02f, 7.28035793e-02f, 2.36748606e-02f, 3.45394127e-02f, -7.34463781e-02f, 1.28523320e-01f, -2.84004454e-02f, 1.33267976e-02f, -2.24192403e-02f,
  3.26854527e-01f, 3.12627971e-01f, 1.78762406e-01f, 1.17335424e-01f, -1.43707052e-01f, 2.72188131e-02f, -4.95682796e-03f, -3.80761586e-02f, 4.33974639e-02f, 2.64705539e-01f,
  -1.03870720e-01f, 5.76622725e-01f, -2.43865728e-01f, -1.02583179e-02f, -4.79640543e-01f, -2.59420484e-01f, 3.38568985e-02f, 1.02128558e-01f, -1.19697206e-01f, 7.22153038e-02f,
  -1.56736091e-01f, -3.74941587e-01f, -2.21890911e-01f, -2.36894801e-01f, 1.97290868e-01f, 3.02051395e-01f, -1.57461837e-01f, -1.07326835e-01f, 2.03145877e-01f, -1.81740567e-01f,
  8.06661099e-02f, -1.01756915e-01f, 1.16180263e-01f, 3.90520282e-02f, -2.51031690e-03f, -7.93801248e-02f, 1.47426054e-01f, -2.57844478e-01f, -2.80905925e-02f, -1.30883791e-02f,
  1.16824500e-01f, -1.22710377e-01f, 2.73365378e-02f, -8.99569094e-02f, -8.65722969e-02f, 1.97358541e-02f, 1.32172301e-01f, 5.58633469e-02f, -2.19761208e-02f, 7.40058795e-02f,
  1.14293307e-01f, 5.84672764e-02f, 3.92208733e-02f, 5.26825599e-02f, 4.65963595e-02f, 1.45583414e-02f, 1.17286757e-01f, -2.56987400e-02f, 9.55775306e-02f, -2.46458314e-02f,
  -1.18819326e-01f, -8.61996561e-02f, -4.94598597e-02f, 1.96607690e-02f, 5.97259067e-02f, -1.16892299e-02f, 5.70127880e-03f, 1.89052895e-02f, 3.38937230e-02f, 8.91632661e-02f,
  1.24891922e-01f, 5.63643724e-02f, -5.34699038e-02f, -1.17646709e-01f, 6.19455948e-02f, 6.47878125e-02f, 1.66389102e-03f, 6.76578432e-02f, 4.95722815e-02f, 2.12124795e-01f,
  -8.46645981e-02f, -5.57968765e-02f, -9.30420905e-02f, 6.59768358e-02f, 3.24680172e-02f, -1.11342646e-01f, -9.13767070e-02f, 2.44192090e-02f, 1.99119747e-02f, -5.66009469e-02f,
  -1.61517318e-02f, -7.80235678e-02f, 9.75529030e-02f, -6.70100898e-02f, 5.39836176e-02f, 2.70983707e-02f, -2.50249356e-02f, 1.78976223e-01f, 1.21300074e-03f, -7.55140185e-02f,
  4.27389629e-02f, 6.97624385e-02f, 3.74946445e-02f, -4.73472215e-02f, 3.52323018e-02f, 6.86313882e-02f, -2.23034471e-02f, -2.61707567e-02f, -3.38699073e-02f, 9.61842090e-02f,
  6.62373826e-02f, 4.57938388e-02f, 2.80262064e-02f, -2.87266914e-02f, 1.60822168e-01f, 1.17986478e-01f, 1.23293981e-01f, 8.69551077e-02f, -9.98528153e-02f, -4.35102209e-02f,
  -3.17418098e-01f, 4.05186385e-01f, 3.40684950e-01f, -3.99818987e-01f, 4.79950234e-02f, 9.00789574e-02f, -3.06617886e-01f, 2.70159215e-01f, -1.37359902e-01f, 1.12653598e-01f,
  -2.00834319e-01f, 3.29653889e-01f, 7.80188246e-03f, 8.87094252e-03f, -2.22116277e-01f, -1.43866122e-01f, -7.75439292e-02f, -1.13046847e-01f, 3.76348644e-02f, 7.49140754e-02f,
  -1.37338251e-01f, -2.33802184e-01f, 1.69131383e-01f, 2.22531319e-01f, 1.41008332e-01f, 8.43101889e-02f, -2.35841408e-01f, 4.47171219e-02f, 2.11702704e-01f, -5.74509725e-02f,
  1.22285351e-01f, -7.01933056e-02f, 6.86676055e-02f, 1.11507066e-01f, 5.03064394e-02f, -2.32476722e-02f, -1.20034099e-01f, -7.98067227e-02f, 6.61616996e-02f, 1.03543177e-01f,
  -6.05731010e-02f, 9.66810621e-03f, -3.29984054e-02f, 4.83366251e-02f, 9.47980806e-02f, 7.58894086e-02f, 8.13400596e-02f, 1.08143091e-01f, 7.80457035e-02f, 1.58089265e-01f,
  8.17793608e-02f, 2.38138493e-02f, -9.55093745e-03f, -3.70895006e-02f, 5.43245412e-02f, -2.92660506e-03f, 2.47177128e-02f, 6.63083568e-02f, 1.48024391e-02f, -3.48960087e-02f,
  7.20454380e-02f, -1.22619774e-02f, -4.48136451e-03f, -5.69693595e-02f, -6.78747008e-03f, -3.02050002e-02f, 4.06704955e-02f, -3.46878953e-02f, 1.33152511e-02f, -1.06304223e-02f,
  -1.31592736e-01f, 1.53362677e-02f, -1.31361233e-03f, 1.09142030e-03f, -1.35764226e-01f, 6.39669821e-02f, 1.37448609e-02f, -8.99005756e-02f, -1.07761025e-01f, 1.93225630e-02f,
  -3.62098925e-02f, -1.42933756e-01f, 2.49458067e-02f, -9.43853706e-02f, 6.70710132e-02f, 2.86936834e-02f, 8.38814229e-02f, 6.27805591e-02f, -3.97677459e-02f, -1.33855000e-01f,
  -2.38535658e-01f, -2.46421486e-01f, -4.89859730e-02f, -1.56612098e-02f, -4.26221080e-02f, 9.60708857e-02f, 2.89615318e-02f, 4.54352275e-02f, -1.70217410e-01f, 1.08957857e-01f,
  -5.62167307e-03f, -2.69116350e-02f, -2.69830064e-03f, -5.96253201e-02f, -7.07248077e-02f, -1.03180446e-01f, -1.94625571e-01f, -1.36300296e-01f, -1.10362634e-01f, 5.77897727e-02f,
  -9.95403603e-02f, -5.65145984e-02f, -7.84171894e-02f, 3.14618386e-02f, -5.52247204e-02f, -1.53790742e-01f, 4.20956537e-02f, 5.35594597e-02f, -1.12161338e-02f, 4.58430350e-02f,
  -2.23224431e-01f, -9.95166823e-02f, -3.80727857e-01f, -1.37861833e-01f, -2.57614672e-01f, -4.50485289e-01f, -2.53754914e-01f, -2.94000626e-01f, 1.11369185e-01f, 3.42652172e-01f,
  5.11517562e-02f, -5.53437844e-02f, 2.16986686e-01f, 2.74199173e-02f, 1.42636560e-02f, 3.52699965e-01f, -1.94261476e-01f, -1.44951921e-02f, -1.86831206e-02f, -2.52569109e-01f,
  -1.91614032e-01f, -1.25085771e-01f, 8.61632172e-03f, -2.58684844e-01f, -2.06458405e-01f, -8.29257444e-02f, 2.20644116e-01f, -2.99812704e-01f, -3.47571410e-02f, -3.28276493e-02f,
  -1.60655156e-01f, -1.26647219e-01f, -9.12490711e-02f, -4.98442650e-02f, -1.41093865e-01f, -9.41735953e-02f, 2.15863436e-02f, 2.32163109e-02f, -5.28451540e-02f, -1.10683575e-01f,
  -9.75027960e-03f, -2.08517164e-02f, -6.56895265e-02f, 1.80849098e-02f, 4.02211212e-02f, -8.33783075e-02f, 5.07502072e-03f, 2.01348606e-02f, -2.40566153e-02f, -2.63870358e-02f,
  1.28825540e-02f, -7.84522966e-02f, -1.76969673e-02f, 6.76902980e-02f, -4.04610820e-02f, 5.76276779e-02f, 9.96436104e-02f, -3.12967151e-02f, -9.39150453e-02f, -7.64862299e-02f,
  -1.05474398e-01f, 5.48023582e-02f, -2.64054202e-02f, 4.35075425e-02f, -1.75904453e-01f, -2.62477715e-02f, 7.41681829e-03f, -5.28440587e-02f, 2.05138028e-02f, -8.85607898e-02f,
  -2.40645166e-02f, -5.99391665e-03f, -3.74305584e-02f, -1.07445285e-01f, 9.38002840e-02f, -4.89707813e-02f, 1.41798660e-01f, -5.12421280e-02f, -7.60882646e-02f, 8.07876736e-02f,
  8.82654041e-02f, -1.18348531e-01f, -1.55910933e-02f, 8.69817287e-02f, -1.40326982e-02f, 6.04109205e-02f, -7.94540122e-02f, -3.72882858e-02f, 4.30924110e-02f, 6.84693530e-02f,
  -9.53514576e-02f, -3.67746621e-01f, 1.53901912e-02f, -6.87794313e-02f, 1.33576253e-02f, -5.68067096e-02f, -7.80333299e-03f, -7.83877671e-02f, -7.28042573e-02f, -1.51520655e-01f,
  6.55750558e-02f, -6.38614222e-03f, -8.96919221e-02f, 1.27633084e-02f, -1.05558604e-01f, 5.75869763e-03f, 1.30548045e-01f, -5.32937497e-02f, -7.30811656e-02f, -8.50582272e-02f,
  -1.26711503e-02f, -6.66108131e-02f, 1.31136671e-01f, -7.40065649e-02f, -7.82132149e-02f, -6.00385852e-03f, 4.21163766e-03f, -5.48708159e-03f, -5.50318807e-02f, -4.54088412e-02f,
  -9.48419571e-01f, 2.20460340e-01f, -2.92442478e-02f, -8.95718858e-02f, -2.03866825e-01f, -1.32229030e-01f, 3.98828201e-02f, -6.62264004e-02f, -2.15471208e-01f, 2.70291269e-01f,
  1.20624319e-01f, -2.66162395e-01f, 7.97852948e-02f, 3.02947909e-01f, -3.91159326e-01f, 2.50907511e-01f, 3.72247323e-02f, -4.14194427e-02f, 5.35522252e-02f, 2.59086490e-02f,
  -1.20504349e-01f, 2.63697863e-01f, 1.18746795e-01f, 1.36081666e-01f, 5.04598627e-03f, -6.40291497e-02f, -6.13305643e-02f, 4.89434563e-02f, 1.25262719e-02f, -7.10583180e-02f,
  -2.02163830e-01f, -8.43258947e-02f, -6.24021553e-02f, -1.42309695e-01f, -1.80769950e-01f, -2.74860114e-02f, -7.79106915e-02f, -1.00830249e-01f, 1.55453775e-02f, -3.02294996e-02f,
  -6.09815530e-02f, 8.01057834e-03f, 1.35175914e-01f, -7.48537630e-02f, -7.76769370e-02f, -1.59591753e-02f, -1.87314730e-02f, -1.27643105e-02f, 5.28970733e-02f, -6.53733173e-03f,
  3.94574702e-02f, -7.88485706e-02f, 4.64587705e-03f, 1.01306409e-01f, 1.07003432e-02f, 3.21782641e-02f, 1.13369912e-01f, -3.52680534e-02f, -1.35609224e-01f, -5.68995215e-02f,
  -3.97134125e-02f, -1.77671444e-02f, -7.21849559e-04f, -2.37624291e-02f, 2.59094667e-02f, 1.61934961e-02f, -3.04448511e-02f, -2.68535819e-02f, -6.58170134e-02f, 1.24810115e-02f,
  -7.62752295e-02f, -6.83205947e-02f, -3.99113446e-02f, 2.14178823e-02f, 2.38347277e-02f, -6.31805211e-02f, -4.20326889e-02f, -6.37648329e-02f, 5.71516603e-02f, -6.66472688e-02f,
  -4.17749491e-03f, -7.28374207e-03f, 1.25826290e-02f, -2.11107824e-02f, -3.44399735e-02f, 5.57388589e-02f, -1.51816243e-02f, 1.14560258e-02f, -3.38430032e-02f, -3.52873281e-02f,
  -5.02301455e-01f, -3.11767668e-01f, 1.10826828e-01f, -1.49934947e-01f, -1.10142091e-02f, -1.59487762e-02f, -1.89915858e-02f, 1.81999691e-02f, -1.23728346e-02f, 2.85673756e-02f,
  -1.13291062e-01f, -1.10369205e-01f, -7.81255141e-02f, -6.48598000e-02f, -1.85210811e-04f, 8.00408274e-02f, -3.78913581e-02f, -1.26807645e-01f, -8.99882838e-02f, -1.66535284e-02f,
  -6.76190332e-02f, 7.85816368e-03f, 1.41927645e-01f, -1.59175973e-02f, -2.19643395e-02f, -4.00459878e-02f, -5.64871393e-02f, -2.07089800e-02f, -3.34898941e-03f, 2.31395960e-02f,
  -6.73622727e-01f, 5.73534481e-02f, 4.59404022e-01f, -4.51850414e-01f, -1.36464968e-01f, 1.47359580e-01f, 1.60618812e-01f, 1.23332264e-02f, -3.18486184e-01f, -7.95764476e-02f,
  -2.52236798e-02f, -1.62515149e-01f, 3.92548978e-01f, -3.77176777e-02f, 3.38159919e-01f, 2.07357526e-01f, -4.96819094e-02f, -1.27312183e-01f, -5.58658019e-02f, -1.44958973e-01f,
  -1.06880002e-01f, -9.33405980e-02f, 3.22951138e-01f, -3.50734740e-02f, -4.41702232e-02f, -2.79919714e-01f, 4.69105281e-02f, 1.33671671e-01f, -8.43394920e-02f, -1.40672559e-02f,
  -1.82696104e-01f, -1.66712299e-01f, 2.69386377e-02f, -1.34342620e-02f, 2.26231311e-02f, 9.70724877e-03f, 1.13268264e-01f, 1.22692332e-01f, -1.13828011e-01f, -3.72505300e-02f,
  2.04057172e-02f, 1.02434419e-01f, -2.47643158e-01f, -1.13740630e-01f, -6.44470155e-02f, -2.90726069e-02f, 1.53909481e-04f, 1.75033119e-02f, 2.03639213e-02f, 7.20947608e-02f,
  1.02986194e-01f, 8.35486799e-02f, -5.44606894e-03f, -8.87315944e-02f, 8.60453770e-02f, -7.61750527e-03f, -1.74383949e-02f, 7.76439458e-02f, -1.05546646e-01f, -2.57619649e-01f,
  1.36939794e-01f, -4.58840141e-03f, 5.65479770e-02f, -2.90151332e-02f, 6.18803827e-03f, -1.27784088e-01f, 1.28298355e-02f, 8.11182261e-02f, -1.05921298e-01f, 4.82968688e-02f,
  -6.89534098e-02f, -4.17401046e-02f, -2.03685686e-02f, -2.01714449e-02f, -3.59986462e-02f, -7.62582868e-02f, 3.72515917e-02f, -2.02994868e-02f, -6.54114038e-02f, -2.12004781e-02f,
  2.61986498e-02f, -7.83125609e-02f, -2.14170106e-03f, 2.71553975e-02f, 1.32927857e-02f, 5.24868593e-02f, -1.28985241e-01f, -1.07543338e-02f, -3.99124809e-02f, -2.87459288e-02f,
  -3.07222575e-01f, -3.05761725e-01f, 3.66102494e-02f, -2.14185882e-02f, 5.96734742e-03f, -3.45726162e-02f, 1.01122409e-01f, -1.54119898e-02f, -1.05455451e-01f, 2.45936513e-02f,
  -1.66974105e-02f, 2.83199213e-02f, 6.81065619e-02f, -5.16557284e-02f, 1.29405454e-01f, 3.19852121e-02f, -2.92391200e-02f, -4.08053994e-02f, 6.87705632e-03f, -2.36093849e-02f,
  -7.84443878e-03f, 3.84561568e-02f, -7.31782988e-02f, 5.35872998e-03f, -5.07360138e-02f, -2.10941322e-02f, -1.04616143e-01f, 3.64882648e-02f, 9.91831627e-03f, 7.76755484e-03f,
  -6.51138723e-01f, 8.62963349e-02f, -2.53786862e-01f, -3.09850365e-01f, 2.04547778e-01f, -1.50827676e-01f, -5.20937983e-03f, 1.00812271e-01f, -2.15887472e-01f, 2.59823292e-01f,
  1.09607980e-01f, -1.96881548e-01f, 2.06715181e-01f, -3.86347830e-01f, -5.45595407e-01f, -2.51598567e-01f, -4.54313129e-01f, -1.24554299e-01f, -1.39838874e-01f, -1.38987154e-01f,
  -2.16048598e-01f, -7.78950006e-02f, -2.12105170e-01f, 3.26624393e-01f, -6.72385469e-02f, 9.19607058e-02f, 1.55423835e-01f, 2.99702823e-01f, -5.95163032e-02f, 1.30992066e-02f,
  3.64180319e-02f, 6.22168742e-02f, 8.75931010e-02f, 2.64458731e-03f, -3.00823967e-03f, 1.23805488e-02f, 1.08970180e-01f, 5.91008109e-04f, -1.94814000e-02f, -7.65170064e-03f,
  -7.47702178e-03f, -6.07651332e-03f, -1.55073479e-01f, -3.99984606e-02f, -1.26033891e-02f, -2.22299509e-02f, -4.29097600e-02f, -1.37244137e-02f, 8.45296979e-02f, -1.10337034e-01f,
  -4.29025143e-02f, 1.94540229e-02f, -8.69524553e-02f, -9.52341408e-02f, -7.61523694e-02f, 1.35644106e-02f, -1.24645784e-01f, 5.64118288e-02f, -1.86333421e-03f, -1.02722414e-01f,
  -7.11264461e-02f, -4.25655534e-03f, 4.13743866e-04f, 7.26887807e-02f, -8.36541597e-03f, 9.14076045e-02f, 2.68586613e-02f, 6.79083988e-02f, -9.09570009e-02f, -3.12299412e-02f,
  1.91975795e-02f, 4.31554578e-02f, -7.47951493e-02f, -1.29307210e-02f, -1.01863056e-01f, 6.62182132e-03f, -5.22323884e-02f, -2.38951575e-02f, -1.32525682e-01f, -3.58194187e-02f,
  1.11546285e-01f, 4.17631157e-02f, 4.20100801e-02f, -3.30970995e-02f, 1.43150046e-01f, -4.78685275e-02f, 5.91725707e-02f, -4.24573570e-02f, -2.70802546e-02f, -5.44489808e-02f,
  4.83027250e-02f, 3.40922512e-02f, 8.66082087e-02f, -8.12696945e-03f, 9.66723338e-02f, -6.73465654e-02f, -1.28099188e-01f, -6.88249171e-02f, -4.76784036e-02f, -3.32218483e-02f,
  -1.61110200e-02f, 6.88867792e-02f, -7.90658742e-02f, -3.14114466e-02f, 6.78601116e-02f, -1.12641519e-02f, 1.15660898e-01f, 1.12352028e-01f, 5.98315597e-02f, 2.85822302e-02f,
  1.19603097e-01f, 6.63863793e-02f, -9.00253132e-02f, -5.27791642e-02f, -2.86966655e-03f, 6.94291443e-02f, 5.52148744e-03f, 2.57145092e-02f, -5.91614731e-02f, -1.24420673e-02f,
  2.49916404e-01f, 2.11124688e-01f, -1.59996778e-01f, 1.52180210e-01f, 2.69465111e-02f, -6.46524280e-02f, -1.45765513e-01f, 2.79050674e-02f, -3.28921199e-01f, 1.02341965e-01f,
  1.88507691e-01f, 1.11903161e-01f, -5.64485937e-02f, 4.00280327e-01f, 2.87449360e-01f, 4.89737056e-02f, 2.18926013e-01f, -2.31501157e-03f, -3.68694961e-02f, 3.13136548e-01f,
  1.47499576e-01f, 4.61490154e-01f, 1.69968605e-01f, 2.17437655e-01f, 3.60846072e-01f, -7.48526752e-02f, 3.96290779e-01f, -2.90870685e-02f, 2.12373227e-01f, 2.58490652e-01f,
  1.03175439e-01f, 1.83368802e-01f, -1.31482128e-02f, 7.01022744e-02f, 1.17065974e-01f, 1.76394992e-02f, 3.48674282e-02f, 8.53247941e-02f, -1.17096081e-01f, 4.27832194e-02f,
  1.10949166e-02f, 1.19269691e-01f, -5.08882850e-02f, -2.36053523e-02f, -9.39575806e-02f, -1.99405998e-02f, -9.74741876e-02f, -4.51775678e-02f, -1.12994753e-01f, 2.17312649e-02f,
  -1.39957994e-01f, 5.69451824e-02f, -1.01766363e-01f, 2.78709196e-02f, -1.31800752e-02f, 6.10634591e-03f, 2.96636615e-02f, 5.40384948e-02f, 2.88396962e-02f, 4.40324359e-02f,
  2.26641782e-02f, 1.21348323e-02f, 7.55614042e-02f, 4.26956601e-02f, 1.47121213e-02f, 7.02839196e-02f, -3.95262428e-02f, 4.42857556e-02f, -9.48050916e-02f, 1.67892054e-01f,
  -7.97678009e-02f, -5.62165007e-02f, 2.57250108e-02f, -1.38555486e-02f, 6.95149451e-02f, 6.51488686e-03f, 3.21192741e-02f, 9.82444733e-02f, -1.26293361e-01f, -4.62463200e-02f,
  1.32655380e-02f, -3.79708372e-02f, -3.28100622e-02f, -5.39740548e-02f, 9.40809306e-03f, -2.37169191e-02f, 1.10478196e-02f, 6.26739040e-02f, -1.21729337e-01f, -1.09083533e-01f,
  1.83343261e-01f, 2.77772784e-01f, -2.07275338e-03f, -2.55060270e-02f, -8.85457397e-02f, 1.14890346e-02f, 1.14060096e-01f, 1.11849360e-01f, 8.70427713e-02f, 1.34979978e-01f,
  6.23734929e-02f, -3.79745699e-02f, -1.76579431e-02f, -7.08746389e-02f, -1.26109928e-01f, 1.26609698e-01f, 3.73604242e-04f, -7.16456100e-02f, 6.56390414e-02f, 5.73471338e-02f,
  2.46345624e-02f, 8.34120288e-02f, 7.84788206e-02f, 8.91505042e-04f, 7.52257109e-02f, 1.22852243e-01f, -2.21077427e-02f, -8.79268199e-02f, 2.19690558e-02f, 3.08006387e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -7.02826353e-03f, -1.07877471e-01f, 8.45931023e-02f, 6.30302075e-03f, 2.96227243e-02f, 5.15256524e-02f, 3.26319247e-01f, 1.81009650e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -9.87208337e-02f, -9.92103368e-02f, -1.22815572e-01f, -3.01915646e-01f, -4.48197603e-01f, -5.57888485e-02f, -4.77433592e-01f, -1.36283442e-01f, -1.29052222e-01f, -7.56675377e-02f,
  -1.42127767e-01f, 9.82093364e-02f, -2.62904018e-01f, 7.75593445e-02f, -1.96179777e-01f, -3.50326896e-01f, 1.31797567e-01f, -7.65215158e-02f, 2.61646267e-02f, -8.43716413e-02f,
  -9.65579674e-02f, -2.37205420e-02f, 3.12827706e-01f, 1.10568151e-01f, 1.57121390e-01f, -2.26311788e-01f, -2.29980707e-01f, 3.30407590e-01f, 1.88359916e-01f, -1.20977834e-01f,
  -1.14279971e-01f, 3.08486164e-01f, -1.41023859e-01f, 2.64268458e-01f, -1.03804469e-01f, 2.69189626e-01f, 2.12709472e-01f, 2.18060508e-01f, 1.05443150e-01f, -2.20186282e-02f,
  -1.15385018e-02f, 8.21742564e-02f, 7.34704956e-02f, -1.84793409e-03f, -1.48458257e-01f, 4.03896920e-05f, 3.06608379e-02f, 2.67944872e-01f, 4.80192080e-02f, -2.77377460e-02f,
  -2.71183074e-01f, 3.56342107e-01f, -5.21499068e-02f, 3.80238555e-02f, -2.28161260e-01f, -2.23050341e-01f, -9.14792493e-02f, -6.58490360e-02f, 2.25803286e-01f, 1.54746115e-01f,
  1.17674761e-01f, 4.14220840e-01f, -5.32921612e-01f, -4.10120577e-01f, 8.67705718e-02f, 3.96951139e-02f, 2.52700806e-01f, -5.74109629e-02f, 1.86808974e-01f, -7.19120447e-03f,
  -2.82131787e-02f, 9.60449651e-02f, -4.36817966e-02f, -9.03357938e-02f, 2.39637941e-01f, 1.80362865e-01f, -3.70745391e-01f, 4.92247231e-02f, 3.65644276e-01f, -2.29530215e-01f,
  -5.74215576e-02f, 1.91000193e-01f, -4.49326485e-01f, -4.31222394e-02f, 5.64082377e-02f, -2.75791138e-01f, 1.20639138e-01f, 3.34529817e-01f, 2.40790039e-01f, 3.65331322e-01f,
  1.57484919e-01f, -4.97226790e-02f, 5.87503165e-02f, -3.96895140e-01f, -4.46060523e-02f, 6.38654456e-02f, 2.79887378e-01f, -1.15036443e-01f, 1.53472805e-02f, 5.86552657e-02f,
  6.68574870e-03f, -2.50685159e-02f, -3.15380901e-01f, 1.85854822e-01f, -2.50821877e-02f, -3.10061295e-02f, 9.10705999e-02f, 2.04764560e-01f, -1.79086655e-01f, -2.69817293e-01f,
  9.10962895e-02f, -1.02129303e-01f, -6.61994740e-02f, -5.13818152e-02f, 7.23063573e-02f, -1.06085151e-01f, 4.66680042e-02f, 4.49107140e-02f, 1.85633570e-01f, -6.80821016e-02f,
  -2.31729358e-01f, 1.43544331e-01f, 1.49813697e-01f, 3.93672466e-01f, 1.55855075e-01f, 4.29900177e-02f, 3.40853333e-01f, -5.09524494e-02f, -1.50582224e-01f, 9.49099585e-02f,
  -2.51629502e-02f, -1.36623144e-01f, 1.29458709e-02f, 1.07527822e-01f, -1.81866735e-01f, 1.23194270e-01f, -8.61811191e-02f, 4.10589203e-02f, -1.61750615e-01f, -2.31772382e-02f,
  -6.62665442e-02f, -5.56329489e-01f, -1.77554101e-01f, 2.29357570e-01f, -2.77967513e-01f, -1.69480279e-01f, 2.23452911e-01f, 4.62230265e-01f, 9.91886556e-02f, 3.26673657e-01f,
  3.51271063e-01f, -3.36649448e-01f, -3.41762006e-01f, -2.95008272e-01f, 5.43223182e-03f, 2.36028776e-01f, 4.26856905e-01f, 5.68616867e-01f, -1.55378906e-02f, -2.28817165e-02f,
  2.52086937e-01f, -9.99488235e-02f, -5.43260984e-02f, 2.28292182e-01f, 1.77948311e-01f, -9.65096727e-02f, 2.71945089e-01f, 1.73464745e-01f, 5.98517135e-02f, 1.01978578e-01f,
  9.02974457e-02f, 1.95613340e-01f, -1.23005277e-02f, -1.05341434e-01f, 2.12375000e-01f, 2.02999189e-02f, 3.65148708e-02f, -3.50142159e-02f, -1.78934440e-01f, -5.72666191e-02f,
  6.74981177e-02f, 1.20223239e-02f, -1.70137078e-01f, 2.63725460e-01f, -1.62993520e-01f, 3.36416632e-01f, 3.45357060e-01f, -1.80534676e-01f, 3.35352242e-01f, 3.80774736e-02f,
  2.35634893e-01f, -1.69327870e-01f, 1.71671137e-01f, -1.31775841e-01f, -4.04007882e-02f, -6.65432736e-02f, 3.59390266e-02f, -2.44477332e-01f, -1.39276594e-01f, -2.56072674e-02f,
  6.32332563e-02f, 2.54092366e-01f, -5.92339896e-02f, -7.91984126e-02f, -3.79294306e-01f, -8.29224139e-02f, 2.59539723e-01f, -2.70219326e-01f, 5.84788807e-02f, 2.98709184e-01f,
  -1.67327315e-01f, -3.77067998e-02f, 1.45660058e-01f, 1.76476836e-02f, 3.96047592e-01f, 3.94930869e-01f, -3.81041735e-01f, -2.27573179e-02f, -1.45211607e-01f, 3.51672135e-02f,
  2.88572878e-01f, -2.07297489e-01f, 1.74313828e-01f, 9.43850800e-02f, -5.61579764e-02f, -5.58182262e-02f, 5.22434227e-02f, 1.28246322e-01f, -1.01944998e-01f, 3.08741868e-01f,
  7.18308613e-02f, -2.60440595e-02f, 6.67236596e-02f, -3.19258153e-01f, 1.28193602e-01f, -1.48521721e-01f, 1.63153663e-01f, 1.24231495e-01f, 1.07698195e-01f, 2.64508054e-02f,
  7.88146183e-02f, 1.60628900e-01f, 3.05348001e-02f, -1.88754067e-01f, -2.92181551e-01f, -1.35064885e-01f, -1.81838244e-01f, -4.09408435e-02f, 4.77041394e-01f, 2.98513591e-01f,
  -6.36452064e-02f, 2.44739264e-01f, -3.44448149e-01f, -1.28719777e-01f, -1.32294714e-01f, -1.31957546e-01f, 8.97183046e-02f, -2.49529630e-01f, -2.71934986e-01f, -2.75595244e-02f,
  -2.50560433e-01f, 2.39941776e-01f, -3.09411082e-02f, -7.77662173e-02f, -1.93010569e-02f, -1.13201655e-01f, -1.16097935e-01f, 4.05895635e-02f, 4.58516508e-01f, 8.01463202e-02f,
  -1.64516941e-02f, 2.54325002e-01f, -1.12741947e-01f, -4.71415222e-01f, 4.25262272e-01f, -1.52254760e-01f, -2.59350300e-01f, -8.07168037e-02f, -2.33453557e-01f, -3.02712232e-01f,
  -2.44569793e-01f, 9.52459648e-02f, 5.05866349e-01f, -4.38296199e-02f, -9.77825448e-02f, 1.17335342e-01f, 2.85848707e-01f, -1.76481381e-01f, -2.53020436e-01f, 1.36460081e-01f,
  1.44498218e-02f, -1.40571356e-01f, 2.20581815e-02f, -4.52647507e-02f, -2.06508383e-01f, -1.05349660e-01f, -8.02078396e-02f, 1.46586653e-02f, -9.47725028e-02f, -2.64718682e-02f,
  -1.04281805e-01f, -2.51950547e-02f, -3.53743047e-01f, 7.63233304e-02f, 4.63811979e-02f, 3.06050390e-01f, -3.52000713e-01f, 3.30328584e-01f, 3.13162118e-01f, 2.12344706e-01f,
  2.86499500e-01f, -1.11981682e-01f, -1.01599172e-01f, -6.76718503e-02f, -2.83508658e-01f, 1.14170633e-01f, -1.22878820e-01f, 1.42381713e-01f, -3.82444859e-01f, 1.70620292e-01f,
  -8.09640139e-02f, 1.46944731e-01f, 1.09582096e-01f, -1.22253157e-01f, -2.26611391e-01f, 1.00329682e-01f, -3.07888567e-01f, -2.15071633e-01f, -2.49620285e-02f, -2.41950601e-02f,
  -1.03753902e-01f, -7.96501860e-02f, -1.51178285e-01f, 5.16704023e-02f, -2.93608785e-01f, -1.14764392e-01f, 5.25454208e-02f, 1.27627552e-01f, -1.63100064e-01f, 2.70240102e-02f,
  4.75175381e-02f, 2.46925820e-02f, 2.38436431e-01f, -2.66653150e-01f, 1.16870970e-01f, -2.67522156e-01f, -2.87201315e-01f, 2.01694995e-01f, -1.15233362e-01f, 7.68180117e-02f,
  -4.39106822e-01f, 2.93399960e-01f, 1.92112789e-01f, -8.95878114e-03f, 4.76689357e-03f, 9.15281847e-03f, 2.31838837e-01f, -9.59498957e-02f, 2.12597758e-01f, 2.26493016e-01f,
  -8.44498277e-02f, 2.06938013e-01f, 1.50314514e-02f, 1.44033134e-01f, -3.89319330e-01f, -1.43128350e-01f, 4.55901712e-01f, -9.43069831e-02f, 2.93175075e-02f, 2.15527385e-01f,
  -3.05865407e-01f, -1.74104080e-01f, 1.13080665e-01f, -1.27366751e-01f, 7.84692764e-02f, 2.48563677e-01f, 1.28568038e-01f, 3.32764685e-01f, 1.39448920e-03f, -2.02919394e-01f,
  1.99651010e-02f, -2.41573423e-01f, 2.67259508e-01f, -3.20359953e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.25563042e-02f, 1.83483124e-01f, 2.69644558e-01f, -1.33461729e-01f, -2.17416227e-01f, 5.12953162e-01f, 2.17861548e-01f, 5.99914007e-02f, 2.32366279e-01f, -1.22695297e-01f,
  4.07738149e-01f, -5.04990816e-02f, 3.57821792e-01f, 5.03671885e-01f, -1.15252718e-01f, -3.96898799e-02f, 1.34362146e-01f, -1.28920555e-01f, 3.58384609e-01f, -2.07402781e-01f,
  -4.31222320e-01f, -1.34627029e-01f, -1.77480236e-01f, -2.54972577e-01f, 6.72697067e-01f, -1.81427643e-01f, -3.87249231e-01f, 1.28423423e-01f, -3.49320173e-01f, -6.36556745e-02f,
  1.72058403e-01f, 1.80383548e-01f, 2.97192007e-01f, -3.68576422e-02f, 1.01288185e-01f, -9.69292223e-02f, -4.33219373e-01f, 6.84573799e-02f, -3.38986784e-01f, 1.35503486e-01f,
  2.91995019e-01f, 1.83214605e-01f, 2.21736372e-01f, 2.84270823e-01f, 2.19765231e-01f, 2.60583758e-01f, -2.47143477e-01f, -3.23565871e-01f, -2.78933048e-01f, 4.93059345e-02f,
  3.82903934e-01f, -3.05311859e-01f, 1.67798311e-01f, 2.44744003e-01f, 2.50258565e-01f, 5.14529109e-01f, 8.09455216e-02f, -8.99698213e-02f, -1.09645156e-02f, 5.27767360e-01f,
  2.55109191e-01f, -2.39779726e-02f, 6.06653452e-01f, 2.96438485e-01f, 1.40139341e-01f, 3.19516003e-01f, 3.06724519e-01f, 4.24814187e-02f, 3.07059795e-01f, 5.19600995e-02f,
  -2.28305146e-01f, -2.89474018e-02f, 1.59950450e-01f, 1.42777741e-01f, 1.36990950e-01f, 2.17122301e-01f, -3.75104129e-01f, 8.38814676e-02f, -1.11938328e-01f, -1.63541272e-01f,
  1.35108367e-01f, 3.74237090e-01f, -4.41803813e-01f, 4.43891026e-02f, 4.47057396e-01f, -1.04805315e-02f, 2.65192032e-01f, -2.48008501e-02f, -8.31397623e-02f, -2.29338869e-01f,
  -3.15976173e-01f, 5.09172440e-01f, 2.68508494e-01f, 3.75487655e-01f, -3.34856093e-01f, 4.40621644e-01f, -1.63937509e-01f, 2.10671961e-01f, 7.90093243e-02f, -2.31380850e-01f,
  1.63913056e-01f, 8.58458355e-02f, 3.92277449e-01f, -6.09736741e-02f, 9.43705589e-02f, -7.98113644e-02f, 1.24116801e-01f, -1.91484764e-01f, -1.32690445e-01f, 1.85159259e-02f,
  2.98643321e-01f, 3.31000201e-02f, 2.73598075e-01f, -1.29981875e-01f, 1.01062886e-01f, -1.77317917e-01f, -5.01241803e-01f, -3.62708360e-01f, -2.65159249e-01f, -6.50877357e-01f,
  3.28040808e-01f, -3.34047556e-01f, -3.96461874e-01f, -1.96912780e-01f, -1.29498973e-01f, 5.33354171e-02f, -4.22414720e-01f, 1.01007350e-01f, 2.82401919e-01f, 1.79529786e-01f,
  6.52978942e-02f, 1.04378924e-01f, -3.45213115e-02f, 1.09665789e-01f, 1.75636396e-01f, 8.08530748e-02f, 1.58814937e-01f, 3.39851975e-01f, 9.88012296e-04f, 1.23787045e-01f,
  4.00566995e-01f, 1.44101288e-02f, -2.54875273e-01f, -1.30840510e-01f, -2.29094565e-01f, -2.92964637e-01f, 1.16877235e-01f, -7.05039361e-03f, 3.07728112e-01f, 3.13764125e-01f,
  9.48526114e-02f, 6.18302561e-02f, -4.29704301e-02f, -1.30123511e-01f, 2.13122338e-01f, 2.11969048e-01f, 6.15153909e-01f, 3.53000432e-01f, 5.92741370e-01f, 2.51947660e-02f,
  -1.98259111e-02f, 2.11475194e-01f, -1.20985381e-01f, 5.07257096e-02f, 1.11308418e-01f, 1.12944372e-01f, 3.41348983e-02f, 3.42317000e-02f, -1.16658911e-01f, -7.78173655e-03f,
  1.63601071e-01f, 1.30477890e-01f, 2.51417518e-01f, -3.65271121e-01f, -1.62395701e-01f, 1.96778968e-01f, 6.55008182e-02f, -4.42075133e-01f, -1.39515430e-01f, 1.31879654e-03f,
  1.85536519e-01f, -1.30624086e-01f, -2.86326587e-01f, -3.38750392e-01f, -2.56780654e-01f, 5.23176432e-01f, 5.52363217e-01f, 1.43890560e-01f, 1.87369227e-01f, 4.09159243e-01f,
  2.52298340e-02f, 2.10920423e-02f, -1.28766745e-01f, 4.19952840e-01f, 1.39752865e-01f, 1.74322277e-01f, 3.95097435e-01f, 2.76684344e-01f, 5.58806002e-01f, 2.01344699e-01f,
  1.71831816e-01f, -8.52972418e-02f, 4.51890767e-01f, 1.66011840e-01f, -3.37478042e-01f, -6.57844901e-01f, 5.28426349e-01f, 6.02767110e-01f, -1.89372212e-01f, 1.41621977e-01f,
  -2.91624069e-01f, 3.53843331e-01f, -1.40821368e-01f, -3.02710712e-01f, -3.08564544e-01f, -4.89864320e-01f, 3.24424803e-01f, 4.29131866e-01f, 1.84540004e-01f, -2.62842834e-01f,
  -4.63117689e-01f, 1.95690542e-01f, -4.88649935e-01f, 1.35661334e-01f, -2.40194518e-02f, 3.97050351e-01f, 3.27532738e-01f, 1.17087103e-01f, 4.14531589e-01f, -1.67353481e-01f,
  1.14349693e-01f, 2.23566622e-01f, 2.76010111e-02f, 2.98170209e-01f, 2.74625123e-01f, 3.27763826e-01f, -3.86876434e-01f, -1.64855778e-01f, -3.48212123e-01f, 8.99998620e-02f,
  3.08506712e-02f, 3.82113338e-01f, -5.42235553e-01f, 4.24097955e-01f, 4.04782981e-01f, 1.93499342e-01f, 2.96987556e-02f, 9.00290441e-03f, 2.78823581e-02f, 4.10204351e-01f,
  -4.89897057e-02f, 6.93831369e-02f, 1.62576541e-01f, 2.51319021e-01f, -4.09522682e-01f, 3.91605824e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.55010360e-01f, 1.89652696e-01f, 2.08809778e-01f, 2.24203885e-01f, 1.95298955e-01f, 1.07552022e-01f, 3.68834674e-01f, 2.84190089e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.31021738e-01f, -4.35830653e-02f, -4.44099456e-02f, -1.16828054e-01f, -7.79682994e-02f, -7.36841336e-02f, -2.67862409e-01f, -1.55314058e-01f, 2.47464597e-01f, 1.38678700e-01f,
  -9.34718996e-02f, -6.49232864e-02f, -2.65450310e-02f, 2.69468367e-01f, -2.90454328e-01f, 4.58581895e-02f, 2.32789099e-01f, 1.71941504e-01f, -6.17465749e-02f, -1.96308672e-01f,
  1.50330558e-01f, -1.07811369e-01f, -1.21734053e-01f, -3.64436954e-01f, 8.45939759e-03f, 2.24181071e-01f, -1.55797780e-01f, -3.40021938e-01f, 3.26892406e-01f, 3.54294002e-01f,
  -2.22855672e-01f, 1.86282083e-01f, 7.91525394e-02f, -1.05004922e-01f, -4.55219857e-02f, -9.30491909e-02f, -6.44014701e-02f, -7.29404315e-02f, -1.82922259e-01f, -1.36108682e-01f,
  -9.03635994e-02f, 8.53321701e-02f, -9.35500860e-02f, -1.31362630e-02f, -3.79955232e-01f, 3.91606539e-01f, -2.02144474e-01f, -9.03079659e-02f, 4.26396012e-01f, 2.99082518e-01f,
  1.10257752e-01f, -3.28758031e-01f, -8.85145664e-02f, 1.06044695e-01f, -1.34752631e-01f, -2.82637216e-02f, -2.73303032e-01f, -2.97233164e-01f, 5.06401286e-02f, -1.57227650e-01f,
  2.34887898e-01f, 1.07246868e-01f, -4.61244322e-02f, 2.59195894e-01f, -1.71687812e-01f, 3.93184051e-02f, -1.64624915e-01f, -7.27899596e-02f, -3.19827944e-02f, -2.69057602e-01f,
  -1.14397310e-01f, -5.28404787e-02f, -1.91795409e-01f, -1.62550971e-01f, -2.28780955e-01f, -1.13385431e-01f, 1.09752536e-01f, -8.76757354e-02f, 2.39227921e-01f, 1.57470137e-01f,
  6.13211915e-02f, 1.27143845e-01f, 3.61310661e-01f, -2.03215063e-01f, -2.03365773e-01f, -1.29072934e-01f, -1.22549117e-01f, 4.15941060e-01f, -3.91551614e-01f, -1.42706141e-01f,
  1.11308612e-01f, -2.02518582e-01f, 5.07789366e-02f, 1.48218080e-01f, -3.30795012e-02f, 2.70743728e-01f, 2.20163185e-02f, -1.46401465e-01f, -1.13558695e-01f, -6.94190189e-02f,
  -8.49018469e-02f, 2.69932956e-01f, -1.51846498e-01f, 1.12195879e-01f, -3.24111819e-01f, 1.09090924e-01f, 2.88885444e-01f, -5.52744530e-02f, 9.83937159e-02f, 2.55072474e-01f,
  -2.15307042e-01f, -2.37482458e-01f, 5.37417591e-01f, -7.63774738e-02f, 4.70225140e-02f, -8.55124667e-02f, -1.66557059e-01f, 3.28857809e-01f, 4.77809198e-02f, -1.50520980e-01f,
  -3.33131552e-02f, -2.75238812e-01f, 8.78862739e-02f, 1.90069154e-01f, 6.74332082e-02f, -2.21802205e-01f, 1.43591017e-02f, 2.53961772e-01f, -1.61870763e-01f, -1.01955839e-01f,
  1.03724435e-01f, -1.23132989e-01f, -8.82014707e-02f, 1.63866296e-01f, 8.10232386e-02f, 7.45808333e-02f, -1.17365733e-01f, 1.09187923e-01f, 2.28480354e-01f, 2.23593507e-02f,
  3.36625755e-01f, -1.69042736e-01f, 1.65733680e-01f, 1.72363684e-01f, -1.04979292e-01f, -5.21572866e-02f, -3.40895839e-02f, 1.25514194e-01f, -1.49786368e-01f, 1.71945840e-02f,
  1.57435894e-01f, -1.11119643e-01f, 1.80067837e-01f, 1.71442509e-01f, 1.95014790e-01f, -6.77674487e-02f, -8.50639343e-02f, -2.31982261e-01f, -4.61634994e-01f, -1.00806914e-01f,
  -2.92462241e-02f, -1.76826239e-01f, -1.98953047e-01f, 6.80214316e-02f, 1.34275720e-01f, -1.31222889e-01f, 3.14256072e-01f, 1.66018307e-01f, -2.94160068e-01f, -2.42196277e-01f,
  -2.71602213e-01f, -1.15938008e-01f, -2.13682517e-01f, -1.94090098e-01f, 2.27518871e-01f, 4.68272790e-02f, -5.44986486e-01f, 7.09026456e-02f, -1.17810503e-01f, 1.82709694e-01f,
  -2.55582601e-01f, 3.00101172e-02f, -4.08168882e-02f, 4.18639511e-01f, -1.14732027e-01f, -9.03030187e-02f, -1.26486465e-01f, -6.74329326e-03f, -2.76310265e-01f, -1.06868111e-01f,
  2.81322122e-01f, 1.68364197e-01f, -8.57692882e-02f, 3.53237763e-02f, -8.53064731e-02f, 3.41210276e-01f, 1.35758162e-01f, 8.30838978e-02f, 2.88792014e-01f, 1.89661644e-02f,
  -2.30535388e-01f, -1.02841236e-01f, 1.22490535e-02f, 2.21548334e-01f, -5.06278694e-01f, -3.93218249e-02f, 2.15997890e-01f, -3.61164436e-02f, -4.37187463e-01f, 2.79764175e-01f,
  -7.57742822e-02f, 2.53484491e-02f, -2.25523040e-01f, 5.75764216e-02f, -1.66779518e-01f, 2.83636540e-01f, 1.34054556e-01f, -3.07861835e-01f, 1.12666771e-01f, 2.96385556e-01f,
  2.56979987e-02f, -1.98020890e-01f, 3.00922483e-01f, -1.89724620e-02f, -1.50991557e-02f, 5.19877635e-02f, -9.88396257e-02f, -2.50577956e-01f, -2.00600992e-03f, 8.54594335e-02f,
  -5.23140244e-02f, 3.83945629e-02f, -1.07512861e-01f, -8.94266665e-02f, 6.05152771e-02f, -1.40352130e-01f, 1.10037006e-01f, -1.00860626e-01f, 1.59262195e-01f, 1.27128229e-01f,
  1.84407070e-01f, 1.20382883e-01f, 3.56845319e-01f, -2.09052667e-01f, -2.46970534e-01f, 1.73595011e-01f, 1.96597755e-01f, 3.40785652e-01f, -3.36243689e-01f, 2.70869941e-01f,
  1.27924636e-01f, -3.12185645e-01f, 5.27566634e-02f, -8.41515958e-02f, 1.22866109e-02f, 1.22871913e-01f, 2.51642521e-02f, -2.14056969e-02f, 3.35028440e-01f, -3.34148645e-01f,
  -2.04942048e-01f, -1.01899788e-01f, -1.24378070e-01f, -9.19338837e-02f, -7.55090043e-02f, -8.68633613e-02f, 3.26158814e-02f, -1.13606371e-01f, -6.29260764e-02f, 2.03570321e-01f,
  1.83653846e-01f, 1.19656213e-01f, 2.51604527e-01f, 1.44197553e-01f, 2.19738737e-01f, -2.07801342e-01f, 2.30718274e-02f, -7.24136531e-02f, -2.49278560e-01f, -8.89899060e-02f,
  -1.52589306e-01f, 2.79216647e-01f, -1.08748795e-02f, -3.48806083e-01f, 2.23273292e-01f, 5.82283502e-03f, -1.49964675e-01f, -1.10810123e-01f, -3.49426195e-02f, 3.36419642e-01f,
  2.21973076e-01f, -2.83591915e-02f, -9.93546918e-02f, -2.75945097e-01f, -2.26221997e-02f, -2.72497147e-01f, -9.63382702e-03f, -3.71291906e-01f, -2.42034882e-01f, -6.77416399e-02f,
  -1.88952893e-01f, 1.61004379e-01f, 1.13659702e-01f, 1.01434492e-01f, 5.94530813e-02f, 2.50111848e-01f, -8.93083885e-02f, -2.47399285e-02f, 2.55001873e-01f, -1.48534551e-01f,
  -3.28838646e-01f, 7.79403746e-02f, -3.00709754e-01f, -2.57641584e-01f, -7.67137036e-02f, -1.07632473e-01f, 1.38444930e-01f, 8.99044871e-02f, 1.34644657e-01f, -2.20764697e-01f,
  -6.70393705e-02f, -1.93005838e-02f, -1.62108231e-03f, -1.38116502e-06f, 5.79170510e-02f, 3.86614837e-02f, -4.77598893e-04f, -2.18895249e-04f, -1.75033808e-02f, -2.09482372e-01f,
  -5.01456857e-02f, 1.86565891e-01f, 1.91669598e-01f, -4.42307025e-01f, 3.05971801e-01f, -1.20578103e-01f, -3.70772749e-01f, -1.45844400e-01f, -7.15390146e-02f, 2.20828727e-01f,
  -1.72509164e-01f, -1.14818983e-01f, 5.67620695e-02f, 1.48671195e-01f, 1.94676206e-01f, 1.92330647e-02f, 1.80507496e-01f, 3.83411586e-01f, -1.42232239e-01f, -2.12969363e-01f,
  -2.20874935e-01f, -1.88068300e-01f, 1.05315916e-01f, -4.39211316e-02f, 2.38836825e-01f, -2.60571122e-01f, -1.16666123e-01f, 2.96174902e-02f, -2.49973625e-01f, 9.52701364e-03f,
  4.87216637e-02f, -3.64085077e-03f, 1.48786277e-01f, -1.35081455e-01f, -1.86550900e-01f, 1.98208958e-01f, -1.60402551e-01f, -3.73054408e-02f, 4.38230217e-01f, 7.38686919e-02f,
  -3.50938886e-02f, -1.12564266e-01f, 6.03053607e-02f, -1.48443459e-02f, -1.62388131e-01f, -3.34595740e-01f, 1.19990170e-01f, 1.41309306e-01f, -1.19196460e-01f, 5.32453917e-02f,
  4.41120505e-01f, -1.51107863e-01f, -2.27344498e-01f, -1.71815589e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.45335430e-01f, 1.79649934e-01f, 1.84323668e-01f, 5.84491603e-02f, 2.17406288e-01f, 6.28782153e-01f, 1.76030800e-01f, 3.45676601e-01f, 2.30482742e-01f, 4.89359319e-01f,
  5.42767823e-01f, 3.44892532e-01f, 6.37479126e-01f, -4.11400825e-01f, -2.39712179e-01f, -5.85200846e-01f, 1.70593157e-01f, -6.41478062e-01f, -4.67461735e-01f, 3.81108642e-01f,
  -1.53928334e-02f, 1.34103462e-01f, 5.41185260e-01f, -5.34461856e-01f, 8.83887231e-01f, 3.52011323e-01f, 4.01097506e-01f, 6.75206363e-01f, -3.11535716e-01f, -1.11474589e-01f,
  4.80129480e-01f, -1.35978088e-01f, -4.85571055e-03f, 2.84872428e-02f, 1.01469852e-01f, 7.36754090e-02f, 4.87426184e-02f, 7.84976967e-03f, 1.05686612e-01f, 5.28316945e-02f,
  4.26735468e-02f, 3.00834104e-02f, 3.21130129e-03f, 5.30138202e-02f, -2.57232040e-02f, -2.68707052e-03f, 5.12763634e-02f, 1.43310716e-02f, -8.26269984e-02f, 5.59875146e-02f,
  1.54508902e-02f, -4.09900695e-02f, 3.32557522e-02f, -3.27554047e-02f, -7.97274932e-02f, 6.94123656e-02f, -6.95903646e-03f, -3.13113704e-02f, -1.28883803e-02f, 2.79460866e-02f,
  -7.15891123e-02f, -7.60823023e-04f, -4.36287792e-03f, -4.83543798e-02f, 7.05137402e-02f, -6.42818809e-02f, 1.48928046e-01f, 2.81437278e-01f, -2.24776596e-01f, 1.50240120e-02f,
  2.29312241e-01f, 3.19892406e-01f, 3.11688751e-01f, 4.53139663e-01f, 3.16282988e-01f, 3.31721008e-01f, -5.49737632e-01f, 9.66736615e-01f, -5.70054412e-01f, 4.16502535e-01f,
  5.14046788e-01f, 5.02475619e-01f, -5.65221190e-01f, -9.84334499e-02f, 4.00709867e-01f, -2.34231070e-01f, -5.59979737e-01f, -5.30664384e-01f, -4.58592139e-02f, -3.93598318e-01f,
  3.46810997e-01f, 1.55381188e-02f, 3.67326707e-01f, 8.29415083e-01f, 5.30960083e-01f, 5.36132932e-01f, -1.08139314e-01f, 3.47479016e-01f, 3.42584751e-03f, 3.76847088e-01f,
  2.23437294e-01f, -6.87431991e-02f, 6.40835226e-01f, 4.10179943e-01f, 4.51034270e-02f, -2.05164656e-01f, 2.47640675e-03f, -4.61119674e-02f, -7.93767452e-01f, 6.27011299e-01f,
  2.69660532e-01f, 3.44231457e-01f, -1.47921816e-01f, 3.92711997e-01f, -1.32361531e-01f, 2.96140581e-01f, -5.78544773e-02f, -3.56749535e-01f, -5.40719628e-01f, 6.83535635e-01f,
  2.40509789e-02f, -4.06820893e-01f, -1.28796846e-01f, 3.23331982e-01f, -2.33099192e-01f, 3.42956275e-01f, 1.05818713e+00f, 3.51649553e-01f, 2.71155924e-01f, 3.70104522e-01f,
  5.59014857e-01f, -3.82042527e-01f, -1.12722047e-01f, 1.53213769e-01f, 6.24536537e-02f, 4.56305370e-02f, 4.56680730e-02f, 1.66690648e-01f, 3.66427228e-02f, 9.10489336e-02f,
  1.43843889e-01f, -4.06986564e-01f, 4.72720951e-01f, 4.38231558e-01f, 3.20842266e-01f, 2.12592870e-01f, 6.81515455e-01f, -3.59645337e-01f, -4.38437797e-02f, -4.91371714e-02f,
  -7.08135739e-02f, 2.79204130e-01f, -1.02005675e-01f, 1.02676666e+00f, 4.68336582e-01f, -5.45443773e-01f, 8.99614513e-01f, 1.88591048e-01f, -3.25132966e-01f, 3.50947738e-01f,
  4.94918786e-02f, 1.43339440e-01f, 6.66510224e-01f, 2.94384181e-01f, -2.21359823e-02f, 1.17595971e-01f, 3.20664704e-01f, 2.18025059e-01f, 5.62324405e-01f, -4.44056571e-01f,
  -1.60273582e-01f, 3.87568653e-01f, -5.38769007e-01f, -2.76189178e-01f, 5.59760034e-01f, 5.36311716e-02f, -4.58442807e-01f, 3.55913788e-01f, -2.54760742e-01f, 2.89671361e-01f,
  6.85379803e-02f, -4.83479381e-01f, -5.27793646e-01f, 5.18511713e-01f, 5.45963526e-01f, 2.54582584e-01f, -3.91372561e-01f, 2.97742695e-01f, 5.13338923e-01f, -1.90533787e-01f,
  -2.58569140e-02f, -4.55377579e-01f, 2.68227756e-01f, 1.00616841e-02f, -9.96131748e-02f, 4.36175436e-01f, 1.26588032e-01f, 4.29044455e-01f, -4.18783091e-02f, 2.79653162e-01f,
  -4.71368462e-01f, 3.85681599e-01f, 5.17225564e-01f, 3.60044837e-01f, 2.28555039e-01f, -5.54175000e-04f, 5.50644577e-01f, 5.13436086e-02f, -4.15183641e-02f, 2.02721760e-01f,
  5.75495124e-01f, -5.81195116e-01f, -6.67638540e-01f, 4.66286004e-01f, 4.15813565e-01f, 5.89271545e-01f, -1.76658273e-01f, -4.16195653e-02f, 9.95413482e-01f, 4.12792340e-02f,
  -6.29038140e-02f, -4.15714383e-01f, 1.10981882e-01f, 7.88589001e-01f, 5.00370003e-03f, -4.65443619e-02f, -6.32794976e-01f, 1.86660483e-01f, 2.59491265e-01f, 2.14003539e-03f,
  4.20855641e-01f, 3.95077467e-01f, -2.05201260e-03f, -1.04247779e-01f, -3.68383676e-01f, -1.99575871e-01f, -1.55408487e-01f, -4.05514210e-01f, 3.82078409e-01f, 1.76393002e-01f,
  -7.40038514e-01f, -8.52194130e-02f, -1.62747260e-02f, 5.96584380e-01f, -4.42990035e-01f, -3.53621989e-02f, 1.62128538e-01f, 4.87209827e-01f, 6.49954379e-01f, 2.39772890e-02f,
  -8.86050388e-02f, 9.45865214e-02f, -1.04426913e-01f, -5.58058061e-02f, 8.37521434e-01f, 3.88978690e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.40800011e-01f, 1.64549462e-02f, 3.16617727e-01f, 4.18041974e-01f, 2.82064259e-01f, 2.70554513e-01f, 1.62145078e-01f, 2.97626525e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.78271347e-01f, -2.42080405e-01f, -2.38434762e-01f, -1.86816826e-01f, -1.07857864e-02f, -1.73803687e-01f, 2.46631488e-01f, -2.97027171e-01f, -2.65159845e-01f, -7.00975731e-02f,
  1.51236489e-01f, 1.12997234e-01f, 3.58183414e-01f, 2.87639201e-01f, 2.12807283e-01f, 3.58202636e-01f, 5.48482955e-01f, -3.22669744e-01f, -3.34792018e-01f, 5.34759574e-02f,
  2.41402820e-01f, -3.39988589e-01f, -3.10520023e-01f, 2.94075519e-01f, -7.08647072e-01f, -8.74641538e-02f, 1.22974418e-01f, -7.20132291e-01f, 2.73924470e-01f, -8.31421614e-01f,
  5.36129832e-01f, -7.37248778e-01f, 3.13915282e-01f, 3.70933831e-01f, 1.74627364e-01f, 1.21072710e-01f, -1.45083934e-01f, 4.11237270e-01f, 1.80061296e-01f, 6.95263147e-02f,
  3.63152832e-01f, -4.24807072e-01f, 2.79882699e-01f, -8.33237469e-02f, -5.00729561e-01f, -1.60263970e-01f, 3.42905968e-01f, 1.14374317e-01f, 4.57473427e-01f, 3.73271346e-01f,
  5.35461128e-01f, 4.47429776e-01f, -5.62902570e-01f, -2.96613932e-01f, 4.54793960e-01f, -5.27169824e-01f, 1.29486620e-01f, 3.91361639e-02f, -8.01496923e-01f, -6.79933190e-01f,
  1.32772103e-01f, -4.42324460e-01f, 5.47139823e-01f, -6.41615363e-03f, 1.46782413e-01f, -2.55604237e-01f, -2.06715852e-01f, 1.23468913e-01f, -2.11723462e-01f, -5.79574071e-02f,
  2.40821660e-01f, -3.92321259e-01f, -1.08739890e-01f, -3.43833864e-01f, -2.26643458e-01f, 1.28104731e-01f, -4.86557156e-01f, -2.74167918e-02f, 2.33644396e-01f, -2.22190365e-01f,
  2.70673394e-01f, -3.80253017e-01f, 3.39423448e-01f, -2.00764850e-01f, -4.83987033e-01f, -2.85567045e-01f, 1.79655552e-01f, 3.72140795e-01f, 5.19041657e-01f, -5.16382046e-02f,
  -4.82839882e-01f, -8.84770036e-01f, -5.14176011e-01f, 3.59172285e-01f, -4.97429460e-01f, 8.63317475e-02f, -2.48970821e-01f, 4.14356649e-01f, 2.63971183e-02f, -7.50299990e-02f,
  7.28258938e-02f, 8.13224260e-03f, -6.26422092e-02f, -4.65047538e-01f, -2.70633847e-01f, 7.80589953e-02f, 2.20120594e-01f, -3.20073098e-01f, 2.93283522e-01f, 4.67012256e-01f,
  5.80315709e-01f, -5.13618529e-01f, -4.85446274e-01f, -4.77767259e-01f, -5.60393810e-01f, 3.87871504e-01f, -1.52132139e-01f, 5.66642344e-01f, -4.11808103e-01f, 2.38513276e-01f,
  -7.34349668e-01f, 9.35032906e-04f, -5.45494139e-01f, -6.09373868e-01f, 4.63675827e-01f, 6.15702868e-02f, -4.61895317e-01f, -5.55921376e-01f, -5.76418817e-01f, -1.71459749e-01f,
  7.38804489e-02f, 2.94667393e-01f, -1.76365465e-01f, 1.63804218e-01f, 2.07530677e-01f, 4.69241172e-01f, -4.57130969e-02f, -2.44290873e-01f, -3.34081918e-01f, 2.32152209e-01f,
  7.85655528e-02f, 1.60730228e-01f, 1.57312304e-01f, -4.78967100e-01f, -3.30274612e-01f, -3.59007537e-01f, 1.63370356e-01f, -1.33696198e-01f, 6.22211039e-01f, 4.15516376e-01f,
  -1.04675561e-01f, 4.77499127e-01f, -8.38458300e-01f, 2.33734585e-02f, 7.36997962e-01f, 7.67274722e-02f, 2.24215500e-02f, 5.37252761e-02f, -3.01947981e-01f, -5.30281365e-01f,
  2.52134025e-01f, -2.02572048e-01f, 1.66737959e-01f, -1.28286868e-01f, 2.01778769e-01f, 3.07434816e-02f, -4.21863526e-01f, 1.62719339e-01f, 2.02478260e-01f, 3.12615842e-01f,
  -2.71180093e-01f, 1.32143304e-01f, -2.75461078e-01f, 4.30457264e-01f, 4.09119248e-01f, 4.94142830e-01f, -6.02098048e-01f, 4.49831545e-01f, -9.45660695e-02f, 3.89937311e-01f,
  8.97684544e-02f, 2.81809038e-03f, -3.24922740e-01f, -4.29083943e-01f, -4.97662097e-01f, 7.25850090e-02f, -1.30781857e-03f, 5.06523132e-01f, -1.62119508e-01f, -5.78908145e-01f,
  4.37174410e-01f, 5.80619797e-02f, -6.01197919e-03f, 1.81766003e-01f, -1.12674743e-01f, 2.47760504e-01f, 7.75723681e-02f, 3.40553552e-01f, -3.27609807e-01f, -2.50215024e-01f,
  2.32234206e-02f, 3.00341308e-01f, 5.22747815e-01f, 2.76607782e-01f, -7.70657301e-01f, -3.89897853e-01f, -3.61741364e-01f, -5.31938195e-01f, -4.28089529e-01f, 4.18853611e-01f,
  -2.59497255e-01f, -1.69666454e-01f, -3.62919271e-01f, 3.43748480e-01f, 4.85932827e-01f, -2.05745101e-01f, -1.18655927e-01f, 1.52288422e-01f, -2.25971956e-02f, 4.48574781e-01f,
  -8.76605630e-01f, 5.69123924e-01f, -4.63936776e-01f, -2.25720573e-02f, 1.76034346e-01f, 1.59965426e-01f, -1.56984746e-01f, 2.59289086e-01f, -1.74423486e-01f, -3.05517495e-01f,
  -3.44081640e-01f, 2.69559711e-01f, 2.01805800e-01f, -4.72753942e-02f, 2.78764218e-01f, 2.92123333e-02f, 2.37883046e-01f, -4.51063454e-01f, -5.05399585e-01f, -1.75877400e-02f,
  4.56062645e-01f, -4.38834615e-02f, -5.23114204e-01f, 4.03827399e-01f, 4.70627874e-01f, -3.80692571e-01f, -1.69411466e-01f, 3.19396734e-01f, 4.74874377e-01f, -6.70451224e-02f,
  -6.74375147e-02f, -5.30129671e-01f, 3.49490672e-01f, -4.91918206e-01f, -5.79673588e-01f, -6.54719055e-01f, -4.06752855e-01f, -1.19899757e-01f, 1.97605435e-02f, -1.26356274e-01f,
  2.00267911e-01f, -8.99362713e-02f, -2.14152947e-01f, 1.47276625e-01f, -3.20423633e-01f, -4.27547008e-01f, -1.12123758e-01f, -2.77993470e-01f, 3.53028089e-01f, -1.52829573e-01f,
  -4.15612668e-01f, 3.37300479e-01f, 1.03282809e-01f, 4.48495269e-01f, -1.85416430e-01f, -3.26124996e-01f, 2.64127314e-01f, -6.06125817e-02f, 2.81675726e-01f, -3.95826101e-01f,
  4.10891294e-01f, -2.17324514e-02f, -5.59798241e-01f, 1.56809520e-02f, -7.28521109e-01f, -3.15386325e-01f, 9.52539146e-02f, 4.15531635e-01f, 2.99176753e-01f, 1.92866609e-01f,
  -3.45304221e-01f, -2.99984813e-01f, -5.39105944e-02f, 1.22859841e-02f, 2.17677757e-01f, -1.36135340e-01f, 1.14410259e-01f, 1.42101511e-01f, 2.32952107e-02f, 1.75268218e-01f,
  4.52423483e-01f, 6.45804703e-01f, -5.28105140e-01f, 7.99741030e-01f, -4.28338736e-01f, -5.74343324e-01f, 4.98010546e-01f, -4.80342865e-01f, -6.20894551e-01f, -4.39683259e-01f,
  -4.77795720e-01f, 5.56617737e-01f, 2.48502880e-01f, -1.04607500e-01f, 5.25381148e-01f, -1.40674070e-01f, -6.75628364e-01f, -5.17878234e-01f, -2.08189592e-01f, -1.74363330e-01f,
  3.56283784e-01f, 4.78567481e-02f, 1.20734788e-01f, -3.07533562e-01f, 2.50092804e-01f, 2.01038808e-01f, 2.34731898e-01f, 1.72048882e-01f, 4.72469144e-02f, 6.33694679e-02f,
  2.65756607e-01f, -3.95719744e-02f, 3.44282389e-01f, -4.42647249e-01f, -1.47558495e-01f, -1.62291437e-01f, 3.09159905e-01f, 3.94472808e-01f, 5.95505238e-01f, 1.47012144e-01f,
  5.37586570e-01f, -3.19009066e-01f, 3.78364414e-01f, 3.91614169e-01f, -6.02534294e-01f, -3.94969955e-02f, -4.27752793e-01f, -2.01851144e-01f, 1.04353009e-02f, 6.53004348e-01f,
  -2.54223347e-01f, 5.91966689e-01f, 2.84574002e-01f, 8.45256969e-02f, -7.50337467e-02f, -4.05768692e-01f, -4.02042478e-01f, -5.15510023e-01f, 9.66674015e-02f, 3.35338473e-01f,
  1.52946666e-01f, -6.86743036e-02f, -3.39043230e-01f, -5.16841352e-01f, 5.73036671e-01f, 1.20464481e-01f, 5.69972217e-01f, -4.18551236e-01f, 2.05730483e-01f, 3.22315931e-01f,
  1.77757561e-01f, -2.27108583e-01f, -2.92995423e-01f, 3.29219550e-01f, -1.07429266e-01f, -4.14857388e-01f, -9.17196274e-01f, -4.14574184e-02f, 2.03638956e-01f, 5.29490590e-01f,
  -5.89895248e-01f, -4.62008566e-01f, -8.24235260e-01f, 5.50995708e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.51955053e-01f, -9.47837308e-02f, 4.25694212e-02f, 1.41147092e-01f, -9.48982537e-02f, -1.39885247e-01f, 2.32559443e-02f, -5.53254336e-02f, -3.39771919e-02f, -4.79228375e-03f,
  -8.01800489e-02f, -1.94959268e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    