/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.43537730e-01f, 1.71684265e-01f, 3.14967424e-01f, -1.32385409e-02f, 1.23881400e-01f, 2.79686481e-01f, 3.01143765e-01f, 4.41753007e-02f, -1.03873899e-02f, 1.60213158e-01f,
  8.00046474e-02f, -6.05031289e-03f, 1.69134900e-01f, 1.01832502e-01f, 1.72629699e-01f, 1.16263539e-01f, -1.01061873e-01f, 1.71171203e-02f, 3.14575881e-01f, 2.15410814e-01f,
  -4.12034765e-02f, -3.95732969e-02f, -5.38802147e-02f, 2.30716206e-02f, -1.12261996e-01f, -5.54300211e-02f, -8.75338241e-02f, -6.65300712e-02f, -4.33069505e-02f, -2.94719547e-01f,
  3.14872116e-01f, 1.33309200e-01f, 1.49950206e-01f, 3.17459814e-02f, 1.33963838e-01f, 2.11560234e-01f, 2.49675512e-01f, 2.01677829e-01f, 1.87365040e-01f, 4.33559641e-02f,
  1.25175491e-01f, 1.15955539e-01f, 1.57461703e-01f, 1.01709619e-01f, 1.27164930e-01f, 1.67061642e-01f, -3.89968907e-03f, 8.76774639e-03f, 2.04752475e-01f, 1.27841964e-01f,
  9.61229354e-02f, 1.32377818e-01f, 1.20006524e-01f, 2.03032881e-01f, 1.57935232e-01f, 2.48666350e-02f, 1.44816458e-01f, -3.81019749e-02f, 8.29912946e-02f, 5.09194136e-02f,
  4.75380383e-02f, -1.34712189e-01f, 1.26478085e-02f, -1.15944014e-03f, 1.87812583e-03f, 5.55017069e-02f, -1.87346816e-01f, -1.14997610e-01f, -1.26520455e-01f, -4.83663380e-02f,
  -6.67097494e-02f, -5.43676242e-02f, 1.48216332e-03f, -1.10582113e-01f, -4.97635528e-02f, 1.07238524e-01f, 9.72322971e-02f, -2.84770783e-02f, -6.36664480e-02f, -6.99518695e-02f,
  -1.01045534e-01f, -1.24016188e-01f, -1.13348007e-01f, -3.85104977e-02f, -6.24678433e-02f, -1.06281623e-01f, -6.58675432e-02f, -6.78527877e-02f, -7.80351162e-02f, -3.54349464e-02f,
  2.41883725e-01f, 2.26632714e-01f, 1.69704676e-01f, 1.25362366e-01f, 1.46965951e-01f, 1.00145854e-01f, 1.04551464e-01f, 9.02469903e-02f, 9.26679224e-02f, 1.64976135e-01f,
  1.30066931e-01f, 9.24679935e-02f, 4.35344540e-02f, -1.53814396e-02f, 1.60874486e-01f, 1.41154900e-01f, 1.84652172e-02f, 8.48117694e-02f, 2.18086869e-01f, 6.77786246e-02f,
  5.90842217e-04f, 2.04578251e-01f, 1.26670018e-01f, 2.72804081e-01f, 1.01617754e-01f, 1.50564134e-01f, 1.32229313e-01f, 1.50189221e-01f, 1.74890384e-01f, 2.09714025e-01f,
  -4.11539197e-01f, -1.51746944e-01f, -1.85369283e-01f, 1.71779003e-02f, 1.38208449e-01f, 1.85079034e-02f, -8.82776082e-02f, -5.77376317e-03f, 6.19527660e-02f, -4.65486534e-02f,
  1.94007099e-01f, 2.74714470e-01f, 1.28134087e-01f, 2.75950789e-01f, -8.86399373e-02f, -5.94929941e-02f, 3.43293361e-02f, -2.75265351e-02f, -2.46720463e-02f, 3.73345502e-02f,
  1.34573281e-01f, -3.58643197e-02f, -7.32620284e-02f, -2.39568818e-02f, 5.22362581e-03f, 6.78043738e-02f, -8.05316344e-02f, 5.45153320e-02f, -7.59481639e-02f, 1.06662810e-01f,
  -5.53474911e-02f, -2.51897842e-01f, -1.89200006e-02f, -6.88649565e-02f, -1.22483296e-03f, -7.95728415e-02f, 8.85282457e-03f, -8.72066393e-02f, 9.34925582e-03f, -8.20381194e-02f,
  2.34457701e-02f, 5.72440326e-02f, 5.21114729e-02f, -4.12748149e-03f, -8.76957476e-02f, -4.08312976e-02f, -4.91298176e-02f, -1.57926485e-01f, -2.77955569e-02f, -7.48168677e-02f,
  4.08636965e-02f, -5.46441823e-02f, -2.11993083e-01f, -1.13878377e-01f, -1.18278533e-01f, -1.49912173e-02f, -1.72284454e-01f, -9.78910327e-02f, -2.75985569e-01f, -1.62918985e-01f,
  8.16882551e-02f, -1.47972042e-02f, -3.02907825e-02f, 2.63486169e-02f, 5.59040997e-03f, -6.12885272e-03f, 5.80718778e-02f, 7.67404959e-02f, -4.48207185e-02f, -7.47664943e-02f,
  -2.22984292e-02f, 1.06553026e-01f, 9.54981148e-02f, -1.26564512e-02f, 6.99997991e-02f, -2.66565401e-02f, 5.03001921e-02f, -6.50842264e-02f, 5.89432605e-02f, -2.95085721e-02f,
  -2.78419275e-02f, 3.51317152e-02f, -3.30205932e-02f, 8.39608163e-02f, -8.11540708e-02f, 6.40949830e-02f, -8.99326503e-02f, 1.73978657e-02f, 3.47593166e-02f, 7.32082203e-02f,
  -5.05445637e-02f, -5.76764792e-02f, 7.09303245e-02f, -1.64278075e-02f, 1.49135338e-02f, -4.11574766e-02f, 8.20446573e-03f, 6.97652949e-03f, 7.50998780e-03f, -9.87326428e-02f,
  -6.14637211e-02f, -1.45609632e-01f, 3.19780111e-02f, 6.48960099e-02f, -5.39700389e-02f, -1.53355477e-02f, -6.81766719e-02f, 6.03049025e-02f, -7.91337788e-02f, -6.61842525e-03f,
  -4.35326919e-02f, -1.72060147e-01f, -1.84322089e-01f, -1.72303736e-01f, -5.76052517e-02f, -1.24341674e-01f, -5.18479645e-02f, -1.62603050e-01f, -2.17486262e-01f, -1.23416364e-01f,
  2.35451266e-01f, 1.37901723e-01f, 1.01264909e-01f, 3.15016270e-01f, 1.07078165e-01f, 1.00589536e-01f, 1.88731924e-01f, 1.24607407e-01f, 8.56716484e-02f, 2.34201625e-01f,
  -3.42996418e-02f, -1.73193052e-01f, -2.91527927e-01f, -2.76154846e-01f, -2.05872968e-01f, 1.49420813e-01f, 2.66585708e-01f, -1.39912456e-01f, -1.32084861e-01f, -1.03588842e-01f,
  8.86084884e-02f, 1.09650053e-01f, -1.09667949e-01f, 2.91101728e-02f, 1.74092039e-01f, 5.22180498e-02f, 1.86653629e-01f, 1.45203963e-01f, -1.36927336e-01f, 1.86117351e-01f,
  -2.45511085e-02f, 1.05503701e-01f, 1.86246000e-02f, -5.30251376e-02f, -3.29359062e-02f, 4.46246676e-02f, 3.85037214e-02f, 1.83376558e-02f, 3.55292996e-03f, 4.28187065e-02f,
  -1.17350332e-02f, 1.43614551e-02f, 3.19661526e-03f, -5.81293274e-03f, 3.71872308e-03f, 1.26909211e-01f, 9.62659419e-02f, 9.54524800e-02f, -1.03106774e-01f, -5.66945672e-02f,
  1.25674112e-03f, -2.55346540e-02f, -1.15898373e-02f, -1.11063896e-02f, 1.95237342e-02f, -1.10565521e-01f, 7.75549980e-03f, -8.21300149e-02f, -5.36889732e-02f, 1.67403538e-02f,
  -3.91023792e-02f, 4.10328433e-02f, 6.64049163e-02f, 3.81516442e-02f, 6.46422757e-03f, -1.06254406e-02f, 9.67926253e-03f, -2.03905329e-02f, 5.59888668e-02f, 4.46549952e-02f,
  -6.56197146e-02f, 1.50196284e-01f, 9.92033705e-02f, 8.77203196e-02f, 1.62592693e-03f, 4.45865840e-03f, -5.66866174e-02f, 1.55174807e-01f, 4.34637927e-02f, 4.04841118e-02f,
  6.47459328e-02f, 5.64168952e-02f, 6.76752478e-02f, 7.77933002e-02f, 6.86020264e-03f, 3.47822765e-03f, 1.72770073e-04f, -5.52815311e-02f, 5.43557219e-02f, 7.34843314e-02f,
  -2.60863900e-02f, -2.34255925e-01f, 7.96559751e-02f, 2.45533697e-02f, -1.92856006e-02f, -1.45037398e-01f, 3.89099750e-03f, -4.02143151e-02f, 3.81976296e-03f, -2.51055509e-02f,
  1.55221419e-02f, -6.61094785e-02f, -6.67578205e-02f, 4.32342999e-02f, 9.91711766e-03f, -4.36343439e-02f, 1.24953650e-02f, 9.94753614e-02f, -5.51026203e-02f, 2.64442395e-02f,
  -6.45715073e-02f, -5.84971830e-02f, 2.95252968e-02f, -6.19002208e-02f, -5.76614588e-02f, 4.77844812e-02f, 1.77962966e-02f, -6.65459856e-02f, -1.61997408e-01f, 1.11783199e-01f,
  -3.20015192e-01f, -2.88071930e-02f, -1.17394932e-01f, -4.44209665e-01f, -3.80716592e-01f, -1.79635391e-01f, -2.14208886e-01f, -1.60319254e-01f, -2.60414720e-01f, -3.11002582e-01f,
  -1.22019425e-01f, -5.61827533e-02f, -8.40296447e-02f, -6.42422885e-02f, -1.03116147e-01f, -2.90322542e-01f, -4.09718543e-01f, -1.29755676e-01f, -2.07647935e-01f, -1.98885456e-01f,
  -2.27138460e-01f, -2.88523436e-01f, -2.06215084e-01f, -1.89599410e-01f, -3.18994045e-01f, -1.99992090e-01f, -2.93719500e-01f, -1.79197788e-01f, -4.71871644e-02f, -3.13571572e-01f,
  -1.05295695e-01f, -1.52309448e-01f, -4.83268984e-02f, -1.14684179e-01f, -1.43963009e-01f, -4.77415025e-02f, 1.53363775e-02f, -1.66991994e-01f, -3.91421802e-02f, -9.59515646e-02f,
  -1.52750492e-01f, 9.08198766e-04f, -1.39193743e-01f, -5.74496277e-02f, -6.96093068e-02f, -1.29522579e-02f, -7.20786825e-02f, 2.19189245e-02f, 5.83946444e-02f, 2.27782615e-02f,
  2.15846417e-03f, -5.01200520e-02f, -1.05221704e-01f, 7.92700648e-02f, 3.30989398e-02f, -7.58836716e-02f, 1.61145572e-02f, -4.95853089e-02f, 7.24956915e-02f, -8.08319300e-02f,
  1.02381200e-01f, 6.20620772e-02f, -5.53707145e-02f, -2.32706852e-02f, 3.12611237e-02f, 7.75625482e-02f, 4.22724144e-04f, -4.81955372e-02f, 2.94581559e-02f, 2.73109615e-01f,
  1.29311532e-01f, 8.47393721e-02f, 7.80205727e-02f, -8.76845866e-02f, 4.53904197e-02f, 4.03525680e-02f, -2.28251982e-03f, 3.05197481e-03f, 1.36084437e-01f, 1.54179707e-01f,
  9.44674239e-02f, 3.19629200e-02f, -1.18819466e-02f, 1.84797198e-01f, 5.54658361e-02f, -7.35527882e-03f, 3.73492762e-02f, 1.72921047e-01f, 1.08258091e-01f, 1.69784904e-01f,
  -1.46213979e-01f, 1.78117245e-01f, -1.75807998e-01f, -6.16785176e-02f, -2.02023029e-01f, -1.55882370e-02f, -7.42181987e-02f, -7.63528422e-02f, -5.73003516e-02f, -1.30150959e-01f,
  3.81160006e-02f, -1.16977431e-01f, -1.09103806e-01f, -1.74946576e-01f, -1.70421511e-01f, -9.39589888e-02f, -8.72645825e-02f, -1.23709984e-01f, 4.55856137e-02f, -5.14263846e-02f,
  -1.22550175e-01f, -1.37141347e-01f, -1.97272629e-01f, -8.64218995e-02f, -2.70463177e-03f, -2.04621494e-01f, 7.83477724e-03f, 1.39028188e-02f, -3.14343385e-02f, -1.28373951e-01f,
  1.13852762e-01f, -1.15956284e-01f, -8.56354013e-02f, 2.59306341e-01f, 3.14991139e-02f, 2.19243139e-01f, 5.69618642e-02f, 1.17619604e-01f, 1.18313089e-01f, -2.64682956e-02f,
  9.00069922e-02f, 6.22567572e-02f, 1.38547927e-01f, 1.55318648e-01f, 1.65645972e-01f, 3.53752077e-02f, -1.09957702e-01f, 6.80658594e-02f, 2.16545403e-01f, 2.25015551e-01f,
  5.60756549e-02f, -1.70436129e-03f, -2.11038496e-02f, 2.72480790e-02f, 3.28832045e-02f, 1.27939522e-01f, -1.41334832e-01f, -6.50584698e-02f, -3.54796909e-02f, -2.28996053e-01f,
  9.25401505e-03f, -1.15245104e-01f, 7.96952844e-03f, -9.62771699e-02f, -2.42874003e-03f, -7.07106665e-03f, 2.26840470e-02f, -2.94213137e-03f, 6.19524792e-02f, 1.71097238e-02f,
  1.92962047e-02f, 3.75597291e-02f, 2.93228626e-02f, 1.73682580e-04f, -1.50677012e-02f, -5.63485473e-02f, -9.87733528e-02f, 3.11742928e-02f, 1.50817325e-02f, -8.38230550e-02f,
  5.85060706e-03f, 1.24480091e-02f, 4.30352241e-02f, 4.65622731e-02f, 4.44168001e-02f, 3.93020436e-02f, -1.34944040e-02f, -9.07677263e-02f, -8.62812623e-02f, -1.48552552e-01f,
  3.39576751e-02f, -3.56177837e-02f, 5.35256602e-02f, 3.53970118e-02f, 6.49060160e-02f, -1.18251862e-02f, -5.34374490e-02f, 1.85834337e-02f, 7.08500147e-02f, 4.77591194e-02f,
  -2.21539475e-02f, 6.22786619e-02f, 5.60736395e-02f, 2.00246610e-02f, 1.10649936e-01f, -2.74039190e-02f, 5.99463135e-02f, -8.33878815e-02f, -3.85479592e-02f, -1.75179560e-02f,
  5.26042394e-02f, -6.23373734e-03f, -2.57157385e-02f, 5.15895747e-02f, -5.56271449e-02f, -1.49477748e-02f, 2.52454504e-02f, -6.53884420e-03f, 1.16034709e-01f, 9.45187360e-02f,
  1.65790409e-01f, -1.36832207e-01f, 1.54715970e-01f, -4.26396318e-02f, 1.95215773e-02f, 1.05043307e-01f, 1.06588759e-01f, 6.28839061e-02f, 7.04709860e-03f, 3.29567119e-02f,
  8.02416205e-02f, 1.32897735e-01f, -7.70395156e-03f, -7.93601796e-02f, 4.62048464e-02f, -4.32849936e-02f, 9.89737064e-02f, 1.55249253e-01f, 1.28982484e-01f, 1.59872338e-01f,
  5.65757509e-03f, 1.82876602e-01f, 2.56108969e-01f, 3.07449158e-02f, 6.67237043e-02f, 1.28346711e-01f, 1.15625024e-01f, 1.50775522e-01f, 1.54836804e-01f, 2.31147319e-01f,
  2.34496042e-01f, -2.58950055e-01f, 8.06203485e-02f, 5.68880923e-02f, -1.41696855e-01f, 4.73294891e-02f, 4.60553169e-02f, 3.51587757e-02f, -9.05620083e-02f, -2.32495070e-01f,
  -3.95475924e-02f, 2.45498419e-02f, 7.25943893e-02f, 5.96587323e-02f, 1.78154096e-01f, -1.01459160e-01f, -1.86251953e-01f, 9.78212059e-02f, 3.26601118e-01f, 6.45139143e-02f,
  -1.01532876e-01f, 3.66891804e-03f, 1.87189624e-01f, 9.04205292e-02f, -3.33791703e-01f, -1.23917624e-01f, -1.35538876e-01f, -1.99187651e-01f, -1.92142501e-01f, -5.49134254e-01f,
  -4.17675637e-02f, -6.19871020e-02f, 1.12642713e-01f, -5.83070442e-02f, 6.80158883e-02f, 7.50551596e-02f, 7.56867677e-02f, 4.82803285e-02f, 7.83988014e-02f, -2.39303913e-02f,
  -1.73361860e-02f, 4.49705943e-02f, 6.88535273e-02f, -3.97299137e-03f, -1.96259022e-02f, -3.24698351e-02f, -3.87302563e-02f, 7.89178014e-02f, 4.47398499e-02f, 4.71108519e-02f,
  -4.46563028e-02f, -1.02796778e-01f, 1.51513899e-02f, -1.72643811e-02f, 4.58896607e-02f, 1.60870906e-02f, -3.90199982e-02f, -6.28475994e-02f, -6.15289286e-02f, -2.40401536e-01f,
  -2.05977596e-02f, 7.34396502e-02f, -2.36266311e-02f, -9.04457495e-02f, 3.84247415e-02f, -1.37412567e-02f, -1.11151345e-01f, -1.27558619e-01f, 5.55074848e-02f, -3.01195197e-02f,
  3.53470631e-02f, 1.11103663e-02f, 2.46796906e-02f, -1.62683744e-02f, -4.64155637e-02f, -3.51894498e-02f, 3.51094045e-02f, 2.60814819e-02f, -4.34361733e-02f, 1.15852598e-02f,
  -1.37716174e-01f, -2.31333710e-02f, 4.93061282e-02f, 3.60230394e-02f, -9.43517089e-02f, 2.97447164e-02f, -1.44127980e-02f, -6.88274130e-02f, -7.43971020e-02f, -3.07886507e-02f,
  1.43412098e-01f, -2.27356311e-02f, -3.79016697e-02f, 1.46354605e-02f, -3.24284378e-03f, 1.02744177e-01f, 5.44011518e-02f, 1.71573516e-02f, 1.19461872e-01f, 1.12655841e-01f,
  1.52269050e-01f, 4.09210473e-02f, 3.90727296e-02f, -1.34285361e-01f, 1.00540528e-02f, 1.11532494e-01f, 1.59942973e-02f, 2.24706996e-02f, -1.64306946e-02f, -3.43769230e-02f,
  -7.36762509e-02f, 8.80068392e-02f, -3.50093469e-02f, 6.11743610e-03f, -8.51038545e-02f, 5.17645665e-02f, 1.02490880e-01f, 4.72352989e-02f, 1.14949070e-01f, 1.91544816e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.88975239e-01f, 2.28807122e-01f, 1.12601183e-01f, -1.22859456e-01f, 2.54737526e-01f, 1.05175920e-01f, 2.17837319e-01f, 1.21604167e-02f, -1.24842758e-04f, 9.40889716e-02f,
  8.46155882e-02f, -1.03933156e-01f, -1.14711933e-02f, -1.38293564e-01f, -1.62987247e-01f, 3.19072083e-02f, 5.42802177e-02f, -2.64990628e-01f, -3.38878930e-01f, -2.55201221e-01f,
  -1.04387775e-01f, -2.43496373e-01f, -2.60750324e-01f, -2.05672592e-01f, 5.34051061e-02f, -1.61867768e-01f, 3.10571436e-02f, 1.73381511e-02f, 8.43885019e-02f, 1.35818467e-01f,
  -1.09793677e-03f, 2.23719716e-01f, 9.55930725e-02f, -6.43735975e-02f, 4.77622030e-03f, -1.71090722e-01f, -6.34826720e-02f, 5.48113473e-02f, 1.40727267e-01f, -5.73971644e-02f,
  4.87262085e-02f, 2.54025422e-02f, 1.12301640e-01f, -9.67747122e-02f, -1.74704924e-01f, -2.12750003e-01f, -5.01898974e-02f, -1.33217141e-01f, 2.05200501e-02f, -3.86307985e-02f,
  7.68440068e-02f, 3.14341858e-02f, -7.97463730e-02f, -4.37683798e-02f, 6.61431700e-02f, -1.54144093e-01f, -1.36717092e-02f, 3.64563130e-02f, 4.92019877e-02f, -1.19684599e-01f,
  3.03915795e-02f, 1.68132745e-02f, 1.24434777e-01f, 1.78357251e-02f, -5.59436306e-02f, 4.48019467e-02f, 3.01575698e-02f, -7.05066025e-02f, 2.53494401e-02f, -1.90753579e-01f,
  4.90068793e-02f, -3.37053724e-02f, -2.18614191e-02f, 9.37481225e-02f, -6.70961738e-02f, 4.52532396e-02f, -7.17201978e-02f, -3.11817676e-02f, -6.51996732e-02f, 2.33973134e-02f,
  -8.01642984e-02f, -1.02948777e-01f, -4.30701487e-02f, -2.36866381e-02f, 6.31716028e-02f, -4.72593121e-02f, 5.94324246e-02f, -1.92587059e-02f, -2.10464839e-03f, 1.85605921e-02f,
  -1.28910139e-01f, 2.08802268e-01f, -1.04699381e-01f, -1.33328438e-01f, -1.93195418e-02f, -1.42989352e-01f, 7.54243881e-02f, -3.34881917e-02f, -2.16633826e-02f, 3.92258167e-02f,
  -7.97368661e-02f, 1.06628187e-01f, 5.21632768e-02f, -1.03928804e-01f, -9.65060741e-02f, -5.96591383e-02f, -1.83118790e-01f, -1.89578697e-01f, -5.08333817e-02f, -1.42384961e-01f,
  -4.24284227e-02f, -2.08024085e-01f, -1.98440313e-01f, -4.59712297e-02f, -4.31904197e-02f, -2.12581664e-01f, -5.47652990e-02f, -1.42159849e-01f, -9.77247059e-02f, -2.84863651e-01f,
  -4.46711242e-01f, 6.40671104e-02f, -1.57000080e-01f, 6.38981014e-02f, 1.74819097e-01f, 1.22838430e-01f, -3.18247229e-02f, -2.20354497e-01f, 9.79465768e-02f, -7.94693455e-03f,
  1.68256909e-01f, 1.91498414e-01f, 1.52364209e-01f, 9.51511040e-02f, -1.64949358e-01f, 7.58385882e-02f, 1.71147764e-01f, -8.25837925e-02f, -3.47907506e-02f, 5.68824597e-02f,
  1.62080899e-01f, 3.82256061e-02f, -8.26169476e-02f, -8.67625140e-03f, 1.12695158e-01f, 1.50621950e-03f, 6.80894731e-03f, 1.19008102e-01f, 1.24327749e-01f, 2.28399947e-01f,
  7.00780526e-02f, -2.56111264e-01f, -1.51139110e-01f, 4.19225125e-03f, 5.68721779e-02f, -1.96062222e-01f, 8.27571936e-03f, -4.75329198e-02f, 2.64486820e-02f, -1.26184942e-02f,
  -3.13200615e-02f, -3.27195115e-02f, 1.17126614e-01f, -2.86664478e-02f, -1.83820263e-01f, -1.94345251e-01f, -8.54770690e-02f, -9.71221700e-02f, -1.43595651e-01f, -1.12510487e-01f,
  1.31227121e-01f, 3.13294113e-01f, -3.43589857e-03f, -6.79749530e-03f, -1.84012502e-01f, 7.90032744e-02f, 2.67552268e-02f, -4.54477891e-02f, -2.92883962e-01f, -2.04685137e-01f,
  -9.86202955e-02f, 1.10858925e-01f, 1.03368163e-02f, -8.36704075e-02f, -5.31531163e-02f, 2.90719867e-02f, 4.15557586e-02f, 1.37440085e-01f, -1.60592198e-02f, -7.90643468e-02f,
  1.38524137e-02f, -2.53388900e-02f, 2.44622193e-02f, -7.95958340e-02f, 4.36525717e-02f, 7.46848881e-02f, -5.70069291e-02f, 1.96167026e-02f, 4.27692793e-02f, -4.87281494e-02f,
  -8.63341242e-02f, 8.47818423e-03f, -2.68070269e-02f, 3.24480906e-02f, 2.41052732e-02f, 6.78093880e-02f, 2.08476447e-02f, 4.55326699e-02f, -9.24644247e-03f, -6.77462947e-03f,
  -4.05158997e-02f, 9.04006884e-02f, -3.88083681e-02f, -2.30111796e-02f, 1.19276978e-01f, -2.11527795e-02f, 8.82891268e-02f, -1.19052883e-02f, 1.41394148e-02f, -1.60120875e-01f,
  -1.55036822e-01f, -1.73646688e-01f, -1.80785842e-02f, -7.21388012e-02f, -1.02931410e-02f, -1.64908037e-01f, -2.02296246e-02f, -1.04708821e-02f, 1.11269780e-01f, -9.79115218e-02f,
  5.36931120e-02f, 9.12439302e-02f, -1.11294925e-01f, 1.90647766e-02f, -4.85993847e-02f, -7.85993710e-02f, -1.02420725e-01f, -1.55288339e-01f, -1.50731206e-01f, -2.09641457e-01f,
  3.89497042e-01f, 9.78438258e-02f, 1.55002534e-01f, -5.25710993e-02f, -1.27611622e-01f, 1.66845441e-01f, 1.05493851e-01f, 3.77408564e-02f, -1.04618713e-01f, -7.33365417e-02f,
  1.47099629e-01f, 9.83667448e-02f, 1.11420631e-01f, -4.01644967e-03f, 3.50436056e-03f, -1.84302807e-01f, -2.58548260e-01f, -9.62261856e-02f, 2.58383811e-01f, -1.87756233e-02f,
  -8.12383369e-02f, -2.34534174e-01f, 1.69257615e-02f, -1.80104181e-01f, -4.10947412e-01f, -1.74312711e-01f, -1.76539674e-01f, -1.58376694e-01f, -1.39023751e-01f, -4.09886658e-01f,
  5.20276017e-02f, 3.80874157e-01f, 7.30171427e-02f, 6.44114092e-02f, 1.01813652e-01f, -7.36298636e-02f, 1.31974414e-01f, -6.62406012e-02f, -5.46034090e-02f, -1.01559252e-01f,
  5.72058186e-02f, -1.58376060e-02f, 8.49685073e-02f, -4.52257060e-02f, 8.10962468e-02f, 8.82829577e-02f, -4.95928898e-02f, 1.58463567e-01f, 2.72704009e-02f, 5.70989959e-02f,
  -1.35354260e-02f, 1.77535087e-01f, 1.86122447e-01f, 1.05048649e-01f, 1.69429109e-01f, 1.43291771e-01f, 1.73113734e-01f, 1.37964249e-01f, 2.55151212e-01f, 8.11032727e-02f,
  -8.52692872e-02f, 2.58014947e-02f, 5.06078340e-02f, 1.07779980e-01f, 9.42036286e-02f, 1.54842883e-01f, 2.37304755e-02f, 9.96774212e-02f, 7.99518228e-02f, 8.35630228e-04f,
  8.54059607e-02f, 7.37353638e-02f, 1.59044728e-01f, -5.82881160e-02f, -1.07274532e-01f, 3.51915322e-02f, 6.92351838e-04f, -5.26937172e-02f, -9.49776359e-03f, -7.53322318e-02f,
  1.32735550e-01f, -6.05217367e-02f, -1.09809637e-01f, 3.08629014e-02f, 8.79968852e-02f, 8.65208954e-02f, 2.24879142e-02f, 2.56000236e-02f, -1.08024038e-01f, -1.45375580e-01f,
  -8.98753256e-02f, 2.82810658e-01f, -2.22578838e-01f, -8.00910890e-02f, -1.22443475e-01f, -2.67361626e-02f, -1.20920483e-02f, -9.17224064e-02f, -1.32284179e-01f, -1.23494305e-01f,
  2.77487207e-02f, 2.03367393e-03f, -1.73242565e-03f, -4.35079783e-02f, 1.57165248e-02f, 3.24449912e-02f, -4.36098278e-02f, -3.05368602e-02f, 2.80202702e-02f, -4.97846752e-02f,
  -4.73692939e-02f, 3.02771647e-02f, 1.47852689e-01f, 1.12624951e-01f, -4.99905162e-02f, -5.48694022e-02f, 3.58761773e-02f, -3.70040759e-02f, 1.57461196e-01f, -3.06507349e-02f,
  -2.77185798e-01f, -1.43834531e-01f, 1.09395161e-01f, -2.07955405e-01f, -1.48577794e-01f, -1.24248594e-01f, -3.71095002e-01f, -8.43268558e-02f, -3.16981561e-02f, -7.84855187e-02f,
  -2.32811226e-03f, 7.68324360e-02f, -8.38368759e-03f, 1.85233504e-01f, 5.27106449e-02f, -2.78188825e-01f, -2.63155639e-01f, -2.53958944e-02f, -7.28455707e-02f, -5.13926446e-02f,
  -1.76613733e-01f, -3.20358008e-01f, -7.18325451e-02f, -8.55946615e-02f, -3.21502984e-02f, 6.86689019e-02f, -1.72242939e-01f, -8.25488195e-02f, -7.30502829e-02f, -8.60429481e-02f,
  4.07869548e-01f, 1.14399148e-02f, 1.57477498e-01f, 9.69342813e-02f, -3.02834082e-02f, 7.14493245e-02f, -6.40482306e-02f, -8.49956721e-02f, -8.00629258e-02f, 3.38952010e-03f,
  1.16951250e-01f, -2.48531774e-02f, -1.04072668e-01f, 3.48335057e-02f, 6.98826313e-02f, 1.18663944e-01f, 1.12348437e-01f, 4.99900021e-02f, 1.18388765e-01f, 9.46981981e-02f,
  7.37854242e-02f, 8.32292885e-02f, 2.02377364e-01f, 4.54462394e-02f, 1.02953322e-01f, 1.65644780e-01f, 2.12416023e-01f, 1.58910081e-01f, 1.71184495e-01f, 1.03038356e-01f,
  -6.48217872e-02f, -1.69080831e-02f, 1.09504566e-01f, -1.04877435e-01f, -1.21753998e-01f, -4.79562804e-02f, -8.83342400e-02f, -9.64451656e-02f, -7.32741430e-02f, -9.48475897e-02f,
  -7.80991614e-02f, -7.38629550e-02f, -5.49498498e-02f, -1.07312903e-01f, -2.19291560e-02f, -8.42611790e-02f, 6.21302463e-02f, 1.70002490e-01f, 4.02946658e-02f, -4.22559828e-02f,
  5.29551320e-02f, 1.11453393e-02f, -1.69591811e-02f, -4.68983017e-02f, 1.82076320e-01f, 1.36837766e-01f, 3.75265852e-02f, 1.05728716e-01f, -1.44474367e-02f, 2.21973024e-02f,
  1.13043092e-01f, 6.17740080e-02f, -9.69763026e-02f, -5.45513593e-02f, 2.19731387e-02f, 1.26993611e-01f, 5.70585094e-02f, -4.96854307e-03f, 1.95686780e-02f, 8.69306102e-02f,
  2.08536342e-01f, 1.47083495e-02f, 4.87476885e-02f, -3.04905884e-02f, 1.24802263e-02f, 9.47626233e-02f, 5.01101986e-02f, 5.18042371e-02f, 1.05625376e-01f, 1.32803053e-01f,
  9.63827372e-02f, 1.74037740e-01f, 1.24517187e-01f, 2.06420660e-01f, 2.04483241e-01f, 1.97980195e-01f, 8.25437531e-02f, 1.28043503e-01f, 2.58609414e-01f, -5.35156056e-02f,
  3.13472956e-01f, -3.88271421e-01f, -2.32456848e-02f, -3.18682678e-02f, -3.14666480e-01f, -4.35503334e-01f, -6.36011124e-01f, -2.07020581e-01f, 5.45554496e-02f, -1.87301576e-01f,
  7.10040554e-02f, 2.99922973e-01f, 2.48996943e-01f, 2.72320628e-01f, 1.45926148e-01f, -2.24822640e-01f, -4.50222492e-02f, 3.13592404e-01f, 1.24131069e-01f, 4.59835604e-02f,
  4.47572172e-02f, 2.54785712e-03f, 2.61818171e-01f, 1.35043412e-01f, -2.08603814e-02f, 5.04093990e-02f, -1.01774046e-02f, 1.43484116e-01f, 4.11282293e-02f, 2.27129489e-01f,
  9.42035317e-02f, -4.36552577e-02f, 7.35179260e-02f, 8.21956918e-02f, 5.22917472e-02f, -9.95669812e-02f, -2.73484830e-02f, 5.34254387e-02f, -1.07656578e-02f, -4.54556346e-02f,
  6.95523992e-02f, 1.28332928e-01f, -4.65792120e-02f, 6.24027885e-02f, -5.89721799e-02f, -5.36955893e-02f, -9.01674759e-03f, 2.10215658e-01f, -8.05109739e-02f, 7.47758597e-02f,
  -9.18267220e-02f, -7.25147352e-02f, -4.61527258e-02f, -2.10689858e-01f, -8.93705338e-02f, 1.04251385e-01f, 1.56169794e-02f, 3.77727970e-02f, -4.47685011e-02f, -8.15093517e-02f,
  1.55997187e-01f, 3.90567593e-02f, 1.72691464e-01f, -5.77038489e-02f, -1.35201558e-01f, -4.04687747e-02f, 2.65341364e-02f, -6.59951568e-02f, 2.31486987e-02f, 1.95949543e-02f,
  6.71228543e-02f, 9.36030224e-02f, 8.37599263e-02f, -6.22639656e-02f, 3.66691388e-02f, 3.15362327e-02f, 3.61870341e-02f, -3.82348113e-02f, -5.39979413e-02f, -1.89919621e-02f,
  1.02854714e-01f, -7.05920160e-03f, -1.78323891e-02f, 1.35847762e-01f, -1.12547004e-03f, 8.54806788e-03f, 6.38580546e-02f, -8.18576515e-02f, -7.72049204e-02f, 7.36780763e-02f,
  -2.49571636e-01f, 4.31939289e-02f, 1.22108065e-01f, 1.09289341e-01f, 2.82876547e-02f, 6.88096732e-02f, -7.87087455e-02f, -6.17388487e-02f, -3.34327817e-02f, -1.52142242e-01f,
  -1.23471253e-01f, -1.55781908e-02f, -1.11571573e-01f, 5.34201600e-02f, 1.28619745e-01f, 8.66548941e-02f, 5.62678538e-02f, 2.76994891e-03f, 1.18820645e-01f, -2.56094374e-02f,
  -7.18392506e-02f, -2.17072710e-01f, -7.89520070e-02f, -1.89976349e-01f, 4.99759354e-02f, -7.71818683e-02f, -1.78738646e-02f, -1.01622708e-01f, -1.48858398e-01f, -2.61285216e-01f,
  6.88270107e-02f, -2.62563020e-01f, -1.01974919e-01f, -5.67528717e-02f, -1.57750100e-01f, 7.28692161e-03f, -2.70188361e-01f, 9.70177501e-02f, -3.40879932e-02f, -2.35149264e-01f,
  -5.52813336e-02f, 2.09600046e-01f, 1.71559557e-01f, 2.69157737e-01f, 1.52298048e-01f, -3.03608567e-01f, -1.35114536e-01f, 1.36659682e-01f, 2.34424472e-01f, 1.62580743e-01f,
  5.58109023e-02f, -4.79437001e-02f, 1.30475566e-01f, 1.13451153e-01f, -2.52378672e-01f, -6.97846785e-02f, -2.85799056e-01f, -1.60722390e-01f, -6.02040701e-02f, -3.18157524e-01f,
  -4.03171517e-02f, -7.61212260e-02f, -2.03936920e-02f, -5.88889532e-02f, -9.49241314e-03f, 1.65866047e-01f, 7.92301595e-02f, -1.51194289e-01f, -2.37463713e-02f, -4.12674174e-02f,
  -4.88606207e-02f, -3.14854123e-02f, -1.10426158e-01f, 1.32678598e-02f, -6.83099329e-02f, 1.36168990e-02f, -1.09148204e-01f, 7.61498883e-02f, -9.52045023e-02f, -1.49532542e-01f,
  -2.19593838e-01f, -1.17886618e-01f, -1.26524344e-01f, -4.46009822e-02f, 1.89719000e-03f, -4.94465837e-03f, 1.48837427e-02f, -9.45796594e-02f, -5.15079014e-02f, -1.87944815e-01f,
  -7.34923631e-02f, 1.04117319e-02f, -9.33324546e-02f, -9.01826993e-02f, -5.26959263e-02f, -1.74004063e-01f, -4.01577093e-02f, -1.25854120e-01f, 4.94148917e-02f, -5.00041433e-02f,
  1.40366098e-02f, 3.14692222e-03f, 1.31905794e-01f, -3.48884016e-02f, -5.94748408e-02f, -1.90086514e-02f, -4.89295647e-02f, -5.99963181e-02f, -9.90633965e-02f, -6.36818400e-03f,
  -1.85925458e-02f, -6.10156097e-02f, -1.23164020e-01f, -2.96221860e-02f, -5.46977855e-02f, 7.15376288e-02f, -6.59338534e-02f, 7.73382233e-03f, 2.27669217e-02f, 1.83711629e-02f,
  1.42682925e-01f, 1.72887385e-01f, 2.09383313e-02f, -1.64944734e-02f, 6.95553496e-02f, 1.38714105e-01f, 4.30013351e-02f, 1.01552933e-01f, 1.25218732e-02f, 7.99201056e-02f,
  8.34841952e-02f, -6.67081401e-02f, -3.73136140e-02f, 7.58154616e-02f, -7.96792805e-02f, -1.87503710e-01f, -9.96360779e-02f, 1.56682089e-01f, 1.00085866e-02f, -1.04457945e-01f,
  -2.18664259e-01f, -8.77171978e-02f, -9.70337074e-03f, -1.17652968e-01f, 1.51452757e-02f, 5.47947623e-02f, -3.47534604e-02f, -8.87709782e-02f, 2.85499413e-02f, -1.42050564e-01f,
  8.88304636e-02f, -7.64356628e-02f, -1.27285466e-01f, 2.20556915e-01f, 1.44904196e-01f, -1.32919967e-01f, -5.48390388e-01f, -1.54821530e-01f, 9.07147750e-02f, -1.63251206e-01f,
  -4.84704971e-02f, 3.96287292e-02f, -3.58132608e-02f, -7.03132600e-02f, -5.06614625e-01f, -4.36502188e-01f, -3.00415128e-01f, -2.53943712e-01f, -2.04369500e-01f, -2.21482310e-02f,
  1.53739732e-02f, 1.31760702e-01f, 6.92521408e-02f, 6.83683483e-03f, 2.28166461e-01f, 8.26398581e-02f, 1.15282871e-01f, 1.24624163e-01f, -5.18801101e-02f, 2.51921564e-01f,
  -2.26795133e-02f, 3.01663838e-02f, 5.47380485e-02f, 3.44515331e-02f, 8.28386620e-02f, 4.17564213e-02f, -9.92518514e-02f, 2.43422911e-02f, -4.83014919e-02f, 7.39799961e-02f,
  -3.21087800e-02f, -1.41249105e-01f, 1.48234218e-01f, -1.24389276e-01f, -3.27728689e-02f, -9.86338109e-02f, -1.14649408e-01f, -2.85883807e-02f, -6.93348125e-02f, -7.07522035e-02f,
  -5.67863360e-02f, -7.01612532e-02f, -1.11519247e-02f, -1.27812535e-01f, -5.61965816e-02f, 1.01667903e-01f, -5.77756092e-02f, 4.73322682e-02f, -1.83131903e-01f, 7.30011463e-02f,
  2.74294708e-03f, -1.06453830e-02f, -5.26026497e-03f, -9.64830443e-02f, -9.84856263e-02f, 4.31157760e-02f, 1.43031906e-02f, -1.24145509e-03f, -5.94354160e-02f, 1.18094375e-02f,
  -8.47870111e-02f, 3.19151990e-02f, 1.06544353e-01f, -5.29785566e-02f, 9.88197327e-02f, 7.56224766e-02f, -3.97930294e-02f, -2.12055515e-03f, 3.14543806e-02f, 1.05580494e-01f,
  -3.74220125e-02f, 2.20696107e-02f, 4.49823076e-03f, -4.07722853e-02f, -1.25185862e-01f, -1.72018092e-02f, 5.79475202e-02f, 3.48535739e-02f, 6.72838241e-02f, -5.12023903e-02f,
  1.62269115e-01f, -1.42959222e-01f, -6.04370721e-02f, 1.16093736e-03f, -5.86609095e-02f, 4.43129195e-03f, 1.06760673e-01f, -9.58509594e-02f, 6.18919618e-02f, -1.52615994e-01f,
  -1.56154213e-02f, -1.61835030e-01f, 1.41081121e-02f, -3.78802121e-02f, -6.04568943e-02f, -1.07449599e-01f, -8.98226053e-02f, 9.50550810e-02f, -3.87870930e-02f, 1.08228298e-02f,
  -1.33135751e-01f, -2.17922583e-01f, -1.38462737e-01f, -1.20224357e-01f, -5.87302884e-06f, -8.63846913e-02f, -7.58733004e-02f, 6.55624270e-02f, -2.61138856e-01f, -2.61923283e-01f,
  8.59055668e-02f, -8.21944922e-02f, -1.25698924e-01f, 2.65727520e-01f, 1.29530311e-01f, -1.38652071e-01f, -4.23061401e-01f, -6.17588274e-02f, 1.72066748e-01f, -1.21010743e-01f,
  -4.95418571e-02f, 1.13179244e-01f, 6.90915883e-02f, -1.95234835e-01f, -4.80466455e-01f, -3.87808681e-01f, -1.79451749e-01f, -1.49658680e-01f, -1.59275502e-01f, -1.51326239e-01f,
  -7.24962130e-02f, 3.98038775e-02f, -1.31592795e-01f, 3.11400071e-02f, 1.14447281e-01f, 6.44656643e-02f, 4.29840013e-02f, 7.12996442e-03f, -1.34433016e-01f, 1.41247839e-01f,
  5.33888564e-02f, 2.14777425e-01f, -4.05255109e-02f, 1.18595622e-01f, 1.11164674e-01f, -1.30389016e-02f, -6.29535466e-02f, 3.80954631e-02f, 2.93143485e-02f, 4.25952394e-03f,
  1.22153990e-01f, -3.35351862e-02f, 1.55629337e-01f, -3.88358049e-02f, 3.16376425e-02f, 6.86227754e-02f, 8.40399340e-02f, 4.90892306e-02f, -2.11149622e-02f, -4.40172367e-02f,
  1.76441632e-02f, -1.10354193e-01f, -9.57258120e-02f, -3.38349193e-02f, -6.39553741e-02f, -1.32540043e-03f, -5.87996915e-02f, -3.85865243e-03f, -1.46344658e-02f, -3.58981662e-03f,
  -7.53846765e-02f, 6.06686203e-03f, 1.18231542e-01f, -6.05547503e-02f, -1.29714340e-01f, 9.18266177e-03f, 8.89004171e-02f, -1.03394784e-01f, -7.62552992e-02f, -6.76368736e-03f,
  -4.77895290e-02f, -3.84425968e-02f, 4.33891267e-02f, -7.35085830e-02f, 1.04690775e-01f, 3.47684585e-02f, -5.83110973e-02f, 3.84187349e-03f, -4.53171358e-02f, 3.63143650e-03f,
  -3.88057670e-03f, 1.69121996e-02f, 3.84228714e-02f, 5.29073179e-02f, 1.20631978e-02f, -6.20210581e-02f, 2.08981521e-02f, -3.51577513e-02f, 1.65055711e-02f, -8.34883079e-02f,
  3.45537998e-02f, -1.25649437e-01f, -5.30053489e-02f, -1.31821439e-01f, -5.23397066e-02f, -6.53505996e-02f, 1.03789046e-01f, -1.03694394e-01f, 1.28657073e-01f, -6.27804399e-02f,
  -1.12385172e-02f, -4.84570451e-02f, -7.08692968e-02f, -7.46474415e-02f, -1.01655595e-01f, 5.50768785e-02f, -1.33779287e-01f, 2.58940160e-02f, -1.28175274e-01f, 9.59568396e-02f,
  -9.15051997e-02f, -1.51800722e-01f, -1.35276601e-01f, -3.66610624e-02f, -2.44205184e-02f, 2.69642584e-02f, -4.55371253e-02f, 8.95475894e-02f, -1.59756050e-01f, -2.56414115e-01f,
  -5.19499719e-01f, 9.28249955e-02f, 9.48644355e-02f, -3.56432647e-01f, 1.17041647e-01f, 1.74829677e-01f, 1.94341362e-01f, -2.25724373e-02f, -1.14421010e-01f, 4.55564521e-02f,
  1.22667469e-01f, 5.21639176e-02f, 1.12991910e-02f, -1.70145333e-02f, -1.34654939e-01f, 3.70423240e-03f, 3.91272008e-02f, -1.83502525e-01f, -3.60600604e-03f, 3.14140716e-03f,
  1.08063683e-01f, -8.68216679e-02f, -1.68611646e-01f, -8.48511979e-02f, 2.08131317e-02f, -1.68153085e-02f, -9.71603543e-02f, -1.47379860e-01f, 9.22084451e-02f, -2.19950057e-03f,
  -1.60339978e-02f, -1.00682139e-01f, 1.57063037e-01f, -3.49091105e-02f, 7.60231018e-02f, -6.60345554e-02f, 6.76257759e-02f, 1.64155327e-02f, 2.25071833e-02f, -4.47337069e-02f,
  4.28922661e-02f, -1.83529907e-03f, 2.49960460e-02f, 3.38024572e-02f, -1.82439119e-01f, -2.24440143e-01f, 3.60205285e-02f, -2.17800543e-01f, -3.91539410e-02f, -9.04112086e-02f,
  -2.86435336e-02f, -1.17842726e-01f, -1.47685513e-01f, -1.13955803e-01f, -4.52486202e-02f, -1.15875080e-01f, 1.11455798e-01f, -8.22505131e-02f, -8.93529058e-02f, -1.44905999e-01f,
  -9.21288282e-02f, 5.75927384e-02f, 2.77839880e-02f, 1.14607334e-01f, -2.27844696e-02f, -3.87236662e-02f, -3.70361656e-02f, 7.54834041e-02f, 7.17615411e-02f, -8.00477043e-02f,
  6.78684413e-02f, -7.65808951e-03f, -1.53037444e-01f, -1.18454024e-01f, 7.43063390e-02f, 1.42936960e-01f, -7.89309368e-02f, -4.06106450e-02f, -2.63143498e-02f, 1.19616650e-01f,
  -9.59303454e-02f, -6.73607960e-02f, -6.82003004e-03f, -1.13187321e-01f, 3.71283516e-02f, -1.76466499e-02f, -1.67414900e-02f, 8.62120762e-02f, -7.73400068e-02f, -1.26376078e-01f,
  -2.39862368e-01f, 7.85245225e-02f, -5.47531843e-02f, 2.49543749e-02f, 8.04768875e-02f, 5.37695512e-02f, 7.61221275e-02f, 6.21378087e-02f, 1.33552670e-01f, -8.63524377e-02f,
  1.96418352e-02f, -1.09757528e-01f, 1.15342945e-01f, -3.19413617e-02f, -1.37411440e-02f, -1.66133866e-02f, -4.42619175e-02f, -9.52067524e-02f, -1.67032033e-02f, -1.66498631e-01f,
  -1.55856665e-02f, -1.46604106e-01f, -2.76496619e-01f, -6.27074018e-02f, -1.18427381e-01f, -8.65989253e-02f, 7.68040568e-02f, -5.84302433e-02f, 3.07011232e-02f, -1.32245377e-01f,
  -1.77374527e-01f, -6.76214248e-02f, -2.00688362e-01f, -4.24801856e-01f, -4.90859263e-02f, 2.16110170e-01f, -4.71179225e-02f, 6.79768249e-02f, -2.90891267e-02f, -1.74312279e-01f,
  -1.20833464e-01f, 6.19926676e-03f, -1.98427394e-01f, 6.28647581e-02f, 1.53620139e-01f, -7.31834397e-02f, -2.57998884e-01f, 3.01795267e-02f, 2.07401425e-01f, 2.22021386e-01f,
  -2.01430544e-02f, -1.45860970e-01f, -7.39439055e-02f, 2.37385109e-02f, -3.43156934e-01f, -1.19947642e-01f, -3.82682472e-01f, -2.25247979e-01f, -2.32124068e-02f, -3.83157641e-01f,
  -2.98098475e-01f, -5.40315136e-02f, 2.13166699e-01f, -1.66238733e-02f, -1.37124851e-01f, 1.31243076e-02f, 2.07119156e-02f, -1.63284928e-01f, 2.60389578e-02f, -7.68028274e-02f,
  -1.77712113e-01f, 4.00254056e-02f, -5.58431186e-02f, -5.08080907e-02f, -1.19799048e-01f, 1.45484045e-01f, -8.42119157e-02f, 8.75417516e-02f, 3.12970281e-02f, 2.16654837e-01f,
  4.84303348e-02f, 9.58873630e-02f, -6.18283749e-02f, 2.36747339e-02f, 2.72643566e-02f, -6.70604929e-02f, 1.23726644e-01f, 5.29528894e-02f, 1.09337226e-01f, -2.51560956e-01f,
  2.08021581e-01f, 1.72737036e-02f, 5.62641583e-02f, 7.69461393e-02f, 3.07682641e-02f, -3.41007262e-02f, -5.08052632e-02f, 1.15353465e-02f, 4.32007797e-02f, -6.66309074e-02f,
  -3.89526673e-02f, 1.12297468e-01f, 9.46521014e-02f, -4.68585603e-02f, -4.03947718e-02f, 1.17379315e-02f, -3.22516002e-02f, -2.50766296e-02f, 7.21567050e-02f, 2.02616286e-02f,
  2.68841814e-02f, 1.59432683e-02f, 7.95449968e-03f, -1.41631085e-02f, 3.70081924e-02f, -6.07174374e-02f, 2.51539759e-02f, 7.19138235e-02f, 8.64657089e-02f, 1.12290025e-01f,
  -2.25860894e-01f, 1.60141423e-01f, -2.81932741e-01f, 8.46021771e-02f, -9.56998542e-02f, -4.50280383e-02f, -1.11671686e-01f, -1.50210083e-01f, -4.66003865e-02f, 2.03743242e-02f,
  1.94565058e-01f, -6.89800605e-02f, -1.23553805e-01f, 2.27607368e-03f, 7.88335949e-02f, 1.78911984e-01f, -5.60497157e-02f, 3.02619506e-02f, 3.26134712e-01f, 1.45925775e-01f,
  6.30967617e-02f, 7.72749111e-02f, -1.22488581e-01f, -1.16767444e-01f, 1.38952136e-02f, -1.19112380e-01f, -1.04832195e-01f, -8.15875977e-02f, 1.10881301e-02f, -2.29041338e-01f,
  1.37474403e-01f, -3.76162112e-01f, 5.10203503e-02f, 1.71785161e-01f, 3.07351977e-01f, 2.67521888e-01f, 6.35089874e-02f, 7.28169978e-02f, 1.25119776e-01f, 9.52668954e-03f,
  5.01188152e-02f, 1.12317704e-01f, 9.57030579e-02f, -1.53477734e-03f, -5.67114679e-03f, 7.90674388e-02f, 9.41204056e-02f, 3.14164869e-02f, 8.89286995e-02f, 1.11446463e-01f,
  4.95751016e-02f, -1.58962876e-01f, -1.32879630e-01f, -6.04518801e-02f, -2.14136615e-01f, 1.35254011e-01f, -1.58937752e-01f, -9.51240882e-02f, -1.66304275e-01f, -2.18128964e-01f,
  -1.02478646e-01f, -1.39380381e-01f, 2.19063193e-01f, -7.55545869e-02f, -9.52973887e-02f, -8.14542454e-03f, -6.19937368e-02f, -1.07435763e-01f, -3.02388668e-02f, -2.19909139e-02f,
  -7.20654130e-02f, -5.74778132e-02f, -2.26928294e-02f, 1.23385489e-02f, -1.61006391e-01f, -8.98520574e-02f, -2.26693511e-01f, -3.98480408e-02f, -1.14271834e-01f, -4.94220741e-02f,
  -9.60086808e-02f, -1.72451720e-01f, -4.27356102e-02f, -7.97549561e-02f, 3.85468528e-02f, 1.74143523e-01f, -7.71075115e-02f, -7.63652176e-02f, -1.02918312e-01f, -2.02240005e-01f,
  3.54058947e-03f, -8.67614821e-02f, -9.70853940e-02f, 4.26247455e-02f, 1.65276080e-01f, 6.39602318e-02f, 1.05528086e-02f, 3.54455523e-02f, 7.66793489e-02f, -7.93910846e-02f,
  -9.13189165e-03f, 4.84225266e-02f, 1.49760209e-02f, 4.64290231e-02f, 8.24320838e-02f, 1.08422851e-02f, 6.16731262e-03f, -6.26150444e-02f, -4.99481894e-03f, -1.50472835e-01f,
  -9.57368836e-02f, 1.51328417e-02f, -1.23911157e-01f, 2.87642740e-02f, 1.54950004e-02f, -5.02993129e-02f, 9.60727260e-02f, -1.99526995e-02f, -9.17275697e-02f, 5.80720492e-02f,
  -8.78485516e-02f, 5.28249405e-02f, 8.34523663e-02f, 2.41113920e-02f, -9.53926668e-02f, -7.49787837e-02f, 4.58739698e-02f, -1.33318514e-01f, 6.74252398e-03f, 4.98982742e-02f,
  2.25424469e-02f, -1.50932580e-01f, 2.80148126e-02f, -6.71177283e-02f, 7.67780095e-02f, 1.40282447e-02f, -2.70405505e-02f, 1.06398523e-01f, -3.90710086e-02f, -2.84595639e-02f,
  -1.56006679e-01f, 1.17460161e-01f, 1.35208145e-01f, 8.16234127e-02f, 1.84647832e-02f, 2.64002234e-01f, 8.96031316e-03f, 3.82509530e-02f, -6.24473253e-03f, 1.56498067e-02f,
  3.05416882e-02f, -1.26122817e-01f, -2.25953519e-01f, -1.19067386e-01f, -2.46492594e-01f, -6.85668439e-02f, -1.56116337e-01f, 5.08000217e-02f, -1.00099027e-01f, -1.92145735e-01f,
  -3.26946005e-02f, 5.90360239e-02f, 1.00680282e-02f, 1.09254934e-01f, 1.72812864e-01f, -2.65617430e-01f, -2.06919387e-01f, -4.05948833e-02f, 1.63431242e-01f, 1.05833113e-01f,
  1.09261245e-01f, 1.87735200e-01f, 1.13222532e-01f, 3.88935953e-02f, -7.22400323e-02f, 6.58194795e-02f, -4.33596224e-02f, -1.00710668e-01f, -1.00808680e-01f, -2.13572696e-01f,
  5.50619662e-02f, -1.04687765e-01f, -1.32492661e-01f, 8.64037871e-03f, -1.07359640e-01f, -2.59179492e-02f, 1.31866559e-02f, -1.26734659e-01f, 4.54607196e-02f, -1.03629023e-01f,
  -1.63708925e-01f, 1.03664899e-03f, 6.24576807e-02f, 1.32847011e-01f, 1.22834649e-02f, 1.13626227e-01f, -4.07856256e-02f, -1.08551987e-01f, -1.49902236e-02f, -4.94551063e-02f,
  -8.80873352e-02f, -1.36854917e-01f, -9.34259295e-02f, -2.64114067e-02f, -1.08170323e-01f, 2.22149957e-02f, 6.91357553e-02f, -1.51157320e-01f, 3.48454118e-02f, 3.32260095e-02f,
  9.63262469e-03f, 1.78685691e-02f, -6.55629039e-02f, 9.14617926e-02f, 2.34863888e-02f, 5.18993549e-02f, 3.15635763e-02f, 1.83891997e-01f, -1.96805429e-02f, 5.63467406e-02f,
  5.43687828e-02f, -1.49190545e-01f, -9.76557806e-02f, -4.14661281e-02f, 7.94358477e-02f, -3.92672196e-02f, -2.28682440e-02f, -4.57154326e-02f, 1.69122238e-02f, -2.63642445e-02f,
  -5.37550747e-02f, 1.19434122e-03f, 1.43984454e-02f, -3.55248526e-02f, -5.16816974e-02f, -9.84370112e-02f, -6.09148145e-02f, -8.08624253e-02f, 4.15897481e-02f, -1.44601807e-01f,
  3.14770550e-01f, -1.41840681e-01f, 3.45663689e-02f, 1.32849365e-01f, 1.44595414e-01f, -8.66635069e-02f, -1.29505962e-01f, -5.44149429e-02f, -1.66293666e-01f, -2.30411962e-02f,
  -5.37126362e-02f, -5.89532256e-02f, 8.41223374e-02f, 2.37890314e-02f, 7.65818357e-02f, -2.40709987e-02f, 6.11476647e-03f, -1.45576578e-02f, -2.63444278e-02f, -1.61540639e-02f,
  -9.64118019e-02f, 9.73265171e-02f, 5.42083085e-02f, 1.58836916e-02f, -2.55875960e-02f, 1.62852630e-01f, 2.39078179e-02f, -6.77498803e-02f, 1.24385789e-01f, 1.97393686e-01f,
  -2.50650615e-01f, 1.94882706e-01f, 7.38128349e-02f, -1.71400756e-01f, 1.64785072e-01f, 2.76762307e-01f, 3.86936516e-01f, 1.88897494e-02f, -1.17739610e-01f, 6.31480813e-02f,
  -2.02970067e-03f, -7.49000162e-02f, -1.31666616e-01f, 6.81018531e-02f, 1.72710270e-01f, 1.78530201e-01f, 1.35020778e-01f, 5.52892238e-02f, -2.02057119e-02f, -1.48087218e-02f,
  4.71150987e-02f, -8.72569084e-02f, -2.33038127e-01f, -1.45119816e-01f, -1.39344886e-01f, -7.75310621e-02f, -8.59055221e-02f, -1.52606452e-02f, 5.67032099e-02f, 2.98857242e-02f,
  -9.79644507e-02f, 1.54298991e-01f, -1.25930652e-01f, -5.05411550e-02f, -1.74018312e-02f, -1.58890918e-01f, -1.35488823e-01f, -1.41199753e-01f, 3.18155624e-02f, -1.02358364e-01f,
  -2.93910149e-02f, 9.79892835e-02f, 5.63278496e-02f, -8.65655486e-03f, 1.27094001e-01f, -5.01400642e-02f, 6.95870444e-02f, 1.19879954e-01f, -8.18895921e-02f, -1.34368408e-02f,
  -1.41828097e-02f, 9.11665335e-02f, -6.32897913e-02f, 1.44837588e-01f, 8.99819732e-02f, -4.33309190e-02f, 1.54816687e-01f, 4.92164642e-02f, 1.52904578e-02f, -8.81292969e-02f,
  -1.27908885e-01f, 6.16602674e-02f, 1.20228060e-01f, -4.55049612e-03f, -4.09373902e-02f, -6.79249093e-02f, 6.34035170e-02f, 2.76371717e-01f, 6.35226518e-02f, -1.99734769e-03f,
  -7.01388204e-03f, -4.42956723e-02f, -6.79589882e-02f, 1.94278136e-02f, -5.49051948e-02f, 2.35934835e-03f, -2.20324062e-02f, 4.91774566e-02f, 3.59392092e-02f, 3.47161107e-02f,
  2.51246430e-03f, -1.08971559e-01f, -1.08061083e-01f, -1.77317858e-02f, 4.51253951e-02f, -5.24393655e-03f, -1.38727650e-01f, -2.64023785e-02f, -1.23269409e-01f, -1.30729049e-01f,
  -2.44471192e-01f, 2.47259930e-01f, -7.60369673e-02f, -8.43545124e-02f, -4.02915627e-02f, 7.36662280e-03f, -7.18202963e-02f, -2.81251576e-02f, 7.05032945e-02f, -1.46113560e-01f,
  -9.36704203e-02f, -2.73446180e-03f, 1.37229294e-01f, 1.07156776e-01f, -8.51926208e-02f, -1.35900512e-01f, 4.30010408e-02f, 3.56657468e-02f, 1.38642434e-02f, -1.06904194e-01f,
  1.57542750e-02f, -1.25529423e-01f, -1.51823670e-01f, -9.61541105e-03f, -1.87115699e-01f, -1.25639349e-01f, -1.26963004e-01f, -6.82211593e-02f, -1.09030725e-03f, -1.86303511e-01f,
  8.11778679e-02f, -2.41609246e-01f, 3.44156772e-01f, 3.96796077e-01f, 2.94321209e-01f, 2.30370805e-01f, 2.68718481e-01f, 1.92329973e-01f, 1.89799711e-01f, 1.19337730e-01f,
  8.71069506e-02f, 1.81918934e-01f, 4.05130759e-02f, 7.59830028e-02f, 4.50529158e-02f, 1.61240339e-01f, 1.96873322e-01f, 2.49683522e-02f, 2.41502464e-01f, 1.21862061e-01f,
  1.18018262e-01f, -7.71555863e-03f, 8.77237692e-02f, 1.29082844e-01f, -1.00175269e-01f, 1.74807996e-01f, 1.74690366e-01f, 9.60042924e-02f, 9.10796896e-02f, -2.68083066e-02f,
  3.29786614e-02f, -5.83001226e-02f, 8.89799222e-02f, -1.91164799e-02f, -6.00284413e-02f, 5.42174606e-03f, -1.78176351e-02f, -6.43527433e-02f, -5.73248751e-02f, -5.25715649e-02f,
  -1.21830869e-02f, -1.19216613e-01f, 1.43837333e-02f, -1.64947614e-01f, -1.24024428e-01f, -5.43872863e-02f, -2.41350129e-01f, 4.71320599e-02f, 1.11628190e-01f, -1.58700757e-02f,
  -4.66651656e-02f, -7.09785223e-02f, -1.25269676e-02f, 1.36098862e-01f, -3.33999023e-02f, 4.76938821e-02f, 2.09323056e-02f, -1.42979711e-01f, 7.65739530e-02f, -4.08379324e-02f,
  1.93144143e-01f, -1.88403800e-02f, -2.81944014e-02f, 6.90683872e-02f, 9.66437440e-03f, -6.58409372e-02f, 7.04550073e-02f, 4.15356271e-02f, 7.20519647e-02f, -4.52492796e-02f,
  -9.59973931e-02f, 9.61180404e-02f, 1.14460751e-01f, 9.55119506e-02f, 8.26162174e-02f, 2.35624555e-02f, -6.37386441e-02f, 5.01588918e-02f, -1.06954671e-01f, -9.12138522e-02f,
  4.82405275e-02f, 2.88172346e-02f, -1.20204026e-02f, -1.38979152e-01f, -3.99325453e-02f, 8.46597627e-02f, 8.20394680e-02f, -9.75824371e-02f, 8.62727240e-02f, -3.45977582e-02f,
  2.27139577e-01f, 1.21189743e-01f, 2.23733131e-02f, -2.74025183e-02f, -4.87033911e-02f, -9.53363329e-02f, -6.78205909e-03f, -4.35894504e-02f, -3.08998507e-02f, 1.04629852e-01f,
  -6.70273453e-02f, 2.96727270e-02f, -1.27106205e-01f, -4.77888435e-02f, 6.35578185e-02f, -4.29416299e-02f, -2.72257239e-01f, 3.91542204e-02f, 1.13818325e-01f, 7.62523338e-02f,
  -6.54420108e-02f, 1.67850241e-01f, 2.23016798e-01f, 5.34712858e-02f, -4.87348512e-02f, 1.76140979e-01f, -2.32753735e-02f, 8.25272780e-03f, 1.92560684e-02f, 1.05152674e-01f,
  1.01231029e-02f, -1.12786926e-01f, 2.99200658e-02f, 8.97327736e-02f, 3.30111057e-01f, 2.88409293e-01f, 2.09633037e-01f, 2.71594375e-02f, 1.16109505e-01f, 5.83846979e-02f,
  4.80352715e-02f, 1.20784789e-02f, 1.09746652e-02f, -9.31405947e-02f, 1.92029551e-02f, 8.70340392e-02f, 5.79689033e-02f, 1.03777535e-01f, 2.69874297e-02f, 1.53181121e-01f,
  1.41743451e-01f, 1.14286572e-01f, -1.28428489e-01f, -3.06986477e-02f, -2.07078736e-02f, 1.19320802e-01f, 4.32140194e-03f, 6.47529811e-02f, 1.17847264e-01f, 3.64537723e-02f,
  -3.36956143e-01f, -1.86176016e-03f, 1.80981662e-02f, -7.19393417e-02f, -1.00447930e-01f, -2.52845854e-01f, 6.90825377e-03f, -1.50045663e-01f, -1.32191658e-01f, -1.03311658e-01f,
  -1.68436781e-01f, -6.10868521e-02f, 1.04870066e-01f, 3.18830721e-02f, 6.73844740e-02f, -1.39768273e-02f, -6.89571351e-02f, 7.54541010e-02f, 1.26644000e-01f, -5.82732074e-02f,
  4.05324437e-02f, 5.37738055e-02f, 2.08385482e-01f, 2.23569438e-01f, 1.88727751e-01f, 1.55770451e-01f, 1.08537246e-02f, 1.44762620e-01f, 4.73313741e-02f, -5.01702055e-02f,
  1.41653225e-01f, 1.91223562e-01f, 1.61758229e-01f, 1.33361012e-01f, -2.32269280e-02f, -7.12728649e-02f, 1.36642894e-02f, 1.23138174e-01f, 2.75803488e-02f, 6.42211810e-02f,
  1.08067043e-01f, 9.38738734e-02f, 8.09407793e-03f, 1.73163310e-01f, 4.58415672e-02f, 1.04839422e-01f, -6.07016496e-02f, -1.14857666e-01f, -6.60879724e-03f, -5.31070642e-02f,
  6.42923564e-02f, 6.92532584e-02f, 9.64080840e-02f, -3.26070413e-02f, 1.34170964e-01f, 2.35060900e-02f, 1.05981715e-01f, 6.08567335e-02f, 1.10221587e-01f, 1.99251935e-01f,
  -4.15520370e-01f, 2.04512686e-01f, -5.96877970e-02f, 1.16010867e-01f, 1.04269706e-01f, -1.34289220e-01f, 1.42455295e-01f, -3.81968357e-02f, -2.04942867e-01f, -2.63170391e-01f,
  -8.27468336e-02f, -5.23744561e-02f, 1.31683320e-01f, 1.53148472e-01f, 1.03737369e-01f, 7.31120408e-02f, 3.10621522e-02f, 1.49937975e-03f, -7.46179223e-02f, -2.51079053e-01f,
  -6.81639537e-02f, 1.34773180e-01f, 6.37029111e-02f, 1.66845337e-01f, 7.94041604e-02f, 1.40153244e-01f, -3.62987295e-02f, -1.85682047e-02f, 1.25609422e-02f, -4.25255336e-02f,
  -7.33075917e-01f, 1.79615617e-01f, 9.65354443e-02f, -3.34875226e-01f, -1.06040046e-01f, -1.65326238e-01f, 4.53274995e-02f, -5.75064160e-02f, -9.36031938e-02f, 1.68964900e-02f,
  1.22469179e-01f, -1.13650024e-01f, 1.17340438e-01f, 1.09392582e-02f, -6.12659827e-02f, 8.36660042e-02f, -7.73075223e-02f, -1.98585302e-01f, -2.56307185e-01f, -1.98850513e-01f,
  -1.06234953e-01f, -1.36641711e-01f, -3.19007844e-01f, -1.26419246e-01f, 1.04023568e-01f, -1.62043758e-02f, 1.48796275e-01f, -5.94218336e-02f, 8.62720981e-02f, 1.32148266e-01f,
  3.05535793e-01f, -2.83936441e-01f, -1.60355553e-01f, -2.30349675e-01f, 8.43870267e-03f, 6.62818104e-02f, -2.65723672e-02f, 5.24959154e-02f, 9.37990006e-03f, 5.28365374e-02f,
  1.37428502e-02f, 9.82762408e-03f, -4.67166677e-02f, 8.07825923e-02f, 1.76934917e-02f, 5.44329453e-03f, -2.83571668e-02f, -3.98786217e-02f, 2.24546082e-02f, 4.56297509e-02f,
  4.53032600e-03f, -2.97472700e-02f, 6.75716847e-02f, 1.10518420e-02f, 6.49210140e-02f, -4.61124703e-02f, 9.56202224e-02f, -7.50049353e-02f, -8.69609937e-02f, 1.32470831e-01f,
  1.56658213e-03f, 8.08822066e-02f, 9.00362581e-02f, 1.59624396e-04f, 1.11152500e-01f, 1.01778463e-01f, 9.70488712e-02f, 1.96576118e-01f, 6.71390668e-02f, 2.00204879e-01f,
  2.34436065e-01f, 1.84995398e-01f, 1.97913721e-01f, 1.51513115e-01f, 1.08282290e-01f, -8.83207098e-02f, 5.27511835e-02f, 2.21327379e-01f, 9.59625691e-02f, 8.36358685e-03f,
  1.01922959e-01f, 1.41872197e-01f, 7.16082528e-02f, 2.96569504e-02f, 1.37725726e-01f, 7.06976727e-02f, -2.66897096e-03f, -4.42808727e-04f, 7.21028401e-03f, -6.40480742e-02f,
  2.92295694e-01f, -1.90183684e-01f, 5.89373000e-02f, -5.89678474e-02f, 7.21631572e-02f, 1.28998905e-02f, 1.21236131e-01f, -2.92045921e-02f, 8.64962488e-03f, 9.04150307e-02f,
  -5.48508614e-02f, 9.59854722e-02f, 1.02428675e-01f, 1.47994101e-01f, -5.17688831e-03f, 1.21157914e-02f, 4.58003059e-02f, 2.90439818e-02f, -9.97684617e-03f, 9.89437774e-02f,
  7.87034854e-02f, -1.37037402e-02f, 1.83651745e-02f, 1.50726378e-01f, 7.29304776e-02f, -1.67426374e-02f, 1.91060647e-01f, 1.29968777e-01f, 4.32775402e-03f, 2.26268694e-01f,
  6.31503314e-02f, -1.37685984e-01f, 3.75766121e-02f, 1.13583669e-01f, 1.48875400e-01f, 3.26012611e-01f, 4.87497807e-01f, 1.39546171e-01f, -7.93733448e-02f, 6.05022795e-02f,
  -1.48221657e-01f, -3.65336418e-01f, -3.96198958e-01f, -1.76108286e-01f, -1.24349110e-01f, 3.20973486e-01f, 2.46599898e-01f, -5.36084138e-02f, 2.28678132e-03f, 8.77416953e-02f,
  -1.70357730e-02f, -9.06621944e-03f, -4.40122634e-02f, -9.28254277e-02f, -5.01942262e-02f, -3.17058265e-02f, 6.71630213e-03f, 2.47772764e-02f, -1.19716652e-01f, -8.59091952e-02f,
  -1.93659469e-01f, -2.39769757e-01f, 3.86980586e-02f, -7.85650015e-02f, -1.89105034e-01f, -7.78061822e-02f, 2.61426391e-03f, -1.43461615e-01f, -1.98906362e-01f, -1.10240415e-01f,
  5.09343222e-02f, -7.39209428e-02f, -1.38041571e-01f, 3.72467376e-02f, 7.91189075e-02f, -7.31733814e-02f, -1.01832628e-01f, -1.31053388e-01f, -2.23697066e-01f, -8.44671354e-02f,
  -1.22071154e-01f, -9.52072963e-02f, -1.45928577e-01f, -1.42003521e-01f, -1.79601789e-01f, -1.53328553e-01f, -4.59587798e-02f, -1.90772921e-01f, -1.70315430e-01f, 1.96896009e-02f,
  3.39403562e-02f, 1.20211104e-02f, -2.96439584e-02f, 1.03507347e-01f, 6.49018586e-02f, 1.48197440e-02f, 7.85970539e-02f, -1.09797977e-01f, -9.25556421e-02f, -5.96681498e-02f,
  -9.93685890e-03f, 1.02839224e-01f, -9.91770849e-02f, 1.05724838e-02f, -1.37005411e-02f, 2.67495401e-02f, 3.67840268e-02f, -3.27517763e-02f, -5.25423102e-02f, 2.41793506e-02f,
  -9.48652253e-02f, -1.52797801e-02f, 1.98607836e-02f, 1.03309248e-02f, -1.58441719e-03f, 5.31749204e-02f, -4.36661951e-02f, 2.32349196e-03f, 5.75270951e-02f, 1.56222312e-02f,
  3.64674702e-02f, -3.69474031e-02f, 1.38435423e-01f, -7.71302879e-02f, 1.29819978e-02f, -2.99369115e-02f, 5.66255003e-02f, -3.60021293e-02f, -1.55394226e-01f, 7.36488262e-03f,
  1.81029588e-02f, 3.73545848e-02f, -7.95832053e-02f, -8.18866566e-02f, 1.31101906e-01f, 5.32372929e-02f, 1.00914612e-01f, -5.26599400e-02f, -3.19344439e-02f, -1.09848091e-02f,
  7.68684149e-02f, 1.31329104e-01f, 8.68726745e-02f, 8.38700384e-02f, 3.31186503e-02f, 1.31310984e-01f, 4.89131622e-02f, 8.65561962e-02f, 1.02029733e-01f, 2.83439726e-01f,
  1.59445360e-01f, 3.31856698e-01f, -1.92384068e-02f, 4.73074839e-02f, -2.36526877e-01f, -2.63728142e-01f, 3.14398259e-02f, 1.00435145e-01f, 4.10143211e-02f, 2.29223400e-01f,
  -2.23218631e-02f, -8.73524696e-02f, -8.22282732e-02f, -9.05865207e-02f, -2.19818149e-02f, 2.61817783e-01f, -1.11862272e-02f, -1.03693239e-01f, -2.72770911e-01f, -2.05372810e-01f,
  -1.87160805e-01f, 4.70863245e-02f, 1.07651256e-01f, -4.16069441e-02f, -1.27739254e-02f, -3.80474031e-02f, 1.10895306e-01f, -9.30258483e-02f, -1.73840061e-01f, -1.12419920e-02f,
  -1.19760223e-02f, -2.22792998e-01f, -1.51734546e-01f, -2.22633258e-01f, -1.52043685e-01f, -4.65823971e-02f, 3.97798941e-02f, -1.23151243e-02f, 2.02375818e-02f, 2.66846083e-02f,
  -9.73460451e-02f, -1.45824747e-02f, -2.52407491e-01f, -1.44047126e-01f, -6.63353577e-02f, -2.39831492e-01f, 8.24613422e-02f, -4.20827791e-02f, -2.96340864e-02f, -2.30291043e-03f,
  -1.09826200e-01f, -2.41014734e-01f, -1.11716278e-01f, -6.35879859e-02f, -2.17883475e-02f, -1.69363797e-01f, -4.17926237e-02f, -1.61999971e-01f, -1.33640379e-01f, 1.89368546e-01f,
  3.77468280e-02f, -2.47931276e-02f, -6.49742335e-02f, 1.03895500e-01f, 1.12299629e-01f, -1.16590515e-01f, -1.79026350e-02f, 1.85969308e-01f, -3.19638252e-02f, 4.59508970e-02f,
  -5.36755286e-03f, 1.04419336e-01f, -1.18929632e-01f, 3.18867862e-02f, 7.23180771e-02f, -6.19970076e-02f, -8.50194097e-02f, 7.92417303e-02f, 4.72657159e-02f, -1.33777261e-01f,
  -8.95660818e-02f, -5.12348786e-02f, -9.61232372e-03f, 7.31479302e-02f, 2.64620055e-02f, -3.92903835e-02f, 3.64131853e-02f, -1.31918430e-01f, 5.66285998e-02f, 5.81167592e-03f,
  2.47222751e-01f, -3.92369986e-01f, 2.52346814e-01f, -7.97039494e-02f, -7.00876936e-02f, -2.96614654e-02f, 9.12219435e-02f, -1.29092112e-01f, -8.45193304e-03f, 2.12815660e-03f,
  -7.22996816e-02f, 1.17041662e-01f, -5.40828407e-02f, -1.45748137e-02f, -1.55687660e-01f, -1.40777037e-01f, 1.18725762e-01f, 2.00421433e-04f, -5.24111800e-02f, 1.05384663e-02f,
  3.09111953e-01f, 9.79314893e-02f, 1.83772549e-01f, 2.46044751e-02f, 4.73753661e-02f, -5.30226063e-03f, -2.22341134e-03f, 1.08776405e-01f, -7.90877193e-02f, 4.62315708e-01f,
  6.70583025e-02f, -4.34672743e-01f, -3.17385703e-01f, -7.09726214e-02f, 2.37936392e-01f, 3.50308448e-01f, 3.06515098e-01f, 9.58141088e-02f, 1.45587891e-01f, -1.36697128e-01f,
  -2.50081539e-01f, -2.91699618e-01f, -2.80754417e-01f, -3.32790881e-01f, -2.42015496e-01f, 5.67469560e-03f, 5.12048453e-02f, -1.30864650e-01f, 2.47466490e-01f, 3.93558562e-01f,
  8.99048746e-02f, 8.42922553e-03f, -1.36601195e-01f, 9.33800731e-03f, -1.19214868e-02f, -4.32405956e-02f, -7.62447864e-02f, -1.32896557e-01f, -3.60728689e-02f, -2.54897624e-01f,
  -3.53537887e-01f, -3.24035376e-01f, 1.93627492e-01f, -2.25657932e-02f, -3.83461975e-02f, 2.46780422e-02f, -2.44796909e-02f, 1.01995714e-01f, 1.24621823e-01f, 8.11116304e-03f,
  -9.56897363e-02f, -2.97232270e-02f, -4.78480458e-02f, 2.46202573e-02f, 1.03384092e-01f, 2.24200767e-02f, -3.18964906e-02f, -1.57295400e-03f, -1.35998711e-01f, -1.20054856e-01f,
  -1.25573143e-01f, 1.33580893e-01f, 6.79384172e-02f, 1.88431427e-01f, 5.46026006e-02f, 1.00257739e-01f, -8.10943358e-03f, 1.42896518e-01f, 1.59745187e-01f, 2.60851473e-01f,
  -6.01949655e-02f, 5.55301830e-02f, 3.02156378e-02f, 1.46048114e-01f, 9.04247239e-02f, 1.98256940e-01f, 1.17580101e-01f, 1.30492195e-01f, -9.65989567e-03f, 5.80367781e-02f,
  -3.34772542e-02f, -1.65503278e-01f, -3.35658714e-02f, 2.22537369e-02f, -2.02176139e-01f, -1.69809908e-01f, 3.95969115e-02f, -1.06494352e-01f, -1.34678081e-01f, 2.01119389e-02f,
  -7.80661255e-02f, 8.44668746e-02f, -2.26882868e-04f, -6.50125071e-02f, -1.56277910e-01f, -5.08149751e-02f, -8.84494483e-02f, -6.61463290e-02f, -7.39222765e-02f, -1.07788935e-01f,
  -4.39373180e-02f, -3.33818734e-01f, -3.52570750e-02f, -4.30751219e-02f, -3.16418856e-02f, -1.81536660e-01f, -2.12199047e-01f, -1.77451551e-01f, -8.25525820e-02f, -2.65180655e-02f,
  -7.65206590e-02f, -6.15601875e-02f, -2.43105620e-01f, 7.48635083e-02f, 2.73987353e-01f, 6.64291754e-02f, -5.28467596e-02f, 1.39681831e-01f, -9.38262716e-02f, -1.90989319e-02f,
  -6.69917539e-02f, 1.37277231e-01f, 2.24057779e-01f, 1.16521113e-01f, 2.28572011e-01f, 1.35538816e-01f, 1.35518610e-01f, 1.66075394e-01f, 9.06372666e-02f, 3.65561128e-01f,
  6.18933082e-01f, -4.52993184e-01f, -1.08381808e-01f, 1.88945115e-01f, -1.73607059e-02f, 1.36858046e-01f, -1.50455954e-02f, 5.84769025e-02f, 1.63347691e-01f, -8.50579068e-02f,
  2.88405921e-02f, 1.46855056e-01f, 1.14547528e-01f, 1.17967688e-01f, 1.70123696e-01f, -1.53037846e-01f, -2.25788027e-01f, 1.01083800e-01f, 3.15578550e-01f, 4.63433787e-02f,
  -1.03600696e-01f, -7.20749125e-02f, 1.28498361e-01f, 3.62666883e-02f, -2.63613909e-01f, 1.68584622e-02f, -2.83166677e-01f, -2.63850600e-01f, -1.75855368e-01f, -4.60381448e-01f,
  -1.07328705e-01f, -4.15197425e-02f, 1.77735999e-01f, 6.28522113e-02f, -1.52590916e-01f, 2.14676205e-02f, -1.75067894e-02f, -1.30125642e-01f, -1.00932322e-01f, -9.52808261e-02f,
  -7.74671324e-03f, -3.31303217e-02f, -5.77745326e-02f, 3.38759534e-02f, -2.03537256e-01f, 1.02517195e-02f, -2.35658571e-01f, 2.46176086e-02f, 1.12776056e-01f, -4.09225821e-02f,
  -1.02091253e-01f, -8.31511021e-02f, -8.97383466e-02f, -8.31043497e-02f, 2.07994487e-02f, 1.30248696e-01f, -2.36979112e-01f, -6.71131685e-02f, -1.11559510e-01f, -1.26399979e-01f,
  9.22691822e-02f, 8.23863968e-02f, -4.51712161e-02f, -8.16939548e-02f, 6.34501353e-02f, 9.04582664e-02f, -9.13234130e-02f, -4.35458124e-02f, -2.09535100e-02f, -1.73692685e-02f,
  1.95095800e-02f, 4.59592752e-02f, 1.03287786e-01f, -2.76574418e-02f, 4.73884307e-02f, 4.92316112e-02f, -4.31637466e-02f, 1.76015869e-02f, -3.86027806e-02f, 1.02284797e-01f,
  9.20811817e-02f, 1.93306394e-02f, -1.19017228e-03f, -8.50054063e-03f, 4.00383472e-02f, 1.28447439e-03f, 5.58303036e-02f, -2.65939087e-02f, 1.10898411e-03f, 1.09778896e-01f,
  -4.86276159e-03f, 1.39830023e-01f, 1.24225646e-01f, -1.95990913e-02f, -5.53258136e-02f, 1.27166167e-01f, 1.08562633e-01f, 2.43377239e-02f, -7.57922903e-02f, 7.36384140e-03f,
  -1.14435786e-02f, -3.30464542e-02f, -8.28203633e-02f, -9.46815982e-02f, 5.96596859e-02f, 6.13749251e-02f, -1.53692856e-01f, 2.01384932e-01f, 1.08819686e-01f, -5.89666180e-02f,
  -3.37372310e-02f, 7.60562494e-02f, 2.15936989e-01f, 1.27485558e-01f, -4.16416228e-02f, 2.16774017e-01f, 2.77586151e-02f, 6.24520481e-02f, 1.62608534e-01f, 1.07571505e-01f,
  -4.95336801e-01f, -1.69386432e-01f, -1.25818491e-01f, 1.93486479e-03f, 3.30471218e-01f, 4.79958028e-01f, 3.05645645e-01f, 3.65062281e-02f, 3.37516628e-02f, 7.42729055e-03f,
  -2.66353488e-01f, -1.73056334e-01f, -1.93474695e-01f, 3.13543715e-02f, 1.38557673e-01f, 2.04302669e-01f, 2.00994715e-01f, 3.06803025e-02f, 1.62309721e-01f, 1.18775167e-01f,
  1.42520502e-01f, 1.76838823e-02f, -2.37483338e-01f, 4.62136641e-02f, 1.33036777e-01f, 8.31304789e-02f, 2.25201044e-02f, -2.47782636e-02f, -2.81203836e-02f, 7.18661249e-02f,
  -2.79691458e-01f, -4.71727550e-01f, 1.36374667e-01f, -2.05429330e-01f, -1.22843139e-01f, -1.76830411e-01f, -1.28265589e-01f, -1.43036500e-01f, -1.57261395e-03f, -1.52593747e-01f,
  -6.61913082e-02f, -6.71076924e-02f, -1.62197828e-01f, 4.16696556e-02f, -1.25401691e-01f, -2.72707175e-02f, -4.13261876e-02f, -5.14480434e-02f, -1.60666257e-01f, -1.19423367e-01f,
  4.89191189e-02f, -7.56512508e-02f, -2.56597221e-01f, 1.35494797e-02f, -2.46073194e-02f, -1.06303040e-02f, 3.31502818e-02f, -9.45231095e-02f, -1.42847478e-01f, -2.78300166e-01f,
  3.25052328e-02f, -1.72345191e-02f, -2.06839424e-02f, -6.58893734e-02f, 8.26050043e-02f, 6.32606372e-02f, -7.27252811e-02f, -3.83964851e-02f, 1.22946911e-02f, 7.38634840e-02f,
  -6.61566257e-02f, 1.43530378e-02f, -1.43213108e-01f, -9.30355340e-02f, 1.44710150e-02f, 1.28650162e-02f, 1.67722449e-01f, -2.96642296e-02f, -4.75005470e-02f, -1.71759762e-02f,
  2.70755235e-02f, 2.07287334e-02f, -8.37298557e-02f, -4.30254899e-02f, 2.13807210e-01f, 2.45925169e-02f, 1.28023803e-01f, -2.67839152e-03f, -3.22475769e-02f, -6.16400093e-02f,
  -1.67762503e-01f, -8.69057234e-03f, -1.85254216e-01f, -1.12908043e-01f, 6.50739344e-03f, 8.12158920e-03f, -1.03127435e-01f, 2.02733465e-03f, -9.78854150e-02f, -1.21947475e-01f,
  -7.07434267e-02f, -1.45754308e-01f, -1.20953452e-02f, -1.36936950e-02f, 1.70258626e-01f, -8.90906714e-03f, 9.83870700e-02f, 1.39024585e-01f, 1.64535120e-01f, 1.97127741e-02f,
  9.69184339e-02f, 1.82781875e-01f, -2.68367063e-02f, 5.92857338e-02f, 4.53197537e-03f, 1.56015083e-01f, 8.15213248e-02f, 1.24769107e-01f, 3.37372310e-02f, -4.55152318e-02f,
  1.81499854e-01f, 4.89557385e-02f, 1.44746393e-01f, 1.20463386e-01f, 3.50005805e-01f, 4.37368035e-01f, 4.68957543e-01f, 2.94212490e-01f, -3.80458720e-02f, 2.15213358e-01f,
  -4.45762649e-02f, -2.07977220e-01f, -1.85672209e-01f, -2.05407739e-01f, -1.69917177e-02f, 1.68990314e-01f, 8.60356018e-02f, 3.73616628e-02f, 7.64524341e-02f, 1.04798600e-01f,
  -2.33920999e-02f, 1.26461357e-01f, 3.41963023e-02f, -3.56040732e-03f, 2.21111607e-02f, -6.70858547e-02f, 1.44183949e-01f, 2.36485824e-01f, 6.55786023e-02f, -1.54338047e-01f,
  -7.60947168e-02f, 3.10782909e-01f, -1.97656885e-01f, -1.73401266e-01f, -1.12026483e-01f, -1.66746840e-01f, -1.06710553e-01f, -1.26051545e-01f, -8.48258659e-02f, -1.33833155e-01f,
  -8.40374455e-02f, 1.83431283e-02f, 1.24822728e-01f, 7.63784498e-02f, 7.52977505e-02f, -4.84764315e-02f, 2.61168964e-02f, 8.83271992e-02f, 1.42213300e-01f, 7.29045877e-03f,
  -7.04622641e-02f, 1.43841922e-01f, 2.77339935e-01f, 2.08558619e-01f, 7.93561190e-02f, -5.84818386e-02f, 7.91303813e-02f, 7.66549781e-02f, -1.42906699e-02f, -2.15926934e-02f,
  -1.33204639e-01f, 2.97553148e-02f, 6.81977049e-02f, 2.76831128e-02f, 1.40679185e-03f, -1.10913329e-01f, -1.44116953e-01f, -5.30700311e-02f, 6.68926910e-02f, 8.83924291e-02f,
  2.56323703e-02f, 7.74976388e-02f, 6.91896155e-02f, 7.88868964e-02f, -3.51147205e-02f, 8.43528360e-02f, 5.67531511e-02f, 2.66542770e-02f, 6.52279705e-02f, 1.30636096e-01f,
  1.47954866e-01f, 9.98437330e-02f, -5.46440408e-02f, 4.49600369e-02f, -3.32726501e-02f, 4.46996726e-02f, 4.82261814e-02f, -2.97679976e-02f, -9.39168781e-02f, 1.95161942e-02f,
  1.80769786e-01f, 1.13664120e-01f, -1.92757770e-01f, -1.03510402e-01f, 5.91604412e-02f, -1.62433051e-02f, 1.89447105e-02f, 2.36833524e-02f, -5.96435778e-02f, -5.28186262e-02f,
  -8.66854563e-02f, -1.84213385e-01f, -6.54930696e-02f, -1.32784462e-02f, -4.95278351e-02f, -2.17382815e-02f, -2.40683898e-01f, -3.75079326e-02f, -3.33304703e-02f, -8.60955268e-02f,
  -4.36845794e-02f, -6.15417324e-02f, 1.38249993e-01f, 5.65723516e-02f, -6.38752729e-02f, -1.92573979e-01f, 4.24706377e-02f, 6.04923163e-03f, 2.20456701e-02f, -2.24756077e-02f,
  6.05589926e-01f, 7.67873153e-02f, 2.53087372e-01f, 2.89203912e-01f, -4.23119916e-03f, -2.73916940e-03f, -4.58065420e-03f, 1.98894456e-01f, 7.80358464e-02f, 1.71443820e-01f,
  9.62409452e-02f, 3.08628857e-01f, 1.15069829e-01f, 2.25643665e-01f, 8.01711082e-02f, -1.03264391e-01f, -1.16254047e-01f, 1.01295114e-01f, 2.49558181e-01f, 8.37709606e-02f,
  -1.14622541e-01f, 2.05212831e-02f, 1.65655687e-01f, 1.43495277e-01f, -9.63213369e-02f, 1.24618739e-01f, 8.86015743e-02f, -1.28604010e-01f, -1.25979483e-01f, -1.26019344e-01f,
  -1.24095939e-01f, 2.33700410e-01f, 1.72483087e-01f, 9.35413316e-03f, -6.55257888e-03f, 7.72824660e-02f, 2.04479501e-01f, -2.62186136e-02f, 2.11891681e-02f, -5.17962687e-02f,
  -7.73964263e-03f, 1.25624128e-02f, -9.99713540e-02f, -3.49740824e-03f, -5.67944311e-02f, 4.77581359e-02f, -2.29769908e-02f, 7.17990026e-02f, 1.25806719e-01f, 1.84294730e-02f,
  -1.49079571e-02f, -8.62841159e-02f, 2.68556066e-02f, 7.27753863e-02f, 2.34031454e-02f, 1.01002932e-01f, -1.63164735e-02f, -3.97883132e-02f, 1.43324614e-01f, 2.11296286e-02f,
  -3.60736437e-02f, 1.27648637e-01f, 1.74923241e-02f, -4.82845120e-02f, 6.75647259e-02f, 8.67993683e-02f, -6.50086105e-02f, -8.67572986e-03f, 8.22530836e-02f, -5.06265871e-02f,
  -5.73666692e-02f, 1.78766251e-01f, 1.34920806e-01f, 1.11145549e-01f, 5.47327474e-03f, -4.73719537e-02f, -2.91475132e-02f, 1.17219061e-01f, -5.80414943e-02f, -1.04656757e-03f,
  1.26708835e-01f, -4.09466401e-02f, -3.91267985e-02f, -9.67911184e-02f, 2.12865006e-02f, 1.41265720e-01f, -2.69360375e-02f, -9.96231381e-03f, -6.20152354e-02f, -3.43749970e-02f,
  -1.26153558e-01f, 1.16999306e-01f, 1.07630573e-01f, -6.31544888e-02f, -4.16728035e-02f, 1.08857434e-02f, 1.57455757e-01f, 8.90964046e-02f, -1.35303944e-01f, -1.26947146e-02f,
  4.05784808e-02f, -3.27569880e-02f, -4.08706293e-02f, -4.88972962e-02f, -4.72534858e-02f, 1.19010948e-01f, -7.33166784e-02f, 1.11402094e-01f, 3.52519527e-02f, -1.01908587e-01f,
  -1.53316736e-01f, 7.74468407e-02f, 1.52013049e-01f, 2.94032297e-03f, -2.13798843e-02f, 6.93854615e-02f, -1.00637101e-01f, -4.50231060e-02f, 6.62958473e-02f, 2.21710969e-02f,
  4.04867172e-01f, 2.36355111e-01f, 1.95790723e-01f, 7.92312920e-02f, -7.94687215e-03f, -8.01091567e-02f, -2.16699541e-01f, -8.87372810e-03f, -2.49045459e-03f, -9.94145405e-03f,
  6.01240546e-02f, 1.99412540e-01f, 4.63605523e-02f, 1.37722179e-01f, 1.44305959e-01f, 2.68694591e-02f, 6.95249671e-03f, 8.95460844e-02f, 8.70347470e-02f, 7.36694485e-02f,
  -1.01830028e-01f, -1.41666844e-01f, 7.66921863e-02f, -1.89872999e-02f, 8.30234401e-03f, -5.72360940e-02f, -1.17768332e-01f, 4.68365848e-02f, 6.35759998e-03f, 1.85540900e-01f,
  1.21442102e-01f, 1.67211518e-01f, 2.62528285e-02f, -1.14321113e-01f, -4.61543277e-02f, -1.07130148e-01f, -6.45234287e-02f, -3.81106064e-02f, -9.44852084e-02f, -1.10300049e-01f,
  -1.87222715e-02f, -5.33242896e-02f, -4.66192141e-02f, -2.03538239e-01f, -8.09197053e-02f, 3.49584408e-02f, 2.92512495e-02f, -1.05364129e-01f, 9.29850265e-02f, 5.95825054e-02f,
  9.98042822e-02f, -1.42302573e-01f, -7.49746338e-02f, -5.14263138e-02f, 3.02254222e-02f, 3.38716805e-02f, 4.09112200e-02f, -4.35029482e-03f, -1.81836896e-02f, 1.33199082e-03f,
  1.53649986e-01f, 1.86887801e-01f, 3.67021561e-02f, 3.33109754e-03f, -2.38469075e-02f, -8.10568556e-02f, -8.06937665e-02f, -7.22557232e-02f, 6.46563694e-02f, -1.68068752e-01f,
  -1.13304734e-01f, 8.02204236e-02f, 9.25498307e-02f, 7.03385845e-02f, -4.25537452e-02f, 3.60726938e-02f, 6.71238406e-03f, 4.01665792e-02f, 4.35010083e-02f, -3.03500555e-02f,
  4.14841771e-02f, -1.11465491e-02f, 2.62412131e-02f, -2.26135296e-03f, 5.46927303e-02f, 9.88245457e-02f, -4.54678908e-02f, 4.06472273e-02f, -2.22271588e-02f, 1.67926271e-02f,
  -2.92415589e-01f, 1.04298510e-01f, 1.08472705e-01f, 1.31743908e-01f, 4.86112125e-02f, 8.32145810e-02f, 1.78992018e-01f, -8.24019406e-03f, -1.37484372e-01f, 4.30520475e-02f,
  1.30755991e-01f, 4.23844308e-02f, 1.87916066e-02f, -7.57207945e-02f, -3.14309113e-02f, -3.27274725e-02f, 1.42794875e-02f, 5.64248953e-03f, 3.79206389e-02f, 1.74539313e-02f,
  1.36448935e-01f, 8.35846085e-03f, -9.39842407e-03f, -7.20192818e-03f, 8.96525159e-02f, 1.53787155e-02f, -7.25825652e-02f, 3.46630178e-02f, 4.51859785e-03f, -1.54930115e-01f,
  -1.40076861e-01f, -7.20058829e-02f, -1.42185450e-01f, 1.62311420e-01f, 3.10259491e-01f, 8.87281075e-02f, 9.90570784e-02f, 2.84158834e-03f, 8.80544186e-02f, 7.98346177e-02f,
  7.29510188e-02f, 2.50981212e-01f, 1.74307242e-01f, 5.52741773e-02f, 3.58834453e-02f, 1.23967841e-01f, 2.58857340e-01f, -5.64406812e-03f, -3.05200294e-02f, 1.39855385e-01f,
  1.23299181e-01f, -1.10235646e-01f, -1.63400590e-01f, -1.02231257e-01f, 2.26534680e-01f, 1.61262408e-01f, -6.95611462e-02f, -3.64561081e-02f, 4.05640826e-02f, 3.94812286e-01f,
  -3.34263556e-02f, -1.20622873e-01f, 2.43065715e-01f, 8.26691240e-02f, -4.44625057e-02f, -3.05952787e-01f, -1.77204102e-01f, -1.60140678e-01f, -1.65563226e-01f, -1.61585614e-01f,
  4.18852754e-02f, -8.24669674e-02f, 1.19813524e-01f, -1.26511425e-01f, -4.58460338e-02f, 4.66749258e-02f, -1.00707002e-01f, -6.66168258e-02f, -9.97295380e-02f, -6.83221519e-02f,
  1.22943781e-01f, -1.00999638e-01f, -5.22782467e-02f, -7.14477077e-02f, 2.78489739e-02f, 3.34199425e-03f, 4.58319373e-02f, -4.16108966e-02f, -2.23942131e-01f, -1.60233185e-01f,
  -9.04192254e-02f, -1.98300868e-01f, -1.86458486e-03f, 4.98306118e-02f, -1.10232038e-02f, -1.69290639e-02f, 7.79262409e-02f, 7.97870606e-02f, 2.53256075e-02f, -4.01981138e-02f,
  -6.15572296e-02f, -3.08365747e-02f, 1.78730227e-02f, -3.66427749e-02f, 1.21334475e-02f, -4.49773706e-02f, 3.14246304e-02f, -5.23505211e-02f, -6.00672960e-02f, -1.94584444e-01f,
  1.57216653e-01f, 1.63386781e-02f, -1.78352147e-01f, 1.43378466e-01f, 1.44792885e-01f, -1.51813820e-01f, -1.12695403e-01f, -1.01887971e-01f, -1.01392239e-01f, -1.46435991e-01f,
  -3.84738833e-01f, -1.11272536e-01f, 2.80592173e-01f, 5.96025512e-02f, 7.04289123e-05f, -8.60562176e-02f, -3.79626974e-02f, -6.09943122e-02f, 3.24439742e-02f, -1.31874025e-01f,
  -1.52312413e-01f, 3.40680294e-02f, -5.42389601e-02f, -1.04927927e-01f, 1.51404738e-01f, -9.13480744e-02f, 6.06480613e-02f, 6.52219802e-02f, -6.07395843e-02f, 4.07939069e-02f,
  3.09065115e-02f, 4.41065170e-02f, 9.61881950e-02f, 1.16625533e-01f, 1.16618097e-01f, 2.11066119e-02f, -1.05310678e-01f, -9.37180743e-02f, -2.02893242e-01f, -2.74694413e-01f,
  -6.13869369e-01f, -1.07308321e-01f, 3.86389643e-01f, -3.53232585e-02f, 1.28526211e-01f, 2.40659043e-01f, 2.06039637e-01f, -7.64632132e-03f, -2.84212679e-01f, -7.19904006e-02f,
  -1.89193524e-02f, 5.44108152e-02f, 6.96235895e-02f, 1.08063936e-01f, 7.62805715e-02f, 1.61014199e-01f, 7.86479563e-02f, 1.20364718e-01f, 1.10721491e-01f, 1.49994707e-02f,
  -1.13261389e-02f, -6.25654384e-02f, -1.35445848e-01f, -1.43784598e-01f, 4.46595959e-02f, -1.61055606e-02f, 6.21915758e-02f, 5.24221994e-02f, 3.04027498e-02f, -1.06279157e-01f,
  6.26785159e-01f, -2.22019106e-01f, -7.45562240e-02f, -1.83031067e-01f, -4.47112657e-02f, -1.60304934e-01f, -6.64417446e-02f, -6.71950579e-02f, -6.32517785e-02f, -9.58324969e-02f,
  7.50045255e-02f, -6.71937093e-02f, -5.76062538e-02f, 3.30223478e-02f, 1.11696087e-01f, 1.24162231e-02f, -1.98793456e-01f, -1.57222092e-01f, 3.12676169e-02f, 1.78981036e-01f,
  -1.73862502e-01f, -3.94624211e-02f, 1.06969513e-01f, -2.09243875e-02f, -6.44805878e-02f, -1.28107026e-01f, 3.74211967e-02f, -7.50515461e-02f, 1.39271636e-02f, -2.48373851e-01f,
  1.18277885e-01f, -2.93490570e-02f, -1.03487231e-01f, 3.13871950e-02f, -1.15993522e-01f, -3.10561899e-02f, 3.54082994e-02f, 8.91381036e-03f, -9.51206535e-02f, -7.45982528e-02f,
  -1.20886549e-01f, 6.93849474e-02f, 5.49002774e-02f, -1.30037805e-02f, -6.61888346e-02f, 6.55739754e-03f, 1.16593949e-01f, -1.42051894e-02f, 2.43509188e-02f, 1.54602407e-02f,
  2.79622618e-02f, 5.04802912e-02f, -2.00324673e-02f, -6.98377341e-02f, -4.55277711e-02f, -5.63350506e-02f, -2.76268944e-02f, -1.15800127e-01f, -7.65202492e-02f, -1.20050432e-02f,
  4.40692753e-01f, -1.24927713e-02f, 8.41458365e-02f, -2.06834730e-02f, 1.58047050e-01f, -2.01357052e-01f, 6.10766746e-02f, 8.55360627e-02f, 1.96755826e-01f, 9.63783860e-02f,
  5.29729575e-02f, 1.99083444e-02f, 3.48988585e-02f, -2.53391135e-02f, -1.41928084e-02f, 3.73924337e-02f, -1.64906755e-01f, 1.05403133e-01f, 1.67342573e-01f, 2.59779572e-01f,
  -1.39860466e-01f, -6.36974052e-02f, 1.76508531e-01f, 1.12517765e-02f, 3.08907847e-03f, 9.55366492e-02f, 2.16196433e-01f, 7.21471161e-02f, 1.76303893e-01f, -3.51121463e-02f,
  3.15289617e-01f, -1.46352425e-01f, -2.98792243e-01f, 1.16142564e-01f, -2.80256867e-01f, -3.21914345e-01f, -4.16408718e-01f, 4.44358848e-02f, 1.13405548e-01f, -3.04732531e-01f,
  -3.64344306e-02f, 1.52901351e-01f, 1.07089534e-01f, 4.63517196e-02f, -1.00711863e-02f, -3.54374349e-01f, -2.79711664e-01f, -1.58861324e-01f, 5.90932108e-02f, 2.56535839e-02f,
  7.22590834e-02f, 1.55370757e-01f, 1.99109271e-01f, 1.09896757e-01f, -1.19060569e-01f, 6.48871437e-03f, -1.84478506e-01f, -1.59709960e-01f, -1.42393112e-01f, -2.89187014e-01f,
  -2.34220296e-01f, -2.90403198e-02f, -1.51234210e-01f, 7.45519400e-02f, -6.91086128e-02f, -9.95833278e-02f, -1.19800329e-01f, 5.28663723e-03f, 6.21839389e-02f, -2.90890113e-02f,
  -4.07644324e-02f, 5.17082624e-02f, -4.68238965e-02f, -4.29909602e-02f, -1.90986115e-02f, 8.49475116e-02f, -8.25019628e-02f, 5.88062815e-02f, -1.14159636e-01f, -7.28055984e-02f,
  7.88027123e-02f, 2.80256942e-02f, -1.00441225e-01f, -1.51185453e-01f, -2.21395910e-01f, -7.46212825e-02f, -1.55458048e-01f, -1.76789925e-01f, -2.40418822e-01f, -8.51687640e-02f,
  -1.63017601e-01f, -3.47945206e-02f, 3.43312062e-02f, 1.04689531e-01f, 1.71361998e-01f, 4.61509116e-02f, 9.65554044e-02f, 5.70930913e-02f, 2.42873263e-02f, 9.64328647e-03f,
  1.09059522e-02f, -1.42920554e-01f, 1.35070551e-02f, -4.25222479e-02f, -3.41199664e-03f, -5.60498647e-02f, 4.25071456e-02f, -9.26582217e-02f, 3.72186154e-02f, 5.50713157e-03f,
  3.13435793e-02f, 3.51514369e-02f, 4.30003777e-02f, 8.11721385e-02f, 3.63811175e-03f, 5.89578710e-02f, 2.31381115e-02f, 7.78356194e-02f, 4.38083932e-02f, -4.75584110e-03f,
  3.02587807e-01f, -1.15164503e-01f, 1.69005096e-02f, -1.17472261e-02f, -8.00962560e-03f, 2.35534422e-02f, 6.85925931e-02f, 8.89901966e-02f, 1.70403104e-02f, 1.98468957e-02f,
  1.63466539e-02f, -3.47775444e-02f, 7.23256320e-02f, 2.34980937e-02f, -5.54574095e-02f, -7.57227186e-03f, -2.92150248e-02f, 1.25001773e-01f, -7.17402995e-02f, 5.23518398e-02f,
  8.47805291e-02f, 1.81405678e-01f, 1.72448814e-01f, 4.27181683e-02f, 6.85169175e-02f, 1.86254993e-01f, -2.47787815e-02f, -6.96254373e-02f, -5.20340167e-02f, -3.37221362e-02f,
  1.90071478e-01f, -2.72996634e-01f, -2.87591726e-01f, 1.37947246e-01f, -4.88620326e-02f, -2.23621368e-01f, -4.03787255e-01f, 4.82576564e-02f, 2.57268250e-01f, -1.96985573e-01f,
  -4.07491177e-02f, 2.21759468e-01f, -2.74805669e-02f, -7.54670948e-02f, -2.43468925e-01f, -5.04227996e-01f, -3.41059595e-01f, -1.82393387e-01f, -8.54818672e-02f, 5.46639971e-02f,
  3.15252803e-02f, 1.20178938e-01f, 1.27132088e-01f, 3.78954858e-02f, 7.95843601e-02f, 5.83379008e-02f, -1.85252354e-01f, 8.67328495e-02f, -1.31950155e-01f, -1.39850274e-01f,
  -7.26850256e-02f, 1.34429842e-01f, -6.53868020e-02f, 1.30224824e-01f, 1.27259701e-01f, -2.40168814e-02f, -1.28381893e-01f, 4.34172787e-02f, 1.74270365e-02f, -8.95966887e-02f,
  1.97956622e-01f, -3.29468283e-03f, 1.34806335e-01f, 3.06258276e-02f, -4.43883501e-02f, 1.55034974e-01f, 4.51122746e-02f, 2.00402718e-02f, -1.61620304e-01f, -1.18299089e-01f,
  1.40038133e-02f, -4.03120508e-03f, -1.52181208e-01f, -1.56859607e-01f, -1.25947222e-01f, -4.42254134e-02f, -7.09542558e-02f, 7.16875196e-02f, -1.66317508e-01f, 1.89507399e-02f,
  -2.65561994e-02f, -3.12338583e-02f, -5.36004566e-02f, 3.80285941e-02f, -4.21175594e-03f, -9.33997706e-02f, 7.65576959e-02f, -1.70619294e-01f, -3.12376563e-02f, 5.09645343e-02f,
  2.41527930e-02f, 3.57428193e-02f, 7.62526691e-02f, -4.51362645e-03f, -2.65386049e-02f, 5.42008057e-02f, -1.26722485e-01f, -1.26871601e-01f, 1.34573188e-02f, -2.15948205e-02f,
  -7.17182606e-02f, 8.85614082e-02f, 1.04275130e-01f, 1.12547070e-01f, -2.70047579e-02f, -1.07478812e-01f, -8.26638266e-02f, 1.73309557e-02f, -1.02105904e-02f, -6.35663122e-02f,
  1.60813600e-01f, -9.60190222e-02f, -4.52822000e-02f, 9.10242647e-02f, 6.67480230e-02f, 2.91942228e-02f, 2.51555238e-02f, -9.14491490e-02f, 1.27617037e-02f, -1.15061281e-02f,
  -2.66620293e-02f, 6.22866116e-02f, -9.53827426e-02f, 8.13342705e-02f, -6.58024475e-02f, -1.88443977e-02f, -1.12362176e-01f, 9.29692164e-02f, -6.06304854e-02f, 3.40074413e-02f,
  -2.68395934e-02f, 3.39541584e-02f, -9.91031006e-02f, -9.78820398e-02f, 8.54112729e-02f, -1.87880285e-02f, -1.04512516e-02f, 9.64166895e-02f, -8.27812254e-02f, -1.67755127e-01f,
  3.82338643e-01f, -3.00180793e-01f, 1.84702069e-01f, 1.22778997e-01f, 1.08501144e-01f, 1.67988122e-01f, -6.24455400e-02f, -1.25631511e-01f, -1.35641750e-02f, -1.03396878e-01f,
  -4.82346155e-02f, 7.87064880e-02f, 3.70150767e-02f, 8.50368291e-02f, 1.55805349e-01f, -4.13055569e-02f, -1.70313612e-01f, 1.49308264e-01f, 2.82000691e-01f, 1.07223697e-01f,
  -7.03930706e-02f, -8.03938136e-02f, -4.17599715e-02f, -2.43645795e-02f, -2.68398196e-01f, 2.53062807e-02f, -1.62866116e-01f, -1.69595301e-01f, -1.37850821e-01f, -7.76573867e-02f,
  2.26417914e-01f, -1.30009934e-01f, 1.18651457e-01f, 9.29682050e-03f, -1.20028310e-01f, -7.27465972e-02f, -9.37047938e-04f, -1.64562449e-01f, -4.09411937e-02f, -1.50762856e-01f,
  -4.61709537e-02f, -4.99750003e-02f, -2.70869583e-02f, -8.92977864e-02f, -1.55645028e-01f, -8.57413094e-03f, -2.49973089e-01f, -2.12898906e-02f, 5.45985289e-02f, -1.40769124e-01f,
  -1.25344232e-01f, -4.75833751e-02f, 8.74136165e-02f, -8.50179866e-02f, -9.84682981e-03f, 1.31355196e-01f, -7.11463168e-02f, 7.52366409e-02f, 9.84570011e-02f, -4.63790931e-02f,
  -6.01122826e-02f, 1.18613027e-01f, -1.03707179e-01f, -1.24152444e-01f, -2.85742972e-02f, -1.24466866e-02f, 8.54348466e-02f, -6.89745024e-02f, -7.58628473e-02f, -6.52426034e-02f,
  7.53425360e-02f, 3.03615835e-02f, -8.21498409e-02f, -8.79794210e-02f, -4.00848128e-02f, 1.00603551e-02f, 3.00106648e-02f, -1.54637903e-01f, -8.72133374e-02f, 2.89558191e-02f,
  1.18360460e-01f, 5.73029369e-02f, 5.54556325e-02f, -2.46382914e-02f, -9.29558575e-02f, -6.68355301e-02f, 8.26575831e-02f, -8.91138688e-02f, -3.15312967e-02f, -3.92234102e-02f,
  -1.74315623e-03f, 5.92763536e-02f, 5.50037846e-02f, -1.01911351e-01f, -4.29594293e-02f, 6.88210949e-02f, 3.67740244e-02f, -1.02656566e-01f, -5.82137890e-03f, -7.45326802e-02f,
  -5.86710200e-02f, 1.45144552e-01f, -8.77114832e-02f, -9.61198583e-02f, 1.89521816e-02f, -8.95619467e-02f, -4.51233285e-03f, 1.41210005e-01f, -1.31829381e-01f, -9.34212655e-02f,
  -1.15544088e-01f, 9.62404907e-02f, 2.65504509e-01f, 3.98743749e-02f, -8.02601427e-02f, 3.58367980e-01f, 8.30608010e-02f, -5.76820150e-02f, 6.37610257e-02f, -7.55171105e-02f,
  -3.49304765e-01f, -1.57390729e-01f, -1.38246000e-01f, -2.29915038e-01f, 1.19639091e-01f, 8.25412944e-02f, -1.29141524e-01f, -9.73689184e-02f, -2.80596525e-03f, -2.26654500e-01f,
  -8.01345706e-02f, 2.87686940e-02f, -1.59618527e-01f, -1.31490618e-01f, -2.79051542e-01f, -2.39235714e-01f, -3.50426286e-01f, -1.80275023e-01f, -1.81148294e-02f, 2.03208476e-01f,
  1.47546828e-01f, -2.68753022e-02f, -2.88535375e-04f, -1.11165427e-01f, -1.00629427e-01f, -4.80703218e-03f, -1.14925265e-01f, -8.76172259e-03f, 4.52646278e-02f, -7.81482458e-02f,
  -1.97625682e-01f, 4.99807298e-02f, 8.94351527e-02f, -6.17906302e-02f, 2.75650490e-02f, -3.74682918e-02f, 3.98606658e-02f, -6.14434518e-02f, 7.48124793e-02f, -1.49181321e-01f,
  -1.05901975e-02f, 7.12723583e-02f, 3.78118386e-03f, 7.30862916e-02f, 8.47140551e-02f, -1.21166892e-02f, -1.20291360e-01f, -5.10749035e-02f, -2.24005580e-02f, -4.15067486e-02f,
  -1.12038672e-01f, 6.54491484e-02f, -8.66549462e-02f, -6.26152009e-02f, 5.78971282e-02f, -7.88718313e-02f, 5.96644580e-02f, 1.43561482e-01f, -2.62302868e-02f, -1.38908923e-01f,
  -7.53785903e-03f, -2.64077764e-02f, -3.32651697e-02f, -2.17993762e-02f, -5.39138466e-02f, -3.55447829e-02f, -1.54238969e-01f, -7.25730136e-02f, 6.12527654e-02f, -4.13196497e-02f,
  -2.64932658e-03f, 1.21115401e-01f, 3.48417610e-02f, 1.35744167e-02f, 2.65026204e-02f, 3.56378928e-02f, -4.99141291e-02f, 3.17197815e-02f, 6.08234247e-03f, -8.14818293e-02f,
  5.21744639e-02f, 2.62545832e-02f, -1.42858140e-02f, -1.45581281e-02f, 1.87967829e-02f, -1.35043561e-01f, -5.01926206e-02f, -6.09699935e-02f, 2.88376771e-02f, 5.66273965e-02f,
  -2.84511417e-01f, 2.00613275e-01f, -2.02445269e-01f, 8.05042312e-02f, -1.61773548e-01f, -7.76788145e-02f, -1.46003226e-02f, 8.47984198e-03f, 5.91249801e-02f, 2.14375872e-02f,
  -1.73631206e-03f, -1.18603453e-01f, 5.80101945e-02f, 8.15359317e-03f, 1.69010937e-01f, -4.10796478e-02f, -9.26840678e-02f, 4.70934846e-02f, 1.25889421e-01f, 3.08804419e-02f,
  -1.86413988e-01f, -5.25552407e-02f, -1.40106022e-01f, -5.32312281e-02f, 2.96942554e-02f, -8.84803161e-02f, -4.88908850e-02f, 6.78265095e-02f, -4.42190878e-02f, -2.83132374e-01f,
  1.28250241e-01f, 3.34459215e-01f, 3.45036574e-02f, 1.56851798e-01f, 5.82882762e-02f, -1.63084999e-01f, -5.37048616e-02f, -1.13079458e-01f, 7.58611038e-02f, 1.40278980e-01f,
  1.21532649e-01f, 9.32444483e-02f, 6.55128807e-02f, 1.46864548e-01f, 9.78098437e-02f, 8.22425559e-02f, 1.48443952e-01f, 1.68932572e-01f, -4.53961119e-02f, 6.09393120e-02f,
  1.75636083e-01f, 2.26648718e-01f, 2.07398340e-01f, 1.42137200e-01f, 1.96709022e-01f, 1.42972633e-01f, 1.00752063e-01f, 1.17432050e-01f, 2.48021454e-01f, 4.71163929e-01f,
  -2.28848290e-02f, -3.83430570e-02f, -1.81871250e-01f, 1.17202461e-01f, 5.83053716e-02f, -2.34971549e-02f, -9.52558368e-02f, -4.69072498e-02f, -1.08236149e-01f, -1.20829821e-01f,
  1.57727022e-02f, 1.93429980e-02f, 3.86878708e-03f, -1.07722133e-01f, 5.70985954e-03f, -1.20291352e-01f, -9.01930407e-02f, -1.17543399e-01f, -5.70886917e-02f, -1.77889273e-01f,
  9.13444757e-02f, 8.47566426e-02f, -4.89876270e-02f, -1.99240938e-01f, -8.05031955e-02f, -1.27027914e-01f, -8.79837424e-02f, -8.95487964e-02f, -2.26162001e-01f, 1.50165556e-03f,
  -1.71263013e-02f, -2.98794378e-02f, -7.27490410e-02f, -1.19521901e-01f, -6.13890328e-02f, -6.71792403e-02f, 1.33526861e-03f, -1.03773542e-01f, -2.35714484e-03f, 1.16141783e-02f,
  -2.12010831e-01f, -1.52882144e-01f, -1.32986507e-03f, -1.60153016e-01f, -7.23513663e-02f, -7.94063061e-02f, 2.89610475e-02f, -3.17553915e-02f, -2.23296091e-01f, -6.76379576e-02f,
  -4.03359309e-02f, 1.97936632e-02f, -9.46543366e-02f, -1.49130328e-02f, 2.16990616e-02f, -1.76617697e-01f, 7.89384637e-03f, 6.35193214e-02f, -7.51970038e-02f, 6.10229000e-02f,
  2.68434500e-03f, -2.51444370e-01f, 4.36867326e-02f, 3.07777554e-01f, 6.87189251e-02f, 1.40647367e-01f, 1.36265635e-01f, 1.18153885e-01f, 1.53813623e-02f, 7.91096836e-02f,
  1.07506774e-01f, 1.28268406e-01f, 1.28642529e-01f, -8.84722695e-02f, -1.21571824e-01f, 2.58678272e-02f, 7.98512027e-02f, 7.34285489e-02f, 2.54427940e-02f, -3.60210650e-02f,
  1.11819290e-01f, -1.01673953e-01f, -7.20208287e-02f, -2.15631500e-01f, -1.70678291e-02f, -1.07113279e-01f, -1.46260545e-01f, 2.33112136e-03f, -2.33913302e-01f, -2.14604124e-01f,
  9.36549902e-02f, -9.39790457e-02f, -3.92452270e-01f, -6.87518790e-02f, -1.08382024e-01f, -3.35847065e-02f, -1.61530018e-01f, 1.44498140e-01f, 2.31300876e-01f, -2.77250912e-02f,
  -4.04462554e-02f, 1.76476985e-01f, 6.02723546e-02f, 9.85550508e-02f, 1.18984496e-02f, -1.90845758e-01f, -3.78665835e-01f, -2.08930776e-01f, -6.16893684e-03f, -4.21534665e-02f,
  -5.50175682e-02f, 1.81393966e-01f, 1.20248422e-01f, 7.31665343e-02f, -4.46484238e-02f, 1.34561941e-01f, -9.42066014e-02f, 1.19360700e-01f, 1.16537720e-01f, -1.22342959e-01f,
  -1.06809139e-01f, 2.13173013e-02f, -1.12196051e-01f, -7.19196275e-02f, -8.59255418e-02f, 8.38883501e-03f, 9.81685705e-03f, -1.63612038e-01f, -7.65702054e-02f, 6.21838346e-02f,
  -1.45714805e-02f, -7.39383847e-02f, -1.99195802e-01f, 8.13047886e-02f, -1.25940785e-01f, -2.58588488e-03f, -1.46349102e-01f, -1.70796782e-01f, -1.41016049e-02f, -8.21654797e-02f,
  -2.02044874e-01f, -1.08973540e-01f, -1.44569755e-01f, 9.20337737e-02f, 1.61822028e-02f, -1.61244556e-01f, 3.54681760e-02f, 6.04251176e-02f, 1.59521356e-01f, 1.48907825e-01f,
  1.07552439e-01f, 1.05293736e-01f, 9.48436186e-02f, 5.30950958e-03f, 5.50650321e-02f, 6.30272031e-02f, 7.76757821e-02f, 4.67882194e-02f, 8.99099484e-02f, -5.13851196e-02f,
  3.73972505e-02f, -8.52213725e-02f, 1.84605375e-03f, -2.50421055e-02f, 6.40225038e-02f, -6.82340562e-02f, -8.72643888e-02f, 2.92540286e-02f, 8.60599950e-02f, 5.59983775e-02f,
  -2.06071418e-02f, 5.88257164e-02f, 6.42175376e-02f, -6.37758290e-04f, -1.06103361e-01f, 4.48877141e-02f, -7.37278759e-02f, 5.41557893e-02f, -5.90604395e-02f, -2.06956923e-01f,
  3.39462221e-01f, -4.43876535e-02f, -3.35191675e-02f, 4.91298875e-03f, -2.57943533e-02f, -1.06436700e-01f, -8.94943029e-02f, -6.57015666e-02f, -1.22438297e-01f, -3.20787802e-02f,
  1.34874983e-02f, -4.55281027e-02f, 4.98515144e-02f, 7.92204402e-03f, -6.80615455e-02f, -7.12904781e-02f, -1.14973700e-02f, -3.47999632e-02f, 2.99682412e-02f, 1.57804601e-02f,
  -4.40453961e-02f, 2.92704962e-02f, 3.60287353e-02f, -1.12639509e-01f, 2.30612293e-01f, 3.83041762e-02f, 1.46423774e-02f, -4.01416719e-02f, 9.15845633e-02f, 1.09776564e-01f,
  -1.89319819e-01f, 4.21515197e-01f, -1.82715114e-02f, -1.08018406e-01f, 2.26341728e-02f, 1.16167888e-01f, 5.51687256e-02f, 7.51227736e-02f, 5.28457314e-02f, 1.31836280e-01f,
  4.88989167e-02f, -1.73509747e-01f, -1.28464177e-01f, -2.11997017e-01f, -4.40544248e-01f, 3.87399420e-02f, -1.49909377e-01f, -4.72781599e-01f, -5.63422859e-01f, -3.26940984e-01f,
  -2.20266089e-01f, -2.25875631e-01f, -3.55437249e-01f, -2.34434679e-01f, 1.04560703e-01f, -3.05783302e-01f, -1.00594483e-01f, -2.02028662e-01f, -1.56030566e-01f, 2.41059586e-02f,
  -1.30395293e-01f, 1.47539482e-01f, -2.25180596e-01f, -3.27557437e-02f, -3.16909142e-03f, 1.72578976e-01f, -4.48772917e-03f, -7.65304640e-03f, -1.91025194e-02f, 1.34545147e-01f,
  1.10729150e-01f, 1.55665696e-01f, -9.37122852e-02f, 3.71096432e-02f, -8.58121961e-02f, -1.11359604e-01f, 8.45272914e-02f, -3.47643346e-02f, 1.61033601e-01f, 1.19005285e-01f,
  1.34180993e-01f, 1.40761733e-01f, 2.48567015e-03f, 1.00268036e-01f, 8.33952874e-02f, -3.53822038e-02f, 7.91082010e-02f, 2.86525339e-02f, -3.15000787e-02f, 2.41738781e-01f,
  9.91984680e-02f, 6.60620481e-02f, 1.10334223e-02f, 7.46616200e-02f, 5.45264482e-02f, -9.85662043e-02f, -2.14499645e-02f, -9.41006467e-02f, -8.15171301e-02f, 1.37767464e-01f,
  2.59349704e-01f, 1.01541594e-01f, 2.75994092e-02f, -2.76481621e-02f, -9.33264121e-02f, -5.70708290e-02f, -1.34384602e-01f, -2.94292029e-02f, -5.29759713e-02f, 5.08711748e-02f,
  -3.34307253e-02f, 1.07017122e-01f, -1.24526732e-02f, 2.21437998e-02f, 5.45402095e-02f, 1.97635144e-02f, -2.39144471e-02f, 5.03592901e-02f, -1.82337444e-02f, -1.20352097e-02f,
  -2.87226707e-01f, -2.37173647e-01f, -1.40620321e-01f, 2.02636141e-02f, 4.28910777e-02f, 2.21770287e-01f, 3.88672873e-02f, 9.69360173e-02f, -4.99294437e-02f, 1.06679514e-01f,
  3.30488980e-02f, 9.18237194e-02f, -7.57544010e-04f, 8.41561425e-03f, -3.40344571e-02f, 3.39775742e-03f, 1.63880065e-01f, -1.05417669e-01f, 1.93284079e-02f, 1.46133274e-01f,
  1.94161594e-01f, -2.45062821e-02f, -1.08238548e-01f, 3.35170850e-02f, 9.00338143e-02f, -2.16754660e-01f, -8.39112997e-02f, 6.59793094e-02f, -1.04657501e-01f, -8.58948305e-02f,
  -1.91052422e-01f, 1.17733479e-01f, 3.06987651e-02f, 4.95180637e-02f, 1.05913930e-01f, -1.15194775e-01f, -1.00057647e-01f, -2.07978696e-01f, -7.50889406e-02f, 6.60143271e-02f,
  1.22148097e-01f, 3.08549926e-02f, 1.65243700e-01f, 7.22851008e-02f, -2.11578041e-01f, 1.08519755e-01f, 2.10413724e-01f, -2.90458743e-02f, -3.59897405e-01f, -1.18336394e-01f,
  2.76038349e-02f, 7.37396851e-02f, -1.86072960e-01f, -1.16415881e-01f, 1.18072703e-01f, 6.53368514e-03f, 2.25641936e-01f, 1.77816689e-01f, 6.14973716e-02f, 3.34604204e-01f,
  2.03090206e-01f, -4.68952842e-02f, -1.45638704e-01f, 8.97648558e-02f, -1.05454940e-02f, -2.08360463e-01f, -1.94914564e-01f, 7.44725242e-02f, -3.98777612e-02f, 3.26073207e-02f,
  1.06447972e-01f, 1.40614230e-02f, 1.13877922e-01f, -1.01016432e-01f, -1.39135987e-01f, -2.69496381e-01f, -1.15440011e-01f, -8.25465992e-02f, -1.67647973e-01f, 5.05379308e-03f,
  9.24266055e-02f, 2.25622598e-02f, -1.48616716e-01f, -2.67081708e-02f, -1.48840919e-01f, -4.16857302e-02f, -1.27777755e-01f, -1.54395262e-02f, -1.11430496e-01f, 9.37325507e-02f,
  -2.38055438e-02f, 1.02556318e-01f, 1.43792080e-02f, 1.12113006e-01f, 6.73928633e-02f, 1.13222405e-01f, 1.29911497e-01f, -2.87087969e-02f, -6.80206046e-02f, -1.32753953e-01f,
  -1.05420776e-01f, -8.37256294e-03f, -8.39176998e-02f, -1.07614033e-01f, -3.45478877e-02f, -3.41532081e-02f, -2.45712884e-02f, -7.73981884e-02f, -7.67900795e-02f, 4.86935377e-02f,
  -4.22109403e-02f, -7.78954178e-02f, 8.24728534e-02f, 1.24785239e-02f, -8.41634199e-02f, -3.05823069e-02f, -1.10709421e-01f, 7.65173510e-02f, 9.00447220e-02f, -5.14905713e-02f,
  -8.49628355e-03f, 1.57225262e-02f, 1.23657376e-01f, -3.52617539e-02f, 5.63188083e-02f, -9.56775397e-02f, -4.61928472e-02f, 2.06431025e-03f, -4.23532017e-02f, -3.09590027e-02f,
  -1.21195033e-01f, -2.37717223e-03f, -5.77457622e-03f, 1.47479055e-02f, -1.43737540e-01f, -4.01360951e-02f, -8.42444077e-02f, -1.67509273e-01f, -3.02849784e-02f, -6.34726807e-02f,
  -4.85564508e-02f, -2.87697054e-02f, -1.44280359e-01f, -3.14224288e-02f, -5.13027944e-02f, -1.56679079e-01f, 1.00858482e-02f, -7.10552856e-02f, -1.73359320e-01f, -6.96835667e-02f,
  -9.91868526e-02f, 9.05581787e-02f, -7.56286159e-02f, -2.36611515e-01f, -2.96312757e-02f, 8.75258520e-02f, 3.58629644e-01f, 4.00164276e-02f, -5.48005151e-03f, 1.57607079e-01f,
  -4.53897491e-02f, -2.97467887e-01f, -1.28546774e-01f, -6.21310845e-02f, -1.66849904e-02f, 1.69365868e-01f, 1.03050321e-02f, -1.50965735e-01f, 4.66958992e-02f, 1.20979093e-01f,
  1.78920358e-01f, 1.27081946e-01f, -2.34645251e-02f, -4.63169394e-03f, -4.34805714e-02f, 9.56685022e-02f, 2.46288124e-02f, -1.15545742e-01f, -1.63916429e-03f, -3.09773803e-01f,
  2.49922602e-03f, -3.47118348e-01f, 2.60808095e-02f, -4.35460694e-02f, -1.49138957e-01f, 3.33846174e-02f, 6.95227236e-02f, -2.15833142e-01f, -1.39585152e-01f, 4.18049516e-03f,
  -1.48311675e-01f, -5.80111742e-02f, -2.59455383e-01f, 7.63224857e-03f, 2.74255574e-02f, -1.04621790e-01f, -8.80772769e-02f, -1.27708584e-01f, -1.73377216e-01f, 4.36221575e-03f,
  -5.24029834e-03f, -9.14923176e-02f, -2.58583039e-01f, -2.39605904e-01f, -2.06888050e-01f, -1.31229460e-01f, -7.54043609e-02f, -2.12194234e-01f, -1.01628713e-01f, -3.56026329e-02f,
  1.07722424e-01f, -1.09172679e-01f, -2.24152636e-02f, 1.03298888e-01f, -5.04059270e-02f, -7.39515871e-02f, 6.34418102e-03f, -4.25128713e-02f, 4.37626466e-02f, -9.34216194e-03f,
  -7.22505152e-02f, -4.96173277e-02f, -1.22102466e-03f, -6.41641533e-03f, 6.03773035e-02f, -2.64638364e-02f, 8.89553577e-02f, 1.97863281e-01f, -5.31015210e-02f, 1.20778121e-01f,
  4.66999114e-02f, -5.03486171e-02f, -2.87675932e-02f, -1.34582683e-01f, -8.22500885e-02f, -1.08509466e-01f, 1.02961428e-01f, 7.62045681e-02f, 2.08674818e-02f, 1.48717731e-01f,
  2.24808201e-01f, -8.23899657e-02f, 1.23137042e-01f, -1.04093468e-02f, 4.54119332e-02f, 5.68491258e-02f, -2.79335994e-02f, -2.93383549e-04f, -1.02979518e-01f, 1.07043356e-01f,
  4.00009006e-02f, -7.92359933e-02f, -4.34396006e-02f, 4.86793295e-02f, 6.15130179e-02f, 1.19337939e-01f, 1.25330359e-01f, 9.61919799e-02f, -6.61305860e-02f, 4.96082902e-02f,
  6.96721375e-02f, 2.02646554e-01f, 1.67972803e-01f, 6.09701034e-03f, -9.33953673e-02f, 3.77843454e-02f, 1.29771933e-01f, 1.94037244e-01f, 1.13708496e-01f, 3.83518457e-01f,
  -6.85357928e-01f, 6.35988712e-02f, 3.01620513e-01f, -4.41281706e-01f, -2.23035559e-01f, -1.41389653e-01f, -6.72619492e-02f, -3.80808234e-01f, -3.30733955e-01f, -8.43313262e-02f,
  9.81098786e-02f, 7.90954679e-02f, 3.20037395e-01f, 3.09733361e-01f, -1.46818385e-02f, 9.19324830e-02f, -7.52103627e-02f, 6.30782843e-02f, 2.09829789e-02f, -8.87732059e-02f,
  -6.14068098e-02f, -2.24850819e-01f, -1.57446176e-01f, -1.92090049e-01f, 2.52868943e-02f, 1.34119332e-01f, 8.11799243e-02f, 3.37859429e-02f, 1.78332821e-01f, 1.22633711e-01f,
  3.95812899e-01f, -2.13068873e-01f, 3.53508443e-02f, -1.89285517e-01f, -1.46836909e-02f, -9.88377184e-02f, -1.59530014e-01f, -2.24278837e-01f, -2.52465934e-01f, -7.10099414e-02f,
  -3.96833476e-03f, -2.07699925e-01f, -2.85007413e-02f, 1.47662356e-01f, 1.43741965e-02f, -1.25312537e-01f, -4.06624712e-02f, -1.06704749e-01f, 8.16546157e-02f, 1.72853917e-01f,
  -8.51094350e-03f, -1.13482758e-01f, 1.02209121e-01f, -1.12763429e-02f, 2.36211922e-02f, 5.98006323e-02f, 7.28370100e-02f, -2.54279487e-02f, -1.00849003e-01f, -6.89737275e-02f,
  -5.23702092e-02f, 8.11519325e-02f, 3.96565907e-03f, -4.91415337e-02f, -8.76830593e-02f, 8.30783844e-02f, 1.81965902e-02f, 4.98617701e-02f, -2.05396917e-02f, 2.50018686e-02f,
  -4.48397435e-02f, -1.24851592e-01f, -3.07791252e-02f, -2.53599640e-02f, 6.85357600e-02f, 3.23127732e-02f, -1.55467436e-01f, -4.85402197e-02f, 8.27496424e-02f, -3.81898619e-02f,
  -3.02582867e-02f, -3.46306525e-02f, 7.40203485e-02f, 1.61504804e-03f, -1.86453074e-01f, -8.95426571e-02f, -4.86299209e-02f, -4.28823829e-02f, 7.41509870e-02f, -1.37629230e-02f,
  4.04463522e-02f, -2.17442941e-02f, 2.72922013e-02f, -4.96570729e-02f, -1.41365200e-01f, -4.26586308e-02f, -1.13201417e-01f, -3.23804617e-02f, 2.16732845e-02f, -1.56264845e-02f,
  -6.96869120e-02f, -1.89786807e-01f, 9.97592434e-02f, 9.19598863e-02f, 8.75667389e-03f, -3.40836719e-02f, 1.49559360e-02f, 9.04940516e-02f, -3.99647281e-02f, 2.29982962e-03f,
  -5.12353517e-02f, -1.05530946e-02f, -1.20994635e-02f, 1.52675182e-01f, 2.59705186e-02f, -5.88890240e-02f, 1.84111252e-01f, -2.30401251e-02f, 9.57369208e-02f, 6.24169894e-02f,
  -2.22271562e-01f, 1.42774135e-01f, 6.12109937e-02f, 1.56432211e-01f, 1.57475904e-01f, -1.95616446e-02f, -1.42092910e-02f, 1.29415402e-02f, 1.34117812e-01f, 2.00885646e-02f,
  1.60705209e-01f, 2.29391098e-01f, 1.15531467e-01f, 2.43153155e-01f, 2.37587422e-01f, 1.49601012e-01f, 3.11958909e-01f, 2.13137060e-01f, 3.79194058e-02f, 9.95499194e-02f,
  1.28342390e-01f, 1.25692729e-02f, 7.83095509e-03f, 5.87433018e-02f, 1.34557039e-01f, 5.93409576e-02f, 6.73836619e-02f, 1.47859633e-01f, 1.37843445e-01f, 3.51326317e-01f,
  1.71420917e-01f, 4.82357219e-02f, -1.10000849e-01f, -3.92027646e-02f, -5.14240675e-02f, -5.67835122e-02f, -4.24567163e-02f, -1.89585611e-02f, -2.27363333e-02f, -5.63423820e-02f,
  1.21130586e-01f, -2.36406960e-02f, 2.18599127e-03f, -2.50215139e-02f, 1.93321190e-04f, 2.44475659e-02f, -8.17546621e-02f, 1.79205388e-01f, -3.55235822e-02f, -5.36583960e-02f,
  1.17958136e-01f, 1.96319014e-01f, 5.71223609e-02f, -7.48172179e-02f, 8.04138333e-02f, 2.10049171e-02f, -8.38475451e-02f, 1.85664836e-02f, -1.30306361e-02f, 5.82008474e-02f,
  1.62282944e-01f, -3.50899026e-02f, 2.95817740e-02f, 1.04798079e-01f, 1.25123709e-01f, -1.14032052e-01f, 9.54661295e-02f, 1.99824408e-01f, 6.54918924e-02f, -5.73575795e-02f,
  -1.94906741e-02f, 6.92519769e-02f, -5.25528602e-02f, 3.79707254e-02f, 1.44286109e-02f, 2.00359583e-01f, -2.83873193e-02f, 2.39588134e-02f, 4.37276885e-02f, -2.06986833e-02f,
  5.12922532e-04f, -7.93334395e-02f, 5.77025823e-02f, -1.05010662e-02f, 6.42257510e-03f, 1.09597817e-01f, 1.55648276e-01f, 1.10063702e-01f, 1.29691809e-01f, 4.27243896e-02f,
  1.23841055e-01f, -1.54804036e-01f, 1.05231730e-02f, 5.70528358e-02f, -1.62642449e-02f, -1.93537120e-02f, 1.53966518e-02f, -3.53286006e-02f, 1.83922667e-02f, 9.17138830e-02f,
  -7.55735785e-02f, 5.94054163e-03f, -1.29681341e-02f, -9.35691819e-02f, -2.23218147e-02f, -1.09127268e-01f, -2.81366840e-04f, 3.41885872e-02f, -4.76293750e-02f, 9.98771712e-02f,
  -9.62331742e-02f, -1.27009660e-01f, 7.12832808e-02f, -4.01279293e-02f, -2.67501473e-02f, -7.50713572e-02f, -1.64551824e-01f, -1.05033070e-01f, -1.11271814e-01f, -1.57383725e-01f,
  4.03960198e-01f, 3.80197048e-01f, 9.10427421e-02f, 4.13395241e-02f, -2.31997475e-01f, -6.48069754e-02f, 2.88551241e-01f, 7.13856593e-02f, -1.12099133e-01f, 9.05795097e-02f,
  -1.71532258e-01f, -3.83951575e-01f, -3.05596948e-01f, -3.22392613e-01f, 1.46787465e-02f, 1.26723945e-01f, 1.19329907e-01f, 1.41852334e-01f, -4.08482030e-02f, 4.14560065e-02f,
  -1.47443280e-01f, 2.23950043e-01f, 2.27478713e-01f, 1.50678664e-01f, 1.50487557e-01f, -1.88835621e-01f, 2.80220956e-02f, 1.03383496e-01f, -7.85899442e-03f, 5.57442568e-02f,
  2.09899852e-03f, 3.62989813e-01f, -5.95124364e-02f, -1.50976479e-01f, -9.95605960e-02f, -8.29479843e-02f, 5.79070263e-02f, -1.61063969e-02f, -1.29796848e-01f, -1.66148812e-01f,
  -2.76414454e-01f, -7.23062605e-02f, -2.66232252e-01f, -2.22940847e-01f, -7.85952359e-02f, -5.39864376e-02f, 8.10590610e-02f, 1.27737969e-01f, -3.87564907e-03f, 6.24456517e-02f,
  -2.11534664e-01f, -7.38282576e-02f, 1.14080794e-02f, -3.79005671e-02f, -2.05867887e-02f, -2.75863260e-01f, -1.11115724e-01f, 3.92086096e-02f, 5.14363907e-02f, 2.93312341e-01f,
  4.83887047e-02f, -7.92003572e-02f, -8.62896517e-02f, -8.60920101e-02f, -5.84768876e-02f, -1.81268275e-01f, -7.93972313e-02f, 3.89847979e-02f, -9.10712220e-03f, 5.44621199e-02f,
  -4.64141667e-02f, 1.10933654e-01f, -1.52112329e-02f, -2.54280642e-02f, -7.78497234e-02f, 4.70181592e-02f, -4.27468233e-02f, 6.64926469e-02f, 4.43177968e-02f, 2.06134375e-02f,
  5.85008040e-02f, 1.40382469e-01f, 8.69720057e-02f, 1.73148327e-02f, 5.07882275e-02f, 1.68793350e-02f, -1.51652601e-02f, 3.09920572e-02f, 6.06285129e-03f, 6.61437213e-03f,
  7.92602822e-02f, -3.46568316e-01f, 9.98191983e-02f, -5.62067796e-03f, 4.18636017e-02f, -1.63349882e-01f, -1.16154768e-01f, -5.24112172e-02f, -1.47875160e-01f, 1.01948023e-01f,
  -4.77199703e-02f, -9.22965258e-02f, -1.55285612e-01f, -2.64783483e-02f, -1.96489096e-01f, 1.34693339e-01f, -5.83886653e-02f, -1.03762962e-01f, -1.67143285e-01f, 8.95382911e-02f,
  2.88741980e-02f, 6.83794245e-02f, 4.42490652e-02f, 2.23188475e-02f, -6.38611168e-02f, -3.34702544e-02f, -1.01283669e-01f, 2.02951357e-02f, -2.63353400e-02f, 2.89664596e-01f,
  -1.04022615e-01f, 2.80596703e-01f, 3.03344935e-01f, -2.39462137e-01f, 1.60563752e-01f, 2.04436824e-01f, 4.35251951e-01f, -1.18001454e-01f, -3.60914260e-01f, 1.66521102e-01f,
  7.42624998e-02f, -2.14153811e-01f, -8.48215595e-02f, -7.34356940e-02f, 8.26637074e-02f, 2.26790905e-01f, 4.83603589e-02f, -6.73781559e-02f, -1.62445322e-01f, 2.27891020e-02f,
  -8.59003142e-02f, -4.42184545e-02f, -1.90209106e-01f, -1.15170389e-01f, -2.91323941e-02f, -2.12979704e-01f, 9.58791822e-02f, -7.98792616e-02f, 1.76252723e-01f, -9.15399268e-02f,
  1.05271168e-01f, 2.20664486e-01f, -1.23282366e-01f, -9.73749459e-02f, 3.91652919e-02f, 2.13383790e-02f, -8.38964479e-06f, -8.14324766e-02f, -1.33154895e-02f, -2.24545356e-02f,
  5.60069792e-02f, 1.31777331e-01f, -2.61915363e-02f, 8.53166804e-02f, -1.15126841e-01f, -8.98718312e-02f, -4.64533195e-02f, 3.78210060e-02f, -1.60877779e-01f, -1.50420144e-01f,
  -3.00911628e-02f, 5.85773289e-02f, 7.73521215e-02f, -7.85327107e-02f, -3.92519031e-03f, -6.74423054e-02f, 1.47325313e-02f, -7.80144054e-03f, 1.75166532e-01f, -1.68243468e-01f,
  -6.44316897e-03f, 7.89357070e-03f, 1.51374161e-01f, 8.35563689e-02f, -5.41799981e-03f, -5.85024199e-03f, 3.81412543e-02f, 2.26077735e-02f, 1.51694845e-02f, 3.20860781e-02f,
  -1.06083699e-01f, 5.38998730e-02f, -1.76286981e-01f, 3.60300206e-02f, -6.12919256e-02f, -4.29134108e-02f, -8.52886289e-02f, 3.42929885e-02f, 3.32301036e-02f, 8.67732465e-02f,
  -7.94617832e-02f, -3.35793346e-02f, -3.05084996e-02f, -6.70259073e-02f, 5.78570887e-02f, -2.77414210e-02f, -1.36218458e-01f, -5.90232238e-02f, 7.76061118e-02f, 7.19379336e-02f,
  -3.19843262e-01f, 2.07922310e-01f, -2.25197271e-01f, 2.42684837e-02f, -5.80983348e-02f, -7.50462934e-02f, -1.74405947e-02f, 1.38763279e-01f, 1.07140206e-01f, 2.56583132e-02f,
  9.84905809e-02f, 8.95399041e-03f, -1.02621160e-01f, 2.60358006e-02f, -1.43815577e-01f, -5.94827831e-02f, -7.36002028e-02f, -1.04838841e-01f, -4.53042723e-02f, -9.19876248e-02f,
  -1.91791743e-01f, -1.85980186e-01f, -9.07895193e-02f, -1.14793694e-02f, -2.33718574e-01f, -1.50686756e-01f, -1.48853168e-01f, -1.30179003e-01f, 1.16281703e-01f, -1.43824533e-01f,
  4.30398770e-02f, 2.24679373e-02f, 6.98713288e-02f, 5.64040281e-02f, 2.06435025e-01f, 1.45177409e-01f, 1.81128502e-01f, -1.13835819e-02f, -1.86272383e-01f, 7.94772618e-03f,
  -3.51819992e-02f, -5.95927984e-02f, -1.40913222e-02f, -6.56219348e-02f, -2.09684372e-02f, 8.63522291e-02f, -1.04664257e-02f, -8.90089795e-02f, -1.46616161e-01f, -9.44043547e-02f,
  7.41619766e-02f, 8.85073375e-03f, -2.08813116e-01f, -1.31704137e-01f, 2.67386157e-02f, -9.80679020e-02f, -4.28200960e-02f, -2.37065163e-02f, 9.06694233e-02f, 1.27254957e-02f,
  2.18377858e-02f, -1.30025495e-03f, -5.78470677e-02f, -2.59795189e-02f, -3.00157294e-02f, -9.97961834e-02f, -8.93197507e-02f, -1.22874632e-01f, -7.94264376e-02f, -8.16511437e-02f,
  4.00900543e-02f, -6.27769753e-02f, 5.61895072e-02f, -1.14964828e-01f, 8.82733390e-02f, -5.62300393e-03f, 1.47312600e-02f, -5.94207421e-02f, -6.98213801e-02f, -1.46307778e-02f,
  6.84986264e-02f, 1.08415715e-01f, 1.58756495e-01f, -2.59027965e-02f, 1.43510267e-01f, 3.19423191e-02f, -4.31891717e-03f, -2.56006438e-02f, -6.79649785e-02f, -1.50900796e-01f,
  3.44088338e-02f, 1.78241745e-01f, 1.81844458e-01f, 4.53051068e-02f, 7.31673762e-02f, 1.81041613e-01f, 2.73248516e-02f, 1.78739373e-02f, 1.45745603e-02f, 1.84307452e-02f,
  3.11097652e-02f, -6.56538010e-02f, -6.19854406e-02f, -5.84081523e-02f, 4.74492088e-02f, 9.63020399e-02f, 6.33366778e-02f, -4.75969464e-02f, -3.03260400e-03f, -9.46702957e-02f,
  -5.72905838e-02f, -2.03528274e-02f, -3.19252983e-02f, -3.39915566e-02f, -2.78387256e-02f, -5.40128956e-03f, 6.40608072e-02f, 1.08858287e-01f, 1.28944263e-01f, 2.09138039e-02f,
  -1.77852660e-01f, 1.47153493e-02f, -1.26866803e-01f, 3.11116446e-02f, 7.49627575e-02f, -3.15969773e-02f, -1.03911478e-02f, -1.62934169e-01f, -1.60126075e-01f, -1.80697381e-01f,
  -5.77780046e-02f, -2.86043691e-03f, -4.75171991e-02f, -1.58528045e-01f, -4.96978648e-02f, -7.28809973e-03f, 2.85022408e-02f, -6.21580444e-02f, -5.60976602e-02f, -5.48158735e-02f,
  -6.10910319e-02f, -8.67568254e-02f, 8.74638557e-03f, -1.00542456e-01f, -1.12820968e-01f, 6.10279068e-02f, 3.92890051e-02f, -1.30456746e-01f, -8.01258832e-02f, -1.09732963e-01f,
  3.98759395e-01f, -1.83869749e-01f, -1.74399838e-01f, 8.28751773e-02f, 5.95814846e-02f, 1.85066476e-01f, 1.44947767e-01f, 2.26775274e-01f, 1.85246959e-01f, 1.93755738e-02f,
  1.92366838e-01f, 2.06558004e-01f, 1.62423179e-01f, 2.99803577e-02f, 1.75700560e-01f, -4.75228243e-02f, -1.30457580e-01f, 1.80563163e-02f, 7.88504183e-02f, 1.55301705e-01f,
  7.63694793e-02f, 1.59490466e-01f, 1.54626250e-01f, 1.26644850e-01f, -1.94531456e-01f, 8.50487873e-03f, -2.11363137e-01f, -1.72135606e-01f, -1.58916503e-01f, -4.04671490e-01f,
  -2.06907734e-01f, 1.49907663e-01f, 1.23303220e-01f, 3.95898968e-02f, -4.52711694e-02f, 1.62845507e-01f, 2.66911741e-02f, -1.28629535e-01f, -4.19754945e-02f, 6.71429485e-02f,
  -8.35825279e-02f, -1.15706593e-01f, 1.48462001e-02f, -1.82359274e-02f, -1.05999611e-01f, 3.45427613e-03f, -4.75754142e-02f, 4.69326563e-02f, 1.82415340e-02f, -6.89372420e-02f,
  -8.21634233e-02f, -1.42008637e-03f, -5.34884557e-02f, -2.48294529e-02f, -1.05988443e-01f, -7.41833262e-03f, -5.11043370e-02f, -1.09453917e-01f, -9.80302617e-02f, -1.36422366e-01f,
  1.46998182e-01f, -2.58494113e-02f, -7.45243952e-02f, -1.02140613e-01f, -5.98432161e-02f, -9.46865156e-02f, -1.77909628e-01f, -1.18621632e-01f, -1.19290993e-01f, -1.11611076e-01f,
  -3.16278897e-02f, -3.93822901e-02f, 5.24389371e-02f, 1.35780424e-01f, 6.97266012e-02f, -3.05238478e-02f, -7.66911358e-02f, -7.51323998e-03f, -8.68188068e-02f, -9.68045861e-05f,
  -5.63847050e-02f, 4.85041970e-03f, -1.03304088e-01f, -1.19793609e-01f, 2.02691299e-03f, 2.05614306e-02f, 5.19235209e-02f, 8.47934559e-02f, 1.16342515e-01f, 1.64933801e-01f,
  1.54798239e-01f, 1.49873272e-01f, 1.63702250e-01f, -1.04682326e-01f, -9.77393165e-02f, 5.67300655e-02f, 3.75060067e-02f, 1.80355329e-02f, -1.21428013e-01f, 1.70955919e-02f,
  1.03047136e-02f, -6.28166944e-02f, -3.72497998e-02f, -1.02934316e-01f, -1.69528291e-01f, -1.36275738e-01f, -1.54663756e-01f, -6.03628345e-02f, -8.97203200e-03f, -4.09330353e-02f,
  1.00184698e-02f, 9.76497903e-02f, 6.77637532e-02f, -2.80191898e-02f, -7.64964595e-02f, 3.39059606e-02f, -6.11587614e-02f, -1.67993769e-01f, 1.55746797e-02f, 1.38421685e-01f,
  4.23575103e-01f, -2.56572336e-01f, -3.91402453e-01f, 5.79883456e-02f, -1.68757588e-01f, -2.91338474e-01f, -2.39075989e-01f, 4.25084122e-02f, 1.64028913e-01f, -2.88014323e-01f,
  -3.67864594e-02f, 2.15867236e-01f, 4.50232364e-02f, 2.09896211e-02f, 1.06304213e-01f, -3.76516134e-01f, -2.36342698e-01f, -3.17320079e-02f, 1.03799164e-01f, -5.94618469e-02f,
  -1.76747311e-02f, 8.93127362e-05f, 2.26715446e-01f, 1.46519288e-01f, -1.66693568e-01f, -7.85911679e-02f, -2.79571176e-01f, -7.66502246e-02f, -1.60712689e-01f, -3.12259614e-01f,
  -2.93511450e-01f, -2.46383511e-02f, -6.64822310e-02f, 7.99795017e-02f, -1.23239428e-01f, -1.41579565e-02f, -9.26634446e-02f, 7.01739744e-04f, 4.53766584e-02f, -7.00926632e-02f,
  -8.81149545e-02f, -1.31834233e-02f, 2.48100031e-02f, 3.80813815e-02f, -1.53930439e-02f, 5.34200594e-02f, 3.76267917e-02f, 1.69767160e-02f, -6.28361776e-02f, -9.71802101e-02f,
  -6.79429770e-02f, -1.05174541e-01f, -5.79599328e-02f, -1.05343685e-01f, -7.83790052e-02f, 1.14163399e-01f, -8.10952112e-02f, -1.39423266e-01f, -1.77196283e-02f, -2.12159142e-01f,
  -1.53841585e-01f, -4.30570245e-02f, -5.59015237e-02f, -3.03670727e-02f, 1.28810897e-01f, 4.29034494e-02f, 5.57859018e-02f, -2.83492617e-02f, 2.84732152e-02f, 8.54314864e-02f,
  5.06123491e-02f, -1.15540087e-01f, 4.26914468e-02f, -5.94275780e-02f, 1.77004281e-02f, 5.16170040e-02f, 2.83269975e-02f, 6.15401473e-03f, 6.19016327e-02f, 6.86026141e-02f,
  3.18810418e-02f, -7.79496580e-02f, -3.83204520e-02f, -3.05511542e-02f, -3.09139080e-02f, -5.46666048e-02f, 5.61956726e-02f, 3.82783078e-02f, 7.41282105e-02f, 3.54714952e-02f,
  2.71494538e-01f, 2.71135401e-02f, -1.44287152e-03f, 1.44187406e-01f, -9.27861501e-03f, 8.92784223e-02f, -1.31080762e-01f, 9.89695564e-02f, -3.13240886e-02f, -3.99980024e-02f,
  -7.01465756e-02f, 3.28824110e-02f, 7.69827738e-02f, -8.94990116e-02f, -4.31038402e-02f, -6.81133419e-02f, 3.42940651e-02f, 2.84048468e-02f, 3.59352194e-02f, 8.38622730e-03f,
  4.87404428e-02f, 2.10212141e-01f, 2.43382215e-01f, 3.54946516e-02f, 5.71369678e-02f, 1.39424220e-01f, 4.37397435e-02f, -1.08878441e-01f, -1.65622197e-02f, 6.21292181e-02f,
  2.70212114e-01f, 1.84852943e-01f, 4.08074595e-02f, 1.31368563e-01f, 9.61025208e-02f, 1.77483514e-01f, 2.29113817e-01f, 2.10355207e-01f, 3.38924845e-04f, 1.99054535e-02f,
  1.36779100e-01f, -3.38267833e-02f, -2.40424704e-02f, -6.13516085e-02f, 1.85719598e-02f, -9.05590206e-02f, -7.11419806e-02f, -1.49905071e-01f, -8.03438798e-02f, -4.12695669e-02f,
  2.43629403e-02f, 3.62717845e-02f, 7.02179447e-02f, 1.99542344e-02f, -1.69131942e-02f, -1.69813782e-01f, 3.96239683e-02f, 5.32877333e-02f, 8.74996483e-02f, -2.08437040e-01f,
  -3.14156830e-01f, 2.82065690e-01f, -2.54686952e-01f, -2.15329364e-01f, 7.86245465e-02f, -1.19327859e-03f, -4.90257591e-02f, 3.78568098e-02f, 6.13012910e-02f, 5.06106578e-02f,
  -1.06043287e-01f, 1.64948720e-02f, 1.36341855e-01f, 3.83766070e-02f, 4.50925641e-02f, 5.49886860e-02f, 4.22259159e-02f, 2.45274138e-02f, 5.76648861e-02f, 2.95583550e-02f,
  4.44735214e-02f, 1.45301640e-01f, 1.16643287e-01f, -3.33388820e-02f, 2.94866245e-02f, -1.36536121e-01f, -2.44477112e-03f, -4.91187861e-03f, -7.41131827e-02f, -4.29255925e-02f,
  -2.33355034e-02f, -4.46759351e-02f, 1.77525923e-01f, 1.43134361e-02f, 1.88396320e-01f, 6.63545728e-02f, -7.15316534e-02f, 6.86547682e-02f, 8.11114088e-02f, 1.00711368e-01f,
  -4.09515686e-02f, 4.71757390e-02f, 6.64139539e-02f, 9.86027345e-02f, -1.31000474e-01f, 9.35600791e-03f, -1.02066845e-01f, 2.05469467e-02f, 5.31365201e-02f, 1.49992898e-01f,
  5.74072264e-02f, -6.05410784e-02f, 1.42856926e-01f, 1.26240566e-01f, 2.27567609e-02f, -8.67843330e-02f, -1.34756833e-01f, 9.55237970e-02f, -8.42782706e-02f, -6.90741241e-02f,
  -2.34896556e-01f, 8.39668810e-02f, -1.71904698e-01f, -2.88113743e-01f, -3.60294878e-02f, -2.25510579e-02f, 1.30675718e-01f, 8.24830588e-03f, 5.45379035e-02f, -1.19350374e-01f,
  4.37965281e-02f, 9.32001229e-03f, 1.82294607e-01f, 1.52245209e-01f, -8.13757628e-02f, -3.07951756e-02f, -1.40634462e-01f, -4.89428379e-02f, -1.24772564e-01f, -1.86950877e-01f,
  8.76607466e-03f, -5.11766821e-02f, -1.28090397e-01f, -1.83880270e-01f, -6.13989942e-02f, -1.99071974e-01f, -1.42932162e-01f, -4.09973077e-02f, -3.90759073e-02f, -1.29592836e-01f,
  3.71301740e-01f, -2.03811795e-01f, 3.00764680e-01f, -1.01510575e-03f, -5.04426599e-01f, -5.52217424e-01f, -5.01262665e-01f, -1.14900947e-01f, -1.36742473e-01f, -1.30567878e-01f,
  -4.30978328e-01f, -1.63742185e-01f, 1.03419542e-03f, 6.19107410e-02f, 3.77410769e-01f, 1.43982306e-01f, 3.00414413e-01f, 5.85023522e-01f, 1.79416746e-01f, -1.72099292e-01f,
  -2.63366461e-01f, 2.41458297e-01f, 4.30187494e-01f, 1.44511089e-01f, -9.16740447e-02f, -1.85113028e-02f, 1.30960852e-01f, 7.01748431e-02f, -1.47823274e-01f, 1.29704937e-01f,
  -6.29554391e-02f, -1.72507122e-01f, 1.10435821e-02f, -6.76106960e-02f, -8.09223577e-02f, 9.58383903e-02f, -5.32053038e-02f, 1.32003322e-01f, -7.92887881e-02f, -6.90621361e-02f,
  -1.98059514e-01f, -1.91850394e-01f, -9.45832208e-02f, -6.71092048e-02f, -1.23677216e-01f, -1.20062545e-01f, 4.94188517e-02f, 4.01591659e-01f, 2.00258702e-01f, -1.73311472e-01f,
  -1.62100285e-01f, -2.29389250e-01f, 1.64476484e-02f, 5.84289804e-02f, 1.23312183e-01f, 5.86098544e-02f, -1.90370753e-01f, -3.70598361e-02f, -1.09470310e-02f, 4.65728529e-02f,
  -1.99826155e-02f, -2.61601321e-02f, -5.30639365e-02f, 1.63426101e-02f, 6.88110245e-03f, -1.05090477e-01f, 2.61123050e-02f, 1.11653969e-01f, 6.24897815e-02f, 1.31778903e-02f,
  -1.20221399e-01f, 1.49521753e-01f, 5.77599835e-03f, -9.60431471e-02f, 5.64418025e-02f, -2.77842004e-02f, -1.39493614e-01f, 6.27669618e-02f, 2.56376863e-02f, 8.60226527e-02f,
  -1.97856184e-02f, -6.95426017e-02f, -1.15694534e-02f, -9.06634852e-02f, 2.40415949e-02f, 6.17594533e-02f, -3.17623577e-04f, -4.71711271e-02f, 6.95490558e-03f, -4.14410159e-02f,
  -6.98628798e-02f, -5.97720966e-02f, -1.34799868e-01f, 6.63876832e-02f, -5.54406121e-02f, -5.72055131e-02f, -8.77731368e-02f, -1.67834796e-02f, 8.71173106e-03f, -5.49021140e-02f,
  -1.44272089e-01f, 2.43363511e-02f, -3.80055830e-02f, -4.23110798e-02f, -8.17524120e-02f, -8.89333785e-02f, -5.36955521e-02f, -6.24480397e-02f, 1.12735024e-02f, -1.21564537e-01f,
  4.82395440e-02f, -2.95877494e-02f, 1.17333144e-01f, 1.76867899e-02f, -9.99989584e-02f, -4.35101055e-03f, -1.09695360e-01f, -7.25592524e-02f, -2.34719031e-02f, 4.76529561e-02f,
  3.95529658e-01f, -2.50117719e-01f, 1.39772832e-01f, 1.38858899e-01f, -2.96797231e-02f, -1.11797629e-02f, -1.39102936e-01f, 1.49704754e-01f, 1.55354619e-01f, 7.42781609e-02f,
  1.78250343e-01f, 2.19487906e-01f, 2.22565860e-01f, 2.22110048e-01f, 2.25970104e-01f, 2.51452457e-02f, -1.13364682e-02f, 1.81698978e-01f, 1.97228298e-01f, 7.31584057e-02f,
  -1.82357728e-01f, -9.30967256e-02f, -5.50126135e-02f, -6.93816394e-02f, -1.09418966e-01f, 1.35496452e-01f, 6.68787863e-03f, -1.63571715e-01f, -1.23136185e-01f, -3.98915410e-02f,
  6.73220977e-02f, -3.58540639e-02f, 1.56528562e-01f, -1.95803400e-02f, -1.85408458e-01f, -6.49348199e-02f, 4.77919169e-02f, -1.01433828e-01f, -9.29411948e-02f, -8.17189366e-02f,
  -7.36359283e-02f, -2.12622639e-02f, -8.29525292e-02f, -1.45365700e-01f, -2.69603729e-01f, -5.47564924e-02f, -1.99491352e-01f, -5.61601445e-02f, 6.72220141e-02f, 3.15952860e-02f,
  -1.78045362e-01f, 1.64064802e-02f, 4.02077585e-02f, 5.44405393e-02f, -2.75129955e-02f, 1.38832808e-01f, -2.52863225e-02f, -6.03776500e-02f, 4.85149436e-02f, -1.60742819e-01f,
  9.68471169e-02f, 7.46287778e-02f, 4.94314916e-02f, 1.29501209e-01f, 3.31270881e-03f, -1.13462284e-02f, -3.39746587e-02f, 6.94496930e-02f, 3.52672786e-02f, 6.32175878e-02f,
  7.22157070e-03f, 1.49767190e-01f, 1.80093452e-01f, 1.21032216e-01f, 5.16959000e-03f, 9.35204923e-02f, -1.93693489e-02f, -1.52747277e-02f, -1.54709322e-02f, -1.02076344e-01f,
  -3.39222252e-02f, 9.24405679e-02f, -6.35665581e-02f, -1.78049356e-02f, -1.67782977e-02f, 2.71859877e-02f, -5.17962649e-02f, 3.61598730e-02f, -1.13537088e-01f, -6.63873702e-02f,
  -1.93910662e-03f, 1.78470254e-01f, 3.40800993e-02f, 5.75583689e-02f, -2.95300800e-02f, 6.58754446e-03f, 1.14895061e-01f, -6.83447942e-02f, -3.30039598e-02f, 8.08830708e-02f,
  -3.22336964e-02f, 1.04750451e-02f, 1.11005940e-02f, -1.46820927e-02f, -1.11003175e-01f, 4.89318967e-02f, -1.01270892e-01f, 1.27543584e-01f, 1.83157951e-01f, 1.01210922e-01f,
  -1.32396102e-01f, 1.50081530e-01f, 2.93024719e-01f, 6.50253221e-02f, 1.06168613e-01f, 1.87074468e-01f, 6.06471300e-02f, -7.08204284e-02f, 1.44647300e-01f, -8.91083106e-02f,
  4.41863686e-01f, 3.82481217e-01f, 1.42208636e-01f, 1.03035793e-02f, 8.94383267e-02f, 1.57345533e-01f, 4.54201758e-01f, 8.34098831e-02f, -2.36309990e-01f, 1.92433059e-01f,
  1.37684390e-01f, -2.51617193e-01f, -9.79583189e-02f, -2.48815924e-01f, -4.27670265e-03f, 1.69825088e-02f, -1.01981461e-01f, -3.46749388e-02f, -1.70190319e-01f, -1.44278988e-01f,
  -6.33190796e-02f, 2.92376783e-02f, 7.47378245e-02f, -5.75068742e-02f, 1.94438286e-02f, -1.78890646e-01f, 1.80239286e-02f, 1.45200521e-01f, -2.89279018e-02f, 6.19781204e-02f,
  1.46257943e-02f, 3.02923411e-01f, -4.01024997e-01f, -8.54064599e-02f, 3.73465903e-02f, -1.12364758e-02f, -1.24894597e-01f, -8.29632804e-02f, -6.86605424e-02f, -1.28203869e-01f,
  1.47277385e-01f, 2.45561805e-02f, 1.50477048e-02f, 4.00837176e-02f, 1.82143170e-02f, -1.12347782e-01f, -7.97933862e-02f, 6.56517409e-03f, -3.18004899e-02f, -3.38601135e-02f,
  6.93513453e-02f, 1.42243907e-01f, 3.01740170e-01f, -8.52549598e-02f, 7.40435347e-02f, -2.07859218e-01f, 6.42641932e-02f, 2.58714594e-02f, 4.47670519e-02f, 1.11432508e-01f,
  -1.46949710e-02f, 1.03973180e-01f, -3.40166432e-03f, 3.66180018e-02f, -1.05214238e-01f, -6.24849722e-02f, -2.87544038e-02f, -3.49701829e-02f, -4.55053523e-02f, -7.33503401e-02f,
  -6.08025752e-02f, -2.02879799e-03f, -7.20717385e-02f, -9.66941714e-02f, -1.40647531e-01f, 5.68584315e-02f, -7.40668476e-02f, 2.99047492e-02f, -6.20911047e-02f, -2.11275332e-02f,
  -1.24373116e-01f, -1.02553859e-01f, 4.15885113e-02f, 1.95131600e-02f, 2.11508404e-02f, -9.70070213e-02f, -1.49814934e-01f, -5.04287705e-02f, -5.14156595e-02f, -6.51184469e-02f,
  -3.96279544e-01f, -1.84287176e-01f, -1.30467564e-01f, -6.42694980e-02f, 1.28763750e-01f, 8.78553372e-03f, -9.14001614e-02f, -5.45940809e-02f, 5.87328263e-02f, -3.89656946e-02f,
  1.70695797e-01f, 5.97885996e-02f, -1.44171175e-02f, -1.10489270e-03f, -7.19164684e-02f, 3.13611515e-02f, -1.31571777e-02f, -1.14739016e-01f, -6.64344355e-02f, 5.14958538e-02f,
  -3.49921943e-03f, -1.06160864e-01f, 4.84216586e-03f, -1.18850440e-01f, -9.18973461e-02f, -1.97217956e-01f, -1.80839505e-02f, -7.76220933e-02f, 2.74767913e-02f, -1.33435741e-01f,
  -2.78144598e-01f, 1.82976589e-01f, 1.83805153e-01f, -9.69572216e-02f, -3.29705663e-02f, -1.94657743e-01f, -5.99258430e-02f, -2.33312294e-01f, -4.00179327e-02f, 1.85482517e-01f,
  1.23040803e-01f, -1.07216157e-01f, 8.52337554e-02f, -1.15951650e-01f, -2.08863750e-01f, 1.36609599e-01f, 8.64237454e-03f, -2.43045434e-01f, -4.91405457e-01f, -3.38174254e-01f,
  -6.42058328e-02f, -1.08502001e-01f, -2.38989606e-01f, -2.71668285e-01f, 1.09542169e-01f, 6.60480931e-02f, 1.04002289e-01f, -1.53014092e-02f, 7.63352662e-02f, 3.29824537e-01f,
  3.55394512e-01f, -1.00812934e-01f, -2.09542021e-01f, -2.98094571e-01f, 4.48962227e-02f, 3.04850079e-02f, -1.03023604e-01f, 3.05092102e-03f, -4.04171422e-02f, -7.78848901e-02f,
  -1.10074818e-01f, -9.96521786e-02f, -1.75804019e-01f, 1.26474267e-02f, -2.52626836e-01f, -2.47245461e-01f, -8.56628567e-02f, -9.04647782e-02f, -6.49519116e-02f, 6.32306710e-02f,
  6.26002029e-02f, -9.12481397e-02f, -4.23309244e-02f, 3.07846740e-02f, -9.53363255e-02f, -2.39151902e-02f, 1.26108788e-02f, -1.74300194e-01f, -2.06217915e-01f, 2.02064067e-01f,
  -1.45913726e-02f, -8.18999186e-02f, 3.06596700e-03f, -9.60902944e-02f, -1.17281213e-01f, 9.46543664e-02f, -3.53751630e-02f, -5.10988198e-02f, -1.92015450e-02f, 3.20422500e-02f,
  1.57642812e-02f, -6.43005669e-02f, 5.59591390e-02f, 1.09177224e-01f, 7.40115205e-03f, 7.42270844e-03f, -1.22883119e-01f, -1.00866333e-03f, 9.32713225e-02f, 8.38667452e-02f,
  -1.47887841e-01f, -1.06252581e-01f, 5.25316335e-02f, -1.04067475e-01f, 9.18667838e-02f, 8.03911164e-02f, -9.38451849e-03f, -6.28546402e-02f, -6.73052967e-02f, -1.39127284e-01f,
  3.52356173e-02f, -7.80135095e-02f, 1.82156220e-01f, -1.85781002e-01f, -7.46845677e-02f, -2.93578040e-02f, 5.14440648e-02f, -1.10158764e-01f, -7.21776113e-02f, -1.48566231e-01f,
  -2.34414190e-01f, -1.82457231e-02f, 1.12412693e-02f, -1.06093429e-01f, -9.72797275e-02f, 3.48134227e-02f, -4.42103064e-03f, -8.45668241e-02f, -1.33493068e-02f, -1.10217787e-01f,
  4.63948725e-03f, -5.46590947e-02f, 4.00147727e-03f, -5.18948808e-02f, 3.78416805e-03f, -1.00356108e-02f, 5.31850755e-02f, -7.34098926e-02f, -6.27574697e-02f, 7.43099898e-02f,
  -6.02772415e-01f, 2.18662303e-02f, -1.15063928e-01f, -1.39259666e-01f, 1.68235615e-01f, 1.66695237e-01f, 1.83002427e-01f, 4.17792834e-02f, -8.12358260e-02f, 9.83765274e-02f,
  1.14413641e-01f, 2.76307575e-02f, -2.02221759e-02f, 5.30794561e-02f, 8.22881535e-02f, 2.91445404e-01f, 2.54822135e-01f, 4.54044007e-02f, -5.94572835e-02f, 6.76856861e-02f,
  1.59167662e-01f, -1.67193368e-01f, -4.18420404e-01f, -1.12386473e-01f, 2.43188888e-02f, -1.01517119e-01f, -1.36349812e-01f, -5.12346029e-02f, 2.41962783e-02f, 2.30747700e-01f,
  1.26563106e-02f, -2.38170370e-01f, 1.25036210e-01f, 2.94110738e-02f, 4.78276163e-02f, -3.11380904e-02f, -2.67017409e-02f, -1.34326354e-01f, -2.05376595e-02f, -6.64404407e-03f,
  -9.25565064e-02f, 4.10551354e-02f, 8.23101550e-02f, -5.23313433e-02f, -1.94953695e-01f, -4.83071096e-02f, -1.37115449e-01f, -8.03578347e-02f, -1.08875252e-01f, -1.55381933e-01f,
  2.77932793e-01f, 1.18571334e-01f, -1.04579017e-01f, 9.03742537e-02f, -2.90457755e-02f, -7.70824105e-02f, -8.54986012e-02f, -1.64923340e-01f, -1.59951061e-01f, -2.61355013e-01f,
  8.38711113e-02f, -7.07448199e-02f, 8.73087347e-02f, -8.42334032e-02f, -2.74382270e-04f, 8.76449794e-02f, -1.40069732e-02f, 9.06515792e-02f, 8.00782517e-02f, -8.97959694e-02f,
  -5.64445592e-02f, 8.12473297e-02f, -1.33684993e-01f, -1.39913946e-01f, -1.81288477e-02f, 2.14043017e-02f, 3.37295681e-02f, 5.78697994e-02f, -9.79653522e-02f, -1.35633126e-01f,
  -5.29689156e-02f, -1.80903785e-02f, -1.14547662e-01f, -1.14214197e-01f, 7.20189288e-02f, -2.96598021e-02f, 1.09202657e-02f, -6.45886362e-02f, -1.40083969e-01f, -8.77192840e-02f,
  -2.66387343e-01f, 1.14470139e-01f, -1.07751312e-02f, 5.45231579e-03f, 3.52718569e-02f, 5.92794735e-04f, -2.73578707e-03f, 1.17106602e-01f, -9.05428641e-03f, -7.42592961e-02f,
  -1.24420740e-01f, -3.30035016e-02f, -6.07478693e-02f, 6.79798797e-02f, -1.77785099e-04f, -1.76313564e-01f, 2.00253204e-02f, -3.96760218e-02f, 1.08944140e-01f, -9.12709609e-02f,
  9.17683244e-02f, 5.21995015e-02f, -2.91010160e-02f, -3.04864272e-02f, -8.59281197e-02f, -6.55957684e-02f, -1.66880414e-01f, -1.35037780e-01f, -4.41118106e-02f, -3.29269797e-01f,
  1.44876555e-01f, 4.07285124e-01f, 1.37673512e-01f, 3.91244292e-02f, 8.81532356e-02f, 1.73624814e-01f, 1.79677308e-01f, -2.91409642e-02f, -8.92416239e-02f, 1.80879489e-01f,
  2.13948288e-03f, 2.61219162e-02f, 5.17065860e-02f, -4.18619476e-02f, -4.19064872e-02f, -1.48234684e-02f, 1.06417254e-01f, -4.29755785e-02f, -2.72067869e-03f, 6.05190396e-02f,
  -2.91559659e-02f, 1.35852441e-01f, 2.22030044e-01f, 2.13652272e-02f, 1.18659865e-02f, -8.03929493e-02f, 6.00704253e-02f, 1.75567612e-01f, 1.40394732e-01f, 3.80364098e-02f,
  -8.49883184e-02f, 2.98093826e-01f, -1.71703339e-01f, 9.08094365e-03f, 9.95775759e-02f, -1.33660128e-02f, -1.24456696e-01f, 9.87980422e-03f, -1.19895592e-01f, -1.00444093e-01f,
  1.34951726e-01f, 2.23777965e-02f, 1.41134724e-01f, -2.19043866e-02f, 6.02292717e-02f, -4.33150008e-02f, -5.86314648e-02f, 5.65862190e-03f, 5.87869808e-02f, -4.31491733e-02f,
  1.41979903e-01f, 3.21605988e-02f, 6.55406713e-02f, -5.55706955e-02f, -1.52673265e-02f, -1.35231346e-01f, -5.83383217e-02f, -7.14721531e-02f, -1.80701185e-02f, -1.14082634e-01f,
  -2.30782583e-01f, -4.13837694e-02f, 4.65688109e-03f, -1.00047387e-01f, -1.51990866e-02f, -7.00880866e-03f, -5.61436117e-02f, 5.35455830e-02f, -1.17752150e-01f, -8.03720653e-02f,
  -1.44031301e-01f, -1.39853433e-01f, -7.17208683e-02f, -1.68847024e-01f, -1.08532377e-01f, -9.97455940e-02f, 1.30959554e-02f, -1.34667447e-02f, -9.93946567e-03f, 8.76434073e-02f,
  4.49146815e-02f, -2.14818865e-03f, 7.94629753e-02f, -5.22744656e-02f, -9.72380117e-02f, -1.65633321e-01f, -1.64156556e-01f, 2.72253286e-02f, -5.65553382e-02f, 6.72779456e-02f,
  2.59457603e-02f, 1.41542688e-01f, -1.31857097e-01f, 2.47548278e-02f, 1.10301964e-01f, -7.87265003e-02f, -2.05928478e-02f, -5.99348210e-02f, -1.21497005e-01f, 4.33893700e-04f,
  1.73913334e-02f, 5.20154424e-02f, 5.93299381e-02f, 8.51625949e-02f, -8.33704174e-02f, -6.28129244e-02f, 2.96662183e-04f, 2.94739380e-02f, -1.30533241e-02f, -6.18539266e-02f,
  -2.60724151e-03f, -1.46286756e-01f, -1.88601896e-01f, -7.86452442e-02f, -1.83761790e-01f, -2.94038028e-01f, -1.02626450e-01f, -1.20999791e-01f, -1.35586858e-01f, -1.28943011e-01f,
  3.67719643e-02f, 1.02599598e-02f, 1.11503877e-01f, 2.22275138e-01f, 1.46580830e-01f, -2.81888992e-01f, -5.27425408e-01f, -2.03787804e-01f, 1.46337926e-01f, 1.22551404e-01f,
  1.87472254e-01f, 1.87140778e-01f, 1.44187668e-02f, -5.03025092e-02f, -5.03824353e-01f, -2.15209529e-01f, -9.78431106e-02f, -1.75539911e-01f, -3.43029469e-01f, -1.92715943e-01f,
  7.54572079e-02f, -9.57919809e-04f, -6.72492087e-02f, -5.26491106e-02f, 3.51787508e-01f, 1.34024709e-01f, 2.33075246e-01f, 1.74092844e-01f, 9.92077440e-02f, 4.63070124e-01f,
  2.87802696e-01f, -6.41260669e-02f, -8.61626267e-02f, 1.79817877e-03f, 1.08751394e-01f, -9.16378573e-03f, 5.39361425e-02f, -3.95773128e-02f, 9.97039229e-02f, 4.17978056e-02f,
  1.57936618e-01f, 6.92812651e-02f, -7.89292678e-02f, 1.02071889e-01f, -6.13016784e-02f, 6.22672364e-02f, -3.26636620e-02f, -1.20272160e-01f, -1.03192002e-01f, 4.39965948e-02f,
  1.04771256e-01f, 1.24730512e-01f, -1.54206576e-02f, -5.60921282e-02f, -6.26712218e-02f, 5.17489389e-02f, 9.27235093e-03f, 3.58471796e-02f, -1.80192977e-01f, 2.53135175e-01f,
  -1.31103564e-02f, 2.41643991e-02f, 5.15031405e-02f, 2.77980622e-02f, 8.79344791e-02f, -2.27359608e-02f, 2.68617198e-02f, 2.00742528e-01f, -6.11822642e-02f, -6.68778569e-02f,
  6.61352975e-03f, -1.24408767e-01f, 4.81528565e-02f, -5.02448604e-02f, 8.99511427e-02f, 1.14777952e-01f, 1.49382979e-01f, -2.36905310e-02f, -3.67116220e-02f, 3.28904279e-02f,
  1.46502301e-01f, 8.92184600e-02f, 9.18430537e-02f, -2.76409704e-02f, 5.40614761e-02f, 9.27234516e-02f, 7.42604658e-02f, -2.81775557e-02f, 4.80745584e-02f, 1.07984647e-01f,
  1.24794677e-01f, -2.88590521e-01f, 1.10399276e-01f, 4.06354852e-03f, -4.05514613e-02f, 5.18533513e-02f, 2.40921140e-01f, -1.52891278e-01f, 1.15205452e-01f, -3.29671055e-02f,
  -4.05352972e-02f, -1.40201114e-02f, -9.55295935e-02f, -5.92492744e-02f, -1.23860151e-01f, 5.05118407e-02f, 6.17286637e-02f, 2.10263114e-03f, -5.94283715e-02f, 1.94652434e-02f,
  -3.20688449e-02f, -2.01641694e-01f, -1.75309896e-01f, -9.44593102e-02f, -3.71571966e-02f, -5.35424575e-02f, -6.44575059e-03f, 3.87098938e-02f, -2.20249861e-01f, -4.55998592e-02f,
  -4.19979215e-01f, -1.80612445e-01f, -1.32292897e-01f, -4.80432540e-01f, -2.70108104e-01f, 9.03732330e-03f, -3.13977301e-02f, -4.43993844e-02f, -2.51269579e-01f, -3.14331234e-01f,
  -1.87239982e-02f, 1.38312131e-01f, -5.36185950e-02f, 1.08205676e-01f, 1.83555841e-01f, -2.83400804e-01f, -2.99123853e-01f, -4.43533882e-02f, 2.41092473e-01f, 2.54569113e-01f,
  8.74143541e-02f, -5.76710477e-02f, -3.31095681e-02f, -4.57645394e-02f, -1.31055161e-01f, 8.25512689e-03f, -3.08746338e-01f, -1.42752051e-01f, 1.03587553e-01f, -1.56107664e-01f,
  -1.11385267e-02f, -1.41776070e-01f, 6.24824390e-02f, -6.41088262e-02f, -1.93960115e-01f, -2.04488169e-02f, -2.40053376e-03f, -9.04052183e-02f, -2.74135321e-02f, -1.64728433e-01f,
  -1.60126388e-01f, 8.34024101e-02f, -1.07000060e-01f, 5.14289513e-02f, -3.30441669e-02f, 1.16645217e-01f, -2.22124290e-02f, -5.78692704e-02f, -1.19770154e-01f, 6.39088973e-02f,
  -1.48726739e-02f, -4.99891303e-02f, 4.74179909e-02f, -2.89943647e-02f, 2.39310265e-02f, 5.05986325e-02f, 5.19371666e-02f, 7.55832195e-02f, 1.25165671e-01f, 1.63523722e-02f,
  -9.78965312e-03f, 4.78996336e-02f, -9.69296843e-02f, 1.22152649e-01f, -3.38914990e-02f, -1.02945641e-02f, 9.40580294e-03f, -9.86009184e-03f, 6.64269701e-02f, 6.16029417e-03f,
  3.89523469e-02f, -4.01229896e-02f, -4.22861800e-02f, -6.33899793e-02f, 9.48911235e-02f, 8.47356692e-02f, 1.68026872e-02f, 5.62220253e-02f, 3.92902941e-02f, -5.51621690e-02f,
  -5.26560359e-02f, -5.76542094e-02f, -3.88967507e-02f, 1.16960667e-01f, -1.03814483e-01f, 2.77278642e-03f, 5.57781048e-02f, 5.93514554e-02f, 1.21311620e-01f, 1.17967606e-01f,
  -5.01669571e-02f, -6.43139631e-02f, -3.27039659e-01f, 1.88137636e-01f, -1.01006791e-01f, 3.23478058e-02f, -1.10987015e-01f, -5.50199673e-02f, -5.47577627e-02f, -1.07278228e-01f,
  7.36622214e-02f, 3.10750771e-02f, 9.54715088e-02f, 3.83169227e-03f, -2.27537584e-02f, -1.40967546e-04f, -4.83441725e-02f, -5.18116876e-02f, 4.14404348e-02f, -5.63415512e-03f,
  -1.83285642e-02f, -1.53577412e-02f, -9.72664729e-03f, 7.44060799e-02f, 5.69872968e-02f, 3.57529111e-02f, 2.96941269e-02f, -3.57091464e-02f, 1.16853595e-01f, -4.31098975e-02f,
  -4.10010159e-01f, -2.67555833e-01f, 1.16492771e-01f, -1.73541605e-01f, -2.27744803e-01f, -6.85276911e-02f, -1.46144584e-01f, -2.45185301e-01f, -3.26229036e-01f, -2.51968265e-01f,
  -2.81891488e-02f, 1.27062410e-01f, 8.61829743e-02f, 1.12856649e-01f, 2.14903876e-01f, -2.72429109e-01f, -1.34815022e-01f, 1.72846794e-01f, 3.31505448e-01f, 2.13999853e-01f,
  7.17414916e-02f, -1.38241440e-01f, 7.85030574e-02f, 4.86232005e-02f, -1.44745246e-01f, 1.08169556e-01f, -1.15289234e-01f, -1.19179033e-01f, 3.98653038e-02f, -1.08772077e-01f,
  1.51596710e-01f, -2.94514120e-01f, -8.84905010e-02f, -5.27209006e-02f, -2.40120385e-02f, 6.35280162e-02f, -3.12071852e-02f, -8.85315463e-02f, -1.24755800e-02f, -7.01556355e-02f,
  2.47923266e-02f, -4.91565242e-02f, 4.23850976e-02f, -4.44752686e-02f, -1.00079305e-01f, 6.10312261e-02f, -1.92659259e-01f, 6.43230379e-02f, -2.68705953e-02f, 1.07759930e-01f,
  3.19590420e-02f, -1.06009068e-02f, 5.86012788e-02f, 1.34175435e-01f, 1.60858467e-01f, 1.36944875e-01f, 4.06818204e-02f, 5.67549579e-02f, 4.77554686e-02f, -7.71302432e-02f,
  8.85039940e-02f, 4.06022556e-02f, -3.82423177e-02f, 7.37824216e-02f, 1.99886560e-01f, 1.45610362e-01f, 9.80005711e-02f, 4.21517082e-02f, -2.23426782e-02f, 1.39766619e-01f,
  -8.41891542e-02f, -5.15527576e-02f, 7.09404871e-02f, -2.55789049e-02f, 5.94912283e-02f, 8.77640992e-02f, -2.73771770e-02f, -3.48421149e-02f, 4.09815024e-04f, 4.55585606e-02f,
  4.57176976e-02f, -1.61199979e-02f, -5.52940518e-02f, -8.16396251e-03f, 5.42826876e-02f, -2.10800506e-02f, -6.67669997e-02f, -5.85221797e-02f, -3.14503722e-02f, -4.07338627e-02f,
  3.15799043e-02f, -9.17955637e-02f, -6.15800880e-02f, -3.54094617e-03f, -2.14851797e-01f, -9.37988758e-02f, -1.60996094e-01f, -8.26734453e-02f, 1.23921242e-02f, 6.83487430e-02f,
  3.20247672e-02f, -9.24291536e-02f, -6.38269633e-02f, -1.63398564e-01f, -2.02794485e-02f, -2.41786707e-02f, -2.13307962e-01f, -4.17102948e-02f, -2.23129615e-02f, 8.53540152e-02f,
  -2.35937774e-01f, -2.14606851e-01f, 5.02531491e-02f, 2.22143950e-03f, 1.01801112e-01f, 1.10499322e-01f, 2.31798366e-01f, 2.77538411e-02f, 4.95354906e-02f, -7.11409226e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.93313166e-01f, 6.26676083e-02f, 1.07765317e-01f, -3.03927690e-01f, 2.46861339e-01f, 1.19222134e-01f, 2.19784062e-02f, -9.75802988e-02f, 1.86630085e-01f, 4.59959172e-02f,
  -7.18725845e-02f, -7.30376765e-02f, 1.46769077e-01f, -1.33990809e-01f, 1.06539033e-01f, 1.66524768e-01f, 1.27119109e-01f, 7.82227069e-02f, 2.20617935e-01f, 1.71961755e-01f,
  1.88832313e-01f, 1.91933855e-01f, -1.28077760e-01f, -1.76762998e-01f, -4.33339775e-02f, 1.57554552e-01f, 7.33058602e-02f, 2.71214508e-02f, 1.63199976e-02f, 9.06484202e-02f,
  1.45518169e-01f, -6.47102436e-03f, 1.80460691e-01f, 7.69473836e-02f, 1.21697523e-01f, 1.11699186e-01f, -1.14405826e-01f, 1.79712072e-01f, 7.45117366e-02f, -5.06580360e-02f,
  1.70495465e-01f, -5.45503013e-02f, 2.99320221e-02f, 2.86560804e-01f, -3.71787101e-02f, 1.65860102e-01f, 5.97116277e-02f, 1.51379809e-01f, 1.39365539e-01f, 6.68728054e-02f,
  2.48688739e-02f, 8.10785294e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.97502184e-02f, -8.73126164e-02f, -5.90323955e-02f, -3.34398597e-02f, -8.01648125e-02f, -1.63091812e-02f, 1.55200856e-02f, 7.84607977e-02f, -1.39574446e-02f, 5.96435741e-03f,
  -2.80245324e-03f, -1.28364012e-01f, 5.97744398e-02f, 1.65398255e-01f, -5.10773659e-02f, -2.40422469e-02f, -3.25647414e-01f, -1.06280908e-01f, -1.14428908e-01f, -7.09864870e-02f,
  2.85035204e-02f, 1.03650361e-01f, -2.08698343e-02f, -6.31092414e-02f, 1.84345156e-01f, -8.69156718e-02f, 1.71971902e-01f, 4.07432988e-02f, 4.24686670e-02f, 1.04279174e-02f,
  -1.12469167e-01f, -3.02656442e-01f, 1.87817469e-01f, 1.52245509e-02f, -9.70085487e-02f, -1.76747926e-02f, -8.96992087e-02f, -1.76938951e-01f, -2.01077461e-01f, -1.78561285e-01f,
  -1.61612332e-01f, 7.86772445e-02f, 1.58495475e-02f, -7.88695365e-02f, 6.39909282e-02f, 1.05315790e-01f, 7.44626746e-02f, 1.59934849e-01f, 3.83724459e-03f, -1.37359440e-01f,
  3.64433900e-02f, -5.84026724e-02f, -6.07555844e-02f, -2.24539295e-01f, -1.16861656e-01f, -8.11576471e-02f, -3.23228315e-02f, -1.16743952e-01f, 8.32091570e-02f, 1.95391595e-01f,
  1.98652316e-02f, -1.95907041e-01f, 1.49022847e-01f, 2.48733838e-03f, 7.77040869e-02f, 1.53358445e-01f, -9.32184234e-02f, 4.76131886e-02f, 5.34148440e-02f, 1.37734301e-02f,
  -1.44649297e-01f, 1.15044881e-02f, -9.46219340e-02f, 6.71573207e-02f, 4.53737415e-02f, 1.62724070e-02f, -1.49683222e-01f, -1.37395456e-01f, 5.79211600e-02f, -1.08912870e-01f,
  -2.30888590e-01f, 3.50161195e-02f, -3.44345838e-01f, -2.83698440e-01f, -1.25293098e-02f, -9.50713903e-02f, 4.26450511e-03f, -5.88580333e-02f, 7.74095356e-02f, 8.65638331e-02f,
  -8.94477740e-02f, 1.84322581e-01f, 3.18275303e-01f, 1.49077654e-01f, 1.84367876e-02f, -1.09726168e-01f, 2.45400682e-01f, -1.12305626e-01f, -8.47622827e-02f, -9.75031406e-03f,
  -2.21221909e-01f, 1.34854525e-01f, -2.32901484e-01f, -1.88304067e-01f, -2.97568794e-02f, -9.49616656e-02f, 4.52674218e-02f, -4.76751998e-02f, -1.07858919e-01f, -4.88591660e-03f,
  1.35780305e-01f, 1.72885895e-01f, -4.90435138e-02f, 1.48027956e-01f, 1.23311430e-01f, -5.49921859e-03f, -5.52401021e-02f, -3.74872014e-02f, -2.81730946e-03f, 1.54460683e-01f,
  -8.24906304e-02f, 5.53722084e-02f, 7.33150542e-02f, 5.73558770e-02f, -4.28008623e-02f, -2.51903772e-01f, 1.11038245e-01f, 4.37743254e-02f, 8.11658986e-03f, 6.99318349e-02f,
  -1.44249797e-01f, -6.11904375e-02f, 1.04910500e-01f, 2.83988491e-02f, -4.38797437e-02f, -9.56505537e-03f, -1.30763099e-01f, 3.24825682e-02f, -1.62912589e-02f, 1.44801602e-01f,
  -1.00731112e-01f, -2.00417832e-01f, 1.95900321e-01f, 9.47919115e-02f, 3.74607109e-02f, 1.39647275e-01f, -2.29532197e-02f, -4.38981950e-02f, 9.74491797e-03f, 1.94113538e-01f,
  6.50315508e-02f, 5.95979057e-02f, -2.92535406e-02f, 1.15503579e-01f, -8.93756226e-02f, -1.08212464e-01f, 3.82898515e-03f, -1.32773221e-01f, -8.18705745e-03f, 1.86117515e-01f,
  -8.60892832e-02f, -7.25388899e-02f, 3.42235677e-02f, 4.34732437e-02f, -1.27280176e-01f, 1.31629154e-01f, -6.58576265e-02f, -1.24685466e-01f, 1.05214685e-01f, 5.22290915e-02f,
  -1.82749376e-01f, 4.86103483e-02f, -4.18592840e-02f, -1.38478860e-01f, 9.21435580e-02f, 8.82791281e-02f, -1.38026431e-01f, -8.59054476e-02f, 1.49697080e-01f, -2.31272448e-02f,
  4.39111963e-02f, -7.84807578e-02f, -9.58439782e-02f, -9.04312581e-02f, 1.47843227e-01f, -1.20049983e-01f, -1.97351560e-01f, -1.06101567e-02f, -8.01868141e-02f, -2.75137484e-01f,
  2.52132088e-01f, 3.02474141e-01f, 2.64727641e-02f, 6.62132576e-02f, 1.06763154e-01f, -4.66997549e-02f, 3.75171229e-02f, -2.13238597e-01f, 6.01183400e-02f, 1.60893604e-01f,
  -1.39518797e-01f, 5.78968152e-02f, 9.92048234e-02f, 1.39508452e-02f, -1.34499138e-03f, 1.94095314e-01f, 1.02902465e-01f, 1.93372235e-01f, -5.64478664e-03f, 2.31650978e-01f,
  1.60597544e-02f, 6.47759880e-04f, 8.52900743e-02f, 1.45181245e-03f, -1.63183380e-02f, 1.10764898e-01f, -1.23515703e-01f, -1.05791107e-01f, -1.17030628e-01f, 1.48195207e-01f,
  -2.17888266e-01f, -4.42778096e-02f, -3.06707382e-01f, 1.46344416e-02f, -1.36702642e-01f, -9.29760784e-02f, 3.87173854e-02f, -2.86959810e-03f, -2.32040524e-01f, 3.11954711e-02f,
  -5.39107481e-03f, -6.64362386e-02f, 1.85982138e-01f, 1.06626958e-01f, -7.12567344e-02f, 2.01801881e-01f, 4.07658741e-02f, -1.71199199e-02f, -7.16240332e-02f, 2.44792640e-01f,
  -8.94886330e-02f, -3.07872862e-01f, 1.52883112e-01f, 1.59650370e-01f, -4.52472642e-02f, -1.34310201e-02f, -6.16554655e-02f, -6.34274632e-02f, -3.87470797e-02f, -1.12231873e-01f,
  1.27963707e-01f, -3.85962725e-02f, 6.20542727e-02f, 7.14298785e-02f, 2.38805427e-03f, 8.89894217e-02f, 4.58118133e-02f, -2.71948762e-02f, 1.74621671e-01f, -2.99862679e-02f,
  -1.19358145e-01f, 1.94607899e-01f, -1.00856408e-01f, -7.51048923e-02f, 1.57572567e-01f, 7.06621706e-02f, -7.85780400e-02f, -5.79530858e-02f, 2.45740980e-01f, -1.27279446e-01f,
  6.87368289e-02f, 5.05211838e-02f, -3.67642283e-01f, -1.94802493e-01f, 5.95933124e-02f, 1.24585763e-01f, 1.49411350e-01f, 3.59409191e-02f, -4.96459231e-02f, -5.32980002e-02f,
  7.33378530e-02f, 3.77026685e-02f, -1.18628830e-01f, 2.71158330e-02f, 2.33359128e-01f, 2.30416149e-01f, 5.25653660e-02f, -1.35535598e-01f, -3.94925252e-02f, 1.27425462e-01f,
  9.64016542e-02f, 3.02561224e-02f, -1.01583570e-01f, 1.17373943e-01f, -2.45615561e-02f, 1.41142933e-02f, 1.84977695e-03f, 1.40744331e-03f, 5.29452935e-02f, -7.98604116e-02f,
  9.23243165e-02f, 8.74780566e-02f, 1.18687697e-01f, -1.12023689e-01f, 4.37417738e-02f, 2.98320740e-01f, 1.65743530e-01f, -2.14700159e-02f, -4.90367636e-02f, -9.07198247e-03f,
  2.49057710e-02f, -1.40708014e-01f, -1.58515409e-01f, 9.00298879e-02f, 3.05324435e-01f, -8.16284120e-02f, 1.89437419e-01f, 1.48370251e-01f, -1.21168174e-01f, -1.78687990e-01f,
  4.23120480e-04f, 2.04267502e-02f, 2.33000759e-02f, 8.21432471e-02f, -3.73605341e-02f, 1.74512208e-01f, -1.54545948e-01f, -6.23732023e-02f, -1.88419938e-01f, 9.35655534e-02f,
  -2.14392394e-01f, -4.76438962e-02f, 1.84254155e-01f, 7.33232051e-02f, -2.35665068e-02f, -1.44886062e-01f, 1.66864961e-01f, -1.86503436e-02f, 8.56936499e-02f, -3.56253609e-02f,
  1.03457615e-01f, -1.33687839e-01f, -1.71315014e-01f, -2.24966332e-01f, 1.12996921e-01f, -1.11014262e-01f, 1.16311245e-01f, -9.92669258e-04f, -8.62613246e-02f, 3.80852595e-02f,
  -1.00941069e-01f, -2.03169346e-01f, 4.35805097e-02f, 3.19258943e-02f, -4.37771641e-02f, 2.59491261e-02f, -1.00888260e-01f, -2.35254392e-02f, -1.00574657e-01f, -1.48454934e-01f,
  -1.74836710e-01f, 9.87093821e-02f, 4.37970944e-02f, -2.02084348e-01f, 7.36268237e-02f, 1.25780046e-01f, -7.80479470e-03f, 1.60033941e-01f, 1.01791091e-01f, 5.70913926e-02f,
  2.10382685e-01f, 9.49496627e-02f, -2.01654285e-01f, -1.63636893e-01f, 1.66618731e-03f, 2.10300252e-01f, -7.33853132e-02f, 1.03874259e-01f, 1.90536723e-01f, 1.50912404e-01f,
  1.15633607e-01f, -2.23157331e-02f, -7.10737705e-02f, 2.22342703e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.33424073e-01f, 6.12682216e-02f, 2.12784827e-01f, 2.24081278e-01f, 9.48434845e-02f, 5.40399812e-02f, -9.94960666e-02f, 2.18297467e-01f, -1.60958357e-02f, 6.57879263e-02f,
  -3.81510612e-03f, -2.32439432e-02f, 1.64747134e-01f, 5.26419617e-02f, 2.58088186e-02f, -2.27186888e-01f, 3.15182149e-01f, 2.35048421e-02f, 1.85131177e-01f, 2.10275277e-02f,
  -9.92210954e-02f, 1.41028777e-01f, 9.86072496e-02f, -8.48410800e-02f, 3.72850895e-02f, 2.16402933e-01f, 9.60710496e-02f, -1.51127055e-01f, -1.97906032e-01f, -9.30762663e-02f,
  -1.71465892e-02f, 8.67422372e-02f, -7.20853568e-04f, 5.38293496e-02f, 3.38102803e-02f, -2.12090444e-02f, 3.69192250e-02f, -1.27465189e-01f, 1.71112984e-01f, 3.31473351e-01f,
  3.84661704e-02f, 1.56708091e-01f, 1.11022480e-01f, 2.17615321e-01f, 8.63370672e-02f, 2.11222306e-01f, -1.69873551e-01f, -1.21787429e-01f, -3.84787400e-03f, -1.11574322e-01f,
  -9.14540291e-02f, 1.49751261e-01f, 2.63985693e-01f, 9.17083621e-02f, 2.23620813e-02f, -2.70004980e-02f, -5.27698658e-02f, 1.98945180e-02f, 1.96529292e-02f, 2.18623221e-01f,
  1.58054084e-02f, 1.93074614e-01f, -5.07014394e-02f, -1.78335831e-01f, -2.26644427e-03f, -8.67254138e-02f, -6.37746882e-03f, -2.91074216e-02f, 1.69354618e-01f, -1.78457145e-02f,
  1.83592692e-01f, 3.94773856e-02f, -4.19055410e-02f, 6.14856072e-02f, 2.30875030e-01f, -1.05248444e-01f, -2.68725723e-01f, -3.73304524e-02f, -2.75093019e-02f, -6.71726912e-02f,
  -3.50815326e-01f, -6.95656165e-02f, -2.86718965e-01f, -3.06203276e-01f, 1.15328021e-01f, -4.05716181e-01f, 1.93183392e-01f, 1.82286873e-01f, -2.25605041e-01f, -1.09149970e-01f,
  -1.03498042e-01f, 8.93308967e-02f, -6.21300936e-03f, -1.19658805e-01f, 7.41683245e-02f, -2.10353173e-02f, 2.28899211e-01f, -1.26689658e-01f, -1.53662741e-01f, -3.31718475e-01f,
  7.27943033e-02f, 3.50225955e-01f, -1.02641970e-01f, -1.68288261e-01f, 6.55159131e-02f, -4.10359561e-01f, -3.23870301e-01f, -1.99914798e-02f, -4.24168050e-01f, -1.23601176e-01f,
  1.64457664e-01f, 4.23612684e-01f, -1.83765188e-01f, -8.91237259e-02f, -3.45314182e-02f, 1.96776897e-01f, -5.20766340e-02f, -2.86262870e-01f, -2.86411166e-01f, -2.08809495e-01f,
  -6.17990345e-02f, -1.43735096e-01f, 7.99836740e-02f, -1.69145644e-01f, -2.85231024e-01f, -3.61080691e-02f, 1.57788500e-01f, 3.52746487e-01f, -1.22572891e-02f, -8.81363004e-02f,
  -1.37648880e-01f, -1.84891522e-01f, 1.08666249e-01f, 6.20356612e-02f, 7.62230307e-02f, 6.00157753e-02f, -4.23605368e-02f, 1.84097160e-02f, -1.30950147e-02f, 1.87205270e-01f,
  -1.37039885e-01f, 3.13852099e-03f, 9.98835266e-02f, 5.69311157e-02f, 2.74572283e-01f, 2.79131047e-02f, -2.31727287e-02f, 4.42628860e-02f, 2.78289299e-02f, 1.22816719e-01f,
  1.90896671e-02f, 1.19206876e-01f, 6.71218559e-02f, -2.27842480e-02f, 1.75911009e-01f, -2.11784124e-01f, -2.17549458e-01f, -2.05857128e-01f, -5.16981296e-02f, 3.26766014e-01f,
  5.43887578e-02f, -2.05207601e-01f, 4.46147704e-03f, -2.35442515e-03f, -1.57412104e-02f, -1.40363157e-01f, 9.73889902e-02f, 2.27798223e-01f, -6.00010389e-03f, 1.62294254e-01f,
  -2.19393626e-01f, 1.40992224e-01f, -1.48268521e-01f, -2.65964746e-01f, -1.62157431e-01f, -5.71005093e-03f, -1.01622388e-01f, -2.04873577e-01f, -1.82560652e-01f, 2.58914952e-05f,
  1.21642798e-01f, 1.35405034e-01f, -7.80939981e-02f, 2.03055456e-01f, 1.32174194e-01f, -1.13854855e-01f, -3.57258916e-01f, 7.68884197e-02f, -2.29061600e-02f, -2.60867208e-01f,
  1.05376363e-01f, 6.54986873e-02f, 1.89946219e-01f, 2.51561366e-02f, 8.41963738e-02f, 3.50016467e-02f, 1.77061930e-01f, 1.62226155e-01f, -5.74846044e-02f, 1.88108191e-01f,
  -1.50632873e-01f, 1.04404658e-01f, 2.37828810e-02f, -6.89792559e-02f, -1.73948817e-02f, 2.53467917e-01f, -2.83081103e-02f, -3.43331285e-02f, 2.01767460e-02f, 2.97357678e-01f,
  2.22469233e-02f, -1.83148701e-02f, 8.41253921e-02f, 3.15392315e-01f, 7.36860139e-03f, 7.15457797e-02f, 1.15172781e-01f, 1.15385354e-01f, 2.23476693e-01f, -8.23591873e-02f,
  -1.89638287e-01f, -3.09107929e-01f, 8.07775036e-02f, 1.11776292e-01f, 2.63030469e-01f, -1.71430781e-02f, -7.07714483e-02f, 1.54837683e-01f, 1.86758280e-01f, -1.01961374e-01f,
  2.93593965e-02f, 1.14425786e-01f, 5.79394065e-02f, 1.46613076e-01f, -1.15110345e-01f, -1.54101893e-01f, -9.66360047e-02f, 4.06544358e-02f, 1.68387573e-02f, -6.93473667e-02f,
  9.19305161e-02f, -4.29382950e-01f, -1.74133163e-02f, 1.28743099e-03f, -1.32663352e-02f, 9.01868343e-02f, -5.14279259e-03f, 6.33400679e-02f, 1.02091551e-01f, -3.57929975e-01f,
  -2.41772577e-01f, 1.81632370e-01f, 2.86843907e-02f, -3.51104885e-01f, 2.27104336e-01f, 9.57051143e-02f, -1.13930749e-02f, 1.90018550e-01f, 5.91800958e-02f, 1.74107224e-01f,
  1.13817960e-01f, 2.54809409e-02f, -1.17371932e-01f, -3.56293842e-02f, 4.56254631e-02f, -5.23679517e-02f, -2.35422432e-01f, -2.19539911e-01f, -4.22843918e-02f, 1.02671795e-01f,
  -3.10808092e-01f, 1.25649363e-01f, 4.51125562e-01f, -1.16891414e-01f, 2.18958721e-01f, 1.88986763e-01f, 2.58109756e-02f, -1.24949716e-01f, -1.54870942e-01f, -1.61275730e-01f,
  -5.39335515e-03f, -1.77881077e-01f, -2.20501095e-01f, -7.01190159e-02f, -1.82115719e-01f, 1.39618546e-01f, -4.04212058e-01f, -1.32081524e-01f, -3.93250972e-01f, -3.88121873e-01f,
  -2.22761417e-03f, 1.39239535e-01f, -9.65492502e-02f, -5.43265939e-02f, 8.24918097e-05f, -2.39799768e-02f, -6.11566342e-02f, 1.27451539e-01f, 3.52116346e-01f, -2.68541444e-02f,
  1.24633826e-01f, 5.62853143e-02f, -4.50639755e-01f, -1.20651506e-01f, 5.42832026e-03f, 2.52166539e-01f, 5.04367100e-03f, 1.64555117e-01f, -2.05323711e-01f, -1.05193421e-01f,
  1.03549729e-03f, 4.39967424e-01f, 2.48733219e-02f, 1.40902638e-01f, 2.16829255e-01f, -1.26838341e-01f, -4.60755639e-02f, 3.74666780e-01f, -2.17617154e-01f, 4.25455272e-02f,
  -8.79340619e-02f, -5.82935549e-02f, 1.43014386e-01f, 1.65626168e-01f, 6.38698861e-02f, -1.91265628e-01f, 9.17740539e-02f, -6.75972179e-02f, 2.12318748e-01f, 2.14050636e-02f,
  -7.42981955e-03f, -1.15858257e-01f, 1.86879665e-01f, 7.98598528e-02f, -1.11333236e-01f, 7.84638599e-02f, 1.31138012e-01f, -8.41330439e-02f, 2.99003452e-01f, 1.67370901e-01f,
  1.61379158e-01f, -6.43141568e-02f, -1.14917763e-01f, 5.01612090e-02f, -2.91422784e-01f, -1.77886367e-01f, -1.46974564e-01f, 6.32042587e-02f, -1.91327646e-01f, 8.98550227e-02f,
  -9.27823260e-02f, -2.26941764e-01f, -1.46555856e-01f, -2.98432648e-01f, -1.46254778e-01f, 7.20756408e-03f, 1.12881744e-02f, -1.09452251e-02f, -6.65811449e-02f, 1.85837537e-01f,
  7.92868659e-02f, -7.01580420e-02f, -1.58723012e-01f, 2.69360870e-01f, 2.15951607e-01f, 2.21440539e-01f, -1.43017083e-01f, -1.59520000e-01f, -1.10898636e-01f, 6.49114139e-03f,
  -1.26539603e-01f, -2.79303063e-02f, -8.15835148e-02f, 6.30575493e-02f, -5.67208491e-02f, -4.23668504e-01f, -8.22628364e-02f, 7.98558593e-02f, 3.76303829e-02f, -1.04960486e-01f,
  2.90491730e-02f, 4.42160666e-01f, 6.14205040e-02f, 1.96623467e-02f, 4.71308567e-02f, -2.70986576e-02f, 7.12670907e-02f, -2.31334507e-01f, -4.32456471e-02f, 5.53154685e-02f,
  -8.16507265e-02f, 1.10848829e-01f, 2.34670397e-02f, -1.15931258e-01f, 1.22991391e-02f, -1.50267974e-01f, 1.29183382e-01f, 1.18860357e-01f, -1.05227800e-02f, -1.46527857e-01f,
  -1.66500539e-01f, 3.34051512e-02f, -1.69851348e-01f, -1.08754560e-01f, 6.94128573e-02f, 3.65573354e-02f, 7.50354538e-03f, -6.26445934e-02f, 1.85506105e-01f, -3.82337794e-02f,
  1.85813680e-01f, 1.36123478e-01f, 8.01997483e-02f, -6.89978674e-02f, -5.24336174e-02f, -5.41843437e-02f, 1.93846107e-01f, -3.69965173e-02f, -2.58499328e-02f, 3.01498063e-02f,
  2.76521832e-01f, -9.85518680e-04f, -3.57733756e-01f, -1.21767066e-01f, -1.08795166e-01f, 1.43914104e-01f, 6.48860261e-02f, -1.74806893e-01f, 2.03624487e-01f, -7.12531507e-02f,
  -1.29604518e-01f, 1.14774629e-01f, 8.83917883e-02f, -3.12120914e-01f, 2.90103495e-01f, 1.10811882e-01f, 7.34264776e-02f, -2.89768308e-01f, 4.61906716e-02f, -4.86739159e-01f,
  1.46047890e-01f, 2.00468183e-01f, -8.48380942e-03f, 2.56152481e-01f, -6.93142861e-02f, -4.00890023e-01f, 1.19680628e-01f, -3.94748338e-02f, 2.10889786e-01f, -2.24351399e-02f,
  -2.02591252e-02f, -8.04664642e-02f, 7.16349557e-02f, -1.91424429e-01f, 2.01787546e-01f, -1.84822649e-01f, 5.48550896e-02f, 4.16045599e-02f, 1.03568591e-01f, 7.40804523e-02f,
  -1.72768369e-01f, -2.02097997e-01f, 7.29717165e-02f, -8.32182821e-03f, 1.59439042e-01f, 1.98804960e-01f, -1.40402820e-02f, 6.57823607e-02f, 1.64484594e-03f, 5.33676930e-02f,
  1.35401696e-01f, 6.60115182e-02f, -1.05286323e-01f, 1.28558487e-01f, 1.05998352e-01f, -2.12382600e-01f, 1.19172409e-02f, -1.36331260e-01f, -3.10192909e-02f, 2.22690135e-01f,
  -2.01035470e-01f, -3.47678550e-02f, -6.34570187e-03f, -3.07424031e-02f, 3.86051089e-02f, -2.15370171e-02f, 2.17988119e-01f, 1.90326750e-01f, 2.92208642e-01f, 6.13517500e-02f,
  -1.12372451e-03f, 1.39851138e-01f, -2.18380764e-01f, -2.71931589e-01f, -1.71334982e-01f, -5.50821163e-02f, -1.33043170e-01f, -1.18381955e-01f, -9.81054604e-02f, 1.35342240e-01f,
  3.92891169e-02f, 3.52624148e-01f, -1.96244475e-02f, -4.49635834e-02f, 1.06024973e-01f, -1.19016476e-01f, -3.04058403e-01f, -1.40727669e-01f, 4.10606600e-02f, -2.05467105e-01f,
  1.49944663e-01f, -7.08748214e-03f, 3.34719643e-02f, -4.29358520e-02f, 1.87044024e-01f, 9.04490501e-02f, -7.65531585e-02f, 2.25881830e-01f, -2.08708905e-02f, -1.11892715e-01f,
  8.58796313e-02f, -1.10085703e-01f, 2.78711081e-01f, 1.19835436e-02f, -2.70039976e-01f, -3.71678732e-02f, -2.05226406e-01f, -1.06982864e-01f, -3.44961464e-01f, -2.25034893e-01f,
  -1.77804416e-03f, -1.57892868e-01f, 5.00737578e-02f, -1.63633414e-02f, 7.35405982e-02f, 2.94508711e-02f, -3.68785530e-01f, 7.54532740e-02f, 2.14460306e-03f, 9.47864726e-02f,
  3.39394301e-01f, 3.03302199e-01f, 3.83408159e-01f, 1.19073272e-01f, 1.65400803e-01f, 5.86346630e-03f, -1.35539383e-01f, -2.27724150e-01f, -1.50528282e-01f, 3.75597775e-02f,
  5.27429692e-02f, -3.97554450e-02f, 6.69030771e-02f, -1.69988945e-01f, -2.77704209e-01f, 6.72482178e-02f, 1.51389197e-01f, -1.64413061e-02f, 1.74649462e-01f, 3.31468433e-02f,
  -4.05975431e-01f, 3.36473495e-01f, -3.70793641e-01f, -9.84526128e-02f, -1.27028758e-02f, 7.30558857e-03f, 6.20135292e-03f, 1.08962469e-02f, 6.27530564e-04f, -1.07521437e-01f,
  -8.71727709e-04f, 1.67083517e-01f, -2.45542020e-01f, 5.70073314e-02f, -3.42168398e-02f, -2.30590358e-01f, 5.39052561e-02f, 5.47363423e-02f, -1.18744269e-01f, 1.22274775e-02f,
  1.11969769e-01f, 2.50860482e-01f, 1.49331674e-01f, 1.67539399e-02f, -5.41329123e-02f, 5.59724718e-02f, 4.66767550e-02f, 1.25778824e-01f, 9.54002962e-02f, -2.52282381e-01f,
  -1.61849037e-01f, -1.14286877e-01f, -2.67668039e-01f, 5.74672483e-02f, -1.27516866e-01f, -9.76041555e-02f, -9.44151804e-02f, -3.44006787e-03f, -4.56668921e-02f, 2.45556310e-02f,
  5.69800548e-02f, 1.73193961e-01f, 5.81463017e-02f, 2.32431918e-01f, 8.44241232e-02f, -9.74007249e-02f, -9.27333981e-02f, 1.97798401e-01f, -1.08202256e-01f, 1.81173250e-01f,
  1.37489485e-02f, -3.79285812e-02f, -5.45509309e-02f, 1.34289026e-01f, -1.82288792e-02f, -2.37565041e-01f, 6.02765679e-02f, 2.25959923e-02f, -1.36276916e-01f, -7.59538934e-02f,
  2.05713464e-03f, -1.02108620e-01f, 2.67644413e-02f, 1.57593772e-01f, -4.58213408e-03f, -2.01429009e-01f, 1.78561017e-01f, 4.29706722e-02f, 2.01304585e-01f, -1.73706681e-01f,
  3.53780314e-02f, -2.51776010e-01f, 1.16494268e-01f, 1.87231734e-01f, 8.26465711e-02f, 1.97664481e-02f, 9.36832279e-02f, -3.68389696e-01f, 1.13694690e-01f, 2.15293393e-01f,
  2.53129125e-01f, 1.76391378e-01f, 1.14738137e-01f, 2.45769873e-01f, 9.21710655e-02f, 2.64005393e-01f, -3.73360626e-02f, -6.98593184e-02f, -2.88252562e-01f, -6.64780587e-02f,
  -9.40114409e-02f, 3.13397914e-01f, 1.08814187e-01f, 1.34686962e-01f, 1.82336524e-01f, -1.63142622e-01f, 1.59459978e-01f, 1.47568807e-01f, -1.54747754e-01f, -1.75281838e-01f,
  1.74477294e-01f, 1.52501479e-01f, -1.38578773e-01f, -2.45400555e-02f, 2.14471668e-01f, 3.98198143e-02f, 1.30998224e-01f, -2.59005338e-01f, -1.25881895e-01f, -8.07569548e-02f,
  -3.27197433e-01f, 2.07456291e-01f, -1.16476387e-01f, 2.26856700e-05f, 2.23502181e-02f, -4.76420075e-02f, -2.31261373e-01f, -1.10628225e-01f, 1.05130747e-02f, -1.66793987e-01f,
  -1.63091924e-02f, -1.90630127e-02f, -1.29830495e-01f, -5.27113043e-02f, -1.47477165e-02f, -5.14418408e-02f, -4.41458710e-02f, 1.90500077e-02f, -1.48891702e-01f, -2.34890059e-01f,
  1.15155503e-01f, 1.77315250e-01f, 2.58464545e-01f, -1.24207519e-01f, 1.62626699e-01f, 3.29488277e-01f, -1.56877115e-02f, 2.97974199e-01f, -1.62341923e-01f, 6.24258146e-02f,
  1.84465721e-01f, -4.55940455e-01f, -1.14381261e-01f, -3.21999975e-02f, 1.71655491e-01f, -8.23258981e-02f, 8.03393647e-02f, 1.49470260e-02f, 8.03477392e-02f, 1.29971623e-01f,
  9.95750278e-02f, 2.32908148e-02f, 1.69529691e-01f, -3.10099125e-01f, 6.95053414e-02f, 3.71483713e-02f, 7.00324178e-02f, 5.43672219e-02f, -7.63500780e-02f, -1.51522145e-01f,
  -3.09441715e-01f, -2.59506971e-01f, 2.92001627e-02f, -6.81098104e-02f, -1.61971580e-02f, -4.47430551e-01f, 8.91584158e-02f, -1.80776566e-01f, -8.31200033e-02f, 1.24998525e-01f,
  1.22058228e-01f, -1.56866506e-01f, 2.67106116e-01f, -6.57699034e-02f, 3.13965648e-01f, 1.72528043e-01f, 4.67055470e-01f, -4.89816256e-02f, 6.65041283e-02f, -1.43344611e-01f,
  3.16454381e-01f, 1.62865818e-02f, -4.52382326e-01f, -2.48381525e-01f, 1.20007508e-01f, -1.71615511e-01f, -8.79000798e-02f, -2.53008664e-01f, -3.34964991e-01f, 9.33393016e-02f,
  2.86884718e-02f, -2.21312746e-01f, -1.27089605e-01f, -1.25659406e-01f, -1.21779330e-01f, 4.04799683e-03f, -1.19990513e-01f, -3.80348951e-01f, -2.93831807e-02f, -2.32518226e-01f,
  -4.04987298e-02f, -9.38264579e-02f, -2.42865786e-01f, 2.99592257e-01f, -1.80227444e-01f, -8.20635557e-02f, -3.30298424e-01f, 5.86457290e-02f, 8.78072083e-02f, 2.37976566e-01f,
  -6.72975183e-02f, 1.12442493e-01f, 3.61203440e-02f, 1.96345925e-01f, -2.17053536e-02f, -9.00657475e-02f, -1.19373240e-01f, -1.12067036e-01f, 3.12958211e-02f, 2.07590535e-02f,
  -2.86829770e-01f, -1.25986770e-01f, -7.80047029e-02f, -1.01036467e-01f, 1.12091161e-01f, 1.11385174e-01f, -7.39806071e-02f, -1.20187573e-01f, -4.10118699e-02f, -1.24827191e-01f,
  3.28526497e-02f, 1.38370842e-01f, -1.67039633e-01f, 6.37525395e-02f, -9.46376622e-02f, 3.57070267e-02f, 1.84859842e-01f, 2.30572879e-01f, 1.31946234e-02f, 2.31190726e-01f,
  -6.36410192e-02f, 1.33972555e-01f, 1.10844992e-01f, -7.01273903e-02f, -1.25745505e-01f, 1.17812082e-01f, 2.51074851e-01f, 1.03689216e-01f, -1.04176268e-01f, -2.42834255e-01f,
  -9.28693190e-02f, -3.39034311e-02f, -1.46994680e-01f, -1.66308552e-01f, 4.03765626e-02f, -6.41878471e-02f, 6.46601170e-02f, 1.48753282e-02f, -2.92084396e-01f, -1.09033756e-01f,
  1.58806622e-01f, 2.54875124e-01f, 1.44132003e-01f, 3.38847429e-01f, 5.47964573e-02f, -1.08612649e-01f, -5.51300086e-02f, -2.96134114e-01f, 1.28033996e-01f, -1.62108108e-01f,
  -9.51921567e-02f, 4.92088422e-02f, -1.25656091e-02f, 2.10846886e-02f, 1.05033532e-01f, 1.29602864e-01f, 1.06325753e-01f, 9.16747153e-02f, 9.06050578e-02f, -1.95389897e-01f,
  1.32345498e-01f, -1.03508256e-01f, -1.52012885e-01f, -4.90737185e-02f, 1.03023618e-01f, 2.60995496e-02f, -4.15102951e-02f, -1.51296183e-01f, -3.90321493e-01f, -3.69902462e-01f,
  -1.61137804e-01f, -1.16367489e-01f, 6.70146793e-02f, -1.02392338e-01f, 7.51109840e-03f, -2.16591612e-01f, 8.97251293e-02f, -8.40690583e-02f, 1.40560538e-01f, -3.56090397e-01f,
  1.64907008e-01f, -1.64519906e-01f, 3.77105251e-02f, -6.78262562e-02f, 1.83553800e-01f, 2.31699124e-01f, -2.77683306e-02f, -8.61048400e-02f, -2.04092208e-02f, 2.40580756e-02f,
  -2.78771937e-01f, -2.22668380e-01f, 8.22593868e-02f, 3.30958702e-03f, -9.27276462e-02f, -3.07608873e-01f, -2.77650543e-02f, -5.06263785e-03f, -4.88347821e-02f, -1.64160118e-01f,
  -2.23421291e-01f, -3.64725813e-02f, 2.09807500e-01f, 4.55422550e-02f, -9.48609412e-02f, -3.07070971e-01f, 1.21701315e-01f, -1.14750877e-01f, -1.09110534e-01f, 2.84731567e-01f,
  -1.82337150e-01f, 1.18995257e-01f, 1.56131744e-01f, -1.22941025e-01f, -1.48398280e-01f, 8.62319991e-02f, 9.59135294e-02f, 1.88106775e-01f, 8.59773308e-02f, 1.53184623e-01f,
  3.99086289e-02f, 2.63545275e-01f, -6.08070418e-02f, 9.86330286e-02f, -2.32504293e-01f, 6.70878217e-02f, 1.00526102e-01f, 2.78647449e-02f, 6.42253384e-02f, -1.36452233e-02f,
  4.90355529e-02f, 5.14391717e-03f, -1.83863956e-02f, 2.40991995e-01f, -8.30355585e-02f, -4.42558303e-02f, 6.50702640e-02f, 1.34867862e-01f, 3.93124223e-02f, 6.26519322e-02f,
  1.32713646e-01f, -3.23088884e-01f, -2.35334739e-01f, 1.97510973e-01f, 1.07855849e-01f, 2.78501689e-01f, 2.94695888e-02f, 2.51324791e-02f, 3.24374624e-02f, -5.88455126e-02f,
  -1.40932873e-01f, -2.13357389e-01f, -1.65307775e-01f, -8.17862377e-02f, 7.90861845e-02f, 7.23289922e-02f, -8.06069747e-02f, 5.92504293e-02f, -2.97853529e-01f, 6.57380223e-02f,
  1.86914384e-01f, -1.21714026e-02f, 5.11814132e-02f, 2.23541498e-01f, -3.19371909e-01f, 2.00037792e-01f, 2.71264315e-02f, 5.80360647e-03f, 2.36583635e-01f, -5.67472726e-03f,
  1.56092197e-01f, -1.44660011e-01f, -9.98649597e-02f, -2.78381586e-01f, 8.41270834e-02f, 8.74894783e-02f, -2.42949992e-01f, -1.93318501e-01f, 1.77460566e-01f, 2.37465426e-01f,
  1.55701146e-01f, -2.17764750e-02f, 7.65444189e-02f, -1.26627102e-01f, 1.08636022e-01f, -7.21839443e-02f, -1.42242432e-01f, -1.31482230e-02f, -6.77656978e-02f, -9.65057984e-02f,
  5.07541038e-02f, 7.07607809e-03f, 2.84908041e-02f, 1.11346625e-01f, 1.47586837e-01f, 2.48144180e-01f, 8.71843174e-02f, 7.16510192e-02f, 1.48258001e-01f, 3.51995341e-02f,
  1.43612931e-02f, 1.69604301e-01f, 2.68609300e-02f, 3.50331627e-02f, -5.02794385e-02f, -1.13362700e-01f, -9.12925899e-02f, -1.62193343e-01f, -1.57117039e-01f, -3.49551022e-01f,
  4.00118947e-01f, 3.11199706e-02f, 1.50771633e-01f, -2.17468664e-01f, 4.58363481e-02f, -3.96618340e-03f, 1.93266738e-02f, -5.04173599e-02f, -6.07397892e-02f, 5.14776781e-02f,
  -6.44018501e-02f, 2.15893283e-01f, -1.16291441e-01f, 5.17482832e-02f, 1.58635870e-01f, -1.78565934e-01f, 1.12557083e-01f, -5.48494197e-02f, -2.00005636e-01f, 2.03878924e-01f,
  -2.19289144e-03f, -9.60111395e-02f, -1.06297933e-01f, 1.45857066e-01f, -1.01643763e-01f, -3.75575334e-01f, 5.26524857e-02f, 6.82958439e-02f, -2.24075392e-01f, 1.55604854e-02f,
  8.78869966e-02f, -3.57303582e-02f, 1.53808430e-01f, 6.99703544e-02f, -2.77021602e-02f, -1.52038666e-03f, 1.92157745e-01f, 1.31806741e-02f, 1.74595013e-01f, 2.33309746e-01f,
  -1.20579302e-02f, 8.41891170e-02f, -1.23741649e-01f, -1.24194615e-01f, 1.45132035e-01f, 1.79590404e-01f, -2.17235789e-01f, 1.80493683e-01f, 1.87899590e-01f, 1.23559833e-01f,
  7.64412135e-02f, 1.08740665e-01f, 7.28068501e-02f, -1.02531932e-01f, -3.73535976e-02f, -9.99346897e-02f, -1.16307952e-01f, 1.48975730e-01f, 5.94527908e-02f, -1.76827431e-01f,
  -1.46706060e-01f, 2.20261123e-02f, -8.92355368e-02f, -2.48575825e-02f, -3.74047607e-01f, 1.71317026e-01f, 1.45735502e-01f, -4.23162937e-01f, 4.10204343e-02f, -5.05451709e-02f,
  1.97702292e-02f, 5.59454337e-02f, 5.16216047e-02f, -7.31412172e-02f, -2.93003675e-02f, -1.97598785e-01f, -2.86952019e-01f, -1.11281201e-01f, -1.37870267e-01f, 3.73093262e-02f,
  -1.72978099e-02f, 1.81241646e-01f, -8.34641457e-02f, -2.31546223e-01f, -1.93776730e-02f, -3.14886458e-02f, 1.43012673e-01f, -8.23012665e-02f, 9.30409357e-02f, 2.10713521e-01f,
  -1.75828084e-01f, -2.53030509e-01f, -1.80638731e-02f, -1.68581694e-01f, -4.47917506e-02f, -5.46435192e-02f, 8.00561979e-02f, 1.76204860e-01f, -5.38039394e-02f, -1.36368781e-01f,
  1.01004228e-01f, 1.59651220e-01f, -4.79879901e-02f, -9.24597606e-02f, -6.39753863e-02f, 3.19838822e-02f, 1.43813919e-02f, 5.12877144e-02f, -6.80733845e-02f, 2.13496715e-01f,
  1.63275953e-02f, 1.82161406e-01f, -2.06539735e-01f, -5.50676994e-02f, 2.98077874e-02f, 3.60118933e-02f, 1.41883805e-01f, 1.12817422e-01f, -9.29275453e-02f, 1.46832392e-01f,
  -4.55292463e-02f, 1.35687038e-01f, -7.88897797e-02f, 1.07601918e-01f, -4.97485697e-03f, -1.59515381e-01f, -5.26161827e-02f, -8.88418332e-02f, 1.70062020e-01f, 5.88846207e-02f,
  1.74146116e-01f, -6.69705942e-02f, -1.16270915e-01f, -1.35204658e-01f, -2.96843618e-01f, -3.03984165e-01f, 2.57159397e-02f, 1.45749614e-01f, -1.84070855e-01f, 6.23986125e-02f,
  -1.49148017e-01f, 2.89291609e-02f, -8.57145861e-02f, -1.47932261e-01f, -1.64812170e-02f, -1.92304254e-01f, -1.45294830e-01f, 2.43541840e-02f, -1.21529810e-01f, 5.23315780e-02f,
  9.04341713e-02f, 1.56665310e-01f, 9.25826952e-02f, 9.33083333e-03f, -4.79744840e-03f, -1.92957625e-01f, -9.03645903e-02f, -5.13073429e-02f, -2.44326610e-02f, 1.64967313e-01f,
  1.39729142e-01f, 7.51559362e-02f, -1.97436377e-01f, -8.28118175e-02f, 1.17742620e-01f, 1.10388007e-02f, 6.28726259e-02f, -1.69044882e-01f, 2.75693275e-02f, 2.34395918e-02f,
  1.98199600e-01f, -9.60534662e-02f, 3.36173922e-02f, -3.28653187e-01f, -8.81969333e-02f, -2.01915056e-02f, -1.68820787e-02f, -7.28578568e-02f, 1.32741421e-01f, -1.77807927e-01f,
  1.34474427e-01f, 7.06612319e-02f, -6.20303005e-02f, -7.51517639e-02f, 9.70225558e-02f, 2.43794061e-02f, -2.47306935e-02f, 1.75190680e-02f, 7.21807182e-02f, -2.17381552e-01f,
  3.91646661e-02f, 9.09060091e-02f, -1.10096395e-01f, 1.67132374e-02f, -4.03756537e-02f, 5.83660454e-02f, -8.47591385e-02f, 9.53697041e-02f, 3.74081999e-01f, -6.28377944e-02f,
  -4.24908213e-02f, 2.03364834e-01f, -1.93833057e-02f, 5.96700720e-02f, 1.91056892e-01f, -2.66929656e-01f, -7.89871439e-02f, 1.53089345e-01f, -2.45131537e-01f, -2.02632636e-01f,
  7.51405805e-02f, -1.04367614e-01f, -1.89783588e-01f, 9.53513905e-02f, 9.96558219e-02f, -1.02850832e-01f, 5.75042889e-02f, -2.54585475e-01f, -2.45681424e-02f, -1.90750882e-02f,
  9.10145864e-02f, 1.33559629e-01f, -4.28756364e-02f, 1.58513293e-01f, -1.68465540e-01f, -1.11084491e-01f, 7.04361638e-03f, 1.69750601e-01f, 9.32953507e-02f, 6.62370026e-02f,
  1.06695734e-01f, 2.36803829e-03f, -1.29518479e-01f, 4.03795727e-02f, 2.10093185e-02f, -1.06280193e-01f, -6.16500974e-02f, -2.64957935e-01f, -8.61394480e-02f, 1.79647341e-01f,
  -3.51585984e-01f, -2.74359696e-02f, 2.54032940e-01f, 3.65937948e-02f, 1.04749151e-01f, -7.24690594e-03f, -5.64375380e-03f, -1.69781819e-02f, 7.35297799e-02f, -1.45044640e-01f,
  4.52434607e-02f, -4.62676324e-02f, 1.48443401e-01f, 8.69350806e-02f, -4.59984429e-02f, -1.56233441e-02f, -1.15073405e-01f, -2.31280848e-01f, 3.94016169e-02f, -2.97125012e-01f,
  -4.70326729e-02f, 1.44720733e-01f, 2.48937845e-01f, -8.53654891e-02f, 5.40683791e-02f, 1.01404302e-01f, 3.29530090e-02f, 5.70267215e-02f, 1.73015922e-01f, -2.46467456e-01f,
  -6.85618818e-02f, 2.05815345e-01f, -3.28196049e-01f, -1.07306175e-01f, 7.99660385e-03f, -5.74002974e-02f, -1.82601362e-01f, 5.41582778e-02f, -2.43886098e-01f, -1.12291880e-01f,
  -4.32406925e-02f, 2.30125353e-01f, -4.83147502e-02f, -1.51966900e-01f, 4.38688770e-02f, 7.53204450e-02f, -2.46805442e-03f, 3.44285965e-01f, -1.91630080e-01f, 1.06994584e-01f,
  1.26103714e-01f, 9.28474590e-03f, -1.97240580e-02f, -8.81106853e-02f, -4.29025702e-02f, -2.30832472e-02f, 3.35448384e-02f, 1.64666876e-01f, 7.64612705e-02f, 9.90179926e-02f,
  -1.01530246e-01f, -2.03717172e-01f, 3.23885046e-02f, 2.28389516e-01f, -2.80411184e-01f, -6.05298802e-02f, 4.63559180e-02f, -1.30324692e-01f, 1.75819576e-01f, 1.61559209e-01f,
  -9.53089520e-02f, -1.44458532e-01f, 8.98617599e-03f, -2.24937394e-01f, 1.14802100e-01f, -8.70555267e-03f, 1.73476692e-02f, 2.19577655e-01f, -1.03265584e-01f, 2.09212601e-02f,
  -1.33085296e-01f, -1.81778640e-01f, 6.17704988e-02f, -2.12420031e-01f, -2.47253999e-01f, -5.77975251e-02f, 2.83113211e-01f, -1.16759852e-01f, 3.39077674e-02f, 5.52944615e-02f,
  9.33324322e-02f, -5.30475937e-03f, 8.78769159e-02f, -9.91988331e-02f, -2.70944051e-02f, 1.19686037e-01f, -1.64712682e-01f, 6.68328404e-02f, 2.25217879e-01f, -3.96113276e-01f,
  -7.05334544e-02f, 1.10448837e-01f, -2.64055073e-01f, -1.03976130e-01f, 2.08552126e-02f, -1.02019394e-02f, -6.01037815e-02f, 8.43972713e-02f, 1.88758940e-01f, 1.93180159e-01f,
  -1.01923440e-02f, 4.66741383e-01f, -1.14272706e-01f, 1.13052368e-01f, -1.22023076e-01f, -3.25960107e-02f, 5.76512553e-02f, 2.77473778e-02f, 1.32989049e-01f, 4.64984328e-02f,
  1.29499147e-02f, 1.77408665e-01f, 1.15997896e-01f, -1.12539418e-01f, 7.22109154e-02f, -3.30577418e-02f, 5.11898957e-02f, 8.07552710e-02f, -7.74365589e-02f, -3.71284671e-02f,
  1.39667615e-01f, -1.06463199e-02f, 1.45337805e-01f, 2.30198443e-01f, 8.89206752e-02f, -3.71485879e-03f, -5.69947902e-03f, 6.02023005e-02f, -2.01402470e-01f, -1.64212156e-02f,
  -1.60000145e-01f, -5.67542063e-03f, -1.40383452e-01f, 1.18054287e-03f, 7.56401941e-02f, -1.22209780e-01f, -1.32273495e-01f, -8.70066732e-02f, -2.81818986e-01f, -1.66281834e-01f,
  -6.58644512e-02f, -9.37801376e-02f, 2.03979090e-01f, 2.94889271e-01f, -2.07743287e-01f, 8.66166800e-02f, 6.78123012e-02f, 2.43613362e-01f, 3.02180648e-01f, 1.38195649e-01f,
  -7.44243339e-02f, -1.98390469e-01f, -1.69568546e-02f, -7.07207844e-02f, -2.78181911e-01f, -1.26792535e-01f, 7.51285180e-02f, 7.93496966e-02f, 4.60287603e-03f, -3.29386771e-01f,
  -1.40842393e-01f, 2.52858158e-02f, 1.60214484e-01f, -1.12450778e-01f, 4.56777290e-02f, 3.61265391e-01f, -9.44228843e-02f, -8.92374068e-02f, 6.63425103e-02f, -2.06406534e-01f,
  -5.55135459e-02f, -1.26025215e-01f, -1.52869254e-01f, -3.37182283e-01f, -1.07546903e-01f, 6.55731633e-02f, 2.84807496e-02f, -2.33023211e-01f, 1.82854533e-01f, 1.79195300e-01f,
  -1.87813982e-01f, 1.68363564e-02f, 1.22455530e-01f, 4.29750197e-02f, 2.07291963e-03f, 1.94497257e-01f, 1.93946749e-01f, 1.31326513e-02f, 7.52131715e-02f, 2.08804533e-01f,
  1.40327498e-01f, 5.66421598e-02f, -4.70098406e-02f, 1.78967312e-01f, 4.31053760e-03f, -2.45512977e-01f, 1.20562881e-01f, -1.12453490e-01f, 1.71088144e-01f, 8.59229341e-02f,
  7.19851032e-02f, -3.53429951e-02f, 1.98493153e-01f, 5.79867773e-02f, 8.50556269e-02f, -4.17550243e-02f, 1.95643187e-01f, 7.63723552e-02f, 7.60999843e-02f, 1.81440368e-01f,
  -5.85972778e-02f, 4.95999567e-02f, -9.22555700e-02f, -1.52526379e-01f, -6.11125007e-02f, -2.22020671e-01f, 1.41107291e-01f, -2.45324701e-01f, -2.99594611e-01f, 1.10594168e-01f,
  1.00252293e-01f, 1.01859011e-01f, -2.46104915e-02f, -5.33421449e-02f, 1.66881844e-01f, -6.47479817e-02f, -1.13966167e-01f, 2.53301635e-02f, -7.73369297e-02f, -1.71236077e-03f,
  9.29029584e-02f, -7.35494681e-03f, 1.16265438e-01f, -1.66626573e-02f, 5.12465462e-02f, -1.99422866e-01f, 1.49049863e-01f, -3.08358129e-02f, -9.16463658e-02f, 2.51818299e-01f,
  2.38632858e-02f, 5.85409030e-02f, 1.24720693e-01f, -5.77557944e-02f, 2.12337688e-01f, 2.55564243e-01f, -8.38039219e-02f, -9.64920223e-02f, -2.51227859e-02f, -7.84544498e-02f,
  2.44088590e-01f, 2.06229016e-01f, 1.88904732e-01f, 1.83172468e-02f, 1.06604593e-02f, -1.81237325e-01f, -2.18507554e-02f, -1.01178601e-01f, 2.41878763e-01f, 4.39608470e-02f,
  -1.15447246e-01f, -2.24921420e-01f, 1.18885644e-01f, -2.48601481e-01f, 7.41299242e-02f, -2.66372766e-02f, -2.70084649e-01f, -8.36983845e-02f, 2.46923864e-01f, -1.01659141e-01f,
  1.13242798e-01f, 1.19756997e-01f, -1.62176445e-01f, 1.19140022e-01f, 2.01375023e-01f, 1.71291545e-01f, 1.13284715e-01f, 8.64595920e-02f, -2.96261460e-01f, 1.28290713e-01f,
  -3.67840491e-02f, -2.99037308e-01f, -3.06478832e-02f, 6.71451390e-02f, -2.41667200e-02f, -1.02129526e-01f, 3.96286845e-02f, -3.23376060e-01f, -5.79330735e-02f, 2.49099694e-02f,
  1.26296878e-01f, 2.63511211e-01f, 1.16978437e-01f, 3.33602816e-01f, -1.15116440e-01f, 6.17985204e-02f, 1.63456947e-01f, 3.92395146e-02f, -3.31018753e-02f, -2.14655604e-03f,
  4.07843338e-03f, -8.70974734e-02f, 6.60553649e-02f, -1.85566604e-01f, 7.31288046e-02f, -9.76410136e-02f, 9.87569690e-02f, -2.08284007e-03f, -1.23516016e-01f, -7.95035958e-02f,
  -1.40096873e-01f, 1.39841199e-01f, -2.13951379e-01f, -1.60877228e-01f, -1.13140538e-01f, 1.28883854e-01f, 1.62282780e-01f, -1.16288424e-01f, -3.22089940e-02f, -6.54834211e-02f,
  -1.31246755e-02f, 2.21707866e-01f, 4.60761376e-02f, 1.15984298e-01f, 3.68288726e-01f, -1.48612753e-01f, 4.02203947e-01f, -1.01274885e-02f, 3.41650397e-01f, 7.47590885e-02f,
  -7.64562264e-02f, 8.35829601e-03f, -3.20671767e-01f, 3.40999424e-01f, -2.04640359e-01f, -2.03385547e-01f, 1.79032668e-01f, -8.65468904e-02f, -1.58192054e-03f, -1.80323750e-01f,
  -3.97104472e-01f, -8.89258534e-02f, -5.74281476e-02f, -2.84581035e-02f, 3.97922397e-02f, 1.77451938e-01f, 3.82398516e-02f, -1.39866114e-01f, -4.74388190e-02f, -1.49082363e-01f,
  -2.87766606e-01f, 1.86283976e-01f, 1.93212032e-01f, -3.80563110e-01f, -3.52007151e-01f, -7.66256964e-03f, -3.71808559e-01f, 2.10341230e-01f, -4.98932377e-02f, 2.93265045e-01f,
  -3.30268443e-02f, -7.73071274e-02f, -8.43565911e-02f, -5.44610061e-02f, 1.45361889e-02f, -6.50430331e-03f, 2.72018854e-02f, -2.85595655e-01f, 4.56441194e-02f, -2.61361189e-02f,
  -7.12012798e-02f, -5.74422404e-02f, 3.42152447e-01f, -1.90828681e-01f, 8.17902088e-02f, 9.71416160e-02f, -4.45511714e-02f, -2.96324138e-02f, -1.28535405e-01f, 1.16596602e-01f,
  1.79460198e-01f, -1.27632646e-02f, -7.99802616e-02f, -1.67299375e-01f, 2.27020949e-01f, 4.37480323e-02f, -8.84697074e-04f, 2.48917684e-01f, 4.86759320e-02f, -5.17305136e-02f,
  -3.74532759e-01f, -2.05369085e-01f, -3.25913519e-01f, 2.54210323e-01f, 2.32850295e-03f, 7.79128820e-02f, -1.13477834e-01f, 3.10601741e-01f, -3.51636887e-01f, -4.53753509e-02f,
  3.38821448e-02f, 5.16232811e-02f, -7.16852620e-02f, -2.80740857e-01f, 2.72869438e-01f, 6.96549937e-02f, -3.30202758e-01f, 8.40481967e-02f, -3.28291580e-02f, 8.43464509e-02f,
  3.50171149e-01f, 1.51248142e-01f, -1.79772060e-02f, -1.70744881e-01f, -5.49206045e-03f, -2.91545987e-01f, 1.34232000e-01f, 3.13360840e-01f, 2.02385426e-01f, 2.39331797e-02f,
  9.46597159e-02f, -1.48125276e-01f, 2.44284943e-02f, 7.02522695e-02f, 1.33149043e-01f, -1.18979265e-03f, 1.03073880e-01f, 1.59245059e-01f, 1.53730839e-01f, -2.61918223e-03f,
  -8.79530534e-02f, -1.08064353e-01f, 2.60595888e-01f, -3.75340320e-02f, 4.56553623e-02f, -4.03952822e-02f, 3.33018720e-01f, 2.68482268e-02f, 1.01201072e-01f, 1.78563036e-02f,
  -4.66167688e-01f, 1.89411938e-02f, -2.65711665e-01f, -1.47339925e-01f, 2.12755144e-01f, 9.01850387e-02f, 3.90377566e-02f, -1.08084276e-01f, 2.04301059e-01f, 1.02163695e-01f,
  3.56500804e-01f, -2.22666822e-02f, 1.76665097e-01f, -1.70398459e-01f, 1.36135116e-01f, 6.46295026e-02f, 3.36964995e-01f, 1.69178173e-01f, 7.15819672e-02f, 6.11775592e-02f,
  2.58740485e-01f, -1.03040963e-01f, -4.07840937e-01f, -2.28652522e-01f, 2.02218682e-01f, 1.53586447e-01f, -1.35547131e-01f, -1.95411503e-01f, -9.16497037e-02f, 5.19299321e-02f,
  -3.99792902e-02f, -2.54759863e-02f, 5.84489927e-02f, -1.13329768e-01f, 2.18244046e-01f, 5.67304157e-02f, -1.23069324e-01f, -3.80557597e-01f, -6.35442808e-02f, -3.90280604e-01f,
  6.14292286e-02f, 1.91534996e-01f, 7.13310689e-02f, 2.55784959e-01f, -6.26386702e-02f, -3.31207544e-01f, -1.26937911e-01f, -1.95051767e-02f, 2.09553633e-02f, 1.53294072e-01f,
  9.64765921e-02f, 2.30840459e-01f, -1.41308621e-01f, 1.17143810e-01f, 1.56666517e-01f, 4.83462363e-02f, -5.35822436e-02f, 1.97993904e-01f, 1.78093642e-01f, 1.71318322e-01f,
  -1.68183386e-01f, 2.80612484e-02f, -1.38891414e-01f, -7.59864599e-02f, -1.17588706e-01f, 3.31554562e-02f, 1.06660157e-01f, -1.77742522e-02f, 1.30627885e-01f, -1.13394380e-01f,
  1.82679996e-01f, -1.40601516e-01f, 5.42822257e-02f, 9.83281434e-03f, -5.20625431e-03f, 2.06436604e-01f, -1.96813792e-01f, 1.44109651e-01f, -1.05694890e-01f, -4.24587838e-02f,
  3.46467979e-02f, -1.19695097e-01f, 5.39586097e-02f, -2.18025148e-02f, -1.78373814e-01f, 4.62030880e-02f, -8.40973929e-02f, 6.29519522e-02f, -6.46820739e-02f, -8.52382928e-02f,
  -1.44247591e-01f, 6.44555539e-02f, -5.50814206e-03f, 3.63504998e-02f, -3.59898992e-02f, 3.99443544e-02f, -1.21218592e-01f, -1.83855310e-01f, -4.66498174e-02f, 1.60942569e-01f,
  2.30995923e-01f, -1.81401029e-01f, -3.58639881e-02f, 1.40470505e-01f, -3.59513685e-02f, -2.67290562e-01f, -5.56417443e-02f, -1.74325138e-01f, -2.44375430e-02f, -1.78432781e-02f,
  -1.06172375e-01f, 1.05147481e-01f, 1.02021255e-01f, 4.57276329e-02f, -7.72731230e-02f, 5.71813770e-02f, 8.37717801e-02f, 1.42449647e-01f, -1.38404623e-01f, -1.50522508e-04f,
  5.49268611e-02f, 8.27348083e-02f, -1.58500791e-01f, 9.00653824e-02f, 1.74999759e-01f, -5.60493805e-02f, 1.90055385e-01f, -8.61502290e-02f, -1.99433267e-01f, -1.15114838e-01f,
  -2.28388712e-01f, 2.24970169e-02f, 1.90197855e-01f, 5.15971631e-02f, -9.63186622e-02f, -2.12891430e-01f, 9.66450274e-02f, -1.19285934e-01f, -7.20290616e-02f, 1.38070941e-01f,
  -8.95401910e-02f, -2.23310530e-01f, -1.08469233e-01f, -3.38685900e-01f, -1.88941881e-01f, 1.55552998e-01f, -2.53375471e-01f, 4.52072807e-02f, -1.56885833e-01f, 2.32518483e-02f,
  -2.68556565e-01f, -3.30732375e-01f, 4.99655232e-02f, 1.67345345e-01f, 6.67745173e-02f, -1.89538062e-01f, 7.62924552e-02f, -6.05127215e-02f, -1.45471856e-01f, 3.29556465e-02f,
  3.66886854e-02f, 1.57395333e-01f, 3.20040435e-01f, 2.99215391e-02f, -1.45331651e-01f, -1.59702078e-01f, 1.44653991e-01f, -2.40879320e-02f, -1.49598137e-01f, 3.43351364e-01f,
  4.54509556e-02f, 1.14817604e-01f, 2.21165001e-01f, -3.58503550e-01f, 4.08588648e-02f, 3.27909663e-02f, 9.89288688e-02f, 2.79629976e-02f, 1.77115098e-01f, -9.33546852e-03f,
  1.20493330e-01f, 1.28064573e-01f, 8.01286250e-02f, -1.26246409e-02f, -9.00286362e-02f, 9.24702659e-02f, -1.99466541e-01f, -5.97674511e-02f, 1.62515640e-01f, 6.29462302e-03f,
  5.65589778e-03f, -1.80433337e-02f, -1.95868030e-01f, 1.34545118e-01f, -6.83166645e-03f, 1.01834804e-01f, 1.52834311e-01f, 1.36552826e-01f, -2.28339940e-01f, 1.42655484e-02f,
  -2.03983665e-01f, -1.91890374e-01f, 1.99394345e-01f, 1.98628083e-01f, -2.88199484e-02f, -1.82882287e-02f, -6.95386231e-02f, -2.40699261e-01f, -1.15110584e-01f, -1.97200760e-01f,
  -2.10500747e-01f, -8.36085901e-02f, -4.05285545e-02f, 6.12450689e-02f, -6.95625842e-02f, -1.81867369e-02f, 2.77364720e-02f, 1.87686831e-01f, -1.02474496e-01f, -5.78102618e-02f,
  2.39070043e-01f, 1.84444115e-01f, -1.09033301e-01f, 7.59214908e-02f, 6.02188371e-02f, -2.85628475e-02f, 2.09902003e-01f, -1.20776325e-01f, -1.53277799e-01f, -2.85523742e-01f,
  -1.09035313e-01f, -2.13228658e-01f, -1.14154540e-01f, 4.85543311e-02f, 2.68419474e-01f, 1.90530822e-01f, 7.04029649e-02f, 2.42166802e-01f, 2.37701893e-01f, -9.50873084e-03f,
  -2.32677273e-02f, 5.64959310e-02f, 6.93954676e-02f, 2.10586190e-01f, 3.81412953e-02f, 2.02671081e-01f, -1.81988627e-01f, -2.31787786e-01f, 8.69093165e-02f, -8.29733035e-05f,
  -4.09832560e-02f, -9.92291272e-02f, 7.24389628e-02f, -6.00383468e-02f, 7.55974129e-02f, -6.97520301e-02f, 4.28774096e-02f, -3.81075382e-01f, -7.98838958e-02f, -1.00674823e-01f,
  -3.20786834e-01f, -2.25870252e-01f, -2.37039521e-01f, -1.23348206e-01f, 2.02246338e-01f, -1.86559409e-01f, 2.74395496e-02f, -2.39034176e-01f, -1.89650923e-01f, 1.31931409e-01f,
  -2.55452335e-01f, -2.73233265e-01f, -3.91437709e-01f, 1.63161412e-01f, -1.49888963e-01f, 1.43072819e-02f, 7.45760053e-02f, 4.10884656e-02f, 5.88283837e-02f, -3.58930789e-02f,
  -7.24063665e-02f, -1.29790515e-01f, 1.89707026e-01f, -1.09668374e-01f, 1.30669579e-01f, -5.18887155e-02f, -2.40605801e-01f, -4.45195436e-01f, 7.24829063e-02f, 2.64071107e-01f,
  2.44585097e-01f, -6.19072877e-02f, -1.42138794e-01f, -1.12299785e-01f, 2.59757429e-01f, 8.65660384e-02f, 7.65123740e-02f, 4.50294137e-01f, 3.24909575e-02f, -1.43995807e-01f,
  1.04335591e-01f, -5.88040613e-02f, 3.40759307e-02f, 4.60094120e-03f, 1.31477639e-01f, 1.43297225e-01f, 1.75308526e-01f, 8.44204277e-02f, 2.17151076e-01f, 6.76117241e-02f,
  3.73209417e-02f, -1.39625043e-01f, -7.84625709e-02f, 1.16414219e-01f, -1.93533674e-01f, -9.14689675e-02f, 2.61367690e-02f, -7.39287883e-02f, 3.71423140e-02f, 1.87936857e-01f,
  4.09326553e-01f, 1.28563941e-01f, 1.42563164e-01f, 1.49192050e-01f, -1.51161745e-01f, -1.12612760e-02f, -3.59086804e-02f, -1.95000395e-02f, 7.24150315e-02f, 4.01015095e-02f,
  -2.91603744e-01f, -2.25415841e-01f, -3.38955283e-01f, -8.95329192e-02f, -3.75499219e-01f, -1.04343377e-01f, -2.50733107e-01f, -1.78523079e-01f, 1.27872050e-01f, 8.63054674e-03f,
  -1.21340873e-02f, 3.16152751e-01f, -1.57203555e-01f, -9.34914860e-04f, 1.29928082e-01f, 6.84767812e-02f, 7.80539662e-02f, -1.94597676e-01f, -2.36045182e-01f, 1.71262875e-01f,
  -3.28148156e-01f, 1.45053640e-01f, -1.66156087e-02f, 5.17775863e-02f, -3.68818976e-02f, -1.36738792e-01f, 1.43194888e-02f, -5.78759760e-02f, -1.08818457e-01f, 6.04270935e-01f,
  8.48928764e-02f, -2.14739457e-01f, 4.92593050e-02f, 4.09756638e-02f, 7.42179528e-02f, 2.07304716e-01f, -6.96047619e-02f, 4.45924662e-02f, 4.44011204e-02f, -5.82672991e-02f,
  1.31924316e-01f, 1.70523264e-02f, 5.39906844e-02f, 1.22738518e-01f, -6.94681033e-02f, -2.42319837e-01f, 3.52353394e-01f, -6.82463348e-02f, -8.70933218e-05f, 3.40961628e-02f,
  2.90097028e-01f, 7.61882123e-03f, 1.19486541e-01f, -1.79740638e-01f, -1.46223083e-01f, -4.24853086e-01f, 5.57994656e-03f, -9.46825668e-02f, -1.50282219e-01f, -4.24347341e-01f,
  -9.49695781e-02f, -6.58656582e-02f, -4.50217538e-02f, -8.50714818e-02f, 1.03023104e-01f, -7.58373588e-02f, 1.22762524e-01f, -3.13649029e-01f, 2.82813311e-01f, -5.34621440e-02f,
  1.10962324e-01f, 2.98453033e-01f, -1.16859876e-01f, 8.31979662e-02f, 3.92367095e-02f, 1.43996522e-01f, -4.65639174e-01f, -2.99942285e-01f, 1.13787487e-01f, -1.44106850e-01f,
  -1.02769569e-01f, -2.76527256e-01f, -1.07007459e-01f, -1.32770121e-01f, -2.71201544e-02f, -3.41700941e-01f, -1.99755982e-01f, 1.52640536e-01f, 1.43713921e-01f, 5.21593429e-02f,
  -6.28433600e-02f, -3.93221676e-01f, 2.12460935e-01f, 8.52825418e-02f, 5.23103327e-02f, 1.51858672e-01f, -4.46743935e-01f, -1.85984612e-01f, 6.00734055e-02f, -1.00586116e-01f,
  -3.12733859e-01f, -1.42485648e-01f, 1.31053299e-01f, 3.92070450e-02f, 9.64220334e-03f, -8.12433437e-02f, 1.37097657e-01f, 7.79324770e-02f, 5.43557815e-02f, -1.04188874e-01f,
  -4.94714901e-02f, -1.99422054e-02f, 1.00068294e-01f, 2.67491400e-01f, -1.50516242e-01f, 1.13249771e-01f, -1.52317822e-01f, -1.06593430e-01f, -1.57472804e-01f, 3.09468545e-02f,
  -4.56390120e-02f, -2.20969811e-01f, 7.51827005e-03f, 1.51988328e-01f, 6.05380498e-02f, 2.04236045e-01f, -2.12817237e-01f, 2.36965343e-02f, -2.52954606e-02f, 4.38561942e-03f,
  -3.58292786e-03f, 1.08043864e-01f, 4.00384098e-01f, 2.07823850e-02f, 2.01556504e-01f, 7.82613084e-02f, -6.38681799e-02f, -4.04555176e-04f, -2.15626627e-01f, 2.56160200e-02f,
  1.99957222e-01f, -4.99299206e-02f, 4.83028926e-02f, 1.16573647e-01f, 1.97707824e-02f, 3.38983871e-02f, 8.38964339e-03f, -1.18714072e-01f, 2.83308208e-01f, -2.87031084e-01f,
  -2.17375964e-01f, 1.19243398e-01f, -1.35909289e-01f, -3.28058749e-02f, 8.50986317e-02f, 2.63609648e-01f, -2.01726090e-02f, 9.41295996e-02f, 4.06503454e-02f, -1.30123273e-02f,
  -2.09239677e-01f, 7.85911456e-02f, -4.32859734e-02f, -1.50017634e-01f, 4.60381210e-02f, -5.70468232e-02f, -1.38213951e-02f, 7.55426213e-02f, 1.40064448e-01f, 1.35656968e-02f,
  9.79622379e-02f, 2.36797348e-01f, -1.26602724e-01f, -2.40430906e-01f, 1.75330326e-01f, -1.07631600e-02f, -9.48095992e-02f, 6.21970631e-02f, -1.06165104e-01f, -1.24620534e-01f,
  3.79354432e-02f, -1.44926533e-01f, 9.35981497e-02f, -1.25826791e-01f, -1.14795610e-01f, -1.53002322e-01f, -2.56108373e-01f, -1.37940988e-01f, -8.56924653e-02f, 1.73307490e-02f,
  -3.01253726e-03f, -2.50064465e-03f, 3.82727683e-02f, 1.51466742e-01f, 7.56914616e-02f, 1.49741769e-01f, 8.00100863e-02f, 1.33665994e-01f, -3.00878942e-01f, 2.50451624e-01f,
  7.61351213e-02f, -8.10805485e-02f, -5.88485450e-02f, -1.19116694e-01f, 1.18945166e-01f, -1.90458689e-02f, -5.07810153e-02f, -1.14136651e-01f, 2.00236782e-01f, -1.38165489e-01f,
  1.57858461e-01f, -2.06656121e-02f, 2.68047780e-01f, -2.98272729e-01f, 1.28099784e-01f, 3.93036783e-01f, 9.97009948e-02f, 5.87698072e-04f, 3.94186564e-02f, -7.15246573e-02f,
  2.36934200e-01f, 1.55063391e-01f, 1.10556215e-01f, 2.36824647e-01f, -1.29358396e-01f, -1.24806233e-01f, 1.32400319e-01f, -5.44252433e-03f, -2.69191027e-01f, -5.18356673e-02f,
  6.02194592e-02f, 2.45598376e-01f, 1.40510127e-01f, 1.58220530e-02f, 1.44062743e-01f, 1.36809230e-01f, -1.67920347e-02f, 2.01210007e-01f, -6.55512065e-02f, 5.92471175e-02f,
  -9.24539864e-02f, 2.68173101e-03f, 2.07182765e-01f, 2.43585438e-01f, 1.20304553e-02f, 2.64860820e-02f, 1.16437431e-02f, 1.57496780e-01f, 7.17024803e-02f, -4.98498604e-02f,
  2.10187450e-01f, 2.41342500e-01f, -1.41120121e-01f, -9.06434134e-02f, 1.65710166e-01f, 4.63744849e-02f, 1.25910118e-01f, 1.34366140e-01f, -1.69023380e-01f, -2.42864847e-01f,
  -9.07023996e-02f, -1.78650573e-01f, 1.92679882e-01f, -7.65995458e-02f, -3.67896378e-01f, -1.02978028e-01f, 4.68073077e-02f, -8.17070007e-02f, -1.10575028e-01f, 1.20533250e-01f,
  -1.62288889e-01f, 2.41085768e-01f, 9.10936967e-02f, -2.42770296e-02f, 2.79829115e-01f, 1.37898326e-01f, -1.35763422e-01f, 7.86990151e-02f, -3.56738036e-03f, -3.52595776e-01f,
  1.06347203e-01f, 1.45430803e-01f, -5.52796610e-02f, -2.20120758e-01f, -8.54367688e-02f, -1.22143030e-01f, -8.26786757e-02f, 5.80104813e-02f, 8.09706673e-02f, 2.61099756e-01f,
  -7.27818683e-02f, 2.59468704e-01f, 3.32076922e-02f, 3.48289162e-02f, -4.54886220e-02f, 3.79790403e-02f, 7.45998323e-02f, -6.31115288e-02f, 7.05857128e-02f, -6.75231311e-03f,
  1.94508344e-01f, 5.52131087e-02f, 1.19632132e-01f, -9.35095623e-02f, 4.55267495e-03f, -2.48309895e-01f, 1.98447164e-02f, 2.31523886e-02f, 4.88464125e-02f, -3.26940604e-02f,
  -1.37549220e-02f, -1.15259603e-01f, 7.64147490e-02f, 1.18070304e-01f, -4.43372730e-04f, -4.57166992e-02f, -3.87661196e-02f, -1.30193189e-01f, 1.29804760e-01f, -1.18969351e-01f,
  6.50433600e-02f, 1.43267848e-02f, 3.26185301e-02f, -7.47911856e-02f, -1.60851151e-01f, -3.81768316e-01f, -7.62981847e-02f, 3.96172889e-02f, -1.74992144e-01f, -1.27704129e-01f,
  3.81433545e-03f, 4.46007727e-03f, -1.16647288e-01f, 9.11880210e-02f, -1.14098042e-01f, 2.05260422e-02f, 1.32181570e-01f, -2.11055651e-01f, 9.48558152e-02f, 1.82725325e-01f,
  -1.39040083e-01f, 5.76753132e-02f, 1.86822161e-01f, -5.96763119e-02f, 4.29399237e-02f, 1.59848228e-01f, -1.24174558e-01f, -5.89526296e-02f, 6.07457720e-02f, 2.80524027e-02f,
  -1.98992297e-01f, 5.73625490e-02f, 6.74918815e-02f, 3.69076580e-02f, 2.03401417e-01f, 2.39104524e-01f, -6.53308332e-02f, -1.90637574e-01f, 1.55729234e-01f, 1.69690382e-02f,
  2.12299004e-01f, 9.58629921e-02f, 1.29091889e-01f, 3.47277582e-01f, 1.18252877e-02f, -8.86955298e-03f, 1.44724533e-01f, -5.58964647e-02f, 1.16739830e-03f, 9.66584757e-02f,
  -1.39217883e-01f, -4.92635034e-02f, -1.19994402e-01f, -1.89598456e-01f, -4.53406602e-01f, -1.90002590e-01f, -2.39609048e-01f, -1.64529204e-01f, -2.40954161e-02f, -3.21053974e-02f,
  7.78325796e-02f, 1.63334459e-01f, 5.40207699e-02f, 1.96133759e-02f, 1.84868407e-02f, -1.73674989e-02f, 2.03402817e-01f, 3.52825597e-02f, 3.41610432e-01f, 3.24091837e-02f,
  6.90994188e-02f, 2.26357028e-01f, 5.34474216e-02f, -1.96973905e-01f, -2.86403984e-01f, 9.17731076e-02f, -5.10659367e-02f, -4.02234755e-02f, -5.44023737e-02f, -1.09912246e-01f,
  -8.36303681e-02f, 2.01704085e-01f, 2.45361507e-01f, -4.91155200e-02f, 2.69836247e-01f, -2.54860103e-01f, -1.49977908e-01f, 1.67809442e-01f, 6.93685040e-02f, 2.24547517e-02f,
  2.46341884e-01f, -4.90626805e-02f, 2.30385780e-01f, -2.75533140e-01f, -2.62238145e-01f, 2.46954843e-01f, 6.33113757e-02f, -2.21304104e-01f, 1.63587779e-01f, -9.04085115e-02f,
  -1.35994375e-01f, -2.53420055e-01f, -4.69977222e-02f, 2.50660982e-02f, -3.59851494e-02f, 4.66430448e-02f, -1.05708510e-01f, -1.08418971e-01f, 1.26160726e-01f, 1.10817634e-01f,
  -4.46064249e-02f, -4.32245657e-02f, 1.66525841e-02f, -6.81080818e-02f, -1.11129723e-01f, -3.13035026e-02f, -1.28791794e-01f, 2.29674652e-01f, -4.18003611e-02f, 3.24170850e-02f,
  -1.84361245e-02f, 1.99746173e-02f, 1.02215797e-01f, -3.48502308e-01f, 9.80775505e-02f, 5.15264273e-02f, -1.24641851e-01f, 5.58352135e-02f, -2.14978382e-01f, 3.34359258e-01f,
  1.97293926e-02f, -7.51290396e-02f, 3.97135429e-02f, -2.79478788e-01f, -7.05180317e-02f, -5.75609021e-02f, -1.20262869e-01f, -2.89097056e-03f, -8.64668190e-02f, 2.97367603e-01f,
  -3.83063853e-02f, 5.79717495e-02f, 2.22492311e-03f, 1.09602381e-02f, -6.31594062e-02f, -7.35690966e-02f, 7.66825005e-02f, 1.20373957e-01f, 1.33103713e-01f, 3.11036587e-01f,
  1.73883274e-01f, -9.28824116e-03f, -8.87846500e-02f, -4.46331203e-02f, -9.95807275e-02f, -3.49991024e-01f, 4.37035486e-02f, -1.97625533e-01f, 5.48212901e-02f, -5.04801422e-02f,
  2.08753482e-01f, -1.48068219e-01f, -9.87513512e-02f, 2.78859645e-01f, 6.17214255e-02f, 3.63776654e-01f, 1.20591760e-01f, 8.20135251e-02f, 1.91872910e-01f, -4.61540669e-02f,
  5.20769469e-02f, 4.61901836e-02f, -4.71079014e-02f, 2.73583028e-02f, -1.77009910e-01f, 1.30285740e-01f, 1.94300920e-01f, 2.02899680e-01f, -3.21223915e-01f, -7.79524967e-02f,
  -1.48376331e-01f, -2.13129029e-01f, -1.40221015e-01f, 1.80096239e-01f, -9.51246768e-02f, -1.86729312e-01f, -8.08200166e-02f, -2.19179273e-01f, 1.21858157e-01f, 9.78450030e-02f,
  -1.09895594e-01f, 3.97584960e-02f, -2.74857223e-01f, 2.34996721e-01f, 2.01379389e-01f, 2.28332952e-01f, 7.50689954e-02f, -1.60808265e-02f, 1.35319561e-01f, 2.32077297e-02f,
  2.40583867e-01f, -3.09826195e-01f, -1.98946938e-01f, -1.12028785e-01f, 2.69099057e-01f, 3.88745815e-02f, -1.90888450e-01f, -1.37649506e-01f, 2.48286575e-02f, 1.09173171e-01f,
  4.84767966e-02f, -2.52934732e-02f, 2.48687148e-01f, 1.03278600e-01f, -1.27574310e-01f, 3.90571803e-02f, -3.41632724e-01f, -9.16787460e-02f, 3.42435330e-01f, 9.34578553e-02f,
  8.00298899e-02f, -7.17016086e-02f, -9.31787863e-02f, -2.12553605e-01f, 1.09314285e-01f, -1.84127897e-01f, -8.80545080e-02f, 6.36215881e-02f, 3.05494089e-02f, -9.86223593e-02f,
  2.37747896e-02f, -1.23628445e-01f, -2.60834433e-02f, -3.13140415e-02f, 5.27257286e-02f, -1.46924466e-01f, 1.02894276e-01f, -1.23204075e-01f, 5.09249382e-02f, -9.93259028e-02f,
  5.35437018e-02f, 1.63444057e-01f, -9.51027274e-02f, -1.85579062e-01f, 1.96022615e-01f, -1.65475607e-02f, -5.36593385e-02f, 1.53531119e-01f, -1.18334085e-01f, 1.29322425e-01f,
  -7.39409700e-02f, 1.16010040e-01f, 9.21076760e-02f, 9.08267125e-02f, -1.34797335e-01f, 2.32913837e-01f, 7.66857108e-03f, -7.78651312e-02f, -8.44529644e-03f, 5.77885658e-02f,
  -1.68195978e-01f, 3.20974320e-01f, -1.56019494e-01f, 7.55174533e-02f, 1.72277123e-01f, 9.86509696e-02f, 8.95161480e-02f, 5.55303786e-03f, 1.07240438e-01f, 1.23847581e-01f,
  1.98077500e-01f, 2.44471341e-01f, 1.33055300e-01f, -7.15191364e-02f, -6.48891181e-02f, -2.63731807e-01f, -3.97906825e-02f, -4.57516387e-02f, 2.58452501e-02f, -3.75501364e-01f,
  -1.55988172e-01f, 1.52227342e-01f, -2.13098489e-02f, 2.43384689e-01f, 1.75837442e-01f, -8.01891461e-02f, 1.34723768e-01f, -2.21379727e-01f, -3.21322381e-01f, -2.92991754e-02f,
  -1.27045080e-01f, -1.15542203e-01f, 1.42580748e-01f, 1.86641496e-02f, 2.81496346e-01f, 2.86343545e-01f, 1.84299856e-01f, 2.92046994e-01f, 1.88158661e-01f, 2.27460027e-01f,
  -3.38687986e-01f, 1.82248399e-01f, -1.43151149e-01f, 4.72505949e-02f, 9.77822691e-02f, 1.53608397e-01f, 9.27609429e-02f, 4.85843755e-02f, -2.08457634e-01f, -2.05039218e-01f,
  2.39124030e-01f, 1.30639106e-01f, 1.11077309e-01f, 6.51706904e-02f, 7.65433088e-02f, 1.86994463e-01f, -1.23867184e-01f, 1.71132132e-01f, -4.84488569e-02f, -1.01422675e-01f,
  -6.88943490e-02f, -6.54214397e-02f, 1.15336619e-01f, 2.51812667e-01f, 6.31864667e-02f, 3.23186517e-01f, 4.33845110e-02f, 9.00092497e-02f, -1.59191210e-02f, -1.49076045e-01f,
  -2.88448602e-01f, -4.91688818e-01f, 3.51664305e-01f, 2.15550866e-02f, -2.06063673e-01f, 1.54562876e-01f, -5.41546233e-02f, 1.64606392e-01f, 1.27995908e-01f, -3.23482510e-03f,
  9.86743271e-02f, -2.03273594e-01f, -9.44821071e-03f, 8.42123013e-03f, -2.14205056e-01f, -1.55169323e-01f, 1.76025763e-01f, 4.29281086e-01f, 4.25918698e-02f, 3.87979060e-01f,
  -1.10543452e-01f, -9.84122083e-02f, 1.17349431e-01f, -1.05825374e-02f, 2.15193018e-01f, -1.83120713e-01f, -3.94312032e-02f, -8.30952972e-02f, 7.08589479e-02f, 6.59488738e-02f,
  6.17837459e-02f, 1.33623853e-01f, 8.75084549e-02f, 1.30739098e-03f, -6.55141547e-02f, -4.45966162e-02f, -1.66126259e-03f, 2.15916678e-01f, 4.48914729e-02f, 3.31543982e-02f,
  1.91141710e-01f, 7.28907511e-02f, 1.19811662e-01f, 1.28878534e-01f, -1.87718809e-01f, 8.52120146e-02f, 1.22416422e-01f, 3.71852368e-02f, 5.07969558e-02f, -1.32676996e-02f,
  -7.92563334e-02f, 1.35931492e-01f, -7.31722414e-02f, -1.87508464e-01f, -2.56704211e-01f, 1.73143089e-01f, -9.31953713e-02f, -3.12812999e-02f, 2.38131985e-01f, -2.68606186e-01f,
  -1.14876501e-01f, 2.67569404e-02f, -2.99251149e-03f, -4.29845713e-02f, -3.14765647e-02f, 7.08141103e-02f, -1.64331403e-02f, -2.82396320e-02f, -4.43315506e-02f, 1.71789736e-01f,
  -3.12767744e-01f, 1.01743154e-01f, 1.79150969e-01f, 1.40438795e-01f, 5.84648661e-02f, 1.02733396e-01f, -3.96670431e-01f, 3.68129879e-01f, 3.05841595e-01f, -1.22339182e-01f,
  -2.01090202e-01f, -3.05279434e-01f, -2.89960593e-01f, -3.37985873e-01f, 1.34104043e-02f, 8.55660886e-02f, 1.80161387e-01f, 1.17475674e-01f, -3.18813682e-01f, 6.28299937e-02f,
  2.70051152e-01f, 2.42919728e-01f, 1.83493942e-01f, 2.75241703e-01f, 3.78116518e-02f, 2.45331809e-01f, 2.53263056e-01f, 3.21663082e-01f, -2.88865659e-02f, -1.41974330e-01f,
  -1.75214827e-01f, -1.66550860e-01f, -1.66978538e-02f, 2.34906763e-01f, -1.02166437e-01f, 1.26116965e-02f, 1.71468332e-02f, -9.26887318e-02f, 7.11300522e-02f, 7.35540614e-02f,
  -2.20250472e-01f, -2.38222390e-01f, -3.43514681e-02f, 7.62132108e-02f, -6.08824231e-02f, 4.12081815e-02f, 6.43200427e-02f, 7.40773231e-02f, 2.31274124e-02f, 5.85749000e-02f,
  2.11547926e-01f, -9.23942192e-04f, 9.29527543e-03f, 8.87588114e-02f, 2.59154141e-01f, 7.57249743e-02f, -3.98918577e-02f, -1.15348585e-01f, -2.52697110e-01f, -6.43399637e-03f,
  -7.17695504e-02f, -1.49864689e-01f, 7.79188648e-02f, -1.24545723e-01f, 3.66651490e-02f, -7.28585273e-02f, -9.98289362e-02f, -4.00710180e-02f, 2.93116905e-02f, 8.08680654e-02f,
  -1.26869112e-01f, 4.62556370e-02f, -1.68918744e-02f, 1.08330309e-01f, -2.07157016e-01f, -2.94551887e-02f, 1.88956320e-01f, 4.54166293e-01f, -1.17086783e-01f, 2.13276595e-03f,
  -9.12577361e-02f, 6.29238263e-02f, 3.55917551e-02f, -2.03515962e-01f, 2.46571712e-02f, 2.95724750e-01f, 1.75966620e-01f, -1.10976463e-02f, -2.45959889e-02f, 3.99692450e-03f,
  1.90842494e-01f, 5.54301925e-02f, -1.70181151e-02f, -1.71511039e-01f, 5.18823862e-02f, -1.68143655e-03f, 1.45761490e-01f, 3.77756990e-02f, 2.46144816e-01f, 6.67382702e-02f,
  -1.02711260e-01f, -5.25583029e-02f, -5.77719688e-01f, -9.85684618e-02f, -1.61112860e-01f, -2.02638328e-01f, 2.46799573e-01f, 2.17653424e-01f, 1.29970163e-01f, -2.36565974e-02f,
  2.18297735e-01f, 2.93762814e-02f, 1.46936104e-01f, -5.33353984e-02f, 1.88496947e-01f, -9.72313210e-02f, 3.52883130e-01f, 3.32616419e-02f, 4.51288581e-01f, 1.11986235e-01f,
  -2.02631697e-01f, -1.68431178e-01f, 4.25677411e-02f, -3.82251330e-02f, -1.83733165e-01f, -1.80862799e-01f, -8.43124241e-02f, 5.39453402e-02f, 1.67960823e-02f, -1.01154372e-01f,
  1.49254605e-01f, 8.82316381e-02f, 3.16557795e-01f, -1.73604071e-01f, -1.35044858e-01f, 8.91043916e-02f, 1.70920566e-01f, 1.12442896e-01f, 1.66907869e-02f, -1.74579754e-01f,
  -6.12846091e-02f, -2.18856618e-01f, -2.05976218e-01f, -4.38622087e-02f, -7.72774592e-02f, 2.36323446e-01f, 3.23943682e-02f, -3.22574794e-01f, 3.42195742e-02f, -6.71359301e-02f,
  8.90318081e-02f, 7.45845214e-02f, 3.45065407e-02f, -4.11066721e-04f, 5.05205430e-02f, -1.02743566e-01f, -2.23871619e-01f, 2.20503315e-01f, -1.50880516e-01f, 6.65704459e-02f,
  -6.73765391e-02f, -1.97468877e-01f, 4.55241576e-02f, 2.81215817e-01f, -9.79105532e-02f, -2.28579771e-02f, -2.13613316e-01f, 7.05908937e-03f, -2.20244661e-01f, -6.31911382e-02f,
  1.98254615e-01f, 2.18545482e-01f, 3.83975394e-02f, -2.00699624e-02f, 2.44243622e-01f, 4.95220199e-02f, 1.45498231e-01f, 1.03734694e-01f, 6.67237788e-02f, -1.12995394e-01f,
  -2.11560503e-02f, -1.06186643e-02f, 4.75992739e-01f, 1.26662806e-01f, -1.67488128e-01f, -1.77036561e-02f, 2.00102076e-01f, 4.97058965e-02f, -3.23150456e-02f, -2.37917542e-01f,
  -4.94531505e-02f, 1.31314248e-01f, 6.41723052e-02f, -2.11491480e-01f, -8.38773698e-02f, 8.90082195e-02f, 7.23290443e-02f, 1.58798158e-01f, 2.88122837e-02f, -2.27376506e-01f,
  7.04629198e-02f, 2.03427970e-02f, -2.70472262e-02f, -2.70079911e-01f, -4.24851701e-02f, -2.04906017e-01f, 5.76547384e-02f, -3.31658244e-01f, 5.38873672e-02f, 3.56089681e-01f,
  -8.55730772e-02f, -2.19900087e-01f, 2.41135612e-01f, 3.24745834e-01f, -2.67818645e-02f, -2.88409088e-02f, 1.11505806e-01f, 3.61019783e-02f, 5.37149981e-02f, -1.18505329e-01f,
  1.37931064e-01f, 8.35267156e-02f, 4.74512726e-02f, 5.24066389e-02f, -1.43574625e-01f, -4.32066135e-02f, 7.02738911e-02f, 2.90986210e-01f, 6.59277057e-03f, -4.67136055e-02f,
  1.63565755e-01f, 2.56558694e-02f, 2.61544824e-01f, 1.92328885e-01f, 6.07215688e-02f, 4.07943949e-02f, 1.95888937e-01f, 2.85397880e-02f, -5.39700761e-02f, -1.18398301e-01f,
  -8.60510990e-02f, 2.17298027e-02f, -9.66116190e-02f, -2.08950430e-01f, 1.63686752e-01f, -5.67739047e-02f, 1.49565503e-01f, -1.25050619e-01f, -3.03993791e-01f, 4.31822315e-02f,
  6.70979619e-02f, -1.29212618e-01f, 3.05472724e-02f, 2.10818574e-01f, -1.28935039e-01f, 1.74768433e-01f, 7.66626969e-02f, 2.28894621e-01f, 3.55265401e-02f, 1.97782993e-01f,
  -1.69745777e-02f, 1.34948730e-01f, 6.74592927e-02f, -1.08569779e-01f, -1.78380497e-02f, 6.34207577e-02f, 1.79014370e-01f, 3.06078196e-02f, -2.41659600e-02f, -3.83091539e-01f,
  -1.88911855e-02f, -6.35959059e-02f, 6.66127130e-02f, 7.68629089e-02f, -2.47006472e-02f, 1.69958085e-01f, -3.55537124e-02f, -2.84922048e-02f, -5.48543260e-02f, -1.56109303e-01f,
  3.57682467e-03f, 1.04062058e-01f, 1.26461282e-01f, 8.61507729e-02f, 5.21988794e-02f, -1.39322896e-02f, 2.27494359e-01f, -2.10940815e-03f, 1.63176864e-01f, 1.24091886e-01f,
  1.50620461e-01f, -6.27692267e-02f, 1.92196369e-02f, 1.33818552e-01f, -2.46037915e-01f, -1.51554570e-01f, 9.52720735e-03f, 2.33205453e-01f, 2.01571379e-02f, -2.27382377e-01f,
  1.05620675e-01f, -1.09603919e-01f, -1.56877160e-01f, 1.39052913e-01f, 1.70223057e-01f, -8.45424831e-02f, 1.78920656e-01f, -1.82323977e-01f, 1.99647278e-01f, 1.89972669e-01f,
  1.60132110e-01f, 1.70836419e-01f, -5.12164412e-03f, -3.09503376e-02f, 1.67390972e-01f, 9.20307711e-02f, -4.44639713e-01f, -2.24040914e-02f, 5.86794205e-02f, 5.61664551e-02f,
  -1.73760042e-01f, -2.23414570e-01f, -3.50787193e-01f, 1.89921539e-02f, -8.71106051e-03f, -1.78584889e-01f, 1.33165166e-01f, -6.27265796e-02f, 1.81962978e-02f, 1.29397074e-02f,
  -1.34918198e-01f, -2.24644110e-01f, -4.06992324e-02f, 8.00907984e-02f, 4.90604192e-02f, 2.92069241e-02f, -1.75443634e-01f, 3.16576846e-02f, 2.37767268e-02f, -1.87730610e-01f,
  -4.61453289e-01f, 1.16646342e-01f, 1.13831386e-01f, 1.89214692e-01f, 1.53846905e-01f, -9.47020724e-02f, 8.60782247e-03f, 1.60838664e-01f, 4.77841049e-02f, -6.82265535e-02f,
  2.44863316e-01f, -9.24300700e-02f, 2.50684153e-02f, 4.53159725e-03f, 2.40079075e-01f, -1.62393570e-01f, -1.12313323e-01f, -1.32870693e-02f, -1.50047928e-01f, -1.28983438e-01f,
  -2.06418168e-02f, 4.41674143e-02f, -3.92950512e-03f, -1.56787470e-01f, -1.65300801e-01f, 4.40816619e-02f, 1.20978147e-01f, -9.76520777e-02f, 2.15557758e-02f, 3.78985345e-01f,
  1.88884482e-01f, 3.38649064e-01f, -2.86024123e-01f, -2.16082901e-01f, -4.84170884e-01f, 2.13676736e-01f, -3.85846756e-02f, 1.00301439e-03f, -7.91883618e-02f, 4.57356796e-02f,
  7.72467107e-02f, -2.46742368e-02f, -1.05988666e-01f, -1.93509355e-01f, 1.35327265e-01f, 1.99145405e-03f, 3.06616753e-01f, 5.99087700e-02f, 7.88204521e-02f, 1.01423822e-01f,
  -6.64882362e-02f, 3.37462664e-01f, -4.80706152e-03f, 1.28496155e-01f, 6.98567405e-02f, 6.37610583e-03f, 3.15573931e-01f, 1.09335132e-01f, -1.33989960e-01f, 3.78874779e-01f,
  1.57085523e-01f, -2.05480874e-01f, 1.18113637e-01f, -6.77543059e-02f, -2.53586043e-02f, -2.49908134e-01f, 1.55348659e-01f, 1.60489514e-01f, 7.10751638e-02f, 1.55066013e-01f,
  6.82842582e-02f, -3.27625275e-02f, 1.18867785e-01f, -7.26661906e-02f, 7.38180131e-02f, 1.45574659e-03f, 1.08507954e-01f, 5.76563664e-02f, -6.83833882e-02f, -2.51280427e-01f,
  -6.03795126e-02f, -1.04198553e-01f, 2.92750865e-01f, 2.18517974e-01f, -1.22134298e-01f, 9.42975655e-02f, -1.88381985e-01f, 1.27518445e-01f, 1.06018417e-01f, 1.86096489e-01f,
  1.05104111e-02f, 2.42083818e-01f, -2.13294867e-02f, -7.81054348e-02f, 1.55612566e-02f, 1.71210170e-01f, 1.25761181e-01f, 3.15209657e-01f, -2.69684374e-01f, 6.87502697e-02f,
  2.03104481e-01f, 1.03499807e-01f, -5.19814342e-02f, 2.76592281e-02f, 2.67910242e-01f, 5.17965034e-02f, 6.72415495e-02f, -9.89777502e-03f, 2.36162543e-01f, 1.19527966e-01f,
  -1.84227586e-01f, -1.29363343e-01f, 2.96203624e-02f, -1.17105894e-01f, -1.44506395e-01f, 8.70341212e-02f, -1.78951204e-01f, 8.53845701e-02f, 1.31028548e-01f, 2.02987954e-01f,
  -1.85870416e-02f, 2.83075720e-01f, 2.03385621e-01f, 7.55627379e-02f, -3.04801643e-01f, -1.51025996e-01f, 9.83940884e-02f, -2.15580881e-01f, 1.92537963e-01f, 3.07920612e-02f,
  1.20055832e-01f, 1.14818715e-01f, 4.32469808e-02f, 7.20709860e-02f, 6.76520839e-02f, 1.71351939e-01f, 3.12302727e-02f, -7.65676275e-02f, 3.20535600e-02f, -9.70605537e-02f,
  -1.89955130e-01f, 8.82523283e-02f, 1.40083462e-01f, 9.12008062e-03f, 2.73141563e-01f, 1.66620299e-01f, 1.24829210e-01f, 5.50162271e-02f, 1.73810497e-01f, 6.16354756e-02f,
  1.09866694e-01f, 2.45993450e-01f, -2.84990817e-01f, -1.32404357e-01f, 1.58412084e-02f, -2.94276834e-01f, 5.07102348e-02f, -9.90714282e-02f, -9.22241285e-02f, -6.20914157e-03f,
  1.39362410e-01f, 3.41240801e-02f, 1.02715597e-01f, -1.23350114e-01f, -5.85759804e-02f, 3.16536576e-02f, -7.87469000e-02f, -1.24226272e-01f, -8.05465505e-02f, 2.03649431e-01f,
  4.23712144e-03f, 1.25937000e-01f, -3.78645957e-01f, 2.09271625e-01f, 4.46344651e-02f, -7.34876022e-02f, -6.45012856e-02f, -9.28995162e-02f, -9.54407454e-02f, 1.58685565e-01f,
  7.06954375e-02f, -7.56927803e-02f, -3.53013873e-02f, 1.90370772e-02f, -7.59931728e-02f, -2.66125381e-01f, -1.18839808e-01f, -9.32839215e-02f, 6.54971972e-02f, 1.17105924e-01f,
  -1.34169638e-01f, -5.55654950e-02f, 1.25888050e-01f, -1.76258728e-01f, 1.99335366e-01f, 8.96266177e-02f, -1.07537523e-01f, -1.27522916e-01f, 1.52734751e-02f, -1.03617072e-01f,
  1.04646824e-01f, -1.86150953e-01f, -2.45628878e-01f, 6.58662170e-02f, 8.83124322e-02f, 1.41602322e-01f, -1.21461503e-01f, -1.56355977e-01f, 9.52223986e-02f, 6.69651628e-02f,
  1.75954908e-01f, 3.50904852e-01f, -2.00078432e-02f, -6.62357137e-02f, 5.05870730e-02f, 2.01719418e-01f, 3.55112217e-02f, 8.28045160e-02f, 3.11161187e-02f, 6.12098351e-03f,
  5.61072715e-02f, -2.53529817e-01f, -1.42491087e-01f, -2.06269935e-01f, -5.45963198e-02f, 3.59438509e-01f, -1.23906918e-01f, 8.87608901e-02f, 2.12158024e-01f, 1.45841554e-01f,
  1.79201916e-01f, -1.13418460e-01f, 1.97955489e-01f, 1.89344287e-01f, 2.01416850e-01f, 1.42654598e-01f, -2.07492374e-02f, -2.45743860e-02f, -1.64906248e-01f, -3.15388769e-01f,
  -1.38018951e-01f, -1.03705097e-02f, 8.02195743e-02f, -3.13813150e-01f, -8.19500536e-02f, -3.80895324e-02f, -3.89062171e-03f, 1.91964611e-01f, -3.45293321e-02f, 1.42926502e-03f,
  1.66082844e-01f, -8.25515762e-02f, -2.52847493e-01f, -2.14080274e-01f, -8.13080296e-02f, -2.85941511e-01f, 1.95716307e-01f, 1.77106097e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.71733826e-01f, 2.11561769e-01f, -7.76406601e-02f, 1.15809612e-01f, 1.62683800e-01f, -1.68141313e-02f, -2.49900855e-02f, -7.56001249e-02f, 1.68900296e-01f, 2.29821190e-01f,
  2.08790943e-01f, 9.30232778e-02f, 2.11851731e-01f, -5.71064800e-02f, 5.71781471e-02f, -1.52403384e-01f, 1.80204168e-01f, -6.21092366e-03f, 1.54802278e-01f, -4.45091166e-02f,
  6.59334809e-02f, -7.52060534e-03f, -1.37682647e-01f, -2.03225743e-02f, -1.06919520e-01f, 3.38078924e-02f, -1.01371795e-01f, 6.27134070e-02f, 2.94965021e-02f, 5.86724319e-02f,
  -4.68286201e-02f, 1.87980160e-01f, 1.70679465e-01f, 5.07987849e-02f, 1.56377733e-01f, 1.25693664e-01f, 1.26960287e-02f, 2.69562662e-01f, 2.46854275e-02f, 1.14269905e-01f,
  -1.15172513e-01f, 1.76577866e-01f, -4.91641611e-02f, 2.33162493e-01f, 2.13398695e-01f, 1.11204915e-01f, 1.83886047e-02f, -2.52775729e-01f, 2.74189323e-01f, -3.10662445e-02f,
  1.27463667e-02f, -1.20296329e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.06798013e-02f, -2.29175195e-01f, -3.10094178e-01f, -2.71367490e-01f, -1.11004123e-02f, 6.78338483e-02f, 2.11417228e-02f, 6.26733340e-03f, -4.69742194e-02f, 5.40848356e-03f,
  -1.45610988e-01f, 1.30388483e-01f, -3.94643508e-02f, 1.95539042e-01f, -6.54879212e-02f, 6.47243336e-02f, -3.51835005e-02f, 1.48186609e-01f, -1.22997224e-01f, -7.69926980e-02f,
  -2.36583501e-02f, -6.69183806e-02f, 5.62301092e-03f, 1.69200823e-02f, -1.64958566e-01f, -1.12073861e-01f, 5.04912399e-02f, 3.19770426e-01f, -1.97207257e-01f, 1.60215154e-01f,
  -3.27437930e-02f, 5.75788580e-02f, 2.66462892e-01f, 7.39097595e-02f, 1.92634091e-01f, 7.89054930e-02f, 2.74098456e-01f, 7.84408823e-02f, 6.85159117e-02f, 3.22736986e-02f,
  -1.82342112e-01f, 1.04160398e-01f, 1.19724413e-02f, 6.55126423e-02f, -2.04395980e-01f, 5.09474762e-02f, -5.13147824e-02f, 5.42836972e-02f, 1.24694891e-01f, -4.85969037e-02f,
  3.58084500e-01f, -1.39907971e-01f, -5.08188456e-02f, -1.44892216e-01f, 2.78549790e-01f, -3.17121260e-02f, 1.52867988e-01f, 8.23286548e-02f, 1.34823501e-01f, 8.35748240e-02f,
  -1.76682785e-01f, -5.72417900e-02f, 8.77367631e-02f, 2.98368204e-02f, -1.52270883e-01f, 1.86347172e-01f, -4.14006338e-02f, -1.34733409e-01f, -1.90724283e-02f, 7.82869011e-02f,
  2.35400587e-01f, -2.06004903e-02f, -4.97162826e-02f, 2.17704345e-02f, -2.94282585e-01f, -1.08274743e-01f, -4.80332114e-02f, -1.90257877e-01f, -2.42360812e-02f, -4.48735431e-03f,
  -1.02003530e-01f, -1.87078536e-01f, 1.78713024e-01f, 1.01745218e-01f, 2.98290532e-02f, 2.16087639e-01f, -1.31692186e-01f, 1.77108124e-01f, 1.80039704e-01f, 9.84022170e-02f,
  -9.43874195e-02f, 3.85531373e-02f, -5.03028035e-02f, -1.80877432e-01f, 9.42855552e-02f, 2.20877212e-03f, 9.29101743e-03f, -1.14034444e-01f, 1.02333665e-01f, -1.12693749e-01f,
  2.04320148e-01f, 2.88306534e-01f, 2.45466292e-01f, -1.72347888e-01f, 2.08502691e-02f, -1.31016821e-01f, 2.63009258e-02f, 2.66522169e-01f, 2.17495874e-01f, -5.40666692e-02f,
  1.46149993e-01f, -2.03747794e-01f, -8.35443661e-02f, -3.42539363e-02f, 8.78501981e-02f, -1.66819781e-01f, 3.12970340e-01f, -1.69945896e-01f, -2.08188355e-01f, -3.15165659e-03f,
  -4.30166423e-02f, -2.33334377e-02f, -1.77947730e-01f, 2.24983290e-01f, 9.03916508e-02f, 2.61256933e-01f, -1.75739616e-01f, 2.52788424e-01f, -4.12231050e-02f, -1.64022844e-03f,
  -1.33450434e-01f, -1.15245111e-01f, -3.56519222e-02f, -1.05128579e-01f, -4.90212403e-02f, -3.75842035e-01f, 1.18465479e-02f, 3.74848954e-03f, 1.91123411e-01f, -1.99915543e-01f,
  1.51684850e-01f, -2.16442004e-01f, -6.00934885e-02f, -3.68501656e-02f, 1.95701774e-02f, 1.25024959e-01f, 1.35860324e-01f, -4.92965877e-02f, -1.95296481e-01f, 4.85961214e-02f,
  -2.34710783e-01f, -5.62890433e-02f, -1.01554699e-01f, 6.96383882e-03f, -1.88961602e-03f, 5.49576096e-02f, -2.43615985e-01f, 3.99648137e-02f, 8.20347294e-02f, 5.91303827e-03f,
  1.16931587e-01f, 1.59790263e-01f, 1.76321771e-02f, 2.76685894e-01f, 7.01757893e-02f, 1.03344895e-01f, -4.02913503e-02f, -1.33005172e-01f, -1.28392443e-01f, 1.57765392e-02f,
  -8.22327882e-02f, -1.33694574e-01f, -7.05560520e-02f, 2.15215012e-02f, -6.07604794e-02f, -6.37614587e-03f, -3.55338491e-03f, -1.13499783e-01f, -4.18654531e-02f, -1.67169064e-01f,
  3.84723954e-02f, 9.89477783e-02f, -4.59887981e-02f, -3.48823756e-01f, 1.59397304e-01f, 2.32689321e-01f, 2.23882973e-01f, -7.87779987e-02f, 1.18038774e-01f, 3.91645078e-03f,
  -4.17860486e-02f, -2.04542026e-01f, 7.65139014e-02f, -2.14144140e-01f, -4.19555828e-02f, 6.46013319e-02f, 1.69124112e-01f, 1.85689613e-01f, -1.27144948e-01f, 3.11349213e-01f,
  1.33490525e-02f, -3.62870097e-02f, -2.45612189e-01f, -2.08341494e-01f, -7.68702552e-02f, 1.18714787e-01f, 3.98097150e-02f, -5.94471507e-02f, 3.08430552e-01f, 6.69325143e-02f,
  -1.21436410e-01f, -5.41741699e-02f, 1.11531757e-01f, -1.31402969e-01f, -1.51531130e-01f, 3.04861367e-02f, 2.69178767e-02f, -1.98184788e-01f, -1.83307528e-01f, 1.66948482e-01f,
  1.67516842e-01f, 4.98282276e-02f, 4.57280464e-02f, 1.04762509e-01f, 4.31305915e-03f, 8.84901509e-02f, 1.19424947e-01f, -1.86747476e-01f, -9.74036679e-02f, -1.78900346e-01f,
  -6.59965398e-03f, 2.79328346e-01f, -1.99738100e-01f, -1.70153737e-01f, -4.24203649e-02f, 8.72762054e-02f, -1.68624252e-01f, -9.05949716e-03f, 1.66508064e-01f, -1.08696766e-01f,
  9.30562317e-02f, -5.94816804e-02f, 1.09589793e-01f, 1.81845143e-01f, -9.14974585e-02f, -8.53834748e-02f, 4.91993390e-02f, -1.73957031e-02f, -2.10273221e-01f, -2.16598094e-01f,
  -8.55811089e-02f, -5.56451604e-02f, -1.14127636e-01f, 1.06659815e-01f, -3.65009457e-02f, -4.53379117e-02f, -4.94874381e-02f, 1.41596040e-02f, 4.20860685e-02f, -1.73205853e-01f,
  -3.33622061e-02f, -1.22856140e-01f, -2.91471690e-01f, -5.95997833e-02f, -1.38161123e-01f, -1.44439027e-01f, 2.72880882e-01f, 1.55266151e-01f, 3.82752344e-02f, -2.97303703e-02f,
  7.91181922e-02f, -7.72000551e-02f, 2.10268229e-01f, -4.73579764e-02f, -3.63798887e-02f, -8.24146569e-02f, 1.28831521e-01f, -2.33027264e-02f, -2.07888454e-01f, 1.17235899e-01f,
  8.39479938e-02f, 1.06721230e-01f, -8.27014744e-02f, -2.46374514e-02f, -1.20971419e-01f, 1.46534473e-01f, -1.68446004e-02f, -9.19440389e-02f, -1.87920883e-01f, 1.12590091e-02f,
  -2.52969116e-02f, -7.47681856e-02f, -7.03971982e-02f, -5.02083078e-02f, 7.98509270e-02f, -2.60226905e-01f, 4.97504212e-02f, -1.25129297e-01f, 1.68258443e-01f, -1.41007811e-01f,
  2.05603078e-01f, 1.50563747e-01f, 1.86340079e-01f, -1.01012349e-01f, -8.05852115e-02f, 1.48773655e-01f, -1.74668208e-01f, -1.24544024e-01f, -6.49566501e-02f, 1.46730408e-01f,
  -7.33254338e-03f, 3.22528966e-02f, -8.13485608e-02f, -1.26759216e-01f, 3.44265229e-03f, 1.29479110e-01f, 1.21979844e-02f, -1.30322099e-01f, 1.39487743e-01f, -8.22770372e-02f,
  -1.69670507e-01f, -1.75178260e-01f, -2.53222495e-01f, -1.15836740e-01f, 4.65316931e-03f, -2.64738977e-01f, -3.77290815e-01f, -1.78936109e-01f, 3.83248553e-02f, 3.53554189e-02f,
  -7.17123151e-02f, 6.98263943e-03f, 6.07836358e-02f, 2.46877864e-01f, 1.74587909e-02f, -1.00665882e-01f, 1.80196702e-01f, 2.93139461e-02f, -6.65475875e-02f, 7.58382380e-02f,
  -1.26554206e-01f, 7.79259354e-02f, 2.99837813e-02f, -1.51317060e-01f, 1.59034386e-01f, -1.85680330e-01f, 6.78590536e-02f, -4.04949971e-02f, 1.71261150e-02f, 1.36037111e-01f,
  1.05270505e-01f, 2.32971609e-01f, 1.56606063e-01f, -5.86095601e-02f, -2.21093707e-02f, 3.09126452e-02f, -5.34541979e-02f, 3.76031175e-02f, -1.33365065e-01f, 8.43374059e-02f,
  -2.25119680e-01f, -1.97442383e-01f, 3.51327620e-02f, 2.19458207e-01f, -1.06067210e-01f, -1.11387700e-01f, 2.05221325e-02f, -1.93285838e-01f, -1.77831084e-01f, -4.79958281e-02f,
  -8.17036629e-03f, 7.78642148e-02f, 9.57867503e-02f, 1.36147261e-01f, -2.93916315e-02f, 2.42637135e-02f, -2.08497018e-01f, 1.10337427e-02f, 1.22667305e-01f, 4.73873839e-02f,
  7.95187950e-02f, 5.73337488e-02f, 6.57435879e-02f, 5.37505485e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.82016378e-02f, 1.65676460e-01f, -6.48390800e-02f, -1.65176429e-02f, 5.85517734e-02f, 2.21927185e-02f, 1.31341383e-01f, -1.93237454e-01f, -1.33388653e-01f, -8.64899233e-02f,
  1.93536982e-01f, 1.43232450e-01f, -1.23098455e-01f, 6.25123233e-02f, -1.84484810e-01f, -1.27904966e-01f, -3.97207439e-02f, -5.02968132e-02f, 2.50521712e-02f, -2.78715372e-01f,
  -2.44180769e-01f, 1.48613468e-01f, 9.00003389e-02f, -1.91493496e-01f, -9.06251371e-02f, 8.36914405e-02f, -1.33312186e-02f, -3.41939144e-02f, 7.96214119e-02f, -3.93235981e-02f,
  4.75017056e-02f, -2.97902208e-02f, -5.55367582e-02f, 1.04213983e-01f, -3.16906303e-01f, 2.05224217e-03f, -1.13368854e-01f, 1.80749416e-01f, -1.43055290e-01f, -1.60791986e-02f,
  1.63366511e-01f, 1.17135808e-01f, 1.11870952e-01f, 2.31749892e-01f, 1.71173573e-01f, -1.02245010e-01f, 2.31403112e-02f, 1.90203279e-01f, 2.18861118e-01f, 1.74443513e-01f,
  2.42798380e-03f, -3.05190712e-01f, -2.61620134e-01f, -6.62938356e-02f, 7.68776312e-02f, -1.17735311e-01f, -4.90481369e-02f, -2.92966627e-02f, 7.50995725e-02f, -1.30609930e-01f,
  1.48358494e-01f, -8.18207115e-02f, -6.90201148e-02f, -2.69074410e-01f, -2.62328833e-01f, 3.39226216e-01f, -1.45166600e-02f, -1.70153633e-01f, 9.69526637e-03f, -2.45085388e-01f,
  8.43071938e-02f, -2.04424739e-01f, 7.66116157e-02f, -1.85368076e-01f, 1.37038723e-01f, 2.11250689e-02f, -2.29631774e-02f, 5.90347312e-02f, -3.74926925e-01f, -6.86092153e-02f,
  1.29519269e-01f, -4.33589518e-01f, -5.26836375e-03f, 1.87281985e-02f, 2.45527267e-01f, 7.62055442e-02f, -2.06680328e-01f, 9.11109298e-02f, 7.12625235e-02f, 2.01638505e-01f,
  -5.22364974e-01f, -3.55156034e-01f, -4.61471051e-01f, -1.79907292e-01f, 1.98302455e-02f, 7.79604912e-02f, -9.14826170e-02f, -4.42268461e-01f, 8.54252800e-02f, 4.67607193e-02f,
  6.91755190e-02f, 2.03517959e-01f, 1.14779375e-01f, -2.63348132e-01f, 3.16285305e-02f, -2.85624057e-01f, 1.35194257e-01f, 1.51556432e-01f, 3.10737103e-01f, -2.74719801e-02f,
  9.28018466e-02f, -3.33659239e-02f, 8.28813314e-02f, 3.56877618e-03f, 4.29029837e-02f, -2.39135966e-01f, 3.83942835e-02f, -3.51856887e-01f, -1.57764688e-01f, 5.82053140e-02f,
  3.19896072e-01f, -7.71787986e-02f, -9.36852768e-02f, 1.00741014e-02f, 1.50221169e-01f, 1.17487542e-01f, -5.64194441e-01f, -7.34709501e-02f, -1.02759518e-01f, 2.49251515e-01f,
  1.19867779e-01f, 1.05512924e-01f, 2.65109390e-01f, 1.37430459e-01f, 5.56034029e-01f, 1.84592381e-02f, 5.81288934e-02f, -6.06377702e-03f, -5.80277145e-02f, 1.10641710e-01f,
  -8.94157812e-02f, 5.53950947e-03f, -1.46865174e-01f, 1.11391917e-01f, -1.07957246e-02f, -3.92792672e-02f, 3.21976334e-01f, -2.72183597e-01f, -2.41312031e-02f, 9.40317959e-02f,
  -8.71770009e-02f, 1.46941707e-01f, -4.13129777e-01f, 2.42690355e-01f, 2.74269208e-02f, -4.79934141e-02f, -3.43085118e-02f, -2.86916494e-01f, 5.40695228e-02f, -1.33392945e-01f,
  7.13643432e-02f, 5.51687591e-02f, -4.37079310e-01f, 6.41724328e-03f, -1.41984254e-01f, 6.72885329e-02f, 2.29250304e-02f, -7.95732066e-03f, 1.80888385e-01f, 1.01323724e-01f,
  -7.77558684e-02f, -2.40325421e-01f, 1.15718804e-01f, -1.02754124e-01f, -2.33758077e-01f, 1.51594982e-01f, 1.82225958e-01f, 1.20769754e-01f, -6.87630028e-02f, -1.29795477e-01f,
  -3.21165740e-01f, -5.48757147e-03f, 1.93432361e-01f, 1.98331684e-01f, 3.36799651e-01f, 2.22376734e-01f, 5.79561591e-02f, -2.68008471e-01f, 2.09362488e-02f, -3.90984535e-01f,
  9.71348062e-02f, -1.55657515e-01f, 2.18206525e-01f, 9.71080363e-02f, -1.73112407e-01f, -1.35054067e-01f, 2.82669932e-01f, -1.28979355e-01f, -1.12323105e-01f, 3.06765616e-01f,
  4.26284641e-01f, 2.63302952e-01f, -2.38081619e-01f, -8.27601030e-02f, -2.87330598e-01f, 5.03410816e-01f, 4.78223711e-02f, -1.84211731e-02f, -9.48832110e-02f, -6.42155930e-02f,
  -1.89684555e-01f, -4.93471622e-02f, 9.06968340e-02f, 1.83645770e-01f, 5.36761768e-02f, -7.48256892e-02f, 1.59460798e-01f, -1.57015190e-01f, 8.53888914e-02f, -3.82010490e-01f,
  2.55403876e-01f, -2.08660923e-02f, -1.48466855e-01f, 5.76557368e-02f, 1.86803907e-01f, -2.23819509e-01f, -7.93366060e-02f, -1.76441282e-01f, -7.79706761e-02f, -7.81338010e-03f,
  -2.48849168e-01f, 2.07735315e-01f, -4.17556725e-02f, 3.37402970e-02f, -3.06271344e-01f, 1.01630561e-01f, -2.19990745e-01f, 7.09501952e-02f, -1.81163311e-01f, -1.20928310e-01f,
  -4.91879471e-02f, -1.44914255e-01f, 2.64567584e-01f, 1.68957010e-01f, -5.09750135e-02f, -2.28807911e-01f, 3.72226164e-02f, 6.24135397e-02f, -3.40852499e-01f, 2.38063544e-01f,
  4.20135744e-02f, -5.87833822e-02f, -8.99393111e-04f, 1.03252329e-01f, -3.10206652e-01f, -3.25371623e-02f, 9.42087993e-02f, 2.06651747e-01f, 8.34716950e-03f, 3.25074106e-01f,
  1.35441780e-01f, -2.53542036e-01f, -1.14959031e-01f, 1.27908634e-02f, 1.13931939e-01f, 2.25726753e-01f, -3.62937003e-01f, -7.23362789e-02f, -3.33941504e-02f, -1.67362660e-01f,
  3.09201688e-01f, 1.42910304e-02f, -1.90831691e-01f, -1.98165536e-01f, 9.90312621e-02f, 9.42103565e-02f, -3.78462151e-02f, 1.07609123e-01f, 2.14860663e-01f, 9.62382928e-02f,
  1.39318824e-01f, 1.98405638e-01f, 8.28428492e-02f, 1.01295009e-01f, 2.73546576e-01f, 1.22197554e-01f, 1.21782221e-01f, -5.22460267e-02f, -2.04307482e-01f, 5.03924824e-02f,
  -1.99434832e-02f, -2.29080305e-01f, -2.86496609e-01f, -1.44513324e-01f, 2.23268811e-02f, -1.95266213e-02f, -1.14659719e-01f, -6.19529635e-02f, -1.15570873e-01f, 1.84786767e-01f,
  -1.46522328e-01f, 1.26201525e-01f, -8.48891065e-02f, 1.49415610e-02f, -6.51374683e-02f, -2.18838960e-01f, -3.20776969e-01f, -9.08958465e-02f, -3.84587757e-02f, 1.85507521e-01f,
  -2.17669234e-01f, 2.12715164e-01f, -3.40552479e-01f, 7.37525597e-02f, 6.75098822e-02f, -7.58543164e-02f, -2.22125441e-01f, 1.02068176e-02f, 2.42957752e-02f, 1.84739724e-01f,
  -6.09863177e-02f, 2.28300914e-01f, 8.72214735e-02f, 1.23091049e-01f, 2.20342487e-01f, 6.61708489e-02f, -1.43752592e-02f, 2.46706650e-01f, 2.06048429e-01f, -3.42135280e-02f,
  -2.69662403e-02f, -3.41320932e-01f, 3.46908532e-02f, 3.24318111e-01f, 2.10087523e-02f, -8.91854689e-02f, -4.30222601e-01f, -5.37603721e-03f, 1.22471191e-01f, 9.01213363e-02f,
  2.21058056e-01f, 1.93651453e-01f, 9.63442549e-02f, 3.40394005e-02f, 6.75816983e-02f, -9.42923203e-02f, 2.38170058e-01f, 2.29248069e-02f, 7.82504603e-02f, -1.05018644e-02f,
  -8.82637277e-02f, -2.44626075e-01f, -1.89169958e-01f, -3.07250191e-02f, -7.01038912e-02f, -1.73549280e-02f, -2.18205169e-01f, -1.13542192e-01f, -6.42584637e-02f, 1.43853858e-01f,
  -1.07011542e-01f, 1.38382092e-01f, -1.56733260e-01f, -2.21535191e-01f, -2.77147770e-01f, -1.61966253e-02f, -9.26094409e-03f, -3.49261388e-02f, -2.34252036e-01f, 2.79343843e-01f,
  -1.22560421e-02f, 1.66171804e-01f, -1.02680683e-01f, -4.67118360e-02f, 7.57307857e-02f, 1.07377000e-01f, 1.20312110e-01f, 1.72950953e-01f, 1.26865610e-01f, -2.84247965e-01f,
  -1.49370525e-02f, 1.85477912e-01f, 6.84849918e-02f, -5.87355681e-02f, 3.59520793e-01f, 9.86021236e-02f, 3.73643218e-03f, 1.06162369e-01f, -6.32484537e-03f, 1.72956407e-01f,
  -1.53333485e-01f, -1.51515841e-01f, -9.26860347e-02f, 6.82941079e-02f, -9.31918621e-03f, 8.57089385e-02f, 2.81689882e-01f, -3.00586641e-01f, 1.51972517e-01f, 6.70894161e-02f,
  2.12105185e-01f, 9.46455970e-02f, -8.15740302e-02f, -2.43253812e-01f, 5.86082935e-02f, 4.15833704e-02f, 1.89611688e-02f, -3.22686166e-01f, 6.93328008e-02f, -4.43202406e-02f,
  -5.40320724e-02f, 5.49289137e-02f, -1.29792675e-01f, 1.94330946e-01f, -5.64757101e-02f, 1.39700398e-01f, 4.26795660e-03f, 3.00613135e-01f, -6.07666560e-02f, 2.30380803e-01f,
  -1.21086806e-01f, -3.16111237e-01f, -3.79833370e-01f, -1.98197346e-02f, -7.70224184e-02f, 4.62724268e-02f, 7.35319853e-02f, 6.24764934e-02f, -3.15224767e-01f, 1.11558139e-01f,
  7.63440132e-02f, 1.37653306e-01f, 6.08021095e-02f, 1.12213515e-01f, -1.75970972e-01f, -6.63501099e-02f, -2.71190733e-01f, 2.47708783e-01f, 1.10428140e-01f, -1.81065854e-02f,
  -2.99609974e-02f, 5.49820326e-02f, 1.77843392e-01f, -2.26663783e-01f, -3.40023935e-02f, -4.96152323e-03f, 6.66772351e-02f, -2.09872156e-01f, 1.58170462e-01f, 2.65156776e-01f,
  1.67465329e-01f, 1.98390007e-01f, 2.15882093e-01f, 2.51901716e-01f, -1.05996951e-01f, 1.80974096e-01f, -1.75410673e-01f, -2.52478093e-01f, 3.26291680e-01f, -1.15093499e-01f,
  -2.46152300e-02f, -1.42702445e-01f, -8.28259140e-02f, 7.30355969e-03f, -1.53532431e-01f, -7.13169500e-02f, -1.23013750e-01f, -1.59076363e-01f, 2.17094436e-01f, -4.23105955e-02f,
  -6.62594363e-02f, -8.59207064e-02f, 2.06950903e-01f, 1.58005863e-01f, -7.37032965e-02f, -2.24828064e-01f, 7.46345967e-02f, -7.87891727e-03f, 6.11696988e-02f, 1.25557510e-02f,
  -1.89105749e-01f, 8.36313218e-02f, -1.01885326e-01f, -9.96857211e-02f, -1.25802979e-01f, 3.66674103e-02f, -6.70283735e-02f, -1.95938218e-02f, -2.18525482e-03f, -7.21254572e-02f,
  1.42397150e-01f, -7.02584088e-02f, 1.09817095e-01f, 1.23452857e-01f, 2.32688367e-01f, -7.85541162e-02f, -2.66813580e-02f, 2.38504231e-01f, -8.61060843e-02f, 3.01693171e-01f,
  3.41202551e-03f, 2.04812080e-01f, -1.49999470e-01f, 1.10993691e-01f, 1.72602937e-01f, -2.02232108e-01f, -1.04777321e-01f, -4.03236970e-03f, 1.83025539e-01f, 6.24315850e-02f,
  -1.34628490e-01f, -2.48519257e-01f, -3.37021381e-01f, 2.53296524e-01f, 1.16299763e-01f, -3.65886427e-02f, -1.14507517e-02f, -2.15105310e-01f, 5.10374531e-02f, -2.18644321e-01f,
  4.69012409e-02f, -2.83569600e-02f, 7.77119547e-02f, -3.27080607e-01f, 7.93753415e-02f, -1.76458195e-01f, -8.62748325e-02f, 2.90247679e-01f, -4.24236923e-01f, -1.07718587e-01f,
  1.26331896e-01f, 5.40290736e-02f, 1.73016459e-01f, 1.79801792e-01f, -9.67748985e-02f, 3.05747688e-01f, -5.28412545e-03f, 2.44250372e-01f, -9.23898220e-02f, -2.44217113e-01f,
  -2.82398254e-01f, -1.68560967e-02f, 3.47360820e-02f, -1.64461181e-01f, -3.66763696e-02f, -8.38359371e-02f, 1.84749032e-03f, 1.60374239e-01f, 1.32513940e-01f, 1.48781985e-01f,
  2.21217111e-01f, 8.66255760e-02f, 1.19028024e-01f, -5.89136500e-03f, -5.32248616e-02f, -1.69836938e-01f, 9.21772197e-02f, -6.73836796e-03f, 1.00060582e-01f, -5.16258553e-03f,
  -1.47443891e-01f, 8.28353688e-02f, -1.08833658e-02f, 2.90544890e-02f, 1.68682963e-01f, -1.45103693e-01f, -4.41567600e-02f, 6.44810274e-02f, 4.31186825e-01f, 3.81961137e-01f,
  -4.92062345e-02f, 2.08735690e-01f, 8.29329044e-02f, 4.53889854e-02f, -8.68445858e-02f, 1.32490858e-01f, 3.69491220e-01f, 3.44111562e-01f, 3.79113078e-01f, 4.03150320e-02f,
  1.45638898e-01f, 9.97235775e-02f, -1.89287946e-01f, -8.98645520e-02f, -3.38743746e-01f, -1.82839274e-01f, 2.39995241e-01f, -2.01066285e-02f, 1.89905480e-01f, -4.06378478e-01f,
  -1.68653056e-01f, -8.81676823e-02f, 2.75199831e-01f, 8.08537845e-03f, 4.38712537e-02f, -1.95641890e-01f, 5.43611646e-02f, 5.41909151e-02f, 2.58419454e-01f, -3.77035022e-01f,
  1.31178588e-01f, -6.86461553e-02f, 1.11680366e-01f, -1.67672306e-01f, -6.22314662e-02f, -1.55899957e-01f, -8.62489119e-02f, -1.64282337e-01f, -1.40462130e-01f, 7.23948255e-02f,
  -2.97286391e-01f, -9.24777016e-02f, -3.40106428e-01f, 1.16348684e-01f, -2.46591140e-02f, -9.80476886e-02f, 1.06957853e-01f, 2.31797677e-02f, 2.68477410e-01f, 1.01076871e-01f,
  3.37139741e-02f, 3.02609876e-02f, 1.05395280e-01f, -8.20722058e-02f, -1.33944424e-02f, 3.00629616e-01f, -1.29661232e-01f, 5.57689704e-02f, -2.36286506e-01f, 2.36025959e-01f,
  5.87573610e-02f, 2.14619655e-02f, -9.02971700e-02f, -1.49362072e-01f, -1.12545781e-01f, -1.64421275e-01f, 3.58952612e-01f, -1.74292196e-02f, -6.63620234e-02f, -4.05158132e-01f,
  1.00544944e-01f, 1.36104096e-02f, -1.26698896e-01f, -5.22637144e-02f, -4.93341200e-02f, 2.33962908e-01f, 1.72733128e-01f, -1.40533462e-01f, 2.61239391e-02f, -3.05293202e-01f,
  -2.61743963e-02f, 5.25577664e-02f, 1.00050196e-01f, -4.59441543e-02f, -3.22429359e-01f, -3.54606569e-01f, 3.75537783e-01f, 6.98335096e-02f, 1.10812053e-01f, -1.09399550e-01f,
  -6.61444515e-02f, -1.25101162e-02f, -1.60548896e-01f, -1.16504006e-01f, -1.18146032e-01f, -9.14238691e-02f, -1.43871367e-01f, 1.38560116e-01f, -2.85061300e-01f, -1.87917411e-01f,
  1.48696631e-01f, 6.85018674e-02f, 1.46979392e-01f, 1.29561633e-01f, -3.51896659e-02f, 5.66578619e-02f, 1.27177417e-01f, 1.49209887e-01f, -1.71882078e-01f, -1.29189771e-02f,
  1.81391984e-01f, 1.35571079e-03f, 2.79163569e-01f, 1.85967758e-01f, 1.48999602e-01f, -4.61925045e-02f, 1.99081466e-01f, 3.79962511e-02f, 3.46886106e-02f, -5.09847105e-02f,
  1.58059597e-02f, -5.19884109e-01f, 8.97230208e-02f, -1.42834932e-01f, -2.42381781e-01f, -1.37742549e-01f, -6.22614250e-02f, -2.49464691e-01f, -7.70873204e-02f, -1.28448056e-02f,
  2.19590619e-01f, 1.72363237e-01f, -1.76316261e-01f, 2.96076518e-02f, 7.99881667e-02f, 3.95909250e-01f, 2.97339946e-01f, 2.28304029e-01f, 2.69527406e-01f, 1.25422224e-01f,
  -8.14253390e-02f, 1.89974949e-01f, 1.76534861e-01f, 8.36346373e-02f, -1.89010203e-01f, 1.83307100e-02f, 6.74290508e-02f, -2.14920551e-01f, 2.77528048e-01f, 1.90314233e-01f,
  -1.34536847e-01f, -1.17167227e-01f, 2.84494553e-02f, 1.35263711e-01f, 8.71466324e-02f, 1.11734040e-01f, 2.12231189e-01f, 4.66354340e-02f, 2.88901746e-01f, 9.68030244e-02f,
  5.00253998e-02f, -7.25165829e-02f, 1.20722480e-01f, 1.59756541e-01f, -1.64976403e-01f, 1.09266818e-01f, -1.63446084e-01f, -1.29617155e-01f, -9.49020162e-02f, -1.04734443e-01f,
  -4.26708311e-02f, -2.29207382e-01f, -2.40484364e-02f, 1.68633536e-01f, 5.31419069e-02f, -7.55478144e-02f, -2.35315129e-01f, 1.36221096e-01f, -3.14534530e-02f, 2.84486681e-01f,
  2.44503114e-02f, 1.39967427e-01f, -1.72349080e-01f, -4.50162822e-03f, -2.71713972e-01f, 2.23573580e-01f, -1.32285729e-01f, 1.68962538e-01f, 1.65873370e-03f, 4.11054969e-01f,
  1.27764061e-01f, 3.38406354e-01f, -1.34815410e-01f, -2.38433540e-01f, -1.76050216e-01f, 1.12782493e-01f, 2.77890433e-02f, 1.10787615e-01f, 2.72879481e-01f, -2.26337966e-02f,
  2.60822088e-01f, 1.53815880e-01f, -1.43832698e-01f, 2.13549376e-01f, 6.00965843e-02f, -3.64336014e-01f, -1.36092650e-02f, 1.36891574e-01f, 1.91984117e-01f, 1.43981382e-01f,
  2.67779201e-01f, -2.70100325e-01f, 1.11783735e-01f, 1.86343491e-01f, -1.63622294e-02f, 1.05408885e-01f, -3.24485861e-02f, -9.24155489e-02f, -5.51877990e-02f, 1.06115349e-01f,
  2.32458532e-01f, -3.18238080e-01f, -5.15730865e-02f, -2.63874903e-02f, 1.37593180e-01f, -2.76270881e-02f, -8.20122734e-02f, 1.25901952e-01f, -6.14310019e-02f, 5.02137979e-03f,
  -1.68948658e-02f, 2.78554171e-01f, -1.76528826e-01f, 5.83593249e-02f, -1.11452565e-01f, 2.03689575e-01f, -1.58704638e-01f, 5.48664182e-02f, 1.96179692e-02f, 2.26725638e-01f,
  6.22662194e-02f, -2.96649754e-01f, -2.15552580e-02f, -1.03461416e-02f, 2.96118148e-02f, 3.01686406e-01f, 1.94333494e-02f, 3.66596311e-01f, 1.24111056e-01f, -4.64864448e-02f,
  -1.13741584e-01f, 1.92399055e-01f, 1.15815334e-01f, -8.39053839e-02f, 3.54395509e-02f, -1.87135577e-01f, 7.56616592e-02f, -1.37488946e-01f, 8.59822407e-02f, -1.34899989e-01f,
  2.21154645e-01f, -2.68884659e-01f, -1.39529467e-01f, 5.51113933e-02f, -1.30159542e-01f, -6.78598732e-02f, 1.69336602e-01f, 4.27843221e-02f, 1.94141522e-01f, -1.09519605e-02f,
  -2.22407997e-01f, 8.96518454e-02f, 1.02655115e-02f, 1.52575821e-01f, 5.77734038e-02f, -6.85326084e-02f, -2.53373742e-01f, 5.29597290e-02f, -5.20695047e-03f, 2.03901172e-01f,
  1.83638185e-01f, -2.58206159e-01f, 9.25748497e-02f, -1.47936389e-01f, -1.22880816e-01f, 2.98700631e-01f, -2.26729959e-01f, -5.55606261e-02f, -1.53984204e-01f, -1.38994530e-01f,
  -5.53165786e-02f, 7.76985893e-04f, 1.91235721e-01f, 2.72709191e-01f, 1.81835741e-01f, 1.88685685e-01f, -8.72766078e-02f, 2.05367148e-01f, 4.94588800e-02f, -2.69056827e-01f,
  -1.28301568e-02f, -8.05026889e-02f, -4.57694083e-02f, 1.09161876e-01f, -2.82978313e-03f, -5.31318784e-02f, -2.43142813e-01f, -1.23645343e-01f, -5.42562492e-02f, 2.69739002e-01f,
  3.48816961e-02f, -2.36298710e-01f, 6.38949946e-02f, 1.50446817e-02f, -1.25269324e-01f, -2.23601297e-01f, -3.10558937e-02f, -2.65664071e-01f, 2.81058908e-01f, 3.34523559e-01f,
  1.25720844e-01f, -7.08338767e-02f, -7.83694983e-02f, -3.82438302e-01f, 8.44155774e-02f, -3.25347543e-01f, 3.89152467e-02f, -5.37874848e-02f, -1.23398110e-01f, 5.76474816e-02f,
  -1.96361706e-01f, 1.88820958e-01f, 1.39178008e-01f, 1.25400588e-01f, -1.97912887e-01f, -2.02052668e-01f, 2.02590153e-01f, 1.20111778e-01f, -9.58389193e-02f, 3.32717933e-02f,
  -1.52032956e-01f, -1.08367406e-01f, -1.28910258e-01f, -1.75546110e-01f, 9.54788327e-02f, -1.50874287e-01f, 2.03972589e-02f, -3.94717753e-02f, 7.32660592e-02f, 5.19165099e-02f,
  -1.10113233e-01f, 2.67811298e-01f, -4.19997007e-01f, -1.40274212e-01f, -6.19048849e-02f, 1.40477911e-01f, 7.33567774e-02f, -7.41619617e-02f, 8.08175951e-02f, -2.05338940e-01f,
  -1.36544615e-01f, 1.04321159e-01f, 7.31106326e-02f, 2.24542096e-01f, 1.91215426e-01f, 3.89975980e-02f, 9.78462845e-02f, -8.25712085e-02f, 1.24026217e-01f, -3.03801388e-01f,
  2.05011755e-01f, 4.24694903e-02f, 1.19801886e-01f, 7.54288062e-02f, 1.79340318e-01f, 3.16624969e-01f, 1.13287918e-01f, 1.41557520e-02f, 7.16089830e-03f, -3.77210498e-01f,
  -2.67763227e-01f, 1.20399527e-01f, 1.48061320e-01f, 4.74058501e-02f, 1.81103835e-03f, 3.72881778e-02f, 7.44645819e-02f, -2.19301507e-01f, -9.98504832e-03f, -2.28507459e-01f,
  3.70628148e-01f, 1.20377421e-01f, 9.83529016e-02f, 1.91081986e-01f, 1.72504991e-01f, 2.40220740e-01f, -1.68939039e-01f, 3.77338193e-02f, -4.56144437e-02f, 7.95157030e-02f,
  8.78590271e-02f, -2.45237574e-02f, 2.07032412e-01f, -1.03771694e-01f, -1.39485730e-03f, 1.81577504e-01f, 2.39870086e-01f, -1.88506197e-03f, -2.32057095e-01f, -2.87026763e-01f,
  1.07375622e-01f, -4.29214686e-02f, 1.47458062e-01f, -3.38388532e-01f, 1.19159751e-01f, -1.30746692e-01f, 2.05911309e-01f, -9.26388577e-02f, 2.02045590e-01f, 9.16934162e-02f,
  3.22630070e-02f, 5.27685955e-02f, 4.76529673e-02f, 1.42697901e-01f, -1.13209099e-01f, 1.02845579e-01f, -2.51097471e-01f, -3.59396309e-01f, -4.89660949e-01f, 2.15519994e-01f,
  -1.79405168e-01f, 1.07221685e-01f, -9.48629677e-02f, 1.71045214e-01f, -2.89057374e-01f, -6.46770522e-02f, 1.52430594e-01f, 1.31265044e-01f, 8.81913155e-02f, 1.54242694e-01f,
  1.69808596e-01f, 1.53584689e-01f, -1.24820597e-01f, 3.04071128e-01f, 7.35968575e-02f, 2.01360375e-01f, -9.89659131e-02f, -2.06315331e-02f, 1.06657550e-01f, -2.52199173e-01f,
  1.80272669e-01f, -8.01516548e-02f, 3.78928669e-02f, -4.12440509e-01f, -2.55685896e-01f, 3.06532145e-01f, -7.96291754e-02f, -8.46942514e-02f, 3.37022208e-02f, -2.31828317e-01f,
  -1.91978246e-01f, -8.13599303e-02f, 6.94952905e-01f, 1.82878971e-01f, 3.14258151e-02f, -7.39122033e-01f, 1.10108461e-02f, 3.40644002e-01f, 8.27937126e-02f, 6.34475332e-03f,
  -3.05473983e-01f, -1.26860574e-01f, 4.63371128e-02f, 7.87310451e-02f, 1.74026430e-01f, 2.36761719e-01f, -3.70536521e-02f, 3.09811354e-01f, 7.35963061e-02f, 1.64745763e-01f,
  9.56296101e-02f, -2.06296876e-01f, 1.25544295e-01f, -1.42956059e-02f, -1.45786092e-01f, -5.02763927e-01f, -3.84797692e-01f, 7.13984370e-02f, -2.07298864e-02f, -1.45080224e-01f,
  1.46239087e-01f, -3.77823897e-02f, -1.40783042e-01f, 1.27063572e-01f, -2.21165851e-01f, -6.48797899e-02f, -3.80850017e-01f, 1.10900782e-01f, 1.66915670e-01f, 9.48211178e-02f,
  -5.43684252e-02f, -2.96850711e-01f, -2.40214005e-01f, 1.12362549e-01f, 3.02820861e-01f, 5.51894633e-03f, 1.22432401e-02f, -4.24655229e-02f, 8.97919759e-03f, 1.83987580e-02f,
  -2.03221127e-01f, 1.78614661e-01f, 6.28054291e-02f, -1.15341581e-01f, 4.42495085e-02f, 1.56014308e-01f, -1.10890292e-01f, -5.30405752e-02f, 1.88814998e-01f, -2.30634566e-02f,
  3.43383461e-01f, 4.32376593e-01f, 6.79042637e-02f, 1.88084751e-01f, -1.81179564e-03f, 1.57304808e-01f, -3.92979272e-02f, -1.50426000e-01f, 3.42164747e-02f, -3.36178206e-02f,
  2.22527266e-01f, -1.71501249e-01f, 2.54717171e-01f, 1.03408834e-02f, 1.13728317e-02f, 1.02695413e-01f, -1.26579449e-01f, -7.85739645e-02f, -8.65283981e-02f, -1.42124072e-01f,
  3.17289203e-01f, -1.41503513e-01f, -6.99183485e-03f, -1.16049619e-02f, -9.63772237e-02f, 2.70500720e-01f, 4.21630740e-01f, 1.74533173e-01f, -2.55596042e-01f, -9.62625816e-02f,
  3.83221619e-02f, 1.53721258e-01f, -1.12774238e-01f, -2.07935479e-02f, -1.43322751e-01f, 7.29086846e-02f, -3.99262039e-03f, 2.34688833e-01f, 3.39424387e-02f, 1.06266372e-01f,
  2.12376490e-02f, 1.08380333e-01f, -1.37636021e-01f, 6.81835711e-02f, -3.23506072e-02f, 1.98205248e-01f, 1.10551648e-01f, 1.40556991e-01f, 5.77673502e-02f, 8.00260529e-02f,
  -8.77680536e-03f, 2.84772236e-02f, 2.44453490e-01f, 5.88232018e-02f, 9.99008678e-03f, 9.50315129e-03f, 2.70672049e-02f, 4.29244041e-02f, -5.22820614e-02f, -2.53518552e-01f,
  3.32670629e-01f, -1.69546213e-02f, 1.63946912e-01f, -2.12225422e-01f, -6.68783262e-02f, 2.38389239e-01f, 8.82165432e-02f, 1.10294625e-01f, -1.61550060e-01f, -5.54971537e-03f,
  1.96627289e-01f, 1.54056922e-01f, -3.84582818e-01f, -9.32307318e-02f, 1.60935223e-01f, -2.75556266e-01f, 2.68920034e-01f, 2.90113930e-02f, -2.13400230e-01f, -3.56034189e-02f,
  3.68121150e-03f, 1.47397920e-01f, -1.94626629e-01f, -2.14497782e-02f, 2.58056093e-02f, 2.03675732e-01f, -1.24970861e-01f, 2.51242101e-01f, 1.48301110e-01f, 3.09599549e-01f,
  3.69758308e-02f, 8.52317289e-02f, 3.76150161e-02f, -6.40548095e-02f, -5.82863837e-02f, 3.19580897e-03f, 4.45333421e-02f, -1.44180238e-01f, 9.56073403e-02f, -9.89077762e-02f,
  3.78609751e-03f, 5.41678444e-03f, 3.26141044e-02f, -7.80428294e-03f, 1.56019479e-01f, 5.34299128e-02f, 7.78611982e-03f, 6.57483935e-02f, -9.20375139e-02f, -1.67099148e-01f,
  -3.72646004e-02f, -7.47299716e-02f, -1.02114350e-01f, 4.38588560e-02f, 1.05698891e-01f, 2.25187227e-01f, 4.04360751e-03f, 4.73745540e-02f, -3.39425087e-01f, -3.49213695e-03f,
  6.11298382e-02f, 1.48398489e-01f, -2.37138614e-01f, 2.43489444e-01f, 8.10508877e-02f, 1.87418550e-01f, 1.45128325e-01f, 9.12941032e-05f, 1.23789050e-01f, 1.11217991e-01f,
  4.68719788e-02f, -4.06597480e-02f, -2.99200173e-02f, -3.07447940e-01f, 1.56684354e-01f, -4.86897863e-02f, 2.29378194e-01f, 2.48194367e-01f, 6.01903088e-02f, -1.88926533e-01f,
  -1.15936480e-01f, -4.56054658e-02f, 2.62776554e-01f, 5.62720820e-02f, -1.58495709e-01f, -1.35433123e-01f, -1.74260765e-01f, -2.34363243e-01f, 4.88514863e-02f, -3.72313887e-01f,
  -1.00559890e-01f, -1.74105391e-01f, -1.19417757e-01f, -1.17359482e-01f, -1.06429450e-01f, -1.18519232e-01f, 6.22328892e-02f, 2.46136308e-01f, 2.11817414e-01f, 7.25236442e-03f,
  -4.09304708e-01f, 1.31079033e-01f, 4.27932851e-02f, -5.81912473e-02f, -3.27864528e-01f, 9.25304145e-02f, -1.46160293e-02f, 2.03604966e-01f, 1.89110637e-01f, 3.43255579e-01f,
  -1.02718860e-01f, -2.00660452e-01f, 4.46004281e-03f, 1.25369534e-01f, 1.98088616e-01f, -2.73744345e-01f, 7.31787756e-02f, -2.66646624e-01f, -2.81937718e-01f, 1.55579478e-01f,
  -6.79467469e-02f, 2.27627575e-01f, -3.27280551e-01f, -2.33221129e-01f, -7.77437910e-02f, -2.46068373e-01f, 1.66313007e-01f, -9.72504728e-03f, -4.64528566e-03f, -1.62844598e-01f,
  -2.05070768e-02f, 2.61695325e-01f, 1.52802944e-01f, 6.52769133e-02f, 2.67444272e-02f, 1.20741852e-01f, 3.04481298e-01f, -1.51214125e-02f, 9.15286541e-02f, 8.20443854e-02f,
  -1.43566370e-01f, -3.13790977e-01f, -5.55506311e-02f, -3.35697055e-01f, 4.22659516e-02f, 2.97488049e-02f, -1.24113254e-01f, 9.57167298e-02f, 1.37773305e-01f, -1.34617493e-01f,
  1.19409800e-01f, 1.19994380e-01f, 2.56926268e-01f, -3.25778902e-01f, -1.37755806e-02f, 8.90846029e-02f, 2.56157130e-01f, 2.71009862e-01f, -1.06140204e-01f, 2.15696454e-01f,
  -6.90364465e-02f, -2.06722721e-01f, -2.74274200e-01f, 1.96620107e-01f, -9.93371531e-02f, -3.66734006e-02f, 3.89449634e-02f, -1.09273940e-02f, 1.83876194e-02f, -7.85798486e-03f,
  1.91998586e-01f, 1.82037964e-01f, -1.06053486e-01f, -2.35789508e-01f, -1.61562055e-01f, 2.39664555e-01f, -1.44129381e-01f, 1.51204214e-01f, 4.13542464e-02f, -1.11474292e-02f,
  -3.46747823e-02f, 1.65602535e-01f, 2.21336763e-02f, 1.37083577e-02f, 6.52493164e-02f, -5.71246780e-02f, 8.29643235e-02f, 3.99334952e-02f, 1.32278979e-01f, -1.58616960e-01f,
  -9.41253528e-02f, 1.93367135e-02f, 2.10302532e-01f, 8.65809545e-02f, 6.69110427e-03f, -1.68495148e-01f, -2.67721713e-03f, 1.54551402e-01f, -1.13519944e-01f, 1.06922388e-01f,
  9.59719941e-02f, 1.50938630e-01f, 1.75991550e-01f, 2.55189538e-01f, -2.70608068e-01f, -9.77138281e-02f, 3.56421284e-02f, -2.52878189e-01f, 2.64110714e-01f, 2.95378901e-02f,
  -8.00952017e-02f, 3.05634625e-02f, -8.03113431e-02f, 7.16501325e-02f, -4.43648733e-02f, -3.36312912e-02f, 1.21615008e-01f, 1.14205904e-01f, 1.44207075e-01f, 4.93823141e-02f,
  -1.14610195e-01f, 5.39634153e-02f, -5.78213669e-03f, 1.80537999e-01f, -8.48079547e-02f, -9.78639945e-02f, -1.34473532e-01f, -7.95509890e-02f, 9.46735293e-02f, -7.64806792e-02f,
  -8.82979482e-02f, 1.72065347e-01f, 1.18392624e-01f, 4.55520265e-02f, 2.56209224e-01f, -3.57350893e-02f, 1.06208697e-01f, 1.90601349e-01f, 3.22096087e-02f, -9.49106440e-02f,
  1.00367770e-01f, -1.64258573e-02f, -1.54903159e-01f, -2.22382590e-01f, -6.40825927e-02f, -3.55047956e-02f, 1.36071131e-01f, -4.47595567e-02f, 3.01145948e-02f, 1.52962953e-01f,
  -3.51803392e-01f, -3.40931773e-01f, -1.12631939e-01f, 1.34113640e-01f, 4.80224676e-02f, 1.21379264e-01f, 5.59741519e-02f, 2.54131496e-01f, 4.40693973e-03f, 4.28438559e-03f,
  -3.72176319e-02f, 4.08419110e-02f, 3.36240023e-01f, -8.34154934e-02f, -7.36232698e-02f, -1.81885958e-01f, -8.94326121e-02f, -1.57519400e-01f, 1.67296752e-01f, -1.41153932e-01f,
  2.10276067e-01f, 1.95818454e-01f, -1.01856411e-01f, -1.49154263e-02f, 4.35731977e-01f, -9.74830613e-03f, 6.48673400e-02f, 1.02634817e-01f, -1.93917483e-01f, -2.41065379e-02f,
  -8.78130198e-02f, -1.07607304e-03f, 1.09261148e-01f, 3.94714437e-02f, -5.19876122e-01f, -2.45353937e-01f, -2.62715101e-01f, -2.24213362e-01f, 1.76518664e-01f, 3.12372684e-01f,
  2.11703122e-01f, 4.17266935e-02f, 1.05060861e-01f, 3.39334160e-02f, 4.89457212e-02f, 8.61532986e-02f, -3.43197025e-02f, -9.59960893e-02f, -1.91510364e-01f, -1.17880888e-01f,
  2.23247930e-01f, 2.31238544e-01f, -5.19203171e-02f, -3.43064308e-01f, 1.48705527e-01f, -4.73244041e-02f, -5.14139328e-03f, -2.25392863e-01f, -1.82179645e-01f, -4.01456922e-01f,
  7.03229243e-03f, -2.47657537e-01f, -4.25940752e-01f, -2.75339127e-01f, -1.94671288e-01f, 4.92495410e-02f, -3.37077752e-02f, 9.68995914e-02f, -6.23120219e-02f, 1.92274332e-01f,
  -4.08276290e-01f, -3.58509948e-03f, 1.66686788e-01f, 1.80760436e-02f, 1.35451406e-01f, 2.49887273e-01f, -5.76447919e-02f, 6.72437251e-02f, 1.94690794e-01f, -1.75971836e-01f,
  1.14451036e-01f, 1.95392966e-02f, 1.18978590e-01f, -8.49265140e-03f, 1.06092848e-01f, -8.07614475e-02f, -1.05339490e-01f, 1.15031071e-01f, 2.62728836e-02f, 2.99906135e-02f,
  -1.47549240e-02f, -1.37762755e-01f, -1.24200799e-01f, 1.96787015e-01f, 2.78237313e-01f, -2.62583405e-01f, -1.38749227e-01f, 1.19270205e-01f, 1.63950473e-01f, -2.09686272e-02f,
  -2.73584463e-02f, 9.15729702e-02f, -1.65525317e-01f, -1.31459475e-01f, -1.09756209e-01f, -1.08708348e-02f, -2.37148523e-01f, -7.31499493e-02f, -1.06670856e-01f, 1.77452430e-01f,
  -1.75225705e-01f, 2.00607076e-01f, 1.45598650e-01f, 1.63424656e-01f, -8.22982639e-02f, -7.81194642e-02f, -1.57581478e-01f, 2.24440899e-02f, -1.46012351e-01f, 2.35316351e-01f,
  -3.74329500e-02f, 2.62063026e-01f, 2.40320829e-03f, 1.06244572e-01f, -7.49248937e-02f, 1.38095692e-01f, 6.50487170e-02f, 8.09869543e-02f, 1.35083839e-01f, 8.45470279e-02f,
  -3.34612727e-02f, -3.57478827e-01f, 5.57011701e-02f, -8.69286153e-03f, 1.35960942e-02f, -1.72689289e-01f, 9.82909724e-02f, 9.83244926e-02f, 8.63323957e-02f, 7.16375783e-02f,
  4.67231423e-02f, -3.65933627e-02f, 5.64440116e-02f, -2.17715781e-02f, 1.79755300e-01f, 2.24003553e-01f, 2.68492967e-01f, -1.36832878e-01f, 7.68555626e-02f, 3.69488806e-01f,
  -2.20227569e-01f, -6.16635308e-02f, 2.37153228e-02f, 2.65529841e-01f, 6.70770779e-02f, -2.01098457e-01f, 2.29448199e-01f, 2.02961400e-01f, -1.43578304e-02f, -8.27054009e-02f,
  -1.19573668e-01f, 4.46581542e-02f, 9.67262685e-02f, -5.65623790e-02f, 1.54486418e-01f, -1.60055697e-01f, 9.28026810e-03f, -6.80079833e-02f, 2.28467405e-01f, -1.51843810e-02f,
  -3.17690402e-01f, 1.94411054e-01f, 9.72995758e-02f, 1.75488845e-01f, -1.25699088e-01f, 9.11180973e-02f, -1.15735941e-01f, 3.99085619e-02f, -1.64844662e-01f, 2.00790495e-01f,
  -1.04266115e-01f, -1.12257309e-01f, -1.77441016e-01f, 8.21889639e-02f, 2.19419360e-01f, 1.45754218e-01f, 2.80395508e-01f, 7.80717805e-02f, -3.80120397e-01f, -7.68421665e-02f,
  1.91906959e-01f, 8.93779173e-02f, 1.28060952e-02f, 1.30142853e-01f, 2.55595129e-02f, -1.16560236e-01f, -1.47121083e-02f, -3.03472400e-01f, -2.88699046e-02f, -4.41123486e-01f,
  -1.91699918e-02f, 1.72330990e-01f, 6.06830455e-02f, 1.84521720e-01f, 9.00367051e-02f, -1.59525707e-01f, 1.26922458e-01f, 8.28007683e-02f, 3.15247923e-01f, 2.91074365e-01f,
  -4.53189850e-01f, 6.12524636e-02f, 1.13785006e-01f, 3.60293686e-02f, 2.63360500e-01f, 4.64471914e-02f, -2.28450850e-01f, -1.06223106e-01f, -4.69369292e-02f, 8.76092762e-02f,
  -2.65057907e-02f, 8.25177357e-02f, 2.04509094e-01f, -1.14847846e-01f, 8.94555822e-02f, 1.49065331e-01f, -8.74657333e-02f, 5.64690307e-03f, 6.79090470e-02f, 2.58597642e-01f,
  1.29200490e-02f, 2.04469591e-01f, -4.17906418e-02f, -3.65470909e-02f, -9.63570476e-02f, 8.35577324e-02f, 1.88566804e-01f, 1.10080495e-01f, 2.03337073e-02f, 1.74155012e-01f,
  9.70198140e-02f, -4.95745875e-02f, 3.69223990e-02f, 3.08277667e-01f, -3.04429438e-02f, -6.26638681e-02f, -5.71719483e-02f, 1.91079840e-01f, -3.62767056e-02f, -2.67226726e-01f,
  1.48612708e-01f, -7.93631971e-02f, -1.46116419e-02f, 1.01117343e-01f, -2.75158193e-02f, 2.22357646e-01f, 3.83570008e-02f, 8.22826922e-02f, -1.38535840e-03f, -7.33901262e-02f,
  -2.39419267e-01f, 1.61858186e-01f, -2.28662826e-02f, 3.33941281e-02f, 2.59679735e-01f, -2.11994469e-01f, 1.92874856e-02f, 9.16297436e-02f, -1.03300460e-01f, 6.05386533e-02f,
  -2.13187203e-01f, -9.22618955e-02f, -4.65188501e-03f, 1.42621115e-01f, 1.47242501e-01f, -3.86240222e-02f, 1.24347471e-01f, 3.22129458e-01f, 7.97462612e-02f, 1.11787722e-01f,
  3.90478075e-02f, 1.34933338e-01f, -1.96941450e-01f, -1.20325506e-01f, 8.35560188e-02f, 4.75338362e-02f, -7.26198405e-03f, -2.86429599e-02f, 8.94960463e-02f, 3.62424063e-03f,
  8.65896977e-03f, 2.60431617e-02f, 2.47790273e-02f, 1.48483172e-01f, -2.79350221e-01f, -1.02220796e-01f, 7.71265104e-02f, 1.23910964e-01f, 2.12404095e-02f, 3.75589989e-02f,
  -1.99203461e-01f, -1.50277331e-01f, -3.93871039e-01f, 2.38858029e-01f, -1.41374528e-01f, -4.35256921e-02f, -1.34766519e-01f, 3.01508214e-02f, -6.35122657e-02f, -5.25113791e-02f,
  -2.47503772e-01f, -7.25445449e-02f, -1.40032038e-01f, 1.56690404e-01f, 1.78497910e-01f, 1.51962668e-01f, -7.28054717e-02f, 1.51606545e-01f, 1.00001916e-01f, 1.21488616e-01f,
  -1.70477778e-02f, -1.51344165e-01f, 1.28113925e-01f, -2.70114571e-01f, 1.14279166e-01f, 4.86591831e-03f, 3.27929780e-02f, -1.78287283e-01f, -2.28968225e-02f, 1.02917880e-01f,
  1.27167739e-02f, 7.21278563e-02f, 1.78410504e-02f, -1.24154694e-01f, -3.17660987e-01f, -1.12939589e-01f, 1.84613958e-01f, 2.06029937e-01f, 1.80419490e-01f, -4.83587891e-01f,
  8.47206637e-03f, -1.78855717e-01f, -6.73851371e-02f, 2.23601326e-01f, -6.72966763e-02f, 7.22725540e-02f, 1.23620868e-01f, 5.31496853e-02f, -1.52596518e-01f, 9.62117314e-02f,
  -1.34915441e-01f, 2.07455397e-01f, -3.74072976e-02f, -1.06078312e-01f, 5.36034070e-02f, 2.32285246e-01f, 1.03621418e-02f, 3.50857116e-02f, 1.24569207e-01f, 1.46713093e-01f,
  9.67134070e-03f, 1.75079525e-01f, 4.31250734e-03f, -3.11715733e-02f, -1.58228248e-01f, -8.41941163e-02f, 1.46288663e-01f, -7.37526417e-02f, -2.24457338e-01f, 5.02498774e-03f,
  1.54121816e-02f, -2.69568264e-01f, -1.53892010e-01f, -9.10318121e-02f, 6.53212070e-02f, 7.99275488e-02f, -9.11273584e-02f, -1.24635205e-01f, -1.76146179e-01f, 1.46132573e-01f,
  4.69473451e-02f, 1.40953138e-01f, 2.80227423e-01f, -1.20085217e-01f, -3.14074643e-02f, 1.44996211e-01f, 1.68377802e-01f, 7.18438327e-02f, 4.78889719e-02f, -2.16829740e-02f,
  2.60303795e-01f, -3.93644124e-02f, 2.59021968e-01f, 2.87985027e-01f, 3.01110029e-01f, 1.45178169e-01f, 1.54162124e-01f, 2.55501658e-01f, 3.65923822e-01f, -1.34258136e-01f,
  2.67625153e-01f, 9.34259966e-02f, 9.33908522e-02f, -2.10626543e-01f, 1.53114155e-01f, -3.32977623e-01f, -3.91150266e-02f, 1.27695605e-01f, -1.58689633e-01f, 1.12732857e-01f,
  1.70250937e-01f, -1.12185605e-01f, 6.34333119e-02f, 2.30762959e-01f, 3.20120633e-01f, -2.91582286e-01f, -1.66540712e-01f, 1.41568527e-01f, 1.69602677e-01f, 1.36994213e-01f,
  1.03711516e-01f, -5.47254132e-03f, -1.25744864e-01f, -2.24432692e-01f, -1.12056263e-01f, 2.54235771e-02f, -1.50632083e-01f, 9.24781188e-02f, -1.30868003e-01f, 1.76027715e-01f,
  -3.36867385e-03f, 1.77106664e-01f, 3.26258361e-01f, 1.67760789e-01f, 1.02087170e-01f, -1.92360878e-02f, 1.75239071e-01f, 3.06312069e-02f, -1.46720946e-01f, 1.03851199e-01f,
  -1.45618081e-01f, 3.07203680e-01f, -1.67945161e-01f, 7.47606456e-02f, -5.79074845e-02f, 1.05522543e-01f, 2.54843831e-01f, -3.26302834e-02f, 1.60670519e-01f, 2.14925513e-01f,
  1.09144032e-01f, -1.67771056e-01f, 2.10131019e-01f, -2.17104107e-01f, 2.75823623e-01f, -1.60463825e-01f, 4.30227630e-02f, 9.47883278e-02f, 1.91419631e-01f, 2.73733288e-01f,
  1.29156036e-03f, 1.92675307e-01f, 1.05310090e-01f, -2.30457559e-01f, 1.27660036e-01f, 4.67732809e-02f, -5.70997149e-02f, 2.03935906e-01f, 8.58826563e-02f, -2.09429130e-01f,
  1.86559841e-01f, 9.81610343e-02f, 1.21760860e-01f, 8.20477754e-02f, -9.51142982e-02f, -2.79062148e-03f, 5.73036745e-02f, -1.34199709e-01f, 7.66239464e-02f, -1.72893375e-01f,
  -1.40406281e-01f, -1.12758651e-01f, 1.38057498e-02f, -4.13607433e-03f, -3.62054184e-02f, 6.71770126e-02f, 2.75705904e-02f, 2.24517211e-01f, 2.17525333e-01f, 9.22549814e-02f,
  -1.24650411e-01f, 1.69524089e-01f, 7.35073388e-02f, -9.55352411e-02f, 8.40699358e-04f, 2.59770360e-02f, -1.17827402e-02f, 1.87394127e-01f, -5.20138070e-02f, -6.97730333e-02f,
  -9.64361206e-02f, -5.38465343e-02f, -2.83577088e-02f, 1.15034059e-01f, 1.97753627e-02f, -2.02262342e-01f, -1.09149292e-02f, -8.89851898e-02f, -1.66043296e-01f, 1.90600619e-01f,
  -8.07166994e-02f, 1.05048241e-02f, -8.93501490e-02f, 8.57744366e-02f, 1.85605079e-01f, -1.06883258e-01f, -2.11300597e-01f, 1.95267871e-02f, 4.66201156e-02f, -1.37010962e-01f,
  -3.92828807e-02f, -1.30391628e-01f, -1.84925139e-01f, 1.10260755e-01f, 2.83578709e-02f, 2.18956336e-01f, 4.33383733e-02f, -9.05132480e-03f, 3.35903391e-02f, 1.18077219e-01f,
  -2.29787886e-01f, -1.36553645e-01f, 2.00267330e-01f, -8.16837549e-02f, 1.20679095e-01f, 2.01861307e-01f, -7.81109091e-03f, 2.64183640e-01f, 1.32511407e-01f, -1.20656900e-02f,
  -2.50475970e-03f, -1.68750063e-01f, -2.32587770e-01f, 4.14124399e-01f, -3.96712236e-02f, 1.21797450e-01f, -2.06505861e-02f, -4.59734946e-02f, -4.80114631e-02f, 2.04880103e-01f,
  2.05224559e-01f, 1.63949654e-01f, 2.07382739e-01f, 2.47896597e-01f, 1.90375850e-01f, 3.31408620e-01f, -1.93116292e-01f, -2.78517514e-01f, 9.25673172e-02f, -3.70290130e-02f,
  -2.52242923e-01f, -1.93657521e-02f, 9.83969420e-02f, -1.98765695e-01f, -1.74952239e-01f, 1.05745703e-01f, -2.38616932e-02f, 3.80556993e-02f, 2.08239630e-01f, -1.36323139e-01f,
  3.54288816e-02f, -9.99918357e-02f, 5.86481094e-02f, 8.09701253e-03f, 5.22891583e-04f, -1.90215364e-01f, 2.34928414e-01f, 3.14191312e-01f, 1.65630564e-01f, -1.29350752e-01f,
  -1.06968984e-01f, -1.48397550e-01f, 4.52257693e-02f, 1.40488416e-01f, 3.02691281e-01f, 3.05407792e-01f, 1.80463746e-01f, 7.88432285e-02f, -1.93911176e-02f, -3.24407741e-02f,
  -2.81464130e-01f, 7.57809058e-02f, -1.72450051e-01f, -1.76215604e-01f, 3.80288452e-01f, 5.64343520e-02f, -8.79299268e-02f, 2.50315219e-02f, -2.18956798e-01f, -2.41743460e-01f,
  8.15762579e-02f, -1.10348701e-01f, -2.15088755e-01f, 4.89433929e-02f, 3.08403641e-01f, -1.42122066e-04f, 9.30969138e-03f, 5.23126237e-02f, 4.03588526e-02f, 1.56283379e-01f,
  -4.25464027e-02f, 1.09666385e-01f, -3.10203761e-01f, 1.83411539e-01f, -7.93087706e-02f, -1.86148044e-02f, -2.36383062e-02f, -1.97811171e-01f, -1.29940823e-01f, -1.00824416e-01f,
  1.76737040e-01f, -1.65727720e-01f, 4.99805734e-02f, -2.16965705e-01f, 1.44293383e-01f, -2.28543580e-01f, 6.25396669e-02f, -1.38487309e-01f, 2.90109158e-01f, 2.59950042e-01f,
  1.78939134e-01f, -2.71052063e-01f, 1.14851914e-01f, 1.98982894e-01f, -1.89749062e-01f, 1.56677067e-01f, -2.41504475e-01f, 2.06978485e-01f, 7.95617327e-02f, -2.01857463e-02f,
  2.81971276e-01f, -2.31916562e-01f, -3.14160585e-01f, 1.57191530e-01f, -1.81113295e-02f, 8.65176991e-02f, 1.03250360e-02f, -3.13931137e-01f, 1.24782570e-01f, 7.82003924e-02f,
  2.66269743e-01f, -3.62643413e-02f, 1.87511981e-01f, 1.52630597e-01f, -4.92805988e-02f, 9.69632417e-02f, 6.32684976e-02f, -1.55467212e-01f, 2.88399726e-01f, -3.00951153e-01f,
  -1.29141593e-02f, -8.11288953e-02f, -5.23433350e-02f, 4.43929434e-03f, -4.68365885e-02f, -2.08821669e-01f, -3.70515659e-02f, 2.73206569e-02f, 1.65822014e-01f, 7.91505128e-02f,
  -1.51961610e-01f, -9.47485678e-04f, 1.79258421e-01f, 1.28690884e-01f, 1.07948095e-01f, -1.82627350e-01f, 7.60695040e-02f, -8.57711211e-03f, 7.05823079e-02f, 3.96135747e-02f,
  7.11982697e-02f, -7.95767754e-02f, 1.13286292e-02f, -2.45206401e-01f, -5.22232614e-02f, -5.94547763e-02f, 2.70792935e-03f, -4.60533090e-02f, 2.94974521e-02f, -2.53275901e-01f,
  1.17253803e-01f, -7.20897168e-02f, 1.50679022e-01f, 1.19951241e-01f, 1.75266176e-01f, -2.94035167e-01f, 6.71029985e-02f, 9.83822420e-02f, -1.80519268e-01f, 1.46034464e-01f,
  1.45532742e-01f, 1.84033945e-01f, -1.42231435e-01f, 1.42851338e-01f, 3.51788737e-02f, -2.22554594e-01f, -1.84601560e-01f, -5.11860959e-02f, 1.11879312e-01f, 1.02629781e-01f,
  -3.84864509e-02f, -8.65206122e-02f, 1.40536234e-01f, 1.29861981e-02f, 2.38741934e-03f, 1.14985213e-01f, 1.88395575e-01f, 2.49073610e-01f, -8.16280767e-03f, -1.07628323e-01f,
  -1.69003829e-01f, -1.19076274e-01f, 1.07749350e-01f, 2.69676268e-01f, 6.23620972e-02f, -7.33748823e-02f, -1.32790163e-01f, -3.09961606e-02f, 2.44872898e-01f, -2.82750838e-02f,
  3.64990868e-02f, -1.93633497e-01f, -1.85059041e-01f, -5.63279688e-02f, -3.96265602e-03f, 1.95896998e-02f, -5.26156910e-02f, 1.86232179e-01f, -8.16019177e-02f, -1.22466624e-01f,
  -2.06949949e-01f, -5.67478612e-02f, 1.51197925e-01f, 9.73291546e-02f, 1.44990504e-01f, -6.13345206e-03f, -2.31893882e-01f, 1.60090938e-01f, -2.19273597e-01f, -9.34903547e-02f,
  -3.25616971e-02f, -6.81914538e-02f, 1.17388949e-01f, 5.04512116e-02f, 1.87015891e-01f, 2.40225866e-01f, 1.61493227e-01f, -2.35391408e-01f, 9.14628804e-02f, 9.16492566e-02f,
  2.09253147e-01f, -9.34255794e-02f, -6.30696043e-02f, -1.27443522e-01f, -1.83368728e-01f, 3.08197141e-02f, -9.05248374e-02f, 1.22946464e-01f, -6.18096516e-02f, 4.29745875e-02f,
  2.26639658e-02f, -1.80100933e-01f, -2.38125212e-02f, -1.36511266e-01f, -1.00352772e-01f, -2.59995192e-01f, -2.21589595e-01f, 7.44822919e-02f, 1.32385083e-02f, -1.08719831e-02f,
  2.55745016e-02f, -1.55038327e-01f, 1.02290809e-01f, 7.18707591e-02f, 4.41939741e-01f, 4.30779636e-01f, -4.23691571e-01f, -2.75458664e-01f, -3.26253893e-03f, 2.88263261e-01f,
  7.20408708e-02f, -1.15383435e-02f, -5.06625116e-01f, -1.26244038e-01f, 2.43238360e-01f, 1.14765704e-01f, 2.08842885e-02f, 1.32246194e-02f, -6.82106381e-03f, -1.90372895e-02f,
  -9.95562300e-02f, -5.57204038e-02f, 2.72281229e-01f, 9.13999081e-02f, 6.13398738e-02f, -6.36064680e-03f, -9.09200981e-02f, -3.02691698e-01f, -2.08389625e-01f, -4.56774272e-02f,
  -5.76078221e-02f, 1.46109133e-03f, -2.29277983e-01f, -2.11323723e-01f, -1.92398746e-02f, 4.09517810e-02f, 1.63454652e-01f, 1.60181254e-01f, -8.82344320e-03f, -1.53061062e-01f,
  -1.71349853e-01f, 1.61055788e-01f, -7.96440467e-02f, 1.16887406e-01f, -9.91429240e-02f, -2.70804822e-01f, 6.26132172e-03f, -7.89567009e-02f, 5.10610119e-02f, 1.31399296e-02f,
  1.11330234e-01f, 1.83067635e-01f, 7.08083957e-02f, 1.06741652e-01f, -7.77995959e-02f, -9.93724614e-02f, -1.66499019e-01f, 1.02875292e-01f, -2.24763323e-02f, 1.38951212e-01f,
  -5.41524701e-02f, 1.69008657e-01f, 1.15166679e-01f, 8.44024420e-02f, 1.81094661e-01f, 1.30800307e-02f, 1.28177553e-01f, 1.34893388e-01f, 4.25822893e-03f, 2.12730430e-02f,
  -3.66219915e-02f, 2.85002470e-01f, 1.91733036e-02f, -1.01608604e-01f, 2.88022310e-02f, 1.19975492e-01f, 2.91618615e-01f, -2.18919650e-01f, 4.87815589e-02f, -7.48708323e-02f,
  -1.74562097e-01f, -1.54888824e-01f, -3.21782306e-02f, 8.45347568e-02f, 1.46124035e-01f, -1.49324596e-01f, -4.58099321e-02f, 4.07905737e-03f, -7.65959620e-02f, 1.30214259e-01f,
  1.14665985e-01f, 2.35576317e-01f, -1.25622731e-02f, -1.77105322e-01f, -1.93163186e-01f, 7.74284527e-02f, -2.14485794e-01f, -3.35902154e-01f, -1.90370753e-01f, -4.44434024e-02f,
  8.14823359e-02f, 2.25593392e-02f, 1.26760170e-01f, 1.66054443e-01f, -6.79274797e-02f, -1.48526346e-02f, 3.14003490e-02f, 1.71381921e-01f, 1.38841927e-01f, -1.88831836e-01f,
  -3.10016036e-01f, 1.98287610e-02f, -2.12958559e-01f, -7.31307641e-02f, -8.79232248e-05f, 2.99479574e-01f, 2.96542905e-02f, 2.39755362e-01f, -3.45306541e-03f, -1.41946018e-01f,
  -1.11369506e-01f, -1.14080712e-01f, -9.56180394e-02f, -2.75714695e-02f, 5.33625409e-02f, -1.12789117e-01f, 9.31021944e-03f, 1.72264069e-01f, -6.72631189e-02f, 1.33047625e-01f,
  1.24329552e-02f, -1.72409579e-01f, -5.83404042e-02f, -9.97883826e-02f, 9.96084884e-02f, -9.99911949e-02f, 2.26874948e-01f, 4.98432480e-02f, 1.75143033e-02f, 1.25854671e-01f,
  7.74589330e-02f, 1.56094715e-01f, -4.92076613e-02f, 9.10456479e-02f, 6.45314306e-02f, -1.77712128e-01f, 1.40058950e-01f, -1.97156146e-01f, -2.31587529e-01f, 5.19872382e-02f,
  -6.28301948e-02f, 1.38180731e-02f, 3.18645656e-01f, 5.65909967e-02f, -7.82616809e-02f, -1.10505074e-02f, 7.32997432e-02f, 5.33340871e-02f, -1.46409020e-01f, 2.52190441e-01f,
  2.05817241e-02f, 1.33413211e-01f, -1.94497675e-01f, -4.61841971e-02f, -1.84869975e-01f, 1.85600445e-01f, 3.61774080e-02f, 1.35239571e-01f, -2.41009623e-01f, -1.50353789e-01f,
  -2.93122120e-02f, 1.57199711e-01f, -1.63514540e-02f, -4.09498625e-02f, 6.10333867e-02f, -1.04239628e-01f, -7.33644664e-02f, 3.50242704e-02f, -4.74178046e-02f, -1.75772533e-01f,
  -2.13232070e-01f, -2.20565453e-01f, 2.01905414e-01f, 6.56920522e-02f, 5.19972704e-02f, -3.74387413e-01f, 2.22740605e-01f, -2.83510592e-02f, 2.01160073e-01f, -1.18552111e-01f,
  -1.01685673e-01f, -6.90387189e-02f, 1.63477972e-01f, 9.24334526e-02f, 7.35674147e-03f, -2.92034149e-01f, -1.96429491e-01f, -4.31876816e-02f, 2.91357875e-01f, 1.97045252e-01f,
  9.47363973e-02f, -1.79705232e-01f, -2.98677325e-01f, -1.29794450e-02f, 1.32463738e-01f, 3.58097106e-02f, -5.35021313e-02f, -2.88705885e-01f, -8.75127241e-02f, -2.02253796e-02f,
  -8.04716349e-02f, -6.37160838e-02f, -1.77969068e-01f, 1.03891186e-01f, -1.08195856e-01f, 1.06285082e-03f, 1.63943172e-02f, -1.63001284e-01f, 1.55426100e-01f, -3.04278247e-02f,
  2.01198548e-01f, 6.72723167e-03f, -2.79533803e-01f, 1.50018603e-01f, 1.47001848e-01f, 9.74161029e-02f, -6.10845983e-02f, 1.70357265e-02f, 5.57742640e-02f, 2.16638297e-01f,
  2.34311357e-01f, -3.82164866e-02f, 1.13653913e-01f, -1.51870459e-01f, 3.03793866e-02f, 2.28139371e-01f, 2.63540924e-01f, 8.03340971e-02f, 1.81732282e-01f, -2.31883779e-01f,
  -2.74444222e-01f, -8.89032632e-02f, -6.55134581e-03f, -1.59158483e-01f, -8.57437178e-02f, -4.62312177e-02f, 8.45317319e-02f, -1.98063821e-01f, 1.89655468e-01f, -2.41588578e-01f,
  7.58627281e-02f, -3.49713534e-01f, -7.56570175e-02f, 2.92066991e-01f, -7.84463063e-02f, 2.09849719e-02f, 6.07922152e-02f, -8.89625251e-02f, 1.54725343e-01f, 2.13294685e-01f,
  1.42224789e-01f, -3.96867454e-01f, 3.59592251e-02f, -8.92245919e-02f, -1.33427709e-01f, 1.76104188e-01f, -6.14262149e-02f, 3.74433435e-02f, 2.13127751e-02f, -6.15244061e-02f,
  1.77843764e-01f, -2.69888379e-02f, 2.74084836e-01f, 1.49851963e-01f, -2.92111903e-01f, 3.09971809e-01f, 7.69961476e-02f, -1.80789754e-02f, 6.22519571e-03f, -1.17475882e-01f,
  -2.26165839e-02f, 3.98743153e-02f, -1.03750169e-01f, -3.28709092e-03f, -4.95592169e-02f, -8.30827206e-02f, -2.24125341e-01f, 1.04357444e-01f, 2.39660919e-01f, -2.20099986e-02f,
  1.63771119e-02f, 1.18349701e-01f, -4.20067832e-02f, 7.01595843e-02f, -2.07295522e-01f, -2.95933813e-01f, 2.42695063e-01f, 3.66904348e-01f, 3.82704213e-02f, -7.90954474e-03f,
  3.04902475e-02f, 2.72462070e-01f, 2.26157919e-01f, 2.60571986e-02f, -6.78371489e-02f, 3.74755375e-02f, 7.49321282e-02f, 8.48548189e-02f, 3.85125697e-01f, 1.22527346e-01f,
  -4.76780310e-02f, 2.24352300e-01f, 1.24030158e-01f, 8.56407806e-02f, -2.91039664e-02f, -1.62953690e-01f, 2.38558933e-01f, -1.02759145e-01f, 2.22412243e-01f, 2.46846583e-02f,
  1.03910305e-01f, 1.17174052e-01f, -3.87128383e-01f, 4.95596118e-02f, -5.40567897e-02f, -1.10382512e-01f, 3.08665186e-01f, -2.40605146e-01f, 7.27350591e-03f, 1.26446038e-01f,
  -1.72564492e-01f, -2.09496349e-01f, 4.19330522e-02f, 2.74627924e-01f, -1.58781007e-01f, -1.88159823e-01f, 2.77320277e-02f, 6.05717003e-02f, 3.54545820e-03f, -3.00572813e-01f,
  1.20191656e-01f, -1.83157742e-01f, -3.89196072e-03f, -1.89499594e-02f, 8.71433616e-02f, 4.80879247e-02f, -4.20739837e-02f, -1.61717162e-01f, 4.20258008e-02f, 1.23466223e-01f,
  8.43799580e-03f, -6.67972788e-02f, -1.46231696e-01f, -1.50991201e-01f, -2.89477855e-01f, 2.48160839e-01f, -2.33926550e-01f, 9.94587019e-02f, -3.61692794e-02f, -1.85889766e-01f,
  -3.25550854e-01f, -1.92655176e-02f, 8.07675496e-02f, -2.11627498e-01f, -1.52355149e-01f, 1.19838893e-01f, 2.08617702e-01f, 2.39011511e-01f, -1.58010527e-01f, 5.54585420e-02f,
  2.42047653e-01f, 1.24861561e-02f, 7.11416872e-03f, -2.41671652e-01f, 1.26947630e-02f, -1.93555489e-01f, 2.85897344e-01f, 5.19646667e-02f, 1.10379405e-01f, -4.10683602e-01f,
  8.00831765e-02f, 1.84707761e-01f, 1.49999350e-01f, 3.84470642e-01f, 2.18709424e-01f, -1.60360694e-01f, -3.51691872e-01f, -1.84474170e-01f, 2.39069551e-01f, 1.90530568e-01f,
  1.71027869e-01f, -4.81341034e-01f, 2.44591936e-01f, -7.92956352e-02f, 1.49368078e-01f, 2.59359717e-01f, -1.76084712e-01f, -9.51086283e-02f, 7.87973404e-02f, 6.77954778e-02f,
  4.00498025e-02f, 1.09883569e-01f, 7.14738294e-02f, 1.26777003e-02f, 2.42390797e-01f, -9.74322185e-02f, -6.70334026e-02f, -6.13396205e-02f, 1.76366642e-01f, 2.84055769e-02f,
  8.38108361e-02f, -4.65428084e-02f, -2.18105331e-01f, 1.86393455e-01f, 5.29712997e-02f, -1.23570889e-01f, -1.44889757e-01f, -1.09418154e-01f, -4.75072190e-02f, -1.23375706e-01f,
  -7.34663680e-02f, -4.38098311e-02f, -8.93066749e-02f, -2.20923334e-01f, -4.71748002e-02f, 4.10684310e-02f, 2.26833262e-02f, -1.69800878e-01f, -1.86897114e-01f, -1.66146144e-01f,
  -4.09640193e-01f, 7.07678571e-02f, 7.52690509e-02f, 2.56929666e-01f, -2.66051948e-01f, 1.12486802e-01f, -2.79188216e-01f, 1.08558826e-01f, 2.17167605e-02f, 1.07762273e-02f,
  -1.06527112e-01f, 1.74047634e-01f, 5.26976101e-02f, 2.39747524e-01f, -1.41406171e-02f, 3.71013619e-02f, 1.54095702e-02f, 1.34098575e-01f, -1.31539544e-02f, -1.62906889e-02f,
  -2.01213002e-01f, -2.29745984e-01f, 5.66179194e-02f, -3.02365839e-01f, -8.86957999e-03f, 2.72140026e-01f, 6.43578172e-02f, 2.03237627e-02f, 1.43826008e-01f, 6.76563084e-02f,
  3.51893902e-01f, -1.51160270e-01f, -1.74494386e-01f, -3.42402272e-02f, 1.37345064e-02f, 1.87035445e-02f, 1.55898318e-01f, -2.31286705e-01f, -1.00787245e-01f, 6.78955242e-02f,
  -2.28264838e-01f, -4.94209863e-02f, 1.73237339e-01f, -1.24789700e-01f, -9.71398577e-02f, 1.97138414e-01f, 1.54666275e-01f, -1.92568064e-01f, -3.04205511e-02f, -3.41520905e-02f,
  -7.62621388e-02f, 6.67609721e-02f, -1.13680363e-01f, -7.52650388e-03f, 1.08536467e-01f, -5.79617061e-02f, 2.14775562e-01f, 1.81141138e-01f, 1.44150466e-01f, -1.82466820e-01f,
  -9.23556089e-02f, 4.87839170e-02f, 6.43864870e-02f, -2.26170987e-01f, -1.40177608e-01f, -1.36823624e-01f, 6.55864105e-02f, 1.12890437e-01f, -2.12923959e-01f, 2.88611114e-01f,
  -2.30398774e-01f, -1.79483548e-01f, -9.97307077e-02f, 9.30822268e-02f, 2.04016045e-02f, -6.58512786e-02f, -6.16912283e-02f, -2.07420830e-02f, 3.18701491e-02f, 1.32697061e-01f,
  9.44152847e-02f, 2.08778813e-01f, 2.90972114e-01f, 1.61436200e-02f, -2.99284965e-01f, -4.79515344e-02f, 3.86945046e-02f, -4.32716720e-02f, 3.45980614e-01f, -4.80862409e-01f,
  1.63214892e-01f, 1.34399673e-02f, 1.01283668e-02f, -1.38532026e-02f, -8.99606720e-02f, -7.56200030e-02f, 1.82799384e-01f, 7.59664848e-02f, -1.63039669e-01f, 1.87704712e-01f,
  1.38780683e-01f, 2.81913251e-01f, 9.55519080e-03f, 1.97347343e-01f, -2.33120888e-01f, -1.82210878e-01f, -1.06581315e-01f, -3.11848372e-01f, 2.73474246e-01f, -3.65837961e-02f,
  -6.51683435e-02f, -2.45743111e-01f, -1.02549665e-01f, -1.65190324e-01f, -2.06137106e-01f, 1.65176407e-01f, 2.12128565e-01f, -8.14442337e-02f, 1.17936485e-01f, -1.15983717e-01f,
  1.24693438e-01f, -2.49414816e-01f, 1.27915457e-01f, 8.49455148e-02f, 2.14560196e-01f, -2.53234506e-01f, -1.40923113e-01f, 2.50899851e-01f, -3.70866090e-01f, -8.64827707e-02f,
  1.05901569e-01f, -1.67706296e-01f, -1.70078520e-02f, -2.07450867e-01f, 1.95769984e-02f, 8.50839466e-02f, -8.30880739e-03f, 4.99070529e-03f, 1.03062227e-01f, 9.58980843e-02f,
  1.88590642e-02f, 1.76391393e-01f, -1.71970978e-01f, 2.70778328e-01f, -4.61599007e-02f, -7.54672587e-02f, 1.12440949e-02f, 3.07863262e-02f, 4.27506328e-01f, -1.08339205e-01f,
  -1.30936414e-01f, 5.38151339e-02f, 4.14241068e-02f, 2.35981941e-01f, 5.71541525e-02f, -4.41152975e-02f, -6.71736225e-02f, 3.17367390e-02f, -1.93521366e-01f, -3.95014174e-02f,
  2.29527816e-01f, -3.21591109e-01f, 6.50596768e-02f, 1.72055690e-04f, 1.14402004e-01f, 2.45007277e-02f, -2.19118297e-01f, 2.03394994e-01f, -6.53664246e-02f, 1.19166657e-01f,
  -5.92509247e-02f, -1.71039551e-01f, 7.76773468e-02f, -8.02346542e-02f, 1.47580564e-01f, -1.90748379e-01f, -3.69392782e-01f, 1.42840236e-01f, -2.79358983e-01f, 2.14494802e-02f,
  1.02459840e-01f, 1.90405641e-02f, 4.92653139e-02f, 1.24060884e-01f, 1.40725017e-01f, -3.62398714e-01f, 1.59883440e-01f, 3.26988250e-02f, -1.42480999e-01f, 2.04117373e-01f,
  9.76214185e-02f, 1.11914515e-01f, -2.08248079e-01f, -2.80685183e-02f, -3.78039211e-01f, -1.74532726e-01f, -5.98276332e-02f, 1.82633132e-01f, 2.38110065e-01f, 3.12435269e-01f,
  -3.59361917e-02f, -3.94139066e-02f, 1.35625862e-02f, -1.61649510e-01f, 6.65333271e-02f, -2.00814590e-01f, 9.93373021e-02f, 1.43693760e-01f, 2.73293406e-01f, 1.35002464e-01f,
  1.27051935e-01f, 1.48529291e-01f, -1.59495696e-01f, 2.61530131e-01f, 3.34745422e-02f, -1.19122136e-02f, 1.80912212e-01f, -1.57840624e-01f, -1.62094623e-01f, 3.20220649e-01f,
  -1.08360477e-01f, 1.87382335e-03f, -3.75556387e-02f, -6.82653338e-02f, 1.45395935e-01f, -3.36699001e-02f, 1.06280921e-02f, 2.52993256e-01f, -6.45268485e-02f, -1.06709845e-01f,
  5.73903471e-02f, 6.79810485e-03f, 1.90800488e-01f, -2.94012398e-01f, 2.00988084e-01f, -7.56810829e-02f, -1.48107678e-01f, -1.39068976e-01f, -2.04529524e-01f, -9.90617871e-02f,
  -5.62390126e-02f, -5.63091785e-02f, -9.30653960e-02f, 8.47204030e-02f, -7.52199516e-02f, 1.46104395e-01f, 1.52335107e-01f, 8.31414238e-02f, 6.13961257e-02f, -1.46624118e-01f,
  5.95888868e-02f, -5.69828674e-02f, 2.17375264e-01f, -1.82633758e-01f, 4.24518585e-02f, 3.06270599e-01f, 2.19207063e-01f, 2.60836154e-01f, 1.12238549e-01f, -1.37685001e-01f,
  -7.00176042e-03f, -8.72591734e-02f, 2.12424006e-02f, 6.09332584e-02f, 4.53460105e-02f, -2.80735102e-02f, 3.24596465e-01f, -1.08637169e-01f, -1.18331373e-01f, -2.22504079e-01f,
  1.56553015e-01f, -3.25860865e-02f, -1.91972796e-02f, 2.17700467e-01f, 1.40171245e-01f, 2.08538562e-01f, -3.98086965e-01f, -1.12373859e-01f, -1.28759101e-01f, 7.65758306e-02f,
  1.67996004e-01f, -2.74810493e-01f, 2.64096618e-01f, -1.47879884e-01f, -1.48175165e-01f, -2.28154957e-02f, 7.04633892e-02f, 2.77352691e-01f, -1.84607640e-01f, 2.83743106e-02f,
  6.13153912e-02f, -5.83278574e-02f, -1.01575501e-01f, -3.49719711e-02f, 6.58243969e-02f, -2.51465380e-01f, 1.63669288e-01f, 7.93595165e-02f, -1.27156496e-01f, 8.57827589e-02f,
  1.46959022e-01f, 2.10683912e-01f, 1.84573427e-01f, 2.17632338e-01f, 9.97154713e-02f, 1.42404243e-01f, -1.93118632e-01f, -8.73115212e-02f, -2.43434161e-01f, 1.59909755e-01f,
  -1.56176850e-01f, -8.48594494e-03f, -1.88614279e-02f, -6.14202358e-02f, -2.99947798e-01f, -7.60744736e-02f, 1.57595024e-01f, 7.80611932e-02f, -2.54021361e-02f, 9.49290246e-02f,
  8.27784743e-03f, 2.88697183e-01f, -1.73471496e-01f, 1.74206898e-01f, 4.35329527e-02f, -1.57166943e-01f, -3.27475786e-01f, -8.55803862e-02f, 1.74066126e-01f, -1.75173968e-01f,
  3.77048249e-03f, 1.00687660e-01f, 8.06181729e-02f, -2.73978591e-01f, 2.38784149e-01f, 2.15083823e-01f, 2.38971442e-01f, 1.88264787e-01f, 1.18319981e-01f, -1.28482848e-01f,
  -4.07956600e-01f, -3.09916586e-01f, 7.83459563e-03f, -5.77011108e-02f, 4.05163527e-01f, -4.34615195e-01f, 5.12259174e-03f, -1.08352713e-01f, 1.08887382e-01f, 5.47581762e-02f,
  -1.17426015e-01f, -1.25762984e-01f, 2.15657175e-01f, 1.11758545e-01f, 3.85778286e-02f, 3.10660317e-03f, 3.81805040e-02f, -2.38590892e-02f, -4.53333445e-02f, 9.93372425e-02f,
  -1.12658702e-02f, -7.64670819e-02f, -9.15865079e-02f, -6.68641999e-02f, 1.41499683e-01f, -1.82781398e-01f, -1.48637861e-01f, 4.29390408e-02f, 6.12794720e-02f, -1.65028200e-01f,
  -2.36387238e-01f, 4.50776592e-02f, 8.61521214e-02f, -3.86239327e-02f, 3.48774642e-02f, -1.94238722e-01f, 1.82724074e-01f, -2.65551031e-01f, 3.17110986e-01f, -1.66272894e-02f,
  1.28888071e-01f, -2.46452883e-01f, -3.64734754e-02f, 2.33012855e-01f, -3.46662819e-01f, 1.83026493e-01f, 1.12251416e-01f, 1.53736442e-01f, -1.92806751e-01f, -9.30859596e-02f,
  -1.44365430e-01f, -2.19449103e-01f, -1.97831258e-01f, -3.45491245e-02f, 2.38629639e-01f, 1.41669706e-01f, 3.34916338e-02f, 1.34005219e-01f, 1.48998365e-01f, 1.68629169e-01f,
  1.71385750e-01f, 1.40593518e-02f, 3.36577892e-01f, 1.68381676e-01f, 1.10689782e-01f, 2.59424537e-01f, 1.71726972e-01f, 1.37086600e-01f, -2.60730505e-01f, -6.08480036e-01f,
  -4.31637354e-02f, 1.07890144e-01f, -1.76019967e-02f, -5.59515841e-02f, -2.15407908e-01f, 7.68990144e-02f, 1.56295091e-01f, 1.23665817e-01f, 7.06950054e-02f, 7.12695569e-02f,
  7.57016093e-02f, 2.93902308e-01f, 1.15609713e-01f, -1.49060205e-01f, 1.39982462e-01f, 1.58620384e-02f, 6.53415248e-02f, 5.02420031e-02f, 1.77793190e-01f, -1.20725073e-01f,
  -1.77216053e-01f, 1.68155074e-01f, -3.80308032e-02f, -1.99472398e-01f, 5.53633869e-02f, -1.85075283e-01f, -4.24598716e-02f, 1.89761236e-01f, -2.48368651e-01f, 3.83449867e-02f,
  -4.75872979e-02f, 2.28655208e-02f, 4.38205004e-02f, 1.56878829e-01f, -5.58789372e-02f, -1.21481970e-01f, -1.22523211e-01f, 1.81373626e-01f, 9.39940810e-02f, 3.48147601e-01f,
  3.65382172e-02f, 6.68047145e-02f, 1.32185251e-01f, 8.25960711e-02f, 8.17076713e-02f, -1.46286845e-01f, -9.22006294e-02f, -1.16005786e-01f, 1.27193168e-01f, 8.75033066e-02f,
  1.35657743e-01f, 4.13402356e-02f, 3.00051183e-01f, 2.25387990e-01f, 2.51791716e-01f, 2.13565409e-01f, 1.99793831e-01f, -1.91535763e-02f, 9.28038210e-02f, 1.95203461e-02f,
  3.19979638e-01f, 1.98765099e-01f, -7.71962618e-03f, -4.41046923e-01f, 7.06344098e-02f, -2.51459956e-01f, 9.26574320e-02f, 9.72788185e-02f, -1.13576189e-01f, 1.15516260e-01f,
  -5.31657822e-02f, -9.67552303e-04f, 1.28419055e-02f, -2.09497027e-02f, 1.61849618e-01f, -2.59456858e-02f, -2.14838237e-01f, -1.08130850e-01f, 2.09371060e-01f, 2.48754367e-01f,
  -3.85195091e-02f, 1.90507974e-02f, 1.06566831e-01f, 1.02123477e-01f, -1.21695317e-01f, 4.83790189e-02f, 7.57922838e-03f, 1.61177784e-01f, -1.13243923e-01f, -9.96730700e-02f,
  8.01471174e-02f, 1.38004929e-01f, -3.50241847e-02f, 4.09693830e-03f, 7.33353151e-03f, 4.65688854e-02f, -4.89475839e-02f, 1.63768426e-01f, 8.69651362e-02f, 1.47858977e-01f,
  1.97091838e-03f, 1.55763403e-01f, -3.71512100e-02f, 1.25067398e-01f, -8.63084421e-02f, 1.82864085e-01f, 8.25190544e-02f, 6.97207004e-02f, 2.05337375e-01f, 1.11460328e-01f,
  1.65042832e-01f, 4.63645793e-02f, -1.37709990e-01f, 9.52509716e-02f, 2.49489918e-01f, 5.41747287e-02f, 5.13183465e-03f, 2.10680157e-01f, 2.34730646e-01f, 2.59448379e-01f,
  2.59884357e-01f, 2.24350654e-02f, -7.92815983e-02f, 1.81806535e-01f, 2.37556454e-02f, -6.94407034e-04f, -4.40779811e-04f, -1.43084735e-01f, 6.27472252e-03f, 9.04219225e-02f,
  -2.50405371e-01f, -1.23786613e-01f, -3.40374619e-01f, -1.59399316e-01f, 1.47559298e-02f, -2.36323804e-01f, 1.72426134e-01f, 2.92184278e-02f, -1.09548785e-01f, 4.75871079e-02f,
  1.35667533e-01f, -1.41860187e-01f, 2.26317614e-01f, -4.27404530e-02f, 6.51881248e-02f, -5.17619075e-03f, 6.56995103e-02f, -9.96551737e-02f, -2.59768274e-02f, 6.44109258e-03f,
  -3.01851798e-02f, -9.83212516e-02f, 9.23264399e-02f, -1.52941674e-01f, 1.50831431e-01f, 5.49037270e-02f, -9.12986249e-02f, 4.45112549e-02f, -2.21067280e-01f, -3.46815020e-01f,
  1.14082485e-01f, 1.88912377e-01f, 4.55089696e-02f, 6.87238276e-02f, 1.15167610e-02f, 3.63674611e-01f, 7.82929808e-02f, 2.19173893e-01f, -1.11451373e-01f, -5.54550104e-02f,
  1.69157296e-01f, 1.82020083e-01f, 2.75743246e-01f, 1.66022733e-01f, 3.07201631e-02f, 8.91568288e-02f, 1.73429549e-01f, 1.32991578e-02f, -6.23395666e-02f, -3.56511116e-01f,
  2.13603750e-01f, -2.33982012e-01f, -1.28357679e-01f, -2.21711937e-02f, -1.22895911e-01f, 7.14280903e-02f, -2.28115827e-01f, -9.58663821e-02f, -1.36987716e-01f, 7.52404332e-03f,
  -2.10425984e-02f, 7.25408122e-02f, 3.09383702e-02f, 2.72459700e-03f, 4.98749204e-02f, 1.08842188e-02f, 1.18681192e-01f, 1.57153681e-01f, 5.30873612e-02f, -1.10740371e-01f,
  -1.78149760e-01f, -1.16499253e-01f, -1.46368682e-01f, -1.56635612e-01f, -8.59808400e-02f, -8.44538491e-03f, -1.24229506e-01f, 4.42922302e-02f, -9.87976789e-03f, 3.06828499e-01f,
  1.62862688e-01f, 2.29510397e-01f, 2.33198702e-02f, 1.56899825e-01f, 1.53950989e-01f, 8.64773542e-02f, -1.55908048e-01f, -2.18712002e-01f, -2.93674111e-01f, 2.55741202e-03f,
  -1.51239738e-01f, 8.63577053e-02f, -3.08155436e-02f, -5.84751777e-02f, -7.46570155e-02f, -1.46762386e-01f, -4.39073797e-03f, 2.03715727e-01f, -4.26231436e-02f, -2.62203868e-02f,
  -1.67585358e-01f, -1.26312450e-01f, -1.55549601e-01f, 8.38032439e-02f, -5.10181524e-02f, -5.11640459e-02f, 3.10175912e-03f, -1.96074229e-02f, 2.01588005e-01f, -2.26080790e-01f,
  -1.52164280e-01f, 7.22663999e-02f, 1.16893798e-01f, -8.56038108e-02f, 1.10911965e-01f, 2.62181252e-01f, 1.21961884e-01f, 2.20341235e-01f, 2.22065896e-01f, -9.64965746e-02f,
  -5.45549206e-02f, -1.01586312e-01f, -1.71499133e-01f, -2.41094008e-01f, 8.09372291e-02f, -6.18735887e-02f, 7.27936700e-02f, -4.04686421e-01f, -1.61194690e-02f, 1.84652954e-02f,
  3.35060030e-01f, -1.10761799e-01f, -1.88672841e-01f, 3.33160833e-02f, 1.32996410e-01f, -1.30453497e-01f, 2.72433817e-01f, -5.09044111e-01f, 2.03099921e-01f, -1.05384357e-01f,
  -1.07842855e-01f, 1.61926113e-02f, 1.71923414e-01f, 8.98930207e-02f, 4.63186093e-02f, 1.39969811e-01f, 3.49770598e-02f, -1.19711354e-01f, -4.08496410e-02f, -1.65361598e-01f,
  -2.77308702e-01f, -4.97888029e-02f, -2.88639426e-01f, -1.06302174e-02f, 1.30749375e-01f, -1.70014039e-01f, 7.36217722e-02f, 2.34066308e-01f, -2.10843375e-03f, 1.62815422e-01f,
  1.83164775e-01f, -9.51150581e-02f, 1.38840631e-01f, 1.48538917e-01f, -1.64907619e-01f, 1.70664966e-01f, 7.94163495e-02f, 2.98584342e-01f, -2.84619927e-01f, 1.34743065e-01f,
  -9.71975625e-02f, -1.08238757e-01f, -2.13414729e-01f, -1.42532274e-01f, 8.08913708e-02f, 2.42908522e-01f, 6.78668693e-02f, -1.27967680e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.20752066e-01f, 2.64722943e-01f, -2.40496099e-02f, -2.08621137e-02f, 2.04894543e-01f, 7.95105398e-02f, -4.86727431e-03f, 9.45573486e-03f, 1.03590697e-01f, 1.80825144e-01f,
  1.40482992e-01f, 1.35536537e-01f, 2.08762527e-01f, 7.48412311e-02f, 9.14906431e-03f, 2.93317199e-01f, 9.57961157e-02f, 9.61507708e-02f, -1.18912987e-01f, 7.13497326e-02f,
  -2.82249264e-02f, -2.09651068e-01f, 1.08519800e-01f, 9.52570587e-02f, 2.65570819e-01f, -1.38930783e-01f, 8.67150873e-02f, 1.73978940e-01f, 1.59281641e-01f, -8.19839817e-03f,
  -2.80824024e-02f, 1.32626295e-01f, 1.84958890e-01f, 1.06876448e-01f, 9.63701755e-02f, -2.87611000e-02f, 1.02704257e-01f, 2.58514881e-01f, 1.10440426e-01f, 2.13995025e-01f,
  1.27597690e-01f, 1.70937225e-01f, 6.71372339e-02f, 6.74042627e-02f, 2.61521246e-02f, 1.16325535e-01f, 1.82124853e-01f, -1.17797032e-01f, -4.93668690e-02f, 8.79234225e-02f,
  -8.94420221e-02f, 2.17465386e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  2.88170371e-02f, 7.65480623e-02f, -6.81810826e-03f, 1.79381862e-01f, -1.14713341e-01f, -1.08528562e-01f, 7.92115480e-02f, 1.73187450e-01f, -9.10064653e-02f, 3.98308747e-02f,
  2.02807989e-02f, -1.43212676e-01f, -6.92492947e-02f, 1.84704974e-01f, -1.27987787e-01f, -2.00453207e-01f, -9.45526809e-02f, -1.70227602e-01f, -4.50813137e-02f, 7.78685063e-02f,
  -1.63581390e-02f, -4.90295738e-02f, 1.35083860e-02f, -1.84763029e-01f, -6.32398427e-02f, 8.56572688e-02f, -8.40650052e-02f, -2.20546037e-01f, 1.94441944e-01f, -1.71309665e-01f,
  -3.44773568e-03f, 8.89979899e-02f, -1.29883766e-01f, -9.48481783e-02f, -7.78343454e-02f, -2.22159788e-01f, 4.84353192e-02f, -2.84541771e-02f, -2.36244261e-01f, -1.88129202e-01f,
  -8.99257213e-02f, -1.34822369e-01f, -1.07665481e-02f, 2.55115569e-01f, 4.88011129e-02f, 1.17369041e-01f, -1.03249095e-01f, 6.19760379e-02f, -1.16365636e-02f, 5.49636446e-02f,
  2.65447684e-02f, -2.14484692e-01f, -5.43944612e-02f, -2.10002456e-02f, -6.62298698e-04f, -3.33833415e-03f, -7.56517947e-02f, -1.51443064e-01f, -3.22848298e-02f, -1.37370467e-01f,
  -1.21315338e-01f, 4.63132747e-02f, 3.20632160e-02f, 3.29385366e-04f, -1.53493239e-02f, -4.55898978e-02f, -9.42487642e-02f, -2.03419209e-01f, -5.04964255e-02f, 1.36678468e-03f,
  -7.69205671e-03f, 8.14934354e-03f, 7.93559998e-02f, 4.13489640e-02f, -8.39644372e-02f, -6.18608743e-02f, -6.12197965e-02f, -5.72882872e-03f, 5.51854707e-02f, 3.26131761e-01f,
  5.43210953e-02f, 1.98317245e-02f, 9.25129503e-02f, -1.24702021e-01f, -1.00876912e-01f, -1.86583087e-01f, 3.28345567e-01f, -5.44261113e-02f, 8.81287381e-02f, -2.41267914e-03f,
  -4.10595648e-02f, -3.33123505e-02f, 1.15391843e-01f, -4.86206729e-03f, 1.27081931e-01f, 1.20757185e-01f, 6.70134276e-02f, 1.55290455e-01f, 8.94832835e-02f, 1.51513994e-01f,
  -1.06157549e-01f, 2.11180940e-01f, 1.00375926e-02f, -1.39065549e-01f, 1.08566336e-01f, 8.85847658e-02f, 3.39675583e-02f, -2.60684550e-01f, -1.27158508e-01f, 5.00619672e-02f,
  -8.40084180e-02f, -1.33953178e-02f, 6.34763762e-02f, 7.67391101e-02f, 4.42215241e-02f, -1.45631477e-01f, -5.07618040e-02f, 2.13488564e-01f, 2.38610227e-02f, -2.19412044e-01f,
  4.34929579e-02f, 1.08977087e-01f, -1.01300515e-01f, 1.11664116e-01f, 8.02665427e-02f, -1.84792310e-01f, 1.31712466e-01f, -1.20591223e-01f, -7.93936476e-02f, 2.79113472e-01f,
  -6.16908073e-02f, 5.99620268e-02f, -1.35928988e-01f, -1.75008774e-01f, -1.13272227e-01f, -1.16896108e-01f, -2.01981828e-01f, 1.06517307e-01f, -1.79571435e-01f, 8.64191949e-02f,
  -1.28707066e-01f, -6.30281866e-03f, 1.88498855e-01f, 1.30336419e-01f, 2.11907372e-01f, 2.25406423e-01f, 6.51356354e-02f, -7.31100887e-02f, 2.61449274e-02f, 8.93751979e-02f,
  -2.41573844e-02f, 2.84557283e-01f, -6.57596886e-02f, 1.07869595e-01f, -1.28344253e-01f, 4.16404046e-02f, 2.19197243e-01f, -2.36752361e-01f, 8.55586082e-02f, -7.17872977e-02f,
  4.85657528e-02f, -1.54400721e-01f, -2.11588331e-02f, 1.50525421e-01f, -1.47284344e-01f, -6.22442812e-02f, 5.48153780e-02f, -2.50928309e-02f, -7.86481518e-03f, -1.53334156e-01f,
  9.37534347e-02f, -4.85363342e-02f, -2.96750367e-02f, -8.10245797e-02f, 2.12925017e-01f, 1.60222575e-01f, -1.50707155e-01f, -3.32166590e-02f, 2.52047747e-01f, -9.02518779e-02f,
  1.80549741e-01f, -7.31272064e-03f, -1.51903421e-01f, 9.35758427e-02f, 9.11663100e-02f, 1.33036256e-01f, -1.02914050e-01f, 2.19023556e-01f, -1.09310664e-01f, 1.33759424e-01f,
  4.66606468e-02f, 2.25532487e-01f, 2.28918288e-02f, -2.88077164e-02f, 1.77800059e-02f, -7.79049620e-02f, 2.90426072e-02f, 2.91566700e-02f, -4.13024008e-01f, -4.14568149e-02f,
  -1.36056080e-01f, 2.51063049e-01f, -4.97731194e-02f, -8.25436190e-02f, -9.94582176e-02f, -1.94658548e-01f, -5.56114502e-02f, 1.00425318e-01f, 2.28552133e-01f, 1.12238400e-01f,
  -2.70127133e-02f, 6.51040152e-02f, -1.41504914e-01f, 3.48812714e-02f, 5.76552302e-02f, 1.52434677e-01f, -3.77792567e-02f, -7.05801090e-03f, -9.68561396e-02f, 1.27577350e-01f,
  1.95837673e-02f, 1.12555280e-01f, 4.71513420e-02f, 4.04848531e-02f, -6.01877458e-02f, -2.57703345e-02f, 2.43090950e-02f, -1.45775154e-01f, -1.97423503e-01f, -2.18958571e-03f,
  -1.31342307e-01f, 1.05290852e-01f, -5.53598627e-02f, 6.31070808e-02f, -5.85120078e-03f, -9.40550715e-02f, -1.14475720e-01f, -7.06466138e-02f, 1.56936854e-01f, 1.01810984e-01f,
  9.21208188e-02f, 7.20284656e-02f, 1.39870659e-01f, -1.62562653e-01f, -2.01876163e-02f, -7.46354386e-02f, -2.00055599e-01f, 1.57006197e-02f, -3.74050662e-02f, -1.05640534e-02f,
  -1.44592777e-01f, 1.09271392e-01f, 2.85990275e-02f, 1.07494362e-01f, 7.02181831e-02f, 1.80760100e-01f, -3.53104845e-02f, 1.14228856e-02f, 2.77898666e-02f, 2.52319686e-02f,
  -1.44710362e-01f, -1.44102022e-01f, 7.75146903e-03f, 2.17387393e-01f, -1.14157937e-01f, 1.10768359e-02f, 2.27847874e-01f, -1.12820603e-01f, 1.31608933e-01f, 7.71875978e-02f,
  -1.01871695e-02f, 1.62418276e-01f, 1.80403039e-01f, 4.62589487e-02f, -7.67444000e-02f, 1.89799502e-01f, -9.80375335e-02f, -2.66815852e-02f, 1.29827932e-01f, 1.35647148e-01f,
  -6.38790801e-02f, -5.81344329e-02f, 8.69302228e-02f, -1.05307065e-01f, 1.71420500e-01f, 1.02059245e-01f, 2.00976193e-01f, -2.59288866e-02f, -7.18104318e-02f, 2.55454779e-01f,
  5.12842648e-02f, -1.35684922e-01f, -1.37599081e-01f, 2.79280037e-01f, 8.09955820e-02f, -1.44326568e-01f, 5.31563088e-02f, -1.08371533e-01f, -2.33987451e-01f, 6.15328103e-02f,
  3.08172796e-02f, 3.60948741e-02f, 1.56852201e-01f, 8.69641453e-02f, -1.31951466e-01f, -7.98583627e-02f, 3.45497392e-02f, -5.61987124e-02f, 1.14651024e-01f, 1.86803937e-01f,
  8.19374435e-03f, -5.04517481e-02f, -3.20100486e-02f, -8.85701701e-02f, 3.06901187e-02f, 7.89089203e-02f, 4.78713624e-02f, 5.73614566e-03f, -4.49499972e-02f, 1.41350571e-02f,
  -2.32575580e-01f, 1.34020641e-01f, -1.57236502e-01f, -9.72772539e-02f, -9.08458680e-02f, 8.33978429e-02f, 1.65008679e-02f, -5.53040989e-02f, -3.14295739e-02f, -1.16417520e-01f,
  3.56198661e-02f, -1.97057903e-01f, 1.94027632e-01f, -1.82221569e-02f, -8.16163644e-02f, 3.53874713e-01f, 6.07231595e-02f, 3.27870846e-02f, -1.33789107e-01f, -5.08085303e-02f,
  9.18454081e-02f, 8.28007683e-02f, 9.53399204e-03f, -1.22600421e-01f, -1.17512457e-01f, -1.36997998e-01f, 8.74694660e-02f, -1.24610312e-01f, -5.26786149e-02f, 9.50735342e-03f,
  -3.29312980e-02f, -7.68866688e-02f, -3.34834084e-02f, 1.33132830e-01f, 5.81490844e-02f, 1.33265331e-02f, -1.03408813e-01f, -2.00351700e-02f, -4.04866189e-02f, 7.37485215e-02f,
  -1.48196712e-01f, -2.77817667e-01f, -1.39477417e-01f, -1.68605670e-01f, -7.29155317e-02f, -1.87771406e-03f, 1.09030604e-01f, -1.67258322e-01f, -9.47437361e-02f, -3.97436731e-02f,
  -2.29373187e-01f, -3.03128343e-02f, 4.32612039e-02f, -1.32854208e-01f, 8.92089680e-02f, 2.94918343e-02f, 2.00424090e-01f, -1.05873168e-01f, 9.42997113e-02f, 1.35986060e-01f,
  1.26767093e-02f, -6.04834408e-02f, -1.07221141e-01f, -3.08325868e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.72702032e-01f, 2.49982521e-01f, -2.29311176e-02f, 2.51763761e-01f, -6.85028136e-02f, -4.17561568e-02f, -4.34879027e-03f, 3.09425197e-03f, -1.37721792e-01f, 4.36134189e-01f,
  -2.66168207e-01f, 3.18934977e-01f, 1.10288970e-01f, -4.67424244e-02f, -1.90613363e-02f, -1.81781147e-02f, 1.52214453e-01f, -2.73844719e-01f, 2.15499267e-01f, -2.35269498e-02f,
  -3.26306045e-01f, 1.12356067e-01f, 2.11688906e-01f, -2.03572009e-02f, 5.85122108e-02f, 6.24411274e-03f, -3.43450271e-02f, 2.75988579e-01f, -1.55231029e-01f, 1.64307192e-01f,
  6.59710541e-03f, 2.91711777e-01f, -2.27747113e-01f, -2.65793372e-02f, 7.49847367e-02f, -5.97468428e-02f, 5.87203912e-02f, -6.93211891e-03f, 1.21488340e-01f, -1.53711632e-01f,
  -1.48568973e-01f, 1.41744480e-01f, -1.23620987e-01f, -8.25092420e-02f, 1.81274954e-02f, 1.92869112e-01f, -3.30102518e-02f, 8.89508799e-02f, 1.38679802e-01f, 5.54814152e-02f,
  -1.04889534e-01f, 1.01858787e-02f, -8.80799815e-02f, 3.16858202e-01f, -2.66008526e-01f, 9.35545787e-02f, -2.64036894e-01f, 5.52211478e-02f, -8.40587243e-02f, -3.24907064e-01f,
  -1.12674370e-01f, -2.57901400e-01f, 1.79569915e-01f, 4.09236997e-01f, 3.09784412e-02f, 8.06526653e-03f, 1.78520471e-01f, 4.12353948e-02f, 1.51883021e-01f, 4.19915244e-02f,
  -2.29187429e-01f, 1.55904651e-01f, -2.60076392e-02f, 6.91091418e-02f, 1.06685283e-02f, -1.77335292e-02f, 1.64147615e-01f, 1.85438842e-01f, -7.91918114e-02f, 1.77855566e-01f,
  -3.71946752e-01f, -2.20304042e-01f, 8.08534920e-02f, 6.50382489e-02f, -8.07209387e-02f, 1.32339075e-01f, 2.67163128e-01f, -5.33264279e-01f, -1.41834706e-01f, -1.02368750e-01f,
  4.43248302e-02f, 5.46757951e-02f, -1.37714431e-01f, -1.49365991e-01f, -1.47000641e-01f, 1.66661084e-01f, -6.66788444e-02f, -9.76655185e-02f, 2.70764023e-01f, -2.04274133e-01f,
  -9.57839042e-02f, -2.15539798e-01f, -2.44415000e-01f, -2.19208926e-01f, -1.24473266e-01f, -1.55426757e-02f, -2.54305124e-01f, 7.51014128e-02f, 2.07679659e-01f, 7.03660026e-02f,
  -2.87191980e-02f, 2.24057585e-02f, 2.29750909e-02f, 2.15429440e-01f, -6.92486539e-02f, -5.23234829e-02f, -2.46584535e-01f, 2.27750182e-01f, 5.02911285e-02f, -4.45192046e-02f,
  3.81569676e-02f, 6.59228638e-02f, 1.71537086e-01f, -2.79321134e-01f, -3.11205894e-01f, 1.73500590e-02f, -1.00862063e-01f, 1.53667435e-01f, 2.66960114e-02f, -3.25370967e-01f,
  1.56150505e-01f, -1.00221619e-01f, 3.46329093e-01f, 5.41833602e-02f, -2.18702331e-01f, 9.94107276e-02f, -2.09106263e-02f, -3.51665735e-01f, -2.34800994e-01f, 1.41466623e-02f,
  -2.70503070e-02f, 6.93701059e-02f, 1.49032816e-01f, 1.15973115e-01f, 2.17867360e-01f, -1.26016036e-01f, -8.82995725e-02f, 1.36062920e-01f, -5.99412574e-03f, 1.44639358e-01f,
  1.42475903e-01f, -6.25625849e-02f, 2.53949948e-02f, 1.12836741e-01f, 2.03145921e-01f, -1.19656824e-01f, 3.28134269e-01f, -2.29283527e-01f, 9.60245542e-03f, -1.29724322e-02f,
  -3.04660678e-01f, -8.60555470e-02f, 2.03706264e-01f, -1.88579708e-01f, -8.63403156e-02f, -1.34168506e-01f, -1.65472388e-01f, 1.18440494e-01f, -5.19411489e-02f, 8.70662108e-02f,
  2.30259478e-01f, -1.18233375e-01f, 1.70205697e-01f, 2.61005640e-01f, -1.20082207e-01f, -1.17624365e-01f, -1.18415102e-01f, 2.00362861e-01f, -1.60040095e-01f, -1.53829053e-01f,
  1.26271829e-01f, 5.35329320e-02f, 2.25980088e-01f, 3.13814640e-01f, -2.91036274e-02f, -8.50488394e-02f, 2.45415747e-01f, -6.71550706e-02f, 1.71039589e-02f, -1.16063796e-01f,
  -3.98520334e-03f, 1.13616288e-01f, 8.76515135e-02f, 2.11733624e-01f, 2.18977600e-01f, 2.90242761e-01f, -5.97829409e-02f, 9.07377526e-02f, -5.18782772e-02f, -4.36836742e-02f,
  -9.74862725e-02f, -1.76370274e-02f, 1.50049612e-01f, -2.20869198e-01f, -1.63497105e-02f, -1.03955112e-01f, 7.54231289e-02f, 1.58198804e-01f, 2.62554381e-02f, 1.88591227e-01f,
  4.92042582e-03f, 2.33022958e-01f, 9.21068266e-02f, 5.57592288e-02f, -4.16877061e-01f, 2.92542934e-01f, -9.49271992e-02f, -2.10486442e-01f, -2.81098336e-01f, 1.30680501e-01f,
  2.11439170e-02f, 2.64472160e-02f, -1.54514760e-01f, 4.00934294e-02f, 6.09467700e-02f, -1.28090233e-01f, -4.29008454e-02f, 1.28745899e-01f, 1.21213943e-01f, 1.88479498e-01f,
  -6.88293129e-02f, 1.27379401e-02f, 1.45424977e-01f, 6.62491620e-02f, -2.42203102e-01f, 2.07484782e-01f, 1.14471458e-01f, -6.33827820e-02f, 1.06743641e-01f, 4.73504215e-02f,
  -1.42315060e-01f, -4.08983119e-02f, 1.24914423e-01f, -6.79685175e-02f, 2.10131388e-02f, 1.33005530e-01f, -3.00541017e-02f, 5.88150434e-02f, 2.04812229e-01f, -1.11759022e-01f,
  -1.20563142e-01f, 1.59825772e-01f, 3.55644189e-02f, 2.78343409e-01f, -2.73632891e-02f, 2.38032579e-01f, -1.17970563e-01f, -5.49109392e-02f, -2.45180935e-01f, 2.21541263e-02f,
  -5.22792265e-02f, 1.71618983e-01f, 1.26761615e-01f, -1.80038705e-01f, 2.63812900e-01f, 1.37835056e-01f, -3.13810594e-02f, 6.46990584e-03f, 1.08453333e-01f, -1.62790507e-01f,
  -7.52035007e-02f, 3.72249693e-01f, -2.58627813e-03f, 1.22073621e-01f, -1.85898971e-02f, -2.36473903e-01f, -2.21571803e-01f, -1.42662838e-01f, 1.46237925e-01f, -7.86208361e-02f,
  -4.40754257e-02f, 1.60231858e-01f, -1.68106873e-02f, 6.10828958e-02f, 1.92024082e-01f, -1.18208155e-01f, 2.53135320e-02f, 9.94292926e-03f, 4.60672751e-02f, -1.18982837e-01f,
  5.04858829e-02f, -6.80858269e-02f, 1.48449674e-01f, -2.51806915e-01f, 6.56936616e-02f, 9.50910524e-02f, -4.37437594e-02f, 6.11557364e-02f, 2.16093361e-01f, -2.40437537e-01f,
  -1.90740466e-01f, -5.04061952e-02f, 1.84908956e-01f, -3.74157703e-03f, 4.47440967e-02f, 1.27469465e-01f, -5.45199700e-02f, 2.43079618e-01f, 8.69815890e-03f, -8.03483725e-02f,
  1.75479725e-01f, -9.22081396e-02f, 2.25512311e-02f, 4.73364629e-02f, 3.58440802e-02f, -2.10935995e-02f, -7.50535401e-03f, -8.82272646e-02f, 1.21156432e-01f, -2.43063853e-03f,
  2.82074302e-01f, 4.83307242e-02f, 7.22237378e-02f, -4.12393622e-02f, 1.98931485e-01f, 2.07120389e-01f, -2.40034923e-01f, 3.42681520e-02f, -9.04802456e-02f, 1.31233081e-01f,
  2.73415968e-02f, 9.37224701e-02f, 6.92968592e-02f, 4.90148701e-02f, -1.30039006e-01f, 5.75223640e-02f, -4.01016176e-02f, -1.90720744e-02f, 1.07237995e-01f, 3.04210991e-01f,
  -1.87157199e-01f, 2.91625619e-01f, -4.02738228e-02f, 1.47642614e-02f, 1.71870038e-01f, -7.17477202e-02f, 3.38683054e-02f, 2.00009406e-01f, -2.07610101e-01f, 5.45757823e-02f,
  -3.04317772e-01f, 2.88304742e-02f, 4.91502136e-02f, -1.25765830e-01f, 6.11900836e-02f, 6.81599155e-02f, 1.67424008e-01f, -3.15019280e-01f, 1.60972908e-01f, -1.46243021e-01f,
  1.23082716e-02f, 2.51899231e-02f, -2.01170623e-01f, 2.17978314e-01f, 2.21113518e-01f, 1.05353864e-02f, -2.42642626e-01f, 1.87582104e-03f, 3.89807634e-02f, -3.22408741e-03f,
  -2.73303483e-02f, 2.25688607e-01f, 6.63071722e-02f, 1.67607553e-02f, 1.53906718e-01f, -1.30022705e-01f, 9.90116596e-02f, 1.72838885e-02f, 2.08039328e-01f, 3.11064497e-02f,
  -2.49683559e-02f, 1.95171401e-01f, 5.40545695e-02f, 2.49550343e-01f, -6.76942896e-03f, 8.85111168e-02f, -2.46031806e-02f, 8.00979696e-03f, -1.66439772e-01f, 2.98518270e-01f,
  1.69098035e-01f, -1.53056145e-01f, 1.52480304e-01f, -7.46243522e-02f, 1.85070381e-01f, -1.61584988e-01f, 1.82701237e-02f, 2.33189296e-03f, 9.47032869e-02f, 1.54071957e-01f,
  -1.52058527e-01f, 2.25053132e-01f, 1.60211891e-01f, 2.79618669e-02f, -6.94725066e-02f, 7.51010850e-02f, -1.06174670e-01f, -1.15497977e-01f, 2.04317868e-01f, -7.90450573e-02f,
  1.42185643e-01f, 2.47460887e-01f, 1.97948620e-01f, 1.48236454e-01f, -6.81618378e-02f, -1.30833164e-02f, -4.67562750e-02f, -7.20358565e-02f, -3.78533095e-01f, 1.75182089e-01f,
  1.35403588e-01f, -2.16161132e-01f, 2.64657944e-01f, 2.03755453e-01f, 1.73119202e-01f, -1.52588964e-01f, 8.67592022e-02f, 1.44740775e-01f, -2.48138979e-02f, 1.04109712e-01f,
  -2.61646304e-02f, -2.59622067e-01f, 7.38037154e-02f, 1.27615303e-01f, 3.12389974e-02f, 3.85223627e-01f, 1.37674296e-02f, -1.32203087e-01f, 1.75801903e-01f, -1.39208823e-01f,
  1.19198568e-01f, 2.57480294e-01f, 2.23790944e-01f, 2.36664221e-01f, 1.94115222e-01f, -1.95084959e-02f, 5.70799708e-02f, -3.67897451e-02f, -1.04488686e-01f, -2.79228203e-02f,
  -2.54299771e-02f, 3.47326487e-01f, 5.81693575e-02f, -2.39157770e-02f, 3.04696739e-01f, -1.94183305e-01f, 2.76588090e-02f, -1.02553040e-01f, -2.84732580e-01f, 1.01498790e-01f,
  8.89173523e-02f, 1.45694897e-01f, 2.32792690e-01f, 4.82143790e-01f, 1.11342415e-01f, -8.07297677e-02f, 2.32847109e-02f, -1.09494284e-01f, -5.42392302e-03f, -2.12225482e-01f,
  -1.68674484e-01f, 2.31759816e-01f, -5.94703294e-02f, 2.70875007e-01f, 2.13617235e-02f, 9.14955363e-02f, 2.42610529e-01f, 8.04329365e-02f, -1.59466028e-01f, 1.16490826e-01f,
  -2.31107369e-01f, -1.45555317e-01f, -6.84929118e-02f, 4.87597957e-02f, 3.28041464e-01f, 1.02274254e-01f, -4.85080406e-02f, -2.82121301e-02f, 2.33549979e-02f, -1.97194107e-02f,
  1.39776438e-01f, -1.19002149e-01f, 6.09926060e-02f, 7.74134621e-02f, 3.13783325e-02f, 1.46037713e-02f, 3.69366519e-02f, 7.62330666e-02f, 1.91127226e-01f, 1.67956762e-02f,
  -1.64148390e-01f, 1.21982567e-01f, -1.27128065e-01f, 1.89952642e-01f, -8.62399191e-02f, -1.80697501e-01f, -2.76979417e-01f, 1.51173268e-02f, -9.11140665e-02f, 3.98286246e-02f,
  4.49848687e-03f, -8.64651948e-02f, 1.43304225e-02f, 2.13142484e-01f, 7.64390156e-02f, 1.26670420e-01f, -1.04789831e-01f, 7.02184662e-02f, -6.22715941e-03f, 3.59122306e-02f,
  -1.47960648e-01f, 2.71811094e-02f, 1.96833655e-01f, -7.74526820e-02f, -1.61939282e-02f, 1.33169606e-01f, 1.03496850e-01f, -9.87696946e-02f, -2.93177247e-01f, 1.44072045e-02f,
  -1.35233074e-01f, 1.45127058e-01f, 1.30168274e-01f, 8.66560712e-02f, 1.43351510e-01f, -5.45369685e-02f, -1.28278136e-01f, 1.43683493e-01f, 4.98105830e-04f, -1.68851331e-01f,
  1.84738994e-01f, -3.02450545e-02f, -6.00301586e-02f, 9.01376531e-02f, -1.90430105e-01f, 5.35499044e-02f, 1.23822100e-01f, -1.84012741e-01f, 5.37066646e-02f, 8.74916315e-02f,
  -2.97706872e-01f, -1.45380422e-01f, -1.35356531e-01f, -1.33709190e-03f, -2.84422133e-02f, 2.05556273e-01f, 4.68623377e-02f, -9.45040360e-02f, -8.63412544e-02f, 1.79332167e-01f,
  2.93676014e-04f, 1.95734128e-01f, 2.81104863e-01f, -1.22198299e-01f, -3.37687910e-01f, 1.10391743e-01f, -1.90238401e-01f, 3.99450287e-02f, 1.37874871e-01f, -2.63744444e-01f,
  -1.02363050e-01f, -1.04095370e-01f, -3.72682184e-01f, 1.41400725e-01f, -1.61784276e-01f, 3.31303962e-02f, -8.90458599e-02f, 6.16819561e-02f, 2.03059345e-01f, -1.77109048e-01f,
  -3.53844799e-02f, -1.69916347e-01f, -1.73807919e-01f, -7.07401037e-02f, 1.16402201e-01f, -3.19532067e-01f, 5.68739399e-02f, -2.40342602e-01f, 2.45740086e-01f, -1.45678073e-02f,
  2.56355703e-01f, -9.23751816e-02f, 1.27257090e-02f, 1.10401273e-01f, -2.35323399e-01f, -1.65365580e-02f, 6.21203296e-02f, 8.82587656e-02f, -1.22630354e-02f, 3.49580236e-02f,
  1.68537542e-01f, 2.88174581e-02f, 1.28245363e-02f, -1.99882522e-01f, -9.08212215e-02f, -6.25239462e-02f, 8.11396539e-02f, -1.06664762e-01f, 3.28009166e-02f, -4.33582738e-02f,
  -8.64308476e-02f, 1.34388223e-01f, -1.03005640e-01f, 1.39986992e-01f, -1.07540965e-01f, -1.43423080e-01f, 1.49936110e-01f, 6.73190728e-02f, 8.20630342e-02f, 4.17277329e-02f,
  8.33903700e-02f, 9.12816450e-02f, 1.77853003e-01f, 1.05194688e-01f, -1.79699391e-01f, 1.19996727e-01f, 1.23337228e-02f, -2.48160046e-02f, -1.32267252e-01f, -1.08502127e-01f,
  -8.97782445e-02f, 2.75045693e-01f, 2.41712686e-02f, -2.46961460e-01f, 1.30364706e-03f, -1.92579087e-02f, -7.28172734e-02f, -9.62118506e-02f, -1.54369950e-01f, -5.05749844e-02f,
  1.70249060e-01f, -1.33860514e-01f, -1.76254749e-01f, 1.94705769e-01f, -4.75777462e-02f, 2.31801972e-01f, 9.30715650e-02f, 1.14368446e-01f, -3.17496538e-01f, 5.71887419e-02f,
  1.70891076e-01f, 4.87431325e-02f, -4.79494222e-02f, -2.13036127e-02f, -5.37748337e-02f, 2.71014929e-01f, 1.61198229e-01f, 9.00190398e-02f, -1.73426077e-01f, 5.64038493e-02f,
  -6.51699752e-02f, -4.17802870e-01f, -2.77417004e-01f, 7.89931789e-02f, -2.40820557e-01f, -6.61251694e-02f, -6.51327819e-02f, -1.57891691e-01f, 2.70198792e-01f, -6.08549602e-02f,
  5.39741777e-02f, 4.34528738e-02f, -5.91093749e-02f, -1.17010579e-01f, -1.42745346e-01f, -5.38605228e-02f, 2.43789017e-01f, -9.79297161e-02f, 1.77704617e-01f, -9.49065760e-02f,
  -1.19585343e-01f, 6.02947827e-03f, -2.04462558e-01f, 1.45818368e-01f, 1.44411147e-01f, 4.41793352e-02f, 1.49780780e-01f, -1.38071440e-02f, -1.67282626e-01f, -2.37219650e-02f,
  2.25889459e-01f, 6.09256551e-02f, 1.29083514e-01f, 1.04742974e-01f, 8.93337205e-02f, -5.20006679e-02f, 1.72440484e-01f, -1.28028214e-01f, -1.51482678e-03f, 1.56426698e-01f,
  -7.10669393e-03f, 2.43247032e-01f, -1.98915955e-02f, -2.73782611e-01f, -2.42930844e-01f, -4.01109494e-02f, 7.03644706e-03f, -1.49720311e-01f, -1.65871978e-01f, 2.37337157e-01f,
  -1.08497582e-01f, -2.06583962e-01f, -1.32896714e-02f, 2.01700613e-01f, 2.39019677e-01f, 9.91863459e-02f, -1.26085311e-01f, -1.75129712e-01f, -1.35522723e-01f, 4.99107502e-03f,
  2.79441662e-02f, 2.50176221e-01f, -1.06180820e-03f, 9.88908336e-02f, -9.47577283e-02f, 3.46222557e-02f, 1.77332133e-01f, 1.00750163e-01f, 1.30529910e-01f, -8.88403058e-02f,
  -1.15412846e-01f, 1.23287357e-01f, 5.55758402e-02f, 7.36466795e-02f, 2.48062879e-01f, -2.43359447e-01f, 2.12899163e-01f, 3.78572717e-02f, -1.05459638e-01f, 5.29566184e-02f,
  7.06636254e-03f, 5.75202145e-02f, 9.96496007e-02f, 1.61560755e-02f, 1.59539744e-01f, -1.85858667e-01f, 8.71514976e-02f, -2.12573946e-01f, -1.60123780e-01f, -2.62553751e-01f,
  1.42368367e-02f, -2.57803470e-01f, 6.63573816e-02f, -4.79514785e-02f, -1.21243648e-01f, 2.58927584e-01f, 1.07765146e-01f, -3.30618650e-01f, 5.22509031e-02f, -2.28500918e-01f,
  1.27640471e-01f, 2.07398161e-01f, 5.20575680e-02f, 2.88608640e-01f, 1.82048842e-01f, 2.56646471e-03f, -1.85573436e-02f, 4.84258868e-03f, 7.65301958e-02f, -1.18280329e-01f,
  1.97510585e-01f, 9.33488756e-02f, -3.97946276e-02f, -1.12338707e-01f, 7.02702478e-02f, -5.38641401e-02f, -3.43602821e-02f, -4.33520317e-01f, 6.96208999e-02f, -1.92615077e-01f,
  1.12618469e-01f, 1.81924164e-01f, 3.15154105e-01f, 7.18612075e-02f, 4.12981547e-02f, 2.81962872e-01f, -6.43020570e-02f, 8.58905241e-02f, 1.42284468e-01f, -1.64689466e-01f,
  -1.29813468e-02f, 2.24919349e-01f, 2.34671421e-02f, 1.21066272e-01f, 1.49061143e-01f, -2.17156157e-01f, 3.16702694e-01f, -6.01952486e-02f, -2.67303824e-01f, -6.91599846e-02f,
  2.67835129e-02f, -9.75513645e-03f, -1.02518551e-01f, -3.18197720e-02f, 1.89158648e-01f, 3.71872894e-02f, -2.05962151e-01f, -9.89668146e-02f, 1.71187803e-01f, -1.30164862e-01f,
  6.13226965e-02f, 1.09474458e-01f, -2.40358841e-02f, 5.17540351e-02f, 1.13842465e-01f, -5.77604920e-02f, 3.24691795e-02f, 1.25436291e-01f, 4.60373223e-01f, -1.95080966e-01f,
  -2.33644992e-01f, -9.53154266e-02f, 1.23368669e-03f, 1.15651682e-01f, 6.76142573e-02f, -2.55128592e-01f, -4.36298512e-02f, 4.45154533e-02f, -6.34123534e-02f, 3.05547625e-01f,
  -3.61685336e-01f, -3.02376270e-01f, 1.71367288e-01f, 6.97023347e-02f, 2.64317878e-02f, -4.65730578e-03f, 1.68934166e-01f, 1.47574261e-01f, -1.90360069e-01f, 4.25257683e-02f,
  -8.81796256e-02f, 2.16083571e-01f, -1.05644181e-01f, 3.64928544e-02f, 2.29006782e-01f, -1.90265141e-02f, -1.38157174e-01f, -8.87322053e-02f, 2.29377702e-01f, -1.57333821e-01f,
  -1.74374925e-03f, 2.03373462e-01f, -2.42623016e-01f, 3.41830194e-01f, 9.26831290e-02f, 1.61367610e-01f, 1.28345311e-01f, -4.87032533e-02f, 8.65482688e-02f, 1.68520749e-01f,
  -1.42866522e-01f, 1.13692179e-01f, 7.47052282e-02f, 2.56455928e-01f, 1.71505846e-02f, -2.15453774e-01f, 2.54765034e-01f, -1.62628651e-01f, 1.68686375e-01f, -5.61726131e-02f,
  -2.67823553e-03f, -1.82006657e-01f, -3.97697575e-02f, 1.80090070e-01f, -1.27418801e-01f, 1.38471276e-01f, 8.48179087e-02f, 2.59833097e-01f, -3.12797815e-01f, 2.57137835e-01f,
  6.99406839e-04f, 9.29762647e-02f, 7.24750161e-02f, 1.09628521e-01f, -5.43288849e-02f, 1.52249143e-01f, -1.49622232e-01f, -1.41873226e-01f, 9.94137824e-02f, 1.26045570e-01f,
  4.00871001e-02f, -5.53766713e-02f, -4.68355678e-02f, -3.69607545e-02f, -2.72659515e-03f, 2.18883425e-01f, -2.06088379e-01f, -4.67921011e-02f, -1.07309325e-02f, -2.61658579e-02f,
  1.81846142e-01f, -9.04595554e-02f, 2.10315385e-03f, 3.39132547e-02f, 1.42791852e-01f, 1.46130666e-01f, -1.28608793e-02f, 1.08788893e-01f, -4.40861098e-02f, 1.69329550e-02f,
  -2.12220356e-01f, -2.93457191e-02f, -1.75826494e-02f, 3.05556543e-02f, -7.52701238e-03f, 3.35922581e-03f, -2.04357624e-01f, -2.96155531e-02f, 1.18008265e-02f, -7.52956122e-02f,
  -1.24606907e-01f, 8.51418227e-02f, -8.48561153e-02f, -1.57454416e-01f, 9.63697731e-02f, -1.83092967e-01f, -2.13185549e-01f, 1.03461612e-02f, 2.32370924e-02f, -1.25043765e-01f,
  -1.31294891e-01f, -1.56513989e-01f, 1.29669338e-01f, -9.28500742e-02f, -3.47942524e-02f, -4.06032475e-03f, -2.28885651e-01f, -1.29168630e-01f, 2.64765900e-02f, -8.24424066e-03f,
  -3.89722921e-02f, -1.25097483e-01f, -2.42084600e-02f, -6.87006488e-02f, -6.21889606e-02f, -8.15643445e-02f, 5.04657775e-02f, -1.28633067e-01f, -1.46928772e-01f, 7.65587091e-02f,
  -2.00144663e-01f, -4.72784936e-02f, -1.44932181e-01f, -1.05216131e-01f, -2.12537289e-01f, 3.58222565e-03f, 6.42421693e-02f, -9.80079025e-02f, -1.09963469e-01f, 9.24642682e-02f,
  -5.48783205e-02f, 1.98197052e-01f, 2.78385490e-01f, 9.21341702e-02f, 2.01743022e-01f, -5.01932204e-02f, -1.75781712e-01f, 5.47188558e-02f, -1.22278169e-01f, 2.65723139e-01f,
  -2.78046876e-01f, 2.96472996e-01f, 1.86091047e-02f, -6.95927814e-02f, -1.89726815e-01f, -1.72688454e-01f, 6.97186664e-02f, 1.09840095e-01f, -3.86786908e-02f, 8.02290887e-02f,
  -8.56935792e-03f, 1.34670183e-01f, 1.92210928e-01f, 1.34271041e-01f, -6.60950392e-02f, 1.82843611e-01f, -3.76191646e-01f, 1.34902284e-01f, 1.69650182e-01f, -1.94979012e-01f,
  1.73764214e-01f, 9.23664719e-02f, -7.02698007e-02f, 9.44720954e-02f, 1.29309684e-01f, 7.54586086e-02f, -7.25583434e-02f, 9.94968489e-02f, 3.93002070e-02f, 1.72982067e-02f,
  -1.26343802e-01f, 3.32642533e-02f, -4.31516161e-03f, -2.23510325e-01f, 1.06740177e-01f, 1.37440175e-01f, -2.54750401e-01f, 3.78033482e-02f, 1.90848708e-02f, 1.03910817e-02f,
  -9.90854055e-02f, 2.31461763e-01f, 1.78009287e-01f, -7.65843391e-02f, 3.03309150e-02f, -2.18502641e-01f, -5.40956035e-02f, 1.77711472e-01f, 4.41122241e-02f, -1.01445995e-01f,
  3.30337062e-02f, -2.99115088e-02f, -2.05727324e-01f, 3.17579508e-01f, -1.03300348e-01f, 1.89336129e-02f, 3.48028362e-01f, 1.03984132e-01f, -7.88435042e-02f, 2.89357305e-01f,
  -1.81384549e-01f, 2.31816053e-01f, 5.95327467e-02f, 1.27988398e-01f, 3.27530414e-01f, -1.42701328e-01f, -1.06562711e-01f, 9.03274864e-02f, 1.06736356e-02f, -2.29551777e-01f,
  -5.36064841e-02f, 1.40785962e-01f, -1.77150100e-01f, -1.21355504e-02f, 1.23823537e-02f, 9.50483829e-02f, 4.45399173e-02f, 1.62813507e-04f, -7.99250230e-02f, -2.44649693e-01f,
  1.52965516e-01f, -6.09972104e-02f, 1.03821732e-01f, 2.81888656e-02f, 4.83851135e-02f, 5.22498460e-03f, 2.05085818e-02f, -9.89947170e-02f, -2.23531146e-02f, 7.67360479e-02f,
  1.93775315e-02f, -1.33346975e-01f, -2.28769392e-01f, 1.44219875e-01f, 1.34378061e-01f, -1.21681541e-01f, -2.67230630e-01f, 2.54748344e-01f, 2.39415735e-01f, 8.80507305e-02f,
  -1.86308101e-02f, -1.03876088e-02f, -2.51121998e-01f, -9.76830125e-02f, 2.50397921e-01f, 3.83202918e-02f, 1.33107722e-01f, -4.35651280e-02f, 1.86452195e-01f, -9.76030454e-02f,
  1.50203884e-01f, 2.85038557e-02f, 1.60671920e-01f, 1.48202851e-01f, -5.78554049e-02f, 1.20820329e-01f, -3.17184061e-01f, 1.77164555e-01f, -9.21866447e-02f, 1.54184178e-01f,
  1.18301421e-01f, 1.00692861e-01f, 1.04215518e-01f, 1.23825513e-01f, -4.10695039e-02f, -7.65164569e-02f, 3.07853281e-01f, -9.05479416e-02f, 3.46220285e-02f, 3.33327278e-02f,
  -7.69863054e-02f, -2.37947270e-01f, 1.99894100e-01f, -2.31407896e-01f, -5.63907214e-02f, 1.95065856e-01f, 1.10408820e-01f, 1.20580181e-01f, 1.35468721e-01f, 1.02063231e-01f,
  -4.28203195e-01f, -7.79017434e-02f, 1.93677545e-01f, -1.34693742e-01f, -2.52475351e-01f, 1.82362661e-01f, -1.03521347e-01f, 1.51997924e-01f, -1.18805714e-01f, 5.16401138e-03f,
  7.10588619e-02f, -2.73075342e-01f, -5.12098193e-01f, 1.28729269e-01f, 7.81568214e-02f, -3.12412292e-01f, 1.43573463e-01f, 1.56425029e-01f, 1.47434786e-01f, 1.30741661e-02f,
  -1.38253987e-01f, 1.93776861e-01f, 5.92745319e-02f, -2.18626574e-01f, 8.42037052e-02f, -1.55643255e-01f, 1.22959182e-01f, 1.10848704e-02f, 1.05139688e-01f, 9.36208293e-02f,
  -1.87344458e-02f, -1.22723028e-01f, -2.94884164e-02f, 3.66947018e-02f, -7.28300214e-02f, 1.72438025e-01f, 3.51198614e-02f, 1.24397658e-01f, 1.71555504e-01f, 1.84972778e-01f,
  -2.38598660e-01f, -4.80854651e-03f, 1.59857571e-01f, -1.32681348e-03f, 5.35334498e-02f, 2.77839333e-01f, 1.02827206e-01f, 6.53656647e-02f, 2.78653294e-01f, -3.05823982e-01f,
  2.77720898e-01f, -1.70549527e-01f, -1.70581251e-01f, -1.02560408e-01f, 2.75468975e-02f, -2.70580590e-01f, -1.48823494e-02f, -1.86642498e-01f, -5.30190766e-02f, -7.00189620e-02f,
  3.78156841e-01f, 4.31742072e-02f, -1.70218810e-01f, 6.13937005e-02f, -1.44477785e-01f, -1.53057784e-01f, 4.11965817e-01f, 5.74955605e-02f, 7.13312626e-03f, 2.40190372e-01f,
  -6.31011426e-02f, 1.36795118e-01f, -1.75762191e-01f, -5.43099083e-03f, 7.60847628e-02f, -8.59879181e-02f, -5.27545363e-02f, 1.78887367e-01f, 1.39559239e-01f, 5.37673309e-02f,
  6.65298775e-02f, 1.96041942e-01f, 1.89570099e-01f, 2.70640045e-01f, 1.09080330e-01f, -1.77927047e-01f, -1.26389250e-01f, 1.28142208e-01f, 2.39045471e-02f, 9.56113935e-02f,
  2.59411484e-01f, 1.96789682e-01f, -8.03228766e-02f, 8.79261345e-02f, 1.02491654e-01f, -6.62836581e-02f, -1.65056646e-01f, 1.09139487e-01f, -3.12727988e-02f, 2.42671087e-01f,
  5.13749719e-02f, -1.63441688e-01f, 1.96257040e-01f, -2.37913996e-01f, 2.06459299e-01f, 1.80180632e-02f, 2.18212847e-02f, 2.90964633e-01f, 1.31485611e-01f, 1.86693788e-01f,
  -1.47600308e-01f, 1.36025831e-01f, 2.21430361e-01f, 1.87154368e-01f, 1.67229876e-01f, -9.39672366e-02f, 3.59132290e-02f, -2.35425919e-01f, 5.49329072e-02f, 2.53704429e-01f,
  1.89967498e-01f, -2.59990871e-01f, -1.41614318e-01f, -1.53981566e-01f, -2.77935527e-04f, 5.64181805e-02f, 8.95945430e-02f, 3.47999364e-01f, 7.68907964e-02f, -1.49049563e-02f,
  6.88571599e-04f, -1.49967074e-01f, -1.10982485e-01f, 9.41808298e-02f, -6.32520691e-02f, -1.94447830e-01f, -2.00749487e-02f, 1.49421945e-01f, 8.43178630e-02f, 1.57309204e-01f,
  -3.75196338e-02f, -5.05344458e-02f, 1.73861850e-02f, 5.04154265e-02f, 5.37443869e-02f, -1.43472552e-02f, 1.72563791e-01f, -1.60670429e-02f, -2.67978430e-01f, 3.89211684e-01f,
  -1.54381946e-01f, 3.68773751e-02f, -8.36528912e-02f, -9.84794367e-03f, 4.09631088e-04f, 1.16334602e-01f, 1.01230815e-01f, 6.93496689e-02f, -2.98577428e-01f, -5.37324473e-02f,
  8.03515548e-04f, -2.90402956e-02f, 1.97220091e-02f, -1.31403923e-01f, -3.27729098e-02f, 3.38618620e-03f, -3.84095050e-02f, 1.73772782e-01f, -1.54625431e-01f, -6.47154003e-02f,
  -9.90890563e-02f, 3.14523466e-02f, 3.17322686e-02f, 2.33417511e-01f, 9.95203620e-04f, -1.03009380e-01f, 2.09807396e-01f, 4.86198887e-02f, 2.01159835e-01f, 2.56470442e-01f,
  -3.71639989e-02f, 6.95627704e-02f, 1.69273764e-01f, 1.31466299e-01f, 6.26239404e-02f, -1.09289579e-01f, -3.24384958e-01f, -1.42220050e-01f, 8.52593366e-05f, -1.24305151e-01f,
  -2.93426663e-01f, 9.41752568e-02f, 2.18206882e-01f, -4.11492676e-01f, 6.05402961e-02f, 6.84831738e-02f, -1.87649414e-01f, 1.20437948e-03f, -2.98843570e-02f, -5.07061444e-02f,
  -2.13781446e-01f, 2.70475507e-01f, 9.91327912e-02f, -1.01592176e-01f, 1.88157499e-01f, 3.27096740e-03f, 1.45119518e-01f, -8.16734210e-02f, -1.32065371e-01f, -5.52798435e-02f,
  3.30605470e-02f, -3.31840776e-02f, -1.06658958e-01f, -4.96113934e-02f, -1.65574759e-01f, 4.52334769e-02f, 4.85984348e-02f, 1.60783663e-01f, 1.45422161e-01f, 1.99539810e-01f,
  -1.91742569e-01f, 1.54574467e-02f, -4.79248390e-02f, 4.94112745e-02f, -1.24843195e-01f, -4.89035696e-02f, -4.32692356e-02f, 1.54129058e-01f, -1.74623072e-01f, -4.41158563e-02f,
  -5.61759882e-02f, -1.50040397e-02f, -5.02014086e-02f, -3.37954536e-02f, -1.44825459e-01f, -5.64266741e-02f, 2.79512852e-01f, 7.90539756e-02f, 4.26342860e-02f, 1.02682613e-01f,
  -6.12367541e-02f, 1.33091092e-01f, 7.87463635e-02f, -5.26124299e-01f, -1.31741419e-01f, -1.10234156e-01f, 8.62340778e-02f, 1.36285722e-01f, 2.50718355e-01f, -8.58853012e-02f,
  7.55434260e-02f, 5.53260706e-02f, -2.60582715e-02f, 6.32476881e-02f, 2.57583082e-01f, 1.04078166e-01f, -9.37380013e-04f, 4.21106741e-02f, 1.27613604e-01f, 9.65975896e-02f,
  1.56579778e-01f, -1.42780766e-01f, 6.78524673e-02f, 6.11129850e-02f, 1.14059806e-01f, -4.84491400e-02f, 1.91288069e-01f, 3.09974868e-02f, 4.57883775e-02f, 2.26814955e-01f,
  3.15536261e-02f, -7.59507902e-03f, -1.15442455e-01f, 6.89648278e-03f, 3.20603549e-01f, 1.10750601e-01f, 4.85320017e-02f, -1.36060908e-01f, -5.18932566e-02f, 8.92759562e-02f,
  3.28820162e-02f, -1.87176019e-01f, 1.82728935e-02f, 4.54059020e-02f, -1.47951886e-01f, -2.37758588e-02f, 1.60158426e-01f, -1.83093790e-02f, 1.03642240e-01f, 3.98360193e-01f,
  4.38372679e-02f, -2.11354103e-02f, 7.69268125e-02f, 6.75991327e-02f, -4.54648808e-02f, -1.68816939e-01f, -7.25241229e-02f, -1.07650265e-01f, 1.18359767e-01f, -1.73703671e-01f,
  6.71512261e-02f, 1.26417875e-01f, 1.69638991e-01f, -1.66161403e-01f, 2.22706422e-02f, 4.84013446e-02f, -2.09913418e-01f, 1.97314844e-01f, -2.50474602e-01f, 2.34734192e-01f,
  -1.81055032e-02f, 7.09703341e-02f, 1.76875219e-02f, 3.38965714e-01f, 1.30608946e-01f, -8.86875615e-02f, -2.10155338e-01f, 7.11355405e-03f, -1.37397662e-01f, -2.81433612e-01f,
  -8.00103769e-02f, 1.65696070e-01f, -2.73124278e-01f, 2.77088821e-01f, -1.48323625e-01f, 1.19249903e-01f, 2.00339168e-01f, -3.04784980e-02f, -1.29983902e-01f, 1.48207337e-01f,
  -5.47830537e-02f, 5.55534521e-03f, 1.88487142e-01f, -2.24862948e-01f, 1.54952154e-01f, 5.89102805e-02f, -3.98425944e-02f, 7.35165700e-02f, -2.92273492e-01f, -8.92917961e-02f,
  1.21568933e-01f, -2.45915979e-01f, 4.52606417e-02f, 2.49589995e-01f, 1.91326812e-01f, 8.87180269e-02f, 1.83826104e-01f, 2.55375840e-02f, -1.60200149e-01f, -9.88810584e-02f,
  2.02180430e-01f, 1.31518558e-01f, 2.25733459e-01f, 2.95729768e-02f, 1.05606884e-01f, 5.15256487e-02f, 7.40019009e-02f, 1.38632178e-01f, -6.46565259e-02f, -9.03123170e-02f,
  -1.33133993e-01f, 1.60138994e-01f, 3.51095229e-01f, 1.85334980e-02f, -2.17194040e-03f, 4.03962463e-01f, 2.78966278e-02f, -1.52579397e-01f, 1.22418500e-01f, -2.16748595e-01f,
  -3.96038964e-02f, -1.51190951e-01f, -2.36567259e-01f, -4.92313579e-02f, 1.26987040e-01f, -2.47312993e-01f, 2.13836923e-01f, -3.14887576e-02f, 2.55579323e-01f, -8.17096233e-02f,
  6.53253496e-02f, -4.10150960e-02f, 7.53254518e-02f, -1.53520526e-02f, -7.00547397e-02f, 1.91539690e-01f, -7.29069710e-02f, 1.99402664e-02f, -2.16617987e-01f, -1.43009389e-03f,
  -2.77073942e-02f, 9.06803906e-02f, 3.83902714e-02f, 1.31255314e-01f, -6.94485903e-02f, 1.24077015e-01f, -1.69107959e-01f, 5.93745261e-02f, 1.82812765e-01f, 1.59532234e-01f,
  -1.56517461e-01f, -4.90422547e-02f, 1.94916055e-02f, 1.01447031e-01f, -1.42559351e-03f, -2.82008320e-01f, -2.12903574e-01f, 1.29378080e-01f, 9.96960253e-02f, 7.58364350e-02f,
  -5.81496470e-02f, 1.21848896e-01f, -2.58302420e-01f, -2.58976281e-01f, 1.04709111e-01f, 6.58644363e-02f, -2.85080910e-01f, 2.93929964e-01f, -3.38056654e-01f, -5.83965778e-02f,
  -7.65384212e-02f, -1.42519236e-01f, 8.69535208e-02f, -7.74294585e-02f, -9.48449448e-02f, 2.18519904e-02f, 6.73801824e-02f, 1.56512439e-01f, 1.82114542e-01f, 1.60596877e-01f,
  2.09485944e-02f, -1.09908171e-01f, 3.75118181e-02f, -2.97462255e-01f, 2.49961153e-01f, -7.73614720e-02f, -2.61296242e-01f, -9.12746191e-02f, 7.44202584e-02f, -8.66283923e-02f,
  1.54321715e-01f, -1.02579035e-01f, -5.28767295e-02f, 1.10073730e-01f, 1.17001049e-02f, -9.24715400e-02f, 3.19664590e-02f, -6.81390241e-02f, -1.83876660e-02f, 9.62824374e-02f,
  1.69989958e-01f, 1.34808794e-01f, -8.88730139e-02f, -7.21116662e-02f, 9.09951553e-02f, -5.29218614e-02f, -1.09478928e-01f, 1.31378412e-01f, -4.46566604e-02f, -1.19274475e-01f,
  1.42442107e-01f, -4.03014943e-03f, -8.37441310e-02f, -3.60408947e-02f, -1.54582718e-02f, 5.14422450e-03f, 1.04540452e-01f, 1.50192082e-01f, 1.00195140e-01f, -2.70300746e-01f,
  -1.60247952e-01f, -2.60507371e-02f, 9.93715525e-02f, 1.56937912e-01f, -4.38606308e-04f, 1.46055311e-01f, -4.55230325e-02f, -1.39275908e-01f, -7.18718842e-02f, 5.67256063e-02f,
  -1.25352383e-01f, 1.55128568e-01f, -5.70407622e-02f, 1.28200039e-01f, -1.79286808e-01f, -9.79913920e-02f, 1.24988116e-01f, -3.87261733e-02f, 6.84791654e-02f, -1.69125460e-02f,
  -7.48161748e-02f, 5.49373291e-02f, 5.21739841e-01f, 1.81366935e-01f, 2.29282752e-01f, 3.00549597e-01f, -2.83959568e-01f, 2.23814026e-01f, 1.52802795e-01f, 1.55657187e-01f,
  2.66528219e-01f, -5.91882057e-02f, -6.18127221e-03f, -6.68603703e-02f, -1.96497694e-01f, -1.32095173e-01f, -7.10609779e-02f, -6.44301623e-02f, -5.49052805e-02f, 2.65291691e-01f,
  1.78185701e-01f, 2.57280648e-01f, -7.48677691e-03f, -1.00225054e-01f, 1.80188566e-02f, -2.98258334e-01f, 2.70741463e-01f, -2.08648950e-01f, 9.16807950e-02f, -5.71605265e-02f,
  -1.04602568e-01f, -1.54387295e-01f, 9.85844880e-02f, 2.58825682e-02f, -1.31560579e-01f, -2.08978608e-01f, -1.81618199e-01f, -2.05380335e-01f, -1.02172501e-01f, 9.18262675e-02f,
  1.18476488e-01f, 5.61860716e-03f, -2.72994071e-01f, 3.72513771e-01f, 1.15777545e-01f, 2.52835453e-02f, -6.18064636e-03f, -1.25747487e-01f, -2.05083620e-02f, 3.40430550e-02f,
  2.08310142e-01f, 1.29253581e-01f, 1.57504529e-01f, 2.48818714e-02f, 2.28649288e-01f, -9.32077877e-03f, 2.04102188e-01f, 4.70098816e-02f, 3.05588305e-01f, 1.36599064e-01f,
  3.17263268e-02f, -3.46487388e-02f, -2.46935397e-01f, 1.95217833e-01f, -3.25164124e-02f, -1.78613663e-01f, 1.46935761e-01f, 9.83113125e-02f, 5.90605848e-02f, -1.97955713e-01f,
  -1.32267401e-01f, 3.86996791e-02f, -2.42671892e-02f, -2.24184811e-01f, 1.34996951e-01f, 4.25201729e-02f, -1.08967885e-01f, -2.15629791e-03f, -9.28748548e-02f, 7.01712668e-02f,
  1.85043886e-01f, 6.27606213e-02f, -1.02907062e-01f, -1.04251258e-01f, 1.30986571e-01f, -4.93227780e-01f, -4.14286293e-02f, 2.09397525e-01f, -2.28272706e-01f, 3.45939510e-02f,
  1.20137349e-01f, -3.71897444e-02f, 3.81882228e-02f, -1.13874294e-01f, 4.57039028e-02f, -2.04148456e-01f, -9.84054618e-03f, -1.01994283e-01f, -1.13670848e-01f, -2.45138451e-01f,
  -1.17824420e-01f, -1.37200564e-01f, -7.14659691e-02f, 2.18263194e-01f, -2.03958675e-01f, 1.76220015e-01f, 2.45935947e-01f, 1.07119165e-01f, 1.73493877e-01f, -2.14403290e-02f,
  2.01036140e-01f, 7.32355937e-02f, -7.49370605e-02f, -2.74358392e-02f, 2.69473623e-02f, -2.25954682e-01f, 5.45908436e-02f, -7.16130361e-02f, 7.82684237e-02f, -5.70229962e-02f,
  -2.12566420e-01f, -1.03692167e-01f, 1.29207239e-01f, 2.81449184e-02f, -3.47760459e-03f, -3.61100994e-02f, 9.32166632e-03f, -1.05081409e-01f, -7.71375000e-02f, 7.70734325e-02f,
  -1.27956301e-01f, 1.94349468e-01f, -2.31917143e-01f, -2.66070724e-01f, 9.03447568e-02f, -4.87977676e-02f, -1.27530038e-01f, 3.90976407e-02f, -2.03322709e-01f, -1.00322835e-01f,
  1.18555650e-01f, -3.56869906e-01f, 2.64085233e-01f, 2.00388938e-01f, 3.42775166e-01f, 2.39001498e-01f, -2.44182065e-01f, -1.38101861e-01f, -6.12496249e-02f, -1.37391135e-01f,
  -3.10263157e-01f, 1.59564003e-01f, 8.41882676e-02f, 7.00559914e-02f, -2.97954977e-02f, -6.93199039e-02f, 4.73549664e-02f, -1.63252428e-01f, -1.39882043e-01f, -1.87548086e-01f,
  1.72366828e-01f, 9.68370400e-03f, -1.47270516e-01f, -1.07757878e-02f, 2.14773193e-01f, -1.63561478e-03f, 1.08955517e-01f, -3.63168791e-02f, -9.24616959e-03f, -2.57475004e-02f,
  -1.10758983e-01f, -2.46453881e-01f, 2.16990430e-02f, -1.07908279e-01f, 3.73773277e-01f, -7.47125521e-02f, -1.30547225e-01f, 6.08486310e-02f, -1.56664383e-02f, -2.24159993e-02f,
  1.63151640e-02f, -1.90252841e-01f, -2.00978518e-01f, 1.36406708e-03f, 2.34084889e-01f, -1.69333816e-01f, -2.44656175e-01f, 8.27146471e-02f, -4.89932075e-02f, 2.14510247e-01f,
  -2.12464109e-01f, -2.13576287e-01f, 1.15474001e-01f, -5.67884706e-02f, 2.75002141e-02f, 1.47064567e-01f, -6.82491735e-02f, -1.84315234e-01f, 2.81758249e-01f, -7.01559260e-02f,
  -5.68461753e-02f, -2.83531696e-01f, -1.48704171e-01f, -1.60525739e-01f, 3.36886905e-02f, 1.67030782e-01f, 4.29006703e-02f, 4.01130505e-03f, -2.40010276e-01f, 1.76476594e-02f,
  7.52279684e-02f, -2.91187197e-01f, 1.52514517e-01f, -6.60489649e-02f, -5.88983595e-02f, -1.22911654e-01f, -5.83130643e-02f, 1.59697458e-01f, -1.45581797e-01f, 4.07720096e-02f,
  2.78496832e-01f, -1.38753414e-01f, -1.48221374e-01f, -3.82136218e-02f, 1.42030278e-02f, -8.82251337e-02f, 1.64321035e-01f, 4.68800813e-02f, -4.72011790e-03f, -7.97838047e-02f,
  -2.56234705e-01f, -5.73627593e-04f, -1.03326038e-01f, -1.32003771e-02f, 5.43347746e-02f, -2.11168692e-01f, -2.68784255e-01f, 4.00016345e-02f, 7.23029822e-02f, 1.55703157e-01f,
  -1.08689070e-01f, 8.16821866e-03f, 3.90477590e-02f, -1.96880102e-01f, -2.39398256e-01f, 5.18714450e-03f, -2.29774982e-01f, 2.32411250e-01f, -1.98657826e-01f, -8.44519734e-02f,
  -3.16030324e-01f, -6.01358376e-02f, 4.60059457e-02f, -5.88181801e-02f, 6.83651343e-02f, -1.26148269e-01f, 3.44077833e-02f, -1.32896453e-01f, -5.90437837e-02f, -2.33474234e-03f,
  -6.67778105e-02f, 2.72542477e-01f, 2.18922839e-01f, -1.66443646e-01f, 2.70614713e-01f, -2.04965293e-01f, -1.01252444e-01f, -9.37606022e-02f, -3.23425978e-02f, -1.74345240e-01f,
  -5.82310483e-02f, 1.85802713e-01f, 7.71781206e-02f, 1.88311219e-01f, -6.75070100e-03f, -1.69555292e-01f, -1.05261341e-01f, -4.39820774e-02f, -2.62464076e-01f, -1.38961151e-01f,
  2.34843224e-01f, -1.37751866e-02f, -2.11231709e-02f, 1.31412730e-01f, -3.44524346e-02f, -2.06208471e-02f, -1.18521675e-01f, -4.71204892e-02f, 4.20207568e-02f, -9.99960527e-02f,
  -5.09787798e-01f, 1.73657298e-01f, 1.47337601e-01f, -3.51578370e-02f, 2.19801560e-01f, 2.13045239e-01f, 1.17787711e-01f, -5.28515652e-02f, 7.09238648e-02f, -9.90921482e-02f,
  2.50224210e-02f, -8.28463584e-02f, 1.31693587e-01f, -5.90288499e-03f, 1.59693077e-01f, 1.51524181e-02f, -1.92912340e-01f, 1.11599900e-01f, 2.85570696e-02f, -1.39250502e-01f,
  5.41422479e-02f, -1.03815041e-01f, 8.98869336e-02f, -1.04667069e-02f, -9.92322192e-02f, 1.87994719e-01f, 1.09455220e-01f, -8.95521268e-02f, 1.15686849e-01f, -1.79529682e-01f,
  -7.21688643e-02f, -1.19800515e-01f, -2.49703173e-02f, 1.52468801e-01f, 2.22258329e-01f, -1.55020356e-01f, 6.59373999e-02f, -1.21312514e-01f, -8.14473107e-02f, 7.26843998e-02f,
  4.09080945e-02f, 3.26694995e-01f, -1.12089654e-02f, -1.97569415e-01f, -7.95084909e-02f, -1.99512462e-03f, 2.39448473e-01f, -1.39513928e-02f, 1.79385021e-01f, -3.54636088e-02f,
  5.24343885e-02f, -1.96031868e-01f, -6.04573339e-02f, 1.63631812e-01f, -1.78709123e-02f, -1.04144894e-01f, -1.02918535e-01f, 4.21391390e-02f, -8.54678750e-02f, 2.87222445e-01f,
  1.47805363e-01f, 3.73039208e-02f, 1.88855886e-01f, 1.83628783e-01f, 8.93623568e-03f, -5.28370962e-02f, -4.72933762e-02f, 1.44425035e-01f, 1.90440133e-01f, 8.90728831e-02f,
  -7.71741569e-02f, 8.87994766e-02f, 4.99650799e-02f, -3.29634964e-01f, -2.37132926e-02f, 2.60626394e-02f, -1.32485079e-02f, -3.97704206e-02f, 3.10219061e-02f, -1.27875954e-01f,
  -1.09496579e-01f, -2.49948669e-02f, 3.29112321e-01f, 8.36679712e-02f, 5.96782751e-02f, -1.31407142e-01f, -2.54247993e-01f, 1.50118649e-01f, 1.55115515e-01f, 1.29529655e-01f,
  1.25561103e-01f, -9.90467221e-02f, 6.36569038e-02f, 1.69756621e-01f, -1.01233296e-01f, 4.64815684e-02f, 3.87531742e-02f, 3.17596309e-02f, 4.76358123e-02f, -4.58025970e-02f,
  1.30884767e-01f, -3.03442925e-01f, 1.68826178e-01f, -5.81205785e-02f, -2.14132532e-01f, -1.39648646e-01f, 3.12062055e-01f, -1.59713984e-01f, 2.41456285e-01f, 2.83938587e-01f,
  -1.83190256e-01f, 4.47603874e-02f, -8.40900168e-02f, 1.00468732e-02f, 5.16311415e-02f, 1.27634749e-01f, 1.61062479e-02f, -2.81834416e-02f, -1.60033982e-02f, 2.48007894e-01f,
  6.91134185e-02f, 6.18611276e-02f, 7.60963932e-02f, 3.63008119e-02f, -1.29760846e-01f, 8.90301820e-03f, -5.89517690e-02f, -2.74889022e-01f, -2.60590881e-01f, 1.12288617e-01f,
  2.58915037e-01f, -2.17044830e-01f, -2.15155613e-02f, 1.10341951e-01f, 1.56985864e-01f, -1.18568324e-01f, 4.03348207e-02f, -1.72120035e-01f, -1.77307595e-02f, 1.57592118e-01f,
  7.81608671e-02f, -1.23595707e-01f, 5.79667613e-02f, 2.81469613e-01f, -1.20401554e-01f, 2.06401169e-01f, -1.18082531e-01f, 7.04194512e-03f, 1.28459722e-01f, 2.88014799e-01f,
  6.98743016e-02f, 4.47167046e-02f, -7.84693062e-02f, -3.06665953e-02f, -5.85993342e-02f, 1.57251194e-01f, -2.68645406e-01f, -3.19107585e-02f, 1.20306157e-01f, 3.84056829e-02f,
  -3.68933752e-02f, -7.92872310e-02f, -5.90265505e-02f, 1.44988358e-01f, 4.55967970e-02f, 2.02754259e-01f, 3.79153825e-02f, -2.16759712e-01f, 3.57247055e-01f, -5.03582776e-01f,
  6.55887425e-02f, -2.03642976e-02f, -8.02167691e-03f, 1.18894733e-01f, -3.72688696e-02f, -2.75138132e-02f, -8.92650560e-02f, 2.18969509e-01f, 1.73343748e-01f, 3.30651365e-02f,
  4.22125719e-02f, -2.14483410e-01f, 3.81845050e-02f, -1.09553136e-01f, 3.72485101e-01f, -3.02857935e-01f, -1.18033528e-01f, -2.16900453e-01f, -2.63503790e-01f, -6.68795854e-02f,
  -2.84689188e-01f, 3.50239761e-02f, -2.60569453e-02f, 5.98679557e-02f, 4.10267673e-02f, -1.29319549e-01f, 2.01376919e-02f, 2.83194426e-02f, 2.00097710e-01f, -1.22707844e-01f,
  -2.05630243e-01f, 3.33994478e-01f, -2.87020151e-02f, 1.04188986e-01f, -1.90803595e-02f, -1.34042144e-01f, 6.62468746e-02f, -5.20584825e-03f, 1.52316138e-01f, -5.48540987e-02f,
  -7.65383840e-02f, -9.10275653e-02f, 1.26003459e-01f, 4.54007089e-02f, 2.11357072e-01f, -2.81257182e-01f, 2.38859460e-01f, 2.69925054e-02f, -2.00043321e-01f, 5.82990982e-02f,
  -1.33980393e-01f, -5.51353581e-02f, 2.60349780e-01f, -1.46762459e-02f, 1.55891523e-01f, 1.79698467e-01f, -7.85623789e-02f, -8.84145275e-02f, 9.11751091e-02f, -4.10821550e-02f,
  -1.41791636e-02f, 3.49029549e-03f, -2.63565838e-01f, -2.50944700e-02f, -4.86229919e-02f, 2.86552571e-02f, 4.60404903e-02f, -7.69870281e-02f, 1.72232449e-01f, 9.04131830e-02f,
  1.08611755e-01f, 1.64212212e-01f, -5.64715527e-02f, 2.00944945e-01f, 4.82647270e-02f, 2.26577252e-01f, 6.26820028e-02f, 5.60642965e-02f, 1.54380634e-01f, 1.64000064e-01f,
  -2.20463440e-01f, 4.76466790e-02f, 6.11184426e-02f, 4.50734124e-02f, -1.65082082e-01f, 3.45823951e-02f, 8.01777840e-03f, 2.43064798e-02f, 1.20808734e-02f, -8.60879421e-02f,
  -4.32999916e-02f, -2.46605948e-01f, 6.60445392e-02f, 1.41332567e-01f, -2.81562865e-01f, 1.19668126e-01f, 1.42266840e-01f, 2.87045240e-02f, -1.77334115e-01f, 1.05589211e-01f,
  -1.09272443e-01f, 7.47947767e-02f, -1.73280239e-01f, -7.74695650e-02f, -1.38804555e-01f, 1.04611620e-01f, -1.41205519e-01f, 1.13627091e-01f, 5.36397584e-02f, -4.26381938e-02f,
  7.56944120e-02f, -1.84156001e-01f, -8.03147331e-02f, -4.13097665e-02f, -2.67329197e-02f, 3.64712000e-01f, 8.05390477e-02f, -1.89315557e-01f, 1.30501941e-01f, -7.08883405e-02f,
  2.48674173e-02f, -8.42436850e-02f, -7.39758462e-02f, 7.97700137e-02f, 6.73721312e-03f, 1.04362499e-02f, 7.71995634e-02f, 1.27458140e-01f, 1.00814879e-01f, 2.44423687e-01f,
  -1.90698072e-01f, -1.02957614e-01f, -2.51540750e-01f, -1.22476622e-01f, 3.25876921e-02f, 8.00319761e-03f, -8.31786022e-02f, 2.44922966e-01f, 1.44829765e-01f, -5.12155294e-01f,
  -1.35142684e-01f, -1.06706284e-01f, 1.46304861e-01f, -9.04496089e-02f, 1.84163034e-01f, -2.57453382e-01f, -6.08402230e-02f, 1.51252210e-01f, 8.16667750e-02f, -1.84435740e-01f,
  2.40038522e-02f, -2.40116879e-01f, -2.51145829e-02f, -1.72357317e-02f, -2.74401724e-01f, -5.06153554e-02f, -1.42083377e-01f, -7.29107708e-02f, -4.85183969e-02f, 8.37785080e-02f,
  -1.67319411e-03f, 1.71308964e-01f, -1.16627775e-01f, 1.84555069e-01f, -2.02833176e-01f, 1.95275977e-01f, 9.51545835e-02f, 6.54479787e-02f, -1.62819192e-01f, -2.06566136e-02f,
  -6.72175288e-02f, 8.73820558e-02f, -2.23068818e-02f, -1.41884938e-01f, 6.77248687e-02f, -2.54650772e-01f, -2.09849983e-01f, -1.99541170e-02f, -5.94219677e-02f, 1.34751037e-01f,
  2.87568253e-02f, 1.30210295e-01f, 2.47132584e-01f, -1.68308869e-01f, -1.23276740e-01f, 7.96633437e-02f, 4.85964157e-02f, 1.72562569e-01f, -1.05412610e-01f, -1.35980800e-01f,
  2.57144511e-01f, -2.96007246e-01f, 1.38606831e-01f, 4.85281609e-02f, -8.14144388e-02f, -1.04073666e-01f, -2.08465174e-01f, -7.29116201e-02f, -1.28800437e-01f, 1.52194872e-01f,
  -3.59406322e-02f, 2.07504690e-01f, 2.59985831e-02f, -2.86666006e-01f, -1.05132245e-01f, 6.78509520e-03f, 1.01278722e-01f, -1.99430343e-02f, -1.70602471e-01f, -2.39525393e-01f,
  -8.95441175e-02f, 1.95402503e-01f, -6.30244687e-02f, -1.35388747e-02f, -1.83349401e-02f, -1.48792356e-01f, -2.08663926e-01f, -6.24055192e-02f, -1.46762803e-01f, -2.17161372e-01f,
  -2.72370726e-02f, -9.81879681e-02f, -3.50919545e-01f, 3.62970024e-01f, 1.07567653e-01f, 1.19797960e-01f, -7.15696588e-02f, -3.90683599e-02f, -1.78271979e-01f, 5.64945787e-02f,
  1.49883389e-01f, -1.79318607e-01f, -2.41654322e-01f, 1.44718587e-01f, 1.07485414e-01f, 5.61485589e-02f, -2.38898974e-02f, -2.05166712e-01f, 1.51997864e-01f, -1.23843171e-01f,
  -1.67139813e-01f, 1.04173519e-01f, -6.65000081e-02f, 1.92682490e-01f, -7.31576607e-02f, 7.49984980e-02f, 2.35033095e-01f, 1.77164853e-01f, -6.47412315e-02f, 1.59955770e-01f,
  -2.23409310e-01f, 2.93629616e-01f, -1.15890853e-01f, 5.72628900e-02f, 1.80491835e-01f, 4.86032814e-02f, -1.05486333e-01f, 3.05731088e-01f, 1.31911874e-01f, -8.57936442e-02f,
  -9.06313583e-02f, 1.64242789e-01f, -1.92457721e-01f, 1.51717812e-01f, 2.99299181e-01f, 1.57351077e-01f, 8.19266662e-02f, 3.29931080e-02f, -3.71733725e-01f, 1.44143999e-01f,
  -2.42858753e-02f, -1.99317291e-01f, 8.52100253e-02f, -2.42563412e-01f, 2.45411351e-01f, -5.12991399e-02f, -2.63042133e-02f, 1.19436666e-01f, 2.54811823e-01f, -2.99747825e-01f,
  -2.33210504e-01f, 8.46223384e-02f, -6.50975555e-02f, 1.35967672e-01f, -2.85395712e-01f, -1.36312529e-01f, -1.90220084e-02f, 1.04543241e-03f, 8.09813142e-02f, 3.46594192e-02f,
  -3.14272828e-02f, 3.40349860e-02f, -4.00688052e-01f, 1.34085463e-02f, 6.02782220e-02f, 4.88897562e-02f, 6.97512999e-02f, 8.92800931e-03f, 1.98349565e-01f, -7.72498548e-02f,
  1.18710652e-01f, -2.50448496e-03f, 2.05229282e-01f, 3.33374739e-02f, -2.35066265e-02f, 6.69364706e-02f, -1.25978753e-01f, 1.74999088e-01f, 1.66451093e-02f, -1.23591557e-01f,
  -3.29573900e-02f, 1.44307092e-01f, -3.69913951e-02f, 1.61871612e-01f, -3.86163704e-02f, 1.71874106e-01f, -1.19706884e-01f, -4.34406579e-01f, -8.13269317e-02f, -1.55552281e-02f,
  9.67410132e-02f, 2.77471125e-01f, 4.22938131e-02f, 1.88022956e-01f, 2.25613981e-01f, -7.82037377e-02f, -2.96589226e-01f, 7.63301253e-02f, 2.51788765e-01f, 5.32226898e-02f,
  -5.90905845e-02f, -5.83665743e-02f, -1.21752985e-01f, 6.64878488e-02f, 1.90844193e-01f, -3.13540548e-01f, -3.09405457e-02f, -1.39576882e-01f, 8.24127439e-03f, -1.12686850e-01f,
  -3.24483931e-01f, 1.17467515e-01f, 1.60462305e-01f, 1.16164319e-01f, 1.12432107e-01f, 8.78542438e-02f, -1.01505384e-01f, -6.04917742e-02f, 2.05261275e-01f, -1.11776300e-01f,
  -5.15637314e-03f, -1.63157284e-01f, 5.85075989e-02f, 9.40906852e-02f, 2.08614930e-03f, 2.11999938e-02f, -2.48588011e-01f, 1.93018146e-04f, -1.83657691e-01f, -2.41097957e-01f,
  1.43883348e-01f, 1.00581569e-03f, 2.09142506e-01f, 2.15692326e-01f, 1.27882391e-01f, -2.92957097e-01f, 2.01152980e-01f, -4.17720936e-02f, -2.02614471e-01f, -1.41518563e-01f,
  -1.01839855e-01f, -1.11802146e-01f, 1.69332191e-01f, 1.61201045e-01f, 1.80291593e-01f, 1.12444289e-01f, -9.48090293e-03f, 6.84091970e-02f, -2.97278911e-01f, -1.66875809e-01f,
  -1.02899686e-01f, 5.68555556e-02f, -8.97775665e-02f, 2.26484507e-01f, -1.06127053e-01f, -1.81375057e-01f, -8.69045109e-02f, -2.26742342e-01f, 4.00301903e-01f, 1.61523864e-01f,
  4.46590446e-02f, 1.44377068e-01f, -1.25337854e-01f, 2.43554935e-02f, 2.89851706e-02f, 3.80212754e-01f, 2.80489959e-02f, -2.14889586e-01f, -2.40010351e-01f, 9.00623575e-02f,
  3.18491571e-02f, 2.78084040e-01f, 2.67718017e-01f, -1.51204035e-01f, 2.34822780e-01f, 2.93510780e-02f, -2.10939184e-01f, 8.75988528e-02f, -1.94379613e-01f, 2.14292109e-01f,
  -4.48596328e-02f, 1.83465108e-01f, 1.35114655e-01f, 9.51135680e-02f, 8.21147040e-02f, -4.05328833e-02f, 2.14935422e-01f, -1.31480992e-01f, 1.39921978e-01f, 5.03471307e-02f,
  -3.74875441e-02f, -2.23168790e-01f, -1.88541505e-02f, -2.31821276e-02f, 3.11040521e-01f, 1.15071438e-01f, 5.52480519e-02f, 8.96736234e-02f, -7.14195371e-02f, 6.52106702e-02f,
  2.09733978e-01f, 1.74320310e-01f, 2.42005378e-01f, 5.89758456e-02f, -1.52556539e-01f, 2.31298864e-01f, 8.60523358e-02f, -5.28479777e-02f, 1.58868626e-01f, 6.28160611e-02f,
  2.28723258e-01f, 1.29715633e-02f, -1.73148155e-01f, 4.16667946e-02f, -4.27384526e-01f, -7.05437548e-03f, -1.91805676e-01f, 1.67678341e-01f, -3.89377661e-02f, 2.01249957e-01f,
  -5.84765244e-03f, -2.06117313e-02f, 2.64531761e-01f, -6.54798979e-03f, 4.14984906e-03f, -4.35280949e-02f, -1.45860136e-01f, 1.13117985e-01f, 1.03736028e-01f, 7.06005748e-03f,
  -2.82567680e-01f, -2.24149138e-01f, 6.61771894e-02f, 8.74761790e-02f, 1.22197103e-02f, -1.03053764e-01f, 1.90341860e-01f, 4.82429797e-03f, -3.11718509e-02f, 1.43083081e-01f,
  8.39586481e-02f, -2.38118306e-01f, -2.56882250e-01f, 3.83881405e-02f, 7.64627904e-02f, -5.04126400e-02f, -1.06068000e-01f, -1.07060177e-02f, -3.72443199e-01f, -1.27834201e-01f,
  2.06818804e-01f, 7.03168139e-02f, -4.15159464e-02f, 3.88502926e-02f, -2.34776452e-01f, -6.18966967e-02f, -4.65367287e-02f, -6.20016903e-02f, 1.22004397e-01f, 8.49613696e-02f,
  8.97413194e-02f, -6.64650463e-03f, -8.50777701e-03f, -1.03278205e-01f, 1.21635392e-01f, -1.76145479e-01f, -7.24553466e-02f, -1.06755920e-01f, -2.85056889e-01f, 3.26028943e-01f,
  -1.63652360e-01f, -1.25844166e-01f, 2.79801846e-01f, 1.06502213e-01f, 2.26161540e-01f, 1.77497894e-01f, -1.78392693e-01f, 1.01431653e-01f, -1.07656598e-01f, 1.10594280e-01f,
  5.58615252e-02f, 2.61761189e-01f, 8.63446668e-02f, -1.16608568e-01f, -4.59870994e-02f, 1.93745866e-01f, -1.54470485e-02f, 1.93777055e-01f, -1.56390637e-01f, 1.53179750e-01f,
  2.66625173e-02f, 9.09247808e-03f, 6.22072630e-03f, 1.96436077e-01f, -5.50562963e-02f, -2.93654919e-01f, -3.13525558e-01f, 1.37853131e-01f, 2.93072820e-01f, -6.62040263e-02f,
  1.41061330e-02f, -1.68109238e-01f, -3.67764663e-03f, -6.27470911e-02f, 1.36457058e-02f, 4.51157652e-02f, -9.45036039e-02f, -4.28808928e-02f, 1.46285981e-01f, 2.10986629e-01f,
  -1.49934307e-01f, -2.44314775e-01f, -1.06298283e-01f, -3.52743417e-02f, 4.68441546e-02f, -2.17568293e-01f, 1.59495488e-01f, -3.53970528e-01f, -2.12491468e-01f, -1.42575145e-01f,
  1.06388712e-02f, 3.08436126e-01f, 1.72257036e-01f, -3.02266300e-01f, -6.74147066e-03f, -2.16184929e-01f, 1.58439368e-01f, 1.64469495e-01f, 1.00946188e-01f, 8.30984414e-02f,
  8.70525092e-02f, 2.49586776e-01f, -2.10946470e-01f, -1.17792845e-01f, 5.33039421e-02f, -1.60741396e-02f, -1.42674208e-01f, -9.76403430e-02f, 1.17544174e-01f, 1.72645211e-01f,
  -4.65752855e-02f, -1.73565313e-01f, -2.71526486e-01f, 2.67868161e-01f, -9.47638825e-02f, 5.34477346e-02f, 1.15856826e-01f, -3.23018640e-01f, -1.41518205e-01f, 1.11769557e-01f,
  7.25736991e-02f, 3.61357518e-02f, -7.12452084e-02f, -3.73470783e-02f, -1.31219074e-01f, 2.18080461e-01f, -8.09534937e-02f, 1.65103853e-01f, 2.88134571e-02f, -2.00427845e-01f,
  -1.02838457e-01f, 1.28775373e-01f, -7.25492612e-02f, 1.21194758e-01f, 1.58281401e-01f, -3.44836712e-02f, -7.16020986e-02f, 1.90886199e-01f, -2.58068562e-01f, 1.64228976e-01f,
  -5.93450153e-03f, 1.18586794e-01f, 1.07891999e-01f, -1.87124852e-02f, -2.49240659e-02f, 6.87120762e-03f, -1.78116709e-01f, -1.21683329e-01f, -4.11370546e-02f, 6.69905841e-02f,
  1.63587946e-02f, 1.46826416e-01f, -3.17881480e-02f, 6.89392909e-02f, 7.51532018e-02f, 2.07867131e-01f, 1.47571608e-01f, 9.13744718e-02f, -1.85004413e-01f, -2.50178695e-01f,
  1.88633755e-01f, -1.24587948e-02f, 1.85782071e-02f, 1.51737869e-01f, -1.51277184e-02f, -1.82707869e-02f, -1.18390493e-01f, 6.73022121e-03f, 3.43115367e-02f, -8.16813633e-02f,
  -5.16689233e-02f, 5.19193262e-02f, 2.41413653e-01f, -5.29660359e-02f, 9.06495675e-02f, 1.08685888e-01f, 3.02418083e-01f, 6.17745556e-02f, -1.23058885e-01f, 1.53981283e-01f,
  -7.83606374e-04f, -8.61256272e-02f, -9.25040990e-03f, 1.13674719e-02f, -3.08910459e-01f, -1.06696405e-01f, 7.93867409e-02f, -7.94924796e-02f, 2.86894757e-02f, -1.15965523e-01f,
  1.87445581e-01f, -3.70932132e-01f, 3.49310972e-02f, 2.44182169e-01f, -3.97386029e-04f, 1.58312097e-02f, 2.94172496e-01f, 8.35825950e-02f, -2.75459558e-01f, 2.82280326e-01f,
  -3.56799513e-02f, -2.06830382e-01f, -3.80977392e-02f, 1.46542182e-02f, 2.11245745e-01f, -2.06253007e-01f, -3.38908844e-02f, 1.36112735e-01f, 8.91816989e-03f, 1.43470019e-01f,
  3.29557002e-01f, -3.25505733e-01f, -2.36315966e-01f, 7.51852756e-03f, -2.69870728e-01f, -3.24124098e-02f, 4.31966372e-02f, 1.97175756e-01f, 7.53600243e-03f, 1.32945031e-01f,
  -2.09755078e-01f, 3.07981465e-02f, -1.17918171e-01f, 1.35557353e-01f, -3.41939539e-01f, 1.22372001e-01f, -9.65057984e-02f, -7.39572868e-02f, -1.29841968e-01f, -1.23848550e-01f,
  1.62685722e-01f, -1.72507167e-01f, 4.09987457e-02f, 1.11234598e-01f, 1.81631684e-01f, 8.42347816e-02f, 1.92423269e-01f, -2.81962324e-02f, 6.08294904e-02f, -7.62961879e-02f,
  2.60191411e-01f, -7.61070326e-02f, -8.54272395e-02f, -4.35586683e-02f, 3.36152092e-02f, -1.51834503e-01f, 1.63647830e-01f, -3.57009262e-01f, -9.44265816e-03f, -7.49190524e-02f,
  1.36516377e-01f, 5.40881790e-02f, -8.98984969e-02f, 1.31974608e-01f, -2.14316964e-01f, -1.29382359e-02f, 1.35096535e-01f, 4.62279133e-02f, -2.86480784e-01f, 3.56729180e-02f,
  4.99226898e-02f, 1.06980108e-01f, -2.45800674e-01f, -5.26355319e-02f, 1.24747716e-01f, -1.80446193e-01f, -4.16160613e-01f, 2.45361686e-01f, 1.43952459e-01f, -2.29723036e-01f,
  -8.66147652e-02f, 1.65563822e-01f, 7.74307176e-02f, 7.10221007e-02f, -1.08055510e-01f, 1.41054451e-01f, 1.23358466e-01f, -1.48970768e-01f, -1.01678111e-01f, -1.43020907e-02f,
  1.32145107e-01f, -4.69953157e-02f, -1.01275161e-01f, 1.67779848e-01f, 1.79973632e-01f, -2.79470325e-01f, -2.44761221e-02f, 5.44947237e-02f, -9.79443267e-02f, 6.19969936e-03f,
  1.51158363e-01f, 3.25785168e-02f, 9.30780098e-02f, 4.81103919e-02f, -2.07759231e-01f, -3.42439190e-02f, 1.07096836e-01f, -1.52548403e-01f, 8.51483494e-02f, 1.74253061e-01f,
  1.01794992e-02f, -2.25305870e-01f, 9.84104127e-02f, 1.52719514e-02f, -3.12831551e-02f, -3.84624660e-01f, -1.63202852e-01f, -3.81095372e-02f, -2.90309191e-02f, 1.33519575e-01f,
  1.42398968e-01f, 1.61592647e-01f, 9.34940949e-02f, 7.98618868e-02f, -1.94484904e-01f, -1.07189663e-01f, 2.48994291e-01f, -4.18040603e-01f, -4.31530401e-02f, 1.12827979e-01f,
  -1.47729322e-01f, 2.45005697e-01f, 6.27342090e-02f, -1.86483711e-01f, 1.67466983e-01f, -2.91318744e-01f, -2.75402777e-02f, -1.42961428e-01f, 1.15117403e-02f, 5.72737493e-02f,
  7.57306367e-02f, -3.75428721e-02f, 1.36183694e-01f, 9.21661779e-02f, 1.77725479e-02f, -7.11910659e-03f, -3.27086747e-02f, 5.14177494e-02f, 8.41588601e-02f, -2.41363764e-01f,
  -4.21661176e-02f, 1.11033864e-01f, 1.00267284e-01f, 1.94828361e-02f, -1.45688295e-01f, 5.54453246e-02f, 1.41425189e-02f, -2.15364188e-01f, 8.07733014e-02f, 6.42403811e-02f,
  -3.33469696e-02f, 1.23589687e-01f, -2.46927232e-01f, 2.70962343e-02f, -1.78135142e-01f, 1.05732083e-01f, -1.53463986e-02f, -7.09517812e-03f, 2.97440365e-02f, -5.63160926e-02f,
  1.47077307e-01f, 1.91019967e-01f, 8.77429619e-02f, -2.09802035e-02f, 1.90013170e-01f, 2.28145227e-01f, -1.93960667e-01f, -1.55934706e-01f, 8.92349184e-02f, 2.60376841e-01f,
  -1.86751634e-01f, 2.87520319e-01f, 1.48261398e-01f, 9.10495445e-02f, 1.23416930e-02f, 5.37363533e-03f, -8.80697966e-02f, 8.60562772e-02f, 2.23640025e-01f, 2.61429489e-01f,
  -3.04697543e-01f, 4.42896605e-01f, 2.16593489e-01f, -6.91042393e-02f, 1.53716356e-01f, 2.18138024e-02f, 3.48977111e-02f, 1.55957803e-01f, -2.32772216e-01f, -3.70673910e-02f,
  -1.22269303e-01f, 2.88668394e-01f, -2.53470019e-02f, -9.75670815e-02f, 6.23287074e-02f, 7.90014118e-02f, 1.21373147e-01f, 2.35626698e-02f, 4.87948023e-02f, -2.02860132e-01f,
  1.23534150e-01f, 5.65172695e-02f, -1.41460106e-01f, -3.43375094e-02f, 7.57401958e-02f, 2.30959862e-01f, -2.79797584e-01f, 1.25818655e-01f, 6.04046322e-02f, 3.18132073e-01f,
  1.31059261e-02f, 1.99251235e-01f, 1.25194211e-02f, 2.27090269e-01f, -1.08701736e-01f, -7.97490776e-02f, 2.09148988e-01f, 2.93343961e-02f, -5.29912114e-03f, -2.70397821e-03f,
  -1.21890746e-01f, 8.19720849e-02f, -7.86702633e-02f, 3.81246209e-01f, -4.29240800e-02f, 2.22080667e-03f, -9.23858657e-02f, 1.75341845e-01f, -2.14193836e-01f, -8.81647691e-02f,
  1.15185715e-01f, -1.83161438e-01f, 3.41914177e-01f, -1.69532493e-01f, -2.47577894e-02f, -2.66776402e-02f, -8.45265687e-02f, 4.20102179e-02f, 2.19721124e-01f, -2.06405059e-01f,
  -5.67022972e-02f, 9.64528602e-03f, 2.10972935e-01f, -2.78275937e-01f, 2.09742591e-01f, -1.50463864e-01f, -3.41093801e-02f, -5.67676611e-02f, 2.31672838e-01f, 1.08509876e-01f,
  -7.07022548e-02f, 1.57893777e-01f, 1.41382888e-02f, 1.73551943e-02f, 1.51089638e-01f, -1.25831589e-01f, 1.36244847e-02f, 9.44383889e-02f, 1.17434978e-01f, 1.99983090e-01f,
  1.15208603e-01f, 3.74671184e-02f, -4.69541028e-02f, 2.28499435e-02f, 1.20551810e-01f, 1.94705695e-01f, 1.87135667e-01f, -2.81672090e-01f, -2.43948057e-01f, -5.36836684e-02f,
  7.38501027e-02f, 2.59992667e-02f, 8.99071470e-02f, -1.79894455e-03f, -2.47252584e-01f, -8.73373970e-02f, 1.00697249e-01f, -1.35078147e-01f, -1.52584851e-01f, 1.01266742e-01f,
  -2.42269218e-01f, 1.70112669e-01f, -1.79698482e-01f, -7.02485535e-03f, 1.39196128e-01f, -1.08889088e-01f, 1.02289394e-01f, -1.18428869e-02f, 1.04606628e-01f, 6.41842708e-02f,
  1.17315434e-01f, 7.30774105e-02f, -1.73442941e-02f, -7.18612373e-02f, 1.48009360e-01f, -2.40563713e-02f, -4.54925969e-02f, 5.85661978e-02f, -2.91164160e-01f, 1.51597857e-01f,
  5.24631105e-02f, -4.10224706e-01f, 8.37936401e-02f, -3.25334258e-02f, 2.37766892e-01f, -1.29333645e-01f, -3.64933610e-02f, -1.52239621e-01f, -1.58156857e-01f, 6.53303787e-02f,
  -3.00121933e-01f, 1.09177776e-01f, 2.06621870e-01f, -7.38246292e-02f, -9.55191627e-02f, 1.49587005e-01f, -2.90861249e-01f, 2.55582541e-01f, 1.35015488e-01f, 1.16425678e-01f,
  9.68988091e-02f, 1.68694779e-01f, -2.30266139e-01f, 3.06034327e-01f, 1.08549818e-01f, 1.27168782e-02f, 9.99135002e-02f, 1.33674115e-01f, 2.34294668e-01f, 3.15704942e-02f,
  -7.23771825e-02f, -1.52760640e-01f, -1.42536208e-01f, 2.87064072e-02f, 1.78934783e-01f, -7.98388720e-02f, 2.01383919e-01f, 9.56839100e-02f, -2.85459489e-01f, -2.10184619e-01f,
  7.07460642e-02f, -9.09332410e-02f, -2.99393058e-01f, 7.81746507e-02f, -2.95732707e-01f, 3.04355957e-02f, -1.58480704e-02f, -9.52945724e-02f, 3.59377041e-02f, -1.74273685e-01f,
  -6.07527941e-02f, 1.50085047e-01f, 2.28762582e-01f, 5.08235581e-02f, 2.45096937e-01f, 1.72823593e-01f, 2.30435997e-01f, 3.10199648e-01f, -2.51497924e-02f, 3.92626133e-03f,
  7.19391927e-02f, 5.02793044e-02f, 1.01475425e-01f, -1.23015516e-01f, -1.41974807e-01f, -1.28523067e-01f, -1.37603000e-01f, -6.76085651e-02f, -4.96604033e-02f, -3.87463681e-02f,
  1.80524737e-02f, 2.36490816e-01f, 1.04437470e-01f, 2.01139927e-01f, -2.80826926e-01f, 1.49411961e-01f, -4.23031971e-02f, -1.70035556e-01f, -1.90979466e-01f, 4.74954844e-02f,
  1.15257457e-01f, 7.54819065e-02f, -5.48680648e-02f, -6.72466010e-02f, -7.16666458e-03f, -2.06146166e-01f, -5.02294749e-02f, 8.77485946e-02f, 1.45197362e-01f, -4.29546125e-02f,
  -5.52727617e-02f, -2.16929018e-02f, 8.46076980e-02f, -7.62424842e-02f, -1.95836514e-01f, 1.56726018e-01f, -4.96911758e-04f, 7.56788775e-02f, -1.19972102e-01f, 7.55113736e-02f,
  -1.63806483e-01f, -1.42578423e-01f, 2.98023909e-01f, -2.43411250e-02f, 5.35424054e-03f, -1.44510463e-01f, -1.52597934e-01f, -6.14859462e-02f, 1.92630872e-01f, 2.38784850e-02f,
  -1.38986707e-01f, 3.48917991e-02f, 6.31665066e-02f, 2.58393884e-01f, -7.82786086e-02f, 2.13858828e-01f, -3.71783040e-02f, -3.90326977e-02f, 5.73173910e-02f, 6.72858208e-02f,
  1.33369967e-01f, 2.52137631e-01f, -1.95771113e-01f, 1.26650080e-01f, -6.40496463e-02f, -7.37830028e-02f, 1.57737404e-01f, -8.13570619e-02f, -8.12852681e-02f, 5.71232773e-02f,
  2.39781309e-02f, 4.59376164e-02f, 3.24111842e-02f, -1.15744015e-02f, -1.96409717e-01f, 2.14449316e-01f, 2.05377758e-01f, -1.00340366e-01f, -1.14239536e-01f, 7.05874413e-02f,
  -1.20710649e-01f, -1.14591323e-01f, 5.96967749e-02f, -1.56904534e-01f, 6.49149269e-02f, -7.11056516e-02f, -3.97962816e-02f, -2.45373085e-01f, -1.29244879e-01f, 3.27801937e-03f,
  -5.48844226e-02f, -1.25897437e-01f, -6.82701319e-02f, -1.84431329e-01f, -2.09292457e-01f, 1.40040845e-01f, 9.07344893e-02f, 6.49714610e-03f, 1.75170675e-01f, 2.24464998e-01f,
  1.86997399e-01f, 4.28256392e-02f, -8.90664160e-02f, -1.16034470e-01f, -1.47552580e-01f, -1.06365703e-01f, 2.39325956e-01f, -1.85506567e-01f, 1.65675029e-01f, -7.95312226e-02f,
  2.24447414e-01f, -8.92865583e-02f, 1.40765667e-01f, 3.19321291e-03f, 3.82608213e-02f, 4.03835587e-02f, 5.48142120e-02f, 2.17831507e-02f, -8.91683549e-02f, -1.27692288e-02f,
  -1.85009971e-01f, 2.71272752e-02f, 2.42389396e-01f, 4.83427234e-02f, 1.29437000e-01f, -1.48390740e-01f, -3.34595531e-01f, 4.72462438e-02f, 1.31584540e-01f, -9.12337005e-02f,
  2.14008018e-02f, 1.40423000e-01f, -2.14137554e-01f, 5.76897077e-02f, -2.50747055e-01f, -1.02645122e-01f, 4.42899717e-03f, 4.07914259e-03f, 9.15454477e-02f, 1.30219266e-01f,
  8.77849162e-02f, -2.24173307e-01f, -4.46277019e-03f, 1.34948492e-01f, -9.17030964e-03f, -1.75342813e-01f, -2.15188265e-02f, -1.46368027e-01f, 8.01888853e-02f, 2.07570866e-01f,
  6.42910227e-02f, -1.44913152e-01f, 1.41144842e-01f, -5.18408269e-02f, -3.05143297e-02f, 4.45434032e-03f, -8.55731294e-02f, -3.13527547e-02f, 1.00987546e-01f, 1.02190629e-01f,
  8.96638632e-02f, -1.85019372e-03f, 2.02509642e-01f, -1.27075538e-01f, 1.17348135e-01f, -9.54792649e-02f, 1.56023160e-01f, -2.61152357e-01f, -3.26431766e-02f, -3.11679870e-01f,
  -2.95925319e-01f, 2.59880554e-02f, 2.84127891e-01f, -9.30452254e-03f, 2.36557215e-01f, -1.69385880e-01f, -1.19653955e-01f, 1.26855904e-02f, 1.69308454e-01f, 1.01411335e-01f,
  2.52097368e-01f, -8.48321542e-02f, -1.04993597e-01f, 2.41513163e-01f, -7.85628408e-02f, -3.38268802e-02f, 1.99863613e-01f, 2.20065668e-01f, 5.02781421e-02f, -2.55838819e-02f,
  -1.36854406e-03f, -3.58902998e-02f, -9.48004946e-02f, -1.70486361e-01f, -8.32203776e-03f, -5.59926108e-02f, -4.79454659e-02f, 5.83497472e-02f, 8.37203935e-02f, -5.11908382e-02f,
  2.50039309e-01f, 2.36393586e-02f, 8.19208175e-02f, -1.23696133e-01f, 1.64388195e-01f, -4.23052698e-01f, -1.23810507e-01f, 2.27990940e-01f, 8.09309247e-04f, 2.17882529e-01f,
  4.33833599e-02f, 4.51668315e-02f, 2.60662019e-01f, -7.12894723e-02f, -2.47029569e-02f, -3.06980520e-01f, 1.76566973e-01f, -1.87252775e-01f, 1.11577399e-02f, -3.97747792e-02f,
  -4.40038368e-02f, 1.07148945e-01f, -1.28133222e-01f, 7.90608749e-02f, -7.06243291e-02f, 1.12024784e-01f, 2.08446234e-01f, -7.30593204e-02f, -4.76763546e-02f, 3.78718972e-02f,
  9.47044566e-02f, 8.84805098e-02f, -1.34674996e-01f, -2.13493600e-01f, 4.19938534e-01f, -4.82014567e-02f, 4.27896567e-02f, -5.18302694e-02f, 1.32324755e-01f, 9.01141837e-02f,
  -8.89539272e-02f, -9.55538824e-02f, 4.99129388e-03f, 1.88105460e-02f, 1.53776765e-01f, 8.81447941e-02f, -1.14067845e-01f, -4.66589537e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  1.90858647e-01f, 8.06602910e-02f, 1.39662132e-01f, 1.40544653e-01f, -7.15481341e-02f, 1.04906105e-01f, -3.86866778e-02f, 2.19984785e-01f, -3.22491564e-02f, -1.89606063e-02f,
  7.80653302e-03f, -2.25254707e-03f, -1.01091549e-01f, 2.57434279e-01f, -1.07690386e-01f, 2.17338905e-01f, -1.10720508e-01f, 1.73711434e-01f, -1.11322301e-02f, 1.52263135e-01f,
  1.97287291e-01f, -7.37829879e-03f, 1.11105658e-01f, 1.19487688e-01f, 1.00832388e-01f, 1.01538308e-01f, 3.32039297e-02f, 1.21375853e-02f, -7.34234229e-02f, -8.17709342e-02f,
  1.18347853e-02f, 1.66023850e-01f, -1.71339154e-01f, 1.07755028e-01f, 1.15453549e-01f, -8.76266360e-02f, 1.89023733e-01f, -9.75334272e-02f, 1.67455629e-01f, 2.71316946e-01f,
  1.45862415e-01f, -1.47649255e-02f, 1.54429615e-01f, 6.95443619e-03f, -2.52888780e-02f, 2.50406265e-01f, -1.68637455e-01f, 4.73569110e-02f, 8.84255543e-02f, 5.19688651e-02f,
  -8.78448114e-02f, 4.08205204e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.75939843e-01f, -1.97563857e-01f, -1.04669310e-01f, -1.99006826e-01f, -3.11508533e-02f, -3.20914894e-01f, 1.17864296e-01f, -1.93570375e-01f, 2.86365181e-01f, 2.09243968e-02f,
  -2.43269861e-01f, -1.28629595e-01f, -7.42699802e-02f, 3.15132827e-01f, 1.46020070e-01f, -1.32745519e-01f, 1.50285691e-01f, -1.56069055e-01f, 1.23933278e-01f, -1.36705324e-01f,
  4.78627952e-03f, -2.55910397e-01f, -1.11362226e-01f, 1.88975334e-01f, -1.46361709e-01f, -3.44817698e-01f, 1.80498213e-01f, -9.86037776e-02f, -1.18123300e-01f, 4.53408808e-02f,
  1.20765969e-01f, -2.65321583e-01f, -1.47980019e-01f, 2.87438128e-02f, -1.05973311e-01f, -3.45964134e-02f, 2.16631405e-03f, -2.88831115e-01f, 1.24907084e-01f, -1.18720345e-01f,
  1.37992213e-02f, 1.48376465e-01f, 1.56471565e-01f, -2.26290926e-01f, 5.12341894e-02f, -2.43580967e-01f, 4.59942430e-01f, 1.88623980e-01f, -4.54321474e-01f, -7.66334534e-02f,
  1.82082966e-01f, -4.78627086e-01f, -2.77721900e-02f, 2.78771482e-02f, -1.43117160e-01f, 4.13909443e-02f, -4.73095737e-02f, -2.89952278e-01f, 1.70930550e-01f, 1.24323115e-01f,
  -1.12166986e-01f, -1.21089302e-01f, 1.97556689e-01f, 1.06027260e-01f, -2.30972782e-01f, 3.81885111e-01f, -1.74962133e-01f, -9.71396640e-02f, 1.37190774e-01f, 5.69627769e-02f,
  -1.93430290e-01f, 2.92237669e-01f, -5.22028133e-02f, 8.47846549e-03f, 5.12824178e-01f, 3.12505275e-01f, -3.40738446e-01f, -2.89472509e-02f, 2.56371856e-01f, -6.40040636e-02f,
  -4.57370654e-02f, -3.89975570e-02f, -3.12340677e-01f, -2.46690139e-01f, -1.99765503e-01f, -9.38700810e-02f, 1.16010010e-02f, 9.25947800e-02f, -2.29173794e-01f, -1.32202774e-01f,
  -1.20515376e-01f, 1.78653762e-01f, 2.28523538e-02f, -7.49518722e-02f, -2.54752487e-01f, -1.72616944e-01f, -1.64250076e-01f, 7.24196956e-02f, 1.23215698e-01f, 5.59279099e-02f,
  -1.47997603e-01f, 8.09883028e-02f, 1.47611991e-01f, 5.76981828e-02f, -1.42026037e-01f, -2.55269498e-01f, 1.36992380e-01f, -3.54724407e-01f, -5.42016104e-02f, -1.07514955e-01f,
  -2.75869757e-01f, -1.64687097e-01f, 1.48226544e-01f, 9.02716815e-02f, 1.71301320e-01f, 7.57736936e-02f, 1.46228403e-01f, 8.92386585e-02f, -1.38552710e-01f, 1.99879538e-02f,
  1.76939685e-02f, -3.39562744e-01f, -9.00686830e-02f, 1.53806552e-01f, -8.63220766e-02f, 6.64392412e-02f, 2.06294209e-01f, 3.71046253e-02f, 1.10318333e-01f, -7.83311874e-02f,
  4.82160151e-02f, -5.89655787e-02f, -7.87451565e-02f, 1.36327788e-01f, -2.72940516e-01f, 3.68430138e-01f, -2.68997531e-02f, 1.88106105e-01f, 8.57719220e-03f, -1.24164879e-01f,
  2.08535835e-01f, -1.97305679e-01f, -3.06703180e-01f, 1.07679561e-01f, -2.41390765e-01f, 9.61848944e-02f, -4.31802958e-01f, 1.41979441e-01f, -1.35284424e-01f, -2.51113832e-01f,
  -9.54846516e-02f, -1.57454997e-01f, -1.91363201e-01f, 1.49273545e-01f, -1.98862970e-01f, 5.04144765e-02f, -2.42961511e-01f, -2.87513107e-01f, 1.23696774e-01f, -1.44965932e-01f,
  -1.76812753e-01f, -3.32090437e-01f, 7.50662237e-02f, 2.50776768e-01f, -2.02314779e-02f, -3.02377403e-01f, -1.37358740e-01f, -3.80874723e-01f, -2.02524349e-01f, -2.86307812e-01f,
  1.16142698e-01f, -1.73757002e-01f, -1.52505994e-01f, 2.05913156e-01f, -2.99691826e-01f, -1.70309290e-01f, -4.42967325e-01f, -2.30504066e-01f, 1.42526358e-01f, 4.65860032e-02f,
  -2.90164441e-01f, 1.48133531e-01f, -2.71043003e-01f, -4.05496150e-01f, -2.14524776e-01f, 1.79439977e-01f, -1.41258880e-01f, 2.12580651e-01f, 1.14252701e-01f, -2.35731453e-01f,
  -1.41728640e-01f, -5.70110790e-02f, -3.40262800e-02f, 8.75039473e-02f, -3.19043323e-02f, -1.99259579e-01f, -8.37328583e-02f, -1.32155254e-01f, 7.31172934e-02f, 4.38323021e-02f,
  1.81511492e-01f, -1.51527077e-02f, -1.38052225e-01f, -6.66328743e-02f, -3.47568274e-01f, -9.98202786e-02f, -3.08707774e-01f, 1.46144614e-01f, 2.42234506e-02f, -3.02349120e-01f,
  -8.99310112e-02f, 8.19432586e-02f, -2.57209033e-01f, 1.52465284e-01f, -9.93531644e-02f, -9.04629529e-02f, 2.57651895e-01f, -3.48133445e-01f, 1.05074167e-01f, -8.40517730e-02f,
  1.96759142e-02f, 1.43950552e-01f, 1.24894187e-01f, 1.20178849e-01f, 7.30366334e-02f, 1.03573471e-01f, -2.31264681e-01f, 9.83596891e-02f, 1.00795567e-01f, -1.43650562e-01f,
  -8.75401497e-02f, 1.92785427e-01f, 1.70914069e-01f, -2.16176063e-02f, -1.01396047e-01f, 1.29262015e-01f, -1.26475304e-01f, -2.76293624e-02f, -1.16059646e-01f, 5.74336536e-02f,
  -5.54823637e-01f, -2.67916352e-01f, 9.52789709e-02f, -3.05825084e-01f, -2.44474843e-01f, -3.19442928e-01f, -1.40322402e-01f, 1.20053217e-01f, 9.41779763e-02f, -1.33978590e-01f,
  1.19804718e-01f, 9.53225419e-02f, 5.73432930e-02f, -1.16697550e-01f, -2.48291083e-02f, 1.03303365e-01f, 1.69807374e-01f, -1.60109445e-01f, 1.47327650e-02f, 1.13607548e-01f,
  3.64734195e-02f, -1.08565623e-02f, -4.61630002e-02f, 1.58093441e-02f, -5.28114885e-02f, -3.12121272e-01f, -1.21501736e-01f, 2.64102638e-01f, -1.03210192e-02f, -1.64044425e-01f,
  -2.23594785e-01f, -1.74205571e-01f, 1.23597302e-01f, 3.10013886e-03f, 1.35159507e-01f, -1.87526606e-02f, 7.31645972e-02f, -7.03050643e-02f, -1.47203505e-01f, 2.71132998e-02f,
  -2.84076095e-01f, -1.30268648e-01f, 1.06986046e-01f, 6.55829683e-02f, -1.35426223e-01f, 1.18156075e-01f, 1.57109529e-01f, 2.09118918e-01f, 1.22473352e-01f, 1.32105947e-02f,
  -2.00488150e-01f, 1.71649419e-02f, 1.81743872e-05f, -1.19161829e-01f, -7.45616406e-02f, -2.08768427e-01f, 2.95473207e-02f, 1.48431391e-01f, 1.07772602e-02f, 9.60372314e-02f,
  -4.72455695e-02f, -5.37296906e-02f, -2.15423211e-01f, -4.56147455e-02f, 1.55219629e-01f, 1.59795642e-01f, -1.38338104e-01f, -2.27624904e-02f, -2.34284624e-01f, -2.56001204e-02f,
  1.27635852e-01f, 1.16012871e-01f, 5.12897335e-02f, 1.09766170e-01f, 8.22824091e-02f, 1.35858208e-01f, -9.74132400e-03f, -8.09079409e-02f, -8.36694613e-02f, -2.91109592e-01f,
  4.64035291e-03f, 2.27051787e-02f, 2.09561050e-01f, 8.13581198e-02f, -1.99582413e-01f, 1.83782980e-01f, -1.54619023e-01f, -4.14023072e-01f, 1.43420562e-01f, 3.44044238e-01f,
  -2.59587228e-01f, -4.19920497e-02f, -1.37293100e-01f, -4.22967784e-02f, -2.35429168e-01f, 1.14411518e-01f, -1.23478040e-01f, 2.49648333e-01f, 4.36768234e-02f, -3.63826931e-01f,
  2.20110323e-02f, -7.85311311e-03f, -8.86761770e-02f, 1.66195139e-01f, -1.91096961e-01f, -3.21834125e-02f, -4.01959270e-02f, 2.12804735e-01f, 1.06361084e-01f, 2.20462665e-01f,
  2.38013677e-02f, 1.04193740e-01f, -5.34336604e-02f, -5.96431941e-02f, -1.56927750e-01f, -2.29554176e-01f, -6.19012192e-02f, 1.80621952e-01f, -7.91604146e-02f, -1.24023974e-01f,
  -1.50453195e-01f, -1.21023349e-01f, -8.00373591e-03f, -6.91339448e-02f, -1.31344557e-01f, -7.04690516e-02f, -1.62518188e-01f, -2.10378677e-01f, 1.00403480e-01f, -2.21817315e-01f,
  1.51752859e-01f, -5.96941039e-02f, 1.72754824e-01f, 8.91141072e-02f, -3.25443745e-01f, 1.75236180e-01f, -2.50300109e-01f, 7.02994764e-02f, -1.64617077e-01f, -1.64928347e-01f,
  2.37786517e-01f, 5.37507646e-02f, 2.57682987e-02f, -1.47865294e-03f, 2.81287730e-02f, 2.22690940e-01f, 1.28653824e-01f, 1.35845184e-01f, 5.82494959e-02f, -6.06696345e-02f,
  -3.68064828e-03f, -2.55520102e-02f, -2.01080427e-01f, 5.41341119e-02f, -1.38093531e-01f, -2.63624340e-02f, 2.02085361e-01f, 2.36934841e-01f, -1.65435635e-02f, -2.03498870e-01f,
  -1.71218842e-01f, 1.14814557e-01f, -4.47095335e-01f, -2.20078111e-01f, 1.40563801e-01f, -8.88452232e-02f, -2.39540160e-01f, -1.24292545e-01f, -3.98359567e-01f, 1.04448721e-01f,
  -7.15011284e-02f, 7.84885660e-02f, 2.52113305e-02f, -1.97255492e-01f, -4.59917516e-01f, 9.62167457e-02f, 2.10370585e-01f, -4.77953911e-01f, 4.00278829e-02f, -1.09557003e-01f,
  1.20849889e-02f, 1.03606209e-02f, -5.40366992e-02f, -2.09799334e-02f, 1.22894412e-02f, -1.75020516e-01f, -1.64740548e-01f, -9.10527185e-02f, -1.27234399e-01f, 1.60148159e-01f,
  2.12882191e-01f, 1.95381761e-01f, 1.11971244e-01f, -1.85980588e-01f, -2.37203568e-01f, 1.26101017e-01f, -2.20005661e-01f, -9.19347256e-02f, -6.78507835e-02f, -1.46687970e-01f,
  -3.46447527e-01f, 1.52471006e-01f, -2.33438760e-01f, -1.68406308e-01f, 3.05847265e-02f, -2.52722710e-01f, -1.90560818e-01f, -2.36177787e-01f, -2.74231229e-02f, -1.68866470e-01f,
  1.85339153e-01f, 6.43272474e-02f, -1.74241677e-01f, 1.17213465e-02f, -1.57593738e-03f, -9.29403864e-03f, -1.10431723e-01f, -2.25393921e-01f, 1.22809276e-01f, -1.13125585e-01f,
  -5.42076290e-01f, -1.60223413e-02f, 9.67762545e-02f, -4.13414448e-01f, -2.36982629e-02f, -4.31437254e-01f, -8.89705643e-02f, 2.90503889e-01f, 1.22865677e-01f, 1.04505859e-01f,
  -1.49051785e-01f, -3.80293936e-01f, 2.55724311e-01f, -1.02555491e-01f, -9.53129381e-02f, -1.77325495e-02f, -2.95994669e-01f, -1.46208897e-01f, -1.98680460e-01f, 6.98536709e-02f,
  -8.56395811e-02f, 6.19695969e-02f, -2.98505370e-02f, -1.00180944e-02f, -2.47141346e-03f, -2.52121031e-01f, 1.21517949e-01f, -2.31819272e-01f, 1.77237272e-01f, -5.60466722e-02f,
  -1.14348926e-01f, 1.00216247e-01f, -1.41894683e-01f, -8.34146664e-02f, 8.35048258e-02f, -7.16627687e-02f, 6.45954087e-02f, 1.05499595e-01f, -2.85426915e-01f, 8.45412258e-03f,
  -1.68946553e-02f, -4.29021604e-02f, 2.14922652e-01f, -1.26149906e-02f, 2.27769822e-01f, -2.66549706e-01f, -4.05420596e-03f, -3.33454579e-01f, -3.45535189e-01f, 1.76874455e-02f,
  -2.22480103e-01f, 1.59259304e-01f, 2.00094700e-01f, -8.01014751e-02f, 4.28819358e-02f, -6.72530383e-02f, 1.56820542e-03f, -1.90882638e-01f, 5.18777847e-01f, -5.26676737e-02f,
  1.28852636e-01f, -2.42478289e-02f, 1.11832157e-01f, -5.47356963e-01f, -1.10123446e-02f, -2.25525513e-01f, -2.09923565e-01f, 1.64789230e-01f, 5.60708754e-02f, -3.87460291e-02f,
  -8.40787813e-02f, -2.59692948e-02f, 1.74661443e-01f, -1.58731773e-01f, 3.28650296e-01f, -1.86162710e-01f, 2.55362213e-01f, -1.93279088e-01f, 1.88140810e-01f, -3.73082191e-01f,
  1.59487173e-01f, -7.15163630e-03f, -1.38554089e-02f, 9.29587930e-02f, -2.50457264e-02f, -1.17794901e-01f, -2.06829846e-01f, -2.60345578e-01f, -2.27201045e-01f, 1.90257430e-01f,
  2.03576818e-01f, -2.89443225e-01f, -1.52755573e-01f, -2.61834830e-01f, -2.07273260e-01f, -3.14470053e-01f, 2.81752408e-01f, -3.05546582e-01f, -1.91954717e-01f, 1.34671992e-02f,
  1.09944835e-01f, -7.88346753e-02f, -6.76223710e-02f, -1.95531085e-01f, 2.72300150e-02f, -1.19062468e-01f, -4.94099408e-02f, 3.01555805e-02f, -2.59105731e-02f, -5.56914866e-01f,
  -1.53483972e-01f, -9.40749496e-02f, 2.04464912e-01f, 2.40760922e-01f, -4.27419394e-02f, 1.57238662e-01f, 8.60831067e-02f, -1.26936316e-01f, 1.80405870e-01f, 1.78516418e-01f,
  -3.52169275e-02f, 1.49049789e-01f, 9.51475725e-02f, 1.81944236e-01f, -2.21794590e-01f, 4.24884148e-02f, 3.28123868e-02f, -3.51398379e-01f, 1.60376787e-01f, 7.42766336e-02f,
  3.95257063e-02f, -5.02989173e-01f, 1.94052085e-01f, -1.41970426e-01f, -1.76418692e-01f, 1.52068168e-01f, 3.06001138e-02f, -1.87144905e-01f, -9.62562338e-02f, -3.90471607e-01f,
  -1.58213601e-01f, 4.47411872e-02f, 1.02338128e-01f, 1.20184474e-01f, -3.40501815e-01f, -4.21433151e-01f, 1.41871855e-01f, -2.14000151e-01f, 2.39604563e-01f, -2.65198231e-01f,
  1.53315276e-01f, 1.11874519e-02f, 1.53068766e-01f, -2.50887930e-01f, -5.21017276e-02f, -2.25779086e-01f, 1.45036682e-01f, -2.99640328e-01f, 2.81890179e-03f, 2.49073133e-02f,
  -2.20339060e-01f, 5.11348397e-02f, 5.53086251e-02f, -2.29371935e-01f, -2.81887323e-01f, -2.31689438e-01f, -4.56585407e-01f, -2.12880507e-01f, 2.27235584e-03f, -2.84339070e-01f,
  2.73302615e-01f, -3.89921367e-01f, -2.02784073e-02f, 1.63876995e-01f, 9.93899927e-02f, -1.74404994e-01f, -3.08908165e-01f, -1.45540327e-01f, 4.39222977e-02f, 2.83325016e-02f,
  -2.17053279e-01f, -4.22536880e-02f, -1.21580049e-01f, -6.66856691e-02f, -3.22174318e-02f, -4.66553234e-02f, -8.58498439e-02f, 6.18445128e-02f, 9.50348228e-02f, 2.10616570e-02f,
  -1.07538968e-01f, 2.10127026e-01f, 2.35201512e-03f, -1.52574047e-01f, -1.52641594e-01f, 9.76549461e-02f, 2.79265404e-01f, 5.09046242e-02f, 1.78423971e-01f, 2.14549929e-01f,
  -2.10960820e-01f, -1.68055430e-01f, 2.43247151e-01f, 1.11814953e-01f, 2.53086202e-02f, -2.91844517e-01f, -8.55954215e-02f, -1.15098588e-01f, 1.42340474e-02f, -2.75815576e-02f,
  -2.37570614e-01f, -1.54838830e-01f, -3.32195349e-02f, -1.56192079e-01f, 1.15363665e-01f, -2.55905181e-01f, -1.00839838e-01f, -1.16127782e-01f, -1.87412918e-01f, 2.67319411e-01f,
  -1.58679530e-01f, 1.42075434e-01f, -1.74748808e-01f, 2.48284593e-01f, 1.21038586e-01f, -2.64857262e-01f, 2.88772471e-02f, -1.72228158e-01f, -2.75931567e-01f, -6.22296594e-02f,
  -7.89722502e-02f, -3.55398089e-01f, 1.97422504e-01f, 1.22586563e-01f, -1.05710976e-01f, -9.37400982e-02f, -4.13167588e-02f, -7.47079998e-02f, -3.71025026e-01f, -2.14050457e-01f,
  8.53026658e-02f, 3.68234701e-02f, -1.38638884e-01f, -5.68987429e-02f, -1.77609827e-02f, 7.54791573e-02f, -3.11820447e-01f, -2.08199471e-01f, 2.78183609e-01f, 1.41016915e-01f,
  1.08800381e-01f, -1.23001926e-01f, -6.19620383e-02f, -5.68733178e-02f, 1.49277583e-01f, 2.26433113e-01f, -1.36880443e-01f, 8.21510479e-02f, 2.14517891e-01f, -1.19476959e-01f,
  -8.60686600e-02f, 9.78004411e-02f, 3.35514471e-02f, -6.88818656e-03f, 1.04500905e-01f, 1.99245483e-01f, -2.14049727e-01f, -1.46072984e-01f, 9.10171494e-02f, -1.81623653e-03f,
  1.01105059e-02f, -3.43298137e-01f, 5.51035143e-02f, -2.60478288e-01f, -4.11642976e-02f, 1.70516655e-01f, -6.48598373e-02f, 1.02833442e-01f, -3.56977195e-01f, -1.25856891e-01f,
  -3.89744830e-03f, 1.77032635e-01f, -4.20297273e-02f, -6.23965040e-02f, 1.29829813e-02f, -1.53472945e-01f, -4.11777556e-01f, 1.14753306e-01f, 1.82988346e-01f, 1.19054697e-01f,
  7.62529075e-02f, 2.20439985e-01f, -2.59584654e-02f, 2.08616838e-01f, -2.25044176e-01f, -3.54238972e-02f, -4.09414172e-02f, -1.18633956e-01f, -7.00228587e-02f, -1.53691322e-01f,
  -2.14960486e-01f, 3.09786741e-02f, -3.87983590e-01f, -3.14478993e-01f, -6.63233176e-02f, 5.00552841e-02f, -4.60133627e-02f, -2.38195911e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.11977437e-01f, 1.66299090e-01f, 4.26979735e-02f, -1.99933991e-01f, -5.64194657e-02f, 7.27262348e-02f, -7.90987089e-02f, 9.76057723e-02f, -1.12345561e-01f, 5.21718003e-02f,
  -1.77235618e-01f, 3.22824791e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    