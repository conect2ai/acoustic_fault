/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.34999675e-01f, -2.64769197e-01f, -4.61961210e-01f, 1.04881838e-01f, 1.75540492e-01f, 3.89592916e-01f, -4.38364446e-02f, 1.45670503e-01f, 8.62130299e-02f, -1.01553306e-01f,
  -7.57789463e-02f, -1.93383545e-01f, -2.52395838e-01f, 3.32730800e-01f, 1.47796437e-01f, -2.48206362e-01f, 3.93366456e-01f, 1.32596567e-01f, -2.38700211e-02f, 1.35352567e-01f,
  1.76255871e-02f, 3.03811789e-01f, -9.53808725e-02f, 1.06832460e-01f, 1.29427552e-01f, -5.96277863e-02f, -2.93113310e-02f, -3.31605703e-01f, 3.12044591e-01f, 2.14669984e-02f,
  8.25221743e-03f, -1.64940849e-01f, -7.16565549e-02f, -1.05461618e-02f, 1.35748200e-02f, 5.55071793e-03f, 3.60737853e-02f, -1.64323136e-01f, -9.72775593e-02f, -1.96637120e-02f,
  1.00912424e-02f, 5.98680303e-02f, 1.30559370e-01f, -3.43326181e-02f, 8.86042118e-02f, -5.95281497e-02f, -1.65494829e-02f, 1.47731289e-01f, -6.11845590e-02f, 2.61746738e-02f,
  -6.92577362e-02f, 9.22127590e-02f, 3.01906522e-02f, 7.63326010e-04f, -4.16264012e-02f, -8.42948779e-02f, -5.82918175e-04f, -2.54197642e-02f, 9.58473682e-02f, 6.56953827e-02f,
  1.57902762e-01f, 5.36069982e-02f, 4.89294343e-02f, -8.18778295e-03f, -2.02809870e-02f, -9.82783362e-02f, 6.33134171e-02f, 3.65277864e-02f, -4.43632007e-02f, -2.50973254e-02f,
  1.11501766e-02f, 3.39348577e-02f, 3.28819714e-02f, 7.00390060e-03f, 1.28186271e-01f, 2.48981584e-02f, -7.93727562e-02f, -7.54255205e-02f, 3.57265286e-02f, -2.20855419e-02f,
  -9.68784168e-02f, -2.09664572e-02f, -5.73917776e-02f, 6.15400970e-02f, -5.61860651e-02f, -5.54704145e-02f, -4.57423367e-02f, -3.00615970e-02f, -2.95934007e-02f, 5.30961007e-02f,
  1.30628884e-01f, -2.30208281e-02f, -7.98327923e-02f, 4.97294627e-02f, -1.56685650e-01f, 6.91921189e-02f, -4.59968597e-02f, 7.64265880e-02f, -2.08002049e-03f, -1.55063774e-02f,
  4.93286848e-02f, 5.83480261e-02f, -5.83030842e-02f, 7.46612018e-03f, 9.23590958e-02f, 8.36630613e-02f, -2.30876612e-03f, -4.40852940e-02f, 2.80570127e-02f, 1.80610344e-02f,
  -2.46676765e-02f, -1.91436633e-02f, -3.18291038e-02f, 1.68708451e-02f, 6.26181439e-02f, -2.64728591e-02f, 1.23283796e-01f, -4.13597701e-03f, 4.25135344e-02f, -4.32403050e-02f,
  -4.99322504e-01f, 3.24991733e-01f, -2.82603443e-01f, 1.37731716e-01f, -2.00693626e-02f, -4.65202369e-02f, 1.54511675e-01f, 1.55870110e-01f, 2.37925544e-01f, 3.24235409e-01f,
  3.66728634e-01f, -6.44030469e-03f, 3.61745566e-01f, 4.90655333e-01f, -4.00480963e-02f, 3.58396500e-01f, 9.65501517e-02f, 1.29881471e-01f, 1.43166974e-01f, 8.28480721e-02f,
  1.27323102e-02f, 4.41670209e-01f, 4.03400697e-02f, 2.89449811e-01f, -7.61595592e-02f, -8.19608495e-02f, -1.31572694e-01f, -2.99368501e-02f, -1.91449467e-02f, -5.31818941e-02f,
  1.46085152e-03f, 1.78039297e-01f, -3.55510898e-02f, -5.87427653e-02f, -9.30716544e-02f, -1.36728168e-01f, -1.32974103e-01f, -3.93589363e-02f, -5.65573685e-02f, 3.09491232e-02f,
  -3.63890752e-02f, -2.36683954e-02f, 8.98682177e-02f, 1.19547628e-01f, -5.90306073e-02f, -1.14533707e-01f, -5.11961542e-02f, -7.87579939e-02f, 1.34623617e-01f, -6.93967193e-02f,
  5.63295819e-02f, -8.87379944e-02f, -1.15385018e-01f, 7.97290727e-02f, -4.35864180e-02f, 3.96032855e-02f, -5.06572165e-02f, -9.55636352e-02f, -4.51129675e-02f, 2.24446561e-02f,
  -5.36254235e-02f, 5.08818701e-02f, 8.54126178e-04f, 3.22826323e-03f, 1.35394782e-01f, -5.13964742e-02f, 1.13420516e-01f, 2.25023422e-02f, -1.03974849e-01f, 3.40290070e-02f,
  -3.32756862e-02f, 2.17881445e-02f, 1.12889735e-02f, -6.76001161e-02f, 1.90124065e-02f, -5.68238050e-02f, -6.21115193e-02f, 2.58230940e-02f, -4.33005206e-02f, -2.78200973e-02f,
  1.02840669e-01f, 2.61430163e-02f, 1.10707328e-01f, -5.61234765e-02f, 6.85814694e-02f, -5.74286021e-02f, 4.86025475e-02f, -1.74670331e-02f, 5.38013093e-02f, -6.80598021e-02f,
  1.75223395e-01f, 1.76148504e-01f, 1.23503342e-01f, 9.24259499e-02f, 6.07828535e-02f, -3.40249687e-02f, 2.79658400e-02f, -5.41091152e-02f, 8.91513824e-02f, -2.12303665e-03f,
  -1.09681718e-01f, 1.52663758e-03f, -1.23775095e-01f, -4.71572205e-02f, -2.62936782e-02f, 1.06164791e-01f, 1.91893242e-02f, -4.36084718e-02f, -6.57128468e-02f, 6.48912508e-03f,
  -6.81176558e-02f, 4.02661338e-02f, -3.90522406e-02f, -2.03707740e-02f, -9.17561054e-02f, -5.87430745e-02f, -8.72629415e-03f, 1.64373014e-02f, 3.81587446e-02f, -1.34604424e-02f,
  3.96714807e-01f, 3.86556447e-01f, -1.23663418e-01f, 1.59363329e-01f, 3.79149467e-01f, -1.89200476e-01f, -6.80266544e-02f, 2.36442000e-01f, 6.20778613e-02f, 2.52761781e-01f,
  2.28241473e-01f, 1.78366706e-01f, -7.13002235e-02f, 1.30496070e-01f, -4.40046430e-01f, -2.46014118e-01f, 9.46063735e-03f, -5.32307010e-03f, -1.43133970e-02f, 1.93890110e-01f,
  -8.91798884e-02f, 4.00654197e-01f, -1.11993738e-01f, 3.88598852e-02f, 1.46353915e-01f, 2.33952776e-02f, -4.28829528e-02f, -9.97483656e-02f, 1.66714385e-01f, -2.70043709e-03f,
  1.10757843e-01f, 2.31476381e-01f, 8.93485099e-02f, -1.08430356e-01f, -1.10241249e-01f, -5.61600141e-02f, -1.72895327e-01f, -1.70872137e-02f, 5.91947837e-03f, 8.14777240e-02f,
  -5.38183376e-02f, 1.28155544e-01f, -3.53796803e-03f, 5.75118028e-02f, 1.48128808e-01f, -2.14699991e-02f, 3.19556408e-02f, 1.38946250e-02f, 7.31625557e-02f, -7.20440745e-02f,
  -6.35234565e-02f, -1.00054421e-01f, -7.80273303e-02f, -1.27614029e-02f, -6.56375065e-02f, 2.83986665e-02f, -1.01414658e-01f, -1.23368539e-01f, -9.77888107e-02f, -1.38792675e-02f,
  -9.64794606e-02f, -9.25853103e-02f, -6.90054521e-02f, 7.49137923e-02f, 6.91225901e-02f, -2.19950825e-02f, 5.63155189e-02f, -7.73969106e-03f, -1.00044964e-03f, 8.46398696e-02f,
  -6.09719865e-02f, 8.56416747e-02f, -4.74181995e-02f, -5.39563857e-02f, 5.90661578e-02f, -5.42745329e-02f, 1.97174642e-02f, -3.08722090e-02f, -5.02593778e-02f, 8.09096673e-04f,
  4.36740294e-02f, -4.32443693e-02f, 6.21285476e-02f, -4.96913446e-03f, -9.18136735e-04f, -3.52747925e-02f, 9.68694836e-02f, 1.63576344e-03f, -2.69597787e-02f, 2.25724559e-02f,
  1.60266250e-01f, 8.17575231e-02f, -4.42674980e-02f, 7.59249777e-02f, 9.55801085e-02f, 3.75778377e-02f, 1.20647112e-02f, 2.38392185e-02f, -7.06480742e-02f, -2.68768221e-02f,
  -1.36072226e-02f, -2.05612481e-02f, -1.43889159e-01f, 5.01250438e-02f, 3.11223119e-02f, 1.07737117e-01f, -6.37898445e-02f, 3.31202671e-02f, 1.41062029e-02f, 8.69970620e-02f,
  7.39721023e-03f, 1.66394077e-02f, -4.95340116e-02f, -1.27971202e-01f, -4.86551933e-02f, -1.76950209e-02f, 4.92519997e-02f, -7.54759237e-02f, -6.51975870e-02f, -3.36504355e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.82032627e-01f, 6.88726664e-01f, 5.21638691e-01f, -6.16693735e-01f, 4.34639528e-02f, -1.97811604e-01f, -3.90637100e-01f, -8.65575857e-03f, -1.91534117e-01f, 1.64165601e-01f,
  -3.81018698e-01f, 4.11843628e-01f, 1.32941127e-01f, -2.06239864e-01f, -6.75188959e-01f, -2.77743548e-01f, -4.91764009e-01f, -3.74751061e-01f, -1.54389769e-01f, -1.91677630e-01f,
  -3.38935107e-01f, -5.77760160e-01f, -9.83831659e-02f, 1.00793622e-01f, 5.98060898e-02f, 1.97400555e-01f, -3.92833591e-01f, 2.91238546e-01f, 4.80798353e-03f, 7.90206492e-02f,
  -2.28778228e-01f, -8.11222941e-02f, -5.82477696e-05f, 2.04258412e-01f, -1.57915488e-01f, -4.07651849e-02f, -4.97109294e-02f, -1.20680816e-01f, -2.05106229e-01f, 3.85346971e-02f,
  8.94515961e-02f, 5.77169172e-02f, 5.22973053e-02f, 1.79901496e-02f, -1.60370190e-02f, 1.62536547e-01f, 1.57732636e-01f, 5.78297023e-03f, 1.34038314e-01f, 2.20949516e-01f,
  2.40894869e-01f, 1.29873380e-01f, 1.25650436e-01f, 1.72064736e-01f, 2.57229581e-02f, 6.76703155e-02f, -9.46351886e-02f, 1.54865310e-01f, 1.19399548e-01f, -7.70506561e-02f,
  -1.20060317e-01f, -1.63541555e-01f, 1.37203913e-02f, 5.73899075e-02f, -1.00894190e-01f, 2.81708408e-02f, -4.16649552e-03f, -7.71393627e-02f, 3.19631360e-02f, -6.53724894e-02f,
  -1.42309442e-01f, 1.82679772e-01f, -1.73648875e-02f, -1.18555218e-01f, -8.86553824e-02f, -2.16243073e-01f, -5.55685163e-02f, 6.71437904e-02f, -1.08455285e-01f, -3.17858607e-02f,
  -1.17232017e-01f, -4.65698428e-02f, 1.65119022e-01f, -1.92053802e-02f, -6.58219010e-02f, -2.70396034e-04f, 7.60852620e-02f, 4.53896560e-02f, -3.08812615e-02f, -1.08845875e-01f,
  -5.57698250e-01f, -4.42704290e-01f, -2.91041017e-01f, 5.27276285e-02f, -1.35656178e-01f, -1.84603065e-01f, -1.23668343e-01f, 1.03972815e-01f, -2.29113907e-01f, -1.69248834e-01f,
  -3.75922322e-02f, -2.12864466e-02f, 3.72284353e-02f, -1.30231693e-01f, -1.24047890e-01f, -2.12580815e-01f, -1.83270454e-01f, -2.87201311e-02f, -1.64045945e-01f, 2.85410248e-02f,
  7.76084885e-02f, -3.02923057e-04f, 5.80562316e-02f, 5.62448474e-03f, -5.47123589e-02f, 1.92784632e-04f, 4.30440763e-03f, 9.82087031e-02f, 6.19407818e-02f, 1.04619667e-01f,
  -1.97566643e-01f, 4.27270457e-02f, -5.13712347e-01f, -3.53661656e-01f, 2.67823517e-01f, 4.11081821e-01f, -2.35398742e-03f, 9.84272286e-02f, -5.56288064e-01f, 5.84827304e-01f,
  5.77419877e-01f, -7.99306750e-01f, 1.48715571e-01f, 3.64567459e-01f, -1.74159408e-01f, -6.72547147e-02f, 5.48389852e-01f, 3.59010786e-01f, -2.08458900e-01f, 2.38683313e-01f,
  -2.16546678e-03f, 5.28950095e-01f, 1.35559022e-01f, 4.26513970e-01f, 4.03195620e-01f, -2.50234038e-01f, 5.90491891e-01f, -5.89318834e-02f, 4.34021711e-01f, -5.00384578e-03f,
  1.09120019e-01f, -1.35615230e-01f, -1.26170605e-01f, -2.42209896e-01f, 2.99382955e-01f, 2.57987082e-01f, 4.88281921e-02f, -2.25690275e-01f, -2.39805505e-01f, -7.03785270e-02f,
  -1.33533686e-01f, -1.60815671e-01f, -2.00527191e-01f, -2.04257786e-01f, 4.83882241e-02f, -4.44230698e-02f, -7.66931251e-02f, 1.03028275e-01f, -1.90111592e-01f, -1.26007327e-03f,
  -5.85643724e-02f, 3.19646113e-02f, 1.16544425e-01f, -9.26705673e-02f, -1.21180549e-01f, -5.76928668e-02f, -9.02819932e-02f, 5.51770329e-02f, 1.24323688e-01f, 1.96427014e-02f,
  2.52254456e-02f, 3.16939279e-02f, 9.48152319e-02f, 1.18842565e-01f, -4.85063121e-02f, 6.05032183e-02f, 9.92042013e-03f, 1.72987077e-02f, -9.04999673e-02f, 7.56808370e-02f,
  1.88507773e-02f, -1.41191527e-01f, -1.39235795e-01f, 2.95333099e-02f, 1.17561229e-01f, -1.48567960e-01f, -1.14977434e-01f, -2.90332790e-02f, -1.47954170e-02f, 1.44852906e-01f,
  2.06301585e-02f, -3.73799950e-02f, -6.95590442e-03f, 5.14089689e-02f, 1.57811902e-02f, -6.27714843e-02f, -5.06163621e-03f, 5.12108905e-03f, -4.23102267e-02f, 1.38610169e-01f,
  2.05228925e-01f, 1.02778606e-01f, -8.84208083e-02f, -8.36888775e-02f, 2.76891664e-02f, 1.32676959e-01f, 4.82241027e-02f, 5.30636795e-02f, 6.11394271e-02f, -1.04180994e-02f,
  6.12872988e-02f, 1.80418193e-01f, 1.25410929e-01f, -4.31377105e-02f, -9.10942703e-02f, 1.41491860e-01f, 1.87453404e-02f, -1.20244235e-01f, 7.84373581e-02f, 2.07727090e-01f,
  1.74638763e-01f, 9.40900967e-02f, 3.55034806e-02f, 9.02706981e-02f, 2.38459222e-02f, 1.42881915e-01f, -6.72616288e-02f, -6.32852241e-02f, 1.84243500e-01f, -1.20865032e-02f,
  -1.75879896e-01f, 3.72743279e-01f, -1.51651010e-01f, -5.32197714e-01f, -2.75962532e-01f, 2.14392859e-02f, -3.61715168e-01f, 1.22481428e-01f, 1.68475196e-01f, -9.88769382e-02f,
  -3.91786844e-01f, 4.27515894e-01f, 5.47282219e-01f, -5.72354555e-01f, 1.47507936e-01f, 3.35088849e-01f, -5.20170093e-01f, -2.47798190e-01f, 1.24347970e-01f, -3.68403010e-02f,
  -1.51561480e-02f, -1.87196940e-01f, -2.79344499e-01f, 1.68893844e-01f, -5.74345887e-01f, -2.32116118e-01f, -4.70407546e-01f, -1.34389937e-01f, -5.36714435e-01f, -5.03107235e-02f,
  -4.08344924e-01f, -2.27278247e-01f, -3.87444258e-01f, -2.56056398e-01f, -2.40916222e-01f, -4.06685285e-02f, -1.96283698e-01f, 2.02940106e-02f, -1.23058530e-02f, -1.36085590e-02f,
  2.13755488e-01f, 1.15089178e-01f, -1.10785484e-01f, 2.19783291e-01f, -1.14880159e-01f, -1.68595538e-01f, -4.61624078e-02f, -2.13426888e-01f, 3.61321867e-02f, 8.85827169e-02f,
  1.21841908e-01f, -3.07500008e-02f, -3.85660410e-01f, -3.17721725e-01f, -1.18744351e-01f, -1.46941870e-01f, -2.34446138e-01f, 1.01655543e-01f, -1.03328653e-01f, -8.34086165e-02f,
  -1.22554459e-01f, -3.04920264e-02f, -1.25072852e-01f, 1.19281724e-01f, 2.05115035e-01f, 2.86056250e-02f, 2.63330992e-02f, -1.14771694e-01f, -1.99018687e-01f, -1.21045284e-01f,
  -1.56717718e-01f, -1.46827430e-01f, -8.38388875e-02f, -1.16510712e-01f, -8.76862779e-02f, 2.46862233e-01f, -6.62544295e-02f, -1.30332693e-01f, 4.66606990e-02f, -1.34026539e-02f,
  8.16288739e-02f, -5.68152368e-02f, -4.16957214e-02f, -1.62849024e-01f, 2.06477810e-02f, 8.58622193e-02f, 2.38307957e-02f, 3.19613479e-02f, -1.13496244e-01f, 1.25437647e-01f,
  -3.28896135e-01f, -2.39819065e-01f, 6.30165860e-02f, -1.35801956e-01f, 9.86338928e-02f, 2.47172583e-02f, -1.58197014e-03f, -8.99213180e-02f, -5.66791967e-02f, 4.41700108e-02f,
  -4.85303327e-02f, -2.54912704e-01f, -1.34224102e-01f, -3.54736671e-02f, 2.81035900e-01f, 5.65190762e-02f, -3.90435979e-02f, -6.51481971e-02f, -1.99116006e-01f, 1.09252874e-02f,
  2.68720761e-02f, 1.05257452e-01f, 4.97090295e-02f, -4.97550294e-02f, -2.08383963e-01f, -1.08862653e-01f, 2.39360765e-01f, -8.95395037e-03f, -1.10213712e-01f, 3.71637940e-02f,
  -1.29339889e-01f, 4.28140432e-01f, 4.48209256e-01f, -1.86461523e-01f, 4.75840449e-01f, 3.00861865e-01f, -5.69442473e-02f, 4.71595883e-01f, 1.95219740e-01f, -2.13091314e-01f,
  -3.44743103e-01f, -9.71355066e-02f, -4.38169055e-02f, -2.02247381e-01f, -7.47457623e-01f, -2.83763587e-01f, -3.75812411e-01f, -1.28136352e-01f, 4.67251867e-01f, 2.91810539e-02f,
  7.45721832e-02f, -4.60540652e-01f, 1.32599905e-01f, 4.17746693e-01f, 6.48458123e-01f, 2.43051723e-01f, -5.22981405e-01f, 2.87740707e-01f, -1.37372375e-01f, -3.72628272e-02f,
  3.97514813e-02f, 2.77597845e-01f, 2.86858529e-01f, 1.88875049e-01f, -2.79558767e-02f, 7.08190128e-02f, -4.17444929e-02f, -3.09455842e-02f, 1.02207907e-01f, 1.01833425e-01f,
  -9.27179353e-04f, 1.29380628e-01f, 8.79010931e-03f, 9.73790735e-02f, 3.22868556e-01f, 1.78019151e-01f, 4.33903337e-01f, 3.07704449e-01f, 2.20853955e-01f, 2.66260922e-01f,
  8.89623985e-02f, 1.52233332e-01f, -2.05995627e-02f, -1.77644193e-01f, -5.66396825e-02f, 7.80176818e-02f, -7.95329288e-02f, -4.55383509e-02f, 2.23113038e-02f, 3.22030187e-02f,
  2.42070630e-02f, -1.25617072e-01f, -1.84487775e-02f, 4.51302677e-02f, -4.51283008e-02f, -3.02736927e-02f, -1.42664500e-02f, -1.32319272e-01f, -7.17423335e-02f, -8.72959867e-02f,
  -5.03598787e-02f, 1.47321731e-01f, -2.25478616e-02f, 1.29563138e-01f, -1.00631572e-01f, 1.11763865e-01f, -3.24423611e-02f, 1.94493849e-02f, 8.32905397e-02f, -5.06247692e-02f,
  5.57114184e-02f, -1.30064756e-01f, -2.57290527e-02f, 1.37444794e-01f, -3.67921516e-02f, 1.14096589e-01f, 1.48670197e-01f, 2.49582618e-01f, 2.24440932e-01f, -8.73919278e-02f,
  -4.74665701e-01f, -7.10263252e-01f, 4.21998315e-02f, 9.54353511e-02f, -6.64242581e-02f, -8.50643218e-02f, 4.44313884e-02f, 1.92060381e-01f, -7.06419796e-02f, -9.31360107e-03f,
  2.14996412e-02f, 5.14383726e-02f, -1.54731527e-01f, 1.37615502e-01f, -1.54736355e-01f, -8.74988586e-02f, -2.65522063e-01f, -3.30771744e-01f, -2.46422365e-01f, -8.09483752e-02f,
  -2.40431614e-02f, -5.82942925e-02f, -2.01839164e-01f, 4.80409712e-02f, 1.45100318e-02f, -1.52717695e-01f, -8.62531736e-02f, -1.00740930e-02f, -1.16503328e-01f, -1.10806033e-01f,
  -6.65367991e-02f, -3.82274836e-02f, 5.70119202e-01f, 5.99726260e-01f, -1.78191066e-01f, -2.58610845e-02f, 4.08595145e-01f, 2.64708817e-01f, 5.19003749e-01f, -4.83687311e-01f,
  -1.19427666e-01f, -1.18492499e-01f, 4.32327926e-01f, -2.06933655e-02f, 3.04573506e-01f, 1.72999293e-01f, 2.24468425e-01f, -1.92283168e-02f, 3.81169468e-01f, 2.03300893e-01f,
  1.62834361e-01f, -2.46542633e-01f, 4.84348983e-01f, -4.66112494e-01f, 8.71940702e-02f, 7.69567192e-02f, -3.18672270e-01f, 2.19068781e-01f, -4.69717354e-01f, -1.48689136e-01f,
  2.57031590e-01f, 5.64482361e-02f, -5.82348928e-02f, -2.68429518e-02f, 1.72043905e-01f, -1.32838234e-01f, 8.86132717e-02f, 6.09877706e-02f, 5.70638664e-02f, -3.29053961e-03f,
  4.48063165e-02f, -7.30751753e-02f, -7.38011226e-02f, -2.31292933e-01f, -1.81407198e-01f, 4.81439047e-02f, 2.10491903e-02f, 1.62046313e-01f, 4.27059131e-03f, 7.42866546e-02f,
  9.32331681e-02f, 4.48921137e-02f, 6.06374256e-02f, -1.51430428e-01f, -4.76456806e-02f, 9.57595184e-02f, -2.93206461e-02f, 2.57974342e-02f, -3.68446670e-02f, -1.18500181e-01f,
  -2.36703828e-01f, 1.25392258e-01f, 3.54660749e-02f, 1.88504070e-01f, -1.25887007e-01f, -8.79835337e-03f, -1.63521349e-01f, -6.58208877e-02f, -2.64363736e-02f, 3.38940546e-02f,
  1.90986529e-01f, -8.33471585e-03f, 7.06004351e-02f, -5.21694534e-02f, -1.17694885e-01f, -1.71144858e-01f, -7.75866285e-02f, -4.70677540e-02f, 9.44166183e-02f, 1.29339434e-02f,
  -2.14081798e-02f, -4.18415107e-02f, 1.22801445e-01f, 5.18304519e-02f, -3.44395451e-03f, 7.04255179e-02f, -8.10954049e-02f, -9.43133160e-02f, 2.11280704e-01f, 8.18173289e-02f,
  2.07209036e-01f, -7.04343542e-02f, 1.41363993e-01f, -3.22195627e-02f, 1.12807848e-01f, -1.87068731e-01f, 5.33238947e-02f, -1.02309093e-01f, 1.77044094e-01f, -1.92061439e-01f,
  -2.19098210e-01f, 2.41000757e-01f, 3.78060862e-02f, 2.47713868e-02f, -7.29057044e-02f, -4.96238433e-02f, -6.30076369e-03f, 2.21981071e-02f, -5.73467575e-02f, -9.85432938e-02f,
  8.41656402e-02f, 7.18466938e-02f, -1.29740924e-01f, -3.79165374e-02f, -1.42963409e-01f, -9.66032818e-02f, -9.08102244e-02f, -1.23778405e-02f, -5.05548567e-02f, 1.30232424e-01f,
  -1.17985427e+00f, 5.00052929e-01f, -2.92962253e-01f, -4.38831866e-01f, 8.51782635e-02f, -4.95559216e-01f, -1.41016990e-01f, 3.36350203e-02f, 1.93856940e-01f, 2.52537489e-01f,
  2.77503550e-01f, -2.25375056e-01f, 5.45643389e-01f, 7.19797015e-02f, -4.85223740e-01f, 4.59240735e-01f, -3.65416974e-01f, -2.35083148e-01f, 1.80504590e-01f, -1.81921586e-01f,
  -2.05913752e-01f, 1.95614040e-01f, -1.86992377e-01f, 2.87994474e-01f, -3.49395096e-01f, -1.95231944e-01f, -2.45047480e-01f, 1.97018653e-01f, -2.79555887e-01f, 2.78466400e-02f,
  -7.13440955e-01f, -1.95722833e-01f, -2.23285809e-01f, -2.89854765e-01f, -3.07935447e-01f, -1.79485217e-01f, -2.37843305e-01f, 1.18340142e-02f, -1.13946516e-02f, 1.60287723e-01f,
  -1.01985462e-01f, 2.31753886e-02f, 6.64842054e-02f, 2.14776322e-01f, -2.22988185e-02f, 7.16098323e-02f, -1.21421248e-01f, -3.22255164e-01f, -4.58838828e-02f, -2.57218797e-02f,
  -9.09302011e-02f, -6.29260466e-02f, -1.57262847e-01f, -9.17310044e-02f, -2.19526678e-01f, -4.54482175e-02f, -1.19521327e-01f, -1.13649212e-01f, -2.05407903e-01f, -1.44007698e-01f,
  1.10731833e-01f, -3.85336392e-02f, -9.47866961e-03f, 9.16435122e-02f, 8.50158930e-02f, 1.45400748e-01f, -2.40668245e-02f, 8.95623490e-03f, -2.38489639e-02f, -1.31273627e-01f,
  3.82315218e-02f, -1.88180655e-01f, 1.60083156e-02f, -8.75778273e-02f, 1.00350372e-01f, -3.44730504e-02f, -1.22407369e-01f, -1.58301592e-02f, 7.27446973e-02f, -6.42691106e-02f,
  -1.05530228e-02f, -1.82582084e-02f, 2.62642130e-02f, 5.74662499e-02f, -6.74929172e-02f, -3.24203074e-02f, 7.63742551e-02f, 3.38941924e-02f, -4.07067873e-02f, -2.15371046e-02f,
  -7.40459561e-01f, -6.31066144e-01f, -1.16673470e-01f, -2.41422594e-01f, -5.79608530e-02f, 3.17853726e-02f, 5.82690351e-02f, -3.27748992e-02f, -2.07321659e-01f, 2.57571246e-02f,
  -1.57847732e-01f, -5.90898935e-03f, -1.39987856e-01f, -1.04606161e-02f, -4.85770218e-02f, -2.01811194e-02f, -1.68995887e-01f, -1.45897686e-01f, -2.95086116e-01f, -1.81914091e-01f,
  -1.37488827e-01f, 6.64478093e-02f, -1.22108748e-02f, -3.44545953e-02f, -3.89858522e-02f, -9.01661366e-02f, -1.18160136e-01f, -3.05255745e-02f, -1.60117164e-01f, 1.57578662e-01f,
  -1.26669860e+00f, 4.61937070e-01f, 2.60409921e-01f, 4.06311601e-01f, -1.59632459e-01f, 2.32028008e-01f, 3.76831055e-01f, 4.44297045e-02f, 5.06733596e-01f, 3.59778553e-01f,
  -1.01365678e-01f, -5.53863108e-01f, 2.95361161e-01f, 4.09396738e-01f, -6.67815685e-01f, 6.16604865e-01f, 3.46408039e-01f, 2.31664836e-01f, 3.21405232e-01f, -3.22342701e-02f,
  8.89170319e-02f, -1.38323396e-01f, -1.03904463e-01f, 1.22871466e-01f, -3.34089309e-01f, 1.14260809e-02f, -3.51271003e-01f, 2.50121474e-01f, -2.22030550e-01f, -1.23753309e-01f,
  -6.08114779e-01f, 7.33994991e-02f, -3.01195025e-01f, -5.94494939e-02f, -1.46230683e-01f, -7.13562816e-02f, 1.89435128e-02f, -6.14624470e-02f, 2.93951202e-02f, 1.85912903e-02f,
  -1.85822204e-01f, -5.88341057e-02f, 1.11782163e-01f, 4.97337468e-02f, 1.09085545e-01f, -3.10121384e-02f, 7.82287493e-02f, 2.52121538e-02f, -7.35207787e-03f, 1.00174114e-01f,
  1.49254441e-01f, 9.85650346e-03f, 1.18038952e-01f, 1.45233586e-01f, -1.22698851e-01f, 2.31423840e-01f, 2.39123061e-01f, -1.06938176e-01f, -1.32627428e-01f, 1.86518822e-02f,
  1.33605421e-01f, 2.13110447e-01f, 8.64408016e-02f, -2.02325046e-01f, -1.02171503e-01f, -1.40651566e-04f, 2.28770413e-02f, -1.62304148e-01f, 2.88456064e-02f, -5.96279204e-02f,
  -6.10385686e-02f, -1.50186857e-02f, -2.64039002e-02f, -1.34310848e-03f, 1.77223668e-01f, -2.09113639e-02f, -3.90310287e-02f, -2.48954557e-02f, -1.25442380e-02f, 8.19076002e-02f,
  9.79599729e-02f, 9.67059098e-03f, -1.94381222e-01f, -8.23828503e-02f, -1.29176266e-02f, 4.79631163e-02f, 2.39397716e-02f, 5.00519052e-02f, 1.78022176e-01f, -1.67192042e-01f,
  -5.10424316e-01f, 5.95114194e-02f, -8.32317844e-02f, -2.11299911e-01f, 7.81891048e-02f, 1.16978586e-02f, 9.88379419e-02f, -3.36061306e-02f, 1.52792230e-01f, 6.54872134e-02f,
  -1.04715489e-01f, 2.89488155e-02f, -2.14634866e-01f, 1.70017779e-02f, 7.14200586e-02f, -3.69566865e-02f, -6.59587234e-02f, 4.11257520e-02f, -2.47569233e-01f, -6.75500259e-02f,
  -2.68049598e-01f, -3.19561437e-02f, 1.82596833e-01f, -8.31687003e-02f, -9.30866525e-02f, -2.02264518e-01f, -2.56457865e-01f, 1.63677949e-02f, -1.93240508e-01f, 1.00326627e-01f,
  -3.08450073e-01f, 1.04097743e-02f, -3.35536242e-01f, -3.03859025e-01f, 7.03523576e-01f, 6.89373970e-01f, 1.37383759e-01f, 2.44019136e-01f, 1.02651261e-01f, 2.70074487e-01f,
  1.99587867e-01f, -1.39865801e-01f, -4.61423576e-01f, -3.56180370e-01f, -4.72265512e-01f, -3.49228442e-01f, 1.00776955e-01f, 9.90748182e-02f, -1.46035522e-01f, 3.87081765e-02f,
  -1.05017863e-01f, 9.99726281e-02f, -6.39711976e-01f, 2.27533951e-01f, 5.37901223e-02f, -2.75776908e-02f, 3.16920802e-02f, -7.44676813e-02f, 3.19096707e-02f, 1.75522968e-01f,
  7.06941402e-03f, -1.76294103e-01f, -7.87883997e-02f, -1.64088830e-01f, 4.66181003e-02f, 7.80964643e-02f, 9.70949456e-02f, -8.95846859e-02f, -1.35059118e-01f, -1.91605061e-01f,
  8.45172778e-02f, -4.48765047e-02f, -1.90964222e-01f, -1.80096328e-01f, 1.39970072e-02f, 3.44681144e-02f, -1.65175974e-01f, 1.39267957e-02f, -1.26186833e-01f, -1.45885050e-01f,
  -3.70800793e-01f, 1.15648303e-02f, 1.57633916e-01f, -1.14107551e-02f, -7.87144154e-02f, 6.19523376e-02f, 1.29620239e-01f, 6.62691444e-02f, 7.46294931e-02f, 9.50189382e-02f,
  4.29497845e-02f, 1.91972569e-01f, -4.32884879e-02f, -1.83710307e-01f, 4.23543304e-02f, 9.09110308e-02f, 2.61854474e-02f, -3.04334052e-02f, -1.10997967e-02f, 6.99661300e-02f,
  1.07505098e-01f, 7.84127265e-02f, -6.65790662e-02f, 3.50398459e-02f, 8.40567723e-02f, -1.01584112e-02f, 8.74322001e-03f, 1.30233457e-02f, 1.34023234e-01f, -5.93234003e-02f,
  -1.41027510e-01f, -5.43307289e-02f, -1.01031372e-02f, -7.78348884e-03f, -9.86346900e-02f, -1.03971474e-01f, 4.14397828e-02f, -1.26223564e-01f, -1.78670973e-01f, 1.74063370e-01f,
  2.58432716e-01f, 4.62618053e-01f, -9.12376344e-02f, -5.56954928e-02f, 1.09960891e-01f, 1.18393928e-01f, 1.34320989e-01f, -6.13921024e-02f, 1.07060291e-01f, 2.41116956e-01f,
  3.20474923e-01f, 1.17346048e-01f, 2.68605053e-01f, -3.95529866e-02f, -9.42090061e-03f, 1.09976806e-01f, 1.18932240e-01f, 9.77651179e-02f, 1.89149305e-01f, 3.95236425e-02f,
  6.69713244e-02f, 2.21753135e-01f, 9.01721492e-02f, 1.44358963e-01f, 8.25090185e-02f, 1.57717884e-01f, 2.00448856e-01f, -8.84863362e-02f, -7.83612207e-02f, -1.90093983e-02f,
  4.93944287e-02f, 5.90238050e-02f, -3.64883691e-01f, -2.08821222e-01f, 8.05233195e-02f, -6.14052296e-01f, -1.80137023e-01f, -1.94031194e-01f, -1.19640231e-01f, 2.43572757e-01f,
  -7.11822584e-02f, 1.38815835e-01f, 2.22362787e-01f, -6.29345119e-01f, -9.93714154e-01f, -5.18697739e-01f, -6.35630071e-01f, -1.54433623e-01f, -2.58537102e-02f, 7.32252896e-02f,
  -2.09780306e-01f, -3.28130960e-01f, -5.37039876e-01f, 1.30312815e-01f, 1.52789345e-02f, 4.35441285e-01f, 2.08606049e-01f, 3.91704232e-01f, -2.16487855e-01f, -1.79422379e-01f,
  -3.07655513e-01f, 6.18598275e-02f, 1.37377501e-01f, -1.50236651e-01f, -2.46762019e-02f, 2.31265232e-01f, 1.71179324e-01f, -2.14239597e-01f, -9.79191437e-02f, -6.96435869e-02f,
  2.22032741e-01f, 7.57914633e-02f, -1.30521595e-01f, 4.16288562e-02f, 3.16532463e-01f, 2.12844536e-02f, -6.92831576e-02f, -2.64286832e-03f, -7.09179491e-02f, -7.81648532e-02f,
  -1.39537320e-01f, -3.43907587e-02f, 6.20927848e-02f, -1.54935971e-01f, -7.29468837e-02f, 3.83090563e-02f, -5.29388450e-02f, 9.59000960e-02f, 7.61704799e-03f, 1.19568212e-02f,
  7.71326721e-02f, 1.89024001e-01f, -4.42272238e-02f, 5.50329825e-03f, -9.14981514e-02f, -5.24768280e-03f, -6.90318784e-03f, -8.03910103e-03f, 1.02065288e-01f, -1.03872316e-02f,
  -5.60063869e-02f, -2.76867729e-02f, 2.22144611e-02f, -2.77508888e-02f, 1.14984095e-01f, 7.80833513e-02f, 8.12062174e-02f, 4.28614281e-02f, -4.49404083e-02f, -2.94471364e-02f,
  2.12445781e-02f, -6.68136254e-02f, 3.20043415e-02f, 1.23923801e-01f, -8.98751318e-02f, 1.18303038e-02f, 3.95916477e-02f, -1.33959889e-01f, -3.07726245e-02f, 3.06046028e-02f,
  -3.46484929e-02f, -7.49194622e-02f, 6.88924547e-03f, 9.63877812e-02f, -5.21229804e-02f, -5.60091529e-03f, -1.72168985e-01f, -1.92436725e-01f, -7.46063888e-02f, -5.83750419e-02f,
  1.69793054e-01f, 3.60895284e-02f, 1.96352839e-01f, 1.18854560e-01f, -1.78184025e-02f, -6.68104216e-02f, 1.56939730e-01f, 1.22041143e-01f, 2.61212569e-02f, 3.86610776e-02f,
  7.87401721e-02f, 2.44500622e-01f, 1.09952137e-01f, 8.52855742e-02f, 1.48035288e-01f, 5.03666475e-02f, 7.43785277e-02f, 6.76628649e-02f, 4.69233431e-02f, -4.89726141e-02f,
  2.68739730e-01f, 3.86288404e-01f, 5.17133713e-01f, 2.77887434e-01f, 5.10556877e-01f, 7.85559654e-01f, 6.06647670e-01f, 6.27307653e-01f, 7.38448441e-01f, -2.78337359e-01f,
  -1.28075570e-01f, 1.02365753e-02f, 1.65931433e-01f, -1.86246768e-01f, 5.89471936e-01f, 3.45649064e-01f, 1.06531031e-01f, 1.18065424e-01f, 4.17273313e-01f, 3.22703451e-01f,
  3.21076602e-01f, 1.10922374e-01f, -1.84512481e-01f, -3.93021144e-02f, 6.33191317e-02f, -7.12598562e-02f, -6.18739903e-01f, 2.53364801e-01f, -3.77156138e-01f, 2.11421952e-01f,
  -1.15511686e-01f, 1.05919853e-01f, -1.46387041e-01f, 3.57064083e-02f, 3.20517980e-02f, -5.35112172e-02f, -3.56132425e-02f, 1.79567888e-01f, 1.89176142e-01f, 9.99388695e-02f,
  -1.94454640e-01f, -9.10152718e-02f, -1.24150425e-01f, -6.19070642e-02f, 1.34627774e-01f, -4.39434648e-02f, -1.97627731e-02f, 8.41849446e-02f, 3.97944264e-02f, 9.52337459e-02f,
  -2.85600107e-02f, 2.51550265e-02f, 1.41969649e-02f, 8.70034192e-03f, 9.18743014e-02f, -9.62540433e-02f, -1.14854075e-01f, 4.51296568e-02f, -4.68730666e-02f, 1.37688339e-01f,
  2.02717170e-01f, 1.52917787e-01f, -2.59198658e-02f, -5.86966686e-02f, 2.80857570e-02f, -8.24985877e-02f, -1.29665375e-01f, -5.89445382e-02f, 3.45044062e-02f, -4.95891310e-02f,
  -8.89900103e-02f, -1.02494203e-01f, 2.12977096e-01f, -6.91526532e-02f, -3.83721367e-02f, -6.71017170e-02f, 6.63229749e-02f, 3.93051989e-02f, -3.76807749e-02f, -1.44338489e-01f,
  9.73999873e-02f, 2.35999282e-02f, 7.65403211e-02f, -1.31773680e-01f, 6.95677381e-03f, 8.56416672e-02f, -1.07318804e-01f, 6.40435666e-02f, -4.97215614e-02f, 8.20742771e-02f,
  1.97424933e-01f, 5.85384011e-01f, 2.54644752e-02f, -5.42385243e-02f, -1.34116828e-01f, -1.51089467e-02f, 1.84881359e-01f, 2.95312908e-02f, 1.94765523e-01f, 1.67306408e-01f,
  -9.08228606e-02f, -1.86250135e-02f, -1.15655251e-01f, -9.88589823e-02f, -8.69434774e-02f, -2.19149478e-02f, -1.75447986e-02f, -1.46055901e-02f, 8.37220252e-02f, -1.08934352e-02f,
  -2.34467536e-01f, 6.32718056e-02f, 8.17749500e-02f, -7.07707852e-02f, -1.01414204e-01f, -7.53150508e-02f, -8.89943466e-02f, -9.76268128e-02f, 6.47875071e-02f, -5.83267771e-02f,
  -8.55680585e-01f, 3.29376101e-01f, 8.22192073e-01f, -6.35127544e-01f, -1.49306208e-01f, 7.28361547e-01f, 6.13615990e-01f, -8.96348506e-02f, -4.34029281e-01f, 2.56598711e-01f,
  -2.45681942e-01f, 1.14755780e-01f, 5.73759615e-01f, -7.70777017e-02f, 2.55362600e-01f, 4.31852788e-01f, 1.02330163e-01f, 2.63352811e-01f, -1.37678266e-01f, -3.40396166e-01f,
  -2.52876669e-01f, -3.63465041e-01f, 4.05568838e-01f, -3.12203705e-01f, -2.78370887e-01f, -3.08294266e-01f, -3.46199930e-01f, 2.93811589e-01f, -1.13381281e-01f, 6.98208064e-02f,
  -6.15030646e-01f, -5.25030375e-01f, -1.36017576e-01f, 1.51896864e-01f, -2.00845122e-01f, -6.94236206e-03f, 1.67330608e-01f, 1.68609872e-01f, -1.45208150e-01f, -6.98390007e-02f,
  4.50616963e-02f, 8.55698884e-02f, -2.64032334e-01f, 9.66345966e-02f, -1.71132460e-01f, 9.99138597e-03f, 2.97345668e-02f, -1.26263369e-02f, 4.10238132e-02f, 9.87500027e-02f,
  1.88858479e-01f, -1.47243151e-02f, -5.12691997e-02f, -1.98690817e-02f, 2.26375405e-02f, -5.00071608e-02f, 1.53620690e-01f, 1.13892771e-01f, -3.93661223e-02f, -1.76415980e-01f,
  1.80662304e-01f, 1.72024928e-02f, 1.27615958e-01f, -5.03099104e-03f, 6.82396144e-02f, -1.35123715e-01f, 1.43162861e-01f, -4.03542332e-02f, 5.85032217e-02f, -5.01846112e-02f,
  -1.40384343e-02f, 6.23641685e-02f, -1.27684250e-01f, 2.49957424e-02f, -6.39024377e-02f, -1.22392185e-01f, 2.12287650e-01f, -1.39268205e-01f, 7.71254897e-02f, -1.29488871e-01f,
  -3.71096022e-02f, -1.13968626e-01f, -1.74407684e-03f, 6.38836622e-02f, 1.20451607e-01f, -1.64548457e-02f, -1.03190675e-01f, 6.86840788e-02f, -6.12613037e-02f, 6.97914660e-02f,
  -5.08358002e-01f, -2.83878148e-01f, 4.83499356e-02f, -8.86425078e-02f, 4.26194668e-02f, 3.47765610e-02f, -8.41465890e-02f, -1.99553534e-01f, -8.12840909e-02f, -1.02293164e-01f,
  -1.11689322e-01f, -1.01018593e-01f, -2.10591294e-02f, 5.50721921e-02f, 1.52692378e-01f, -3.17591764e-02f, 5.31404689e-02f, -1.51883364e-01f, 4.46158908e-02f, -3.40686254e-02f,
  -3.94640341e-02f, -5.82955517e-02f, 5.87413982e-02f, -7.22812414e-02f, 4.19103280e-02f, -8.51409808e-02f, -1.40628904e-01f, 7.81525373e-02f, -4.31937389e-02f, 5.23397289e-02f,
  -1.70114443e-01f, 6.82006478e-02f, -5.31177759e-01f, 2.55777612e-02f, -5.69024444e-01f, -5.73306859e-01f, -3.64086121e-01f, -2.12012976e-01f, 2.82908171e-01f, 4.64583427e-01f,
  -6.50259256e-02f, 3.06371003e-01f, 4.24576640e-01f, -6.75191358e-02f, -1.87193364e-01f, 5.41991830e-01f, -3.63377243e-01f, 1.82795674e-01f, 1.85580656e-01f, -2.67903626e-01f,
  -8.57807547e-02f, -2.16944575e-01f, -1.27713516e-01f, -2.48112470e-01f, -5.87784886e-01f, -1.19658768e-01f, 2.26392690e-02f, -3.72150570e-01f, -3.73027831e-01f, -2.83834130e-01f,
  -2.21563280e-01f, 2.92290270e-01f, -1.28856197e-01f, 1.59447402e-01f, -9.36807692e-02f, -6.64774626e-02f, -1.16193876e-01f, -2.00665966e-02f, 2.27094740e-02f, 6.33000731e-02f,
  1.58600703e-01f, 1.54921979e-01f, -9.25042257e-02f, 8.21381584e-02f, 3.83745357e-02f, -9.64420736e-02f, -5.43744788e-02f, 1.50702730e-01f, 5.88805415e-03f, -2.66842637e-02f,
  -1.60651833e-01f, -8.72979239e-02f, -3.86767164e-02f, 3.00160170e-01f, -1.03630163e-02f, -6.58365935e-02f, 3.57018225e-02f, -1.05365761e-01f, 1.68131199e-02f, -9.54457372e-03f,
  5.92008755e-02f, -4.98550385e-02f, -4.50938903e-02f, -4.87059727e-02f, 1.01209238e-01f, -8.26787502e-02f, 1.08726993e-01f, 1.28006607e-01f, 1.38100833e-01f, -1.38438538e-01f,
  -1.44665286e-01f, 4.65322584e-02f, -1.59841757e-02f, -2.97461897e-02f, -1.42214103e-02f, 4.90357541e-02f, -3.91476415e-03f, 4.24427958e-03f, -3.91606130e-02f, -4.37252335e-02f,
  5.17639704e-02f, -5.94670363e-02f, 1.31960168e-01f, -5.91262430e-02f, -1.13421068e-01f, -5.30145084e-03f, -3.33309080e-03f, -7.04898126e-03f, 9.56383497e-02f, -1.49090871e-01f,
  -1.13995656e-01f, 1.72328055e-01f, 6.48810761e-04f, 2.04165861e-01f, -2.64233835e-02f, -1.41647130e-01f, 7.18284175e-02f, -1.01440571e-01f, -7.06750602e-02f, 4.56210151e-02f,
  -1.17883928e-01f, 1.04757786e-01f, -1.66090667e-01f, 2.99209543e-02f, 1.17236868e-01f, -1.75936952e-01f, -6.90200776e-02f, 9.11707357e-02f, -1.79177970e-01f, -6.76964736e-03f,
  -3.67465653e-02f, -3.50690410e-02f, 9.28603411e-02f, 4.28674230e-03f, 2.12228283e-01f, -3.58281285e-03f, -1.15544625e-01f, -4.32186946e-02f, -1.80018526e-02f, 1.55567871e-02f,
  -2.40219355e-01f, -6.36008620e-01f, -2.20043004e-01f, -9.12208855e-02f, 4.13231879e-01f, 7.60037526e-02f, -2.56649792e-01f, -2.23130062e-01f, -4.11952227e-01f, -5.13983965e-01f,
  -3.07154566e-01f, 6.76465081e-03f, -4.96776223e-01f, -1.55820623e-01f, 6.54756129e-01f, -2.09950000e-01f, -7.65519813e-02f, 6.30016252e-02f, 1.57219306e-01f, -4.37743068e-01f,
  3.41913730e-01f, 2.56733537e-01f, 2.53260463e-01f, 1.16887204e-01f, -1.94153134e-02f, 1.81843251e-01f, 2.68207312e-01f, 2.76180387e-01f, 2.55423307e-01f, 3.01724702e-01f,
  5.27515411e-02f, -4.92635578e-01f, -6.19257540e-02f, 7.70810992e-02f, -1.41450912e-01f, 5.60615957e-02f, 1.45818532e-01f, 1.04561947e-01f, 2.31771663e-01f, 2.90282406e-02f,
  -8.73473845e-03f, 2.35706478e-01f, 1.63914524e-02f, 1.95878863e-01f, 7.56550282e-02f, 5.11990637e-02f, 8.56934711e-02f, -6.92305714e-02f, -1.69022053e-01f, -5.69133684e-02f,
  -1.49052754e-01f, -1.21692196e-02f, -6.18518405e-02f, -6.70433789e-02f, -2.74202917e-02f, 5.78921176e-02f, 1.28447279e-01f, -7.72337476e-03f, 7.98368007e-02f, 1.14536084e-01f,
  -2.80077271e-02f, 4.72146794e-02f, -8.56598616e-02f, -2.50732526e-02f, -2.14042932e-01f, 9.57727358e-02f, 1.45699829e-04f, 5.44239581e-02f, 3.18635441e-02f, 1.87208168e-02f,
  -2.00514980e-02f, -2.38145795e-02f, 2.30523180e-02f, -2.63101775e-02f, -9.75171328e-02f, 2.22388469e-03f, 1.68904305e-01f, 3.54117304e-02f, -2.42983233e-02f, 7.27020390e-03f,
  1.25975199e-02f, 2.74440292e-02f, -1.27363354e-01f, 1.09982699e-01f, -8.38753879e-02f, -2.64461450e-02f, -6.95611686e-02f, -9.09996554e-02f, -1.86821818e-01f, 1.31076947e-01f,
  -1.49737507e-01f, -6.85764372e-01f, -9.10900757e-02f, 1.61083385e-01f, -1.65736373e-03f, -1.18191531e-02f, 5.25879413e-02f, 4.20101918e-03f, -2.22690240e-01f, -2.15371728e-01f,
  5.90251125e-02f, 1.73944563e-01f, -1.13537736e-01f, -8.17618426e-03f, 1.59336805e-01f, -5.92516176e-02f, -1.20698974e-01f, 3.70666012e-02f, -1.58476442e-01f, -8.98091048e-02f,
  -4.61208858e-02f, 6.91649839e-02f, 1.61385357e-01f, 1.49654180e-01f, -1.03886500e-02f, -8.78665783e-03f, -1.95724959e-03f, -1.81210134e-02f, 1.95516959e-01f, -1.82245485e-02f,
  7.36703873e-02f, 8.94715488e-01f, -1.41875371e-02f, 1.65029302e-01f, -2.43777633e-01f, 7.54686892e-01f, 3.40597063e-01f, -2.26342995e-02f, 1.35509416e-01f, 4.02178347e-01f,
  -4.20888424e-01f, 5.75495422e-01f, -4.47666287e-01f, 4.91202056e-01f, 1.83961391e-01f, 1.73434451e-01f, 5.55991054e-01f, 4.22568619e-01f, 2.88525596e-02f, 3.39658447e-02f,
  -1.50894448e-01f, 1.28279448e-01f, -3.49037379e-01f, -3.74981202e-02f, -4.49223386e-04f, 3.62423025e-02f, -4.73203897e-01f, -3.69559437e-01f, 2.59163916e-01f, 9.64113921e-02f,
  1.20500706e-01f, -1.20017268e-01f, 6.62017167e-02f, 2.19263718e-01f, -4.12421450e-02f, -5.07344864e-02f, 1.27989784e-01f, -7.73482472e-02f, -1.65132180e-01f, 5.80579303e-02f,
  1.21811755e-01f, 6.80373833e-02f, 2.19380841e-01f, 6.17316552e-02f, 5.56027293e-02f, 6.93477690e-02f, -5.56914434e-02f, -4.34751995e-02f, 1.76036850e-01f, -9.14230347e-02f,
  8.16495344e-03f, 4.53373976e-02f, -1.42897740e-01f, 9.22605321e-02f, -6.45911023e-02f, 1.30388975e-01f, 2.85169184e-01f, -1.16544366e-01f, 2.76432455e-01f, 2.09194869e-01f,
  -4.50726375e-02f, 1.63441509e-01f, 3.22076469e-03f, 2.48353705e-02f, 4.46583815e-02f, -1.08062036e-01f, 2.39498150e-02f, -8.35500211e-02f, -8.96876082e-02f, 6.32305816e-02f,
  -3.73241352e-03f, 2.55335420e-02f, -6.10917211e-02f, 2.50067711e-02f, -5.23274811e-03f, 9.32745785e-02f, -6.11090623e-02f, 2.76762955e-02f, -6.28994033e-02f, -8.26585740e-02f,
  -7.42713138e-02f, 1.68640614e-01f, -4.20491211e-02f, -1.02949172e-01f, 1.74572542e-01f, -1.71489447e-01f, 4.68061529e-02f, -3.12231742e-02f, -1.01545908e-01f, -8.31552744e-02f,
  2.29838073e-01f, 3.91429871e-01f, 6.31516203e-02f, 7.58957118e-02f, 7.46745020e-02f, -2.50652097e-02f, 8.93031210e-02f, 2.23841503e-01f, 8.51483047e-02f, 1.39233813e-01f,
  -1.74876694e-02f, 4.38480079e-02f, 8.44653547e-02f, -1.04697496e-02f, 1.94078516e-02f, 1.09116606e-01f, 3.47598605e-02f, 9.71800759e-02f, 2.62866751e-03f, -2.07827631e-02f,
  -2.69801654e-02f, -8.28046501e-02f, 4.24024425e-02f, 8.15883949e-02f, 1.37627274e-01f, 1.71112418e-02f, 1.46616325e-01f, -5.75241856e-02f, -8.74778554e-02f, 5.36731146e-02f,
  3.10051143e-01f, 6.47223413e-01f, 6.42879963e-01f, 6.37642026e-01f, -4.73762929e-01f, -5.36809266e-01f, -3.63952219e-01f, 1.96517631e-02f, 1.15899011e-01f, 1.63870245e-01f,
  -1.70889065e-01f, 6.91952229e-01f, -1.99238837e-01f, 3.91571224e-01f, -5.44062436e-01f, -4.35398340e-01f, 2.58152097e-01f, 2.11151376e-01f, -1.42726049e-01f, 4.41423506e-01f,
  9.62602422e-02f, -4.27204072e-01f, 2.26390556e-01f, -1.75248027e-01f, 2.43406594e-01f, 5.70829034e-01f, 9.98587683e-02f, -7.90422410e-02f, 4.28838581e-01f, -2.92504162e-01f,
  -1.93139762e-01f, 4.79455516e-02f, 1.26718432e-01f, 2.77716126e-02f, 7.39846081e-02f, 4.00476865e-02f, 1.04286671e-01f, -1.89371467e-01f, -1.78427011e-01f, 9.18600336e-02f,
  9.99882743e-02f, -1.63295060e-01f, 9.72754359e-02f, -1.39407247e-01f, -1.18823899e-02f, 1.25660956e-01f, 1.14672363e-01f, 1.31524757e-01f, 1.93322763e-01f, 1.19533911e-01f,
  1.93983406e-01f, 2.86431015e-01f, 6.83231577e-02f, 2.01269343e-01f, 3.39986645e-02f, -1.20444156e-01f, 3.10471952e-02f, 2.43824020e-01f, 6.10263124e-02f, 1.04322687e-01f,
  9.62318555e-02f, -4.25797980e-03f, 5.48123615e-03f, -4.22915742e-02f, -1.47663713e-01f, -4.64025624e-02f, 3.92214488e-03f, -1.16753906e-01f, 1.02293398e-02f, -5.42023368e-02f,
  -6.12905100e-02f, -1.96373593e-02f, -7.80678019e-02f, -9.57360640e-02f, 5.97405620e-02f, 9.57411807e-03f, -1.17652759e-01f, 7.77205154e-02f, 1.64117157e-01f, 5.25259972e-02f,
  1.24440528e-02f, -1.66853249e-01f, -1.64629202e-02f, 2.23624744e-02f, -2.54649520e-01f, 8.17572922e-02f, 1.13901921e-01f, 1.21822804e-01f, -5.13522476e-02f, -4.77119237e-02f,
  6.20123707e-02f, 3.72815013e-01f, 1.55868575e-01f, -1.54754773e-01f, 6.15832210e-02f, 4.49453779e-02f, -8.33545178e-02f, 1.30458578e-01f, 8.89889821e-02f, -8.95126686e-02f,
  1.93841070e-01f, -6.71323016e-02f, 6.10504597e-02f, -3.67406681e-02f, -6.24331906e-02f, -1.98446605e-02f, -3.66295800e-02f, 1.09539934e-01f, 2.29341667e-02f, 2.00395927e-01f,
  1.85125813e-01f, -1.09657556e-01f, -1.39899300e-02f, -4.19061631e-02f, -3.20223207e-03f, 4.34624888e-02f, -3.80508427e-04f, 5.71308695e-02f, 1.80311892e-02f, 9.21412930e-02f,
  3.60791922e-01f, 2.60943741e-01f, -6.70302093e-01f, -2.69848049e-01f, -1.82369038e-01f, 5.34472048e-01f, 5.03579795e-01f, -2.27845088e-01f, -3.18084121e-01f, 6.55287743e-01f,
  4.22966093e-01f, -1.57088354e-01f, 4.73983973e-01f, 6.73655927e-01f, -1.68221027e-01f, 4.96768057e-01f, 3.75456482e-01f, 3.09137762e-01f, -2.22032338e-01f, 2.12697104e-01f,
  -1.78834617e-01f, 7.43570149e-01f, -1.70766577e-01f, 1.00811660e-01f, 3.81954402e-01f, -5.42747915e-01f, -1.36078242e-02f, -4.49338049e-01f, -8.52518622e-03f, -1.02840230e-01f,
  3.79470102e-02f, -9.31534916e-03f, -8.24572816e-02f, -2.12393655e-03f, 9.49876085e-02f, 9.87224504e-02f, -6.67650923e-02f, -6.82691932e-02f, -1.44755080e-01f, 5.98317087e-02f,
  1.71515912e-01f, 1.42323878e-02f, 3.89079824e-02f, -3.94160748e-02f, -6.16305368e-03f, 9.45840869e-03f, -1.63504601e-01f, -1.21333599e-01f, -1.55462906e-01f, 1.38127446e-01f,
  -2.27885190e-02f, 3.12172808e-02f, 1.50267659e-02f, -7.67383426e-02f, -1.12264588e-01f, -5.19636013e-02f, -9.99637470e-02f, -5.00572240e-03f, -1.59068201e-02f, -5.08593507e-02f,
  7.53566697e-02f, 7.27662742e-02f, 1.85470670e-01f, 2.23285053e-03f, 6.59962893e-02f, 1.25132790e-02f, -4.63133939e-02f, -2.60915365e-02f, -1.67858973e-01f, 2.18014970e-01f,
  -6.37197495e-02f, -7.44031519e-02f, 3.76248732e-02f, 1.12592101e-01f, 1.22073002e-01f, 5.20419553e-02f, -2.09963899e-02f, -6.68701343e-03f, -8.09844136e-02f, -1.52543500e-01f,
  -2.06589722e-03f, 6.64755777e-02f, 5.17372973e-02f, 1.59143284e-02f, 1.49271354e-01f, -1.03116378e-01f, 1.93248570e-01f, 1.94581021e-02f, -1.95675101e-02f, -3.05421818e-02f,
  2.60897242e-02f, 6.83082715e-02f, -9.52085704e-02f, -2.66768690e-02f, -3.56052518e-02f, 1.28014699e-01f, 6.18241029e-03f, 5.18049337e-02f, -9.85758156e-02f, 2.24061266e-01f,
  1.19226143e-01f, -1.31853715e-01f, 6.70746192e-02f, -2.80616368e-04f, -2.11660683e-01f, 1.49592683e-01f, 9.42035317e-02f, -1.54599831e-01f, -3.37168239e-02f, -3.12744007e-02f,
  4.04285789e-02f, 1.30341902e-01f, 6.79387599e-02f, 5.14004305e-02f, -6.68702349e-02f, 1.27792254e-01f, -6.99061453e-02f, -1.31571218e-01f, 1.32345296e-02f, -7.67744258e-02f,
  9.99529004e-01f, -8.39058518e-01f, 2.25678906e-02f, 6.46402597e-01f, 5.34956872e-01f, 8.50614384e-02f, 4.61251765e-01f, 4.49986234e-02f, 1.17166996e-01f, -6.70926213e-01f,
  2.91883707e-01f, -2.96270132e-01f, -5.05372703e-01f, 1.70793101e-01f, 4.03453857e-01f, -4.34227288e-01f, 3.14680874e-01f, 8.40902403e-02f, 4.37262990e-02f, 1.41468896e-02f,
  3.61621737e-01f, 1.92155793e-01f, 1.62127495e-01f, -2.60258377e-01f, 2.95019388e-01f, 5.75275868e-02f, -1.94312334e-01f, -3.46887618e-01f, 6.16642497e-02f, 4.81315441e-02f,
  -1.84456155e-01f, 1.16709061e-01f, 1.57007918e-01f, -1.58770278e-01f, -3.23563404e-02f, 3.49034257e-02f, -6.59689233e-02f, 6.99214116e-02f, 1.39648393e-01f, -4.15194817e-02f,
  -4.61334996e-02f, 1.37082651e-01f, -7.49765150e-03f, -4.78646606e-02f, 6.83589955e-04f, 8.64382163e-02f, -5.00251167e-02f, 4.44198810e-02f, -3.58239934e-02f, 3.68546210e-02f,
  8.19246769e-02f, 3.02787740e-02f, 1.62890777e-01f, -9.57361248e-04f, 3.27764340e-02f, 4.27370593e-02f, 3.44358757e-02f, -1.07734306e-02f, -8.60801637e-02f, -5.95864318e-02f,
  1.94080304e-02f, -6.56149462e-02f, -1.01074331e-01f, 7.84587022e-03f, 7.17038363e-02f, 1.84204951e-01f, -8.06823671e-02f, 1.01656187e-02f, -1.12590224e-01f, -6.50905371e-02f,
  1.25331819e-01f, 4.49559540e-02f, -2.89371237e-02f, -6.60731420e-02f, 5.19954190e-02f, 1.33549487e-02f, 1.22439399e-01f, -9.90071371e-02f, 9.88187175e-03f, 1.96934901e-02f,
  -7.15970024e-02f, -8.12644064e-02f, -1.31254956e-01f, 6.84511513e-02f, -8.70218351e-02f, -1.30715877e-01f, -9.38032344e-02f, 6.41479418e-02f, 8.30133073e-03f, -2.00727656e-02f,
  -1.17316782e+00f, -9.15592611e-01f, -1.91102967e-01f, 6.84483210e-03f, -1.85023010e-01f, -9.21683684e-02f, 7.29582226e-03f, 3.30729000e-02f, -3.21433812e-01f, 4.01652418e-02f,
  -5.07338345e-02f, 3.53751183e-02f, -1.04452990e-01f, 5.59834614e-02f, -5.66355288e-02f, -7.60401189e-02f, -1.41793653e-01f, -1.75568312e-01f, 3.65992934e-02f, -9.08826143e-02f,
  -1.67127438e-02f, -1.97793301e-02f, 9.09285694e-02f, 6.14422373e-02f, 4.87788990e-02f, -1.59208924e-02f, -1.61754355e-01f, -2.44273245e-02f, -5.15764467e-02f, -2.76272520e-02f,
  5.19008279e-01f, -1.84707731e-01f, 3.68757099e-01f, -2.50538319e-01f, 4.31485206e-01f, 7.02048481e-01f, 4.52877060e-02f, 3.49980950e-01f, 2.75331914e-01f, -2.39826962e-01f,
  -2.18975004e-02f, -6.50158286e-01f, -1.50020629e-01f, -2.57990807e-01f, 5.64989030e-01f, 3.83418314e-02f, -4.26826291e-02f, -6.00726902e-01f, -5.89032881e-02f, -3.77482355e-01f,
  -1.36394829e-01f, -5.10415971e-01f, -9.05106589e-02f, -4.83071744e-01f, -2.58616626e-01f, -2.71107167e-01f, -4.74292755e-01f, -4.31847304e-01f, -3.59489053e-01f, -2.68273205e-02f,
  1.84954703e-01f, 2.73738205e-02f, 1.02475822e-01f, -3.17822695e-02f, 1.85719728e-01f, 3.40299383e-02f, -3.00052345e-01f, -1.47961423e-01f, -2.37695943e-03f, 1.16044901e-01f,
  -2.24218264e-01f, -2.34952256e-01f, -9.77663174e-02f, 2.80048605e-02f, 1.50148526e-01f, 1.86990768e-01f, -1.10540660e-02f, 2.39871040e-01f, -1.89950634e-02f, 1.09907404e-01f,
  1.04678996e-01f, 2.10954528e-03f, 1.81791678e-01f, -2.31432199e-01f, 7.42232725e-02f, 6.44056723e-02f, 9.39711630e-02f, -4.96157678e-03f, 1.62417293e-02f, 1.67935580e-01f,
  -9.19999033e-02f, -2.42773746e-03f, 1.72152475e-01f, 6.40620887e-02f, 1.48346305e-01f, 1.08174525e-01f, 1.48735017e-01f, 6.51468039e-02f, 8.72065723e-02f, -4.00803685e-02f,
  2.54267137e-02f, -3.87851894e-02f, -2.43282467e-02f, 1.50321238e-02f, 3.49433795e-02f, 6.15367806e-03f, -1.54301196e-01f, -1.08619362e-01f, 6.56785816e-03f, 2.16521338e-01f,
  -1.61621988e-01f, 1.47572225e-02f, 1.05311442e-02f, -1.91799536e-01f, 3.68792042e-02f, -5.84953185e-03f, -1.54039457e-01f, 8.85036066e-02f, 5.63916564e-02f, -1.72080606e-01f,
  1.15097225e-01f, -4.03488338e-01f, -2.08941810e-02f, -2.26973459e-01f, -3.27867232e-02f, 2.22963676e-01f, -1.33757859e-01f, 1.28592551e-01f, -1.52862534e-01f, -2.17359792e-02f,
  1.62370373e-02f, -2.02854529e-01f, 1.25151679e-01f, 1.41555786e-01f, -4.21435721e-02f, 1.52326033e-01f, -4.97180700e-01f, -1.49965197e-01f, -1.79460701e-02f, -8.89125243e-02f,
  -2.42180794e-01f, -2.20451981e-01f, -1.26779214e-01f, -6.80649281e-02f, -1.37763873e-01f, 1.26630033e-03f, 1.04393221e-01f, -6.99150264e-02f, -4.57319319e-02f, -7.46021643e-02f,
  6.01468205e-01f, -3.95682126e-01f, -2.57846057e-01f, 6.27833068e-01f, 3.06375980e-01f, 6.94531202e-01f, 8.49856973e-01f, 2.80136615e-01f, 6.48581088e-01f, 2.73601711e-02f,
  3.47252399e-01f, -2.84111142e-01f, -2.79264987e-01f, 5.60930312e-01f, 4.93886113e-01f, 1.43608069e-02f, 5.35570443e-01f, 4.06034887e-01f, 6.99498355e-02f, 2.44235367e-01f,
  2.85750449e-01f, 5.53407609e-01f, -1.70919687e-01f, -3.75321060e-01f, 1.07161142e-01f, -4.09051299e-01f, -3.10059130e-01f, -2.68977821e-01f, -6.89137280e-02f, 1.68407992e-01f,
  1.47362426e-01f, 1.81353390e-01f, -1.62031688e-02f, -6.57614246e-02f, -9.03490745e-03f, -5.86702712e-02f, -3.10566872e-02f, -1.47019133e-01f, -2.21768022e-02f, 6.93792943e-03f,
  -8.11058208e-02f, -1.35286391e-01f, 1.45912707e-01f, -4.98650521e-02f, 1.93861216e-01f, -1.46906987e-01f, -7.85746127e-02f, -7.36336708e-02f, -2.04914078e-01f, -1.23442665e-01f,
  8.76527652e-02f, -8.61543939e-02f, 1.58296824e-01f, -3.56191918e-02f, -4.09400985e-02f, 4.23966572e-02f, 1.34742800e-02f, -1.83858484e-01f, -1.84956327e-01f, 6.22116961e-02f,
  -3.52010913e-02f, 1.33536011e-01f, -5.56084104e-02f, -4.93610427e-02f, -1.15641370e-01f, 2.95655951e-02f, 1.24408491e-01f, -8.27634409e-02f, -1.49067026e-02f, -1.18264556e-02f,
  -6.39892370e-02f, 1.61454886e-01f, 1.02592543e-01f, -1.17996797e-01f, 2.38306761e-01f, 3.24903168e-02f, 3.87928374e-02f, -6.08330630e-02f, 1.79264069e-01f, -2.82128546e-02f,
  -4.32945155e-02f, 1.01725817e-01f, -1.21426292e-01f, -4.23888899e-02f, 9.35157090e-02f, 4.02163640e-02f, -1.97564010e-02f, 4.58235592e-02f, 5.85467890e-02f, 3.48123275e-02f,
  8.17793906e-02f, -2.40782220e-02f, 7.52572492e-02f, -5.40602319e-02f, -1.04844473e-01f, -4.04527672e-02f, -2.10644789e-02f, 1.43361725e-02f, -1.01563893e-01f, 2.53005810e-02f,
  1.44299492e-01f, -2.66720261e-02f, -1.13998957e-01f, 3.03114858e-02f, 4.02380638e-02f, 5.45905121e-02f, 1.73113674e-01f, 3.28588188e-02f, 6.30328357e-02f, -1.11688219e-01f,
  -1.31415814e-01f, 1.26567796e-01f, -5.24958409e-02f, 1.08076790e-02f, -6.03528023e-02f, -4.87230159e-03f, 1.76633775e-01f, -2.87356060e-02f, -2.06147149e-01f, 8.05006325e-02f,
  7.91347206e-01f, -5.62644005e-01f, -1.93077296e-01f, 2.77183473e-01f, -7.55898654e-02f, -1.24701425e-01f, 5.39471328e-01f, -4.24678445e-01f, 5.10995269e-01f, -4.24650043e-01f,
  -3.85745585e-01f, 2.89849281e-01f, 3.34575415e-01f, -5.57881296e-01f, 6.76356673e-01f, 3.19506288e-01f, -3.37856151e-02f, 5.24605885e-02f, 1.03265800e-01f, -2.57247597e-01f,
  1.46774262e-01f, -3.13712269e-01f, -2.36088216e-01f, -5.01028180e-01f, -1.61105618e-01f, -2.64182746e-01f, -2.01931402e-01f, -2.36856490e-02f, -6.63082838e-01f, -4.10042517e-02f,
  -1.87712871e-02f, 7.22152218e-02f, -5.39256930e-02f, 5.00904210e-02f, -1.20355450e-01f, 9.58792958e-03f, 4.79480401e-02f, 1.48428395e-01f, 1.34701401e-01f, 7.33752847e-02f,
  1.57990471e-01f, 1.40293494e-01f, 6.12021126e-02f, 1.07829534e-01f, 1.45266533e-01f, -1.07033372e-01f, 2.65306253e-02f, -1.57532007e-01f, -1.87577426e-01f, 5.25726238e-03f,
  1.58249527e-01f, -1.78900715e-02f, 4.32208441e-02f, -1.36531651e-01f, 7.25152194e-02f, -2.34302413e-02f, 1.69327240e-02f, 6.64972421e-03f, 1.06993057e-01f, 8.62348527e-02f,
  4.46897093e-03f, 1.01360731e-01f, 4.85006608e-02f, -9.33272112e-03f, 8.31193253e-02f, -1.02447368e-01f, 6.81267353e-03f, -1.48941666e-01f, 6.38020113e-02f, -4.08459902e-02f,
  1.07218325e-01f, 5.75114824e-02f, -3.34119424e-02f, 7.37080127e-02f, -6.75297678e-02f, -7.11724237e-02f, 8.35192017e-03f, 4.79523875e-02f, 1.20783739e-01f, 9.37495157e-02f,
  3.21721323e-02f, 1.84621766e-01f, 8.79122503e-03f, -7.07126632e-02f, -6.92354888e-02f, 1.59203988e-02f, -4.75874543e-02f, 4.64375839e-02f, -3.86633202e-02f, 1.32634342e-01f,
  -1.07703201e-01f, -2.32116625e-01f, -7.19971359e-02f, -9.52185467e-02f, -1.41430885e-01f, -7.27754831e-02f, 1.76679306e-02f, -1.80439465e-02f, -2.92741377e-02f, 2.82028038e-02f,
  -1.38197303e-01f, 6.56300187e-02f, 4.63247113e-02f, -7.68420175e-02f, -9.32694450e-02f, -1.42090037e-01f, 6.84088320e-02f, -1.38614299e-02f, -2.33097989e-02f, -1.75849870e-01f,
  -1.33603932e-02f, 1.05835304e-01f, 9.88716632e-02f, 4.79625389e-02f, -1.22915410e-01f, 1.03270903e-01f, 2.64845192e-02f, -1.40181318e-01f, 7.53721818e-02f, 5.71197420e-02f,
  3.90375495e-01f, 2.73352712e-01f, 1.65153906e-01f, -1.31500080e-01f, -1.97405994e-01f, -5.06058097e-01f, -7.88182735e-01f, 7.61713162e-02f, -5.02634645e-01f, -5.86819112e-01f,
  -2.78461754e-01f, -2.35644743e-01f, 3.19736362e-01f, -8.96058306e-02f, 6.48846567e-01f, 4.61685359e-01f, 2.44634464e-01f, -2.96282560e-01f, 6.15137994e-01f, 4.24987704e-01f,
  5.12530267e-01f, 7.16168210e-02f, 6.86043978e-01f, 3.59084755e-01f, 2.54858732e-01f, 2.68600494e-01f, 3.55721116e-01f, 1.19237363e-01f, -2.93687433e-01f, -1.55691907e-01f,
  -1.08107485e-01f, 6.26127422e-02f, 4.24968712e-02f, -1.90084338e-01f, 1.81474194e-01f, -1.28909796e-01f, -9.34310537e-03f, -4.22546640e-02f, -1.11343123e-01f, -2.42162272e-01f,
  -2.23948434e-02f, 9.58546400e-02f, -7.14420527e-02f, -5.22364210e-03f, -1.64311994e-02f, -4.16173264e-02f, 1.68219388e-01f, 2.92387959e-02f, -2.51817495e-01f, 1.43731326e-01f,
  2.98159979e-02f, 7.14782625e-02f, 3.12369652e-02f, 7.17584863e-02f, 2.03784853e-02f, -1.64106622e-01f, -2.59700585e-02f, -6.56400025e-02f, -1.88741505e-01f, 2.75146980e-02f,
  1.63284361e-01f, 4.86012250e-02f, -5.83440019e-03f, -1.07228592e-01f, -9.43957195e-02f, 8.79822578e-03f, 2.80719865e-02f, -6.46750629e-02f, -8.96846817e-04f, 1.13657219e-02f,
  -2.04777777e-01f, 1.18413985e-01f, -1.59087226e-01f, -2.15992108e-01f, 1.70132741e-01f, 3.20704840e-02f, 1.35332569e-01f, 2.28710137e-02f, -1.82712510e-01f, -5.46062812e-02f,
  -1.05988808e-01f, -1.47038065e-02f, -1.56819331e-03f, -1.49220955e-02f, -1.73995897e-01f, -1.61341310e-01f, 4.53310795e-02f, -5.14281318e-02f, 1.43556356e-01f, 4.74218912e-02f,
  1.42469388e-02f, 2.44161069e-01f, -1.82922184e-01f, -2.10246161e-01f, 1.68772209e-02f, 5.12747802e-02f, -5.54252565e-02f, -9.60298553e-02f, -1.86130609e-02f, 6.08935654e-02f,
  3.70904393e-02f, 4.18939302e-03f, -1.85858995e-01f, -3.70802358e-02f, -4.32659015e-02f, -3.00523639e-03f, 8.45400319e-02f, -3.45356286e-01f, -2.17762038e-01f, 1.63094416e-01f,
  -3.81586701e-02f, 4.63603474e-02f, 5.48245609e-02f, -1.76253598e-02f, -1.78493008e-01f, 1.06399099e-03f, 6.18397705e-02f, -1.40321717e-01f, 1.38514176e-01f, -4.49112765e-02f,
  -7.73291588e-01f, -1.34467214e-01f, -2.63987303e-01f, -1.49355575e-01f, 1.95113167e-01f, -6.94209993e-01f, -6.03586972e-01f, 3.57525349e-01f, -1.90334752e-01f, 2.29403079e-01f,
  1.09996989e-01f, -6.49712324e-01f, 2.03325465e-01f, -5.76113999e-01f, -4.73322660e-01f, -5.25273979e-01f, -4.26827848e-01f, -4.62033033e-01f, -3.13118666e-01f, 1.22744162e-02f,
  -9.99945775e-03f, 2.63008714e-01f, 6.42973259e-02f, 6.40371561e-01f, 1.83611233e-02f, 3.16757292e-01f, 7.64776170e-01f, 3.07508051e-01f, 1.54731750e-01f, -4.31887060e-02f,
  -2.11687818e-01f, 1.28852099e-01f, -1.56589982e-03f, -4.24709283e-02f, 7.55983144e-02f, 9.45983902e-02f, 5.68693839e-02f, -3.05151008e-02f, -8.70734304e-02f, 2.18058713e-02f,
  -3.46728973e-02f, 5.14783673e-02f, 1.19500887e-02f, -3.33806761e-02f, 2.97461692e-02f, 6.26499504e-02f, 2.11442932e-02f, -1.21293999e-01f, -4.10151333e-02f, -2.63510138e-01f,
  -1.61395580e-01f, -8.40199143e-02f, -2.72054598e-02f, 1.93876341e-01f, -6.66247755e-02f, 2.58655399e-02f, -7.99432695e-02f, -6.36073425e-02f, 7.33614340e-02f, -1.17055349e-01f,
  6.05189167e-02f, -6.01690076e-02f, -7.93298557e-02f, -6.83545992e-02f, -1.10258959e-01f, 1.36549801e-01f, 6.75546750e-02f, -1.35694281e-03f, -3.62834195e-03f, -3.48992972e-03f,
  8.67862478e-02f, 3.66794541e-02f, -1.94241051e-02f, 2.89826486e-02f, -9.79636759e-02f, -5.60427643e-02f, -1.11588590e-01f, 5.46937250e-03f, -4.32890318e-02f, -1.45179793e-01f,
  2.41998807e-01f, -1.08367525e-01f, 6.99863881e-02f, 8.85807574e-02f, -1.23522609e-01f, 1.37345493e-01f, 7.43017569e-02f, -1.58925354e-01f, 3.41810565e-03f, 1.31923050e-01f,
  1.77572563e-01f, 6.06539845e-01f, 1.59682244e-01f, 3.30512449e-02f, 9.33806747e-02f, -4.38456200e-02f, -1.28229603e-01f, -6.63563833e-02f, 1.48041859e-01f, -4.82908003e-02f,
  1.58880174e-01f, 4.21632081e-02f, 1.50501877e-01f, -2.24327631e-02f, 1.17902830e-01f, 8.77478719e-02f, 1.70259550e-01f, 2.16828004e-01f, 2.49048144e-01f, 2.55780190e-01f,
  4.11926508e-01f, 6.96652522e-03f, 6.05570450e-02f, 4.10075039e-02f, 1.43128514e-01f, 1.28291756e-01f, 6.54824683e-03f, -3.79983373e-02f, 9.40292180e-02f, 1.41819239e-01f,
  2.06420109e-01f, -6.13205612e-01f, -5.09807944e-01f, -6.78929612e-02f, 5.47159910e-02f, 4.05550182e-01f, -2.81546593e-01f, -4.63648587e-02f, -6.77914619e-01f, -1.32962525e-01f,
  4.44499254e-01f, -1.19088897e-02f, -3.71889472e-01f, 8.06191504e-01f, 6.64853334e-01f, 1.08813755e-02f, 5.34497619e-01f, 4.63699967e-01f, -1.38431609e-01f, 1.34328559e-01f,
  2.09080264e-01f, 7.57742763e-01f, 3.52901578e-01f, 5.49975693e-01f, 5.33449233e-01f, -3.15680578e-02f, 2.04620659e-01f, 5.29739410e-02f, 5.43818593e-01f, 5.43080628e-01f,
  1.58682689e-01f, -1.07539169e-01f, -5.76481335e-02f, -9.21944156e-02f, -1.36507740e-02f, -1.49954231e-02f, 7.87304565e-02f, 2.95071304e-01f, -3.25552635e-02f, -3.14691802e-03f,
  -7.85751939e-02f, 1.38176516e-01f, 1.93788320e-01f, -1.24371250e-03f, -3.07859350e-02f, -1.17285088e-01f, -1.97589338e-01f, -9.47729126e-02f, -1.07310764e-01f, 2.25633513e-02f,
  -2.82649398e-01f, -7.05037564e-02f, -7.22182393e-02f, 2.26021688e-02f, -1.69570640e-01f, -2.02402145e-01f, -2.46388406e-01f, -4.98118810e-02f, -1.14049591e-01f, -7.72955567e-02f,
  7.86630288e-02f, -6.11714385e-02f, -3.72594297e-02f, -2.09475867e-02f, -7.59285269e-03f, 4.82699983e-02f, -4.99438494e-02f, 7.16494396e-02f, -7.49353468e-02f, -2.62663551e-02f,
  5.23101166e-02f, -1.23555601e-01f, -9.47612396e-04f, -1.17453717e-01f, 2.13750061e-02f, -1.62677199e-01f, 6.08424768e-02f, 9.32087749e-02f, -1.93174198e-01f, 1.03796506e-02f,
  -5.07540293e-02f, 9.41804424e-02f, 1.18178930e-02f, 2.77364124e-02f, -2.11435207e-03f, 4.25566472e-02f, 2.30093226e-01f, 1.28921106e-01f, 7.65290111e-02f, 9.43436846e-02f,
  6.69398457e-02f, -2.25696061e-02f, -5.15251048e-02f, -1.76433511e-02f, 2.40969043e-02f, 1.87441304e-01f, 8.53584781e-02f, 2.50929743e-02f, 1.05503634e-01f, 6.85027661e-03f,
  8.75177011e-02f, -1.35159478e-01f, 1.05909146e-01f, 1.37634009e-01f, 2.46162433e-02f, 8.25747568e-03f, -4.87425476e-02f, -1.13200195e-01f, 9.68152508e-02f, 1.49710789e-01f,
  -1.48047935e-02f, -1.65744767e-01f, 1.13255545e-01f, -1.19942091e-01f, -6.32478371e-02f, 5.89791015e-02f, -1.30205671e-03f, -9.76029560e-02f, 1.92014411e-01f, -7.74339661e-02f,
  -4.20427561e-01f, -7.19933689e-01f, 3.94487679e-01f, -2.68458985e-02f, 1.81305289e-01f, 2.28840545e-01f, 3.24475616e-01f, -4.46284443e-01f, -8.16133380e-01f, -4.71348733e-01f,
  6.40439987e-02f, 3.37679731e-03f, 5.68228550e-02f, -4.09522951e-01f, 6.42060995e-01f, -4.51360971e-01f, -2.76750773e-01f, 6.36243001e-02f, -2.43111119e-01f, 3.84386301e-01f,
  2.83945948e-02f, -1.06220409e-01f, 4.53164279e-01f, -7.84491599e-02f, -1.55043855e-01f, 1.87817797e-01f, 6.49536192e-01f, 5.97142458e-01f, 3.49096566e-01f, 1.74079359e-01f,
  -2.79058754e-01f, -2.81419665e-01f, 2.63994392e-02f, -1.99787453e-01f, 3.47471586e-03f, 6.99653327e-02f, 2.21934035e-01f, 3.10647339e-01f, 1.14148416e-01f, 1.01849511e-01f,
  5.52644879e-02f, 2.14464813e-01f, -3.55182923e-02f, 2.01068059e-01f, -6.68572038e-02f, -9.43378806e-02f, -2.04150751e-01f, -1.00580662e-01f, 2.01312602e-02f, 1.22825935e-01f,
  7.68334186e-03f, -2.93526471e-01f, -4.65200692e-02f, 5.07196237e-04f, 1.13292448e-01f, -1.18689544e-01f, -1.26528302e-02f, 2.02872708e-01f, -3.83137092e-02f, 7.85477161e-02f,
  -1.24956414e-01f, 5.18516526e-02f, -8.30907226e-02f, -1.41424805e-01f, -8.07227120e-02f, -3.07973400e-02f, -4.40498702e-02f, -5.52377552e-02f, 1.14929974e-01f, -2.24793255e-01f,
  2.43929196e-02f, -5.80033325e-02f, -1.76920071e-01f, -1.91275459e-02f, -1.23584196e-02f, -3.20292175e-01f, 1.91558912e-01f, 2.31172498e-02f, -2.99007073e-02f, 1.92220770e-02f,
  -2.41634343e-02f, 1.27170816e-01f, 4.21922281e-03f, 5.95134981e-02f, -8.72639492e-02f, -3.62015190e-03f, -2.41635423e-02f, -1.88145731e-02f, 3.81873432e-03f, 2.39561975e-01f,
  -5.97731955e-03f, 1.52468368e-01f, -7.70482793e-03f, 1.90265721e-03f, 4.83486168e-02f, 1.55294500e-02f, -1.84820339e-01f, -5.80398142e-02f, 1.01229534e-01f, -2.49858163e-02f,
  -2.03142092e-02f, 2.25553706e-01f, -1.49071664e-01f, 6.61964761e-03f, 4.67481837e-02f, 4.35676798e-02f, 1.00063808e-01f, -8.06543678e-02f, 7.60817826e-02f, 7.75569007e-02f,
  -9.74875838e-02f, 4.99664433e-02f, -3.06179468e-02f, -1.12051718e-01f, -1.79596722e-01f, 1.66772738e-01f, 3.58399414e-02f, 4.36550053e-03f, 9.92587730e-02f, 2.95581259e-02f,
  -5.55075884e-01f, -3.04433793e-01f, -2.53544524e-02f, -4.74743396e-02f, -1.43372998e-01f, 1.60482422e-01f, 9.41076398e-01f, -5.43261588e-01f, -3.57513845e-01f, 2.59819984e-01f,
  2.79562950e-01f, 2.93758325e-03f, 6.14039302e-01f, 2.15323821e-01f, 1.51559621e-01f, 5.86805284e-01f, 7.59264594e-03f, 1.81466579e-01f, -3.33456099e-01f, -4.23022956e-01f,
  -2.02575028e-01f, -1.75884798e-01f, 5.25239766e-01f, -7.95163214e-01f, -7.98784345e-02f, -5.73713660e-01f, 5.10723554e-02f, 7.30123371e-02f, -2.49124169e-01f, 1.75416782e-01f,
  -2.25152627e-01f, -5.16185820e-01f, 1.67153671e-01f, -1.08809032e-01f, -7.44947344e-02f, 1.06193379e-01f, 3.02159190e-01f, 2.91521877e-01f, 3.79315205e-02f, -7.57039245e-03f,
  9.11158845e-02f, -2.79267102e-01f, -3.40097636e-01f, 3.24888416e-02f, -1.55640393e-01f, -2.19661996e-01f, 1.70833152e-02f, 1.85624421e-01f, -1.19810579e-02f, 5.87169528e-02f,
  1.04558527e-01f, 8.10994115e-03f, 1.87387858e-02f, 1.16550811e-01f, 7.84307495e-02f, -2.36059099e-01f, 1.54860273e-01f, 2.32079253e-01f, -1.02857031e-01f, -1.59445465e-01f,
  6.97432980e-02f, 1.70056168e-02f, 7.86042958e-02f, -5.79383522e-02f, 3.91443074e-02f, -4.01769131e-02f, 9.52503011e-02f, 2.15846390e-01f, -4.91971299e-02f, 6.60790652e-02f,
  -2.56464750e-01f, -1.06846774e-02f, -8.03439394e-02f, -4.05919105e-02f, 5.84729761e-02f, -2.26639286e-02f, 9.73106474e-02f, -1.15149863e-01f, -9.86801758e-02f, 1.27345547e-01f,
  5.81194945e-02f, -1.13107808e-01f, 6.43459931e-02f, 1.60583004e-01f, -1.01397224e-01f, 1.84420899e-01f, -1.41908482e-01f, 4.23911698e-02f, -2.25262577e-03f, 1.04148686e-01f,
  -4.18724626e-01f, -6.21119559e-01f, 1.08665123e-03f, -1.49879247e-01f, 1.22806147e-01f, -3.95609327e-02f, 2.73154732e-02f, -1.27013862e-01f, -6.08895011e-02f, -3.35688796e-03f,
  -1.83666751e-01f, 1.99562274e-02f, -2.59541214e-01f, -3.48109081e-02f, -8.18455219e-02f, 7.09982298e-04f, 2.81592235e-02f, -8.93436279e-03f, 2.06152685e-02f, -2.66038567e-01f,
  -3.15826349e-02f, -4.61779535e-02f, -9.73290764e-03f, -1.21034466e-01f, -7.72597119e-02f, 7.74206147e-02f, -1.43041641e-01f, -2.06831038e-01f, -6.45530298e-02f, -6.46454543e-02f,
  7.02779353e-01f, 4.08612847e-01f, 6.33806288e-01f, 7.68271506e-01f, -1.83134049e-01f, -6.44222915e-01f, -1.34186894e-01f, 1.84212700e-01f, 4.60101306e-01f, -3.06988358e-01f,
  -2.56009549e-01f, 3.85875851e-01f, -7.09647536e-01f, 4.08889323e-01f, 9.51413140e-02f, -6.44655645e-01f, 5.61982214e-01f, -7.94040859e-02f, 9.82801467e-02f, 3.47196162e-01f,
  5.62353611e-01f, -1.30485401e-01f, 3.61840904e-01f, -8.48304033e-02f, 4.03243124e-01f, 5.19318819e-01f, -2.30431724e-02f, -2.67394096e-01f, 4.17898953e-01f, -2.81619370e-01f,
  -7.90195260e-03f, 1.13446563e-01f, 2.64415026e-01f, 3.19196773e-03f, 7.41907358e-02f, 1.26474826e-02f, -2.39579026e-02f, -2.92266607e-01f, -4.27236073e-02f, 7.54419155e-03f,
  8.77075717e-02f, 3.52290608e-02f, 1.30502298e-01f, -5.12058809e-02f, 1.31487012e-01f, 2.94223011e-01f, 1.85014844e-01f, 4.06509042e-02f, 1.46398440e-01f, 9.93693918e-02f,
  2.89770156e-01f, 5.56336343e-02f, 6.65157661e-02f, 9.03828815e-02f, 1.70046955e-01f, 2.07044557e-01f, 6.14006519e-02f, 4.79101837e-02f, 1.08981699e-01f, 2.54391134e-01f,
  1.31530231e-02f, -7.59458393e-02f, -5.75128980e-02f, -2.80784164e-02f, 6.39840737e-02f, 5.46204597e-02f, 1.86001640e-02f, -4.44595404e-02f, -2.02635536e-03f, -1.06183469e-01f,
  6.29464760e-02f, 1.62865624e-01f, -1.61482334e-01f, 6.04982376e-02f, 9.25555527e-02f, 1.92186370e-01f, -1.50067568e-01f, -2.11213246e-01f, 1.99791119e-01f, 8.31936076e-02f,
  -2.67552789e-02f, -1.19183175e-01f, -7.71149993e-03f, -5.12082800e-02f, -1.07030511e-01f, -1.95926651e-01f, 8.02689567e-02f, 8.91228616e-02f, -4.43484895e-02f, -1.35399383e-02f,
  -6.29891083e-02f, 2.94870764e-01f, -3.06734461e-02f, -1.91159938e-02f, -4.99663353e-02f, 8.63372907e-02f, -6.86321557e-02f, 1.47651389e-01f, 4.70012240e-02f, -4.55629230e-02f,
  4.82226051e-02f, 6.30948097e-02f, -1.09614052e-01f, -2.37333961e-02f, -3.07362303e-02f, -4.66890913e-03f, -3.37414108e-02f, 8.39151666e-02f, 4.60924283e-02f, -5.50827086e-02f,
  -4.84193210e-03f, -1.26820385e-01f, 2.04707593e-01f, 2.16725454e-01f, 4.96187285e-02f, -3.07295788e-02f, 2.15469394e-02f, 3.35024111e-02f, -1.23034026e-02f, -5.10004275e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.68848336e-01f, 7.10186541e-01f, 4.10702795e-01f, 7.20618784e-01f, 6.37140334e-01f, 2.86097795e-01f, 6.50103986e-01f, 6.82560861e-01f, 6.91448271e-01f, 8.36816907e-01f,
  6.57817960e-01f, 2.09902823e-01f, 5.08167148e-01f, 7.57042825e-01f, 6.00318968e-01f, 3.25755864e-01f, 3.06892425e-01f, 4.96308327e-01f, 5.67556918e-01f, 7.20642328e-01f,
  4.37785804e-01f, 7.94590950e-01f, 4.76978123e-01f, 7.32295454e-01f, 4.69254732e-01f, 7.25239396e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  4.30310696e-01f, -5.22555709e-01f, -1.12473436e-01f, -5.62791862e-02f, 2.60105312e-01f, -3.80261779e-01f, -4.21047479e-01f, 6.27852976e-01f, -7.39332497e-01f, -9.52690423e-01f,
  3.98037106e-01f, 2.93883294e-01f, 7.82778382e-01f, -2.95545727e-01f, -7.56255805e-01f, -1.25773740e+00f, 4.81752574e-01f, 4.44375902e-01f, -7.28011072e-01f, 4.39902619e-02f,
  -3.61562163e-01f, 5.18032908e-01f, -1.64637566e-01f, -6.67221844e-01f, 5.15590869e-02f, -6.00530326e-01f, -4.72690314e-01f, -1.31352171e-01f, -1.77982643e-01f, -7.34092653e-01f,
  7.78360844e-01f, -9.41569686e-01f, -7.32813954e-01f, -4.92294014e-01f, -1.51093572e-01f, 5.33798218e-01f, 5.52300155e-01f, 8.25600624e-01f, -4.59960312e-01f, 6.34337008e-01f,
  -7.89845884e-01f, -3.37134659e-01f, -1.02486539e+00f, -8.50919604e-01f, -6.56238317e-01f, 5.30861735e-01f, -5.04210666e-02f, 1.57498091e-01f, -6.80275500e-01f, -3.73124808e-01f,
  -6.24489725e-01f, 2.35088661e-01f, -5.48882067e-01f, 8.42635810e-01f, -2.73593545e-01f, 9.21627656e-02f, 5.66897035e-01f, 1.05882965e-01f, 3.82696450e-01f, -5.53730249e-01f,
  5.85284770e-01f, -6.86173141e-01f, -8.31506774e-02f, -4.41196412e-01f, -7.85715163e-01f, 9.32349563e-02f, -8.81942827e-03f, 3.52588207e-01f, -4.64056909e-01f, -2.37615451e-01f,
  -3.30140769e-01f, 9.17755812e-03f, -4.81118888e-01f, -3.01032305e-01f, -3.62699628e-01f, -2.07254499e-01f, -2.60909110e-01f, -1.94924906e-01f, -5.63381612e-01f, -7.06090868e-01f,
  -4.90556389e-01f, -5.42636633e-01f, 7.89177120e-01f, 1.39587849e-01f, -5.51239550e-01f, -8.42445612e-01f, 6.40104592e-01f, -9.10716712e-01f, 2.82848120e-01f, -3.09611946e-01f,
  -4.45117444e-01f, 1.51978090e-01f, 7.54946887e-01f, 3.90772104e-01f, -7.52042651e-01f, 1.18312493e-01f, -7.00675786e-01f, -1.03939176e-01f, -9.83426645e-02f, -2.95389742e-01f,
  1.08188629e+00f, 7.56981373e-01f, 4.74169075e-01f, -6.41702652e-01f, 3.77846092e-01f, 4.93134946e-01f, -8.35810125e-01f, 7.27200091e-01f, 1.96684390e-01f, -6.95234761e-02f,
  4.56885666e-01f, -3.79367560e-01f, -1.60818443e-01f, 2.86199600e-01f, -8.02071989e-01f, -6.25586092e-01f, -3.96847546e-01f, -1.14832185e-01f, -2.27743506e-01f, -1.06813645e+00f,
  -5.13224661e-01f, -8.94856989e-01f, -4.08721447e-01f, 6.04393959e-01f, -6.55764043e-01f, -1.00026178e+00f, -2.20927387e-01f, -3.82055342e-01f, 1.00543108e-02f, 4.92469639e-01f,
  -1.66608095e-01f, -6.11387074e-01f, 8.14201906e-02f, -6.47981167e-01f, 4.34302300e-01f, 2.57555455e-01f, 2.12726191e-01f, 5.68839729e-01f, 2.10015848e-01f, 8.63620043e-02f,
  4.71467406e-01f, -2.59828806e-01f, -9.55321729e-01f, 1.85572758e-01f, 6.91289902e-01f, -8.45675588e-01f, 2.12580681e-01f, -1.57501340e-01f, -5.78197539e-01f, -5.20484269e-01f,
  -6.39405370e-01f, 7.40329444e-01f, -1.24050879e+00f, -8.75125945e-01f, 5.92578232e-01f, -2.81603664e-01f, 1.65988117e-01f, 2.75260340e-02f, -3.32508944e-02f, -7.89656758e-01f,
  6.02784276e-01f, 2.42344245e-01f, 4.27602023e-01f, 4.29858953e-01f, 7.69330382e-01f, -3.72765154e-01f, -1.07817352e+00f, -1.09302366e+00f, 5.12447715e-01f, -7.22125232e-01f,
  3.50153387e-01f, -2.14221865e-01f, 5.32728791e-01f, 3.78321439e-01f, -5.77059209e-01f, 7.54510939e-01f, 1.43179789e-01f, 2.78503865e-01f, -6.39126122e-01f, 7.58792281e-01f,
  4.60684896e-02f, 6.58361837e-02f, -1.12351656e+00f, -2.20688254e-01f, 2.66564757e-01f, 3.21697742e-01f, -7.55557775e-01f, -5.23733139e-01f, -8.27268124e-01f, -1.07799158e-01f,
  -5.71958840e-01f, 4.18132395e-01f, 1.78029433e-01f, 1.47476494e-01f, 1.33418605e-01f, 5.02825677e-01f, -2.57538587e-01f, -8.63683894e-02f, -5.76029718e-01f, -2.30231538e-01f,
  -7.73904562e-01f, 4.74430680e-01f, 4.81331825e-01f, -2.45953679e-01f, -8.40674527e-03f, -2.84908861e-01f, -8.84587094e-02f, 2.88285404e-01f, -1.20057011e+00f, -4.80685025e-01f,
  -1.32799834e-01f, -8.13234687e-01f, -7.24844217e-01f, -3.21923316e-01f, 8.76007080e-01f, 5.12325823e-01f, 6.49593771e-01f, 4.61726636e-01f, -1.82851478e-01f, -1.85224250e-01f,
  -9.18895841e-01f, -4.42970008e-01f, -4.77355510e-01f, 5.39128423e-01f, 1.19316503e-02f, -3.15535516e-01f, -5.23575246e-01f, -2.41995320e-01f, -4.69443291e-01f, -4.62887943e-01f,
  5.62829152e-02f, -3.69800031e-01f, 6.10687435e-01f, -5.25772393e-01f, -3.96281540e-01f, 7.77656659e-02f, -4.64624673e-01f, -7.22807646e-01f, 1.79666668e-01f, -4.59801704e-01f,
  -2.84007221e-01f, 7.16448545e-01f, 4.25887644e-01f, -2.50450850e-01f, -2.55364716e-01f, -4.17865008e-01f, -6.91053927e-01f, 4.49912965e-01f, -4.47743237e-01f, 5.31526566e-01f,
  2.64188021e-01f, 2.03161854e-02f, -5.53044677e-01f, -5.71040511e-01f, 1.13317929e-02f, -4.49284464e-01f, -8.63308981e-02f, -2.34834209e-01f, -1.95392653e-01f, -2.19866753e-01f,
  4.93732840e-01f, 2.98307329e-01f, -6.45052254e-01f, 1.46437004e-01f, -3.80703539e-01f, -6.00579977e-01f, 1.39696524e-01f, -4.81440455e-01f, 1.06314629e-01f, -8.14172387e-01f,
  -5.77072084e-01f, 1.70817852e-01f, -6.55732632e-01f, -2.53272951e-01f, -4.47057813e-01f, -3.39467853e-01f, 5.48742115e-01f, -4.59744543e-01f, -4.21576589e-01f, -5.12409568e-01f,
  -3.44634980e-01f, -4.91540521e-01f, 5.72282374e-01f, 4.25503254e-01f, 1.80418894e-01f, 3.68715882e-01f, -4.43270206e-01f, 7.57973075e-01f, 1.43006071e-01f, -1.10343143e-01f,
  -3.06379050e-01f, -4.42512810e-01f, -6.00537658e-01f, -5.42601407e-01f, -3.86086524e-01f, -5.42597234e-01f, -1.25559777e-01f, -6.91457510e-01f, 4.21061128e-01f, -8.68871689e-01f,
  -7.65636444e-01f, -5.54797113e-01f, -1.69709533e-01f, 1.15836889e-01f, 6.18510842e-01f, -5.42920887e-01f, 2.80715615e-01f, -1.03848648e+00f, -5.23421645e-01f, -3.59138191e-01f,
  2.60453731e-01f, 2.21021026e-02f, -4.09937389e-02f, 6.53197408e-01f, -5.72028058e-03f, -6.34924710e-01f, -7.57136419e-02f, 7.90954232e-01f, 9.16829824e-01f, -9.25720394e-01f,
  6.73396766e-01f, 2.71302700e-01f, 4.41504955e-01f, -3.85946520e-02f, -7.08807230e-01f, -1.37251010e-03f, 1.43267736e-01f, 7.70859778e-01f, -7.12838590e-01f, -2.60280460e-01f,
  -5.00299037e-01f, -4.14839566e-01f, -6.71249390e-01f, 8.29049051e-01f, 6.55764401e-01f, -5.98489881e-01f, -8.03051054e-01f, -7.51492321e-01f, -5.27194068e-02f, -3.26280057e-01f,
  -1.17028713e-01f, 1.73595164e-03f, -6.28016233e-01f, -8.47310126e-02f, -4.61651385e-01f, -1.72758341e-01f, -3.25415850e-01f, 6.87372804e-01f, -5.68550766e-01f, 6.02699459e-01f,
  -2.67959803e-01f, -6.32590830e-01f, 1.03867888e-01f, -1.90893278e-01f, -3.00843474e-02f, -1.86998397e-01f, -5.75138032e-01f, 5.26826680e-01f, 6.58577502e-01f, -1.61607414e-01f,
  -1.63768306e-01f, 5.09659529e-01f, 5.11920899e-02f, -6.31134391e-01f, -1.32268071e-01f, -3.78287971e-01f, 4.22074497e-01f, -2.13524207e-01f, -3.79354209e-02f, -1.42115653e-02f,
  -6.56357646e-01f, 2.65379369e-01f, 7.98014104e-01f, -6.67385757e-01f, -4.65902053e-02f, -1.91127017e-01f, -5.98796606e-01f, -3.15041691e-01f, -7.31252372e-01f, -9.43348706e-01f,
  -5.49225926e-01f, -3.75765055e-01f, -2.43970901e-01f, 6.95796967e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.34239376e-01f, 6.57026656e-03f, 5.62616400e-02f, 1.80042181e-02f, 2.73555845e-01f, 2.65558600e-01f, -8.05234537e-02f, -2.52207577e-01f, -8.95598084e-02f, -5.64169958e-02f,
  1.45594645e-02f, 1.79140836e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    