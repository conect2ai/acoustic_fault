/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.80261481e-01f, 5.45638263e-01f, 8.74922425e-02f, 1.88498363e-01f, -2.08993837e-01f, 1.04156360e-01f, 6.53529540e-04f, 1.88798055e-01f, 2.44710028e-01f, 1.97717443e-01f,
  -2.45699063e-01f, 1.71164140e-01f, -9.97948647e-03f, 9.46180522e-02f, -1.96659222e-01f, 9.68914106e-02f, 1.36863634e-01f, 2.35894676e-02f, 1.10101141e-01f, 5.80724254e-02f,
  4.80984524e-02f, 4.18122485e-03f, -1.05755158e-01f, -9.20957793e-03f, 6.54622838e-02f, 1.85261160e-01f, -1.67392015e-01f, -8.63307714e-02f, 1.73835997e-02f, -1.51103243e-01f,
  -2.68529039e-02f, 6.93750009e-02f, -2.97116805e-02f, -7.12757409e-02f, -2.88987774e-02f, -6.86748847e-02f, -3.89457084e-02f, -1.29864082e-01f, -4.02557626e-02f, 5.88954100e-03f,
  1.56352594e-02f, -4.43441309e-02f, 1.83373019e-02f, -4.84655518e-03f, 5.05690947e-02f, -2.38743494e-03f, -1.57118794e-02f, -3.18543874e-02f, -2.32247636e-02f, 1.65438764e-02f,
  -4.73692715e-02f, -1.08253071e-03f, -2.71764714e-02f, -4.97801527e-02f, -2.81399628e-03f, 3.82451750e-02f, -1.75820489e-03f, -2.71901079e-02f, 1.25305075e-02f, 8.82938057e-02f,
  8.18604678e-02f, 1.94112472e-02f, -2.24530119e-02f, -1.26470448e-02f, 2.67732013e-02f, -3.45210508e-02f, 7.49385962e-03f, -4.70777266e-02f, 8.16929713e-03f, -3.83848660e-02f,
  -3.68052423e-02f, -6.37425226e-04f, -2.20220760e-02f, 2.69729719e-02f, 2.30183080e-02f, 4.31448594e-02f, -7.30316117e-02f, 1.36731248e-02f, 7.96401128e-03f, -8.05916637e-03f,
  -3.02490033e-02f, 1.75457317e-02f, 2.24577892e-03f, -1.51765775e-02f, -7.56942714e-03f, -2.03291215e-02f, 1.92299094e-02f, 6.31053001e-02f, -1.06481798e-02f, -3.36130708e-02f,
  1.07055441e-01f, 3.49081397e-01f, 1.74020361e-02f, 1.70924198e-02f, 3.15209031e-02f, -3.71617475e-03f, -7.02462066e-03f, 6.52927384e-02f, -1.56989805e-02f, 4.61377725e-02f,
  -3.48862782e-02f, 1.03956293e-02f, -1.63845420e-02f, -1.21763051e-02f, -2.58373804e-02f, 1.28172711e-02f, -4.27384228e-02f, -2.26062667e-02f, -5.97736761e-02f, 1.30479280e-02f,
  1.70625988e-02f, -1.09016392e-02f, -2.17454433e-02f, -3.74133326e-02f, -1.98498610e-02f, -7.42978677e-02f, 8.12122822e-02f, 2.83503998e-02f, -3.34625281e-02f, 1.41503951e-02f,
  3.95914763e-01f, -3.05830121e-01f, 1.23084679e-01f, 2.78827786e-01f, 1.11145973e-01f, 8.53650346e-02f, 2.25206167e-01f, -2.40538847e-02f, -7.57553279e-02f, -1.97594255e-01f,
  4.53989431e-02f, 3.82202715e-02f, -1.51137367e-01f, 7.61274025e-02f, 3.62439513e-01f, -3.12505573e-01f, 1.73149601e-01f, -5.90051375e-02f, -8.52458477e-02f, 1.11648589e-01f,
  4.23571020e-02f, 4.61766012e-02f, 1.01231948e-01f, -1.21828184e-01f, 2.28932127e-01f, -3.35361548e-02f, 4.81091514e-02f, -3.78363393e-02f, -3.29147303e-03f, -3.91844958e-02f,
  -2.00715140e-02f, -1.14968449e-01f, 4.79082391e-02f, -7.26365298e-02f, 4.84282225e-02f, 2.34817546e-02f, 2.93602478e-02f, 2.80127451e-02f, 5.06531596e-02f, -6.71780556e-02f,
  -3.47954147e-02f, 5.00118546e-02f, -3.86304893e-02f, -3.13728675e-02f, 5.58608845e-02f, 1.01861339e-02f, 1.05696479e-02f, 3.06837354e-02f, -3.36084403e-02f, 2.91366149e-02f,
  -5.05689159e-03f, 1.13158617e-02f, 6.01564124e-02f, -5.76958023e-02f, -1.18125137e-02f, 3.77947912e-02f, 1.63166095e-02f, 5.12589794e-03f, -4.64220718e-02f, -1.80189740e-02f,
  -3.03690545e-02f, -1.22481612e-02f, 5.66961952e-02f, 1.57541502e-02f, 8.50588977e-02f, -3.22423615e-02f, 2.21325178e-02f, 1.10990917e-02f, 1.72639620e-02f, 6.93444461e-02f,
  5.94198983e-03f, 5.81412837e-02f, -4.53998633e-02f, 2.96560302e-02f, 3.01679466e-02f, 2.41629947e-02f, 5.76640405e-02f, -8.00957531e-02f, 3.23782489e-03f, 6.06426336e-02f,
  -5.32331057e-02f, 2.30525713e-02f, 7.46613881e-03f, -1.45036075e-02f, -1.69010852e-02f, 3.35107818e-02f, -5.90866804e-02f, -1.79892946e-02f, 2.80268919e-02f, 4.87410203e-02f,
  8.84938892e-03f, -1.68366790e-01f, -2.24525128e-02f, -4.10308596e-03f, -7.61812404e-02f, 3.55586633e-02f, -5.50698340e-02f, -4.21113186e-02f, -5.90744875e-02f, 3.31837796e-02f,
  -2.55101454e-03f, 2.42368039e-02f, -2.44298466e-02f, 4.26742770e-02f, 8.58402625e-03f, -8.43805354e-03f, -3.34127545e-02f, 7.21451768e-04f, 3.38940434e-02f, -1.11511201e-02f,
  5.83261997e-02f, -1.09962206e-02f, -3.08340639e-02f, 4.16408740e-02f, -5.36502078e-02f, -1.66257136e-02f, 3.49265151e-02f, 6.74317591e-03f, -3.56967747e-02f, -1.77089311e-02f,
  5.66068012e-03f, -2.52505898e-01f, 8.58720616e-02f, 9.94681939e-02f, -1.66673269e-02f, -1.03954159e-01f, 8.58408213e-02f, 2.44887453e-02f, 3.13564613e-02f, -9.51430649e-02f,
  8.09312016e-02f, -8.34904090e-02f, 1.52297989e-01f, 2.17074722e-01f, 3.02443504e-01f, 1.23963207e-01f, 5.44373058e-02f, -7.21464027e-03f, 1.11876301e-01f, 6.31081164e-02f,
  2.37074211e-01f, 2.22007528e-01f, 3.11795056e-01f, 8.52927789e-02f, 7.96596557e-02f, -5.82537390e-02f, 2.01983944e-01f, 9.49241966e-02f, -5.82346553e-03f, 6.23948574e-02f,
  3.07410024e-02f, -5.51311253e-03f, 7.42321387e-02f, -7.36299381e-02f, -7.23403916e-02f, -6.04137518e-02f, -4.40224670e-02f, 1.00592762e-01f, 1.82358678e-02f, -2.09946409e-02f,
  -6.27600551e-02f, 2.68008783e-02f, -4.35913391e-02f, -3.42940763e-02f, -6.59263209e-02f, -8.49175546e-03f, -3.46355587e-02f, -8.06455908e-04f, 3.68608944e-02f, 5.92657737e-02f,
  3.41527238e-02f, -5.16801029e-02f, 4.48606052e-02f, 3.24960821e-03f, 8.01991001e-02f, 1.54189356e-02f, 5.49634881e-02f, 3.55450233e-04f, -7.14056268e-02f, -2.73794704e-03f,
  -4.62951213e-02f, 1.39347906e-03f, 8.45814403e-03f, 1.28603331e-03f, -4.57615070e-02f, 4.20148671e-02f, -4.04466456e-03f, -2.62938556e-06f, -3.01860049e-02f, -3.25171128e-02f,
  -1.61108989e-02f, -3.99873331e-02f, 1.49336392e-02f, 1.80885270e-02f, -5.19446004e-03f, 6.23333221e-03f, -2.50090864e-02f, -2.20236927e-03f, 1.25386612e-02f, 3.25314403e-02f,
  6.10215310e-03f, -2.33624950e-02f, 7.59295328e-03f, 4.18858156e-02f, -2.57996656e-02f, -1.63370986e-02f, -7.74613023e-03f, 1.84454639e-02f, -2.82881092e-02f, 2.46252567e-02f,
  -2.33366936e-01f, 3.20712961e-02f, 4.40503992e-02f, 2.06553768e-02f, -9.22773872e-03f, -6.30445704e-02f, 5.21524027e-02f, -3.41281928e-02f, 2.85667600e-03f, 4.85683233e-02f,
  1.26531059e-02f, -7.62944901e-03f, -5.63056059e-02f, 6.95049018e-02f, -2.16343012e-02f, 2.23477986e-02f, 2.08696816e-02f, -8.15541223e-02f, -7.16138771e-03f, 1.55756925e-03f,
  -3.20981187e-03f, 7.66362855e-03f, 6.50549075e-03f, 4.99724410e-02f, 2.59446967e-02f, -1.49839791e-02f, -6.13458082e-02f, -3.07491887e-03f, -1.45730628e-02f, -5.06171286e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.50998642e-02f, 5.24617955e-02f, -2.08562121e-01f, -1.49070501e-01f, -1.07297607e-01f, -8.24043974e-02f, -1.86207548e-01f, 6.92429813e-03f, 2.29884143e-04f, 1.06496289e-01f,
  3.61012556e-02f, 1.60575192e-02f, 1.77402750e-01f, -9.97031555e-02f, -6.83184862e-02f, 8.83961543e-02f, -1.16596170e-01f, -1.54735073e-01f, 3.25624309e-02f, -8.18197206e-02f,
  1.13575803e-02f, -8.05835128e-02f, -3.42309591e-03f, -6.58958554e-02f, -2.07652107e-01f, -7.89339915e-02f, -9.48769599e-02f, -1.33362144e-01f, -2.57403869e-02f, 1.13139972e-02f,
  1.19767347e-02f, 7.96977505e-02f, 1.61725786e-02f, 3.82460691e-02f, 1.10504380e-03f, 2.19530743e-02f, -1.29194215e-01f, -2.41143685e-02f, -6.51203096e-02f, -9.53331664e-02f,
  1.32900542e-02f, 3.49834971e-02f, -7.44535625e-02f, -5.46439700e-02f, 6.06146501e-03f, -5.81742339e-02f, -8.66799578e-02f, -3.71868275e-02f, 4.89984313e-03f, -6.01930134e-02f,
  -8.92961770e-02f, -9.44873765e-02f, -6.64038630e-03f, -1.55528747e-02f, -2.52566077e-02f, -7.34633729e-02f, 2.51939856e-02f, -1.42300632e-02f, 3.05502936e-02f, -8.64762217e-02f,
  -1.03661017e-02f, -4.69119996e-02f, 4.09554131e-02f, -8.33726227e-02f, -7.70181883e-03f, 1.26090376e-02f, -2.65465844e-02f, 4.78230976e-02f, -5.68669103e-02f, -1.42384162e-02f,
  -6.33185133e-02f, 4.99930978e-02f, -1.03946151e-02f, -4.46809642e-02f, 1.87743735e-02f, -5.59351742e-02f, -2.91845092e-04f, 5.84144406e-02f, -4.08069007e-02f, -5.07026501e-02f,
  -4.85245921e-02f, 3.69662605e-02f, 5.07465675e-02f, -2.63145305e-02f, 8.73103345e-05f, 2.82023754e-02f, 2.16537453e-02f, 6.85869008e-02f, -5.26811481e-02f, -3.56472135e-02f,
  -1.07960992e-01f, -5.23279272e-02f, 1.80775821e-02f, -4.59432155e-02f, -8.84234160e-02f, -1.03332244e-01f, 2.80827563e-02f, -9.73490775e-02f, -8.20254833e-02f, 2.74779461e-02f,
  -1.75270147e-03f, -4.82037999e-02f, -1.21273413e-01f, 4.10981737e-02f, -6.46655262e-02f, 7.45339040e-03f, -8.88137892e-02f, 1.23823853e-02f, -2.24091709e-02f, 4.24634665e-02f,
  -3.23160961e-02f, -5.01309223e-02f, -5.71588874e-02f, 1.27398530e-02f, -9.66062248e-02f, -1.97608247e-02f, -3.27744074e-02f, -3.98910046e-02f, 1.11653525e-02f, -7.48445168e-02f,
  1.23184793e-01f, 3.56812537e-01f, 4.16491210e-01f, 2.18854934e-01f, -1.29655883e-01f, -4.33822721e-02f, 1.19142823e-01f, -6.74154907e-02f, -1.22604035e-02f, 9.92493853e-02f,
  -1.40311256e-01f, 4.32265878e-01f, -8.33361968e-02f, 8.56033415e-02f, -1.51905060e-01f, -1.86545134e-01f, -7.11690187e-02f, 1.45581529e-01f, -1.90947000e-02f, 5.15775420e-02f,
  -1.25014141e-01f, -2.15339079e-01f, -1.72253139e-02f, -1.89747974e-01f, 1.66051954e-01f, 1.66783020e-01f, -1.43247738e-01f, 5.55842817e-02f, 2.04558149e-01f, 3.11837345e-02f,
  1.54767837e-02f, -8.21049884e-02f, 7.58837909e-02f, 9.82232988e-02f, -6.59364322e-03f, 3.25603783e-02f, 1.12339906e-01f, -3.11599653e-02f, 1.48739619e-02f, 6.30242527e-02f,
  7.85380527e-02f, 5.05888183e-03f, -1.51290779e-03f, 1.17206313e-02f, 2.47292519e-02f, 8.67133960e-02f, -3.51532921e-03f, 1.21123023e-01f, 9.84254032e-02f, 1.82411019e-02f,
  1.54444382e-01f, 4.46531251e-02f, 7.03311786e-02f, 1.02730654e-01f, 1.21203037e-02f, -6.65003210e-02f, 4.40733172e-02f, 1.19207762e-02f, -1.05688376e-02f, -1.26325723e-03f,
  7.61548281e-02f, -1.06234729e-01f, 5.69570251e-02f, -4.69978005e-02f, -5.24456333e-03f, 6.21064454e-02f, 5.69655886e-03f, 4.70011234e-02f, -2.95041874e-02f, 6.35159835e-02f,
  6.50503561e-02f, 3.48759741e-02f, -2.82756053e-02f, -2.48250626e-02f, -2.67086290e-02f, 1.49992900e-02f, 4.34572771e-02f, -1.74954124e-02f, 8.38467851e-02f, -7.53457472e-02f,
  -2.61815414e-02f, -7.67218322e-02f, -7.75059909e-02f, -5.89033961e-02f, -4.32613678e-02f, -5.02566211e-02f, -1.38287647e-02f, 4.12423909e-02f, -2.23307312e-03f, 4.84617725e-02f,
  -2.94953380e-02f, 5.54455817e-03f, 3.40094939e-02f, 5.52335642e-02f, 1.41614052e-02f, 1.73584390e-02f, -1.93722285e-02f, -2.45692227e-02f, -1.13599911e-01f, -2.29235794e-02f,
  2.53732540e-02f, 3.65249850e-02f, 4.73559611e-02f, -5.28441742e-03f, 7.51543697e-03f, -2.89284475e-02f, -2.87087411e-02f, -3.95647585e-02f, 2.99952980e-02f, -4.25615758e-02f,
  -1.80080254e-03f, 3.99537524e-03f, -9.41906124e-03f, 4.79695834e-02f, -6.47642314e-02f, -5.51166162e-02f, -4.22580242e-02f, -3.85610536e-02f, -2.24741977e-02f, -6.18068837e-02f,
  1.27383426e-01f, 1.11431196e-01f, -2.00490028e-01f, -1.40055671e-01f, 1.09315500e-01f, -7.20055997e-02f, -6.59436360e-02f, 4.26248685e-02f, -2.81414539e-01f, 1.48350894e-01f,
  2.38198414e-01f, -2.04140052e-01f, -6.55348366e-03f, -1.76629975e-01f, -9.83001962e-02f, -2.16756374e-01f, 1.12204868e-02f, -5.80940209e-02f, -1.59185380e-01f, 2.63251007e-01f,
  -8.24705139e-02f, 9.79137197e-02f, -2.01943696e-01f, 1.48622319e-01f, 1.21733524e-01f, 1.64380729e-01f, 4.09086436e-01f, 1.06274962e-01f, 1.78516373e-01f, -6.87069446e-02f,
  -9.29019526e-02f, -1.75314043e-02f, -1.57065511e-01f, -1.48578346e-01f, 1.50432199e-01f, 1.11701071e-01f, 6.04487173e-02f, -7.91294798e-02f, -1.23871900e-01f, -6.32729009e-02f,
  4.79213111e-02f, -1.08376235e-01f, -5.42133301e-02f, -5.08627854e-02f, -3.78201492e-02f, -1.03488460e-01f, -8.38897154e-02f, -6.37070984e-02f, -1.15356304e-01f, -3.08821234e-03f,
  -1.47472145e-02f, -1.50867859e-02f, 7.12009445e-02f, 9.65949707e-03f, -1.64871253e-02f, -8.94199940e-04f, 2.31369399e-02f, 4.50879410e-02f, 1.12719141e-01f, -3.08032203e-02f,
  9.63970348e-02f, -4.64656651e-02f, 5.30074723e-02f, -8.54410082e-02f, 2.87726801e-02f, 1.76472086e-02f, -3.58882956e-02f, -1.17326099e-02f, -3.59980240e-02f, 4.59101461e-02f,
  1.24519309e-02f, 3.88927944e-02f, 2.85133291e-02f, 3.83921042e-02f, 3.48194167e-02f, -6.10885620e-02f, -5.08194417e-02f, 4.75103296e-02f, -4.14959267e-02f, 1.09017354e-04f,
  -7.94569179e-02f, 1.40187554e-02f, -2.44121719e-03f, 3.60493511e-02f, -2.72724945e-02f, 6.35192217e-03f, -8.64362251e-03f, 2.56705135e-02f, -7.23879505e-03f, -2.11309809e-02f,
  2.03892052e-01f, 3.98284584e-01f, 6.61050295e-03f, -5.57444524e-03f, -2.09522173e-02f, 2.65056901e-02f, -9.49925464e-03f, 3.91508527e-02f, 9.19846073e-03f, 3.10557764e-02f,
  1.59746170e-01f, -5.59766181e-02f, 1.22192964e-01f, 8.11552629e-03f, 3.41996551e-03f, 1.08749874e-01f, 1.93035230e-02f, 4.86057848e-02f, 1.76798910e-01f, 6.19218498e-02f,
  9.58018750e-02f, -2.02998472e-03f, -5.41498400e-02f, 1.12133157e-02f, 4.48924750e-02f, 5.63906804e-02f, 1.24843135e-01f, 1.99366012e-03f, 1.16484955e-01f, 2.40004575e-03f,
  5.91040015e-01f, -2.00799182e-01f, -4.00610328e-01f, 7.07053542e-02f, 2.39818633e-01f, 2.45441735e-01f, 9.53527614e-02f, 2.14125849e-02f, -3.11120991e-02f, -9.44466442e-02f,
  1.86743692e-01f, -1.18580893e-01f, -2.51390159e-01f, 2.99966425e-01f, 2.37357691e-01f, -6.10818006e-02f, 2.11796001e-01f, 1.48385555e-01f, -3.03530265e-02f, 3.55864167e-02f,
  7.16113299e-02f, 3.21685702e-01f, -2.37307310e-01f, 3.06083951e-02f, 2.37830415e-01f, -1.21195048e-01f, -1.19683206e-01f, -2.67916828e-01f, 8.79316851e-02f, 8.05149302e-02f,
  1.20579630e-01f, 6.75350055e-02f, -3.12475897e-02f, 8.26758239e-03f, 2.53321659e-02f, 1.67481229e-02f, -7.32127130e-02f, 3.45743075e-02f, -3.66322994e-02f, -2.86648013e-02f,
  -5.30685950e-03f, 7.79413730e-02f, -2.46455241e-03f, 1.60730686e-02f, 7.71154761e-02f, -3.45845334e-02f, -5.29779494e-02f, -2.10665092e-02f, -1.24832608e-01f, 1.59022063e-02f,
  -2.87979338e-02f, -6.31250143e-02f, 1.66058782e-02f, -2.10219882e-02f, -7.71108270e-03f, 7.44249159e-03f, -1.39174629e-02f, -4.57473956e-02f, 2.58024111e-02f, 1.05178848e-01f,
  7.00607523e-02f, 1.03651090e-02f, 3.11509427e-02f, 9.69896913e-02f, 5.71141131e-02f, -5.06563075e-02f, -2.19598524e-02f, 2.10109316e-02f, -1.94541421e-02f, 5.20025529e-02f,
  -8.14080238e-03f, 2.33260076e-03f, 5.60506359e-02f, 3.01562827e-02f, 4.08037007e-02f, -2.50703953e-02f, -8.75145569e-03f, 1.50474543e-02f, -2.48988383e-02f, -2.15681586e-02f,
  -4.75013666e-02f, 3.50726768e-02f, -7.98288807e-02f, -2.29778644e-02f, -3.66358683e-02f, 1.78628843e-02f, 4.48039360e-02f, 4.48289923e-02f, -2.28197444e-02f, 4.81846482e-02f,
  -1.91511977e-02f, -1.87291205e-01f, -1.04086913e-01f, -3.57870348e-02f, -6.85675740e-02f, 3.88920084e-02f, -4.04549241e-02f, 4.64048162e-02f, -6.96863383e-02f, 3.79530266e-02f,
  -5.01412675e-02f, -9.49565694e-03f, 2.05595009e-02f, -2.30951775e-02f, -7.68291056e-02f, 4.48408872e-02f, -4.30087298e-02f, -2.54064775e-03f, -1.17516592e-02f, 2.98881438e-02f,
  -7.06848428e-02f, 1.20035689e-02f, -1.23853907e-02f, -2.66459994e-02f, -1.44295944e-02f, -7.29203923e-03f, -1.68165099e-02f, -2.93213371e-02f, -1.50074447e-02f, -9.14009884e-02f,
  -2.52408355e-01f, 1.09865665e-01f, 1.01625144e-01f, -1.59768507e-01f, 2.12846801e-01f, -1.65898427e-01f, -7.26704374e-02f, 1.52659208e-01f, 1.60562009e-01f, 1.36128291e-01f,
  1.72855519e-02f, -2.29457114e-02f, 1.05818324e-01f, -1.26660198e-01f, -5.11214733e-01f, -1.36541680e-01f, -4.36816722e-01f, -1.74680799e-01f, 4.31657657e-02f, -8.56225342e-02f,
  -2.20810398e-01f, 1.46039268e-02f, -1.02321751e-01f, 2.29734614e-01f, 2.61733402e-02f, 7.78094400e-03f, -1.37012303e-01f, 2.61922777e-01f, 1.54886190e-02f, -3.82262352e-03f,
  9.23580304e-03f, 2.66199261e-01f, 6.31500781e-02f, 6.28912300e-02f, 2.91247871e-02f, 1.93603747e-02f, -9.13507640e-02f, 4.53444980e-02f, -5.54390624e-02f, 2.86822002e-02f,
  -2.87532080e-02f, -4.40573273e-03f, -6.08984716e-02f, 8.90222937e-02f, 1.30954012e-01f, 3.82233784e-02f, 2.81147007e-02f, -4.45660912e-02f, 1.19919673e-01f, 1.22570889e-02f,
  7.96248689e-02f, -6.67019635e-02f, 2.63538724e-03f, -7.29428902e-02f, -3.36638209e-03f, -1.28875636e-02f, -4.65178341e-02f, -1.25659153e-01f, -3.84735204e-02f, -2.94586103e-02f,
  -4.77558486e-02f, -4.80780527e-02f, -1.64238233e-02f, 3.45236994e-02f, 1.38409454e-02f, 3.99806211e-03f, 5.39316284e-03f, 5.49931545e-03f, 2.74716467e-02f, 6.78460300e-03f,
  -2.60859169e-02f, 8.23218748e-02f, 2.43738741e-02f, -6.56973347e-02f, -3.51346307e-03f, 3.45125832e-02f, -7.77472928e-02f, 1.01831984e-02f, -1.93469021e-02f, -9.46402028e-02f,
  -1.46514538e-03f, 2.05661710e-02f, 1.28898872e-02f, 2.53015459e-02f, 2.35521179e-02f, 7.20447376e-02f, 3.54472622e-02f, 7.19841383e-03f, -1.27601931e-02f, -8.88534486e-02f,
  -9.73224491e-02f, 5.23275696e-04f, 7.61024877e-02f, 2.16961522e-02f, -3.60692032e-02f, -3.42257395e-02f, -9.70551744e-04f, -5.08218147e-02f, -5.13594635e-02f, 6.78797960e-02f,
  -2.21190485e-03f, -4.67991829e-02f, -6.14481717e-02f, 4.88016829e-02f, -5.18535301e-02f, -7.80025646e-02f, -2.91014332e-02f, 1.21551612e-02f, -2.16174498e-02f, 4.15972807e-02f,
  2.67396611e-03f, -9.06956475e-03f, -1.99692068e-03f, -9.17071626e-02f, 2.79804654e-02f, -5.14910333e-02f, -6.23833239e-02f, 6.57483265e-02f, -9.48555185e-04f, 2.05965266e-02f,
  -2.42502064e-01f, 2.60320842e-01f, 1.14391342e-01f, -7.33404979e-02f, 6.38019741e-02f, -5.79717569e-02f, 1.80910733e-02f, 1.40796201e-02f, 1.23181827e-01f, -7.32692778e-02f,
  5.42877428e-02f, -1.07759096e-01f, 1.06915027e-01f, -1.58226117e-03f, -2.20908463e-01f, -8.39122459e-02f, -1.99374467e-01f, -1.73136607e-01f, 8.33666846e-02f, -4.87354100e-02f,
  -2.39585005e-02f, 5.43800145e-02f, -3.43975495e-03f, 2.11630210e-01f, -2.31868438e-02f, 8.87206197e-02f, -8.45407695e-02f, 1.16413027e-01f, -9.12358984e-02f, 6.49410859e-02f,
  -1.21963866e-01f, -1.78313300e-01f, -1.24096885e-01f, -6.08165264e-02f, -8.54289979e-02f, -9.89478976e-02f, -1.74782947e-01f, -9.53364745e-02f, -1.86390337e-02f, 2.54877619e-02f,
  -7.22210705e-02f, 4.66757128e-03f, 4.33535315e-02f, 1.30795140e-03f, 6.47459179e-02f, 2.94905994e-02f, -3.47875394e-02f, 9.32033733e-03f, 7.78075457e-02f, 6.16837712e-03f,
  3.92846540e-02f, 2.99275890e-02f, -9.59214792e-02f, -8.42969194e-02f, -3.55344750e-02f, 2.31776964e-02f, 1.20788869e-02f, 2.88878884e-02f, -7.06116483e-02f, 2.54795998e-02f,
  7.70873129e-02f, -3.75336744e-02f, -2.02817121e-03f, 1.03638135e-01f, -2.09679711e-03f, 4.07364815e-02f, 4.66765836e-02f, -3.89763154e-02f, -7.90010989e-02f, 4.50360179e-02f,
  -3.14618871e-02f, -8.44468474e-02f, -6.69912668e-03f, 2.72645485e-02f, -6.73063025e-02f, -1.82279963e-02f, 5.81264757e-02f, -1.39685357e-02f, -1.60955247e-02f, -1.49827462e-03f,
  1.66178588e-02f, -3.30174789e-02f, -5.08436225e-02f, -1.89093538e-02f, 5.76738678e-02f, -6.45143986e-02f, -4.32722904e-02f, 9.26764980e-02f, -1.12109119e-03f, -2.41304357e-02f,
  -1.41969040e-01f, -2.54955143e-01f, -1.24342125e-02f, -1.39876053e-01f, -9.28966254e-02f, -5.83286248e-02f, -2.37678140e-02f, 3.74767110e-02f, -4.44107428e-02f, -7.53836930e-02f,
  1.26918592e-02f, -2.96117011e-02f, 1.01027256e-02f, 8.76602009e-02f, -2.34396961e-02f, 4.90712449e-02f, 8.66068248e-03f, -3.26438807e-02f, -4.55516949e-02f, -4.98974584e-02f,
  -7.72116259e-02f, -1.89088024e-02f, 2.63092238e-02f, 1.86346155e-02f, -1.05145447e-01f, -3.22160274e-02f, 4.00721245e-02f, 4.22459170e-02f, -7.34531507e-02f, 5.11961132e-02f,
  1.11724958e-01f, 3.82107571e-02f, 3.14389825e-01f, 1.36875317e-01f, 1.04742922e-01f, 2.29749441e-01f, 3.71010035e-01f, 1.25153318e-01f, 4.78686154e-01f, -2.90281028e-01f,
  -1.75953507e-01f, -1.07643321e-01f, 1.05653284e-02f, -1.79232135e-01f, 2.56867141e-01f, 1.42525122e-01f, -3.01238382e-03f, -6.71680942e-02f, 1.38823435e-01f, -1.03877090e-01f,
  1.15050729e-02f, -1.37860507e-01f, -7.20110312e-02f, -2.82546282e-01f, -1.72107190e-01f, -9.08066556e-02f, -3.34430575e-01f, 4.82897535e-02f, -2.28438511e-01f, 1.89086329e-02f,
  -6.84624389e-02f, 9.14557371e-03f, -5.93771040e-02f, -7.14894533e-02f, -2.81256419e-02f, 5.65696359e-02f, -5.33689372e-03f, -2.83882469e-02f, 1.05771855e-01f, 6.08488247e-02f,
  -7.26816356e-02f, -8.29892531e-02f, -3.97833921e-02f, -3.05529349e-02f, 2.06455532e-02f, 2.70305239e-02f, 5.48593439e-02f, 6.37070835e-03f, 1.79214943e-02f, 9.21737477e-02f,
  4.75588553e-02f, -3.51301059e-02f, 5.73293343e-02f, 1.09301619e-02f, -1.72873922e-02f, -4.04036753e-02f, 8.68726596e-02f, 1.88556723e-02f, 3.68490070e-02f, 7.41714314e-02f,
  3.56012173e-02f, 1.71732441e-01f, 1.14193950e-02f, -4.33898494e-02f, -3.58383432e-02f, 4.83275726e-02f, -8.89699310e-02f, -1.51222060e-02f, 9.73052084e-02f, -8.96394402e-02f,
  3.16023007e-02f, -8.44991058e-02f, 4.93007265e-02f, 2.38304827e-02f, -5.32748401e-02f, -2.92357486e-02f, -7.16159567e-02f, 4.10568714e-02f, 9.87257250e-03f, -5.40116392e-02f,
  1.04581669e-01f, 1.94912478e-02f, -7.77837262e-02f, -1.10200778e-01f, -3.70493867e-02f, 1.97136067e-02f, -2.59139091e-02f, 1.41504966e-02f, 1.91734862e-02f, 5.86362602e-03f,
  6.23069629e-02f, -2.42812932e-02f, -8.99845064e-02f, -5.88645935e-02f, -2.56546624e-02f, -1.08343348e-01f, 2.12358497e-02f, -2.71861702e-02f, 3.61682437e-02f, -1.60832144e-02f,
  5.15795983e-02f, -7.17192218e-02f, -5.32210991e-02f, -4.69316505e-02f, 4.34848107e-03f, -8.93173181e-03f, -4.15301658e-02f, 3.07236481e-02f, -4.20114733e-02f, -1.81911588e-02f,
  -3.80343013e-02f, -2.71274205e-02f, 1.91570017e-02f, -6.88380450e-02f, -7.07281381e-02f, 4.52950085e-03f, -6.89993128e-02f, -3.02120652e-02f, -7.72516876e-02f, 1.30414702e-02f,
  -5.12597561e-01f, 2.91575402e-01f, -1.41006231e-01f, -9.49322581e-02f, -1.27884120e-01f, 2.14683980e-01f, 2.34796062e-01f, -1.24199279e-01f, -3.59229743e-01f, 3.02148938e-01f,
  2.21764788e-01f, -3.66316020e-01f, 2.18306094e-01f, 1.65972233e-01f, -2.12495029e-01f, 2.65004396e-01f, 3.32130879e-01f, 1.98178589e-01f, -6.66791275e-02f, -2.71955840e-02f,
  -3.45898164e-03f, 1.94360152e-01f, 1.45539373e-01f, 9.30095837e-02f, -7.63727054e-02f, -1.47466764e-01f, 1.14208393e-01f, -4.67086434e-02f, 1.41727403e-01f, -6.41692057e-02f,
  7.37788156e-02f, -2.02215180e-01f, -6.44262955e-02f, -8.24368373e-02f, 4.67654876e-02f, 4.94421162e-02f, -1.47505188e-02f, -8.81755427e-02f, -1.25282496e-01f, -5.01912534e-02f,
  -4.68049459e-02f, -6.57792320e-04f, -1.28244743e-01f, -5.46632223e-02f, -3.30181196e-02f, 5.54732280e-03f, -5.89454267e-03f, 7.93331936e-02f, -1.66676808e-02f, -7.65310228e-02f,
  2.48727109e-02f, 3.01461797e-02f, 4.54049557e-02f, 1.84460101e-03f, -3.83880064e-02f, -2.87060291e-02f, -3.81852947e-02f, 1.72462352e-02f, -1.02415001e-02f, -6.45796955e-02f,
  -4.75299247e-02f, -5.57711571e-02f, 9.85175669e-02f, -2.45379768e-02f, -6.18052967e-02f, -5.32104867e-04f, -4.01284453e-03f, 6.03622906e-02f, -8.28704610e-02f, 6.38484806e-02f,
  -3.34951803e-02f, -4.42029759e-02f, -3.07622086e-02f, 4.79778685e-02f, 3.43004465e-02f, -5.02042212e-02f, -1.55727854e-02f, 2.21031923e-02f, 2.39370484e-02f, 2.09042318e-02f,
  -2.20887661e-02f, -3.44711728e-02f, 4.54199314e-02f, 6.37718067e-02f, 5.38488291e-02f, -5.18717691e-02f, -2.92502027e-02f, 2.06391867e-02f, 4.10685092e-02f, -1.10175665e-02f,
  1.01700887e-01f, -5.56200650e-03f, -9.73672606e-03f, -1.48346880e-03f, 5.81971882e-03f, -2.95157339e-02f, 5.42073250e-02f, -5.27857803e-02f, -2.26476099e-02f, -7.34985322e-02f,
  -3.91356461e-03f, -4.37536240e-02f, -1.50778359e-02f, -3.44675011e-03f, 6.71392083e-02f, -3.89629370e-03f, 9.80504379e-02f, -8.99898037e-02f, -5.26109710e-03f, 5.34353824e-03f,
  1.48440488e-02f, 3.06430478e-02f, -2.91770580e-03f, 2.95859575e-02f, -2.93019358e-02f, 1.52202388e-02f, -5.11098318e-02f, -2.42889505e-02f, 8.34320579e-03f, 3.72063033e-02f,
  -1.11376375e-01f, -1.82080775e-01f, 7.45273679e-02f, -2.34267697e-01f, 3.22878473e-02f, -4.55285655e-03f, 1.14984468e-01f, -1.83629632e-01f, -2.70614415e-01f, -3.23656738e-01f,
  -7.97621682e-02f, 3.86145823e-02f, 2.67586768e-01f, -2.49129713e-01f, 3.85474414e-01f, 3.43211085e-01f, -1.34433657e-01f, 3.41463387e-02f, -5.47289848e-02f, -2.51836985e-01f,
  -8.29797089e-02f, -2.32006028e-01f, 2.31515914e-01f, -2.71391928e-01f, -1.71181157e-01f, -2.44554117e-01f, -5.46598658e-02f, 1.23443060e-01f, -2.11277723e-01f, 1.47571802e-01f,
  -2.28393972e-01f, -1.76133558e-01f, -1.22986935e-01f, -8.20184946e-02f, -4.31774408e-02f, -4.55000991e-04f, 5.67732789e-02f, 1.49545208e-01f, 7.84501462e-05f, 6.13028109e-02f,
  -4.11861576e-02f, 2.77396850e-02f, -1.85201541e-01f, 3.76262739e-02f, -7.02052265e-02f, -3.54032889e-02f, 5.56542911e-02f, 3.18048261e-02f, -9.35196802e-02f, 1.09711714e-01f,
  3.91163044e-02f, -2.97561716e-02f, 2.10500974e-02f, 8.85093957e-03f, 5.84188811e-02f, -1.05707370e-01f, 1.17852511e-02f, 1.50034681e-01f, 1.88582875e-02f, -1.12223700e-01f,
  -1.01714348e-02f, -2.21791808e-02f, -2.48161033e-02f, -1.07361907e-02f, -9.87519417e-03f, 1.41430115e-02f, -6.22746870e-02f, -1.81937800e-03f, 5.17779216e-02f, 1.75394565e-02f,
  -5.88864721e-02f, -1.87365320e-02f, -4.67142882e-03f, 5.92612065e-02f, 6.58585727e-02f, -3.94799933e-02f, 3.85000966e-02f, -2.72201821e-02f, 4.48957160e-02f, 9.36795550e-04f,
  -8.35569277e-02f, -5.23483492e-02f, 8.75094607e-02f, 3.75106595e-02f, -1.15984246e-01f, -1.03636626e-02f, -4.06968705e-02f, -9.71709285e-03f, -2.32529659e-02f, 1.83892474e-02f,
  -2.90444463e-01f, -3.45380396e-01f, -1.56335369e-01f, -6.17672876e-02f, 2.70257471e-04f, 6.67150319e-03f, -8.71187747e-02f, -8.32858682e-02f, -3.13247629e-02f, -7.60315806e-02f,
  -1.08545991e-02f, -4.89239283e-02f, 4.82595414e-02f, 3.94686200e-02f, -2.90115718e-02f, -3.45868319e-02f, -7.32779726e-02f, -7.52608106e-02f, -8.11622441e-02f, -9.79869962e-02f,
  -4.16937247e-02f, -8.41106812e-04f, 1.55003322e-03f, -8.53363872e-02f, 2.12242939e-02f, -1.87344104e-02f, -6.27084002e-02f, -6.11689575e-02f, 1.59840077e-01f, -1.85335837e-02f,
  3.21861021e-02f, -2.07295731e-01f, -8.52834135e-02f, 2.63800532e-01f, 4.18505579e-01f, 1.36280224e-01f, 7.83470050e-02f, 2.87431747e-01f, 2.29164317e-01f, -2.03075796e-01f,
  1.38121210e-02f, -1.43008456e-01f, -3.08453143e-01f, 3.85222696e-02f, 1.61465667e-02f, -1.58751413e-01f, 7.12572336e-02f, -5.05647883e-02f, 9.32667404e-02f, 2.17584483e-02f,
  1.69511154e-01f, 1.55336693e-01f, -1.52850702e-01f, 1.23707063e-01f, 5.41476496e-02f, -3.69345434e-02f, -1.67392921e-02f, -9.06844288e-02f, 8.50281585e-03f, 4.69943099e-02f,
  -1.07358890e-02f, -5.34845293e-02f, -1.02877477e-02f, -8.87387842e-02f, 3.75056751e-02f, -2.15938427e-02f, -1.03423811e-01f, -1.18706234e-01f, 4.12853155e-03f, 1.03555925e-01f,
  -1.16502129e-01f, 5.78417033e-02f, 1.12474293e-01f, 3.25085856e-02f, 7.66578838e-02f, 4.59320955e-02f, 5.59640974e-02f, 2.60108011e-03f, 4.70687490e-04f, 3.25877406e-02f,
  -3.49462368e-02f, 5.92457242e-02f, 7.32686967e-02f, 2.52588224e-02f, 1.13863172e-02f, 3.32988705e-03f, 3.38425743e-03f, -5.16417138e-02f, 4.39097174e-02f, 2.97190090e-05f,
  -1.88754522e-03f, -1.02604933e-01f, -7.67345354e-02f, -1.78591888e-02f, 1.15016839e-02f, 7.47227073e-02f, -2.68991664e-02f, -2.62357797e-02f, 1.06126070e-02f, -3.36616859e-02f,
  1.04119167e-01f, 6.57734796e-02f, 7.38587230e-02f, -4.23686467e-02f, -6.09816350e-02f, 7.30587468e-02f, -2.83269193e-02f, -8.30706023e-03f, -2.52648490e-03f, 5.04778661e-02f,
  -4.91663516e-02f, -3.58287920e-03f, 6.26226962e-02f, 1.49368765e-02f, 2.27467418e-02f, 2.88332850e-02f, -1.78949833e-02f, -4.45661508e-02f, -1.78100877e-02f, -1.23574629e-01f,
  -9.60244052e-03f, -1.59831211e-01f, -1.74264554e-02f, 9.82042179e-02f, -1.16413496e-01f, 8.09316784e-02f, -9.66096111e-03f, -1.90108493e-02f, -2.66061425e-02f, -2.41536256e-02f,
  5.01893908e-02f, -6.24060482e-02f, -4.53115143e-02f, -5.56612238e-02f, -1.05097964e-01f, 2.34612916e-02f, -3.40980627e-02f, -1.13435037e-01f, -4.44527641e-02f, -8.42034668e-02f,
  3.54565121e-02f, 9.56896394e-02f, -7.96595663e-02f, 8.78867880e-02f, 5.99513650e-02f, -5.20290621e-02f, -2.31235456e-02f, -4.90088910e-02f, 1.26182502e-02f, -7.76113346e-02f,
  -1.67059377e-01f, -9.68125015e-02f, 5.29585630e-02f, 2.67659277e-01f, -7.87473768e-02f, -1.84621707e-01f, -2.01451797e-02f, -3.30791585e-02f, -1.16788715e-01f, 2.22831201e-02f,
  2.10568339e-01f, -8.89541879e-02f, -9.59100723e-02f, 1.98363021e-01f, 1.92893595e-01f, 1.18703350e-01f, 2.06171706e-01f, 6.85481727e-02f, 4.90620658e-02f, 9.17095840e-02f,
  7.81652853e-02f, 2.07722381e-01f, 2.30133876e-01f, 1.82008073e-01f, 5.43707088e-02f, 1.16975568e-01f, 1.30601659e-01f, -7.13944808e-02f, 2.62597471e-01f, 6.01493604e-02f,
  -1.28922060e-01f, -3.69383357e-02f, 3.16825062e-02f, -4.09264341e-02f, -7.11761490e-02f, -2.81782113e-02f, 3.66398431e-02f, -3.15284841e-02f, 9.00411382e-02f, 8.08439124e-03f,
  -1.44220158e-01f, 5.26152141e-02f, -2.02780188e-06f, 3.15859914e-02f, -5.60642704e-02f, 7.52586275e-02f, -1.42200543e-02f, -5.57598658e-02f, -1.13948032e-01f, -2.59710439e-02f,
  -4.09605280e-02f, -8.18904340e-02f, -6.57534748e-02f, 8.79777893e-02f, 8.30100924e-02f, 2.88207214e-02f, -1.39067378e-02f, 3.10278740e-02f, -7.53126070e-02f, 1.07631989e-01f,
  -3.37917134e-02f, 5.06892335e-03f, -8.63781050e-02f, 4.04966995e-02f, 2.17058472e-02f, 7.56994858e-02f, -3.79355554e-03f, 6.90196874e-03f, 9.25406814e-02f, 5.43892942e-02f,
  9.76829231e-02f, 2.20775940e-02f, 5.36826067e-03f, -5.55948839e-02f, 2.32943445e-02f, 6.38544140e-03f, -1.26074720e-02f, -5.90715706e-02f, 6.40829131e-02f, 2.16844259e-03f,
  2.76793223e-02f, 2.25667898e-02f, -2.31514890e-02f, -1.21967355e-02f, -2.94665825e-02f, 7.39294514e-02f, 9.30915177e-02f, 2.22472828e-02f, -1.65086314e-02f, 3.69074121e-02f,
  4.32293005e-02f, 1.33523896e-01f, 2.93560280e-03f, -1.01877958e-01f, 3.85095440e-02f, -7.94223994e-02f, 1.58345085e-02f, -4.11209725e-02f, -3.52796838e-02f, 5.20119034e-02f,
  -5.08355834e-02f, 5.46230003e-02f, -7.76933432e-02f, -2.03491822e-02f, 1.28598269e-02f, 2.03542830e-03f, -6.12138025e-02f, 3.34225275e-04f, -5.08348830e-02f, 1.29307667e-02f,
  -5.36733083e-02f, 8.70879181e-03f, 3.67851630e-02f, -3.55088934e-02f, -3.95293199e-02f, 7.20770657e-02f, -9.95898526e-03f, -4.45906632e-02f, 2.77500972e-02f, 8.37849751e-02f,
  -3.26843381e-01f, 9.61140543e-02f, -2.08300948e-01f, -1.50893435e-01f, 2.24234670e-01f, 1.98620752e-01f, 1.97275937e-01f, 1.36122629e-01f, 1.40658349e-01f, 2.58159846e-01f,
  1.84328124e-01f, -4.74943966e-03f, -8.23646858e-02f, 1.00008398e-01f, -8.00479650e-02f, 2.60804184e-02f, 1.28191009e-01f, 5.32726906e-02f, -7.23937824e-02f, 2.39097327e-02f,
  -1.83489248e-01f, 8.57069194e-02f, -2.67734211e-02f, 1.32101640e-01f, 7.50494078e-02f, -5.77116236e-02f, -4.79202569e-02f, -9.19059142e-02f, 9.15719047e-02f, 8.34626518e-03f,
  -5.33312000e-02f, -1.37149751e-01f, -1.42646879e-01f, -2.82764304e-02f, -7.15035992e-03f, -1.33093027e-02f, -2.17864010e-02f, 1.73866432e-02f, -1.75451152e-02f, 7.75306821e-02f,
  -1.37892872e-01f, -1.38485702e-02f, -1.06087551e-02f, 5.27504757e-02f, -7.38568902e-02f, -6.91274554e-02f, 2.16782149e-02f, 9.62637216e-02f, 4.73629311e-02f, -1.32495426e-02f,
  2.14290489e-02f, 2.37394813e-02f, 1.37718441e-02f, -7.11019412e-02f, 1.38330217e-02f, 7.27631152e-02f, 1.12576388e-01f, -4.42006327e-02f, -3.69335338e-02f, 4.66827713e-02f,
  -6.56737238e-02f, -1.52028222e-02f, -3.39873210e-02f, -5.97816296e-02f, 2.38795970e-02f, -1.72683857e-02f, -3.40399519e-02f, -1.15075186e-01f, -8.50396138e-03f, 9.36546735e-03f,
  2.91969478e-02f, -1.19054159e-02f, -5.62822744e-02f, -3.06286924e-02f, 6.02339357e-02f, 9.48503390e-02f, -3.57164778e-02f, -4.85209264e-02f, 9.35885385e-02f, -5.47052436e-02f,
  2.08997168e-02f, -2.34559271e-02f, 8.95872936e-02f, -2.35392302e-02f, -8.28725919e-02f, -6.81475028e-02f, -7.72330090e-02f, 8.92787203e-02f, 7.14168185e-03f, 2.08685864e-02f,
  5.39606474e-02f, -5.13748862e-02f, -6.08255938e-02f, -4.63923030e-02f, -1.53004536e-02f, 4.38250564e-02f, -6.19261451e-02f, 5.37546054e-02f, 3.86478268e-02f, -1.83382668e-02f,
  1.03939883e-01f, 2.19460465e-02f, 5.59419878e-02f, 5.92180993e-03f, -7.64872059e-02f, 8.75763595e-02f, 1.44155193e-02f, -3.58106308e-02f, 2.33012978e-02f, -1.18305445e-01f,
  4.27562743e-02f, 2.83847582e-02f, -1.11257834e-02f, 9.69703868e-02f, 4.89115454e-02f, 4.51716967e-02f, 1.63348522e-02f, 6.12428226e-02f, 9.77964699e-03f, -3.19054686e-02f,
  -7.42538273e-02f, 1.28379196e-01f, -1.85965687e-01f, 1.16595507e-01f, -4.45719697e-02f, 1.39558390e-01f, 1.02432974e-01f, -2.96706874e-02f, 7.51286447e-02f, 1.57809481e-01f,
  9.30944309e-02f, -1.20707341e-01f, 7.98337311e-02f, 2.80806720e-01f, 6.18856400e-02f, 1.07010864e-01f, 3.06404412e-01f, 2.45996490e-01f, -8.97696838e-02f, 4.79213661e-03f,
  -4.93148193e-02f, 1.48534566e-01f, -5.34262210e-02f, -1.47926450e-01f, -8.52048174e-02f, -1.22848630e-01f, -7.70187797e-03f, -2.38033801e-01f, -8.12077746e-02f, 2.09489521e-02f,
  -8.54905415e-03f, 2.77178381e-02f, -8.87945443e-02f, -9.01423842e-02f, -5.29617667e-02f, 5.06303348e-02f, -8.42005908e-02f, -1.42845675e-01f, -9.19566378e-02f, 2.48295553e-02f,
  -3.64399031e-02f, -2.61169765e-03f, 7.51763061e-02f, 2.90961843e-02f, -2.57558450e-02f, -1.67153683e-02f, -2.20357589e-02f, 4.76016663e-02f, -2.59504728e-02f, -1.34799749e-01f,
  3.65356989e-02f, -9.13346303e-04f, 4.33756877e-03f, -4.04668637e-02f, -7.90149122e-02f, 2.76251342e-02f, 2.51064301e-02f, -6.81550056e-02f, -9.59280878e-02f, 6.75210878e-02f,
  4.90352921e-02f, 5.73082417e-02f, -5.47349863e-02f, -2.34921407e-02f, -4.37975526e-02f, 2.63978485e-02f, 5.50882779e-02f, 3.47907543e-02f, 6.46705106e-02f, 1.33504905e-02f,
  5.72778247e-02f, 1.75308380e-02f, -6.27676621e-02f, 3.92687088e-03f, 6.28207996e-02f, 7.37601891e-02f, 5.61608709e-02f, -3.72311361e-02f, -2.95842532e-02f, 5.52858450e-02f,
  9.04569253e-02f, 2.63704993e-02f, -2.92893685e-02f, 4.11042161e-02f, 3.68670635e-02f, -6.47922978e-02f, -1.16863297e-02f, -7.51872361e-02f, -9.45081934e-02f, 3.66584100e-02f,
  1.32031322e-01f, 6.36136681e-02f, -8.79139174e-03f, -7.82382488e-02f, -1.72204133e-02f, 6.65860623e-02f, 2.85083391e-02f, -6.19271398e-02f, -4.07575741e-02f, -1.19601469e-03f,
  8.31369031e-03f, 2.91597284e-02f, 2.62536425e-02f, 6.51849806e-02f, -5.75006381e-02f, -5.80256321e-02f, 8.62070993e-02f, 1.13134393e-02f, 1.04369864e-01f, 6.19524457e-02f,
  -4.79522757e-02f, -9.45235416e-02f, 1.24358516e-02f, 7.95032233e-02f, 6.16454743e-02f, 8.55393112e-02f, -5.75020649e-02f, -7.32583255e-02f, 6.99952757e-03f, 2.12452225e-02f,
  -6.69919094e-03f, 4.00697023e-01f, -1.43741131e-01f, 1.98934883e-01f, -1.28375590e-01f, 3.36537242e-01f, 2.67622828e-01f, 7.01119378e-02f, 1.04725942e-01f, 3.87833148e-01f,
  1.00243449e-01f, 1.65270776e-01f, 7.04379156e-02f, 4.48357046e-01f, 1.59172535e-01f, 1.84064642e-01f, 5.26970506e-01f, 2.99975067e-01f, -3.32249999e-02f, 1.52957812e-01f,
  -1.96741223e-02f, 3.46320093e-01f, -7.73169398e-02f, -2.09894422e-02f, -7.69627094e-02f, -2.54286468e-01f, -8.97742361e-02f, -2.24073604e-01f, 2.15140749e-02f, 1.06414117e-01f,
  -5.67742102e-02f, 4.91966121e-02f, -4.60134484e-02f, -8.53516087e-02f, -6.77972287e-02f, -3.58312652e-02f, 8.49257782e-03f, -2.26742625e-02f, -1.49293751e-01f, 7.16400705e-03f,
  -2.81414774e-04f, -3.06701027e-02f, 6.33988604e-02f, 6.91549946e-03f, 7.96382055e-02f, -1.93953216e-02f, -5.50850518e-02f, -9.63200182e-02f, -3.98020931e-02f, -4.86615971e-02f,
  -9.07481015e-02f, -1.67035055e-03f, -1.08116725e-02f, 1.07817635e-01f, -5.67328595e-02f, 3.37764658e-02f, 6.03159629e-02f, 1.87199879e-02f, 3.62202786e-02f, 6.49679974e-02f,
  -1.23669310e-02f, 7.58864656e-02f, 7.35768466e-04f, -4.88874875e-02f, 5.36520928e-02f, -5.17182872e-02f, 2.20758952e-02f, -9.73759405e-03f, 2.18782318e-03f, 3.53600867e-02f,
  9.72731877e-03f, -4.36653197e-02f, -4.44054883e-03f, 8.68683606e-02f, 5.06134853e-02f, -2.71548089e-02f, 3.38340476e-02f, -5.06886374e-03f, 2.07086168e-02f, -8.90978128e-02f,
  -1.78403761e-02f, 3.93018797e-02f, 2.41195671e-02f, -8.35661069e-02f, 2.91576274e-02f, -7.65398890e-02f, 5.42755760e-02f, -8.12445804e-02f, -3.37166712e-02f, -2.52904203e-02f,
  2.07805187e-01f, 3.74974668e-01f, 1.02277100e-02f, -1.69455784e-03f, 8.84013474e-02f, 3.51578034e-02f, 7.17489496e-02f, -2.58390717e-02f, 1.12484530e-01f, 6.19021878e-02f,
  2.91888993e-02f, 6.22209981e-02f, 2.37535741e-02f, -4.89922576e-02f, 4.15814808e-03f, 9.05116946e-02f, 1.09931856e-01f, -1.20265894e-02f, 1.18940212e-01f, -4.86588106e-02f,
  -7.61329290e-03f, 2.98474077e-02f, -4.45556119e-02f, -1.71470344e-02f, 7.00114742e-02f, -3.69208567e-02f, 8.52393061e-02f, -6.88707978e-02f, -8.95537809e-02f, 2.49255858e-02f,
  -3.99640828e-01f, 2.41063878e-01f, -1.25254080e-01f, -9.51737314e-02f, -8.93117934e-02f, -3.28623712e-01f, -1.97320387e-01f, -4.55863327e-02f, -5.50314300e-02f, 2.78242111e-01f,
  2.83049159e-02f, -7.99021348e-02f, 2.09908247e-01f, -6.82466105e-02f, -3.11324567e-01f, 1.12809449e-01f, -1.19896360e-01f, -1.14251055e-01f, 6.58341050e-02f, -7.66161010e-02f,
  -7.51277283e-02f, -9.10370797e-02f, -8.97681639e-02f, 8.19344521e-02f, -1.65840402e-01f, -4.95705158e-02f, 9.41611156e-02f, 1.28960907e-01f, -5.19208647e-02f, -9.86304954e-02f,
  -2.08041072e-01f, -8.82382393e-02f, -1.03316363e-02f, -1.36658117e-01f, -1.45360664e-01f, -8.35068151e-02f, -2.69629853e-03f, -2.47042403e-02f, -4.81031509e-03f, -6.91339821e-02f,
  -2.15236042e-02f, 1.82883069e-02f, -8.84841606e-02f, 7.55052418e-02f, 2.56403256e-02f, 2.31043715e-02f, -5.19314036e-03f, -3.66672128e-02f, -5.08916676e-02f, 1.50511395e-02f,
  -5.37826195e-02f, -7.33622685e-02f, -5.70288450e-02f, -1.42009333e-02f, -5.11285700e-02f, 3.31887156e-02f, 6.78787939e-03f, 7.91382194e-02f, -3.44833173e-02f, 4.42511886e-02f,
  7.32112750e-02f, -1.34732127e-02f, -1.36501342e-02f, -3.11619416e-02f, 3.81176770e-02f, 4.70831096e-02f, 5.93981296e-02f, 2.42139194e-02f, 5.73934130e-02f, 2.68882886e-02f,
  -9.01842862e-02f, -1.97090805e-02f, 1.34276575e-03f, 5.64428270e-02f, -8.07798132e-02f, -1.66031718e-02f, 3.65169942e-02f, -6.57702237e-02f, 4.69683819e-02f, -2.15217303e-02f,
  8.64551440e-02f, -1.23747595e-01f, 4.50253412e-02f, -6.48063421e-02f, 3.43757309e-02f, 3.96674424e-02f, -4.26857919e-02f, 3.97377424e-02f, 4.57063876e-03f, 3.24443588e-03f,
  -1.10733874e-01f, -1.23089090e-01f, -5.71697690e-02f, 2.66451761e-02f, -5.81844486e-02f, 1.47452566e-03f, -5.23439087e-02f, -3.43962088e-02f, -1.13281451e-01f, 5.62711172e-02f,
  3.99630964e-02f, 5.77701367e-02f, -6.97315577e-03f, -1.11997277e-01f, -5.49789481e-02f, -8.09331890e-03f, -4.14431170e-02f, -5.72056472e-02f, -1.49104595e-01f, -4.94120941e-02f,
  7.90932477e-02f, 8.59268606e-02f, -4.10625227e-02f, 2.47643758e-02f, 2.45135576e-02f, 1.79627258e-02f, -4.22411822e-02f, 6.60641771e-03f, -6.63565025e-02f, -6.21496402e-02f,
  1.34861216e-01f, 1.44514248e-01f, -1.00145832e-01f, -1.21649779e-01f, -4.97703403e-02f, -8.04479048e-03f, -4.05458547e-02f, 9.25452113e-02f, -2.20298842e-01f, 7.06088990e-02f,
  7.18426332e-02f, 1.50291864e-02f, 2.76842806e-02f, 3.61122638e-02f, -9.26507264e-02f, -1.43109754e-01f, -7.51269236e-03f, 6.70163706e-02f, -6.00240380e-02f, 1.99075595e-01f,
  -1.50801549e-02f, 5.21070845e-02f, 2.84259003e-02f, 1.41667128e-01f, 1.56050026e-01f, 1.04277574e-01f, 2.12077305e-01f, -5.17561883e-02f, 7.56625161e-02f, -2.78044119e-02f,
  9.66538151e-04f, 7.34067261e-02f, 4.64998595e-02f, -1.67735163e-02f, 3.23653780e-02f, 6.26734048e-02f, -8.44452530e-03f, -3.74221280e-02f, -4.16103797e-03f, 5.82810417e-02f,
  4.08169627e-02f, 6.90316483e-02f, -3.82348895e-02f, -3.75554524e-02f, -8.16973820e-02f, 4.96156700e-02f, 6.73582554e-02f, -3.06703113e-02f, -1.48492446e-03f, 7.36494362e-02f,
  -6.71781451e-02f, 8.88865292e-02f, -1.91130899e-02f, -3.23060416e-02f, -5.25802448e-02f, -2.24431567e-02f, -8.22143406e-02f, 5.34738339e-02f, -1.23883858e-02f, -2.56805066e-02f,
  -1.36301843e-02f, 8.18689764e-02f, -5.48329018e-02f, -4.06266563e-02f, 1.58974826e-02f, -6.55684471e-02f, -1.87397357e-02f, -1.65188350e-02f, -2.23884434e-02f, 4.16161828e-02f,
  -4.29846235e-02f, -3.98629904e-02f, -1.52935050e-02f, 5.59747741e-02f, -8.31696391e-02f, 1.16328627e-01f, 4.49288562e-02f, 9.78071913e-02f, -6.13447502e-02f, -4.48206030e-02f,
  -1.45907206e-02f, -2.90209949e-02f, 7.87490457e-02f, -3.23852971e-02f, -7.83054456e-02f, -9.59607679e-03f, 2.88750743e-03f, 8.57825577e-02f, -1.16529754e-05f, -1.93350054e-02f,
  6.03910014e-02f, 2.84325480e-01f, 5.72823472e-02f, -1.07224464e-01f, -1.47419679e-03f, -1.77653693e-02f, -1.49399741e-02f, -3.97828259e-02f, -5.32952920e-02f, -3.42691913e-02f,
  1.65389627e-02f, -1.19837031e-01f, 1.16316192e-01f, -5.62092997e-02f, -8.65503177e-02f, 8.55552554e-02f, 1.31534189e-01f, 9.35075153e-03f, 2.72441898e-02f, 1.55537769e-01f,
  -1.11225247e-03f, 1.20739162e-01f, -1.91126876e-02f, -3.05936299e-02f, -2.76858639e-02f, 5.68499230e-02f, 5.76542094e-02f, 1.19294725e-01f, 3.95274116e-03f, -7.20105767e-02f,
  1.10030420e-01f, -1.70789897e-01f, -1.07626148e-01f, 3.43255520e-01f, -1.42077561e-02f, -2.37499326e-01f, -1.49027452e-01f, 2.24717140e-01f, -2.64481455e-01f, -7.40616471e-02f,
  6.46577924e-02f, -1.29022330e-01f, -2.93902665e-01f, 1.95509762e-01f, 1.50439009e-01f, -2.43784040e-01f, 1.93699285e-01f, 1.98267936e-03f, -7.51482025e-02f, 1.03804208e-01f,
  2.26043120e-01f, 3.18333954e-01f, 2.31467351e-01f, 3.65318209e-01f, 1.41670838e-01f, 3.54292244e-01f, 3.80513549e-01f, 1.94839295e-03f, 4.98823851e-01f, 1.42901480e-01f,
  -1.37211919e-01f, -7.90689662e-02f, 5.86399883e-02f, -3.14731933e-02f, 7.28034526e-02f, 6.16844185e-02f, 3.92762497e-02f, 5.57680503e-02f, -9.02594440e-03f, 3.50563414e-03f,
  1.82273891e-02f, 5.25943898e-02f, 8.58994871e-02f, -4.85325493e-02f, 6.61229044e-02f, 1.89913884e-02f, -7.59263113e-02f, -1.95144641e-03f, 3.31600569e-02f, -4.32447903e-02f,
  -1.77506939e-01f, -1.72659550e-02f, -8.55764896e-02f, -6.78837076e-02f, -3.09061669e-02f, -3.97597924e-02f, -4.01302502e-02f, 1.79668469e-03f, 2.06450163e-03f, 6.65325373e-02f,
  1.25327736e-01f, 3.09808017e-03f, -1.02518760e-01f, -2.83839293e-02f, 1.41799226e-02f, -3.29022482e-02f, 1.06109204e-02f, 3.33476290e-02f, -3.07879802e-02f, 1.54685490e-02f,
  4.94014006e-04f, 1.28693832e-02f, -2.92622438e-03f, 5.29630948e-03f, 1.06151018e-03f, -7.62372836e-02f, -5.58529934e-03f, 8.42665806e-02f, 2.40591876e-02f, -2.17246264e-02f,
  -5.38890287e-02f, 1.34050911e-02f, -2.10139360e-02f, 2.43833922e-02f, -3.64677347e-02f, 5.90312816e-02f, 5.94602078e-02f, -1.59612186e-02f, 9.47970524e-03f, 5.94235444e-03f,
  1.03073426e-01f, 1.56998292e-01f, -4.40521985e-02f, -1.53383724e-02f, -6.90746754e-02f, 5.02164243e-03f, -5.92237972e-02f, 2.44573932e-02f, 7.40970895e-02f, -1.77235510e-02f,
  1.33745685e-01f, 5.67830205e-02f, -1.40967686e-02f, 4.14340869e-02f, 9.83590633e-02f, -2.76714936e-03f, -9.52566136e-03f, 2.30535753e-02f, 9.42310244e-02f, 1.28322363e-01f,
  1.06627062e-01f, 3.01510934e-03f, 3.12881507e-02f, -7.76432753e-02f, 7.00501353e-02f, -2.36794874e-02f, 3.03494483e-02f, -4.41876948e-02f, -1.84408389e-04f, 4.88847792e-02f,
  -4.14024174e-01f, -7.14360178e-02f, -8.53751972e-02f, -3.00176680e-01f, 1.52310342e-01f, 7.78896809e-02f, -5.46250455e-02f, 2.35866029e-02f, -2.29201213e-01f, 2.49815397e-02f,
  -4.05557007e-02f, -2.25455612e-01f, -6.53284565e-02f, -2.10634053e-01f, -4.11009341e-01f, -2.82685786e-01f, -2.55148888e-01f, -1.06656693e-01f, -9.68732834e-02f, -7.23989028e-03f,
  -1.74924597e-01f, 5.00237122e-02f, -1.32731318e-01f, 2.54177928e-01f, -1.74605213e-02f, 1.32603750e-01f, 1.23058692e-01f, 2.13323489e-01f, -1.83644500e-02f, 3.27224396e-02f,
  -6.13115123e-03f, -1.31049663e-01f, -5.17355129e-02f, -6.91332445e-02f, -2.59909146e-02f, 3.62353064e-02f, 3.59887853e-02f, -3.64009142e-02f, 6.85554072e-02f, -7.06590489e-02f,
  -8.09079483e-02f, -1.82275493e-02f, -1.39751686e-02f, -2.26993393e-02f, 1.26056271e-02f, 3.57668698e-02f, -6.41606515e-03f, 6.89798146e-02f, -9.07654017e-02f, -8.83141253e-03f,
  -3.07182670e-02f, 4.90108654e-02f, 1.91617198e-02f, 3.57639678e-02f, 9.71863884e-03f, -4.25841026e-02f, 4.65307720e-02f, 5.74178174e-02f, 5.43871745e-02f, 1.59102604e-02f,
  1.19556766e-02f, 1.01657107e-01f, 1.77847836e-02f, -4.50792536e-03f, -1.03047872e-02f, 5.37052974e-02f, 2.53256708e-02f, 2.49908231e-02f, -2.15056650e-02f, -4.45301458e-03f,
  3.67641747e-02f, -9.63328630e-02f, -1.45389559e-02f, -1.63704026e-02f, 1.39039047e-02f, -2.97307074e-02f, -2.93347687e-02f, 5.27802743e-02f, 2.59526394e-04f, 3.41754928e-02f,
  4.48411964e-02f, 1.53175741e-02f, 7.97229540e-03f, 3.03249769e-02f, -7.49567524e-02f, -3.49446982e-02f, 9.19275433e-02f, -3.61071266e-02f, -8.03846121e-03f, 8.11357871e-02f,
  -5.34332357e-02f, 9.53464583e-02f, 2.49709524e-02f, 1.15219392e-01f, 5.33934496e-02f, -2.09662803e-02f, 2.32517757e-02f, -3.98580283e-02f, 4.29797918e-02f, -1.53673869e-02f,
  8.42166021e-02f, 5.79191670e-02f, 8.21180865e-02f, -4.62279917e-04f, 3.98876630e-02f, 6.98620221e-04f, 6.83204085e-02f, 3.59181017e-02f, 8.80187601e-02f, 3.57889608e-02f,
  6.63447455e-02f, 8.74310210e-02f, -6.67638518e-03f, 5.61333336e-02f, 4.52914275e-02f, 5.80551364e-02f, -3.51210348e-02f, -8.21819976e-02f, -2.06028530e-03f, -3.40033546e-02f,
  2.92003900e-02f, 4.40018140e-02f, -2.31701732e-02f, 4.83939573e-02f, -1.15978479e-01f, -1.04947001e-01f, -1.21910907e-01f, 7.62277469e-02f, -3.80694531e-02f, -2.01452654e-02f,
  1.04025587e-01f, 2.45029218e-02f, 1.30271688e-01f, 7.30237141e-02f, -3.34761105e-02f, 7.17839599e-02f, 1.89690385e-02f, 4.63925973e-02f, 1.04044285e-03f, 1.48919240e-01f,
  1.27145514e-01f, 6.37709796e-02f, 2.01741591e-01f, -5.19991741e-02f, 8.08224976e-02f, 7.28301853e-02f, 2.25006729e-01f, 6.48018867e-02f, 1.07170828e-01f, -4.69804369e-03f,
  3.14627849e-02f, -1.33442422e-02f, 3.79476510e-02f, -6.68821111e-02f, 6.84756562e-02f, -2.02301834e-02f, -3.90187465e-02f, 3.43876556e-02f, -1.00184446e-02f, 5.88450581e-02f,
  -4.21350077e-02f, -5.45519739e-02f, -5.66827022e-02f, -6.80198073e-02f, -1.39088243e-01f, -2.31719837e-02f, 6.25271490e-03f, 1.53469993e-03f, 4.43680361e-02f, -6.49556071e-02f,
  4.53393497e-02f, 5.63468561e-02f, 3.49308662e-02f, -5.55598959e-02f, 3.86048779e-02f, 1.79993697e-02f, 4.92835417e-02f, 5.96679561e-02f, 1.06390836e-02f, -3.79824005e-02f,
  -9.51047987e-03f, 4.07661423e-02f, -8.34528804e-02f, 2.99136341e-02f, 3.09234392e-03f, -6.79591745e-02f, -2.25376780e-03f, 1.08650655e-01f, 1.65916067e-02f, 1.42830024e-02f,
  3.08465622e-02f, -3.82565223e-02f, 5.94888302e-03f, 2.91104484e-02f, 3.52853909e-02f, 2.30519567e-03f, -7.92242661e-02f, -3.17710936e-02f, 2.06125956e-02f, -4.11701128e-02f,
  1.03608362e-01f, -4.13797982e-02f, 1.38637749e-02f, 6.42835274e-02f, 6.58241063e-02f, 2.62017939e-02f, 1.12947291e-02f, 6.68873917e-03f, 5.72994410e-04f, 2.26147678e-02f,
  1.67757288e-01f, 1.18935876e-01f, -6.34035394e-02f, 2.77438946e-02f, 2.47910842e-02f, -2.10091267e-02f, -4.61516492e-02f, 1.55337136e-02f, 5.35624474e-02f, -6.08369894e-02f,
  -3.93904001e-02f, -4.54407558e-02f, -1.50385909e-02f, 4.92972136e-02f, 4.35177386e-02f, 5.54723591e-02f, -3.55906151e-02f, -5.10575948e-03f, 1.20870620e-02f, 1.19898394e-01f,
  8.57269466e-02f, -7.40242600e-02f, -6.54196218e-02f, -5.71042225e-02f, 3.35202110e-03f, 6.60886616e-02f, -3.80608737e-02f, 1.52618270e-02f, -6.60797656e-02f, 3.23294140e-02f,
  -1.34661466e-01f, -5.47471419e-02f, 2.64498293e-01f, -6.36716112e-02f, 3.12589705e-01f, 1.97977826e-01f, 2.42285058e-01f, 1.87241703e-01f, 2.07033679e-01f, -2.71635890e-01f,
  -1.23170927e-01f, -2.71550894e-01f, -1.26819789e-01f, -7.73452148e-02f, 1.86298072e-01f, 9.53080505e-02f, 1.67388439e-01f, -4.58276011e-02f, 2.57897168e-01f, 5.26222289e-02f,
  1.42258033e-01f, -7.14354739e-02f, 1.59150228e-01f, -7.41340518e-02f, -2.63190325e-02f, 2.25651218e-03f, -1.95441902e-01f, 4.71416153e-02f, -1.94579899e-01f, 6.69780746e-03f,
  -1.24523044e-02f, -4.74180281e-02f, 8.20708200e-02f, 6.06169179e-03f, 8.31685308e-03f, -6.01643659e-02f, -4.16755117e-02f, 2.24914569e-02f, 1.35079082e-02f, 3.84745412e-02f,
  -5.67590632e-03f, -2.41624610e-03f, 3.77789624e-02f, -6.58255517e-02f, 1.20228507e-01f, 3.29215154e-02f, 6.64948970e-02f, 2.78775357e-02f, 2.98986714e-02f, -1.05243633e-02f,
  1.04220435e-01f, 5.15227690e-02f, 1.04151495e-01f, -4.55687866e-02f, 5.73308654e-02f, 2.56568883e-02f, -1.98988933e-02f, -5.03203049e-02f, 7.37138465e-02f, 5.01993038e-02f,
  7.68841431e-02f, 4.07062285e-02f, -5.06145135e-03f, 3.71545441e-02f, -4.05849293e-02f, -4.86499965e-02f, 1.46213069e-03f, -2.20219176e-02f, 4.28770557e-02f, 3.82481255e-02f,
  6.12008013e-03f, -8.77305865e-02f, 5.26776277e-02f, 9.04913023e-02f, 2.11350080e-02f, -1.09685481e-01f, -3.83548476e-02f, -7.94487968e-02f, 1.10960633e-01f, -5.79884797e-02f,
  -7.42885098e-02f, -3.39434929e-02f, -5.86467572e-02f, 2.30932534e-02f, -1.75241679e-02f, -8.85312853e-04f, -3.52943763e-02f, -3.29606719e-02f, -1.79092691e-03f, 3.52380201e-02f,
  4.69014840e-03f, -1.38646618e-01f, 1.39995977e-01f, 2.31643710e-02f, -2.33079698e-02f, -4.69665900e-02f, -1.59256924e-02f, 3.35687697e-02f, -6.89371750e-02f, 3.26765366e-02f,
  5.31434491e-02f, 1.61258373e-02f, -6.27840608e-02f, 1.88970175e-02f, -4.73617725e-02f, 1.28744375e-02f, -5.97046129e-02f, -4.67621582e-03f, -2.89151501e-02f, 2.88019255e-02f,
  -7.18412250e-02f, -7.18005002e-02f, 1.53517965e-02f, -4.07937691e-02f, -3.07776518e-02f, -7.37858424e-03f, -7.37461746e-02f, 4.41817716e-02f, -3.89758833e-02f, 6.66644648e-02f,
  1.89706177e-01f, 3.72005939e-01f, 3.14612865e-01f, 3.27523351e-01f, -2.63212889e-01f, -4.85102504e-01f, -2.91331857e-01f, -1.90856885e-02f, 5.79264620e-03f, 5.33925463e-03f,
  -2.27426901e-01f, 4.25504386e-01f, -5.24708033e-02f, 2.42587533e-02f, -1.64300933e-01f, -1.47175789e-01f, -3.67314257e-02f, 3.72916311e-02f, 9.46977362e-02f, 9.97577459e-02f,
  1.14512704e-01f, -2.15063736e-01f, 1.09287955e-01f, -8.17637444e-02f, 1.60612419e-01f, 3.31052780e-01f, 1.31392537e-03f, -1.21545441e-01f, 1.34935454e-01f, -4.41384353e-02f,
  -2.98898108e-02f, 8.00192207e-02f, 1.06404506e-01f, 7.37816617e-02f, -4.71647410e-03f, -7.24031106e-02f, -5.46820578e-04f, -5.31484485e-02f, -3.52179892e-02f, -1.36704892e-02f,
  1.78749096e-02f, -2.62907594e-02f, 7.35410899e-02f, -8.19778964e-02f, -2.30726693e-02f, 9.50785130e-02f, 1.04795374e-01f, 6.73863366e-02f, 1.18574679e-01f, 5.84307015e-02f,
  1.12738356e-01f, 6.32950589e-02f, -4.07289639e-02f, 7.89637789e-02f, 5.15583530e-02f, -3.28933797e-03f, -4.61492408e-03f, 1.00877889e-01f, 1.12572856e-01f, 6.49649575e-02f,
  -2.01775543e-02f, -7.15038329e-02f, -2.87819412e-02f, -7.69458059e-03f, -6.86060935e-02f, -4.14639302e-02f, -2.22149249e-02f, 2.24852711e-02f, 1.98058039e-02f, -9.29912031e-02f,
  -1.26390541e-02f, 5.43917827e-02f, -7.14969784e-02f, -2.65648123e-02f, -8.89360905e-03f, -8.24614912e-02f, 1.13962283e-02f, 3.15934047e-02f, 2.82143839e-02f, 5.14369830e-02f,
  2.26235203e-03f, -2.74121342e-03f, 7.64007345e-02f, 1.26867536e-02f, -4.00699563e-02f, 4.32787612e-02f, 2.25601960e-02f, 7.08657950e-02f, -1.35573642e-02f, -2.26847120e-02f,
  2.90785339e-02f, 2.20064670e-01f, 1.68784782e-02f, -5.66350333e-02f, -2.15375498e-02f, -1.08509593e-01f, -7.64602842e-03f, 4.39429358e-02f, 1.21190250e-01f, 6.41255220e-03f,
  -6.60913512e-02f, 3.04913912e-02f, -2.48490386e-02f, -2.26477776e-02f, 8.87200888e-03f, -2.18010619e-02f, 6.31109849e-02f, 8.56945515e-02f, 4.54032235e-02f, 9.74936932e-02f,
  4.76269089e-02f, 3.22580300e-02f, 3.15862559e-02f, -3.09613217e-02f, 1.57002360e-02f, -3.10992599e-02f, -1.19684925e-02f, 1.47033082e-02f, 3.15715447e-02f, 3.59936990e-02f,
  2.55697191e-01f, 1.18312091e-02f, -9.30174366e-02f, -1.37148082e-01f, -1.33166254e-01f, -1.02192812e-01f, 2.86047999e-02f, 4.43129130e-02f, 1.52514756e-01f, 2.37274207e-02f,
  -2.09351648e-02f, 1.67704567e-01f, -3.99932116e-02f, -1.03933960e-01f, 1.02936074e-01f, 1.16627283e-01f, 2.76163835e-02f, 5.19834012e-02f, -6.55256631e-03f, 8.66599232e-02f,
  2.46601906e-02f, -9.89142805e-02f, -9.45270732e-02f, -4.60624099e-02f, -1.26637414e-01f, -1.45979017e-01f, 1.31759895e-02f, -3.34741361e-02f, -1.18159473e-01f, -2.21172404e-02f,
  -5.25978841e-02f, -4.29977216e-02f, -9.91028640e-03f, 6.89638108e-02f, 5.82989212e-03f, 2.75754873e-02f, -2.80736834e-02f, -1.75085049e-02f, 7.19424561e-02f, -4.79755029e-02f,
  6.31239265e-02f, 2.05961522e-03f, -1.15646310e-02f, 4.63500433e-02f, 9.24540535e-02f, 5.78178540e-02f, 2.34116167e-02f, -7.52627477e-02f, -8.38197768e-02f, -7.87717178e-02f,
  2.23225746e-02f, -1.49308443e-02f, -5.20222401e-03f, 5.26545383e-02f, 5.66861182e-02f, 3.88523228e-02f, -6.09640591e-02f, 3.83030362e-02f, -7.81481564e-02f, -3.99657153e-02f,
  2.29137801e-02f, -1.76333345e-03f, -7.18654469e-02f, -5.62408045e-02f, -7.69623602e-03f, -9.66285840e-02f, -4.48508076e-02f, -1.92769966e-03f, 4.46640141e-02f, 3.30578573e-02f,
  4.50065210e-02f, 8.11256655e-03f, 1.30771901e-02f, 9.99991223e-02f, -1.36261275e-02f, 1.07743002e-01f, 3.91795933e-02f, 3.40445973e-02f, 1.65095795e-02f, -7.71533027e-02f,
  -1.11286696e-02f, -4.85658785e-03f, -4.07697968e-02f, -1.17723815e-01f, 7.22332001e-02f, -3.20708044e-02f, 1.25650978e-02f, -6.92220777e-02f, -7.52880499e-02f, 1.02970086e-01f,
  5.17349318e-02f, 4.82232263e-03f, 8.00188258e-02f, 2.54661385e-02f, 5.81939779e-02f, -3.23179923e-02f, 1.09414896e-03f, -2.70376056e-02f, 6.37207627e-02f, 9.90508497e-02f,
  7.86721334e-03f, -6.70117289e-02f, 1.07246675e-01f, 4.13677841e-02f, 1.60403233e-02f, -5.15554734e-02f, 5.34773804e-02f, -1.51539994e-02f, -6.26128614e-02f, -3.23520489e-02f,
  3.76712978e-02f, 3.82871181e-02f, -2.13953247e-03f, -3.58954519e-02f, 2.96427440e-02f, -6.57452270e-02f, 8.55648294e-02f, 7.84757584e-02f, -2.02078768e-03f, 6.38143718e-02f,
  -2.26588666e-01f, 1.11560762e-01f, 3.81791145e-02f, -2.84773827e-01f, 9.01631732e-03f, 2.03571782e-01f, -6.80972710e-02f, 1.33177921e-01f, -2.60174096e-01f, 4.11231555e-02f,
  4.52553574e-03f, -4.64916900e-02f, 1.54908448e-01f, -1.56156257e-01f, -4.82364669e-02f, 2.21554916e-02f, 2.77101118e-02f, -1.20098386e-02f, 1.23100273e-01f, 8.87937099e-02f,
  -6.63466677e-02f, -8.48549306e-02f, 5.74007481e-02f, 1.63518265e-01f, 1.23276755e-01f, -1.73023380e-02f, -1.05388351e-01f, 1.40675306e-01f, -3.70822288e-03f, -1.19270971e-02f,
  3.37920859e-02f, 8.05473402e-02f, 1.01617709e-01f, 9.91603956e-02f, 2.89191455e-02f, 5.13200797e-02f, 5.46319894e-02f, 4.60343175e-02f, -4.58730869e-02f, -6.53930604e-02f,
  1.74040254e-02f, -5.31703746e-03f, 1.07116047e-02f, -5.54575808e-02f, -2.41513569e-02f, 5.15486812e-03f, -4.95205969e-02f, -4.37485687e-02f, -6.92020580e-02f, 1.60920203e-01f,
  4.85175736e-02f, 5.06909825e-02f, -1.00278765e-01f, -1.23931065e-01f, 6.04997091e-02f, -1.71996076e-02f, -9.44934711e-02f, -4.41330783e-02f, -3.87509614e-02f, -4.13543954e-02f,
  4.22442026e-05f, -6.81128306e-03f, 8.84195939e-02f, -4.60105576e-02f, 6.39320686e-02f, 7.67470971e-02f, -6.91380948e-02f, 3.66179645e-02f, -8.08615424e-03f, -3.96045716e-03f,
  2.74525601e-02f, 7.37122959e-03f, 5.87810501e-02f, -6.79836571e-02f, 5.91345504e-02f, -2.97865700e-02f, 6.64196536e-02f, 3.42125967e-02f, 1.12821292e-02f, 8.68926719e-02f,
  -6.69012591e-03f, 5.56618348e-02f, -4.63930033e-02f, -3.90345640e-02f, 2.98525337e-02f, -8.84192809e-02f, -1.80699292e-03f, -1.04415882e-02f, 4.94239777e-02f, 5.40892556e-02f,
  -1.89312715e-02f, -2.84556281e-02f, 8.92945305e-02f, 8.90352726e-02f, 9.30038095e-02f, 1.12828851e-01f, 6.91146851e-02f, 2.59060203e-03f, -3.38166691e-02f, 5.22916531e-03f,
  -7.06921369e-02f, -2.20043678e-03f, -1.34048266e-02f, -8.89471993e-02f, -7.49721155e-02f, -1.00305527e-02f, 2.29880054e-04f, -2.34871376e-02f, -4.68786657e-02f, 8.51212367e-02f,
  -7.77734444e-02f, -2.28498806e-03f, -1.26085458e-02f, -9.33351293e-02f, -8.50597620e-02f, -3.26408260e-02f, 1.58797037e-02f, -2.45834384e-02f, -1.58474799e-02f, -7.22267316e-04f,
  -1.57890003e-02f, -1.29864141e-01f, -3.69064093e-01f, -1.86677739e-01f, -2.90730149e-01f, -3.33693624e-01f, -2.08328620e-01f, -2.24107906e-01f, 2.36444380e-02f, 9.34739783e-02f,
  8.19081515e-02f, -1.74834039e-02f, 2.67809629e-01f, -1.95078224e-01f, 8.40864033e-02f, 3.20080012e-01f, -2.58082509e-01f, -1.72175150e-02f, 3.12397610e-02f, -8.74010846e-02f,
  -9.60079730e-02f, -4.65795472e-02f, -1.61857277e-01f, -1.42702088e-01f, -2.47127786e-01f, -2.08508432e-01f, 1.80661660e-02f, -1.30110219e-01f, -1.34840220e-01f, -1.47931948e-01f,
  1.97358932e-02f, 2.48646870e-01f, -9.66150761e-02f, 1.80146992e-02f, -6.03413060e-02f, -4.42983024e-02f, -6.59317002e-02f, 5.45223206e-02f, 3.62629294e-02f, 6.29549772e-02f,
  7.63770714e-02f, -2.34242305e-02f, 2.55836407e-04f, -7.62581453e-03f, -7.06335232e-02f, -1.01611149e-02f, -5.52604981e-02f, 2.80157733e-03f, -3.63687314e-02f, -3.90629657e-02f,
  -2.35314425e-02f, 1.16998302e-02f, -7.05162138e-02f, 1.52830128e-02f, -7.25523755e-02f, -2.89330427e-02f, -5.86233176e-02f, -4.78892401e-03f, -7.71948174e-02f, -3.26044485e-02f,
  2.50723623e-02f, 2.17395555e-03f, 7.90342912e-02f, 1.83417108e-02f, 5.45881204e-02f, 7.48015987e-03f, 4.29764576e-03f, 9.92316753e-02f, -6.52159681e-04f, 1.03228249e-01f,
  2.38815155e-02f, 2.54603121e-02f, 2.76305936e-02f, -9.66743603e-02f, -6.03873469e-02f, 2.58804718e-03f, -7.32817948e-02f, 2.90355328e-02f, -3.49667333e-02f, -5.68364859e-02f,
  4.39337827e-02f, -3.92869785e-02f, 3.04906685e-02f, 9.17076506e-03f, -6.95860386e-02f, 5.18607385e-02f, -7.17269722e-03f, -8.36043358e-02f, 7.88520575e-02f, 3.94391529e-02f,
  1.23840068e-02f, -6.53624609e-02f, 7.89417103e-02f, 1.62600968e-02f, 2.74839904e-02f, 1.74261164e-02f, -6.18588515e-02f, -1.88930274e-03f, -8.25699717e-02f, 2.36996468e-02f,
  -1.24752104e-01f, -2.84866919e-03f, -6.35652766e-02f, 6.55866936e-02f, 2.73083933e-02f, -8.51270556e-02f, -3.06071211e-02f, 5.70935309e-02f, -6.18945174e-02f, -3.88572179e-02f,
  -2.60978900e-02f, 1.68956369e-02f, 7.36515671e-02f, 7.16530383e-02f, 1.15664387e-02f, -5.54496162e-02f, -1.62244700e-02f, 1.91327631e-02f, -7.09731504e-02f, 2.47083642e-02f,
  5.51294424e-02f, -2.48852700e-01f, 3.07746887e-01f, 9.15884078e-02f, 3.29122804e-02f, 2.44841516e-01f, 3.59564960e-01f, -1.92352489e-01f, -1.01397954e-01f, -1.79090470e-01f,
  -1.58143625e-01f, 2.79409140e-01f, 1.05616763e-01f, -8.46626908e-02f, 4.04644310e-01f, 6.04169369e-02f, 2.23943554e-02f, 9.47659761e-02f, -2.21421383e-02f, 5.28715830e-03f,
  -8.33013132e-02f, -1.99308917e-01f, -2.55078487e-02f, -3.12689096e-01f, 7.66546233e-03f, -2.87484210e-02f, -1.18569031e-01f, 1.65118888e-01f, -1.81309327e-01f, 5.02462946e-02f,
  -1.26445387e-02f, -2.12674625e-02f, 6.50459435e-04f, -5.32923527e-02f, -9.12502185e-02f, 3.26193944e-02f, 6.42285347e-02f, 2.19519719e-01f, 9.72619187e-03f, -2.98492964e-02f,
  1.03167057e-01f, 6.80655390e-02f, -1.81650370e-02f, 3.06429751e-02f, -1.77666340e-02f, -9.45587009e-02f, -3.66177633e-02f, -1.32530823e-01f, 3.27591151e-02f, -1.78466830e-03f,
  -1.10011823e-01f, 2.96278819e-02f, -1.14798851e-01f, -3.23305428e-02f, 3.71359996e-02f, 5.84500730e-02f, 6.48362190e-02f, 3.51018272e-02f, -7.44183660e-02f, 1.36500718e-02f,
  -3.46790031e-02f, -1.44255022e-02f, -3.51592265e-02f, -4.94630225e-02f, 5.53182028e-02f, -1.23297743e-01f, 1.79928374e-02f, -9.16379169e-02f, 2.23128609e-02f, -6.94697201e-02f,
  -8.93828832e-03f, 2.80178543e-02f, -5.52549474e-02f, 2.70635821e-02f, -6.98884726e-02f, -5.13640456e-02f, 5.35113439e-02f, -5.23385815e-02f, -6.36872202e-02f, 2.00390397e-03f,
  -2.49568727e-02f, 5.80303855e-02f, 6.33446500e-02f, 6.68609813e-02f, 4.69240397e-02f, 1.01050556e-01f, -8.87240395e-02f, 2.48795021e-02f, 3.61367874e-03f, 1.24262308e-03f,
  3.01838387e-02f, -8.28175340e-03f, -1.29914567e-01f, -5.25575280e-02f, 1.00996206e-02f, -2.77565084e-02f, 2.40321513e-02f, -6.92336261e-02f, 5.30578010e-02f, -6.28572777e-02f,
  -1.07620545e-01f, 3.72709781e-02f, 6.62847608e-02f, 2.85940580e-02f, 4.37390879e-02f, -2.55864728e-02f, 1.25508353e-01f, -5.17918430e-02f, 5.00886254e-02f, -1.17293388e-01f,
  -7.18863010e-02f, 1.03458472e-01f, 2.91772597e-02f, -6.98892996e-02f, -8.75753537e-02f, -2.44073998e-02f, 6.75800592e-02f, 2.02193316e-02f, -6.04079198e-03f, 3.45130265e-02f,
  2.03211397e-01f, 2.79973239e-01f, 1.13887876e-01f, 2.49745950e-01f, 9.66870785e-02f, 1.75429448e-01f, 2.82391030e-02f, 6.76626191e-02f, 2.60897011e-01f, 1.94221735e-02f,
  -1.16938829e-01f, 2.30329186e-01f, -7.07976818e-02f, 1.30329624e-01f, -6.63489923e-02f, -8.49945918e-02f, 3.08719352e-02f, 1.19296543e-01f, 1.03259027e-01f, 1.16784722e-01f,
  -5.72082326e-02f, -2.13765330e-03f, -1.13969125e-01f, -1.27334520e-01f, 6.10138886e-02f, 6.21428825e-02f, -1.37916625e-01f, -8.92779380e-02f, -5.03117628e-02f, -6.27735630e-02f,
  -7.35082328e-02f, -6.66524284e-03f, 6.44711107e-02f, 4.51780763e-03f, 9.42131132e-03f, 1.57694314e-02f, 4.50747386e-02f, -2.45755352e-02f, -6.85352534e-02f, 7.50141824e-03f,
  -2.69918181e-02f, -5.82941948e-03f, -5.24020009e-02f, -3.87233905e-02f, 9.79104787e-02f, 9.56883729e-02f, 6.51755705e-02f, 8.07654932e-02f, 4.76066582e-02f, 7.01848790e-02f,
  1.25696748e-01f, 1.96923502e-02f, 2.12386157e-02f, -6.07550591e-02f, 2.61571426e-02f, 7.10800365e-02f, 1.02692366e-01f, -1.35042088e-03f, 1.23826049e-01f, 4.61834855e-02f,
  -8.69166106e-02f, -3.54672223e-02f, -1.94524005e-02f, -5.44021428e-02f, 2.53857654e-02f, -7.11487830e-02f, 8.61668810e-02f, 1.55351385e-02f, -1.66384652e-02f, 5.41072674e-02f,
  -3.90617363e-02f, -2.05128547e-02f, -2.22113933e-02f, -4.68284264e-02f, 1.01393320e-01f, -1.73696969e-02f, -5.72526380e-02f, -1.78665966e-02f, 6.86376318e-02f, 9.28412899e-02f,
  -1.03209905e-01f, -6.14210144e-02f, -2.50478778e-02f, 5.16525842e-02f, 4.87553291e-02f, 3.16929333e-02f, -9.32902619e-02f, 5.39896712e-02f, -8.55797320e-04f, -3.41687500e-02f,
  1.42132491e-01f, 6.46730810e-02f, -4.55919206e-02f, 4.16329876e-02f, 4.92016338e-02f, -8.06813240e-02f, 1.89913083e-02f, 5.43602630e-02f, 1.00161634e-01f, -5.67322969e-02f,
  6.55218139e-02f, -2.93042604e-02f, 5.38214631e-02f, 5.05133020e-03f, -5.14302775e-02f, 2.06967145e-02f, -7.88979903e-02f, 5.76896593e-02f, -4.93627712e-02f, -7.13626295e-02f,
  1.67087801e-02f, 3.69233601e-02f, 4.21430953e-02f, 9.22932550e-02f, -1.19056692e-02f, -8.19396041e-03f, -3.76216061e-02f, 1.92786136e-03f, -3.50315087e-02f, -1.50849475e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.03519574e-01f, 1.25154525e-01f, 2.45333090e-01f, 2.95636714e-01f, 3.07343006e-01f, 2.02091962e-01f, 3.95248294e-01f, 3.28539282e-01f, 4.67651904e-01f, 2.45494887e-01f,
  1.33923516e-01f, 3.91276985e-01f, 2.35173702e-01f, 3.66495192e-01f, 2.97505975e-01f, 1.55041575e-01f, 2.47436538e-01f, 2.63874650e-01f, 1.99101921e-02f, 2.43719861e-01f,
  2.33913288e-01f, 1.38774440e-01f, 1.66017413e-01f, 1.45246372e-01f, 3.39396715e-01f, 6.89894110e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.40384287e-01f, 6.89639896e-02f, 1.81717649e-01f, -1.86017877e-03f, -2.81510860e-01f, -4.26215120e-02f, 7.94835836e-02f, -2.56492525e-01f, -2.94967033e-02f, 1.78257361e-01f,
  2.39228398e-01f, 1.18885182e-01f, -2.49537885e-01f, -2.66150245e-03f, -3.83112244e-02f, 1.28866844e-02f, -8.62400681e-02f, 1.38848379e-01f, -1.54499803e-02f, -9.68350992e-02f,
  2.44599372e-01f, -3.55894938e-02f, -2.27784321e-01f, 1.77638516e-01f, -2.07831129e-01f, -4.57210280e-02f, -2.23982066e-01f, -6.48942515e-02f, 3.76339778e-02f, 2.34332308e-01f,
  -2.71698117e-01f, -1.51597634e-01f, -7.49420449e-02f, -5.61397336e-02f, 2.86559671e-01f, -2.75964111e-01f, 2.54574299e-01f, 3.10229331e-01f, -1.03210054e-01f, 3.04469443e-03f,
  -3.12444299e-01f, -1.06221385e-01f, -1.96737230e-01f, 2.43396591e-02f, 1.81333467e-01f, 2.52864435e-02f, 1.11421153e-01f, -1.12466328e-01f, 3.87984626e-02f, 9.79479998e-02f,
  -1.53309450e-01f, -3.16001803e-01f, -1.08669661e-01f, -2.96271741e-01f, 7.62761086e-02f, -1.49812683e-01f, -2.72375375e-01f, 1.69295356e-01f, -1.71536982e-01f, -6.51783347e-02f,
  2.77803978e-04f, -3.10028046e-01f, 2.62700617e-01f, -1.21849291e-01f, 1.67385891e-01f, 1.59652501e-01f, -2.00756907e-01f, 3.23418558e-01f, -3.11993491e-02f, 2.36748345e-02f,
  -4.98140678e-02f, -2.13175714e-01f, -2.84889042e-02f, 5.06951027e-02f, -3.15239400e-01f, -2.10730404e-01f, 1.73596770e-01f, 2.36321852e-01f, -1.80921420e-01f, -6.28636628e-02f,
  1.14735156e-01f, -9.65534449e-02f, 2.02866837e-01f, 3.78182709e-01f, -3.07450481e-02f, -9.75116938e-02f, -1.19724721e-01f, -3.10812920e-01f, 1.59338996e-01f, -3.01708449e-02f,
  8.44841748e-02f, 1.24636084e-01f, -2.69442856e-01f, 7.38815889e-02f, -1.44948855e-01f, 1.34326875e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.50339651e-01f, 2.43318915e-01f, -6.48940355e-02f, 1.92781731e-01f, 6.08822471e-03f, 1.55631706e-01f, 1.78158849e-01f, 1.12032846e-01f, -4.12186747e-03f, -1.84231415e-01f,
  -1.63393378e-01f, 1.56166017e-01f, -4.96913530e-02f, 3.90800714e-01f, 3.31473529e-01f, -2.09756657e-01f, 2.10801303e-01f, 1.56137004e-01f, 1.75489068e-01f, -9.56161879e-03f,
  1.12092450e-01f, 7.91690201e-02f, -1.08725287e-01f, -1.47589430e-01f, 2.46174246e-01f, 4.56196889e-02f, 2.00330973e-01f, -1.88257545e-01f, 1.21901758e-01f, 2.72892118e-01f,
  -1.01176538e-01f, -4.55333330e-02f, 2.73228794e-01f, 2.32005984e-01f, 4.11441270e-03f, -4.73842353e-01f, 1.80474564e-01f, 1.93285331e-01f, 1.19756302e-02f, -4.47424836e-02f,
  5.05168974e-01f, 3.86563629e-01f, -1.66847572e-01f, -1.73762903e-01f, -3.60735625e-01f, 5.52324951e-01f, 1.63741723e-01f, 4.74299751e-02f, 2.20976263e-01f, 2.10576475e-01f,
  3.41473222e-01f, 2.24640697e-01f, 2.46198066e-02f, 3.12111497e-01f, 4.54365730e-01f, 3.15063298e-02f, 1.82631910e-01f, -1.32246673e-01f, -2.62174904e-01f, -1.72856018e-01f,
  6.00115210e-02f, -3.91026065e-02f, -2.81077653e-01f, -2.33825952e-01f, 1.15518399e-01f, -2.17325538e-01f, 3.14001560e-01f, -4.03096080e-02f, -3.80784243e-01f, -8.52418691e-02f,
  1.55758634e-01f, 9.62246954e-03f, -7.66571164e-02f, -1.82778433e-01f, 3.06772530e-01f, 2.30156615e-01f, 5.90644926e-02f, 2.54393339e-01f, 1.11312017e-01f, -7.12200552e-02f,
  -7.03630671e-02f, 2.51704574e-01f, 4.19579707e-02f, 3.64237964e-01f, 3.25877547e-01f, 5.28955124e-02f, -2.31148094e-01f, -1.24720529e-01f, 1.28090596e-02f, -2.52551168e-01f,
  -3.16294208e-02f, -6.33941218e-02f, -5.70927374e-02f, 4.72166091e-01f, 1.21719996e-02f, -1.83979392e-01f, 1.54513121e-01f, 2.02778298e-02f, 1.13393538e-01f, -4.32556063e-01f,
  2.53520787e-01f, 1.85591295e-01f, -7.01813102e-02f, 1.19442850e-01f, -1.50036022e-01f, -2.79053412e-02f, -2.59629369e-01f, -5.66195920e-02f, 1.35090336e-01f, 3.30113769e-01f,
  3.86609137e-01f, -2.26547077e-01f, 1.49650022e-01f, -9.06863883e-02f, -6.68355003e-02f, -1.96311623e-02f, 1.75159901e-01f, -4.22253571e-02f, 3.26626897e-01f, 8.74002874e-02f,
  1.39928102e-01f, -5.69541119e-02f, -1.92031741e-01f, -9.30058882e-02f, -1.20771252e-01f, -1.37948081e-01f, 4.14016873e-01f, -1.65028140e-01f, -8.02716762e-02f, 3.59056890e-01f,
  2.20235124e-01f, 3.40481475e-02f, -2.30043754e-01f, -9.31561664e-02f, -2.53377706e-02f, 6.95865899e-02f, 2.11337909e-01f, -2.53233910e-01f, 2.03065485e-01f, 1.42776072e-01f,
  -1.61972661e-02f, 9.05160904e-02f, 1.41766751e-02f, -8.99755806e-02f, 7.34448358e-02f, 2.68438071e-01f, -8.47334266e-02f, -8.32034126e-02f, 1.28025040e-01f, 2.27377877e-01f,
  -1.56340867e-01f, 2.24949211e-01f, -3.05412300e-02f, 1.84251979e-01f, -1.35434017e-01f, 1.90923624e-02f, 4.22193706e-01f, -3.57518643e-02f, 1.90487862e-01f, 1.61738917e-01f,
  -1.15388922e-01f, 1.03184894e-01f, 1.10819019e-01f, 3.16680409e-02f, -2.09494591e-01f, -7.44522084e-03f, 1.29260570e-01f, 1.57659128e-01f, -4.03676592e-02f, -1.44332469e-01f,
  -5.79218268e-02f, 6.75521344e-02f, 1.15909986e-02f, 1.43123880e-01f, -8.40200931e-02f, 5.27113155e-02f, -1.65356267e-02f, -1.26246242e-02f, 2.07737088e-01f, 2.74957657e-01f,
  2.59517711e-02f, -1.66619554e-01f, -1.12258963e-01f, -6.58224300e-02f, -7.42040277e-02f, 1.94036300e-04f, -6.95640519e-02f, 8.44276771e-02f, -2.91396566e-02f, -6.65814504e-02f,
  1.17770411e-01f, -1.47883803e-01f, 2.41623729e-01f, -3.31102661e-03f, 1.53769314e-01f, 5.91713004e-03f, 5.07861525e-02f, 6.96435943e-02f, -6.49078237e-03f, 2.49200966e-02f,
  -7.33053684e-02f, -1.38386905e-01f, -1.17361536e-02f, 1.47900105e-01f, 5.62580645e-01f, -1.07882515e-01f, 4.74848568e-01f, 1.03212841e-01f, -6.09532967e-02f, 1.00983612e-01f,
  7.42153153e-02f, -1.68887116e-02f, -1.69125378e-01f, -8.64843130e-02f, 4.88516036e-03f, -1.35584086e-01f, -1.27134666e-01f, 3.97429138e-01f, -2.11791828e-01f, 4.55313548e-02f,
  6.70009181e-02f, 1.86700393e-02f, 5.42713225e-01f, -6.83583841e-02f, 4.73705024e-01f, 8.29266831e-02f, 4.92001563e-01f, 2.20709741e-01f, 1.92052260e-01f, 4.25174624e-01f,
  -3.26222405e-02f, -1.89023435e-01f, -1.37532815e-01f, 4.92650151e-01f, -1.14562683e-01f, 1.92414541e-02f, 3.73303384e-01f, 2.44527636e-03f, -3.23441684e-01f, 5.17713726e-01f,
  2.80270912e-02f, 3.30292791e-01f, 2.86413014e-01f, 4.92553681e-01f, -1.95470512e-01f, -1.12869702e-01f, 1.10635489e-01f, 5.56465052e-03f, -1.82382911e-01f, 3.45481694e-01f,
  -2.93444782e-01f, 7.22653195e-02f, -1.63459182e-01f, 9.50320363e-02f, -1.40273318e-01f, 1.93459302e-01f, 1.93913266e-01f, 2.32359499e-01f, 4.02557552e-01f, 5.83938062e-01f,
  5.95770329e-02f, -2.24914193e-01f, 1.16059810e-01f, 3.87046695e-01f, 1.55324131e-01f, 3.89629424e-01f, 9.71360970e-03f, -5.36716878e-02f, 2.41261452e-01f, 3.07366937e-01f,
  -3.35635453e-01f, 2.45506629e-01f, -1.62217364e-01f, 3.56182188e-01f, 2.77508527e-01f, 4.57846731e-01f, -2.29609653e-01f, 1.76350117e-01f, -2.79559512e-02f, -1.96665391e-01f,
  -8.10471326e-02f, 2.19704565e-02f, 5.11217602e-02f, 1.70161352e-01f, -9.80537608e-02f, -8.42142850e-02f, -1.02035619e-01f, 3.73698831e-01f, -4.43426631e-02f, 9.12356824e-02f,
  -1.35598943e-01f, -1.92892268e-01f, -3.74775603e-02f, 4.68604080e-02f, -7.35404808e-03f, 2.19983570e-02f, 3.01125854e-01f, 1.86254770e-01f, 1.18724167e-01f, 5.69528341e-02f,
  -6.09788746e-02f, -8.23607445e-02f, 2.04924941e-02f, -9.32308100e-03f, 8.82251486e-02f, 7.94469938e-02f, 2.25370321e-02f, 2.12406084e-01f, -2.22167876e-02f, 1.32544458e-01f,
  3.31354290e-01f, 2.24653855e-01f, 1.32764190e-01f, -6.43086433e-02f, 2.69799531e-01f, 6.42812774e-02f, 7.99946412e-02f, -1.95614815e-01f, -9.33996961e-02f, -4.04828899e-02f,
  -1.36258587e-01f, -2.23412663e-01f, 1.50803149e-01f, -1.88491419e-01f, 3.40712249e-01f, 3.00675750e-01f, 7.63486773e-02f, 6.86203912e-02f, -1.37363560e-03f, 4.45634544e-01f,
  -7.10838288e-02f, -2.68938560e-02f, -1.63458526e-01f, 2.02505365e-02f, -2.10901931e-01f, 2.35665962e-01f, 2.90279478e-01f, 7.84117654e-02f, -7.92548060e-03f, 3.58057767e-01f,
  -1.86595917e-01f, 8.71771574e-02f, 6.57040358e-01f, -2.43177205e-01f, 9.89373252e-02f, -8.69882703e-02f, 7.04288064e-03f, -4.63754013e-02f, -2.03332558e-01f, -1.90854430e-01f,
  -2.54593521e-01f, 4.81223762e-02f, 4.51413058e-02f, 9.07183886e-02f, -1.05801411e-02f, 7.51203373e-02f, 7.54742101e-02f, -1.63580179e-01f, -1.55742049e-01f, 4.19922680e-01f,
  -1.10623613e-01f, 1.16190612e-01f, -4.01599444e-02f, -1.01324700e-01f, 1.17526263e-01f, -1.69525862e-01f, -1.08766118e-02f, -1.52396366e-01f, -4.78745662e-02f, 1.03336431e-01f,
  9.40555856e-02f, -1.07043870e-01f, 1.24580696e-01f, 7.67095238e-02f, -5.06560914e-02f, -8.73399824e-02f, -2.30441820e-02f, -6.74093142e-02f, 2.69260198e-01f, -1.14316329e-01f,
  -1.35032639e-01f, -8.97060409e-02f, 1.59916848e-01f, 5.24864644e-02f, 2.19746217e-01f, -1.09437257e-01f, 4.97049987e-02f, -2.33034134e-01f, -2.97106981e-01f, -1.78087667e-01f,
  2.37595011e-03f, -6.78470135e-02f, 2.05992714e-01f, 1.05995527e-02f, 9.01593640e-02f, -5.65206259e-02f, -2.57760018e-01f, 3.27856898e-01f, -8.42151791e-02f, -1.89025374e-03f,
  2.50680923e-01f, 5.03366329e-02f, 2.94838428e-01f, 7.71477148e-02f, 3.80312681e-01f, -6.54075444e-02f, 1.56338900e-01f, 4.69946444e-01f, 9.93481278e-02f, -2.13964298e-01f,
  5.33393994e-02f, -6.99840188e-02f, -1.84635580e-01f, -7.96146784e-03f, 1.53082572e-02f, -1.89525425e-01f, -9.65065416e-03f, 1.57459632e-01f, 6.85283169e-03f, -2.10030109e-01f,
  -1.25746831e-01f, -9.59093124e-02f, 1.54803306e-01f, 6.51540384e-02f, -2.30579183e-01f, -3.40569280e-02f, 4.20530945e-01f, 2.53409803e-01f, -1.43782869e-01f, 3.20355475e-01f,
  2.03215033e-01f, -6.02493696e-02f, 1.73954964e-01f, 3.15567441e-02f, -6.97145313e-02f, -5.37090153e-02f, 3.03755134e-01f, -1.66604072e-01f, -4.82842363e-02f, 2.03636825e-01f,
  -3.84809785e-02f, 1.05648257e-01f, -6.01625368e-02f, -8.04687962e-02f, 1.60879567e-01f, -2.81570777e-02f, -1.40804544e-01f, -1.88043967e-01f, -3.21349762e-02f, 3.75053525e-01f,
  -1.24877682e-02f, 4.57624644e-01f, -1.23471752e-01f, -4.03309792e-01f, 2.23377034e-01f, 5.77530384e-01f, -1.31792501e-01f, -3.08029085e-01f, -7.02778548e-02f, 3.81261110e-02f,
  3.42372566e-01f, -1.07988231e-01f, 5.55634946e-02f, -1.95770964e-01f, 1.27079375e-02f, 1.46067724e-01f, -1.72048733e-01f, 1.40547007e-01f, 5.05103404e-03f, 5.59282862e-02f,
  -8.08189288e-02f, -1.62747681e-01f, 7.75215700e-02f, 5.47377430e-02f, 5.46953142e-01f, 1.56855956e-01f, 1.54786989e-01f, 7.87123367e-02f, 2.32896999e-01f, 3.29193175e-01f,
  9.98437107e-02f, -1.41609862e-01f, -1.03888037e-02f, -2.10993767e-01f, 1.20164625e-01f, -1.48689538e-01f, 2.25633606e-01f, -1.67172417e-01f, -1.30854085e-01f, 7.98633918e-02f,
  -2.67571568e-01f, -1.36495844e-01f, 3.81274462e-01f, -1.99450716e-01f, 8.06749046e-01f, -2.50604868e-01f, -1.35582536e-01f, -2.74587423e-01f, 1.46614715e-01f, 1.18236747e-02f,
  1.34086967e-01f, -5.47717959e-02f, -1.49872333e-01f, -9.37650874e-02f, -3.46435346e-02f, 2.19477460e-01f, 2.28178069e-01f, 2.69642591e-01f, -9.50143784e-02f, 6.24457777e-01f,
  4.30643678e-01f, -2.36275926e-01f, -5.21746576e-02f, -6.50755838e-02f, -1.82937622e-01f, -1.68902591e-01f, 1.70549572e-01f, 1.33930460e-01f, -1.18563287e-01f, -1.37216970e-01f,
  -4.00806926e-02f, -7.77734369e-02f, 1.84873223e-01f, 5.91584817e-02f, -1.83523864e-01f, 5.17100375e-03f, -7.68187791e-02f, -8.62370208e-02f, 3.11693221e-01f, -4.30436619e-02f,
  5.80595508e-02f, 2.27570180e-02f, 2.75418490e-01f, -1.07374877e-01f, 3.58733624e-01f, 1.15105003e-01f, 2.60820836e-02f, -3.71776447e-02f, 3.04538339e-01f, 5.16621396e-02f,
  2.71466989e-02f, -7.60966986e-02f, -4.30160053e-02f, -1.54160276e-01f, 1.20488531e-03f, -1.82534903e-01f, 3.73079404e-02f, -1.63043160e-02f, 1.68252899e-03f, 9.50978175e-02f,
  1.11322120e-01f, 4.55380492e-02f, 1.25974998e-01f, 2.28782818e-02f, -1.68657452e-01f, -2.23366767e-02f, -4.50426899e-02f, -1.39129922e-01f, -1.61821708e-01f, 4.73538227e-02f,
  1.04574963e-01f, 1.57005057e-01f, -5.69251552e-02f, -1.17092714e-01f, -5.90459667e-02f, 9.04056728e-02f, 4.77072522e-02f, -1.21346600e-01f, 4.17459272e-02f, 2.16979012e-02f,
  1.93902671e-01f, -1.45593792e-01f, -7.08000315e-03f, 2.47546434e-02f, -1.21231034e-01f, -9.50157344e-02f, 9.33387503e-02f, -1.65986300e-01f, -1.28681719e-01f, -1.93212420e-01f,
  4.66463447e-01f, 2.55143672e-01f, -1.87112585e-01f, 2.52173811e-01f, 4.85569388e-02f, -1.02534629e-01f, -1.58921510e-01f, -1.08605728e-01f, 2.25665703e-01f, -3.04087520e-01f,
  1.21896327e-01f, 1.52845553e-03f, 3.64295423e-01f, -2.74544924e-01f, 1.09403521e-01f, 2.98799891e-02f, -8.40546563e-02f, 4.33215089e-02f, 5.53732991e-01f, -6.86527640e-02f,
  1.41289253e-02f, 5.15838750e-02f, 3.80061835e-01f, -2.63591087e-03f, -1.72896802e-01f, -1.71368897e-01f, 1.32432833e-01f, 6.82799071e-02f, 6.41892731e-01f, 3.39556597e-02f,
  2.78494298e-01f, -2.23528057e-01f, -3.42266738e-01f, 7.93646351e-02f, 1.33351341e-01f, -2.55013227e-01f, -2.24655941e-01f, -2.40143865e-01f, 4.80581135e-01f, 4.90825921e-01f,
  3.26738715e-01f, 4.15975839e-01f, 2.97311187e-01f, 3.27363461e-01f, -8.50481987e-02f, 2.04324231e-01f, -5.16731180e-02f, -4.32707757e-01f, 3.76175046e-01f, -1.04149856e-01f,
  -5.27120344e-02f, 3.53307575e-01f, -1.39650658e-01f, 4.85624075e-01f, -2.62533486e-01f, -1.19887166e-01f, 2.20163241e-01f, -1.75252721e-01f, -1.32925734e-01f, -1.71722919e-01f,
  1.66850373e-01f, -2.27021694e-01f, 1.34743884e-01f, -2.74665505e-01f, 3.91263008e-01f, 1.13769822e-01f, 6.34457916e-02f, -2.18919013e-02f, 1.35806248e-01f, 5.96310675e-01f,
  2.48747632e-01f, 6.37074560e-02f, 2.39230972e-02f, -2.94327289e-01f, -1.62198991e-01f, 4.27607417e-01f, -4.62607451e-04f, 1.29192069e-01f, 1.38471618e-01f, 1.80453528e-02f,
  -1.25604317e-01f, -2.41482500e-02f, 2.78396547e-01f, 2.57859945e-01f, -6.33333549e-02f, 2.72123307e-01f, -1.75274491e-01f, 2.20966578e-01f, -3.13221961e-02f, 1.21672779e-01f,
  2.09430724e-01f, 7.96088353e-02f, 1.92799643e-01f, -2.21541584e-01f, 4.06291485e-02f, 2.27831095e-01f, -1.63484529e-01f, -3.00615374e-02f, 2.71370232e-01f, 1.19958930e-02f,
  -1.43121565e-02f, -1.60334751e-01f, 3.29342484e-01f, 1.97975427e-01f, -6.55377060e-02f, -2.68215239e-01f, 3.17130893e-01f, -1.10030033e-01f, -1.93045568e-02f, -2.26962611e-01f,
  6.79566637e-02f, -7.77418092e-02f, 3.41926694e-01f, 1.59658000e-01f, 5.25033521e-03f, -1.05308190e-01f, 3.28856297e-02f, -2.25832537e-01f, 5.53204954e-01f, 1.89754441e-01f,
  -8.44875947e-02f, 2.53978908e-01f, -8.34233016e-02f, 1.66842137e-02f, -5.00102565e-02f, -8.61615315e-03f, 2.06422620e-02f, 7.97518902e-03f, -6.91974675e-03f, -3.06537032e-01f,
  -3.60858142e-02f, 5.69349751e-02f, 4.57708508e-01f, -2.95394778e-01f, 3.13161254e-01f, 1.63766906e-01f, -6.37024194e-02f, 4.82015051e-02f, -3.69989611e-02f, -1.14998288e-01f,
  5.71330301e-02f, -1.34931251e-01f, -1.12518415e-01f, 3.73585187e-02f, 2.31333449e-01f, 2.82759994e-01f, 3.34126472e-01f, 1.11949503e-01f, 1.05757773e-01f, -1.92525521e-01f,
  2.07827672e-01f, -2.24555414e-02f, -1.77900009e-02f, -2.46564373e-01f, -1.82928905e-01f, 2.24981099e-01f, 1.78473983e-02f, 3.36447358e-01f, 1.08142219e-01f, -1.87273175e-01f,
  5.07850684e-02f, -2.24592686e-01f, -1.50952026e-01f, -1.25606671e-01f, 4.45850968e-01f, -1.52258947e-01f, -6.98108634e-04f, -1.08838901e-01f, -4.10786979e-02f, 2.80745258e-03f,
  -7.41674080e-02f, 1.65987730e-01f, 1.17223993e-01f, 1.97073013e-01f, 8.20637681e-03f, -7.03232363e-02f, -7.20677152e-02f, 9.92396176e-02f, 3.86069238e-01f, 4.67143655e-01f,
  -8.22571889e-02f, -1.48409247e-01f, 1.76561579e-01f, -1.20049909e-01f, -6.06572367e-02f, -2.27838293e-01f, 8.84665027e-02f, -1.65481135e-01f, -9.81342494e-02f, 2.70054519e-01f,
  5.63333742e-02f, 4.62293804e-01f, -2.52152622e-01f, -1.32389009e-01f, -4.30422388e-02f, 2.35415563e-01f, -1.67922318e-01f, 3.47316661e-03f, 1.20358549e-01f, -4.98983674e-02f,
  3.05144548e-01f, -1.18433177e-01f, -1.36917114e-01f, -1.81392040e-02f, -1.32884949e-01f, -1.72242999e-01f, 1.99409112e-01f, 3.58720958e-01f, 1.02670603e-01f, -1.05807520e-01f,
  -4.42350134e-02f, -1.71551034e-01f, -1.48325235e-01f, 1.35262609e-01f, 2.43948437e-02f, 1.94968171e-02f, -3.64121757e-02f, -4.77049351e-02f, 1.25506878e-01f, 2.03976139e-01f,
  1.50334137e-02f, 1.90010697e-01f, 2.74518073e-01f, 2.47262537e-01f, -3.86032850e-01f, -1.41588405e-01f, 1.15240611e-01f, -2.39177480e-01f, 1.78967550e-01f, -1.27221718e-01f,
  -2.34749205e-02f, -1.36961207e-01f, 1.16355240e-01f, 3.91163319e-01f, -5.93927540e-02f, -8.54142457e-02f, 2.03792676e-01f, 3.96698684e-01f, 2.68576443e-01f, 6.40093803e-01f,
  1.92291737e-02f, 3.05632472e-01f, -1.01828188e-01f, 8.55880827e-02f, 1.44405023e-03f, 1.81010708e-01f, -1.38330489e-01f, 3.99256423e-02f, 2.57629365e-01f, 2.77462721e-01f,
  -1.19543284e-01f, -3.59108411e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.03866214e-01f, 2.15021387e-01f, 4.66889217e-02f, 9.76734906e-02f, 3.17533553e-01f, 1.89890005e-02f, 1.41958043e-01f, 1.93348765e-01f, 3.33266079e-01f, -3.47635262e-02f,
  1.90185890e-01f, 1.01225242e-01f, 9.83225480e-02f, 1.30685031e-01f, 3.68066937e-01f, 2.94790804e-01f, 8.29526931e-02f, -1.40235558e-01f, 1.58952355e-01f, 5.64048052e-01f,
  1.27861381e-01f, 1.49626553e-01f, 1.18816867e-01f, 9.04502124e-02f, 2.71897048e-01f, 3.38438004e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.40248751e-03f, 3.20432365e-01f, -2.08340436e-01f, 4.04653251e-01f, 3.44906114e-02f, 4.03460473e-01f, 5.14857471e-01f, 4.05471265e-01f, 4.02305096e-01f, 1.64302796e-01f,
  -3.56075913e-02f, 2.78660208e-01f, -2.75353551e-01f, 2.61086881e-01f, 1.75461322e-01f, -1.53241485e-01f, -1.43894479e-01f, 1.56638362e-02f, 3.92361373e-01f, 1.09321304e-01f,
  -1.88139290e-01f, -2.24832803e-01f, -1.07439965e-01f, -1.90949496e-02f, -1.55685484e-01f, 1.93005249e-01f, -5.47830403e-01f, -2.79035002e-01f, -2.28571042e-01f, -2.42788523e-01f,
  -1.18667647e-01f, 4.54057008e-01f, 7.45357573e-02f, -2.95003235e-01f, 3.63633148e-02f, 1.81222141e-01f, -4.19702917e-01f, 2.61384189e-01f, -1.88382521e-01f, 5.96846700e-01f,
  -1.51713744e-01f, -2.49732241e-01f, -2.34349281e-01f, -1.64318785e-01f, -2.17257783e-01f, 3.58452857e-01f, 7.73281932e-01f, 2.31854647e-01f, 4.51500863e-01f, -1.04784079e-01f,
  -1.89960927e-01f, -3.29047650e-01f, -4.03842896e-01f, -2.90525496e-01f, -3.30990434e-01f, 1.00180753e-01f, -4.11080122e-01f, -5.64567387e-01f, 2.98163146e-01f, -2.74553984e-01f,
  -2.06577510e-01f, -2.49101245e-03f, -1.63299009e-01f, 3.26554894e-01f, 7.27332830e-02f, 1.96231768e-01f, -4.41210866e-02f, -2.38838494e-01f, 1.10045947e-01f, -3.29702020e-01f,
  -4.84144241e-01f, 2.85555601e-01f, -2.69878209e-01f, 2.35398889e-01f, -1.96199805e-01f, -2.97395773e-02f, -2.92725533e-01f, 3.88436079e-01f, -3.75844300e-01f, 1.39961779e-01f,
  8.19515884e-01f, 2.30944231e-02f, 1.40505955e-01f, 2.75617260e-02f, -3.10375243e-01f, -1.72833398e-01f, 2.06902966e-01f, 1.10346511e-01f, 3.80278379e-01f, -2.75926530e-01f,
  5.34759521e-01f, -2.39253059e-01f, -2.84009457e-01f, 2.25620121e-01f, -1.65675774e-01f, -3.46466511e-01f, -7.28831947e-01f, -1.04928933e-01f, -3.28947216e-01f, 3.01751137e-01f,
  -2.82666415e-01f, -4.35461730e-01f, -1.99022532e-01f, -5.02342820e-01f, 6.39298677e-01f, -1.98210850e-01f, 2.98111945e-01f, -9.61824432e-02f, -3.20720971e-01f, -1.74993098e-01f,
  -2.21871987e-01f, -2.65424121e-02f, -6.32378012e-02f, -1.77883878e-01f, 2.40170673e-01f, 5.07456303e-01f, -1.55341715e-01f, -3.68649960e-01f, 1.88379735e-01f, 4.96120937e-03f,
  -5.00054806e-02f, 6.31367803e-01f, 1.06979869e-01f, 3.52328032e-01f, 1.55777678e-01f, -1.87038958e-01f, -1.31841516e-02f, 3.98940854e-02f, 4.74804580e-01f, 6.02889299e-01f,
  3.23093504e-01f, 2.91252792e-01f, 3.86670798e-01f, -3.95540744e-01f, 3.01482081e-01f, 1.02880009e-01f, -2.10807934e-01f, 1.44841552e-01f, 5.41370869e-01f, -6.38412386e-02f,
  2.88347721e-01f, -1.72895804e-01f, -1.56067178e-01f, -1.92214306e-02f, -3.36800188e-01f, -1.22896373e-01f, -3.89506400e-01f, 3.21375728e-01f, 2.48061761e-01f, -6.77966475e-02f,
  -9.19799209e-02f, 5.28227128e-02f, -3.27563047e-01f, 1.05712748e+00f, -2.72562444e-01f, -1.92411199e-01f, -2.64489412e-01f, -2.01273374e-02f, 2.11055763e-02f, 2.48295113e-01f,
  2.58673966e-01f, 3.28618944e-01f, -8.83080885e-02f, -1.41353071e-01f, 1.01744376e-01f, 5.49336255e-01f, -1.57912940e-01f, -6.42372251e-01f, 7.23935813e-02f, -2.77664542e-01f,
  1.49343312e-01f, 2.08718657e-01f, 2.32918710e-01f, 4.09030855e-01f, 5.15673697e-01f, -1.08576819e-01f, -1.31950706e-01f, -3.60646881e-02f, -1.85662016e-01f, -2.60747045e-01f,
  4.55980361e-01f, 4.73642237e-02f, -1.92007348e-01f, -1.51702091e-01f, -1.74714237e-01f, -3.92475307e-01f, -1.73423290e-01f, -1.41372755e-01f, -1.71153486e-01f, -6.03124499e-02f,
  6.34806156e-01f, 6.14912510e-01f, 3.31863791e-01f, 1.98029026e-01f, 1.97659567e-01f, -6.18610531e-02f, 7.22955227e-01f, 3.58898267e-02f, -1.22577421e-01f, -2.75468349e-01f,
  -4.45079982e-01f, -2.10742310e-01f, -2.75063813e-01f, -2.18423158e-01f, 3.10794622e-01f, 8.77558768e-01f, 2.08609834e-01f, -2.07976148e-01f, -1.23714404e-02f, 3.44458856e-02f,
  -3.65654796e-01f, -8.05968270e-02f, -1.67784974e-01f, 6.62078289e-03f, -1.90509066e-01f, -1.10167593e-01f, 1.70510605e-01f, 4.79394674e-01f, 5.89214683e-01f, 1.21071003e-02f,
  -2.23651052e-01f, -1.19851738e-01f, 5.20915128e-02f, -4.52908337e-01f, -2.00608432e-01f, 7.90448934e-02f, -3.36336121e-02f, 4.37867612e-01f, -4.54522222e-01f, 7.57645816e-02f,
  2.36180767e-01f, -2.77025282e-01f, 3.42658758e-01f, -1.05893545e-01f, -2.95336813e-01f, -1.66264415e-01f, 8.39234591e-02f, -4.14573163e-01f, -3.11606765e-01f, -2.19127506e-01f,
  -1.61779951e-02f, -1.21283501e-01f, 6.78686798e-02f, -2.22353041e-02f, 1.62100568e-01f, 9.38859224e-01f, 8.76362547e-02f, -4.90602627e-02f, -2.46078163e-01f, 5.88409305e-02f,
  -1.28149122e-01f, 6.36187673e-01f, -2.13721216e-01f, -3.10353428e-01f, -4.91893254e-02f, 2.42698770e-02f, -4.95749325e-01f, -2.08793312e-01f, -1.65192291e-01f, -5.27373016e-01f,
  -1.88303933e-01f, 2.21962005e-01f, 5.59308678e-02f, 3.11675012e-01f, -2.68878222e-01f, 1.69225007e-01f, -6.46043494e-02f, -1.22815378e-01f, -2.61719793e-01f, -4.44839925e-01f,
  -1.43574327e-01f, 4.04466301e-01f, 4.72575903e-01f, -4.94912080e-02f, 1.17730394e-01f, -6.94229007e-02f, -4.01695818e-02f, -1.73613712e-01f, 3.72744530e-01f, 2.36173853e-01f,
  7.31985509e-01f, -4.76305008e-01f, -2.67193317e-01f, 2.49172419e-01f, 3.72907162e-01f, 2.26746857e-01f, -1.21673033e-01f, -3.21510434e-02f, 2.07362413e-01f, -3.12575638e-01f,
  5.31212837e-02f, -5.16208470e-01f, 7.16260791e-01f, -3.81632239e-01f, -3.56864817e-02f, 5.34403138e-02f, -1.15802355e-01f, 7.52964795e-01f, 8.22158232e-02f, -9.64517072e-02f,
  5.46919763e-01f, -2.89638758e-01f, -5.89286447e-01f, 6.19398803e-03f, -1.97703212e-01f, 9.82076451e-02f, -1.25504844e-02f, -1.05302341e-01f, 1.57767124e-02f, 7.63317883e-01f,
  -1.71541303e-01f, -7.61261061e-02f, 2.60688841e-01f, -1.25280112e-01f, 1.88356355e-01f, -2.53486067e-01f, -1.49262249e-01f, -4.16119881e-02f, -2.89556235e-01f, -3.45624715e-01f,
  -5.25751635e-02f, -1.02268405e-01f, 1.05480060e-01f, 4.02727544e-01f, -5.90777755e-01f, -5.12559772e-01f, -2.02884540e-01f, 4.19356108e-01f, -2.23806247e-01f, -2.77292007e-03f,
  3.96656305e-01f, -1.49527937e-01f, -2.59498119e-01f, -4.10714984e-01f, -5.32165952e-02f, 2.91866869e-01f, -2.84905940e-01f, -6.54064715e-02f, 5.32556117e-01f, 8.46368819e-03f,
  -2.49253362e-01f, -3.39422196e-01f, -7.01170638e-02f, -1.49591729e-01f, -3.17443430e-01f, 2.49233872e-01f, 8.62463936e-02f, -3.60552192e-01f, 4.68243182e-01f, 7.70311296e-01f,
  -2.04586700e-01f, 2.28439018e-01f, 2.52360791e-01f, 1.93717241e-01f, 1.24307983e-01f, -2.65080810e-01f, -2.73379147e-01f, -1.66216061e-01f, 4.82478784e-03f, -5.42612910e-01f,
  -1.65905625e-01f, -2.41945639e-01f, 1.75430626e-01f, -6.31515607e-02f, -2.04958439e-01f, -4.89583224e-01f, 5.03321826e-01f, 3.81050445e-02f, -1.09455839e-01f, 5.10656178e-01f,
  -2.18258038e-01f, -1.48906767e-01f, 9.65996861e-01f, -2.62517542e-01f, 2.32203342e-02f, -1.41196415e-01f, 4.21704128e-02f, -3.91774327e-01f, -1.64406613e-01f, 2.91641116e-01f,
  1.88567370e-01f, 8.77789594e-03f, 3.22160065e-01f, -4.46096659e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.29225472e-01f, -8.26766938e-02f, 1.08001135e-01f, -3.40197049e-02f, 8.18725079e-02f, -1.20541696e-02f, 1.60303805e-02f, -2.24236190e-01f, -2.03888223e-01f, 2.33253598e-01f,
  6.48760470e-03f, 1.90414175e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    