/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.21791220e-01f, -2.31480226e-01f, 6.71006739e-02f, 2.59801894e-01f, 8.96362122e-03f, 3.57629135e-02f, -7.09786499e-03f, -3.31155211e-02f, 2.37012252e-01f, -1.44825764e-02f,
  -3.14971840e-04f, 3.27447876e-02f, 1.63312443e-02f, 5.05092628e-02f, 1.75842583e-01f, 8.41542035e-02f, 2.69969791e-01f, 2.30407894e-01f, 1.37362719e-01f, -1.16776675e-01f,
  1.93159431e-02f, 6.04926497e-02f, 1.85639501e-01f, -1.02465823e-02f, -1.26629584e-02f, -5.66422641e-02f, -4.23735753e-02f, -6.18012995e-02f, -6.07297905e-02f, 1.88950589e-03f,
  -2.89073884e-02f, -1.73915233e-02f, 5.30070215e-02f, 2.57015508e-02f, -1.07408963e-01f, -7.03648664e-03f, 1.07135646e-01f, 3.38583142e-02f, -1.65728517e-02f, -3.11663235e-03f,
  5.01893973e-03f, -1.35133080e-02f, 5.66079728e-02f, 1.30546512e-02f, -1.93267968e-02f, 4.60180826e-02f, 2.92384885e-02f, 4.69456315e-02f, 1.00597672e-01f, 8.59909784e-03f,
  -3.98625918e-02f, 2.75998767e-02f, -5.30501232e-02f, 4.00814265e-02f, -7.12820441e-02f, 1.31681338e-01f, -1.60300404e-01f, -6.15498275e-02f, -9.54381842e-03f, -7.94697627e-02f,
  1.63965411e-02f, 2.62784585e-02f, 6.00688122e-02f, -8.81971195e-02f, 4.01479565e-02f, -1.92915145e-02f, -9.63327438e-02f, -6.39751479e-02f, 4.10535075e-02f, -1.37088690e-02f,
  -4.49247584e-02f, 2.83577219e-02f, 3.46745201e-03f, 3.24743800e-02f, 1.24609787e-02f, 2.47433148e-02f, -1.99060626e-02f, 1.44153079e-02f, -8.64240900e-03f, -8.61311257e-02f,
  -6.39039874e-02f, -2.35555861e-02f, 4.92305048e-02f, -1.86290488e-01f, 1.10461846e-01f, -8.45531747e-03f, 1.10112742e-01f, 8.00202880e-03f, -3.82521166e-03f, 3.67427729e-02f,
  -6.96053654e-02f, 1.62876457e-01f, 4.66860048e-02f, -3.52620259e-02f, 2.16054674e-02f, 4.11613099e-02f, -3.53405252e-02f, -4.22044583e-02f, -8.10737982e-02f, -4.91575748e-02f,
  -9.56248119e-02f, -8.88271108e-02f, -4.29435708e-02f, -1.24636114e-01f, 9.45994072e-03f, -2.74371896e-02f, -5.34593277e-02f, -2.49505360e-02f, 1.14376806e-02f, -5.50752990e-02f,
  -3.24109988e-03f, -7.07875863e-02f, -3.34149748e-02f, -4.78814729e-02f, 4.82653864e-02f, 1.09410226e-01f, -4.20010947e-02f, -3.58111598e-02f, 1.19904459e-01f, -1.36673138e-01f,
  3.08403283e-01f, -9.44533721e-02f, 1.86033294e-01f, 5.91611722e-03f, -2.50863796e-03f, 1.84450418e-01f, 1.41541407e-01f, 6.44498318e-02f, -4.76711467e-02f, -5.99405030e-03f,
  -1.15333006e-01f, -1.32316276e-01f, -4.20440100e-02f, -1.32243529e-01f, 8.24868977e-02f, 8.18074867e-03f, 9.34632123e-02f, 2.53489837e-02f, 1.32120788e-01f, 7.85378218e-02f,
  -1.95727214e-01f, -5.09297363e-02f, 4.53994758e-02f, 6.53375126e-03f, -4.55495454e-02f, -1.23112559e-01f, 3.02126259e-02f, -5.98420873e-02f, -1.51557714e-01f, -2.67831296e-01f,
  -6.41734004e-02f, 1.60700306e-01f, -6.66706562e-02f, -6.68735951e-02f, 2.19688583e-02f, -3.73730771e-02f, 4.30728383e-02f, 5.41428961e-02f, 5.21454141e-02f, -4.20386763e-03f,
  2.03444604e-02f, -7.28312731e-02f, 1.05652086e-01f, -4.24291454e-02f, -1.11539327e-02f, 6.31380379e-02f, -1.97970378e-03f, 7.22183064e-02f, 3.27728689e-02f, 5.68053802e-04f,
  8.20011646e-03f, 2.40140799e-02f, 1.14503860e-01f, -4.44471762e-02f, -1.07209943e-02f, -4.26408313e-02f, 4.11969498e-02f, 6.42913627e-03f, 1.96682531e-02f, -4.99418937e-02f,
  -1.75964851e-02f, 5.04276790e-02f, -2.54576933e-02f, 6.48427755e-02f, -2.33775955e-02f, -5.28748594e-02f, 4.30969428e-03f, -3.85250486e-02f, -7.14311153e-02f, 7.51268002e-04f,
  -1.37169724e-02f, -5.89460470e-02f, -5.51734678e-02f, 4.57220376e-02f, -6.32019192e-02f, 7.00165778e-02f, 4.09588441e-02f, 4.98102605e-02f, -4.86430228e-02f, -1.71104830e-03f,
  -7.84179792e-02f, -7.20743090e-03f, -1.78398173e-02f, 7.21502230e-02f, 5.15480489e-02f, 2.77981497e-02f, 6.08930811e-02f, -2.99840774e-02f, -2.88354624e-02f, -1.83877070e-02f,
  -1.22980915e-01f, 7.13613406e-02f, -1.51071876e-01f, -5.86530045e-02f, 7.38199279e-02f, -3.56428176e-02f, -1.03640668e-01f, -3.29737701e-02f, 3.51323038e-02f, -2.96859890e-02f,
  1.09112389e-01f, 8.03896859e-02f, -1.56977586e-02f, -1.68923177e-02f, -5.93523234e-02f, -3.12606990e-02f, 1.66914333e-02f, 4.12956625e-03f, -1.19058833e-01f, -9.48741511e-02f,
  -8.30153376e-02f, 1.00049097e-02f, -1.91400026e-03f, -9.59305093e-02f, -6.99712411e-02f, -5.47430515e-02f, -4.40518484e-02f, 3.86546478e-02f, 5.17615043e-02f, -7.20192641e-02f,
  -1.19419187e-01f, 1.47773877e-01f, 2.87895113e-01f, -1.23754479e-01f, 5.18398248e-02f, -1.35248795e-01f, 9.90685076e-03f, -7.00317547e-02f, -1.42669648e-01f, 3.54687460e-02f,
  -7.47571066e-02f, -1.11387543e-01f, -1.20445929e-01f, -7.07971379e-02f, 4.52921689e-02f, 1.80719927e-01f, 2.12846160e-01f, 9.86848250e-02f, -1.55461848e-01f, -1.18658826e-01f,
  -3.78520787e-02f, 1.87999289e-02f, 3.68662365e-02f, -1.30672846e-03f, 1.65787879e-02f, -1.55739188e-01f, 1.39653847e-01f, 1.27263471e-01f, -2.27175275e-04f, 2.82673836e-01f,
  5.04459627e-02f, 7.44849965e-02f, -3.15660723e-02f, 2.25883555e-02f, 9.33245867e-02f, -4.78387810e-02f, -6.87664449e-02f, 6.16058409e-02f, -5.93854561e-02f, 9.94453356e-02f,
  5.48429415e-02f, 1.75937172e-02f, 2.82625444e-02f, -1.66867748e-02f, -5.17852465e-03f, -3.76725830e-02f, 8.00464079e-02f, 1.11124694e-01f, 1.33670911e-01f, 3.58399972e-02f,
  5.40216919e-03f, -2.63222530e-02f, 9.86041874e-02f, -5.01741841e-02f, -3.44136953e-02f, -9.49902982e-02f, -1.45054338e-02f, -6.95866812e-03f, -3.10399402e-02f, 1.04983198e-02f,
  -1.33519480e-02f, 1.80568993e-02f, -3.86688709e-02f, -1.85533129e-02f, -1.91751644e-02f, 4.89513874e-02f, -5.71023561e-02f, 5.80965951e-02f, 7.65395090e-02f, 4.86876536e-03f,
  -1.64112058e-02f, -3.63831297e-02f, -2.04973598e-03f, -3.66505585e-03f, -2.18905620e-02f, 7.74894059e-02f, -4.35774513e-02f, -6.38048947e-02f, 6.38008267e-02f, 2.18468048e-02f,
  -1.60924066e-02f, -4.89889819e-04f, 4.15656567e-02f, -1.55916410e-02f, 5.86211011e-02f, 6.16554692e-02f, 5.29751517e-02f, -4.51773852e-02f, -2.14042235e-02f, 6.50499240e-02f,
  -2.06319794e-01f, 6.14042580e-02f, -1.94442626e-02f, -5.77939264e-02f, -3.70420106e-02f, 4.26533893e-02f, -1.90843865e-02f, 9.68795046e-02f, 7.25803059e-03f, -1.81480851e-02f,
  -6.22087643e-02f, -4.80950102e-02f, -5.63200330e-03f, 7.96563700e-02f, -7.52212107e-02f, -1.38801131e-02f, -8.42933878e-02f, -8.75057578e-02f, -6.14107074e-03f, -3.01363766e-02f,
  -7.18798414e-02f, -1.27396941e-01f, -2.11989656e-01f, -1.15339465e-01f, -9.12854522e-02f, -2.45712399e-01f, -2.10409194e-01f, -9.82765406e-02f, -1.48893252e-01f, -1.28615230e-01f,
  -2.87400186e-01f, 7.10240230e-02f, -2.42060944e-01f, -2.92260498e-01f, -2.90333301e-01f, -3.69339809e-03f, -2.08906010e-02f, -5.29052056e-02f, -2.46518124e-02f, 1.91390719e-02f,
  2.14772411e-02f, 1.36117847e-03f, 4.34153676e-02f, 2.14236956e-02f, 7.88702667e-02f, -8.50127190e-02f, -1.01796374e-01f, -1.52442023e-01f, -1.76303953e-01f, -1.25451505e-01f,
  1.60476100e-03f, -1.78159133e-01f, -1.31795168e-01f, 5.79862259e-02f, -9.09072757e-02f, -2.94191707e-02f, -2.04932713e-03f, -8.12725499e-02f, 1.02074854e-02f, -1.48870081e-01f,
  -1.26922280e-01f, -1.48329064e-01f, -1.08099565e-01f, -7.07326317e-03f, -7.55174160e-02f, -2.58730445e-02f, -6.38434896e-03f, -3.31335552e-02f, 1.09153070e-01f, -6.66584820e-04f,
  -2.53592078e-02f, 6.26929253e-02f, -7.02936947e-02f, 2.37286258e-02f, -9.16028991e-02f, -3.94079573e-02f, 5.28205968e-02f, -1.16600180e-02f, -3.71524645e-03f, -4.44400683e-02f,
  -4.43647206e-02f, 4.97338176e-02f, 1.25277508e-02f, 8.30748007e-02f, 1.35212634e-02f, -4.22726246e-03f, 2.10595429e-02f, -1.55477226e-02f, -5.39348982e-02f, 8.97958055e-02f,
  2.04315484e-02f, 3.91199663e-02f, 4.12742086e-02f, -1.24662500e-02f, 4.22258973e-02f, 2.30084378e-02f, -1.43317595e-01f, 8.50485638e-03f, -6.63714856e-02f, 7.03519508e-02f,
  5.52712865e-02f, -1.60433259e-03f, 7.19007105e-02f, -1.76625401e-02f, -2.95580681e-02f, -4.52017374e-02f, 3.21231573e-03f, 1.80693604e-02f, 1.26894878e-03f, -4.59365696e-02f,
  1.45965139e-03f, 5.41131310e-02f, -6.77810386e-02f, -4.91718315e-02f, 4.67364155e-02f, -6.27708947e-03f, 2.43573040e-02f, -2.74344459e-02f, -6.08161315e-02f, 3.56567763e-02f,
  -9.38181533e-04f, 3.41610424e-02f, 3.11869625e-02f, -3.29931490e-02f, 5.33942766e-02f, 1.18521363e-01f, -3.40296775e-02f, -8.49556103e-02f, -7.29717240e-02f, -1.71582215e-02f,
  1.81694776e-02f, -3.10234297e-02f, 6.08707108e-02f, 3.28977406e-02f, 2.09668074e-02f, -1.70646179e-02f, 1.70583688e-02f, -1.22246640e-02f, 1.96960941e-02f, -7.32186586e-02f,
  8.24023187e-02f, 1.03706839e-02f, 7.23817572e-02f, 2.65926961e-02f, 9.21409279e-02f, -5.67436405e-02f, -3.93679226e-03f, -1.79476552e-02f, 7.81749636e-02f, 1.21486843e-01f,
  3.20506364e-01f, -3.32907557e-01f, -7.30195343e-02f, 7.78292269e-02f, -2.96322405e-01f, -2.41170630e-01f, -4.49063838e-01f, -6.61912039e-02f, 1.57666668e-01f, -1.80594638e-01f,
  -2.74328709e-01f, 1.94973722e-01f, 1.06106922e-01f, 6.56242296e-02f, 7.92814121e-02f, -1.08379811e-01f, -8.67723227e-02f, 1.41868129e-01f, 2.21252128e-01f, -1.02570996e-01f,
  -4.87784296e-02f, -3.23251784e-02f, 1.90216675e-01f, 2.25501746e-01f, -1.43537506e-01f, 3.09442610e-01f, 3.05834692e-02f, -8.56220871e-02f, -9.63702276e-02f, -1.59886643e-01f,
  -1.63917821e-02f, -8.56772885e-02f, 6.00590520e-02f, 9.44380537e-02f, -4.74002957e-02f, 8.60512033e-02f, -5.71106449e-02f, 7.17317611e-02f, 5.94516322e-02f, 7.53088444e-02f,
  -1.10023431e-01f, -5.36868684e-02f, 3.60333659e-02f, -1.41738076e-02f, -6.19561933e-02f, -1.39729800e-02f, 1.30372364e-02f, 1.20595336e-01f, -9.77906026e-03f, 9.69885103e-03f,
  -2.94355564e-02f, -1.51456460e-01f, -2.41217643e-01f, -4.96571735e-02f, 6.51128665e-02f, 2.86647175e-02f, -1.28044575e-01f, -2.94215847e-02f, -3.74647900e-02f, -4.99216132e-02f,
  4.47139516e-03f, -3.14417086e-03f, -2.93501206e-02f, -3.22300009e-02f, 3.02455630e-02f, -2.56861765e-02f, 7.51223415e-02f, -4.10489812e-02f, -3.10387444e-02f, 8.30580294e-02f,
  -1.87353324e-02f, 1.72162894e-02f, -3.56778532e-04f, -4.75822110e-03f, 5.63053489e-02f, -6.60258159e-02f, 1.71237942e-02f, -5.36946654e-02f, 5.77432290e-02f, -6.49008993e-03f,
  1.08581141e-01f, 2.27753795e-03f, -6.13462292e-02f, 2.45218650e-02f, -5.46897296e-03f, 7.80444667e-02f, 2.68755737e-03f, -3.27138528e-02f, 3.99172157e-02f, -5.08276187e-02f,
  8.52801502e-02f, -2.92424727e-02f, 1.22528352e-01f, -4.91335429e-02f, -1.13083068e-02f, 2.86150053e-02f, 5.16676530e-02f, 3.42364833e-02f, -7.73285031e-02f, -1.04789041e-01f,
  -5.41450791e-02f, 5.38465194e-02f, -4.75295708e-02f, 1.13830259e-02f, -2.62917094e-02f, 5.96187543e-04f, 2.01423536e-05f, -2.00640541e-02f, -1.19348401e-02f, -4.27187979e-02f,
  -2.43734270e-02f, 2.53195204e-02f, -4.70965030e-03f, 4.42209989e-02f, -2.53163092e-02f, -3.54968049e-02f, -3.94316250e-03f, 2.54863575e-02f, 6.46872562e-04f, 7.64737949e-02f,
  -1.19936414e-01f, -9.83636361e-03f, 1.45069361e-01f, 1.24892808e-01f, 1.14033092e-02f, 6.47201240e-02f, -2.12361887e-01f, 3.39849084e-03f, 5.19954674e-02f, -8.38576034e-02f,
  6.46284893e-02f, 2.04992577e-01f, 9.22981352e-02f, 4.98332083e-02f, -9.18201879e-02f, -2.74868757e-02f, -1.20986477e-01f, -6.18810253e-03f, 2.23016758e-02f, 9.98676643e-02f,
  3.02594132e-03f, -4.89577502e-02f, 6.72693029e-02f, -4.31732722e-02f, -1.00312561e-01f, 7.54522309e-02f, -1.20872542e-01f, -2.32284784e-01f, -4.18649167e-02f, -3.97634536e-01f,
  2.52928883e-02f, -3.60492878e-02f, 1.89083576e-01f, 2.22403519e-02f, 3.73567753e-02f, 1.15147690e-04f, 4.60593067e-02f, -3.31378169e-02f, 4.99309450e-02f, 5.46572953e-02f,
  2.29765978e-02f, 8.58546868e-02f, 7.52374530e-02f, 6.94162846e-02f, -1.17165156e-01f, -1.95595101e-02f, -7.66510367e-02f, -5.64905666e-02f, -2.49968152e-02f, 1.14524662e-01f,
  -5.96219376e-02f, -1.21618137e-01f, -1.58398673e-01f, -3.74696329e-02f, -9.90614742e-02f, -4.40730946e-03f, -5.11086211e-02f, -2.03669846e-01f, -1.41426697e-01f, -2.25419819e-01f,
  7.19714984e-02f, -3.83843994e-03f, -1.98439509e-02f, -1.38032530e-02f, 3.11955735e-02f, 7.00453222e-02f, -9.11268815e-02f, -3.11550274e-02f, 1.89857669e-02f, -4.40390632e-02f,
  -2.71222964e-02f, -2.16633119e-02f, -5.79956919e-02f, 1.94560550e-02f, 2.22879481e-02f, -4.40004431e-02f, -2.95338780e-02f, -3.06494590e-02f, 3.31065170e-02f, -6.70613647e-02f,
  4.39187251e-02f, -7.51641244e-02f, 7.21261604e-03f, -3.70207988e-03f, 3.81034873e-02f, -6.17337637e-02f, 6.27758726e-02f, 4.78100702e-02f, 5.89634292e-02f, 7.38997385e-02f,
  1.48917198e-01f, 1.07379414e-01f, -6.65020123e-02f, -1.92392804e-02f, 7.38848820e-02f, 3.69328409e-02f, -3.36550213e-02f, -1.52775347e-02f, 4.30194587e-02f, -5.15069142e-02f,
  8.85842089e-03f, -2.68796962e-02f, -5.57711571e-02f, 1.11646773e-02f, -9.64434817e-03f, -3.08932029e-02f, 6.71494529e-02f, -2.21338030e-02f, 1.91959068e-02f, -6.63476810e-02f,
  -2.45889509e-03f, -1.73638649e-02f, 2.44357381e-02f, -7.55003318e-02f, 1.32388063e-02f, 1.86076015e-02f, 1.72506180e-02f, 3.86363454e-02f, 7.16844797e-02f, 1.19145222e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.54897946e-01f, -4.06391591e-01f, -2.85118610e-01f, 8.75976402e-03f, -8.75910744e-02f, 4.75029275e-02f, 2.15924680e-02f, 1.32760450e-01f, 9.90027636e-02f, 1.62998142e-04f,
  1.09936786e-03f, 1.08371340e-01f, 8.70391354e-02f, 6.33037388e-02f, 2.25077406e-01f, -1.07744798e-01f, -7.98825771e-02f, -1.29636424e-03f, 2.64804095e-01f, 1.04592927e-01f,
  -4.09706123e-02f, 4.19618413e-02f, 1.28653675e-01f, 9.55617335e-03f, -2.37212270e-01f, 1.38663545e-01f, -1.47781312e-01f, -1.21829875e-01f, -1.71137489e-02f, -3.33583683e-01f,
  -3.51546779e-02f, -1.00510299e-01f, 1.23349153e-01f, 1.00462556e-01f, -6.28912821e-02f, -3.84501293e-02f, -4.77013998e-02f, -4.57104854e-02f, -5.50636128e-02f, -7.11888447e-02f,
  -7.31918365e-02f, -2.07300596e-02f, -2.21583433e-02f, 1.05764512e-02f, -6.84559494e-02f, -3.22124884e-02f, 3.61069366e-02f, -7.80375348e-03f, 1.08050380e-03f, 4.82999049e-02f,
  -1.41571626e-01f, 3.48971710e-02f, -2.19821464e-02f, -7.85874650e-02f, -4.71638776e-02f, -3.99419405e-02f, -5.76125421e-02f, -8.50646291e-03f, 6.69921637e-02f, -1.31889567e-01f,
  -1.59303118e-02f, -4.58771475e-02f, 6.15960695e-02f, -5.09526767e-02f, 1.34351142e-02f, -1.56237483e-02f, -1.63668804e-02f, -4.79145721e-03f, 7.44742304e-02f, -6.09795079e-02f,
  -4.27994058e-02f, 9.37679224e-03f, -9.92090721e-03f, -4.42797355e-02f, -1.94042958e-02f, 9.23642516e-02f, -4.74098921e-02f, 1.24595733e-02f, 4.12744321e-02f, -1.45470062e-02f,
  2.56179553e-02f, 2.98881214e-02f, -2.46480256e-02f, 1.69639494e-02f, -6.29158458e-04f, 6.65372424e-03f, 9.16334912e-02f, 2.45445110e-02f, 3.98836099e-02f, 6.81278706e-02f,
  -4.55808640e-02f, 1.56109408e-01f, 5.05734682e-02f, 8.26718733e-02f, -6.31026030e-02f, -1.14031369e-02f, 2.64097992e-02f, 4.44084629e-02f, 5.87953292e-02f, 2.04897039e-02f,
  2.99760811e-02f, 8.60438347e-02f, -1.11040011e-01f, -1.58087909e-02f, 3.41758952e-02f, 6.09950721e-02f, -8.53171498e-02f, 3.73447835e-02f, 1.09754890e-01f, -3.11203338e-02f,
  4.43312824e-02f, 4.78325002e-02f, 7.43551552e-02f, 3.66774313e-02f, 1.31610306e-02f, 1.45862624e-01f, 2.52462048e-02f, -1.46685779e-01f, 4.20054756e-02f, -4.25461940e-02f,
  -3.69993150e-01f, 7.40965977e-02f, -6.95873871e-02f, -1.47771195e-01f, 7.45381936e-02f, 1.93537131e-01f, 3.40456128e-01f, 1.90968707e-01f, 2.49491706e-02f, -4.05851752e-02f,
  -6.53566569e-02f, -1.19937353e-01f, 7.54437596e-02f, 1.31598696e-01f, 2.01207668e-01f, 1.89340815e-01f, 2.06946775e-01f, 1.38121350e-02f, -6.59391508e-02f, 1.15688317e-01f,
  1.00104019e-01f, -9.51178223e-02f, -2.04833955e-01f, -9.35989693e-02f, 5.70757054e-02f, -9.54792202e-02f, -5.33591658e-02f, -5.23156412e-02f, -1.57925580e-02f, 5.58191016e-02f,
  -6.07369132e-02f, 6.49951622e-02f, -5.36530279e-03f, -1.18691541e-01f, 2.22276226e-02f, -9.11890790e-02f, -3.09427492e-02f, 7.18328217e-03f, -7.51082925e-03f, -7.14795217e-02f,
  -5.95113598e-02f, 5.06523289e-02f, 3.99042070e-02f, 1.53395357e-02f, -9.70959887e-02f, -5.97247519e-02f, -5.06471172e-02f, 5.18750539e-03f, -2.63713039e-02f, 3.92666012e-02f,
  3.55495326e-02f, -3.46522927e-02f, -3.92290279e-02f, 1.01562120e-01f, 1.41317472e-01f, -6.52241781e-02f, -2.80553550e-02f, -6.79164426e-03f, 6.69327974e-02f, -6.92746788e-02f,
  -4.12539318e-02f, -3.15412544e-02f, 5.96716208e-03f, 6.41331496e-03f, -5.10744713e-02f, 3.59715521e-02f, 6.34099096e-02f, 3.94061878e-02f, 2.27857158e-02f, 1.92220695e-02f,
  -4.02863547e-02f, -2.58637145e-02f, 3.90833057e-02f, -9.63122919e-02f, 3.47551964e-02f, -3.39234397e-02f, 6.11846074e-02f, 2.30172998e-03f, 6.54132338e-03f, -5.57888113e-02f,
  5.99810407e-02f, 6.61762953e-02f, -6.95637614e-02f, 1.03794485e-01f, -4.38902453e-02f, 8.90977532e-02f, -1.11104354e-01f, -1.80548877e-02f, -6.10800833e-03f, -7.37622306e-02f,
  -1.69158354e-01f, 1.91787362e-01f, -5.74304610e-02f, -4.52967966e-03f, -4.52335440e-02f, -7.75379911e-02f, -3.50201093e-02f, -1.90107394e-02f, -9.30325221e-03f, 2.73975004e-02f,
  -5.09072915e-02f, 6.32426888e-02f, 8.38799868e-03f, 3.28317285e-02f, -1.24059031e-02f, -8.55475105e-03f, 7.31175244e-02f, -4.17588949e-02f, 1.31053910e-01f, -9.27716941e-02f,
  4.55804244e-02f, -1.34326527e-02f, 1.54244369e-02f, 8.23123846e-03f, -3.89984017e-03f, -8.49887431e-02f, 3.04504838e-02f, -1.45795971e-01f, 2.30861641e-02f, -1.73148349e-01f,
  -5.41391782e-02f, -1.80246875e-01f, -7.65683874e-02f, 7.19606355e-02f, -1.18624613e-01f, -2.82194465e-02f, -4.67612743e-02f, -6.03922233e-02f, 9.08175483e-03f, -5.24497367e-02f,
  -4.59755883e-02f, -9.51519907e-02f, 2.14531459e-02f, 1.09839223e-01f, 7.19511807e-02f, 1.12254582e-01f, 1.33919612e-01f, 1.48585945e-01f, 1.98059455e-01f, -3.59550677e-02f,
  4.45748307e-02f, 1.62923649e-01f, 6.46932200e-02f, 1.87954053e-01f, 1.05915129e-01f, 1.47094697e-01f, 5.80569878e-02f, 5.98147549e-02f, 7.39968047e-02f, 1.16424058e-02f,
  -2.44521067e-01f, -1.20938182e-01f, 1.13866046e-01f, 4.60317656e-02f, -9.13298577e-02f, -2.87800301e-02f, -7.64622614e-02f, 4.49729571e-03f, -4.08918820e-02f, -1.19173778e-02f,
  -3.63890780e-03f, 3.05565423e-03f, -1.52577786e-03f, 3.83424424e-02f, -6.60342947e-02f, -2.30040997e-02f, 1.04388475e-01f, 1.38956711e-01f, 2.46818922e-03f, -4.64389436e-02f,
  -7.95042515e-02f, -1.43137202e-01f, -1.90461934e-01f, 1.94203928e-02f, -8.46550912e-02f, 3.48311514e-02f, -1.01746157e-01f, -1.26143873e-01f, -7.26338550e-02f, -1.21639952e-01f,
  -3.30880210e-02f, 3.76146175e-02f, -2.90436614e-02f, -7.40566477e-02f, -6.54071346e-02f, 2.61023007e-02f, -3.54294712e-03f, -1.25603462e-02f, 1.00657254e-01f, -5.93510233e-02f,
  3.83727476e-02f, 1.63235087e-02f, 9.32362601e-02f, 6.42489567e-02f, -2.03908999e-02f, -6.57728836e-02f, 9.37027931e-02f, -6.88575208e-02f, 1.46245971e-01f, 6.09724633e-02f,
  -8.80417973e-02f, 8.13864991e-02f, 6.86275810e-02f, 1.74947549e-03f, -5.37980720e-02f, -1.27947889e-03f, -2.45702192e-02f, -5.35941236e-02f, -1.25052524e-03f, 3.70597839e-02f,
  -1.00899950e-01f, 3.44938524e-02f, 3.97841521e-02f, -2.88399290e-02f, 1.53510980e-02f, 2.77867001e-02f, -7.96917528e-02f, 2.91053839e-02f, -4.28264961e-02f, 1.92185026e-02f,
  -1.46374449e-01f, 5.11711538e-02f, -4.27957922e-02f, 3.40230316e-02f, -2.40156148e-02f, -3.69655341e-02f, -1.48261324e-01f, -3.33885849e-02f, -3.54725458e-02f, 1.39089897e-02f,
  -9.94194001e-02f, 2.71262396e-02f, -6.88583776e-02f, -1.26655534e-01f, -1.08610973e-01f, -9.55611914e-02f, -1.19299896e-01f, -7.21388012e-02f, -2.84828283e-02f, -2.59384252e-02f,
  -3.17340605e-02f, -4.64993790e-02f, -5.84112331e-02f, 7.79827237e-02f, 1.49190417e-02f, 3.29234935e-02f, -1.58114657e-01f, -1.36969075e-01f, 1.01713255e-01f, 1.98086910e-02f,
  -3.28328907e-02f, 5.47155626e-02f, -5.40500693e-02f, 9.85207930e-02f, -1.25136152e-01f, -1.07009940e-01f, -4.53721993e-02f, -2.51449849e-02f, -4.77341786e-02f, 7.38212466e-02f,
  2.41041500e-02f, 2.90983710e-02f, 6.98699579e-02f, 1.07724100e-01f, -4.90000732e-02f, 8.22166800e-02f, -4.44189720e-02f, -2.41567008e-02f, 1.04246922e-01f, 1.35346442e-01f,
  -1.31092831e-01f, -7.61652738e-02f, -3.57131064e-02f, 3.01291682e-02f, 6.65573627e-02f, -8.88382643e-02f, 4.43214513e-02f, -1.50055941e-02f, -1.08714528e-01f, -9.98675972e-02f,
  8.47490691e-03f, 5.76802678e-02f, 2.09076051e-02f, -2.00084951e-02f, 2.50918344e-02f, -4.83835936e-02f, -1.04357274e-02f, -3.61648910e-02f, -1.01550996e-01f, 9.72113200e-03f,
  1.71165902e-03f, 1.31985992e-02f, 4.63160919e-03f, -8.25005472e-02f, 2.11911905e-03f, -6.35895925e-03f, -1.20608129e-01f, -8.68405476e-02f, -6.04982786e-02f, -7.27895051e-02f,
  5.85928485e-02f, 7.01238587e-02f, -3.08602992e-02f, 2.31352188e-02f, 7.05590025e-02f, -2.23923977e-02f, -1.53614860e-02f, 1.07009999e-01f, -4.29870971e-02f, -4.70457859e-02f,
  -3.86375450e-02f, 5.37263714e-02f, -2.72252299e-02f, -9.35077965e-02f, 9.62713659e-02f, 6.47901818e-02f, 4.42459136e-02f, -3.32954116e-02f, 5.51180318e-02f, -6.58839270e-02f,
  -3.94027587e-03f, 2.29535326e-02f, -5.80673516e-02f, 3.20930071e-02f, 4.09344174e-02f, 6.17756248e-02f, 4.17023152e-02f, -3.54595706e-02f, 8.00609682e-03f, -1.57894511e-02f,
  -1.22586694e-02f, -4.92768642e-03f, -7.83383176e-02f, -5.58918715e-02f, 6.92458898e-02f, -6.50721863e-02f, 1.45268943e-02f, 4.00881357e-02f, -2.25312859e-02f, 5.62387630e-02f,
  -2.85600945e-02f, 7.09277950e-03f, -1.53462670e-03f, 4.85452041e-02f, 3.21509577e-02f, 2.19002878e-03f, -3.57174426e-02f, 1.27118062e-02f, 8.60327184e-02f, -7.31679946e-02f,
  4.02968414e-02f, 4.88502011e-02f, 3.21242213e-02f, -6.72004744e-02f, -2.16705948e-02f, 7.01868348e-03f, 4.46706116e-02f, -5.06278165e-02f, -1.09771624e-01f, -7.14790970e-02f,
  -1.66504234e-01f, -6.87796995e-02f, -4.53978442e-02f, -2.48500321e-04f, 8.51003453e-02f, 6.40272424e-02f, 8.75978321e-02f, -7.39082787e-03f, 2.10361974e-03f, -3.67664136e-02f,
  1.23854533e-01f, -3.74339968e-02f, 8.05778429e-02f, -5.78258857e-02f, 8.35601836e-02f, -2.07332596e-02f, 8.93356726e-02f, 1.77517328e-02f, -1.00307483e-02f, 5.59138022e-02f,
  1.06452890e-01f, -3.52838822e-02f, -1.48557335e-01f, -2.04367414e-02f, -9.25579593e-02f, -1.22711904e-01f, -4.63217050e-02f, -9.18093026e-02f, 1.04658790e-01f, -4.69708294e-02f,
  7.57822916e-02f, 2.23773438e-02f, 4.41596918e-02f, 5.07675111e-02f, -4.79299901e-03f, -7.02191591e-02f, 1.22377388e-01f, 2.42105946e-02f, 3.59932473e-03f, 1.13623753e-01f,
  7.74864629e-02f, 5.10850139e-02f, -1.26437647e-02f, -4.05565649e-02f, 3.49022932e-02f, -3.23980078e-02f, -2.70509132e-04f, -1.09443218e-01f, 5.08866683e-02f, -6.75700977e-02f,
  -4.38161008e-03f, -1.57340318e-02f, -5.42308316e-02f, 7.29445461e-03f, -2.95368191e-02f, 6.97116479e-02f, 1.66960787e-02f, 7.79306218e-02f, -5.41961193e-02f, 2.86411177e-02f,
  -6.28729835e-02f, -6.37061298e-02f, 6.54856339e-02f, 3.39703113e-02f, -5.48269711e-02f, 9.01246741e-02f, 3.54598425e-02f, -9.07513425e-02f, -5.37261516e-02f, -1.28488436e-01f,
  4.89880890e-02f, -1.27066607e-02f, -9.13049281e-02f, -3.99254635e-03f, -1.94394868e-02f, -4.89167236e-02f, 5.70703633e-02f, -8.60580131e-02f, 2.79303454e-02f, 1.12174749e-01f,
  -3.80824567e-05f, -2.10276642e-03f, -5.87299131e-02f, -2.25734431e-02f, -3.48356403e-02f, 5.04725613e-02f, 1.14786318e-02f, 5.87930866e-02f, -7.59009421e-02f, 3.45298946e-02f,
  -8.16781893e-02f, 9.35043991e-02f, -4.44250740e-03f, -2.26511899e-02f, -4.06988896e-02f, -8.62674117e-02f, -9.09263641e-02f, -4.80053201e-02f, 4.32987921e-02f, -4.47191186e-02f,
  -7.66812172e-03f, 5.52917123e-02f, 8.28708559e-02f, -1.31728854e-02f, 5.02166674e-02f, -4.69901487e-02f, -2.70193117e-03f, -1.51396461e-03f, 1.81247015e-02f, 4.74184006e-02f,
  -9.90195107e-03f, -2.81559187e-04f, -8.38334486e-02f, -5.54578342e-02f, 4.79548573e-02f, -9.20353606e-02f, 7.12281615e-02f, 4.76218853e-03f, -6.76522478e-02f, -5.56942075e-02f,
  -3.29260111e-01f, -7.88959563e-02f, -1.04107074e-01f, -1.66063532e-01f, -6.32083043e-02f, 4.67351936e-02f, -4.77940366e-02f, 3.41481864e-02f, 3.36109139e-02f, -1.34065971e-01f,
  -4.97982986e-02f, -5.30217476e-02f, -7.30684176e-02f, 5.14597725e-03f, -3.85440923e-02f, -1.28542691e-01f, -1.25394151e-01f, -1.80578336e-01f, -1.58542156e-01f, 5.62309176e-02f,
  -7.21592307e-02f, -2.30782449e-01f, -2.05134541e-01f, -1.65730283e-01f, 2.45331787e-02f, -1.82060823e-01f, -9.77152437e-02f, -1.67985827e-01f, 3.14631090e-02f, -1.94332987e-01f,
  -1.04110604e-02f, -3.35845165e-02f, -1.36051830e-02f, -5.57970703e-02f, -6.80566358e-04f, 4.98490371e-02f, -9.00903046e-02f, -1.88516770e-02f, -1.12635335e-02f, -8.80907252e-02f,
  -1.97315719e-02f, -3.16531025e-02f, 3.15659791e-02f, 8.32931399e-02f, -2.21996997e-02f, 3.78858764e-03f, 3.32144089e-02f, 6.13496602e-02f, 1.38964979e-02f, 1.67276576e-01f,
  1.49219781e-01f, -8.38492066e-03f, 4.98064384e-02f, 1.40378088e-01f, 9.17013958e-02f, -2.52407584e-02f, 1.07786924e-01f, 1.66970015e-01f, 6.00086115e-02f, 1.10909134e-01f,
  -5.51487356e-02f, 7.67263351e-03f, 8.22842494e-03f, -7.55266994e-02f, -1.52314985e-02f, -3.71258482e-02f, -1.06399097e-02f, 2.41865590e-02f, -1.86541962e-04f, -6.04070760e-02f,
  -1.73474308e-02f, 2.05286406e-02f, 1.24173304e-02f, -5.99296167e-02f, -3.10813598e-02f, -7.01616779e-02f, -1.17483519e-01f, 5.75224496e-02f, 3.71703841e-02f, 9.14907083e-03f,
  -3.45766370e-04f, -1.89119801e-02f, 8.95642489e-02f, 3.00447247e-03f, 5.06917126e-02f, 2.06280425e-02f, 6.77973330e-02f, -2.00558007e-02f, 4.54348400e-02f, 5.79643063e-03f,
  -1.55146554e-01f, -7.25236535e-03f, -5.24617732e-03f, -1.78890489e-02f, 2.16293745e-02f, -2.79524475e-02f, -8.44300631e-03f, 5.88086322e-02f, 1.55635588e-02f, 7.56939128e-02f,
  1.12215932e-02f, 2.31360327e-02f, -5.22643439e-02f, 1.87344439e-02f, -1.48452166e-03f, -1.79804359e-02f, -4.39093821e-02f, 2.57689301e-02f, 1.95671674e-02f, -2.12381240e-02f,
  1.01225495e-01f, 7.89802670e-02f, 3.57972085e-02f, 3.65662314e-02f, 6.42821789e-02f, -5.73123433e-02f, 1.03388190e-01f, 5.97728752e-02f, -5.23711219e-02f, -8.08419939e-03f,
  6.46111429e-01f, -4.37241495e-01f, 3.35514396e-01f, 1.37396023e-01f, 2.60137200e-01f, 3.34910929e-01f, 3.22610557e-01f, 3.87247205e-02f, -4.32133907e-03f, 9.16025788e-02f,
  3.63877378e-02f, -1.22100651e-01f, -7.07695484e-02f, -1.28320590e-01f, 5.23749292e-02f, -1.63864698e-02f, -4.80404645e-02f, 1.72446191e-01f, 2.05173686e-01f, 1.31251901e-01f,
  -1.68769687e-01f, -6.72608912e-02f, 1.54684931e-02f, 4.51580249e-02f, -1.27990529e-01f, 7.90123194e-02f, -1.12605244e-01f, -1.20728783e-01f, -5.43856397e-02f, -2.97975034e-01f,
  1.05364956e-01f, -4.26503830e-02f, 1.30867392e-01f, -2.77434494e-02f, 3.51373479e-03f, 7.74566755e-02f, 1.57042742e-02f, -9.80143920e-02f, 2.28558835e-02f, -6.02186397e-02f,
  7.92849362e-02f, -3.16031165e-02f, -4.79078665e-02f, -9.45722014e-02f, 6.08060788e-03f, 3.86990011e-02f, -1.29017368e-01f, 2.25000127e-04f, 1.75742507e-02f, -1.05988914e-02f,
  -1.69354618e-01f, 1.63195562e-02f, 1.37345970e-01f, 1.27387106e-01f, 2.34987691e-01f, 6.06911778e-02f, -1.14774339e-01f, -1.10417968e-02f, 8.45392123e-02f, -6.01514243e-02f,
  -3.49746868e-02f, 6.14826456e-02f, 7.43300468e-02f, -4.04117033e-02f, -2.81732753e-02f, 1.79026984e-02f, -1.00461617e-02f, 2.27118842e-02f, 5.24530886e-03f, -2.61556953e-02f,
  -6.60295486e-02f, 1.02204233e-01f, 2.07931791e-02f, 6.54217228e-02f, -5.42721674e-02f, -3.26277986e-02f, 1.18098088e-01f, -9.36719775e-02f, 1.29578626e-02f, 2.75571924e-02f,
  -7.12356493e-02f, 8.52047652e-02f, 4.14865166e-02f, -9.22642648e-02f, 6.60793157e-03f, 1.29008386e-03f, -3.60367745e-02f, -7.28410929e-02f, -7.39258453e-02f, 1.82668548e-02f,
  -2.24373564e-01f, 1.96222544e-01f, 3.32340114e-02f, -7.42452145e-02f, -7.14134276e-02f, -4.78513017e-02f, 1.27603812e-02f, -1.91825870e-02f, -6.35744333e-02f, -1.33805582e-03f,
  1.89877413e-02f, -1.06730578e-04f, 1.27590913e-02f, -4.23799865e-02f, 8.26555938e-02f, 2.62257382e-02f, -1.13386385e-01f, 2.63339020e-02f, 5.06517850e-02f, -3.26511189e-02f,
  -7.77275115e-03f, 1.32456154e-01f, 2.55851597e-02f, -1.58564486e-02f, 7.89282098e-02f, 1.47792399e-01f, -9.21874046e-02f, -8.57463665e-03f, 5.59284464e-02f, -5.18822931e-02f,
  -5.29641658e-03f, -6.28105029e-02f, 2.02767596e-01f, -5.61748259e-02f, -1.00946158e-01f, 5.84028065e-02f, 1.04366012e-01f, 1.14707701e-01f, -7.14282086e-03f, -3.42082605e-02f,
  3.24477106e-02f, 4.07229327e-02f, 6.00053705e-02f, 1.31843939e-01f, 1.32555902e-01f, 1.57314450e-01f, 1.12293944e-01f, 1.87906668e-01f, 1.34945840e-01f, 2.92640217e-02f,
  5.78950532e-02f, -3.11181741e-03f, 1.09363221e-01f, 4.59561124e-02f, 7.55287260e-02f, 2.46890597e-02f, 2.08587069e-02f, 1.09962255e-01f, 2.29690876e-02f, 1.24343792e-02f,
  -8.12471360e-02f, -1.04112901e-01f, 7.18207210e-02f, -2.92322729e-02f, -8.16835985e-02f, -1.53749604e-02f, -5.21524251e-02f, -3.21726464e-02f, -6.19508922e-02f, 2.89253499e-02f,
  -1.13089405e-01f, -2.71113333e-03f, -8.79801437e-02f, -4.10968103e-02f, -7.01725483e-02f, 6.67507155e-03f, 9.45745260e-02f, 1.12966686e-01f, -7.40776304e-03f, -8.13152920e-03f,
  -7.46522471e-02f, -9.35272574e-02f, 2.42640879e-02f, 6.58456609e-02f, 2.28544511e-02f, -4.31653112e-03f, -1.01615764e-01f, 6.90097287e-02f, 8.64669532e-02f, -6.50456990e-04f,
  1.01217240e-01f, 8.94286409e-02f, 2.16472615e-02f, 3.78390104e-02f, 3.48936650e-03f, 3.55692953e-02f, -4.17890288e-02f, 2.02020612e-02f, 6.45432062e-03f, 7.47917071e-02f,
  3.29371542e-02f, -2.53092516e-02f, 5.98694235e-02f, 9.21015162e-03f, 6.01548553e-02f, 4.03202418e-03f, -3.86371911e-02f, 6.51667193e-02f, -6.11242801e-02f, 3.51322331e-02f,
  9.50939432e-02f, -2.91625708e-02f, -4.11071368e-02f, -1.48143023e-02f, 7.20129311e-02f, -1.45109033e-03f, 2.75198137e-03f, -1.87730771e-02f, -4.88226376e-02f, -6.92277104e-02f,
  -1.64051190e-01f, -1.92964375e-02f, -4.15665992e-02f, 1.01186581e-01f, 1.95583161e-02f, -7.53517300e-02f, 4.03166115e-02f, 1.41380835e-04f, -7.02956542e-02f, 3.66909243e-02f,
  4.30439301e-02f, -2.11146027e-02f, -8.29785392e-02f, 4.21810448e-02f, 3.77072021e-02f, 1.50229391e-02f, -8.11748654e-02f, -6.45400509e-02f, -5.50272241e-02f, -2.81664245e-02f,
  2.52663158e-02f, -1.08276673e-01f, -5.68586402e-02f, -1.44259576e-02f, -5.55937253e-02f, -4.27534431e-03f, -2.36089751e-02f, -1.20276086e-01f, -5.16759567e-02f, -9.92621016e-03f,
  1.88639894e-01f, -2.10281208e-01f, 1.14885736e-02f, 2.05436647e-02f, 1.19618267e-01f, 1.64584503e-01f, 1.31436810e-02f, 6.46264032e-02f, -7.92044327e-02f, -8.34007412e-02f,
  -7.47419670e-02f, -2.39338413e-01f, -2.15568423e-01f, -2.08616704e-01f, 2.42946837e-02f, -7.10187200e-03f, 1.11954227e-01f, 9.72695202e-02f, 7.44060427e-02f, -5.97609431e-02f,
  -8.71357601e-03f, 1.70137156e-02f, -5.59185408e-02f, 2.08336338e-02f, -1.42365068e-01f, -2.71435082e-02f, 5.11587830e-03f, 6.91813827e-02f, -4.39354777e-02f, -2.67633926e-02f,
  2.79947650e-02f, -2.13134242e-03f, -6.19785823e-02f, -7.60891214e-02f, 4.71223742e-02f, 9.96529590e-03f, 3.18393968e-02f, 2.46831938e-03f, -1.00124143e-01f, -3.40123549e-02f,
  4.41895127e-02f, -2.93054301e-02f, -7.03246295e-02f, 6.05952553e-02f, 1.24595158e-01f, -7.40820616e-02f, -5.20070791e-02f, -3.32474988e-03f, -6.90909801e-03f, 8.90719425e-03f,
  -1.00526802e-01f, 7.75295794e-02f, 2.39399131e-02f, 7.10114539e-02f, 7.51180127e-02f, 3.29837985e-02f, -4.37997431e-02f, -1.76900979e-02f, 3.74292247e-02f, -1.66004136e-01f,
  4.95169945e-02f, 2.94002313e-02f, -3.30091603e-02f, 9.09514725e-03f, 2.41950750e-02f, 4.20340002e-02f, -3.86841372e-02f, -4.26331349e-02f, 3.83647345e-02f, -1.90040320e-02f,
  1.73932444e-02f, -1.92637164e-02f, 3.79375592e-02f, -3.27178203e-02f, -6.76812977e-02f, 1.58414823e-05f, -5.96443154e-02f, -4.05359641e-02f, 3.64788100e-02f, 5.92767522e-02f,
  4.20036651e-02f, 4.77205813e-02f, 3.42114866e-02f, -9.83714126e-03f, -2.39722952e-02f, 6.31500036e-02f, 2.92087849e-02f, 6.90664873e-02f, -4.36130865e-03f, 1.60140395e-01f,
  -1.01737520e-02f, 1.66786373e-01f, -3.49726826e-02f, -2.30396334e-02f, 7.31331110e-02f, 1.47368163e-02f, 2.67356243e-02f, -5.78079484e-02f, -2.65792999e-02f, 9.03775394e-02f,
  -6.05649725e-02f, 7.60671683e-03f, 4.17047646e-03f, 4.76075895e-03f, 2.84948456e-03f, -2.51934654e-03f, 2.99697854e-02f, 4.15272685e-03f, 1.03565499e-01f, -3.24076712e-02f,
  3.26233506e-02f, 3.91567871e-02f, 1.46139711e-01f, 1.05511971e-01f, -3.52695845e-02f, 9.48835388e-02f, 1.15070902e-01f, 2.25942396e-02f, 9.72098485e-02f, 1.02275684e-02f,
  1.97208747e-02f, 1.13824651e-01f, 3.43677439e-02f, -4.44132686e-02f, 1.35672420e-01f, 1.27709478e-01f, 1.00475818e-01f, 5.13695329e-02f, -1.16848890e-02f, 8.65958929e-02f,
  1.71195522e-01f, 1.17129058e-01f, 8.00820366e-02f, 1.11067206e-01f, 5.38199656e-02f, 8.99633840e-02f, 1.23766653e-01f, 5.49959838e-02f, 8.98142532e-02f, -1.64767541e-02f,
  2.92635169e-02f, 3.31437252e-02f, -7.36505911e-02f, -1.83169078e-02f, 1.23804249e-01f, 1.18001783e-02f, 4.85202782e-02f, -9.76482034e-03f, -2.40428261e-02f, -4.36281785e-02f,
  5.56918269e-04f, 1.64244361e-02f, -3.54983360e-02f, 5.23655303e-03f, 4.24580909e-02f, 2.14371383e-02f, -5.62826172e-02f, -6.59852922e-02f, -3.11303604e-02f, 5.92367128e-02f,
  5.61882816e-02f, -2.60419883e-02f, -1.12098670e-02f, 4.69897427e-02f, -4.66817431e-02f, -3.59968431e-02f, -3.97669710e-02f, 5.06412350e-02f, 1.35120809e-01f, 3.56413238e-02f,
  2.52378676e-02f, -1.53874848e-02f, 4.74980101e-02f, 8.85915309e-02f, 1.15560181e-01f, 9.04217884e-02f, 2.74802912e-02f, -5.26019745e-02f, -1.86534822e-02f, 5.90351224e-02f,
  -2.25534383e-02f, 6.34243786e-02f, -1.73390768e-02f, 4.26678620e-02f, 1.47087378e-02f, 1.67140029e-02f, -5.15716225e-02f, -8.14428255e-02f, -4.29275446e-02f, -3.68383192e-02f,
  6.09798878e-02f, 7.56788999e-02f, 8.35515261e-02f, -3.85434702e-02f, -2.31445991e-02f, 5.33643067e-02f, 3.86990793e-02f, -8.01292732e-02f, -4.35318723e-02f, -2.80231442e-02f,
  9.06378310e-03f, 5.38665466e-02f, 8.02841485e-02f, 7.38352910e-02f, 6.70884773e-02f, 2.30063070e-02f, 3.86562943e-02f, 7.57112876e-02f, -2.43238751e-02f, 2.52147354e-02f,
  1.24207310e-01f, 1.86687708e-02f, -1.05766216e-02f, -9.08269584e-02f, -4.73947002e-04f, -1.31618045e-02f, 6.79514632e-02f, -4.82075624e-02f, -2.46445239e-02f, -4.46440466e-03f,
  2.91470438e-02f, -6.04623705e-02f, 3.73424068e-02f, -4.42528464e-02f, 2.68528573e-02f, -1.01864025e-01f, 2.62827682e-03f, 8.18469599e-02f, -3.95873338e-02f, 4.38769609e-02f,
  5.80353290e-02f, -3.88841331e-02f, -4.44958173e-02f, 6.89486340e-02f, 6.38077930e-02f, 4.54086736e-02f, 6.24776669e-02f, -5.89285456e-02f, 6.58793896e-02f, 5.00985757e-02f,
  2.30827108e-01f, -1.87328786e-01f, -2.70657539e-01f, 2.45079789e-02f, -1.33273721e-01f, -7.18883350e-02f, -1.32300034e-01f, -1.72864661e-01f, -6.64810017e-02f, -1.36360049e-01f,
  -1.64439529e-01f, -6.94845570e-03f, -1.01789623e-01f, -7.49979913e-03f, 1.68058723e-02f, -2.61465777e-02f, -3.41072306e-02f, -5.31866262e-03f, -1.32352382e-01f, -2.00274050e-01f,
  -1.50070831e-01f, 2.75267549e-02f, 7.21546263e-02f, -1.17168635e-01f, -2.54819989e-01f, -1.38130784e-01f, -1.65786579e-01f, -1.27953529e-01f, -1.80643797e-01f, -2.13629708e-01f,
  -1.02727450e-01f, -1.12968251e-01f, 2.76698470e-02f, -4.19087559e-02f, -2.39443723e-02f, 2.12105690e-04f, -7.62303397e-02f, 5.87791093e-02f, 8.66695270e-02f, -2.12870520e-02f,
  5.42739891e-02f, 1.75358690e-02f, 1.52588546e-01f, 6.42306963e-03f, -1.51754646e-02f, -8.02726001e-02f, -7.91869767e-04f, 2.14420948e-02f, -4.56635654e-03f, -7.93067887e-02f,
  5.80680743e-02f, -6.05901480e-02f, 5.89067340e-02f, 4.45261635e-02f, -8.96802098e-02f, -1.99855641e-02f, -7.35449344e-02f, -6.74712434e-02f, 3.70697901e-02f, -8.09686705e-02f,
  -1.03414096e-01f, 1.26968890e-01f, -3.86808440e-02f, 3.16545255e-02f, 4.76733409e-02f, 3.20476890e-02f, 4.58703488e-02f, 3.30285430e-02f, 2.74613616e-03f, -3.79310697e-02f,
  2.44887080e-02f, -2.29692040e-03f, -1.08581148e-02f, -7.33175874e-02f, 4.21961769e-02f, -1.08389035e-02f, 2.75970623e-02f, 1.03009038e-01f, 5.87060302e-02f, 1.09982416e-01f,
  -2.03801244e-02f, -7.80752748e-02f, 3.64548936e-02f, -2.15333607e-02f, -3.63801941e-02f, -7.62964636e-02f, -3.58520001e-02f, 7.26613123e-03f, 1.84473842e-02f, 5.20191900e-03f,
  8.59222487e-02f, -5.50245494e-02f, -3.76601927e-02f, -2.39919815e-02f, 9.01676565e-02f, 1.47781624e-02f, 1.94640588e-02f, -6.80319872e-03f, 6.58489168e-02f, -2.79324073e-02f,
  1.82000156e-02f, 5.57574518e-02f, 1.37233555e-01f, -1.78926550e-02f, -8.67456645e-02f, -4.82912883e-02f, -5.23558334e-02f, 5.40736914e-02f, 3.79231051e-02f, 1.57118328e-02f,
  3.93130332e-02f, 8.60918686e-03f, 1.27803192e-01f, -4.02687415e-02f, -1.87189013e-04f, 1.02785289e-01f, -6.27273275e-03f, -6.11275760e-03f, 1.54752359e-01f, 5.12578450e-02f,
  7.67299682e-02f, -6.41658157e-02f, -5.86241968e-02f, 2.20517386e-02f, 5.72679844e-03f, -9.64871868e-02f, -8.72018263e-02f, -4.55795079e-02f, 1.15450464e-01f, 7.44287446e-02f,
  1.23288862e-01f, 1.28799349e-01f, 7.14497268e-02f, -1.66476574e-02f, 8.49476736e-03f, -5.31030260e-02f, -3.40502858e-02f, -1.67609714e-02f, 7.46254623e-02f, -4.39177863e-02f,
  -9.29938164e-03f, 6.98308125e-02f, 4.89274859e-02f, -4.39474592e-04f, -2.56183986e-02f, 1.10152543e-01f, 6.16357401e-02f, -3.05110868e-03f, -4.56130169e-02f, -2.59528272e-02f,
  2.88516283e-02f, 1.22323204e-02f, -3.44239734e-02f, 4.32383083e-02f, 8.27631354e-03f, -1.06342703e-01f, -3.03637832e-02f, 2.46767849e-02f, 1.52669158e-02f, -5.31211682e-02f,
  5.19040227e-02f, 6.66255653e-02f, -2.30823513e-02f, -3.07111777e-02f, -2.19007842e-02f, -1.64992816e-03f, -1.26350196e-02f, 3.47473323e-02f, -1.12740353e-01f, -2.54406556e-02f,
  -6.12691343e-02f, 3.55586484e-02f, 1.49939228e-02f, -6.78935051e-02f, -3.96298617e-02f, 4.20050211e-02f, -5.75322509e-02f, -1.22532636e-01f, 2.32038703e-02f, 5.84526397e-02f,
  -5.40816858e-02f, -2.51414292e-02f, 3.24222073e-02f, 1.35230701e-02f, 7.82502964e-02f, -3.84680107e-02f, 2.35874709e-02f, 4.26162919e-03f, -6.23157136e-02f, 3.73609699e-02f,
  8.95507559e-02f, 2.94180382e-02f, 1.22109056e-02f, -8.06902200e-02f, -1.13083953e-02f, 4.17375937e-02f, 4.06160057e-02f, 2.50652991e-02f, 7.30068758e-02f, 3.65084969e-02f,
  7.51450583e-02f, -7.42309466e-02f, 5.04551120e-02f, 2.65353452e-03f, -5.29267676e-02f, 8.07261020e-02f, 6.60293251e-02f, 1.06302187e-01f, -5.00187604e-03f, -6.30193204e-03f,
  6.51227608e-02f, -8.39537289e-03f, 4.30193394e-02f, -8.91401246e-02f, -2.56044623e-02f, 7.19130337e-02f, 9.23806801e-02f, 2.73913499e-02f, 3.72286444e-03f, 8.69644210e-02f,
  2.84599066e-02f, -4.32748422e-02f, 1.83666125e-02f, -9.90709811e-02f, -1.05337994e-02f, -3.46126850e-03f, -3.15835290e-02f, 7.08522368e-03f, 7.53756538e-02f, 3.98505777e-02f,
  3.12334578e-02f, -2.57337205e-02f, -3.17763984e-02f, -2.37980182e-03f, -1.18453242e-02f, 2.68810187e-02f, -9.71669182e-02f, -7.50985965e-02f, 2.46874914e-02f, 1.05049774e-01f,
  -3.35269094e-01f, -1.62606344e-01f, -2.07868189e-01f, -8.79838616e-02f, 2.72476107e-01f, -1.15333483e-01f, -1.61371559e-01f, -2.07830667e-01f, 7.17000812e-02f, -6.26013279e-02f,
  -1.34774726e-02f, 1.46689206e-01f, 2.74524763e-02f, 9.42382142e-02f, -1.66452035e-01f, -5.38538545e-02f, 6.84355292e-03f, 1.51807712e-02f, -1.03472784e-01f, 2.90488470e-02f,
  2.25059792e-01f, 1.04064802e-02f, -1.76382601e-01f, -3.10010500e-02f, 6.61408305e-02f, 9.11664069e-02f, 2.46241651e-02f, -8.55495967e-03f, 4.37175184e-02f, 1.49265438e-01f,
  -7.32102664e-03f, -1.50285274e-01f, 1.26831010e-01f, 1.07620195e-01f, 4.93877530e-02f, -1.68090744e-03f, -5.38035668e-02f, 4.53649536e-02f, 7.12758973e-02f, -3.16750184e-02f,
  4.89175729e-02f, 2.23057643e-02f, 1.17767900e-02f, -6.27640681e-03f, -8.63624513e-02f, 2.65241060e-02f, -6.75975978e-02f, -6.48358986e-02f, -7.69692659e-02f, -1.14325538e-01f,
  1.30785823e-01f, 3.00328601e-02f, -1.60229519e-01f, -6.58334941e-02f, -1.36153847e-01f, -2.67556738e-02f, -9.80093852e-02f, -4.31560837e-02f, -7.72078559e-02f, -6.72872066e-02f,
  -3.33583094e-02f, 6.72306269e-02f, -5.81370667e-02f, 1.55266365e-02f, -9.61066224e-03f, 1.80824436e-02f, 6.08676188e-02f, 9.37024131e-03f, -7.53043871e-03f, 1.96687598e-02f,
  1.20708263e-02f, -1.08065590e-01f, -1.16797201e-02f, 5.82951456e-02f, 2.07990631e-02f, 1.52143342e-02f, 2.07970999e-02f, -5.85389547e-02f, 1.83095671e-02f, 5.91070950e-02f,
  -5.14720939e-02f, -5.00749983e-03f, 4.59571276e-03f, 4.53308485e-02f, 9.32846889e-02f, 5.22523001e-02f, 3.20704952e-02f, -1.15781687e-01f, -6.46466538e-02f, -2.03757007e-02f,
  -1.53785750e-01f, 1.08971350e-01f, 2.24773698e-02f, 2.71535870e-02f, 1.25984065e-02f, 5.44823147e-02f, 1.02579324e-02f, 2.63053342e-03f, 3.67503911e-02f, -1.14115149e-01f,
  3.50816622e-02f, -2.65354477e-02f, -6.89840391e-02f, 2.42066476e-02f, -9.19187963e-02f, -5.34471907e-02f, -8.22665691e-02f, -3.91706116e-02f, -2.86577251e-02f, -9.88319796e-03f,
  -1.65578082e-01f, -1.73201188e-01f, -1.93540111e-01f, -1.18307918e-01f, -3.59322727e-02f, -4.35610153e-02f, -1.19095854e-01f, -3.61322686e-02f, -1.49020076e-01f, -2.99606860e-01f,
  -3.57436031e-01f, 1.28755942e-01f, -1.84446976e-01f, 1.56403929e-02f, 2.13611588e-01f, 2.86740717e-03f, 1.28737032e-01f, 5.78232296e-03f, -9.98571664e-02f, -3.51363085e-02f,
  4.78738137e-02f, 7.72035271e-02f, 3.76976631e-03f, 1.23638824e-01f, -1.88449100e-02f, 1.88597962e-01f, 1.37499109e-01f, -7.12755248e-02f, -1.68683082e-01f, 1.88357010e-02f,
  1.64845839e-01f, -1.25031576e-01f, -2.35082820e-01f, -8.40821210e-03f, -4.98688128e-03f, -7.25079998e-02f, -5.73553853e-02f, 4.70059961e-02f, 7.48906285e-02f, 1.64004251e-01f,
  1.20534133e-02f, -9.88537669e-02f, 8.79868343e-02f, -4.32906449e-02f, 1.47442082e-02f, -8.88717128e-04f, -8.17306992e-03f, -5.18729016e-02f, 6.14647791e-02f, 6.00662408e-03f,
  2.91072708e-02f, -7.26952702e-02f, -3.02832983e-02f, 3.93684357e-02f, -3.18383090e-02f, 3.23843397e-02f, -5.42943962e-02f, 3.60191725e-02f, -6.89021498e-02f, 3.55967432e-02f,
  4.75939177e-02f, 6.07321709e-02f, 2.35384740e-02f, 4.04942930e-02f, 1.07576745e-02f, 5.22884279e-02f, -1.26241714e-01f, -9.15906057e-02f, -5.99474134e-03f, -1.12105384e-02f,
  6.98992312e-02f, 8.60421732e-02f, 5.54224811e-02f, 7.10635213e-04f, 2.44109239e-02f, -2.24420875e-02f, 1.66300312e-02f, 5.44515513e-02f, 1.15071870e-01f, -6.41016141e-02f,
  7.65235275e-02f, 1.11007597e-02f, 1.09906513e-02f, -6.49161190e-02f, -3.06323748e-02f, 1.10932114e-02f, 7.56692439e-02f, 8.45335871e-02f, -3.63628641e-02f, 4.26139310e-02f,
  9.16350726e-03f, -6.31586909e-02f, 2.72021513e-03f, 6.81442171e-02f, 2.09942460e-02f, 1.25776660e-02f, 3.55713964e-02f, -4.73760888e-02f, 8.07984397e-02f, 5.77703156e-02f,
  -9.98419076e-02f, 4.92015481e-02f, -3.98527943e-02f, 8.66357330e-03f, 1.53319174e-02f, -8.61244649e-03f, 5.29515967e-02f, -7.45795714e-03f, -6.82607442e-02f, -1.10712297e-01f,
  -6.75868690e-02f, -3.08489949e-02f, -3.20875831e-02f, -6.60071447e-02f, 3.09475604e-03f, -9.89044681e-02f, 3.00473766e-03f, 7.45235160e-02f, 3.46085131e-02f, 9.00356565e-03f,
  5.86962998e-02f, -3.41873504e-02f, -5.08942120e-02f, -1.10153735e-01f, -2.64352784e-02f, 1.67735785e-01f, -1.06989048e-01f, -1.22592650e-01f, -2.13444475e-02f, -4.86412644e-02f,
  -1.41678780e-01f, 1.67962179e-01f, 1.71070918e-02f, -1.36210071e-02f, 1.06460005e-01f, -5.10450862e-02f, -6.18427582e-02f, -1.45870551e-01f, -1.63789317e-01f, 1.82530105e-01f,
  1.98115960e-01f, 7.96393454e-02f, 1.16082840e-02f, 4.24784571e-02f, -2.22226337e-01f, 1.12932958e-01f, -4.54056915e-03f, -1.24428757e-01f, -1.73628673e-01f, -1.68897122e-01f,
  1.13233775e-02f, -8.47991705e-02f, -8.15127566e-02f, -1.43274128e-01f, 1.52046397e-01f, -3.07031404e-02f, -2.81594731e-02f, -2.27002916e-03f, 9.91085079e-03f, 3.61151516e-01f,
  1.64664879e-01f, 7.49537200e-02f, 1.91158541e-02f, 3.37481424e-02f, 1.07574891e-02f, -6.29940554e-02f, 2.93848105e-02f, -5.36117777e-02f, 2.89679933e-02f, 4.62498963e-02f,
  1.02625482e-01f, 7.04465434e-02f, 1.42310068e-01f, -1.21514443e-02f, -5.32745123e-02f, -5.44493422e-02f, -1.09105997e-01f, -1.22291230e-01f, -1.63361147e-01f, 1.07827941e-02f,
  1.01664625e-01f, -1.73231419e-02f, 3.75088565e-02f, -1.63048059e-01f, -1.69501588e-01f, 4.99905366e-03f, -2.37677582e-02f, -1.39234975e-01f, -1.58792406e-01f, -7.85588995e-02f,
  4.25039120e-02f, -4.04642988e-03f, 6.65570125e-02f, 4.34125923e-02f, -2.92811804e-02f, 2.40280349e-02f, -1.59892312e-03f, -4.47408073e-02f, -1.20881293e-02f, -6.78855032e-02f,
  -4.55643311e-02f, 1.50270876e-03f, 1.25123356e-02f, 1.26480944e-02f, -2.25713365e-02f, 1.53257512e-04f, -6.75970614e-02f, -5.56350239e-02f, 3.72018330e-02f, -3.95254269e-02f,
  4.89325821e-02f, 2.69461088e-02f, -1.65430829e-03f, 7.09972112e-03f, 2.68821064e-02f, -5.75729236e-02f, -4.11135182e-02f, -4.36926708e-02f, -2.05685571e-02f, 6.73031881e-02f,
  -5.73072545e-02f, -1.21784145e-02f, -1.42197665e-02f, 4.11560899e-03f, 3.75473686e-02f, -2.13091411e-02f, 8.17171633e-02f, 1.15047321e-02f, 1.01421125e-01f, -9.08182636e-02f,
  -4.12325449e-02f, 1.93793736e-02f, 5.49813733e-02f, 8.45508873e-02f, -1.03694774e-01f, 2.57989019e-02f, 1.69436801e-02f, -1.34367123e-02f, -8.63503590e-02f, -7.16420785e-02f,
  2.75776945e-02f, -1.13554433e-01f, 6.33961521e-03f, -2.69782227e-02f, -6.74918015e-03f, -7.99078420e-02f, -9.75920260e-02f, -8.39303061e-02f, -8.91258344e-02f, -1.69398203e-01f,
  -1.06461607e-02f, -9.52992439e-02f, -2.22019374e-01f, -1.11883648e-01f, 1.98480785e-02f, -5.80183081e-02f, -3.33502442e-02f, 5.08322828e-02f, -3.54933320e-03f, -4.90923859e-02f,
  4.11010012e-02f, 2.33572945e-02f, 2.04144642e-02f, -6.50397837e-02f, 4.20282707e-02f, -2.58502550e-02f, -6.92996755e-02f, -6.98993504e-02f, -1.20690428e-02f, 1.00789465e-01f,
  8.03214498e-03f, -7.05210865e-02f, 7.91549832e-02f, 7.29698166e-02f, -1.47091091e-01f, -5.68387751e-03f, -1.61284685e-01f, -1.19715817e-01f, 6.39287848e-03f, -2.74679929e-01f,
  -3.00980598e-01f, 2.36368142e-02f, -3.70089971e-02f, 1.26047535e-02f, -1.43316239e-01f, 6.29051998e-02f, 7.30088130e-02f, -2.28875671e-02f, -4.82203625e-02f, 2.75693312e-02f,
  -1.19426046e-02f, 1.17811225e-01f, -5.11800647e-02f, -5.20261144e-03f, -8.02552998e-02f, -1.15236696e-02f, -2.26864964e-02f, 6.80375248e-02f, 1.67568643e-02f, -9.85393077e-02f,
  5.38913086e-02f, -9.13831517e-02f, -3.77721637e-02f, -5.47595881e-02f, 3.13175246e-02f, 2.77025010e-02f, -7.93474093e-02f, 3.39945196e-04f, -1.14510104e-01f, -2.15422258e-01f,
  -9.02831778e-02f, -7.37758428e-02f, 1.06362058e-02f, 4.89853835e-03f, -7.32126236e-02f, 3.37477550e-02f, 1.98077336e-02f, 3.94312888e-02f, 4.15033549e-02f, -6.13884553e-02f,
  3.56111140e-03f, -4.88410778e-02f, -1.55155212e-02f, 1.79378558e-02f, 5.33608161e-02f, -2.62856930e-02f, -5.57701550e-02f, -1.22652926e-01f, -1.05302304e-01f, -1.77845475e-03f,
  1.87951867e-02f, -2.72566043e-02f, -7.52999261e-02f, 2.29625646e-02f, 9.50668380e-02f, 1.83112640e-02f, -3.27686146e-02f, 9.01545922e-04f, -6.90571219e-03f, -6.48757862e-03f,
  -2.31315754e-02f, 1.46765947e-01f, -1.23899125e-01f, 6.88969865e-02f, -4.90351766e-02f, -1.66867711e-02f, 1.44812511e-02f, 6.74322024e-02f, -4.66224998e-02f, -6.61152229e-02f,
  -8.11815709e-02f, -1.11416593e-01f, -4.65855636e-02f, 3.19717289e-03f, 3.25635299e-02f, 8.97866413e-02f, -8.58675018e-02f, -1.98645163e-02f, -1.33093856e-02f, 6.24924414e-02f,
  -4.37787361e-02f, -5.52781166e-05f, -5.63214906e-02f, -2.73802206e-02f, -4.31175809e-03f, -8.45248103e-02f, -9.45746154e-02f, -4.81817983e-02f, 3.03997211e-02f, -7.80719295e-02f,
  -1.25739321e-01f, -4.19890368e-03f, 1.18178546e-01f, -3.29954065e-02f, -3.21839415e-02f, 6.85719401e-02f, 8.76116306e-02f, 4.64432128e-02f, -3.38539407e-02f, -3.86540815e-02f,
  9.48541909e-02f, 1.71443373e-01f, 9.57521349e-02f, 9.72194523e-02f, 1.64938256e-01f, 8.25372711e-02f, -1.68324895e-02f, 1.22248784e-01f, 1.38570726e-01f, 3.59844305e-02f,
  -3.32342610e-02f, -6.53273016e-02f, -1.86865479e-02f, 2.03112625e-02f, -9.33112130e-02f, 1.09283537e-01f, -3.09512392e-02f, -1.04014628e-01f, 3.00864428e-02f, 2.19779499e-02f,
  4.96203184e-01f, -3.42285447e-02f, 1.59806654e-01f, -9.90456194e-02f, -5.43382801e-02f, -5.06096967e-02f, 2.56337561e-02f, 2.70907115e-03f, -8.46436322e-02f, 8.59936699e-02f,
  3.27794068e-03f, -5.79088442e-02f, -6.37263581e-02f, 4.72466201e-02f, 7.62881860e-02f, -5.68206757e-02f, -2.27552369e-01f, -2.54619401e-02f, -8.45300686e-03f, 9.66144130e-02f,
  -1.87010895e-02f, -7.92289898e-02f, 7.56469443e-02f, -9.36293323e-03f, 2.03754148e-03f, 4.64886054e-02f, -6.95439801e-02f, -1.53353915e-01f, -9.10685509e-02f, -1.39436470e-02f,
  8.56258422e-02f, 6.47000074e-02f, -6.97353259e-02f, -2.20950344e-03f, 2.98142433e-03f, 1.76976863e-02f, 1.26324305e-02f, -1.15604904e-02f, -1.61013231e-02f, 1.53563693e-02f,
  3.99983563e-02f, 4.97426465e-02f, 7.24694431e-02f, 2.82328520e-02f, -3.28356400e-03f, -1.83580425e-02f, -4.37180512e-02f, 2.36506686e-02f, -7.14417398e-02f, -3.59195620e-02f,
  -6.47275522e-02f, 7.64306681e-03f, 3.28111835e-02f, -3.48487608e-02f, -7.52300546e-02f, -6.01940081e-02f, 3.70947756e-02f, 5.36572263e-02f, -5.82056157e-02f, -4.74451482e-02f,
  2.83496052e-01f, -8.56686756e-02f, 2.14791328e-01f, -7.43621960e-02f, 4.87245657e-02f, -8.47549886e-02f, 5.94618469e-02f, 3.47433425e-02f, -7.86609575e-02f, 4.76479903e-02f,
  1.33581325e-01f, -2.61023864e-02f, 5.99670559e-02f, -3.68099883e-02f, -8.89778975e-03f, -1.77878831e-02f, -1.42154083e-01f, 1.01379417e-01f, -3.64370793e-02f, 7.92852640e-02f,
  -7.49457181e-02f, 3.32646328e-03f, 2.04541177e-01f, 1.78424090e-01f, 5.57008758e-02f, 1.74231321e-01f, 2.85934657e-01f, 1.33933008e-01f, 1.91935718e-01f, 2.22360775e-01f,
  -4.09704655e-01f, -9.00954083e-02f, -2.38084465e-01f, -3.15799892e-01f, 9.20437798e-02f, 1.81764394e-01f, 1.15292542e-01f, -9.74346977e-03f, -1.32960053e-02f, 1.19748432e-02f,
  2.48521306e-02f, -1.21563748e-01f, -5.64593300e-02f, 1.92392319e-02f, 1.67784374e-02f, 4.80513927e-03f, -3.40877697e-02f, -1.30818292e-01f, 1.72649650e-03f, 1.77608818e-01f,
  6.98694959e-02f, -2.23732650e-01f, -1.63397804e-01f, -6.49586394e-02f, 5.50391003e-02f, 1.18518444e-02f, -1.18303768e-01f, -2.02003688e-01f, 1.56996064e-02f, -1.82326227e-01f,
  -9.53365788e-02f, 4.67723012e-02f, 7.16219470e-02f, -1.04527585e-01f, -5.82802072e-02f, -2.67257541e-02f, 1.05417641e-02f, -6.47604093e-02f, 6.07121270e-03f, -4.56435047e-02f,
  -7.19371513e-02f, -1.18334694e-02f, -7.17532262e-02f, 2.59425193e-02f, -8.50486085e-02f, 8.13824683e-02f, -2.43469384e-02f, -8.36420152e-03f, 7.84142688e-02f, 9.83296037e-02f,
  -3.85759724e-03f, 7.21857557e-03f, -8.73681065e-03f, 1.26430839e-01f, 1.03806257e-01f, -4.87840958e-02f, -1.83731655e-03f, 7.64145190e-03f, 4.88631986e-02f, -9.76459086e-02f,
  9.26640183e-02f, 1.14863075e-01f, 5.26825823e-02f, -2.22475380e-02f, -3.78249772e-02f, -5.23184799e-02f, -3.54491770e-02f, 1.53545160e-02f, 3.69654000e-02f, -1.09281033e-01f,
  6.12762710e-03f, 6.37210384e-02f, -2.43163202e-02f, -1.05413757e-01f, 4.14784811e-02f, 4.78520133e-02f, -4.06271219e-02f, 9.39427018e-02f, 1.07882228e-02f, -4.55560535e-02f,
  2.63217092e-02f, -6.22106232e-02f, -8.29069391e-02f, -1.77307371e-02f, 4.54908051e-03f, -3.11466530e-02f, 5.25406599e-02f, 1.50788799e-01f, -2.32833326e-02f, 6.54649585e-02f,
  -2.45435119e-01f, 1.53099582e-01f, 1.00601632e-02f, -2.34749541e-02f, -3.19366045e-02f, -2.98014954e-02f, -6.87372163e-02f, -4.62577678e-02f, -3.22654508e-02f, 4.21080776e-02f,
  3.32364887e-02f, 1.10288635e-02f, -2.49640997e-02f, -5.58922514e-02f, 4.73964885e-02f, 1.92806087e-02f, -6.19068481e-02f, -4.14061323e-02f, 1.36834458e-01f, 6.10656478e-02f,
  -9.03058872e-02f, -2.76669562e-02f, -9.51864347e-02f, -1.01607792e-01f, 2.26720013e-02f, -3.90493199e-02f, -1.05481826e-01f, -8.46437290e-02f, 1.50090856e-02f, -2.41546303e-01f,
  3.95523459e-02f, 4.09369580e-02f, -7.22168982e-02f, -5.89139909e-02f, -3.58429849e-02f, -1.14608735e-01f, -1.10198796e-01f, -1.96686555e-02f, -8.16640183e-02f, 5.49732707e-02f,
  -1.32728800e-01f, -4.17443290e-02f, -4.34593782e-02f, 5.02277985e-02f, 1.01423524e-01f, 9.26645920e-02f, 1.19078219e-01f, 1.17803976e-01f, -1.01835765e-02f, -9.40889195e-02f,
  -1.33654429e-02f, 3.89533862e-02f, 1.25414729e-01f, -8.74448381e-03f, -5.94264176e-03f, 7.07733780e-02f, 5.66969737e-02f, 7.31078684e-02f, -3.25922817e-02f, 2.04778180e-01f,
  -8.72117095e-03f, -8.73277262e-02f, 4.76737656e-02f, 6.93577761e-03f, -4.85464297e-02f, -1.26247061e-02f, -1.22357696e-01f, 8.82945508e-02f, -5.88452816e-02f, 4.29745652e-02f,
  -7.01019615e-02f, -8.50591287e-02f, -2.26867311e-02f, -6.14847951e-02f, -1.06975354e-01f, 1.30716478e-02f, 8.70355964e-02f, 1.05928145e-01f, 8.82949829e-02f, -8.31090752e-03f,
  -1.31859500e-02f, -4.69808280e-02f, -1.55300722e-01f, -8.66569206e-02f, -3.51658615e-04f, 1.90000627e-02f, -8.20719600e-02f, 4.94830571e-02f, 1.07846074e-02f, 2.47590281e-02f,
  -1.03610240e-01f, 6.26395995e-05f, -5.92786632e-03f, -3.25250067e-02f, 4.13779803e-02f, -8.02790225e-02f, -4.50899005e-02f, -7.56417140e-02f, -2.67851055e-02f, 5.21205664e-02f,
  -3.29025835e-02f, 6.17991714e-03f, -1.38275504e-01f, -1.32745726e-03f, 2.64428388e-02f, -6.50314614e-02f, -9.28855985e-02f, -5.48437312e-02f, 7.09516481e-02f, -7.14406073e-02f,
  -2.87018571e-04f, -7.95798078e-02f, -4.82971668e-02f, -1.14835054e-02f, 7.92879239e-02f, 1.70310363e-02f, 1.17787877e-02f, 7.08663315e-02f, -1.03315553e-02f, -6.68239146e-02f,
  8.58744457e-02f, -4.31406088e-02f, 1.15045521e-04f, 1.19099114e-02f, 5.28952740e-02f, 1.09470457e-01f, -5.79076856e-02f, 7.12112582e-04f, 1.45737408e-03f, -8.40794891e-02f,
  -2.89022271e-02f, 1.46031566e-02f, 2.02207267e-03f, -3.39844748e-02f, -1.09837065e-02f, -6.60794228e-02f, 6.58538043e-02f, 6.96783364e-02f, 3.04917656e-02f, 9.98886582e-03f,
  7.56738856e-02f, -1.84674300e-02f, -1.13512009e-01f, -1.10550925e-01f, -9.26029906e-02f, -7.92648420e-02f, -1.32613197e-01f, -8.49895030e-02f, -1.99761000e-02f, -7.41772875e-02f,
  1.58090666e-01f, -1.58764496e-01f, -1.76334232e-01f, -2.58153141e-03f, -8.21428746e-02f, 8.43908340e-02f, -5.13118878e-02f, 6.14564307e-02f, 6.62507564e-02f, -2.18352228e-02f,
  3.72959413e-02f, 7.49892071e-02f, -2.44825464e-02f, 1.53795974e-02f, 8.49696994e-02f, -1.04851767e-01f, -5.35793528e-02f, 3.74788791e-02f, 1.26053691e-01f, -1.77659951e-02f,
  -3.67021337e-02f, -3.37132141e-02f, -1.18169701e-02f, 5.19074649e-02f, -9.16713476e-02f, -2.93699233e-03f, -3.39195915e-02f, 3.90220666e-04f, -1.12937637e-01f, -6.20778017e-02f,
  -5.12050949e-02f, 1.35674630e-03f, 6.84438422e-02f, -6.24738410e-02f, -1.40380055e-01f, -2.72791535e-02f, 4.12352011e-02f, -4.93401699e-02f, 4.97531407e-02f, -5.90966344e-02f,
  1.53437136e-02f, 1.05059678e-02f, 6.37276992e-02f, 1.14848725e-02f, 6.32824609e-03f, 1.12289805e-02f, 6.09858893e-03f, 2.82434281e-02f, -4.87457551e-02f, -3.70736644e-02f,
  8.81684106e-03f, -3.38377780e-03f, -6.32356759e-03f, 2.43393220e-02f, 1.09049574e-01f, -6.07951507e-02f, -4.56272475e-02f, -7.20741972e-02f, -7.36136362e-02f, -8.43413919e-02f,
  8.91728550e-02f, 2.96529140e-02f, -4.65007015e-02f, 6.15912601e-02f, 7.70821571e-02f, -4.35286798e-02f, -9.64102224e-02f, 9.50101763e-02f, 8.64755288e-02f, -7.24119842e-02f,
  1.75985526e-02f, 9.81750265e-02f, -1.73622109e-02f, 1.77669991e-03f, -1.38682639e-02f, -8.07268545e-02f, -7.44042024e-02f, -3.49429436e-02f, 5.55138998e-02f, 4.90716211e-02f,
  -1.04151256e-02f, -7.18835071e-02f, -1.78837311e-02f, -7.34071881e-02f, -1.98251009e-02f, -8.60284790e-02f, -1.04310408e-01f, -9.43493471e-02f, 1.28817316e-02f, -7.33041763e-02f,
  -1.12817734e-01f, 1.06956631e-01f, -1.88918691e-02f, 1.08035713e-01f, 5.66534139e-02f, 2.93824673e-02f, -1.11100599e-02f, 6.27685115e-02f, 9.19572711e-02f, 3.14699635e-02f,
  -9.07411240e-03f, 5.34570217e-02f, 8.09474289e-02f, -2.51252996e-03f, 5.30855320e-02f, 5.85078336e-02f, -7.53860455e-03f, -2.57368069e-02f, 3.00777182e-02f, 5.23422733e-02f,
  -4.05720770e-02f, 6.69738352e-02f, -5.20798657e-03f, -3.74702550e-02f, -6.19724728e-02f, 6.84457719e-02f, -8.05184767e-02f, -5.27968034e-02f, -3.11107077e-02f, -2.75120512e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.52062595e-01f, 6.56871423e-02f, 3.16493630e-01f, 1.35543004e-01f, 4.27347943e-02f, 8.10867995e-02f, 2.43177135e-02f, 9.57246795e-02f, 4.15607505e-02f, -9.37945619e-02f,
  6.39023185e-02f, 9.38004106e-02f, 2.72676051e-01f, -3.37158702e-02f, 2.02378973e-01f, 9.86061618e-02f, 2.60191355e-02f, -3.89633812e-02f, 1.54642954e-01f, 7.34630451e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.94961655e-02f, 1.93456531e-01f, -2.05013648e-01f, 3.28132957e-02f, 2.16322079e-01f, 4.27894033e-02f, 4.83507477e-02f, 5.14024235e-02f, -1.20030589e-01f, -9.67764631e-02f,
  4.77414250e-01f, 2.39781514e-01f, 3.60509098e-01f, -3.40893894e-01f, 2.29491759e-02f, 1.13406397e-01f, -6.56921715e-02f, -3.66964675e-02f, 3.17879647e-01f, -2.04508454e-02f,
  2.18017697e-02f, -1.62062779e-01f, 1.89735964e-01f, -5.87310269e-02f, 5.82372881e-02f, -3.52812260e-01f, -6.82105869e-02f, 1.17172324e-03f, 3.36691856e-01f, -2.95545489e-01f,
  -6.86158612e-02f, 1.48094386e-01f, 5.35312258e-02f, -8.73125941e-02f, 5.86892059e-03f, 8.72110762e-03f, -2.21750408e-01f, -1.31960720e-01f, 8.68315473e-02f, 2.37918094e-01f,
  -1.38511792e-01f, -6.78485781e-02f, -8.63885432e-02f, 2.06573620e-01f, 1.14713222e-01f, -1.63626894e-01f, 6.01218119e-02f, 1.81030288e-01f, 1.16783991e-01f, -6.78082928e-02f,
  2.28840038e-01f, -1.25543550e-01f, 5.89084858e-03f, -7.38319457e-02f, -3.27943526e-02f, 1.42178938e-01f, 3.53324488e-02f, -1.14346936e-01f, -1.22903340e-01f, 2.45181113e-01f,
  -3.27165663e-01f, 1.92140967e-01f, -2.01222658e-01f, 1.29755303e-01f, -1.58593863e-01f, -4.50764596e-02f, -1.80232137e-01f, 6.39801100e-02f, 2.09576506e-02f, -1.71706453e-01f,
  -8.94215554e-02f, -1.41426325e-01f, -5.83849661e-02f, 1.35954559e-01f, 2.51955390e-01f, 3.11571389e-01f, 2.15228990e-01f, -2.05911100e-01f, 2.12834716e-01f, -1.28131565e-02f,
  -1.26720384e-01f, 1.13447994e-01f, -1.30617306e-01f, -3.05530266e-04f, -2.86988527e-01f, 5.24844183e-03f, -1.44259185e-01f, 1.71579748e-01f, 2.62808637e-03f, -2.37262458e-01f,
  -2.74662286e-01f, 2.35322818e-01f, 5.27219355e-01f, -6.49181306e-02f, -4.13192138e-02f, -1.12497047e-01f, -2.48702064e-01f, 1.23875208e-01f, -1.03309922e-01f, -5.92763796e-02f,
  2.37484857e-01f, -2.46558025e-01f, -3.07947159e-01f, -1.48537889e-01f, -1.76643476e-01f, 3.60901579e-02f, -2.68451780e-01f, -1.48380350e-03f, -8.38463008e-02f, 1.04472257e-01f,
  2.34963477e-01f, 1.19468495e-01f, 2.37353832e-01f, 1.43892139e-01f, -3.05988580e-01f, -4.38323505e-02f, -1.35535955e-01f, 8.72256756e-02f, -2.83836186e-01f, -1.15989678e-01f,
  1.87474862e-01f, 5.79031669e-02f, -1.35218084e-01f, 1.08275086e-01f, -4.89498116e-02f, 4.03090835e-01f, -1.71718642e-01f, 5.40877786e-03f, -3.15254122e-01f, 7.74695128e-02f,
  -3.23996996e-03f, 1.96926221e-01f, 3.16477746e-01f, -2.83642653e-02f, -2.08775744e-01f, -1.89527914e-01f, -1.92360938e-01f, 1.09463342e-01f, 3.40132624e-01f, 2.70427585e-01f,
  7.27724880e-02f, -2.05919340e-01f, 2.00420201e-01f, 2.22688407e-01f, 1.03388794e-01f, -1.17468782e-01f, -4.23220754e-01f, 1.41947880e-01f, -2.36289710e-01f, -1.06740566e-02f,
  1.10986181e-01f, 1.37054592e-01f, -4.69546169e-02f, -2.20548622e-02f, -7.03174993e-02f, -6.99673370e-02f, -3.98805924e-03f, -1.30822971e-01f, 4.70823944e-02f, 2.14394648e-02f,
  2.74677128e-01f, -1.59424171e-01f, -1.67610511e-01f, 7.63024837e-02f, -3.71393442e-01f, 1.63053513e-01f, 2.03527495e-01f, 1.33144662e-01f, 2.96307713e-01f, -2.31732428e-01f,
  4.91833799e-02f, -2.30681971e-01f, -1.27740502e-01f, 2.47387923e-02f, -1.48325011e-01f, -2.71101415e-01f, -3.13540511e-02f, -1.30735226e-02f, 2.30697498e-01f, 1.90869898e-01f,
  2.06376180e-01f, 1.19079843e-01f, 3.10656548e-01f, 3.11020259e-02f, -1.54612198e-01f, -5.22066914e-02f, 1.41737849e-01f, -1.00584604e-01f, 1.09305941e-01f, -2.82990247e-01f,
  -4.29237122e-03f, -2.35232219e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.36757562e-01f, 2.59708524e-01f, 5.82432672e-02f, -5.00473715e-02f, -7.76287764e-02f, 1.56294391e-01f, 2.21143454e-01f, -1.11335516e-01f, 1.52520627e-01f, 9.09562334e-02f,
  1.43877208e-01f, 1.72306988e-02f, 2.28481099e-01f, 1.77833289e-01f, 2.87045479e-01f, -1.31708547e-01f, 1.61955178e-01f, 2.40249887e-01f, 2.78320104e-01f, 1.02062367e-01f,
  -8.83273780e-02f, 1.17528737e-01f, 2.62747198e-01f, -9.44744200e-02f, 2.09519982e-01f, -6.20842725e-02f, 9.61204618e-03f, 3.18944395e-01f, -2.44016618e-01f, 2.88133770e-01f,
  1.90578297e-01f, 2.49323443e-01f, 4.02330428e-01f, 2.68943340e-01f, 1.40539408e-01f, 3.95920932e-01f, -1.50667384e-01f, -2.65067518e-02f, 3.26316774e-01f, 1.46975800e-01f,
  3.69037032e-01f, -3.15392047e-01f, -1.38736412e-01f, -3.54437798e-01f, -2.74059270e-02f, 2.00545728e-01f, 2.13739261e-01f, 1.20518066e-01f, 4.18750606e-02f, -3.75401378e-01f,
  1.40917331e-01f, -6.53078500e-03f, 2.20025882e-01f, 6.94735395e-03f, -4.89252657e-02f, -6.13398403e-02f, -6.22934941e-03f, 1.16620332e-01f, 1.49772987e-01f, -1.51074216e-01f,
  2.29937047e-01f, -2.71172076e-01f, 1.99381486e-01f, -1.37033999e-01f, 8.40295106e-02f, 3.22620451e-01f, 2.27777153e-01f, -1.15410686e-01f, 1.32606655e-01f, -1.05569430e-01f,
  -8.41429457e-02f, -1.52967229e-01f, 1.28178760e-01f, 1.27275288e-01f, 4.52140756e-02f, -6.54065236e-02f, -6.34980127e-02f, 2.75435925e-01f, 1.46998540e-01f, -4.93509509e-02f,
  1.36368617e-01f, 3.68879288e-01f, -3.36521417e-01f, -9.39088315e-03f, 1.15424722e-01f, -4.49097529e-02f, 4.33233194e-02f, 5.37473150e-02f, 4.34464782e-01f, 2.95232594e-01f,
  2.42172301e-01f, 1.30458161e-01f, -3.87701184e-01f, 4.75799441e-01f, 2.44380832e-01f, -1.53870853e-02f, 3.02157104e-01f, 4.02442455e-01f, 1.07534647e-01f, 1.33193031e-01f,
  2.29212627e-01f, 2.92965591e-01f, 9.37940925e-02f, 8.24557617e-02f, -1.74378783e-01f, 1.63344160e-01f, 4.67519820e-01f, -1.76645927e-02f, 1.58718467e-01f, -9.77218151e-02f,
  1.84588596e-01f, 8.63257572e-02f, -1.94132090e-01f, -1.10356674e-01f, 1.25385979e-02f, 6.80875108e-02f, 1.93695366e-01f, -2.15466037e-01f, 3.93537492e-01f, -1.10103205e-01f,
  -1.61103740e-01f, -2.78869361e-01f, -1.29910365e-01f, 7.50876144e-02f, 5.77114858e-02f, 4.97682579e-02f, 2.72887945e-01f, 7.29202107e-02f, 1.10223778e-02f, 2.80969203e-01f,
  1.76061198e-01f, -4.72957827e-02f, 3.58079642e-01f, -5.92137165e-02f, -1.11609660e-02f, 1.61617491e-02f, -1.59263492e-01f, 2.91110188e-01f, 6.83064833e-02f, -3.15555744e-02f,
  -6.49787933e-02f, 2.98103951e-02f, 2.27080975e-02f, 1.39196083e-01f, -1.25637069e-01f, 2.06515625e-01f, -6.17740676e-02f, -8.04600716e-02f, -1.15735158e-01f, -1.30468786e-01f,
  -1.44351825e-01f, 1.48326829e-01f, 2.97626466e-01f, 2.20938951e-01f, 2.11161330e-01f, 2.01086089e-01f, -6.04591742e-02f, 1.83953077e-01f, 1.78735122e-01f, -6.52386472e-02f,
  1.18570507e-01f, 1.08778544e-01f, 8.47866293e-03f, 1.82914883e-02f, -1.15521513e-01f, -3.29050981e-02f, -5.21121472e-02f, 2.58943532e-02f, -8.18685517e-02f, 1.55265674e-01f,
  -1.84104502e-01f, -1.62464380e-01f, 5.19483835e-02f, -4.84398827e-02f, -1.10725634e-01f, 1.75789014e-01f, 2.03117862e-01f, 2.32793614e-01f, 4.30410989e-02f, 1.21019280e-03f,
  2.34335326e-02f, -1.39366433e-01f, -1.17285281e-01f, -9.33230594e-02f, 1.24916606e-01f, -5.85439242e-02f, 1.14919439e-01f, 4.10996452e-02f, -1.89863488e-01f, 1.48867562e-01f,
  1.30504863e-02f, -2.47457996e-02f, 4.35596779e-02f, 3.62224393e-02f, 2.37831905e-01f, -9.24531445e-02f, -1.39581747e-02f, 1.43113405e-01f, -2.31714249e-01f, -1.97082371e-01f,
  -8.08101296e-02f, 7.35240281e-02f, -4.14962173e-02f, 1.61864027e-01f, 8.81456807e-02f, 8.58937055e-02f, 1.74514383e-01f, 2.40532085e-02f, 1.36011556e-01f, 1.75245762e-01f,
  -3.66773531e-02f, -1.89521268e-01f, 4.62234812e-03f, -9.77677852e-02f, 5.25133274e-02f, 4.57559004e-02f, 3.22640508e-01f, 6.06438108e-02f, 1.12333022e-01f, 1.38755932e-01f,
  -1.29447922e-01f, 2.62574077e-01f, -2.65412051e-02f, -6.39702007e-02f, -6.71013370e-02f, 2.88415462e-01f, 1.57891184e-01f, 9.04591456e-02f, 1.45993233e-01f, 1.05188742e-01f,
  9.84715000e-02f, -2.33314872e-01f, 2.85190672e-01f, -2.16905579e-01f, -1.44079402e-01f, -2.48715982e-01f, -8.60199779e-02f, 3.68258744e-01f, 2.69294083e-01f, 2.07601711e-01f,
  -9.89042968e-03f, 1.53662920e-01f, -3.39027584e-01f, 4.79065217e-02f, -2.01499294e-02f, 1.38725758e-01f, 1.64600968e-01f, -2.94340830e-02f, 4.21763241e-01f, 1.40846297e-01f,
  1.12131275e-01f, 8.68836790e-02f, -2.32752696e-01f, 1.41569272e-01f, 1.48654774e-01f, -7.85597116e-02f, 5.35444841e-02f, 3.44096243e-01f, -3.77485231e-02f, 1.02475278e-01f,
  3.85421962e-01f, 6.74013644e-02f, 1.76394090e-01f, -2.23796844e-01f, 2.98520327e-01f, -9.04715285e-02f, 4.56882976e-02f, -1.94183197e-02f, -2.23716021e-01f, -1.08595759e-01f,
  1.33425236e-01f, 2.07162797e-01f, -1.35101736e-01f, -1.06017269e-01f, -3.18641156e-01f, -6.98307976e-02f, -1.24939971e-01f, -1.79091275e-01f, 8.49985406e-02f, -2.69793731e-04f,
  3.35038453e-01f, 2.15198308e-01f, 4.16812420e-01f, -1.66522637e-01f, 5.54394722e-02f, -2.35727355e-01f, 2.79498249e-01f, 3.35703194e-02f, -1.90094754e-01f, 1.03052117e-01f,
  1.38239801e-01f, -5.96173927e-02f, 1.32325208e-02f, 2.28061434e-02f, 9.80892479e-02f, 6.89929947e-02f, -8.56125541e-03f, 7.54146799e-02f, -8.53955746e-02f, -1.60118997e-01f,
  5.05515561e-02f, -1.71222210e-01f, -6.99126944e-02f, -5.50774522e-02f, -1.04751870e-01f, -2.00433224e-01f, -1.58161715e-01f, 1.34204924e-01f, -1.19273840e-02f, -8.87703747e-02f,
  1.16537213e-01f, 5.75492680e-02f, 5.41067384e-02f, -8.20795521e-02f, -9.15013701e-02f, 5.34529649e-02f, -7.30391294e-02f, -3.87918763e-02f, -1.13052197e-01f, 7.91796669e-02f,
  1.45143583e-01f, 1.93209220e-02f, 6.94756210e-02f, -2.86248885e-02f, 6.53615873e-03f, 1.70816109e-01f, 2.71160662e-01f, 6.71918765e-02f, 2.53470629e-01f, -1.31002054e-01f,
  2.65900213e-02f, -4.97832932e-02f, -3.88791412e-02f, 3.11023504e-01f, 1.71607718e-01f, 1.43428482e-02f, 7.97306448e-02f, -1.70412377e-01f, -2.42715642e-01f, 1.18893877e-01f,
  1.90157406e-02f, 5.35649993e-03f, -1.01968586e-01f, -1.27519354e-01f, 1.81031063e-01f, 3.86728123e-02f, -3.21742333e-02f, -1.08030597e-02f, -1.55247167e-01f, -1.11744307e-01f,
  -5.95772937e-02f, 3.81255820e-02f, 1.15233235e-01f, 4.40164804e-02f, -1.22341320e-01f, 1.86672643e-01f, 5.47374971e-02f, 2.33894467e-01f, 2.76165992e-01f, 1.32640868e-01f,
  2.70391256e-01f, -6.41463473e-02f, -7.22720996e-02f, -2.54265368e-01f, -1.67444989e-01f, 5.55231124e-02f, 1.57073513e-01f, -1.36284947e-01f, -3.24540287e-02f, -3.47018242e-02f,
  -1.06024660e-01f, 1.39906213e-01f, 1.49119884e-01f, -1.51736334e-01f, 1.44228518e-01f, 1.63264349e-02f, 1.07151695e-01f, 6.83727041e-02f, 1.26694173e-01f, -2.40497235e-02f,
  1.17612995e-01f, 1.10224359e-01f, 1.71916708e-01f, -1.91321954e-01f, -1.26699507e-01f, -1.83784634e-01f, 1.18180782e-01f, -2.22587332e-01f, 1.04452789e-01f, -1.64109349e-01f,
  -1.35114327e-01f, -8.30952451e-02f, 2.43237894e-02f, -5.06714545e-02f, -9.89006311e-02f, -1.56390458e-01f, -5.30490950e-02f, 1.29802108e-01f, 3.16105201e-03f, 8.14129226e-03f,
  -8.77030194e-03f, -5.56736402e-02f, 2.55811304e-01f, 8.49014595e-02f, -5.73688447e-02f, 4.08353806e-01f, -1.01207905e-01f, 8.19011033e-02f, 1.67433798e-01f, 8.84025693e-02f,
  -4.86130156e-02f, -3.90637703e-02f, 1.59298092e-01f, 1.71489373e-01f, 1.01656839e-01f, 5.80809452e-02f, -2.08918959e-01f, -5.64880110e-03f, -1.32407178e-03f, 8.26230794e-02f,
  1.29587114e-01f, 1.96887568e-01f, -1.81935579e-01f, 6.33520856e-02f, -2.44815841e-01f, 2.26442944e-02f, 2.04910815e-01f, 3.13366950e-01f, 3.39382231e-01f, 1.38190314e-01f,
  2.27804363e-01f, -2.55950335e-02f, -7.03640506e-02f, 3.47971055e-03f, 2.92789966e-01f, 2.38025144e-01f, -1.79770142e-01f, 2.18165174e-01f, 1.21674053e-01f, -2.77931411e-02f,
  8.77969116e-02f, -1.02789730e-01f, -2.92980283e-01f, 1.30204275e-01f, 4.42896709e-02f, 1.81306228e-01f, -1.82424128e-01f, 6.43559359e-03f, 2.24566590e-02f, -1.88601818e-02f,
  -6.34730756e-02f, 1.49182141e-01f, -1.40549660e-01f, -7.02377856e-02f, 1.40326098e-01f, 1.18516795e-01f, -7.45124891e-02f, -1.50494620e-01f, 1.94461644e-01f, -1.19828478e-01f,
  6.25984073e-02f, 3.23363170e-02f, 1.73486322e-01f, 1.46048293e-01f, -1.50672039e-02f, -3.66798975e-02f, -1.85993135e-01f, 1.96737707e-01f, 1.72650456e-01f, -6.48379400e-02f,
  -1.53090402e-01f, -1.71345528e-02f, 1.91442579e-01f, 1.68033421e-01f, 9.62025821e-02f, -5.69829568e-02f, -1.68357223e-01f, 2.33198311e-02f, -2.62335204e-02f, -1.49325848e-01f,
  2.65080839e-01f, 1.72589183e-01f, 6.05599722e-03f, 1.52110634e-02f, -1.60550520e-01f, 9.56264213e-02f, 2.02299938e-01f, 1.61154673e-01f, -4.81397137e-02f, -3.69676203e-02f,
  9.96808484e-02f, -1.16341859e-01f, 3.59968722e-01f, 2.42717564e-01f, 2.10749820e-01f, -1.21596813e-01f, -1.29281074e-01f, 7.77041987e-02f, 4.70973670e-01f, 2.19395548e-01f,
  3.16240489e-01f, 9.82828736e-02f, 3.57402772e-01f, 6.10865504e-02f, -5.38281053e-02f, -7.95551911e-02f, 7.34880045e-02f, 2.17962086e-01f, -2.91816950e-01f, 3.05004511e-02f,
  1.18522443e-01f, 1.60123363e-01f, -8.07467569e-03f, 1.75734147e-01f, 2.26086184e-01f, 1.84312999e-01f, 4.28833723e-01f, 1.65768221e-01f, -3.60092819e-01f, -3.00335765e-01f,
  -4.95165922e-02f, 3.96582335e-01f, 8.73002410e-02f, 1.74696088e-01f, -1.22302338e-01f, -3.01209718e-01f, -1.52638145e-02f, 8.21088031e-02f, -2.07963064e-02f, 2.28906706e-01f,
  -3.63229841e-01f, -2.23766968e-01f, -1.96252659e-01f, 9.24205035e-03f, 5.59205115e-02f, 2.30886400e-01f, 4.10349429e-01f, -1.06346808e-01f, 3.00482780e-01f, 2.07396522e-01f,
  1.05502240e-01f, 1.55922309e-01f, -1.09755762e-01f, -6.37182966e-02f, 1.58600956e-01f, 2.31574088e-01f, 2.76757348e-02f, 3.77332270e-02f, 1.67468786e-01f, 2.42261350e-01f,
  -6.60933275e-03f, 2.56014019e-01f, -1.92459896e-01f, 2.32409358e-01f, 4.98593241e-01f, 3.57407182e-01f, 4.82768387e-01f, -4.20221500e-02f, 3.51940602e-01f, 1.06795087e-01f,
  -1.31465778e-01f, 1.14922188e-01f, 3.04048210e-01f, 1.80030361e-01f, -4.13902253e-02f, -9.03102905e-02f, 2.20905364e-01f, 1.42354406e-02f, -6.72929501e-03f, -2.68781632e-01f,
  -3.73071015e-01f, 3.21112067e-01f, 6.52625039e-02f, -7.96184838e-02f, -5.60662635e-02f, 2.13753164e-01f, 2.00755343e-01f, 2.72245914e-01f, 1.20288871e-01f, -7.73350894e-02f,
  2.33105391e-01f, 1.39034614e-01f, 1.68456003e-01f, -4.20025587e-02f, 5.66404089e-02f, 5.98268546e-02f, 4.24305573e-02f, -6.87312484e-02f, -1.95589475e-02f, -1.01782292e-01f,
  1.94265679e-01f, 1.00674026e-01f, -1.97561055e-01f, 5.12289777e-02f, 1.66553259e-01f, 1.65838808e-01f, 9.81806815e-02f, -1.43305331e-01f, 3.00368130e-01f, 6.71164766e-02f,
  -1.36758491e-01f, -4.64331135e-02f, -1.57754079e-01f, -4.85226214e-02f, -2.01445550e-01f, -3.30031328e-02f, 2.01295149e-02f, 2.16706172e-01f, -7.35384272e-03f, 8.89707804e-02f,
  1.27770528e-01f, -1.44734070e-01f, -1.13811705e-03f, 1.10679030e-01f, 2.22544685e-01f, 1.02395557e-01f, 1.46701425e-01f, 3.12528275e-02f, -1.31382778e-01f, -7.03257928e-03f,
  4.81475256e-02f, 2.69546837e-01f, -6.50576502e-02f, 7.18350485e-02f, -1.00750975e-01f, -7.62385204e-02f, -1.14261925e-01f, 1.02398336e-01f, -1.50024906e-01f, -1.10694557e-01f,
  4.48592426e-03f, -2.56449319e-02f, -1.40735088e-02f, -1.31963417e-01f, 1.83111623e-01f, -8.91847834e-02f, -1.27221093e-01f, 4.00806330e-02f, 8.15780684e-02f, -3.12515460e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.62758291e-01f, 1.36005953e-01f, 2.68484622e-01f, 2.30727777e-01f, 3.08282003e-02f, 1.74825676e-02f, 8.10092166e-02f, 1.26059517e-01f, 3.72966528e-01f, -1.41710177e-01f,
  1.02036260e-01f, 1.30465403e-01f, -9.31645110e-02f, -2.13988144e-02f, 2.92266291e-02f, 2.89608747e-01f, 3.98654133e-01f, 7.19297454e-02f, 1.50351435e-01f, 1.70874983e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.61248222e-01f, 1.98769271e-01f, 3.39488685e-02f, 1.58892721e-01f, -3.78571637e-02f, -1.57699168e-01f, -7.27874339e-02f, 1.17314421e-01f, -4.82967079e-01f, -3.22187133e-02f,
  -2.74523079e-01f, 2.62820005e-01f, 1.72107071e-01f, 3.54870677e-01f, 1.03780866e-01f, -2.13471562e-01f, -7.70974625e-03f, 6.81111068e-02f, 1.28710121e-01f, 3.01500503e-02f,
  1.64585993e-01f, -1.08335964e-01f, -4.99148816e-02f, -6.41165599e-02f, -1.78023055e-01f, -1.36170164e-01f, 2.90777050e-02f, 1.49461970e-01f, -2.35334367e-01f, -3.43592882e-01f,
  1.90199450e-01f, 5.38769271e-03f, 7.91051611e-02f, 1.15987122e-01f, 1.45003900e-01f, 2.16146648e-01f, -3.01215425e-02f, 2.15320721e-01f, 2.70013422e-01f, -2.63099540e-02f,
  3.16950619e-01f, -5.41849583e-02f, 3.12021226e-01f, -1.50056988e-01f, 1.70323715e-01f, -4.14719105e-01f, -2.16038182e-01f, 9.00084749e-02f, -4.58846148e-03f, -7.39181861e-02f,
  -5.76386601e-02f, -1.41439572e-01f, -2.11404115e-01f, -5.51542044e-02f, 1.15589611e-01f, -1.35816589e-01f, 2.24607810e-01f, 3.68952066e-01f, -7.19042048e-02f, 3.23551260e-02f,
  -2.18835175e-02f, 4.30199265e-01f, -8.30945298e-02f, -1.80230170e-01f, 5.93878701e-02f, 1.63825333e-01f, -1.40921146e-01f, 1.77001685e-01f, -1.62238047e-01f, 1.15073971e-01f,
  -2.75084879e-02f, -9.04596224e-02f, -9.12280306e-02f, -1.20636798e-01f, -3.08383346e-01f, 3.72603208e-01f, -1.36967823e-01f, 2.10753068e-01f, -1.71980187e-01f, 6.77719191e-02f,
  -1.58652350e-01f, -3.95634212e-02f, -1.16026789e-01f, 1.18327318e-02f, -1.46984663e-02f, 1.48606524e-01f, 1.33348048e-01f, -3.36273350e-02f, -6.41457736e-02f, -8.47261474e-02f,
  9.55140963e-02f, 1.71891630e-01f, -4.68168519e-02f, -1.63795650e-01f, 2.07195636e-02f, -8.48329440e-03f, 1.51405603e-01f, -1.48018226e-01f, 1.00645676e-01f, 1.53633490e-01f,
  -1.25638917e-01f, 1.51403382e-01f, -2.35567972e-01f, -1.95011303e-01f, -4.72589454e-04f, -8.39355122e-03f, -1.62506565e-01f, -1.02733932e-01f, -4.92390804e-02f, 7.23118931e-02f,
  1.04992248e-01f, -1.27792535e-02f, 1.46570459e-01f, -1.01955779e-01f, -1.54283524e-01f, 3.64209488e-02f, 1.43659100e-01f, 7.20615089e-02f, 1.24128245e-01f, 1.57574311e-01f,
  -3.59329730e-02f, -1.47092596e-01f, 1.50698947e-03f, -9.03479848e-03f, -8.64418447e-02f, -2.38911793e-01f, 1.09103121e-01f, 2.48972066e-02f, -1.70962229e-01f, -2.03520253e-01f,
  1.80105434e-03f, -1.99866578e-01f, -5.34623228e-02f, -8.71872529e-02f, -3.57179552e-01f, 1.08766727e-01f, -1.75230786e-01f, 3.10905352e-02f, 2.75480915e-02f, -3.39227580e-02f,
  1.20815925e-01f, 1.81825906e-01f, 2.58983552e-01f, -2.03899711e-01f, -1.16782121e-01f, 1.99907422e-01f, 1.97438955e-01f, 3.29996534e-02f, 8.26596096e-02f, -5.27835116e-02f,
  1.79858506e-01f, 2.70335209e-02f, 2.83926517e-01f, -1.81348935e-01f, 7.47762397e-02f, -2.17283681e-01f, 9.23567712e-02f, -3.36366206e-01f, -1.70478359e-01f, 7.92164262e-03f,
  5.72169870e-02f, -1.19164854e-01f, 2.01256558e-01f, -1.57822534e-01f, -5.83995059e-02f, -6.18172623e-02f, -5.72109446e-02f, 5.01927212e-02f, -3.06835491e-02f, 2.37042859e-01f,
  2.22569704e-02f, -1.30097881e-01f, -1.08699299e-01f, -3.45627099e-01f, 8.98237601e-02f, 5.54263406e-02f, -3.96774188e-02f, -8.09738995e-05f, 7.24124983e-02f, -1.66323230e-01f,
  -1.68021888e-01f, -3.51136662e-02f, -1.03851549e-01f, 1.02804117e-02f, -5.91550283e-02f, 9.41448566e-03f, -6.69651479e-02f, -1.61516517e-01f, 1.31209433e-01f, 5.51118068e-02f,
  3.04254889e-02f, -9.89993140e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.24932373e-01f, 7.47462958e-02f, 1.81154549e-01f, 1.47453114e-01f, 2.54680365e-01f, 6.62429705e-02f, 3.06203365e-01f, -8.02435204e-02f, -3.42498124e-02f, -2.05202162e-01f,
  -1.01408683e-01f, 2.37904210e-02f, 1.66376755e-01f, -6.40781820e-02f, -2.08578706e-02f, 2.47482955e-01f, -4.88199182e-02f, -2.00523347e-01f, -1.14506006e-01f, -9.00907665e-02f,
  5.35444096e-02f, 1.79212421e-01f, 6.57663643e-02f, 9.54838321e-02f, 7.35099092e-02f, -8.85322914e-02f, -2.39655711e-02f, 3.23679894e-02f, -1.84519365e-01f, 9.00060460e-02f,
  1.48236260e-01f, 8.34828615e-02f, -1.69059411e-01f, -1.20888017e-01f, -1.68540571e-02f, 7.20853433e-02f, -1.41480267e-01f, 4.02346440e-02f, 8.82131830e-02f, 1.07246131e-01f,
  -1.38699621e-01f, 5.46661578e-02f, -1.97269969e-06f, -1.26276854e-02f, -7.68118538e-04f, 1.54439151e-01f, -1.40617594e-01f, -1.13370940e-01f, -3.85801829e-02f, 1.06874444e-01f,
  -9.41351131e-02f, -2.23931856e-02f, 5.87414950e-02f, 5.10056652e-02f, -3.18857916e-02f, 2.47407332e-02f, -1.23995952e-01f, 9.95340757e-03f, -9.26953331e-02f, -1.06824003e-01f,
  -1.31816447e-01f, 7.09994584e-02f, 1.42101899e-01f, 1.23275764e-01f, 1.32904008e-01f, 1.78698912e-01f, 1.42274275e-01f, -1.38833821e-02f, 2.20784321e-01f, 2.58983344e-01f,
  -3.44498217e-01f, -1.67902887e-01f, -1.74437001e-01f, 8.57214555e-02f, 2.57294029e-02f, 1.41721249e-01f, 2.87653416e-01f, 3.28746676e-01f, 4.20951545e-01f, -4.77742925e-02f,
  2.01325461e-01f, -1.58939764e-01f, 2.24250201e-02f, 4.56517458e-01f, 4.22569215e-01f, 1.45467103e-01f, 3.85943174e-01f, 2.60148704e-01f, 4.51080091e-02f, -2.35631123e-01f,
  2.51081079e-01f, 2.11901441e-02f, -2.03946248e-01f, -2.43345141e-01f, 2.08180510e-02f, 1.94317982e-01f, 1.80795997e-01f, 2.57532090e-01f, 2.56116033e-01f, -1.45450026e-01f,
  6.17433749e-02f, -1.08403727e-01f, -1.95698917e-01f, -7.01940036e-04f, 9.48666558e-02f, 1.36047885e-01f, 3.55894379e-02f, -1.28653003e-02f, 5.50219119e-01f, 6.31017238e-02f,
  4.71106976e-01f, 4.33318056e-02f, 5.58817759e-02f, -5.20716086e-02f, 1.62509099e-01f, 3.91347706e-01f, -2.53116712e-02f, -1.34327993e-01f, 2.38080695e-01f, 9.27117541e-02f,
  2.44700238e-01f, 1.66273370e-01f, 1.64213359e-01f, 5.01597762e-01f, -1.37467803e-02f, 9.34884250e-02f, 2.59237736e-01f, 9.63676572e-02f, 7.55254775e-02f, -5.80880605e-02f,
  9.78682563e-03f, -9.75855291e-02f, -1.39669791e-01f, -1.91384673e-01f, -8.47790465e-02f, -3.87038775e-02f, -8.46037343e-02f, -9.27949101e-02f, 6.68595508e-02f, -1.75679922e-02f,
  6.41337410e-02f, 6.14503250e-02f, 9.49890167e-02f, -4.62388881e-02f, -9.41862911e-02f, -1.45564526e-01f, 8.30155388e-02f, -1.50933221e-01f, 5.09437844e-02f, -4.07637320e-02f,
  2.84621082e-02f, -5.84897101e-02f, 1.64680004e-01f, -2.34506615e-02f, -1.76447839e-01f, 1.08941168e-01f, 8.93697664e-02f, -1.47238418e-01f, -1.56947777e-01f, 2.94298232e-02f,
  -1.81533203e-01f, 4.55720723e-02f, 2.04631224e-01f, -1.72330916e-01f, 1.66129872e-01f, 1.15270227e-01f, 2.19540849e-01f, -1.62804425e-02f, 6.42979518e-02f, -2.29848057e-01f,
  -8.45236704e-02f, 1.91090137e-01f, 5.51928990e-02f, 1.03183262e-01f, -4.43512835e-02f, 3.31835337e-02f, 4.19006795e-02f, -1.71038747e-01f, -1.92123324e-01f, 3.80231701e-02f,
  -2.25747257e-01f, -8.91673472e-03f, 1.27583131e-01f, -1.32997677e-01f, -2.76395977e-02f, 1.11718073e-01f, -1.08657144e-01f, 2.89005637e-01f, -1.46796063e-01f, 2.73638457e-01f,
  2.46124327e-01f, 1.59221157e-01f, 4.04833078e-01f, 2.60944754e-01f, 3.24907377e-02f, 4.58982825e-01f, 2.59108335e-01f, 4.14680392e-01f, 1.82829738e-01f, -3.62387478e-01f,
  2.14551687e-01f, 1.25365838e-01f, 4.49466854e-01f, -2.82359391e-01f, -2.09041938e-01f, 4.46712226e-02f, 1.25418574e-01f, 9.68730226e-02f, 2.03777760e-01f, -1.53869554e-01f,
  1.16287291e-01f, 1.02281734e-01f, 2.38739923e-01f, -1.81199051e-02f, -1.39891729e-01f, 7.11795613e-02f, 4.17811759e-02f, -1.61822543e-01f, 1.30412400e-01f, -3.57973993e-01f,
  5.21648347e-01f, -3.66605222e-02f, 1.14398159e-01f, 1.79976108e-03f, 3.40272449e-02f, -1.48620188e-01f, 6.37370273e-02f, 5.12534147e-03f, 9.18077603e-02f, -5.44332974e-02f,
  3.16278376e-02f, 2.92553268e-02f, -8.28366652e-02f, 1.68267995e-01f, -3.72879878e-02f, 6.90709874e-02f, -8.63745660e-02f, 7.07695410e-02f, -1.23158090e-01f, -1.71036646e-02f,
  9.06812027e-02f, -1.18469670e-02f, -8.75950977e-02f, -9.48721468e-02f, -3.29765975e-02f, -3.04466411e-02f, 1.30265936e-01f, 1.51528213e-02f, -1.70645535e-01f, 9.85790640e-02f,
  -1.60817295e-01f, 2.88313031e-02f, -4.19533923e-02f, 1.30108401e-01f, 1.59226149e-01f, -1.51243120e-01f, 5.30113019e-02f, 1.86034352e-01f, 2.47151643e-01f, 3.01194519e-01f,
  8.14737380e-02f, 3.89027059e-01f, 5.75107217e-01f, -7.23897964e-02f, 4.65694964e-01f, -1.02831997e-01f, 4.73187506e-01f, -1.26687111e-02f, 1.77944422e-01f, -1.02001421e-01f,
  -2.94506252e-01f, 5.02365470e-01f, 7.24386610e-03f, -2.54286051e-01f, -1.64856851e-01f, -8.38787928e-02f, 8.72891471e-02f, -5.99026196e-02f, -9.63233784e-02f, 4.38937992e-02f,
  -2.07280964e-01f, 2.82513380e-01f, -5.72629310e-02f, 1.88576758e-01f, 3.03477079e-01f, 4.98242587e-01f, 1.46179125e-01f, -1.71327516e-01f, 3.75236496e-02f, 2.44106576e-01f,
  4.26746309e-01f, 2.23341342e-02f, 1.34989038e-01f, 2.11021736e-01f, 1.80391684e-01f, -1.02983415e-01f, -2.81657100e-01f, -4.94554102e-01f, -2.08580315e-01f, 4.20931727e-01f,
  2.97448665e-01f, 3.74449074e-01f, -2.30578437e-01f, 3.97778958e-01f, -2.41037190e-01f, 6.21850379e-02f, -2.29561612e-01f, 1.42881081e-01f, -1.23732850e-01f, -4.09542136e-02f,
  5.46423309e-02f, 2.23599523e-01f, -5.73123954e-02f, 3.56334224e-02f, -9.95939001e-02f, 5.19243002e-01f, -4.35580760e-01f, 4.60929543e-01f, 2.56310523e-01f, 1.67569533e-01f,
  3.35629493e-01f, -8.53570402e-02f, 2.95223534e-01f, 2.66268134e-01f, 3.36377978e-01f, 2.08655164e-01f, 1.66325137e-01f, -3.37827742e-01f, -8.66379887e-02f, 7.87260234e-02f,
  2.60014743e-01f, -1.64705813e-01f, -2.55138934e-01f, 3.29013437e-01f, 1.29542649e-01f, -9.17498842e-02f, 2.37475857e-01f, 4.26246971e-02f, 6.57880902e-02f, 3.55033785e-01f,
  5.68685651e-01f, 1.65177047e-01f, 1.35147991e-02f, 2.16711745e-01f, 2.25912482e-01f, 6.89617218e-03f, 5.36747947e-02f, -3.44891310e-01f, 5.06667614e-01f, -1.76615179e-01f,
  -5.36235161e-02f, -2.42808498e-02f, -1.07896157e-01f, -1.18982166e-01f, -1.97672583e-02f, -2.53187548e-02f, 1.21466175e-01f, 1.44358635e-01f, 1.49129152e-01f, 1.32145688e-01f,
  -9.66576487e-02f, -6.15447611e-02f, -9.95725393e-02f, -4.26753908e-02f, 7.88435247e-03f, 2.12576780e-02f, -9.01695117e-02f, 1.32286519e-01f, -1.37378529e-01f, 1.13276213e-01f,
  -1.05244823e-01f, -1.36489749e-01f, 1.31688029e-01f, -1.44266367e-01f, -4.17954735e-02f, 1.24454170e-01f, -1.22063003e-01f, 1.33963913e-01f, -1.72548980e-01f, 1.73079029e-01f,
  -1.42170608e-01f, -7.19808638e-02f, 2.05985934e-01f, -8.92914832e-02f, 2.39395365e-01f, -1.13641107e-02f, 3.92228663e-02f, 1.79231808e-01f, 2.10591048e-01f, 3.87124941e-02f,
  -8.92079994e-02f, 4.69468869e-02f, 1.78155646e-01f, 1.95350051e-01f, 1.03681743e-01f, -6.30605102e-01f, 3.98873657e-01f, -4.41802204e-01f, 6.42826438e-01f, 1.89446256e-01f,
  5.33538699e-01f, 1.93705648e-01f, 3.37083161e-01f, 4.00870383e-01f, 1.60297509e-02f, -1.15929566e-01f, 1.55735640e-02f, -2.44208708e-01f, 1.04370937e-01f, 1.12044334e-01f,
  -3.05484328e-02f, -5.36381733e-03f, 5.87095261e-01f, 2.37608433e-01f, 1.22619487e-01f, -2.01105028e-01f, 1.54734194e-01f, 1.25347733e-01f, 2.87027359e-02f, 6.25603646e-02f,
  -5.80254495e-02f, 1.23521484e-01f, -1.96754545e-01f, -1.00477040e-02f, -2.64211357e-01f, -5.64431772e-02f, -2.43623704e-01f, 2.05461055e-01f, 6.61640167e-02f, -1.13864541e-02f,
  6.83066919e-02f, 9.92979482e-02f, 1.52141064e-01f, 3.80735770e-02f, -9.07081962e-02f, 1.24681912e-01f, 1.49911344e-01f, 1.14058189e-01f, 1.43212408e-01f, 2.09755138e-01f,
  1.40804145e-02f, -9.16663930e-02f, -1.17939606e-01f, 1.93352848e-01f, 1.68208167e-01f, -2.19186127e-01f, -8.27198476e-02f, -3.87710868e-03f, 1.16589665e-01f, -1.12668842e-01f,
  -1.27919525e-01f, -1.85557708e-01f, -1.30005091e-01f, -2.52696648e-02f, 1.58109382e-01f, 1.95114478e-01f, 4.50465307e-02f, 6.57160580e-02f, -1.30009472e-01f, -1.20831139e-01f,
  -4.37817909e-03f, 1.52281225e-01f, 1.62956491e-01f, 6.84966519e-02f, 8.43138769e-02f, 8.87795165e-02f, 1.38361216e-01f, -1.06916197e-01f, -1.66166387e-02f, -1.95207745e-02f,
  -1.41741812e-01f, -1.52783051e-01f, 1.93230689e-01f, 2.84127057e-01f, -2.03652307e-02f, 1.49990723e-01f, -1.24454245e-01f, 3.84679846e-02f, 1.29400432e-01f, 1.82168275e-01f,
  -5.64673245e-02f, -9.09212381e-02f, -1.50234446e-01f, 5.48558794e-02f, -8.65086466e-02f, 1.17179021e-01f, 2.81711053e-02f, 4.83890586e-02f, 1.48141906e-01f, -8.86928067e-02f,
  4.67905365e-02f, -8.71962234e-02f, 1.02849118e-01f, 4.54393476e-02f, -1.70520365e-01f, -1.41155452e-01f, -1.11123338e-01f, 1.52575999e-01f, 1.06479421e-01f, 1.30621091e-01f,
  -5.60821705e-02f, 4.51208130e-02f, 6.39868304e-02f, 2.17077136e-02f, 1.89010039e-01f, 1.45835012e-01f, 3.35869864e-02f, 1.76951662e-01f, -4.32280637e-02f, -1.21432031e-03f,
  4.25474942e-02f, -1.13733009e-01f, 2.68065125e-01f, 1.85036108e-01f, 2.94266582e-01f, -1.90410614e-02f, -7.13709444e-02f, 4.59061041e-02f, 2.96461463e-01f, 1.84387654e-01f,
  2.15154186e-01f, -1.33193716e-01f, 2.80980229e-01f, -2.05847353e-01f, -1.16798338e-02f, -4.30496074e-02f, 4.32272851e-02f, 3.04866105e-01f, 2.22998381e-01f, -1.18252210e-01f,
  1.61082074e-01f, -9.29318517e-02f, 2.45858192e-01f, 1.24883428e-01f, -2.51928009e-02f, -1.23080030e-01f, -2.13220567e-02f, 1.57673955e-01f, -2.43520532e-02f, -3.96969430e-02f,
  4.04079229e-01f, 2.95656204e-01f, 1.55576825e-01f, 6.78716823e-02f, -1.47403225e-01f, 1.68513745e-01f, 8.26102272e-02f, -1.77444488e-01f, 2.24581242e-01f, -2.18387693e-01f,
  -3.05549670e-02f, 1.37796432e-01f, 1.00199923e-01f, -1.48670390e-01f, -2.24413827e-01f, 6.86751306e-02f, 2.52725810e-01f, -8.49100426e-02f, 2.03860521e-01f, 7.13147819e-02f,
  1.37519762e-01f, 1.37636006e-01f, 1.53284684e-01f, -1.47531880e-02f, -6.29690364e-02f, -8.87592807e-02f, -1.02623798e-01f, -1.04293749e-01f, 2.31341273e-01f, 1.72603518e-01f,
  -1.33205339e-01f, 2.29645878e-01f, 1.48185000e-01f, 2.09439285e-02f, -5.49148321e-02f, -1.70594096e-01f, 3.04879218e-01f, 2.46997997e-01f, 1.76214650e-01f, 2.47579977e-01f,
  3.77126604e-01f, 4.02448177e-01f, 2.18173951e-01f, 1.02918074e-01f, -9.87218916e-02f, -5.21411419e-01f, -2.34621074e-02f, 4.54920739e-01f, 1.87579766e-01f, 3.77041370e-01f,
  -1.05680756e-01f, 5.20004094e-01f, -1.57332331e-01f, -1.19757717e-02f, -1.41205817e-01f, -5.63100986e-02f, 4.23609555e-01f, -6.62879124e-02f, 2.45078862e-01f, 1.08113907e-01f,
  -6.73593506e-02f, -2.92313159e-01f, 7.66325817e-02f, 2.14979649e-01f, -9.49054584e-02f, 2.00557813e-01f, 2.81578541e-01f, -3.71040478e-02f, 7.60582536e-02f, -3.44358273e-02f,
  3.17383409e-02f, 7.22543895e-02f, 1.87402233e-01f, 2.80193299e-01f, -4.07997906e-01f, -1.55497521e-01f, -3.88335407e-01f, 1.10982984e-01f, -9.00066420e-02f, 2.67571092e-01f,
  4.40490507e-02f, 3.36067200e-01f, 3.87931257e-01f, -2.92272389e-01f, -8.57733861e-02f, 9.13631229e-04f, -1.00112259e-01f, 5.18813908e-01f, 2.66703874e-01f, 1.07972160e-01f,
  3.31661701e-01f, 2.96713978e-01f, 1.55782029e-01f, -1.36578187e-01f, 1.89523146e-01f, -2.08362024e-02f, 6.31215125e-02f, -3.57553810e-01f, -1.61868080e-01f, 1.96333397e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.36841008e-01f, -1.40169606e-01f, 7.74121806e-02f, -5.04066683e-02f, -9.15648937e-02f, -6.75960332e-02f, 1.01451859e-01f, -2.94023938e-02f, 3.86889488e-01f, 2.08325103e-01f,
  4.13850024e-02f, 1.56645179e-01f, 2.73324281e-01f, 9.70323849e-03f, -1.42521234e-02f, 4.41577211e-02f, 6.64803162e-02f, -5.07475473e-02f, 2.68327653e-01f, 1.93890885e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.28328145e-01f, 2.12845013e-01f, -4.14574780e-02f, 3.90013196e-02f, -1.94049165e-01f, -1.38431668e-01f, 2.50374973e-01f, -5.61089590e-02f, 9.73631162e-03f, -7.06903497e-03f,
  1.73193559e-01f, 3.78143750e-02f, -7.66004473e-02f, 4.51759063e-02f, 4.79479916e-02f, -1.27496272e-01f, -1.22366868e-01f, -1.25627115e-01f, -1.47630185e-01f, 1.19067565e-01f,
  -2.05760852e-01f, 2.29311779e-01f, -1.51952565e-01f, 2.55971849e-02f, 6.04248270e-02f, 1.61500007e-01f, -1.49785295e-01f, -2.15483487e-01f, 6.25707358e-02f, 5.20452559e-02f,
  9.66188461e-02f, 1.10933453e-01f, 2.29305834e-01f, 1.78256840e-01f, 1.21796936e-01f, -1.01587810e-01f, 3.32427531e-01f, -4.96381558e-02f, 2.76477516e-01f, -8.54776576e-02f,
  5.21844625e-02f, -3.40863317e-02f, -2.65239570e-02f, -8.79724547e-02f, -1.15255632e-01f, -7.46049685e-03f, 1.86982229e-01f, -5.89787252e-02f, 8.28392804e-02f, -3.62436324e-02f,
  1.50814250e-01f, -8.95571783e-02f, -6.85715824e-02f, -1.87428609e-01f, 3.22380185e-01f, 7.27661848e-02f, -1.96250230e-01f, 1.94601640e-02f, -1.09713905e-01f, -6.61926940e-02f,
  5.35834255e-03f, 1.63638219e-02f, 1.16294309e-01f, 1.13267012e-01f, 1.55135971e-02f, 2.20162898e-01f, 2.09607482e-01f, 1.64158922e-02f, 2.16651827e-01f, 1.47712797e-01f,
  1.37129232e-01f, 3.21716458e-01f, -1.41666844e-01f, 6.18186295e-02f, -2.78609358e-02f, -1.70443267e-01f, -6.28908575e-02f, 5.96101433e-02f, -1.05005708e-02f, -2.77598053e-01f,
  -3.65502834e-02f, 7.56571442e-02f, 2.43601918e-01f, -5.73397335e-03f, 3.32830638e-01f, 7.39616752e-02f, 6.58051670e-02f, 8.51090699e-02f, -8.44606832e-02f, 1.15074232e-01f,
  -1.81307748e-01f, -6.29010573e-02f, 4.62120846e-02f, 1.34767704e-02f, 1.04875289e-01f, -1.54379979e-01f, 5.98117784e-02f, 6.35722280e-02f, -8.55776593e-02f, 1.97547272e-01f,
  2.98999250e-02f, 1.11468546e-01f, 7.13472292e-02f, 2.11852834e-01f, -1.99580044e-02f, -1.46370083e-01f, -2.19054163e-01f, -7.53824413e-02f, 2.99827158e-02f, 7.77723491e-02f,
  -2.20077053e-01f, -1.61188811e-01f, 9.19194147e-02f, -2.08518848e-01f, 3.35822821e-01f, -4.09235023e-02f, 2.85074860e-01f, -1.03608966e-01f, 2.59078532e-01f, -1.06021740e-01f,
  -1.72364876e-01f, 1.52671903e-01f, 1.16734896e-02f, 3.68557833e-02f, -5.39717972e-02f, -1.97924823e-01f, 1.05511032e-01f, -9.73588005e-02f, -1.59378618e-01f, 1.36333659e-01f,
  1.44364759e-01f, -6.24186471e-02f, -1.39689550e-01f, 6.44728765e-02f, 2.47723833e-02f, 1.46941632e-01f, 2.22302452e-01f, 1.46904975e-01f, -2.81841308e-01f, -1.18736140e-01f,
  2.02711374e-01f, -1.58003613e-01f, -1.01187967e-01f, -1.86751748e-03f, 1.49270678e-02f, 8.24645534e-02f, -1.06931536e-03f, 9.73126441e-02f, 9.70968381e-02f, 2.97792226e-01f,
  -1.19712502e-01f, -1.22764751e-01f, -2.39777595e-01f, -9.93284807e-02f, -2.09078640e-01f, -1.28647566e-01f, 2.06191465e-01f, -9.30145383e-02f, 2.42516384e-01f, -1.02773331e-01f,
  4.77164276e-02f, 2.23657608e-01f, -7.11542889e-02f, 5.66411614e-02f, 1.33044308e-03f, 2.24094409e-02f, -4.49123420e-02f, -2.68996060e-01f, -1.04587995e-01f, 1.30299151e-01f,
  -8.28448236e-02f, -1.44771308e-01f, 2.50711329e-02f, 7.99277201e-02f, 3.41773957e-01f, 9.78933349e-02f, 1.20674945e-01f, -1.25373766e-01f, 8.07377920e-02f, 3.45640555e-02f,
  -2.06084520e-01f, -9.14595574e-02f, 1.60667315e-01f, -1.03822812e-01f, -1.01782314e-01f, 1.14035189e-01f, -1.26374081e-01f, -1.21795110e-01f, -1.06763452e-01f, -1.67813987e-01f,
  1.62349224e-01f, 1.63375698e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  9.90247205e-02f, 1.71521455e-01f, 7.88391829e-02f, 2.09971935e-01f, 1.42137244e-01f, -3.87727283e-02f, 3.80007982e-01f, -8.35042447e-02f, 3.13197464e-01f, 1.16881058e-01f,
  8.09888244e-02f, 1.22063551e-02f, 1.17408358e-01f, 4.45037037e-02f, 4.71841365e-01f, 3.97880673e-01f, -1.25523478e-01f, 2.80369133e-01f, -2.40826175e-01f, 2.04101787e-03f,
  1.21152870e-01f, 8.15525770e-01f, -1.28553540e-01f, 2.66625211e-02f, -2.99533695e-01f, 2.93981377e-02f, -1.08569704e-01f, -1.00196093e-01f, -1.09599620e-01f, 2.12093703e-02f,
  6.32474124e-01f, 4.17186797e-01f, -4.00388949e-02f, -6.47413880e-02f, -2.74367668e-02f, 2.94268411e-02f, -1.84200361e-01f, -1.13194913e-01f, 3.47224809e-02f, -1.07601330e-01f,
  2.28679925e-03f, -1.08658031e-01f, 1.40570313e-01f, -1.10480189e-01f, 1.36097819e-01f, -3.39137986e-02f, -7.50607848e-02f, 1.07925028e-01f, 9.37737972e-02f, -7.00602606e-02f,
  -1.19732700e-01f, -9.05171931e-02f, 4.46472038e-03f, -1.51118189e-01f, -4.86980453e-02f, -1.51112497e-01f, 4.41314951e-02f, 4.25062329e-02f, -1.29377097e-02f, 1.34445215e-03f,
  -1.69128031e-01f, -3.64035331e-02f, -9.68254134e-02f, 1.18070282e-02f, 4.42793779e-02f, -1.59376115e-01f, -1.65349454e-01f, -1.45089611e-01f, -1.47810519e-01f, 1.25781983e-01f,
  7.60816708e-02f, 1.86377853e-01f, -4.83810045e-02f, -9.35028773e-03f, 1.53536471e-02f, 8.11542124e-02f, -3.72916870e-02f, 1.53705686e-01f, 1.77382100e-02f, -6.33421317e-02f,
  4.30542044e-02f, -7.16334507e-02f, -1.60432667e-01f, -2.27637371e-04f, -1.71357378e-01f, 1.29937395e-01f, 1.04661308e-01f, -2.75283009e-02f, 3.63585316e-02f, 1.13298986e-02f,
  7.70983994e-02f, -1.44889593e-01f, -1.70554101e-01f, -1.24648653e-01f, -3.03418059e-02f, 1.92058776e-02f, 9.38136727e-02f, -1.90803513e-01f, 9.59289223e-02f, -6.40980303e-02f,
  -1.75017744e-01f, -9.61067826e-02f, 2.23058417e-01f, -1.31068677e-01f, -5.16190492e-02f, -1.39686242e-01f, -6.76784813e-02f, 5.79432845e-02f, 2.13541716e-01f, -1.12702034e-01f,
  1.86577752e-01f, 3.63659590e-01f, 8.01564306e-02f, 3.27508777e-01f, -2.79228479e-01f, 1.11371338e-01f, 2.04635307e-01f, 5.09739339e-01f, -8.83989409e-02f, 1.63946152e-01f,
  -7.41247237e-02f, 1.04745030e-01f, 2.00902343e-01f, 2.43038252e-01f, -1.66239709e-01f, 2.72316694e-01f, 3.17590564e-01f, 2.97490716e-01f, 1.18240155e-01f, 2.96383381e-01f,
  2.21346930e-01f, 2.16551334e-01f, 2.20317855e-01f, -1.45658344e-01f, 3.60125422e-01f, -2.01077700e-01f, 3.01812161e-02f, 2.99579382e-01f, 1.59500837e-01f, -2.45184854e-01f,
  1.97977304e-01f, -2.80318409e-02f, 3.28329563e-01f, 2.92723268e-01f, 1.95565373e-02f, -4.21938747e-02f, -2.46369746e-02f, -2.59251129e-02f, -2.95113325e-01f, 1.63328990e-01f,
  4.44159567e-01f, -1.77176371e-01f, -1.86727345e-01f, 2.12672040e-01f, 1.15812365e-02f, -2.63992827e-02f, 6.27929494e-02f, -9.84845608e-02f, 4.03773189e-01f, 4.61539090e-01f,
  6.50456071e-01f, 2.81783909e-01f, 2.47048989e-01f, 3.25543806e-02f, 2.10487187e-01f, 1.15113869e-01f, 6.90374076e-02f, 2.24002138e-01f, -3.72957051e-01f, 6.37817681e-02f,
  1.32467106e-01f, -6.47194684e-02f, -1.25805765e-01f, 7.46288225e-02f, 3.21615756e-01f, 5.11687219e-01f, 9.94259790e-02f, -1.42428637e-01f, 5.39983392e-01f, 9.44309980e-02f,
  -1.75310776e-01f, -2.82509476e-01f, 5.39370477e-01f, -7.15494677e-02f, 8.72813344e-01f, -9.73202437e-02f, -3.96764465e-02f, -4.23497297e-02f, 2.61698455e-01f, 8.83865878e-02f,
  1.91474743e-02f, -2.55216081e-02f, 4.33943905e-02f, 1.02648353e-02f, 8.42089877e-02f, -1.49208933e-01f, 7.07961735e-04f, -1.69318274e-01f, -6.88666627e-02f, -1.03217736e-01f,
  -4.54252660e-02f, 1.22579694e-01f, -2.87132859e-02f, -7.51619712e-02f, 7.00458884e-02f, 9.79517773e-03f, 1.65094599e-01f, -1.66940913e-01f, 8.48017260e-02f, -1.94158703e-02f,
  3.82923603e-01f, 1.78411882e-02f, 1.57136291e-01f, -4.98007238e-02f, 2.13174313e-01f, -1.18993893e-02f, 2.16381386e-01f, -1.85167894e-01f, -1.67924047e-01f, -1.38189942e-01f,
  2.35598743e-01f, -2.31454410e-02f, 7.23085552e-02f, 5.46196364e-02f, 1.85072292e-02f, -1.20778956e-01f, 2.12277859e-01f, 1.15293242e-01f, -1.14307523e-01f, 6.82185143e-02f,
  1.03118636e-01f, 3.29805352e-02f, -1.41276419e-01f, 1.18553355e-01f, 1.66126236e-01f, 6.27505407e-02f, -1.59679726e-02f, 1.26785144e-01f, 2.66892195e-01f, -6.73375130e-02f,
  7.89800808e-02f, 1.03568574e-02f, 3.00978065e-01f, -1.22396365e-01f, -8.52035508e-02f, -1.59591556e-01f, 4.53893781e-01f, 1.03245273e-01f, 3.20346981e-01f, 1.45878375e-01f,
  4.71442938e-02f, 9.55410376e-02f, -7.72976950e-02f, -4.74000089e-02f, -1.64932102e-01f, 3.86103183e-01f, 1.07254721e-02f, 3.10559850e-02f, -7.12694898e-02f, 2.89189047e-03f,
  -2.31188778e-02f, 1.19650634e-02f, 1.67734638e-01f, 2.87459362e-02f, -1.84419509e-02f, 1.60495180e-03f, 1.20470144e-01f, -7.68081397e-02f, 9.77941900e-02f, 8.16476643e-02f,
  -7.86504596e-02f, -1.76163360e-01f, -8.58267024e-02f, -9.77936015e-02f, 1.62813604e-01f, -1.56125650e-02f, -7.59977177e-02f, 1.42539993e-01f, -2.24861242e-02f, -5.06930761e-02f,
  -1.44420862e-01f, 1.83205158e-02f, 6.94689993e-03f, -1.47142589e-01f, 6.63392022e-02f, 1.01723917e-01f, -9.18538645e-02f, -1.03246281e-02f, 2.11661875e-01f, 3.70799690e-01f,
  1.06377371e-01f, 8.44705254e-02f, 3.23062807e-01f, 3.15372646e-01f, -4.26902920e-02f, -2.36493424e-01f, -7.35775679e-02f, -2.11678326e-01f, 1.28159732e-01f, 1.64674118e-01f,
  -1.41598284e-01f, 6.54578507e-02f, -2.68722717e-02f, 3.72734606e-01f, 1.53976917e-01f, 1.25017822e-01f, 1.45330742e-01f, -1.36962518e-01f, 1.22085586e-01f, -2.41261661e-01f,
  4.46869619e-02f, 1.15161590e-01f, 7.58873284e-01f, -3.43723372e-02f, -2.94148754e-02f, 4.48480882e-02f, 1.49352849e-01f, 2.77393371e-01f, -2.84271330e-01f, -3.69507633e-02f,
  7.74304196e-02f, 2.72992879e-01f, -4.86453734e-02f, 6.95172250e-02f, 1.67996556e-01f, 2.78079987e-01f, 9.84147377e-03f, -3.56458686e-02f, -2.40518808e-01f, -1.48356095e-01f,
  2.72757858e-02f, -4.23996560e-02f, -3.30853425e-02f, -2.01412085e-02f, -2.83869728e-03f, 2.98491687e-01f, 8.92892331e-02f, -1.49801418e-01f, 1.77857757e-01f, 5.97470701e-02f,
  -1.24934621e-01f, -3.62366021e-01f, 2.62063533e-01f, 9.48696863e-03f, 7.96906471e-01f, -7.66943395e-02f, 2.55244989e-02f, 3.44516262e-02f, 2.56192744e-01f, 2.01353937e-01f,
  -3.72937173e-01f, -6.06363900e-02f, -1.07841492e-01f, 4.19861048e-01f, 2.89022505e-01f, 9.03164148e-02f, 4.30599272e-01f, -1.32172257e-01f, 3.84106338e-01f, -5.11109948e-01f,
  3.31962943e-01f, 3.85825306e-01f, 2.34844506e-01f, -3.05708528e-01f, 1.82990745e-01f, 7.79521689e-02f, 7.89263010e-01f, 1.97478786e-01f, -1.59447730e-01f, -1.23660669e-01f,
  1.08354628e-01f, -1.66798130e-01f, -2.92093724e-01f, 3.30572933e-01f, 4.03084964e-01f, -1.69805989e-01f, -1.27911463e-01f, 3.04810137e-01f, -1.47408158e-01f, -1.60845518e-01f,
  -2.70731956e-01f, -6.74275979e-02f, 3.57952058e-01f, 6.69043958e-01f, 9.50190797e-02f, 2.42764816e-01f, 1.38729334e-01f, 1.94726974e-01f, -5.97757362e-02f, 1.73367754e-01f,
  -6.14547729e-02f, 3.89875203e-01f, 1.26097590e-01f, 8.01854581e-02f, -7.09458217e-02f, -7.00042248e-02f, 2.69125372e-01f, 6.56961799e-02f, -2.18104683e-02f, -3.09465170e-01f,
  -1.20630085e-01f, -7.19530806e-02f, 1.12154782e-01f, -6.53040782e-03f, 1.17163040e-01f, 2.77727872e-01f, 1.93489581e-01f, 1.35053158e-01f, -9.05626863e-02f, 1.40744090e-01f,
  -2.75589764e-01f, -4.68757190e-02f, -3.97148207e-02f, -3.22142541e-01f, 4.38443482e-01f, 5.87726571e-02f, 2.18302295e-01f, -1.13319121e-01f, 1.06960826e-01f, -4.49864380e-02f,
  -8.64187777e-02f, -1.53811008e-01f, -1.91743851e-01f, 8.50609839e-02f, -1.96877927e-01f, -1.71413377e-01f, 3.94823477e-02f, -4.46652174e-02f, 1.16912000e-01f, 1.21298872e-01f,
  1.91057175e-02f, 2.49340266e-01f, -5.01541682e-02f, 8.86480436e-02f, -2.88345873e-01f, -1.55826151e-01f, 2.40680456e-01f, 2.44557127e-01f, -2.24208847e-01f, -1.21414490e-01f,
  9.44120139e-02f, -2.07823873e-01f, -8.03860351e-02f, 6.39183670e-02f, 2.10097462e-01f, 1.00202128e-01f, 2.69547433e-01f, -2.92888403e-01f, 8.06495994e-02f, -1.22108907e-01f,
  4.71954823e-01f, 1.88503534e-01f, 2.40217343e-01f, 3.15124810e-01f, -2.05606863e-01f, 3.42054248e-01f, -2.17715427e-01f, -3.83211337e-02f, -2.81779498e-01f, -4.47676703e-02f,
  1.64497331e-01f, -3.04891523e-02f, -1.75055966e-01f, -3.67349774e-01f, 1.38770401e-01f, -2.72032261e-01f, 7.10032880e-01f, 5.87323122e-02f, 6.47162199e-01f, -1.36787429e-01f,
  5.64456940e-01f, -2.08304152e-01f, 1.16107464e-01f, 6.73162490e-02f, -9.57188308e-02f, -1.39539912e-01f, 5.85273564e-01f, -3.19077015e-01f, 4.39369619e-01f, -1.94633558e-01f,
  2.56049573e-01f, -3.65664124e-01f, 3.96952569e-01f, 1.15695849e-01f, -1.59399122e-01f, 3.79974395e-02f, -4.17354763e-01f, 6.89523280e-01f, -6.93893209e-02f, -1.57625809e-01f,
  -3.87079060e-01f, -3.02075129e-02f, 2.99535692e-01f, 1.42212033e-01f, -3.02196801e-01f, 2.15383783e-01f, 8.24658945e-02f, 2.52876997e-01f, 3.68593127e-01f, -1.38085082e-01f,
  1.02877879e+00f, 3.73651683e-01f, 9.36914012e-02f, 1.81574509e-01f, 2.82263547e-01f, -2.93201655e-01f, -7.88821578e-02f, -9.16766673e-02f, 3.16152930e-01f, 4.59580533e-02f,
  1.40758276e-01f, -4.28716242e-01f, -1.08654790e-01f, -2.42841259e-01f, -1.37701392e-01f, -1.11951567e-01f, -1.16015255e-01f, -1.74273923e-01f, 5.13349436e-02f, -1.21495746e-01f,
  3.92497936e-03f, 1.45935521e-01f, -5.82104325e-02f, -6.59886524e-02f, -4.34819087e-02f, 1.19902253e-01f, 2.01818675e-01f, 6.02168888e-02f, 1.10570729e-01f, -1.69543520e-01f,
  7.70795345e-02f, 7.90542364e-02f, -2.00402990e-01f, -1.32884338e-01f, 2.28115823e-02f, -1.78863719e-01f, -3.31987962e-02f, 8.75814632e-03f, -1.04870282e-01f, -1.15258366e-01f,
  1.23222813e-01f, -3.58936004e-02f, -1.44226506e-01f, 1.36574104e-01f, -1.32080495e-01f, -1.68514594e-01f, -9.24855098e-02f, 1.61348525e-02f, -3.14433388e-02f, 9.82764526e-04f,
  1.47175536e-01f, 2.37162244e-02f, 4.04229313e-02f, 2.24752463e-02f, 2.51055919e-02f, 1.15674585e-01f, 1.27971321e-01f, 3.07931285e-02f, 2.21615881e-01f, 9.48430374e-02f,
  7.98286051e-02f, 1.60735101e-01f, -5.58710396e-02f, 1.64684296e-01f, -8.46171901e-02f, 4.09030961e-03f, -4.77963127e-02f, -1.04937561e-01f, 2.83474401e-02f, -1.17561325e-01f,
  -1.18167683e-01f, -1.04794271e-01f, -1.65922493e-01f, -1.66795328e-01f, -1.65587366e-02f, -3.03406245e-03f, 6.15956001e-02f, -1.54038042e-01f, 1.59082130e-01f, 2.31527146e-02f,
  3.51530761e-02f, -3.66808325e-02f, 9.62458029e-02f, -4.89323922e-02f, 5.42458787e-04f, -2.20027447e-01f, -3.17677230e-01f, -3.90833020e-02f, 3.56912374e-01f, 7.47461915e-02f,
  -1.31639078e-01f, 2.61436433e-01f, 1.34302108e-02f, 3.07147771e-01f, -2.74883062e-01f, -1.39384314e-01f, 2.06541926e-01f, 5.56113362e-01f, -4.19388324e-01f, -1.09252304e-01f,
  5.86900264e-02f, 8.59382078e-02f, 1.69101432e-01f, 6.73766062e-02f, 3.56695950e-01f, 2.16219917e-01f, 6.01184726e-01f, -2.73641050e-01f, 1.78648084e-02f, 3.13506015e-02f,
  -8.95890296e-02f, -5.18590510e-02f, -1.64802581e-01f, 5.79697564e-02f, 4.74741943e-02f, 1.53921038e-01f, 1.24047972e-01f, 4.96970080e-02f, -1.83146477e-01f, 6.51377141e-02f,
  8.17878693e-02f, -9.40559879e-02f, -4.32237647e-02f, -9.00966823e-02f, -1.59512818e-01f, 1.09616898e-01f, 5.66637367e-02f, 1.25203207e-01f, 1.55157357e-01f, 3.17330539e-01f,
  -6.56240508e-02f, 1.93511143e-01f, -1.83676794e-01f, -2.41956562e-02f, -8.63141567e-03f, -1.61596879e-01f, 1.11470230e-01f, -1.00246437e-01f, 2.25811750e-01f, -9.32574570e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  1.16557740e-01f, -1.00564376e-01f, -5.56992404e-02f, -3.87422368e-02f, 1.76541060e-01f, 1.03096738e-01f, -1.51751176e-01f, 3.35561745e-02f, -1.62254542e-01f, 1.61290213e-01f,
  -1.98259274e-03f, 3.55412364e-01f, 1.50792584e-01f, 4.55121025e-02f, 2.93899357e-01f, 2.96989709e-01f, 6.70883134e-02f, 8.69667158e-04f, 5.00034727e-02f, -1.30865440e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.45275398e-02f, 4.56899889e-02f, 8.79512504e-02f, -5.66675104e-02f, 1.34204194e-01f, 1.62777454e-01f, -1.51983753e-01f, -2.31046647e-01f, -2.14798868e-01f, -1.88643098e-01f,
  -1.52640149e-01f, -3.26800346e-01f, -3.40892702e-01f, -9.58172157e-02f, 7.44315982e-02f, -2.94238865e-01f, -7.11526632e-01f, 2.52269506e-01f, -1.25033811e-01f, -3.00060898e-01f,
  -1.57228678e-01f, 6.46729112e-01f, 6.88862801e-01f, -6.81401849e-01f, -6.55991882e-02f, 1.85512066e-01f, -9.59468931e-02f, 3.49311620e-01f, -1.14911586e-01f, 1.62891269e-01f,
  3.55030410e-02f, -6.21364601e-02f, 4.65520993e-02f, -2.80549556e-01f, 2.07540974e-01f, 1.02981336e-01f, -2.09423095e-01f, -2.46865779e-01f, -1.86874837e-01f, -1.00824527e-01f,
  1.81887552e-01f, -1.76039711e-01f, 4.26919669e-01f, -3.67980093e-01f, -2.34343946e-01f, -2.05633324e-02f, -1.39206812e-01f, 4.60281074e-01f, -4.20742840e-01f, -5.53901136e-01f,
  1.10389583e-01f, -2.85335243e-01f, 7.80913159e-02f, -7.64326453e-02f, -3.20028096e-01f, -7.11862624e-01f, -3.64851356e-01f, 4.46259618e-01f, -1.31073194e-02f, 7.24996090e-01f,
  9.33807641e-02f, 1.41150400e-01f, 7.20721364e-01f, -9.97905340e-03f, 1.45854726e-01f, -6.95416424e-03f, -1.33710161e-01f, 2.19714537e-01f, -1.89441461e-02f, 1.47205725e-01f,
  -5.98330013e-02f, 2.41342679e-01f, 1.94140859e-02f, 9.05792974e-03f, 3.16761672e-01f, 2.42884666e-01f, 1.10148929e-01f, 1.11575060e-01f, -1.18357815e-01f, 5.12269652e-03f,
  1.67391166e-01f, 3.98381352e-01f, 1.80786893e-01f, -3.01208228e-01f, 1.39807701e-01f, -1.29438415e-01f, -2.62536973e-01f, 1.00239828e-01f, 2.39565209e-01f, 3.45025986e-01f,
  4.56278548e-02f, 3.00509274e-01f, 5.54399192e-02f, -2.24289387e-01f, 9.54629928e-02f, 6.94794506e-02f, 1.56386092e-01f, 2.47972757e-01f, -1.07890531e-01f, -2.50592917e-01f,
  -1.31549567e-01f, -1.91240087e-02f, 1.41878560e-01f, -6.59245327e-02f, -2.27938116e-01f, -2.72154629e-01f, -1.71028897e-01f, 2.53539473e-01f, -1.23962529e-01f, 1.53497281e-02f,
  1.31682664e-01f, -7.64205083e-02f, 7.62874931e-02f, 5.37021279e-01f, -1.54549807e-01f, 2.61697710e-01f, 1.38957545e-01f, 5.93025804e-01f, 5.63245714e-01f, 9.43971425e-02f,
  9.63475108e-02f, -2.32390895e-01f, -5.60478210e-01f, -5.30400574e-01f, 1.63070232e-01f, 1.22756034e-01f, -5.01089215e-01f, -1.07955024e-01f, 3.08003556e-02f, 1.63787827e-01f,
  1.32841364e-01f, 3.65886360e-01f, -2.48115789e-02f, 3.84416878e-01f, 4.48274687e-02f, 3.20405066e-01f, 2.50289053e-01f, -1.34742213e-02f, -5.30197263e-01f, 9.39136073e-02f,
  -3.18878800e-01f, -1.48222923e-01f, 1.36294439e-01f, -5.83374575e-02f, 6.74459189e-02f, 5.23990273e-01f, 1.59440801e-01f, 2.17657536e-01f, 5.01871146e-02f, 4.07278687e-01f,
  2.45693207e-01f, -1.24599211e-01f, -2.18681052e-01f, -1.48918733e-01f, 2.55217850e-01f, -6.98198304e-02f, -2.02444028e-02f, 1.15259767e-01f, -2.74179757e-01f, 7.45089129e-02f,
  4.71991114e-02f, 1.11218341e-01f, -2.03076005e-01f, -4.03954759e-02f, 9.08224061e-02f, 3.39217484e-01f, -1.08031824e-01f, -3.74784052e-01f, -1.67403385e-01f, 1.73082426e-01f,
  2.82996237e-01f, -2.27016926e-01f, -2.86160231e-01f, 1.25216782e-01f, 2.96779331e-02f, -4.71807681e-02f, -1.59027651e-01f, 3.30416322e-01f, -2.19537634e-02f, -5.49018942e-02f,
  -1.70229957e-01f, -1.14273302e-01f, -1.09736487e-01f, -6.00297689e-01f, 3.56694460e-01f, -3.01455818e-02f, 4.07734632e-01f, 6.29551709e-01f, -1.67616516e-01f, -4.54916544e-02f,
  3.30999494e-01f, 1.22088172e-01f, 3.87962500e-04f, -1.45619288e-01f, -1.66488085e-02f, 2.30073527e-01f, -2.86401004e-01f, -3.87254536e-01f, -9.63403434e-02f, 3.28546800e-02f,
  1.14090845e-01f, -1.71218202e-01f, 3.24860156e-01f, 1.44275263e-01f, 4.36063141e-01f, -5.80547117e-02f, -8.11609924e-02f, 1.10992961e-01f, 2.60601521e-01f, -3.99974808e-02f,
  4.94037345e-02f, -1.30214747e-02f, 1.58204529e-02f, -2.79388577e-01f, -6.00470603e-01f, 6.53651357e-01f, 2.08628133e-01f, -1.45301372e-01f, -1.97609842e-01f, -1.60387561e-01f,
  -2.38428816e-01f, 1.50591478e-01f, -9.83130485e-02f, 1.12874791e-01f, -4.79061492e-02f, 5.14397658e-02f, -2.95541495e-01f, -4.43152696e-01f, -1.37985304e-01f, -2.24027663e-01f,
  1.11175098e-01f, -1.20632790e-01f, -3.41636211e-01f, -7.92138204e-02f, -2.87449807e-01f, -1.75971419e-01f, 2.81784236e-01f, -1.10361338e-01f, -8.87929350e-02f, 4.05924231e-01f,
  3.81702781e-01f, 1.90937921e-01f, -1.89344790e-02f, 3.90200168e-01f, 1.61641121e-01f, -7.01703876e-02f, -9.67329219e-02f, 5.17475247e-01f, -3.97507638e-01f, -2.12395906e-01f,
  -7.87713349e-01f, -4.36862856e-01f, 3.25819284e-01f, 2.30313361e-01f, -4.69657719e-01f, 3.67539786e-02f, 1.32483229e-01f, -1.65627658e-01f, -3.06490630e-01f, 4.15273346e-02f,
  -2.34329492e-01f, -9.93207619e-02f, 4.26747411e-01f, 1.22711547e-02f, 3.40941995e-02f, 7.61767700e-02f, -1.76292554e-01f, -2.05292210e-01f, 5.96537352e-01f, 1.26365215e-01f,
  -2.27601398e-02f, 4.10798937e-01f, -1.98206436e-02f, -7.83377290e-01f, -2.34565839e-01f, -1.71541989e-01f, -6.34668544e-02f, -5.73487461e-01f, -5.68311363e-02f, -2.36570388e-01f,
  4.88940120e-01f, 1.38310358e-01f, -1.25329271e-01f, 2.11313993e-01f, 4.80981311e-04f, -9.91442576e-02f, 3.56070399e-01f, 4.20239478e-01f, -2.38236785e-02f, -2.02323869e-01f,
  4.48786980e-03f, 1.19981058e-01f, 4.42268759e-01f, -1.35344937e-01f, 7.25825652e-02f, 1.66115031e-01f, 1.54826967e-02f, -3.58655527e-02f, -1.13882951e-01f, 1.11468971e-01f,
  -1.08923212e-01f, 1.32802218e-01f, 4.94527034e-02f, -2.75686860e-01f, 5.17977595e-01f, 3.18279833e-01f, 1.63987800e-01f, 7.76180476e-02f, 8.47948436e-03f, 1.67590767e-01f,
  -1.06618404e-02f, 5.90856314e-01f, 1.99880172e-02f, -2.04690173e-01f, 3.71284723e-01f, -5.66632926e-01f, -2.79019177e-02f, -2.14976758e-01f, -1.31571651e-01f, -2.93774277e-01f,
  -1.97388589e-01f, 1.79892808e-01f, -2.34613329e-01f, -3.44674289e-01f, 4.60416019e-01f, 1.89470425e-01f, -3.80111098e-01f, -1.15150832e-01f, 2.44678825e-01f, 2.74312615e-01f,
  2.81062394e-01f, -2.38268346e-01f, -8.24431062e-01f, 3.23263183e-03f, -1.02430366e-01f, -5.93034565e-01f, -3.68480653e-01f, -1.96957842e-01f, 2.90642112e-01f, 1.47846580e-01f,
  -8.43650550e-02f, -7.73534477e-02f, 1.53903618e-01f, -3.28465790e-01f, 3.55181843e-01f, -2.97372103e-01f, 9.97743428e-01f, 6.90290809e-01f, -1.63775608e-01f, 2.06170306e-02f,
  -4.69110280e-01f, 8.57951641e-02f, 9.29302126e-02f, 1.57421499e-01f, 3.16422507e-02f, 9.02445316e-02f, -1.17119633e-01f, -1.02826372e-01f, 3.22002113e-01f, 5.24739772e-02f,
  -1.19112909e-01f, -1.59127608e-01f, 2.91900188e-01f, 3.02123040e-01f, 6.84420109e-01f, -1.04502261e-01f, -1.69772416e-01f, 1.41918734e-01f, 3.29924107e-01f, -8.56099069e-01f,
  -4.48672652e-01f, -4.07712281e-01f, 3.78353298e-02f, -2.37383187e-01f, -1.56327933e-01f, 7.89907932e-01f, 2.02067554e-01f, -2.48626620e-01f, -7.56130397e-01f, -8.95538807e-01f,
  -6.27517700e-02f, -2.45959740e-02f, 2.19254494e-01f, 1.32749021e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.00499017e-02f, -1.16316453e-01f, -2.15427384e-01f, -7.08774179e-02f, 2.55171239e-01f, 1.09871112e-01f, -8.43148157e-02f, 4.76356177e-03f, -1.72476798e-01f, -2.88661011e-02f,
  -9.20680072e-03f, 1.87322706e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    