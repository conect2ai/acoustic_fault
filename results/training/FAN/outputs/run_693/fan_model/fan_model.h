/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.06043914e-02f, -2.67292649e-01f, 1.11452676e-01f, -1.24726079e-01f, -5.65862581e-02f, 1.10435866e-01f, 1.61380455e-01f, 8.50080550e-02f, -8.57851561e-03f, -2.77281553e-01f,
  -1.35763496e-01f, -1.41741589e-01f, -1.95086300e-02f, -4.15996239e-02f, 5.84143363e-02f, -1.10551059e-01f, 2.18852045e-04f, 1.44356698e-01f, 2.43250132e-01f, -3.34533826e-02f,
  -2.77511299e-01f, 2.52500195e-02f, 5.54764010e-02f, 3.29488218e-02f, -3.97391647e-01f, -2.82348782e-01f, -1.29304767e-01f, -2.51881093e-01f, -1.33614808e-01f, -5.30432940e-01f,
  -2.44711176e-01f, 3.16014178e-02f, 2.43717302e-02f, -1.80455387e-01f, -6.64427653e-02f, -9.30700004e-02f, -3.35321855e-03f, 7.62610277e-03f, -3.63819674e-02f, 2.33701374e-02f,
  -1.58987403e-01f, -5.72613440e-02f, -1.14253664e-03f, -4.98742983e-02f, -5.45598678e-02f, -1.87748950e-02f, -3.42917703e-02f, 2.71600485e-02f, 2.36403346e-02f, -2.15218142e-02f,
  -2.54259020e-01f, -3.24681289e-02f, -1.85097959e-02f, 2.06325483e-02f, 7.71294609e-02f, -6.56084344e-03f, -1.48338869e-01f, -1.34017214e-01f, -1.08557129e-02f, -3.24899852e-01f,
  -2.09430918e-01f, 1.03989787e-01f, 1.25687267e-03f, 2.07562856e-02f, 8.31369616e-05f, -1.21396622e-02f, -1.82657633e-02f, -5.52108437e-02f, 1.09636404e-01f, 2.19000857e-02f,
  4.97323014e-02f, 2.14729160e-02f, 6.33064136e-02f, -3.96718234e-02f, 3.70645300e-02f, 1.05371689e-02f, 4.31049056e-02f, -4.88664210e-02f, -6.35296255e-02f, 7.57742971e-02f,
  4.66915360e-03f, 1.36229489e-02f, 6.07701913e-02f, -3.91293503e-02f, -3.63989584e-02f, 1.18872620e-01f, 4.09184992e-02f, 1.06580518e-01f, 6.40510619e-02f, 7.20064417e-02f,
  1.45718142e-01f, 2.03200579e-01f, -1.49038732e-01f, -7.20323324e-02f, -3.88635397e-02f, -8.89784321e-02f, -1.05320893e-01f, 5.56017738e-03f, 2.04956420e-02f, -3.49667259e-02f,
  3.93378641e-03f, -9.02423859e-02f, -8.28039423e-02f, -2.44932473e-02f, 6.73051104e-02f, -1.01709194e-01f, -1.08353741e-01f, -9.56702903e-02f, -3.55867073e-02f, -1.31505698e-01f,
  -3.97167131e-02f, 9.18386355e-02f, 7.08497390e-02f, 3.22826244e-02f, -7.17720762e-02f, -2.89158970e-02f, 2.98623126e-02f, -1.11423567e-01f, -7.40478933e-03f, -1.07710510e-01f,
  -2.67000739e-02f, -2.00755298e-01f, 5.74060678e-02f, 5.38122281e-02f, -5.32872137e-03f, -2.77508050e-01f, -3.59928429e-01f, -1.81379795e-01f, -4.92541045e-02f, -1.22489460e-01f,
  -3.90745625e-02f, 9.84956324e-02f, 7.90926367e-02f, 2.75759632e-03f, -1.15886956e-01f, -1.66515961e-01f, 6.31446540e-02f, 6.19591586e-02f, 3.39119583e-02f, -1.91441432e-01f,
  -1.27232835e-01f, 6.78596646e-02f, 4.72988486e-02f, -8.02262127e-02f, 8.87257233e-02f, -7.43156746e-02f, 2.50810534e-02f, 7.37303719e-02f, 3.49020958e-02f, 2.53999442e-01f,
  2.11973917e-02f, 4.04541269e-02f, -1.79576695e-01f, -4.73463461e-02f, -2.45448835e-02f, -1.51456729e-01f, -1.69579819e-01f, -9.99113470e-02f, -5.63486479e-02f, -1.16878055e-01f,
  -2.55504996e-02f, -5.50467595e-02f, -5.12269251e-02f, -7.26154000e-02f, -1.59821391e-01f, -7.67324120e-02f, -1.05289795e-01f, -2.39951406e-02f, -5.20560741e-02f, -1.52994767e-01f,
  3.11225653e-02f, -7.97219872e-02f, -8.00327957e-02f, -2.01815307e-01f, 5.86904772e-03f, -3.53203830e-03f, -8.20973366e-02f, -1.17979813e-02f, -1.00376673e-01f, -9.92308855e-02f,
  -1.43774688e-01f, 1.53898261e-02f, 9.96659324e-02f, 4.86792177e-02f, -2.95502366e-03f, 2.48672497e-02f, 1.59132168e-01f, -3.88384354e-03f, 8.66942704e-02f, 1.42583456e-02f,
  6.70850500e-02f, 7.62084275e-02f, 1.32555276e-01f, -1.07730897e-02f, 1.33172378e-01f, 2.05236338e-02f, 2.57317871e-02f, 1.67341232e-02f, 7.63798058e-02f, 1.15678115e-02f,
  1.46853447e-01f, 1.67535454e-01f, 1.03770845e-01f, 9.70712975e-02f, 1.41242132e-01f, 9.50271264e-02f, 1.11109816e-01f, 1.14822611e-01f, 1.88423507e-02f, 1.13118201e-01f,
  -2.31947556e-01f, -9.70493555e-02f, -1.25764295e-01f, -1.18858449e-01f, -1.15874395e-01f, 1.20388949e-02f, -3.35698575e-02f, -7.33891651e-02f, -6.28747120e-02f, -7.96725824e-02f,
  -3.76345180e-02f, -9.39101577e-02f, -1.07978687e-01f, -1.48926586e-01f, -1.14815697e-01f, -1.69993952e-01f, -9.33022872e-02f, -9.61820707e-02f, -8.86079371e-02f, -1.94624335e-01f,
  -1.55959636e-01f, -2.39140749e-01f, -1.40642688e-01f, -2.24855185e-01f, -1.41002283e-01f, -1.08438000e-01f, -1.29178256e-01f, -2.33666003e-01f, -1.72661141e-01f, -3.80483538e-01f,
  7.43411243e-01f, 8.63647088e-02f, 1.16302647e-01f, 5.52090779e-02f, -2.77463943e-01f, -1.12911835e-01f, 7.27722198e-02f, 1.84570625e-01f, -1.96236391e-02f, 1.16197029e-02f,
  -1.70583904e-01f, -2.41261885e-01f, -9.23202559e-02f, -1.06807634e-01f, 1.62193999e-01f, 1.04228429e-01f, -5.78941181e-02f, 1.74320012e-01f, 1.19218700e-01f, -1.17119148e-01f,
  -1.49619490e-01f, 1.90283149e-01f, 2.26866797e-01f, 8.58311653e-02f, -8.34743604e-02f, -1.54134005e-01f, 6.23405650e-02f, 3.75882499e-02f, -1.85754821e-01f, -1.21396482e-01f,
  -1.35577526e-02f, 2.40191191e-01f, -6.97100908e-02f, -4.06443551e-02f, -6.37116805e-02f, 1.58995196e-01f, 2.94803027e-02f, 9.75906104e-02f, 5.78207709e-02f, 6.25678897e-02f,
  -1.91507246e-02f, -4.25787456e-02f, 5.47917560e-04f, 2.56126039e-02f, -8.41071643e-03f, 8.36798325e-02f, 1.02666831e-02f, 1.74112916e-01f, 1.62372634e-01f, -2.56907176e-02f,
  -4.55260314e-02f, -1.04484772e-02f, 5.44109158e-02f, 1.13526821e-01f, -2.84447707e-02f, -7.88623914e-02f, -3.01789287e-02f, -1.93635803e-02f, 7.28067532e-02f, 1.32105067e-01f,
  -3.72929759e-02f, -5.84687665e-03f, -1.03086522e-02f, -3.23831290e-02f, 2.45227572e-02f, -4.63516079e-02f, -1.09242804e-01f, -3.81009206e-02f, -3.99641432e-02f, 8.90138671e-02f,
  -6.57600537e-02f, -2.95672677e-02f, 3.86785902e-02f, 1.18104823e-01f, -7.99766742e-03f, -2.98211128e-02f, 5.15144058e-02f, 3.41729186e-02f, 1.84158962e-02f, 4.32830714e-02f,
  -2.18906906e-02f, -2.62858858e-03f, 5.39738238e-02f, -1.87133402e-02f, 1.38642360e-02f, 1.04765296e-02f, -6.90540951e-03f, -7.36973584e-02f, 7.12317452e-02f, 5.25927655e-02f,
  1.34601757e-01f, -1.77159309e-01f, 5.58693241e-03f, 2.70395391e-02f, 9.34119150e-02f, 1.79771297e-02f, 1.69298553e-03f, -6.98049814e-02f, 5.78413382e-02f, 2.42300816e-02f,
  1.75231025e-02f, 4.70250510e-02f, -2.01062988e-02f, 1.24241635e-02f, -1.40159652e-02f, -4.39989641e-02f, 1.30010648e-02f, -3.33006904e-02f, -3.46473306e-02f, -1.71937123e-02f,
  1.60498768e-02f, 1.40426055e-01f, 9.67561379e-02f, -2.98293941e-02f, -3.87856388e-03f, 2.41850261e-02f, 7.24529251e-02f, 1.43627990e-02f, 1.64554134e-01f, 3.59978676e-01f,
  -2.18056172e-01f, -1.98286384e-01f, -2.25193217e-01f, 1.22047998e-01f, 4.80773337e-02f, -1.24015123e-01f, -2.66848356e-01f, -2.72725970e-02f, 9.77883767e-03f, -2.47127935e-02f,
  -1.01072211e-02f, 3.81622091e-02f, -9.92566273e-02f, -8.62266049e-02f, -2.15087920e-01f, -2.81288952e-01f, -2.35408321e-01f, -1.77276134e-01f, -1.59781918e-01f, 1.45965721e-02f,
  1.81726068e-01f, -1.35525186e-02f, 1.13205295e-02f, 7.60458186e-02f, 1.72980905e-01f, -4.31340113e-02f, -1.10727601e-01f, -7.38865696e-03f, 1.83679946e-02f, 2.41705611e-01f,
  -5.23386188e-02f, 2.71972865e-02f, -4.58204653e-03f, 4.14031483e-02f, 3.54982652e-02f, 7.13646039e-02f, -6.58833459e-02f, 2.85175443e-03f, 6.43489361e-02f, 2.67458502e-02f,
  6.95907697e-02f, 1.12291668e-02f, 7.55189210e-02f, 2.25537121e-02f, 8.80249664e-02f, 4.26669009e-02f, -1.98598998e-03f, -4.95222285e-02f, 3.01860254e-02f, 1.62964147e-02f,
  8.12804773e-02f, 1.25382394e-01f, 1.23243764e-04f, 5.86250005e-03f, -5.97365797e-02f, -6.41792314e-03f, 3.43384929e-02f, 1.16925545e-01f, -6.23452738e-02f, 3.99638005e-02f,
  -2.00165920e-02f, 2.12990330e-03f, 6.08051894e-03f, -4.01634723e-02f, -4.75008190e-02f, -8.17509592e-02f, 7.47625455e-02f, -3.26284058e-02f, -6.57973513e-02f, -1.09431380e-03f,
  3.79442610e-02f, -9.86752566e-03f, 2.90276837e-02f, 4.75136973e-02f, 1.70418937e-02f, 4.79627177e-02f, 1.33648328e-02f, 2.49889586e-02f, 7.08079292e-03f, 5.80030866e-02f,
  -3.14857587e-02f, -1.68811232e-02f, -3.81512498e-03f, 2.77460106e-02f, 2.34981030e-02f, -6.59175441e-02f, 3.10357288e-02f, 5.60927764e-02f, 5.41426837e-02f, 7.59111391e-03f,
  -6.94423243e-02f, -1.51161745e-01f, 8.23194683e-02f, -5.40961605e-03f, -4.41513211e-03f, 4.89197262e-02f, 5.51834814e-02f, 4.83061653e-03f, 5.47006987e-02f, 1.78138837e-02f,
  1.08319391e-02f, -8.06069672e-02f, -2.77795866e-02f, 1.76017184e-03f, -1.82018057e-02f, -6.27595261e-02f, -9.70261395e-02f, 6.40273243e-02f, 8.39722976e-02f, 4.95011099e-02f,
  -1.09602660e-02f, -1.21719018e-01f, -7.91886970e-02f, -3.05395611e-02f, -5.26807271e-02f, -7.86352828e-02f, -1.02139436e-01f, 3.97433452e-02f, -1.33539543e-01f, -1.40808165e-01f,
  1.10444061e-01f, 1.58069432e-01f, -1.30087018e-01f, 1.19539857e-01f, 4.61693481e-02f, 5.81856351e-03f, 1.98152989e-01f, 5.75132892e-02f, 1.69427022e-02f, 1.10393111e-02f,
  -7.81022310e-02f, -1.37579992e-01f, -4.01150100e-02f, -1.82017252e-01f, -2.44235471e-02f, 2.24386547e-02f, 8.28325823e-02f, -9.79279950e-02f, -1.51086152e-01f, -2.32674368e-02f,
  -2.97411717e-02f, 1.79204773e-02f, 1.73790250e-02f, -9.08683091e-02f, 1.39132589e-01f, 1.18288234e-01f, -4.03951928e-02f, 3.60642299e-02f, 9.29293111e-02f, 2.30107471e-01f,
  -3.58588770e-02f, -8.00582170e-02f, -1.19191848e-01f, -3.47275883e-02f, -1.98453441e-01f, -2.84395851e-02f, -1.22818284e-01f, -1.32908195e-01f, -5.68986796e-02f, -7.34420121e-02f,
  -4.26379927e-02f, -3.26399803e-02f, -3.89017761e-02f, -6.72917143e-02f, -3.04971505e-02f, -1.16346508e-01f, -6.48814216e-02f, -1.31875992e-01f, -2.81976853e-02f, -7.33550414e-02f,
  -8.49685892e-02f, 8.41948241e-02f, 2.28172839e-02f, 4.97668274e-02f, -4.87474352e-02f, -1.01445012e-01f, -4.18856032e-02f, 5.04252315e-02f, -3.82095911e-02f, 1.66668132e-01f,
  1.47506937e-01f, -8.12857077e-02f, -7.85235018e-02f, 8.38589221e-02f, 7.89825842e-02f, 3.97364385e-02f, -5.12131453e-02f, -5.74527169e-03f, 8.25549010e-03f, 5.29646538e-02f,
  -3.81031819e-02f, 1.53086074e-02f, 1.65902711e-02f, 2.93305144e-02f, -2.42776219e-02f, 8.43285695e-02f, 1.32503062e-02f, 9.82093662e-02f, -9.54070594e-03f, 1.02863073e-01f,
  -4.02180515e-02f, -3.52019519e-02f, 2.54584178e-02f, -5.91669790e-02f, 1.03550218e-02f, -6.60258979e-02f, 3.30411941e-02f, -8.03703144e-02f, 1.37661947e-02f, -7.16304928e-02f,
  1.02694303e-01f, -3.34645927e-01f, 7.52975121e-02f, 5.34391738e-02f, -8.31465349e-02f, -2.94196494e-02f, -6.08724169e-02f, -7.55264089e-02f, -1.11422434e-01f, 5.56973787e-03f,
  -1.20775156e-01f, 1.55154681e-02f, -1.25289988e-02f, -1.51903719e-01f, -2.30844542e-02f, -2.97198314e-02f, -9.77426469e-02f, -7.73597136e-02f, -5.14609255e-02f, -2.43341606e-02f,
  1.57891437e-02f, 1.00668088e-01f, 1.33844018e-01f, 5.90070486e-02f, 6.29186481e-02f, 1.03235386e-01f, 7.31649250e-02f, 1.72211587e-01f, 1.00742340e-01f, 2.40405679e-01f,
  4.88548338e-01f, 2.54615456e-01f, -1.24362797e-01f, 1.30290598e-01f, 1.21252639e-02f, -6.32250831e-02f, 3.04167625e-02f, -3.84528302e-02f, 6.02692142e-02f, 1.34613276e-01f,
  -2.05391962e-02f, -4.33422960e-02f, -4.23328243e-02f, -7.54879788e-02f, -1.44732624e-01f, 7.14969561e-02f, 6.22664625e-03f, -1.13167502e-01f, -2.82965839e-01f, -2.33947411e-01f,
  2.03247909e-02f, 9.69541296e-02f, 7.11382478e-02f, -2.33771726e-02f, 1.29503384e-01f, -9.94582027e-02f, 4.16092202e-02f, 1.74263194e-02f, -1.26377836e-01f, 2.13555142e-01f,
  -7.73158595e-02f, 1.91300392e-01f, -2.08660454e-01f, 3.95394117e-02f, -1.18545368e-02f, -7.83494934e-02f, -7.10651875e-02f, 4.23304290e-02f, 3.44043523e-02f, -2.81925853e-02f,
  9.12464038e-02f, -8.18243995e-03f, 1.18224882e-01f, -7.89633244e-02f, 4.22558412e-02f, -4.42867279e-02f, 1.83125101e-02f, -2.46212585e-03f, 1.84757020e-02f, -6.92356899e-02f,
  -5.13899233e-03f, 1.05761871e-01f, 7.17700347e-02f, -4.61657457e-02f, -6.75663650e-02f, -8.29091519e-02f, 1.80853475e-02f, -2.72220783e-02f, -1.20353483e-01f, 8.17073584e-02f,
  -1.53481504e-02f, 1.64343007e-02f, -4.72218096e-02f, 3.16362120e-02f, 4.54086550e-02f, -2.90078968e-02f, 3.29628997e-02f, 7.74337947e-02f, -4.73397858e-02f, -2.23116372e-02f,
  2.11514928e-03f, 2.39200005e-03f, 5.27272634e-02f, 7.41678327e-02f, -2.09725704e-02f, 1.19718045e-01f, 1.90713182e-02f, -1.21218516e-02f, 9.24804993e-03f, 7.70297050e-02f,
  4.43231314e-02f, 2.17209235e-02f, 2.17700098e-02f, -3.68818045e-02f, -4.39818837e-02f, 6.27897978e-02f, 7.23553449e-03f, -1.31110763e-02f, 9.29454416e-02f, 8.72339681e-02f,
  4.01986428e-02f, -7.70682320e-02f, 6.27738088e-02f, 1.35273105e-02f, -8.70323461e-03f, -9.37195122e-03f, -1.13268765e-02f, -7.14865401e-02f, -2.95481160e-02f, 3.71368900e-02f,
  -6.54816777e-02f, -2.74787154e-02f, 9.06430036e-02f, -1.30123096e-02f, -9.35212001e-02f, -3.94493900e-02f, 3.53065319e-02f, 3.62049527e-02f, -1.07812487e-01f, -2.32828669e-02f,
  3.86587461e-03f, -2.81683132e-02f, -7.03755915e-02f, -3.20438594e-02f, 2.66181640e-02f, 4.48999293e-02f, -1.82790291e-02f, -1.87304076e-02f, -4.40613227e-03f, -1.43845362e-04f,
  6.40125349e-02f, -3.46406698e-01f, 9.46781412e-02f, 5.20802289e-02f, -8.74255523e-02f, 3.71649452e-02f, -2.22342938e-01f, -1.19312525e-01f, -8.71178433e-02f, -1.51615337e-01f,
  -7.43150786e-02f, 3.35722677e-02f, 1.08818069e-01f, -6.79066107e-02f, -2.44380664e-02f, -1.47273615e-01f, -1.57156095e-01f, 1.29862502e-01f, 1.95657358e-01f, 2.02625170e-02f,
  -1.31374091e-01f, -2.38482505e-02f, -2.55645791e-05f, -6.59709647e-02f, -1.55274451e-01f, -2.35653203e-02f, -1.31109014e-01f, -3.11146472e-02f, -1.65269986e-01f, -2.11137474e-01f,
  8.42486545e-02f, -1.55266494e-01f, -5.30409673e-03f, -1.00646213e-01f, 6.07276782e-02f, 3.99568342e-02f, -6.94121495e-02f, -4.15183082e-02f, 3.54937906e-03f, -8.81984681e-02f,
  -2.95263883e-02f, -3.44803780e-02f, 7.27407485e-02f, -9.13334731e-03f, -6.05959296e-02f, -9.08538327e-02f, -1.36963233e-01f, -8.40333663e-03f, 4.38614422e-03f, -7.56379887e-02f,
  -1.23285666e-01f, -6.29400685e-02f, -5.25777750e-02f, -8.92331004e-02f, 7.70840719e-02f, 5.41435033e-02f, 1.99644733e-03f, -1.49110402e-03f, 5.20503372e-02f, -1.46373197e-01f,
  7.08827227e-02f, 4.43829931e-02f, 3.00124101e-02f, -3.75996227e-03f, 1.26904771e-01f, 6.92388741e-03f, 7.33510107e-02f, -2.33933870e-02f, 3.03765126e-02f, 8.23641643e-02f,
  9.49862227e-02f, 9.79001522e-02f, 3.90167944e-02f, 1.26435056e-01f, 1.11160334e-02f, -2.77177710e-02f, 9.45164114e-02f, 1.50382388e-02f, 8.30781385e-02f, 1.46240899e-02f,
  9.06413198e-02f, 9.32892188e-02f, 1.11322626e-01f, 2.93470547e-02f, -1.14270318e-02f, 1.62086546e-01f, 1.87979117e-01f, 7.49767572e-02f, 1.70144409e-01f, 4.04381454e-02f,
  6.13535345e-02f, -4.01612259e-02f, -8.71408358e-02f, -1.92830488e-02f, 5.18189855e-02f, -4.41398472e-02f, 4.48955372e-02f, -2.06281543e-02f, -2.05220785e-02f, -6.81344569e-02f,
  -6.67450251e-03f, 3.35294455e-02f, -1.06971458e-01f, -1.15915492e-01f, -3.82336788e-02f, -1.93780046e-02f, -7.20037520e-02f, -3.01447250e-02f, -5.46571575e-02f, -9.06402171e-02f,
  -1.05497353e-01f, 5.43065146e-02f, 1.31199121e-01f, 4.82015200e-02f, -7.67716393e-02f, 1.81755975e-01f, 8.86900052e-02f, 1.30202353e-01f, 1.50062218e-01f, 1.27572387e-01f,
  -1.68865606e-01f, 1.79768622e-01f, 1.58434004e-01f, 2.84514967e-02f, 4.02332693e-01f, 3.13631922e-01f, 5.41973531e-01f, 3.57498899e-02f, 1.16737941e-02f, 1.64904028e-01f,
  2.13568449e-01f, 2.04531655e-01f, 1.04484066e-01f, 2.14930788e-01f, 1.71283573e-01f, 3.46594691e-01f, 2.51992136e-01f, 1.63752675e-01f, 2.26626724e-01f, 3.43775958e-01f,
  2.52759963e-01f, 1.19070984e-01f, 1.76570322e-02f, 1.94029398e-02f, 9.79330391e-02f, 2.25926414e-01f, 5.03298305e-02f, 1.45590320e-01f, 2.28369936e-01f, 2.69265085e-01f,
  2.06394106e-01f, -9.10608396e-02f, 2.10050315e-01f, 1.90200925e-01f, 1.24727666e-01f, 1.39519542e-01f, 2.09633961e-01f, -4.07953002e-02f, 8.72849673e-02f, 1.07563935e-01f,
  1.67755023e-01f, 8.82478058e-02f, 1.83636039e-01f, 1.47905201e-01f, 1.86687589e-01f, 6.46954626e-02f, 8.57402459e-02f, 8.42657834e-02f, 9.87349004e-02f, 1.59937039e-01f,
  3.32374513e-01f, 3.67509067e-01f, 2.56547719e-01f, 7.93076009e-02f, 9.12112966e-02f, 1.40666172e-01f, 1.35195091e-01f, -2.79651536e-03f, 8.58885348e-02f, 1.05800740e-01f,
  -7.54092783e-02f, -9.67616439e-02f, -9.26289409e-02f, -1.15442082e-01f, -1.18086167e-01f, -5.19651584e-02f, -7.90329725e-02f, -4.11528945e-02f, -3.17930281e-02f, -8.97601694e-02f,
  -1.19967468e-01f, 4.22410294e-03f, -7.94260055e-02f, -6.19864129e-02f, -1.59420237e-01f, -6.92962185e-02f, -1.74952224e-02f, -1.54838055e-01f, -8.94259438e-02f, -7.50821084e-02f,
  -5.87242655e-02f, -4.28974479e-02f, -7.37721398e-02f, -9.29474086e-02f, -5.02112284e-02f, -1.24276295e-01f, -1.32309526e-01f, -7.58782923e-02f, -1.47150636e-01f, -1.20631732e-01f,
  9.35935155e-02f, 1.85412735e-01f, 1.50434434e-01f, 1.34597331e-01f, 1.99570000e-01f, 1.26021281e-01f, 1.33642420e-01f, 1.35772482e-01f, 2.05532253e-01f, 1.88015237e-01f,
  1.96845725e-01f, 1.49260968e-01f, 1.38172090e-01f, 1.12850949e-01f, 2.40795583e-01f, 1.43318772e-01f, 1.87504023e-01f, 2.08732292e-01f, 1.38817623e-01f, 7.10600317e-02f,
  1.72260359e-01f, 2.41510466e-01f, 3.40588182e-01f, 3.09605390e-01f, 2.26211026e-01f, 3.54052693e-01f, 2.80967802e-01f, 1.76913738e-01f, 3.12506527e-01f, 3.08022946e-01f,
  -2.15414688e-01f, 1.37828633e-01f, 6.47856994e-03f, 2.11966084e-03f, 4.65086028e-02f, -1.53575346e-01f, -1.96764290e-01f, -2.48147100e-01f, -1.94503665e-01f, -2.53784284e-02f,
  -2.18737155e-01f, -1.93876013e-01f, -6.25000447e-02f, -1.63434744e-01f, -9.01717171e-02f, 5.35053238e-02f, 1.60449803e-01f, -1.09256692e-01f, -1.83725670e-01f, -1.81249157e-01f,
  9.94040980e-04f, -8.84782970e-02f, -9.13422033e-02f, -3.48836584e-05f, 2.62775589e-02f, -1.23858996e-01f, -2.72668116e-02f, -3.16962861e-02f, -1.19571842e-01f, 2.96049356e-01f,
  -4.99995537e-02f, -1.64116006e-02f, -1.12128288e-01f, 3.50356895e-05f, -2.48274580e-02f, -8.98827915e-04f, -3.79247032e-02f, 3.58368549e-03f, -6.41383929e-03f, 3.40497233e-02f,
  -5.01734838e-02f, -5.53234387e-03f, -4.63730842e-02f, -1.36069879e-01f, -1.13262542e-01f, -4.64945510e-02f, 4.80099842e-02f, -5.32256328e-02f, -1.43883927e-02f, -4.08482701e-02f,
  4.14949562e-03f, 2.15251874e-02f, -1.50928050e-01f, -1.00704171e-01f, -2.67185252e-02f, -2.04424620e-01f, -1.63988218e-01f, -1.59436241e-01f, -1.88178495e-01f, -1.10469386e-01f,
  1.98247433e-02f, 4.98810820e-02f, -8.36923486e-04f, -5.34184054e-02f, -3.27488631e-02f, 1.97905861e-02f, 5.06493263e-03f, -7.90873915e-03f, 7.54581299e-03f, -3.53036933e-02f,
  -3.53004634e-02f, -4.68316898e-02f, -6.01902269e-02f, -3.46883871e-02f, -2.62892824e-02f, -6.69677630e-02f, -1.13393791e-01f, 1.78846754e-02f, 1.49648869e-02f, -3.79585214e-02f,
  -3.26907560e-02f, -3.92633900e-02f, -1.03622368e-02f, -7.65047893e-02f, -2.65803076e-02f, -2.11830926e-03f, -4.06315029e-02f, -3.81286927e-02f, -3.00091915e-02f, -8.46724287e-02f,
  -2.39000872e-01f, -5.66017255e-02f, -8.05108473e-02f, -1.21454962e-01f, -7.63721988e-02f, -1.08690500e-01f, -7.58040845e-02f, 4.10797782e-02f, -1.92313939e-02f, -9.31304321e-02f,
  -1.59390166e-01f, -6.01485893e-02f, -1.20050453e-01f, -4.76108938e-02f, -9.93460044e-02f, -1.32397026e-01f, -8.33050162e-02f, -1.60075445e-02f, -1.12906262e-01f, -1.33754820e-01f,
  -1.03534438e-01f, -2.23580733e-01f, -2.54810870e-01f, -2.21106142e-01f, -1.52777895e-01f, -2.72155136e-01f, -1.81318462e-01f, -2.28086114e-01f, -1.90591425e-01f, -2.34430268e-01f,
  -2.90338576e-01f, 9.41653270e-03f, 6.53100759e-02f, -1.34877071e-01f, 1.17483728e-01f, -4.24972549e-02f, -1.65560707e-01f, -1.29774064e-01f, 7.52400160e-02f, 5.26522547e-02f,
  3.36340904e-01f, 3.19142431e-01f, 1.81561872e-01f, 1.72375292e-01f, -1.28882835e-02f, -2.56247818e-01f, -2.20780343e-01f, -2.12032616e-01f, -4.27846089e-02f, 5.04560620e-02f,
  1.20103218e-01f, -1.14497319e-01f, -9.99744795e-03f, -2.78960317e-02f, 3.82518657e-02f, 1.91800326e-01f, -9.81940143e-03f, -8.41890182e-03f, 9.23590660e-02f, 2.96323039e-02f,
  1.04349591e-01f, 1.73637047e-02f, -1.47020696e-02f, 1.78957358e-01f, 1.69164568e-01f, 1.31767765e-01f, 2.24670139e-03f, -1.51568220e-03f, 1.18789233e-01f, 1.25190634e-02f,
  1.33155495e-01f, 5.08609153e-02f, -3.74500789e-02f, 1.03777073e-01f, -9.06708464e-02f, 5.95410652e-02f, -6.86895773e-02f, -9.99227613e-02f, -2.70988159e-02f, 1.25877246e-01f,
  1.00835904e-01f, 1.33955240e-01f, -6.30322397e-02f, 7.27442130e-02f, -3.82682197e-02f, 8.92238989e-02f, 1.03085577e-01f, 1.28124701e-02f, 1.08706057e-02f, -9.07347258e-03f,
  8.70990846e-03f, 2.89303921e-02f, -2.00240221e-02f, -4.36716340e-02f, -5.63645363e-03f, 5.36140390e-02f, -9.33503285e-02f, -1.53611898e-02f, -5.10003604e-02f, -1.63196567e-02f,
  4.73137684e-02f, -4.13408764e-02f, -8.34714330e-04f, -6.82039633e-02f, 1.48575287e-02f, -6.20423304e-03f, -7.23173171e-02f, 2.08629891e-02f, -1.26009481e-02f, 1.67590715e-02f,
  -2.33802013e-02f, -5.14396876e-02f, -7.23296497e-03f, -9.94908586e-02f, 1.02364153e-04f, -7.60500431e-02f, -2.54931822e-02f, 1.43987285e-02f, 5.54510541e-02f, 4.87033054e-02f,
  6.92156628e-02f, 1.66526914e-01f, 8.90327245e-02f, -3.70531753e-02f, -6.30013943e-02f, 5.94576336e-02f, 5.33507839e-02f, 6.03539087e-02f, 1.18653052e-01f, 2.97518242e-02f,
  5.95390275e-02f, -3.36021744e-02f, 1.01211183e-02f, 6.19970635e-02f, 2.23573986e-02f, 1.00487784e-01f, 2.78981701e-02f, 5.09703606e-02f, 1.08020559e-01f, 7.85213038e-02f,
  -2.74242628e-02f, -4.81510833e-02f, -2.48347595e-02f, 2.27332227e-02f, 7.28396177e-02f, 3.84558961e-02f, 1.09513529e-01f, -9.97627992e-03f, 1.28521100e-01f, -1.44020811e-01f,
  1.98632061e-01f, 1.18597187e-02f, -3.63686681e-01f, -1.39826044e-01f, -3.20318371e-01f, -2.56065220e-01f, -3.32904235e-02f, 1.44028857e-01f, 3.50409374e-02f, -2.07531035e-01f,
  -3.74301188e-02f, -1.24386199e-01f, -6.69710934e-02f, -1.18278392e-01f, -1.10939601e-02f, -1.42016485e-01f, -1.26104951e-01f, -2.20180258e-01f, -1.15308970e-01f, -8.53351429e-02f,
  -1.44574165e-01f, -1.48250371e-01f, -7.61154527e-03f, 8.07266459e-02f, -1.53662965e-01f, -1.03690952e-01f, -9.16140303e-02f, -1.24611117e-01f, -1.55097507e-02f, -2.19535261e-01f,
  -3.53789926e-01f, 1.63074613e-01f, 5.48278503e-02f, 3.59889306e-02f, -1.31917357e-01f, 8.39781240e-02f, 3.05333901e-02f, 4.34426479e-02f, 1.05754852e-01f, -8.00458044e-02f,
  -8.65419284e-02f, -7.42803067e-02f, 1.31232785e-02f, -1.31377533e-01f, 2.26965658e-02f, -4.77668792e-02f, 7.44879320e-02f, 7.86558166e-02f, -2.33670641e-02f, -1.18771223e-02f,
  -4.80491780e-02f, -1.03510462e-01f, -5.25404774e-02f, -1.41239278e-02f, 8.33233967e-02f, 1.25077609e-02f, 1.96518041e-02f, 8.12616572e-02f, 8.31485465e-02f, 6.01090454e-02f,
  -1.12029957e-02f, 2.87810341e-02f, 4.16236147e-02f, 1.42547280e-01f, 1.00267246e-01f, 1.96391670e-03f, 7.49680633e-03f, -6.02411218e-02f, 9.59329121e-03f, 5.13313524e-02f,
  -4.00225371e-02f, 9.72229987e-03f, 5.73076494e-02f, 8.41225311e-03f, 1.50409276e-02f, -2.63261842e-03f, 5.74875884e-02f, 4.53534238e-02f, 1.35640085e-01f, 1.45962099e-02f,
  2.63731908e-02f, 1.54360468e-02f, -6.38672113e-02f, 8.34060162e-02f, 2.48060096e-02f, 3.18253599e-02f, -7.41935074e-02f, 4.99215117e-03f, 5.26574366e-02f, -9.09150466e-02f,
  -6.89292103e-02f, 6.40293211e-02f, -6.03485964e-02f, 7.40558654e-02f, -3.48326415e-02f, -4.62132581e-02f, 5.69399036e-02f, -5.24037294e-02f, -3.31238322e-02f, -5.32055600e-03f,
  3.32805663e-02f, 1.89016864e-03f, -7.28727132e-02f, -7.38128182e-03f, -4.76208776e-02f, -4.72352020e-02f, 6.82570338e-02f, -7.17080161e-02f, 8.65277369e-03f, 7.64395967e-02f,
  2.86594443e-02f, 2.81659681e-02f, -6.04014669e-04f, -1.65562686e-02f, 7.68889114e-02f, -9.33025256e-02f, -2.59636552e-03f, -1.73359755e-02f, -1.43671874e-02f, 6.08398579e-03f,
  8.24830979e-02f, -2.39100397e-01f, -2.49233857e-01f, 1.33151799e-01f, 3.76843056e-03f, -6.28109202e-02f, -1.38999939e-01f, 8.40098336e-02f, 1.67667761e-01f, -6.59205988e-02f,
  8.98804218e-02f, 2.48928651e-01f, 3.75140280e-01f, 3.11658382e-01f, 1.07024506e-01f, -1.05277270e-01f, -7.27869794e-02f, 6.34254217e-02f, 1.81861386e-01f, 8.50737244e-02f,
  -3.00321286e-03f, -1.76646579e-02f, 1.17763437e-01f, 1.61677450e-02f, 2.11144108e-02f, 1.32327542e-01f, -9.42838266e-02f, -1.06928229e-01f, 1.13311401e-02f, -1.93521768e-01f,
  9.68826115e-02f, -1.36781454e-01f, 2.43229285e-01f, 8.05209056e-02f, 6.43820092e-02f, 5.23537882e-02f, 7.94312432e-02f, 5.68940304e-02f, 9.98414010e-02f, -3.90569307e-02f,
  9.80030149e-02f, 5.98377734e-02f, 9.95132104e-02f, 2.96904594e-02f, 4.72283959e-02f, 1.36007741e-01f, -4.73965555e-02f, 4.48874608e-02f, 3.76473330e-02f, 9.10850242e-02f,
  8.10249969e-02f, -3.63121480e-02f, 1.77463908e-02f, 1.87623035e-02f, -7.38190603e-04f, 1.42141849e-01f, -7.77746886e-02f, -7.82897417e-03f, -6.34296611e-02f, -3.53510529e-02f,
  -1.08929342e-02f, -2.32222080e-02f, 5.00599407e-02f, -9.78401974e-02f, -2.71251090e-02f, 8.73799622e-02f, -8.58125612e-02f, 7.22522475e-03f, 1.88688003e-02f, 1.64414570e-02f,
  -5.49787562e-03f, -3.26208887e-03f, -6.77672625e-02f, -5.18775918e-02f, -4.98269591e-03f, -1.24856465e-01f, 4.66127880e-03f, 3.20442696e-03f, -9.49436240e-03f, -7.37619773e-02f,
  -2.60269474e-02f, 2.21781768e-02f, -2.98945140e-02f, 4.71288934e-02f, -1.40576605e-02f, -1.05802707e-01f, -5.86829893e-02f, -6.55498132e-02f, -7.23028705e-02f, 6.23399485e-03f,
  3.23658168e-01f, 1.13089308e-01f, 9.24321935e-02f, 1.03839986e-01f, 1.02872714e-01f, 6.32384419e-02f, 4.64848690e-02f, 8.33124146e-02f, -3.25572900e-02f, 4.71082516e-02f,
  3.31273675e-02f, 7.66253844e-02f, 8.97258073e-02f, 9.25621539e-02f, 9.83056203e-02f, 1.47731915e-01f, 5.55660874e-02f, 6.61191642e-02f, 2.38724053e-02f, -3.50611173e-02f,
  1.72100738e-02f, 8.10416266e-02f, 1.35845274e-01f, 3.83733101e-02f, 7.46221319e-02f, 2.21675649e-01f, 9.17804763e-02f, 4.17955816e-02f, 1.78978562e-01f, 3.20965536e-02f,
  -5.07134020e-01f, -6.09179214e-03f, 2.43771344e-01f, -6.35559931e-02f, 1.45241305e-01f, -5.32529168e-02f, -3.23578194e-02f, -1.89471632e-01f, -7.97694102e-02f, 6.03390187e-02f,
  2.55535897e-02f, -5.80400974e-02f, 6.37496635e-02f, 3.66419889e-02f, -8.06128085e-02f, 8.21508616e-02f, 1.76943853e-01f, 1.12039104e-01f, 4.42977697e-02f, -9.75098312e-02f,
  4.42657731e-02f, -4.84720431e-02f, -1.47041082e-01f, -3.73636112e-02f, 1.84945643e-01f, 1.66633472e-01f, 2.07674861e-01f, 1.55341715e-01f, 5.90114333e-02f, 2.52226055e-01f,
  2.11802244e-01f, -1.75995484e-01f, 6.41535744e-02f, -5.42944893e-02f, 5.88313863e-02f, -1.48911532e-02f, 5.38317114e-02f, 3.27475481e-02f, 3.33468504e-02f, 4.25713733e-02f,
  9.29544568e-02f, 4.78870906e-02f, 5.39412983e-02f, 4.26748348e-03f, -3.43624949e-02f, -4.38258201e-02f, -2.43334509e-02f, -6.73443303e-02f, -2.19004806e-02f, -3.53184268e-02f,
  1.33390546e-01f, 9.78085250e-02f, -1.89404134e-02f, 1.88375320e-02f, -6.88716397e-02f, -5.87658444e-03f, -7.74309097e-04f, -6.95858325e-04f, -4.19590296e-03f, -6.80549117e-03f,
  -1.01195887e-01f, -2.25356445e-02f, -2.73076426e-02f, -5.49379587e-02f, 3.90986912e-02f, -4.05811295e-02f, 4.31408621e-02f, 3.68486904e-02f, -4.10208292e-02f, -2.69561913e-02f,
  -4.21448387e-02f, -4.20744717e-02f, -2.41845585e-02f, -2.72891074e-02f, 2.34652497e-02f, -2.19875835e-02f, 3.94412652e-02f, -3.70657071e-02f, 4.42190319e-02f, -1.12720691e-02f,
  -4.34621098e-03f, 7.02859908e-02f, 1.20726049e-01f, -1.34577621e-02f, 4.99060526e-02f, 3.96893844e-02f, 7.85554349e-02f, -3.11792698e-02f, -6.06611855e-02f, -5.67409731e-02f,
  -2.24529840e-02f, 5.79858571e-03f, -1.07478872e-01f, -7.28558972e-02f, 1.05003156e-01f, -3.20636667e-02f, 5.64209558e-03f, 2.41768956e-02f, 4.10288833e-02f, -3.25738303e-02f,
  -7.83913359e-02f, -1.61762871e-02f, -3.76321822e-02f, 5.18865068e-04f, 4.97092828e-02f, -6.92919195e-02f, -4.42764238e-02f, 1.16088975e-03f, 2.58873142e-02f, 5.01044188e-03f,
  -8.46781954e-02f, -8.29525143e-02f, -9.89751294e-02f, 1.85067002e-02f, 4.45857681e-02f, -1.90609805e-02f, 3.38302292e-02f, 1.15397980e-03f, -3.72014269e-02f, -1.42438933e-01f,
  -4.70287725e-02f, 2.62336761e-01f, -2.13462830e-01f, 1.44010559e-01f, 1.72152579e-01f, 7.16134831e-02f, 1.07954025e-01f, -1.30432770e-01f, -3.93742099e-02f, 8.14179108e-02f,
  1.69541076e-01f, 2.55295094e-02f, -4.65998054e-02f, -8.43352303e-02f, -1.89010918e-01f, -3.29845808e-02f, -8.62133279e-02f, -1.96434632e-01f, -3.41802895e-01f, -1.56768546e-01f,
  3.16297822e-02f, 1.10886674e-02f, -3.05897057e-01f, -1.64361298e-01f, 1.16555400e-01f, -1.44860670e-02f, -6.43180460e-02f, 1.13995150e-01f, 9.00538340e-02f, 2.92825222e-01f,
  -7.85615519e-02f, 1.79223761e-01f, -2.59774715e-01f, 1.84447281e-02f, 8.79086740e-03f, -1.10978626e-01f, -8.23291391e-02f, -1.37114167e-01f, -7.75709152e-02f, -6.62988648e-02f,
  -1.92618091e-02f, -7.84758255e-02f, -1.30244587e-02f, -9.82198715e-02f, -1.20852061e-01f, -7.27030709e-02f, -1.27576724e-01f, -2.53480554e-01f, -2.89429575e-01f, -1.81085333e-01f,
  -1.54591240e-02f, 2.37248074e-02f, -5.71937039e-02f, -1.27545044e-01f, -4.30341996e-02f, -8.33168030e-02f, 3.01254280e-02f, -2.49707084e-02f, -1.95909724e-01f, -1.29706897e-02f,
  3.33738066e-02f, -3.84354219e-03f, 2.52764113e-02f, 7.16431960e-02f, 1.08825807e-02f, 7.09429011e-02f, 1.19257502e-01f, -3.24684605e-02f, -3.54768671e-02f, -8.60704705e-02f,
  -1.09536136e-02f, -9.29956809e-02f, -2.32178457e-02f, -1.51688512e-02f, 9.47715435e-03f, 1.85095072e-02f, 7.79271647e-02f, -5.94149157e-02f, -4.18788716e-02f, -2.24631093e-03f,
  -4.44348343e-02f, 3.20134079e-03f, 1.31649030e-02f, -7.26381615e-02f, 4.81861606e-02f, -1.86187271e-02f, -5.41170686e-02f, 8.77007749e-03f, -1.01388693e-01f, 1.11788936e-01f,
  -1.36493653e-01f, -2.09815741e-01f, -8.20039436e-02f, -5.96470013e-02f, -6.04203418e-02f, -1.06720820e-01f, -7.29931444e-02f, -1.81412145e-01f, -1.94171946e-02f, -1.25142559e-01f,
  3.59481312e-02f, -2.66135745e-02f, -9.08392295e-02f, -1.40886888e-01f, -8.77002478e-02f, -1.13443643e-01f, -5.24139106e-02f, -6.69358522e-02f, -1.47625148e-01f, -1.07770324e-01f,
  -1.48937821e-01f, -1.01459369e-01f, -2.12799922e-01f, -1.31973207e-01f, -1.22843601e-01f, -1.51124462e-01f, -7.91958719e-02f, -8.63092318e-02f, -1.69000909e-01f, -7.85932466e-02f,
  1.94636360e-01f, 5.04228808e-02f, -3.45026046e-01f, 8.48116651e-02f, 1.15103610e-02f, 2.17235945e-02f, -7.64183607e-03f, 1.14995018e-01f, 2.51400530e-01f, -6.20594844e-02f,
  1.34981334e-01f, 1.32994696e-01f, 1.08283475e-01f, 4.84323949e-02f, 5.49965240e-02f, -2.20446303e-01f, -2.21516252e-01f, -1.40646815e-01f, -6.92349523e-02f, 3.86180207e-02f,
  1.42702848e-01f, 6.07475191e-02f, 5.45284785e-02f, 1.12169668e-01f, 9.43337902e-02f, 8.48049745e-02f, -7.82980546e-02f, 1.73407160e-02f, 4.00720816e-03f, -1.68992639e-01f,
  -3.01306874e-01f, 8.61717984e-02f, 2.58648582e-02f, 1.70643404e-01f, 3.63091789e-02f, 4.53234138e-03f, 5.54761551e-02f, -1.22123482e-02f, 1.08455963e-01f, 2.48870533e-02f,
  1.03493510e-02f, 1.33532450e-01f, 1.04042701e-01f, -1.79228839e-02f, 9.04305577e-02f, -2.18045283e-02f, 7.08344877e-02f, -2.16479264e-02f, 3.46665382e-02f, -5.19179106e-02f,
  -2.92139070e-04f, 1.11950472e-01f, 1.14017881e-01f, 8.62648860e-02f, -3.83897126e-03f, 2.43635383e-02f, 2.57206634e-02f, 1.03670627e-01f, -1.63185745e-02f, -8.54260568e-03f,
  -9.39248428e-02f, -8.27892199e-02f, 1.53364977e-02f, -2.17805076e-02f, 5.93373403e-02f, 5.20119257e-02f, -1.60427950e-02f, -4.08737697e-02f, -2.33642682e-02f, 3.04894038e-02f,
  2.49329545e-02f, -7.22609907e-02f, 1.45830037e-02f, -4.08915197e-03f, -2.63270717e-02f, 3.15291504e-03f, -5.23596816e-03f, -2.72715315e-02f, 2.04885583e-02f, -1.87978111e-02f,
  2.14210171e-02f, -3.19106951e-02f, -1.13717886e-02f, 1.92730036e-02f, 2.44114194e-02f, -3.51406410e-02f, -1.58683043e-02f, 5.61429337e-02f, -5.81497420e-03f, 3.00852605e-03f,
  1.80722296e-01f, 2.34257616e-02f, -8.82024914e-02f, -8.36733205e-04f, -2.73432974e-02f, 2.31990777e-02f, -6.14579506e-02f, 2.82515045e-02f, 6.33495301e-02f, 5.82953915e-02f,
  7.17538446e-02f, 2.03063749e-02f, -2.21945029e-02f, -3.02062556e-02f, -3.17751952e-02f, 3.19083259e-02f, 5.53911999e-02f, -5.02581149e-02f, 2.08750907e-02f, 4.71350104e-02f,
  5.88520169e-02f, -4.85023437e-03f, 5.99021539e-02f, 8.96529257e-02f, 1.55199528e-01f, 7.71646351e-02f, -5.68975024e-02f, 8.90370533e-02f, 9.94235054e-02f, 1.07063636e-01f,
  6.13649666e-01f, -3.13107431e-01f, -1.15116991e-01f, 1.02695949e-01f, -3.33572477e-01f, -1.01948142e-01f, -1.35077193e-01f, -4.65852022e-03f, 1.43486798e-01f, -1.65748447e-01f,
  -2.02895358e-01f, 1.00272223e-01f, 5.62000796e-02f, -1.74741987e-02f, 2.14232862e-01f, -1.15738265e-01f, -9.65767279e-02f, 2.31748000e-01f, 3.88549566e-01f, 8.29090700e-02f,
  5.01559228e-02f, 9.18298364e-02f, 3.68780702e-01f, 1.64846763e-01f, -1.56567186e-01f, 1.06590278e-01f, -1.58312634e-01f, -1.12116314e-01f, -2.06930026e-01f, -1.57870904e-01f,
  -1.43828811e-02f, -1.98901355e-01f, 9.50681642e-02f, 5.09659462e-02f, -5.47345765e-02f, 3.98747101e-02f, 6.72351802e-03f, 6.13447726e-02f, -5.23178987e-02f, -4.55946960e-02f,
  -1.45290062e-01f, -3.21351588e-02f, 2.15718187e-02f, -1.24437988e-01f, -6.03418835e-02f, 1.10447649e-02f, -2.82766223e-02f, 1.08445421e-01f, 4.01826948e-03f, -1.02387019e-01f,
  -1.56018332e-01f, -7.98930749e-02f, -8.47479701e-02f, -1.76111963e-02f, -9.05179605e-02f, 5.72479330e-02f, -1.72125027e-01f, -4.77535464e-02f, -4.58438955e-02f, -1.53759243e-02f,
  5.02508208e-02f, 4.21675555e-02f, -1.91343613e-02f, 4.72922064e-02f, 2.93794367e-03f, 1.53500345e-02f, 1.68315042e-02f, 3.61844450e-02f, 9.21829194e-02f, -6.69553271e-03f,
  1.53412521e-02f, -1.63138900e-02f, -3.52054974e-03f, 8.40267108e-04f, -1.19943200e-02f, -6.11732006e-02f, 8.55722744e-03f, -3.86916520e-03f, -3.02682025e-03f, 2.89269537e-02f,
  -5.46423085e-02f, 1.51461782e-02f, -2.49609835e-02f, -2.16850452e-02f, -3.30621861e-02f, 6.43187314e-02f, -2.73837689e-02f, 2.63894405e-02f, -3.27829309e-02f, -6.21528029e-02f,
  1.35757849e-01f, -1.39401317e-01f, 2.91569643e-02f, 1.32833160e-02f, -8.18707570e-02f, 4.97738423e-04f, 4.20897380e-02f, -1.50885070e-02f, -2.58399509e-02f, 3.89816910e-02f,
  7.74002969e-02f, 3.16131823e-02f, 2.93844752e-02f, 4.19114530e-02f, 1.32846519e-01f, 6.56597242e-02f, -5.51506951e-02f, -2.77428459e-02f, -3.59674916e-02f, 1.25005422e-02f,
  -1.61575209e-02f, 3.81700620e-02f, 1.19568311e-01f, 3.58794481e-02f, 4.77269739e-02f, 1.30396098e-01f, 8.29481184e-02f, 3.61664891e-02f, 1.18284672e-01f, 1.82211056e-01f,
  -3.42277974e-01f, -1.88830361e-01f, -2.39044055e-01f, -1.21848531e-01f, -2.99339928e-02f, -5.59608862e-02f, -1.03012145e-01f, 1.74458474e-01f, 1.35615587e-01f, -1.88958570e-01f,
  -1.45495251e-01f, 8.43538493e-02f, -5.19800745e-02f, -3.75746861e-02f, 1.55005589e-01f, -9.15744305e-02f, -6.39619008e-02f, -3.35707739e-02f, 7.72934814e-04f, -6.75691962e-02f,
  6.53335676e-02f, 1.05963081e-01f, 6.12377189e-02f, 9.14393440e-02f, -1.31790906e-01f, -1.19159110e-02f, -2.23136134e-02f, -6.00746684e-02f, 2.14782245e-02f, -3.37512314e-01f,
  -4.85024959e-01f, -2.38806576e-01f, -9.47747659e-03f, 8.62102956e-02f, -4.78176586e-02f, 8.03321302e-02f, -1.01238571e-01f, 2.15713512e-02f, 1.34012073e-01f, -5.00327684e-02f,
  -1.64866690e-02f, 6.86119422e-02f, 5.14590181e-02f, 7.77437259e-03f, 4.83763590e-02f, 5.40446080e-02f, 7.69592747e-02f, -3.24828289e-02f, 6.15903921e-02f, -1.15322620e-01f,
  -7.91475773e-02f, -3.26771252e-02f, -6.05546944e-02f, 4.78728004e-02f, -5.31136394e-02f, -1.37293860e-02f, -4.76277471e-02f, -2.65828036e-02f, 7.77120069e-02f, -2.78156046e-02f,
  1.61296211e-03f, -6.18469790e-02f, 1.12244422e-02f, 5.38866371e-02f, 3.52380387e-02f, 3.89346406e-02f, -7.65298158e-02f, 4.17244807e-03f, -1.72415525e-02f, -5.94200520e-03f,
  -1.25775801e-03f, -3.51369195e-02f, 3.65499668e-02f, -4.93287146e-02f, -3.70978378e-02f, 2.22811121e-02f, -2.44925711e-02f, 1.31728388e-02f, -2.80096382e-02f, 5.41807562e-02f,
  -5.67070358e-02f, -8.65401328e-02f, -1.77559238e-02f, 1.01414984e-02f, 9.79760066e-02f, -4.49153706e-02f, 4.82464507e-02f, 7.83703011e-03f, -1.91812473e-03f, 2.88328994e-02f,
  7.49111027e-02f, 1.74058273e-01f, -2.28591457e-01f, 4.56201099e-02f, 8.52430239e-03f, -3.57962810e-02f, -5.32098785e-02f, -4.30286191e-02f, 3.08210738e-02f, -1.02188885e-01f,
  -7.15585202e-02f, -8.76057670e-02f, -9.43306759e-02f, -7.59809464e-02f, -1.59450341e-02f, -5.07590808e-02f, 9.98522900e-03f, -4.82693054e-02f, 7.01928586e-02f, 2.29275669e-03f,
  1.41222831e-02f, 5.29007651e-02f, 7.93697406e-03f, 3.61524783e-02f, 3.45101357e-02f, 8.25476572e-02f, -2.55473908e-02f, -3.23733245e-03f, 1.02799185e-01f, 1.06273189e-01f,
  -4.35238063e-01f, -7.56995529e-02f, -1.16091214e-01f, -1.18982315e-01f, 1.47433244e-02f, 2.80578583e-01f, 2.77249038e-01f, 1.29373029e-01f, 6.15378171e-02f, 8.08348693e-03f,
  1.73381358e-01f, 2.19525248e-01f, 9.82800722e-02f, 2.59106576e-01f, 1.05814144e-01f, 3.72230099e-03f, -2.01083213e-01f, -8.75066295e-02f, 1.68522537e-01f, 1.91130564e-01f,
  -3.22221629e-02f, -1.54392287e-01f, -1.56262398e-01f, 8.99046734e-02f, -1.48891255e-01f, -6.01810068e-02f, -1.19618967e-01f, -1.53415352e-01f, -4.94086482e-02f, -3.19642127e-01f,
  -1.43626094e-01f, -1.30524680e-01f, 1.92033097e-01f, 4.92975712e-02f, 7.33434185e-02f, 9.15154442e-02f, 2.16967929e-02f, -3.67843099e-02f, 1.21402346e-01f, 3.89476232e-02f,
  5.67374006e-02f, 3.92240211e-02f, 1.03936121e-01f, -1.11810947e-02f, 8.72562826e-02f, 5.57467639e-02f, 1.71723124e-02f, -4.94910367e-02f, -1.27837257e-02f, -2.76707415e-03f,
  2.75520459e-02f, -8.76907930e-02f, -3.85353416e-02f, 8.74270275e-02f, 1.34511277e-01f, 2.99813077e-02f, 9.11617428e-02f, -1.55746555e-02f, -4.45660166e-02f, -2.29564428e-01f,
  -1.42384619e-01f, -1.42654190e-02f, 1.89619493e-02f, -1.39105171e-01f, 1.06023587e-02f, 1.25027215e-02f, -9.09966156e-02f, -2.14369576e-02f, 2.32023504e-02f, -3.36408466e-02f,
  5.78522794e-02f, -4.66904566e-02f, 7.56705552e-03f, 2.64257025e-02f, -1.03902064e-01f, -1.75344124e-02f, 1.22274058e-02f, -7.78631419e-02f, -9.00372770e-03f, -7.99246281e-02f,
  -1.83646511e-02f, -4.00309414e-02f, -5.31997830e-02f, 1.58717185e-02f, -1.36270121e-01f, -7.77159333e-02f, -1.39215821e-02f, 5.01663983e-02f, -8.93945619e-02f, -6.49322271e-02f,
  1.51038527e-01f, 2.15285957e-01f, -6.99713603e-02f, 7.44464248e-02f, 4.42806631e-02f, 2.83217002e-02f, -4.01793085e-02f, 5.24835326e-02f, 1.83186047e-02f, 9.88743380e-02f,
  8.21517333e-02f, 1.08141094e-01f, 5.21237850e-02f, 2.17275061e-02f, 7.96209872e-02f, 4.86365110e-02f, -7.96584189e-02f, 6.01374283e-02f, 1.13369435e-01f, -6.31045550e-02f,
  1.33516798e-02f, -1.64190102e-02f, 6.75325170e-02f, 5.21489419e-02f, -6.53554723e-02f, 9.92810279e-02f, -4.54797707e-02f, -1.50866911e-03f, 1.48632318e-01f, -8.20401609e-02f,
  1.78414375e-01f, 1.12020813e-01f, -1.39894515e-01f, -5.55216148e-02f, -1.53435096e-01f, -5.63110709e-02f, 1.16240613e-01f, 1.57256022e-01f, -6.50788844e-02f, 7.50212446e-02f,
  1.84684563e-02f, 1.38434589e-01f, 1.10509142e-01f, 1.57515034e-01f, 2.30621263e-01f, 2.11702496e-01f, 1.00641064e-01f, 1.51318401e-01f, 9.06525403e-02f, -1.53470719e-02f,
  -1.15910292e-01f, 7.45999739e-02f, 5.23812510e-02f, -3.46356351e-03f, 6.75969245e-03f, 2.09597081e-01f, -4.01366167e-02f, 4.54441234e-02f, -1.76778752e-02f, 5.34176044e-02f,
  1.79889068e-01f, 4.39425074e-02f, -4.15752456e-02f, -5.59205040e-02f, -9.05839503e-02f, -2.95543540e-02f, -3.52791138e-02f, -1.04079694e-01f, 2.48122811e-02f, -3.97799723e-02f,
  -7.87304491e-02f, -1.43059455e-02f, 6.20824005e-03f, -7.64110312e-02f, -1.34267006e-02f, -7.24851117e-02f, -9.77226496e-02f, -1.20326858e-02f, -6.52896166e-02f, 1.10586910e-02f,
  -9.37848017e-02f, -1.18304178e-01f, -2.88421251e-02f, -8.06066170e-02f, 3.45019693e-03f, -6.88121095e-02f, 4.53409227e-03f, 2.62670275e-02f, 1.21713793e-02f, 1.09684847e-01f,
  -1.44188786e-02f, -3.13948393e-02f, -5.32771461e-02f, 2.77867611e-03f, -1.79037265e-02f, -5.39257750e-02f, -3.42968218e-02f, -4.18734923e-02f, -7.48785734e-02f, -1.70441307e-02f,
  -1.11769950e-02f, -2.65999977e-02f, -5.01018912e-02f, -4.42620590e-02f, -2.06343364e-02f, -2.59219129e-02f, -2.99109612e-02f, 7.03286976e-02f, -2.78497804e-02f, -1.02511272e-01f,
  -1.52922124e-02f, -4.96459939e-02f, -6.15549684e-02f, -5.87477125e-02f, 9.30306967e-03f, -9.37651992e-02f, -1.61161553e-02f, 6.34050891e-02f, 3.62395607e-02f, 1.04933850e-01f,
  3.04196894e-01f, -9.97019038e-02f, 1.11653969e-01f, 1.80351466e-01f, -4.67084460e-02f, -9.33259875e-02f, -1.51459603e-02f, -4.71151900e-03f, -5.95874451e-02f, 2.64482796e-02f,
  -5.39333001e-02f, -6.80785403e-02f, 3.22769508e-02f, -4.85233404e-02f, -4.67391983e-02f, 2.15000026e-02f, 3.76045853e-02f, 9.40489322e-02f, -1.25272647e-01f, -8.86461586e-02f,
  -8.49698484e-02f, 9.55343060e-03f, 1.47280321e-01f, 1.41902030e-01f, -7.70888701e-02f, 4.09157835e-02f, 1.45981982e-01f, 1.43572956e-01f, 1.47132277e-01f, 1.70457050e-01f,
  -2.56341517e-01f, 1.00174509e-01f, -2.23033383e-01f, -1.45018876e-01f, 4.10541035e-02f, 1.56856716e-01f, 8.38719904e-02f, 1.30129904e-01f, 7.21089020e-02f, 1.27359882e-01f,
  1.21521719e-01f, -4.73002158e-02f, -6.94993809e-02f, -1.06149651e-01f, -1.77493840e-01f, 9.10440236e-02f, -1.48891315e-01f, -3.68960172e-01f, -2.56631970e-01f, -1.10451179e-03f,
  9.29264352e-02f, 7.12795928e-02f, -1.03349306e-01f, -7.47493953e-02f, 2.00137752e-03f, 3.57694440e-02f, 6.20925613e-02f, -3.40005942e-02f, -9.87772923e-03f, -1.65891886e-01f,
  -2.95489818e-01f, -2.23950848e-01f, -1.00063644e-01f, 2.87439413e-02f, -1.11104682e-01f, -1.66607611e-02f, -1.22308195e-01f, -9.21179652e-02f, -8.83850455e-02f, -1.80749118e-01f,
  -3.04004531e-02f, 3.71859572e-03f, -1.66104347e-01f, -4.08651344e-02f, -1.55823186e-01f, -5.81123866e-02f, -5.59783541e-03f, -1.09550655e-01f, -9.50795636e-02f, -3.33373025e-02f,
  4.54548262e-02f, -2.13673282e-02f, -1.34138286e-01f, 7.24874660e-02f, -8.24745297e-02f, -7.37918466e-02f, 1.88833792e-02f, -7.96830207e-02f, 8.04210361e-03f, -6.96124975e-03f,
  -2.66377423e-02f, -4.23285328e-02f, -3.67379136e-04f, 7.40182772e-02f, 2.40502157e-03f, -1.07547445e-02f, -1.37001378e-02f, -4.13165540e-02f, -2.55485214e-02f, -9.06148925e-02f,
  -6.07172810e-02f, 9.59744211e-03f, -1.37992306e-02f, -7.84822553e-02f, -1.32161994e-02f, -6.60649687e-02f, -2.10931385e-03f, 9.00693610e-02f, 1.42510040e-02f, 4.99008261e-02f,
  -6.20823018e-02f, 2.34319828e-02f, -4.65711914e-02f, -8.26904625e-02f, -4.93857488e-02f, -2.82092150e-02f, -8.84255245e-02f, 1.03180945e-01f, -2.60253064e-02f, -1.51791230e-01f,
  1.59662157e-01f, -4.62695248e-02f, -1.13798797e-01f, -5.66640981e-02f, -2.06365716e-02f, -6.48122728e-02f, 1.95478890e-02f, 4.09964435e-02f, -9.78728384e-02f, 3.66374925e-02f,
  -9.72333550e-02f, -1.24676682e-01f, -2.64849160e-02f, -8.48551616e-02f, -1.57219753e-01f, -1.62503552e-02f, 5.53912818e-02f, -1.19746417e-01f, -2.78139375e-02f, -3.70146222e-02f,
  1.32694751e-01f, 4.34123278e-02f, -3.97741273e-02f, 3.46287154e-02f, -5.69402836e-02f, -5.64833507e-02f, 2.24979986e-02f, -3.70750688e-02f, -8.09714198e-02f, 5.58646545e-02f,
  -4.53010380e-01f, 4.22928929e-01f, 8.07765648e-02f, -7.64609873e-02f, 1.13029741e-01f, 1.83059633e-01f, 3.35988700e-01f, 1.56110330e-02f, -4.30880934e-02f, 2.50921786e-01f,
  1.48930877e-01f, -6.63673580e-02f, -7.92556629e-02f, -1.00523002e-01f, -1.61946088e-01f, 2.79223442e-01f, 3.32550481e-02f, -3.32297236e-01f, -3.31380576e-01f, -9.67115685e-02f,
  4.36764769e-03f, -1.01594970e-01f, -2.48522654e-01f, -2.53060669e-01f, 1.37793303e-01f, -3.65958028e-02f, 1.97451085e-01f, 5.06750196e-02f, 5.55899478e-02f, 1.57831356e-01f,
  8.67901444e-02f, 1.35325477e-03f, -2.14302354e-02f, 4.20383830e-03f, 7.49515742e-02f, -6.50573894e-02f, 3.40243392e-02f, 5.34699904e-03f, -5.31047694e-02f, 1.12702744e-02f,
  -1.76078118e-02f, -8.92071202e-02f, -7.50442296e-02f, 8.23036116e-03f, -5.21035232e-02f, 2.13709641e-02f, -1.16284870e-01f, -7.14554712e-02f, -7.96928555e-02f, 9.01929066e-02f,
  1.39990777e-01f, 1.86950818e-03f, 7.51938950e-03f, 4.02824357e-02f, -9.35453400e-02f, -9.43734720e-02f, 9.53684468e-03f, 1.54042365e-02f, -5.34081161e-02f, -3.49723361e-02f,
  8.89459625e-02f, 4.29131314e-02f, -2.94169914e-02f, -3.16381902e-02f, 7.64294760e-03f, 1.05770737e-01f, -6.86677322e-02f, 9.04772878e-02f, -9.39571708e-02f, 5.21001145e-02f,
  -8.03592280e-02f, 9.33576468e-03f, -4.13349755e-02f, -1.85075887e-02f, 4.40415405e-02f, -7.55333081e-02f, 3.55670527e-02f, -3.08670886e-02f, -4.47968068e-03f, -5.31229265e-02f,
  1.45004224e-02f, -8.44070688e-03f, -2.66556274e-02f, -4.07586060e-02f, 1.93182547e-02f, -2.11789878e-03f, -2.73675229e-02f, -4.52608243e-03f, 4.27513346e-02f, -2.55528893e-02f,
  2.23679364e-01f, -8.28044042e-02f, 7.75454119e-02f, -2.94799395e-02f, -4.87849340e-02f, 6.69290647e-02f, 7.06665516e-02f, -7.76006207e-02f, -1.07437233e-03f, 2.64138076e-02f,
  2.74213459e-02f, 3.52857970e-02f, 6.81114271e-02f, 5.62034361e-02f, -1.04935970e-02f, -2.46334635e-02f, 7.69462958e-02f, -1.40342060e-02f, 4.05780151e-02f, 1.42073274e-01f,
  6.09331802e-02f, -2.48430111e-02f, 7.10770786e-02f, 1.66277718e-02f, 8.30840468e-02f, 3.10766958e-02f, 1.37600854e-01f, 1.61598697e-02f, -1.59031022e-02f, 2.19545260e-01f,
  1.55370295e-01f, 1.49885416e-01f, -5.31506129e-02f, -1.32582868e-02f, -1.11341618e-01f, -1.38117626e-01f, -1.55559480e-01f, -3.06430310e-02f, 1.24425977e-01f, 3.96709107e-02f,
  4.37835343e-02f, 6.23280220e-02f, -5.98975930e-05f, -2.45580673e-02f, -1.18650883e-01f, -1.09331727e-01f, -2.75702477e-01f, -2.95996040e-01f, -1.54012665e-01f, -1.77574426e-01f,
  -1.33497000e-01f, -9.84734967e-02f, -3.43110971e-02f, -2.03749426e-02f, -2.00578813e-02f, -4.74551730e-02f, 1.13767959e-01f, 7.09264055e-02f, 8.56388956e-02f, -8.32743272e-02f,
  3.93630005e-04f, 1.66487426e-01f, -7.46324807e-02f, -5.61948456e-02f, -1.37743607e-01f, -9.90244150e-02f, -6.42929748e-02f, -1.08904690e-01f, -1.46842495e-01f, -8.23880211e-02f,
  -4.73396741e-02f, -5.56712504e-03f, -7.84649029e-02f, -1.55856945e-02f, 9.90200508e-03f, -1.54977426e-01f, -1.11038901e-01f, 2.13063266e-02f, -5.14325313e-03f, -6.05971366e-02f,
  -1.14232376e-01f, -1.21502683e-01f, -1.11813083e-01f, -9.10633877e-02f, -4.07355987e-02f, -1.15510128e-01f, 1.84097572e-03f, 9.34336632e-02f, -4.97406758e-02f, 7.58693665e-02f,
  -8.69909152e-02f, 6.73294887e-02f, 3.14648040e-02f, -1.00401100e-02f, -1.76451989e-02f, 1.23174071e-01f, 1.66445095e-02f, 2.67389510e-02f, 7.74513185e-02f, 4.97885011e-02f,
  5.31827025e-02f, 1.19878493e-01f, 6.20975457e-02f, 2.70717125e-02f, 9.48829204e-03f, -1.54805835e-02f, 1.36774210e-02f, 1.75636820e-02f, -2.66884366e-04f, 1.96828954e-02f,
  -2.87226215e-02f, 6.20433949e-02f, 1.19192287e-01f, 1.53610650e-02f, 7.24211782e-02f, 1.85974892e-02f, 1.01792915e-02f, 1.16658199e-03f, -8.70129745e-03f, 5.08774333e-02f,
  1.11480594e-01f, 1.82895064e-02f, 8.35672542e-02f, -3.05453390e-02f, -4.41342667e-02f, 3.56515683e-02f, 7.98168033e-02f, 4.82961861e-03f, 9.59885865e-02f, 3.78098376e-02f,
  5.94004467e-02f, 4.26878221e-03f, -2.53921952e-02f, -1.84787083e-02f, -4.53592166e-02f, 6.68014959e-02f, -7.93886632e-02f, -5.45352548e-02f, -2.52773799e-02f, 4.00003456e-02f,
  -6.92086965e-02f, -7.69425035e-02f, -2.81474404e-02f, -9.82281007e-03f, 8.31572413e-02f, -1.67393275e-02f, 5.47680855e-02f, 1.09538937e-03f, -9.54455361e-02f, 6.11185990e-02f,
  -4.06004131e-01f, 4.95258681e-02f, -3.34601581e-01f, -2.17041343e-01f, 1.97334900e-01f, 1.11052133e-01f, 7.19198585e-02f, -1.72734141e-01f, 2.86354199e-02f, 5.07243909e-02f,
  1.93994403e-01f, 3.04445982e-01f, 1.15021311e-01f, 1.23577215e-01f, -1.95463762e-01f, -3.11801713e-02f, -5.42586371e-02f, -3.83055329e-01f, -1.66775107e-01f, 8.68064240e-02f,
  2.41833642e-01f, -1.33912593e-01f, -3.02193075e-01f, -1.67752519e-01f, 1.52891934e-01f, 2.05078065e-01f, 6.14742935e-02f, -1.82234943e-02f, 8.02572891e-02f, 8.62640738e-02f,
  5.17624840e-02f, -1.38369083e-01f, 2.06360221e-02f, 7.12212548e-03f, 5.69187738e-02f, -7.16616884e-02f, -3.57602239e-02f, -1.14192970e-01f, 1.99375786e-02f, -4.04860154e-02f,
  -4.42835614e-02f, 4.04185541e-02f, 5.29420227e-02f, 3.98984477e-02f, 1.05417334e-02f, -9.37854797e-02f, -1.71529695e-01f, -1.09390885e-01f, -1.06497966e-01f, -4.70266230e-02f,
  1.51552036e-01f, -8.02778751e-02f, -2.21106842e-01f, 3.85943502e-02f, -7.81277288e-03f, -6.35446310e-02f, 7.05511775e-04f, -5.78053258e-02f, -1.35979816e-01f, -1.77401945e-01f,
  3.91080976e-02f, 2.57578716e-02f, 8.66889730e-02f, 9.33783501e-02f, 1.61691308e-02f, 3.89880799e-02f, 5.14969602e-02f, 8.54716543e-03f, 4.69470620e-02f, 2.94507649e-02f,
  2.38370448e-02f, -2.68354509e-02f, 6.62927632e-04f, 1.45603269e-02f, 1.51385078e-02f, -4.43526870e-03f, 3.98363657e-02f, 6.95978850e-02f, -3.67553830e-02f, 5.64172082e-02f,
  5.83533831e-02f, 3.27731036e-02f, 6.34842888e-02f, 2.25830767e-02f, 1.54992454e-02f, -8.05036537e-03f, 7.40302727e-02f, 3.82979475e-02f, 3.85444313e-02f, -5.05886264e-02f,
  1.71695769e-01f, -7.49140680e-02f, 6.92640692e-02f, -8.71192757e-03f, -8.39788988e-02f, 3.45830694e-02f, 7.85330832e-02f, -4.90250960e-02f, 3.36882547e-02f, 5.53799036e-04f,
  1.98545009e-02f, -9.07555819e-02f, 4.42279726e-02f, 6.73822220e-03f, 2.90136896e-02f, 3.47984135e-02f, 1.30556850e-02f, -4.33002114e-02f, -7.51532521e-03f, 5.95410243e-02f,
  2.40623690e-02f, -1.01454109e-01f, -1.03229366e-01f, -1.09097801e-01f, 1.92479063e-02f, 2.36893855e-02f, -1.17222844e-02f, 2.27478947e-02f, -8.38293582e-02f, -9.45016891e-02f,
  5.07792652e-01f, 2.01245219e-01f, -1.00754827e-01f, 1.36925116e-01f, -1.04581490e-01f, -1.98688522e-01f, -3.16306621e-01f, -4.03326121e-04f, 8.06423426e-02f, 8.72809440e-02f,
  1.90241963e-01f, 1.79872796e-01f, 8.45155958e-03f, 8.57563987e-02f, 2.21157391e-02f, -4.44782488e-02f, -9.51610133e-02f, -9.51869711e-02f, -6.32407293e-02f, 2.86860834e-03f,
  2.89205853e-02f, 1.01595543e-01f, 1.50077656e-01f, 1.00178890e-01f, 6.59515709e-02f, -3.50185446e-02f, 3.13309468e-02f, 7.05035403e-02f, 1.00682359e-02f, 1.79038867e-01f,
  1.11068085e-01f, 1.81125551e-01f, -5.07416986e-02f, 8.90305489e-02f, 3.36355641e-02f, 1.66353509e-01f, 8.81438032e-02f, 1.59950480e-01f, 6.35920018e-02f, 1.14864372e-01f,
  5.27361892e-02f, 1.51635334e-01f, 6.14420213e-02f, 8.11994523e-02f, 7.97462240e-02f, 5.59512675e-02f, 1.41741291e-01f, 1.45338401e-01f, 9.15343165e-02f, 1.71685413e-01f,
  1.23603962e-01f, 1.06221117e-01f, 7.03039467e-02f, -5.38982376e-02f, 1.60253987e-01f, 6.03767522e-02f, 3.37976180e-02f, 1.29339337e-01f, 2.85015497e-02f, 1.38414294e-01f,
  -1.29039260e-02f, -5.29984087e-02f, -5.52582629e-02f, -1.06918380e-01f, -2.51587182e-02f, -8.07974190e-02f, -1.03777274e-01f, -9.59870666e-02f, -4.20995913e-02f, -1.44157082e-01f,
  -1.05376327e-02f, -5.57351783e-02f, -2.36774739e-02f, -2.17512138e-02f, -1.30042478e-01f, -5.34191765e-02f, -9.75357518e-02f, -3.38637270e-02f, -5.23940735e-02f, -3.98732089e-02f,
  -5.96820489e-02f, -6.48055151e-02f, -9.26919803e-02f, -8.89955014e-02f, -2.60118302e-02f, -8.24760124e-02f, -4.68510129e-02f, -1.26776174e-01f, -3.41643319e-02f, 4.42445697e-03f,
  8.35279673e-02f, 3.81372906e-02f, 1.19456433e-01f, 9.72245932e-02f, 6.04458787e-02f, 1.00162402e-01f, 4.78168689e-02f, 7.27519765e-02f, 1.40215203e-01f, 1.25954524e-01f,
  4.00316678e-02f, 1.01689592e-01f, 5.81618398e-02f, 1.54339820e-01f, 4.48109657e-02f, 1.08753294e-02f, 1.35379639e-02f, 3.99119370e-02f, 6.59535527e-02f, 1.56678513e-01f,
  1.98363289e-02f, -2.63831578e-02f, -1.17108822e-01f, -5.74141182e-03f, 7.18825012e-02f, 5.11176251e-02f, -8.33834708e-02f, -1.08231768e-01f, -4.55105118e-02f, -5.92187755e-02f,
  -1.19350210e-01f, 2.32483715e-01f, 2.23995373e-01f, 1.87214360e-01f, 1.56735629e-01f, -7.38876686e-02f, -8.31235498e-02f, -9.08919349e-02f, 1.23577602e-01f, 2.48220116e-01f,
  2.91036554e-02f, -8.64161029e-02f, 8.59355405e-02f, 3.49478200e-02f, -1.53911948e-01f, 2.52460688e-01f, 3.86458158e-01f, 1.36248961e-01f, -2.82335598e-02f, 2.56894529e-03f,
  1.22748010e-01f, 2.23813742e-01f, 3.14498879e-02f, -2.73770932e-02f, 3.42028737e-01f, 2.00080737e-01f, 2.08115160e-01f, 1.99755400e-01f, 1.88037276e-01f, 5.10054469e-01f,
  2.59981573e-01f, -1.87984575e-02f, 9.98232737e-02f, 1.02364928e-01f, 1.05956495e-01f, 1.25294417e-01f, 1.55143356e-02f, 1.24873646e-01f, 2.89878659e-02f, 6.80705234e-02f,
  1.13099761e-01f, 6.07909262e-02f, 7.37654865e-02f, 1.39979914e-01f, 5.91816939e-02f, 6.55294359e-02f, 1.58476844e-01f, 1.28707632e-01f, 3.97704504e-02f, 3.45870852e-02f,
  1.72898218e-01f, 1.71882197e-01f, 7.04030832e-03f, 1.03669569e-01f, 3.55387554e-02f, 1.31407738e-01f, 8.53995755e-02f, 1.12245165e-01f, -4.17887084e-02f, 2.00051799e-01f,
  -1.83156300e-02f, -1.15423039e-01f, -4.24845591e-02f, -2.63795145e-02f, -3.51314545e-02f, -2.63216719e-02f, -7.33973682e-02f, 2.54920218e-02f, -5.35952263e-02f, -3.25492099e-02f,
  -5.48185073e-02f, -9.48641673e-02f, -6.41801432e-02f, -9.37662348e-02f, -5.39121637e-03f, -7.03495294e-02f, -8.68606344e-02f, -6.32034540e-02f, -8.37866440e-02f, -9.65131149e-02f,
  -1.04093827e-01f, -1.34922981e-01f, -7.62412474e-02f, -1.48241803e-01f, -2.83517912e-02f, -7.76102692e-02f, -7.57247284e-02f, -1.53619438e-01f, -3.94591875e-02f, -1.12244159e-01f,
  1.42434359e-01f, -9.49639902e-02f, 1.51490971e-01f, 1.35917172e-01f, 1.19587883e-01f, 5.43055758e-02f, 1.62977025e-01f, 1.09866165e-01f, 9.42743793e-02f, 1.27916172e-01f,
  7.58151617e-03f, 5.90569153e-02f, 1.28787547e-01f, 1.31403580e-01f, 3.97833697e-02f, 1.41440153e-01f, 8.73025209e-02f, 1.31387666e-01f, 1.07852034e-01f, 1.55007884e-01f,
  6.32674843e-02f, 1.52851462e-01f, 1.01122044e-01f, 5.70144840e-02f, 4.05332148e-02f, -4.91667464e-02f, 1.11233369e-01f, 7.54019022e-02f, -1.25922924e-02f, 1.27869815e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.18577242e-01f, 2.66515940e-01f, 4.26941514e-01f, 1.82014704e-01f, 2.85834372e-01f, 2.88900077e-01f, 2.86003649e-01f, 2.14109525e-01f, 1.19737707e-01f, 1.04131773e-01f,
  2.42994696e-01f, 1.78486466e-01f, 1.54909611e-01f, 2.08386227e-01f, 1.11889631e-01f, -3.49440277e-02f, -6.28411174e-02f, 1.26354799e-01f, 9.24509019e-02f, 1.38551235e-01f,
  1.53069124e-02f, -5.06381020e-02f, 5.84626570e-02f, 2.12249830e-02f, -1.19160660e-01f, -8.07658508e-02f, 8.88187736e-02f, -8.33324809e-03f, -3.13118398e-02f, -1.79002777e-01f,
  2.17674464e-01f, 2.22578332e-01f, 1.53147625e-02f, -8.49355757e-02f, 2.83687524e-02f, -5.25838472e-02f, 1.15364455e-01f, -1.19655445e-01f, -4.01669517e-02f, -2.61447858e-02f,
  -1.53053254e-01f, -1.05126128e-01f, -6.76054209e-02f, -9.36679989e-02f, -1.16385175e-02f, -1.20017514e-01f, -2.88327225e-02f, 8.56318101e-02f, 3.00266109e-02f, -6.44204319e-02f,
  -4.98106778e-02f, -7.58805685e-03f, 2.06623644e-01f, -1.21762361e-02f, 8.49013180e-02f, -7.04765171e-02f, 9.07696858e-02f, 1.37752399e-01f, 1.47265688e-01f, 2.63273008e-02f,
  2.42870495e-01f, 1.16711482e-01f, 1.99327454e-01f, 4.51376028e-02f, -7.13395700e-02f, -1.12360932e-01f, -7.73549229e-02f, -2.27218028e-02f, 2.82879192e-02f, -3.62755544e-02f,
  6.99989349e-02f, 2.22862929e-01f, 8.54369253e-02f, 1.02394819e-01f, 8.92835855e-02f, -2.76690833e-02f, -1.17702030e-01f, 7.88189024e-02f, -3.35598178e-02f, 8.84838123e-03f,
  -1.79434400e-02f, -5.57239242e-02f, -1.90542176e-01f, -1.17570587e-01f, -8.58051106e-02f, 3.61101516e-02f, -1.05571397e-01f, 4.45062369e-02f, 2.32506432e-02f, 8.91014468e-03f,
  -2.21051052e-01f, 3.17989647e-01f, 6.13458790e-02f, 2.85914280e-02f, -2.44347394e-01f, -2.44261205e-01f, 1.40064299e-01f, -7.35667050e-02f, -1.66879699e-01f, -4.21398059e-02f,
  2.25446634e-02f, -1.43387951e-02f, 2.19090432e-02f, -1.34187356e-01f, -6.15198091e-02f, -1.96213722e-01f, -7.83976167e-02f, 5.35153151e-02f, -1.45631039e-03f, -1.56227887e-01f,
  -3.83429602e-02f, -5.99715337e-02f, 7.97108114e-02f, -1.42872864e-02f, -1.13615230e-01f, -4.82589267e-02f, -5.10207787e-02f, -7.41489306e-02f, 3.20534222e-02f, -8.44008774e-02f,
  -8.12291205e-01f, 1.23270065e-01f, -5.00051439e-01f, -4.41545397e-01f, -2.98250556e-01f, -1.46089733e-01f, 6.62213191e-02f, 1.92363292e-01f, -3.28784026e-02f, 2.16010343e-02f,
  2.35592484e-01f, 7.83349723e-02f, 2.80862283e-02f, 1.12935089e-01f, -1.90815121e-01f, -1.51599199e-01f, -4.64018732e-01f, -5.62205493e-01f, -2.92042136e-01f, 1.68261334e-01f,
  -1.67272314e-01f, -5.65489173e-01f, -5.25695801e-01f, -3.01605940e-01f, 4.94619757e-02f, -3.31569947e-02f, -1.20429240e-01f, -3.51604283e-01f, -1.79832369e-01f, -3.42707515e-01f,
  2.32818410e-01f, -3.06826383e-01f, 1.73415169e-02f, 3.11203068e-03f, -8.07151347e-02f, 2.41878219e-02f, 1.04822125e-02f, 7.64298439e-02f, 3.87663320e-02f, 1.19841993e-01f,
  -2.20990442e-02f, 1.42410798e-02f, -1.44737557e-01f, 3.00006401e-02f, -6.81657940e-02f, 7.23532885e-02f, 1.82086989e-01f, 8.93885642e-02f, -2.42973454e-02f, 1.48791954e-01f,
  7.16768950e-02f, 3.35379541e-02f, 8.59837011e-02f, 1.85722589e-01f, 1.29242212e-01f, -6.31706566e-02f, 1.57191455e-01f, 1.17516629e-01f, 1.14931069e-01f, 2.23168850e-01f,
  -2.30806708e-01f, 9.84040052e-02f, 1.73931703e-01f, 4.54290695e-02f, 6.96061030e-02f, 6.36101738e-02f, 2.98575852e-02f, 7.28051513e-02f, 2.70772986e-02f, 7.28405491e-02f,
  1.21457353e-01f, -9.50486287e-02f, 4.09408733e-02f, -4.20625024e-02f, -7.66332224e-02f, -1.09252572e-01f, -4.34942767e-02f, -1.35714365e-02f, -2.40905769e-02f, 6.38032407e-02f,
  8.23835284e-02f, 8.49284381e-02f, -8.07073191e-02f, 9.58505087e-03f, -3.22762714e-03f, -2.39439346e-02f, -3.13822590e-02f, 1.98115259e-02f, -2.29522772e-02f, -1.17003433e-02f,
  2.03347400e-01f, -4.06094283e-01f, 7.64597999e-03f, 4.32374813e-02f, -1.34367928e-01f, -2.09259391e-02f, 1.49577903e-02f, 4.43872251e-02f, -1.01009652e-01f, -3.05446656e-03f,
  1.23340476e-04f, -3.07587725e-05f, 9.69709828e-03f, 1.92590088e-01f, -3.52893434e-02f, -1.08745657e-01f, 1.12045720e-01f, -2.48848759e-02f, -2.27050819e-02f, 5.28049730e-02f,
  7.71510452e-02f, 8.33346397e-02f, 1.14700235e-01f, 1.92674994e-01f, 1.23656467e-02f, -8.36357400e-02f, 1.29597798e-01f, 1.10091716e-01f, -5.47955520e-02f, 2.94941604e-01f,
  -5.97701252e-01f, -2.55027652e-01f, 1.63331792e-01f, 2.93289006e-01f, 4.75285590e-01f, 4.05248374e-01f, 3.34279925e-01f, 2.55117446e-01f, 1.34615332e-01f, 1.83406156e-02f,
  -1.57392308e-01f, -1.84796199e-01f, -1.38933927e-01f, 4.43483666e-02f, 3.78089845e-02f, 3.93692940e-01f, 4.00308996e-01f, 2.31465660e-02f, 1.99883685e-01f, 2.42851272e-01f,
  2.50994653e-01f, 7.73695437e-03f, -1.66426361e-01f, -4.32692356e-02f, 7.36420155e-02f, 7.56954104e-02f, 6.09867685e-02f, 8.51131827e-02f, 1.16088063e-01f, 1.82956740e-01f,
  -4.53734510e-02f, -2.93233752e-01f, 7.11950958e-02f, -2.42543176e-01f, -2.76229322e-01f, -2.64118314e-01f, -1.20738290e-01f, -1.19206652e-01f, -8.29928964e-02f, -1.28192678e-02f,
  -6.26478568e-02f, -9.47872102e-02f, -9.15692672e-02f, -6.91550374e-02f, 3.51635888e-02f, 8.08821525e-03f, -1.13530159e-01f, -9.63499695e-02f, 1.90575719e-02f, -9.78251994e-02f,
  -5.73966652e-02f, 3.90662201e-04f, 1.79578796e-01f, 1.57473773e-01f, 9.28903073e-02f, 5.54951131e-02f, -1.28417149e-01f, -1.32478267e-01f, 7.58381357e-05f, -3.46183628e-02f,
  1.10397093e-01f, -3.55323106e-02f, -1.25416532e-01f, -7.08457008e-02f, -1.62919529e-03f, 1.21853165e-01f, 1.35582730e-01f, 1.51688486e-01f, 7.35121667e-02f, 3.80065758e-03f,
  -1.90345868e-02f, 1.15378723e-01f, 1.23333983e-01f, -1.81038696e-02f, -1.43325567e-01f, -5.77783063e-02f, 1.44615464e-04f, -2.08432227e-01f, -2.34821916e-01f, -6.04259707e-02f,
  -1.12555750e-01f, 1.53310061e-01f, -7.23520145e-02f, -3.36377956e-02f, -2.74371319e-02f, -1.09269239e-01f, -7.76772052e-02f, -1.48963735e-01f, -8.14621970e-02f, 7.64498860e-02f,
  8.97067338e-02f, 8.05157349e-02f, -5.37608378e-02f, -3.80155221e-02f, 1.19678788e-01f, -2.40901172e-01f, 1.30636897e-02f, -6.10804744e-02f, 1.49597377e-01f, 1.14150383e-01f,
  -4.37788665e-03f, -1.25901774e-01f, -1.15611807e-01f, -4.39006202e-02f, 8.04052055e-02f, -5.18898200e-03f, -6.89526275e-02f, 8.86133090e-02f, 1.15053721e-01f, 1.29011139e-01f,
  1.40973488e-02f, 1.28826559e-01f, 1.65455416e-01f, 9.59595963e-02f, 2.20329255e-01f, 1.29899934e-01f, 4.46011946e-02f, 9.25138369e-02f, 8.44204128e-02f, -2.75473483e-02f,
  6.67754352e-01f, 2.53903151e-01f, 3.80765140e-01f, 1.49147585e-01f, -7.14803785e-02f, 2.21511200e-02f, 2.34286800e-01f, 1.29383966e-01f, 7.43840411e-02f, 8.51254016e-02f,
  -8.70277453e-03f, 1.38506508e-02f, 7.95691311e-02f, 5.06007671e-02f, 2.15779141e-01f, 2.04173505e-01f, 2.31538460e-01f, 1.93598583e-01f, 2.10910335e-01f, 8.93335044e-02f,
  -7.88962841e-03f, 1.29815772e-01f, 2.07585588e-01f, 1.61896855e-01f, 1.01473950e-01f, -6.16717227e-02f, 1.49032250e-01f, 3.19959410e-02f, 1.58571228e-01f, 2.69582063e-01f,
  -6.83344230e-02f, 4.55027878e-01f, -1.35054752e-01f, -8.11037421e-02f, 3.81308123e-02f, 2.73683202e-03f, 2.23265495e-02f, -3.63168977e-02f, -1.32823855e-01f, -1.04287378e-01f,
  -1.96954608e-01f, -3.09474245e-02f, -1.46123953e-03f, 4.26255129e-02f, -9.68821533e-03f, -7.33756125e-02f, 1.42656460e-01f, 2.27457941e-01f, 1.13387972e-01f, -9.59933475e-02f,
  -1.69854179e-01f, -4.31390032e-02f, 5.38493367e-03f, -6.38022125e-02f, 1.28037468e-01f, 6.57532539e-04f, 8.03586319e-02f, 1.11779332e-01f, 2.56460556e-03f, 7.77189508e-02f,
  1.87914502e-02f, 1.29830569e-01f, 1.44550011e-01f, 1.16329007e-01f, 1.36259884e-01f, 8.71926397e-02f, 7.58252740e-02f, -1.09999152e-02f, 4.61942032e-02f, 1.54724166e-01f,
  -3.82475890e-02f, -4.22280841e-02f, -1.79014858e-02f, -1.23869456e-01f, -4.16935198e-02f, -1.23333737e-01f, -1.48485407e-01f, -9.79663432e-02f, 4.54233177e-02f, -3.52614932e-02f,
  8.29231441e-02f, -1.70738026e-02f, 2.82024331e-02f, 1.06478982e-01f, -1.53379023e-01f, 6.17553480e-02f, -1.02790892e-01f, -8.94859154e-03f, -6.83357641e-02f, -7.16784224e-02f,
  -6.30972683e-01f, -2.71056443e-02f, -1.58947948e-02f, 1.76150873e-02f, 3.48452441e-02f, -2.19205469e-02f, 1.70812719e-02f, -3.49431261e-02f, -1.75841704e-01f, -1.12051181e-01f,
  -1.53607264e-01f, 1.19212486e-01f, 6.64754957e-02f, -7.46902020e-04f, -1.11299716e-01f, -2.03630626e-01f, -1.24209233e-01f, -1.38365272e-02f, 5.42199165e-02f, -5.31362519e-02f,
  -3.40197086e-02f, -9.58043784e-02f, -2.00804695e-01f, -6.27736598e-02f, -9.95883495e-02f, -1.12352051e-01f, -1.83844924e-01f, -1.06069528e-01f, -4.95429821e-02f, -1.35825664e-01f,
  -4.31722671e-01f, -2.58725703e-01f, -2.30294108e-01f, -5.77269018e-01f, -1.12135425e-01f, 2.99872726e-01f, 6.77379668e-02f, 1.18089959e-01f, -1.44971311e-01f, -3.32349390e-01f,
  -7.81913549e-02f, 7.13177547e-02f, -1.81034192e-01f, 8.91453698e-02f, 1.62327498e-01f, -2.52674371e-01f, -3.69834423e-01f, -9.83851552e-02f, 4.33558881e-01f, 4.76278394e-01f,
  1.99508563e-01f, -1.79966673e-01f, 1.20126875e-02f, -3.89259905e-02f, -3.27016532e-01f, -1.44724116e-01f, -3.79898489e-01f, -2.23269418e-01f, 1.05961874e-01f, -4.56314266e-01f,
  -3.10598791e-01f, 2.95537487e-02f, 1.98713243e-01f, 3.79929729e-02f, -1.53407276e-01f, 2.45477166e-02f, -6.25637770e-02f, -5.51152229e-02f, 3.87164801e-02f, -9.54009220e-02f,
  -1.09573081e-02f, 2.13002339e-01f, 7.48061091e-02f, 8.83719847e-02f, 4.15306762e-02f, 5.15684672e-02f, 2.06861217e-02f, 9.31976363e-02f, 8.91949907e-02f, -1.04277227e-02f,
  2.77885087e-02f, 8.10776129e-02f, 9.61599052e-02f, 1.49451330e-01f, 1.60927609e-01f, 1.70582741e-01f, 1.20264336e-01f, 2.41081983e-01f, 2.67077386e-01f, -2.41232842e-01f,
  5.75706512e-02f, -9.02471915e-02f, 3.82661596e-02f, -3.76523775e-03f, 1.03454486e-01f, -8.21326580e-03f, -7.90712237e-02f, 1.35087976e-02f, 2.87121162e-02f, 2.56433971e-02f,
  7.29752481e-02f, 7.26169869e-02f, 3.35047431e-02f, -6.46065027e-02f, 2.22478174e-02f, -4.34543528e-02f, 6.60892650e-02f, -8.46951231e-02f, 3.02097499e-02f, -2.52807848e-02f,
  4.55593765e-02f, 1.16824180e-01f, -6.79637194e-02f, 1.49556816e-01f, 1.26880243e-01f, -1.05593622e-01f, -1.79578643e-02f, 1.88043088e-01f, 2.45028213e-02f, 4.87386659e-02f,
  -4.03124183e-01f, 3.38200837e-01f, -2.94513106e-01f, 1.34932166e-02f, -1.32993042e-01f, -5.56947961e-02f, -2.31765479e-01f, -3.73773575e-02f, -1.23261280e-01f, -5.70342802e-02f,
  1.21744148e-01f, -8.05426165e-02f, -5.77963032e-02f, 9.91740916e-03f, 1.46432230e-02f, 4.74079140e-02f, -9.52396765e-02f, -7.72444978e-02f, 1.19931683e-01f, -1.19407810e-01f,
  -7.78251439e-02f, 3.62708494e-02f, -1.34194255e-01f, -7.45907202e-02f, 6.59434870e-02f, 4.01060358e-02f, -8.39730948e-02f, -3.44489701e-02f, 1.65614814e-01f, -4.67328250e-01f,
  3.98101598e-01f, -2.72888225e-03f, 1.21949412e-01f, -5.98903857e-02f, -5.13660833e-02f, -4.72165123e-02f, -1.46388963e-01f, -9.20758024e-02f, -1.24443704e-02f, 6.96679503e-02f,
  4.71683294e-02f, 5.72714880e-02f, 8.56396928e-02f, 1.38818502e-01f, 9.67058614e-02f, -1.78772420e-01f, -1.49114177e-01f, 1.36071220e-02f, 9.47122499e-02f, -1.29342917e-02f,
  -1.67093843e-01f, -2.72530705e-01f, -5.57129197e-02f, -3.95365767e-02f, -1.81077302e-01f, -7.68029466e-02f, -1.94141671e-01f, -2.99935818e-01f, -7.88393095e-02f, -1.51985914e-01f,
  3.38762134e-01f, 1.07880227e-01f, 9.69588235e-02f, 2.17949614e-01f, 1.01084627e-01f, 1.53201178e-01f, 1.34388089e-01f, 6.45603612e-03f, 1.66776001e-01f, 1.75757706e-03f,
  5.05232206e-03f, 2.42658593e-02f, -5.09300418e-02f, -1.07123032e-01f, -7.22071230e-02f, -4.81361263e-02f, 3.15077789e-02f, 2.61877943e-02f, 1.24690302e-01f, 1.11031257e-01f,
  2.44733621e-03f, -9.47230831e-02f, 7.59118646e-02f, 1.70816220e-02f, 8.68379772e-02f, 4.93745543e-02f, 3.68472822e-02f, 7.24123269e-02f, 3.78474295e-02f, -1.10184446e-01f,
  -1.09080777e-01f, 1.45522341e-01f, 2.23291907e-02f, 4.27015591e-03f, -3.68380197e-03f, 5.04971258e-02f, 7.86901712e-02f, -1.71985943e-02f, -6.59450516e-02f, -2.02576682e-01f,
  -8.71706903e-02f, -9.97727886e-02f, -3.83730158e-02f, -3.16427276e-03f, 5.46625219e-02f, -3.96963619e-02f, -5.95915783e-03f, -2.04045083e-02f, -9.60838422e-02f, -8.60282928e-02f,
  -1.63507536e-02f, -3.60528640e-02f, -1.11543044e-01f, -1.23327941e-01f, -1.15326241e-01f, -1.45645902e-01f, -5.48174232e-02f, -2.01783627e-01f, -1.77304655e-01f, -8.22412446e-02f,
  1.50658891e-01f, 1.65492266e-01f, 1.50391415e-01f, -2.90167588e-03f, 2.57040393e-02f, -3.95930894e-02f, 1.65443286e-01f, -3.28132883e-02f, 1.36482855e-02f, 9.92187485e-02f,
  -5.55466721e-03f, -2.41067559e-02f, -7.35250935e-02f, -9.29922089e-02f, -3.85795608e-02f, -5.82405180e-02f, 8.81457478e-02f, 1.89250171e-01f, 1.72239304e-01f, 1.19229265e-01f,
  8.92325491e-02f, 8.27794075e-02f, 1.19018219e-01f, 1.30414918e-01f, -2.41975375e-02f, 4.62212935e-02f, 8.45903531e-02f, -4.31547612e-02f, 1.35389224e-01f, -1.15554847e-01f,
  6.35805368e-01f, -2.20376208e-01f, 1.31541997e-01f, 2.79699564e-01f, 2.02907890e-01f, 2.13530928e-01f, -4.08667922e-02f, -1.13405660e-02f, 1.01359487e-01f, -4.13730331e-02f,
  -7.81747792e-03f, 1.33295774e-01f, 1.32252023e-01f, 1.86626613e-03f, 1.39787987e-01f, 3.50068621e-02f, 1.23632364e-02f, 1.64832175e-01f, 2.62483269e-01f, 1.98058654e-02f,
  -2.03598604e-01f, -6.66596144e-02f, -6.53492510e-02f, -6.20949082e-02f, -2.01063842e-01f, -7.89012481e-03f, -2.25673765e-02f, -1.69783205e-01f, -1.78064898e-01f, -2.08447203e-01f,
  9.55508277e-02f, 2.28524581e-01f, 2.40848958e-01f, 1.12575199e-02f, 3.44635807e-02f, 5.82762733e-02f, 1.55944392e-01f, -7.55412951e-02f, -3.59904282e-02f, -4.01251279e-02f,
  -1.45748844e-02f, -6.76477924e-02f, 4.48733531e-02f, -1.23894013e-01f, -8.13724995e-02f, -6.67489618e-02f, -1.12425752e-01f, 8.31993595e-02f, 1.95355006e-02f, -4.22975719e-02f,
  2.27753893e-02f, 1.35661751e-01f, 1.55837074e-01f, 8.68781283e-02f, 5.50372303e-02f, 1.27575368e-01f, 8.79611075e-02f, -1.67342182e-02f, 6.10374436e-02f, -1.29089549e-01f,
  9.40435156e-02f, 6.67344332e-02f, -2.53987182e-02f, 1.51433572e-01f, 9.78468731e-02f, 1.08440630e-01f, 5.35899922e-02f, 1.46281958e-01f, 7.04167932e-02f, 8.26635957e-03f,
  -6.33665174e-02f, 1.18506722e-01f, 1.92340165e-01f, 3.23376395e-02f, 1.52931288e-01f, 6.65403828e-02f, 1.51050286e-02f, 1.51820602e-02f, 5.10933772e-02f, 9.38751153e-04f,
  9.79822055e-02f, 6.56396896e-02f, -4.25557978e-02f, -1.54697642e-01f, -3.12683322e-02f, 8.80245119e-02f, 6.37581274e-02f, -1.32062867e-01f, -3.37133296e-02f, -9.31491926e-02f,
  9.29316953e-02f, 3.18005294e-01f, 9.05461758e-02f, -1.02795325e-01f, -5.57279475e-02f, -1.29402623e-01f, 7.49864951e-02f, 4.45008464e-02f, 8.86645913e-02f, 2.33032107e-02f,
  -2.13577580e-02f, 3.71264666e-02f, -4.30496633e-02f, -2.19477136e-02f, -3.42069715e-02f, 6.81194738e-02f, 7.62653581e-05f, 6.02104664e-02f, 7.22832931e-03f, -3.27586606e-02f,
  -2.78441571e-02f, 1.26979381e-01f, 2.53495872e-01f, 1.78368390e-01f, 1.17329426e-01f, 1.86659306e-01f, 6.13463446e-02f, -9.04924870e-02f, 1.61546394e-01f, -1.75502181e-01f,
  -1.94724187e-01f, -2.76116252e-01f, -1.73455432e-01f, 1.56665757e-01f, 9.15136859e-02f, -2.41300642e-01f, -6.28002286e-01f, -3.82081419e-01f, 2.44179547e-01f, -1.63210064e-01f,
  9.94178234e-04f, 4.08118248e-01f, 2.59766549e-01f, 2.55884260e-01f, -2.05031991e-01f, -2.02612996e-01f, 3.75084966e-01f, 2.09064350e-01f, -7.58861005e-02f, -4.57046479e-02f,
  2.91154385e-01f, 1.90326914e-01f, 5.66079170e-02f, 3.72319743e-02f, 2.96011150e-01f, 1.90609902e-01f, 1.72816534e-02f, 2.14480966e-01f, -1.32448554e-01f, 5.42881310e-01f,
  -1.05795832e-02f, -1.47381514e-01f, -8.81035905e-03f, 1.40487149e-01f, 1.02048978e-01f, -2.41678774e-01f, -2.27608413e-01f, 9.65388566e-02f, -1.53514640e-02f, -1.20407715e-01f,
  2.01357901e-01f, -1.25221133e-01f, 3.49979699e-01f, -1.46795493e-02f, -2.41238121e-02f, -1.64477274e-01f, 6.07655086e-02f, 3.38129513e-02f, -1.86601579e-01f, -1.35600522e-01f,
  2.55152196e-01f, 1.06605947e-01f, -2.11502194e-01f, -9.35744122e-02f, -1.82663709e-01f, 1.52684316e-01f, -2.21425295e-01f, -1.01981737e-01f, -4.28762823e-01f, -1.00422114e-01f,
  9.23784450e-02f, -4.52482514e-03f, -9.90656484e-03f, 2.52442434e-02f, -4.41049896e-02f, -1.32422755e-02f, 1.31350622e-01f, 2.68067569e-02f, 1.31876111e-01f, -1.12049900e-01f,
  6.53822208e-03f, 2.96612587e-02f, 6.14271834e-02f, -1.48192406e-01f, 7.35253515e-03f, -9.30017233e-03f, -9.60141420e-02f, -5.49514294e-02f, 4.75191884e-02f, -1.20426193e-01f,
  -1.61352046e-02f, -4.35573459e-02f, -2.40378790e-02f, 5.75502850e-02f, -9.19501856e-02f, 1.15885744e-02f, 4.37753536e-02f, -4.56386134e-02f, -1.18538961e-02f, 3.67265418e-02f,
  -1.65252790e-01f, -2.92776455e-03f, -5.15675247e-02f, 8.88727754e-02f, -3.06759868e-02f, 2.76367422e-02f, 5.78161702e-02f, 3.45733538e-02f, -8.45880210e-02f, -1.30717486e-01f,
  -1.43446416e-01f, -1.10722356e-01f, -5.12877703e-02f, 3.26352865e-02f, 2.65193428e-03f, -9.39469710e-02f, 5.63154928e-02f, 5.00357300e-02f, -2.43790094e-02f, -2.36314069e-03f,
  3.00180092e-02f, -2.40700722e-01f, -2.52934605e-01f, -3.81071895e-01f, 7.30587263e-03f, -1.40127912e-01f, -2.16553628e-01f, -2.12592438e-01f, -6.04610145e-01f, -6.77678168e-01f,
  -1.09347498e+00f, -4.31415796e-01f, 1.35051832e-01f, -5.46615303e-01f, -2.47420564e-01f, -2.50936542e-02f, -3.16075623e-01f, -1.70737356e-01f, -3.96686912e-01f, -4.81169015e-01f,
  -2.47750521e-01f, 6.93342313e-02f, 8.51799920e-02f, 2.88858831e-01f, 6.37859991e-03f, -3.77313644e-01f, -3.59209746e-01f, -5.04716113e-02f, 4.81571823e-01f, 2.99861789e-01f,
  -8.56280848e-02f, -1.60945371e-01f, -1.45725146e-01f, 3.28001454e-02f, -8.45105574e-02f, -1.98724607e-04f, -1.38712123e-01f, -1.63120180e-01f, 1.59226321e-02f, -4.32130128e-01f,
  4.35308516e-01f, -1.32628858e-01f, 1.65572576e-02f, -1.84850454e-01f, -1.85684845e-01f, -4.68049347e-02f, -6.18646108e-03f, -1.74547076e-01f, -5.30001707e-02f, -1.63656086e-01f,
  -9.93898585e-02f, 6.36625290e-02f, 8.18127692e-02f, 1.10163152e-01f, -8.21471065e-02f, -1.21094912e-04f, -5.01105227e-02f, -1.38868719e-01f, -7.50505850e-02f, 1.05870016e-01f,
  7.83028528e-02f, -1.02043130e-01f, 2.07683630e-03f, 9.07129142e-03f, 1.52658775e-01f, 2.56170072e-02f, 1.98794529e-02f, 5.84062524e-02f, 7.52371848e-02f, -1.77965418e-01f,
  2.09208895e-02f, 9.13030282e-02f, 8.34635552e-03f, 1.17084021e-02f, -1.04864173e-01f, -5.64832538e-02f, 4.19789180e-02f, 5.49182389e-03f, 1.12279728e-01f, -8.67704377e-02f,
  -1.17019914e-01f, -7.18715191e-02f, 3.22862752e-02f, -6.53856695e-02f, -9.17443782e-02f, -1.00362062e-01f, -5.74940033e-02f, -3.76394019e-02f, 2.12270822e-02f, -1.24252565e-01f,
  -7.96157047e-02f, -6.21498674e-02f, -8.10834989e-02f, 5.09352162e-02f, -4.32113484e-02f, -1.37697607e-01f, 1.67242717e-02f, 6.12777211e-02f, -7.61051755e-03f, -4.57838587e-02f,
  2.48368811e-02f, 3.55420411e-02f, -6.26262277e-02f, 8.75208005e-02f, 3.64227109e-02f, -6.06369935e-02f, -3.86500522e-03f, 4.04419843e-03f, 4.38621454e-02f, 5.78914955e-02f,
  1.81839257e-01f, 6.88819662e-02f, -2.80742384e-02f, -4.72201593e-02f, 7.34340101e-02f, -2.96483822e-02f, -1.27326146e-01f, -3.37531455e-02f, 1.01872817e-01f, 4.85619344e-02f,
  -1.14797272e-01f, -1.38501108e-01f, 1.51024237e-02f, 3.09208613e-02f, 1.50553808e-01f, 1.29771128e-01f, 1.86704695e-01f, 1.76627174e-01f, 2.30490983e-01f, -8.95275250e-02f,
  6.70684636e-01f, -1.86501697e-01f, -7.40017831e-01f, 1.84449345e-01f, -2.92933732e-01f, 2.59282216e-02f, -1.01405539e-01f, 1.99145868e-01f, 1.85258925e-01f, -2.43802577e-01f,
  5.87964021e-02f, 4.46368247e-01f, 1.23123087e-01f, 4.85023297e-02f, 2.05493271e-01f, -4.91476089e-01f, -4.43864733e-01f, -1.88429564e-01f, 3.04532200e-01f, 3.72208148e-01f,
  1.79440439e-01f, 4.02661934e-02f, 3.62018973e-01f, 1.11610949e-01f, -1.88964546e-01f, 5.84780127e-02f, -6.62768245e-01f, -1.38572842e-01f, -1.31327629e-01f, -5.20143688e-01f,
  -1.40919581e-01f, -1.36871517e-01f, -7.45288879e-02f, 1.56711966e-01f, -7.84338340e-02f, 7.19853789e-02f, 1.31569272e-02f, -2.03163862e-01f, 4.26406506e-03f, -8.10193643e-02f,
  5.33585101e-02f, 4.43161987e-02f, 1.80827036e-01f, 7.68978745e-02f, 7.88089335e-02f, 2.19224736e-01f, -7.44128898e-02f, -5.24319969e-02f, -1.58875659e-01f, -7.85411615e-03f,
  8.84964094e-02f, -1.39907151e-02f, -1.03998415e-01f, -1.94226012e-01f, 7.12309331e-02f, -1.33313522e-01f, -1.43013105e-01f, 5.43622524e-02f, -4.31767814e-02f, -2.49915257e-01f,
  -2.96825711e-02f, 1.08361421e-02f, -2.94551235e-02f, -6.16891719e-02f, 5.22184819e-02f, -5.46194166e-02f, 1.44061744e-02f, -3.00635044e-02f, 4.16504927e-02f, -1.43794445e-02f,
  -6.19687997e-02f, -1.92230865e-02f, 4.25297953e-02f, -6.89166933e-02f, -7.05596209e-02f, -5.00800982e-02f, -1.02885086e-02f, -3.15949097e-02f, -8.21616724e-02f, 2.14152168e-02f,
  7.03469962e-02f, -4.14805710e-02f, -1.03206061e-01f, 4.32892144e-02f, -4.32875901e-02f, 7.29452297e-02f, 1.32337855e-02f, -1.08132733e-03f, 1.10699534e-01f, 5.72206490e-02f,
  9.06913262e-03f, -8.71109813e-02f, -1.24957599e-01f, 4.92165647e-02f, 1.20211489e-01f, -6.07265346e-03f, -1.29755199e-01f, -5.94707951e-03f, -4.90524620e-02f, 4.39860523e-02f,
  8.81077126e-02f, 5.74585572e-02f, -1.39912337e-01f, -9.32774469e-02f, -9.17838141e-03f, -3.77496034e-02f, 8.91228914e-02f, 4.68147285e-02f, 3.78616154e-02f, -1.02907278e-01f,
  -4.13917117e-02f, 3.88681665e-02f, 2.15937331e-01f, -1.15819101e-03f, 7.37162232e-02f, 1.56935547e-02f, -1.26334086e-01f, -1.53806135e-01f, 7.40118101e-02f, -1.28209695e-01f,
  -6.62760139e-01f, -2.68730730e-01f, 2.60571837e-01f, -1.40837356e-01f, 3.89895260e-01f, 4.98037279e-01f, 5.48412383e-01f, 1.70720622e-01f, 1.48473363e-02f, 4.30277139e-02f,
  -2.40726694e-01f, -3.62533629e-01f, -2.58295059e-01f, -9.27928719e-04f, 1.04033463e-01f, 3.60044450e-01f, 4.51912373e-01f, 1.33881062e-01f, 1.73220351e-01f, 9.40683261e-02f,
  2.06811279e-01f, -1.75345957e-01f, -4.11500394e-01f, -1.73805580e-01f, -1.47589594e-01f, 9.89304408e-02f, 9.29620266e-02f, -9.83702764e-02f, 6.30857348e-02f, -4.57523763e-02f,
  -4.93986398e-01f, -2.41472125e-01f, 2.05623418e-01f, -1.14185899e-01f, -8.10479838e-03f, -1.41537547e-01f, 1.05099835e-01f, -1.58048779e-01f, -6.09059744e-02f, -1.27233134e-03f,
  -1.07579499e-01f, -8.60686004e-02f, -3.60903144e-02f, 5.26030734e-02f, -1.60508141e-01f, -2.65477388e-03f, -2.26467893e-01f, -3.03488374e-01f, -1.88549399e-01f, -1.30061418e-01f,
  6.67526796e-02f, 5.62920421e-02f, -7.92399570e-02f, 4.01086509e-02f, 2.93997638e-02f, 5.93752638e-02f, -1.92966592e-02f, -1.52703658e-01f, -1.51149064e-01f, -3.94551247e-01f,
  -3.07736881e-02f, -5.11993794e-03f, 2.35182598e-01f, 4.70425747e-03f, -3.10603809e-03f, 6.13704100e-02f, -2.35300884e-02f, -1.05304914e-02f, 3.27518992e-02f, -5.34648858e-02f,
  3.13953720e-02f, 5.18372245e-02f, 1.68785080e-02f, -9.85325873e-02f, -1.05431922e-01f, 5.65258088e-03f, 1.31064221e-01f, -3.31259482e-02f, -6.40017241e-02f, 1.44128993e-01f,
  -4.80356924e-02f, 2.56868806e-02f, -1.98297009e-01f, -7.73353726e-02f, 5.67961857e-02f, 4.51855958e-02f, 7.09016249e-02f, -1.62301660e-02f, -7.26886764e-02f, 6.39244691e-02f,
  -4.68570024e-01f, 1.87303618e-01f, -2.64400065e-01f, 1.28456190e-01f, 6.09584823e-02f, 2.44635306e-02f, 2.83585419e-03f, 1.06888767e-02f, -1.02249049e-01f, -9.39291343e-03f,
  2.17316439e-03f, -8.81729275e-02f, -1.09789781e-01f, 3.40148658e-02f, 7.15566352e-02f, -2.38528959e-02f, 2.95401048e-02f, 1.44755468e-01f, -8.21186453e-02f, -1.66514423e-02f,
  -3.41386050e-02f, 2.90029287e-01f, -7.65953260e-03f, 5.64947315e-02f, -1.61035180e-01f, 1.84770808e-01f, 1.99812744e-02f, 5.82709610e-02f, 8.24355334e-02f, -6.55307621e-02f,
  2.66406715e-01f, -2.00625300e-01f, 1.10293418e-01f, 2.39729360e-01f, 5.87065630e-02f, -3.19746226e-01f, -8.85848105e-01f, -3.85861099e-01f, 1.43034652e-01f, -4.39997911e-01f,
  -1.77083850e-01f, 3.70122999e-01f, 3.71873885e-01f, -7.45974928e-02f, -4.98484343e-01f, -7.02696621e-01f, -4.53312218e-01f, -1.42123356e-01f, -1.43280730e-01f, -5.49233735e-01f,
  -1.32716537e-01f, 1.02716079e-02f, 1.48951830e-02f, 1.73507221e-02f, 1.12749785e-01f, 2.80093700e-01f, 7.86085650e-02f, 1.73879206e-01f, -1.30211011e-01f, 4.50490043e-02f,
  -5.45906909e-02f, -5.50131164e-02f, 6.94616064e-02f, -2.39949450e-02f, 1.74189508e-01f, 8.45263600e-02f, -1.43474057e-01f, 5.80438226e-02f, 1.60089303e-02f, 3.08004823e-02f,
  1.91476062e-01f, -9.88254249e-02f, 1.73165932e-01f, 1.71785980e-01f, -7.59215802e-02f, -1.14289567e-01f, -3.19524184e-02f, -4.58985753e-02f, 4.96305246e-03f, -1.46502122e-01f,
  -1.70769423e-01f, -1.02682047e-01f, 9.48949307e-02f, -3.13763246e-02f, -9.59673375e-02f, 1.23220108e-01f, 1.24379590e-01f, 1.01658128e-01f, 1.48806900e-01f, 1.67709477e-02f,
  -1.77220985e-01f, 1.60896868e-01f, 5.94849288e-02f, -1.12259194e-01f, -8.39188173e-02f, 6.64324164e-02f, 5.90901896e-02f, -1.32448316e-01f, -2.27099955e-02f, 8.41649100e-02f,
  -7.37691969e-02f, 1.12415263e-02f, -9.28912684e-02f, 3.36092710e-02f, 1.19915307e-01f, 1.33748636e-01f, 7.79415369e-02f, -3.21101919e-02f, 9.58241057e-03f, 9.61025134e-02f,
  -3.40299904e-02f, 3.31017114e-02f, 7.42761046e-02f, -1.65803328e-01f, -7.94110820e-02f, -4.86159371e-03f, 1.13451645e-01f, 7.59639516e-02f, 1.40427738e-01f, -8.94613266e-02f,
  1.29158497e-01f, -1.38777062e-01f, 1.02383681e-01f, -1.62133709e-01f, 1.23798996e-02f, 3.35155092e-02f, 2.45001361e-01f, -9.67725888e-02f, 2.43767813e-01f, -9.59420949e-02f,
  -1.22334577e-01f, 5.80516234e-02f, -4.08704802e-02f, -1.18295196e-02f, -1.69787273e-01f, -9.13837329e-02f, -2.07867190e-01f, -8.22732076e-02f, -1.50246039e-01f, 7.17187487e-03f,
  -1.45996660e-01f, -3.67253810e-01f, -9.38093364e-02f, 8.33821483e-03f, 7.14161545e-02f, 1.25282034e-01f, 9.20739770e-02f, 1.65982813e-01f, -4.97593731e-02f, -3.05048227e-01f,
  1.62200704e-01f, 5.81436753e-01f, 1.40636206e-01f, -7.04417527e-02f, 2.85402268e-01f, 2.75413930e-01f, 5.45794249e-01f, 1.39404451e-02f, -2.04133362e-01f, 1.83538869e-01f,
  3.96357059e-01f, -1.80705994e-01f, -1.17834434e-01f, -1.19860813e-01f, -7.55230039e-02f, 9.03947800e-02f, -9.12283137e-02f, -3.18684608e-01f, -4.41765368e-01f, -2.31712729e-01f,
  -1.65725544e-01f, -1.23292640e-01f, -2.16707796e-01f, -1.97654575e-01f, 5.21965027e-02f, -3.10560435e-01f, 2.92328715e-01f, 2.57712007e-01f, 2.96490729e-01f, -9.63253155e-02f,
  3.11557770e-01f, 4.40157831e-01f, -3.23808312e-01f, -1.02411784e-01f, 2.32076824e-01f, -1.73488945e-01f, -2.74946596e-02f, -1.10393494e-01f, 1.00788131e-01f, -6.33831248e-02f,
  1.80014804e-01f, 1.20340765e-01f, 1.78443611e-01f, 3.12222838e-02f, 9.59462970e-02f, -1.09139681e-01f, -2.01063864e-02f, -1.23744808e-01f, -1.48047119e-01f, 3.01384311e-02f,
  -8.55724812e-02f, 1.69688061e-01f, 3.05486947e-01f, -1.65556818e-02f, 6.56775981e-02f, -1.93786919e-01f, 3.06783289e-01f, -1.21193819e-01f, 1.11018069e-01f, -2.84443349e-02f,
  -5.88242598e-02f, 1.87269226e-01f, 5.10529801e-02f, -3.89478616e-02f, -6.75458685e-02f, 2.67848447e-02f, -7.47776628e-02f, 3.89624760e-02f, -1.84157013e-03f, -1.46715948e-02f,
  1.21747572e-02f, -3.07393689e-02f, -5.47676869e-02f, 9.78894532e-03f, -1.20014414e-01f, -8.02859385e-03f, -3.49547975e-02f, -6.81764483e-02f, -4.21180297e-03f, -5.66321239e-03f,
  -8.21855888e-02f, 3.32302302e-02f, 4.17871438e-02f, -2.82026678e-02f, 6.22897558e-02f, -2.25582942e-02f, 1.37428837e-02f, -1.89130679e-02f, -1.06104024e-01f, 6.26064092e-02f,
  -3.52909595e-01f, 5.01862206e-02f, -2.41038904e-01f, -8.66722539e-02f, 2.17170730e-01f, 6.86550215e-02f, 5.97616769e-02f, 6.73387107e-03f, 1.53454870e-01f, -1.97149515e-01f,
  7.21560493e-02f, -1.13743216e-01f, 1.51439145e-01f, -5.43205403e-02f, -1.32218137e-01f, 2.13131420e-02f, 7.80477896e-02f, -2.91971713e-02f, -3.75923291e-02f, 1.10531710e-02f,
  -7.99272060e-02f, -2.45070472e-01f, -2.86850572e-01f, -2.27998108e-01f, -3.14697325e-01f, -3.38261992e-01f, -7.89553300e-02f, -1.86888710e-01f, -8.81968960e-02f, -3.95223320e-01f,
  6.40872777e-01f, -4.51735228e-01f, 4.29738909e-02f, -1.10489570e-01f, -2.51504451e-01f, -3.17525603e-02f, -2.13143632e-01f, 1.21190837e-02f, -5.83005324e-02f, -8.44970122e-02f,
  -3.33972946e-02f, 2.32991904e-01f, 3.75001132e-01f, 2.27090925e-01f, 2.99353361e-01f, -1.97077572e-01f, -3.12324315e-02f, 3.88727963e-01f, 3.53582829e-01f, -4.88232709e-02f,
  -1.91279307e-01f, -1.46737963e-01f, 1.06661499e-01f, -5.20808585e-02f, -3.56103331e-01f, 6.67136014e-02f, -1.90621018e-01f, -1.11278690e-01f, -8.27478990e-02f, -2.21494183e-01f,
  2.37360746e-01f, 1.04386866e-01f, -2.58452985e-02f, 2.91782375e-02f, -3.88144776e-02f, -3.41434665e-02f, 4.64131497e-02f, -9.76629853e-02f, -1.14243910e-01f, -1.86125990e-02f,
  -2.55940147e-02f, -1.26856476e-01f, 7.08409250e-02f, -1.95901468e-01f, -1.92768231e-01f, -1.24972001e-01f, -4.03962694e-02f, 3.96272205e-02f, -5.08247502e-02f, -1.01201385e-01f,
  -7.92180598e-02f, 6.65144324e-02f, -1.47605194e-02f, -1.06388792e-01f, -2.22781580e-02f, 1.56844914e-01f, -1.70516089e-01f, -1.66351378e-01f, -4.37575430e-02f, -2.33007088e-01f,
  -1.19934700e-01f, 1.19559793e-02f, -3.39017361e-02f, 1.56746581e-02f, 4.75911312e-02f, 5.49524762e-02f, 1.29595473e-01f, 2.73030326e-02f, -1.79868210e-02f, 3.12732533e-02f,
  -5.72198890e-02f, -1.78315882e-02f, 1.56520884e-02f, -4.56170700e-02f, 2.02242173e-02f, 9.90629569e-02f, 3.62693565e-03f, -1.16882222e-02f, 5.81489727e-02f, 8.54734033e-02f,
  7.42767379e-02f, 4.02518921e-02f, -1.63012333e-02f, 1.54441334e-02f, -8.88523161e-02f, 7.46571049e-02f, -2.47383174e-02f, -4.50291075e-02f, -1.27228182e-02f, -4.73735929e-02f,
  6.97965175e-02f, 3.18863869e-01f, 1.87671199e-01f, 9.51046124e-02f, -4.47307378e-02f, -5.09917103e-02f, 5.04745096e-02f, 9.94200353e-03f, -8.22985247e-02f, 2.04226524e-02f,
  1.23406705e-02f, 2.57828943e-02f, 5.76689793e-03f, -1.28606129e-02f, -1.47592321e-01f, 1.18966717e-02f, -5.11171147e-02f, 1.03485242e-01f, 1.63990155e-01f, -2.33425368e-02f,
  -1.00822777e-01f, 3.89599986e-02f, 1.78581953e-01f, 1.33957446e-01f, 1.35876745e-01f, 3.08008045e-01f, 1.72644854e-01f, 5.28056547e-02f, 1.91646516e-01f, -1.35596141e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.50745988e-01f, 6.19913518e-01f, 2.23416865e-01f, 3.31998438e-01f, 2.46500731e-01f, -1.32761076e-01f, 1.44920021e-01f, 5.10150909e-01f, 3.30355555e-01f, 2.43586615e-01f,
  6.74015045e-01f, 3.59459907e-01f, 5.42376757e-01f, 2.41279200e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.72036314e-01f, -1.76531952e-02f, 1.13141000e-01f, -1.69314593e-01f, -2.77647167e-01f, -8.56415927e-02f, 1.58011183e-01f, 1.21547049e-02f, 1.25442997e-01f, 5.77345956e-03f,
  5.23491204e-02f, 1.07594274e-01f, 2.80513056e-02f, 1.13562113e-02f, 1.26444642e-02f, 4.94327880e-02f, -3.25603262e-02f, -2.98131835e-02f, -1.74169332e-01f, -7.61626214e-02f,
  -1.03082277e-01f, -1.37517020e-01f, 1.48383740e-04f, 3.96009944e-02f, 3.49941291e-02f, -3.09130419e-02f, 2.00757593e-01f, -2.93042183e-01f, 1.85559243e-01f, -1.93071082e-01f,
  -2.43889973e-01f, -7.42394105e-03f, -8.27781782e-02f, -2.46471521e-02f, 1.21027023e-01f, 1.15433149e-01f, 5.43945543e-02f, 3.39141451e-02f, 3.84687539e-03f, 6.28931969e-02f,
  -1.32078007e-01f, 2.39793241e-01f, -1.34012684e-01f, -2.23992556e-01f, 4.35680524e-02f, -1.23404838e-01f, -8.69387835e-02f, 2.76885852e-02f, -5.31369038e-02f, -6.17607050e-02f,
  6.37022033e-02f, -1.05854943e-02f, -2.04378217e-01f, -9.98349115e-02f, 2.81149298e-01f, -8.93133730e-02f, -7.31187016e-02f, 2.82482624e-01f, -9.62811634e-02f, 1.03453249e-01f,
  -1.40298873e-01f, 1.18909933e-01f, -1.85807064e-01f, -1.52177557e-01f, 6.62107915e-02f, 5.15056923e-02f, 1.06625035e-02f, 5.32320961e-02f, 5.04584610e-02f, 9.66749340e-03f,
  1.58140168e-01f, 9.57582444e-02f, 1.22987494e-01f, 3.94717269e-02f, 1.98242977e-01f, 1.67008445e-01f, -5.00773080e-02f, 1.89619914e-01f, 6.39301836e-02f, -4.77548130e-02f,
  -2.05663368e-01f, -2.26364940e-01f, 1.84319317e-01f, -7.59767666e-02f, 6.17231615e-02f, 8.74699876e-02f, -6.26015142e-02f, -3.78110521e-02f, 5.22712357e-02f, 4.88593802e-02f,
  1.07298560e-01f, 3.02339077e-01f, 5.52355312e-02f, -1.46636823e-02f, 4.74302284e-02f, -1.05487823e-01f, -1.11945741e-01f, 7.32362941e-02f, -2.24304274e-01f, 1.61431178e-01f,
  -1.76211163e-01f, -8.73239636e-02f, -4.49455716e-02f, -3.34342499e-03f, -1.82204926e-03f, -7.29914308e-02f, -1.58450678e-01f, 2.38619912e-02f, 1.22655287e-01f, -1.43044088e-02f,
  -6.64866269e-02f, -2.83459038e-01f, 6.44382387e-02f, 7.55005479e-02f, 8.62438008e-02f, 1.72395855e-01f, -1.40980273e-01f, 3.07085544e-01f, 4.73964475e-02f, -1.54632464e-01f,
  1.17692947e-01f, -2.02821240e-01f, -3.74111384e-01f, -2.69494262e-02f, -2.33626917e-01f, -2.18172863e-01f, 2.03950733e-01f, -8.39853957e-02f, -5.83878756e-02f, 7.65736774e-02f,
  1.13679208e-01f, 5.84058277e-02f, -4.85667121e-03f, -3.67976092e-02f, -1.06085953e-03f, -4.63110618e-02f, 4.83196490e-02f, -1.37440771e-01f, 2.43797198e-01f, -1.59063190e-02f,
  7.22102299e-02f, 2.45897076e-03f, -8.15574676e-02f, 1.15670472e-01f, 1.09637439e-01f, 5.70408106e-02f, -1.37588561e-01f, -6.20457418e-02f, -1.01722457e-01f, -8.19887221e-02f,
  -6.78968355e-02f, 6.54948279e-02f, 9.00176179e-04f, 1.46677464e-01f, -1.99181703e-03f, -9.97852907e-02f, -5.91157489e-02f, 7.99899772e-02f, -8.53560418e-02f, 5.12728170e-02f,
  -4.34759296e-02f, 1.06157362e-01f, -7.33153075e-02f, -2.65164934e-02f, -8.55816975e-02f, 1.05756350e-01f, -1.14465930e-01f, -1.78543210e-01f, -5.36771379e-02f, 1.97748795e-01f,
  -1.10256143e-01f, -1.21391542e-01f, 9.51246470e-02f, 8.58598724e-02f, -2.40280181e-01f, -4.16755350e-03f, -1.94247678e-01f, 1.12851365e-02f, -2.46876143e-02f, 2.00297773e-01f,
  -7.24038258e-02f, 5.58962002e-02f, -6.92874864e-02f, -1.59902140e-01f, -1.68497443e-01f, 1.80589244e-01f, 1.34054497e-01f, -4.74696785e-01f, 2.11575359e-01f, -2.33267114e-01f,
  -2.38820627e-01f, -2.19153568e-01f, 1.63401756e-02f, 3.08409184e-02f, 9.84894298e-03f, -6.90631568e-02f, -3.94832008e-02f, 2.62519252e-02f, -6.05467483e-02f, 4.50385883e-02f,
  -3.56382541e-02f, 7.93196484e-02f, -1.20337896e-01f, 4.33324575e-02f, -2.27488279e-02f, 1.32504748e-02f, 4.64856485e-03f, -1.29234597e-01f, 1.15072593e-01f, -3.54853785e-03f,
  9.16547666e-04f, -6.00793250e-02f, -8.89539346e-02f, 6.97228238e-02f, -1.10011129e-02f, -7.63692558e-02f, -2.22113989e-02f, -9.18597206e-02f, -1.04369238e-01f, -1.56609774e-01f,
  -2.97668832e-03f, -4.67064120e-02f, -6.11849837e-02f, 8.61269385e-02f, 2.67118011e-02f, -7.19784647e-02f, -8.89527500e-02f, -1.13905631e-01f, 1.74952876e-02f, -1.39036332e-03f,
  -1.35767266e-01f, -1.63113279e-03f, 6.34958968e-02f, 2.34251216e-01f, 2.11764365e-01f, -3.56979519e-02f, 1.04572430e-01f, 3.47722434e-02f, 2.43675541e-02f, 1.12220511e-01f,
  -2.20513493e-01f, -1.09530821e-01f, 1.31062612e-01f, 4.89464961e-02f, 3.04167300e-01f, -2.59315163e-01f, 1.70041502e-01f, -1.61307618e-01f, 5.23461737e-02f, -1.14496358e-01f,
  3.73457223e-01f, 2.55954444e-01f, 6.19968176e-01f, -2.78754085e-01f, -1.19718753e-01f, -1.39332771e-01f, -1.28115579e-01f, -2.78314725e-02f, -1.13664225e-01f, 9.78466049e-02f,
  -7.08041489e-02f, -5.69189303e-02f, 3.83326672e-02f, -6.68017492e-02f, -1.14736587e-01f, -1.63376734e-01f, 9.66907740e-02f, 1.47865703e-02f, 1.83700860e-01f, 3.71698253e-02f,
  -5.26407957e-02f, -8.05709362e-02f, 7.51196221e-02f, -1.14463478e-01f, -9.80457962e-02f, -1.15220547e-01f, 1.25901818e-01f, -1.22931086e-01f, -5.24917990e-02f, -6.50249720e-02f,
  -6.29602969e-02f, 2.13438757e-02f, -1.30144134e-01f, 7.89367687e-03f, -5.56643568e-02f, -4.99998815e-02f, 2.32473984e-02f, -2.58359939e-01f, -2.55713612e-02f, 1.80166552e-03f,
  -4.92463671e-02f, 1.41393781e-01f, -1.46107703e-01f, 1.73859984e-01f, 8.02603960e-02f, -4.63032462e-02f, -1.05346002e-01f, -5.86166345e-02f, 9.87072513e-02f, -5.27221933e-02f,
  -6.57273643e-03f, 2.10367426e-01f, -3.50683331e-02f, -2.23806761e-02f, 5.40455095e-02f, 8.12573433e-02f, -1.60151109e-01f, 1.16911754e-01f, -5.94206192e-02f, 1.79199979e-01f,
  1.44617647e-01f, -3.74100693e-02f, -2.30550006e-01f, -3.33863012e-02f, 9.98911038e-02f, -5.88161170e-01f, 2.07290724e-01f, -1.43894926e-01f, 3.13179582e-01f, -1.36991635e-01f,
  2.37919271e-01f, 5.36213852e-02f, 4.88371290e-02f, 4.64844443e-02f, -2.76713781e-02f, -1.11460440e-01f, 3.59928347e-02f, 1.33237559e-02f, -2.91155875e-02f, 9.16632190e-02f,
  8.57546926e-02f, 8.95059854e-03f, 7.47067556e-02f, -4.59147505e-02f, 1.53732494e-01f, -4.78846617e-02f, 1.53988853e-01f, -3.33255082e-02f, -8.90161991e-02f, -2.68179160e-02f,
  8.67027640e-02f, 7.32218549e-02f, 1.60919186e-02f, -3.90284657e-02f, 2.35241856e-02f, 2.03137174e-02f, -1.01242945e-01f, 9.92228910e-02f, -2.16813907e-02f, 4.79789041e-02f,
  3.47794853e-02f, 4.12287638e-02f, 3.55335996e-02f, -7.69378841e-02f, -1.58773493e-02f, 2.72826791e-01f, -6.78304359e-02f, -1.51439995e-01f, 1.57714397e-01f, 1.13316521e-01f,
  -2.81672180e-01f, 2.73594502e-02f, -8.14200938e-02f, 7.93912187e-02f, 1.95015669e-01f, 3.90665442e-01f, 1.00508425e-02f, 1.62499711e-01f, 3.24824154e-02f, -7.13486895e-02f,
  1.96585450e-02f, 2.47978717e-01f, -2.22680822e-01f, -4.49137911e-02f, -1.67516455e-01f, -5.89683242e-02f, -4.66525219e-02f, -2.70110399e-01f, -3.80984172e-02f, -1.55616209e-01f,
  -3.93864885e-03f, -1.14103943e-01f, 3.38284403e-01f, -1.09897129e-01f, -1.50192782e-01f, 1.11410618e-02f, -3.98350582e-02f, -1.18559249e-01f, -1.22212656e-02f, -1.25495657e-01f,
  -7.18010962e-02f, 3.99735011e-02f, -1.04322501e-01f, 6.54437244e-02f, -1.60814345e-01f, 3.46336663e-02f, -7.76189268e-02f, 3.32707446e-03f, -1.81923509e-01f, 5.58719784e-02f,
  -8.30056444e-02f, -1.16263442e-01f, -1.67706609e-01f, -5.56220417e-04f, 7.75689185e-02f, -6.52439520e-02f, 4.41407040e-02f, 1.54865369e-01f, -1.51498541e-01f, -2.80386835e-01f,
  -5.20588383e-02f, -2.68161654e-01f, 2.06128404e-01f, 5.22034839e-02f, 1.17981128e-01f, -1.77334074e-03f, 3.81037518e-02f, -3.47254500e-02f, 2.30509918e-02f, 1.19944200e-01f,
  1.85196951e-01f, -8.61423910e-02f, 8.64716917e-02f, 8.77857432e-02f, -1.35209367e-01f, 9.44215730e-02f, 1.47649571e-01f, 6.93303421e-02f, 1.09470017e-01f, 1.79768875e-01f,
  7.04233646e-02f, 3.42754573e-01f, 2.89359447e-02f, 3.51650976e-02f, -7.87841231e-02f, 1.78135991e-01f, -1.34840176e-01f, 6.18065521e-02f, -6.51050881e-02f, -1.38777822e-01f,
  -3.74182835e-02f, 1.90994859e-01f, 3.62983681e-02f, 1.96472511e-01f, 3.07394154e-02f, 2.76798150e-04f, 4.26667854e-02f, -3.36246043e-01f, 3.02199498e-02f, -1.14777960e-01f,
  -9.71158892e-02f, 1.05899788e-01f, -8.39715078e-02f, -1.23409651e-01f, -1.40661463e-01f, 5.36257215e-02f, -9.30817127e-02f, -6.91564456e-02f, 9.05306414e-02f, -4.16457765e-02f,
  1.20534465e-01f, 7.86633044e-03f, 1.46544194e-02f, -1.26036897e-01f, 1.05818316e-01f, 1.59362569e-01f, 3.58689427e-02f, -1.47774160e-01f, -1.14878990e-01f, 3.93575174e-04f,
  -4.74914946e-02f, 1.07992843e-01f, -3.44230495e-02f, 1.76384792e-01f, -3.06966268e-02f, -6.03944361e-02f, -1.11271530e-01f, -1.78248763e-01f, -8.36528018e-02f, 4.38672770e-03f,
  6.97855577e-02f, 2.08494812e-01f, -6.64034858e-02f, -1.41090184e-01f, -1.88357428e-01f, 8.76223892e-02f, -1.19617768e-01f, -6.51049688e-02f, -1.55372526e-02f, 9.10088569e-02f,
  -8.56412873e-02f, -1.38067186e-01f, 4.12886739e-02f, 4.20965552e-02f, -8.14165026e-02f, -2.17216439e-03f, -1.76886231e-01f, 4.15590107e-02f, 3.71895656e-02f, -2.47968361e-01f,
  2.78148443e-01f, 1.14624076e-01f, -2.83352528e-02f, -2.81064790e-02f, 1.04440026e-01f, 5.79487868e-02f, 5.92268445e-02f, -6.38137817e-01f, 1.23682223e-01f, -2.57758647e-01f,
  -1.87700927e-01f, -8.82626176e-02f, -6.12089736e-03f, -3.98228541e-02f, 6.34608418e-02f, -1.16475560e-01f, -2.92415116e-02f, 1.70988869e-02f, 5.85913509e-02f, 6.54224679e-02f,
  1.31298117e-02f, 5.72548136e-02f, -1.30276203e-01f, 6.83071241e-02f, 1.32751577e-02f, -9.35091898e-02f, -1.30125865e-01f, 2.86739748e-02f, 3.81728187e-02f, -7.24448040e-02f,
  1.33724033e-03f, -2.96624955e-02f, 6.30199164e-02f, -3.95335220e-02f, 8.19053650e-02f, 5.52192479e-02f, -1.92671847e-02f, -2.24645033e-01f, 1.11811303e-01f, -3.28193396e-01f,
  2.15886012e-01f, -1.54606819e-01f, 3.59128639e-02f, -9.18232799e-02f, 4.08941619e-02f, 3.18575092e-02f, 1.88042983e-01f, 1.52815193e-01f, 8.03003553e-03f, 2.80416477e-02f,
  1.57860339e-01f, 1.77185386e-02f, -1.21366918e-01f, -4.98991311e-02f, 5.25545049e-03f, -1.33297473e-01f, 5.65504795e-03f, 1.30864576e-01f, 5.10004126e-02f, 2.68155605e-01f,
  1.32706359e-01f, 2.05231402e-02f, 9.11348499e-03f, -2.26304337e-01f, 3.39140855e-02f, 5.22319861e-02f, 1.31414264e-01f, -2.31095627e-01f, -8.47333893e-02f, 3.21584493e-01f,
  2.34362453e-01f, 1.22368991e-01f, -1.86775923e-02f, 2.54773140e-01f, -2.21836418e-02f, -1.93912700e-01f, -3.29763532e-01f, -3.02703008e-02f, 5.37647419e-02f, -3.47680822e-02f,
  2.90139671e-02f, 2.22116373e-02f, 1.40125960e-01f, -1.40611958e-02f, -6.37355670e-02f, -2.18897730e-01f, -7.00738803e-02f, -1.46087185e-01f, -6.95161000e-02f, 1.29442632e-01f,
  -6.65497929e-02f, 6.89407066e-02f, -2.00641125e-01f, -1.56138673e-01f, 4.72734980e-02f, -6.06406294e-03f, -8.19337219e-02f, 3.72276269e-02f, -2.14217007e-02f, -2.35207714e-02f,
  -5.37418835e-02f, -1.14180110e-01f, 3.09302788e-02f, -1.14792012e-01f, 5.40724136e-02f, -2.67275106e-02f, -1.19477278e-02f, -1.05629772e-01f, -2.77185328e-02f, 6.30727634e-02f,
  4.85563204e-02f, 6.59758747e-02f, 5.32498434e-02f, -2.23858096e-02f, 4.12997119e-02f, -2.53272783e-02f, 1.11769684e-01f, -1.29919266e-02f, 1.01887345e-01f, -1.32817671e-01f,
  -1.59653157e-01f, -3.33446980e-01f, 2.78862063e-02f, -9.91798714e-02f, 1.56492189e-01f, 5.65410778e-02f, -5.92949465e-02f, -1.34901404e-01f, -3.49053413e-01f, 1.21345073e-01f,
  2.57630557e-01f, 6.55934438e-02f, 8.09188560e-02f, 2.95262605e-01f, -2.28740737e-01f, 4.01306838e-01f, -3.15959483e-01f, 5.52025586e-02f, -2.06498355e-01f, 1.22717209e-01f,
  -2.97516249e-02f, -7.48698190e-02f, 1.94980621e-01f, 1.17519964e-02f, -1.23728812e-01f, 1.89582258e-01f, -1.23736247e-01f, 4.65641217e-03f, -7.03487247e-02f, -8.72077793e-02f,
  7.00683743e-02f, 6.27574176e-02f, 1.63972750e-01f, -6.30036741e-02f, 9.16587934e-02f, 2.87350826e-02f, 5.96204102e-02f, 6.31690621e-02f, 2.87091006e-02f, 1.14472717e-01f,
  -1.31295770e-01f, -1.04916384e-02f, 6.83664978e-02f, -5.78955887e-03f, 2.35476717e-02f, 1.40163526e-01f, -8.59522671e-02f, 2.15178225e-02f, -3.08740977e-03f, -1.33157551e-01f,
  -1.82083160e-01f, 8.03711712e-02f, 9.11886990e-03f, -4.04056497e-02f, -4.34567891e-02f, -2.79621273e-01f, -4.06529419e-02f, 2.53555179e-01f, -2.13394269e-01f, -1.05518401e-01f,
  2.02469632e-01f, -7.07654059e-02f, 2.72962183e-01f, 1.62462249e-01f, -1.45479396e-01f, -1.48772314e-01f, -7.09603280e-02f, -1.09407760e-01f, -7.44891390e-02f, 3.86449657e-02f,
  -3.93561944e-02f, -2.11923886e-02f, -1.74488485e-01f, 5.60559854e-02f, 4.76690173e-01f, -8.35328829e-03f, 1.60505563e-01f, -3.91634814e-02f, 4.65772510e-01f, -1.79112047e-01f,
  1.22784577e-01f, -6.51568398e-02f, -3.45879585e-01f, 9.98061150e-02f, -2.14486513e-02f, -1.37128942e-02f, 5.95779158e-03f, -4.16435897e-02f, -3.19010094e-02f, 2.47037113e-02f,
  6.00864738e-02f, 1.06482111e-01f, 7.11697713e-02f, -1.54066468e-02f, -8.10604095e-02f, 1.01982765e-01f, 2.24671531e-02f, -7.40070790e-02f, -1.57992807e-04f, 4.33871448e-02f,
  9.56631824e-02f, 8.23603049e-02f, -5.01726791e-02f, -5.88690192e-02f, 7.57640526e-02f, -8.43718648e-02f, 6.48081377e-02f, 1.45537138e-01f, 1.00063846e-01f, 8.81961882e-02f,
  1.56865433e-01f, -1.67941332e-01f, 5.33261187e-02f, -1.78616077e-01f, 4.32902947e-02f, 1.21810883e-01f, -2.87099071e-02f, 1.42812043e-01f, 9.34293866e-02f, 5.50300106e-02f,
  3.53465392e-03f, 3.51682343e-02f, 7.24958181e-02f, 5.37823662e-02f, -1.86310008e-01f, 2.30420262e-01f, -1.28692031e-01f, -2.26345569e-01f, 3.49894799e-02f, -1.44587100e-01f,
  -2.22074404e-01f, 9.38102044e-03f, 1.86481312e-01f, 1.38422295e-01f, -2.51094043e-01f, 9.71295461e-02f, 9.03638825e-02f, -1.49311557e-01f, 6.93332180e-02f, 1.40329957e-01f,
  1.48295343e-01f, 6.99661791e-01f, -2.37578213e-01f, -1.03053927e-01f, 1.20593190e-01f, 3.26733530e-01f, -7.03230675e-04f, -8.37195739e-02f, 1.15690097e-01f, -3.68991718e-02f,
  -1.23050638e-01f, 1.92257732e-01f, 1.25791263e-02f, 1.40889496e-01f, -9.33311656e-02f, 3.51476148e-02f, 6.54839352e-02f, 7.13073462e-02f, 3.69848162e-02f, 6.85191434e-03f,
  -4.05341871e-02f, 1.54204741e-01f, 6.71911463e-02f, 2.84504853e-02f, 7.17040375e-02f, 9.86543074e-02f, 1.75534859e-01f, -9.62861851e-02f, -7.57516315e-03f, -7.16356211e-04f,
  -4.34359871e-02f, -1.54724792e-02f, 1.14846803e-01f, 1.04673438e-01f, -1.93676725e-02f, 3.32649112e-01f, -5.20969406e-02f, -2.65156943e-02f, 6.83572888e-02f, -8.79503787e-02f,
  1.86652821e-02f, 1.06314965e-01f, -2.21992061e-01f, 1.60952002e-01f, -8.04361552e-02f, -2.01608762e-02f, -2.04445407e-01f, -2.40926780e-02f, 8.05877224e-02f, 4.01849411e-02f,
  -1.62750617e-01f, -1.41020752e-02f, 9.12180319e-02f, -9.91625264e-02f, -5.49671166e-02f, -1.90477937e-01f, -1.83395911e-02f, 8.32444727e-02f, 3.31026912e-02f, -1.67609841e-01f,
  1.75536443e-02f, 2.01461956e-01f, -3.16352993e-01f, -2.22391158e-01f, -1.37066677e-01f, 2.17225507e-01f, -1.64019078e-01f, -2.16515407e-01f, -7.40111396e-02f, 1.78827569e-01f,
  -5.94759174e-02f, 1.22814327e-01f, 2.32938498e-01f, 1.80655792e-01f, 1.34749850e-03f, 2.07282845e-02f, -7.66946077e-02f, -4.23640758e-02f, 5.89891188e-02f, 1.33418189e-02f,
  4.86213267e-02f, 1.34869426e-01f, -9.30115581e-02f, 1.85505785e-02f, 1.21419713e-01f, 1.94377407e-01f, 6.95573119e-03f, -3.80489156e-02f, -7.03388155e-02f, 2.27157865e-02f,
  -2.78247204e-02f, -1.07258655e-01f, 1.39279261e-01f, 1.96918890e-01f, 2.57146787e-02f, 6.13774620e-02f, -9.82110947e-03f, 1.85491964e-01f, -2.42006164e-02f, 1.26000464e-01f,
  -3.94650400e-02f, -5.77539951e-02f, -1.86373875e-03f, -7.81793818e-02f, -6.92806914e-02f, 1.75707102e-01f, 8.22666809e-02f, 2.14462906e-01f, -1.97387874e-01f, -2.14704841e-01f,
  8.27212259e-02f, -8.70802533e-03f, 9.50385071e-03f, 1.46158725e-01f, -2.30669435e-02f, -8.88317972e-02f, 2.12324217e-01f, 1.46987319e-01f, 2.21312419e-01f, -6.61547761e-03f,
  4.76448089e-02f, -7.57350177e-02f, -5.09149246e-02f, 6.75680041e-02f, -2.88686484e-01f, 2.94751316e-01f, 1.29513666e-01f, 8.94936696e-02f, -6.42459765e-02f, -1.58997536e-01f,
  -2.69019276e-01f, 2.99746618e-02f, -1.75852582e-01f, -3.42860341e-01f, 2.60382295e-01f, -2.05500588e-01f, -4.76553962e-02f, -1.88896824e-02f, -3.31054404e-02f, -1.79760590e-01f,
  -3.18540335e-02f, 3.53135802e-02f, -2.57961620e-02f, 4.21328172e-02f, 3.78810763e-02f, 9.62566305e-03f, -1.03507198e-01f, 3.76695879e-02f, -1.18422240e-01f, 9.76905227e-02f,
  -5.48466062e-03f, -5.82867488e-02f, -2.23026231e-01f, -1.75099112e-02f, 4.79208305e-02f, 3.23608257e-02f, -8.99740681e-02f, 8.94343406e-02f, 5.99294938e-02f, -6.96797222e-02f,
  -3.64410505e-02f, 8.96019563e-02f, 3.58363837e-02f, -8.66892263e-02f, 3.31153795e-02f, -1.91854373e-01f, -1.74917355e-01f, 1.38617784e-01f, -1.08193539e-01f, 5.25794923e-02f,
  8.31864178e-02f, -4.38877232e-02f, 5.17672598e-02f, -7.29502663e-02f, -1.21078610e-01f, 3.67024094e-02f, 1.52470201e-01f, -4.14824933e-02f, 2.30684858e-02f, 4.33273204e-02f,
  -1.46640480e-01f, -3.55192482e-01f, -1.29070938e-01f, -1.07959583e-02f, 1.03981398e-01f, -1.04400199e-02f, -4.33249734e-02f, -2.38018513e-01f, 9.18083638e-02f, -1.02354035e-01f,
  2.85217434e-01f, 7.68468902e-02f, 2.49186829e-01f, 1.98278487e-01f, -1.39978394e-01f, 3.15313607e-01f, -6.73166439e-02f, 2.11757541e-01f, -3.39166909e-01f, 1.73944682e-01f,
  3.38189267e-02f, -4.06186134e-02f, -2.04225630e-01f, -1.09027460e-01f, -1.18051939e-01f, -8.95415619e-02f, 1.09744251e-01f, -1.30160153e-02f, 1.14988767e-01f, -6.47578612e-02f,
  -1.82761326e-02f, 1.11823693e-01f, 2.24728566e-02f, 2.44147629e-02f, -3.22859809e-02f, -1.51633337e-01f, 1.23728335e-01f, -8.30118731e-02f, 7.34658241e-02f, 1.06279855e-03f,
  1.40456825e-01f, 1.90773625e-02f, -7.76735097e-02f, 1.65619999e-01f, 2.18497645e-02f, -3.59437242e-03f, -1.95690878e-02f, -1.75537225e-02f, 5.96533120e-02f, -5.31270802e-02f,
  7.10784867e-02f, -1.16968215e-01f, -7.65537901e-04f, -1.46308206e-02f, -1.27763459e-02f, 2.54492462e-01f, -2.75477201e-01f, -1.25465199e-01f, 1.61627665e-01f, 1.37502953e-01f,
  -4.35483009e-01f, 1.74567759e-01f, 2.43954659e-02f, -9.74010006e-02f, 2.49380946e-01f, 1.91761985e-01f, 3.90474796e-02f, 1.90579206e-01f, 4.13379772e-03f, -8.98982659e-02f,
  7.16010332e-02f, 2.63198107e-01f, 1.14017107e-01f, 7.29479939e-02f, 1.45758912e-01f, -3.69470268e-02f, -3.62987048e-03f, -2.51403321e-02f, -1.39089540e-01f, 8.69941413e-02f,
  4.73932102e-02f, -1.67056113e-01f, 3.05162132e-01f, -3.84419858e-01f, 1.16746262e-01f, 1.17541008e-01f, -1.18626155e-01f, -1.10888712e-01f, -7.37523288e-03f, -4.96318489e-02f,
  1.52451038e-01f, 2.36163568e-02f, -3.66089717e-02f, 3.40281725e-02f, -9.07245874e-02f, -5.05648591e-02f, 1.71423350e-02f, 9.29611847e-02f, -7.63684064e-02f, -3.12946439e-01f,
  -6.57628551e-02f, 1.19302519e-01f, -1.69857726e-01f, -8.45581945e-03f, 1.86539814e-01f, -8.80525913e-03f, -4.23870459e-02f, 1.57387048e-01f, 5.34740500e-02f, 2.02858463e-01f,
  -1.36405200e-01f, 1.14652827e-01f, 3.22614908e-02f, -5.88662475e-02f, 1.21375903e-01f, 8.94168764e-03f, -1.14431717e-01f, -1.19839117e-01f, -1.70929208e-02f, 1.28472820e-01f,
  -1.97054654e-01f, -1.67774096e-01f, 5.65164536e-02f, 3.44357193e-01f, -2.93811001e-02f, 8.79801437e-02f, 1.82452034e-02f, -1.52096778e-01f, 3.64247829e-01f, 1.15333438e-01f,
  -4.07284312e-02f, -6.83659464e-02f, 2.09750667e-01f, -5.32832108e-02f, 1.35341123e-01f, 1.08374692e-01f, 3.57408635e-02f, -1.17066137e-01f, 1.31847531e-01f, 1.51733197e-02f,
  8.62761140e-02f, -4.31565017e-01f, -1.02925800e-01f, 2.71999329e-01f, 1.14397131e-01f, -1.79792956e-01f, 4.47597414e-01f, -3.60279471e-01f, -1.22572310e-01f, 1.55681046e-02f,
  1.42340049e-01f, 1.29567366e-02f, 3.31344306e-02f, -1.26759291e-01f, 7.34953806e-02f, -6.26526475e-02f, 8.65202695e-02f, 7.93989375e-02f, -1.36636943e-02f, -2.63053440e-02f,
  1.38910897e-02f, 1.37066126e-01f, 2.11534444e-02f, -6.65577948e-02f, 2.19250489e-02f, 2.41411757e-02f, -4.03646044e-02f, 1.17536522e-01f, -3.00478727e-01f, 1.27581239e-01f,
  1.01699032e-01f, 7.33656809e-02f, -6.20988756e-02f, 1.39622599e-01f, -1.00630382e-02f, -2.56639495e-02f, -3.48901376e-02f, -1.57442391e-01f, -3.12438071e-01f, 2.86631379e-02f,
  -1.43750876e-01f, 6.41342178e-02f, -1.40117444e-02f, 3.73210534e-02f, 1.25891581e-01f, 4.69987839e-02f, -2.14631915e-01f, -6.74482659e-02f, 2.46077314e-01f, 6.82089180e-02f,
  1.01526640e-01f, 6.02285378e-02f, -3.95655148e-02f, -2.81174839e-01f, 1.18799023e-01f, -2.64915794e-01f, -3.48438951e-03f, -1.24604978e-01f, 2.58026868e-01f, 5.42795211e-02f,
  -2.83416267e-02f, 1.25631362e-01f, 2.43036330e-01f, 1.30968764e-02f, 1.47403240e-01f, -1.51772514e-01f, 1.46454662e-01f, 4.84044820e-01f, -1.93535149e-01f, 5.83521789e-03f,
  -3.65606695e-01f, 1.82968080e-01f, 8.47188905e-02f, 1.37031674e-01f, 1.33526221e-01f, -1.38205905e-02f, -9.48548913e-02f, 2.70982701e-02f, 7.01098666e-02f, -7.52470419e-02f,
  -3.86553556e-02f, 3.92747606e-04f, -1.69253610e-02f, -6.40724599e-02f, 2.72547174e-02f, 1.19869925e-01f, -8.64327699e-03f, 1.10763706e-01f, -1.03274137e-01f, 5.48322126e-02f,
  8.08532536e-03f, 5.22112623e-02f, -4.93699573e-02f, 2.05389336e-02f, 1.33831622e-02f, 9.53091681e-02f, -1.80750098e-02f, 9.51980576e-02f, -3.36903855e-02f, 1.06723737e-02f,
  -4.36025746e-02f, -7.90229365e-02f, -1.83847278e-01f, 4.28960584e-02f, -7.07120299e-02f, 1.05012029e-01f, -6.50850832e-02f, 2.62686312e-02f, -1.72446780e-02f, 1.28592290e-02f,
  -4.77296896e-02f, -1.26302794e-01f, 1.95754319e-01f, 7.66229630e-02f, 2.21726298e-01f, -5.12952618e-02f, 1.83047224e-02f, -6.71524629e-02f, 4.61822748e-02f, -1.38366237e-01f,
  -2.19733901e-02f, 1.69771370e-02f, 9.45066884e-02f, 9.94190201e-02f, -4.09282804e-01f, 2.62552261e-01f, 2.11103082e-01f, 5.61437868e-02f, 9.10237804e-02f, -2.35401392e-02f,
  4.62487303e-02f, 3.57200980e-01f, -2.93370545e-01f, 7.57939145e-02f, -2.82932997e-01f, 3.47027667e-02f, 9.43498164e-02f, 9.13396571e-03f, 1.88961804e-01f, 1.37306573e-02f,
  6.45480379e-02f, 2.63872351e-02f, -3.37130986e-02f, -3.00775766e-02f, 5.11376262e-02f, 7.34250247e-02f, -1.23512559e-01f, -9.67743546e-02f, -8.10294822e-02f, -6.88211177e-04f,
  -5.25965728e-02f, -8.10618922e-02f, 1.24931306e-01f, 2.30094433e-01f, 2.50217736e-01f, 1.35218158e-01f, 4.89080772e-02f, 3.24327759e-02f, 2.53952276e-02f, -7.73490742e-02f,
  4.75900769e-02f, 2.48699918e-01f, -6.36124238e-02f, 2.36420706e-01f, -1.00793555e-01f, -1.17649674e-01f, -3.33948657e-02f, 1.38167143e-01f, -4.34175953e-02f, -1.67627946e-01f,
  3.38975899e-02f, -4.70292661e-03f, 1.30588382e-01f, -1.13318890e-01f, -5.09337559e-02f, 4.45128186e-03f, 2.42831662e-01f, 4.48666848e-02f, 1.00577064e-02f, 2.65630446e-02f,
  -8.40369761e-02f, -1.71954140e-01f, 1.46503923e-02f, -1.94099188e-01f, -5.10994345e-02f, -8.02638754e-02f, 3.66213351e-01f, -6.07772246e-02f, 1.20318793e-01f, 3.22999172e-02f,
  -6.32518064e-03f, -4.14450951e-02f, 1.81722000e-01f, -3.22860658e-01f, 1.04907729e-01f, 5.60134113e-01f, -1.71213925e-01f, 1.14182323e-01f, -2.07605883e-01f, 2.15976775e-01f,
  -2.23163031e-02f, 7.57959560e-02f, 1.49148718e-01f, 7.58567974e-02f, 5.87503761e-02f, 8.92082527e-02f, -1.50042633e-02f, -4.15174179e-02f, 8.62053782e-02f, 6.63278112e-03f,
  8.39936063e-02f, -1.47719672e-02f, 8.77137855e-03f, 3.45154628e-02f, 7.86715746e-02f, -2.44524956e-01f, 5.65372221e-02f, 1.18327133e-01f, 1.25194833e-01f, 1.12780973e-01f,
  -7.58313686e-02f, 1.03617820e-03f, 8.67648199e-02f, 2.27292612e-01f, -8.64687860e-02f, 2.76892275e-01f, -4.51791845e-02f, -1.20872967e-01f, -8.06440413e-03f, -1.42472610e-01f,
  -1.85878173e-01f, 1.82445645e-01f, 1.04425274e-01f, -1.56536940e-02f, 2.93698192e-01f, 1.08811252e-01f, -1.39171304e-03f, 1.35358095e-01f, -7.29977340e-02f, 2.03810539e-02f,
  -3.11202258e-01f, 1.19909465e-01f, 1.20087363e-01f, -1.13441989e-01f, 2.90454482e-03f, 5.36228046e-02f, -6.75039738e-02f, -6.45750910e-02f, 5.26658855e-02f, -7.66938999e-02f,
  6.85526356e-02f, 2.81718913e-02f, -2.10690781e-01f, -6.89350143e-02f, 1.92449853e-01f, 3.80077884e-02f, 2.81870700e-02f, -1.25459120e-01f, 2.60490358e-01f, -2.80711442e-01f,
  -3.33476551e-02f, 2.74338961e-01f, 3.10209066e-01f, 1.74852818e-01f, -3.03895846e-02f, -1.64326485e-02f, -1.51153738e-02f, -4.25345562e-02f, -2.58353055e-02f, 6.60440922e-02f,
  -2.81801909e-01f, -4.09233645e-02f, -1.17583185e-01f, 4.34991159e-03f, -8.97523761e-02f, -1.13551039e-02f, -1.84187219e-02f, -1.68802813e-01f, 1.06769346e-01f, -5.71991429e-02f,
  -2.24568192e-02f, -4.86759655e-02f, -2.25330815e-02f, 6.42331466e-02f, -2.55771005e-03f, -1.99304223e-02f, -8.90752375e-02f, -1.94773674e-02f, 1.91495016e-01f, -1.97991170e-02f,
  -1.12708755e-01f, -1.33092254e-01f, -1.83256596e-01f, 1.18207939e-01f, -1.41656309e-01f, 5.01002744e-02f, 3.44957039e-02f, 7.14864284e-02f, 2.02320348e-02f, -2.08326638e-01f,
  1.11449547e-01f, 1.87309250e-01f, -1.19576477e-01f, -9.82429460e-02f, -3.47403847e-02f, -2.71896303e-01f, 2.20621198e-01f, -2.11863462e-02f, -9.27537307e-02f, 2.20192477e-01f,
  5.72575033e-02f, 3.02446395e-01f, -2.34830782e-01f, -4.81696278e-02f, 3.12371254e-02f, 6.12977296e-02f, 9.20598805e-02f, 2.38906108e-02f, -1.05021805e-01f, 7.00100735e-02f,
  7.99297616e-02f, -8.95912051e-02f, 2.03615874e-01f, -5.15110075e-01f, 3.08566630e-01f, -2.40245432e-01f, -1.28879026e-01f, -3.77608351e-02f, -6.79701716e-02f, 7.45004043e-02f,
  -8.08746666e-02f, -1.09385483e-01f, -1.01068251e-01f, -8.48147050e-02f, -5.99052608e-02f, -6.29785284e-02f, 1.36030212e-01f, 1.41911969e-01f, -1.42940301e-02f, -7.02658817e-02f,
  1.14581630e-01f, 1.40149402e-03f, -1.04409643e-01f, -1.68548018e-01f, -1.07938461e-01f, -1.07212067e-02f, -4.01418917e-02f, -4.39123511e-02f, -5.93454354e-02f, 1.54442593e-01f,
  -2.63817944e-02f, 8.92789476e-03f, -9.27427337e-02f, 1.76022664e-01f, -6.49040565e-02f, 4.67502475e-02f, -5.97761944e-02f, -1.63806856e-01f, -1.19060427e-01f, -4.50948114e-03f,
  -2.74050701e-02f, 1.75507404e-02f, 1.03644401e-01f, 5.04163653e-02f, 5.35083190e-02f, -4.33749966e-02f, -1.38951242e-01f, -8.60117897e-02f, 7.49512017e-02f, 7.39510208e-02f,
  2.10455835e-01f, -1.09282367e-01f, -2.00997904e-01f, -1.44848689e-01f, 7.16948211e-02f, -1.40121281e-01f, 1.10970670e-02f, -1.45701438e-01f, -2.23315507e-02f, -2.59842634e-01f,
  1.47099540e-01f, -7.67917335e-02f, 4.80887175e-01f, 7.67545849e-02f, 2.22613320e-01f, -3.60196710e-01f, 2.82265633e-01f, 2.87433892e-01f, 3.15641016e-02f, 6.32055104e-03f,
  1.48007507e-02f, 1.39190316e-01f, 1.33251846e-01f, -7.42761493e-02f, 1.75459474e-01f, 1.44657210e-01f, 3.70884016e-02f, 9.36567336e-02f, -3.02777160e-02f, 4.72991951e-02f,
  1.36407064e-02f, 1.50034409e-02f, -6.61473945e-02f, 3.30411866e-02f, 1.18897811e-01f, 1.10416807e-01f, 9.77341458e-03f, 1.12974286e-01f, -2.85860226e-02f, 1.56112369e-02f,
  1.09328575e-01f, 1.23036895e-02f, 1.03682168e-01f, 5.26970997e-02f, 7.33614862e-02f, 5.67055270e-02f, -2.93885283e-02f, -1.03841200e-02f, 5.96612766e-02f, 1.55671820e-01f,
  -2.95756180e-02f, -1.13463916e-01f, 2.06385888e-02f, 6.48935512e-02f, -9.94368941e-02f, 3.34629454e-02f, -1.40999556e-01f, -1.60046041e-01f, 5.54608591e-02f, 5.02102599e-02f,
  -7.96211660e-02f, -5.77830300e-02f, 5.06280065e-01f, 6.30390048e-02f, -1.09702468e-01f, 1.34971961e-01f, -1.25981495e-01f, -2.87920624e-01f, 7.32114762e-02f, -2.40417108e-01f,
  6.93258271e-02f, 7.72846043e-02f, -1.48513943e-01f, -8.28210413e-02f, -1.70605466e-01f, -2.07577739e-02f, -3.40599120e-01f, 9.21876803e-02f, 1.17741078e-01f, 1.35183677e-01f,
  -6.73839673e-02f, 6.98303059e-02f, 9.80787426e-02f, 1.83083490e-01f, -3.26690197e-01f, -1.01756128e-02f, -3.07882335e-02f, 5.98531356e-03f, -7.95873702e-02f, -2.13973776e-01f,
  -1.26066461e-01f, 2.11113319e-02f, -2.26166118e-02f, 7.20949173e-02f, -1.02328882e-03f, -2.47524586e-02f, 6.09271862e-02f, 9.79759358e-03f, 8.21017101e-02f, -7.86971077e-02f,
  -3.66755612e-02f, 1.57978218e-02f, -1.24843803e-03f, 2.55792513e-02f, -8.22675750e-02f, -7.08120689e-02f, 2.25740150e-02f, -2.02902071e-02f, 4.52585928e-02f, 9.13379937e-02f,
  4.51030023e-02f, 5.88631481e-02f, 2.14093029e-02f, -1.40293568e-01f, 2.15228014e-02f, -3.64278518e-02f, 1.30308392e-02f, 6.24380261e-02f, 1.69830192e-02f, -4.56859656e-02f,
  3.07391230e-02f, -6.99205324e-02f, -3.85075770e-02f, -7.86124095e-02f, -1.37217119e-02f, 4.33212183e-02f, -2.98892140e-01f, 7.32183903e-02f, 4.59576882e-02f, -5.06306924e-02f,
  -3.28452396e-03f, 7.96853900e-02f, -2.04271764e-01f, 2.26088744e-02f, 1.46998450e-01f, -1.62851568e-02f, -2.71949410e-01f, -2.29276088e-03f, 1.66317642e-01f, -1.34846523e-01f,
  3.15537661e-01f, -8.60627517e-02f, -1.16696902e-01f, 3.54031213e-02f, 2.96431273e-01f, -3.67801309e-01f, 4.53238130e-01f, -1.67044058e-01f, 4.60214227e-01f, -2.69552711e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.08820835e-01f, 2.49645207e-02f, 2.66544998e-01f, -5.32194003e-02f, 1.95921391e-01f, 1.73448756e-01f, 1.76471800e-01f, 9.55903251e-03f, 9.99431871e-03f, 1.40866965e-01f,
  1.68831691e-01f, 1.00497819e-01f, -5.80621324e-02f, -2.27843478e-01f, 1.86236098e-01f, 3.38711329e-02f, 3.01501542e-01f, -4.98562679e-02f, -8.13334361e-02f, 1.16384350e-01f,
  5.04799113e-02f, -1.87705144e-01f, 1.29774019e-01f, -4.29927260e-02f, 2.17672527e-01f, -8.57686624e-02f, 3.35895151e-01f, -2.92395890e-01f, 1.24876253e-01f, -1.93074614e-01f,
  2.06528693e-01f, -1.14615604e-01f, 1.45950774e-02f, 2.63717741e-01f, 6.91828430e-02f, 1.23825170e-01f, -1.21827304e-01f, 2.91593701e-01f, 1.00697719e-01f, -9.48491544e-02f,
  -6.87792182e-01f, -1.67023197e-01f, -1.41328052e-01f, -2.11647362e-01f, -1.01971887e-01f, 1.56601053e-02f, -9.34370235e-03f, 6.25305921e-02f, 1.00953825e-01f, 1.16483390e-01f,
  1.73698559e-01f, -1.15413435e-01f, 1.66208908e-01f, 3.19478184e-01f, -2.94933259e-01f, -5.20440675e-02f, 7.45170861e-02f, 7.84771621e-01f, -2.34606430e-01f, -4.54711050e-01f,
  -5.35661131e-02f, 6.87141001e-01f, 4.86759037e-01f, 1.03101954e-01f, -1.04044370e-01f, -1.68057121e-02f, 1.42925233e-01f, 4.22104821e-02f, 1.88540712e-01f, -8.52541998e-02f,
  2.50326902e-01f, 1.70758620e-01f, -7.56618977e-02f, 1.81010872e-01f, 1.69478208e-01f, 1.70136452e-01f, -1.96813196e-02f, 1.40794694e-01f, 1.28383309e-01f, 1.43921196e-01f,
  -6.12610094e-02f, 7.40128681e-02f, 1.42847374e-02f, 1.55683011e-01f, -8.48050490e-02f, 1.53692111e-01f, 1.82664782e-01f, -7.15657100e-02f, 1.66222379e-01f, -8.29406083e-02f,
  2.16081023e-01f, -3.21380556e-01f, 7.97194690e-02f, -2.51884162e-01f, 4.84530702e-02f, 7.87348822e-02f, -8.04753881e-03f, 1.26756057e-01f, -1.99360736e-02f, -3.05367261e-01f,
  -2.15645991e-02f, 2.31040120e-01f, -1.30425975e-01f, -3.27369183e-01f, -1.29824594e-01f, -1.24987520e-01f, -3.17614563e-02f, -2.16882735e-01f, -2.70213276e-01f, -2.24696845e-01f,
  -1.22718588e-01f, -4.31438945e-02f, 1.81756720e-01f, 1.59711055e-02f, 2.58352347e-02f, -4.97777075e-01f, 1.04634836e-02f, 2.28097737e-01f, 2.26933300e-01f, 1.68630823e-01f,
  4.79732007e-02f, 9.27628517e-01f, -4.66948509e-01f, 1.44926578e-01f, 1.05922975e-01f, 5.15250862e-01f, 8.81194621e-02f, 2.86620229e-01f, 1.39722258e-01f, 7.73973614e-02f,
  -1.94450960e-01f, 7.07813213e-03f, 8.19398277e-03f, 1.44125223e-01f, -1.70038983e-01f, -3.67777608e-02f, -1.44580200e-01f, -1.99835166e-01f, 1.65198907e-01f, -2.15697557e-01f,
  1.39170483e-01f, -5.19074835e-02f, 2.15350956e-01f, 2.34086886e-02f, -3.12798545e-02f, -1.06550679e-01f, 1.95132136e-01f, 1.22693017e-01f, 1.78334936e-01f, -3.33020687e-02f,
  -3.26596089e-02f, -1.81331187e-01f, 1.86468259e-01f, 4.25207987e-02f, -9.46796313e-02f, 4.97879773e-01f, -2.04185694e-01f, 1.45574883e-01f, 2.08932787e-01f, -1.58558577e-01f,
  9.00293738e-02f, 8.19945633e-02f, -3.95875692e-01f, -3.32828045e-01f, -1.54837608e-01f, -2.40651369e-01f, -9.35644060e-02f, -1.07634300e-02f, 5.52334450e-02f, -1.90154329e-01f,
  4.54127863e-02f, 3.24428618e-01f, -3.05305928e-01f, -1.12024032e-01f, -6.39723539e-02f, -3.24998260e-01f, 1.23543411e-01f, 4.27367240e-02f, 8.14631283e-02f, -3.68345320e-01f,
  3.76156926e-01f, 4.36752349e-01f, 2.56926566e-01f, -5.78863285e-02f, 1.79288134e-01f, -2.39529356e-01f, -6.13308884e-02f, -2.49734312e-01f, 4.34152186e-01f, -5.48309803e-01f,
  3.92796099e-01f, 1.66177228e-02f, -2.59952307e-01f, 1.88678905e-01f, -1.92432746e-01f, -1.57558098e-01f, 5.96977808e-02f, 3.05509996e-02f, -7.23780245e-02f, 1.33868761e-03f,
  1.85084604e-02f, 1.97219625e-02f, 1.03707165e-02f, -1.00004077e-02f, 5.25018014e-02f, 4.11558077e-02f, 9.07839239e-02f, -3.55969250e-01f, -7.54137337e-02f, 8.98701102e-02f,
  1.09888174e-01f, 8.69281590e-02f, -9.24591273e-02f, 1.46445960e-01f, 8.07891786e-02f, 2.28791520e-01f, -2.39745378e-02f, 2.75537193e-01f, -8.59570876e-02f, -8.04878399e-02f,
  1.15447808e-02f, -2.51741588e-01f, -8.44894275e-02f, -7.62095302e-02f, -3.10284346e-02f, 1.28185693e-02f, -3.35837677e-02f, 1.24714017e-01f, -1.51212318e-02f, -1.84236422e-01f,
  2.84452010e-02f, 1.43767849e-01f, -1.08875275e-01f, 2.37927511e-01f, 2.98487723e-01f, -1.94728643e-01f, 9.36553702e-02f, -1.93313599e-01f, -6.58905506e-02f, -1.55101821e-01f,
  1.22644171e-01f, -2.97374278e-01f, 1.80924043e-01f, 9.46039632e-02f, 1.05643511e-01f, 5.72748125e-01f, 9.11462903e-01f, 4.97194473e-03f, 4.67903763e-02f, -4.45951730e-01f,
  9.07946154e-02f, 4.07037973e-01f, 4.61189300e-01f, -2.92559341e-03f, 8.41983259e-01f, 1.99034169e-01f, 1.35339648e-01f, -5.69352023e-02f, 3.82121205e-01f, -2.70290975e-03f,
  -1.34556457e-01f, 2.15806618e-01f, 1.02575526e-01f, 1.59182563e-01f, 9.57272574e-02f, 1.41498417e-01f, 3.77022684e-01f, 1.99520722e-01f, 2.39706755e-01f, 7.70304576e-02f,
  2.63759434e-01f, 3.35435122e-01f, 3.62142175e-01f, 9.34146717e-02f, -8.78758952e-02f, 1.26380250e-01f, 3.21440175e-02f, 1.49265870e-01f, 9.79689136e-02f, 8.46235305e-02f,
  1.79402769e-01f, 1.53266981e-01f, -4.85504754e-02f, -4.32249427e-01f, 1.59342855e-01f, -2.57373124e-01f, -3.88615310e-01f, 1.29075304e-01f, 6.32640123e-02f, -7.35859647e-02f,
  2.27134854e-01f, -1.21905856e-01f, 4.78268154e-02f, 4.63404924e-01f, -7.83757269e-02f, -1.14350900e-01f, -3.26262742e-01f, 7.20009133e-02f, 2.45123059e-01f, -1.96744651e-01f,
  2.02626228e-01f, 3.90357077e-01f, 1.46850899e-01f, 3.87572646e-01f, -1.77211493e-01f, -3.44844982e-02f, -2.23802641e-01f, 5.10120153e-01f, -2.32172459e-01f, -2.78983772e-01f,
  2.04592228e-01f, -1.11385293e-01f, -4.55184370e-01f, 4.46588218e-01f, 5.78665674e-01f, -4.70608920e-01f, -5.74192964e-02f, 4.65276361e-01f, 2.05763131e-01f, -1.63375869e-01f,
  3.80076557e-01f, -3.21148485e-02f, 6.02266565e-02f, 2.81700879e-01f, 4.42263819e-02f, 1.78968087e-01f, 1.12970481e-02f, 1.77877992e-01f, 2.00050816e-01f, 3.12347472e-01f,
  1.40486076e-01f, 2.62824625e-01f, 7.47045279e-02f, 1.50948361e-01f, 2.56756753e-01f, 1.27217144e-01f, 2.87804037e-01f, 3.32770377e-01f, 1.87176228e-01f, 1.19155854e-01f,
  1.45030707e-01f, 3.95698428e-01f, 8.14808160e-02f, 8.50051194e-02f, 9.98415053e-02f, 1.17228679e-01f, -1.92452326e-01f, -1.42194703e-01f, -1.81157380e-01f, 9.31192413e-02f,
  -2.69303262e-01f, 9.08105541e-03f, 2.10978270e-01f, 1.43290740e-02f, -7.08233342e-02f, -2.13550076e-01f, -1.55756418e-02f, 4.09476459e-03f, -1.26257569e-01f, -6.70422688e-02f,
  2.70003617e-01f, 3.56956959e-01f, 7.21001923e-02f, 1.17252395e-01f, 3.42415214e-01f, 4.67017852e-02f, -1.34631634e-01f, 1.15673043e-01f, -2.94723749e-01f, 8.14403743e-02f,
  -1.87890127e-01f, 1.11276604e-01f, 5.57372272e-01f, -1.86933771e-01f, 1.46808654e-01f, -1.22414038e-01f, -9.23758894e-02f, 2.74407417e-01f, 1.27146661e-01f, 6.48263097e-02f,
  1.20032692e+00f, -3.98856163e-01f, -4.17891353e-01f, -7.87669346e-02f, -6.18230514e-02f, -2.09377617e-01f, 3.37006390e-01f, 9.52690095e-03f, 3.04025710e-01f, 1.16123483e-01f,
  2.30524838e-01f, 1.08435251e-01f, 1.06485009e-01f, 1.25544861e-01f, 8.56803283e-02f, 8.31914321e-02f, 2.42483407e-01f, 1.17884979e-01f, 1.49482146e-01f, 3.61201584e-01f,
  -2.83548236e-01f, -4.64975357e-01f, -7.06230057e-03f, -1.16559137e-02f, 2.51953691e-01f, 2.56508738e-01f, 1.50412858e-01f, -2.08493814e-01f, 1.12303406e-01f, -5.65871954e-01f,
  1.48993880e-01f, 3.74612302e-01f, 1.97988778e-01f, 5.03817387e-02f, 4.07800913e-01f, -3.43675345e-01f, -1.90423816e-01f, 1.71675399e-01f, -8.36494789e-02f, -2.32306048e-01f,
  -1.97254702e-01f, -2.79879607e-02f, 3.05858135e-01f, -2.73780614e-01f, 5.09966165e-02f, -7.47510374e-01f, -8.68035033e-02f, 6.27976432e-02f, -5.56075752e-01f, 1.55531038e-02f,
  1.43486589e-01f, -2.36458331e-01f, 4.35822219e-01f, 1.29216269e-01f, 9.33415145e-02f, -5.56251824e-01f, -2.74297357e-01f, 4.34575289e-01f, -2.85662413e-01f, 5.32535128e-02f,
  -1.19215123e-01f, 4.07558382e-01f, -4.75588411e-01f, 9.26322863e-02f, -5.08615553e-01f, -1.67328678e-02f, 7.04823494e-01f, -1.20886862e-01f, 1.24854416e-01f, 7.10160136e-02f,
  -1.49214074e-01f, 1.44228488e-01f, 1.48360640e-01f, 5.92312589e-02f, -1.15379710e-02f, 1.44339249e-01f, -1.72965899e-02f, 6.19974881e-02f, 2.38258928e-01f, 8.78658593e-02f,
  2.18676105e-01f, -1.29653648e-01f, 1.09444492e-01f, -4.95558009e-02f, 2.50732005e-01f, 1.57225475e-01f, 1.10664502e-01f, 9.77881029e-02f, 1.02921322e-01f, 1.36496514e-01f,
  9.97622684e-02f, -2.90794950e-02f, 1.09234169e-01f, 1.45508507e-02f, -1.19253941e-01f, -6.05479106e-02f, -2.16964888e-03f, 1.51633009e-01f, -1.04827709e-01f, -7.73892156e-04f,
  2.77147472e-01f, 5.28095253e-02f, -8.06827769e-02f, -2.99978584e-01f, -1.44906163e-01f, 1.58898756e-01f, 5.33825383e-02f, -1.66792542e-01f, -2.98980504e-01f, -1.19462885e-01f,
  -3.68596055e-02f, 1.29488155e-01f, -1.85645476e-01f, 4.45352793e-01f, -3.10783684e-01f, 3.20159011e-02f, -1.51772603e-01f, 2.71794423e-02f, -1.18097633e-01f, 1.56036407e-01f,
  4.17362213e-01f, -1.75934106e-01f, 4.80817944e-01f, -2.37204254e-01f, 4.13141362e-02f, -3.14472914e-01f, 3.35500807e-01f, -7.85356939e-01f, 9.33135867e-01f, -6.64444506e-01f,
  6.27095222e-01f, 1.58747867e-01f, 4.53052580e-01f, 6.34200573e-02f, 3.13855410e-01f, 1.07252663e-02f, -1.21739373e-01f, 1.24888867e-01f, 3.62749577e-01f, 6.70475066e-02f,
  1.53151795e-01f, 2.15065733e-01f, 3.06964695e-01f, 3.80498260e-01f, 3.05061251e-01f, 1.94866762e-01f, 3.53835262e-02f, 3.11819911e-01f, 2.55403578e-01f, 5.10958314e-01f,
  3.30966413e-02f, 8.19295719e-02f, 4.09691781e-01f, 9.08028558e-02f, 2.61178672e-01f, 3.83058220e-01f, 2.12505534e-01f, 4.00871396e-01f, -1.05951458e-01f, -3.57885599e-01f,
  1.40596807e-01f, -3.42836261e-01f, -7.45738298e-02f, 5.28395250e-02f, -1.37550578e-01f, -2.30681926e-01f, 1.10289380e-01f, 2.99038887e-01f, 3.82977873e-02f, -1.90536752e-01f,
  7.62649179e-02f, 7.84142129e-03f, -1.16491549e-01f, 4.44652677e-01f, -6.52038455e-02f, -4.47884083e-01f, 4.84165698e-01f, 1.85412958e-01f, 1.69704229e-01f, 2.95831800e-01f,
  1.00379407e-01f, -2.48180971e-01f, 9.85800624e-02f, 3.47131252e-01f, -2.00954124e-01f, -1.41262919e-01f, 2.89432764e-01f, -2.84163147e-01f, 6.61218911e-02f, 1.55108228e-01f,
  6.28567114e-02f, 2.70665497e-01f, -2.22196221e-01f, 4.18166101e-01f, 5.41126847e-01f, -3.16046715e-01f, -5.26532829e-02f, -1.21908061e-01f, -1.41223907e-01f, -1.30012007e-02f,
  1.61586683e-02f, -1.33708507e-01f, -1.31134167e-01f, -3.21075320e-02f, -3.52559835e-02f, -1.74473271e-01f, -1.29638463e-01f, -1.49105683e-01f, -3.36527899e-02f, -1.15450481e-02f,
  4.22894433e-02f, 2.90970653e-02f, 5.70761561e-02f, -8.14022198e-02f, 4.02828641e-02f, -1.11845762e-01f, 3.40390168e-02f, -7.87004922e-03f, -4.47488651e-02f, -4.98810038e-02f,
  2.81858109e-02f, -1.08264141e-01f, 1.48013547e-01f, -9.39952061e-02f, 4.72328924e-02f, -1.23686694e-01f, 7.38060921e-02f, 1.02331363e-01f, -1.63143918e-01f, 1.01427019e-01f,
  -5.40464297e-02f, -1.35955483e-01f, 5.87390661e-02f, -4.22910899e-02f, 9.46628675e-02f, 8.89132023e-02f, 2.07452014e-01f, -5.48345856e-02f, -1.08892858e-01f, 8.54116008e-02f,
  -1.32692726e-02f, 3.84982191e-02f, 1.33208424e-01f, 2.17344388e-01f, 6.47220686e-02f, -6.41457550e-03f, -1.26295850e-01f, 7.80312866e-02f, 1.51244655e-01f, -1.85449347e-01f,
  -8.78484473e-02f, -7.49996677e-02f, 1.03040464e-01f, -1.06233329e-01f, 9.23734233e-02f, 2.42204130e-01f, 1.21382900e-01f, -5.66244423e-02f, -4.50575165e-02f, 1.57480408e-02f,
  1.56325996e-01f, 1.85402125e-01f, 1.08872965e-01f, -2.72973645e-02f, 1.96088210e-01f, 8.72956291e-02f, 5.40232658e-02f, 1.22759245e-01f, 1.46566838e-01f, 4.89572436e-02f,
  -1.07674755e-01f, 8.20752159e-02f, 6.53593466e-02f, 1.48982093e-01f, -3.93980443e-02f, 2.16130167e-01f, 8.57381597e-02f, 2.04791054e-02f, 4.70093898e-02f, 1.83095813e-01f,
  2.14108191e-02f, -2.26276278e-01f, 2.75313538e-02f, 2.91381657e-01f, 1.97837269e-03f, -2.05908194e-01f, -3.08031570e-02f, 6.30439520e-02f, -1.46489509e-03f, 9.12902504e-02f,
  3.95643301e-02f, 8.22514743e-02f, 4.17320728e-02f, -1.28995627e-01f, 6.08538128e-02f, 1.45521805e-01f, 2.87969440e-01f, -1.71800807e-01f, 1.14946254e-01f, 2.08405584e-01f,
  2.43964911e-01f, -5.36478218e-03f, 1.06380798e-01f, 5.58279529e-02f, 2.49559581e-01f, 9.28016901e-02f, 1.74733818e-01f, 3.43846828e-01f, -1.42864287e-01f, -4.85033393e-02f,
  3.04652542e-01f, 5.66512227e-01f, 1.42389476e-01f, 2.58269668e-01f, -2.75981992e-01f, 1.09831505e-01f, 1.36475027e-01f, -6.42682239e-02f, -4.22539702e-03f, 9.58688438e-01f,
  -4.57166225e-01f, 3.71761858e-01f, -4.62819189e-01f, -4.91800383e-02f, 5.37698925e-01f, 1.48507848e-01f, 2.99910605e-01f, 4.08983707e-01f, 1.76816791e-01f, 3.15779984e-01f,
  1.97265297e-01f, 1.23815708e-01f, 1.24066994e-01f, 1.36763722e-01f, 2.95992315e-01f, 1.08533129e-01f, 2.49116316e-01f, 3.58242810e-01f, 1.64668381e-01f, 2.33835243e-02f,
  1.12052746e-01f, 2.70394802e-01f, 4.51125681e-01f, 5.88409826e-02f, 1.22448385e-01f, 3.55063289e-01f, 5.09399436e-02f, 1.06324494e-01f, 2.05348834e-01f, 5.49268425e-01f,
  -1.63272023e-01f, 8.05169880e-01f, -3.87064397e-01f, 8.61098394e-02f, 4.33154143e-02f, 5.71439192e-02f, -5.88112995e-02f, -1.62414059e-01f, -3.54475856e-01f, -1.02532834e-01f,
  -2.25677602e-02f, -2.29542881e-01f, -2.16991201e-01f, -8.02321211e-02f, 6.75479591e-01f, 1.37469098e-01f, -2.09281996e-01f, 3.29267859e-01f, -2.38652632e-01f, -1.87361300e-01f,
  4.20504883e-02f, -7.21302927e-01f, -1.33530527e-01f, -1.05030306e-01f, 1.05722465e-01f, 7.17812479e-02f, -1.15077399e-01f, 3.84682387e-01f, -1.21282846e-01f, -1.54230922e-01f,
  4.54233633e-03f, -4.03443128e-01f, 7.33073428e-02f, 9.12084281e-02f, 1.39538776e-02f, 4.18925621e-02f, -2.20868364e-01f, 4.79870170e-01f, -1.12596706e-01f, 1.95385054e-01f,
  3.33707511e-01f, 1.19301461e-01f, 2.16259763e-01f, 7.96019584e-02f, -9.30119902e-02f, 9.05978084e-02f, 1.25927165e-01f, 2.75049768e-02f, -3.60440254e-01f, -2.16984097e-02f,
  -7.33243152e-02f, 7.12374412e-03f, 9.04901847e-02f, 3.52251641e-02f, -1.64064661e-01f, -9.78220180e-02f, -5.76975830e-02f, 2.43664771e-01f, -1.05265170e-01f, 7.42980242e-02f,
  -7.52172992e-02f, 3.60065624e-02f, 6.26804307e-03f, -1.64101154e-01f, -2.67889239e-02f, -9.87701714e-02f, -1.27469882e-01f, 1.55085754e-02f, -2.76838541e-01f, 1.92795411e-01f,
  8.00152421e-02f, -1.15383670e-01f, 7.34066814e-02f, -1.54566392e-01f, 4.54482198e-01f, 7.04070330e-02f, -6.12280928e-02f, -2.65675392e-02f, 3.11273783e-01f, -2.29799494e-01f,
  4.26148444e-01f, 4.66382951e-01f, -2.44600579e-01f, 7.50573650e-02f, 7.52294958e-02f, 2.02173725e-01f, -1.99996129e-01f, -1.25126064e-01f, 3.29673976e-01f, 5.75632341e-02f,
  5.06058596e-02f, 2.30854064e-01f, 3.34664673e-01f, -2.09229738e-01f, -2.74360701e-02f, -3.18179131e-01f, 4.67330664e-01f, 5.62859774e-01f, 1.80470884e-01f, -2.13149134e-02f,
  -5.45478880e-01f, 5.23048937e-01f, 1.13430806e-01f, 1.59937948e-01f, 8.73976499e-02f, -1.12456374e-01f, 1.70140624e-01f, 1.00911148e-01f, 1.56515747e-01f, 7.11324960e-02f,
  5.84083050e-03f, 8.27599764e-02f, -3.61769438e-01f, 6.25593364e-02f, 2.68461071e-02f, 9.26299989e-02f, -3.97255793e-02f, 1.07505232e-01f, -1.56111956e-01f, 1.10206984e-01f,
  -3.50017869e-03f, 5.54400571e-02f, 1.54763103e-01f, 7.15092719e-02f, 2.28713900e-01f, -4.59369235e-02f, -7.78110698e-02f, -5.91308251e-02f, -1.41752198e-01f, -1.66367237e-02f,
  7.20004439e-02f, 1.09810837e-01f, -9.88732725e-02f, 6.73992187e-02f, 4.59118467e-03f, -2.24018902e-01f, 5.56783900e-02f, 3.66838127e-01f, 1.98563963e-01f, -4.07423019e-01f,
  1.94278166e-01f, 3.15291047e-01f, 2.77357429e-01f, 1.68469295e-01f, 3.13344181e-01f, 3.94899622e-02f, 1.54588044e-01f, -1.93066910e-01f, 3.43773395e-01f, -1.36428894e-02f,
  2.06974313e-01f, -2.08309487e-01f, 2.73957610e-01f, 1.60392359e-01f, -9.06531587e-02f, -6.06357232e-02f, 4.03104573e-01f, -1.35364741e-01f, -1.95339650e-01f, -1.45033106e-01f,
  3.06307405e-01f, 1.10214150e+00f, 1.46466109e-03f, 3.84941213e-02f, -1.29947424e-01f, 2.11521238e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.33884776e-01f, 3.33272755e-01f, 2.22761080e-01f, 1.13660529e-01f, 7.65247494e-02f, 2.05530912e-01f, 2.01926917e-01f, 3.48442703e-01f, 2.87619561e-01f, -1.10005520e-01f,
  -9.55930278e-02f, 3.04064155e-01f, -3.91263794e-03f, -1.03151098e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -5.17311871e-01f, -9.47674811e-02f, 2.63091922e-01f, -4.45633322e-01f, -9.97279137e-02f, -1.29734343e-02f, -3.27336401e-01f, -2.79424358e-02f, -2.40768135e-01f, -2.23282382e-01f,
  -2.49546498e-01f, 1.74567312e-01f, -5.26752293e-01f, -1.21327534e-01f, 3.39272767e-02f, -1.02788359e-01f, -1.04990944e-01f, -4.99676406e-01f, -5.45365751e-01f, -1.68595254e-01f,
  -9.96659137e-03f, 8.15257877e-02f, -2.96965867e-01f, -3.17065082e-02f, -1.17027096e-01f, 4.24346536e-01f, -1.37174323e-01f, -1.47435516e-01f, 7.61236697e-02f, -6.34850487e-02f,
  -4.13217634e-01f, 3.42589796e-01f, 1.03212073e-01f, 1.36622801e-01f, 6.05287552e-01f, 1.53725013e-01f, 5.85740097e-02f, 1.39493747e-02f, -1.79984421e-02f, 3.50595981e-01f,
  3.47784966e-01f, 1.16714418e-01f, 3.20190303e-02f, -6.34140000e-02f, 2.72242606e-01f, 2.53825486e-01f, -4.54446912e-01f, 2.35624000e-01f, -3.21134537e-01f, 5.72470188e-01f,
  -3.67338002e-01f, -1.65171623e-01f, -3.58670384e-01f, 1.74123049e-01f, 1.26118269e-02f, -6.84628859e-02f, -1.37320206e-01f, -6.23668253e-01f, 1.71026289e-01f, 1.47312079e-02f,
  2.36803785e-01f, -7.50002921e-01f, 2.33921885e-01f, 4.70482945e-01f, 2.38336436e-02f, 9.12323296e-02f, -8.79931092e-01f, 9.65523422e-02f, -4.13976550e-01f, -2.96209957e-02f,
  -2.39793155e-02f, -3.83865654e-01f, 1.73314601e-01f, 1.07795060e-01f, -6.72762021e-02f, 3.00390750e-01f, 2.08108947e-01f, 1.05661623e-01f, -4.90182608e-01f, -9.39105749e-02f,
  1.27264112e-01f, -3.80087495e-01f, -2.24889830e-01f, -3.08751106e-01f, -2.38779441e-01f, -1.35300860e-01f, -5.69494903e-01f, -3.68429907e-02f, -2.35453740e-01f, -3.24535340e-01f,
  -4.51191980e-03f, -8.46421272e-02f, 1.41147763e-01f, -1.34592369e-01f, -3.87700945e-01f, -5.89672267e-01f, -4.23147343e-02f, -3.86934608e-01f, 3.60240340e-01f, 2.63585627e-01f,
  3.47942077e-02f, -3.27444553e-01f, -2.38646179e-01f, 5.44292450e-01f, -2.48611048e-01f, -6.69548512e-02f, -8.40316266e-02f, 1.86075285e-01f, -5.35386026e-01f, -5.80407272e-04f,
  7.01897964e-02f, 4.30525839e-01f, 1.37629330e-01f, -2.89063662e-01f, -5.95307015e-02f, 1.18340857e-01f, 1.24515481e-01f, 2.95057714e-01f, -4.37444836e-01f, -3.65455687e-01f,
  1.60539541e-02f, -5.13913453e-01f, -4.24191564e-01f, 5.60611300e-02f, 2.87816703e-01f, 3.06723952e-01f, 4.90571171e-01f, 2.98559368e-01f, -9.71455500e-02f, 1.71291366e-01f,
  -1.77640729e-02f, 2.54007876e-01f, -1.93702221e-01f, -1.44979447e-01f, -2.20638469e-01f, 3.80321234e-01f, 3.01857710e-01f, 1.25782654e-01f, -4.37754422e-01f, -5.05996108e-01f,
  -8.40448514e-02f, 1.03121623e-01f, -1.56105757e-01f, 2.92845387e-02f, -1.88586712e-01f, -4.26049441e-01f, -3.38694513e-01f, -3.78035456e-02f, -2.19405726e-01f, -1.85636133e-02f,
  1.09783821e-01f, -4.42641199e-01f, -9.69776511e-02f, 3.46991599e-01f, 5.31856306e-02f, 7.34071732e-01f, -3.19497615e-01f, -1.19124845e-01f, -6.90538704e-01f, -4.72651511e-01f,
  4.09062684e-01f, 4.71064478e-01f, 3.05317283e-01f, 3.65090132e-01f, -4.26208824e-01f, 3.12752068e-01f, 2.53111631e-01f, 2.89891452e-01f, -4.27016288e-01f, -1.19714372e-04f,
  3.80016118e-01f, 4.94845033e-01f, 2.64893889e-01f, 5.52157223e-01f, -2.06140071e-01f, -1.96879372e-01f, 2.32594371e-01f, -1.44358724e-01f, 8.15554149e-03f, 2.82131255e-01f,
  -1.82270467e-01f, -5.37179485e-02f, 2.75154412e-01f, 2.49629900e-01f, -5.14854133e-01f, -3.75943720e-01f, 3.14504176e-01f, -7.64478073e-02f, -1.41868025e-01f, 2.75903553e-01f,
  -3.35365623e-01f, -7.39977598e-01f, 1.55469850e-01f, 1.86133519e-01f, -4.22334708e-02f, -4.73337919e-01f, -4.02475685e-01f, -1.46016162e-02f, -7.89490119e-02f, 2.48969540e-01f,
  7.29780346e-02f, -2.56541789e-01f, -7.59260356e-02f, 1.07237101e-01f, -1.20721936e-01f, 1.45161271e-01f, 4.84379269e-02f, -5.42967498e-01f, -6.71373978e-02f, 2.01571897e-01f,
  1.74484476e-01f, 5.34672737e-02f, -3.62423658e-01f, 2.37291664e-01f, 4.20011468e-02f, -4.15383279e-01f, -4.66941893e-01f, 2.06806570e-01f, -8.06335807e-02f, 3.35106879e-01f,
  2.80834660e-02f, 2.79224634e-01f, 4.10234749e-01f, 1.96180046e-01f, 6.49321973e-02f, 2.59358019e-01f, -2.33136773e-01f, 1.79728180e-01f, 3.10853302e-01f, 9.04608890e-02f,
  4.00210947e-01f, -2.56536007e-01f, -1.12971351e-01f, 3.46017569e-01f, -6.11976981e-02f, -4.73777741e-01f, -3.97319019e-01f, 1.11876443e-01f, 5.13588309e-01f, 4.69436079e-01f,
  2.92821396e-02f, -1.80676490e-01f, -3.16588461e-01f, -4.57418770e-01f, -4.58216786e-01f, 3.08318079e-01f, 1.69377804e-01f, 3.11659217e-01f, -3.12426239e-01f, 5.09204149e-01f,
  -1.91051140e-02f, -2.08257157e-02f, -3.67647707e-01f, -4.90632743e-01f, -1.59448624e-01f, 5.91458306e-02f, 2.79755555e-02f, 5.78793231e-03f, 3.01347017e-01f, 6.46634519e-01f,
  3.87548774e-01f, -2.85442844e-02f, 1.34643823e-01f, -3.28400314e-01f, -2.40651086e-01f, 1.93886891e-01f, 2.01502424e-02f, -3.37777615e-01f, 2.75872082e-01f, 6.80653146e-03f,
  2.33999953e-01f, -1.59897923e-01f, -9.42183509e-02f, 2.67754525e-01f, 1.00371003e-01f, 4.35853034e-01f, -2.43874148e-01f, 1.24775305e-01f, 3.99897367e-01f, 1.80213913e-01f,
  1.12877548e-01f, 2.81969070e-01f, -9.41354781e-02f, 7.66498595e-02f, 3.34708124e-01f, 6.57945812e-01f, 4.06376809e-01f, 4.63365883e-01f, -3.63425493e-01f, 1.80332959e-01f,
  -5.40239930e-01f, 2.27391422e-01f, 9.28418785e-02f, -2.25127324e-01f, -1.20620400e-01f, -4.68200803e-01f, 2.67447859e-01f, 1.42950386e-01f, -1.34248704e-01f, 1.94691941e-01f,
  -6.92358539e-02f, -4.43756692e-02f, -2.81452656e-01f, -3.76165748e-01f, -4.62251246e-01f, 6.29725575e-01f, 4.54985470e-01f, -2.90287793e-01f, -4.75632735e-02f, -1.62445419e-02f,
  4.04126585e-01f, -5.99276543e-01f, -6.07698917e-01f, -5.05934298e-01f, 3.17816645e-01f, -2.22550720e-01f, 1.57021329e-01f, -5.13283908e-01f, -7.20410883e-01f, -1.22307017e-01f,
  3.75454038e-01f, 2.52578557e-01f, 3.47121775e-01f, 2.58048505e-01f, 1.98986847e-02f, 1.93616271e-01f, 3.07943344e-01f, -1.66653842e-01f, 3.20169508e-01f, 1.71852544e-01f,
  6.01243913e-01f, 1.69387773e-01f, 4.30658698e-01f, 7.02077746e-02f, 4.84658092e-01f, 2.70516336e-01f, 1.18746914e-01f, 1.71623647e-01f, -1.16653759e-02f, -3.17313373e-01f,
  4.40998197e-01f, 6.61517978e-02f, 6.29670858e-01f, 2.03893378e-01f, -4.49827388e-02f, -1.52669057e-01f, 5.61772525e-01f, -3.36344838e-01f, 6.31075203e-02f, -4.43544358e-01f,
  7.23979771e-01f, 2.03325465e-01f, -3.20882410e-01f, -1.75665841e-02f, -3.86516809e-01f, -5.15494764e-01f, -1.17140219e-01f, 1.62901700e-01f, 4.94015396e-01f, -2.39259109e-01f,
  4.27040398e-01f, 4.41516995e-01f, 5.01029909e-01f, 1.34659529e-01f, 3.39672774e-01f, -1.96904883e-01f, -4.22141194e-01f, -3.53316456e-01f, 2.16832265e-01f, -6.28504813e-01f,
  -3.61855596e-01f, -2.65492409e-01f, -7.37137049e-02f, -1.88405752e-01f, -1.94901362e-01f, 3.35129797e-01f, -2.43356764e-01f, -5.69168329e-01f, 1.66982889e-01f, 9.64287221e-02f,
  2.57689327e-01f, 2.38704801e-01f, -2.32994720e-01f, 2.04958394e-01f, 2.86069989e-01f, -5.68464160e-01f, 3.03569674e-01f, -4.30397421e-01f, 1.58139244e-01f, 2.39854813e-01f,
  2.98499912e-01f, 2.30266646e-01f, 2.24041834e-01f, 1.25087306e-01f, 3.20902497e-01f, 2.60969162e-01f, -4.47627276e-01f, 1.41979665e-01f, 4.92294639e-01f, 2.87822753e-01f,
  -1.33919567e-02f, 3.39542568e-01f, 1.65347055e-01f, 1.70132399e-01f, 1.93180084e-01f, -1.66909005e-02f, 9.43141803e-02f, -8.35024491e-02f, -7.14011043e-02f, -2.23729104e-01f,
  1.40884578e-01f, -1.19904816e-01f, -4.01868254e-01f, 4.99446094e-01f, -3.34309310e-01f, -2.88023055e-01f, -1.54989883e-01f, 1.79630909e-02f, 5.46786845e-01f, 1.30054533e-01f,
  3.09727132e-01f, -9.47196707e-02f, 6.37232363e-01f, -2.44063571e-01f, -3.03872228e-01f, -3.51909906e-01f, 4.11508903e-02f, 4.88392264e-01f, -2.71023750e-01f, -2.86764532e-01f,
  -4.80034016e-02f, -3.45857233e-01f, 1.92081153e-01f, -5.02565861e-01f, -4.26113643e-02f, 1.58796057e-01f, 2.40457356e-01f, -2.68121958e-01f, -6.76859021e-01f, -9.36052620e-01f,
  5.28681040e-01f, -2.53856689e-01f, -7.75982678e-01f, -1.17259897e-01f, -1.47299215e-01f, 3.69731665e-01f, -3.99745792e-01f, -3.10467780e-01f, -1.39155254e-01f, -8.49962831e-02f,
  -1.22014023e-01f, -3.82417999e-02f, -1.50568709e-01f, -3.80981080e-02f, -8.49011019e-02f, -4.02459294e-01f, -4.52077001e-01f, 1.03261493e-01f, 3.26348931e-01f, -6.67964876e-01f,
  7.10365409e-03f, -3.54110301e-01f, -2.03066483e-01f, -1.90264344e-01f, -9.19694006e-02f, -2.88062006e-01f, -1.26092434e-01f, -4.56120186e-02f, -1.95237249e-01f, -2.88367141e-02f,
  -1.93392932e-01f, 1.69010982e-01f, -7.67415538e-02f, -3.25517118e-01f, -5.08380115e-01f, 4.69546050e-01f, 2.32286826e-01f, 2.60126501e-01f, -3.63483131e-01f, 3.53384048e-01f,
  2.28463694e-01f, 3.82831216e-01f, -2.92947665e-02f, -4.35044438e-01f, 2.15363607e-01f, 3.24148208e-01f, -3.78568709e-01f, -2.36396626e-01f, 1.70118019e-01f, -2.22804978e-01f,
  -2.97852874e-01f, -3.12072188e-01f, -2.77271152e-01f, -4.11966175e-01f, 2.82226712e-01f, -2.86369532e-01f, -6.01187944e-01f, 2.88458526e-01f, 2.47601375e-01f, 1.27203897e-01f,
  2.03028783e-01f, 2.37377565e-02f, -1.66895047e-01f, 2.73900658e-01f, -5.06354928e-01f, 3.03413451e-01f, -6.64550960e-01f, 2.07810178e-02f, -1.19214877e-01f, -5.93716860e-01f,
  -4.98678461e-02f, -2.06050873e-01f, -4.25778866e-01f, 1.84589341e-01f, 4.75473702e-02f, -3.42505634e-01f, 2.82807380e-01f, 5.94031215e-02f, -4.47931737e-01f, 9.23425928e-02f,
  -1.94028020e-01f, -2.80445933e-01f, -1.77198961e-01f, 1.59501396e-02f, -8.02788436e-02f, -1.80213019e-01f, 2.55369574e-01f, 9.93955657e-02f, 2.38989845e-01f, 1.75373062e-01f,
  1.29204363e-01f, -1.46223873e-01f, 1.13739312e-01f, -2.87729781e-02f, 6.17363192e-02f, -1.44079804e-01f, 3.44597757e-01f, -1.17377579e-01f, -6.52725697e-02f, -7.97950327e-02f,
  2.17278242e-01f, -2.99780250e-01f, -2.01974064e-01f, -2.74765432e-01f, 5.82666039e-01f, -3.98666203e-01f, -4.26671088e-01f, 5.41480243e-01f, 1.55560985e-01f, 2.99333066e-01f,
  -3.19875211e-01f, 3.81118089e-01f, -3.41948092e-01f, 6.19235523e-02f, -1.11267634e-03f, -8.03210616e-01f, 2.26754367e-01f, -2.47575030e-01f, 2.81965762e-01f, 3.37995261e-01f,
  3.01888406e-01f, 3.97280931e-01f, -3.37275982e-01f, -3.46390247e-01f, 2.91781753e-01f, -5.17260656e-02f, -5.68735003e-01f, 3.53414983e-01f, -4.26583916e-01f, 3.63806337e-01f,
  -7.21721470e-01f, 2.37852857e-01f, -1.40487686e-01f, 3.93086046e-01f, 9.53671616e-03f, -4.70537364e-01f, 3.18407863e-01f, 4.91801381e-01f, -9.85228345e-02f, 1.62342459e-01f,
  1.02988034e-01f, 1.05320536e-01f, 1.77149817e-01f, -5.74978516e-02f, -5.70947528e-01f, 1.30874425e-01f, 2.02296942e-01f, -5.62403083e-01f, 2.06042469e-01f, 7.99518898e-02f,
  1.32464645e-02f, 3.14807177e-01f, -1.17011905e-01f, 1.19948074e-01f, 3.40099782e-01f, -1.29813608e-02f, 1.95395067e-01f, 1.17646605e-01f, -4.11993414e-01f, 2.37410590e-01f,
  1.37563616e-01f, 2.10282236e-01f, -1.86857749e-02f, -4.49648678e-01f, -5.27229071e-01f, -7.15932488e-01f, -2.61839122e-01f, 6.35877788e-01f, -3.27516854e-01f, 7.98888579e-02f,
  3.65081698e-01f, -1.93345338e-01f, -8.74226168e-02f, 1.64785013e-01f, -3.48173410e-01f, 3.16927493e-01f, -1.70005023e-01f, -1.29429713e-01f, -2.60980368e-01f, -1.70884013e-01f,
  -1.90581203e-01f, -4.19099107e-02f, -3.15247029e-02f, 5.89809939e-02f, 4.84790772e-01f, -3.98301452e-01f, 4.35407072e-01f, 3.37131262e-01f, -4.34156805e-01f, -6.60565794e-01f,
  -6.19664267e-02f, -4.82708484e-01f, 3.37924331e-01f, -3.00603174e-02f, 9.54998191e-03f, -5.76222427e-02f, -9.22879875e-02f, -7.59443462e-01f, 7.44706392e-02f, -2.61536509e-01f,
  -1.14012301e-01f, -2.48333573e-01f, 1.00819975e-01f, -3.50920469e-01f, 8.38005021e-02f, -6.90415055e-02f, 2.96440035e-01f, 2.69971758e-01f, 3.01180542e-01f, -4.60817963e-01f,
  -5.60692489e-01f, 2.26185486e-01f, -1.56708911e-01f, -2.40818709e-01f, -1.30068600e-01f, 1.68464810e-01f, -1.00498162e-01f, -4.99717705e-02f, 1.06401324e-01f, 4.53057187e-03f,
  -8.53965059e-02f, -2.95809805e-01f, 1.04229547e-01f, 1.01647317e-01f, 1.21066265e-01f, -3.86158377e-01f, -2.22773358e-01f, 2.82307535e-01f, 2.45842725e-01f, 1.02672018e-01f,
  3.70948374e-01f, -1.38956666e-01f, -2.64638424e-01f, -3.10163230e-01f, -1.21337980e-01f, -1.01583682e-01f, -5.96194744e-01f, -3.79537940e-01f, -3.66384089e-01f, -3.69973302e-01f,
  -3.79617125e-01f, -7.10084200e-01f, 1.15067631e-01f, -1.15465015e-01f, 2.41546050e-01f, 1.27185866e-01f, 5.10480165e-01f, -2.36310691e-01f, -2.79096246e-01f, 1.02373235e-01f,
  -3.67209226e-01f, -4.64035958e-01f, -6.14710212e-01f, -6.77078962e-01f, 4.39263940e-01f, 1.58100158e-01f, -1.34728357e-01f, 1.41588941e-01f, -1.89896554e-01f, -9.88123938e-02f,
  7.23243579e-02f, 1.19700730e-01f, 5.38796604e-01f, -1.06642194e-01f, -1.46419615e-01f, -1.05589509e-01f, -1.80278063e-01f, 2.57231712e-01f, 5.89768402e-02f, -1.21358791e-02f,
  1.35216624e-01f, 3.61584812e-01f, 2.53218532e-01f, -6.87534884e-02f, -1.87312067e-01f, 1.62827596e-01f, 2.20502988e-01f, 9.66236219e-02f, -3.84030282e-01f, -1.05719373e-01f,
  -2.04705764e-02f, 2.07340389e-01f, 7.27779120e-02f, 1.07330374e-01f, 3.05448007e-02f, 2.77627677e-01f, 2.20176876e-01f, -7.15030283e-02f, 1.92623645e-01f, -9.75451544e-02f,
  3.73748630e-01f, -6.10283971e-01f, -1.35102540e-01f, 6.60804957e-02f, 4.78581458e-01f, -3.29565376e-01f, 3.82371172e-02f, -2.61146665e-01f, -1.80693328e-01f, -3.18109512e-01f,
  -3.15130018e-02f, -7.14583173e-02f, 3.17845911e-01f, -1.56328052e-01f, 2.96770632e-01f, 5.78325033e-01f, -2.20131546e-01f, -1.06143169e-01f, 4.52315003e-01f, 3.74276131e-01f,
  7.64184222e-02f, -6.36427256e-04f, -6.40960932e-01f, 6.33699656e-01f, -9.86869037e-02f, -7.98867866e-02f, 2.60182559e-01f, 3.70322853e-01f, -6.91033006e-01f, -5.63547134e-01f,
  2.08417878e-01f, 4.22755629e-01f, 3.08298796e-01f, -1.16514765e-01f, -6.07793987e-01f, 1.04235411e-01f, -2.52879411e-01f, -1.60162270e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.64553553e-01f, -1.35287747e-01f, 4.85381410e-02f, -9.66274142e-02f, 1.68726556e-02f, -1.13706859e-02f, 1.55660689e-01f, 2.93568224e-02f, 8.23593885e-02f, 7.90832750e-03f,
  -1.51450470e-01f, -7.83673748e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    