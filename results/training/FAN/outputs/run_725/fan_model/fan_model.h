/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.32761684e-02f, -2.73712743e-02f, -3.92137654e-02f, -3.89972813e-02f, -2.82343328e-01f, -2.17602327e-01f, -1.14508703e-01f, 1.04951866e-01f, 8.06528926e-02f, -1.18450157e-01f,
  -1.72577441e-01f, -1.86589491e-02f, 1.20818220e-01f, 1.49439946e-01f, 2.39900708e-01f, 1.05094001e-01f, 1.19302638e-01f, 2.76341558e-01f, 8.92881975e-02f, -1.00101605e-01f,
  -3.78941931e-02f, -1.04618436e-02f, 2.02047139e-01f, 2.03105345e-01f, -7.52587691e-02f, -8.80368650e-02f, -2.95224506e-02f, -1.10773686e-02f, -2.98582949e-02f, 4.43913937e-02f,
  -1.78974345e-01f, 1.06091663e-01f, 9.34545770e-02f, 8.44709948e-02f, 2.33356692e-02f, 1.51289210e-01f, 1.17412612e-01f, 2.04911217e-01f, 9.28941816e-02f, 8.83702934e-02f,
  3.15760821e-02f, 1.55830607e-01f, 5.53570651e-02f, 1.15791172e-01f, 1.17787324e-01f, 6.94552362e-02f, 2.55087495e-01f, 2.96553254e-01f, 1.92667946e-01f, 7.00022057e-02f,
  9.13929567e-02f, -1.30670518e-01f, -5.80098405e-02f, 2.14653477e-01f, 2.61868775e-01f, 1.82961598e-01f, 1.80806577e-01f, 1.08337596e-01f, 1.91894308e-01f, 1.03966892e-01f,
  2.21918691e-02f, -4.54051280e-03f, -6.46048412e-02f, -4.09219079e-02f, -4.02596407e-02f, -6.06192648e-02f, -4.84051667e-02f, -5.85614666e-02f, -2.79890303e-03f, 2.22259592e-02f,
  -9.57450941e-02f, -9.11584795e-02f, -5.79352453e-02f, -1.32996812e-01f, -2.24893726e-03f, -6.26103580e-02f, -4.37508374e-02f, -3.22381756e-03f, -8.45544562e-02f, 1.54555617e-02f,
  -8.83613974e-02f, -2.70945039e-02f, 2.00104788e-02f, -4.41954248e-02f, 2.04119645e-02f, 5.50818071e-02f, -1.33739794e-02f, 3.80211920e-02f, 6.06060028e-02f, 2.01691557e-02f,
  -1.44247547e-01f, 2.54276413e-02f, -2.03045309e-02f, 1.44370869e-01f, 7.47954398e-02f, 4.30712104e-02f, -3.42014208e-02f, -2.11894009e-02f, 9.76082124e-03f, 1.42102288e-02f,
  7.86708295e-02f, 1.07199758e-01f, 2.14536935e-02f, -3.79097238e-02f, -3.11645307e-02f, 6.61846697e-02f, -1.54193060e-03f, 9.11733694e-03f, 1.63348034e-01f, 4.07352746e-02f,
  5.65794297e-02f, 5.09361690e-03f, 2.51305383e-02f, -6.26451476e-03f, -7.43574463e-03f, -3.60788107e-02f, 9.14224703e-03f, 4.61699218e-02f, 5.84866554e-02f, 7.51518086e-02f,
  -1.84038863e-01f, -1.80155456e-01f, -1.31423801e-01f, -8.46788660e-02f, -2.64986977e-02f, 1.14472821e-01f, 1.15552731e-01f, 2.48051092e-01f, 1.25625297e-01f, 1.13401026e-01f,
  9.06126350e-02f, 8.03103969e-02f, 1.96200788e-01f, 1.90024510e-01f, 1.95322797e-01f, 5.85155562e-02f, -6.76630065e-02f, 5.21055423e-02f, 2.34928071e-01f, 2.11244881e-01f,
  2.03805134e-01f, 8.73019397e-02f, 1.05094671e-01f, 1.53170153e-01f, 1.34286601e-02f, 9.62123871e-02f, 6.32199459e-03f, 1.85854472e-02f, -7.64457043e-04f, 1.13356542e-02f,
  2.36786962e-01f, -2.05691531e-02f, 2.02587813e-01f, 8.82037655e-02f, 1.91960093e-02f, 3.65715264e-03f, 5.67309484e-02f, 5.31093404e-03f, -2.69133206e-02f, -1.54204331e-02f,
  -2.13517970e-03f, 1.19157799e-01f, -4.95277084e-02f, 1.63286608e-02f, 1.52280793e-01f, 1.27546772e-01f, -9.30149667e-03f, 3.75853926e-02f, 1.40606597e-01f, 1.63130775e-01f,
  6.84951916e-02f, -1.21917769e-01f, 3.45116336e-04f, 1.68423593e-01f, 5.59201837e-02f, 7.50669139e-03f, 5.33021092e-02f, 1.54427052e-01f, 5.88303022e-02f, 1.27970919e-01f,
  1.81879830e-02f, -6.56331107e-02f, 3.47062509e-04f, -5.15509546e-02f, 3.43908817e-02f, 1.12709415e-03f, 1.62594672e-02f, -5.04555879e-03f, 2.10126899e-02f, 1.45252151e-02f,
  -1.76127423e-02f, -3.41292424e-03f, 2.26730891e-02f, 8.29785038e-03f, 3.90732214e-02f, 8.07456002e-02f, -1.38701117e-02f, 2.28021070e-02f, -3.15608568e-02f, -1.04937769e-01f,
  -4.86922860e-02f, -8.79240036e-03f, 1.88426618e-02f, -2.08530128e-02f, -1.29026949e-01f, 2.83328872e-02f, 3.57566625e-02f, 3.55507992e-02f, 4.11793813e-02f, -3.41306394e-03f,
  3.01145792e-01f, 6.87275082e-02f, 1.64229363e-01f, 1.35562211e-01f, -1.20287463e-02f, 7.07428828e-02f, 8.13005269e-02f, 7.62043800e-03f, 6.39307052e-02f, 1.73349783e-01f,
  1.09512947e-01f, -6.15927670e-03f, 5.89181706e-02f, 5.85147105e-02f, 5.63230217e-02f, 1.62178636e-01f, -6.57561943e-02f, 9.78901610e-03f, 1.14154257e-01f, 4.73490469e-02f,
  4.17181030e-02f, 1.62343055e-01f, 2.27668092e-01f, 7.56388754e-02f, 6.82719126e-02f, 8.27765316e-02f, 2.06244439e-01f, 1.71441168e-01f, 1.47808567e-01f, 2.56369352e-01f,
  4.54821944e-01f, 1.54860824e-01f, -4.44284171e-01f, 1.27014279e-01f, -1.14812896e-01f, -5.52531425e-03f, -7.86984526e-03f, 6.11424223e-02f, 5.95982978e-03f, -2.86832289e-03f,
  -1.76669151e-01f, -1.18814401e-01f, -1.32243171e-01f, -2.21603259e-01f, -1.01882823e-01f, 9.39956773e-03f, -1.97295502e-01f, -2.61543274e-01f, -2.02119976e-01f, -1.54365793e-01f,
  -6.38074875e-02f, -7.28605688e-02f, -2.70734951e-02f, -5.21790832e-02f, -8.64410400e-02f, -1.78296596e-01f, -2.38746002e-01f, -7.47242868e-02f, -2.26972431e-01f, -9.92461294e-02f,
  -3.18484008e-01f, 8.88503417e-02f, -2.53474087e-01f, -1.32689327e-01f, -1.13199458e-01f, -4.55187559e-02f, -1.52643427e-01f, -1.64087579e-01f, -5.24426922e-02f, -3.46337259e-02f,
  -2.07726434e-01f, -2.82487050e-02f, -2.09573936e-02f, -1.06114015e-01f, 3.24893147e-02f, -9.74595547e-02f, -7.58330449e-02f, -1.33987544e-02f, -6.84150308e-02f, -5.91792762e-02f,
  -5.99384718e-02f, -1.25836045e-01f, -7.95389190e-02f, -1.57446042e-01f, -2.28943974e-02f, -1.30352080e-01f, -1.50599793e-01f, -1.00247987e-01f, -1.59294546e-01f, -8.67072418e-02f,
  -5.05441204e-02f, 4.49627312e-03f, -1.28559256e-03f, 1.47714078e-01f, 2.90784463e-02f, 1.41030565e-01f, 3.62518057e-02f, 5.03987037e-02f, 1.21760704e-01f, 1.06226772e-01f,
  6.60323277e-02f, 4.35042009e-02f, 9.11638737e-02f, 6.65697455e-02f, 1.91302206e-02f, 3.54356170e-02f, 1.16999000e-01f, 1.92868076e-02f, -3.68368439e-03f, 2.96325833e-02f,
  1.26591086e-01f, 7.21604079e-02f, 9.87769142e-02f, 1.68742309e-03f, 7.43367001e-02f, 1.06224008e-01f, 1.04113773e-01f, 1.10826001e-01f, 6.62543550e-02f, 1.30620047e-01f,
  -9.75186899e-02f, -1.57683134e-01f, -7.74224550e-02f, -1.74307805e-02f, -1.64899245e-01f, -9.76739377e-02f, -1.73979118e-01f, -1.28150940e-01f, -8.31000954e-02f, -1.95071191e-01f,
  -8.77528340e-02f, -4.97787818e-02f, -9.11556855e-02f, -1.15345232e-02f, -8.98115188e-02f, -1.29762769e-01f, 1.59440376e-02f, -1.89007774e-01f, -1.61576599e-01f, -1.21643752e-01f,
  -5.09322397e-02f, -9.10220891e-02f, -4.36389744e-02f, -5.28005771e-02f, -1.44589871e-01f, -1.21560387e-01f, -2.44100019e-01f, -7.31370002e-02f, -2.17842191e-01f, -1.02276206e-01f,
  -1.87416784e-02f, -9.84062850e-02f, -8.50384608e-02f, 5.11745038e-03f, -2.51339942e-01f, -8.14278945e-02f, -1.94814414e-01f, 7.08606616e-02f, 5.64785209e-04f, -1.11176647e-01f,
  2.20948365e-02f, 2.09765479e-01f, 1.41229972e-01f, 2.50059873e-01f, 2.37290457e-01f, -8.13808888e-02f, 1.32822348e-02f, 1.26466140e-01f, 1.67711332e-01f, 3.09565812e-02f,
  -6.52396213e-03f, -1.70649942e-02f, 4.28460278e-02f, 1.35354474e-01f, -1.45878613e-01f, 8.98973793e-02f, -1.14151821e-01f, -7.63557479e-02f, -1.72937259e-01f, 7.12389685e-03f,
  -5.48764504e-02f, -1.19371384e-01f, -2.09866166e-02f, 2.40919255e-02f, -1.81568578e-01f, -1.38644893e-02f, 2.08252016e-02f, -2.88484339e-02f, -5.00442721e-02f, -1.53302588e-02f,
  -1.18502356e-01f, 1.45318620e-02f, -3.26446481e-02f, -9.52087492e-02f, -7.72632584e-02f, -5.89140989e-02f, 1.31434398e-02f, -3.49211805e-02f, 5.67288324e-02f, 1.23027759e-02f,
  -7.43842125e-02f, -2.12203145e-01f, -6.09647967e-02f, -1.34725660e-01f, 6.60058111e-02f, 4.45259102e-02f, -1.67212844e-01f, -3.83512713e-02f, -8.15240592e-02f, 2.00007223e-02f,
  2.98813600e-02f, -5.70566133e-02f, -3.73270847e-02f, 9.26691368e-02f, 4.01801802e-02f, 4.67684232e-02f, 5.83665855e-02f, -3.30918692e-02f, -3.03204125e-03f, 2.14420892e-02f,
  8.01323429e-02f, 4.12015952e-02f, 7.52206370e-02f, -3.30334455e-02f, 3.90577526e-03f, -6.60466328e-02f, -8.31717625e-02f, 8.06843862e-02f, -6.12632483e-02f, -3.16327848e-02f,
  7.00543746e-02f, -6.19120114e-02f, -1.27800154e-02f, 3.75972316e-02f, 3.43324021e-02f, 4.30446342e-02f, -9.86953173e-03f, 5.97038530e-02f, -4.50051390e-02f, 1.07298223e-02f,
  1.68174729e-01f, -6.96032727e-03f, -4.70523313e-02f, 8.95271897e-02f, -5.40615395e-02f, -4.28037755e-02f, -1.86631791e-02f, -3.41704711e-02f, 1.28785903e-02f, -4.47017187e-03f,
  -8.28932896e-02f, -3.49950418e-02f, -9.51070786e-02f, -1.68134011e-02f, -9.22980458e-02f, -4.78194878e-02f, 1.25845019e-02f, -4.24892735e-03f, -2.35958323e-02f, -1.32945523e-01f,
  1.34212933e-02f, -1.15520343e-01f, -5.50976135e-02f, -1.04852682e-02f, -1.79641470e-02f, -3.57706323e-02f, -6.42061532e-02f, -1.42899632e-01f, 2.35842820e-02f, 3.84195521e-02f,
  -6.79711029e-02f, -1.51077032e-01f, -6.39374256e-02f, 1.20046452e-01f, 1.67536676e-01f, 1.29302144e-01f, 4.62086014e-02f, 1.50796115e-01f, 1.87983662e-01f, 1.01972893e-01f,
  -1.57028466e-01f, -1.44838035e-01f, -1.33532047e-01f, -1.22158773e-01f, -2.71885574e-01f, -5.71678532e-03f, 2.19762884e-02f, -1.09325044e-01f, -5.16378209e-02f, 9.45840701e-02f,
  4.81387153e-02f, -2.38140989e-02f, -4.94009256e-02f, -1.15767024e-01f, 1.72364712e-01f, 1.77079096e-01f, 1.20588787e-01f, 8.84110853e-02f, -8.80843252e-02f, 1.99155271e-01f,
  -4.93439920e-02f, -2.68035948e-01f, 2.35174070e-04f, -2.56203502e-01f, -1.59620300e-01f, -2.07057640e-01f, -1.67161405e-01f, -2.22538903e-01f, -1.97191611e-01f, -9.35014635e-02f,
  -1.91279173e-01f, -1.36895493e-01f, -8.74105394e-02f, -3.47025022e-02f, -5.10452874e-02f, -1.78754792e-01f, -1.42176807e-01f, -1.89241976e-01f, -1.88009545e-01f, -9.43813771e-02f,
  -1.75839350e-01f, -9.81247351e-02f, -2.25224659e-01f, -9.89295617e-02f, -2.04894185e-01f, -6.08113892e-02f, -1.07650012e-01f, -3.95016335e-02f, -6.72056526e-02f, 7.21776932e-02f,
  9.33273807e-02f, -1.18874088e-02f, 9.03792009e-02f, 2.12717485e-02f, 3.36870477e-02f, 6.90435395e-02f, 8.22612420e-02f, 8.40039402e-02f, 8.15724730e-02f, 4.35531065e-02f,
  -6.53347597e-02f, 3.96651328e-02f, 8.14648271e-02f, 1.01736493e-01f, 1.85565278e-02f, 4.54245321e-02f, 2.74771806e-02f, -2.46389513e-03f, -9.68582928e-03f, -2.60441322e-02f,
  -6.66260049e-02f, 2.90952600e-03f, 5.30519858e-02f, -1.33697316e-02f, 6.73484057e-03f, -6.06234558e-02f, 1.19241580e-01f, -3.38697545e-02f, 3.14003080e-02f, 7.59658590e-02f,
  1.25058919e-01f, -2.62435347e-01f, -4.75488566e-02f, -1.40962556e-01f, -1.08356617e-01f, -8.27258751e-02f, -2.61999182e-02f, -3.06388158e-02f, -5.93203381e-02f, -9.24524814e-02f,
  -1.28025830e-01f, -6.07930608e-02f, -1.31871596e-01f, -1.33844018e-01f, -1.01002127e-01f, 4.35288586e-02f, -1.26659036e-01f, -8.53660479e-02f, -8.30232725e-02f, -1.30562307e-02f,
  2.46742759e-02f, -2.24798247e-02f, 3.79653089e-02f, 1.03014760e-01f, 1.80765148e-02f, -6.81954920e-02f, 3.14233787e-02f, 7.63296336e-02f, -1.44187817e-02f, 1.51363865e-01f,
  3.27253431e-01f, 3.62263285e-02f, 1.39544380e-03f, 1.93203956e-01f, 3.32180381e-01f, 2.79000252e-01f, 2.01045662e-01f, 2.14497522e-01f, 1.87480554e-01f, 1.11158304e-01f,
  8.59448835e-02f, 8.92563537e-02f, 1.26519576e-02f, -9.49558988e-03f, -1.13103181e-01f, 1.64394706e-01f, 1.27226859e-01f, 5.99828139e-02f, 1.92773119e-02f, 1.92201361e-01f,
  1.46113545e-01f, 1.35258749e-01f, 5.36089651e-02f, 1.02840863e-01f, 2.76569992e-01f, 1.41083941e-01f, 7.06786886e-02f, 1.75090581e-01f, 1.88266739e-01f, 3.16400707e-01f,
  1.35557488e-01f, 2.01392353e-01f, -3.92583944e-02f, 4.33502235e-02f, 1.10465534e-01f, 1.81217328e-01f, 1.33423105e-01f, 7.27638602e-02f, 1.64366439e-01f, 9.14790928e-02f,
  2.21573025e-01f, 1.16343655e-01f, 8.89711380e-02f, 3.04794516e-02f, 1.42153844e-01f, 4.83824201e-02f, 1.08033873e-01f, 2.40201522e-02f, 5.20958379e-02f, 9.07495394e-02f,
  2.37506837e-01f, 2.99207687e-01f, 1.49877995e-01f, 1.73717394e-01f, 1.24951869e-01f, 2.01458156e-01f, 1.43827692e-01f, 1.58348128e-01f, 1.90944329e-01f, 2.54542381e-01f,
  -5.32026263e-03f, -5.22877201e-02f, -4.29724297e-03f, 1.15376702e-02f, -1.13237947e-01f, -1.61685310e-02f, 4.42814827e-02f, -2.06520297e-02f, -1.07524008e-01f, 2.78682057e-02f,
  -7.72585301e-03f, -1.44915795e-02f, -1.69433933e-02f, 5.33284210e-02f, -4.90056425e-02f, 6.76134555e-03f, -4.62376550e-02f, -2.29581781e-02f, -4.95645069e-02f, -8.49219710e-02f,
  5.66344336e-02f, -5.46243154e-02f, -6.57138675e-02f, 1.42902217e-03f, -1.09980494e-01f, 4.67802994e-02f, 3.46202357e-03f, -6.64331019e-02f, -7.42459148e-02f, 1.61227938e-02f,
  -2.10363701e-01f, 3.95243429e-02f, 8.79795775e-02f, 7.42128193e-02f, 1.44910440e-01f, -2.09374577e-02f, 2.41201352e-02f, 6.05208986e-02f, 7.82029331e-02f, 8.61943364e-02f,
  7.98240528e-02f, 9.48706120e-02f, 1.06735967e-01f, 2.26592645e-02f, 1.49612442e-01f, 1.23679198e-01f, 7.18395412e-02f, 9.68477726e-02f, 4.00403142e-02f, 1.33338720e-01f,
  6.99146464e-02f, 1.54799968e-01f, 1.77456424e-01f, -1.48783717e-03f, 1.49016470e-01f, 6.19787648e-02f, 8.71235207e-02f, 1.15182661e-01f, 1.34200066e-01f, -1.33327888e-02f,
  2.48549208e-01f, 5.44158891e-02f, -6.70981482e-02f, -3.04378327e-02f, -1.69427842e-01f, -1.40298918e-01f, 4.22590151e-02f, 1.12417191e-01f, 1.32589698e-01f, 7.67420977e-02f,
  -1.83720186e-01f, -2.03489363e-02f, 5.77107295e-02f, -7.02913180e-02f, 1.45226344e-01f, 1.58732966e-01f, 7.86001757e-02f, -7.32794106e-02f, -6.85765445e-02f, -1.83478147e-01f,
  -1.08924694e-01f, -1.54363677e-01f, -4.77215610e-02f, -9.27517638e-02f, -8.00527409e-02f, -2.03532130e-01f, -1.50546029e-01f, -1.37957752e-01f, -1.97556034e-01f, -2.03799292e-01f,
  -2.69082654e-03f, -2.19687745e-02f, 1.15666434e-01f, 4.21065791e-03f, 3.34750265e-02f, 1.02615617e-01f, 9.29675717e-03f, 8.32573976e-03f, -1.77772157e-02f, 1.94613319e-02f,
  3.64007871e-03f, 8.70517641e-02f, 1.54083651e-02f, -8.01904425e-02f, 1.02759443e-01f, 1.27441436e-01f, 4.15008180e-02f, 7.29940385e-02f, -1.06999185e-02f, 4.55225222e-02f,
  -8.90866667e-02f, -8.91443714e-02f, 5.51683195e-02f, 6.22396916e-02f, -4.67421710e-02f, 5.52800745e-02f, 7.53462389e-02f, 4.72903065e-02f, 3.84591967e-02f, 1.58065304e-01f,
  1.40046805e-01f, 5.23558073e-02f, -1.04420133e-01f, -8.33157599e-02f, -6.78352118e-02f, -2.49972437e-02f, 4.75712977e-02f, -1.12380423e-01f, 8.89486820e-03f, 1.33064361e-02f,
  3.19879167e-02f, 1.75959859e-02f, -1.14052698e-01f, 7.03438967e-02f, -3.79575454e-02f, -6.30638674e-02f, -3.41862105e-02f, -8.15786794e-02f, -8.56882706e-02f, -2.53817700e-02f,
  -7.78502673e-02f, -3.83503661e-02f, -7.64257461e-02f, -4.31820713e-02f, -7.33592287e-02f, 4.62098047e-02f, -7.01195076e-02f, -1.47348225e-01f, 3.53683718e-02f, -1.33563709e-02f,
  5.97751476e-02f, -2.84507852e-02f, 1.41589075e-01f, 6.77749217e-02f, 1.53697832e-02f, 2.15440188e-02f, 1.18755236e-01f, 3.46303396e-02f, 1.00517899e-01f, 9.30427089e-02f,
  -4.42651547e-02f, 1.44324064e-01f, 9.64339264e-03f, 4.37611416e-02f, 1.21718340e-01f, 4.88605797e-02f, 1.07646853e-01f, 1.35238484e-01f, 4.05644141e-02f, 6.30601794e-02f,
  9.88039151e-02f, 9.72695574e-02f, 1.55641973e-01f, 1.35491669e-01f, 8.91053304e-02f, 7.43938759e-02f, 1.43449977e-01f, 1.71934664e-01f, 7.20701888e-02f, 2.64274329e-01f,
  2.83725202e-01f, -1.23930067e-01f, 1.51058689e-01f, 1.57999977e-01f, 1.92925006e-01f, 2.64474869e-01f, 4.27753031e-02f, 1.16690062e-01f, 1.71445280e-01f, 1.61475718e-01f,
  1.12037353e-01f, 2.84288585e-01f, 9.88082811e-02f, 9.72739980e-02f, 2.33891487e-01f, -2.83973012e-02f, 2.40019592e-03f, 2.41093293e-01f, 2.08723247e-01f, 2.67265916e-01f,
  9.52059254e-02f, -2.31327340e-02f, 2.61891522e-02f, 1.58998221e-01f, -9.47859734e-02f, -8.53939541e-03f, 3.17941122e-02f, -3.36622521e-02f, 1.35420626e-02f, -1.02845065e-01f,
  -3.55791636e-02f, 1.12549461e-01f, 1.63275421e-01f, 2.30177477e-01f, 1.04593359e-01f, 1.06984526e-01f, 1.72294632e-01f, 1.43343195e-01f, 1.36264682e-01f, 1.39168248e-01f,
  1.56137154e-01f, 1.74890012e-01f, 1.38408169e-01f, 1.64364681e-01f, 1.61664560e-01f, 1.16844490e-01f, 1.89717516e-01f, 7.53882825e-02f, 1.15348965e-01f, 1.65404469e-01f,
  1.02403894e-01f, 2.16346398e-01f, 1.20430984e-01f, 1.68252140e-01f, 6.80239201e-02f, 1.61803201e-01f, 1.09007597e-01f, 7.68251643e-02f, 2.22859174e-01f, 4.80365306e-02f,
  -1.56136416e-02f, 2.80828662e-02f, -6.54058382e-02f, -1.31913409e-01f, -9.70941484e-02f, -6.78614452e-02f, -4.37404774e-02f, -9.44734141e-02f, -1.07920915e-01f, -1.63288131e-01f,
  -5.46272993e-02f, -2.10247561e-02f, 2.45529767e-02f, -2.58644037e-02f, -6.25245050e-02f, -1.65398624e-02f, -3.24391834e-02f, -9.67147350e-02f, -6.94248155e-02f, -1.00781143e-01f,
  -9.90279168e-02f, -2.29855068e-02f, -1.14673294e-01f, -1.33168191e-01f, -6.44175336e-02f, -1.48381302e-02f, -4.78349589e-02f, 2.69385893e-02f, -4.69801836e-02f, -1.12206429e-01f,
  -1.49493113e-01f, 2.11869299e-01f, 6.05782494e-02f, 1.59801804e-02f, 3.78083251e-02f, 5.07075191e-02f, 1.04996465e-01f, 9.61918756e-02f, 1.09955549e-01f, -2.76488587e-02f,
  5.03125861e-02f, 1.09234788e-01f, 1.02356579e-02f, 9.14772227e-02f, 8.07697773e-02f, 9.32660848e-02f, 3.71128358e-02f, 1.93762049e-01f, 1.79756179e-01f, 1.20340735e-01f,
  4.33405042e-02f, 1.83569491e-01f, 2.13475272e-01f, 1.55098736e-01f, 7.18010366e-02f, 2.52631158e-01f, 1.07508697e-01f, 9.74225774e-02f, 1.82317659e-01f, -9.57857370e-02f,
  2.25799054e-01f, -2.19536886e-01f, -7.96492398e-02f, 3.04743260e-01f, 4.00200039e-02f, -1.51294276e-01f, -1.83266774e-01f, -1.00413844e-01f, 2.08974257e-01f, 4.16584499e-02f,
  -6.83290586e-02f, 5.53507656e-02f, 1.06485836e-01f, 5.27831391e-02f, -3.63578089e-02f, -1.19997159e-01f, 1.37109503e-01f, 7.03012571e-02f, 3.79048586e-02f, -3.94585095e-02f,
  8.25056583e-02f, 2.13780791e-01f, 1.30218863e-01f, 1.42053261e-01f, 1.06789656e-01f, 1.12518601e-01f, 5.52962311e-02f, -3.02264281e-03f, -1.26056701e-01f, 8.58183205e-02f,
  -1.35258242e-01f, -7.85899833e-02f, 5.81196360e-02f, -7.35187810e-03f, 4.41797525e-02f, -5.16538927e-03f, 5.97241241e-03f, -3.03291697e-02f, -5.36016859e-02f, -1.63136143e-03f,
  2.20889989e-02f, 8.49470031e-04f, 4.55099009e-02f, 5.28849922e-02f, 6.50914237e-02f, 3.72152925e-02f, 9.68604460e-02f, 3.34470086e-02f, 9.88122076e-02f, -9.91751999e-03f,
  -4.93465811e-02f, -9.08510536e-02f, -3.00762430e-02f, -6.17714562e-02f, -7.97285140e-02f, 8.88902247e-02f, -9.54792574e-02f, 1.23102851e-02f, -6.01621345e-02f, -4.98998202e-02f,
  6.30804524e-02f, 2.83958856e-02f, -6.49142414e-02f, 4.26993482e-02f, 3.55856530e-02f, 1.64481085e-02f, 6.66282177e-02f, -3.81506458e-02f, -1.27061252e-02f, -4.01183777e-02f,
  -1.50032891e-02f, 2.38178466e-02f, 3.80494706e-02f, 1.05964881e-03f, 6.74600154e-03f, 1.92547068e-02f, -3.20402198e-02f, -9.15483199e-03f, 5.78738153e-02f, 7.74355456e-02f,
  3.02732009e-02f, 2.86434777e-02f, 1.48888022e-01f, 7.42065236e-02f, 1.20854370e-01f, 1.09263740e-01f, 2.20209658e-02f, 6.60633221e-02f, 3.21918391e-02f, -2.05371864e-02f,
  2.15522610e-02f, -1.69736091e-02f, -3.43047045e-02f, -3.86935510e-02f, -4.44582338e-03f, -4.36236411e-02f, -1.99864395e-02f, -4.04555490e-03f, -2.94041075e-02f, 3.90820578e-03f,
  -1.87122878e-02f, -3.53961475e-02f, 4.49051969e-02f, -5.64219095e-02f, -5.59408404e-02f, 1.17461123e-02f, -6.71308935e-02f, 8.85234028e-02f, -8.74370337e-02f, -7.33101815e-02f,
  -7.06514716e-02f, -1.11268893e-01f, -1.53124467e-01f, -4.68586162e-02f, -5.44108124e-03f, 4.27123681e-02f, -5.59255965e-02f, -1.63126867e-02f, -4.55563096e-03f, -5.99932810e-03f,
  3.42254192e-01f, 2.61643648e-01f, 6.01338334e-02f, 1.33948699e-01f, 1.50851607e-01f, 8.37914348e-02f, 2.69176036e-01f, 3.73284966e-02f, 1.68022424e-01f, 1.93919986e-01f,
  1.44244550e-04f, -3.45325172e-02f, -4.71550450e-02f, -2.06448033e-01f, -1.50494173e-01f, 1.25273958e-01f, 1.21838056e-01f, -1.19038686e-01f, -1.55530646e-02f, 1.27960458e-01f,
  4.74088863e-02f, 1.44902706e-01f, -7.71521777e-02f, -9.95442271e-02f, 1.23082064e-01f, 1.26319733e-02f, -2.80878004e-02f, -3.90563831e-02f, -1.87622812e-02f, 1.07233331e-01f,
  7.65995160e-02f, 3.52401212e-02f, -2.88128108e-02f, -1.88302733e-02f, 1.97304059e-02f, 1.74409356e-02f, 5.32769598e-02f, -2.44446713e-02f, -8.96170828e-03f, 1.02523945e-01f,
  -7.11318180e-02f, 3.33302990e-02f, 1.13988863e-02f, -3.15514766e-02f, 4.09336425e-02f, 1.09381989e-01f, -2.00130176e-02f, 6.32843748e-02f, -1.08102802e-02f, 7.93021098e-02f,
  5.59221953e-02f, 9.48926508e-02f, 1.18897296e-01f, -4.26658876e-02f, -5.17473519e-02f, 2.69013587e-02f, 3.59706804e-02f, -7.74807259e-02f, 1.02967005e-02f, 5.78513071e-02f,
  -2.40699332e-02f, 2.92914896e-03f, -6.90623671e-02f, 5.95923848e-02f, 7.43756886e-04f, 2.54543731e-03f, -4.34282199e-02f, -1.43578649e-02f, -6.38414770e-02f, 7.51946047e-02f,
  -4.62301411e-02f, -9.18069780e-02f, 4.03119531e-03f, 6.19697645e-02f, 3.95796522e-02f, 3.92258801e-02f, -1.19326881e-03f, -4.98301163e-03f, 6.71381550e-03f, -1.47862975e-02f,
  2.93760262e-02f, -2.11398117e-02f, -4.36802246e-02f, -7.43498281e-03f, 3.59390229e-02f, -4.95382100e-02f, -3.08383610e-02f, -5.19072302e-02f, 4.75329347e-02f, 3.86704206e-02f,
  1.25918210e-01f, -1.61092326e-01f, 1.89439297e-01f, 6.53862283e-02f, 1.11911461e-01f, 7.47756585e-02f, 3.49545702e-02f, -9.68080293e-03f, 4.23904555e-03f, 5.58459423e-02f,
  2.27086060e-02f, 7.96234533e-02f, 6.10443577e-02f, 4.52428870e-02f, 5.45815602e-02f, 1.00973293e-01f, 1.16420500e-01f, 3.63586657e-02f, -2.03909278e-02f, 6.11521825e-02f,
  2.69997045e-02f, 1.15652807e-01f, 8.88869613e-02f, 3.60210724e-02f, 1.65782552e-02f, 1.39663950e-01f, 1.46571726e-01f, 1.26985267e-01f, 6.96381107e-02f, 2.42800042e-01f,
  -2.99590528e-01f, -2.64164120e-01f, -3.71704489e-01f, -2.22844332e-01f, -1.40053709e-03f, -1.35306194e-01f, -2.15020686e-01f, -1.64446533e-01f, -4.01362181e-02f, -1.09491095e-01f,
  -7.47247413e-02f, -5.28388023e-02f, -2.22419858e-01f, -1.82485238e-01f, -2.47928619e-01f, -3.23689014e-01f, -3.09425890e-01f, -2.37362891e-01f, -8.75214040e-02f, -3.06379385e-02f,
  8.50545093e-02f, -1.05586283e-01f, -2.01038778e-01f, -1.27886936e-01f, -2.41868082e-03f, -4.16528843e-02f, -2.03987956e-01f, -1.35316044e-01f, -1.38060585e-01f, -9.79957283e-02f,
  -3.62719029e-01f, -1.62751958e-01f, 2.90748607e-02f, 2.02883501e-02f, -4.37608138e-02f, -9.41566378e-02f, -1.29380636e-02f, -1.41862467e-01f, 2.61756778e-02f, -1.27634197e-01f,
  -2.34471634e-03f, -1.02230941e-03f, -6.93004429e-02f, 4.07020971e-02f, -1.72855407e-01f, -6.39104703e-03f, -1.56967312e-01f, -1.88135996e-01f, -1.71952069e-01f, -1.15975998e-01f,
  6.20862208e-02f, -9.07235667e-02f, -2.08364338e-01f, -1.43248409e-01f, -1.02144562e-01f, -1.60848498e-01f, -1.09924972e-01f, -1.20994546e-01f, -2.44525328e-01f, -2.05972418e-01f,
  3.94974947e-02f, 1.25212640e-01f, 9.42167044e-02f, 4.87663895e-02f, 1.52880713e-01f, 4.71966565e-02f, 7.77191743e-02f, 2.22621504e-02f, 1.63827896e-01f, 6.61561489e-02f,
  -3.94477099e-02f, 5.49866557e-02f, 1.02224452e-02f, -3.64227444e-02f, 1.17438093e-01f, 9.29200277e-03f, 9.22768936e-02f, 3.36468369e-02f, 7.64706805e-02f, 4.79013920e-02f,
  3.99145223e-02f, 6.66360185e-02f, 1.38545692e-01f, 2.35121530e-02f, 7.23521486e-02f, -1.16991801e-02f, 5.85434176e-02f, 8.68318900e-02f, 1.78828523e-01f, 1.36234527e-02f,
  -3.40397730e-02f, -1.38441265e-01f, -1.00851379e-01f, -8.29318538e-02f, -2.18345225e-02f, 4.26660897e-03f, -5.29659130e-02f, -1.42818168e-01f, -8.84568021e-02f, -8.42216015e-02f,
  -6.33291900e-02f, -5.95478341e-02f, -1.00465395e-01f, -1.98518764e-02f, -3.42873000e-02f, -6.70051277e-02f, -4.91960496e-02f, -1.13328330e-01f, -2.17223968e-02f, 2.10013706e-02f,
  3.19216102e-02f, -3.51269953e-02f, -7.50964284e-02f, -5.26978448e-02f, -5.41008785e-02f, -2.65372582e-02f, -1.07135661e-01f, -1.81703314e-01f, -1.94182977e-01f, -1.66782022e-01f,
  -4.03561771e-01f, -2.51946241e-01f, -2.32745066e-01f, -2.04974860e-01f, -2.72227466e-01f, -2.14329481e-01f, -2.35419586e-01f, -1.57172501e-01f, -1.51350126e-01f, -1.14730090e-01f,
  -3.39350700e-02f, 6.21333942e-02f, -7.22595351e-03f, -7.34758154e-02f, -6.49966225e-02f, -1.48806259e-01f, -2.74713159e-01f, -1.90240219e-01f, -1.31312415e-01f, -1.65570691e-01f,
  -2.52215505e-01f, -2.61204392e-01f, -1.45108625e-01f, -2.53422499e-01f, -2.92008132e-01f, -2.22539857e-01f, -2.76103646e-01f, -2.33076885e-01f, -2.97607809e-01f, -3.09185088e-01f,
  6.84610754e-02f, -2.71908224e-01f, -1.40510067e-01f, -1.30039960e-01f, -1.33066878e-01f, -1.48329839e-01f, -2.04569921e-01f, -2.20662832e-01f, -2.62812167e-01f, -2.53017724e-01f,
  -1.33716151e-01f, -9.87404212e-02f, -1.74479276e-01f, -9.75034386e-02f, -1.21485226e-01f, -8.32762569e-02f, -2.48518750e-01f, -2.49233902e-01f, -2.49252871e-01f, -1.56612307e-01f,
  -2.03550026e-01f, -2.93031812e-01f, -3.02441567e-01f, -1.77317247e-01f, -2.34339923e-01f, -1.54739633e-01f, -2.13723779e-01f, -2.52209336e-01f, -2.01922879e-01f, -2.89643794e-01f,
  -1.04258452e-02f, 1.10833041e-01f, 1.84866011e-01f, 1.37462407e-01f, 1.34050816e-01f, 1.86531708e-01f, 1.32082745e-01f, 9.11213234e-02f, 1.64292991e-01f, 1.24989785e-01f,
  2.32587114e-01f, 1.85151994e-01f, 1.30151466e-01f, 1.41763508e-01f, 1.93667829e-01f, 1.08042866e-01f, 5.22017181e-02f, 1.65864646e-01f, 1.45828322e-01f, 1.92215756e-01f,
  1.59422576e-01f, 1.59522697e-01f, 2.09123254e-01f, 1.61722749e-01f, 7.67444149e-02f, 1.40796766e-01f, 2.00887188e-01f, 1.74527809e-01f, 2.46063933e-01f, 1.96410388e-01f,
  -7.84264728e-02f, 1.41639113e-02f, -1.96674287e-01f, -1.57433271e-01f, -1.99216589e-01f, -9.45342630e-02f, -1.49172306e-01f, -1.73881546e-01f, -8.55125412e-02f, -1.21994585e-01f,
  -9.05672610e-02f, -1.23908110e-01f, -1.83697548e-02f, -1.34020299e-01f, -1.12649456e-01f, -2.11311817e-01f, -1.54985398e-01f, -2.64858752e-01f, -9.35011804e-02f, -8.27620327e-02f,
  -1.95893511e-01f, -3.41193825e-01f, -3.29557866e-01f, -1.95046514e-01f, -2.47956559e-01f, -2.58329272e-01f, -1.04901060e-01f, -2.38473356e-01f, -1.96825117e-01f, -2.18236387e-01f,
  -4.05998707e-01f, 1.82857826e-01f, 1.00118749e-01f, -1.61243081e-01f, 1.84820190e-01f, 1.62406534e-01f, 2.62410253e-01f, -7.49980509e-02f, -1.18743420e-01f, -9.31845829e-02f,
  -6.34612665e-02f, -1.14689961e-01f, -1.04444414e-01f, -1.30504832e-01f, 3.83115048e-03f, 2.02492908e-01f, 9.38093439e-02f, -1.10618196e-01f, -2.15100739e-02f, -1.02941610e-01f,
  -7.72524402e-02f, -2.00131044e-01f, -2.84683943e-01f, -1.49156004e-01f, -2.04238161e-01f, -1.58014819e-01f, 2.13333238e-02f, -1.31650688e-02f, 7.41380751e-02f, -3.95858847e-02f,
  -2.28936871e-04f, -1.94220454e-01f, -1.34055495e-01f, -1.84812412e-01f, 7.92661086e-02f, -1.52696878e-01f, -1.78194270e-02f, -1.02683440e-01f, -1.31611660e-01f, -1.27223581e-01f,
  -4.64591235e-02f, -2.50727534e-02f, -1.00310884e-01f, -9.64200571e-02f, -1.29163444e-01f, -2.68866513e-02f, -1.23769246e-01f, -1.03987530e-01f, -2.02994868e-02f, -1.08935378e-01f,
  2.05477104e-02f, 1.11801522e-02f, 5.17233647e-02f, 6.03551045e-02f, -6.99464604e-02f, -1.35643631e-01f, -9.48297456e-02f, -1.15125917e-01f, -1.39640355e-02f, -7.69169331e-02f,
  -5.87290339e-02f, -2.26407754e-03f, -3.75511907e-02f, -7.68994167e-02f, -1.25910491e-02f, 7.13608190e-02f, -1.61066279e-02f, 3.15898433e-02f, -4.94232439e-02f, 6.63383454e-02f,
  -3.52061167e-02f, 2.77441442e-02f, -8.65939781e-02f, -5.41416369e-02f, -5.31021766e-02f, -4.15890813e-02f, 1.88876595e-02f, -3.33975605e-03f, -2.76484323e-04f, 2.36719684e-03f,
  -1.14376523e-01f, -4.79287319e-02f, -1.86997410e-02f, 5.14423884e-02f, -7.81943277e-02f, -6.67603314e-02f, -3.77836195e-03f, -1.28991798e-01f, -3.92109752e-02f, -5.49377836e-02f,
  8.66669230e-03f, 2.08575636e-01f, -1.03139728e-01f, -9.20843631e-02f, -9.97322872e-02f, -7.31930211e-02f, -1.23377845e-01f, -1.11541957e-01f, -2.61436403e-02f, -1.17743485e-01f,
  -9.82385799e-02f, -1.47072583e-01f, -2.35157199e-02f, 2.15414278e-02f, -1.90459564e-02f, -5.35333492e-02f, -2.33970080e-02f, -1.06686294e-01f, -8.75785276e-02f, -1.80729069e-02f,
  4.18160968e-02f, -6.35189936e-02f, -2.59913206e-02f, 6.79913685e-02f, 2.51636077e-02f, -3.01686674e-02f, 8.87352694e-03f, -8.12820569e-02f, 4.08019610e-02f, -2.94591114e-02f,
  -2.67901402e-02f, 2.93657538e-02f, 1.09842964e-01f, 2.22362000e-02f, -1.73667371e-02f, -2.43612770e-02f, 8.95501003e-02f, 1.60833318e-02f, -6.05217516e-02f, 3.13184261e-02f,
  2.91672125e-02f, 7.54240016e-03f, -5.46455663e-03f, -6.73747435e-02f, 4.59307171e-02f, 2.93111634e-02f, 1.63382161e-02f, -4.08603698e-02f, -9.53526348e-02f, -8.61930251e-02f,
  -2.66693588e-02f, -6.68097809e-02f, -1.18524462e-01f, -7.47392178e-02f, -1.96951386e-02f, -3.73043567e-02f, -6.32835925e-02f, 5.05093262e-02f, -1.06364666e-02f, 1.31598383e-01f,
  1.57834291e-01f, -1.78973064e-01f, -2.30349138e-01f, -8.38327780e-02f, -7.89114684e-02f, -1.50793895e-01f, -1.74402475e-01f, -2.38748431e-01f, -2.31521413e-01f, -4.50531468e-02f,
  -6.88466728e-02f, -1.18235059e-01f, -1.88079238e-01f, -9.89077613e-02f, -1.38120547e-01f, -1.13496482e-01f, -4.08865660e-02f, -7.19021037e-02f, -7.49786422e-02f, -2.41695821e-01f,
  -2.06940964e-01f, -1.46705315e-01f, -2.91910350e-01f, -1.39946088e-01f, -1.08371243e-01f, -2.30963200e-01f, -2.19451636e-01f, -9.73819569e-02f, -1.70576081e-01f, -1.37676150e-01f,
  -6.04659738e-03f, 1.03200980e-01f, 1.15401171e-01f, 5.51092327e-02f, 1.92877278e-01f, 1.19040266e-01f, 1.45595893e-01f, 1.34925857e-01f, 1.62619233e-01f, 1.22021124e-01f,
  2.28112161e-01f, 2.00954080e-01f, 1.46818981e-01f, 2.61311412e-01f, 1.24663100e-01f, 1.00974150e-01f, 9.22434852e-02f, 9.00365710e-02f, 7.13048354e-02f, 1.91206589e-01f,
  2.38417327e-01f, 1.54527515e-01f, 1.25355482e-01f, 9.90456492e-02f, 1.19665377e-01f, 1.44571871e-01f, 1.05287120e-01f, 1.06497392e-01f, 1.20156810e-01f, 2.27131948e-01f,
  2.07075407e-03f, -2.44197130e-01f, 3.79791893e-02f, 3.95597704e-03f, -1.52246103e-01f, -1.26516268e-01f, -8.90736431e-02f, -1.22181609e-01f, -2.33412296e-01f, -5.33042289e-02f,
  -2.42676839e-01f, -1.46363676e-01f, -9.18699503e-02f, -1.22266337e-01f, -1.53928369e-01f, -7.15432018e-02f, -2.08020359e-01f, -1.53192729e-01f, -1.42351002e-01f, -1.96766391e-01f,
  -2.32281253e-01f, -1.96078986e-01f, -9.13223624e-02f, -1.06777258e-01f, -2.36641675e-01f, -7.78584927e-02f, -2.03224063e-01f, -1.50321975e-01f, -1.69530272e-01f, -1.21126823e-01f,
  3.17080766e-01f, 5.57966083e-02f, -4.62565832e-02f, -4.06791121e-02f, -1.60113767e-01f, -2.28683412e-01f, -2.46920273e-01f, -8.34339559e-02f, 3.03376280e-02f, -2.63930745e-02f,
  9.24079865e-03f, -3.74697968e-02f, 9.25429687e-02f, 3.61107811e-02f, 5.11716530e-02f, 3.51364501e-02f, 2.94181313e-02f, 1.67207062e-01f, -4.26442772e-02f, -2.00403526e-01f,
  -1.14970386e-01f, 8.13941434e-02f, 1.83355927e-01f, 6.82949414e-03f, -8.02797824e-03f, -1.19276762e-01f, 1.46168713e-02f, -1.51348084e-01f, -1.04585305e-01f, 3.74596864e-02f,
  9.14200172e-02f, 7.37359934e-03f, 1.80147658e-03f, 1.21114664e-01f, 9.84572843e-02f, 1.02169186e-01f, 9.56269205e-02f, 4.16543111e-02f, 1.11733064e-01f, 1.18346617e-01f,
  6.16282299e-02f, 5.30008180e-03f, 1.06338626e-02f, 4.18188013e-02f, -2.38458626e-02f, 1.33787775e-02f, 1.63217574e-01f, 1.78388566e-01f, 6.01161085e-02f, 8.28727409e-02f,
  -8.81879106e-02f, -1.23778030e-01f, -3.50710899e-02f, -6.45906553e-02f, -8.27906933e-03f, 2.53464710e-02f, -2.87803859e-02f, -5.78977391e-02f, -4.58661877e-02f, 2.00593725e-01f,
  4.08502407e-02f, 6.80153742e-02f, -7.01995119e-02f, 2.79966276e-02f, 2.96537038e-02f, -1.91894397e-02f, 7.31076896e-02f, 3.87359820e-02f, 9.16941371e-03f, 4.55988273e-02f,
  -2.93897763e-02f, 5.03691249e-02f, -5.28352670e-02f, -4.78216335e-02f, -4.46504317e-02f, 8.12409155e-04f, 5.27197355e-03f, 9.87405106e-02f, 4.31020930e-02f, -4.27522929e-03f,
  1.39306914e-02f, 4.60942015e-02f, 3.79643813e-02f, 6.73253760e-02f, -6.12458121e-03f, -3.61148827e-02f, -6.04067417e-03f, -6.39245808e-02f, -5.05136810e-02f, -8.46460611e-02f,
  2.19841287e-01f, -9.76948738e-02f, 6.26751930e-02f, 7.71762431e-02f, 7.16411276e-03f, -8.62528477e-03f, 4.93737161e-02f, 5.66721633e-02f, -8.88070762e-02f, 2.78925914e-02f,
  -6.96683303e-02f, -1.49014210e-02f, -1.38517926e-02f, -4.06474434e-02f, -9.09331720e-03f, -1.11469030e-01f, 2.51836944e-02f, -1.54493582e-02f, -2.87286658e-02f, -7.34089836e-02f,
  6.84669614e-02f, -2.99608465e-02f, 5.01484387e-02f, 6.83367401e-02f, 6.34718919e-03f, -7.03899935e-02f, 7.03799948e-02f, 1.13638593e-02f, 2.24119127e-02f, 1.70026988e-01f,
  -3.09737355e-01f, 1.49849489e-01f, 1.63892627e-01f, -1.12365253e-01f, -1.30034136e-02f, 3.23240310e-02f, 6.52925521e-02f, -1.29152447e-01f, -7.10324347e-02f, 3.99246290e-02f,
  -3.42063904e-02f, -4.68243584e-02f, -9.98612419e-02f, -5.67788817e-02f, -1.99139595e-01f, 1.33596389e-02f, 1.28616855e-01f, -8.53784680e-02f, -6.12641647e-02f, 3.30090034e-03f,
  7.93870315e-02f, 4.56205988e-03f, -1.06258944e-01f, 2.73709930e-02f, 1.70894206e-01f, 8.12887996e-02f, 1.23533674e-01f, 1.51271015e-01f, 3.55803780e-02f, 1.93801284e-01f,
  1.39448658e-01f, -5.88941947e-02f, -6.24633133e-02f, -2.42336243e-02f, 9.73719433e-02f, -1.04964323e-01f, -5.02528399e-02f, -5.14534153e-02f, -2.01947205e-02f, 5.63836209e-02f,
  -3.24906334e-02f, -8.14022273e-02f, -3.31980712e-03f, -4.11100350e-02f, -5.97424842e-02f, -1.64576173e-02f, -7.49319345e-02f, -2.34257337e-02f, -1.85349956e-01f, -4.90942923e-03f,
  1.44775435e-01f, 1.11607999e-01f, -6.80432515e-03f, -1.49016768e-01f, -1.49696022e-01f, -9.37265437e-03f, -2.62793172e-02f, -9.16708931e-02f, -1.64280683e-01f, -2.46928353e-03f,
  8.08266848e-02f, 9.25930366e-02f, 6.06522895e-02f, 3.47597562e-02f, 3.36121097e-02f, 6.53210357e-02f, 3.54027338e-02f, 7.67006129e-02f, 1.16258319e-02f, 9.59663391e-02f,
  4.86677065e-02f, 8.00685883e-02f, 8.92278701e-02f, 6.26719370e-02f, 1.02040336e-01f, 6.60229474e-02f, 1.59615800e-01f, 3.46645303e-02f, 3.77345718e-02f, 5.27746566e-02f,
  5.29376976e-02f, 5.52447811e-02f, 1.24347486e-01f, 1.93526205e-02f, -1.07385041e-02f, 9.91077051e-02f, 5.09120859e-02f, 8.41341987e-02f, 5.44472188e-02f, 1.25768900e-01f,
  -1.07146904e-01f, -1.79834366e-01f, -2.23059636e-02f, -3.05284820e-02f, -7.31938407e-02f, 2.23045163e-02f, 7.58977653e-03f, 1.33343618e-02f, -2.13699918e-02f, -9.62131657e-03f,
  9.53049492e-03f, -5.34275696e-02f, -4.86514792e-02f, 2.89996881e-02f, -9.20848846e-02f, -1.33333087e-01f, -6.61936328e-02f, -3.76516879e-02f, -8.64708200e-02f, -5.71555756e-02f,
  3.58578824e-02f, -7.20232278e-02f, -1.51395380e-01f, -8.08331277e-03f, -1.53767183e-01f, -6.10342845e-02f, 4.32566032e-02f, -6.58479379e-03f, -1.91567808e-01f, -7.55361095e-02f,
  2.29845256e-01f, 4.34872746e-01f, 1.83711559e-01f, -1.46567538e-01f, -3.56927961e-02f, 2.54869461e-01f, 3.95507276e-01f, 2.30972305e-01f, -1.47091776e-01f, 1.60506323e-01f,
  7.69954547e-03f, -2.17760399e-01f, -1.27683744e-01f, 6.26757799e-04f, 1.57781348e-01f, 1.46921024e-01f, 2.70284689e-03f, -7.18719885e-02f, -6.94658831e-02f, 7.77142569e-02f,
  -6.49616271e-02f, -1.78354263e-01f, -2.25911867e-02f, -6.04079328e-02f, -8.40483047e-03f, -8.48592147e-02f, 7.37593696e-02f, 6.64474666e-02f, 1.61955789e-01f, -8.81309733e-02f,
  -9.03100222e-02f, 2.67418563e-01f, -2.69364733e-02f, -1.72851309e-01f, -5.57458028e-03f, 5.79430070e-03f, 5.09812944e-02f, -1.33170672e-02f, 6.32891878e-02f, 1.20581172e-01f,
  -2.77272835e-02f, 6.75068200e-02f, -6.49179667e-02f, 1.58306712e-03f, 1.97267439e-02f, 6.75703660e-02f, 1.12198390e-01f, 2.73535610e-03f, 9.01635289e-02f, 1.56875059e-01f,
  -8.90104994e-02f, 8.82538781e-03f, 1.67014286e-01f, 1.20647728e-01f, 1.71110958e-01f, 1.54587030e-02f, 7.13919625e-02f, 2.02958018e-01f, 2.07019150e-01f, 9.41775665e-02f,
  -4.01675403e-02f, 1.82468910e-02f, 4.97298650e-02f, -1.99969206e-02f, 1.28639687e-03f, 4.02751900e-02f, -5.17627746e-02f, -4.74971719e-02f, -2.44356617e-02f, -3.84658687e-02f,
  -3.18023264e-02f, -2.22524907e-02f, -7.94640556e-03f, 3.09805181e-02f, 3.29734348e-02f, 1.33013591e-01f, 1.49489045e-02f, 2.78268307e-02f, 1.21137034e-02f, 6.41070083e-02f,
  -4.64273393e-02f, -1.67720823e-03f, -4.23017442e-02f, 6.50698468e-02f, 3.45845781e-02f, 1.10793658e-01f, 8.09589773e-02f, -2.03932673e-02f, 7.23111704e-02f, 1.23889223e-01f,
  -2.74724662e-01f, 6.82443231e-02f, 1.77334268e-02f, -1.91573370e-02f, -6.20537139e-02f, 4.61067483e-02f, 2.05703769e-02f, -1.36957057e-02f, -1.94235612e-02f, -1.45117044e-02f,
  3.84996273e-02f, 1.64490677e-02f, -3.86932045e-02f, 6.58937618e-02f, -3.63070741e-02f, 2.72850282e-02f, 2.89825797e-02f, 3.33121419e-02f, 3.37631330e-02f, 2.74427943e-02f,
  -3.10098249e-02f, 5.24194203e-02f, 1.90151501e-02f, -2.83467602e-02f, 4.47790064e-02f, -2.00469382e-02f, 2.81334594e-02f, 5.09421341e-02f, 6.28181174e-02f, 7.60537013e-02f,
  -9.10790265e-02f, -1.70553595e-01f, -1.49650350e-01f, -1.63923606e-01f, -1.50101542e-01f, -7.58916289e-02f, -1.89123511e-01f, 3.86321619e-02f, -3.63986902e-02f, -1.60097122e-01f,
  -6.51751980e-02f, 2.28048488e-03f, -5.57025298e-02f, 5.22257760e-02f, 3.33751552e-02f, -1.50970787e-01f, -1.30810425e-01f, -5.08170463e-02f, 1.27334774e-01f, -1.85398608e-02f,
  -4.13670503e-02f, 3.64607051e-02f, 1.71947107e-01f, 1.98514666e-02f, -7.38740414e-02f, -8.93825293e-02f, -3.75475809e-02f, -1.57631665e-01f, -1.24408372e-01f, -2.11183205e-01f,
  -2.20298618e-01f, 2.98087820e-02f, 1.94804817e-01f, 1.15346961e-01f, 1.16813302e-01f, 1.09530762e-01f, 1.04574136e-01f, 1.90003410e-01f, 1.46072134e-01f, 2.03572889e-03f,
  1.15326211e-01f, 8.44506770e-02f, 1.68908283e-01f, 9.84666795e-02f, 1.02422707e-01f, 1.19093070e-02f, 2.16344386e-01f, 9.49414670e-02f, 2.17996668e-02f, 1.07225172e-01f,
  7.33295307e-02f, -1.15000764e-02f, 6.18852116e-02f, 1.20702252e-01f, 3.55736129e-02f, 8.71384665e-02f, 6.14665728e-03f, 5.51009271e-03f, 1.01356067e-01f, -8.01015645e-02f,
  -3.05155553e-02f, -7.13459104e-02f, -1.57974418e-02f, -8.83972049e-02f, 2.33733915e-02f, -4.34734970e-02f, -5.78179173e-02f, -2.13834364e-02f, -5.11699840e-02f, 4.19644304e-02f,
  -4.44201455e-02f, -1.00659356e-01f, -5.32123595e-02f, -1.99989025e-02f, -1.59190353e-02f, -7.05433637e-02f, -7.69123377e-04f, -4.48543727e-02f, -3.36795449e-02f, 4.51816665e-03f,
  -6.88191950e-02f, -4.62800339e-02f, -9.75419506e-02f, -5.11544049e-02f, -8.70347098e-02f, -2.29992811e-02f, -5.11164591e-02f, -6.28644973e-02f, 1.79635622e-02f, 3.82812298e-03f,
  1.17107511e-01f, 2.78278142e-01f, 2.39838548e-02f, 6.56045824e-02f, 9.70156491e-02f, 1.15469761e-01f, -1.82371177e-02f, 1.07477471e-01f, 9.82459188e-02f, -8.94587580e-03f,
  6.89368472e-02f, 1.62829891e-01f, 7.37472251e-02f, 7.07074925e-02f, 5.93398362e-02f, 1.21189401e-01f, 9.95514095e-02f, 4.79245521e-02f, 5.50445504e-02f, 5.06211966e-02f,
  7.44252354e-02f, 6.11658394e-02f, 3.68743725e-02f, 7.91177079e-02f, 9.75998193e-02f, 1.58359542e-01f, 1.33740366e-01f, 1.53902858e-01f, 1.35955542e-01f, 5.12584858e-02f,
  -2.98856467e-01f, 6.12518229e-02f, 1.93192244e-01f, 1.18698001e-01f, 3.54336888e-01f, 3.50107342e-01f, 3.59852254e-01f, 3.75718474e-02f, 8.68451223e-02f, 7.93348327e-02f,
  1.61395460e-01f, 1.81818176e-02f, 7.58947209e-02f, 6.49721920e-02f, -9.22203213e-02f, 2.28021294e-01f, 1.60066411e-01f, -2.61791628e-02f, -3.85792963e-02f, 8.05302262e-02f,
  1.04290031e-01f, 7.09385499e-02f, -1.79768786e-01f, -9.66889784e-02f, -3.41454940e-03f, 8.56600329e-02f, 1.15136035e-01f, 4.54734750e-02f, 1.15997531e-01f, 4.32762019e-02f,
  1.02472477e-01f, -1.03938319e-01f, 1.05214708e-01f, -2.40734722e-02f, 5.47503382e-02f, -4.66017909e-02f, 8.38662311e-02f, 1.46344230e-02f, 9.64708219e-04f, 1.44811189e-02f,
  9.72243100e-02f, -5.22590615e-02f, 8.63618404e-02f, 7.19600730e-03f, -5.92365563e-02f, 2.11510807e-02f, -3.85343023e-02f, -1.06658384e-01f, -5.72702102e-02f, -8.04949030e-02f,
  1.05429001e-01f, 1.32935256e-01f, 5.61154932e-02f, 7.69974366e-02f, 3.43434811e-02f, 4.93154209e-03f, 9.57024246e-02f, -1.21480506e-02f, 3.45293805e-02f, 1.06331572e-01f,
  -5.19598648e-02f, -6.15925863e-02f, -1.14551634e-01f, -4.66431752e-02f, 1.19143324e-02f, -1.99566036e-02f, -4.12205840e-03f, 3.91165502e-02f, -5.31876571e-02f, -4.44415174e-02f,
  -2.60096192e-02f, -1.01242617e-01f, -7.17224479e-02f, -3.08779422e-02f, -2.92541143e-02f, -6.21410310e-02f, -3.04979142e-02f, -1.80581119e-02f, -4.28197049e-02f, -1.25304043e-01f,
  -1.15164615e-01f, 9.94775444e-03f, -6.67781085e-02f, -1.91843569e-01f, -9.36310291e-02f, -1.70639604e-02f, -9.33032855e-02f, -9.28858742e-02f, -1.91589128e-02f, -5.42547591e-02f,
  5.87480254e-02f, 7.33424574e-02f, 6.40899613e-02f, -7.41668418e-02f, 9.54651684e-02f, 9.16369855e-02f, 4.21376573e-03f, -4.23744395e-02f, -2.64140381e-03f, 1.18149422e-01f,
  1.15979640e-02f, -3.91728133e-02f, -1.07823536e-02f, 7.10821599e-02f, 1.45639226e-01f, 5.62112778e-02f, 8.46123099e-02f, 1.16080917e-01f, 9.51715931e-02f, 9.33079273e-02f,
  1.23485886e-01f, 2.09776491e-01f, 3.03572059e-01f, 1.34054169e-01f, 1.55001462e-01f, 1.84755623e-01f, 1.48889080e-01f, 1.22277051e-01f, 1.95333466e-01f, 1.94455102e-01f,
  4.52898711e-01f, -2.00546011e-01f, -5.68269007e-03f, 7.31293438e-03f, -1.33974142e-02f, -5.48564121e-02f, -7.83937126e-02f, 4.41098660e-02f, -7.68982247e-02f, -1.81634024e-01f,
  -1.23921685e-01f, -5.16016083e-03f, -3.67207155e-02f, 8.99823233e-02f, 2.11912662e-01f, -1.04482092e-01f, -9.12005678e-02f, 2.76626557e-01f, 3.58481199e-01f, 2.72101671e-01f,
  5.54548576e-02f, 1.04768135e-01f, 1.53546885e-01f, 3.78890634e-02f, -6.66723102e-02f, -2.01559216e-02f, -1.00490198e-01f, -1.02919322e-02f, -1.04893334e-01f, -2.19567418e-01f,
  -2.58948021e-02f, 2.11036861e-01f, 2.18704626e-01f, 1.31543770e-01f, 7.49707296e-02f, 1.78945407e-01f, 1.26841769e-01f, 8.47114250e-02f, 3.38956937e-02f, -2.28480762e-03f,
  -3.87286022e-02f, 1.66336402e-01f, 1.10766374e-01f, 5.29885329e-02f, 1.45091802e-01f, 2.22455394e-02f, 7.39824697e-02f, 1.37887999e-01f, 1.49625823e-01f, 2.58641597e-02f,
  -1.14224128e-01f, 1.02374084e-01f, 1.54404551e-01f, -4.24321480e-02f, -1.41160376e-03f, 1.91245630e-01f, 9.03264061e-02f, 1.24049932e-01f, 2.62745488e-02f, -3.00771720e-03f,
  9.11062509e-02f, -5.42857684e-02f, -7.54046515e-02f, -1.02024741e-01f, -7.59098679e-02f, -9.52686444e-02f, -6.40997216e-02f, -1.09325007e-01f, -7.14750364e-02f, -3.51750776e-02f,
  3.12003714e-04f, -7.66014159e-02f, -2.58009769e-02f, -8.69181603e-02f, -6.32369816e-02f, -1.53520003e-01f, -2.62019224e-03f, -1.40729174e-01f, -1.30968556e-01f, -1.72510054e-02f,
  -5.85496239e-02f, -8.42337981e-02f, -1.61101192e-01f, -3.13223898e-02f, -6.43766671e-02f, -2.60885917e-02f, -5.64932935e-02f, -2.66238358e-02f, 9.88489203e-03f, -9.88781899e-02f,
  -6.04574643e-02f, 1.67938054e-01f, 5.46876937e-02f, 1.58282518e-01f, 1.03250951e-01f, 8.85022134e-02f, -1.21068209e-02f, 5.42345606e-02f, 3.25056575e-02f, 1.83581281e-02f,
  8.26542825e-02f, 3.08089349e-02f, -4.96720113e-02f, 1.15427218e-01f, 5.91055788e-02f, 9.31160599e-02f, -8.78399536e-02f, -1.03471382e-02f, -4.58092801e-02f, 8.43753666e-02f,
  -3.79599035e-02f, 8.88581350e-02f, 5.80102652e-02f, 1.03161559e-01f, -2.43030805e-02f, 1.15118615e-01f, 7.00434074e-02f, 5.80191426e-02f, 8.49392563e-02f, 4.78212386e-02f,
  2.30617020e-02f, -9.94710103e-02f, -2.54127443e-01f, -8.66133422e-02f, -2.43443400e-01f, -2.09814325e-01f, -2.05382720e-01f, -1.54522985e-01f, 2.30125673e-02f, -1.97434127e-02f,
  -1.30142227e-01f, -8.36407915e-02f, -8.58874545e-02f, -8.08113739e-02f, -2.07701474e-01f, -1.31802410e-01f, -3.34340781e-01f, -2.50529885e-01f, -1.52809188e-01f, -2.17044309e-01f,
  -2.39999160e-01f, -2.73942202e-01f, -1.68123141e-01f, -2.91297823e-01f, -1.84834287e-01f, -1.59540474e-01f, -2.30577096e-01f, -3.11386526e-01f, -2.78175205e-01f, -1.93980202e-01f,
  1.07745141e-01f, -8.59660804e-02f, -2.12896556e-01f, -1.12895057e-01f, -1.69475481e-01f, -1.20440669e-01f, -1.77005202e-01f, -9.85200331e-02f, -7.68475309e-02f, -1.25507697e-01f,
  -1.52905032e-01f, -6.23061694e-02f, -6.17412105e-02f, -1.71165466e-01f, -1.19014956e-01f, -1.87151656e-01f, -2.41431773e-01f, -2.40489870e-01f, -1.69023067e-01f, -1.68254927e-01f,
  -1.06625400e-01f, -2.18753964e-01f, -2.70595551e-01f, -1.87528864e-01f, -1.77977681e-01f, -1.88911349e-01f, -2.18106195e-01f, -7.85086155e-02f, -7.77550414e-02f, -1.34518921e-01f,
  -1.29718948e-02f, 6.62525818e-02f, 1.68314144e-01f, 6.73969015e-02f, 1.14861779e-01f, 5.19130602e-02f, 6.71774074e-02f, 1.57617182e-02f, 2.02571601e-02f, 1.37127861e-01f,
  1.34248182e-01f, 1.19029634e-01f, 4.35297154e-02f, 5.37342206e-02f, 1.40023187e-01f, -3.66847068e-02f, 1.13781773e-01f, 1.21278139e-02f, 1.04833432e-01f, 1.00458950e-01f,
  1.43648028e-01f, 1.36373848e-01f, 2.26710457e-02f, 1.40710786e-01f, 6.00244366e-02f, 2.20395625e-02f, 1.07580177e-01f, 1.32568747e-01f, 1.72179863e-01f, 1.51504174e-01f,
  1.37083363e-02f, -2.91654199e-01f, 4.67354152e-03f, -5.20605519e-02f, -6.33830130e-02f, -5.18972017e-02f, -1.02970056e-01f, -1.87670082e-01f, -1.92358851e-01f, -8.16118643e-02f,
  -1.36149749e-01f, -1.60298079e-01f, -1.40571535e-01f, -8.58562365e-02f, -1.80732444e-01f, -1.82138905e-01f, -1.97794646e-01f, -1.84170216e-01f, -9.73807424e-02f, -6.49511814e-02f,
  -1.77410722e-01f, -2.12401375e-01f, -9.74800810e-02f, -1.49633124e-01f, -1.99899167e-01f, -5.63800968e-02f, -1.72110990e-01f, -3.83412167e-02f, -5.37168570e-02f, -3.15969139e-02f,
  3.38559210e-01f, 2.88325753e-02f, 2.45294683e-02f, 1.98671564e-01f, 6.54641539e-02f, -5.41298324e-03f, 6.73275739e-02f, 1.53762951e-01f, 1.16281584e-01f, 5.50182424e-02f,
  5.93004040e-02f, 6.81321323e-02f, 1.27702177e-01f, 2.21329927e-02f, 1.03437364e-01f, 4.45135683e-02f, 1.82014674e-01f, 1.83830753e-01f, -6.61780220e-03f, 3.69394310e-02f,
  -5.64721748e-02f, 1.04826212e-01f, 1.08356245e-01f, 2.50127781e-02f, 1.15798786e-01f, 1.00104593e-01f, 6.71761632e-02f, 9.03012231e-02f, 5.27546518e-02f, 8.33627731e-02f,
  -4.75613289e-02f, 1.97073221e-01f, 9.10081938e-02f, 6.88093528e-02f, -6.82508871e-02f, 1.38594568e-01f, 1.25461638e-01f, 4.70768958e-02f, 8.30031931e-02f, 8.42196792e-02f,
  -2.36462131e-02f, 1.24561705e-03f, 1.12473063e-01f, 4.28073928e-02f, 7.54773691e-02f, 1.44393697e-01f, 9.80129912e-02f, 2.22373456e-01f, 9.59829018e-02f, 8.73976797e-02f,
  7.21781654e-03f, 6.87456653e-02f, 5.88954315e-02f, 8.92569423e-02f, 8.07245001e-02f, 3.29823196e-02f, 8.71658549e-02f, 9.93095338e-02f, 1.23703912e-01f, 2.96636056e-02f,
  -1.63276047e-01f, -3.21310014e-02f, 2.71962807e-02f, 1.09618772e-02f, 1.31114013e-02f, 6.13902919e-02f, 1.08732931e-01f, -1.16503146e-02f, 3.01135369e-02f, 4.08289321e-02f,
  1.13349251e-01f, 4.71164025e-02f, 5.95259853e-02f, 4.84069586e-02f, 3.90207581e-02f, -1.07038105e-02f, 1.45063903e-02f, 3.41194645e-02f, 1.15165956e-01f, 3.77550684e-02f,
  3.86031084e-02f, 4.35984172e-02f, 7.45383650e-02f, 3.13225464e-04f, -3.19922268e-02f, -5.15029952e-02f, -3.64003256e-02f, -3.65045145e-02f, 3.95945348e-02f, 1.21502064e-01f,
  5.18629216e-02f, -2.81385705e-02f, 5.07481769e-02f, 1.07153162e-01f, -8.53269640e-03f, 1.06770486e-01f, 1.86801404e-02f, 9.48458165e-02f, -3.85670201e-03f, 6.85868934e-02f,
  6.02868833e-02f, -5.39964102e-02f, -2.49773990e-02f, 1.02492750e-01f, 6.27740324e-02f, 8.47802404e-03f, 1.23310141e-01f, 5.93455397e-02f, 4.44862582e-02f, 1.71232536e-01f,
  1.07208781e-01f, 4.42470610e-02f, 1.41063586e-01f, 7.54103512e-02f, 1.52878195e-01f, 9.89881903e-02f, 1.68830175e-02f, 1.25017911e-01f, 1.54926494e-01f, 9.21999663e-02f,
  2.44613796e-01f, 1.44030243e-01f, 1.21799052e-01f, 1.16242863e-01f, 3.80157344e-02f, 5.07579297e-02f, 1.17515266e-01f, -4.68277633e-02f, 3.12671699e-02f, 1.24076627e-01f,
  1.99819077e-02f, -1.37639210e-01f, -9.32474211e-02f, -1.39162183e-01f, -1.50413916e-01f, -1.78753287e-02f, -9.61831771e-03f, -9.36654657e-02f, 3.29017490e-02f, 2.44913157e-02f,
  7.42637441e-02f, 1.28097028e-01f, 8.72230530e-02f, -9.49176122e-03f, 2.24064484e-01f, 1.07866377e-01f, 6.60157353e-02f, 1.99349433e-01f, 1.64369285e-01f, 2.65240043e-01f,
  2.09340513e-01f, 1.17540270e-01f, -9.42405909e-02f, -2.69976910e-02f, -4.54640165e-02f, 8.14108849e-02f, 9.63623971e-02f, 1.55063411e-02f, 5.73492795e-02f, 1.00557841e-01f,
  1.04816727e-01f, 7.67125981e-04f, 8.03948864e-02f, 1.05514646e-01f, -6.04043622e-03f, 5.73535562e-02f, 9.85267535e-02f, 9.80094150e-02f, -7.49636739e-02f, 7.24636465e-02f,
  4.78414670e-02f, 1.15466133e-01f, 1.24641925e-01f, 7.60313198e-02f, 2.00283229e-02f, 3.55417877e-02f, 1.38176829e-01f, 1.51905820e-01f, 1.63444385e-01f, 1.30561605e-01f,
  -3.83220427e-02f, 1.13828637e-01f, 3.47394459e-02f, 1.73908472e-01f, 1.40629783e-01f, 1.57407403e-01f, 7.35500902e-02f, 1.08266823e-01f, -1.46094440e-02f, 1.32711977e-01f,
  5.89481629e-02f, 1.19788788e-01f, 1.06691204e-01f, 5.73009886e-02f, 1.13488384e-01f, 2.14148805e-01f, 1.45482689e-01f, 1.57986358e-01f, 1.18397355e-01f, 1.22799046e-01f,
  1.47707403e-01f, 1.52258024e-01f, 1.52653307e-01f, 9.95177776e-03f, 8.14833194e-02f, 9.94577780e-02f, 5.66957854e-02f, 1.70064226e-01f, 1.29780114e-01f, 1.05222464e-01f,
  -4.01218161e-02f, -7.71997795e-02f, 1.47353128e-01f, 2.39554923e-02f, 5.66242300e-02f, 3.14890631e-02f, -4.14481945e-03f, 9.55221131e-02f, -5.45943249e-03f, 6.17708974e-02f,
  2.62306840e-03f, -4.59753704e-04f, -8.45889095e-03f, -5.72324209e-02f, 1.16620377e-01f, -3.02547570e-02f, -3.00710611e-02f, 2.69039511e-03f, -3.56545225e-02f, 1.23823121e-01f,
  1.27866846e-02f, 1.43608510e-01f, 9.08650905e-02f, -2.34899353e-02f, 1.20596044e-01f, -5.23707978e-02f, 1.16786353e-01f, 6.21443540e-02f, 6.22660704e-02f, 1.22627638e-01f,
  -4.74383146e-01f, -1.58037782e-01f, -1.25734940e-01f, -2.19505490e-03f, 1.28048897e-01f, -1.02728605e-01f, -2.02556461e-01f, -1.62965059e-01f, -5.10802418e-02f, -1.42424271e-01f,
  -2.83587649e-02f, 2.17514243e-02f, -8.95443559e-02f, -4.44168597e-02f, -2.32747301e-01f, -4.57899086e-02f, -5.47576100e-02f, -1.91569477e-01f, -2.64359683e-01f, -1.77851424e-01f,
  -2.47395807e-03f, -1.89121470e-01f, -2.61264205e-01f, -1.92229360e-01f, 8.60249903e-03f, 6.70207962e-02f, -5.73306680e-02f, -7.45917484e-02f, 5.65752275e-02f, 1.36310691e-02f,
  -1.58359796e-01f, -1.57994583e-01f, -3.89028601e-02f, -4.00099345e-02f, -6.71554729e-02f, -7.63273239e-02f, -4.87846658e-02f, -1.37327984e-01f, -1.00251600e-01f, -1.24576584e-01f,
  -8.13473687e-02f, -1.02051608e-01f, -9.26135331e-02f, -1.39666095e-01f, -1.23776764e-01f, -4.13607173e-02f, -6.83067068e-02f, -6.16290383e-02f, -1.02777801e-01f, -1.35285020e-01f,
  1.09149255e-01f, -6.56528026e-02f, -1.16952807e-01f, -5.81368729e-02f, -4.31129299e-02f, -2.77624335e-02f, -2.78286710e-02f, -4.57566082e-02f, -9.10239518e-02f, -1.24598585e-01f,
  -2.13979799e-02f, 5.35464361e-02f, -9.89782158e-03f, 2.20110696e-02f, -8.01887959e-02f, 4.20188457e-02f, 3.24270688e-02f, 5.05111516e-02f, -4.19367664e-02f, 8.04044232e-02f,
  -4.26967256e-02f, -7.99710974e-02f, 3.37967612e-02f, 1.55822383e-02f, -4.61162515e-02f, -1.01795182e-01f, 2.94249617e-02f, -3.57034542e-02f, 4.26085293e-02f, -2.40568258e-02f,
  -3.81437317e-02f, 1.98958907e-02f, 4.76935655e-02f, 2.50886697e-02f, 7.69909844e-02f, 4.26570624e-02f, -1.86816212e-02f, -1.81477163e-02f, -1.81195978e-02f, 2.12926548e-02f,
  -1.17075391e-01f, -6.72279224e-02f, -6.46372885e-02f, -1.44606993e-01f, -2.48700734e-02f, -2.17861645e-02f, -3.15068811e-02f, -8.32255557e-02f, 2.12373342e-02f, -1.02109753e-01f,
  -6.46957979e-02f, -8.74056146e-02f, -8.32238048e-02f, -9.73499715e-02f, -4.82473709e-02f, -1.13194525e-01f, -1.26688361e-01f, -8.11674893e-02f, -7.31159076e-02f, -1.08198039e-01f,
  -7.22465441e-02f, -2.75547095e-02f, -2.40031585e-01f, -1.65321957e-02f, -4.11062799e-02f, -5.66088855e-02f, -1.91684231e-01f, -1.49615422e-01f, -2.37656787e-01f, -2.12212875e-01f,
  8.46627504e-02f, -9.97438431e-02f, -2.45594531e-01f, 2.23169580e-01f, 7.41709843e-02f, -1.83650258e-03f, -1.92335486e-01f, 1.34101510e-01f, 3.69452178e-01f, 5.19518480e-02f,
  1.24237649e-01f, 2.91260958e-01f, 3.02245438e-01f, 2.47001052e-01f, -4.91761044e-02f, 5.40629923e-02f, 1.99612100e-02f, 4.66556586e-02f, -5.56329079e-03f, 1.54390708e-01f,
  8.53272453e-02f, 3.33595276e-02f, 7.78387189e-02f, 1.33204967e-01f, 2.67058372e-01f, 3.06502879e-01f, 5.94297461e-02f, 1.15792610e-01f, -7.91677162e-02f, 1.40417293e-01f,
  2.32927743e-02f, 9.83209312e-02f, 2.38723725e-01f, 2.57235497e-01f, 1.96183532e-01f, 1.93482265e-01f, 1.68045685e-01f, 1.92815363e-01f, 2.29815289e-01f, 1.04931943e-01f,
  1.15356945e-01f, 1.72523007e-01f, 9.70251784e-02f, 1.91021904e-01f, 6.40085489e-02f, 1.65158227e-01f, 1.93645865e-01f, 2.06931680e-01f, 1.85100853e-01f, 5.79634272e-02f,
  1.99735776e-01f, 5.14728427e-02f, 1.19841233e-01f, 5.26872985e-02f, 9.68466327e-02f, 1.41775250e-01f, 6.95833787e-02f, 1.34581923e-01f, 2.90882792e-02f, 1.08753674e-01f,
  -6.23377599e-02f, -5.99357784e-02f, -1.59167022e-01f, -2.44333372e-01f, -9.35364366e-02f, -2.26696823e-02f, -3.17594409e-02f, -4.88213897e-02f, -1.20721504e-01f, -1.39824077e-01f,
  -1.37281716e-01f, -8.65072161e-02f, -5.83309121e-02f, -1.18098587e-01f, -1.52611300e-01f, -1.12047672e-01f, -5.29293008e-02f, -1.25951394e-01f, -1.25385433e-01f, -9.33040008e-02f,
  -1.33052140e-01f, -1.75488085e-01f, -1.49112791e-01f, -5.62403873e-02f, -2.26010486e-01f, -1.73351064e-01f, -3.65836993e-02f, -1.74549684e-01f, -1.05432793e-01f, -1.28453687e-01f,
  3.05096358e-01f, -2.66280305e-02f, 2.45882303e-01f, 2.02597633e-01f, 1.97960109e-01f, 1.64023891e-01f, 1.51051685e-01f, 1.76667020e-01f, 1.79507926e-01f, 1.02151409e-01f,
  1.76209822e-01f, 1.42477751e-01f, 1.66001335e-01f, 1.38790041e-01f, 1.58654273e-01f, 1.21872567e-01f, 4.64319624e-02f, 2.11327747e-01f, 1.78814113e-01f, 1.45492449e-01f,
  1.01230912e-01f, 4.83427159e-02f, 1.24605767e-01f, 2.43844673e-01f, 1.80921346e-01f, 1.79020256e-01f, 7.36151040e-02f, 2.54152000e-01f, 1.18638046e-01f, 8.96369740e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.07509768e-01f, -1.76026687e-01f, 1.57564789e-01f, -3.22946548e-01f, -3.32718939e-01f, 8.01828783e-03f, -2.64138997e-01f, -3.28220189e-01f, -4.22154963e-01f, -1.95945755e-01f,
  -9.90293548e-02f, -8.19556862e-02f, -1.41408131e-01f, -3.89510244e-02f, -7.24872947e-02f, -2.75179863e-01f, -2.20421448e-01f, -7.18938187e-02f, -4.48425524e-02f, -2.29819849e-01f,
  -2.75581867e-01f, -3.36662978e-01f, -1.39197037e-01f, -2.19911322e-01f, -2.17120916e-01f, -1.81919172e-01f, 9.21812747e-03f, -1.86329558e-01f, 7.24969944e-03f, -2.39929348e-01f,
  2.49703765e-01f, 3.60837504e-02f, -2.24685259e-02f, 1.91623531e-02f, 1.22080639e-01f, 1.07196689e-01f, 1.07869849e-01f, 6.75810128e-02f, 3.00253052e-02f, -1.93705317e-02f,
  2.90650688e-02f, 3.36751863e-02f, 1.64250001e-01f, 1.26182243e-01f, 3.16189229e-02f, 6.15924858e-02f, 5.21337353e-02f, -7.08994493e-02f, 1.36514291e-01f, 1.40966177e-01f,
  2.21053779e-01f, 1.69847891e-01f, 2.14016393e-01f, 2.95148373e-01f, 2.89547771e-01f, 1.31026655e-01f, 1.18608095e-01f, 2.27024183e-01f, 2.27373272e-01f, 1.40706763e-01f,
  1.26835749e-01f, -7.26744309e-02f, 1.65319487e-01f, 1.07086584e-01f, 3.88210043e-02f, -3.46766300e-02f, -9.99412462e-02f, -5.96300960e-02f, 4.30844054e-02f, -3.29561681e-02f,
  -1.13865443e-01f, 8.41659158e-02f, 5.77896088e-02f, -8.69105384e-02f, 6.85680367e-04f, -4.57881652e-02f, -5.03533185e-02f, 1.68819159e-01f, 1.94644794e-01f, 3.11144441e-02f,
  9.05349776e-02f, -9.29540172e-02f, -1.13343380e-01f, 5.79537190e-02f, 8.10509324e-02f, -4.79896367e-02f, 3.79590578e-02f, 2.56084621e-01f, 1.31130256e-02f, -1.09989010e-01f,
  -1.37545634e-02f, 3.92317772e-01f, -2.04226077e-01f, -1.92922220e-01f, -2.67654452e-02f, 3.90470251e-02f, 7.30233965e-04f, -2.55608018e-02f, -1.72361389e-01f, -2.99161319e-02f,
  4.14779820e-02f, -1.23154059e-01f, -6.67489544e-02f, -2.33875308e-02f, -2.09563263e-02f, 5.00227772e-02f, 2.67999079e-02f, -1.65667802e-01f, 3.90091091e-02f, 2.77149249e-02f,
  -1.03358449e-02f, -5.30720241e-02f, 3.22609395e-02f, 1.13101983e-02f, 1.10442773e-01f, 6.55467212e-02f, 4.73793112e-02f, 4.36045043e-03f, 1.00497842e-01f, -4.55339476e-02f,
  -6.16808176e-01f, 3.65444452e-01f, -3.75342667e-01f, -3.13302100e-01f, -4.40908670e-02f, 1.39898628e-01f, 4.14388835e-01f, 2.87783563e-01f, 4.68948595e-02f, 1.58445284e-01f,
  -7.20233396e-02f, -1.30817503e-01f, 3.29649150e-02f, 3.99438515e-02f, 1.92644432e-01f, 4.11220610e-01f, 2.94229180e-01f, -3.73546749e-01f, -4.95130599e-01f, -1.75589964e-01f,
  1.81344628e-01f, -2.37500235e-01f, -3.87889385e-01f, -1.17299356e-01f, 5.89858033e-02f, -6.38218150e-02f, 7.00728074e-02f, -2.03774691e-01f, 1.01045221e-01f, 4.81257439e-02f,
  -2.11677775e-01f, -3.22971553e-01f, -3.86636220e-02f, -1.02204762e-01f, -1.70466840e-01f, -4.75038327e-02f, -9.78477746e-02f, -2.14988083e-01f, -5.42588979e-02f, -7.02295899e-02f,
  -2.49428213e-01f, -1.19507104e-01f, -1.21534005e-01f, 7.84586370e-02f, -8.37083012e-02f, -2.03120932e-02f, -1.63564831e-02f, -7.59947300e-02f, 4.95002493e-02f, 1.11764483e-01f,
  2.24285036e-01f, -1.16691358e-01f, -1.45756990e-01f, 1.24318972e-01f, 9.92912725e-02f, -1.37501433e-01f, 3.04502575e-03f, -5.48932143e-02f, -1.85555696e-01f, -1.76967569e-02f,
  1.69741467e-01f, 9.93794650e-02f, -8.19918439e-02f, -1.15797192e-01f, 4.01481576e-02f, -3.78303118e-02f, 8.79414473e-03f, -2.83877086e-02f, -4.95462380e-02f, 1.07100949e-01f,
  2.95545403e-02f, 4.85110208e-02f, -9.89886820e-02f, -3.43762562e-02f, -9.04022083e-02f, 2.04630569e-02f, -6.44701347e-02f, 3.02290246e-02f, -5.86780831e-02f, -4.74468805e-02f,
  -7.76670948e-02f, 2.09736377e-02f, -9.00561959e-02f, 3.61034125e-02f, 2.67139357e-02f, -4.68627177e-02f, 5.03161177e-02f, -8.27360228e-02f, 5.01918383e-02f, 1.43992128e-02f,
  1.66148111e-01f, -1.44503623e-01f, 1.46472007e-01f, 1.18003547e-01f, 7.63149932e-02f, 1.14525087e-01f, -1.09799199e-01f, -4.50561987e-03f, 4.15914692e-03f, 1.22708064e-02f,
  -7.40852281e-02f, -1.13805838e-01f, 9.68036652e-02f, 5.03874943e-02f, -1.41264111e-01f, -7.00870752e-02f, 1.60092741e-01f, 1.43777188e-02f, 2.55394578e-01f, 1.72860444e-01f,
  3.16068023e-01f, 8.65217224e-02f, 2.63720956e-02f, 4.94727232e-02f, 1.87063232e-01f, -9.37718078e-02f, 8.04451257e-02f, 6.75903484e-02f, -2.73243226e-02f, 1.25069305e-01f,
  7.68047422e-02f, -5.27752824e-02f, -3.95046800e-01f, 1.43079698e-01f, -1.64819300e-01f, -1.27917677e-01f, -1.23299487e-01f, 1.45891294e-01f, 2.67366529e-01f, 4.13865857e-02f,
  -1.06808841e-01f, -1.00255638e-01f, -1.86329797e-01f, -1.73634067e-01f, -1.67006239e-01f, -2.05368102e-01f, -2.17967510e-01f, -3.08783114e-01f, -1.68387219e-01f, 1.78473704e-02f,
  -2.70818695e-02f, -3.52180637e-02f, -3.24779227e-02f, -2.85129398e-02f, 5.12879938e-02f, -2.92870700e-02f, -1.41793743e-01f, -1.92080557e-01f, -2.02577919e-01f, -2.60550916e-01f,
  -2.04582021e-01f, -7.15455785e-02f, -1.81927923e-02f, 1.29950270e-02f, -4.83473614e-02f, 6.45888597e-02f, 4.18838412e-02f, -8.70983303e-03f, -4.63486928e-03f, -4.20048013e-02f,
  -1.02878250e-01f, 3.70364264e-02f, -5.65970764e-02f, -9.06887129e-02f, -9.03896149e-03f, 4.90121264e-03f, -4.51598577e-02f, -9.30773318e-02f, -1.11287698e-01f, -7.54040480e-02f,
  -1.75201401e-01f, -2.45838806e-01f, -1.29105151e-01f, 2.71102414e-02f, -3.26737314e-02f, -1.46285981e-01f, -4.54257359e-04f, 7.68409744e-02f, -3.28547023e-02f, 4.02856693e-02f,
  1.93228468e-01f, -1.29499845e-02f, 1.27363354e-02f, 1.92906521e-02f, 4.24439274e-02f, -1.69047108e-03f, -8.91262218e-02f, -1.19713336e-01f, -4.46885936e-02f, 6.32193685e-02f,
  -2.54848581e-02f, 1.70524474e-02f, -5.74463829e-02f, 5.30247437e-03f, -1.07095726e-01f, -1.42744526e-01f, -1.28907427e-01f, 2.40280107e-02f, -6.37681112e-02f, 1.20231966e-02f,
  -8.57831240e-02f, -8.00581202e-02f, 6.13505370e-04f, 1.44437896e-02f, 1.00089470e-02f, -1.03910565e-01f, -5.51102348e-02f, -2.22171228e-02f, 3.88013758e-02f, -8.04853588e-02f,
  2.13754058e-01f, -1.88593686e-01f, 8.07149783e-02f, -5.92600927e-02f, -1.40716493e-01f, -2.40533911e-02f, -7.26041794e-02f, -4.90718614e-03f, -2.83788126e-02f, -1.79424528e-02f,
  -9.98165831e-02f, -2.93038189e-02f, 1.97033919e-02f, -2.16437969e-02f, -5.46832010e-02f, -2.77929772e-02f, -6.49473444e-02f, -1.94223076e-01f, -1.51155874e-01f, 2.96717472e-02f,
  -3.06325871e-02f, -8.10932219e-02f, -9.36616138e-02f, -6.56098574e-02f, -2.86958739e-02f, -1.14976801e-01f, -4.46915179e-02f, 4.35543060e-03f, -9.41303819e-02f, 1.67378023e-01f,
  1.33024037e-01f, 5.57596013e-02f, 2.71781057e-01f, 1.46687180e-01f, -1.18719853e-01f, -2.62603670e-01f, -5.40399373e-01f, -2.48206958e-01f, 1.11507252e-01f, 4.16375436e-02f,
  -6.93216920e-02f, 5.14517091e-02f, 1.08206809e-01f, -1.67080741e-02f, -2.00148910e-01f, -7.78994858e-02f, 7.75361760e-03f, 1.09251022e-01f, -1.26937464e-01f, -3.54640692e-01f,
  -1.70291632e-01f, -1.86888985e-02f, 1.03135429e-01f, 8.61231014e-02f, 2.60155976e-01f, -2.12118719e-02f, 2.59324253e-01f, 8.53105336e-02f, 8.95251334e-02f, 3.98145407e-01f,
  2.18168035e-01f, 1.34232000e-01f, -2.96228111e-01f, 1.26845971e-01f, 2.65463352e-01f, 8.80006254e-02f, -1.07848153e-01f, 3.12522918e-01f, 4.05314900e-02f, 9.42633823e-02f,
  1.33673340e-01f, 5.38189486e-02f, 6.09540679e-02f, -2.64052656e-02f, -4.01787795e-02f, -1.21864840e-01f, 3.00132185e-02f, 4.07625809e-02f, 9.65255350e-02f, 1.04878105e-01f,
  -1.50611490e-01f, -6.51060045e-02f, -3.18300799e-02f, -2.21662357e-01f, 3.11456118e-02f, -1.36803642e-01f, -1.05768405e-01f, -3.66542079e-02f, -2.18563691e-01f, 5.09240367e-02f,
  -4.26467769e-02f, 6.72401488e-02f, -3.65045108e-02f, 1.83192752e-02f, -1.03185348e-01f, 9.06972215e-02f, 8.66176784e-02f, -1.04046166e-02f, 7.62234703e-02f, 4.75464426e-02f,
  2.45803986e-02f, 6.38399571e-02f, 4.44349460e-02f, -1.71528533e-02f, -2.96841823e-02f, 3.82309733e-03f, -5.78892045e-02f, -1.13848768e-01f, -7.99471326e-03f, -8.71861819e-03f,
  1.93120744e-02f, 3.52042057e-02f, 1.18682526e-01f, 2.98020104e-03f, 7.06054419e-02f, -1.74998771e-02f, -9.25664678e-02f, -7.08508044e-02f, -1.49236470e-01f, -1.38738722e-01f,
  -1.20089330e-01f, -1.62494346e-01f, -9.92539674e-02f, -8.51511583e-02f, 3.92382070e-02f, 3.18582840e-02f, -3.07209734e-02f, -5.94802611e-02f, 8.83691609e-02f, -1.21244818e-01f,
  -9.01688412e-02f, -8.46323967e-02f, 1.04906112e-01f, -2.09652539e-02f, -1.14991836e-01f, -1.61241759e-02f, -1.89440995e-01f, -5.79906330e-02f, -3.69033255e-02f, 1.21133678e-01f,
  -3.19588818e-02f, -4.11956668e-01f, -3.19296420e-01f, -2.54701167e-01f, -2.37443447e-01f, -3.52445006e-01f, -2.36800373e-01f, -2.26123795e-01f, -3.38940322e-01f, -4.57932681e-01f,
  5.42046189e-01f, 3.28376144e-01f, -3.12650651e-01f, 9.60031524e-02f, -3.78636986e-01f, -4.12714958e-01f, -2.50665814e-01f, -2.00859696e-01f, 3.59882414e-02f, 1.90513313e-01f,
  -1.42635375e-01f, 4.49480787e-02f, -7.28777144e-03f, -4.32746224e-02f, -2.34594941e-02f, -4.75289784e-02f, -6.94412664e-02f, -5.07663004e-02f, -1.80980772e-01f, -9.54262316e-02f,
  1.69241086e-01f, 2.21793815e-01f, 2.85112411e-01f, 1.51660129e-01f, 7.95520991e-02f, 6.11925498e-02f, 4.31522392e-02f, 1.74991973e-02f, -2.04630181e-01f, 2.20117360e-01f,
  3.43027711e-02f, -2.60529727e-01f, -1.68121368e-01f, 8.14020634e-02f, 4.43866849e-02f, 1.62038639e-01f, 1.32665619e-01f, 3.48129757e-02f, 7.28169829e-02f, 3.72000597e-02f,
  -2.21896619e-02f, -4.73151542e-02f, -4.30652360e-03f, 4.14796993e-02f, 5.55715300e-02f, -3.06318216e-02f, 6.83048740e-02f, -7.10418820e-02f, 4.82025556e-02f, 2.54873373e-02f,
  -9.94254835e-03f, -1.53434321e-01f, -2.29490757e-01f, -1.21798016e-01f, -1.67070404e-01f, -1.66023180e-01f, -1.61747381e-01f, -1.25387296e-01f, -1.84743613e-01f, 7.64569938e-02f,
  -1.17766425e-01f, 4.97658923e-02f, 1.23091541e-01f, 7.87530392e-02f, 6.69058785e-02f, -1.62750222e-02f, 2.05405392e-02f, 5.85666997e-03f, 8.60551000e-02f, 1.33233786e-01f,
  6.87968917e-03f, -7.31017091e-04f, -4.53185011e-03f, 7.94451907e-02f, 8.60036016e-02f, -4.03922312e-02f, -1.25542153e-02f, 1.15260758e-01f, -4.96505648e-02f, 3.04246298e-03f,
  3.86931412e-02f, -9.39159319e-02f, 9.68074650e-02f, 1.14878088e-01f, -1.06090680e-01f, -1.77430380e-02f, -8.04173723e-02f, 3.66120972e-02f, -2.74122208e-02f, -1.27396464e-01f,
  3.30992192e-01f, -3.68151784e-01f, 1.39565289e-01f, -6.47971258e-02f, -4.54221554e-02f, -1.54886758e-02f, 1.51354268e-01f, 1.26497120e-01f, 4.32293713e-02f, 1.22741103e-01f,
  -5.10427952e-02f, 1.72651574e-01f, 2.16635726e-02f, -6.73657507e-02f, 1.54834799e-02f, -2.76321676e-02f, 1.51560962e-01f, -2.77894195e-02f, 1.10987015e-02f, 6.00367934e-02f,
  5.07923514e-02f, -1.42136058e-02f, -2.77947970e-02f, -6.17831685e-02f, -1.04069494e-01f, -3.86853367e-02f, -1.69010479e-02f, -1.23789966e-01f, -1.98232740e-01f, 2.73667067e-01f,
  -1.62680313e-01f, 4.85261172e-01f, 3.16636413e-01f, -2.65368521e-01f, 4.70737182e-02f, 1.82189792e-01f, 2.86001623e-01f, 1.23134613e-01f, -1.65936574e-01f, 9.78784729e-03f,
  6.57582656e-02f, -2.48455420e-01f, -1.01545185e-01f, -1.20569438e-01f, -1.86966322e-02f, 1.40489593e-01f, 1.43465415e-01f, 1.51675846e-02f, -1.32577881e-01f, -1.77508637e-01f,
  -1.66439503e-01f, -2.09005103e-01f, -1.86539501e-01f, -1.14253819e-01f, 4.94625457e-02f, -1.80889189e-01f, 1.78276047e-01f, 4.40271497e-02f, 1.35574266e-01f, 5.24798222e-02f,
  -2.70696972e-02f, 3.85098636e-01f, -2.10699514e-01f, -1.70929357e-01f, -3.33160497e-02f, -1.29309013e-01f, -9.95134637e-02f, -6.47758916e-02f, -4.24628705e-03f, 4.02183644e-02f,
  -4.72878180e-02f, 3.23206596e-02f, 7.96479732e-03f, -4.93130907e-02f, -9.51892044e-03f, 1.62303187e-02f, 1.78205296e-02f, 7.10220113e-02f, -7.13679334e-03f, 9.68887210e-02f,
  -2.26489529e-02f, 1.17107406e-02f, 1.45193964e-01f, 1.55234337e-01f, 7.48233348e-02f, -1.66405246e-01f, 1.68467090e-01f, 2.94703562e-02f, 6.03872091e-02f, 1.72158759e-02f,
  -1.93710417e-01f, 5.98741323e-02f, -4.31725383e-02f, 5.43467421e-03f, -8.13181177e-02f, 7.13629127e-02f, 1.69955213e-02f, -6.65498748e-02f, -5.09762205e-02f, -3.31754470e-03f,
  -9.50526167e-03f, -9.94242802e-02f, 4.83650640e-02f, 1.89754963e-02f, -4.33358066e-02f, -6.12613335e-02f, -5.89543441e-03f, -4.97611314e-02f, -1.12841520e-02f, 2.27720346e-02f,
  -1.04509696e-01f, -4.33833599e-02f, -6.77123144e-02f, -9.68851298e-02f, 6.89224079e-02f, 5.52726239e-02f, -1.52860045e-01f, 4.39367606e-04f, -4.04174738e-02f, 1.17717400e-01f,
  -2.34079346e-01f, 3.54309753e-02f, -1.80032417e-01f, 4.90366295e-02f, 1.15671903e-02f, 8.06366503e-02f, -1.02919503e-03f, -9.12833512e-02f, -4.65604588e-02f, -8.56482610e-02f,
  1.23023756e-01f, -7.75365811e-03f, 6.82871640e-02f, -1.09828308e-01f, -1.47988290e-01f, -1.21411972e-01f, -1.59156442e-01f, -1.08333632e-01f, -1.03659056e-01f, 3.75316739e-02f,
  -7.78852031e-02f, -2.30284974e-01f, -4.28941995e-01f, -2.12842792e-01f, -1.81314021e-01f, -3.70906919e-01f, -1.38455942e-01f, -1.02386162e-01f, -2.03635544e-01f, -3.19905102e-01f,
  5.10286570e-01f, -3.07562113e-01f, -7.25738287e-01f, 2.04294458e-01f, -1.41831011e-01f, -3.34948570e-01f, -4.52259749e-01f, -1.40559301e-01f, -1.18373232e-02f, -1.90176398e-01f,
  2.65564900e-02f, 2.61427581e-01f, -3.50831496e-03f, 1.93700001e-01f, 1.30011141e-01f, -3.54141802e-01f, -2.49235928e-01f, 5.44137768e-02f, 3.24617773e-01f, 2.96896100e-01f,
  2.68959165e-01f, 3.38420779e-01f, 4.37135607e-01f, 1.03616931e-01f, -6.67008534e-02f, 1.67648882e-01f, -2.92280018e-01f, -1.02674868e-02f, -4.02653702e-02f, -1.68374747e-01f,
  -1.89077526e-01f, -2.71697313e-01f, -1.47496358e-01f, 2.84650534e-01f, -9.93994027e-02f, -1.07895099e-01f, -1.75237939e-01f, -4.01795544e-02f, 5.06124422e-02f, -2.68004477e-01f,
  -7.28095248e-02f, 5.05469069e-02f, 5.18170334e-02f, -6.63156137e-02f, -3.27878781e-02f, -6.15738817e-02f, -1.16474442e-01f, -4.22445051e-02f, -3.14110927e-02f, -1.45232499e-01f,
  1.31340757e-01f, 1.15224950e-01f, -2.92676151e-01f, -2.35540062e-01f, -2.78210610e-01f, 5.95047362e-02f, -2.16796845e-01f, -1.10074066e-01f, -1.44485816e-01f, -1.82866216e-01f,
  5.46786971e-02f, 1.38539141e-02f, -8.75384584e-02f, -1.82701260e-01f, 6.15386777e-02f, -9.10029188e-02f, -3.59390900e-02f, 1.60699993e-01f, 1.71408299e-02f, -1.56934727e-02f,
  -4.48442213e-02f, -7.56946998e-03f, -2.69491021e-02f, -1.12595946e-01f, 1.03457913e-01f, 1.54974256e-02f, -3.22992839e-02f, 4.81753536e-02f, 1.69664711e-01f, 3.82462032e-02f,
  2.99781393e-02f, -5.20400237e-03f, -7.43763745e-02f, 1.10980399e-01f, -8.77868608e-02f, -3.30364257e-02f, 2.71392055e-02f, 5.03135137e-02f, 9.40130726e-02f, -1.04192644e-01f,
  1.93246379e-01f, -4.90338691e-02f, -1.45961612e-01f, 5.18775880e-02f, -8.95461626e-03f, -7.53155649e-02f, -2.26199664e-02f, 9.19892862e-02f, -2.15818640e-02f, 2.00957283e-02f,
  -1.38188154e-01f, 4.76215631e-02f, -6.28689975e-02f, -6.79882616e-02f, -2.67975107e-02f, -7.46359602e-02f, 8.47352743e-02f, 6.82383776e-02f, -9.85473469e-02f, -6.30841628e-02f,
  -2.58182324e-02f, 7.21249208e-02f, 7.20725134e-02f, -7.34962076e-02f, -1.90014131e-02f, 1.55924633e-01f, -2.00687110e-01f, -2.51281291e-01f, -1.38240874e-01f, -7.24549443e-02f,
  8.50470424e-01f, -2.53046513e-01f, -5.62379777e-01f, 2.05551177e-01f, -2.42501765e-01f, -3.13754022e-01f, -3.02201420e-01f, -3.03495191e-02f, 1.63284063e-01f, -1.93770900e-01f,
  -9.71134901e-02f, 3.47358316e-01f, 1.47418961e-01f, 1.46874115e-01f, 3.24007720e-02f, -4.55750048e-01f, -5.36939561e-01f, -1.69210240e-01f, 9.07142311e-02f, 1.13339469e-01f,
  1.31605759e-01f, 1.27076432e-02f, 1.38932496e-01f, 8.25330429e-03f, -1.79047182e-01f, -4.45885882e-02f, -4.29193079e-01f, -1.79580852e-01f, -3.13209057e-01f, -4.35040295e-01f,
  -2.11244449e-01f, -1.99050203e-01f, -7.78189749e-02f, 1.29704461e-01f, -1.08284414e-01f, 2.04706714e-01f, 4.94722798e-02f, -2.54681736e-01f, 1.06885560e-01f, -1.34899288e-01f,
  5.41997626e-02f, 1.47200882e-01f, 1.23161403e-02f, -8.92353803e-02f, -8.91351104e-02f, 4.10795771e-02f, -1.16597682e-01f, -5.91924004e-02f, -1.20472103e-01f, -1.38702795e-01f,
  -4.63073254e-02f, -8.68396834e-02f, -1.04191005e-01f, -1.50773063e-01f, -1.73836961e-01f, -4.92124483e-02f, -3.48047495e-01f, -1.01556912e-01f, -1.74793109e-01f, -2.09648058e-01f,
  3.08806933e-02f, 3.76093797e-02f, -5.43238111e-02f, -9.97658819e-02f, 6.84595257e-02f, -6.53216839e-02f, 4.50601242e-02f, 4.26955288e-04f, 2.67817086e-04f, -4.42707986e-02f,
  -7.99523145e-02f, -8.83500427e-02f, 4.62880880e-02f, -7.14422157e-03f, -8.56587514e-02f, -1.32586017e-01f, -1.27636513e-03f, -6.85133636e-02f, -9.82586816e-02f, 4.64780293e-02f,
  -4.18620706e-02f, -1.59260575e-02f, -3.73107418e-02f, 6.95638135e-02f, -1.08171515e-02f, -3.12809721e-02f, 9.87953767e-02f, 6.08596504e-02f, 2.85134539e-02f, -8.04066509e-02f,
  2.81883746e-01f, -5.69219291e-02f, 1.26439601e-01f, 1.07120432e-01f, -1.21662758e-01f, -1.40904009e-01f, -1.16252014e-02f, -7.17726946e-02f, 3.59713733e-02f, 8.92111063e-02f,
  -6.25453368e-02f, 1.98447645e-01f, -9.43961293e-02f, -1.13311736e-02f, -3.09615433e-02f, 3.37398760e-02f, 5.27524278e-02f, -4.75987084e-02f, -1.60338804e-01f, -1.52299060e-02f,
  -1.08277448e-01f, 1.20098844e-01f, 3.20275724e-01f, 5.69644719e-02f, 9.88364369e-02f, 2.02205464e-01f, -1.44506514e-01f, 3.96927334e-02f, 1.35791376e-01f, 1.51571617e-01f,
  -1.52940184e-01f, 4.36850280e-01f, 4.30839211e-01f, -2.35506862e-01f, -1.57574296e-01f, -1.46852925e-01f, -8.05203430e-03f, -1.38665587e-01f, -8.14050734e-02f, 1.73475280e-01f,
  1.69070810e-02f, -3.61163855e-01f, -8.12790021e-02f, -6.92921877e-02f, -8.86904821e-02f, 2.22568378e-01f, 2.18599334e-01f, -5.83779626e-02f, -3.35554957e-01f, -4.33828413e-01f,
  -3.18692178e-01f, -2.53877103e-01f, -2.45104432e-01f, -2.95259878e-02f, 1.60991415e-01f, -1.51366398e-01f, 2.47978151e-01f, 1.06821157e-01f, 2.07942590e-01f, 3.24742347e-01f,
  2.52360106e-01f, 3.33982617e-01f, -3.22969258e-01f, -2.42672145e-01f, -8.93146694e-02f, -1.97221991e-02f, 7.29912566e-03f, -2.45306324e-02f, -3.50737274e-02f, 9.76464078e-02f,
  -1.42378598e-01f, -5.54584526e-02f, -7.19695240e-02f, -1.28147259e-01f, -1.43331975e-01f, -1.58263385e-01f, -7.90310577e-02f, 5.68383932e-03f, -3.48110087e-02f, 1.07159011e-01f,
  -2.73190707e-01f, -1.67059764e-01f, -3.70162772e-03f, -6.00869209e-02f, 1.33047596e-01f, -1.59010097e-01f, 2.45190039e-02f, -3.03449985e-02f, 1.15515493e-01f, 2.20052257e-01f,
  -4.92394753e-02f, -3.46572027e-02f, -2.11117230e-02f, 7.16647878e-03f, -9.78457034e-02f, -6.71696812e-02f, 3.65685001e-02f, -2.44616829e-02f, 3.46328840e-02f, -1.27154574e-01f,
  3.23892720e-02f, 5.50802983e-02f, -5.29118404e-02f, 9.75980535e-02f, 6.75823018e-02f, -9.61906556e-03f, -5.23401499e-02f, 6.44060643e-03f, 1.77311897e-01f, 9.46475342e-02f,
  -1.12582296e-01f, 3.24151060e-03f, -6.58558905e-02f, -5.11105619e-02f, 1.32412955e-01f, 7.48945074e-03f, -3.24735902e-02f, -7.05858767e-02f, -5.46177775e-02f, 1.67245138e-02f,
  -3.32507610e-01f, -3.57467942e-02f, -6.78159818e-02f, 7.54374033e-03f, -1.07402302e-01f, 5.74332774e-02f, -5.61207812e-03f, -1.82588339e-01f, -3.50522511e-02f, -7.69608766e-02f,
  8.30097795e-02f, -8.23152885e-02f, -8.04906562e-02f, -4.22884226e-02f, -2.12473765e-01f, -1.66317269e-01f, -2.25316346e-01f, -3.10995638e-01f, -1.65145040e-01f, -1.87430486e-01f,
  -1.30037501e-01f, -3.47510844e-01f, -4.45493817e-01f, -2.75880337e-01f, -2.59517938e-01f, -3.03373128e-01f, -1.74016118e-01f, -1.48909539e-01f, -2.67143965e-01f, -1.77603826e-01f,
  -4.99910235e-01f, 2.36756891e-01f, 2.49769941e-01f, -2.32040450e-01f, 2.17708237e-02f, -1.14097968e-01f, -2.83225238e-01f, -4.10358578e-01f, -1.02734551e-01f, 1.26192868e-01f,
  1.74270213e-01f, 1.45670801e-01f, 1.70841619e-01f, 1.39663359e-02f, -1.34067819e-01f, 1.47421226e-01f, 3.26786429e-01f, -1.06387794e-01f, -2.87502974e-01f, -1.90347448e-01f,
  1.39678707e-02f, -1.82591289e-01f, -2.20376030e-01f, -1.60982892e-01f, 1.68308705e-01f, 4.18103999e-03f, 1.39508113e-01f, 3.11564915e-02f, 2.49966741e-01f, 4.25079942e-01f,
  3.55938882e-01f, -1.15720689e-01f, -1.19391114e-01f, 8.94900262e-02f, 2.14008838e-01f, -6.67095557e-02f, -1.31937712e-01f, 3.01572010e-02f, 1.56796295e-02f, 4.52476218e-02f,
  8.45027715e-02f, 1.17937185e-01f, 4.88357842e-02f, -6.16347678e-02f, -1.43358976e-01f, -3.25030982e-01f, -1.16128713e-01f, -2.97677130e-01f, -1.42709419e-01f, -6.56616837e-02f,
  2.58190274e-01f, -1.26111666e-02f, -2.41880313e-01f, -1.95481688e-01f, -2.17090681e-01f, -1.18169270e-01f, -2.45237827e-01f, -3.15214306e-01f, -3.79091591e-01f, -1.85950637e-01f,
  -2.29842775e-03f, 9.53201726e-02f, 7.28143677e-02f, -4.19780053e-02f, 2.25168504e-02f, 2.64817905e-02f, 7.94635937e-02f, 8.89535248e-02f, 9.53510776e-02f, -9.12031978e-02f,
  7.19562024e-02f, 7.33679831e-02f, -1.00618511e-01f, 2.04323195e-02f, -1.98326204e-02f, -1.25799522e-01f, 4.76505868e-02f, 8.86770338e-03f, 7.45331720e-02f, -4.99444176e-03f,
  4.87895459e-02f, -5.74643947e-02f, 1.43342197e-01f, -3.32736075e-02f, 1.21628970e-01f, 8.81142728e-03f, -1.74022503e-02f, -3.77982743e-02f, -1.97815150e-01f, -3.56601621e-03f,
  -2.60733902e-01f, 2.82069370e-02f, 8.71644239e-04f, -2.13336665e-02f, 7.47106969e-02f, 6.02200739e-02f, 1.22982180e-02f, -2.56197508e-02f, 8.22002590e-02f, -8.49781856e-02f,
  -9.23749134e-02f, -3.66471782e-02f, -3.71933333e-03f, 1.98383033e-02f, -1.73127308e-01f, -1.08624808e-02f, 1.00562140e-01f, -1.05233185e-01f, -1.18039720e-01f, -1.11902103e-01f,
  -6.59855315e-03f, -2.58418620e-01f, -2.83511728e-01f, -2.74826467e-01f, -1.14321679e-01f, -2.59742677e-01f, -2.22110495e-01f, -1.71829194e-01f, -3.16224426e-01f, -4.22155946e-01f,
  3.33818138e-01f, 3.84754330e-01f, 1.72653452e-01f, -2.97740418e-02f, -1.93944708e-01f, -4.54991274e-02f, 1.64811939e-01f, 2.00761944e-01f, 1.60745695e-01f, 2.21266761e-01f,
  -7.93584064e-02f, -4.51088727e-01f, -1.57007977e-01f, -1.74452439e-01f, -3.42933126e-02f, 2.44648933e-01f, 2.05213085e-01f, -5.72005846e-02f, -3.87949616e-01f, -3.42363417e-01f,
  -2.72081673e-01f, 7.46757314e-02f, 1.20612614e-01f, 5.91823682e-02f, 7.26401955e-02f, -1.50946528e-01f, 3.63972396e-01f, 1.49815828e-01f, -7.44774118e-02f, -7.47648105e-02f,
  5.00733964e-02f, 5.03619134e-01f, -3.25364441e-01f, -2.16097951e-01f, -3.52534093e-03f, -1.21346250e-01f, -1.13748655e-01f, 8.92741233e-02f, -1.71627268e-01f, 8.00969526e-02f,
  -3.03395957e-01f, -1.97232217e-01f, -2.29612067e-01f, -1.86854377e-01f, -1.54748380e-01f, -6.72644749e-02f, 1.43504262e-01f, 3.09027135e-02f, 1.34249508e-01f, -6.24540187e-02f,
  -4.21637207e-01f, -8.74510333e-02f, 8.96025002e-02f, 6.91432729e-02f, 2.05284581e-02f, -3.00530106e-01f, 1.67939603e-01f, -2.82805208e-02f, 2.53810197e-01f, 3.41928124e-01f,
  2.82961614e-02f, 1.38165966e-01f, -4.19177897e-02f, 2.05630064e-01f, -5.75620048e-02f, -1.41046345e-01f, -7.30832815e-02f, 4.38520946e-02f, -3.32371704e-02f, 8.94221440e-02f,
  1.47707360e-02f, 2.15201691e-01f, 7.87125230e-02f, 1.75907597e-01f, -4.00584154e-02f, 7.75050074e-02f, -7.05569610e-02f, 1.22521326e-01f, 9.71273258e-02f, 4.37030718e-02f,
  -5.40030040e-02f, -1.14263833e-01f, -6.25583827e-02f, 2.09438466e-02f, 1.11548625e-01f, 2.76044775e-02f, -4.23063301e-02f, -8.13424885e-02f, -1.10138711e-02f, 9.57712233e-02f,
  -7.97309950e-02f, -5.62486798e-02f, -2.96562966e-02f, 1.52829392e-02f, 1.70281515e-01f, -8.90394598e-02f, 4.69440334e-02f, 9.03570130e-02f, -1.72297508e-02f, -1.64244220e-01f,
  -2.28960603e-01f, -1.97896019e-01f, 5.11846729e-02f, -9.43355113e-02f, -2.09901363e-01f, -9.94820148e-02f, -1.20220527e-01f, -1.93277553e-01f, -4.22373526e-02f, -3.54719558e-03f,
  -4.32825871e-02f, 1.88818434e-03f, -1.37224779e-01f, -4.33926396e-02f, 9.10834745e-02f, -1.65593848e-01f, 6.26721829e-02f, -1.33501872e-01f, -2.82420609e-02f, 3.14831555e-01f,
  5.14710903e-01f, 2.68748313e-01f, 5.53949513e-02f, 6.45639524e-02f, -1.69820279e-01f, -2.98957348e-01f, -2.67345041e-01f, 5.68321813e-03f, 2.66331173e-02f, 2.13670935e-02f,
  -9.18466598e-03f, -1.83794200e-02f, 4.64660004e-02f, 3.21021937e-02f, -6.52367529e-03f, 4.64649871e-02f, -8.04281831e-02f, 1.31505221e-01f, 3.85571681e-02f, 5.66516677e-03f,
  -9.85356234e-03f, 1.10348307e-01f, 3.10358107e-01f, 1.34868443e-01f, 2.26176325e-02f, -7.14025944e-02f, -3.73952910e-02f, -2.76646484e-02f, -3.78958024e-02f, 1.17079601e-01f,
  1.18141234e-01f, 1.86806053e-01f, -1.45058662e-01f, -8.89231861e-02f, -1.66041497e-03f, 1.45800099e-01f, 4.59930487e-02f, -4.92838398e-03f, 3.03177014e-02f, -1.63247436e-01f,
  4.52934243e-02f, 7.17993975e-02f, -5.59640117e-03f, -8.92588645e-02f, -8.47117528e-02f, 2.86255646e-02f, -8.47079903e-02f, -6.60876632e-02f, -8.50488245e-02f, 1.28146494e-03f,
  -1.47048995e-01f, -2.31917739e-01f, -1.80687085e-01f, -2.24168479e-01f, -1.59946233e-01f, -1.55925065e-01f, -8.58429074e-02f, -9.60870162e-02f, -6.09555431e-02f, -2.46091606e-03f,
  -2.19324782e-01f, -8.05185586e-02f, -2.10660338e-01f, -1.92120463e-01f, -1.87611878e-01f, -2.47092351e-01f, -2.51793772e-01f, -1.39341846e-01f, -1.82112172e-01f, -1.50906309e-01f,
  -1.97425306e-01f, -2.41904065e-01f, -1.86686158e-01f, 3.29327420e-04f, -1.21436797e-01f, -1.22295633e-01f, -1.75129380e-02f, -1.10868394e-01f, -1.51827827e-01f, -1.63580760e-01f,
  -1.66432023e-01f, -1.11152530e-01f, -2.13954896e-02f, -1.62431940e-01f, -2.13023618e-01f, -1.21669456e-01f, -1.27016291e-01f, -1.51533604e-01f, 8.42780098e-02f, -2.26823296e-02f,
  -7.27364197e-02f, -3.72857302e-01f, 1.75513715e-01f, 1.59655571e-01f, 6.27926439e-02f, 6.33473769e-02f, 1.33355437e-02f, -6.64069783e-03f, 4.70335968e-02f, -1.07830964e-01f,
  3.58684920e-02f, 1.49272442e-01f, 5.75218871e-02f, 1.99733302e-02f, -3.28077115e-02f, 2.23479862e-03f, -2.22257152e-02f, -7.39804730e-02f, -8.40180069e-02f, 3.27701331e-04f,
  -1.11674117e-02f, 7.14773638e-03f, -8.85833204e-02f, -2.14371849e-02f, 5.11996038e-02f, -1.12081893e-01f, -3.40193734e-02f, 2.28650533e-02f, -1.48901744e-02f, -7.71933943e-02f,
  3.55135828e-01f, -3.40553433e-01f, -2.04727173e-01f, -1.34874865e-01f, -1.13334246e-01f, 1.90464064e-01f, 2.92794723e-02f, 1.06935255e-01f, 1.87056027e-02f, 3.72760519e-02f,
  1.55069977e-01f, 3.45410675e-01f, 2.50801891e-01f, 2.81248719e-01f, 2.79628307e-01f, -7.96717778e-02f, -2.10506603e-01f, 2.27962166e-01f, 4.16529387e-01f, 2.25770652e-01f,
  -2.88613029e-02f, -2.29894653e-01f, -8.40863436e-02f, -9.32688415e-02f, -4.18411523e-01f, 1.23996295e-01f, -3.12612683e-01f, -2.31707796e-01f, -2.00990185e-01f, -3.32198799e-01f,
  1.30687222e-01f, -2.60701150e-01f, 1.73367225e-02f, -2.47976035e-02f, -1.62727565e-01f, -4.47326154e-02f, 5.11408076e-02f, -1.78204104e-02f, 3.89559045e-02f, -9.91554409e-02f,
  -1.05547100e-01f, -7.16557801e-02f, -8.06166828e-02f, -6.57819957e-02f, -1.12714812e-01f, -1.06844880e-01f, -2.10365266e-01f, -5.61923683e-02f, 2.11598929e-02f, -8.23654979e-02f,
  -6.32415712e-02f, -1.54980391e-01f, -1.57814950e-01f, -1.19056910e-01f, -1.22582197e-01f, 3.64315733e-02f, -1.33280113e-01f, -1.22880191e-01f, 8.30541924e-02f, -1.73661694e-01f,
  2.73122247e-02f, 3.63372192e-02f, -1.66345220e-02f, -1.92110799e-02f, -4.68633734e-02f, 2.35899650e-02f, -4.27253731e-02f, 2.63707228e-02f, 5.21180518e-02f, 8.50676671e-02f,
  8.26783404e-02f, -3.65381688e-02f, 1.06871920e-02f, -3.97953652e-02f, -8.94606933e-02f, -1.69483721e-02f, 1.49781741e-02f, -8.66732076e-02f, -3.32650058e-02f, 9.51924473e-02f,
  1.32055372e-01f, 5.93068711e-02f, 8.20670277e-02f, 1.25745654e-01f, -4.61783446e-03f, 9.22731012e-02f, 2.75203213e-03f, 5.87076992e-02f, -4.92235199e-02f, 4.12126184e-02f,
  1.02568045e-01f, 1.62586510e-01f, 1.63425371e-01f, 1.71945527e-01f, 1.91383436e-02f, 4.59802635e-02f, 9.35193449e-02f, 1.14453942e-01f, 4.00370965e-03f, 6.83263689e-02f,
  -8.98169260e-03f, 9.78624150e-02f, -1.56476185e-01f, 3.76461521e-02f, 1.28225550e-01f, 7.67506147e-03f, -6.97274804e-02f, 9.06944349e-02f, 1.51977077e-01f, -2.71002278e-02f,
  -4.61778715e-02f, 5.19120097e-02f, 2.02188596e-01f, 1.40240848e-01f, 3.59456651e-02f, 2.22480252e-01f, 1.44210190e-01f, 1.14102997e-01f, 2.11640656e-01f, 1.08393870e-01f,
  4.01229948e-01f, -2.67030716e-01f, -5.57922423e-02f, 2.83368587e-01f, 2.52749980e-03f, -2.41786793e-01f, -5.26238620e-01f, -1.47539049e-01f, 1.97200581e-01f, -2.46507227e-01f,
  3.80587354e-02f, 3.17500651e-01f, 2.18479365e-01f, 4.57324274e-03f, -3.18055511e-01f, -5.05463839e-01f, -3.56036663e-01f, -5.47628812e-02f, -1.10697038e-01f, -1.66357890e-01f,
  -2.77957786e-02f, -2.37726024e-03f, 8.98116305e-02f, -8.68339166e-02f, -7.74488375e-02f, 3.64930518e-02f, -1.28053308e-01f, 1.69047322e-02f, -1.91331506e-01f, -1.45646557e-01f,
  -1.52488604e-01f, -5.98462112e-02f, -1.15575068e-01f, 3.48887444e-02f, 5.21190986e-02f, 1.24261044e-01f, -1.01672128e-01f, 3.43809053e-02f, -4.70539322e-04f, 6.07186668e-02f,
  1.90325350e-01f, 2.22032722e-02f, 1.56661406e-01f, -2.25528535e-02f, -2.78536025e-02f, -2.16801614e-02f, -2.25227810e-02f, -8.18388388e-02f, -9.11031663e-02f, -1.24849506e-01f,
  -4.70369570e-02f, 1.22072287e-02f, -2.67293584e-02f, -1.00857303e-01f, -1.39082536e-01f, 1.50221631e-01f, -2.06980079e-01f, -1.22869141e-01f, -1.93462387e-01f, -1.96544141e-01f,
  -8.90735388e-02f, -3.16345245e-02f, -6.72232583e-02f, 4.51870598e-02f, -1.85097661e-02f, 9.51493084e-02f, -5.33333747e-03f, -1.24395430e-01f, 7.24459365e-02f, 4.04673405e-02f,
  -2.60033328e-02f, 2.56271716e-02f, 9.05171111e-02f, -8.02058727e-02f, -6.98871985e-02f, -8.32614452e-02f, 7.06489012e-03f, -1.46750644e-01f, -9.63545293e-02f, -5.97448535e-02f,
  4.59991805e-02f, 4.19655070e-03f, 1.30500719e-01f, -5.61298691e-02f, 1.97037403e-03f, -8.50631595e-02f, -1.64702709e-03f, 4.13601287e-02f, 7.12382719e-02f, -7.15211928e-02f,
  2.47616008e-01f, -4.42931764e-02f, -4.92058694e-02f, -1.22898422e-01f, -2.84032151e-02f, -1.99204348e-02f, 8.34345147e-02f, 7.52978632e-03f, 1.07813872e-01f, -2.44105048e-02f,
  -1.56149358e-01f, -1.21700820e-02f, 7.32497126e-02f, 7.58133233e-02f, -3.12931016e-02f, -1.95653029e-02f, -1.60777137e-01f, 2.77235936e-02f, -2.36258730e-02f, 6.70035928e-02f,
  -4.41976860e-02f, -2.08392277e-01f, 4.87374403e-02f, -4.88307327e-02f, -6.37516752e-02f, 1.32686436e-01f, -2.14079559e-01f, -1.67340577e-01f, -1.50922716e-01f, -3.09693158e-01f,
  -3.31548631e-01f, 3.30507696e-01f, -4.35363740e-01f, -4.70671803e-01f, -4.52004790e-01f, -2.74957925e-01f, 3.63301486e-01f, -1.38976555e-02f, -3.10677886e-01f, 1.84574813e-01f,
  1.71386734e-01f, -1.85801119e-01f, -1.49435624e-01f, -1.95721351e-02f, 2.31935248e-01f, 4.08726186e-01f, -4.02584188e-02f, -1.32269159e-01f, -2.17848882e-01f, 5.75368367e-02f,
  7.18417913e-02f, -1.70883775e-01f, -2.19581664e-01f, -2.13819385e-01f, -2.56580979e-01f, -3.35165650e-01f, -2.58465052e-01f, -2.94816554e-01f, 9.75402351e-03f, -1.00864448e-01f,
  1.66771188e-01f, -3.28991115e-01f, -3.28692459e-02f, -1.64552882e-01f, -5.85485809e-02f, -2.75288597e-02f, -5.49532212e-02f, -2.22894371e-01f, 2.11857017e-02f, -9.87892319e-03f,
  -2.66829699e-01f, -6.57369643e-02f, -1.79371297e-01f, 6.37804344e-03f, -1.95601016e-01f, -1.13737382e-01f, -1.86441496e-01f, -7.94173852e-02f, -7.04062730e-02f, 9.44971740e-02f,
  1.97337970e-01f, -5.20873331e-02f, -1.42366186e-01f, 1.09769680e-01f, -9.48661938e-02f, -1.73898801e-01f, -2.96892393e-02f, -1.75616160e-01f, -1.73578024e-01f, 1.20732471e-01f,
  1.17337473e-01f, -1.04880869e-01f, -6.23057447e-02f, 3.52938287e-02f, 9.16052833e-02f, 1.56183699e-02f, -3.02533247e-02f, 6.50862115e-04f, -1.25740226e-02f, 4.20210883e-02f,
  4.86950837e-02f, 8.75001252e-02f, 3.35693359e-02f, 5.11567816e-02f, -6.60593361e-02f, -3.37163731e-02f, 1.85993716e-01f, 2.41472930e-01f, -2.68702935e-02f, -2.56183110e-02f,
  -6.37287721e-02f, -8.21250379e-02f, -6.69041276e-02f, 1.14539616e-01f, 7.21880049e-02f, -7.31056482e-02f, -3.19493413e-02f, 7.51779079e-02f, -6.53005838e-02f, -4.94359396e-02f,
  1.44128516e-01f, 3.06157321e-02f, 1.77896366e-01f, 3.11835017e-02f, -1.19805239e-01f, -2.59449091e-02f, -3.03250905e-02f, 1.28930584e-02f, -6.35069832e-02f, 2.58762389e-02f,
  -3.71349864e-02f, 5.00567295e-02f, -7.18012229e-02f, -7.06925914e-02f, -1.06931850e-01f, -1.30106464e-01f, 2.17771247e-01f, -3.38733345e-02f, -7.19481483e-02f, 1.16588943e-01f,
  1.88537285e-01f, 2.23737255e-01f, 1.95864663e-01f, 2.41526186e-01f, 8.11550207e-03f, -4.25572917e-02f, 2.21300364e-01f, 1.25493988e-01f, 2.24402770e-01f, 4.33094442e-01f,
  -6.28819346e-01f, 3.44309032e-01f, 1.85428411e-02f, -1.28410175e-01f, 1.41917181e-03f, -1.50298595e-01f, -9.29893032e-02f, -2.22662881e-01f, -3.93899605e-02f, 2.40603819e-01f,
  1.07043929e-01f, -2.82863766e-01f, -2.27399245e-01f, -3.45996708e-01f, -3.73604864e-01f, -2.32276320e-02f, -5.81615455e-02f, -4.32428777e-01f, -7.19817102e-01f, -4.27030355e-01f,
  -1.86977297e-01f, -3.11213493e-01f, -4.86670762e-01f, -2.72683561e-01f, 2.13572681e-01f, -2.99299359e-01f, -2.97669247e-02f, -8.30688253e-02f, -9.63547230e-02f, 7.50101805e-02f,
  1.15535051e-01f, -1.71062708e-01f, -2.07848325e-01f, 6.22685486e-03f, 1.20706722e-01f, -4.81785834e-02f, 7.66293379e-03f, -3.02211195e-03f, 5.79783246e-02f, 4.36324291e-02f,
  1.19130559e-01f, -4.74124253e-02f, -4.39692512e-02f, 4.16943617e-02f, -3.63806933e-02f, 2.12481376e-02f, 1.47619352e-01f, -9.99809131e-02f, -5.91417514e-02f, 1.66827396e-01f,
  9.83012989e-02f, -3.25692967e-02f, 6.91783279e-02f, -5.58195934e-02f, -7.73049593e-02f, -1.71228386e-02f, 7.02481940e-02f, 5.77979609e-02f, -1.08142592e-01f, 2.10392892e-01f,
  1.89082608e-01f, 1.38299346e-01f, 7.45246783e-02f, 6.74879029e-02f, 1.10579751e-01f, 8.28261748e-02f, 6.61118329e-02f, 6.59766793e-02f, -1.35560617e-01f, 2.03315448e-02f,
  1.08058505e-01f, -6.55119270e-02f, -5.32626808e-02f, -4.23913822e-02f, 3.87926474e-02f, -1.21787172e-02f, -1.41989857e-01f, 8.09848495e-03f, 1.11756042e-01f, 3.86365652e-02f,
  -6.53643832e-02f, 2.25935746e-02f, -3.34060378e-02f, -1.83073319e-02f, -3.21892053e-02f, 8.84213373e-02f, 1.77998357e-02f, -5.07840235e-03f, 6.75306246e-02f, 1.65870786e-02f,
  -6.93891048e-02f, -3.33651751e-01f, 3.77215073e-02f, -5.32375686e-02f, 4.28978279e-02f, 7.10874889e-03f, -9.55402385e-03f, -4.70881499e-02f, -1.56798549e-02f, -5.90691157e-02f,
  5.83162904e-02f, 2.91498099e-02f, -1.87905189e-02f, 6.70341179e-02f, -4.17873375e-02f, -6.40324876e-03f, 2.02140942e-01f, 1.02457643e-01f, 5.77799752e-02f, 3.16698670e-01f,
  2.58360922e-01f, 3.80539312e-03f, 1.03139365e-02f, 1.84235230e-01f, 3.55499201e-02f, -7.29748607e-02f, -2.95911487e-02f, 8.09478387e-02f, -4.54497263e-02f, 1.11477263e-01f,
  3.64840388e-01f, 4.85013038e-01f, 1.15475617e-01f, 2.34579861e-01f, 4.03061301e-01f, 3.80164802e-01f, 6.37274861e-01f, 4.67785865e-01f, 2.13556319e-01f, 2.76787698e-01f,
  3.40289921e-01f, 1.43487617e-01f, 1.97968453e-01f, 6.25451282e-02f, 7.60875419e-02f, 1.25905722e-01f, 1.21998295e-01f, -9.12683904e-02f, -5.77500500e-02f, 6.13746010e-02f,
  1.56942800e-01f, 1.70678109e-01f, 7.08510503e-02f, 6.63120896e-02f, 9.93296728e-02f, 1.40119702e-01f, 2.02418864e-01f, 2.67021209e-01f, 7.63734207e-02f, -6.02915101e-02f,
  -4.62493390e-01f, 2.07194686e-02f, -8.32091942e-02f, -1.32734999e-01f, -6.69344366e-02f, -1.24683186e-01f, -4.98996377e-02f, -7.89557397e-02f, -6.50691763e-02f, -1.21627398e-01f,
  -1.93195827e-02f, -9.81138349e-02f, -4.12082374e-02f, -8.63632113e-02f, 2.23538987e-02f, -1.92494676e-01f, -6.39772117e-02f, -9.02247429e-02f, -3.13460678e-02f, -4.37956676e-02f,
  -1.05815008e-01f, -2.95997877e-02f, 3.80663425e-02f, 4.80284244e-02f, -1.47861312e-03f, -1.27208289e-02f, -2.63909381e-02f, -7.96883479e-02f, -8.83470550e-02f, 4.59277891e-02f,
  1.92399938e-02f, 2.80367467e-03f, -9.74937230e-02f, 5.90592921e-02f, 5.42468065e-03f, 4.62600924e-02f, -1.50130065e-02f, 1.05045922e-01f, -1.31041836e-02f, 4.35888022e-02f,
  1.02864148e-03f, -1.28194913e-01f, 6.69268938e-03f, -1.25801265e-01f, -1.73679143e-01f, -1.07460953e-02f, 2.56555267e-02f, -4.78489138e-02f, -2.88096189e-01f, -1.32179081e-01f,
  -1.77422062e-01f, 7.25327134e-02f, -6.38242662e-02f, -1.27696842e-01f, -8.44321400e-03f, 4.85132076e-03f, -1.97270326e-02f, -4.37980257e-02f, 1.27022550e-01f, -1.21286968e-02f,
  -3.24343033e-02f, -2.25735873e-01f, -1.32765561e-01f, -3.79524603e-02f, -6.96850196e-02f, -8.21990296e-02f, 5.79410652e-03f, -7.21881092e-02f, -9.60917175e-02f, -2.42894143e-02f,
  -4.02333550e-02f, -5.85052222e-02f, -2.32812557e-02f, 3.74164768e-02f, -7.73155987e-02f, -2.89121270e-02f, -3.95981334e-02f, 1.68768898e-01f, 3.35974023e-02f, 7.10057318e-02f,
  1.22397080e-01f, 1.24878377e-01f, 3.44128422e-02f, 5.84324896e-02f, -3.59338783e-02f, 4.72157374e-02f, 1.27013400e-02f, 6.96678981e-02f, 7.45714828e-02f, 4.01658155e-02f,
  -3.99019986e-01f, -4.90764499e-01f, -1.30923241e-01f, -5.14068246e-01f, -2.53290027e-01f, -2.66219606e-03f, -2.76839644e-01f, -2.74091717e-02f, -1.92007110e-01f, -5.01211643e-01f,
  -2.26886515e-02f, 1.11044951e-01f, -3.17453258e-02f, 1.44480765e-01f, 1.86955214e-01f, -3.95250142e-01f, -2.53318757e-01f, 9.40157548e-02f, 4.71864730e-01f, 1.44904241e-01f,
  -1.31040409e-01f, -3.57532799e-02f, 2.32761905e-01f, 2.22460758e-02f, -4.37417090e-01f, -1.04136601e-01f, -3.48392606e-01f, -2.42106780e-01f, -6.38984442e-02f, -4.26061064e-01f,
  -2.63401955e-01f, -1.59928232e-01f, 2.19429627e-01f, 2.44349912e-01f, -1.77822083e-01f, -9.09153372e-03f, -8.97600278e-02f, 5.08094206e-02f, 8.18075761e-02f, -1.35681495e-01f,
  7.10569741e-03f, 7.51016811e-02f, 3.01967300e-02f, 3.65268514e-02f, -7.80713856e-02f, -2.35356968e-02f, 6.63882196e-02f, 1.25328928e-01f, -1.57788284e-02f, -8.84532556e-02f,
  -2.82240529e-02f, -6.43215002e-03f, 2.47672815e-02f, 7.07452046e-03f, 8.06485191e-02f, 1.57808900e-01f, -8.37860629e-02f, 1.59127980e-01f, 1.63908362e-01f, -4.31459427e-01f,
  -5.03866039e-02f, -1.59577448e-02f, 1.66391544e-02f, 8.99797976e-02f, 1.16587065e-01f, -2.68293102e-03f, -1.08078010e-01f, -4.84250560e-02f, 9.37902480e-02f, 4.62193377e-02f,
  4.71425913e-02f, -4.33086744e-03f, -9.81138786e-04f, -1.07605584e-01f, 1.22076813e-02f, -1.58195756e-02f, -3.98786850e-02f, -7.65784783e-03f, 1.37371924e-02f, -2.98377369e-02f,
  7.83905163e-02f, 7.70010427e-03f, -6.86939657e-02f, 5.00233136e-02f, 1.05776042e-01f, -5.70407696e-02f, -5.67058064e-02f, 1.21104546e-01f, -8.34659487e-02f, 6.63256040e-03f,
  -2.16342300e-01f, 3.85217011e-01f, -4.10790116e-01f, 7.62786791e-02f, -8.62775221e-02f, 1.25744209e-01f, -8.60394537e-02f, 1.38227269e-01f, -1.38372257e-02f, -1.26257390e-01f,
  1.95075110e-01f, -1.29185557e-01f, -1.35208383e-01f, 2.38613579e-02f, 6.59564091e-03f, 8.70524812e-03f, -4.89178039e-02f, -1.25927046e-01f, 1.23657815e-01f, 6.18341519e-03f,
  4.24810722e-02f, -5.82442842e-02f, -1.34873942e-01f, -1.28437757e-01f, -5.23882806e-02f, 9.02732611e-02f, -6.20954037e-02f, -3.97821590e-02f, 3.49564776e-02f, -4.11370009e-01f,
  1.18180528e-01f, 1.01901464e-01f, -6.36147022e-01f, -1.44662336e-01f, -7.04122558e-02f, -1.07408248e-01f, 1.74369052e-01f, 3.24073881e-02f, -1.79810096e-02f, 1.06887974e-01f,
  -2.39835586e-02f, -2.06774831e-01f, -4.58599716e-01f, -3.05537909e-01f, -2.49390617e-01f, -1.98607221e-01f, -2.78544754e-01f, -3.86917681e-01f, -2.65928775e-01f, 2.63312310e-01f,
  2.31401071e-01f, 4.56191860e-02f, -2.22691987e-02f, -1.18005037e-01f, 3.65501866e-02f, -2.57606536e-01f, -3.78317684e-01f, -2.19142318e-01f, -1.39897034e-01f, -1.05358124e-01f,
  -2.61258751e-01f, -2.25818485e-01f, -1.17655136e-01f, 2.63023134e-02f, -4.24462855e-02f, 9.24571883e-04f, 1.51055679e-01f, -1.08963065e-01f, 9.05087590e-02f, 6.15513325e-02f,
  -5.22946753e-02f, 1.12860933e-01f, -6.82706162e-02f, -9.07771438e-02f, -4.87344479e-03f, -4.12038825e-02f, -1.69634134e-01f, -1.93849504e-01f, -1.46183759e-01f, 1.27541900e-01f,
  2.58649021e-01f, -1.13182828e-01f, -2.85378814e-01f, -3.90040912e-02f, -1.42789245e-01f, -2.82529861e-01f, -3.72925624e-02f, -4.54345047e-02f, -1.96500614e-01f, 7.81322420e-02f,
  2.22106144e-01f, 9.08926129e-02f, 2.88794041e-02f, 7.44139180e-02f, 1.47055522e-01f, -5.51749058e-02f, -1.41045619e-02f, 4.12654467e-02f, 1.18857818e-02f, 4.17765118e-02f,
  2.13908888e-02f, 1.20594628e-01f, 4.21370827e-02f, -8.03092420e-02f, -1.78546652e-01f, -1.07406028e-01f, -3.94316530e-03f, 6.53840527e-02f, -6.20409995e-02f, 9.29719359e-02f,
  3.46567556e-02f, -6.82034343e-02f, -6.13114461e-02f, 1.14059195e-01f, 1.37714203e-02f, 8.54950696e-02f, 7.33133852e-02f, 1.65350304e-03f, 2.01179776e-02f, 7.53389150e-02f,
  -1.48733780e-01f, -2.39480868e-01f, -1.08394891e-01f, 1.05781108e-02f, 2.64863633e-02f, -2.82778963e-03f, 4.36755754e-02f, 1.85690865e-01f, 7.39046112e-02f, 2.63089865e-01f,
  4.53181863e-02f, 2.36498982e-01f, -1.86570555e-01f, 3.16245258e-02f, -5.69194816e-02f, -1.95833482e-02f, 2.24257961e-01f, 2.15344392e-02f, -1.58687830e-02f, 2.24059910e-01f,
  5.06469384e-02f, 3.53544541e-02f, 2.17446592e-02f, -5.49168959e-02f, 8.29028040e-02f, -2.56066680e-01f, -1.60323277e-01f, 7.95416441e-03f, -1.47965938e-01f, 2.20636323e-01f,
  5.50167441e-01f, 1.87436298e-01f, 1.12923965e-01f, 2.32282177e-01f, -7.69268954e-03f, 6.87632635e-02f, 1.04253709e-01f, 1.08215272e-01f, 1.27121419e-01f, 2.26640314e-01f,
  1.23728119e-01f, 2.09445775e-01f, 9.95202065e-02f, 1.74985468e-01f, 8.21736678e-02f, 4.50608507e-02f, 3.82659584e-02f, 7.63944313e-02f, 2.00368479e-01f, 1.47821218e-01f,
  1.64274067e-01f, 1.22450896e-01f, 2.15537697e-02f, 1.89482942e-01f, 1.83807656e-01f, 1.99299902e-01f, 5.94000742e-02f, 1.12501852e-01f, 1.26717478e-01f, 1.87171191e-01f,
  2.11682841e-01f, 2.84230337e-02f, 5.67336474e-03f, -4.48088683e-02f, -8.38289484e-02f, -1.32355392e-01f, -5.57702258e-02f, -8.71495157e-02f, -9.72475857e-03f, -6.53748959e-02f,
  -5.00805415e-02f, -2.81086192e-02f, -1.28184780e-01f, -1.39257178e-01f, -1.20600417e-01f, -1.09736815e-01f, -6.82695881e-02f, 3.08609996e-02f, -3.38886939e-02f, -9.46508721e-02f,
  -1.04331456e-01f, -8.13194215e-02f, -1.03848696e-01f, -1.29736841e-01f, -7.08018914e-02f, -3.94098088e-02f, -1.79758016e-02f, -1.36238988e-02f, -7.62570724e-02f, -8.84269252e-02f,
  9.45362672e-02f, -6.91804010e-03f, 1.19445749e-01f, 1.28264174e-01f, 2.76857972e-01f, 2.84795687e-02f, 5.80148101e-02f, 4.89144921e-02f, 5.36970198e-02f, 7.57168680e-02f,
  -2.42766570e-02f, 1.44563824e-01f, 5.12523279e-02f, 1.24240875e-01f, 8.32124949e-02f, 2.46975925e-02f, -1.31572232e-01f, -4.39137407e-03f, 8.56781602e-02f, -3.26396488e-02f,
  1.44676119e-01f, -4.18571234e-02f, -1.27742603e-01f, 2.05630288e-02f, -1.61205102e-02f, -1.83774754e-02f, 4.23345044e-02f, -3.13406400e-02f, -4.43164632e-03f, -2.30187061e-03f,
  -2.50662446e-01f, -2.12753072e-01f, 1.60583586e-01f, -8.85747299e-02f, -1.84483349e-01f, -7.51326531e-02f, -6.51210099e-02f, -1.38277218e-01f, -1.27873465e-01f, -8.25727358e-02f,
  -1.30532444e-01f, -1.27038419e-01f, -5.47611043e-02f, -3.83053593e-05f, -5.34660891e-02f, -4.79862764e-02f, -1.50257289e-01f, -1.12578616e-01f, -1.96153432e-01f, -2.20679432e-01f,
  -1.52028441e-01f, -2.71894366e-01f, -2.39048228e-01f, -8.44328180e-02f, -7.22096935e-02f, -8.49720761e-02f, -4.68104295e-02f, -5.28868996e-02f, -1.92586541e-01f, -1.01941146e-01f,
  5.08556962e-01f, -1.41838133e-01f, 1.60159230e-01f, 1.51943430e-01f, 6.67815059e-02f, -3.72217372e-02f, -1.31757662e-01f, 4.55644019e-02f, 1.49527052e-02f, 2.92430893e-02f,
  1.14428282e-01f, 6.89063370e-02f, 5.97324744e-02f, 1.09500699e-01f, 5.27210422e-02f, -5.53920120e-02f, 3.93585488e-02f, 2.23349527e-01f, 2.15002865e-01f, 1.22442715e-01f,
  -1.14245014e-02f, 7.43281692e-02f, 5.81254140e-02f, 5.21063581e-02f, 7.29912519e-02f, 1.41200289e-01f, 6.59744963e-02f, -2.53929682e-02f, 6.46306872e-02f, -6.77694902e-02f,
  5.46442121e-02f, 1.75152048e-01f, 1.43882066e-01f, 1.59082875e-01f, 1.03776015e-01f, 1.20527960e-01f, -1.37304338e-02f, -3.10014226e-02f, -1.33527130e-01f, -4.89420816e-02f,
  -3.71158421e-02f, 7.80118704e-02f, -3.35383564e-02f, 9.30229723e-02f, 1.26643687e-01f, 1.38888299e-01f, 2.08419383e-01f, 4.48884210e-03f, 1.46268727e-02f, 3.98263196e-03f,
  3.84180360e-02f, 7.78599977e-02f, 7.79608935e-02f, -5.75926453e-02f, 1.82474162e-02f, 7.84713477e-02f, 9.28374156e-02f, 1.88691542e-02f, 1.81174353e-01f, 1.80718377e-02f,
  2.43459329e-01f, 1.62026018e-01f, 1.67725176e-01f, 9.58285779e-02f, 1.05068535e-01f, 2.09094256e-01f, 1.74718529e-01f, -4.59777862e-02f, 1.41289458e-01f, 1.47083804e-01f,
  1.56571984e-01f, 9.75546017e-02f, 1.35434359e-01f, 2.65572648e-02f, 2.95083731e-01f, 1.25901669e-01f, 1.40387565e-01f, 1.13028571e-01f, 2.85083890e-01f, 3.69047374e-02f,
  1.03673600e-01f, 1.23864993e-01f, 2.23816186e-01f, 1.72893375e-01f, 2.12293431e-01f, 2.54105151e-01f, 1.90512791e-01f, 3.54722515e-02f, 1.98200971e-01f, 8.02055821e-02f,
  -2.76628166e-01f, 1.33228749e-01f, 6.52977750e-02f, -5.51206879e-02f, 1.96181629e-02f, 1.01468742e-01f, -8.72469172e-02f, -9.77388956e-03f, -1.75609499e-01f, -1.93689972e-01f,
  -4.99933325e-02f, 4.97177020e-02f, 2.69751828e-02f, 1.69506967e-02f, 8.79955944e-03f, 5.98401390e-02f, -5.10687195e-02f, 3.72968204e-02f, -1.73029080e-01f, -3.99931036e-02f,
  -9.87417996e-02f, -7.95878842e-02f, -7.15611950e-02f, -1.13588706e-01f, -4.79281992e-02f, 1.54366180e-01f, -2.83072200e-02f, -1.33404225e-01f, -3.82679179e-02f, -1.02560580e-01f,
  4.97362524e-01f, 1.91518140e-03f, -1.90734997e-01f, 3.10525000e-01f, -1.22929111e-01f, -3.99594277e-01f, -4.00729567e-01f, -6.36299253e-02f, 2.65628576e-01f, 3.86095196e-02f,
  -2.29222938e-01f, -9.07746330e-02f, 1.48104802e-01f, -1.37417093e-01f, -2.64062107e-01f, -7.98604637e-02f, -5.60426787e-02f, -2.12993577e-01f, -3.75651836e-01f, -4.65455085e-01f,
  -1.67241439e-01f, -2.15861965e-02f, -1.98321547e-02f, -3.82636525e-02f, 2.56044209e-01f, 3.34926620e-02f, 1.88589796e-01f, 7.78531507e-02f, -1.31039113e-01f, 2.36642286e-01f,
  2.66400427e-01f, 5.47415800e-02f, -1.41699418e-01f, -8.44249576e-02f, -6.40740544e-02f, 5.24763279e-02f, -1.02078170e-01f, -5.64331422e-03f, -1.47082075e-01f, -2.18027253e-02f,
  -2.54694950e-02f, -9.72722322e-02f, -1.45538643e-01f, -7.78171420e-02f, -3.47184055e-02f, -4.70041484e-02f, -1.29899740e-01f, -1.75980806e-01f, -3.41853611e-02f, -1.09204367e-01f,
  -2.17722848e-01f, -1.89764559e-01f, -4.09109630e-02f, -1.02209784e-01f, -1.13819085e-01f, -1.04938947e-01f, -3.52123789e-02f, -1.65545702e-01f, -1.40601888e-01f, 1.72926664e-01f,
  1.00580446e-01f, 9.43541303e-02f, -4.38425057e-02f, -8.54825824e-02f, 4.39338852e-03f, -8.20814818e-02f, -2.05184687e-02f, -1.05273135e-01f, 3.76100726e-02f, 6.07865117e-02f,
  -1.80763647e-01f, -4.31322195e-02f, -9.46751088e-02f, 4.93079573e-02f, 5.78171574e-02f, 1.07683122e-01f, -5.47790118e-02f, -7.48144835e-02f, -7.46344216e-03f, 3.70063335e-02f,
  -3.87849100e-02f, 6.78603575e-02f, 5.19771725e-02f, 6.82027563e-02f, -9.20257717e-02f, -8.72548744e-02f, 4.67353016e-02f, -3.46739851e-02f, 6.67279661e-02f, -2.06546523e-02f,
  2.39713758e-01f, -2.99721897e-01f, 3.42305571e-01f, -4.97255512e-02f, 6.01945594e-02f, -1.03674233e-01f, 2.57265400e-02f, -1.46765560e-01f, 1.02231599e-01f, -6.38515800e-02f,
  -2.76279658e-01f, -1.01284571e-01f, 1.82637304e-01f, -5.55469319e-02f, -9.72788259e-02f, -1.18607126e-01f, -1.65843278e-01f, -3.32314111e-02f, -5.87588102e-02f, 7.28650987e-02f,
  3.62245813e-02f, -4.17828932e-02f, 1.08972095e-01f, 1.86277941e-01f, 1.49379196e-02f, 1.04193926e-01f, 5.80415390e-02f, 2.52317209e-02f, -5.54453917e-02f, 2.99424291e-01f,
  5.29955387e-01f, 2.70749658e-01f, 1.58220783e-01f, 2.71824338e-02f, -1.33716971e-01f, 1.12829261e-01f, 2.62911826e-01f, 1.61790222e-01f, 1.44333169e-01f, 1.82074979e-02f,
  2.84255501e-02f, 5.45672216e-02f, 1.21103197e-01f, 9.91694406e-02f, 2.15496168e-01f, 1.89265087e-01f, 1.41874373e-01f, 2.84396410e-01f, 1.76530302e-01f, -3.54107618e-02f,
  -1.77311548e-03f, 7.39830211e-02f, 1.87037587e-01f, 1.29076332e-01f, -4.20454666e-02f, -9.11762044e-02f, 1.04762241e-01f, 2.03408068e-03f, 3.03982776e-02f, -4.42288332e-02f,
  -9.28044170e-02f, 2.36539111e-01f, 4.94270921e-02f, 1.33283898e-01f, 1.57573819e-01f, 2.21954286e-01f, 6.74290732e-02f, -3.52674797e-02f, -6.55301437e-02f, -5.50878048e-02f,
  2.55354233e-02f, -4.40617278e-02f, 1.02667741e-01f, 7.32453465e-02f, 2.47138254e-02f, -5.92035577e-02f, 3.70172486e-02f, 1.17319703e-01f, 8.50205570e-02f, 7.11250007e-02f,
  5.38143404e-02f, -4.03421856e-02f, 1.14852106e-02f, 1.13044202e-01f, 2.22383410e-01f, 5.92759512e-02f, 1.47574022e-02f, 2.45437659e-02f, 1.36819050e-01f, 9.69612226e-02f,
  2.89113939e-01f, 2.86428690e-01f, 4.44815047e-02f, 4.54208255e-02f, 4.26934212e-02f, -3.60799506e-02f, -4.34149541e-02f, 7.53994733e-02f, 1.11724257e-01f, 1.05351470e-01f,
  -1.39732063e-01f, -5.37930392e-02f, 6.54220656e-02f, -9.94079933e-03f, -7.01247295e-03f, -4.40056995e-02f, -7.09630735e-03f, 1.31708518e-01f, 1.11571811e-01f, 1.48211271e-01f,
  1.16125166e-01f, 2.79138517e-02f, -1.40867040e-01f, -5.74186333e-02f, -1.80393666e-01f, -4.36951071e-02f, 4.84504998e-02f, 7.78463557e-02f, -1.13810766e-02f, -7.62482584e-02f,
  -1.18632026e-01f, 2.18270719e-01f, -8.17093346e-03f, 1.47998601e-01f, -4.06657383e-02f, 5.92871383e-02f, 1.02895640e-01f, -1.49280518e-01f, -1.77067339e-01f, -2.17663422e-02f,
  -4.30455692e-02f, 1.23288490e-01f, 6.35624826e-02f, -4.55630496e-02f, -1.61500618e-01f, -1.69303678e-02f, -6.10162206e-02f, -8.51645097e-02f, -4.54392508e-02f, 3.13786417e-02f,
  7.01105148e-02f, -8.50519687e-02f, -7.84017518e-03f, -3.36475335e-02f, 8.21794346e-02f, -1.02426179e-01f, -1.52946830e-01f, -5.49823307e-02f, 1.20012602e-02f, -1.34194553e-01f,
  -5.61947167e-01f, 3.95098096e-03f, -1.40032232e-01f, -2.29898095e-01f, 2.55198181e-01f, 4.07344013e-01f, 3.61252010e-01f, 3.27863336e-01f, 5.28474785e-02f, -3.13072428e-02f,
  -4.51943241e-02f, -1.49768978e-01f, -2.39841655e-01f, -8.95598810e-03f, 1.05055667e-01f, 1.40414014e-01f, 7.70680308e-02f, -8.96712542e-02f, 4.97957245e-02f, 2.97995418e-01f,
  9.27717462e-02f, -1.97264016e-01f, -3.61939371e-01f, -6.96765557e-02f, -6.62859306e-02f, -1.56372502e-01f, -2.81502277e-01f, -1.94739848e-01f, 3.46111432e-02f, -2.35496849e-01f,
  -2.96721041e-01f, -9.90823880e-02f, 1.92597672e-01f, -5.13575189e-02f, -2.15362787e-01f, -6.39007017e-02f, -1.96467992e-02f, -1.21145815e-01f, 2.35681683e-02f, -1.46582965e-02f,
  -1.29932806e-01f, 5.27382679e-02f, -7.39663765e-02f, -1.16379885e-02f, -8.59708861e-02f, 3.23176049e-02f, -5.15269302e-02f, -1.05563462e-01f, -1.90255448e-01f, 6.32005781e-02f,
  1.85715035e-01f, -9.71618965e-02f, -1.75243333e-01f, 1.46894559e-01f, 1.28844142e-01f, -2.24542797e-01f, -1.74238354e-01f, -4.27661687e-02f, -1.63416013e-01f, -3.15212250e-01f,
  -6.06558323e-02f, -1.19650491e-01f, 7.55108073e-02f, 1.90029405e-02f, -9.73956287e-02f, 6.77868053e-02f, -1.08584411e-01f, 1.71954930e-02f, 5.95766790e-02f, 5.11719920e-02f,
  9.10358503e-02f, 3.92488278e-02f, -3.79859284e-02f, -4.88882810e-02f, 1.14953611e-03f, -7.44051710e-02f, 8.17171112e-02f, 3.91626246e-02f, 8.14892235e-04f, 2.21796092e-02f,
  5.32687036e-03f, 9.41952467e-02f, -2.21892912e-02f, -1.12726428e-02f, 1.24653436e-01f, 3.71728837e-02f, 9.31375027e-02f, 3.92978862e-02f, 6.00849185e-03f, 3.38875577e-02f,
  -2.65758485e-01f, 7.65959499e-03f, -1.37011409e-01f, 5.94507903e-02f, -6.84489012e-02f, 4.02217731e-02f, -6.56795427e-02f, 1.41063170e-03f, -2.39433553e-02f, 8.02013353e-02f,
  8.10162723e-02f, 2.14439072e-03f, -1.31881133e-01f, 8.55405480e-02f, 5.76398186e-02f, 3.58458199e-02f, 5.63399643e-02f, -2.94494927e-02f, 7.72987530e-02f, 7.93053433e-02f,
  7.23136812e-02f, 7.95964524e-02f, -1.97691798e-01f, -2.41592117e-02f, -6.29815087e-02f, -2.41433680e-01f, -3.24861377e-01f, -1.47493156e-02f, -2.23463774e-01f, -3.33067954e-01f,
  6.32905424e-01f, -3.43507499e-01f, -3.12465459e-01f, -5.95913529e-02f, -8.67340192e-02f, -1.33037880e-01f, -1.94992855e-01f, -7.84430876e-02f, -6.29941523e-02f, -6.90430030e-02f,
  5.66305080e-03f, 7.88557604e-02f, -1.30345020e-02f, -1.40507430e-01f, 1.24451164e-02f, -2.59251207e-01f, -2.77432859e-01f, -5.93792535e-02f, 6.92620948e-02f, -5.37749194e-02f,
  2.08259886e-03f, 3.76517535e-03f, -3.94675545e-02f, -8.93017426e-02f, -2.18901560e-01f, -1.41507447e-01f, -1.78939611e-01f, -2.64854342e-01f, -2.38053709e-01f, -3.99006307e-01f,
  -5.61384678e-01f, -6.30516484e-02f, 9.19900090e-02f, -5.46618029e-02f, 5.32578118e-02f, 7.51999244e-02f, -4.32902984e-02f, 2.99030216e-04f, 1.10697232e-01f, -1.06541738e-01f,
  1.05940495e-02f, -5.95749654e-02f, -1.00775950e-01f, -6.52938732e-04f, -4.40946817e-02f, 5.04850037e-02f, 1.17960863e-01f, 7.33498335e-02f, -3.71114090e-02f, -7.63084367e-02f,
  -5.96401356e-02f, 3.55159938e-02f, 4.07879017e-02f, 1.42527148e-02f, 1.88840851e-01f, 1.87528655e-01f, -1.96753349e-02f, 1.50215864e-01f, 1.24719478e-01f, 9.92970541e-02f,
  -1.83162645e-01f, 3.30447257e-02f, 2.45687012e-02f, 1.15469933e-01f, 2.75783092e-01f, 1.29138649e-01f, -4.99321930e-02f, -2.30489951e-02f, -2.22613267e-03f, 9.49334130e-02f,
  2.68144514e-02f, 8.35865387e-04f, 7.43415728e-02f, 1.30157307e-01f, -4.57328670e-02f, -1.41100019e-01f, -7.43673444e-02f, -1.69621594e-02f, -3.51381190e-02f, -7.40661025e-02f,
  1.74933895e-02f, -2.08950400e-01f, -1.37873858e-01f, -2.01428980e-01f, -1.03019759e-01f, -1.40831973e-02f, -7.76507184e-02f, -1.34253830e-01f, -1.59456089e-01f, -1.28523812e-01f,
  -2.54267216e-01f, 1.82420477e-01f, 1.12127088e-01f, -6.83467835e-02f, -7.09391758e-02f, 2.01303773e-02f, -3.57435606e-02f, 1.97947100e-02f, -9.94974226e-02f, -1.20925508e-01f,
  1.31031843e-02f, 4.29642349e-02f, -4.54730466e-02f, -2.05146931e-02f, 2.16724426e-01f, 9.84641388e-02f, 2.06118986e-01f, 3.43703255e-02f, 1.48139624e-02f, -9.99818742e-02f,
  -7.29112551e-02f, 1.86329797e-01f, 1.26620650e-01f, 2.68494010e-01f, 2.32979491e-01f, 9.48574543e-02f, 5.03526814e-02f, 2.17126571e-02f, 8.72248709e-02f, 2.61286050e-01f,
  2.42837995e-01f, -6.11024559e-01f, -1.75642878e-01f, 4.94377576e-02f, -1.26966029e-01f, 3.69587019e-02f, -3.17667633e-01f, 9.47035179e-02f, 2.58390699e-02f, -4.45028126e-01f,
  -3.71021181e-01f, -5.41536622e-02f, -2.14153007e-01f, -5.91085628e-02f, 9.93118286e-02f, -4.10933465e-01f, -2.41095036e-01f, 1.85817510e-01f, 5.99230230e-01f, 2.95606911e-01f,
  -5.05789295e-02f, 1.42442867e-01f, 4.20504957e-01f, 1.53062239e-01f, -1.91520765e-01f, 3.65970694e-02f, -3.65506858e-01f, -1.87093318e-01f, -2.06427634e-01f, -4.69668597e-01f,
  -2.46945888e-01f, -1.85821414e-01f, 1.22183576e-01f, 7.68650174e-02f, -2.98163053e-02f, 5.15618771e-02f, -1.69207882e-02f, 1.64907485e-01f, 7.06410855e-02f, -2.52712995e-01f,
  -1.42523915e-01f, 8.71853083e-02f, -2.20607221e-02f, -5.72849512e-02f, 6.47930289e-03f, 1.00738525e-01f, 8.31458867e-02f, 1.35877386e-01f, 2.50052623e-02f, -1.30402744e-01f,
  -1.99556544e-01f, -1.29579574e-01f, 8.34575072e-02f, 6.14548381e-03f, 2.35437155e-02f, 1.26056775e-01f, -4.56001014e-02f, 7.15395287e-02f, 8.03699791e-02f, -2.99526274e-01f,
  4.44199480e-02f, -1.38485551e-01f, 8.48712549e-02f, 8.82007256e-02f, 9.58290324e-02f, 2.45162603e-02f, 8.58736709e-02f, -7.97597915e-02f, 7.61476830e-02f, 6.07660934e-02f,
  -4.89968024e-02f, 2.78962012e-02f, 7.16612190e-02f, -1.28270492e-01f, -1.49592847e-01f, 5.07981107e-02f, -1.12631693e-02f, -9.30946320e-02f, -8.87561068e-02f, -5.91763388e-03f,
  8.55753496e-02f, 6.37916774e-02f, 3.54396366e-02f, 5.49680442e-02f, -3.54594626e-02f, -3.69161018e-03f, 6.28178418e-02f, -1.17395278e-02f, 1.07142001e-01f, 5.42126633e-02f,
  2.00864244e-02f, 7.10545899e-03f, -2.52849728e-01f, 6.81632832e-02f, 8.66176002e-03f, -1.29368588e-01f, -1.40337601e-01f, 1.37225673e-01f, -1.42123839e-02f, -4.61082235e-02f,
  -1.32960781e-01f, -3.16911414e-02f, -9.99904424e-02f, 6.19746745e-02f, 7.97875077e-02f, 2.18716338e-02f, -5.93986653e-04f, 4.70883809e-02f, -2.45053992e-02f, -2.12491816e-03f,
  -1.13409132e-01f, 3.22919525e-02f, 1.23673782e-01f, -3.48105654e-02f, 2.35377718e-02f, 9.28047597e-02f, 5.77093996e-02f, -1.18024191e-02f, 1.75185680e-01f, -1.97326869e-01f,
  5.32070220e-01f, 3.82722825e-01f, -2.75579631e-01f, 4.58828777e-01f, -2.11567417e-01f, -3.09166342e-01f, -3.67553830e-02f, 1.00315914e-01f, 6.47132620e-02f, 9.12113339e-02f,
  -1.00866847e-01f, -3.40092838e-01f, -1.49274692e-01f, -2.93904185e-01f, -1.24313876e-01f, 6.14096411e-02f, -3.24756885e-03f, -3.58612329e-01f, -5.41749477e-01f, -4.01617169e-01f,
  -2.25290716e-01f, 8.56773481e-02f, 7.98551887e-02f, -7.23638535e-02f, -1.92220472e-02f, -2.11423978e-01f, 1.16542235e-01f, 2.77224090e-02f, -2.94310182e-01f, -1.25162169e-01f,
  -2.04130813e-01f, 2.10834026e-01f, -2.56456524e-01f, -1.04717851e-01f, 1.18795976e-01f, -7.06475452e-02f, -2.56380979e-02f, 7.14260992e-03f, -5.36128692e-02f, 3.70987095e-02f,
  2.82947645e-02f, -1.64958611e-01f, -1.31280333e-01f, -2.74801046e-01f, 1.41040599e-02f, -6.60536736e-02f, -2.86241323e-02f, -1.61041111e-01f, 3.53278406e-02f, -1.37629002e-01f,
  -1.00857675e-01f, -2.95151118e-02f, 8.12418088e-02f, 1.10860402e-03f, -5.62057421e-02f, -1.38514996e-01f, -2.24653613e-02f, -2.18216851e-01f, -9.19020474e-02f, 1.88949168e-01f,
  2.35313792e-02f, -1.06991147e-05f, 6.09562695e-02f, 1.54038683e-01f, 7.62492195e-02f, 1.09726809e-01f, 1.27238836e-02f, -1.12791672e-01f, -1.40241101e-01f, -7.52893537e-02f,
  -6.42138869e-02f, -3.49238105e-02f, 1.59207880e-02f, 1.93059202e-02f, 6.34879768e-02f, -7.15546906e-02f, -2.00968944e-02f, -1.39915664e-03f, -1.62204690e-02f, 8.55116174e-03f,
  -5.13914786e-02f, -2.68067922e-02f, -4.30182926e-02f, -6.68918490e-02f, -6.45102412e-02f, -2.23162863e-02f, -5.03119081e-02f, -2.03213513e-01f, -3.44123244e-02f, -3.43540981e-02f,
  1.10809624e-01f, -6.67479858e-02f, 6.94044381e-02f, -8.81675035e-02f, -3.72000486e-02f, -1.16777614e-01f, 6.71091080e-02f, -4.43957895e-02f, -8.17459896e-02f, -1.44894525e-01f,
  -1.71575978e-01f, -2.98913140e-02f, 7.63743594e-02f, -1.72903791e-01f, -1.56365931e-01f, 4.49735671e-02f, 1.22936517e-01f, -1.76847756e-01f, -1.03333354e-01f, -1.99271217e-02f,
  1.90090686e-01f, 1.38179705e-01f, 1.80205762e-01f, 4.72866632e-02f, 1.61644518e-02f, 4.47333343e-02f, -3.41962129e-02f, -1.99877173e-01f, -1.82368994e-01f, 2.82182515e-01f,
  1.95240844e-02f, -2.63849884e-01f, -1.62840664e-01f, 1.76613539e-01f, 3.79631102e-01f, -4.12256233e-02f, -2.62434572e-01f, -3.92459363e-01f, -2.87101120e-02f, 5.80972694e-02f,
  3.45740258e-03f, 2.79123057e-02f, -3.22733521e-01f, -2.40179777e-01f, -4.68209624e-01f, -1.06508031e-01f, 9.29683447e-02f, -6.95380792e-02f, 1.54288590e-01f, 3.19314063e-01f,
  4.02847528e-01f, 4.86485332e-01f, 2.54709184e-01f, -2.60318052e-02f, 2.52790868e-01f, 2.57271677e-01f, 2.31792361e-01f, 2.17338443e-01f, 8.88436218e-04f, 2.45951399e-01f,
  8.08423609e-02f, -2.43962809e-01f, -3.84795777e-02f, 8.39871615e-02f, 3.50404494e-02f, -1.79443881e-01f, -7.20198676e-02f, -2.46055186e-01f, -2.31760740e-01f, -8.54847282e-02f,
  6.54480830e-02f, -1.38480723e-01f, -3.15215945e-01f, 5.40858023e-02f, 1.02104373e-01f, -2.11045355e-01f, -1.49355680e-01f, -4.59344208e-01f, -3.99965137e-01f, -1.74574554e-01f,
  2.23241430e-02f, 2.44794771e-01f, -1.19012445e-01f, -2.57648230e-01f, -4.43515658e-01f, 1.13726832e-01f, -1.02933660e-01f, -1.65980443e-01f, -3.67302388e-01f, 1.47904148e-02f,
  -4.39272001e-02f, -3.45484130e-02f, -4.40557152e-02f, -9.81480628e-03f, 1.07113279e-01f, 1.20816365e-01f, 1.91157439e-03f, -8.34653620e-03f, 2.00677291e-02f, 1.44403595e-02f,
  -1.99900925e-01f, -4.65930738e-02f, -1.02314115e-01f, -1.83101017e-02f, -3.55130923e-03f, 5.34731848e-03f, -4.44299495e-03f, 1.86525621e-02f, 2.73651048e-03f, -8.62588733e-02f,
  6.17359169e-02f, -8.28990713e-03f, 1.02066919e-01f, -2.17709631e-01f, 4.63905595e-02f, -1.95186496e-01f, 1.88980684e-01f, 2.57547703e-02f, 2.26748851e-03f, 1.45698637e-01f,
  2.90921539e-01f, -2.54506409e-01f, 6.66100383e-02f, 6.55737519e-02f, 1.57982737e-01f, -2.25672452e-03f, -3.13451700e-02f, -9.45179909e-02f, -1.90178230e-01f, -2.25847349e-01f,
  -7.20343292e-02f, -2.65568674e-01f, -2.04210311e-01f, -3.26860473e-02f, 1.17346875e-01f, 1.62842311e-02f, 1.20816283e-01f, 1.24092437e-01f, -2.84259748e-02f, 1.59349330e-02f,
  -2.54530665e-02f, 1.89674020e-01f, 3.24955851e-01f, -2.01512873e-01f, 2.54721791e-02f, 2.39615127e-01f, 2.99774408e-01f, 2.02789903e-01f, -1.38967305e-01f, 3.30928534e-01f,
  2.23762736e-01f, 3.57578516e-01f, -1.33613050e-01f, 1.09644189e-01f, 1.72416851e-01f, 2.02406764e-01f, 3.88154477e-01f, 2.13601813e-01f, 8.09111074e-02f, 1.50021827e-02f,
  -5.49525917e-02f, -2.33169064e-01f, -1.25216052e-01f, -2.40731925e-01f, -3.21712345e-02f, 3.84474508e-02f, -4.74929437e-02f, -1.89296126e-01f, -4.94733192e-02f, 1.77851748e-02f,
  8.88854116e-02f, 2.69054979e-01f, 7.61221349e-02f, -2.67839991e-02f, -7.05202147e-02f, -7.88001493e-02f, 1.05892457e-01f, 1.33296713e-01f, -1.15850598e-01f, -2.28106752e-01f,
  -1.17762156e-01f, 8.02038684e-02f, -2.37763181e-01f, -2.48866543e-01f, 1.47501938e-02f, -2.28021480e-02f, 1.05066486e-02f, 3.67297716e-02f, 1.13459732e-02f, -1.99279352e-03f,
  -1.06455147e-01f, 3.37899961e-02f, 1.47551449e-03f, 7.17295185e-02f, 2.22641543e-01f, -1.73618309e-02f, -1.50145769e-01f, -3.79534885e-02f, -1.35529965e-01f, -2.24388406e-01f,
  -1.51604936e-01f, 2.09161025e-02f, 6.66681584e-03f, 8.26123729e-02f, -7.73841217e-02f, -1.51579171e-01f, -5.25362156e-02f, -1.55120879e-01f, -8.10895562e-02f, -5.70272021e-02f,
  -8.63624969e-04f, -2.58368161e-02f, 1.52463866e-02f, 1.90532170e-02f, 5.29273227e-02f, 7.09668770e-02f, 1.56224445e-01f, 1.40594721e-01f, 8.94767568e-02f, 2.08699912e-01f,
  5.15082516e-02f, 1.38847023e-01f, 2.60007381e-01f, 1.60451055e-01f, 1.89679787e-02f, 6.61582798e-02f, 9.24268812e-02f, 3.21434028e-02f, 1.05665304e-01f, 1.25435606e-01f,
  -8.92584585e-03f, 5.25382943e-02f, 9.67302993e-02f, 8.08753893e-02f, -2.33923141e-02f, -1.00036703e-01f, -8.83916914e-02f, 8.47601593e-02f, -3.40320431e-02f, 6.11549243e-02f,
  4.57495153e-01f, 5.10128960e-02f, -9.68463197e-02f, -1.11214161e-01f, 1.05465591e-01f, 2.74370145e-02f, 8.39910060e-02f, -2.50021201e-02f, 1.59451723e-01f, 7.34340772e-02f,
  6.60713688e-02f, -5.67333680e-03f, 2.15215683e-01f, 4.54458408e-03f, 8.41830075e-02f, 9.31624919e-02f, 5.38525432e-02f, -3.73886228e-02f, -4.22825068e-02f, 1.28577102e-03f,
  2.00999522e-04f, 1.88941639e-02f, 9.27393064e-02f, 6.81640655e-02f, -8.80785566e-03f, -3.14962678e-02f, 9.05354545e-02f, 2.59603038e-02f, 9.39095113e-03f, 3.47613662e-01f,
  -2.51240790e-01f, 1.36687130e-01f, -3.53493690e-01f, -3.17435116e-01f, -3.54629815e-01f, -3.08868736e-01f, 4.24461663e-02f, -2.44894385e-01f, -3.36883396e-01f, -5.89758530e-02f,
  -2.83318423e-02f, 2.28609711e-01f, 5.56551293e-02f, 1.74418882e-01f, 1.87821835e-01f, -2.20786817e-02f, -3.93794701e-02f, 4.71410565e-02f, 2.08795235e-01f, 1.08190909e-01f,
  1.52193114e-01f, -1.91676524e-02f, -3.45914513e-02f, -1.56218454e-01f, -1.74164638e-01f, 8.59538466e-02f, -2.50498801e-01f, -1.82302296e-01f, -1.76949054e-02f, -2.24253222e-01f,
  3.34059477e-01f, -4.61691499e-01f, -1.49019301e-01f, -5.27869724e-02f, -3.75024602e-02f, -4.01825234e-02f, -8.91901404e-02f, -1.87618941e-01f, -5.27625605e-02f, -4.82788831e-02f,
  -1.37427628e-01f, -1.18783973e-01f, -9.31127090e-03f, -1.05300425e-02f, -4.88509014e-02f, 2.92482655e-02f, 5.81472069e-02f, -1.11983210e-01f, -7.47791454e-02f, -1.79936253e-02f,
  6.44830316e-02f, -2.06158951e-01f, -1.25079960e-01f, -1.00254901e-01f, -8.75402614e-02f, -1.15021244e-02f, -6.39455244e-02f, -1.14736207e-01f, -1.80351987e-01f, -5.26765399e-02f,
  -2.60620043e-02f, 4.02751267e-02f, 1.05529083e-02f, 7.51768425e-02f, 2.01838166e-02f, 6.16430491e-03f, 3.83998267e-02f, 1.03151619e-01f, 3.87000502e-03f, 1.27710372e-01f,
  -1.08373195e-01f, 3.15218121e-02f, 3.07910033e-02f, -1.53192729e-01f, -1.06580723e-02f, -1.54445708e-01f, -6.98658898e-02f, 4.09722589e-02f, -1.06833704e-01f, -1.27056420e-01f,
  -7.28156641e-02f, -9.05721188e-02f, -2.96720471e-02f, 4.23580147e-02f, -1.25225708e-01f, 2.00764872e-02f, -9.27656144e-03f, 4.08582911e-02f, -2.85824053e-02f, -1.47798344e-01f,
  4.09641743e-01f, -1.92015290e-01f, 7.50720873e-03f, -2.65257880e-02f, -8.52817893e-02f, -4.43021432e-02f, -1.17414780e-01f, -1.00148536e-01f, -6.64290935e-02f, -1.19232526e-02f,
  -6.92684352e-02f, 2.21279380e-03f, 7.89226070e-02f, 8.99790302e-02f, 1.66445509e-01f, 3.17679122e-02f, 1.07820764e-01f, -3.77314463e-02f, -1.03533871e-01f, -4.41753343e-02f,
  1.30336974e-02f, -9.09886062e-02f, 2.59720057e-01f, 8.03328604e-02f, -6.55827373e-02f, 9.08285156e-02f, 2.35360190e-01f, 6.77191932e-03f, 1.07776292e-01f, 2.24737495e-01f,
  -1.26071677e-01f, 9.06421840e-02f, -7.98663557e-01f, 1.51183903e-01f, 8.38494375e-02f, -3.15782353e-02f, 2.50373721e-01f, 2.41864175e-01f, 2.58286834e-01f, 1.44774973e-01f,
  1.76938787e-01f, 1.76447347e-01f, 9.01437551e-02f, 9.18400586e-02f, 2.49568690e-02f, 1.44385956e-02f, 7.92656541e-02f, -3.41777861e-01f, -2.81755000e-01f, 1.40507475e-01f,
  4.28878009e-01f, 2.01272666e-01f, -8.19409713e-02f, 3.97887453e-02f, 8.42375904e-02f, 5.01376130e-02f, -6.23469017e-02f, -1.13860495e-01f, -1.12824976e-01f, -3.92942756e-01f,
  -4.07731086e-01f, -2.27189809e-01f, -3.44259664e-02f, -7.80169815e-02f, -3.02941620e-01f, -2.61143595e-01f, -1.49778217e-01f, -3.55098397e-01f, -2.18323059e-02f, -9.89840031e-02f,
  -1.94449529e-01f, -4.82286587e-02f, 4.23379317e-02f, -6.45796722e-03f, -1.09804552e-02f, -2.01653820e-02f, -1.38429347e-02f, -2.32626140e-01f, -2.06562996e-01f, -3.27199996e-01f,
  7.63169453e-02f, -2.83393770e-01f, -4.42859352e-01f, -8.64556804e-02f, -2.21207425e-01f, -1.84455559e-01f, -2.61504024e-01f, -3.31243694e-01f, -2.93983459e-01f, -3.53804469e-01f,
  1.67438127e-02f, -6.76659793e-02f, -6.72446340e-02f, 4.41707261e-02f, 2.18045875e-01f, 4.95947339e-02f, 3.15251313e-02f, 3.71435541e-03f, 2.53497977e-02f, -1.29902894e-02f,
  1.51106352e-02f, 7.98760634e-03f, -7.54717663e-02f, 1.49803637e-02f, 7.12841749e-02f, -6.19795769e-02f, -7.84424767e-02f, 2.32202429e-02f, -1.82109848e-02f, 3.36747319e-02f,
  4.70624231e-02f, -3.67433727e-02f, 8.23890269e-02f, -2.48212423e-02f, -6.91518486e-02f, -3.44441794e-02f, 4.36109044e-02f, -6.15345910e-02f, -7.98467398e-02f, 1.32511020e-01f,
  3.66529852e-01f, 1.03496552e-01f, -1.06998980e-02f, -1.36998286e-02f, -2.43173137e-01f, -4.92337486e-03f, 7.50921965e-02f, -2.33359914e-02f, 1.97677277e-02f, -7.07649579e-03f,
  -4.46858481e-02f, -1.68352388e-02f, 1.60501406e-01f, -4.55699377e-02f, 2.35262103e-02f, 1.11774050e-01f, 1.44973695e-01f, -6.57356977e-02f, -1.47431577e-02f, -1.42410606e-01f,
  1.44977942e-01f, 5.56965582e-02f, -1.69631973e-01f, -5.07454984e-02f, 7.09534809e-02f, 1.21968627e-01f, -1.05233587e-01f, -9.69627351e-02f, -9.45391208e-02f, 6.20829500e-02f,
  4.52916443e-01f, 4.56056505e-01f, 2.85649836e-01f, 3.93735319e-01f, 3.06274205e-01f, 3.45197409e-01f, 2.70663649e-01f, 8.58423114e-02f, 1.59629613e-01f, 1.20112404e-01f,
  3.16430122e-01f, 1.57960638e-01f, 1.64697051e-01f, 1.81919947e-01f, 1.97015002e-01f, 1.15521967e-01f, -4.23203222e-02f, 3.06876209e-02f, 1.08057193e-01f, 8.65469873e-02f,
  1.82820290e-01f, 5.90487272e-02f, 1.74072012e-01f, 1.24899819e-01f, 2.93595698e-02f, 1.33307427e-01f, 1.26089856e-01f, 2.51558155e-01f, 2.38795742e-01f, 1.59372017e-02f,
  -9.43663716e-02f, 8.42189938e-02f, -9.76685658e-02f, -3.50933410e-02f, 3.97638902e-02f, -1.76775664e-01f, -9.01430547e-02f, -2.06015989e-01f, -8.54634568e-02f, -1.44730881e-01f,
  -9.29879677e-03f, -6.62810132e-02f, 5.23741879e-02f, -1.59372166e-01f, -1.10685907e-01f, -1.56284824e-01f, -2.17479855e-01f, -7.82694072e-02f, 2.27396353e-03f, -4.27143183e-03f,
  8.25521573e-02f, 8.92512426e-02f, 3.81530561e-02f, -2.75070351e-02f, 9.56376120e-02f, -8.19557905e-03f, 5.56486100e-02f, -8.46582130e-02f, 4.92223315e-02f, -5.18988073e-03f,
  9.42571368e-03f, 5.00651598e-02f, 1.55108646e-01f, -2.11508162e-02f, -9.78030497e-04f, -7.91694447e-02f, -9.21381935e-02f, 8.37040991e-02f, 4.01460379e-02f, -5.01602627e-02f,
  -1.18824109e-01f, 4.57463264e-02f, 7.17813298e-02f, -2.15423875e-03f, 4.06145826e-02f, 8.63744915e-02f, -2.61241850e-02f, -2.85548400e-02f, -2.20111217e-02f, -1.25789866e-01f,
  -2.32053455e-02f, -1.23362698e-01f, -1.84183568e-02f, -9.76575911e-02f, -2.21541747e-01f, -4.58708145e-02f, 1.19474772e-02f, -2.56520212e-02f, -1.06333969e-02f, -3.00008170e-02f,
  -3.10393333e-01f, 1.77174315e-01f, -1.90419883e-01f, -1.15209289e-01f, 4.08407561e-02f, -1.19608127e-01f, 1.19027041e-01f, -1.66535109e-01f, -1.49262413e-01f, -5.17864786e-02f,
  2.66229697e-02f, -8.85150582e-02f, -6.27368763e-02f, -2.00950846e-01f, -1.26214579e-01f, -1.65375993e-01f, -1.01985179e-01f, -7.32233077e-02f, -1.34090021e-01f, -2.00874224e-01f,
  -1.34338558e-01f, -8.27713013e-02f, -1.23668857e-01f, -2.50980980e-03f, 1.12794256e-02f, -9.85352620e-02f, -1.72806635e-01f, -1.05942138e-01f, -1.30838184e-02f, -4.93484847e-02f,
  -5.21011353e-01f, -3.90795231e-01f, -4.00023796e-02f, -5.28035760e-01f, 1.37440458e-01f, 3.95548522e-01f, 4.89129812e-01f, 2.32114181e-01f, -4.31128256e-02f, 3.73739637e-02f,
  -9.36866477e-02f, -7.50404969e-02f, -3.47470015e-01f, 2.95703765e-02f, -6.19007312e-02f, 4.90727760e-02f, -1.98019728e-01f, -1.19577929e-01f, 3.37335408e-01f, 5.55781364e-01f,
  2.15562910e-01f, -1.92952216e-01f, -1.74673632e-01f, -1.73200011e-01f, -2.14407295e-01f, -7.20270649e-02f, -2.98237890e-01f, -2.80600131e-01f, -5.60760200e-02f, -3.94013554e-01f,
  2.39472836e-01f, -2.14262784e-01f, 3.78955267e-02f, -2.75084347e-01f, -1.72065154e-01f, -8.63477960e-02f, 9.92356390e-02f, -2.33228400e-01f, -7.97570199e-02f, -9.89866555e-02f,
  -1.28155515e-01f, -9.48789343e-02f, -9.70069095e-02f, -4.49102595e-02f, 2.17061490e-02f, 7.32789859e-02f, -1.82925180e-01f, -1.87381521e-01f, -8.94443095e-02f, 7.65635371e-02f,
  -1.45671964e-01f, -8.85125846e-02f, -6.77253604e-02f, 6.66766241e-02f, 7.96284750e-02f, -2.46537048e-02f, 1.14489332e-01f, 7.98943564e-02f, 8.06593597e-02f, -2.38813348e-02f,
  2.28062794e-02f, -1.95473284e-02f, 8.17409903e-02f, 2.05114149e-02f, -1.28907477e-03f, 4.37424816e-02f, 1.87498925e-04f, -1.09278001e-01f, 1.52667286e-02f, -6.72411397e-02f,
  -7.16199502e-02f, -4.83298041e-02f, 7.33796582e-02f, -5.18371910e-02f, -6.35953471e-02f, -6.41924292e-02f, 6.36625886e-02f, -5.27371839e-02f, -9.97892320e-02f, -1.13340423e-01f,
  -4.00287770e-02f, 5.15143126e-02f, 2.83975061e-03f, -8.91210698e-03f, -6.83377907e-02f, -4.83728573e-02f, -8.34753886e-02f, -4.02170792e-02f, 6.15829267e-02f, -2.52267234e-02f,
  -1.02913510e-02f, -6.63314089e-02f, -9.55845565e-02f, -9.35271755e-02f, -1.20809816e-01f, -9.30234268e-02f, -1.42253205e-01f, 4.85747674e-04f, -1.82516593e-02f, 7.56443143e-02f,
  1.61162898e-01f, 6.07447065e-02f, -1.00003339e-01f, -3.72007340e-02f, 2.09077686e-01f, 1.25883132e-01f, -4.61884886e-02f, -1.02365687e-01f, -5.15278764e-02f, 3.47977802e-02f,
  -4.58132364e-02f, 4.82443497e-02f, 2.67207287e-02f, 1.36957258e-01f, 1.81764543e-01f, 9.64226425e-02f, 1.33221701e-01f, 2.52780080e-01f, 1.67803660e-01f, 9.76496562e-02f,
  -5.79903364e-01f, -4.07998353e-01f, 3.17707777e-01f, 1.18998989e-01f, 3.05198401e-01f, 1.78801641e-01f, 2.04895571e-01f, 5.41568479e-05f, 1.09812811e-01f, -1.44835874e-01f,
  -2.53752142e-01f, -2.99434274e-01f, -1.44527242e-01f, -2.00022861e-01f, -1.57575533e-01f, 5.29033877e-02f, 3.71810228e-01f, 2.19594270e-01f, 2.65134692e-01f, 1.28535867e-01f,
  8.79209563e-02f, 1.34057507e-01f, 1.90618746e-02f, 6.13923110e-02f, -5.44609465e-02f, 6.83303829e-03f, 1.43990278e-01f, 1.29900813e-01f, -4.16241251e-02f, 3.72382663e-02f,
  4.85718995e-02f, -1.98400691e-01f, 4.77820635e-02f, -7.73604214e-02f, 2.08679270e-02f, -5.19305542e-02f, 5.72848320e-02f, 1.33863268e-02f, 1.54006764e-01f, 1.53508887e-01f,
  1.50512516e-01f, 2.58742347e-02f, 6.95124865e-02f, 8.50767121e-02f, 1.50593579e-01f, 4.13015485e-02f, 6.14470392e-02f, 8.81581679e-02f, 8.71984065e-02f, -1.24369478e-02f,
  -6.09125607e-02f, 3.85988429e-02f, 2.20213130e-01f, 1.16911151e-01f, -9.83045250e-02f, 8.98899958e-02f, 4.28104028e-02f, -4.67974991e-02f, 1.65396288e-01f, -4.33793152e-03f,
  1.33665696e-01f, -7.80747831e-02f, 1.37878880e-02f, -8.76637846e-02f, -3.93965393e-02f, 9.55896731e-03f, 1.78399518e-01f, 7.49781132e-02f, 2.74352394e-02f, -1.30688548e-02f,
  2.02376153e-02f, -5.01362272e-02f, 9.63152125e-02f, 4.57023270e-02f, 5.07226177e-02f, -5.14821103e-03f, -2.44864076e-02f, 1.08236792e-02f, 4.96336073e-02f, -9.38169807e-02f,
  6.71012253e-02f, 2.99539622e-02f, 1.08627528e-01f, 1.42635956e-01f, 1.25300810e-01f, 9.43067223e-02f, 8.93141627e-02f, 3.22917774e-02f, -1.88422631e-02f, 5.48101626e-02f,
  3.36758308e-02f, -7.72925243e-02f, -1.09616563e-01f, -2.85710156e-01f, 4.93310243e-02f, 3.63928615e-03f, -2.50812531e-01f, -8.64471346e-02f, 1.36928588e-01f, 1.89670563e-01f,
  5.00195287e-02f, 3.60051244e-02f, -6.03667786e-03f, -4.56312187e-02f, 1.85752481e-01f, 1.94502599e-03f, -7.91829899e-02f, -6.05678074e-02f, -2.00292398e-03f, -3.39263529e-02f,
  -1.31631028e-02f, -8.60407203e-03f, 1.72564790e-01f, -1.45464092e-02f, -9.50945988e-02f, 9.64955464e-02f, 9.58516449e-02f, 1.55293001e-02f, 1.44084528e-01f, 9.40150693e-02f,
  -1.39436319e-01f, 3.73455942e-01f, 3.65225166e-01f, -2.29535803e-01f, 1.29410475e-01f, 1.27229169e-01f, 1.35710938e-02f, -1.08862855e-01f, -5.63337542e-02f, 7.36927092e-02f,
  2.39316300e-01f, -1.78091571e-01f, -1.24553099e-01f, -2.69355565e-01f, -4.16590631e-01f, -1.41696036e-01f, -2.81996906e-01f, -4.10359293e-01f, -4.35622066e-01f, -2.42665231e-01f,
  -1.80340871e-01f, -2.04257533e-01f, -4.11744028e-01f, -3.08723569e-01f, -7.69338012e-02f, -9.63111222e-02f, 1.70699283e-02f, -8.88672099e-02f, 6.46718666e-02f, -6.26491979e-02f,
  8.15752819e-02f, 2.96714276e-01f, -1.34410694e-01f, -2.10184436e-02f, 6.88314587e-02f, -1.79915279e-02f, 5.79924602e-03f, 7.89076686e-02f, 1.96317360e-02f, 1.44279907e-02f,
  1.74938977e-01f, 9.57458019e-02f, 4.73489054e-02f, 4.68473183e-03f, -5.27054816e-02f, -2.99328510e-02f, -1.79835975e-01f, -1.20633103e-01f, -3.36547829e-02f, 1.64140403e-01f,
  4.42980602e-02f, 1.66775331e-01f, 5.56722097e-02f, 9.01666582e-02f, 1.35491984e-02f, -1.13989793e-01f, 1.68668196e-01f, 1.20163471e-01f, 6.24419227e-02f, 1.93995927e-02f,
  -1.05897695e-01f, 5.85366525e-02f, -7.09382584e-03f, 4.68957946e-02f, -1.36275068e-01f, 7.52722397e-02f, -9.07176211e-02f, -3.13834511e-02f, -6.25461936e-02f, 5.27159171e-03f,
  -4.37635407e-02f, -2.06415597e-02f, -3.03090103e-02f, -1.41211510e-01f, -9.42771584e-02f, -6.56768307e-02f, -5.21410778e-02f, -1.89099580e-01f, -1.33340836e-01f, -5.64885177e-02f,
  -1.00748457e-01f, -6.49397820e-02f, -3.98957133e-02f, -1.36175528e-01f, 6.70118257e-02f, -8.71777087e-02f, 6.79696212e-03f, -7.43791014e-02f, -1.16906039e-01f, -5.99281602e-02f,
  -2.37687841e-01f, 1.42433465e-01f, -1.28365979e-01f, -1.37242585e-01f, 2.67398041e-02f, 1.02147982e-01f, 4.78171036e-02f, -2.78120115e-02f, 5.97711578e-02f, -1.15307763e-01f,
  9.19568837e-02f, -4.09206636e-02f, 3.76820303e-02f, -9.26784649e-02f, -1.39039010e-01f, -3.33517157e-02f, -1.83408856e-01f, -1.06706314e-01f, 1.91041455e-03f, 3.55864875e-02f,
  -1.14520036e-01f, -1.23332672e-01f, -3.08214605e-01f, -2.06370384e-01f, -8.70115235e-02f, -2.77859390e-01f, -1.65886611e-01f, -1.16434105e-01f, -2.48032749e-01f, -3.20633918e-01f,
  3.04440647e-01f, 3.21826100e-01f, -2.24834874e-01f, 3.75344083e-02f, -1.41238049e-01f, 1.44095384e-02f, 3.08958381e-01f, 2.69900501e-01f, 1.17771134e-01f, 2.76978284e-01f,
  1.22785665e-01f, -3.48855883e-01f, -1.94400951e-01f, -2.51513988e-01f, -1.27848417e-01f, 5.63301072e-02f, -1.01623878e-01f, -4.35680807e-01f, -5.02683282e-01f, -2.45565355e-01f,
  -1.93068311e-01f, -1.26488969e-01f, -1.90492183e-01f, -1.75132275e-01f, -1.09047510e-01f, -3.67093623e-01f, -1.33461997e-01f, -1.34623930e-01f, -1.75096586e-01f, -3.23658168e-01f,
  -3.21110517e-01f, 1.76101699e-01f, -1.21828027e-01f, -4.63308915e-02f, 5.91122210e-02f, 7.11090490e-02f, 6.73816800e-02f, 2.87121944e-02f, 2.05932409e-01f, 7.79689848e-02f,
  5.31739518e-02f, 8.34086258e-03f, 5.19744493e-02f, -2.65095979e-02f, 1.31923974e-01f, -1.05085457e-02f, 2.07057774e-01f, 4.97058257e-02f, 3.68272625e-02f, 7.66960010e-02f,
  9.08645168e-02f, 1.36914670e-01f, 1.37044802e-01f, 6.42427579e-02f, 1.01401269e-01f, -5.30617684e-02f, 2.06583515e-01f, -6.53477311e-02f, -6.79023042e-02f, 1.84001222e-01f,
  -6.86402852e-03f, 3.93434763e-02f, -1.61429584e-01f, -1.88017543e-02f, 1.17214799e-01f, 1.25677302e-01f, 1.08770313e-04f, 1.65479816e-02f, -8.62854943e-02f, 5.47455139e-02f,
  1.78162381e-02f, -5.89174442e-02f, 1.12933544e-02f, -9.15913433e-02f, -2.36788288e-01f, -5.21479398e-02f, 1.14473537e-01f, 6.47061840e-02f, -1.01028895e-02f, 1.10912234e-01f,
  5.69487410e-03f, 8.52154046e-02f, -3.31724212e-02f, -2.10045464e-02f, 3.38537060e-03f, -9.38848630e-02f, -6.68102410e-03f, 8.47886205e-02f, 7.94031024e-02f, 1.18521512e-01f,
  -1.83772147e-01f, 6.94729313e-02f, 1.77090112e-02f, 2.96099391e-02f, 9.86409141e-04f, 7.25562945e-02f, -1.87011287e-01f, 1.37479017e-02f, 3.33241001e-02f, -3.35310120e-03f,
  -1.32153258e-01f, -3.20246555e-02f, 1.46637522e-02f, 1.33404553e-01f, 4.12150063e-02f, -1.02306560e-01f, 1.53403312e-01f, 4.88540605e-02f, -8.70769471e-03f, 1.01112902e-01f,
  1.16232038e-01f, 1.36877894e-01f, 1.70819730e-01f, 7.10159540e-02f, 3.61937992e-02f, -1.41470760e-01f, 1.46556748e-02f, -1.77285951e-02f, -5.84750921e-02f, 1.55242354e-01f,
  5.21081030e-01f, -3.41353208e-01f, 3.50359261e-01f, 2.41742253e-01f, -2.11594969e-01f, -8.49058628e-02f, -1.42526910e-01f, 2.17621237e-01f, 2.19804004e-01f, -6.44311011e-02f,
  -5.60273170e-01f, -4.47887570e-01f, -3.17588001e-01f, -1.00433089e-01f, -2.20968798e-02f, 3.15491289e-01f, 3.97303104e-01f, 4.39211041e-01f, 3.75749111e-01f, -1.29274395e-03f,
  -2.64530797e-02f, 2.13504791e-01f, 2.84241647e-01f, 2.40965053e-01f, 1.50937185e-01f, -5.62524684e-02f, -4.85079587e-02f, -1.06010474e-01f, -2.27277741e-01f, 3.85136515e-01f,
  -4.88976687e-02f, -1.91587970e-01f, 3.00115757e-02f, -3.56272489e-01f, -1.83805406e-01f, 2.19857246e-01f, 8.07338953e-02f, 1.80299371e-01f, -1.00831710e-01f, 2.28957742e-01f,
  -1.76481321e-01f, -4.62841988e-02f, -1.17170207e-01f, 2.64161918e-02f, 1.30508598e-02f, 5.78614995e-02f, 8.28559920e-02f, 1.02397725e-01f, 1.41637206e-01f, -1.39481336e-01f,
  -3.14115018e-01f, -2.55964398e-01f, -1.06040940e-01f, -1.99723050e-01f, -7.38731399e-02f, -2.26466283e-01f, -1.74686760e-01f, 4.12948150e-03f, -1.14729211e-01f, 3.30461472e-01f,
  -4.50313799e-02f, -1.56987719e-02f, -6.64501414e-02f, -1.00242614e-03f, 3.21631040e-03f, 7.36709917e-03f, 1.57985408e-02f, -8.41980651e-02f, -9.01286025e-03f, -1.10716168e-02f,
  2.66357753e-02f, 1.44337257e-02f, 6.99756444e-02f, -6.81760088e-02f, -1.02244332e-01f, -5.00134937e-02f, 1.18256984e-02f, -1.76505670e-01f, -2.54068375e-01f, 1.61698703e-02f,
  -9.48301107e-02f, -7.18958452e-02f, -8.00105929e-02f, -3.08013167e-02f, -2.70200279e-02f, -8.32610801e-02f, 7.00868070e-02f, -1.86331183e-01f, -1.66547105e-01f, -7.56174475e-02f,
  -3.41413394e-02f, -4.75480258e-01f, 7.66075775e-02f, -7.59733543e-02f, -3.34847458e-02f, -1.64914951e-01f, -1.92620993e-01f, -7.61871487e-02f, -5.99363633e-02f, -2.68751513e-02f,
  -1.39566660e-01f, -4.70211543e-03f, -1.30812749e-01f, -1.05195111e-02f, 2.02611312e-01f, -1.85738392e-02f, -8.99768248e-02f, 5.89309782e-02f, -4.66061523e-03f, -4.43439409e-02f,
  2.31497679e-02f, 1.64605290e-01f, 1.75304249e-01f, -7.18756914e-02f, -1.39527202e-01f, -2.21329927e-02f, -1.64261833e-02f, 1.66019395e-01f, -5.35110049e-02f, 2.51450628e-01f,
  -5.10585904e-01f, -3.74917209e-01f, 1.41231149e-01f, -2.12252498e-01f, 2.37980500e-01f, 4.72111434e-01f, 3.00787657e-01f, 2.12737262e-01f, -3.85196060e-02f, -1.11725643e-01f,
  -2.74482250e-01f, -4.07859892e-01f, -3.09735060e-01f, -1.18800513e-01f, -2.80021504e-03f, 2.81736076e-01f, 3.43620867e-01f, 2.51243711e-01f, 2.03235656e-01f, 2.71147460e-01f,
  8.23215349e-04f, -7.95830488e-02f, -3.17676902e-01f, -1.44083008e-01f, -2.38912418e-01f, -2.41830368e-02f, -6.98242858e-02f, -1.54826179e-01f, 4.64726798e-02f, -1.27658650e-01f,
  -1.55561075e-01f, -2.80407846e-01f, 2.12161988e-01f, -1.76704988e-01f, -1.31881341e-01f, -7.28598312e-02f, -2.29600146e-02f, -1.74770594e-01f, -1.46220312e-01f, 4.15511336e-03f,
  -6.44426271e-02f, -4.79014814e-02f, 2.38373596e-03f, 2.28924826e-02f, -8.36247951e-03f, 1.46157071e-02f, -8.37655589e-02f, -8.77350196e-02f, -1.51686624e-01f, -1.91453055e-01f,
  -9.40666497e-02f, 5.89918420e-02f, -7.53182471e-02f, 4.67332378e-02f, -9.01206285e-02f, 1.96957681e-03f, -1.24237500e-01f, -1.72588304e-01f, 1.89778823e-02f, -2.13791743e-01f,
  1.63042456e-01f, -3.03972717e-02f, -5.50263152e-02f, 5.09385532e-03f, -1.02494985e-01f, 8.08010399e-02f, -5.03273262e-03f, -1.54188499e-01f, -4.08946276e-02f, -3.30859274e-02f,
  -5.25760800e-02f, 5.58010079e-02f, -7.77383298e-02f, 2.35503335e-02f, -1.49075702e-01f, -6.41184226e-02f, 5.89913987e-02f, -1.19314969e-01f, -1.08574443e-01f, -6.12627156e-02f,
  -4.43373695e-02f, 7.74180889e-03f, -1.04937255e-01f, 1.11896284e-02f, -1.65052414e-02f, -7.98409730e-02f, -7.36705810e-02f, -1.14439808e-01f, -7.09370077e-02f, -1.21737942e-01f,
  -3.70048285e-01f, 2.62220651e-01f, 2.32277513e-02f, -6.10980997e-03f, -3.19470763e-02f, -1.15027502e-01f, -1.01492658e-01f, 5.92555366e-02f, -4.00978178e-02f, 1.23622464e-02f,
  5.47797233e-02f, 3.13311554e-02f, -3.41032445e-02f, 5.17566428e-02f, 2.15756387e-01f, 1.24729693e-01f, -5.53766005e-02f, 6.38763886e-04f, -1.04919495e-03f, -2.59782746e-02f,
  -2.86005326e-02f, 2.59699404e-01f, 1.91475898e-01f, 2.32729446e-02f, 9.52667296e-02f, 2.59360939e-01f, 1.48471132e-01f, 1.59954071e-01f, 1.72271311e-01f, 2.91237593e-01f,
  -3.40113461e-01f, -3.73691916e-02f, -4.13649231e-01f, -3.90264392e-01f, -1.25383630e-01f, 1.39851114e-02f, 2.30512634e-01f, 8.91407281e-02f, -1.74737886e-01f, 5.19530289e-03f,
  1.31625438e-03f, -1.62705734e-01f, -3.36269021e-01f, -5.36726490e-02f, -1.14212409e-02f, -8.73879790e-02f, -2.52052903e-01f, -1.40502006e-01f, 3.47182266e-02f, 3.91980052e-01f,
  1.26268029e-01f, -1.05017751e-01f, -1.27873495e-01f, -9.58175864e-03f, -8.38720649e-02f, -1.71094790e-01f, -2.90112227e-01f, -1.74873546e-01f, -1.35797886e-02f, -1.65420964e-01f,
  -1.08835675e-01f, -1.23193152e-01f, 4.68057534e-03f, 7.07440972e-02f, -4.08295989e-02f, 2.34506675e-03f, 9.09838155e-02f, -7.48229474e-02f, 5.56139797e-02f, -5.19208126e-02f,
  -8.76776576e-02f, 1.09020904e-01f, -3.58585678e-02f, -3.75076830e-02f, 2.40615085e-02f, 6.78551570e-02f, -6.63108230e-02f, -6.22766092e-02f, -1.34446457e-01f, 5.21408953e-02f,
  1.40882686e-01f, -7.51662552e-02f, -1.50436431e-01f, 3.10329888e-02f, 4.23772261e-02f, -1.05448879e-01f, 7.51891988e-04f, 8.38642642e-02f, -4.33096327e-02f, -1.47428006e-01f,
  5.37170991e-02f, -8.13437402e-02f, 4.20222394e-02f, 8.68697315e-02f, 1.27587644e-02f, -3.89089882e-02f, 7.36842770e-03f, 4.93496135e-02f, 2.13580262e-02f, 1.54688861e-02f,
  2.00248249e-02f, -5.66160074e-03f, -1.51432743e-02f, 3.32309529e-02f, -6.00442365e-02f, -1.34634763e-01f, 3.86839658e-02f, 3.37970294e-02f, 5.01818992e-02f, -3.55697013e-02f,
  2.26600212e-03f, 2.15308950e-03f, -1.20182121e-02f, 8.73325318e-02f, 6.16948120e-02f, -2.54324824e-02f, -1.74320731e-02f, 5.02196476e-02f, -5.34617603e-02f, -3.67086846e-03f,
  -1.05133221e-01f, 5.43857291e-02f, -1.52355760e-01f, 2.98234839e-02f, -4.49003279e-02f, 1.26793101e-01f, -3.09426039e-02f, 3.26713100e-02f, -1.02295280e-01f, 1.64829232e-02f,
  9.04385075e-02f, 1.00297429e-01f, -1.60632804e-01f, 4.99279983e-02f, 5.54905385e-02f, -2.84464587e-03f, 9.05026942e-02f, -1.20739736e-01f, -1.42743792e-02f, 3.41940001e-02f,
  -1.16292490e-02f, -5.93355345e-03f, -2.64546424e-02f, -1.21456578e-01f, 3.58095914e-02f, -8.13460499e-02f, -9.67277363e-02f, 8.04348513e-02f, -2.97729615e-02f, -2.66370382e-02f,
  3.81114274e-01f, -8.96262154e-02f, -3.18571508e-01f, 3.05818439e-01f, -6.17432930e-02f, -2.41853520e-01f, -3.78073633e-01f, -1.65941074e-01f, 6.43179044e-02f, 4.32752445e-02f,
  2.38494247e-01f, 2.05799803e-01f, 1.07170440e-01f, 1.41403407e-01f, -7.96202868e-02f, -1.20081969e-01f, -1.53228849e-01f, -9.03027579e-02f, 5.47168218e-02f, 1.35286987e-01f,
  2.36002773e-01f, 1.92685351e-01f, 1.62113816e-01f, 9.16198567e-02f, 2.11927399e-01f, 2.55152375e-01f, -9.96596068e-02f, 9.09960419e-02f, 1.48661211e-02f, 2.82517821e-01f,
  1.54723659e-01f, -6.22683316e-02f, -2.61811912e-02f, 7.90637434e-02f, 3.85101559e-03f, -1.14704438e-01f, -7.51378760e-02f, 6.48485357e-03f, 4.55703912e-03f, -1.23441376e-01f,
  1.31602678e-02f, 5.08787110e-02f, 1.79213043e-02f, -4.64747287e-02f, 4.25549643e-03f, 1.18613420e-02f, -9.29223895e-02f, -1.02841511e-01f, -2.48478521e-02f, -6.87609985e-02f,
  1.96279008e-02f, 6.63281530e-02f, -1.24693505e-01f, -2.28519738e-01f, -1.46408364e-01f, 6.57672435e-02f, -1.41865373e-01f, 3.04577313e-03f, -2.57633887e-02f, 8.19754004e-02f,
  5.15293591e-02f, -4.05470952e-02f, 1.47319257e-01f, -3.45237926e-02f, -5.57441898e-02f, -8.01106542e-02f, -1.66481938e-02f, 7.03596249e-02f, 8.20536911e-02f, 3.11129298e-02f,
  -1.80025883e-02f, 2.10788250e-02f, -7.51772597e-02f, 7.77058154e-02f, 1.89964131e-01f, 6.74850494e-02f, 6.82685450e-02f, -2.29889527e-02f, 5.78290336e-02f, -1.03600100e-02f,
  8.82701278e-02f, 2.21108664e-02f, -9.32683609e-03f, -7.41355270e-02f, 4.39717285e-02f, 9.52379480e-02f, 1.81946367e-01f, 8.24737474e-02f, 8.84945169e-02f, 8.16638395e-03f,
  -5.47779836e-02f, -1.85035110e-01f, 1.79808706e-01f, -2.75372472e-02f, -4.44365330e-02f, -1.21855177e-01f, 2.34527653e-03f, -1.80947911e-02f, 6.52262121e-02f, -6.53371960e-02f,
  -9.86221507e-02f, -1.19918063e-01f, -1.75510287e-01f, -1.97427586e-01f, -9.35850292e-03f, -6.42508343e-02f, 5.75470552e-02f, -8.86073858e-02f, -3.52059081e-02f, -6.66974708e-02f,
  -1.10579722e-01f, -7.79411793e-02f, -8.54205713e-02f, -2.17792526e-01f, -9.55003798e-02f, 6.30904958e-02f, -1.17046803e-01f, -1.17309421e-01f, -1.22247495e-01f, -2.17703089e-01f,
  3.11916787e-02f, 1.37579858e-01f, -2.50773549e-01f, 3.31571043e-01f, -1.75873220e-01f, -3.54194283e-01f, -1.13711834e-01f, 1.81957766e-01f, 1.61151588e-01f, 1.16073415e-02f,
  -3.22566003e-01f, -4.29434590e-02f, -1.97876245e-02f, 7.72690251e-02f, 2.06752159e-02f, 1.11644730e-01f, 3.18311840e-01f, 1.10503733e-01f, -1.27921641e-01f, -1.80516601e-01f,
  1.06167905e-01f, 1.65351376e-01f, 2.34729350e-01f, 1.43968895e-01f, 1.52847348e-02f, 3.83878760e-02f, 1.33577138e-01f, -6.95258752e-02f, -9.27654058e-02f, 2.20774800e-01f,
  -3.87937546e-01f, -2.12401688e-01f, -1.42770678e-01f, 9.44967673e-04f, -2.60565370e-01f, -1.05278991e-01f, -1.22810937e-01f, -3.30680050e-02f, -8.27738419e-02f, 3.36512029e-02f,
  -7.35367388e-02f, -1.72790632e-01f, -1.81646332e-01f, -1.57484002e-02f, -9.25353840e-02f, -2.51982540e-01f, 2.17366114e-01f, 1.18317991e-01f, 3.23161774e-04f, -2.47587457e-01f,
  8.93180370e-02f, -3.34548265e-01f, -3.13868672e-01f, -5.70555665e-02f, -2.07117841e-01f, -1.45041689e-01f, -2.47344702e-01f, -2.53067672e-01f, -2.71629781e-01f, 1.01162262e-01f,
  -1.07478872e-01f, -1.86409131e-01f, 3.05109061e-02f, 1.45663485e-01f, 1.45740211e-01f, 3.57004926e-02f, 8.17818046e-02f, -4.26985845e-02f, -8.33870769e-02f, -5.25070503e-02f,
  -2.90421601e-02f, -1.07757092e-01f, -1.13039508e-01f, -2.32080802e-01f, 1.17489263e-01f, -1.22165427e-01f, -3.16953994e-02f, 8.13118443e-02f, 1.80730561e-03f, -7.53564462e-02f,
  8.53283256e-02f, 2.23081820e-02f, 5.65400161e-02f, 1.21244282e-01f, 4.88347486e-02f, -7.40496665e-02f, 2.52805781e-02f, -7.27960765e-02f, 2.59823855e-02f, -3.48600335e-02f,
  8.93719569e-02f, -2.71141589e-01f, -8.39855149e-02f, -3.60842906e-02f, -7.34264031e-02f, -2.00462699e-01f, -1.07564300e-01f, -1.31074160e-01f, -1.25013098e-01f, -1.63022548e-01f,
  -1.15054213e-01f, -1.28165066e-01f, -7.60255381e-02f, 5.46775153e-03f, -1.27476141e-01f, -1.95565119e-01f, 1.42477885e-01f, 1.22587182e-01f, 3.96521911e-02f, -2.41256163e-01f,
  2.52392620e-01f, 4.41913456e-02f, -5.53106666e-02f, 1.40097097e-01f, -6.18967861e-02f, 1.58976272e-01f, -9.85802338e-02f, -1.19821973e-01f, -1.23360008e-01f, 2.20125690e-01f,
  3.39186966e-01f, -6.02290809e-01f, 4.90510702e-01f, 2.57687777e-01f, 2.52665967e-01f, 1.04099490e-01f, -2.61602312e-01f, 1.01905139e-02f, 6.37625083e-02f, -6.97989091e-02f,
  -1.90752208e-01f, -5.16002206e-03f, 2.59368978e-02f, 3.17780115e-03f, -6.30057044e-03f, -5.34963422e-02f, 2.67164677e-01f, 4.96774942e-01f, 4.56958741e-01f, -3.54167856e-02f,
  -2.44512990e-01f, 1.26274452e-01f, 2.22220451e-01f, 4.82581928e-02f, -2.65596241e-01f, 1.56259507e-01f, 7.62677267e-02f, 1.24097280e-02f, -1.14667192e-01f, -1.59262121e-01f,
  -2.80793399e-01f, -2.66313493e-01f, 5.24690002e-02f, -9.78516564e-02f, -4.70431186e-02f, -9.10546407e-02f, -8.20884779e-02f, -1.06527247e-02f, 1.00602666e-02f, -1.35089755e-01f,
  -7.61245638e-02f, -3.03061157e-02f, -3.92053425e-02f, -3.66110653e-02f, -1.36940151e-01f, -8.88334587e-02f, -1.21721871e-01f, -6.26098588e-02f, -6.91775745e-03f, -1.28065839e-01f,
  -1.43745378e-01f, -1.05361648e-01f, 8.64543021e-03f, 6.15519471e-02f, -1.40893087e-01f, 1.75850198e-01f, -1.15817964e-01f, -8.66802037e-02f, 9.15455595e-02f, -9.68442410e-02f,
  7.46176094e-02f, 1.35577649e-01f, 2.69460045e-02f, -1.03062587e-02f, 6.70239255e-02f, -7.27105364e-02f, -3.57202031e-02f, -3.98451686e-02f, 5.02460450e-02f, -1.34470358e-01f,
  9.67916846e-03f, 2.91822962e-02f, 9.74145159e-02f, -7.02609122e-02f, 1.55339697e-02f, 9.01637003e-02f, -5.62494434e-02f, -4.72540408e-02f, -2.94965804e-02f, 3.77529161e-03f,
  3.75100337e-02f, -5.59184179e-02f, 3.11759487e-02f, -1.47028610e-01f, -7.21596181e-02f, 1.03416570e-01f, 4.96110320e-02f, 3.39796506e-02f, -4.68306802e-02f, 4.50145788e-02f,
  -2.27843672e-01f, 1.97716385e-01f, -4.66684736e-02f, -1.57074735e-01f, -1.08264722e-01f, -6.47751335e-03f, -4.36405931e-03f, -6.47749230e-02f, -3.64987217e-02f, -1.37862459e-01f,
  -2.28190497e-01f, -1.35274917e-01f, -3.32935862e-02f, -9.23989266e-02f, 6.14892505e-03f, -7.11290762e-02f, -1.84402809e-01f, -3.44448872e-02f, 3.42913275e-03f, -1.30183503e-01f,
  -1.00242622e-01f, 1.25015810e-01f, 9.60322917e-02f, 1.03748038e-01f, -6.01627640e-02f, 2.34179795e-01f, 1.22948652e-04f, -1.13392062e-02f, 1.03279479e-01f, 6.07347712e-02f,
  -3.21386665e-01f, -6.56949878e-02f, 1.43168375e-01f, 1.26229271e-01f, -8.15746933e-02f, -4.17817831e-01f, -5.11893630e-01f, -3.07493538e-01f, -3.91381308e-02f, -5.35599142e-02f,
  -2.58608639e-01f, -1.06593864e-02f, 1.84476286e-01f, 6.07218593e-02f, -1.25709698e-01f, 1.13351218e-01f, 4.44234252e-01f, 3.13689172e-01f, -1.13921791e-01f, -2.91460752e-01f,
  5.97552117e-03f, 7.88480714e-02f, 9.64517966e-02f, 9.89762321e-02f, 2.61128128e-01f, 1.79060400e-01f, 1.51558831e-01f, 2.15878889e-01f, 8.13021958e-02f, 4.34177935e-01f,
  1.45049900e-01f, -1.69711888e-01f, -8.98704827e-02f, 1.63495973e-01f, 1.53147876e-01f, -2.91571906e-03f, -2.08027363e-02f, 2.19850093e-01f, -1.87393706e-02f, 2.72368621e-02f,
  2.60352492e-02f, 3.07480376e-02f, -3.10954005e-02f, 3.32942605e-02f, -5.94718605e-02f, -3.14363897e-01f, 5.46188466e-02f, 4.16429453e-02f, 8.30002278e-02f, -1.89226285e-01f,
  1.44870535e-01f, -6.22203834e-02f, -3.03845197e-01f, -2.03757718e-01f, 1.83787458e-02f, -4.66578901e-02f, -1.92505330e-01f, -6.22513182e-02f, -2.72864848e-01f, 6.30775392e-02f,
  -6.72871172e-02f, -2.88039558e-02f, -5.66212647e-02f, 3.90037410e-02f, -2.49048304e-02f, 5.81358895e-02f, 1.21103011e-01f, 2.67149862e-02f, 4.99553680e-02f, 5.56834750e-02f,
  -2.77259927e-02f, -5.79244234e-02f, -2.17494015e-02f, -6.20513037e-02f, -7.69541711e-02f, 6.79760724e-02f, 4.61976938e-02f, -8.92774314e-02f, -6.80260211e-02f, 4.05408256e-02f,
  6.59121014e-03f, 1.16243370e-01f, 1.21819496e-01f, 1.55757040e-01f, 7.50859231e-02f, 1.12123743e-01f, 8.60148482e-03f, -4.86826822e-02f, -1.18069641e-01f, -6.57868087e-02f,
  -8.24595690e-02f, -1.26598075e-01f, -5.07588461e-02f, 3.50249521e-02f, 5.42834178e-02f, -1.04597889e-01f, -1.27026113e-02f, 3.64486910e-02f, 2.49564145e-02f, -1.75566599e-01f,
  -2.48359814e-01f, -9.77559760e-02f, 6.25202581e-02f, -6.14300091e-03f, -1.03065252e-01f, -4.17129248e-02f, 2.32885927e-02f, -2.90398039e-02f, -5.84360352e-03f, -1.17918644e-02f,
  6.97851926e-02f, -2.86399931e-01f, -3.20048243e-01f, -1.80577293e-01f, -1.31938472e-01f, -3.17879915e-01f, -1.71266004e-01f, -2.80275285e-01f, -4.04951364e-01f, -4.95056331e-01f,
  -1.76370576e-01f, 2.37171456e-01f, -4.86701317e-02f, 3.19431186e-01f, 4.35137361e-01f, 3.29200804e-01f, 1.98929638e-01f, 1.59876838e-01f, 2.33263671e-01f, 2.71016449e-01f,
  3.25073779e-01f, 3.89852375e-01f, 2.26079881e-01f, 2.24296182e-01f, 1.44298971e-01f, 1.13457225e-01f, 1.58758625e-01f, -6.58507571e-02f, -3.76838236e-03f, 2.24806800e-01f,
  1.96569517e-01f, 1.75005123e-01f, -4.58780080e-02f, 1.75874645e-03f, 2.22182885e-01f, 2.96215057e-01f, 2.24088579e-01f, 2.95914918e-01f, 1.55569017e-01f, 2.04001106e-02f,
  1.01282239e-01f, -1.52074760e-02f, -5.77523932e-02f, 1.71013679e-02f, 2.43737902e-02f, -2.11910591e-01f, -3.63430306e-02f, -8.57895687e-02f, -8.58398080e-02f, -8.07860270e-02f,
  2.53309608e-02f, -1.14178762e-01f, -2.05554981e-02f, -2.45346688e-02f, 1.28033422e-02f, -1.30879119e-01f, -7.28222355e-02f, -5.79181761e-02f, 3.70718688e-02f, -1.78147610e-02f,
  1.52234226e-01f, 7.55844414e-02f, 1.45022962e-02f, -4.73909490e-02f, -2.40289909e-03f, -1.80353019e-02f, 7.73918182e-02f, -9.22762081e-02f, -3.08444258e-02f, -6.26197755e-02f,
  3.02026868e-01f, 2.36591715e-02f, 4.71494123e-02f, 1.51295334e-01f, 6.27335683e-02f, 7.65715763e-02f, 6.72312900e-02f, 1.12713583e-01f, 6.28162473e-02f, -5.89735620e-03f,
  -6.02869987e-02f, 7.53121749e-02f, 2.36320384e-02f, -5.59972636e-02f, -3.78204957e-02f, -9.26256366e-03f, 3.04316655e-02f, 3.55824232e-02f, -5.89412227e-02f, -9.40463543e-02f,
  -6.98343739e-02f, -1.26480326e-01f, -1.71182036e-01f, -2.89870072e-02f, -1.34788472e-02f, 5.88228665e-02f, -9.15567204e-02f, 1.02612153e-01f, 7.65832365e-02f, -5.27127869e-02f,
  3.50845873e-01f, -2.58254725e-02f, -1.17169812e-01f, -1.31064370e-01f, -2.66597327e-02f, -1.97756663e-01f, -4.50591743e-02f, -7.50851706e-02f, -1.91704594e-02f, -3.78783867e-02f,
  1.10002533e-02f, -9.30324942e-02f, -7.86654875e-02f, -3.55402380e-02f, -6.54339641e-02f, -1.12194046e-01f, -1.41972778e-02f, 1.32536992e-01f, 9.44776088e-03f, 4.01358306e-03f,
  -6.09639958e-02f, 9.57246646e-02f, 1.07195742e-01f, -2.37964466e-02f, 1.03069313e-01f, -2.82430165e-02f, 3.49865705e-02f, -8.60197842e-02f, -8.51164535e-02f, -8.99107978e-02f,
  2.56793320e-01f, 2.92632401e-01f, -1.22986481e-01f, 7.90296029e-03f, -2.09813222e-01f, -3.40107888e-01f, -3.82668167e-01f, -3.02307069e-01f, -3.62862833e-02f, 2.02247471e-01f,
  4.41465154e-02f, -1.18243950e-03f, -1.51961342e-01f, -7.06959739e-02f, -1.31341189e-01f, -7.53934979e-02f, -3.24456021e-02f, 2.16846284e-03f, -1.62288263e-01f, -3.65130715e-02f,
  9.92161185e-02f, 1.02398276e-01f, 1.90837950e-01f, -2.62376145e-02f, 2.42405340e-01f, 1.37014352e-02f, 1.17267914e-01f, 1.93035617e-01f, 1.13834426e-01f, 4.05825347e-01f,
  4.18879420e-01f, 2.45656297e-01f, -3.61999303e-01f, 6.72358423e-02f, 1.32132456e-01f, 1.26882628e-01f, -2.50615384e-02f, 6.60333931e-02f, -4.97675128e-02f, 1.10425100e-01f,
  1.16594724e-01f, 2.21350357e-01f, -7.24779293e-02f, 5.11861145e-02f, 1.63130031e-03f, -4.52828035e-02f, -1.10953905e-01f, -2.23507434e-01f, -1.43502876e-01f, 5.01402244e-02f,
  -1.15036014e-02f, -8.48190635e-02f, -1.56568006e-01f, -3.65777731e-01f, -9.26372688e-03f, -1.72389612e-01f, -1.37949092e-02f, 2.43402813e-02f, -2.01274514e-01f, 2.44130105e-01f,
  -9.62933302e-02f, 1.83791980e-01f, 1.64609645e-02f, 9.86341611e-02f, 1.76791713e-01f, 6.46464676e-02f, 1.98838279e-01f, 2.04122350e-01f, 1.21030673e-01f, 1.01925828e-01f,
  3.44226547e-02f, 4.96228971e-02f, 9.85627398e-02f, -2.67659401e-04f, 3.69671136e-02f, 1.46926805e-01f, 2.32217088e-01f, 1.43065033e-02f, -1.29074335e-01f, 1.43243760e-01f,
  -2.30524037e-02f, -7.28763565e-02f, 1.53580993e-01f, 3.19719985e-02f, 1.30759731e-01f, 7.35265613e-02f, 2.00536162e-01f, 1.45162299e-01f, 9.10094455e-02f, 1.26076892e-01f,
  -1.61322653e-02f, -3.47126305e-01f, 7.45519996e-02f, 1.03482390e-02f, 6.60037696e-02f, 7.05059022e-02f, 1.76970422e-01f, 4.10465188e-02f, 1.09603234e-01f, 6.00038730e-02f,
  7.10869133e-02f, 1.58068776e-01f, 1.29544660e-02f, -6.41207919e-02f, 1.31095247e-02f, -1.04426451e-01f, 1.00862525e-01f, -1.05930515e-01f, -1.86340541e-01f, 1.51884764e-01f,
  -1.25263453e-01f, -3.20491523e-01f, -3.19557726e-01f, -4.08677161e-01f, -5.74457087e-02f, -2.33060464e-01f, -3.80322337e-02f, 5.86550385e-02f, -2.58621305e-01f, -5.45235835e-02f,
  -6.02084816e-01f, -8.66143778e-02f, 2.14536056e-01f, -3.17852110e-01f, -1.38176531e-01f, -3.50391194e-02f, -1.60679981e-01f, -1.65745560e-02f, -1.05490260e-01f, -7.63534307e-02f,
  -9.00493097e-03f, -1.62824169e-01f, -1.39990211e-01f, -5.99822402e-02f, -1.90290838e-01f, -1.77131191e-01f, -1.30270526e-01f, -1.20077357e-01f, -2.46261582e-02f, -7.70716965e-02f,
  -6.45518601e-02f, -1.78217441e-01f, -1.46105126e-01f, 3.28854434e-02f, -7.75628015e-02f, -1.03067458e-01f, 1.76950544e-02f, -6.89379945e-02f, -6.71874285e-02f, -2.86118448e-01f,
  1.90872446e-01f, -8.39315504e-02f, 1.51492700e-01f, -1.90195441e-01f, 1.12601712e-01f, -1.42105240e-02f, -8.24577268e-03f, 1.02503657e-01f, -1.41048640e-01f, -2.38056369e-02f,
  -4.21330892e-02f, 1.69683788e-02f, -6.20826930e-02f, 2.69124545e-02f, 4.59648250e-03f, 2.94127837e-02f, -4.26778570e-02f, 1.85667779e-02f, 2.83998419e-02f, 6.85570166e-02f,
  -1.81401819e-01f, -1.79079026e-01f, -9.74385515e-02f, 1.04688793e-01f, 7.93912783e-02f, -9.53247845e-02f, 1.78570777e-01f, 6.19837865e-02f, 5.09128626e-03f, -2.42118135e-01f,
  -4.84670065e-02f, -7.30838850e-02f, -5.63666224e-02f, -5.08340858e-02f, -7.18007516e-03f, 8.24784935e-02f, 1.62751470e-02f, 9.14065838e-02f, 1.77972950e-02f, -9.09728259e-02f,
  1.38033643e-01f, 1.63252234e-01f, 1.26276046e-01f, 7.23865554e-02f, 1.29578384e-02f, -2.62429155e-02f, 1.86068602e-02f, 7.86365047e-02f, 2.14319341e-02f, 1.78509578e-02f,
  4.74335700e-02f, 5.39898761e-02f, 7.50963017e-02f, 1.23420417e-01f, 7.89976791e-02f, -1.34230489e-02f, -1.39212301e-02f, 1.05508275e-01f, 1.02610528e-01f, -3.65421772e-02f,
  1.13065898e-01f, 2.04932064e-01f, -1.34575754e-01f, -1.38664380e-01f, -9.06431153e-02f, 1.31638572e-01f, -4.91270348e-02f, -3.17012593e-02f, -2.09904891e-02f, -8.20422620e-02f,
  3.86336744e-02f, 2.90549453e-02f, 8.14719275e-02f, 1.25502388e-03f, 4.22650650e-02f, -1.23686619e-01f, -1.40059680e-01f, -1.58359572e-01f, 1.21979630e-02f, -3.51372873e-03f,
  -2.13096365e-01f, -2.27590010e-01f, -3.13891649e-01f, -1.31252438e-01f, -8.60638842e-02f, -2.77827322e-01f, -7.58326054e-02f, 2.22458448e-02f, -1.17295347e-01f, -3.84204954e-01f,
  -4.78825450e-01f, 4.49656136e-02f, -5.03148079e-01f, -1.65967703e-01f, 6.06603809e-02f, 2.03935713e-01f, 3.79686028e-01f, 3.67723435e-01f, 2.10994750e-01f, 6.27237512e-03f,
  2.16009412e-02f, -3.93022783e-02f, -1.70512185e-01f, 7.33258948e-02f, 6.00126423e-02f, 1.72915012e-01f, 7.03593791e-02f, -1.70825511e-01f, -7.98746049e-02f, 2.43071914e-01f,
  3.44577193e-01f, -1.83059042e-03f, -8.96580592e-02f, -2.58848042e-04f, -2.88424678e-02f, 2.06846166e-02f, -1.33977011e-01f, -1.66921213e-01f, -1.07661672e-01f, -3.40584069e-01f,
  -5.33782065e-01f, -2.38892883e-01f, 5.66000193e-02f, -1.22362912e-01f, -2.26307079e-01f, -1.77926436e-01f, -4.58324328e-02f, -1.79366902e-01f, -1.51644247e-02f, -7.87882209e-02f,
  -2.08047450e-01f, -5.31658530e-02f, -5.41090369e-02f, 4.07199562e-02f, -2.07485650e-02f, -4.87016141e-02f, 2.75785122e-02f, -7.29627013e-02f, -8.52979943e-02f, -2.27307335e-01f,
  1.68442994e-01f, -2.45395929e-01f, -4.69718128e-01f, 9.55360383e-03f, -1.17181065e-02f, -1.65859714e-01f, -1.34104073e-01f, -2.01693386e-01f, -1.56882271e-01f, -3.78194124e-01f,
  4.55397777e-02f, 1.81724748e-03f, -6.16602926e-03f, 3.95606011e-02f, 7.52920210e-02f, 2.88359448e-02f, 1.42192200e-01f, 5.34447096e-02f, -4.17281203e-02f, 1.32010207e-02f,
  2.77442914e-02f, -9.25516114e-02f, 7.12479129e-02f, -1.57357641e-02f, -9.30386558e-02f, -5.80321206e-03f, 8.74463841e-03f, 7.80077800e-02f, -7.92992637e-02f, 7.64944032e-02f,
  8.07653144e-02f, 5.23333363e-02f, 4.93617766e-02f, 1.28319323e-01f, 4.69688252e-02f, 9.50620770e-02f, 1.00619286e-01f, 5.38480282e-03f, -3.49082798e-02f, 9.90796760e-02f,
  1.46229222e-01f, 1.07547559e-01f, -1.92370772e-01f, 9.79333743e-02f, -1.26661509e-01f, 1.74942128e-02f, 3.52798887e-02f, 7.95797817e-03f, -1.36607483e-01f, 9.95784625e-03f,
  1.10223100e-01f, 3.94842811e-02f, 9.72365437e-04f, 9.42753106e-02f, -3.06640915e-03f, 1.63266417e-02f, 4.18034010e-02f, -1.31761059e-01f, -3.33704799e-02f, -1.14915550e-01f,
  7.69951046e-02f, -3.45772207e-02f, -2.13594630e-01f, -1.78003758e-01f, -7.86857605e-02f, -1.61508828e-01f, -2.37378895e-01f, -7.83738568e-02f, -1.26934379e-01f, -1.22163698e-01f,
  6.94131792e-01f, 1.99357346e-02f, -2.02081442e-01f, 9.29758996e-02f, -2.64261693e-01f, -1.37517810e-01f, -2.76211888e-01f, -6.05559461e-02f, -4.09147330e-02f, -2.18431349e-03f,
  -2.72184424e-02f, 8.54728967e-02f, 1.54489309e-01f, 8.23009834e-02f, 1.76339239e-01f, -1.37471352e-02f, -7.95037821e-02f, 8.31615180e-02f, 1.42379224e-01f, -1.44807696e-02f,
  3.19659412e-02f, 6.86509013e-02f, 1.81570753e-01f, 6.75325170e-02f, 5.14099747e-02f, -1.56962231e-03f, -1.25294566e-01f, -1.77599505e-01f, -6.48600608e-02f, -1.13748170e-01f,
  -1.35988250e-01f, -3.33528072e-02f, 1.84825301e-01f, 5.50580248e-02f, 2.63488200e-02f, 1.69303253e-01f, 9.46822315e-02f, -2.40130555e-02f, 9.52465683e-02f, 2.40194276e-02f,
  4.41751182e-02f, 5.84058054e-02f, 4.11697924e-02f, -1.30129391e-02f, -1.70899667e-02f, -5.86982965e-02f, -8.03277269e-03f, 2.27608997e-02f, -1.24349520e-02f, -1.07165519e-02f,
  -8.98127034e-02f, -1.93315949e-02f, -1.98251203e-01f, -9.07314867e-02f, 1.82950869e-03f, 1.47515414e-02f, 2.41837930e-02f, -3.83640230e-02f, 7.67364204e-02f, 1.44043863e-01f,
  -2.39965450e-02f, 5.69813140e-02f, -4.86167558e-02f, 2.34077498e-02f, 4.19214182e-03f, -1.72451437e-02f, -1.04666427e-01f, 4.21079388e-03f, -6.88749105e-02f, 9.20297951e-02f,
  -1.06178135e-01f, -2.38418989e-02f, -2.21984275e-02f, 1.05496727e-01f, 1.58992484e-01f, -6.35666177e-02f, -4.19482663e-02f, -8.78698975e-02f, 5.41157834e-02f, -8.31072032e-02f,
  -7.96691850e-02f, -7.43862763e-02f, -1.39978632e-01f, -1.40921865e-02f, -1.11948229e-01f, -1.17141120e-01f, -1.64513625e-02f, -6.61081225e-02f, 6.31602257e-02f, -1.22843571e-02f,
  -2.79063761e-01f, -4.13322374e-02f, 2.79439479e-01f, 1.48913443e-01f, 1.53852999e-02f, 1.16266616e-01f, 9.75509509e-02f, 7.05150096e-03f, 3.29781100e-02f, 3.35230790e-02f,
  -5.39009497e-02f, 9.84556451e-02f, 1.28895894e-01f, 5.02245799e-02f, 4.87231128e-02f, -2.61459947e-02f, 1.26599491e-01f, 5.23591265e-02f, 2.91163591e-03f, -4.41647321e-03f,
  2.02598553e-02f, 1.04400860e-02f, -1.81873087e-02f, 1.83936954e-02f, 1.77564681e-01f, 5.93866855e-02f, -5.42925559e-02f, -4.15689051e-02f, -3.00537180e-02f, 2.94773541e-02f,
  -2.57641315e-01f, 4.76783305e-01f, 3.28103244e-01f, -1.08562179e-01f, 3.92155737e-01f, 2.10414425e-01f, 1.89661294e-01f, -2.12434575e-01f, -6.97146282e-02f, 2.12237358e-01f,
  3.50228667e-01f, 8.91665183e-03f, -6.73613744e-03f, -6.77545145e-02f, -2.21691355e-01f, 3.51668075e-02f, 1.07815631e-01f, -2.51408219e-01f, -4.44997102e-01f, -2.33028933e-01f,
  9.38603189e-03f, -1.50119334e-01f, -2.56156117e-01f, -2.61392295e-01f, 2.18003988e-01f, -1.05384458e-02f, 1.41539022e-01f, 2.17360467e-01f, 2.39545688e-01f, 2.71050990e-01f,
  5.19428588e-02f, 1.57643422e-01f, -2.51826823e-01f, -5.39758336e-03f, 1.71387836e-01f, -2.00391129e-01f, -5.35139814e-02f, -3.16696204e-02f, -3.71320397e-02f, -1.55488342e-01f,
  1.13193564e-01f, -4.01018523e-02f, 2.11982816e-01f, 6.31173030e-02f, -7.67806172e-02f, -1.49130672e-01f, -9.51217487e-02f, -2.63236761e-01f, -1.96394816e-01f, 1.80958565e-02f,
  2.32836917e-01f, 1.61259159e-01f, 5.93782887e-02f, 8.67729355e-03f, -2.23040059e-01f, -1.17645569e-01f, 1.20877335e-03f, -1.92098901e-01f, -1.54985160e-01f, -1.71938658e-01f,
  -5.39549775e-02f, 2.38865744e-02f, 9.02949944e-02f, -1.43051269e-02f, -1.49553001e-01f, -7.62294903e-02f, -2.15310119e-02f, 4.66942862e-02f, -9.72920805e-02f, -5.58807589e-02f,
  1.85430981e-02f, 7.04644322e-02f, -1.24341533e-01f, 4.15478088e-02f, 2.91347802e-02f, -5.59322711e-04f, 1.68645997e-02f, 7.45307334e-05f, 6.69814795e-02f, -6.98850900e-02f,
  -4.53408696e-02f, -1.00914724e-01f, 2.40794290e-02f, -1.34241402e-01f, 3.09280679e-02f, -1.10377101e-02f, -1.43519580e-01f, -1.14607304e-01f, -9.21728909e-02f, 6.23185448e-02f,
  -3.00295144e-01f, -5.68148098e-04f, -1.90534219e-01f, -4.90571931e-02f, 1.61061972e-01f, 2.21096724e-02f, 1.85543567e-01f, 1.54644027e-01f, 1.77889347e-01f, -1.01968586e-01f,
  -2.22817156e-02f, -8.57278705e-02f, 7.96458200e-02f, -2.91428473e-02f, -1.44653603e-01f, 3.06277443e-02f, -1.65732112e-02f, 3.90264504e-02f, -1.40049875e-01f, -1.50678856e-02f,
  4.85889614e-02f, -2.48469874e-01f, -1.76786304e-01f, -1.53930068e-01f, -1.40739799e-01f, -2.17846289e-01f, -2.07900375e-01f, -1.75213650e-01f, -1.97378248e-01f, -4.03064370e-01f,
  4.07322228e-01f, 3.21482383e-02f, 2.53577054e-01f, 2.14116156e-01f, 3.47052902e-01f, 3.81289065e-01f, 3.47881645e-01f, 5.91196418e-02f, -5.08935414e-02f, 6.08275533e-02f,
  -3.38040292e-02f, -1.84832603e-01f, -2.74630696e-01f, -1.99240059e-01f, -9.89144892e-02f, 2.35836823e-02f, -4.34195139e-02f, -1.13815181e-02f, 9.63078514e-02f, 1.41682193e-01f,
  -5.01706228e-02f, 2.14413792e-01f, 2.33958006e-01f, -1.02493174e-01f, -1.16881467e-01f, -3.06052025e-02f, 9.34921578e-02f, 1.91662818e-01f, 1.05267473e-01f, -1.74739406e-01f,
  -8.11565071e-02f, 2.06338957e-01f, -1.11063547e-01f, -1.21886514e-01f, -3.80582665e-03f, -1.42625675e-01f, 1.49401873e-01f, 1.40250279e-02f, -7.09657073e-02f, -1.13509558e-01f,
  -1.96524858e-02f, -3.68888751e-02f, 3.36289182e-02f, 9.25490037e-02f, 1.08211368e-01f, -8.43763445e-03f, -9.62498039e-02f, -1.15881050e-02f, -5.45837134e-02f, -9.21735987e-02f,
  -6.91013932e-02f, 1.34603634e-01f, 6.81735873e-02f, 2.40385011e-02f, 2.26994324e-02f, -8.11881125e-02f, -4.99608368e-02f, -3.02026570e-02f, -5.36350980e-02f, -3.66505869e-02f,
  9.56504866e-02f, 3.71525660e-02f, 2.61903796e-02f, 5.96614368e-02f, 1.97114623e-05f, -2.06157397e-02f, -6.11320371e-03f, 8.80864263e-02f, 1.55968755e-01f, 1.62148342e-01f,
  1.70799673e-01f, 1.24080285e-01f, 2.07247928e-01f, 2.19269648e-01f, -9.78520364e-02f, 2.46119350e-01f, 2.34717965e-01f, 1.43360481e-01f, 1.84139252e-01f, 2.48935774e-01f,
  1.40522674e-01f, 1.55275509e-01f, 6.65117502e-02f, 1.10474303e-01f, 7.05484524e-02f, 2.31033906e-01f, 1.15191393e-01f, 3.18284601e-01f, 2.34860837e-01f, 2.83996016e-01f,
  1.78796917e-01f, 3.62928182e-01f, -6.16445094e-02f, -1.86390057e-01f, -6.88399374e-02f, -2.45258827e-02f, -4.95473109e-02f, 2.61026621e-02f, 3.67147960e-02f, -2.73601897e-02f,
  5.67748658e-02f, -7.19588473e-02f, 4.98262420e-02f, 1.29977092e-01f, 2.13111028e-01f, 3.15360837e-02f, -1.44108757e-01f, -1.56845413e-02f, -1.41581461e-01f, -1.06004827e-01f,
  -1.76333681e-01f, 6.55841306e-02f, 1.17066987e-01f, 1.26403607e-02f, -5.49797295e-03f, -9.62321181e-03f, 3.98633555e-02f, 1.03144035e-01f, 2.72951666e-02f, 9.60847586e-02f,
  6.19882159e-02f, -1.20046467e-01f, 1.64994895e-01f, 1.51188985e-01f, -1.75406948e-01f, -2.72453845e-01f, -5.35802782e-01f, -2.07128063e-01f, 5.76050095e-02f, -7.35589564e-02f,
  -1.29366862e-02f, 1.57008082e-01f, 2.93805391e-01f, -1.11992834e-02f, -2.65421808e-01f, -2.21538037e-01f, -9.43835378e-02f, -1.78459629e-01f, -3.58527571e-01f, -3.61817479e-01f,
  -3.45225215e-01f, -1.53161049e-01f, -1.87875912e-01f, -7.64086023e-02f, 1.56247601e-01f, 1.15942977e-01f, 1.52134717e-01f, 2.15876941e-02f, -1.89081922e-01f, 7.40586817e-02f,
  3.48202199e-01f, -1.04981147e-01f, -1.69189170e-01f, -6.41504526e-02f, -7.09598809e-02f, -4.63090055e-02f, -6.65824860e-02f, 7.77071416e-02f, -8.28336403e-02f, 1.73145413e-01f,
  1.62385717e-01f, -3.47428992e-02f, 6.89590797e-02f, 5.06013632e-02f, 4.88261394e-02f, 1.05450138e-01f, 7.82094672e-02f, -6.77094311e-02f, -6.24079481e-02f, -3.31458449e-02f,
  -4.67508845e-02f, 1.39745092e-02f, 1.41169831e-01f, 6.28659502e-02f, -3.58106047e-02f, 8.03349987e-02f, 6.15789443e-02f, -6.44018129e-02f, -5.99573413e-03f, 1.27370274e-02f,
  5.16981408e-02f, 3.19192678e-01f, 3.84442247e-02f, 1.88851580e-02f, 6.64380267e-02f, 1.15791254e-01f, 1.45186149e-02f, 5.56927472e-02f, -1.74215119e-02f, 8.65598917e-02f,
  1.02086611e-01f, 8.18869751e-03f, -1.58058748e-01f, -4.52047437e-02f, 1.44750133e-01f, 1.04129761e-01f, 3.33392099e-02f, 1.30151093e-01f, 2.81045318e-01f, 1.81267351e-01f,
  1.33134767e-01f, 1.18680280e-02f, 1.30716443e-01f, 4.72691432e-02f, -1.36255145e-01f, 1.18689343e-01f, 3.14348303e-02f, 7.68622980e-02f, 1.81815982e-01f, -9.70283151e-03f,
  3.26958150e-01f, -2.80346662e-01f, 2.08628342e-01f, -3.48492004e-02f, 3.25519256e-02f, -9.46738645e-02f, -2.09283289e-02f, -1.62421420e-01f, 2.37538237e-02f, -2.48605534e-02f,
  2.80307140e-02f, 5.86902760e-02f, 1.69567600e-01f, -5.69058061e-02f, -1.66195929e-02f, 9.57171842e-02f, -1.54261722e-03f, -4.90200222e-02f, -1.12880535e-01f, 7.93476105e-02f,
  -1.09793819e-01f, -2.19514929e-02f, 1.53280243e-01f, 1.21405117e-01f, -2.42859572e-02f, 1.22310966e-01f, 1.36852175e-01f, 5.50311357e-02f, -1.47175090e-02f, 1.35742566e-02f,
  4.49696720e-01f, 3.46812844e-01f, -3.19486022e-01f, 1.53843671e-01f, -8.61900523e-02f, -3.91417816e-02f, 1.44611716e-01f, 1.55161992e-01f, 8.93843621e-02f, 2.15444088e-01f,
  1.59860924e-01f, -2.85847969e-02f, -1.10200725e-01f, -1.05878398e-01f, -7.11168870e-02f, -1.13018699e-01f, -1.30077496e-01f, -3.42589051e-01f, -3.33034933e-01f, -1.07113652e-01f,
  -6.08981587e-02f, 2.29355488e-02f, 2.61156149e-02f, -1.52908415e-01f, -4.17915024e-02f, -3.09806168e-01f, -9.60120931e-02f, -1.20745003e-01f, -1.90846771e-01f, -2.49251038e-01f,
  -3.78193766e-01f, -7.04585481e-03f, -2.00804889e-01f, -6.03335313e-02f, -1.09916836e-01f, 9.91780385e-02f, 2.28790399e-02f, 8.85788873e-02f, 1.48966953e-01f, 3.56881991e-02f,
  -1.19671494e-01f, -4.35040705e-03f, -6.22687340e-02f, -9.42326523e-03f, 4.52083759e-02f, -2.94910744e-02f, 1.96015745e-01f, 4.08816859e-02f, 3.52569781e-02f, -7.56443813e-02f,
  3.81481722e-02f, 6.19240813e-02f, 2.69776192e-02f, -2.19876319e-02f, 2.64933258e-02f, -8.59222785e-02f, 1.46616613e-02f, -4.50597256e-02f, -1.24527767e-01f, 8.14111531e-02f,
  -7.46298805e-02f, -3.09561733e-02f, 2.69318018e-02f, -2.85138804e-02f, 6.81774989e-02f, 1.42413422e-01f, 1.62281722e-01f, -2.18769740e-02f, -1.13907941e-02f, 1.07084572e-01f,
  1.57634929e-01f, -5.64102642e-02f, 3.98893729e-02f, 1.62311960e-02f, -3.16548720e-02f, 6.64530694e-02f, 8.27853680e-02f, 9.12263840e-02f, -8.12392235e-02f, -7.31188431e-03f,
  -2.94034332e-02f, 4.33868803e-02f, 1.43305421e-01f, 2.96686534e-02f, 4.21161763e-03f, 1.14983588e-01f, 3.26084457e-02f, -3.49467434e-02f, 1.35772843e-02f, 3.83735150e-02f,
  1.11642666e-01f, -3.70521694e-01f, -1.47285864e-01f, -5.81595562e-02f, -9.06585902e-02f, 4.03510854e-02f, -8.10553208e-02f, -9.52794701e-02f, 3.29077132e-02f, -9.44999307e-02f,
  -6.66475506e-04f, -1.25279829e-01f, -4.16591093e-02f, 7.77219534e-02f, -4.02504057e-02f, 1.45589318e-02f, 1.12760551e-01f, 2.74011493e-02f, -7.18078986e-02f, 1.16050094e-01f,
  1.82088003e-01f, 5.89046888e-02f, 3.87013480e-02f, -2.73768511e-02f, 2.34683584e-02f, -1.88609317e-01f, 4.12858166e-02f, -5.94513379e-02f, -5.42876795e-02f, 1.22200750e-01f,
  4.15135503e-01f, -2.49667093e-02f, -7.15020075e-02f, 2.82856822e-01f, -1.59811348e-01f, -4.26268607e-01f, -5.54552376e-01f, -2.75138289e-01f, 5.98116927e-02f, -1.07228540e-01f,
  -2.05138028e-01f, 6.06526546e-02f, 2.37451851e-01f, -1.98947281e-01f, -2.37357035e-01f, -2.24021271e-01f, -2.37776816e-01f, -2.55270064e-01f, -4.25212175e-01f, -6.06263757e-01f,
  -3.37214589e-01f, -1.65195987e-01f, -8.59426409e-02f, -1.75657988e-01f, 1.18511669e-01f, 1.16996802e-01f, 1.55519973e-02f, -5.92293106e-02f, -1.45247519e-01f, 7.65635446e-02f,
  -1.39155567e-01f, -4.14009579e-02f, -1.62644491e-01f, 7.57903652e-03f, 8.68740976e-02f, 1.69359446e-02f, -1.47227034e-01f, 2.88172420e-02f, 6.76694384e-04f, -1.92465670e-02f,
  5.51191196e-02f, -8.74167830e-02f, 4.22528572e-02f, -1.44502774e-01f, -2.11411089e-01f, -1.26671866e-01f, -1.15833454e-01f, -2.12992445e-01f, -1.72576625e-02f, -2.95553565e-01f,
  -2.48937249e-01f, -7.23552629e-02f, 2.72714496e-02f, -6.50845021e-02f, -1.38255358e-01f, 6.43912256e-02f, -1.08027264e-01f, -1.21581942e-01f, 2.31096218e-03f, 1.08847380e-01f,
  1.11988317e-02f, 1.26362115e-01f, 3.12589444e-02f, -1.41103908e-01f, -5.18883988e-02f, 7.85155222e-02f, 7.32005090e-02f, -1.36841983e-01f, -1.87041517e-02f, 5.48639111e-02f,
  -1.18491344e-01f, 3.84547710e-02f, 2.07078308e-02f, 1.98392160e-02f, -7.17678433e-03f, -2.25858968e-02f, -5.57489402e-04f, -1.38923034e-01f, -4.84969541e-02f, -1.84649695e-02f,
  -5.14354780e-02f, 2.46219803e-02f, 1.38502389e-01f, 3.27731147e-02f, -3.76965590e-02f, -2.32838024e-03f, 2.55190581e-02f, -5.25981188e-02f, 1.41403796e-02f, -5.48167787e-02f,
  1.85028121e-01f, -1.33531645e-01f, 1.50901586e-01f, -8.71325061e-02f, 5.70446067e-02f, -7.80053888e-05f, -5.75434044e-02f, -1.13377132e-01f, 1.33101329e-01f, -1.34294674e-01f,
  -2.48503044e-01f, -4.93751056e-02f, 1.37863755e-01f, -7.96354096e-03f, -1.57277375e-01f, -1.50623485e-01f, -1.92055836e-01f, -7.78600127e-02f, -9.38955173e-02f, -1.00316275e-02f,
  -6.40018657e-02f, -1.22966379e-01f, 1.17715307e-01f, 1.62918448e-01f, 3.21255368e-03f, 2.26359904e-01f, 1.24491781e-01f, 4.09654975e-02f, 4.37524617e-02f, 2.25615710e-01f,
  -1.25039563e-01f, 4.23104972e-01f, 8.91911015e-02f, 4.85175243e-03f, 3.44387531e-01f, 2.94472516e-01f, 3.35505694e-01f, -7.28339925e-02f, -2.27214098e-01f, 9.12680998e-02f,
  2.65434861e-01f, 8.53616372e-02f, -1.06885366e-01f, -6.09092116e-02f, -4.60558459e-02f, 1.15876161e-01f, -1.78955775e-03f, -1.28564849e-01f, -1.92447335e-01f, 9.26202908e-02f,
  1.59463286e-01f, -1.74328927e-02f, -1.87695563e-01f, -1.29878253e-01f, 1.27511486e-01f, -4.56458181e-02f, 2.06581876e-02f, 2.38439456e-01f, 2.25772738e-01f, 1.69774786e-01f,
  5.75512797e-02f, 1.56136304e-01f, -1.85349450e-01f, 4.78614941e-02f, 9.57663730e-02f, -3.36196303e-01f, -1.06518500e-01f, -2.39741415e-01f, -1.71456393e-02f, -1.91973969e-01f,
  2.36316592e-01f, 1.52756581e-02f, 1.23899788e-01f, -4.30078432e-02f, -3.45247835e-02f, -4.57638837e-02f, -1.93557993e-01f, -2.05726147e-01f, -2.20787600e-01f, -4.67233397e-02f,
  3.34113121e-01f, 3.93829554e-01f, 1.90796912e-01f, 8.50047544e-03f, -9.12206247e-02f, -1.13141023e-01f, 4.21743803e-02f, -1.45388961e-01f, -2.75221795e-01f, -2.42592290e-01f,
  -1.61333829e-01f, 5.05253226e-02f, 3.35938968e-02f, -5.93748204e-02f, 4.33454812e-02f, -9.24456641e-02f, 2.02715974e-02f, 7.24935830e-02f, 4.56733480e-02f, -2.65762433e-02f,
  7.08289631e-03f, -3.14280242e-02f, 2.90378393e-03f, -1.18104257e-01f, -1.51889026e-01f, 9.15541723e-02f, 7.43109584e-02f, -1.71879411e-01f, -3.56207453e-02f, -9.39284787e-02f,
  3.26140635e-02f, 5.80979162e-04f, -1.10839181e-01f, -2.50728540e-02f, -1.19212352e-01f, -1.99459776e-01f, -1.27009153e-01f, -6.11855388e-02f, -2.51369566e-01f, -8.85724500e-02f,
  -2.07474366e-01f, -9.17140469e-02f, -2.41657585e-01f, -6.69328570e-02f, 2.02543378e-01f, -4.01969366e-02f, -5.84256416e-03f, -1.40739838e-02f, 1.02148503e-01f, -1.25936806e-01f,
  6.27777129e-02f, -3.32023501e-02f, -6.84871397e-04f, -8.04034173e-02f, -1.80048808e-01f, -1.77035462e-02f, 1.56269111e-02f, 7.55059719e-02f, 2.97159832e-02f, 1.88244134e-01f,
  3.49382088e-02f, -9.32936966e-02f, -9.40949395e-02f, -2.09239438e-01f, -2.25622579e-01f, -3.32826376e-01f, -1.68926746e-01f, -1.90489247e-01f, -2.38391638e-01f, -2.96282291e-01f,
  -3.34127024e-02f, -1.22467779e-01f, 2.57588439e-02f, -9.50654447e-02f, -2.05559283e-01f, -5.21042980e-02f, 1.71724800e-02f, -4.17024195e-02f, -3.49748768e-02f, 1.74334869e-02f,
  3.93938795e-02f, 2.07469165e-01f, 7.97182769e-02f, 8.62229988e-02f, 1.21307150e-01f, 1.21910401e-01f, -7.18896324e-03f, 1.91605106e-01f, 1.33687258e-01f, 7.57719204e-02f,
  6.48033842e-02f, 2.84522423e-03f, 8.28399062e-02f, 2.49307062e-02f, 3.62587906e-02f, 1.36363670e-01f, -8.57142955e-02f, -4.51615639e-02f, -6.21075481e-02f, 7.31772929e-02f,
  2.66687781e-01f, -2.64887065e-01f, 5.73753230e-02f, -1.84992447e-01f, -9.66843516e-02f, -1.30511165e-01f, -3.15093212e-02f, -1.21184357e-01f, -2.04388410e-01f, -1.33975312e-01f,
  -1.50237292e-01f, -7.23002777e-02f, -1.35736729e-04f, -1.43105641e-01f, -1.78650156e-01f, -1.88491940e-02f, -5.48441708e-03f, -5.12698293e-02f, -3.04052402e-04f, -1.10912032e-01f,
  -7.03681037e-02f, -1.83304697e-01f, -7.09355399e-02f, -6.81219902e-03f, 3.78856212e-02f, -8.30332562e-02f, -7.00020343e-02f, -1.33762479e-01f, 2.59988033e-03f, -4.14804295e-02f,
  9.31857452e-02f, 1.42305270e-01f, 7.73740560e-02f, 1.68443948e-01f, 1.22049086e-01f, 1.09720781e-01f, -3.40079563e-03f, 1.60930395e-01f, 1.08696885e-01f, 5.97874448e-02f,
  2.21647657e-02f, 7.79946893e-02f, 8.41183215e-02f, -2.39345934e-02f, 2.70850621e-02f, 4.59241085e-02f, 2.46389024e-02f, 2.48031467e-02f, -7.41429776e-02f, -7.56058320e-02f,
  1.73425023e-02f, -2.24898998e-02f, -1.78657219e-01f, -5.50657660e-02f, -8.32066163e-02f, -1.39208436e-01f, -6.76320419e-02f, 2.54439991e-02f, 4.14298624e-02f, 7.55595230e-03f,
  2.19093293e-01f, -1.03717431e-01f, 2.42107287e-01f, 1.30812898e-01f, -2.03122467e-01f, -4.98430766e-02f, 3.77778932e-02f, -2.33722143e-02f, -7.21447989e-02f, 5.23470715e-02f,
  -1.33932441e-01f, 1.98091585e-02f, 2.16416479e-03f, 6.96465448e-02f, -2.80946959e-03f, 5.54937087e-02f, 1.01596285e-02f, -1.46274734e-02f, -3.67093720e-02f, 1.54323541e-02f,
  -1.03817187e-01f, -4.67760414e-02f, 1.19774662e-01f, 1.29132509e-01f, 1.02975532e-01f, -5.41034294e-03f, -4.10122424e-03f, 7.84108341e-02f, -3.76998819e-02f, 1.04780562e-01f,
  6.18616700e-01f, 3.75256121e-01f, 2.94429034e-01f, 3.74593143e-03f, -1.84524819e-01f, 3.24344188e-02f, 1.12697028e-01f, -1.07725682e-02f, -1.26332983e-01f, 1.87616974e-01f,
  5.66985644e-02f, -7.15538561e-02f, -1.59440830e-01f, -8.33965912e-02f, -3.10238339e-02f, 1.62996903e-01f, -5.15383556e-02f, 1.63152009e-01f, 1.64294854e-01f, 2.37925828e-01f,
  -5.68699278e-02f, 1.79262739e-02f, 2.32090488e-01f, 1.04090735e-01f, 1.19610198e-01f, -1.72813728e-01f, 8.42898712e-03f, 1.61344513e-01f, 1.69848412e-01f, 1.68033153e-01f,
  3.72635692e-01f, 3.69363874e-01f, -3.59663934e-01f, -2.32363686e-01f, -1.23279989e-02f, 1.04000472e-01f, 4.69743870e-02f, -1.64644420e-02f, 1.56432239e-03f, -8.02875161e-02f,
  -7.17878863e-02f, -1.05586071e-02f, 3.31799425e-02f, -6.23689480e-02f, -2.66269911e-02f, -5.03842235e-02f, 8.80777463e-02f, -1.42657515e-02f, -1.55911565e-01f, 6.31281286e-02f,
  -9.65134501e-02f, -3.30733620e-02f, -1.15696546e-02f, -1.58818856e-01f, 8.13176408e-02f, -4.03456725e-02f, 2.24434156e-02f, -8.70186277e-03f, 1.96488388e-02f, 2.22051263e-01f,
  4.51095542e-03f, 1.10743687e-01f, 8.25908221e-03f, 5.94260767e-02f, -4.80731651e-02f, -2.92183608e-02f, 4.68647331e-02f, -5.01641165e-03f, 3.38152982e-02f, 5.89482151e-02f,
  -1.65498480e-02f, 1.79444745e-01f, 8.71869698e-02f, -1.35156140e-03f, -8.20667520e-02f, -6.93092719e-02f, 1.04581326e-01f, -5.79943648e-03f, 2.51971520e-02f, -8.70297030e-02f,
  -1.38156135e-02f, 6.08238280e-02f, 1.44877397e-02f, 1.50814205e-01f, -2.63976050e-03f, 1.02111967e-02f, 3.84297669e-02f, 1.93211921e-02f, 1.53597277e-02f, 5.85551858e-02f,
  -6.05594993e-01f, -3.08004200e-01f, -3.48461866e-02f, -5.56828119e-02f, 4.19942141e-02f, 1.15204705e-02f, 1.37370992e-02f, -5.89515567e-02f, -1.03660144e-01f, -2.70535704e-02f,
  -2.20462983e-03f, 5.24717234e-02f, -2.33356468e-02f, 3.75540033e-02f, -1.50523886e-01f, -1.46462291e-01f, -4.47953790e-02f, -4.13016006e-02f, -1.79096758e-01f, -1.39613152e-01f,
  -1.34109750e-01f, -8.95721391e-02f, -1.60501465e-01f, -2.06187293e-01f, -1.10899426e-01f, -2.00944930e-01f, -2.20152915e-01f, -1.28894910e-01f, -1.54820234e-01f, -1.25206545e-01f,
  -4.84024048e-01f, 1.04118019e-01f, -7.05405176e-02f, -3.33330631e-01f, -5.95267452e-02f, 3.18765044e-02f, 1.93645462e-01f, -3.58983688e-02f, -1.81675076e-01f, 3.87976877e-02f,
  5.58062494e-02f, -2.66266745e-02f, 5.71290143e-02f, 1.34008095e-01f, 2.05192447e-01f, 2.23442957e-01f, 3.40608321e-02f, -3.75919342e-02f, -1.34825148e-02f, 5.33664562e-02f,
  1.20061286e-01f, -4.61509600e-02f, -1.34042412e-01f, 1.94033328e-02f, -4.64794114e-02f, 3.82819623e-02f, -1.57636154e-04f, -1.62147041e-02f, 2.26045754e-02f, -6.81467727e-02f,
  2.15324983e-01f, -2.72919089e-01f, -1.14703521e-01f, -1.32512748e-01f, -1.11472979e-01f, -2.90306844e-02f, -9.19657722e-02f, -1.92151219e-01f, -5.44489659e-02f, -1.00669377e-01f,
  -1.01648003e-01f, -8.67481604e-02f, -8.17243904e-02f, -2.89923213e-02f, 1.95316821e-02f, -1.24555789e-01f, -1.30031407e-01f, -4.69874777e-03f, 9.21589881e-02f, -7.17710406e-02f,
  6.74669445e-02f, -2.80230939e-02f, 6.05385117e-02f, 9.74080525e-03f, 7.66540989e-02f, -8.04030299e-02f, 1.32491067e-02f, -1.53113320e-01f, 5.74678890e-02f, 7.29269907e-03f,
  3.08857318e-02f, 2.79024802e-02f, 4.53897007e-02f, 2.36896202e-02f, 8.35745409e-02f, 9.79793072e-02f, 7.20976070e-02f, 1.55261561e-01f, 2.50673592e-02f, 1.14026383e-01f,
  7.99988359e-02f, -9.40791797e-03f, 7.08768815e-02f, 5.66778220e-02f, 7.76670640e-03f, -1.90486610e-02f, -6.34215102e-02f, 4.72959224e-03f, 5.61071001e-02f, -5.26414588e-02f,
  -5.87454848e-02f, -5.41098900e-02f, 8.75616074e-03f, -6.66149557e-02f, -3.25090103e-02f, -3.50757055e-02f, -6.92809522e-02f, -2.83069275e-02f, 9.96094197e-03f, -5.95726743e-02f,
  3.18530619e-01f, -1.82651386e-01f, 7.61349860e-04f, -9.82247014e-03f, -4.55279723e-02f, -1.57220021e-01f, -1.68494016e-01f, -1.08197957e-01f, -8.43126476e-02f, -9.04357806e-03f,
  -7.66150504e-02f, -6.32371604e-02f, -3.29420790e-02f, 2.68577468e-02f, 8.17616060e-02f, -8.46552551e-02f, 6.45570755e-02f, 5.98175153e-02f, 8.27855989e-02f, -1.75452828e-02f,
  -3.61161903e-02f, 5.07825948e-02f, 1.30584344e-01f, 3.39936577e-02f, 8.42415318e-02f, 1.13755397e-01f, 5.04042357e-02f, -3.76856923e-02f, 1.25134632e-01f, 1.31090835e-01f,
  -5.12067020e-01f, 2.48673201e-01f, 3.82570513e-02f, -1.73236638e-01f, 6.45399392e-02f, 1.63530231e-01f, 1.65418550e-01f, 7.82298949e-03f, -1.18065916e-03f, 1.76470086e-01f,
  9.05751437e-02f, -6.39010444e-02f, 2.12158024e-01f, 7.91073665e-02f, 7.97369853e-02f, 3.68004948e-01f, 4.29231703e-01f, -4.47103605e-02f, -4.45920110e-01f, -3.85058790e-01f,
  -2.07864475e-02f, -3.43367547e-01f, -4.21818912e-01f, -1.72076643e-01f, 1.91802174e-01f, 6.47375062e-02f, 2.49644920e-01f, -2.27871109e-02f, 1.94715336e-01f, 3.69413435e-01f,
  1.27001241e-01f, -2.10105851e-01f, -9.28529128e-02f, -2.82347649e-01f, 2.92543378e-02f, 2.19318233e-02f, -4.18802872e-02f, -5.68865389e-02f, -1.48110548e-02f, -1.62991397e-02f,
  -2.67929100e-02f, -3.57250161e-02f, 5.64779863e-02f, 6.08172035e-03f, -1.11649707e-01f, -1.97841063e-01f, -1.37397766e-01f, -1.78160295e-01f, -1.12497203e-01f, -1.52166471e-01f,
  1.42584756e-01f, -3.41175616e-01f, -3.12318444e-01f, -7.22732395e-03f, 8.43447745e-02f, -1.50801718e-01f, -1.02117188e-01f, -1.89754412e-01f, -1.57342374e-01f, 2.27570757e-02f,
  -8.64548981e-02f, 1.99548993e-02f, 1.06456600e-01f, 2.67648604e-02f, 1.55046254e-01f, 1.08827099e-01f, 1.45389393e-01f, 1.62676975e-01f, 7.77388737e-02f, 2.02886350e-02f,
  1.75552055e-01f, -2.72304229e-02f, -4.24160529e-03f, 1.48108695e-02f, 3.07171959e-02f, -8.57114792e-02f, 7.88501576e-02f, 7.75978342e-02f, 1.02733448e-01f, 9.47885886e-02f,
  -6.26785904e-02f, 3.48682739e-02f, -4.87348363e-02f, 8.54243040e-02f, 1.04747988e-01f, 1.76695064e-02f, 1.26240656e-01f, 5.21044694e-02f, -1.55557081e-01f, -2.30130851e-02f,
  -5.44650592e-02f, -1.04604006e-01f, 3.21078934e-02f, -3.70755680e-02f, 3.48148569e-02f, 1.13803558e-01f, 3.34726200e-02f, 1.49097322e-02f, 2.12394819e-02f, -2.27453962e-01f,
  -9.69607756e-02f, -1.60445552e-02f, 1.16476670e-01f, 7.43168443e-02f, -1.26568422e-01f, -2.11445037e-02f, 6.94413781e-02f, -1.11704178e-01f, -3.75550054e-02f, -6.38677701e-02f,
  1.71110421e-01f, -2.32072294e-01f, -2.36628026e-01f, 1.11072533e-01f, -4.30198871e-02f, -2.30936274e-01f, -7.59062171e-02f, -9.41356495e-02f, -1.25807539e-01f, 1.05283633e-01f,
  -7.18690872e-01f, 1.27262652e-01f, 3.19920778e-01f, -1.52898952e-01f, -1.68798730e-01f, -9.95692834e-02f, -1.24300204e-01f, -1.68933958e-01f, -7.56507739e-02f, -5.57171181e-02f,
  5.05184643e-02f, -8.02777987e-03f, 3.92489396e-02f, 6.43040389e-02f, 6.75527900e-02f, 1.14651859e-01f, 2.61724055e-01f, 1.05351850e-01f, 1.95263363e-02f, -1.15563050e-01f,
  8.01107064e-02f, -5.97983785e-02f, 4.64678369e-03f, 4.79261838e-02f, 1.71837613e-01f, 1.85833082e-01f, 1.90777898e-01f, 5.62334470e-02f, 5.23579568e-02f, 2.47203603e-01f,
  5.37499487e-01f, 1.22661265e-02f, 8.28466713e-02f, -6.50672615e-02f, 5.50696924e-02f, -2.02837065e-02f, -1.58989783e-02f, 2.82729473e-02f, -9.29119959e-02f, -1.23384539e-02f,
  7.03807697e-02f, 1.30033880e-01f, 5.09777293e-02f, -2.41459254e-02f, -2.35730838e-02f, 2.20659878e-02f, -7.30351582e-02f, 3.58327888e-02f, 6.75109327e-02f, 2.27683559e-01f,
  4.25756164e-02f, 3.46386284e-02f, -6.68136999e-02f, -8.29682201e-02f, -1.19307367e-02f, -8.79124105e-02f, 9.23056081e-02f, -6.90995380e-02f, -8.52658525e-02f, -1.01433210e-01f,
  -4.80712503e-02f, -1.50060341e-01f, -2.04252955e-02f, -7.15810582e-02f, -1.10009037e-01f, -1.42870158e-01f, -2.65696179e-02f, -1.95915207e-01f, -1.34428799e-01f, -1.15142301e-01f,
  -9.79863107e-02f, 5.69027811e-02f, -3.72976065e-02f, -7.05222338e-02f, 8.44311342e-02f, 9.25179943e-02f, -3.01283225e-02f, 9.24325734e-03f, 6.98753120e-03f, 9.31082964e-02f,
  -2.22316869e-02f, -4.46885936e-02f, 2.43576104e-03f, 9.54443887e-02f, 1.47864148e-02f, -9.48698968e-02f, -3.07168369e-03f, 1.80129893e-02f, 4.91907857e-02f, -9.82856974e-02f,
  3.88616115e-01f, 2.53866259e-02f, 8.35776776e-02f, 1.61087245e-01f, 1.23723149e-01f, 1.34648025e-01f, 2.16359168e-01f, 9.19978619e-02f, 1.27813593e-01f, 5.92045560e-02f,
  -4.25015315e-02f, 9.85938087e-02f, 1.44571990e-01f, 4.25922722e-02f, -1.39781550e-01f, -5.95071986e-02f, -9.56298560e-02f, 8.14131275e-02f, 1.37617569e-02f, 1.58377260e-01f,
  4.91594262e-02f, -1.77676141e-01f, -1.71577670e-02f, -3.75470556e-02f, -9.74843353e-02f, -1.72510948e-02f, -5.11158705e-02f, -4.32782993e-03f, -7.13353828e-02f, -2.21977770e-01f,
  -6.57961726e-01f, -2.44590789e-01f, 2.04147100e-01f, -4.57122743e-01f, -2.36053854e-01f, 3.41298321e-04f, -1.67941172e-02f, -1.04341835e-01f, -3.60576689e-01f, -2.76320189e-01f,
  -1.81109712e-01f, -2.53461987e-01f, -2.59227455e-01f, -3.46279405e-02f, 2.26954862e-01f, 2.33014040e-02f, 1.65950313e-01f, 3.53959739e-01f, 3.98121089e-01f, 8.34147483e-02f,
  -9.75486934e-02f, -9.41689685e-03f, 2.15981036e-01f, 1.68383360e-01f, -3.35455179e-01f, -6.80546314e-02f, -4.89351265e-02f, -2.23320574e-02f, 6.26519099e-02f, -1.84089154e-01f,
  -1.52244717e-01f, -1.21068820e-01f, 1.52785465e-01f, -1.82359833e-02f, -6.73494935e-02f, -8.37100744e-02f, 4.70808819e-02f, -2.15109028e-02f, -3.62034105e-02f, -9.22625139e-02f,
  -1.85561463e-01f, -3.42187993e-02f, -2.49864459e-01f, -1.00329526e-01f, -2.01997176e-01f, -3.73207778e-02f, 1.53310969e-01f, 2.10080326e-01f, 6.92340434e-02f, 6.81037009e-02f,
  6.13901280e-02f, -6.12107404e-02f, -2.99533121e-02f, 1.06062166e-01f, -1.75644998e-02f, 5.58151677e-02f, 8.70406926e-02f, 5.16102128e-02f, 1.68883651e-01f, -2.79432625e-01f,
  -6.33561984e-03f, 3.82722681e-03f, -4.07152474e-02f, 2.20580082e-02f, -9.27423611e-02f, -6.98877266e-03f, 6.66496605e-02f, -8.80404841e-03f, -7.25652054e-02f, -1.35853831e-02f,
  9.53608658e-03f, -9.28432047e-02f, -1.85841098e-02f, -1.05596734e-02f, 7.38431560e-03f, -5.62110208e-02f, -4.74193245e-02f, 1.85946539e-01f, 9.28576663e-02f, -3.93616520e-02f,
  -8.11038166e-02f, 1.16977375e-02f, 6.52792230e-02f, 1.00173019e-01f, 1.18993938e-01f, 2.12038487e-01f, -1.05748519e-01f, 4.54376712e-02f, -1.24277296e-02f, -4.14963476e-02f,
  -2.74630994e-01f, 3.36284757e-01f, -3.79054099e-01f, 9.13997069e-02f, -1.77396119e-01f, 1.62184492e-01f, -3.23147960e-02f, 1.74280107e-02f, -9.16138738e-02f, 2.94659194e-02f,
  1.82229474e-01f, 2.33447701e-02f, -2.57499635e-01f, 7.37748966e-02f, -1.02942035e-01f, -2.05367580e-01f, -4.45679985e-02f, -1.31350279e-01f, -1.06124178e-01f, -1.29717454e-01f,
  -3.50211300e-02f, -1.92223087e-01f, -3.57325792e-01f, -2.50411212e-01f, -3.33309233e-01f, -1.60208955e-01f, -1.02129050e-01f, -7.05569461e-02f, -7.17323506e-03f, -3.79812151e-01f,
  -7.02905729e-02f, -3.17303032e-01f, -4.02882129e-01f, 1.65911287e-01f, 1.54270068e-01f, -1.80276886e-01f, -3.93177390e-01f, -1.28118619e-01f, 1.64297774e-01f, -1.28045812e-01f,
  1.51902726e-02f, 2.55259901e-01f, -5.92689775e-02f, -9.67229903e-02f, -3.13571960e-01f, -4.47711945e-01f, -3.41638654e-01f, -1.72816962e-01f, 1.15452915e-01f, 2.79955357e-01f,
  3.31929743e-01f, 3.12818468e-01f, 1.58626050e-01f, 1.24857917e-01f, 1.17013164e-01f, 4.19993661e-02f, -1.30022660e-01f, -4.99780513e-02f, -2.13750586e-01f, -2.53820866e-01f,
  -2.86870688e-01f, -3.34220588e-01f, 1.65756375e-01f, 9.39225629e-02f, 8.64885375e-02f, -5.99744171e-02f, 5.27776293e-02f, 1.27089936e-02f, 1.41562730e-01f, -1.19931228e-01f,
  1.76943287e-01f, 1.02152981e-01f, 1.55529410e-01f, 6.96078613e-02f, 1.07058473e-01f, -6.53923452e-02f, 1.72487944e-02f, -2.28659168e-01f, -2.05927923e-01f, 1.05134444e-03f,
  2.70183943e-02f, 1.67397410e-02f, -2.24476606e-01f, -1.17140777e-01f, -1.36598572e-01f, -2.54986491e-02f, -6.62932247e-02f, -1.06999122e-01f, -1.57229230e-01f, -2.26544663e-01f,
  2.99341157e-02f, -1.79337077e-02f, 7.35230651e-03f, -1.63665321e-03f, 6.24819957e-02f, -4.16787565e-02f, -6.98602870e-02f, -2.24476591e-01f, -7.14372769e-02f, -2.40438972e-02f,
  8.49479139e-02f, -2.39109788e-02f, -4.89660986e-02f, -8.42796415e-02f, 4.66081612e-02f, -9.27860066e-02f, -1.75187826e-01f, -8.80954489e-02f, -1.19596254e-03f, -3.70617211e-02f,
  -9.64848511e-03f, -1.06227472e-01f, 6.49289116e-02f, -1.50284236e-02f, -1.49351031e-01f, -1.00803874e-01f, 1.18289646e-02f, 5.01683541e-02f, 7.80673623e-02f, -2.59086620e-02f,
  2.06777632e-01f, 7.49656186e-02f, -1.34584978e-01f, -1.38613731e-01f, -1.37308404e-01f, 5.20398282e-02f, 6.37127459e-02f, -4.51130942e-02f, -3.02119311e-02f, 3.21498476e-02f,
  -5.64191639e-02f, -9.05990601e-02f, 5.70843592e-02f, 3.33899297e-02f, -1.63449207e-04f, -1.47665534e-02f, -3.26203890e-02f, -1.89870968e-01f, -8.98016766e-02f, 8.34302679e-02f,
  -2.53637191e-02f, -3.44078422e-01f, -1.85730338e-01f, -1.96425915e-01f, -1.30026359e-02f, -1.48554787e-01f, -1.92360595e-01f, -1.04421318e-01f, -3.40855241e-01f, -2.54572719e-01f,
  5.04932582e-01f, -3.39373410e-01f, -1.06581368e-01f, -9.63819399e-02f, -8.93063918e-02f, 5.22554815e-02f, -1.01540588e-01f, 5.07284589e-02f, -1.04910322e-01f, -1.43976808e-01f,
  2.52309471e-01f, 4.90403235e-01f, 3.81899655e-01f, 3.08124959e-01f, 3.65324974e-01f, -2.69079089e-01f, -3.32006425e-01f, 6.41103983e-02f, 4.30573642e-01f, 1.60264865e-01f,
  -1.71824455e-01f, -2.62071997e-01f, -6.51523694e-02f, -1.18971646e-01f, -4.13940579e-01f, 5.63379154e-02f, -3.54802996e-01f, -1.93757668e-01f, -1.80582955e-01f, -4.43250805e-01f,
  2.79359281e-01f, 2.25614190e-01f, 3.06866830e-03f, -4.71842699e-02f, -1.57849923e-01f, -8.77359435e-02f, 4.09398563e-02f, -6.79252371e-02f, 4.70837466e-02f, -2.78883874e-02f,
  5.12301698e-02f, -4.68823873e-03f, -8.64977539e-02f, -7.71841705e-02f, -1.18976153e-01f, -2.19385163e-03f, -1.56784967e-01f, 1.21639453e-01f, 1.22211695e-01f, -3.55240367e-02f,
  -2.03529701e-01f, -9.12045538e-02f, -6.24542404e-03f, -1.16669424e-01f, 2.42530629e-02f, 1.19785056e-01f, 1.52585218e-02f, -5.41354753e-02f, 7.39244148e-02f, -4.32845980e-01f,
  -5.12169264e-02f, -1.62695915e-01f, -1.14594981e-01f, 5.89203797e-02f, -1.98278837e-02f, 8.78801346e-02f, -5.77775910e-02f, 4.40484360e-02f, -2.40688268e-02f, -1.29781917e-01f,
  -2.40851045e-02f, -2.56384909e-02f, 1.54048400e-02f, -1.20805040e-01f, -1.63754681e-03f, -1.23347931e-01f, -1.03430226e-02f, 4.62154262e-02f, 8.83706212e-02f, -8.28938037e-02f,
  5.11501022e-02f, -1.71904657e-02f, 1.42871812e-01f, 2.11006496e-02f, 9.46555659e-02f, 1.07333444e-01f, 1.69312373e-01f, -1.38329593e-02f, 5.78494444e-02f, -8.60465094e-02f,
  4.31025364e-02f, 2.42529199e-01f, 4.71935421e-02f, 1.67174920e-01f, -1.99756816e-01f, 3.72179151e-02f, -8.82208794e-02f, -2.78925039e-02f, 1.68871924e-01f, 1.12985536e-01f,
  4.78508025e-02f, 1.81871250e-01f, 6.14953786e-03f, -1.11818664e-01f, -8.89810845e-02f, -3.67885418e-02f, 2.78400141e-03f, 1.85757756e-01f, 3.73998918e-02f, -1.30137429e-01f,
  -2.83097655e-01f, -3.45120504e-02f, 1.31856218e-01f, 2.41453685e-02f, -1.17977753e-01f, 1.74785584e-01f, 7.42365792e-02f, -5.77888973e-02f, 1.99190795e-01f, -3.05444539e-01f,
  1.05753198e-01f, -7.67584443e-02f, -4.28944737e-01f, 2.55772948e-01f, 1.75606281e-01f, -1.59852624e-01f, -4.43132848e-01f, -2.60135084e-01f, 2.69632220e-01f, -1.43684708e-02f,
  6.53121844e-02f, 1.30208373e-01f, -1.10667720e-01f, -2.66761631e-01f, -6.20658696e-01f, -6.15233481e-01f, -4.19528276e-01f, -5.30302405e-01f, -4.04131293e-01f, -1.21189058e-01f,
  3.12216301e-02f, 4.59230039e-03f, -1.20989844e-01f, -1.21338189e-01f, 2.91347802e-01f, 1.88099682e-01f, 1.07218146e-01f, 7.22661242e-02f, -8.87769088e-02f, 1.49576128e-01f,
  -3.11679542e-01f, -3.05211872e-01f, -1.37877077e-01f, 6.52666762e-02f, 1.44393906e-01f, 1.48809358e-01f, -6.69068471e-02f, 4.19254452e-02f, 9.28177536e-02f, -5.15791913e-03f,
  1.07190341e-01f, 5.09589091e-02f, 7.72788525e-02f, 2.28781961e-02f, -1.31896362e-01f, -1.88810229e-01f, -4.84087653e-02f, -1.72308847e-01f, -1.83827877e-01f, -3.70711051e-02f,
  2.02181697e-01f, -8.59039091e-03f, -2.34859556e-01f, -1.29245251e-01f, -2.25704182e-02f, 2.02290788e-02f, 5.11874370e-02f, 1.06680267e-01f, -1.49761930e-01f, 1.35610566e-01f,
  -7.83879589e-03f, 1.72348823e-02f, 6.75603002e-02f, 7.97871202e-02f, 3.50974388e-02f, 1.05901465e-01f, 1.20385764e-02f, -1.09391827e-02f, 3.68942320e-02f, -5.46401888e-02f,
  -3.32025960e-02f, -6.62439018e-02f, -9.49013680e-02f, -2.21688539e-01f, -1.50918469e-01f, 2.79301908e-02f, -8.66957232e-02f, -1.05168760e-01f, -1.18922673e-01f, -1.26289960e-03f,
  -1.36733860e-01f, -4.53750342e-02f, 7.99130946e-02f, 6.40693726e-03f, -5.02195321e-02f, 2.54034158e-02f, -3.83261070e-02f, -1.97864138e-02f, -4.00407724e-02f, -8.83685872e-02f,
  -6.84498847e-02f, -4.02174920e-01f, -3.06458734e-02f, -2.60214239e-01f, 7.21957767e-03f, 1.15626834e-01f, 1.07510671e-01f, 2.97838300e-02f, 5.85385226e-02f, -7.12012425e-02f,
  -7.45066553e-02f, -4.82161976e-02f, 1.42743597e-02f, -1.20838797e-02f, -8.33366960e-02f, -4.71629128e-02f, 1.82854738e-02f, 2.39989776e-02f, -8.52080658e-02f, 2.58839369e-01f,
  5.46127148e-02f, -2.78590232e-01f, -1.13976561e-01f, -6.21592961e-02f, 7.75069594e-02f, -2.24684089e-01f, -9.15880352e-02f, -1.05871759e-01f, -2.92476058e-01f, 1.77373532e-02f,
  3.57855141e-01f, -2.94283062e-01f, -4.24824476e-01f, -4.05163258e-01f, -2.69604176e-01f, -1.44143239e-01f, -1.43265679e-01f, -8.05342495e-02f, -1.68952614e-01f, -2.01559678e-01f,
  -5.44350632e-02f, 2.04118475e-01f, -1.20457493e-01f, 6.81876764e-02f, 1.64391443e-01f, -2.67157525e-01f, -1.95502430e-01f, 2.40617953e-02f, 3.05160105e-01f, 4.72486317e-02f,
  -9.07331482e-02f, -1.88673317e-01f, -1.46608278e-02f, -1.24931805e-01f, -4.62076724e-01f, -1.12603754e-01f, -3.86038244e-01f, -2.56858110e-01f, -9.73933935e-02f, -3.99019241e-01f,
  -2.74278849e-01f, -1.29194230e-01f, -1.44640850e-02f, 9.56235826e-02f, -1.92827448e-01f, -2.34057009e-02f, 5.50708845e-02f, -1.54047534e-01f, -4.21844190e-03f, -1.76373675e-01f,
  -1.17917694e-01f, 2.27820757e-03f, 6.43111244e-02f, -1.12749889e-01f, -4.66187224e-02f, -4.62487973e-02f, -8.78095850e-02f, 9.01927352e-02f, 3.78150158e-02f, -4.69386429e-02f,
  1.13536350e-01f, 5.53984419e-02f, 9.55280587e-02f, -5.33595867e-02f, -9.70433503e-02f, 2.40358245e-02f, -1.91516474e-01f, 5.82561502e-03f, 1.21793956e-01f, -1.77880049e-01f,
  1.01536490e-01f, 1.29787223e-02f, 7.88363144e-02f, -7.09575042e-02f, 2.73510255e-03f, 1.03822418e-01f, 8.65065455e-02f, 4.03971635e-02f, 1.35650441e-01f, 4.41751210e-03f,
  -1.93333868e-02f, -1.20870199e-03f, 1.60832591e-02f, 3.86128726e-04f, -5.02909124e-02f, -3.82875931e-03f, 1.13216549e-01f, 2.50429790e-02f, -2.61595603e-02f, 7.18499571e-02f,
  1.13190047e-01f, 7.25315437e-02f, -2.18079668e-02f, -6.03435598e-02f, 8.99542421e-02f, -2.41608731e-02f, 8.79134908e-02f, 9.90484282e-02f, -6.94156885e-02f, 5.46072237e-02f,
  -1.75032586e-01f, 2.06971526e-01f, -1.04305498e-01f, 9.16626751e-02f, -7.28893606e-03f, -3.36077809e-02f, 4.16683918e-03f, -1.17519110e-01f, -1.54035524e-01f, -1.13501372e-02f,
  -8.45948607e-03f, 7.38288015e-02f, 3.62058915e-02f, -2.60943938e-02f, 2.86793578e-02f, 7.94697087e-03f, 9.06563476e-02f, 4.57704514e-02f, 1.66443698e-02f, -8.60206708e-02f,
  3.37289460e-02f, 2.18365431e-01f, 2.60781854e-01f, 2.55230106e-02f, 1.23848103e-01f, 1.44878313e-01f, -3.64279263e-02f, 1.02793008e-01f, 2.95913100e-01f, -2.96335667e-02f,
  1.66409746e-01f, -1.57757252e-01f, -3.33158612e-01f, 1.86458394e-01f, 6.10644929e-02f, -2.42635235e-01f, -4.37157631e-01f, -5.76601289e-02f, 1.99884593e-01f, -1.85870856e-01f,
  -1.23078682e-01f, 5.96314520e-02f, -1.81281626e-01f, -2.74339288e-01f, -4.64613348e-01f, -4.89008904e-01f, -3.69503826e-01f, -3.77997935e-01f, -2.64997333e-01f, -6.03274209e-03f,
  3.97878252e-02f, 6.77520484e-02f, 9.48880985e-03f, 8.91684904e-04f, 4.63275999e-01f, 2.00241819e-01f, 7.79951215e-02f, 1.34721890e-01f, -6.85434090e-04f, 1.55970052e-01f,
  -4.14738059e-02f, 2.19648510e-01f, -3.36545780e-02f, 1.97014540e-01f, 6.16204180e-03f, 6.88960180e-02f, -6.66317195e-02f, 5.95349520e-02f, 1.90269575e-02f, -7.70931318e-02f,
  5.51515520e-02f, 1.60105750e-01f, 6.54864609e-02f, 1.38425261e-01f, 6.89967126e-02f, 9.42279100e-02f, -4.66828644e-02f, -2.25608662e-01f, -1.47415116e-01f, 2.88906097e-02f,
  2.85619665e-02f, -5.15294895e-02f, -1.29085630e-01f, -2.20872797e-02f, 1.25950783e-01f, -6.82158843e-02f, 9.32183191e-02f, 2.65417308e-01f, 4.33510542e-03f, 1.86570212e-01f,
  7.37954825e-02f, -1.66103020e-01f, -2.90109161e-02f, 8.97384509e-02f, -9.82035100e-02f, 2.86560040e-02f, -2.83083450e-02f, -4.40200679e-02f, -4.37529124e-02f, -8.05147458e-03f,
  -1.06475957e-01f, -1.11249492e-01f, -2.74375435e-02f, 1.09498665e-01f, -3.87665369e-02f, 3.91108282e-02f, 4.88818251e-02f, -5.07279970e-02f, -6.93390369e-02f, -1.49322199e-02f,
  8.53292085e-03f, 4.82162610e-02f, 9.74926278e-02f, 2.19016075e-02f, 1.12155657e-02f, 1.35528278e-02f, 6.77067786e-02f, 7.52640218e-02f, 2.75184438e-02f, 1.32882386e-01f,
  1.37071982e-01f, -3.02860677e-01f, 8.21807981e-02f, -4.87286747e-02f, -2.30230317e-02f, 5.98777421e-02f, 6.36130199e-02f, -3.95242944e-02f, 1.38681471e-01f, 2.14620288e-02f,
  4.63281125e-02f, 2.50976556e-03f, 1.04119956e-01f, 4.01004218e-02f, -3.19356695e-02f, 7.53751844e-02f, -2.35637918e-01f, -4.08405475e-02f, -1.84789598e-01f, 1.45299122e-01f,
  -1.68248773e-01f, -2.96476930e-01f, -2.96959013e-01f, -2.47079492e-01f, 1.03864387e-01f, -9.23161060e-02f, -8.92596245e-02f, 6.04858510e-02f, -2.16808677e-01f, -2.32438698e-01f,
  -7.14860037e-02f, -3.14088941e-01f, -4.78480309e-02f, 7.47411624e-02f, 7.42013603e-02f, -2.16820270e-01f, -5.34386396e-01f, -2.65470207e-01f, 1.16448149e-01f, -2.32686386e-01f,
  -4.43592034e-02f, 2.97859728e-01f, 8.60627890e-02f, -1.35833165e-03f, -2.51351565e-01f, -4.05917168e-01f, -2.26955101e-01f, 5.37432805e-02f, 1.07979514e-01f, 8.10506418e-02f,
  4.25171815e-02f, 1.32076845e-01f, 1.96739495e-01f, 1.55336156e-01f, 8.13273713e-02f, 1.52941808e-01f, -5.53789213e-02f, 1.05225772e-01f, -1.02135442e-01f, -1.96420532e-02f,
  3.93320108e-03f, -1.12586297e-01f, 6.55478314e-02f, 2.81200767e-01f, 1.86902195e-01f, -1.66015461e-01f, -1.89077079e-01f, 1.14433482e-01f, -5.50291203e-02f, -1.46120787e-01f,
  1.33805975e-01f, 1.13052472e-01f, -2.41946429e-02f, -1.09399939e-02f, 4.37843464e-02f, -1.16227224e-01f, 4.11051027e-02f, -4.17722985e-02f, -1.31556958e-01f, -7.16183111e-02f,
  3.88332158e-02f, 4.48403927e-03f, -1.17942087e-01f, -1.27999321e-01f, -1.47091582e-01f, 6.66185915e-02f, -9.11026075e-02f, -7.31101558e-02f, -2.54923701e-01f, -2.31191143e-01f,
  6.45743012e-02f, 1.12023659e-01f, -1.78174134e-02f, 1.73516665e-02f, -1.08518407e-01f, -6.22786917e-02f, -1.83985718e-02f, 2.08463520e-02f, 7.93980435e-02f, -1.50480913e-02f,
  5.42381480e-02f, -3.25653590e-02f, 6.23324551e-02f, -6.18813746e-02f, 5.30660264e-02f, -9.75438394e-03f, -6.61735311e-02f, -1.12756908e-01f, 4.51492518e-02f, -2.94934530e-02f,
  3.87108885e-02f, -5.60848340e-02f, 2.24444810e-02f, 2.88419258e-02f, -5.13811447e-02f, -8.08344856e-02f, -1.22544551e-02f, 9.14259162e-03f, 1.12777138e-02f, -4.86905314e-02f,
  -2.74582803e-02f, 7.08052283e-03f, -1.16462566e-01f, -3.94507172e-03f, 3.54481936e-02f, 8.00178945e-02f, -1.65381655e-02f, 3.74978259e-02f, 7.19408095e-02f, 8.79333634e-03f,
  -7.59984478e-02f, -4.08625044e-02f, -2.77855676e-02f, 7.70596936e-02f, -5.24050035e-02f, -3.35451178e-02f, -1.35013282e-01f, -1.01960152e-02f, -1.95867047e-02f, 1.04343988e-01f,
  -1.37920409e-01f, -2.43826866e-01f, -2.71816015e-01f, -2.56549716e-01f, -9.31847841e-02f, -1.71733782e-01f, -2.07659692e-01f, -1.46384373e-01f, -3.00536454e-01f, -5.39709389e-01f,
  -2.41824631e-02f, -3.34798217e-01f, 2.53750205e-01f, 3.73643190e-01f, 2.84790009e-01f, 1.15001783e-01f, 3.77078503e-02f, -1.12435119e-02f, 2.61561185e-01f, 1.96276397e-01f,
  2.09496468e-01f, 4.00969326e-01f, 2.78056115e-01f, 3.37782979e-01f, 1.05506383e-01f, 1.67223781e-01f, 2.21189797e-01f, 2.71555305e-01f, 1.95788220e-01f, 1.79182693e-01f,
  5.79307005e-02f, -1.25496287e-03f, 1.49561828e-02f, 9.43100825e-02f, 1.30519733e-01f, 2.64402092e-01f, 9.38007757e-02f, 1.11803794e-02f, 7.43123963e-02f, 5.62405474e-02f,
  1.83477446e-01f, -7.68561810e-02f, 2.53010869e-01f, 1.17907174e-01f, -5.55801578e-02f, -1.62697107e-01f, 5.75746149e-02f, -1.08856708e-01f, -9.00720656e-02f, -8.07862207e-02f,
  4.34005819e-02f, -6.98787868e-02f, 6.83671162e-02f, -9.10186842e-02f, -2.09945932e-01f, -1.07330784e-01f, -1.38105020e-01f, -6.77191690e-02f, -1.62849631e-02f, -2.20340546e-02f,
  1.05353341e-01f, -5.36739454e-02f, 3.46530438e-03f, 2.69298721e-02f, 1.00264221e-01f, 1.55532314e-02f, -5.83031401e-03f, 9.64457449e-03f, -2.57506538e-02f, -1.56580985e-01f,
  3.43204856e-01f, 2.87676156e-01f, 2.40745023e-01f, 1.38043031e-01f, 7.75686577e-02f, 1.34274051e-01f, 2.91361287e-02f, 5.58569208e-02f, 7.31355324e-02f, 1.28285021e-01f,
  2.20469795e-02f, 2.21131191e-01f, 7.54412413e-02f, 1.35357499e-01f, 2.36725971e-01f, 8.44411552e-02f, 6.69445097e-02f, 4.59651500e-02f, 3.74786593e-02f, -2.85382010e-03f,
  1.88179150e-01f, -9.02042985e-02f, -1.15308613e-01f, -3.78515385e-02f, -5.28555587e-02f, 1.23985196e-02f, 9.63419080e-02f, 3.01379971e-02f, 9.43929255e-02f, -1.59656733e-01f,
  7.80052468e-02f, 3.24074000e-01f, 9.72645283e-02f, -1.19019911e-04f, -3.38312872e-02f, -8.34240392e-02f, 1.63950637e-01f, -1.94064096e-01f, -1.56489372e-01f, -1.23194039e-01f,
  -7.76056275e-02f, -1.39577687e-01f, -7.60967731e-02f, 5.71530359e-03f, 6.02929806e-03f, 8.90685711e-03f, 1.20886564e-02f, 1.40015706e-01f, -6.80064633e-02f, -6.70888051e-02f,
  -4.54356931e-02f, 8.33592340e-02f, 1.28576338e-01f, 8.40824768e-02f, 1.17862180e-01f, 2.11905271e-01f, 1.91826429e-02f, 2.39776503e-02f, 5.25956303e-02f, -3.63681577e-02f,
  -1.57272622e-01f, -2.46245980e-01f, -5.54620549e-02f, -3.24029148e-01f, 6.91500083e-02f, 6.26965985e-02f, -1.99340537e-01f, -1.79798692e-01f, -2.14467660e-01f, -2.55350798e-01f,
  8.64712447e-02f, 2.69685984e-01f, 7.31279254e-02f, 1.10543728e-01f, 1.36698067e-01f, -1.97934657e-01f, -2.54854821e-02f, 2.68975079e-01f, 4.00910974e-01f, 2.99384803e-01f,
  1.15903646e-01f, 4.72259484e-02f, 1.70302719e-01f, 1.60925254e-01f, -2.62967825e-01f, -2.91310623e-02f, -1.38307005e-01f, -2.21666344e-03f, 7.46092424e-02f, -1.28584757e-01f,
  -2.61150837e-01f, -2.82878041e-01f, 4.67337156e-03f, 1.50346443e-01f, 5.85868321e-02f, -1.47764832e-01f, -1.00475229e-01f, -1.25390932e-01f, 4.01008688e-02f, -1.51869133e-01f,
  3.25005059e-03f, 1.08334720e-02f, 4.33915434e-03f, -7.42308199e-02f, -4.77870703e-02f, -8.19814429e-02f, 4.44463529e-02f, 8.85058343e-02f, -2.77386308e-02f, 5.95609844e-02f,
  1.44525588e-01f, 1.34315908e-01f, -4.13008854e-02f, -4.96954545e-02f, -1.87505051e-01f, 6.36275997e-03f, -1.15075566e-01f, 4.05020826e-02f, -2.03242283e-02f, -3.02734166e-01f,
  1.45508662e-01f, 4.36315015e-02f, 1.82984769e-02f, -4.22490351e-02f, -1.05684781e-02f, -3.83157618e-02f, -3.87836620e-02f, -1.52109275e-02f, 1.01946622e-01f, -5.06314076e-02f,
  9.96678695e-02f, 1.21489778e-01f, 2.40396112e-01f, 4.01386730e-02f, 6.82923049e-02f, -1.03644103e-01f, -6.41896296e-03f, 5.55438129e-03f, -5.11530451e-02f, 2.39968225e-02f,
  8.30866471e-02f, -1.48762595e-02f, 4.20055427e-02f, 4.97583486e-02f, 4.97663319e-02f, 5.98186851e-02f, -7.97584131e-02f, 3.46086547e-02f, -1.02978893e-01f, 2.00077575e-02f,
  -4.03916508e-01f, 2.39885733e-01f, -2.57009655e-01f, 1.86728965e-03f, -1.12933986e-01f, 5.61674461e-02f, -4.18435894e-02f, -1.66355789e-01f, -1.48437768e-01f, -1.28212601e-01f,
  -7.14967214e-03f, -9.35103819e-02f, -1.89891592e-01f, 7.21974820e-02f, -3.90835702e-02f, -1.30711496e-01f, -1.71115417e-02f, -1.01276068e-02f, 3.46925482e-02f, 3.67462821e-02f,
  -4.85730730e-02f, -1.50523022e-01f, -1.05160207e-01f, -1.26533002e-01f, -4.12300378e-02f, 6.86794445e-02f, -1.52831361e-01f, -6.69780672e-02f, -6.92418292e-02f, -4.20748204e-01f,
  2.91124523e-01f, -7.32172728e-02f, 1.03568695e-01f, 7.44045228e-02f, -1.95991173e-01f, -2.43417904e-01f, -2.07655653e-01f, -2.25345448e-01f, -9.76223499e-02f, -8.76976252e-02f,
  -9.24528912e-02f, -6.16982253e-03f, 2.28273645e-01f, 3.70622985e-02f, 4.84176055e-02f, 5.02615459e-02f, -8.56897905e-02f, 9.31658223e-02f, -4.41995859e-02f, -2.47322783e-01f,
  -2.07390770e-01f, -4.01125699e-02f, 2.14299071e-03f, -2.23324522e-02f, 4.63158600e-02f, -4.02603187e-02f, 9.10168216e-02f, -1.40897380e-02f, -9.99253020e-02f, 7.59750828e-02f,
  3.48167956e-01f, -6.74979165e-02f, -1.26451142e-02f, -1.54455438e-01f, -9.07554626e-02f, -7.04222918e-02f, -2.10016617e-03f, -8.18249658e-02f, -6.00447915e-02f, -4.57476899e-02f,
  -5.27092703e-02f, -6.97307289e-02f, 1.24426754e-02f, -9.65881627e-03f, -5.83624914e-02f, -7.39916868e-04f, -2.65671369e-02f, -8.70115757e-02f, -2.65234169e-02f, -7.95409009e-02f,
  -1.13639660e-01f, -1.08725406e-01f, 6.00937046e-02f, -1.00531600e-01f, -5.01352176e-02f, -2.52880678e-02f, 2.56783441e-02f, -5.11900596e-02f, -1.15489356e-01f, 9.96772572e-02f,
  -1.39708117e-01f, 2.53733788e-02f, -1.28709093e-01f, -6.55500814e-02f, -8.23693350e-02f, -7.88205713e-02f, -5.77005334e-02f, 1.97888575e-02f, -2.47626659e-02f, -1.07400017e-02f,
  -1.76391438e-01f, -1.24791833e-02f, -1.41282782e-01f, 8.14136583e-03f, -1.02773026e-01f, -1.25891091e-02f, -4.94000129e-03f, -7.55854771e-02f, -9.66039449e-02f, -4.82835248e-02f,
  -4.20533819e-03f, 9.21815168e-03f, -1.00795075e-01f, -1.19614385e-01f, -7.72050470e-02f, -2.14946195e-02f, -1.48315340e-01f, 1.07365083e-02f, -6.35284409e-02f, -5.27427457e-02f,
  2.28382394e-01f, -2.00737149e-01f, 1.86968222e-01f, -2.00314168e-02f, -1.23498976e-01f, -2.08021685e-01f, -5.89985847e-02f, -1.08944543e-01f, -3.39415111e-02f, -1.45623431e-01f,
  -1.30857959e-01f, -8.97748247e-02f, 1.15323693e-01f, -5.40848821e-02f, -8.47860947e-02f, 3.78924422e-02f, -1.64475471e-01f, 1.19174942e-02f, -1.16930448e-01f, -9.74777043e-02f,
  -8.94257426e-02f, 4.78835478e-02f, 1.57217830e-01f, 1.64374337e-01f, 6.17652340e-03f, 7.58723989e-02f, 6.63116202e-02f, 4.27149087e-02f, -3.51669379e-02f, 1.34721383e-01f,
  -5.72725773e-01f, -3.02499175e-01f, -2.35615522e-01f, -5.20704687e-01f, -4.06308174e-01f, -1.27432540e-01f, -2.96188146e-01f, -1.32014990e-01f, -2.64578462e-01f, -3.12226802e-01f,
  3.39967050e-02f, 2.10705385e-01f, 6.42351434e-02f, -3.24627906e-02f, -2.22666990e-02f, -3.73092651e-01f, -3.70730758e-01f, -2.08441511e-01f, 6.65505752e-02f, -1.23486735e-01f,
  -1.52604446e-01f, -3.34686428e-01f, -1.27835602e-01f, -4.24210243e-02f, -1.76943198e-01f, 1.01163452e-02f, -1.72567710e-01f, -2.24606186e-01f, -1.31082848e-01f, -3.12327832e-01f,
  4.84999791e-02f, -9.60172340e-02f, 3.36103402e-02f, 3.40224206e-02f, -6.89081103e-02f, -4.16544601e-02f, 2.13058405e-02f, 1.13685355e-02f, -6.16284646e-02f, -1.13201395e-01f,
  -6.55782521e-02f, 6.13533109e-02f, 1.79016925e-02f, 4.01014090e-02f, -1.89160034e-01f, -4.89501022e-02f, -5.69287054e-02f, -1.44939020e-01f, -7.07619563e-02f, 8.58996063e-02f,
  3.08255162e-02f, -1.20895110e-01f, 6.26402944e-02f, 6.09787218e-02f, 1.40958205e-02f, 5.98555356e-02f, 7.61486366e-02f, 1.25109583e-01f, 4.36026342e-02f, -1.08682968e-01f,
  -1.14211239e-01f, 2.13239323e-02f, 1.01357229e-01f, 8.08277540e-03f, 3.34846713e-02f, 8.55112523e-02f, 4.90681902e-02f, 8.51520896e-02f, 9.35376137e-02f, 4.65277908e-03f,
  5.70248738e-02f, 7.01057911e-02f, 9.95808169e-02f, -1.85307916e-02f, 7.80425360e-03f, 8.85353982e-02f, 3.32436003e-02f, -5.25722541e-02f, 3.35238613e-02f, -1.19690234e-02f,
  -6.72691967e-03f, 3.23818214e-02f, -5.72453924e-02f, 1.02287330e-01f, -5.46237342e-02f, -1.13475539e-01f, -7.15029659e-03f, 5.34984134e-02f, -6.49423227e-02f, -5.49331866e-02f,
  1.57458082e-01f, 1.09544834e-02f, -1.15241602e-01f, 5.35090826e-03f, -1.18692638e-02f, -1.86193772e-02f, 3.13794650e-02f, -5.93295731e-02f, -8.93891975e-02f, 2.18137447e-02f,
  7.44782090e-02f, -1.38434516e-02f, -4.76798229e-02f, 1.12651158e-02f, -5.36230952e-02f, 5.14563508e-02f, -1.46158546e-01f, -8.34429413e-02f, 8.93577412e-02f, 7.13756755e-02f,
  -5.49423210e-02f, -5.25191985e-02f, 1.15545727e-02f, -5.13575459e-03f, 2.44588796e-02f, 1.40893862e-01f, 1.48617074e-01f, 5.02776057e-02f, 1.03811175e-01f, -2.38083452e-01f,
  -9.35219526e-01f, -3.87477875e-01f, 4.38417166e-01f, -5.96235394e-01f, -2.10014898e-02f, 2.35288933e-01f, 1.35115683e-01f, -1.17519975e-01f, -1.72756657e-01f, -4.77401614e-02f,
  -1.65373161e-01f, -2.10168093e-01f, -1.25971004e-01f, -9.32318941e-02f, -1.49944589e-01f, 4.27815408e-01f, 2.45394453e-01f, -4.79801418e-03f, -4.95840609e-02f, -1.45279691e-01f,
  -1.09997176e-01f, -3.73365015e-01f, -5.25427163e-01f, -3.33600283e-01f, -1.82178915e-01f, -1.97213218e-01f, -9.33867041e-03f, -2.12375090e-01f, -1.08755333e-02f, -1.72122270e-01f,
  4.05288041e-01f, -3.90499830e-01f, 7.88334832e-02f, -2.14118049e-01f, -2.33394951e-02f, -1.61731109e-01f, -7.91747943e-02f, -1.20010003e-01f, -2.30823338e-01f, -5.30493027e-03f,
  -8.48143846e-02f, -4.77316566e-02f, 2.28324290e-02f, 1.18840262e-02f, -9.56882611e-02f, -9.04591382e-03f, -8.52580890e-02f, -1.27833128e-01f, -1.51317880e-01f, 5.15738204e-02f,
  8.05290067e-04f, -1.02009192e-01f, 1.05411030e-01f, -3.90605554e-02f, -1.47897333e-01f, -9.92717966e-02f, -9.18353871e-02f, -8.27452764e-02f, 1.57141779e-02f, -1.01187989e-01f,
  1.70725003e-01f, 4.26654443e-02f, -6.96422979e-02f, -1.52879015e-01f, -9.27376822e-02f, 1.40367188e-02f, -8.14357772e-02f, -1.40473694e-01f, -7.20909331e-03f, -4.47105356e-02f,
  -1.38649508e-01f, -2.41123363e-02f, -5.09442911e-02f, -9.17550102e-02f, -8.53101835e-02f, -1.77136049e-01f, -1.45220339e-01f, -5.74630201e-02f, -2.14661490e-02f, -1.04812257e-01f,
  -1.18658811e-01f, -5.60301095e-02f, -9.02956948e-02f, -1.84851754e-02f, -5.25415950e-02f, -1.06734693e-01f, 4.23581414e-02f, -2.02222429e-02f, 5.72579093e-02f, -1.26618192e-01f,
  -5.83728068e-02f, 3.40886042e-03f, 5.74350990e-02f, -5.83691895e-02f, 4.08772426e-03f, 2.07269359e-02f, 1.03980443e-02f, -3.60222459e-02f, -9.96082462e-03f, 6.65692836e-02f,
  4.49061804e-02f, 8.10386017e-02f, -4.87882970e-03f, -1.01521999e-01f, -4.11198512e-02f, 1.18170097e-01f, -2.84348410e-02f, 3.22895162e-02f, 1.36803566e-02f, 8.60863477e-02f,
  1.24255598e-01f, 8.58500004e-02f, 1.05093233e-01f, 1.66960925e-01f, 1.24253556e-01f, 1.69746056e-01f, 1.46631882e-01f, 9.34556052e-02f, 2.18570948e-01f, 1.94227099e-01f,
  6.73465788e-01f, -1.68865129e-01f, 1.34667695e-01f, 1.13990335e-02f, -1.15649346e-02f, 1.80205442e-02f, -4.48124930e-02f, 4.63925768e-03f, 1.65951595e-01f, 1.17387667e-01f,
  1.09238148e-01f, 2.39231780e-01f, 2.15016156e-01f, 5.58747128e-02f, 2.08983779e-01f, 5.16884290e-02f, 4.52062860e-02f, 2.51438141e-01f, 2.08878621e-01f, 1.66491523e-01f,
  7.54788667e-02f, 2.58986093e-02f, 1.81879133e-01f, 8.11502337e-02f, 1.04157351e-01f, 2.95987781e-02f, -1.87784079e-02f, -8.77293665e-03f, 7.35202804e-02f, -4.56253551e-02f,
  -1.86016057e-02f, 7.37878680e-02f, 7.77968988e-02f, 5.38682230e-02f, -3.41403298e-02f, -5.59984939e-04f, 6.50510518e-03f, -1.26545012e-01f, -1.17709208e-02f, -1.29900575e-01f,
  -1.16314724e-01f, -3.74526791e-02f, 6.45599188e-03f, -4.64125350e-02f, 1.37285739e-02f, 6.55484796e-02f, 6.94891345e-03f, -2.67583746e-02f, 5.86403087e-02f, -7.97402486e-03f,
  -2.46289130e-02f, -3.22166830e-02f, 8.06405302e-03f, -1.38111254e-02f, 1.06705576e-01f, 6.56424612e-02f, 6.58665597e-02f, -3.28796469e-02f, 1.29174501e-01f, 3.38710472e-02f,
  9.87780169e-02f, 2.74160922e-01f, 2.61178374e-01f, 2.20373213e-01f, 2.23154873e-01f, 1.47289678e-01f, -3.95175628e-02f, -1.01289906e-01f, 1.47558451e-01f, 1.47548899e-01f,
  1.10532962e-01f, 1.42133504e-01f, -4.14396562e-02f, 3.23513485e-02f, 1.04192555e-01f, 5.58333844e-02f, -1.38204575e-01f, -4.40187678e-02f, 3.49025726e-02f, -2.16643512e-03f,
  1.38755888e-01f, 1.02455668e-01f, -1.33908298e-02f, 7.22567141e-02f, 4.05817814e-02f, 5.20208180e-02f, 1.14650894e-02f, 5.65836094e-02f, 7.55680427e-02f, 1.09467477e-01f,
  -3.97450596e-01f, 1.55454248e-01f, 1.36139423e-01f, 8.28449521e-03f, -1.21029176e-01f, -3.16759981e-02f, 4.25471812e-02f, -1.09252937e-01f, -2.54396647e-01f, -1.59958288e-01f,
  -1.74964219e-01f, -2.46109013e-02f, 4.41223904e-02f, 3.78932059e-02f, -2.68849923e-04f, -1.17756492e-02f, -4.54011858e-02f, 8.15895852e-03f, -3.11307888e-02f, -1.49578154e-01f,
  -3.86154130e-02f, -7.50061264e-03f, 8.91736243e-03f, -1.02351516e-01f, -1.62333495e-03f, -7.85207958e-05f, -1.24656506e-01f, 2.02940144e-02f, 2.21616849e-02f, 2.98196310e-03f,
  -3.95931304e-01f, -3.53208244e-01f, 1.44579545e-01f, 7.15284124e-02f, 3.50986481e-01f, 3.88086736e-01f, 3.22074682e-01f, 1.06546097e-01f, 1.26750723e-01f, 8.46621692e-02f,
  -2.70825267e-01f, -1.29944593e-01f, -4.13195677e-02f, 3.41268256e-02f, -3.19420248e-02f, 3.11737031e-01f, 3.04929793e-01f, 1.79697976e-01f, 1.82986319e-01f, 1.21221691e-01f,
  1.11985750e-01f, -9.64206606e-02f, -1.27646595e-01f, -2.73654498e-02f, -4.43225773e-03f, 8.63055978e-03f, 3.61952814e-03f, 7.67250955e-02f, -3.48613528e-03f, -3.49385515e-02f,
  -1.32146269e-01f, -1.40678138e-01f, 9.39467400e-02f, -2.40074292e-01f, -1.69200063e-01f, -1.40001878e-01f, 2.93691410e-03f, -1.60591096e-01f, -9.44481939e-02f, -7.88028724e-03f,
  -1.71311516e-02f, -8.05791318e-02f, 5.95477372e-02f, -3.46243046e-02f, -1.33593306e-01f, -7.83867463e-02f, -2.30580375e-01f, -3.89126167e-02f, 1.03621431e-01f, 1.69206057e-02f,
  8.32835492e-03f, 1.43080443e-01f, 6.14699051e-02f, 1.69802368e-01f, 1.23319561e-02f, 7.79285058e-02f, -1.17010877e-01f, -9.69884470e-02f, 3.80332060e-02f, -1.98354218e-02f,
  1.29021287e-01f, 3.05440128e-02f, 6.26472235e-02f, -5.41964509e-02f, 5.31645566e-02f, 4.27304991e-02f, 6.83110729e-02f, 4.45201732e-02f, 9.18638632e-02f, -3.02046295e-02f,
  1.18822053e-01f, 2.07255870e-01f, 7.77188092e-02f, -2.55893487e-02f, 3.61488461e-02f, -4.41539437e-02f, 3.30868624e-02f, 7.33781047e-03f, 2.45430190e-02f, 1.23132281e-01f,
  3.56126986e-02f, -2.53588837e-02f, -2.03795716e-01f, -6.20513363e-03f, -6.44181669e-02f, 1.15513146e-01f, 1.17974661e-01f, 5.41741922e-02f, -5.02509661e-02f, 1.80745311e-02f,
  -3.51362750e-02f, 1.57438621e-01f, 8.11331272e-02f, 6.81710318e-02f, -1.20716467e-02f, -1.59377575e-01f, 1.18148647e-01f, -2.56943181e-02f, -1.81954373e-02f, 4.21151407e-02f,
  -6.39925078e-02f, -1.21063419e-01f, 4.89390679e-02f, -3.17243747e-02f, 8.45774487e-02f, 8.49987268e-02f, -1.08992502e-01f, 9.80927888e-03f, 5.12114614e-02f, 1.58354566e-02f,
  -2.54098009e-02f, 1.38735235e-01f, 1.28614351e-01f, 2.07498193e-01f, 1.66237220e-01f, 1.65543109e-01f, 3.70022133e-02f, 4.98785749e-02f, 1.51035458e-01f, -4.40734029e-02f,
  3.61889377e-02f, -5.29525340e-01f, -5.58830574e-02f, -1.52053639e-01f, -3.36649448e-01f, -1.82712555e-01f, -5.48342764e-01f, -2.76630014e-01f, -1.04699008e-01f, -5.36810815e-01f,
  -1.47077471e-01f, 3.60093474e-01f, 2.11929008e-01f, 1.36658087e-01f, 1.18348718e-01f, -5.74877679e-01f, -3.93410951e-01f, -5.94653211e-05f, 2.96624601e-01f, -2.58348852e-01f,
  -4.14244205e-01f, -2.11819246e-01f, 7.61618689e-02f, 1.57202990e-03f, -2.95158744e-01f, -2.58671269e-02f, -2.47559771e-01f, -2.08539277e-01f, -1.97859317e-01f, -3.29943508e-01f,
  -1.90167889e-01f, 2.98911892e-02f, 2.33647957e-01f, 8.34172741e-02f, -6.36793748e-02f, 9.60462391e-02f, -4.37147170e-02f, 6.39013872e-02f, -5.26361316e-02f, -1.73664950e-02f,
  -5.14972098e-02f, 1.53438486e-02f, 1.65783197e-01f, -4.42136042e-02f, -1.24644332e-01f, -2.33108327e-02f, -1.47716254e-01f, 3.19401291e-03f, -1.18781477e-02f, -2.34288916e-01f,
  -3.14798355e-01f, -2.73301583e-02f, 2.14836836e-01f, -6.93765953e-02f, 1.72986090e-02f, 1.63825139e-01f, -6.09177835e-02f, 1.30242422e-01f, 1.00345112e-01f, -3.76409143e-01f,
  -1.61611333e-01f, 2.52667274e-02f, -4.53524515e-02f, 1.58544313e-02f, -2.08105166e-02f, 3.11126933e-02f, 5.29923216e-02f, -6.23698644e-02f, 2.77827643e-02f, 1.12568466e-02f,
  -9.35014859e-02f, -6.86381310e-02f, 1.13066219e-01f, -5.43255312e-03f, 2.62696501e-02f, -6.46204129e-03f, -9.08367336e-03f, -9.48735476e-02f, 3.12538855e-02f, -9.02232826e-02f,
  6.12554587e-02f, 2.51834691e-02f, -5.79976551e-02f, 6.32912889e-02f, -3.44260037e-02f, -1.09282099e-01f, -5.09572141e-02f, -2.81797126e-02f, -6.69053644e-02f, -5.62564060e-02f,
  1.58591092e-01f, 1.72125921e-01f, -3.97468805e-02f, 2.43658777e-02f, -1.65061638e-01f, -2.02162609e-01f, -9.65660512e-02f, 2.80896015e-02f, 1.39165476e-01f, 5.57390936e-02f,
  -4.16538641e-02f, -3.09277456e-02f, -2.27059983e-03f, -8.32735226e-02f, -1.30086765e-01f, -3.16036046e-02f, -2.87625730e-01f, -1.29674934e-02f, -4.58056517e-02f, -2.32968464e-01f,
  -1.95802569e-01f, -1.50463432e-01f, 7.28448555e-02f, -1.61463134e-02f, -8.18152633e-03f, 1.95719630e-01f, 1.62005052e-02f, 5.57138324e-02f, 7.40728527e-02f, -3.89559209e-01f,
  -3.45135152e-01f, -5.10585669e-04f, -5.47804773e-01f, -2.49178335e-01f, -9.84227168e-04f, 1.19204961e-01f, 2.98274338e-01f, 2.68496573e-01f, 1.92105528e-02f, 4.44536507e-02f,
  5.83751276e-02f, 1.40892401e-01f, -1.04422085e-01f, 9.56445094e-03f, 1.24658622e-01f, 4.84421737e-02f, -1.50600851e-01f, -2.78551161e-01f, -2.33885981e-02f, 3.87824982e-01f,
  2.64632076e-01f, 4.35976125e-02f, -1.23539358e-01f, 5.42095117e-02f, -9.69620328e-03f, -5.95322810e-02f, -3.17817867e-01f, -2.07791865e-01f, -9.69923437e-02f, -3.28833431e-01f,
  -3.88255566e-01f, -9.96522978e-02f, 1.41216904e-01f, 1.49845421e-01f, 3.45238298e-02f, 4.44736220e-02f, 2.03557029e-01f, 1.13270022e-01f, 1.67535737e-01f, -5.61750494e-02f,
  1.09266020e-01f, 3.99987176e-02f, 2.26251438e-01f, 1.72559805e-02f, 1.20135590e-01f, 1.71440039e-02f, -9.97976288e-02f, -1.15106866e-01f, -1.51697978e-01f, 7.96448365e-02f,
  2.25080714e-01f, 8.98052603e-02f, -2.79829711e-01f, -2.02694125e-02f, -1.32676423e-01f, -9.08492655e-02f, -1.23384461e-01f, 3.93440351e-02f, -9.78137460e-03f, -1.33003011e-01f,
  1.44956887e-01f, -1.39725238e-01f, -1.13719933e-01f, -8.75233337e-02f, 2.34037917e-02f, -8.09771568e-02f, -9.40052345e-02f, 6.66706078e-03f, -3.74223292e-02f, -4.53777239e-02f,
  4.29439312e-03f, -8.08720216e-02f, 1.10615417e-02f, 2.74834931e-02f, 2.58182082e-02f, -4.90445532e-02f, 7.34922290e-02f, 1.12768207e-02f, 2.31699273e-02f, 3.69730480e-02f,
  -1.26575321e-01f, -3.93708907e-02f, -6.40997887e-02f, 5.28869331e-02f, -5.37238084e-02f, -6.99181929e-02f, 8.00823197e-02f, 1.88010037e-02f, -7.23679317e-03f, 1.08347982e-01f,
  -1.24367801e-02f, 1.42919540e-01f, -1.17232449e-01f, -1.00029344e-02f, -7.98837841e-02f, -5.50897159e-02f, -4.39227521e-02f, -1.78283639e-02f, -1.75939038e-01f, 2.85030790e-02f,
  3.80184427e-02f, -8.75275657e-02f, -5.64124621e-02f, 6.90279528e-02f, 4.35997695e-02f, -1.32964179e-01f, -3.84573862e-02f, -1.90773815e-01f, -1.15926906e-01f, -1.07678540e-01f,
  -1.53336391e-01f, -2.62624975e-02f, -2.61079103e-01f, -2.40476221e-01f, -6.78601563e-02f, -9.15672854e-02f, -7.84379318e-02f, -5.47571573e-03f, -9.07930806e-02f, -4.52685319e-02f,
  3.01183671e-01f, 1.65034607e-01f, 2.64562964e-01f, 1.31787375e-01f, -7.44377822e-02f, -1.58363745e-01f, -1.09975256e-01f, -9.57529098e-02f, -6.46902397e-02f, -2.80073402e-03f,
  -2.19602898e-01f, -1.61414310e-01f, -1.72914326e-01f, -7.79349282e-02f, 2.97183301e-02f, 8.68112743e-02f, 1.52743965e-01f, 3.33701193e-01f, 1.91330582e-01f, 1.97705254e-02f,
  -5.60363382e-02f, 9.78827477e-02f, 2.35712752e-01f, 1.14336669e-01f, 4.75441292e-02f, -1.60144903e-02f, 7.14037120e-02f, 1.22484513e-01f, 5.93792349e-02f, 2.70804256e-01f,
  1.07230820e-01f, 1.28175512e-01f, -3.13576847e-01f, -6.81546628e-02f, -1.98410265e-02f, 2.84004323e-02f, 1.82326324e-02f, 4.83657233e-02f, -3.13581675e-02f, 2.97315437e-02f,
  4.41313870e-02f, 5.97055517e-02f, -2.41036247e-02f, 5.66059276e-02f, -9.38751176e-03f, -5.37382662e-02f, 1.37559921e-01f, 1.73860803e-01f, 5.35446554e-02f, -2.65028886e-02f,
  -5.14814537e-03f, 5.64334020e-02f, 4.00821455e-02f, -2.03407839e-01f, -1.13965124e-01f, -1.28780946e-01f, -1.10751487e-01f, 6.45688325e-02f, -1.41310140e-01f, 4.85338494e-02f,
  -1.38050333e-01f, 3.03180106e-02f, -8.12736526e-02f, 8.37513655e-02f, 4.42211553e-02f, 5.51001914e-02f, 4.61378098e-02f, 1.84526015e-02f, 1.53324027e-02f, 2.61304170e-01f,
  -1.11074867e-02f, 7.74626210e-02f, 6.19961545e-02f, 6.52852803e-02f, -1.58881873e-01f, 5.26417270e-02f, 8.11853930e-02f, -8.16919208e-02f, -1.28406554e-01f, 5.57563677e-02f,
  4.52805012e-02f, 8.79200473e-02f, 6.21277280e-03f, 1.48855537e-01f, -2.24176738e-02f, -2.10404228e-02f, -5.82969859e-02f, -1.44495694e-02f, -5.71212471e-02f, -8.08197632e-02f,
  -2.71719366e-01f, -3.04070860e-01f, -2.27082580e-01f, -2.67053079e-02f, -1.26080625e-02f, -1.56398758e-01f, -6.66616186e-02f, -5.45119010e-02f, -4.44749221e-02f, -4.43588607e-02f,
  1.08824193e-01f, 8.85723531e-03f, -8.37673545e-02f, -3.32280658e-02f, -7.94824492e-03f, -2.13016346e-01f, -4.51338775e-02f, -3.74225318e-03f, -5.84222525e-02f, 9.30975527e-02f,
  8.60392302e-02f, -1.91160843e-01f, -1.92517877e-01f, -2.81879574e-01f, -3.02325159e-01f, -4.08460110e-01f, -2.31216639e-01f, -1.66807532e-01f, -2.95327544e-01f, -2.14614347e-01f,
  1.86387643e-01f, 2.70637929e-01f, 1.37447506e-01f, -1.59397617e-01f, 7.58854151e-02f, 2.28254795e-01f, 3.13634247e-01f, -9.01852027e-02f, -2.69968837e-01f, 1.20514572e-01f,
  1.46556422e-01f, -2.89546251e-01f, -2.24264070e-01f, -1.99855626e-01f, 6.55051619e-02f, 1.38959631e-01f, 6.42126948e-02f, -7.58715570e-02f, -9.78348106e-02f, 5.07297218e-02f,
  -8.82197320e-02f, 5.23333773e-02f, 8.72082189e-02f, -5.53876720e-02f, -8.77230465e-02f, -2.20588863e-01f, 1.37420654e-01f, 1.50307775e-01f, 2.30751917e-01f, -6.20465800e-02f,
  3.47996950e-02f, 2.14175448e-01f, -1.90948606e-01f, -9.58289877e-02f, 1.24157935e-01f, -6.85509592e-02f, -7.35745504e-02f, -3.45451869e-02f, 4.50688042e-02f, -3.52278687e-02f,
  1.59549385e-01f, 2.35702819e-03f, -2.46475469e-02f, 8.11748430e-02f, 9.35004205e-02f, -2.51555839e-03f, 1.29875476e-02f, -8.92676935e-02f, -1.54347895e-02f, -4.49894294e-02f,
  -1.96925029e-02f, 1.05989031e-01f, 1.51489586e-01f, -7.82986283e-02f, -1.02886103e-01f, -1.74154177e-01f, 1.24608576e-01f, -8.45899954e-02f, -4.48015593e-02f, -1.92313150e-01f,
  -1.77845478e-01f, 7.48090670e-02f, 5.71993478e-02f, -8.40124041e-02f, 1.89888235e-02f, 7.01230625e-03f, -1.06204949e-01f, -4.00552619e-03f, 3.86108011e-02f, 1.10053435e-01f,
  -1.67337388e-01f, -2.12472286e-02f, -8.75247940e-02f, -1.89759925e-01f, -2.33835116e-01f, 1.45131294e-02f, -1.85070783e-02f, -8.56065750e-02f, 1.13430351e-01f, 2.06389278e-03f,
  -7.15869889e-02f, 1.64347533e-02f, -4.57743146e-02f, -9.24558416e-02f, -4.49410826e-02f, -5.38314506e-02f, -1.79611191e-01f, -1.29114673e-01f, -9.80532542e-02f, 4.07270677e-02f,
  -1.59769848e-01f, 3.84829909e-01f, -2.57490516e-01f, -5.69526553e-02f, 4.00059484e-02f, 4.89204749e-03f, -1.18286051e-01f, -7.17594177e-02f, 7.49147311e-02f, -1.45234793e-01f,
  2.16064498e-01f, -1.65665120e-01f, 4.78971004e-02f, -5.04711978e-02f, -4.21430729e-02f, -5.32434881e-02f, 1.52985260e-01f, -8.74231011e-02f, -2.72425860e-02f, -6.41730195e-03f,
  -6.72041178e-02f, 1.59335998e-03f, -2.19562754e-01f, -2.02165037e-01f, -2.24775463e-01f, -3.34011078e-01f, -4.47479226e-02f, -1.06250286e-01f, 3.81451920e-02f, -1.45180911e-01f,
  2.01401219e-01f, 4.63186145e-01f, 2.22800344e-01f, -1.04688846e-01f, -1.45985827e-01f, 8.17116201e-02f, 3.45158845e-01f, 2.26752341e-01f, -1.35664210e-01f, -6.55364916e-02f,
  -1.58656657e-01f, -2.93009222e-01f, -1.97047144e-01f, -9.54891741e-02f, 1.11241095e-01f, 8.38688090e-02f, 3.67726870e-02f, 5.23697399e-02f, 1.36662778e-02f, 2.97846757e-02f,
  -3.13740000e-02f, 8.40100124e-02f, 6.52765483e-02f, 7.38121271e-02f, 2.49349605e-02f, -2.01699123e-01f, 2.18262617e-02f, 1.32530779e-01f, 8.04197788e-02f, 2.83944122e-02f,
  -1.83248267e-01f, 3.04374963e-01f, -3.44655663e-01f, -2.59646922e-01f, -7.61182010e-02f, 2.46754307e-02f, 5.93497232e-02f, 5.15531823e-02f, -3.70627157e-02f, 5.63149415e-02f,
  -1.07554927e-01f, 1.00971833e-01f, -3.38126905e-02f, 1.68370292e-01f, 8.79084170e-02f, 1.08035006e-01f, 1.43398613e-01f, 2.62789816e-01f, 2.65285037e-02f, 3.12756039e-02f,
  -2.15595365e-01f, -9.43857208e-02f, 1.67004168e-02f, 4.23494130e-02f, 2.01559991e-01f, -2.46605858e-01f, 1.51755050e-01f, 1.29511803e-01f, 1.14201657e-01f, 1.06450140e-01f,
  -2.10974976e-01f, 9.83253717e-02f, 1.75526336e-01f, 7.91839808e-02f, 6.16929159e-02f, -2.05767695e-02f, 8.38687271e-02f, -2.00696997e-02f, 3.85242887e-02f, 1.63529500e-01f,
  -2.41267066e-02f, -7.78628588e-02f, 5.56127448e-03f, 5.13152368e-02f, -2.84789383e-01f, 4.52673994e-03f, 1.80225432e-01f, -6.74090013e-02f, -1.46797195e-01f, 1.21212387e-02f,
  -7.80017078e-02f, -8.95647053e-03f, 7.72572532e-02f, 1.46437705e-01f, -1.18871242e-01f, -2.77290907e-04f, -3.40733416e-02f, -4.67129610e-03f, -6.55616000e-02f, -3.94805670e-02f,
  -2.72986889e-01f, -1.21823803e-01f, -2.92356402e-01f, 1.10318333e-01f, 3.49704698e-02f, -4.41162661e-02f, -1.32547036e-01f, -3.50160375e-02f, 1.32704705e-01f, -1.35367978e-02f,
  1.35949552e-01f, 1.84574947e-02f, 3.09109185e-02f, 3.98650207e-02f, -1.06372856e-01f, -4.97510433e-02f, -7.99066275e-02f, -1.23575330e-01f, 4.61883508e-02f, -2.17188541e-02f,
  5.60190761e-03f, -1.79727420e-01f, -3.00577193e-01f, -1.30793005e-01f, -1.06795184e-01f, -4.24440503e-01f, -1.77982897e-01f, -1.23671837e-01f, -6.39970005e-02f, -1.54057384e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  1.85047910e-01f, 5.88433444e-01f, 2.41084009e-01f, 3.42317581e-01f, 6.06317103e-01f, 4.34384376e-01f, 4.59422857e-01f, 3.39697182e-01f, 2.57936746e-01f, 1.97878808e-01f,
  5.92180431e-01f, 3.28738809e-01f, 3.69434625e-01f, 3.45041186e-01f, 2.92157918e-01f, 4.49466676e-01f, 3.30092758e-01f, 2.38886610e-01f, 2.22628325e-01f, 1.21688664e-01f,
  1.79651752e-01f, 4.51871276e-01f, 1.89722344e-01f, 2.28601694e-01f, 2.43303835e-01f, 3.35371107e-01f, 4.37757701e-01f, 4.04422283e-01f, 3.66966933e-01f, 4.52491313e-01f,
  3.61384630e-01f, 3.10636222e-01f, 3.40025574e-01f, 1.80689842e-01f, 2.16618881e-01f, 4.56269711e-01f, 5.32460153e-01f, 5.98621845e-01f, 5.29210456e-02f, 2.67828673e-01f,
  4.70083416e-01f, 5.49349248e-01f, 4.71846223e-01f, 1.55818328e-01f, 3.14708352e-01f, 2.84731239e-01f, 2.82218039e-01f, 2.82493949e-01f, 3.88485193e-01f, 3.73023391e-01f,
  1.92219764e-01f, 1.49158880e-01f, 2.64054805e-01f, 2.41500974e-01f, 2.50045627e-01f, 2.58961141e-01f, 2.65899450e-01f, 3.83797377e-01f, 2.61238605e-01f, 4.07963693e-01f,
  2.57543504e-01f, 3.59867603e-01f, 2.58725405e-01f, 3.36452164e-02f, 1.22153394e-01f, 2.52846301e-01f, 2.52409279e-01f, 3.88582200e-01f, 3.90712619e-01f, 1.46554381e-01f,
  4.10155207e-01f, 2.49031529e-01f, 3.92953336e-01f, 2.28776351e-01f, 2.16307208e-01f, 3.05475920e-01f, 3.81764144e-01f, 3.08377117e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  2.43593156e-02f, -8.84251371e-02f, -1.56709388e-01f, -1.05612822e-01f, 1.66732650e-02f, 3.98460329e-02f, -8.24731067e-02f, 8.49440619e-02f, -1.16346493e-01f, -1.04516879e-01f,
  -2.04167649e-01f, -1.01474663e-02f, -1.64181769e-01f, -2.80637205e-01f, -8.00289437e-02f, -1.00991286e-01f, -9.32107940e-02f, -1.54893249e-01f, -2.62079656e-01f, 8.91941637e-02f,
  3.61832231e-02f, -1.06805615e-01f, -1.54083207e-01f, -7.47655034e-02f, -2.19736218e-01f, 7.93240070e-02f, 1.88417986e-01f, 8.53223950e-02f, 5.63457012e-02f, 4.14166488e-02f,
  3.57983704e-03f, -9.31603014e-02f, 1.17013231e-01f, 1.78197790e-02f, -1.02889903e-01f, 2.17891093e-02f, -8.38876367e-02f, -2.74635702e-01f, 1.56857222e-02f, -1.14174426e-01f,
  -1.18435837e-01f, -2.64741719e-01f, 1.32220924e-01f, -8.61281380e-02f, 1.49967641e-01f, -1.98040769e-01f, -1.18322130e-02f, -1.52263373e-01f, -7.12931231e-02f, 1.13743216e-01f,
  1.81299135e-01f, -1.46854088e-01f, 2.27965653e-01f, -3.07596296e-01f, -1.84237018e-01f, -1.95780113e-01f, 3.07854325e-01f, 1.98586151e-01f, -4.64546055e-01f, -4.67745662e-01f,
  -4.76103991e-01f, -3.69521022e-01f, -1.00616943e-02f, 1.71281353e-01f, -1.77005976e-01f, -1.98548362e-01f, -1.91642329e-01f, 3.10360670e-01f, 2.91926563e-01f, -6.81799725e-02f,
  -2.83625096e-01f, -3.45873684e-01f, 8.50557610e-02f, 2.67064214e-01f, 1.99957758e-01f, 4.39736247e-01f, -1.45185575e-01f, 1.48829669e-01f, -1.15960672e-01f, -1.01672545e-01f,
  1.25518501e-01f, -3.21830511e-02f, 2.30845526e-01f, 1.08362570e-01f, -3.32471058e-02f, 1.68253798e-02f, -8.68222341e-02f, -4.11741108e-01f, 2.90085882e-01f, 4.12927754e-02f,
  -3.57037902e-01f, -2.25713521e-01f, -3.97355735e-01f, -2.62200981e-01f, -2.56353229e-01f, 1.49986267e-01f, 2.72969991e-01f, 4.82256822e-02f, -5.59716105e-01f, -1.05227418e-01f,
  -2.54798621e-01f, 1.45926490e-01f, -2.69058406e-01f, -1.29036292e-01f, -1.02818221e-01f, -7.71727264e-02f, -7.97748864e-02f, -6.67514384e-01f, -9.46690664e-02f, 8.96556377e-02f,
  3.43936533e-01f, 2.27069512e-01f, 2.54165202e-01f, 7.97736570e-02f, 3.26956153e-01f, 2.58734673e-01f, -3.62996817e-01f, 3.03489834e-01f, -1.94798693e-01f, 1.57817483e-01f,
  -4.56176400e-01f, -2.61629730e-01f, -2.05794841e-01f, 1.94141433e-01f, 3.80427420e-01f, -1.46357685e-01f, -3.53568435e-01f, 1.57393590e-01f, -5.78090409e-03f, 7.98692331e-02f,
  3.10610514e-02f, -7.18231872e-02f, 1.13646053e-01f, -4.32545170e-02f, 1.15854919e-01f, 8.67825374e-03f, -7.07413927e-02f, -4.86606471e-02f, 4.37049493e-02f, 7.74162933e-02f,
  6.72515109e-02f, -1.83676660e-01f, -1.21368483e-01f, -1.20234154e-01f, 1.45072609e-01f, -1.34564951e-01f, 7.16225430e-02f, -1.76774152e-03f, 1.51420999e-02f, 1.02756500e-01f,
  -1.51223829e-02f, 9.91688222e-02f, 2.17568964e-01f, 4.03370857e-02f, 1.24553688e-01f, 1.58343181e-01f, 2.06357419e-01f, -1.34500161e-01f, -8.57540444e-02f, 1.69346020e-01f,
  1.18940525e-01f, 1.46522462e-01f, -1.15093634e-01f, -1.27933741e-01f, 1.45246089e-01f, -8.38645622e-02f, 6.89422712e-02f, 5.06112445e-03f, -1.72550738e-01f, -1.46599308e-01f,
  3.10296025e-02f, -1.17652807e-02f, 1.48495123e-01f, 1.09531015e-01f, 1.93871900e-01f, -2.55321145e-01f, -1.55170858e-01f, 5.98327182e-02f, 7.93870911e-02f, -4.68409032e-01f,
  -1.39321322e-02f, -3.06164205e-01f, -1.35590747e-01f, -2.71533012e-01f, 2.96981812e-01f, 5.70608616e-01f, -4.07189757e-01f, -5.04698396e-01f, -7.27312326e-01f, 3.45864296e-02f,
  5.09502590e-01f, 4.21375304e-01f, -1.49720445e-01f, -6.88526094e-01f, 4.76700738e-02f, 4.46370184e-01f, -4.08608288e-01f, 3.16793710e-01f, 1.41320378e-01f, 7.74053633e-02f,
  1.03397541e-01f, -3.65582108e-01f, 3.01753789e-01f, 3.24640244e-01f, -1.46507517e-01f, -6.59406602e-01f, -2.01763853e-01f, 7.36518875e-02f, -1.70306623e-01f, 3.58358473e-01f,
  -4.87458438e-01f, -2.08822191e-01f, -3.58689129e-01f, -1.17007799e-01f, -1.99793696e-01f, -1.02203138e-01f, -1.27761215e-01f, 1.57394305e-01f, -1.08925670e-01f, 1.28802732e-01f,
  -5.92065990e-01f, 5.37425727e-02f, -5.94160557e-01f, -5.73020279e-01f, -4.92952347e-01f, 7.84933493e-02f, -1.66459188e-01f, -8.10765550e-02f, 1.23137839e-01f, -4.12340574e-02f,
  3.38921994e-01f, -1.86107635e-01f, 1.42575145e-01f, 1.77498296e-01f, -9.03220251e-02f, -4.40038502e-01f, -2.04917639e-01f, -5.10926485e-01f, -2.40299121e-01f, 7.66849220e-01f,
  -2.46969938e-01f, 5.73201180e-01f, -5.31444609e-01f, -2.25876987e-01f, 2.14550003e-01f, 8.67158845e-02f, 1.20477229e-01f, 2.76998252e-01f, -3.57861698e-01f, 3.39974403e-01f,
  9.10779741e-03f, 5.98063648e-01f, -2.87142456e-01f, -2.08047092e-01f, -2.77469486e-01f, -4.15584654e-01f, 5.80872735e-03f, 8.71036723e-02f, 8.89438465e-02f, 4.79754386e-03f,
  1.00421242e-01f, 3.69165395e-03f, 1.90531373e-01f, -3.95615622e-02f, 9.96613875e-02f, -1.37831733e-01f, 2.13115945e-01f, 9.04496089e-02f, 9.10717472e-02f, 2.14077711e-01f,
  4.41437364e-02f, 1.42464608e-01f, -3.51677462e-02f, 2.07737535e-01f, -2.59535722e-02f, 5.31460680e-02f, -5.60100377e-03f, 1.78488433e-01f, 1.06508853e-02f, 1.25820801e-01f,
  5.07341027e-02f, 2.60663450e-01f, -6.45115674e-02f, -2.80819058e-01f, 2.96137184e-01f, -2.55581915e-01f, -2.39020422e-01f, -1.81238681e-01f, 8.71721283e-02f, 2.54159570e-01f,
  -1.86094895e-01f, -2.50845123e-03f, 1.49242982e-01f, -1.26550645e-01f, -1.48441315e-01f, 2.51754403e-01f, 3.13725509e-02f, -1.98844597e-01f, 1.30152896e-01f, -2.07065865e-01f,
  3.16178858e-01f, -1.36140376e-01f, -1.51365131e-01f, -2.07839578e-01f, 9.93380323e-02f, -7.00061694e-02f, 1.63374603e-01f, -2.23945901e-01f, -3.41742158e-01f, 2.15858817e-01f,
  -1.57822147e-01f, 1.62012747e-03f, 3.13927770e-01f, -4.30027068e-01f, 7.62325386e-03f, 8.93715546e-02f, 5.62718585e-02f, 2.25818437e-02f, 3.85554438e-03f, 6.74542338e-02f,
  -3.59826207e-01f, -3.08345824e-01f, -5.02632260e-01f, 5.67310750e-01f, -5.65212607e-01f, -3.04516166e-01f, 1.80884093e-01f, -2.90617734e-01f, 1.48962304e-01f, -2.62478828e-01f,
  -4.08953987e-02f, 4.70015079e-01f, -3.19148779e-01f, -1.38726339e-01f, -1.43843606e-01f, 8.88759643e-02f, -4.23996270e-01f, -1.97972879e-01f, -3.55877966e-01f, 1.38876885e-01f,
  -3.10465336e-01f, -4.43024039e-01f, 1.02981597e-01f, 1.75199389e-01f, -3.42991590e-01f, -7.38126412e-02f, 2.12487325e-01f, 5.74787199e-01f, 4.08055425e-01f, -4.35203105e-01f,
  -2.84060389e-01f, 1.92349449e-01f, -9.20699164e-02f, 3.74995023e-02f, -3.18895310e-01f, -9.65957642e-02f, -1.75573349e-01f, -2.13308185e-01f, -2.18883678e-01f, -4.04320806e-01f,
  -7.85819441e-02f, -4.50250536e-01f, -1.01250447e-01f, -1.13560118e-01f, 1.08954467e-01f, 9.03454900e-01f, 1.43368155e-01f, 2.19926927e-02f, -2.11544409e-01f, -1.18877992e-01f,
  -3.79455209e-01f, 3.30961764e-01f, 4.50079739e-02f, 6.08795524e-01f, -3.59652415e-02f, -2.13185623e-01f, 4.59513180e-02f, -4.06718627e-02f, -1.95016772e-01f, 3.01709086e-01f,
  -4.03241694e-01f, 1.30609408e-01f, 2.49782689e-02f, -5.14736585e-02f, -2.17495169e-02f, 1.10242523e-01f, 9.28494558e-02f, -9.57334414e-02f, -1.29673276e-02f, -9.44950357e-02f,
  4.10869950e-03f, -6.82495069e-03f, -4.34805632e-01f, -3.57354730e-02f, 3.85059714e-02f, -1.58639058e-01f, -1.69074953e-01f, 5.42771369e-02f, 4.01663128e-03f, 5.10312989e-02f,
  -6.16623946e-02f, 2.52796747e-02f, 5.18156886e-02f, -7.97519982e-02f, 8.89484957e-02f, -5.03200144e-02f, -1.94623083e-01f, 2.33744327e-02f, -9.05594304e-02f, 1.20047063e-01f,
  3.61715145e-02f, -1.87409952e-01f, -8.27905387e-02f, -2.53653288e-01f, -3.83467264e-02f, -1.03669152e-01f, 5.02169356e-02f, -1.92258209e-01f, -1.61737651e-01f, 9.51184407e-02f,
  -3.52503769e-02f, 3.86739880e-01f, -1.90087929e-01f, -2.66287535e-01f, 1.14665210e-01f, 4.10689592e-01f, -8.64679739e-03f, 1.16887026e-01f, -8.49863514e-02f, 6.22797124e-02f,
  6.76450357e-02f, 1.30927013e-02f, 7.82766417e-02f, -2.95766622e-01f, 2.56917655e-01f, 3.16658854e-01f, -7.26258308e-02f, -2.55826175e-01f, -6.00885868e-01f, 2.78313249e-01f,
  -5.83176076e-01f, -6.38354182e-01f, 3.62318784e-01f, 3.83089989e-01f, 1.14421844e-01f, -5.14561474e-01f, -6.56683743e-02f, -3.39270294e-01f, 3.98878336e-01f, 2.00851589e-01f,
  -5.52779853e-01f, 1.76030606e-01f, 1.09390512e-01f, -1.13034390e-01f, -1.68400601e-01f, -6.89522326e-01f, -1.33094713e-01f, 3.57509345e-01f, -2.29303002e-01f, -4.80278403e-01f,
  -3.11625689e-01f, -2.39013076e-01f, -3.29021037e-01f, -1.87542841e-01f, 1.22091817e-02f, -2.22988650e-01f, 3.52210045e-01f, -1.72916308e-01f, 2.37861395e-01f, 5.63416667e-02f,
  -1.85876265e-01f, 3.98358524e-01f, 2.48595923e-01f, -3.11938912e-01f, -4.80174273e-01f, -1.71644986e-01f, -3.18924576e-01f, -5.01652360e-01f, -1.79630563e-01f, 2.03031734e-01f,
  2.14285478e-01f, -4.11733180e-01f, 3.01918328e-01f, -4.09687534e-02f, -4.48726445e-01f, -2.21794397e-01f, -4.59617615e-01f, 1.33462086e-01f, -3.19704324e-01f, -5.96609451e-02f,
  2.02521414e-01f, 3.76451999e-01f, -2.38553062e-01f, 4.18430567e-01f, -1.66310832e-01f, -2.56368448e-03f, -2.38915622e-01f, 4.62195743e-03f, -2.89644480e-01f, -1.23886131e-01f,
  -3.72806430e-01f, 1.74185753e-01f, -4.03273314e-01f, 9.58843157e-02f, 4.60906714e-01f, -5.06306533e-03f, 2.35689774e-01f, -1.49319604e-01f, 2.45859087e-01f, -3.81403834e-01f,
  2.35025078e-01f, 4.69434150e-02f, -1.08549371e-01f, -5.78336641e-02f, 1.38051650e-02f, -9.06004086e-02f, -7.25729540e-02f, -1.10530689e-01f, 1.81243107e-01f, -1.23166651e-01f,
  1.33310154e-01f, 2.98461970e-02f, -3.27666365e-02f, -1.76750973e-01f, 2.18931019e-01f, 1.11531317e-01f, 1.37604833e-01f, 4.94191870e-02f, -1.17678687e-01f, 7.69516453e-02f,
  1.94482617e-02f, -1.17966339e-01f, -2.43655190e-01f, 2.00397037e-02f, 5.16296402e-02f, -1.54386610e-01f, 4.57232520e-02f, 3.48812318e-03f, -1.84143111e-01f, 3.90661173e-02f,
  3.70459631e-02f, 1.71946988e-01f, 4.86040041e-02f, 4.46499363e-02f, -1.43605977e-01f, -1.51629388e-01f, -1.00073874e-01f, 2.55510360e-01f, -4.38630395e-02f, 3.36583108e-02f,
  -6.11713417e-02f, 8.71459991e-02f, -4.03706990e-02f, 3.77198458e-02f, 4.57040146e-02f, -1.05087496e-01f, -2.46441841e-01f, 1.47716895e-01f, -1.40212640e-01f, 2.60767844e-02f,
  7.49545693e-02f, 2.74141669e-01f, -3.56927551e-02f, 8.27900991e-02f, 1.38154954e-01f, 4.17325944e-01f, -1.32371247e-01f, 4.88347411e-02f, -6.52175546e-01f, -3.07778597e-01f,
  3.25554222e-01f, 2.14020744e-01f, 4.53183979e-01f, 2.23295041e-03f, -5.08282781e-01f, 1.97848886e-01f, -2.91598827e-01f, 4.73552763e-01f, 2.20226482e-01f, -1.75720692e-01f,
  -1.24913946e-01f, -3.38152379e-01f, 8.86946842e-02f, 3.86053950e-01f, 1.90239046e-02f, -8.96966979e-02f, -2.15131819e-01f, -3.92006397e-01f, 1.51792616e-01f, -2.92331040e-01f,
  -1.73938483e-01f, -5.54385126e-01f, -2.12582368e-02f, -2.68256605e-01f, -3.43564481e-01f, -4.23594229e-02f, 2.82714188e-01f, 1.21656895e-01f, -3.01139176e-01f, -6.00783646e-01f,
  -1.30372807e-01f, -2.30174661e-01f, -2.18331993e-01f, -1.10381521e-01f, 1.71964213e-01f, 1.96858108e-01f, 3.24532911e-02f, 2.01426014e-01f, -5.74913137e-02f, -1.28771961e-01f,
  1.33266687e-01f, -3.61349732e-01f, 4.39189672e-01f, 1.52249888e-01f, 3.54928970e-01f, -1.32898733e-01f, -5.77839427e-02f, -1.53304100e-01f, -8.94373879e-02f, 2.16797456e-01f,
  2.79583149e-02f, -2.76176214e-01f, 7.94018507e-02f, -1.23722516e-01f, 3.48482817e-01f, -4.27308738e-01f, 3.05689871e-01f, 1.82068378e-01f, 9.74632353e-02f, -3.60038847e-01f,
  8.06277171e-02f, 7.89617524e-02f, 9.73873585e-02f, -1.29240111e-01f, -9.26304311e-02f, 8.47278312e-02f, -3.05481881e-01f, -3.98168832e-01f, -3.30046296e-01f, 6.67433813e-02f,
  -4.18531783e-02f, 1.92411780e-01f, 4.68272567e-02f, 2.22303301e-01f, 6.20773956e-02f, 2.11325005e-01f, -1.36676803e-01f, 7.24953264e-02f, 1.31089032e-01f, 3.52553613e-02f,
  5.05114347e-02f, 5.07988855e-02f, 3.69809344e-02f, 6.95700049e-02f, -9.98582765e-02f, 1.65438294e-01f, 7.10918009e-02f, 1.00146435e-01f, 1.77711532e-01f, 4.91880924e-02f,
  -3.16165499e-02f, 9.39103682e-03f, 2.63879240e-01f, 1.72547713e-01f, -1.39159322e-01f, 5.68592437e-02f, 6.03679940e-02f, 2.75760442e-01f, 3.00559729e-01f, 1.39238402e-01f,
  -1.09196246e-01f, 1.78347066e-01f, -1.03560664e-01f, -5.77760162e-03f, 2.80889243e-01f, 1.13693506e-01f, -1.00999683e-01f, -1.83295622e-01f, -1.51508236e-02f, 1.19613506e-01f,
  -2.01428443e-01f, -1.10892981e-01f, 2.03498930e-01f, -7.55966157e-02f, -2.51269370e-01f, 8.84089321e-02f, 1.37929479e-02f, 9.36648995e-02f, -8.40145687e-04f, 1.08432248e-01f,
  -3.02275121e-01f, 4.86954711e-02f, 2.80390114e-01f, -4.98261243e-01f, 6.08622611e-01f, -6.12728059e-01f, 3.08735967e-01f, 2.89006561e-01f, -5.33064544e-01f, -3.87524605e-01f,
  3.37197274e-01f, 6.71126917e-02f, -1.49409860e-01f, -8.32487568e-02f, 4.89356905e-01f, 4.55278084e-02f, 2.02091977e-01f, -6.20930374e-01f, 5.11268318e-01f, -2.57324055e-03f,
  -2.76318401e-01f, 4.41728532e-01f, 2.10731644e-02f, -4.40676779e-01f, 9.98467579e-02f, -1.92422941e-01f, 6.53255880e-01f, 3.71246606e-01f, 3.79861593e-01f, 2.22566769e-01f,
  5.28135061e-01f, -4.22002934e-02f, -2.63433486e-01f, -1.83741692e-02f, -3.87698025e-01f, 2.91491389e-01f, 5.90521209e-02f, -1.84725806e-01f, 2.00246498e-02f, 1.73874497e-01f,
  5.27410448e-01f, -2.88879752e-01f, -1.83957309e-01f, 3.38799320e-02f, 9.94067565e-02f, -2.23816544e-01f, 1.95928261e-01f, 4.68366295e-02f, -5.19227684e-01f, 1.91650361e-01f,
  -4.95937839e-02f, 2.51742214e-01f, 2.38671705e-01f, -4.76457119e-01f, -9.21616564e-04f, -4.75423247e-01f, 2.23273505e-02f, -5.52300103e-02f, -2.57515848e-01f, -6.08270228e-01f,
  2.07586154e-01f, -4.83767897e-01f, 1.39720842e-01f, -3.23343500e-02f, -1.22024044e-01f, -2.81676888e-01f, -3.24353188e-01f, -6.48290575e-01f, 1.16149202e-01f, -2.75673091e-01f,
  -3.03088576e-01f, -1.79568306e-01f, -2.51786858e-01f, -4.55363780e-01f, 2.82916903e-01f, -3.98487747e-01f, 1.33690154e-02f, -2.90073097e-01f, 8.33829679e-03f, -2.66335905e-02f,
  1.46713117e-02f, 5.52961342e-02f, 8.10137317e-02f, -7.52166333e-03f, 5.30628599e-02f, -6.53906241e-02f, -5.94541654e-02f, 4.57167551e-02f, -1.04733996e-01f, -3.15637998e-02f,
  -1.16439201e-01f, 5.95076159e-02f, 1.30925828e-03f, 7.06659332e-02f, 2.62874573e-01f, -8.25588331e-02f, -1.86569393e-01f, 3.99463624e-02f, 6.50626197e-02f, 2.18803082e-02f,
  7.86985084e-02f, -9.49708931e-03f, -8.63883924e-03f, 2.78331518e-01f, -2.13697821e-01f, 2.85427570e-01f, 1.83874458e-01f, -1.12552710e-01f, 1.79990411e-01f, -6.55766129e-02f,
  -1.24563396e-01f, 2.05366582e-01f, 8.63534287e-02f, -4.14085835e-01f, -1.41813442e-01f, -4.06436890e-01f, 1.91783160e-01f, 2.09363475e-01f, 8.78910795e-02f, 9.37525332e-02f,
  -1.39899075e-01f, -3.04998398e-01f, 1.42500550e-01f, -1.74689412e-01f, 2.21225724e-01f, 5.04704975e-02f, -3.36007863e-01f, 7.12698326e-02f, -4.59708273e-01f, -1.67759359e-01f,
  -1.47402838e-01f, 3.46311927e-01f, 4.89195496e-01f, 3.61423120e-02f, -2.43423483e-03f, -3.43178511e-01f, 5.38066149e-01f, -1.49991721e-01f, 4.20598835e-01f, 3.35397512e-01f,
  -2.31409326e-01f, -5.01921594e-01f, -6.35082722e-02f, -3.45383078e-01f, -2.56781336e-02f, -3.66213888e-01f, -3.61657739e-01f, 1.69763938e-01f, -1.57792121e-02f, 2.20532253e-01f,
  1.65262669e-01f, -3.19099784e-01f, -2.17939466e-01f, -1.07277468e-01f, 5.84669337e-02f, -4.70557779e-01f, -2.08175346e-01f, -2.54498690e-01f, -7.35067904e-01f, -1.56867772e-01f,
  -1.91018462e-01f, -3.18978131e-01f, -3.05914551e-01f, -3.93484771e-01f, 6.05602026e-01f, -5.75504243e-01f, -1.99321896e-01f, 6.24859072e-02f, 1.93079516e-01f, -3.79496485e-01f,
  2.12845832e-01f, -2.99676031e-01f, 3.99544299e-01f, -4.40543592e-01f, -4.71411884e-01f, 1.91241741e-01f, -3.59788537e-01f, -2.35461310e-01f, -3.16696614e-01f, -3.59908305e-02f,
  -4.58360732e-01f, -4.27657336e-01f, 1.47133712e-02f, 4.19167280e-01f, -2.26746276e-01f, -1.36286706e-01f, 1.37020737e-01f, 7.70392492e-02f, -6.07825994e-01f, -1.26236707e-01f,
  -5.79198539e-01f, -2.34259546e-01f, 7.43537694e-02f, -1.69989437e-01f, -3.93191934e-01f, -2.15704441e-01f, 2.28415102e-01f, -1.58651292e-01f, -1.87585428e-01f, 6.80666342e-02f,
  -3.67650241e-01f, -3.11907560e-01f, -4.11471784e-01f, 3.94983321e-01f, -1.13987252e-01f, 3.69247288e-01f, -5.05613871e-02f, -1.70581937e-01f, -1.30169377e-01f, 1.03205301e-01f,
  -1.56729162e-01f, 7.64157102e-02f, -2.36340255e-01f, -6.66135922e-02f, -1.41283333e-01f, -1.03052191e-01f, 1.94662474e-02f, -5.56430146e-02f, -1.94176584e-01f, -1.31017819e-01f,
  -3.03877294e-01f, -3.11318874e-01f, -1.85388491e-01f, -2.00387701e-01f, -1.49053885e-02f, -6.31622449e-02f, -5.29436208e-02f, -2.16688938e-03f, -2.20884934e-01f, -7.48471990e-02f,
  1.37273103e-01f, 2.71463264e-02f, -9.45894234e-03f, -2.65570395e-02f, -1.09395966e-01f, 3.98040600e-02f, 7.15607926e-02f, -9.63153616e-02f, -8.56751353e-02f, 9.29365456e-02f,
  -8.54744762e-02f, -5.87468818e-02f, -4.69947010e-02f, 1.11198425e-01f, 2.93491222e-02f, -1.14703462e-01f, 1.22961745e-01f, -2.00003356e-01f, -3.37206833e-02f, 1.55852452e-01f,
  -8.35910439e-02f, -3.42119336e-02f, -8.72558728e-02f, -2.81646907e-01f, 3.56769830e-01f, 1.96320370e-01f, -2.19090953e-02f, 4.65958625e-01f, -2.29364723e-01f, -2.55043536e-01f,
  -9.56970379e-02f, 1.10053077e-01f, -1.28833920e-01f, -1.67844906e-01f, -6.46301731e-02f, 2.26368338e-01f, -3.01686704e-01f, -3.98396075e-01f, -3.52891356e-01f, -1.24722682e-01f,
  -5.19744158e-01f, -2.19887227e-01f, 4.58428860e-02f, -1.81992844e-01f, -2.40291387e-01f, -1.04903154e-01f, -2.88973272e-01f, -9.18771401e-02f, 4.51225303e-02f, 4.41172957e-01f,
  -4.53496069e-01f, -8.41523707e-02f, -1.58469975e-01f, -2.87824631e-01f, 9.96589512e-02f, -1.58336107e-02f, 3.40013206e-01f, -5.10139344e-03f, -2.48028427e-01f, 8.16179514e-02f,
  -3.24690193e-01f, -3.05492938e-01f, -6.58524558e-02f, 2.18276635e-01f, -2.10607588e-01f, -1.87712371e-01f, 3.95645410e-01f, -2.34941453e-01f, 3.11101794e-01f, 1.88040018e-01f,
  -3.70135248e-01f, -3.36244911e-01f, 4.63332474e-01f, -1.70239061e-01f, 3.13434601e-01f, -3.04083854e-01f, -1.55586571e-01f, -3.15981537e-01f, -8.70221481e-02f, 3.42525065e-01f,
  5.38391285e-02f, -4.68462139e-01f, 1.09949499e-01f, 5.64893007e-01f, 1.76182210e-01f, 7.31153879e-03f, -2.06341296e-01f, -4.73415583e-01f, -6.68277889e-02f, -1.18029840e-01f,
  -1.28921553e-01f, -3.36520076e-01f, 1.69829905e-01f, -5.54324780e-03f, -1.04008242e-01f, -3.30030918e-01f, 2.69731224e-01f, -4.18312311e-01f, 2.03076750e-01f, -8.80698040e-02f,
  1.66755497e-01f, -2.18588077e-02f, -1.49807855e-01f, 1.00139983e-01f, -3.20802219e-02f, 1.39299572e-01f, -1.87474105e-03f, 2.14409512e-02f, -2.42640171e-02f, -9.11957771e-03f,
  -1.29129710e-02f, 1.59452632e-02f, 3.08776855e-01f, -8.61135796e-02f, 1.10866204e-01f, -2.22999662e-01f, 9.98730659e-02f, -6.83636032e-03f, 1.09732926e-01f, 4.30953652e-02f,
  1.64166808e-01f, 1.61963582e-01f, -1.27555698e-01f, 2.60624774e-02f, 1.04225948e-01f, -6.86595589e-02f, 1.21240929e-01f, -1.62525252e-01f, 7.86956772e-02f, -5.18190712e-02f,
  1.55194625e-02f, -2.82237679e-02f, -2.79434443e-01f, 3.38163942e-01f, 3.19747895e-01f, 1.43381998e-01f, 5.89384250e-02f, 1.30285723e-02f, 2.81122714e-01f, -8.35595280e-02f,
  -1.45308673e-01f, -2.69470494e-02f, 9.43953693e-02f, -2.66723651e-02f, -7.90005475e-02f, 1.39177933e-01f, -9.64676440e-02f, 2.78904408e-01f, 1.38590872e-01f, -1.32938445e-01f,
  1.62356079e-01f, 2.38263056e-01f, -1.84693020e-02f, -3.13922763e-02f, -3.32052767e-01f, -3.36971462e-01f, -3.20147157e-01f, -1.56128049e-01f, -3.00601870e-01f, -2.35408261e-01f,
  -3.78874779e-01f, -8.69444981e-02f, -2.01441914e-01f, -9.91776064e-02f, -1.53638348e-02f, 1.26295052e-02f, 2.47131824e-01f, -3.47242922e-01f, -3.56663525e-01f, -4.28571641e-01f,
  -4.63693738e-02f, -2.95303941e-01f, -1.82852253e-01f, -1.52647138e-01f, 6.02530576e-02f, 1.86216142e-02f, -4.02676255e-01f, 2.40895256e-01f, 1.03876725e-01f, 4.02549833e-01f,
  -2.56188095e-01f, 5.86994112e-01f, 1.99110508e-01f, -1.68673202e-01f, -5.65631151e-01f, -1.84756562e-01f, 4.16594118e-01f, 2.95378000e-01f, -2.38200575e-01f, -2.00412586e-01f,
  7.60566592e-01f, 6.86436415e-01f, -2.45072514e-01f, -1.63264617e-01f, -6.40201643e-02f, 5.35910904e-01f, -2.20096007e-01f, -1.74869344e-01f, -3.37044120e-01f, -2.90043086e-01f,
  -3.27841431e-01f, -1.61956564e-01f, -2.23751783e-01f, 3.10739487e-01f, -2.17773370e-03f, -3.52218449e-01f, -1.99121207e-01f, -1.23790540e-01f, 3.73449214e-02f, -1.27895787e-01f,
  -3.92756658e-03f, -1.35217175e-01f, -2.45797738e-01f, -1.34062514e-01f, -2.60828227e-01f, -2.43591309e-01f, -1.56153008e-01f, -1.17075751e-02f, -1.93283170e-01f, -1.98086172e-01f,
  6.41207546e-02f, -7.65348151e-02f, 2.61571910e-02f, -2.64387488e-01f, 2.86970586e-01f, 4.24790150e-03f, 3.64699990e-01f, -4.51939762e-01f, -2.82710403e-01f, 5.99104576e-02f,
  5.23208901e-02f, -1.93337873e-01f, 8.66077617e-02f, -7.06748851e-03f, 1.28535122e-01f, 8.77725706e-03f, 1.21686561e-02f, 3.49084027e-02f, -3.44909042e-01f, -1.55977100e-01f,
  2.17092130e-02f, 1.37354493e-01f, 4.44214186e-03f, 7.15094581e-02f, -3.62866856e-02f, 5.31270057e-02f, -1.69702899e-02f, -1.95712388e-01f, -9.34337229e-02f, 2.67012119e-02f,
  1.84746742e-01f, 3.56461518e-02f, 3.50870891e-03f, -1.44390821e-01f, 3.22904959e-02f, -3.16774659e-02f, -6.10487871e-02f, -3.21736455e-01f, -1.12699553e-01f, -1.28425330e-01f,
  -2.51195669e-01f, -3.73756066e-02f, 1.48002639e-01f, -1.10880628e-01f, 1.47389779e-02f, 8.98284987e-02f, -5.86028136e-02f, 3.89020443e-01f, 3.20507474e-02f, -6.57663941e-02f,
  -9.61216316e-02f, -7.30437711e-02f, 1.57390401e-01f, -3.62402111e-01f, -1.75335646e-01f, -2.32446808e-02f, -9.13984627e-02f, 8.53867084e-02f, 1.08121373e-02f, 3.74822095e-02f,
  3.44330043e-01f, 1.07798323e-01f, -2.71137357e-01f, -5.36220670e-01f, -1.79740295e-01f, 2.57612675e-01f, 7.42961317e-02f, -2.70746559e-01f, 3.19618881e-01f, 6.88918168e-03f,
  -1.54037625e-01f, 5.44853687e-01f, -6.80446088e-01f, 1.37920871e-01f, -4.92555737e-01f, 3.34201127e-01f, -2.77070701e-01f, -6.70142844e-02f, -3.74566585e-01f, -5.81125498e-01f,
  3.52503121e-01f, -3.13101411e-02f, 1.64730161e-01f, 1.43959388e-01f, -3.38998824e-01f, -4.41728592e-01f, 8.42822716e-02f, -4.28305149e-01f, -1.11337222e-01f, 6.12759113e-01f,
  -1.98455855e-01f, -1.13162927e-01f, -2.45065466e-01f, -2.84856302e-03f, -2.54712760e-01f, -1.89941168e-01f, 5.82944602e-02f, -1.96524411e-01f, -3.79931211e-01f, -1.93402201e-01f,
  -1.52053058e-01f, 5.36250830e-01f, -1.03512637e-01f, -2.56414711e-01f, 2.80868262e-01f, 6.76212981e-02f, 4.52993393e-01f, -3.26271415e-01f, -5.55361748e-01f, 1.00980729e-01f,
  3.46452087e-01f, 6.33015633e-02f, 1.51674852e-01f, -1.12872876e-01f, 1.74693838e-01f, 3.48160446e-01f, -5.34835793e-02f, -1.84220355e-02f, -1.42390996e-01f, -1.10786349e-01f,
  2.78819352e-01f, -5.53123116e-01f, 2.79019058e-01f, -5.22513509e-01f, 4.44829285e-01f, -1.74072951e-01f, 4.00200814e-01f, 3.48525792e-01f, 5.72176613e-02f, 2.07308173e-01f,
  8.80037341e-03f, -5.45348167e-01f, -2.82775670e-01f, -8.85511935e-02f, -3.10054928e-01f, -3.45477849e-01f, -1.37026027e-01f, -3.14034000e-02f, 1.21677667e-02f, -6.34330928e-01f,
  -6.27130717e-02f, -1.59880280e-01f, -5.40653951e-02f, -8.19289126e-03f, 2.85218842e-02f, -2.44255587e-02f, 2.28090771e-02f, 6.17515966e-02f, -1.14801995e-01f, 1.13953441e-01f,
  9.24117938e-02f, -9.84400418e-03f, 3.74215767e-02f, 8.33917558e-02f, 1.40552580e-01f, 8.88596624e-02f, 1.20680675e-01f, 6.34124056e-02f, 1.83147341e-02f, 1.31654590e-01f,
  -1.66547745e-02f, 5.91836832e-02f, 1.06417231e-01f, 9.76356044e-02f, 1.19328953e-01f, -1.16905138e-01f, 2.22523004e-01f, -1.75654203e-01f, 9.55844149e-02f, 1.90026417e-01f,
  -2.45126531e-01f, 1.03284523e-01f, -1.16173625e-01f, -2.11746052e-01f, 1.48221642e-01f, 1.52935041e-02f, 1.94250479e-01f, 2.10307911e-01f, 2.19677061e-01f, 1.37020230e-01f,
  2.37566680e-01f, -1.73329949e-01f, -2.32503805e-02f, 2.31844425e-01f, -1.57678902e-01f, 1.21728994e-01f, -1.72585502e-01f, 1.07507436e-02f, -1.52848959e-01f, -1.49083007e-02f,
  1.70020565e-01f, 1.26828894e-01f, -8.76655430e-02f, -3.15796584e-01f, 8.41103345e-02f, -2.19058603e-01f, -2.70425349e-01f, -2.98694611e-01f, -2.86017656e-01f, -2.03556150e-01f,
  -1.99063793e-01f, 2.12425031e-02f, 3.05053055e-01f, -4.75180000e-01f, 3.80150467e-01f, 7.30452165e-02f, -3.19150001e-01f, -4.34876680e-01f, -3.28045011e-01f, -8.04723129e-02f,
  -2.37452343e-01f, 1.07046776e-03f, -2.77589351e-01f, -3.28786671e-01f, -3.87072414e-01f, -3.19412231e-01f, -5.21098256e-01f, 1.24553077e-01f, 1.68033481e-01f, 8.69700909e-01f,
  -1.73680037e-01f, -4.84407507e-02f, 4.27492768e-01f, -2.06756949e-01f, -3.04037690e-01f, -4.63765681e-01f, -1.49079263e-01f, 1.24661494e-02f, -1.59786478e-01f, -1.70539364e-01f,
  -2.35026300e-01f, -3.41475248e-01f, -2.10967779e-01f, 2.78210007e-02f, 1.10942990e-01f, 1.95442647e-01f, -1.43448353e-01f, -2.64565378e-01f, -1.98993206e-01f, 2.99346191e-03f,
  3.05142105e-01f, -3.70638251e-01f, -1.57681018e-01f, -9.37309861e-02f, 4.21545297e-01f, 1.31243216e-02f, 5.57134092e-01f, 2.17412785e-01f, 2.67092347e-01f, -2.16847792e-01f,
  -2.88493395e-01f, 1.73731387e-01f, -3.22782606e-01f, -4.28000242e-01f, -3.78641248e-01f, -3.01759213e-01f, -1.12627894e-01f, -2.51369774e-01f, 3.54888439e-01f, 2.37478167e-01f,
  4.62861389e-01f, -9.35824215e-02f, -2.35608965e-01f, -5.88563792e-02f, -1.76159829e-01f, -4.95829247e-02f, -2.35527933e-01f, -1.43619135e-01f, 1.88484099e-02f, -1.77863184e-02f,
  1.31492391e-01f, -1.40620172e-01f, 5.76945283e-02f, 1.64048094e-02f, 1.12733535e-01f, -8.40749964e-03f, 2.06813529e-01f, 1.15986668e-01f, -1.58038475e-02f, 1.08868226e-01f,
  1.21024184e-01f, 8.89624879e-02f, 8.86770934e-02f, 7.57829025e-02f, -1.31527975e-01f, 8.92451853e-02f, 8.51528123e-02f, 2.88211480e-02f, -8.52686465e-02f, 5.84876537e-02f,
  2.50845379e-03f, -2.95249969e-02f, -9.39456969e-02f, -1.52987361e-01f, -2.17468709e-01f, 1.87145188e-01f, -2.43933424e-01f, -3.20383072e-01f, 1.41679823e-01f, -1.54452384e-01f,
  -1.27230799e-02f, -2.34167486e-01f, 1.41200468e-01f, -2.06049442e-01f, -1.72367573e-01f, 2.88903654e-01f, -7.74684101e-02f, -3.07051808e-01f, 7.39725381e-02f, 3.53678256e-01f,
  1.72580697e-03f, 2.42194787e-01f, 7.88978860e-02f, -1.45301580e-01f, -1.24471948e-01f, 2.28340507e-01f, -1.25678241e-01f, -3.04527104e-01f, 6.58570603e-02f, -2.02306986e-01f,
  -2.93058038e-01f, -1.33789361e-01f, -5.17556608e-01f, 4.01496470e-01f, -2.09304795e-01f, -3.37953031e-01f, 2.07172304e-01f, -2.45520040e-01f, 5.06496608e-01f, -3.28568630e-02f,
  -3.18729281e-01f, -6.16606250e-02f, -1.29196346e-01f, -1.60936683e-01f, 1.46796957e-01f, -1.56248569e-01f, -1.43240675e-01f, -1.01323433e-01f, 9.22454223e-02f, -3.21521014e-01f,
  7.29050338e-02f, -2.70896167e-01f, -4.21347320e-01f, -1.50174692e-01f, 4.30400342e-01f, -3.61924499e-01f, 4.06992465e-01f, -1.20849364e-01f, -6.76267743e-02f, 2.25313663e-01f,
  -7.52375349e-02f, -1.64695576e-01f, 2.69346356e-01f, 3.80654931e-01f, -5.15873015e-01f, -1.94209009e-01f, -2.44931668e-01f, -4.38032389e-01f, -3.98420602e-01f, -3.52287591e-01f,
  -5.81194222e-01f, -1.18042370e-02f, -9.76975560e-02f, 1.63204018e-02f, -1.57854572e-01f, -4.25076038e-01f, 4.74723667e-01f, 4.88546431e-01f, -1.03230827e-01f, 1.46215171e-01f,
  -2.50580549e-01f, 4.61682588e-01f, -3.11747253e-01f, 3.28357995e-01f, 3.66336219e-02f, -4.09536242e-01f, -1.94978386e-01f, -6.78586736e-02f, -2.28756741e-01f, 2.65256345e-01f,
  -3.65242034e-01f, -2.35971287e-01f, -3.05296063e-01f, -2.30608374e-01f, -4.39394563e-01f, 5.19399568e-02f, 3.21386755e-02f, -1.62098676e-01f, -2.20610440e-01f, -1.05612896e-01f,
  -2.21138194e-01f, 1.16805565e-02f, -1.47067502e-01f, 1.36793509e-01f, 5.33745348e-01f, 5.56257784e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.92027643e-01f, 1.18176587e-01f, -4.85014915e-03f, -3.75362337e-02f, -1.09577179e-01f, 3.29306126e-02f, -9.08237249e-02f, -1.00662727e-02f, -2.66526248e-02f, 1.06529156e-02f,
  7.33087882e-02f, 5.76840341e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    