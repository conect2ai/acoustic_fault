/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.84757489e-01f, -3.84602904e-01f, 7.51343742e-02f, -2.86927730e-01f, 8.66279453e-02f, 2.82856107e-01f, 2.30097041e-01f, -6.77224696e-02f, -1.10427588e-01f, -1.36509567e-01f,
  1.08530410e-01f, 5.05652986e-02f, -2.91579310e-02f, -2.78814249e-02f, 2.49829903e-01f, -6.68277266e-03f, -1.45415664e-01f, 5.34283295e-02f, 3.71225238e-01f, 4.27019715e-01f,
  3.07637081e-02f, 3.83118466e-02f, 7.66725931e-03f, 4.12449688e-02f, -2.04418406e-01f, 4.91322204e-02f, -2.09033519e-01f, -1.03325285e-01f, 1.29163042e-01f, -6.09531403e-01f,
  -1.67826191e-01f, -1.46665424e-01f, 7.49220327e-02f, -2.43715197e-02f, -1.01035766e-01f, -1.47263587e-01f, -7.96738341e-02f, -8.26219395e-02f, -1.47575095e-01f, -8.80846605e-02f,
  -1.01024322e-01f, -7.35599026e-02f, -8.94966498e-02f, -1.14454098e-01f, -1.06544226e-01f, -1.67238619e-02f, -1.19807251e-01f, -3.93365175e-02f, -5.86693399e-02f, -2.20644221e-01f,
  -7.86237717e-02f, -2.25396864e-02f, -4.75481432e-03f, -1.44678280e-01f, -7.93526247e-02f, -2.77858600e-02f, -2.01378062e-01f, -9.53934491e-02f, -6.45994022e-02f, -3.39747012e-01f,
  -6.41156584e-02f, -2.34585367e-02f, -2.71998299e-03f, 3.47909257e-02f, -3.42233628e-02f, 3.28905322e-02f, 7.95092508e-02f, -2.66046301e-02f, 7.65329897e-02f, 9.07184370e-03f,
  2.81974841e-02f, -8.16148818e-02f, -1.09540094e-02f, -4.30571213e-02f, 6.47497475e-02f, 1.08201224e-02f, 1.00187533e-01f, -1.10819660e-01f, 8.72464254e-02f, -4.09932174e-02f,
  6.51114807e-03f, 4.58718423e-04f, -5.41113243e-02f, 1.25581935e-01f, -1.18878810e-02f, -7.10645271e-03f, 9.46931262e-03f, 2.89636832e-02f, -3.56271863e-02f, 9.55769047e-02f,
  -2.06579313e-01f, 2.00332835e-01f, -8.28596354e-02f, -2.73752753e-02f, -9.02258828e-02f, -8.09722021e-02f, -1.25875428e-01f, -3.40368561e-02f, -1.14848994e-01f, -9.29792449e-02f,
  2.62864912e-03f, -8.42734128e-02f, -8.12561437e-02f, -2.65195183e-02f, -3.22903618e-02f, -4.19518016e-02f, -9.32893082e-02f, 3.79307717e-02f, 6.78191185e-02f, -1.36695951e-01f,
  -9.12778378e-02f, -1.91348102e-02f, 2.14220155e-02f, -1.19188331e-01f, -9.12941620e-02f, 9.74314138e-02f, 2.96426639e-02f, -4.53380607e-02f, 1.72088951e-01f, -7.39377439e-02f,
  3.68164070e-02f, -9.82414708e-02f, -9.19269919e-02f, 2.29626931e-02f, 1.38690963e-01f, 1.97958246e-01f, 1.05231017e-01f, 3.29322428e-01f, 7.14177862e-02f, -2.73864985e-01f,
  -1.54053643e-01f, -1.55608431e-01f, -3.84764709e-02f, -1.54170115e-02f, -2.07665469e-02f, -1.83216467e-01f, -1.20809153e-01f, -1.79770589e-01f, -3.34989466e-02f, 2.10814446e-01f,
  2.06252858e-02f, -1.65095374e-01f, 4.78098914e-03f, 1.54267266e-01f, 4.00188081e-02f, -2.78378353e-02f, -3.57063860e-02f, 4.77743149e-02f, 1.06069066e-01f, -1.36536345e-01f,
  -1.33200988e-01f, 1.69253588e-01f, 1.14790604e-01f, 5.94012663e-02f, -1.07967285e-02f, 1.28568962e-01f, 9.27890688e-02f, 5.41099869e-02f, 2.12896928e-01f, 9.41490903e-02f,
  -1.14054941e-02f, 3.03201713e-02f, 1.55096740e-01f, 1.14532024e-01f, 1.51906952e-01f, 1.20461062e-01f, 1.58020005e-01f, 1.57519981e-01f, 1.54952049e-01f, 1.40646160e-01f,
  1.54266894e-01f, 1.16469443e-01f, 1.50825992e-01f, 2.59413838e-01f, 1.60466015e-01f, 1.41853049e-01f, 2.42572233e-01f, 2.46487990e-01f, 2.01954409e-01f, 1.92913681e-01f,
  3.36045511e-02f, -1.50056422e-01f, -3.02393511e-02f, 1.24510713e-02f, -6.27075583e-02f, 1.49681820e-02f, -5.99066168e-02f, -9.85116214e-02f, 2.57923845e-02f, -7.39546716e-02f,
  -2.94608250e-02f, -2.06467450e-01f, -5.99689856e-02f, 1.91000551e-02f, -1.70816451e-01f, -1.34737015e-01f, -2.56401636e-02f, -6.12068586e-02f, 5.64924367e-02f, -2.53447071e-02f,
  -1.11411609e-01f, -5.77773787e-02f, -1.69667214e-01f, -4.37022448e-02f, -1.24207474e-01f, -8.91594440e-02f, -7.41262585e-02f, -5.09291142e-02f, -1.25589117e-01f, -1.01537868e-01f,
  -2.08103377e-02f, 5.98484017e-02f, -7.00027198e-02f, 3.40430140e-02f, 7.72285834e-03f, 7.34616444e-02f, 6.27156198e-02f, 9.49021131e-02f, 2.70551872e-02f, 7.67941996e-02f,
  6.46892413e-02f, -4.66753319e-02f, 2.10293867e-02f, 9.10968706e-03f, -6.56148139e-03f, 7.37073794e-02f, 3.75740929e-03f, 6.97683766e-02f, 1.44884922e-02f, 1.21136606e-01f,
  1.13473088e-01f, -4.70886454e-02f, -5.79350404e-02f, 1.20117307e-01f, 1.41065359e-01f, -5.86128347e-02f, 4.69708107e-02f, -4.74450644e-03f, 1.79673746e-01f, -7.78015004e-03f,
  -6.49192393e-01f, 6.75121024e-02f, 4.01344478e-01f, -4.79753822e-01f, 6.18270598e-02f, 4.13225919e-01f, 5.61044872e-01f, 3.80409211e-02f, -4.17171150e-01f, 9.23379138e-02f,
  1.91906556e-01f, -1.60614103e-01f, -4.31936271e-02f, 2.54344773e-02f, 1.38912931e-01f, 2.04601914e-01f, -9.59240571e-02f, -9.12873149e-02f, 1.20206520e-01f, 3.13656956e-01f,
  -3.10840998e-02f, -2.81968176e-01f, -2.21651956e-01f, -1.07442185e-01f, -2.15741828e-01f, -8.89639333e-02f, 8.10667574e-02f, -8.73033404e-02f, 2.23745987e-01f, -4.13744241e-01f,
  2.47340441e-01f, 3.56780142e-02f, 4.59582731e-02f, -1.76247194e-01f, 4.86077555e-02f, -1.28735751e-01f, 4.35136557e-02f, -6.44088835e-02f, -4.33822609e-02f, -2.28637811e-02f,
  -5.00152819e-02f, -7.03619495e-02f, -3.93860787e-02f, -2.69104168e-02f, 6.99445158e-02f, -4.55777012e-02f, -1.80701911e-01f, -6.89381957e-02f, -7.69895613e-02f, 8.68808478e-02f,
  -8.14782307e-02f, 6.07424863e-02f, 1.64392874e-01f, 1.41659364e-01f, -3.76476981e-02f, -4.19746228e-02f, 1.41862094e-01f, 2.85893921e-02f, 5.09949178e-02f, -1.47014439e-01f,
  1.81189366e-02f, -2.77024060e-02f, 1.01091657e-02f, 3.29986252e-02f, -7.43637532e-02f, -9.18425899e-03f, 7.18455669e-03f, -2.45719147e-03f, 7.29113668e-02f, 3.79356034e-02f,
  -2.03646757e-02f, 3.96350287e-02f, -2.73512788e-02f, 1.48271546e-02f, -2.71589123e-02f, 2.09667198e-02f, -2.22964771e-02f, 6.06356859e-02f, 1.80238038e-02f, -3.72637995e-02f,
  -5.87402657e-02f, 5.03692403e-02f, -4.47310545e-02f, 2.36301292e-02f, -6.88227117e-02f, -4.91051525e-02f, -5.06841540e-02f, -6.62007406e-02f, -1.76602334e-05f, 3.17345466e-03f,
  -1.59465119e-01f, 1.24490663e-01f, -2.28566881e-02f, 3.52212973e-02f, -4.41339351e-02f, -2.02801684e-03f, 7.54116997e-02f, -5.26337698e-02f, -3.18323262e-02f, -7.53852651e-02f,
  4.93867807e-02f, -4.38967645e-02f, 6.24988675e-02f, 1.78618580e-02f, -2.40457174e-03f, -1.58389844e-02f, 2.99794003e-02f, 2.33478714e-02f, 5.84965162e-02f, -1.21203484e-02f,
  -2.11541541e-02f, -1.81880295e-02f, -8.08755867e-03f, -3.29262431e-04f, -1.21180646e-01f, -5.76242842e-02f, 1.68824196e-01f, 3.82397287e-02f, 1.85153455e-01f, -7.93038774e-03f,
  -2.56987542e-01f, -3.56928945e-01f, 3.82189341e-02f, -7.22216666e-02f, 8.82333368e-02f, 3.89666736e-01f, 7.54090995e-02f, 1.04951076e-01f, 1.28807902e-01f, -2.93752134e-01f,
  -9.93293822e-02f, 1.73900470e-01f, 1.42577365e-01f, 1.64604470e-01f, 1.75540894e-01f, 1.21473633e-02f, -2.64399704e-02f, 9.77810845e-02f, 5.08837283e-01f, 2.00835079e-01f,
  -1.77603774e-02f, -1.15278333e-01f, -9.72254667e-03f, 6.67410642e-02f, -9.48430672e-02f, 3.76808316e-01f, -8.65881145e-02f, -6.18802896e-03f, 8.05342123e-02f, -2.73532271e-01f,
  -6.33017421e-02f, -7.05940425e-02f, 1.87837556e-01f, 8.95094126e-02f, 3.80311944e-02f, 1.14613213e-02f, 2.33919080e-02f, -4.09853794e-02f, -4.18865085e-02f, -5.98084182e-02f,
  3.77163105e-02f, 2.16349796e-03f, -3.39865126e-02f, 3.53273898e-02f, 1.30172595e-02f, 9.64093208e-02f, -2.50608809e-02f, 1.17980495e-01f, 9.91945043e-02f, 3.23888324e-02f,
  -7.99997449e-02f, -3.36596631e-02f, 3.04159392e-02f, 9.77904797e-02f, 6.88609555e-02f, 5.64037748e-02f, 4.74987812e-02f, 8.83243605e-02f, 2.00408429e-01f, -1.41109917e-02f,
  -7.22019672e-02f, -4.94508930e-02f, 6.59366250e-02f, -1.25829726e-01f, -1.63096543e-02f, -9.74210165e-03f, -1.21202268e-01f, -3.54195200e-02f, -7.44264689e-04f, 2.57239118e-02f,
  2.34559178e-03f, 1.39352836e-04f, 5.11750542e-02f, -3.87832485e-02f, 2.26112977e-02f, -2.91273056e-04f, 4.06757407e-02f, -4.91068400e-02f, 5.07542193e-02f, -5.21424413e-02f,
  4.59228121e-02f, 1.22902645e-02f, 2.88075376e-02f, 2.38067992e-02f, 5.22477971e-03f, 6.04628511e-02f, 4.63958718e-02f, -6.91299811e-02f, -1.55001425e-03f, -6.29434809e-02f,
  3.05719614e-01f, 1.27322450e-01f, -2.97844559e-02f, 1.46543831e-01f, 1.49377286e-01f, 8.20895657e-02f, 6.19156957e-02f, 4.50448953e-02f, 2.36264858e-02f, -2.94187311e-02f,
  1.19180828e-01f, 3.58313695e-02f, 1.98395755e-02f, 8.51013046e-03f, 7.69449547e-02f, 1.07172281e-01f, -3.06301489e-02f, 1.06122904e-01f, 1.16813488e-01f, 4.06156443e-02f,
  -6.95618168e-02f, 3.50702330e-02f, 1.87222496e-01f, 1.59882754e-01f, 1.27202109e-01f, 2.49856457e-01f, 7.18072653e-02f, 1.55001894e-01f, 2.68061608e-01f, 2.63395384e-02f,
  2.09368929e-01f, 1.28084734e-01f, 1.88692018e-01f, -6.46948144e-02f, -1.51850879e-01f, -4.80405204e-02f, 3.58208954e-01f, 7.83068016e-02f, -9.06292126e-02f, 1.41107216e-01f,
  -1.31483182e-01f, -6.16450533e-02f, 7.58792982e-02f, 6.57884851e-02f, 1.24074809e-01f, 4.59115952e-01f, 3.33729535e-01f, 1.20184042e-01f, 2.90668514e-02f, -1.31531149e-01f,
  -3.07529401e-02f, 1.02605596e-01f, -1.22434631e-01f, -1.74769700e-01f, 1.00254476e-01f, -3.95682156e-02f, -5.40548526e-02f, -1.77775651e-01f, -2.96521574e-01f, 2.06054226e-01f,
  9.35929194e-02f, 6.05487786e-02f, -5.02951257e-02f, -1.51769623e-01f, -7.84169585e-02f, 1.18369557e-01f, 3.86742540e-02f, 2.66817631e-03f, -8.85476843e-02f, 3.27222534e-02f,
  -2.42608190e-02f, -9.48211476e-02f, -3.97173241e-02f, 8.11465755e-02f, 6.75301114e-03f, -2.16925773e-03f, 3.09765525e-02f, 1.08916834e-02f, 8.44287649e-02f, 4.65822406e-02f,
  -4.70867194e-02f, -2.43786052e-01f, -1.07392661e-01f, -5.61793037e-02f, -5.38780075e-03f, -2.24525575e-03f, -7.93764964e-02f, 2.54946575e-03f, -3.75331938e-02f, 8.34963992e-02f,
  8.20278283e-03f, 1.90785974e-02f, 2.38733608e-02f, 2.81677060e-02f, -9.31110885e-03f, -1.22205928e-01f, 4.68047187e-02f, -1.17098376e-01f, -1.91361667e-03f, 1.74838360e-02f,
  5.40048629e-03f, 2.35102829e-02f, 2.45734528e-02f, 9.08760577e-02f, -9.24166515e-02f, -7.61873946e-02f, 2.24458035e-02f, -3.17695104e-02f, -8.93602986e-03f, 3.01783755e-02f,
  -4.17650230e-02f, 5.39823668e-04f, -2.19446402e-02f, -5.05450889e-02f, -9.98149347e-03f, 1.30434781e-02f, -6.88042641e-02f, -8.48100111e-02f, -8.13380815e-03f, 1.96283311e-02f,
  8.58514011e-03f, -2.41657291e-02f, 9.56499353e-02f, 2.97536347e-02f, -8.28026161e-02f, 2.70503834e-02f, -1.57124642e-02f, -8.59376788e-02f, -4.92306799e-02f, -5.05578145e-02f,
  -1.67947516e-01f, -8.32547620e-02f, 3.47616561e-02f, -1.22453958e-01f, 9.54265073e-02f, -7.00815544e-02f, -5.69880567e-03f, 6.40889704e-02f, 7.42093027e-02f, -4.82917391e-02f,
  -8.98526311e-02f, 7.83573613e-02f, 1.12943299e-01f, 1.02577820e-01f, -5.22148274e-02f, -8.87312461e-03f, -2.21458822e-02f, -4.71019261e-02f, 2.16992032e-02f, 9.42673832e-02f,
  -2.62874007e-01f, -1.13913201e-01f, 3.07383537e-01f, -2.57140517e-01f, 1.23210721e-01f, 3.16419780e-01f, 2.98270851e-01f, 1.60320997e-01f, 1.70538351e-02f, -1.45392954e-01f,
  7.31032267e-02f, -2.70754725e-01f, -1.84733406e-01f, -3.35015431e-02f, 1.09951414e-01f, 6.32696599e-02f, -4.88141086e-03f, -1.28682733e-01f, -2.14854516e-02f, -6.81935176e-02f,
  -1.56693250e-01f, -2.43360400e-01f, -6.24585524e-02f, 2.25912631e-02f, -2.08875433e-01f, -2.34371573e-02f, 1.24176793e-01f, -8.25220272e-02f, 2.23637730e-01f, -3.45380902e-01f,
  -1.57636166e-01f, 7.16185495e-02f, 6.04039840e-02f, -2.10043997e-01f, -8.85395855e-02f, -6.50537834e-02f, -1.95274577e-02f, -6.40649199e-02f, -6.29792139e-02f, -3.08242813e-02f,
  -1.58088654e-01f, -7.28015751e-02f, -1.25039861e-01f, 3.17507759e-02f, -8.53402987e-02f, -8.29380453e-02f, 2.11525690e-02f, 3.04725599e-02f, -3.88265327e-02f, 3.33274230e-02f,
  -1.32657930e-01f, 3.11999824e-02f, 7.11820498e-02f, 1.41086653e-01f, 9.88144130e-02f, -7.24126073e-03f, 9.58272070e-02f, 5.80926077e-04f, 2.27215096e-01f, -1.38078243e-01f,
  -5.03061041e-02f, -5.87578956e-03f, 4.17772718e-02f, 9.89369489e-03f, -9.13298316e-03f, 5.21692485e-02f, -3.33302766e-02f, 5.26276864e-02f, -1.42853765e-03f, -3.94171919e-04f,
  4.69649732e-02f, -3.19437422e-02f, 5.25757149e-02f, 2.17828695e-02f, -3.61038707e-02f, 9.12845731e-02f, 6.58974126e-02f, -1.02046728e-02f, 1.18220620e-01f, -1.61492657e-02f,
  7.84436390e-02f, 1.66442133e-02f, -5.33104651e-02f, -5.77256493e-02f, 1.17798880e-01f, 2.69117095e-02f, 5.71122095e-02f, 4.09160443e-02f, -2.96107065e-02f, 4.11831625e-02f,
  -3.07955146e-01f, 2.58640289e-01f, -2.10640907e-01f, -1.63723435e-02f, -8.98268670e-02f, -4.49289717e-02f, 1.48159005e-02f, 9.67658237e-02f, -7.15549663e-02f, 2.52640788e-02f,
  -6.49158880e-02f, 3.80651057e-02f, 7.90384859e-02f, 1.91468478e-03f, -4.44141664e-02f, 7.12814229e-03f, 3.47255282e-02f, -6.54409220e-03f, 5.29695419e-04f, -5.74983917e-02f,
  1.43896909e-02f, -2.79584341e-02f, -1.44220427e-01f, 3.38180251e-02f, -6.14052005e-02f, -4.60600480e-02f, 9.13981721e-03f, -3.36691774e-02f, 7.37866834e-02f, -1.81389213e-01f,
  -1.85037687e-01f, 1.98184878e-01f, -4.53880399e-01f, -2.97947437e-01f, -2.77649283e-01f, -8.59077051e-02f, 1.91428185e-01f, 2.12406188e-01f, 9.35740843e-02f, 1.10372551e-01f,
  -1.45095348e-01f, -1.01134725e-01f, 2.15581968e-01f, 1.37026519e-01f, 2.48170272e-01f, 1.89917043e-01f, -5.28644659e-02f, -1.06730103e-01f, -1.20990418e-01f, -4.05579843e-02f,
  -4.97925133e-02f, -3.66942227e-01f, -3.10340315e-01f, 9.02265757e-02f, 4.32655364e-02f, 2.31143124e-02f, -1.08721010e-01f, -3.60670209e-01f, -1.25318781e-01f, -1.68710768e-01f,
  -1.63380042e-01f, -1.24471232e-01f, 6.93883654e-03f, -6.42300099e-02f, -6.39498681e-02f, 9.51854065e-02f, 3.83489244e-02f, -4.38643433e-02f, 1.05631322e-01f, 1.34503851e-02f,
  -1.52557120e-01f, 8.26723725e-02f, -1.03108801e-01f, -9.48924571e-02f, -3.79246511e-02f, 3.74536938e-03f, 5.43276742e-02f, -5.50112836e-02f, 3.03753112e-02f, 2.39790268e-02f,
  -4.41567451e-02f, -1.68033853e-01f, -1.10996842e-01f, 1.79035991e-01f, 9.36558172e-02f, -7.50933141e-02f, -8.04345775e-03f, 2.13206355e-02f, 2.57978551e-02f, 2.33141884e-01f,
  5.36406115e-02f, -4.78948839e-02f, -3.71741503e-02f, 4.49676439e-02f, -1.12204133e-02f, -9.88372136e-03f, -8.63218457e-02f, -4.98294942e-02f, -1.89941265e-02f, -2.41929814e-02f,
  1.60742290e-02f, -1.54145602e-02f, 1.33432616e-02f, 1.21432738e-02f, -5.14645223e-03f, -1.19398937e-01f, -3.94881004e-03f, 2.74068639e-02f, -6.12510033e-02f, 3.47733423e-02f,
  -3.01888306e-02f, 6.95217401e-02f, -8.65063369e-02f, 7.02740252e-02f, -1.31293833e-01f, 1.83138549e-02f, -7.47075602e-02f, 5.57028912e-02f, -3.73221934e-02f, -1.22113891e-01f,
  1.36757746e-01f, -9.36188251e-02f, 7.38936767e-04f, 1.71147197e-01f, -2.08861139e-02f, 1.68667547e-02f, -1.20864429e-01f, 1.62945524e-01f, -4.62336801e-02f, 9.51338485e-02f,
  -2.22187955e-02f, 1.02922373e-01f, -6.14624768e-02f, 9.42977667e-02f, 9.14392322e-02f, 2.53579691e-02f, 6.58624619e-02f, 6.89053349e-03f, 4.18382883e-02f, 7.34826028e-02f,
  1.20916426e-01f, 2.09971324e-01f, 2.79076189e-01f, 2.36604720e-01f, 5.89563586e-02f, 9.18418914e-02f, 1.48884147e-01f, 3.05123962e-02f, 1.56376153e-01f, 4.62109596e-01f,
  -7.47710764e-02f, -2.41862684e-02f, -2.93481886e-01f, 8.19606408e-02f, -1.03832304e-01f, -1.40927747e-01f, -3.27319533e-01f, 4.87890393e-02f, 1.59222916e-01f, -2.51344532e-01f,
  1.57223463e-01f, 3.06918323e-01f, 3.07108819e-01f, 1.78640246e-01f, 1.94173735e-02f, -2.77632803e-01f, -2.09351465e-01f, -1.23370275e-01f, -1.40331671e-01f, -1.69480398e-01f,
  2.71454193e-02f, 4.09318209e-02f, 1.73162147e-01f, 1.46822155e-01f, -5.45556508e-02f, 1.28605783e-01f, 6.08741306e-03f, -9.12152305e-02f, 1.74582773e-03f, -2.13876113e-01f,
  -3.42977613e-01f, -1.20555207e-01f, -3.70328710e-03f, 1.62847221e-01f, 7.59416074e-02f, 3.12256292e-02f, -2.39328872e-02f, 3.05403695e-02f, 1.26140922e-01f, 3.31564285e-02f,
  1.42899305e-01f, 1.01017691e-01f, 5.97211532e-02f, -4.68611494e-02f, -8.68464168e-03f, -4.58641797e-02f, 2.50214320e-02f, 5.64128868e-02f, 1.40334740e-01f, -8.47444907e-02f,
  9.77283344e-02f, -1.87931284e-02f, -2.98728924e-02f, 1.53730232e-02f, 2.88889650e-02f, 1.52304173e-01f, 1.01294614e-01f, -8.05003569e-03f, 1.34361878e-01f, 8.18356350e-02f,
  -2.29844041e-02f, 7.18358383e-02f, -5.38983755e-02f, 4.80059348e-02f, 9.35665742e-02f, 1.07503161e-02f, 9.99183282e-02f, -3.90299633e-02f, -3.26144360e-02f, 5.31901196e-02f,
  -1.25135267e-02f, -1.88991815e-01f, 2.01979522e-02f, -6.86518252e-02f, -1.28060609e-01f, 3.78928967e-02f, 4.31685857e-02f, -3.19608080e-04f, 2.41307579e-02f, -3.70595641e-02f,
  -7.67146610e-03f, 8.00693557e-02f, -2.92632412e-02f, -1.53938038e-02f, -5.56861237e-02f, -2.32268907e-02f, -3.57345119e-02f, -7.06028566e-02f, -6.69265538e-02f, 3.63309942e-02f,
  2.64278620e-01f, 1.83114797e-01f, 5.57898507e-02f, -5.94535694e-02f, -2.28118654e-02f, 1.41972050e-01f, 1.71025857e-01f, 2.29088981e-02f, 3.28520760e-02f, 3.38524440e-03f,
  6.93863556e-02f, -2.75931582e-02f, 6.73502758e-02f, 1.03689432e-01f, 1.32806785e-03f, 5.73094599e-02f, 2.25978773e-02f, 9.68769416e-02f, 1.34730861e-01f, 8.67797360e-02f,
  1.46844774e-01f, 2.23267507e-02f, -3.21348645e-02f, 6.44097850e-02f, 2.46861950e-02f, -3.82923745e-02f, -1.94305964e-02f, -1.91942118e-02f, 5.74137755e-02f, -3.85029204e-02f,
  -3.93146873e-01f, -1.26057267e-01f, -1.61352053e-01f, 1.68179139e-01f, 8.51038620e-02f, -1.57940999e-01f, -4.04489189e-01f, -4.80628051e-02f, 1.72359318e-01f, -7.96298087e-02f,
  -7.37382695e-02f, 8.40586200e-02f, 3.00547630e-02f, 8.80019292e-02f, -1.15881950e-01f, -1.37870386e-01f, 1.02799907e-01f, -2.97968313e-02f, -2.49291003e-01f, -8.01822022e-02f,
  3.36769111e-02f, 3.81839089e-02f, 1.94994390e-01f, 2.15443239e-01f, 1.29420951e-01f, 1.23452209e-01f, 2.32650816e-01f, 5.02711572e-02f, -4.43198755e-02f, 3.47649455e-01f,
  -1.18864328e-01f, -9.99118984e-02f, -1.31400004e-01f, -1.27995789e-01f, 3.82495336e-02f, -8.51428211e-02f, -1.46649107e-01f, -1.98229239e-03f, -2.56680660e-02f, 2.81940307e-02f,
  -4.32412475e-02f, 3.27908285e-02f, -7.32873231e-02f, 1.25234514e-01f, -3.05958260e-02f, -5.85749820e-02f, 8.76867697e-02f, 5.85575774e-02f, -3.32680903e-02f, -6.95330873e-02f,
  4.71073613e-02f, 5.79297990e-02f, 6.03630964e-04f, 5.46440333e-02f, 4.70816642e-02f, 4.37107570e-02f, 5.14131375e-02f, 1.18938088e-01f, 4.25354876e-02f, 8.01913068e-02f,
  -9.72798094e-03f, 7.50124827e-02f, -7.26348236e-02f, -5.66994846e-02f, 4.13119532e-02f, 8.10437500e-02f, 1.00976355e-01f, 1.17957192e-02f, 5.43432757e-02f, -9.83881503e-02f,
  7.18727615e-03f, 7.32606798e-02f, 5.52395396e-02f, -4.73452639e-03f, 1.27066255e-01f, 2.43025031e-02f, 3.50853130e-02f, 5.28440438e-03f, 1.79096520e-01f, -1.15256555e-01f,
  5.83900698e-02f, -5.88272735e-02f, -3.83852771e-03f, 2.43776813e-02f, -9.29678082e-02f, 7.42377415e-02f, 1.20890751e-01f, 3.89989354e-02f, -9.44112334e-03f, -2.10268870e-02f,
  -1.43447146e-01f, -1.28365993e-01f, -1.02567956e-01f, -1.10828795e-01f, -9.04451683e-02f, -7.39221275e-03f, 5.43982629e-03f, 4.48663579e-03f, -7.85076469e-02f, 8.68179894e-04f,
  -2.04982534e-02f, -4.65185232e-02f, -9.92284790e-02f, -3.22664194e-02f, -1.38077706e-01f, -2.00201590e-02f, -7.21933916e-02f, -5.65077141e-02f, 1.44157140e-02f, 6.19934835e-02f,
  7.04943389e-02f, -3.15182470e-02f, 2.07566768e-02f, 1.48681048e-02f, 5.00134006e-02f, -1.45295650e-01f, -1.37278154e-01f, -5.36080152e-02f, -2.54482657e-01f, 1.37626892e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.02230465e-01f, 1.78845987e-01f, -4.07368809e-01f, -1.94823310e-01f, -4.41672295e-01f, -3.79150897e-01f, -5.82135543e-02f, -2.38521352e-01f, -7.19442815e-02f, -1.56487122e-01f,
  6.62278831e-02f, 3.67697597e-01f, 4.86838877e-01f, 1.89802617e-01f, 1.32327184e-01f, -1.71102166e-01f, -2.63612777e-01f, 9.26491767e-02f, -6.93694875e-02f, -4.22909379e-01f,
  -2.80008644e-01f, 3.33975554e-02f, -8.24584141e-02f, -1.45230278e-01f, -2.09789976e-01f, -2.12137476e-02f, -2.31431365e-01f, -3.65888685e-01f, -4.30869818e-01f, -2.18791559e-01f,
  4.76333387e-02f, -2.66842246e-01f, -2.32305080e-01f, -7.96383992e-03f, -1.80401709e-02f, 9.37937424e-02f, 3.96712944e-02f, 1.00337617e-01f, 1.34261832e-01f, -6.83958679e-02f,
  -1.45893931e-01f, -4.53958623e-02f, 5.61140142e-02f, -8.12340751e-02f, -1.18556812e-01f, -1.55133650e-01f, -8.75229239e-02f, -7.13712573e-02f, 4.57037985e-02f, 2.04359069e-02f,
  -3.84293422e-02f, -4.48158123e-02f, 1.72250494e-02f, -2.30534717e-01f, -9.75552797e-02f, -1.10511489e-01f, -2.24183097e-01f, -2.46865451e-01f, -1.93357289e-01f, -7.58872181e-02f,
  -1.58270374e-01f, 1.80897102e-01f, 4.84309532e-02f, 3.15264501e-02f, 1.31114945e-01f, 1.29158441e-02f, 1.35219097e-01f, 8.06877241e-02f, -7.87522942e-02f, -1.32553959e-02f,
  6.95150122e-02f, -3.81275490e-02f, 2.96185315e-02f, 6.13999814e-02f, 9.52777341e-02f, -7.75548909e-03f, 5.89618608e-02f, 3.89962681e-02f, -4.87128692e-03f, 1.66484550e-01f,
  4.33764718e-02f, -2.87576411e-02f, -1.87475677e-03f, 7.68370554e-02f, -1.37904167e-01f, -1.98910409e-03f, -6.55157564e-05f, 1.20282313e-02f, -4.58896570e-02f, -7.56366029e-02f,
  2.39117891e-01f, -1.83933284e-02f, 9.47257131e-03f, 9.04421061e-02f, 7.09147602e-02f, 1.21679030e-01f, 7.05907568e-02f, 8.61790106e-02f, 1.51798442e-01f, 9.64737162e-02f,
  -4.58031707e-02f, 1.19277343e-01f, 1.52960066e-02f, -4.37455140e-02f, -1.50259733e-01f, -2.39769593e-02f, -1.16094656e-01f, -3.75525802e-02f, 4.82256375e-02f, 1.64094251e-02f,
  4.72091045e-03f, -9.93750431e-03f, 1.80675343e-01f, 1.04984038e-01f, 4.40740474e-02f, 2.51446459e-02f, 7.13887736e-02f, 1.00780100e-01f, 2.00570688e-01f, 2.41786256e-01f,
  4.15988714e-02f, -1.88669026e-01f, -1.75624117e-01f, 2.49835372e-01f, -1.50203049e-01f, -2.53567874e-01f, -4.43203449e-01f, 6.49022684e-02f, 3.15094173e-01f, -2.51732379e-01f,
  -1.07546732e-01f, 2.19809994e-01f, 5.22183850e-02f, -1.27189845e-01f, -3.15230072e-01f, -4.26863849e-01f, -1.76496223e-01f, -1.76400810e-01f, -3.91697977e-03f, -1.84139505e-01f,
  1.65386811e-01f, 1.87812507e-01f, 3.39175373e-01f, 1.57860607e-01f, -2.08009616e-01f, 3.36759654e-03f, -1.83648113e-02f, -1.52422532e-01f, -3.52770954e-01f, -3.89518529e-01f,
  -2.89780259e-01f, -2.43001789e-01f, -9.09612402e-02f, -3.25361080e-02f, -4.07997519e-02f, -9.42044705e-02f, -2.13233069e-01f, -2.61376888e-01f, -1.04012221e-01f, 7.21125752e-02f,
  -1.59658063e-02f, -3.17752850e-03f, -5.00128558e-03f, 1.47936670e-02f, 1.06122591e-01f, -1.30928025e-01f, 3.73948365e-02f, -1.01485893e-01f, -1.61149308e-01f, -3.46271843e-01f,
  -9.30709466e-02f, -3.10071141e-01f, -8.52748901e-02f, -8.29472914e-02f, -3.39620382e-01f, 1.35952011e-01f, -1.22817539e-01f, -2.32967764e-01f, -2.56330043e-01f, -1.75081104e-01f,
  -7.65266195e-02f, -4.69940491e-02f, -7.41363391e-02f, 8.72398019e-02f, 3.17290239e-02f, -9.91306379e-02f, -2.96866614e-02f, -7.43739530e-02f, 2.39539873e-02f, -5.91557380e-03f,
  4.86346595e-02f, -2.63261367e-02f, 7.61484504e-02f, 1.26972256e-04f, -1.16283208e-01f, -1.19763181e-01f, -1.69360321e-02f, -1.95011213e-01f, -4.84577119e-02f, -1.02257598e-02f,
  -1.24514662e-01f, 2.75352485e-02f, 1.20377600e-01f, -1.03879735e-01f, -1.15019806e-01f, -1.07174635e-01f, -2.01990623e-02f, -1.31844118e-01f, 1.19984433e-01f, 1.32438838e-01f,
  4.36375916e-01f, 8.39251801e-02f, -2.34080106e-02f, -1.65395031e-03f, 7.42162764e-03f, 2.94833944e-06f, -8.32848325e-02f, 3.87309492e-02f, -4.76412196e-03f, -5.81889004e-02f,
  -1.17506303e-01f, -5.69511726e-02f, 1.03963770e-01f, 1.06211476e-01f, 1.06212534e-01f, 8.32953751e-02f, -1.86842278e-01f, -1.36005506e-01f, -1.43608481e-01f, -4.83735986e-02f,
  -1.70603041e-02f, -2.03468964e-01f, 3.49486731e-02f, 4.61190660e-03f, -3.21195945e-02f, 5.12753315e-02f, 5.50747849e-02f, 2.13885065e-02f, 7.66652152e-02f, -4.35237680e-03f,
  -3.65930945e-01f, -2.67585486e-01f, -1.59711748e-01f, 4.49146599e-01f, 2.53476709e-01f, 2.98453718e-01f, 4.63687927e-01f, 1.80965349e-01f, 2.06645161e-01f, 1.63881425e-02f,
  -3.40514690e-01f, -6.75695240e-02f, -9.16710868e-02f, -2.52269376e-02f, -1.16988510e-01f, 1.79532364e-01f, 3.20155531e-01f, -1.27183691e-01f, -1.48275495e-02f, -6.71341736e-03f,
  1.12016201e-01f, -1.93781778e-01f, -3.94492924e-01f, 1.23513751e-02f, 1.90669701e-01f, 1.69295147e-01f, -1.59537748e-01f, -1.47682086e-01f, -3.43667418e-01f, 1.77423611e-01f,
  -6.51385307e-01f, -4.19454306e-01f, 1.70246035e-01f, -3.18870619e-02f, -6.38817102e-02f, -7.19529763e-03f, -1.24888703e-01f, -6.85490817e-02f, -1.38942808e-01f, -3.03160455e-02f,
  -5.41119426e-02f, -7.98700973e-02f, -1.01471856e-01f, -9.99837816e-02f, -3.53814401e-02f, -2.90099587e-02f, -1.55920580e-01f, -3.07382911e-01f, -2.36000225e-01f, -2.06432238e-01f,
  1.02796078e-01f, -1.71068177e-01f, -2.66480595e-01f, -6.11469373e-02f, -1.10969074e-01f, -3.07018012e-02f, -5.76723106e-02f, -7.50710964e-02f, -2.73670256e-01f, -1.72791407e-01f,
  -6.26670569e-02f, 4.07701023e-02f, 5.08849956e-02f, 8.82225949e-03f, 7.76435658e-02f, -1.69274397e-02f, -2.51746252e-02f, -4.50242311e-02f, 9.85863060e-02f, 8.20103958e-02f,
  6.61968589e-02f, -5.27274385e-02f, 5.02454601e-02f, -2.07114026e-01f, 3.62980701e-02f, 1.58708636e-02f, 1.02681229e-02f, 5.70957363e-02f, 9.67383292e-03f, -2.68216450e-02f,
  2.08712611e-02f, 6.57232851e-02f, -6.41966909e-02f, 6.64500566e-03f, -5.93081899e-02f, 9.03089419e-02f, 9.18799662e-04f, 2.60582585e-02f, 1.51353916e-02f, 1.86051410e-02f,
  1.36912197e-01f, -1.21634088e-01f, 3.07150818e-02f, 9.91430134e-03f, -2.05772873e-02f, -4.43723649e-02f, -1.01422563e-01f, -1.63847506e-01f, -8.40635747e-02f, -8.89587495e-03f,
  -7.45663270e-02f, -2.10088491e-02f, 1.17975548e-02f, -1.64068900e-02f, 9.93197784e-02f, -2.03238893e-02f, 4.68597673e-02f, 1.93279594e-01f, 2.85953917e-02f, 8.37048590e-02f,
  2.37581119e-01f, 2.17088073e-01f, 1.03127517e-01f, 2.19819367e-01f, -9.80505720e-03f, 8.24850425e-02f, 5.36878556e-02f, 3.37834805e-02f, -1.02303863e-01f, 2.00811818e-01f,
  -5.93534172e-01f, -1.46723107e-01f, 2.39359230e-01f, -3.04535143e-02f, -2.55000312e-02f, 8.69826376e-02f, 6.66782409e-02f, -6.50206655e-02f, -1.89350426e-01f, -2.16201600e-02f,
  1.03293471e-01f, 2.45944798e-01f, 2.10008532e-01f, 2.78703988e-01f, 1.69506848e-01f, -7.82945286e-03f, 9.10439342e-03f, 9.50289443e-02f, 1.48829550e-01f, 6.41287863e-02f,
  3.64849605e-02f, -4.09102887e-02f, -9.50297564e-02f, -5.42526841e-02f, -9.07207206e-02f, 1.82456657e-01f, 1.37022749e-01f, 3.44959721e-02f, 1.02518890e-02f, 7.78704509e-02f,
  7.64490783e-01f, -2.43997455e-01f, 1.73706606e-01f, 1.87760256e-02f, 6.49898779e-03f, -1.53834820e-01f, 9.18894634e-02f, -1.12646632e-01f, -1.71058953e-01f, -1.26425117e-01f,
  -8.22619721e-02f, -7.91814774e-02f, -9.96334851e-03f, -1.39266746e-02f, -1.72684759e-01f, -1.47431707e-02f, -9.45243165e-02f, -6.30552471e-02f, 4.65913601e-02f, 9.10588503e-02f,
  8.66894647e-02f, -1.69860810e-01f, -3.16682309e-02f, 7.75368139e-02f, 1.57749373e-02f, -4.67090160e-02f, -3.85239124e-02f, -5.09683900e-02f, -1.46501148e-02f, -9.17259380e-02f,
  1.00127198e-01f, -3.52954492e-02f, 7.07608555e-03f, 1.46974206e-01f, 1.01041570e-02f, 3.76237147e-02f, -7.38650188e-02f, 2.51724217e-02f, -3.41960080e-02f, -1.44984424e-01f,
  -1.12405628e-01f, 8.26782510e-02f, -3.01398113e-02f, 2.38689390e-04f, 6.20405488e-02f, -1.09145738e-01f, -5.97838871e-02f, 4.49142456e-02f, -1.60187289e-01f, -5.27756773e-02f,
  -8.69474858e-02f, -2.79480182e-02f, -9.39028040e-02f, -2.11409370e-05f, -1.15209304e-01f, -8.29103738e-02f, -8.20328817e-02f, -2.20352877e-02f, 4.59713489e-03f, -1.01884514e-01f,
  6.67278767e-01f, -3.88574451e-02f, 1.87987387e-01f, -4.00350727e-02f, -6.94443658e-02f, -4.87589650e-02f, 9.73689482e-02f, 3.68387960e-02f, -6.28541708e-02f, 9.82646793e-02f,
  -4.78894748e-02f, 5.88321090e-02f, -3.00379824e-02f, -4.28160094e-02f, -1.15978770e-01f, 8.57206061e-03f, -9.88281425e-03f, 4.13173325e-02f, 9.36762169e-02f, 2.18464024e-02f,
  -2.61170138e-02f, -9.78239179e-02f, 1.01613671e-01f, 8.71702805e-02f, 4.72412445e-02f, 2.04431430e-01f, 3.01130563e-02f, -4.29500975e-02f, 7.83175230e-02f, -2.06025504e-02f,
  -4.83033836e-01f, -2.65878946e-01f, 2.38651231e-01f, 1.76282302e-02f, -2.49284536e-01f, -2.57462353e-01f, -3.19447756e-01f, -1.05832212e-01f, -7.18023181e-02f, -2.16443226e-01f,
  -2.58570999e-01f, 3.92154194e-02f, 1.62340999e-01f, 1.84598818e-01f, 3.24971557e-01f, 1.23753667e-01f, 4.22660530e-01f, 4.35557783e-01f, 1.63083509e-01f, -5.39062843e-02f,
  -2.71747634e-02f, 1.04093045e-01f, 2.41152167e-01f, 1.04522787e-01f, -1.36590330e-02f, 6.64061233e-02f, 1.85739398e-01f, 1.25284269e-01f, -4.84460443e-02f, 4.29698229e-01f,
  -8.57324898e-02f, -2.09588051e-01f, 8.55418593e-02f, -9.70311686e-02f, -6.03766851e-02f, 1.68486815e-02f, -1.24930657e-01f, 7.03532770e-02f, -5.41274920e-02f, 2.28616260e-02f,
  -2.44883411e-02f, -9.38523374e-03f, -9.93433874e-03f, 1.59041788e-02f, -6.61684349e-02f, -1.20492905e-01f, 5.46922460e-02f, 1.09862104e-01f, 1.47140458e-01f, -1.84092328e-01f,
  -8.53401423e-02f, -1.46420315e-01f, -4.55315076e-02f, -7.09327171e-04f, -9.19400230e-02f, 4.33403589e-02f, -5.28177992e-02f, 3.21267871e-03f, -6.97644474e-03f, -1.72973081e-01f,
  -1.43666044e-01f, 9.73877683e-02f, -5.67556545e-02f, -1.19047582e-01f, -4.51165624e-02f, -1.43912718e-01f, 1.02619070e-03f, 2.92548854e-02f, 4.84688617e-02f, -8.03995132e-02f,
  2.47249566e-02f, -3.36375311e-02f, -3.98896933e-02f, -1.21539012e-01f, 8.94340053e-02f, 8.08059573e-02f, -6.68460503e-02f, 2.67376155e-02f, 7.64098838e-02f, -5.02724084e-04f,
  4.25455011e-02f, 3.42729688e-02f, -1.34005724e-02f, 9.50082317e-02f, -2.37039346e-02f, -3.19758207e-02f, -3.15255411e-02f, -4.18506153e-02f, -3.24009620e-02f, 6.87192604e-02f,
  -1.46381939e-02f, 3.66809040e-01f, 4.34685536e-02f, 1.25384629e-01f, -2.33726874e-02f, 4.28977795e-02f, 1.94946658e-02f, 2.50880793e-02f, 2.21218020e-02f, 1.42126977e-01f,
  -5.53948842e-02f, -8.96691158e-03f, 7.48127028e-02f, 6.81877835e-03f, 4.66386825e-02f, -8.42733309e-02f, -3.12275235e-02f, -1.42800976e-02f, 1.31582558e-01f, -1.24441527e-01f,
  7.98733085e-02f, -1.06134631e-01f, -1.74878135e-01f, -2.02119313e-02f, -5.68461828e-02f, -1.46086812e-02f, -8.23305994e-02f, -8.87978747e-02f, -4.49557640e-02f, -2.02410549e-01f,
  1.93649400e-02f, -2.84236044e-01f, -3.68796796e-01f, -3.45852107e-01f, -1.66038126e-01f, 5.64223938e-02f, 1.95606306e-01f, 9.67466906e-02f, -1.80955932e-01f, -1.38703123e-01f,
  -2.50086576e-01f, -2.08709054e-02f, -4.23224866e-02f, -5.97221702e-02f, 1.67450681e-01f, 1.08813141e-02f, -1.24684691e-01f, 7.01247230e-02f, 4.56743240e-01f, 3.10789853e-01f,
  2.35352293e-01f, 6.16503768e-02f, 1.38868541e-02f, 7.22067356e-02f, -1.81132600e-01f, 1.27351835e-01f, -2.77561784e-01f, -2.42625833e-01f, -1.93186432e-01f, -4.66983110e-01f,
  5.15842848e-02f, -2.52001584e-01f, -3.63430530e-02f, -1.36052117e-01f, -1.66868404e-01f, 2.66892184e-02f, 6.36608601e-02f, -1.47271812e-01f, -1.81193335e-03f, -2.35735867e-02f,
  -1.26513451e-01f, -4.48497571e-02f, -7.97175914e-02f, -5.48699126e-02f, 7.77622387e-02f, 1.20928369e-01f, -2.80297734e-02f, -7.93649331e-02f, 2.57836729e-02f, -1.44091576e-01f,
  1.69115793e-02f, 3.83671857e-02f, -1.55659681e-02f, -3.60155143e-02f, -9.69553664e-02f, 2.98769753e-02f, 2.25424282e-02f, 3.08176782e-03f, -1.27557516e-02f, -3.77507024e-02f,
  1.48381010e-01f, -4.14995141e-02f, -2.15305276e-02f, -5.18793017e-02f, 6.24628365e-02f, 8.80975872e-02f, 1.95760764e-02f, 9.93237346e-02f, 1.16490722e-01f, 8.23586658e-02f,
  -1.83488317e-02f, -1.17322341e-01f, 2.44751163e-02f, -8.29964578e-02f, -1.05031684e-01f, -1.04476616e-01f, 1.23591103e-01f, 5.66022098e-02f, -1.04215309e-01f, 2.75211851e-03f,
  2.08947863e-02f, -1.57625824e-02f, -1.02534987e-01f, 9.25345346e-02f, -9.85507369e-02f, -2.90981065e-02f, -4.19509336e-02f, -3.63232344e-02f, -8.76454636e-03f, -3.15464474e-02f,
  1.06093027e-01f, -1.65293232e-01f, 7.94133395e-02f, 6.27447739e-02f, -3.94462012e-02f, -8.79214108e-02f, -1.23387218e-01f, -1.41646210e-02f, -2.26106390e-01f, 1.94762908e-02f,
  -1.30996004e-01f, 4.48159911e-02f, -1.13489389e-01f, -5.55729084e-02f, 8.72115046e-02f, 2.32915767e-02f, -3.38339396e-02f, 1.05057426e-01f, -4.26771529e-02f, 1.13696065e-02f,
  -3.45405452e-02f, 1.65410966e-01f, 2.08544284e-01f, 1.11014374e-01f, 1.15519091e-01f, 1.64598420e-01f, 1.17934488e-01f, 6.42347112e-02f, 1.31909847e-01f, 3.15016031e-01f,
  7.11330950e-01f, 2.34104097e-01f, 2.66585678e-01f, 2.15971693e-01f, -3.47983267e-04f, -4.82051484e-02f, 1.65445149e-01f, 1.24527931e-01f, -1.39812872e-01f, 1.06382377e-01f,
  -1.91376001e-01f, -1.75682753e-01f, -8.86631683e-02f, -4.69179861e-02f, 4.98490781e-02f, 1.98354840e-01f, -2.58905850e-02f, 1.02499291e-01f, 1.12618372e-01f, 6.56689107e-02f,
  1.49158701e-01f, 9.25008878e-02f, 2.33874798e-01f, 1.34815827e-01f, 1.53171226e-01f, -2.70849258e-01f, -1.49068773e-01f, 2.83582341e-02f, -1.86427832e-02f, 2.95752674e-01f,
  -5.83467539e-03f, 3.86042804e-01f, -2.02697530e-01f, -1.39230683e-01f, -5.51387481e-02f, -1.21505000e-01f, -7.13910982e-02f, -2.35447437e-02f, -1.01246051e-01f, -2.53504012e-02f,
  -4.25199084e-02f, -4.40442786e-02f, 8.66476670e-02f, -2.30391789e-02f, 5.06006666e-02f, 1.71633109e-01f, 6.83716014e-02f, 1.78789824e-01f, -7.65141621e-02f, -5.36740720e-02f,
  -1.16801769e-01f, -3.47481221e-02f, 2.03573018e-01f, -2.65870467e-02f, 1.38967961e-01f, -5.44137619e-02f, 4.85464148e-02f, 1.38175145e-01f, -7.96696916e-02f, 1.21028192e-01f,
  -9.83769223e-02f, 5.38031608e-02f, -3.12168319e-02f, 3.53252180e-02f, -6.53014407e-02f, 4.16749455e-02f, 3.11593506e-02f, -4.07991447e-02f, 1.93093065e-02f, 1.51775584e-01f,
  -8.37003663e-02f, -3.43361795e-02f, -8.72598439e-02f, -3.30194980e-02f, -1.64323285e-01f, -3.59495729e-02f, 7.12158112e-03f, -1.18039973e-01f, -2.66989078e-02f, -6.11912422e-02f,
  -3.20447027e-03f, 7.80306384e-02f, -2.89799795e-02f, 7.63706714e-02f, -7.48597234e-02f, -4.63014022e-02f, -6.42158762e-02f, -3.36546265e-02f, 5.98172285e-02f, -2.83507723e-03f,
  -3.17011565e-01f, -1.86713323e-01f, 5.32103106e-02f, -1.86062586e-02f, 1.06706694e-01f, 6.89260894e-03f, -5.36849983e-02f, -1.55302426e-02f, -5.41684637e-03f, -9.38531533e-02f,
  2.34288760e-02f, 4.57047410e-02f, -6.10534549e-02f, 2.03496106e-02f, -4.10312004e-02f, -1.10393159e-01f, -1.36535466e-01f, -7.76243731e-02f, -1.36781514e-01f, -6.07049689e-02f,
  -8.49048272e-02f, -1.01280615e-01f, -7.77294412e-02f, -8.82596970e-02f, -1.62979618e-01f, -1.77333504e-01f, 6.10797957e-04f, -6.86652511e-02f, -7.29583278e-02f, -1.63650736e-01f,
  -7.20777452e-01f, -2.03840643e-01f, 2.98059195e-01f, -2.32047558e-01f, -1.15630209e-01f, 1.56924263e-01f, -1.97084412e-01f, -8.35946426e-02f, 2.48748511e-02f, -1.44119889e-01f,
  9.86799896e-02f, -1.15105905e-01f, -6.50925264e-02f, 4.65351120e-02f, 3.75254685e-03f, 2.02424586e-01f, 9.09176841e-02f, -6.01861291e-02f, 9.94579121e-02f, 5.95356664e-03f,
  -1.77839711e-01f, -2.73283213e-01f, -2.61357635e-01f, -1.30733490e-01f, -2.45939419e-01f, -2.72305578e-01f, -1.93758681e-01f, -3.99615526e-01f, -1.86745048e-01f, -4.82639670e-01f,
  3.71150188e-02f, -1.07910141e-01f, 1.09998658e-01f, -9.61565077e-02f, -1.01043843e-01f, -3.29698510e-02f, 4.38875966e-02f, -2.98647340e-02f, 2.23687887e-02f, 3.96323875e-02f,
  2.30070986e-02f, 1.51514813e-01f, -1.52137293e-03f, -2.17405874e-02f, -1.82199791e-01f, 3.70731838e-02f, 1.22507520e-01f, 9.72338617e-02f, 7.93956220e-02f, 1.92154527e-01f,
  -5.52964024e-02f, 1.13250073e-02f, -5.25161326e-02f, 9.53725874e-02f, 1.89953059e-01f, -4.71048728e-02f, -1.58985704e-02f, -1.53434314e-02f, -1.06820747e-01f, -3.99606615e-01f,
  7.26654530e-02f, 9.33286548e-02f, 9.33712646e-02f, -6.55779541e-02f, 5.42312376e-02f, 1.19065121e-02f, 1.17521912e-01f, 2.13884916e-02f, -2.11929064e-02f, -8.24570358e-02f,
  9.65360105e-02f, 1.68693259e-01f, -2.77525373e-03f, -3.71236317e-02f, -5.68049997e-02f, -2.95364559e-02f, -6.32750094e-02f, 4.11307253e-03f, -7.75800198e-02f, -5.93534671e-02f,
  -4.61754426e-02f, 2.48534288e-02f, 3.97410393e-02f, 8.60237628e-02f, 7.68581256e-02f, 2.45138742e-02f, -1.12174049e-01f, -8.37414488e-02f, -7.14683235e-02f, 2.53606085e-02f,
  -2.70211816e-01f, 1.43373564e-01f, -1.55920520e-01f, -1.71758607e-02f, 8.22745077e-03f, 1.01031885e-01f, -1.08209662e-01f, 5.58445826e-02f, -3.33206914e-02f, 9.79176164e-03f,
  -5.25305159e-02f, -1.86116267e-02f, -3.39487381e-02f, 8.13524947e-02f, -1.03666596e-02f, -5.58559820e-02f, -9.89759266e-02f, -9.05591622e-02f, 9.40596126e-03f, 8.21894780e-02f,
  -8.36057886e-02f, -1.54001758e-01f, -5.33476293e-01f, -1.29838958e-01f, -2.12759316e-01f, -3.55498582e-01f, -2.63106406e-01f, -2.82550365e-01f, -4.33845937e-01f, -4.92283791e-01f,
  -5.52323163e-02f, 3.55869420e-02f, -7.29969367e-02f, 4.57753390e-01f, 1.71757326e-01f, 1.83836281e-01f, 1.83682650e-01f, 2.86911398e-01f, 3.07087243e-01f, 2.64855295e-01f,
  2.25136638e-01f, 5.35900593e-01f, 4.38105762e-01f, 3.31834972e-01f, 2.80413389e-01f, 1.97717488e-01f, 3.75411749e-01f, 2.67326742e-01f, 2.17473656e-01f, 1.04186550e-01f,
  2.89689958e-01f, 1.54542461e-01f, 2.72821747e-02f, 1.77277341e-01f, 1.63617939e-01f, 2.55220503e-01f, 2.98195053e-02f, -8.56217146e-02f, 1.33437991e-01f, 1.76287040e-01f,
  -2.97677100e-01f, -6.85976744e-02f, 1.76181540e-01f, -1.48342550e-02f, -7.56189376e-02f, -1.10860534e-01f, -3.63273509e-02f, -1.57515600e-01f, -1.16200529e-01f, -8.88061076e-02f,
  -1.41515970e-01f, -1.05547838e-01f, -2.57364679e-02f, -3.02528869e-02f, -1.73473313e-01f, -1.33804426e-01f, -1.49192093e-02f, 7.31952265e-02f, 1.66268766e-01f, -3.01287454e-02f,
  -3.94921051e-03f, -3.98524804e-03f, -1.52083158e-01f, -2.27801763e-02f, 1.12907313e-01f, 1.25072330e-01f, 4.82674316e-02f, 6.85563684e-02f, -3.51225138e-02f, 4.84301709e-02f,
  2.70801604e-01f, -6.22790456e-02f, 1.14926696e-01f, 5.54834977e-02f, 1.09833494e-01f, 4.78891283e-02f, 4.43935245e-02f, 2.13312194e-01f, 1.27749592e-01f, -1.00378647e-01f,
  -1.66011173e-02f, -2.64411345e-02f, -3.30556221e-02f, -4.55915648e-03f, 1.24504119e-01f, -1.01705082e-01f, -1.61480933e-01f, -4.16593365e-02f, -1.41381800e-01f, -3.91376019e-02f,
  -8.87653381e-02f, -2.17402000e-02f, -8.60283747e-02f, -1.11358911e-01f, -7.13991374e-02f, 6.34724200e-02f, -1.73847377e-02f, 4.07903045e-02f, 7.57494494e-02f, 6.99058473e-02f,
  -1.51570231e-01f, 3.12731028e-01f, 6.57984763e-02f, 8.72968659e-02f, -2.16148030e-02f, -5.93613386e-02f, 6.84599504e-02f, -2.12180540e-02f, -2.72501916e-01f, -1.32689804e-01f,
  -1.74397767e-01f, -9.10442788e-03f, 6.11261167e-02f, -1.74836949e-01f, -1.19433969e-01f, -1.07783265e-01f, -5.81666194e-02f, 1.10583059e-01f, 4.85310666e-02f, -1.51868656e-01f,
  -7.64980167e-02f, 8.72391835e-02f, 4.61020395e-02f, 5.99418804e-02f, 6.55254629e-03f, -2.11955290e-02f, -8.90134647e-02f, -3.76205742e-02f, -1.77878380e-01f, -5.89452013e-02f,
  6.96952224e-01f, -8.07205796e-01f, 1.42523274e-01f, 2.51129299e-01f, 2.64415801e-01f, 1.60579056e-01f, -1.48614481e-01f, 6.07799087e-03f, 2.01693505e-01f, -1.80662021e-01f,
  -8.97487774e-02f, 1.29654095e-01f, 6.90374821e-02f, 2.75529269e-02f, -1.36675850e-01f, -9.71589312e-02f, 1.07510746e-01f, 1.12268806e-01f, 4.11038607e-01f, 3.10965449e-01f,
  -2.03818381e-02f, -1.79486111e-01f, -1.55752420e-01f, -1.18665643e-01f, -9.22959372e-02f, 1.46800548e-01f, -1.48891047e-01f, -1.25672668e-01f, -1.62810951e-01f, -3.36794853e-01f,
  2.94256601e-02f, -6.44273087e-02f, 2.53191948e-01f, -2.33356543e-02f, -1.44106463e-01f, 3.39816622e-02f, 1.77971162e-02f, -4.10373462e-03f, 1.38284579e-01f, 1.17373876e-01f,
  -8.37889034e-03f, -9.64206681e-02f, -1.05870515e-01f, -2.24580821e-02f, -1.33980392e-02f, -2.12346260e-02f, -6.30983785e-02f, -4.43596691e-02f, 2.78502144e-03f, 6.83364738e-03f,
  -1.43274531e-01f, -1.52860070e-02f, 1.70860976e-01f, 1.67315155e-01f, 3.90906297e-02f, 2.08001062e-01f, -9.54885334e-02f, -4.45202850e-02f, 7.72720873e-02f, -8.81152749e-02f,
  6.96571544e-02f, 2.01863497e-02f, -6.27131313e-02f, 2.76066326e-02f, 2.48440541e-02f, 7.47985467e-02f, 6.17553145e-02f, -2.25984585e-02f, 3.32877524e-02f, -1.03380442e-01f,
  -7.29974266e-03f, 3.29177789e-02f, 7.02073872e-02f, -2.96792705e-02f, -1.14255466e-01f, -9.88147557e-02f, -7.98363686e-02f, -4.95160148e-02f, -7.68261999e-02f, -8.19279160e-03f,
  -5.19543551e-02f, 1.35333806e-01f, -1.03780083e-01f, -6.36332156e-03f, -4.80594859e-02f, 1.15790121e-01f, 7.16354698e-02f, -1.12032041e-01f, -1.10086687e-01f, -8.62012431e-02f,
  -9.11763534e-02f, 1.42464057e-01f, 2.56843045e-02f, -2.28586212e-01f, -6.39759377e-02f, -3.14776152e-02f, -2.22010724e-02f, -2.27281004e-02f, 6.61201924e-02f, 5.57571985e-02f,
  3.04982010e-02f, 1.39464950e-02f, -1.33978933e-01f, 1.24991685e-02f, 2.02465385e-01f, 7.22779259e-02f, -2.37931520e-01f, 1.62822604e-01f, 4.08713482e-02f, 7.48374090e-02f,
  -1.81351751e-01f, 1.90078810e-01f, 2.55695164e-01f, 2.60893911e-01f, 1.20969854e-01f, 2.98985153e-01f, 1.76521149e-02f, 3.70221287e-02f, 9.30920094e-02f, -3.98842096e-02f,
  2.02264324e-01f, 4.20877486e-01f, 1.01165436e-01f, 2.20971465e-01f, -2.24029496e-01f, 7.96516836e-02f, 2.69974381e-01f, 2.98462719e-01f, 1.20233320e-01f, 1.60837904e-01f,
  -1.79966763e-01f, 3.53969000e-02f, 1.43807560e-01f, 6.03387952e-02f, 2.33537436e-01f, 1.65739074e-01f, 1.25182018e-01f, 1.14865392e-01f, 5.91993295e-02f, 1.85323451e-02f,
  5.77995740e-02f, -5.16380146e-02f, -4.28720079e-02f, 6.62842616e-02f, 1.32740721e-01f, -1.56638905e-01f, 3.90905291e-02f, -1.02799848e-01f, -4.04971093e-02f, 1.43707186e-01f,
  -1.57461446e-02f, 3.74735057e-01f, 2.03796122e-02f, -1.06567234e-01f, -3.00231148e-02f, 1.21633865e-01f, 4.32338938e-02f, 1.02349333e-01f, 4.46336381e-02f, -1.61591489e-02f,
  -4.65375558e-02f, -3.34983282e-02f, -2.83101760e-02f, -2.56459322e-02f, 7.90891498e-02f, 8.50876644e-02f, 2.40744561e-01f, 2.90554106e-01f, 2.59716809e-01f, 6.76989108e-02f,
  1.04656944e-03f, -4.73604538e-02f, 4.36315872e-02f, 4.81681898e-02f, 1.60671353e-01f, 9.36411768e-02f, 7.95396939e-02f, 5.66980690e-02f, 6.01571128e-02f, 9.49371457e-02f,
  -2.36452654e-01f, 6.24039695e-02f, 3.46607529e-02f, -1.13682188e-02f, -8.68506655e-02f, -5.57639636e-03f, 4.28973623e-02f, 7.47691374e-04f, -4.09183018e-02f, 3.71629968e-02f,
  3.01035680e-02f, 3.72996181e-02f, 1.72746122e-01f, 4.39991541e-02f, 1.41268084e-02f, -2.02456359e-02f, 2.62613278e-02f, 8.52845758e-02f, 4.79784347e-02f, -1.05437944e-02f,
  7.48981684e-02f, -5.23090316e-03f, 2.11110655e-02f, 1.04046546e-01f, -5.88824823e-02f, 1.66596457e-01f, 9.64699686e-02f, 1.05044425e-01f, -1.15774728e-01f, -5.23139983e-02f,
  -3.73767409e-03f, 2.40088418e-01f, 4.16176114e-03f, 1.13188475e-01f, 1.66799817e-02f, 1.24044623e-02f, 7.93365389e-02f, 2.91262530e-02f, -6.40495047e-02f, 1.71119198e-01f,
  3.53862010e-02f, 5.44804111e-02f, 5.84489591e-02f, 4.82190624e-02f, -1.50451371e-02f, 3.60396914e-02f, 7.47386366e-02f, -2.67399987e-03f, 3.26337591e-02f, 1.10358700e-01f,
  -1.86604820e-03f, -3.69560905e-02f, -6.51015341e-02f, 8.53085220e-02f, -2.51043923e-02f, -1.53316602e-01f, 3.85923684e-02f, -3.37273651e-03f, 6.33767992e-02f, -1.36113033e-01f,
  -1.71405375e-02f, -3.37557226e-01f, -2.86756754e-01f, 1.11056052e-01f, -1.69050559e-01f, -1.48766227e-02f, -3.30611050e-01f, 4.08838540e-02f, 1.05449222e-01f, -3.03511053e-01f,
  1.46742146e-02f, 4.15095836e-01f, 1.27087146e-01f, 4.22939807e-02f, 1.68343335e-01f, -4.43426102e-01f, -3.74989688e-01f, 6.97446913e-02f, 4.69708383e-01f, 2.56270379e-01f,
  3.01139541e-02f, -7.79132843e-02f, 1.53161615e-01f, 9.35994685e-02f, -3.29554260e-01f, -1.65549755e-01f, -5.44109821e-01f, -3.17680925e-01f, -2.80446738e-01f, -6.61237180e-01f,
  -3.50292593e-01f, 1.46064863e-01f, 2.20790088e-01f, 1.46308811e-02f, -1.53319612e-01f, 1.11358300e-01f, 2.07848474e-01f, 3.78522612e-02f, 8.39859247e-02f, 5.72510846e-02f,
  -5.09694628e-02f, 8.92120525e-02f, 7.91435763e-02f, 1.51279330e-01f, 2.72804871e-02f, -6.35543256e-04f, 8.81810859e-02f, 8.60151649e-02f, -3.01772300e-02f, 8.97051319e-02f,
  2.74410984e-03f, 5.36457859e-02f, 1.55477002e-01f, 5.13581857e-02f, 2.32223094e-01f, 1.71836644e-01f, -3.44822407e-02f, -4.97121625e-02f, 2.51369718e-02f, -2.35985264e-01f,
  -1.11453719e-01f, 1.97690949e-02f, -7.48815853e-03f, 8.47658515e-02f, 7.53851309e-02f, -5.27522806e-03f, -7.49531910e-02f, -2.39565093e-02f, 1.64474901e-02f, -4.91633676e-02f,
  7.40965679e-02f, 4.25058901e-02f, 7.10557252e-02f, 3.89011228e-03f, -8.22094455e-02f, -7.71409180e-03f, -1.12312466e-01f, -8.85411818e-03f, -1.51961641e-02f, -6.76710606e-02f,
  9.60646719e-02f, 3.58385928e-02f, -2.58959867e-02f, -4.19789962e-02f, -7.17775449e-02f, -9.52800140e-02f, -6.20612763e-02f, 1.12269931e-01f, 9.99926329e-02f, 3.88244875e-02f,
  -5.19699268e-02f, 1.51906861e-02f, -1.05852269e-01f, 2.57330865e-01f, -1.37631714e-01f, 2.58725621e-02f, -1.04479581e-01f, -2.24435013e-02f, -8.82149860e-03f, 3.77730392e-02f,
  3.96882892e-02f, 5.73091349e-03f, -9.88659933e-02f, 2.93517150e-02f, 8.62396061e-02f, 1.57026816e-02f, -7.89609700e-02f, -8.76452476e-02f, 7.12135732e-02f, -5.37481792e-02f,
  -7.21876025e-02f, 3.45642269e-02f, 8.50538313e-02f, -8.54558349e-02f, 4.92693996e-03f, 3.93880308e-02f, -1.88715607e-01f, -1.47490889e-01f, -3.88952233e-02f, -2.65309721e-01f,
  -5.55943787e-01f, 1.31548986e-01f, -1.98125646e-01f, 3.03917471e-02f, 5.08957803e-02f, 1.95027813e-02f, 6.13204204e-02f, 2.37808917e-02f, 4.84916866e-02f, -4.08615693e-02f,
  -8.41898657e-03f, -5.33761680e-02f, 4.29154448e-02f, 1.99457761e-02f, 1.30387917e-01f, 2.27066904e-01f, 1.93973243e-01f, -1.63473748e-02f, -2.03373209e-01f, -1.86055213e-01f,
  6.08217791e-02f, 3.94298090e-03f, -1.77703649e-01f, 4.15953837e-04f, 3.27493459e-01f, 7.62854218e-02f, 9.83330309e-02f, 3.48524824e-02f, 1.67654470e-01f, 4.64793384e-01f,
  -6.14193976e-02f, 1.37474686e-01f, 1.61450028e-01f, 4.87323888e-02f, 5.30193634e-02f, 6.20711502e-03f, 1.35946004e-02f, 6.13212772e-02f, -6.90531265e-03f, 7.21527562e-02f,
  1.28614694e-01f, -1.43398762e-01f, -1.33312076e-01f, -1.10470451e-01f, -1.69320121e-01f, -1.36008650e-01f, -5.17616160e-02f, -3.89991282e-03f, 1.40095726e-01f, 9.00202915e-02f,
  3.69827189e-02f, 1.22078784e-01f, 5.46791442e-02f, -9.57915187e-03f, 9.34280753e-02f, 1.49552122e-01f, 6.65335357e-02f, 7.78196007e-02f, 4.46732938e-02f, 4.39975634e-02f,
  -8.73180553e-02f, -1.45846397e-01f, -5.32511510e-02f, -7.44789764e-02f, -1.01657026e-01f, -8.38154405e-02f, -1.35885283e-01f, -5.44788390e-02f, -9.32698250e-02f, -1.70668691e-01f,
  -1.80686880e-02f, -3.93911488e-02f, -2.92027686e-02f, -1.84422851e-01f, -5.45464158e-02f, 5.86959384e-02f, 8.05507824e-02f, 1.73046112e-01f, 8.57659802e-02f, 8.10069814e-02f,
  1.14425704e-01f, -6.70714378e-02f, -7.45398700e-02f, 7.38414526e-02f, 8.82677957e-02f, -5.17607114e-05f, 3.54298274e-03f, 2.66407002e-02f, -1.36266619e-01f, -3.22406529e-03f,
  1.27548411e-01f, 1.88087255e-01f, 1.53202415e-01f, 2.84444302e-01f, 9.82912332e-02f, 1.27845868e-01f, 1.37686759e-01f, -4.35521975e-02f, 2.30296165e-01f, 1.32516295e-01f,
  1.96492612e-01f, -9.23419893e-02f, 2.63906512e-02f, 5.84712252e-02f, -2.17479944e-01f, -5.56949638e-02f, 5.14072645e-03f, -3.55904130e-03f, 8.99979621e-02f, 1.44426590e-02f,
  5.33167236e-02f, 3.20512541e-02f, -6.48116991e-02f, -4.92335893e-02f, -7.43408650e-02f, 8.90855342e-02f, 1.76318549e-02f, 1.26870468e-01f, -1.19786942e-02f, -1.64291263e-01f,
  -3.11574101e-01f, -6.01788424e-02f, 2.25867957e-01f, 1.94640592e-01f, -1.65180415e-01f, -3.90370578e-01f, -3.55207294e-01f, -1.19928256e-01f, -2.68460345e-02f, -4.50223982e-02f,
  -4.23596561e-01f, -9.85844806e-02f, 1.16556048e-01f, 1.89744979e-01f, 1.36717394e-01f, 1.19735010e-01f, 4.59113032e-01f, 4.87092793e-01f, 1.61172003e-01f, -2.46349841e-01f,
  -2.37226915e-02f, 1.87063277e-01f, 1.17938988e-01f, 7.93308541e-02f, 4.93077524e-02f, 4.12422582e-04f, 4.51272912e-02f, 8.67611766e-02f, -1.32694930e-01f, 5.68761885e-01f,
  -1.30879760e-01f, -1.22271866e-01f, 4.69211414e-02f, -9.25095081e-02f, 4.89923768e-02f, 7.50776902e-02f, 6.77548572e-02f, 1.48652866e-01f, -7.81716779e-02f, 2.10314855e-01f,
  1.23448540e-02f, -5.87230250e-02f, -3.72293703e-02f, -9.70932189e-03f, 4.77027334e-03f, -1.18549272e-01f, 2.02926308e-01f, 2.83710480e-01f, 1.52536184e-01f, -1.80528179e-01f,
  5.70580773e-02f, -3.21257934e-02f, -6.70628250e-02f, -1.02277681e-01f, 1.20986417e-01f, 9.99481305e-02f, -1.67888165e-01f, 5.81942759e-02f, -7.97831863e-02f, 7.07773268e-02f,
  -5.31370305e-02f, -8.27467591e-02f, -5.18316962e-03f, 9.49171260e-02f, 1.93649922e-02f, 3.76503952e-02f, 4.19621542e-02f, 3.05391420e-02f, 6.47186860e-02f, 6.76551387e-02f,
  -3.80312093e-02f, -1.52917933e-02f, 1.32041842e-01f, -9.78815034e-02f, -5.84998503e-02f, 1.02767311e-01f, -6.31148517e-02f, -2.87248679e-02f, -3.42620015e-02f, 2.21192408e-02f,
  -1.68396533e-02f, 5.58676682e-02f, -4.59371954e-02f, 5.62502593e-02f, -5.15040196e-02f, 5.16089844e-03f, 9.44072474e-03f, -5.07713819e-04f, -1.24909645e-02f, 8.57044086e-02f,
  -9.00654644e-02f, 1.06130600e-01f, -2.08000585e-01f, 9.72004905e-02f, -2.94579305e-02f, -1.75665189e-02f, -8.04842710e-02f, -1.01070136e-01f, -3.97950150e-02f, -1.61164001e-01f,
  -9.55406874e-02f, -1.61674824e-02f, 7.21702725e-02f, 1.30745918e-01f, -1.84348486e-02f, 8.59426931e-02f, -5.88466786e-02f, -1.15471497e-01f, -4.08423245e-02f, -7.07349554e-02f,
  -4.62564640e-02f, -6.10910058e-02f, -2.08662391e-01f, -6.17549457e-02f, 2.86605768e-02f, -1.59488156e-01f, -1.44998610e-01f, 3.45558003e-02f, -1.72994375e-01f, -2.91070014e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.25327555e-03f, 3.15702617e-01f, 5.78170829e-02f, -2.20520541e-01f, -2.83011217e-02f, 1.20851412e-01f, 1.34879455e-01f, 1.17004424e-01f, 7.38393292e-02f, 2.33787224e-02f,
  2.13844124e-02f, -1.02178119e-01f, -3.12231690e-01f, 9.99446362e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.80649620e-02f, -1.51045453e-02f, 3.54341209e-01f, 4.32270691e-02f, -3.21647376e-02f, 2.36887351e-01f, 2.72573352e-01f, 1.57962054e-01f, 1.18282929e-01f, -5.69144562e-02f,
  8.56263712e-02f, -5.67576408e-01f, -7.70036923e-03f, -1.05226366e-03f, -1.35778934e-01f, -2.56913248e-02f, 1.05317973e-01f, 1.20481990e-01f, 2.03774676e-01f, 5.87172136e-02f,
  7.90516585e-02f, 8.17253441e-02f, 1.61460236e-01f, -1.75508961e-01f, -1.49132475e-01f, 2.48410814e-02f, 9.46491957e-02f, -4.49085892e-05f, 4.44336310e-02f, -2.37502009e-02f,
  9.03774127e-02f, 1.71616659e-01f, 4.78889011e-02f, 2.95277417e-01f, 2.97571719e-01f, -6.66036978e-02f, 4.21128273e-01f, 3.45126987e-01f, 3.28581601e-01f, 3.37368727e-01f,
  2.32080311e-01f, -2.13234931e-01f, -3.03451777e-01f, -1.47639215e-01f, -5.19284420e-03f, 3.89251888e-01f, -9.78911743e-02f, -2.66789407e-01f, -2.42147416e-01f, -2.79215187e-01f,
  1.57788068e-01f, 4.60945554e-02f, 2.49358863e-01f, -5.31580374e-02f, 1.62502676e-01f, -2.79074967e-01f, 2.32500538e-01f, 1.84169114e-01f, -1.92529261e-02f, 2.63083428e-01f,
  2.42137328e-01f, -2.60045081e-01f, 3.81296575e-02f, 7.95886219e-02f, -1.22612230e-01f, -4.05881032e-02f, 1.43381745e-01f, -2.48600453e-01f, -2.20049933e-01f, 1.10203708e-02f,
  -2.28224043e-02f, -3.65309387e-01f, -1.88895896e-01f, -1.51273124e-02f, 2.29441021e-02f, -3.29782069e-01f, 1.50630414e-01f, -1.32020727e-01f, -2.88445260e-02f, 2.41396546e-01f,
  1.76702186e-01f, -1.30719975e-01f, 4.79645818e-01f, 2.14330420e-01f, -4.76887256e-01f, 1.02457978e-01f, 1.01140747e-02f, -1.33546084e-01f, -2.14422733e-01f, -2.18354702e-01f,
  -4.37286235e-02f, -2.22304508e-01f, -1.64073929e-01f, 1.46846950e-01f, -1.14641145e-01f, -2.23992437e-01f, 4.07841653e-02f, 2.73738056e-02f, -3.35829183e-02f, -1.56352982e-01f,
  1.21952072e-01f, 1.60145342e-01f, 1.42552584e-01f, -6.06455328e-03f, 2.34846041e-01f, 2.93644905e-01f, -1.56160325e-01f, 1.84750259e-02f, 3.20607513e-01f, 2.51229778e-02f,
  -1.02718495e-01f, -1.74807888e-02f, -1.81920797e-01f, -2.29261145e-01f, 1.51823103e-01f, -3.99217531e-02f, -2.28435129e-01f, 1.98277667e-01f, -7.81253651e-02f, 4.59318385e-02f,
  -1.44994318e-01f, -5.26589632e-01f, 7.11573511e-02f, 2.77684629e-01f, -1.27593964e-01f, 1.09342083e-01f, -1.76569194e-01f, -4.14426714e-01f, 3.85274887e-02f, -2.72469060e-03f,
  -1.05352283e-01f, -1.08974203e-02f, 4.90848944e-02f, -8.56844634e-02f, 2.33057424e-01f, 1.02004625e-01f, -1.04976311e-01f, -1.54319644e-01f, 3.93199958e-02f, 1.77686796e-01f,
  -2.12364122e-01f, -2.50597745e-01f, 1.77704856e-01f, -2.40368739e-01f, 1.46475472e-02f, 7.79188722e-02f, -2.59460598e-01f, -6.30132779e-02f, -2.31784374e-01f, -9.54695717e-02f,
  1.84557676e-01f, -4.04276371e-01f, 1.98408112e-01f, 2.85870105e-01f, 7.86604211e-02f, 1.62855685e-01f, 3.04988921e-01f, 1.40347660e-01f, 2.51900941e-01f, -3.53064388e-02f,
  -7.49289244e-02f, -1.89946100e-01f, -1.87960029e-01f, -7.49093900e-03f, -3.01268846e-01f, -1.63476124e-01f, -5.85530996e-02f, -6.12985417e-02f, -1.07471175e-01f, -1.37973055e-01f,
  9.34329908e-03f, -1.79854095e-01f, -1.36537328e-01f, 1.82948872e-01f, -3.49488497e-01f, -4.06049401e-01f, -1.26494244e-01f, 7.06465542e-02f, -5.40137254e-02f, -2.28076100e-01f,
  1.80934846e-01f, -1.55474380e-01f, 5.13389707e-02f, 9.15121213e-02f, -1.11321900e-02f, -3.85536462e-01f, 8.77270848e-02f, -5.83591424e-02f, -1.68169677e-01f, 5.14147319e-02f,
  -2.19394922e-01f, 5.27420163e-01f, 1.08651659e-02f, 2.21380502e-01f, -2.55343765e-01f, 1.05814829e-01f, 1.75293580e-01f, 2.22348154e-01f, 5.26262075e-02f, 1.37057006e-01f,
  -6.92712516e-02f, 1.33741081e-01f, -9.95566789e-03f, 5.02664387e-01f, 4.63285476e-01f, 1.35139972e-01f, 1.08972140e-01f, -9.25795361e-03f, -1.24832809e-01f, -3.50227989e-02f,
  9.31208432e-02f, -1.76129326e-01f, 4.48760539e-01f, 2.51136273e-01f, -4.95295078e-02f, 4.43660200e-01f, -2.35154495e-01f, -2.22782325e-02f, 1.11281618e-01f, 3.59415896e-02f,
  -4.96072285e-02f, 1.90302849e-01f, -3.41023803e-02f, -2.47326553e-01f, 6.85178116e-02f, 3.33609432e-02f, -1.20802574e-01f, -2.37934664e-01f, -3.92626077e-02f, -1.64185748e-01f,
  -9.02722478e-02f, 3.55844642e-03f, 2.29905903e-01f, 9.76355150e-02f, -1.27202258e-01f, -1.87293991e-01f, 1.18362755e-01f, 2.42731586e-01f, -6.37027100e-02f, 3.23447064e-02f,
  -1.27227064e-02f, -1.02207661e-01f, 7.79318213e-02f, -2.74650097e-01f, 8.31890777e-02f, 4.11845595e-02f, 5.64267412e-02f, -4.31695655e-02f, -6.69155046e-02f, -1.25101253e-01f,
  -5.78647181e-02f, 1.81387246e-01f, 1.42618686e-01f, 2.14021727e-02f, -9.65653285e-02f, 2.20305100e-01f, -1.90715984e-01f, 2.73646927e-03f, 4.82991844e-01f, 1.53741702e-01f,
  -7.67631549e-03f, 3.23741287e-01f, 3.19824338e-01f, -1.44201815e-01f, -7.52016976e-02f, 2.54260391e-01f, 1.58335671e-01f, -2.04747871e-01f, 5.16428053e-01f, -1.55979618e-01f,
  1.93071157e-01f, 5.21708950e-02f, 2.49558777e-01f, 1.09380215e-01f, 3.24424729e-02f, 1.60705447e-01f, -4.23986822e-01f, -2.40350962e-01f, 3.89178991e-01f, -2.58888274e-01f,
  -3.90739948e-01f, 9.47433934e-02f, 3.73344272e-02f, 1.48774460e-01f, -8.66216496e-02f, 2.42330596e-01f, -1.74333155e-01f, 1.52309120e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.03219980e-01f, 2.00981066e-01f, 1.25574693e-01f, 4.44870777e-02f, 6.90213218e-02f, 1.05483688e-01f, 1.29500061e-01f, 1.56406552e-01f, 1.10456169e-01f, -1.17657883e-02f,
  1.41425794e-02f, -2.25903168e-02f, -1.93535194e-01f, 1.21167548e-01f, -8.03196132e-02f, -2.26602763e-01f, -1.96142703e-01f, 4.86854762e-02f, 1.64646909e-01f, 1.20760314e-01f,
  1.96404025e-01f, 3.29320520e-01f, 2.54073530e-01f, -1.06680885e-01f, -1.04254536e-01f, -7.35624582e-02f, 3.04207534e-01f, -3.11797231e-01f, 5.19965328e-02f, -2.75831252e-01f,
  8.55671987e-03f, 4.13217783e-01f, 7.48367235e-02f, 1.09682442e-03f, 9.47731137e-02f, 1.47462741e-01f, -1.96291208e-01f, 1.07924581e-01f, 1.54985502e-01f, -3.56478602e-01f,
  -1.57880604e-01f, 4.50617731e-01f, 3.18418927e-02f, -1.96140021e-01f, 2.41414785e-01f, -7.91297555e-02f, -1.89711750e-01f, -3.42314132e-02f, -6.74168020e-02f, -1.69393480e-01f,
  1.44934297e-01f, 6.10588975e-02f, 2.51642048e-01f, -3.03826064e-01f, -1.47021770e-01f, 3.30910116e-01f, -1.63802819e-03f, -2.41421744e-01f, -1.51082993e-01f, 2.92017072e-01f,
  -1.90889835e-01f, 4.64297563e-01f, 3.75158563e-02f, -3.08438510e-01f, 1.60280243e-01f, 9.84614119e-02f, 6.15369342e-02f, 3.64053339e-01f, 2.76876628e-01f, -1.05001427e-01f,
  -9.32765082e-02f, 2.27583662e-01f, 9.71455500e-02f, 2.79489160e-01f, 6.49609640e-02f, -4.65280861e-02f, -4.71162833e-02f, -9.72456783e-02f, -4.25739251e-02f, -1.09610803e-01f,
  3.78918439e-01f, 7.32946545e-02f, -5.68550639e-02f, -9.04354919e-03f, -1.74053654e-01f, -8.64987150e-02f, 3.26195598e-01f, -7.66879544e-02f, 2.82788157e-01f, 2.50223190e-01f,
  2.75930226e-01f, -1.94350868e-01f, -6.63741380e-02f, 2.24801332e-01f, -1.19284689e-01f, 2.96491861e-01f, 2.42765516e-01f, 1.68324828e-01f, 2.31235683e-01f, -1.52261093e-01f,
  2.40745425e-01f, 1.80056468e-01f, 9.98765752e-02f, -1.15068266e-02f, 1.98897451e-01f, -4.51022029e-01f, 3.53389680e-02f, -4.68242556e-01f, -2.10870251e-01f, 1.59258515e-01f,
  2.84377695e-03f, -2.29367957e-01f, 2.32744217e-01f, 2.24039823e-01f, 1.23856679e-01f, 1.15646884e-01f, 3.77921224e-01f, -4.56122868e-02f, 3.51090610e-01f, -2.29777992e-01f,
  -4.89031188e-02f, 7.61910295e-03f, 8.68664682e-02f, -1.74368173e-01f, -1.48854256e-01f, -2.20041171e-01f, 5.13169952e-02f, 5.65911651e-01f, -9.93303284e-02f, 3.28245685e-02f,
  1.92189366e-01f, 1.24972090e-01f, 1.36475936e-01f, 9.34011787e-02f, 5.04077934e-02f, 2.59453177e-01f, 1.20368876e-01f, -7.43950531e-02f, 8.68327823e-03f, 2.04927146e-01f,
  6.85154572e-02f, -2.56137341e-01f, 2.08425596e-01f, -1.43107668e-01f, 1.01818688e-01f, 2.83820659e-01f, -4.61891592e-01f, 1.77299306e-01f, 2.72129644e-02f, -2.66848922e-01f,
  -1.36330515e-01f, -9.82092991e-02f, 5.35057411e-02f, 4.49829519e-01f, -4.44074720e-01f, 8.87635723e-03f, 6.88103493e-03f, 3.20653677e-01f, 1.96676731e-01f, 1.91976890e-01f,
  5.15309274e-02f, 1.51388114e-02f, 7.27226660e-02f, -1.38669536e-01f, 1.36600211e-02f, 1.44765347e-01f, 1.83011219e-01f, -8.25286880e-02f, -5.94617501e-02f, -2.24979311e-01f,
  7.56466165e-02f, 1.17224939e-01f, 9.20835808e-02f, 4.26308736e-02f, 1.13469996e-01f, -2.59756207e-01f, -4.98845354e-02f, -9.95247141e-02f, -4.88182068e-01f, -2.41108999e-01f,
  4.95965540e-01f, 1.94720551e-01f, 1.15110986e-01f, 6.85693473e-02f, 2.44048178e-01f, -3.07472120e-03f, 1.66640952e-01f, 2.82061309e-01f, 1.60515711e-01f, -8.67132246e-02f,
  4.98943031e-02f, -1.29516006e-01f, -2.42930539e-02f, 2.56876759e-02f, 1.46184877e-01f, -7.50165284e-02f, 2.24577174e-01f, 2.58164525e-01f, 9.11065713e-02f, -8.24664682e-02f,
  6.28875718e-02f, 2.06573635e-01f, 1.29002526e-01f, -9.81438458e-02f, 3.82083445e-03f, 2.31744438e-01f, 1.21213734e-01f, 6.70290515e-02f, -5.78579187e-01f, -1.96789250e-01f,
  -5.89645743e-01f, -6.07888758e-01f, 2.86458492e-01f, -2.08283663e-01f, 4.31617014e-02f, 1.95560053e-01f, 4.15322095e-01f, -5.29298186e-01f, -2.36210376e-01f, 4.49272007e-01f,
  -1.47705033e-01f, -2.36472845e-01f, -3.02194923e-01f, 1.70728505e-01f, 1.55682206e-01f, 2.73987390e-02f, 1.11625180e-01f, 2.60918792e-02f, 2.41540879e-01f, 4.97621782e-02f,
  7.54514709e-03f, -1.23149849e-01f, -1.29450291e-01f, 1.76045820e-01f, 4.11238223e-02f, 4.12460864e-01f, 3.96495052e-02f, 9.19192955e-02f, 2.18656003e-01f, -3.00395992e-02f,
  -2.06043631e-01f, -2.52721816e-01f, -1.52851408e-02f, -3.22240382e-01f, -5.12058258e-01f, -2.05276400e-01f, 8.02711584e-03f, -2.90902644e-01f, 2.93228000e-01f, 3.95655679e-03f,
  1.04393415e-01f, -2.15280458e-01f, 2.59333074e-01f, 2.15612024e-01f, -2.01329604e-01f, -1.73443303e-01f, 6.43169507e-02f, 1.32722870e-01f, 3.56825352e-01f, 2.48973608e-01f,
  3.78044881e-02f, 1.61107540e-01f, -3.11996546e-02f, 6.36031032e-02f, 1.20190114e-01f, 5.92712723e-02f, 3.91389839e-02f, -4.33947951e-01f, -6.37790039e-02f, -6.12898357e-02f,
  1.02139965e-01f, 1.30529106e-01f, 1.24796666e-01f, -2.86390968e-02f, 1.38207152e-01f, 2.66448408e-01f, 2.41287068e-01f, -8.92838184e-03f, -1.53106853e-01f, 1.87497452e-01f,
  -2.30457246e-01f, 3.52528453e-01f, 3.15087698e-02f, 3.07816535e-01f, -4.89188768e-02f, 5.26222110e-01f, -1.16757214e-01f, -1.03049420e-01f, 1.00070402e-01f, 1.79678798e-01f,
  -4.14749645e-02f, -2.43425503e-01f, 2.69782990e-01f, 1.13815933e-01f, 6.19370788e-02f, 2.50400513e-01f, 4.14540261e-01f, 2.97669210e-02f, -4.48465645e-02f, 1.95580468e-01f,
  9.01620369e-03f, 1.06614083e-01f, -4.16331857e-01f, 2.21556023e-01f, -1.45995885e-01f, -1.23896092e-01f, 1.98653430e-01f, -1.22712627e-02f, 1.79088905e-01f, 1.70243561e-01f,
  -1.98299915e-01f, 1.41073868e-01f, 2.48572528e-01f, -1.98656783e-01f, -7.74932802e-02f, 3.08163553e-01f, -1.77519083e-01f, -5.67796640e-02f, -1.92408428e-01f, 1.13716513e-01f,
  2.61092395e-01f, 7.00459704e-02f, 1.26563415e-01f, 7.77767375e-02f, -4.53328453e-02f, -1.66107006e-02f, -4.70494293e-03f, 5.30954264e-02f, -6.53847009e-02f, -1.59013480e-01f,
  -9.48849134e-03f, -1.20723106e-01f, -1.85558036e-01f, 7.09182471e-02f, -1.97204202e-01f, 6.71269745e-02f, -6.54928461e-02f, 1.73854828e-01f, 2.33024150e-01f, 1.94822922e-01f,
  3.73089649e-02f, 2.26416990e-01f, 5.08244708e-03f, -1.16007775e-01f, -1.87057048e-01f, -1.39083564e-01f, -3.43786895e-01f, 3.19782831e-02f, 1.47399336e-01f, 5.46156131e-02f,
  2.55439699e-01f, 2.47290120e-01f, 8.52680728e-02f, 8.26137960e-02f, 5.22910953e-01f, 1.56485260e-01f, -1.40716702e-01f, 3.23593378e-01f, 8.53074566e-02f, -2.71038748e-02f,
  1.68056916e-02f, -1.56630203e-01f, -1.19536445e-01f, -3.98575425e-01f, -1.44600868e-01f, -2.63531536e-01f, 1.26786008e-01f, 5.52543849e-02f, -4.44854945e-02f, 5.65197051e-01f,
  -8.36886291e-04f, 3.76399517e-01f, 5.08412719e-01f, -1.71141282e-01f, 5.31345844e-01f, -1.05564833e-01f, -2.54983068e-01f, -1.18734874e-01f, 2.81020820e-01f, -2.35323220e-01f,
  -2.03665853e-01f, 3.36626381e-01f, 8.17173123e-02f, 5.08549750e-01f, -8.48690942e-02f, 6.58527464e-02f, -6.90044649e-03f, -1.57466196e-02f, 1.52445406e-01f, 1.02233768e-01f,
  1.38824105e-01f, -1.04493052e-01f, 1.96586084e-03f, -4.28533554e-03f, 4.77733556e-03f, -2.09549695e-01f, 6.68132082e-02f, 1.17304914e-01f, -2.04150409e-01f, 2.77755270e-03f,
  5.40720262e-02f, -9.41667259e-02f, 1.99729323e-01f, -5.36711067e-02f, 5.34617424e-01f, 1.89312827e-02f, -8.13767612e-02f, 1.99161425e-01f, -2.64293496e-02f, -3.87756079e-01f,
  4.14528936e-01f, 3.24943125e-01f, 1.06085427e-01f, 6.46373108e-02f, -1.74866781e-01f, -7.20686913e-02f, 3.88738178e-02f, -3.83427516e-02f, 4.84514445e-01f, 1.66839913e-01f,
  1.16546743e-01f, 2.10987300e-01f, -2.46924549e-01f, 4.88689952e-02f, -2.52947714e-02f, -3.42972577e-02f, 4.86754701e-02f, -3.28253090e-01f, 4.13812138e-02f, -3.57835740e-01f,
  -3.64483297e-02f, 2.37248406e-01f, 4.36451614e-01f, 2.55959153e-01f, 1.39668792e-01f, 5.21423638e-01f, -3.81365567e-01f, -8.24269056e-02f, 3.06256086e-01f, 2.41612732e-01f,
  -4.04250771e-01f, -6.46724179e-02f, 1.78772271e-01f, -1.26859099e-01f, -3.33973885e-01f, 2.17668265e-01f, -1.53861046e-02f, 1.41660213e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.96647161e-01f, 1.63032189e-01f, 1.09354734e-01f, -1.26601622e-01f, 3.70972097e-01f, -1.96035087e-01f, -5.40351029e-03f, 9.33444276e-02f, 4.19895887e-01f, 2.19814718e-01f,
  -4.16783579e-02f, -6.73321262e-02f, 1.24129161e-01f, 1.71350509e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.44176960e-01f, -7.98168778e-02f, 7.87414983e-02f, -2.13274315e-01f, 6.91599697e-02f, 1.00845225e-01f, -7.97267929e-02f, 1.41226828e-01f, 2.49119163e-01f, 1.51221693e-01f,
  4.50928807e-02f, 2.33834922e-01f, 2.36366808e-01f, 5.70163950e-02f, 1.61987498e-01f, 1.27576232e-01f, 8.87190402e-02f, 1.96919553e-02f, 1.63602948e-01f, -1.70166299e-01f,
  -2.03047499e-01f, 8.47085565e-02f, -1.94922253e-01f, 1.96036056e-01f, 1.38189942e-01f, -2.36906976e-01f, 1.27634227e-01f, 1.74745023e-01f, -7.08150789e-02f, -3.24682221e-02f,
  3.42762053e-01f, -2.76807636e-01f, 9.81377065e-02f, -2.48947572e-02f, -2.49490783e-01f, -2.77634501e-01f, 2.42079034e-01f, -1.78055111e-02f, -2.00049073e-01f, 1.56684652e-01f,
  1.01837248e-01f, -4.73600030e-02f, -1.37946710e-01f, 2.91866660e-01f, 2.05422956e-02f, 3.95670719e-02f, 5.33189587e-02f, 1.34225398e-01f, 3.71813513e-02f, 7.94581100e-02f,
  -6.42215163e-02f, 1.75917640e-01f, -1.16037488e-01f, -1.50094137e-01f, 2.30625302e-01f, 2.59732157e-01f, 7.35107243e-01f, -2.55876303e-01f, 1.52016893e-01f, 9.23547298e-02f,
  1.37133390e-01f, 1.48253500e-01f, 9.03785303e-02f, -2.53108859e-01f, 2.23456800e-01f, 2.90317506e-01f, -1.69684783e-01f, 9.66317132e-02f, 8.99384692e-02f, -1.82729885e-02f,
  -7.62491748e-02f, -1.68631747e-01f, -8.99151415e-02f, -2.66528815e-01f, 1.80016860e-01f, 7.41015375e-03f, 5.10160774e-02f, 1.89077601e-01f, -1.38601393e-01f, 3.08535278e-01f,
  -5.38446121e-02f, -1.22107841e-01f, -1.26861498e-01f, 3.89511943e-01f, 1.30026579e-01f, -2.52749264e-01f, 2.14824140e-01f, -8.93798172e-02f, -1.31436422e-01f, 2.16629021e-02f,
  2.94058248e-02f, -6.75540715e-02f, -1.80299267e-01f, 1.94686666e-01f, -2.99925894e-01f, 2.54102536e-02f, -1.27664730e-01f, -1.37533825e-02f, 1.52443066e-01f, 2.43518263e-01f,
  -2.66282022e-01f, 1.18971854e-01f, 1.30413830e-01f, -1.03887217e-03f, -1.58156916e-01f, 2.59140432e-01f, 8.68052617e-02f, 2.76206166e-01f, -1.97802037e-01f, -2.05632702e-01f,
  -3.06348920e-01f, -1.18578270e-01f, -7.05635250e-02f, 8.55600834e-02f, 2.73562483e-02f, 1.86235532e-01f, 1.12154409e-02f, 9.91257504e-02f, 7.82545283e-02f, 1.11038938e-01f,
  -6.84753239e-01f, 8.23452249e-02f, 1.32363260e-01f, -2.35032424e-01f, 1.65322050e-01f, 2.94888377e-01f, -1.26010925e-01f, 2.09412441e-01f, -3.37799378e-02f, -1.09393865e-01f,
  -1.85811669e-01f, 5.75694209e-03f, 1.72736019e-01f, -1.67816699e-01f, 4.02287506e-02f, 1.20191887e-01f, -2.98773021e-01f, 7.76590407e-02f, -2.71730013e-02f, -7.46638551e-02f,
  3.39926518e-02f, 6.69139624e-02f, -4.24820110e-02f, 2.08418407e-02f, -6.20408803e-02f, 1.96457073e-01f, 9.82789919e-02f, 1.74331293e-01f, 8.33943710e-02f, -1.06103063e-01f,
  1.45160183e-01f, -2.55589545e-01f, -2.35657170e-01f, 1.47117168e-01f, 1.54075190e-01f, -1.35515720e-01f, -2.57961094e-01f, 2.37497650e-02f, -2.89397359e-01f, 2.78441966e-01f,
  4.59030680e-02f, -6.76226094e-02f, 1.87225297e-01f, 8.52360949e-02f, 1.93944022e-01f, 1.64316833e-01f, 3.39381576e-01f, -5.03049269e-02f, -2.19539165e-01f, 1.57152727e-01f,
  1.12328440e-01f, 7.69945160e-02f, 5.24094664e-02f, -3.37757438e-01f, -2.87110329e-01f, 6.16984591e-02f, 3.41129124e-01f, 3.88919175e-01f, -3.95495184e-02f, 6.26118779e-01f,
  6.17528670e-02f, 5.98536618e-02f, -1.62278995e-01f, -1.12457946e-01f, 2.78540283e-01f, 6.32025525e-02f, 1.22959509e-01f, -1.26183197e-01f, -1.37530062e-02f, 2.29251057e-01f,
  -9.26532000e-02f, 3.16043913e-01f, -5.53547293e-02f, -1.12644695e-01f, 3.71500134e-01f, -2.26967156e-01f, 5.76926023e-02f, -1.23086803e-01f, -2.93113701e-02f, 1.49475383e-02f,
  -8.03251415e-02f, 6.73988536e-02f, 5.58953509e-02f, 7.27842674e-02f, 3.71006280e-01f, -5.22453725e-01f, -3.54264706e-01f, 6.88443473e-03f, 2.83438206e-01f, 1.20489314e-01f,
  2.25208234e-02f, -1.04229979e-01f, -1.63948491e-01f, -4.96425927e-02f, -5.05495727e-01f, -2.10215718e-01f, 5.90580776e-02f, 3.77258286e-02f, -3.70827615e-02f, 3.57447565e-01f,
  -2.24812385e-02f, -9.27033089e-03f, 1.82297930e-01f, 1.54263780e-01f, 2.78571278e-01f, 1.58062935e-01f, -8.91912146e-04f, -1.89744368e-01f, 1.26007766e-01f, -1.19450223e-02f,
  -1.29392713e-01f, 1.95638910e-01f, 2.84353167e-01f, -2.62674749e-01f, -5.32080829e-02f, 7.22393095e-02f, 2.15466067e-01f, -2.32024774e-01f, -3.89733434e-01f, 1.33653253e-01f,
  -3.76407243e-02f, -1.20513812e-01f, -2.92737558e-02f, 7.25054443e-02f, 1.42478094e-01f, -1.44090578e-01f, -2.89276779e-01f, 1.69728443e-01f, 1.33751899e-01f, 8.80025253e-02f,
  2.49252707e-01f, 1.01284929e-01f, -3.22421700e-01f, -3.84892464e-01f, 1.97941601e-01f, 7.65479505e-02f, -1.48556948e-01f, -2.86287636e-01f, -3.24851543e-01f, -3.53619695e-01f,
  2.48747803e-02f, -1.29047036e-01f, 2.62508020e-02f, 1.30890340e-01f, 8.69907141e-02f, -1.38715416e-01f, -4.94818911e-02f, 1.06942318e-01f, 1.42410234e-01f, 2.45964140e-01f,
  -9.98983309e-02f, 1.04567952e-01f, 2.20073909e-01f, 8.08735192e-02f, -2.46793441e-02f, -1.34426504e-02f, -6.64114347e-03f, 7.67074749e-02f, 5.88442981e-02f, 8.65604952e-02f,
  7.91449606e-01f, 8.53873789e-02f, -1.33397490e-01f, 3.09584349e-01f, -3.84189069e-01f, -2.33777598e-01f, -8.03120062e-02f, -9.10243839e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.74531037e-01f, 2.13320926e-01f, 6.32081628e-02f, 3.93894196e-01f, -5.59620522e-02f, 2.85058677e-01f, 7.07052574e-02f, 3.94306540e-01f, 3.00828427e-01f, 1.73826981e-03f,
  2.38174751e-01f, -3.89194340e-01f, 9.19123888e-02f, 1.02055445e-01f, -1.71921402e-01f, -1.31101891e-01f, -2.82070041e-01f, -5.86465597e-01f, 4.16249514e-01f, -4.43851471e-01f,
  2.89383084e-01f, 1.16467379e-01f, -1.11009099e-01f, -8.57410654e-02f, 4.23648298e-01f, 5.81811011e-01f, -9.30426344e-02f, 3.15260470e-01f, -7.93756172e-02f, 1.29090980e-01f,
  1.34243995e-01f, -1.16997443e-01f, 2.11796518e-02f, -2.43249148e-01f, -5.20539641e-01f, -7.56515414e-02f, 2.87594944e-01f, 8.39041397e-02f, -3.57391387e-02f, -2.10169926e-02f,
  1.82982191e-01f, -1.16305470e-01f, -4.87400033e-02f, -1.37156144e-01f, 3.82545501e-01f, -5.03626466e-02f, 2.58883864e-01f, -5.87925985e-02f, 1.62691936e-01f, 2.78410971e-01f,
  -3.16754758e-01f, 4.86240804e-01f, -4.07102585e-01f, 1.39737532e-01f, 3.10037911e-01f, 1.59971163e-01f, 9.49580669e-01f, -1.37102976e-02f, 9.21941944e-04f, 3.23731184e-01f,
  4.07865532e-02f, 5.92880286e-02f, 1.01434380e-01f, -2.75078863e-01f, 1.27721275e-03f, 9.89529863e-02f, 1.10644348e-01f, 4.28540796e-01f, -2.00487643e-01f, 1.44710898e-01f,
  6.64617121e-02f, 3.36333185e-01f, 3.34464520e-01f, 4.08474624e-01f, 5.03866911e-01f, -6.06142059e-02f, -6.09185815e-01f, 2.06934169e-01f, 3.06547523e-01f, -4.88729268e-01f,
  2.38635093e-02f, -2.08370090e-01f, 2.87169635e-01f, -3.83591235e-01f, 1.04743741e-01f, 3.97950292e-01f, 1.44248173e-01f, -3.97907853e-01f, -4.18110713e-02f, -1.92078695e-01f,
  -1.61811560e-01f, 2.87552834e-01f, 2.79972881e-01f, 3.37199539e-01f, -1.87080160e-01f, 1.08091429e-01f, -3.47627401e-02f, -1.00925252e-01f, -3.64158660e-01f, -8.19177404e-02f,
  -6.76455349e-03f, 1.63641319e-01f, 4.97929975e-02f, -1.33549497e-01f, -3.50958616e-01f, 8.41022655e-02f, 4.92628254e-02f, -2.79981017e-01f, -2.82316804e-01f, 5.17298162e-01f,
  4.03659970e-01f, -4.21907529e-02f, 4.44260120e-01f, 3.10841560e-01f, 3.15758795e-01f, -4.42087978e-01f, 3.91961604e-01f, 4.91607130e-01f, -1.24464437e-01f, 1.63831621e-01f,
  -2.04155102e-01f, -4.81707245e-01f, -1.27078176e-01f, -2.22064871e-02f, -6.07781559e-02f, 4.76487219e-01f, 6.67114705e-02f, 4.22673300e-02f, 2.36264125e-01f, -1.11460863e-02f,
  1.22146085e-01f, 7.14898575e-03f, -2.66698569e-01f, -1.29444256e-01f, 1.91272587e-01f, 1.73266560e-01f, 6.36226535e-02f, 1.69661567e-01f, 9.30610970e-02f, -4.55715001e-01f,
  -2.20895827e-01f, -3.78687412e-01f, 1.31296933e-01f, -2.72952080e-01f, 5.97829558e-02f, -1.84951335e-01f, -2.39041179e-01f, 2.98737735e-02f, -1.99695572e-01f, -9.98379514e-02f,
  2.04186738e-02f, -2.44199727e-02f, -3.13177317e-01f, -4.77964550e-01f, -1.18106911e-02f, -4.99683172e-01f, 1.50344461e-01f, -5.83774373e-02f, -1.99345294e-02f, -9.52250585e-02f,
  -7.28035346e-02f, -4.40278128e-02f, 1.77041069e-01f, 9.50729921e-02f, 2.52113074e-01f, 3.34595442e-01f, 4.40632254e-01f, 1.67324562e-02f, -4.45432030e-02f, 1.51577428e-01f,
  2.27633238e-01f, -1.90677986e-01f, 2.25491628e-01f, -2.81807691e-01f, -3.71530801e-01f, 1.71233147e-01f, 6.66811094e-02f, 3.28222185e-01f, -1.47999570e-01f, 5.53822517e-01f,
  3.53656709e-01f, 7.88388327e-02f, 2.22000822e-01f, -1.22861974e-02f, -2.43294552e-01f, 4.62188721e-01f, 4.49238837e-01f, 2.22858265e-02f, -1.77475139e-01f, 2.37570375e-01f,
  2.36649409e-01f, 3.93640190e-01f, -1.79731194e-02f, 5.13567589e-02f, -1.93399936e-01f, -4.45917815e-01f, 6.81425855e-02f, 9.20136571e-02f, -2.35574171e-01f, -8.00703689e-02f,
  -5.48375249e-01f, -3.37096825e-02f, -2.21315682e-01f, 3.83607537e-01f, 4.22832757e-01f, 2.27581993e-01f, -7.15673566e-02f, 2.97527552e-01f, -7.03266412e-02f, 6.40009046e-01f,
  -1.07258372e-02f, 5.09185195e-01f, -4.61989045e-02f, -3.36221725e-01f, -1.04002908e-01f, -1.58710510e-01f, 5.54584563e-01f, -4.43504781e-01f, 5.85363582e-02f, 1.14396602e-01f,
  -2.53034860e-01f, 2.30699822e-01f, -4.66375835e-02f, 7.65486956e-02f, 3.67861569e-01f, 2.08541796e-01f, -4.69395034e-02f, 2.66358346e-01f, 1.17700480e-01f, -4.21242975e-03f,
  6.15774333e-01f, 1.44916743e-01f, 1.75943568e-01f, 3.41380745e-01f, 1.47191793e-01f, -3.14860791e-01f, -4.11920696e-02f, 2.47643841e-03f, -2.14956045e-01f, 1.72917351e-01f,
  -9.59855393e-02f, 1.28208056e-01f, -1.08902872e-01f, 4.20040250e-01f, 5.48699051e-02f, 1.17626078e-02f, 3.20660591e-01f, -4.09031034e-01f, -6.00537300e-01f, -8.21250379e-02f,
  5.16419291e-01f, -1.51052296e-01f, -7.06563964e-02f, 3.76641631e-01f, 3.72410901e-02f, 4.32596356e-01f, 1.94817670e-02f, -2.54708409e-01f, -1.44332781e-01f, 8.39624461e-03f,
  -3.79928410e-01f, 2.89472610e-01f, 1.65456265e-01f, 1.45813525e-01f, -1.82730570e-01f, -2.03335151e-01f, 8.75600129e-02f, -3.61427605e-01f, 1.21210091e-01f, -2.54430354e-01f,
  -9.44468305e-02f, -3.72762054e-01f, -1.07522056e-01f, -1.47865266e-01f, 4.14262526e-02f, 6.19433746e-02f, 1.45131230e-01f, 1.88022912e-01f, 1.72825143e-01f, -3.50889787e-02f,
  7.25270510e-01f, 6.08741343e-01f, -3.30767810e-01f, 2.69948930e-01f, 1.42542139e-01f, -1.19483154e-02f, -1.50952727e-01f, 4.78962213e-02f, 2.81347096e-01f, 1.01359852e-01f,
  3.42668474e-01f, 1.79270104e-01f, -6.36642650e-02f, 5.75257801e-02f, -6.05238229e-02f, 6.66154269e-03f, 1.23442873e-01f, 3.15319240e-01f, 3.75403129e-02f, -1.27600998e-01f,
  2.13870138e-01f, -2.59955227e-01f, 2.55864531e-01f, -1.95384979e-01f, 2.58137792e-01f, -2.39417002e-01f, 3.28948528e-01f, -1.57347366e-01f, -7.63058662e-02f, 4.42803353e-01f,
  -1.57727063e-01f, 8.19982514e-02f, 8.29033196e-01f, -2.25877374e-01f, -6.44514784e-02f, 1.12299912e-01f, -1.99846793e-02f, 3.57198417e-01f, 4.69453447e-02f, 4.17876765e-02f,
  8.00203681e-02f, 9.83698368e-02f, 3.85403305e-01f, 2.26905737e-02f, 2.80422986e-01f, -3.11615318e-01f, -1.24749355e-01f, -2.12802246e-01f, 1.66433692e-01f, 1.30883023e-01f,
  -3.81026119e-01f, -1.54020429e-01f, -3.73159230e-01f, 1.72538802e-01f, 1.13693938e-01f, 2.14409769e-01f, -4.63455886e-01f, 1.37826279e-01f, -3.60023767e-01f, 5.10725714e-02f,
  -1.24079369e-01f, -1.99405760e-01f, 2.01829761e-01f, -1.47884637e-01f, 5.20173669e-01f, -1.43623397e-01f, 1.25918716e-01f, -1.29400864e-01f, -1.56646475e-01f, 2.87162885e-02f,
  -6.33730173e-01f, 3.47602665e-01f, 3.10231090e-01f, 3.06876332e-01f, 4.00680512e-01f, -2.06100374e-01f, -9.41919908e-02f, 2.51100510e-01f, -2.57625878e-01f, 3.59750420e-01f,
  1.06684588e-01f, 1.21614039e-02f, 1.29378989e-01f, 3.03450733e-01f, 6.03406429e-01f, -4.01042044e-01f, -1.87551469e-01f, 1.94767952e-01f, 2.66183704e-01f, 9.12654400e-03f,
  1.02754235e-01f, 4.42834079e-01f, 1.77823007e-01f, 3.03900037e-02f, -4.73331302e-01f, 6.49955869e-02f, -4.58920389e-01f, 4.48904634e-02f, 3.18877250e-01f, 3.72317910e-01f,
  -8.44692439e-02f, 2.78967708e-01f, 1.34694651e-01f, 3.56316417e-01f, -3.06489319e-01f, -4.61673468e-01f, -1.49767607e-01f, -1.92500412e-01f, 8.70644152e-02f, 2.06595391e-01f,
  -7.61461854e-02f, 5.06713837e-02f, -9.56876278e-02f, -8.67180973e-02f, -3.24494511e-01f, 1.93692327e-01f, -1.94481134e-01f, 2.45635837e-01f, -3.69058400e-02f, 1.60981849e-01f,
  5.20250976e-01f, -9.78682116e-02f, 3.67145568e-01f, -5.81533372e-01f, 2.50832707e-01f, 1.68199390e-01f, -2.94535428e-01f, 6.56830445e-02f, -2.30448246e-01f, -1.51064888e-01f,
  -1.54636204e-01f, 2.72345990e-02f, -1.04070224e-01f, 8.32274649e-03f, 2.99404979e-01f, -9.19628978e-01f, -4.25341129e-01f, -2.20457435e-01f, 1.39546245e-02f, 1.52796999e-01f,
  6.31527752e-02f, 2.60695934e-01f, 7.60499239e-02f, -6.46717027e-02f, -1.92644581e-01f, 1.91921517e-01f, 1.38440467e-02f, -1.78000256e-01f, -1.87492236e-01f, 3.18085819e-01f,
  -2.71107465e-01f, 1.49380565e-01f, -9.51798484e-02f, 5.49819827e-01f, 2.03701958e-01f, -2.53660735e-02f, 1.70839652e-01f, 3.14511806e-01f, 2.73420602e-01f, 1.12958491e-01f,
  -4.83041227e-01f, -2.79094607e-01f, 4.02822018e-01f, -1.48158357e-01f, 1.06208652e-01f, 5.18501520e-01f, 2.00811148e-01f, 6.23754412e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.71361440e-01f, -6.73403740e-02f, 1.16233878e-01f, 4.47813161e-02f, 1.68571785e-01f, 2.78272927e-01f, 3.95320840e-02f, 6.67265877e-02f, 2.10309744e-01f, -1.37451068e-01f,
  1.26273513e-01f, 2.66723037e-01f, 3.39950509e-02f, -1.93352386e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.63476372e-01f, -6.17845543e-02f, 3.94036435e-02f, 1.90039903e-01f, -2.50969797e-01f, 4.01635647e-01f, 2.69833237e-01f, 1.66095108e-01f, -1.37360051e-01f, -2.09350467e-01f,
  -1.60459295e-01f, -8.59059766e-02f, -7.63325915e-02f, -3.92023891e-01f, -3.68856788e-02f, -2.49339640e-01f, -2.09001586e-01f, -1.49647826e-02f, -4.32056002e-02f, 2.67479181e-01f,
  7.34299719e-02f, 1.59517154e-01f, 6.04293607e-02f, -3.01245630e-01f, -3.17955285e-01f, -7.52380341e-02f, -3.13043952e-01f, 2.94979274e-01f, 1.40632927e-01f, -1.57541350e-01f,
  1.41394064e-01f, 1.49833575e-01f, 2.57783562e-01f, 1.06132433e-01f, 1.08096920e-01f, 3.87620091e-01f, 2.07282528e-01f, 1.37825578e-01f, -1.87646136e-01f, 9.27925333e-02f,
  1.65925995e-01f, 2.42106169e-02f, 2.61808723e-01f, 5.31152040e-02f, 2.44253613e-02f, -2.10118651e-01f, -2.95826495e-02f, 3.38049114e-01f, 3.72617424e-01f, -1.07263342e-01f,
  -7.69210756e-02f, -2.74046063e-01f, -3.19575310e-01f, -1.03406191e-01f, 5.00890950e-04f, 2.33977512e-02f, 1.94815397e-01f, 3.21879417e-01f, -2.83250660e-01f, 1.60226263e-02f,
  9.50062275e-02f, 3.21088284e-01f, 2.16754243e-01f, -8.46044868e-02f, -6.29658327e-02f, 3.86440605e-02f, 5.31823933e-02f, 1.28379971e-01f, -1.17354639e-01f, 2.24732772e-01f,
  -4.95273545e-02f, 8.80006701e-02f, 1.27453491e-01f, 8.32047760e-02f, -1.87662646e-01f, -1.37673482e-01f, -1.24408729e-01f, -4.90386605e-01f, -2.20569193e-01f, 6.46454021e-02f,
  6.12924732e-02f, -1.41250476e-01f, 3.23072195e-01f, 3.48997712e-02f, 1.07126897e-02f, 1.02563471e-01f, -2.17209995e-01f, -1.61656842e-01f, -3.55387837e-01f, -1.92738310e-01f,
  -2.44613066e-01f, 6.13488480e-02f, -2.65391290e-01f, 2.42114812e-01f, 3.58607024e-01f, -1.34232327e-01f, -3.47561598e-01f, 7.88072944e-02f, -1.30196556e-01f, -2.83724964e-01f,
  -4.11749542e-01f, -1.85356706e-01f, -2.33967632e-01f, -2.79791296e-01f, 1.12041235e-02f, -1.27019535e-03f, 6.82681441e-01f, -8.58229026e-02f, -4.42945182e-01f, -2.37023473e-01f,
  -4.13336791e-02f, 4.81994927e-01f, 1.10768989e-01f, 4.68500048e-01f, -1.83380947e-01f, 7.27610216e-02f, -2.05029503e-01f, -4.87067625e-02f, -1.13222294e-01f, 4.42079790e-02f,
  3.27805102e-01f, -4.22253320e-03f, 1.45761356e-01f, -4.29253206e-02f, 1.11490868e-01f, -8.97547416e-03f, 8.19979236e-03f, 3.27006839e-02f, 3.40554953e-01f, 2.29911074e-01f,
  -1.02104314e-01f, 2.77570784e-01f, -5.81064187e-02f, 1.23444855e-01f, 2.06802949e-01f, 2.94885188e-01f, -2.29666263e-01f, -2.25668356e-01f, 5.49281836e-02f, 1.59835875e-01f,
  -1.18980929e-01f, -9.35481023e-03f, 1.70137491e-02f, -3.98515344e-01f, 2.76747584e-01f, 1.70097798e-01f, -5.48869744e-02f, -2.21555844e-01f, -8.77423137e-02f, -1.17364712e-01f,
  9.52841043e-02f, 1.62377477e-01f, 9.77217406e-02f, 2.39477172e-01f, -3.06400388e-01f, -2.19352812e-01f, 2.89461017e-01f, -3.17167193e-01f, 1.68530926e-01f, -1.55499741e-01f,
  -4.31527317e-01f, 4.94093969e-02f, -2.61963248e-01f, 2.30368242e-01f, -9.87488851e-02f, 1.43203616e-01f, -1.37553170e-01f, 2.25194782e-01f, 1.50607467e-01f, -5.04874960e-02f,
  2.61618167e-01f, -1.30030528e-01f, -1.48875222e-01f, -2.33272538e-01f, -3.45763154e-02f, 2.95392126e-01f, 3.29411119e-01f, -2.02591732e-01f, 6.97381720e-02f, -5.27605377e-02f,
  -4.15727962e-03f, -9.71630029e-03f, -6.01261556e-02f, -1.00565694e-01f, -4.64055747e-01f, -2.28452116e-01f, -3.44423860e-01f, 1.19298279e-01f, 2.02026844e-01f, 1.30957156e-01f,
  3.70162010e-01f, 2.65418589e-02f, -2.07669780e-01f, -2.76891798e-01f, -4.98703182e-01f, 4.49980833e-02f, -3.78753662e-01f, 3.40900630e-01f, -1.50504619e-01f, 7.28457496e-02f,
  1.64273083e-01f, 1.43007666e-01f, 4.61469054e-01f, -2.15192363e-01f, -2.86880806e-02f, 3.30106676e-01f, -3.73123795e-01f, -2.02644393e-01f, 1.78919598e-01f, 5.10567069e-01f,
  -4.77069505e-02f, 1.94575742e-01f, -3.26382458e-01f, -8.55005160e-02f, -9.69504938e-03f, 2.98188049e-02f, 2.70942569e-01f, 5.64499348e-02f, -9.62203965e-02f, -1.66022971e-01f,
  2.07524031e-01f, -4.31695767e-02f, 1.31671667e-01f, 5.62684089e-02f, 6.63343728e-01f, 1.41916886e-01f, 2.40545824e-01f, 1.59185424e-01f, 4.23123449e-01f, 1.16374455e-02f,
  -6.27420330e-03f, 2.08360970e-01f, -1.28990814e-01f, 3.36569339e-01f, -5.90714574e-01f, 1.90513328e-01f, 2.43897110e-01f, -8.35290328e-02f, 2.73906499e-01f, 2.57144988e-01f,
  -2.36479104e-01f, -3.47027540e-01f, 2.37252060e-02f, 4.68931459e-02f, 1.02165222e-01f, -1.23160802e-01f, -4.13231254e-02f, 4.89680171e-02f, 1.23672627e-01f, -2.64791138e-02f,
  1.82520077e-02f, -5.07633314e-02f, -2.41518229e-01f, 1.71695590e-01f, -2.18673915e-01f, -4.16665673e-02f, -3.31736863e-01f, 1.12857826e-01f, -4.80796754e-01f, -6.50791675e-02f,
  -7.16772527e-02f, -3.56372535e-01f, -1.26701415e-01f, -2.33051777e-01f, -1.75297130e-02f, -1.93077117e-01f, 2.48680428e-01f, 2.10379705e-01f, 5.24624065e-02f, 1.60390258e-01f,
  -2.16746956e-01f, -1.73428223e-01f, 2.79934853e-02f, 5.25150836e-01f, -3.24202985e-01f, 1.74900442e-01f, -4.14491713e-01f, 1.49072379e-01f, 1.31108552e-01f, 1.18857704e-01f,
  1.31168261e-01f, -1.28984526e-01f, 9.65920836e-02f, -1.65779755e-01f, 1.20725185e-01f, -3.34016606e-02f, 1.47775009e-01f, 2.56630599e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -3.81361008e-01f, -7.73140669e-01f, -6.66157678e-02f, -1.75224766e-01f, -5.46335220e-01f, 2.55943369e-02f, 3.18368018e-01f, -8.61269161e-02f, 2.19677433e-01f, -1.77718103e-01f,
  3.68887872e-01f, -1.35683224e-01f, -1.67489443e-02f, 5.59385829e-02f, 1.07870661e-01f, -3.03291287e-02f, 2.90246308e-01f, 4.56080645e-01f, 1.53701797e-01f, 2.34701950e-02f,
  -4.54202443e-01f, 1.59862548e-01f, -5.24093546e-02f, 2.59435862e-01f, 1.87745877e-02f, -6.21242970e-02f, -3.61241817e-01f, 1.79731712e-01f, -9.68673050e-01f, 1.74714267e-01f,
  4.89734828e-01f, 1.63262755e-01f, 8.51460248e-02f, 1.06139638e-01f, -3.02782118e-01f, -5.86458445e-01f, -4.87816751e-01f, -8.81692708e-01f, 2.79526025e-01f, 1.65334255e-01f,
  -2.95372039e-01f, -2.83990473e-01f, 4.31967616e-01f, 5.43936789e-01f, 2.00813875e-01f, 6.61183476e-01f, 1.32251382e-01f, -2.83242613e-01f, -1.70668766e-01f, -4.14319903e-01f,
  1.32725254e-01f, -1.74653575e-01f, 1.21924371e-01f, 3.49524349e-01f, -4.06321650e-03f, 6.25669897e-01f, -5.41885614e-01f, 8.38259876e-01f, -3.99073631e-01f, -9.42080766e-02f,
  4.50465173e-01f, 2.36462176e-01f, 2.13952689e-03f, 8.01349342e-01f, 1.33306056e-01f, 1.71742618e-01f, 1.37087256e-01f, -2.54504174e-01f, -1.15977123e-01f, -1.14999346e-01f,
  -1.05622746e-01f, -1.64071340e-02f, 6.06246479e-02f, -1.98926702e-01f, -1.96377128e-01f, 8.56658444e-02f, -3.70643973e-01f, 3.46702546e-01f, -2.44670644e-01f, 1.54258206e-01f,
  1.43374142e-03f, 5.61154187e-01f, 4.06359844e-02f, -1.37823507e-01f, -4.43104744e-01f, 9.42712128e-02f, 3.39935452e-01f, 3.75066549e-01f, -1.06179260e-01f, -3.15938652e-01f,
  4.64879394e-01f, 2.52170414e-01f, -2.22542346e-01f, -6.54093027e-02f, -6.33610785e-02f, 2.69227117e-01f, -7.61300206e-01f, -2.60976225e-01f, -1.04806162e-02f, -4.02593166e-01f,
  2.12215438e-01f, -4.89806861e-01f, -3.20622101e-02f, 1.06773367e-02f, -3.36574078e-01f, 1.32998019e-01f, -4.79228934e-03f, -4.86869842e-01f, -2.54439503e-01f, -4.70079303e-01f,
  -1.65182129e-01f, 9.25667942e-01f, 3.19571227e-01f, -4.29799594e-02f, -9.08487290e-02f, 4.08249140e-01f, -3.94130796e-01f, -1.28754497e-01f, -2.18860686e-01f, 4.39566731e-01f,
  9.09488380e-01f, 8.12933370e-02f, -1.15462951e-01f, 1.61865413e-01f, -6.28122222e-03f, 4.96591091e-01f, 5.74676972e-03f, 2.43756473e-01f, 1.95331022e-01f, 6.96885511e-02f,
  1.33354897e-02f, -1.17904343e-01f, 3.93413335e-01f, 7.41167545e-01f, 5.55957913e-01f, -1.13264164e-02f, 2.15875834e-01f, 3.32543969e-01f, -4.14938748e-01f, -6.48675919e-01f,
  3.54364485e-01f, -6.30312935e-02f, 5.89143895e-02f, -9.14969981e-01f, -8.65223348e-01f, -5.57640254e-01f, 4.01113957e-01f, -2.70840794e-01f, 8.62947762e-01f, 7.25850701e-01f,
  -4.85958159e-02f, -2.39170060e-01f, -3.81470054e-01f, -2.49840066e-01f, 3.29008460e-01f, 4.36077625e-01f, -2.59898186e-01f, -5.81000634e-02f, 1.67278409e-01f, 1.51018485e-01f,
  4.34136033e-01f, 2.83435702e-01f, 3.58811557e-01f, 1.30885944e-01f, 6.02557540e-01f, 3.29103053e-01f, 3.96280348e-01f, 1.47006691e-01f, 2.91234106e-01f, 2.15035096e-01f,
  3.47841740e-01f, 5.42832315e-02f, -2.57674068e-01f, 1.48234982e-03f, -8.50769207e-02f, 3.02387327e-01f, 5.38134634e-01f, 4.02397960e-01f, 6.66224957e-01f, 9.87762660e-02f,
  9.53679755e-02f, -2.35653579e-01f, -3.79046082e-01f, 1.38918087e-01f, 4.06321585e-01f, -1.76427234e-02f, 5.38238823e-01f, 1.36004314e-01f, -2.68017083e-01f, 1.39185071e-01f,
  -1.16536528e-01f, -3.93278778e-01f, 1.57708809e-01f, 1.13905065e-01f, -2.69504309e-01f, 4.02066201e-01f, 2.01112792e-01f, 8.28050554e-01f, -4.02529836e-01f, 1.96228504e-01f,
  2.97116369e-01f, -3.78338657e-02f, 6.45175874e-01f, 1.99590102e-01f, -8.63411874e-02f, 2.93722868e-01f, -5.69156528e-01f, 4.41432260e-02f, 6.01014376e-01f, 5.19369781e-01f,
  2.40549922e-01f, -3.78446043e-01f, 1.24925561e-01f, -5.78375272e-02f, -4.03962076e-01f, 5.47347367e-02f, 5.07842183e-01f, -7.06207007e-02f, 2.58356243e-01f, -1.69630408e-01f,
  -1.50043562e-01f, 1.62009552e-01f, 1.86618075e-01f, 9.14523602e-02f, -4.22225058e-01f, 3.22505742e-01f, -4.42485631e-01f, 2.44054161e-02f, 9.55647454e-02f, 8.46217647e-02f,
  7.23738894e-02f, 1.17172644e-01f, 5.20669460e-01f, 4.33925800e-02f, 6.30616426e-01f, -6.78272769e-02f, -2.47993618e-02f, -6.51172757e-01f, -6.36081100e-01f, -3.41903269e-01f,
  8.44809487e-02f, 3.05528224e-01f, 2.34236330e-01f, -5.19598648e-02f, 1.89741060e-01f, 3.04030657e-01f, 2.46648073e-01f, -3.79175574e-01f, -5.85263550e-01f, -7.20152259e-01f,
  2.68425375e-01f, 1.60571888e-01f, -1.59839138e-01f, -2.58997500e-01f, 5.83132267e-01f, 2.96221405e-01f, 1.52836777e-02f, -2.27827206e-02f, 9.98688221e-01f, -3.00205231e-01f,
  -3.56471717e-01f, -3.30138713e-01f, -5.40114999e-01f, -2.62545764e-01f, 5.12356795e-02f, 4.49063212e-01f, 3.47505450e-01f, -6.08404763e-02f, -6.05736859e-02f, -7.46800676e-02f,
  8.37875724e-01f, 4.86445814e-01f, 2.10084230e-01f, -6.91817999e-01f, 8.27557668e-02f, -2.01498747e-01f, 3.03635001e-01f, -1.89619809e-02f, -1.34597301e-01f, 2.10910022e-01f,
  -1.58894733e-01f, 7.69898444e-02f, -3.67361367e-01f, 2.04615846e-01f, -6.32140934e-01f, 4.63717103e-01f, -1.75911233e-01f, 2.37346381e-01f, -3.78223918e-02f, 1.91998616e-01f,
  -4.16813165e-01f, 8.60710919e-01f, 1.65580407e-01f, 8.78049791e-01f, -7.75207996e-01f, -4.14117098e-01f, 8.83688450e-01f, 1.62355155e-01f, 8.09838355e-01f, 2.69253969e-01f,
  -2.52249420e-01f, 4.14429277e-01f, -2.93030739e-01f, 2.69129574e-01f, 6.67863488e-01f, 1.44351527e-01f, 1.54618770e-01f, -5.68227947e-01f, -3.48893017e-01f, 9.10203159e-02f,
  -2.45637313e-01f, 2.85393596e-01f, 6.91370666e-01f, 1.02814607e-01f, -3.27322960e-01f, -1.82153866e-01f, -1.27452821e-01f, 4.04338717e-01f, 1.96081638e-01f, -1.69116288e-01f,
  3.04538459e-01f, 2.29951113e-01f, 1.74125522e-01f, 2.25704312e-01f, -4.23929989e-02f, 2.85371274e-01f, -3.81055325e-01f, 1.59399174e-02f, 2.76585639e-01f, 2.22469747e-01f,
  2.78677493e-01f, 1.85190335e-01f, -3.58375251e-01f, -4.21485335e-01f, -4.31349762e-02f, 5.93586564e-01f, 7.06383824e-01f, 3.22232842e-01f, 2.79351711e-01f, 2.65506506e-01f,
  -5.98789811e-01f, -1.29501835e-01f, 1.54629052e-01f, 3.01841497e-01f, 6.28200948e-01f, 2.19938099e-01f, 3.27127159e-01f, -6.96960315e-02f, 1.14953361e-01f, 3.37858975e-01f,
  1.45276636e-01f, -9.62746069e-02f, -6.85715616e-01f, -2.38398269e-01f, -4.36365724e-01f, 2.87076971e-03f, 1.62736371e-01f, 2.83072460e-02f, 2.69849241e-01f, 1.91723064e-01f,
  2.74911940e-01f, -1.57318823e-03f, 3.18498671e-01f, -2.05291703e-01f, 1.61829829e-01f, -2.75136739e-01f, -1.80091351e-01f, -3.66878361e-02f, 4.92579825e-02f, 2.42364451e-01f,
  1.02985218e-01f, -1.92565128e-01f, 2.24449813e-01f, 2.90554434e-01f, 1.62558436e-01f, -2.70493090e-01f, -3.90729755e-01f, -3.52738857e-01f, -2.30442211e-01f, 9.52629149e-02f,
  8.61937832e-03f, 4.75426726e-02f, 4.75686669e-01f, 2.11708382e-01f, 1.79589778e-01f, -4.56967466e-02f, -6.55094394e-03f, 2.72317648e-01f, -4.14720140e-02f, 2.43464440e-01f,
  1.44961998e-01f, 1.75616182e-02f, 2.29102612e-01f, -3.44623685e-01f, 1.05208123e+00f, -2.49452125e-02f, 3.51329669e-02f, 9.39365923e-02f, 5.62684983e-02f, -4.04457480e-01f,
  -2.99412370e-01f, -1.59678832e-01f, -3.72069031e-01f, -6.39009625e-02f, 2.44552612e-01f, -3.36093247e-01f, 3.21328908e-01f, 1.38844505e-01f, 6.72090650e-01f, 2.65547246e-01f,
  -9.19385135e-01f, -1.19454361e-01f, 1.29663110e+00f, -8.27867463e-02f, 1.24173388e-02f, 1.07159570e-01f, -3.96863371e-01f, -9.28052008e-01f, -1.44279510e-01f, -5.88803411e-01f,
  -3.98490071e-01f, 1.64459981e-02f, 1.38760552e-01f, -5.29602729e-02f, -3.34514141e-01f, -6.17141537e-02f, -1.42351136e-01f, -2.97631413e-01f, -3.35637510e-01f, -7.71572888e-02f,
  3.74091119e-01f, -4.99110483e-02f, 4.56967875e-02f, 3.26520741e-01f, 1.92520201e-01f, 6.08001828e-01f, -2.20323533e-01f, 5.65010915e-03f, -7.58722574e-02f, 1.82559624e-01f,
  8.30309510e-01f, -7.57447556e-02f, 2.98600197e-01f, 2.85129458e-01f, 4.07609731e-01f, 9.27385688e-02f, -1.72612011e-01f, -1.79524720e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -3.38630497e-01f, 1.26939222e-01f, 1.53357551e-01f, 1.19044915e-01f, 3.64347219e-01f, 1.97963357e-01f, 2.32716843e-01f, -2.12216139e-01f, 1.40028000e-01f, 1.53671391e-02f,
  2.72696406e-01f, -3.79438773e-02f, -1.46191576e-02f, -4.55498174e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -9.05024633e-02f, -4.34977025e-01f, -1.07355691e-01f, -3.14821780e-01f, -6.84413612e-01f, -1.43506259e-01f, -1.58863857e-01f, -1.95437446e-02f, -4.33203220e-01f, 2.21466739e-02f,
  -2.81101137e-01f, -4.37177680e-02f, 8.41222644e-01f, 2.57093251e-01f, -3.11670899e-01f, 3.82649481e-01f, -2.66242713e-01f, -3.79806906e-02f, -4.41603959e-01f, 1.34880155e-01f,
  1.73568130e-01f, 3.14362288e-01f, -6.15283310e-01f, -6.24335170e-01f, -2.50552773e-01f, -1.37687072e-01f, -8.46556365e-01f, -3.47822726e-01f, 1.36884600e-01f, -1.26656681e-01f,
  2.33185440e-01f, -2.10991830e-01f, 6.72918409e-02f, 2.14221984e-01f, -1.53211281e-02f, 1.48046002e-01f, 4.58485126e-01f, -3.53934616e-01f, 3.75135273e-01f, -3.90989363e-01f,
  -5.97442053e-02f, 3.64493608e-01f, -1.83531176e-02f, -1.98763385e-01f, 7.92259634e-01f, -6.73825890e-02f, 8.46425910e-03f, 7.95834422e-01f, -3.01161945e-01f, 8.45647037e-01f,
  3.43047053e-01f, -1.66886777e-01f, 3.91462475e-01f, 4.32722420e-02f, -4.02724177e-01f, -8.37499723e-02f, 7.14206919e-02f, 2.12806109e-02f, 9.22031477e-02f, 3.46791625e-01f,
  7.55698606e-02f, 4.42803465e-02f, -2.23718747e-01f, -2.77046293e-01f, 5.16491354e-01f, -2.49330506e-01f, 1.76695228e-01f, -2.60372937e-01f, -2.03760371e-01f, -6.18147068e-02f,
  -3.06855440e-01f, 2.16418728e-01f, 2.09613338e-01f, -1.61462337e-01f, -5.71767151e-01f, -9.34186697e-01f, -3.12764019e-01f, -3.87318432e-01f, -4.11294818e-01f, 2.69579679e-01f,
  1.61469117e-01f, -4.17399377e-01f, -6.88967556e-02f, 3.00141752e-01f, 6.57870714e-03f, -3.46248835e-01f, -6.18834905e-02f, -1.22556758e+00f, -3.00000727e-01f, -5.43097317e-01f,
  1.21324003e-01f, -1.13015807e+00f, -6.79849923e-01f, -3.30678552e-01f, -1.56604087e+00f, 2.12942302e-01f, -4.34575789e-02f, -2.55595922e-01f, 2.07319006e-01f, -2.26578265e-02f,
  -2.49666378e-01f, 4.37178463e-01f, 1.61072969e-01f, 4.61479366e-01f, 4.72967476e-01f, -5.25487483e-01f, 5.41014254e-01f, -4.48268443e-01f, -2.73511916e-01f, 4.36484903e-01f,
  -1.41377732e-01f, 8.98461640e-01f, -5.19406684e-02f, 2.95641333e-01f, -4.48442519e-01f, 4.57442962e-02f, -7.31287062e-01f, -8.26068699e-01f, -5.11699557e-01f, -3.13207358e-02f,
  5.96862257e-01f, -3.85240078e-01f, -7.94738889e-01f, 6.77772760e-01f, 2.29345247e-01f, -5.39276302e-01f, 2.10992526e-02f, -3.56620014e-01f, 2.08083406e-01f, 7.42504776e-01f,
  -5.35650313e-01f, -4.83518280e-02f, 3.35865855e-01f, -1.43627927e-01f, 4.18937206e-01f, 3.12590241e-01f, 4.27072912e-01f, -1.74015552e-01f, 9.34994698e-01f, 1.18573993e-01f,
  -2.78167546e-01f, 5.61982214e-01f, -2.84263134e-01f, -7.85427749e-01f, 6.48401022e-01f, 1.36232778e-01f, 1.83467984e-01f, 2.37267464e-01f, -9.70370770e-02f, -4.04238760e-01f,
  -2.09311783e-01f, -2.76682615e-01f, -5.53210258e-01f, -5.14218286e-02f, -1.56981185e-01f, -8.50341797e-01f, -1.77228719e-01f, 1.05463326e-01f, 2.62060434e-01f, -5.97112775e-01f,
  -5.67004144e-01f, -2.57292420e-01f, 5.72186410e-01f, 4.79466230e-01f, 4.33004558e-01f, 3.46865773e-01f, -2.28194460e-01f, -5.51421523e-01f, -2.83394963e-01f, 1.56239882e-01f,
  2.51134753e-01f, -9.67352390e-02f, -7.46718705e-01f, -5.01044631e-01f, -1.21995963e-01f, -7.06375539e-01f, 7.27015957e-02f, -6.90555751e-01f, -2.50725359e-01f, 1.38169527e-01f,
  -4.45321530e-01f, 2.24052265e-01f, -4.55205172e-01f, -1.57032721e-02f, -2.60031402e-01f, -1.73489824e-01f, 2.90787816e-01f, -2.93327212e-01f, 1.01037621e-01f, 2.43352354e-02f,
  -8.91144514e-01f, -5.42784750e-01f, -2.99258381e-01f, -1.96643189e-01f, -1.91057503e-01f, -2.04712480e-01f, -2.36763477e-01f, 2.49526128e-01f, -1.48658141e-01f, 7.08029866e-01f,
  -6.76284313e-01f, 4.60366577e-01f, -2.77175963e-01f, 1.19374275e-01f, -5.58799468e-02f, -3.92098039e-01f, 7.06021667e-01f, -6.68000698e-01f, 8.45664442e-02f, -2.09498331e-01f,
  -8.02558064e-01f, -8.73837471e-01f, 9.34154242e-02f, -2.98474640e-01f, 3.04985195e-01f, -1.14893787e-01f, 6.52196407e-02f, 5.40295184e-01f, -7.25840449e-01f, -7.71052003e-01f,
  -4.76011515e-01f, 2.61583239e-01f, 1.78829536e-01f, -1.56839833e-01f, -2.72649407e-01f, 2.06605956e-01f, -2.09022030e-01f, -1.06658116e-01f, -2.74625301e-01f, -7.05242395e-01f,
  -7.05372691e-02f, -2.29710579e-01f, 4.99553800e-01f, -1.20477751e-01f, -4.38290052e-02f, -2.07277089e-01f, -3.98850411e-01f, 4.34451938e-01f, -1.13824189e-01f, 9.65139735e-03f,
  -5.30868351e-01f, -2.99462881e-02f, 2.56307214e-01f, -9.88257751e-02f, -4.07272220e-01f, -1.20017417e-01f, 2.59971488e-02f, -7.08493352e-01f, 1.08976156e-01f, 2.27055922e-01f,
  -6.98871687e-02f, -6.44043028e-01f, -5.54649353e-01f, 3.98803771e-01f, -8.45375359e-01f, -3.86616260e-01f, -1.66510388e-01f, 4.36103106e-01f, -9.20412913e-02f, -2.50824839e-01f,
  -2.87604421e-01f, -1.83156937e-01f, 3.85263450e-02f, -1.86361652e-02f, 4.72980917e-01f, 6.55699819e-02f, -3.29154849e-01f, 4.60014731e-01f, 7.68287256e-02f, 1.69612125e-01f,
  3.50715846e-01f, 1.67639032e-02f, -1.90146014e-01f, -1.75250098e-01f, 1.36048093e-01f, -5.69306076e-01f, -3.41405839e-01f, 3.05879861e-01f, -2.07469851e-01f, 3.02556902e-01f,
  -1.82271749e-01f, -2.28081346e-01f, 7.72999674e-02f, -9.40143287e-01f, 1.49974108e-01f, -2.35970542e-01f, -6.89691365e-01f, 6.29480720e-01f, 3.16323549e-01f, -4.19090614e-02f,
  6.87520564e-01f, 8.96213651e-02f, 7.35362759e-03f, 5.37156165e-01f, -4.05443758e-01f, -6.41436517e-01f, -3.13071907e-01f, 5.96687198e-01f, -6.01306260e-01f, 7.33235121e-01f,
  9.69469249e-01f, -3.67640704e-01f, -3.84157151e-01f, 6.88157439e-01f, 2.85483822e-02f, 8.29315305e-01f, -1.42830521e-01f, -2.61592209e-01f, -7.80668557e-01f, -7.53962219e-01f,
  4.21408176e-01f, 6.92423386e-03f, -2.57291030e-02f, -3.77335817e-01f, 8.22361410e-02f, -6.04773998e-01f, -6.50793791e-01f, -1.89488530e-01f, -6.63920462e-01f, -3.13528270e-01f,
  2.68627644e-01f, -6.06449842e-01f, -4.76784855e-01f, 3.72526884e-01f, -5.26193619e-01f, -1.55929431e-01f, 2.75118291e-01f, -2.06423014e-01f, -3.89707565e-01f, -5.96802771e-01f,
  2.97640711e-01f, 3.59463602e-01f, 1.39294550e-01f, -1.98096812e-01f, 6.78107977e-01f, -4.16776389e-01f, 2.30473787e-01f, -2.64719009e-01f, -1.04814982e+00f, -1.08320642e+00f,
  -6.70073509e-01f, 4.24323343e-02f, -4.70095903e-01f, 2.41953537e-01f, 4.05113518e-01f, -7.24673867e-01f, 3.87668103e-01f, 5.97927868e-01f, 3.33212584e-01f, -7.15396225e-01f,
  -8.22652936e-01f, -4.98552024e-01f, 4.66962695e-01f, 6.43388808e-01f, 3.52607369e-02f, 1.26524959e-02f, 7.34932661e-01f, -8.66450428e-04f, 3.65058988e-01f, 2.99492538e-01f,
  -9.30432528e-02f, -2.89154232e-01f, -3.27226818e-02f, 6.20959818e-01f, -3.73674601e-01f, 7.47202560e-02f, -3.44638169e-01f, -9.60228294e-02f, 3.05510342e-01f, -5.93580782e-01f,
  -3.80594015e-01f, -1.00551295e+00f, 5.56386672e-02f, -5.85430205e-01f, -1.12187512e-01f, 6.54816449e-01f, 6.36119306e-01f, -1.12054981e-01f, -8.33143473e-01f, -4.14589345e-01f,
  3.19443047e-01f, -4.09659594e-01f, -1.10322905e+00f, -3.97604138e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.10046917e-01f, -2.23958820e-01f, 1.29861459e-01f, 6.43807929e-03f, 2.32536748e-01f, 3.51714730e-01f, 1.26618609e-01f, -3.22723478e-01f, -1.33486614e-01f, 3.20313096e-01f,
  -1.05322458e-01f, 1.49005502e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    