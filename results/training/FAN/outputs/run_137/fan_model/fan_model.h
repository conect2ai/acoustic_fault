/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.84879392e-01f, -3.16025764e-02f, 2.84479856e-01f, -7.90076628e-02f, 1.27888247e-02f, 1.14027575e-01f, 1.44761354e-01f, 2.56357975e-02f, 2.03148738e-01f, -3.36135291e-02f,
  -6.01039343e-02f, 1.12476610e-01f, 2.25328863e-01f, -1.75635323e-01f, 9.88045782e-02f, 6.39275685e-02f, 6.74716139e-04f, -4.89739403e-02f, 8.30444545e-02f, 6.50909618e-02f,
  1.29349204e-02f, -2.89744318e-01f, -9.54633877e-02f, -2.70383537e-01f, 6.80411817e-04f, 3.55619453e-02f, -2.35648125e-01f, 2.01141350e-02f, -2.33002394e-01f, -1.34427577e-01f,
  8.45529214e-02f, 3.46023440e-02f, -2.46620569e-02f, 6.32370189e-02f, 1.08376965e-01f, 5.30188680e-02f, 6.59499615e-02f, -5.47473244e-02f, 7.86832720e-02f, 8.43478441e-02f,
  6.47904947e-02f, 9.37828869e-02f, -1.39506355e-01f, 9.10583045e-03f, -3.39836180e-02f, 6.00856394e-02f, -2.23791357e-02f, -4.56768163e-02f, -8.13355148e-02f, 5.86522967e-02f,
  1.06580779e-01f, 4.56955731e-02f, 4.71023377e-03f, -1.46954674e-02f, 9.25193503e-02f, 6.67735487e-02f, 4.76061255e-02f, 3.09279431e-02f, 8.76191258e-03f, -2.95241624e-02f,
  3.57373618e-02f, -3.20394076e-02f, 3.79250124e-02f, -3.58399376e-02f, 3.71129550e-02f, 6.38012141e-02f, -1.12883382e-01f, -5.91631569e-02f, 4.41539381e-03f, 3.14911269e-02f,
  3.06126513e-02f, 1.75208934e-02f, -2.22453754e-02f, 2.24967711e-02f, -3.94121036e-02f, -7.70534053e-02f, 8.27211738e-02f, -7.61327818e-02f, -2.49625687e-02f, -9.70747173e-02f,
  2.81491522e-02f, 2.22191215e-02f, -1.20109893e-01f, -4.11195941e-02f, 1.82476528e-02f, -5.25581576e-02f, 8.76894593e-02f, 1.56767704e-02f, 9.02943611e-02f, -1.06619457e-02f,
  -1.58747718e-01f, -1.61963657e-01f, 1.08387563e-02f, 1.59800723e-02f, -4.44802083e-02f, -5.63153103e-02f, 5.08702174e-03f, -3.22296657e-02f, 1.40887983e-02f, -3.03511545e-02f,
  -7.42293000e-02f, 1.78752211e-03f, 7.05054849e-02f, -1.00148976e-01f, -6.20820820e-02f, 7.82543644e-02f, 4.68509831e-02f, -5.93420342e-02f, -9.50480700e-02f, -7.16353953e-02f,
  -9.64870527e-02f, -4.58919443e-02f, 3.87484953e-02f, 6.69143945e-02f, -6.50074407e-02f, -2.94945445e-02f, -1.02513283e-02f, 1.15399197e-01f, -4.55096224e-03f, -5.41250966e-02f,
  -2.48560175e-01f, 5.52602373e-02f, -1.26842543e-01f, -2.81663656e-01f, -2.07351297e-01f, 1.58602089e-01f, 1.26389980e-01f, -1.44028202e-01f, -1.49157077e-01f, -5.50395157e-03f,
  1.19160779e-01f, -9.01050195e-02f, 2.90036798e-01f, -1.22217424e-01f, 1.57046139e-01f, 2.14927390e-01f, -3.60200554e-02f, -1.18273146e-01f, 2.76163295e-02f, -1.82379454e-01f,
  -1.38940617e-01f, -1.01724513e-01f, -3.94984111e-02f, -8.64988863e-02f, -7.96272978e-02f, -1.04890160e-01f, 1.54806208e-02f, 9.79585871e-02f, -1.73227102e-01f, 4.76781353e-02f,
  3.49862725e-02f, 6.77100047e-02f, -2.59805601e-02f, 4.80588414e-02f, -7.69905448e-02f, 2.20922548e-02f, 3.23880278e-02f, 8.55186805e-02f, -1.39771309e-02f, -2.95650326e-02f,
  1.97111219e-02f, -2.81878170e-02f, -5.90498112e-02f, 2.39499360e-02f, 6.60783276e-02f, -4.70473804e-02f, 3.24472860e-02f, -2.20220871e-02f, -1.06432904e-02f, -8.76132548e-02f,
  -6.39191121e-02f, -9.23301429e-02f, -2.12912783e-02f, -8.23554695e-02f, 1.15857478e-02f, 7.88004026e-02f, -4.36839461e-02f, 2.16799732e-02f, -9.29247495e-03f, -2.51961332e-02f,
  6.07335707e-03f, -2.95937601e-02f, -5.96666941e-03f, -7.29592741e-02f, 5.08825518e-02f, -4.19739932e-02f, -1.59348566e-02f, -3.01131457e-02f, 1.13421679e-02f, -3.25871725e-03f,
  -9.25437640e-03f, 2.99026482e-02f, 2.39111986e-02f, -1.28639519e-01f, -4.02956046e-02f, -5.29357307e-02f, -5.68041466e-02f, -3.59859765e-02f, 1.47481589e-02f, -2.92234030e-02f,
  -6.81794211e-02f, 2.21957620e-02f, -7.29542524e-02f, -5.77484965e-02f, 1.41808176e-02f, -2.37169079e-02f, -2.93796901e-02f, -1.08746618e-01f, 1.87870357e-02f, 6.22207746e-02f,
  1.02813758e-01f, -2.42071450e-02f, 3.81117165e-02f, -2.73601431e-02f, -3.70334089e-02f, -2.58968528e-02f, -2.66156159e-03f, -8.14368725e-02f, 1.86656862e-01f, 3.97643149e-02f,
  -8.67049322e-02f, -1.03912935e-01f, 1.01964302e-01f, -1.72565375e-02f, 3.55339237e-02f, 3.62234302e-02f, -3.71990502e-02f, 5.55973835e-02f, -5.67726679e-02f, 5.48353344e-02f,
  -1.55913290e-02f, 3.62371095e-02f, 5.70149682e-02f, -5.91894165e-02f, -4.71108407e-02f, 2.06220113e-02f, -3.80983017e-02f, 3.60787734e-02f, -3.56504833e-03f, -3.92463133e-02f,
  -4.09781069e-01f, 1.66694224e-01f, 1.42660644e-02f, 1.70456581e-02f, -2.43876968e-02f, 3.52659449e-02f, -1.72836393e-01f, 8.68568495e-02f, -1.17063165e-01f, 6.44474849e-02f,
  6.16822913e-02f, -1.81910396e-01f, -1.30763138e-02f, 6.86539784e-02f, -2.09394336e-01f, -2.18381938e-02f, -4.01166035e-03f, -2.20481232e-02f, -3.71587314e-02f, -1.16255097e-02f,
  -9.99840125e-02f, 1.20362468e-01f, 8.78976658e-02f, 2.21741363e-01f, 4.35700901e-02f, -4.30413493e-04f, 1.48823529e-01f, -1.91314088e-04f, 1.76728308e-01f, -4.22879085e-02f,
  1.78663079e-02f, -5.75013347e-02f, -3.38855833e-02f, -2.55809468e-03f, 4.66047712e-02f, 7.67012835e-02f, -2.73594409e-02f, 1.66950524e-02f, -6.60682991e-02f, -7.37342564e-03f,
  -3.81639712e-02f, 3.58867762e-03f, -4.64072600e-02f, -2.08554952e-03f, -4.62938985e-03f, 1.53567521e-02f, -4.37991619e-02f, 5.11936732e-02f, 3.55213135e-02f, -4.22350913e-02f,
  7.16281086e-02f, 7.14184046e-02f, 1.23681009e-01f, 2.55750194e-02f, 5.52939363e-02f, -1.39680458e-02f, 8.33607614e-02f, -4.79179733e-02f, -5.44660678e-03f, 3.80203053e-02f,
  -6.80595413e-02f, -1.98025443e-02f, -1.44861257e-02f, 3.95066366e-02f, 6.50469065e-02f, 5.98076656e-02f, -2.03437209e-02f, 4.13661211e-04f, 1.83049927e-03f, 3.86917815e-02f,
  -6.81335703e-02f, 9.38151032e-03f, 3.83172259e-02f, -6.00077584e-02f, 2.49983892e-02f, -3.18152867e-02f, -2.14942284e-02f, -6.75961236e-03f, -2.48676958e-03f, -1.78332590e-02f,
  -4.83060442e-02f, -2.55590118e-02f, 9.69187766e-02f, -1.79815274e-02f, 5.99958971e-02f, -1.00432225e-02f, 1.18460752e-01f, -4.66742180e-02f, 1.75212417e-02f, -2.14795163e-03f,
  2.03860924e-02f, 1.51158810e-01f, -9.28573683e-02f, 4.47822101e-02f, -4.30689231e-02f, 5.86207733e-02f, -6.92621022e-02f, -6.92563653e-02f, 7.79802799e-02f, 7.89431706e-02f,
  9.94250029e-02f, -5.81799448e-02f, 2.92051379e-02f, 5.56195863e-02f, -1.33574056e-02f, -8.10577720e-03f, 3.34150232e-02f, -3.92760523e-02f, 4.07692231e-02f, -2.16238946e-02f,
  -8.48535076e-03f, -1.28438836e-02f, -9.38513112e-05f, 4.74268571e-02f, 1.02735095e-01f, 5.01877181e-02f, -5.00273220e-02f, 3.16189975e-02f, 5.48193604e-02f, -6.60219789e-02f,
  2.91394472e-01f, -7.71606863e-02f, 1.27623901e-01f, 2.74508923e-01f, 6.91019297e-02f, -1.32406220e-01f, -7.12622851e-02f, -5.47598489e-02f, 1.09504782e-01f, -8.18412900e-02f,
  -1.55251652e-01f, 1.98695540e-01f, -1.89552382e-01f, 1.81018457e-01f, 9.91372764e-02f, -1.68018490e-01f, 1.79393083e-01f, 9.12839174e-02f, -4.40147705e-02f, 2.38243908e-01f,
  1.65228277e-01f, 2.63554184e-03f, 1.00055829e-01f, -1.58611998e-01f, 7.15459734e-02f, 3.56745794e-02f, 1.17933013e-01f, -9.44193006e-02f, 5.72250821e-02f, -1.54597983e-01f,
  -3.63205560e-02f, 4.89303805e-02f, 7.94265512e-03f, -4.65595312e-02f, -2.96337996e-02f, 6.86798170e-02f, 4.61413246e-03f, -1.35262027e-01f, 8.56612623e-02f, -7.32095391e-02f,
  1.16989389e-01f, -1.78540777e-02f, 9.40667540e-02f, -5.17246090e-02f, -3.21915792e-03f, 6.66844547e-02f, 4.72970419e-02f, 5.45273758e-02f, -1.56973712e-02f, -3.41568850e-02f,
  5.55289350e-02f, -2.86045913e-02f, 9.16715562e-02f, -3.91456852e-05f, 9.05975997e-02f, 4.01659049e-02f, -3.30688842e-02f, 8.08746666e-02f, 7.98517168e-02f, 3.12881954e-02f,
  -7.06305436e-04f, -1.86301433e-02f, -4.03598696e-02f, 3.05045792e-03f, -3.09475008e-02f, -4.40161079e-02f, -3.86510715e-02f, -2.94956453e-02f, 7.37148672e-02f, 1.99308340e-02f,
  -4.92681563e-02f, 2.65472066e-02f, -3.13104800e-04f, 2.04307381e-02f, 7.87972007e-03f, 4.88661975e-02f, 8.45653340e-02f, -9.32543948e-02f, 8.25708434e-02f, -2.74036098e-02f,
  -3.71085145e-02f, 3.71355340e-02f, -3.19672003e-02f, 1.63240936e-02f, -9.42311287e-02f, 4.54535559e-02f, -1.20808454e-02f, -6.45314297e-03f, -8.84601697e-02f, -1.37750506e-02f,
  5.63253686e-02f, 4.54714485e-02f, 4.23090234e-02f, -2.21624374e-04f, -2.06875894e-02f, 8.13279599e-02f, -3.68973203e-02f, 4.73175459e-02f, -3.26777771e-02f, -5.59546277e-02f,
  8.89767483e-02f, -7.97919277e-03f, -1.27369631e-02f, 7.64842005e-03f, 1.85815860e-02f, -1.45801632e-02f, 5.62923513e-02f, 2.40272172e-02f, 1.31640896e-01f, -4.04837914e-03f,
  2.90712044e-02f, 1.93662476e-02f, 3.84236537e-02f, 1.74754914e-02f, 2.89960131e-02f, 4.48839404e-02f, 7.11441562e-02f, 8.05205777e-02f, 3.01429089e-02f, 4.84034196e-02f,
  1.43762350e-01f, -6.39474392e-02f, 1.99675672e-02f, 9.63235125e-02f, 6.26628324e-02f, 1.79512411e-01f, 2.37408474e-01f, 2.64972970e-02f, 1.55433357e-01f, 9.38892290e-02f,
  1.50861487e-01f, -3.33328731e-02f, -8.95059258e-02f, 2.35035568e-01f, 2.27120161e-01f, 9.52893794e-02f, 1.47676721e-01f, 7.33344406e-02f, 1.29061922e-01f, -3.94173637e-02f,
  1.61885042e-02f, 1.97172061e-01f, -5.86693473e-02f, -1.07947811e-01f, 7.17742890e-02f, -1.06478401e-01f, -1.40365973e-01f, -1.38828456e-01f, 4.07549739e-02f, 8.21955428e-02f,
  2.61035729e-02f, -3.14098001e-02f, -1.39290132e-02f, -1.45938233e-01f, -1.35876268e-01f, -9.02480856e-02f, -6.88334405e-02f, 3.40179354e-02f, 4.85456437e-02f, 1.14631804e-03f,
  -2.17248760e-02f, 1.74874533e-02f, 9.50701013e-02f, -6.11488894e-02f, 3.02002523e-02f, 3.30638103e-02f, -4.90923636e-02f, 9.27780941e-02f, -2.98240110e-02f, 2.71950290e-02f,
  -6.31596372e-02f, 5.71350418e-02f, 6.06307574e-02f, 1.04471698e-01f, 3.44435982e-02f, 5.36239520e-02f, -1.36559993e-01f, -2.43303590e-02f, 8.90345424e-02f, 1.44308794e-03f,
  3.13999616e-02f, -7.75304064e-02f, 1.58889755e-03f, -9.73632559e-02f, -4.56037819e-02f, -2.36575417e-02f, 4.69262637e-02f, -1.04593029e-02f, 5.77819720e-02f, -2.18939893e-02f,
  1.80966243e-01f, 3.05079501e-02f, 1.09553464e-01f, -1.14489303e-04f, -3.89663987e-02f, 8.98310468e-02f, 3.10762059e-02f, 7.12625012e-02f, 4.41285223e-02f, -5.07329665e-02f,
  6.59165606e-02f, -1.50391636e-02f, 5.75401783e-02f, -1.14364661e-02f, -3.87523770e-02f, 9.08381268e-02f, 5.34084067e-02f, -1.71171520e-02f, -7.49789923e-02f, 1.42441206e-02f,
  -4.93430533e-02f, 2.84999106e-02f, -1.86432432e-02f, 2.34849416e-02f, 3.99192274e-02f, -3.85901779e-02f, 6.92045838e-02f, 4.19690162e-02f, -8.98745880e-02f, 4.88795489e-02f,
  -9.91018936e-02f, -1.07385278e-01f, 1.15478775e-02f, 3.12182643e-02f, 1.21730484e-01f, 7.28569180e-02f, -6.44994481e-03f, -1.72227491e-02f, 1.18006155e-01f, 4.46770303e-02f,
  5.21758236e-02f, 1.46284429e-02f, 2.83792354e-02f, -1.19974181e-01f, 2.36528777e-02f, -1.88763645e-02f, -9.58968177e-02f, -6.33605272e-02f, 1.24559477e-01f, -1.63485240e-02f,
  -2.02166796e-01f, 1.90017313e-01f, 1.97810326e-02f, -1.12882532e-01f, -2.20625758e-01f, -1.08802035e-01f, -1.02645792e-01f, -4.27171178e-02f, -1.18670516e-01f, 1.91493496e-01f,
  -2.39128619e-01f, 3.32920328e-02f, 1.36260942e-01f, -1.02157004e-01f, -2.01882377e-01f, 7.48721510e-02f, -1.50238171e-01f, 5.05628670e-03f, 8.61984938e-02f, -1.18555576e-01f,
  -4.58229408e-02f, -1.78505972e-01f, -4.48496155e-02f, 1.37330033e-02f, 4.41055559e-02f, 3.39991264e-02f, -1.35784641e-01f, 7.54493177e-02f, 3.05479635e-02f, -1.41687125e-01f,
  -1.73830345e-01f, -2.39163768e-02f, 3.06153987e-02f, 7.19289258e-02f, -7.06784129e-02f, -8.23875424e-03f, -3.41307442e-03f, -2.61069126e-02f, -5.26588783e-02f, 5.68264835e-02f,
  1.05328880e-01f, 2.56738393e-03f, -8.57218355e-02f, 1.49249703e-01f, 4.86471467e-02f, 6.80496022e-02f, 8.32924619e-02f, -3.71247577e-03f, -5.76509610e-02f, -6.91879401e-03f,
  1.69044703e-01f, 3.26777659e-02f, 1.20749973e-01f, 1.04307055e-01f, 8.15838296e-03f, 3.88429165e-02f, -2.71076057e-02f, -4.59280908e-02f, 4.42162119e-02f, -4.90521230e-02f,
  5.23839751e-03f, 2.50205304e-02f, -2.22324897e-02f, -2.76596583e-02f, -1.08333286e-02f, -3.39131430e-02f, -6.04749694e-02f, -8.04788396e-02f, 6.18087538e-02f, 9.93781956e-04f,
  -4.84300740e-02f, -1.99923459e-02f, -1.76301543e-02f, 2.44133566e-02f, 1.54890995e-02f, -6.15563393e-02f, 5.72787747e-02f, 3.04995030e-02f, 1.82061940e-02f, -1.23573624e-01f,
  -8.99230503e-03f, -1.68126577e-03f, -7.47499987e-04f, -3.32197584e-02f, 2.25912463e-02f, -2.93444563e-03f, 1.28433600e-01f, 1.59212753e-01f, -1.02735400e-01f, -4.45392653e-02f,
  -1.06967419e-01f, -1.40290201e-01f, -8.77263695e-02f, 5.06729782e-02f, -1.12830270e-02f, 3.95124294e-02f, -4.00925614e-02f, 3.46942879e-02f, -1.08276941e-02f, -5.98960221e-02f,
  1.47832744e-02f, -8.09515119e-02f, -6.99954033e-02f, 2.92716175e-02f, -2.21310202e-02f, -2.23924480e-02f, -3.69569398e-02f, -8.93877540e-03f, -1.53227784e-02f, -7.42385685e-02f,
  3.25237699e-02f, -4.75953370e-02f, -2.78173499e-02f, 4.95293885e-02f, 3.55140902e-02f, 3.46437958e-03f, -8.45798030e-02f, -3.03576663e-02f, 2.03300416e-02f, -4.36326005e-02f,
  -6.94305152e-02f, 5.91231398e-02f, 1.43113695e-02f, 1.78346202e-01f, -2.93850154e-02f, -2.04084262e-01f, -1.38279766e-01f, 1.98987931e-01f, 1.09819934e-01f, -6.52869642e-02f,
  8.87066275e-02f, -6.48698434e-02f, 1.27079174e-01f, 1.27562225e-01f, -4.13821936e-02f, 6.57630861e-02f, -7.82363117e-02f, -7.01493397e-02f, 6.86054453e-02f, 4.97955047e-02f,
  2.58138981e-02f, 1.34209603e-01f, 6.06526956e-02f, 1.83097139e-01f, 1.10049304e-02f, -1.25223771e-02f, 1.43665606e-02f, -1.70347411e-02f, 1.21653654e-01f, -9.20650586e-02f,
  -1.02569617e-01f, 1.49134025e-01f, 1.08820140e-01f, 7.33116828e-03f, -3.87930647e-02f, -7.10443482e-02f, -8.12540725e-02f, 1.52654825e-02f, 4.54044994e-03f, -2.08842531e-02f,
  -9.00949091e-02f, -1.28844881e-03f, 6.14942200e-02f, 8.10961351e-02f, -1.23324014e-01f, 1.09443851e-01f, 4.24722023e-02f, 3.06014866e-02f, 6.40115701e-03f, 2.32106708e-02f,
  8.35525021e-02f, 7.68234879e-02f, -1.18199237e-01f, 6.21657334e-02f, -1.43322190e-02f, 8.16175994e-03f, -5.09949215e-02f, -2.45421901e-02f, -2.97301114e-02f, -8.27098787e-02f,
  -9.13795307e-02f, -1.25804637e-02f, -1.74677800e-02f, 2.11258326e-02f, -4.65814136e-02f, -2.65186559e-02f, -3.23348269e-02f, -9.98382922e-03f, -5.17989807e-02f, 4.90075089e-02f,
  7.89942313e-03f, 6.94444850e-02f, 3.99160720e-02f, -7.36238286e-02f, 5.26769087e-02f, -3.03732827e-02f, -7.18241837e-03f, 3.10623460e-02f, -7.59790763e-02f, -1.55008184e-02f,
  -7.37628667e-03f, 1.76252648e-02f, -2.77545508e-02f, -2.45997626e-02f, -7.19561875e-02f, 6.14798162e-03f, 5.22353910e-02f, -3.62098776e-02f, -6.10053241e-02f, 3.59381549e-02f,
  -1.79019272e-01f, 2.79391301e-03f, -5.22318343e-03f, 7.89186433e-02f, -8.94035101e-02f, -1.25091732e-03f, -6.20007440e-02f, -3.89820151e-03f, -6.81218458e-03f, 5.29341176e-02f,
  -7.16138035e-02f, -3.85541767e-02f, -1.85836467e-03f, -2.52671149e-02f, -1.08324639e-01f, 3.33158150e-02f, 2.04929840e-02f, -9.75026637e-02f, -9.11976621e-02f, -3.57180387e-02f,
  -2.60826088e-02f, -6.28538197e-03f, -4.47887443e-02f, 7.33102858e-02f, 1.27102192e-02f, 7.93247968e-02f, -9.47816148e-02f, 1.52052650e-02f, 5.19396625e-02f, -8.20009038e-02f,
  -7.24439546e-02f, -1.43556535e-01f, 9.19686928e-02f, -1.28033802e-01f, -5.71257137e-02f, 6.64798766e-02f, 6.15168773e-02f, -1.57129601e-01f, -3.85781497e-01f, -6.76194876e-02f,
  1.15558982e-01f, 2.49341261e-02f, 6.01231083e-02f, -6.79591149e-02f, 2.62483418e-01f, 5.49980402e-02f, -1.70464173e-03f, -5.23143858e-02f, -1.01725891e-01f, -2.58556958e-02f,
  -5.02068177e-02f, 9.67962667e-02f, 2.31566906e-01f, 5.72794303e-02f, 5.96472770e-02f, -3.06138899e-02f, 2.26114407e-01f, 3.77882607e-02f, 1.03357933e-01f, 1.71231735e-03f,
  -7.19834790e-02f, -1.80219784e-01f, 2.23974623e-02f, -8.98278281e-02f, -7.80635104e-02f, -7.00134709e-02f, 5.35166264e-02f, 1.38589844e-01f, -2.39720140e-02f, 1.82904385e-03f,
  6.89956546e-02f, -3.12431492e-02f, 5.42287976e-02f, -2.63747722e-02f, -9.78663787e-02f, 2.40816139e-02f, -3.79287414e-02f, -3.45242098e-02f, -7.78067159e-03f, 1.31934287e-03f,
  5.03636412e-02f, 3.33680697e-02f, 2.42376383e-02f, 2.06806157e-02f, 1.40048470e-02f, -4.90949303e-02f, 7.83244148e-02f, 4.66076322e-02f, -1.62203982e-02f, 1.29438024e-02f,
  -6.81624329e-03f, -9.02211592e-02f, 2.47012619e-02f, -4.21687104e-02f, 2.52390411e-02f, -2.00766046e-02f, 4.91595268e-02f, -7.79730920e-03f, -2.90339403e-02f, 4.37979065e-02f,
  -4.29383516e-02f, -2.13882793e-02f, -1.08469613e-01f, -2.56380904e-02f, 1.28661003e-02f, -2.52320748e-02f, -2.16682106e-02f, 8.91979504e-03f, 9.13790427e-03f, -1.31424228e-02f,
  2.71080807e-03f, -9.76752639e-02f, -2.71419715e-02f, 3.12987566e-02f, -1.23684993e-02f, 1.27691895e-01f, 7.68933492e-03f, -3.32704857e-02f, -3.77423689e-02f, 4.47646454e-02f,
  -3.97553965e-02f, -7.58713111e-02f, -6.65206369e-03f, -8.75463188e-02f, -6.07370250e-02f, 5.58469705e-02f, -6.98444471e-02f, -1.95583086e-02f, -6.42123520e-02f, 3.66796926e-02f,
  8.07882398e-02f, -5.84837869e-02f, -1.46327689e-02f, -1.76113639e-02f, 1.23760805e-01f, -6.35879636e-02f, -2.17018928e-02f, 3.68376151e-02f, 6.94171190e-02f, -2.63191853e-03f,
  5.81336487e-03f, 8.09871331e-02f, 2.04230286e-02f, -3.65046039e-03f, 2.64452379e-02f, -3.89939770e-02f, -5.68559719e-03f, -2.20863931e-02f, 4.15432490e-02f, 9.12835449e-02f,
  3.50129306e-01f, -1.14608079e-01f, 1.40432239e-01f, 1.05387550e-02f, -7.05062971e-02f, 6.36283979e-02f, 1.00155815e-01f, 2.36683134e-02f, 2.32633665e-01f, -1.66647911e-01f,
  -3.55870388e-02f, 1.96525231e-01f, -6.57034442e-02f, 9.72478092e-03f, 2.65634477e-01f, 5.61369993e-02f, 4.35241871e-02f, -3.53803835e-03f, 4.70734425e-02f, -3.95053364e-02f,
  1.12564623e-01f, -6.31658658e-02f, 4.47915494e-03f, -1.80400714e-01f, -4.81290594e-02f, -4.54156175e-02f, -1.32656366e-01f, 2.12697983e-02f, -1.09253220e-01f, -6.27771998e-03f,
  1.63514018e-01f, 8.10056850e-02f, 7.08110631e-02f, 2.09893007e-02f, 3.14110257e-02f, -3.05632092e-02f, -6.44306913e-02f, 5.31465188e-02f, 1.32800704e-02f, 6.14840686e-02f,
  -6.92455284e-03f, 1.42732188e-02f, 8.45729113e-02f, 2.72727758e-02f, 3.90088595e-02f, 4.17250842e-02f, -1.37453049e-01f, 2.83730943e-02f, -5.06953970e-02f, 2.08827518e-02f,
  -2.93201283e-02f, 2.57992633e-02f, -1.16990708e-01f, 2.31512841e-02f, -3.86799648e-02f, -6.52814656e-02f, -1.97078194e-02f, -8.09838101e-02f, -1.21125774e-02f, 1.13512933e-01f,
  -1.54502606e-02f, 1.85513124e-02f, 1.68321636e-02f, -2.08103415e-02f, -4.67153937e-02f, -1.28911333e-02f, -4.52010483e-02f, -1.09461602e-02f, 9.72532388e-03f, -3.37426141e-02f,
  6.45957068e-02f, 3.75301689e-02f, -4.33077589e-02f, 3.48739475e-02f, 1.24396551e-02f, -3.61705907e-02f, -1.41935721e-02f, 9.23438184e-03f, 2.11140756e-02f, 7.97823444e-02f,
  5.77066503e-02f, 3.06131020e-02f, -8.90761986e-02f, 1.95284672e-02f, 3.20997648e-02f, 9.93430801e-03f, 1.51367402e-02f, 4.32554213e-03f, -7.24462941e-02f, -6.76545256e-04f,
  -1.25119090e-01f, 4.93484959e-02f, 4.04130071e-02f, 1.76600702e-02f, 3.01365778e-02f, -2.11403202e-02f, 9.80838016e-02f, 1.83113590e-02f, 1.57220606e-02f, 2.11466998e-02f,
  -6.17723316e-02f, 7.69849587e-03f, -3.37619297e-02f, 1.70099419e-02f, 1.86292939e-02f, -1.58627133e-03f, -3.68351862e-02f, -4.20610560e-03f, -4.18626294e-02f, -4.81364923e-03f,
  -7.73864612e-02f, -1.84997581e-02f, -1.02022132e-02f, -3.09005491e-02f, 1.88397542e-02f, -2.24709306e-02f, 4.86555472e-02f, -9.55282059e-03f, -1.16530605e-01f, 3.75724286e-02f,
  -7.46202022e-02f, -2.76061624e-01f, -5.38946912e-02f, -7.30227530e-02f, -1.41521571e-02f, 1.27590209e-01f, 8.49437639e-02f, -9.93786603e-02f, 1.27578050e-01f, -1.36708066e-01f,
  -1.29071958e-02f, -6.49502873e-03f, 5.59241557e-03f, -5.09745115e-03f, 2.03467995e-01f, 1.78292766e-01f, 1.08503424e-01f, 7.84480274e-02f, 7.97582343e-02f, -7.40053970e-03f,
  1.92575827e-02f, -3.35735530e-02f, -7.29456693e-02f, -1.19756304e-01f, -9.38527137e-02f, -2.24206194e-01f, -1.10203435e-03f, -8.26415792e-02f, -7.06102699e-02f, 7.44453445e-02f,
  -1.38429673e-02f, 4.88414280e-02f, -6.94343448e-02f, -1.16036274e-02f, -1.15550198e-01f, 2.22601239e-02f, 8.69607180e-02f, 1.23131506e-01f, -5.37541099e-02f, -1.47465020e-02f,
  -7.99567699e-02f, -4.00356762e-02f, 6.99893609e-02f, 7.71503747e-02f, -3.28755043e-02f, 4.68281582e-02f, 1.29442677e-01f, -2.14319825e-02f, -5.52891903e-02f, 6.15376420e-02f,
  6.91978261e-02f, 9.99775082e-02f, -5.31359911e-02f, -3.83455642e-02f, -9.42044482e-02f, 1.17673222e-02f, 1.01162225e-01f, 1.00740932e-01f, 2.68056430e-02f, -4.72481325e-02f,
  1.97716467e-02f, -6.43121973e-02f, -3.70859914e-02f, -5.04301190e-02f, -4.44382019e-02f, -9.42034740e-03f, 2.08945107e-02f, -6.65085390e-02f, 6.14569224e-02f, -3.61414924e-02f,
  -6.09044731e-03f, -1.18467063e-01f, 1.42730966e-01f, -2.72860639e-02f, -1.30802682e-02f, -4.09115516e-02f, -9.26936492e-02f, 1.68793783e-01f, 7.99280480e-02f, -8.82628337e-02f,
  1.21497763e-02f, 8.92178565e-02f, -3.43095846e-02f, -6.06932817e-03f, -2.60686222e-02f, 1.14527429e-02f, 9.93923517e-04f, 7.67993033e-02f, -8.14808160e-03f, 1.19603630e-02f,
  -1.83894515e-01f, -9.44136232e-02f, -6.21013865e-02f, 5.12638465e-02f, -5.00155948e-02f, -3.89446206e-02f, 2.33544353e-02f, 7.34792976e-03f, 2.71337163e-02f, 5.54357283e-02f,
  -9.12668854e-02f, -3.37994359e-02f, 1.59639686e-01f, 1.24133207e-01f, -1.55515164e-01f, 3.52479890e-02f, 3.17335390e-02f, -1.13274202e-01f, -8.66892338e-02f, 7.24033341e-02f,
  -3.87559198e-02f, 1.07945059e-03f, -8.09469074e-03f, -8.48172680e-02f, 1.85135994e-02f, 2.28388980e-02f, 1.47658484e-02f, 3.38186435e-02f, 2.19400432e-02f, 8.97132531e-02f,
  -1.26761854e-01f, 2.17165574e-01f, 3.63809094e-02f, -1.69362262e-01f, 1.77894711e-01f, -2.82767922e-01f, -1.66302085e-01f, 6.94637522e-02f, -1.80531263e-01f, 5.85907139e-02f,
  -8.45613182e-02f, 9.95879099e-02f, -4.36401106e-02f, -2.60042772e-02f, -5.56757823e-02f, -6.22785166e-02f, -1.09676890e-01f, -9.71166193e-02f, -1.20229743e-01f, 5.45065403e-02f,
  -5.43490089e-02f, 7.88256079e-02f, 2.75539141e-02f, 2.20389403e-02f, 1.20159872e-01f, -6.53326511e-02f, 1.54272512e-01f, -5.10224141e-02f, -2.60124244e-02f, 1.32000297e-01f,
  -1.11534130e-02f, 8.60510990e-02f, 1.08621649e-01f, 1.53132556e-02f, -7.52749294e-02f, -4.39442210e-02f, 5.17242663e-02f, -3.56337316e-02f, 5.73809706e-02f, -7.42519870e-02f,
  1.06816972e-02f, -2.94462107e-02f, 7.52104353e-03f, -9.49092035e-04f, -5.90991341e-02f, -2.93244720e-02f, -1.63688380e-02f, 5.76136522e-02f, 4.01385240e-02f, 7.95620084e-02f,
  -3.57291587e-02f, -3.24758561e-03f, -9.96256694e-02f, 3.47702801e-02f, -9.78210196e-02f, -6.97964802e-02f, -1.32155776e-01f, 1.08491741e-01f, -1.59044433e-02f, 8.12711492e-02f,
  6.50095195e-02f, -1.13207186e-02f, -2.31160913e-02f, -1.59053877e-02f, 1.25381164e-02f, 2.68884767e-02f, -1.58470962e-02f, 4.47305245e-03f, -1.73269063e-02f, 2.91903317e-02f,
  3.84586267e-02f, -3.09199654e-02f, 3.45954560e-02f, -2.99456976e-02f, -3.71230058e-02f, 6.55717030e-02f, 8.40735957e-02f, 4.39951085e-02f, -1.06004387e-01f, 8.84290412e-02f,
  3.00250277e-02f, 4.47134413e-02f, 1.89403500e-02f, -3.00048366e-02f, -4.86752503e-02f, 1.18908351e-02f, -6.83993101e-02f, -1.19537124e-02f, 1.09203324e-01f, -3.27610597e-02f,
  4.42131162e-02f, -2.33943444e-02f, -6.33988678e-02f, 3.19850221e-02f, -2.15185736e-03f, -4.36590053e-02f, 7.12323636e-02f, 8.88438895e-03f, 4.47529219e-02f, -1.21471487e-01f,
  -4.24004596e-04f, 5.22826426e-02f, -2.56788302e-02f, -4.27308418e-02f, 2.43283771e-02f, -2.48144623e-02f, -1.60792425e-01f, -7.60015566e-03f, 5.76900989e-02f, 6.98540434e-02f,
  -1.53754661e-02f, -2.88609676e-02f, 2.52725594e-02f, 4.89236303e-02f, -1.45964265e-01f, -2.78951526e-02f, -1.83826070e-02f, -4.04421948e-02f, 1.70692336e-02f, -7.44049475e-02f,
  1.06512666e-01f, -2.85589725e-01f, 1.74369499e-01f, 5.62293828e-02f, -5.57965562e-02f, 1.85830638e-01f, 5.95929362e-02f, 1.08677903e-02f, -4.61652018e-02f, -2.57254690e-01f,
  1.28140941e-01f, -1.83507949e-01f, 1.66396409e-01f, 1.39158726e-01f, 8.85272026e-02f, 1.05204657e-01f, 4.90624346e-02f, 5.62450625e-02f, -6.86021373e-02f, -6.62051588e-02f,
  1.09924138e-01f, -1.99382044e-02f, 1.68833598e-01f, -7.45854899e-02f, 1.14878053e-02f, 4.36873324e-02f, -1.01978987e-01f, -4.50671948e-02f, 6.76184744e-02f, -4.35233396e-03f,
  -1.75616257e-02f, -6.14362359e-02f, -4.74350415e-02f, 5.08161150e-02f, 1.27385512e-01f, 5.90898618e-02f, -5.94083667e-02f, -1.08348867e-02f, 5.27315512e-02f, 8.22897181e-02f,
  -3.27678630e-03f, 1.12984516e-01f, -6.44566342e-02f, 5.43549806e-02f, 6.31674156e-02f, -6.67993724e-02f, 7.69228563e-02f, 1.19371176e-01f, 3.99616472e-02f, -6.66884333e-03f,
  6.07622489e-02f, -2.37962194e-02f, 6.45434484e-02f, 3.07989214e-02f, 1.40772521e-01f, -5.44140562e-02f, 8.81551206e-02f, 3.06952782e-02f, 1.01345912e-01f, -6.72087893e-02f,
  -7.73814395e-02f, -7.24515840e-02f, -3.49657200e-02f, -9.46270376e-02f, -7.92313144e-02f, -1.59792099e-02f, 2.95773353e-02f, 2.07285844e-02f, 4.26853374e-02f, 6.79935291e-02f,
  5.73108010e-02f, -2.83943564e-02f, 6.74130619e-02f, -1.91166643e-02f, 7.60938972e-02f, -8.75162929e-02f, 3.15817595e-02f, 9.94238779e-02f, 1.49354085e-01f, -5.52008860e-02f,
  -7.65858218e-02f, -9.66974813e-03f, 1.60208587e-02f, -5.58594987e-03f, 1.53035242e-02f, -8.75279680e-03f, 2.36655828e-02f, -5.06957620e-02f, 4.09391709e-02f, 9.19003263e-02f,
  -1.07948281e-01f, -2.75923431e-01f, -5.85852042e-02f, 8.65008757e-02f, -7.89533556e-02f, -4.20774706e-02f, -1.21710226e-02f, -2.36643627e-02f, 3.72034498e-02f, 1.66070107e-02f,
  1.18887462e-02f, 7.86436200e-02f, 7.54957125e-02f, 1.96386725e-02f, 3.98205742e-02f, -4.58754934e-02f, 7.67078716e-03f, -1.65593438e-03f, -5.39094098e-02f, -5.00077717e-02f,
  3.41515765e-02f, -9.52375382e-02f, -6.51655067e-03f, 6.78899959e-02f, -1.87950917e-02f, -6.87892735e-02f, -2.20451914e-02f, -6.87371641e-02f, 3.73490877e-03f, -1.08779982e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.12031408e-02f, -4.67397179e-03f, -1.22235762e-02f, -3.12469639e-02f, -3.29309031e-02f, -1.07667617e-01f, -1.15880713e-01f, 5.89875281e-02f, 5.01201414e-02f, -2.23542154e-02f,
  -1.72067583e-01f, 1.48104737e-02f, 1.76016556e-03f, -1.52848765e-01f, -9.45708528e-02f, 2.31502000e-02f, -1.06892169e-01f, 7.58699775e-02f, 1.15005225e-01f, -8.81448016e-02f,
  -6.58899546e-02f, -1.19563609e-01f, -1.49220645e-01f, -1.55947775e-01f, -2.00120285e-01f, 3.77931260e-02f, -1.48992240e-01f, 1.52360294e-02f, -7.70014375e-02f, -2.74899136e-02f,
  5.06008863e-02f, 1.23052798e-01f, 3.06342002e-02f, -7.50655541e-04f, -1.56924967e-02f, -2.24740747e-02f, -1.16366655e-01f, -1.59331504e-02f, 9.64377895e-02f, -6.24956712e-02f,
  2.62552779e-02f, -9.01821554e-02f, -8.26237053e-02f, 2.48658620e-02f, -4.11716942e-03f, 3.88846807e-02f, 7.91372582e-02f, -5.83871789e-02f, -6.85172677e-02f, 1.77135430e-02f,
  5.86024625e-03f, -4.65716869e-02f, -6.26349375e-02f, 7.26095736e-02f, -2.09614094e-02f, 6.67168498e-02f, 3.18902396e-02f, 5.87877035e-02f, 5.96363917e-02f, 1.03925481e-01f,
  2.77684443e-02f, 8.69263988e-03f, -1.69325322e-01f, -2.38737892e-02f, 4.79440205e-02f, 9.81725901e-02f, -3.47460844e-02f, 1.83379799e-02f, -2.94578969e-02f, 3.39898355e-02f,
  -5.73726259e-02f, -5.37979938e-02f, -1.70328617e-02f, 3.97022069e-03f, -7.56073073e-02f, 1.11321555e-02f, -7.32044727e-02f, -3.20659876e-02f, -4.85518686e-02f, 5.25603555e-02f,
  -6.62507638e-02f, 8.99984501e-03f, 3.24944034e-02f, -2.36003753e-02f, -1.58039872e-02f, -1.40414285e-02f, -6.38755132e-03f, 9.61637963e-03f, 8.63299295e-02f, -4.35405187e-02f,
  -5.80731630e-02f, 9.85065848e-02f, -9.62781254e-03f, -5.90303876e-02f, 9.04093608e-02f, -2.90523954e-02f, -2.55294647e-02f, -1.06868297e-02f, 1.07243665e-01f, -1.00094125e-01f,
  -7.02347457e-02f, -1.07408717e-01f, 4.28344980e-02f, 1.06447317e-01f, -2.19234284e-02f, -1.00500047e-01f, 5.08968607e-02f, -5.97031265e-02f, -1.79084321e-03f, 4.53622575e-04f,
  -3.55774760e-02f, -6.47011586e-03f, 1.43807183e-03f, 2.92545594e-02f, -5.81173524e-02f, 4.55391444e-02f, 3.78260538e-02f, -3.13518941e-02f, -1.98311592e-03f, 3.40366140e-02f,
  -2.64678329e-01f, 2.61384677e-02f, -1.58734154e-02f, 1.58883646e-01f, -2.50278115e-01f, -1.99717328e-01f, -3.83077711e-02f, 4.20633703e-02f, 7.36974925e-02f, 2.52397865e-01f,
  2.95761198e-01f, -1.75995842e-01f, 2.26302266e-01f, 4.21199836e-02f, -1.78845093e-01f, 1.39855579e-01f, -5.19579314e-02f, -2.07335688e-02f, -4.29889485e-02f, 2.01033410e-02f,
  6.79294765e-02f, 8.14642906e-02f, 1.36027306e-01f, 9.36450958e-02f, -6.13444522e-02f, 1.73141211e-01f, 1.16448380e-01f, 4.30832617e-02f, 8.93812776e-02f, 3.11451722e-02f,
  -5.29266223e-02f, 1.96401581e-01f, 4.24654856e-02f, 7.52188871e-03f, 8.76055192e-03f, -6.20096661e-02f, -5.96148148e-03f, -5.23616597e-02f, 4.70125154e-02f, 8.85300431e-03f,
  -3.64908129e-02f, 2.67713647e-02f, -6.24232972e-03f, -3.39353923e-03f, -1.11252315e-01f, 7.34900907e-02f, -8.83773416e-02f, -1.22410372e-01f, 3.41228303e-03f, 2.10542940e-02f,
  6.19696639e-02f, -5.12806438e-02f, -8.20172355e-02f, 2.65178028e-02f, -8.05177987e-02f, 1.08386707e-02f, 8.31499230e-03f, 7.17324018e-02f, -6.39435090e-03f, -8.78550112e-02f,
  4.35031950e-02f, 2.10809638e-03f, 4.49156053e-02f, -2.26430595e-02f, -5.73483668e-02f, 8.82294923e-02f, -9.17437896e-02f, -1.44842472e-02f, -2.70868428e-02f, 1.03294156e-01f,
  -3.73679101e-02f, -3.53865065e-02f, 1.18086696e-01f, -6.40474409e-02f, -9.60183665e-02f, -1.13873640e-02f, 1.14788488e-02f, 8.59595016e-02f, -1.35317400e-01f, 3.53511758e-02f,
  1.28678173e-01f, -6.70328811e-02f, 3.34666036e-02f, 2.04379931e-02f, 4.93981950e-02f, 2.51909550e-02f, -2.95089725e-02f, -1.18215561e-01f, 8.01164210e-02f, -1.62729248e-02f,
  1.29304320e-01f, 1.42579198e-01f, 4.85761501e-02f, 1.81469209e-02f, 1.42301559e-01f, -1.27669886e-01f, 2.24202648e-02f, -2.02717744e-02f, 2.30051614e-02f, -4.84783836e-02f,
  -4.69516963e-02f, -1.06427027e-02f, -1.63517166e-02f, 3.72732803e-02f, 4.97974455e-02f, 9.63908061e-02f, 2.07000803e-02f, -9.34376493e-02f, -7.03769911e-04f, 9.43557620e-02f,
  7.44411871e-02f, -5.16610704e-02f, -3.65690812e-02f, 1.62139423e-02f, -3.29947211e-02f, -3.74369398e-02f, -4.06367294e-02f, 3.02191544e-02f, -6.11108877e-02f, -2.75769141e-02f,
  -2.17116922e-01f, 1.50716215e-01f, -2.37462014e-01f, -4.53696921e-02f, -1.93627283e-01f, 1.41354799e-01f, 1.69343129e-01f, -9.60950777e-02f, -5.21923043e-02f, 2.87623346e-01f,
  1.62063405e-01f, -1.86914086e-01f, 2.18881637e-01f, 2.52993703e-01f, -1.19056128e-01f, 2.68392146e-01f, 2.20704839e-01f, 1.05848491e-01f, -2.38014534e-02f, 6.47435933e-02f,
  -3.19472626e-02f, 1.87932149e-01f, 1.71923071e-01f, 3.81388143e-02f, 7.97047466e-03f, -1.39618441e-01f, 3.39329615e-02f, -1.33093655e-01f, -1.04284333e-02f, -1.26485944e-01f,
  1.00412324e-01f, 1.70890931e-02f, -4.28535156e-02f, 9.30382460e-02f, 3.80173586e-02f, -2.86766025e-03f, 3.36399488e-02f, -1.11659944e-01f, -1.52322218e-01f, 7.49123618e-02f,
  3.15607153e-02f, 5.84991695e-03f, -1.13499993e-02f, -3.33850197e-02f, -1.44127220e-01f, -4.04019468e-02f, 8.01587105e-02f, -5.75989522e-02f, -7.87276253e-02f, 5.29772677e-02f,
  1.48366913e-02f, 3.12705003e-02f, -7.33622955e-03f, -4.97945026e-03f, -3.17823403e-02f, 3.00627332e-02f, 1.09562770e-01f, -9.49309543e-02f, -4.83768061e-03f, -3.06422785e-02f,
  2.15618592e-02f, 8.97589177e-02f, 5.90869375e-02f, 5.55330291e-02f, -5.33805415e-02f, 6.80352524e-02f, -9.12004896e-03f, 5.64179681e-02f, -6.09947629e-02f, 7.87090603e-03f,
  -5.76056466e-02f, -8.03461671e-02f, 9.58894268e-02f, 4.86900881e-02f, -6.01392016e-02f, 3.78848389e-02f, 1.92709379e-02f, -4.39100452e-02f, -1.26119656e-02f, -5.90357147e-02f,
  -1.31727085e-02f, -2.13742759e-02f, -5.17028496e-02f, 2.71622767e-03f, -1.80851743e-02f, 2.50030402e-03f, -3.72416154e-02f, 1.00698650e-01f, -4.43013757e-02f, 2.73953076e-03f,
  2.97854394e-02f, -1.61085129e-02f, -9.05137286e-02f, 4.54227552e-02f, 1.56642590e-02f, 3.00572328e-02f, 7.57280141e-02f, 2.85851285e-02f, 2.85943300e-02f, 6.17661234e-03f,
  -5.30365407e-02f, -2.19555572e-02f, 9.60652065e-03f, -1.84802860e-02f, -8.59979242e-02f, -5.29703172e-03f, 1.88534465e-02f, -7.99319595e-02f, -5.58964312e-02f, -3.31095010e-02f,
  -7.68211484e-02f, -3.81235592e-02f, -5.90722822e-02f, 9.38135460e-02f, 8.31297040e-03f, 5.08598844e-03f, -7.75538683e-02f, 2.00230870e-02f, -7.35805649e-03f, -6.43463433e-02f,
  -5.10437548e-01f, 2.63290405e-01f, 2.08313838e-02f, -3.74405414e-01f, 1.54557284e-02f, -1.11877769e-01f, -3.93461734e-02f, 4.72744592e-02f, -1.12668440e-01f, 2.16062479e-02f,
  -1.92066357e-02f, 2.62923427e-02f, 1.98931292e-01f, -3.87413651e-02f, -7.00549632e-02f, 2.29817837e-01f, -2.14628398e-01f, -5.76666966e-02f, 6.84768409e-02f, -2.30908051e-01f,
  -2.22162046e-02f, -3.76029685e-02f, 4.40191776e-02f, 1.08048052e-01f, -1.69164300e-01f, -1.53899968e-01f, 4.44984389e-03f, 3.13799120e-02f, 5.35708107e-03f, 9.11275446e-02f,
  -4.06209052e-01f, -2.38104343e-01f, -1.31680220e-01f, -2.04919592e-01f, -1.60839975e-01f, 1.86290580e-03f, -6.07533641e-02f, 8.89867768e-02f, -9.81068313e-02f, -7.05560995e-03f,
  -3.43667902e-02f, 9.81630906e-02f, -3.23847383e-02f, 9.82843265e-02f, -5.21405414e-02f, 6.71170047e-03f, -1.58061422e-02f, 3.36234644e-03f, -6.77727815e-03f, -2.87162792e-02f,
  9.83786583e-03f, 3.23601961e-02f, -1.09463207e-01f, -5.24797998e-02f, -5.42154256e-03f, 2.62747128e-02f, 2.38104481e-02f, -1.40826113e-03f, -3.54335979e-02f, -8.73605534e-02f,
  8.67278948e-02f, -9.81554165e-02f, 2.67814808e-02f, -3.63693535e-02f, 3.18131596e-02f, -2.21579485e-02f, -9.85365827e-03f, -7.27820164e-03f, -6.43621013e-02f, -7.79634640e-02f,
  -2.93773180e-03f, -7.43799284e-02f, 9.51364730e-03f, -1.00801652e-02f, -2.86829751e-02f, -4.02636677e-02f, 1.24779800e-02f, -1.08574018e-01f, -7.63281062e-02f, -2.28975266e-02f,
  -2.06780843e-02f, -2.31820755e-02f, 3.41716334e-02f, -1.09339111e-01f, 1.38517404e-02f, -2.45567374e-02f, -1.52047398e-03f, 9.86437201e-02f, 3.10662370e-02f, -1.05510063e-01f,
  -4.24072981e-01f, -3.63986671e-01f, -5.26038893e-02f, -6.01073578e-02f, -7.93131143e-02f, -4.08459529e-02f, 4.25304957e-02f, -4.98236120e-02f, -4.78819907e-02f, 2.35589780e-02f,
  -6.17634803e-02f, -9.51648280e-02f, -3.31183672e-02f, -4.29600179e-02f, 1.70605406e-02f, -6.63211048e-02f, -2.14046724e-02f, -5.96185699e-02f, -8.67030919e-02f, 4.20375951e-02f,
  2.88663022e-02f, 5.08407014e-04f, 4.56971191e-02f, 2.69747209e-02f, 8.27575848e-02f, -6.75299913e-02f, -6.10392578e-02f, 2.98949033e-02f, 2.20535211e-02f, 7.86076263e-02f,
  1.38135225e-01f, 2.06672363e-02f, 4.99092713e-02f, -7.87833259e-02f, -1.18194394e-01f, -2.12568566e-01f, -1.02744818e-01f, -2.25638196e-01f, 6.85656667e-02f, -5.61654987e-03f,
  -1.90152109e-01f, 2.85138786e-01f, 1.52412299e-02f, -1.83620512e-01f, 9.60986838e-02f, 3.71318795e-02f, -4.00892422e-02f, 4.78386208e-02f, -3.20052244e-02f, -8.33697096e-02f,
  -1.03671238e-01f, -1.55867130e-01f, -7.65677169e-02f, -1.24720059e-01f, -1.04610145e-01f, 2.86860969e-02f, 1.33136466e-01f, -7.96392485e-02f, 2.15267390e-02f, -1.29622873e-02f,
  2.30559446e-02f, -1.19179562e-02f, -6.33258522e-02f, -2.30598245e-02f, 1.75726358e-02f, -3.86121534e-02f, -6.71379566e-02f, -3.79830115e-02f, 6.62761331e-02f, -2.36199796e-02f,
  7.24830180e-02f, 8.79687294e-02f, 2.32907403e-02f, 4.45701815e-02f, 9.82163567e-03f, 5.80227515e-03f, 9.26634669e-02f, 1.06829457e-01f, 1.07907737e-02f, -5.33738434e-02f,
  4.97526303e-02f, 4.75764684e-02f, -1.17067695e-02f, 1.74254626e-01f, 7.75587037e-02f, -3.79222743e-02f, 4.93389517e-02f, 1.17188364e-01f, 5.57674840e-02f, 1.91978306e-01f,
  6.37029558e-02f, 3.48860137e-02f, -1.13443531e-01f, 8.19220487e-03f, -4.38502356e-02f, -7.13571673e-03f, 3.25779058e-02f, -2.94150934e-02f, 6.33375198e-02f, -9.45274439e-03f,
  -5.73482402e-02f, -8.34188908e-02f, 2.01241225e-02f, 1.07915886e-01f, 1.45619465e-02f, -3.38801555e-03f, 1.06059127e-01f, -1.03867389e-02f, -3.21806804e-03f, 8.05249587e-02f,
  -8.80113319e-02f, -1.05009198e-01f, 2.19954140e-02f, 3.30976918e-02f, 1.03883538e-02f, 7.33780488e-03f, 6.38391525e-02f, 4.15996537e-02f, -1.17830358e-01f, -1.30099311e-01f,
  8.68815631e-02f, 1.43017665e-01f, 5.64014278e-02f, -7.39042982e-02f, 3.00458428e-02f, -5.33455387e-02f, -3.44342776e-02f, -7.48509094e-02f, 6.39933720e-02f, -1.27426639e-01f,
  2.95831263e-02f, -4.71010953e-02f, 4.94027250e-02f, 6.23784177e-02f, 5.67387827e-02f, -2.92898398e-02f, 5.11445776e-02f, 2.75714565e-02f, 5.77599779e-02f, 2.46074926e-02f,
  6.32755831e-02f, 2.41092313e-02f, 2.44098138e-02f, 1.78068969e-02f, 8.31081122e-02f, 7.09642023e-02f, 5.89052513e-02f, 8.94327164e-02f, 7.00337589e-02f, 1.18857905e-01f,
  1.96345419e-01f, -1.70819834e-01f, 2.05023795e-01f, -1.45440758e-03f, 1.26950741e-01f, 1.68612495e-01f, 3.38392854e-01f, 3.43393050e-02f, 8.97540227e-02f, -2.55407453e-01f,
  -8.51582214e-02f, 1.56842154e-02f, 1.36731759e-01f, -1.24220163e-01f, 2.73468047e-01f, 1.11883849e-01f, 3.20576876e-03f, -7.91368410e-02f, 8.31681937e-02f, 5.99657036e-02f,
  6.50035543e-03f, -1.82910234e-01f, 3.20972614e-02f, -3.17091763e-01f, -1.69272423e-01f, -1.02232799e-01f, -8.79865214e-02f, 1.06946796e-01f, -2.85783708e-01f, 3.44885029e-02f,
  3.26503851e-02f, 2.97205709e-02f, -8.77722427e-02f, -4.00710888e-02f, -3.58013436e-02f, 6.61199121e-03f, 1.05106622e-01f, 4.00836021e-02f, 8.32463354e-02f, 4.75370251e-02f,
  -1.25681937e-01f, -1.00518592e-01f, -1.44333094e-01f, 3.15730311e-02f, 7.61694927e-03f, -5.34323379e-02f, 1.66263022e-02f, 4.54046112e-03f, -1.07123494e-01f, 7.98898041e-02f,
  -7.28685111e-02f, -1.15905190e-02f, -4.15912867e-02f, -1.76563468e-02f, 5.49351200e-02f, 4.53571491e-02f, -2.33676247e-02f, 5.22706434e-02f, 9.85219982e-03f, 1.15900449e-02f,
  -1.04271220e-02f, 2.90698074e-02f, 3.73051949e-02f, -1.13793304e-02f, -7.22257122e-02f, -6.14502281e-02f, -1.03801578e-01f, -1.70192926e-03f, 6.39045658e-03f, 1.76546983e-02f,
  4.26411256e-03f, 4.70672511e-02f, 6.05005398e-02f, 1.19686268e-01f, -1.01720266e-01f, -2.35907566e-02f, -4.87372205e-02f, -3.73368375e-02f, -6.73297048e-02f, -1.92159880e-02f,
  -7.82393515e-02f, 7.35773668e-02f, -7.64034986e-02f, -7.20938027e-04f, 3.43416329e-03f, 5.81063963e-02f, -6.51816949e-02f, -5.46300225e-02f, 1.04887709e-01f, 1.17692806e-01f,
  -3.59072872e-02f, -1.34355903e-01f, -2.75057461e-02f, 5.39962649e-02f, 5.35098230e-03f, 4.80811782e-02f, 4.33817543e-02f, -6.19166568e-02f, -3.37859690e-02f, -6.84325695e-02f,
  5.57558984e-02f, -5.91057241e-02f, 1.33921364e-02f, 1.87908560e-02f, -3.84920686e-02f, -1.38868883e-01f, 4.96158376e-02f, 3.02444734e-02f, -2.17566434e-02f, -7.45581277e-03f,
  -1.08597733e-01f, -8.09755772e-02f, -2.91030183e-02f, -6.85680658e-02f, -3.45554277e-02f, -3.46130542e-02f, 1.00308731e-02f, 6.39135465e-02f, 2.66820136e-02f, -4.18393733e-03f,
  -4.67800081e-01f, 1.43463258e-02f, -2.81237196e-02f, -1.20745227e-02f, -2.34129429e-01f, 1.28759861e-01f, 3.35071295e-01f, -4.28082198e-02f, -4.21175696e-02f, 2.07483023e-01f,
  1.43795937e-01f, -7.89196268e-02f, 2.08367124e-01f, 2.30585098e-01f, 9.04486403e-02f, 2.19135284e-01f, 7.22571313e-02f, 6.06431663e-02f, -2.45318450e-02f, -2.43040267e-02f,
  -1.32138222e-01f, 7.99033605e-03f, 1.72819883e-01f, -8.66108611e-02f, 1.29467128e-02f, -1.20931767e-01f, 3.02634458e-03f, -3.90137918e-02f, 8.88485759e-02f, 1.44524416e-02f,
  -1.93504035e-01f, -3.01980555e-01f, 6.56522661e-02f, 9.61131603e-02f, 1.94223318e-02f, -1.32734314e-01f, -4.07298468e-03f, -2.19034664e-02f, -1.01202115e-01f, -4.02312055e-02f,
  -1.06475619e-03f, -7.26123601e-02f, 1.57063978e-03f, 6.56348839e-02f, 1.21416599e-02f, -1.22833960e-02f, 2.88671311e-02f, 1.71707831e-02f, -3.84924412e-02f, -5.33900112e-02f,
  1.03081785e-01f, -1.27177425e-02f, 6.01721667e-02f, -1.16513027e-02f, 5.75378984e-02f, -5.66899441e-02f, 4.41898741e-02f, 2.59457435e-02f, -8.17223042e-02f, -3.21914889e-02f,
  -2.92783100e-02f, -1.74758174e-02f, 4.24245978e-03f, 2.59665772e-02f, 4.52468731e-02f, 4.18900326e-02f, 3.50129120e-02f, -1.85022242e-02f, -2.30789054e-02f, 3.95139605e-02f,
  2.19272431e-02f, -6.33151606e-02f, 5.13865352e-02f, 4.07132506e-02f, -4.82710488e-02f, 6.45916024e-03f, -2.63414904e-02f, -1.22928079e-02f, 4.41725254e-02f, -5.71344681e-02f,
  -4.55100276e-02f, 8.71447027e-02f, -2.39786021e-02f, -1.04264785e-02f, -1.06530376e-01f, -2.99111009e-02f, -6.73559308e-02f, -2.82428153e-02f, 9.34927911e-02f, -5.08945733e-02f,
  -4.66002487e-02f, -2.07483694e-01f, 1.75903663e-02f, -1.34310052e-02f, -5.05206399e-02f, -1.17763884e-01f, 2.11193953e-02f, -1.01680852e-01f, 6.48621693e-02f, -1.40241951e-01f,
  -5.35851941e-02f, -3.51811387e-02f, -8.21878910e-02f, 6.83842867e-04f, -5.60335219e-02f, 5.95013797e-02f, -5.01786405e-03f, 2.58663930e-02f, 4.67068106e-02f, -1.85533497e-03f,
  6.20506853e-02f, -6.36413246e-02f, -1.01271749e-03f, 2.01926921e-02f, -7.09855705e-02f, 3.24852131e-02f, -1.27339736e-01f, 2.21199729e-02f, -2.19591260e-02f, 5.42690186e-03f,
  8.97252634e-02f, -1.80543154e-01f, -7.92676881e-02f, -1.10718898e-01f, -9.47235748e-02f, -1.45481555e-02f, 1.66700542e-01f, -3.27532887e-01f, -3.32363218e-01f, -7.74437860e-02f,
  7.80825466e-02f, 5.71177974e-02f, 2.09641963e-01f, -2.49242075e-02f, 3.03453356e-01f, 1.11508176e-01f, -5.94461970e-02f, 1.35364085e-01f, -5.55025935e-02f, -6.02660235e-03f,
  -1.80027424e-03f, 1.83341205e-01f, 1.72957093e-01f, -2.14522570e-01f, 2.36254986e-02f, -3.93964164e-02f, 4.79465090e-02f, 1.58591628e-01f, -7.82873854e-02f, 4.14923429e-02f,
  8.43503028e-02f, -4.69028763e-02f, -4.76407520e-02f, 5.89909516e-02f, -2.23658979e-02f, 1.35759851e-02f, 5.54657355e-02f, 2.21534014e-01f, -2.86182836e-02f, -1.52853802e-01f,
  1.04726501e-01f, -1.74414087e-02f, 9.61397402e-03f, -6.01870082e-02f, -7.89122358e-02f, -1.17949367e-01f, -2.07039565e-02f, -5.81490286e-02f, 6.74736872e-03f, 1.55103087e-01f,
  3.66440900e-02f, 5.88085502e-02f, 3.80445682e-02f, -1.41172251e-02f, -2.04001553e-03f, -3.26213390e-02f, 5.43450750e-02f, 2.13611275e-02f, 9.71182343e-03f, -8.26986879e-02f,
  6.72995998e-03f, 7.53610507e-02f, 8.18779096e-02f, 4.20381390e-02f, -5.21036088e-02f, 1.36146080e-02f, -3.88196856e-02f, -3.94524150e-02f, -4.38410118e-02f, -5.33171603e-03f,
  -2.17966568e-02f, 3.34521942e-02f, -5.85367866e-02f, 4.12605330e-03f, 9.48442221e-02f, -2.69984305e-02f, 5.72682731e-02f, 4.60730009e-02f, -5.47246821e-02f, -7.55213425e-02f,
  -9.10181180e-03f, 3.39266583e-02f, -8.24978277e-02f, 9.28180814e-02f, -8.16500373e-03f, -2.85410695e-02f, -1.30582124e-01f, -8.51311237e-02f, -4.56004515e-02f, 8.80129635e-02f,
  -7.23937824e-02f, -4.70134355e-02f, -1.13195449e-01f, -2.95731379e-03f, -4.62879390e-02f, -7.50797689e-02f, -9.66507420e-02f, -1.28083721e-01f, 3.15385754e-03f, -1.34940539e-02f,
  -5.00842966e-02f, 1.50077213e-02f, 2.23108940e-02f, -7.52607808e-02f, 5.98674305e-02f, 2.65618898e-02f, -3.55354063e-02f, -3.92355956e-02f, -4.77751158e-02f, -8.51366017e-03f,
  1.47997010e-02f, 1.61643494e-02f, 7.46620670e-02f, 1.07209887e-02f, -4.40938435e-02f, 4.62880768e-02f, 9.01761837e-03f, -1.19509744e-02f, 7.40666837e-02f, -8.74406323e-02f,
  -4.77404773e-01f, 1.32336736e-01f, 1.35274053e-01f, -2.98372260e-03f, -9.09473225e-02f, 1.43482104e-01f, 3.18301648e-01f, -4.21669707e-02f, 6.93324283e-02f, 1.29268751e-01f,
  -2.38493681e-02f, -3.23562995e-02f, 1.44385427e-01f, 1.15810044e-01f, 5.91454059e-02f, 7.67497048e-02f, 1.07866451e-01f, 5.43616042e-02f, -3.09166089e-02f, -9.27590877e-02f,
  -1.52602956e-01f, -2.80693918e-02f, 7.89316446e-02f, -1.33677348e-01f, -1.11938240e-02f, -1.01303160e-01f, 5.14716506e-02f, 6.46247268e-02f, 4.78651673e-02f, 5.54500381e-03f,
  -1.43388405e-01f, -1.70934826e-01f, -6.64974097e-03f, -1.80456098e-02f, -6.52121613e-03f, -1.72319133e-02f, -3.57989967e-02f, -9.35377460e-03f, -3.04721948e-02f, -1.31780412e-02f,
  -2.97513306e-02f, -1.00676909e-01f, -1.40604796e-03f, 2.92916019e-02f, -3.21496725e-02f, -3.34472880e-02f, 7.09100887e-02f, -4.08943221e-02f, 2.82784011e-02f, -8.09620246e-02f,
  9.85708237e-02f, -6.17602468e-02f, 3.26328352e-02f, 4.90264967e-02f, -2.99662575e-02f, -1.25117609e-02f, 1.08069576e-01f, -1.30995857e-02f, 1.20163234e-02f, -6.67138472e-02f,
  -2.20838990e-02f, -1.18378796e-01f, -2.59629823e-02f, 2.17931084e-02f, 2.98946276e-02f, -3.13175842e-02f, 1.93776246e-02f, 2.32016798e-02f, 3.07436846e-02f, -4.25709337e-02f,
  -7.49176145e-02f, -3.36036435e-03f, -4.26592790e-02f, -4.87091132e-02f, -2.14132052e-02f, -5.82405068e-02f, -7.34091625e-02f, 7.29118735e-02f, 5.57647310e-02f, -8.99531692e-02f,
  4.17312197e-02f, 5.28460331e-02f, 9.20486450e-03f, -9.51112732e-02f, -3.36016193e-02f, -4.78941388e-02f, 1.04575835e-01f, -3.26584838e-02f, 5.25171086e-02f, 1.96782369e-02f,
  -4.65282723e-02f, -6.10812977e-02f, 8.08296204e-02f, 1.74385100e-03f, -9.28060263e-02f, -1.20508716e-01f, 2.91849058e-02f, -1.53665524e-02f, 9.59529504e-02f, 2.24174536e-03f,
  -1.76379681e-02f, -1.09215360e-02f, -6.19212165e-02f, -6.14820570e-02f, -7.80986026e-02f, 1.11689515e-01f, -4.20877896e-02f, -5.91984950e-02f, 6.01600530e-03f, -2.97920797e-02f,
  3.19385231e-02f, -3.19122374e-02f, 5.38345352e-02f, 3.94933950e-03f, -2.12837942e-02f, -5.44371605e-02f, -7.20259622e-02f, 3.00089270e-02f, -4.54009362e-02f, 8.99099112e-02f,
  -5.10780513e-01f, 4.60818447e-02f, 4.04975921e-01f, -4.23001468e-01f, 2.36303449e-01f, 1.41473427e-01f, 1.04213059e-02f, -7.30703399e-02f, -1.80381998e-01f, -2.31318831e-01f,
  -1.76018789e-01f, -7.54252821e-02f, 1.95765898e-01f, -1.98460937e-01f, 2.12551370e-01f, 2.17165574e-01f, -1.79593042e-01f, -9.62105542e-02f, 1.78490207e-01f, -8.25796872e-02f,
  -1.18210427e-02f, -2.91831885e-03f, 2.76951432e-01f, 1.10639535e-01f, 3.01126018e-02f, -1.96813360e-01f, -5.60116805e-02f, 1.75470486e-01f, -1.35376811e-01f, 1.71245754e-01f,
  -7.12276846e-02f, -1.49074510e-01f, 2.29448318e-01f, 7.69314840e-02f, 6.29631802e-02f, -7.03036858e-05f, 2.05506030e-02f, 5.05821966e-02f, -5.38832247e-02f, -9.35197547e-02f,
  2.69500520e-02f, 1.79849453e-02f, -1.21079937e-01f, 1.40714711e-02f, -5.02309352e-02f, 4.19054274e-03f, 1.05475172e-01f, 1.19529553e-02f, 9.52586979e-02f, 9.96016189e-02f,
  1.50561735e-01f, -5.59939584e-03f, -4.45945561e-02f, -1.36828050e-01f, 2.02388410e-02f, -6.20923415e-02f, -1.10293157e-01f, -8.16641562e-03f, -1.39193684e-02f, -8.64415318e-02f,
  5.75649701e-02f, 4.65629064e-02f, 7.68187195e-02f, 1.73409528e-03f, -3.09625976e-02f, -1.11839384e-01f, -1.01719247e-02f, 4.62320633e-02f, 2.25120131e-02f, 3.62112746e-03f,
  -3.09114791e-02f, 2.00342815e-02f, -5.39654726e-03f, 1.35381622e-02f, 4.97108065e-02f, -6.67645363e-03f, 1.03161283e-01f, -2.89942883e-02f, 1.91233810e-02f, 1.12719107e-02f,
  1.37072755e-02f, -3.62144038e-02f, -5.51903201e-03f, 1.70228928e-02f, 1.66846849e-02f, 4.54427898e-02f, -9.73904654e-02f, -7.61398748e-02f, -3.59102078e-02f, 7.35787749e-02f,
  -1.62497878e-01f, -4.00721014e-01f, 1.50349410e-02f, -1.32991269e-01f, -3.22660580e-02f, 1.49132870e-02f, 7.26384148e-02f, -6.67565688e-02f, -1.88520476e-02f, -6.00050054e-02f,
  -6.27815202e-02f, -3.06849610e-02f, 5.22961188e-03f, -3.73009779e-02f, 1.22416586e-01f, -5.50229363e-02f, -4.43660729e-02f, 3.50905806e-02f, 1.15098176e-03f, -2.91344263e-02f,
  -4.82975058e-02f, -1.74800470e-03f, -6.11440130e-02f, -1.68618634e-02f, 1.97560266e-02f, -1.34215308e-02f, -5.88801093e-02f, -1.04977647e-02f, 4.27216776e-02f, 3.27930530e-03f,
  -1.66530564e-01f, 9.31304470e-02f, -2.73495615e-01f, 5.56327179e-02f, 1.04542665e-01f, 1.66898355e-01f, 8.61293450e-02f, 3.25710140e-02f, 4.50043343e-02f, 1.26482025e-01f,
  1.68630794e-01f, 9.14750546e-02f, -4.45531644e-02f, 3.33279222e-01f, 2.22813874e-01f, 2.01753825e-02f, 2.30473906e-01f, 6.76776320e-02f, 4.55258088e-03f, 1.12567373e-01f,
  -1.11123092e-01f, 2.12928072e-01f, -7.57807568e-02f, -7.34963790e-02f, 1.04091235e-01f, -1.21603988e-01f, 3.12282424e-03f, -1.49398878e-01f, -4.18126397e-03f, 5.28670549e-02f,
  6.08584136e-02f, -1.21997051e-01f, -5.95858209e-02f, -1.82972372e-01f, -9.88284349e-02f, -3.85412686e-02f, 2.55930182e-02f, -3.55493575e-02f, -3.82488631e-02f, -1.07416036e-02f,
  -6.04108833e-02f, 9.79675800e-02f, -2.45430171e-02f, -1.94787234e-02f, 7.00707585e-02f, -5.96421352e-03f, -1.42792184e-02f, 1.04850158e-01f, 3.52384299e-02f, -4.14080098e-02f,
  -6.08730353e-02f, 4.07175831e-02f, 9.13349837e-02f, 3.19274962e-02f, -7.97094554e-02f, -4.82663363e-02f, 4.95553464e-02f, -9.50728636e-03f, 5.08032851e-02f, 7.13541731e-02f,
  -4.22800565e-03f, 7.00137718e-03f, -2.52317674e-02f, -4.38202508e-02f, 8.84582847e-02f, -6.98253140e-03f, 5.25892600e-02f, 1.14744768e-01f, -3.51330899e-02f, 5.65313324e-02f,
  -3.77799049e-02f, 1.06909342e-01f, 3.87502313e-02f, -4.02662680e-02f, 6.05416447e-02f, -5.42201428e-03f, 3.07706669e-02f, 7.75519684e-02f, -2.92426702e-02f, -5.47347963e-03f,
  7.21965730e-02f, -6.27816189e-03f, -5.89949936e-02f, -4.92314547e-02f, 7.75039718e-02f, -3.44772264e-02f, -1.87172331e-02f, -1.65396575e-02f, -2.17992645e-02f, -5.62468059e-02f,
  1.94782495e-01f, 2.16946661e-01f, -2.33904440e-02f, -5.26033491e-02f, 4.84173466e-03f, -9.31587163e-03f, -5.62578179e-02f, 2.92296358e-03f, 3.23084034e-02f, 2.92051863e-02f,
  -5.11961654e-02f, 5.33581190e-02f, -9.02951434e-02f, 2.41016783e-02f, 5.12747932e-03f, 1.55324727e-01f, -2.62480509e-03f, -2.38697268e-02f, 1.47498369e-01f, -7.44439214e-02f,
  -1.47056766e-02f, -1.66381598e-02f, 1.17169274e-02f, 4.20392901e-02f, -2.66128778e-02f, 5.19158207e-02f, -1.72663182e-02f, -2.22757757e-02f, -3.57883498e-02f, 3.27045694e-02f,
  9.12840068e-02f, -7.25665838e-02f, -2.44878698e-02f, -3.67481560e-02f, 1.64823800e-01f, -2.43221045e-01f, -2.47811347e-01f, -1.60856351e-01f, 1.40384808e-01f, -2.30482981e-01f,
  -1.95768196e-02f, -6.15526875e-03f, 2.33634729e-02f, -4.89491969e-02f, -3.46837863e-02f, -4.36903723e-03f, -1.70063719e-01f, -2.35208310e-02f, 7.83271268e-02f, -1.86242282e-01f,
  9.68151987e-02f, -1.35298789e-01f, -9.16240960e-02f, -6.51389435e-02f, -1.22395620e-01f, -7.48951212e-02f, -1.06959485e-01f, 1.02890348e-02f, -1.43742114e-01f, 2.08006194e-03f,
  -2.48227328e-01f, 8.72581825e-02f, 9.47814900e-03f, -1.91726342e-01f, -1.13476209e-01f, -6.15427904e-02f, -9.17646289e-02f, 2.09827665e-02f, -9.34716128e-03f, 1.16511034e-02f,
  5.94826862e-02f, -2.05381624e-02f, -2.96778195e-02f, 1.39680982e-01f, -4.02506366e-02f, -2.13912874e-02f, -2.33720895e-03f, -2.31631137e-02f, 1.55317765e-02f, 1.15803100e-01f,
  1.25222892e-01f, -2.67168712e-02f, -3.11524365e-02f, -9.25715566e-02f, 5.33990413e-02f, -5.14733344e-02f, 8.43284186e-03f, -1.77546088e-02f, -4.77232747e-02f, 8.30221083e-03f,
  1.07978307e-01f, 1.38485972e-02f, 1.04863644e-01f, -2.07185000e-03f, -7.58927986e-02f, 1.29287615e-01f, 8.87748525e-02f, -3.14548463e-02f, 1.41018666e-02f, 2.84021683e-02f,
  4.58229892e-02f, -5.08316718e-02f, 1.75924048e-01f, 4.29855213e-02f, 4.88215163e-02f, -2.84761302e-02f, -5.39118573e-02f, 9.02918652e-02f, 9.06256884e-02f, -5.59238493e-02f,
  -5.07703945e-02f, -3.82703058e-02f, -3.51357125e-02f, -2.53941864e-02f, -9.23901573e-02f, 1.76043424e-03f, -5.86648993e-02f, -1.23595456e-02f, 6.86640444e-04f, -6.37470186e-02f,
  -3.87853503e-01f, -3.42087477e-01f, -5.25997467e-02f, -1.15991928e-01f, -1.31693438e-01f, -9.74659026e-02f, 1.04870005e-02f, -5.22610657e-02f, -4.62515876e-02f, 2.21004691e-02f,
  -7.99859837e-02f, -1.77145246e-02f, 3.13416421e-02f, 4.81478684e-03f, 1.09722158e-02f, 4.62074578e-03f, -4.93474156e-02f, -3.19095366e-02f, -9.80937034e-02f, -7.65230060e-02f,
  -4.17528637e-02f, 1.27904555e-02f, -3.54178883e-02f, -1.91332120e-02f, -2.01916099e-02f, -1.29092215e-02f, -2.82814503e-02f, -2.12314036e-02f, 2.19642073e-02f, -5.58663234e-02f,
  -2.59713054e-01f, 1.59111559e-01f, 9.04228240e-02f, 3.28479856e-02f, 4.34873551e-02f, -9.82078239e-02f, -1.10568173e-01f, 6.25894293e-02f, -2.00468943e-01f, 7.61002749e-02f,
  9.96764898e-02f, -1.04720928e-01f, -2.53248531e-02f, -1.28391638e-01f, -3.36250901e-01f, -1.14832170e-01f, -1.26616165e-01f, -1.89161417e-03f, -4.53718826e-02f, 1.95632458e-01f,
  -7.90959820e-02f, -8.46845135e-02f, 8.92384648e-02f, 1.59641936e-01f, 5.34232408e-02f, 1.62850648e-01f, 1.54025659e-01f, 1.45158142e-01f, 8.86519626e-02f, -1.36680797e-01f,
  -1.46142244e-01f, -1.96882039e-02f, 6.43370748e-02f, -1.47322612e-02f, -5.89189772e-03f, 8.23933184e-02f, -2.09284574e-02f, -5.62806763e-02f, -6.31802157e-02f, -2.95849447e-03f,
  -3.82630154e-02f, -1.22410692e-01f, 1.07461559e-02f, -1.23146340e-01f, -4.16225493e-02f, -4.33237031e-02f, -7.24914521e-02f, 2.46020015e-02f, 5.07036224e-02f, 3.03776120e-03f,
  6.24584444e-02f, 5.07560410e-02f, 6.94767162e-02f, -1.20148368e-01f, -1.88482497e-02f, 2.18434352e-02f, 4.52362262e-02f, -2.79705413e-02f, -2.01919265e-02f, -4.01761420e-02f,
  -8.07697922e-02f, 8.67084265e-02f, 5.54029681e-02f, -2.33867411e-02f, -2.80640274e-03f, -9.30547193e-02f, 5.08070216e-02f, 4.21402454e-02f, -1.16619645e-02f, 1.63839795e-02f,
  -2.12002583e-02f, 6.99602962e-02f, -8.82472694e-02f, 1.88770536e-02f, 2.68729329e-02f, 7.41419941e-02f, 1.12765975e-01f, 8.02977830e-02f, -3.50132361e-02f, 5.03054224e-02f,
  6.14316426e-02f, -5.84694935e-05f, 4.26221900e-02f, -5.25517389e-02f, -8.62525403e-02f, 2.09930744e-02f, 3.79882171e-03f, -3.90826631e-03f, 5.67185581e-02f, 1.45191159e-02f,
  4.95961010e-02f, 1.70355886e-01f, 1.00920975e-01f, -1.26796141e-01f, -3.33776250e-02f, 1.48786698e-02f, -2.35311617e-03f, -5.65339178e-02f, -3.20458338e-02f, 5.60141020e-02f,
  6.10798374e-02f, -7.41816759e-02f, -4.81932051e-02f, -2.45573279e-02f, -7.26604685e-02f, 1.21623896e-01f, 5.17301112e-02f, -4.08682004e-02f, 1.12694480e-01f, 3.28545662e-04f,
  9.42256898e-02f, -6.92769373e-03f, -2.01293603e-02f, -7.01221377e-02f, 1.99140068e-02f, -6.00193860e-03f, 1.15166772e-02f, -9.29329079e-03f, 3.71430106e-02f, -5.43398000e-02f,
  2.51279324e-01f, -9.22708586e-03f, -2.59417653e-01f, -4.48005684e-02f, 2.75382716e-02f, 1.53801426e-01f, 1.77854776e-01f, 4.65917625e-02f, 1.64075732e-01f, 2.27710187e-01f,
  1.18342966e-01f, 1.62999883e-01f, 1.05637573e-01f, 1.95832685e-01f, 2.31383637e-01f, 1.22585006e-01f, 1.99192107e-01f, 1.04418591e-01f, -5.20715304e-03f, 1.41538665e-01f,
  1.54415935e-01f, 2.68101931e-01f, -1.54377684e-01f, 3.73598710e-02f, -3.81523967e-02f, -2.55990535e-01f, -1.28859565e-01f, -2.73525536e-01f, -2.86052506e-02f, 2.35859659e-02f,
  4.43856828e-02f, 4.59347963e-02f, -3.27406116e-02f, -5.13720587e-02f, 1.47694713e-02f, 2.56773178e-02f, -2.51814090e-02f, -5.47391400e-02f, -3.58535945e-02f, 9.98892188e-02f,
  -3.13565768e-02f, 2.20259707e-02f, -3.11739985e-02f, -2.51409207e-02f, 2.15736646e-02f, -1.60615668e-02f, -7.78343305e-02f, -1.14282869e-01f, 5.33238389e-02f, 1.37742296e-01f,
  -5.88494428e-02f, -7.31878653e-02f, -3.16771381e-02f, -3.42417508e-03f, -9.22862664e-02f, 5.31061664e-02f, -6.21328801e-02f, -2.00403079e-01f, 1.41610624e-02f, -5.82327396e-02f,
  2.28075143e-02f, 9.16189030e-02f, -9.21357051e-03f, -1.39000013e-01f, -5.00526875e-02f, -1.51169160e-02f, 3.30723487e-02f, 7.70388916e-02f, 1.68647058e-02f, 5.40563986e-02f,
  1.36278439e-02f, 2.14915462e-02f, -1.16369659e-02f, -9.47451591e-03f, 8.93319622e-02f, -1.36597296e-02f, 3.63871455e-02f, 5.01016937e-02f, -7.24491030e-02f, -3.36902961e-02f,
  -3.17602605e-02f, 1.01930099e-02f, -4.24768403e-02f, -1.52338026e-02f, 3.99091421e-03f, -1.69400945e-02f, -1.06402440e-02f, -6.44054562e-02f, -2.05044076e-02f, -4.04082984e-02f,
  1.36841774e-01f, 9.87061486e-02f, 3.02390084e-02f, -4.41635884e-02f, -2.43966244e-02f, -1.38013270e-02f, 1.80624146e-02f, 8.89962688e-02f, -7.42914006e-02f, 4.94284518e-02f,
  4.48215604e-02f, -1.01364739e-01f, -1.75026562e-02f, -5.70147410e-02f, -5.99086359e-02f, -6.02047471e-03f, 5.15748151e-02f, -4.02692482e-02f, 2.56655514e-02f, 3.30917314e-02f,
  8.92316326e-02f, 6.05228990e-02f, -8.01522732e-02f, -4.59435061e-02f, 1.68038812e-02f, 1.66275799e-02f, 1.82211418e-02f, -1.85156286e-01f, 2.02414468e-02f, -6.01338521e-02f,
  -3.66779953e-01f, 5.79094552e-02f, -2.22501561e-01f, -2.98265427e-01f, 2.93174759e-02f, -7.67961890e-02f, -1.16594300e-01f, 4.11531813e-02f, -1.39093667e-01f, 2.60311961e-01f,
  1.02454498e-01f, -1.47612870e-01f, 9.39242020e-02f, -1.07760280e-01f, -3.72065276e-01f, -7.97389001e-02f, -2.62441725e-01f, -9.88367274e-02f, -1.08794443e-01f, -2.64142361e-02f,
  -6.87436685e-02f, 3.38525921e-02f, -2.46880665e-01f, 2.06052825e-01f, -5.46457842e-02f, -3.23616676e-02f, 1.24130875e-01f, 1.11832172e-01f, -1.06523216e-01f, -2.92802751e-02f,
  -2.01259062e-01f, -9.09268260e-02f, 6.62001083e-03f, -5.55298924e-02f, -5.93242906e-02f, 2.84809414e-02f, -1.69250984e-02f, -5.75111099e-02f, -8.01669210e-02f, -4.13445868e-02f,
  -5.58016188e-02f, -7.73407519e-02f, -3.03879771e-02f, 5.28281964e-02f, 1.35517977e-02f, 6.78270906e-02f, -3.41041461e-02f, -1.21638551e-01f, -1.02535725e-01f, -1.45757481e-01f,
  -7.93603957e-02f, -3.35281417e-02f, -8.28874558e-02f, -6.51798397e-03f, 2.85052359e-02f, 7.56138265e-02f, 4.36959695e-03f, 1.83682218e-02f, -1.21415839e-01f, -7.80852959e-02f,
  8.75553489e-03f, -4.90190787e-03f, -4.78850193e-02f, -4.29003611e-02f, -2.13143434e-02f, 3.35237011e-02f, 5.53737618e-02f, -1.35046989e-03f, 1.25891775e-01f, 3.40233110e-02f,
  6.10626116e-02f, -8.97705182e-02f, 6.98066875e-02f, 4.77706939e-02f, 2.37183310e-02f, -4.38728146e-02f, 4.38524857e-02f, -5.61932027e-02f, 2.80994456e-03f, -1.29417926e-01f,
  -1.27397766e-02f, 7.30313286e-02f, -3.20901424e-02f, 3.31741991e-03f, -5.50989015e-03f, -5.12219705e-02f, 3.31872441e-02f, -3.54255922e-02f, 2.69282535e-02f, 2.19477639e-02f,
  -7.37589672e-02f, -8.51646215e-02f, -1.05026312e-01f, 1.91880800e-02f, -4.87521365e-02f, 4.48472844e-03f, 7.24696461e-03f, -5.90853486e-03f, 1.48632586e-01f, -1.88678075e-02f,
  1.27529055e-01f, 1.39436036e-01f, -3.91705632e-02f, 8.30511227e-02f, 2.65924912e-02f, -4.66845930e-02f, 6.61885366e-02f, 5.05594239e-02f, -4.23135124e-02f, -5.89040034e-02f,
  -1.25275757e-02f, -6.53929450e-03f, 1.05080776e-01f, 8.39370042e-02f, -4.61063981e-02f, -1.86169725e-02f, -2.20506806e-02f, -3.88643108e-02f, -1.18989851e-02f, 3.79204340e-02f,
  -9.16950181e-02f, 7.36619234e-02f, -5.56804612e-02f, -1.37507707e-01f, -4.79443036e-02f, -1.74376026e-01f, -1.86597630e-01f, 4.72749360e-02f, -1.82371251e-02f, 6.59387708e-02f,
  -8.14030878e-03f, 1.74618632e-01f, 1.19942114e-01f, -4.31375280e-02f, -1.81427792e-01f, 9.45822150e-02f, -1.36486888e-01f, -8.32125545e-02f, 2.92436592e-02f, -7.23544881e-02f,
  -9.79176015e-02f, -6.51971325e-02f, -7.12102056e-02f, 1.08028650e-01f, -1.27178803e-01f, -7.97868893e-03f, -6.84211925e-02f, 5.02490401e-02f, 5.98458648e-02f, 6.11437559e-02f,
  -2.17045248e-01f, 2.18428131e-02f, 9.20320489e-03f, -4.28918451e-02f, -1.65724650e-01f, 1.24862716e-02f, -1.27435727e-02f, -1.06166445e-01f, -6.88217729e-02f, 7.14340135e-02f,
  3.47366333e-02f, -9.10716131e-02f, -2.82020774e-03f, 4.62048091e-02f, 4.77264151e-02f, -1.50447479e-02f, 2.61801970e-03f, -9.52631533e-02f, 1.57031137e-02f, -9.86796338e-03f,
  -1.83778014e-02f, 2.28897817e-02f, -1.14878118e-01f, -4.94223135e-03f, -2.74114348e-02f, 9.54404753e-03f, -5.00503108e-02f, 1.72079317e-02f, 1.93805341e-02f, -2.23495662e-02f,
  7.68273547e-02f, -3.41718122e-02f, 2.21833773e-02f, -7.14811683e-02f, 7.15235993e-02f, -9.32489559e-02f, -3.27487774e-02f, -9.09631476e-02f, -6.13393355e-03f, -4.72457185e-02f,
  -5.30996956e-02f, 8.16902816e-02f, 6.89977854e-02f, -1.14863731e-01f, -2.11607572e-02f, -3.36232111e-02f, -5.85506000e-02f, -9.71545205e-02f, 5.79120629e-02f, -1.04018087e-02f,
  6.54769316e-02f, -4.39232029e-03f, 3.58814420e-03f, -1.16028339e-01f, -3.14455070e-02f, -5.49074709e-02f, -5.09715676e-02f, -7.67940134e-02f, 5.19330986e-02f, 1.17907254e-02f,
  -3.07340741e-01f, -1.27805457e-01f, 1.78362913e-02f, -3.23146842e-02f, -9.49899852e-02f, -1.60501450e-02f, -6.63863495e-03f, 3.08519583e-02f, 8.15563127e-02f, -7.00084306e-03f,
  3.45799811e-02f, -3.46362442e-02f, 8.17044452e-02f, -2.42485311e-02f, 5.55373169e-02f, -7.12235644e-02f, -7.73548037e-02f, -1.17555875e-02f, -1.08563706e-01f, -7.50725642e-02f,
  -7.59893209e-02f, -5.99677069e-03f, -2.69877468e-03f, 1.04086116e-01f, -8.59515555e-03f, -4.36774641e-02f, -3.38171907e-02f, -6.64391648e-03f, -2.92636734e-02f, 2.89141778e-02f,
  2.13835344e-01f, 2.43230015e-01f, 8.39258432e-02f, 1.39181241e-01f, -1.16099834e-01f, -2.37308532e-01f, -1.72333494e-01f, 2.15734281e-02f, 6.28386065e-02f, -1.02761626e-01f,
  -2.78733283e-01f, 3.59132946e-01f, -3.16805840e-01f, 1.77212536e-01f, -1.69787839e-01f, -3.27752292e-01f, 1.06530547e-01f, 1.07604034e-01f, 8.94137099e-02f, -1.54732578e-02f,
  1.02137709e-02f, -2.15288475e-01f, 1.55520320e-01f, -4.95923683e-02f, 1.61869034e-01f, 2.09239855e-01f, 5.57053871e-02f, -4.38268557e-02f, 1.62241474e-01f, 1.63489074e-01f,
  5.26184924e-02f, -1.02199651e-02f, 9.30707455e-02f, 1.36659160e-01f, -3.15949619e-02f, 3.07756029e-02f, 4.66097407e-02f, 3.86380628e-02f, 5.89799546e-02f, -1.36357751e-02f,
  -5.79447597e-02f, -1.10195845e-01f, 3.00302822e-02f, -6.27067834e-02f, 1.28431216e-01f, 8.00951123e-02f, -5.77437282e-02f, 7.66137708e-03f, 1.75630122e-01f, 4.76810150e-02f,
  6.73384741e-02f, 9.26400274e-02f, 4.97935303e-02f, 1.34712130e-01f, 3.99395265e-02f, 2.06537433e-02f, -4.99515608e-02f, 4.72749211e-02f, 1.00454867e-01f, 5.60901053e-02f,
  -8.64131469e-03f, -1.16157450e-01f, 3.62406485e-02f, 6.13009371e-02f, -4.27527577e-02f, 1.83963403e-02f, -2.57291775e-02f, -1.50244087e-02f, -8.70554149e-02f, -1.77139714e-02f,
  1.13221280e-01f, 1.07604675e-01f, -6.02584751e-03f, 1.18722230e-01f, -1.13849930e-01f, 1.34988427e-01f, 5.40220700e-02f, -9.75862518e-02f, 3.53206210e-02f, 2.61546597e-02f,
  -6.64522275e-02f, -3.88628989e-02f, -2.55787261e-02f, 3.24880742e-02f, -5.69731183e-02f, -3.60488221e-02f, -5.44142239e-02f, 2.09405739e-02f, -1.12649724e-02f, -4.69489656e-02f,
  -5.58472052e-02f, -1.89024627e-01f, -4.18508938e-03f, 1.36365891e-01f, -6.94913194e-02f, 8.81780311e-02f, -3.85952555e-02f, 9.17901751e-03f, -1.12170331e-01f, -6.16135867e-03f,
  5.99993430e-02f, -4.16328348e-02f, -1.40288249e-01f, 1.62539873e-02f, 2.78418455e-02f, -1.58625375e-02f, -1.08843572e-01f, -1.04480915e-01f, 1.96175333e-02f, 3.77296172e-02f,
  -1.99477567e-04f, -1.48343354e-01f, 7.87441793e-04f, 9.33772996e-02f, -1.79853979e-02f, -2.67796014e-02f, 4.15091738e-02f, 9.55805555e-02f, -6.95098191e-02f, 3.03901322e-02f,
  1.24636970e-01f, 5.14157228e-02f, 9.09496397e-02f, 2.20525876e-01f, -1.35859311e-01f, -2.24377289e-01f, -2.11272076e-01f, 2.09012613e-01f, -2.96424717e-01f, -4.62163053e-02f,
  3.82097997e-02f, 2.95951646e-02f, 1.12012649e-05f, 2.35495076e-01f, 2.67873138e-01f, -8.93731415e-02f, 2.10996270e-01f, -1.65880602e-02f, 1.99273303e-02f, 8.88273194e-02f,
  2.62277842e-01f, 1.57150000e-01f, 2.78836101e-01f, 2.21948147e-01f, 6.04633987e-02f, 1.96459591e-01f, 1.20327719e-01f, -1.32266777e-02f, 2.75886506e-01f, -2.25469600e-02f,
  -4.93658073e-02f, 4.62156460e-02f, 1.00310698e-01f, -4.72551590e-04f, -2.62497831e-02f, -8.73035118e-02f, -1.57583877e-02f, 2.92028971e-02f, 5.82591370e-02f, 1.34878149e-02f,
  4.91962880e-02f, 1.71320643e-02f, -4.32899036e-03f, -1.57207549e-02f, 5.39196432e-02f, -1.38301086e-02f, -2.86493450e-02f, -2.84090191e-02f, -8.04328099e-02f, 1.23232499e-01f,
  1.24084763e-01f, 1.74092390e-02f, -3.27767059e-02f, 9.94841158e-02f, 6.88881204e-02f, 2.63587423e-02f, 4.75127585e-02f, -5.74166104e-02f, -3.74764726e-02f, 3.61665040e-02f,
  7.79588744e-02f, -1.54878214e-01f, -7.04117194e-02f, -5.55058792e-02f, 5.94321825e-02f, 6.42950684e-02f, -5.75543102e-03f, 6.00927956e-02f, -5.97777553e-02f, 1.04654832e-02f,
  -3.69060412e-02f, 4.72499393e-02f, -4.22759019e-02f, -9.26440507e-02f, 3.21167856e-02f, -2.07202993e-02f, 6.64225221e-02f, 5.29767461e-02f, -6.10794052e-02f, -2.11546682e-02f,
  -2.59599611e-02f, -3.32157640e-03f, -5.25239781e-02f, -2.82201674e-02f, 2.94680651e-02f, -4.64530140e-02f, -3.04374204e-04f, -1.16322741e-01f, 2.40138490e-02f, -2.06731912e-02f,
  -2.07456984e-02f, 1.63017109e-01f, 6.16392493e-03f, -1.84767519e-03f, -2.06867655e-04f, -2.41542533e-02f, -4.73442301e-02f, 7.91511685e-02f, 4.27742638e-02f, -2.76143476e-02f,
  8.01801123e-03f, 4.16337922e-02f, -1.01296313e-01f, 6.03471994e-02f, 8.71789008e-02f, -1.21135503e-01f, 9.92255062e-02f, -2.50327284e-03f, 9.36110839e-02f, 7.58885592e-02f,
  -5.05739963e-03f, -7.16932565e-02f, 1.52827621e-01f, -5.92268147e-02f, 9.21299830e-02f, -8.51694345e-02f, 2.12617181e-02f, 3.18749845e-02f, 7.10618123e-02f, 1.81876197e-02f,
  3.09519023e-01f, -3.72846574e-02f, 7.01178834e-02f, 2.64095277e-01f, 3.16111416e-01f, 4.44803387e-02f, 9.52064469e-02f, 1.71847984e-01f, 2.60786831e-01f, -1.90742090e-01f,
  -1.00803226e-01f, -8.00805390e-02f, -2.35862970e-01f, 2.58932374e-02f, -4.64605540e-02f, -1.45032659e-01f, 1.66331261e-01f, 1.78931560e-03f, -3.55674662e-02f, -6.42003939e-02f,
  1.18687741e-01f, 4.58289236e-02f, -8.96380097e-03f, -2.11020075e-02f, 1.32962868e-01f, 8.73394012e-02f, -2.30726041e-02f, -1.15821257e-01f, 9.26270485e-02f, -5.79447020e-03f,
  8.83469731e-02f, 2.12114807e-02f, 4.14389558e-02f, -1.16085924e-01f, -1.77154341e-03f, -6.23094551e-02f, -4.84159291e-02f, -1.35165244e-01f, 1.44099563e-01f, -1.81530342e-02f,
  -5.43447733e-02f, 1.35324700e-02f, 4.62155566e-02f, 1.72800536e-03f, 1.20734788e-01f, 1.78330634e-02f, -6.20211521e-03f, 7.72479996e-02f, 9.76558551e-02f, -1.37118161e-01f,
  -7.64628425e-02f, -1.13141231e-01f, 3.50682251e-02f, 6.90533966e-02f, -3.36941443e-02f, 1.70657426e-01f, -1.37278661e-01f, 3.82978022e-02f, 4.35706154e-02f, -5.50787477e-03f,
  1.62197575e-02f, -2.60444414e-02f, -1.00381114e-01f, -1.00414589e-01f, -9.20056365e-03f, 9.98737067e-02f, 1.36199640e-02f, -5.82025275e-02f, -8.55637621e-03f, 2.85961721e-02f,
  -1.21375909e-02f, 4.01424170e-02f, -7.24700652e-03f, -5.64181730e-02f, 1.57768782e-02f, 4.65103425e-02f, 3.45127434e-02f, -8.21921676e-02f, -4.32274342e-02f, -6.36998117e-02f,
  4.15014625e-02f, -7.48808635e-03f, -1.02642998e-01f, -5.21841757e-02f, 4.96032648e-02f, 5.29024145e-03f, -8.86946619e-02f, 1.60373375e-03f, -8.95179957e-02f, -7.49115199e-02f,
  -1.25941619e-01f, -3.21760587e-02f, 3.57821165e-03f, 1.15055628e-02f, 4.98324409e-02f, -9.59191471e-02f, 3.40530947e-02f, 1.65351816e-02f, 1.90439597e-02f, 4.20967303e-02f,
  -5.57445660e-02f, -1.55867776e-02f, -6.55395687e-02f, -1.05959460e-01f, 7.53396899e-02f, -7.54258856e-02f, -6.07659202e-03f, 2.76975855e-02f, 3.39279771e-02f, -9.18702036e-02f,
  -2.60791425e-02f, -2.35912520e-02f, -1.58286095e-02f, 7.24316165e-02f, 5.76342940e-02f, 4.63629663e-02f, 3.13112587e-02f, -5.49330525e-02f, -4.17655110e-02f, -4.25071828e-02f,
  2.46880770e-01f, -1.95451960e-01f, 3.68520394e-02f, 1.21288769e-01f, 1.48931503e-01f, 8.12891424e-02f, 1.31816998e-01f, -1.74895421e-01f, -1.66974425e-01f, -1.29786208e-01f,
  1.61932260e-01f, 1.35181785e-01f, -1.25953019e-01f, 1.10813767e-01f, 3.51442784e-01f, -8.20661187e-02f, -1.51987663e-02f, 9.63009298e-02f, -6.76301569e-02f, -1.82522889e-02f,
  -5.74852377e-02f, 8.68274719e-02f, -1.77958198e-02f, 3.72079611e-02f, 1.18304044e-01f, -1.08964657e-02f, 5.79306632e-02f, 8.09513256e-02f, 7.19575807e-02f, 1.77295521e-01f,
  9.81313661e-02f, -2.94556338e-02f, -4.50463146e-02f, 8.19220766e-03f, -6.55762628e-02f, -3.29369158e-02f, 1.26533836e-01f, 2.10092381e-01f, -2.93398313e-02f, -9.92890522e-02f,
  5.35099730e-02f, 1.28332436e-01f, -5.89375757e-02f, 4.04633842e-02f, -5.38291484e-02f, 2.88612880e-02f, -3.90309133e-02f, -6.59711361e-02f, -4.51950822e-04f, -8.11523795e-02f,
  -5.04085571e-02f, 7.11221099e-02f, -2.34721843e-02f, 5.29341176e-02f, -3.01437341e-02f, -9.30387452e-02f, -7.58136213e-02f, 9.24371108e-02f, -1.83756985e-02f, 8.70213956e-02f,
  1.00898728e-01f, -6.79340437e-02f, -2.09092386e-02f, -6.46689301e-03f, 1.94181707e-02f, -2.63427105e-02f, 1.78044691e-04f, 3.65493223e-02f, 6.01557158e-02f, 9.58617255e-02f,
  -1.39582232e-02f, -5.43658016e-03f, -3.43409143e-02f, 1.44045502e-02f, 5.74903339e-02f, -6.13478199e-03f, 8.25197995e-02f, 7.72866458e-02f, -9.53626260e-02f, 9.42099616e-02f,
  -5.81026194e-04f, 3.14376242e-02f, 2.91899405e-02f, -4.87743691e-02f, 5.79849556e-02f, 2.98366193e-02f, -3.75470798e-03f, 3.81002581e-04f, -8.79412740e-02f, -1.68878920e-02f,
  -8.54622498e-02f, -1.86420217e-01f, 3.16102244e-02f, 7.81480074e-02f, 9.44854598e-03f, 9.60984677e-02f, 3.48590650e-02f, -4.35349569e-02f, -4.50519845e-02f, -2.33857194e-03f,
  3.28810923e-02f, 8.79513174e-02f, -9.86480415e-02f, 2.19568349e-02f, -4.30301465e-02f, -1.53877676e-01f, 1.22606587e-02f, 7.58883059e-02f, -6.41705468e-02f, 5.39487600e-02f,
  -5.08355089e-02f, 1.05016202e-01f, 1.50002927e-01f, 1.06129467e-01f, 3.39529924e-02f, -8.83096755e-02f, 5.48584089e-02f, -2.02771686e-02f, -7.54241496e-02f, 8.16309005e-02f,
  2.50040710e-01f, 1.23703822e-01f, 2.22167179e-01f, 1.38333201e-01f, 4.58611511e-02f, -2.18068019e-01f, -1.62752289e-02f, 1.11496784e-01f, 2.82394260e-01f, 6.33088946e-02f,
  3.95640619e-02f, 1.06697127e-01f, 3.25212851e-02f, 1.18658096e-01f, -3.63526255e-01f, -3.91907953e-02f, -1.74678996e-01f, 8.54335502e-02f, -6.06389940e-02f, 4.91618551e-02f,
  -2.97493953e-02f, -1.39450788e-01f, -1.91393420e-01f, -1.54744670e-01f, 1.59371078e-01f, 1.23865031e-01f, -3.17885518e-01f, -1.18209243e-01f, 2.24725492e-02f, -8.69426802e-02f,
  -1.32975385e-01f, 1.54584423e-01f, 8.04009587e-02f, -8.01360533e-02f, 2.98858136e-02f, 2.62792837e-02f, 2.72014271e-02f, -5.51384650e-02f, -7.38206133e-02f, 7.07053542e-02f,
  8.82905200e-02f, -9.54046920e-02f, 2.17411648e-02f, -3.55850570e-02f, 4.76385728e-02f, 5.09040989e-02f, 1.85574725e-01f, 8.68036970e-02f, 7.50867324e-03f, 5.24278805e-02f,
  2.22793818e-01f, 4.01501842e-02f, -3.39778028e-02f, -6.96513131e-02f, 5.90077341e-02f, 2.63697915e-02f, 4.45741601e-03f, -5.72697930e-02f, -2.15014927e-02f, 1.99545901e-02f,
  -5.46289161e-02f, -5.22696190e-02f, -6.84713479e-03f, 7.88807496e-02f, 9.47769955e-02f, 1.16208270e-01f, 3.07951234e-02f, 1.21170850e-02f, 6.67598248e-02f, -2.21528951e-02f,
  -3.46924365e-02f, 1.38529226e-01f, 1.58925444e-01f, 7.81350657e-02f, 4.56896275e-02f, 9.32505652e-02f, -6.77572982e-03f, 9.35288146e-03f, -4.56738658e-02f, -6.23199530e-02f,
  4.97244634e-02f, -6.28864020e-02f, -4.78925891e-02f, -6.08267970e-02f, -1.00637831e-01f, 7.71644861e-02f, 4.81640771e-02f, 2.55789445e-03f, -5.01702502e-02f, -1.06338948e-01f,
  -9.63813737e-02f, -1.07347503e-01f, -1.44006342e-01f, 2.57082544e-02f, -4.12030369e-02f, -2.34619305e-02f, 1.89870279e-02f, 3.33220139e-02f, -5.05688749e-02f, -1.02634616e-01f,
  -7.48498440e-02f, 1.28201246e-01f, -1.58754196e-02f, -2.53425278e-02f, -7.51530454e-02f, -8.73070806e-02f, 1.76209044e-02f, -5.75482734e-02f, -5.32230623e-02f, 1.13212932e-02f,
  8.75662044e-02f, -3.55946366e-03f, 5.12735955e-02f, -9.14544091e-02f, -1.26084879e-01f, -9.99106169e-02f, -2.31952108e-02f, -1.32144438e-02f, 4.46627848e-02f, -1.12646095e-01f,
  1.29363641e-01f, 2.30195299e-01f, 2.85525352e-01f, 1.80688083e-01f, -6.30431697e-02f, -1.86772630e-01f, -2.48825267e-01f, 1.45491883e-01f, -2.40733847e-02f, -4.36582416e-02f,
  1.39017224e-01f, -1.66444713e-03f, -3.23037207e-02f, 1.21781938e-01f, -7.84318745e-02f, -4.83950973e-02f, 1.14377448e-02f, -9.14144441e-02f, 5.83159141e-02f, 6.18042611e-02f,
  5.80767281e-02f, -5.33258133e-02f, 2.16180503e-01f, 1.77058801e-01f, 2.63624638e-01f, 1.70645401e-01f, -6.67931046e-04f, 1.12821542e-01f, -1.98427401e-02f, -1.02144405e-01f,
  -9.73723754e-02f, 1.08712770e-01f, -3.24678048e-02f, 1.21335918e-02f, 9.95866302e-03f, -7.24027306e-02f, -9.52372774e-02f, 3.43026109e-02f, -5.16273640e-02f, 1.46161728e-02f,
  -2.05559917e-02f, -8.23657960e-02f, 3.88901196e-02f, 1.39258668e-01f, -2.58079078e-02f, 1.05032399e-01f, 6.04933612e-02f, -5.93540072e-02f, 1.35911303e-02f, 9.62545164e-03f,
  1.40958071e-01f, 1.06651329e-01f, -9.18783322e-02f, -5.62808849e-02f, -3.73789817e-02f, -8.07641298e-02f, -7.78419375e-02f, -1.89977195e-02f, 4.90756221e-02f, -2.92191915e-02f,
  1.31294370e-01f, -4.39970978e-02f, 1.19473465e-01f, -9.08982456e-02f, 2.95973513e-02f, -2.75637377e-02f, 3.76010127e-02f, -3.28212120e-02f, 4.66591157e-02f, -6.17124550e-02f,
  7.61534795e-02f, -5.91400489e-02f, 6.44775480e-02f, -4.77494225e-02f, 6.49084449e-02f, -5.75008653e-02f, 1.13733551e-02f, 2.68303454e-02f, 7.35990778e-02f, 5.64000420e-02f,
  -3.75872254e-02f, -6.67512864e-02f, 9.29393098e-02f, 3.28573808e-02f, 1.01658842e-02f, -8.62640440e-02f, -2.18164418e-02f, 9.10753384e-02f, -1.26286279e-02f, 1.07983001e-01f,
  -2.89701939e-01f, -1.25293359e-01f, -6.55350164e-02f, -6.83756247e-02f, 6.67038001e-03f, -6.64228275e-02f, -5.00341095e-02f, -3.42167728e-03f, -4.60987836e-02f, 1.09353572e-01f,
  -1.92649558e-01f, 8.25170241e-03f, -5.77725172e-02f, 1.59854610e-02f, -6.14057742e-02f, -6.24655820e-02f, -1.35379866e-01f, -1.45562023e-01f, -1.41699076e-01f, -1.35473944e-02f,
  1.24282174e-01f, -3.59587744e-02f, -1.16876841e-01f, -2.26055868e-02f, -1.12735964e-02f, -4.74257022e-02f, 5.32743931e-02f, -2.65597701e-02f, 5.82420155e-02f, -4.90879752e-02f,
  -4.39852268e-01f, 1.80548176e-01f, -2.86612004e-01f, 1.08105972e-01f, -2.07543164e-01f, 1.03942998e-01f, 2.25997284e-01f, 6.98452741e-02f, -7.17210025e-03f, 2.76935548e-01f,
  2.05211595e-01f, -1.75364226e-01f, 7.36735612e-02f, 3.11465502e-01f, -1.17610611e-01f, 2.55628616e-01f, 1.77268386e-01f, 1.08240932e-01f, 7.57062808e-03f, -2.05937754e-02f,
  -5.01567079e-03f, 1.01096354e-01f, 8.92423913e-02f, 1.09023668e-01f, -2.23325612e-03f, -1.14918083e-01f, 5.82854114e-02f, -8.06924403e-02f, 1.38643131e-01f, -7.44229257e-02f,
  -1.39243500e-02f, -6.55470556e-03f, -1.10254791e-02f, -1.93072297e-02f, -9.30439755e-02f, 1.59982163e-02f, 1.20131271e-02f, -1.54828042e-01f, -6.59077615e-02f, -5.75703345e-02f,
  -8.95738322e-03f, -8.27540383e-02f, 2.59680394e-02f, -3.73158343e-02f, -1.85153093e-02f, -4.01997603e-02f, 3.29599716e-02f, 6.78339899e-02f, -2.21794900e-02f, -3.96193303e-02f,
  -5.79383806e-04f, 1.06193135e-02f, 3.26641947e-02f, 5.58332913e-02f, 4.66693845e-03f, -1.48633793e-02f, 2.43570525e-02f, -1.68148234e-01f, 1.14329765e-02f, -5.29957041e-02f,
  -7.61602521e-02f, -7.22192153e-02f, 5.15056178e-02f, 1.26705216e-02f, -4.21986580e-02f, 3.67470123e-02f, -2.04498954e-02f, -1.40466169e-02f, 4.54992652e-02f, 3.48681323e-02f,
  -2.14815177e-02f, 7.09493645e-03f, 7.93418102e-03f, -2.31728535e-02f, 5.75397983e-02f, -1.89809538e-02f, -5.98651059e-02f, 2.10687611e-02f, 4.40714769e-02f, 2.52002981e-02f,
  -1.43712452e-02f, -1.05521902e-01f, 4.28072810e-02f, 1.19750060e-01f, 2.85313334e-02f, -4.67477590e-02f, 4.50855270e-02f, -5.07894754e-02f, 2.19356436e-02f, 1.52028969e-03f,
  1.97543204e-01f, 1.14290610e-01f, -4.17246446e-02f, -5.82515709e-02f, -1.77667488e-03f, 3.35544581e-03f, 9.14403424e-02f, 5.42623959e-02f, -8.54334421e-03f, 3.50936428e-02f,
  -6.77288473e-02f, 8.83233082e-03f, 4.25740071e-02f, -5.78911342e-02f, -5.23509569e-02f, 3.55781354e-02f, 6.84202909e-02f, -7.49762449e-03f, -3.60361300e-02f, -1.01402672e-02f,
  -2.16635950e-02f, 3.90923545e-02f, -3.31391804e-02f, 3.85019071e-02f, -6.25779852e-02f, -2.77824122e-02f, -9.19120328e-04f, 1.15740485e-02f, -9.40352795e-04f, -1.08786626e-02f,
  2.17016637e-01f, -5.90655990e-02f, -5.39997816e-02f, -6.22061640e-02f, 1.74176265e-02f, 3.94430645e-02f, -1.18391819e-01f, -3.83300930e-02f, -3.72203052e-01f, -2.63448227e-02f,
  1.07749522e-01f, -1.24432631e-01f, -5.11708781e-02f, 7.85148963e-02f, 1.62855372e-01f, -1.18011817e-01f, -3.53953689e-02f, 4.03780781e-04f, -8.40997994e-02f, 2.11917043e-01f,
  -5.67643624e-03f, 2.35672563e-01f, -1.38496957e-03f, 2.21836641e-01f, 2.31033981e-01f, 1.44481435e-01f, 1.19630754e-01f, 1.02786608e-01f, 7.75279403e-02f, 7.95287266e-02f,
  4.84761186e-02f, 2.20387988e-02f, -7.91662857e-02f, -3.01573370e-02f, 4.91532795e-02f, 1.12566851e-01f, 1.03913739e-01f, -4.26866747e-02f, 8.27147509e-04f, -1.36537313e-01f,
  1.19191252e-01f, -9.46317147e-03f, 1.41022131e-02f, -6.48803413e-02f, -6.84938487e-03f, -1.14006229e-01f, -9.72387418e-02f, -2.95109153e-02f, -1.05784915e-01f, 3.80977802e-02f,
  -5.43394648e-02f, 7.65516423e-03f, -3.88629846e-02f, 8.10364783e-02f, -9.82020050e-03f, -8.78586099e-02f, 2.63491124e-02f, -3.52806486e-02f, -5.30459881e-02f, 1.87510327e-02f,
  6.23685718e-02f, -2.20772941e-02f, 6.25753924e-02f, -3.49832922e-02f, 4.74540703e-03f, 2.66942699e-02f, -5.29606603e-02f, -3.87693085e-02f, 2.53928881e-02f, -2.12053098e-02f,
  1.30151417e-02f, 1.69385336e-02f, -8.40319879e-03f, -1.63135882e-02f, 1.30154297e-01f, -1.03250995e-01f, 1.08264126e-02f, 6.39469689e-03f, 6.94982260e-02f, -4.44263034e-02f,
  -1.68869514e-02f, 5.29967099e-02f, 2.45334916e-02f, -9.14073288e-02f, -7.28907716e-03f, -3.07689197e-02f, 2.35842690e-02f, 3.10456995e-02f, -1.11369686e-02f, -2.33333539e-02f,
  6.27243146e-02f, 1.86207071e-01f, -1.58543661e-02f, -4.09136713e-02f, 2.89532170e-02f, 1.57376245e-01f, -2.51641702e-02f, -4.63964045e-02f, -7.40020815e-03f, 4.05698083e-02f,
  1.07723914e-01f, -1.24242809e-02f, 9.85529739e-03f, 1.03996746e-01f, 1.67608187e-02f, 5.07987104e-02f, 1.37488857e-01f, -7.80625120e-02f, 7.29324445e-02f, 8.16537738e-02f,
  3.63388881e-02f, 3.31242792e-02f, 8.33612029e-03f, 8.67931079e-03f, 2.68805604e-02f, 6.90230206e-02f, 7.49407038e-02f, -4.04848233e-02f, 4.55086976e-02f, -3.64987105e-02f,
  2.44478196e-01f, -3.27962160e-01f, -2.65122116e-01f, -4.47800756e-02f, 1.78731322e-01f, 1.55986756e-01f, 1.77386366e-02f, -8.45122263e-02f, -1.58217371e-01f, -1.30150676e-01f,
  9.44242924e-02f, -2.65844222e-02f, -2.94531643e-01f, -5.31366765e-02f, 1.16416439e-01f, -2.64972389e-01f, 7.01051876e-02f, 1.27645701e-01f, -1.13393731e-01f, 2.77181640e-02f,
  1.18175052e-01f, 2.82555670e-01f, -5.37026338e-02f, 1.47872612e-01f, 1.62238151e-01f, -1.11446299e-01f, 2.38102421e-01f, -4.37051952e-02f, 2.41214514e-01f, 1.52188018e-01f,
  7.86985233e-02f, -1.28579915e-01f, 1.52594689e-02f, 7.67903775e-02f, -3.43744680e-02f, 5.96811958e-02f, 4.75710779e-02f, 2.75527295e-02f, -4.83913496e-02f, -8.73534605e-02f,
  -2.15830747e-02f, 1.22996047e-02f, -1.37347989e-02f, 7.42858946e-02f, 9.08169225e-02f, -2.41404828e-02f, -6.57604709e-02f, -3.30014527e-02f, -1.41457438e-01f, 4.23706621e-02f,
  -1.68774039e-01f, -9.42255631e-02f, 4.62715998e-02f, -3.29910256e-02f, -1.25456795e-01f, -1.96396317e-02f, -4.39248197e-02f, -1.11952778e-02f, -2.85685882e-02f, 1.23888850e-02f,
  4.22321968e-02f, 8.48484971e-03f, 3.45067307e-02f, 2.65963953e-02f, 5.15248179e-02f, -3.52667570e-02f, 2.55552810e-02f, -1.22277133e-01f, 2.22077463e-02f, 5.66825457e-02f,
  5.58067532e-03f, -1.22639783e-01f, -6.69216216e-02f, 6.27868101e-02f, -6.46504050e-04f, 7.65533969e-02f, 5.33060506e-02f, -2.26594842e-04f, -1.57901019e-01f, -1.37462795e-01f,
  2.52435151e-02f, 3.30388024e-02f, -2.02335045e-03f, 9.25919265e-02f, -7.37906322e-02f, 6.43291473e-02f, 2.73243207e-02f, -2.53193872e-03f, -2.51595750e-02f, 8.79876837e-02f,
  1.97189189e-02f, -6.39668331e-02f, -1.15829669e-01f, 4.60981168e-02f, -1.49112448e-01f, -1.89727675e-02f, 7.99749047e-03f, -1.31510943e-02f, -2.34953407e-02f, 2.69495193e-02f,
  -1.33944927e-02f, 2.59629432e-02f, 9.60383490e-02f, -6.80343956e-02f, 1.17042787e-01f, -3.98592912e-02f, -5.35595082e-02f, -6.75422419e-03f, 3.89332930e-03f, -8.03369358e-02f,
  1.31579816e-01f, -1.36551121e-02f, -1.00746997e-01f, -9.64031741e-02f, -1.55734560e-02f, 9.39375386e-02f, -4.36183549e-02f, 3.40830274e-02f, 1.67066809e-02f, -8.22584853e-02f,
  1.52805433e-01f, -1.72774628e-01f, -2.87231445e-01f, -8.04901049e-02f, 1.70373634e-01f, 2.33192027e-01f, 5.61436936e-02f, -3.05273123e-02f, -2.36817420e-01f, 1.17712572e-01f,
  1.01422153e-01f, -4.86584287e-03f, -1.22406438e-01f, 8.67175460e-02f, 5.00693545e-02f, -1.70141354e-01f, 1.34587884e-01f, -1.89791638e-02f, -1.74010441e-01f, -1.73014449e-03f,
  -1.80614193e-03f, 2.32089907e-01f, -7.23766237e-02f, 8.40741768e-02f, 1.78124145e-01f, -1.54661968e-01f, 6.59453571e-02f, -3.75113785e-02f, 9.30134282e-02f, 1.21280067e-01f,
  -6.38040854e-03f, -6.93355352e-02f, -8.03619996e-02f, -8.63741562e-02f, 1.11813985e-01f, 1.43345490e-01f, 7.33751804e-02f, 9.18867290e-02f, 2.86648422e-02f, 7.87697267e-03f,
  1.23320736e-01f, -8.64401683e-02f, 6.37319637e-03f, -3.35084796e-02f, 6.96229339e-02f, 5.43836784e-03f, -9.79866087e-02f, -2.70271711e-02f, -6.73956126e-02f, 1.02208443e-02f,
  -1.33538357e-04f, -8.95022822e-04f, -1.00266539e-01f, -7.00170472e-02f, -7.38640353e-02f, -1.83063559e-02f, -9.68142226e-02f, 6.40448034e-02f, 7.24603459e-02f, 1.30118877e-02f,
  8.79841745e-02f, -1.26801459e-02f, 1.63491130e-01f, 3.56474593e-02f, -5.05200634e-03f, -3.65837626e-02f, 4.83384915e-03f, -3.89361307e-02f, -5.95404729e-02f, -1.89345405e-02f,
  4.28561606e-02f, 4.41515334e-02f, 6.61030486e-02f, 3.68340034e-03f, -2.26829853e-02f, 5.90267181e-02f, 6.62446097e-02f, 2.14608833e-02f, -1.09437434e-02f, -1.18918773e-02f,
  -6.41801804e-02f, -3.49626802e-02f, 5.95177487e-02f, 2.42045689e-02f, -1.30471230e-01f, 1.52074188e-01f, 7.46234655e-02f, -9.55307484e-03f, -8.05158913e-02f, 9.03509706e-02f,
  8.55627880e-02f, 2.05008775e-01f, -5.38456589e-02f, 2.53875852e-02f, -1.10173947e-03f, 2.64785942e-02f, -4.51449864e-02f, 4.30759303e-02f, 9.79952235e-03f, 1.11719035e-01f,
  1.68366373e-01f, -5.07251807e-02f, 7.52444714e-02f, -2.70775370e-02f, -5.74172586e-02f, 1.55404925e-01f, -3.49682686e-03f, -1.18902158e-02f, -6.04853816e-02f, -1.90744735e-02f,
  8.50773975e-02f, 1.71696559e-01f, -1.07990414e-01f, 2.66408194e-02f, 6.42542392e-02f, 8.37646518e-03f, 4.57954928e-02f, 9.43872631e-02f, 5.24149761e-02f, -2.64765862e-02f,
  -1.49549961e-01f, -1.35974139e-02f, -2.58258402e-01f, -2.96425615e-02f, -5.75605556e-02f, -9.57076997e-02f, -1.57267109e-01f, -1.25989402e-02f, -4.63269614e-02f, 2.15239286e-01f,
  -5.33686094e-02f, -4.94784378e-02f, -1.97884794e-02f, -1.03840321e-01f, -2.67508209e-01f, 8.59711170e-02f, -2.33188108e-01f, -8.28570575e-02f, 1.29527032e-01f, -4.84111831e-02f,
  -1.05433963e-01f, -5.82368560e-02f, -1.65113300e-01f, 1.21294837e-02f, -1.60647988e-01f, 7.96356648e-02f, 9.87235382e-02f, 4.25555520e-02f, -6.47419915e-02f, -5.67179546e-02f,
  -2.20786501e-02f, -1.69752836e-02f, 5.43061085e-02f, 4.16635945e-02f, -1.02020867e-01f, -1.67560379e-03f, -1.47126298e-02f, 7.61891343e-03f, -9.29569602e-02f, 1.01630278e-02f,
  -7.39384890e-02f, 5.39429160e-03f, -1.15955742e-02f, 2.19235476e-03f, -1.23016275e-01f, -5.37910536e-02f, 2.01075766e-02f, -1.12703620e-02f, 3.38984989e-02f, -5.98530471e-03f,
  -1.05278030e-01f, -5.41444086e-02f, 3.97978015e-02f, 4.66620512e-02f, -2.94611696e-02f, -2.37762649e-03f, 1.04757234e-01f, -9.18275192e-02f, -1.36662088e-02f, -4.15215231e-02f,
  2.27148924e-03f, -6.20501377e-02f, -2.56215921e-03f, -4.59301695e-02f, 4.43660021e-02f, 2.98206639e-02f, -3.14006619e-02f, 1.90289356e-02f, -4.19420488e-02f, 5.01419343e-02f,
  3.31652910e-02f, 5.02469912e-02f, 9.67866480e-02f, -6.39928579e-02f, -1.01063497e-01f, -2.61685858e-03f, -8.40726420e-02f, 7.39365742e-02f, -2.13969629e-02f, -1.15876019e-01f,
  -5.93122968e-04f, -2.21572798e-02f, -6.01174198e-02f, 6.14507161e-02f, -7.56334737e-02f, -5.05219027e-02f, 7.34353613e-04f, -9.51347724e-02f, 7.19122514e-02f, 5.59906512e-02f,
  3.37017924e-02f, 6.48712814e-02f, 1.72741376e-02f, -1.03911152e-02f, 4.86715250e-02f, 4.70471615e-03f, 3.65794860e-02f, 1.11639383e-03f, 2.16629263e-02f, -7.77881294e-02f,
  -9.10789594e-02f, 6.48891851e-02f, 9.46404412e-02f, -3.73402461e-02f, 2.59036897e-03f, -5.99324591e-02f, 3.39323096e-02f, 8.67142007e-02f, 8.22638348e-02f, -5.50336856e-03f,
  5.40318266e-02f, 1.16547449e-02f, 1.73180312e-01f, 2.30089128e-02f, 1.91094875e-01f, -6.59425603e-03f, -1.11120697e-02f, -4.15256917e-02f, -2.14115735e-02f, -5.92768937e-02f,
  1.34994388e-02f, -2.06937477e-01f, -2.55460739e-01f, -1.89467534e-01f, -2.51393408e-01f, -2.27662206e-01f, -2.82525748e-01f, -2.61080712e-01f, 2.93759927e-02f, -1.08927749e-02f,
  -1.30000636e-01f, 7.85100460e-02f, 1.23574987e-01f, -2.20945328e-01f, 1.27518266e-01f, 3.21447462e-01f, -1.70616359e-01f, -2.18165535e-02f, -3.28264534e-02f, -1.95698872e-01f,
  -5.42174019e-02f, -1.55818373e-01f, -5.94700538e-02f, -1.30377516e-01f, -3.84832621e-01f, -1.33348063e-01f, 5.69874756e-02f, -2.34090745e-01f, -2.17719331e-01f, -7.85557330e-02f,
  -1.56435117e-01f, -3.17236632e-02f, -4.46557291e-02f, 7.35937059e-02f, -1.41637385e-01f, -2.93355081e-02f, -9.01459754e-02f, 4.51985374e-02f, -2.84479372e-02f, 2.27939449e-02f,
  6.83724210e-02f, 3.08271199e-02f, -1.40173629e-01f, 6.32245615e-02f, -8.26348141e-02f, -2.92205345e-02f, 9.22526121e-02f, -9.01569054e-02f, 1.27564315e-02f, -2.90902685e-02f,
  -1.99500304e-02f, -5.64181134e-02f, -8.91969278e-02f, 6.22773059e-02f, -3.65247130e-02f, -1.09032989e-01f, 5.28030097e-02f, -6.85841441e-02f, -5.39808534e-02f, -7.27879852e-02f,
  1.92010198e-02f, -8.61677229e-02f, 2.98507120e-02f, -3.43470164e-02f, -6.22927509e-02f, 2.02167984e-02f, -8.56082663e-02f, 6.25488237e-02f, 8.53015631e-02f, 8.40230361e-02f,
  3.99108231e-02f, -2.30845455e-02f, 5.86615354e-02f, -3.90741527e-02f, -1.13078142e-02f, 9.54752043e-02f, -6.88699335e-02f, 3.10475435e-02f, -7.47097060e-02f, -3.74044701e-02f,
  -5.12569696e-02f, -3.10458504e-02f, -3.16254571e-02f, -8.13711062e-03f, -1.44933358e-01f, 1.08593330e-02f, -1.42350756e-02f, 5.33209443e-02f, -3.35410098e-03f, -1.49266822e-02f,
  -9.47648510e-02f, 5.23808785e-02f, -4.88517880e-02f, 5.85589111e-02f, 4.18322859e-03f, -3.09213568e-02f, 1.40984869e-02f, 3.11572081e-03f, -9.22570154e-02f, 5.87204173e-02f,
  -1.32466733e-01f, -4.32283152e-03f, -2.17909981e-02f, -2.50262432e-02f, -2.46330779e-02f, -6.13427497e-02f, -2.12144926e-02f, 9.13406536e-02f, -1.73922814e-02f, -6.96986839e-02f,
  -3.67210098e-02f, 1.08898945e-01f, 9.68515649e-02f, 1.79501064e-02f, -1.64859649e-02f, -8.78659338e-02f, -2.73678289e-03f, -5.49905747e-03f, 1.80719439e-02f, -1.78719703e-02f,
  -1.51897937e-01f, 4.40278044e-03f, -5.54493675e-03f, -4.53166999e-02f, 2.57359184e-02f, -8.49790499e-02f, -1.17263809e-01f, -4.73817401e-02f, -5.05164377e-02f, 3.75985987e-02f,
  9.58535448e-03f, -3.03017087e-02f, -6.51494041e-02f, -1.76031932e-01f, -1.12159863e-01f, -4.01419997e-02f, -3.38788889e-02f, -6.94202865e-03f, 1.52239546e-01f, 5.30969910e-02f,
  2.51938794e-02f, -7.86154270e-02f, 8.64328071e-02f, 1.06594421e-01f, 2.44874787e-02f, 9.84132886e-02f, 1.21652462e-01f, 3.94541174e-02f, 6.50443211e-02f, 3.92424427e-02f,
  -1.03048488e-01f, -3.43483835e-02f, -3.35985310e-02f, 6.03708588e-02f, -9.41821486e-02f, 8.03455263e-02f, -1.35356169e-02f, -4.28846329e-02f, 4.72510792e-03f, -5.11976704e-03f,
  2.05654763e-02f, -5.11466935e-02f, -5.28037846e-02f, -3.33624855e-02f, 2.44693533e-02f, -3.60045806e-02f, 1.04062520e-02f, 5.75434193e-02f, -7.71389604e-02f, -6.84039891e-02f,
  -9.90330591e-04f, 2.42957864e-02f, 1.35854065e-01f, -1.32099763e-01f, 3.35074887e-02f, -1.50208361e-03f, 3.35430056e-02f, -6.72355741e-02f, 2.77416762e-02f, 2.27364507e-02f,
  2.96548475e-02f, 3.16108726e-02f, -7.31047243e-02f, 5.91788925e-02f, -3.41054685e-02f, -9.23313666e-03f, 4.60643023e-02f, -1.97328199e-02f, -3.31711285e-02f, 2.22774013e-03f,
  -7.51557499e-02f, -2.95631308e-02f, -6.65218895e-03f, 1.36738122e-01f, 4.89481911e-02f, -5.98309487e-02f, -1.10289678e-02f, 7.45699182e-02f, 1.08680427e-02f, -3.35535705e-02f,
  -6.02382906e-02f, -4.14767209e-03f, 1.97907537e-02f, -8.97061545e-03f, -6.28569871e-02f, -6.57559857e-02f, 1.31777795e-02f, 1.85315702e-02f, -4.88949232e-02f, 5.03184497e-02f,
  1.92229405e-01f, 2.25053832e-01f, -9.53417048e-02f, -4.57555801e-02f, 4.16498929e-02f, 5.20260744e-02f, -1.42659754e-01f, -1.37011381e-02f, 1.63664091e-02f, 1.12999059e-01f,
  7.97707364e-02f, -4.37596813e-02f, 2.66404655e-02f, -1.19423661e-02f, -1.70576889e-02f, 5.04117832e-02f, -1.43602667e-02f, -1.35483472e-02f, 9.19975620e-03f, 2.39024330e-02f,
  7.05564767e-02f, -5.92380622e-03f, -6.93205744e-02f, 3.46505782e-03f, 8.81600529e-02f, -1.46479504e-02f, 2.77093016e-02f, 8.17293394e-03f, -2.31160130e-03f, -9.73246712e-03f,
  -3.06931436e-02f, 1.64407805e-01f, 1.23202160e-01f, 2.53764868e-01f, -3.48736942e-02f, -2.92362034e-01f, -2.65820414e-01f, 1.93784431e-01f, -1.09742448e-01f, -1.37719139e-01f,
  1.10961117e-01f, -1.17200740e-01f, -4.27927217e-03f, 1.15436897e-01f, 7.26580769e-02f, 1.03190526e-01f, 1.50367469e-02f, -8.61093923e-02f, -6.93361927e-03f, 1.63706049e-01f,
  1.65125608e-01f, 1.54076383e-01f, 2.21432999e-01f, 1.08051516e-01f, 4.58776206e-02f, 1.61116607e-02f, 1.25799149e-01f, 9.56995785e-02f, 1.74977109e-02f, -1.18312210e-01f,
  2.89996695e-02f, 7.57847428e-02f, 3.53300385e-02f, -4.44902740e-02f, -2.95029860e-02f, -7.47293755e-02f, -5.95317520e-02f, -5.03707826e-02f, -2.17025504e-02f, -7.45311007e-02f,
  -8.74796584e-02f, -7.21137524e-02f, -4.65020537e-02f, -1.02054693e-01f, -4.18461524e-02f, 5.05053997e-02f, 6.12335354e-02f, -8.75214338e-02f, -6.02902137e-02f, 5.00040017e-02f,
  2.89578307e-02f, 5.03186285e-02f, -4.18929234e-02f, -6.62593842e-02f, 2.04365738e-02f, -7.53296120e-03f, -5.35236523e-02f, 6.71152696e-02f, -6.25902787e-02f, 2.32330174e-03f,
  -7.34245358e-03f, -7.74830282e-02f, -3.08094565e-02f, -9.73365381e-02f, -9.17426590e-03f, -2.94316746e-02f, -7.61367008e-02f, -6.08024672e-02f, -6.11399785e-02f, 2.07080338e-02f,
  5.26958797e-03f, 4.95393388e-02f, 2.39365771e-02f, -4.44905320e-03f, 2.93000005e-02f, 5.88601679e-02f, 7.57628456e-02f, -2.21525878e-02f, 4.14484274e-03f, 2.20466498e-02f,
  5.79874665e-02f, -3.75352823e-03f, -3.41743976e-02f, 1.42315272e-02f, -7.29584768e-02f, -1.66766886e-02f, 6.40382394e-02f, -2.37252563e-02f, 1.14636742e-01f, 2.00464837e-02f,
  8.30956176e-02f, 1.84774518e-01f, 2.63954010e-02f, -7.00846873e-03f, -5.55991083e-02f, -3.78558598e-02f, 5.08862175e-02f, 5.82608115e-03f, -4.31687832e-02f, -1.95992924e-02f,
  2.53650062e-02f, 1.44216772e-02f, -4.95309271e-02f, -2.10982896e-02f, 4.58049253e-02f, -4.38263305e-02f, -2.52576359e-02f, -8.72785226e-02f, 1.68138985e-02f, 8.21593404e-02f,
  -3.19369957e-02f, -7.88111985e-02f, -4.28297371e-02f, -7.04732910e-02f, 3.48858885e-03f, -1.39886260e-01f, 1.66722219e-02f, -3.08896452e-02f, 5.16716503e-02f, -4.21238504e-03f,
  1.82987764e-01f, -2.07030222e-01f, -1.02670476e-01f, 7.13859871e-02f, 8.77896622e-02f, 3.07837408e-02f, 1.26069531e-01f, -1.30421311e-01f, -1.42003983e-01f, -5.61975315e-02f,
  1.01140425e-01f, 4.14000116e-02f, 5.01445644e-02f, 1.84872106e-01f, 3.57693464e-01f, -1.79464277e-02f, 1.44359693e-01f, 4.30260114e-02f, -4.49369922e-02f, -1.02787651e-01f,
  1.23964651e-02f, 2.28915825e-01f, 1.47532523e-01f, 6.73632920e-02f, 1.24754876e-01f, 5.21670282e-02f, 1.20432876e-01f, 6.02132529e-02f, 1.36419479e-02f, 1.20475776e-01f,
  9.52247530e-02f, -4.78951447e-02f, 4.70835268e-02f, -7.45052844e-02f, -2.34844582e-03f, 2.05595922e-02f, 1.26806065e-01f, 1.08874738e-01f, 1.88888256e-02f, -7.90731907e-02f,
  -1.38160929e-01f, 1.09063067e-01f, -1.14670329e-01f, 2.82328613e-02f, 1.76296942e-02f, -9.62375328e-02f, -4.09121178e-02f, 4.35319059e-02f, -5.76847009e-02f, -1.87162142e-02f,
  1.45107107e-02f, -9.16645527e-02f, -4.86879572e-02f, 2.70735547e-02f, -1.15066078e-02f, 1.01281973e-02f, -1.32497713e-01f, -2.99382973e-02f, -1.28055036e-01f, -1.04756497e-01f,
  -1.49932050e-04f, 1.37286231e-01f, -5.22165932e-02f, 9.27883387e-02f, -6.20123819e-02f, 7.45136067e-02f, 2.46047806e-02f, 2.96341740e-02f, 3.54665257e-02f, -4.80745174e-02f,
  -3.21609639e-02f, 9.15326253e-02f, 7.14705512e-02f, 7.75803067e-03f, -1.31651508e-02f, -1.29104108e-01f, 1.08345836e-01f, 1.60541441e-02f, 3.35787237e-02f, 7.05164000e-02f,
  4.33737487e-02f, -9.11811441e-02f, -5.96336573e-02f, 2.07413174e-03f, 3.05822422e-03f, 1.05627952e-02f, -6.52107177e-03f, -3.65721039e-03f, -7.68818110e-02f, -8.24652053e-03f,
  -3.35883275e-02f, -1.13441207e-01f, -3.91012989e-02f, 3.45999445e-03f, 1.93020096e-03f, 5.63079417e-02f, 1.56051572e-02f, -3.81958559e-02f, -1.13302626e-01f, -9.81681943e-02f,
  -7.31826946e-02f, -6.69624954e-02f, -1.16334885e-01f, -9.34629589e-02f, 5.00723757e-02f, -8.97284821e-02f, 2.56956238e-02f, -1.18726380e-01f, -6.92262948e-02f, -9.71959829e-02f,
  1.03150047e-02f, -4.25329767e-02f, -2.36098412e-02f, 3.69597450e-02f, -3.22310589e-02f, -8.60662386e-03f, -8.02422985e-02f, 2.25659576e-03f, 3.60201026e-04f, -4.85136509e-02f,
  -1.09106764e-01f, -5.04406616e-02f, -1.56184249e-02f, -9.64830890e-02f, 1.42266182e-02f, 5.92518486e-02f, -1.22026414e-01f, 4.84050922e-02f, -1.99464515e-01f, 1.66472569e-01f,
  4.95655425e-02f, -1.63748771e-01f, 2.66843960e-02f, -2.56428182e-01f, -3.56620014e-01f, -1.65797099e-01f, -1.80235654e-01f, -6.63922057e-02f, -3.75814512e-02f, 1.68290790e-02f,
  -5.29723093e-02f, -1.28045619e-01f, -1.02469631e-01f, 5.23351245e-02f, -5.58533482e-02f, 1.64146036e-01f, 5.25882393e-02f, 1.12896137e-01f, 1.18607856e-01f, -1.17606692e-01f,
  -1.32403255e-01f, -1.00212678e-01f, 2.27194354e-02f, 4.93810400e-02f, -4.35315212e-03f, 1.66269660e-01f, 8.12390894e-02f, -4.32872996e-02f, 2.98271049e-02f, -7.07566962e-02f,
  9.44949538e-02f, -2.62077246e-02f, -6.56828433e-02f, 2.18007322e-02f, 7.66418735e-03f, -2.75132302e-02f, -1.15680218e-01f, 8.28155950e-02f, -9.61179193e-03f, -9.24415141e-02f,
  -1.21217236e-01f, -1.54447770e-02f, 1.20981626e-01f, 1.03636356e-02f, -8.20292905e-03f, 2.50038672e-02f, 6.83479803e-03f, 7.58284554e-02f, 2.34500295e-03f, 3.74735743e-02f,
  5.37464023e-02f, 1.19967893e-01f, -5.38361967e-02f, 1.73779707e-02f, 6.72791526e-02f, 8.13959986e-02f, 4.52114493e-02f, -1.93906501e-02f, -1.35943843e-02f, 3.35733071e-02f,
  1.65011771e-02f, 3.29300208e-04f, -1.61537826e-02f, -2.72222590e-02f, 5.60306534e-02f, -3.92406844e-02f, 1.19714625e-01f, 1.96107477e-02f, -6.50690794e-02f, -7.85530433e-02f,
  -2.33579203e-02f, -5.16896211e-02f, -3.54992151e-02f, -9.29070637e-03f, -3.91252935e-02f, 7.51197264e-02f, 4.04611081e-02f, 5.96562326e-02f, -8.78518522e-02f, 2.52792090e-02f,
  1.05480179e-02f, 1.64173737e-01f, -6.88607767e-02f, -1.40784113e-02f, 7.67117441e-02f, 1.03479452e-01f, -1.15066610e-01f, 3.17041315e-02f, -6.60235714e-03f, 4.99026477e-02f,
  1.41282260e-01f, 8.42517987e-02f, 8.97122324e-02f, 8.39306340e-02f, 1.97630506e-02f, 1.20861404e-01f, 6.64320588e-02f, 5.80536649e-02f, 1.12670725e-02f, -7.41872713e-02f,
  1.32151231e-01f, 4.88334969e-02f, 2.46319044e-02f, -1.64848734e-02f, 6.15583286e-02f, 9.72027555e-02f, 4.00567278e-02f, 4.88621509e-03f, 7.84767941e-02f, -8.16257969e-02f,
  2.52482533e-01f, -4.07276481e-01f, -6.51220679e-02f, 1.37620479e-01f, 2.35233724e-01f, -2.72041876e-02f, 1.20768894e-03f, -2.89248358e-02f, 6.43494204e-02f, -1.87011674e-01f,
  1.04544036e-01f, -1.71792522e-01f, -2.41749853e-01f, 1.16187662e-01f, 3.44048887e-01f, -1.19226135e-01f, 1.01581544e-01f, 7.48604536e-02f, -1.13653965e-01f, 6.56813234e-02f,
  2.14088544e-01f, 2.10315242e-01f, 8.25891495e-02f, 9.08400938e-02f, 1.53394565e-01f, 8.09004605e-02f, 8.63290951e-02f, 3.89616168e-03f, 6.23215511e-02f, 1.73917904e-01f,
  -6.02056496e-02f, 6.81410879e-02f, -5.29150963e-02f, -6.12823591e-02f, -8.96464810e-02f, -5.43866977e-02f, -3.68938036e-02f, 3.15515622e-02f, 9.15445983e-02f, 1.64388437e-02f,
  -1.08062603e-01f, 2.04626359e-02f, 7.91149437e-02f, 8.28038305e-02f, -2.20835861e-02f, 6.73478842e-02f, 1.11091398e-02f, -2.01844722e-02f, 5.69768529e-03f, 1.42913600e-02f,
  -2.42018625e-02f, -1.35056265e-02f, -1.13535039e-01f, 2.64098272e-02f, 6.90250769e-02f, -3.22098918e-02f, 3.11208889e-02f, 1.33787990e-02f, -1.18979178e-02f, -1.84492953e-02f,
  9.80656520e-02f, -1.18982218e-01f, 9.06450450e-02f, 2.43412964e-02f, -2.27880068e-02f, 3.80335227e-02f, -3.62216905e-02f, 9.96361375e-02f, -6.43165186e-02f, -3.45931612e-02f,
  -5.65603143e-03f, -6.49872720e-02f, -7.14757815e-02f, -5.50284795e-02f, -6.94353729e-02f, -4.15976420e-02f, -7.35758096e-02f, -5.08225039e-02f, -3.41919325e-02f, -1.63779538e-02f,
  -8.66927113e-03f, 1.28451437e-01f, -3.60624902e-02f, 5.10907844e-02f, 4.98382887e-03f, -5.01677394e-02f, -6.87574074e-02f, -1.88615154e-02f, 3.39450352e-02f, 4.59339581e-02f,
  -4.31485772e-01f, -2.91227818e-01f, -5.88176884e-02f, 6.06310845e-04f, 4.61505353e-02f, -9.98924598e-02f, 1.98544580e-02f, -6.27903491e-02f, -1.03874333e-01f, 7.26525933e-02f,
  -3.99999470e-02f, -1.76593084e-02f, -5.16555496e-02f, 5.75721599e-02f, -4.51186970e-02f, -3.47572416e-02f, -5.51106632e-02f, -1.01482429e-01f, 1.48137594e-02f, -1.28725106e-02f,
  -9.86074507e-02f, -3.96268889e-02f, 1.68242514e-01f, 1.47606596e-01f, -4.65625562e-02f, -6.48173830e-03f, -3.34504843e-02f, -5.67323044e-02f, 6.33193273e-03f, -1.67845506e-02f,
  -2.00784981e-01f, 2.72456724e-02f, 1.08306453e-01f, 1.25015751e-01f, -2.08116159e-01f, -2.12663651e-01f, -1.80810422e-01f, 1.48350567e-01f, 1.40335662e-02f, 3.45164388e-02f,
  1.61038518e-01f, -1.00444918e-02f, 1.04611136e-01f, 4.20932211e-02f, -7.14626387e-02f, 1.25841156e-01f, -1.32242795e-02f, -3.23311687e-02f, 2.11446397e-02f, -3.06020118e-02f,
  6.00603893e-02f, -6.21605143e-02f, 1.08856268e-01f, 8.04611444e-02f, -1.55010536e-01f, 1.15935631e-01f, -2.28733080e-03f, -8.16083252e-02f, 3.75412777e-03f, -1.25900954e-01f,
  -1.28083108e-02f, 1.26278207e-01f, 1.61365494e-02f, 3.69408168e-02f, 8.21586475e-02f, -4.33006696e-02f, -1.62244793e-02f, -1.95864365e-02f, 6.53420836e-02f, -8.07593390e-03f,
  -8.52979347e-02f, -5.17240874e-02f, 5.30628599e-02f, -1.22963093e-01f, -1.07797526e-01f, 5.58524765e-02f, -5.54662608e-02f, -1.31184235e-01f, 2.23047212e-02f, -3.27108838e-02f,
  2.35519800e-02f, 3.46631999e-03f, -1.15312263e-01f, 1.09166754e-02f, 1.98880788e-02f, 4.54543419e-02f, 1.72812883e-02f, 5.21419235e-02f, -4.34032438e-04f, -1.04877383e-01f,
  8.36031437e-02f, 2.12154910e-02f, -8.56866837e-02f, 7.59494826e-02f, -5.98577447e-02f, 6.21820502e-02f, -1.48025855e-01f, -4.37343214e-03f, -8.75323713e-02f, -4.69492972e-02f,
  7.59138986e-02f, -3.15008089e-02f, 2.54225656e-02f, -1.52009115e-01f, -7.51761273e-02f, 7.36972466e-02f, -5.53813018e-02f, -3.43899019e-02f, 5.67209441e-03f, 5.31350449e-02f,
  3.54095036e-03f, -3.77794206e-02f, -4.07736562e-02f, -6.21090420e-02f, -4.83517833e-02f, -1.41626745e-01f, -5.52324504e-02f, -1.09400526e-01f, 1.23087823e-01f, -6.07089736e-02f,
  7.20852390e-02f, 1.56666055e-01f, 4.63437699e-02f, 7.39075541e-02f, 7.72515312e-02f, -1.22525215e-01f, 5.71835674e-02f, 8.13930929e-02f, 1.38147116e-01f, -5.71784414e-02f,
  -4.25799526e-02f, 1.49319659e-03f, -3.51019949e-02f, -4.49159518e-02f, 7.70462006e-02f, -2.70833075e-02f, -5.40384352e-02f, 1.01100899e-01f, 1.07247762e-01f, -3.54927853e-02f,
  -6.23866506e-02f, -5.81249967e-02f, 9.47901420e-03f, 1.94381028e-02f, 3.34844030e-02f, 5.08751534e-02f, 4.43737358e-02f, 5.13716824e-02f, -1.50820436e-02f, 1.94563195e-02f,
  1.85389873e-02f, -2.15753108e-01f, -1.39273986e-01f, -1.44057989e-01f, 3.42243500e-02f, -2.64457911e-01f, -1.99158221e-01f, -2.23854497e-01f, -5.64596280e-02f, -1.18875904e-02f,
  -2.40008757e-02f, 1.10463902e-01f, 9.84120518e-02f, -2.45644644e-01f, 8.63462985e-02f, 1.74973041e-01f, -3.03578824e-01f, -1.20297782e-01f, -1.20621372e-03f, -1.78486377e-01f,
  -3.75013910e-02f, -2.05112845e-02f, -7.80230213e-04f, -1.09897330e-01f, -2.70157248e-01f, -2.73055746e-03f, 1.37069374e-01f, -5.22882771e-03f, -1.82926700e-01f, -2.75620632e-02f,
  -1.11813150e-01f, 1.60387456e-01f, -3.55623290e-02f, -1.22108459e-02f, -4.95858043e-02f, -3.38385552e-02f, -1.29723921e-02f, 9.07659084e-02f, -1.04708234e-02f, -2.10679490e-02f,
  -2.35133618e-03f, 1.20048143e-01f, -1.13334231e-01f, 2.11933888e-02f, -1.47763893e-01f, 1.43429441e-02f, -7.89451301e-02f, -3.11136637e-02f, -2.70660147e-02f, 6.73732087e-02f,
  -4.43419488e-03f, -5.95576987e-02f, -9.14570987e-02f, 2.74258517e-02f, -5.09977564e-02f, -7.01829195e-02f, -9.62302648e-03f, 6.09050058e-02f, 2.17471179e-02f, -2.48542782e-02f,
  -5.71737252e-02f, -4.14989963e-02f, 6.75428193e-04f, -8.05650372e-03f, 8.25307369e-02f, -2.44576717e-03f, -8.24390575e-02f, 1.15087502e-01f, 6.41749823e-04f, 1.14573315e-02f,
  4.22427580e-02f, -5.81780784e-02f, -4.78394330e-03f, -1.58628315e-01f, -9.73702595e-03f, -2.19235197e-02f, 6.85351044e-02f, 1.40876323e-01f, -1.05602676e-02f, -4.56761084e-02f,
  6.34824559e-02f, 5.63140437e-02f, 7.35859424e-02f, 1.48850298e-02f, 8.32953230e-02f, -2.87811868e-02f, 1.30461091e-02f, -5.58471978e-02f, -7.75177032e-03f, -4.83006332e-03f,
  -2.56061014e-02f, 8.95772316e-03f, -4.37450707e-02f, 1.17505062e-02f, -1.85437649e-02f, -1.20790236e-01f, 1.41685484e-02f, -1.25781715e-01f, -2.94996928e-02f, -1.57060668e-01f,
  -7.26688430e-02f, -4.45118593e-03f, -1.49970829e-01f, -2.96032373e-02f, 6.45884648e-02f, -5.99501207e-02f, -2.20651273e-02f, -4.47883196e-02f, 4.11514454e-02f, 1.42999124e-02f,
  -3.95498499e-02f, 4.01926041e-03f, 5.44089936e-02f, -5.30623384e-02f, -7.74755180e-02f, -6.11516908e-02f, 5.70393726e-03f, -8.84199049e-04f, 2.98835225e-02f, 5.80864633e-03f,
  5.52267060e-02f, 4.64878045e-02f, 1.13288403e-01f, 2.01896280e-01f, -5.03496081e-02f, -2.70651221e-01f, -2.64350146e-01f, 1.13504902e-01f, -3.11008785e-02f, -1.81662455e-01f,
  7.61986971e-02f, 6.14045635e-02f, -9.92747620e-02f, 2.48567969e-01f, 1.28964677e-01f, 3.73959243e-02f, 1.23928465e-01f, 3.25463340e-02f, 1.04584187e-01f, 7.37392753e-02f,
  2.30365008e-01f, 1.39752194e-01f, 2.62414247e-01f, 5.28589450e-02f, -4.70139720e-02f, 1.38207868e-01f, 7.94988051e-02f, -9.93491411e-02f, 1.87944591e-01f, -8.38081017e-02f,
  -1.30025774e-01f, 6.99288538e-03f, -9.23960507e-02f, -8.80952850e-02f, -5.65945022e-02f, -1.08730413e-01f, -2.28304043e-03f, -5.73417954e-02f, -5.75586595e-02f, -4.59133536e-02f,
  5.50672561e-02f, -4.93914681e-03f, 9.44549367e-02f, 8.68564472e-03f, 1.08377840e-02f, 6.95724860e-02f, 5.29031940e-02f, -1.37925521e-02f, 3.03277820e-02f, 7.68446922e-02f,
  1.10750891e-01f, 2.19562873e-02f, 6.73175082e-02f, -8.88855532e-02f, 1.06739566e-01f, -3.71006839e-02f, -3.15332972e-02f, 6.22933134e-02f, 3.77076156e-02f, 7.38203749e-02f,
  -5.90791665e-02f, -1.72691606e-02f, 5.12488373e-02f, 7.64720961e-02f, 3.20367552e-02f, 1.83193311e-02f, 5.38384244e-02f, 2.11155005e-02f, -1.60672572e-02f, -3.03160083e-02f,
  3.32390098e-03f, 7.13071376e-02f, 2.37601586e-02f, -1.47977266e-02f, 5.34529462e-02f, 1.07325830e-01f, -1.67285763e-02f, -4.91430238e-02f, -1.77636296e-02f, -1.91141032e-02f,
  3.64938416e-02f, -2.86460649e-02f, 4.49737767e-04f, 1.68880005e-03f, 5.79580851e-02f, -5.37840277e-02f, 2.45006923e-02f, 7.20255589e-03f, 4.54896092e-02f, 5.89583069e-02f,
  -1.94009468e-02f, 1.42918602e-01f, -8.30596834e-02f, 2.86278389e-02f, -1.06805768e-02f, 8.17158148e-02f, -4.82986569e-02f, 4.06920649e-02f, -7.99665824e-02f, -2.86044050e-02f,
  7.26176985e-03f, 2.32378803e-02f, -1.08612776e-01f, -1.53506538e-02f, 2.34072078e-02f, 3.40754129e-02f, 4.00428288e-02f, -5.46172000e-02f, 6.46027401e-02f, -1.31914215e-02f,
  5.20655178e-02f, -3.53231393e-02f, 4.01069745e-02f, -7.42395520e-02f, 1.40883969e-02f, -1.07264489e-01f, 1.32822283e-02f, 2.48254016e-02f, 1.68923736e-02f, -4.08283137e-02f,
  1.32117465e-01f, -2.24397674e-01f, 7.52546489e-02f, 1.55393273e-01f, 2.44006529e-01f, 4.44429070e-02f, 1.77568242e-01f, -6.77605346e-02f, 1.67133629e-01f, -3.02006245e-01f,
  -7.60465562e-02f, -1.82436630e-01f, 3.82029898e-02f, -1.11248769e-01f, 2.88162529e-01f, 5.85953780e-02f, -3.96854430e-02f, -1.54901475e-01f, -3.01707648e-02f, -5.89177161e-02f,
  1.00798830e-01f, 1.38227846e-02f, 1.44219041e-01f, -2.03598142e-01f, 1.03746593e-01f, -4.56595533e-02f, -8.90709162e-02f, -9.26352516e-02f, -1.66336238e-01f, 2.57264711e-02f,
  9.48415920e-02f, -1.82070173e-02f, 3.65750566e-02f, -7.84379318e-02f, -4.12207805e-02f, -1.07069984e-02f, 4.11698036e-02f, -3.06315664e-02f, 1.62738189e-01f, 5.71930446e-02f,
  -5.74324839e-03f, -1.43239975e-01f, -1.40339926e-01f, -2.83999611e-02f, 2.85231620e-02f, -1.12017933e-02f, 1.63209625e-02f, 3.15217972e-02f, -7.05411434e-02f, -3.06194369e-02f,
  5.24803624e-02f, 2.83897202e-03f, -7.17129037e-02f, -2.30285615e-01f, -7.97702298e-02f, -2.39123739e-02f, -7.06391933e-04f, -1.51761815e-01f, -4.39308546e-02f, -1.31440610e-01f,
  -8.01717043e-02f, -6.75022975e-02f, 3.12303286e-02f, 1.96605474e-02f, 1.12567410e-01f, 5.79218604e-02f, 1.76133327e-02f, 3.78937237e-02f, 1.01677082e-01f, -3.46113406e-02f,
  -2.81890128e-02f, -6.00671992e-02f, -9.08694789e-02f, 1.27565682e-01f, -9.11712181e-03f, 5.95321804e-02f, 3.06484289e-02f, -8.46326258e-03f, -5.97807877e-02f, -9.57068056e-02f,
  6.49379790e-02f, 8.00440367e-03f, -4.50188294e-02f, 6.34440929e-02f, -3.82013470e-02f, 5.83206676e-02f, 1.78752712e-03f, -7.99843147e-02f, 1.35496348e-01f, -1.20324790e-02f,
  -1.12890862e-02f, -2.54397422e-01f, -4.42215130e-02f, 3.93961966e-02f, 5.14201708e-02f, -6.01092242e-02f, -1.41262189e-02f, 4.23773238e-03f, 3.04129086e-02f, -1.85418539e-02f,
  1.57665685e-02f, 2.89809983e-02f, -3.99367139e-02f, -2.71935705e-02f, -2.96027213e-02f, 3.09468824e-02f, 5.06695360e-02f, -1.05673850e-01f, 6.64889365e-02f, -9.31507051e-02f,
  -4.79862243e-02f, -1.27165271e-02f, 4.08633286e-03f, -1.02892764e-01f, -6.96669072e-02f, -2.97084432e-02f, 1.27715338e-02f, -5.59005141e-03f, -3.25212479e-02f, 3.98215614e-02f,
  3.00682765e-02f, 8.55526552e-02f, 1.07806213e-01f, 7.38861710e-02f, 3.03309895e-02f, -2.19498664e-01f, -1.10277288e-01f, 1.64271384e-01f, 3.06313068e-01f, 9.93196517e-02f,
  -7.56955799e-03f, 1.62642345e-01f, 5.30140698e-02f, -9.29612294e-03f, -2.36840799e-01f, 1.52484588e-02f, -2.44651869e-01f, -1.53673023e-01f, -5.51933236e-02f, -5.51579893e-02f,
  -1.26756385e-01f, -1.08369768e-01f, -2.44203225e-01f, -7.01705441e-02f, -7.02980161e-02f, 9.03688148e-02f, -8.21066946e-02f, 3.67687419e-02f, -1.28343791e-01f, -8.18463136e-03f,
  7.21778050e-02f, 1.94159105e-01f, 1.18449666e-02f, 1.09695241e-01f, -1.11034185e-01f, -2.02491656e-01f, 4.77030361e-03f, 7.30344877e-02f, 3.31478044e-02f, 1.19931728e-01f,
  1.81327034e-02f, -4.08212207e-02f, -2.37464882e-03f, -7.45724738e-02f, 1.67986825e-02f, 8.19336623e-02f, 1.18829228e-01f, -5.65053895e-02f, 2.39772676e-03f, -2.85840388e-02f,
  3.43881287e-02f, -3.22817452e-02f, 4.17464301e-02f, 4.50756960e-02f, 4.11100074e-04f, 1.31166026e-01f, -7.36986175e-02f, -3.88144553e-02f, -3.34683172e-02f, -4.48084921e-02f,
  -1.44744530e-01f, -2.04964578e-02f, 1.21728443e-01f, -6.24521123e-03f, 8.60979110e-02f, 8.68308619e-02f, 2.90393420e-02f, 1.14115492e-01f, 8.91593918e-02f, -3.32915112e-02f,
  1.18186243e-01f, -8.97307787e-03f, 2.40257103e-02f, -1.56795725e-01f, -8.72628912e-02f, 7.56803975e-02f, 3.84172089e-02f, -3.29045095e-02f, -4.07977477e-02f, -1.38498113e-01f,
  9.08375382e-02f, 1.42176021e-02f, 6.84351027e-02f, -9.12832469e-02f, -8.11848566e-02f, -1.15369037e-02f, -7.60581642e-02f, -5.32723702e-02f, -3.39569785e-02f, -1.91649035e-01f,
  -2.08587851e-02f, 3.51512395e-02f, 1.20764447e-03f, 9.82212499e-02f, -3.91497053e-02f, -1.94135755e-02f, 7.70266261e-03f, 1.51634395e-01f, -2.47984286e-02f, -5.60493357e-02f,
  -1.04127564e-01f, -1.44662405e-03f, -1.14762530e-01f, 1.72770061e-02f, 1.00474887e-01f, 4.21546921e-02f, -5.86433001e-02f, 5.18242754e-02f, -7.63721243e-02f, -2.21584328e-02f,
  -5.15872426e-02f, 4.76951823e-02f, 3.50009240e-02f, -5.28554395e-02f, -1.41607776e-01f, -2.23053209e-02f, 4.70925197e-02f, -2.40944345e-02f, -8.37411731e-02f, -9.64543223e-02f,
  1.50414335e-03f, -1.49987400e-01f, -1.27218872e-01f, -1.42108813e-01f, 2.37159226e-02f, -2.70627551e-02f, -1.08255586e-02f, -9.51191932e-02f, -7.17677698e-02f, 1.11549877e-01f,
  4.43984568e-03f, -1.37840705e-02f, 4.37520817e-02f, -2.73993462e-01f, -2.51884788e-01f, -1.53824851e-01f, -1.35015309e-01f, -9.85936821e-02f, -3.93022820e-02f, 2.45799888e-02f,
  -1.02728046e-01f, -7.02352673e-02f, -1.18105717e-01f, 8.18898678e-02f, -5.66478223e-02f, 1.42359465e-01f, 1.83223814e-01f, 9.72031876e-02f, 2.62179337e-02f, -2.05634139e-03f,
  -5.76023832e-02f, -9.27263796e-02f, 1.29270200e-02f, -1.05044441e-02f, 3.59274447e-02f, 1.01183608e-01f, 6.46145269e-02f, -4.46026921e-02f, 4.15990576e-02f, -5.06026596e-02f,
  6.54883636e-03f, -2.22684704e-02f, 6.53497735e-03f, -1.73944719e-02f, -6.90269284e-03f, -5.26241353e-03f, 2.36667376e-02f, 7.11613372e-02f, -8.21008086e-02f, -2.97013428e-02f,
  -1.05704218e-01f, -8.30279365e-02f, 1.71875488e-02f, -1.10229231e-01f, -1.93704348e-02f, -3.97717543e-02f, 6.77352995e-02f, 4.74502519e-02f, 8.70221183e-02f, 4.67141271e-02f,
  5.98061457e-02f, -8.18814337e-02f, -3.57405543e-02f, -4.31726463e-02f, 1.10072657e-01f, 1.15041420e-01f, 5.35860136e-02f, -7.62358541e-03f, -5.37578650e-02f, 4.66520190e-02f,
  -4.87181963e-03f, 3.10533913e-03f, 1.05582327e-02f, -2.27396321e-02f, 6.32312819e-02f, 4.69191484e-02f, 3.63313407e-02f, 2.09520385e-03f, 4.97757867e-02f, -6.40960783e-02f,
  -1.00881243e-02f, -1.30245797e-02f, -2.31636260e-02f, -2.13258974e-02f, -5.47715090e-02f, -3.79896089e-02f, -2.84841321e-02f, -5.28381020e-02f, -7.85354525e-02f, 1.09900370e-01f,
  3.76415215e-02f, 8.75383615e-02f, 6.31564930e-02f, -1.64888930e-02f, 9.73227769e-02f, 5.26367389e-02f, -7.93219581e-02f, -7.10614324e-02f, -7.98674151e-02f, 5.99387959e-02f,
  3.95597704e-02f, -3.22921686e-02f, -6.86606904e-03f, 2.92135240e-03f, 3.96342613e-02f, 5.57654053e-02f, 1.33495137e-01f, 4.04875353e-02f, 4.04285230e-02f, 1.68908276e-02f,
  4.15529162e-02f, 4.39639166e-02f, -5.56899607e-02f, -9.26728770e-02f, 9.20494944e-02f, 1.45272193e-02f, 1.86804123e-02f, 1.65351219e-02f, 2.75960267e-02f, -8.77812207e-02f,
  -9.97827277e-02f, -1.39326423e-01f, 1.60278112e-01f, 9.39309523e-02f, 2.91716997e-02f, 1.82433426e-01f, 2.68546134e-01f, 6.02318964e-04f, -7.34907389e-02f, -1.96841769e-02f,
  -8.82871076e-03f, -2.68385746e-02f, -4.63482663e-02f, -5.17195687e-02f, 1.46323219e-01f, -5.97384386e-02f, 6.12457581e-02f, 5.45805274e-03f, 2.49017980e-02f, -6.68522567e-02f,
  3.76167670e-02f, 8.47862065e-02f, 1.43690214e-01f, -1.92759819e-02f, 1.03229247e-02f, -1.66586936e-02f, -4.94947191e-03f, 2.70528439e-02f, 8.61550942e-02f, 8.46382678e-02f,
  -1.30169943e-01f, -1.65308371e-01f, -1.22199200e-01f, 3.66125330e-02f, -5.87813072e-02f, -8.62345919e-02f, 2.79260967e-02f, 8.16748291e-02f, 1.32401027e-02f, 1.65271405e-02f,
  -1.65517747e-01f, -1.33874803e-03f, 4.16849218e-02f, 2.21353956e-02f, 3.58921066e-02f, -8.07261001e-03f, 1.13669626e-01f, -1.37524858e-01f, 1.13533586e-02f, 1.21296756e-03f,
  -5.22125559e-03f, 1.14458673e-01f, -8.09612721e-02f, 4.80971634e-02f, 8.92740935e-02f, 1.08795665e-01f, 8.18543583e-02f, -1.93467923e-02f, -2.54434813e-02f, -8.51426348e-02f,
  5.75083494e-02f, -4.31468561e-02f, -1.54429808e-01f, -4.75101806e-02f, -5.75123690e-02f, 1.94593906e-01f, 2.60044802e-02f, -2.54584067e-02f, 3.60722579e-02f, -2.44733151e-02f,
  1.34600634e-02f, -7.84574077e-02f, 4.12594043e-02f, -3.37697864e-02f, -2.71689594e-02f, -3.15694399e-02f, -1.01814196e-01f, 1.11217368e-02f, -8.36994573e-02f, 5.90552203e-02f,
  -6.62587509e-02f, -9.17775556e-03f, -8.67217928e-02f, -1.00899301e-01f, -1.72963999e-02f, -3.77484709e-02f, -1.26948711e-02f, -7.96405151e-02f, -2.86880671e-03f, -5.01563773e-02f,
  -4.33941424e-01f, -3.39094758e-01f, -5.53607792e-02f, 5.19198477e-02f, -9.61129442e-02f, -8.84664506e-02f, 6.43889159e-02f, -6.81888778e-03f, -8.19233805e-03f, -1.26764670e-01f,
  -2.08538920e-02f, -8.45344514e-02f, -7.64470594e-03f, 8.96998495e-03f, 4.00756765e-03f, 4.82476205e-02f, 4.52925153e-02f, -8.74968152e-03f, 8.34955275e-03f, -1.53520843e-02f,
  -4.88257073e-02f, -2.35704724e-02f, -2.08898708e-02f, 7.92023838e-02f, 2.92610917e-02f, -3.04003730e-02f, -5.87836802e-02f, -1.89913176e-02f, -1.00650797e-02f, -6.19293773e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.70156339e-02f, 6.64418787e-02f, 8.15392137e-02f, 1.96185559e-01f, 6.78679571e-02f, 1.78134888e-01f, 6.07868806e-02f, 2.55398881e-02f, 1.92215387e-02f, 1.00768216e-01f,
  1.27087384e-01f, 1.75706983e-01f, 1.13005571e-01f, 2.42153481e-02f, 1.12974741e-01f, 6.44466653e-02f, 1.25851780e-01f, -7.38977119e-02f, 8.65233541e-02f, 8.38542357e-02f,
  -1.33542139e-02f, 2.68033184e-02f, 1.30152404e-01f, 8.67747422e-03f, 1.75252840e-01f, 5.36731966e-02f, 4.92969193e-02f, -6.21269979e-02f, -1.78070758e-02f, 4.49078903e-03f,
  -1.65170350e-04f, 1.26499891e-01f, 1.23147599e-01f, -3.82108092e-02f, 5.47022708e-02f, 5.81918918e-02f, 4.00836281e-02f, 2.78624576e-02f, 5.84063381e-02f, 1.07764073e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.44048529e-02f, -1.51469603e-01f, -1.29791349e-01f, -1.91090792e-01f, -1.05047608e-02f, -1.47691280e-01f, -1.22269161e-01f, -1.57282725e-01f, -2.28791758e-02f, -7.71300793e-02f,
  -1.31718516e-01f, -1.40248761e-01f, -2.67578708e-03f, -7.81510025e-02f, -1.39251664e-01f, 3.53340735e-03f, -7.02511072e-02f, 1.76731627e-02f, 1.24305271e-01f, 6.07737526e-02f,
  3.44374105e-02f, -5.24148606e-02f, 1.42690539e-01f, 3.58105153e-02f, 5.57126738e-02f, 2.82947477e-02f, -2.27815330e-01f, 2.06899151e-01f, -3.13871540e-02f, 2.62534041e-02f,
  -2.13799551e-01f, -6.47523478e-02f, -1.34534284e-01f, 2.28423670e-01f, -1.86078757e-01f, 2.57402360e-01f, -8.67980812e-03f, -1.24925472e-01f, -8.06584805e-02f, 1.84726849e-01f,
  6.13977611e-02f, 1.22576632e-01f, -3.12262923e-02f, -3.80128738e-03f, 2.12247685e-01f, 1.98181629e-01f, -1.74428657e-01f, -1.56197563e-01f, -1.76566362e-01f, -1.24056473e-01f,
  4.67882045e-02f, 1.21370606e-01f, 1.66850947e-02f, 1.60518706e-01f, 3.16324942e-02f, -6.53758878e-03f, 2.19421238e-01f, 6.54916912e-02f, 9.16161910e-02f, 2.51097381e-01f,
  8.94879997e-02f, 1.12204008e-01f, -6.93863705e-02f, -1.16039656e-01f, -6.55563176e-02f, 8.76457896e-03f, 2.05954406e-02f, 5.82929216e-02f, -5.69784604e-02f, 4.48479503e-02f,
  -4.53860089e-02f, 1.89035665e-02f, 5.04675433e-02f, -2.12340690e-02f, 7.97969699e-02f, -2.48447359e-02f, 8.70009586e-02f, 7.53066167e-02f, 9.51055884e-02f, -9.20636728e-02f,
  2.62284800e-02f, -6.84841871e-02f, -4.17797565e-02f, 4.23661768e-02f, 3.44836377e-02f, 1.34200007e-01f, -6.95129186e-02f, 1.76725060e-01f, 3.64606604e-02f, -1.09613352e-01f,
  1.42698035e-01f, 4.92152348e-02f, -1.18116498e-01f, 1.06931508e-01f, 1.86140820e-01f, 7.66423717e-02f, 1.49192929e-01f, 1.28631547e-01f, 4.04826999e-02f, -2.03908846e-01f,
  -3.72572872e-03f, -5.99806309e-02f, -1.95622042e-01f, -1.40630648e-01f, -2.45846003e-01f, -4.10243757e-02f, -1.34962965e-02f, -2.19126400e-02f, -1.93668783e-01f, -1.41889274e-01f,
  8.32443386e-02f, 1.00772567e-01f, 1.01721138e-01f, 9.08742920e-02f, -1.43477216e-01f, -5.55797219e-02f, -6.03270493e-02f, -6.27485067e-02f, 1.59963652e-01f, -4.15216945e-02f,
  -1.10854827e-01f, -1.05654653e-02f, -1.39840126e-01f, -1.43013209e-01f, 1.89683232e-02f, -4.70289811e-02f, -1.01575091e-01f, 1.45127431e-01f, 4.20180224e-02f, -3.40757929e-02f,
  -6.79277033e-02f, -3.10351197e-02f, 4.43017520e-02f, -1.57436412e-02f, -4.17222753e-02f, -1.13741001e-02f, 4.50409055e-02f, 7.36852661e-02f, 1.13389958e-02f, -3.99865657e-02f,
  5.40799089e-02f, -3.27273309e-02f, -5.90350591e-02f, 2.33991966e-02f, 5.24067394e-02f, -6.74182475e-02f, 2.09033757e-01f, -7.64057878e-03f, 6.80114776e-02f, -3.87769716e-04f,
  -5.33896573e-02f, 1.09186098e-01f, -1.47103593e-01f, 1.35298878e-01f, 2.64426976e-01f, 1.91376619e-02f, -5.35447821e-02f, -2.85254922e-02f, 3.10653090e-01f, 1.33180246e-01f,
  2.28954986e-01f, 1.08436793e-01f, 1.17326699e-01f, -1.45722583e-01f, -1.05610102e-01f, 1.73748985e-01f, -1.93600789e-01f, -1.00861996e-01f, -1.02687404e-01f, 1.46874562e-01f,
  7.42460415e-02f, 7.75532797e-02f, -9.65028107e-02f, 7.11253583e-02f, 2.73823470e-01f, 5.96133508e-02f, -9.04782414e-02f, -9.62283164e-02f, -1.13517411e-01f, -6.85584024e-02f,
  -4.93531190e-02f, 1.80964470e-01f, 1.67594001e-01f, -1.96644530e-01f, 1.76989838e-01f, 7.28203356e-02f, -1.77549124e-01f, 3.82297635e-02f, 9.94235426e-02f, 3.36563811e-02f,
  -2.12560415e-01f, 1.85091466e-01f, -5.64623736e-02f, 1.16112225e-01f, -1.40794829e-01f, 4.70605195e-02f, 1.49679948e-02f, 4.49783131e-02f, -8.97563919e-02f, 9.00502801e-02f,
  -1.24814190e-01f, 3.51557955e-02f, 4.25200127e-02f, -1.54076025e-01f, -7.26422817e-02f, 1.29558206e-01f, -1.02623783e-01f, 1.58371255e-02f, -5.90605326e-02f, 6.21606857e-02f,
  -1.08408794e-01f, -6.82156300e-03f, -7.47131780e-02f, 1.08652569e-01f, 5.92492484e-02f, 2.68912651e-02f, -5.15731350e-02f, 1.26490802e-01f, 8.80270302e-02f, 3.78843769e-02f,
  1.25282362e-01f, -5.80543466e-02f, 6.18023388e-02f, 7.22749233e-02f, -1.35047110e-02f, -1.24980964e-01f, 2.69708578e-02f, 9.52863507e-03f, 9.35153849e-03f, 1.12298697e-01f,
  1.42447293e-01f, -2.68563591e-02f, -1.21527262e-01f, -1.86915666e-01f, -6.19622134e-02f, -5.44489659e-02f, -1.99587688e-01f, -1.69588894e-01f, 1.05076440e-01f, 6.42973185e-02f,
  2.09376663e-02f, 1.52270555e-01f, 2.14463755e-01f, 1.82093933e-01f, -1.68926585e-02f, -6.80447966e-02f, -1.25977024e-01f, 9.83726829e-02f, -1.71907485e-01f, 6.77043870e-02f,
  2.09195584e-01f, -1.29610568e-01f, -1.12921678e-01f, -7.63839036e-02f, 1.10547170e-01f, -1.27250299e-01f, 1.05829492e-01f, 6.91282451e-02f, -1.23845078e-01f, -5.24711199e-02f,
  -1.03744082e-01f, 1.00675703e-03f, -4.93975244e-02f, 4.74327952e-02f, 4.49908972e-02f, 5.55711091e-02f, -6.62992150e-02f, 1.04780262e-02f, -1.76612973e-01f, 3.11900582e-02f,
  1.16509847e-01f, -1.04949497e-01f, -4.32372689e-02f, -3.93955410e-02f, 8.01243111e-02f, -1.18372947e-01f, -3.18522640e-02f, 2.27387361e-02f, 1.01640068e-01f, -1.60782680e-01f,
  1.06008060e-01f, 2.24916592e-01f, 6.88762069e-02f, 2.46352740e-02f, 4.32251133e-02f, -1.53928384e-01f, 2.80665476e-02f, 8.71159062e-02f, -4.65662917e-03f, 7.24615306e-02f,
  9.08157378e-02f, 6.59204721e-02f, -3.14981602e-02f, 1.39834061e-01f, 2.01132998e-01f, -3.23094167e-02f, -2.60319352e-01f, -6.55561760e-02f, 5.10178842e-02f, -8.32216367e-02f,
  -1.08457968e-01f, -9.34173390e-02f, 1.62825078e-01f, 4.99355271e-02f, -1.35540485e-01f, 5.34357578e-02f, 1.82043418e-01f, 2.67475337e-01f, 1.14827445e-02f, 1.00281455e-01f,
  -9.53627229e-02f, 1.04999475e-01f, -1.16467588e-01f, 2.19455272e-01f, 2.66300261e-01f, 2.92095207e-02f, -8.72332603e-02f, -1.85270682e-02f, 1.22832052e-01f, -1.45762116e-01f,
  3.43871862e-02f, -4.08694260e-02f, 5.56148179e-02f, -1.78244695e-01f, 1.06901571e-01f, -1.27965503e-03f, -1.25725091e-01f, 2.35030968e-02f, 3.36228241e-03f, -1.06084719e-01f,
  -9.71842371e-03f, -1.51018485e-01f, 5.25250398e-02f, -1.13730528e-03f, 3.71151008e-02f, -7.61321485e-02f, -1.05445452e-01f, 1.02446236e-01f, 1.10895567e-01f, 3.11148036e-02f,
  -7.03947395e-02f, -1.20143041e-01f, 1.10650398e-01f, 2.61303745e-02f, -4.04649926e-03f, 1.17765658e-01f, -1.49736375e-01f, 1.52379051e-01f, -5.67969345e-02f, 5.45540005e-02f,
  -1.58767596e-01f, 1.14215780e-02f, -2.95341183e-02f, 1.87689483e-01f, -1.65070564e-01f, -4.22734991e-02f, 3.62643190e-02f, -1.29476815e-01f, 5.33116199e-02f, 2.84770541e-02f,
  -1.85203664e-02f, 1.25809774e-01f, -4.71215928e-03f, -1.50619191e-03f, 8.86239633e-02f, 1.20210081e-01f, -5.36594428e-02f, -5.95396087e-02f, -1.34406850e-01f, -2.02370405e-01f,
  -6.88461810e-02f, -2.14438334e-01f, 2.89097484e-02f, 2.01900601e-01f, 6.42072735e-03f, 6.21798150e-02f, 7.06588253e-02f, 1.22968756e-01f, -7.79027771e-03f, 1.10026233e-01f,
  8.71249735e-02f, 2.55195141e-01f, -4.00799736e-02f, -8.09748396e-02f, 5.29534295e-02f, 1.15469113e-01f, -2.47222241e-02f, 2.12162454e-02f, 5.95056415e-02f, 6.61389902e-02f,
  -4.53679711e-02f, 1.49871921e-02f, 3.47159840e-02f, 9.16088298e-02f, -3.30013894e-02f, 6.78819343e-02f, -1.71485826e-01f, -3.56644951e-02f, 1.15123510e-01f, 9.24359560e-02f,
  -1.78889856e-01f, 1.07747205e-01f, -1.32361144e-01f, 1.41909420e-01f, -1.65836722e-01f, -1.32523254e-01f, 2.34301627e-01f, -1.33109555e-01f, 2.43905336e-02f, -5.67427054e-02f,
  -1.11322805e-01f, 3.29106837e-03f, 1.27509713e-01f, -1.62365139e-01f, -8.92336071e-02f, -6.09088968e-03f, -1.03745371e-01f, -7.65344650e-02f, 9.12055001e-03f, 5.87410182e-02f,
  3.83303016e-02f, -8.57846215e-02f, 1.17952965e-01f, 6.61006942e-02f, 2.41881371e-01f, 8.43523890e-02f, -1.54627606e-01f, -1.16389990e-02f, -2.00500106e-03f, 4.55867164e-02f,
  -1.46829307e-01f, 1.69867948e-01f, 1.62661925e-01f, 4.98776138e-03f, 9.75586325e-02f, -1.51696978e-02f, 1.22905765e-02f, 5.07951481e-03f, -5.34270611e-03f, 1.78701028e-01f,
  6.71349987e-02f, 2.88155042e-02f, 1.15346275e-01f, 3.44563872e-02f, -9.54015777e-02f, 2.78595164e-02f, -2.30226163e-02f, -4.33459207e-02f, 1.48970382e-02f, -8.45459253e-02f,
  -3.11076501e-03f, -1.41374052e-01f, 1.82667039e-02f, -9.62927118e-02f, -1.07988492e-01f, -1.29837230e-01f, 4.61102612e-02f, -1.03867352e-01f, -6.57897294e-02f, -4.28830720e-02f,
  2.20004953e-02f, -1.79612517e-01f, 3.36609483e-02f, 1.32955894e-01f, -4.36461793e-04f, -7.72000328e-02f, 1.16640128e-01f, -4.13614400e-02f, 7.84254000e-02f, -9.36008394e-02f,
  2.25780578e-03f, -2.21747458e-02f, 3.41978967e-02f, 2.18568533e-03f, -4.76099700e-02f, -9.02470425e-02f, 8.67379978e-02f, -1.94895677e-02f, -4.51532714e-02f, 1.44619010e-02f,
  -7.50968829e-02f, -1.06136119e-02f, -2.53784601e-02f, 1.13287963e-01f, -5.18088564e-02f, 8.59346357e-04f, -2.21158341e-01f, -6.60457239e-02f, 1.94839403e-01f, 1.73344418e-01f,
  7.32171535e-02f, 1.05881751e-01f, 1.74116835e-01f, 2.49448717e-01f, -1.53809652e-01f, -6.55337051e-02f, 8.58021975e-02f, -1.01102747e-01f, -1.03787377e-01f, 2.48700976e-02f,
  6.68259710e-02f, 8.66606757e-02f, -4.84724827e-02f, -1.06005140e-01f, 2.70963043e-01f, 6.38904721e-02f, 3.59221548e-02f, 1.78300560e-01f, 1.10782743e-01f, -7.75819570e-02f,
  -7.11165741e-02f, -1.16072446e-02f, -1.00904368e-02f, -8.86928812e-02f, 2.07415428e-02f, -1.06565185e-01f, 5.24872774e-03f, 4.20398526e-02f, 1.11333363e-01f, -6.48112446e-02f,
  5.44678569e-02f, 9.07410085e-02f, 1.02450825e-01f, -6.30548224e-02f, 2.43756950e-01f, -1.56841278e-02f, -1.85446918e-01f, 1.20312832e-02f, -3.74219194e-02f, 1.01704977e-01f,
  -4.97338735e-02f, -2.19332114e-01f, 1.99519381e-01f, 6.84494600e-02f, -6.11203834e-02f, 3.26882936e-02f, 2.64476184e-02f, -1.31481573e-01f, -1.60209357e-03f, 1.39406128e-02f,
  7.59670734e-02f, 1.28818899e-01f, -1.01827919e-01f, -3.55737656e-02f, -1.69738512e-02f, -5.65698147e-02f, -8.04889128e-02f, 6.45821318e-02f, -1.48174157e-02f, -1.95290633e-02f,
  -8.22040215e-02f, 9.88193378e-02f, 1.68378308e-01f, -2.18685523e-01f, 1.48287371e-01f, -1.41637698e-01f, 1.97691590e-01f, 7.54294693e-02f, -9.56363901e-02f, -9.11811069e-02f,
  -2.22499236e-01f, -2.58340776e-01f, 9.27800164e-02f, 1.49895668e-01f, 4.79551069e-02f, -2.69378107e-02f, -1.17700808e-01f, -1.29744440e-01f, -2.13572700e-02f, 3.49660441e-02f,
  -1.15416229e-01f, -8.73686895e-02f, 1.28632531e-01f, 2.44895652e-01f, 1.30934156e-02f, -1.78471640e-01f, 4.61793877e-02f, 2.23902464e-02f, 1.85074389e-01f, -1.18751846e-01f,
  1.05030863e-02f, 1.58322603e-01f, 5.04755042e-03f, 1.45473078e-01f, 8.63641426e-02f, 1.16963148e-01f, 2.36467477e-02f, -1.51067646e-02f, -9.51991305e-02f, -1.33901224e-01f,
  9.55731794e-02f, -4.03762748e-03f, -3.74394208e-02f, 1.02458842e-01f, 1.19886205e-01f, -1.42736554e-01f, 1.65313799e-02f, 4.88578193e-02f, -3.12882774e-02f, -1.73050791e-01f,
  -6.16810694e-02f, 7.64689595e-02f, 9.90946442e-02f, -3.19115557e-02f, -1.31293386e-01f, -1.03834867e-01f, 1.05845056e-01f, -1.92501992e-01f, 5.56590110e-02f, -7.94234499e-02f,
  1.89787775e-01f, 3.47172879e-02f, 1.18178613e-01f, -9.45331976e-02f, 2.18956724e-01f, 1.39090568e-01f, 7.89349303e-02f, 5.76100573e-02f, -5.63952923e-02f, -1.90490529e-01f,
  1.66956559e-01f, 1.12751633e-01f, 2.19455436e-01f, -1.57434374e-01f, -1.61867321e-01f, -1.22329801e-01f, -3.35147344e-02f, -1.55247778e-01f, 2.64213374e-03f, 3.93186649e-03f,
  -1.36301652e-01f, 1.65909484e-01f, -8.82684141e-02f, 4.40328345e-02f, -1.25588961e-02f, 5.96720278e-02f, -1.68791192e-03f, 2.43261456e-02f, -5.75279146e-02f, -8.80628005e-02f,
  9.27698910e-02f, -3.65407951e-02f, -3.18537769e-03f, 7.88834095e-02f, 6.08761869e-02f, 9.86049026e-02f, 1.54158041e-01f, -3.88607122e-02f, 1.48718014e-01f, 1.01306349e-01f,
  6.95083737e-02f, 1.67917296e-01f, 2.24458858e-01f, -9.28470120e-03f, -5.36928885e-03f, 8.32390264e-02f, 2.79027838e-02f, 8.04006532e-02f, -1.54886812e-01f, 2.22799405e-01f,
  1.04089350e-01f, 1.96444541e-02f, -9.48467180e-02f, 1.48655593e-01f, -7.07017183e-02f, -2.69448817e-01f, -5.59666529e-02f, 5.74787743e-02f, -3.18182656e-03f, 1.19142286e-01f,
  -1.82544887e-02f, 5.12931570e-02f, -2.72790901e-02f, 1.69912338e-01f, -1.00563303e-01f, 2.66827103e-02f, -8.50535464e-03f, -1.36152908e-01f, -1.38003230e-01f, -1.13382125e-02f,
  2.10223370e-03f, -6.58957213e-02f, 6.02721646e-02f, 9.79999974e-02f, -3.12654972e-02f, -6.37853937e-03f, -1.52636006e-01f, -4.09627333e-02f, -7.17718294e-03f, -1.24677956e-01f,
  -1.77937344e-01f, -4.38714102e-02f, 5.57840019e-02f, -7.56923184e-02f, 1.26199707e-01f, -9.98727307e-02f, 1.32190406e-01f, -1.25989914e-01f, -1.60053343e-01f, -1.26205862e-01f,
  7.01523945e-02f, -2.03241169e-01f, -1.21311791e-01f, 1.54218808e-01f, 3.04747727e-02f, 3.61490436e-03f, 9.63308616e-04f, 7.39259794e-02f, -2.95218155e-02f, -2.61712857e-02f,
  -7.67562464e-02f, -1.36233225e-01f, -3.86722088e-02f, -1.11844830e-01f, 4.92224060e-02f, 1.22146025e-01f, 8.16054642e-02f, 1.56709656e-01f, -1.10145293e-01f, -1.23224277e-02f,
  1.71660274e-01f, -2.36322820e-01f, 2.03628335e-02f, -7.41730481e-02f, 4.83046882e-02f, 2.23227024e-01f, -8.90733078e-02f, 1.04665384e-01f, -1.21369503e-01f, -9.57410485e-02f,
  1.76963210e-01f, -3.14190052e-02f, -1.41092148e-02f, 2.18637940e-02f, 2.04511121e-01f, 1.04488783e-01f, 4.36133631e-02f, -2.33688876e-02f, 1.76255390e-01f, 5.83233200e-02f,
  -2.28119299e-01f, 1.41827613e-01f, -2.19353423e-01f, -8.84536579e-02f, -5.41249029e-02f, -2.78853402e-02f, 1.17323026e-01f, 2.99958736e-01f, -6.38208911e-02f, -7.85016865e-02f,
  1.20476887e-01f, 2.31042672e-02f, 1.22363001e-01f, 9.63593349e-02f, -5.26808910e-02f, 1.60197448e-02f, -1.15465656e-01f, -1.31914020e-01f, 5.90987206e-02f, -2.35788688e-01f,
  1.88986257e-01f, -1.07409365e-01f, 2.12781113e-02f, -5.04198261e-02f, 7.92724174e-03f, -5.71083166e-02f, -1.34925172e-01f, 1.22055553e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.28895948e-03f, 8.39306042e-02f, 1.28219634e-01f, 6.94802850e-02f, 1.68182597e-01f, -5.58648929e-02f, 9.01971683e-02f, 1.72582626e-01f, 8.56541395e-02f, 4.61315252e-02f,
  1.25671327e-01f, 5.58356494e-02f, -1.61703289e-01f, -1.21311598e-01f, 1.56740099e-01f, 1.87164217e-01f, -8.41941312e-02f, -1.20085880e-01f, 2.77959276e-02f, 1.04522772e-01f,
  -4.72492240e-02f, -2.04975247e-01f, 7.75818229e-02f, 1.61465369e-02f, 7.77590796e-02f, -2.19627339e-02f, 2.67095882e-02f, -2.80266613e-01f, 3.50028947e-02f, -2.24051863e-01f,
  -9.79913771e-02f, -8.20323676e-02f, -1.45739779e-01f, -1.44105881e-01f, 1.59183219e-01f, -2.29308695e-01f, 1.81457311e-01f, -1.72344334e-02f, 2.72177402e-02f, -6.68695793e-02f,
  1.76043704e-01f, 2.71626383e-01f, -6.19449504e-02f, -2.32338496e-02f, -2.44565979e-02f, 1.38668329e-01f, 1.00750901e-01f, 2.01621205e-01f, 2.71950215e-01f, 1.88430548e-01f,
  5.67621887e-02f, -1.36456594e-01f, 9.40940753e-02f, 1.95043489e-01f, -1.24814902e-02f, 1.67825893e-01f, 1.83700427e-01f, 7.09437728e-02f, 2.13960018e-02f, 2.29138210e-01f,
  -1.80679515e-01f, -1.50850520e-01f, -8.62492528e-03f, 6.08991012e-02f, 2.50249207e-02f, 5.98319471e-02f, 1.49306074e-01f, 1.75388992e-01f, -1.20590217e-02f, 5.99726140e-02f,
  1.28354520e-01f, 9.08580550e-04f, -9.37077962e-03f, 1.34175271e-01f, 1.68866038e-01f, 1.65191069e-01f, 1.29672766e-01f, 1.59894228e-01f, -1.67695388e-01f, 8.79535358e-03f,
  1.29923567e-01f, -2.01410457e-01f, -2.47288286e-03f, -1.13136992e-01f, 5.25087006e-02f, 5.99254947e-03f, -1.91268608e-01f, 4.54113185e-02f, -7.63054518e-03f, -1.78896431e-02f,
  2.01564193e-01f, -1.65882055e-02f, -6.43632114e-02f, 2.19269216e-01f, 9.42046717e-02f, 1.26934424e-01f, 1.82227865e-01f, -4.03194986e-02f, 1.43522024e-01f, -6.54140487e-02f,
  -1.34506434e-01f, 1.62658557e-01f, -1.73053339e-01f, -8.07333067e-02f, -1.87327668e-01f, 5.59009314e-02f, 1.58958375e-01f, 1.07640043e-01f, -5.21991514e-02f, -3.27080935e-02f,
  1.65074706e-01f, 2.71517430e-02f, 3.22488062e-02f, 6.45874590e-02f, -1.14984363e-01f, 4.73070517e-02f, -1.05947718e-01f, -6.90430626e-02f, -1.44699179e-02f, -1.22216322e-01f,
  1.20041579e-01f, -9.80953202e-02f, -8.56235698e-02f, -1.13811582e-01f, 1.21982969e-01f, 1.03831641e-01f, -5.27118333e-02f, 9.47207436e-02f, 1.76717326e-01f, 7.65743107e-02f,
  4.46022563e-02f, -3.91148701e-02f, 9.52023044e-02f, 7.94954300e-02f, 2.01682389e-01f, 1.11418599e-02f, 1.46645540e-03f, 9.58841220e-02f, -6.54766848e-03f, 4.38147150e-02f,
  -5.52167892e-02f, 1.85718071e-02f, 9.58360657e-02f, -1.80452481e-01f, -1.07740946e-02f, 1.78104371e-01f, -3.33044007e-02f, 5.24975955e-02f, -4.51330431e-02f, 8.04429948e-02f,
  1.98174119e-01f, -5.47497496e-02f, 5.67439124e-02f, 2.82169342e-01f, 1.63903862e-01f, 2.91879863e-01f, -5.43856062e-02f, -1.59651767e-02f, 5.50064370e-02f, -1.37238652e-02f,
  1.35913268e-01f, 1.52402133e-01f, 9.33967903e-02f, 2.23115105e-02f, 9.70230103e-02f, 1.94575731e-02f, 1.86814532e-01f, 1.46579519e-01f, -1.56467855e-02f, -1.44035220e-01f,
  -1.09201506e-01f, -1.62852153e-01f, -3.44342478e-02f, 1.89557485e-02f, 2.38784805e-01f, 8.29450861e-02f, -2.05914795e-01f, -1.07223958e-01f, 2.65521761e-02f, -2.56664716e-02f,
  1.42450314e-02f, 1.72687709e-01f, -6.40755193e-03f, -7.22598583e-02f, -7.25772753e-02f, 1.34866670e-01f, -4.11555506e-02f, 9.34747308e-02f, 3.29426639e-02f, 5.89768216e-02f,
  1.00172319e-01f, -2.05924921e-03f, 1.13518618e-01f, 1.79420814e-01f, 1.52217761e-01f, 1.85123071e-01f, 5.63905202e-02f, 1.31151482e-01f, 1.65540189e-01f, 1.53665379e-01f,
  6.26128539e-02f, 5.13669476e-02f, 1.08734943e-01f, 1.81190148e-01f, 3.17009911e-02f, 8.73833448e-02f, 3.11716925e-02f, 1.07885944e-02f, 4.18941155e-02f, -1.14587933e-01f,
  -7.27252513e-02f, -2.50488259e-02f, -5.82168028e-02f, 8.87619033e-02f, -4.67715710e-02f, -9.78859290e-02f, 6.03888184e-02f, -1.45508945e-02f, 1.23267680e-01f, -8.28889906e-02f,
  -8.96421745e-02f, -3.28423567e-02f, 1.30967110e-01f, -4.41669784e-02f, 1.24188453e-01f, -3.88798602e-02f, 1.65871933e-01f, -1.71117485e-01f, 3.74302198e-03f, -2.11683530e-02f,
  1.07542917e-01f, -2.69110370e-02f, -1.07679777e-01f, -6.93908846e-03f, 2.54800785e-02f, 1.42164147e-02f, -1.89002469e-01f, -1.66584045e-01f, 1.37832269e-01f, 1.33057414e-02f,
  1.54671818e-01f, 1.99066713e-01f, 8.59557316e-02f, 1.50743383e-03f, 2.09243763e-02f, -6.66847676e-02f, 4.03623879e-02f, 1.21711284e-01f, -1.02942526e-01f, -3.24188620e-02f,
  -1.26988478e-02f, -1.02101624e-01f, -6.01688102e-02f, -9.06542316e-02f, 1.12978294e-01f, 3.43733728e-02f, 3.87291126e-02f, 8.07928294e-02f, 1.52861420e-02f, 5.13244830e-02f,
  1.60029069e-01f, 5.58734797e-02f, 3.49318162e-02f, 8.75162557e-02f, 1.35723084e-01f, -4.86331023e-02f, 8.72529149e-02f, 2.52665076e-02f, 1.39741138e-01f, -7.46046752e-02f,
  -1.30517483e-01f, 9.15154666e-02f, -2.16870792e-02f, -1.03769347e-01f, -8.20248295e-03f, 6.47915676e-02f, 8.75020400e-02f, 1.52536593e-02f, -2.34674573e-01f, 2.09348887e-01f,
  2.89487671e-02f, -1.80499315e-01f, -1.62353650e-01f, 3.37141789e-02f, -2.45181583e-02f, 1.71979979e-01f, -6.00625724e-02f, 5.48348576e-02f, 8.02435074e-03f, -7.17103248e-04f,
  -4.37612869e-02f, 1.87029243e-01f, -9.18009952e-02f, -5.07205836e-02f, -5.69226556e-02f, -2.00184751e-02f, 7.78323188e-02f, -4.51689512e-02f, 2.45441914e-01f, 2.27477163e-01f,
  -1.55907860e-02f, 8.97330120e-02f, -1.38099238e-01f, 2.39296574e-02f, 1.71629682e-01f, 3.44245955e-02f, -1.31278545e-01f, -7.62694925e-02f, -3.92294452e-02f, -1.35697946e-01f,
  8.03375319e-02f, -7.35741183e-02f, 3.33537459e-01f, -4.63219956e-02f, -1.71747711e-02f, -9.51695293e-02f, 2.62390077e-01f, -3.90503854e-02f, -8.19065869e-02f, 2.01355353e-01f,
  1.68284625e-01f, 9.90252495e-02f, 5.79404533e-02f, 1.35228574e-01f, -1.50969140e-02f, 8.68137330e-02f, 1.12928934e-01f, 1.01832435e-01f, 1.07358873e-01f, 1.49765372e-01f,
  8.74991417e-02f, 5.09049892e-02f, 6.86720237e-02f, 1.73180714e-01f, -1.17131546e-01f, -1.12544127e-01f, 2.00092457e-02f, 2.08636448e-02f, -7.36755431e-02f, 2.38012791e-01f,
  1.52602121e-01f, 2.04823092e-01f, 8.73290971e-02f, -4.83585037e-02f, 5.11603765e-02f, 2.55884398e-02f, 1.54378980e-01f, 3.14019829e-01f, 9.75981727e-03f, 1.85449883e-01f,
  1.97782949e-01f, 1.78798527e-01f, 1.08183540e-01f, 2.65133709e-01f, -1.08209394e-01f, 1.24317437e-01f, -2.71336213e-02f, -1.00280777e-01f, 7.13478178e-02f, 1.23017810e-01f,
  -1.79630741e-01f, -1.33029103e-01f, -1.96205080e-01f, 4.11630422e-02f, -2.12760687e-01f, -1.58902660e-01f, 1.29016981e-01f, 1.01639973e-02f, 6.40743226e-03f, -5.82535267e-02f,
  1.04805425e-01f, 2.96919078e-01f, -2.43621282e-02f, 4.26669307e-02f, 1.12719715e-01f, -1.02186404e-01f, -4.04270217e-02f, 1.32995144e-01f, 1.74528435e-01f, -4.22361717e-02f,
  1.46014363e-01f, 5.14694266e-02f, 1.05104625e-01f, 1.86723843e-02f, -8.16888511e-02f, -3.82154472e-02f, 3.42823081e-02f, 2.47120112e-03f, 1.61691532e-01f, 1.40693337e-01f,
  9.99395698e-02f, 1.12698190e-01f, 1.30521938e-01f, -8.03921893e-02f, 5.67105860e-02f, 9.02756602e-02f, 7.57156610e-02f, -7.83663802e-03f, -2.93397158e-02f, -6.13033287e-02f,
  7.50751123e-02f, -8.88187364e-02f, 4.71885800e-02f, 3.13238233e-01f, 5.00116795e-02f, 1.33198708e-01f, -5.63271493e-02f, 2.84522325e-01f, -1.06293403e-01f, -1.24090157e-01f,
  -2.26522744e-01f, 8.97361562e-02f, 1.76565093e-03f, 2.67785609e-01f, 3.53563502e-02f, 2.08197445e-01f, 4.68497090e-02f, 1.96997076e-01f, -1.14873283e-01f, 2.04420656e-01f,
  3.36834267e-02f, -2.19085366e-01f, -1.49189189e-01f, 3.34254242e-02f, 6.30481988e-02f, 4.24927883e-02f, 1.32246509e-01f, 2.53130615e-01f, -3.97114735e-03f, 1.81126997e-01f,
  -2.88092494e-01f, 1.00858606e-01f, 7.94732794e-02f, -9.96378288e-02f, -6.73322752e-02f, -1.56341612e-01f, -2.50972547e-02f, 4.07790355e-02f, 1.72464564e-01f, 7.74681242e-03f,
  3.69415611e-01f, -1.07690059e-01f, -4.35151812e-03f, 3.98539053e-03f, 1.49462000e-01f, -1.22137688e-01f, -9.18740183e-02f, 2.48828843e-01f, 8.82683471e-02f, 8.57181251e-02f,
  1.70818403e-01f, -2.24734731e-02f, 2.03658968e-01f, 1.63826555e-01f, 8.78911614e-02f, 5.19372486e-02f, 1.82695955e-01f, 8.26944113e-02f, 1.39416471e-01f, 1.00444064e-01f,
  4.83751968e-02f, -1.71442717e-01f, 1.19444355e-01f, 1.47678033e-02f, -1.58934012e-01f, 3.52129824e-02f, 5.82018532e-02f, -2.72318013e-02f, -6.78530037e-02f, -8.80518407e-02f,
  9.68110561e-02f, -9.29938480e-02f, -4.96252626e-02f, 2.85734031e-02f, -9.08892676e-02f, 1.43755063e-01f, -1.29932687e-01f, -1.06469981e-01f, -1.11421771e-01f, -1.42926574e-01f,
  -7.82838538e-02f, 1.64507121e-01f, -1.60288721e-01f, 5.15201502e-02f, 1.83841109e-01f, -2.00425893e-01f, 6.83523938e-02f, 6.56711832e-02f, 2.66804546e-01f, 1.28401458e-01f,
  3.62709574e-02f, -1.20165579e-01f, 2.59735644e-01f, 1.97266445e-01f, -2.14227184e-04f, -9.49265957e-02f, -2.64273304e-02f, -1.26369283e-01f, -1.52734853e-02f, -2.35923961e-01f,
  9.74430814e-02f, 1.40039667e-01f, -8.95711929e-02f, 1.77863210e-01f, 9.18304697e-02f, -5.48743531e-02f, -1.63857147e-01f, 1.67873472e-01f, 3.78817040e-03f, 1.29953295e-01f,
  3.89858894e-02f, -2.24274583e-02f, 1.36330858e-01f, 2.74165422e-01f, -1.09415967e-04f, 2.35400945e-01f, -5.36433607e-02f, 2.24227607e-01f, 5.88053316e-02f, 1.46538585e-01f,
  1.64890978e-02f, 6.07180186e-02f, 1.58444554e-01f, 1.82995960e-01f, -1.70060962e-01f, 7.18525611e-03f, -1.39931263e-02f, -4.58060913e-02f, 3.47855664e-03f, -8.35438147e-02f,
  -2.32817084e-01f, -8.29893500e-02f, -1.29912019e-01f, -1.61584448e-02f, -1.89737771e-02f, -4.03998680e-02f, 6.99228719e-02f, -5.48362248e-02f, 1.93788353e-02f, -2.19536245e-01f,
  2.66281758e-02f, -1.29282996e-01f, -5.13853356e-02f, -8.78676772e-02f, 2.89867464e-02f, -3.05359155e-01f, 7.22506568e-02f, -4.40273397e-02f, 9.17500854e-02f, -8.78719985e-03f,
  7.54752532e-02f, -9.54627767e-02f, 2.57970039e-02f, -2.10695967e-01f, 6.13970906e-02f, 1.50442701e-02f, -8.19247216e-02f, -2.02783823e-01f, 9.76534933e-02f, -7.85626844e-02f,
  1.33790821e-01f, 2.18690142e-01f, 1.80442110e-01f, 1.43918768e-01f, 1.14272945e-01f, -2.01858714e-01f, -7.71598965e-02f, 1.81932226e-01f, -3.20119441e-01f, -7.19595477e-02f,
  1.30357845e-02f, -7.44109452e-02f, -2.43876010e-01f, -1.11275434e-01f, 1.70799956e-01f, -6.83586299e-02f, 9.94640216e-02f, 1.66120440e-01f, 1.09033264e-01f, 2.14666069e-01f,
  4.16105390e-02f, 5.84446117e-02f, 1.14507265e-01f, 1.29758105e-01f, 6.78227842e-02f, 1.54109418e-01f, 1.14900276e-01f, 2.76665211e-01f, -1.89151661e-03f, 6.64345995e-02f,
  6.10032640e-02f, -6.36444166e-02f, 8.43254700e-02f, -1.48105696e-01f, -1.77987859e-01f, -1.67292818e-01f, -2.03741044e-02f, -3.74173075e-02f, -1.00780688e-01f, -1.49230495e-01f,
  5.47884069e-02f, -6.22877255e-02f, 1.51050046e-01f, -1.36216179e-01f, -1.08210899e-01f, 5.08268783e-03f, 5.28473966e-03f, -1.90925021e-02f, 3.68906409e-02f, -2.62665153e-01f,
  1.68328077e-01f, -1.78832948e-01f, 1.81450639e-02f, 8.73222575e-02f, -2.32852194e-02f, -8.24557319e-02f, -1.20638847e-01f, 2.14169547e-02f, 1.69319421e-01f, -7.66605735e-02f,
  -7.38112852e-02f, -1.47688746e-01f, 1.46581262e-01f, 3.92086394e-02f, 4.28544506e-02f, 1.53721735e-01f, 7.56931826e-02f, -1.00073673e-01f, 1.78249832e-02f, -4.62172441e-02f,
  -2.04286957e-03f, 1.29280910e-01f, -1.19794130e-01f, -5.20030782e-03f, 3.11716646e-02f, -2.17963587e-02f, -1.33632794e-01f, -1.07650705e-01f, 3.18948529e-03f, -7.71811837e-03f,
  3.03003341e-02f, 1.92927793e-01f, 1.64440528e-01f, 2.49984208e-02f, 1.42404422e-01f, 2.22654954e-01f, 9.95375291e-02f, 6.02126531e-02f, 6.56827614e-02f, 1.79580852e-01f,
  1.36172578e-01f, -1.21566327e-02f, 1.31179513e-02f, 1.21237457e-01f, 1.49561316e-01f, -1.89067513e-01f, -1.41618093e-02f, 1.08352736e-01f, -7.51722828e-02f, 2.02586949e-01f,
  -5.04722446e-02f, 5.19585088e-02f, -9.28960927e-03f, 1.24730252e-01f, 5.47192059e-02f, -2.18278100e-03f, -2.36463957e-02f, 2.32944593e-01f, -2.68089101e-02f, 4.09266762e-02f,
  1.68286085e-01f, 1.45513445e-01f, 1.36073366e-01f, 3.90392125e-01f, 7.84814265e-03f, -1.09182335e-01f, 3.53478268e-02f, -2.25503951e-01f, 1.47614488e-02f, -4.44042347e-02f,
  -9.32457894e-02f, 2.21220776e-02f, -6.34793416e-02f, 8.14368390e-03f, -1.41769201e-01f, 2.68205721e-02f, 7.14644417e-02f, 2.26202942e-02f, -1.02265991e-01f, -4.19056490e-02f,
  -9.41177458e-02f, -1.71203062e-01f, -2.80754548e-03f, 4.22262512e-02f, 2.62663253e-02f, -4.59361784e-02f, -1.29826173e-01f, 1.17951622e-02f, -1.32447168e-01f, -8.15216359e-03f,
  -2.03083754e-02f, -7.44145783e-03f, -1.05454344e-02f, 2.10927352e-01f, -4.92647327e-02f, -2.98515353e-02f, -3.12012667e-03f, 1.14381313e-01f, 1.51655406e-01f, 1.86499923e-01f,
  9.81336161e-02f, -2.81415600e-02f, 1.62323952e-01f, 2.00307630e-02f, 9.99548361e-02f, 1.73185170e-02f, 5.13253883e-02f, 1.82764843e-01f, -1.48614854e-01f, 6.15010746e-02f,
  -6.01902381e-02f, 1.13993632e-02f, -1.21675029e-01f, 2.75191456e-01f, 6.50271475e-02f, 1.92141593e-01f, 2.23177560e-02f, 1.60708621e-01f, 4.30440642e-02f, -1.10615812e-01f,
  -2.31844649e-01f, 7.28299171e-02f, 1.16981007e-01f, 1.36845917e-01f, 6.04918115e-02f, 3.29677492e-01f, -6.71452982e-03f, 2.87759781e-01f, -2.21593589e-01f, 2.15385094e-01f,
  -8.86316150e-02f, -2.63782740e-01f, -1.03191540e-01f, 2.04996690e-02f, 1.56599353e-03f, -1.16154879e-01f, -1.63123578e-01f, 2.44397864e-01f, -2.57127762e-01f, -1.35673404e-01f,
  -3.26060593e-01f, -9.86048393e-03f, 2.55974978e-01f, 1.29875869e-01f, -2.93700472e-02f, 2.82818586e-01f, 3.88452895e-02f, -8.84012505e-02f, 1.05753288e-01f, 5.98377399e-02f,
  2.20751837e-01f, -6.62996247e-02f, 2.68684655e-01f, 1.77952219e-02f, 6.72266707e-02f, -1.52936533e-01f, 5.68744130e-02f, 5.65030016e-02f, 6.40931875e-02f, 1.23281576e-01f,
  1.53945118e-01f, 8.07414800e-02f, 8.11289102e-02f, 3.23060304e-02f, 1.71353355e-01f, 7.50815421e-02f, 1.39987037e-01f, 1.98944304e-02f, 5.75975217e-02f, 2.46383518e-01f,
  -5.22248484e-02f, -1.10391043e-01f, -1.76821332e-02f, 1.22351974e-01f, 6.10755896e-03f, 2.14008037e-02f, 2.97399685e-02f, -9.39388499e-02f, 5.06363213e-02f, 7.02250842e-03f,
  4.27431129e-02f, 2.03691218e-02f, 1.99491829e-02f, -3.92608121e-02f, -6.75066561e-02f, -1.46574125e-01f, 3.45571637e-02f, 1.86760370e-02f, -1.51424304e-01f, -1.81063205e-01f,
  -9.02004689e-02f, -5.01374565e-02f, 9.98105407e-02f, 1.13391027e-01f, -2.76246406e-02f, 1.06374480e-01f, -1.91645604e-02f, -4.58467789e-02f, 2.80979484e-01f, 1.47786111e-01f,
  7.11945668e-02f, 4.93323691e-02f, 9.69246551e-02f, 7.20736608e-02f, -3.91206071e-02f, -5.23292385e-02f, 1.95984825e-01f, 1.17445551e-01f, -2.13171337e-02f, 8.12216848e-02f,
  6.78498372e-02f, -3.53662260e-02f, -6.71542138e-02f, 4.69478965e-02f, 1.68051422e-01f, -1.13271497e-01f, -5.71811236e-02f, 1.20063834e-01f, -7.31728896e-02f, 1.17368763e-02f,
  3.89074162e-03f, 1.58624481e-02f, 1.52515620e-01f, -3.78606915e-02f, 9.08471569e-02f, -7.99005572e-03f, 1.12277761e-01f, 1.68070525e-01f, 9.30378437e-02f, 1.18471421e-02f,
  4.79479544e-02f, 5.19211516e-02f, -1.99357476e-02f, -1.16039775e-01f, -3.31112519e-02f, -7.26410327e-03f, 8.35187733e-02f, -5.68663292e-02f, -3.71887311e-02f, 1.80761412e-01f,
  -1.85669009e-02f, 2.79154256e-02f, -7.97659159e-02f, 1.37787238e-01f, 6.60952181e-02f, -1.31499603e-01f, 6.16296940e-02f, 1.14439003e-01f, 2.05423012e-01f, 1.93050042e-01f,
  3.47426869e-02f, 9.05847643e-03f, 1.56784847e-01f, -6.81744739e-02f, 1.55111611e-01f, 2.06010327e-01f, -2.95318738e-02f, 6.49633780e-02f, 7.38874078e-02f, -3.43213789e-02f,
  1.01796113e-01f, 1.25745296e-01f, -9.77343023e-02f, -1.56030297e-01f, -1.13278419e-01f, -1.53230622e-01f, 7.07749557e-03f, -7.85487890e-02f, 2.12743700e-01f, -9.45002958e-02f,
  -2.29395762e-01f, -1.11122802e-01f, 9.92224142e-02f, 8.42172727e-02f, 8.20488483e-02f, -5.76865375e-02f, 1.62186306e-02f, 3.67740318e-02f, -1.29029537e-02f, 1.48311421e-01f,
  9.94297415e-02f, 3.99774231e-04f, -2.71864720e-02f, 1.46811053e-01f, 6.38625696e-02f, 5.90602830e-02f, 4.65562008e-02f, 1.81246653e-01f, 8.40805173e-02f, 1.20516509e-01f,
  -4.61135320e-02f, 2.80046836e-02f, -7.06723705e-02f, 1.59486577e-01f, -2.32207887e-02f, 6.54183477e-02f, 5.68242185e-02f, 9.04084072e-02f, -1.81031168e-01f, 1.75254181e-01f,
  4.61384058e-02f, -6.45924434e-02f, 3.81606296e-02f, -1.31474659e-01f, 4.13847081e-02f, 8.02414641e-02f, -9.51264352e-02f, -1.22574810e-02f, 8.17874819e-02f, 9.72323790e-02f,
  -1.22279331e-01f, 2.08008438e-01f, 1.97807297e-01f, 7.58501440e-02f, -9.65990722e-02f, -1.38370410e-01f, 1.90867737e-01f, 2.01753765e-01f, 1.50304556e-01f, -3.10584307e-02f,
  1.10151872e-01f, -1.91357061e-01f, 3.89796905e-02f, 1.58888370e-01f, -6.25882372e-02f, -3.68688926e-02f, -5.86854480e-02f, 2.39936247e-01f, -8.84088799e-02f, -4.36376557e-02f,
  -1.42437100e-01f, -4.74934839e-03f, 1.55182183e-01f, 1.47186860e-01f, 1.09322451e-01f, 1.25286341e-01f, -3.84887457e-02f, 5.43240132e-03f, -5.36451489e-02f, 1.91123858e-01f,
  2.49036312e-01f, -1.15163438e-02f, 8.07217285e-02f, -3.22690010e-02f, 4.85248342e-02f, 1.77292451e-01f, 3.47993821e-02f, -2.14734510e-01f, -3.62418294e-02f, 2.03002051e-01f,
  4.17052396e-03f, 2.58720759e-02f, 1.15732789e-01f, 1.72901854e-01f, 7.25049302e-02f, -4.19946946e-02f, -3.35544832e-02f, 7.08907247e-02f, 1.10771246e-01f, 1.11901551e-01f,
  5.74015863e-02f, 1.00591071e-01f, -8.52370709e-02f, 4.00450192e-02f, 4.82575148e-02f, 3.95703055e-02f, 7.42183328e-02f, -4.76021692e-02f, -3.55278440e-02f, 2.52093822e-02f,
  -1.03018112e-01f, -2.24406626e-02f, 1.03649393e-01f, 2.78046285e-03f, 3.89339961e-02f, 5.59500000e-03f, 3.58369239e-02f, -3.80305797e-02f, -1.18591554e-01f, -1.21946722e-01f,
  1.17163986e-01f, 7.76246414e-02f, 6.03337511e-02f, -1.35130793e-01f, 7.93390125e-02f, -1.02131590e-01f, 7.21884817e-02f, 1.19282112e-01f, -3.23572420e-02f, -6.82876185e-02f,
  -3.36937942e-02f, 6.54831082e-02f, -3.49974595e-02f, 6.34846240e-02f, -1.65586755e-01f, -1.14592230e-02f, 1.47316515e-01f, 1.25133350e-01f, 1.52635619e-01f, 1.97880954e-01f,
  1.45074604e-02f, -6.21313006e-02f, -4.65995483e-02f, -5.04486635e-03f, 1.66132316e-01f, 2.24908739e-02f, 8.75048041e-02f, -1.14069566e-01f, 3.08127310e-02f, 5.07369637e-02f,
  -9.67000946e-02f, -1.62308827e-01f, 6.75440114e-03f, 2.39422061e-02f, 1.88676622e-02f, -6.39710501e-02f, 1.64431468e-01f, -6.39887676e-02f, 5.44352755e-02f, 7.56960083e-03f,
  1.29551485e-01f, 9.99031886e-02f, 4.84283790e-02f, 8.48640203e-02f, 1.02845222e-01f, 2.18702748e-01f, 2.08131045e-01f, -1.61887243e-01f, -2.95351386e-01f, 2.36225247e-01f,
  9.58386287e-02f, -5.11921309e-02f, -4.30401303e-02f, -2.24606052e-01f, 2.41428986e-01f, 1.64390802e-02f, -1.98799968e-01f, -9.45462734e-02f, 1.13919616e-01f, -1.08720347e-01f,
  -2.68024467e-02f, 5.68953715e-02f, 2.65815705e-01f, 2.77767479e-01f, -9.08810422e-02f, -1.75132185e-01f, -1.30998716e-01f, -1.62835225e-01f, -1.13620954e-02f, 2.22854197e-01f,
  -2.02817932e-01f, 1.80876851e-01f, -8.48966166e-02f, 1.17818095e-01f, 2.09472865e-01f, -1.47819355e-01f, 2.32500106e-01f, -7.84134418e-02f, 1.69605538e-01f, -1.67089477e-02f,
  -1.20541655e-01f, -2.21524641e-01f, -5.30219153e-02f, -2.48690978e-01f, 5.26836105e-02f, 1.74906179e-01f, -1.12711769e-02f, -7.59193525e-02f, -1.11175023e-01f, -7.76899680e-02f,
  4.99236770e-02f, 3.38854119e-02f, 1.35056809e-01f, 1.10503249e-01f, 1.09763272e-01f, 1.36985078e-01f, -4.03999398e-03f, -9.27332267e-02f, -4.83048595e-02f, 1.12292049e-02f,
  9.91373509e-02f, -1.09478772e-01f, 1.52935252e-01f, 1.43988386e-01f, 3.94754745e-02f, 1.55372649e-01f, 1.02242783e-01f, -2.57726032e-02f, 2.56378502e-02f, 8.02826062e-02f,
  -1.14866808e-01f, -9.62435603e-02f, 1.87568720e-02f, 4.93772030e-02f, -1.05667904e-01f, 2.68048886e-02f, 4.03279923e-02f, 2.48715412e-02f, 1.36373304e-02f, -1.66087449e-01f,
  1.77214295e-01f, -9.15128365e-02f, 3.53586078e-02f, 1.72229171e-01f, -1.70175761e-01f, 8.37887079e-03f, 5.44249043e-02f, -5.96675165e-02f, -1.23414427e-01f, -1.19992696e-01f,
  -5.90778776e-02f, 6.29914925e-03f, -1.34141266e-01f, -4.79569994e-02f, 2.31813580e-01f, -1.89107239e-01f, 2.40233228e-01f, 1.43237904e-01f, 1.22485481e-01f, 2.33920023e-01f,
  -1.18307889e-01f, -1.38005346e-01f, 1.56329632e-01f, 1.09130368e-01f, 3.50997262e-02f, 7.95093626e-02f, -8.86624306e-02f, -8.93174112e-02f, 8.89345631e-02f, -1.18657999e-01f,
  1.05224527e-01f, 1.63966954e-01f, -1.15337618e-01f, 1.67307273e-01f, -1.02621496e-01f, 3.14804655e-03f, -8.16702917e-02f, 4.89404909e-02f, -1.50036421e-02f, 1.57232191e-02f,
  7.20610991e-02f, -6.45358041e-02f, -3.34511958e-02f, 1.78941339e-02f, 6.55178502e-02f, 1.13058753e-01f, 3.03018726e-02f, -7.21393302e-02f, 1.90776084e-02f, 1.34362847e-01f,
  1.28470570e-01f, 4.31759544e-02f, 2.01145366e-01f, 9.08309817e-02f, 1.52038813e-01f, 8.84048194e-02f, -1.13263823e-01f, -2.29278617e-02f, 9.67121944e-02f, -2.31010303e-01f,
  1.13169774e-01f, 1.22875482e-01f, 3.03581674e-02f, 2.02170126e-02f, 2.84311041e-04f, 1.67405292e-01f, -1.27818482e-02f, -5.08109555e-02f, 2.58649755e-02f, -7.69076273e-02f,
  -1.66048065e-01f, 2.59870917e-01f, 3.43825743e-02f, 1.96935520e-01f, -2.70093363e-02f, 1.18528843e-01f, 4.16836701e-02f, 9.20219794e-02f, -4.73020785e-02f, 8.00398737e-02f,
  -1.96581900e-01f, -7.62255862e-02f, -8.26389268e-02f, 8.65990072e-02f, 1.91626802e-01f, 2.12344557e-01f, -5.98413385e-02f, 3.60835791e-02f, -1.68046892e-01f, 1.10868081e-01f,
  3.01106691e-01f, 3.14313471e-02f, -6.00395203e-02f, -2.00951565e-02f, -2.09242832e-02f, 1.20369777e-01f, 2.10743591e-01f, -9.12907198e-02f, 1.74018130e-01f, -1.24216281e-01f,
  9.80733633e-02f, -5.96145391e-02f, 2.52703816e-01f, -7.59483278e-02f, 1.06583096e-01f, 1.88197538e-01f, 1.56313062e-01f, 4.56190221e-02f, 1.66335907e-02f, 4.17452566e-02f,
  -3.59493941e-02f, 2.03808755e-01f, 2.05961734e-01f, 3.98208760e-03f, 9.53208879e-02f, 4.44309264e-02f, 5.83958961e-02f, 5.89691214e-02f, -4.29197624e-02f, -1.17095187e-02f,
  -8.04776028e-02f, -6.57110885e-02f, 1.47367707e-02f, 6.02956004e-02f, -8.18661228e-02f, -1.33978292e-01f, 5.12490720e-02f, 8.05979073e-02f, -2.32639462e-02f, -7.29105026e-02f,
  -1.13481246e-02f, 1.18981197e-01f, 1.54600948e-01f, 4.70921677e-03f, 1.54210389e-01f, -8.88977498e-02f, 1.19664721e-01f, -7.77310655e-02f, 2.74973288e-02f, -1.99619085e-01f,
  1.64410010e-01f, 4.93786223e-02f, 5.64027242e-02f, 1.67050958e-02f, 2.09027603e-01f, 2.87684388e-02f, 5.28216250e-02f, -1.02140792e-01f, -1.23691065e-02f, -1.24190763e-01f,
  -3.59980427e-02f, -1.18432119e-01f, 2.17818126e-01f, -5.84424660e-02f, -5.60815148e-02f, -6.89769089e-02f, 1.30550131e-01f, 1.99625462e-01f, 8.67953151e-02f, -5.47892265e-02f,
  -1.30635232e-01f, 5.56585230e-02f, -2.47576907e-01f, 2.89266407e-02f, 4.73452061e-02f, -4.10019420e-03f, -1.61732659e-01f, 5.07768951e-02f, 2.06292700e-02f, -5.24672195e-02f,
  9.11390409e-02f, 2.04692423e-01f, 8.62183049e-02f, 8.30359086e-02f, 9.97056812e-02f, 1.99962527e-01f, 1.04055360e-01f, 1.41280413e-01f, 1.26015261e-01f, 1.54030979e-01f,
  6.49738163e-02f, -8.11902210e-02f, -2.60329042e-02f, 1.28923014e-01f, 1.31503567e-01f, -1.25812590e-01f, -6.38719350e-02f, 1.43711299e-01f, -4.78312373e-02f, 1.01871796e-01f,
  -6.87636957e-02f, 5.97722940e-02f, -3.79356602e-03f, 2.73923390e-02f, -5.13828360e-02f, 1.13595881e-01f, 1.34647653e-01f, 3.37794423e-01f, -5.37923798e-02f, 1.48477815e-02f,
  2.46205747e-01f, 9.93956923e-02f, 1.71420351e-01f, 2.85445511e-01f, -2.94094682e-02f, 2.74684671e-02f, 1.03460714e-01f, -1.86836481e-01f, 1.63435861e-01f, 8.87619108e-02f,
  -1.44221485e-01f, -1.39117241e-01f, -8.32984075e-02f, 1.98796224e-02f, -1.24413736e-01f, 2.72982381e-03f, 2.21298024e-01f, -1.16802633e-01f, -2.50359148e-01f, -1.17294662e-01f,
  5.09789400e-03f, -3.69614922e-02f, -2.58994754e-02f, 9.49263200e-02f, -1.71658676e-02f, -6.27948418e-02f, -1.20176755e-01f, 1.38754338e-01f, 5.01758717e-02f, 1.50322225e-02f,
  4.32110727e-02f, 1.36668384e-01f, -4.33769301e-02f, 1.26422122e-01f, 1.30137399e-01f, 5.35261594e-02f, 2.40300205e-02f, 3.43029536e-02f, 1.17714442e-01f, 1.09617651e-01f,
  1.68002233e-01f, 3.98949087e-02f, 1.13640741e-01f, 8.44479725e-02f, 5.92176579e-02f, 6.27094805e-02f, -2.44166516e-03f, 2.73177074e-03f, -1.80485174e-01f, 5.66889532e-02f,
  -5.46008013e-02f, 8.77544284e-03f, -2.46623173e-01f, 1.16841912e-01f, 1.21161826e-01f, 1.11832991e-02f, 1.65066551e-02f, -1.38001278e-01f, 4.76489067e-02f, -1.90731250e-02f,
  1.93710346e-02f, 1.02625035e-01f, 3.90020981e-02f, 4.53242473e-02f, -7.69335851e-02f, -4.62836511e-02f, -1.64661147e-02f, 6.33299127e-02f, -4.07881700e-02f, 3.27045172e-02f,
  -2.61986684e-02f, -2.94436347e-02f, 3.81345563e-02f, 5.09437807e-02f, -4.36215959e-02f, -1.83146745e-01f, 5.60960267e-03f, 8.64101574e-04f, -1.43231004e-01f, -1.01868898e-01f,
  -7.44101033e-02f, -1.73598286e-02f, 1.22645143e-02f, -3.83918062e-02f, 2.26693898e-02f, 2.37809971e-01f, 1.30608991e-01f, -7.70665854e-02f, -3.41764092e-02f, 7.04375058e-02f,
  -2.12487757e-01f, -4.95543890e-02f, 1.89403161e-01f, 5.40919192e-02f, 2.68744351e-03f, -4.74135093e-02f, -4.99315225e-02f, -8.64758193e-02f, 1.82472795e-01f, -9.29182861e-03f,
  2.09751889e-01f, 3.96863185e-02f, 2.15108857e-01f, 1.99211791e-01f, 1.54639319e-01f, 9.06461105e-02f, 1.82665080e-01f, 1.74780130e-01f, 1.79252222e-01f, 7.63721317e-02f,
  2.55819350e-01f, 3.80124971e-02f, -8.65003169e-02f, -5.18190749e-02f, -8.54297541e-03f, 1.02642730e-01f, -7.74925128e-02f, -9.09900814e-02f, 9.98252630e-02f, 9.95291471e-02f,
  -1.12371705e-01f, -6.14026412e-02f, 9.75372717e-02f, -1.35602251e-01f, 4.37695608e-02f, 2.33753279e-01f, 1.14607483e-01f, 2.26885989e-01f, -6.10362254e-02f, -1.92627549e-01f,
  1.91710647e-02f, 1.41583100e-01f, -7.43735284e-02f, 5.47711439e-02f, -8.55873078e-02f, -3.84852514e-02f, -8.12194571e-02f, 9.25545245e-02f, 1.86779216e-01f, -1.31674275e-01f,
  7.99360499e-02f, -3.72347957e-03f, 1.62778318e-01f, 1.52485937e-01f, -5.46213165e-02f, -9.53101888e-02f, -2.42243767e-01f, -1.24049380e-01f, 6.65683001e-02f, 2.36143414e-02f,
  3.09071131e-02f, -9.12538096e-02f, -1.24395870e-01f, 6.14903234e-02f, -1.09206401e-01f, -6.11236505e-02f, -2.41404511e-02f, -4.49981540e-02f, 1.09270312e-01f, 1.68139204e-01f,
  -4.13597263e-02f, 1.48974755e-03f, 1.08888067e-01f, 1.28494233e-01f, 5.61927631e-02f, -9.56912264e-02f, 1.67715326e-01f, 1.05747156e-01f, 1.50143847e-01f, 6.15770780e-02f,
  7.15707913e-02f, 1.18241288e-01f, 1.56569824e-01f, -6.71896636e-02f, 5.40318573e-03f, 1.17831096e-01f, 1.56249583e-01f, -1.47433951e-01f, -5.14324661e-03f, 1.18599199e-01f,
  3.74237858e-02f, 1.41609982e-01f, 4.31726081e-03f, 4.47816662e-02f, -1.66846663e-02f, 1.57805309e-02f, 3.88195217e-02f, 1.81208134e-01f, 1.62619933e-01f, 3.14171702e-01f,
  -1.29302815e-01f, -6.87129609e-03f, 2.22041532e-01f, -1.82768106e-02f, 1.41937762e-01f, 2.63243824e-01f, -3.47775556e-02f, -2.72104982e-02f, 2.84560043e-02f, -2.41681367e-01f,
  1.49029896e-01f, 1.62591934e-01f, -1.48276046e-01f, 4.05722111e-02f, -1.07984610e-01f, -1.51789904e-01f, 6.37647212e-02f, 1.33980751e-01f, 1.00089163e-01f, -1.29993603e-01f,
  -3.45078319e-01f, -1.49239659e-01f, 6.17161170e-02f, -1.43914685e-01f, 5.01843216e-03f, 2.34185919e-01f, 7.09424391e-02f, 2.59569776e-03f, 2.80483253e-02f, 1.40497074e-01f,
  -1.45087279e-02f, 6.12307675e-02f, 1.63590759e-01f, 1.69323981e-01f, -1.02888875e-01f, 2.01431796e-01f, -6.39877468e-02f, 8.33240598e-02f, 1.27826914e-01f, 3.23986113e-02f,
  8.51526260e-02f, 2.71652509e-02f, -9.77028534e-03f, 1.38021052e-01f, 1.21935241e-01f, -4.91670556e-02f, 1.22255847e-01f, 7.14589953e-02f, 3.39394771e-02f, -2.01309994e-01f,
  -1.55822515e-01f, 2.90994018e-01f, 1.16617538e-01f, -2.38575295e-01f, 9.19536501e-03f, -2.65206277e-01f, 1.89722091e-01f, 6.24596700e-03f, -6.73518106e-02f, 1.80807170e-02f,
  -3.33731659e-02f, -6.76536337e-02f, -1.06288483e-02f, -2.28081197e-01f, -8.36965144e-02f, 1.45778116e-02f, -6.36875778e-02f, -1.89856797e-01f, -1.12335822e-02f, -2.43618220e-01f,
  7.85879884e-03f, 1.64575487e-01f, 3.03179994e-02f, 1.47350922e-01f, -1.08635388e-01f, -6.75885603e-02f, 2.11603701e-01f, 7.42290542e-02f, 2.47733414e-01f, -1.35600846e-02f,
  2.73042381e-01f, 1.57573894e-01f, -1.03072569e-01f, -9.26622003e-02f, 1.14012331e-01f, -1.52371423e-02f, -2.89437883e-02f, -1.21992461e-01f, -5.14877867e-03f, 1.30281270e-01f,
  1.27094284e-01f, -1.14037797e-01f, 2.52229005e-01f, 4.49342281e-02f, -2.22236723e-01f, 2.07931355e-01f, 1.58376664e-01f, 1.62904650e-01f, -1.09191909e-01f, 1.47395015e-01f,
  1.30877541e-02f, 6.22914769e-02f, 9.24895704e-02f, -7.56225586e-02f, 1.68010473e-01f, -5.96121280e-03f, -6.72765123e-03f, -1.37741743e-02f, 1.29857749e-01f, 6.98939636e-02f,
  4.24163230e-03f, 5.64454049e-02f, 1.25083625e-01f, -1.75343409e-01f, 6.36744052e-02f, 5.63240387e-02f, -1.31746745e-02f, 9.17612389e-02f, -3.28027718e-02f, -7.55644813e-02f,
  -7.80351311e-02f, -1.01356387e-01f, 6.86129928e-02f, 4.48057987e-02f, -3.88875208e-03f, -1.15616180e-01f, -6.43328652e-02f, 1.42431453e-01f, 1.23209385e-02f, -6.31853342e-02f,
  -8.02116245e-02f, -1.55214936e-01f, -3.14589068e-02f, 1.20716304e-01f, -7.63906166e-02f, 1.26397401e-01f, 1.33557856e-01f, -8.79240558e-02f, -8.20120052e-03f, 7.64624625e-02f,
  2.37952679e-01f, 5.89132681e-02f, 9.82173234e-02f, 6.83028325e-02f, 2.94161528e-01f, 1.66732028e-01f, -9.06272233e-02f, -1.24849685e-01f, 3.99379991e-02f, -7.23371208e-02f,
  -3.97083312e-02f, -1.83657870e-01f, -1.82766765e-02f, 4.94946018e-02f, -5.78294247e-02f, 1.71791520e-02f, 6.75415918e-02f, -5.05285300e-02f, -1.36264473e-01f, 3.35838385e-02f,
  1.03555722e-02f, 1.42726555e-01f, 5.61091758e-04f, 4.19156775e-02f, 9.06968862e-02f, 6.32172450e-02f, 2.02848792e-01f, -5.04585216e-04f, 7.26203397e-02f, 6.48670495e-02f,
  1.27951607e-01f, 1.47282267e-02f, 3.22909318e-02f, 8.20753500e-02f, 1.35470331e-01f, 2.03625858e-01f, 2.18472168e-01f, -1.76637232e-01f, -7.51337633e-02f, 2.10189372e-01f,
  9.60893631e-02f, -4.87249605e-02f, -1.46690011e-01f, -1.78413957e-01f, 1.72707334e-01f, 1.61546618e-02f, -9.46342275e-02f, -3.85830067e-02f, 8.10198486e-02f, -1.08453199e-01f,
  1.11429445e-01f, -2.50886440e-01f, 8.32466409e-02f, 9.96419266e-02f, -1.24481656e-01f, -2.12137282e-01f, 1.64027065e-02f, -2.62470096e-01f, 1.46263152e-01f, -5.33529408e-02f,
  -3.98431420e-02f, 1.25418693e-01f, -1.13838144e-01f, -9.61615443e-02f, 2.27102518e-01f, 1.02655485e-01f, 1.56359911e-01f, -1.49518969e-02f, 2.02608138e-01f, 1.42415449e-01f,
  -3.25670391e-02f, -3.35488655e-02f, -1.49406448e-01f, -1.66374788e-01f, 4.50356863e-04f, -1.09850407e-01f, 4.02566753e-02f, 3.22520509e-02f, -1.44557774e-01f, 2.77066827e-02f,
  4.10442352e-02f, 3.07283998e-02f, -1.85553357e-01f, 1.24086723e-01f, -4.58501577e-02f, 7.67551421e-04f, -2.49960124e-02f, -3.84146050e-02f, 9.01393816e-02f, -2.74566803e-02f,
  5.73983379e-02f, 5.30003523e-03f, 3.92408147e-02f, -1.84607506e-02f, 6.14129193e-02f, -4.86061629e-03f, 2.86648516e-02f, 5.57853505e-02f, 4.75588553e-02f, 6.88942075e-02f,
  1.80006742e-01f, -1.18685998e-01f, -2.41924152e-02f, 3.56807671e-02f, 6.89015016e-02f, 6.82416856e-02f, -4.52039652e-02f, -1.51131883e-01f, 4.53028604e-02f, 7.65516609e-03f,
  -8.93123522e-02f, -7.02268630e-03f, -1.64160300e-02f, -9.89134684e-02f, 3.35924849e-02f, -2.73942836e-02f, 1.44701013e-02f, 9.81994793e-02f, -1.04011029e-01f, -1.34773105e-01f,
  -4.19710092e-02f, -4.24746834e-02f, 4.16883864e-02f, 3.84085290e-02f, -8.40780046e-03f, 3.58102540e-03f, -5.75688370e-02f, -1.51289837e-03f, 1.54347375e-01f, -1.13871224e-01f,
  1.44231364e-01f, -1.58126117e-03f, 2.38063037e-01f, 6.69993535e-02f, -5.78630641e-02f, -9.49229151e-02f, -7.09877461e-02f, -1.24030486e-01f, -2.51763575e-02f, -1.02517024e-01f,
  2.60114539e-02f, -2.67830212e-02f, -7.55988061e-02f, 1.84706803e-02f, -4.45880778e-02f, -2.05243248e-02f, -1.30123124e-01f, -3.75386402e-02f, 9.30772200e-02f, 9.03778821e-02f,
  -4.40485291e-02f, -1.69642493e-02f, 6.37997836e-02f, 1.87953159e-01f, 1.88525081e-01f, 1.64301112e-01f, 1.26628429e-01f, 4.49131764e-02f, 1.88052356e-01f, 2.08304390e-01f,
  1.12676300e-01f, 1.80974782e-01f, 2.00554401e-01f, 2.06119388e-01f, -4.38865684e-02f, -1.31957363e-02f, -1.06513448e-01f, 1.38005406e-01f, -3.96344159e-03f, -9.58053023e-02f,
  -2.52956688e-01f, 8.89907067e-04f, -7.09273294e-03f, 4.58765179e-02f, -2.57088132e-02f, -9.19863880e-02f, 1.07420877e-01f, -9.99732018e-02f, -9.46799293e-02f, -2.36338571e-01f,
  1.25255272e-01f, 3.10452431e-02f, -9.00060087e-02f, 1.17210336e-02f, -4.19879779e-02f, -2.73182780e-01f, 1.66823864e-01f, -7.11452961e-02f, -1.81337763e-02f, 6.32031709e-02f,
  5.22543117e-02f, -5.37668504e-02f, 1.17200844e-01f, 1.03557050e-01f, 4.38600173e-03f, 8.56503323e-02f, -1.13125682e-01f, -3.51722911e-02f, 2.40384992e-02f, 1.14488877e-01f,
  1.57859266e-01f, 1.20775066e-01f, 8.35253671e-02f, 5.29994518e-02f, 4.39517088e-02f, -1.83416814e-01f, -6.97134137e-02f, 6.77494630e-02f, -9.75571424e-02f, -1.55656427e-01f,
  1.33169800e-01f, 5.82002848e-03f, -1.95965543e-01f, -2.08766684e-02f, 1.37311712e-01f, -1.01500412e-03f, 2.43690163e-02f, 1.62604859e-03f, -3.17296423e-02f, 6.66393861e-02f,
  1.32285565e-01f, 2.72826338e-03f, 9.54023283e-03f, -3.11425272e-02f, 3.31434086e-02f, 2.74592284e-02f, 1.38331503e-01f, 8.94213170e-02f, 7.94341937e-02f, 1.66964546e-01f,
  -8.43227133e-02f, -3.72692905e-02f, 9.03468654e-02f, -1.90894008e-01f, -1.43812522e-02f, 8.08742195e-02f, 5.87485880e-02f, 3.41860615e-02f, -1.35603607e-01f, 1.04278646e-01f,
  -4.35158275e-02f, -1.76505111e-02f, -5.16361073e-02f, -6.05516918e-02f, -1.27166092e-01f, 9.97761711e-02f, 4.38144431e-02f, 8.29326287e-02f, 5.49193732e-02f, 6.14227168e-02f,
  2.51723304e-02f, -5.86564466e-02f, -1.37136936e-01f, 9.80972126e-03f, -1.21428668e-01f, -6.83970973e-02f, -1.55919984e-01f, 1.15771040e-01f, 7.19363391e-02f, 2.25413755e-01f,
  -2.66639795e-02f, -6.12860695e-02f, -6.83268830e-02f, 1.11055747e-01f, 2.27916479e-01f, 5.15785851e-02f, -5.55118099e-02f, 5.83131984e-02f, -8.08111206e-02f, -1.53464023e-02f,
  1.52743012e-01f, -6.97386935e-02f, 1.98192015e-01f, -1.53255388e-01f, 4.68534604e-03f, -7.47643262e-02f, 1.10607155e-01f, 6.83738617e-03f, -2.00352687e-02f, 1.25309721e-01f,
  7.96625465e-02f, 1.04949102e-01f, 1.35222539e-01f, 3.25259054e-04f, 1.26318216e-01f, 6.59119636e-02f, 1.63406543e-02f, 6.22340813e-02f, 5.92634566e-02f, 1.41152576e-01f,
  1.26027316e-01f, -4.63697165e-02f, -8.86238664e-02f, -2.07568668e-02f, -4.92856875e-02f, -1.26895279e-01f, -1.04117520e-01f, 2.00213164e-01f, -6.65790075e-03f, 3.41657475e-02f,
  -1.20014943e-01f, -7.65263885e-02f, 2.10279077e-02f, -1.40207618e-01f, -3.13313454e-02f, 7.33624473e-02f, -7.28159547e-02f, 1.13237821e-01f, 4.90315370e-02f, -1.57262295e-01f,
  -9.78496857e-03f, -1.01407915e-01f, 2.50137206e-02f, 4.03375402e-02f, -5.92995584e-02f, 1.24116585e-01f, 1.44154668e-01f, -1.34848997e-01f, 2.47350916e-01f, 1.71094581e-01f,
  1.86212629e-01f, -6.69068322e-02f, -4.52989228e-02f, -2.68522017e-02f, 1.81317642e-01f, 2.07317434e-02f, -2.47865468e-02f, -1.89024806e-01f, -1.21026702e-01f, -3.14635783e-02f,
  2.65048426e-02f, 5.56308217e-03f, 1.42535130e-02f, -1.80576611e-02f, -1.13918625e-01f, 4.12994921e-02f, -7.92252421e-02f, -9.69820544e-02f, -3.92979942e-02f, -3.57606485e-02f,
  -1.13240242e-01f, 1.52632415e-01f, 3.02589163e-02f, -8.42956454e-02f, 1.55161368e-02f, -5.67803755e-02f, -2.00458057e-02f, -1.26668409e-01f, 1.78758308e-01f, 2.59905588e-02f,
  -3.02492995e-02f, 9.46931317e-02f, 7.73913413e-02f, -5.69584370e-02f, 1.16643598e-02f, -6.51279166e-02f, -1.35303020e-01f, -7.25683421e-02f, -1.87545642e-02f, -9.44232345e-02f,
  -1.24677792e-01f, 1.90015391e-01f, 4.37166542e-03f, -2.66241580e-02f, -1.30465813e-02f, -1.60964072e-01f, 1.55196294e-01f, -1.35609537e-01f, 5.37831187e-02f, 1.26716331e-01f,
  -6.65519312e-02f, 1.68020681e-01f, 9.04703804e-04f, -1.76145554e-01f, -4.80689630e-02f, -2.88868751e-02f, -7.25057349e-02f, 1.25312194e-01f, -1.05080262e-01f, 5.27363159e-02f,
  3.08979061e-02f, -5.62689938e-02f, 7.28148520e-02f, 5.45944162e-02f, 2.19827861e-01f, -6.01660945e-02f, -1.12391919e-01f, -3.22712697e-02f, 2.17865765e-01f, 1.10202774e-01f,
  -6.24697395e-02f, -5.18872291e-02f, -3.20989126e-03f, -1.02214716e-01f, 6.67186081e-02f, 7.82072544e-02f, -2.68569086e-02f, -3.92763317e-02f, -8.21494386e-02f, 8.37952942e-02f,
  -8.30035061e-02f, 1.95660722e-02f, 1.33903101e-01f, 5.64498641e-03f, -5.30919954e-02f, 2.21333906e-01f, 1.23651534e-01f, -5.79428039e-02f, 4.63643707e-02f, -4.91092056e-02f,
  -1.30856082e-01f, -9.00518671e-02f, -6.83495626e-02f, 1.06412284e-01f, -5.93564548e-02f, -7.02148257e-03f, -5.28433248e-02f, -1.92668289e-02f, -9.30477679e-02f, -1.14918016e-01f,
  -1.01921022e-01f, -6.87354356e-02f, -9.23663527e-02f, -4.44123298e-02f, -5.17691337e-02f, 1.28453329e-01f, 1.21908911e-01f, -5.61861955e-02f, 2.96887029e-02f, 7.41315447e-03f,
  6.59084544e-02f, -5.82217202e-02f, 1.14946537e-01f, 1.92214102e-01f, 5.43792397e-02f, 1.65385932e-01f, 1.97504461e-01f, -8.65801796e-02f, -3.34172719e-03f, 2.45585926e-02f,
  -3.25848386e-02f, 3.80856581e-02f, -2.21707914e-02f, 2.50533402e-01f, -4.38814722e-02f, 7.82089755e-02f, 2.40559071e-01f, 1.38984486e-01f, 6.33397922e-02f, 1.13550024e-02f,
  -1.12348907e-01f, 7.42021436e-03f, 6.39213622e-02f, -1.50303980e-02f, 5.08219749e-02f, -7.25180879e-02f, -9.84237343e-02f, -8.46436769e-02f, 4.98469360e-02f, 2.31934041e-01f,
  3.79078798e-02f, 3.31438556e-02f, -1.43228799e-01f, -2.03215051e-02f, 5.81981207e-04f, 1.14447877e-01f, 2.86453396e-01f, 1.29358619e-01f, -1.06313296e-01f, 1.63877860e-01f,
  -3.70926373e-02f, -1.49833396e-01f, 3.58882062e-02f, 9.36086774e-02f, 1.09770469e-01f, 1.72299385e-01f, 4.11245711e-02f, 1.85135473e-02f, 8.09213370e-02f, 7.16689453e-02f,
  3.16560938e-04f, 8.95224512e-02f, 1.25659391e-01f, 1.53726980e-01f, 4.38676961e-02f, 1.21192999e-01f, -1.56162262e-01f, -2.65079606e-02f, 7.73358718e-02f, -1.90109402e-01f,
  9.14382562e-02f, 1.00223962e-02f, 4.67908084e-02f, 6.90859631e-02f, 7.06777303e-03f, -9.59200133e-03f, -7.00721741e-02f, -1.59391165e-01f, -2.80776918e-02f, -1.28483117e-01f,
  -9.61976871e-02f, 1.64005473e-01f, 4.72084284e-02f, 1.02829352e-01f, -4.39372100e-03f, -8.14588144e-02f, 1.40646100e-01f, -4.00735810e-02f, -1.08563736e-01f, 1.89072192e-01f,
  -9.14522931e-02f, -1.00072518e-01f, -1.04757935e-01f, 5.80781177e-02f, 9.25580710e-02f, 2.45104060e-01f, -6.90834271e-03f, -1.22154588e-02f, 5.02478480e-02f, 1.07149281e-01f,
  2.12246925e-01f, 2.01592848e-01f, -1.07604526e-02f, 6.64109588e-02f, -9.41581056e-02f, -3.07879988e-02f, 2.30590533e-02f, -5.09793013e-02f, 1.87351719e-01f, -2.27833271e-01f,
  4.96004289e-03f, -5.05164601e-02f, 8.46356302e-02f, -9.50032398e-02f, -2.37571541e-02f, 4.83858623e-02f, 4.07857634e-02f, 5.97839467e-02f, 1.05325483e-01f, 5.09644635e-02f,
  7.48405829e-02f, 1.35366572e-02f, 3.60979810e-02f, 7.58444471e-03f, 1.03861295e-01f, 4.89643700e-02f, 1.08202547e-01f, 1.10128768e-01f, 4.86425078e-03f, 2.25098938e-01f,
  -4.17442471e-02f, 2.68698242e-02f, 1.46790862e-01f, -1.06349647e-01f, -1.45212403e-02f, -4.00205143e-02f, 1.15169860e-01f, 2.52100881e-02f, -5.63279577e-02f, -1.56888813e-02f,
  -4.39420454e-02f, -2.04640962e-02f, 2.39396945e-01f, 3.41646262e-02f, 4.53891233e-03f, -6.04453613e-04f, 2.25332201e-01f, 1.51132628e-01f, 1.07850693e-01f, -6.04580827e-02f,
  2.28509232e-01f, -5.02930954e-02f, -1.38783827e-01f, 2.38824815e-01f, -1.69144079e-01f, -7.46350810e-02f, -7.33021647e-02f, 6.24885829e-03f, 9.17087644e-02f, 5.87734058e-02f,
  -2.55003646e-02f, -9.46620405e-02f, 2.71200776e-01f, -7.24919140e-02f, 1.73255671e-02f, 1.11877486e-01f, -2.71615516e-02f, 3.59038413e-02f, -1.27813607e-01f, -5.14144674e-02f,
  9.18934196e-02f, -2.09505185e-01f, -9.33565199e-03f, -2.50624977e-02f, 9.69503482e-04f, -8.07680637e-02f, 4.66802716e-02f, -5.93109988e-02f, -1.00552708e-01f, -4.94949520e-02f,
  9.74893011e-03f, 1.49048805e-01f, 1.09946497e-01f, 6.51695728e-02f, -3.98840420e-02f, 6.03207238e-02f, 3.36752832e-02f, 2.09936630e-02f, 7.84943849e-02f, 9.21166316e-02f,
  -4.84225899e-02f, 1.17817827e-01f, -4.36775945e-02f, 1.16556890e-01f, 1.49057806e-01f, 5.57136014e-02f, 6.02219105e-02f, -6.29778802e-02f, 1.34836406e-01f, 5.80095686e-02f,
  -8.49295035e-02f, 2.30002329e-02f, 9.38937590e-02f, -8.03424325e-03f, -1.47257403e-01f, 1.61290064e-01f, 1.61334962e-01f, -4.91526388e-02f, -4.75554727e-02f, -8.97381753e-02f,
  7.12807477e-02f, 1.71234965e-01f, 8.69441703e-02f, -1.55875385e-01f, 1.14962414e-01f, -1.44063234e-01f, -5.56243621e-02f, 1.70467228e-01f, -2.39212494e-02f, -9.30448472e-02f,
  -2.94549447e-02f, 2.10788757e-01f, -7.04534072e-03f, 1.14857741e-01f, -1.93179652e-01f, 8.57211128e-02f, 2.75983125e-01f, 1.60563603e-01f, 1.48219928e-01f, 2.26042405e-01f,
  -9.24984217e-02f, -4.20035981e-02f, -1.44650778e-02f, 2.38916397e-01f, 1.78196028e-01f, -1.29412830e-01f, -7.63298990e-03f, 6.16952814e-02f, -2.68161893e-02f, 1.98526651e-01f,
  -1.17648140e-01f, -4.55024354e-02f, 2.72467155e-02f, 5.11675701e-02f, -1.22582100e-01f, 1.15475792e-03f, 1.25492901e-01f, -1.64658111e-02f, 6.03633514e-03f, -8.69637132e-02f,
  -2.59054825e-02f, 1.11031353e-01f, 6.21615015e-02f, -1.01006851e-01f, -3.02246176e-02f, 3.47740799e-02f, -1.00745060e-01f, -1.93816528e-01f, 9.52270702e-02f, 1.95022717e-01f,
  4.53743264e-02f, -1.67375296e-01f, 2.37894192e-01f, -2.90945806e-02f, -6.58512861e-02f, -7.70156980e-02f, 9.60031641e-04f, 8.25305805e-02f, -2.95882393e-02f, -2.25772131e-02f,
  -2.97384392e-02f, -1.40071005e-01f, 1.26476912e-02f, -2.92117205e-02f, -2.36939136e-02f, -4.24380600e-02f, -1.59354657e-01f, -1.20611437e-01f, 6.35799170e-02f, -9.56167001e-03f,
  2.10852940e-02f, 1.15841371e-03f, -1.41684964e-01f, -1.76303321e-03f, 1.89893961e-01f, 3.75829577e-01f, 1.30884305e-01f, 5.80802783e-02f, 4.15999256e-02f, 2.04754278e-01f,
  1.62228569e-02f, 3.61476876e-02f, 1.94439352e-01f, 4.67905030e-02f, -3.66876344e-03f, -1.11420415e-01f, 8.44491050e-02f, 9.60943848e-02f, 7.58236051e-02f, -7.31855556e-02f,
  3.99396867e-01f, 1.92694664e-01f, -7.04109594e-02f, 2.32353374e-01f, 2.06652917e-02f, -1.59354284e-01f, -9.11570638e-02f, 5.75609542e-02f, 1.05972260e-01f, 5.37596643e-02f,
  1.42643213e-01f, 1.93696804e-02f, 1.31910937e-02f, 1.45510718e-01f, 9.35555175e-02f, 8.85078870e-03f, 9.71046537e-02f, 5.34895174e-02f, 1.02440640e-01f, 4.37546223e-02f,
  2.03494743e-01f, 7.89855197e-02f, -1.09902792e-01f, -3.29966508e-02f, 8.85799453e-02f, -3.44551611e-03f, -1.17839046e-01f, 1.10856749e-01f, 2.11655095e-01f, 1.23579495e-01f,
  -1.49578229e-01f, -1.37444204e-02f, -2.29989979e-02f, 8.93503428e-02f, 6.89467564e-02f, 3.76653671e-02f, 1.19038157e-01f, 7.82011226e-02f, 1.90041572e-01f, 1.20414026e-01f,
  2.05565035e-01f, 1.10808291e-01f, 1.36858806e-01f, -1.46723278e-02f, -1.60637304e-01f, 1.54476419e-01f, -8.36456716e-02f, 5.03532076e-03f, -7.68407285e-02f, -1.16004206e-01f,
  9.61580798e-02f, 1.20528415e-01f, -8.04839209e-02f, -1.05273940e-01f, 1.03175573e-01f, -5.60058281e-02f, -1.65403023e-01f, 6.79817498e-02f, -5.64718507e-02f, 1.06547497e-01f,
  -1.29584111e-02f, -1.11612275e-01f, -4.97282147e-02f, -1.34668797e-01f, -1.94513395e-01f, 9.89890322e-02f, 1.47882178e-02f, -5.38100637e-02f, 6.43534437e-02f, 1.15037963e-01f,
  -2.76962630e-02f, 2.45389752e-02f, 1.92062512e-01f, 1.08076997e-01f, 3.98774967e-02f, -6.08704314e-02f, 1.12775475e-01f, 2.38738209e-01f, 2.09806576e-01f, 1.18939184e-01f,
  1.38262272e-01f, 3.31527069e-02f, 5.72286546e-02f, 4.43631895e-02f, -1.88547403e-01f, 2.81511694e-02f, 1.78822260e-02f, -1.33763522e-01f, -1.33966133e-01f, 1.36082426e-01f,
  -1.10913247e-01f, 2.33305246e-03f, -1.00933105e-01f, 6.43789992e-02f, 1.28536165e-01f, -3.89869809e-02f, -3.14669982e-02f, 1.79890633e-01f, 3.30989738e-03f, 2.91818351e-01f,
  7.15945289e-02f, -9.74882096e-02f, 1.28242839e-02f, -2.30377130e-02f, -3.07678375e-02f, 1.80953383e-01f, -1.53126735e-02f, 7.86823928e-02f, 5.85636124e-02f, -1.88744098e-01f,
  2.00767487e-01f, 1.24393336e-01f, 6.67988807e-02f, -1.23339906e-01f, -1.55163184e-01f, -6.76320419e-02f, 1.29556349e-02f, -2.73112655e-02f, -2.87823584e-02f, -1.61177427e-01f,
  -1.53400227e-01f, -5.03583811e-02f, 1.36906549e-01f, 1.60296112e-01f, 1.08417027e-01f, -2.66447533e-02f, -1.02858711e-02f, 1.27006039e-01f, -4.42991257e-02f, -4.37484756e-02f,
  9.35900286e-02f, -1.57231241e-02f, -4.22667339e-02f, 7.50677586e-02f, 1.36467636e-01f, -2.59821936e-02f, 4.40533645e-03f, 1.32683478e-02f, 6.46245554e-02f, 8.66998434e-02f,
  6.99220300e-02f, 1.96827382e-01f, -6.55184500e-03f, 6.92606717e-02f, 1.32315367e-01f, 5.62022477e-02f, 2.45012455e-02f, 1.46999568e-01f, 2.54496545e-01f, 6.88691959e-02f,
  -1.93297684e-01f, -1.28221586e-02f, 6.42587095e-02f, -2.25093439e-02f, -2.18176737e-01f, 5.87674230e-02f, 1.91216588e-01f, 1.20942354e-01f, -1.43904284e-01f, -1.04107589e-01f,
  9.84044746e-02f, -1.49235472e-01f, 1.22507219e-03f, 1.42443031e-01f, 1.27000660e-01f, 2.43306637e-01f, -5.84001318e-02f, 2.06939191e-01f, -2.08358876e-02f, 1.08589023e-01f,
  -3.74383181e-02f, 1.58462778e-01f, -1.62785724e-01f, 6.59180805e-02f, -1.49849102e-01f, 1.16744794e-01f, -1.17226571e-01f, -8.46583769e-02f, -9.08615720e-03f, 1.25107557e-01f,
  -6.02793135e-02f, -6.34646937e-02f, -1.41108572e-01f, 1.54627813e-02f, -2.65672412e-02f, 1.37652112e-02f, 1.51816318e-02f, 1.89833462e-01f, 1.07657745e-01f, -1.38284981e-01f,
  -2.86803748e-02f, -4.90232781e-02f, -2.73141563e-02f, 3.70277204e-02f, 1.17739156e-01f, -2.25887727e-02f, 1.43829465e-01f, 2.40759812e-02f, -8.26198012e-02f, -9.42889675e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.27119601e-01f, 3.89590301e-02f, 1.72179595e-01f, 7.97188804e-02f, -5.94663084e-04f, 9.06376094e-02f, 1.55275732e-01f, 1.02905661e-01f, 8.78236592e-02f, 1.54476941e-01f,
  5.24386652e-02f, 1.31702766e-01f, 1.88766688e-01f, 1.12542972e-01f, -6.06991537e-03f, 3.90142538e-02f, 2.34085292e-01f, -2.30295174e-02f, 1.11364566e-01f, 3.66173163e-02f,
  8.90507922e-02f, 1.20187446e-01f, 1.24851316e-01f, 6.96243569e-02f, 3.50026079e-02f, 1.64223358e-01f, 1.29984822e-02f, 7.60262311e-02f, 8.93180370e-02f, -2.85790507e-02f,
  1.27523243e-01f, 1.35288447e-01f, 4.73465659e-02f, 3.31381895e-02f, 1.03122145e-02f, -6.48894981e-02f, 1.37706548e-01f, 8.44903942e-03f, 5.61266020e-02f, 9.26021710e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.59903899e-01f, 2.85422318e-02f, -9.96724069e-02f, -6.74439967e-02f, -1.44349933e-02f, -5.84921129e-02f, -1.53903076e-02f, -2.04102714e-02f, -8.17633942e-02f, 2.01173797e-02f,
  -7.30933920e-02f, -3.45262624e-02f, 8.06980357e-02f, -5.84331108e-03f, -1.40640125e-01f, 1.17862642e-01f, 1.20323271e-01f, -9.25834058e-04f, 6.30551130e-02f, -1.10571712e-01f,
  -1.38737872e-01f, 3.16312015e-02f, -1.66252881e-01f, -1.10691607e-01f, 6.69002980e-02f, -8.57005045e-02f, 1.28875583e-01f, -4.48112749e-03f, -1.09039441e-01f, -2.41798721e-02f,
  -1.47929966e-01f, 3.74803506e-02f, 1.21015981e-01f, -2.15046238e-02f, -2.56309919e-02f, 5.97042404e-02f, 3.99443358e-02f, 9.33235586e-02f, 1.27196088e-01f, -1.33047812e-02f,
  -1.05128758e-01f, 3.13671939e-02f, -1.65442545e-02f, 3.06023769e-02f, 1.25834137e-01f, 3.68076488e-02f, -1.11370906e-01f, 4.70929407e-02f, -1.13150388e-01f, -3.22307236e-02f,
  -1.52318999e-02f, -5.06448187e-02f, -1.50171230e-02f, 1.69312563e-02f, -3.29131330e-03f, 5.78235798e-02f, 2.28011571e-02f, -9.16374102e-02f, -4.58482094e-02f, 9.74640474e-02f,
  -1.51424212e-02f, -2.48533003e-02f, 8.92441124e-02f, -2.29566637e-02f, 6.09052517e-02f, 3.88810262e-02f, 1.69813614e-02f, -2.06345785e-02f, -8.83282220e-04f, -2.58914698e-02f,
  1.16777189e-01f, 6.19607791e-02f, 1.15485787e-01f, -4.97999527e-02f, -3.66804712e-02f, 1.14015430e-01f, -2.25403570e-02f, -3.35023068e-02f, 2.74335351e-02f, 3.36614549e-02f,
  -8.43434071e-04f, -5.52829467e-02f, -3.08884829e-02f, -6.32266924e-02f, 1.05621420e-01f, 3.87196592e-03f, 3.73944966e-03f, 7.22230151e-02f, -1.52958721e-01f, -3.31023075e-02f,
  9.06474814e-02f, -5.86881116e-02f, 4.47921418e-02f, 1.10414654e-01f, -8.79968330e-03f, -1.59225464e-02f, -8.43286067e-02f, 3.32259052e-02f, 1.07477650e-01f, -2.63596196e-02f,
  -2.99562677e-03f, 1.19442068e-01f, -8.55744444e-03f, -4.10778075e-02f, 1.43291309e-01f, -8.75430703e-02f, -1.04019910e-01f, 5.62314168e-02f, 1.80168182e-01f, -1.33049360e-03f,
  5.36004677e-02f, 1.32709771e-01f, 4.80699651e-02f, -7.12492839e-02f, -2.69967876e-02f, -4.43796581e-03f, -7.09258020e-02f, 4.42706048e-02f, -2.77185056e-04f, -4.87765223e-02f,
  -1.49944499e-02f, -1.20255083e-01f, -2.64036898e-02f, -1.45375609e-01f, -1.39435530e-01f, 1.40029058e-01f, 1.33615822e-01f, -2.19663084e-02f, -9.06764194e-02f, 1.57218985e-02f,
  -1.09260544e-01f, -3.18298675e-02f, -5.35986982e-02f, -5.91274500e-02f, 2.96584032e-02f, -8.83057434e-03f, 4.33981381e-02f, -1.24276970e-02f, 1.71850820e-03f, -5.80546521e-02f,
  1.11532874e-01f, -4.57472466e-02f, 3.09205763e-02f, 3.44963782e-02f, 1.05994366e-01f, 1.68604832e-02f, 1.26190549e-02f, -3.96282226e-02f, -1.34015689e-02f, 1.37114644e-01f,
  -3.78871225e-02f, -5.40007539e-02f, 3.59130390e-02f, 3.20025161e-02f, 1.77048698e-01f, 2.02155653e-02f, -8.14058930e-02f, 8.27955902e-02f, -1.71379030e-01f, -2.16813777e-02f,
  -7.66974525e-04f, 4.54113558e-02f, -8.60482082e-02f, -1.84861302e-01f, 7.99928233e-02f, 1.25675291e-01f, 9.19569731e-02f, -7.21104592e-02f, 7.65842211e-04f, 8.75164047e-02f,
  -1.10943630e-01f, 1.28420472e-01f, 6.97116777e-02f, -2.28804108e-02f, -3.82508487e-02f, 1.46980107e-01f, 1.44042879e-01f, -4.00032327e-02f, 4.68690414e-03f, -1.59662403e-02f,
  -1.48821622e-01f, -1.21704720e-01f, 5.21640740e-02f, 9.37703345e-03f, 1.19941011e-01f, -7.43146520e-03f, -4.36268784e-02f, -4.06150036e-02f, 5.55826612e-02f, -5.08505143e-02f,
  1.14108816e-01f, -1.27678305e-01f, 1.23186119e-01f, -2.33744290e-02f, 1.99184805e-01f, -5.98831102e-03f, 6.63418770e-02f, -3.75487469e-02f, -2.29807422e-02f, 9.26370472e-02f,
  2.52180919e-02f, 5.86975701e-02f, -1.98002718e-02f, 2.06631143e-03f, 7.62552619e-02f, -5.47874048e-02f, -3.78383994e-02f, -1.12656020e-01f, -6.85978234e-02f, -1.01134190e-02f,
  -1.45564573e-02f, 1.04625188e-01f, 7.74182603e-02f, -1.08518787e-01f, 9.76448655e-02f, -4.04087156e-02f, -1.81618646e-01f, -1.16216168e-01f, 2.56248489e-02f, -5.70601672e-02f,
  1.28379583e-01f, 6.07845560e-02f, 6.00963272e-02f, 2.23932341e-02f, -1.48389459e-01f, -1.52066410e-01f, -7.45647103e-02f, 1.78967357e-01f, 2.54585128e-02f, 4.62151915e-02f,
  -6.36994764e-02f, -4.24165688e-02f, 1.12838738e-01f, -4.13535461e-02f, -7.36250542e-03f, -6.31165877e-02f, -6.01209849e-02f, 1.07436322e-01f, -3.88084305e-03f, 2.28646975e-02f,
  1.04335859e-01f, -1.36056263e-03f, 4.86178510e-03f, -4.91083339e-02f, -1.05762839e-01f, -2.91100368e-02f, 4.69496921e-02f, 5.55147715e-02f, 1.68761984e-02f, -9.94545966e-02f,
  1.92550868e-02f, -1.92302719e-01f, -6.09380528e-02f, -5.74329309e-02f, 7.82286227e-02f, 1.37102813e-01f, -2.91582290e-02f, -7.04411119e-02f, -5.42644486e-02f, 3.21171619e-02f,
  8.66112933e-02f, -9.20636058e-02f, -5.13484813e-02f, -1.93281844e-02f, 3.66591034e-03f, 6.14930131e-02f, 9.79482755e-02f, -7.88944513e-02f, -2.06513684e-02f, 1.85843147e-02f,
  -2.98394617e-02f, -2.68610362e-02f, 2.31270539e-03f, -2.87554674e-02f, 1.20520070e-01f, 1.08976010e-03f, -1.02836393e-01f, 1.00081071e-01f, -1.92101240e-01f, -7.28262067e-02f,
  2.21088856e-01f, -5.41322939e-02f, -5.83300414e-03f, 3.64249274e-02f, 1.51136145e-02f, -1.22430772e-01f, -6.56998456e-02f, 1.10720165e-01f, 2.83608828e-02f, 7.58838803e-02f,
  1.70489233e-02f, 7.40320534e-02f, 7.20969290e-02f, -1.71420172e-01f, 9.48848724e-02f, 1.10478058e-01f, -1.65169090e-01f, 1.20060630e-01f, 1.00456223e-01f, -9.03944299e-02f,
  -1.51608244e-01f, -7.53322318e-02f, -1.10588238e-01f, -1.68607071e-01f, -1.60256904e-02f, -5.26929684e-02f, -4.70305420e-02f, -5.66399768e-02f, 1.09561153e-01f, 8.61286372e-02f,
  -6.07705414e-02f, -3.21461931e-02f, -7.53654838e-02f, 1.39435427e-02f, -7.19400076e-03f, 6.79099634e-02f, 5.55853620e-02f, -9.61146057e-02f, 6.33158833e-02f, -1.04920126e-01f,
  -3.73188071e-02f, -7.45417550e-02f, -3.23735066e-02f, -9.48591009e-02f, -9.67698470e-02f, 4.57254015e-02f, -9.27883089e-02f, -2.14040224e-02f, 3.29885185e-02f, 4.72065136e-02f,
  -6.04805797e-02f, 2.18745153e-02f, 7.04288110e-02f, -1.11459561e-01f, -1.98298767e-01f, 9.47684497e-02f, 4.41483548e-03f, 4.10261415e-02f, 1.63713574e-01f, 5.88698834e-02f,
  3.39896642e-02f, -2.94719785e-02f, -7.17928037e-02f, -1.55916452e-01f, 3.38676311e-02f, -7.66279772e-02f, 8.24928507e-02f, -1.29828649e-02f, -1.60529718e-01f, -1.08253077e-01f,
  -1.10673070e-01f, 8.56616721e-02f, 1.03013508e-01f, -8.80555362e-02f, -4.31647897e-02f, 1.21786380e-02f, -6.08496703e-02f, 3.40560824e-02f, -1.33652717e-01f, -4.10623103e-02f,
  2.63893250e-02f, 4.33383249e-02f, -1.13514997e-02f, 1.12733074e-01f, 6.08946942e-03f, 1.04498178e-01f, 6.46554157e-02f, -3.63969766e-02f, 6.19326383e-02f, 1.12898061e-02f,
  9.13648959e-03f, 4.58476804e-02f, 9.80340317e-02f, -5.38304076e-02f, 1.32181332e-01f, 1.31140456e-01f, 1.25845045e-01f, -1.03291154e-01f, -1.32445559e-01f, -7.20018670e-02f,
  -1.06568329e-01f, -6.81500807e-02f, 1.56118795e-01f, -2.62683108e-02f, -1.19874338e-02f, 8.74608681e-02f, -1.95759088e-02f, -2.04948001e-02f, -2.63328534e-02f, 4.51968238e-02f,
  1.87173672e-02f, 6.61393628e-02f, -1.34816960e-01f, -6.87901378e-02f, 4.76475991e-02f, 8.04551095e-02f, -1.43420339e-01f, 1.49222344e-01f, -3.31953317e-02f, 8.33011195e-02f,
  6.28896014e-05f, -3.13113518e-02f, 4.37213443e-02f, -4.77799736e-02f, -1.31614551e-01f, -1.44457132e-01f, -7.63671705e-03f, 2.83292532e-02f, -6.87368885e-02f, 3.26264948e-02f,
  -1.16702877e-01f, 1.30466789e-01f, 1.13431871e-01f, 1.39758304e-01f, 3.11718397e-02f, -1.03580274e-01f, 8.52180496e-02f, 8.60821083e-02f, 1.55649811e-01f, 1.91740111e-01f,
  -2.86386609e-02f, 1.59028396e-02f, 1.33925200e-01f, 9.86412168e-02f, -8.10905248e-02f, -8.68298039e-02f, -5.75783895e-03f, -7.22071454e-02f, -4.07493003e-02f, -4.23345435e-03f,
  -5.75207472e-02f, -1.21372856e-01f, -1.54616609e-01f, -3.66624594e-02f, -1.29122883e-01f, -2.00879239e-02f, -3.01448833e-02f, 1.15786701e-01f, -8.48739073e-02f, -8.25784579e-02f,
  -1.01297535e-01f, 9.05309692e-02f, 1.16048362e-02f, 1.03374526e-01f, -8.26344043e-02f, 2.22184993e-02f, -8.04652795e-02f, 8.04821253e-02f, 4.91608754e-02f, -4.21642363e-02f,
  5.63506372e-02f, -6.02589780e-03f, 3.64157632e-02f, 1.57106351e-02f, -2.92800013e-02f, 2.52722967e-02f, 1.55166807e-02f, -6.05474226e-02f, 4.64323116e-03f, -1.36177018e-01f,
  4.73416783e-02f, -1.01948287e-02f, -8.37216452e-02f, -2.79378816e-02f, -3.68991196e-02f, 1.04632437e-01f, 9.38606262e-02f, 4.46872637e-02f, -5.12351766e-02f, 1.45467103e-01f,
  -1.14463687e-01f, -1.55972853e-01f, 1.25126585e-01f, -1.40522704e-01f, 1.13975048e-01f, -9.78088900e-02f, -7.04408810e-02f, -3.80603299e-02f, -2.66997572e-02f, 1.55665532e-01f,
  1.18823322e-02f, -8.74647126e-02f, 4.95754182e-02f, -2.23596364e-01f, -3.72025371e-02f, -4.70923409e-02f, 1.43271941e-03f, -2.49292441e-02f, -7.23884851e-02f, 1.96765557e-01f,
  -4.51923870e-02f, -9.97127593e-03f, -4.60706986e-02f, -7.68444315e-03f, 3.24417204e-02f, 8.05787295e-02f, -8.29831362e-02f, 8.94255042e-02f, 9.13979765e-03f, 3.68091166e-02f,
  -4.84232232e-02f, -5.23850918e-02f, 1.42996863e-01f, 1.32313222e-01f, -8.65133628e-02f, -1.30355909e-01f, -1.54835746e-01f, 1.15691051e-02f, 2.18671821e-02f, -1.19672805e-01f,
  -2.19096290e-03f, -1.60366111e-02f, -1.08314969e-01f, 3.13294008e-02f, -1.36959970e-01f, 1.74681246e-02f, 4.87200841e-02f, 1.10264868e-01f, -8.66501108e-02f, 8.37230706e-04f,
  -1.12552777e-01f, 1.11225784e-01f, 8.18307176e-02f, -3.33137773e-02f, -1.68570980e-01f, -4.90683019e-02f, -8.28127041e-02f, 1.60801262e-01f, 1.22302063e-01f, -2.23781094e-01f,
  -6.09920062e-02f, -3.13077495e-02f, -9.13862064e-02f, -7.24472255e-02f, -1.12180993e-01f, 1.15822457e-01f, -5.97881712e-02f, 1.57977566e-01f, 5.29614873e-02f, 1.81756094e-01f,
  5.95845096e-02f, 2.92830709e-02f, -1.37087956e-01f, -7.02566355e-02f, 1.84732258e-01f, 1.10604741e-01f, -9.80229527e-02f, 1.10440858e-01f, 4.89602983e-02f, 4.96855155e-02f,
  9.01402161e-02f, 6.86094463e-02f, 5.72798997e-02f, -1.76454708e-02f, -1.17938168e-01f, 1.93512011e-02f, -1.06456287e-01f, 1.42182395e-01f, -1.11310303e-01f, -1.63136691e-01f,
  -5.87932914e-02f, -1.38772294e-01f, -1.27087981e-02f, -3.00815813e-02f, 6.97336048e-02f, 2.52432725e-03f, -8.12336877e-02f, -1.37446195e-01f, 2.72946451e-02f, 8.62789899e-02f,
  1.43906534e-01f, -5.87222651e-02f, -1.11172870e-01f, 9.37763155e-02f, 1.21783920e-01f, 6.93468228e-02f, 1.57781728e-02f, -8.80944282e-02f, 3.31038088e-02f, -3.07109617e-02f,
  2.19842643e-02f, -3.68230119e-02f, -8.75164419e-02f, 3.29838917e-02f, -3.48649956e-02f, -5.05416989e-02f, -8.07867497e-02f, -1.68282375e-01f, -3.80113013e-02f, -1.02636576e-01f,
  -1.31234899e-01f, 1.05694607e-01f, -5.28604127e-02f, 6.42735511e-02f, 3.13431323e-02f, 6.69517089e-03f, -6.68362752e-02f, -8.34030584e-02f, -1.16491474e-01f, -3.52341263e-03f,
  6.77940249e-02f, 2.59929821e-02f, -1.21379137e-01f, -1.22531749e-01f, 1.73838064e-01f, 3.37863266e-02f, 1.57930359e-01f, 2.90811919e-02f, -1.48139615e-03f, -6.82929009e-02f,
  4.27058078e-02f, 2.17971802e-01f, 1.48383053e-02f, -1.43040210e-01f, 7.34520191e-03f, -5.18165231e-02f, -9.59122330e-02f, 1.42012343e-01f, 1.33457616e-01f, -4.62237224e-02f,
  -4.22434434e-02f, 6.71480922e-03f, -8.67977273e-03f, 1.51426224e-02f, -3.85510474e-02f, -1.76283829e-02f, -8.97791907e-02f, -2.89667435e-02f, 9.15409531e-04f, 8.24446976e-02f,
  1.66353937e-02f, 5.36646247e-02f, 4.40098792e-02f, -3.48273553e-02f, -8.82100984e-02f, -4.81775589e-02f, 8.05263370e-02f, -1.00071937e-01f, 3.91289070e-02f, 7.61413500e-02f,
  9.47484225e-02f, -1.02448347e-03f, -2.62793954e-02f, -5.29333502e-02f, -3.26458253e-02f, -1.27042025e-01f, 7.89337829e-02f, -3.79633065e-03f, -2.45806538e-02f, -5.60264699e-02f,
  -1.36604011e-01f, 6.09621685e-03f, 1.33776218e-02f, 8.48977789e-02f, 5.98172098e-02f, 8.13633800e-02f, 7.92017393e-03f, 1.23602971e-01f, -5.39323092e-02f, -1.09184615e-01f,
  -1.00789338e-01f, -1.11239016e-01f, 4.23221327e-02f, -6.71281070e-02f, -6.26210943e-02f, 6.67783171e-02f, 8.07563812e-02f, -1.39802638e-02f, 5.80110848e-02f, 1.03654630e-01f,
  6.63177297e-02f, 4.55846498e-03f, -1.78658620e-01f, -1.14849806e-01f, 1.36102423e-01f, 8.89297128e-02f, -7.53243864e-02f, 1.63577478e-02f, 1.62632048e-01f, 7.88586512e-02f,
  -1.78843439e-01f, -4.70537916e-02f, -4.76710964e-03f, -6.54331744e-02f, 1.22827061e-01f, -2.33133622e-02f, -3.05182952e-02f, 2.04602867e-01f, -1.72011301e-01f, -1.30283292e-02f,
  -6.09993376e-02f, -6.80082962e-02f, -1.75896972e-01f, -4.30039540e-02f, -8.74861330e-02f, -6.08156733e-02f, 5.65954344e-03f, -4.58030216e-02f, 9.96709242e-03f, 1.70908511e-01f,
  3.55733559e-02f, -4.81679738e-02f, 1.89715363e-02f, -9.53127965e-02f, 5.55846691e-02f, -8.99568945e-02f, -4.59898449e-02f, -5.58559187e-02f, -1.32794946e-01f, -8.93934965e-02f,
  -4.92657116e-03f, -2.07493287e-02f, -4.01984528e-02f, -3.86501104e-03f, -1.56734735e-02f, -3.08777373e-02f, 9.52022895e-02f, -1.14267454e-01f, -1.37978360e-01f, -2.80067902e-02f,
  6.47784621e-02f, 2.41929907e-02f, 4.53725234e-02f, 9.00100768e-02f, 8.24083686e-02f, 6.63976520e-02f, -4.98556867e-02f, -1.53460220e-01f, 8.85307714e-02f, -1.20712340e-01f,
  9.80604962e-02f, -1.00742146e-01f, -8.57326388e-02f, -6.46216497e-02f, -1.00463986e-01f, 1.30727440e-02f, -9.14773066e-03f, -3.08811292e-02f, -1.06339261e-03f, -1.04387477e-01f,
  4.86997217e-02f, 1.16903886e-01f, -9.21686664e-02f, -1.09538056e-01f, 2.24316325e-02f, 9.12733451e-02f, -1.44757610e-02f, 1.12074590e-03f, 4.89032120e-02f, 1.13070592e-01f,
  1.00721225e-01f, 1.43676087e-01f, -2.68321075e-02f, 6.09822087e-02f, 7.79531971e-02f, 4.39687930e-02f, -5.60448207e-02f, -1.37152925e-01f, 2.51751207e-02f, 1.24587819e-01f,
  1.56436414e-01f, -1.09395720e-01f, -1.15456983e-01f, -7.80912340e-02f, -3.37849297e-02f, -1.00336455e-01f, 1.43572792e-01f, -1.43187568e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.34828487e-02f, 9.26746652e-02f, 2.57056560e-02f, 1.24978490e-01f, 2.15628341e-01f, 1.53439730e-01f, 1.95049588e-02f, 7.55372420e-02f, 6.58646878e-03f, 1.02240250e-01f,
  7.70482495e-02f, 1.68239307e-02f, -1.14871487e-01f, -1.51964262e-01f, -4.05725501e-02f, -1.65509224e-01f, -1.42877862e-01f, 2.23063976e-02f, 5.36513887e-02f, 2.71586459e-02f,
  8.92470628e-02f, 2.24746421e-01f, 7.78592527e-02f, -1.23498656e-01f, 2.68003196e-01f, 1.64118279e-02f, 1.09123969e-02f, 8.20555389e-02f, 1.08502723e-01f, -1.53206393e-01f,
  4.26580198e-02f, 2.78004467e-01f, 1.38032353e-02f, 1.74620733e-01f, 8.68338495e-02f, -1.26376927e-01f, 2.46667102e-01f, -1.10289373e-01f, -6.71456680e-02f, 1.01158060e-02f,
  8.58417451e-02f, 2.17245057e-01f, -9.82317254e-02f, 6.08342290e-02f, -4.89820689e-02f, 6.91456534e-03f, 1.02220707e-01f, 5.49333496e-03f, 2.26378620e-01f, 2.52799869e-01f,
  3.23549628e-01f, 1.85926378e-01f, 1.87861189e-01f, -7.45085627e-02f, 3.40365991e-02f, 4.51344065e-03f, -2.42730826e-01f, -8.85775164e-02f, -7.82512575e-02f, 5.91334738e-02f,
  1.51376992e-01f, -7.41053149e-02f, 2.02101935e-02f, -1.18207566e-01f, -2.17340756e-02f, 4.40470092e-02f, 7.48741925e-02f, 4.68610004e-02f, 8.07755888e-02f, -1.28325156e-03f,
  -5.48428148e-02f, -7.25100785e-02f, -4.07845899e-02f, 6.12424538e-02f, 1.03152037e-01f, -2.47426331e-03f, 3.31054325e-03f, -4.74611148e-02f, -2.12748483e-01f, 1.52816894e-02f,
  -3.06791347e-02f, -9.04496387e-03f, 1.55482054e-01f, -1.05530672e-01f, -2.13871114e-02f, 7.73822069e-02f, 4.58012782e-02f, -1.40896291e-01f, 9.15669352e-02f, -1.20181948e-01f,
  -3.77464481e-02f, 1.48806823e-02f, -1.49607053e-02f, 4.59359214e-02f, -5.77303693e-02f, 7.84448683e-02f, 2.01725200e-01f, 3.86092290e-02f, 1.19720912e-02f, 1.38912782e-01f,
  1.03225470e-01f, 3.03259883e-02f, -1.29598245e-01f, -2.66170334e-02f, 1.43409654e-01f, 1.38308078e-01f, -1.51506498e-01f, 2.29112208e-02f, 3.87964733e-02f, 1.51803911e-01f,
  1.23043589e-01f, -6.97839772e-03f, -6.77231103e-02f, 7.23579377e-02f, 5.40205725e-02f, 3.74509767e-02f, 1.58123836e-01f, -1.15969077e-01f, 6.68088570e-02f, 6.93190768e-02f,
  1.62350237e-02f, -2.06109025e-02f, -1.51711226e-01f, -1.44568279e-01f, -8.64027143e-02f, -1.03016563e-01f, 8.26041996e-02f, 6.53061643e-02f, -1.59232097e-03f, 2.26593129e-02f,
  -3.55240889e-02f, -1.12340068e-02f, 5.20290099e-02f, 1.50356116e-02f, 2.62976228e-03f, 2.82347738e-03f, -6.45436123e-02f, 8.34831521e-02f, -1.36515470e-02f, 9.88063985e-05f,
  5.18328361e-02f, -4.04403359e-02f, -1.39976606e-01f, -2.53680013e-02f, 3.23169604e-02f, 1.05281226e-01f, 1.10500216e-01f, -1.35949135e-01f, -5.03046103e-02f, 1.04809836e-01f,
  8.22636560e-02f, -1.74023479e-01f, 5.90252727e-02f, -1.22491330e-01f, 1.01061471e-01f, 7.31236935e-02f, -1.33459955e-01f, 1.07741505e-01f, -6.87513500e-02f, 1.78526327e-01f,
  1.04879946e-01f, 8.56439024e-02f, 1.28541872e-01f, 1.99869052e-02f, 1.10652812e-01f, 1.63817093e-01f, 1.07247598e-01f, 8.91652890e-03f, -1.19722605e-01f, 4.40082885e-02f,
  -9.73015055e-02f, 5.91904931e-02f, 1.62898630e-01f, 3.92624810e-02f, 8.48089233e-02f, 8.39626566e-02f, -2.99457442e-02f, 9.98494029e-02f, -6.12422079e-02f, 2.29570596e-03f,
  -2.75430568e-02f, -7.13435560e-02f, 1.73360527e-01f, 1.09336495e-01f, -2.62475442e-02f, -1.02744699e-01f, -1.07960127e-01f, -8.15648139e-02f, -1.00754224e-01f, -4.53753807e-02f,
  6.81368485e-02f, -8.61892700e-02f, 7.35368878e-02f, -8.06579553e-03f, 5.44150621e-02f, 8.55625048e-02f, 4.82791439e-02f, 1.71265170e-01f, 3.71096805e-02f, 6.26187250e-02f,
  -5.91300428e-02f, 7.92139024e-02f, 3.34314182e-02f, 7.45454580e-02f, 4.78594862e-02f, -2.66691633e-02f, -1.01886261e-02f, -9.66961905e-02f, -1.99563205e-01f, -1.07417434e-01f,
  1.32484168e-01f, 1.15905680e-01f, -2.25983225e-02f, -3.97919938e-02f, 2.04160675e-01f, -9.79689434e-02f, 6.22585788e-02f, -1.18396692e-02f, -6.04832172e-02f, 1.23006580e-02f,
  2.01140776e-01f, -6.48150519e-02f, 1.93678647e-01f, 4.78900298e-02f, 5.34243025e-02f, 9.21517611e-02f, 8.66119191e-02f, 2.02225670e-01f, 1.05006836e-01f, -1.03540570e-01f,
  2.81340983e-02f, 6.22178316e-02f, 2.12005660e-01f, 2.89522428e-02f, 1.21678829e-01f, -8.02308321e-02f, -1.51727006e-01f, 4.27453816e-02f, 1.15188025e-01f, -1.37460440e-01f,
  1.19090810e-01f, 8.11423287e-02f, 3.65479961e-02f, 6.31012842e-02f, 4.44978252e-02f, 1.10541889e-03f, 6.68889210e-02f, 9.64282602e-02f, -5.68738468e-02f, 9.70349386e-02f,
  2.38241293e-02f, -7.73827285e-02f, 1.78025708e-01f, -9.90797877e-02f, 8.92359763e-02f, 2.21895184e-02f, -4.00443387e-04f, -1.32009119e-01f, 2.28037685e-02f, -9.77646634e-02f,
  -7.31067583e-02f, -2.96423081e-02f, -1.03837281e-01f, -3.40180174e-02f, -6.38851821e-02f, 4.68539335e-02f, 1.07641295e-02f, -7.50405788e-02f, 1.68417707e-01f, -1.92127287e-01f,
  -1.90942645e-01f, 9.19585004e-02f, -3.61370854e-02f, -1.63195003e-02f, 1.53695896e-01f, -3.34043056e-02f, -4.14213389e-02f, 5.22115976e-02f, -1.17039099e-01f, -6.59501702e-02f,
  -1.83060206e-02f, -2.06174299e-01f, 1.75416116e-02f, -2.64347978e-02f, -5.91910966e-02f, 5.79118244e-02f, -5.73642328e-02f, 3.48115549e-03f, 6.56587407e-02f, -6.98403567e-02f,
  -1.40494704e-01f, 1.71084970e-01f, 1.30317196e-01f, 8.38551950e-03f, -3.66027541e-02f, -2.65915152e-02f, 9.39718336e-02f, 1.12317704e-01f, -4.30119038e-02f, 7.43415207e-02f,
  1.08794868e-01f, 4.80560511e-02f, 2.52489913e-02f, 2.59185694e-02f, 6.04197830e-02f, 5.40436544e-02f, 1.16312560e-02f, -6.53452426e-02f, 5.53522371e-02f, -7.55617246e-02f,
  1.94879457e-01f, 9.63278338e-02f, 1.20881177e-01f, -2.77934875e-02f, -1.45093843e-01f, -6.11104555e-02f, 1.67074706e-02f, -1.32560119e-01f, 1.54464573e-01f, 7.64319226e-02f,
  -5.62228821e-02f, 5.77235781e-02f, 2.02205703e-02f, 8.59651715e-02f, -4.90795299e-02f, 6.51464537e-02f, 1.30114064e-01f, -6.40158653e-02f, 2.05117185e-02f, 1.92701779e-02f,
  5.28015606e-02f, -3.97818461e-02f, -6.99196085e-02f, 9.14581493e-02f, -4.74446826e-03f, -9.74481460e-03f, 2.06555516e-01f, 8.68771039e-03f, -1.16712593e-01f, -1.41003892e-01f,
  -1.03914209e-01f, -2.76246900e-03f, -7.67883239e-03f, -3.37222219e-02f, 2.10239552e-02f, -1.06381513e-02f, 2.09055379e-01f, 1.04772240e-01f, -1.64092705e-02f, 2.37686023e-01f,
  -1.49724362e-02f, 7.69019825e-03f, 9.58247632e-02f, 1.10252455e-01f, 2.75186598e-01f, 1.08656004e-01f, 4.07819599e-02f, 2.87897699e-02f, 2.05323517e-01f, 1.18365347e-01f,
  -2.11504549e-01f, 2.12244187e-02f, 9.08213481e-02f, 4.35034093e-03f, 1.72647372e-01f, -6.88153878e-03f, 1.68056898e-02f, 9.45897549e-02f, -1.80310279e-01f, -3.14592160e-02f,
  -6.74386322e-02f, -4.09215838e-02f, 9.89081636e-02f, 9.91125405e-02f, 7.86291957e-02f, -7.10177049e-02f, -8.07864442e-02f, 7.38120228e-02f, 1.71596482e-01f, 1.43477350e-01f,
  -1.61861897e-01f, 1.03721552e-01f, 8.56584236e-02f, 4.15209755e-02f, 4.15935516e-02f, 7.99728185e-02f, 5.04382662e-02f, 1.13629267e-01f, 1.84169546e-01f, -6.68042377e-02f,
  1.34225190e-01f, -6.60673827e-02f, 1.45622835e-01f, 1.16515927e-01f, -2.75126696e-02f, -8.08677927e-04f, 1.06283404e-01f, -1.58645362e-02f, 6.07004054e-02f, -6.71806633e-02f,
  2.10873857e-01f, 2.13989913e-01f, 6.95432723e-02f, -9.52014774e-02f, -7.89453685e-02f, 2.12636650e-01f, -4.51481342e-02f, -1.92686200e-01f, 4.54944596e-02f, -1.04182407e-01f,
  1.44176990e-01f, 1.15427531e-01f, -1.49977341e-01f, 1.17336869e-01f, -7.73857310e-02f, 2.32968777e-01f, -7.33753815e-02f, -1.52683742e-02f, 2.23469734e-01f, -1.68965206e-01f,
  -4.21335474e-02f, 1.29804224e-01f, 1.92066669e-01f, -6.73607737e-03f, -1.11801282e-01f, 2.09413439e-01f, -1.24128461e-01f, 9.03081894e-03f, 2.34741181e-01f, -6.65930053e-03f,
  1.43721715e-01f, 2.95253873e-01f, -1.22589171e-02f, 1.00009024e-01f, 9.42196138e-03f, -1.17066456e-02f, -1.52675018e-01f, -4.33771312e-02f, 9.35379565e-02f, 5.58239920e-03f,
  -8.77823383e-02f, -1.71619147e-01f, 2.94095203e-02f, 5.70184849e-02f, 3.58480066e-02f, -1.31455259e-02f, 1.51205316e-01f, -9.94482785e-02f, 2.71208659e-02f, 5.66782989e-03f,
  -9.83761400e-02f, 3.40957120e-02f, -7.11566396e-03f, 4.07216251e-02f, -3.72153074e-02f, -1.20587237e-02f, 2.51038792e-03f, 3.44728120e-04f, -7.20053539e-02f, -6.80502206e-02f,
  -4.76333797e-02f, 9.28654000e-02f, -6.47889078e-02f, 5.90219162e-02f, 6.31170198e-02f, 2.79832166e-02f, 3.51457000e-02f, -6.57322481e-02f, -1.88016325e-01f, -8.65641981e-02f,
  -5.08956760e-02f, -3.97981592e-02f, 7.32349679e-02f, -3.84127758e-02f, -8.04194212e-02f, 8.98112729e-02f, 2.97997650e-02f, 1.56654358e-01f, 1.82713106e-01f, 2.53552431e-03f,
  1.79228321e-01f, 1.96865890e-02f, 1.58497527e-01f, 3.49186420e-01f, -1.02763455e-02f, -1.04647828e-02f, 1.48687914e-01f, 1.23748414e-01f, -2.21361637e-01f, 1.58446433e-04f,
  1.21783987e-01f, -7.55361617e-02f, 7.31522217e-03f, 2.73572803e-02f, -1.04788445e-01f, 6.04060702e-02f, -1.31330371e-01f, -4.43416834e-02f, -1.87137678e-01f, -1.08582690e-01f,
  2.12298520e-03f, 8.92451853e-02f, -3.89852971e-02f, -4.54977388e-03f, -9.90147591e-02f, 6.34296760e-02f, -9.53391567e-02f, 4.25244458e-02f, -3.20505053e-02f, -1.11150630e-02f,
  7.06069246e-02f, 1.77241564e-02f, 1.14653558e-02f, 4.02204171e-02f, 7.78670385e-02f, 6.70065507e-02f, 1.52458781e-02f, -1.80655718e-02f, -8.95184744e-03f, -1.00652482e-02f,
  -5.87540399e-03f, 1.86070986e-02f, 7.84801319e-02f, -5.73050231e-02f, 1.04718857e-01f, -1.13186255e-01f, -1.65509224e-01f, -4.14537042e-02f, 1.78077538e-02f, 1.34854376e-01f,
  1.57852307e-01f, -1.23057835e-01f, -8.34899861e-03f, 8.68503377e-02f, -6.55971915e-02f, -1.95141613e-01f, 1.06843151e-02f, -1.72208413e-01f, 1.71600252e-01f, 9.60473716e-02f,
  -1.05077587e-01f, 1.01299040e-01f, 2.90741604e-02f, 2.47712672e-01f, 1.07918695e-01f, 2.27307715e-02f, 3.17826308e-02f, -3.73169873e-03f, 1.36205494e-01f, 5.88126965e-02f,
  -1.94566846e-02f, 8.46370123e-03f, -2.06248593e-02f, 2.38299668e-01f, -4.72320169e-02f, 1.84599310e-02f, 1.59584254e-01f, 1.38947859e-01f, -3.50909843e-03f, 6.42748326e-02f,
  -5.44283092e-02f, 1.12553939e-01f, -6.41455576e-02f, 1.49995955e-02f, -6.40843213e-02f, -5.15397713e-02f, 2.12383196e-01f, 1.09336160e-01f, 7.23762438e-03f, -1.26716599e-01f,
  -1.83224574e-01f, -1.97084770e-02f, -4.50591631e-02f, -9.62753817e-02f, 2.35262305e-01f, -8.15281868e-02f, 2.06781372e-01f, 9.96542871e-02f, 1.49644673e-01f, 8.54374170e-02f,
  2.13022456e-01f, 1.52004391e-01f, 1.11030936e-01f, 6.19300380e-02f, 6.33781254e-02f, 8.08584690e-02f, 1.40049770e-01f, 2.11580515e-01f, -9.01152790e-02f, 8.04270208e-02f,
  9.77897495e-02f, -2.45990530e-01f, -1.12282872e-01f, -1.91476606e-02f, -9.79386494e-02f, 1.21114813e-01f, 2.49572188e-01f, 8.24451372e-02f, 2.81963885e-01f, 9.99604468e-04f,
  3.12842093e-02f, 1.46155775e-01f, 1.14164883e-02f, -2.49575893e-03f, 1.30303070e-01f, 7.37696365e-02f, 1.45638376e-01f, 9.41545740e-02f, -1.44530013e-01f, 1.06669746e-01f,
  1.81726564e-03f, 1.14746979e-02f, 1.32355705e-01f, -3.19052450e-02f, -1.65218323e-01f, -1.09136127e-01f, 2.93916464e-01f, -1.60735450e-03f, 1.04770310e-01f, -4.24253941e-02f,
  5.80910631e-02f, -5.84174395e-02f, 2.00723112e-01f, -3.10122259e-02f, 1.99803859e-01f, 1.50415361e-01f, 1.57680109e-01f, 1.62568450e-01f, 8.71645063e-02f, -2.66817939e-02f,
  -6.49865493e-02f, -6.91706613e-02f, -1.03107259e-01f, 1.21135823e-01f, 5.25809228e-02f, -1.36623070e-01f, 1.24391183e-01f, 1.08900890e-02f, -1.53193008e-02f, 1.49621934e-01f,
  -6.66658804e-02f, 2.28464473e-02f, -6.70190901e-02f, -4.24056165e-02f, 2.83636283e-02f, -3.10626440e-02f, -3.92067246e-03f, 5.62729649e-02f, 5.60401864e-02f, -7.21793547e-02f,
  -6.63590655e-02f, 3.19487788e-02f, -5.50790466e-02f, 7.22642541e-02f, -8.66822992e-03f, 1.62286922e-01f, 8.30589980e-02f, -1.53870866e-01f, 1.31433317e-02f, -1.07516058e-01f,
  -1.19368933e-01f, -2.30178580e-01f, -3.50713953e-02f, 1.17897265e-01f, -9.23343003e-02f, 5.36173880e-02f, 5.80825061e-02f, -1.64896622e-02f, -3.86612341e-02f, 2.88256854e-01f,
  1.38594404e-01f, -1.73274815e-01f, -2.85386760e-03f, -5.29797897e-02f, -2.78393347e-02f, 3.28352541e-01f, -5.13147898e-02f, 3.88723351e-02f, 1.39065653e-01f, 1.08433142e-01f,
  3.99015322e-02f, -9.16653574e-02f, 3.76359038e-02f, 6.77200109e-02f, 1.12863451e-01f, 2.20668152e-01f, -4.07389477e-02f, 1.17885713e-02f, -1.91405460e-01f, -1.78557739e-01f,
  -1.59114316e-01f, -1.55489251e-01f, 1.50699154e-01f, 2.28836220e-02f, -1.40248373e-01f, -4.32227142e-02f, 1.07051410e-01f, 4.02661823e-02f, 1.49623692e-01f, 9.68545601e-02f,
  -1.88908368e-01f, 1.35661170e-01f, 9.66608375e-02f, 2.50501662e-01f, 1.12102047e-01f, 1.59326941e-01f, 1.69987097e-01f, 3.78584638e-02f, 1.19215354e-01f, 7.44576156e-02f,
  3.65467891e-02f, 1.46265224e-01f, 3.16215903e-02f, 1.42544270e-01f, 5.60599566e-02f, 1.69770151e-01f, 1.35819660e-02f, 9.57088079e-03f, 1.79416791e-01f, -1.29770324e-01f,
  -2.73662005e-02f, 1.21456087e-02f, -2.88725691e-03f, 7.85841718e-02f, 2.62216032e-01f, 4.09379415e-02f, 1.75320491e-01f, 3.74088772e-02f, -2.91794781e-02f, 9.84547362e-02f,
  7.19699487e-02f, -1.36326641e-01f, 3.76844145e-02f, 1.64751522e-02f, -4.68821786e-02f, 3.91175710e-02f, -1.92500338e-01f, -6.76971003e-02f, -7.23031089e-02f, -8.69963765e-02f,
  1.47069946e-01f, 1.25876769e-01f, -1.18850879e-01f, -7.32256398e-02f, 3.43693137e-01f, 1.10707544e-01f, -7.87661225e-02f, -9.89865698e-03f, 3.24425548e-02f, 1.08013473e-01f,
  2.17336491e-01f, 8.01908895e-02f, 2.22761795e-01f, 1.09640621e-01f, 1.77084506e-01f, 1.11868002e-01f, -4.81876694e-02f, 3.03476248e-02f, -1.50362793e-02f, 6.11114092e-02f,
  1.25509024e-01f, 4.74018268e-02f, -1.71782561e-02f, -1.13441963e-02f, 8.79021287e-02f, -1.68242157e-02f, 3.41206603e-02f, 5.74901886e-02f, 4.86092903e-02f, 1.17476068e-01f,
  9.64873880e-02f, 4.28924635e-02f, 1.67699493e-02f, 6.52373061e-02f, -1.20858001e-02f, 5.87205738e-02f, 4.23746323e-03f, 1.12394001e-02f, 1.74669638e-01f, -5.00286520e-02f,
  7.27105290e-02f, -7.08171204e-02f, 1.21399142e-01f, -2.16514945e-01f, -9.83423740e-02f, 6.57517686e-02f, 6.32534698e-02f, 1.58327103e-01f, -5.78484349e-02f, 1.55956313e-01f,
  6.93783984e-02f, 2.27184352e-02f, 2.40998223e-01f, -7.85497297e-03f, -5.36361411e-02f, -8.19921941e-02f, 6.71419799e-02f, -1.35807589e-01f, 1.43337667e-01f, 1.42782152e-01f,
  -1.22224666e-01f, 1.56241450e-02f, -9.70292836e-02f, -1.11474760e-01f, 2.41906270e-01f, -1.00792281e-01f, 8.32452625e-02f, 1.11212015e-01f, 9.73079279e-02f, 1.21158719e-01f,
  8.29348415e-02f, -1.13964751e-02f, -1.60849229e-01f, -1.44598559e-01f, -9.83444601e-02f, -1.98462978e-02f, 2.19942883e-01f, 1.11129984e-01f, 2.03446954e-01f, 7.19727576e-02f,
  1.50167067e-02f, 7.04491064e-02f, 2.69082468e-02f, -3.11447755e-02f, -5.86182512e-02f, 2.23795231e-02f, 1.43665835e-01f, 1.18583530e-01f, 2.54528463e-01f, -3.34035084e-02f,
  -5.05418070e-02f, -7.96534494e-02f, -1.91012286e-02f, 9.25619751e-02f, -2.07939073e-02f, 3.83042097e-02f, 2.81456858e-02f, 3.77086177e-02f, 2.25897301e-02f, 6.54826313e-02f,
  -3.35952826e-02f, -1.71227455e-02f, 9.18641388e-02f, 7.60644451e-02f, -5.04365265e-02f, 1.05695248e-01f, -9.94988438e-03f, 7.43747950e-02f, 1.58105239e-01f, -7.45323077e-02f,
  -1.05166435e-01f, -1.64024562e-01f, -1.83776945e-01f, -7.61426985e-02f, 4.53098789e-02f, 1.19768448e-01f, 1.55809194e-01f, 1.29750714e-01f, 1.47658482e-01f, 1.55451655e-01f,
  -8.66358951e-02f, 1.55973151e-01f, 1.20333731e-02f, -5.69619834e-02f, 1.48671925e-01f, 1.31286114e-01f, 1.93380252e-01f, 1.54683441e-01f, 8.88409391e-02f, 1.33453878e-02f,
  2.17170775e-01f, 1.15771361e-01f, -1.40385896e-01f, -5.68315201e-02f, 1.50624231e-01f, 6.61467984e-02f, 1.16168536e-01f, -4.01452109e-02f, 5.13143837e-02f, 3.29277180e-02f,
  -2.17819422e-01f, -1.17783502e-01f, -1.27083272e-01f, -6.95141703e-02f, 1.46959126e-01f, 1.21443324e-01f, -4.34570499e-02f, -1.33334681e-01f, -1.37101844e-01f, 1.71018481e-01f,
  7.08910674e-02f, 7.20686913e-02f, -9.91900638e-02f, 4.62491065e-02f, -6.25163317e-02f, 4.22603302e-02f, -6.27390891e-02f, 6.46846071e-02f, -3.79441641e-02f, 1.09140642e-01f,
  -5.36085963e-02f, 1.52729318e-01f, 9.07943696e-02f, -8.63251612e-02f, 1.49219990e-01f, 6.31650910e-02f, 1.32848486e-01f, 2.58901827e-02f, -1.65019780e-01f, -4.28633690e-02f,
  -6.67734966e-02f, 1.63887113e-01f, 1.28049925e-01f, -1.02658734e-01f, -7.03343097e-03f, -9.91549492e-02f, 8.72319937e-02f, 7.00031668e-02f, 1.02234460e-01f, 4.64091785e-02f,
  -7.22828880e-02f, 2.52417997e-02f, 7.71010518e-02f, 1.48346871e-01f, -8.57851654e-02f, 1.97019532e-01f, -1.45116642e-01f, -3.22964564e-02f, 1.71534702e-01f, 8.26907754e-02f,
  1.19819209e-01f, -1.47828157e-03f, -3.44815217e-02f, 2.14758143e-01f, -4.77851322e-03f, -8.88829157e-02f, 1.91803992e-01f, 2.22321527e-04f, -2.50057250e-01f, 2.50611633e-01f,
  1.27331048e-01f, 6.79198205e-02f, 5.79558834e-02f, 1.57354146e-01f, -1.16524689e-01f, -4.97754030e-02f, 8.95799547e-02f, -1.93627272e-02f, 1.82504803e-01f, -5.29779159e-02f,
  1.33237168e-01f, -7.74934590e-02f, 1.64491251e-01f, -1.20476753e-01f, 9.81323048e-02f, -2.34517045e-02f, -1.15173183e-01f, 1.06210098e-01f, 1.47099018e-01f, 1.15340166e-01f,
  1.29074410e-01f, 7.50973523e-02f, 5.08122854e-02f, 2.65529528e-02f, 1.08493790e-01f, 9.89581048e-02f, 8.14199299e-02f, 8.03254396e-02f, 1.39927089e-01f, 4.17788327e-02f,
  1.94218941e-02f, 2.02936426e-01f, -1.06086493e-01f, 1.14623636e-01f, 1.16027437e-01f, -3.25441994e-02f, 2.58013364e-02f, -1.16891876e-01f, -1.22355945e-01f, -5.68765216e-02f,
  1.89722389e-01f, -1.45818457e-01f, 1.25676304e-01f, 1.18532136e-01f, -1.44604936e-01f, 1.65747225e-01f, -1.01667881e-01f, 1.25038205e-03f, 1.91208750e-01f, 1.48662165e-01f,
  1.05173282e-01f, -9.19251367e-02f, -1.30579248e-02f, 8.44208598e-02f, 6.40624389e-02f, 2.46649206e-01f, 2.63919798e-03f, 4.00646068e-02f, -9.81483534e-02f, -8.31589028e-02f,
  6.08461760e-02f, -1.81128532e-01f, 1.04581773e-01f, -2.50006896e-02f, 1.46116868e-01f, 1.37200832e-01f, 6.38248771e-02f, 1.15959067e-03f, 7.91296735e-02f, -8.10041055e-02f,
  -1.80302095e-02f, -4.75458521e-03f, 6.92894310e-02f, 1.27169803e-01f, -1.19946077e-01f, -1.51690096e-01f, 4.37170500e-03f, 1.15356609e-01f, 1.52575141e-02f, -1.00068025e-01f,
  -4.34572482e-03f, 2.04743132e-01f, -8.92647170e-03f, 1.85019061e-01f, 2.36040398e-01f, 1.43274352e-01f, 2.72854239e-01f, 3.26703638e-02f, 1.71994701e-01f, 2.06300467e-01f,
  1.03535801e-01f, 1.69272497e-01f, 8.51927772e-02f, 1.01846159e-01f, -4.53431234e-02f, 1.19370565e-01f, 6.45804126e-03f, 5.53371795e-02f, 1.23737887e-01f, -2.60218918e-01f,
  -1.97147742e-01f, 9.42994654e-02f, -5.24295270e-02f, 6.56147152e-02f, 1.67917207e-01f, -1.24986656e-01f, 3.37342113e-01f, 4.51221354e-02f, -5.29862829e-02f, 1.04717098e-01f,
  4.58082296e-02f, -7.23164380e-02f, 2.10735410e-01f, 1.45589709e-01f, 2.70970017e-01f, 1.90780357e-01f, -1.29703388e-01f, -2.71189660e-02f, 1.43223926e-01f, 1.21605732e-01f,
  9.06967092e-03f, -5.55030778e-02f, -1.88690171e-01f, -1.29440919e-01f, 1.24326818e-01f, 2.29294738e-03f, 2.37175584e-01f, -1.97191462e-01f, 8.35498944e-02f, -5.45131974e-02f,
  1.65040717e-01f, 1.31915808e-01f, 1.98001623e-01f, 1.58362195e-01f, 2.23143287e-02f, 1.19045220e-01f, -1.12871274e-01f, 1.16021104e-01f, 3.16325240e-02f, -4.10234779e-02f,
  -1.04724720e-01f, 4.27102819e-02f, -7.30292648e-02f, -2.13175893e-01f, 4.61396985e-02f, -2.17040386e-02f, -7.73613527e-02f, 1.61569901e-02f, 1.13701969e-01f, 9.65905264e-02f,
  1.31323323e-01f, 2.01922506e-02f, 9.56870541e-02f, -3.53604625e-03f, 9.88830067e-03f, 7.31357932e-02f, 8.74972157e-03f, -2.24781185e-02f, 1.01262666e-01f, -7.06645623e-02f,
  8.84765759e-02f, 3.83217186e-02f, 1.63661078e-01f, -1.28459990e-01f, -1.63449779e-01f, 1.09342001e-01f, 7.42581189e-02f, 1.45188659e-01f, -1.11602522e-01f, 1.68511365e-02f,
  4.74035852e-02f, 6.41456768e-02f, 1.76978841e-01f, 9.19138417e-02f, -7.80341923e-02f, 3.94141190e-02f, 6.54270723e-02f, -6.01738878e-02f, 2.22784027e-01f, 1.52719781e-01f,
  -1.31656513e-01f, -5.95327951e-02f, -2.45952867e-02f, 7.94266537e-02f, 1.86534539e-01f, -8.37920606e-02f, 1.52987048e-01f, 8.28358456e-02f, -7.81100914e-02f, 3.20980400e-02f,
  1.99182466e-01f, -1.43254817e-01f, -3.60941142e-02f, -9.95355248e-02f, -3.22813392e-02f, 3.15278135e-02f, 1.92311421e-01f, 1.05253875e-01f, 2.43768971e-02f, 3.18392143e-02f,
  9.34938714e-02f, 6.57828990e-03f, -1.54545635e-03f, -4.50220704e-03f, -3.95868272e-02f, 1.08288109e-01f, 1.90276653e-02f, 8.98923501e-02f, 1.98998928e-01f, -2.47216094e-02f,
  -9.21051502e-02f, 1.32032260e-02f, 2.11190999e-01f, 2.09289752e-02f, 2.03974500e-01f, -3.30028981e-02f, 6.32647797e-02f, 1.63261354e-01f, 1.48755070e-02f, 1.81557044e-01f,
  -8.20637122e-03f, 4.27395105e-02f, -7.90113807e-02f, 1.85291797e-01f, 1.61673892e-02f, 8.19483325e-02f, 2.59000491e-02f, -8.84732511e-03f, -1.36732355e-01f, -9.00148824e-02f,
  1.53044583e-02f, 7.41948560e-02f, 1.22940294e-01f, -2.95210689e-01f, 2.25054070e-01f, 5.89311570e-02f, -4.25366051e-02f, 4.63290513e-02f, -5.50073199e-02f, 3.48727331e-02f,
  2.96324611e-01f, 2.44218469e-01f, 3.53174388e-01f, 4.90447655e-02f, -1.38785511e-01f, -1.50429413e-01f, 5.63586093e-02f, 3.24403077e-01f, 1.87086850e-01f, -1.17568754e-01f,
  -8.15165937e-02f, 9.58971027e-03f, 2.11642310e-01f, -6.90523088e-02f, 2.61177838e-01f, -1.26101434e-01f, -1.03900149e-01f, 1.24965191e-01f, 5.74925467e-02f, -1.02947317e-01f,
  9.97660905e-02f, 4.76326281e-03f, -8.24761093e-02f, -5.80663905e-02f, 1.77540313e-02f, 1.38490275e-01f, -6.21487349e-02f, 9.37999636e-02f, 7.75812492e-02f, 1.85903534e-01f,
  -3.34027261e-02f, -5.74604683e-02f, 1.07501574e-01f, 1.22215936e-03f, 8.40884447e-02f, 2.08584115e-01f, -1.56565666e-01f, 1.60315856e-01f, 5.04883640e-02f, 1.48346305e-01f,
  3.37172523e-02f, 5.18796071e-02f, 8.35757256e-02f, 7.37284496e-03f, -2.64849309e-02f, 7.79865757e-02f, 2.37868398e-01f, -4.34388919e-03f, -2.92131662e-01f, 5.16277216e-02f,
  5.70846125e-02f, 8.60328525e-02f, 2.20606714e-01f, -2.36839071e-01f, 7.52768889e-02f, -1.78209484e-01f, -1.27104238e-01f, 1.06664836e-01f, -7.74678141e-02f, 4.81483340e-02f,
  1.78686514e-01f, 1.12926207e-01f, 8.21578577e-02f, 2.15136111e-01f, -2.19462290e-02f, -6.67881146e-02f, -2.60618389e-01f, 8.78209155e-03f, 2.76648819e-01f, 3.67650658e-01f,
  8.23683590e-02f, -1.54070795e-01f, 1.71273053e-01f, -7.14228451e-02f, 2.23397732e-01f, 1.98010013e-01f, -6.55251369e-02f, 1.44942045e-01f, -3.70080359e-02f, 1.74709424e-01f,
  -4.92454432e-02f, 4.17390205e-02f, 1.10584581e-02f, -1.66650683e-01f, -5.13030868e-03f, -8.80309716e-02f, 1.14133000e-01f, -3.38230133e-02f, 2.67086565e-01f, -5.69543578e-02f,
  -1.73283085e-01f, -2.18353391e-01f, -2.25382984e-01f, 4.59617972e-02f, 2.01326281e-01f, 1.80734515e-01f, 9.20439512e-02f, 9.02787745e-02f, -1.23281077e-01f, 1.03549436e-02f,
  8.44678059e-02f, -3.10798045e-02f, 1.52137458e-01f, 9.84599739e-02f, -3.03215552e-02f, -5.11659868e-02f, 9.03861970e-02f, 2.47090776e-02f, 3.86673622e-02f, -6.64102659e-02f,
  -1.83008656e-01f, 1.39612213e-01f, 2.26284433e-02f, 1.68058276e-01f, 3.11353207e-02f, -3.67766395e-02f, 4.18014005e-02f, 1.49429217e-01f, -3.58284973e-02f, -1.52423903e-01f,
  -7.19226077e-02f, -8.43415931e-02f, 1.67500019e-01f, 1.46965813e-02f, -1.10539503e-01f, 2.09058393e-02f, 2.14301735e-01f, -3.64727601e-02f, 1.39920518e-01f, 7.71992728e-02f,
  8.30568150e-02f, -8.42919387e-03f, -1.83545738e-01f, -2.35500075e-02f, 1.67751044e-01f, 1.60686165e-01f, -2.24537011e-02f, 9.59875714e-03f, 1.92510307e-01f, -9.49704647e-03f,
  -2.22063974e-01f, -8.63799155e-02f, 4.73979786e-02f, -1.21284127e-01f, 2.06349939e-01f, 5.04698269e-02f, 1.81552842e-01f, 2.04230398e-01f, -2.05854222e-01f, 1.44916344e-02f,
  -2.05500185e-01f, -8.48354921e-02f, -1.14856519e-01f, 8.41969848e-02f, 3.95761468e-02f, -3.59022878e-02f, -8.28726664e-02f, 9.96299647e-03f, 3.28754485e-02f, 7.04787448e-02f,
  -2.03943938e-01f, 3.71327959e-02f, 9.08826217e-02f, 2.64852364e-02f, 1.30168870e-01f, 1.85863242e-01f, 9.73170549e-02f, 1.40254796e-01f, 8.31951350e-02f, 7.81455189e-02f,
  1.02044947e-01f, 4.98264022e-02f, 1.32798448e-01f, 1.51798815e-01f, 2.73212586e-02f, 1.24242865e-01f, -1.49972945e-01f, 5.91957793e-02f, 1.96980774e-01f, -9.03187320e-02f,
  4.72624861e-02f, -4.51013483e-02f, -1.42718002e-01f, -1.49032101e-01f, 1.62520185e-01f, 6.47950917e-02f, 1.55115977e-01f, 1.64092943e-01f, -6.01394214e-02f, 2.46698737e-01f,
  8.72649699e-02f, 1.56169817e-01f, 4.45372425e-02f, 6.61375150e-02f, -4.14992403e-03f, -1.02678433e-01f, -1.45488605e-02f, 2.25127026e-01f, 1.20422384e-02f, -6.62512258e-02f,
  6.21062098e-03f, 2.25489736e-02f, 9.19857547e-02f, -2.88441982e-02f, 2.72106901e-02f, -1.95083857e-01f, 1.76590249e-01f, -3.46332649e-03f, 1.13047339e-01f, -1.18963923e-02f,
  8.49989057e-02f, 3.92455757e-02f, 7.75171667e-02f, 3.51009145e-02f, 1.10242009e-01f, 1.07425518e-01f, -3.88809219e-02f, 1.00064151e-01f, -9.76753831e-02f, -1.03486650e-01f,
  -1.36132523e-01f, 8.65853429e-02f, 1.99600995e-01f, 1.05200946e-01f, -1.10170916e-01f, 2.39577010e-01f, -1.43521950e-01f, 6.65458962e-02f, -7.60304257e-02f, 9.04337503e-03f,
  -7.90925398e-02f, 1.88642461e-02f, 1.27478972e-01f, -1.22751236e-01f, -7.70785734e-02f, 6.91811293e-02f, -1.06956892e-01f, 8.87075216e-02f, 1.55233771e-01f, -1.51432320e-01f,
  9.30586383e-02f, -1.17179334e-01f, -1.57585263e-03f, 5.17424531e-02f, 1.06085286e-01f, 8.51376206e-02f, 1.16856880e-01f, -1.67085938e-02f, -1.06894530e-01f, 1.14206553e-01f,
  -2.17110038e-01f, -1.24094784e-01f, 2.88212478e-01f, -9.00567248e-02f, -6.70703733e-03f, 9.51969698e-02f, -6.07877932e-02f, 2.68574860e-02f, 4.64524254e-02f, 1.47910312e-01f,
  9.96261165e-02f, 1.89669803e-01f, -6.47468269e-02f, -9.56980512e-02f, 1.16019428e-01f, -5.90050742e-02f, 7.59315863e-02f, 1.42093644e-01f, -1.05103202e-01f, 2.05652237e-01f,
  5.73897138e-02f, 7.71838352e-02f, -4.39622514e-02f, 7.97851458e-02f, -1.26693994e-01f, -3.66877094e-02f, 6.57318020e-03f, 4.31644395e-02f, 1.25645190e-01f, -4.50008437e-02f,
  2.36049905e-01f, 7.91519806e-02f, 3.25905718e-02f, 1.32053373e-02f, -3.86967100e-02f, 1.12345934e-01f, -5.34131862e-02f, 1.14617169e-01f, 1.36671558e-01f, -6.84192181e-02f,
  -1.82120726e-02f, -8.86234939e-02f, 6.13675406e-03f, 1.74864307e-02f, -1.12524303e-02f, 4.96401452e-02f, 4.57543768e-02f, -2.05295589e-02f, 5.90672269e-02f, 9.03426111e-02f,
  -2.29720902e-02f, 1.62150729e-02f, 1.04553085e-02f, -7.73890093e-02f, -3.73892263e-02f, 5.17569557e-02f, -1.08772106e-01f, 5.15407175e-02f, -3.89588736e-02f, 5.33271804e-02f,
  8.98786038e-02f, -1.30603239e-01f, -2.67175049e-01f, -1.00232668e-01f, -7.01389555e-03f, 3.23097743e-02f, 1.75520435e-01f, -6.26213849e-02f, -1.02495246e-01f, 8.03738981e-02f,
  6.69804460e-04f, -6.21526651e-02f, 1.03076667e-01f, 1.84815377e-02f, 9.11789536e-02f, 3.21463495e-02f, 1.79378271e-01f, 1.24352716e-01f, 1.61990836e-01f, -1.07458681e-01f,
  1.93224221e-01f, 1.61497235e-01f, -2.68799245e-01f, 8.60442296e-02f, 1.38174847e-01f, -1.31010816e-01f, 1.21570230e-02f, 2.30428390e-02f, -8.55011120e-02f, -3.96634415e-02f,
  -1.26878515e-01f, 8.82151816e-03f, -9.40763876e-02f, -8.37873518e-02f, 1.66415587e-01f, 1.27199799e-01f, -8.68022889e-02f, -4.00850847e-02f, -1.64168790e-01f, 1.94488078e-01f,
  4.26147953e-02f, 1.28493860e-01f, 1.58586010e-01f, -1.49933502e-01f, 4.51496318e-02f, -2.42991280e-02f, -9.02621355e-03f, -7.33427480e-02f, 3.50027531e-02f, 4.99168411e-02f,
  -1.33574143e-01f, -2.05571223e-02f, -3.37386131e-02f, 1.47153530e-02f, 1.08806044e-02f, 4.13423292e-02f, 1.68584660e-02f, -9.83961374e-02f, 1.53362930e-01f, -2.06257910e-01f,
  -2.24891081e-01f, 6.30818680e-02f, -1.12654999e-01f, -2.54064761e-02f, 1.77695349e-01f, 5.47703803e-02f, 5.38927652e-02f, 5.50051332e-02f, -4.21403795e-02f, -7.86152259e-02f,
  -9.68167465e-03f, -1.84787393e-01f, 6.53395429e-02f, -1.24526910e-01f, -5.69052175e-02f, 4.60343696e-02f, 9.52304527e-03f, 1.73201397e-01f, 1.17654927e-01f, -6.63566589e-02f,
  -5.37627749e-02f, 1.33565888e-01f, 1.68127030e-01f, 4.79499921e-02f, -1.65782422e-01f, 6.07559178e-03f, 5.25160804e-02f, 1.56872541e-01f, -1.51655570e-01f, 1.61781505e-01f,
  -2.53471266e-02f, 3.53959277e-02f, 1.86934248e-01f, -7.65014142e-02f, -5.71840489e-03f, 1.87849090e-01f, 4.01880965e-02f, 1.10542411e-02f, 9.24248993e-02f, -1.08156301e-01f,
  1.78822398e-01f, 1.64991871e-01f, 2.31802553e-01f, -9.97764766e-02f, -1.29996240e-01f, -1.24763712e-01f, -7.72772133e-02f, -4.50848490e-02f, 2.10118800e-01f, -5.36807813e-02f,
  -1.55370831e-01f, 3.07615642e-02f, -1.36618525e-01f, -5.78810042e-03f, 9.65913907e-02f, 1.21430062e-01f, -2.24584527e-02f, 1.54440124e-02f, 2.65768319e-02f, 6.56661168e-02f,
  1.23455070e-01f, 6.60251901e-02f, -7.12129250e-02f, 1.16795108e-01f, 1.26379328e-02f, 1.09947190e-01f, 2.26552635e-01f, -1.07488871e-01f, -2.95513161e-02f, -1.69771135e-01f,
  -4.94296253e-02f, 3.79010364e-02f, -4.21362072e-02f, 4.64905351e-02f, 1.58358775e-02f, 2.28837922e-01f, 9.40480232e-02f, 2.08333224e-01f, -1.68055266e-01f, 1.17021568e-01f,
  -2.37358317e-01f, 3.46695669e-02f, 2.76973039e-01f, 2.20659375e-01f, 1.81744359e-02f, -1.61830022e-03f, 7.82604665e-02f, 6.27368018e-02f, 8.45966935e-02f, 1.52703673e-01f,
  -1.98028050e-02f, -4.88657504e-02f, 4.81529459e-02f, 2.06730947e-01f, 1.32151365e-01f, 1.73079088e-01f, 2.18942426e-02f, 1.10942930e-01f, -1.28258452e-01f, -1.52185962e-01f,
  1.46759301e-02f, -7.39763770e-03f, 7.17916936e-02f, -3.44204865e-02f, -2.93721654e-03f, -6.70873746e-02f, -9.28172618e-02f, 5.74985296e-02f, 2.34078348e-01f, 1.99762344e-01f,
  -2.24746704e-01f, 1.41227543e-01f, 1.56323269e-01f, 1.17687903e-01f, 6.63487613e-03f, -1.81410611e-01f, -8.15132633e-02f, 4.28598002e-02f, -2.87541300e-01f, 2.64110193e-02f,
  1.08811678e-02f, -2.62802038e-02f, -4.39557172e-02f, -1.20190606e-01f, -1.71770543e-01f, -1.63021728e-01f, 1.76316172e-01f, 2.74530724e-02f, 7.87985623e-02f, 1.30816117e-01f,
  7.67895728e-02f, 9.07109678e-02f, -3.66355442e-02f, 1.06402738e-02f, -2.87502501e-02f, -8.02326202e-03f, -6.12655133e-02f, 4.57623489e-02f, -2.12663963e-01f, 7.52661899e-02f,
  2.15864539e-01f, -3.58849689e-02f, -4.08715941e-02f, 1.89704955e-01f, 8.51303041e-02f, -2.02742796e-02f, 4.77449000e-02f, -9.32129696e-02f, 8.35811272e-02f, 1.08996890e-02f,
  -5.27875945e-02f, 2.10519761e-01f, 1.27490640e-01f, -3.18542942e-02f, -1.61808282e-01f, 7.33911395e-02f, -4.94255796e-02f, 6.53553829e-02f, 1.51240408e-01f, -5.21039926e-02f,
  -4.00939398e-02f, 2.26545498e-01f, -1.45282909e-01f, 2.87506729e-02f, -2.12816849e-01f, -8.39507654e-02f, -9.14074033e-02f, 2.14535417e-03f, 1.23060837e-01f, 1.33121774e-01f,
  1.68914944e-01f, 1.68078672e-02f, 5.25351502e-02f, 1.35558024e-01f, -9.77136195e-02f, 7.26725757e-02f, 1.77679256e-01f, -2.86128484e-02f, -9.25887898e-02f, -3.14337085e-03f,
  -1.38319626e-01f, 1.63836777e-02f, 3.66876237e-02f, -1.08309038e-01f, -3.09443232e-02f, -2.95655373e-02f, -3.58626842e-02f, -7.15713482e-03f, -1.30643584e-02f, -9.65676084e-02f,
  4.17931704e-03f, 4.44453210e-02f, 1.34178996e-02f, 5.47929890e-02f, 1.59794360e-01f, 6.01783097e-02f, 1.03370100e-01f, -3.38318460e-02f, -2.94899821e-01f, 1.60365000e-01f,
  -2.50144601e-01f, -7.97854215e-02f, 1.08029060e-01f, -2.29981709e-02f, 2.11264700e-01f, 7.98267722e-02f, -1.00005113e-01f, 1.89508474e-03f, -2.60740574e-02f, 1.11386873e-01f,
  3.80660892e-02f, 1.32288590e-01f, 8.95187855e-02f, -1.15168832e-01f, -6.08831421e-02f, 6.74560368e-02f, 2.29339123e-01f, 1.70840338e-01f, -3.34270418e-01f, 1.95766091e-01f,
  -4.34921235e-02f, -4.30329442e-02f, 2.26758629e-01f, -2.78405671e-04f, -1.26344606e-01f, 1.21457249e-01f, 6.47345185e-03f, -7.23624080e-02f, -8.69898945e-02f, -1.14216395e-01f,
  -3.38074192e-02f, 3.15246433e-02f, 1.09321773e-01f, 2.81712785e-02f, -5.79012334e-02f, -2.97400914e-02f, 7.99157321e-02f, 1.81499004e-01f, 1.13939777e-01f, -1.39085680e-01f,
  6.97576329e-02f, -1.85144097e-01f, -4.16212790e-02f, 8.09818506e-02f, -4.19203192e-03f, -5.69882197e-03f, 1.83011238e-02f, 4.94357646e-02f, -8.35249387e-03f, 9.67522264e-02f,
  5.41056804e-02f, -8.81354697e-03f, 4.58986163e-02f, 6.11963309e-03f, -1.44328708e-02f, 4.22879905e-02f, 6.66828603e-02f, -8.67207441e-03f, -4.00897264e-02f, -1.13833055e-01f,
  -5.96799850e-02f, -5.01085259e-03f, 8.13691970e-03f, -4.48016375e-02f, 5.10503985e-02f, 2.33276322e-01f, 1.92009248e-02f, 1.19691148e-01f, -1.66476175e-01f, 1.09053172e-01f,
  2.07279235e-01f, 5.62899821e-02f, 1.50099203e-01f, -1.59361199e-01f, 3.12527712e-03f, 1.07838295e-01f, -8.70546550e-02f, 1.03694603e-01f, 4.62810546e-02f, -1.53782114e-01f,
  -2.69467551e-02f, -4.70410613e-03f, 2.02583060e-01f, -1.94039240e-01f, 8.89425725e-02f, -4.46499586e-02f, -1.89560190e-01f, 3.29531431e-02f, -3.11924126e-02f, -1.10228591e-01f,
  1.90552026e-01f, -9.19715464e-02f, 7.78704286e-02f, 4.49048653e-02f, 1.70465201e-01f, 1.88665345e-01f, -1.88420162e-01f, -1.49499670e-01f, -1.16175056e-01f, 2.45253786e-01f,
  1.46330833e-01f, 7.81887099e-02f, -1.79367140e-02f, 1.10653006e-01f, -1.77693725e-01f, 2.03198761e-01f, 9.00769532e-02f, -2.51153242e-02f, 1.62570238e-01f, 5.26675284e-02f,
  -5.41621409e-02f, 1.22854188e-01f, 1.29723087e-01f, 1.04043901e-01f, 2.18337074e-01f, 3.65133546e-02f, -3.42495590e-02f, 1.31443962e-01f, 1.21710546e-01f, -6.03827974e-03f,
  -7.39944447e-03f, 3.60138789e-02f, -3.27250846e-02f, -6.15740381e-02f, -3.25559489e-02f, -6.16206340e-02f, 1.05097130e-01f, -2.43890077e-01f, 6.92697018e-02f, 8.53716210e-02f,
  -2.35494733e-01f, -4.86671664e-02f, 1.27860755e-01f, -5.87229133e-02f, 1.46377742e-01f, 2.81854570e-01f, 1.18330680e-01f, 1.43012905e-03f, -1.09295882e-01f, -1.71531618e-01f,
  -3.32308770e-03f, 2.94034809e-01f, 7.81844184e-02f, 1.22549698e-01f, -1.19156539e-01f, -1.18257403e-01f, 1.50919631e-01f, 3.05915140e-02f, 4.74180542e-02f, 7.70794004e-02f,
  1.81700110e-01f, 2.36951351e-01f, 2.22656593e-01f, 1.52517259e-01f, -9.15828440e-03f, -6.60101026e-02f, -5.17399833e-02f, -5.15730456e-02f, -2.46447953e-03f, 8.21328610e-02f,
  7.71217719e-02f, 9.07558799e-02f, 2.26708919e-01f, 2.19952097e-04f, 5.53490594e-02f, -1.09597802e-01f, -1.95294619e-01f, 1.67206332e-01f, 1.80856630e-01f, 2.65874594e-01f,
  -6.19315030e-03f, -2.17789598e-02f, -4.10189256e-02f, -1.77464373e-02f, -7.17708899e-04f, -8.15762505e-02f, 1.27527062e-02f, -6.57466426e-02f, -5.80388680e-03f, -4.86417301e-02f,
  -1.77235696e-02f, -5.70391566e-02f, 6.30892441e-02f, -3.66249420e-02f, 5.11537082e-02f, -3.28509174e-02f, 2.61736251e-02f, 3.77268530e-02f, -4.00127359e-02f, 5.57987057e-02f,
  -3.81904989e-02f, 4.78532817e-03f, -4.28120904e-02f, -1.63712073e-02f, 1.00305989e-01f, -1.08645838e-02f, 1.04174698e-02f, -5.41984700e-02f, -4.85979877e-02f, -5.86623736e-02f,
  1.76196005e-02f, 1.03592975e-02f, -6.63524196e-02f, -4.69058715e-02f, -2.07556132e-03f, -1.08475983e-02f, 2.99566127e-02f, -3.70375626e-02f, 4.68962677e-02f, -1.96907520e-02f,
  -4.24313433e-02f, 6.36199042e-02f, -2.23973338e-02f, -3.61534245e-02f, -1.34734446e-02f, -5.38803898e-02f, -7.48120844e-02f, 2.46213768e-02f, 2.72907019e-02f, -2.61199567e-02f,
  1.42478971e-02f, -5.12362458e-02f, -4.11338322e-02f, -1.93038583e-02f, -6.33326322e-02f, -6.75284490e-03f, 2.17408370e-02f, -1.98584441e-02f, 3.57592199e-03f, 7.50431046e-02f,
  1.18155412e-01f, 4.59872745e-03f, -3.71660590e-02f, -7.79436342e-03f, -1.35636985e-01f, 2.80237589e-02f, 5.14813401e-02f, -4.73055094e-02f, -1.17216362e-02f, 5.80657162e-02f,
  -8.40493515e-02f, -2.54133791e-02f, 1.90649722e-02f, 1.29347965e-01f, 1.24739058e-01f, 8.13661665e-02f, -1.37506261e-01f, -1.55761540e-01f, -2.34306261e-01f, 9.36995149e-02f,
  -4.36187610e-02f, -1.54127419e-01f, 1.64016724e-01f, -7.55489171e-02f, 6.95358962e-02f, 1.02039345e-01f, 5.38333971e-03f, -1.06755860e-01f, 9.44688991e-02f, -1.37887314e-01f,
  -6.72928914e-02f, 1.17096178e-01f, 2.77476385e-02f, -9.50598717e-02f, -4.75348197e-02f, 5.73841222e-02f, 3.25182945e-01f, 5.91713153e-02f, -4.35396656e-02f, 9.64199901e-02f,
  9.41716954e-02f, 7.95738474e-02f, -1.78708613e-01f, -8.05742282e-04f, 1.86739221e-01f, 6.37105554e-02f, -2.17040092e-01f, 9.41457152e-02f, 3.25682983e-02f, 1.08569697e-01f,
  5.66658340e-02f, -2.14918852e-01f, 6.20810799e-02f, 1.21770583e-01f, 2.02717260e-01f, 8.54219794e-02f, 2.49932647e-01f, -1.18339054e-01f, 1.30392477e-01f, 1.26957625e-01f,
  -9.93173197e-03f, -3.25161479e-02f, -4.26577851e-02f, -1.67389706e-01f, -8.54055211e-02f, 3.95793244e-02f, 1.76381007e-01f, 1.29511341e-01f, 6.58804225e-03f, 2.95735523e-02f,
  1.60587542e-02f, 1.52705861e-02f, 4.33964469e-02f, -1.55746937e-03f, -2.13206057e-02f, -1.14374317e-01f, -3.34257558e-02f, 3.01991422e-02f, -5.49869724e-02f, 1.39268506e-02f,
  1.66648626e-02f, 7.10754022e-02f, -3.59873697e-02f, 2.22362671e-02f, 1.28435180e-01f, 1.52731970e-01f, 1.74639169e-02f, -1.07952073e-01f, -6.42049313e-02f, 4.72026058e-02f,
  1.72996018e-02f, -1.07333250e-01f, 4.99824993e-02f, -9.72890481e-02f, 1.77269712e-01f, 9.41810310e-02f, -1.24967424e-02f, 1.28019691e-01f, 4.87581156e-02f, 9.20165610e-03f,
  5.59896752e-02f, -4.85109463e-02f, 1.21999368e-01f, -1.87560101e-03f, -7.76220784e-02f, 1.03693947e-01f, 9.32573527e-02f, 1.32818278e-02f, -1.85071632e-01f, 1.49932593e-01f,
  -4.01136130e-02f, 1.44143431e-02f, 1.34185046e-01f, 2.25704163e-02f, -6.99747577e-02f, 2.72265047e-01f, -1.07077815e-01f, 6.40887097e-02f, -1.55628860e-01f, -6.28109574e-02f,
  -6.41437899e-03f, -7.39177093e-02f, 5.70216142e-02f, 6.69271201e-02f, 1.74214635e-02f, -1.27585456e-01f, -8.79919678e-02f, 1.09747283e-01f, -5.31771705e-02f, -2.42311228e-02f,
  1.50413528e-01f, -1.46712512e-02f, -1.56006724e-01f, -8.86016898e-03f, -5.92153445e-02f, -8.03751312e-03f, -2.74253450e-02f, 1.59081612e-02f, 6.61307871e-02f, -5.09241447e-02f,
  7.42454007e-02f, 3.39885149e-03f, 6.01875782e-02f, 1.68846827e-02f, -2.10558087e-01f, 2.03465410e-02f, 4.70394194e-02f, 7.22725913e-02f, 1.49657354e-01f, -1.29353806e-01f,
  -1.26712099e-01f, -6.73472211e-02f, -4.38997820e-02f, 9.19466168e-02f, -6.41116649e-02f, 1.61778629e-01f, 1.95603948e-02f, 1.55063838e-01f, 4.25737798e-02f, 1.45212650e-01f,
  -1.09647233e-02f, 8.27252492e-02f, -5.12077995e-02f, -3.40782143e-02f, 1.98229596e-01f, 1.96702510e-01f, 4.10946179e-03f, -6.54738322e-02f, 1.03236921e-02f, 7.19225854e-02f,
  1.72458798e-01f, 6.56433776e-02f, -2.11961046e-02f, -7.16339797e-02f, -4.48249243e-02f, 1.17226921e-01f, 3.03189363e-02f, 5.95034547e-02f, 1.03209518e-01f, -1.76018905e-02f,
  -6.55696243e-02f, -1.27346337e-01f, 1.22205667e-01f, 4.30406220e-02f, 6.90829977e-02f, 7.17509026e-03f, 2.39666458e-02f, -1.11374617e-01f, -8.69326070e-02f, 1.40225917e-01f,
  2.34708607e-01f, 1.42870098e-01f, -7.41129443e-02f, 2.24675670e-01f, -8.07079226e-02f, 9.79122370e-02f, 8.97646770e-02f, 1.87423062e-02f, 3.06229964e-02f, 4.52082120e-02f,
  1.16696674e-02f, -1.03746563e-01f, -4.18265723e-02f, -2.30986346e-02f, 2.17679646e-02f, -1.49909721e-03f, 6.46021813e-02f, -6.54406473e-02f, 1.64286241e-01f, -8.03885609e-02f,
  2.21606687e-01f, -1.90179333e-01f, -6.86379150e-02f, 1.24656580e-01f, -1.07228018e-01f, 2.18716994e-01f, -8.63551125e-02f, 3.20119485e-02f, -1.21661328e-01f, 5.50771393e-02f,
  2.90758342e-01f, 1.29445404e-01f, -2.35979725e-02f, -5.52178733e-02f, 1.15191117e-01f, -7.27493986e-02f, 2.03922205e-02f, 1.75311184e-03f, -1.52955279e-01f, -1.05151227e-02f,
  -3.76258306e-02f, -3.41739580e-02f, 7.58069977e-02f, -1.16967119e-01f, 2.40432456e-01f, 2.89818738e-02f, 1.96544025e-02f, 1.94877442e-02f, 2.17804700e-01f, -6.54874891e-02f,
  -9.78834406e-02f, -1.68129146e-01f, -1.39479563e-01f, -5.81796467e-02f, 2.94000953e-01f, -3.90604623e-02f, 2.08087377e-02f, -7.23987743e-02f, -7.95419980e-03f, 1.46121770e-01f,
  -2.14355543e-01f, -7.60828182e-02f, 8.52892622e-02f, 1.45819306e-01f, 1.05297342e-01f, 2.07949519e-01f, 3.09135765e-01f, -5.98838441e-02f, -2.07200676e-01f, -1.55646801e-01f,
  9.93652716e-02f, 1.40734594e-02f, 1.26292422e-01f, 5.10773435e-02f, 1.65240113e-02f, 7.00358897e-02f, 8.65255892e-02f, 1.59093395e-01f, 1.44780964e-01f, 8.32363963e-02f,
  6.50424883e-02f, 1.19534865e-01f, 3.90453776e-03f, -1.46350682e-01f, -1.09735362e-01f, -9.47121084e-02f, -7.57812057e-04f, -3.07090376e-02f, 5.60036413e-02f, 1.07702045e-02f,
  2.35550746e-01f, 2.87831146e-02f, 1.44550353e-01f, -4.97974791e-02f, 9.75179579e-03f, -1.88083258e-02f, 1.72915086e-01f, 3.80853824e-02f, 2.45594103e-02f, 5.86154386e-02f,
  -5.59135117e-02f, 1.11539789e-01f, 8.65009278e-02f, -1.88211687e-02f, 5.40215522e-02f, -9.53122005e-02f, 5.58185391e-02f, 1.36321887e-01f, -1.84478313e-01f, -1.53809071e-01f,
  3.24692160e-01f, 1.37691021e-01f, 2.07816660e-02f, 1.81268513e-01f, -8.57434329e-03f, 2.12923869e-01f, 2.65477270e-01f, 1.27471149e-01f, 6.72751069e-02f, 7.54659623e-02f,
  1.80039600e-01f, 1.20799728e-01f, 1.77483499e-01f, -8.05131122e-02f, 1.67256549e-01f, 1.45794719e-01f, 1.18452273e-01f, -5.52595630e-02f, -4.44515944e-02f, -4.70557064e-02f,
  -8.56060684e-02f, 1.09395072e-01f, 9.21319947e-02f, 1.73879787e-01f, -3.81536372e-02f, -1.09657170e-02f, -6.45947903e-02f, 6.24939427e-03f, 1.18157268e-02f, -7.09574297e-02f,
  -6.98025748e-02f, -2.70160176e-02f, -2.96498425e-02f, -1.10392831e-01f, -1.39461849e-02f, -1.16708517e-01f, 9.60059762e-02f, 2.31814068e-02f, 1.56655759e-01f, -2.77714971e-02f,
  6.96078390e-02f, 1.67911407e-02f, 6.43051136e-03f, 1.34965494e-01f, -1.74499810e-01f, -1.04070969e-01f, -1.09887600e-01f, 5.65759502e-02f, 2.38940388e-01f, 7.54693225e-02f,
  -4.77312282e-02f, 2.19749697e-02f, 7.82477856e-02f, 5.31151779e-02f, 1.21299468e-01f, -1.87298041e-02f, -2.40878500e-02f, -3.42316367e-02f, -6.83643622e-03f, 1.80077940e-01f,
  9.64799896e-02f, -9.48903784e-02f, 1.96187228e-01f, 1.15170017e-01f, -2.27573797e-01f, -1.35895638e-02f, 1.51522309e-01f, -9.31285322e-02f, -1.00189168e-03f, -1.09005295e-01f,
  -2.48388216e-01f, 6.30819127e-02f, 8.83254260e-02f, -6.49570450e-02f, -9.66672972e-02f, -1.59581855e-01f, 4.18272726e-02f, 8.42610374e-02f, -1.53958961e-01f, -3.78284343e-02f,
  1.13957591e-01f, 1.07326075e-01f, 9.36015546e-02f, 2.33346030e-01f, 2.90044278e-01f, -5.16578704e-02f, -1.19001716e-01f, -5.46488725e-02f, 2.40699276e-01f, 1.54141307e-01f,
  2.78411329e-01f, 1.80943102e-01f, 2.70250253e-02f, 1.04952440e-01f, 1.73094586e-01f, 1.11134000e-01f, 9.33534354e-02f, 6.53645843e-02f, -6.23998903e-02f, 1.56529546e-01f,
  -2.82184388e-02f, 1.52300969e-01f, 1.83178589e-01f, -2.20970273e-01f, -1.02484867e-01f, 1.77182481e-01f, -1.84304208e-01f, -1.03137968e-02f, 1.23337604e-01f, -2.14801691e-02f,
  2.26773068e-01f, -8.79417360e-03f, -2.10241094e-01f, 1.36528403e-01f, 1.92087144e-01f, -5.84749430e-02f, 1.93531707e-01f, 4.04575020e-02f, 9.61846933e-02f, 2.08257020e-01f,
  -1.83111623e-01f, 3.77480197e-03f, 1.43891409e-01f, -8.45350847e-02f, -3.65571082e-02f, 1.81763902e-01f, 4.12112065e-02f, -8.05644989e-02f, 1.46770343e-01f, -9.42813158e-02f,
  1.80400595e-01f, -1.68297824e-03f, 1.48525149e-01f, 6.57240627e-03f, 2.24712953e-01f, 2.23746940e-01f, 8.73889029e-02f, 1.34167209e-01f, -6.41833758e-03f, 1.53193742e-01f,
  -1.73989668e-01f, 3.69788450e-03f, 3.91861461e-02f, -8.23372509e-03f, -7.67050497e-03f, -4.72759418e-02f, 7.45178461e-02f, -1.58702627e-01f, -1.31314501e-01f, 1.76408619e-01f,
  1.29127964e-01f, 1.23621359e-01f, 3.50952893e-01f, 5.38394563e-02f, 1.38830498e-01f, 1.16233513e-01f, 9.55283120e-02f, 1.70873448e-01f, 1.04921751e-01f, 1.40505135e-01f,
  1.29109293e-01f, 7.81546086e-02f, -3.36681157e-02f, 1.42400399e-01f, -5.44362441e-02f, 2.13814750e-01f, 6.41879588e-02f, -1.36178717e-01f, -1.08588144e-01f, 1.68274090e-01f,
  -9.02784392e-02f, -9.52904597e-02f, 2.09842231e-02f, -2.35325977e-01f, 1.84368148e-01f, -6.49366528e-02f, -1.60876423e-01f, -1.49223013e-02f, -3.68089005e-02f, 8.13743621e-02f,
  1.05057940e-01f, -1.80018693e-02f, 3.50489050e-01f, 3.01908217e-02f, -1.91103160e-01f, -4.45516519e-02f, 2.70980626e-01f, 2.15104207e-01f, -9.56393555e-02f, 2.09358092e-02f,
  -8.83818045e-02f, -1.34530673e-02f, -1.06977083e-01f, -1.16288615e-02f, 2.49293983e-01f, -2.94957072e-01f, 1.01841398e-01f, -2.42469944e-02f, 3.80881391e-02f, 1.22387961e-01f,
  -1.12741873e-01f, 6.14274293e-02f, -1.40003383e-01f, -1.31791672e-02f, 6.17534854e-03f, 1.22744642e-01f, -7.91680887e-02f, -9.33901742e-02f, -2.18640909e-01f, -1.24366749e-02f,
  -1.14416659e-01f, -1.28574759e-01f, -2.08874028e-02f, 4.52503897e-02f, 1.89913493e-02f, 1.34018824e-01f, 2.08205596e-01f, 4.50139046e-02f, 1.29304782e-01f, 4.90411855e-02f,
  1.02469347e-01f, 3.10424305e-02f, 4.35247980e-02f, -6.39498308e-02f, 5.97155765e-02f, 1.36019662e-02f, 4.01575975e-02f, 1.17199950e-01f, 2.17036083e-01f, 1.35436747e-02f,
  4.59224172e-02f, -1.08743727e-01f, 1.49723515e-01f, 2.96723038e-01f, 1.49183288e-01f, -1.34118468e-01f, -1.27474964e-01f, 1.54007301e-01f, 3.71472165e-03f, -1.83897346e-01f,
  2.36617494e-02f, -1.69949099e-01f, 1.38276502e-01f, 5.26246578e-02f, -1.99264050e-01f, -1.96730960e-02f, -3.06775398e-03f, 2.17920825e-01f, -1.27864033e-01f, -8.36414546e-02f,
  2.92381644e-01f, -1.56050503e-01f, -3.69933248e-02f, 1.90011531e-01f, 2.22783953e-01f, 3.42932418e-02f, -1.73533037e-01f, 2.55826443e-01f, -4.56567481e-02f, -1.06786024e-02f,
  1.96964830e-01f, -6.23086579e-02f, 4.90178354e-03f, 3.59553099e-01f, -9.23719928e-02f, 8.53244811e-02f, 2.29184106e-02f, -2.00854335e-02f, -1.23567156e-01f, -1.08906887e-01f,
  5.32467328e-02f, 1.23579539e-01f, 7.27070644e-02f, -1.43640593e-01f, -7.23240227e-02f, 1.71237990e-01f, 1.05124330e-02f, 1.26602678e-02f, 9.65944380e-02f, -1.69790566e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  7.80916736e-02f, 4.25746739e-02f, 2.15542335e-02f, 2.17595380e-02f, 7.96507746e-02f, 1.22119911e-01f, 4.43525575e-02f, 1.09331338e-02f, 4.81545180e-03f, 6.13309294e-02f,
  1.63025036e-02f, 1.46706626e-01f, 8.07564706e-02f, 1.12802655e-01f, 1.53635129e-01f, 4.86852825e-02f, 8.79589170e-02f, 3.30131985e-02f, 6.83444515e-02f, 5.03887646e-02f,
  3.37667279e-02f, 5.62723354e-02f, 3.81869711e-02f, -4.96663852e-03f, -4.55975570e-02f, 1.81576572e-02f, 6.77853171e-03f, 5.52668236e-02f, 6.89716414e-02f, -7.80580007e-03f,
  -5.28915785e-02f, 6.56433776e-02f, -3.70953046e-02f, -4.12550047e-02f, 1.13412008e-01f, 3.47637534e-02f, -2.06287988e-02f, 4.28304896e-02f, 3.61212455e-02f, 1.05886482e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  7.18535259e-02f, 4.05866131e-02f, -4.14481573e-02f, 6.77499175e-02f, 1.45654351e-01f, -1.33058270e-02f, 3.59640084e-02f, -4.76044565e-02f, 3.09175579e-03f, -2.04849970e-02f,
  4.36141454e-02f, -6.45721108e-02f, -3.33317183e-02f, -3.79600339e-02f, -1.60361803e-03f, -7.89111182e-02f, 1.35491416e-01f, 5.36402836e-02f, -1.74338706e-02f, 9.00166705e-02f,
  1.23482347e-01f, 9.63334292e-02f, 1.99877601e-02f, 3.39142308e-02f, 8.18083733e-02f, -4.45776843e-02f, 1.77863501e-02f, 6.15431601e-03f, 1.23525932e-01f, -8.04435611e-02f,
  -5.40280454e-02f, 4.98368070e-02f, 9.11711305e-02f, -4.20479849e-02f, -2.96676401e-02f, -6.21009618e-02f, -2.48455405e-02f, -1.17916532e-01f, 7.00580748e-03f, -4.13772501e-02f,
  2.95726210e-02f, 9.83726010e-02f, 1.74976885e-02f, -1.87959448e-02f, -9.71303731e-02f, 3.12460586e-03f, 3.13194692e-02f, -5.82475364e-02f, 1.16594546e-01f, -6.54274821e-02f,
  4.95621189e-02f, 4.07465659e-02f, -1.91588141e-03f, 1.38109058e-01f, 6.39382899e-02f, 4.20921203e-03f, -4.77285162e-02f, -7.24649951e-02f, 7.82698467e-02f, 9.45773870e-02f,
  8.43961909e-02f, -4.90331799e-02f, 1.93984229e-02f, 9.18671787e-02f, 5.79625778e-02f, 1.35435993e-02f, 6.88261837e-02f, 1.54804392e-02f, -3.71457674e-02f, 7.41570219e-02f,
  8.03786069e-02f, -5.15377857e-02f, -5.67261279e-02f, -6.88546523e-02f, 5.79461176e-03f, 6.17852211e-02f, -2.14139707e-02f, 4.11568619e-02f, 8.90765414e-02f, -5.81929795e-02f,
  -9.36586857e-02f, -1.91821620e-01f, -4.35133167e-02f, -1.19956687e-01f, -1.98686831e-02f, -1.06592819e-01f, 5.15449345e-02f, -1.47565261e-01f, 8.28788728e-02f, -4.81634550e-02f,
  -1.28089532e-01f, 3.09298635e-02f, -9.24814120e-02f, -4.77849543e-02f, -1.18785852e-03f, -8.00783932e-02f, -1.15271159e-01f, -1.78644080e-02f, -6.52389750e-02f, 8.24431032e-02f,
  1.25049233e-01f, -3.26948166e-02f, 6.68743029e-02f, -7.22079724e-02f, -2.87527442e-02f, 1.06516860e-01f, -1.22141197e-01f, 1.52835205e-01f, -2.20991261e-02f, 9.50856432e-02f,
  -1.23585658e-02f, -1.27687022e-01f, -1.78816020e-01f, 3.49302893e-03f, -7.12108612e-02f, 4.18569054e-03f, 2.14794725e-02f, -8.36141035e-02f, -4.80344668e-02f, -3.00097223e-02f,
  -9.25059915e-02f, 1.09829530e-01f, 6.30830750e-02f, -8.50908533e-02f, -6.94890693e-02f, 3.43765803e-02f, -8.29999447e-02f, -4.51613367e-02f, -3.37293744e-02f, -6.28866488e-03f,
  -7.16977427e-03f, 3.33614014e-02f, 1.08150154e-01f, -8.00687224e-02f, 8.16955715e-02f, 1.03025790e-02f, 6.22835457e-02f, 7.25187419e-04f, -2.33621299e-02f, -9.46239531e-02f,
  -1.32302105e-01f, 4.62084375e-02f, -6.48187250e-02f, 8.56144503e-02f, 7.58493543e-02f, 5.50085306e-02f, 8.55084509e-03f, -1.00869723e-01f, 1.45540118e-01f, 4.43621464e-02f,
  -1.90571621e-01f, 2.55962964e-02f, 1.36475693e-02f, -1.91919859e-02f, -4.20649573e-02f, 1.03128046e-01f, 3.57390493e-02f, -2.72800010e-02f, -2.14073598e-01f, -4.64073978e-02f,
  -8.06978568e-02f, 1.37116581e-01f, 4.74505313e-02f, -5.55893034e-02f, -6.10014424e-02f, -1.01996720e-01f, -6.40350878e-02f, 3.34117748e-02f, 7.71877542e-02f, -1.37210533e-03f,
  1.25473782e-01f, 6.96586668e-02f, -1.28837004e-01f, 3.82456630e-02f, -3.56739312e-02f, -8.11386406e-02f, -8.03264827e-02f, -6.76824450e-02f, -2.04491898e-01f, 2.92733740e-02f,
  1.33361474e-01f, 3.49843018e-02f, 7.34640693e-04f, -3.21521014e-02f, -1.10529125e-01f, -3.25587317e-02f, -4.81710061e-02f, 7.29767233e-02f, -1.25803798e-01f, -5.41988648e-02f,
  2.98239123e-02f, -1.40822649e-01f, 1.71805229e-02f, -8.97326544e-02f, -1.48949206e-01f, 2.80634779e-02f, -1.88460320e-01f, -1.69315301e-02f, -8.72645378e-02f, 1.29394680e-02f,
  -8.62663686e-02f, -7.52223507e-02f, -5.19114686e-03f, -3.12329736e-02f, -1.01688439e-02f, 1.21472917e-01f, 1.61113203e-01f, -5.44827059e-02f, -1.32022537e-02f, 1.78714439e-01f,
  -2.92879250e-02f, 6.74159080e-02f, -4.92100753e-02f, 1.15144126e-01f, 1.07159860e-01f, 1.71371445e-01f, -5.55319078e-02f, -5.53224050e-02f, -1.69774592e-02f, -7.99285099e-02f,
  1.35660106e-02f, 5.57237864e-02f, -7.24032847e-03f, 3.66231054e-02f, -1.58385970e-02f, 1.83752999e-02f, -7.06638247e-02f, -1.86741486e-01f, -7.06946626e-02f, 6.93741515e-02f,
  1.59414038e-02f, 1.35016674e-02f, -1.47707626e-01f, -5.60630374e-02f, -1.14304513e-01f, -4.03660722e-02f, 1.27505690e-01f, -7.54583254e-02f, -2.49396339e-02f, 3.05989720e-02f,
  3.51870693e-02f, 7.83541985e-03f, 1.19702881e-02f, -6.82040304e-02f, -1.81050420e-01f, -4.99759503e-02f, 9.47332457e-02f, -4.16901968e-02f, 4.09373641e-02f, -6.98263720e-02f,
  -1.17982715e-01f, -1.02935717e-01f, -4.57096659e-02f, -1.15654044e-01f, -1.10351909e-02f, -1.05684012e-01f, 5.21001965e-02f, -9.32879150e-02f, -2.57800370e-02f, 1.16147079e-01f,
  5.35597764e-02f, 1.01317555e-01f, 6.76033571e-02f, 6.37639537e-02f, -1.56018091e-02f, 1.66959669e-02f, 3.12126055e-03f, 1.19834989e-01f, 3.80323231e-02f, -4.14635763e-02f,
  7.08719045e-02f, -3.78428549e-02f, -8.69078338e-02f, 3.39135411e-03f, -4.47560707e-03f, 9.92268994e-02f, -8.98388177e-02f, 1.30759608e-02f, 2.15404411e-03f, 3.08644976e-02f,
  -1.45210735e-02f, 7.20465183e-02f, 5.55100366e-02f, -8.42515230e-02f, 5.69890290e-02f, 3.23557295e-02f, 5.83474301e-02f, 5.04820794e-03f, 6.36154115e-02f, 2.82606017e-02f,
  7.20399767e-02f, 8.54645520e-02f, -3.84701602e-02f, 1.16318632e-02f, 1.08604141e-01f, -1.65097594e-01f, -1.04636379e-01f, -2.08060201e-02f, -1.15504265e-01f, -9.97510552e-02f,
  5.67900063e-03f, -4.66316305e-02f, 6.08348586e-02f, -1.48932323e-01f, -2.05670241e-02f, -3.92199345e-02f, 7.51224458e-02f, 8.80161673e-02f, -3.65073197e-02f, 6.75581535e-03f,
  4.38213348e-02f, -3.07227578e-02f, 6.65684640e-02f, -1.16659857e-01f, 3.57564352e-02f, 2.95166653e-02f, 1.83620621e-02f, -5.70199639e-03f, -2.65778340e-02f, 1.96980596e-01f,
  4.36728410e-02f, 3.67825897e-03f, -7.23208189e-02f, 1.16873413e-01f, -5.44575714e-02f, 6.42353520e-02f, 9.04101208e-02f, 3.35337296e-02f, 8.47945735e-02f, 5.96272685e-02f,
  -5.82913049e-02f, 8.41758326e-02f, -6.87644929e-02f, 9.74123999e-02f, 6.47714874e-03f, 6.48916885e-02f, -9.44109932e-02f, 8.62245858e-02f, 1.74308326e-02f, 2.20803730e-02f,
  7.72242695e-02f, 1.97054297e-02f, 1.51180133e-01f, -8.31963941e-02f, -5.81993572e-02f, -6.28868714e-02f, -1.67817087e-03f, -5.44798672e-02f, -4.65419143e-02f, 9.24188793e-02f,
  3.09630465e-02f, -1.45538505e-02f, -6.28258986e-03f, 1.04358271e-01f, -2.30001137e-02f, 3.53453159e-02f, -8.66548494e-02f, 1.05586171e-01f, 1.95494220e-01f, 1.31129012e-01f,
  1.16144434e-01f, -5.70517033e-02f, 8.06405470e-02f, -1.44496679e-01f, 2.60303970e-02f, 6.58189654e-02f, -1.36397900e-02f, -4.70882915e-02f, -1.16759017e-02f, -4.01900150e-02f,
  1.23624364e-02f, -4.96277884e-02f, -5.09408899e-02f, 4.79382575e-02f, -8.44699070e-02f, 1.02576748e-01f, 1.17165735e-02f, -2.91033927e-02f, -7.42218867e-02f, 2.44765989e-02f,
  -1.07348703e-01f, 1.61634192e-01f, 1.47671938e-01f, -1.32497158e-02f, -2.96014231e-02f, -8.49949345e-02f, 9.12590697e-02f, -1.53447483e-02f, -8.13724399e-02f, 6.62564188e-02f,
  -1.02710001e-01f, 1.80622749e-02f, -4.42112647e-02f, 1.08763538e-02f, -5.22655956e-02f, -2.65366565e-02f, 5.28555848e-02f, -7.51041248e-02f, 7.86232576e-02f, -1.11004906e-02f,
  1.72358528e-02f, -4.83376160e-02f, 4.88501824e-02f, -2.26317979e-02f, -9.16689113e-02f, -1.50854401e-02f, 4.29253392e-02f, 2.20659636e-02f, -2.57643145e-02f, 5.24677075e-02f,
  9.34430733e-02f, -1.86944291e-01f, 5.66793457e-02f, -1.40803857e-02f, 1.15648091e-01f, 5.95435239e-02f, 1.23402745e-01f, -7.21767619e-02f, 4.43099327e-02f, -4.73453216e-02f,
  2.03746893e-02f, -7.89366011e-03f, -5.85721321e-02f, -4.49480563e-02f, -1.66228384e-01f, -2.54203342e-02f, -3.22244726e-02f, -2.40621381e-02f, 1.00210212e-01f, 5.78817576e-02f,
  1.09534197e-01f, -2.89405771e-02f, -7.38221779e-02f, -3.04172225e-02f, 6.96510598e-02f, 1.58387884e-01f, 2.06724759e-02f, -1.09035239e-01f, -1.06834974e-02f, -8.42030123e-02f,
  3.22111957e-02f, 5.24962135e-02f, 3.20802219e-02f, -6.92996532e-02f, 1.24543905e-01f, -4.09936681e-02f, -1.32738307e-01f, 1.25936002e-01f, 2.80545317e-02f, 6.05710633e-02f,
  6.88017085e-02f, 4.93209474e-02f, 2.90912557e-02f, 1.37154888e-02f, -9.01516341e-03f, -6.86813518e-02f, -3.67540978e-02f, -2.75856014e-02f, 2.32541859e-02f, 1.03160879e-02f,
  5.95162474e-02f, -1.05491862e-01f, 7.37927780e-02f, -5.86285107e-02f, 9.16876495e-02f, 2.84493640e-02f, -7.54072592e-02f, 9.92416069e-02f, -7.29061067e-02f, -2.47210637e-02f,
  -2.37594694e-02f, 9.42681432e-02f, 2.08995283e-01f, 2.85693854e-02f, 8.98969546e-02f, 1.30300537e-01f, -6.12436645e-02f, -1.06095541e-02f, -4.67107520e-02f, 3.54106799e-02f,
  -1.56931095e-02f, -2.19305009e-02f, -1.20509304e-01f, 2.93549001e-02f, 1.41757011e-01f, 1.17916008e-02f, -1.28375515e-02f, 3.21531706e-02f, 5.40553667e-02f, 5.76393232e-02f,
  1.21531747e-02f, 1.16189547e-01f, -5.53463437e-02f, 6.87810685e-03f, 7.22543150e-02f, 4.81717400e-02f, -4.54981402e-02f, 8.63964707e-02f, -1.20255195e-01f, 1.33888423e-02f,
  1.08309746e-01f, -5.07464930e-02f, 2.98403408e-02f, 4.05299328e-02f, 7.02184886e-02f, 3.11555248e-02f, 6.71069175e-02f, 1.57559346e-02f, 8.40408728e-03f, -4.81522977e-02f,
  6.48086071e-02f, 8.29292834e-02f, -2.68843696e-02f, -1.00300321e-03f, 6.47121221e-02f, 1.59000561e-01f, 1.27378985e-01f, -3.85177732e-02f, -8.03817809e-02f, -8.00798386e-02f,
  1.01956293e-01f, 2.99971718e-02f, -3.74074765e-02f, -5.35006113e-02f, -3.13453339e-02f, 1.36254385e-01f, -1.22760445e-01f, -2.74597593e-02f, -1.37618780e-01f, -1.21873915e-01f,
  5.23103178e-02f, -4.13391441e-02f, -9.75436494e-02f, 8.79822124e-04f, 1.76099595e-02f, -9.43185017e-02f, 1.32203393e-03f, -1.20305598e-01f, 5.13911098e-02f, -1.11139111e-01f,
  1.77525878e-02f, -1.04653284e-01f, -5.48710525e-02f, -2.43861992e-02f, 1.86794046e-02f, 1.12931073e-01f, -1.44472361e-01f, 4.54472005e-02f, -3.43236066e-02f, -1.91192701e-02f,
  3.45944129e-02f, -3.01611498e-02f, 1.00953311e-01f, -3.06638237e-02f, -1.09490409e-01f, -2.20764503e-02f, 3.33454204e-03f, 4.88217063e-02f, -1.16170086e-01f, -1.07791975e-01f,
  -1.12650447e-01f, -4.56906222e-02f, 9.11891460e-02f, 8.35743472e-02f, -2.30920396e-05f, 3.63099575e-02f, -5.08915670e-02f, -4.65680026e-02f, -5.49126826e-02f, 7.44602084e-02f,
  -7.38590136e-02f, 6.65411651e-02f, -8.57185721e-02f, 1.83387250e-01f, 4.47236896e-02f, 1.17496714e-01f, 1.16199397e-01f, -7.47049460e-03f, -3.89994085e-02f, 9.00257602e-02f,
  1.56952813e-01f, -1.05494030e-01f, -5.50401211e-02f, -1.07381396e-01f, -2.43625715e-02f, -3.58403027e-02f, 7.55764097e-02f, -1.66260734e-01f, 1.00155803e-03f, 3.93039081e-03f,
  -4.53094915e-02f, -8.80262721e-03f, 5.83731383e-02f, -7.35323504e-02f, 4.11529653e-02f, 1.23976305e-01f, -1.09770102e-03f, 2.63195653e-02f, -2.58314330e-02f, -4.45434451e-02f,
  1.72348738e-01f, 1.18706204e-01f, -5.26526757e-02f, 4.88211401e-02f, 9.01449025e-02f, 1.24201767e-01f, 1.22767784e-01f, 1.01770386e-01f, 4.10496518e-02f, 7.99195026e-04f,
  5.46589643e-02f, 4.93160337e-02f, 3.47314849e-02f, 9.94646400e-02f, 1.53529942e-01f, 1.10528618e-01f, -1.21251689e-02f, 1.08284600e-01f, -4.66154702e-02f, 1.52514473e-01f,
  -1.38882231e-02f, 1.27486333e-01f, 1.72942415e-01f, 8.68654028e-02f, 9.40932985e-03f, 1.32047385e-01f, 1.27417957e-02f, -5.43740056e-02f, 1.76468253e-01f, -3.99374999e-02f,
  3.84359397e-02f, 5.22268079e-02f, 1.27572156e-02f, 1.05108254e-01f, 1.19934022e-01f, -4.51786704e-02f, 1.44519702e-01f, -4.87954356e-02f, -6.32924959e-04f, -1.14166215e-02f,
  9.21825971e-03f, 5.76895289e-02f, 2.00667349e-03f, 1.78533807e-01f, 1.54835537e-01f, 2.11347137e-02f, 2.80827675e-02f, 6.94795251e-02f, 9.86180231e-02f, -1.80417150e-02f,
  -1.02333814e-01f, 9.68459249e-02f, 6.50235116e-02f, 4.02359329e-02f, -2.09634267e-02f, 1.73273180e-02f, 3.14008966e-02f, 1.02159046e-01f, 4.73249741e-02f, 1.28008485e-01f,
  -3.22206356e-02f, 4.83788364e-02f, -4.94372956e-02f, -4.69568036e-02f, 5.82012571e-02f, 1.33130506e-01f, 3.70035501e-04f, 5.35460263e-02f, 9.56488699e-02f, 4.94232588e-02f,
  1.55497819e-01f, 5.62087633e-02f, 1.19249985e-01f, -1.34627521e-01f, 5.36429882e-02f, -8.41930043e-03f, 5.11147566e-02f, 1.34751387e-02f, -2.92774662e-03f, -6.82183774e-03f,
  -7.71258771e-02f, -1.17182471e-01f, 1.27429627e-02f, -1.96840074e-02f, -3.55046839e-02f, -4.97511402e-02f, -7.76835158e-02f, -8.21103901e-02f, 1.00501731e-01f, -6.35121912e-02f,
  1.45343125e-01f, 1.42302113e-02f, -1.05181538e-01f, 1.26865342e-01f, 1.20083103e-02f, 4.89762016e-02f, 7.85001963e-02f, -1.35340288e-01f, -1.56024531e-01f, 1.26073733e-01f,
  -4.65246523e-03f, 2.98352763e-02f, -4.58901934e-02f, 9.46862325e-02f, -9.56324562e-02f, 1.39379576e-02f, 3.93802039e-02f, -1.68520100e-02f, 8.01580474e-02f, 8.12418014e-02f,
  1.38774822e-02f, 2.49791872e-02f, 7.43416101e-02f, 5.69125973e-02f, 4.83497344e-02f, -3.03529240e-02f, -4.95588146e-02f, 5.86858429e-02f, 3.07388995e-02f, 6.78396076e-02f,
  -2.55741775e-02f, -1.44659474e-01f, -4.12887633e-02f, -9.15070251e-02f, -5.33258030e-03f, -1.80324167e-02f, 5.91263212e-02f, -1.49456978e-01f, -6.82022721e-02f, -1.55167729e-02f,
  1.91225372e-02f, -7.36261085e-02f, -1.16599768e-01f, -2.34104525e-02f, 6.82199448e-02f, -4.38277125e-02f, 7.01142475e-02f, -6.72695190e-02f, 7.31139407e-02f, 6.30300939e-02f,
  -1.01209961e-01f, 7.13152513e-02f, 6.71776384e-02f, -7.60314008e-03f, 1.01129115e-01f, 5.20619703e-03f, 9.39924046e-02f, -7.94291869e-02f, -3.06725018e-02f, 6.75717443e-02f,
  -5.83230257e-02f, -1.25113815e-01f, -1.26766175e-01f, 1.21075250e-01f, 1.57962665e-01f, -2.64139697e-02f, -8.94978829e-03f, 1.24839492e-01f, -6.84639737e-02f, -1.52318269e-01f,
  5.17005064e-02f, -2.43261810e-02f, 2.55138502e-02f, 8.12980067e-03f, 5.12548834e-02f, 1.57753885e-01f, 8.95562917e-02f, 4.22840565e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -7.45202601e-03f, -4.27435385e-03f, 3.32777714e-03f, -5.11788987e-02f, 6.07956573e-02f, 5.09499647e-02f, -1.16562031e-01f, 8.90898705e-02f, 3.26410756e-02f, -7.64553472e-02f,
  -8.93709287e-02f, 1.09155856e-01f, 8.72619450e-02f, 9.41559598e-02f, 3.13916989e-02f, -1.74581502e-02f, -9.78793427e-02f, -6.11761995e-02f, 1.07221186e-01f, -5.16005196e-02f,
  3.97208221e-02f, 8.45904555e-03f, 1.70752764e-01f, 7.56642371e-02f, -1.35142356e-01f, -4.43885736e-02f, 1.81167331e-02f, -6.02965169e-02f, -1.38935626e-01f, 1.01405822e-01f,
  1.56740732e-02f, 1.36171743e-01f, -1.13347182e-02f, 3.83790359e-02f, 7.44922236e-02f, -2.92801596e-02f, -2.16099501e-01f, -7.92627037e-03f, 1.44475877e-01f, 2.34196000e-02f,
  5.00563905e-02f, -8.47991258e-02f, -3.71876508e-02f, -2.47245934e-02f, 1.98387593e-01f, 4.74929139e-02f, -1.48470104e-01f, -1.81004091e-03f, -8.01380053e-02f, -7.52168521e-03f,
  6.57006353e-02f, 2.87376391e-03f, -1.45617634e-01f, 1.58491328e-01f, 1.68723892e-03f, -6.62766024e-02f, 9.80910063e-02f, 9.26565230e-02f, -1.62169233e-01f, -1.12954989e-01f,
  -5.02647385e-02f, 1.98615715e-01f, 2.31666207e-01f, 8.41507316e-02f, 1.61176324e-02f, -7.63119981e-02f, 1.98007021e-02f, -2.23306026e-02f, -1.33430853e-01f, 3.19004096e-02f,
  -5.56840450e-02f, -1.98478648e-03f, 1.99979749e-02f, -2.60709431e-02f, -2.64836964e-03f, 4.10548560e-02f, -8.70678276e-02f, 1.29348284e-03f, 3.44400071e-02f, 9.59020406e-02f,
  1.87774301e-02f, 9.03111622e-02f, -1.53102070e-01f, 1.14561565e-01f, -1.39485314e-01f, 4.39111926e-02f, -8.95488914e-03f, 1.18370883e-01f, 2.43320063e-01f, 2.62282994e-02f,
  -1.97448600e-02f, 1.50987223e-01f, 9.75838210e-03f, -1.95351437e-01f, 2.24994905e-02f, -1.09211415e-01f, 9.72371101e-02f, 2.20245615e-01f, -2.69676149e-01f, 6.23366274e-02f,
  1.74604729e-01f, -3.84022593e-02f, -1.21708199e-01f, -1.15915038e-01f, 1.11966945e-01f, 1.36965543e-01f, 1.61658064e-01f, 4.64777416e-03f, -1.15595311e-01f, -1.49962366e-01f,
  1.27498090e-01f, -5.32430829e-03f, 1.01041086e-01f, -2.69366950e-01f, -1.78616762e-01f, -2.50769556e-02f, 1.86032858e-02f, -1.83583423e-01f, 6.07796907e-02f, 7.43709728e-02f,
  -1.13337755e-01f, -7.02454522e-02f, 1.81683868e-01f, -6.28813878e-02f, 1.55637518e-01f, -7.06373975e-02f, -1.33535966e-01f, 1.19094416e-01f, 7.20906854e-02f, -2.05886271e-02f,
  -1.02415845e-01f, -9.35544819e-03f, 9.95754227e-02f, 3.42908166e-02f, -1.03295684e-01f, -1.02202624e-01f, 1.03528900e-02f, -9.38265771e-02f, -3.22769322e-02f, -4.06623110e-02f,
  -2.79981066e-02f, 8.76036510e-02f, 1.47375939e-02f, 1.10604398e-01f, -1.24756895e-01f, -2.87313052e-02f, 5.76948412e-02f, -9.15337205e-02f, 6.36499701e-03f, 6.03259774e-03f,
  1.96667314e-02f, 7.38025119e-04f, -8.73168781e-02f, 4.69047688e-02f, -8.60252697e-03f, 9.78825167e-02f, 5.72185181e-02f, -1.41931679e-02f, 3.58695649e-02f, -1.32394489e-02f,
  1.38199463e-01f, 2.46146899e-02f, 1.87206253e-01f, 5.00380360e-02f, -1.47355109e-01f, 6.01749159e-02f, 2.16888860e-01f, 1.51864037e-01f, 1.19687542e-01f, -1.12508602e-01f,
  1.82489157e-01f, -1.91417605e-01f, 2.12294966e-01f, 3.80213708e-02f, -1.68191969e-01f, -1.00600377e-01f, 1.52642339e-01f, 4.45552636e-03f, 1.59950212e-01f, -8.51370543e-02f,
  -6.85429871e-02f, 2.99248934e-01f, -1.76025014e-02f, 6.63123950e-02f, 1.18995778e-01f, 2.84842104e-02f, -1.21883072e-01f, 2.45170951e-01f, -1.44224182e-01f, 1.88371748e-01f,
  8.37019607e-02f, 8.59681983e-03f, 5.31998239e-02f, -3.12196333e-02f, 1.43950030e-01f, -3.36240456e-02f, -1.32586196e-01f, 1.00633889e-01f, 3.48767117e-02f, 6.11579716e-02f,
  -6.07597157e-02f, 6.05906397e-02f, 8.67093578e-02f, 1.61068305e-01f, 1.12591930e-01f, -5.86487204e-02f, 1.08358547e-01f, -5.98151097e-03f, 9.68907326e-02f, 1.10556468e-01f,
  -6.06276095e-02f, 1.35297716e-01f, 4.81701344e-02f, 6.50819167e-02f, -1.26055507e-02f, 1.23039208e-01f, 7.40645230e-02f, 1.54415863e-02f, 1.80913173e-02f, 1.40575483e-01f,
  8.82279351e-02f, -5.84201328e-02f, 1.21411316e-01f, 2.02292368e-01f, 1.67680472e-01f, 2.15133894e-02f, 7.35162124e-02f, -4.42235433e-02f, 7.54977092e-02f, 1.00445248e-01f,
  -4.11626138e-02f, -4.60568666e-02f, -6.74630329e-02f, 1.40024498e-01f, 5.32478131e-02f, 2.18464807e-01f, -6.39526993e-02f, -1.44556090e-01f, 2.47727469e-01f, 1.87819868e-01f,
  9.85996649e-02f, 2.82543041e-02f, -1.80419594e-01f, 1.55421898e-01f, -8.40806738e-02f, -1.35513023e-01f, 5.50300553e-02f, 6.31361604e-02f, 1.03090122e-01f, 5.37590422e-02f,
  1.05170317e-01f, 1.08799927e-01f, 1.17973186e-01f, -2.60829479e-01f, -3.36702960e-03f, 1.51616707e-01f, -4.34662662e-02f, 9.84496176e-02f, 9.67404321e-02f, 7.67952129e-02f,
  2.94583403e-02f, 3.98177042e-04f, -4.13920879e-02f, -2.31048465e-02f, -3.97886932e-02f, -4.29749768e-03f, 3.63394581e-02f, -1.99931096e-02f, 7.56804645e-02f, 6.05712160e-02f,
  3.70198078e-02f, -6.87943250e-02f, 2.03072764e-02f, -8.80983174e-02f, -6.64224178e-02f, 7.21332878e-02f, -1.39516369e-01f, -1.20212033e-01f, 6.18550889e-02f, -6.47737235e-02f,
  9.37090069e-02f, -4.35064174e-02f, 8.46076980e-02f, -8.07529390e-02f, -4.86417152e-02f, 2.27452710e-01f, 3.02345425e-01f, -2.23565958e-02f, 1.07279122e-01f, 5.60122393e-02f,
  4.18932587e-02f, -2.81755254e-02f, -1.49974758e-02f, 1.56487480e-01f, 7.54888281e-02f, -5.01586609e-02f, -7.24333525e-02f, -4.78042066e-02f, -2.05640301e-01f, 1.75797954e-01f,
  1.34880230e-01f, 1.48861483e-01f, 1.17001005e-01f, 2.04768479e-02f, 4.58151586e-02f, 2.65623838e-01f, 9.17785317e-02f, 3.39325130e-01f, -5.88811599e-02f, -1.17837720e-01f,
  -1.52176078e-02f, -8.59839562e-03f, 1.39891863e-01f, 2.12267622e-01f, 3.47488523e-02f, 1.03445210e-01f, 4.60395217e-02f, 8.40988383e-03f, -9.39427242e-02f, 2.47022226e-01f,
  -4.84856404e-02f, 4.42246906e-02f, -7.24278465e-02f, -1.74210176e-01f, -2.47571524e-02f, -1.31968915e-01f, 4.59374711e-02f, -2.08048932e-02f, -8.72731507e-02f, -3.34021039e-02f,
  -5.19183353e-02f, -8.32435861e-03f, 1.03465565e-01f, -2.26062015e-02f, 5.27108312e-02f, -3.65417339e-02f, 1.27023190e-01f, 7.90474936e-02f, -1.71585437e-02f, -6.40764460e-02f,
  9.12534371e-02f, 3.83554138e-02f, -8.93263072e-02f, 1.07125327e-01f, -8.16214085e-02f, 1.60146430e-01f, 9.24953595e-02f, -1.53375864e-02f, 1.95439026e-01f, 1.51340812e-01f,
  -1.10044487e-01f, 1.19209848e-01f, 8.90352279e-02f, -1.48738563e-01f, 1.67518646e-01f, -9.94602367e-02f, -1.39829442e-01f, 1.01581663e-01f, 4.37574834e-02f, -5.19532245e-03f,
  -2.95973599e-01f, -1.48559332e-01f, 5.68623804e-02f, 1.24488026e-01f, -1.15719482e-01f, -1.13898851e-01f, 1.01193652e-01f, 8.84430856e-02f, 4.02753167e-02f, 2.52110571e-01f,
  1.06983908e-01f, 1.01199321e-01f, 5.05314246e-02f, 2.25878246e-02f, -4.03511189e-02f, 1.20226853e-01f, 1.28827885e-01f, 9.74494442e-02f, -1.12158924e-01f, 5.59706390e-02f,
  3.44428383e-02f, -9.27262008e-02f, -2.86097437e-01f, -1.58118948e-01f, -7.42588565e-02f, 2.60318220e-02f, -1.79327667e-01f, -2.41467375e-02f, 1.28320213e-02f, 1.41217292e-03f,
  -1.60104066e-01f, 1.40382601e-02f, 1.29311662e-02f, -6.46598637e-02f, 6.42532632e-02f, 1.04450323e-02f, 6.31913766e-02f, -1.00310154e-01f, 1.44359842e-01f, 4.09213938e-02f,
  5.47610037e-03f, -5.47020584e-02f, 5.86242266e-02f, 2.05988467e-01f, 2.37920303e-02f, 3.77760008e-02f, 1.75558656e-01f, 1.18302777e-01f, 3.50814126e-02f, -4.48385142e-02f,
  8.23637694e-02f, -3.41355707e-03f, -1.06992304e-01f, 1.82136610e-01f, 6.50025606e-02f, 1.88717842e-01f, 9.32227448e-02f, 7.59133026e-02f, 1.62457809e-01f, -1.86360210e-01f,
  -1.45250335e-01f, 2.02411562e-01f, -7.06152767e-02f, -7.75903370e-03f, -9.41784978e-02f, -4.45304215e-02f, 2.58160103e-02f, 3.59059349e-02f, 2.08064348e-01f, 1.00906275e-01f,
  1.42448545e-01f, 1.60713911e-01f, -1.67728007e-01f, 1.04315847e-01f, 1.52604967e-01f, 2.44423524e-01f, 8.06573257e-02f, 4.18508202e-02f, 4.06365246e-02f, -4.04397920e-02f,
  8.99433792e-02f, 2.51898300e-02f, -3.99255529e-02f, -1.01855531e-01f, 9.61992294e-02f, 4.80130278e-02f, 1.21499076e-01f, 2.15766147e-01f, -9.56759788e-03f, -2.71171834e-02f,
  -6.98768767e-03f, -4.31519896e-02f, -9.42908749e-02f, 6.67003728e-03f, 4.92395461e-02f, 6.93610609e-02f, 1.39161780e-01f, 3.78389098e-02f, 1.12677760e-01f, 1.74907252e-01f,
  -1.92331132e-02f, 7.80855417e-02f, -2.84585860e-02f, 1.31844610e-01f, -1.07625397e-02f, -7.08012208e-02f, -2.50398442e-02f, -1.07174395e-02f, -1.06108151e-01f, 8.82255360e-02f,
  -1.10902870e-02f, 5.01167178e-02f, 4.09076624e-02f, -2.31470615e-02f, 1.35379851e-01f, 1.76671863e-01f, 1.11815296e-01f, -9.59513485e-02f, 1.84545845e-01f, 5.30449534e-03f,
  2.15990633e-01f, 1.00079939e-01f, -1.45758539e-01f, 1.84279367e-01f, 1.64420053e-01f, -1.14465348e-01f, -9.94723812e-02f, -6.72074482e-02f, 6.80245161e-02f, 7.38543868e-02f,
  1.86714739e-01f, -2.00799763e-01f, -8.01807493e-02f, -1.16305575e-01f, 6.52130619e-02f, 4.61462177e-02f, 1.89284161e-02f, -2.01687023e-01f, 6.94117695e-02f, 1.34957492e-01f,
  -8.65159482e-02f, 9.94045287e-03f, 3.58092524e-02f, -1.79123044e-01f, 1.29742533e-01f, -1.86232150e-01f, 2.59914815e-01f, 1.28418609e-01f, 1.54466912e-01f, 1.85072288e-01f,
  7.74866901e-03f, 2.39467874e-01f, -3.73410061e-02f, -1.10798448e-01f, -2.17202589e-01f, -1.18490987e-01f, -8.83362722e-03f, -9.36860144e-02f, -1.95432529e-01f, -1.45398334e-01f,
  5.72500657e-03f, -1.24597758e-01f, 2.17393655e-02f, -1.91287547e-01f, 1.17955856e-01f, 1.20617228e-03f, 2.01600753e-02f, -4.28051781e-03f, -1.82929281e-02f, -5.36237918e-02f,
  -2.99757887e-02f, -4.78730723e-02f, 4.05474193e-02f, 8.68205279e-02f, 1.88154504e-01f, -6.94359615e-02f, -3.50210577e-01f, -1.81308538e-02f, 1.19912207e-01f, 2.20796969e-02f,
  2.16307100e-02f, 1.34964794e-01f, -1.40570318e-02f, 6.75258785e-02f, 4.02472354e-03f, -8.21270198e-02f, 2.57144660e-01f, -2.05872972e-02f, -1.34562284e-01f, 1.82167172e-01f,
  1.23607583e-01f, 8.17837641e-02f, -6.14347011e-02f, -1.20162189e-01f, 1.31222382e-01f, -1.32447258e-01f, 1.75030529e-01f, 2.53834538e-02f, -4.27255630e-02f, -7.89256543e-02f,
  1.66365176e-01f, 6.02284558e-02f, 3.29095423e-01f, -7.89748039e-03f, -2.81655695e-02f, 1.92658409e-01f, 2.13043205e-02f, -6.60698116e-02f, 1.24005415e-01f, 6.81865364e-02f,
  2.03461070e-02f, 9.75364298e-02f, 1.47856548e-01f, 7.36944228e-02f, -7.50391111e-02f, 1.15760557e-01f, 8.94010160e-03f, 6.14705943e-02f, 7.66672567e-02f, -7.80207803e-04f,
  2.19273921e-02f, -1.33677654e-03f, 1.87613107e-02f, 1.33554637e-01f, -2.35942397e-02f, 9.85630676e-02f, -6.38692752e-02f, 1.52135938e-01f, 8.15009698e-02f, 3.63614457e-03f,
  1.29841253e-01f, 6.22702315e-02f, 2.55155079e-02f, 1.21760376e-01f, 6.23704074e-03f, 1.07155450e-01f, 8.64051059e-02f, -3.00838742e-02f, -6.80689812e-02f, 1.12111039e-01f,
  1.78273708e-01f, 1.58819526e-01f, 1.26981050e-01f, 1.37863770e-01f, 1.29037902e-01f, 4.01120186e-02f, 1.14066778e-02f, 7.54117295e-02f, 1.79583371e-01f, 9.02817026e-02f,
  -4.78452118e-03f, 2.31534634e-02f, -3.92201804e-02f, -3.20691639e-03f, 2.68380754e-02f, -5.00081368e-02f, 1.20623246e-01f, -7.15277642e-02f, -5.55121861e-02f, 3.40273380e-02f,
  -5.79278097e-02f, -1.14737630e-01f, 9.75111276e-02f, -7.63732893e-03f, 3.78634185e-02f, 9.60175991e-02f, -1.69815034e-01f, -1.04364999e-01f, -1.80872321e-01f, -2.48214845e-02f,
  -9.40522403e-02f, 2.65072703e-01f, 9.34653133e-02f, 5.49555058e-03f, -3.02514076e-01f, 3.44782546e-02f, -1.91837832e-01f, -9.91939977e-02f, 1.52577087e-02f, 2.12825164e-02f,
  -4.51660380e-02f, 1.74449176e-01f, 8.89773071e-02f, 1.43984733e-02f, 2.57442729e-03f, -4.24649529e-02f, 1.24859773e-01f, -4.11414281e-02f, -1.33434609e-01f, 7.03556463e-02f,
  1.31496899e-02f, -1.96902990e-01f, -1.44174710e-01f, 1.03016026e-01f, -5.26829623e-02f, 2.88371667e-02f, 9.64977965e-02f, -9.25987810e-02f, -8.98204092e-03f, -1.20571874e-01f,
  2.88738936e-01f, -1.62136704e-01f, -2.64096498e-01f, -1.19407900e-01f, 5.17682694e-02f, 1.23702966e-01f, -1.37074202e-01f, 1.55792579e-01f, 9.02587771e-02f, -8.47790986e-02f,
  -2.38849327e-01f, -6.53705299e-02f, 1.46620441e-02f, 1.63480863e-01f, 1.93917945e-01f, 1.14969164e-01f, 1.17262401e-01f, 9.10954326e-02f, 1.09116016e-02f, 1.38788149e-01f,
  3.49459350e-02f, 1.15817219e-01f, 2.05711484e-01f, 2.03718752e-01f, -1.07440494e-01f, 2.24870071e-01f, 1.02631204e-01f, -8.33306834e-02f, 7.71986395e-02f, 9.22708437e-02f,
  -1.79790348e-01f, -2.42487997e-01f, 2.97130823e-01f, 1.88280627e-01f, -7.28893280e-02f, 2.44158730e-01f, -2.27897406e-01f, 3.80841345e-02f, -7.09405243e-02f, 2.26744413e-01f,
  -1.03557609e-01f, -3.34427059e-02f, -1.27896145e-01f, -3.92745972e-01f, -2.97439173e-02f, 4.91925627e-02f, -3.10548525e-02f, -4.58585797e-04f, -3.95900570e-02f, -1.22098178e-01f,
  -3.82903516e-02f, -6.64092675e-02f, -6.34789914e-02f, -2.87496280e-02f, -2.78073419e-02f, -1.26670226e-01f, 2.40685716e-02f, -6.68337643e-02f, -5.07013053e-02f, -1.12878814e-01f,
  8.85089934e-02f, 1.85402110e-02f, 7.30332285e-02f, -8.59469175e-02f, 1.26567125e-01f, -2.58833114e-02f, 2.56653875e-02f, 5.02351597e-02f, 3.52160782e-02f, 7.03028496e-03f,
  3.61324959e-02f, 3.64451334e-02f, -6.96195755e-03f, 2.20176056e-01f, -1.49637043e-01f, 5.91232218e-02f, -2.30517965e-02f, 1.14720888e-01f, 1.21184371e-01f, -4.64921258e-02f,
  -1.38784889e-02f, 2.26034686e-01f, 2.61603724e-02f, 7.08099231e-02f, -1.61745548e-01f, -1.54519882e-02f, 1.84222031e-02f, 1.81962281e-01f, -5.54161407e-02f, 1.63092583e-01f,
  1.05920769e-01f, 7.86439925e-02f, -4.26497590e-03f, 1.52166456e-01f, 2.42126174e-02f, -3.88766229e-02f, 5.28419577e-02f, -1.46256492e-01f, -1.25855580e-02f, 4.51696888e-02f,
  -6.18539490e-02f, 2.48011485e-01f, 1.06476201e-03f, -3.63422185e-02f, 5.97502775e-02f, -1.00839719e-01f, -1.58624232e-01f, -1.31529033e-01f, 7.99140260e-02f, -1.34099750e-02f,
  1.00264482e-01f, 1.87459290e-02f, 1.01816699e-01f, 6.43379465e-02f, 9.71131697e-02f, -2.51362547e-02f, 1.40458515e-05f, -2.83355918e-02f, 1.16467625e-01f, -2.10627522e-02f,
  1.14990873e-02f, 8.73036832e-02f, 2.07896568e-02f, 9.38195735e-03f, 4.97087464e-02f, -5.14029264e-02f, 8.21748301e-02f, -1.36615233e-02f, 1.72319394e-02f, -1.45121023e-01f,
  5.69981104e-03f, 2.34440193e-02f, -1.07365139e-01f, -9.04679969e-02f, -1.13645419e-01f, -5.59883518e-03f, -2.13893637e-01f, 1.63887113e-01f, 5.30035384e-02f, -2.61932984e-03f,
  -1.77552387e-01f, 1.33766145e-01f, 1.57251999e-01f, 6.88210428e-02f, -6.74214959e-02f, 2.09913209e-01f, 7.53481835e-02f, 2.55821079e-01f, 1.39186054e-01f, -9.24144238e-02f,
  6.91472664e-02f, 1.68764129e-01f, 1.88893288e-01f, 3.07494402e-01f, -1.97506920e-01f, 1.14272833e-01f, -2.17678577e-01f, 1.53662011e-01f, 3.18660177e-02f, -9.25521925e-02f,
  4.33157086e-02f, 1.19605757e-01f, -1.38243213e-02f, -1.74658477e-01f, -5.40355220e-02f, 2.07521960e-01f, -2.95647234e-02f, 1.00578610e-02f, -1.16086707e-01f, 2.23790869e-01f,
  2.58662015e-01f, -4.46649678e-02f, -6.92916885e-02f, 8.66296440e-02f, -9.46563408e-02f, 6.68220446e-02f, 4.11701314e-02f, 2.30308548e-02f, 1.13580488e-01f, -5.27509786e-02f,
  -8.39274600e-02f, -1.45908162e-01f, -3.15628722e-02f, -6.48239208e-03f, -5.47838211e-02f, 1.85494587e-01f, 5.89920282e-02f, -8.68431926e-02f, -1.09955333e-01f, -8.02474990e-02f,
  2.29511037e-02f, -1.49249271e-01f, 3.15748274e-01f, -7.78216422e-02f, -1.10505879e-01f, -9.16814283e-02f, 9.56052467e-02f, 1.17318384e-01f, 1.09847456e-01f, -5.45490123e-02f,
  1.32612824e-01f, 5.89228459e-02f, 1.09617159e-01f, -1.29609957e-01f, -3.05035189e-02f, 8.62655342e-02f, 1.01665318e-01f, -5.93356928e-03f, -6.84385560e-03f, 2.90422514e-02f,
  3.20404857e-01f, 1.16575368e-01f, -1.84712738e-01f, -2.48909131e-01f, -1.13118887e-01f, 1.91421539e-01f, -6.86833933e-02f, 6.56203425e-04f, -1.44634712e-02f, -1.75114214e-01f,
  -1.16639351e-02f, 2.90142864e-01f, 1.71648443e-01f, -7.32359737e-02f, 7.90583622e-03f, 1.32058561e-01f, -1.39812138e-02f, 2.45041803e-01f, -1.29707120e-02f, 1.56473190e-01f,
  -2.31476322e-01f, 5.88528998e-02f, -2.26410612e-01f, -2.49845553e-02f, -1.86940670e-01f, -1.47822455e-01f, 9.77509934e-03f, -1.56362948e-04f, 1.38222277e-01f, 3.12852934e-02f,
  9.09111798e-02f, 1.10030256e-01f, 3.87316570e-02f, 1.29503220e-01f, -4.44309674e-02f, 6.03567213e-02f, -1.25859946e-01f, 1.76723465e-01f, 5.81021607e-02f, 1.27812132e-01f,
  6.67930618e-02f, -1.47149423e-02f, -5.73318228e-02f, 1.03783168e-01f, 6.61062151e-02f, 5.59219578e-03f, 1.50670066e-01f, -7.75174424e-02f, -5.41537441e-02f, 5.29971719e-02f,
  3.29932459e-02f, 2.14565381e-01f, 2.16212034e-01f, 9.75075215e-02f, -8.04985501e-03f, 1.04016416e-01f, 1.22484803e-01f, 5.20400777e-02f, 1.76963374e-01f, 5.15159592e-02f,
  -9.69344110e-04f, 6.96477443e-02f, -1.53551549e-01f, 7.76557950e-03f, 2.57341564e-01f, -1.89412907e-02f, 1.43238157e-02f, -1.54716492e-01f, 1.64135303e-02f, 6.76052347e-02f,
  2.66553890e-02f, -1.05280103e-02f, -7.14129210e-02f, 1.33350389e-02f, 7.35417530e-02f, 9.46313888e-02f, 1.75769553e-02f, 2.53686961e-02f, -1.73373386e-01f, -2.15672958e-03f,
  -7.80725479e-02f, 1.92751110e-01f, 5.88463694e-02f, 9.93962139e-02f, -3.20111394e-01f, 1.95541084e-01f, -2.12946177e-01f, -8.78977962e-03f, 3.31497118e-02f, 8.93622041e-02f,
  1.30905241e-01f, 1.06696740e-01f, 1.61366746e-01f, 6.04258589e-02f, -1.06375646e-02f, 7.72846490e-03f, 1.66323222e-02f, 7.20037445e-02f, -8.21557045e-02f, 1.00918040e-01f,
  1.08599521e-01f, 3.68111879e-02f, 4.09625806e-02f, -4.77414168e-02f, -3.59062164e-04f, -2.68995166e-02f, 8.40737671e-02f, -2.91573629e-03f, 9.18811280e-03f, 1.07501037e-01f,
  -1.12685755e-01f, -1.19664691e-01f, -1.38728708e-01f, 1.11517243e-01f, 3.41672808e-01f, 9.50963944e-02f, 1.32896483e-01f, 7.66844600e-02f, 1.03904374e-01f, -3.94082591e-02f,
  8.70474204e-02f, -1.23457208e-01f, 1.01226747e-01f, 9.60417017e-02f, -2.37316266e-01f, 1.61770750e-02f, 1.76415607e-01f, 5.66328578e-02f, -1.06349997e-01f, -9.95902494e-02f,
  4.58215177e-03f, 1.48409486e-01f, -1.22513331e-01f, 2.76285112e-01f, 5.19626541e-03f, 9.82971042e-02f, 2.92829663e-01f, 1.57756492e-01f, 2.72977538e-02f, -6.10862346e-03f,
  -2.13870123e-01f, -1.17318600e-03f, 1.03651658e-01f, -8.71816799e-02f, -9.09919199e-03f, 1.74080387e-01f, -8.58474448e-02f, -1.45911565e-02f, 6.46213293e-02f, 1.99140340e-01f,
  -3.42853181e-02f, -3.67833674e-02f, -1.26215085e-01f, 1.33842945e-01f, 3.09048407e-02f, -3.22654694e-02f, 9.13630649e-02f, 7.21567124e-02f, -7.59983361e-02f, 7.57144690e-02f,
  1.16497293e-01f, 1.73894778e-01f, -5.84682040e-02f, 4.50769663e-02f, -7.18726888e-02f, 8.70273188e-02f, 1.47280842e-01f, -1.29138827e-02f, 1.19348407e-01f, -1.23228999e-02f,
  1.42226562e-01f, 8.20853785e-02f, 1.09340981e-01f, -5.18720374e-02f, 1.25986338e-01f, -2.29550060e-02f, 8.11579823e-02f, 1.60678193e-01f, -5.56082539e-02f, 6.95172995e-02f,
  6.27993420e-02f, 1.46650374e-01f, 2.93109994e-02f, 1.95994779e-01f, -7.17221349e-02f, 1.78509146e-01f, -1.19576789e-02f, 4.66571562e-02f, 1.86447322e-01f, -7.59968907e-02f,
  -5.73893115e-02f, 2.17465892e-01f, 1.69178411e-01f, -1.59267373e-02f, 3.17187756e-02f, -9.12606064e-03f, 8.68304968e-02f, 1.90073967e-01f, 6.71370849e-02f, 3.48486491e-02f,
  4.46767434e-02f, 2.09228829e-01f, 7.79037923e-02f, 2.29633555e-01f, -5.67758121e-02f, -1.12212509e-01f, -5.03145270e-02f, -3.38765755e-02f, -2.87116673e-02f, 8.46075490e-02f,
  1.19847186e-01f, 9.72873792e-02f, -3.00256647e-02f, 4.47566472e-02f, 8.49375352e-02f, -1.33740336e-01f, -2.17828378e-02f, -1.12559944e-01f, 4.07297537e-02f, -1.98796508e-03f,
  -8.31464753e-02f, -7.42951597e-05f, 4.59548272e-02f, -4.64870483e-02f, -1.03627078e-01f, -7.85860494e-02f, -5.02033457e-02f, -4.30346802e-02f, -3.14616077e-02f, -1.38302431e-01f,
  -3.17438841e-02f, 6.33816272e-02f, -4.61711660e-02f, 1.49421692e-01f, -8.02982673e-02f, 8.08444843e-02f, -3.19231525e-02f, 7.72500560e-02f, -5.54604530e-02f, -6.65819943e-02f,
  -8.47357586e-02f, 3.63716148e-02f, 1.38994366e-01f, 1.31786853e-01f, 1.05254322e-01f, 1.49863660e-01f, 5.78197613e-02f, -1.43398166e-01f, 1.27688348e-01f, -7.53055140e-02f,
  1.08522594e-01f, 3.53119187e-02f, -1.20345645e-01f, 1.13895625e-01f, 1.92703735e-02f, -1.79911986e-01f, 1.45471379e-01f, -2.62096435e-01f, -6.42784759e-02f, -3.68775241e-03f,
  -9.92380381e-02f, -1.40110925e-01f, 2.57240317e-05f, -1.99406981e-01f, 1.90092549e-02f, -8.38671327e-02f, 2.81117558e-01f, -7.77805746e-02f, 5.42124212e-02f, 6.38388768e-02f,
  -5.01311608e-02f, 1.13257812e-02f, 1.23341149e-02f, 2.27159485e-01f, 8.45017433e-02f, -3.85912322e-02f, -1.59222931e-01f, 9.78045315e-02f, -6.96994960e-02f, 1.99854933e-02f,
  -1.52387336e-01f, 1.67222336e-01f, 8.79404042e-03f, 3.12775299e-02f, 1.44349113e-01f, 8.16289559e-02f, 1.19147627e-02f, 2.15146959e-01f, 2.03485399e-01f, 2.67109632e-01f,
  9.36667994e-02f, 6.38609827e-02f, 1.26098571e-02f, 2.64048785e-01f, 1.05639972e-01f, 5.83300442e-02f, 2.73918688e-01f, -4.78837639e-02f, 9.27152261e-02f, 4.11737375e-02f,
  7.15629682e-02f, 7.31066614e-02f, -9.38311219e-02f, -1.56997163e-02f, 9.81085971e-02f, 1.14854900e-02f, 1.07263513e-01f, 1.12780966e-01f, 1.02706559e-01f, -2.00203564e-02f,
  -1.52797386e-01f, 1.81447595e-01f, 2.75798589e-01f, 6.48476258e-02f, -8.08362104e-03f, 8.80573597e-03f, -7.98288509e-02f, -9.79453418e-03f, -4.98341434e-02f, 1.51179120e-01f,
  1.20739065e-01f, -2.16226690e-02f, 8.94652680e-02f, -3.99926715e-02f, -1.92411184e-01f, 1.31787747e-01f, 7.58136958e-02f, 4.38759066e-02f, 6.12045871e-03f, 4.80270274e-02f,
  -1.54014230e-01f, 2.10991323e-01f, 1.97129063e-02f, 1.68687716e-01f, -2.95941770e-01f, -5.35663776e-02f, 3.71899121e-02f, 1.04535581e-03f, 9.98481140e-02f, 3.31452899e-02f,
  4.18253914e-02f, -5.10742031e-02f, -2.44714916e-02f, 1.34716913e-01f, 6.51805848e-02f, 1.84972808e-01f, 1.06398024e-01f, 4.00089808e-02f, -1.56068336e-02f, 2.83341948e-02f,
  3.61065641e-02f, 1.23893537e-01f, 1.40743833e-02f, -7.19394013e-02f, 6.83700759e-03f, -4.95507866e-02f, 5.37553430e-02f, -6.31230101e-02f, -1.10585429e-02f, -6.04191795e-02f,
  3.27725820e-02f, -9.79716629e-02f, 2.13886239e-02f, -1.76829785e-01f, -1.08983740e-01f, -1.56094795e-02f, -1.35640521e-02f, -1.90453887e-01f, -2.31663068e-03f, -3.58829163e-02f,
  6.16294481e-02f, -1.33715719e-01f, -1.35948032e-01f, -1.18647076e-01f, -1.20617568e-01f, 4.88854535e-02f, 1.02799788e-01f, -1.90533921e-01f, -2.14050412e-01f, 1.77627653e-01f,
  -5.26582822e-02f, 9.39384028e-02f, 2.38869235e-01f, 6.47857040e-02f, 9.41438600e-02f, 1.07815623e-01f, -4.05689739e-02f, 1.25948504e-01f, -9.89949107e-02f, 2.12654531e-01f,
  -6.00648765e-03f, 1.75154269e-01f, 1.76144734e-01f, 5.48090134e-03f, -2.03069672e-01f, 8.81145671e-02f, -8.62155855e-02f, 3.75192463e-02f, 9.83384326e-02f, -1.48346081e-01f,
  1.04074776e-01f, -2.07860455e-01f, -1.53215647e-01f, 2.36139625e-01f, 2.75663465e-01f, -3.98531072e-02f, 9.45859402e-02f, 1.04938343e-01f, -1.85895517e-01f, 9.37435552e-02f,
  3.71846631e-02f, -4.43425924e-02f, -8.58283564e-02f, 1.07618690e-01f, 2.11093742e-02f, 1.54137202e-02f, 3.64947617e-02f, -8.41051042e-02f, 4.38314751e-02f, -5.90463653e-02f,
  1.59583595e-02f, -6.93407701e-03f, 2.44590603e-02f, 1.49378881e-01f, -2.88650393e-02f, -7.32446238e-02f, -4.20167595e-02f, -2.71547660e-02f, 8.04046988e-02f, -1.19888723e-01f,
  1.29241660e-01f, -1.06295615e-01f, -4.61187772e-02f, -1.15845188e-01f, -1.44327939e-01f, 1.36194434e-02f, -1.23655470e-02f, -1.19829819e-01f, 4.93945032e-02f, 7.39830956e-02f,
  3.35738324e-02f, -2.11195974e-03f, 2.95586996e-02f, -3.47489417e-02f, 1.90499961e-01f, -4.64149080e-02f, -2.01155484e-01f, -1.72660369e-02f, 1.39629409e-01f, 1.68013245e-01f,
  1.43326428e-02f, -5.67388088e-02f, 1.56819761e-01f, 2.76795682e-02f, 6.05931282e-02f, 8.21892545e-02f, 2.21589953e-02f, -6.47779405e-02f, 4.57786843e-02f, 3.64639908e-02f,
  5.28822541e-02f, -1.24465480e-01f, 7.56824836e-02f, 2.51623571e-01f, 1.40231280e-02f, 1.74495801e-02f, 1.10208178e-02f, 1.11680426e-01f, -1.53492838e-01f, 1.74505815e-01f,
  -1.72685921e-01f, 3.19652520e-02f, 5.89651279e-02f, -8.08949471e-02f, -4.59446805e-03f, 4.40683514e-02f, -7.91996717e-02f, 6.47142471e-04f, -8.00730288e-02f, -1.65760219e-01f,
  -2.43901730e-01f, -1.61357853e-03f, -1.93568468e-02f, -4.26061638e-02f, 5.96287958e-02f, -1.56484798e-01f, -6.46175221e-02f, -1.23236954e-01f, -1.32236168e-01f, -5.37248962e-02f,
  5.50357886e-02f, 2.80855806e-03f, 7.99870938e-02f, -5.83357252e-02f, -6.75825179e-02f, 2.08787069e-01f, 1.15479521e-01f, 8.62164572e-02f, -1.07666954e-01f, -3.10137533e-02f,
  -8.39866027e-02f, 1.72018379e-01f, -4.60251048e-02f, 1.56241879e-01f, -2.34994188e-01f, 2.41199732e-01f, -1.67376667e-01f, -4.30062180e-03f, 2.36703351e-01f, -9.56281573e-02f,
  9.10308138e-02f, 2.57079661e-01f, -2.71147668e-01f, 4.33237664e-03f, 1.22627944e-01f, 2.09818363e-01f, 2.43992910e-01f, 8.86629988e-03f, 1.71344861e-01f, -4.98678610e-02f,
  1.09185442e-01f, 1.70903474e-01f, -5.69117777e-02f, -4.82432097e-02f, -3.88541967e-02f, 5.54879680e-02f, 2.17538521e-01f, 3.31116021e-02f, 2.17402428e-02f, -9.33525711e-02f,
  -1.35457441e-01f, 5.21189757e-02f, 9.40734446e-02f, -2.93131620e-01f, 2.61743128e-01f, -5.90840494e-03f, 2.38938540e-01f, -1.29804835e-01f, 6.22409359e-02f, 2.61896662e-02f,
  1.93926930e-01f, 1.79996878e-01f, 3.83708589e-02f, 7.47503787e-02f, 2.06881657e-01f, 2.13994920e-01f, 1.56447753e-01f, 8.23196694e-02f, -1.28086135e-02f, 1.46925613e-01f,
  2.16591544e-02f, 3.78916487e-02f, 1.45901695e-01f, 6.99988101e-03f, -3.21109705e-02f, -1.03841824e-02f, 4.69054505e-02f, -3.69175561e-02f, -1.00390278e-02f, -1.27885416e-01f,
  5.39990067e-02f, -5.30009009e-02f, 9.10620242e-02f, -7.62015805e-02f, 1.07270814e-01f, -2.91334148e-02f, -1.43409565e-01f, 1.32018864e-01f, 1.44726112e-01f, -8.93426985e-02f,
  -6.21458562e-03f, 8.29007179e-02f, -1.76463693e-01f, 7.67962784e-02f, -6.18406292e-03f, 2.86678467e-02f, 3.26739653e-04f, 7.42438361e-02f, 8.78133848e-02f, 4.75878119e-02f,
  -2.14113910e-02f, 1.43975228e-01f, 9.44128782e-02f, 1.83930561e-01f, -1.26005802e-03f, 5.65376505e-02f, -8.16893280e-02f, 2.85102502e-02f, -5.47042228e-02f, 3.98213835e-03f,
  -3.28307487e-02f, -8.47628042e-02f, -4.20000888e-02f, -8.70249271e-02f, 1.06078714e-01f, -1.93994641e-02f, -1.56496782e-02f, 5.56471664e-03f, -1.03454061e-01f, 1.13130271e-01f,
  -6.37055710e-02f, 1.30008146e-01f, -4.41229939e-02f, 1.01415634e-01f, 1.80857442e-02f, -6.83621839e-02f, 4.41141846e-03f, 3.83102931e-02f, 5.05004227e-02f, 6.58305585e-02f,
  5.79445921e-02f, 5.50727583e-02f, 1.78149641e-02f, 6.06250130e-02f, 4.41973396e-02f, 3.72827123e-03f, 4.96659279e-02f, 1.94154665e-01f, 5.19918418e-03f, 6.42425641e-02f,
  4.58214320e-02f, 8.86383932e-03f, 1.60712134e-02f, 1.44021749e-01f, -5.87941818e-02f, 4.76612747e-02f, 2.19944138e-02f, 9.32429358e-02f, 1.03788428e-01f, 6.80675283e-02f,
  1.71963617e-01f, -9.25089568e-02f, -9.75661352e-02f, 6.44713268e-02f, 4.59027402e-02f, 6.77491678e-03f, 5.77811934e-02f, 1.10114530e-01f, -1.08138785e-01f, -9.25953984e-02f,
  6.50639907e-02f, 5.48697524e-02f, 1.02309361e-01f, -2.95722429e-02f, 2.58455038e-01f, -2.24452943e-01f, 4.94210757e-02f, -6.14241846e-02f, -5.18488325e-02f, 1.71898361e-02f,
  1.50870502e-01f, -8.80265683e-02f, -5.40072583e-02f, -8.51489305e-02f, -4.69373316e-02f, 2.45022401e-01f, -3.07561886e-02f, 3.07432227e-02f, -1.01437531e-02f, -2.16035679e-01f,
  -9.47892442e-02f, 9.87706259e-02f, -8.15148652e-02f, 6.00090213e-02f, 6.62155375e-02f, -1.52407065e-02f, -8.76997225e-03f, -1.89171284e-02f, -4.91401739e-02f, -1.88767351e-03f,
  -1.54821039e-03f, 5.78176938e-02f, -1.01042502e-01f, -6.89335838e-02f, -1.48768472e-02f, 5.94307631e-02f, 3.40802483e-02f, -4.48672809e-02f, -3.10762413e-02f, 1.74773429e-02f,
  1.43721830e-02f, 6.25961572e-02f, -9.16567370e-02f, 4.63055726e-03f, -1.27887532e-01f, 1.94768816e-01f, -1.50876045e-01f, -4.75632101e-02f, -9.55609828e-02f, -2.66358978e-03f,
  2.35006511e-01f, 1.07873268e-01f, 1.17368214e-01f, -8.06215182e-02f, 1.96048804e-02f, 1.01491429e-01f, 1.77013099e-01f, -8.28246176e-02f, 1.87841743e-01f, -6.03268575e-03f,
  -2.50147194e-01f, 5.18488027e-02f, 5.77029623e-02f, -1.06138639e-01f, -3.51414680e-02f, -2.24473804e-01f, -1.05355054e-01f, 1.11177668e-01f, -1.93806097e-01f, -5.93842790e-02f,
  -7.72530064e-02f, -1.57218978e-01f, 2.36783683e-01f, 4.95511442e-02f, 1.42152473e-01f, -2.04191841e-02f, 6.85004592e-02f, 1.88903049e-01f, -6.23688139e-02f, -6.48230240e-02f,
  2.75679808e-02f, 4.92801219e-02f, 6.23744912e-02f, -9.03255865e-02f, 9.62308375e-04f, 7.93004632e-02f, 4.92147766e-02f, 1.05282240e-01f, -1.56514436e-01f, 3.20040047e-01f,
  -1.91096395e-01f, 1.64531376e-02f, -1.29531324e-01f, -1.33560330e-01f, -2.94061564e-02f, -1.06775701e-01f, -1.04745641e-01f, -1.17331399e-02f, -9.84893441e-02f, 6.18259888e-03f,
  -8.77699479e-02f, -7.36735687e-02f, 9.33733061e-02f, 3.91862839e-02f, 5.76173002e-03f, 7.57996738e-03f, 1.67872093e-03f, 9.80200693e-02f, 1.44256921e-02f, 3.64803337e-03f,
  9.68341604e-02f, -1.99034177e-02f, -9.97322500e-02f, -6.93856776e-02f, 1.43400421e-02f, 9.08969417e-02f, 1.13991320e-01f, -8.25631917e-02f, 9.54929441e-02f, 1.15923695e-02f,
  1.63567767e-01f, 5.31945117e-02f, 1.87748909e-01f, -2.87396282e-01f, -1.17640407e-03f, -1.25594378e-01f, -2.15577960e-01f, -1.35489868e-03f, 2.46830687e-01f, -2.77249757e-02f,
  -2.59850889e-01f, -2.53140271e-01f, -2.70289719e-01f, 6.11627698e-02f, 2.07176544e-02f, -2.04622090e-01f, 8.20525661e-02f, -1.92667525e-02f, 1.11479230e-01f, 1.15163714e-01f,
  1.85270026e-01f, 1.88999549e-01f, -4.43532802e-02f, 1.12890802e-01f, -2.89844628e-02f, 1.65727168e-01f, 6.91843405e-02f, 8.39831904e-02f, -2.13333666e-01f, 4.02228869e-02f,
  -1.23275936e-01f, -2.52148092e-01f, -2.70410091e-01f, 9.54608768e-02f, 9.39864963e-02f, 6.49022460e-02f, 1.36265352e-01f, -1.70735400e-02f, -4.11545001e-02f, 4.77099568e-02f,
  8.85783136e-02f, -1.15260202e-03f, -1.42773435e-01f, -1.02380440e-01f, -7.42830560e-02f, 5.18876426e-02f, -4.10975963e-02f, -3.74691561e-02f, -1.15452250e-02f, -2.16196284e-01f,
  2.95004714e-02f, -5.95673174e-02f, 7.84339532e-02f, -2.03183278e-01f, 2.28297740e-01f, -1.91007152e-01f, -2.16878757e-01f, -1.15060024e-01f, -3.45029794e-02f, -2.62730792e-02f,
  -5.36200665e-02f, -5.31155430e-02f, -2.05461681e-02f, 8.89221653e-02f, -1.35059327e-01f, -1.01384729e-01f, -8.10502842e-02f, 3.20110805e-02f, 9.81225893e-02f, 1.36921376e-01f,
  -1.08989500e-01f, 1.57715783e-01f, 2.40997970e-01f, 3.98281887e-02f, -8.41917563e-03f, -1.76794082e-01f, -1.09882832e-01f, 3.70031685e-01f, -1.52045876e-01f, 6.25017062e-02f,
  1.22742943e-01f, -2.57596076e-02f, -4.24216725e-02f, 2.70792753e-01f, -1.55882700e-03f, 4.01656702e-03f, 1.22338921e-01f, 9.02260020e-02f, -6.64252341e-02f, 1.97001651e-01f,
  -1.09295309e-01f, 1.44517899e-01f, 1.21118324e-02f, 1.22279771e-01f, -7.96978101e-02f, -9.94600803e-02f, -2.96968967e-01f, -1.63329840e-01f, 5.47054363e-03f, 4.90530394e-03f,
  1.13518678e-01f, 1.29660452e-02f, -1.14945576e-01f, 4.39780876e-02f, 1.46961704e-01f, 3.60034704e-02f, 3.68601317e-03f, -2.73710024e-02f, -1.16096273e-01f, 1.15271792e-01f,
  -2.24517342e-02f, -1.33481517e-01f, 1.03207245e-01f, -8.96389484e-02f, 1.66318864e-01f, 4.34431396e-02f, -8.87714848e-02f, -5.11464849e-02f, 1.77000687e-01f, 6.17488585e-02f,
  -4.63114008e-02f, 1.08314052e-01f, 2.29668409e-01f, 1.20696895e-01f, -2.29680929e-02f, 2.36727923e-01f, 1.92180648e-02f, 1.53776463e-02f, 7.06132967e-03f, 1.89532917e-02f,
  -3.33267264e-02f, 1.36574075e-01f, -7.31668174e-02f, 8.28287527e-02f, 2.52559245e-01f, -9.43480656e-02f, 5.65918796e-02f, -9.41023827e-02f, 2.40043793e-02f, 7.07385242e-02f,
  1.06895775e-01f, 1.89572051e-01f, -2.61875808e-01f, 2.56686052e-03f, 7.65684023e-02f, 1.50712371e-01f, 4.78893593e-02f, -8.21931213e-02f, -2.39266038e-01f, 2.00009383e-02f,
  -7.63091072e-02f, -6.78348988e-02f, 3.61260679e-03f, 2.01188266e-01f, -3.55317183e-02f, 1.68545656e-02f, 1.71372741e-01f, -8.46924353e-03f, 1.17562816e-01f, -1.82284310e-01f,
  -1.07982427e-01f, 1.06112966e-02f, -7.48150796e-02f, 9.60309617e-03f, -4.39967588e-02f, 5.92711419e-02f, 9.43240374e-02f, -6.53529018e-02f, -1.95777729e-01f, -9.96695459e-02f,
  -6.32307008e-02f, 4.38766778e-02f, -6.54238835e-02f, -7.34752789e-02f, -5.97042702e-02f, 4.86513674e-02f, -6.31229430e-02f, 6.32612035e-02f, -2.50071529e-02f, 8.15985277e-02f,
  -1.22423030e-01f, 1.48061305e-01f, -1.28385633e-01f, -2.44317017e-02f, -1.34335190e-01f, 1.23539446e-02f, 6.05776533e-02f, 3.39400917e-02f, 1.58912972e-01f, 1.43228456e-01f,
  1.56979069e-01f, -4.85944711e-02f, -3.09723895e-02f, -8.45794007e-02f, 1.07140690e-01f, -3.47348526e-02f, -2.12999210e-01f, 1.84755567e-02f, 1.08339600e-01f, -9.85975936e-02f,
  2.78700106e-02f, -3.05100292e-01f, 4.80106510e-02f, -2.04960797e-02f, -1.48401245e-01f, -1.89870238e-01f, -6.51500821e-02f, -2.38684565e-01f, 6.20097667e-02f, -7.26571456e-02f,
  2.31294617e-01f, -1.55807838e-01f, 7.83358589e-02f, 2.35040877e-02f, -1.63326524e-02f, -4.52841148e-02f, -1.02174124e-02f, 1.29528075e-01f, 2.27939896e-02f, -6.12064973e-02f,
  -8.78284872e-02f, 1.56082675e-01f, -9.44352522e-02f, 5.54746427e-02f, -1.71622619e-01f, 1.19945288e-01f, -1.79166663e-02f, -6.27683178e-02f, 2.62365473e-04f, 7.48079121e-02f,
  1.86291441e-01f, 1.05304278e-01f, 1.89598799e-01f, -4.46112528e-02f, 8.19415227e-02f, 3.90631855e-02f, 1.24483578e-01f, 1.06704541e-01f, 1.19615123e-02f, 1.58051074e-01f,
  -8.81419051e-03f, 4.19217311e-02f, -1.34729862e-01f, -1.86186865e-01f, 4.12129946e-02f, -2.04871908e-01f, 1.79117918e-02f, -1.46145433e-01f, -9.58260298e-02f, -2.28257075e-01f,
  -1.71643719e-01f, -5.56730591e-02f, -2.08937544e-02f, -6.50221109e-02f, -2.50636972e-02f, 1.25162765e-01f, 1.32247671e-01f, -1.01947799e-01f, -5.03754616e-02f, 2.36130357e-01f,
  1.33940652e-01f, 2.50593662e-01f, -8.44366942e-03f, -5.84575497e-02f, 8.46466944e-02f, 1.53582707e-01f, 2.14491308e-01f, -1.15844883e-01f, 6.45102635e-02f, -1.68680832e-01f,
  1.95628256e-01f, 1.32150576e-01f, -1.88838184e-01f, -1.26473576e-01f, -1.10853344e-01f, 7.66890272e-02f, 8.61125886e-02f, 9.01300274e-03f, 1.35778755e-01f, 1.51240751e-01f,
  -2.97736358e-02f, -4.25067544e-02f, 1.05582573e-01f, -9.89788119e-03f, -1.02395438e-01f, 1.66080073e-01f, -2.03087956e-01f, 2.71402031e-01f, 1.04503036e-01f, 1.26076400e-01f,
  -3.28813158e-02f, 3.86938713e-02f, -3.86834852e-02f, 1.25120226e-02f, -6.42233342e-02f, -4.75251451e-02f, -1.16046578e-01f, -1.23850152e-01f, 1.92087069e-02f, 2.91102775e-03f,
  5.42634875e-02f, 2.24380549e-02f, 1.70065870e-03f, 3.70875597e-02f, 1.10203125e-01f, -1.12067878e-01f, -3.55252996e-02f, -1.30552948e-01f, -5.56779243e-02f, 3.32056731e-02f,
  -5.11373281e-02f, -4.36440744e-02f, -7.22008618e-03f, 3.98865454e-02f, 1.12057645e-02f, -9.14655104e-02f, 5.48293032e-02f, -6.01371564e-02f, -5.23637682e-02f, 8.24730545e-02f,
  2.06564307e-01f, -5.64591475e-02f, 7.42432028e-02f, -1.48252308e-01f, 5.26474342e-02f, 3.19708697e-02f, 1.56345516e-01f, 5.37414439e-02f, 8.08351338e-02f, -1.57262027e-01f,
  -1.92839637e-01f, 2.04733741e-02f, -2.72299141e-01f, 1.77592888e-01f, -1.20222889e-01f, -5.89669719e-02f, 1.50507510e-01f, -1.00348406e-01f, -7.61033222e-02f, 1.39574841e-01f,
  8.98474604e-02f, 1.79755062e-01f, -1.29366189e-01f, -1.00160956e-01f, 1.05774447e-01f, -1.50442809e-01f, 8.75291452e-02f, 7.15618432e-02f, 2.06552297e-01f, -1.11465612e-02f,
  8.80527198e-02f, -1.21874392e-01f, -2.75366753e-01f, 2.04344362e-01f, 1.82605147e-01f, 5.82655799e-03f, 4.42322083e-02f, 1.50535613e-01f, 1.89646520e-02f, 1.94320604e-01f,
  2.75986567e-02f, 7.62897134e-02f, 1.08687662e-01f, 8.93810689e-02f, 1.01719670e-01f, 5.50805628e-02f, -8.01153407e-02f, 9.23570096e-02f, 9.49730352e-03f, -6.35072812e-02f,
  -2.60048127e-03f, -7.16518611e-02f, 7.43925273e-02f, 8.34418647e-03f, -1.02193737e-02f, -1.42476633e-02f, 6.72093406e-02f, 7.84538314e-02f, 1.77568898e-01f, 1.29664214e-02f,
  -2.03928538e-02f, 1.48354635e-01f, -9.19919834e-02f, 1.44994929e-01f, -7.56964507e-03f, -7.97896832e-03f, -1.35962278e-01f, 2.17466950e-01f, 1.18539803e-01f, 7.66022205e-02f,
  1.68418512e-01f, 2.12641463e-01f, -7.63535202e-02f, 2.16054708e-01f, 2.60548204e-01f, 2.10073322e-01f, 2.08166808e-01f, 1.06007613e-01f, 1.64541557e-01f, 1.75930530e-01f,
  -1.11581177e-01f, 2.11137772e-01f, -7.40102157e-02f, -1.37862153e-02f, -8.17853659e-02f, -2.33702883e-01f, -4.56439406e-02f, 1.31291047e-01f, 2.67764553e-02f, -1.23206362e-01f,
  -6.91381767e-02f, 8.05623904e-02f, 1.08371392e-01f, 7.52720833e-02f, 8.24979246e-02f, 2.19596758e-01f, 3.26298505e-01f, 7.56017922e-04f, 2.89066173e-02f, -1.71427447e-02f,
  1.76792440e-03f, 7.29358569e-02f, 2.27943938e-02f, 5.15813343e-02f, -2.48963870e-02f, 1.21073842e-01f, 4.16288003e-02f, 8.95125717e-02f, -1.15221285e-03f, 5.40254824e-02f,
  8.54633823e-02f, -3.66015658e-02f, 3.57422158e-02f, 2.38881502e-02f, 6.61828816e-02f, 6.33876100e-02f, 1.05448633e-01f, 5.61985858e-02f, 3.13485526e-02f, -2.19879393e-03f,
  1.40678316e-01f, 9.48170945e-03f, -1.32755518e-01f, 7.71545395e-02f, 1.88386142e-01f, 6.16408363e-02f, 4.99086827e-02f, 1.94820121e-01f, 5.22839203e-02f, 2.17601463e-01f,
  1.54029667e-01f, -5.72696216e-02f, 9.25719291e-02f, -1.87697373e-02f, -1.66861087e-01f, 1.94059983e-01f, 5.30125462e-02f, 1.63144857e-01f, -7.70750269e-02f, -1.13736112e-02f,
  -6.97475970e-02f, 1.53898925e-01f, 2.57935256e-01f, 1.03277206e-01f, -1.35583226e-02f, 5.49437441e-02f, -4.80762962e-03f, 1.86156213e-01f, 1.48588449e-01f, 1.67744175e-01f,
  1.22474541e-03f, 1.59304127e-01f, -2.57972442e-02f, -7.58331195e-02f, 1.21887788e-01f, 5.12014255e-02f, -6.32305220e-02f, -5.48392460e-02f, 4.08349112e-02f, 6.95706159e-02f,
  1.65663846e-02f, 2.28180796e-01f, -1.02355249e-01f, 1.14361405e-01f, -9.46303383e-02f, 1.68051526e-01f, 1.05013371e-01f, 6.10284833e-03f, 7.98096806e-02f, -1.85776770e-03f,
  1.75297037e-01f, -9.25287697e-03f, -2.33489671e-03f, 3.59216668e-02f, -1.63913712e-01f, 5.44541441e-02f, -9.06439498e-02f, 1.03867926e-01f, -5.19700162e-02f, -1.36342213e-01f,
  3.80902514e-02f, -5.87039776e-02f, 1.37931099e-02f, 2.49170046e-02f, -1.65064067e-01f, -6.67869449e-02f, 1.84198141e-01f, -1.76705763e-01f, -1.54595897e-01f, 2.31882423e-01f,
  -9.43820402e-02f, -1.35197029e-01f, -2.12334037e-01f, -1.34189159e-01f, -2.12302700e-01f, 1.72215611e-01f, -9.71635357e-02f, 8.94301161e-02f, 1.24061882e-01f, -8.13890174e-02f,
  -7.07222447e-02f, 1.46591961e-01f, 1.60196945e-01f, 7.91491494e-02f, 2.48938039e-01f, 5.16660884e-02f, -3.40714864e-02f, 1.61369979e-01f, -6.54540062e-02f, -2.45761201e-02f,
  -1.45185277e-01f, -8.23960900e-02f, -1.71189204e-01f, -2.10285813e-01f, 1.14933610e-01f, -4.50574793e-02f, -5.45421056e-02f, -4.09382321e-02f, -2.07083553e-01f, -1.20517891e-02f,
  2.23188818e-01f, -8.14431757e-02f, 8.88797548e-03f, 3.13198194e-02f, 1.51679497e-02f, -3.03364187e-01f, 3.67599800e-02f, -1.02733865e-01f, -1.12143531e-01f, 3.73925939e-02f,
  8.45754296e-02f, -5.63555695e-02f, -7.12668747e-02f, -1.48576135e-02f, 9.63944048e-02f, 1.05062522e-01f, 5.09282686e-02f, -1.17537200e-01f, -1.80408303e-02f, 1.26177758e-01f,
  1.70006435e-02f, 1.40710339e-01f, -6.17136918e-02f, -5.55264615e-02f, -9.65807959e-02f, 7.62780532e-02f, -2.35987559e-01f, 2.91581377e-02f, 4.61518131e-02f, 2.28406787e-02f,
  4.69254479e-02f, 9.07105282e-02f, 4.42833127e-03f, 9.23704579e-02f, 1.50805771e-01f, 2.41383929e-02f, 1.16472490e-01f, -2.87911408e-02f, 5.17796166e-02f, 1.62157372e-01f,
  -7.62542337e-02f, 1.05745271e-01f, 5.78654148e-02f, -1.87800676e-01f, -1.48418039e-01f, 1.13457471e-01f, 2.75169820e-01f, 1.56553805e-01f, 5.73363341e-02f, -3.65995228e-01f,
  1.56150833e-01f, -2.84059942e-02f, 1.93721633e-02f, -1.15473896e-01f, 1.20992571e-01f, -2.01925606e-01f, 6.43014014e-02f, -4.07365374e-02f, 2.36682594e-02f, 2.42890269e-01f,
  -1.83241330e-02f, -7.91696161e-02f, 2.70635239e-03f, -1.95859551e-01f, 2.40680829e-01f, 1.20216139e-01f, 1.09680749e-01f, 1.02362141e-01f, 1.92871407e-01f, 1.98682070e-01f,
  -2.36755113e-06f, 1.48010850e-01f, 2.54249215e-01f, 4.28075381e-02f, 6.71442524e-02f, 6.73405528e-02f, 1.91039547e-01f, 4.70514670e-02f, 1.18354000e-02f, 1.77793950e-01f,
  -1.00616257e-04f, 1.54124141e-01f, -7.04400800e-03f, 4.85136509e-02f, 1.01837583e-01f, 4.60708141e-02f, -3.45336869e-02f, -3.27531286e-02f, -1.56221129e-02f, -3.98242697e-02f,
  -1.86489895e-02f, -1.15090765e-01f, -2.47419015e-01f, -5.66100553e-02f, 2.50657499e-01f, 1.54069930e-01f, 9.16157067e-02f, 8.88256058e-02f, -1.53708616e-02f, -1.09301927e-03f,
  1.91911295e-01f, -2.13045046e-01f, 7.01605454e-02f, 1.30260974e-01f, -6.93869144e-02f, 1.70306563e-01f, -3.87724228e-02f, -1.06076218e-01f, 1.95992529e-01f, 1.51525093e-02f,
  8.34013056e-03f, -2.23974939e-02f, 1.37524232e-01f, -1.29457384e-01f, 6.38561323e-02f, 4.05514129e-02f, 4.04064208e-02f, -2.02706426e-01f, 1.52751386e-01f, -6.16242783e-03f,
  -1.13117374e-01f, -9.68475267e-02f, -5.92262410e-02f, 1.15780391e-01f, -9.51300710e-02f, 1.72410205e-01f, -4.11735754e-03f, 5.17046712e-02f, -1.89913418e-02f, 2.50330180e-01f,
  -2.06449598e-01f, 1.58784837e-01f, 7.36021101e-02f, 1.15344703e-01f, 4.72000279e-02f, -2.44825259e-02f, 3.79512943e-02f, 2.43313052e-02f, 4.06710543e-02f, 1.15436494e-01f,
  4.50240746e-02f, 1.82130449e-02f, -5.33596464e-02f, -8.79238322e-02f, -1.25625312e-01f, 7.64053091e-02f, -3.08057037e-03f, 5.34905531e-02f, 9.33949426e-02f, -5.34257405e-02f,
  -1.30907223e-01f, -6.23920150e-02f, 2.18873620e-02f, -1.61097229e-01f, 7.65023008e-02f, -2.19334945e-01f, -5.00353947e-02f, -1.56563837e-02f, 3.81182693e-03f, 4.53743432e-03f,
  8.41368809e-02f, -7.21477577e-03f, 5.95004894e-02f, 1.72160435e-02f, 7.39974976e-02f, -1.18243545e-01f, -6.69238269e-02f, 1.40515238e-01f, 7.24903420e-02f, 9.61134657e-02f,
  -1.28671855e-01f, 1.18175499e-01f, 2.16770157e-01f, -2.19180901e-02f, 8.85428023e-03f, -2.37724796e-01f, -7.03607723e-02f, 1.26565173e-01f, 2.97886990e-02f, -3.41751787e-04f,
  -1.27172694e-01f, -1.76274359e-01f, -2.06347257e-02f, 1.47456422e-01f, 2.44969353e-02f, -1.86569110e-01f, -4.50198725e-03f, 2.30036199e-01f, 9.88642592e-03f, 8.11890587e-02f,
  7.19086220e-03f, 7.08409101e-02f, -3.02960068e-01f, 1.59180865e-01f, -1.71817333e-01f, 5.92235252e-02f, -1.38751492e-01f, -6.60395399e-02f, 6.47434592e-02f, 8.57105628e-02f,
  2.80810207e-01f, 1.05765589e-01f, 1.33803427e-01f, 2.38726377e-01f, 2.44965181e-01f, 1.52732596e-01f, 5.19025326e-02f, 7.84363672e-02f, 3.59823704e-02f, 1.78229451e-01f,
  -6.17934251e-03f, 6.63301423e-02f, 7.00661540e-02f, 9.56341475e-02f, -3.34487706e-02f, -2.09155623e-02f, 6.12090677e-02f, -1.35280788e-01f, -2.32919827e-02f, -1.48478270e-01f,
  -1.24959275e-01f, -7.85496682e-02f, 1.36103034e-01f, 7.37569109e-02f, 1.30047835e-02f, 1.07762374e-01f, -8.65388215e-02f, -3.69797423e-02f, 1.40853614e-01f, -1.65987208e-01f,
  -2.26993337e-02f, 1.30838722e-01f, -5.16287144e-03f, 2.68768638e-01f, -2.59414781e-02f, 3.03622559e-02f, -4.85375673e-02f, 2.65586544e-02f, 1.94994211e-01f, 2.21712422e-02f,
  1.10187851e-01f, -3.95450741e-03f, 5.04376891e-04f, 1.57646000e-01f, -1.29675567e-01f, -1.36916324e-01f, -8.86275768e-02f, -8.99726376e-02f, -1.34093404e-01f, -1.92004576e-01f,
  4.26197089e-02f, 7.59106502e-02f, -8.23889524e-02f, -1.27488896e-02f, -7.40767419e-02f, 4.20336053e-02f, -1.27215013e-01f, 8.96680281e-02f, -2.19073370e-01f, 2.20955864e-01f,
  1.29444659e-01f, -1.41379489e-02f, 6.34308532e-02f, 2.30328608e-02f, -5.25411926e-02f, -1.86087899e-02f, 9.61937010e-02f, 3.15009281e-02f, -9.80152711e-02f, 5.52800223e-02f,
  4.38889675e-02f, 5.05951270e-02f, 4.27434184e-02f, -7.28750508e-03f, 1.25556171e-01f, 7.03522041e-02f, 4.97771427e-02f, 1.09031506e-01f, -8.95037800e-02f, 9.28344503e-02f,
  6.03563674e-02f, 9.80291143e-03f, -1.13009267e-01f, -1.97813213e-02f, 9.77573246e-02f, 3.94129008e-02f, -9.10894647e-02f, 1.35982975e-01f, 2.11729798e-02f, -7.59547856e-03f,
  1.56283721e-01f, 1.35565937e-01f, 1.64374784e-02f, 1.01752244e-01f, 1.10884689e-01f, 9.50179249e-03f, 1.19632766e-01f, 1.17607519e-01f, -8.61221626e-02f, -6.41147047e-02f,
  -1.33428890e-02f, -5.18937446e-02f, 1.10136695e-01f, -5.16446754e-02f, 1.11254238e-01f, -2.76887834e-01f, 6.57613873e-02f, -1.81970239e-01f, 7.56694889e-03f, 4.86936457e-02f,
  3.53757069e-02f, -3.97909917e-02f, 6.36565313e-02f, -5.70963509e-02f, -5.37096821e-02f, 2.70563990e-01f, 2.65308656e-02f, -3.37591209e-02f, 2.17429195e-02f, -1.56986475e-01f,
  -1.00639582e-01f, 1.09978817e-01f, 5.91338873e-02f, 8.37982744e-02f, 1.34133950e-01f, 6.18276931e-02f, 2.40985174e-02f, 5.93130514e-02f, -3.49876359e-02f, 7.08547980e-02f,
  3.20095010e-02f, -1.64629389e-02f, -6.96631335e-03f, 1.15809422e-02f, 7.22999200e-02f, 8.82052705e-02f, 4.68262583e-02f, -1.09158874e-01f, -7.52336010e-02f, 1.46100968e-01f,
  -1.59137532e-01f, 1.38201013e-01f, 3.08357291e-02f, 4.12727408e-02f, 4.40262444e-02f, -7.34484196e-02f, 9.04465169e-02f, 2.80368682e-02f, -1.34563133e-01f, -1.34529576e-01f,
  1.31371871e-01f, 6.90864623e-02f, -4.66328077e-02f, 2.24297822e-01f, 1.18873110e-02f, -1.10590629e-01f, -1.22669533e-01f, -1.27491876e-01f, 7.71526946e-03f, 2.83298790e-01f,
  3.70084904e-02f, 2.09230050e-01f, 1.31284505e-01f, -1.03831038e-01f, 6.31817281e-02f, 2.07567424e-01f, 2.64534473e-01f, 2.02032298e-01f, 1.77287966e-01f, -1.84043333e-01f,
  -9.95641574e-02f, -8.75065289e-03f, -1.10666536e-01f, -9.87646282e-02f, 1.80295691e-01f, -1.23054117e-01f, -3.09655499e-02f, -1.91787466e-01f, 1.42515481e-01f, 1.69474855e-01f,
  -3.26060578e-02f, 8.37719142e-02f, -1.45989791e-01f, 8.76403153e-02f, 3.29175815e-02f, 2.15957165e-01f, -1.92235440e-01f, 2.41896823e-01f, 1.04507595e-01f, -1.32457331e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -1.11361966e-02f, 5.64644299e-02f, 1.04752621e-02f, -1.97359044e-02f, 1.18096493e-01f, -2.64559165e-02f, -7.54989684e-02f, 1.18881047e-01f, -2.10036989e-02f, 2.50047334e-02f,
  2.22932883e-02f, 4.00047377e-02f, 3.45438942e-02f, 9.40918699e-02f, 8.73992816e-02f, 3.73593532e-02f, 4.72148992e-02f, 6.20058104e-02f, -1.65772544e-05f, 1.28738567e-01f,
  7.82019719e-02f, -9.44399461e-03f, 9.11370143e-02f, 7.10052019e-03f, -2.68329680e-02f, -3.90823632e-02f, -1.85589753e-02f, -3.52490135e-03f, 4.65510115e-02f, 8.79849494e-02f,
  4.21858430e-02f, 6.97649121e-02f, -7.96704262e-05f, -5.20777032e-02f, 9.34208557e-02f, 1.12154752e-01f, -2.28978414e-02f, 1.14843249e-01f, 2.29875818e-02f, 7.56780952e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -4.82989848e-02f, -3.07165682e-02f, 5.55201024e-02f, -5.41208461e-02f, 2.86298264e-02f, -8.62721354e-02f, -2.38235518e-02f, -2.92502390e-03f, 4.22861315e-02f, -1.11797884e-01f,
  1.36553571e-01f, -1.34412467e-01f, 2.86475569e-02f, 1.37710631e-01f, -7.81178474e-02f, 3.62155773e-02f, 2.12251185e-03f, 4.88835387e-02f, -2.55814642e-02f, -1.86572000e-02f,
  8.13998953e-02f, -5.22139203e-03f, -1.31091457e-02f, -3.28870602e-02f, 2.11024657e-01f, 1.35812610e-01f, -4.35828753e-02f, -1.98901206e-01f, 2.30435371e-01f, 1.03893146e-01f,
  1.87236786e-01f, -2.44071990e-01f, 2.27889255e-01f, -2.35387027e-01f, -2.70213962e-01f, 9.85395238e-02f, 1.31760165e-01f, 2.52372712e-01f, 3.25058103e-02f, -2.95508325e-01f,
  4.88137268e-02f, -1.72578827e-01f, 1.59540892e-01f, 4.23097350e-02f, -3.89549113e-03f, -1.85020834e-01f, 3.81969623e-02f, -2.50913888e-01f, -1.03690878e-01f, 1.22364230e-01f,
  8.78637508e-02f, -1.97373152e-01f, -6.96022734e-02f, 7.86491409e-02f, 1.81008920e-01f, -1.33767858e-01f, 1.72808409e-01f, -2.77441919e-01f, -3.62714618e-01f, -1.74809560e-01f,
  3.12897377e-02f, -3.03216755e-01f, -2.14337468e-01f, -4.29078311e-01f, 3.06060966e-02f, -4.11224701e-02f, 1.77015826e-01f, -7.00128898e-02f, -1.23748094e-01f, -4.12534829e-03f,
  9.70519111e-02f, -5.10449633e-02f, -3.98092195e-02f, 2.81010084e-02f, -1.86521485e-01f, 1.40427113e-01f, 1.26022696e-02f, 6.67122081e-02f, 2.22391635e-02f, 1.15164826e-02f,
  -9.30635110e-02f, 1.54691845e-01f, 9.29337591e-02f, -8.06828663e-02f, -2.28670314e-01f, 9.18216631e-02f, -6.21827804e-02f, 7.94200450e-02f, -2.26848930e-01f, -1.41162351e-01f,
  -3.06417704e-01f, 2.59313751e-02f, 1.96545377e-01f, 1.65634498e-01f, 1.46285847e-01f, -2.49717772e-01f, 4.74092700e-02f, -1.97981298e-01f, 1.47034600e-01f, 2.47787088e-01f,
  1.70171246e-01f, -1.06974952e-01f, -2.79845268e-01f, 1.23919904e-01f, 1.18643403e-01f, 4.22348492e-02f, 2.22177058e-02f, 1.79236084e-01f, -5.17036431e-02f, 1.74814612e-01f,
  3.50878760e-02f, -9.71340016e-02f, -9.22702178e-02f, -2.58346856e-01f, 1.94145247e-01f, 1.46006281e-02f, 6.81160763e-02f, -2.46641874e-01f, 9.53446105e-02f, -1.73080862e-02f,
  1.12875111e-01f, -1.15317985e-01f, -3.37740600e-01f, -3.02137733e-01f, -2.18355507e-01f, -2.47491881e-01f, -5.84430527e-03f, -2.60170341e-01f, 3.57254148e-02f, 2.93782577e-02f,
  1.45408079e-01f, -7.89233893e-02f, -8.68973210e-02f, -1.80443898e-02f, 1.34439498e-01f, 7.43107796e-02f, -9.36917439e-02f, 1.00259427e-02f, -9.19121355e-02f, 1.40620962e-01f,
  1.06480032e-01f, 1.05939463e-01f, 9.93621275e-02f, 8.85902196e-02f, -1.09880134e-01f, 6.32736925e-03f, -1.40319139e-01f, -2.01029897e-01f, -8.80613253e-02f, 3.55062447e-02f,
  5.04575111e-02f, -1.11362197e-01f, -7.05468580e-02f, 2.38190576e-01f, -2.42073148e-01f, -4.60899388e-03f, -2.97337592e-01f, -1.07351683e-01f, -4.44579907e-02f, 1.34140298e-01f,
  -5.15871197e-02f, -1.00522339e-01f, -3.86399799e-04f, 9.94147882e-02f, -7.08399564e-02f, 9.08723939e-03f, -1.17225900e-01f, 4.96865809e-02f, 2.58890949e-02f, -7.47123882e-02f,
  -3.23157728e-01f, 4.59564626e-02f, -2.45345801e-01f, 2.35634789e-01f, 4.42120694e-02f, -3.38747442e-01f, -1.80323362e-01f, -6.78829476e-02f, -2.24961266e-01f, 2.30647817e-01f,
  1.83659308e-02f, -3.10564667e-01f, -2.68281043e-01f, 1.10329337e-01f, -8.03182498e-02f, 2.28835300e-01f, -2.89807655e-02f, -4.37971115e-01f, 2.79706009e-02f, -2.60353416e-01f,
  -1.05171517e-01f, 1.14273228e-01f, -1.11389600e-01f, -8.44907090e-02f, -5.84513247e-02f, -1.26182079e-01f, -4.22130972e-02f, -1.71747550e-01f, -1.14662588e-01f, 6.83278516e-02f,
  -1.60495192e-02f, -9.66396928e-02f, 1.62295118e-01f, -1.38958812e-01f, 1.36327729e-01f, 1.81997269e-02f, 8.91405642e-02f, -1.27075128e-02f, -1.26586601e-01f, -6.33155480e-02f,
  6.55264854e-02f, -1.76794659e-02f, 2.10956290e-01f, 1.28740221e-01f, 6.68909699e-02f, 1.58465818e-01f, -5.81107326e-02f, -2.04791620e-01f, 8.72173458e-02f, -6.85172677e-02f,
  1.80317596e-01f, -3.04768700e-03f, 2.83690989e-02f, 9.22323614e-02f, 9.83414501e-02f, -1.12507539e-02f, -3.91850740e-01f, -2.05297425e-01f, -3.52406293e-01f, 3.99442315e-02f,
  7.89901465e-02f, 4.82886881e-02f, -1.38754681e-01f, 2.19737828e-01f, -7.71921575e-02f, -1.57259449e-01f, 7.56640956e-02f, 4.96431179e-02f, -1.35200381e-01f, -2.16288902e-02f,
  1.93547025e-01f, 1.81007758e-01f, -1.98093250e-01f, -3.67613822e-01f, 2.21676171e-01f, -3.71245039e-03f, 4.02071290e-02f, -4.54911470e-01f, 6.07624836e-02f, 1.14676459e-02f,
  1.55272141e-01f, 8.73186439e-02f, 7.63032178e-04f, -2.85722643e-01f, 1.52769491e-01f, -8.52050483e-02f, 7.08020329e-02f, -9.67121646e-02f, 3.04611996e-02f, 1.25825599e-01f,
  -1.37261003e-02f, 2.41127566e-01f, 4.59822118e-02f, 2.23744605e-02f, 2.14296095e-02f, 1.26586720e-01f, -1.28142923e-01f, -4.40430902e-02f, -9.24213156e-02f, -2.34832823e-01f,
  -2.55434006e-01f, -1.38338253e-01f, 1.12231359e-01f, -6.69903457e-02f, 5.09428605e-02f, -1.71972319e-01f, 1.47367999e-01f, -1.28824726e-01f, 1.20935410e-01f, -2.24468075e-02f,
  1.98112190e-01f, -1.64242432e-01f, 6.76402301e-02f, 5.87576404e-02f, 6.68330193e-02f, -2.63847113e-01f, 1.02891713e-01f, 1.12325124e-01f, -5.12366705e-02f, 6.40516803e-02f,
  -3.21742803e-01f, -1.33118793e-01f, 9.95438620e-02f, -2.10712925e-01f, 1.46138504e-01f, 6.01046905e-02f, 1.31860822e-01f, -1.18273683e-01f, 2.89940119e-01f, -1.77179694e-01f,
  2.27491334e-02f, -6.97715133e-02f, 1.88083291e-01f, 3.29793468e-02f, -4.13213819e-02f, -2.36372143e-01f, -2.24504888e-01f, -1.82147771e-01f, -2.82465160e-01f, 1.51565805e-01f,
  -1.78874373e-01f, 9.00041983e-02f, 2.02503666e-01f, -3.86045694e-01f, 4.37345877e-02f, 1.57426670e-01f, 8.93483609e-02f, 1.99070454e-01f, 1.45042434e-01f, -1.27293512e-01f,
  -1.79863051e-01f, -2.55333888e-03f, -1.80469736e-01f, 2.24936992e-01f, 1.22156981e-02f, -2.96241567e-02f, -5.44474041e-03f, 1.90424789e-02f, 9.07250270e-02f, -1.65105209e-01f,
  1.92958385e-01f, 7.85717592e-02f, -2.28837982e-01f, 1.83604985e-01f, 1.99973211e-01f, 3.34178954e-02f, -1.29342526e-01f, 2.53705800e-01f, -2.58401006e-01f, -6.02149107e-02f,
  2.34045714e-01f, 8.65515172e-02f, -8.31077099e-02f, 1.44416496e-01f, -2.00587474e-02f, -7.40066990e-02f, -1.22140488e-02f, -2.78751969e-01f, -3.22179794e-02f, -9.60311815e-02f,
  -1.04936019e-01f, -4.08459932e-01f, -1.12828292e-01f, -5.21588475e-02f, 2.02487707e-01f, 6.77207559e-02f, 1.59587383e-01f, 2.90022910e-01f, 8.38083848e-02f, 5.46106324e-02f,
  1.33645777e-02f, -2.27668285e-01f, -2.82221623e-02f, 1.51842028e-01f, 1.73360333e-01f, -2.97862172e-01f, 9.53043848e-02f, -3.24210972e-01f, -2.07256988e-01f, -2.40488008e-01f,
  2.77441055e-01f, 7.97255710e-02f, -1.62712470e-01f, 1.59588203e-01f, -8.90052915e-02f, 5.79365306e-02f, -6.84719607e-02f, 7.95468241e-02f, -2.96872735e-01f, 8.93731862e-02f,
  3.09848964e-01f, 1.13578729e-01f, -1.78111002e-01f, 7.37524629e-02f, 8.36603045e-02f, 1.41333640e-01f, -1.12583637e-01f, 2.51214989e-02f, -3.73918638e-02f, -1.22323297e-01f,
  1.97977703e-02f, -1.29242346e-01f, 2.59988997e-02f, -3.80588584e-02f, -7.08888397e-02f, -1.26582056e-01f, -1.22819424e-01f, 1.27158701e-01f, 7.75806755e-02f, -1.60813481e-01f,
  -8.02598670e-02f, 2.00582936e-01f, -1.01699635e-01f, -1.11527227e-01f, 1.67292759e-01f, -1.66914344e-01f, -4.67066504e-02f, 1.33386254e-01f, -6.86577857e-02f, 6.09762147e-02f,
  -5.86941503e-02f, -3.53962094e-01f, -3.09735805e-01f, -2.73295213e-02f, -3.36079538e-01f, 1.79105133e-01f, -3.00913095e-01f, -1.87543243e-01f, 1.73758015e-01f, -1.74024463e-01f,
  6.64639100e-02f, -3.65701467e-01f, -1.90319538e-01f, -1.06153391e-01f, -4.24951404e-01f, -3.05613667e-01f, -1.14149958e-01f, -1.46112507e-04f, -1.22426629e-01f, -1.29627079e-01f,
  3.72594148e-02f, -2.14426238e-02f, -2.92667985e-01f, -5.54085290e-03f, -2.53686905e-01f, 1.04159396e-02f, -1.95204690e-01f, 1.88059062e-01f, -1.06711783e-01f, -4.86230329e-02f,
  -3.61023724e-01f, 2.66978413e-01f, 1.43223315e-01f, 8.61968845e-02f, -2.95527697e-01f, 2.45681480e-01f, -1.38804212e-01f, 2.51293033e-01f, -8.26652497e-02f, -1.00904241e-01f,
  6.32435009e-02f, 8.42727199e-02f, 1.35323495e-01f, 4.29272391e-02f, 3.99317853e-02f, -4.15889248e-02f, -2.63389498e-02f, 7.88352787e-02f, -5.88284098e-02f, 8.35501179e-02f,
  1.52908817e-01f, -6.00200891e-02f, 1.88025355e-01f, -8.01703334e-02f, 3.83899634e-04f, -1.85408309e-01f, -3.82704176e-02f, 2.82919686e-02f, -2.55019993e-01f, 2.42462065e-02f,
  1.58075809e-01f, 6.98585212e-02f, -2.02724561e-02f, -1.72031045e-01f, 1.56263724e-01f, 4.65389341e-02f, -2.67835498e-01f, 2.68399835e-01f, -1.81886867e-01f, 6.75249100e-02f,
  2.57859439e-01f, 3.58296894e-02f, 2.58750916e-01f, -1.47111779e-02f, -1.50879860e-01f, 1.98596895e-01f, 9.14078206e-02f, -1.98270783e-01f, 1.74028382e-01f, 4.13418701e-03f,
  -3.11723918e-01f, -2.83783644e-01f, 1.25918865e-01f, -8.03878456e-02f, -4.89096671e-01f, 2.15189338e-01f, -2.52457082e-01f, 1.27550185e-01f, 1.27678320e-01f, 4.23659943e-02f,
  -1.06076203e-01f, 4.24270257e-02f, -1.78286150e-01f, -2.21368253e-01f, 7.33816251e-02f, -1.24144249e-01f, -4.94462624e-03f, 6.55461773e-02f, 1.65201396e-01f, -4.88052368e-02f,
  1.39647096e-01f, 4.68515903e-02f, 8.24285597e-02f, -7.87311047e-02f, -1.49667442e-01f, 7.26959705e-02f, 8.58695954e-02f, -5.34890555e-02f, -3.99945192e-02f, -3.59503962e-02f,
  3.81706320e-02f, -6.74967282e-03f, 1.56852752e-01f, 2.51415316e-02f, 8.96554738e-02f, 1.74163595e-01f, -1.24025181e-01f, -1.15090750e-01f, 1.87716767e-01f, -2.05563352e-01f,
  1.51006714e-01f, 7.15164840e-02f, -2.84361150e-02f, -6.60561100e-02f, -6.58435300e-02f, -3.42593268e-02f, -7.12174475e-02f, 1.92735523e-01f, -2.08819479e-01f, 2.35891849e-01f,
  1.19915515e-01f, -1.96359277e-01f, 4.86023501e-02f, 2.33644605e-01f, -1.46707669e-01f, -1.33111075e-01f, -3.14589500e-01f, -1.78150445e-01f, -1.74723521e-01f, -1.70863897e-01f,
  -2.61184931e-01f, 1.20734029e-01f, -2.13617474e-01f, -3.18051539e-02f, 7.18395859e-02f, 2.84480840e-01f, -1.49262533e-01f, -1.54087901e-01f, -4.20582667e-02f, -1.10713378e-01f,
  2.59989619e-01f, -1.84004724e-01f, -9.54184309e-02f, 1.91822514e-01f, -3.41719277e-02f, -1.07466333e-01f, 3.22557986e-01f, -1.07566997e-01f, -1.70857579e-01f, -5.70806637e-02f,
  7.35570118e-02f, -4.12865635e-03f, -3.77834141e-02f, -7.06974566e-02f, -8.79741982e-02f, -8.61007869e-02f, -1.60252843e-02f, -1.47712663e-01f, -1.14869654e-01f, -8.27911124e-03f,
  -1.59306183e-01f, -1.66439265e-01f, -1.10443942e-01f, -6.89889342e-02f, 7.62180686e-02f, 1.06981218e-01f, 3.91000882e-02f, -3.03353695e-03f, -1.31934896e-01f, -2.34628379e-01f,
  9.68206972e-02f, 2.16177136e-01f, -3.18841897e-02f, 3.25896069e-02f, 3.07334159e-02f, 3.44460122e-02f, 8.81563053e-02f, -2.30468288e-02f, -1.17178239e-01f, 1.46281794e-02f,
  1.84533030e-01f, -2.85208493e-01f, 1.58217981e-01f, -1.59690678e-01f, -4.11978900e-01f, -2.56381601e-01f, 1.97638124e-01f, -2.32571334e-01f, 1.35160416e-01f, -2.05613047e-01f,
  5.32701053e-02f, -5.12729138e-02f, 1.97082072e-01f, -3.40875059e-01f, -1.56864405e-01f, -3.09654057e-01f, -9.54887569e-02f, 1.87155383e-03f, -2.99305409e-01f, -1.00311548e-01f,
  1.67716101e-01f, 2.91263252e-01f, -9.28657651e-02f, -2.89135203e-02f, 8.02901834e-02f, 4.55547832e-02f, -2.80707508e-01f, -2.31903791e-01f, -1.26078604e-02f, 7.79029280e-02f,
  2.49467697e-02f, 1.16062246e-01f, -4.23574299e-02f, 3.20333540e-02f, 4.36548479e-02f, -2.11523086e-01f, -1.08534016e-01f, -9.02885199e-02f, 6.63257837e-02f, 1.35926113e-01f,
  -8.57791901e-02f, -4.95888712e-03f, 6.48443028e-02f, 1.36584133e-01f, -5.75509155e-04f, 6.57926574e-02f, -1.73769984e-02f, -4.31860723e-02f, -7.00730011e-02f, -9.86179784e-02f,
  -1.22079372e-01f, 1.01779044e-01f, 1.26281187e-01f, -1.82861343e-01f, -1.60581425e-01f, 9.72453598e-03f, 1.03214458e-01f, -1.68644398e-01f, 8.27979669e-02f, 1.87397912e-01f,
  -1.24037363e-01f, 9.82889831e-02f, 1.38464704e-01f, -1.46497965e-01f, -9.98899564e-02f, -1.25983760e-01f, -1.63980946e-01f, 2.09641039e-01f, 1.59965664e-01f, 2.31226236e-01f,
  1.17842481e-01f, -5.38262390e-02f, -2.97793776e-01f, 1.90700471e-01f, -5.14292456e-02f, 7.96540529e-02f, -1.76919997e-01f, 1.79496199e-01f, 1.95300788e-01f, 7.07133263e-02f,
  1.49753928e-01f, 9.95503366e-03f, 1.54335067e-01f, -2.71212310e-01f, -1.33181037e-02f, -1.46743953e-01f, -4.84453216e-02f, -2.48319935e-02f, 5.28569110e-02f, 1.80373907e-01f,
  1.29339039e-01f, 1.44071147e-01f, -8.18234403e-03f, -3.62434685e-01f, 2.72158924e-02f, -3.67044508e-01f, 9.70076919e-02f, -2.23645687e-01f, -2.33398989e-01f, 3.24649811e-02f,
  -9.56531763e-02f, -1.50062665e-01f, -1.24257833e-01f, -1.73464760e-01f, 4.29230975e-03f, 8.91321674e-02f, 4.67100032e-02f, -1.36921570e-01f, 1.88380897e-01f, -2.04644650e-02f,
  2.23146360e-02f, 9.05127823e-03f, -7.86460564e-03f, 2.98625156e-02f, -1.14349656e-01f, 2.05056239e-02f, 1.13506429e-01f, -1.72203258e-01f, -5.19347526e-02f, 4.24281601e-03f,
  6.48360420e-03f, -1.78489625e-01f, -8.29773769e-02f, 1.84968486e-01f, -4.80683260e-02f, -1.25833750e-01f, 2.01495454e-01f, -1.02831468e-01f, -1.17544591e-01f, 2.05114529e-01f,
  1.10285701e-02f, -1.08674746e-02f, -8.99727121e-02f, -1.36409342e-01f, -2.14275807e-01f, 2.40108632e-02f, -3.29156458e-01f, 1.40534148e-01f, 1.36607468e-01f, -4.95664738e-02f,
  -1.42712653e-01f, -1.50967538e-01f, 1.25526488e-01f, 1.98661909e-01f, -4.78316471e-02f, 2.59538561e-01f, -1.34008482e-01f, -2.87289023e-01f, -1.44102648e-01f, -4.16132569e-01f,
  -1.12099759e-01f, 1.02832362e-01f, 1.18114226e-01f, -9.95792598e-02f, -8.64433944e-02f, 1.30171567e-01f, 2.76364684e-01f, -1.69846460e-01f, -2.43385777e-01f, -6.06833510e-02f,
  -1.51990473e-01f, -9.53613594e-02f, 3.55812684e-02f, 2.23020643e-01f, 1.36754476e-02f, 6.85117990e-02f, 3.63464318e-02f, 1.87461987e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.23670381e-02f, -2.65811756e-02f, -9.36949179e-02f, 7.93818980e-02f, 7.24539831e-02f, -6.08907603e-02f, -5.89034185e-02f, -5.43167628e-02f, -1.65955015e-02f, 8.07046667e-02f,
  6.49658889e-02f, -8.66579190e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    