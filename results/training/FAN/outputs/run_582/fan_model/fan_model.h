/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.01691800e-01f, -3.06363791e-01f, -4.41775501e-01f, -1.66214183e-01f, -4.70871013e-03f, 1.38270274e-01f, -1.70296893e-01f, 1.15693659e-01f, 1.14537969e-01f, -2.48970345e-01f,
  1.17015094e-01f, 1.74862951e-01f, 8.77695158e-02f, 1.27674803e-01f, 6.66779429e-02f, -3.47940832e-01f, -2.72224963e-01f, -1.53679907e-01f, 1.96512967e-01f, 1.42778710e-01f,
  3.33866514e-02f, -3.03148944e-02f, 1.86698765e-01f, 3.78445792e-03f, -2.26233035e-01f, -8.51487517e-02f, -2.95178574e-02f, 1.55374948e-02f, -3.04412544e-02f, -6.15385771e-01f,
  -3.95176411e-01f, -1.03422634e-01f, 4.79871370e-02f, 9.93223414e-02f, 3.63569930e-02f, -2.74362359e-02f, 5.89705184e-02f, 9.57490690e-03f, 1.14155307e-01f, -1.15261320e-02f,
  7.62662143e-02f, 4.70248088e-02f, 8.27144980e-02f, 6.90828136e-04f, 3.16550769e-02f, 3.45769860e-02f, 2.43546087e-02f, 8.52448121e-03f, -7.27125183e-02f, -7.02579021e-02f,
  -1.00296512e-01f, 5.57032935e-02f, -3.64380926e-02f, -1.12412591e-03f, 5.73883392e-02f, 6.34125620e-02f, -3.14595401e-02f, 5.44906221e-03f, 1.70899466e-01f, -1.73431292e-01f,
  1.48883900e-02f, -5.89961000e-02f, 3.57623883e-02f, -1.19234035e-02f, 5.37165776e-02f, 1.13754449e-02f, -6.23954199e-02f, -2.52333656e-02f, -2.80121956e-02f, -3.19751119e-03f,
  -5.37731238e-02f, -1.32555962e-02f, -4.25416529e-02f, -6.54229848e-03f, -1.23718902e-01f, -9.70631540e-02f, -2.20400225e-02f, -3.16951312e-02f, -5.85934557e-02f, -6.56367745e-04f,
  3.20900939e-02f, 2.67286170e-02f, -3.33095118e-02f, -6.64636418e-02f, -3.19371410e-02f, -3.87592912e-02f, -1.38253039e-02f, 1.87227279e-02f, 9.72813591e-02f, 6.90869540e-02f,
  1.81073353e-01f, 1.68135226e-01f, -1.92618951e-01f, -1.48346163e-02f, -6.22908026e-02f, 5.51382974e-02f, -1.39630988e-01f, -4.33208495e-02f, 3.56472805e-02f, -1.11579206e-02f,
  6.25401288e-02f, 4.68171462e-02f, -7.09374696e-02f, -1.28031680e-02f, 3.64546627e-02f, 3.75437737e-02f, 6.13822639e-02f, -6.62511885e-02f, 8.50191414e-02f, -3.43483798e-02f,
  2.57518776e-02f, 4.03854549e-02f, 1.57457516e-01f, 2.76192487e-03f, 7.45993331e-02f, 1.14809297e-01f, -6.45298138e-02f, 2.25392487e-02f, 2.04734951e-01f, -9.57085416e-02f,
  1.52112946e-01f, 1.36229664e-01f, -1.99921876e-01f, 3.98752093e-01f, 1.83145806e-01f, -8.58139992e-02f, -3.50883007e-02f, -5.44395819e-02f, 2.50665635e-01f, 2.11808532e-01f,
  -2.85763562e-01f, -1.13977775e-01f, -3.12583268e-01f, -2.85824984e-01f, -3.50606710e-01f, 1.41015798e-01f, 2.11581469e-01f, -2.13811815e-01f, -2.07772836e-01f, 6.66593909e-02f,
  3.45679641e-01f, 3.49644959e-01f, -1.02942422e-01f, -1.13128513e-01f, 4.04707432e-01f, 3.11825544e-01f, 1.55533642e-01f, 9.94916633e-02f, -1.10833876e-01f, 6.55435383e-01f,
  4.68999557e-02f, -1.31302193e-01f, 1.35114435e-02f, -2.69925930e-02f, 3.41898017e-02f, 7.14992508e-02f, 3.93608324e-02f, 1.18989137e-03f, -3.51981958e-04f, 1.34027228e-01f,
  9.33626667e-03f, 1.48190642e-02f, -1.07601061e-02f, 5.03360555e-02f, 3.09372656e-02f, 1.21551663e-01f, -1.06256276e-01f, -9.72892791e-02f, -1.14474177e-01f, -6.11930117e-02f,
  -3.39627825e-02f, -6.58722743e-02f, -1.37147769e-01f, -3.75748947e-02f, -2.19326153e-01f, -1.63484275e-01f, -1.58821106e-01f, -1.16986372e-01f, -2.73186624e-01f, 3.79069924e-01f,
  8.90341625e-02f, 9.34406463e-03f, -4.10359465e-02f, -1.67775284e-02f, -1.80810578e-02f, -6.99319551e-03f, -9.05604288e-03f, 1.62202138e-02f, -3.71270590e-02f, 2.56264042e-02f,
  -9.70648006e-02f, 8.48413631e-03f, -1.71542242e-02f, 1.82022508e-02f, -6.95290556e-03f, -4.40432839e-02f, -7.88304769e-03f, 2.90203257e-03f, -1.79043822e-02f, 8.54903311e-02f,
  -3.07393912e-02f, -5.72962649e-02f, -2.11017691e-02f, -2.00135410e-02f, -9.30709913e-02f, -8.53697062e-02f, -6.13542739e-03f, -9.86599848e-02f, -9.13103297e-02f, -6.44037798e-02f,
  2.60826617e-01f, -2.59094924e-01f, 2.52892733e-01f, -2.62603182e-02f, 1.09638959e-01f, -6.75241556e-03f, 8.81802216e-02f, -1.41977314e-02f, -2.75630737e-03f, -1.32986549e-02f,
  -8.78385603e-02f, -6.32216185e-02f, 4.16213423e-02f, 1.63742490e-02f, 1.19854487e-01f, 3.17621417e-02f, 1.35390550e-01f, 1.05259024e-01f, 3.87842022e-02f, 4.41647545e-02f,
  4.03136164e-02f, 1.40743911e-01f, 1.83531851e-01f, 1.21508986e-01f, 3.81704196e-02f, 8.31877291e-02f, 1.75959125e-01f, 1.91587776e-01f, 8.56030919e-03f, 4.66538042e-01f,
  -8.95070851e-01f, -4.81171399e-01f, 5.93088232e-02f, -1.18839689e-01f, 2.42816731e-01f, -7.68342465e-02f, -5.03217459e-01f, -3.35909754e-01f, -3.58707942e-02f, -1.26476035e-01f,
  2.29465842e-01f, 4.75067228e-01f, 1.31785497e-01f, 2.60992825e-01f, -8.17009155e-03f, -2.33431444e-01f, -6.69714287e-02f, 1.25898838e-01f, 3.11787575e-01f, 2.66017109e-01f,
  9.07217190e-02f, -1.20577119e-01f, -8.82745013e-02f, -3.33851837e-02f, -1.30858719e-01f, 1.39427125e-01f, -1.90119475e-01f, -6.08918928e-02f, 4.28265333e-02f, 5.84569871e-02f,
  1.86701283e-01f, -2.87768036e-01f, 2.65599966e-01f, 1.39683992e-01f, 1.73938990e-01f, -1.17923012e-02f, 3.90987135e-02f, 1.04915276e-01f, 3.83595526e-02f, 9.42279492e-03f,
  1.62304312e-01f, 5.79117537e-02f, 1.71001092e-01f, 1.13674544e-01f, -5.77344783e-02f, 1.40370941e-02f, -4.15733941e-02f, 4.91847098e-02f, 8.19961652e-02f, 5.01849763e-02f,
  2.05781579e-01f, 4.81628031e-02f, -1.15205850e-02f, 9.35836285e-02f, 2.13626418e-02f, 1.09525681e-01f, 2.67221946e-02f, 4.27042283e-02f, -1.11133128e-03f, -1.19765244e-01f,
  3.70430131e-03f, -1.39919877e-01f, -1.14831999e-01f, -6.68607652e-02f, -4.89005111e-02f, 2.84893308e-02f, -8.35321564e-03f, -8.79113674e-02f, -8.65521654e-03f, -1.07396327e-01f,
  -2.63319835e-02f, 6.79134857e-04f, -1.25371600e-02f, -6.79400042e-02f, 1.02954783e-01f, -1.52156651e-01f, -1.02991082e-01f, -1.23070724e-01f, 6.08266294e-02f, -1.03422984e-01f,
  -1.84829254e-02f, -1.71904657e-02f, -4.71304730e-02f, -8.85167494e-02f, -4.63381074e-02f, -1.22905008e-01f, -6.20225854e-02f, -6.39057392e-03f, -1.39608949e-01f, -1.53892562e-01f,
  7.65815899e-02f, 2.67459482e-01f, 5.21798804e-02f, -1.07278693e-02f, 6.84972405e-02f, 7.82589391e-02f, 1.40582651e-01f, 1.25866592e-01f, 1.19158417e-01f, -2.79216538e-03f,
  8.58213753e-02f, -2.44776569e-02f, 7.10280165e-02f, 8.89178291e-02f, 1.61870942e-01f, 3.83894928e-02f, 5.51915281e-02f, 8.00670981e-02f, 1.89317822e-01f, 1.94711238e-02f,
  -9.67986975e-03f, -4.14345115e-02f, -5.06164692e-02f, -7.25278854e-02f, 4.90042046e-02f, 2.94464012e-03f, 1.15491152e-01f, 7.94545189e-02f, -7.21291825e-02f, -1.45342469e-01f,
  7.86012173e-01f, 9.26380828e-02f, -3.17016765e-02f, 3.55610460e-01f, 3.45638692e-01f, 2.19355077e-01f, 1.56509131e-01f, 2.38272101e-02f, 1.12914115e-01f, 1.06196821e-01f,
  7.82511160e-02f, -3.43659855e-02f, -3.43347192e-01f, -2.52350599e-01f, -5.30403517e-02f, 2.01952010e-02f, -6.91136494e-02f, -4.29410897e-02f, 1.64852679e-01f, 4.65425730e-01f,
  2.28592187e-01f, 2.69497514e-01f, 1.94865167e-01f, -1.58980966e-01f, 2.00500816e-01f, -7.62363672e-02f, -2.72427469e-01f, 2.33756810e-01f, -1.59194767e-02f, 2.51170635e-01f,
  1.41846955e-01f, 2.61988580e-01f, -2.75071375e-02f, 8.56909156e-02f, 1.18571050e-01f, 3.59686054e-02f, 1.40442982e-01f, 2.28709932e-02f, 1.64484512e-02f, 6.72461614e-02f,
  1.25354841e-01f, 1.00456782e-01f, 7.72306994e-02f, 8.87671039e-02f, 1.51418939e-01f, 1.31518513e-01f, -8.16782564e-02f, -1.24107301e-02f, 7.07929442e-03f, 3.77057046e-02f,
  1.89825147e-01f, 4.30672348e-01f, 2.43683413e-01f, -6.82353377e-02f, 2.16136687e-02f, 6.85714511e-03f, 3.27835493e-02f, 1.57566890e-01f, -1.17654897e-01f, 1.42707229e-01f,
  6.66872784e-02f, -9.49549116e-03f, 3.43804993e-02f, -2.35818807e-04f, -2.04135180e-02f, 1.49505679e-02f, -4.48985100e-02f, 8.73997528e-03f, -8.79594684e-03f, 4.86641824e-02f,
  -3.98937091e-02f, 2.41719652e-02f, -2.29443912e-03f, 6.63699582e-02f, -8.06546584e-02f, 7.07205459e-02f, 7.72164240e-02f, -6.14992268e-02f, -3.14110033e-02f, 8.03025812e-02f,
  2.38067079e-02f, 7.17478171e-02f, -2.45771836e-02f, -5.82173280e-02f, 1.11241238e-02f, -2.34122444e-02f, 1.31315678e-01f, -7.12012034e-03f, 3.54409814e-02f, 1.23687617e-01f,
  -7.83217847e-02f, -1.71845973e-01f, 8.14327970e-02f, 5.36459172e-03f, 1.55082583e-01f, 2.78131850e-02f, 2.81009097e-02f, 7.77399465e-02f, -8.80876556e-03f, 3.16932984e-02f,
  7.29600042e-02f, 4.50789817e-02f, 2.40384880e-02f, 4.96779121e-02f, 1.16809912e-01f, 1.11819975e-01f, 6.31106272e-02f, 3.68355885e-02f, 7.87969977e-02f, 1.83148265e-01f,
  1.82447415e-02f, 1.21300310e-01f, 2.40788817e-01f, 3.08035035e-02f, 1.35626733e-01f, 7.02363476e-02f, -7.79364929e-02f, 1.10603377e-01f, 4.07070369e-02f, -1.32000968e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.07649517e-01f, -1.03062487e+00f, 8.62640083e-01f, -1.06620514e+00f, -4.33314778e-02f, 6.26895845e-01f, 6.40263617e-01f, -4.78380084e-01f, -8.18527400e-01f, 2.14232821e-02f,
  -1.67707816e-01f, 7.78713748e-02f, -2.94372439e-01f, -1.93402991e-01f, 1.66831821e-01f, 3.75731826e-01f, -3.07843864e-01f, 1.40618309e-01f, 1.01729596e+00f, 6.83489382e-01f,
  -8.63391832e-02f, -5.64506471e-01f, -4.98321265e-01f, -1.84238795e-02f, -5.15198529e-01f, 2.28407860e-01f, -4.35468197e-01f, -6.93794787e-01f, -8.62961821e-03f, -9.49829161e-01f,
  9.43122685e-01f, -7.96812952e-01f, 1.18915707e-01f, -3.38825434e-01f, -1.13004580e-01f, 8.16661566e-02f, 3.07622284e-01f, -3.20389748e-01f, 1.27906308e-01f, -8.47667381e-02f,
  -3.65629852e-01f, -1.36148989e-01f, -7.26946145e-02f, -8.19589496e-02f, 8.80490392e-02f, 7.77306780e-02f, -4.31504548e-01f, -3.85722250e-01f, -3.46155614e-01f, 2.28720065e-02f,
  -1.61023453e-01f, -8.65547657e-02f, 4.71100733e-02f, -2.24396195e-02f, -9.72119719e-02f, 5.00489026e-02f, -9.55879688e-02f, -8.43523294e-02f, -1.07372753e-01f, -1.82486862e-01f,
  2.07766443e-01f, 3.88027549e-01f, 1.54504448e-01f, -1.96439683e-01f, 4.27908637e-02f, 1.21614232e-03f, 2.81247646e-02f, 1.31236047e-01f, 7.87803531e-02f, -3.28651257e-02f,
  5.46641313e-02f, 1.26451716e-01f, -5.94440885e-02f, 3.70656624e-02f, 8.29734206e-02f, -1.46769941e-01f, 2.53899872e-01f, 9.22600680e-04f, -2.63170954e-02f, -7.48616233e-02f,
  -2.54925221e-01f, -6.17703013e-02f, -6.35735989e-02f, 3.11712194e-02f, -2.26184711e-01f, -1.18823782e-01f, -5.84048666e-02f, -1.81283876e-02f, -4.81263436e-02f, -1.13438956e-01f,
  1.02779120e-01f, 2.24424712e-02f, 3.11687887e-01f, -5.76816648e-02f, -2.21697614e-02f, -1.76568791e-01f, -2.27365822e-01f, 5.22789359e-02f, -2.42293268e-01f, -1.00277841e-01f,
  -2.46708781e-01f, -1.81875303e-02f, 6.60329834e-02f, -6.11291304e-02f, 4.40834463e-01f, -2.01867130e-02f, -2.33402714e-01f, -2.18732748e-02f, -5.36000133e-02f, 7.69665018e-02f,
  -2.28865609e-01f, 2.31398761e-01f, 4.18391913e-01f, 2.41988182e-01f, -9.39095691e-02f, 3.92917126e-01f, 4.19570595e-01f, 2.99346060e-01f, 3.98274064e-01f, 5.12161195e-01f,
  -9.79474962e-01f, 6.62225902e-01f, 3.69922578e-01f, -8.94387960e-01f, 3.31969373e-02f, 5.37843287e-01f, 9.78614271e-01f, 6.51113465e-02f, -5.58913469e-01f, -9.70834494e-02f,
  -3.41135442e-01f, -5.62537611e-01f, -4.91467327e-01f, 1.13091946e-01f, 3.19907606e-01f, 5.38141727e-01f, 4.64766681e-01f, 4.77237433e-01f, 1.01042725e-01f, 2.52010852e-01f,
  3.60582054e-01f, -4.02202196e-02f, -1.88882262e-01f, 5.79608679e-02f, -2.19953701e-01f, -3.15853179e-01f, -1.10572428e-01f, -1.64907753e-01f, 5.13576925e-01f, 3.89500856e-01f,
  -3.73829603e-01f, 1.70527045e-02f, -2.05579355e-01f, -2.22854614e-01f, 1.19846582e-01f, -4.72333059e-02f, -1.64535239e-01f, -1.37145832e-01f, -2.33083427e-01f, -6.22147359e-02f,
  -1.39420986e-01f, 4.19283733e-02f, -2.31906027e-01f, 2.24610925e-01f, -7.61377364e-02f, 3.19490321e-02f, 1.84686139e-01f, 1.85275301e-01f, 1.84824169e-01f, 1.94949552e-01f,
  2.60858059e-01f, 1.25267699e-01f, 6.81854188e-02f, 2.09460571e-01f, 3.83473784e-01f, -2.15860978e-01f, 7.98552185e-02f, 8.60313475e-02f, 2.97027938e-02f, -4.06312138e-01f,
  -9.46528167e-02f, -9.93026071e-04f, 1.50927007e-01f, -9.29676443e-02f, 1.91577487e-02f, -6.33255988e-02f, -1.22338027e-01f, -8.20738380e-04f, 1.39141038e-01f, -4.82002385e-02f,
  1.98880926e-01f, -1.59975946e-01f, 1.45618990e-01f, -1.98798686e-01f, -2.68962830e-01f, 8.88372585e-02f, 1.85728088e-01f, -1.35307284e-02f, 1.18539162e-01f, 3.06853410e-02f,
  2.10418086e-02f, 3.82271297e-02f, -3.01468641e-01f, 2.41964713e-01f, 1.78989977e-01f, -4.09635343e-02f, -1.15058884e-01f, 5.12286695e-03f, -2.07096919e-01f, 4.40189755e-03f,
  -9.92100716e-01f, 7.21404672e-01f, -4.13955212e-01f, 3.59149985e-02f, -1.38978623e-02f, 2.09878162e-02f, -2.21730158e-01f, 5.51296398e-02f, -1.30841687e-01f, 5.07675111e-02f,
  1.08145863e-01f, -1.48692563e-01f, -2.40501277e-02f, 2.16459423e-01f, -1.58901244e-01f, -3.28345478e-01f, 1.42950177e-01f, -2.18309894e-01f, 1.97840825e-01f, -3.80811282e-02f,
  1.91890061e-01f, -1.54726163e-01f, -5.32257855e-01f, -3.07875067e-01f, -3.29539180e-01f, -7.55788803e-01f, -3.38666886e-01f, -4.40034300e-01f, -2.37463251e-01f, -7.70365834e-01f,
  -5.38775086e-01f, -7.09975362e-01f, -6.69494867e-01f, 2.40956575e-01f, 7.94485137e-02f, -5.62312901e-01f, -1.63240719e+00f, -6.62367940e-01f, 2.56067842e-01f, -7.80827343e-01f,
  -3.02118286e-02f, 6.44916892e-01f, -1.04588218e-01f, 2.50279278e-01f, -5.05476952e-01f, -9.19608235e-01f, -4.22764421e-01f, 1.22319395e-02f, 6.07468724e-01f, 6.39005899e-01f,
  6.46709740e-01f, 6.34925961e-01f, 4.22266245e-01f, 4.06728148e-01f, 4.85025883e-01f, 5.13518751e-01f, -3.52328688e-01f, 3.91680062e-01f, -1.08396731e-01f, 3.51744354e-01f,
  -2.07321599e-01f, -2.82706738e-01f, 8.44509155e-02f, 1.73823625e-01f, 2.78325677e-01f, -2.96273947e-01f, -4.84207869e-01f, 3.57578583e-02f, -3.88132893e-02f, -1.38634384e-01f,
  1.53095126e-01f, 6.77243099e-02f, 2.20231533e-01f, 1.97667833e-02f, 1.98002875e-01f, -2.89343148e-01f, 5.44941537e-02f, -4.01444882e-01f, -3.97355527e-01f, -4.77845483e-02f,
  6.05888844e-01f, 4.33582813e-01f, -4.88882452e-01f, -3.83805513e-01f, -2.23703787e-01f, 2.57202119e-01f, -2.68571824e-01f, 2.59337932e-01f, -4.01996553e-01f, -4.79254395e-01f,
  4.92308140e-02f, 1.46423608e-01f, -3.32944691e-02f, 2.93905213e-02f, -8.53898153e-02f, 8.54095221e-02f, -9.98410210e-02f, 1.61897857e-02f, 1.10864341e-01f, -1.83997788e-02f,
  1.45682722e-01f, 1.45720631e-01f, 8.95155519e-02f, -1.81469351e-01f, -2.21069367e-03f, 9.32023898e-02f, 2.40983516e-01f, 4.52628732e-02f, -5.78428805e-02f, -1.08279757e-01f,
  4.84365895e-02f, -9.70757976e-02f, 3.39663535e-01f, 8.24050903e-02f, -9.02483612e-02f, -4.22118902e-02f, 2.69302994e-01f, 1.22781143e-01f, 4.34065945e-02f, -3.59805286e-01f,
  -1.44278795e-01f, 2.75304645e-01f, -3.77705723e-01f, -1.97161809e-01f, -1.04306467e-01f, 2.96192527e-01f, -3.54743823e-02f, -1.52568547e-02f, -6.36538863e-02f, -1.78935781e-01f,
  -1.22343503e-01f, -1.74587682e-01f, -1.46506011e-01f, 1.61737084e-01f, -9.47005451e-02f, -1.86822861e-01f, -6.24774061e-02f, -2.58632630e-01f, -8.09557177e-03f, -1.22415684e-01f,
  -2.09605277e-01f, -3.95973861e-01f, -6.41578734e-01f, -7.37998366e-01f, 8.22504088e-02f, -5.30693948e-01f, -5.22952139e-01f, -2.94273943e-01f, -9.79316354e-01f, -1.55027378e+00f,
  7.59615302e-01f, 6.61316216e-01f, -7.04817176e-01f, 4.93762285e-01f, -4.63257879e-01f, -7.11788476e-01f, -3.90673429e-01f, -1.91931486e-01f, 1.20387077e-01f, 2.41743386e-01f,
  -1.14064608e-02f, 3.41054827e-01f, 3.28460187e-01f, 2.22248673e-01f, 1.03552036e-01f, 1.84593305e-01f, 6.93069771e-02f, -2.38691992e-03f, -5.11955917e-01f, -2.35063806e-01f,
  3.95209223e-01f, 4.69095945e-01f, 2.46820509e-01f, -3.96083444e-02f, 1.90520078e-01f, 1.98971331e-01f, -2.52158418e-02f, -1.31295338e-01f, -5.62715679e-02f, 5.76744795e-01f,
  -4.04503904e-02f, -2.28121951e-01f, -2.85560396e-02f, 2.91203499e-01f, -1.20340183e-01f, 1.63100675e-01f, 5.67106307e-02f, 6.95508718e-02f, 1.73620999e-01f, 2.40263909e-01f,
  -1.45644015e-02f, -1.47622526e-01f, 1.59695428e-02f, -2.08684877e-01f, -9.95076150e-02f, -1.81857765e-01f, -7.17175826e-02f, 2.61541866e-02f, -1.81916971e-02f, -8.01021606e-02f,
  1.73353642e-01f, -2.49862537e-01f, -4.97622281e-01f, -1.85566276e-01f, -3.26009184e-01f, -4.33184281e-02f, -2.43768722e-01f, -2.76347160e-01f, -3.58802289e-01f, 2.09034592e-01f,
  1.87766165e-01f, 8.99131596e-02f, -1.56931281e-01f, -1.24713160e-01f, 6.37003183e-02f, 9.50646326e-02f, -1.05411680e-02f, 9.65876654e-02f, -4.99457233e-02f, 1.11296028e-02f,
  4.20067236e-02f, 7.06599653e-03f, -1.47360608e-01f, 9.84495580e-02f, 6.22287765e-02f, -1.30243734e-01f, -1.19370557e-01f, 1.43401809e-02f, -3.74645889e-02f, 8.13908875e-02f,
  2.15282924e-02f, -6.94202110e-02f, -3.45554762e-02f, -8.84191394e-02f, -1.67749375e-02f, -5.78751676e-02f, -6.23369664e-02f, -9.73796919e-02f, 9.06606615e-02f, 5.41155301e-02f,
  5.69931567e-01f, -3.95466983e-01f, 2.52903968e-01f, -1.09017357e-01f, -1.92976277e-02f, -5.92571013e-02f, 7.24850409e-03f, 4.77211177e-02f, 7.03187212e-02f, 6.87024072e-02f,
  -1.32647306e-01f, -1.04668163e-01f, 6.80162534e-02f, -9.28434543e-03f, -3.56972516e-02f, -9.48389396e-02f, 1.88749745e-01f, 5.60729578e-02f, 3.63229029e-03f, -1.48738161e-01f,
  1.57944173e-01f, 7.73368254e-02f, 2.14426562e-01f, 1.48847178e-01f, 1.06718235e-01f, 1.36856377e-01f, -5.35557605e-02f, -8.51146802e-02f, -2.40621045e-01f, 5.15995383e-01f,
  1.99992204e+00f, -8.42257440e-02f, 1.10005252e-01f, 6.23471895e-03f, -6.39045477e-01f, -3.32113057e-01f, -5.18177524e-02f, 3.94028611e-02f, -1.00650564e-01f, -2.28197183e-02f,
  1.64438248e-01f, 1.50616884e-01f, 3.40026379e-01f, 2.91061938e-01f, 5.31256855e-01f, -1.07258126e-01f, -1.19723819e-01f, 4.52315897e-01f, 4.67849433e-01f, 1.16939753e-01f,
  -2.80196995e-01f, -9.70183909e-02f, 5.16311169e-01f, 2.19044909e-01f, -2.82895595e-01f, -1.52550533e-01f, -1.46873891e-01f, -1.04643777e-01f, -5.06943204e-02f, -2.50122994e-01f,
  -3.58264125e-03f, 5.30843377e-01f, -1.75788537e-01f, -5.78835681e-02f, -1.59382433e-01f, 8.32931325e-02f, -1.66260362e-01f, -1.26016796e-01f, -1.09491996e-01f, -2.03651354e-01f,
  -1.95649728e-01f, 1.80728119e-02f, 6.42849058e-02f, -3.09585724e-02f, 2.67710015e-02f, 9.30355042e-02f, 1.21922344e-01f, 2.76653856e-01f, 1.38958320e-01f, -3.47436182e-02f,
  -2.69683182e-01f, -1.99111365e-02f, 8.31751525e-02f, -3.54807638e-02f, 1.51397675e-01f, 2.26804074e-02f, -8.49281996e-02f, 5.92930429e-02f, 1.40468419e-01f, 7.72688165e-02f,
  -1.18302638e-02f, -3.14805545e-02f, 1.44789159e-01f, -1.72153134e-02f, 2.02512488e-01f, -1.26377821e-01f, 4.38434519e-02f, 3.01965009e-02f, 1.95591241e-01f, -8.44287723e-02f,
  -6.31011352e-02f, 2.85081595e-01f, 8.37408528e-02f, 8.01673979e-02f, -1.40380621e-01f, -4.07122672e-02f, -3.51064419e-03f, -3.52442302e-02f, 6.81800991e-02f, 7.21485615e-02f,
  1.97140083e-01f, -4.93746139e-02f, -3.34671214e-02f, 1.45544276e-01f, -3.11913788e-02f, 4.93525714e-02f, 3.73746306e-02f, -4.01049154e-03f, -1.61929071e-01f, -1.85256138e-01f,
  -5.36058545e-01f, 3.97821397e-01f, 1.14805788e-01f, 1.88175589e-01f, -2.19719455e-01f, -1.37240142e-01f, 1.45115247e-02f, -8.06300566e-02f, -2.64548153e-01f, -1.53891534e-01f,
  -1.22891396e-01f, 1.03814811e-01f, -4.91112508e-02f, 5.36172539e-02f, 1.04583062e-01f, -5.30902632e-02f, -3.07688881e-02f, -7.64503703e-03f, -1.30057141e-01f, -2.53503293e-01f,
  -2.02979416e-01f, -7.54019395e-02f, 7.81380758e-02f, 3.14513519e-02f, -1.49909630e-01f, 2.41825785e-02f, -1.82503119e-01f, -4.18403782e-02f, 1.82942003e-01f, -1.85323626e-01f,
  -3.06754708e-01f, -8.05231631e-01f, 2.35120863e-01f, 7.25118101e-01f, 1.04347384e+00f, 8.75196815e-01f, 5.45902729e-01f, 3.46651644e-01f, 3.13176632e-01f, 2.40863226e-02f,
  -4.17134672e-01f, -1.75019786e-01f, -1.93285957e-01f, -2.03622803e-01f, -1.82477385e-01f, 4.11052167e-01f, 6.27916157e-01f, 8.89012367e-02f, 1.90681219e-01f, 1.60835579e-01f,
  1.47858724e-01f, -7.95169763e-05f, -3.10991228e-01f, -5.18243238e-02f, 7.65693141e-03f, 1.52022213e-01f, 1.75517589e-01f, 2.87943687e-02f, -4.23351750e-02f, -1.41685843e-01f,
  -5.56444526e-01f, -1.08111404e-01f, 1.69058725e-01f, -1.34746075e-01f, -2.17445254e-01f, -5.15436232e-01f, -5.28514534e-02f, -3.68524969e-01f, -1.37417555e-01f, 8.84770378e-02f,
  -7.33382478e-02f, -1.12006530e-01f, 1.44327715e-01f, -1.45454835e-02f, 1.92305773e-01f, -8.60950723e-02f, -1.67473137e-01f, -1.67800099e-01f, 4.70945537e-02f, -1.95191383e-01f,
  -1.06064163e-01f, 1.06321752e-01f, 2.66959518e-01f, 1.49819821e-01f, -4.63774875e-02f, 2.11310983e-01f, -3.58715802e-01f, -1.87777951e-01f, -1.55460894e-01f, -3.23424518e-01f,
  9.04454514e-02f, -4.18578461e-02f, 3.83698642e-02f, -1.58841647e-02f, 5.48974089e-02f, 3.22205424e-02f, 1.74002707e-01f, 6.95857406e-02f, 9.18797329e-02f, -5.38845956e-02f,
  6.75387904e-02f, 1.74255773e-01f, 2.99881166e-03f, 4.55320850e-02f, 3.22770216e-02f, -5.43607920e-02f, -2.98860632e-02f, -1.37600778e-02f, -3.27472202e-02f, 2.43828431e-01f,
  -1.05317971e-02f, 6.87980875e-02f, -1.25052273e-01f, -9.43181515e-02f, 7.62915462e-02f, -4.84815426e-02f, -1.75357088e-02f, -2.76585966e-01f, 1.67566482e-02f, -1.74883120e-02f,
  8.03679898e-02f, 3.10872406e-01f, -8.22207192e-04f, -3.03486781e-03f, 3.78715433e-02f, -1.61676109e-01f, 1.52631059e-01f, -2.90043764e-02f, 7.09918290e-02f, 4.72691208e-02f,
  -9.33055431e-02f, -1.75189286e-01f, -1.47090256e-01f, -1.09839126e-01f, 1.91340372e-01f, 1.38369262e-01f, -1.08383283e-01f, 5.37098870e-02f, 7.65563501e-03f, -1.38704777e-01f,
  -2.12926582e-01f, 2.63413996e-01f, 3.24046135e-01f, 9.83357355e-02f, -6.45536277e-03f, 3.65485251e-01f, -7.96934869e-03f, 3.91833782e-02f, 2.14345738e-01f, -9.70675051e-02f,
  -1.97548658e-01f, 1.27082002e+00f, -1.15922713e+00f, 4.30977434e-01f, 1.95277482e-01f, -1.52456313e-01f, 4.31741059e-01f, 2.64754355e-01f, 3.73412549e-01f, 8.61319065e-01f,
  7.20438540e-01f, -3.77727181e-01f, -5.02781510e-01f, -4.96127546e-01f, -1.00330865e+00f, -1.39191851e-01f, -4.14939433e-01f, -1.87144184e+00f, -1.78925240e+00f, -2.56421149e-01f,
  1.55681819e-01f, -1.68410599e-01f, -5.44803321e-01f, -3.70018482e-01f, 6.06613398e-01f, -3.02982569e-01f, 3.34892362e-01f, 1.06666209e-02f, -9.49401110e-02f, -3.45222279e-02f,
  -7.44031549e-01f, 1.20344914e-01f, -3.15284640e-01f, 9.53044668e-02f, 1.78176180e-01f, -5.27643552e-03f, -2.42155626e-01f, -3.85996968e-01f, -3.97467390e-02f, -3.47768098e-01f,
  4.26573306e-02f, -1.81833982e-01f, -2.38643482e-01f, -1.34506077e-01f, -1.01118833e-01f, -1.92403615e-01f, -1.37367845e-01f, -5.38237214e-01f, -4.93119299e-01f, 1.15170710e-01f,
  4.12584364e-01f, -3.57143134e-01f, -7.15465307e-01f, 2.61607289e-01f, -1.26413941e-01f, -3.31982553e-01f, 3.74532372e-01f, -1.99938968e-01f, -4.77656573e-01f, 3.61913592e-01f,
  1.01778999e-01f, 2.48150929e-04f, 9.32866111e-02f, 9.62034389e-02f, 1.68240488e-01f, 1.10662252e-01f, -1.97593480e-01f, 2.01230869e-02f, 5.00557721e-02f, -4.47222367e-02f,
  3.35063189e-02f, 8.09088424e-02f, -1.26631437e-02f, 4.00667153e-02f, -1.30937755e-01f, 2.36553550e-02f, 1.55319450e-02f, 1.99340153e-02f, 1.19947949e-02f, 1.10056242e-02f,
  -1.42147452e-01f, -6.86468706e-02f, 4.66445610e-02f, -1.04854658e-01f, 1.60641119e-01f, -2.35598639e-01f, 9.82133020e-03f, 2.69175500e-01f, 4.33401912e-02f, -1.60842210e-01f,
  1.44877642e-01f, -4.60511744e-02f, -2.43571088e-01f, -2.69291073e-01f, -1.15933038e-01f, 2.95121758e-03f, 5.15394323e-02f, 1.67763650e-01f, -1.24090873e-01f, -1.95332572e-01f,
  -7.91736394e-02f, -2.04135597e-01f, 2.06668019e-01f, 2.49166474e-01f, -1.83395311e-01f, 3.45222093e-02f, 1.97770894e-01f, -9.58192945e-02f, -1.30182713e-01f, 1.95149437e-01f,
  2.10190788e-01f, -2.97145043e-02f, -2.75859147e-01f, 1.34359553e-01f, -4.67725359e-02f, -5.40653288e-01f, -2.31919467e-01f, -1.57339096e-01f, -4.08876538e-01f, 5.87719440e-01f,
  3.14053260e-02f, 4.36139107e-01f, 1.23486614e+00f, 5.32439053e-02f, 1.10092580e-01f, -3.05973321e-01f, -2.50525266e-01f, -4.61626858e-01f, -3.08583707e-01f, 1.88064143e-01f,
  4.61052686e-01f, -4.44755346e-01f, 2.10601483e-02f, -6.70574009e-01f, -6.35535538e-01f, 6.75332770e-02f, 1.67584375e-01f, 4.21956778e-02f, -8.85043859e-01f, -1.04610705e+00f,
  -1.12710571e+00f, -2.76089966e-01f, 1.86619133e-01f, 1.25801206e-01f, 5.18725395e-01f, -2.56941855e-01f, 9.85287428e-01f, 6.60101295e-01f, 4.95547593e-01f, 4.62173164e-01f,
  8.27043951e-01f, 7.06846952e-01f, -5.41661978e-01f, -2.19303936e-01f, 4.18764859e-01f, -2.90090024e-01f, -5.24063595e-02f, 2.16521725e-01f, 1.51925236e-02f, 2.05480695e-01f,
  -4.88835163e-02f, -9.84479859e-02f, 2.63264298e-01f, 6.89543858e-02f, 5.67393489e-02f, -3.68227601e-01f, 1.10909641e-01f, -9.68324542e-02f, 2.91163102e-02f, 1.87196478e-01f,
  -4.62153643e-01f, 1.24822907e-01f, 6.39796972e-01f, -5.15130349e-02f, 1.25791982e-01f, -3.30644459e-01f, 3.56550992e-01f, 2.72500869e-02f, 2.90402710e-01f, -1.09716635e-02f,
  -1.62584558e-02f, 1.66599438e-01f, 4.53139842e-02f, 3.31766158e-02f, -3.58955711e-01f, 1.25478372e-01f, 2.74922699e-02f, -9.09033045e-02f, -1.36081398e-01f, 6.27820054e-03f,
  2.00261474e-02f, 1.48891881e-01f, 1.51337634e-04f, -1.67317670e-02f, 1.49934471e-01f, 1.67243600e-01f, 5.37835015e-03f, 5.23222238e-02f, 1.00570217e-01f, 1.07096825e-02f,
  -1.12410612e-01f, -1.47977740e-01f, 1.37957782e-01f, -1.66381523e-01f, 2.51278281e-02f, 5.76025015e-03f, -2.05895095e-03f, 4.23649326e-02f, -1.35679096e-01f, -1.21626258e-03f,
  -3.52012962e-01f, -2.34263182e-01f, 2.32705977e-02f, -1.40142128e-01f, 1.57955155e-01f, 2.43784964e-01f, 1.15423322e-01f, 1.05594538e-01f, 2.92124093e-01f, -3.64542119e-02f,
  -1.41896933e-01f, 6.80759549e-02f, 2.31504992e-01f, 7.11010024e-02f, -4.25817490e-01f, 8.76547396e-03f, -1.32675350e-01f, -1.36121109e-01f, -2.23930597e-01f, 3.70550640e-02f,
  -8.60361084e-02f, -5.00289798e-01f, -7.79248536e-01f, -1.84294865e-01f, -1.59611627e-01f, -6.30514383e-01f, -2.11212814e-01f, -3.60619068e-01f, -7.20153272e-01f, -1.08060277e+00f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.81300890e+00f, 1.32986283e+00f, 8.02442789e-01f, 1.42786896e+00f, 1.44706869e+00f, 1.00128174e+00f, 1.55108047e+00f, 1.17964244e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.53471637e+00f, -3.98201346e-01f, -3.39748591e-01f, 5.42724967e-01f, 9.95966271e-02f, -3.33317250e-01f, 4.39907223e-01f, -4.17989586e-03f, -2.56829977e-01f, -4.25424457e-01f,
  1.16489315e+00f, -1.71646833e+00f, -6.92114949e-01f, -1.00876713e+00f, 5.56295872e-01f, -2.31907058e+00f, -1.06941068e+00f, 5.88104129e-01f, 2.98725873e-01f, 5.23823798e-01f,
  5.45333564e-01f, -7.36631036e-01f, 8.54310915e-02f, -3.32663625e-01f, -9.41641256e-02f, -1.40463316e+00f, -9.75439250e-01f, 3.17464650e-01f, 1.36588645e+00f, 5.32284267e-02f,
  -1.24694681e+00f, -1.11258781e+00f, 8.25970888e-01f, 3.71446043e-01f, 3.21796626e-01f, -1.84452415e-01f, 6.79699481e-01f, -8.75007212e-01f, 1.20387959e+00f, -1.30545318e+00f,
  -7.21450746e-01f, 1.48348555e-01f, 8.87826085e-01f, -7.54256308e-01f, 2.86691338e-02f, -7.59121418e-01f, -2.32894230e+00f, 2.89664860e-03f, 9.58148658e-01f, -8.08424950e-01f,
  -5.07762194e-01f, -1.42831832e-01f, 4.67362881e-01f, -4.12341803e-01f, 7.35695958e-01f, 2.78774779e-02f, 4.98620927e-01f, 1.30253577e+00f, -1.18161380e+00f, -2.23025751e+00f,
  -1.46166849e+00f, -4.21030611e-01f, 2.50898629e-01f, -4.38117325e-01f, 1.11310780e+00f, -1.44082084e-01f, -2.20853820e-01f, -3.56216997e-01f, 5.43662846e-01f, -3.60709995e-01f,
  -2.82245189e-01f, -8.35577309e-01f, -8.18325698e-01f, -1.71023154e+00f, 4.32124548e-02f, -8.57917726e-01f, -1.14893210e+00f, 1.88373506e-01f, 6.60144627e-01f, 8.50811124e-01f,
  6.86177254e-01f, -1.30079567e-01f, 2.26942077e-02f, 3.41383696e-01f, 7.84680665e-01f, 1.05242562e+00f, -8.63086879e-01f, 4.47825603e-02f, -5.50733507e-01f, -1.43331730e+00f,
  -3.03345263e-01f, 8.55464816e-01f, -1.98153183e-01f, -3.22588235e-01f, 8.56811166e-01f, -1.98761106e+00f, -7.36266196e-01f, 2.43185461e-01f, -7.64521420e-01f, 8.37869272e-02f,
  -5.22510827e-01f, 3.81786853e-01f, -1.18529224e+00f, 6.97729349e-01f, -1.57863259e+00f, 3.88124168e-01f, -5.44170916e-01f, 9.52378690e-01f, 7.16866851e-01f, -2.22453403e+00f,
  -2.13758469e+00f, 6.93512976e-01f, -5.23412585e-01f, 2.98068430e-02f, -1.46220088e-01f, 6.78545162e-02f, -1.49782002e-01f, 3.42264593e-01f, 1.80120423e-01f, -3.51869434e-01f,
  -1.31844330e+00f, 1.02385712e+00f, 7.12855393e-03f, 2.69729681e-02f, -1.54478347e+00f, 6.56758368e-01f, 2.30347410e-01f, -1.08607590e+00f, 3.59004796e-01f, -4.40626532e-01f,
  6.37562752e-01f, -8.02234590e-01f, 2.00935215e-01f, 7.26357520e-01f, -7.28466034e-01f, 8.18789959e-01f, 7.49344528e-01f, -4.13463041e-02f, -9.03366208e-01f, -1.20800829e+00f,
  -9.77444574e-02f, 7.11982906e-01f, -1.42920494e+00f, -7.39216328e-01f, -4.18549806e-01f, 2.73651481e-01f, 9.68144834e-01f, 4.01346385e-02f, -9.62300241e-01f, 1.06698525e+00f,
  7.02668309e-01f, 8.24596703e-01f, -2.24683142e+00f, -5.82834661e-01f, 1.01280284e+00f, 4.12733495e-01f, -6.95593119e-01f, -7.97116518e-01f, -2.64437616e-01f, 4.16936010e-01f,
  8.14535856e-01f, 3.87646586e-01f, -8.02046210e-02f, -2.61357009e-01f, -8.84330511e-01f, 5.11375487e-01f, 6.19028926e-01f, -8.48204911e-01f, 1.35589981e+00f, -8.72800648e-01f,
  -1.20586824e+00f, -6.89246416e-01f, -1.70686388e+00f, -1.15033448e+00f, -9.33204651e-01f, -3.86840254e-01f, 6.60200357e-01f, 6.41095638e-01f, -5.56991994e-01f, -6.85040414e-01f,
  -3.61570626e-01f, -9.31530058e-01f, -6.48816049e-01f, 5.22939682e-01f, -9.61788893e-01f, 6.31420135e-01f, -2.13260484e+00f, -1.24434566e+00f, 5.28018832e-01f, -8.50987285e-02f,
  -3.19815516e-01f, 1.09794116e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  7.73638844e-01f, 8.26299965e-01f, 3.80512655e-01f, -6.24446869e-01f, 6.11686289e-01f, -2.92331651e-02f, -3.83314073e-01f, -4.16295797e-01f, -7.72028327e-01f, -5.50608337e-01f,
  -7.88627803e-01f, 2.06762813e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    