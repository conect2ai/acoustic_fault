/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.46861807e-01f, -3.54126453e-01f, -1.46821633e-01f, -1.06516548e-01f, -2.52642065e-01f, -5.20922989e-02f, -3.20975155e-01f, 4.02704179e-02f, 2.12361086e-02f, -4.10022795e-01f,
  1.16965972e-01f, 2.73579955e-01f, 3.64307225e-01f, 2.10239932e-01f, 2.73569852e-01f, -3.92956197e-01f, -3.41549665e-01f, 1.81874290e-01f, 6.04092717e-01f, 2.18918219e-01f,
  1.45765468e-02f, -6.02559187e-02f, 3.24295044e-01f, 2.92286962e-01f, -3.82991463e-01f, 2.30305213e-02f, -2.11007357e-01f, -2.73763806e-01f, -2.07378820e-01f, -7.63036013e-01f,
  -1.51306331e-01f, -3.62749323e-02f, 1.90988034e-01f, 1.03061654e-01f, -1.12662755e-01f, 5.43988533e-02f, 8.48571025e-03f, -7.17853233e-02f, 1.57905258e-02f, 2.66596135e-02f,
  8.28302931e-03f, -6.35029981e-03f, 4.79894690e-02f, 1.43587531e-03f, 9.97776538e-02f, 2.25318801e-02f, 4.98159900e-02f, 1.23524100e-01f, 8.64273161e-02f, -5.17556593e-02f,
  -2.12541983e-01f, -1.35898173e-01f, -2.42766589e-02f, 1.24714151e-01f, 5.74312359e-02f, -3.90271321e-02f, 2.66037136e-03f, -2.75454186e-02f, 2.94471998e-02f, -3.26959819e-01f,
  -2.68814191e-02f, 4.03700992e-02f, -1.18996669e-02f, -8.79839715e-03f, -1.09616257e-02f, -5.16517051e-02f, -6.81492127e-03f, -1.01388358e-02f, 1.14564829e-01f, -3.37419733e-02f,
  1.57534257e-02f, -5.99978790e-02f, 3.37815061e-02f, -5.45736775e-02f, -5.59185445e-02f, -1.11293653e-03f, -7.14037791e-02f, 6.69328822e-03f, 8.24261308e-02f, 9.06340256e-02f,
  1.06813625e-01f, -6.35438308e-04f, -1.07616298e-01f, 2.35245470e-02f, -6.28189147e-02f, 9.16141272e-03f, -4.02744263e-02f, 4.37099524e-02f, 6.05648849e-03f, 9.98043828e-03f,
  5.48028350e-02f, 2.42203206e-01f, -1.19118705e-01f, 6.47163242e-02f, -8.08910187e-03f, -4.34591025e-02f, -8.81023705e-03f, 2.02288553e-02f, 1.47454487e-02f, -1.62985306e-02f,
  8.39344338e-02f, 7.19075557e-03f, 3.30661125e-02f, 5.22290096e-02f, 9.40136961e-04f, 5.88834621e-02f, -7.30339214e-02f, 1.85809452e-02f, 6.38111457e-02f, -5.00223180e-03f,
  -1.08619995e-01f, -4.41231430e-02f, 4.14864235e-02f, 6.98116198e-02f, 1.74968764e-02f, 1.19111225e-01f, -8.43706354e-03f, -2.42083780e-02f, 7.95923695e-02f, -1.66950792e-01f,
  -5.54023385e-01f, -2.58672833e-01f, -5.11012375e-01f, -1.98108062e-01f, -4.31333259e-02f, -1.70200422e-01f, -2.58994102e-01f, 2.74772849e-02f, 1.04581460e-01f, -1.97250545e-01f,
  1.86673597e-01f, 3.31341028e-01f, 3.51195574e-01f, 2.55578816e-01f, 1.20454110e-01f, -1.94115445e-01f, -3.81385714e-01f, -8.28020871e-02f, 2.03839362e-01f, 2.36925632e-01f,
  2.91756094e-01f, -7.79403560e-03f, -7.50823244e-02f, 2.36732826e-01f, -1.56096354e-01f, 8.90201032e-02f, -3.03273648e-01f, -3.44540864e-01f, -2.85290629e-02f, -4.66648161e-01f,
  -2.60179460e-01f, -4.19631481e-01f, 1.66091159e-01f, 3.09225805e-02f, 9.57660098e-03f, 5.79350442e-02f, 5.91794141e-02f, 2.79160924e-02f, 9.87236574e-02f, -2.33385358e-02f,
  3.15881819e-02f, 1.21325731e-01f, 8.09098110e-02f, 1.22840010e-01f, 1.52976774e-02f, -8.49739939e-04f, -5.56205064e-02f, -6.59317598e-02f, -4.86267824e-03f, -5.45077659e-02f,
  9.58416089e-02f, -3.42370495e-02f, -2.06272915e-01f, -6.27540648e-02f, -2.92402823e-02f, 3.26960743e-03f, -4.42187600e-02f, -8.05291235e-02f, -1.54606747e-02f, -1.76578224e-01f,
  -4.71098274e-02f, 7.82866478e-02f, -2.65811570e-02f, -6.04441501e-02f, -3.13809700e-02f, 8.02843347e-02f, -4.32438478e-02f, 6.25742376e-02f, 3.97992171e-02f, 2.04705335e-02f,
  -4.57342342e-02f, -1.79246813e-02f, -1.39889084e-02f, -5.21155540e-03f, 9.21383798e-02f, -2.32860986e-02f, 1.29591476e-03f, 3.25367600e-02f, 7.35403672e-02f, 2.66990736e-02f,
  4.15353291e-02f, -8.03728029e-02f, 1.98561419e-02f, 9.81716886e-02f, -1.05660722e-01f, -2.49722004e-02f, 6.18179562e-03f, 2.44098864e-02f, 5.46401143e-02f, 3.12306192e-02f,
  2.47384086e-01f, 2.00842824e-02f, -4.91729118e-02f, 7.15191960e-02f, 4.47823703e-02f, 1.42374769e-01f, 5.24471886e-02f, 1.19342513e-01f, 8.75784233e-02f, 5.74890822e-02f,
  8.36053565e-02f, 5.13587892e-02f, 3.55950221e-02f, 1.09922267e-01f, 7.03514740e-02f, 7.90167451e-02f, 1.38782650e-01f, 5.15503809e-02f, 5.60249761e-02f, 6.33613095e-02f,
  5.70196249e-02f, 3.23779620e-02f, -5.49529456e-02f, 3.95149775e-02f, 3.51347774e-02f, -4.62269895e-02f, 1.22545525e-01f, 9.37616527e-02f, 7.42809474e-02f, 2.26634607e-01f,
  -9.70208168e-01f, 2.02812821e-01f, 7.12758601e-02f, -8.76215324e-02f, -6.26985878e-02f, -1.14577986e-01f, -2.77178466e-01f, -2.16211732e-02f, 9.36230719e-02f, 4.29699384e-02f,
  1.30573824e-01f, 3.14604282e-01f, 3.23388129e-01f, 2.62531459e-01f, 6.85781091e-02f, -1.71638429e-01f, -4.69015874e-02f, -1.12559237e-01f, -1.52627438e-01f, -1.16450518e-01f,
  -9.50479880e-03f, -7.70252571e-02f, -6.08614013e-02f, 1.20095171e-01f, -4.12169658e-02f, 1.22098893e-01f, 9.92853269e-02f, 4.37511876e-02f, 9.56973284e-02f, 1.24228233e-02f,
  -4.86410558e-02f, -1.15777239e-01f, -2.40889862e-02f, 1.95253603e-02f, 2.00668182e-02f, -5.17045110e-02f, -1.27288312e-01f, 1.28499763e-02f, -4.04336303e-02f, -1.11088902e-02f,
  -3.35420221e-02f, -1.89784486e-02f, 3.16699455e-03f, -2.66258679e-02f, -1.29962474e-01f, -7.95155764e-02f, 5.12956530e-02f, -1.61543004e-02f, 4.25447598e-02f, 2.43898258e-02f,
  3.20562273e-02f, -5.99078164e-02f, -1.60709992e-01f, -4.16129688e-03f, -7.24510662e-03f, 6.17589802e-02f, 7.86837284e-03f, -2.40296796e-02f, 3.15403901e-02f, 7.11238161e-02f,
  3.72358449e-02f, 7.06503540e-02f, 9.06482711e-03f, -1.93133559e-02f, 5.19459881e-02f, 2.56371312e-02f, -4.17616069e-02f, 3.42806764e-02f, 1.71838645e-02f, -2.28498168e-02f,
  4.39988524e-02f, -5.49962856e-02f, 1.49495536e-04f, -5.81531450e-02f, 3.37299593e-02f, -7.98532218e-02f, -6.64773658e-02f, 4.02639061e-02f, -2.97984723e-02f, -4.83514778e-02f,
  4.71550971e-02f, -3.83971184e-02f, 5.05320821e-03f, 1.10811344e-03f, 2.48619579e-02f, 4.86464007e-03f, -7.33594075e-02f, 5.39272279e-02f, 1.24436291e-02f, 6.98040146e-03f,
  1.41305059e-01f, 5.26563302e-02f, -2.32353769e-02f, 4.43320051e-02f, -7.02838451e-02f, 1.13753751e-01f, 4.21362258e-02f, 5.02137281e-03f, 6.29861001e-03f, 1.01242363e-02f,
  5.38514480e-02f, -1.39745753e-02f, -1.88792646e-02f, 6.30573183e-02f, 4.96662408e-03f, -8.93606804e-03f, 5.01977019e-02f, -1.64261460e-02f, 4.07730527e-02f, -6.49547670e-03f,
  1.37820303e-01f, 1.49199006e-03f, 9.04531591e-03f, 1.11073002e-01f, 1.37602342e-02f, -6.07235320e-02f, 2.12141871e-02f, 2.58394796e-02f, -8.35942030e-02f, 7.75252357e-02f,
  -6.51832521e-01f, 5.71628332e-01f, -3.54526117e-02f, -2.35543162e-01f, 1.68068126e-01f, 1.32006571e-01f, 4.75175560e-01f, 6.45695254e-02f, -4.97059561e-02f, 3.32567990e-01f,
  9.24470872e-02f, -1.57922998e-01f, -1.73982799e-01f, -1.62233368e-01f, -1.91555619e-01f, 3.59528005e-01f, 1.61317140e-01f, -4.87464607e-01f, -5.17393649e-01f, -6.16812930e-02f,
  4.45076935e-02f, -4.65606488e-02f, -2.85240501e-01f, -1.39555350e-01f, 2.41240218e-01f, -8.94154236e-02f, 1.86103731e-01f, 4.02279682e-02f, 7.66333193e-02f, -5.26253469e-02f,
  -1.03060171e-01f, -6.18997514e-02f, -9.84006897e-02f, -3.91730145e-02f, 7.85116758e-03f, 1.35440165e-02f, 3.61513011e-02f, -6.52228147e-02f, 3.77683267e-02f, -1.99216115e-03f,
  -4.87866178e-02f, -7.78165236e-02f, -7.88235441e-02f, 2.64426675e-02f, -8.86663049e-02f, 2.70199738e-02f, 1.09035661e-02f, -5.73014207e-02f, -7.96027333e-02f, 7.53653869e-02f,
  4.33120504e-02f, 5.08230226e-03f, -4.13067304e-02f, 7.87502825e-02f, -6.23883978e-02f, -1.63105011e-01f, -5.96410176e-03f, -1.07123487e-01f, -1.09904967e-01f, 9.68502909e-02f,
  7.64507428e-02f, 3.60882329e-03f, 4.42460217e-02f, 5.48068769e-02f, 8.96324888e-02f, -1.39482645e-02f, -6.08430728e-02f, 5.32101728e-02f, -3.44640762e-02f, -1.50502101e-02f,
  3.33589837e-02f, 6.31312281e-02f, -6.37217984e-02f, 6.00582510e-02f, -2.24540010e-03f, -3.72112654e-02f, -6.84235319e-02f, 2.28546653e-02f, -2.02439930e-02f, 4.64286245e-02f,
  -7.01320693e-02f, 1.41988927e-02f, 3.83514240e-02f, -2.71845125e-02f, 4.22123186e-02f, -6.21783473e-02f, -8.12439322e-02f, 2.46419664e-02f, 1.79435816e-02f, -2.53931582e-02f,
  2.24929884e-01f, -1.15603276e-01f, -1.64253935e-02f, 2.72807963e-02f, -1.17505593e-02f, 1.99511070e-02f, -9.89389140e-03f, 2.40091048e-02f, -1.73049271e-02f, 8.34933817e-02f,
  -4.91628014e-02f, 8.77763331e-03f, 4.47705500e-02f, 9.90239903e-03f, -2.41917418e-03f, 3.18269990e-02f, 1.52931616e-01f, -3.39954756e-02f, 4.84707057e-02f, 5.42572811e-02f,
  1.19604968e-01f, 1.32202134e-01f, 3.43257412e-02f, 4.46990989e-02f, 7.42343115e-03f, 4.71127545e-03f, 4.92746681e-02f, 6.46471605e-02f, 2.78005209e-02f, 3.26927423e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.13717377e-01f, -8.05607557e-01f, 6.92392886e-01f, -3.20657454e-02f, 1.96736917e-01f, 5.10947645e-01f, 5.06971121e-01f, -7.87985474e-02f, -3.20856124e-01f, -4.00745543e-03f,
  -2.05442995e-01f, -2.15428114e-01f, -1.54071495e-01f, -2.48944044e-01f, -1.92811698e-01f, 5.24872422e-01f, 1.38662294e-01f, 1.83966815e-01f, 5.03305733e-01f, 5.04725933e-01f,
  9.63601917e-02f, -8.37546028e-03f, -3.81868690e-01f, -1.27095774e-01f, 1.33413360e-01f, 1.96886197e-01f, 8.28278214e-02f, -1.32028595e-01f, -8.18672702e-02f, -9.46345329e-02f,
  5.98115742e-01f, -4.64292884e-01f, 1.85887218e-02f, -4.01314944e-01f, -4.34041470e-02f, -2.64964029e-02f, 1.14068955e-01f, -6.05122373e-02f, -1.56159550e-01f, -7.03531951e-02f,
  -2.02614039e-01f, -1.34619325e-01f, -3.98234688e-02f, -2.08969638e-02f, 2.33158693e-02f, -8.24799687e-02f, -9.07478780e-02f, -2.08218619e-01f, -1.20953485e-01f, -3.31921712e-03f,
  -6.92024454e-02f, -1.38552099e-01f, -1.60886824e-01f, -1.95571199e-01f, -1.34513542e-01f, -5.22522777e-02f, -4.83817235e-02f, -5.41910976e-02f, -1.75036088e-01f, -7.13042840e-02f,
  -1.09616622e-01f, 1.74294218e-01f, -2.06799563e-02f, 8.04159325e-03f, -7.60505861e-03f, 1.14142828e-01f, 4.38782014e-02f, -1.10471681e-01f, -5.87383052e-03f, 1.57313198e-01f,
  3.42116412e-03f, -2.13753972e-02f, 1.19160879e-02f, 8.80332440e-02f, -3.17655727e-02f, -1.46152377e-01f, 1.38275042e-01f, -3.08697410e-02f, -1.58093333e-01f, -1.50904089e-01f,
  -1.48791462e-01f, -1.50662735e-01f, -2.53595356e-02f, -1.01086304e-01f, -1.69933602e-01f, 2.31726877e-02f, 5.68635873e-02f, -1.65968332e-02f, 2.34491155e-02f, 1.10451423e-01f,
  4.17887330e-01f, -4.07499373e-01f, 4.02884036e-01f, -1.97310597e-02f, -3.97491977e-02f, -1.17670640e-01f, -4.55902424e-03f, -6.32970184e-02f, -1.89994901e-01f, -1.02909468e-03f,
  -1.11943901e-01f, 3.27010155e-02f, -4.27201316e-02f, 4.48719822e-02f, 2.20891446e-01f, 3.51431221e-02f, -9.80420336e-02f, 1.17812611e-01f, -1.29370272e-01f, -2.00577937e-02f,
  -1.50131434e-01f, 8.32324401e-02f, 2.70006418e-01f, 1.13900512e-01f, 4.08029882e-03f, 2.14948490e-01f, 2.91564584e-01f, 1.87742487e-01f, 9.66914967e-02f, 4.66393262e-01f,
  7.37831235e-01f, -5.37294745e-01f, -2.32087433e-01f, 8.38929713e-01f, 6.36454165e-01f, 3.42719406e-01f, -5.33734001e-02f, 1.11277655e-01f, 4.42906708e-01f, 1.30587310e-01f,
  1.27572596e-01f, 3.57259542e-01f, 3.74837726e-01f, 2.60792732e-01f, 9.13140103e-02f, 2.87426829e-01f, 4.82619613e-01f, 3.77270430e-02f, 2.79064151e-03f, 2.92575099e-02f,
  1.39073566e-01f, 1.21551156e-02f, -3.77255715e-02f, 5.10855541e-02f, -1.11566946e-01f, 3.80324900e-01f, 2.18890324e-01f, 5.31914122e-02f, -2.41160721e-01f, -1.36006856e-02f,
  -3.24882716e-01f, -1.06164344e-01f, 2.56823182e-01f, 8.67039859e-02f, -1.15606338e-01f, -4.32563163e-02f, 5.96639700e-02f, -9.92021486e-02f, -7.27266520e-02f, -1.74519122e-01f,
  -9.38853025e-02f, -1.32246390e-01f, -7.68775567e-02f, -2.15614185e-01f, -2.12978367e-02f, -2.79786766e-01f, -1.92886770e-01f, -6.63324967e-02f, 5.65793477e-02f, -7.61813298e-03f,
  -1.36074647e-01f, -1.15219817e-01f, -1.42138287e-01f, -1.25359565e-01f, 3.69875729e-02f, 1.79052457e-01f, -1.25444159e-01f, 4.94695604e-02f, 1.02585733e-01f, 1.34859815e-01f,
  1.84766904e-01f, -4.23837230e-02f, 4.52368893e-02f, 4.38281382e-03f, -2.71941513e-01f, -1.23529129e-01f, -1.96650270e-02f, -1.93745986e-01f, -9.68095437e-02f, -5.03638908e-02f,
  -2.66821701e-02f, -1.94391143e-02f, -6.90624416e-02f, -4.48760130e-02f, 2.83571370e-02f, -1.96027875e-01f, -1.99586257e-01f, -2.88205296e-01f, -2.01454744e-01f, 1.65887788e-01f,
  3.76725048e-02f, 4.34514508e-02f, -9.74766985e-02f, -2.37240404e-01f, 4.37434949e-02f, 1.85329586e-01f, -7.45220017e-03f, 8.54553580e-02f, 4.94517237e-02f, 1.57779515e-01f,
  4.55446601e-01f, 2.25484803e-01f, 9.53627005e-02f, 8.78617689e-02f, -3.26178856e-02f, -1.27471015e-01f, 6.81020543e-02f, -2.01903805e-01f, -2.29493141e-01f, -1.55200750e-01f,
  -1.42931357e-01f, -1.38602108e-01f, -2.02279046e-01f, -8.68905559e-02f, -4.65041436e-02f, -7.44027123e-02f, 7.14516640e-02f, 6.97985068e-02f, 1.41935334e-01f, 1.12602208e-02f,
  -4.68880683e-02f, 1.60074294e-01f, 2.22258627e-01f, 2.12668553e-02f, 1.08255371e-01f, 1.98265299e-01f, -1.48592830e-01f, 3.22003923e-02f, 1.09854542e-01f, 2.13251293e-01f,
  1.56304705e+00f, -3.73304248e-01f, -1.61686599e+00f, 2.69559205e-01f, -9.38171327e-01f, -4.89996314e-01f, -6.54578507e-01f, 8.88756439e-02f, 4.95087862e-01f, -4.82068539e-01f,
  -8.16527307e-02f, 5.04769623e-01f, 1.85538560e-01f, -1.89734191e-01f, -9.38663706e-02f, -7.31001794e-01f, -8.25439215e-01f, -4.73852962e-01f, -4.77472097e-02f, -8.56301785e-02f,
  -2.04135552e-01f, 1.29973173e-01f, 3.50255698e-01f, 1.02828875e-01f, -2.15470344e-01f, 2.28583738e-01f, -7.48862147e-01f, -2.05005169e-01f, -3.21636051e-01f, -5.51903188e-01f,
  -6.00488603e-01f, -4.65037078e-01f, -1.11612998e-01f, 2.13799208e-01f, -5.67607999e-01f, 2.64387131e-01f, -3.89146879e-02f, -1.23737648e-01f, 1.79191142e-01f, -1.77966371e-01f,
  -4.29751985e-02f, -4.25437726e-02f, 1.15148470e-01f, -6.10586330e-02f, 7.71280974e-02f, -3.50077190e-02f, -1.36183217e-01f, -2.33889133e-01f, -2.97918171e-01f, -1.23084649e-01f,
  -8.65148157e-02f, -3.23999703e-01f, -3.59121472e-01f, -2.45363504e-01f, -2.28450403e-01f, 2.07645986e-02f, -3.88693511e-01f, -1.53572321e-01f, -1.89607769e-01f, -7.43714049e-02f,
  3.04439850e-02f, -1.55806750e-01f, -6.96645258e-03f, 7.01898942e-03f, 9.52131003e-02f, 5.88040128e-02f, 1.46550745e-01f, 2.03240401e-04f, -1.15071014e-01f, 8.74723941e-02f,
  -1.29661262e-02f, -1.33287892e-01f, -4.05845977e-02f, 1.10884383e-01f, -1.40861854e-01f, -1.05332129e-01f, 9.64454338e-02f, -9.37811658e-02f, -6.86275773e-03f, -4.33844253e-02f,
  2.69259512e-02f, -1.71024978e-01f, -5.60351834e-02f, 4.21452858e-02f, -2.80744225e-01f, -2.01891828e-02f, 7.56400600e-02f, 1.70683429e-01f, 1.63141191e-01f, 2.25687593e-01f,
  9.86928463e-01f, -4.34010267e-01f, 1.61971956e-01f, 1.35693684e-01f, -1.25759225e-02f, -7.12444186e-02f, -2.70297438e-01f, -2.72348598e-02f, 1.55235857e-01f, -5.89983501e-02f,
  -1.27547592e-01f, 1.74816728e-01f, -1.06114984e-01f, -1.55656427e-01f, 4.00333405e-02f, 1.48663476e-01f, -1.68323424e-02f, 1.03442788e-01f, 1.20138638e-01f, 6.98319599e-02f,
  -2.03019697e-02f, 1.18766129e-01f, 4.38657731e-01f, 3.02001923e-01f, 6.27685785e-02f, 3.07327002e-01f, -6.45053387e-02f, 1.20220132e-01f, 2.15889305e-01f, 5.25163472e-01f,
  -1.57291257e+00f, -2.59864807e-01f, -1.55680791e-01f, -7.79357612e-01f, -1.08168675e-02f, 8.68156925e-02f, -3.83262187e-02f, 2.32493505e-01f, 1.78181246e-01f, -3.35905582e-01f,
  -3.26472186e-02f, -3.27987134e-01f, -6.65648401e-01f, -3.66429836e-01f, -7.37592995e-01f, -6.02670431e-01f, -6.51797652e-01f, -8.36694717e-01f, -3.21037441e-01f, 5.14372468e-01f,
  1.06188685e-01f, -7.67509520e-01f, -8.69880915e-01f, 2.38691613e-01f, 7.50187458e-03f, -2.71791548e-01f, -1.92741454e-01f, -4.83724356e-01f, -5.56232557e-02f, -9.81263101e-01f,
  -3.79827291e-01f, 4.34589148e-01f, 3.99487987e-02f, -1.88179433e-01f, -9.62066948e-02f, -1.37858465e-01f, -1.52301388e-02f, -3.36387396e-01f, 3.22579384e-01f, -8.09898004e-02f,
  -2.77393937e-01f, 4.47729617e-01f, 4.90855388e-02f, 3.37906688e-01f, 9.59920734e-02f, 9.84557644e-02f, -1.29537731e-02f, -1.04108550e-01f, -3.33939195e-01f, 3.79586250e-01f,
  -9.98588745e-04f, 1.19909793e-02f, -1.83873996e-01f, 9.45593715e-02f, 4.51729596e-01f, -5.61535843e-02f, 2.57539928e-01f, 5.74725449e-01f, 1.92183912e-01f, -4.85919118e-01f,
  6.26352653e-02f, -9.85618010e-02f, 6.33250698e-02f, -1.20402232e-01f, -5.90477474e-02f, 1.26986295e-01f, -8.34486913e-03f, -2.83555746e-01f, 1.78866033e-02f, -2.25677118e-01f,
  2.37004355e-01f, 1.69985592e-02f, 7.00962171e-02f, -1.75443649e-01f, -2.69344896e-02f, -2.62824465e-02f, -2.13209918e-04f, -5.31325117e-02f, 1.35029771e-03f, 7.28232712e-02f,
  -1.86883837e-01f, -8.94295126e-02f, -1.60593554e-01f, 8.38405043e-02f, 8.50669481e-03f, 1.70525890e-02f, 7.74013286e-04f, 1.09498844e-01f, 4.81475368e-02f, 1.56500831e-01f,
  -5.65947711e-01f, -7.41713718e-02f, -2.69251138e-01f, 1.21352613e-01f, -4.14304249e-02f, 1.46832578e-02f, -2.31742442e-01f, -8.96464214e-02f, 4.16273810e-02f, -2.47246191e-01f,
  1.71736524e-01f, -2.96874940e-01f, 6.17894679e-02f, 1.20140417e-02f, -8.10347050e-02f, 7.92189837e-02f, -2.83296287e-01f, -4.18645114e-01f, -3.36436659e-01f, 2.43064851e-01f,
  -6.17833734e-02f, -2.08428800e-01f, -9.24604833e-01f, -4.79761302e-01f, 7.80483261e-02f, -2.67512828e-01f, -3.47026259e-01f, -1.20449148e-01f, -3.04588348e-01f, -8.42230558e-01f,
  -8.99766624e-01f, -2.29149293e-02f, -5.79312503e-01f, 5.15032589e-01f, 5.87237716e-01f, -1.90509826e-01f, -4.76512194e-01f, -5.49354136e-01f, 3.08535755e-01f, 8.65769535e-02f,
  1.77445084e-01f, 4.46790695e-01f, 3.08119893e-01f, 9.27345902e-02f, -4.84257519e-01f, 7.73152709e-02f, 6.03859127e-01f, -2.04569027e-01f, -5.34897625e-01f, -3.10681403e-01f,
  5.89959860e-01f, 7.05656223e-03f, -3.86184365e-01f, -1.42525017e-01f, 2.83815265e-01f, 1.64583161e-01f, 3.18755135e-02f, 2.04519287e-01f, -8.65684301e-02f, 6.17824495e-01f,
  -4.33764279e-01f, -6.09961152e-01f, 1.51496395e-01f, 2.95390040e-01f, 1.35531127e-01f, -3.53655487e-01f, -1.93488657e-01f, -1.47805080e-01f, -2.39136238e-02f, -8.98325518e-02f,
  2.52294302e-01f, -1.33702576e-01f, 2.92016447e-01f, 1.64416675e-02f, -5.79774417e-02f, -6.63951933e-02f, -2.45954528e-01f, -1.99197873e-01f, -4.64544475e-01f, -4.14426148e-01f,
  6.01618230e-01f, 2.31401905e-01f, -7.72822380e-01f, -1.67557284e-01f, -3.61390769e-01f, 4.05910760e-01f, -4.14540648e-01f, -3.72433275e-01f, -7.69847453e-01f, -6.09401166e-01f,
  4.30142209e-02f, 3.88947874e-02f, -5.63844517e-02f, -1.79906756e-01f, 3.44432145e-02f, -2.13624854e-02f, 1.67145282e-01f, 1.24128446e-01f, 1.30412513e-02f, -1.96933784e-02f,
  1.20537311e-01f, 7.73607343e-02f, 1.13506645e-01f, -9.79766473e-02f, 1.37342542e-01f, -3.57484235e-03f, -9.94500071e-02f, -1.22526504e-01f, -1.21618249e-01f, -4.36305776e-02f,
  2.74396548e-03f, -1.90764278e-01f, 1.15802772e-01f, 7.94882178e-02f, 9.29983146e-03f, -4.88881618e-02f, 8.23350847e-02f, -9.94627848e-02f, -6.34324446e-04f, -4.35803756e-02f,
  1.09356537e-01f, 3.91305029e-01f, -3.70358415e-02f, -1.93566754e-01f, -1.65441558e-01f, 1.36028439e-01f, 2.43420377e-01f, -2.05226406e-01f, -7.29425699e-02f, -1.09112658e-01f,
  -1.56246632e-01f, -3.12085133e-02f, 2.38966346e-02f, 5.28232865e-02f, 7.44985929e-03f, 2.58124825e-02f, 1.45210326e-02f, 1.39314890e-01f, -1.38617784e-01f, 1.30290672e-01f,
  1.24637119e-01f, -3.88923824e-01f, -3.18455875e-01f, -1.51621416e-01f, 8.76358226e-02f, -9.24566165e-02f, -3.25939298e-01f, -1.71125814e-01f, -3.67735088e-01f, -4.63817030e-01f,
  1.39887309e+00f, 3.52387667e-01f, 3.29100400e-01f, 2.08701253e-01f, -1.98453769e-01f, -3.41782719e-02f, 3.22944298e-02f, 1.47024587e-01f, 9.81818512e-02f, 1.10528380e-01f,
  3.31560731e-01f, 3.24722916e-01f, 3.00240725e-01f, 1.83835924e-01f, 1.86313033e-01f, -7.64301494e-02f, -2.58467048e-01f, 7.82146230e-02f, 3.12946737e-01f, 3.29765230e-01f,
  8.80223587e-02f, 1.54548496e-01f, 3.44785035e-01f, 6.87250346e-02f, 4.92657200e-02f, 2.14840714e-02f, -2.96923500e-02f, -1.09883547e-01f, 8.60551838e-03f, 1.36514366e-01f,
  6.51260674e-01f, 4.72187310e-01f, -1.79664612e-01f, -4.23365235e-02f, -1.90823212e-01f, -6.60884678e-02f, 1.46109641e-01f, -1.79287538e-01f, -2.05775082e-01f, -1.90422177e-01f,
  -1.49860695e-01f, 9.78288874e-02f, 4.33177724e-02f, 5.00604361e-02f, 8.58949795e-02f, 6.82340935e-03f, 1.28036365e-01f, 1.48342952e-01f, -6.02706969e-02f, 3.75599153e-02f,
  -8.29156861e-02f, -1.64182812e-01f, -2.45337665e-01f, -1.48079962e-01f, 7.07214996e-02f, 1.79808177e-02f, -7.86971152e-02f, 3.67128588e-02f, 1.25609949e-01f, 8.60909522e-02f,
  -3.54908668e-02f, 1.22380674e-01f, 1.08321846e-01f, -5.04963510e-02f, 1.40308708e-01f, 1.39375940e-01f, 6.15233881e-03f, -3.35255149e-03f, 1.22988537e-01f, 7.24485740e-02f,
  5.17377555e-02f, 3.35626602e-02f, 1.50361419e-01f, 1.68326050e-02f, 9.63692181e-03f, -1.25040993e-01f, -6.86918125e-02f, -1.70059934e-01f, -5.33667728e-02f, -1.78667288e-02f,
  4.86762747e-02f, -1.45440713e-01f, 3.09788026e-02f, 1.06359281e-01f, 7.65172839e-02f, -9.53366235e-03f, 1.22875189e-02f, -2.47066119e-03f, 5.10579124e-02f, -7.74950758e-02f,
  -4.13938075e-01f, -1.64437503e-01f, 2.54381597e-01f, -1.15879411e-02f, -1.35310546e-01f, -1.14976254e-03f, 3.14957276e-02f, -2.09074363e-01f, -2.34278396e-01f, 4.00280654e-02f,
  5.67994304e-02f, 1.23772949e-01f, 1.51829153e-01f, 4.88107167e-02f, -1.98265221e-02f, -1.13816656e-01f, 4.79713753e-02f, -1.21290214e-01f, -2.02991888e-01f, -1.67048797e-01f,
  -1.21569619e-01f, -2.65350610e-01f, -1.63107544e-01f, -2.27649495e-01f, -8.73043165e-02f, -2.60796219e-01f, -2.87056178e-01f, -1.22718006e-01f, -1.69131517e-01f, -1.11070178e-01f,
  4.46749508e-01f, -2.80032307e-01f, 6.26244009e-01f, 3.90310585e-02f, -4.61558580e-01f, -8.08055103e-01f, -1.31250095e+00f, -4.65681523e-01f, 2.98686326e-01f, -1.86166301e-01f,
  -3.10140908e-01f, 7.27749169e-02f, 3.33082974e-01f, 9.83601287e-02f, -4.56304193e-01f, -4.08296138e-01f, 2.56735682e-01f, 5.69261134e-01f, -1.54560581e-02f, -6.81487978e-01f,
  -1.82169333e-01f, 3.63220036e-01f, 4.40743625e-01f, 5.27070947e-02f, 1.67425603e-01f, -8.77249315e-02f, 3.17068249e-01f, 1.95291668e-01f, -2.43987277e-01f, 7.51900494e-01f,
  3.30347389e-01f, 1.71633791e-02f, -1.26958892e-01f, 1.49498641e-01f, 1.15062982e-01f, 9.88815650e-02f, -5.30711710e-02f, 4.22694653e-01f, -5.92783205e-02f, 1.34705931e-01f,
  1.51779220e-01f, 3.34482342e-02f, 1.24296091e-01f, 3.21124271e-02f, -6.75169379e-02f, -1.14686146e-01f, 2.60421604e-01f, 1.70646831e-01f, 1.51288956e-01f, -1.57843947e-01f,
  -1.15048319e-01f, -2.42862597e-01f, -2.22623631e-01f, -3.81013840e-01f, -4.98884544e-02f, 2.43631333e-01f, -2.17763156e-01f, 1.51055917e-01f, 2.89927761e-04f, 1.57503977e-01f,
  -1.94375068e-01f, 9.53206122e-02f, -3.48378457e-02f, -1.85187533e-02f, -4.75257263e-03f, 8.54154211e-03f, 1.08512990e-01f, -7.64606372e-02f, -8.20592120e-02f, 1.30521283e-02f,
  -6.39805272e-02f, 8.20830185e-03f, 8.35884288e-02f, -1.43142305e-02f, 3.96508947e-02f, 8.06227997e-02f, -4.90166945e-03f, 2.59265192e-02f, -7.14850798e-03f, 6.19604103e-02f,
  -1.55397970e-02f, -1.13646090e-01f, 1.64137423e-01f, 4.76267077e-02f, -6.27916157e-02f, 1.59310848e-02f, 7.84456655e-02f, -3.48341092e-02f, 9.04317126e-02f, 1.35794744e-01f,
  1.65926978e-01f, -3.36133480e-01f, 2.33985364e-01f, -8.64275321e-02f, 4.54057641e-02f, -5.53305671e-02f, 9.42151248e-02f, 7.10609835e-04f, 2.09210441e-01f, -9.66172069e-02f,
  -1.35779515e-01f, -3.00555713e-02f, 1.82524726e-01f, 3.05936653e-02f, -1.65775195e-01f, -3.80931282e-03f, -1.98408723e-01f, -5.99588715e-02f, -1.74173638e-01f, 1.37994632e-01f,
  -3.97509672e-02f, -3.62544537e-01f, -6.30828381e-01f, -2.52699256e-01f, -3.98882888e-02f, -3.12328130e-01f, -2.43368775e-01f, -1.49636194e-01f, -5.47874033e-01f, -4.68960226e-01f,
  8.89465511e-02f, 1.08441150e+00f, -2.49539703e-01f, 2.44437054e-01f, 7.05253422e-01f, 1.98275194e-01f, 5.82613707e-01f, -1.14946224e-01f, -6.71642274e-02f, 3.80097508e-01f,
  2.59378463e-01f, 8.74665156e-02f, 6.68647140e-03f, -3.30111921e-01f, -3.37684780e-01f, 1.49171367e-01f, 3.25181693e-01f, -5.18481076e-01f, -6.28741264e-01f, -5.75275496e-02f,
  3.10027450e-01f, 3.46302718e-01f, -1.16597265e-01f, -2.06401050e-01f, 5.22526562e-01f, -1.29047975e-01f, -3.61017175e-02f, 5.08486509e-01f, 3.20516266e-02f, 5.43578804e-01f,
  -1.31092489e-01f, 7.61493683e-01f, -5.20788014e-01f, 6.96308762e-02f, 3.10099363e-01f, -1.61136121e-01f, -1.45418402e-02f, -2.99182236e-02f, -4.12061326e-02f, -2.14877576e-02f,
  8.88579935e-02f, 6.15488291e-02f, 6.02711141e-01f, 6.17722124e-02f, 3.15011173e-01f, 5.49635254e-02f, -1.10902533e-01f, -3.40594165e-02f, -4.31290299e-01f, -7.73703903e-02f,
  2.38377318e-01f, 4.25971240e-01f, 7.18255788e-02f, -1.18055411e-01f, -1.73009709e-01f, -3.00527632e-01f, 1.23958953e-01f, -1.82221122e-02f, -4.55597222e-01f, -9.30313095e-02f,
  -2.68434405e-01f, 2.86335181e-02f, 9.22220871e-02f, 6.98768869e-02f, 7.47163519e-02f, 6.25652447e-02f, 3.35179977e-02f, -4.35069762e-02f, 4.85603102e-02f, 2.25014210e-01f,
  -1.41462296e-01f, -2.11516216e-01f, -1.38280287e-01f, 5.26070110e-02f, -9.02520716e-02f, 9.84368473e-02f, -7.84783959e-02f, -1.92364872e-01f, 5.75879700e-02f, -4.86114733e-02f,
  1.64657265e-01f, -1.17929146e-01f, -1.92951053e-01f, 2.05501192e-03f, 5.46150133e-02f, -2.74682879e-01f, -7.70128220e-02f, 6.38826191e-02f, -6.83997422e-02f, 1.12614021e-01f,
  4.26176600e-02f, -3.73927861e-01f, -4.86111455e-02f, -2.77349830e-01f, 1.51595464e-02f, 1.06576830e-01f, 1.79089252e-02f, -2.29215413e-01f, 3.39486334e-03f, -2.83584267e-01f,
  1.09146349e-01f, -1.93574458e-01f, 1.27478227e-01f, 7.77684711e-03f, -7.07911253e-02f, 1.25649292e-03f, 1.20290294e-01f, -1.82884708e-01f, -9.97032151e-02f, -4.57992665e-02f,
  -1.50646731e-01f, -3.09906691e-01f, -3.85197639e-01f, -3.61859947e-01f, -1.19702764e-01f, -4.21318024e-01f, -1.46594837e-01f, -2.03144640e-01f, -5.13597429e-01f, -3.61555904e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.76495886e-01f, 7.05755830e-01f, 6.12941146e-01f, -5.43874726e-02f, 4.68399525e-01f, 3.55847925e-01f, 6.91235602e-01f, 9.82392371e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  8.42850447e-01f, -7.73805231e-02f, -2.81001866e-01f, -5.28071001e-02f, 3.94696623e-01f, 3.15981843e-02f, 3.44725549e-02f, 5.88555634e-01f, 3.74407619e-01f, 1.82692260e-01f,
  -8.68348479e-02f, 1.10937826e-01f, -5.61880827e-01f, -2.15802848e-01f, 3.01410109e-01f, -1.75177962e-01f, -7.20086038e-01f, 6.58118203e-02f, 2.14951947e-01f, 7.92442411e-02f,
  2.57764757e-01f, -2.05990262e-02f, 2.96713054e-01f, -2.54689127e-01f, -1.31122023e-01f, -2.35723794e-01f, 3.39403093e-01f, -3.86970560e-03f, 1.20296553e-01f, -3.77794892e-01f,
  1.18426636e-01f, -3.16502422e-01f, -3.65879953e-01f, -1.37315363e-01f, -3.06951143e-02f, -1.22198164e-01f, -5.68229444e-02f, 6.59469143e-02f, 1.01296596e-01f, -2.40464523e-01f,
  5.65849960e-01f, 4.84552346e-02f, -1.90638572e-01f, 3.02261323e-01f, -5.77334940e-01f, 1.79381385e-01f, 3.71162407e-02f, -2.48174667e-01f, 3.91953856e-01f, 1.43015370e-01f,
  4.95871902e-02f, -2.01152742e-01f, -2.50649583e-02f, -1.11879259e-01f, -5.86527944e-01f, -1.00206956e-01f, -6.02610588e-01f, -2.61592064e-02f, -2.20048934e-01f, -5.14889583e-02f,
  -2.30198085e-01f, 4.11203861e-01f, 4.72787678e-01f, -4.04433981e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.31815681e-01f, 9.62226808e-01f, 5.23542285e-01f, -5.75272515e-02f, 3.76167446e-01f, 4.02216949e-02f, 5.05105704e-02f, -9.61798429e-01f, 1.23052202e-01f, -1.62858386e-02f,
  -5.34207076e-02f, -2.19131500e-01f, 4.53944504e-01f, 5.23724854e-01f, 1.57806408e+00f, -1.70003578e-01f, 1.79606807e+00f, 5.78705311e-01f, 5.08618057e-01f, 3.69981170e-01f,
  3.79058450e-01f, 6.08836906e-03f, 1.37360680e+00f, 1.86065102e+00f, 5.88585734e-01f, -5.02247214e-01f, 2.83962578e-01f, 3.38420391e-01f, 5.26960909e-01f, -2.91460007e-01f,
  5.91068208e-01f, 3.21372926e-01f, 3.14556241e-01f, -8.17273569e-04f, 9.47917178e-02f, 3.19031447e-01f, -1.01529849e+00f, -2.35487983e-01f, -1.00514340e+00f, 9.25539434e-02f,
  1.05291271e+00f, -2.06914157e-01f, 1.20198153e-01f, -6.49145663e-01f, 2.75018483e-01f, -2.21144363e-01f, 6.89463317e-02f, 8.31988394e-01f, 5.78636944e-01f, 6.43630862e-01f,
  1.47620782e-01f, 6.39194071e-01f, 2.48611644e-02f, 7.80319721e-02f, -7.85111248e-01f, 4.17224258e-01f, -5.58233783e-02f, -9.70232859e-02f, 2.34176978e-01f, 3.32352340e-01f,
  1.18128884e+00f, -2.12019742e-01f, -9.13400829e-01f, 1.07350183e+00f, 1.28508866e-01f, -6.26517177e-01f, 2.67753750e-01f, 5.67172825e-01f, -3.38221043e-02f, 1.30979955e-01f,
  -3.17886174e-01f, -5.50060272e-01f, 2.29491502e-01f, -1.76547870e-01f, 1.38927436e+00f, -5.69065614e-03f, -8.89916897e-01f, 1.25556481e+00f, 4.11624908e-01f, 6.23548746e-01f,
  1.51643544e-01f, 4.83045101e-01f, 4.62317169e-01f, 2.13039726e-01f, 4.03112024e-01f, 1.54396623e-01f, -4.57517475e-01f, -4.19609547e-01f, 3.60446632e-01f, 4.12517607e-01f,
  1.51064777e+00f, -6.78198636e-01f, 3.33597839e-01f, 7.81050563e-01f, -9.61107612e-01f, -3.43244553e-01f, 4.62249994e-01f, 4.66010123e-01f, -5.93383126e-02f, 7.38159359e-01f,
  -4.68760505e-02f, -5.59339285e-01f, -7.13034332e-01f, -3.67629752e-02f, -1.25346243e-01f, 6.24814630e-01f, 6.82775617e-01f, -3.80642295e-01f, 7.15932369e-01f, -4.65620548e-01f,
  1.33411515e+00f, 7.77864933e-01f, -7.61962414e-01f, 3.07152450e-01f, 5.04495502e-01f, 2.99004048e-01f, 6.84438199e-02f, 3.05509306e-02f, 5.71754575e-01f, 1.97009102e-01f,
  -3.62668544e-01f, 4.84245718e-01f, 5.68619311e-01f, 1.31990254e+00f, 1.57344806e+00f, 1.20306127e-01f, 8.20824087e-01f, 1.08669378e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.87525910e-02f, 1.61258191e-01f, 1.29059821e-01f, 2.07320467e-01f, 5.10496557e-01f, 2.04330802e-01f, 4.56838496e-02f, 3.18565965e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  4.57042754e-01f, -2.11799040e-01f, 6.25240266e-01f, -4.92313564e-01f, -9.18327212e-01f, -4.73911434e-01f, 1.33214265e-01f, 2.00924143e-01f, -6.33366585e-01f, -5.95044017e-01f,
  -5.27047336e-01f, -2.12593764e-01f, 3.12904805e-01f, -2.01804787e-01f, -5.07546902e-01f, 6.38793647e-01f, 2.35310465e-01f, -9.76160228e-01f, 5.76082051e-01f, -2.48507649e-01f,
  -2.01545477e-01f, -2.46020138e-01f, -2.89693177e-01f, 9.87254009e-02f, -8.11310112e-03f, -1.71268725e+00f, -1.07582188e+00f, -3.95011902e-01f, 6.16186202e-01f, 7.04506218e-01f,
  -2.81222314e-01f, -8.68209004e-02f, 8.69149745e-01f, 1.35003269e-01f, 1.60741240e-01f, 2.44301319e-01f, 1.23631760e-01f, 5.13685703e-01f, -7.14356720e-01f, 9.83823121e-01f,
  9.63109910e-01f, -9.32584107e-02f, -1.36685038e+00f, -8.34482491e-01f, -9.75817800e-01f, -4.71005499e-01f, 1.62260890e-01f, 1.43188089e-01f, 6.03258967e-01f, 6.31876051e-01f,
  -4.01413329e-02f, -3.82209532e-02f, 6.89654350e-01f, 3.02150309e-01f, 8.76614511e-01f, -9.21908081e-01f, -9.77061152e-01f, 8.03077042e-01f, -2.11458102e-01f, 4.89271224e-01f,
  -1.39779472e+00f, -7.94303596e-01f, -2.11860085e+00f, 3.89114499e-01f, -4.28204499e-02f, 2.71326274e-01f, 3.96647424e-01f, 1.37895942e+00f, 2.96597987e-01f, 1.26716876e+00f,
  -3.91235292e-01f, -2.43780598e-01f, -3.10177475e-01f, 6.93829417e-01f, -1.09218204e+00f, -2.44946823e-01f, -2.68740922e-01f, -5.93364000e-01f, 1.43928424e-01f, 2.38945127e-01f,
  3.88965875e-01f, 1.72656193e-01f, -2.60638356e-01f, 1.08673640e-01f, 5.48567295e-01f, 1.02278042e+00f, -1.30294526e+00f, -3.99979591e-01f, -6.73399210e-01f, 2.80987531e-01f,
  -5.33016026e-01f, 2.71220684e-01f, 1.97366163e-01f, 3.91920984e-01f, 1.62105009e-01f, -3.49550635e-01f, -5.28477609e-01f, -4.91152406e-01f, 8.58818829e-01f, -3.47684711e-01f,
  -3.60959619e-01f, -6.68130219e-01f, 1.05844177e-01f, -8.54110956e-01f, 3.45175058e-01f, -1.48882890e+00f, 2.40828395e-01f, -1.20316219e+00f, 5.13311148e-01f, -4.06934679e-01f,
  2.54428834e-01f, -1.73371598e-01f, -5.54732084e-01f, -9.48870108e-02f, -9.08116817e-01f, -2.54300565e-01f, -2.46586069e-01f, -6.39807433e-02f, -2.32547328e-01f, 6.59064129e-02f,
  -4.60022986e-01f, -3.57763141e-01f, 5.21030426e-01f, 5.41317165e-01f, -1.45362067e+00f, -2.14102287e-02f, 1.57982200e-01f, 1.36400431e-01f, -7.19532132e-01f, -1.26691863e-01f,
  1.90769255e-01f, -1.24599494e-01f, 3.00895810e-01f, -8.46700013e-01f, 1.30157423e+00f, -1.22630048e+00f, -3.06234777e-01f, -5.22200167e-01f, 8.86534095e-01f, 3.44908386e-01f,
  -1.92150757e-01f, 5.27484536e-01f, 1.55889243e-01f, -1.23883629e+00f, -9.22927201e-01f, 8.95664990e-01f, -1.13564253e+00f, -7.83123374e-01f, 5.70315123e-02f, -1.25498724e+00f,
  4.33663167e-02f, 8.13646793e-01f, 4.22438890e-01f, -4.76615131e-01f, 3.03614020e-01f, -3.38466883e-01f, -4.28118855e-01f, -7.34127462e-01f, 4.57788438e-01f, 1.04613071e-02f,
  -7.88365304e-01f, 8.80208254e-01f, -1.28438115e+00f, -1.14979947e+00f, 4.36893225e-01f, -1.02478273e-01f, 1.21270967e+00f, -1.97555989e-01f, -1.70475587e-01f, 1.17259669e+00f,
  -2.16098577e-02f, -1.07581568e+00f, 7.32194602e-01f, 6.28719255e-02f, -1.29515135e+00f, -6.90267682e-01f, 8.03087294e-01f, -2.79001594e-01f, 4.66256380e-01f, 1.33486927e-01f,
  -1.39645946e+00f, -2.56780118e-01f, -1.11380517e+00f, 1.48387229e+00f, -7.51708806e-01f, -9.28290784e-01f, 4.00211155e-01f, 8.14140439e-01f, 6.60186946e-01f, -5.18952549e-01f,
  -2.41046444e-01f, -8.31829369e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.11565906e-01f, 2.59134918e-02f, 1.88981101e-01f, 1.36734888e-01f, -2.55473763e-01f, -3.73538852e-01f, -2.80244760e-02f, -5.96535146e-01f, -3.89087260e-01f, -1.42093664e-02f,
  2.19838798e-01f, 4.40963179e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    