/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.07240844e-01f, -2.60181166e-02f, -1.10512726e-01f, 5.03599197e-02f, 1.91770881e-01f, -3.16837765e-02f, -2.78941691e-01f, 1.59885466e-01f, -6.90270811e-02f, -1.37775540e-01f,
  1.13418497e-01f, -5.01875803e-02f, -1.59122631e-01f, 5.33464961e-02f, 1.33269355e-01f, -1.16241090e-01f, 4.15401086e-02f, -4.94567975e-02f, 3.72804031e-02f, 9.21657085e-02f,
  4.68582623e-02f, 1.66196883e-01f, 1.01657674e-01f, 1.24341093e-01f, 7.81106902e-03f, 7.05092400e-02f, 1.26959458e-01f, -7.79231489e-02f, 1.50820047e-01f, 3.64692062e-02f,
  7.60841668e-02f, 4.75708731e-02f, -1.20026045e-01f, -5.05779758e-02f, 2.55637858e-02f, -3.66180092e-02f, -8.94877836e-02f, -4.53973701e-03f, -5.56434169e-02f, 3.17478762e-03f,
  -8.81608129e-02f, 5.07115349e-02f, 5.81568405e-02f, -6.64646700e-02f, -4.07779850e-02f, -7.78593123e-02f, -1.23272799e-02f, -2.67913379e-02f, -1.73689071e-02f, -2.23882310e-02f,
  -8.34950954e-02f, -6.70595095e-03f, -1.00751199e-01f, -1.04168970e-02f, 3.60799804e-02f, -6.46315655e-03f, -1.32512711e-02f, -7.57735968e-02f, -3.63137610e-02f, 6.58143163e-02f,
  -5.83988391e-02f, -1.78090241e-02f, 1.55026803e-03f, 5.26635982e-02f, -1.23033999e-02f, 8.95735063e-03f, -3.28709856e-02f, -6.52783504e-03f, -7.16125667e-02f, -2.05746461e-02f,
  1.02207258e-01f, -1.28355585e-02f, -7.33094243e-03f, -5.72202392e-02f, -1.10028097e-02f, 2.47540846e-02f, -6.33454099e-02f, 4.49855737e-02f, 4.69177179e-02f, 3.21052112e-02f,
  -2.12207865e-02f, 2.24025249e-02f, 5.83631694e-02f, 8.81343428e-03f, 2.73761880e-02f, -1.08731091e-02f, -3.13008763e-02f, -7.34207481e-02f, -3.58131342e-02f, -2.33903658e-02f,
  1.11939378e-01f, 1.50844008e-01f, 3.74507345e-02f, 1.06810845e-01f, 1.13751907e-02f, -1.01405242e-02f, -8.44375342e-02f, 3.03433873e-02f, -2.97111291e-02f, 3.85645628e-02f,
  5.77422976e-03f, -5.04502170e-02f, 6.47559091e-02f, 1.36229685e-02f, -4.28759977e-02f, 2.15103328e-02f, 2.34693978e-02f, 2.24979203e-02f, -2.23399065e-02f, 1.23334065e-01f,
  1.03572458e-01f, 6.20729551e-02f, -6.17431663e-02f, 4.39342037e-02f, 2.74902787e-02f, 7.24588782e-02f, 3.08316648e-02f, 2.09225714e-02f, -4.26950678e-02f, -7.88661838e-02f,
  4.58546400e-01f, -2.73511916e-01f, -1.11472912e-01f, 1.57083601e-01f, -1.00795232e-01f, -1.71757847e-01f, -6.40573399e-03f, -1.21271849e-01f, 1.48370802e-01f, -8.50837007e-02f,
  -6.36308491e-02f, 4.26826775e-02f, -7.50521645e-02f, -1.03437221e-02f, 8.88962001e-02f, -5.70613379e-03f, 1.45370334e-01f, 3.80661972e-02f, 1.52800214e-02f, -7.41713345e-02f,
  3.97710167e-02f, -7.80250430e-02f, -3.03192735e-02f, -1.28297508e-01f, -6.45493343e-02f, 1.78286284e-02f, 2.07066741e-02f, -1.04945555e-01f, 5.82915582e-02f, -7.68950135e-02f,
  -4.27529681e-03f, 1.10724112e-02f, -1.39106624e-02f, -2.54178140e-02f, -2.15154290e-02f, -2.07260922e-02f, 4.75284457e-03f, 2.26025824e-02f, 4.84078564e-02f, -9.59691219e-03f,
  1.06306700e-02f, 1.92166604e-02f, 8.02168436e-03f, -3.47834360e-03f, 8.26110989e-02f, 6.77182470e-05f, -5.00238035e-03f, 2.62655336e-02f, -3.40605341e-02f, 2.87918781e-04f,
  4.64919675e-03f, 2.38905158e-02f, 7.08831765e-04f, 3.52525786e-02f, 2.59896498e-02f, 6.38931477e-03f, -2.07071286e-02f, 2.64505012e-04f, 2.47640423e-02f, 1.14108075e-03f,
  2.86030155e-02f, 1.10839074e-02f, 2.15507168e-02f, -1.98636148e-02f, -2.12673452e-02f, -5.30287996e-03f, 8.28009844e-03f, -1.42666772e-02f, 4.28372473e-02f, -3.05029582e-02f,
  6.20235577e-02f, 1.90472249e-02f, -1.76678691e-02f, 5.69297709e-02f, 3.50931026e-02f, -8.95696506e-03f, 5.20839617e-02f, -1.02392904e-01f, 7.35738873e-02f, -3.45956497e-02f,
  -1.18851047e-02f, -1.12344418e-02f, -1.48883052e-02f, 2.51105744e-02f, -6.49844706e-02f, 3.01788896e-02f, 3.91945103e-03f, -1.44460564e-02f, -4.37024832e-02f, 1.72489602e-02f,
  -1.31874353e-01f, -1.78688407e-01f, -2.99119186e-02f, -3.63485552e-02f, 4.40540607e-04f, 1.31905433e-02f, 3.98686714e-02f, -7.83392694e-03f, -1.86209399e-02f, -1.53685259e-02f,
  1.15458500e-02f, 9.22248978e-03f, -1.68651380e-02f, 2.07640650e-03f, 1.14420373e-02f, -4.03339081e-02f, -1.67319067e-02f, 2.73829661e-02f, 3.65266539e-02f, -3.90782729e-02f,
  -2.32102186e-03f, 1.46844191e-02f, 3.32765989e-02f, -1.03077134e-02f, 3.22889797e-02f, -4.73822504e-02f, -3.30585800e-02f, 3.43856961e-02f, -4.06941772e-03f, 1.43797658e-02f,
  2.94374943e-01f, 2.73304470e-02f, 6.96681589e-02f, 1.06147043e-01f, 1.07702091e-01f, 5.76136597e-02f, 4.27245200e-02f, 5.89177981e-02f, -4.06794017e-03f, -9.69470665e-02f,
  3.22094075e-02f, 1.51507139e-01f, -1.23821013e-01f, 1.24082752e-01f, 1.19158603e-01f, -2.80373633e-01f, 1.70355737e-01f, 3.91260237e-02f, -6.98863491e-02f, 1.36313602e-01f,
  5.45823574e-02f, 5.77513464e-02f, 4.98290174e-02f, 3.98412719e-02f, 9.89636257e-02f, 4.89499047e-02f, -4.14706916e-02f, -4.75093946e-02f, 8.18348154e-02f, -1.43432608e-02f,
  4.43730168e-02f, -6.58583790e-02f, 3.00402055e-03f, -8.22635740e-03f, -2.01182663e-02f, 3.16190831e-02f, -4.58666310e-02f, -4.59979251e-02f, 3.79058234e-02f, -2.80876532e-02f,
  -3.80926840e-02f, 2.36883443e-02f, 2.82073002e-02f, -1.78782344e-02f, 9.23843831e-02f, 6.86995685e-02f, 1.03731342e-02f, -3.08715203e-03f, -1.94512140e-02f, 1.82733424e-02f,
  2.30475627e-02f, -3.43010314e-02f, 4.29558828e-02f, -2.78316345e-02f, 1.19700246e-02f, 2.87522022e-02f, 5.08280396e-02f, 3.98430079e-02f, -7.72152767e-02f, 4.78192978e-02f,
  1.58896316e-02f, -1.33036654e-02f, 1.77024584e-02f, -7.62830004e-02f, 2.84048915e-02f, -4.64754701e-02f, -8.38211458e-03f, -9.70257726e-03f, -8.64680018e-03f, 3.99147682e-02f,
  2.22396124e-02f, -1.37649449e-02f, -7.18732327e-02f, 2.11703442e-02f, 3.67725082e-02f, 1.01362001e-02f, -2.09729355e-02f, -5.10442024e-03f, 7.44609162e-02f, -3.88195552e-02f,
  -4.82536033e-02f, 3.29457223e-02f, 4.37906850e-03f, -3.45537849e-02f, 7.36099621e-03f, 2.68892720e-02f, -3.97517420e-02f, 2.56894040e-03f, -5.66539876e-02f, -3.68872806e-02f,
  -2.31472477e-02f, 5.34326248e-02f, -3.55029553e-02f, -1.59148667e-02f, -4.72961217e-02f, 2.67472398e-02f, 2.17160229e-02f, 9.61340312e-03f, 1.43457260e-02f, -1.18546281e-02f,
  8.97350088e-02f, 3.19098942e-02f, -5.04299998e-02f, 4.06482928e-02f, -9.76603478e-03f, -1.87581591e-02f, -4.15497161e-02f, 1.40758837e-02f, 7.17647821e-02f, 4.09709476e-02f,
  3.26604433e-02f, 1.41750779e-02f, 2.44519021e-02f, 3.62869911e-02f, 4.68989871e-02f, -3.08602746e-03f, 4.66319770e-02f, 4.99509983e-02f, -7.19022229e-02f, 1.42435879e-02f,
  3.94737452e-01f, -4.65982519e-02f, -1.28840715e-01f, 1.49355799e-01f, 1.07442692e-01f, 1.46552935e-01f, 1.94784969e-01f, -1.72594506e-02f, 1.18654110e-01f, -1.46802887e-01f,
  7.71189034e-02f, -5.54567426e-02f, -5.44114485e-02f, 1.32103777e-02f, 3.02148789e-01f, -1.34332985e-01f, 1.12579316e-01f, 2.71056220e-03f, -3.53623778e-02f, 1.60167724e-01f,
  4.82044034e-02f, 9.25542116e-02f, -1.15509287e-01f, -1.91464946e-01f, 7.34416470e-02f, -1.36448786e-01f, -4.07697493e-03f, -1.10805646e-01f, 8.02626181e-03f, 6.33610561e-02f,
  1.51301384e-01f, 3.11002154e-02f, -1.00270137e-02f, -6.03550225e-02f, 3.05118673e-02f, -1.49565088e-02f, -2.65800450e-02f, -8.41945931e-02f, -2.85618305e-02f, 6.92900317e-03f,
  1.69570707e-02f, 5.51485643e-02f, 1.79600976e-02f, -7.42163882e-02f, 4.33013067e-02f, -8.20052028e-02f, -6.20772764e-02f, -3.47586460e-02f, -3.76759954e-02f, 1.12806670e-02f,
  -4.91658896e-02f, -1.93771794e-02f, -3.74770164e-02f, -6.80684596e-02f, -4.63080220e-02f, 3.92347854e-03f, -8.70631784e-02f, 7.11109256e-03f, 4.46985513e-02f, 2.31433064e-02f,
  -2.69516557e-02f, 3.28158587e-02f, -4.47630920e-02f, 1.22345546e-02f, 5.86321503e-02f, -1.77100115e-03f, 2.41471324e-02f, -4.10675183e-02f, -6.45046309e-02f, 4.26740609e-02f,
  8.31914395e-02f, 4.96473238e-02f, 8.08037803e-05f, -7.37427035e-03f, 4.24550176e-02f, 5.03092855e-02f, -5.62804304e-02f, 1.86451003e-02f, -1.53440200e-02f, -2.84226686e-02f,
  -1.58660728e-02f, 5.39146848e-02f, 3.20590921e-02f, -3.47657539e-02f, 8.71883519e-03f, -3.59649509e-02f, -4.45942543e-02f, -6.56499490e-02f, -1.32785356e-02f, 1.75115056e-02f,
  1.98249191e-01f, 6.01988733e-02f, -6.62696213e-02f, 2.43726708e-02f, -6.47637844e-02f, -9.07655582e-02f, -5.84382564e-02f, -4.74873222e-02f, -1.35274539e-02f, 3.43768969e-02f,
  -5.90389296e-02f, -3.67718674e-02f, 6.76478446e-02f, 7.89138838e-04f, 3.49527001e-02f, 6.93460703e-02f, 6.62064701e-02f, -2.66536828e-02f, 9.26078781e-02f, 1.45142982e-02f,
  2.40215417e-02f, 5.44595486e-03f, -5.85665442e-02f, -3.64243947e-02f, 1.82728481e-03f, -1.73481200e-02f, 3.78737152e-02f, -4.35430482e-02f, 2.40559187e-02f, -3.64062525e-02f,
  -1.46995023e-01f, -2.70397127e-01f, -3.78870927e-02f, -8.66003186e-02f, 7.79239535e-02f, 1.51923090e-01f, 6.75510466e-02f, -6.10288233e-02f, -1.79938376e-01f, -2.47559063e-02f,
  6.93481416e-02f, -1.48868561e-01f, -2.99982410e-02f, 5.65541647e-02f, 1.72024548e-01f, 6.42727613e-02f, 1.13374606e-01f, -2.77619846e-02f, -3.20158154e-02f, -8.76227468e-02f,
  -2.79624164e-02f, 1.34411722e-01f, 8.94595832e-02f, 1.25723323e-02f, 8.04454554e-03f, -1.85957216e-02f, 4.03132755e-03f, 8.04142654e-03f, 5.41298091e-02f, 9.73638818e-02f,
  3.13698016e-02f, -7.64726847e-03f, -4.39356714e-02f, -4.68953699e-02f, 5.20555526e-02f, -4.88324556e-03f, -2.00280230e-02f, 4.29840386e-02f, 1.00783091e-02f, 3.27477306e-02f,
  -2.29288056e-03f, 3.45352218e-02f, 1.34399896e-02f, 4.15407270e-02f, -2.00958680e-02f, 8.60983506e-03f, -1.99879967e-02f, 3.96984955e-03f, -4.76122051e-02f, 4.99708503e-02f,
  2.87108985e-03f, -8.96544568e-03f, -3.08807585e-02f, -6.58888603e-03f, -3.25863138e-02f, 3.38508189e-02f, 5.53692393e-02f, 1.39519721e-02f, 2.39654370e-02f, 9.10465315e-04f,
  8.69910866e-02f, -4.51614596e-02f, -2.65728626e-02f, -4.22139764e-02f, 1.99183375e-02f, 3.73707600e-02f, 1.53517129e-03f, 3.30675058e-02f, 1.59755405e-02f, 1.40595119e-02f,
  1.29451314e-02f, -2.25025155e-02f, 4.19026401e-05f, 1.31628597e-02f, 2.35176664e-02f, -9.68043972e-03f, -1.60487276e-03f, -4.08630930e-02f, -1.80064477e-02f, 3.11354809e-02f,
  -3.08696460e-02f, 1.24226511e-03f, 1.81066265e-04f, 1.23215644e-02f, -1.26961935e-02f, -3.81257609e-02f, -3.00201289e-02f, 2.23250333e-02f, -1.04677947e-02f, 2.29406394e-02f,
  -1.48238540e-01f, -1.78146631e-01f, -1.53390858e-02f, 3.22751552e-02f, 4.54051197e-02f, 3.24552283e-02f, -6.34259265e-03f, -2.24543661e-02f, -2.22317912e-02f, 2.78208335e-03f,
  -2.09606998e-02f, 1.13573642e-02f, -2.22305525e-02f, -3.10773049e-02f, -1.92666501e-02f, 3.93406264e-02f, 2.82964054e-02f, -1.71227735e-02f, 1.54879102e-02f, -2.41887812e-02f,
  -3.04893516e-02f, 3.72275226e-02f, 2.98486333e-02f, 6.39576465e-02f, -7.55366031e-03f, -1.51044736e-02f, -5.42475879e-02f, -4.33049425e-02f, 4.26342823e-02f, 2.47921087e-02f,
  -2.78562099e-01f, 2.11346429e-02f, -6.22980669e-02f, -6.23874068e-02f, 1.63406089e-01f, 2.61256129e-01f, 1.40028968e-01f, 1.67693481e-01f, 1.98259845e-01f, 1.68482587e-01f,
  8.13137218e-02f, -1.15922131e-01f, 8.21364224e-02f, 1.56793207e-01f, -8.38584304e-02f, 1.08556166e-01f, 8.87548253e-02f, -1.02488650e-02f, 7.46561065e-02f, 1.52221248e-02f,
  6.11341335e-02f, 7.92855024e-02f, -3.34485732e-02f, 1.06360272e-01f, 3.75797339e-02f, -8.66115466e-02f, -8.99735317e-02f, -9.27803293e-02f, -7.42846951e-02f, -5.57627156e-02f,
  -2.48888358e-02f, -1.96350679e-01f, -3.09349853e-03f, -2.56138272e-03f, 3.19518782e-02f, -3.91352251e-02f, -3.04017775e-02f, -7.52519891e-02f, -7.09984160e-04f, 3.89893726e-02f,
  1.94348656e-02f, -4.61435178e-03f, -1.05982283e-02f, 2.67002042e-02f, 8.37042332e-02f, 4.31576073e-02f, 1.04412243e-01f, 5.56263141e-02f, 8.51246491e-02f, 3.30875777e-02f,
  2.47177240e-02f, -1.00365616e-02f, 4.77829762e-02f, 7.06309592e-03f, -8.32800847e-03f, 6.33172467e-02f, -2.43544802e-02f, -5.41277155e-02f, 1.23977121e-02f, 2.22676806e-02f,
  1.79068893e-02f, 2.21210648e-03f, 2.58911420e-02f, 7.72190338e-04f, -3.80801074e-02f, -7.53832683e-02f, 2.95700729e-02f, 9.69060871e-04f, -5.54770604e-02f, 4.19803299e-02f,
  5.14706522e-02f, 1.84525605e-02f, -2.87383031e-02f, 2.30712127e-02f, -4.46704924e-02f, 2.47164164e-02f, -5.04127257e-02f, -1.12593919e-02f, 1.51964342e-02f, 1.05296876e-02f,
  -2.37412415e-02f, -1.45411333e-02f, 2.84966510e-02f, -1.20452186e-02f, 3.82353626e-02f, 2.47238968e-02f, 7.80038461e-02f, 5.96694928e-03f, 3.57053019e-02f, -9.68886688e-02f,
  -5.86715639e-02f, -2.09597304e-01f, 3.93774770e-02f, 4.66339178e-02f, -2.33688690e-02f, 8.04566517e-02f, -5.26585057e-02f, 4.96705323e-02f, -4.28602323e-02f, 9.72781703e-03f,
  -4.89162318e-02f, -4.71508577e-02f, -5.13405539e-02f, 4.38252231e-03f, -5.82459830e-02f, 3.65422517e-02f, -3.90685871e-02f, -6.79544732e-02f, 2.19353363e-02f, -3.33406851e-02f,
  -2.21857671e-02f, -4.79128323e-02f, -1.73622817e-02f, 1.61856655e-02f, -3.53682227e-02f, -4.06794325e-02f, -2.91022137e-02f, -3.66750844e-02f, -5.38776405e-02f, -1.71332620e-02f,
  1.49140686e-01f, 4.00120057e-02f, 1.36003837e-01f, 2.89134681e-01f, -1.09203428e-01f, -1.53727248e-01f, 9.46714655e-02f, -7.32587874e-02f, 7.73993134e-02f, 4.39373823e-03f,
  7.70426821e-03f, 1.17944971e-01f, -1.04270980e-01f, 2.13021174e-01f, -1.73314974e-01f, -3.37485247e-03f, 1.21660113e-01f, 1.51191011e-01f, -5.24332970e-02f, 7.57799149e-02f,
  -6.76741377e-02f, 5.61110638e-02f, 9.20631923e-03f, -4.47688848e-02f, 2.81990692e-02f, 7.91792497e-02f, -1.44450679e-01f, 1.17769921e-02f, 8.49222243e-02f, -3.61702517e-02f,
  -1.06391599e-02f, 6.60153329e-02f, -2.08068662e-03f, -2.40500495e-02f, 3.32020083e-03f, -3.27095129e-02f, 3.78936082e-02f, -9.24307201e-03f, 2.88366191e-02f, 3.03201936e-02f,
  8.03695619e-03f, -4.12424318e-02f, 7.87829757e-02f, 3.15244421e-02f, 6.50199736e-03f, 6.17817007e-02f, 1.13389725e-02f, -5.62281162e-03f, 3.51706259e-02f, -3.52040529e-02f,
  4.12110798e-02f, 3.22692376e-03f, 4.01976286e-03f, 1.34351710e-02f, -2.63699163e-02f, 8.75773430e-02f, -1.09726777e-02f, -1.99833866e-02f, -3.67073976e-02f, -8.67090281e-03f,
  -5.46394698e-02f, 1.20515367e-02f, 2.79349908e-02f, 7.34229535e-02f, -7.30219018e-03f, -1.87224156e-04f, 2.49108241e-04f, -4.55390662e-02f, 1.15322219e-02f, -5.62249757e-02f,
  -2.50884108e-02f, 4.51885574e-02f, 2.35477798e-02f, -1.55884922e-02f, 2.29057949e-02f, 3.68957259e-02f, 1.21437258e-03f, 2.06330586e-02f, 6.10615732e-03f, -1.32460892e-02f,
  1.02387071e-02f, 4.50524827e-03f, 2.77139749e-02f, -5.46210399e-03f, -3.58429505e-03f, -2.77317055e-02f, -6.10176285e-05f, 3.48916911e-02f, 3.63577716e-02f, -6.30896837e-02f,
  -1.08939178e-01f, -1.38283670e-01f, -4.47118375e-03f, 1.75933074e-02f, -3.63053335e-03f, -1.60256103e-02f, 1.82510428e-02f, -1.37653342e-02f, -5.07727452e-02f, -1.84209254e-02f,
  -9.40723438e-03f, 1.76857095e-02f, -5.01936413e-02f, 9.28864069e-03f, -2.27555986e-02f, -3.80245559e-02f, 3.97188999e-02f, -4.19500172e-02f, -7.01639056e-02f, -7.34873787e-02f,
  -1.84501167e-02f, -5.40724676e-03f, -5.12706488e-02f, -5.65490164e-02f, -6.89460244e-03f, -6.78166654e-03f, 4.78402972e-02f, 2.04779617e-02f, -2.69086771e-02f, -2.32043527e-02f,
  1.91367343e-01f, -1.09176829e-01f, 1.72546059e-01f, 1.10349998e-01f, 8.59056562e-02f, -1.59549788e-02f, 3.50638069e-02f, 8.88369903e-02f, 1.98010147e-01f, -1.01053216e-01f,
  1.28736004e-01f, -2.31920540e-01f, -4.47861443e-04f, 6.12054616e-02f, 4.05891202e-02f, 5.71205914e-02f, 2.02252083e-02f, -8.50420073e-02f, -1.42704323e-03f, -3.22455317e-02f,
  2.76149251e-02f, -2.02522185e-02f, 1.13148123e-01f, -1.17119186e-01f, 1.19252093e-01f, 2.19407957e-02f, 2.68616080e-02f, -5.82874641e-02f, -4.55536731e-02f, -9.56212506e-02f,
  3.38937342e-02f, 1.98708326e-02f, 4.91629839e-02f, -1.77449323e-02f, 1.34335116e-01f, 3.88123207e-02f, 3.06044985e-03f, -4.36902530e-02f, 1.49806803e-02f, -4.73229215e-02f,
  -2.94178631e-02f, -4.28597741e-02f, -5.92529438e-02f, 1.60283595e-02f, 6.79432526e-02f, 2.98521332e-02f, 2.21452937e-02f, 1.16674930e-01f, -3.19119245e-02f, -2.93629221e-03f,
  6.81393370e-02f, 9.87584963e-02f, 7.00765923e-02f, -3.22616696e-02f, 2.53159571e-02f, 2.54269168e-02f, -1.62976272e-02f, -1.37332156e-02f, -7.84758031e-02f, 5.26324622e-02f,
  -4.68782187e-02f, 5.38303629e-02f, 3.40030193e-02f, 5.07169068e-02f, 1.47460354e-02f, 3.22597623e-02f, -3.86575200e-02f, -3.11345514e-02f, 1.59764215e-02f, -6.73908517e-02f,
  2.68278997e-02f, 1.16188638e-02f, 7.55418697e-03f, 6.04032055e-02f, 2.06196588e-02f, 2.41904762e-02f, -3.52709740e-02f, -4.10622954e-02f, 4.46239896e-02f, 2.03479305e-02f,
  1.24660851e-02f, -5.82089275e-03f, -1.20983468e-02f, -2.52009202e-02f, -6.28994554e-02f, -4.83715348e-03f, -1.37661409e-04f, -8.73975828e-03f, -4.27757762e-03f, -1.61037038e-04f,
  -3.30004729e-02f, -7.39817619e-02f, -3.62820588e-02f, -6.84415698e-02f, -5.20530678e-02f, 4.15679067e-03f, -1.93971973e-02f, -8.68437439e-03f, -2.76439562e-02f, 2.38415692e-02f,
  -4.80463505e-02f, 2.37544104e-02f, 5.45650907e-02f, -3.44471261e-02f, -4.46897261e-02f, 3.85315642e-02f, -2.32034810e-02f, 2.75734328e-02f, -4.92931716e-02f, -6.06794246e-02f,
  -2.35068668e-02f, -2.65454520e-02f, -5.08327223e-03f, 3.06048691e-02f, -2.76468974e-02f, 2.97508612e-02f, -7.92282913e-03f, 7.66400772e-04f, 4.58536390e-03f, 2.46844068e-02f,
  -4.64210138e-02f, 1.82333216e-01f, -1.12287641e-01f, -6.54785410e-02f, 9.57006589e-02f, 6.02583475e-02f, -7.20170662e-02f, 1.75542310e-01f, 1.03132896e-01f, 1.41329959e-01f,
  1.11306794e-01f, -2.17984796e-01f, 1.88365236e-01f, 7.79038519e-02f, -1.20145626e-01f, 1.70856953e-01f, 7.90672526e-02f, -8.83887038e-02f, 1.86303571e-01f, -1.08298594e-02f,
  6.40009716e-02f, 1.59848452e-01f, -1.15768470e-01f, 1.77643716e-01f, -6.05473556e-02f, -7.13131502e-02f, -1.27931312e-01f, -3.48418094e-02f, -1.60318851e-01f, 1.42253246e-02f,
  -8.21017846e-02f, 1.24138936e-01f, -6.12418391e-02f, 6.27915338e-02f, 5.53385802e-02f, -1.05462903e-02f, -6.59161955e-02f, -3.88731509e-02f, -7.05531687e-02f, 4.89427429e-03f,
  5.49202459e-03f, -2.23777592e-02f, 6.60378709e-02f, -5.47037600e-03f, -1.74167082e-02f, -4.63718809e-02f, -2.31790519e-03f, -5.53496880e-03f, -2.88636256e-02f, -1.95152368e-02f,
  -3.08469571e-02f, -2.32190304e-02f, 8.12069327e-03f, 2.42284816e-02f, -2.11812295e-02f, 6.78743189e-03f, -7.15593845e-02f, -9.02155861e-02f, -3.53742428e-02f, -1.52357724e-02f,
  6.52149841e-02f, 9.19399783e-02f, 2.27432977e-02f, 1.87432170e-02f, 1.19345272e-02f, 1.51429046e-02f, -4.30014357e-02f, -6.88997610e-03f, 3.02978721e-03f, -6.03860840e-02f,
  -6.03502318e-02f, -3.84035297e-02f, 2.60387715e-02f, -5.73770255e-02f, -1.40103418e-02f, 2.07545944e-02f, -5.67606613e-02f, -3.13992910e-02f, 9.47444979e-03f, -2.15448830e-02f,
  8.65065828e-02f, 2.38592904e-02f, -7.85320848e-02f, -3.09655461e-02f, 2.65656486e-02f, -6.78122565e-02f, 6.79711550e-02f, -5.96256591e-02f, -1.41719719e-02f, -7.26026110e-03f,
  6.33382946e-02f, 1.78381518e-01f, 3.42242680e-02f, -2.37301588e-02f, -1.08442246e-03f, -4.79661394e-03f, 1.34366855e-01f, -1.97343472e-02f, 1.70185268e-02f, 5.44411652e-02f,
  -1.32659217e-02f, 2.98943724e-02f, -4.68070619e-03f, -1.79199968e-02f, -5.90267777e-02f, -2.86314338e-02f, -8.19161758e-02f, -1.98009843e-03f, -5.42555489e-02f, -1.13918399e-02f,
  1.12232734e-02f, 5.47452178e-03f, 2.15005428e-02f, -7.27876741e-03f, -3.52658071e-02f, -7.51315355e-02f, -2.08848137e-02f, -9.16769952e-02f, 1.44396657e-02f, -2.94557214e-03f,
  2.12138146e-01f, 6.58429191e-02f, 8.15574974e-02f, -4.85592932e-02f, 1.02269771e-02f, -4.67151590e-02f, -6.10932820e-02f, 1.65932402e-01f, 2.44473413e-01f, 3.01828678e-03f,
  -3.43261994e-02f, 7.62057900e-02f, -1.64647866e-02f, -1.56556457e-01f, -1.97963402e-01f, -1.16514288e-01f, -2.92586893e-01f, -2.12327853e-01f, -2.88801715e-02f, -6.53367713e-02f,
  -1.52724564e-01f, -3.25014949e-01f, -2.42676929e-01f, -1.60625055e-01f, -9.01689008e-02f, 2.31447979e-03f, -1.22014485e-01f, -7.37679675e-02f, -1.99153706e-01f, -7.76470974e-02f,
  -3.22261378e-02f, 1.03115119e-01f, 7.27100521e-02f, 2.08661873e-02f, 3.41960392e-03f, -1.46462326e-03f, -1.06266886e-01f, -9.64169949e-03f, 8.26285407e-02f, -2.83310153e-02f,
  9.15190205e-03f, 1.97849907e-02f, -1.79837570e-02f, -2.09608637e-02f, 9.61460769e-02f, 2.00366490e-02f, 1.09935878e-02f, 6.34552836e-02f, 4.11690064e-02f, -3.69004495e-02f,
  -6.56101853e-02f, -1.53662581e-02f, 6.22176901e-02f, 1.17258681e-02f, 5.16602211e-02f, 8.94467011e-02f, -3.75536382e-02f, -3.20104733e-02f, -2.66535077e-02f, 3.37250158e-02f,
  -2.57571209e-02f, -2.09552385e-02f, -5.64945303e-02f, 6.00318331e-03f, -5.21998256e-02f, -2.10209917e-02f, -8.52561519e-02f, -7.98657350e-03f, -2.08295528e-02f, -1.19077954e-02f,
  5.86052835e-02f, 8.73787105e-02f, 2.81444956e-02f, 3.27843800e-02f, -1.06880844e-01f, 3.32700983e-02f, -1.02604777e-01f, -3.09970286e-02f, -4.06809449e-02f, 2.85537113e-02f,
  -3.90568143e-03f, 3.55222598e-02f, 1.42562445e-02f, -5.46818525e-02f, 9.52509698e-03f, -1.04898382e-02f, 2.52016876e-02f, 9.31425765e-03f, 2.46826597e-02f, -1.01556100e-01f,
  -4.55919728e-02f, -8.96923840e-02f, 6.45053387e-02f, -1.89530652e-03f, -6.03931546e-02f, 1.06703490e-02f, -2.85476241e-02f, 5.50804399e-02f, -6.31150827e-02f, -3.37545015e-02f,
  -2.96591129e-03f, -2.74419822e-02f, -1.05115091e-02f, 9.90519971e-02f, -7.06987679e-02f, 4.47139889e-02f, -1.05736256e-01f, 1.00335479e-02f, -2.64170244e-02f, -1.82448328e-02f,
  -5.41056544e-02f, -3.83795872e-02f, -3.10027786e-02f, -6.34525791e-02f, 1.07338540e-02f, 2.01499015e-02f, 9.13916305e-02f, 6.80248588e-02f, -9.36040878e-02f, -3.50274630e-02f,
  -3.15688431e-01f, 2.96435446e-01f, -1.67582810e-01f, 3.65455411e-02f, 5.80255985e-02f, 2.09793195e-01f, 6.84028789e-02f, 2.31873523e-02f, 5.48621453e-02f, -3.37999724e-02f,
  -6.08515413e-03f, -4.30602431e-02f, -1.88591555e-02f, 1.84326395e-01f, 5.05409464e-02f, 1.08558908e-01f, 4.51592617e-02f, -6.98006228e-02f, 1.35597378e-01f, -1.99725572e-02f,
  4.42613028e-02f, 1.76674694e-01f, 1.07710483e-02f, 1.62359595e-01f, 1.22329155e-02f, -1.26289623e-02f, -1.06425449e-01f, 1.07052913e-02f, -5.09609468e-02f, -1.14850057e-02f,
  1.92354862e-02f, -2.48766869e-01f, -8.68382007e-02f, -9.30937380e-02f, -5.48451133e-02f, -1.23642303e-01f, -8.72198567e-02f, -3.44115845e-03f, 3.35800424e-02f, -5.17814048e-03f,
  2.09531337e-02f, 5.73546905e-03f, 1.07983546e-03f, -4.03983332e-03f, -9.62714606e-04f, -4.11757156e-02f, 4.27848548e-02f, 7.58219957e-02f, 1.42210992e-02f, 9.14148614e-03f,
  2.67497394e-02f, 5.94761632e-02f, -8.77002545e-04f, 1.19704921e-02f, 1.78088937e-02f, -2.48234812e-02f, 9.79200192e-03f, -1.46931680e-02f, -1.85699519e-02f, -2.67436318e-02f,
  5.70560293e-03f, -2.15236600e-02f, 3.67514300e-03f, -4.26136814e-02f, 3.72911133e-02f, -1.54172136e-02f, 1.25337159e-03f, -2.36300044e-02f, -2.81495713e-02f, 4.61487621e-02f,
  4.61523607e-02f, -1.53696425e-02f, -5.52905239e-02f, 2.88258474e-02f, 2.38071568e-02f, -4.34768237e-02f, 1.16854198e-02f, -7.32913800e-03f, 6.71811923e-02f, 3.29793780e-03f,
  -3.50890942e-02f, -2.13623885e-02f, -3.99478637e-02f, 1.34163350e-02f, 8.35900474e-03f, -7.75388815e-03f, -1.75870229e-02f, 2.37931963e-02f, -3.11746765e-02f, 3.13247973e-03f,
  3.08308238e-03f, -2.24604219e-01f, 2.11514216e-02f, -2.81289890e-02f, 2.46372707e-02f, 3.50848511e-02f, 5.85995093e-02f, 3.18144932e-02f, -2.20777374e-02f, -4.53051878e-03f,
  -3.04841287e-02f, -7.20812380e-02f, -5.53327671e-04f, 3.56594883e-02f, 7.10313991e-02f, 2.88613923e-02f, -2.16661524e-02f, -1.59660242e-02f, -1.69225596e-02f, -3.99723230e-03f,
  -1.80224087e-02f, -2.25823820e-02f, -6.64498704e-03f, -4.16257679e-02f, -5.17678484e-02f, -2.59982776e-02f, -2.07517780e-02f, 4.51559909e-02f, -4.78924625e-02f, 2.98961233e-02f,
  -4.81215380e-02f, 1.24112628e-01f, -2.59963065e-01f, -1.21478766e-01f, -7.04665557e-02f, 1.59563795e-01f, 1.95732322e-02f, 3.40150557e-02f, -7.89477490e-03f, 1.76204428e-01f,
  2.33416572e-01f, -1.69403479e-01f, 2.07173586e-01f, 9.33964401e-02f, -1.50193900e-01f, 1.21617049e-01f, 1.44262640e-02f, -3.99701223e-02f, -7.21419007e-02f, -3.43677886e-02f,
  -8.99421051e-02f, 1.15317732e-01f, -1.10467918e-01f, -6.37012199e-02f, -9.27642211e-02f, -2.04373583e-01f, 4.37662415e-02f, -1.36685610e-01f, -7.96653703e-02f, -4.78408448e-02f,
  1.51615873e-01f, -9.01247375e-03f, -5.69744892e-02f, -1.80409532e-02f, 5.86304925e-02f, 2.09490396e-02f, 1.40806455e-02f, -4.10426036e-02f, -5.41812479e-02f, -5.93056791e-02f,
  5.46146370e-02f, 4.51001674e-02f, -4.94937822e-02f, -3.73524316e-02f, 3.97109054e-03f, -5.28780073e-02f, -1.55487293e-02f, 5.40006310e-02f, -8.73892754e-03f, 5.51293716e-02f,
  1.11137331e-02f, -1.51790376e-03f, -2.41527823e-03f, 6.47388920e-02f, -9.92828533e-02f, 3.24249193e-02f, -1.84348579e-02f, -7.37250596e-02f, 9.00073163e-03f, 8.18423089e-03f,
  -1.17858090e-01f, 7.15604005e-03f, -5.41662611e-03f, 7.68244416e-02f, 1.60013773e-02f, 7.32286423e-02f, 4.89597954e-02f, 4.61051799e-02f, 3.46674919e-02f, 3.40995714e-02f,
  5.63340113e-02f, -4.19893116e-02f, 2.01545302e-02f, -2.90990695e-02f, 4.13935930e-02f, 3.15425044e-04f, -3.56470421e-02f, 7.02407286e-02f, -1.47948479e-02f, 1.95080950e-03f,
  2.80422182e-03f, 4.82383184e-02f, -1.60994790e-02f, 3.54589080e-03f, -3.02385800e-02f, -1.89020038e-02f, 4.84015979e-02f, -6.59627141e-03f, 1.52285974e-02f, -9.46719758e-03f,
  2.36721933e-01f, 1.34759471e-01f, -7.66152469e-03f, 5.66824190e-02f, 1.19809341e-02f, 4.98393492e-04f, -6.39453083e-02f, -4.42953482e-02f, 5.91929443e-02f, 6.41880408e-02f,
  1.59132611e-02f, 1.60670374e-02f, 1.07485000e-02f, -2.40932442e-02f, 1.82275157e-02f, 4.30402607e-02f, -1.53596466e-02f, 2.10467447e-02f, 3.57890502e-02f, 2.54095010e-02f,
  8.47541094e-02f, 2.35180221e-02f, -5.80307096e-02f, -1.20366603e-01f, 2.27049775e-02f, 2.89311651e-02f, 5.69193577e-03f, -5.89885227e-02f, 1.64064430e-02f, 1.83296055e-02f,
  -2.03830972e-02f, -2.61037908e-02f, -2.14763910e-01f, -4.49543521e-02f, 8.85123312e-02f, -1.98453981e-02f, -1.64062470e-01f, -1.19254505e-02f, -2.64255375e-01f, -4.13285196e-02f,
  6.96571842e-02f, -4.26634168e-03f, -6.47373497e-02f, 7.26897568e-02f, 1.11542962e-01f, -8.91414434e-02f, 1.98016018e-01f, 1.10710710e-02f, 9.94559973e-02f, 5.98507486e-02f,
  8.62808824e-02f, 2.75505424e-01f, 1.78267971e-01f, 2.23831356e-01f, 1.08464278e-01f, 2.01904923e-02f, 2.00703859e-01f, 1.51894186e-02f, 1.73327461e-01f, 2.02123988e-02f,
  9.74581391e-02f, -7.10917190e-02f, 7.48466179e-02f, -8.31220113e-03f, 1.28348023e-01f, -5.87260500e-02f, 1.71469823e-02f, -4.92713004e-02f, -1.24095324e-02f, -3.34628783e-02f,
  -4.53257747e-02f, -5.54318614e-02f, 3.93629540e-03f, -6.23642914e-02f, -1.17053807e-01f, -1.83096137e-02f, 5.80565594e-02f, 5.19808866e-02f, -1.56207606e-02f, -2.88699213e-02f,
  1.86269898e-02f, 9.89239942e-03f, -2.02998146e-02f, -2.74007153e-02f, -3.19282757e-03f, 6.62829913e-03f, -3.00402362e-02f, 1.03874980e-02f, 4.68438603e-02f, -3.55509520e-02f,
  3.34451608e-02f, 3.09640728e-02f, 6.57401532e-02f, -2.92752739e-02f, 3.76416408e-02f, 1.31585086e-02f, -4.23634239e-02f, 1.17693190e-02f, 4.68009748e-02f, 1.94099254e-03f,
  4.65667658e-02f, 3.06662843e-02f, -5.18821105e-02f, -3.20241004e-02f, 1.30374487e-02f, -7.78907686e-02f, 6.82486072e-02f, -6.79785609e-02f, -3.17714699e-02f, 8.19907486e-02f,
  -5.55792972e-02f, -2.01749392e-02f, 2.31626853e-02f, -4.16691005e-02f, -2.44945809e-02f, -4.20583077e-02f, -8.60092938e-02f, -8.78611356e-02f, 2.91798394e-02f, 4.18499559e-02f,
  1.63430482e-01f, 7.49954358e-02f, 1.09924451e-01f, 1.10546313e-02f, 5.04918844e-02f, 9.73431468e-02f, -2.33443901e-02f, 6.79321215e-02f, 1.32999886e-02f, -6.34905696e-03f,
  4.54174317e-02f, 2.21579373e-02f, 5.77490516e-02f, -1.13485577e-02f, 5.12209050e-02f, -4.94975131e-03f, 1.63916498e-02f, 7.62511119e-02f, 1.52412817e-01f, 4.22040634e-02f,
  1.37765616e-01f, 5.02553135e-02f, 4.08524796e-02f, 1.12288006e-01f, 9.39977691e-02f, 1.46297179e-02f, 2.08461173e-02f, -2.02025771e-02f, 9.58540291e-02f, 3.24267801e-03f,
  -1.62697528e-02f, -1.55648202e-01f, -2.38867030e-02f, -1.68899775e-01f, 1.98282942e-01f, 2.86114424e-01f, 9.21831504e-02f, 7.20925406e-02f, -1.19535021e-01f, -1.29560575e-01f,
  1.09538004e-01f, -2.27029815e-01f, 5.60120866e-03f, -1.03294380e-01f, 1.49781123e-01f, -1.20617479e-01f, -6.41409978e-02f, -1.54609635e-01f, -3.56991426e-03f, -2.43219472e-02f,
  5.48662841e-02f, 4.27523926e-02f, 1.52236829e-02f, 5.72638661e-02f, 5.87199554e-02f, -5.42708635e-02f, -1.43280206e-02f, -5.11757284e-03f, -6.91989087e-04f, 1.77408960e-02f,
  1.03964210e-01f, -8.02342892e-02f, 1.33581636e-02f, 7.02037709e-03f, 2.19079703e-02f, 5.97143918e-02f, 2.22833790e-02f, 1.18183726e-02f, 3.37588452e-02f, 8.34636157e-04f,
  -2.89612524e-02f, -9.83427372e-03f, -4.55417112e-02f, -3.53821088e-03f, 1.85841061e-02f, -1.53370770e-02f, 2.99905892e-02f, 9.70623642e-02f, -4.56324816e-02f, -2.37305984e-02f,
  2.33147461e-02f, -2.00744122e-02f, 3.46466489e-02f, -7.50676617e-02f, -2.54072659e-02f, -1.73012335e-02f, 6.02877885e-03f, -3.26258456e-03f, 1.23744477e-02f, -1.67464260e-02f,
  -4.50894162e-02f, -2.00572517e-02f, -1.44995218e-02f, 4.26406749e-02f, 4.70292270e-02f, 1.70784313e-02f, 1.54335666e-02f, 2.99907029e-02f, -2.42638402e-02f, -9.76158958e-03f,
  3.29713188e-02f, -8.92365649e-02f, 2.29762811e-02f, 4.93929572e-02f, 3.46598886e-02f, -4.47780974e-02f, -4.70712073e-02f, -2.67471038e-02f, 1.91863626e-02f, 4.20881361e-02f,
  1.74317397e-02f, 2.65471376e-02f, -2.36777216e-02f, 9.38056689e-03f, 9.90140066e-02f, -3.62444147e-02f, -2.83397175e-02f, 1.95953883e-02f, 4.27944697e-02f, 2.89568920e-02f,
  2.45495467e-04f, -8.53132457e-02f, -7.71315582e-03f, 2.36424641e-03f, -1.86863746e-02f, -3.14965248e-02f, -6.91493275e-03f, -1.34136686e-02f, -1.33418050e-02f, -2.87119509e-03f,
  6.05468042e-02f, -3.38389166e-02f, 2.13870909e-02f, -4.18487377e-03f, -6.66407542e-03f, 2.90482286e-02f, 6.96594594e-03f, -6.25704601e-02f, 6.33756295e-02f, 8.92241113e-03f,
  2.58447006e-02f, -3.76491388e-03f, -1.83379706e-02f, 1.23308720e-02f, -7.19466596e-04f, 3.20811220e-03f, 4.24177796e-02f, 5.96882030e-03f, 2.19442341e-02f, -5.58355562e-02f,
  -4.34084330e-03f, 1.46758735e-01f, 7.83431157e-02f, 1.72863826e-01f, 1.50238678e-01f, 1.25541762e-01f, -2.52874922e-02f, 1.84036270e-01f, 1.69775605e-01f, -6.52459171e-03f,
  4.33251970e-02f, 1.34218037e-01f, -1.11291274e-01f, 1.48527384e-01f, 3.53985876e-01f, -6.63210228e-02f, 2.46309727e-01f, -2.86098868e-02f, 2.41781399e-02f, 1.67209938e-01f,
  7.45491609e-02f, 2.11301222e-01f, 5.78815788e-02f, 1.05686188e-01f, 2.15915386e-02f, -6.23858087e-02f, 1.26754582e-01f, -6.97858408e-02f, 5.24729528e-02f, 7.85906911e-02f,
  3.24683003e-02f, 1.84617825e-02f, -4.92475331e-02f, -4.68284003e-02f, 3.85106960e-03f, -7.65348598e-02f, -6.86354190e-02f, 1.37951011e-02f, 2.12723576e-02f, -5.14978729e-02f,
  -8.82842168e-02f, 1.96747892e-02f, 4.79906388e-02f, -2.38577295e-02f, -2.14415714e-02f, 7.61973904e-03f, -1.72576364e-02f, -1.20991888e-02f, 1.59272924e-02f, -1.60776358e-02f,
  -1.19862501e-02f, -9.71563309e-02f, 1.50588816e-02f, -6.09291717e-02f, -5.35329571e-03f, 4.77163456e-02f, 1.67928729e-02f, -5.06272390e-02f, -3.10427547e-02f, 7.63808265e-02f,
  -7.68418564e-03f, 2.95659099e-02f, -4.77164425e-02f, -6.76020223e-04f, 8.77209231e-02f, -5.26466183e-02f, 5.61349355e-02f, -1.15381321e-02f, -5.33009842e-02f, -1.81535799e-02f,
  2.86269505e-02f, 1.40559031e-02f, -2.74461638e-02f, -7.57717807e-03f, -2.09083445e-02f, 3.55140492e-02f, -3.94552611e-02f, -7.49918520e-02f, -1.98878571e-02f, 1.82703435e-02f,
  -1.96865704e-02f, 8.23351219e-02f, -5.90795018e-02f, -7.17887133e-02f, 4.65884842e-02f, 3.32273468e-02f, -1.74680296e-02f, 8.63402616e-03f, 6.34570718e-02f, 5.76734683e-03f,
  3.31919640e-02f, 2.11134210e-01f, 1.44640021e-02f, -2.25196742e-02f, -3.74285667e-03f, 2.10662503e-02f, 1.01681538e-01f, -5.92518747e-02f, 3.80697027e-02f, -2.13922188e-02f,
  -4.92219115e-03f, 2.54284386e-02f, -2.87588295e-02f, 3.71658541e-02f, 1.34586245e-02f, 4.09110747e-02f, -2.49751266e-02f, 7.67944055e-03f, 1.02429487e-01f, 4.08814065e-02f,
  4.95776907e-02f, -2.86247320e-02f, 2.28395890e-02f, 3.25500481e-02f, -2.54135244e-02f, -4.04937714e-02f, 1.13502413e-01f, 5.09850681e-02f, -3.20770480e-02f, -8.49041343e-03f,
  -1.10472657e-01f, -4.94720340e-02f, -8.56949240e-02f, 1.35384247e-01f, 7.58320019e-02f, 2.59454161e-01f, 2.15258285e-01f, -1.11871492e-02f, 3.49297710e-02f, 1.58955351e-01f,
  1.04859926e-01f, -6.31664842e-02f, -1.45453051e-01f, 1.69367433e-01f, -1.05763279e-01f, -1.67180344e-01f, 2.13333771e-01f, 1.58679530e-01f, -8.33673924e-02f, -8.22220445e-02f,
  -2.85731126e-02f, 1.23537026e-01f, -9.33040753e-02f, -7.62072206e-02f, 2.22765002e-02f, -9.47068781e-02f, 1.88752599e-02f, -1.20012961e-01f, 2.20399812e-01f, 5.77316768e-02f,
  2.13360023e-02f, -1.30583942e-01f, 5.55154169e-03f, -9.14558247e-02f, 3.48067284e-02f, 9.36194975e-03f, 1.67942885e-02f, -4.10647504e-02f, -7.09147286e-03f, 5.51095186e-03f,
  -1.45436954e-02f, -9.77483764e-02f, -4.53101704e-03f, -7.37634078e-02f, -7.18278252e-03f, -1.55456075e-02f, 8.78883468e-04f, 3.41218971e-02f, -9.37450118e-03f, -7.89092258e-02f,
  -4.46324237e-02f, -2.54688058e-02f, 2.70263068e-02f, 1.56705435e-02f, 4.63114642e-02f, -3.22194807e-02f, -1.29511105e-02f, 3.72136943e-02f, 9.77749527e-02f, 6.12212298e-03f,
  2.09184806e-03f, -1.17437869e-01f, 1.39460042e-02f, 1.32776732e-02f, -4.18404043e-02f, -1.94566585e-02f, 4.68200259e-02f, -4.21111360e-02f, -3.03025218e-03f, -3.59015465e-02f,
  2.95914989e-02f, 1.19403834e-02f, -6.76865205e-02f, -1.39286593e-02f, 9.26164687e-02f, 2.57810205e-03f, 4.08359878e-02f, 4.95234653e-02f, 8.57389867e-02f, 9.80076045e-02f,
  -6.15112148e-02f, -2.39966754e-02f, 4.94552553e-02f, 1.57535039e-02f, -3.37358229e-02f, 2.06426010e-02f, 4.55198763e-03f, 3.70846950e-02f, 1.64827593e-02f, 6.33548796e-02f,
  1.09745935e-01f, 7.55664613e-03f, 4.54306342e-02f, 4.47777659e-02f, -8.67103040e-03f, -6.17266446e-02f, -2.81030759e-02f, 1.35502629e-02f, -3.11262906e-02f, -3.02907936e-02f,
  9.68583487e-03f, 2.43423488e-02f, 5.42412549e-02f, 4.34681214e-03f, 6.45668991e-03f, 9.93722603e-02f, 4.70148213e-02f, 4.43962067e-02f, 6.90421760e-02f, 5.53166345e-02f,
  1.66922603e-02f, 9.18299053e-03f, -4.14588600e-02f, 4.36365865e-02f, 8.78768265e-02f, 3.19173597e-02f, 4.79846001e-02f, -4.94158231e-02f, 3.85950767e-02f, 2.75241062e-02f,
  1.70680463e-01f, 2.12031171e-01f, 1.20173730e-01f, 1.34144664e-01f, 2.22657379e-02f, -1.62090555e-01f, -2.32278600e-01f, 1.33926317e-01f, 1.07984044e-01f, -1.75738670e-02f,
  -5.57946600e-02f, 8.17091540e-02f, -1.13457747e-01f, -3.39707918e-02f, -2.98870683e-01f, -1.69520184e-01f, -3.80627252e-02f, 1.70828812e-02f, 3.55153643e-02f, 5.13853654e-02f,
  3.81868854e-02f, -9.58726648e-03f, -4.68882732e-02f, 1.56697109e-01f, 2.19060242e-01f, 1.58380449e-01f, 2.89997067e-02f, -4.59366627e-02f, 7.43308589e-02f, -9.22542959e-02f,
  -7.79719949e-02f, 9.37554166e-02f, 2.55757477e-02f, 1.80841275e-02f, 6.49020225e-02f, -6.85254261e-02f, -6.14148751e-02f, -1.31246388e-01f, -6.36523888e-02f, -1.63018797e-02f,
  -6.06801473e-02f, -1.91645753e-02f, 3.15092988e-02f, 3.67453210e-02f, 1.06039504e-02f, 1.54959271e-02f, 4.86113057e-02f, 2.92720050e-02f, 2.54156310e-02f, 5.76188862e-02f,
  6.10527955e-02f, 3.04698944e-02f, 7.99276233e-02f, -5.11380099e-02f, -1.88023224e-02f, 4.93580736e-02f, -6.14373339e-03f, -4.85026613e-02f, -5.31222746e-02f, 6.20164573e-02f,
  2.75451336e-02f, 2.18187869e-02f, -3.71033363e-02f, 1.56512298e-02f, -1.90928169e-02f, -5.88155398e-03f, -3.42886709e-02f, -5.05715944e-02f, 2.91144904e-02f, -1.56700686e-02f,
  6.81221485e-03f, -2.28340607e-02f, -2.82936040e-02f, 2.86584534e-02f, 4.20829579e-02f, 6.71827644e-02f, -4.33952585e-02f, 1.34866014e-02f, 7.87217449e-03f, 6.77307993e-02f,
  -6.24590600e-03f, -4.23138030e-02f, 5.34654260e-02f, -1.20382197e-03f, -4.45139110e-02f, 9.46160499e-03f, 3.71958390e-02f, 6.95089921e-02f, -4.04126570e-02f, 1.41885206e-02f,
  -3.14804539e-02f, 1.47587746e-01f, 1.57001261e-02f, -3.35416594e-03f, -5.32804653e-02f, 1.50105916e-02f, 1.20598497e-02f, 4.49572653e-02f, 5.62012121e-02f, 1.23629291e-02f,
  -6.08462505e-02f, -1.48681868e-02f, 4.84820306e-02f, -3.88354100e-02f, -2.01733410e-02f, 7.58292899e-02f, -6.89091980e-02f, -4.36160825e-02f, 2.09251456e-02f, 2.13616993e-02f,
  7.97591954e-02f, 5.17282635e-03f, -3.76774743e-02f, 1.44151360e-04f, 2.47244202e-02f, -3.72627228e-02f, 6.15127981e-02f, -5.62733039e-03f, 5.41634997e-03f, 1.38327538e-03f,
  7.37101212e-02f, -1.02613337e-01f, 2.16203034e-01f, 9.08183903e-02f, 7.33811248e-05f, 1.20209046e-02f, 2.73787919e-02f, 1.99458543e-02f, 2.92345345e-01f, -3.23813915e-01f,
  -1.37520179e-01f, 2.23636404e-02f, 7.12672919e-02f, -2.87087470e-01f, 2.57679820e-01f, 1.49140999e-01f, -8.81637335e-02f, -3.69236991e-02f, 1.62309796e-01f, -1.46369353e-01f,
  7.47677535e-02f, -2.82598317e-01f, 9.13795009e-02f, -2.19209850e-01f, -1.28924027e-01f, 3.86545919e-02f, -2.55638003e-01f, 1.49686828e-01f, -2.49887705e-01f, 7.89048988e-03f,
  -8.02630465e-03f, 8.20808392e-03f, 2.07850821e-02f, 6.58696443e-02f, 7.39923771e-03f, -6.87258020e-02f, -5.29890656e-02f, 1.10424072e-01f, 1.07480429e-01f, -4.94244844e-02f,
  -2.60166675e-02f, -1.99421141e-02f, 1.64530668e-02f, 3.60629056e-03f, -6.29481743e-04f, -4.98327427e-03f, 3.17805447e-02f, 2.07352582e-02f, 2.40932759e-02f, 3.18833068e-02f,
  7.09958225e-02f, 2.58678067e-02f, 6.29274349e-04f, -7.46949837e-02f, 8.54396224e-02f, 4.11449783e-02f, 5.40159037e-03f, 7.76787102e-03f, -2.13192273e-02f, 5.20626269e-02f,
  -4.91804890e-02f, 2.34210747e-03f, 2.67726984e-02f, -3.61020640e-02f, 2.86273323e-02f, -1.41027651e-03f, -5.69815375e-02f, -6.65736794e-02f, 5.19735999e-02f, -5.31610064e-02f,
  -3.26469094e-02f, 4.50502057e-03f, -9.73347761e-03f, -4.57685143e-02f, -4.21957187e-02f, -3.98681499e-02f, -5.62148839e-02f, -1.49934145e-03f, -4.87677157e-02f, 3.88664603e-02f,
  -4.19381894e-02f, 7.01007098e-02f, 2.04744469e-03f, -1.84154157e-02f, -2.07387544e-02f, 4.07253876e-02f, -5.31602390e-02f, -1.45105775e-02f, 3.26729119e-02f, 7.30438828e-02f,
  3.19051817e-02f, -7.59156123e-02f, 3.97033282e-02f, -1.30817830e-03f, -5.33386357e-02f, -8.44134763e-02f, 5.30180298e-02f, -3.29747200e-02f, 4.37963009e-02f, -5.93172275e-02f,
  -2.00372208e-02f, -1.64286215e-02f, -7.70891085e-03f, -2.13859510e-02f, 6.46860376e-02f, -5.55411354e-02f, -4.91802171e-02f, -3.95737328e-02f, -7.57902414e-02f, -5.46363443e-02f,
  -6.69279248e-02f, -4.80734147e-02f, -2.86508594e-02f, -4.48278971e-02f, -1.25442505e-01f, -2.98086349e-02f, -5.13742268e-02f, 8.92104506e-02f, 7.77490344e-03f, -8.01920425e-03f,
  -2.14017808e-01f, 8.44513774e-02f, 1.52699754e-01f, -7.05911368e-02f, -1.93251342e-01f, -5.37982471e-02f, -1.13239691e-01f, -1.50000975e-02f, 4.76971865e-02f, -3.35260630e-02f,
  -1.07402690e-01f, -1.05092833e-02f, 2.66732270e-04f, 5.63653558e-02f, 1.91405848e-01f, 2.51036376e-01f, 5.11635132e-02f, -3.20368074e-02f, 3.98994870e-02f, -8.10760260e-02f,
  8.55264217e-02f, -7.80970901e-02f, 1.67374715e-01f, -3.34362127e-02f, -1.52016088e-01f, -2.08473448e-02f, -3.42399888e-02f, -6.27036095e-02f, -5.14217056e-02f, -4.73184176e-02f,
  -2.15707589e-02f, 4.99241389e-02f, 7.82824680e-03f, 9.39771608e-02f, 5.31490482e-02f, -2.63267625e-02f, -1.35999266e-02f, -5.32067148e-03f, 3.18969004e-02f, 4.56074513e-02f,
  -7.36815408e-02f, -1.62150040e-02f, -1.75656425e-03f, 1.40080025e-04f, -7.63913468e-02f, 3.59557290e-03f, 2.42481362e-02f, -9.41654854e-03f, 1.05868317e-02f, -1.15135610e-02f,
  1.21266572e-02f, 7.18956739e-02f, -5.91485947e-02f, 5.33713214e-02f, -1.65346935e-02f, 2.23991275e-02f, 6.92475215e-02f, -4.36315872e-02f, 3.16387787e-02f, -1.33340526e-02f,
  -6.08051457e-02f, -2.35054903e-02f, 1.07245184e-02f, 1.35924397e-02f, -2.66752057e-02f, -2.77988855e-02f, 8.88200768e-04f, -3.59483436e-02f, 5.14073437e-03f, -4.18992341e-03f,
  1.07711519e-03f, -4.24880013e-02f, -5.67559525e-02f, 4.42442251e-04f, -4.88749966e-02f, 2.53654979e-02f, 5.18192127e-02f, 1.36891529e-02f, -4.05520834e-02f, -3.39918844e-02f,
  4.85569648e-02f, 1.37074012e-03f, -3.16258818e-02f, -3.51489596e-02f, -1.31564680e-02f, -7.35195773e-03f, -1.65972095e-02f, 3.54772359e-02f, 4.41240966e-02f, -3.98253053e-02f,
  6.47876337e-02f, 8.65687951e-02f, 3.17843864e-03f, -1.22938724e-02f, 2.45634336e-02f, -2.88807880e-02f, 2.57878080e-02f, -1.92513205e-02f, 4.52496111e-02f, -9.47111566e-03f,
  2.82712863e-04f, -5.20344861e-02f, -2.65077921e-03f, -2.83752438e-02f, 1.50721157e-02f, 3.18182968e-02f, 3.32098790e-02f, 1.41588505e-02f, -6.88723195e-03f, -1.78541727e-02f,
  -7.71523640e-02f, -3.93225439e-02f, 4.14014272e-02f, -7.64621124e-02f, 2.79024672e-02f, 2.80569680e-02f, -5.48903421e-02f, 4.32807580e-02f, -1.42165245e-02f, 5.31436577e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.58088261e-01f, 8.56425762e-02f, -3.45015109e-01f, -4.61212918e-02f, -2.49312878e-01f, 2.85169989e-01f, 2.57266134e-01f, -9.25020501e-02f, -1.88449040e-01f, 3.39805633e-01f,
  2.64028251e-01f, -9.50675383e-02f, 1.96161076e-01f, 4.12812442e-01f, -4.88736592e-02f, 2.49643192e-01f, 2.87120700e-01f, 1.92021593e-01f, -1.48723811e-01f, 1.42086431e-01f,
  -8.90046656e-02f, 3.72104526e-01f, -9.48390178e-03f, -5.39939031e-02f, 1.19999126e-01f, -2.72739857e-01f, -8.18320736e-02f, -2.45771587e-01f, 3.07898242e-02f, -6.11344390e-02f,
  1.53365597e-01f, 6.01992197e-02f, -1.16234506e-02f, 7.51830288e-04f, 1.49474135e-02f, 5.67089859e-03f, -8.19135085e-02f, -3.67943197e-02f, -9.52367187e-02f, -5.53182187e-03f,
  5.03068380e-02f, -1.66933015e-02f, 3.38844173e-02f, -6.53292909e-02f, -3.36213596e-02f, -7.02660903e-02f, -1.14961676e-02f, -7.19710737e-02f, 1.01713864e-02f, 3.62700298e-02f,
  -2.95155961e-02f, -4.54213321e-02f, 1.77774690e-02f, 1.26635784e-03f, -1.06969990e-01f, 2.89053731e-02f, -1.17900362e-02f, -4.26445492e-02f, -7.68629427e-04f, -1.42107932e-02f,
  7.80712739e-02f, 9.80358571e-03f, 7.34902546e-02f, 3.44566703e-02f, -9.79656167e-03f, 2.91611790e-03f, 6.31595179e-02f, 1.14739034e-02f, -5.21040633e-02f, 5.35018407e-02f,
  -4.73334379e-02f, -3.28250378e-02f, 2.46115644e-02f, 2.48472281e-02f, 6.71528354e-02f, 8.15993696e-02f, -1.07188504e-02f, 3.29482518e-02f, -1.92023292e-02f, -2.77870111e-02f,
  -2.14545820e-02f, 1.11497454e-02f, -7.91146979e-03f, -2.64810938e-02f, 5.20446673e-02f, -8.40668231e-02f, 6.21678531e-02f, 2.39958223e-02f, -1.86795443e-02f, -4.01316434e-02f,
  1.15576191e-02f, 5.12369983e-02f, -7.56522790e-02f, 1.00870326e-03f, -8.45703855e-02f, 3.71553041e-02f, 1.46954469e-02f, 8.55357386e-03f, -8.09669420e-02f, 7.08998665e-02f,
  5.87167554e-02f, -3.91387083e-02f, -2.61084791e-02f, -6.74518496e-02f, -7.85899535e-02f, 4.86932732e-02f, 9.29626003e-02f, -5.39237745e-02f, -2.28178445e-02f, -5.10422587e-02f,
  1.04580233e-02f, 2.84585170e-02f, -2.06273869e-02f, 1.18706506e-02f, 3.13496552e-02f, 3.95750590e-02f, -6.86521679e-02f, -5.37642837e-02f, -8.28037784e-02f, -4.08389531e-02f,
  2.13168293e-01f, 2.85876423e-01f, 1.27719447e-01f, 1.92973673e-01f, 1.63089246e-01f, 2.42725059e-01f, 2.43393719e-01f, 2.01715484e-01f, 4.09520894e-01f, -1.68014556e-01f,
  -1.47716150e-01f, -2.38568559e-02f, -1.60265222e-01f, 4.99514826e-02f, -5.17490469e-02f, 7.90505707e-02f, 1.89518943e-01f, 1.33779332e-01f, 2.32114464e-01f, -8.92627463e-02f,
  5.57148941e-02f, -2.23019257e-01f, -1.92088813e-01f, -1.98930383e-01f, 1.45046571e-02f, 3.96905438e-04f, -2.23114535e-01f, 5.74724451e-02f, -1.28393739e-01f, 1.08609080e-01f,
  4.01837341e-02f, 5.75351678e-02f, -5.87476231e-03f, 1.04680859e-01f, 4.40174565e-02f, -6.35333732e-02f, -4.96925302e-02f, 1.26246437e-02f, 2.57852450e-02f, 3.06495186e-02f,
  -3.60924788e-02f, -8.29663575e-02f, 1.15899304e-02f, -8.57825857e-03f, 8.94841179e-02f, -2.95803230e-02f, 1.75686646e-02f, 3.23895216e-02f, 4.11416180e-02f, 2.07932703e-02f,
  7.11940986e-04f, 1.28244236e-01f, 4.56226021e-02f, 5.24777398e-02f, 9.20348167e-02f, 1.43635347e-01f, 5.62314875e-02f, 6.49588406e-02f, 5.65423742e-02f, 6.48169592e-02f,
  -5.29589728e-02f, 1.76446363e-01f, -6.70262948e-02f, -1.33219033e-01f, 4.37504761e-02f, 3.79126403e-03f, -1.58177260e-02f, -3.40387635e-02f, 1.06635235e-01f, 3.31525467e-02f,
  8.60574320e-02f, 5.51393395e-03f, 1.19643494e-01f, 9.90312099e-02f, -2.28969231e-02f, -6.12561516e-02f, -2.56503616e-02f, 2.00530011e-02f, 6.87979683e-02f, -6.99002817e-02f,
  -6.13918938e-02f, -7.33449589e-03f, -3.70614268e-02f, -1.03353932e-01f, 4.35529873e-02f, -4.13845703e-02f, -8.78256410e-02f, -2.54069660e-02f, -8.46315734e-03f, 9.24315676e-03f,
  9.07043219e-02f, 1.20585799e-01f, 4.67292219e-03f, -1.94265402e-03f, -1.22868512e-02f, -6.88362494e-02f, -2.75760032e-02f, 6.84330836e-02f, 5.75545207e-02f, -3.67126390e-02f,
  1.18584111e-02f, -4.19155806e-02f, -1.67484153e-02f, -5.00208698e-03f, -3.78733128e-02f, -6.44425154e-02f, 1.06520252e-02f, 6.64691925e-02f, -1.36365965e-02f, -4.44946662e-02f,
  -4.47428823e-02f, -4.10432033e-02f, -2.11369991e-02f, 1.88168511e-02f, 3.87259983e-02f, -4.23691124e-02f, 4.30688774e-03f, 8.21792111e-02f, -4.31227833e-02f, 3.35150287e-02f,
  -1.78688094e-01f, 3.83766353e-01f, 3.49781394e-01f, -1.24780364e-01f, -1.95106417e-01f, -1.74338743e-02f, -8.61301869e-02f, 8.31904188e-02f, 5.87984845e-02f, 2.74797857e-01f,
  2.23507918e-02f, 1.70485541e-01f, -4.44915295e-02f, 1.18521735e-01f, -3.04175526e-01f, -2.02182174e-01f, -5.24909347e-02f, 8.14190805e-02f, -3.84179913e-02f, -3.26716043e-02f,
  -1.88380912e-01f, -3.20806503e-01f, -5.66964447e-02f, -3.70150548e-03f, 1.77755967e-01f, 1.54792607e-01f, -2.53321350e-01f, -1.38084413e-02f, 1.82907552e-01f, 1.92041881e-02f,
  1.09262131e-01f, -5.66714630e-02f, 1.87410861e-01f, 5.66612259e-02f, 7.89161921e-02f, 8.91406387e-02f, 5.78672402e-02f, -2.91340351e-02f, -5.05167432e-02f, 6.64163604e-02f,
  2.27813069e-02f, 1.95763763e-02f, 2.12309845e-02f, 4.55342643e-02f, 2.35867351e-02f, 1.33007303e-01f, 7.27092177e-02f, 6.72537237e-02f, 7.92333111e-02f, 1.18592910e-01f,
  1.10018767e-01f, 9.89862531e-02f, -5.75250154e-03f, 1.91902295e-02f, -1.30657861e-02f, 4.02638242e-02f, -3.45018022e-02f, 4.20639738e-02f, 6.73519224e-02f, 2.72089466e-02f,
  -8.10382143e-03f, -1.33094400e-01f, 1.35911712e-02f, 1.35382349e-02f, -3.29159833e-02f, 6.34084120e-02f, 2.80372445e-02f, -8.68526101e-03f, -3.19984294e-02f, -6.23473562e-02f,
  -6.85450211e-02f, 1.43725211e-02f, -1.03134960e-01f, -1.74709801e-02f, 7.40795024e-03f, 7.75275305e-02f, -7.07349256e-02f, 1.82031915e-02f, 1.28579270e-02f, 2.80887745e-02f,
  -4.57543358e-02f, -1.01381401e-02f, 3.45043316e-02f, -4.50033620e-02f, -1.33893751e-02f, -2.09645890e-02f, 3.45848240e-02f, 4.59181853e-02f, 2.59940699e-02f, -1.25425950e-01f,
  -1.77755624e-01f, -3.21535170e-01f, -7.64598027e-02f, 1.47828773e-01f, -1.62413865e-02f, 1.12131676e-02f, -6.70005828e-02f, 9.15943310e-02f, -3.19456086e-02f, -6.24767058e-02f,
  4.54946011e-02f, 2.73087192e-02f, -1.63176116e-02f, 1.38284918e-02f, -4.18158360e-02f, -3.64425443e-02f, -1.46493345e-01f, -5.10505438e-02f, -6.26736730e-02f, 6.61785156e-02f,
  1.66881494e-02f, -3.11094206e-02f, 8.74597654e-02f, -2.40737535e-02f, -2.50758268e-02f, 1.89690515e-02f, -6.30648211e-02f, 7.84998909e-02f, -5.81137538e-02f, 1.66994147e-02f,
  2.84832716e-01f, -3.75252992e-01f, -1.02597177e-01f, -1.18396759e-01f, 3.44706289e-02f, -2.35163391e-01f, -1.30820945e-02f, -2.95334697e-01f, -1.01414338e-01f, -3.27892423e-01f,
  8.90841335e-03f, 1.08743407e-01f, 1.64523080e-01f, -1.57711729e-01f, 4.27338660e-01f, 1.68509752e-01f, -1.23916246e-01f, -3.45340744e-03f, 1.22170307e-01f, -1.03959471e-01f,
  2.94226333e-02f, -1.72068447e-01f, 2.08060797e-02f, -3.15222114e-01f, -1.47705153e-01f, -1.82810843e-01f, 8.23308006e-02f, 5.44938259e-02f, -2.73957610e-01f, 8.49515572e-02f,
  4.34276015e-02f, 2.81704310e-02f, -2.90635061e-02f, -4.24140133e-02f, -4.41249087e-02f, 1.54977767e-02f, 7.45918378e-02f, 1.25597075e-01f, 6.45422712e-02f, 1.53135974e-02f,
  1.06335364e-01f, -5.10729523e-03f, -8.61031488e-02f, 4.08945940e-02f, -1.00950681e-01f, -5.21838740e-02f, -3.14777903e-02f, -4.63506178e-04f, -8.45157653e-02f, 3.46122198e-02f,
  3.71785872e-02f, 2.77265720e-03f, 1.57415755e-02f, -4.37569991e-02f, -3.12967338e-02f, -1.78017765e-02f, 5.25037237e-02f, 2.42218580e-02f, 2.72731371e-02f, -4.03268784e-02f,
  -5.68852536e-02f, 5.51764220e-02f, -2.59386804e-02f, -5.71818613e-02f, -1.91338565e-02f, -4.74988073e-02f, 2.18270142e-02f, 4.47402569e-03f, 3.15572359e-02f, -7.61926733e-03f,
  -3.84073108e-02f, 3.88462620e-04f, -1.26794344e-02f, -3.73792555e-03f, 3.80751826e-02f, 6.07760437e-02f, 1.01674721e-01f, 2.66738236e-02f, -5.25118448e-02f, 1.50423665e-02f,
  6.04155138e-02f, -5.98516734e-03f, -3.68584394e-02f, -2.92935073e-02f, 1.82280131e-02f, 2.81146709e-02f, -6.61056712e-02f, -4.39590625e-02f, -3.13846883e-03f, 3.39070074e-02f,
  -3.21310535e-02f, -1.61739245e-01f, -2.35320851e-02f, -5.23620173e-02f, 2.92166490e-02f, 3.20782773e-02f, 2.93959435e-02f, -8.34903345e-02f, -2.41438914e-02f, 8.80253408e-03f,
  -2.66942903e-02f, 5.17743174e-03f, -3.17588784e-02f, -2.68627889e-02f, -4.39770184e-02f, -1.04026645e-01f, 7.26361154e-03f, 3.39643285e-02f, 6.90645427e-02f, -4.62332107e-02f,
  -5.32854088e-02f, -2.56180763e-02f, 1.07748127e-02f, -1.17037401e-01f, -8.19127932e-02f, 8.69872272e-02f, 2.44439226e-02f, -3.27598527e-02f, -2.60435082e-02f, 1.06265666e-02f,
  7.78889954e-02f, 2.09734485e-01f, -2.96271443e-02f, -6.70893714e-02f, -3.26839276e-02f, -1.16334312e-01f, -1.06727034e-01f, -6.73724934e-02f, -6.61549568e-02f, 6.83841622e-03f,
  -1.05632745e-01f, 1.89843491e-01f, -5.26895747e-02f, -3.99252884e-02f, -3.36752594e-01f, -1.78510606e-01f, -1.26126662e-01f, 2.98617557e-02f, -3.98018211e-02f, -3.12909372e-02f,
  -7.12011009e-02f, -2.70561576e-01f, -1.07332736e-01f, -1.04448408e-01f, 1.56116551e-02f, 1.64441824e-01f, -1.51983336e-01f, -6.91467077e-02f, 2.00481527e-02f, -6.18153671e-03f,
  7.73506612e-02f, 3.07502169e-02f, 1.12286337e-01f, 7.19185360e-03f, -3.84633169e-02f, 1.16430325e-02f, 5.21210581e-02f, 7.44141638e-02f, -2.78672036e-02f, -1.13631738e-02f,
  -7.65941571e-03f, -3.37648913e-02f, 3.92548293e-02f, -8.67238045e-02f, -7.49220103e-02f, -2.33027618e-03f, 5.65886647e-02f, 1.04780145e-01f, 1.20730534e-01f, -1.25478543e-02f,
  1.87139641e-02f, 8.28679949e-02f, -1.03349306e-01f, -4.13596258e-02f, -6.53628707e-02f, -4.48294915e-03f, 2.39454280e-03f, -9.61779151e-03f, 5.06274179e-02f, -4.30810302e-02f,
  1.18492241e-03f, -4.22889926e-02f, -4.06272672e-02f, 8.60622451e-02f, 1.34399836e-03f, 7.38744484e-03f, -1.70735251e-02f, 3.85514013e-02f, -3.17453928e-02f, 1.98729653e-02f,
  2.91573461e-02f, 4.66155484e-02f, -3.39156277e-02f, -9.63665470e-02f, -6.27808496e-02f, 6.45074546e-02f, 4.30246675e-03f, 8.06787908e-02f, 8.83231033e-03f, 3.56270559e-02f,
  1.87070388e-02f, -2.04188265e-02f, -1.19520966e-02f, -3.66531312e-02f, -9.67824087e-03f, 1.50663382e-03f, -1.93218999e-02f, 8.30327123e-02f, 4.64017279e-02f, -1.01816386e-01f,
  4.66070063e-02f, -5.65978326e-02f, 9.95232388e-02f, 4.07303944e-02f, 9.56136510e-02f, 6.02127193e-03f, -4.41861674e-02f, 4.75301817e-02f, -5.42678237e-02f, -7.60220140e-02f,
  -9.20202732e-02f, 6.04009023e-03f, -6.05015596e-03f, -5.11615127e-02f, -3.50043811e-02f, -2.19243187e-02f, 2.44701635e-02f, 3.71987782e-02f, 2.00689286e-02f, -6.64058607e-03f,
  4.24526632e-02f, 5.34288958e-02f, -6.08886331e-02f, -4.21026535e-02f, -4.89648134e-02f, -3.56955938e-02f, 7.71755353e-02f, 5.91621809e-02f, -6.54247031e-02f, -6.02434725e-02f,
  -6.94717407e-01f, 2.14032620e-01f, -1.25731140e-01f, -1.82913646e-01f, 1.75812095e-01f, -2.30248615e-01f, -2.28678770e-02f, 1.38255745e-01f, 5.33229746e-02f, 1.95419118e-01f,
  2.03122556e-01f, -1.03399292e-01f, 2.45049044e-01f, -7.61121651e-03f, -3.13721508e-01f, 9.70586091e-02f, -2.96291709e-01f, -1.42273143e-01f, 9.50893760e-02f, -1.51964098e-01f,
  -6.21650778e-02f, 1.50260732e-01f, -8.60763416e-02f, 3.35209697e-01f, -3.84019092e-02f, -7.45195150e-03f, -1.58957466e-01f, 2.80554354e-01f, -1.59291610e-01f, 1.34635314e-01f,
  -1.59780949e-01f, 1.75808936e-01f, -2.29532272e-02f, -2.34710090e-02f, -2.12049469e-01f, -5.74572831e-02f, -1.49115011e-01f, 3.11845373e-02f, 3.45852668e-03f, -1.97005775e-02f,
  -6.40868396e-02f, 4.16812561e-02f, -2.83771157e-02f, 1.41187489e-01f, 6.32082596e-02f, 2.76678847e-03f, -1.46519272e-02f, -9.88242179e-02f, 1.22090191e-01f, -4.07177955e-02f,
  8.78342763e-02f, -8.17283764e-02f, -1.13271564e-01f, -8.83676298e-03f, -4.39729951e-02f, 5.43924421e-02f, -7.09847733e-02f, -5.08504137e-02f, -8.80143568e-02f, -3.51517387e-02f,
  2.28205398e-02f, -8.73438641e-02f, 3.42667438e-02f, 1.55308833e-02f, 7.89875984e-02f, 4.13311608e-02f, 2.37184130e-02f, -3.27656716e-02f, -3.55129987e-02f, -2.36053485e-02f,
  -2.23101079e-02f, 1.52604294e-03f, 7.80944573e-03f, -1.17404819e-01f, 4.28727679e-02f, -1.26930587e-02f, -5.46962172e-02f, -3.21353823e-02f, -5.67969494e-02f, -8.44821855e-02f,
  7.57359341e-02f, 1.98901184e-02f, 2.24848781e-02f, 2.34166104e-02f, 5.31257465e-02f, 2.71210074e-02f, -5.76476268e-02f, -2.20819749e-02f, -8.20605904e-02f, -7.22267702e-02f,
  -3.54597837e-01f, -1.18884049e-01f, 1.84862614e-02f, 7.67710134e-02f, -2.08816137e-02f, -1.18434556e-01f, -3.50046828e-02f, -7.69188404e-02f, -4.57911305e-02f, -2.62699239e-02f,
  -1.08756371e-01f, -5.39661832e-02f, -1.70826167e-01f, 9.04817134e-03f, -1.34372227e-02f, -3.38914581e-02f, -3.61411385e-02f, -3.43723223e-02f, -8.96934494e-02f, -8.64735320e-02f,
  -3.99243124e-02f, 5.60003072e-02f, 1.60115547e-02f, 2.03416664e-02f, -2.23390702e-02f, -4.70184423e-02f, -6.25323951e-02f, 5.80075346e-02f, -4.83467318e-02f, 3.29834074e-02f,
  -3.24484557e-01f, 1.97875530e-01f, -2.05283493e-01f, -1.50348455e-01f, 1.13596700e-01f, -3.72736782e-01f, -9.39646140e-02f, 7.43658319e-02f, -1.30805194e-01f, 2.64521450e-01f,
  6.63190261e-02f, -1.35995612e-01f, 1.50180459e-01f, -2.22568095e-01f, -4.48033512e-01f, -2.74335921e-01f, -2.09796786e-01f, -1.45949855e-01f, -4.53741699e-02f, 1.30637333e-01f,
  -9.63397622e-02f, 4.78936844e-02f, -2.02530712e-01f, 2.39060923e-01f, 9.06370208e-02f, 1.51227012e-01f, 3.43419105e-01f, 1.08919613e-01f, 6.13699630e-02f, -6.42661229e-02f,
  -1.54243752e-01f, 6.59996197e-02f, -1.19597958e-02f, -8.17633420e-02f, -6.81745773e-03f, 5.86226769e-02f, 2.36412156e-02f, -1.75012350e-02f, -5.14535159e-02f, -6.52160197e-02f,
  3.15016732e-02f, 2.82772873e-02f, -5.95301799e-02f, -4.68170904e-02f, 6.12940975e-02f, -5.63291227e-03f, -8.95591229e-02f, -8.14702883e-02f, -3.47530022e-02f, -1.11585043e-01f,
  -9.75285843e-02f, -9.55950916e-02f, 6.42172322e-02f, -6.30636290e-02f, -4.44808789e-02f, 3.29920687e-02f, -1.66160502e-02f, -2.72561107e-02f, 8.87879636e-03f, -5.33013158e-02f,
  8.77425298e-02f, 2.65256204e-02f, -5.42480908e-02f, -9.75423753e-02f, -2.45995726e-03f, -7.74132460e-03f, 6.36037290e-02f, 1.67948436e-02f, 5.14417253e-02f, 6.15226589e-02f,
  1.33515336e-02f, 4.11756374e-02f, 1.04437312e-02f, 1.66425202e-02f, -1.90327838e-02f, -1.84312370e-02f, 4.24563512e-02f, 1.64256413e-02f, -1.86787657e-02f, -3.95937152e-02f,
  6.84366077e-02f, -8.51621968e-04f, -3.24209817e-02f, 8.65584761e-02f, -2.30487194e-02f, -7.19526643e-03f, 6.88492581e-02f, -2.82758567e-02f, 2.44356617e-02f, 1.16300210e-02f,
  7.40145519e-02f, 2.73011476e-01f, 4.03810292e-02f, -2.99822874e-02f, -1.16856750e-02f, -4.15700935e-02f, -2.77543385e-02f, -2.99809016e-02f, 6.39451146e-02f, 5.27576469e-02f,
  9.84681845e-02f, 1.79423448e-02f, 3.77088375e-02f, -3.37176509e-02f, 1.03576751e-02f, -1.07946899e-02f, 9.73576233e-02f, 1.86214186e-02f, 7.97818750e-02f, 3.51199210e-02f,
  1.24886028e-01f, 6.89821392e-02f, -1.81291357e-03f, -1.44774271e-02f, 5.83981574e-02f, 2.49258913e-02f, 7.28684664e-02f, 2.88280547e-02f, 1.01115899e-02f, 6.72669634e-02f,
  -5.53926945e-01f, -9.33798179e-02f, 3.69258225e-01f, -2.20691353e-01f, -1.19436644e-01f, 2.70350724e-01f, 3.66369992e-01f, -8.23329985e-02f, -1.91761166e-01f, -4.41985019e-02f,
  6.59531802e-02f, -5.71324080e-02f, 2.96935618e-01f, 4.99101765e-02f, 2.53424764e-01f, 1.64574653e-01f, 3.87117751e-02f, 4.95743193e-02f, -7.22600073e-02f, -1.38922215e-01f,
  -5.19201420e-02f, -9.57675576e-02f, 2.90333331e-01f, -2.28369966e-01f, -2.18113232e-02f, -2.16192052e-01f, -2.52139848e-02f, 1.00299731e-01f, -1.02858711e-02f, 7.72497132e-02f,
  -1.82993367e-01f, -2.97593594e-01f, -9.68518034e-02f, -4.10283245e-02f, -3.51848565e-02f, -1.69094894e-02f, 8.63230824e-02f, 3.31546441e-02f, -4.53861877e-02f, -2.72151288e-02f,
  -7.20557049e-02f, -5.81287481e-02f, -1.10190071e-01f, 4.41546068e-02f, -1.32535085e-01f, -3.86301838e-02f, 3.08430772e-02f, 5.55383340e-02f, -1.45081002e-02f, 1.29635394e-01f,
  1.50360957e-01f, 1.24289980e-02f, 3.65417674e-02f, 1.62329748e-02f, 1.03203632e-01f, -2.36031078e-02f, 3.53151858e-02f, 6.90624937e-02f, -3.25258374e-02f, -6.55452088e-02f,
  1.63855460e-02f, 6.28891215e-02f, 2.51958054e-02f, -1.47112533e-02f, 6.16098419e-02f, -3.36916484e-02f, 3.99336256e-02f, 2.20775306e-02f, -1.29623050e-02f, -2.31198482e-02f,
  3.58589808e-03f, -5.04512824e-02f, -4.16719876e-02f, -2.23863702e-02f, -1.04541294e-02f, -1.49284583e-02f, 6.69782981e-02f, -1.11135416e-01f, 4.21003141e-02f, -2.61354242e-02f,
  -5.68279950e-03f, -3.70234661e-02f, 4.37471867e-02f, 5.62870316e-03f, -1.85809145e-03f, 5.28625809e-02f, -1.08002320e-01f, 5.97663857e-02f, -4.07136604e-02f, 4.65701744e-02f,
  -2.91090250e-01f, -2.09044844e-01f, -3.82589288e-02f, -6.23116829e-02f, -2.82603297e-02f, -2.15285327e-02f, -5.30925579e-02f, -2.72289757e-02f, -6.25957102e-02f, -2.76832785e-02f,
  -4.86824568e-03f, -8.12038500e-03f, -8.17339793e-02f, 2.64368573e-04f, 8.77610222e-02f, 4.79628779e-02f, -7.93556124e-02f, -5.06062098e-02f, -7.09062582e-03f, -4.67655323e-02f,
  -2.73167975e-02f, -5.99288903e-02f, 5.05438484e-02f, -1.03933491e-01f, -6.67975005e-03f, 3.76754366e-02f, -1.79317787e-01f, -2.35472713e-02f, -1.61910430e-02f, 3.42763737e-02f,
  -2.72322502e-02f, 2.85464615e-01f, -2.14259420e-02f, -1.29603311e-01f, -6.34736568e-02f, -3.21572609e-02f, -1.24416374e-01f, 4.65836339e-02f, 2.74640080e-02f, -3.00736222e-02f,
  -1.66676775e-01f, 2.50719368e-01f, 1.97546557e-02f, -9.20593962e-02f, -1.28435239e-01f, -2.99585611e-02f, -9.74744037e-02f, -4.94303666e-02f, 9.72669572e-02f, -1.14256749e-02f,
  -9.72061884e-03f, -1.65870711e-01f, -1.02926023e-01f, 1.30839914e-03f, -1.58117950e-01f, 2.61671711e-02f, -2.09330961e-01f, -7.38864765e-02f, -1.19777560e-01f, 8.45445413e-03f,
  -1.33042142e-03f, -1.16504356e-01f, -6.01894073e-02f, 1.38372239e-02f, -1.24398351e-01f, 1.72965806e-02f, -4.01322544e-02f, -8.06428045e-02f, -1.05512261e-01f, -8.92140809e-03f,
  3.82643156e-02f, 3.57677490e-02f, 5.37688322e-02f, 2.09094137e-02f, 1.70830265e-02f, 2.39077909e-03f, 2.34225392e-02f, 6.00836538e-02f, -6.22756518e-02f, -1.48351947e-02f,
  7.55044520e-02f, 6.94097439e-03f, -1.10888965e-01f, -6.63498640e-02f, -8.42929725e-03f, -7.03407601e-02f, 6.19189255e-02f, -3.33144292e-02f, 6.56526312e-02f, -1.87665236e-03f,
  -9.08388477e-03f, -7.76715577e-03f, -4.52813953e-02f, -4.69826087e-02f, -8.25427379e-03f, 4.73730359e-03f, 2.99878716e-02f, 2.06124745e-02f, -1.59309141e-03f, -1.93395093e-02f,
  8.96374136e-03f, 1.06246285e-01f, -1.60163792e-04f, -7.18196901e-03f, 4.19570170e-02f, -4.83018942e-02f, -7.74602592e-02f, -4.32306677e-02f, 5.28183989e-02f, 7.93979093e-02f,
  3.33931260e-02f, -4.66754474e-03f, 1.19734414e-01f, 6.40458101e-03f, 3.66957597e-02f, -1.30619183e-02f, 8.28067288e-02f, -4.36349697e-02f, -4.29430716e-02f, -7.07349032e-02f,
  -3.90636623e-02f, -2.20794603e-01f, -6.82074064e-03f, 2.66365334e-02f, -5.89290448e-02f, 1.30293062e-02f, 1.23448987e-02f, -1.85823906e-02f, -5.91872819e-02f, -2.92573217e-02f,
  -7.64917536e-03f, 4.31587966e-03f, 4.30158488e-02f, -2.05870662e-02f, 8.74252468e-02f, 1.04911691e-02f, -6.15797602e-02f, 3.77784967e-02f, -7.02591389e-02f, 2.25137807e-02f,
  2.44625602e-02f, 1.81016549e-02f, -7.06866607e-02f, -2.11725216e-02f, -1.71646383e-02f, -1.37314662e-01f, 5.95542453e-02f, 1.72007177e-02f, -4.88923527e-02f, 4.68919538e-02f,
  2.07897853e-02f, -3.08789879e-01f, 1.94760431e-02f, 1.11322917e-01f, 1.27619296e-01f, -1.01620229e-02f, 3.48639451e-02f, -7.38695711e-02f, -1.10445075e-01f, -2.32299864e-01f,
  1.55272130e-02f, 9.21258777e-02f, -1.53799281e-01f, 1.25493363e-01f, 2.38178268e-01f, -1.03867374e-01f, 5.71959019e-02f, 7.97317699e-02f, -5.24638481e-02f, -2.59274747e-02f,
  4.01024148e-02f, 7.35238045e-02f, 1.39299050e-01f, 1.21681571e-01f, 7.06947222e-02f, 1.31893635e-01f, 7.77815059e-02f, 1.19824633e-01f, 2.30502859e-01f, 1.97944298e-01f,
  -5.64262550e-03f, -7.01985210e-02f, 7.24264905e-02f, 4.71608639e-02f, -8.59079883e-02f, 4.33167294e-02f, 7.61688501e-02f, 1.44613221e-01f, 7.53992796e-02f, -5.87722147e-03f,
  -3.24902833e-02f, 9.56119820e-02f, 5.72288595e-02f, 5.08352257e-02f, 7.51935178e-03f, 1.83014497e-02f, 1.75983813e-02f, -3.24466042e-02f, 4.66826186e-02f, -5.48046194e-02f,
  -7.82519057e-02f, -3.31552550e-02f, -3.83414254e-02f, 9.51297209e-02f, -1.05699785e-02f, -8.40169843e-03f, -3.99087667e-02f, 3.91069353e-02f, -2.02989802e-02f, 3.72367948e-02f,
  -7.01144487e-02f, 4.12345678e-03f, -1.16485590e-02f, 4.50823344e-02f, -1.44714769e-03f, -5.77832456e-04f, -6.26061633e-02f, 1.19067626e-02f, 5.15885390e-02f, -2.73369998e-03f,
  -2.19911952e-02f, 2.98371036e-02f, 2.15389803e-02f, -4.18663546e-02f, -3.81858498e-02f, -2.40257140e-02f, 3.50431912e-02f, 7.32779801e-02f, 1.42821083e-02f, 5.01608616e-03f,
  4.32143807e-02f, 5.94132952e-02f, 4.95059714e-02f, 3.21776681e-02f, -6.46569487e-03f, -5.94971552e-02f, -1.78574678e-02f, -8.66598338e-02f, -2.35646609e-02f, 2.97280140e-02f,
  -1.42221600e-01f, -1.70274183e-01f, -1.30112665e-02f, 8.06328058e-02f, 4.16763267e-03f, -6.09395951e-02f, 2.92412862e-02f, 1.63934715e-02f, 9.03680082e-03f, -3.52205709e-02f,
  -9.96268541e-03f, 4.43749987e-02f, -9.26976725e-02f, 4.57024276e-02f, 1.01901352e-01f, -1.01800203e-01f, 7.18812123e-02f, 3.19706202e-02f, 2.64305752e-02f, -1.34283500e-02f,
  6.88016415e-03f, -7.35092834e-02f, 3.21369804e-02f, 4.41730842e-02f, -5.18262237e-02f, -4.69323993e-02f, -3.64013016e-02f, 3.52999084e-02f, -7.66620692e-03f, -2.12758295e-02f,
  -4.95239139e-01f, 3.01520258e-01f, -1.31153330e-01f, 2.12426618e-01f, -2.08627626e-01f, 3.29647124e-01f, 4.39981371e-01f, -4.25128825e-02f, 1.42029449e-01f, 3.91000628e-01f,
  2.41985783e-01f, -5.37594147e-02f, 1.64416581e-01f, 4.05891746e-01f, -9.14997607e-02f, 2.55986482e-01f, 2.82709837e-01f, 2.34682783e-01f, -4.67895232e-02f, -6.82340637e-02f,
  -1.10618062e-01f, 2.28755802e-01f, -7.88784120e-03f, -4.79207821e-02f, -1.62321441e-02f, -9.43822414e-02f, -6.24799505e-02f, -1.96186617e-01f, 1.56748116e-01f, 4.00151014e-02f,
  1.31079793e-01f, -3.28817554e-02f, -4.55689542e-02f, -6.81523383e-02f, 1.62887073e-03f, -5.18343821e-02f, 4.38769422e-02f, -1.01891853e-01f, -9.04166624e-02f, 4.30248268e-02f,
  -4.70164753e-02f, -4.74826917e-02f, 9.24165770e-02f, -6.04441017e-02f, -4.34243679e-02f, -3.82943526e-02f, -3.08682546e-02f, 3.47275734e-02f, 1.27547309e-02f, 6.18502824e-03f,
  -1.24532273e-02f, -6.59105694e-03f, 3.54969688e-02f, 1.08093716e-01f, -3.01065389e-02f, 7.47212172e-02f, 5.46758398e-02f, -5.19775674e-02f, 4.02662084e-02f, 4.68516089e-02f,
  -1.76842080e-03f, 4.26666588e-02f, 1.65307820e-02f, -7.32145878e-03f, 4.94777923e-03f, 3.27435732e-02f, 1.49328876e-02f, 7.75507046e-03f, -6.62070364e-02f, 8.03151652e-02f,
  4.22897711e-02f, 2.17913892e-02f, 2.72315815e-02f, 5.57574518e-02f, 3.51231843e-02f, -1.55273620e-02f, -1.14307649e-01f, -2.96416711e-02f, 1.90668199e-02f, 1.12395771e-02f,
  8.06834251e-02f, 2.19756532e-02f, 1.07551433e-01f, 6.77202493e-02f, 3.87849584e-02f, -3.16326134e-02f, 6.97980449e-02f, -1.70228370e-02f, 2.29386669e-02f, -4.30984981e-02f,
  2.94822991e-01f, 1.33608013e-01f, 3.22984904e-02f, 1.25964526e-02f, -3.17977108e-02f, -6.75083250e-02f, 1.85829811e-02f, 1.54148061e-02f, 8.59023705e-02f, -3.64184044e-02f,
  -5.83523624e-02f, 6.49143830e-02f, 1.13756675e-02f, -3.19830701e-02f, -6.06867038e-02f, 6.58817366e-02f, 9.79665220e-02f, 2.17220630e-03f, 2.14591771e-02f, -2.76055411e-02f,
  4.33763489e-03f, 2.36328039e-02f, -1.87233798e-02f, -1.94853265e-02f, 2.81335935e-02f, 9.80643481e-02f, -4.51285206e-02f, -9.47702676e-03f, -2.92633194e-02f, 6.80804029e-02f,
  1.75599307e-01f, -9.40784812e-02f, 7.54329190e-02f, 2.86377251e-01f, -1.07887879e-01f, -2.93348759e-01f, -2.30863795e-01f, 1.05013162e-01f, 3.65637168e-02f, -1.67544499e-01f,
  3.39399315e-02f, -1.39947578e-01f, -4.38067913e-02f, 9.58241671e-02f, 2.28733480e-01f, -3.32288072e-02f, 1.15342766e-01f, -1.10646747e-01f, 5.92583828e-02f, 1.58831567e-01f,
  2.69785583e-01f, 1.80374637e-01f, 2.10254759e-01f, 1.89997077e-01f, 4.35486659e-02f, 2.57603705e-01f, 2.57027775e-01f, 2.49739867e-02f, 1.79034218e-01f, -1.16195597e-01f,
  -4.22338359e-02f, -1.64851081e-02f, 6.81299195e-02f, -7.47709125e-02f, 1.03597552e-01f, -9.15980861e-02f, -8.17308575e-03f, -6.75683320e-02f, 7.12941866e-03f, 2.97219232e-02f,
  -2.74685845e-02f, 1.06969014e-01f, -1.97825674e-02f, -1.97439659e-02f, -5.03780656e-02f, 1.85431968e-02f, 5.25158755e-02f, 6.16970360e-02f, -5.52137606e-02f, 4.69130166e-02f,
  1.55522060e-02f, -6.31433502e-02f, 3.66871729e-02f, -4.27120924e-02f, 1.06049769e-01f, 2.91054361e-02f, -3.03436946e-02f, -5.07287793e-02f, -1.14478404e-02f, 4.17256206e-02f,
  8.08266103e-02f, -7.46317208e-02f, -5.06570451e-02f, -6.55662566e-02f, -2.56784614e-02f, -1.51011208e-03f, -3.50993611e-02f, 1.26879001e-02f, 1.49892159e-02f, 5.86148165e-03f,
  -5.94337285e-03f, 5.87658323e-02f, 2.30988748e-02f, -5.29081635e-02f, 2.82321963e-02f, -3.15144658e-02f, -7.51847867e-03f, 2.89994497e-02f, 8.58182311e-02f, 3.43510211e-02f,
  -3.51432040e-02f, 2.89840084e-02f, -2.85955761e-02f, -5.35374619e-02f, -4.40975577e-02f, -3.70512493e-02f, 1.06843047e-01f, 3.38735171e-02f, -5.36771258e-03f, -5.84631823e-02f,
  1.77114289e-02f, 1.24421358e-01f, 4.61532697e-02f, -2.17629503e-02f, -1.04700420e-02f, -3.53562012e-02f, -3.63192409e-02f, 5.14687710e-02f, -3.43286730e-02f, 3.48571427e-02f,
  7.47676343e-02f, -1.55098662e-02f, -4.48805951e-02f, 4.95895743e-02f, 1.08174160e-02f, 5.20585254e-02f, 5.75442128e-02f, -5.43222250e-03f, 3.71925533e-02f, 1.14684448e-01f,
  3.59982555e-03f, -2.28927284e-02f, 3.13460715e-02f, -5.36869913e-02f, 5.00081964e-02f, -3.17483507e-02f, -1.25270458e-02f, 2.81473249e-02f, 4.82387282e-02f, -2.20849551e-02f,
  -1.12595893e-01f, -2.46336192e-01f, -8.59292895e-02f, -1.11357018e-01f, 1.77462533e-01f, 2.75685579e-01f, -2.96616070e-02f, 5.58569655e-02f, -1.95527464e-01f, 4.32420485e-02f,
  -5.82169183e-02f, -2.22121730e-01f, -3.05953503e-01f, -2.57984251e-01f, -1.52452514e-01f, -2.77786762e-01f, -5.01939617e-02f, -9.79470238e-02f, -1.91664279e-01f, -2.61135064e-02f,
  -3.25218122e-03f, -1.70237869e-02f, -2.39496063e-02f, 2.10030749e-01f, 9.78501514e-02f, 1.79963961e-01f, 2.47009352e-01f, 9.30893347e-02f, 1.73414052e-01f, 1.84993520e-02f,
  -6.37900755e-02f, -1.57524467e-01f, -4.75004241e-02f, 4.32776324e-02f, 1.25195667e-01f, 9.39522982e-02f, 8.55427757e-02f, -3.39957327e-02f, 2.18289113e-03f, -4.46681008e-02f,
  5.60245104e-02f, -4.71946830e-03f, -6.22182228e-02f, -2.79587694e-02f, 4.50776133e-04f, -8.20546877e-03f, -4.62451950e-02f, 1.08357789e-02f, -8.38212594e-02f, -7.43489638e-02f,
  -6.37314767e-02f, 6.13800548e-02f, -7.00665489e-02f, 7.18393456e-03f, 4.53274362e-02f, 8.61739926e-03f, 1.16557367e-01f, 1.38309956e-01f, -8.07305202e-02f, 3.80741879e-02f,
  4.46642712e-02f, 6.71265721e-02f, 6.54350668e-02f, -9.58497003e-02f, -1.17016220e-02f, -4.25509103e-02f, -6.17518984e-02f, -2.83084176e-02f, -5.60066327e-02f, 3.27889249e-03f,
  5.02650030e-02f, -8.08204804e-03f, -1.08726725e-01f, 6.81355894e-02f, 9.06500071e-02f, -2.30164435e-02f, 8.54456984e-03f, 4.39720936e-02f, 8.67417604e-02f, -2.33293995e-02f,
  -4.16376963e-02f, 6.78079650e-02f, 6.57663792e-02f, -1.98187679e-02f, -1.17710575e-01f, 8.98422226e-02f, 2.33758297e-02f, 8.89048539e-03f, 1.55673092e-02f, 8.20251405e-02f,
  1.10033549e-01f, 5.52886538e-02f, -2.43671332e-03f, -2.76461020e-02f, -8.76417235e-02f, 3.30250300e-02f, -8.10572132e-02f, -2.62846481e-02f, 4.29497138e-02f, -3.01078390e-02f,
  1.67479098e-01f, 8.69505107e-02f, 1.47476628e-01f, -2.16977745e-02f, 1.47727588e-02f, 9.53873172e-02f, 5.83853498e-02f, 6.93526939e-02f, 9.19786245e-02f, 7.13816807e-02f,
  1.30171835e-01f, 8.51962939e-02f, -3.47492397e-02f, 4.54191342e-02f, 4.73686159e-02f, 5.36712483e-02f, 8.06820616e-02f, 7.62556419e-02f, -8.12245160e-02f, -1.47628170e-02f,
  1.60803616e-01f, -2.80329771e-02f, -1.51996329e-01f, 1.20217629e-01f, 4.30854671e-02f, -1.78415120e-01f, -3.38948220e-01f, 4.22254018e-02f, -2.15435907e-01f, -7.01654106e-02f,
  1.13631636e-01f, -2.65510613e-03f, -1.72232702e-01f, 3.45230609e-01f, 3.68502170e-01f, -1.63308561e-01f, 3.21221828e-01f, 2.63133161e-02f, 8.47907737e-03f, 2.25317016e-01f,
  1.46383077e-01f, 4.08191204e-01f, 6.37223721e-02f, 2.23179087e-01f, 1.28429472e-01f, -1.21815512e-02f, 1.92097142e-01f, -1.54545993e-01f, 2.49130756e-01f, 5.99945560e-02f,
  -1.83968863e-03f, 1.09520800e-01f, -2.55389642e-02f, -1.35904029e-02f, 4.89646830e-02f, -9.72166378e-03f, -1.04482621e-01f, 6.27672416e-04f, 2.79155374e-02f, -2.04194169e-02f,
  -5.20532131e-02f, 1.03260174e-01f, 5.88001609e-02f, -1.22652564e-03f, 3.00327614e-02f, 1.84505302e-02f, -9.93236061e-03f, -6.44962937e-02f, -5.52671812e-02f, 6.82838485e-02f,
  -5.49292900e-02f, -1.63427182e-02f, -5.15919141e-02f, -4.54309061e-02f, -5.06432876e-02f, 1.48749966e-02f, -3.74633707e-02f, 1.34918757e-03f, 2.09754985e-02f, -3.54553275e-02f,
  1.10033162e-01f, -4.93649133e-02f, -1.29347229e-02f, 1.02316914e-02f, 4.20222916e-02f, 2.15705633e-02f, -1.57404747e-02f, -1.69580579e-02f, -2.34054849e-02f, 8.01161081e-02f,
  2.69212648e-02f, 1.86916180e-02f, -2.66336575e-02f, 1.19804339e-02f, 6.65757619e-03f, -6.23477697e-02f, -3.04578654e-02f, 4.43559140e-02f, -3.78202237e-02f, -5.53712696e-02f,
  -6.26021773e-02f, 5.27613834e-02f, -6.69570044e-02f, -3.05071268e-02f, 9.69548244e-03f, 5.93577623e-02f, 7.83098713e-02f, 2.31579738e-03f, -9.92068723e-02f, -2.58098859e-02f,
  -1.51353730e-02f, 2.11460978e-01f, -9.01866928e-02f, -5.67957340e-03f, -2.17885505e-02f, 1.17106840e-01f, 9.81714576e-03f, 4.97703850e-02f, 6.03226982e-02f, 8.88002198e-03f,
  8.58493373e-02f, -1.20588228e-01f, -1.72387771e-02f, 5.92546128e-02f, 3.17023508e-02f, -3.62472124e-02f, 8.68888572e-03f, -6.61816075e-02f, -1.33347930e-02f, 9.15233642e-02f,
  -1.86176021e-02f, 3.13373692e-02f, 3.83938551e-02f, -2.33684909e-02f, 1.65719893e-02f, -2.90675815e-02f, 7.73254270e-03f, -6.23123348e-02f, 5.51336147e-02f, 2.15218216e-03f,
  1.69547766e-01f, 3.60334754e-01f, 1.60491511e-01f, 1.72578588e-01f, -1.40427306e-01f, 2.73555487e-01f, 2.51049101e-01f, 6.04248084e-02f, 2.48800039e-01f, 1.05428897e-01f,
  -2.40741357e-01f, 3.56593817e-01f, -8.06218982e-02f, 5.08530214e-02f, 2.75194068e-02f, -2.91729276e-03f, 1.92936584e-01f, 2.20152378e-01f, 5.38152121e-02f, 1.53546751e-01f,
  8.60624611e-02f, -8.55798274e-02f, -1.78927049e-01f, -6.99116513e-02f, -2.30441671e-02f, -2.33078878e-02f, -2.87043422e-01f, -6.84707612e-02f, -1.33585995e-02f, -3.31016700e-03f,
  -1.15695626e-01f, 3.66734713e-02f, -3.08824237e-02f, 1.31072989e-02f, -3.96963619e-02f, 3.65739167e-02f, -1.73848646e-03f, -7.15467148e-03f, -1.60140060e-02f, 9.90913585e-02f,
  1.20934501e-01f, 2.92304698e-02f, 4.97270375e-02f, 4.90455180e-02f, 7.41323531e-02f, -2.37153992e-02f, 1.39004132e-02f, -4.28669248e-03f, 5.65589638e-03f, -5.87836094e-02f,
  -1.04722101e-02f, 9.27210320e-03f, -4.00327481e-02f, 5.28745279e-02f, -2.29367311e-03f, 1.61931012e-02f, 9.57739651e-02f, 3.03620175e-02f, 9.29061845e-02f, 8.68791342e-02f,
  1.06625736e-01f, 2.96760425e-02f, -5.21364510e-02f, -8.63096863e-02f, -4.65403963e-03f, -1.08085983e-01f, 2.09936388e-02f, -7.07083791e-02f, 2.47874819e-02f, -3.57043855e-02f,
  3.57483514e-02f, -3.96899879e-02f, -3.72634530e-02f, -9.22434404e-03f, 6.27059639e-02f, 1.79887970e-03f, 6.64777607e-02f, 8.77943914e-03f, 1.28774960e-02f, -4.38572019e-02f,
  -7.98274577e-03f, 5.17266914e-02f, -3.56501751e-02f, -9.55003798e-02f, -1.51426438e-02f, -1.01859635e-02f, -4.81771566e-02f, 1.33047597e-02f, -7.26028532e-02f, 5.32049723e-02f,
  2.43854314e-01f, 3.19520861e-01f, 6.59212396e-02f, 4.94017825e-02f, 7.87821859e-02f, -1.71470419e-02f, 9.51404870e-02f, 7.52232894e-02f, 1.17415071e-01f, 6.76219836e-02f,
  3.02963909e-02f, 1.01680331e-01f, 2.02399492e-02f, -8.84480104e-02f, 6.38545230e-02f, -8.16800222e-02f, -1.65928062e-02f, 3.48406360e-02f, 7.25398138e-02f, -4.39435542e-02f,
  -3.37621793e-02f, 9.53554660e-02f, 6.28076866e-02f, 1.45518994e-02f, -5.40146232e-03f, 4.51582856e-03f, 9.10452977e-02f, 7.97295943e-03f, 2.42439676e-02f, 7.16961101e-02f,
  5.26995540e-01f, -4.73766290e-02f, 1.94318280e-01f, 4.03826028e-01f, 4.16922830e-02f, 2.08167788e-02f, 7.77420253e-02f, 1.00967087e-01f, 4.72465187e-01f, 2.65532639e-02f,
  -8.14491957e-02f, 2.17731267e-01f, -7.14141056e-02f, 8.61194916e-03f, -7.53713446e-03f, -6.88076541e-02f, 9.44893062e-03f, 4.72120456e-02f, 9.65960026e-02f, 2.22119033e-01f,
  1.48052424e-01f, -1.16238952e-01f, -4.13679257e-02f, -7.41438493e-02f, 4.31809984e-02f, 4.70871814e-02f, -3.44788402e-01f, -2.40276754e-01f, -1.71951979e-01f, -2.34001637e-01f,
  7.60678295e-03f, 8.95923302e-02f, 2.24600043e-02f, -7.46965855e-02f, 5.46229258e-02f, -6.87807798e-02f, -2.35881023e-02f, -1.40775770e-01f, -1.73748285e-02f, 3.64061631e-02f,
  9.27067548e-02f, 1.44601669e-02f, 1.66793875e-02f, -5.57809249e-02f, 3.42528298e-02f, 2.69293003e-02f, 1.04426049e-01f, 9.47376639e-02f, -1.58986878e-02f, 4.16966304e-02f,
  1.45950258e-01f, 3.46491635e-02f, -7.25433230e-03f, -1.21125884e-01f, 1.10838246e-02f, 6.94309473e-02f, 2.20372938e-02f, -1.01139002e-01f, -4.14491370e-02f, 7.64160678e-02f,
  -3.47145391e-03f, -4.72692363e-02f, -7.22753108e-02f, -2.45990208e-03f, -2.07035821e-02f, 3.61213572e-02f, -4.96819662e-03f, -5.27648255e-02f, -1.15951449e-02f, 4.67548193e-03f,
  1.26272719e-02f, -4.91024181e-02f, 4.46141465e-03f, -2.38251127e-02f, 1.06401637e-01f, 7.51724541e-02f, 1.12481462e-02f, 4.25537676e-02f, 4.78588678e-02f, 3.63851935e-02f,
  7.19543397e-02f, -7.79867843e-02f, -3.91730852e-02f, 5.13154501e-03f, -3.20940353e-02f, -3.09792943e-02f, 4.76182401e-02f, 9.13483053e-02f, 4.15823758e-02f, -6.76625669e-02f,
  -1.49420723e-01f, -1.48324430e-01f, -2.68981624e-02f, 3.32418755e-02f, -3.89390439e-03f, -3.06858905e-02f, 9.09861624e-02f, 1.98382344e-02f, -1.47632450e-01f, 1.83835328e-02f,
  1.25267759e-01f, -4.18655155e-03f, 1.94558520e-02f, -4.26411293e-02f, -5.72002865e-02f, -3.64369736e-03f, 1.28958285e-01f, -7.86035582e-02f, -1.50145944e-02f, -4.19090167e-02f,
  6.23517707e-02f, 2.14611478e-02f, 3.40782106e-02f, 4.88152914e-02f, 5.91979660e-02f, -8.54465887e-02f, 8.44780877e-02f, -4.81300056e-02f, -1.38792396e-03f, -2.95646079e-02f,
  -6.06678724e-02f, 4.21923518e-01f, 2.64468461e-01f, 3.74698400e-01f, -6.97220936e-02f, -5.24964094e-01f, -2.54412264e-01f, 7.67884851e-02f, 1.37206852e-01f, -1.04637546e-02f,
  1.98820140e-02f, 2.24071667e-01f, -6.16239570e-02f, 2.60353684e-01f, -1.71786249e-01f, -9.29390043e-02f, -5.61214658e-03f, -1.99405085e-02f, 7.01992288e-02f, 1.50655434e-01f,
  8.28836486e-02f, 6.60157055e-02f, 1.96441203e-01f, 9.50164336e-04f, 7.36625418e-02f, 2.05728829e-01f, 2.19911695e-01f, 1.21885464e-01f, 7.82460496e-02f, -1.11971917e-02f,
  -6.30095601e-02f, 1.22898825e-01f, 1.80170219e-02f, -3.15960757e-02f, 1.81834605e-02f, -1.47053212e-01f, -1.20385000e-02f, -3.97678837e-02f, 3.45474295e-02f, -5.72811626e-02f,
  -1.01523763e-02f, -1.31668672e-01f, 4.92021255e-02f, 3.14208493e-02f, -6.63560256e-02f, 5.37790284e-02f, 4.17580828e-02f, 2.55519133e-02f, 1.08259231e-01f, -2.32208390e-02f,
  1.03801362e-01f, 2.90953144e-02f, 5.68923838e-02f, 2.97513027e-02f, 1.25657450e-02f, -6.87880488e-03f, -6.94971755e-02f, 5.30830435e-02f, 2.56469212e-02f, 6.09469414e-02f,
  -1.03993565e-01f, 6.10391349e-02f, 9.91202518e-02f, 7.58310333e-02f, 3.40401232e-02f, 1.85954124e-02f, 6.66213827e-03f, 3.91026633e-03f, 1.49236759e-02f, -4.84436098e-03f,
  1.52859120e-02f, 6.42293990e-02f, 2.21231692e-02f, 1.20995184e-02f, 8.78434852e-02f, 7.36552253e-02f, -3.88440676e-02f, 1.30905258e-02f, -5.43117709e-02f, 7.14776665e-02f,
  3.88329849e-02f, -3.97048332e-02f, 4.01491150e-02f, -3.16939577e-02f, -9.54186916e-02f, 8.49924982e-02f, 6.61160052e-02f, -2.67904084e-02f, 5.18655144e-02f, 4.98961993e-02f,
  -2.45553292e-02f, 2.29039326e-01f, 7.66297011e-03f, -7.08551332e-02f, 2.67367754e-02f, -3.13818268e-02f, -7.64768524e-03f, -5.35641424e-02f, 7.14809299e-02f, -1.09531455e-01f,
  -3.41725089e-02f, -7.41229653e-02f, -3.23155038e-02f, -8.24823081e-02f, -6.89381873e-03f, 5.70140742e-02f, 1.18793450e-01f, 8.37046281e-02f, 7.23497644e-02f, 2.87299473e-02f,
  9.13356841e-02f, -6.90921396e-02f, -4.70189713e-02f, -3.06251757e-02f, -1.20978892e-01f, 3.84168290e-02f, -3.65236215e-02f, 1.99396818e-04f, 2.56682951e-02f, 2.27273465e-03f,
  -1.59422979e-01f, 2.45009527e-01f, 2.37841815e-01f, -5.16998675e-03f, 1.61263779e-01f, 1.78926483e-01f, -2.31840417e-01f, 1.40230358e-01f, -1.36836186e-01f, -2.31465757e-01f,
  -2.87551105e-01f, 1.34306811e-02f, -2.76720583e-01f, 9.40398425e-02f, -8.65353867e-02f, -6.21707067e-02f, 1.25618279e-01f, -4.70845103e-02f, 7.58576095e-02f, 7.85111859e-02f,
  1.01753332e-01f, -1.05111338e-01f, 1.27149031e-01f, 2.39693284e-01f, 1.27676576e-01f, 7.87340552e-02f, -1.95371151e-01f, -2.01329892e-03f, 1.47487029e-01f, 2.40780003e-02f,
  -5.48041053e-02f, -1.28639758e-01f, -6.00013398e-02f, -7.12563768e-02f, -1.01954760e-02f, -3.94832902e-02f, -8.14001560e-02f, -8.37522149e-02f, -2.12651119e-02f, -2.23878380e-02f,
  -2.10345499e-02f, 8.91100317e-02f, 4.95358743e-02f, -9.48178992e-02f, 5.51132374e-02f, 9.27129239e-02f, 1.14378467e-01f, 4.11340334e-02f, 6.96112141e-02f, 7.55829215e-02f,
  7.34520406e-02f, 1.43221945e-01f, 7.32437596e-02f, 3.21918773e-03f, 3.33881900e-02f, 5.35146482e-02f, 6.17433675e-02f, 8.45574867e-03f, 1.02283768e-01f, 9.87703204e-02f,
  7.47924075e-02f, -8.12349841e-02f, 4.30813543e-02f, -4.16785069e-02f, -1.84110627e-02f, -2.20154356e-02f, -3.03997155e-02f, -8.62372220e-02f, 1.40394494e-02f, -1.26094026e-02f,
  2.99394913e-02f, 2.11701896e-02f, 4.73899134e-02f, 2.04482209e-02f, -8.51656571e-02f, 4.07476153e-04f, -8.27778969e-03f, -3.69879045e-02f, 5.50021119e-02f, 5.31900823e-02f,
  -7.38765374e-02f, 6.41215884e-04f, -3.79204005e-02f, 8.22333992e-02f, 2.79343524e-03f, -6.28532469e-02f, -4.74207057e-03f, 9.97290313e-02f, -2.44895779e-02f, -3.17755863e-02f,
  -3.12565029e-01f, -3.84149760e-01f, -8.30167532e-02f, -1.13609634e-01f, -1.33823585e-02f, -8.67155753e-03f, 3.14191654e-02f, 7.12428093e-02f, -8.41976851e-02f, -7.83620626e-02f,
  -3.25446092e-02f, 3.61191258e-02f, -5.96901812e-02f, -5.63719384e-02f, -4.21916060e-02f, -6.05523251e-02f, -1.15848541e-01f, -1.00829080e-01f, -8.68040994e-02f, 9.31728072e-03f,
  -6.94598537e-03f, -6.98216632e-02f, 2.66371556e-02f, 1.13697514e-01f, -1.47994002e-02f, -2.18845741e-03f, -1.84302852e-02f, 9.27427970e-03f, -2.00008005e-02f, 5.51771279e-03f,
  -2.90109158e-01f, 4.51504327e-02f, -2.20826175e-02f, -2.07335085e-01f, 1.37716144e-01f, -1.18136602e-02f, -1.26793891e-01f, 3.88349011e-03f, -4.31776568e-02f, -9.75338146e-02f,
  -1.03390574e-01f, 3.04045826e-02f, 1.58434868e-01f, -1.39763936e-01f, 1.54189333e-01f, 1.28192946e-01f, -2.79780328e-01f, -2.21037567e-01f, -6.24376722e-02f, -2.05980435e-01f,
  -2.63008941e-02f, -1.59782946e-01f, -2.74914387e-03f, -8.86738300e-03f, -1.40832514e-01f, -1.25599235e-01f, -6.01665536e-03f, 2.01962501e-01f, -9.33175161e-02f, 1.28614113e-01f,
  -1.43526912e-01f, -1.20198794e-01f, -2.19874039e-01f, -2.81128660e-02f, -5.47487698e-02f, -1.62686836e-02f, -1.00905016e-01f, 8.30650032e-02f, 2.61289757e-02f, 6.28362447e-02f,
  6.34875223e-02f, 2.21025385e-03f, 1.45405820e-02f, 1.47682969e-02f, -2.34930664e-02f, 6.75658882e-02f, 1.12678356e-01f, 1.45950811e-02f, -4.24373038e-02f, 2.63961311e-02f,
  4.46938127e-02f, -2.86489669e-02f, -9.39363912e-02f, -1.05777420e-01f, 4.06763479e-02f, 1.35203665e-02f, -7.30735734e-02f, 1.46173630e-02f, -1.66888479e-02f, -4.35034037e-02f,
  9.18408558e-02f, 4.95323949e-02f, -3.71286273e-03f, -1.62857100e-02f, -6.11679032e-02f, -3.23823392e-02f, -5.29256463e-02f, -4.49570976e-02f, -1.67731419e-02f, 3.05374768e-02f,
  -7.86655098e-02f, -1.08214049e-02f, -5.70463240e-02f, -4.74327020e-02f, 1.70685863e-03f, 1.02990237e-03f, -6.70744330e-02f, 8.92204512e-03f, -8.45650733e-02f, 1.28903287e-02f,
  -9.12364498e-02f, -2.70429235e-02f, 2.18286831e-03f, -1.17027819e-01f, 2.76505128e-02f, 7.59487078e-02f, -6.80587888e-02f, -4.41800728e-02f, 5.98336831e-02f, 1.02117188e-01f,
  -1.89478695e-01f, -1.74955785e-01f, -4.42904420e-02f, -9.47203264e-02f, -2.67606564e-02f, 3.23002189e-02f, -1.46230785e-02f, -5.43112047e-02f, 1.11014873e-01f, 6.27468601e-02f,
  2.42420435e-02f, -7.42728859e-02f, -3.76650393e-02f, -4.12742756e-02f, -2.42942087e-02f, -1.28153721e-02f, -1.68638080e-02f, 9.91284102e-03f, -6.03611805e-02f, -4.77609895e-02f,
  -1.06293507e-01f, -5.94628491e-02f, 2.59709861e-02f, -7.87098482e-02f, -8.35086182e-02f, -3.58380489e-02f, -4.51513156e-02f, -5.91473132e-02f, 1.00534968e-01f, 1.28383143e-03f,
  -4.38733175e-02f, -4.06054929e-02f, -2.74617732e-01f, -3.16314772e-02f, -1.35446712e-01f, -3.17091644e-01f, -2.29055047e-01f, -5.56372441e-02f, 5.77555336e-02f, 1.86937854e-01f,
  -4.57527228e-02f, 1.33716181e-01f, 1.24781348e-01f, -1.53088138e-01f, -2.83750501e-02f, 2.58393645e-01f, -1.88198656e-01f, -2.46469467e-03f, 7.79578611e-02f, -1.03607714e-01f,
  -8.97688270e-02f, -9.79150608e-02f, -9.22656506e-02f, -6.31353334e-02f, -2.55071551e-01f, -7.52941966e-02f, 2.15535723e-02f, -1.99019969e-01f, -2.40044907e-01f, -1.23911321e-01f,
  -5.24335913e-02f, 1.20348170e-01f, 6.28714263e-03f, 7.24050254e-02f, -6.12207875e-02f, -9.41169560e-02f, -7.98006505e-02f, -2.73798741e-02f, 1.97309479e-02f, 9.51619148e-02f,
  1.29857749e-01f, 1.30458191e-01f, 1.34268291e-02f, 6.09605946e-02f, -9.44933593e-02f, -1.31964050e-02f, -2.04433016e-02f, -9.64050665e-02f, 2.67113838e-02f, 5.12702651e-02f,
  -8.21488202e-02f, -8.66299868e-03f, -1.15407825e-01f, 6.91227093e-02f, -7.37100169e-02f, -2.68876143e-02f, -3.36748026e-02f, -7.18356743e-02f, -2.83915810e-02f, 1.83272623e-02f,
  -5.14049605e-02f, 5.10573061e-03f, -5.62777417e-03f, -5.78482822e-02f, -4.35483363e-03f, -4.11927998e-02f, 1.94856394e-02f, 7.98645709e-03f, -5.11340983e-02f, -1.18922638e-02f,
  9.08006653e-02f, -5.38292993e-03f, 3.03223915e-02f, 4.32508662e-02f, -3.11246738e-02f, 4.41875570e-02f, -5.39980754e-02f, 8.74907821e-02f, -4.98864893e-03f, -8.02600905e-02f,
  3.40394266e-02f, -1.30609140e-01f, 3.16934697e-02f, 7.87773449e-03f, -7.57460967e-02f, -6.06364757e-03f, -2.50441413e-02f, 3.45210824e-03f, 7.22151697e-02f, -9.24156681e-02f,
  -3.74212749e-02f, 1.33716417e-02f, 1.04637817e-01f, 8.32511708e-02f, 2.47248989e-02f, -5.35711721e-02f, -7.06262216e-02f, 2.41508968e-02f, -5.94514385e-02f, -5.06960750e-02f,
  1.16700344e-02f, 1.30323961e-01f, -2.45144833e-02f, 2.76922677e-02f, 2.78669205e-02f, -1.03574157e-01f, -2.54174694e-02f, 7.70415366e-02f, -1.43492790e-02f, 4.98365425e-03f,
  -4.33001609e-04f, 5.41799143e-02f, 1.62891701e-01f, 8.22369978e-02f, 1.44126609e-01f, 8.16408098e-02f, -1.36110947e-01f, 5.58052808e-02f, 2.23812684e-02f, 3.00079305e-02f,
  3.70961815e-01f, -4.54959333e-01f, 1.15883820e-01f, 2.90183872e-01f, 2.96082526e-01f, -1.47048514e-02f, 2.75016695e-01f, -5.27244993e-02f, 5.32287955e-02f, -3.27476054e-01f,
  6.28700480e-02f, 2.35363888e-03f, -1.13871008e-01f, 3.57302055e-02f, 2.90551156e-01f, -8.92068297e-02f, 1.12174945e-02f, -6.27671601e-03f, 5.38617419e-03f, 8.20760056e-02f,
  1.84008002e-01f, 9.89289656e-02f, 8.98469314e-02f, -1.55284479e-01f, 9.42594931e-02f, -5.85912131e-02f, -6.72051013e-02f, -1.59027390e-02f, -3.49350721e-02f, 6.00904487e-02f,
  -2.20937207e-02f, 2.10030493e-03f, -9.27089807e-03f, -3.38959768e-02f, -8.11491609e-02f, -7.16115609e-02f, 1.20983385e-02f, 5.56273423e-02f, 9.94417667e-02f, 3.33620328e-03f,
  1.44355901e-04f, 3.28994542e-02f, -2.54626409e-03f, 6.03953078e-02f, -3.67673263e-02f, -9.57494788e-03f, 4.26268615e-02f, -3.86447497e-02f, 4.54385765e-02f, 4.26796153e-02f,
  6.15253709e-02f, -4.26148325e-02f, 2.18580309e-02f, 1.78384073e-02f, 4.08496298e-02f, 2.15026252e-02f, 6.13989644e-02f, 5.42980805e-03f, -1.55515978e-02f, 4.55589294e-02f,
  8.30584168e-02f, 1.27432514e-02f, -3.71800624e-02f, -1.72174955e-03f, 2.70775985e-02f, 7.05018491e-02f, 4.50017676e-02f, -9.09240637e-03f, -2.85227541e-02f, -2.19392609e-02f,
  6.51932582e-02f, 2.09990758e-02f, -1.38286396e-03f, 4.84353863e-02f, -1.73879676e-02f, 4.73365225e-02f, 1.72562264e-02f, -1.94888115e-02f, -6.12229183e-02f, 4.27711383e-02f,
  -8.76582880e-03f, 1.56225283e-02f, -6.93408847e-02f, 8.77872407e-02f, -1.76068619e-02f, -2.58883014e-02f, -2.73077339e-02f, -4.32401411e-02f, 4.29843515e-02f, 1.06091313e-02f,
  -4.17221218e-01f, -3.95581067e-01f, -4.53079902e-02f, -9.01843794e-03f, -7.59047642e-02f, -6.89466149e-02f, -9.19725746e-03f, -1.09940609e-02f, -9.95502397e-02f, 5.42633347e-02f,
  -4.91450354e-02f, 5.81272729e-02f, -1.10781096e-01f, 7.22188726e-02f, -6.66182265e-02f, -5.63841779e-03f, -4.23102044e-02f, -1.51784509e-01f, -8.04705843e-02f, -8.69633555e-02f,
  -3.38682197e-02f, -1.53770894e-02f, 2.31735129e-02f, 3.63445468e-02f, -3.83011773e-02f, 4.90181223e-02f, -3.24461870e-02f, -1.39533021e-02f, -1.57504324e-02f, -4.28606495e-02f,
  3.94138247e-01f, -2.17387110e-01f, -1.73084244e-01f, 2.36945644e-01f, 3.48682582e-01f, 1.59206435e-01f, 5.04509695e-02f, 2.04351708e-01f, 4.63616699e-01f, -2.16408655e-01f,
  8.14787950e-03f, -2.44283855e-01f, -2.29502887e-01f, 9.95735526e-02f, 1.51038557e-01f, -7.71119669e-02f, 2.38762036e-01f, -1.17120072e-02f, 9.66891944e-02f, -9.63421613e-02f,
  1.80428222e-01f, 1.64643615e-01f, -1.67919636e-01f, -3.72725427e-02f, 3.52806039e-02f, -9.87399593e-02f, -1.70836359e-01f, -1.62219495e-01f, -1.29958421e-01f, 5.12226894e-02f,
  6.10286780e-02f, 1.09016091e-01f, 3.25403027e-02f, -5.43720946e-02f, 2.11582216e-03f, 3.94158950e-03f, -8.19834545e-02f, -1.00683391e-01f, 4.12376113e-02f, -3.48583870e-02f,
  -7.87599608e-02f, 1.79014187e-02f, 2.48656422e-02f, -2.74238735e-02f, 1.02079257e-01f, 1.10725746e-01f, 7.19515933e-03f, 2.53224894e-02f, -4.00145873e-02f, -8.03944543e-02f,
  -4.36947346e-02f, -6.32750094e-02f, 1.24735147e-01f, -6.61207289e-02f, -5.56370355e-02f, 5.54190800e-02f, -1.38850003e-01f, -1.15100354e-01f, -2.82188747e-02f, 5.63455299e-02f,
  -7.07366690e-02f, -4.61357506e-03f, 1.02345729e-02f, 5.77611029e-02f, 1.42288879e-02f, 7.17601329e-02f, 3.73036042e-02f, -3.41092534e-02f, 3.45182382e-02f, -3.78419645e-02f,
  1.37387291e-02f, 6.93337545e-02f, 5.44492602e-02f, 7.67630059e-03f, 9.02575906e-03f, 1.05041906e-01f, -2.64557190e-02f, -7.83441886e-02f, 2.39495491e-03f, 7.30553046e-02f,
  2.96550598e-02f, 1.60027612e-02f, -7.14454502e-02f, -2.98146047e-02f, 5.10740951e-02f, 5.29009011e-03f, 3.28119397e-02f, -2.20381767e-02f, -1.21621843e-02f, -9.28304065e-03f,
  1.55625455e-02f, -1.50799766e-01f, -9.91257206e-02f, -5.92292771e-02f, -8.09932873e-02f, 4.94877025e-02f, 1.88758168e-02f, 3.98240872e-02f, -2.76156720e-02f, 2.18068343e-02f,
  -8.48077759e-02f, -1.91389527e-02f, -3.97501849e-02f, 2.96275057e-02f, -2.47273464e-02f, -2.85300019e-04f, -1.52812287e-01f, -1.57582480e-02f, -1.36289382e-02f, -5.95928691e-02f,
  -1.02493271e-01f, -4.60973661e-03f, 2.32017376e-02f, 6.30928203e-02f, 3.02125178e-02f, -8.66793320e-02f, 4.81952205e-02f, 1.84019841e-02f, -2.70683691e-02f, -9.62019432e-03f,
  -1.72560498e-01f, 1.00079671e-01f, -1.59973666e-01f, 1.77050754e-02f, -4.13946867e-01f, -2.34060772e-02f, 2.12099981e-02f, -1.36609018e-01f, 2.09971562e-01f, 2.31986433e-01f,
  -1.41899377e-01f, 7.30054900e-02f, 9.98921022e-02f, -3.49453394e-03f, 1.12444252e-01f, 3.30257297e-01f, 1.10844649e-01f, 9.82632115e-02f, -1.20101441e-02f, -1.13625482e-01f,
  4.26864363e-02f, -4.86249328e-02f, -1.21741578e-01f, -9.80438516e-02f, -3.29868585e-01f, -1.52635783e-01f, -4.84971888e-02f, -1.40699252e-01f, -1.35656655e-01f, -8.97486731e-02f,
  -1.41206026e-01f, -1.69037238e-01f, -2.31823638e-01f, 4.60704863e-02f, -6.84442073e-02f, -3.90837640e-02f, -3.49914208e-02f, 8.80359486e-03f, -2.49731522e-02f, -5.03589325e-02f,
  9.03363153e-02f, -4.81046028e-02f, 1.89794730e-02f, 2.47695372e-02f, 4.25591096e-02f, -7.57285953e-02f, -3.02678142e-02f, -1.40099111e-03f, -5.09516187e-02f, -6.76588565e-02f,
  -7.18388259e-02f, -9.05518979e-02f, -5.99736571e-02f, 2.09035315e-02f, -1.27816036e-01f, -3.60257328e-02f, 1.04380511e-01f, -3.59323807e-02f, -4.59084176e-02f, 2.31003272e-03f,
  6.36719540e-02f, -8.86324048e-02f, -1.32423770e-02f, 1.66877639e-02f, -6.15686690e-03f, -9.61167887e-02f, 6.71954751e-02f, -1.70020014e-02f, 5.28431982e-02f, -1.13857381e-01f,
  1.26349088e-02f, -7.47422799e-02f, -8.90970172e-04f, 1.66701842e-02f, 6.13398738e-02f, 6.96213990e-02f, 2.33909767e-02f, -3.16177569e-02f, 8.52743909e-02f, 1.02656826e-01f,
  3.31072249e-02f, -5.21560619e-03f, -8.74751881e-02f, 1.17419371e-02f, -3.70560847e-02f, 2.72136871e-02f, -2.12298147e-02f, -7.50696706e-03f, -2.66689882e-02f, -3.23582254e-02f,
  3.11857257e-02f, 5.68239279e-02f, -7.34354407e-02f, -6.14772588e-02f, 8.61326605e-02f, -4.27535884e-02f, 3.03786411e-03f, -7.84607232e-02f, 7.14715943e-02f, 2.75300294e-02f,
  4.53573316e-02f, 2.65142992e-02f, -2.68899873e-02f, 5.82256541e-03f, 8.18712339e-02f, 5.89988977e-02f, 5.97311445e-02f, 1.07471071e-01f, 2.11382434e-02f, -1.03601776e-01f,
  -1.74432166e-03f, -2.95663234e-02f, -2.71250885e-02f, -2.51366058e-03f, -4.72793840e-02f, -2.70640645e-02f, 2.44679675e-02f, -3.22662890e-02f, -8.22099969e-02f, -3.34054716e-02f,
  -7.92748574e-03f, -2.27585241e-01f, -3.04752231e-01f, 3.62605006e-02f, 8.61542672e-02f, 2.34712824e-01f, -5.00320718e-02f, 3.56472023e-02f, -1.34468570e-01f, 1.36884242e-01f,
  8.11632350e-02f, 3.59265730e-02f, -3.18222225e-01f, 2.94278204e-01f, 1.09979376e-01f, -6.06651418e-02f, 2.53725320e-01f, 2.23724082e-01f, -1.22883148e-01f, -2.21531868e-01f,
  -5.67506552e-02f, 2.35993728e-01f, -7.78574347e-02f, 1.90474212e-01f, 1.15547702e-01f, -5.33882529e-02f, 1.36001408e-01f, -1.07242160e-01f, 3.25927228e-01f, 2.24004403e-01f,
  1.35063708e-01f, -1.81994066e-01f, -7.68849850e-02f, 1.05553949e-02f, -1.09865740e-01f, -4.16013598e-02f, 1.36723658e-02f, 7.03363046e-02f, 2.68918648e-03f, -9.57323909e-02f,
  -1.80317238e-02f, 2.72502359e-02f, 9.49204564e-02f, 6.53354973e-02f, 2.61379480e-02f, -1.72431823e-02f, -3.44474241e-02f, 2.80716233e-02f, -5.51421046e-02f, -1.00195661e-01f,
  -1.77565411e-01f, 3.56456563e-02f, 7.92896822e-02f, -8.13935697e-03f, -6.46134689e-02f, 1.51938051e-02f, -6.80378526e-02f, -1.32050514e-01f, 3.26249823e-02f, -2.51795072e-02f,
  -4.82329503e-02f, -2.87534017e-02f, -1.09908342e-01f, 1.21766301e-02f, -1.21618003e-01f, 9.73182023e-02f, 8.86666253e-02f, 4.96589206e-02f, -4.53458056e-02f, -5.50018959e-02f,
  -7.80599937e-02f, -2.86215525e-02f, 3.39082405e-02f, -4.30053882e-02f, 8.44269060e-03f, 2.18060315e-02f, 1.54097108e-02f, 2.98921131e-02f, -1.54468715e-01f, 2.89731789e-02f,
  5.77218421e-02f, -2.56326906e-02f, -7.07666948e-02f, 8.17160457e-02f, -2.89506814e-03f, -8.46057311e-02f, 8.23298022e-02f, -7.87402838e-02f, 1.58361532e-02f, 3.66998799e-02f,
  1.14821298e-02f, -2.44119123e-01f, -6.75636157e-03f, 8.42593834e-02f, -6.93746358e-02f, -8.01981762e-02f, 6.11706078e-02f, 2.20525991e-02f, -4.92054708e-02f, -9.51213315e-02f,
  4.36857902e-03f, 2.96291076e-02f, 2.68071685e-02f, -2.04569809e-02f, 1.04415618e-01f, -9.41140056e-02f, -5.49276471e-02f, 1.47438860e-02f, 3.57802100e-02f, 4.37001372e-03f,
  -1.49709694e-02f, -1.06704965e-01f, 3.64605859e-02f, -3.85960899e-02f, 6.47302642e-02f, -1.91683490e-02f, -8.29810649e-03f, -3.21156308e-02f, 6.88160658e-02f, -3.52479331e-03f,
  -1.77054137e-01f, -3.24471854e-02f, -3.69929463e-01f, -2.62120903e-01f, 1.07038848e-01f, -3.49725127e-01f, -3.10291827e-01f, -9.15981755e-02f, -9.05224122e-03f, 1.71232715e-01f,
  -9.30772126e-02f, -6.72455654e-02f, 6.88244849e-02f, -3.75033021e-01f, -4.29574370e-01f, -1.39412239e-01f, -3.52279216e-01f, -1.24692120e-01f, -1.51753118e-02f, -7.31505528e-02f,
  -9.62910503e-02f, -1.22808099e-01f, -2.99166739e-01f, 1.27109155e-01f, -9.71938074e-02f, 6.14662655e-02f, 2.16934144e-01f, 6.05912879e-02f, -4.13972028e-02f, -4.47426811e-02f,
  -1.76482558e-01f, -1.07448623e-02f, -1.97254289e-02f, -4.93674539e-03f, -7.46019483e-02f, 6.82055280e-02f, 8.29353184e-03f, -2.70099286e-02f, -1.80047415e-02f, -7.33022019e-02f,
  4.45978679e-02f, 4.31042686e-02f, -4.34860252e-02f, 1.31894844e-02f, 6.29522204e-02f, -4.63524647e-03f, -7.08258748e-02f, 7.03239581e-03f, -6.27072901e-02f, -1.12673536e-01f,
  -1.08272687e-01f, -5.28773144e-02f, 1.62429630e-03f, 1.18938545e-02f, -4.44635302e-02f, -1.20962253e-02f, -4.74579595e-02f, 3.83366905e-02f, -1.88964810e-02f, -5.15443049e-02f,
  4.03605215e-02f, 7.47524500e-02f, 9.66917351e-03f, -3.59545485e-03f, -3.88544099e-03f, 6.32180320e-03f, -2.23804414e-02f, 2.95287836e-02f, 3.03988755e-02f, 6.62177568e-03f,
  1.30587369e-02f, -3.22739892e-02f, 5.80204800e-02f, -1.37403021e-02f, -6.83848560e-03f, -5.63750938e-02f, 1.23149129e-02f, 2.30300752e-03f, -3.15720215e-02f, -4.04338166e-02f,
  -9.73802526e-03f, 1.65393949e-02f, -1.54740680e-02f, 4.52677011e-02f, -5.59967980e-02f, 1.08729796e-02f, 3.36070322e-02f, -4.80974615e-02f, 3.44145531e-03f, 1.17797889e-02f,
  -1.60989016e-02f, 5.29339574e-02f, 3.08524929e-02f, -2.00612727e-03f, 6.20249240e-03f, -6.04743417e-03f, -7.80858621e-02f, -3.19480672e-02f, -3.71679850e-02f, 1.89353563e-02f,
  2.89690066e-02f, 3.09603680e-02f, 9.35848057e-02f, 3.93144228e-02f, 1.15584526e-02f, -7.30796307e-02f, 4.53964099e-02f, 8.71241242e-02f, 1.92516986e-02f, 5.05754491e-03f,
  4.08231616e-02f, 3.43215503e-02f, 1.59404101e-03f, 5.56140356e-02f, 6.00791648e-02f, 2.05877926e-02f, 1.73694696e-02f, 7.86333531e-03f, 4.37257923e-02f, 5.48182018e-02f,
  -1.74968168e-01f, -1.25397503e-01f, -6.72003776e-02f, -3.35296601e-01f, -5.31046167e-02f, -6.23476952e-02f, -1.39824778e-01f, -1.50263086e-01f, -4.63837460e-02f, -1.28349140e-01f,
  -1.75467327e-01f, 1.14978608e-02f, 2.03776449e-01f, -1.82035819e-01f, 2.61150092e-01f, 2.65680313e-01f, -1.73937872e-01f, -2.00222638e-02f, -5.16348146e-03f, -1.89206958e-01f,
  1.48882400e-02f, -1.53397113e-01f, 1.38162270e-01f, -1.89157084e-01f, -2.27614835e-01f, -1.38659179e-01f, 1.10650212e-01f, -1.17125675e-01f, -2.16859490e-01f, -6.36004657e-02f,
  -9.59857628e-02f, -2.66000926e-01f, -3.96653675e-02f, 8.66618473e-03f, -8.95644948e-02f, 4.42445911e-02f, -4.35102880e-02f, 1.83414593e-02f, -8.26824456e-02f, -5.10607660e-02f,
  -3.38234752e-02f, 1.25415260e-02f, -1.02406710e-01f, 6.77661374e-02f, -4.25691530e-02f, -1.37097627e-01f, -3.20779942e-02f, -1.28332570e-01f, -6.67101443e-02f, 7.89303426e-03f,
  6.22913521e-03f, -7.10859150e-02f, -1.56630315e-02f, 1.14793936e-02f, 2.85939258e-02f, -9.99326855e-02f, 7.03773201e-02f, 6.52660877e-02f, -5.91171496e-02f, -9.50931758e-02f,
  -1.27192400e-02f, 4.31882292e-02f, -6.67327717e-02f, 3.84480804e-02f, -2.75608879e-02f, -1.46568641e-02f, -7.63432533e-02f, 1.84411854e-02f, 2.75584105e-02f, 5.76328930e-05f,
  2.46922802e-02f, 5.01400605e-02f, -1.08912945e-01f, 1.38787124e-02f, -4.13727760e-02f, -1.59453023e-02f, 1.22518413e-01f, -8.81764852e-03f, -5.18102199e-03f, 2.15937700e-02f,
  1.48487044e-02f, -2.64821704e-02f, 3.23052052e-03f, -3.08136246e-03f, -1.04938848e-02f, 1.13597311e-01f, -1.39457723e-02f, 8.51190370e-03f, -1.66584209e-01f, -8.77950620e-03f,
  -9.06382278e-02f, -2.20226467e-01f, -1.56008378e-02f, -8.63127038e-02f, 6.73528761e-02f, -3.92928459e-02f, 5.04135750e-02f, -1.24950884e-02f, -1.16947852e-01f, -9.70085412e-02f,
  -1.31862134e-01f, -2.47181597e-04f, -3.64456996e-02f, -8.65090080e-03f, 4.21666279e-02f, 1.04030489e-03f, 2.59795953e-02f, -1.28773749e-01f, -1.11210812e-02f, -3.59280817e-02f,
  4.20622379e-02f, 8.64957739e-03f, 1.38689727e-01f, -2.91178059e-02f, 8.84114131e-02f, -2.69280765e-02f, -8.98783654e-03f, 2.92348191e-02f, -6.12072721e-02f, 6.88008172e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.93151909e-02f, 2.17476502e-01f, 2.48526484e-01f, 2.16716990e-01f, 1.70299724e-01f, 8.46307054e-02f, 2.87997335e-01f, 1.55157164e-01f, 2.44724452e-01f, 1.74887642e-01f,
  1.44399554e-01f, 1.45191178e-01f, 9.16176736e-02f, 1.49091899e-01f, 2.66939610e-01f, 2.69587159e-01f, 2.13099167e-01f, 3.74535292e-01f, 2.77519137e-01f, 1.28668040e-01f,
  1.47795305e-01f, 1.91692144e-01f, 1.80209681e-01f, 4.01337706e-02f, 1.78335980e-01f, 1.51104644e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.03982911e-03f, -6.74776062e-02f, -9.80268493e-02f, -3.64958234e-02f, -4.33410779e-02f, 3.65657620e-02f, -1.00467324e-01f, -1.54619843e-01f, -1.71681941e-02f, -9.15405080e-02f,
  -7.56614059e-02f, 7.80701404e-03f, -1.69108845e-02f, -1.23550005e-01f, -3.75847444e-02f, 5.38843647e-02f, 1.03079742e-02f, 3.96464020e-02f, -5.21183647e-02f, -5.72463088e-02f,
  1.02705248e-01f, -3.73518243e-02f, -1.78445339e-01f, -7.39978030e-02f, -6.35768399e-02f, 3.01740281e-02f, 3.50812040e-02f, -5.71437879e-03f, 2.13763013e-01f, -9.96951461e-02f,
  -1.05890892e-01f, -5.83207794e-02f, -2.64903028e-02f, -1.11299969e-01f, -9.87154022e-02f, 1.34200543e-01f, 1.34012952e-01f, 5.81871457e-02f, -2.50579596e-01f, 5.04358718e-03f,
  1.40514120e-01f, 4.28319685e-02f, 1.13829561e-01f, 1.46132559e-01f, -2.59090923e-02f, -4.10724953e-02f, 1.11953422e-01f, -6.32142872e-02f, -3.12999815e-01f, 2.78042201e-02f,
  -1.12481982e-01f, -1.03664882e-01f, -9.99379605e-02f, 1.79901093e-01f, 8.33160207e-02f, 1.97807044e-01f, 8.50984007e-02f, 4.69683297e-02f, 4.45780419e-02f, 1.74519494e-02f,
  -1.03212923e-01f, -2.13150367e-01f, 6.91368729e-02f, 1.25662917e-02f, -8.08281917e-03f, -2.42540762e-02f, -9.79487300e-02f, -1.46961600e-01f, 5.95128387e-02f, 3.64548229e-02f,
  1.17056230e-02f, -1.45968094e-01f, 4.71572727e-02f, -1.18129365e-01f, -2.79151872e-02f, 2.24080682e-03f, -1.37904689e-01f, 4.78197373e-02f, -3.84312086e-02f, -3.76786739e-02f,
  5.45686521e-02f, 4.73725051e-02f, 6.44455478e-02f, 1.13538846e-01f, 1.53678041e-02f, 8.76393467e-02f, 1.55473286e-02f, 2.25443579e-02f, 1.91148534e-01f, 5.27299270e-02f,
  3.64896134e-02f, 1.43417507e-01f, 7.79368281e-02f, 1.69543982e-01f, 5.83595745e-02f, -7.38612900e-04f, 5.39796986e-02f, 5.70003614e-02f, -1.22739434e-01f, 9.23744589e-02f,
  -1.01460747e-01f, -8.81473869e-02f, 4.02498692e-02f, 1.75305444e-03f, 2.39173546e-02f, -7.50593841e-02f, -2.94611771e-02f, 3.23091090e-01f, 8.54896307e-02f, -1.97348326e-01f,
  1.11739701e-02f, 3.00091784e-02f, -1.36542633e-01f, 1.23195201e-01f, -1.04072191e-01f, 2.29042441e-01f, -1.00981751e-02f, 1.05464086e-01f, 3.48765664e-02f, 1.72594517e-01f,
  -3.47330206e-04f, -1.05060682e-01f, 8.08535516e-02f, 1.70615315e-01f, -2.16915652e-01f, 3.01281288e-02f, -1.04833553e-02f, -1.76588610e-01f, -1.36529192e-01f, -1.21564806e-01f,
  -6.26246035e-02f, -4.31285016e-02f, -1.00832246e-01f, -6.08020350e-02f, -7.14905560e-02f, -3.88026014e-02f, 7.56782433e-03f, -1.88284159e-01f, -9.99957770e-02f, -5.05179688e-02f,
  -1.41825125e-01f, -1.26517996e-01f, -2.39536422e-03f, -9.99260619e-02f, -4.54932675e-02f, 8.34205598e-02f, -1.21787116e-02f, -1.62554588e-02f, -3.01169269e-02f, -1.17309310e-01f,
  -1.53955370e-01f, 3.17049064e-02f, 6.93463981e-02f, -2.03505736e-02f, -8.76430869e-02f, 7.05501512e-02f, 2.33791489e-02f, 1.27140865e-01f, 1.84788238e-02f, -4.96004242e-03f,
  3.04481923e-03f, -1.29394932e-02f, -1.45580873e-01f, -3.99769004e-03f, -2.94728670e-03f, 9.90962982e-02f, -1.71213642e-01f, -2.19516292e-01f, 7.85407498e-02f, 8.29366669e-02f,
  7.47859329e-02f, 2.36970797e-01f, -6.50499016e-02f, -1.02404244e-02f, 9.76695642e-02f, 1.53292483e-03f, -1.20500833e-01f, 8.73098895e-03f, -1.20098777e-01f, 1.97636262e-01f,
  -2.01131850e-01f, -1.79073706e-01f, 2.46367082e-02f, 1.38812378e-01f, 1.73946425e-01f, 9.44896340e-02f, -1.47889748e-01f, -1.75305441e-01f, -7.34862536e-02f, -2.29511652e-02f,
  1.11100264e-01f, 1.12176672e-01f, -1.69130426e-03f, -1.27658797e-02f, 7.36778155e-02f, 1.36175469e-01f, 6.66944636e-03f, -1.23075927e-02f, 8.34292769e-02f, 3.85867357e-02f,
  7.29986653e-02f, -2.40717046e-02f, 3.34381573e-02f, 1.06958620e-01f, 8.31686184e-02f, -2.60449480e-02f, 5.18421717e-02f, 2.09504485e-01f, 1.25863990e-02f, 8.82307813e-02f,
  5.70001267e-02f, -1.71884775e-01f, -5.29288724e-02f, -4.22415175e-02f, -1.20788150e-01f, -2.85630189e-02f, -2.99458876e-02f, 2.97004208e-02f, 1.14902787e-01f, -2.11330801e-02f,
  1.41315646e-02f, -4.58094291e-02f, -9.50987265e-02f, -1.94244549e-01f, -1.14577815e-01f, 6.50047734e-02f, -8.31969380e-02f, 1.21769495e-02f, 2.41679296e-01f, 1.49113476e-01f,
  -1.18181378e-01f, 1.79377556e-01f, 1.98542953e-01f, -5.66503964e-02f, -2.25714557e-02f, 2.33113155e-01f, -4.40578945e-02f, 1.70524627e-01f, 1.41087204e-01f, -3.16342786e-02f,
  2.79672127e-02f, 9.42878500e-02f, -1.79393157e-01f, -6.67201430e-02f, 1.55952543e-01f, 6.78698123e-02f, 2.61764914e-01f, 4.60714176e-02f, 1.72112808e-01f, 1.67122051e-01f,
  -1.59013718e-02f, -1.53124839e-01f, 1.05222024e-01f, -2.18169093e-01f, -1.19957723e-01f, 1.58632174e-01f, -6.91577345e-02f, 2.47874521e-02f, 3.48672830e-02f, 7.36674741e-02f,
  -1.07974470e-01f, -2.80691478e-02f, 4.11525331e-02f, 8.86495039e-02f, -9.07636061e-02f, 8.66681803e-03f, 4.36474681e-02f, -9.39250290e-02f, 1.09242566e-01f, -1.75428335e-02f,
  2.47760061e-02f, 1.19613737e-01f, -2.37169996e-01f, -2.37409768e-04f, -4.46833260e-02f, -1.89788565e-01f, -2.33249441e-02f, -3.31003070e-02f, -1.34868294e-01f, 2.37061344e-02f,
  -1.64227203e-01f, 1.73355192e-01f, 5.51001169e-02f, -1.23176560e-01f, -1.10553056e-01f, -1.07525848e-01f, -1.17258132e-01f, -8.21094662e-02f, -1.09653786e-01f, -1.31059974e-01f,
  1.38963744e-01f, -8.36181045e-02f, -1.79454967e-01f, -1.92687865e-02f, -6.72395825e-02f, -1.84227884e-01f, 1.86988413e-01f, -1.98676791e-02f, 9.84640121e-02f, 5.79155609e-02f,
  2.35403523e-01f, 2.09521323e-01f, -2.48181000e-02f, 1.39699966e-01f, 9.78649631e-02f, -2.26821005e-03f, 2.93763485e-02f, 3.58016193e-02f, -8.58588219e-02f, -6.46101013e-02f,
  2.01341644e-01f, -2.26412658e-02f, -7.68371373e-02f, -5.31150401e-02f, 1.42801523e-01f, -1.78990051e-01f, -1.11235008e-01f, 1.54687718e-01f, 2.12631151e-02f, -1.06860017e-02f,
  -3.54949683e-02f, -3.17093432e-02f, -9.37129185e-02f, -8.79781246e-02f, 5.21898791e-02f, -1.08212255e-01f, -5.28939441e-02f, -1.18177440e-02f, -8.26586410e-03f, -1.14549167e-01f,
  -7.52812549e-02f, -2.56743003e-02f, -4.37982194e-02f, -2.77646556e-02f, -1.74589172e-01f, -2.52977967e-01f, -3.99756581e-02f, -6.48000017e-02f, -7.25573376e-02f, 7.07441419e-02f,
  -1.07774092e-02f, -6.91847429e-02f, -2.56495085e-03f, -3.34241316e-02f, 8.28422233e-02f, 6.82631657e-02f, -1.89424027e-02f, 7.99843818e-02f, -1.46053612e-01f, 3.33873443e-02f,
  1.60905689e-01f, 6.19907714e-02f, -9.46535841e-02f, 6.99754581e-02f, -2.69920882e-02f, 6.59599528e-02f, -1.68047234e-01f, 6.96315337e-03f, 1.67273894e-01f, -1.42642990e-01f,
  -6.13702051e-02f, -6.93743303e-03f, -5.25619276e-02f, 1.48401648e-01f, 5.80909587e-02f, -7.95628279e-02f, 4.17062715e-02f, -1.36902452e-01f, 2.67981619e-01f, 6.13163337e-02f,
  -1.97755650e-01f, 1.30793825e-01f, 5.67217544e-03f, -2.08133027e-01f, 1.99543253e-01f, -8.71234536e-02f, 1.56100234e-02f, 1.37222871e-01f, -2.46992633e-01f, -1.21323280e-01f,
  4.75873202e-02f, -2.29294654e-02f, 8.53011534e-02f, 7.82901496e-02f, 8.00690204e-02f, -1.02134030e-02f, -1.15227178e-02f, -7.72646368e-02f, 6.89311400e-02f, -3.12516815e-03f,
  2.52993908e-02f, 2.13728901e-02f, 1.46654313e-02f, 1.78177562e-02f, -5.14585664e-03f, 1.28961063e-03f, 8.30221847e-02f, -2.59207580e-02f, 4.11341600e-02f, -2.40508094e-02f,
  6.20842203e-02f, 6.26681373e-02f, -2.83001345e-02f, -1.13495193e-01f, -1.93305433e-01f, -6.76146746e-02f, -5.56711145e-02f, -5.22551872e-02f, 1.09057575e-01f, 7.36092553e-02f,
  -9.58878845e-02f, 1.36381462e-01f, 9.57325753e-03f, 1.79200575e-01f, 1.12301782e-01f, 1.69285387e-03f, -7.02101290e-02f, -5.87574504e-02f, 5.46988361e-02f, 4.55325842e-02f,
  -1.75433770e-01f, -5.78352474e-02f, 2.47577488e-01f, 7.88029730e-02f, 1.30378321e-01f, -1.47111386e-01f, 8.73873010e-02f, 1.28558591e-01f, 6.00049794e-02f, -6.95745125e-02f,
  2.23324653e-02f, -1.30727679e-01f, 2.60258347e-01f, -1.17584147e-01f, -5.28159887e-02f, -7.19396845e-02f, 1.04945548e-01f, -1.25876263e-01f, -2.40811519e-03f, 4.26082015e-02f,
  -7.15896785e-02f, 1.94829181e-02f, -2.21955031e-01f, -1.29929051e-01f, 9.29851905e-02f, -4.99600731e-02f, 1.19233355e-01f, -5.27004227e-02f, -1.53071173e-02f, -3.18434052e-02f,
  -5.19396514e-02f, 8.09042826e-02f, -1.18815765e-01f, 2.71860603e-02f, -8.20522159e-02f, -1.79637875e-02f, -1.28189847e-02f, -1.08469374e-01f, -8.31485689e-02f, 1.22832805e-02f,
  5.81490397e-02f, -2.18526386e-02f, 2.56224368e-02f, 1.14219613e-01f, -8.09293613e-02f, 1.16546877e-01f, -5.95966540e-02f, -1.45826861e-01f, -9.52812806e-02f, -6.66481704e-02f,
  -2.17630297e-01f, -7.21850544e-02f, -7.73687661e-02f, 3.43699045e-02f, -4.22335975e-02f, -3.15901823e-02f, 8.58384669e-02f, 2.61185970e-02f, -9.37908590e-02f, -5.65606095e-02f,
  -1.10528879e-02f, -1.26969904e-01f, 3.59219662e-03f, 1.08865127e-01f, -9.65873152e-02f, -1.32015776e-02f, -2.08201781e-01f, -1.11404553e-01f, 1.88686803e-01f, -1.67702839e-01f,
  1.41383842e-01f, 1.64750099e-01f, 1.87146157e-01f, -7.05887750e-02f, 5.31992353e-02f, -2.98454659e-03f, -8.75322819e-02f, -8.15135092e-02f, 4.98841070e-02f, -6.88081980e-02f,
  -5.69555573e-02f, -3.41029912e-02f, 1.22853428e-01f, 1.74683660e-01f, 3.32083600e-03f, 2.07526330e-02f, -8.79462212e-02f, -1.67897403e-01f, -6.54231384e-02f, 9.00458731e-03f,
  1.20727256e-01f, -6.32091761e-02f, 1.36934770e-02f, 6.05582781e-02f, 4.22865786e-02f, -3.90844904e-02f, -1.13093741e-02f, 1.12943031e-01f, 1.37217082e-02f, -2.61212531e-02f,
  -3.12757753e-02f, -2.64394619e-02f, -1.59869231e-02f, 2.07518879e-02f, 4.11091708e-02f, 8.83518253e-03f, 2.99159326e-02f, 2.49365084e-02f, 4.78398241e-02f, -4.91595874e-03f,
  9.77220237e-02f, 1.62687331e-01f, 5.95103130e-02f, 1.68619037e-01f, 7.43067190e-02f, 3.75647135e-02f, 3.26771066e-02f, -6.80661201e-02f, 1.67877190e-02f, -9.38565135e-02f,
  5.84996156e-02f, -4.26189341e-02f, -2.29261518e-02f, 1.63033128e-01f, 1.52075425e-01f, -2.60014161e-02f, 3.30746472e-02f, -3.25639587e-04f, -1.27170935e-01f, -1.50718123e-01f,
  1.57980733e-02f, -1.96001939e-02f, -1.23939915e-02f, 9.68017709e-03f, -4.51466627e-03f, -1.49475068e-01f, 1.41658351e-01f, -1.17586255e-01f, -1.46150216e-01f, 1.21126443e-01f,
  -2.06428200e-01f, -2.10499018e-03f, 2.21899927e-01f, -1.39623869e-03f, -1.22284219e-01f, 1.42575294e-01f, -2.17131078e-01f, 5.41917793e-02f, -1.67094037e-01f, -2.20737293e-01f,
  2.37127990e-01f, 1.95516184e-01f, -1.76278725e-01f, 1.77269459e-01f, 9.17130411e-02f, -1.61736950e-01f, 2.80860867e-02f, 7.92030653e-04f, 5.84401302e-02f, 8.72452259e-02f,
  -9.71680973e-03f, 2.69390736e-02f, 2.30996385e-02f, 5.70122302e-02f, 4.47482914e-02f, -2.04013605e-02f, 3.83417718e-02f, 2.34048278e-03f, 4.25399318e-02f, 1.02031399e-02f,
  9.68871266e-02f, 2.17345357e-01f, -3.99912409e-02f, 3.65533717e-02f, 2.11368853e-04f, -2.27767602e-02f, -5.30294850e-02f, 4.21521179e-02f, -1.11571319e-01f, 4.22435068e-02f,
  -5.77905141e-02f, -7.83584118e-02f, 8.06314573e-02f, -1.29986510e-01f, 1.12687379e-01f, -1.16708711e-01f, -9.02358294e-02f, 4.74902727e-02f, 1.02060787e-01f, -6.54814318e-02f,
  5.68176284e-02f, 2.11437419e-02f, 7.21440390e-02f, -3.70592368e-03f, -1.89814195e-01f, -1.07095868e-03f, 9.49310511e-02f, -8.65154192e-02f, -4.16408926e-02f, -1.22476645e-01f,
  9.71153602e-02f, 1.54821649e-01f, -6.19285479e-02f, 1.11670949e-01f, -1.68957725e-01f, 7.00555444e-02f, 2.01223418e-01f, -7.63347894e-02f, -6.04306385e-02f, 9.54666212e-02f,
  -3.50372531e-02f, 7.88356140e-02f, -1.48954019e-02f, -1.72140628e-01f, 1.78088367e-01f, 5.09996675e-02f, -1.37176543e-01f, -3.62917483e-02f, -3.37879173e-02f, -8.22700486e-02f,
  -6.29409775e-02f, -5.14484849e-03f, -4.36445139e-02f, -4.34226021e-02f, -4.60939743e-02f, 3.38042267e-02f, -2.35562045e-02f, -3.29667367e-02f, -7.47167692e-02f, -2.78756823e-02f,
  6.62435815e-02f, -8.42744578e-03f, -1.87981054e-02f, -2.64387839e-02f, -1.29072383e-01f, 1.64735392e-02f, -5.80221526e-02f, 6.38202727e-02f, -5.25779836e-02f, 2.81833950e-02f,
  1.87023640e-01f, 2.60391701e-02f, 9.91027653e-02f, -5.27839623e-02f, -7.84344450e-02f, 1.61173940e-01f, -4.25736532e-02f, -2.12711096e-02f, 3.36174816e-02f, -2.84449160e-02f,
  -9.15532038e-02f, -1.62957683e-01f, -1.31481797e-01f, 1.49451375e-01f, -9.01603699e-03f, 4.90903594e-02f, 6.40676618e-02f, 2.26545352e-02f, -1.04057215e-01f, 9.07568559e-02f,
  -8.45630169e-02f, -2.12741494e-02f, -6.89631328e-02f, 2.04908207e-01f, 1.63016319e-02f, -1.89035311e-01f, 8.45109671e-02f, 1.73019409e-01f, -1.04276866e-01f, 5.22662885e-02f,
  -1.77226231e-01f, 1.28238454e-01f, 1.54472336e-01f, 9.98931751e-02f, 1.61957949e-01f, -7.92624988e-03f, 1.62735488e-02f, 1.94727451e-01f, 9.14863199e-02f, 1.38054311e-01f,
  1.12196393e-01f, 4.92057391e-02f, -2.46055750e-03f, 1.91816092e-02f, -2.16230657e-02f, -2.43774010e-03f, 1.59706324e-02f, 5.23757329e-03f, 1.54884178e-02f, 2.64732484e-02f,
  -4.85204570e-02f, -9.10315216e-02f, -3.41401920e-02f, -3.43354382e-02f, 3.91072500e-03f, -2.81686219e-03f, -6.04352206e-02f, -9.88983549e-03f, -6.89123198e-02f, 6.59646292e-04f,
  2.03507654e-02f, 6.30600974e-02f, 2.70466004e-02f, 1.74035117e-01f, 1.10887587e-01f, 1.69262305e-01f, 9.16629136e-02f, -7.26243556e-02f, -9.95044596e-03f, 7.02667609e-02f,
  3.03877555e-02f, -5.81918024e-02f, 1.26096949e-01f, -7.52355978e-02f, -3.05650625e-02f, 3.45906317e-02f, -7.24168718e-02f, 1.00211456e-01f, 1.58952195e-02f, 1.75945461e-01f,
  -3.74059938e-02f, -3.17648016e-02f, 1.60658211e-02f, 1.40712112e-01f, 2.50336342e-02f, -1.08020678e-01f, 7.96076097e-03f, -2.28185236e-01f, -1.30684271e-01f, -1.85799152e-01f,
  -1.01731056e-02f, 3.13412696e-02f, -1.50477841e-01f, 2.01414928e-01f, 7.72019522e-03f, 1.74886212e-01f, 1.54492497e-01f, 1.91793635e-01f, 9.80839059e-02f, 1.19228274e-01f,
  -1.96378052e-01f, -7.55927861e-02f, -1.15931267e-02f, 1.92148089e-01f, -9.69271064e-02f, 4.28005718e-02f, -1.68522328e-01f, -2.30717987e-01f, 7.12622628e-02f, 6.45572543e-02f,
  6.34278730e-02f, -1.03772767e-01f, 6.19398504e-02f, 3.87359411e-02f, -8.26862548e-03f, -1.86723266e-02f, -1.20568097e-01f, 1.15089424e-01f, -8.25637858e-03f, -7.00390339e-02f,
  1.15442567e-01f, 8.20409954e-02f, -8.63448754e-02f, -1.21133752e-01f, -5.49952015e-02f, -5.66398054e-02f, 6.49003983e-02f, -6.44987449e-02f, -3.57042067e-02f, 9.08623263e-03f,
  1.98526576e-01f, -6.85902014e-02f, 9.17677060e-02f, 1.41306788e-01f, -5.12407497e-02f, 1.15976945e-01f, -4.51053213e-03f, 5.98245189e-02f, 1.07835673e-01f, -8.44663009e-02f,
  -1.15678743e-01f, -7.57089704e-02f, 3.70972231e-02f, -1.17966393e-02f, -1.88306361e-01f, -1.55525938e-01f, 2.47058660e-01f, 7.08901361e-02f, -6.75052106e-02f, -1.92579050e-02f,
  9.89017561e-02f, 7.37398639e-02f, 1.31404296e-01f, -1.41067475e-01f, -3.63910720e-02f, -1.30523682e-01f, 1.15676545e-01f, -1.23762004e-01f, -1.50411427e-01f, -9.64948982e-02f,
  1.49230346e-01f, -6.76584765e-02f, -1.95686575e-02f, -1.14818819e-01f, -1.04069896e-01f, 8.65107551e-02f, -1.39283404e-01f, -6.08483441e-02f, 7.01194108e-02f, -3.37795950e-02f,
  1.27864018e-01f, -7.69125894e-02f, -3.96934114e-02f, -7.79854730e-02f, -5.69806993e-02f, 4.98389490e-02f, -3.21392603e-02f, 1.02930749e-02f, -8.41997117e-02f, 4.75124503e-03f,
  -4.50936481e-02f, 8.93621612e-03f, 4.25731055e-02f, -3.94106582e-02f, -3.44175249e-02f, -5.03583029e-02f, 9.72262695e-02f, 5.62155945e-03f, -3.07634454e-02f, -1.18426487e-01f,
  -1.85050108e-02f, 4.77998033e-02f, 1.76304236e-01f, 2.57381778e-02f, 9.04096067e-02f, 1.03981569e-01f, -9.30919871e-02f, -1.61442403e-02f, 9.51435491e-02f, -1.80384964e-01f,
  5.46273664e-02f, -1.17415987e-01f, -1.04389742e-01f, 7.47291446e-02f, 1.00689717e-01f, -8.07714537e-02f, 9.68297273e-02f, -1.07389539e-01f, 1.27051368e-01f, -6.43930286e-02f,
  -1.76283807e-01f, -4.64087315e-02f, -1.76668633e-02f, 1.13522612e-01f, -4.69890349e-02f, -2.81775117e-01f, -1.04193598e-01f, 4.93889190e-02f, -6.71578646e-02f, 8.23956206e-02f,
  -2.54422039e-01f, -4.81137112e-02f, 1.48795143e-01f, -1.28943145e-01f, -1.57008320e-01f, 9.38739553e-02f, -2.13278919e-01f, -2.28502527e-02f, -4.59693074e-02f, -1.44273162e-01f,
  2.03499630e-01f, 1.01726323e-01f, -1.22395515e-01f, 1.04332194e-01f, -9.51521769e-02f, -2.28901282e-02f, -3.51139680e-02f, 6.85630068e-02f, 2.94639803e-02f, -6.26743287e-02f,
  -5.28934039e-02f, -1.27947573e-02f, -2.62134466e-02f, -3.20118442e-02f, -6.87136874e-02f, -3.47916000e-02f, -1.27361631e-02f, 5.19722700e-02f, -1.14910141e-01f, 2.55166814e-02f,
  -3.44818830e-02f, -3.46234697e-03f, 3.76802124e-02f, 1.21049613e-01f, -3.18037421e-02f, 1.26378536e-01f, 7.25674406e-02f, 1.04168341e-01f, -5.61709097e-03f, -7.77159184e-02f,
  -1.36457821e-02f, 8.00668672e-02f, -3.02191116e-02f, 7.01265633e-02f, 1.32903308e-01f, 4.46744114e-02f, -6.19837902e-02f, -1.33819049e-02f, -8.20959806e-02f, 1.00930937e-01f,
  -3.23062614e-02f, 2.04476073e-01f, 4.05891649e-02f, 6.28177375e-02f, -7.75374323e-02f, 1.81250215e-01f, 8.05848464e-02f, -1.80502951e-01f, 2.03919620e-03f, -1.73368640e-02f,
  -1.56425089e-01f, -2.46939003e-01f, 3.44009325e-02f, 5.73815331e-02f, -1.34775311e-01f, 1.48548499e-01f, -5.89177534e-02f, 1.29222587e-01f, 1.21111624e-01f, 1.74978569e-01f,
  1.27485991e-01f, 2.14298785e-01f, -1.12458907e-01f, -5.23825642e-03f, -1.10740289e-01f, 1.64639756e-01f, 1.96943292e-03f, -2.41199937e-02f, -1.95399791e-01f, -2.04205081e-01f,
  -1.52053339e-02f, -1.20297298e-01f, -7.22367540e-02f, -1.41993180e-01f, 2.59483736e-02f, 1.01498449e-02f, -8.62884372e-02f, -1.91966251e-01f, 4.15944718e-02f, -6.69746324e-02f,
  -9.02835727e-02f, -2.73628794e-02f, -8.28711390e-02f, -5.51326461e-02f, 7.23424554e-02f, -5.71870594e-04f, 2.79885978e-02f, 5.74382581e-03f, 7.53016304e-03f, -5.09890020e-02f,
  9.31028090e-03f, -1.10976063e-01f, -1.26374289e-01f, 5.49549311e-02f, 1.56647429e-01f, 6.56170305e-03f, 5.99412359e-02f, 1.51402712e-01f, 1.49808913e-01f, 1.45399407e-01f,
  -3.96155119e-02f, -6.92615733e-02f, 4.33553569e-02f, -2.97583789e-02f, -7.98819810e-02f, -8.15174542e-03f, 9.47466046e-02f, 5.19599672e-03f, -1.10900402e-01f, 1.06181074e-02f,
  -3.48461582e-03f, 3.51338685e-02f, 1.20305028e-02f, 3.42325062e-01f, -9.80853010e-03f, -5.73408119e-02f, 1.66713838e-02f, -5.67998849e-02f, -1.19763166e-01f, -9.44856331e-02f,
  -6.81287795e-02f, -1.19586036e-01f, -2.18826145e-01f, 1.06299646e-01f, -1.28434867e-01f, 8.74579474e-02f, 5.42761199e-02f, 3.67623456e-02f, 1.46023467e-01f, 1.76102042e-01f,
  -6.82892874e-02f, -1.77585304e-01f, 6.24770038e-02f, -3.31605971e-03f, -1.27712101e-01f, -4.94868867e-02f, -4.83927913e-02f, -7.61870062e-03f, -2.08103620e-02f, -1.21103995e-01f,
  6.46254513e-03f, -3.88113633e-02f, 1.29624918e-01f, -6.60122931e-02f, -9.18592662e-02f, -8.34520906e-02f, -1.43487215e-01f, -2.59376112e-02f, -6.82742447e-02f, -2.10911900e-01f,
  1.15467004e-01f, -6.02104813e-02f, 1.01558038e-03f, 9.14893076e-02f, -8.92438591e-02f, 2.64846720e-02f, -7.75372935e-03f, 1.59366112e-02f, 1.52088687e-01f, -5.57752885e-02f,
  2.01435313e-02f, 1.68067336e-01f, -1.57645822e-01f, 1.12489842e-01f, 1.67943969e-01f, 1.17547989e-01f, 2.42223237e-02f, 1.61408558e-01f, 5.98708391e-02f, 5.44977421e-03f,
  -9.43486989e-02f, 1.04776450e-01f, 2.53616214e-01f, 3.53429392e-02f, -1.41542315e-01f, -1.18399844e-01f, -1.69859067e-01f, -9.89569724e-02f, -1.56748801e-01f, 2.74091847e-02f,
  -8.56053978e-02f, -1.75556242e-02f, 3.39620799e-01f, 1.53803065e-01f, 3.21801081e-02f, 1.58774137e-01f, -2.81387568e-02f, -1.11613229e-01f, -4.77140732e-02f, 4.14493075e-03f,
  -8.01261812e-02f, 5.44222072e-03f, -1.62812114e-01f, 4.20405641e-02f, 1.81635424e-01f, 1.39162078e-01f, -1.79486305e-01f, -4.45548333e-02f, 5.58105111e-02f, 1.41988304e-02f,
  4.03113570e-03f, -5.25854900e-02f, -2.80902889e-02f, 3.56549062e-02f, -9.63113457e-02f, -6.78416044e-02f, -9.50652063e-02f, 2.27073170e-02f, -3.53800692e-02f, 3.68411168e-02f,
  1.15802243e-01f, -2.18733866e-02f, 3.46096940e-02f, -8.82442854e-03f, 1.81763489e-02f, 7.61334896e-02f, -2.76687760e-02f, -1.21920124e-01f, 1.12521276e-02f, -8.48224014e-02f,
  -5.74227907e-02f, -4.79085296e-02f, 2.59174854e-02f, 1.38129726e-01f, -7.62213469e-02f, 8.44234377e-02f, 8.01694766e-02f, 3.74261998e-02f, -1.55993858e-02f, -2.00750217e-01f,
  -1.24088317e-01f, -7.09988922e-02f, 4.24953457e-03f, 1.82808582e-02f, -8.30295123e-03f, -8.90068524e-03f, 3.81929800e-02f, 1.28560036e-01f, 1.29720554e-01f, -2.18223304e-01f,
  1.02565102e-01f, 1.90791026e-01f, -4.67356108e-02f, -1.04437076e-01f, 6.82220757e-02f, -1.70183614e-01f, 1.19172938e-01f, -1.86171874e-01f, -2.00444087e-01f, -2.33609051e-01f,
  1.38754562e-01f, -9.17211082e-03f, 1.15749702e-01f, 4.17424813e-02f, -6.10787794e-02f, 7.68551081e-02f, -1.37721270e-01f, -8.26152042e-02f, 8.68187845e-02f, -1.96067452e-01f,
  -2.60995068e-02f, -4.43899930e-02f, 1.00351229e-01f, 4.72505158e-03f, -3.47425230e-02f, 3.48306037e-02f, -1.69535559e-02f, 3.00655549e-04f, -3.93820181e-02f, 2.05929317e-02f,
  -2.83910893e-02f, -3.23725715e-02f, -2.96822954e-02f, -3.49241309e-03f, 1.36181533e-01f, -4.12052311e-02f, 3.86446267e-02f, 1.74549967e-02f, -1.10502191e-01f, -3.34777050e-02f,
  -3.70765873e-03f, -1.72204584e-01f, -6.77972957e-02f, -9.08004791e-02f, -9.50627550e-02f, 2.22676285e-02f, -4.71821912e-02f, 2.31022630e-02f, -1.87149327e-02f, -9.88799408e-02f,
  1.09707238e-02f, -7.60062411e-02f, -3.43773589e-02f, -6.10122383e-02f, 5.25037292e-03f, -1.79379612e-01f, 3.30332220e-02f, -7.30612129e-02f, -3.57501134e-02f, -7.56993517e-02f,
  -4.68691103e-02f, -1.39020324e-01f, 1.52343720e-01f, 6.02302365e-02f, 1.29007056e-01f, 9.96160805e-02f, 1.12103060e-01f, 1.72787204e-01f, 3.17483693e-02f, -5.62083200e-02f,
  3.59944329e-02f, -2.37574518e-01f, -9.59248515e-04f, -1.98681056e-01f, -1.09488755e-01f, -8.58123302e-02f, -5.44963293e-02f, -4.96802367e-02f, 8.54815170e-02f, -5.48034534e-03f,
  2.51893010e-02f, -2.19658300e-01f, -9.26114917e-02f, -3.20664085e-02f, 1.63084134e-01f, 1.33379251e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.67652667e-01f, 1.17068894e-01f, 1.16421148e-01f, 1.71234488e-01f, 5.71432449e-02f, 1.52224481e-01f, 1.37273580e-01f, 1.89764202e-01f, -3.52488831e-02f, 2.07945868e-01f,
  1.52618587e-01f, 1.76688269e-01f, 2.07326159e-01f, 1.37709633e-01f, 6.18846677e-02f, 2.19845518e-01f, -2.87799723e-02f, 5.65954670e-02f, 6.90512657e-02f, -9.60831568e-02f,
  4.47799452e-02f, -5.20571209e-02f, 2.46955007e-02f, -1.18322447e-01f, -2.53243506e-01f, -3.89311872e-02f, -9.59676132e-02f, -1.81712314e-01f, 1.00230705e-02f, -2.42260426e-01f,
  -3.89577895e-02f, -1.01426460e-01f, -8.97131488e-02f, -1.47158995e-01f, 2.13981550e-02f, 1.62430909e-02f, -9.52031091e-02f, -1.16312705e-01f, -1.56718582e-01f, -9.32067260e-02f,
  1.17725194e-01f, 5.36629297e-02f, 1.40227407e-01f, 4.73769233e-02f, 4.29305971e-01f, 5.39651839e-03f, 1.49810091e-01f, 4.16284539e-02f, -7.41947591e-02f, -1.20121270e-01f,
  1.67813897e-01f, -1.35416090e-01f, 1.22008033e-01f, -1.30296675e-02f, 1.87282830e-01f, -2.21318126e-01f, 7.59653822e-02f, 1.79877743e-01f, 1.73222751e-03f, -1.41249210e-01f,
  2.02973075e-02f, -2.63479184e-02f, 3.46772820e-01f, 1.65401787e-01f, 1.11389212e-01f, 8.68717730e-02f, 1.41423196e-01f, 7.49321422e-03f, 1.40586510e-01f, 7.55958334e-02f,
  1.25186101e-01f, 8.05713795e-03f, 3.93376276e-02f, 2.15060100e-01f, 1.33513689e-01f, 1.05541395e-02f, 1.14792019e-01f, 1.50926396e-01f, 9.30111632e-02f, 6.98810965e-02f,
  1.03081763e-01f, -1.04720937e-02f, 1.19258806e-01f, -2.30257958e-02f, 9.57764089e-02f, 8.44617113e-02f, 2.59139270e-01f, -3.40399929e-05f, 4.12006117e-02f, 1.11516379e-01f,
  4.77621108e-02f, -3.60194072e-02f, -7.79882190e-04f, 9.59691033e-03f, 5.02349064e-02f, -1.20789140e-01f, -2.83222739e-02f, 2.68703122e-02f, 5.16153648e-02f, -6.48805499e-02f,
  5.55663928e-02f, -5.54105565e-02f, 2.90648580e-01f, 2.69909680e-01f, -7.53997713e-02f, 7.03717694e-02f, -4.37432453e-02f, -1.09340139e-01f, -7.82544538e-02f, 3.77231725e-02f,
  -6.64728433e-02f, 1.90027487e-02f, 1.60981938e-01f, -1.14314526e-01f, -5.86347282e-02f, -1.19556166e-01f, 2.69355386e-01f, 1.95559934e-01f, -9.90930200e-02f, -1.39370322e-01f,
  -1.20487206e-01f, -1.74449626e-02f, 9.55696329e-02f, 1.69576883e-01f, 1.49622425e-01f, -4.92656901e-02f, -1.16311498e-01f, -4.26872820e-02f, 1.41410142e-01f, 1.30914837e-01f,
  1.24211870e-01f, 1.63109854e-01f, 2.87908521e-02f, 9.74186510e-02f, 1.12796769e-01f, 2.55246580e-01f, 6.14418723e-02f, 4.39953022e-02f, 1.58254467e-02f, 5.89109249e-02f,
  1.51109487e-01f, 2.57312190e-02f, 2.01837361e-01f, 1.05977729e-01f, 4.10960130e-02f, 1.25423893e-01f, 5.01613915e-02f, -3.81393313e-01f, -4.94171381e-02f, -1.61949381e-01f,
  -1.89966843e-01f, -4.00109254e-02f, -5.64988591e-02f, 4.22270931e-02f, -1.53746754e-02f, -9.27822217e-02f, -9.65106636e-02f, 8.18973407e-03f, -1.28788725e-01f, -2.39124790e-01f,
  -8.82112235e-02f, -1.45027041e-01f, -8.40996020e-03f, -1.66222095e-01f, 2.33658612e-01f, 2.46194407e-01f, 2.04049442e-02f, 1.92128997e-02f, 3.65032673e-01f, 1.47128075e-01f,
  2.41742030e-01f, 9.36739668e-02f, -2.62980610e-01f, 4.92660731e-01f, 2.11455479e-01f, 5.71654439e-02f, 3.16219598e-01f, -2.09932372e-01f, -1.81873009e-01f, -2.05684856e-01f,
  1.72681034e-01f, -7.30826110e-02f, 1.63585410e-01f, 1.00320935e-01f, 2.45652303e-01f, 2.75520116e-01f, -1.44590333e-01f, -3.63152534e-01f, 3.32489967e-01f, -7.36539587e-02f,
  -9.54386592e-02f, 4.05396700e-01f, -1.16756544e-01f, 1.02387026e-01f, -6.33726269e-02f, 2.19379127e-01f, -9.00397822e-02f, 7.22552016e-02f, -2.01231558e-02f, 1.64205030e-01f,
  2.75148302e-02f, -1.54119655e-01f, 1.31281868e-01f, 2.84906998e-02f, -3.07994559e-02f, 4.08055671e-02f, -1.12110592e-01f, 4.38949913e-02f, -6.68561682e-02f, 1.55216083e-01f,
  1.85836963e-02f, 1.25906110e-01f, 1.75665438e-01f, 1.30960584e-01f, -9.12706777e-02f, -1.41717563e-03f, -2.92659074e-01f, 6.48018345e-02f, -9.96422768e-02f, -1.73017085e-01f,
  -1.24796398e-01f, -2.05704346e-01f, -2.77997106e-01f, 1.56069145e-01f, -1.56182095e-01f, 1.33220240e-01f, 1.06499285e-01f, 7.46765211e-02f, -4.33138385e-02f, 1.95945174e-01f,
  -2.48448253e-01f, -1.58700168e-01f, 1.79100201e-01f, 1.96708798e-01f, 1.13825001e-01f, -1.88677907e-01f, -7.92221427e-02f, 1.91679057e-02f, 1.66553035e-01f, 3.63483191e-01f,
  -1.21548317e-01f, 3.05295587e-01f, 7.19251335e-02f, 2.88063735e-01f, 3.58817652e-02f, -6.58483431e-02f, 3.58259827e-01f, 2.50782967e-01f, 9.76292044e-02f, 2.33704433e-01f,
  4.87130396e-02f, -8.96617398e-02f, 1.20277897e-01f, 3.44949275e-01f, 2.56742481e-02f, 2.44044915e-01f, 6.96041882e-02f, -2.55489945e-02f, -6.01387769e-02f, 1.78289060e-02f,
  1.38617307e-01f, -4.40663518e-03f, 1.84543058e-02f, -2.27320511e-02f, 4.05457392e-02f, -2.09528524e-02f, 8.49174708e-02f, 8.55445191e-02f, -4.96987393e-03f, 9.44667831e-02f,
  -1.41476825e-01f, -5.44345193e-03f, 2.12020576e-02f, 1.07979989e-02f, 5.63019440e-02f, 1.50865093e-01f, 2.66434383e-02f, -1.26376644e-01f, -4.35680784e-02f, -1.61964461e-01f,
  -9.75871682e-02f, -1.07538998e-01f, -8.30500200e-02f, 1.80361524e-01f, 3.70507725e-02f, -1.46262810e-01f, 1.25451207e-01f, 4.75923270e-02f, -1.11303948e-01f, 3.36195040e-03f,
  -2.06649348e-01f, 1.70077622e-01f, -1.34036273e-01f, -3.91553268e-02f, 2.11085193e-02f, -1.73817247e-01f, -2.14079678e-01f, 1.53645888e-01f, -2.87296493e-02f, 4.16221231e-01f,
  5.24928272e-01f, -2.44082972e-01f, 1.29909828e-01f, -3.24320793e-02f, -1.25223160e-01f, 2.31684700e-01f, 1.63975097e-02f, 2.38305658e-01f, -9.44085717e-02f, -5.47851436e-02f,
  2.68583655e-01f, -2.53875881e-01f, 1.68148339e-01f, 3.26964259e-01f, -1.14708923e-01f, -7.45295584e-02f, 7.02869222e-02f, -1.07252553e-01f, 5.52013338e-01f, 2.02993795e-01f,
  -5.29147685e-03f, -2.58680247e-03f, 1.34559959e-01f, -1.27013266e-01f, 1.22556917e-01f, -1.03548065e-01f, 2.16195017e-01f, 6.13876246e-02f, 2.32752129e-01f, -1.05739743e-01f,
  -7.87387639e-02f, -1.95486918e-02f, -3.66741642e-02f, 1.07868835e-01f, 3.95642444e-02f, -1.57222897e-01f, 2.12453917e-01f, 7.05454946e-02f, 1.89213842e-01f, -4.17710021e-02f,
  -3.67587686e-01f, -1.26473218e-01f, -1.69740394e-01f, 5.27624078e-02f, 3.28347445e-01f, -3.07699330e-02f, -1.31336832e-02f, 3.09560418e-01f, -1.58002272e-01f, 3.87147903e-01f,
  3.52689952e-01f, 9.39689502e-02f, 2.41921674e-02f, -7.44731873e-02f, -2.05286711e-01f, -1.30713135e-02f, -3.70170295e-01f, 2.03941260e-02f, 4.74828959e-01f, -2.29618326e-01f,
  1.82234868e-01f, 1.77787710e-03f, 1.18557841e-01f, 4.98937875e-01f, 2.89855063e-01f, 2.89971918e-01f, -2.08351742e-02f, -2.03120977e-01f, 3.95351827e-01f, 1.54957667e-01f,
  -1.24996938e-01f, 3.13989818e-01f, -1.95908979e-01f, -3.67560387e-01f, 2.31691152e-01f, 9.12642702e-02f, 1.49719164e-01f, -8.58837292e-02f, -2.71300226e-01f, -2.36257076e-01f,
  -1.03885092e-01f, -1.86298769e-02f, 1.08460136e-01f, -4.88363430e-02f, 1.06214970e-01f, -4.92004380e-02f, 2.12872811e-02f, 1.56083688e-01f, 2.15229718e-03f, 5.35797551e-02f,
  -2.06723344e-02f, 1.43064782e-01f, 8.36472958e-02f, -8.16757977e-02f, -1.10651948e-01f, 6.41202927e-02f, 4.21009734e-02f, -5.72655872e-02f, 2.08321407e-01f, 8.14919546e-02f,
  1.42283976e-01f, 7.90385231e-02f, -2.65463046e-03f, -2.60401607e-01f, -1.11900084e-01f, -2.42485970e-01f, -4.41778898e-01f, -2.84350775e-02f, 7.30901882e-02f, -9.99090746e-02f,
  -1.47419907e-02f, 1.01362966e-01f, -6.82013249e-03f, 3.18117323e-03f, 4.39078286e-02f, 1.08697843e-02f, 3.89898680e-02f, -2.19121978e-01f, 9.94295254e-02f, -2.34742016e-02f,
  -6.51476085e-02f, 1.60232365e-01f, 3.21663767e-02f, -6.40443489e-02f, 2.60120064e-01f, -2.65001189e-02f, 1.51749685e-01f, 2.04986647e-01f, 1.92989111e-01f, 2.25101635e-01f,
  1.41687572e-01f, -1.46701559e-01f, 2.60140777e-01f, -1.35217290e-02f, 2.51247585e-01f, -1.38644293e-01f, -1.93705991e-01f, -1.27212718e-01f, 2.17788983e-02f, 2.03271165e-01f,
  1.35993585e-01f, 2.48361737e-01f, -2.09196538e-01f, -1.51281416e-01f, 2.86548167e-01f, 4.59967926e-02f, 2.31578723e-01f, 2.19364882e-01f, 3.85800265e-02f, 1.82612687e-01f,
  1.95972651e-01f, 9.61997360e-02f, 1.68988168e-01f, 1.38359563e-03f, 2.52529442e-01f, 3.30362946e-01f, 1.28649920e-01f, 8.90054405e-02f, 1.12383114e-02f, 4.85143214e-02f,
  1.09749310e-01f, 2.44415537e-01f, 1.38385743e-01f, -8.34500417e-02f, 1.55730128e-01f, 4.55128402e-02f, 1.35914013e-01f, -8.51142108e-02f, -2.42609829e-01f, -4.71495129e-02f,
  2.17772231e-01f, 1.77921787e-01f, 2.68663228e-01f, -1.57310575e-01f, -1.36432275e-02f, 1.68540686e-01f, -2.99705535e-01f, 3.47109616e-01f, 2.52941549e-01f, 1.05205841e-01f,
  9.89257246e-02f, 3.30497846e-02f, -3.42988670e-02f, -3.16360056e-01f, -3.82340960e-02f, 1.66298851e-01f, 4.55300033e-01f, 2.03160465e-01f, -1.89806465e-02f, 2.94890016e-01f,
  1.39325028e-02f, -1.43387794e-01f, -4.07027245e-01f, 4.26375329e-01f, 6.36385232e-02f, -8.56530741e-02f, 4.91049707e-01f, -1.62704974e-01f, -1.36111647e-01f, 1.48532286e-01f,
  2.03506872e-01f, -2.09905550e-01f, -2.63890177e-01f, -7.25049600e-02f, 1.38315022e-01f, 6.52512237e-02f, -2.30342820e-01f, -9.94270071e-02f, 2.15984657e-01f, 3.93742509e-02f,
  -3.00528258e-01f, 2.55063236e-01f, 5.56518212e-02f, -1.35391392e-02f, 1.07624993e-01f, 6.55503795e-02f, 1.06218018e-01f, 9.33709461e-03f, 1.25510976e-01f, 5.59598245e-02f,
  8.99072513e-02f, 5.71948104e-02f, 8.25363025e-03f, 2.05841865e-02f, 6.85287779e-03f, 6.77594021e-02f, 1.61550358e-01f, 1.73766896e-01f, 1.34331852e-01f, 2.27696579e-02f,
  1.23074681e-01f, -1.50698453e-01f, 7.22757261e-03f, -7.65165612e-02f, -1.30522251e-01f, 7.80963749e-02f, 1.69297114e-01f, 2.18867566e-02f, 1.52778447e-01f, 9.15393531e-02f,
  6.15079515e-02f, 1.53642014e-01f, -9.24705490e-02f, -1.52551115e-01f, 6.03013821e-02f, -1.53489737e-02f, -5.18595204e-02f, -9.02741551e-02f, 2.07285091e-01f, 1.04196668e-01f,
  8.07795152e-02f, 2.17938900e-01f, 1.09596297e-01f, -2.77671553e-02f, -1.43898996e-02f, 1.89231783e-01f, -9.56690311e-02f, 2.46603295e-01f, -1.72397271e-02f, -1.55449621e-02f,
  1.05641864e-01f, 1.76770110e-02f, -2.13326933e-03f, -1.31243989e-01f, -7.61683211e-02f, 1.70182556e-01f, -3.59065495e-02f, 1.62678704e-01f, 1.77069642e-02f, -3.56983319e-02f,
  1.95145145e-01f, 1.71791106e-01f, 1.00915283e-01f, -1.53268635e-01f, -1.91520497e-01f, 4.75744251e-04f, 1.12720728e-02f, 1.21631227e-01f, 2.38490421e-02f, 1.26993015e-01f,
  3.61495502e-02f, 3.58232185e-02f, 7.72952288e-02f, 7.58564621e-02f, 9.69223380e-02f, 4.70387638e-02f, 6.64747655e-02f, 4.84521082e-03f, 9.81701463e-02f, 1.20085798e-01f,
  -1.02462493e-01f, -9.04143825e-02f, 2.97797490e-02f, 3.44259739e-02f, 4.55585793e-02f, 5.57439104e-02f, 8.50740895e-02f, 4.62771133e-02f, 1.93936359e-02f, -6.80088848e-02f,
  -3.53678539e-02f, 3.90859842e-02f, -7.74475932e-02f, -3.30612846e-02f, -2.04788819e-01f, -6.80182129e-02f, 1.25332743e-01f, 1.68419972e-01f, -1.20126016e-01f, 8.21175426e-02f,
  2.22929627e-01f, 1.20436624e-02f, -3.00496757e-01f, 4.45413142e-02f, 2.19008788e-01f, -1.41775068e-02f, -3.49462032e-02f, 6.98435074e-03f, 4.98367883e-02f, -1.88817456e-01f,
  1.59013957e-01f, -1.10387154e-01f, 4.47420478e-02f, 7.86676481e-02f, 4.53835011e-01f, 1.17313661e-01f, 1.90386519e-01f, 2.63866812e-01f, 1.47261932e-01f, -7.71628171e-02f,
  1.22134566e-01f, -2.26363521e-02f, -6.44192472e-02f, 2.40746364e-01f, -1.93013445e-01f, 1.72476992e-02f, 3.67490143e-01f, 3.88442695e-01f, 2.58111387e-01f, 1.15470305e-01f,
  1.13216400e-01f, 1.55456036e-01f, 1.50985196e-01f, 6.39182478e-02f, 8.73934850e-02f, 1.42210856e-01f, 1.38168782e-02f, 2.69449875e-02f, 6.22371137e-02f, 3.33159007e-02f,
  -2.13032868e-02f, 1.70412019e-01f, 7.75949506e-04f, 1.04527764e-01f, 9.12690759e-02f, 1.66772380e-01f, 1.64259821e-01f, 2.13649243e-01f, 7.55246058e-02f, -1.32780880e-01f,
  -1.83479115e-01f, -6.60442412e-02f, -3.23267393e-02f, -5.81153780e-02f, 1.89344153e-01f, 5.72634824e-02f, -1.02072135e-01f, 2.07486555e-01f, 1.32811293e-01f, 2.50625670e-01f,
  -3.08076516e-02f, -1.58437356e-01f, -6.14618249e-02f, 4.54896949e-02f, -3.29363979e-02f, 1.25982523e-01f, 1.36568159e-01f, 8.97540003e-02f, -1.22470716e-02f, 3.48547965e-01f,
  2.74350166e-01f, -3.15385878e-01f, 1.93027109e-01f, 2.93819070e-01f, -6.30586743e-02f, -1.05011940e-01f, 1.97367683e-01f, -4.80254665e-02f, 1.00566298e-01f, -8.56287703e-02f,
  -1.49567217e-01f, -1.04855984e-01f, 2.83914298e-01f, 6.75726235e-02f, 6.39331043e-02f, 3.31150472e-01f, 5.40738404e-02f, 1.29931271e-01f, -1.66653037e-01f, 1.35835364e-01f,
  1.29945844e-01f, -1.70148924e-01f, -1.32463768e-01f, -6.26914054e-02f, 1.28505146e-02f, 8.64517540e-02f, 8.65408108e-02f, 4.82093869e-03f, 1.44949257e-01f, 1.13969997e-01f,
  9.93006825e-02f, 4.77407984e-02f, 1.57076791e-01f, 8.51167291e-02f, 1.61292434e-01f, 4.18220051e-02f, 1.78938322e-02f, 9.45976600e-02f, -5.81815504e-02f, 7.52969757e-02f,
  9.62705836e-02f, -5.67279942e-03f, 8.18678811e-02f, 2.93163359e-01f, 1.14717573e-01f, 1.82976723e-01f, 1.58799976e-01f, 1.14419581e-02f, -7.48566836e-02f, -8.88668001e-02f,
  2.77926475e-02f, -2.08823439e-02f, -5.20140715e-02f, -1.05474740e-01f, -8.73644557e-03f, 1.95632428e-01f, 8.27097446e-02f, 2.08173186e-01f, 1.47901094e-02f, 8.58912468e-02f,
  -1.39210761e-01f, -1.28515527e-01f, 8.12711567e-02f, 3.63062955e-02f, -2.23003685e-01f, 1.28835946e-01f, -1.40216023e-01f, -1.88457698e-01f, 2.12417662e-01f, -1.40246734e-01f,
  -1.30816773e-01f, 2.27524117e-01f, -1.33718655e-01f, 3.37374389e-01f, 2.81244665e-01f, 3.60116690e-01f, 3.67722884e-02f, 1.54419571e-01f, 4.70468141e-02f, 6.37292769e-03f,
  -9.41269547e-02f, -1.19978093e-01f, 2.47649565e-01f, 2.76719004e-01f, -1.16185427e-01f, 2.75166899e-01f, 1.40628248e-01f, -1.70987099e-01f, 2.12952256e-01f, 9.82604548e-03f,
  5.86565174e-02f, 9.91074666e-02f, 6.16387241e-02f, 2.17549711e-01f, 1.12684272e-01f, 6.54653832e-02f, 9.44616422e-02f, 9.32636261e-02f, 5.52069992e-02f, 1.41629949e-01f,
  1.74121201e-01f, 7.60224313e-02f, 1.94402322e-01f, 2.16585144e-01f, 8.00087750e-02f, 9.62965861e-02f, 1.05099306e-01f, -8.31333995e-02f, 2.69998237e-02f, -6.40260726e-02f,
  -2.18272537e-01f, -2.51785517e-02f, -2.49878932e-02f, -1.76931862e-02f, 4.50894609e-02f, -1.28772393e-01f, 2.85532087e-01f, -9.86172259e-02f, -1.29569635e-01f, -8.12096670e-02f,
  1.48641467e-01f, -3.00615638e-01f, -1.31084830e-01f, 3.93142626e-02f, 9.27906856e-02f, -1.85429975e-01f, -2.23706335e-01f, -4.44464758e-02f, 3.96663457e-01f, 2.41919100e-01f,
  2.72860736e-01f, 3.14025313e-01f, 3.46763194e-01f, 1.19909018e-01f, 1.18334189e-01f, 3.49030038e-03f, -3.86551529e-01f, -1.48492664e-01f, 1.58912137e-01f, -2.23982856e-01f,
  -1.61163792e-01f, 2.33214691e-01f, -2.29635574e-02f, 2.52456129e-01f, 2.19195291e-01f, -3.65157984e-02f, 3.76969248e-01f, 1.16209291e-01f, -3.01813364e-01f, -1.44993484e-01f,
  2.97567904e-01f, 1.10771753e-01f, 1.03508845e-01f, 1.32922605e-01f, 4.88039292e-02f, -4.25743731e-03f, 9.57974792e-02f, 6.08454496e-02f, 3.97169925e-02f, -5.60972057e-02f,
  6.11546785e-02f, 1.76189184e-01f, 9.38730687e-02f, 6.17857575e-02f, 5.10898754e-02f, 1.30881459e-01f, 1.55640123e-02f, 7.63062909e-02f, 8.13294277e-02f, -1.58115663e-02f,
  1.13207325e-01f, 7.13461116e-02f, 2.57399708e-01f, 1.78008646e-01f, 1.46743342e-01f, 1.65376924e-02f, 9.63357389e-02f, 2.46637985e-01f, 6.98430389e-02f, -5.02501950e-02f,
  1.07373729e-01f, -2.42639948e-02f, 1.16209500e-02f, -4.95735668e-02f, -6.16800487e-02f, 2.62310561e-02f, 1.32587135e-01f, 7.11352974e-02f, -4.28084284e-02f, -1.67440563e-01f,
  3.76159370e-01f, 2.67372012e-01f, 1.64457262e-01f, 8.70047696e-03f, 7.26154968e-02f, -1.51680917e-01f, -1.46232873e-01f, -1.44637063e-01f, -4.05244455e-02f, 5.48675507e-02f,
  1.66912645e-01f, -6.67487457e-02f, 6.01882907e-03f, -2.92105749e-02f, 2.47141466e-01f, 3.96643579e-01f, -6.86145872e-02f, 2.18498126e-01f, -2.96422780e-01f, 4.13643606e-02f,
  1.87136799e-01f, 4.19713080e-01f, 8.15395415e-02f, 1.77033335e-01f, -7.68474638e-02f, -2.28000045e-01f, -1.10986419e-02f, 1.48205280e-01f, 1.47595346e-01f, 1.44033849e-01f,
  5.76569475e-02f, 1.11660577e-01f, 1.32641703e-01f, 2.01688036e-01f, 1.27569392e-01f, -2.96615008e-02f, 2.21980475e-02f, 9.85943619e-03f, -7.87755176e-02f, 9.87099558e-02f,
  2.16971323e-01f, 1.32813603e-01f, 1.79548681e-01f, 1.58103853e-01f, 1.72343075e-01f, 6.72708377e-02f, -1.63910061e-01f, 8.48086104e-02f, -6.03839867e-02f, 1.67415455e-01f,
  9.09289867e-02f, -2.00187922e-01f, 4.96234596e-02f, -1.26083449e-01f, -1.98353231e-02f, 1.36035532e-01f, -1.39238149e-01f, 1.77945673e-01f, 2.89077520e-01f, 3.91865000e-02f,
  -1.26907658e-02f, -1.59533635e-01f, 8.25640038e-02f, 2.19177566e-02f, -1.24272160e-01f, -7.67852664e-02f, 1.88656911e-01f, 2.02029333e-01f, 6.35624900e-02f, -7.44603202e-02f,
  -1.39100343e-01f, 3.90779376e-01f, -3.14841233e-02f, 3.25218379e-01f, -2.36626700e-01f, 1.51041254e-01f, 3.13100010e-01f, 2.50356287e-01f, -1.71534762e-01f, -4.01753895e-02f,
  -2.09520206e-01f, 4.02864039e-01f, 1.62148491e-01f, -2.56686538e-01f, 2.89835781e-01f, 9.56319198e-02f, -2.66710013e-01f, 2.59883404e-01f, -2.43918732e-01f, 4.15673293e-02f,
  1.72686484e-02f, 9.29234549e-02f, 7.52700120e-02f, -2.34157918e-03f, 5.71430810e-02f, -2.57147872e-03f, 1.62455708e-01f, 1.51537269e-01f, 9.95574519e-02f, 1.31105080e-01f,
  1.38799667e-01f, -1.40076745e-02f, 3.03525552e-02f, 4.78991829e-02f, 6.76523000e-02f, -2.00222079e-02f, 5.66168278e-02f, -9.76103079e-03f, 1.34086058e-01f, 1.29125699e-01f,
  8.65359530e-02f, 1.34053126e-01f, 1.14563361e-01f, 1.77835777e-01f, 7.85797387e-02f, 3.78608704e-02f, 1.06816888e-01f, -5.14220074e-02f, -1.58589125e-01f, 3.84444967e-02f,
  1.09612048e-01f, 1.27238661e-01f, 8.13522935e-02f, 8.11668634e-02f, 4.52637039e-02f, -1.59590676e-01f, -9.95353088e-02f, -1.04324847e-01f, 2.55006701e-01f, -1.27596065e-01f,
  -4.24911231e-02f, 2.01044530e-01f, -1.06972486e-01f, -4.36413661e-02f, 6.17053770e-02f, 2.17224225e-01f, -1.63423702e-01f, 1.73806831e-01f, 1.63762972e-01f, 1.10858485e-01f,
  6.03352040e-02f, 2.74294853e-01f, -1.47808775e-01f, -1.47091681e-02f, -3.66683714e-02f, -5.88367693e-02f, -4.71886322e-02f, -1.41022980e-01f, 2.94596732e-01f, 7.31123984e-02f,
  -6.48955181e-02f, 2.28106633e-01f, -7.21842051e-02f, -2.10868921e-02f, 2.41039351e-01f, 1.01809211e-01f, 1.01567589e-01f, 1.40698105e-01f, 1.24809869e-01f, 1.97106987e-01f,
  1.60443485e-02f, 4.85422425e-02f, -2.42866157e-03f, 1.69490010e-01f, 6.79484531e-02f, 1.38963282e-01f, 9.16396007e-02f, 7.86469504e-02f, 1.34568810e-01f, 2.63380617e-01f,
  1.92497611e-01f, 1.84994131e-01f, 1.63809165e-01f, -1.07437991e-01f, 1.57261431e-01f, -1.02992577e-03f, 2.02033725e-02f, -1.96126968e-01f, -1.28466904e-01f, -2.89788917e-02f,
  -3.28398235e-02f, -5.47429435e-02f, 2.88688213e-01f, -1.28983349e-01f, -2.08907023e-01f, -2.54570067e-01f, -2.32659280e-02f, -1.50653999e-02f, -6.28196299e-02f, 5.93271926e-02f,
  4.08203691e-01f, 1.18029818e-01f, -1.78776950e-01f, 4.00269538e-01f, 1.03813931e-01f, 1.33118168e-01f, 1.89480394e-01f, -1.12776302e-01f, -2.21096188e-01f, -6.41800389e-02f,
  2.74546325e-01f, 7.02324286e-02f, -2.04285055e-01f, -9.02556628e-02f, -9.20272470e-02f, -2.67023474e-01f, 3.39522690e-01f, 4.05971736e-01f, 4.11798730e-02f, 1.07435375e-01f,
  1.61326304e-01f, 1.74584717e-01f, 1.29826084e-01f, 1.92162260e-01f, 2.18789876e-01f, -2.41892442e-01f, -4.62886132e-02f, 1.76739290e-01f, 8.46229419e-02f, 1.62876099e-01f,
  1.95917264e-01f, 1.40021607e-01f, 1.01359755e-01f, 1.46875605e-01f, 1.53954118e-01f, 8.37044865e-02f, -3.99031453e-02f, 6.11723699e-02f, 7.45368302e-02f, 1.48452684e-01f,
  5.96045926e-02f, 1.07648984e-01f, 8.38180557e-02f, 2.37278506e-01f, 1.90016348e-02f, 2.28954107e-01f, 1.34456173e-01f, -1.43406779e-01f, -1.84974089e-01f, -3.87447216e-02f,
  -3.09790019e-02f, -8.92522559e-02f, -1.95740163e-01f, 4.05233838e-02f, -1.41856046e-02f, -3.06510031e-02f, 5.59860393e-02f, 4.20337319e-02f, -2.20694140e-01f, -2.10383341e-01f,
  -1.63761303e-01f, 2.94105597e-02f, -1.86969325e-01f, 1.04959480e-01f, 2.03930527e-01f, 1.29146397e-01f, -1.24186382e-01f, 2.19555840e-01f, 2.10565746e-01f, -1.25750706e-01f,
  8.11159760e-02f, 1.33272991e-01f, -1.64730921e-02f, 7.76934922e-02f, 1.62316397e-01f, 1.19854249e-01f, -7.80679435e-02f, 1.23290747e-01f, -2.05575109e-01f, 3.54386643e-02f,
  3.96007389e-01f, 1.28397048e-01f, 4.47957724e-01f, 8.22589248e-02f, 1.50164649e-01f, 1.63289811e-02f, -2.71624457e-02f, -1.46457359e-01f, -6.94078803e-02f, -3.13199282e-01f,
  -2.20298722e-01f, 3.95693704e-02f, 5.14423735e-02f, 1.57323763e-01f, 1.00148499e-01f, 3.08496971e-02f, 5.38730398e-02f, 2.94600092e-02f, 1.95554480e-01f, 2.90610820e-01f,
  6.51122211e-03f, 1.61101028e-01f, 9.29747745e-02f, -5.64502962e-02f, 1.56643689e-01f, 1.81316137e-01f, 1.26765957e-02f, -1.49659038e-01f, -7.82174338e-03f, -7.41064698e-02f,
  8.26778263e-02f, 1.40193284e-01f, -2.44243555e-02f, 9.23848674e-02f, 2.84302860e-01f, 1.38011202e-01f, -1.06948912e-01f, -2.25265041e-01f, -5.60799502e-02f, -2.43549243e-01f,
  -1.71660036e-01f, -1.79200619e-01f, 1.61698803e-01f, 3.12455356e-01f, 1.71213269e-01f, -1.43523335e-01f, 1.17811136e-01f, -1.97307989e-01f, -2.15883210e-01f, -1.90901577e-01f,
  1.00806087e-01f, -2.56519318e-01f, -1.50425404e-01f, 4.66686457e-01f, 9.51578617e-02f, -4.46424603e-01f, 1.62330076e-01f, 2.25510389e-01f, -5.93093261e-02f, 1.26302510e-01f,
  1.97834074e-02f, -1.65962815e-01f, 3.11864853e-01f, 1.20004818e-01f, -4.05307822e-02f, -2.75479406e-01f, -3.49574238e-01f, -2.40050137e-01f, 5.96103147e-02f, -5.22094220e-03f,
  6.45679384e-02f, 4.84708510e-03f, -9.32130404e-03f, 3.97302628e-01f, 2.81878442e-01f, 2.65078574e-01f, 6.01818264e-02f, 3.13930325e-02f, 5.81740178e-02f, 6.64591044e-03f,
  8.07484314e-02f, 9.37397704e-02f, 9.43456963e-02f, -1.87072530e-02f, 2.23812014e-01f, 1.92159868e-03f, -7.20307278e-03f, 5.95634319e-02f, -6.16346896e-02f, 1.37098476e-01f,
  1.54628128e-01f, 2.37436518e-02f, 2.29128137e-01f, 1.00949056e-01f, 1.33955628e-01f, 1.56758845e-01f, -1.35781348e-01f, -7.10827345e-03f, -8.48107412e-02f, 4.20817100e-02f,
  2.68329084e-01f, -2.26069123e-01f, 1.96070150e-02f, 1.51598305e-01f, 1.50039271e-01f, 2.03640565e-01f, 8.85984153e-02f, 1.97370127e-01f, 2.99079895e-01f, 6.38654502e-03f,
  -9.86885559e-03f, -7.52893556e-03f, -2.57935990e-02f, -9.79516357e-02f, -1.74408536e-02f, 1.12747915e-01f, -1.10322703e-02f, -1.93151906e-02f, 4.43855785e-02f, 1.31103531e-01f,
  1.02266289e-01f, -7.06043765e-02f, -4.01834212e-02f, 4.96591702e-02f, -1.55510843e-01f, 9.81878191e-02f, 3.21116418e-01f, 1.06643282e-01f, -1.35529876e-01f, 7.70010129e-02f,
  -3.27441454e-01f, 2.78784305e-01f, 5.94042540e-02f, -1.64055496e-01f, 8.15571696e-02f, 3.35517168e-01f, -1.53945982e-01f, 1.31618574e-01f, 9.53236148e-02f, -1.36150569e-01f,
  2.03457803e-01f, 1.72786385e-01f, 1.71377420e-01f, 9.30227339e-02f, 1.68867439e-01f, 1.21853486e-01f, 8.39776173e-02f, 8.47123656e-03f, 6.36614561e-02f, 1.72809184e-01f,
  1.76364481e-01f, 1.30277216e-01f, 1.06412962e-01f, 1.31193131e-01f, 1.08706430e-02f, 2.05933005e-01f, 1.53283700e-01f, 4.46439646e-02f, 1.37771919e-01f, 1.47523388e-01f,
  5.07823490e-02f, 2.06355318e-01f, 1.64439321e-01f, -1.56611070e-01f, -9.05318409e-02f, -4.10154052e-02f, 6.28100634e-02f, 1.03320621e-01f, 1.76270097e-01f, -2.29768842e-01f,
  1.06873453e-01f, 7.43514076e-02f, -8.79214182e-02f, 6.36404902e-02f, 6.42508566e-02f, 2.15947032e-01f, -9.88713503e-02f, -1.30946741e-01f, 8.79861563e-02f, 3.17953706e-01f,
  -2.50814110e-02f, -2.00278103e-01f, 1.47580891e-03f, -2.79393941e-01f, 2.72946477e-01f, -2.75927961e-01f, -3.11849825e-02f, -1.95394531e-01f, 3.72997634e-02f, 1.94429964e-01f,
  1.52538881e-01f, -2.78531816e-02f, 3.69903594e-01f, 4.32141364e-01f, 2.25933731e-01f, -4.21603657e-02f, -2.67529756e-01f, -6.21284544e-02f, -5.04032150e-02f, 2.21058160e-01f,
  -2.40670945e-02f, -2.36399814e-01f, 1.14490204e-01f, -3.22013289e-01f, 9.78211835e-02f, 8.30816701e-02f, 1.14521615e-01f, 9.20598879e-02f, 1.30921289e-01f, 6.64528972e-03f,
  1.48773745e-01f, 8.00729021e-02f, 1.34771615e-01f, 3.94228175e-02f, 5.75551251e-03f, 4.53070216e-02f, 1.13233618e-01f, 3.43741514e-02f, 1.49960890e-01f, 1.10094284e-03f,
  1.27587959e-01f, -2.51020789e-02f, 1.30303070e-01f, -2.01947823e-01f, -2.47852597e-03f, -2.23361701e-01f, -1.48093641e-01f, 1.07012823e-01f, 9.57780704e-02f, -9.26255807e-02f,
  1.45141616e-01f, 8.81419778e-02f, -1.34778410e-01f, 1.09041505e-01f, 3.46003007e-03f, -1.26660749e-01f, 5.72665706e-02f, -8.59004632e-02f, -6.11650907e-02f, -2.32488289e-01f,
  2.18563959e-01f, 2.32362211e-01f, 1.17093593e-01f, 7.42760748e-02f, -5.39839976e-02f, 3.52855593e-01f, 6.74253516e-03f, 2.01115131e-01f, -1.79307997e-01f, 4.22499776e-01f,
  6.03284799e-02f, -2.79024150e-02f, 2.63641685e-01f, -4.95994501e-02f, -7.46946484e-02f, -1.88922942e-01f, -1.25480160e-01f, -3.05266604e-02f, -2.32964624e-02f, -5.95336109e-02f,
  3.00191790e-01f, 2.55584866e-01f, 1.62273422e-01f, 1.08623896e-02f, 2.77855575e-01f, -1.20094709e-01f, -1.43521400e-02f, 3.28206033e-01f, 6.86801076e-02f, 4.77151126e-02f,
  3.26714367e-02f, 5.74299842e-02f, 6.03018589e-02f, 5.21156192e-02f, 2.02038195e-02f, 6.15435615e-02f, 1.31509835e-02f, -1.10267401e-01f, 1.28040547e-02f, 1.16976306e-01f,
  -2.87505630e-02f, 3.33465524e-02f, -2.15474311e-02f, 9.52746198e-02f, 1.79423504e-02f, 2.36581668e-01f, 8.12253505e-02f, -5.06941974e-02f, -2.71743629e-02f, -6.01748005e-02f,
  -1.50681213e-01f, -9.65838879e-02f, -5.22249565e-02f, 3.81062850e-02f, -7.87096545e-02f, 3.67917158e-02f, 1.78589001e-01f, 4.21101451e-02f, -1.36460498e-01f, -1.03479877e-01f,
  -1.10570721e-01f, -4.29664701e-02f, -1.95098624e-01f, 1.38534352e-01f, 8.59479606e-02f, 7.07303137e-02f, -1.40441418e-01f, 5.23233004e-02f, 3.50150436e-01f, 2.59671677e-02f,
  3.03853333e-01f, 2.73375422e-01f, 3.69486064e-02f, -1.89591758e-02f, 2.74665684e-01f, -1.25369830e-02f, -2.24504173e-01f, 1.27646863e-01f, -2.28298053e-01f, 1.30904138e-01f,
  1.32526487e-01f, 1.53747842e-01f, 3.27931494e-01f, 2.94871390e-01f, 2.53662497e-01f, 2.44745746e-01f, -1.05455801e-01f, -8.81842226e-02f, -5.85645735e-02f, -1.52031586e-01f,
  1.25477642e-01f, 1.10159926e-01f, 3.19158542e-03f, 6.29004687e-02f, -1.35936560e-02f, 1.62866600e-02f, 5.34595959e-02f, 7.93300755e-03f, -3.97341959e-02f, -1.01107766e-03f,
  2.81705670e-02f, -3.59748751e-02f, 7.97904283e-02f, 6.30702078e-02f, -2.29258705e-02f, -2.01709196e-02f, -6.40858412e-02f, 5.27277812e-02f, -6.30035251e-02f, 1.42298220e-02f,
  3.25574912e-02f, 6.85220361e-02f, 1.88898861e-01f, 5.78135811e-02f, -5.93471304e-02f, -1.42112240e-01f, -1.59184933e-01f, 1.69035837e-01f, 9.70549881e-02f, -7.14047477e-02f,
  1.12605847e-01f, -2.28702784e-01f, -1.10188305e-01f, -5.84673248e-02f, -1.74315974e-01f, -4.82925400e-02f, -9.43796486e-02f, 1.81416869e-01f, 3.37742306e-02f, 4.72311750e-02f,
  4.11966490e-03f, -7.44293677e-03f, 2.26923734e-01f, 1.89318299e-01f, 1.55706182e-01f, -1.58577098e-03f, 4.44638804e-02f, -1.08449683e-01f, 1.21641412e-01f, -3.10430788e-02f,
  -1.57822534e-01f, 2.83200502e-01f, -1.47697330e-01f, 1.44482091e-01f, 6.92578107e-02f, 3.09724122e-01f, 4.05328423e-01f, 1.32855952e-01f, 1.96498558e-02f, 1.72429934e-01f,
  8.49946365e-02f, 2.50350889e-02f, -3.35862488e-02f, -1.72752753e-01f, 3.74031365e-02f, 3.17784660e-02f, 1.55924857e-01f, 1.02638170e-01f, 9.03571919e-02f, -1.20574217e-02f,
  2.32456803e-01f, 5.27094379e-02f, 1.76268548e-01f, 9.47633460e-02f, 8.51341262e-02f, 2.17147872e-01f, 1.56220526e-01f, 1.19753860e-01f, 9.71773192e-02f, 2.27829561e-01f,
  -3.61734554e-02f, 1.00316517e-01f, 1.99430376e-01f, 9.75235105e-02f, 9.88003612e-02f, 1.60222441e-01f, -9.02184248e-02f, 6.52883947e-03f, 1.89680338e-01f, -6.44612908e-02f,
  1.39193505e-01f, -1.70224234e-01f, -4.57933359e-02f, 2.83120334e-01f, -5.43418713e-03f, 6.70746043e-02f, 2.41132453e-01f, 1.32476315e-01f, 6.98554516e-02f, 1.80994704e-01f,
  3.20456102e-02f, 1.18201502e-01f, -1.10932916e-01f, -9.31304470e-02f, 2.13008761e-01f, 2.52771735e-01f, -3.85186821e-01f, -1.56732291e-01f, -1.34616524e-01f, 6.62431270e-02f,
  3.16179723e-01f, -2.20839843e-01f, -4.00353596e-02f, -5.41318953e-02f, 1.86944410e-01f, 1.92411810e-01f, 1.26949310e-01f, 1.55308366e-01f, 2.38664240e-01f, 9.61750820e-02f,
  4.64391671e-02f, -1.90762550e-01f, -8.91076475e-02f, -5.73326461e-02f, -1.00991957e-01f, 2.75747448e-01f, 1.36740670e-01f, -9.73053575e-02f, 1.91983819e-01f, -1.46616355e-01f,
  -7.82833714e-03f, 1.24774501e-01f, 1.12584844e-01f, 7.01011717e-02f, 5.84459268e-02f, 4.23233174e-02f, 1.25310868e-01f, 4.90536802e-02f, 5.96404262e-02f, 2.09366292e-01f,
  2.43679792e-01f, 3.17130014e-02f, 5.26037253e-02f, 1.04073629e-01f, 4.80631702e-02f, 1.69464111e-01f, 2.19167452e-02f, -7.43740723e-02f, 1.39802188e-01f, 4.03761640e-02f,
  3.12619925e-01f, 1.45978943e-01f, 3.06136131e-01f, 8.46666619e-02f, -1.53267860e-01f, 1.35949761e-01f, 1.76209763e-01f, -1.47369400e-01f, -1.86926555e-02f, -1.59107879e-01f,
  -1.30416796e-01f, -1.12834990e-01f, 2.34921146e-02f, 1.51921004e-01f, 5.65219223e-02f, -9.93272737e-02f, 2.01419383e-01f, -3.61072011e-02f, 4.40083370e-02f, 1.68489262e-01f,
  -2.25513950e-01f, 3.45153719e-01f, -2.16092259e-01f, -1.34193555e-01f, -5.79406023e-02f, 1.25430614e-01f, -1.25675321e-01f, 2.72148132e-01f, -1.03239484e-01f, 1.45495296e-01f,
  -3.10378731e-03f, 1.23149738e-01f, 9.02852342e-02f, 3.02331060e-01f, 4.09599431e-02f, -2.07365572e-01f, -4.32595760e-02f, -1.81396410e-03f, 4.70582426e-01f, 3.86808127e-01f,
  5.50403967e-02f, 1.29836813e-01f, -1.41665518e-01f, 3.62876654e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  7.16074929e-02f, 1.21723808e-01f, 1.30611449e-01f, 1.23730898e-01f, 4.58854176e-02f, 1.83251023e-01f, 8.45858902e-02f, 1.12588882e-01f, 5.56104034e-02f, 8.75849798e-02f,
  1.18501052e-01f, 1.41207561e-01f, 9.62280408e-02f, 7.15531260e-02f, 1.68928146e-01f, 1.00877754e-01f, 1.93933025e-01f, 1.69974327e-01f, 1.33733794e-01f, 1.57218710e-01f,
  1.64565951e-01f, 8.27839896e-02f, 6.17586188e-02f, 7.64157251e-02f, 7.60744065e-02f, 1.02750599e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.31450945e-01f, 2.07914580e-02f, 1.26744345e-01f, 1.73739880e-01f, -1.02966130e-02f, -4.21834886e-02f, -2.57265478e-01f, 6.07998967e-02f, -4.18681242e-02f, -2.66203173e-02f,
  2.09378581e-02f, -1.75302163e-01f, -1.21773861e-01f, 1.12245902e-02f, -1.79957360e-01f, 1.02352947e-01f, -2.22562015e-01f, 4.07519117e-02f, 1.24879435e-01f, 2.94579584e-02f,
  -2.38868475e-01f, -2.23161533e-01f, 2.00449437e-01f, 3.80453080e-01f, 2.98153341e-01f, 4.44849208e-02f, -7.90942311e-02f, -3.09243232e-01f, -2.65332490e-01f, -2.23623678e-01f,
  -2.43283257e-01f, 1.80758342e-01f, 7.06449375e-02f, -2.75338024e-01f, -6.75157458e-02f, 1.41105473e-01f, 1.52605847e-01f, 1.25745922e-01f, -2.60024130e-01f, 3.08287479e-02f,
  3.18010360e-01f, -2.48300627e-01f, -2.19242871e-01f, 4.68002707e-01f, 4.17751163e-01f, 3.40629339e-01f, 1.86478138e-01f, 3.42722356e-01f, -5.45926280e-02f, -5.50864875e-01f,
  -5.32529116e-01f, 7.09742121e-03f, -3.91938001e-01f, 1.40981987e-01f, -6.00838661e-01f, -3.60003769e-01f, -8.57458338e-02f, -1.95452943e-01f, -4.08938557e-01f, 2.84505218e-01f,
  -5.71754873e-01f, -2.73156732e-01f, -7.62169808e-02f, -3.41579437e-01f, -1.25157803e-01f, -1.27383266e-02f, -5.66828698e-02f, 1.11016773e-01f, 5.52145652e-02f, 9.65118036e-02f,
  4.94163558e-02f, -3.00435007e-01f, 2.03209877e-01f, -3.08825653e-02f, 1.99493900e-01f, 1.81099072e-01f, 2.85546146e-02f, 5.39972484e-02f, 1.68194905e-01f, -1.23736031e-01f,
  -1.28814608e-01f, -4.95440215e-02f, -9.19718817e-02f, 1.42966852e-01f, 3.25277597e-01f, 6.09223843e-02f, -5.06377399e-01f, -4.03789252e-01f, 3.35630804e-01f, 2.59564549e-01f,
  -1.05835676e-01f, 3.63983452e-01f, -3.73683751e-01f, -1.90882280e-01f, 1.80316761e-01f, 3.82507831e-01f, -2.88191438e-01f, -4.00148556e-02f, -2.55296286e-02f, 1.42905012e-01f,
  -1.66559830e-01f, -2.46257484e-01f, -4.43922877e-01f, 1.06120490e-01f, -5.79705060e-01f, -3.62486154e-01f, 4.49365154e-02f, 3.48857105e-01f, -5.69700122e-01f, 4.48133886e-01f,
  -2.29691759e-01f, 1.82104245e-01f, -9.21136141e-02f, 1.38060063e-01f, -2.92691797e-01f, 1.79422677e-01f, -7.77580440e-02f, 2.57841587e-01f, -5.48983693e-01f, -4.48608965e-01f,
  3.73677611e-01f, 1.97450459e-01f, 1.22329406e-01f, -2.72787243e-01f, -2.33935654e-01f, -1.89847752e-01f, 3.00821900e-01f, -1.18389338e-01f, -1.52009800e-01f, -2.55737659e-02f,
  7.34719038e-02f, 4.99209436e-03f, -8.40589181e-02f, -1.53263986e-01f, -1.98585287e-01f, -1.32301338e-02f, -2.67967135e-01f, 1.48128252e-02f, -1.18222125e-01f, -2.22539194e-02f,
  -2.07724035e-01f, 9.19636488e-02f, 9.65490341e-02f, -9.08041671e-02f, 1.46508381e-01f, -2.08875865e-01f, -1.77808970e-01f, -1.75647408e-01f, 1.40672356e-01f, -6.35216609e-02f,
  -3.43173414e-01f, 2.57725298e-01f, -2.28166699e-01f, -2.26524562e-01f, 4.84759584e-02f, 5.88768125e-02f, 1.62483677e-01f, 1.90163761e-01f, 1.68546051e-01f, -2.37169087e-01f,
  2.63799667e-01f, 1.88502386e-01f, -1.56474859e-01f, 2.26319775e-01f, 9.38095227e-02f, -8.39791298e-02f, -2.77093977e-01f, -1.22464247e-01f, -2.86187172e-01f, 4.93825048e-01f,
  -3.30561519e-01f, -6.28401816e-01f, -7.88139775e-02f, -2.14599133e-01f, -1.66513473e-01f, 2.69313693e-01f, -2.67571181e-01f, 3.41085345e-01f, -2.49369085e-01f, 1.40107706e-01f,
  3.78370076e-01f, 2.48272032e-01f, -3.80221099e-01f, -3.86245131e-01f, 2.19938472e-01f, 2.69785136e-01f, -3.58319551e-01f, -4.28296149e-01f, -3.05163473e-01f, -2.64617652e-01f,
  -1.18963815e-01f, 2.34554008e-01f, 8.05304870e-02f, -1.60674050e-01f, -7.22381985e-03f, -1.84573606e-01f, -4.41222871e-03f, 1.23682112e-01f, -2.70693719e-01f, -1.74385116e-01f,
  1.62405998e-01f, 2.06016049e-01f, 9.18604285e-02f, -2.51015455e-01f, -1.61702290e-01f, -3.78928989e-01f, 3.23784202e-02f, -7.82721713e-02f, -1.94702178e-01f, -9.90279838e-02f,
  -9.39330086e-02f, 1.44107163e-01f, 3.65583926e-01f, 3.79388988e-01f, 1.95477158e-01f, 1.84680462e-01f, 3.13418865e-01f, 1.48270294e-01f, 1.65087730e-01f, -2.72307783e-01f,
  -2.11806297e-01f, 2.41617814e-01f, -1.42819583e-01f, 2.98545718e-01f, 1.48677096e-01f, -9.52175036e-02f, 3.47617805e-01f, -3.54712680e-02f, 2.67764717e-01f, 1.96929693e-01f,
  1.98272273e-01f, -2.66984493e-01f, -3.03629749e-02f, -4.23798442e-01f, 4.55629438e-01f, 4.70956862e-01f, 1.43641040e-01f, -5.92534602e-01f, -7.86248669e-02f, -1.63843617e-01f,
  2.51849979e-01f, -3.76153827e-01f, 3.47618729e-01f, -3.32549810e-01f, -5.92662275e-01f, -2.95449942e-01f, -1.17632285e-01f, 1.30816221e-01f, -5.56532860e-01f, 4.14888300e-02f,
  -2.48294771e-01f, -7.73492977e-02f, 3.08358699e-01f, -9.21334401e-02f, 2.92041432e-02f, -1.10066064e-01f, 2.19406798e-01f, 1.94703251e-01f, 1.72196522e-01f, -1.10451579e-01f,
  1.67059526e-01f, 1.29837252e-03f, 1.74996063e-01f, 3.19693476e-01f, 7.07451627e-02f, 5.04802540e-02f, -1.82404425e-02f, 2.29645893e-02f, -2.53282748e-02f, 8.21286291e-02f,
  2.34741747e-01f, 1.60212994e-01f, 4.21389461e-01f, 2.06577033e-01f, 1.79248393e-01f, 1.17027260e-01f, 3.87045220e-02f, 2.80907273e-01f, -9.78889093e-02f, -1.50870651e-01f,
  -2.43014842e-01f, 1.73834741e-01f, 2.10825831e-01f, -1.67002529e-02f, 1.76201880e-01f, -2.89573520e-01f, -2.47865573e-01f, -4.79835510e-01f, -2.37259820e-01f, -1.19424760e-01f,
  3.22134763e-01f, -1.60713166e-01f, -7.71937296e-02f, 1.01510644e-01f, -3.08448017e-01f, -2.82208890e-01f, 2.69843549e-01f, -1.41035780e-01f, -4.83261168e-01f, 2.20763475e-01f,
  2.67413735e-01f, 2.11649850e-01f, 2.71737903e-01f, -4.26441312e-01f, 2.27652892e-01f, -2.81645596e-01f, 1.11033872e-01f, -5.22872031e-01f, 4.25430298e-01f, -1.81610227e-01f,
  7.18623325e-02f, 2.00108722e-01f, -2.80914336e-01f, 3.08284938e-01f, -4.08764660e-01f, 2.14326456e-01f, 1.02590151e-01f, -2.44291067e-01f, -2.55737066e-01f, -6.70234919e-01f,
  -1.32865518e-01f, 5.68247661e-02f, -2.37505615e-01f, -2.09694415e-01f, -2.59714313e-02f, 2.30777502e-01f, 7.74178281e-02f, -5.42247817e-02f, 3.36192697e-02f, 3.12761702e-02f,
  4.15681116e-02f, 1.68225050e-01f, -2.52303630e-02f, -3.86883020e-02f, 5.62784448e-02f, -2.91781835e-02f, 3.76242518e-01f, 3.89398113e-02f, -2.71892548e-02f, -4.40820724e-01f,
  -2.65521318e-01f, 9.54519492e-03f, 3.01279753e-01f, -3.62246633e-01f, -2.35524833e-01f, 3.14300299e-01f, -3.39388967e-01f, -2.78350264e-01f, -2.12190464e-01f, 2.93151289e-01f,
  5.38031310e-02f, 3.09810519e-01f, -2.96166748e-01f, 1.71812579e-01f, -1.99735329e-01f, 2.09485218e-01f, 3.07192206e-01f, -2.54835397e-01f, -6.01148792e-02f, 2.82005370e-01f,
  1.76126435e-01f, -1.88467845e-01f, -1.25368446e-01f, -5.55563807e-01f, -1.76827058e-01f, 2.10419312e-01f, 8.67400914e-02f, 8.51590261e-02f, 4.23363030e-01f, -2.15564534e-01f,
  -7.47720599e-01f, 1.49472550e-01f, -5.67176759e-01f, -2.68877655e-01f, 3.60041887e-01f, 3.10626060e-01f, -3.68737429e-01f, -1.65242016e-01f, 2.13758871e-01f, 9.97892860e-03f,
  -1.71051681e-01f, -2.71691561e-01f, 3.18111271e-01f, 4.27768715e-02f, 2.41317302e-01f, -1.90996248e-02f, -1.86703905e-01f, 1.60076559e-01f, -3.60378325e-02f, -2.03648686e-01f,
  -6.57712072e-02f, -7.47131258e-02f, -2.31506526e-01f, -5.97065613e-02f, 3.17062624e-02f, -4.58755195e-02f, 1.05059236e-01f, 1.50325462e-01f, 1.31329507e-01f, 7.27018788e-02f,
  1.52063429e-01f, 1.41775951e-01f, -8.84508342e-02f, 1.57227844e-01f, 3.19652140e-01f, -1.28875365e-02f, 1.24346927e-01f, -3.43828976e-01f, -2.16987468e-02f, -4.30340588e-01f,
  -1.68162733e-01f, 2.06739485e-01f, 3.59802768e-02f, 5.15136309e-02f, 3.33068550e-01f, -1.87806591e-01f, 3.47189128e-01f, 3.17216456e-01f, 4.26576853e-01f, -2.16660738e-01f,
  -2.15998560e-01f, -2.06001416e-01f, -3.44527900e-01f, 1.59533113e-01f, -5.83872259e-01f, -4.32868451e-01f, 1.80258288e-03f, -2.22955838e-01f, -2.93053389e-01f, -4.80606854e-01f,
  2.81075180e-01f, -4.64101195e-01f, -9.79716629e-02f, 1.98138177e-01f, 1.71617076e-01f, 4.01217133e-01f, -9.00691375e-02f, 2.83043422e-02f, 2.20680758e-01f, -1.76816612e-01f,
  -4.71754193e-01f, 2.97583133e-01f, 3.23192447e-01f, -7.66149685e-02f, -1.46632403e-01f, 1.39392242e-01f, 3.79505754e-02f, 3.54204267e-01f, 5.02573885e-02f, -1.74177274e-01f,
  -9.61466953e-02f, 9.50864237e-03f, -6.10235892e-02f, -1.10022567e-01f, 1.08063109e-01f, 1.14329435e-01f, -1.87266409e-01f, -1.77829355e-01f, 3.72716896e-02f, -2.71329228e-02f,
  -2.25311574e-02f, -1.36917094e-02f, -6.44104332e-02f, 7.00307861e-02f, -3.14744413e-02f, 6.51104003e-02f, 1.30838845e-02f, 1.92686081e-01f, -2.30300933e-01f, 2.61354268e-01f,
  5.45311049e-02f, -2.29906142e-01f, 2.28483200e-01f, -2.34662265e-01f, -1.66268095e-01f, -1.64390951e-01f, -2.75313765e-01f, 1.93402588e-01f, -6.85536116e-02f, -7.58522302e-02f,
  -1.13869034e-01f, -5.87749444e-02f, 2.84440387e-02f, 4.07072604e-02f, -1.56514794e-01f, 6.41701892e-02f, 1.36440501e-01f, -2.46985272e-01f, 2.51349956e-01f, 3.42536002e-01f,
  3.97068202e-01f, -3.26701581e-01f, 2.34716117e-01f, -9.83672738e-02f, -2.78410465e-01f, 2.40600422e-01f, -3.21119070e-01f, -1.26515061e-01f, 3.64092961e-02f, -2.18081549e-01f,
  -3.55907798e-01f, -2.57329464e-01f, 2.43078589e-01f, -2.70331383e-01f, 2.41797164e-01f, -3.62700880e-01f, -2.99531817e-01f, 2.81139880e-01f, 1.69284046e-01f, 2.30511978e-01f,
  -2.98296928e-01f, -6.55967966e-02f, 8.46078470e-02f, -7.63820410e-02f, 1.32328823e-01f, -1.04983836e-01f, -8.16817209e-02f, -4.92996797e-02f, 4.08973843e-02f, 1.69563800e-01f,
  1.24612115e-01f, 1.38307497e-01f, -3.46096046e-02f, -1.17767133e-01f, 2.03751139e-02f, -1.84536353e-01f, -5.01699261e-02f, -2.37172008e-01f, 1.44911066e-01f, -1.05423443e-01f,
  -1.92936420e-01f, -4.89790291e-02f, 1.46084860e-01f, -5.59837706e-02f, 2.77413577e-01f, 2.10005462e-01f, 2.61048645e-01f, -2.23049790e-01f, -2.92695481e-02f, -1.29798427e-01f,
  5.62266372e-02f, 1.97306812e-01f, 1.28959537e-01f, -1.99856475e-01f, -1.34581640e-01f, 2.14918882e-01f, -3.18886414e-02f, 1.75691307e-01f, -2.01620102e-01f, -7.43151531e-02f,
  -2.41545849e-02f, -2.48162881e-01f, -2.86684960e-01f, 3.40007842e-01f, 3.42024356e-01f, 1.25625297e-01f, -2.89489806e-01f, -3.52967530e-01f, -2.00243831e-01f, 1.43932253e-01f,
  -1.89688161e-01f, 2.93083787e-01f, -3.59097034e-01f, -3.15467298e-01f, -1.61148041e-01f, 4.38205749e-02f, -2.30560064e-01f, 3.62311214e-01f, -4.56432819e-01f, -2.96126455e-01f,
  3.25076044e-01f, -2.44627640e-01f, 1.78412959e-01f, 3.70328665e-01f, 1.88139200e-01f, 9.95830223e-02f, 1.04620315e-01f, 3.17182951e-02f, -8.17334652e-02f, -3.66628319e-02f,
  -1.77577466e-01f, -2.44370922e-01f, -1.58664450e-01f, -4.75902371e-02f, 1.58900484e-01f, -5.65647930e-02f, 1.34218633e-01f, 6.50433227e-02f, 7.57780224e-02f, -6.24091877e-03f,
  -2.29158759e-01f, 1.46531099e-02f, -2.31647104e-01f, -3.42767909e-02f, 6.42089024e-02f, -2.17830271e-01f, -4.57955092e-01f, -3.18444550e-01f, 1.42131701e-01f, 3.39536846e-01f,
  -8.96251798e-02f, -2.56225199e-01f, -2.50946760e-01f, 2.09833279e-01f, 9.00786892e-02f, -9.11677554e-02f, -3.81807029e-01f, -1.74406290e-01f, 2.95597970e-01f, -3.91340286e-01f,
  -9.16976109e-02f, -2.23104313e-01f, -2.85636187e-01f, 3.25918287e-01f, 2.17157811e-01f, 1.01291120e-01f, 2.70921707e-01f, -9.35780182e-02f, -3.62836719e-01f, -4.10163581e-01f,
  -3.88188869e-01f, 1.55767024e-01f, 3.24164331e-02f, -4.14600104e-01f, -6.00211143e-01f, -1.03988938e-01f, 2.05872744e-01f, -2.27132842e-01f, 1.88283890e-01f, 2.38355011e-01f,
  5.56752943e-02f, 1.22433759e-01f, 4.59621340e-01f, -2.30136290e-01f, -4.43064362e-01f, 2.22776890e-01f, -2.15126097e-01f, -1.36294901e-01f, -4.85861957e-01f, 3.37153822e-01f,
  9.13592279e-02f, 5.81068695e-02f, 7.13656191e-03f, 1.49977237e-01f, 1.36882830e-02f, 9.52764004e-02f, -1.96573678e-02f, 9.50684864e-03f, -1.65666014e-01f, -1.55980095e-01f,
  -1.88014984e-01f, 8.81091729e-02f, 8.75020549e-02f, 1.16608679e-01f, -1.06621914e-01f, 1.12571314e-01f, -5.35224527e-02f, 8.63970891e-02f, 4.98310924e-02f, -1.77189320e-01f,
  -1.94056183e-01f, -3.06624472e-01f, -2.35687017e-01f, 1.70003191e-01f, -2.43490845e-01f, 1.97762191e-01f, 3.13452452e-01f, 2.91093379e-01f, 2.48274982e-01f, -2.72411138e-01f,
  -2.97778636e-01f, 8.47020745e-02f, -1.16807081e-01f, -2.79399961e-01f, -2.88596362e-01f, -1.56574920e-01f, -2.51020759e-01f, 2.79506832e-01f, 3.43410552e-01f, -1.59472331e-01f,
  -3.72087896e-01f, -2.68201381e-01f, 2.13978425e-01f, -1.07768685e-01f, 2.15898246e-01f, -3.43581498e-01f, -3.12155575e-01f, 2.15728790e-01f, -2.33137131e-01f, 1.69067785e-01f,
  2.55321324e-01f, -2.84481794e-01f, -1.33437365e-01f, -1.30054623e-01f, -1.00046724e-01f, -2.55365789e-01f, 4.32005435e-01f, 2.73560792e-01f, 4.08118367e-01f, -3.64253759e-01f,
  -2.70751595e-01f, -3.04533541e-01f, 3.34010363e-01f, -3.46986085e-01f, 5.60121238e-02f, -2.19789762e-02f, 1.50551572e-02f, 7.68908253e-03f, -9.00930911e-02f, -1.34249218e-02f,
  2.43380181e-02f, -1.08514674e-01f, 1.75272450e-01f, 8.27993974e-02f, 1.04751937e-01f, -3.55620235e-02f, 7.01306760e-02f, 7.40004629e-02f, -8.48472342e-02f, -5.53648956e-02f,
  -3.43815267e-01f, -6.65844828e-02f, 1.55109838e-01f, 2.70439267e-01f, -5.78316562e-02f, -1.81358695e-01f, -1.56663973e-02f, 3.00594598e-01f, -7.54778832e-02f, 1.69244334e-01f,
  3.99361789e-01f, 8.52678791e-02f, 2.13001698e-01f, 6.50559068e-02f, 3.21587622e-01f, 9.36543867e-02f, -1.22709274e-01f, 2.96261400e-01f, -1.59358039e-01f, -1.25608876e-01f,
  3.00698549e-01f, 2.08627641e-01f, 1.63776681e-01f, -1.77874304e-02f, 2.42500037e-01f, 1.88218027e-01f, -4.03539151e-01f, -3.81398678e-01f, -1.05415694e-02f, -4.86309439e-01f,
  -1.13909401e-01f, -1.14417356e-02f, 2.78536260e-01f, -2.92034149e-01f, 1.94116801e-01f, 3.05246025e-01f, -1.96158856e-01f, -3.50277364e-01f, 3.01002681e-01f, 2.70106554e-01f,
  -1.13392726e-01f, -2.66316384e-01f, 2.49529958e-01f, -5.27921617e-01f, 3.52669716e-01f, 3.41180891e-01f, -5.14152706e-01f, -3.11665237e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.90888821e-02f, 5.46062477e-02f, -4.95866947e-02f, -6.44786730e-02f, 5.40260188e-02f, 5.73550574e-02f, 3.16529628e-03f, -5.23211882e-02f, 2.96981186e-02f, 5.46823069e-02f,
  7.97035396e-02f, 3.52405012e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    