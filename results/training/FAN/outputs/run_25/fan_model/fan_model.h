/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.64598405e-01f, 2.66187966e-01f, 2.29359865e-01f, 3.81086946e-01f, -1.48410335e-01f, 7.79855922e-02f, 3.73338163e-01f, 5.24911657e-02f, -2.38933899e-02f, 1.78714439e-01f,
  6.31732419e-02f, -1.22439452e-01f, 1.63547650e-01f, 2.97567338e-01f, 6.58446252e-02f, 3.28050070e-02f, 2.72477955e-01f, 1.67128704e-02f, -1.61082387e-01f, 2.21083641e-01f,
  -1.06223933e-01f, 2.80419767e-01f, 2.24042624e-01f, 1.33040864e-02f, 1.11313142e-01f, -1.82007417e-01f, 8.96097422e-02f, 6.62400154e-03f, 2.32271329e-02f, -6.78058043e-02f,
  -7.98248276e-02f, 8.16232860e-02f, 8.55135918e-02f, 2.77740862e-02f, 4.12993804e-02f, 2.93400814e-03f, -5.42159267e-02f, -2.31959242e-02f, 7.32324123e-02f, 1.26682296e-02f,
  1.63475797e-02f, -6.12040870e-02f, -8.31520632e-02f, -1.19613931e-02f, -1.12252003e-02f, 5.90557456e-02f, 2.88985502e-02f, -2.54360568e-02f, -5.56000248e-02f, -4.84775715e-02f,
  1.42315969e-01f, 4.95593883e-02f, 1.83997139e-01f, 9.64095537e-03f, -1.57196783e-02f, 6.74957484e-02f, -5.88254072e-02f, -1.48172351e-02f, 6.16822690e-02f, -2.98930611e-02f,
  -5.28806038e-02f, -5.72564127e-03f, 1.26554891e-01f, -8.90636817e-03f, 5.00203520e-02f, -2.84985937e-02f, 1.00216985e-01f, -6.30178526e-02f, -6.54264316e-02f, -2.82585640e-02f,
  5.73242549e-03f, -3.76557596e-02f, -5.07643595e-02f, -1.27257162e-03f, -2.62112655e-02f, -2.23868024e-02f, -5.43472683e-03f, -1.10372044e-01f, -1.05763907e-02f, -6.65640533e-02f,
  2.41904929e-02f, 3.90691422e-02f, 4.56023356e-03f, 5.68475164e-02f, 7.14843646e-02f, 8.39279890e-02f, -7.42490143e-02f, -3.80925536e-02f, 2.75543816e-02f, 4.15749960e-02f,
  1.29268140e-01f, 2.00183019e-01f, 8.35751556e-03f, -1.25747353e-01f, 2.89653856e-02f, -2.90835071e-02f, -4.34328150e-03f, -1.71882957e-01f, -3.85227278e-02f, -9.17203203e-02f,
  6.15920722e-02f, 4.10272516e-02f, 1.57553293e-02f, -1.36325154e-02f, 4.22222726e-02f, -2.41920445e-02f, -3.70859962e-05f, 1.32920016e-02f, 9.87913460e-02f, -6.84744492e-02f,
  6.65336996e-02f, -2.17857864e-02f, -2.15469413e-02f, -7.59756938e-02f, -8.81987438e-03f, -4.08643931e-02f, 3.44222412e-02f, 1.28267169e-01f, 3.02126538e-02f, 1.00674912e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.58602464e-01f, 3.96489114e-01f, 1.84050232e-01f, -4.18235034e-01f, -5.62753119e-02f, -3.69555116e-01f, -4.15726215e-01f, 1.35548815e-01f, 3.78041565e-02f, 2.29432866e-01f,
  -2.66034037e-01f, 2.94358671e-01f, -7.73265809e-02f, -3.00520331e-01f, -8.06012690e-01f, -3.88261348e-01f, -5.28248012e-01f, -1.32811755e-01f, 6.06879080e-03f, -1.07558310e-01f,
  -1.92711458e-01f, -4.36515003e-01f, -2.75584370e-01f, 1.95372671e-01f, 1.67906985e-01f, 3.47181678e-01f, -2.56055295e-01f, 1.00602798e-01f, 6.28120229e-02f, -1.17805153e-01f,
  -1.31798521e-01f, 1.59943238e-01f, 1.75988287e-01f, 3.25777791e-02f, -1.91072091e-01f, 7.29872137e-02f, 3.47880870e-02f, 6.30273372e-02f, -1.07209846e-01f, 4.04016525e-02f,
  1.15124658e-01f, 3.29454206e-02f, -3.73391248e-02f, 1.97039470e-02f, 8.35030675e-02f, 5.25855348e-02f, 2.39086598e-01f, 1.20644808e-01f, 2.34641075e-01f, 1.46706790e-01f,
  2.99365949e-02f, 1.63501024e-01f, -6.41476586e-02f, 3.59207876e-02f, -9.02651176e-02f, 8.83334428e-02f, -1.24509558e-01f, 1.51004285e-01f, 5.07755876e-02f, 1.04819899e-02f,
  1.28848076e-01f, 1.42507942e-03f, 6.15251549e-02f, 1.22552067e-01f, -4.87968288e-02f, 2.98568849e-02f, -1.77805454e-01f, -1.01368055e-01f, -5.57650551e-02f, -4.86881472e-02f,
  -8.55609849e-02f, 1.09522305e-01f, 7.89088011e-02f, -6.32571951e-02f, -1.31545857e-01f, -4.78109792e-02f, -6.20127246e-02f, -4.94994223e-02f, -6.35839328e-02f, -1.00371197e-01f,
  -5.38235269e-02f, -1.06148809e-01f, -2.51641329e-02f, -3.17390519e-03f, 5.87246865e-02f, 2.32961103e-02f, 1.01998746e-01f, 2.47233331e-01f, -1.01439759e-01f, -1.07854567e-01f,
  -1.99298918e-01f, 2.13923194e-02f, -5.40090092e-02f, 1.00939564e-01f, 6.90141767e-02f, -2.85780579e-02f, -1.55835673e-01f, 2.00594123e-03f, -1.06853127e-01f, -1.68079548e-02f,
  4.98163365e-02f, -5.19675575e-02f, -1.02239951e-01f, 4.45637777e-02f, -3.97154093e-02f, -8.71148705e-02f, -6.21375330e-02f, 7.91855901e-02f, -5.67450095e-03f, 1.47535279e-03f,
  1.40951440e-01f, 2.70832852e-02f, 5.64973578e-02f, -8.43316913e-02f, 3.03777754e-02f, -4.52321470e-02f, -9.96642038e-02f, -4.92342701e-03f, -5.71857281e-02f, 1.16641866e-03f,
  6.85869992e-01f, 4.47468646e-02f, 3.76579583e-01f, 8.73632789e-01f, 1.63993418e-01f, -5.73184729e-01f, 1.12726226e-01f, 6.42004311e-02f, 5.22243083e-01f, -3.76311362e-01f,
  4.62241806e-02f, 3.27873051e-01f, -2.08080366e-01f, 3.37258428e-01f, 7.18189478e-02f, -3.61302316e-01f, 2.18058452e-01f, 7.00639933e-03f, 2.73683906e-01f, 1.80151522e-01f,
  3.21330130e-01f, -3.48897427e-02f, 3.88366848e-01f, -2.34708682e-01f, 3.91137451e-01f, 3.04573894e-01f, -5.23276068e-02f, -6.09800704e-02f, 4.39375974e-02f, -5.36169596e-02f,
  -1.20161287e-02f, 2.28291228e-01f, 1.33440435e-01f, -1.23750620e-01f, 6.91126660e-02f, -5.98348528e-02f, -3.97598259e-02f, -9.04703513e-02f, 1.40525907e-01f, -1.64597109e-01f,
  -6.81492016e-02f, 4.16570865e-02f, 7.54675418e-02f, -6.87936172e-02f, 8.85089189e-02f, 1.31390601e-01f, 2.12320194e-01f, 6.23240359e-02f, -2.15211511e-02f, 1.77728236e-01f,
  1.72942251e-01f, 8.81750211e-02f, 9.50246751e-02f, -1.34137273e-01f, 2.19955951e-01f, 3.89560908e-02f, -1.05835490e-01f, 4.25125435e-02f, -3.75972129e-03f, 7.40500093e-02f,
  -8.64190012e-02f, 2.29267273e-02f, -4.06665914e-02f, 1.06647443e-02f, -1.70901883e-02f, 1.02588214e-01f, -7.04338476e-02f, -5.35372794e-02f, 4.99952212e-02f, -6.09576739e-02f,
  -3.96593660e-02f, 6.22074828e-02f, 1.08193709e-02f, 6.90509193e-03f, -5.74104451e-02f, 5.87951355e-02f, 5.59997745e-02f, -5.31910360e-02f, 6.62399968e-03f, 3.15498970e-02f,
  4.18186039e-02f, 2.20311750e-02f, 2.11510248e-02f, -1.43025154e-02f, -1.57003954e-01f, 3.43383849e-02f, 1.61291473e-02f, -5.13516702e-02f, 9.20805186e-02f, -7.71069005e-02f,
  -3.46352547e-01f, -2.37763003e-01f, 2.19685603e-02f, -1.05021589e-01f, -1.38022631e-01f, -7.17389062e-02f, 1.17641851e-01f, 6.08204789e-02f, 2.60762107e-02f, -3.27855833e-02f,
  2.59647076e-03f, -3.37746032e-02f, -7.48274103e-02f, -1.15666084e-01f, -1.10082135e-01f, 2.68890094e-02f, 1.21226251e-01f, -1.51457772e-01f, -1.09074870e-02f, -4.60479558e-02f,
  4.00585646e-04f, -9.50908586e-02f, -1.34038672e-01f, 1.23605311e-01f, -8.28049928e-02f, -8.27911496e-02f, 4.15403582e-02f, -1.00454399e-02f, -8.57914388e-02f, 2.15074271e-02f,
  2.49213412e-01f, 3.16534890e-03f, 2.02022970e-01f, 2.73019284e-01f, 7.52671123e-01f, 7.01126695e-01f, 4.24807519e-01f, 5.62222540e-01f, 8.39255452e-01f, -1.39599741e-01f,
  -6.18369021e-02f, -8.17765445e-02f, -3.24588060e-01f, 7.19418302e-02f, 1.28916040e-01f, -1.81548372e-01f, 2.95933247e-01f, -1.19743571e-02f, 2.53730208e-01f, 5.71317151e-02f,
  1.22914396e-01f, 1.23947375e-01f, -3.63102704e-01f, -5.13234995e-02f, -8.21535587e-02f, -2.83242483e-02f, -4.86557305e-01f, -4.23839763e-02f, -2.29061693e-01f, 1.34877875e-01f,
  1.00215532e-01f, 4.96073253e-02f, -7.03488141e-02f, -3.97998132e-02f, 9.01913494e-02f, 3.81284556e-03f, 2.22290377e-03f, 2.50170357e-03f, 4.14346671e-03f, 2.82956921e-02f,
  3.18733952e-03f, -4.55721915e-02f, 1.67769536e-01f, 7.34844059e-02f, 1.75511599e-01f, 1.66538283e-02f, 4.09740098e-02f, 2.37816870e-02f, 6.56702071e-02f, 9.99365933e-03f,
  -3.39841060e-02f, 5.83097488e-02f, 9.91513953e-02f, -1.34151736e-02f, 2.47749966e-02f, 1.41471932e-02f, -1.13073457e-02f, -7.68213421e-02f, 4.55224216e-02f, 2.12648690e-01f,
  1.16613574e-01f, -3.28702070e-02f, -9.16272849e-02f, -4.74847779e-02f, 1.50188645e-02f, -5.80914542e-02f, -9.90115106e-02f, -8.39580223e-02f, -8.60752091e-02f, -2.96473000e-02f,
  -8.84997249e-02f, 1.47091880e-01f, 7.07330629e-02f, 1.50785804e-01f, 9.08080935e-02f, -3.11577599e-02f, 8.02388135e-03f, -1.46867231e-01f, 4.62733917e-02f, -2.44289860e-02f,
  -8.30878764e-02f, 5.61453253e-02f, -6.33142218e-02f, 7.77587071e-02f, -1.34168148e-01f, -3.94251756e-02f, -2.45611407e-02f, 3.07837222e-02f, -7.65639618e-02f, -7.25657418e-02f,
  1.11731656e-01f, 1.94735780e-01f, -7.29190335e-02f, -3.86549979e-02f, -7.64351785e-02f, -9.51181352e-02f, 1.41507946e-02f, 1.63229018e-01f, -2.98336633e-02f, 1.41429156e-01f,
  3.46329845e-02f, -3.67659479e-02f, 6.12042248e-02f, -5.92932291e-02f, -1.65902898e-01f, 1.18623845e-01f, -5.11428434e-03f, 3.77871916e-02f, 6.39490560e-02f, -2.95128729e-02f,
  -1.28297105e-01f, 9.80356932e-02f, -3.33824791e-02f, 7.42055848e-02f, 2.42745522e-02f, 4.99670170e-02f, 1.04493015e-01f, 1.91389397e-02f, -4.66607995e-02f, -2.83821896e-02f,
  1.10896885e-01f, 4.29076821e-01f, 3.60064358e-01f, 8.84825289e-02f, -1.57978594e-01f, 3.44918594e-02f, 2.89591789e-01f, -2.54205495e-01f, -3.82630201e-03f, 5.73430620e-02f,
  -3.90707627e-02f, 6.35233998e-01f, -1.26020983e-01f, -1.03252530e-02f, -4.13865112e-02f, -2.00220630e-01f, -7.73477256e-02f, 8.66452307e-02f, 1.30217686e-01f, -1.59837112e-01f,
  -9.46599245e-02f, -3.48100722e-01f, -3.86635214e-02f, -1.52351290e-01f, 2.67362207e-01f, 1.72245085e-01f, -1.89565301e-01f, 1.80550203e-01f, 1.69554353e-01f, 1.64220005e-01f,
  1.38088584e-01f, -1.59227192e-01f, 1.22255478e-02f, 1.41716003e-02f, 4.08001207e-02f, -6.88533857e-02f, 1.77854169e-02f, 2.35182479e-01f, 4.47496772e-02f, -4.48464276e-03f,
  -4.35006013e-03f, -7.31545910e-02f, 9.28993896e-02f, 3.22958790e-02f, -9.02292598e-03f, 1.87023748e-02f, 9.53297913e-02f, 1.03629529e-01f, 1.11915514e-01f, 2.64814734e-01f,
  1.73151139e-02f, 1.23558506e-01f, -4.28450713e-03f, -4.18181717e-02f, 8.58968347e-02f, -4.16566571e-03f, 7.10079540e-03f, 1.00148477e-01f, 5.79568669e-02f, -1.48451790e-01f,
  1.32570371e-01f, -1.26268446e-01f, -9.08984523e-03f, -8.99512023e-02f, -8.19249824e-02f, -6.82012439e-02f, -3.90348136e-02f, -1.20007031e-01f, -1.44946063e-02f, -1.55943319e-01f,
  -8.52608383e-02f, -4.56098691e-02f, -9.56766456e-02f, -1.58264730e-02f, 8.48791525e-02f, -2.08041277e-02f, 8.80710781e-03f, -4.75452468e-02f, -8.94765463e-03f, 5.46479858e-02f,
  -5.60395010e-02f, 7.86562711e-02f, -1.07533701e-01f, -7.93977231e-02f, 3.85344634e-03f, -8.48686323e-02f, 1.16919987e-01f, 1.05017155e-01f, -1.95899867e-02f, 5.06400056e-02f,
  -2.02372208e-01f, -1.78273752e-01f, 7.19284508e-05f, 1.91210642e-01f, 6.78717196e-02f, 8.53544176e-02f, 7.54364878e-02f, 8.87838602e-02f, 9.18578058e-02f, 8.25733021e-02f,
  5.38391024e-02f, -1.07697539e-01f, 9.34020523e-03f, -6.00453950e-02f, -4.25537601e-02f, 9.08406973e-02f, -4.70655086e-03f, 1.02598667e-01f, 3.89393456e-02f, 1.00275338e-01f,
  9.60155763e-03f, 2.73057166e-02f, -8.99754539e-02f, -1.26860872e-01f, 1.17895529e-01f, 3.39564774e-03f, -2.45868247e-02f, 1.30606696e-01f, 2.41994977e-01f, 1.54099446e-02f,
  1.97054654e-01f, -7.88300931e-02f, -5.60209490e-02f, -6.43165549e-03f, -1.31614320e-02f, -1.84560061e-01f, 3.75994980e-01f, -4.58546937e-01f, 1.73047796e-01f, -3.02574515e-01f,
  -2.12132066e-01f, 3.35580200e-01f, 3.11199397e-01f, -4.83352870e-01f, 6.27867997e-01f, 4.00118768e-01f, -1.90936252e-01f, 9.44303945e-02f, 6.07881658e-02f, -1.97804838e-01f,
  -6.95097223e-02f, -3.81235242e-01f, 5.59619442e-03f, -4.81006980e-01f, -2.84628510e-01f, -2.38269150e-01f, -7.05710845e-03f, 3.33115816e-01f, -3.85732800e-01f, 1.76150575e-01f,
  -1.03888169e-01f, -1.57169148e-01f, -1.65981561e-01f, -5.57660051e-02f, -3.06105856e-02f, 4.50350903e-02f, 1.70462042e-01f, 2.21419200e-01f, 3.95179540e-02f, -1.31609589e-01f,
  1.08754762e-01f, 2.70306561e-02f, -8.57530609e-02f, 3.21271159e-02f, 3.16623375e-02f, -7.02979937e-02f, 2.71490160e-02f, -1.52289301e-01f, -1.17602050e-01f, 4.16441727e-03f,
  -5.22227548e-02f, -2.13759318e-02f, 2.54650861e-02f, -4.18513641e-02f, 1.03849500e-01f, -3.83802950e-02f, 5.97936064e-02f, 5.59808761e-02f, -2.26699829e-01f, 4.87993769e-02f,
  -1.57577842e-02f, 2.95630656e-02f, -1.42450053e-02f, -1.08666085e-01f, 4.62629553e-03f, -1.29025295e-01f, -2.21512504e-02f, -1.11801527e-01f, 2.27225199e-02f, 2.92966664e-02f,
  -6.62561730e-02f, 1.94208454e-02f, -4.29197662e-02f, 4.16479772e-03f, -4.70168702e-02f, -8.90010595e-02f, 7.34139308e-02f, 1.39795914e-02f, 1.80868097e-02f, 3.07366289e-02f,
  -9.29552987e-02f, 9.69062299e-02f, -9.35097635e-02f, -1.08572163e-01f, 8.66341293e-02f, 1.22714348e-01f, -1.35454640e-01f, -3.21937837e-02f, 4.78678122e-02f, 9.40152705e-02f,
  7.80063868e-03f, 1.88478991e-01f, -8.12564120e-02f, -4.92318757e-02f, 6.51869103e-02f, -1.43429980e-01f, 3.60706425e-03f, -6.12757076e-03f, 9.01015177e-02f, -1.12824060e-01f,
  -7.94847235e-02f, 3.89925204e-02f, 5.36071323e-02f, -2.33778097e-02f, 5.24163172e-02f, -3.30442153e-02f, 1.65672272e-01f, 1.02750704e-01f, 1.34316623e-01f, -5.47419973e-02f,
  2.20255721e-02f, 8.05804059e-02f, 5.70422858e-02f, -3.91979180e-02f, -7.82387406e-02f, 8.13628286e-02f, -1.28233522e-01f, -1.52211692e-02f, 1.08366564e-01f, 6.49024546e-03f,
  4.15488809e-01f, 3.50956246e-02f, 1.16007179e-01f, 1.50167048e-01f, 1.33809075e-01f, -1.78452581e-01f, 5.98036423e-02f, 1.74860239e-01f, 5.56885362e-01f, -3.57842982e-01f,
  -3.71724814e-01f, 1.54804690e-02f, 5.86066842e-02f, -3.63462985e-01f, 6.88290447e-02f, 1.25567958e-01f, 2.68627815e-02f, -8.61117151e-03f, 1.48110285e-01f, 4.71721217e-02f,
  1.61311664e-02f, -2.94806093e-01f, -1.19161814e-01f, -3.12890649e-01f, -3.28736007e-01f, -1.02985926e-01f, -4.28035647e-01f, -9.95986350e-03f, -5.21294475e-01f, -2.71255016e-01f,
  -2.72747099e-01f, -1.69700369e-01f, -2.15518594e-01f, -1.17165603e-01f, -2.40613878e-01f, -1.14360303e-01f, -2.77999967e-01f, -3.07463557e-01f, -3.99524681e-02f, 1.18640466e-02f,
  1.40685573e-01f, -6.85764700e-02f, -1.11377798e-01f, 1.12950616e-01f, 9.18924138e-02f, -1.29673600e-01f, 4.80882823e-03f, -1.18809097e-01f, 7.50004649e-02f, 1.11232586e-01f,
  7.13511780e-02f, -1.43036127e-01f, 1.29883066e-02f, 4.70717661e-02f, -4.93528955e-02f, 3.68280970e-02f, 1.01143487e-01f, -2.42900476e-02f, -9.92763694e-03f, 3.55397388e-02f,
  -1.12726569e-01f, 2.64953673e-01f, 2.12655999e-02f, 8.00824985e-02f, -6.51162788e-02f, 4.24251892e-02f, -4.07700203e-02f, -1.37338683e-01f, 1.10466287e-01f, -6.35843500e-02f,
  5.35162389e-02f, -1.07430957e-01f, 1.99817102e-02f, 9.03394446e-02f, 7.07055107e-02f, 7.73018152e-02f, -3.55744958e-02f, 2.85961907e-02f, -4.19933870e-02f, -7.36952052e-02f,
  1.87556982e-01f, -8.05860851e-03f, 9.14494395e-02f, -5.47398347e-03f, 8.74600410e-02f, 1.36181330e-02f, -5.32205142e-02f, 2.29434237e-01f, -1.30752355e-01f, -1.36564478e-01f,
  -3.70015472e-01f, -4.15538669e-01f, -6.89990744e-02f, -2.50622910e-02f, 1.08648971e-01f, -1.52264014e-01f, -6.26028851e-02f, 6.64350390e-02f, -2.62910426e-01f, -5.79720661e-02f,
  -5.59296319e-03f, -1.29955977e-01f, -6.83890507e-02f, 9.26741213e-02f, 8.88203643e-03f, -3.45139690e-02f, -2.49268442e-01f, -1.28689393e-01f, -2.90460259e-01f, -6.32613450e-02f,
  1.06709860e-01f, -1.18928835e-01f, -8.92939791e-02f, -1.59615234e-01f, -6.14402518e-02f, 2.38216780e-02f, 9.89903882e-03f, -3.54609191e-02f, -1.59431342e-02f, -5.74651621e-02f,
  -4.83034015e-01f, 1.91051498e-01f, -2.41290957e-01f, -8.36977735e-02f, 1.74290806e-01f, -7.27932870e-01f, -4.35027301e-01f, 9.62645113e-02f, -2.02673510e-01f, 2.55926847e-01f,
  -8.36884081e-02f, -6.79984614e-02f, 1.97888061e-01f, -6.16779983e-01f, -4.45406914e-01f, -4.22152787e-01f, -4.23695117e-01f, -3.10474902e-01f, -2.54143894e-01f, 1.42739668e-01f,
  -1.51010916e-01f, -5.45273274e-02f, -3.23645830e-01f, 9.27551538e-02f, -4.64464910e-03f, 2.58158714e-01f, 5.92145920e-01f, 2.78048962e-01f, -4.01640907e-02f, -3.06795184e-02f,
  -1.12996422e-01f, 8.43751878e-02f, 5.58338352e-02f, -1.60582915e-01f, 1.53615316e-02f, 3.85072343e-02f, -1.09523848e-01f, -7.53692091e-02f, -5.17141670e-02f, -1.15919255e-01f,
  9.02650654e-02f, 4.49341759e-02f, -7.88193196e-02f, 8.70306417e-02f, -3.41656022e-02f, -3.66038568e-02f, -1.39268503e-01f, -1.49583355e-01f, -1.65559530e-01f, -5.48663512e-02f,
  -8.00785497e-02f, -8.30037668e-02f, 8.73886049e-02f, 2.43046805e-02f, -1.82596445e-02f, -4.68328856e-02f, -6.59003705e-02f, 5.26903309e-02f, 7.49265030e-02f, -6.13540858e-02f,
  6.46932945e-02f, 1.92408897e-02f, 1.01306178e-02f, -8.82966146e-02f, -2.65058856e-02f, -2.30231471e-02f, -2.25328226e-02f, -2.26121843e-02f, 2.22456884e-02f, -4.48624603e-02f,
  -5.93587849e-03f, -3.49771306e-02f, -6.06826209e-02f, 1.42402902e-01f, 4.04559709e-02f, 1.62901431e-02f, -5.61456159e-02f, 7.71357268e-02f, -9.30593312e-02f, -1.84464097e-01f,
  1.66156322e-01f, 7.73794251e-03f, -1.35584950e-01f, 3.78495641e-03f, -5.83287217e-02f, 1.20727345e-01f, 3.77517156e-02f, -7.98607841e-02f, -8.88483040e-03f, 2.86019896e-03f,
  5.86304329e-02f, 3.35732937e-01f, -7.54693151e-02f, 1.02871470e-02f, -9.29183513e-02f, -1.68341011e-01f, -5.53694041e-03f, -6.64230287e-02f, 1.13346256e-01f, 2.18601804e-02f,
  1.55470490e-01f, -1.63537934e-02f, 1.23700172e-01f, 1.22273853e-02f, -7.26561248e-02f, 4.89725694e-02f, 9.76061523e-02f, 9.69819352e-02f, 1.82966545e-01f, 6.41783699e-02f,
  1.30895123e-01f, -2.28682011e-02f, 6.65934309e-02f, -7.76377320e-02f, 9.53355432e-02f, 3.48134041e-02f, 9.47821662e-02f, 6.10727593e-02f, 1.17179424e-01f, 1.32162541e-01f,
  -1.41601884e+00f, 4.29310709e-01f, -2.35893615e-02f, -1.60717636e-01f, -5.88958971e-02f, 1.22233227e-01f, 2.07269698e-01f, -6.16913382e-03f, -1.58802330e-01f, 1.50799900e-01f,
  -7.10755363e-02f, -1.77924111e-01f, 2.94651687e-01f, 2.06843615e-01f, -2.28983805e-01f, 3.77962947e-01f, -8.28338042e-02f, -1.70697346e-01f, 8.99915099e-02f, -1.81435466e-01f,
  -2.07936406e-01f, 1.16900131e-01f, 1.21270664e-01f, 2.03700602e-01f, -3.93169522e-01f, -1.83196142e-01f, -1.73413634e-01f, 9.51635092e-02f, -9.40805748e-02f, -8.18963200e-02f,
  -6.30283415e-01f, -3.24620008e-01f, -1.64331809e-01f, -2.33924806e-01f, -2.57447362e-01f, -1.97962031e-01f, -1.62196293e-01f, -3.48605923e-02f, -4.00519297e-02f, -2.00494621e-02f,
  -5.97442985e-02f, -7.23813176e-02f, 5.14574759e-02f, 2.49562301e-02f, 4.32637008e-03f, -2.54707556e-04f, 9.46917236e-02f, -8.60180780e-02f, 1.69453397e-02f, 1.77265838e-01f,
  1.22836046e-01f, -1.29929885e-01f, -8.09674636e-02f, -8.12693406e-03f, -4.50758524e-02f, 8.49503726e-02f, 5.21409325e-02f, -4.27804887e-02f, -6.44134060e-02f, -5.88202775e-02f,
  -1.86062455e-01f, 8.60818699e-02f, 8.48916546e-02f, -1.20282313e-02f, -2.76227891e-02f, 1.10222986e-02f, 7.87703916e-02f, 1.92179400e-02f, -8.06581527e-02f, -3.54801281e-03f,
  -8.78337622e-02f, -8.95862952e-02f, -1.32736847e-01f, 5.29806642e-03f, -1.92716978e-02f, -1.21702604e-01f, 5.17131239e-02f, -3.93356569e-02f, -6.17325567e-02f, -2.68777981e-02f,
  3.37683335e-02f, 3.67594510e-02f, 1.54856950e-01f, 4.68772370e-03f, -1.43385768e-01f, 9.32280123e-02f, -2.68170983e-02f, 5.54511659e-02f, 1.20512754e-01f, -2.52797771e-02f,
  -5.89457273e-01f, -5.96485436e-01f, -8.86693150e-02f, -2.17520207e-01f, -3.42284553e-02f, -5.96895628e-02f, -7.59618648e-04f, -4.85445857e-02f, -5.03652059e-02f, -8.64288509e-02f,
  -1.06559098e-01f, -7.47104138e-02f, -1.17096603e-01f, 2.56701000e-03f, -1.01625721e-03f, 2.68838485e-03f, 9.09133032e-02f, -1.89500451e-01f, -1.63693026e-01f, -5.75174130e-02f,
  4.47022403e-03f, -1.51103944e-01f, -1.46401441e-02f, 9.47498158e-03f, 6.53257146e-02f, -1.38611853e-01f, -2.20425710e-01f, 4.48351577e-02f, -3.26783955e-02f, 5.38380295e-02f,
  2.85203695e-01f, -1.55045047e-01f, -2.80473530e-01f, 1.01352908e-01f, -4.66125488e-01f, -6.20415747e-01f, -6.26464069e-01f, -3.16186905e-01f, 1.26902595e-01f, 2.49978807e-02f,
  -8.37285817e-02f, 3.44539076e-01f, 2.94979841e-01f, -3.59800190e-01f, 9.66026112e-02f, 2.92090803e-01f, -3.69403064e-01f, -3.12646896e-01f, -3.77778597e-02f, -1.02469325e-01f,
  1.83645517e-01f, -6.86255544e-02f, -1.34444889e-02f, -3.46644744e-02f, -2.62711972e-01f, -7.87076075e-03f, 2.18124077e-01f, -7.57026896e-02f, -2.80436784e-01f, -1.03162676e-01f,
  -1.88551098e-01f, 2.21660048e-01f, -9.69063416e-02f, 1.69781724e-03f, -1.20946109e-01f, 6.44164830e-02f, -2.02499390e-01f, 3.47033963e-02f, 1.67433172e-02f, 1.33418217e-01f,
  1.24016188e-01f, 2.44155824e-01f, -6.92643365e-03f, 1.29125923e-01f, -8.89496226e-03f, 3.92074808e-02f, 5.35715222e-02f, -1.90226287e-01f, 5.63150346e-02f, 1.20041473e-03f,
  3.93338799e-02f, -5.03909066e-02f, -6.29271418e-02f, -1.40122259e-02f, 4.61430028e-02f, -3.19465958e-02f, 3.01154312e-02f, -1.27072781e-01f, -1.93004850e-02f, 2.36169212e-02f,
  3.36450785e-02f, -6.82609752e-02f, 7.85132125e-02f, -1.29153192e-01f, 3.81149091e-02f, 6.31130263e-02f, 2.07061782e-01f, 3.47563326e-02f, 7.08932504e-02f, 9.25203189e-02f,
  -4.05138656e-02f, 4.06803228e-02f, 3.91337574e-02f, -5.43809682e-02f, 1.33943275e-01f, 1.17508858e-01f, 6.37715980e-02f, 1.02526248e-01f, -5.61372004e-02f, -8.62642527e-02f,
  1.30386114e-01f, 8.12635496e-02f, -2.85768583e-02f, -1.45199969e-02f, -5.73724024e-02f, -2.02312181e-03f, 4.66048494e-02f, -1.08647142e-02f, -1.48127051e-02f, 1.28068738e-02f,
  -1.55261993e-01f, 6.92145005e-02f, 3.63408066e-02f, 1.54927790e-01f, -1.07867673e-01f, -1.25231355e-01f, -5.12369797e-02f, 5.91061041e-02f, 9.69103053e-02f, 8.24525058e-02f,
  -8.47700387e-02f, 1.00634560e-01f, -2.73338556e-01f, -1.23250857e-02f, 6.04982488e-03f, -1.21621713e-01f, -1.67176798e-02f, 1.78622070e-03f, -5.43612577e-02f, 8.21875036e-02f,
  7.11072609e-02f, 5.52434884e-02f, 1.80580720e-01f, 1.16617851e-01f, -2.68620234e-02f, -5.31091392e-02f, -1.82221666e-01f, 3.46437842e-02f, 1.96592078e-01f, -4.97759916e-02f,
  4.51323777e-01f, -8.39458406e-02f, 9.69672948e-02f, 4.35474485e-01f, -1.16714265e-03f, -3.45065385e-01f, -4.98074651e-01f, 1.22573510e-01f, -2.37382665e-01f, -1.85398132e-01f,
  2.28821263e-01f, -2.86687672e-01f, -6.73556998e-02f, 3.27725738e-01f, 2.68324614e-02f, -9.01155472e-02f, 1.61000684e-01f, -3.57598439e-02f, -7.98872411e-02f, 1.13287821e-01f,
  3.49994361e-01f, 3.70062113e-01f, 8.54407698e-02f, 3.46377730e-01f, 1.94963381e-01f, 1.91444442e-01f, 2.84724474e-01f, 9.65403244e-02f, 2.64758110e-01f, -1.59099713e-01f,
  -5.18221967e-02f, 1.32808182e-03f, -2.51501091e-02f, 2.53914446e-02f, 1.90805607e-02f, 2.98534222e-02f, -1.63134471e-01f, -1.77893266e-02f, -5.44410199e-02f, 2.28181225e-03f,
  1.20372716e-02f, 7.65212774e-02f, 3.13722305e-02f, -3.47687863e-02f, 3.30327600e-02f, -1.55696526e-01f, -5.12195453e-02f, -1.16028771e-01f, -1.72705367e-01f, 1.63025096e-01f,
  -7.92825148e-02f, -8.20127651e-02f, 3.60100605e-02f, -3.35789286e-02f, 2.86228489e-02f, 9.49653983e-02f, -5.90782464e-02f, -8.74184743e-02f, -4.31219675e-02f, 1.54244620e-02f,
  1.46952599e-01f, -9.44874436e-02f, 6.40107691e-02f, 4.33496758e-02f, 3.88950855e-02f, 6.32585287e-02f, -1.00336978e-02f, 1.46030504e-02f, -1.93407182e-02f, -1.03833698e-01f,
  6.06311746e-02f, 6.91404417e-02f, 1.32541850e-01f, -9.26879942e-02f, 7.34612569e-02f, -3.99853401e-02f, -2.05551796e-02f, 4.26135994e-02f, -6.67020818e-03f, -1.30380005e-01f,
  5.51792234e-02f, 5.50566837e-02f, 1.66652903e-01f, 5.25070028e-03f, 1.10691860e-02f, 7.47641772e-02f, 2.27101758e-01f, 2.24329121e-02f, -7.61146471e-02f, -1.88905261e-02f,
  -8.54013041e-02f, 1.57443136e-01f, -1.83129311e-01f, -1.93921998e-02f, -9.06703845e-02f, 5.36433980e-02f, -6.07364718e-03f, 6.07578084e-02f, 6.45259619e-02f, 8.07777643e-02f,
  9.19471458e-02f, -8.45347419e-02f, 9.78450552e-02f, 2.32028347e-02f, -9.15813446e-02f, -2.85708215e-02f, 2.21703753e-01f, -2.02401262e-02f, -5.62391989e-03f, 8.92518833e-03f,
  1.62991267e-02f, -1.64571032e-01f, 1.36718862e-02f, -2.83067729e-02f, -3.41259316e-02f, 4.67628390e-02f, -2.16487408e-01f, 5.71590215e-02f, -9.68487486e-02f, -6.98060915e-02f,
  1.61605716e-01f, -4.46687788e-01f, 3.27297866e-01f, 1.20808899e-01f, 2.18980744e-01f, 4.73940253e-01f, 2.59075671e-01f, -1.19746722e-01f, -2.95217782e-01f, -5.11240721e-01f,
  -1.42558128e-01f, 2.45476767e-01f, -2.24520832e-01f, -5.87687679e-02f, 2.82837927e-01f, -2.48292685e-01f, -2.11239100e-01f, -2.13184029e-01f, -2.01052576e-01f, 2.34485380e-02f,
  2.91204423e-01f, -2.28887405e-02f, 2.74282098e-01f, -1.52873710e-01f, 1.75992534e-01f, -1.03385948e-01f, -9.83060375e-02f, 4.72796820e-02f, 1.54952779e-01f, 1.23453163e-01f,
  -1.06339850e-01f, -1.40990630e-01f, -9.45162177e-02f, -1.49550974e-01f, -1.95265122e-04f, 7.04734102e-02f, 4.90999557e-02f, 4.09744196e-02f, 5.27274534e-02f, 3.36643606e-02f,
  9.39710140e-02f, 1.06989995e-01f, -4.39676503e-03f, 8.67450088e-02f, -1.49736619e-02f, -1.09698121e-02f, 1.66364953e-01f, -1.18778169e-01f, 1.25829224e-02f, 3.40498686e-02f,
  -1.61899384e-02f, 1.12777920e-02f, -1.09077813e-02f, 3.65313143e-02f, -2.33123675e-02f, -2.86730174e-02f, 1.24523267e-02f, 1.24563560e-01f, 1.11924581e-01f, 1.13592848e-01f,
  8.59278720e-03f, -1.14612542e-02f, -4.71831392e-03f, -2.41363738e-02f, 5.04103340e-02f, 5.02827466e-02f, 7.47991726e-02f, -3.14238556e-02f, 1.14849240e-01f, 2.46217847e-03f,
  -9.85884070e-02f, 6.71960115e-02f, -4.48818654e-02f, 2.41165352e-03f, 1.05921544e-01f, -5.20835584e-03f, 6.77750558e-02f, -5.72205856e-02f, -9.34444591e-02f, -1.57491520e-01f,
  -4.33201566e-02f, -3.37554775e-02f, -1.26438141e-01f, 1.71659246e-01f, -4.51399647e-02f, 9.12984088e-02f, -3.56159881e-02f, 6.95051998e-02f, -4.60795797e-02f, -3.90556492e-02f,
  -7.07028627e-01f, -5.08044600e-01f, -1.54120341e-01f, 1.04839483e-03f, -3.41463089e-02f, 1.92609448e-02f, -9.54154283e-02f, -1.04749218e-01f, -1.09295443e-01f, 1.67411685e-01f,
  3.26311216e-02f, 1.32849485e-01f, -6.75585791e-02f, -2.73770690e-02f, -1.74796227e-02f, -1.09122798e-01f, -2.39687953e-02f, -1.12689748e-01f, -5.49449697e-02f, -6.69278353e-02f,
  -5.86550385e-02f, 5.95725421e-03f, 9.25619379e-02f, 2.77941301e-02f, -3.67739871e-02f, 5.34482636e-02f, -1.16325885e-01f, -9.87110808e-02f, 3.64779718e-02f, 1.04177073e-01f,
  -4.86532636e-02f, 7.02930450e-01f, -2.60158777e-01f, 5.03565550e-01f, -2.38230839e-01f, 2.87080437e-01f, 3.54981631e-01f, -3.90108079e-02f, 7.06119239e-02f, 5.23172617e-01f,
  9.83347148e-02f, 2.47911513e-01f, 2.18851432e-01f, 3.82472426e-01f, 5.96204866e-03f, 3.48425984e-01f, 4.82151151e-01f, 2.00631246e-01f, 1.19029202e-01f, 1.27301559e-01f,
  8.53237733e-02f, 4.36112851e-01f, 5.53189730e-03f, -9.00412351e-02f, 2.54354402e-02f, -6.72294647e-02f, 2.27293745e-01f, -1.99547976e-01f, 1.86245684e-02f, -4.53581475e-03f,
  -1.12006543e-02f, 1.90867335e-01f, -2.45565712e-01f, -1.11994572e-01f, 5.42375296e-02f, -2.14688014e-02f, 3.90726551e-02f, -1.69754535e-01f, -1.02262758e-01f, -1.51160490e-02f,
  9.68308672e-02f, -2.73024314e-03f, 1.99355241e-02f, -7.00526312e-02f, 6.76584244e-02f, -9.12529528e-02f, -7.47332126e-02f, -1.44167691e-01f, -3.52646261e-02f, -1.84884621e-03f,
  -1.38264254e-01f, 2.11279970e-02f, -3.43519151e-02f, 1.45913228e-01f, -6.23713546e-02f, 1.19685434e-01f, 1.26832530e-01f, -3.78375277e-02f, 1.43218651e-01f, 1.83449000e-01f,
  4.73429374e-02f, 8.89741033e-02f, 6.20801561e-02f, -3.11498549e-02f, 5.73558174e-02f, 2.30550580e-02f, -8.22704285e-02f, -1.78019255e-01f, -6.43250868e-02f, 6.12910651e-02f,
  -5.25935777e-02f, -8.55512694e-02f, 1.82285272e-02f, -2.04687379e-02f, 3.09294499e-02f, 1.31132111e-01f, -4.15155999e-02f, 3.68327834e-02f, -1.30363390e-01f, -2.78307814e-02f,
  5.28204925e-02f, -4.03954880e-03f, -1.10020395e-02f, 4.45039794e-02f, 4.41451147e-02f, -5.00408188e-02f, 3.23599726e-02f, 1.47618772e-02f, 5.62169142e-02f, -1.53880253e-01f,
  2.77992636e-01f, 5.10410905e-01f, 1.97675116e-02f, 4.13235165e-02f, 1.31470021e-02f, 1.63050778e-02f, 1.99907622e-03f, 6.98779374e-02f, 1.89791769e-01f, 6.68919012e-02f,
  4.61636744e-02f, -5.96591234e-02f, 3.65200117e-02f, -8.94358233e-02f, 3.99215706e-03f, 1.52135476e-01f, 1.01753220e-01f, -1.44063234e-02f, 4.03563268e-02f, 2.99621169e-02f,
  7.50105530e-02f, -2.74855224e-03f, -1.35861978e-01f, -6.64505884e-02f, -2.94082556e-02f, 5.35580777e-02f, 4.75234464e-02f, -1.09084681e-01f, -7.64753371e-02f, 6.44417480e-02f,
  -2.52424985e-01f, -1.52745843e-01f, -3.00982982e-01f, -4.89868335e-02f, 2.58273333e-01f, 2.12516934e-01f, -4.59780633e-01f, 3.57114881e-01f, -3.31080645e-01f, -1.99519053e-01f,
  2.09608585e-01f, -2.36574084e-01f, -4.55018818e-01f, 7.15906993e-02f, 1.95510224e-01f, -5.47801375e-01f, 4.37420934e-01f, 1.40023872e-01f, -2.00701162e-01f, 1.49371907e-01f,
  2.14750573e-01f, 5.10280371e-01f, 2.46103302e-01f, 5.14784515e-01f, 1.36293145e-03f, 2.67095983e-01f, 4.75343019e-01f, -2.74784639e-02f, 4.87964720e-01f, 1.55404702e-01f,
  -3.92424576e-02f, -5.37855364e-02f, -1.52930364e-01f, -6.93164468e-02f, -5.72507642e-03f, 3.68847437e-02f, -2.06143297e-02f, 9.06121209e-02f, 9.31955650e-02f, -4.69535999e-02f,
  -6.55297264e-02f, 8.05384219e-02f, 9.21380445e-02f, 4.01117560e-03f, 1.48662537e-01f, 5.91486990e-02f, -1.10357190e-02f, 4.00636457e-02f, -6.74726889e-02f, -5.20056710e-02f,
  4.72952463e-02f, 1.07273817e-01f, -1.08684123e-01f, -2.52619274e-02f, -3.10246833e-02f, 8.24427083e-02f, -7.56379664e-02f, 1.03744507e-01f, 4.56954092e-02f, 1.66291632e-02f,
  1.42971510e-02f, 2.26462055e-02f, -3.51415761e-02f, -1.58622697e-01f, 3.22718211e-02f, -1.25629500e-01f, -5.58377281e-02f, -1.51175454e-01f, -2.82834079e-02f, -1.69830784e-01f,
  3.87452468e-02f, -3.55292447e-02f, -9.34979543e-02f, -2.03678012e-03f, 7.14481100e-02f, -2.24567875e-02f, 8.42513924e-04f, 7.11630192e-03f, -1.87823772e-02f, 3.84048447e-02f,
  -8.81596878e-02f, 1.97501361e-01f, -3.27774920e-02f, 1.15472816e-01f, 1.73074249e-02f, -1.46601826e-01f, 6.51456937e-02f, -5.61638689e-03f, -9.03614089e-02f, 8.53184760e-02f,
  1.52505249e-01f, 2.11322248e-01f, -1.13077238e-01f, 7.18547106e-02f, -5.73964119e-02f, 1.72572322e-02f, -2.62744337e-01f, 1.08638160e-01f, -1.59784164e-02f, 4.79972921e-02f,
  1.78617910e-01f, 4.65061590e-02f, 5.53001231e-03f, -5.37984148e-02f, 1.15569122e-01f, 7.09236562e-02f, 5.06332554e-02f, 8.71977508e-02f, 8.88936520e-02f, 1.44089684e-01f,
  1.04299299e-01f, 1.75178181e-02f, 4.59119910e-03f, 1.50321916e-01f, 1.60847351e-01f, -3.23451906e-02f, 8.34312439e-02f, -2.31433026e-02f, 1.61182597e-01f, -2.44472902e-02f,
  3.31691593e-01f, -4.02889438e-02f, -2.37743363e-01f, 6.78058937e-02f, 1.03777289e-01f, -3.66817531e-03f, -1.93690270e-01f, 2.32364833e-01f, -1.44173220e-01f, -5.31121083e-02f,
  1.88772306e-01f, 2.25437991e-02f, -1.60976425e-01f, 4.23061818e-01f, 3.74914080e-01f, -3.63373250e-01f, 6.35218680e-01f, 1.15952499e-01f, 9.82303917e-02f, 2.40514442e-01f,
  1.75325617e-01f, 5.54105639e-01f, 1.04338989e-01f, 4.08918083e-01f, 4.43003416e-01f, 1.47153586e-02f, 1.08741015e-01f, 3.79025820e-03f, 4.70945716e-01f, 2.64855027e-01f,
  -1.20164134e-01f, -1.12163514e-01f, 6.65641353e-02f, -8.37591141e-02f, 5.30103408e-03f, -8.43915716e-02f, -3.13513950e-02f, -1.30784988e-01f, -2.00243980e-01f, -1.09147832e-01f,
  -9.95533466e-02f, 1.42957382e-02f, 4.55421172e-02f, 9.41695943e-02f, 1.40083745e-01f, 1.69015862e-02f, -2.57343077e-03f, -2.56141066e-03f, 1.73424855e-02f, 4.61362712e-02f,
  9.12996382e-03f, -7.75958076e-02f, 1.25623532e-02f, 1.53702302e-02f, -4.11276259e-02f, 7.33237118e-02f, -1.73847869e-01f, -7.12109730e-02f, -3.67058739e-02f, 8.25918615e-02f,
  6.66026697e-02f, 1.67454574e-02f, -4.44893818e-03f, -6.74132779e-02f, 8.10656846e-02f, 5.67685440e-02f, 1.95520073e-01f, -4.33567017e-02f, 3.66271809e-02f, 1.43481418e-01f,
  6.05451204e-02f, 5.61152883e-02f, 1.02698632e-01f, -5.14023304e-02f, 9.49028656e-02f, -1.03105471e-01f, -3.91180366e-02f, 1.55024212e-02f, 3.54749300e-02f, -8.72594267e-02f,
  6.36710366e-03f, 1.48526922e-01f, 8.91715065e-02f, 1.20030658e-03f, -3.58219668e-02f, 7.70972520e-02f, 1.18376464e-01f, 6.90016523e-02f, -2.09234059e-01f, -1.29278451e-02f,
  9.74406973e-02f, 1.68027043e-01f, 7.69916400e-02f, -1.28223404e-01f, -2.31349133e-02f, 1.32265911e-01f, 1.44413427e-01f, 1.39292888e-02f, 1.25651672e-01f, -2.82126460e-02f,
  -3.88565939e-03f, -5.68710454e-02f, -1.67173836e-02f, 4.97689983e-03f, -7.18531534e-02f, 1.24507666e-01f, -9.97822732e-03f, 9.42480937e-02f, 8.87961388e-02f, 9.06365290e-02f,
  -1.05862573e-01f, -1.51131563e-02f, 1.50275314e-02f, 4.13331315e-02f, -3.19153741e-02f, -3.20419259e-02f, 4.56559425e-03f, -8.07073247e-03f, 1.74487755e-01f, 3.74872759e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.86023510e-01f, 6.28330886e-01f, 5.14969110e-01f, 2.10120514e-01f, 2.40724489e-01f, 7.60593653e-01f, 4.55176353e-01f, 5.67330599e-01f, 1.12334654e-01f, -3.57538052e-02f,
  5.79949200e-01f, 2.97616929e-01f, 4.03758317e-01f, 1.39200792e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.20477909e-01f, 1.32947713e-01f, 2.49166996e-03f, 5.33019423e-01f, 1.52460307e-01f, 4.27064538e-01f, -1.29701898e-01f, 2.98457682e-01f, -2.55757570e-01f, -3.12638909e-01f,
  3.51931900e-01f, -4.81709361e-01f, 1.27801765e-02f, -2.35267859e-02f, -3.93107504e-01f, -3.06647450e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.16521555e-01f, -6.61015883e-02f, 4.24320161e-01f, 7.65169024e-01f, -2.04537809e-02f, 5.73619306e-01f, 1.38809517e-01f, 6.51943207e-01f, 3.16795856e-01f, -1.87950820e-01f,
  -1.73654482e-01f, -1.54362038e-01f, 4.67065305e-01f, -3.21616411e-01f, 5.33352613e-01f, -1.15378015e-02f, 2.43760943e-01f, -9.02605653e-02f, 3.15681249e-01f, 4.11578983e-01f,
  -6.92909770e-03f, 6.13597870e-01f, 6.56820774e-01f, 5.55891812e-01f, 2.76400298e-01f, 3.02674193e-02f, 5.62683761e-01f, -5.97042620e-01f, 4.46004301e-01f, 1.40517384e-01f,
  -1.19767211e-01f, -3.87892634e-01f, 4.54045117e-01f, -3.14102590e-01f, 6.39898658e-01f, 2.06478879e-01f, -1.53375566e-01f, 6.63230240e-01f, 4.62254196e-01f, 3.86723280e-01f,
  1.07212119e-01f, 4.28879410e-01f, 3.76420617e-01f, -2.72233188e-01f, 2.12213069e-01f, 4.80453610e-01f, -2.74187565e-01f, -1.78924903e-01f, 1.25092238e-01f, -2.60258913e-01f,
  6.09978855e-01f, -3.06210548e-01f, 2.43471906e-01f, 1.93306372e-01f, -1.60983250e-01f, 4.85267758e-01f, 5.47958970e-01f, 6.89693093e-01f, 1.68284118e-01f, 8.11117738e-02f,
  -2.00056419e-01f, 4.47520167e-01f, 2.95585096e-02f, -4.06745300e-02f, 9.76997375e-01f, 8.23870748e-02f, -2.04302296e-01f, -3.24855417e-01f, 9.29679751e-01f, 3.28419775e-01f,
  2.18257949e-01f, 1.35646164e-01f, -9.14123952e-01f, 5.23691595e-01f, 7.06187785e-02f, 1.06901051e-02f, 7.37136066e-01f, 2.49773100e-01f, 2.78740555e-01f, 5.98562300e-01f,
  5.33969879e-01f, 5.05419374e-01f, -1.17670581e-01f, -7.98093081e-01f, 4.78892058e-01f, 1.79093167e-01f, -4.70492840e-02f, 6.68827910e-03f, -7.53572464e-01f, 6.87078774e-01f,
  -1.31170973e-01f, -3.15076113e-02f, 2.05233060e-02f, 8.14498007e-01f, 7.00418428e-02f, 1.60116985e-01f, 4.12178487e-01f, 2.51817554e-01f, -4.35386896e-01f, -7.69003248e-03f,
  8.90192211e-01f, 9.05861408e-02f, 5.17485440e-01f, 5.49662173e-01f, -3.14727634e-01f, 4.69125016e-03f, 4.07757193e-01f, 1.35651037e-01f, -1.49776703e-02f, 2.86742657e-01f,
  2.33618729e-02f, 1.46977097e-01f, 4.80796993e-01f, -6.59953296e-01f, 9.16041076e-01f, -3.48716408e-01f, 4.54375625e-01f, 1.22427166e-01f, -6.27788007e-01f, 3.19494694e-01f,
  6.27296329e-01f, 4.46562529e-01f, -5.02100229e-01f, -7.71137923e-02f, 1.49251640e-01f, -4.50941861e-01f, 5.92298567e-01f, 2.90114522e-01f, -1.38566494e-01f, -3.35795693e-02f,
  2.31047049e-01f, 3.05263937e-01f, 3.62193108e-01f, -4.03653532e-02f, -6.09257631e-02f, 3.08782697e-01f, 4.10829663e-01f, 5.16326368e-01f, 7.20844805e-01f, 7.88263261e-01f,
  -5.78042984e-01f, 6.93877816e-01f, 3.78811300e-01f, 6.56692147e-01f, -1.74903572e-01f, 1.33828595e-01f, -2.85936981e-01f, 7.64257610e-01f, 8.37475836e-01f, -1.08480133e-01f,
  4.09274876e-01f, 3.98754686e-01f, 2.08043769e-01f, -5.99971533e-01f, 2.63011873e-01f, 5.95495760e-01f, 1.02965675e-01f, 4.82572824e-01f, 6.15401089e-01f, 6.22793853e-01f,
  7.48416245e-01f, -4.77664471e-01f, 4.11854625e-01f, -1.79057522e-03f, -3.97322744e-01f, 4.64032024e-01f, -5.52642206e-03f, -2.09278632e-02f, -3.67310643e-01f, 4.91144329e-01f,
  -3.01698208e-01f, -2.68001229e-01f, 8.11787426e-01f, -3.55987310e-01f, 3.83337289e-01f, 4.07389738e-02f, 3.02452117e-01f, -3.22640479e-01f, 3.92604381e-01f, 4.96728957e-01f,
  8.03238750e-02f, -2.21504554e-01f, -6.18488014e-01f, 1.09536014e-01f, 9.03679848e-01f, -4.34215307e-01f, -4.30651307e-01f, 3.25262606e-01f, 1.27620399e-01f, 1.08210780e-01f,
  8.76580000e-01f, 3.67712229e-01f, -5.17515063e-01f, 3.25502366e-01f, 4.22009349e-01f, -8.39004338e-01f, -2.89438665e-01f, -9.94329900e-02f, -3.57299060e-01f, 1.93456143e-01f,
  3.79586704e-02f, 8.00812185e-01f, 1.72925025e-01f, 1.19555175e-01f, -3.20228785e-01f, 6.68606818e-01f, -5.52304804e-01f, -5.50867260e-01f, 7.63959857e-03f, 3.66998821e-01f,
  1.73008274e-02f, 6.88627601e-01f, 5.78055739e-01f, -1.17800228e-01f, 5.05324066e-01f, 7.92321384e-01f, -3.85317765e-02f, -3.73088747e-01f, -2.72272527e-01f, -9.70656350e-02f,
  6.41649544e-01f, -4.17828202e-01f, -2.28007063e-01f, -2.11568817e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.41163325e-01f, -1.72653813e-02f, 1.66352943e-01f, 3.81856740e-01f, 3.34448904e-01f, 3.83941531e-01f, 3.25084269e-01f, 4.24388617e-01f, -1.10904574e-01f, 2.76411057e-01f,
  6.68274522e-01f, 3.18398833e-01f, -1.47970021e-01f, 6.78677142e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.12113096e-01f, -3.12402427e-01f, -5.68539277e-02f, 8.22928399e-02f, 8.36997405e-02f, 1.44486144e-01f, 2.30784677e-02f, -2.18538865e-01f, -1.61215067e-01f, 1.39551595e-01f,
  -3.16357166e-02f, -2.28083640e-01f, 4.42517817e-01f, 2.27691188e-01f, -2.48012483e-01f, -1.35626569e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -7.07354665e-01f, 1.05625653e+00f, 5.80390632e-01f, 4.27061349e-01f, 2.57847130e-01f, 1.27054146e-02f, -8.14689249e-02f, -1.02914095e-01f, 4.76391643e-01f, -2.96872824e-01f,
  -9.06700362e-03f, 3.29751104e-01f, -5.49930632e-01f, 5.75054176e-02f, -1.21384218e-01f, 5.75113475e-01f, 1.47403385e-02f, 1.82800874e-01f, -4.28880714e-02f, 8.98540989e-02f,
  2.93882072e-01f, 2.41749808e-01f, 3.33867401e-01f, 3.77271444e-01f, 4.40332927e-02f, -1.48498967e-01f, 1.87886104e-01f, -8.87235552e-02f, 4.28513020e-01f, -3.12791526e-01f,
  4.26660120e-01f, -9.24822763e-02f, 7.19797611e-02f, -5.50062716e-01f, 7.68608376e-02f, -5.64518645e-02f, -9.41317007e-02f, 4.49083835e-01f, -3.27784568e-01f, -7.76482761e-01f,
  2.20165178e-01f, 5.89040756e-01f, 6.98628962e-01f, 4.27897751e-01f, -6.32727206e-01f, 4.90918517e-01f, 1.09614678e-01f, 2.36268029e-01f, -1.49402499e-01f, 4.37631369e-01f,
  2.49636203e-01f, 4.83444333e-01f, -3.28720622e-02f, -3.77880216e-01f, 8.39445591e-01f, 1.67286798e-01f, 7.94821918e-01f, 2.90816188e-01f, -3.90821904e-01f, 3.13135386e-01f,
  1.98627517e-01f, -4.17427003e-01f, -5.40885270e-01f, 7.84680426e-01f, 4.70972419e-01f, -5.38039267e-01f, 2.86989093e-01f, -4.18912768e-01f, -4.07108635e-01f, -2.56347060e-01f,
  8.02728355e-01f, 5.49350679e-01f, 4.85577315e-01f, 1.71992719e-01f, 3.44450593e-01f, 7.37174511e-01f, 5.32029212e-01f, 4.15424824e-01f, -6.12983584e-01f, 9.23077166e-02f,
  5.52065559e-02f, 7.16577023e-02f, 7.60847449e-01f, 2.25800276e-01f, -8.60233307e-02f, -2.25113705e-01f, -1.78273320e-01f, -6.31164730e-01f, 1.13329096e-02f, 1.82234809e-01f,
  -2.09081814e-01f, 2.11311400e-01f, 6.46655679e-01f, 6.94375336e-01f, -4.64660764e-01f, 6.96028650e-01f, -5.38013875e-01f, -3.39136183e-01f, 5.45107484e-01f, 7.20196543e-03f,
  -5.08708805e-02f, 8.11317414e-02f, -3.51776958e-01f, -8.85402501e-01f, -1.64411992e-01f, 2.66581595e-01f, 7.29535297e-02f, 2.14613840e-01f, -1.91415057e-01f, 6.68289185e-01f,
  -4.94978487e-01f, 2.48998120e-01f, -1.19509138e-01f, -8.98970544e-01f, 2.76056737e-01f, -2.25013927e-01f, -3.44776601e-01f, -8.55429843e-02f, -3.05912048e-02f, -1.89505115e-01f,
  6.29791766e-02f, 2.77860284e-01f, 3.24883759e-01f, 6.22201860e-01f, -1.79812945e-02f, 8.96087110e-01f, -7.54863024e-01f, -3.45107973e-01f, 3.14315647e-01f, -1.04304814e+00f,
  -3.14799041e-01f, -4.80769306e-01f, 1.45840734e-01f, 8.00930202e-01f, 4.04748112e-01f, 8.70710969e-01f, 1.67760938e-01f, 8.79141450e-01f, 5.63405156e-01f, -1.34130687e-01f,
  4.82033551e-01f, 3.21403891e-01f, 6.80323899e-01f, -5.68282962e-01f, 3.84884953e-01f, -3.18417847e-01f, 5.92721283e-01f, 1.27552032e-01f, -2.03177750e-01f, 3.12467933e-01f,
  -1.17883189e-02f, 7.18478709e-02f, 2.54181679e-02f, 4.57426161e-01f, -4.69559550e-01f, -3.62463981e-01f, 3.57836604e-01f, 2.18683630e-01f, -6.22179031e-01f, 6.31740093e-01f,
  1.28982291e-01f, 8.44741285e-01f, 5.59267342e-01f, 6.35465205e-01f, 6.57183051e-01f, 1.52204558e-01f, 3.43122512e-01f, -1.51318371e-01f, -2.92994399e-02f, 8.46431106e-02f,
  -2.53108174e-01f, -2.93422163e-01f, 6.78399146e-01f, -3.74113739e-01f, -4.92634505e-01f, 3.94910276e-01f, 2.14247048e-01f, 4.34636086e-01f, -2.66909152e-01f, 4.39603269e-01f,
  3.64961505e-01f, 2.39597976e-01f, 2.57010996e-01f, 5.29712260e-01f, 9.19686377e-01f, -4.97534007e-01f, 7.46678054e-01f, 6.31764054e-01f, -3.98886025e-01f, -3.64783138e-01f,
  2.57683307e-01f, 5.65860160e-02f, 3.20755765e-02f, 9.17339146e-01f, 4.00397718e-01f, 3.94471914e-01f, 6.46352291e-01f, 4.28710490e-01f, 7.29527056e-01f, 5.42690158e-01f,
  3.33926946e-01f, -3.17000076e-02f, -1.65874019e-01f, -6.69874996e-03f, 7.77520299e-01f, -6.01001441e-01f, 7.37495005e-01f, -4.36718129e-02f, -2.17054263e-01f, 4.76240851e-02f,
  4.92511541e-01f, 7.60408223e-01f, 8.29109550e-01f, 6.21656299e-01f, -6.63614392e-01f, -8.59519958e-01f, -1.93453163e-01f, 6.13775015e-01f, 2.35569105e-01f, -2.13855177e-01f,
  3.27285886e-01f, 9.35299024e-02f, -2.49202531e-02f, -1.38287261e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.52963931e-02f, -1.44514292e-01f, 2.68248059e-02f, 3.37974906e-01f, 9.51097012e-02f, 1.67517867e-02f, -2.61749327e-01f, 1.68950319e-01f, 6.17989719e-01f, 5.29951930e-01f,
  -3.41724716e-02f, 2.68343892e-02f, 1.24684103e-01f, -2.91766196e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  5.02663434e-01f, -8.72638524e-02f, -8.40729952e-01f, 2.70983219e-01f, -4.75278109e-01f, -9.06139314e-01f, -1.22374848e-01f, -4.20283109e-01f, -3.30691822e-02f, -4.22792047e-01f,
  6.31737471e-01f, -5.36381185e-01f, -7.91096389e-01f, 1.58418283e-01f, 6.33862436e-01f, -7.68857837e-01f, 3.03071618e-01f, -6.86530113e-01f, -4.95480031e-01f, -4.18519229e-02f,
  2.67034799e-01f, 8.22545588e-02f, 3.95494342e-01f, -1.12329733e+00f, -8.13372076e-01f, 3.70957077e-01f, 3.34772527e-01f, -4.46258128e-01f, -9.96022463e-01f, 3.66828203e-01f,
  -4.61943924e-01f, -1.93448067e-01f, 1.57799274e-01f, 3.64470601e-01f, -2.79180735e-01f, -2.07402289e-01f, -3.76462229e-02f, 1.77951232e-01f, 4.25638646e-01f, 3.22753757e-01f,
  1.48275226e-01f, 4.58291918e-01f, 1.20362118e-02f, -2.96290293e-02f, -5.99471450e-01f, -5.82740903e-01f, -1.91967934e-01f, -6.05886638e-01f, 8.91072452e-02f, -8.97443965e-02f,
  -4.61976200e-01f, 1.73876241e-01f, 4.12258297e-01f, -6.42856896e-01f, -8.11966419e-01f, -1.20864496e-01f, -2.50960290e-01f, -4.14441496e-01f, 4.35797185e-01f, -1.86094314e-01f,
  -2.79661506e-01f, -2.58205205e-01f, 1.68491751e-02f, 5.35663009e-01f, -2.84602433e-01f, 6.82710767e-01f, -7.59536982e-01f, 1.18744910e-01f, -2.27209345e-01f, 1.08929239e-01f,
  1.89778820e-01f, -3.00878465e-01f, -7.60594964e-01f, -1.37363464e-01f, 5.16299248e-01f, 5.46734512e-01f, 3.06098014e-01f, -5.48765838e-01f, 1.80773705e-01f, -6.96995258e-02f,
  -4.47609961e-01f, -4.06401038e-01f, 3.65109444e-01f, 1.19712174e-01f, -2.08757728e-01f, 2.70054251e-01f, 4.02820520e-02f, -6.07773423e-01f, -4.96682972e-01f, -3.62512499e-01f,
  -2.53410518e-01f, -4.96888548e-01f, -2.67581522e-01f, 4.64590758e-01f, 3.77496898e-01f, -7.34944046e-01f, 2.49237478e-01f, -8.00695956e-01f, 1.45393789e-01f, -6.02917969e-01f,
  2.28013188e-01f, 4.54851240e-01f, -6.79122061e-02f, 1.28441602e-01f, 3.84176403e-01f, -5.37043475e-02f, -7.79440224e-01f, 3.24486166e-01f, -8.97823423e-02f, 3.89180332e-02f,
  -3.97763290e-02f, -6.76618874e-01f, 1.11415066e-01f, 2.07130715e-01f, 3.97767067e-01f, 4.56370637e-02f, 3.20101708e-01f, -9.03971344e-02f, -7.88476706e-01f, -5.64259648e-01f,
  -3.02779168e-01f, -3.62225264e-01f, -5.27969718e-01f, -5.08476555e-01f, 7.55125564e-03f, 4.06444609e-01f, 1.22819602e-01f, 4.43285048e-01f, 8.35914388e-02f, -2.42882192e-01f,
  9.43988115e-02f, -4.22354996e-01f, 4.44278866e-01f, -9.56021786e-01f, 2.36927927e-01f, -6.71706647e-02f, 5.01727998e-01f, 4.14416581e-01f, -2.80735135e-01f, -3.58751476e-01f,
  -3.35676044e-01f, 2.07812637e-01f, -9.22178984e-01f, -2.90269196e-01f, 2.02943593e-01f, 1.47813141e-01f, -2.67222282e-02f, 2.73045868e-01f, -1.12214756e+00f, 3.73212248e-01f,
  -2.19836012e-01f, 1.81759939e-01f, -3.98359746e-01f, -6.41039729e-01f, -1.03737116e+00f, -1.37706231e-02f, 4.41676408e-01f, -3.66571844e-02f, 4.49660331e-01f, -2.04185188e-01f,
  -6.00230575e-01f, 1.87064230e-01f, -2.60780871e-01f, -3.48625422e-01f, 1.18399665e-01f, -5.67607939e-01f, -2.90577918e-01f, 2.55292267e-01f, 4.44160938e-01f, 5.39981127e-01f,
  1.12487048e-01f, 3.90739828e-01f, -2.20706820e-01f, -9.23188090e-01f, -6.25933528e-01f, 3.90284210e-01f, -3.36492777e-01f, 1.40329704e-01f, -2.17322186e-02f, -3.01954783e-02f,
  -3.42722446e-01f, -4.82863970e-02f, -4.07369375e-01f, 2.02869892e-01f, 3.71679187e-01f, 1.46689385e-01f, -5.22811592e-01f, 2.05574289e-01f, 3.82666469e-01f, -6.23840570e-01f,
  2.55819291e-01f, 5.05909741e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.13791013e-01f, 6.17367364e-02f, -2.50010997e-01f, -2.07529590e-01f, 4.29742970e-03f, -2.19383568e-01f, 3.22130173e-01f, -1.08631589e-02f, -2.78822243e-01f, 2.82734390e-02f,
  1.43968999e-01f, -2.68438190e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    