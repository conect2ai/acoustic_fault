/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.95180893e-01f, -1.07803874e-01f, -2.82268170e-02f, -3.27057987e-02f, -1.24374129e-01f, 7.85301328e-02f, 9.36853364e-02f, -1.78383574e-01f, -1.10257760e-01f, -1.33255288e-01f,
  3.48071493e-02f, 8.70724693e-02f, -2.80076936e-02f, 1.47028014e-01f, 2.37513006e-01f, 5.82081452e-02f, 6.92802295e-02f, 6.40090406e-02f, -1.42491441e-02f, -7.28205964e-02f,
  6.48679882e-02f, 6.25382960e-02f, 1.22487999e-01f, 2.70950161e-02f, -5.54188602e-02f, -3.06001026e-02f, 1.23509648e-03f, -2.22745780e-02f, 4.84787300e-03f, 1.08226679e-01f,
  1.46484405e-01f, -2.49292539e-03f, -3.51429507e-02f, 3.92417721e-02f, -5.11393696e-02f, 3.73159871e-02f, -6.93422779e-02f, 8.40603709e-02f, 2.18396261e-02f, -4.54892404e-02f,
  -3.83230075e-02f, 2.50035040e-02f, 1.40889091e-02f, -6.71844557e-02f, -6.77944273e-02f, 3.03072333e-02f, 1.35415345e-02f, 2.30138209e-02f, -9.50320885e-02f, 1.42055480e-02f,
  -3.13148387e-02f, 2.33228598e-02f, -2.14895494e-02f, -4.98350821e-02f, -5.37241809e-02f, 3.14429291e-02f, -1.16695026e-02f, -1.31837307e-02f, 1.75913400e-03f, -2.29983609e-02f,
  -5.64601757e-02f, -3.27411704e-02f, -2.15039728e-03f, 1.94778666e-02f, 2.59457789e-02f, -3.78418081e-02f, 5.23890778e-02f, 2.83968784e-02f, 9.94833373e-03f, -1.26684960e-02f,
  -3.14904861e-02f, 3.44253033e-02f, -9.75328218e-03f, -4.78313044e-02f, 8.90503079e-03f, 6.15745923e-03f, -2.85559408e-02f, 2.18694415e-02f, -8.40498358e-02f, -6.02374859e-02f,
  3.09384931e-02f, -2.36466546e-02f, -5.54260164e-02f, 1.67235509e-02f, 1.80711113e-02f, -5.67154866e-03f, -1.38601400e-02f, -2.53799465e-02f, -1.40537079e-02f, 7.48732314e-03f,
  -1.36397853e-01f, -2.06676662e-01f, -1.12956418e-02f, -1.14074163e-02f, 1.69932179e-03f, -4.98113083e-03f, 2.02803500e-02f, -6.28223270e-02f, 3.92815284e-02f, -3.21043842e-02f,
  -2.43358891e-02f, 2.25006114e-03f, -5.91719896e-02f, 9.05950889e-02f, 1.64009649e-02f, -8.10579583e-02f, 1.66740511e-02f, 2.89053787e-02f, -3.63497548e-02f, 2.09229868e-02f,
  -3.35808434e-02f, -1.13652227e-02f, 6.25508744e-03f, 4.83644521e-03f, 4.33123671e-02f, -6.10807240e-02f, -3.29993921e-03f, 1.71518512e-02f, -2.99116354e-02f, 2.34388076e-02f,
  7.79938698e-02f, -1.49729978e-02f, 8.32320377e-02f, 1.85240731e-01f, 4.16866317e-02f, -9.59056839e-02f, -1.47607431e-01f, 1.06417440e-01f, 5.02006933e-02f, -8.92886147e-02f,
  -3.76953222e-02f, 2.28685513e-02f, -1.74121365e-01f, 1.00062611e-02f, -9.60581377e-02f, -1.08440489e-01f, 1.05506539e-01f, 5.32962894e-03f, 1.15017049e-01f, 7.79765397e-02f,
  4.49779443e-02f, -3.97696868e-02f, 5.08421883e-02f, 2.87644863e-02f, 1.14468217e-01f, 1.37484327e-01f, 1.33051261e-01f, 1.20753683e-02f, -2.64458936e-02f, -6.18405268e-02f,
  4.83944900e-02f, -6.14806525e-02f, 5.48874661e-02f, -4.24869768e-02f, 1.13877626e-02f, 2.50930302e-02f, -3.62400897e-02f, 1.77358352e-02f, 1.30315395e-02f, -5.64279407e-02f,
  1.36724683e-02f, -5.38521586e-03f, -3.39377075e-02f, -7.42225349e-02f, -2.44773589e-02f, 9.78132337e-02f, 8.87288675e-02f, 6.76868996e-03f, 5.99374995e-02f, -6.29950687e-02f,
  -2.21568393e-03f, -4.62442078e-02f, -1.96725642e-03f, -6.23886194e-03f, 3.96818891e-02f, 5.85805215e-02f, -6.48629069e-02f, -5.03641926e-02f, -1.85284019e-02f, 3.27340811e-02f,
  9.34635568e-03f, -1.59811042e-02f, -6.53663501e-02f, -4.21558544e-02f, -8.46156757e-03f, 8.72946065e-03f, -1.02323992e-02f, 3.57560515e-02f, 6.04259633e-02f, 2.04342771e-02f,
  5.86189032e-02f, 6.02371097e-02f, 5.98770753e-02f, -7.11402297e-02f, 6.13817275e-02f, 4.09770720e-02f, 2.25637332e-02f, -4.33778204e-03f, 1.20832808e-02f, 8.28144848e-02f,
  4.34267186e-02f, 4.52482654e-03f, 2.93207578e-02f, 9.52130407e-02f, 1.31392451e-02f, -2.61033652e-03f, 1.71950441e-02f, -5.68476208e-02f, 2.63246335e-02f, 6.18310012e-02f,
  -6.11873679e-02f, -8.16864818e-02f, -4.98114228e-02f, -2.94025484e-02f, -1.35764396e-02f, -4.60914075e-02f, -6.82941154e-02f, -3.39331999e-02f, 1.38483569e-03f, 1.24089345e-02f,
  -1.43173675e-04f, 4.49867919e-02f, -4.88344431e-02f, 4.94810715e-02f, 3.45711433e-03f, 1.78880244e-02f, -1.59183983e-02f, -1.35564236e-02f, -1.15642534e-03f, 3.26742008e-02f,
  2.27916706e-02f, -3.98488045e-02f, -2.53024772e-02f, 4.80928607e-02f, 2.80206576e-02f, -4.83752374e-04f, 3.10394652e-02f, 3.87922525e-02f, -7.38819018e-02f, 5.53752556e-02f,
  -2.23213032e-01f, -1.26008410e-02f, -3.41278166e-02f, -1.22710548e-01f, -1.21431150e-01f, 7.64493719e-02f, 2.12078448e-02f, -1.19004689e-01f, -1.83324113e-01f, 2.61861831e-02f,
  -2.62645446e-02f, 1.91455055e-02f, 1.49191946e-01f, -3.26024070e-02f, 8.11920166e-02f, 1.50978610e-01f, -1.22843705e-01f, -1.10211715e-01f, -5.50603308e-02f, -9.01928768e-02f,
  -5.83875626e-02f, 4.87570502e-02f, 1.62492260e-01f, -4.90508880e-03f, -3.34598916e-03f, 2.18535718e-02f, 7.96139538e-02f, 2.66953986e-02f, -4.06540744e-02f, 4.24986258e-02f,
  -1.58817351e-01f, -1.96555257e-01f, 3.10554579e-02f, -1.23036705e-01f, -1.38957918e-01f, 5.53897917e-02f, 1.41110166e-03f, 1.19380914e-01f, 8.38847980e-02f, -8.21741577e-03f,
  9.83122885e-02f, 3.13019417e-02f, 1.10073918e-02f, -7.93050155e-02f, -4.82469834e-02f, -8.99857953e-02f, 9.03251767e-02f, 2.09047049e-02f, 6.68734014e-02f, 7.30475783e-02f,
  4.68494892e-02f, 1.82155357e-03f, -2.30484046e-02f, -2.00245157e-02f, -2.02778708e-02f, 2.59645912e-03f, 7.53506497e-02f, 8.39895085e-02f, -4.14557680e-02f, -3.09935063e-02f,
  -6.33779690e-02f, -1.38355121e-02f, -2.77615935e-02f, -3.12077235e-02f, -2.17140000e-02f, 4.24517430e-02f, -3.64211090e-02f, -3.88290398e-02f, -1.75727513e-02f, 5.34457825e-02f,
  -6.65851533e-02f, -3.87697816e-02f, -1.57052688e-02f, -1.11110797e-02f, 3.37983482e-02f, -2.00717766e-02f, -3.05414125e-02f, -5.66367172e-02f, 1.96768381e-02f, -4.71547432e-02f,
  1.66019164e-02f, -7.66559094e-02f, -7.73948878e-02f, -1.13291517e-02f, -4.24617119e-02f, 3.03283427e-02f, -4.75841835e-02f, -1.17153963e-02f, 3.17412689e-02f, -6.74528256e-02f,
  -1.86124325e-01f, -2.25036010e-01f, -8.32858146e-04f, -8.11537653e-02f, 3.74895670e-02f, -3.57765406e-02f, 2.10622270e-02f, 3.53503157e-04f, -1.25924364e-01f, -6.65585473e-02f,
  -4.75704893e-02f, -1.30186351e-02f, 1.98321715e-02f, -6.98657567e-03f, 6.25633402e-04f, 7.18460381e-02f, -5.00449948e-02f, -1.32272184e-01f, -3.98343876e-02f, 7.42308237e-03f,
  -7.82400966e-02f, -1.53554389e-02f, 6.02007806e-02f, -2.98698414e-02f, 6.21157046e-03f, 4.56409790e-02f, -8.39874893e-02f, 1.55292759e-02f, 6.28915355e-02f, -2.85671721e-03f,
  -6.41756803e-02f, 1.70551687e-01f, 7.52883554e-02f, 5.78283891e-03f, -1.95260033e-01f, -7.43931383e-02f, 6.23771586e-02f, -1.24250844e-01f, -1.78667661e-02f, 5.61751686e-02f,
  -3.21617499e-02f, 1.55259773e-01f, 1.07922487e-01f, 5.29336520e-02f, -1.33839503e-01f, 1.41699150e-01f, -1.33194355e-02f, 8.55639055e-02f, -1.69596337e-02f, -8.13980475e-02f,
  -1.93150282e-01f, -2.52833962e-01f, -5.49588688e-02f, -1.44923881e-01f, -2.83221202e-03f, -4.18531075e-02f, -1.81387573e-01f, -9.38279647e-03f, 3.18787340e-03f, 5.09651452e-02f,
  1.15630202e-01f, -1.51347844e-02f, 1.01185076e-01f, 2.19005570e-02f, -2.39454173e-02f, -7.81367272e-02f, 8.87064561e-02f, 9.09137446e-03f, -7.91576430e-02f, 7.19193816e-02f,
  2.95037646e-02f, 6.42433465e-02f, -3.85309346e-02f, 5.32904789e-02f, -5.67864217e-02f, 1.02758773e-01f, -1.10565173e-02f, 3.59615646e-02f, 1.40968310e-02f, 8.86536986e-02f,
  1.62539575e-02f, 7.58373439e-02f, -1.50598120e-02f, -2.34201681e-02f, -5.40150702e-02f, -6.86933426e-03f, -8.33530128e-02f, -5.38281277e-02f, 1.57359075e-02f, -5.09624779e-02f,
  -4.05404158e-02f, -1.10077947e-01f, 5.02119884e-02f, 2.65927725e-02f, 3.72311585e-02f, -8.22922364e-02f, 2.74319686e-02f, 2.08227173e-03f, -7.65867978e-02f, -7.14127999e-03f,
  1.30918389e-02f, 2.06275284e-02f, 4.45421450e-02f, -4.46391888e-02f, -1.05818406e-01f, 6.14831820e-02f, -4.34416495e-02f, -6.05936572e-02f, -5.17662019e-02f, 6.91809729e-02f,
  -4.70609590e-02f, -8.88472237e-03f, -3.38340849e-02f, 1.64667889e-02f, 7.39777684e-02f, -2.43621171e-02f, -2.42326260e-02f, 9.31990072e-02f, 4.79553267e-02f, -1.31168198e-02f,
  -8.80100802e-02f, -8.54273811e-02f, -2.14392226e-02f, 1.34209162e-02f, 4.92873713e-02f, 2.67729741e-02f, -5.12487963e-02f, 5.23909181e-02f, -3.44973430e-02f, 7.60077760e-02f,
  -4.82498221e-02f, -3.45112346e-02f, -1.65481493e-02f, 5.44042960e-02f, -6.50797337e-02f, -7.52026215e-02f, -6.81011826e-02f, -9.36722010e-02f, -3.96967232e-02f, 1.86292306e-02f,
  -2.95267981e-02f, 1.36962859e-02f, -1.94123145e-02f, -9.61797237e-02f, -8.70316476e-02f, -5.34779653e-02f, -1.02326393e-01f, -7.43112266e-02f, 6.81821257e-02f, -3.97616029e-02f,
  2.12318520e-03f, 2.74215400e-01f, -1.93967149e-02f, 1.08364627e-01f, -8.13370124e-02f, -1.90736547e-01f, -9.63916257e-02f, -1.85764842e-02f, -1.65739462e-01f, 7.05496222e-02f,
  -9.45874527e-02f, 2.38896459e-01f, -1.24974206e-01f, 5.74854687e-02f, -2.38468394e-01f, -6.07893243e-03f, -2.20321007e-02f, 8.07906315e-03f, 4.66604456e-02f, 7.57134929e-02f,
  -1.77241047e-03f, 2.67567243e-02f, 6.15021400e-03f, 1.28521949e-01f, 8.82189795e-02f, 3.28324139e-02f, 2.24987287e-02f, -4.91047911e-02f, 1.03390120e-01f, -4.00473215e-02f,
  9.83530208e-02f, -1.93578878e-03f, 7.61013031e-02f, 5.06146401e-02f, -1.38749797e-02f, -9.41188261e-02f, 2.86478698e-02f, 3.08698579e-03f, -1.11480482e-01f, 2.46680770e-02f,
  1.56513788e-02f, -3.79606858e-02f, 3.31888013e-02f, -8.41883570e-02f, -7.01051876e-02f, 2.90686879e-02f, -3.63745354e-02f, -7.53081515e-02f, 1.08921183e-02f, -3.69281061e-02f,
  8.35355818e-02f, -4.59390171e-02f, 2.57027782e-02f, 3.00486246e-03f, -2.27223225e-02f, -1.00216515e-01f, -1.59961805e-02f, -2.10484825e-02f, 1.15659870e-02f, 2.05323286e-02f,
  -6.25918806e-02f, -8.22418779e-02f, 9.38901678e-02f, -2.00999063e-02f, 1.36683241e-01f, -3.15992273e-02f, 5.26139922e-02f, 4.84786220e-02f, 4.13998067e-02f, 5.30594364e-02f,
  3.00233271e-02f, 1.53812943e-02f, -4.89337854e-02f, 4.63197790e-02f, -9.52446088e-03f, 4.88603599e-02f, -4.59379517e-02f, 7.37453029e-02f, 3.78279336e-04f, 1.67874675e-02f,
  1.82379433e-03f, -4.09843959e-02f, 3.29124765e-03f, -1.32361604e-02f, 3.68077941e-02f, 2.69470233e-02f, -1.72423255e-02f, -6.05092198e-03f, -7.23247603e-02f, 1.14344098e-02f,
  8.54113474e-02f, 1.39793726e-02f, -3.49381715e-02f, 4.10531163e-02f, 5.67899346e-02f, -1.30429398e-02f, 2.53135581e-02f, 4.19608643e-03f, 3.88772711e-02f, -4.92714010e-02f,
  -7.34932870e-02f, 2.53810864e-02f, 6.08214773e-02f, -1.59389223e-04f, 6.57328367e-02f, 6.12010956e-02f, 1.43022873e-02f, 1.53745245e-02f, -2.18876544e-02f, -1.16915433e-02f,
  -4.88908552e-02f, 1.36928707e-02f, -3.06620356e-02f, 2.48579606e-02f, 2.44505592e-02f, 8.05220660e-03f, -2.63923667e-02f, 5.26516291e-04f, 8.96693114e-03f, -7.05135940e-03f,
  -1.08030304e-01f, 4.48582470e-02f, -7.81485587e-02f, -2.31893975e-02f, -7.65133724e-02f, 7.04122484e-02f, 7.94095099e-02f, -5.24078049e-02f, 2.04245687e-01f, 5.79283871e-02f,
  -1.23662697e-02f, -5.60217910e-02f, 1.37681097e-01f, 1.31633818e-01f, 8.73948485e-02f, 1.23781860e-01f, 1.52414501e-01f, 7.94165879e-02f, 8.55474919e-02f, 4.11837399e-02f,
  -2.31229402e-02f, 4.61885296e-02f, -1.29426226e-01f, -1.09224685e-01f, -1.05960920e-01f, -2.56019831e-01f, -2.05152601e-01f, -1.12418585e-01f, -1.60730213e-01f, -1.99519172e-02f,
  8.93382803e-02f, 6.95357174e-02f, 3.92019302e-02f, -7.60219097e-02f, 3.58186103e-02f, -3.90128262e-04f, -7.27852434e-02f, -7.29717761e-02f, -7.44340336e-03f, 2.09445646e-03f,
  -2.72626858e-02f, 3.45725343e-02f, 1.29668722e-02f, -4.24055979e-02f, 3.94297764e-02f, -5.24173342e-02f, 6.25457019e-02f, -3.92438844e-02f, 3.72929610e-02f, 6.71207160e-02f,
  4.13071662e-02f, 1.02264388e-02f, 7.69261420e-02f, -5.48788719e-02f, -5.52968793e-02f, -5.08156009e-02f, -6.77141082e-03f, -8.56996253e-02f, -1.18248714e-02f, 5.75355301e-03f,
  7.80920964e-03f, 2.85222835e-04f, 1.42276930e-02f, 8.99840239e-03f, 6.80703595e-02f, 4.87031303e-02f, 1.16543666e-01f, 1.20686237e-02f, 5.93321724e-03f, 6.99467957e-02f,
  -6.73031062e-02f, -2.87525868e-03f, 1.06053008e-02f, 2.86298953e-02f, -4.53082211e-02f, 1.52926811e-03f, -5.92019930e-02f, -1.42891053e-02f, -1.27914622e-01f, -3.82019058e-02f,
  -1.65344905e-02f, 3.63795757e-02f, -3.48125696e-02f, -1.47706140e-02f, 5.82435764e-02f, -7.91174918e-02f, 6.42299978e-03f, -7.17450231e-02f, 5.29269762e-02f, -1.00113908e-02f,
  1.15218642e-03f, 5.11996895e-02f, -2.87184156e-02f, -3.06157898e-02f, -2.26456788e-03f, -3.63965258e-02f, 3.57866175e-02f, -4.65042070e-02f, 2.23300494e-02f, 3.70845199e-02f,
  -6.36155084e-02f, -1.62888486e-02f, 1.86667796e-02f, 2.43284926e-02f, 2.75408514e-02f, -1.69037934e-02f, -6.87599108e-02f, -7.72128925e-02f, -4.64034230e-02f, -6.33976758e-02f,
  -1.06892027e-01f, -3.62232588e-02f, -5.09473272e-02f, -5.46694547e-03f, -5.54077365e-02f, 4.17939201e-03f, 5.08227125e-02f, 1.77721754e-02f, -2.50333808e-02f, -1.60847437e-02f,
  -1.33037260e-02f, 7.33176544e-02f, 7.17249587e-02f, -1.37923276e-02f, -5.63220717e-02f, 9.68587473e-02f, -6.57282323e-02f, 4.46519479e-02f, 1.09798729e-01f, -1.23875991e-01f,
  -5.43102659e-02f, 6.52366281e-02f, -4.95291241e-02f, 2.42692139e-02f, -1.52164534e-01f, -8.91651809e-02f, -6.84217364e-02f, 4.17807959e-02f, 4.80068065e-02f, -1.12033062e-01f,
  1.08806968e-01f, -2.16188923e-01f, 1.80526040e-02f, -3.92620228e-02f, 6.89884275e-02f, 8.33474919e-02f, -2.23536998e-01f, -2.44759489e-03f, 6.68584332e-02f, -3.79805453e-02f,
  -1.18788742e-01f, -4.83336858e-02f, 1.17511526e-01f, 1.22517925e-02f, 1.82020422e-02f, -4.42011505e-02f, 2.15671398e-03f, 6.60228208e-02f, -2.50141565e-02f, 5.40938228e-02f,
  7.42982328e-02f, -5.34578487e-02f, 4.57381532e-02f, -3.20271924e-02f, 1.62974130e-02f, 3.54299024e-02f, 5.97915836e-02f, 1.09557778e-01f, 2.75660921e-02f, -3.42905149e-03f,
  1.07439056e-01f, 9.11517218e-02f, 3.61882336e-02f, 5.07967547e-03f, -2.20202450e-02f, -1.14537654e-02f, -1.71655975e-02f, 5.57374507e-02f, 8.30457956e-02f, 5.88821210e-02f,
  6.95549324e-02f, -5.61745763e-02f, 7.62514770e-02f, -2.36120522e-02f, 1.65072823e-04f, 1.33497790e-02f, -3.05058854e-03f, -1.81730650e-02f, 9.64191370e-03f, -5.61568812e-02f,
  -4.87059131e-02f, 1.99471582e-02f, -4.73878123e-02f, 1.69579836e-03f, -6.96142688e-02f, -8.75756592e-02f, 2.66228858e-02f, 2.01125983e-02f, 6.73852563e-02f, -4.65393476e-02f,
  2.53016837e-02f, -2.06172280e-02f, 4.67138290e-02f, -6.08563907e-02f, 3.84246856e-02f, -1.19437454e-02f, 1.60186260e-03f, 7.07961544e-02f, 3.13635841e-02f, -4.71442305e-02f,
  -1.39521047e-01f, -2.16825321e-01f, -3.36189494e-02f, -2.46689543e-02f, -7.90940151e-02f, 1.69281997e-02f, 1.30539434e-02f, 1.68946628e-02f, -8.16292390e-02f, 2.08234694e-02f,
  9.69497778e-04f, 2.71280743e-02f, -1.09804645e-02f, 6.11362532e-02f, 3.61221246e-02f, -1.23447096e-02f, -1.10614903e-01f, 5.90570178e-03f, -8.45795646e-02f, 2.90706335e-03f,
  2.85615698e-02f, -1.00529619e-01f, -4.02069613e-02f, -5.73312826e-02f, 1.30683985e-02f, -1.68365110e-02f, 3.31908762e-02f, 3.29502523e-02f, 2.27884017e-02f, -3.06107979e-02f,
  -2.09125638e-01f, -1.37438908e-01f, -6.75178468e-02f, -1.09220885e-01f, -1.35846362e-01f, 3.79871428e-02f, 2.30786484e-02f, -8.25751945e-03f, -3.61490622e-02f, 3.65435183e-02f,
  8.32642913e-02f, -1.09056808e-01f, 1.63151771e-01f, -8.86312053e-02f, -3.29857320e-02f, 1.04641058e-01f, -1.83960393e-01f, -6.89541027e-02f, 7.35529587e-02f, -9.72518846e-02f,
  3.02939350e-03f, -9.71018076e-02f, 8.69680475e-03f, -7.22596422e-02f, -1.36524498e-01f, 5.04166670e-02f, -4.58409749e-02f, 6.21890724e-02f, 1.70338079e-02f, 4.26033065e-02f,
  -2.43299603e-02f, 8.82974789e-02f, 3.82798873e-02f, -3.67426015e-02f, -1.03795296e-02f, -1.23976020e-03f, -3.57985459e-02f, 7.54717588e-02f, 3.76059674e-02f, 2.95321066e-02f,
  3.52298543e-02f, -7.33931586e-02f, 5.52140102e-02f, -4.55558263e-02f, 8.51231068e-03f, 3.46187614e-02f, -7.01460689e-02f, -6.28608912e-02f, -1.28722759e-02f, -1.05845764e-01f,
  2.49540079e-02f, -6.63708821e-02f, -6.75993636e-02f, -1.34217050e-02f, -1.97390933e-02f, 2.83951107e-02f, -6.01338185e-02f, -3.33802663e-02f, -6.34379536e-02f, -5.43892458e-02f,
  5.34187034e-02f, 3.56198177e-02f, 1.78147629e-02f, -1.15116294e-02f, -7.80601148e-03f, -1.20798796e-02f, -1.58348680e-03f, 6.51617125e-02f, 3.04045565e-02f, -5.33600571e-03f,
  -4.73871715e-02f, 5.00495872e-03f, 2.27741860e-02f, 7.44032580e-03f, -2.65402589e-02f, 2.88299769e-02f, 2.70858780e-02f, 3.45952958e-02f, -1.20593319e-02f, 6.96717352e-02f,
  9.04334113e-02f, -6.88740686e-02f, 5.72344847e-02f, 5.33137172e-02f, 1.15925213e-02f, 5.14065698e-02f, 4.48165201e-02f, 7.31900781e-02f, 7.56512284e-02f, -5.22772968e-03f,
  2.60271262e-02f, -8.46203193e-02f, -2.59675179e-02f, 1.81747489e-02f, -3.79128731e-03f, -9.36759785e-02f, 1.24349082e-02f, -3.55187319e-02f, 5.58661968e-02f, 3.69320400e-02f,
  3.42049748e-02f, -4.89220917e-02f, -4.55541834e-02f, 8.82068463e-03f, 4.48917644e-03f, -5.25580719e-02f, -4.48080041e-02f, 2.56811194e-02f, -1.02513663e-01f, -1.01124831e-02f,
  -5.00279758e-03f, 4.57762294e-02f, -2.17242278e-02f, -4.63083573e-02f, 3.71146873e-02f, 8.82807001e-03f, 1.89200193e-02f, -3.82256918e-02f, 4.87829046e-03f, 4.43474948e-02f,
  2.51553118e-01f, -2.16972321e-01f, -1.04728274e-01f, -1.37057388e-02f, 1.09105431e-01f, 1.85523346e-01f, 2.27081329e-01f, -8.24954733e-02f, 1.03041694e-01f, -3.83164510e-02f,
  6.85054585e-02f, -7.22490549e-02f, -6.13938496e-02f, 6.04399815e-02f, 1.36981010e-01f, -6.38867319e-02f, 1.54224366e-01f, 4.25201878e-02f, 3.17996256e-02f, 1.19969910e-02f,
  4.68033999e-02f, 9.33942869e-02f, -1.07210100e-01f, -3.62579860e-02f, 6.23276606e-02f, -7.28888661e-02f, -4.11506221e-02f, -1.08378902e-01f, -4.41362523e-02f, -5.06063038e-03f,
  3.24843265e-02f, -4.32594083e-02f, 3.67760584e-02f, -9.11892205e-02f, -7.97908055e-04f, 1.83559079e-02f, 1.65302809e-02f, 4.11909856e-02f, -1.34387892e-03f, -6.88228989e-04f,
  2.27374863e-02f, 2.77572535e-02f, 1.21569335e-02f, 4.54855077e-02f, 5.79562522e-02f, -5.04378676e-02f, -6.66673109e-02f, -3.42213623e-02f, -4.78096306e-02f, -4.20968942e-02f,
  -3.02880462e-02f, -8.35869610e-02f, -2.91246315e-03f, -1.19039533e-03f, 5.67693450e-02f, 3.15246433e-02f, 5.65005802e-02f, 1.81544665e-02f, 1.88048948e-02f, 4.13106419e-02f,
  8.33546184e-03f, 1.72558259e-02f, 3.17970216e-02f, -1.20567316e-02f, 1.67237397e-03f, -5.75316288e-02f, -6.08294411e-03f, 1.97326113e-03f, 1.59526523e-02f, -3.64794098e-02f,
  6.35118932e-02f, -4.30244058e-02f, 5.51382266e-02f, -2.51795165e-02f, 1.07430488e-01f, -1.29227182e-02f, -1.43038910e-02f, 2.33184434e-02f, 4.64874543e-02f, 7.32139498e-02f,
  -7.65021741e-02f, 3.71678621e-02f, -8.42478871e-03f, 3.39546278e-02f, -2.28461977e-02f, 7.13611580e-03f, -4.61685322e-02f, 2.32909899e-02f, -4.48604207e-03f, 8.39253888e-02f,
  -6.59430251e-02f, -2.45123189e-02f, 8.66630301e-03f, 7.08796531e-02f, -5.84882051e-02f, -7.56749976e-03f, 2.37817131e-02f, -2.16110386e-02f, 9.38869268e-03f, -2.02165302e-02f,
  2.58409381e-02f, 3.68168503e-02f, 8.12966377e-02f, -1.75099261e-02f, 3.60220633e-02f, 7.05362782e-02f, 6.33844640e-03f, -2.39162450e-03f, 3.04377694e-02f, -4.27214764e-02f,
  2.63276342e-02f, 2.57440805e-02f, 8.55259895e-02f, -2.81523373e-02f, -2.88793147e-02f, 2.98252255e-02f, -3.02214082e-02f, -3.35421041e-02f, 2.89068632e-02f, -5.48801050e-02f,
  -8.10237750e-02f, 1.39862031e-01f, -7.90369213e-02f, 7.50847012e-02f, -1.63717121e-01f, -1.17545500e-01f, 8.49968120e-02f, -1.79320555e-02f, 1.56809330e-01f, 1.76350266e-01f,
  5.68977445e-02f, 1.46575933e-02f, 1.32228941e-01f, 4.65736911e-02f, -2.17373725e-02f, 1.56742439e-01f, 2.62504956e-03f, 5.44990972e-02f, -1.67883672e-02f, -4.05653119e-02f,
  -5.19427508e-02f, 4.27046195e-02f, -1.90837726e-01f, -9.91326291e-03f, -9.22790244e-02f, -3.68133634e-02f, -2.22034268e-02f, -5.15832491e-02f, -5.33987917e-02f, 1.36029888e-02f,
  -1.02289356e-01f, 1.26194194e-01f, -2.28545498e-02f, 2.84820087e-02f, -1.82920229e-02f, -1.07386567e-01f, 2.64665522e-02f, 2.34710108e-02f, -6.66472837e-02f, -2.04577222e-02f,
  5.29161207e-02f, -5.49939126e-02f, 2.57524922e-02f, -6.51003867e-02f, -2.81028100e-04f, -1.02956640e-02f, 1.51927555e-02f, -4.80907783e-02f, -4.64315973e-02f, 1.35433087e-02f,
  -6.80523813e-02f, -1.08788505e-01f, 5.42334579e-02f, 6.48356183e-03f, -4.36077900e-02f, 6.20024577e-02f, -7.41123874e-03f, -5.14169931e-02f, 8.08230266e-02f, 2.72620935e-02f,
  6.66128099e-02f, 8.63399953e-02f, 3.54543105e-02f, 4.98493463e-02f, 7.51214027e-02f, 3.74668874e-02f, 6.29052147e-02f, 8.37989710e-03f, -2.86197234e-02f, -1.35084183e-03f,
  -6.39992533e-04f, 1.07950047e-02f, 4.12033238e-02f, 1.24903936e-02f, -7.70442933e-03f, 2.73285341e-02f, -2.90807988e-02f, 3.81340645e-03f, -9.12195258e-03f, -1.98567640e-02f,
  1.10714450e-01f, 4.76731956e-02f, 4.09659110e-02f, 6.67223334e-02f, 3.15408446e-02f, -4.43905070e-02f, 8.07211250e-02f, -4.79673147e-02f, 5.77655109e-03f, 2.28288323e-02f,
  8.42629224e-02f, 2.18778715e-01f, -4.45140041e-02f, 5.14513999e-03f, -3.26759070e-02f, 1.70653071e-02f, -8.68672784e-03f, -2.57007498e-02f, 3.91719937e-02f, 2.40664533e-03f,
  -1.02533542e-01f, -1.60410125e-02f, 4.94310260e-02f, 1.31832398e-02f, -1.97794251e-02f, 8.82580504e-02f, 8.41437206e-02f, -4.32390813e-03f, 1.47993378e-02f, 3.36169079e-02f,
  -1.55227957e-03f, 2.57213656e-02f, 4.25615311e-02f, 3.82609735e-03f, 5.49041331e-02f, 4.97693755e-02f, 4.12961990e-02f, -2.68301256e-02f, -6.20726719e-02f, -2.05145814e-02f,
  -1.54134452e-01f, 1.94424577e-02f, 1.27585307e-01f, -1.41466722e-01f, 3.26416343e-02f, -8.79526362e-02f, 9.01375115e-02f, -8.90853852e-02f, 1.06214620e-01f, -5.41485064e-02f,
  -4.29141335e-02f, 8.91585127e-02f, 1.11942083e-01f, -1.39688747e-02f, 1.48514695e-02f, 4.10426669e-02f, -1.17259368e-01f, -4.48940322e-02f, 9.55539644e-02f, -9.89777595e-02f,
  -2.23908632e-04f, -6.86606690e-02f, 5.55976592e-02f, -6.71526715e-02f, -5.85809834e-02f, -5.76885231e-03f, 4.92440909e-02f, 2.00509988e-02f, -8.43745917e-02f, -2.99063325e-02f,
  -9.08070651e-04f, -1.47166504e-02f, 2.09537074e-02f, 7.89146647e-02f, 4.90627205e-03f, -2.84128003e-02f, 1.72579866e-02f, 6.41513318e-02f, -6.52126642e-03f, 5.11011072e-02f,
  3.22850905e-02f, -6.03835136e-02f, -2.24685799e-02f, 5.59545048e-02f, 3.35846618e-02f, 7.48315603e-02f, -2.24390943e-02f, 6.50093630e-02f, -2.14917469e-03f, 3.56927216e-02f,
  3.80511060e-02f, -2.52107009e-02f, 2.58272998e-02f, -2.80646235e-02f, 2.31658518e-02f, 5.62989265e-02f, 5.87211736e-03f, 3.65870036e-02f, -5.36261573e-02f, 4.69317287e-02f,
  9.77854338e-03f, 8.60810578e-02f, -4.91515212e-02f, 3.25498395e-02f, -3.66210286e-03f, -2.42234562e-02f, -7.48760067e-04f, 2.63201166e-03f, 4.94924262e-02f, -5.01972437e-02f,
  -9.52000543e-03f, -4.57615219e-02f, -3.03622428e-02f, 6.97618127e-02f, 9.52529628e-03f, -4.57506552e-02f, 1.44448569e-02f, -7.70800263e-02f, -3.66826467e-02f, -8.09913203e-02f,
  -1.82089992e-04f, -4.41938378e-02f, -4.93466333e-02f, 5.11068106e-02f, 4.80327709e-03f, 8.19438398e-02f, 1.37034552e-02f, 3.63603570e-02f, -6.53566048e-02f, 2.78660972e-02f,
  -1.31755456e-01f, -9.63980705e-02f, 7.90673420e-02f, -4.23956849e-02f, -2.39294618e-02f, 1.50871370e-02f, 4.13257591e-02f, -8.82387161e-03f, 8.19209218e-03f, -6.91023022e-02f,
  -4.83134426e-02f, -1.09875863e-02f, -5.65147810e-02f, 9.06188879e-03f, 9.03154686e-02f, -5.85924229e-03f, 3.09711117e-02f, -8.40765983e-02f, -3.20165381e-02f, -6.12997673e-02f,
  -5.42164557e-02f, 1.19438879e-02f, 1.31280674e-02f, -5.63046383e-03f, 2.61738314e-03f, -3.63824144e-03f, 2.74503846e-02f, 2.45119762e-02f, -3.92672084e-02f, 2.59491783e-02f,
  -1.27883762e-01f, -2.06942230e-01f, -4.26894575e-02f, -1.73767313e-01f, 9.08874348e-02f, 2.54841328e-01f, 1.96654096e-01f, -1.35163926e-02f, -1.31870180e-01f, 4.44155894e-02f,
  1.33508667e-01f, -2.19601750e-01f, 6.49631768e-02f, -9.48791504e-02f, 1.33885160e-01f, 8.27457309e-02f, -7.93486461e-03f, 1.32337157e-02f, -7.00458139e-02f, -1.96172912e-02f,
  -9.50802118e-02f, 1.61542416e-01f, 4.88592405e-03f, 4.98131849e-02f, 4.46552038e-02f, -4.70949076e-02f, 4.03538384e-02f, 3.10695898e-02f, -5.01912972e-03f, 9.08535533e-03f,
  8.70404392e-02f, -8.03046599e-02f, 8.87128804e-03f, 4.95178811e-02f, 9.25167948e-02f, -9.39049001e-04f, 6.94649816e-02f, -2.68279668e-02f, -5.70311537e-03f, 6.03240542e-02f,
  6.34278590e-03f, -1.66028775e-02f, -3.94647084e-02f, -2.88270991e-02f, 4.41940539e-02f, -4.79193330e-02f, -3.43918316e-02f, 7.96177685e-02f, -8.95606354e-02f, 5.61460629e-02f,
  -4.61174734e-03f, -4.68703918e-02f, 3.41860019e-02f, 6.86934516e-02f, -4.83436473e-02f, -5.68762012e-02f, 1.61830112e-02f, -2.34080199e-02f, 3.90293822e-02f, -3.89121398e-02f,
  2.10878681e-02f, -7.90404826e-02f, -2.90180258e-02f, -9.97362211e-02f, 1.93766523e-02f, 5.32180592e-02f, 4.42598341e-03f, 1.04847707e-01f, -9.00848433e-02f, 7.44518042e-02f,
  -1.02528566e-02f, -5.24302982e-02f, -2.87197600e-03f, 8.77657905e-02f, -5.49972169e-02f, 1.16323214e-02f, 3.50651331e-02f, 1.80692580e-02f, -4.29979116e-02f, 1.43047292e-02f,
  4.89320643e-02f, 2.39230674e-02f, 1.23800430e-02f, -5.04802279e-02f, 2.53111385e-02f, -6.81099817e-02f, -1.96061214e-03f, -2.44188923e-02f, -3.21156308e-02f, 3.94518897e-02f,
  1.35489553e-01f, 3.11690010e-02f, -3.90324369e-02f, -2.70593129e-02f, -5.04436940e-02f, -5.47618680e-02f, -6.40097708e-02f, -7.93455634e-03f, -4.37717400e-02f, 4.43890803e-02f,
  4.57467791e-03f, 1.89138930e-02f, 5.88339120e-02f, 4.61535938e-02f, 5.24033792e-02f, 2.89479494e-02f, -8.93948972e-03f, 4.44402844e-02f, 4.10060398e-02f, 1.15672704e-02f,
  1.04850940e-01f, 9.64622200e-02f, -8.63727257e-02f, 5.15386276e-02f, 3.42635736e-02f, 4.10533622e-02f, -2.43976843e-02f, -6.90769553e-02f, 3.73384282e-02f, -4.65328433e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.89403799e-02f, 1.50647193e-01f, 2.62984276e-01f, 3.94815207e-02f, -6.85399026e-02f, -8.50648209e-02f, -7.57891014e-02f, 1.00664593e-01f, -6.26642853e-02f, 9.29479972e-02f,
  -1.35769844e-01f, 1.23451062e-01f, -4.30700593e-02f, 1.78824618e-01f, -2.41434440e-01f, -3.41742150e-02f, -8.12240764e-02f, 1.23591356e-01f, -2.87831742e-02f, 4.41840813e-02f,
  5.18388785e-02f, -1.69441417e-01f, 8.97301286e-02f, -1.14703484e-01f, 1.58651575e-01f, 1.32364318e-01f, -1.05123455e-03f, -7.77876601e-02f, 9.59410444e-02f, -1.20584868e-01f,
  -1.14097282e-01f, 1.16109140e-01f, 9.59814787e-02f, 7.27508217e-02f, 7.81066865e-02f, -3.97301763e-02f, 9.27135199e-02f, -6.50716200e-02f, -8.37126821e-02f, 5.18623926e-02f,
  4.06939387e-02f, -2.54972763e-02f, 6.69487715e-02f, -6.38240427e-02f, 8.31575915e-02f, 8.13542753e-02f, 1.30553439e-01f, 1.51612893e-01f, -7.39161298e-03f, 9.43424627e-02f,
  -1.28845312e-02f, 1.36947617e-01f, 3.03887408e-02f, 8.15465394e-03f, 3.44677307e-02f, 8.62898584e-03f, 3.84867787e-02f, -6.39823778e-03f, 8.16373155e-02f, 6.08508624e-02f,
  4.10409346e-02f, -1.10720269e-01f, -1.02893442e-01f, -4.96582575e-02f, -2.33263783e-02f, 4.75597084e-02f, 8.30032397e-03f, -4.65891212e-02f, -3.45282741e-02f, -5.58036193e-02f,
  -5.40352799e-02f, 4.82794419e-02f, 4.01827367e-03f, 3.64478789e-02f, 3.51092741e-02f, -5.66065274e-02f, 7.94884562e-03f, -2.89583988e-02f, 8.34437832e-02f, 9.48281884e-02f,
  -3.60959792e-03f, -6.52451292e-02f, 1.01072371e-01f, 3.75890546e-02f, -9.45863500e-02f, -7.66030699e-02f, 1.63229071e-02f, -3.12325954e-02f, -9.97138023e-02f, -6.76800613e-04f,
  -7.65256137e-02f, 1.09583531e-02f, -1.72039047e-02f, -3.78327444e-02f, 5.80882281e-02f, -1.01093866e-01f, -6.17833734e-02f, 5.17342649e-02f, -7.46120065e-02f, -8.46355334e-02f,
  -5.78688718e-02f, -6.25694767e-02f, -4.62047756e-02f, 4.98888865e-02f, -9.84849483e-02f, -1.81738958e-02f, -9.51043144e-02f, -8.77080709e-02f, -7.60254934e-02f, 8.43332782e-02f,
  5.80780618e-02f, -1.04503639e-01f, -7.41564557e-02f, -3.55278188e-03f, 1.68711413e-03f, 4.86773998e-02f, -6.66889474e-02f, 5.51542789e-02f, -8.28727856e-02f, 3.28222066e-02f,
  8.41302350e-02f, -2.12303512e-02f, -5.48903644e-03f, 4.81937714e-02f, -2.07387045e-01f, -2.46370696e-02f, 3.41805350e-03f, -1.09717488e-01f, 1.80282533e-01f, 8.69047176e-03f,
  -7.25935400e-02f, 7.88013488e-02f, 1.23352662e-01f, -1.92145020e-01f, 2.58104324e-01f, 1.99118629e-01f, -3.50712473e-03f, 2.79571079e-02f, -4.43329960e-02f, 4.30995487e-02f,
  5.32009676e-02f, -7.02027306e-02f, -7.89885595e-02f, -2.43160635e-01f, -1.73842564e-01f, 4.14751610e-03f, -7.48657733e-02f, -1.04009762e-01f, -1.91847712e-01f, -1.27152652e-01f,
  -1.15515195e-01f, -6.66216910e-02f, -9.25165340e-02f, -5.26901148e-02f, -5.98756894e-02f, -5.46858879e-04f, -2.29981821e-02f, -6.12684526e-02f, 4.16190550e-02f, 1.07121535e-01f,
  7.44240433e-02f, 3.29452404e-03f, 1.05765052e-01f, 8.11195448e-02f, -1.12769544e-01f, -3.93133610e-02f, -5.27121276e-02f, -9.92476419e-02f, -1.02060596e-02f, -8.32453743e-02f,
  -2.55169123e-02f, -4.35724668e-02f, 8.70807841e-02f, 3.75349298e-02f, 5.89533150e-02f, -4.20986935e-02f, 5.56984544e-03f, 4.98352200e-02f, 1.10841531e-04f, -1.94242806e-03f,
  -6.64982721e-02f, 4.87902798e-02f, 2.51067448e-02f, -5.30797057e-02f, -1.45358711e-01f, -1.14349395e-01f, -8.76380503e-02f, 7.93640465e-02f, -8.93524587e-02f, 6.77634999e-02f,
  7.06960559e-02f, -5.22917919e-02f, 9.10630673e-02f, 2.98321545e-02f, -8.05499405e-02f, -1.69038773e-02f, 1.29104285e-02f, 5.21320291e-02f, 3.47776152e-02f, 4.62174453e-02f,
  -5.84634533e-03f, 9.54057351e-02f, 6.58739880e-02f, -6.05618805e-02f, -9.08008218e-02f, 3.59723507e-03f, 2.55304277e-02f, 6.96381181e-02f, 2.59717479e-02f, 7.47068226e-02f,
  -5.67977503e-02f, -5.53559549e-02f, -3.07354089e-02f, 5.98714463e-02f, 3.80448140e-02f, -6.16285764e-02f, 1.02578543e-01f, -1.54396966e-02f, -7.34825060e-02f, 2.15882845e-02f,
  -3.38342637e-02f, 8.27435330e-02f, -6.96116760e-02f, 5.83414957e-02f, -6.85557052e-02f, 7.29816640e-03f, -5.81420176e-02f, 1.05228439e-01f, 3.01651862e-02f, 1.62086543e-02f,
  -7.53659755e-02f, 3.66067793e-03f, 6.87703788e-02f, -1.13765039e-02f, 3.61445025e-02f, 2.56195292e-02f, 5.57247782e-03f, -1.85945537e-02f, 3.20125110e-02f, 1.09872986e-02f,
  -1.08833604e-01f, 1.49124503e-01f, -1.64728388e-01f, -1.70241699e-01f, 1.87246874e-02f, -1.36356041e-01f, -4.76069972e-02f, -6.04599118e-02f, -4.48039509e-02f, -9.85494033e-02f,
  -2.30253637e-01f, 3.91798876e-02f, -8.41967296e-03f, -1.17438857e-03f, -3.99255492e-02f, 8.30758214e-02f, -2.55232424e-01f, -1.26751855e-01f, 1.03996359e-01f, 8.88659526e-03f,
  -5.11012338e-02f, -1.40658570e-02f, 7.20914975e-02f, 5.65351248e-02f, -7.42150396e-02f, 3.79890576e-02f, -1.24637876e-02f, 4.31407504e-02f, -8.59921053e-02f, 1.55124441e-01f,
  2.47730277e-02f, -2.21651003e-01f, -5.63896485e-02f, -1.07655369e-01f, -1.45287499e-01f, 4.10522111e-02f, -7.76723921e-02f, -4.64062355e-02f, -3.06334309e-02f, -3.59475315e-02f,
  -9.40037705e-03f, -8.89588594e-02f, -4.65581752e-02f, 1.01907745e-01f, 1.09511921e-02f, 3.37688392e-03f, 9.87743363e-02f, -5.50858863e-02f, -7.26506710e-02f, -3.44658121e-02f,
  2.41228770e-02f, -3.16472650e-02f, -2.58674026e-02f, -2.36947164e-02f, 8.46938118e-02f, -8.68659094e-03f, 4.37811725e-02f, -1.01515971e-01f, -8.46594647e-02f, -7.39912912e-02f,
  -6.36950657e-02f, 2.41180579e-03f, -7.50378445e-02f, 3.45792957e-02f, 8.97154137e-02f, -3.28634791e-02f, 9.73577201e-02f, 5.05815446e-02f, -3.27779166e-02f, -1.15535378e-01f,
  -6.68317899e-02f, -2.73006838e-02f, 6.24037981e-02f, -1.20732412e-02f, -5.07571809e-02f, -9.02433768e-02f, -7.48681799e-02f, -3.58689390e-03f, -3.99102978e-02f, -3.89442965e-02f,
  -6.87698498e-02f, 7.33646750e-02f, 1.88582782e-02f, -7.69585893e-02f, 5.88901974e-02f, 9.98808444e-03f, 4.05389331e-02f, 2.50363606e-03f, 3.21179964e-02f, 5.92144281e-02f,
  -9.30326506e-02f, -1.59488395e-01f, -5.42153455e-02f, -3.91935231e-03f, -2.33331788e-02f, -3.21255662e-02f, 6.79357946e-02f, 3.65606882e-02f, 1.88322514e-02f, -1.04819715e-01f,
  -5.37391081e-02f, 7.57348984e-02f, -8.78042355e-02f, 8.62585567e-03f, 1.16796391e-02f, -1.63358413e-02f, -5.15907770e-03f, -5.53530082e-02f, -5.54878786e-02f, -3.51564474e-02f,
  6.61298679e-03f, 1.61932092e-02f, 6.50786012e-02f, 3.14690024e-02f, 3.32592172e-03f, -8.95195082e-02f, 7.57745653e-03f, -4.06760126e-02f, 1.20972032e-02f, 7.63715506e-02f,
  1.64434239e-02f, 1.15915328e-01f, 8.26419815e-02f, -1.27411745e-02f, 2.72241561e-03f, -1.20289907e-01f, -1.70140088e-01f, 1.42336981e-02f, -2.31829718e-01f, -1.83271412e-02f,
  -4.63662893e-02f, 1.49922177e-01f, -8.22562352e-02f, 1.85632154e-01f, 7.56116360e-02f, -2.29419082e-01f, 7.96728507e-02f, 9.30928662e-02f, -2.17384566e-02f, 1.47028670e-01f,
  -2.42200727e-03f, 7.83689693e-02f, 9.18591302e-03f, 2.02550784e-01f, -3.19090635e-02f, 1.28452823e-01f, 1.71941265e-01f, -1.13361262e-01f, 2.21125752e-01f, 7.53230453e-02f,
  -5.19339368e-02f, -1.34409759e-02f, -1.87555384e-02f, -7.62883946e-02f, 9.05548409e-02f, -2.18716711e-02f, -5.82658984e-02f, 7.34550729e-02f, -3.34467329e-02f, 9.14970860e-02f,
  -4.89185788e-02f, -3.02210636e-02f, 5.94623312e-02f, 8.70197788e-02f, -5.87286614e-02f, 9.36250240e-02f, -4.47433367e-02f, 1.00741379e-01f, 5.21370880e-02f, -4.99266125e-02f,
  3.57993245e-02f, 2.22533685e-03f, 2.96209045e-02f, -1.97669622e-02f, -1.53430663e-02f, 8.63318443e-02f, 5.34164123e-02f, 3.86600476e-03f, -5.55864312e-02f, -5.10819927e-02f,
  1.07650988e-01f, -8.24879482e-02f, 3.43528688e-02f, -1.10591635e-01f, -7.71637261e-02f, 3.13010029e-02f, -1.27233109e-02f, -3.86255831e-02f, -1.00343905e-01f, -1.24150127e-01f,
  -7.74517655e-02f, 2.94263512e-02f, -1.03464261e-01f, 2.49846354e-02f, 3.22810076e-02f, 1.74351428e-02f, -7.26036727e-02f, -3.54758091e-02f, -7.66993500e-03f, -3.65486927e-02f,
  -1.06472515e-01f, -6.41523600e-02f, 3.02591603e-02f, 2.96384469e-02f, -5.12029268e-02f, 6.18884340e-02f, 1.41486526e-02f, 2.86076590e-02f, -6.75164834e-02f, -8.49017128e-02f,
  4.13351990e-02f, 2.52354052e-02f, 5.48759587e-02f, -7.84722529e-03f, -1.06770031e-01f, -1.31930947e-01f, 1.74919441e-02f, 2.32440676e-03f, -2.53179297e-02f, -1.20788902e-01f,
  8.63996744e-02f, 6.91631138e-02f, 7.14631975e-02f, -2.23115180e-02f, -8.97125434e-03f, 4.55732271e-02f, -9.43481624e-02f, -8.09770525e-02f, 4.51175123e-02f, -2.20356602e-02f,
  1.95784634e-03f, 1.02588773e-01f, -5.71126603e-02f, 1.95598733e-02f, -3.68428566e-02f, 9.03447345e-02f, 8.61862525e-02f, 2.83096489e-02f, 7.36579299e-02f, -1.06361061e-01f,
  1.75112292e-01f, -1.02701345e-02f, -1.21240141e-02f, 1.06676318e-01f, -1.02751940e-01f, -2.29126550e-02f, -1.37978986e-01f, -3.04242503e-02f, -7.70333260e-02f, -2.28932593e-02f,
  4.91334386e-02f, -2.16074195e-02f, 7.32479692e-02f, -1.01011014e-03f, -8.11523572e-02f, -8.20536390e-02f, 3.55310515e-02f, -3.02145276e-02f, -5.18921623e-03f, 1.58689424e-01f,
  1.11760395e-02f, 8.61975774e-02f, 1.24413908e-01f, 1.25717312e-01f, 4.37097177e-02f, 1.66772828e-01f, 9.81970951e-02f, -2.45449431e-02f, 1.84628010e-01f, -3.04511338e-02f,
  -9.78749711e-03f, 3.58280577e-02f, -3.56265600e-03f, -1.06130779e-01f, -2.83285156e-02f, 8.44176412e-02f, 4.75346483e-02f, 6.75637624e-04f, 3.52489986e-02f, -5.59432320e-02f,
  1.54100507e-02f, 4.73361425e-02f, -5.78310788e-02f, -1.16714373e-01f, -5.20587265e-02f, -1.15001677e-02f, -6.11471348e-02f, -4.55099829e-02f, -1.39982194e-01f, 5.00606410e-02f,
  -2.15133708e-02f, -1.32664889e-01f, -6.64507374e-02f, 6.36236444e-02f, 7.44158626e-02f, -2.28519123e-02f, 1.57106537e-02f, -4.74792421e-02f, 2.98117683e-03f, 7.32602403e-02f,
  7.56949186e-02f, -5.48599400e-02f, 7.88845588e-03f, -7.17756078e-02f, 7.15229064e-02f, 5.78919351e-02f, -3.52659971e-02f, 6.82777241e-02f, 2.55828202e-02f, 3.60952467e-02f,
  4.97142375e-02f, 8.11055861e-03f, -2.37064213e-02f, 5.02451919e-02f, 8.27271268e-02f, -8.17976668e-02f, -7.49399932e-03f, 1.88008342e-02f, 1.00533158e-01f, -8.00865144e-02f,
  -2.14490145e-02f, -3.08977515e-02f, -1.43190138e-02f, -9.09232199e-02f, -1.08895032e-02f, 1.79500552e-03f, 9.81564522e-02f, 7.35727102e-02f, -1.08717151e-01f, -2.80794688e-02f,
  6.85685426e-02f, 1.36139080e-01f, -5.52207008e-02f, -9.29942913e-03f, -9.67440102e-03f, -1.28677972e-02f, -6.00219406e-02f, 8.86603445e-02f, 2.31248084e-02f, 1.17078371e-01f,
  2.62847971e-02f, -9.73667279e-02f, -4.24405001e-02f, 3.99008803e-02f, -5.96278384e-02f, -1.60169154e-02f, 2.39469931e-02f, 1.10660279e-02f, -3.40837017e-02f, -9.12341624e-02f,
  2.77550071e-02f, 1.61126852e-02f, -7.56521896e-02f, -2.50270148e-03f, 6.28443062e-02f, 6.70498312e-02f, -8.98918062e-02f, 1.53699620e-02f, 2.99672931e-02f, -2.59580347e-03f,
  -1.81802616e-01f, -1.51355034e-02f, -2.43127886e-02f, 1.17181018e-01f, -7.65517801e-02f, -1.11348271e-01f, -7.64114857e-02f, -2.82785925e-03f, -1.99953422e-01f, 6.37974143e-02f,
  1.27816588e-01f, -1.76411226e-01f, -1.50766253e-01f, -5.82000986e-02f, -1.33914649e-01f, 1.05574364e-02f, -1.61255822e-02f, 2.25314032e-03f, -1.31239578e-01f, 3.94286700e-02f,
  9.99146774e-02f, 2.08788708e-01f, 4.68249917e-02f, 2.95534760e-01f, 5.81733473e-02f, 2.00880170e-01f, 2.82020986e-01f, 1.60901189e-01f, 1.41475901e-01f, 3.23666744e-02f,
  -1.16260625e-01f, -8.33049268e-02f, -5.94225265e-02f, 1.16058607e-02f, -1.43613368e-02f, 2.90161148e-02f, 6.02615438e-02f, -9.48384926e-02f, 3.03914491e-02f, -2.70145433e-03f,
  -4.72857356e-02f, 5.14538176e-02f, -8.58936384e-02f, -1.17532045e-01f, -9.92099419e-02f, -2.06459295e-02f, -2.85015311e-02f, -6.51441561e-03f, -9.27414224e-02f, -9.56235379e-02f,
  -3.14127132e-02f, -3.55275124e-02f, 1.40392795e-01f, -4.58490960e-02f, 3.26550826e-02f, 6.72509968e-02f, 3.13323326e-02f, 8.76702443e-02f, -2.35710926e-02f, -3.16144377e-02f,
  2.40880577e-03f, 7.34994281e-03f, 3.02202292e-02f, 7.23811686e-02f, -2.20492333e-02f, 1.23310313e-02f, 7.39510804e-02f, 8.57596323e-02f, -9.64325666e-03f, 3.91486026e-02f,
  -3.18037532e-02f, -4.38538566e-02f, -4.44025919e-02f, 7.20954537e-02f, -4.93861921e-02f, -5.24568334e-02f, -2.14685835e-02f, 2.41339598e-02f, -5.67002594e-02f, 5.60802966e-03f,
  2.10859277e-03f, 3.78525928e-02f, -6.79204091e-02f, -9.68432799e-02f, 8.28905217e-03f, -1.19627146e-02f, 3.42385918e-02f, 9.73826274e-03f, 7.37849623e-02f, -9.05566092e-04f,
  2.35193130e-02f, -3.91628128e-04f, -6.76130783e-03f, 3.72051336e-02f, 1.33758355e-02f, 3.25791016e-02f, -7.25206509e-02f, -5.30869476e-02f, 7.52077997e-02f, -4.76839244e-02f,
  -3.45150419e-02f, 2.31667981e-02f, 1.09577782e-01f, -6.26875684e-02f, 7.20905364e-02f, 6.45861253e-02f, 2.86596287e-02f, 4.21885811e-02f, 2.12012753e-02f, -1.73608921e-02f,
  1.59507878e-02f, -1.06462575e-01f, 1.23295292e-01f, 3.58968377e-02f, 9.42268148e-02f, 1.26894042e-02f, 1.11540623e-01f, 7.25593567e-02f, 7.00020194e-02f, -4.25625294e-02f,
  -9.52145234e-02f, -1.92881927e-01f, -1.11346170e-02f, -7.26973191e-02f, -2.17234418e-02f, -1.13120034e-01f, -2.45901309e-02f, -1.55527130e-01f, -1.04414925e-01f, -1.71001088e-02f,
  -5.89728169e-03f, 4.23904918e-02f, 1.71452790e-01f, -1.18961804e-01f, 3.37742686e-01f, 1.94574773e-01f, -1.04138926e-01f, -9.09446627e-02f, -9.64604914e-02f, -3.62556167e-02f,
  3.33705731e-02f, -9.29124281e-02f, 1.60518184e-01f, -6.25976101e-02f, 1.08968681e-02f, -1.44916713e-01f, 5.95631776e-04f, 6.90518618e-02f, -2.35690959e-02f, 3.81872691e-02f,
  -9.84941795e-02f, -3.95756736e-02f, -9.89634618e-02f, 2.24884227e-03f, -7.35303462e-02f, -3.11748721e-02f, -3.51270847e-02f, 1.44786954e-01f, 2.44934391e-03f, 2.06638798e-02f,
  7.50843659e-02f, -8.27529579e-02f, -4.33095060e-02f, -3.74330883e-03f, -6.45656288e-02f, 3.39546427e-03f, -4.20977436e-02f, -5.13990708e-02f, 2.42063422e-02f, -4.04915437e-02f,
  2.62016151e-02f, 2.79692225e-02f, -7.37643093e-02f, -6.57397583e-02f, 1.13592967e-01f, -9.84334946e-02f, 3.72112840e-02f, 4.46422957e-02f, -3.34903933e-02f, 1.04212817e-02f,
  4.15367261e-02f, 4.45080921e-02f, -2.61807721e-02f, 2.97101457e-02f, -1.36959046e-01f, -2.51107924e-02f, -6.10311702e-02f, 1.54802455e-02f, -4.36328910e-02f, -3.03549040e-03f,
  -6.63959533e-02f, 1.54797910e-02f, -2.47971173e-02f, 2.91118287e-02f, 4.24648672e-02f, 4.27672639e-03f, 1.13980835e-02f, 8.72384384e-03f, 4.94063906e-02f, 6.48213476e-02f,
  9.60219353e-02f, 9.21191052e-02f, 1.45025551e-02f, 4.55481894e-02f, -1.16140498e-02f, 5.19649358e-03f, -4.56163213e-02f, -7.35165700e-02f, 1.22910917e-01f, 9.22277644e-02f,
  -2.81822890e-01f, -2.07932428e-01f, -3.39153856e-02f, -2.74975765e-02f, -6.80726999e-03f, -1.95851680e-02f, 7.36429263e-03f, 9.58521757e-03f, -8.93454775e-02f, 9.95160341e-02f,
  -8.92161652e-02f, -7.46405348e-02f, -8.52658600e-02f, 4.02456187e-02f, -7.24301115e-02f, -5.74530065e-02f, -8.44299123e-02f, -3.74697447e-02f, -1.48536144e-02f, -2.02069879e-02f,
  -7.15026334e-02f, 6.43833503e-02f, 5.69359846e-02f, 7.27642700e-02f, -3.61798774e-03f, 5.82409054e-02f, 1.95273105e-02f, 3.82478908e-02f, 6.85092732e-02f, -4.09012027e-02f,
  1.11068636e-01f, 4.81854901e-02f, -3.05378027e-02f, 9.17666107e-02f, -1.13658831e-01f, -9.85560119e-02f, -9.86022875e-02f, -1.55191585e-01f, 4.28125151e-02f, 1.19619116e-01f,
  -1.60280913e-01f, 1.26529858e-01f, 1.47136420e-01f, 1.30784020e-01f, 5.62899709e-02f, 2.27517709e-01f, 6.78386912e-02f, -8.59620888e-03f, 6.77623153e-02f, 8.71746168e-02f,
  -2.36648936e-02f, 8.48176852e-02f, 1.73423916e-01f, -4.08486910e-02f, -1.05186485e-01f, -3.33435424e-02f, 1.80565789e-01f, -1.37526169e-01f, 8.87104683e-03f, 5.14462143e-02f,
  2.88610235e-02f, 7.76183680e-02f, -8.73511210e-02f, 3.76199223e-02f, -2.92971125e-03f, -7.41777867e-02f, 2.73911376e-02f, 3.10040321e-02f, -1.14373825e-01f, 7.25044906e-02f,
  9.26925465e-02f, -1.06673157e-02f, -4.92309332e-02f, -6.55699447e-02f, 6.65178001e-02f, -2.10515484e-02f, -1.24573931e-02f, -6.31183833e-02f, 1.74422171e-02f, -6.98540453e-03f,
  -2.18879003e-02f, -8.08098316e-02f, -7.67128170e-02f, 1.02069288e-01f, 3.55350366e-03f, 5.48513979e-02f, 6.16072752e-02f, 7.27707297e-02f, 1.36616603e-01f, -2.85726376e-02f,
  3.92444506e-02f, 5.59650213e-02f, 3.56993526e-02f, 1.18261494e-03f, 5.79003394e-02f, -7.90249929e-02f, -3.91465388e-02f, -5.23883104e-02f, 9.04933289e-02f, 1.12793870e-01f,
  5.99354133e-02f, -4.17783596e-02f, -5.61672486e-02f, -7.02294409e-02f, 9.61219519e-02f, 8.78815055e-02f, 5.43962941e-02f, 3.25181633e-02f, -5.61822653e-02f, 6.24974333e-02f,
  3.55690047e-02f, -4.16033901e-02f, 1.93113405e-02f, 1.11654453e-01f, 1.25675285e-02f, -2.70596123e-03f, -1.56425033e-02f, 2.68065394e-03f, -6.60225227e-02f, -6.73275143e-02f,
  2.64058542e-02f, 2.84746051e-01f, 3.35058458e-02f, -1.11470245e-01f, 2.34452821e-02f, -1.08533479e-01f, 3.48925963e-02f, 2.65336204e-02f, 9.23515633e-02f, -7.96046946e-03f,
  1.02768205e-01f, -4.07641530e-02f, 4.27609608e-02f, -5.57159670e-02f, 2.80795735e-03f, 1.58456430e-01f, 6.35208935e-02f, 9.76132676e-02f, -1.49381468e-02f, -5.49925864e-02f,
  8.11475981e-03f, 4.68867980e-02f, 1.52069684e-02f, 1.54136559e-02f, -3.45827104e-03f, -4.41965498e-02f, -1.14617549e-01f, -6.48070052e-02f, 3.24840508e-02f, 8.61712992e-02f,
  8.80805925e-02f, -1.31803602e-01f, -1.32968947e-01f, -1.45657942e-01f, -1.09084025e-01f, -3.14641267e-01f, -1.99381962e-01f, -1.48963377e-01f, -4.12494503e-02f, -1.40162170e-01f,
  -1.39390081e-01f, 1.10454030e-01f, 9.73929614e-02f, -2.29471400e-01f, 9.00756046e-02f, 1.53922722e-01f, -1.28508434e-01f, -6.06044456e-02f, -9.14663300e-02f, -3.21151242e-02f,
  3.67999189e-02f, -7.83900544e-02f, 5.38587570e-02f, -1.51014954e-01f, -2.26828143e-01f, 1.65651937e-03f, 7.44206458e-02f, -1.84337705e-01f, -1.26601890e-01f, -9.70063508e-02f,
  -1.26476865e-02f, -3.38921733e-02f, 4.10465822e-02f, 3.85078490e-02f, 9.72696301e-03f, -1.25171086e-02f, -1.15133598e-01f, 5.47949336e-02f, -7.70863891e-02f, -3.88106965e-02f,
  6.55548498e-02f, 4.02053110e-02f, -2.04016473e-02f, 6.46973215e-03f, 1.67228598e-02f, -2.65364628e-02f, -2.16835048e-02f, -2.45636981e-02f, -1.80443097e-03f, 2.97076143e-02f,
  -3.81460711e-02f, -2.09040847e-03f, -4.75604162e-02f, 1.24591827e-01f, 1.24706412e-02f, -1.31193995e-01f, 6.98191226e-02f, -3.59703116e-02f, 1.19941346e-02f, -7.17490911e-02f,
  9.83148515e-02f, -5.01579009e-02f, -3.82450037e-02f, -7.66998455e-02f, 6.05851002e-02f, -8.76789354e-03f, 5.82117252e-02f, 7.56838322e-02f, 4.08476926e-02f, -9.63569805e-03f,
  -3.58625464e-02f, -2.29774956e-02f, -5.69536164e-02f, 3.11776227e-03f, -3.01892706e-03f, 1.52721452e-02f, -6.14153454e-04f, -8.29103962e-02f, -4.87036966e-02f, -7.53192231e-02f,
  -3.50183179e-03f, -4.19883505e-02f, 3.56120686e-03f, 7.70211592e-02f, 3.03705055e-02f, -5.94132729e-02f, -2.32997406e-02f, 4.82351286e-03f, -3.38626988e-02f, -5.91472909e-02f,
  -6.70978129e-02f, -4.93520685e-02f, 5.59699675e-03f, 1.89627036e-02f, -2.40691239e-03f, 2.34232517e-03f, 3.16483877e-03f, -5.09168580e-02f, -9.25861374e-02f, -1.05029456e-01f,
  -8.70377347e-02f, -4.50004041e-02f, -6.74470142e-02f, -7.95185473e-03f, -2.83604134e-02f, -7.98106790e-02f, -3.35134678e-02f, 6.60926700e-02f, -1.02215402e-01f, -7.92615637e-02f,
  4.60458994e-02f, 1.00893490e-01f, 9.10643116e-02f, -3.93782742e-02f, 6.27405271e-02f, -6.53297529e-02f, -7.29395426e-04f, 1.17203228e-01f, 9.79882777e-02f, -4.55642678e-02f,
  2.47964904e-01f, 7.10806325e-02f, 2.13517562e-01f, 1.05025865e-01f, -4.40938994e-02f, -1.84666442e-05f, -5.54132015e-02f, 7.85820931e-02f, 2.86972374e-01f, 5.11072651e-02f,
  -6.33779392e-02f, 1.62908018e-01f, -1.68532133e-01f, 1.16289109e-01f, -3.07836980e-02f, -7.28942752e-02f, -7.89465904e-02f, -4.11445200e-02f, 2.42180638e-02f, 5.33255935e-02f,
  3.34550738e-02f, -1.39392480e-01f, -7.13741928e-02f, -1.43137380e-01f, -1.14343062e-01f, -1.54557228e-01f, -3.74934494e-01f, -3.54081765e-02f, -4.87583019e-02f, -7.19459727e-02f,
  -1.58695709e-02f, 4.85265739e-02f, -5.26371337e-02f, -7.78464079e-02f, 3.98584306e-02f, -6.24836497e-02f, 9.62882191e-02f, -1.28918394e-01f, -4.33436334e-02f, 1.75141974e-03f,
  -6.68792846e-03f, -2.92856898e-02f, 1.03635035e-01f, -4.06442247e-02f, -6.24055751e-02f, -7.93070421e-02f, 6.33074343e-02f, 7.36403987e-02f, -6.97917417e-02f, 6.79890141e-02f,
  3.59665230e-02f, 3.02991569e-02f, 8.03041384e-02f, 6.31385818e-02f, -4.21140231e-02f, -1.36150895e-02f, 8.12855139e-02f, -9.96529907e-02f, -2.33341251e-02f, 7.61089697e-02f,
  4.80256267e-02f, 7.98978433e-02f, -4.84426832e-03f, -2.13304330e-02f, 7.84804113e-03f, -1.49568832e-02f, 1.75106376e-02f, -1.02986386e-02f, 4.59552594e-02f, 5.21930717e-02f,
  -2.54740529e-02f, 7.62187168e-02f, 7.90499896e-03f, 4.72304113e-02f, 4.70120870e-02f, 2.51475908e-02f, -4.32152972e-02f, 1.45337842e-02f, -7.39703476e-02f, 7.69483969e-02f,
  8.65733400e-02f, -1.93391871e-02f, -1.90308079e-01f, -3.88564132e-02f, -1.14451505e-01f, 6.16646670e-02f, 1.19707249e-01f, 8.70473161e-02f, -8.77317041e-02f, -5.28196655e-02f,
  -2.36853033e-01f, 4.50823645e-05f, -5.65481521e-02f, 3.11451927e-02f, -9.87364650e-02f, -6.08856827e-02f, 1.61621854e-01f, 5.26292957e-02f, 4.00613360e-02f, 8.01797025e-03f,
  8.41217637e-02f, -1.43057272e-01f, 1.82465371e-02f, 1.33137004e-02f, 4.72895242e-03f, 1.93331223e-02f, 9.20843855e-02f, 2.05464251e-02f, -8.75416100e-02f, 7.59606063e-02f,
  -6.25782311e-02f, 1.05156042e-01f, -5.07360026e-02f, -6.30920753e-02f, 5.13050444e-02f, 2.43086740e-02f, 4.71026786e-02f, -4.16528769e-02f, 6.38321275e-03f, -4.87459674e-02f,
  -2.89004028e-01f, 9.16287303e-02f, -1.46522656e-01f, -6.38747141e-02f, 8.35511833e-02f, -1.01808675e-01f, -1.13335654e-01f, 1.17481962e-01f, -1.71372384e-01f, 1.08469322e-01f,
  -6.88061491e-02f, -9.58583206e-02f, 1.29248723e-02f, -7.03286678e-02f, -3.44624430e-01f, -3.27450275e-01f, -1.45321772e-01f, -1.68107852e-01f, -1.22965649e-01f, -3.24712172e-02f,
  -4.25727628e-02f, 1.24195836e-01f, -1.91596672e-01f, 2.44696051e-01f, 1.88076440e-02f, 1.11430608e-01f, 1.94783583e-01f, 1.22506335e-01f, 9.23190191e-02f, 5.20553589e-02f,
  -7.96902850e-02f, -1.20181352e-01f, 6.62246794e-02f, -9.12530720e-02f, -1.46624714e-03f, 6.53300956e-02f, 5.15825115e-03f, 7.96676800e-02f, 2.40265019e-02f, -8.90674442e-02f,
  -2.67019961e-03f, 2.06054132e-02f, 7.35594891e-03f, 6.16605990e-02f, -1.68297328e-02f, -2.01902781e-02f, -3.39531824e-02f, 1.95049793e-02f, 6.76786387e-03f, -1.56781077e-01f,
  -1.30459502e-01f, -1.69585668e-03f, 2.64626928e-03f, -9.10084229e-03f, -2.37431843e-02f, 6.19282126e-02f, -3.77008244e-02f, -1.37870638e-02f, 5.19071110e-02f, -5.31778336e-02f,
  -5.69427535e-02f, -5.30063584e-02f, 3.22649418e-03f, -3.72264683e-02f, -1.73124652e-02f, 4.57715020e-02f, -4.39129025e-02f, -1.76913254e-02f, 1.21160932e-02f, 9.55805629e-02f,
  4.60785261e-04f, -2.37170793e-02f, -1.34676099e-02f, -4.28140014e-02f, -2.01641340e-02f, -5.57898879e-02f, 1.36988208e-01f, -6.74007609e-02f, -4.86394204e-02f, -4.67411429e-02f,
  2.53882986e-02f, -9.95567068e-03f, 4.28750329e-02f, 1.16491295e-01f, 7.12658698e-03f, 2.72913501e-02f, -5.98804355e-02f, -6.41880976e-03f, 6.38987124e-02f, -1.67742502e-02f,
  -3.77741195e-02f, 9.13145170e-02f, 1.31120803e-02f, 4.88460362e-02f, -8.93867388e-03f, -3.21496949e-02f, 6.82433555e-03f, -2.02120300e-02f, -7.65631050e-02f, -5.04012182e-02f,
  3.89541201e-02f, 1.15576811e-01f, 6.55933991e-02f, -3.11068762e-02f, 7.35166296e-02f, -1.70440704e-01f, 7.72067904e-02f, 6.97426647e-02f, 1.11863934e-01f, 5.93568571e-02f,
  -8.73146206e-03f, 3.87502573e-02f, 9.05838460e-02f, -3.55623662e-02f, -2.23153923e-02f, -3.88287976e-02f, 1.37854680e-01f, -1.32783605e-02f, 3.62185463e-02f, -5.85936420e-02f,
  -1.82136074e-01f, 2.13353112e-01f, -2.03543156e-01f, 1.85261935e-01f, -9.04780179e-02f, 2.18494132e-01f, 2.63408959e-01f, 7.00709000e-02f, 1.12654760e-01f, 3.00677240e-01f,
  1.49735838e-01f, 1.42010134e-02f, 8.41201320e-02f, 2.99540490e-01f, -3.01694982e-02f, 1.12154409e-01f, 2.11179584e-01f, 1.65796787e-01f, -3.47995758e-02f, -5.23974448e-02f,
  -8.43608901e-02f, 9.97918770e-02f, 8.09995830e-02f, -6.04068562e-02f, 1.68987699e-02f, -1.50564179e-01f, 2.68906038e-02f, -1.50239408e-01f, 6.41841535e-03f, -2.94415522e-02f,
  -2.59090252e-02f, -5.34062497e-02f, -6.92568570e-02f, 6.75303768e-03f, -4.99352850e-02f, -1.04812376e-01f, -5.78520969e-02f, -1.00594781e-01f, -3.87573731e-03f, 7.33639374e-02f,
  2.40502711e-02f, -3.94566320e-02f, 5.80261424e-02f, -8.31085443e-03f, -1.33035528e-02f, -8.27329978e-03f, -5.45489639e-02f, 5.84113151e-02f, 7.71927759e-02f, -7.39567056e-02f,
  -3.12470011e-02f, 2.04086024e-02f, 5.08671962e-02f, 6.24116790e-03f, -6.29403219e-02f, 1.33311227e-02f, 4.40347195e-02f, 4.66404036e-02f, -1.38765527e-03f, -4.07102592e-02f,
  -1.71859551e-03f, -1.99631415e-02f, -4.98582199e-02f, -3.65446657e-02f, -3.67168561e-02f, 7.50226378e-02f, 1.03502884e-03f, -3.91119951e-03f, -1.39282795e-03f, -7.53615573e-02f,
  3.67393321e-03f, -2.30235793e-02f, 3.74809206e-02f, 3.46481241e-02f, 7.57967234e-02f, -1.67995617e-02f, 1.43934535e-02f, 5.08849137e-02f, 2.51463335e-03f, 3.95926312e-02f,
  7.77906254e-02f, -3.01819462e-02f, 2.50993297e-02f, 6.81412499e-03f, 1.43102254e-03f, -5.12806652e-03f, -8.10140967e-02f, -5.11481985e-03f, -6.17445707e-02f, -7.03447685e-02f,
  1.57502979e-01f, 6.99739978e-02f, -1.04765603e-02f, -2.37475708e-02f, 6.83569988e-06f, 2.07780791e-03f, -2.04105321e-02f, 5.05410284e-02f, -5.80613390e-02f, -6.22326098e-02f,
  1.38900075e-02f, 1.97640397e-02f, -7.00701773e-02f, 4.18017171e-02f, 9.84418020e-02f, -6.38803840e-02f, 2.27249321e-02f, 2.88344249e-02f, -2.80003268e-02f, -5.50453551e-02f,
  -1.82114337e-02f, 7.92243108e-02f, -5.16009331e-02f, 2.39799358e-02f, 3.59299630e-02f, -3.85854691e-02f, 5.19256741e-02f, -2.48351526e-02f, 1.00099808e-02f, 2.98450422e-02f,
  -4.33513701e-01f, 2.02445284e-01f, -1.19769141e-01f, -9.00803879e-02f, 1.37269059e-02f, -2.53076088e-02f, 3.95303629e-02f, -1.66782048e-02f, -2.09063832e-02f, 1.42476290e-01f,
  8.84128436e-02f, -1.83039203e-01f, 1.09559000e-01f, 4.43147309e-02f, -2.09607899e-01f, 1.15755983e-02f, 1.39596052e-02f, -1.95917990e-02f, 5.30964062e-02f, -5.05113862e-02f,
  -1.15122572e-01f, 1.97068170e-01f, -1.19586706e-01f, 1.14109948e-01f, -1.27482668e-01f, -3.56963128e-02f, 5.02278144e-03f, 4.95433211e-02f, -9.25222337e-02f, -5.39098540e-03f,
  -2.22770706e-01f, -1.41363353e-01f, -3.82306129e-02f, -3.23230959e-02f, -1.93329483e-01f, -7.90463537e-02f, -7.54915178e-02f, -5.20736612e-02f, 1.85587779e-02f, -6.67765141e-02f,
  -3.28349359e-02f, -1.08531453e-02f, 3.93564515e-02f, 1.38342483e-02f, -1.92946773e-02f, 6.54215813e-02f, 6.06609322e-03f, -1.08203687e-01f, 5.92849068e-02f, 1.25233894e-02f,
  2.16767658e-02f, 1.32666472e-02f, -9.78426784e-02f, -2.19383072e-02f, -5.34928292e-02f, 2.39958707e-02f, -5.03843501e-02f, 2.75389589e-02f, -1.09962925e-01f, -3.00023053e-02f,
  1.74127799e-03f, -3.33890580e-02f, 3.70717756e-02f, 1.71117932e-02f, -5.57371266e-02f, -2.34853756e-02f, 1.39679434e-02f, 1.18526788e-02f, 3.77636030e-02f, -1.66278128e-02f,
  1.31833730e-02f, -7.92900622e-02f, 4.58523922e-04f, 3.87831405e-02f, 4.26082015e-02f, 5.80298565e-02f, -3.48935723e-02f, 2.81375740e-02f, -4.89464812e-02f, -1.19075038e-01f,
  -1.78206936e-02f, 5.80753013e-02f, 5.88040426e-03f, 5.14426380e-02f, -4.30450439e-02f, -2.53804438e-02f, -5.75871915e-02f, 8.43027700e-03f, 1.03004321e-01f, 2.60218419e-02f,
  -2.47218385e-01f, -2.05685422e-01f, 7.50549063e-02f, 4.10977714e-02f, -5.62321767e-03f, 4.01075482e-02f, 1.28844250e-02f, -2.86611617e-02f, -3.60356010e-02f, 4.80752774e-02f,
  2.48583723e-02f, -3.21606323e-02f, -6.37002438e-02f, -4.70977090e-02f, -4.91951555e-02f, -5.05087562e-02f, 1.81757882e-02f, -1.35143436e-02f, -1.12095878e-01f, -4.68580499e-02f,
  -7.45408162e-02f, -2.20275447e-02f, 1.52936861e-01f, 3.26461196e-02f, 8.79944209e-03f, 3.93925644e-02f, -8.71430039e-02f, -2.93752179e-02f, -5.11944890e-02f, 1.16140489e-03f,
  1.92141876e-01f, -2.74176687e-01f, 1.90034777e-01f, 1.07424468e-01f, 8.84969383e-02f, 9.34598967e-02f, 3.72953042e-02f, 1.79338291e-01f, 1.11945547e-01f, -1.04648642e-01f,
  -1.43738508e-01f, -3.97409610e-02f, -1.29543319e-01f, -2.96042953e-02f, 1.07305832e-01f, -3.77333462e-02f, 5.87036684e-02f, 2.44522113e-02f, 2.89682113e-02f, -1.95515212e-02f,
  1.74803212e-02f, 4.52829376e-02f, 8.55546147e-02f, -1.15676738e-01f, 1.14944046e-02f, 5.16360179e-02f, 2.31236499e-02f, 2.52845958e-02f, -1.25094980e-01f, 6.89364597e-02f,
  -6.22155182e-02f, 1.94101278e-02f, -3.95170692e-03f, -4.91850777e-03f, 2.49685925e-02f, -1.54663712e-01f, 8.40395340e-04f, -1.63006838e-02f, 2.02396791e-02f, -2.51810886e-02f,
  -1.54603675e-01f, -2.32443996e-02f, 2.07516178e-02f, 1.04559019e-01f, -5.37401848e-02f, 8.53253230e-02f, -1.83552280e-02f, -8.05863738e-02f, 5.83982430e-02f, 1.03075244e-01f,
  5.93317002e-02f, -1.06428519e-01f, 6.74115717e-02f, -7.45559037e-02f, -4.17595431e-02f, 1.82930492e-02f, -3.81033123e-02f, 6.92863315e-02f, 6.38123080e-02f, 2.79672053e-02f,
  5.54562099e-02f, -3.37652490e-02f, -2.12566163e-02f, -2.42818743e-02f, -4.90315259e-02f, 1.18600857e-02f, 2.31395010e-02f, 1.62326600e-02f, 1.91375334e-02f, -1.60322059e-02f,
  1.52286468e-02f, 3.68865915e-02f, -8.33042860e-02f, 4.09908518e-02f, 7.80324712e-02f, -3.93536538e-02f, -2.19013058e-02f, -3.01422700e-02f, -8.16631541e-02f, -4.90778051e-02f,
  5.73540032e-02f, -1.87476110e-02f, 1.23386718e-01f, 6.89520016e-02f, 1.26209287e-02f, -1.08312897e-01f, -9.24526155e-02f, 4.01104540e-02f, 3.68690565e-02f, -3.54854506e-03f,
  -3.45300049e-01f, -2.35727891e-01f, -1.02864429e-01f, 4.18132730e-02f, -1.00648798e-01f, -3.41254212e-02f, -1.19894631e-01f, 2.50470415e-02f, -9.68165882e-03f, 3.83892432e-02f,
  -1.08588174e-01f, 2.78628934e-02f, 3.96839902e-02f, 4.90361899e-02f, -9.16505009e-02f, 6.80951923e-02f, -5.60921729e-02f, -3.90609652e-02f, -5.07728867e-02f, -7.77703524e-02f,
  4.58500758e-02f, -3.44754308e-02f, 5.32482639e-02f, -2.64211372e-02f, -5.07556424e-02f, -8.05525407e-02f, 1.04143620e-02f, 1.58956759e-02f, 3.48831974e-02f, -6.49653152e-02f,
  1.08790368e-01f, -2.07676217e-01f, -5.04074171e-02f, 1.49949849e-01f, 1.04490578e-01f, 2.21919492e-01f, 1.31589994e-01f, -3.84405516e-02f, -8.40058699e-02f, -3.43375988e-02f,
  8.97566602e-02f, 7.79078305e-02f, -6.91579953e-02f, 1.72174647e-01f, 1.90480620e-01f, -1.40927052e-02f, 8.74603763e-02f, -1.74624771e-02f, -3.27467695e-02f, -1.25907972e-01f,
  6.72863051e-02f, 1.72830999e-01f, -2.83801649e-02f, 1.25899062e-01f, 1.40449852e-01f, 4.33762819e-02f, 1.35871172e-01f, 8.95907171e-03f, 2.44349942e-01f, 1.87359616e-01f,
  -2.08261367e-02f, -5.99479675e-03f, -4.77176644e-02f, -7.65016824e-02f, 7.29700848e-02f, -8.71383473e-02f, -4.59003411e-02f, 2.46791616e-02f, -5.63832149e-02f, -7.01178983e-02f,
  6.10550381e-02f, -2.87855938e-02f, 4.67544198e-02f, -1.11516146e-02f, 8.70083943e-02f, 7.52732605e-02f, -5.96686713e-02f, 4.18882817e-02f, -1.07041441e-01f, -5.88680953e-02f,
  6.81167189e-03f, 8.42048451e-02f, -3.14089917e-02f, 1.30570590e-01f, -2.31910292e-02f, 3.93975750e-02f, -7.27013648e-02f, 1.07207067e-01f, -6.47713542e-02f, -1.62088796e-02f,
  4.36688140e-02f, 1.21473745e-02f, -1.25484139e-01f, -5.51051535e-02f, 2.20733718e-03f, 6.15764000e-02f, 9.79467109e-02f, 2.61852592e-02f, 4.43215668e-02f, -6.99777156e-02f,
  6.60405979e-02f, 8.35325569e-03f, -8.49722326e-03f, -1.10888563e-01f, 1.54719306e-02f, -7.25910664e-02f, -2.92537957e-02f, -1.46223893e-02f, 6.94945678e-02f, 5.95098473e-02f,
  3.31198424e-02f, 4.27198447e-02f, 2.85306182e-02f, 4.08512391e-02f, -4.27939929e-02f, 7.81804919e-02f, 4.47644703e-02f, -7.86908902e-03f, -4.03713211e-02f, -1.92205701e-02f,
  -7.58995563e-02f, -2.04846606e-01f, -9.19292402e-03f, -3.48916985e-02f, 1.08487047e-01f, -2.15486847e-02f, -3.32679786e-02f, -1.49803562e-02f, -1.17161989e-01f, -4.01686020e-02f,
  3.05793528e-02f, -1.82647407e-02f, -6.03084080e-02f, -6.72215149e-02f, 7.12221041e-02f, -6.39963821e-02f, -1.70722958e-02f, 8.84067453e-03f, 7.63071701e-02f, -4.91585918e-02f,
  -2.08386946e-02f, -4.70128618e-02f, 1.01830341e-01f, -6.86188936e-02f, 1.15394220e-01f, 9.23401341e-02f, 9.03474092e-02f, -6.10419898e-04f, 1.47273503e-02f, -6.34279475e-02f,
  1.73557669e-01f, -4.38420009e-03f, -1.15199968e-01f, 4.47121784e-02f, -1.87966421e-01f, 2.92377174e-02f, -1.70121327e-01f, 1.84006721e-01f, -5.50381280e-02f, 9.99653637e-02f,
  1.14404052e-01f, 2.65956717e-03f, -7.58455927e-03f, 2.11614773e-01f, 1.54337510e-01f, 8.09813756e-03f, 9.74539071e-02f, 1.01022638e-01f, -7.18919113e-02f, 1.59055084e-01f,
  1.54323757e-01f, 2.19998181e-01f, 9.12677422e-02f, 1.12407438e-01f, 4.99265380e-02f, 5.32487184e-02f, 1.06655955e-01f, 2.18120357e-03f, 1.66856721e-01f, 6.69541508e-02f,
  -9.23626944e-02f, 6.68153539e-02f, -7.72145391e-02f, -6.23835362e-02f, -1.32463882e-02f, 3.56877521e-02f, -8.82921591e-02f, 8.12951699e-02f, -7.03663975e-02f, -1.03766304e-02f,
  4.12091799e-02f, -6.38120696e-02f, 1.01883791e-01f, 4.66627505e-04f, 1.14619341e-02f, 1.22744981e-02f, -4.03000526e-02f, -3.15958485e-02f, -1.07190162e-01f, 4.69527543e-02f,
  -1.66107640e-02f, 3.36562470e-02f, 7.37307668e-02f, -8.24316666e-02f, -2.15317160e-02f, -1.68771879e-03f, -6.63731992e-02f, -3.51520954e-03f, 1.13602161e-01f, -2.90321615e-02f,
  2.46883258e-02f, -1.57782417e-02f, 1.00171134e-01f, -1.56815294e-02f, -7.67020658e-02f, -4.79816198e-02f, 1.81608368e-02f, -1.38211362e-02f, -2.84043010e-02f, 3.27152833e-02f,
  2.90505067e-02f, 3.02764447e-03f, -4.29879948e-02f, 3.99356596e-02f, 8.24874863e-02f, -5.70155606e-02f, 5.26340790e-02f, -2.52258088e-02f, -5.58006093e-02f, 1.20233269e-02f,
  -4.48034592e-02f, 1.58533547e-02f, -3.08494028e-02f, 1.02282569e-01f, 5.89818992e-02f, 2.84057483e-02f, 1.06580481e-01f, -6.20973594e-02f, -1.41880825e-01f, 5.91087677e-02f,
  1.00297078e-01f, 1.46980882e-01f, 3.49742733e-02f, -6.88462406e-02f, 4.14783843e-02f, -5.72058149e-02f, 2.73645986e-02f, 6.03856109e-02f, 1.97923928e-03f, 4.61107679e-02f,
  -2.26456840e-02f, 2.74500903e-02f, 1.20462753e-01f, 4.14226912e-02f, 2.17683949e-02f, -3.37884948e-02f, 2.93541607e-02f, -8.39108601e-02f, -3.53358574e-02f, 6.82788566e-02f,
  2.96299625e-02f, -9.59408581e-02f, 1.82836596e-02f, -1.53437763e-01f, 7.50142038e-02f, 3.67029421e-02f, 2.75817681e-02f, -2.59203091e-02f, 3.11196372e-02f, -9.42905433e-03f,
  -1.14964813e-01f, 1.94492955e-02f, -6.29341230e-02f, 2.70399498e-03f, 1.52742036e-03f, -2.45075494e-01f, -1.22089006e-01f, 8.19552392e-02f, 1.32134065e-01f, 7.09188655e-02f,
  4.88765053e-02f, 1.17820635e-01f, 2.06638098e-01f, -1.74156114e-01f, -2.24448845e-01f, -6.58395961e-02f, -1.95493057e-01f, -9.67014581e-02f, 5.32281175e-02f, 6.66951435e-03f,
  -1.31403923e-01f, 1.13446094e-01f, -2.52299547e-01f, 1.87698051e-01f, -2.47764215e-02f, -1.06597040e-02f, 4.75288518e-02f, 1.02928422e-01f, -1.36026859e-01f, -9.38572269e-03f,
  -1.21206328e-01f, 8.37534070e-02f, 4.19784114e-02f, -5.09856120e-02f, -1.06041662e-01f, -1.37015402e-01f, -1.11883834e-01f, -1.51645532e-03f, 4.17895652e-02f, -9.60340276e-02f,
  7.72925615e-02f, 2.12825183e-02f, -6.97163120e-02f, 6.99249208e-02f, 6.86081126e-02f, -3.23746242e-02f, -8.06754008e-02f, -3.11558899e-02f, -2.14532632e-02f, -1.21289901e-01f,
  5.75319640e-02f, 1.87840667e-02f, -6.22698106e-02f, -8.85588750e-02f, -1.31494939e-01f, 7.51225948e-02f, 3.86892706e-02f, 2.70434171e-02f, -8.30200911e-02f, -8.31419006e-02f,
  -6.39794162e-03f, -1.00883566e-01f, 1.57125518e-02f, 1.05455004e-01f, -6.18468486e-02f, -2.80306265e-02f, -4.32329765e-03f, 5.50634600e-03f, 2.91873235e-02f, 2.54972242e-02f,
  -7.73712695e-02f, -8.86818618e-02f, -5.66972084e-02f, -8.06341022e-02f, -4.12668549e-02f, 5.69771454e-02f, 7.35326484e-02f, 1.21460266e-01f, -5.28995171e-02f, 2.02890486e-03f,
  5.14094159e-02f, -5.05277701e-02f, 2.92654298e-02f, -1.28646836e-01f, 1.27839580e-01f, 7.67870769e-02f, 1.00254141e-01f, 9.66719911e-03f, -1.38022915e-01f, -6.69405535e-02f,
  -7.89351091e-02f, 4.58817668e-02f, 1.41640743e-02f, -4.78131138e-02f, 2.77522076e-02f, 8.75964481e-03f, -4.36827391e-02f, 2.55656410e-02f, 1.14506893e-01f, 3.01777944e-02f,
  8.26018304e-02f, -4.84020524e-02f, -9.50291902e-02f, 9.25474707e-03f, 1.09864604e-02f, 4.78962883e-02f, 7.39383101e-02f, 3.27147618e-02f, -7.61706382e-03f, 5.31574711e-02f,
  -3.19480412e-02f, 6.27986863e-02f, -4.81463782e-02f, -5.01753278e-02f, -3.13208066e-02f, 2.19915733e-02f, 2.75016185e-02f, -1.00007437e-01f, 4.53439243e-02f, 4.16804664e-02f,
  2.56473832e-02f, 2.56417871e-01f, -6.62960112e-02f, 1.78103536e-01f, 1.96652450e-02f, -3.19343023e-02f, 9.96300504e-02f, 2.15367451e-02f, 1.66162960e-02f, 1.43113226e-01f,
  1.86823178e-02f, 6.35099187e-02f, 2.57617477e-02f, 2.89857090e-01f, 1.36083677e-01f, 1.36993468e-01f, 1.90343454e-01f, 3.80706340e-02f, 1.29685439e-02f, 1.08298361e-01f,
  1.01406120e-01f, 1.98657736e-01f, 2.47904118e-02f, 6.82447031e-02f, 3.80197838e-02f, -4.91127633e-02f, 5.63587770e-02f, -5.52248806e-02f, 5.56572899e-02f, -2.33025849e-02f,
  -5.89714013e-02f, 5.13958372e-02f, -8.04893523e-02f, -8.45447481e-02f, 6.19222522e-02f, 1.15173459e-02f, 1.74861366e-03f, -6.13497458e-02f, -1.88571848e-02f, 5.37595041e-02f,
  -4.32236642e-02f, 8.75570625e-03f, 5.05838990e-02f, -3.35956924e-02f, -4.91591357e-02f, 2.37781089e-02f, -6.25591818e-03f, 2.94078588e-02f, -4.49105911e-03f, -3.76931205e-02f,
  -4.27205041e-02f, 7.41721541e-02f, -2.43688710e-02f, 1.15407757e-01f, 3.13916281e-02f, 7.44150281e-02f, 1.82827394e-02f, -3.20701674e-02f, -2.93568848e-03f, 9.19590667e-02f,
  -4.36016917e-02f, 3.43773402e-02f, -9.97241680e-03f, 2.63081826e-02f, 6.38913512e-02f, 2.17102971e-02f, -6.49324507e-02f, -2.06808671e-02f, 3.83065753e-02f, 1.63709670e-02f,
  -1.11446623e-02f, -5.05805314e-02f, -2.53590140e-02f, -1.16183367e-02f, 4.17327732e-02f, 2.41075270e-03f, -1.03619151e-01f, 1.45264603e-02f, -4.50991616e-02f, -2.25858148e-02f,
  -1.23229036e-02f, -1.90272368e-02f, 7.04851523e-02f, -6.47516400e-02f, 5.55838533e-02f, 1.75786074e-02f, -7.64920237e-03f, -4.04116232e-03f, -6.36534393e-02f, -4.91230562e-02f,
  1.43311530e-01f, 1.29386008e-01f, 1.99163202e-02f, -1.04713943e-02f, -5.57922572e-03f, 5.81234880e-02f, 6.93120509e-02f, 8.52536559e-02f, 9.52125415e-02f, 4.15694825e-02f,
  1.15059996e-02f, -6.43308088e-02f, -4.47458997e-02f, -2.94464771e-02f, -4.42630462e-02f, 1.12868294e-01f, -3.81024592e-02f, -1.34647889e-02f, -3.10057048e-02f, 4.61186357e-02f,
  2.43027753e-04f, -3.58585157e-02f, -2.60782149e-02f, -4.02073152e-02f, 1.15341023e-02f, -3.61418165e-02f, -4.27456461e-02f, -9.61137488e-02f, 8.32398012e-02f, -1.34798437e-02f,
  -2.48341057e-02f, 1.38021737e-01f, -2.60687649e-01f, -4.34500165e-02f, -1.29755989e-01f, -3.33405025e-02f, 1.01639688e-01f, -1.19158790e-01f, 1.45193815e-01f, 1.31495863e-01f,
  -6.77914470e-02f, 2.37713736e-02f, 9.40595493e-02f, 1.52119342e-02f, 1.89242568e-02f, 1.03073694e-01f, 1.59907565e-01f, 1.25428781e-01f, 1.07922293e-01f, 3.49526517e-02f,
  -7.19153732e-02f, -3.60091962e-02f, -2.09805995e-01f, -1.00069657e-01f, -1.95605740e-01f, -2.19360813e-01f, -1.09181188e-01f, -1.40105128e-01f, -2.31477380e-01f, -1.95923254e-01f,
  -8.94303918e-02f, -7.06548169e-02f, -1.35791734e-01f, 5.80343641e-02f, -1.30823895e-01f, -5.78531213e-02f, -5.63460737e-02f, -4.58072033e-03f, -1.35614440e-01f, -2.13305429e-02f,
  5.33878468e-02f, -7.99330231e-03f, 3.47748734e-02f, 4.02178019e-02f, -4.53601517e-02f, 5.80197163e-02f, -6.36931136e-02f, -3.28918919e-02f, 6.90110251e-02f, 5.73885301e-03f,
  -1.27282858e-01f, -1.90291982e-02f, -2.51362156e-02f, 8.25587586e-02f, -9.64949504e-02f, -9.37614962e-02f, 6.32823259e-02f, -1.04619600e-01f, -1.27957821e-01f, 4.52932753e-02f,
  -1.48557927e-02f, 2.63613965e-02f, -9.21939462e-02f, 5.38371764e-02f, -2.79028732e-02f, -1.39779329e-01f, 3.56106125e-02f, 5.44290543e-02f, 1.19977619e-03f, 4.46199588e-02f,
  -9.80216563e-02f, 2.38034520e-02f, -2.01220065e-02f, 1.98958237e-02f, 1.06722578e-01f, -5.13458364e-02f, -8.49131867e-02f, -2.99915299e-02f, 9.48295444e-02f, 8.40394758e-03f,
  -1.51385190e-02f, 7.66113698e-02f, -9.81508717e-02f, -6.42208457e-02f, 7.06399456e-02f, -9.60756987e-02f, -2.90779378e-02f, 3.20334360e-02f, 9.87303406e-02f, 5.83590881e-04f,
  -2.57819034e-02f, 1.68348551e-01f, 7.36296102e-02f, -8.61436501e-02f, 3.46366689e-02f, -8.08253735e-02f, 5.23452759e-02f, 2.14155912e-02f, -7.66659528e-02f, -5.44424206e-02f,
  6.60164282e-02f, 6.08392470e-02f, -7.82199949e-02f, -4.36647758e-02f, -3.31823854e-03f, 2.43981043e-03f, 5.76623380e-02f, 1.03604645e-01f, 1.24937326e-01f, -6.04474079e-03f,
  1.11541413e-01f, 2.23364178e-02f, 2.77869105e-02f, -6.02300428e-02f, -1.57531723e-02f, -7.61826336e-02f, 1.88904442e-02f, -3.73316817e-02f, 6.56246841e-02f, 2.24599130e-02f,
  -1.87123880e-01f, -1.01031438e-01f, 2.36388326e-01f, -1.90931320e-01f, -1.61457565e-02f, 2.13741764e-01f, 1.45467579e-01f, -2.08388597e-01f, -2.65393823e-01f, -2.49333248e-01f,
  -4.01712880e-02f, 9.33249108e-03f, 2.68545508e-01f, -8.47337618e-02f, 2.16432318e-01f, 1.46332905e-01f, -4.68294807e-02f, 1.18020624e-01f, 7.26929400e-03f, -1.10754691e-01f,
  -2.25253552e-02f, -1.05522051e-01f, 2.32046753e-01f, -1.32351473e-01f, -6.64073005e-02f, -4.07603197e-02f, -7.32003301e-02f, 1.76895916e-01f, -5.83134629e-02f, 5.02417870e-02f,
  -6.74271211e-02f, -8.37906227e-02f, -5.23167737e-02f, 6.15173914e-02f, 5.99027425e-02f, -5.50102163e-03f, 1.00487888e-01f, 1.85926959e-01f, -3.72107029e-02f, -3.77385393e-02f,
  6.92087710e-02f, 4.08664495e-02f, -9.32015032e-02f, -1.49797108e-02f, -4.70163450e-02f, -5.82393818e-02f, 1.08096162e-02f, 3.67152765e-02f, 3.72875948e-03f, 9.07664448e-02f,
  6.50495738e-02f, 2.43159523e-03f, 2.33933162e-02f, 9.34464484e-03f, 5.84146455e-02f, 9.19669587e-03f, 3.16897668e-02f, 7.35125318e-02f, -2.76350733e-02f, -5.65192336e-03f,
  1.28189949e-02f, -5.29443435e-02f, -2.13150010e-02f, -4.00292873e-02f, 1.18324803e-02f, -5.46192080e-02f, -2.17563566e-02f, 4.14335690e-02f, 2.35865060e-02f, -3.47881019e-02f,
  -4.81526135e-03f, -5.85922040e-02f, -5.90586569e-03f, -3.09390277e-02f, -5.66456355e-02f, -1.26612827e-01f, 8.89907256e-02f, 1.14720203e-02f, -5.40126860e-02f, -5.64382458e-03f,
  -4.85785352e-03f, -4.41320129e-02f, 6.97274879e-02f, 7.61210322e-02f, 2.90814266e-02f, 1.23585515e-01f, 3.30978562e-03f, -4.57546636e-02f, -3.13918479e-02f, 1.25340477e-01f,
  -1.85001288e-02f, -7.60613084e-02f, 1.56455860e-02f, 1.02792736e-02f, -1.88711882e-02f, -8.90844967e-03f, 2.88979104e-03f, -2.66465507e-02f, 4.31545898e-02f, -8.10944811e-02f,
  -8.91097486e-02f, -7.96892960e-03f, 2.34581511e-02f, -4.77847718e-02f, -1.75679140e-02f, 7.35031068e-02f, 1.90509520e-02f, 2.51406245e-02f, -7.86721148e-03f, -7.14457110e-02f,
  4.03035730e-02f, -5.24305403e-02f, 4.79592271e-02f, -4.14148942e-02f, -2.88250055e-02f, -5.06727248e-02f, -8.20427164e-02f, -1.28088314e-02f, 5.50991446e-02f, -6.34260103e-02f,
  -2.72538334e-01f, 1.85916454e-01f, -8.43774620e-03f, 3.67562175e-02f, -1.37402922e-01f, 1.54096514e-01f, 1.84444577e-01f, -4.00788300e-02f, 8.17141682e-02f, 2.01520458e-01f,
  9.51087475e-02f, -5.93710281e-02f, 1.55014619e-01f, 9.68247578e-02f, 4.95050699e-02f, 2.23743170e-01f, 8.84322003e-02f, 1.36602595e-01f, -4.34355997e-03f, -1.63878471e-01f,
  -1.29330248e-01f, -1.28609240e-02f, 1.17009422e-02f, -1.01298383e-02f, -1.37529075e-01f, -1.66523337e-01f, -6.80858120e-02f, -1.41467214e-01f, 6.43593520e-02f, -1.24386353e-02f,
  5.58779500e-02f, -2.02658057e-01f, -1.63637549e-01f, -2.99600232e-02f, -1.99996345e-02f, -2.50637345e-03f, -1.23755494e-02f, 1.04748402e-02f, -6.70299828e-02f, -4.06258814e-02f,
  -6.29630238e-02f, -9.79404449e-02f, -1.35103399e-02f, 2.78546624e-02f, -9.46240351e-02f, -1.95114072e-02f, 8.59039351e-02f, 1.34816661e-03f, -3.56626324e-02f, -5.99892139e-02f,
  -7.48500302e-02f, 1.07879294e-02f, -1.56297386e-02f, 7.70655051e-02f, 4.94284481e-02f, 8.09439197e-02f, 1.07937366e-01f, -5.34028597e-02f, 5.41765690e-02f, 9.55937132e-02f,
  -3.65407695e-03f, -1.08431242e-01f, 3.45090032e-02f, -6.23783953e-02f, 3.53512913e-02f, 4.37568640e-03f, -2.06426736e-02f, 5.55884354e-02f, 1.67530552e-02f, 7.57939890e-02f,
  1.79368444e-02f, -4.87175621e-02f, -4.75920215e-02f, 2.56273523e-02f, -1.11743575e-02f, 7.95410480e-03f, -2.58460883e-02f, -5.91710024e-02f, 2.76165977e-02f, 5.22881001e-02f,
  -7.50029534e-02f, -6.84921369e-02f, -1.23073836e-03f, 2.14810278e-02f, -1.58057380e-02f, 6.01993874e-02f, 7.52442405e-02f, 3.95546332e-02f, 6.15103208e-02f, 2.94797309e-02f,
  8.91623870e-02f, -1.59424007e-01f, 1.09653817e-02f, -4.60521244e-02f, -5.41363433e-02f, 7.53044114e-02f, 1.01783068e-03f, -1.09547608e-01f, 7.47795310e-03f, -8.38720351e-02f,
  4.72946442e-04f, 1.96605567e-02f, -3.94012369e-02f, 6.81291893e-03f, 5.83840497e-02f, 6.97455332e-02f, 9.95849166e-03f, 6.18655719e-02f, 9.46364403e-02f, 8.65901820e-03f,
  4.92515117e-02f, -6.99569434e-02f, 5.66605628e-02f, -1.13775283e-02f, 3.19783986e-02f, 3.05719357e-02f, -1.16896003e-01f, 8.05783086e-03f, -1.50293752e-03f, 5.57577871e-02f,
  -2.56123245e-01f, 6.58257008e-02f, -1.34932827e-02f, -1.37027264e-01f, -1.53763250e-01f, -1.41686067e-01f, -2.79759970e-02f, -4.98326011e-02f, -1.20027080e-01f, -1.92387740e-03f,
  -6.90315738e-02f, 1.30198449e-01f, -5.73447198e-02f, 4.56941091e-02f, 1.72262006e-02f, 1.09675683e-01f, -3.95801999e-02f, -2.56758351e-02f, 1.04335034e-02f, -2.15202332e-01f,
  3.79439816e-02f, -1.38165087e-01f, -3.16266231e-02f, 1.28274430e-02f, -3.47814523e-02f, -7.13925436e-02f, -5.65009974e-02f, -3.04032825e-02f, 4.15026806e-02f, 1.49837941e-01f,
  -2.02949509e-01f, -1.93833306e-01f, -2.35152528e-01f, 5.83719788e-03f, -5.23328558e-02f, 3.52845713e-02f, -5.84596097e-02f, -2.39105970e-02f, -4.49573509e-02f, -1.50733888e-01f,
  2.59358454e-02f, 3.54558341e-02f, 1.21332675e-01f, -2.56180633e-02f, -5.83272688e-02f, 1.48279667e-02f, 7.51857413e-03f, 3.75468992e-02f, 4.64854129e-02f, 7.09012300e-02f,
  5.13460413e-02f, 1.99486632e-02f, -1.52364627e-01f, 9.25041437e-02f, 8.63819495e-02f, -3.20335776e-02f, -5.48606180e-02f, 5.92620894e-02f, 9.51243564e-03f, 1.40066436e-02f,
  -3.21084745e-02f, -4.77658324e-02f, 6.77963952e-03f, -7.71190301e-02f, 7.86886439e-02f, 3.84668149e-02f, -7.99997374e-02f, 1.77561045e-02f, 2.09496822e-02f, -4.63437475e-02f,
  3.31675522e-02f, -5.64362109e-02f, -1.03026800e-01f, -7.70157725e-02f, -7.75535554e-02f, -5.19675389e-03f, 3.53977308e-02f, -1.09453417e-01f, 1.22534782e-02f, 1.05341218e-01f,
  -3.44248265e-02f, 2.30003037e-02f, 2.89740376e-02f, -4.53940593e-02f, -5.48450425e-02f, 4.47373949e-02f, -1.08964536e-02f, 9.36612263e-02f, -5.40170074e-02f, 4.63042483e-02f,
  -2.48091549e-01f, -2.43249983e-01f, -6.81302473e-02f, -7.00555295e-02f, 1.68892108e-02f, -8.66306350e-02f, -8.43231902e-02f, 3.39067914e-02f, 2.52640247e-02f, 4.38217307e-03f,
  -9.14079882e-03f, -2.03753226e-02f, 4.46169041e-02f, -2.07786225e-02f, 1.00507155e-01f, 1.22571131e-02f, 5.90712857e-03f, 4.51073609e-02f, -6.68342337e-02f, -4.48799320e-02f,
  -3.45037095e-02f, -6.58275886e-03f, -4.31852974e-02f, -8.79602283e-02f, -8.13400224e-02f, -1.02862706e-02f, 6.11883551e-02f, 4.13867794e-02f, 4.85729389e-02f, -1.67971700e-02f,
  7.56218284e-02f, 1.99104205e-01f, 1.66801274e-01f, 2.63600320e-01f, -1.57303363e-01f, -1.25448838e-01f, -2.01040819e-01f, 1.01012938e-01f, -1.10276528e-02f, -8.35990310e-02f,
  1.76435281e-02f, 2.34710202e-01f, -6.57575876e-02f, 2.00376078e-01f, 2.62136161e-02f, -6.61794469e-02f, 4.91561405e-02f, 6.52577505e-02f, 3.26396525e-02f, 7.83970356e-02f,
  6.41160086e-02f, 3.69919166e-02f, 1.72725782e-01f, 2.94179446e-03f, 1.08098559e-01f, 2.05149502e-01f, 2.44171228e-02f, 5.84136986e-04f, 8.06325972e-02f, 8.06604512e-03f,
  -7.18673244e-02f, 7.95023367e-02f, -2.38170084e-02f, 4.90977690e-02f, -1.94820780e-02f, 6.11793308e-04f, -5.75662591e-02f, -5.63485697e-02f, -5.14391623e-02f, 8.09843689e-02f,
  4.46914621e-02f, 7.40942806e-02f, 1.22016454e-02f, -6.02959394e-02f, 2.87393089e-02f, 2.78311018e-02f, 4.95369770e-02f, 7.84875359e-03f, 9.18184891e-02f, 1.34156212e-01f,
  1.10961296e-01f, 2.95565687e-02f, 2.15211846e-02f, 2.59997044e-02f, 7.83736780e-02f, 6.25282004e-02f, 3.32484208e-02f, 1.38898371e-02f, 7.45253861e-02f, 4.87651415e-02f,
  -6.25355029e-03f, -1.06194548e-01f, -4.07425016e-02f, -1.41009120e-02f, 5.97529858e-02f, -6.89417571e-02f, 5.15436009e-03f, -6.47698268e-02f, -5.19923419e-02f, -6.40704036e-02f,
  -6.30435571e-02f, 3.59959267e-02f, 8.71371254e-02f, -2.33961921e-02f, 2.18283702e-02f, 1.68613177e-02f, -3.77442874e-02f, -8.68919119e-02f, -8.33314061e-02f, 2.13150457e-02f,
  3.91805768e-02f, 1.06320586e-02f, -2.97885705e-02f, -5.25018573e-02f, -5.89106642e-02f, -2.71005221e-02f, 9.30404887e-02f, -3.01938946e-03f, -2.85600405e-02f, -6.39404822e-03f,
  1.95022933e-02f, -9.83553659e-03f, -4.41654846e-02f, -7.32212439e-02f, 3.09150647e-02f, 4.50523868e-02f, 1.29323620e-02f, 6.14927337e-02f, 3.53386328e-02f, -7.61826560e-02f,
  -9.35275406e-02f, 5.19457692e-03f, 3.31413141e-03f, 1.17479432e-02f, 8.80481862e-03f, -7.42386803e-02f, 1.03755132e-03f, 3.36426012e-02f, 6.91035315e-02f, -1.74719957e-03f,
  7.03875721e-02f, -2.45539621e-02f, 6.53726384e-02f, 5.91180008e-03f, -3.43536176e-02f, -7.25883022e-02f, -5.63446283e-02f, 6.37802901e-03f, 5.26640527e-02f, -8.12408254e-02f,
  1.54948577e-01f, -3.72038931e-02f, 1.59746677e-01f, 1.81328341e-01f, 2.93108597e-02f, 3.16296052e-03f, 1.38238305e-02f, 6.19452968e-02f, 2.45881632e-01f, 1.11707337e-02f,
  -5.77519052e-02f, 9.97358784e-02f, -2.63173878e-01f, -1.69455111e-02f, -1.55939475e-01f, -1.04916677e-01f, -2.18705982e-02f, 5.22027984e-02f, -1.11133708e-02f, -4.34651114e-02f,
  -7.65819428e-03f, -1.67565167e-01f, -1.11937761e-01f, -6.34457171e-02f, 2.22519189e-01f, 1.17028847e-01f, -1.31219625e-01f, -1.07409135e-01f, 4.07433026e-02f, -4.55099270e-02f,
  1.05263740e-01f, 3.40306871e-02f, -1.79282874e-02f, 6.36253804e-02f, 7.17613101e-02f, -5.02318703e-02f, -1.58905283e-01f, -8.90907645e-02f, 1.13194510e-01f, -2.41734590e-02f,
  -1.85767524e-02f, 1.48558225e-02f, 3.13594937e-02f, -4.05600294e-02f, 1.22012414e-01f, 7.54205734e-02f, -4.85075377e-02f, 3.12840752e-02f, 1.55953899e-01f, 5.93306683e-02f,
  9.06636491e-02f, 2.66471244e-02f, 7.74776489e-02f, 2.17419509e-02f, -1.38999824e-03f, -5.93636930e-02f, -4.15897779e-02f, 3.99754047e-02f, 6.61731511e-02f, 3.94326858e-02f,
  -8.62827376e-02f, -8.37062374e-02f, 7.21118599e-02f, 9.39996541e-02f, 3.21759917e-02f, 8.04420561e-02f, -2.65956055e-02f, 3.61678377e-02f, 1.59617648e-01f, 1.01705655e-01f,
  -5.08152414e-03f, -4.85716872e-02f, 3.70755792e-02f, 8.52214694e-02f, 1.77429151e-02f, 6.26045614e-02f, 5.55848144e-02f, -5.45875169e-02f, -2.17769928e-02f, -2.76384549e-03f,
  -2.74069291e-02f, 4.46282662e-02f, -6.03506267e-02f, 8.86958092e-02f, 8.29434693e-02f, 1.76640507e-02f, -6.07540272e-02f, 1.15255497e-01f, 2.96779885e-03f, -2.05263030e-02f,
  3.96314375e-02f, -1.77556843e-01f, -6.43372461e-02f, -7.40399435e-02f, 2.57725678e-02f, 5.87807335e-02f, 9.65892896e-03f, 6.13714149e-03f, 3.49911898e-02f, -1.17071159e-01f,
  -3.75543684e-02f, 2.38118544e-02f, -5.44719249e-02f, 5.46839722e-02f, -2.82935593e-02f, -2.39227302e-02f, 1.17304558e-02f, -4.93103713e-02f, -9.57817510e-02f, -1.21679686e-01f,
  3.73365954e-02f, 5.33431361e-04f, 8.86250511e-02f, 5.28795831e-02f, 3.90466787e-02f, 4.05764170e-02f, 3.16609889e-02f, 1.92033835e-02f, 4.99753514e-03f, -1.72731411e-02f,
  -2.74075614e-03f, -1.21948989e-02f, 1.63317025e-01f, 1.37952745e-01f, -3.00118346e-02f, -2.32371077e-01f, -2.12118432e-01f, -4.08806801e-02f, 1.34912223e-01f, -1.06006600e-01f,
  -1.93452299e-01f, 1.62675753e-01f, -1.08211823e-01f, 7.23753497e-02f, 5.86594827e-02f, 2.07569033e-01f, 1.43909603e-02f, -1.18368097e-01f, 1.61444291e-01f, 7.41416961e-02f,
  1.72121927e-01f, 7.46556446e-02f, 5.95238283e-02f, 2.15910561e-02f, -1.51452385e-02f, 9.09440070e-02f, 2.14776292e-01f, 1.38029829e-01f, 2.23467853e-02f, 2.70462092e-02f,
  -1.24696970e-01f, 1.92707524e-01f, 2.79020742e-02f, -2.39210743e-02f, -3.61710601e-02f, -1.62294999e-01f, -2.90089827e-02f, -5.53337075e-02f, -3.44685763e-02f, -3.61991674e-02f,
  -7.48857334e-02f, 5.90900006e-03f, 1.95027255e-02f, 5.49508892e-02f, -7.60850962e-03f, 7.03125149e-02f, 1.05555229e-01f, -7.30587840e-02f, -4.32162732e-02f, -6.51455820e-02f,
  9.09398124e-02f, 3.87377068e-02f, 5.71144819e-02f, 1.37343541e-01f, 9.11054015e-03f, 7.72159621e-02f, -7.93416277e-02f, 1.02137841e-01f, 7.24255443e-02f, 8.27068537e-02f,
  -2.08572950e-02f, 2.41151024e-02f, -1.45275975e-02f, -2.67390888e-02f, -7.07889860e-03f, 7.00384602e-02f, 2.92333029e-02f, -1.20822184e-01f, -8.61545727e-02f, -5.06708995e-02f,
  5.54560348e-02f, -6.99136555e-02f, -4.15283293e-02f, 6.23975135e-03f, 2.42577177e-02f, -1.10197872e-01f, 6.99225888e-02f, 9.06500593e-02f, 6.81169927e-02f, 3.29368794e-03f,
  1.13153078e-01f, -1.19904160e-01f, 3.19167152e-02f, -6.85343444e-02f, -1.08612344e-01f, -2.38718875e-02f, 8.13396499e-02f, 7.66860023e-02f, 9.88499373e-02f, 6.74048299e-03f,
  1.03289522e-01f, 3.03682119e-01f, 7.76932687e-02f, 4.28831503e-02f, 4.64948220e-03f, 4.17018384e-02f, -9.35924426e-03f, -4.24427353e-02f, 1.03353091e-01f, 3.09579354e-02f,
  -4.58696410e-02f, 5.93181849e-02f, -2.94530671e-02f, 5.80487959e-02f, 1.13451891e-01f, -1.67855229e-02f, 9.29641649e-02f, 9.25195962e-02f, 1.48915380e-01f, 9.70424041e-02f,
  2.95992475e-02f, -1.45272523e-01f, -2.13530310e-03f, -5.17420359e-02f, -6.83183447e-02f, -1.48739517e-02f, 4.18200865e-02f, -4.10176441e-02f, -1.58030502e-02f, 1.64810270e-02f,
  2.40422904e-01f, -2.65961468e-01f, 2.09804177e-01f, 2.03123406e-01f, 1.33311659e-01f, -6.42285123e-03f, 1.78333551e-01f, -1.83303896e-02f, 1.25734031e-01f, -2.62158692e-01f,
  -8.05189684e-02f, 6.98939413e-02f, -7.61896521e-02f, 4.04288843e-02f, 2.89390492e-03f, -8.88324678e-02f, 1.31016178e-02f, -4.62384038e-02f, -1.30064934e-02f, 4.33182530e-02f,
  9.41185355e-02f, 4.95482190e-03f, 5.01874462e-02f, -1.94259122e-01f, 3.65385860e-02f, 9.61788297e-02f, -4.74032685e-02f, -1.34815082e-01f, -1.86098553e-02f, 7.52584264e-02f,
  -6.79954439e-02f, 6.18233271e-02f, -7.83314556e-03f, -1.63330305e-02f, -5.25589585e-02f, -5.60755022e-02f, 6.85036927e-02f, -3.69933881e-02f, 2.79469695e-03f, 4.22098860e-02f,
  4.43287045e-02f, 3.74150984e-02f, 1.33923944e-02f, -3.31113040e-02f, 4.26097447e-03f, 3.12139783e-02f, 1.61106914e-01f, -1.50907291e-02f, 1.97949056e-02f, -1.02287736e-02f,
  5.86482510e-02f, 7.63671175e-02f, 8.02840739e-02f, -3.37756313e-02f, 6.10134080e-02f, 9.87241324e-03f, 4.24509719e-02f, -4.74630594e-02f, -2.05094218e-02f, -1.02455216e-02f,
  -8.64453167e-02f, -9.95450690e-02f, -2.86779366e-02f, 6.68176860e-02f, 7.88563788e-02f, 2.28594504e-02f, -1.78167056e-02f, -1.61410589e-02f, 2.55894242e-03f, -2.63817776e-02f,
  2.62256842e-02f, -4.66897525e-02f, -6.16860343e-03f, 9.70646646e-03f, -8.88989493e-02f, 6.42332807e-02f, -7.04283416e-02f, 4.91947085e-02f, -3.36716548e-02f, 2.33571678e-02f,
  -7.51746744e-02f, 4.90539074e-02f, -1.71002652e-02f, 2.33787787e-03f, -1.76528224e-03f, 4.36888039e-02f, 2.11468022e-02f, -4.42233197e-02f, -1.22087321e-03f, -7.40825459e-02f,
  -2.29900792e-01f, -2.63408542e-01f, -1.49141136e-03f, -2.86704078e-02f, -5.77120408e-02f, -9.82127897e-03f, -4.84893471e-03f, 7.62036294e-02f, -1.16128087e-01f, -3.99095938e-02f,
  -2.38148198e-02f, 3.07672676e-02f, -3.58479582e-02f, 1.29606379e-02f, -1.02087390e-02f, -1.18365638e-01f, -3.82067785e-02f, -3.82129662e-02f, -4.65170071e-02f, -2.31117103e-02f,
  -3.58483605e-02f, -7.70122185e-02f, 5.84352426e-02f, 8.05370584e-02f, -1.38854846e-01f, -1.78568009e-02f, 1.49352858e-02f, -7.03771561e-02f, 2.64884438e-02f, 6.71232026e-03f,
  -1.21394791e-01f, 1.04734674e-01f, 1.39113958e-03f, 3.50442708e-01f, -9.98880863e-02f, -4.53568324e-02f, 1.95621625e-02f, -2.36567482e-02f, -2.45672747e-01f, 6.68956637e-02f,
  9.99021083e-02f, 7.35194981e-03f, -5.37003316e-02f, 3.26546699e-01f, 1.43082947e-01f, 1.27367988e-01f, 1.95267707e-01f, 3.84542905e-02f, -5.29690497e-02f, 1.02914609e-01f,
  6.08714074e-02f, 2.99502194e-01f, 1.99073106e-01f, 1.03464864e-01f, 5.46151213e-02f, 2.10143011e-02f, 1.28603339e-01f, -8.92051309e-03f, 1.84066236e-01f, 4.29873317e-02f,
  -4.07707272e-03f, 3.96389700e-02f, -3.65776499e-03f, -8.63089710e-02f, 3.20252590e-02f, 1.19115757e-02f, -4.51845909e-03f, -2.22466327e-03f, 2.74132229e-02f, 1.96254681e-04f,
  -1.64464880e-02f, 5.38214929e-02f, -6.85110241e-02f, 8.51844251e-02f, -6.10536337e-02f, 5.76815754e-02f, -2.57603433e-02f, -2.32596826e-02f, 5.97001091e-02f, 7.77214095e-02f,
  1.85335521e-02f, 2.78768986e-02f, 6.03005029e-02f, -2.41494011e-02f, -7.88772255e-02f, 5.59713058e-02f, 1.63193848e-02f, -3.63434143e-02f, -7.50421733e-02f, 1.76087301e-02f,
  -6.28066435e-02f, -3.09638865e-02f, 6.30364344e-02f, -4.10826458e-03f, 6.52599558e-02f, 7.05465525e-02f, 2.65522189e-02f, -6.73343018e-02f, -3.20023037e-02f, 1.35724500e-01f,
  7.51386061e-02f, -1.44582251e-02f, 5.10023050e-02f, -4.14491855e-02f, 3.09059140e-03f, 6.68006688e-02f, -1.35632176e-02f, 5.21151014e-02f, 2.39132699e-02f, -5.19093834e-02f,
  -6.31193742e-02f, 1.85518432e-02f, 6.61298335e-02f, -1.00543767e-01f, -6.01252168e-02f, -8.74461830e-02f, -6.54668501e-03f, -1.19147273e-02f, 6.91850930e-02f, -1.59945544e-02f,
  7.35423714e-02f, 4.94957268e-02f, -8.34612772e-02f, -3.37884054e-02f, -3.87727097e-02f, -1.45069545e-03f, -1.15385326e-02f, -7.86662996e-02f, 1.42121045e-02f, -2.32235920e-02f,
  1.34942913e-02f, 4.01818156e-02f, -1.03130275e-02f, 4.40434963e-02f, -1.68551807e-03f, -2.60157958e-02f, -7.81177590e-03f, -1.96529049e-02f, 4.08914126e-02f, 9.56786647e-02f,
  8.29599127e-02f, 2.51564421e-02f, 1.20003959e-02f, -2.32193954e-02f, -6.32224185e-03f, 1.22240894e-02f, 1.43342763e-02f, -3.03035397e-02f, -4.34910506e-02f, -5.14365546e-02f,
  1.91398740e-01f, -1.29984364e-01f, -1.75135210e-01f, 3.89850438e-02f, 6.42573014e-02f, 7.22835734e-02f, -7.85098374e-02f, 5.01132309e-02f, -1.21333607e-01f, -6.80135116e-02f,
  8.58933777e-02f, -7.33510358e-03f, -1.99162677e-01f, 1.75196290e-01f, 1.26224995e-01f, -1.76606327e-01f, 1.95487112e-01f, 7.07078353e-02f, -1.25592694e-01f, -8.38791803e-02f,
  -3.10803484e-02f, 3.02384555e-01f, -1.34897336e-01f, 7.26883933e-02f, 1.46780163e-01f, -1.45775989e-01f, 7.08153695e-02f, -9.70030576e-02f, 1.60142198e-01f, 2.25117579e-02f,
  -2.39096563e-02f, -1.21363640e-01f, -5.78159746e-03f, -4.05795909e-02f, -1.89344790e-02f, 4.31180857e-02f, -8.05359185e-02f, 9.76160616e-02f, 2.28036176e-02f, -1.11545071e-01f,
  3.21532739e-03f, -1.66499260e-04f, -2.08429601e-02f, -1.37120625e-02f, 1.22057840e-01f, 4.86491024e-02f, -4.97254217e-03f, -5.19670472e-02f, 2.20260005e-02f, -9.83050279e-03f,
  -1.24238782e-01f, -7.77485594e-02f, -6.72198161e-02f, 8.73518270e-03f, -3.48388851e-02f, -6.59106150e-02f, -1.01076089e-01f, -6.73654154e-02f, -3.08636259e-02f, 7.40534440e-02f,
  -3.95045467e-02f, 8.28438532e-03f, -6.24340139e-02f, -6.09991956e-04f, 1.21579789e-01f, -3.59161235e-02f, 5.95408026e-03f, 1.01324216e-01f, 5.14883883e-02f, 1.18452035e-01f,
  1.01968283e-02f, 3.96133773e-02f, -1.53104952e-02f, -2.45490503e-02f, -4.13398147e-02f, -1.56082790e-02f, 5.15649319e-02f, 1.05641969e-02f, 2.80156415e-02f, 3.10586002e-02f,
  1.39124598e-02f, -1.85281467e-02f, 9.94983036e-03f, -4.44740765e-02f, 1.48526989e-02f, 8.77441913e-02f, 7.66422227e-02f, 4.96086217e-02f, -2.58292444e-03f, 5.24155213e-04f,
  6.59158975e-02f, -7.48104379e-02f, -8.92082751e-02f, 8.91212448e-02f, -4.83766235e-02f, 5.49230501e-02f, -3.42479795e-02f, -2.62039490e-02f, -1.15450270e-01f, 7.77095780e-02f,
  -1.88971050e-02f, -8.39115158e-02f, -4.73447591e-02f, 1.05153337e-01f, 4.31878027e-03f, 7.68759698e-02f, -9.05848220e-02f, 2.08868762e-03f, 7.06237406e-02f, 6.62327185e-02f,
  -6.93001077e-02f, -8.13073590e-02f, 6.38696784e-03f, -9.73769929e-03f, 8.11539069e-02f, -1.21947221e-01f, 1.57654751e-02f, -4.03151847e-03f, 1.56351700e-02f, -6.26283116e-04f,
  -1.97620034e-01f, 5.18969670e-02f, -1.13176376e-01f, 2.59672105e-03f, -7.99683630e-02f, 1.71429515e-01f, 3.20360750e-01f, 1.22766308e-02f, 3.87859941e-02f, 2.55579025e-01f,
  1.90401047e-01f, 4.01568115e-02f, 1.13715954e-01f, 2.54822850e-01f, 1.08628944e-02f, 5.97883277e-02f, 1.96593300e-01f, 5.50041087e-02f, 1.05484843e-03f, 2.63415128e-02f,
  -2.09977329e-02f, 1.94631010e-01f, -7.97376260e-02f, -6.28356487e-02f, 1.58818990e-01f, -9.77870822e-02f, 8.91961381e-02f, -4.34713997e-02f, 1.13212898e-01f, 1.06664851e-01f,
  2.97574699e-02f, 8.29522312e-02f, -1.47167025e-02f, -7.63722584e-02f, -2.05447543e-02f, -1.87827535e-02f, 3.19484882e-02f, -6.52355999e-02f, -7.30015859e-02f, 6.47023413e-03f,
  -1.84907876e-02f, -3.15431356e-02f, -4.01213244e-02f, -3.81578393e-02f, -1.71221942e-02f, -1.19739853e-01f, 3.51353586e-02f, -6.85103461e-02f, -3.76615524e-02f, -4.14649956e-02f,
  5.01967296e-02f, 4.25394438e-03f, 7.05345646e-02f, -3.57221509e-03f, 2.59046052e-02f, -6.69732541e-02f, 1.79148111e-02f, -4.10763100e-02f, -1.76738277e-02f, -3.07404641e-02f,
  -5.52735897e-03f, 3.42074111e-02f, 8.99623428e-03f, 1.15080670e-01f, -1.08506367e-01f, -2.72063352e-02f, 9.45678502e-02f, -2.41501513e-03f, -8.04754794e-02f, -1.80541016e-02f,
  -2.67685596e-02f, 5.05524129e-02f, 8.10773969e-02f, -2.14779116e-02f, 7.95428082e-02f, -3.58294882e-02f, 9.85539798e-03f, 5.51164523e-02f, -4.64671105e-02f, 6.49421364e-02f,
  8.07463527e-02f, -1.15338508e-02f, 1.04915779e-02f, 1.55545566e-02f, 7.08409846e-02f, 4.02818769e-02f, 7.58080855e-02f, 3.15373279e-02f, 5.92706539e-02f, -6.23589605e-02f,
  1.50564030e-01f, 4.66347188e-02f, -2.61614262e-03f, 9.91136879e-02f, 2.87701748e-02f, -6.31182874e-03f, -3.10448324e-03f, -1.76330432e-02f, 2.41088383e-02f, 8.38522464e-02f,
  2.80818306e-02f, 6.75276220e-02f, 1.01836920e-02f, -4.88206260e-02f, -9.88348946e-02f, 9.79591906e-02f, 9.23646390e-02f, -1.98872462e-02f, 1.78328101e-02f, -2.15932187e-02f,
  4.81955661e-03f, -7.87764136e-03f, -2.82996930e-02f, -2.81417742e-02f, -7.29668215e-02f, 1.12745434e-01f, 1.80669054e-02f, 9.32980999e-02f, 5.80671653e-02f, 3.30769978e-02f,
  1.36214450e-01f, 7.42262080e-02f, -1.24793842e-01f, 7.36106746e-03f, -6.75884113e-02f, -7.61545263e-04f, -6.46838099e-02f, 7.28725642e-02f, -1.12577498e-01f, 8.15924108e-02f,
  6.29698411e-02f, -5.65681383e-02f, -5.07945940e-03f, -1.73019707e-01f, -2.64749616e-01f, -1.34689078e-01f, -1.08892336e-01f, -6.47759414e-04f, -1.33618981e-01f, 4.25508693e-02f,
  -4.45580520e-02f, 1.38274625e-01f, -8.68882015e-02f, 6.94110468e-02f, 1.43746898e-01f, 1.12858698e-01f, 1.58258155e-01f, 7.09700286e-02f, 1.34996802e-01f, -2.86531094e-02f,
  -6.65157735e-02f, 5.17593250e-02f, 4.98900376e-03f, 2.17713360e-02f, 4.36646566e-02f, 7.53616318e-02f, 1.30252138e-01f, -3.10622305e-02f, 1.63253639e-02f, -9.65027660e-02f,
  7.50955706e-03f, 7.31322914e-02f, -6.95866123e-02f, -1.79475397e-02f, 6.29183203e-02f, -8.09720382e-02f, -1.95104536e-02f, 2.54966933e-02f, -1.92192629e-01f, -1.43258693e-02f,
  7.39397248e-03f, -6.28892332e-02f, 1.18147507e-01f, 9.76275932e-03f, -1.71780791e-02f, -9.08245444e-02f, -4.18974720e-02f, -7.71706998e-02f, -2.50192787e-02f, 5.82346879e-02f,
  2.05679685e-02f, -2.40190122e-02f, 4.60967198e-02f, 2.39650905e-02f, 6.45822212e-02f, -7.24911317e-02f, 1.22233555e-02f, -8.13344643e-02f, 1.91293005e-02f, -8.35071206e-02f,
  -6.39045686e-02f, -3.48667242e-02f, -2.44922731e-02f, 9.84771848e-02f, -7.86151215e-02f, 6.00901991e-02f, -2.38691326e-02f, 2.97653154e-02f, -2.54586595e-03f, -2.86298618e-02f,
  -6.60709664e-02f, -1.86378863e-02f, -6.03463463e-02f, 2.30645463e-02f, -1.41136065e-01f, 6.82859719e-02f, 7.08205923e-02f, 6.79943934e-02f, -1.90572701e-02f, 6.76570609e-02f,
  -5.94430566e-02f, 6.90591289e-03f, 1.75289661e-02f, 5.94497565e-03f, -7.06842402e-03f, 2.62862314e-02f, -2.60102637e-02f, 9.25376639e-02f, 5.67766614e-02f, -3.89499939e-03f,
  8.62013996e-02f, -3.94873731e-02f, 6.64229244e-02f, 4.99875993e-02f, -8.95723701e-02f, 2.01430619e-02f, -3.78386676e-02f, 6.36453703e-02f, -1.04198843e-01f, 2.32626311e-02f,
  1.64872468e-01f, 9.36093405e-02f, 1.52651500e-02f, 3.52348723e-02f, 1.05809368e-01f, 9.11719650e-02f, 2.49924231e-02f, 1.33234262e-01f, -2.98938155e-02f, -3.53244729e-02f,
  1.86992198e-01f, -2.13132992e-01f, -1.47159189e-01f, 1.68213844e-02f, 4.27628495e-03f, 9.34257582e-02f, -4.43063583e-03f, -1.06933504e-01f, -2.58727092e-02f, -1.40398830e-01f,
  -7.96026085e-03f, -1.34635687e-01f, -1.41064629e-01f, 1.88408941e-01f, 2.33530581e-01f, -1.40846640e-01f, 1.39914200e-01f, -7.97802880e-02f, 2.84101954e-03f, -1.38755450e-02f,
  1.71761364e-02f, 2.61425048e-01f, -4.63849455e-02f, 5.42960241e-02f, 1.19908333e-01f, 6.21941537e-02f, 1.02511376e-01f, -8.12736824e-02f, 1.71677023e-01f, 6.44247755e-02f,
  1.20798543e-01f, 1.21150827e-02f, 7.95026496e-02f, 1.44626554e-02f, -2.62334589e-02f, -1.08457990e-01f, 3.53150703e-02f, 5.65133393e-02f, -3.03388368e-02f, -2.52926014e-02f,
  -2.26594545e-02f, 4.53095622e-02f, 2.51570921e-02f, 1.73504744e-02f, -1.16885472e-02f, 2.58053616e-02f, -6.05735295e-02f, 4.56165726e-04f, -5.49264476e-02f, -9.81342793e-03f,
  -1.15775160e-01f, 1.35671590e-02f, 1.76966265e-02f, 3.82813029e-02f, -2.15940662e-02f, 1.24966539e-02f, 5.24065644e-02f, -7.36332983e-02f, 6.96430076e-03f, -3.53057199e-04f,
  9.41050649e-02f, 3.89632024e-02f, -2.21752338e-02f, 2.20548641e-02f, -6.01783805e-02f, 3.92746851e-02f, 1.00230418e-01f, -6.42651543e-02f, -5.40533848e-02f, -3.01369205e-02f,
  -7.18906298e-02f, -4.00817720e-03f, 8.13531596e-03f, 3.04910783e-02f, 1.80815998e-02f, -5.74397892e-02f, 2.00827066e-02f, 1.95415504e-02f, -1.01080403e-01f, 1.00868093e-02f,
  7.68471137e-02f, 2.90181059e-02f, -9.30959806e-02f, 1.19810648e-01f, 6.22400679e-02f, -1.62053123e-01f, 4.23714221e-02f, -5.68065085e-02f, -4.43142131e-02f, -1.23770144e-02f,
  -4.76259319e-03f, -1.41874954e-01f, -1.10505424e-01f, 4.21188027e-02f, -6.86198398e-02f, -1.28324749e-02f, 1.54150845e-02f, 2.84454152e-02f, 1.65562574e-02f, 3.25507149e-02f,
  5.58746010e-02f, 3.06333769e-02f, 7.56360441e-02f, -1.86755660e-03f, -2.88870614e-02f, -5.94668761e-02f, 1.21849641e-01f, 3.30981705e-03f, -1.84939466e-02f, -2.58824080e-02f,
  1.93130076e-02f, 3.55748576e-03f, -2.22389940e-02f, 1.52504528e-02f, 2.92321183e-02f, 5.65316491e-02f, 5.36581781e-03f, -2.26264615e-02f, 3.41654904e-02f, -4.87566590e-02f,
  1.38378859e-01f, 6.97520981e-03f, 5.59943542e-03f, -4.05713357e-02f, -6.32818565e-02f, -1.25375718e-01f, -2.33285487e-01f, -1.39921829e-01f, 2.17501581e-01f, -1.33935601e-01f,
  3.92570347e-03f, 1.61645457e-01f, 1.14521779e-01f, -1.29607484e-01f, 1.09798834e-01f, 2.11919948e-01f, 1.60397422e-02f, 1.20106436e-01f, 8.77930373e-02f, -1.01720437e-01f,
  -7.10831806e-02f, -2.16474563e-01f, -7.55868256e-02f, -1.58337638e-01f, 1.07112629e-02f, -1.25611335e-01f, -1.09572969e-02f, -9.09605771e-02f, -1.60206422e-01f, 7.05169886e-02f,
  -6.79114014e-02f, 5.93952946e-02f, -1.90326646e-01f, -4.57918122e-02f, -5.30363321e-02f, 1.73244141e-02f, -4.66505252e-02f, 4.02190499e-02f, 5.02253734e-02f, -3.21308896e-02f,
  9.25344080e-02f, -1.03322081e-02f, -3.28465812e-02f, 3.31971273e-02f, 2.89347470e-02f, -5.46103008e-02f, 4.91610505e-02f, -2.52537616e-02f, -5.86108863e-02f, 3.23019661e-02f,
  7.81012746e-03f, -1.29259108e-02f, -8.77119079e-02f, -2.23798840e-03f, 4.77010235e-02f, -5.68376258e-02f, -1.43781547e-02f, 5.47513785e-03f, -1.01933278e-01f, -2.17570737e-02f,
  5.36439084e-02f, 1.47970570e-02f, -2.83525628e-03f, -9.56158489e-02f, 1.06071336e-02f, 3.41623686e-02f, -8.09221193e-02f, -7.81248510e-02f, -8.16406533e-02f, -6.05329014e-02f,
  -7.05697089e-02f, -7.04760551e-02f, 1.20046325e-01f, 4.20688130e-02f, -5.04384451e-02f, 1.42069552e-02f, 2.01535467e-02f, 4.59889136e-03f, 1.41589016e-01f, 8.83704945e-02f,
  -8.09741318e-02f, 5.91321960e-02f, -5.45870885e-03f, -8.10063407e-02f, 2.28132568e-02f, 2.52212249e-02f, -1.20753404e-02f, -4.07875217e-02f, 1.21342711e-01f, 3.62687036e-02f,
  -1.47957206e-01f, -8.44659284e-02f, -1.36278883e-01f, -1.12818591e-01f, 2.22789720e-02f, 7.99528733e-02f, -4.52564806e-02f, -4.11543511e-02f, -6.95386752e-02f, 1.70483794e-02f,
  -7.37890229e-02f, -4.77372296e-03f, 5.27241081e-02f, -1.21822633e-01f, 4.67647202e-02f, 7.71986647e-03f, -5.03940657e-02f, 3.37069035e-02f, -5.07622585e-02f, -2.70153675e-03f,
  -3.56459171e-02f, -2.04267018e-02f, -6.72272444e-02f, 4.13906435e-03f, -4.42635976e-02f, 8.08384642e-02f, 1.27609625e-01f, -1.61552150e-02f, -5.57750501e-02f, 4.28296998e-02f,
  1.17958061e-01f, 7.25928545e-02f, -1.22438997e-01f, 1.07707717e-01f, 1.22222140e-01f, 1.39087588e-01f, 2.22262874e-01f, 7.58030489e-02f, 1.12836950e-01f, 1.07699782e-02f,
  1.11536577e-01f, 3.24271284e-02f, -1.17845014e-01f, 4.85559814e-02f, 2.44720444e-01f, 6.12252466e-02f, 9.98439267e-02f, 1.70120880e-01f, -3.83378495e-03f, 5.03224693e-02f,
  7.45341331e-02f, 1.00628927e-01f, -1.38300672e-01f, 1.10563800e-01f, 1.50519563e-02f, -1.10053562e-01f, 3.90531830e-02f, -8.49214122e-02f, 3.98595259e-02f, 1.19891830e-01f,
  8.90525803e-02f, 3.54540609e-02f, 3.40547636e-02f, -1.46806205e-03f, 3.72997299e-02f, -6.66842088e-02f, 1.88774299e-02f, -5.33761643e-03f, -6.21858165e-02f, 4.00072010e-03f,
  2.25468371e-02f, -1.39117092e-02f, 1.42424613e-01f, -1.55755635e-02f, 8.76995400e-02f, -7.28636384e-02f, -7.38356188e-02f, -5.59559092e-02f, -2.53703240e-02f, -3.37199755e-02f,
  -8.66389796e-02f, -1.85222067e-02f, -5.59595115e-02f, 4.87727486e-02f, -8.90876949e-02f, 1.89566258e-02f, -2.15668883e-02f, 3.92779186e-02f, 2.89707817e-02f, 5.72098158e-02f,
  8.26788321e-02f, -4.04044241e-03f, -5.27560003e-02f, -2.60556620e-02f, -2.92998776e-02f, -3.07848789e-02f, 7.23435506e-02f, -7.79038742e-02f, 2.51584928e-02f, 1.44629711e-02f,
  -5.37578501e-02f, -5.04621230e-02f, 2.98407604e-03f, 2.28033848e-02f, 1.86231360e-02f, -2.01345868e-02f, -8.15899745e-02f, -5.86285144e-02f, -8.89477134e-02f, -9.90341976e-02f,
  8.21440388e-03f, 6.91961050e-02f, 4.62488793e-02f, 4.93964702e-02f, -3.83956917e-03f, 5.68475462e-02f, -3.42696928e-03f, 5.97167611e-02f, -3.73683162e-02f, 5.90131097e-02f,
  4.23045941e-02f, 1.40257806e-01f, -4.24688049e-02f, -6.89353645e-02f, -1.34861981e-02f, 8.76255333e-03f, 9.72368345e-02f, 9.58130956e-02f, 8.57185721e-02f, -4.27822117e-03f,
  -1.56338625e-02f, 1.88260712e-02f, 7.88446143e-02f, 1.49018513e-02f, -3.47710326e-02f, 6.76219165e-03f, 3.49681601e-02f, -7.09203407e-02f, 9.70737077e-03f, 2.24314239e-02f,
  -1.03546634e-01f, 6.49639070e-02f, -1.92824118e-02f, -7.39886314e-02f, 3.66246104e-02f, 2.50491481e-02f, 5.74481338e-02f, -7.56009296e-02f, -5.64434491e-02f, 7.07366839e-02f,
  -1.69047028e-01f, -8.12417641e-02f, 2.06328049e-01f, -1.34634450e-01f, 1.06449030e-01f, 6.29454926e-02f, 2.26844043e-01f, 1.22806737e-02f, 5.79129308e-02f, -1.16653129e-01f,
  -8.07139352e-02f, -1.11817338e-01f, 7.48163238e-02f, -8.53140876e-02f, 2.28676274e-01f, -1.74980722e-02f, -3.40907574e-02f, -1.46451429e-01f, 1.53531888e-02f, -2.30832472e-02f,
  4.68239337e-02f, -7.31457919e-02f, 3.95628326e-02f, 5.31503884e-03f, 1.01021528e-02f, -1.25537768e-01f, -1.18282266e-01f, 1.51176587e-01f, -7.71114975e-02f, -3.88242528e-02f,
  -1.16173379e-01f, -1.59982994e-01f, -5.93903959e-02f, -1.17466912e-01f, -6.36206567e-02f, -1.31678551e-01f, 6.94044903e-02f, 2.37396676e-02f, -6.83186501e-02f, -4.50633047e-03f,
  1.60775520e-02f, -5.46840616e-02f, -5.17476238e-02f, -6.96250098e-03f, 5.52393086e-02f, 4.53401096e-02f, 4.22682278e-02f, -7.86852539e-02f, -8.13422948e-02f, 1.13350954e-02f,
  7.26790875e-02f, 7.33675808e-02f, 4.63773757e-02f, -3.88863906e-02f, -8.82536452e-03f, -1.51921727e-03f, 2.84775104e-02f, 1.07388563e-01f, 1.23004720e-03f, -4.07489613e-02f,
  -5.35661615e-02f, -4.23067398e-02f, 4.30265330e-02f, -8.90164971e-02f, 1.23002231e-01f, 3.80813181e-02f, 2.34770719e-02f, 4.26510796e-02f, -2.28797328e-02f, -3.64303328e-02f,
  4.23182733e-03f, -4.82669994e-02f, 6.48019612e-02f, -7.33306035e-02f, -4.59908284e-02f, -4.85338643e-02f, -5.65497428e-02f, 3.81906214e-03f, 2.92693125e-03f, 3.11254971e-02f,
  -6.71699718e-02f, 4.65336069e-02f, -6.29183464e-03f, -5.09654321e-02f, 7.80971050e-02f, 3.24763656e-02f, -4.25343327e-02f, -2.64309011e-02f, -1.18535601e-01f, 8.64495486e-02f,
  -1.80174768e-01f, -6.63778186e-02f, -1.27973929e-02f, -1.26753211e-01f, -1.49322359e-03f, -4.36378308e-02f, -1.30617479e-02f, -5.41966176e-03f, 1.56291928e-02f, -3.37532237e-02f,
  8.29169676e-02f, 2.76101548e-02f, -4.73219305e-02f, 3.78704108e-02f, -2.92085335e-02f, -1.18697342e-02f, 1.02071362e-02f, -1.79478042e-02f, -1.40920013e-01f, -9.60263833e-02f,
  -8.68912488e-02f, -7.95579925e-02f, 6.33298159e-02f, -1.05597116e-01f, -6.69252425e-02f, 1.51274225e-03f, -4.27794792e-02f, 3.54037210e-02f, -7.05021918e-02f, 1.71238687e-02f,
  4.27430235e-02f, -3.29085104e-02f, -1.00639656e-01f, -9.75043401e-02f, -6.33738935e-02f, -1.08838826e-01f, -8.66085887e-02f, -1.13431036e-01f, 2.01552480e-01f, 4.52061445e-02f,
  3.24670784e-02f, 1.52994236e-02f, 5.53132258e-02f, -1.88639268e-01f, -8.58125184e-03f, 4.63609174e-02f, -2.06094041e-01f, -1.51889756e-01f, 4.84983772e-02f, -6.92497715e-02f,
  -1.42375588e-01f, -2.10491046e-01f, -1.67134807e-01f, -7.97455385e-02f, -1.89409986e-01f, 3.38855349e-02f, 2.24810112e-02f, -2.61224471e-02f, -1.22116528e-01f, 7.25317672e-02f,
  5.02748154e-02f, 1.28293484e-01f, -3.67432311e-02f, -2.10482739e-02f, -8.59656185e-02f, -1.66025773e-01f, -4.62990478e-02f, -4.76905052e-03f, -2.03689355e-02f, 4.52996045e-02f,
  5.10355309e-02f, 6.62286505e-02f, -7.79343396e-02f, 1.20111607e-01f, -2.63243113e-02f, -3.38645093e-02f, 6.99371984e-03f, -3.33797410e-02f, 6.71625808e-02f, -8.85932818e-02f,
  -3.44291292e-02f, -7.63070360e-02f, -9.31444019e-03f, 1.21961631e-01f, 8.29966962e-02f, 7.20318109e-02f, -4.13560448e-03f, -7.47763067e-02f, 1.78292673e-02f, 5.16658314e-02f,
  -7.90236667e-02f, -1.08937122e-01f, -8.87261052e-03f, 4.61544581e-02f, 1.71563141e-02f, -2.38809492e-02f, -1.59219094e-02f, 6.05561445e-03f, -4.83333804e-02f, -8.58687609e-03f,
  1.75479706e-02f, 3.79799604e-02f, -6.60700276e-02f, 2.04164982e-02f, -5.31789735e-02f, -1.01223588e-02f, -3.39415111e-02f, 1.54257771e-02f, -1.12864211e-01f, -2.49133706e-02f,
  5.19369915e-02f, 1.04876310e-01f, 1.01321228e-02f, -1.13105342e-01f, 6.68246076e-02f, 5.59579469e-02f, -2.06770524e-02f, -3.80805656e-02f, 5.58041260e-02f, -7.57979974e-02f,
  -9.14799646e-02f, 1.44942449e-02f, 5.37605956e-02f, 1.34829506e-01f, 3.61112244e-02f, 8.21192488e-02f, -8.25890456e-04f, 1.21244118e-01f, -1.84418075e-02f, -5.81819601e-02f,
  -3.41109224e-02f, 2.42572092e-02f, 4.95853312e-02f, 2.24048905e-02f, 1.10280104e-02f, 8.83934721e-02f, -1.28488662e-02f, 2.86641740e-03f, 1.90897547e-02f, -5.63204139e-02f,
  -1.26559794e-01f, 7.15718344e-02f, -5.01804426e-03f, 8.57349560e-02f, -7.63694048e-02f, 4.10058722e-02f, 4.33826558e-02f, 6.45355508e-02f, 3.00104655e-02f, -6.32056221e-02f,
  -3.10885627e-02f, -5.55517487e-02f, 1.44355167e-02f, -1.34758562e-01f, 1.91631191e-03f, -1.84974730e-01f, -6.94298297e-02f, 4.14493792e-02f, -8.26081634e-02f, 1.86599791e-01f,
  1.13181464e-01f, -1.19535692e-01f, 3.74263786e-02f, -1.92983657e-01f, -2.61000574e-01f, -2.35915214e-01f, -8.27092752e-02f, -2.12556757e-02f, -1.22318193e-01f, 1.99684184e-02f,
  -9.31863859e-02f, -1.24146184e-03f, -1.28024936e-01f, 1.37572527e-01f, 5.21979779e-02f, 1.35493442e-01f, 2.25519046e-01f, 1.23901397e-01f, 3.55127491e-02f, -1.80001017e-02f,
  5.73701039e-02f, 1.24728329e-01f, 7.27227181e-02f, 3.62641625e-02f, 1.30324379e-01f, 6.86548799e-02f, -2.22124662e-02f, -1.29326805e-01f, -6.66558743e-02f, -5.50464801e-02f,
  -5.44120595e-02f, -9.60563943e-02f, -1.04441950e-02f, -6.97609857e-02f, -6.05904050e-02f, 5.13803177e-02f, -5.30307554e-02f, 1.50307212e-02f, 1.00043640e-01f, 5.92972077e-02f,
  -1.71758613e-04f, 2.52928082e-02f, 1.28349932e-02f, 4.93852347e-02f, 6.34501642e-03f, -8.06685761e-02f, 5.07007539e-03f, 7.76925357e-03f, 6.89278841e-02f, -3.46674286e-02f,
  -7.05360770e-02f, 1.30677596e-01f, -6.76936517e-03f, -9.07932669e-02f, -2.74667726e-03f, 6.05124421e-02f, 4.27503772e-02f, 1.01153158e-01f, -3.66061255e-02f, -4.03141640e-02f,
  2.69655883e-02f, -7.75385946e-02f, 8.60982388e-02f, -6.72242865e-02f, 3.27179246e-02f, 3.78587395e-02f, -2.70267315e-02f, 2.62527633e-02f, -2.65706647e-02f, 1.33730574e-02f,
  6.78121373e-02f, -3.82120274e-02f, -2.13620756e-02f, 7.77633712e-02f, -2.63286773e-02f, -3.88826430e-02f, -5.22175916e-02f, -4.23754845e-03f, -4.96089384e-02f, 6.79623336e-02f,
  -5.48718125e-02f, 1.44143313e-01f, 5.19204214e-02f, 5.67902699e-02f, 2.89411079e-02f, 2.92650703e-02f, -1.71484705e-02f, -1.82085969e-02f, -8.23555365e-02f, 8.42484012e-02f,
  1.17813610e-01f, 4.76762913e-02f, 7.53951818e-02f, -9.26856883e-04f, -2.22755242e-02f, 1.19325146e-02f, 1.38556197e-01f, -7.25440532e-02f, 2.85655819e-02f, 3.67777310e-02f,
  4.39640135e-02f, -7.24159107e-02f, -8.29513073e-02f, 2.79994141e-02f, 2.13498343e-02f, 1.02299228e-02f, -7.49784037e-02f, 1.03849685e-02f, -5.80528006e-02f, -5.20571060e-02f,
  -6.65070862e-02f, -1.49143457e-01f, -3.23933996e-02f, -1.50333241e-01f, 3.27504389e-02f, -2.46275619e-01f, -2.29630694e-01f, -1.86646171e-02f, -8.38755965e-02f, -4.46913503e-02f,
  -7.72793815e-02f, 5.55690471e-03f, 6.39059022e-02f, -1.51430115e-01f, -1.13244727e-02f, 1.34876356e-01f, -2.42215425e-01f, -6.00023046e-02f, 4.21399809e-02f, -1.50961682e-01f,
  1.04995752e-02f, -1.07320175e-01f, 2.77795251e-02f, 5.67192063e-02f, -1.06542565e-01f, -6.20626137e-02f, -2.19128355e-02f, -8.22776556e-02f, -1.17878199e-01f, 5.52216247e-02f,
  7.02856705e-02f, 5.38513921e-02f, 3.27769071e-02f, 6.58566039e-03f, 3.94666418e-02f, 3.70939821e-02f, -1.39715001e-01f, 3.69939841e-02f, -4.94407006e-02f, 4.27647419e-02f,
  -2.84270775e-02f, -9.60686337e-03f, -4.82378863e-02f, 3.84898484e-02f, -4.78616506e-02f, 2.50220783e-02f, 1.32872030e-01f, -4.55134884e-02f, 1.08063687e-02f, -1.84933078e-02f,
  -2.11368930e-02f, -1.37531180e-02f, -4.84490693e-02f, -4.52857837e-02f, 3.04302499e-02f, -4.68619205e-02f, 5.63097447e-02f, -4.36425284e-02f, -4.46440317e-02f, -4.68534604e-02f,
  -4.13605161e-02f, -4.94931228e-02f, -7.39230737e-02f, 2.31058244e-02f, -3.06071434e-02f, 5.50257824e-02f, -1.10961609e-01f, 7.61739463e-02f, -9.02734101e-02f, 1.01502933e-01f,
  2.35314970e-03f, -6.98530599e-02f, 1.02848532e-02f, -3.97776663e-02f, 4.10815924e-02f, 2.07102243e-02f, -4.87478115e-02f, 7.34519735e-02f, -6.27582967e-02f, 1.68091897e-02f,
  4.86037396e-02f, -3.56912389e-02f, -6.76777260e-03f, 3.69146094e-03f, 5.93783855e-02f, 2.23142430e-02f, -9.78596285e-02f, 3.18136998e-03f, 5.63812666e-02f, -4.69022989e-03f,
  -6.92081377e-02f, 2.02223286e-02f, 5.23426570e-02f, 1.98317654e-02f, 5.50617203e-02f, 1.50448633e-02f, -3.60525050e-03f, -4.51399349e-02f, -7.43360445e-02f, -9.40796137e-02f,
  -5.91197759e-02f, -5.40670641e-02f, -2.70667393e-02f, -6.62114620e-02f, 6.49367319e-03f, 8.30371864e-04f, 5.45622967e-02f, 7.80153945e-02f, -3.08709107e-02f, -5.37950136e-02f,
  2.55642198e-02f, -3.50255370e-02f, -6.73679709e-02f, 2.09057648e-02f, -7.48154595e-02f, -2.71564238e-02f, -5.40674143e-02f, 5.78787439e-02f, 3.12690362e-02f, -2.91411672e-02f,
  -4.51411456e-01f, 1.52786300e-01f, -5.57536706e-02f, 2.43776180e-02f, -1.35690182e-01f, -9.48743373e-02f, -8.16189572e-02f, -4.64032479e-02f, -5.19293509e-02f, 1.42612129e-01f,
  2.10136265e-01f, -2.14310959e-01f, 1.44499928e-01f, 1.48345128e-01f, -2.42329597e-01f, 1.16199464e-01f, 2.21463796e-02f, -4.98006865e-03f, 9.50205326e-03f, -2.15705354e-02f,
  2.35280418e-03f, 1.63477346e-01f, 1.13641940e-01f, 1.03652343e-01f, -2.10087877e-02f, -9.99768171e-03f, 5.47282062e-02f, -8.30440875e-03f, 4.43592668e-02f, -1.00142367e-01f,
  -1.84599057e-01f, -5.92757687e-02f, -7.71818832e-02f, -7.81248212e-02f, -8.32235217e-02f, -9.15663168e-02f, -4.05240804e-02f, 6.78891838e-02f, -9.65786129e-02f, 2.27041133e-02f,
  -4.30691168e-02f, -5.67223120e-04f, -1.78916864e-02f, -1.01182302e-02f, -6.25687391e-02f, 5.18152080e-02f, -3.88584025e-02f, -3.92137840e-02f, 7.71410093e-02f, -4.17187624e-02f,
  -3.16092558e-02f, -6.55142292e-02f, 7.64430836e-02f, 2.09606737e-02f, -4.11508977e-02f, -4.43161242e-02f, -2.53525730e-02f, -5.93781359e-02f, -2.23482046e-02f, -6.96497262e-02f,
  -5.03189601e-02f, 1.32554621e-01f, 6.45576930e-03f, 4.72264215e-02f, -5.00822850e-02f, -8.43351800e-03f, -2.22895667e-02f, -4.53116111e-02f, 1.38105797e-02f, 8.10889229e-02f,
  -1.15408756e-01f, 2.03805305e-02f, 5.46486750e-02f, -8.27838629e-02f, -1.08287940e-02f, 1.77825950e-02f, -2.14325823e-02f, -2.35196352e-02f, 3.01775858e-02f, 8.07828084e-02f,
  -1.14310626e-02f, 1.90358348e-02f, 4.39197533e-02f, 7.38033429e-02f, -2.54251119e-02f, 8.03218037e-02f, 7.08608776e-02f, 9.10521206e-03f, 3.27314325e-02f, 4.28843237e-02f,
  -2.11817235e-01f, -1.35670051e-01f, -5.10427393e-02f, -7.81395361e-02f, 3.17930914e-02f, -3.79977673e-02f, 3.31164375e-02f, -3.17240357e-02f, 6.27387874e-03f, -6.81371391e-02f,
  -1.13911033e-01f, -1.21766301e-02f, 2.00876798e-02f, 4.55844738e-02f, -1.28198676e-02f, -3.77902687e-02f, -4.91776094e-02f, 4.05676253e-02f, -7.92809501e-02f, -5.57212010e-02f,
  4.84411865e-02f, -4.40663509e-02f, 9.16899517e-02f, -9.81432572e-03f, -8.80871899e-03f, -5.84121887e-03f, 2.31775139e-02f, 2.84094978e-02f, -1.50221318e-01f, -6.21233322e-02f,
  -2.04644367e-01f, 1.26401886e-01f, -1.17741451e-01f, -2.52039373e-01f, 7.99815953e-02f, 2.82995384e-02f, -7.73665905e-02f, -5.68231195e-02f, -1.28700379e-02f, -9.78162810e-02f,
  -1.52327806e-01f, -3.70271541e-02f, -1.47827948e-02f, -1.12820655e-01f, -2.81343330e-02f, 1.38210878e-01f, -1.11542590e-01f, -7.48314187e-02f, 1.55436233e-01f, -4.90746349e-02f,
  -3.97687294e-02f, 2.30841711e-02f, 4.34938408e-02f, 1.39860407e-01f, -7.88991302e-02f, -6.76539540e-02f, -1.06320009e-01f, 5.23165315e-02f, -8.51600319e-02f, 1.97611246e-02f,
  -1.13706723e-01f, -1.38487622e-01f, 1.91416293e-02f, -6.60219714e-02f, -6.68474436e-02f, 1.17341271e-02f, -1.23123445e-01f, 6.10056445e-02f, -1.07991509e-01f, 4.36343327e-02f,
  2.59407405e-02f, 1.02377631e-01f, -5.26092164e-02f, 4.88214158e-02f, -8.46802536e-03f, -2.09870953e-02f, -3.27391289e-02f, -2.15563830e-02f, -3.79427373e-02f, 1.04469314e-01f,
  1.10519104e-01f, 3.07481419e-02f, -6.84420615e-02f, -7.04270527e-02f, -2.35430561e-02f, -1.17121004e-01f, 2.91496981e-02f, -2.72028465e-02f, 4.01948169e-02f, -8.79860297e-02f,
  1.25938401e-01f, 3.56948562e-02f, 2.65156361e-03f, -1.33137703e-02f, -8.90711695e-02f, -3.76633219e-02f, -6.33313414e-03f, -3.79553474e-02f, 1.52131887e-02f, 4.27496657e-02f,
  2.62331683e-02f, 4.30161729e-02f, -2.02246830e-02f, -5.55497743e-02f, 9.30622742e-02f, -1.60895422e-01f, -5.18011190e-02f, 1.18960915e-02f, 5.13346419e-02f, -5.79741132e-03f,
  4.04708274e-02f, -4.07278277e-02f, 1.28926346e-02f, 8.78751203e-02f, -7.31627569e-02f, -1.30089983e-01f, -1.26467543e-02f, 2.93679978e-03f, -1.76691897e-02f, -9.64487717e-02f,
  -8.00196081e-02f, -2.92578042e-01f, -1.04741924e-01f, 8.01118985e-02f, 4.45823977e-03f, 7.70507473e-03f, 5.66817485e-02f, -8.32927302e-02f, 7.00929575e-03f, 8.31282660e-02f,
  -5.32286726e-02f, 6.79560425e-03f, 1.61089972e-02f, 1.35716991e-02f, -1.12611484e-02f, -4.59717214e-02f, -6.56719953e-02f, -1.74789326e-04f, -5.98710068e-02f, 2.33390611e-02f,
  -1.10293757e-02f, -4.96884808e-02f, 6.72138948e-03f, 5.94206434e-03f, 1.53235234e-02f, -1.39487162e-02f, -4.70368750e-02f, -1.69639122e-02f, 2.56794356e-02f, -9.47696995e-03f,
  -4.99517098e-02f, -2.08452970e-01f, -6.09553326e-03f, -9.55745578e-02f, -1.14462964e-01f, -1.40407726e-01f, -6.78771809e-02f, -5.45965359e-02f, 7.43597299e-02f, 5.25322892e-02f,
  -1.37698101e-02f, -1.30160144e-02f, 1.81607887e-01f, -1.62659541e-01f, 1.62145942e-01f, 8.03329572e-02f, -1.31903246e-01f, -3.98559459e-02f, -4.19967249e-02f, -1.71696082e-01f,
  -6.99051917e-02f, -1.74452066e-01f, -1.41195327e-01f, -1.10311724e-01f, -1.53121084e-01f, -7.25594386e-02f, 1.72251370e-02f, -1.37639523e-01f, -1.11624956e-01f, 3.27359512e-02f,
  -7.82954618e-02f, 1.11071274e-01f, -1.32221095e-02f, 8.35832730e-02f, -1.78858787e-02f, -6.89012483e-02f, -5.94730824e-02f, 1.07739903e-01f, 2.86226366e-02f, 4.76704240e-02f,
  -6.41628653e-02f, 9.11616534e-02f, 6.00366406e-02f, -1.40665872e-02f, 1.05569670e-02f, 1.61332451e-02f, 3.82067822e-03f, -1.42151369e-02f, -2.21336968e-02f, 1.32195577e-02f,
  -4.66788150e-02f, -2.25111302e-02f, 2.14350391e-02f, 8.98147374e-02f, -4.75857221e-02f, -2.10471563e-02f, 6.79093301e-02f, 8.29981193e-02f, -7.02583045e-02f, -5.36642910e-04f,
  -7.30928108e-02f, -2.44032629e-02f, -5.81546538e-02f, -1.76163912e-02f, -1.06746405e-01f, -1.17253140e-01f, 2.26408266e-03f, -1.05431583e-02f, 9.02562290e-02f, -1.92248784e-02f,
  -8.68041590e-02f, -1.34221502e-02f, -8.14017653e-02f, 1.46708256e-02f, -6.33179247e-02f, 7.45113892e-03f, 6.95681944e-02f, 7.50822108e-03f, -9.67368707e-02f, -2.34990865e-02f,
  -2.61432175e-02f, 4.26855311e-02f, -7.04328194e-02f, -4.44083102e-02f, -1.14546083e-01f, 7.41118640e-02f, -2.55764090e-02f, -4.04400192e-02f, -6.64804503e-02f, -7.97690526e-02f,
  -2.38074157e-02f, 9.45941731e-02f, -5.06943278e-02f, -2.85534710e-02f, -7.77965710e-02f, -1.70956105e-02f, -4.55549657e-02f, 1.79666188e-02f, 1.37872070e-01f, 1.67554226e-02f,
  -1.25942589e-03f, 1.59375519e-02f, -8.09077621e-02f, 1.49525411e-04f, 7.15585202e-02f, -6.64792359e-02f, -4.78322282e-02f, -1.34258075e-02f, 4.68988828e-02f, 1.43594397e-02f,
  5.88489091e-03f, -4.29451428e-02f, 4.99328561e-02f, 2.47732773e-02f, 5.63166998e-02f, 8.18316415e-02f, -7.54899858e-03f, -2.16567945e-02f, 1.34897595e-02f, -9.21631884e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  8.10508355e-02f, 7.95637965e-02f, 3.18289511e-02f, 1.77800462e-01f, -2.75429673e-02f, 2.07217127e-01f, 1.32201925e-01f, 3.40714343e-02f, -1.07753530e-01f, 1.27492532e-01f,
  2.44014084e-01f, -2.76029184e-02f, 1.97475120e-01f, 9.86766592e-02f, 3.74348015e-02f, 5.57775199e-02f, 1.33832648e-01f, -4.60629212e-03f, 1.68114185e-01f, 6.47171140e-02f,
  1.15529701e-01f, 5.47797941e-02f, 5.38233556e-02f, 1.92044750e-02f, 1.39702514e-01f, 1.65081307e-01f, 1.37657583e-01f, 1.37428492e-01f, 3.26116085e-02f, 1.26323342e-01f,
  9.57966000e-02f, 2.63680164e-02f, 2.03922391e-01f, 8.10626149e-02f, 7.69046322e-02f, 9.25250947e-02f, -1.16047040e-02f, 1.61287621e-01f, 1.21000208e-01f, 1.01546146e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  8.52404237e-02f, -6.49554059e-02f, 6.16108179e-02f, 6.88165352e-02f, 1.67689100e-02f, -5.45627177e-02f, -1.19818881e-01f, -1.19016148e-01f, 9.10547376e-02f, 5.95345453e-04f,
  -1.16697542e-01f, -1.05276173e-02f, -1.45488203e-01f, -2.27000177e-01f, -1.38144299e-01f, 4.40082289e-02f, 9.67557207e-02f, -4.12793756e-02f, 8.16019922e-02f, 7.33507350e-02f,
  -1.17870435e-01f, 2.11638808e-01f, -1.31573811e-01f, 1.50857821e-01f, 4.12600636e-02f, -1.30561709e-01f, 4.41928767e-02f, -9.36499238e-02f, 1.15195192e-01f, 8.97155330e-02f,
  -2.09741324e-01f, 1.85883060e-01f, 1.81112885e-01f, 1.39575964e-02f, 1.64897844e-01f, 2.72864401e-01f, 1.42987240e-02f, -1.55396238e-01f, -7.51938075e-02f, -1.37777955e-04f,
  7.22066239e-02f, 1.48359925e-01f, 1.58921286e-01f, -9.52194631e-02f, 1.26094609e-01f, 4.12296169e-02f, 1.62119791e-01f, -5.68612590e-02f, -1.99958533e-02f, -2.43191794e-01f,
  3.85660902e-02f, -4.19235118e-02f, 7.29590207e-02f, 1.15687713e-01f, -1.39141843e-01f, 7.35828727e-02f, -6.68242425e-02f, -1.35450453e-01f, 1.94534641e-02f, 2.15503946e-01f,
  1.33989170e-01f, 7.66789392e-02f, 2.01342180e-02f, 9.12644863e-02f, 1.50420904e-01f, -2.61307508e-02f, 4.84924465e-02f, 1.24904931e-01f, -2.96163443e-03f, -5.42040877e-02f,
  -6.44614324e-02f, 1.65554937e-02f, 1.63029298e-01f, 5.73872589e-02f, -6.37454018e-02f, -1.08553804e-01f, -1.17997294e-02f, -1.06755562e-01f, 1.44295841e-01f, -1.11228041e-01f,
  -1.09250441e-01f, 6.82843029e-02f, 8.75544250e-02f, 1.10080741e-01f, 4.99642408e-03f, -9.74269956e-02f, 1.35430530e-01f, -4.33855243e-02f, -1.39728427e-01f, 3.71452421e-02f,
  -5.45489416e-02f, -1.75683573e-01f, -1.45995811e-01f, -1.76667079e-01f, 1.38650492e-01f, 1.43137261e-01f, 9.17523205e-02f, -3.30531411e-02f, -2.17589989e-01f, -1.87309295e-01f,
  -5.83194271e-02f, 6.86229691e-02f, -1.42370865e-01f, -2.18906820e-01f, 3.84030230e-02f, -1.18713394e-01f, -1.72845483e-01f, 1.16808213e-01f, -6.01538643e-02f, -2.08875053e-02f,
  -1.30748525e-01f, 2.46530995e-02f, 1.39720649e-01f, 7.40309209e-02f, -1.85065076e-01f, -6.21063560e-02f, 5.41430302e-02f, -1.99111700e-01f, -1.48015082e-01f, -1.87829565e-02f,
  2.50381157e-02f, 1.66221663e-01f, 1.40654400e-01f, -4.39997353e-02f, 1.52146772e-01f, 2.45651277e-03f, -5.55671081e-02f, -3.53502035e-02f, -5.09769768e-02f, 3.16316262e-02f,
  6.59134537e-02f, -4.13014330e-02f, 1.62960932e-01f, -5.04309486e-04f, 1.51645318e-01f, -2.90839970e-02f, 1.05992578e-01f, 1.49187177e-01f, 9.43056494e-02f, 1.08847968e-01f,
  -1.44372636e-03f, -1.06137551e-01f, 8.54904205e-02f, -7.51881525e-02f, -9.98292789e-02f, 9.02838481e-04f, -8.92141238e-02f, -6.22171238e-02f, 2.25111648e-01f, -1.27244115e-01f,
  -5.67010157e-02f, 2.36649558e-01f, -1.73051864e-01f, 7.06013590e-02f, -1.55604213e-01f, -6.97462931e-02f, -6.19951487e-02f, 4.43296432e-02f, 6.96816156e-03f, -3.34327668e-02f,
  8.88549257e-03f, -1.62487835e-01f, -1.03128038e-01f, 1.90304294e-01f, -1.61181316e-01f, -4.27032821e-02f, 1.77345335e-01f, 1.11518279e-01f, -1.26017988e-01f, 7.73024419e-03f,
  1.49481837e-02f, 1.93632096e-01f, 2.54905075e-01f, -2.17984289e-01f, -6.23921640e-02f, -1.83467731e-01f, -1.09607734e-01f, -2.91267838e-02f, 6.50243089e-02f, 1.25868753e-01f,
  1.79248065e-01f, 8.30341801e-02f, 1.08204924e-01f, -1.00098394e-01f, 1.21303134e-01f, -3.37674618e-02f, -1.55704930e-01f, -6.96008354e-02f, -3.07170320e-02f, -7.68042058e-02f,
  -1.56984448e-01f, -1.64184105e-02f, 2.89106984e-02f, -4.89635468e-02f, 3.26494267e-03f, -3.10638659e-02f, 1.14877157e-01f, 8.18990450e-03f, 4.19998951e-02f, -3.67487706e-02f,
  2.62392708e-03f, 6.60854504e-02f, -1.09331325e-01f, -4.75045145e-02f, 4.41872105e-02f, -8.47620517e-03f, 8.32397200e-04f, -6.19760016e-03f, 5.11095375e-02f, 1.42745733e-01f,
  -1.33079126e-01f, 9.55634657e-03f, -1.84377097e-02f, 1.78218503e-02f, -1.35792509e-01f, 6.48968220e-02f, 4.70866263e-02f, -1.00306548e-01f, 5.53385615e-02f, -8.91915634e-02f,
  1.73319682e-01f, 5.37972897e-02f, -1.16912156e-01f, -3.89078967e-02f, -5.95508739e-02f, -1.87729374e-01f, 1.20616749e-01f, 2.17704013e-01f, 1.69660717e-01f, -1.14774451e-01f,
  2.88966279e-02f, 1.27458408e-01f, -7.69671872e-02f, 1.81478113e-01f, 2.63422150e-02f, -1.56833529e-01f, 1.99896052e-01f, -5.24043441e-02f, 1.45400940e-02f, -1.91552207e-01f,
  8.65762755e-02f, -1.32985726e-01f, 2.54591256e-01f, 1.67706296e-01f, 2.85748318e-02f, 1.26311243e-01f, 7.82657415e-02f, -1.56547695e-01f, 1.36105090e-01f, -1.86920732e-01f,
  -1.01846978e-01f, 9.61189419e-02f, -1.35662913e-01f, 2.12683514e-01f, -7.77939707e-02f, -1.56830877e-01f, 1.92362741e-01f, -9.07546803e-02f, 1.58505850e-02f, 3.27874571e-02f,
  -1.06421478e-01f, 1.02860913e-01f, -6.17790185e-02f, 7.20927939e-02f, -1.06077120e-01f, -9.31896735e-03f, 1.26669630e-01f, 3.16842385e-02f, -1.56261802e-01f, 9.84184518e-02f,
  -5.21942265e-02f, -7.62544721e-02f, 8.53401795e-02f, 4.47684526e-02f, -5.61134517e-02f, 3.46975401e-02f, -1.10929936e-01f, 1.90384537e-02f, 8.61524120e-02f, -1.26624957e-01f,
  1.35544404e-01f, 7.26546869e-02f, 1.28133312e-01f, 3.32589410e-02f, 2.58640442e-02f, 1.73589271e-02f, -2.91230250e-02f, 4.93964590e-02f, 9.80043262e-02f, 7.79582709e-02f,
  1.14371479e-01f, -4.63433824e-02f, 2.79456638e-02f, -1.26738831e-01f, -2.11006284e-01f, -1.26661286e-01f, 3.09850220e-02f, 1.08314434e-03f, -1.61925852e-02f, -3.57685387e-02f,
  -8.21251199e-02f, 1.02246972e-02f, -6.60802796e-03f, -6.36981055e-02f, 2.11056814e-01f, -8.35469440e-02f, 4.93091829e-02f, -2.36392736e-01f, -5.40629663e-02f, -1.39364094e-01f,
  -3.57294679e-02f, -6.90190634e-03f, -6.65051565e-02f, -7.71273524e-02f, 1.42920706e-02f, 5.30010909e-02f, 1.08009212e-01f, 1.58325300e-01f, 1.73687607e-01f, 4.41772230e-02f,
  -9.90477502e-02f, 1.82367846e-01f, -8.76089782e-02f, 2.41468251e-02f, -7.63086304e-02f, 4.70778756e-02f, 9.24425498e-02f, 8.06729794e-02f, 1.33830056e-01f, 1.68660432e-02f,
  8.48112181e-02f, -7.20159486e-02f, 1.70725763e-01f, -6.44503310e-02f, 2.56690919e-01f, 1.84197396e-01f, 1.51617438e-01f, -2.71497108e-03f, 9.19832941e-03f, 3.38346995e-02f,
  -8.26119259e-02f, -1.48909926e-01f, -4.60669063e-02f, 1.32710531e-01f, -4.40355875e-02f, -1.23272799e-02f, 9.80604663e-02f, 9.87004638e-02f, 2.35137180e-04f, 4.76633161e-02f,
  -3.47261950e-02f, 3.14594321e-02f, -7.01038763e-02f, -1.55140042e-01f, 9.42266211e-02f, 1.37003466e-01f, 1.07121013e-01f, 2.36712443e-03f, 6.35356456e-02f, 1.30105600e-01f,
  3.53433774e-03f, -4.81736250e-02f, -9.08656269e-02f, 2.42764756e-01f, 1.22071259e-01f, 1.61381185e-01f, 1.13734961e-01f, -2.08504498e-01f, -4.41174097e-02f, -4.43163030e-02f,
  2.91487873e-01f, 1.90099269e-01f, 8.42871144e-02f, 8.66017863e-02f, 1.29343867e-01f, -1.00072905e-01f, 1.88635979e-02f, -3.49499248e-02f, -2.31816500e-01f, 5.43614700e-02f,
  1.49810687e-01f, 2.39547506e-01f, 1.57828089e-02f, -2.01135546e-01f, 1.55350585e-02f, 3.46439555e-02f, -1.95443347e-01f, 8.25839788e-02f, -8.87389109e-03f, 1.78149268e-01f,
  5.61963059e-02f, -6.76551014e-02f, 1.17387362e-02f, -7.68419877e-02f, -1.23058073e-01f, -1.57967396e-02f, -1.09261960e-01f, -4.93514128e-02f, 1.23924874e-01f, 9.78970807e-03f,
  4.08985727e-02f, 1.44941688e-01f, 1.38280392e-01f, 1.62824184e-01f, -1.45888939e-01f, -4.90318760e-02f, 7.02257305e-02f, 1.37849867e-01f, 1.29216552e-01f, -1.75287828e-01f,
  1.62151590e-01f, -8.46726820e-02f, -6.81206658e-02f, 8.56127292e-02f, -7.15709627e-02f, 7.35199219e-03f, -2.11695105e-01f, -1.90083683e-02f, 5.50122559e-02f, 7.17318878e-02f,
  2.44786605e-01f, -1.04431726e-01f, 5.44407777e-03f, -8.77182782e-02f, -7.03223199e-02f, -9.31736305e-02f, -1.90856040e-01f, 7.66867250e-02f, 1.04808412e-01f, 1.91284880e-01f,
  -1.26375616e-01f, -6.05656877e-02f, 9.12547205e-03f, 5.93587058e-03f, 1.61854088e-01f, -2.19504088e-01f, 1.71886951e-01f, -1.80021226e-01f, -1.51653156e-01f, -2.75092334e-01f,
  -1.49367332e-01f, 4.10802513e-02f, 2.74616927e-02f, 5.60123660e-02f, 3.95523719e-02f, 2.53903449e-01f, 1.28416762e-01f, -6.55768160e-03f, -1.48700148e-01f, -9.38436985e-02f,
  -1.22078918e-01f, -8.68465900e-02f, -6.54718280e-02f, -4.53955606e-02f, 6.86780661e-02f, -8.80651996e-02f, -3.59956548e-02f, -1.80483326e-01f, -1.04269153e-02f, -5.39341904e-02f,
  -4.57269996e-02f, -5.25617935e-02f, -2.75548995e-02f, -2.69846171e-01f, -1.07424827e-02f, -6.24756739e-02f, -2.11086735e-01f, 1.29322827e-01f, -2.25823298e-02f, 5.04129194e-02f,
  6.98098987e-02f, -4.85473759e-02f, -3.17893445e-01f, 3.72566818e-03f, 1.22969270e-01f, -3.96906361e-02f, -2.11067572e-02f, 1.06622517e-01f, 2.12093249e-01f, -5.58892637e-02f,
  1.32934764e-01f, -4.65859398e-02f, -7.26863882e-03f, -2.91076422e-01f, -6.91486597e-02f, -1.55037362e-03f, -8.79685804e-02f, 4.86483946e-02f, 1.34649858e-01f, -9.25039351e-02f,
  6.96972087e-02f, -1.22104272e-01f, -1.31723583e-02f, 1.87046621e-02f, -1.68505579e-01f, -1.53735355e-01f, 1.09453641e-01f, -1.13124922e-01f, -3.36903967e-02f, 4.85702651e-03f,
  -1.20191351e-01f, -6.28056154e-02f, 8.16275254e-02f, 1.54687032e-01f, -9.66773480e-02f, 1.26564816e-01f, 1.03876613e-01f, -2.65685190e-03f, 1.14458688e-01f, -1.19256869e-01f,
  2.92099062e-02f, 1.98630333e-01f, 7.96050876e-02f, -5.48607297e-02f, 5.55220339e-03f, -3.01836431e-02f, -4.79519777e-02f, 1.18888520e-01f, 1.08428642e-01f, -6.84681907e-02f,
  1.28653169e-01f, 1.89936962e-02f, -1.03928678e-01f, 4.89553772e-02f, 3.54940072e-02f, -2.07327642e-02f, 2.05285281e-01f, 1.48565788e-02f, -9.68171954e-02f, 5.42411879e-02f,
  -1.50983647e-01f, 1.80641279e-01f, 1.19384043e-02f, 1.04585178e-02f, -1.98627003e-02f, 1.60104707e-01f, 3.14037427e-02f, -4.04835679e-02f, 9.49438363e-02f, -1.17417671e-01f,
  -1.55495450e-01f, 1.25627243e-03f, 1.92260861e-01f, -6.15713000e-02f, 3.12759951e-02f, -3.53827178e-02f, 5.47323935e-02f, -8.92115310e-02f, -5.37742395e-04f, 6.99943900e-02f,
  -5.20299077e-02f, -1.98868811e-01f, 2.22316846e-01f, -6.10525869e-02f, -1.86232269e-01f, 1.89643279e-01f, -4.62031141e-02f, 2.02812269e-01f, -2.33446404e-01f, -7.64935911e-02f,
  1.94530431e-02f, -2.90563051e-02f, -1.48040146e-01f, -1.87719166e-01f, 7.73545122e-03f, -9.47499822e-04f, -1.43412322e-01f, 3.88886891e-02f, -1.31614311e-02f, 1.04579300e-01f,
  1.96420066e-02f, -3.77825089e-02f, 1.74036086e-01f, 4.00217883e-02f, 1.60193220e-01f, -4.16578017e-02f, -3.18548940e-02f, -1.46688679e-02f, 7.30756074e-02f, 1.12494402e-01f,
  -5.90142282e-03f, -1.68974251e-02f, 1.07017376e-01f, -1.04500295e-03f, 5.49944192e-02f, -9.17224884e-02f, -3.17901582e-03f, -1.41057735e-02f, -1.75554320e-01f, -4.40416066e-03f,
  -1.28770933e-01f, -6.28758222e-02f, 2.57055052e-02f, -1.06124282e-01f, -1.40713960e-01f, 2.78141946e-02f, 8.65001008e-02f, -3.17696631e-02f, 5.14348373e-02f, 1.80736601e-01f,
  -1.72191516e-01f, 6.77583069e-02f, -7.19902217e-02f, 3.43113467e-02f, 2.77176239e-02f, -1.09621568e-03f, -7.17602111e-03f, -1.30407944e-01f, -4.04490419e-02f, 1.60519332e-02f,
  2.01919630e-01f, -3.29226665e-02f, 9.36732069e-02f, 9.13189426e-02f, 2.60126311e-02f, 5.90308942e-02f, 1.18610896e-01f, -6.54305443e-02f, 6.70032427e-02f, -7.68186003e-02f,
  5.41909970e-03f, -2.18300715e-01f, -3.88130099e-02f, -1.12233162e-01f, -1.11618027e-01f, -5.22146299e-02f, -1.52025577e-02f, 1.20749407e-01f, 5.56140058e-02f, 1.61044464e-01f,
  6.92985728e-02f, 3.85615081e-02f, 1.02607749e-01f, 5.08624949e-02f, -2.46985685e-02f, 3.34480517e-02f, -1.57900289e-01f, -4.86630127e-02f, 3.61908437e-03f, -1.50355786e-01f,
  6.29736707e-02f, -1.28709152e-01f, 3.04465722e-02f, -1.50219172e-01f, -4.73906323e-02f, -7.14415088e-02f, 5.42790443e-02f, -2.01111306e-02f, 1.50755405e-01f, -2.20151637e-02f,
  1.47558242e-01f, 6.29505813e-02f, -1.18005641e-01f, 1.43416179e-02f, 8.01381096e-02f, -5.41577004e-02f, 1.01984434e-01f, -7.05635399e-02f, 6.16007000e-02f, -3.19699384e-02f,
  -1.41424686e-01f, -2.31139526e-01f, -1.41347004e-02f, -1.53537452e-01f, 1.61243066e-01f, -1.62052706e-01f, 7.02506723e-03f, 2.21794337e-01f, -1.23870494e-02f, 6.98470473e-02f,
  -4.24048584e-03f, -7.90272057e-02f, -1.09168343e-01f, 8.41105729e-03f, 2.60300517e-01f, -1.36114627e-01f, 2.73682103e-02f, -1.02636032e-02f, -6.01131096e-02f, 7.62590617e-02f,
  8.71231332e-02f, -1.53386012e-01f, -2.53332369e-02f, -2.00828075e-01f, -1.38486132e-01f, 1.43927693e-01f, 1.57836512e-01f, 1.00354150e-01f, 1.24916844e-02f, -1.77680105e-02f,
  -2.10894048e-02f, -6.71045184e-02f, -2.45693862e-01f, 2.04920378e-02f, 4.15741242e-02f, -5.66430986e-02f, -1.74726337e-01f, 7.13819778e-03f, -5.60276434e-02f, 9.18706506e-02f,
  -7.23020285e-02f, -3.30232456e-02f, 3.51970270e-02f, -1.80271894e-01f, 2.10623294e-02f, -8.13285783e-02f, -4.08170521e-02f, -8.06369558e-02f, -1.79912448e-01f, -7.97515959e-02f,
  -1.31246746e-01f, -1.00681238e-01f, -1.69105843e-01f, -1.80637613e-01f, -5.43117523e-02f, -1.13367200e-01f, -1.16697676e-01f, 3.84895205e-02f, -6.03915229e-02f, -1.29476070e-01f,
  5.74730374e-02f, -1.23974763e-01f, -7.33528286e-02f, 3.42240110e-02f, -2.72726178e-01f, 4.77998964e-02f, 1.11019447e-01f, -2.49428824e-01f, 1.60938993e-01f, 4.13307995e-02f,
  2.06139758e-01f, 3.74944061e-02f, -3.69835123e-02f, -8.75801742e-02f, 2.85285548e-03f, 1.28029510e-01f, 1.08456127e-01f, -1.02437414e-01f, -1.84549000e-02f, -2.05616262e-02f,
  2.62210593e-02f, -6.18516095e-02f, -5.02472930e-02f, 3.20786634e-03f, 1.39153376e-01f, -6.28556591e-03f, -5.65751605e-02f, 1.03307329e-01f, -1.92370117e-01f, 4.72235866e-02f,
  3.27021554e-02f, -8.72323737e-02f, 2.06160665e-01f, -1.40662849e-01f, 2.12884739e-01f, -8.14462081e-02f, 3.06662563e-02f, -1.97205618e-01f, -1.03995487e-01f, 1.20148547e-01f,
  -1.50416389e-01f, -1.01774089e-01f, 1.22553118e-01f, 7.03250393e-02f, 1.43605530e-01f, 1.38967991e-01f, 8.92995596e-02f, 1.58841521e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -6.41617626e-02f, -1.24607466e-01f, -7.58266672e-02f, -1.14121854e-01f, 1.10848144e-01f, -7.11394474e-02f, -1.97024401e-02f, 3.78329456e-02f, -8.23973864e-02f, 7.18317106e-02f,
  1.77400447e-02f, 1.17438667e-01f, 6.68997541e-02f, 8.89575183e-02f, 9.67496559e-02f, -9.61215943e-02f, 9.91395563e-02f, 1.55868456e-02f, -1.45614237e-01f, -1.65394500e-01f,
  1.60779878e-01f, -1.47238016e-01f, -1.87256411e-01f, 6.41523674e-02f, -4.46493812e-02f, -2.38043159e-01f, 2.64006685e-02f, 2.26371512e-01f, 5.15483730e-02f, 4.21472266e-02f,
  6.76478744e-02f, 8.50369558e-02f, -5.67540377e-02f, -2.04990525e-02f, 1.57437578e-01f, 1.55172301e-02f, 4.19583395e-02f, 3.66531685e-02f, 1.23759396e-01f, 2.66629845e-01f,
  -1.14643052e-01f, 9.30967629e-02f, -5.37459292e-02f, -2.10397124e-01f, -1.26276135e-01f, -2.31217593e-02f, 2.13146657e-01f, -1.86641350e-01f, 1.41033709e-01f, 5.50446624e-04f,
  1.59193441e-01f, 3.21656764e-01f, -1.25221582e-02f, 8.75281841e-02f, 2.08581463e-01f, -1.27933115e-01f, 7.10585639e-02f, -8.55016261e-02f, 4.17685360e-02f, -9.02234837e-02f,
  -3.15372124e-02f, -2.79370998e-03f, -1.49151877e-01f, -4.56183180e-02f, -5.79635762e-02f, 5.98961227e-02f, 9.92703438e-02f, 1.63879260e-01f, 2.12438516e-02f, -3.25909629e-02f,
  9.17099267e-02f, -1.38378702e-02f, 4.74518761e-02f, 1.29065007e-01f, 1.42621979e-01f, 2.30786189e-01f, 2.30630919e-01f, -3.36430297e-04f, -8.14729184e-02f, -7.09965378e-02f,
  8.05332437e-02f, -1.15446538e-01f, -6.71913400e-02f, 2.37094015e-02f, 1.67526454e-01f, 2.44248714e-02f, -1.63559258e-01f, 8.19213837e-02f, -5.65553941e-02f, -4.17871028e-02f,
  5.33963814e-02f, 5.08781001e-02f, 1.12400249e-01f, 2.03364030e-01f, -6.58060387e-02f, 5.35760447e-02f, -2.06446219e-02f, 8.08233246e-02f, 8.04128721e-02f, 5.32689355e-02f,
  -1.01565517e-01f, 1.53416425e-01f, 1.21137924e-01f, 1.63421258e-01f, -7.45986924e-02f, 1.08866543e-01f, 2.18995456e-02f, -1.08001292e-01f, 1.37474621e-02f, -3.38075422e-02f,
  3.80164646e-02f, -8.02353173e-02f, 1.01982556e-01f, 1.15977131e-01f, 1.93236187e-01f, 1.67651922e-01f, -1.19770877e-02f, 1.82901789e-02f, 2.12281227e-01f, 8.37324827e-04f,
  1.59849703e-01f, 9.78834778e-02f, -8.36522505e-02f, 4.20866441e-03f, -5.99027909e-02f, -1.70704603e-01f, -7.64068812e-02f, 8.30181502e-03f, 1.96806595e-01f, 1.38734311e-01f,
  1.14107870e-01f, -1.33026130e-02f, -2.13108715e-02f, 1.04960278e-01f, -1.13189574e-02f, 7.68387839e-02f, 3.08233891e-02f, -2.77453158e-02f, 2.74672918e-02f, -7.16491714e-02f,
  -2.47881666e-01f, 6.47299811e-02f, 7.39607513e-02f, 6.57343864e-02f, 3.77987977e-03f, 1.42667592e-01f, 1.30513504e-01f, 1.80136278e-01f, -1.71236068e-01f, 6.51250035e-02f,
  2.56465711e-02f, -1.06075265e-01f, -6.50914982e-02f, -1.51991751e-03f, 2.82557189e-01f, -5.34763420e-03f, 1.89928636e-02f, -6.92903027e-02f, 1.28417104e-01f, 1.22763492e-01f,
  7.50572085e-02f, -7.34099373e-02f, 1.31358057e-01f, -1.17494650e-01f, 2.10936114e-01f, -1.58459842e-02f, 3.13200764e-02f, -7.98082631e-03f, 2.25445598e-01f, -6.71555623e-02f,
  1.86187134e-03f, 2.36606468e-02f, 1.30402207e-01f, 2.79602289e-01f, -1.17887571e-01f, -6.11919239e-02f, 9.51982066e-02f, -1.66044816e-01f, -4.65865321e-02f, -1.27044115e-02f,
  1.68762542e-02f, -6.85125291e-02f, -8.60956013e-02f, -1.23079866e-01f, -1.27075072e-02f, 4.35270742e-02f, 1.74028635e-01f, 1.82112858e-01f, 1.47639081e-01f, 2.77259171e-01f,
  2.49064296e-01f, 1.20991141e-01f, 2.07923967e-02f, 1.74986031e-02f, 1.44449085e-01f, 2.07522213e-01f, 2.02898920e-01f, 2.56642371e-01f, 1.47538260e-01f, 7.87272826e-02f,
  8.84889737e-02f, 3.19269225e-02f, 7.44651556e-02f, -3.81934680e-02f, -2.98790574e-01f, 2.41932590e-02f, 1.33089110e-01f, -7.77256116e-02f, 8.60446841e-02f, -1.12200022e-01f,
  2.18715832e-01f, 1.37035087e-01f, -2.68921822e-01f, -2.25175962e-01f, -7.57756680e-02f, 2.07587779e-01f, 1.67148723e-03f, -1.49432212e-01f, 1.59867093e-01f, 2.79176771e-03f,
  -1.17804751e-01f, 2.23696176e-02f, -1.20488748e-01f, -3.32380474e-01f, -1.93896905e-01f, 1.70418322e-01f, 2.85434127e-01f, -1.53764471e-01f, 2.95204908e-01f, 1.39260098e-01f,
  -2.31579155e-01f, -1.24333300e-01f, 1.69322401e-01f, -2.23974034e-01f, -3.82772870e-02f, 4.48515341e-02f, -1.61617398e-01f, -6.78462833e-02f, -1.41382501e-01f, 2.59807527e-01f,
  -1.35961026e-01f, -9.27575305e-02f, -1.43200397e-01f, 1.17004411e-02f, -1.85843706e-01f, 2.53857434e-01f, -1.90325305e-01f, -1.05311774e-01f, -9.61493626e-02f, 1.19897380e-01f,
  2.10558370e-01f, 3.47525626e-01f, 1.24688789e-01f, 3.95036563e-02f, 2.59852141e-01f, 6.82709599e-03f, 1.77058160e-01f, 2.08879694e-01f, 5.74431680e-02f, 6.17838465e-02f,
  1.90192923e-01f, 5.83148785e-02f, 1.07019499e-01f, 5.75522557e-02f, 2.14805417e-02f, 7.29067698e-02f, 2.17825085e-01f, 1.32088020e-01f, -2.41138905e-01f, 1.60764948e-01f,
  2.92669218e-02f, -2.40895525e-01f, 7.06857294e-02f, -2.58018468e-02f, -7.68786743e-02f, -1.09310620e-01f, -2.88532954e-02f, 3.24194916e-02f, -1.01430826e-01f, 7.65653923e-02f,
  -2.26409212e-02f, -7.95756653e-03f, 1.43544972e-01f, 1.88075274e-01f, 5.55836335e-02f, 2.44752422e-01f, -4.19833064e-02f, 7.45369792e-02f, -1.52226806e-01f, 1.39296368e-01f,
  3.53659123e-01f, 3.83487754e-02f, 1.56702191e-01f, -1.15094408e-01f, -5.13403900e-02f, 6.20979350e-04f, 1.05265707e-01f, 8.32193531e-03f, 1.38068959e-01f, -9.85347107e-02f,
  7.92136714e-02f, 1.67983808e-02f, -7.20945522e-02f, 2.41906382e-02f, 1.57144189e-01f, -1.91145375e-01f, 7.91123435e-02f, 7.23793879e-02f, 1.01227291e-01f, 7.37733096e-02f,
  -1.25053346e-01f, -1.24819264e-01f, 1.75673082e-01f, 1.54310122e-01f, -1.54926583e-01f, 8.38535428e-02f, -6.05482385e-02f, 3.59313637e-02f, 1.33813277e-01f, -1.19745582e-02f,
  1.07078783e-01f, -4.61927056e-02f, 1.16699778e-01f, -2.82154083e-02f, -8.93908180e-03f, -5.98622635e-02f, 9.04571563e-02f, -6.48730323e-02f, -8.07053447e-02f, -4.99570183e-02f,
  1.51756242e-01f, 3.93871451e-03f, 3.67013249e-03f, 1.05630182e-01f, 1.82960983e-02f, -7.99394622e-02f, 1.66399673e-01f, -1.45977885e-01f, -6.96212873e-02f, -1.37320280e-01f,
  1.51231214e-02f, 2.44404688e-01f, -1.92445442e-02f, -3.09727341e-01f, -4.71026003e-02f, 2.58925200e-01f, 3.46929431e-02f, 4.31981236e-02f, -2.46831365e-02f, 1.10858932e-01f,
  2.32680723e-01f, 6.02226034e-02f, 2.28323489e-01f, -5.40286489e-02f, -2.06512898e-01f, 2.13212334e-02f, -2.95557901e-02f, -1.12673685e-01f, -9.97465551e-02f, -1.96505748e-02f,
  8.19563568e-02f, 1.04288369e-01f, 8.81755874e-02f, -1.57582998e-01f, -9.42614824e-02f, 1.16932407e-01f, 2.00134426e-01f, 4.65876497e-02f, 3.16269964e-01f, -1.53838336e-01f,
  1.78466469e-01f, -1.48125991e-01f, -3.55852842e-02f, -5.73806167e-02f, -1.59529373e-01f, 1.85667709e-01f, 1.05305538e-01f, -4.88505810e-02f, 2.67870843e-01f, 4.93012518e-02f,
  2.03875557e-01f, -1.69844478e-01f, 1.05505278e-02f, 2.68328696e-01f, 2.49728233e-01f, 1.12935841e-01f, 1.70346156e-01f, 6.88558146e-02f, 5.39088026e-02f, 1.82418227e-01f,
  1.57752499e-01f, 2.09889859e-01f, 2.45143056e-01f, 2.30638519e-01f, 1.05948456e-01f, 4.88144159e-02f, -3.12030375e-01f, -1.66108217e-02f, -1.84558570e-01f, 1.14913806e-01f,
  8.80661458e-02f, -2.03211028e-02f, 9.89788584e-03f, -2.99843699e-02f, -2.44395122e-01f, 5.58952056e-02f, 1.38450801e-01f, -2.22357064e-01f, 1.45042285e-01f, 2.04151139e-01f,
  9.28454697e-02f, -2.75481064e-02f, -6.66870326e-02f, 1.69838801e-01f, 9.97093096e-02f, 1.99804589e-01f, 3.97737697e-02f, 2.43969306e-01f, 6.92164078e-02f, 8.09272304e-02f,
  2.21376464e-01f, 1.98178254e-02f, -1.64775074e-01f, 4.02011797e-02f, 2.66264081e-01f, 4.58715558e-02f, 1.96873754e-01f, -7.91229829e-02f, 1.09922118e-01f, 7.49721304e-02f,
  1.89595476e-01f, 1.12687692e-01f, 2.93937236e-01f, -1.18934708e-02f, 1.08213581e-01f, -1.46879762e-01f, -5.58154657e-02f, 1.45638615e-01f, -1.90923676e-01f, 3.88424173e-02f,
  1.62418067e-01f, 6.97856396e-02f, 1.47236243e-01f, -2.80847810e-02f, -9.78510454e-03f, 1.69699386e-01f, 1.34906322e-01f, 2.52019316e-01f, -4.44529345e-04f, 5.61248958e-02f,
  1.23354614e-01f, 1.00119233e-01f, 1.33873761e-01f, 2.06490114e-01f, 1.44991443e-01f, 1.90295547e-01f, 8.64320025e-02f, 4.39008437e-02f, 1.34897977e-01f, 1.27471328e-01f,
  -2.67883807e-01f, -1.75963998e-01f, 1.88893452e-01f, -8.10624063e-02f, -9.04470310e-02f, 1.23556882e-01f, 4.74113673e-02f, 1.06710471e-01f, -1.85252413e-01f, -5.18147312e-02f,
  2.74951383e-03f, 3.29510868e-01f, -1.05296679e-01f, -2.86551207e-01f, 3.39926220e-02f, -5.77799790e-02f, 1.85929276e-02f, 1.09636918e-01f, -3.52148078e-02f, -8.11255723e-02f,
  -2.23807573e-01f, -1.07004471e-01f, 1.87388793e-01f, -1.25490934e-01f, 1.54184669e-01f, -9.57617834e-02f, -2.96232905e-02f, -2.14139037e-02f, 1.12480916e-01f, -1.50567964e-01f,
  8.97442643e-03f, 8.22140872e-02f, 1.49193913e-01f, 1.30720764e-01f, -1.21702060e-01f, 1.10736892e-01f, 3.12391520e-02f, -4.39184271e-02f, -1.03631698e-01f, -1.38621479e-01f,
  9.53842029e-02f, 1.45229220e-01f, -1.11868538e-01f, -8.88465717e-02f, 8.58336389e-02f, 1.90987423e-01f, 1.50641128e-01f, 1.69602260e-01f, -6.14567101e-02f, 2.22214445e-01f,
  1.77867308e-01f, -3.89682390e-02f, -7.20494986e-02f, 1.08354073e-02f, -2.19252612e-02f, 1.28445819e-01f, 1.97720472e-02f, -1.25907645e-01f, 1.74942419e-01f, -1.25181535e-02f,
  1.29673734e-01f, 8.97537917e-02f, 8.18164870e-02f, 9.43624228e-02f, -4.65116426e-02f, 3.38366553e-02f, 7.06737936e-02f, -1.95319384e-01f, 6.60587698e-02f, -9.13841724e-02f,
  -2.35940248e-01f, -1.25839025e-01f, 1.79302260e-01f, -1.65658265e-01f, -2.91072011e-01f, 1.96360052e-01f, 3.93282017e-03f, -2.36172024e-02f, 9.39844102e-02f, 1.95857450e-01f,
  1.70509025e-01f, 1.22910380e-01f, -1.19024120e-01f, -1.10565417e-01f, 1.26935109e-01f, -2.43983313e-01f, 1.07250094e-01f, -1.35816243e-02f, -7.27633247e-03f, -8.83698612e-02f,
  3.78532447e-02f, 2.07076594e-01f, -1.13662099e-02f, 9.02334005e-02f, 8.80004019e-02f, -1.09939843e-01f, 8.89940932e-03f, -1.45492136e-01f, -4.36556153e-02f, -1.14638135e-01f,
  -1.20441923e-02f, -1.03244677e-01f, 1.91319324e-02f, 2.49274850e-01f, 1.24695301e-01f, 8.87671635e-02f, 2.08818555e-01f, -1.84291765e-01f, 6.02534749e-02f, -8.97244737e-02f,
  -1.39084337e-02f, 3.84591557e-02f, -3.05015333e-02f, -2.41433140e-02f, -3.82481478e-02f, -9.71269421e-03f, 1.68292820e-01f, 1.13663683e-02f, 7.71697834e-02f, 4.05326299e-02f,
  1.57755151e-01f, 8.05699155e-02f, 2.04592347e-01f, 8.91997442e-02f, 1.78631872e-01f, -2.10925378e-02f, -1.22371297e-02f, 1.38010785e-01f, 1.64969012e-01f, -2.33869135e-01f,
  1.83870926e-01f, 2.00055242e-01f, -1.13690503e-01f, 1.13081917e-01f, 5.99625595e-02f, -1.05926376e-02f, -3.36208194e-02f, 2.02324077e-01f, 5.63677177e-02f, 1.66933432e-01f,
  -1.37754306e-01f, 1.21400587e-01f, 4.84681986e-02f, 7.91138969e-03f, -5.80457877e-03f, 3.67961936e-02f, 8.35227892e-02f, 1.01254173e-01f, 1.14248365e-01f, -9.86956805e-02f,
  -1.30122900e-01f, 2.63578892e-01f, 2.06157625e-01f, -6.07133508e-02f, 9.97803286e-02f, 1.43862933e-01f, 6.12044819e-02f, 1.05659645e-02f, 8.76759961e-02f, 2.53392279e-01f,
  2.24888310e-01f, 1.33215487e-01f, -2.26318296e-02f, -2.44314456e-03f, -1.51644170e-01f, -1.92792833e-01f, 8.90347511e-02f, 3.59597504e-02f, 1.66413531e-01f, 8.36940706e-02f,
  -5.83688840e-02f, 6.08519167e-02f, 1.55705914e-01f, 6.76111579e-02f, -1.42943189e-01f, 2.71711033e-02f, 2.33091470e-02f, 2.37396613e-01f, 1.20214522e-01f, 1.70942143e-01f,
  2.84579322e-02f, -2.02617440e-02f, 2.02641204e-01f, 3.71598527e-02f, 9.52473879e-02f, 1.38541669e-01f, 3.51399519e-02f, 9.58407670e-02f, 8.66541266e-02f, 1.20262869e-01f,
  5.08598313e-02f, -4.47565019e-02f, -2.01216593e-01f, 2.01198295e-01f, -4.74222451e-02f, -6.57221749e-02f, 4.02336381e-02f, -2.01651737e-01f, 1.54314518e-01f, -1.22338869e-01f,
  -1.89160645e-01f, 1.86907444e-02f, -1.49680883e-01f, -1.02328844e-01f, 2.71045417e-01f, 4.28021662e-02f, -1.26154209e-02f, 1.78957105e-01f, 8.04383904e-02f, 7.39153177e-02f,
  -7.76401982e-02f, -3.15605439e-02f, -1.54664412e-01f, 3.99349965e-02f, 1.44470796e-01f, -2.03564391e-01f, 2.26347819e-02f, -4.64779250e-02f, -1.41628042e-01f, 9.51556712e-02f,
  1.50766820e-01f, 8.70775059e-02f, -2.92657246e-03f, -1.34376556e-01f, -1.68824852e-01f, -1.20537676e-01f, 1.62701100e-01f, -6.00186773e-02f, 1.52419627e-01f, 1.20383091e-01f,
  4.39103357e-02f, 1.04515078e-02f, 2.21904786e-03f, -3.46707031e-02f, -1.59464851e-01f, 1.37384802e-01f, 9.75708961e-02f, 1.21128093e-02f, 2.96196137e-02f, 1.52959898e-01f,
  -1.00553796e-01f, 2.25823354e-02f, 1.79368898e-01f, -5.87545857e-02f, 2.93385893e-01f, 2.39919364e-01f, 1.34808064e-01f, 7.25527853e-02f, 1.11869253e-01f, 2.14196384e-01f,
  1.76402450e-01f, 2.26674274e-01f, 8.45821276e-02f, 2.15017408e-01f, 2.30229154e-01f, 1.77044049e-01f, 1.43388286e-01f, -1.13339067e-01f, 1.24707073e-01f, 1.33860812e-01f,
  -5.52353710e-02f, 2.31187239e-01f, -1.68696400e-02f, 2.03007468e-04f, -3.66172381e-02f, 1.46869391e-01f, 1.54323429e-01f, 2.24031851e-01f, -4.23094779e-02f, 1.79816708e-01f,
  -2.18250193e-02f, 1.94737986e-02f, 6.36534940e-04f, -9.56375748e-02f, 1.66236177e-01f, 2.63980720e-02f, -7.17343166e-02f, 1.03191376e-01f, -2.28702143e-01f, 2.52169430e-01f,
  1.62635908e-01f, 3.77241671e-02f, -4.03003693e-02f, 4.60674874e-02f, 1.50956467e-01f, 1.29679799e-01f, 2.12253198e-01f, 2.57213980e-01f, 3.07135046e-01f, 1.14579350e-01f,
  -8.65197480e-02f, -1.94534902e-02f, 5.92048839e-03f, -8.48111585e-02f, 1.39196932e-01f, -9.41771418e-02f, 1.18302427e-01f, -1.50332928e-01f, 9.54862088e-02f, 3.32116261e-02f,
  9.64649860e-03f, 2.60132134e-01f, -1.04949109e-01f, -1.71843190e-02f, -1.42813949e-02f, 9.35394615e-02f, 1.91741005e-01f, 1.74084559e-01f, 1.54668093e-01f, 1.47847071e-01f,
  2.50149280e-01f, 1.95437819e-02f, 3.97936478e-02f, -2.45860755e-03f, 9.79104564e-02f, 1.24717236e-01f, 8.54802430e-02f, 1.08809974e-02f, 2.61515468e-01f, 1.93148836e-01f,
  -4.02538553e-02f, 1.00351416e-01f, -1.95913345e-01f, -1.24829017e-01f, 2.49133110e-02f, 6.50865659e-02f, 1.70467362e-01f, -1.05328307e-01f, 9.27229002e-02f, -1.08233161e-01f,
  -2.07631965e-03f, -1.28651738e-01f, 1.32659763e-01f, -6.12277351e-02f, -9.53686237e-02f, 1.78391144e-01f, -1.08126821e-02f, 1.48148596e-01f, 1.66547913e-02f, -1.58799171e-01f,
  -2.09667072e-01f, 2.30024889e-01f, 2.47122869e-01f, -2.00481966e-01f, -2.66278777e-02f, 1.87762767e-01f, 2.70333663e-02f, 2.11619679e-02f, -1.80593564e-03f, -9.75240692e-02f,
  7.74230659e-02f, -1.50809631e-01f, -1.12011388e-01f, -1.03417657e-01f, 2.07880475e-02f, 1.02236934e-01f, 1.37351640e-02f, 2.20811263e-01f, -1.27543226e-01f, 1.48354411e-01f,
  -1.89034477e-01f, 1.34343281e-01f, -7.11529478e-02f, 1.81710392e-01f, -3.46847102e-02f, -7.48695061e-02f, 5.27635887e-02f, 2.48926744e-01f, -1.29870072e-01f, 7.28571787e-02f,
  1.12940408e-01f, 7.01913703e-03f, 1.60607010e-01f, 9.05818045e-02f, -2.55656918e-03f, 2.71154910e-01f, 1.97868258e-01f, 1.22497484e-01f, 2.75252342e-01f, 2.05725223e-01f,
  3.27716209e-02f, 6.66498393e-02f, 2.04478562e-01f, 2.93024808e-01f, -6.53109103e-02f, -2.09096223e-02f, -1.94652870e-01f, -2.19145194e-01f, -1.87095553e-01f, 1.23837650e-01f,
  -1.98947802e-01f, -1.70738567e-02f, 2.61048675e-01f, 1.50951236e-01f, -1.09463617e-01f, 2.52153516e-01f, -1.77516669e-01f, 3.71719860e-02f, 1.83646509e-04f, 9.98513103e-02f,
  1.94930434e-01f, 1.69580758e-01f, 2.57450305e-02f, 1.28280297e-01f, -6.46838620e-02f, 3.16817090e-02f, 1.78708389e-01f, 3.07533503e-01f, 2.12609693e-01f, 4.34245765e-02f,
  1.26256913e-01f, -1.82394288e-04f, 2.21405804e-01f, 7.05692396e-02f, 2.75020421e-01f, -1.62249565e-01f, 7.49571994e-02f, -1.25825301e-01f, -1.09789431e-01f, -1.68909132e-02f,
  3.90508398e-02f, -1.68641116e-02f, -1.00467347e-01f, 9.97326002e-02f, 1.65448353e-01f, 1.92280799e-01f, -2.63258480e-02f, 1.03688218e-01f, 2.56721586e-01f, 1.91641584e-01f,
  5.58298528e-02f, 8.26683342e-02f, -7.95971155e-02f, 1.19486295e-01f, 1.10712706e-03f, 1.02884129e-01f, 1.56195372e-01f, 6.06727526e-02f, -7.03195110e-03f, 3.73842008e-02f,
  1.49172932e-01f, 1.44572288e-01f, 1.57061026e-01f, 8.33364278e-02f, -5.40242046e-02f, -4.27329578e-02f, 1.45917028e-01f, 6.73929453e-02f, 3.35418247e-02f, 1.49193304e-02f,
  2.77757253e-02f, -7.12060630e-02f, -1.75083295e-01f, -1.22510277e-01f, -1.25854015e-01f, 4.29524183e-02f, 2.11130425e-01f, -2.98624635e-01f, 1.22349888e-01f, 1.38180479e-01f,
  -1.56693444e-01f, 1.44550145e-01f, -1.18180916e-01f, -1.53734192e-01f, -7.36238435e-02f, -2.14740068e-01f, 2.21108302e-01f, 3.17850001e-02f, 2.47333571e-02f, -1.20797448e-01f,
  -4.90944199e-02f, -3.84979457e-01f, -1.57356948e-01f, 8.28434303e-02f, 1.52960839e-02f, -2.25205407e-01f, -8.32252651e-02f, -2.29833499e-01f, -3.74007262e-02f, 3.09176803e-01f,
  -1.84860796e-01f, -2.73352433e-02f, -8.38973895e-02f, -1.06677555e-01f, -1.42264762e-03f, 1.73228458e-01f, 7.66631439e-02f, -1.83046162e-01f, 2.70895772e-02f, -2.22219691e-01f,
  1.05281703e-01f, 1.16340341e-02f, 3.61685641e-02f, 9.82556492e-02f, -1.36970580e-01f, -2.05592304e-01f, -1.18470587e-01f, -1.50693068e-03f, -5.46238646e-02f, 3.62425600e-03f,
  1.43497720e-01f, 1.52455136e-01f, 3.50286998e-03f, 1.45802125e-02f, 2.25924402e-01f, 8.80499482e-02f, 2.36306280e-01f, 1.52876034e-01f, 2.53153563e-01f, 1.58018112e-01f,
  2.38453805e-01f, 8.40966180e-02f, -8.69467705e-02f, -1.37614412e-02f, -9.53653455e-02f, 2.03235596e-02f, -3.16083916e-02f, 1.07176051e-01f, 8.45171213e-02f, 1.57387066e-03f,
  -1.15617149e-01f, 1.86215952e-01f, 5.79231307e-02f, -3.12027395e-01f, 6.21132031e-02f, 2.37378925e-01f, 9.86972544e-03f, 8.60101357e-02f, -6.48191944e-02f, -2.30482504e-01f,
  1.87605601e-02f, 2.34326631e-01f, 1.32005915e-01f, 3.45326692e-01f, -2.76638210e-01f, -1.51168546e-02f, -1.88108936e-01f, 3.03435951e-01f, -8.97008032e-02f, -4.87370975e-02f,
  8.31681862e-02f, 6.60522804e-02f, 8.36825445e-02f, 2.08962522e-02f, 5.77026494e-02f, 2.01021433e-01f, 1.49686828e-01f, 2.64035076e-01f, 8.93350020e-02f, 2.46644616e-01f,
  -9.70478728e-02f, -1.98663741e-01f, 8.71976689e-02f, -2.03018598e-02f, -7.96935856e-02f, 2.02932552e-01f, 1.16428293e-01f, 1.35460734e-01f, 1.43926397e-01f, -1.82076499e-01f,
  -2.47231517e-02f, -2.31432244e-01f, 3.27924863e-02f, 7.88248777e-02f, 3.52102704e-02f, 1.57694340e-01f, -5.02592921e-02f, 3.50335650e-02f, 1.67011395e-01f, 5.55511266e-02f,
  1.94671556e-01f, 1.94357589e-01f, 2.29534224e-01f, -2.57088561e-02f, 5.93444258e-02f, -2.93804407e-02f, 3.24842066e-01f, -2.83116661e-02f, 3.79068464e-01f, 1.44867018e-01f,
  -1.22391291e-01f, 3.59251685e-02f, 1.23584038e-02f, -2.99106073e-02f, -1.28030002e-01f, -4.48456183e-02f, 1.90901071e-01f, 2.62850255e-01f, -4.49280068e-02f, -9.44516733e-02f,
  3.07333637e-02f, 1.24288928e-02f, 9.85831954e-04f, 4.45040455e-03f, 1.04274981e-01f, -1.36522753e-02f, -7.14274794e-02f, -1.05103806e-01f, -2.22346395e-01f, 7.81311989e-02f,
  1.14279486e-01f, -3.35902162e-02f, 1.74952731e-01f, 1.68701715e-03f, -1.97915822e-01f, 8.47894773e-02f, -1.40706405e-01f, 3.34823310e-01f, 1.45970792e-01f, 2.85141289e-01f,
  -8.45932588e-02f, -1.69570833e-01f, -2.79596727e-02f, 1.14043348e-01f, 1.41210392e-01f, 6.03232682e-02f, 9.39392447e-02f, -8.72372091e-02f, 1.80049628e-01f, -2.06780389e-01f,
  -1.19925857e-01f, 1.18852109e-01f, -1.87614456e-01f, -1.10039301e-01f, -2.83927415e-02f, 1.53166339e-01f, 2.73613874e-02f, 9.92715433e-02f, 2.27991611e-01f, 1.36390403e-01f,
  1.22196592e-01f, 1.40327603e-01f, 9.23199952e-02f, 2.14597419e-01f, 3.15201283e-02f, -3.13372053e-02f, 1.77748397e-01f, 7.15553761e-02f, 4.19829600e-02f, 1.53569793e-02f,
  -1.03818871e-01f, 6.81959987e-02f, 1.81418788e-02f, 2.68606186e-01f, 1.69498652e-01f, 9.31885839e-02f, 1.87446132e-01f, -1.64829642e-01f, -2.09399417e-01f, 1.22293070e-01f,
  -5.32876961e-02f, -3.11666042e-01f, 2.54830748e-01f, -7.07688406e-02f, 2.54521698e-01f, 1.29426960e-02f, 8.31316188e-02f, 1.34351224e-01f, 8.80368799e-03f, 9.18571427e-02f,
  7.60200769e-02f, 2.24769935e-01f, 7.72443693e-03f, 1.65358052e-01f, 2.13760301e-01f, -1.27002224e-01f, -6.00033887e-02f, 1.77114338e-01f, 5.19896746e-02f, 2.04480141e-01f,
  1.53156608e-01f, -1.95420384e-02f, 2.32233554e-01f, 1.51802525e-01f, 2.40244687e-01f, 1.17855936e-01f, 1.05201267e-01f, -1.15864232e-01f, 1.03730522e-01f, -9.77500826e-02f,
  1.85646176e-01f, 1.78270862e-02f, -2.39594094e-03f, 3.54823656e-02f, -5.37505783e-02f, 3.89452614e-02f, 6.92899972e-02f, 4.42533791e-02f, -6.60668826e-03f, 1.79946870e-01f,
  2.28806600e-01f, 1.66633427e-01f, -4.78558764e-02f, 1.77304342e-01f, 9.15296376e-02f, 6.42676279e-02f, 1.92968398e-01f, -2.76019610e-02f, 7.47748464e-02f, 6.09126613e-02f,
  -2.90180482e-02f, 1.23587390e-02f, -7.49808326e-02f, 1.58225864e-01f, 2.76266392e-02f, 4.93517146e-02f, -4.59509715e-02f, 6.77162735e-03f, 5.69206104e-02f, -1.45359829e-01f,
  -2.04824936e-03f, -3.73445861e-02f, 1.53251633e-01f, -1.38277695e-01f, -2.25710839e-01f, 2.78011221e-03f, 5.74615598e-02f, -1.39926627e-01f, 9.33507755e-02f, 2.04297379e-01f,
  2.12921202e-01f, 1.20995007e-01f, -1.26711145e-01f, 8.30889642e-02f, 1.20025344e-01f, -6.81208745e-02f, 1.84985474e-01f, 8.78080204e-02f, -4.46962118e-02f, -1.30540088e-01f,
  8.21148455e-02f, 1.26714051e-01f, 4.97093759e-02f, 1.94687337e-01f, 5.93675934e-02f, -4.72552963e-02f, -2.28924602e-02f, -6.14534728e-02f, 1.58604644e-02f, -2.18209341e-01f,
  1.91190746e-02f, -9.00834054e-03f, 2.59096831e-01f, 1.57933205e-01f, 1.29725263e-01f, -9.00879502e-03f, 2.39808008e-01f, -1.46855533e-01f, 2.36052185e-01f, -3.07154283e-02f,
  -1.39621273e-01f, 6.53052628e-02f, 4.04164270e-02f, 6.16924129e-02f, -2.47771144e-02f, -1.64747477e-01f, 8.20997506e-02f, 2.98261433e-03f, -2.38541868e-02f, 7.00478405e-02f,
  4.11982387e-02f, 2.22653210e-01f, 1.87395021e-01f, 7.35493600e-02f, 4.08583805e-02f, 1.80839717e-01f, 7.61746988e-02f, -5.72809018e-02f, 1.62535340e-01f, -1.74055561e-01f,
  2.67201483e-01f, 1.84620216e-01f, -1.25466853e-01f, 1.90545082e-01f, 5.07882684e-02f, 1.51563302e-01f, -2.43713796e-01f, -1.75876766e-01f, 1.67294011e-01f, 8.07776004e-02f,
  -7.26910979e-02f, -6.48345724e-02f, 1.98906213e-01f, -1.26494333e-01f, 2.60552391e-02f, -3.24008451e-03f, 1.40492320e-01f, 2.34346632e-02f, 1.87266290e-01f, 5.68505600e-02f,
  -1.62435733e-02f, -1.19103298e-01f, 3.78839485e-03f, -8.02240241e-03f, 6.67327046e-02f, -1.40867591e-01f, 8.62323120e-03f, -9.12422985e-02f, -2.90639754e-02f, 2.02243119e-01f,
  1.95692092e-01f, 2.78305978e-01f, 3.34971212e-02f, -1.24815464e-01f, 5.13794348e-02f, -2.99273171e-02f, -7.12145939e-02f, -1.05751179e-01f, 7.04877079e-02f, -2.39889011e-01f,
  -8.92161354e-02f, 1.39515370e-01f, -7.15937912e-02f, 2.47335762e-01f, 6.90339878e-02f, 3.61156277e-02f, 2.28327945e-01f, 5.08100539e-02f, 1.43341705e-01f, 5.13998494e-02f,
  2.48104572e-01f, 7.55914673e-02f, -4.70616855e-02f, 2.58213043e-01f, 2.16610283e-01f, 9.22658890e-02f, 1.09346643e-01f, 1.05750166e-01f, 1.60842687e-01f, 1.79113746e-01f,
  8.31144229e-02f, 7.77615756e-02f, 2.56327808e-01f, -1.44216493e-01f, -8.61175209e-02f, 1.53544083e-01f, -6.15197793e-02f, 1.98115870e-01f, 1.57661438e-02f, -7.25326091e-02f,
  2.08403394e-01f, 6.02872893e-02f, -6.77958280e-02f, 5.30640744e-02f, -5.96930124e-02f, 2.42808416e-01f, -8.03933386e-03f, -1.46684140e-01f, -2.23334078e-02f, -9.94924232e-02f,
  2.36908928e-01f, 2.27868333e-01f, 6.62257746e-02f, 1.65321082e-02f, -3.32191914e-01f, 2.44488642e-01f, 4.42871526e-02f, 1.40328944e-01f, 1.99818701e-01f, -1.80414561e-02f,
  -6.88564926e-02f, 2.18848601e-01f, 1.83669224e-01f, 1.30650118e-01f, 3.28907400e-01f, 1.31500289e-01f, -6.89489022e-02f, -6.51491210e-02f, 1.43671259e-01f, 1.45022988e-01f,
  -7.05060139e-02f, 4.66229692e-02f, 2.65473127e-01f, -1.79889500e-02f, 1.81811824e-01f, 1.38861820e-01f, 1.95201248e-01f, 1.14898467e-02f, 1.11320764e-01f, -1.08379409e-01f,
  1.80722997e-01f, -6.58270717e-02f, 1.47672938e-02f, 2.33796701e-01f, 7.27627128e-02f, 5.01718484e-02f, 1.70139492e-01f, -1.10056423e-01f, -1.06070228e-02f, -3.29074413e-02f,
  9.84708965e-02f, 1.52465507e-01f, 1.16811851e-02f, 1.32674977e-01f, -1.54843861e-02f, 3.81590128e-02f, 1.82661131e-01f, 2.16810405e-01f, -6.83437958e-02f, -3.88917178e-02f,
  3.62277925e-02f, -1.61333069e-01f, 3.66046727e-02f, -1.04830235e-01f, -4.71985340e-02f, -1.78950414e-01f, -1.85514256e-01f, -2.12198615e-01f, 2.55091965e-01f, 2.61033792e-02f,
  -6.21423870e-02f, 3.48078161e-02f, -5.06776534e-02f, 2.53574401e-01f, 6.01936318e-02f, -6.44883662e-02f, -1.72812760e-01f, 2.65391856e-01f, 1.65695637e-01f, -1.29725680e-01f,
  -1.87206432e-01f, 2.45128229e-01f, 1.55930027e-01f, -3.67216170e-02f, -8.18728507e-02f, -1.13120712e-02f, -2.37954035e-02f, -3.79351005e-02f, -1.18425645e-01f, 7.88062885e-02f,
  2.57167608e-01f, 2.12490544e-01f, 1.87635213e-01f, 2.54396886e-01f, 4.15155850e-02f, 2.39761338e-01f, -1.86866280e-02f, 3.14117782e-02f, 1.65733740e-01f, 2.56139003e-02f,
  -6.05312921e-02f, -1.05829798e-01f, 4.40156683e-02f, -3.95058617e-02f, -1.65681452e-01f, -7.86595419e-03f, -1.44901291e-01f, -1.29327163e-01f, 7.12523684e-02f, 1.51106790e-01f,
  4.27509136e-02f, -9.97395162e-03f, -5.30282371e-02f, 1.40892595e-01f, -1.08471178e-02f, -2.15398949e-02f, 1.60361931e-01f, 9.84435752e-02f, 8.60844925e-02f, 1.45798117e-01f,
  7.51236454e-02f, -1.65939584e-01f, 1.71493858e-01f, 1.48476213e-01f, 8.96655023e-03f, -2.00852305e-02f, 1.43032834e-01f, 1.43727779e-01f, -1.84622500e-02f, 4.15303931e-02f,
  2.24882454e-01f, -9.91103351e-02f, -7.21400902e-02f, 1.21942364e-01f, 2.02639833e-01f, 9.23628882e-02f, -1.96209013e-01f, -1.58517826e-02f, 2.16534168e-01f, -1.82110723e-02f,
  1.83283791e-01f, 3.80757935e-02f, 8.05525780e-02f, -2.41080783e-02f, 2.56026298e-01f, 3.67064662e-02f, 6.54320195e-02f, 9.99413617e-03f, 1.18953496e-01f, -4.30622101e-02f,
  6.12096749e-02f, 1.16363697e-01f, 1.62808061e-01f, 2.58939922e-01f, -2.02878937e-02f, -4.14874591e-02f, -3.33173387e-02f, -1.09973541e-02f, -3.81910428e-02f, 1.13536185e-02f,
  -2.58516017e-02f, -1.29948348e-01f, -2.12936938e-01f, 8.47630054e-02f, -1.13729369e-02f, 1.78172424e-01f, 1.74802765e-01f, -3.47277895e-02f, 1.59300536e-01f, 2.11603224e-01f,
  1.32927567e-01f, 1.69430494e-01f, 1.28109664e-01f, 1.73528995e-02f, 5.87243289e-02f, 7.67228082e-02f, 1.28157124e-01f, 1.47042409e-01f, -6.20926879e-02f, -1.82379056e-02f,
  1.28503397e-01f, 9.70552489e-03f, 1.63706541e-01f, 7.63118491e-02f, -2.82264769e-01f, 7.20747560e-02f, -1.37561575e-01f, -4.71988088e-03f, 1.34138554e-01f, -2.45942637e-01f,
  -2.18658075e-01f, -5.79094961e-02f, -2.10457861e-01f, -8.03526565e-02f, -6.94610327e-02f, 6.65422454e-02f, -6.19202070e-02f, -1.78017363e-01f, 5.27638569e-02f, -4.65444177e-02f,
  4.97204997e-03f, 8.74159411e-02f, -1.03149243e-01f, 1.07640773e-01f, -1.03842452e-01f, 5.10129539e-05f, 6.22507855e-02f, -1.45702526e-01f, 5.08541726e-02f, -2.02534303e-01f,
  6.35474920e-02f, 1.83162436e-01f, 4.10940265e-03f, -5.46782017e-02f, 1.51108101e-01f, -2.00648069e-01f, -1.68771729e-01f, -2.20759034e-01f, -7.67478049e-02f, -1.91028103e-01f,
  1.00319438e-01f, -1.08546034e-01f, -2.07708851e-02f, 2.86820233e-02f, 2.36885939e-02f, 1.49721801e-01f, -9.93295461e-02f, -8.12035948e-02f, -6.29327297e-02f, -1.49038360e-01f,
  2.14014035e-02f, 2.00478449e-01f, 3.24318372e-02f, 2.08366215e-01f, 7.48191262e-03f, -3.24206576e-02f, 1.46528736e-01f, 2.01173201e-01f, 2.32213199e-01f, -4.67077792e-02f,
  3.95395309e-02f, 7.62816593e-02f, 1.51848614e-01f, 2.31656387e-01f, 1.55750349e-01f, 1.97238162e-01f, 1.10437460e-01f, 1.25116825e-01f, 8.41468871e-02f, -2.63690129e-02f,
  -2.79054455e-02f, -7.20837153e-03f, -2.39223968e-02f, -2.86746193e-02f, 1.37609154e-01f, -1.39930891e-02f, 1.70122251e-01f, -3.04117054e-01f, 8.26065615e-02f, 1.86320692e-01f,
  1.47860542e-01f, 2.68704128e-02f, 1.83191299e-02f, 1.54482620e-02f, -1.07318573e-01f, 1.13754950e-01f, 2.41086081e-01f, -2.87543714e-01f, -1.65289849e-01f, 2.06246302e-01f,
  2.80686244e-02f, -3.13679993e-01f, -6.33463115e-02f, 2.83442259e-01f, 9.86968726e-02f, -7.26323351e-02f, 1.12911016e-02f, -1.96496800e-01f, -1.95464462e-01f, 2.36994424e-03f,
  -1.21315949e-01f, 1.05675399e-01f, -1.94673583e-01f, 2.07239121e-01f, -7.47365579e-02f, 2.54471004e-01f, 3.95600311e-02f, 7.33469948e-02f, -1.36338249e-01f, -2.60933768e-02f,
  1.08842447e-01f, 1.04085594e-01f, -1.62501149e-02f, 2.47972146e-01f, -3.13355997e-02f, 1.24439292e-01f, 4.09157798e-02f, 9.43815336e-02f, 8.09330195e-02f, -8.60249922e-02f,
  4.84137721e-02f, 1.15937941e-01f, 2.76322156e-01f, 6.66896030e-02f, 1.69307575e-01f, -1.70855224e-02f, 5.34926541e-02f, 1.71484232e-01f, 2.21623227e-01f, 1.27388090e-01f,
  1.22791819e-01f, 1.56321600e-01f, 1.30677193e-01f, 5.05007841e-02f, 2.24385858e-02f, -1.36275098e-01f, -2.44754612e-01f, -1.98674351e-02f, 2.88665649e-02f, -8.87973309e-02f,
  2.92820007e-01f, 6.40015292e-04f, -1.10823654e-01f, 7.98020959e-02f, -8.81979242e-02f, 9.70889330e-02f, -1.25882655e-01f, -5.33598177e-02f, 1.69166997e-02f, 3.84154432e-02f,
  2.12193504e-01f, -7.09183142e-02f, -5.81931360e-02f, 2.54389077e-01f, 1.27309233e-01f, -1.00611731e-01f, 8.15497711e-03f, 2.11977959e-01f, 2.24188864e-01f, 6.71926811e-02f,
  -1.22958176e-01f, -2.00815387e-02f, 2.14691252e-01f, 1.77218869e-01f, 1.33741811e-01f, -9.68081430e-02f, -7.14695305e-02f, 3.51674086e-03f, 7.02604577e-02f, 1.63304627e-01f,
  1.16482712e-01f, 1.31930172e-01f, -6.79710507e-02f, -5.40277213e-02f, 1.94987863e-01f, 1.15467988e-01f, 7.13871792e-02f, 6.33410439e-02f, 5.34344185e-03f, -2.74160132e-02f,
  -1.56949207e-01f, -1.55912191e-01f, 9.29526519e-04f, -7.35332891e-02f, 1.84186891e-01f, 9.08610672e-02f, 1.96061283e-03f, 2.15707749e-01f, -2.27070674e-02f, 1.03256248e-01f,
  -8.58008042e-02f, 1.27535343e-01f, -1.52985668e-02f, 2.00399935e-01f, 1.94569394e-01f, 2.81357691e-02f, -2.42798790e-01f, 5.58652468e-02f, -1.13897473e-01f, -8.67413804e-02f,
  8.87459815e-02f, -8.30037370e-02f, 2.11739037e-02f, -1.47095144e-01f, -7.64295384e-02f, 8.35968927e-02f, -1.07340924e-01f, 2.80843442e-03f, 1.73444062e-01f, -2.89089959e-02f,
  -3.16830352e-02f, 1.38333037e-01f, 1.58957168e-01f, -5.01588620e-02f, -1.86387882e-01f, 5.88923171e-02f, 1.16680890e-01f, -8.59409794e-02f, 2.91306246e-02f, 5.67347333e-02f,
  6.37615249e-02f, -2.02717513e-01f, -7.42068887e-02f, 1.26793459e-01f, 1.68109536e-01f, 6.11750782e-02f, -1.82517394e-02f, -1.87835187e-01f, -1.58659264e-01f, -1.36537224e-01f,
  8.20037276e-02f, -1.47808209e-01f, 5.17052189e-02f, -1.38664931e-01f, 1.43768325e-01f, 3.77928913e-02f, 4.01054136e-02f, 1.60899475e-01f, -7.18632936e-02f, 3.64715271e-02f,
  1.43333852e-01f, -1.06625527e-01f, -4.46538366e-02f, 8.98340046e-02f, -7.40742311e-02f, -3.87632884e-02f, 1.02547847e-01f, 5.12553984e-03f, 1.18874468e-01f, 2.12851912e-01f,
  4.62619998e-02f, 9.86753255e-02f, 1.95987243e-03f, 1.90137193e-01f, 5.17411716e-02f, 1.12094015e-01f, 5.93044199e-02f, 6.43357784e-02f, 2.01125145e-01f, 1.96969762e-01f,
  -2.10046306e-01f, -1.29090220e-01f, -3.28032449e-02f, -1.51012927e-01f, 1.17000781e-01f, 1.40166000e-01f, -5.35741635e-02f, 3.63160558e-02f, -2.19232440e-01f, 7.34492913e-02f,
  9.62099954e-02f, 2.29318157e-01f, 2.09889598e-02f, -3.73945273e-02f, 7.54682496e-02f, -5.40229082e-02f, 3.29556651e-02f, 1.98915958e-01f, -1.16310537e-01f, -6.16914295e-02f,
  -2.00102985e-01f, 4.84283641e-02f, 1.77810028e-01f, 2.12953791e-01f, 3.34844232e-01f, -1.81776807e-01f, -1.15050070e-01f, 1.09486869e-02f, 2.38472655e-01f, 1.40836492e-01f,
  -6.45866022e-02f, -2.40951404e-02f, 3.48962098e-02f, -8.71223509e-02f, 3.17445993e-02f, -2.25491617e-02f, 7.06172884e-02f, -1.17302038e-01f, 1.47311255e-01f, -9.22151506e-02f,
  2.41534323e-01f, -2.26417705e-02f, -1.25626981e-01f, -1.72597900e-01f, 6.35394081e-02f, 2.36228090e-02f, -8.13489407e-02f, 4.39342819e-02f, 1.01690039e-01f, 2.55200326e-01f,
  1.80886284e-01f, 1.51569992e-01f, 1.78501904e-01f, 1.48560986e-01f, 1.00088544e-01f, 2.63456907e-02f, -4.10144683e-03f, 2.48819977e-01f, -9.35706943e-02f, -7.81298950e-02f,
  1.12647176e-01f, 1.64648294e-01f, 5.83177023e-02f, -2.33622864e-02f, -2.81691492e-01f, 7.85568208e-02f, -3.50002870e-02f, 9.89275649e-02f, 1.09620303e-01f, -1.41469195e-01f,
  2.53060967e-01f, -1.13321528e-01f, -1.86867073e-01f, 6.23920001e-02f, 5.60469739e-02f, -2.31436729e-01f, 2.00618029e-01f, -1.30078718e-01f, 1.75468519e-01f, 2.10624203e-01f,
  8.76364186e-02f, 2.13270020e-02f, -5.37360124e-02f, 7.08246231e-02f, 5.40284514e-02f, 1.54828265e-01f, 1.96586221e-01f, -2.03598902e-01f, 1.30328700e-01f, 1.32254720e-01f,
  -2.27819942e-02f, 4.76829223e-02f, 1.90247461e-01f, 7.10651502e-02f, -1.13895968e-01f, -9.52437297e-02f, -2.11405322e-01f, 1.27268940e-01f, 1.03587769e-01f, 3.75790661e-03f,
  1.06850676e-01f, 1.70535296e-01f, 7.59696588e-02f, -1.44207090e-01f, -1.12810127e-01f, 1.08505564e-03f, -1.24755077e-01f, 2.12803390e-02f, -2.09184766e-01f, -7.13256970e-02f,
  1.40997097e-01f, 1.16024695e-01f, 1.90996706e-01f, 4.39212807e-02f, 1.63670003e-01f, -2.37601791e-02f, -4.60196659e-02f, 1.22101568e-01f, 1.73183769e-01f, -5.65726049e-02f,
  1.52383611e-01f, 7.25301579e-02f, 2.79242755e-03f, 9.34817791e-02f, 1.34066358e-01f, 5.32805361e-02f, 1.00667432e-01f, 7.31952395e-03f, 1.88385338e-01f, 2.95940004e-02f,
  5.78489341e-02f, 6.16859421e-02f, -3.47473403e-03f, 4.55366895e-02f, -5.73939309e-02f, -3.11287073e-03f, 1.84854507e-01f, -1.89387828e-01f, -1.68741867e-01f, 1.58776149e-01f,
  7.90964663e-02f, 5.95441051e-02f, -7.89267123e-02f, 6.82963878e-02f, 1.06021133e-03f, 1.13844715e-01f, -1.46826310e-02f, -9.04522091e-02f, -1.31914243e-01f, 4.84516323e-02f,
  1.30150169e-01f, -1.30937740e-01f, -1.65304825e-01f, 1.88140020e-01f, 1.79714769e-01f, 2.25964538e-03f, 4.74633202e-02f, -4.62297052e-02f, 1.91061497e-02f, -7.26192594e-02f,
  -3.18779647e-02f, 5.86850494e-02f, -8.90830904e-02f, 1.50448695e-01f, -2.70682555e-02f, 1.49097845e-01f, -7.61112049e-02f, 1.95017233e-01f, 1.64591074e-02f, -2.97016371e-02f,
  4.47819233e-02f, 8.67755115e-02f, 1.05865672e-01f, 2.49008927e-03f, 9.28830132e-02f, -2.45681386e-02f, -2.49026120e-02f, -1.62499800e-01f, -2.74470150e-02f, -3.79827954e-02f,
  1.33283630e-01f, 1.57187894e-01f, 5.18508367e-02f, 1.26777411e-01f, 1.74558789e-01f, 2.09875666e-02f, 8.09621215e-02f, 8.19093140e-04f, 3.58246081e-02f, 1.63989559e-01f,
  6.72144815e-02f, 2.75870681e-01f, 3.03298850e-02f, -9.72231328e-02f, -1.59617558e-01f, -8.03337023e-02f, -3.41782048e-02f, 1.71620220e-01f, -1.20585613e-01f, -1.07329600e-01f,
  1.80283532e-01f, 1.53137892e-01f, -1.18571110e-01f, 5.57412803e-02f, -5.47996946e-02f, 6.32680533e-03f, 1.79720625e-01f, 1.01552166e-01f, 7.75655657e-02f, 1.44075483e-01f,
  8.02413300e-02f, 1.88562736e-01f, 1.39241949e-01f, -1.59643307e-01f, 6.58813268e-02f, 1.78030208e-01f, 3.20033245e-02f, -8.42084065e-02f, 2.36240804e-01f, 2.55888164e-01f,
  9.14622098e-02f, 1.54077142e-01f, 2.32199445e-01f, 9.23443660e-02f, 1.18560202e-01f, -2.55167652e-02f, 5.32709919e-02f, -2.15043798e-01f, 4.02758308e-02f, -1.51498437e-01f,
  1.72645599e-01f, 1.18048094e-01f, 2.92653173e-01f, 1.23744786e-01f, 1.04254909e-01f, -1.32587314e-01f, 6.73004761e-02f, -4.97535877e-02f, -5.45323640e-02f, 1.00637294e-01f,
  5.24230935e-02f, 1.97542712e-01f, -1.33177936e-01f, -3.98997329e-02f, 1.14549220e-01f, -1.82891209e-02f, -3.40258703e-02f, 1.41812816e-01f, 1.46824479e-01f, 7.93493837e-02f,
  1.37269169e-01f, 1.37949601e-01f, 7.38352910e-03f, 1.29131338e-04f, 8.95611243e-04f, 1.14602512e-02f, 1.07746631e-01f, -9.83739570e-02f, -7.94773027e-02f, 9.76074859e-02f,
  1.03027210e-01f, -1.30562698e-02f, 4.53972071e-02f, 1.33639231e-01f, -5.48170172e-02f, 8.31201747e-02f, 3.51618999e-03f, 1.46107925e-02f, -4.50531729e-02f, 1.18537664e-01f,
  1.01863079e-01f, -1.54415891e-01f, 1.87836252e-02f, -7.41678625e-02f, 1.31754354e-01f, 1.76435620e-01f, 1.26367897e-01f, -1.97886631e-01f, 4.79412600e-02f, 1.78994253e-01f,
  1.79898679e-01f, -1.00228779e-01f, 6.82356432e-02f, 8.01297352e-02f, 3.39754601e-03f, 1.22020217e-02f, -3.10276151e-02f, 2.15629384e-01f, 1.32599259e-02f, 8.72909054e-02f,
  1.04623817e-01f, 4.80463766e-02f, 1.73579976e-01f, -1.63872629e-01f, 6.77225217e-02f, -1.91297010e-01f, 2.50718594e-01f, -7.14351833e-02f, 8.13825801e-02f, 3.07566449e-02f,
  -5.35441488e-02f, 3.61107802e-03f, -9.02401283e-02f, 1.27881482e-01f, 1.39583901e-01f, 1.71064764e-01f, 9.81698632e-02f, 1.30909100e-01f, 2.31872693e-01f, 8.29384103e-02f,
  7.76527636e-03f, 1.65511072e-02f, -3.00793331e-02f, 9.86108482e-02f, -5.36995381e-02f, 1.02606207e-01f, 1.15799509e-01f, 9.18647572e-02f, 4.50755954e-02f, 1.38981178e-01f,
  -7.98008144e-02f, 1.83624715e-01f, -3.04407179e-01f, -8.97525251e-02f, -1.41609073e-01f, 2.72659302e-01f, 9.37951133e-02f, -5.41596264e-02f, 3.01347613e-01f, 1.37390837e-01f,
  8.26088563e-02f, -1.26921996e-01f, -3.47573049e-02f, 1.88344896e-01f, -3.63473624e-01f, -1.40050352e-01f, 3.21095921e-02f, -1.02697685e-01f, -1.62039965e-01f, 9.71174911e-02f,
  -2.86168724e-01f, 2.23251119e-01f, -1.24469057e-01f, 7.19161704e-02f, -7.01436177e-02f, 1.07113875e-01f, 2.88762189e-02f, -1.88924670e-01f, 1.08316831e-01f, 7.77537003e-02f,
  1.42921120e-01f, -3.57817382e-01f, -1.34870306e-01f, -2.58354366e-01f, -2.04554363e-03f, 3.17182332e-01f, 1.53544992e-01f, 2.17907876e-01f, -3.23715925e-01f, -3.80538218e-02f,
  -6.38330057e-02f, -1.62306260e-02f, 6.85101151e-02f, 1.41952962e-01f, 1.05052255e-01f, -3.81459296e-02f, 5.35555743e-03f, -1.46342367e-01f, -1.40208155e-01f, -9.55517143e-02f,
  3.68360360e-03f, -4.92395088e-02f, -1.51332505e-02f, -4.59365137e-02f, 7.09252208e-02f, -1.97185762e-02f, -5.22323288e-02f, 2.25036308e-01f, 1.51757076e-01f, -4.12152521e-02f,
  2.10463721e-02f, -7.30627701e-02f, -4.22901772e-02f, -1.05005108e-01f, 7.27967918e-02f, -2.67067663e-02f, -7.48391775e-03f, -5.65236295e-03f, -8.54364857e-02f, -1.08514344e-02f,
  -9.09739509e-02f, 1.05543926e-01f, -8.42094868e-02f, 6.83594421e-02f, -1.59901511e-02f, -6.13537282e-02f, -1.29509747e-01f, 7.65318573e-02f, 1.07352115e-01f, -7.43990317e-02f,
  -1.36487171e-01f, -1.82554219e-02f, 1.52177781e-01f, 3.64371203e-02f, 1.16926633e-01f, -8.67663398e-02f, 1.44160092e-01f, -2.99877763e-01f, 9.17720646e-02f, 5.66668622e-02f,
  -2.95504909e-02f, -1.91697791e-01f, 1.47914201e-01f, -1.65992424e-01f, -3.47202346e-02f, 1.77495152e-01f, -1.56097636e-01f, 2.50594020e-01f, -1.30838573e-01f, -1.46523967e-01f,
  8.44558328e-02f, -1.46635264e-01f, 5.10802083e-02f, -7.94776976e-02f, 2.78738365e-02f, 6.58511147e-02f, -8.53866711e-02f, 2.24169835e-01f, -8.31349343e-02f, 1.48939908e-01f,
  2.79969156e-01f, -1.20424271e-01f, 2.70554125e-01f, 5.72659187e-02f, 2.37726033e-01f, 9.79550779e-02f, -2.10988037e-02f, 6.94414750e-02f, -9.10071880e-02f, 2.60233860e-02f,
  7.71265998e-02f, 1.05841301e-01f, 4.28637005e-02f, 1.68970764e-01f, 1.14255510e-01f, -2.93968003e-02f, 8.75967368e-02f, -9.58620682e-02f, 2.15328068e-01f, -1.35550946e-01f,
  1.11001395e-01f, 2.16366827e-01f, 6.47040755e-02f, 5.54098468e-03f, 8.23017061e-02f, 9.64480266e-02f, -2.66272038e-01f, -1.10157914e-01f, 8.57911364e-04f, -1.37109965e-01f,
  1.67109028e-01f, 7.19256699e-02f, 2.22246915e-01f, 8.36570412e-02f, -1.18525717e-02f, 1.22047178e-01f, 2.01505229e-01f, 1.52588084e-01f, 2.15499446e-01f, -1.11584805e-01f,
  -1.22625232e-01f, 1.27071291e-02f, 2.31528267e-01f, 1.08964682e-01f, 3.18746120e-02f, 8.52299333e-02f, 1.31392896e-01f, 1.56543493e-01f, -1.39680579e-01f, 2.12820366e-01f,
  1.65663689e-01f, 2.23944992e-01f, 2.03975499e-01f, -4.17313119e-03f, 1.23843044e-01f, -1.43941883e-02f, 1.44957453e-01f, -1.43098161e-01f, 1.70243099e-01f, -3.84084731e-02f,
  1.16956964e-01f, 9.50605795e-03f, -1.07125394e-01f, 1.14322521e-01f, -3.20538729e-02f, 1.12621821e-01f, 1.18710659e-01f, 1.73665121e-01f, 1.01978563e-01f, 1.54836208e-01f,
  2.35360280e-01f, -7.04087541e-02f, 2.06736892e-01f, 7.27392547e-03f, -5.44013968e-03f, -1.05747446e-01f, 9.03044865e-02f, 2.59991810e-02f, 2.29904830e-01f, 1.64785862e-01f,
  1.63901508e-01f, 1.46412715e-01f, 9.36622024e-02f, 2.16873109e-01f, -2.05487117e-01f, -7.80401868e-04f, 3.98000255e-02f, 6.43171882e-03f, 1.25410542e-01f, -5.53584434e-02f,
  -1.29696180e-03f, -2.75102188e-03f, -7.92208761e-02f, -3.25983912e-01f, 1.40267745e-01f, 1.67593241e-01f, -9.21607018e-02f, 1.81691647e-01f, -2.89306473e-02f, 9.82454941e-02f,
  1.37545034e-01f, 1.29710017e-02f, 1.93992153e-01f, 2.38346249e-01f, -3.77958007e-02f, 3.35232099e-03f, -1.62980586e-01f, 8.51197615e-02f, 1.77675098e-01f, 1.22751974e-01f,
  6.49235118e-03f, 2.16625575e-02f, 2.31435344e-01f, -2.52408326e-01f, -1.32058173e-01f, 1.91086397e-01f, 5.73573150e-02f, 2.24140689e-01f, 2.03042343e-01f, 1.19624943e-01f,
  1.17092259e-01f, 4.22888584e-02f, -1.36080563e-01f, -4.58324961e-02f, 1.60624608e-01f, 3.70483458e-01f, 7.63488486e-02f, -5.00088483e-02f, 1.11547701e-01f, -9.55982879e-02f,
  -8.44601076e-03f, -2.21294388e-01f, 3.79701927e-02f, 2.04208761e-01f, 7.79828196e-03f, 2.15051949e-01f, 3.45255621e-02f, 6.92430511e-02f, 1.00623168e-01f, 5.68328938e-03f,
  1.45120353e-01f, 1.52279973e-01f, 1.18818395e-02f, 5.60476929e-02f, 5.34072034e-02f, 8.41470733e-02f, 1.02626406e-01f, -9.45315789e-03f, 2.46508978e-02f, -3.61520112e-01f,
  -2.97071338e-01f, -1.35897592e-01f, -5.55283278e-02f, 4.73044328e-02f, 1.53476492e-01f, -9.93482694e-02f, -4.22069840e-02f, 1.82698756e-01f, -6.85795471e-02f, 7.73077086e-02f,
  -2.12967724e-01f, 1.30810082e-01f, -9.60978866e-02f, 9.97140184e-02f, 1.33618847e-01f, -2.02309206e-01f, -1.89155191e-01f, -5.38231544e-02f, 1.79964721e-01f, -2.25298494e-01f,
  -1.64536208e-01f, 2.52118111e-01f, -6.17286712e-02f, -1.94407076e-01f, 8.76662731e-02f, -7.46319890e-02f, 4.82025929e-02f, 7.34227747e-02f, -9.57100168e-02f, -4.58422601e-02f,
  -2.72333205e-01f, -3.04020513e-02f, 1.37191966e-01f, 2.71785706e-01f, -1.14426754e-01f, -2.60295509e-03f, -7.25836381e-02f, 4.88974787e-02f, 1.67199537e-01f, 1.27293158e-03f,
  -7.71572739e-02f, 2.29956195e-01f, -3.76757141e-03f, 1.94312587e-01f, -1.04185238e-01f, -1.06733441e-01f, -7.89020509e-02f, -1.22787356e-02f, 1.26872018e-01f, 1.70068204e-01f,
  6.44421279e-02f, -1.15412848e-04f, 8.49896893e-02f, 1.48174062e-01f, 1.99673459e-01f, 1.56711116e-01f, 1.13761537e-01f, 2.46057257e-01f, 1.75781593e-01f, 1.39225483e-01f,
  2.16549054e-01f, 1.65795058e-01f, 2.90906616e-02f, -5.36503494e-02f, -1.46793306e-01f, -1.15894288e-01f, -7.15189129e-02f, 4.47715186e-02f, 1.42539188e-01f, -5.07159717e-02f,
  6.09093299e-03f, -3.84816751e-02f, 1.86364204e-01f, -4.43486543e-03f, -2.44118869e-02f, 8.09987355e-03f, 8.18495080e-03f, 5.03563248e-02f, 1.87970087e-01f, -6.05657557e-03f,
  -1.81278378e-01f, 1.12137929e-01f, 1.25745565e-01f, -1.68665394e-01f, -2.45745201e-03f, 3.60724002e-01f, 2.27631647e-02f, -1.57568857e-01f, -1.39218122e-01f, -7.24006891e-02f,
  -2.06091374e-01f, 1.96634963e-01f, -4.02753986e-02f, 8.47499594e-02f, 7.41301700e-02f, 2.86091328e-01f, -6.11881614e-02f, 2.40573674e-01f, 6.48375824e-02f, -2.24137753e-02f,
  -1.89536139e-01f, 6.49075769e-03f, 9.09755006e-02f, -5.99083956e-03f, 4.60944418e-03f, 2.96371043e-01f, 8.19992051e-02f, -7.49010220e-02f, -2.05778077e-01f, -1.22405529e-01f,
  1.34385452e-01f, -8.19287077e-02f, 1.16731115e-01f, 8.47464055e-02f, 2.44524032e-01f, -2.85940990e-02f, 2.34816521e-02f, -7.14437068e-02f, 9.93461013e-02f, -1.41473366e-02f,
  9.14981216e-02f, 8.38378966e-02f, 1.28887460e-01f, 2.98758484e-02f, -7.67198652e-02f, 1.69940650e-01f, -1.19121544e-01f, -8.97114575e-02f, 5.47455736e-02f, -1.45491868e-01f,
  9.56428722e-02f, -2.29029343e-01f, -1.75743416e-01f, -1.47071794e-01f, -3.10074817e-02f, -4.43788879e-02f, 2.53335297e-01f, -3.57621945e-02f, -1.95765253e-02f, 1.67606533e-01f,
  1.69281587e-01f, 2.10124403e-01f, -4.44295518e-02f, -2.97470298e-02f, 6.47123754e-02f, 1.55977858e-02f, 3.51144411e-02f, 1.07518420e-01f, -1.25009790e-01f, -7.12556764e-02f,
  1.90932423e-01f, 1.41933471e-01f, -5.26986346e-02f, 4.62684557e-02f, -5.19697974e-03f, -1.26290485e-01f, -1.25238806e-01f, -3.14162932e-02f, 2.54052490e-01f, -3.73393036e-02f,
  1.04789890e-01f, 8.10523033e-02f, 1.18004844e-01f, 9.74863842e-02f, 1.10031426e-01f, 2.93030459e-02f, 9.93955806e-02f, -1.19537979e-01f, 7.35525489e-02f, -1.78396568e-01f,
  -1.80965990e-01f, -3.63140218e-02f, 3.19377668e-02f, 1.39497086e-01f, -1.56013921e-01f, -1.21846728e-01f, 1.46777973e-01f, 1.10646106e-01f, 3.07042561e-02f, 1.43145517e-01f,
  1.18947580e-01f, 2.37340122e-01f, 4.75755595e-02f, 9.60186347e-02f, 3.04389428e-02f, 4.03356701e-02f, 8.96164849e-02f, 6.03694208e-02f, -1.55012265e-01f, -8.79788697e-02f,
  1.42433822e-01f, 2.13952452e-01f, 1.48027346e-01f, -2.47271117e-02f, 2.54355460e-01f, -1.13065407e-01f, -1.57659292e-01f, -2.50890821e-01f, 1.50385633e-01f, -1.30579412e-01f,
  1.97086841e-01f, -1.64138302e-01f, -2.39869915e-02f, 1.35759488e-01f, 5.73599525e-02f, 3.27074043e-02f, 4.70681861e-02f, -1.85521364e-01f, -2.42900193e-01f, 2.53518254e-01f,
  9.94520355e-03f, -1.15927979e-01f, 1.47399992e-01f, 1.43067434e-01f, 6.50172262e-03f, -1.80947840e-01f, 1.21532992e-01f, -2.42597669e-01f, -1.65071905e-01f, 1.83959827e-02f,
  7.43112490e-02f, 6.44362420e-02f, 7.80054256e-02f, 1.26658440e-01f, -7.83890933e-02f, 1.17280096e-01f, -1.05677061e-01f, 4.27590571e-02f, 4.07207612e-04f, 1.32032990e-01f,
  -1.72809422e-01f, 9.55736563e-02f, -1.73634455e-01f, 8.57833400e-02f, -1.37519301e-03f, 1.36331618e-02f, 8.25612154e-03f, 9.31411535e-02f, 9.13130417e-02f, -1.31744951e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -7.80324414e-02f, 1.24109000e-01f, 1.03968278e-01f, 1.32205874e-01f, 1.15455762e-01f, -1.03748776e-02f, 1.20469943e-01f, 3.41656357e-02f, 1.32141693e-03f, 5.69447316e-02f,
  2.18635537e-02f, 4.79207076e-02f, 1.19367816e-01f, 2.70539463e-01f, 1.01056598e-01f, 1.47716478e-01f, 1.29737675e-01f, 1.77919045e-01f, 1.66689366e-01f, 1.05723098e-01f,
  1.84345450e-02f, 1.45864757e-02f, 1.65679991e-01f, 4.48706225e-02f, 2.09535155e-02f, 4.06876132e-02f, 1.56538159e-01f, 9.48533509e-03f, 1.20763597e-03f, 1.64814472e-01f,
  5.00164628e-02f, 8.71646628e-02f, -7.89739098e-03f, 9.26444083e-02f, 1.63628131e-01f, 2.28943691e-01f, 9.64464545e-02f, 2.74630357e-02f, -1.73166785e-02f, 1.10671133e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.09496288e-01f, -4.54076529e-02f, -1.47093847e-01f, -1.57114029e-01f, 1.93970837e-02f, -3.27290185e-02f, 5.01574157e-03f, -1.22809984e-01f, -2.97123864e-02f, 3.11681982e-02f,
  -3.16749923e-02f, 1.16456367e-01f, -2.30354462e-02f, -4.99469712e-02f, 5.50021753e-02f, 3.76693681e-02f, -1.56036600e-01f, 2.15971515e-01f, 7.11504444e-02f, 3.57768722e-02f,
  -5.97652979e-02f, -1.70707941e-01f, -1.75464764e-01f, -1.18358970e-01f, -6.01923838e-02f, 1.19534127e-01f, -1.11199856e-01f, -1.29101977e-01f, -1.14075236e-01f, -1.64813191e-01f,
  -5.25330417e-02f, -9.24468040e-02f, -7.48619363e-02f, 1.02707423e-01f, -1.98420316e-01f, -1.48939353e-03f, -2.01960310e-01f, 6.20087087e-02f, 1.75415188e-01f, 1.84136685e-02f,
  2.36387506e-01f, 7.44341910e-02f, 3.66674885e-02f, -1.01351524e-02f, 1.88829929e-01f, -1.60321191e-01f, -1.45547111e-02f, -3.39104384e-02f, 5.53695932e-02f, 1.41790986e-01f,
  -1.10746384e-01f, 2.24517938e-02f, -2.87930630e-02f, 8.44876617e-02f, 9.52213034e-02f, -7.58183524e-02f, -1.63658649e-01f, -1.38718501e-01f, -4.18745354e-02f, -1.18714780e-01f,
  -9.92234945e-02f, -1.33092865e-01f, 1.06630602e-03f, 8.11117515e-02f, 3.98861542e-02f, -6.58288375e-02f, -7.47325197e-02f, -6.36808127e-02f, -1.41129643e-01f, 1.04773045e-01f,
  -3.62396576e-02f, -1.17798373e-02f, -1.81473732e-01f, 6.71504736e-02f, 1.61062309e-03f, 6.95603415e-02f, -1.96390934e-02f, 7.81881735e-02f, -1.10994883e-01f, 6.68153018e-02f,
  -2.80538816e-02f, -6.93396777e-02f, -5.54027520e-02f, 1.07583389e-01f, -8.58710557e-02f, 7.54842609e-02f, 4.75433143e-03f, 1.55620575e-01f, -9.96190868e-03f, -7.74036646e-02f,
  7.92115629e-02f, -5.38861491e-02f, 1.32187054e-01f, 9.32244584e-02f, 8.81274492e-02f, 2.43551619e-02f, -1.63967058e-01f, -1.15192592e-01f, -1.76529624e-02f, 7.37306774e-02f,
  -1.62730739e-01f, -4.91828611e-03f, -2.92226542e-02f, 1.35849461e-01f, -1.86683804e-01f, 1.15715913e-01f, -7.33756721e-02f, -2.10467763e-02f, 3.10677532e-02f, -7.07415044e-02f,
  -1.05156496e-01f, -7.14570954e-02f, -5.71942590e-02f, -1.87478155e-01f, -4.22438905e-02f, 1.45886108e-01f, 1.54302880e-01f, -1.70045227e-01f, 5.77234291e-02f, 8.17428902e-02f,
  -3.62498872e-02f, 5.04590012e-02f, 1.00235127e-01f, 3.29149403e-02f, -2.55002201e-01f, -1.20599754e-02f, 1.60887077e-01f, -1.18550517e-01f, 1.28833175e-01f, -3.37975062e-02f,
  3.87675539e-02f, -1.59041271e-01f, -6.30128756e-02f, -8.50453507e-03f, -1.30662560e-01f, -5.31008542e-02f, -8.26518536e-02f, 7.68975839e-02f, -4.50653397e-02f, -1.03189871e-01f,
  1.00917213e-01f, -1.76242024e-01f, -1.36368245e-01f, 1.32145375e-01f, 2.28902493e-02f, 9.14030671e-02f, 1.65093601e-01f, 2.33866926e-02f, -3.89446728e-02f, 7.21071437e-02f,
  5.99444173e-02f, 7.33259097e-02f, -9.03825611e-02f, -9.74110365e-02f, -1.15635037e-01f, 1.38262793e-01f, 7.44303241e-02f, -2.23951280e-01f, 1.43566713e-01f, 9.24159586e-02f,
  1.33840367e-01f, 1.48859560e-01f, 6.76263943e-02f, -1.15287043e-02f, 1.08772583e-01f, -9.50650945e-02f, -7.46865571e-02f, -1.45947158e-01f, 9.66629684e-02f, -9.06109158e-03f,
  1.68414548e-01f, -7.14247823e-02f, -7.72221163e-02f, -5.54197729e-02f, 4.34721299e-02f, 1.63735747e-01f, -1.31712496e-01f, 2.30237041e-02f, 7.97672570e-02f, 1.45318180e-01f,
  1.02898069e-01f, -5.12877516e-02f, -4.01172228e-02f, -9.36104879e-02f, -1.51761234e-01f, -2.31581822e-01f, 1.23881176e-01f, -1.01326630e-01f, -7.21360296e-02f, 2.28990130e-02f,
  1.60701245e-01f, 7.80016705e-02f, 1.09909587e-01f, 1.30246822e-02f, 1.15982927e-01f, -1.09836254e-02f, -6.82727471e-02f, -7.02960864e-02f, 1.13524301e-02f, -1.09891899e-01f,
  4.72596437e-02f, -8.40509385e-02f, 4.34792601e-02f, 2.17577554e-02f, 5.12346104e-02f, -8.89447182e-02f, 8.21013227e-02f, -8.16975981e-02f, 1.86766371e-01f, -7.86378235e-02f,
  2.43236665e-02f, -3.54744308e-02f, 5.33448495e-02f, 3.09756454e-02f, -9.17950831e-03f, 1.04557306e-01f, -1.00208871e-01f, -1.10103734e-01f, 1.56546421e-02f, 5.75229563e-02f,
  -1.45334266e-02f, 2.46988088e-01f, 1.68999344e-01f, -9.13960263e-02f, -1.43396586e-01f, -1.83582395e-01f, 4.87045199e-02f, -1.39177561e-01f, -9.06692725e-03f, 5.64658940e-02f,
  -1.22872382e-01f, 1.25388399e-01f, -2.10265070e-01f, -6.75938500e-04f, -4.60907780e-02f, -9.76783857e-02f, -1.93350520e-02f, -5.56949973e-02f, 5.36611155e-02f, 1.21528834e-01f,
  9.37186629e-02f, -8.31516013e-02f, 1.76718429e-01f, -6.68472983e-03f, 1.79495290e-01f, -1.56256795e-01f, 2.39509568e-02f, -1.06765144e-01f, 1.68291196e-01f, 1.74900159e-01f,
  -6.78464919e-02f, 1.58499703e-01f, 2.00106222e-02f, -2.39281449e-02f, 5.91947772e-02f, -7.64108971e-02f, 1.28296884e-02f, -7.73925260e-02f, -1.34807393e-01f, -1.58005267e-01f,
  1.10807516e-01f, 1.84775963e-02f, 2.28190050e-02f, 9.66202375e-03f, -6.43978044e-02f, -7.64648914e-02f, -9.82638728e-03f, 1.40501082e-01f, -6.83574900e-02f, 1.23027198e-01f,
  1.53836250e-01f, 2.44377926e-02f, -1.42197236e-01f, 4.09032293e-02f, 2.52499003e-02f, -2.61554774e-02f, 9.88161638e-02f, 1.00195594e-01f, -1.38089016e-01f, -3.05885356e-02f,
  -2.05145888e-02f, 6.75197020e-02f, -1.44315697e-03f, -4.33043316e-02f, -7.07395375e-02f, -1.01425067e-01f, -1.20156661e-01f, -1.15694568e-01f, 1.45893127e-01f, 1.18218005e-01f,
  -1.78289175e-01f, 1.59204781e-01f, -1.56953946e-01f, -1.42844841e-01f, 5.07643260e-02f, -1.02756388e-01f, 2.61037380e-01f, -9.85149294e-02f, 2.99289934e-02f, 7.14287441e-03f,
  2.53397040e-02f, -7.69403204e-02f, -3.94859314e-02f, -1.31925315e-01f, 4.08642627e-02f, 6.84715435e-02f, -1.25184536e-01f, -5.86560518e-02f, -1.16546869e-01f, -6.91621974e-02f,
  1.37627020e-01f, -1.28239430e-02f, -2.72513479e-01f, -1.09592520e-01f, 7.79653341e-02f, -9.85929891e-02f, 8.21475238e-02f, 5.01444079e-02f, -4.98766415e-02f, 1.10195447e-02f,
  -1.64889067e-03f, -1.35581866e-01f, -2.51250621e-02f, -1.79490317e-02f, 3.97019275e-02f, -1.45682797e-01f, -1.06198229e-01f, 2.78612860e-02f, 9.82255563e-02f, -4.90420945e-02f,
  4.52939384e-02f, -8.83893073e-02f, 5.77459410e-02f, -7.42197335e-02f, 1.82296425e-01f, 9.27499533e-02f, 5.54346479e-03f, 7.79147893e-02f, 1.42165869e-01f, 6.92059344e-04f,
  1.15915790e-01f, 1.63870290e-01f, -7.17898980e-02f, -6.76710531e-02f, -8.93649533e-02f, -3.37201506e-02f, -4.32637185e-02f, -1.23693004e-01f, -1.61879122e-01f, -2.92197466e-01f,
  -1.25774369e-01f, 5.61898537e-02f, 1.49543241e-01f, 7.64392391e-02f, -1.88111752e-01f, -7.38711432e-02f, -1.58373252e-01f, -8.49923342e-02f, 2.26648256e-01f, -1.96141481e-01f,
  3.15123677e-01f, -8.90866946e-03f, 7.33407512e-02f, 1.17923580e-01f, -1.03155449e-01f, 6.93399757e-02f, 2.41183490e-02f, 1.47471307e-02f, -2.65968461e-02f, 4.10664305e-02f,
  -1.28810257e-01f, -6.02496080e-02f, -2.41072252e-01f, 4.23028320e-03f, 1.38759062e-01f, 5.02464883e-02f, -2.60224998e-01f, 5.62817231e-03f, 1.37874261e-02f, -2.82777119e-02f,
  5.33605590e-02f, 4.97392518e-03f, -2.33377125e-02f, 9.98890847e-02f, -4.16732244e-02f, 1.11819558e-01f, 1.09003723e-01f, -5.92716523e-02f, 1.98245067e-02f, 4.05998938e-02f,
  1.15518153e-01f, 2.49223281e-02f, -3.04658916e-02f, 6.98034018e-02f, 5.94075881e-02f, -8.78852755e-02f, -4.51321714e-02f, -2.12620869e-01f, -4.65346426e-02f, 3.71560305e-02f,
  -1.21603295e-01f, -3.13858353e-02f, -1.69412434e-01f, -1.35896176e-01f, -1.28560528e-01f, -1.11125901e-01f, 4.94618667e-03f, 5.72840013e-02f, 1.69438809e-01f, 1.55981556e-01f,
  -3.43622267e-02f, -7.97713250e-02f, -1.34740084e-01f, -7.27439523e-02f, 7.10368454e-02f, -1.75262377e-01f, -8.07251483e-02f, -8.70002955e-02f, 2.25621406e-02f, -4.46511321e-02f,
  9.80233401e-02f, -7.73920119e-02f, -2.02181906e-01f, 8.32421631e-02f, -1.58823192e-01f, 1.31572351e-01f, 5.93989268e-02f, -4.99741137e-02f, -1.00351609e-01f, 1.47886559e-01f,
  -1.56524286e-01f, -9.23276916e-02f, -7.94378296e-02f, 6.86571151e-02f, -7.70100765e-03f, -1.26119312e-02f, 2.91386303e-02f, 6.24134354e-02f, -3.98954712e-02f, -7.03105479e-02f,
  2.77092904e-01f, -3.07626814e-01f, -1.14014074e-01f, 1.32877022e-01f, -1.32046878e-01f, -2.51209401e-02f, 1.87706485e-01f, 7.16309696e-02f, -3.86158898e-02f, 1.11035883e-01f,
  1.31682694e-01f, 7.03263059e-02f, -4.69173603e-02f, 1.10436767e-01f, 8.53026435e-02f, -8.53241906e-02f, 4.08163816e-02f, -7.64922649e-02f, -6.82080463e-02f, -1.17244639e-01f,
  4.06444967e-02f, 4.39074039e-02f, -8.85449275e-02f, -8.97497386e-02f, 1.01496220e-01f, -7.24307150e-02f, -1.06838509e-01f, 1.70530304e-01f, -5.21138252e-04f, 7.45418221e-02f,
  -1.22215590e-02f, 1.67941123e-01f, -1.11800544e-01f, -2.92414445e-02f, 1.63134381e-01f, 2.08785698e-01f, -9.17464215e-03f, 1.66149527e-01f, 7.45279491e-02f, 6.71841810e-03f,
  8.64110738e-02f, -6.57730028e-02f, 5.10417968e-02f, -1.38017982e-01f, 1.18429661e-01f, 6.17776141e-02f, 6.19247034e-02f, -7.21882433e-02f, -1.32474244e-01f, -8.82047191e-02f,
  -6.39918000e-02f, -1.03530958e-01f, -1.16122320e-01f, 5.94501905e-02f, 6.08036630e-02f, 4.92197350e-02f, 7.68197849e-02f, -4.14143577e-02f, 1.33696422e-01f, 1.10025212e-01f,
  8.58535543e-02f, -1.48890197e-01f, -1.93887442e-01f, 4.35300805e-02f, 2.99314499e-01f, 2.45311439e-01f, -1.13900192e-01f, 2.18485743e-02f, 5.34479693e-02f, -9.51239616e-02f,
  -6.35814890e-02f, -4.06287126e-02f, 6.92951307e-02f, 2.78805709e-03f, -3.40304114e-02f, -7.98424184e-02f, 2.50354335e-02f, -5.17415889e-02f, -2.05851626e-02f, -1.79683596e-01f,
  -3.63362171e-02f, 9.91989896e-02f, -8.44969898e-02f, -6.79150894e-02f, 3.84227410e-02f, 6.12823665e-03f, -2.37409905e-01f, 1.25227258e-01f, 1.51974007e-01f, 8.03905353e-02f,
  1.99262455e-01f, -7.69298896e-02f, -1.03461213e-01f, -1.21676661e-01f, 1.41978994e-01f, 8.44092108e-03f, -1.01264477e-01f, -9.15649161e-03f, 1.40227243e-01f, -4.82476242e-02f,
  1.00456603e-01f, 9.95639190e-02f, 1.26487568e-01f, -1.34834409e-01f, -2.05661416e-01f, 8.49635750e-02f, -3.57651315e-03f, 1.23641277e-02f, -6.07731789e-02f, -1.73989683e-01f,
  -1.87349796e-01f, -1.14566116e-02f, 1.01842970e-01f, 2.23317593e-01f, -6.71122447e-02f, 6.89857034e-03f, -7.04728886e-02f, 9.39690843e-02f, 7.76986778e-02f, -1.17953949e-01f,
  -1.17675588e-01f, -1.83562204e-01f, -2.51277909e-02f, -5.25943898e-02f, 2.01710850e-01f, -2.41616573e-02f, 8.85833874e-02f, 1.44010052e-01f, 8.01071823e-02f, 3.93390618e-02f,
  1.40534146e-02f, -8.99325497e-03f, -2.44435430e-01f, -1.53072610e-01f, -6.00198880e-02f, 1.52806997e-01f, -7.99167603e-02f, -7.07833171e-02f, -7.97613487e-02f, 8.29618275e-02f,
  8.55579823e-02f, 5.83705418e-02f, 1.52401580e-02f, -5.31968735e-02f, 9.17633325e-02f, -8.23052526e-02f, -1.05533496e-01f, -1.14892200e-02f, -5.97488955e-02f, 1.77588925e-01f,
  -1.56244813e-02f, 4.81187664e-02f, -1.14792429e-01f, 4.77655493e-02f, -2.87891775e-02f, 4.14030664e-02f, 1.32244080e-01f, -4.42093797e-02f, -2.25939870e-01f, 5.63949682e-02f,
  -4.12804410e-02f, -6.27688989e-02f, -9.19529647e-02f, -1.52317703e-01f, -1.07084222e-01f, 4.50941883e-02f, -9.71844569e-02f, 8.33715275e-02f, 6.81246221e-02f, 4.16212007e-02f,
  -1.13878176e-01f, 1.53032541e-01f, -1.34805247e-01f, 2.27776193e-03f, 2.15101577e-02f, 1.45654649e-01f, 2.75102794e-01f, -5.56765795e-02f, -4.27595247e-03f, 1.20142072e-01f,
  2.34434307e-01f, -1.54550865e-01f, 3.45428996e-02f, -1.09945588e-01f, -3.23233269e-02f, -1.21084765e-01f, 6.14610538e-02f, 6.49465993e-02f, -8.97300467e-02f, 1.48195773e-02f,
  1.87332720e-01f, 1.93512499e-01f, -5.81811853e-02f, 1.46377850e-02f, 5.60686849e-02f, -1.73166588e-01f, -1.73580766e-01f, 9.35833622e-03f, -1.73554242e-01f, -7.12828562e-02f,
  -4.13934626e-02f, -6.19590543e-02f, 7.07102120e-02f, 1.73597857e-01f, 1.12664334e-01f, -7.46048316e-02f, 4.81956974e-02f, 1.83394924e-01f, -6.21032417e-02f, 2.48101484e-02f,
  8.40310976e-02f, 2.37390287e-02f, -3.74755301e-02f, 5.21030016e-02f, 8.90171751e-02f, -5.12918830e-03f, -4.46282253e-02f, 1.34018436e-01f, -1.11075975e-01f, -1.07603118e-01f,
  -8.74006450e-02f, -7.27592036e-03f, 8.88172984e-02f, -2.02720374e-01f, 3.53662781e-02f, 8.34820792e-02f, -4.54351865e-02f, 1.01959735e-01f, -1.53350085e-01f, -2.00028569e-01f,
  -1.85614616e-01f, 1.06407486e-01f, 5.92967123e-02f, -3.66990641e-03f, -9.80940182e-03f, 4.63700704e-02f, 1.38790593e-01f, -1.68060232e-02f, 7.35863894e-02f, -2.97980402e-02f,
  1.65887862e-01f, -8.27585161e-02f, 5.12113087e-02f, 8.79835617e-03f, 1.45039424e-01f, -7.73032829e-02f, 2.57555135e-02f, -8.46867636e-02f, 1.95828199e-01f, 1.51493028e-01f,
  -1.22002907e-01f, -1.24518601e-02f, -1.85466066e-01f, 1.71724841e-01f, -1.15244336e-01f, -1.33191809e-01f, -1.70681357e-01f, -6.52079359e-02f, 2.95833847e-03f, -1.27426460e-02f,
  1.26697928e-01f, 8.68297443e-02f, -1.12947367e-01f, 1.29656732e-01f, -7.26464167e-02f, 3.45698092e-03f, -9.51899812e-02f, 1.21809639e-01f, 1.12644248e-01f, -6.07595406e-02f,
  6.17193319e-02f, 2.60480568e-02f, 8.01117867e-02f, 6.55207485e-02f, 8.45587403e-02f, 3.17100845e-02f, -1.78041294e-01f, 2.26983190e-01f, 7.44820088e-02f, -1.81482494e-01f,
  1.40308499e-01f, -1.46286741e-01f, 6.28349856e-02f, 6.16847239e-02f, 5.84067181e-02f, 4.29340824e-03f, -1.10132679e-01f, 1.56784967e-01f, -1.68392777e-01f, -6.93905950e-02f,
  1.23724677e-01f, 7.83052444e-02f, 2.50386000e-02f, 1.24631733e-01f, 4.83543016e-02f, -6.63392171e-02f, -2.14148872e-02f, 5.13296798e-02f, -5.43456525e-03f, -3.91523205e-02f,
  1.09586962e-01f, -8.45108703e-02f, 6.99645728e-02f, -3.17554101e-02f, 4.48215790e-02f, 2.34758807e-03f, -6.93903416e-02f, 1.32921591e-01f, 1.18170455e-01f, 7.49537870e-02f,
  7.35877827e-02f, -8.03147480e-02f, 1.14477113e-01f, 2.39817724e-02f, -1.31695747e-01f, 1.60922576e-02f, 1.32110253e-01f, 5.02154641e-02f, -2.01243803e-01f, 3.85580771e-02f,
  3.26656438e-02f, 2.61081785e-01f, -4.56433706e-02f, 7.82373920e-02f, 6.08431958e-02f, -6.00778311e-02f, -6.83483481e-02f, -3.05566657e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.74900606e-01f, 2.41160858e-02f, 6.14419915e-02f, 8.89842287e-02f, 1.03542782e-01f, 1.76521868e-01f, 9.26363021e-02f, -2.14552116e-02f, 6.90064654e-02f, 3.68162356e-02f,
  1.71929568e-01f, 2.33330458e-01f, 1.71049815e-02f, -2.36088112e-02f, -1.57244667e-01f, 8.99782702e-02f, 2.85885185e-01f, 8.62266347e-02f, 2.27261499e-01f, -6.47667572e-02f,
  -9.08528715e-02f, 1.29901752e-01f, 2.07649842e-01f, -1.94609463e-02f, -2.57718414e-01f, -5.94936237e-02f, 4.51055765e-02f, 3.21595609e-01f, 5.45920245e-02f, -2.30955139e-01f,
  2.15618879e-01f, 1.87810317e-01f, -3.80635299e-02f, -1.62034854e-01f, 2.21408039e-01f, -4.56417352e-02f, 1.64045587e-01f, -1.40548660e-03f, -1.33104160e-01f, 5.02594821e-02f,
  4.29376177e-02f, 2.35349864e-01f, -3.22725065e-02f, 6.91546351e-02f, -1.35002509e-01f, 5.07265292e-02f, -2.21242616e-03f, 1.11817487e-01f, 1.91765979e-01f, -4.83478755e-02f,
  1.22401305e-01f, 1.84981465e-01f, 3.19707692e-01f, 4.37068269e-02f, -1.15358807e-01f, -3.85639518e-02f, 6.41974509e-02f, -1.85128808e-01f, -2.84711588e-02f, 1.46565353e-03f,
  -4.69174283e-03f, 8.62535015e-02f, -9.30681080e-03f, 2.81944841e-01f, 1.14972040e-01f, 1.17176488e-01f, 3.13407965e-02f, 2.83773113e-02f, 8.11611786e-02f, 1.05171211e-01f,
  1.61181927e-01f, 3.84022631e-02f, 1.74724102e-01f, 1.63533047e-01f, 4.26948145e-02f, 2.16229498e-01f, -1.39692187e-01f, 1.78686351e-01f, 2.13755861e-01f, -4.66386788e-02f,
  -8.52109268e-02f, 2.93413941e-02f, -2.12975174e-01f, -2.33057916e-01f, 2.02083997e-02f, -4.43027467e-02f, -3.15471798e-01f, -2.79094934e-01f, -1.18760660e-01f, 9.35368016e-02f,
  -1.58119082e-01f, -2.23544300e-01f, -1.43184528e-01f, -1.17717013e-01f, 3.76367755e-02f, -4.28609960e-02f, -4.04479839e-02f, 2.13229924e-01f, -2.60365605e-01f, 2.45311379e-01f,
  2.35607568e-02f, 1.30383641e-01f, 2.72925287e-01f, 3.06989223e-01f, 3.09206188e-01f, 8.94747749e-02f, -4.75845523e-02f, 5.57485521e-02f, 2.31494471e-01f, 5.67615144e-02f,
  8.17367956e-02f, -1.78543806e-01f, 3.55905630e-02f, 2.81834632e-01f, -1.52008414e-01f, -8.90465602e-02f, -1.35245591e-01f, 2.28682607e-02f, 2.51839042e-01f, 5.26483655e-02f,
  7.61306211e-02f, -1.13333520e-02f, -6.24443702e-02f, 9.41335484e-02f, 8.31317604e-02f, 2.58172989e-01f, -1.09222539e-01f, -1.25370556e-02f, -7.17891082e-02f, -1.07604489e-01f,
  -9.91796553e-02f, -1.84073210e-01f, -4.71783094e-02f, -1.21871792e-01f, -1.49714857e-01f, 4.81516533e-02f, -1.71355292e-01f, 1.52589098e-01f, 2.03855280e-02f, 1.23560838e-01f,
  -4.05091196e-02f, -2.92516220e-02f, -1.59570515e-01f, 1.81516241e-02f, 5.98348379e-02f, 2.45970219e-01f, 1.31208703e-01f, 1.63701791e-02f, -1.63995638e-01f, -4.07420248e-02f,
  2.83900052e-01f, 2.11153165e-01f, 1.86400950e-01f, 1.59541368e-01f, 3.88216339e-02f, 5.27683049e-02f, 1.42692521e-01f, 7.93163329e-02f, 7.83466324e-02f, -5.09142466e-02f,
  2.04112858e-01f, -6.98673949e-02f, 2.30969250e-01f, -8.31569135e-02f, -1.05268462e-02f, -1.11225331e-02f, -1.70177743e-01f, 4.26932685e-02f, 2.48749748e-01f, 2.16676280e-01f,
  1.53778717e-01f, 1.12208821e-01f, -1.36900498e-02f, 2.66081005e-01f, 5.11683850e-03f, 4.78362925e-02f, 6.61493242e-02f, 1.58237353e-01f, -4.02888469e-02f, -6.09703711e-04f,
  1.46728098e-01f, 9.64795351e-02f, 9.16979685e-02f, 1.20025296e-02f, -2.68599153e-01f, -1.08882546e-01f, 2.95615755e-02f, 1.71056762e-01f, -2.19435662e-01f, 1.30224138e-01f,
  2.32121795e-01f, 1.06728405e-01f, 1.06190778e-02f, 1.75180063e-01f, 1.85541421e-01f, 8.96966904e-02f, 1.30152225e-01f, -3.61041678e-03f, 9.86932740e-02f, 2.43651673e-01f,
  1.03669405e-01f, -4.05593328e-02f, 1.59907728e-01f, 3.75206731e-02f, 1.68652624e-01f, 1.17333360e-01f, -2.72287019e-02f, -9.99254361e-03f, 6.09350502e-02f, -1.44235566e-01f,
  1.84627458e-01f, 1.53916582e-01f, 1.71937913e-01f, 2.84798205e-01f, 1.23509184e-01f, -1.26020372e-01f, -1.98142260e-01f, -1.42213032e-01f, 2.91944951e-01f, 4.20366883e-01f,
  2.02651724e-01f, -2.05460727e-01f, -1.16560468e-02f, 3.10563505e-01f, 5.40059581e-02f, 4.81865481e-02f, 1.27091734e-02f, -9.09106135e-02f, 1.13702454e-01f, 1.15072593e-01f,
  1.55774355e-01f, -1.67163670e-01f, -1.51855692e-01f, 8.06426164e-03f, -1.02064840e-03f, -2.16255318e-02f, -2.54209101e-01f, -1.33864164e-01f, -2.33926810e-02f, 1.45532146e-01f,
  6.60412386e-02f, -1.11788079e-01f, 5.78509793e-02f, 2.49062344e-01f, 9.89211947e-02f, 7.85968602e-02f, 5.78567088e-02f, 8.96056518e-02f, -2.57193316e-02f, 1.62811518e-01f,
  -1.76596135e-01f, -7.32514784e-02f, 3.50043386e-01f, 1.65836185e-01f, -1.81238234e-01f, 6.65601864e-02f, 3.62962298e-02f, 1.16268501e-01f, -8.54424834e-02f, -2.60138392e-01f,
  -7.07213357e-02f, -2.04389587e-01f, 1.92821659e-02f, -3.32176127e-02f, 1.08990408e-01f, -5.21166697e-02f, -1.40401781e-01f, -3.36926617e-02f, 5.72710671e-02f, -2.05582693e-01f,
  1.72128126e-01f, 1.48287937e-01f, -2.07611859e-01f, 2.06474274e-01f, 1.31482795e-01f, -1.98618636e-01f, -2.42100343e-01f, -1.18960170e-02f, -1.53892159e-01f, -1.85419200e-03f,
  -7.89251365e-03f, 3.74564645e-03f, 4.45370153e-02f, -3.02684069e-01f, -8.75906572e-02f, -3.47482741e-01f, -1.26525417e-01f, 1.39186978e-01f, 1.64771438e-01f, 1.30911946e-01f,
  1.60741042e-02f, -5.56103559e-03f, -2.51994103e-01f, 1.16695706e-02f, -1.85395181e-01f, -1.38444930e-01f, 1.50681496e-01f, -8.17761756e-03f, 3.14627141e-02f, -1.53419957e-03f,
  4.69746552e-02f, -1.75575718e-01f, 3.78746130e-02f, 1.83968410e-01f, -1.82932615e-01f, 5.80481663e-02f, 2.40058914e-01f, 1.62549078e-01f, -1.01569034e-01f, -7.20919576e-03f,
  2.44774669e-01f, 9.73700508e-02f, -2.14403898e-01f, -3.06264013e-01f, 7.18135834e-02f, -2.02171907e-01f, -3.10699314e-01f, -3.06262523e-01f, 1.32530674e-01f, -5.59350848e-02f,
  -3.02234571e-03f, -4.89563756e-02f, 8.08881670e-02f, -6.33165762e-02f, 3.92400362e-02f, 1.77232921e-01f, 1.62983194e-01f, -8.24232101e-02f, 9.38047022e-02f, 2.02708021e-02f,
  1.46570569e-02f, 9.23788771e-02f, -9.16590914e-02f, 2.43540164e-02f, 2.32347995e-02f, -6.48423610e-03f, -3.91606838e-02f, -1.45234793e-01f, -2.03160182e-01f, -6.68823868e-02f,
  -2.41001666e-01f, -1.50799826e-01f, 1.46690071e-01f, 1.07046694e-01f, 2.91743279e-02f, 1.59712564e-02f, -1.16203934e-01f, -8.37824133e-04f, -9.39507782e-02f, 1.69574067e-01f,
  6.84852526e-02f, -3.62703502e-01f, -1.75156072e-01f, -4.82304879e-02f, 1.82804570e-01f, -1.04179673e-01f, 1.55577138e-01f, -1.74309269e-01f, -1.44511640e-01f, 3.28267127e-01f,
  -1.39469236e-01f, 2.39710346e-01f, 1.95964407e-02f, -1.47577897e-01f, 6.74923807e-02f, 3.27454954e-01f, -8.83121118e-02f, 7.15070963e-02f, 2.51647327e-02f, -5.43370144e-03f,
  1.93005279e-01f, -2.27179863e-02f, 1.04431808e-01f, 4.82592620e-02f, -6.02824613e-02f, -2.14102138e-02f, 3.18476140e-01f, -2.57013112e-01f, -3.77858430e-02f, 2.19191775e-01f,
  -1.28143117e-01f, 8.05820227e-02f, 2.59872496e-01f, 1.57864273e-01f, 6.46731183e-02f, 1.47373423e-01f, 1.10170744e-01f, 2.54268318e-01f, 5.18414564e-02f, 1.05469383e-01f,
  6.23594932e-02f, 1.92702144e-01f, 1.63091153e-01f, 1.09553419e-01f, 2.89290342e-02f, -5.31884562e-03f, -1.94605887e-01f, 2.41229117e-01f, 1.05650656e-01f, -3.04692276e-02f,
  -1.36796921e-01f, -1.98202189e-02f, -4.56491522e-02f, -1.58945657e-02f, 1.91286266e-01f, -3.67845260e-02f, -1.22612864e-01f, -1.60574004e-01f, 5.83679508e-03f, 1.32277429e-01f,
  -1.28335163e-01f, -8.66920725e-02f, 5.05198985e-02f, -2.16226682e-01f, 5.08376360e-02f, 7.60471895e-02f, 3.31384987e-02f, -2.08436958e-02f, -1.45177497e-02f, 4.98569123e-02f,
  1.64988369e-01f, 1.85527772e-01f, 1.72790796e-01f, 1.33714691e-01f, 1.93324685e-01f, -1.69284299e-01f, 1.21830069e-01f, 2.53967762e-01f, 2.48327032e-01f, 1.51397362e-01f,
  6.19098619e-02f, -1.17412999e-01f, 2.79925495e-01f, 2.56066382e-01f, -1.70014933e-01f, -1.62352607e-01f, -2.72720098e-01f, 2.43566528e-01f, 3.42324097e-03f, 1.47300567e-02f,
  -1.52014747e-01f, -5.75827248e-02f, 7.16954544e-02f, 6.41865581e-02f, 2.82585680e-01f, 2.44181171e-01f, -7.22320750e-02f, -2.64510382e-02f, 7.69337192e-02f, 3.57267894e-02f,
  1.55108853e-03f, -1.31724536e-01f, 1.25753254e-01f, -5.58799319e-02f, 1.03371270e-01f, 1.09145716e-01f, -9.50735807e-02f, 1.10107977e-02f, 6.90255985e-02f, 3.14140990e-02f,
  2.34551668e-01f, -2.82597065e-01f, 2.55947635e-02f, 2.42253706e-01f, -2.54512429e-02f, 3.04445297e-01f, 2.01911166e-01f, -1.46574423e-01f, 3.29089090e-02f, 2.02529043e-01f,
  -2.68632565e-02f, -5.54529764e-02f, 2.22177058e-01f, 1.21392205e-01f, 1.11092843e-01f, 6.70718728e-03f, 1.22673854e-01f, -2.77346671e-01f, 8.56656581e-02f, 5.43339662e-02f,
  2.26580918e-01f, 1.17320279e-02f, 7.07678720e-02f, 9.04663503e-02f, 9.40245539e-02f, 1.47353128e-01f, -2.45825917e-01f, -9.63272527e-02f, 1.29786447e-01f, 1.03397943e-01f,
  2.13456064e-01f, -3.90476957e-02f, -9.35229659e-02f, 4.03417535e-02f, -2.02504434e-02f, 1.25151947e-01f, -6.72517121e-02f, 4.50563245e-02f, 4.01812270e-02f, 6.44676387e-02f,
  6.05474180e-03f, 8.17671567e-02f, 2.54466504e-01f, 2.45502871e-02f, -2.13266179e-01f, -3.31305414e-02f, 8.12615380e-02f, 6.01099469e-02f, 2.29037162e-02f, 4.32663336e-02f,
  1.62259102e-01f, 1.47496060e-01f, -1.86110716e-02f, 3.52299064e-02f, -3.20806727e-02f, -1.53327376e-01f, 9.11257938e-02f, -5.18247485e-02f, 1.00519964e-02f, 1.42932206e-01f,
  -7.70741850e-02f, 1.28675371e-01f, 1.10758148e-01f, -4.60508503e-02f, -4.48991079e-03f, -2.01307908e-01f, 1.16331726e-01f, 1.99345082e-01f, -2.29490370e-01f, 2.75642723e-01f,
  -2.03310996e-01f, -1.61019593e-01f, -1.90983295e-01f, 4.38321494e-02f, -1.38980657e-01f, -1.94730476e-01f, 1.92048967e-01f, 5.91932125e-02f, -1.86008260e-01f, -2.93099254e-01f,
  -1.05789043e-01f, -1.35950312e-01f, -1.75037757e-01f, -1.84822008e-01f, 1.41735062e-01f, 1.36942849e-01f, -1.56366542e-01f, 6.46935925e-02f, -1.09787278e-01f, 2.12524682e-02f,
  -6.00386113e-02f, -4.51917388e-03f, 1.74515665e-01f, 7.45007619e-02f, 2.02136174e-01f, 1.44887264e-04f, 9.84111875e-02f, 8.68055820e-02f, 1.22412205e-01f, -1.91190720e-01f,
  -4.99020368e-02f, 1.97910205e-01f, -1.13709509e-01f, -5.77357076e-02f, -2.38662645e-01f, 1.71143338e-01f, 1.58898875e-01f, 7.76425079e-02f, -2.26281852e-01f, -1.71709042e-02f,
  1.33089721e-01f, 1.45030066e-01f, -7.28222495e-03f, -1.02157891e-03f, 1.01478666e-01f, 6.23731166e-02f, 1.48861527e-01f, 7.85550624e-02f, 1.14449203e-01f, -6.31729588e-02f,
  -2.89404765e-02f, 1.79984957e-01f, 1.68346167e-01f, 1.62697658e-01f, -4.27462235e-02f, 8.85855556e-02f, -3.49909402e-02f, 9.07840207e-03f, 8.14816505e-02f, -1.88571811e-01f,
  2.64095217e-01f, 1.56014681e-01f, -9.29689854e-02f, -7.24386200e-02f, -1.20484501e-01f, -1.05610535e-01f, -2.27629960e-01f, 6.78111985e-02f, -1.57244787e-01f, -1.03154466e-01f,
  6.87336177e-02f, 7.47007355e-02f, -8.35063308e-02f, -9.65110585e-02f, 1.62418067e-01f, 1.06583377e-02f, 2.55929958e-02f, 3.92870605e-02f, 1.72203481e-01f, 1.46247059e-01f,
  3.84555943e-03f, 6.96040988e-02f, -2.13080458e-02f, 2.40741670e-01f, -2.38637254e-01f, 2.18943190e-02f, -1.13233119e-01f, 1.12514213e-01f, 7.62163103e-02f, -2.21880674e-01f,
  1.26347646e-01f, -1.73143953e-01f, -1.50998488e-01f, 8.76899660e-02f, -1.46178752e-01f, 7.13840574e-02f, 2.65640348e-01f, 1.53662011e-01f, -1.65853932e-01f, -3.83513495e-02f,
  4.77445908e-02f, 6.02996238e-02f, 1.73863724e-01f, -2.15710551e-01f, -1.32031351e-01f, -3.58146690e-02f, -7.00972136e-03f, -9.51058418e-02f, -2.75007766e-02f, -1.90143958e-01f,
  -3.84221375e-02f, 2.06739232e-01f, 1.64636105e-01f, 2.50133693e-01f, 1.66878834e-01f, 4.90591377e-02f, 1.10059828e-01f, 5.39362058e-02f, 2.48823445e-02f, 4.77470383e-02f,
  1.53339788e-01f, 1.74406275e-01f, -5.72486967e-02f, 2.23689079e-01f, 6.54226691e-02f, -1.35704696e-01f, 4.10363749e-02f, 9.17494893e-02f, 1.88596219e-01f, -1.49748743e-01f,
  2.83795685e-01f, -8.87429491e-02f, -4.82783243e-02f, -1.12795934e-01f, -3.88711542e-01f, -1.35666057e-02f, 7.59662269e-03f, 1.75885379e-01f, 8.37188736e-02f, -7.03105778e-02f,
  1.39729783e-01f, 2.16052219e-01f, -2.17823654e-01f, 1.59422502e-01f, -3.05642765e-02f, 2.15495139e-01f, 1.08862221e-01f, 1.20608270e-01f, 1.85560912e-01f, 1.99250400e-01f,
  1.23454988e-01f, 1.05369054e-01f, -1.33037820e-01f, 2.77876079e-01f, 5.31052332e-03f, -3.27521525e-02f, 1.80849686e-01f, -9.00832713e-02f, 2.51778036e-01f, 5.17778285e-02f,
  -1.29604295e-01f, -3.13469470e-02f, 3.56566347e-02f, -3.17755118e-02f, -1.34910434e-01f, 7.14643672e-02f, -1.84806529e-02f, 1.55884340e-01f, 2.61850148e-01f, -8.22036352e-04f,
  1.84979171e-01f, 1.10314235e-01f, -6.11379854e-02f, 1.82205543e-01f, 1.79225728e-01f, 9.37936455e-02f, -5.23610823e-02f, -2.99674831e-02f, 1.85066499e-02f, 1.94881242e-02f,
  1.10375717e-01f, -1.07867075e-02f, 1.34306386e-01f, -4.33309115e-02f, 1.37099653e-01f, 4.86027859e-02f, 3.18022460e-01f, -8.18583146e-02f, 7.58457705e-02f, 2.04172030e-01f,
  1.61325634e-01f, -4.76478934e-02f, 1.37416318e-01f, -1.41189173e-01f, -1.31735399e-01f, -1.55865878e-01f, -1.76721171e-01f, -4.70219925e-02f, -1.90642551e-01f, 6.14700057e-02f,
  6.77745715e-02f, -2.52734721e-01f, 6.55817911e-02f, 1.33495167e-01f, 1.09747089e-01f, -1.33782085e-02f, 1.58133470e-02f, 2.08637998e-01f, 4.57733087e-02f, 2.27224991e-01f,
  -2.26755440e-01f, 1.25491038e-01f, -1.91958487e-01f, 5.96005144e-03f, -1.80878285e-02f, 1.53184354e-01f, 5.46401106e-02f, -7.18833134e-02f, 1.22500077e-01f, -7.10426196e-02f,
  8.24933276e-02f, 7.25958720e-02f, -3.01945806e-01f, -6.14243634e-02f, 1.96570724e-01f, 9.84887481e-02f, -1.31927848e-01f, -1.28181964e-01f, 2.75680155e-01f, 1.34506688e-01f,
  1.06896080e-01f, -1.94010139e-01f, 1.51638180e-01f, -7.77106583e-02f, -1.27729475e-01f, -7.93844312e-02f, 1.13138584e-02f, -1.25896230e-01f, 1.75212771e-01f, 1.05892897e-01f,
  -1.17077236e-03f, -6.69536414e-03f, 1.83658823e-01f, -6.98138922e-02f, -4.04647663e-02f, 1.65004805e-01f, 1.05564147e-01f, 1.87431335e-01f, 1.40086517e-01f, 1.45617962e-01f,
  2.67481267e-01f, -2.78915882e-01f, 8.26836377e-02f, 2.48689339e-01f, 1.44408643e-01f, 2.83447593e-01f, 2.71014959e-01f, -1.55752748e-01f, -8.16562548e-02f, 2.03203544e-01f,
  -5.66729568e-02f, -8.39909315e-02f, -1.04821749e-01f, -3.43897492e-02f, 7.29595944e-02f, 2.01772004e-01f, 3.07064772e-01f, -2.77189016e-01f, 8.48696902e-02f, 2.72210449e-01f,
  -3.18890251e-03f, 1.88371688e-01f, 7.37930015e-02f, 1.09373461e-02f, 8.43325034e-02f, 9.95442048e-02f, -2.29063258e-01f, -7.85676241e-02f, 4.19327803e-02f, 1.50049061e-01f,
  1.25300229e-01f, 7.17062876e-02f, 3.63167338e-02f, -2.26221830e-01f, 5.23933060e-02f, 2.02940792e-01f, 1.12350630e-02f, -7.86870718e-02f, 1.54785171e-01f, 3.58753532e-01f,
  -2.02433346e-03f, -1.13757819e-01f, 2.83185631e-01f, 3.72645352e-03f, -1.85639143e-01f, -1.90388799e-01f, 4.48286422e-02f, -1.90425664e-01f, -4.13815826e-02f, -1.48157477e-01f,
  6.00432716e-02f, 1.39669299e-01f, -7.23174959e-02f, -4.98975068e-03f, 3.43197286e-02f, -2.67841995e-01f, -1.92328654e-02f, -2.25746691e-01f, -8.43891948e-02f, -1.00049019e-01f,
  -4.08684649e-02f, 2.56257076e-02f, -9.65039283e-02f, -3.31180505e-02f, 1.30936980e-01f, -1.63983017e-01f, -2.85740313e-03f, 8.06834400e-02f, -4.98915464e-03f, 1.59352079e-01f,
  1.06918662e-04f, -2.65027639e-02f, -3.51574272e-02f, 8.37265328e-02f, -8.12401175e-02f, 8.46912116e-02f, 1.85587421e-01f, 2.49908462e-01f, -1.41184241e-01f, -1.72783867e-01f,
  9.80058089e-02f, -1.56656038e-02f, -7.52393007e-02f, -2.90012192e-02f, 1.53794229e-01f, 1.52911663e-01f, 1.73408642e-01f, 1.00876711e-01f, 3.45586948e-02f, 1.02541437e-02f,
  8.73359814e-02f, -1.86592266e-01f, 1.98946506e-01f, -3.93923409e-02f, 2.18043908e-01f, 9.90955159e-02f, 1.66117966e-01f, 1.25073979e-03f, -1.21406734e-01f, 7.69664859e-03f,
  -2.17023510e-02f, 9.59035158e-02f, 4.51609604e-02f, 1.41637281e-01f, 1.12597682e-01f, -3.68774645e-02f, 2.24351987e-01f, -2.16364730e-02f, -3.08485359e-01f, -1.67630181e-01f,
  1.73831701e-01f, -1.01723790e-01f, -3.65758985e-02f, -2.76762638e-02f, 3.02069843e-01f, -1.28494814e-01f, -9.40925069e-03f, 1.69323996e-01f, -9.37717035e-03f, 5.54555431e-02f,
  7.23023862e-02f, 1.68022290e-01f, -3.59176770e-02f, 3.23230959e-02f, 1.34630188e-01f, 3.07243951e-02f, 6.87964633e-02f, 1.80872697e-02f, 2.36733913e-01f, 5.67925796e-02f,
  -4.73763980e-02f, 1.90394148e-01f, 2.28325859e-01f, 1.72789827e-01f, 3.81779224e-01f, -1.30745023e-01f, 1.25656888e-01f, 3.32464576e-02f, -2.52479725e-02f, 1.33569345e-01f,
  -2.73651510e-01f, -6.96197301e-02f, 2.71933734e-01f, 1.11470439e-01f, 2.64777929e-01f, 6.01594858e-02f, 2.21295312e-01f, 2.59197354e-01f, -2.46545374e-01f, 2.20826581e-01f,
  1.11057326e-01f, 6.21895455e-02f, 7.18089640e-02f, 1.52963325e-01f, -5.57120480e-02f, 1.72022715e-01f, 1.48461282e-01f, 1.28651068e-01f, -3.18514071e-02f, 2.13288948e-01f,
  2.00757638e-01f, -1.59499776e-02f, 2.78967768e-01f, 5.90628805e-03f, -5.99316843e-02f, -3.04342359e-02f, -1.89946778e-02f, 3.35741401e-01f, 1.73670873e-01f, -1.51467696e-01f,
  1.53079033e-01f, 1.02402411e-01f, 3.42049114e-02f, 5.59469387e-02f, 8.79850984e-02f, 3.64602394e-02f, -1.78657770e-01f, -7.70517886e-02f, 2.22224626e-03f, 1.62883893e-01f,
  5.21872714e-02f, -1.70202355e-03f, -4.65658195e-02f, 9.08853635e-02f, 7.61987418e-02f, -2.55388878e-02f, 1.00551493e-01f, 2.34985426e-01f, 2.17824563e-01f, -1.24405837e-02f,
  2.05734253e-01f, 4.33101915e-02f, -2.39203256e-02f, -1.48674414e-01f, 1.50684610e-01f, 1.89168483e-01f, -4.41573560e-02f, 2.66768932e-01f, -8.26526135e-02f, -1.92335322e-01f,
  -1.62604466e-01f, 1.91429272e-01f, -7.97055662e-02f, -1.14215404e-01f, 7.48025104e-02f, 2.84095734e-01f, -1.22253545e-01f, -1.63697898e-01f, 1.79396674e-01f, -8.68250206e-02f,
  6.22652955e-02f, 7.75147378e-02f, 2.98612982e-01f, 2.29365498e-01f, 1.05793804e-01f, 2.67148465e-01f, -5.43355122e-02f, 2.64276594e-01f, 2.06194207e-01f, 2.33901646e-02f,
  8.95097330e-02f, -7.45125394e-03f, 1.17018014e-01f, 1.29763350e-01f, 1.21752508e-01f, 3.81627902e-02f, -4.62698415e-02f, 1.52548075e-01f, 3.75914536e-02f, 2.72897154e-01f,
  6.10968806e-02f, 1.53768972e-01f, -8.21991041e-02f, 2.61086319e-02f, 2.11339816e-01f, 1.01439416e-01f, -1.91990301e-01f, -2.20082924e-01f, 9.23837423e-02f, -4.95241843e-02f,
  9.59702432e-02f, 1.62589520e-01f, 6.00955300e-02f, 4.52581886e-03f, 1.73398722e-02f, 1.75913423e-01f, 1.33323982e-01f, 3.53887416e-02f, 1.01723425e-01f, 2.59168260e-03f,
  -5.14128357e-02f, -7.23524168e-02f, 1.91979967e-02f, 3.53892520e-02f, 7.69147351e-02f, 1.90459304e-02f, -4.94931899e-02f, -1.43831909e-01f, -2.09433943e-01f, -2.08067656e-01f,
  -2.71460228e-02f, -2.05567420e-01f, -2.04494402e-01f, -8.16390738e-02f, -2.42382497e-01f, -1.69604883e-01f, 1.75099373e-01f, -4.62571494e-02f, -3.14501256e-01f, 3.67741883e-02f,
  -7.89429247e-02f, 6.87243491e-02f, -1.28943264e-01f, -1.63943425e-01f, 1.94037799e-02f, -9.82456505e-02f, -1.90308288e-01f, -3.67657959e-01f, 1.91666499e-01f, -6.15668483e-02f,
  2.52408236e-01f, -1.42462179e-01f, -1.37916207e-01f, 2.41425321e-01f, -3.89798619e-02f, 7.66945034e-02f, -1.90703481e-01f, -1.03279382e-01f, -2.58078687e-02f, 2.63500005e-01f,
  -1.27793983e-01f, 4.94236164e-02f, 2.36873955e-01f, -5.12266755e-02f, 8.31252411e-02f, -2.26352602e-01f, 2.15035439e-01f, 1.07766591e-01f, -2.25370675e-01f, -3.33530754e-01f,
  3.16826880e-01f, -3.74905556e-01f, 2.48735957e-02f, 1.43727645e-01f, -4.01735045e-02f, 8.77421498e-02f, -5.21046333e-02f, 2.50949681e-01f, 1.41785145e-01f, 1.00494280e-01f,
  -4.31213640e-02f, 1.50034174e-01f, 6.39625564e-02f, 1.03978686e-01f, 8.14697593e-02f, -8.73445347e-02f, 3.10973618e-02f, -1.69353746e-02f, 1.48831040e-01f, -1.81298722e-02f,
  4.05802876e-02f, 1.34090587e-01f, -2.12605029e-01f, -1.85701951e-01f, 1.50197476e-01f, 2.24118736e-02f, 1.21996226e-02f, 8.01081508e-02f, -4.32705358e-02f, -2.36013770e-01f,
  5.41044138e-02f, 1.98589653e-01f, -1.28585130e-01f, -6.06404059e-02f, 1.54084742e-01f, 1.19411983e-01f, -1.58840511e-02f, 2.12416187e-01f, 2.40982696e-01f, -4.66167144e-02f,
  -1.03220209e-01f, 1.10300727e-01f, -7.12286755e-02f, 1.72453150e-01f, -4.23667058e-02f, -1.48882583e-01f, -1.69514641e-01f, 1.46007523e-01f, 7.35330880e-02f, 2.40838870e-01f,
  1.07335839e-02f, 1.98252290e-01f, 1.26420241e-02f, 2.40986068e-02f, 1.93299234e-01f, -2.44625695e-02f, -5.29182330e-02f, -1.34203032e-01f, -5.76388016e-02f, -4.93990667e-02f,
  2.59319067e-01f, -7.21997954e-03f, -1.16792910e-01f, 4.08716835e-02f, -1.17630139e-01f, 1.64126635e-01f, 2.28690162e-01f, 2.59994090e-01f, -3.24079007e-01f, 6.66620806e-02f,
  1.42251492e-01f, 1.28024668e-01f, 5.67636415e-02f, 1.52112469e-01f, 1.43761588e-02f, -8.73399898e-02f, -3.93108353e-02f, -2.84974463e-02f, -4.22016904e-02f, 2.28383075e-02f,
  1.41649082e-01f, 8.12271982e-02f, 9.22448784e-02f, -2.15686373e-02f, -1.34274468e-01f, 1.59246221e-01f, 7.31430948e-02f, 1.25002041e-01f, 1.67550579e-01f, 7.12287128e-02f,
  3.85637343e-01f, -2.35861484e-02f, 2.86788553e-01f, -1.82197854e-01f, -7.27362260e-02f, 1.71721548e-01f, -2.14055762e-01f, -1.04904488e-01f, 2.60211408e-01f, 1.17463417e-01f,
  -2.92203072e-02f, -2.59319339e-02f, 1.58593670e-01f, 6.70939162e-02f, -2.43267715e-01f, 1.16141863e-01f, -1.75209731e-01f, 1.93560898e-01f, -1.84434369e-01f, -3.24570760e-03f,
  1.21437557e-01f, -2.28293315e-02f, 3.50356162e-01f, 1.76976487e-01f, -2.45149434e-02f, 1.71008050e-01f, 1.21874645e-01f, -7.89159238e-02f, 2.23546490e-01f, -4.78087721e-04f,
  1.78583726e-01f, -1.16781697e-01f, -4.16712090e-02f, 2.18276680e-01f, 2.38837060e-02f, -4.27546017e-02f, 1.62223801e-02f, 2.19538495e-01f, -3.43461335e-01f, 2.45738804e-01f,
  2.66881615e-01f, -2.00723767e-01f, -1.66056845e-02f, 6.00190125e-02f, -3.52517404e-02f, 7.87883028e-02f, 1.48041621e-01f, 1.81682855e-01f, 1.80565647e-03f, -4.18025367e-02f,
  7.84267411e-02f, -3.98077667e-02f, 1.11374535e-01f, 5.44628408e-03f, -3.91940959e-03f, 1.38413519e-01f, 1.62762910e-01f, 7.68470094e-02f, 2.63635695e-01f, -3.64779271e-02f,
  1.98323444e-01f, 1.02676943e-01f, 3.10139637e-02f, -5.87415276e-03f, 1.07398994e-01f, -4.42460440e-02f, 1.21139847e-02f, 9.40109789e-02f, -1.60283804e-01f, -1.56928957e-01f,
  -1.64891630e-01f, 3.27627212e-02f, 1.28232867e-01f, -3.66175361e-02f, 3.71531434e-02f, -1.66912585e-01f, 9.93252546e-02f, 2.59813759e-02f, 7.34980479e-02f, 8.27962607e-02f,
  -5.95209226e-02f, 2.47248247e-01f, -2.11110171e-02f, 2.52503335e-01f, -2.48575360e-02f, -1.45727792e-03f, 6.87210038e-02f, 1.26659349e-01f, 1.46835357e-01f, 3.11555061e-02f,
  2.06377015e-01f, -2.81399190e-01f, -4.83470522e-02f, 4.32894118e-02f, -2.98505258e-02f, -8.04018825e-02f, 7.58656487e-02f, 1.72296599e-01f, -1.10781007e-01f, -7.93412421e-03f,
  4.63815555e-02f, 2.27683216e-01f, -2.41376199e-02f, -2.26418599e-01f, 5.55419363e-02f, -1.76772758e-01f, -1.78363577e-01f, -1.17287815e-01f, -5.84824197e-02f, -1.05365314e-01f,
  1.07305720e-01f, 2.70450935e-02f, 2.16713160e-01f, 8.56618360e-02f, 1.49431154e-01f, 7.96000883e-02f, 3.11985686e-02f, 1.42567381e-01f, -1.75219011e-02f, 9.69301090e-02f,
  7.50645623e-02f, 1.39136285e-01f, 1.56120984e-02f, -3.32577452e-02f, -8.61708373e-02f, 1.27494782e-01f, 1.58351362e-01f, -7.28712156e-02f, -2.30329514e-01f, -2.55754948e-01f,
  -1.38964951e-01f, 2.49437112e-02f, 1.31237313e-01f, -2.23180085e-01f, 1.27026990e-01f, 1.45175248e-01f, -1.31146684e-01f, 4.32900824e-02f, 2.25397617e-01f, 7.38731474e-02f,
  1.97250336e-01f, 6.59714267e-02f, 7.41387531e-02f, -8.32039192e-02f, 2.71390110e-01f, 8.97412561e-03f, 2.57266432e-01f, 1.18487803e-02f, -1.60168245e-01f, 1.86446786e-01f,
  -1.57805085e-01f, 4.45438698e-02f, 1.28348202e-01f, -1.66103214e-01f, -1.61842719e-01f, 3.30046892e-01f, 6.51382729e-02f, 1.67456433e-01f, 1.82356134e-01f, 1.75780699e-01f,
  1.10003553e-01f, 1.70716252e-02f, 1.81698769e-01f, 2.09740251e-01f, 1.27061096e-03f, -1.21608332e-01f, 1.61889315e-01f, -2.36321285e-01f, -4.75691929e-02f, 2.81800836e-01f,
  -6.01609759e-02f, 2.26631239e-01f, 2.19151050e-01f, 2.08430156e-01f, 1.83970422e-01f, 1.67154726e-02f, -1.44755125e-01f, -1.59427762e-01f, -1.10255562e-01f, -7.87443575e-03f,
  1.46959841e-01f, 9.46349204e-02f, 8.24641287e-02f, 5.31510301e-02f, -8.16355199e-02f, -1.04640655e-01f, 1.63797900e-01f, -5.24385311e-02f, 1.67046353e-01f, 5.72970062e-02f,
  -4.16964525e-03f, 2.21582018e-02f, -7.93894082e-02f, 3.17501053e-02f, -8.66476446e-02f, 6.93974793e-02f, -2.87209988e-01f, 1.08431548e-01f, 2.21463665e-02f, 2.62491018e-01f,
  -1.26813129e-01f, -1.68308109e-01f, 1.55683547e-01f, 9.19212103e-02f, -1.94929726e-02f, -2.50420749e-01f, 1.85444966e-01f, 1.81476101e-01f, 3.92336659e-02f, 1.19036175e-01f,
  -2.21903980e-01f, 7.71644041e-02f, -1.89197809e-01f, 5.27291261e-02f, 1.34521410e-01f, 1.49888843e-01f, 2.59617358e-01f, 4.40454483e-02f, 3.50260586e-01f, 8.15023929e-02f,
  -3.08274161e-02f, -2.71308664e-02f, -2.79166758e-01f, -8.56456161e-03f, 1.65918514e-01f, 7.51414523e-02f, -1.31465495e-01f, -1.09708577e-01f, 2.58342713e-01f, 1.43554091e-01f,
  -6.20298758e-02f, -4.45420947e-03f, 6.24384312e-03f, 1.41323075e-01f, -2.15573341e-01f, -9.54297855e-02f, 1.85476750e-01f, -2.46339694e-01f, 1.44104779e-01f, 2.15031896e-02f,
  1.16491035e-01f, 4.65439297e-02f, 1.11557983e-01f, 1.72854751e-01f, 1.17303595e-01f, 1.41019393e-02f, 1.66299731e-01f, 1.10312305e-01f, 7.95832183e-03f, 4.12085950e-02f,
  1.86258122e-01f, -1.39468938e-01f, -3.17695774e-02f, 9.62083638e-02f, 2.25677073e-01f, 2.45061312e-02f, -1.84128389e-01f, -1.22797862e-02f, -1.72945678e-01f, 2.30106130e-01f,
  1.44949898e-01f, -1.00485273e-01f, 1.37604550e-01f, 7.10038617e-02f, 1.91123579e-02f, 6.35383502e-02f, 3.29498313e-02f, 1.48937538e-01f, 1.84084177e-01f, 3.73520446e-03f,
  -2.62877475e-02f, -1.29393265e-01f, 1.71879664e-01f, 4.80162911e-02f, 1.76661387e-01f, 2.03178644e-01f, -1.95139781e-01f, 1.65431067e-01f, -2.91049629e-01f, 7.73757100e-02f,
  2.01094851e-01f, -1.59029782e-01f, -3.46657187e-02f, 9.86048505e-02f, -1.08128496e-01f, 2.52422720e-01f, -2.30698343e-02f, 2.87316963e-02f, 1.33905530e-01f, 1.20205536e-01f,
  1.70070037e-01f, -4.29793224e-02f, 1.64499268e-01f, -1.15423575e-01f, 6.57393783e-03f, -3.72001231e-02f, -1.26708612e-01f, 1.52266736e-03f, 5.46138287e-02f, 1.80573687e-02f,
  1.70530245e-01f, 8.77274349e-02f, -2.47344486e-02f, 5.07443808e-02f, -2.68419571e-02f, 1.97420865e-01f, -4.94247652e-04f, 1.43190101e-01f, 2.36760885e-01f, 1.77848831e-01f,
  3.52746025e-02f, 7.22908825e-02f, 1.65613040e-01f, -5.38964830e-02f, -7.62139335e-02f, -7.85925984e-03f, 2.54931003e-01f, -3.10377795e-02f, -1.28007129e-01f, -6.55017374e-03f,
  -3.74601394e-01f, 4.71671820e-02f, -1.56981647e-02f, 3.05393904e-01f, 6.95315897e-02f, -2.61086792e-01f, 1.25936851e-01f, 2.86663175e-01f, -1.06333181e-01f, 1.32022023e-01f,
  1.11388385e-01f, -6.50051758e-02f, 3.83342467e-02f, -6.52681440e-02f, 3.36083055e-01f, 4.12081042e-03f, -9.53181833e-02f, -1.25956265e-02f, 1.98339269e-01f, 2.56192297e-01f,
  9.00413096e-02f, -8.72650221e-02f, 4.81482921e-03f, -2.71797121e-01f, 1.70867488e-01f, -1.46269009e-01f, 1.00907728e-01f, 1.06052659e-01f, 6.78194091e-02f, 9.34751704e-02f,
  2.56969482e-01f, 1.76011994e-01f, -6.83452785e-02f, -5.85224330e-02f, -1.44221857e-01f, 2.89371252e-01f, 1.40035138e-01f, -2.01339647e-01f, 1.56669199e-01f, -1.50336280e-01f,
  -1.19116887e-01f, 9.90360081e-02f, 2.97437519e-01f, 8.03902820e-02f, 1.32547274e-01f, -1.18539564e-01f, 3.32994852e-03f, 2.08451636e-02f, 1.86472181e-02f, -3.40253450e-02f,
  1.72369834e-02f, 1.88388363e-01f, 2.02082723e-01f, -2.75445520e-03f, 1.65629581e-01f, 8.46366361e-02f, 6.42685965e-02f, 1.11955717e-01f, -4.74992506e-02f, -1.81942150e-01f,
  1.11171246e-01f, 2.38359198e-01f, -9.17190388e-02f, 1.53794378e-01f, -2.13911548e-01f, -4.18010205e-02f, -1.44083872e-01f, 2.64085859e-01f, -1.36097446e-01f, -2.57381111e-01f,
  6.97854310e-02f, 1.35199979e-01f, -5.59602492e-02f, 4.71902601e-02f, 1.87261239e-01f, -1.93827465e-01f, 3.98582257e-02f, 1.37656540e-01f, 2.22796440e-01f, 1.44406989e-01f,
  -2.05402970e-02f, 1.17908880e-01f, -2.86579225e-02f, 2.02979654e-01f, -8.33519474e-02f, -7.70340264e-02f, -1.83646511e-02f, -1.03609040e-01f, 8.69866237e-02f, -1.31510511e-01f,
  4.78903577e-02f, -6.17852807e-02f, 3.40692420e-03f, 1.56234488e-01f, 1.70845479e-01f, 1.66867957e-01f, 1.03961185e-01f, 5.65926312e-04f, -1.86253816e-01f, 1.14969954e-01f,
  2.40632117e-01f, 7.64821544e-02f, -9.95360874e-03f, -8.74330923e-02f, -1.28027335e-01f, 1.14162371e-01f, 1.01030529e-01f, -9.58786756e-02f, 9.26524326e-02f, -1.75077796e-01f,
  1.39700649e-02f, 7.33954236e-02f, 1.76668778e-01f, 5.97711653e-02f, 1.63413197e-01f, 1.78577341e-02f, 4.13544700e-02f, 7.75189549e-02f, -2.75769420e-02f, 5.91509640e-02f,
  1.61656484e-01f, -3.89800668e-02f, -1.72955632e-01f, 2.07919464e-01f, 5.79693541e-02f, -2.04208165e-01f, 1.72347412e-01f, -5.48527278e-02f, 2.31434833e-02f, -2.92865559e-04f,
  1.96648806e-01f, -1.99607983e-01f, -1.37915462e-01f, -9.68810171e-02f, -3.40944052e-01f, -2.70270929e-02f, 1.81665853e-01f, -1.41864032e-01f, -1.24455668e-01f, 2.77055025e-01f,
  2.21896127e-01f, 4.27641033e-04f, -2.87531555e-01f, 3.01079005e-02f, -6.13595769e-02f, 7.87794515e-02f, 1.00632742e-01f, 1.29450917e-01f, 2.49816611e-01f, 2.84275115e-01f,
  -7.06233904e-02f, -3.80770266e-02f, -1.51945874e-01f, 2.60512888e-01f, 2.00912282e-01f, -1.46778435e-01f, 9.27703753e-02f, -2.80797835e-02f, 9.57541466e-02f, 9.17542055e-02f,
  -1.73908383e-01f, 8.97434205e-02f, -3.60958092e-02f, 4.97919731e-02f, 5.05730733e-02f, 7.84092173e-02f, 2.62534887e-01f, 5.09801582e-02f, 1.61987796e-01f, 1.02893591e-01f,
  1.22466356e-01f, 1.56589150e-01f, -9.27051902e-02f, 6.57513887e-02f, 1.49725929e-01f, 8.52018520e-02f, 4.37938757e-02f, 2.51270980e-01f, 4.87114675e-02f, 1.33995533e-01f,
  8.39599743e-02f, 1.65866703e-01f, 1.95665732e-01f, 4.86304685e-02f, 7.13054370e-03f, 2.07562204e-02f, 1.11700051e-01f, 1.94488600e-01f, -2.32327789e-01f, 3.62057611e-02f,
  1.52636603e-01f, 2.89578605e-02f, 9.88475457e-02f, -1.27174839e-01f, 1.21089913e-01f, -6.14142865e-02f, -5.63065633e-02f, -7.68022388e-02f, -3.09778303e-01f, -1.80022091e-01f,
  2.75891006e-01f, 2.42293313e-01f, 1.43646851e-01f, 1.54882697e-02f, 2.29444131e-01f, 1.20941564e-01f, -1.35695994e-01f, 7.38138258e-02f, 3.65580507e-02f, 9.79731083e-02f,
  1.21606141e-01f, 1.07956976e-01f, 7.37731606e-02f, 1.08513467e-01f, 3.99705060e-02f, 7.61173815e-02f, -5.48194302e-03f, 2.24678144e-01f, 7.11586848e-02f, -1.81415647e-01f,
  2.76605636e-01f, 4.53405594e-03f, 2.19315588e-01f, -1.00917019e-01f, 1.20912999e-01f, 1.24750242e-01f, 1.07286148e-01f, 7.74147063e-02f, -3.33622284e-02f, 1.62786786e-02f,
  1.28185362e-01f, 2.06971526e-01f, 1.46304537e-02f, -5.69292679e-02f, 3.18377949e-02f, 1.40841693e-01f, -1.96919844e-01f, 2.54751861e-01f, 1.37975261e-01f, 5.52773103e-02f,
  1.00251481e-01f, 1.01819247e-01f, 3.82869132e-02f, 5.54431900e-02f, 1.81848928e-02f, -1.64891817e-02f, -9.25483461e-03f, 1.00101717e-01f, -5.94688430e-02f, 1.09083779e-01f,
  1.90373838e-01f, -3.35583761e-02f, -1.04503691e-01f, -5.47906309e-02f, 2.34482676e-01f, -1.27823576e-01f, 7.76807889e-02f, -4.37353402e-02f, -8.09198543e-02f, 5.03252149e-02f,
  1.26534387e-01f, 1.75467998e-01f, -3.33929434e-02f, 1.68150980e-02f, 2.92706370e-01f, 3.02139595e-02f, 5.12020886e-02f, 2.64575094e-01f, 2.66569108e-01f, 2.74372399e-02f,
  -1.13609158e-01f, 1.24186680e-01f, 2.91881025e-01f, 4.63801920e-02f, 1.29759625e-01f, 5.12140151e-03f, -2.45731115e-01f, 2.97045290e-01f, -1.38336226e-01f, 2.74658412e-01f,
  -4.71208580e-02f, 1.95822567e-01f, -5.08044399e-02f, -1.62828192e-02f, 1.39026403e-01f, 2.09308803e-01f, -1.57334313e-01f, -7.11708050e-03f, 1.97884113e-01f, 2.09096253e-01f,
  2.26570532e-01f, -6.72185048e-02f, 8.09162855e-02f, 1.81388095e-01f, 1.08849064e-01f, 2.85503447e-01f, 1.13870323e-01f, 2.29899570e-01f, -2.56367117e-01f, -7.90853277e-02f,
  3.77331413e-02f, 1.41056165e-01f, 1.05048560e-01f, -8.67938176e-02f, -7.16764331e-02f, 1.17249647e-02f, 1.70293618e-02f, -8.41166005e-02f, 1.41210347e-01f, 4.79173362e-02f,
  -7.86740258e-02f, 3.32333967e-02f, -1.53275784e-02f, 1.70454890e-01f, 1.85650855e-01f, -2.52996117e-01f, 2.73799542e-02f, 2.00946301e-01f, 2.28716824e-02f, 2.35124871e-01f,
  -5.78254135e-03f, 8.72431174e-02f, -1.24365948e-01f, 1.33515656e-01f, -9.65413302e-02f, 4.29355577e-02f, 2.20219836e-01f, 2.05260575e-01f, 1.44332394e-01f, 8.90592858e-02f,
  2.59440392e-02f, -2.77277287e-02f, 6.20144941e-02f, 1.42251858e-02f, 1.71111867e-01f, 1.22665174e-01f, 4.35291827e-02f, 1.10377438e-01f, 1.12966903e-01f, 1.98120177e-01f,
  -2.10639775e-01f, -2.49770790e-01f, 4.50560898e-02f, 1.46585077e-01f, 2.57458568e-01f, -1.39046282e-01f, -1.59436092e-01f, 8.30065534e-02f, 1.43009603e-01f, 2.96688993e-02f,
  -1.23472027e-01f, 2.75021400e-02f, 1.16581820e-01f, 1.80529162e-01f, 7.66297355e-02f, 8.74875113e-03f, 2.48140350e-01f, 2.32854187e-02f, -2.91012138e-01f, 1.27884671e-01f,
  8.89777765e-03f, -6.31623641e-02f, -8.50427523e-02f, 3.61643210e-02f, 1.33284241e-01f, 2.65908930e-02f, 2.14096040e-01f, -1.15768611e-02f, 1.75861806e-01f, 5.34489453e-02f,
  -6.54855277e-03f, -5.19316420e-02f, 5.35904896e-03f, -2.61626076e-02f, 5.01844287e-03f, 1.99011758e-01f, 5.49407862e-02f, 6.01918995e-02f, -2.55629927e-01f, -7.42767230e-02f,
  1.28493309e-01f, -1.01255484e-01f, -1.27286300e-01f, 8.88867974e-02f, -2.24125192e-01f, -6.72918335e-02f, -7.27412328e-02f, -1.79348335e-01f, 1.26248658e-01f, -2.22358868e-01f,
  2.60033667e-01f, 1.55479312e-01f, 9.62049961e-02f, -7.90540129e-02f, -3.74407992e-02f, 8.60251039e-02f, 7.70654231e-02f, -1.53735280e-01f, -1.32687800e-02f, -1.36015574e-02f,
  -3.29992957e-02f, -1.74775142e-02f, -2.59548047e-04f, -1.02944128e-01f, 2.46943589e-02f, 1.34572491e-01f, 1.70130327e-01f, 1.53770998e-01f, 2.30877966e-01f, 1.68172181e-01f,
  1.52590737e-01f, 3.11801195e-01f, 1.29328802e-01f, -2.06464961e-01f, 1.09146051e-01f, 1.79224700e-01f, -1.26975864e-01f, -2.62689084e-01f, 3.61326570e-03f, 2.23842129e-01f,
  -6.00960702e-02f, -6.36773109e-02f, -7.72456527e-02f, -1.10631458e-01f, 2.33860970e-01f, 2.91386187e-01f, -9.73087475e-02f, 2.65380949e-01f, 2.42918789e-01f, 1.47667557e-01f,
  4.16603349e-02f, 7.74704665e-02f, 1.85585022e-01f, 2.51404345e-01f, 2.13337317e-02f, 1.41217202e-01f, -2.76073813e-02f, 2.81876385e-01f, 1.91526830e-01f, -4.40959670e-02f,
  5.05535342e-02f, -2.15282049e-02f, -2.45737240e-01f, 1.62662849e-01f, 1.73880413e-01f, -7.85409287e-02f, 5.57559282e-02f, -1.60035282e-01f, -3.79534066e-02f, 1.03325099e-02f,
  2.09209651e-01f, 1.52555987e-01f, -7.21599013e-02f, -9.36482698e-02f, -1.08093150e-01f, 1.78931326e-01f, 8.70314687e-02f, 2.03445956e-01f, 3.89736183e-02f, -1.21126823e-01f,
  8.94843563e-02f, 2.22202748e-01f, -3.27247940e-02f, -1.96567193e-01f, -1.92400590e-02f, 5.67573234e-02f, 1.08986109e-01f, 2.09489137e-01f, 2.09165633e-01f, 1.61156401e-01f,
  1.10610969e-01f, -1.42677352e-01f, 7.09959865e-02f, 6.03833795e-02f, -3.71248908e-02f, 1.36109665e-01f, -9.07818675e-02f, 5.54795340e-02f, 2.93757886e-01f, 2.23083466e-01f,
  -1.56475037e-01f, -4.10577878e-02f, 4.15975228e-02f, 5.76857254e-02f, 4.57202941e-02f, -2.13497400e-01f, 3.54186893e-01f, -6.21373691e-02f, -2.57678896e-01f, -3.31660770e-02f,
  3.46987486e-01f, 9.54709500e-02f, -5.15050516e-02f, 8.96411315e-02f, 1.32143393e-01f, -3.84166315e-02f, -1.06409222e-01f, -1.51052132e-01f, 5.25872819e-02f, 1.33274822e-02f,
  1.74799174e-01f, -5.89110292e-02f, 3.21706175e-03f, -6.46312013e-02f, -4.38361429e-02f, -8.41393918e-02f, 2.14646548e-01f, 5.43079711e-02f, 3.09091378e-02f, 6.77714050e-02f,
  4.02558856e-02f, -5.75619154e-02f, -1.85744092e-01f, 1.44366220e-01f, -1.20969951e-01f, 1.70318633e-02f, -1.28599390e-01f, 1.18689209e-01f, -4.20685224e-02f, 5.85603528e-02f,
  5.68878651e-02f, -2.63040811e-01f, 3.66584770e-02f, 3.69219810e-01f, 2.60330439e-01f, -3.09271701e-02f, -9.44443978e-03f, 9.61609557e-02f, 3.08381524e-02f, 1.00166099e-02f,
  -2.03744367e-01f, 1.15185104e-01f, -1.14440002e-01f, 2.60463536e-01f, -1.51017919e-01f, 1.46228865e-01f, 1.45207763e-01f, 1.36348009e-01f, 2.48527631e-01f, -2.07488164e-01f,
  1.31602570e-01f, 8.17384422e-02f, -2.68299490e-01f, -1.27455860e-01f, 2.32299268e-01f, -6.64956197e-02f, -1.30060375e-01f, -2.55872123e-02f, 2.66955107e-01f, 1.62785426e-01f,
  1.68887347e-01f, 2.20900863e-01f, 7.96154812e-02f, 2.42835358e-01f, -2.43183568e-01f, -2.43960366e-01f, -4.62348983e-02f, -1.59139633e-01f, -1.63924843e-02f, 6.53659403e-02f,
  2.17551187e-01f, 2.32767507e-01f, 1.57151803e-01f, 1.59072906e-01f, 4.82277572e-02f, 2.26749629e-01f, 2.15621784e-01f, 1.33547382e-02f, 1.33492630e-02f, 7.38440603e-02f,
  -2.67737389e-01f, 1.50557205e-01f, 2.82058418e-01f, -1.73385978e-01f, -9.17172059e-02f, -1.87699184e-01f, -2.39140570e-01f, -2.16997311e-01f, -6.46137968e-02f, 1.25697061e-01f,
  -6.89203367e-02f, -2.46101037e-01f, -6.89830035e-02f, -9.76295618e-04f, -1.74253955e-01f, 1.29991114e-01f, -1.08662313e-02f, 2.42233425e-02f, -1.91995446e-02f, -4.84608300e-02f,
  -5.31582534e-02f, -1.31411701e-01f, -6.56414405e-02f, 2.25463480e-01f, 2.79716402e-01f, 1.29733724e-03f, 2.10368618e-01f, 3.48771691e-01f, 2.71571837e-02f, 5.77911288e-02f,
  -6.69025332e-02f, 8.31794217e-02f, 1.94977939e-01f, 2.37651452e-01f, -5.25471568e-03f, -9.10248011e-02f, 1.68494359e-01f, 3.14470589e-01f, -8.43771622e-02f, -1.73448011e-01f,
  -2.87190955e-02f, 1.52434632e-01f, -9.26905796e-02f, -6.05867952e-02f, 2.15443909e-01f, -2.17427522e-01f, -1.59051389e-01f, 2.60296971e-01f, 2.76674062e-01f, 3.30905259e-01f,
  9.30645317e-02f, 1.74773037e-01f, 1.09406605e-01f, 1.23669215e-01f, 3.72445546e-02f, 1.48263857e-01f, 4.80543785e-02f, -6.57385141e-02f, 2.84613576e-03f, 1.02855138e-01f,
  5.48014306e-02f, 2.66269632e-02f, 7.04525486e-02f, 1.25934094e-01f, 8.22302774e-02f, 1.65383235e-01f, -1.18277639e-01f, 8.41436312e-02f, 1.42025426e-01f, 1.89471871e-01f,
  2.52799779e-01f, -1.41116887e-01f, 1.20464914e-01f, -7.46024325e-02f, -1.47941083e-01f, -8.02895650e-02f, -2.51616746e-01f, 1.85767859e-02f, 1.62171572e-01f, 1.72302797e-02f,
  -9.13282186e-02f, -4.50762212e-02f, 2.02255189e-01f, 2.29698524e-01f, 2.77748592e-02f, 1.93529218e-01f, -7.58781098e-03f, 2.66375542e-01f, -1.39983207e-01f, 1.66194111e-01f,
  1.78738907e-01f, 1.63203746e-01f, 3.43863852e-02f, 1.73516020e-01f, -7.14786500e-02f, 2.69198179e-01f, 1.62541911e-01f, -2.22133219e-01f, 2.55791187e-01f, -2.44752839e-02f,
  2.05476619e-02f, 8.40306580e-02f, -2.22753081e-03f, 1.04400545e-01f, -8.32995325e-02f, -3.09961718e-02f, 3.86839770e-02f, 6.96536526e-02f, -3.68608795e-02f, 8.37606639e-02f,
  1.35919988e-01f, 1.40483323e-02f, 9.16842595e-02f, 3.51238959e-02f, -1.83442473e-01f, -1.17229111e-02f, 1.71280608e-01f, 5.71758598e-02f, 1.56274557e-01f, 8.76638740e-02f,
  1.20532967e-01f, 1.89254314e-01f, 1.26030847e-01f, -1.70844235e-02f, 1.62933215e-01f, 1.37356207e-01f, -6.56782696e-03f, 4.74385805e-02f, -2.86973808e-02f, -8.65126550e-02f,
  4.52004857e-02f, 1.80370197e-01f, 1.25011485e-02f, -2.79158652e-02f, -1.48786500e-01f, -1.08682759e-01f, -2.22342774e-01f, 1.30418345e-01f, 1.81220695e-01f, -6.83256388e-02f,
  1.18400335e-01f, 7.79675171e-02f, -3.88558507e-02f, 2.63797551e-01f, 2.29745612e-01f, -6.22219518e-02f, 1.90202534e-01f, 3.75863202e-02f, 1.62618697e-01f, -1.86219439e-01f,
  3.02963108e-01f, 2.25853138e-02f, 2.87954569e-01f, 2.25684062e-01f, -2.40421891e-01f, 7.43166581e-02f, -1.76366225e-01f, 1.29111499e-01f, 1.50663391e-01f, -8.04608241e-02f,
  2.15227623e-02f, 2.60889262e-01f, -9.61313844e-02f, 2.32800439e-01f, 1.87457144e-01f, 5.89658991e-02f, 1.08460866e-01f, -9.46777873e-03f, 2.12925389e-01f, 2.30113924e-01f,
  -8.25440884e-02f, -2.50299186e-01f, 4.04168397e-01f, -2.37932727e-01f, -1.60248160e-01f, 1.42547861e-01f, -1.07181139e-01f, 6.77523464e-02f, 2.37645581e-01f, 7.52138719e-02f,
  1.14787817e-02f, 5.04729897e-02f, 8.64041299e-02f, 3.79846655e-02f, 1.26598522e-01f, 7.29763135e-02f, 8.09983984e-02f, 1.34655163e-02f, 1.35068297e-01f, -5.52159548e-02f,
  9.37069878e-02f, -1.05951987e-02f, 2.28819579e-01f, -2.24883124e-01f, 2.37344891e-01f, 4.04423885e-02f, -8.18961486e-02f, 1.96355000e-01f, -2.34634429e-01f, 5.56384958e-02f,
  -1.82248473e-01f, 1.05624773e-01f, -9.84779373e-02f, 6.72322363e-02f, 2.16626570e-01f, 1.14447445e-01f, -1.33260146e-01f, -1.79242164e-01f, 4.70037460e-02f, 1.96694061e-01f,
  2.06931934e-01f, -8.48051757e-02f, 2.52465546e-01f, 8.76807049e-02f, 8.43509361e-02f, 1.20707918e-02f, -1.34092957e-01f, 1.98763490e-01f, -1.78857863e-01f, 9.41347107e-02f,
  7.34359538e-03f, 1.37473300e-01f, 1.68869048e-01f, -7.38745034e-02f, 1.81363001e-01f, -4.05235700e-02f, -7.22626075e-02f, 1.18452132e-01f, -2.14906812e-01f, 1.74587920e-01f,
  1.77737281e-01f, 1.48835545e-03f, -7.99208507e-02f, -6.58017918e-02f, 1.00758433e-01f, 9.66988206e-02f, -3.18366513e-02f, -5.87851666e-02f, 1.21149607e-01f, 1.91587254e-01f,
  -8.22719410e-02f, -1.33845016e-01f, 2.59385318e-01f, -1.29075140e-01f, -8.11106060e-03f, 2.19643235e-01f, 2.26690054e-01f, 1.97571963e-01f, 2.03784868e-01f, 2.57027969e-02f,
  1.07105568e-01f, 5.22178486e-02f, 7.01381033e-03f, 1.77542835e-01f, 1.05188392e-01f, 1.63049236e-01f, -1.06757440e-01f, 4.68823127e-02f, 4.42833565e-02f, -1.18854813e-01f,
  6.73016831e-02f, 3.73442657e-02f, 1.91660330e-01f, -1.94287270e-01f, 9.30853039e-02f, -5.97744398e-02f, 1.83793783e-01f, -1.06750265e-01f, -1.37120709e-01f, -7.16425925e-02f,
  2.25665763e-01f, 2.75146395e-01f, 2.11991444e-01f, -2.43458614e-01f, 1.48570389e-01f, 2.66967863e-01f, -1.84728485e-02f, -3.62104923e-02f, 1.40287634e-02f, 1.67685270e-01f,
  2.68342309e-02f, -8.34199265e-02f, 4.40228619e-02f, 8.13176408e-02f, 2.47245446e-01f, 9.53711420e-02f, 2.07008198e-02f, 2.40105003e-01f, -1.52668178e-01f, 1.32537931e-01f,
  7.48325065e-02f, 5.97336292e-02f, 2.78164476e-01f, -8.17743875e-03f, 7.61273801e-02f, 2.97322720e-01f, 1.60321862e-01f, 3.45881358e-02f, -5.35490736e-03f, 1.16880551e-01f,
  1.36652023e-01f, -7.86480978e-02f, 1.51620641e-01f, -1.57344285e-02f, 2.02563748e-01f, 2.80846924e-01f, 1.57383591e-01f, 3.41010243e-01f, 5.02031157e-03f, 1.51253194e-01f,
  1.88288271e-01f, 1.41022876e-01f, 1.92614600e-01f, 7.49658644e-02f, -1.92707423e-02f, 1.93589732e-01f, 1.86652645e-01f, 2.17832416e-01f, 1.50869265e-01f, 1.46762267e-01f,
  -4.81200218e-03f, 2.07426861e-01f, 2.23701969e-01f, -5.09195849e-02f, 3.19111943e-02f, 2.05317259e-01f, 3.04885566e-01f, -1.53472885e-01f, 2.04608247e-01f, 5.63980117e-02f,
  -6.17028959e-02f, -2.31766745e-01f, -1.37330532e-01f, -1.05206452e-01f, 1.31300747e-01f, 1.57893658e-01f, 4.83007841e-02f, -3.38871107e-02f, 2.98306756e-02f, 1.36892349e-01f,
  9.86121893e-02f, 2.10588261e-01f, -6.01715408e-02f, 1.71837896e-01f, -4.65763509e-02f, 1.41411856e-01f, 2.05246300e-01f, 1.14636235e-01f, 3.58704418e-01f, 1.17027856e-01f,
  -7.90325645e-03f, 2.64515251e-01f, 2.96879292e-01f, 1.77630465e-02f, 1.00915290e-01f, -1.51203826e-01f, 2.91522890e-01f, 2.38622442e-01f, -4.82542589e-02f, -4.18584347e-02f,
  -1.11486778e-01f, 1.47338837e-01f, 1.46626025e-01f, 8.51923898e-02f, -4.40954901e-02f, -9.16196108e-02f, 4.82448563e-02f, -1.55475764e-02f, 1.37638941e-01f, 2.39247233e-01f,
  -1.26583815e-01f, 1.62734479e-01f, 5.12292050e-02f, 1.99060112e-01f, 2.15870261e-01f, 2.54454136e-01f, -1.85864512e-02f, 1.51099503e-01f, 1.10959359e-01f, 7.70793557e-02f,
  1.68788537e-01f, 1.69345498e-01f, -4.34756018e-02f, 1.12168178e-01f, -4.46667932e-02f, -1.70644715e-01f, 4.97152358e-02f, 7.45058954e-02f, -6.19091056e-02f, -1.31227300e-01f,
  -3.35178882e-01f, -1.19363435e-01f, -7.28578791e-02f, 1.70293182e-01f, 4.70166700e-03f, -2.33188525e-01f, 8.03094730e-02f, 1.47355169e-01f, 4.71532258e-04f, -1.82517186e-01f,
  1.74929619e-01f, 3.77689418e-03f, 7.64417648e-02f, -1.89858321e-02f, 1.46081254e-01f, 7.84583092e-02f, -6.87578321e-02f, 7.49236643e-02f, 2.29082406e-01f, 2.05269158e-01f,
  -1.56963646e-01f, 2.96382487e-01f, -1.33982018e-01f, -8.50416645e-02f, 9.04004350e-02f, -1.98573411e-01f, 2.05567807e-01f, 2.44384974e-01f, 5.50774187e-02f, -9.74090956e-03f,
  6.78573251e-02f, 2.01321289e-01f, 1.17549099e-01f, -1.31105945e-01f, -8.79631117e-02f, 2.03252375e-01f, 1.80201411e-01f, -1.82442084e-01f, 4.37779397e-01f, -3.81145984e-01f,
  -1.56826690e-01f, 2.78238684e-01f, 1.05796963e-01f, 7.70067945e-02f, 6.03032559e-02f, 1.30549353e-02f, 7.53986612e-02f, 7.74202496e-02f, 7.25918189e-02f, -6.13538846e-02f,
  9.48481932e-02f, -1.18683875e-01f, 9.20376740e-03f, 2.30627842e-02f, 6.56501763e-03f, 5.66782756e-03f, -1.06935846e-02f, 2.05276579e-01f, 2.34850436e-01f, -1.10565826e-01f,
  6.35438263e-02f, 3.77263725e-02f, 5.98680489e-02f, 4.07083295e-02f, 2.72705257e-01f, -5.62704913e-02f, 3.46559053e-03f, 6.56594858e-02f, 5.40972278e-02f, 4.07693386e-02f,
  4.82363440e-02f, -1.57720149e-02f, 1.02699786e-01f, 7.51472861e-02f, 2.39651650e-01f, -8.92328396e-02f, 6.14861175e-02f, 1.28961831e-01f, 9.86714065e-02f, -4.81364084e-03f,
  7.89327919e-02f, 2.29023203e-01f, -2.95305997e-02f, 2.27640346e-01f, 1.06557319e-02f, -2.19816223e-01f, -8.86353105e-02f, 4.94901948e-02f, 4.74994890e-02f, 1.03173591e-02f,
  -1.33853974e-02f, -6.41141534e-02f, 2.85934657e-02f, 2.20279306e-01f, -3.45454141e-02f, 1.16464281e-02f, 2.13746592e-01f, 2.57676721e-01f, 3.03543750e-02f, -1.09910958e-01f,
  1.19473167e-01f, 1.99037611e-01f, -3.51052545e-02f, -9.36928093e-02f, -2.41673226e-03f, -9.08064544e-02f, -1.11252060e-02f, -1.34518445e-01f, 1.00514732e-01f, -5.59352823e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -2.29024887e-02f, 6.00241311e-02f, -6.31726682e-02f, 7.66725093e-02f, -2.14092359e-02f, -6.27543703e-02f, 1.74715444e-02f, -5.61641641e-02f, 1.20727792e-01f, 6.01411127e-02f,
  1.57896712e-01f, 8.72456431e-02f, 3.50193642e-02f, 5.65360114e-02f, 8.78003985e-02f, 6.70052096e-02f, -2.11024061e-02f, 2.96649095e-02f, 1.11416206e-01f, 1.06990077e-01f,
  1.64993312e-02f, 1.39895186e-01f, 6.66025430e-02f, 3.86050306e-02f, 1.14160128e-01f, 2.45138705e-02f, 1.41632378e-01f, 8.84230435e-02f, 1.18758023e-01f, 7.53944442e-02f,
  3.54426019e-02f, 1.47471383e-01f, 2.05973729e-01f, 1.10431299e-01f, 2.55501680e-02f, 1.66048825e-01f, 1.27543122e-01f, 8.84040371e-02f, 1.57033741e-01f, 1.08370468e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.36818677e-01f, 7.48441666e-02f, 1.10398389e-01f, 2.96919309e-02f, 6.40688390e-02f, 7.62952790e-02f, -1.50689960e-01f, -2.06251964e-02f, 2.25838516e-02f, 2.43231319e-02f,
  -5.32501303e-02f, -9.35470536e-02f, -1.25605136e-01f, -6.06977493e-02f, 1.48595750e-01f, 5.47962263e-02f, -9.59969386e-02f, -1.03352830e-01f, 7.87413940e-02f, 1.41994953e-01f,
  6.24104552e-02f, -1.67880654e-01f, 1.15659483e-01f, 7.91308209e-02f, -9.39818472e-02f, -6.44818321e-02f, 7.50456601e-02f, 6.30130619e-02f, 3.01001556e-02f, -8.86962190e-02f,
  -9.32509229e-02f, -4.36757766e-02f, -1.04641549e-01f, -2.27766354e-02f, 1.25681900e-03f, -1.09496573e-02f, 2.88334880e-02f, 1.21671267e-01f, 7.01327920e-02f, -3.22191641e-02f,
  -8.69921520e-02f, 9.99935064e-03f, 5.83550408e-02f, -1.60151139e-01f, 1.02559917e-01f, -1.42207801e-01f, 1.07267536e-01f, 6.41017482e-02f, -8.68626237e-02f, -1.53283164e-01f,
  9.18307602e-02f, 4.29484844e-02f, 1.05375297e-01f, -7.04310983e-02f, -9.03034955e-02f, -1.11561336e-01f, 9.72372387e-03f, -9.24064815e-02f, 7.19868541e-02f, -6.62348494e-02f,
  1.53363571e-01f, 9.62671358e-03f, 9.34983790e-02f, 2.21030805e-02f, -6.19695857e-02f, -1.37228131e-01f, 5.64024821e-02f, -2.77813040e-02f, -2.43797209e-02f, 3.71762253e-02f,
  -8.60404149e-02f, 1.77593827e-02f, -2.05267798e-02f, 5.58005944e-02f, 9.67157409e-02f, -3.21822353e-02f, -5.91426566e-02f, -5.22530079e-02f, -9.55420826e-03f, -6.41759634e-02f,
  1.76115796e-01f, 1.02788724e-01f, -1.82327226e-01f, -4.31244858e-02f, 7.27767497e-02f, 1.31399646e-01f, -1.47177964e-01f, 1.41114205e-01f, -3.58263217e-02f, -3.19318473e-02f,
  5.13029508e-02f, -7.14498921e-04f, 1.65908813e-01f, -1.46235839e-01f, -6.29678816e-02f, 5.29503115e-02f, 7.94312079e-03f, -6.12200350e-02f, 6.60290569e-02f, -4.65965383e-02f,
  6.04678169e-02f, 1.07614130e-01f, 3.48961800e-02f, -1.21207654e-01f, -4.22266982e-02f, -3.38433571e-02f, 9.33967680e-02f, -3.99380587e-02f, -3.82840377e-03f, -7.30102062e-02f,
  -8.86491761e-02f, 1.94675699e-02f, -1.82293244e-02f, 1.25196174e-01f, 1.15600340e-01f, -1.25253543e-01f, -1.32796302e-01f, -6.51563052e-03f, -8.99592638e-02f, 4.76582348e-02f,
  -2.06892062e-02f, 1.40279964e-01f, -1.38439551e-01f, 4.75840941e-02f, 1.01661958e-01f, 3.15958522e-02f, -7.68846273e-02f, -2.23789234e-02f, -1.05684362e-01f, 8.30717310e-02f,
  -8.09712335e-02f, -3.75143997e-02f, -1.07086048e-01f, 2.77491938e-02f, 5.74969836e-02f, -8.64968300e-02f, 3.83192115e-02f, 7.69743347e-04f, 1.01397924e-01f, 9.96048972e-02f,
  5.53094922e-03f, -1.98674768e-01f, 1.44041374e-01f, 5.21273762e-02f, -7.15010390e-02f, 2.84026824e-02f, 5.57506382e-02f, 1.10542001e-02f, 3.51354107e-02f, -1.91503167e-01f,
  -1.53875863e-02f, -1.34489000e-01f, -4.25878428e-02f, 2.58294158e-02f, 3.11013171e-03f, -4.07893173e-02f, -7.16537982e-02f, 8.24601650e-02f, 5.16429879e-02f, -3.04605835e-03f,
  8.35567191e-02f, 3.29331611e-03f, -6.94340393e-02f, -1.21050246e-01f, 6.34972844e-03f, 1.67827997e-02f, -4.85472381e-02f, -5.37354425e-02f, -2.74685547e-02f, -1.32350996e-01f,
  -9.52657014e-02f, 5.49270175e-02f, 7.45917037e-02f, -6.61487430e-02f, 7.05494210e-02f, 7.73079842e-02f, 1.09637059e-01f, -9.74475965e-02f, -9.49583799e-02f, 6.00753278e-02f,
  1.70329750e-01f, 1.60182957e-02f, -1.04696155e-01f, -3.03024892e-02f, 3.79584618e-02f, -2.32780501e-02f, 3.53441462e-02f, -7.32474402e-02f, 1.15976222e-01f, 1.24365920e-02f,
  -4.71075624e-02f, 6.59910813e-02f, -6.26960099e-02f, 4.81066108e-02f, 1.45793380e-02f, 3.15467715e-02f, -7.45087564e-02f, 6.68014493e-03f, 1.40176592e-02f, -1.83928654e-01f,
  -7.00200349e-02f, -5.07523231e-02f, -1.20457329e-01f, 6.92176400e-04f, 1.26202539e-01f, -7.55797178e-02f, -1.70360710e-02f, -2.60006301e-02f, 1.22276947e-01f, -6.14257203e-03f,
  6.89401701e-02f, -3.25525142e-02f, -2.15381056e-01f, 1.69458501e-02f, 1.46963134e-01f, -1.86133329e-02f, -5.39192371e-03f, -7.30437487e-02f, 7.84763023e-02f, 2.12924629e-01f,
  1.68090194e-01f, -1.06502369e-01f, -4.78960723e-02f, -3.16780526e-03f, 9.63852704e-02f, 1.25769973e-02f, -7.74031654e-02f, 5.67768812e-02f, -4.11778912e-02f, 6.86377287e-02f,
  -1.04942918e-01f, -3.32009941e-02f, -5.43479137e-02f, -1.11235365e-01f, -8.90580658e-03f, -5.71127571e-02f, 5.79877570e-02f, -3.17536108e-02f, -8.02219585e-02f, 2.04814047e-01f,
  1.16347961e-01f, -9.83927399e-02f, -3.70479040e-02f, -4.72296253e-02f, -5.39496355e-02f, 1.06576055e-01f, 1.86633825e-01f, -1.39874313e-02f, -5.27064539e-02f, -2.31492445e-02f,
  -6.33118395e-03f, 1.99600519e-03f, -1.18522774e-02f, -5.53891025e-02f, -1.13718502e-01f, -2.12925151e-02f, -9.69904438e-02f, 4.76997495e-02f, -2.23876350e-02f, 1.22055106e-01f,
  7.58217275e-02f, 1.11337103e-01f, -7.00755790e-02f, 8.45156759e-02f, 4.67855819e-02f, 1.02690101e-01f, 2.71146577e-02f, -2.48018317e-02f, 1.44818172e-01f, -5.10896407e-02f,
  -7.96264112e-02f, -1.03853039e-01f, -8.27584192e-02f, 3.56768146e-02f, 3.26781496e-02f, -1.98727295e-01f, -1.02454580e-01f, 1.33178905e-01f, -7.35952333e-03f, 5.33074252e-02f,
  7.74475485e-02f, 9.00370628e-02f, -1.10255949e-01f, 1.67682655e-02f, 6.28391206e-02f, 7.25530162e-02f, 7.64429867e-02f, -3.62855825e-03f, -6.33059489e-03f, 1.47037908e-01f,
  1.95733309e-02f, -4.83733863e-02f, -1.76630765e-02f, -3.98852713e-02f, 3.21950316e-02f, -7.87175223e-02f, 5.64226769e-02f, -2.09767997e-01f, -4.05526869e-02f, 1.39540583e-01f,
  -1.19077735e-01f, -2.04570647e-02f, -4.00188230e-02f, -4.25979961e-03f, 1.23650528e-01f, 1.42355042e-03f, -2.11503338e-02f, -1.09696940e-01f, -6.72615767e-02f, -8.02833065e-02f,
  -4.25209254e-02f, 1.10991679e-01f, 5.38935810e-02f, 1.37166545e-01f, 5.43071479e-02f, 8.36271942e-02f, -9.74754691e-02f, 9.15761665e-02f, -2.59791259e-02f, -7.62882235e-04f,
  -1.04751803e-01f, 3.32345441e-02f, 1.88615695e-02f, 8.88752416e-02f, 2.64651123e-02f, 3.63566971e-04f, -1.24398835e-01f, -2.09339913e-02f, 2.79032066e-02f, -4.44641225e-02f,
  -9.14678797e-02f, 4.97562587e-02f, 9.11807120e-02f, 3.76209505e-02f, -5.87294772e-02f, 7.03168958e-02f, -1.78602770e-01f, 3.49895917e-02f, -1.33736366e-02f, 5.38741499e-02f,
  -1.03097461e-01f, -1.30859707e-02f, -3.57453749e-02f, -1.01896442e-01f, -4.89296615e-02f, -9.11208466e-02f, -7.38369599e-02f, 5.15106544e-02f, -1.13678560e-01f, -7.84785897e-02f,
  -6.31476715e-02f, 1.40513554e-01f, -5.16500250e-02f, 9.77653041e-02f, -1.24802172e-01f, 9.85197052e-02f, 9.75095183e-02f, -1.33504257e-01f, 5.12637645e-02f, 6.92855287e-03f,
  -1.42096564e-01f, -1.07751563e-01f, -5.57599254e-02f, 9.08247568e-03f, 2.00474430e-02f, 3.02095003e-02f, 1.09620273e-01f, -8.92195851e-02f, 5.94776915e-03f, 1.24602005e-01f,
  -1.92444213e-02f, 1.03581503e-01f, 1.23645842e-01f, -1.00200303e-01f, 7.81772882e-02f, -6.77829236e-02f, 5.87701350e-02f, -4.46668938e-02f, 1.27471715e-01f, 1.13408277e-02f,
  -1.03999570e-01f, -4.26376760e-02f, -5.25999814e-02f, 8.32875147e-02f, -6.54655024e-02f, -2.94660199e-02f, 1.48289995e-02f, 4.44605015e-03f, -8.26867446e-02f, 4.19251174e-02f,
  -5.66629432e-02f, -9.66051966e-02f, -1.02731198e-01f, -1.14804909e-01f, 4.80594747e-02f, -6.95383400e-02f, 3.84542756e-02f, 6.90746903e-02f, -1.32413760e-01f, -7.17806965e-02f,
  3.98404822e-02f, 2.09292918e-01f, -1.38383135e-01f, -4.81184795e-02f, -7.16431886e-02f, 7.96936303e-02f, -6.94864392e-02f, 2.32281797e-02f, -6.40903339e-02f, -9.26765203e-02f,
  1.01467378e-01f, -1.35245577e-01f, 9.52591375e-02f, 9.28930193e-02f, 3.42567749e-02f, 1.10430643e-01f, 8.78725573e-02f, -5.37471063e-02f, 8.62836093e-02f, 1.05747648e-01f,
  1.06154561e-01f, 9.68758203e-03f, 3.37444544e-02f, 7.20920265e-02f, 3.08505185e-02f, -1.18118882e-01f, 8.20138454e-02f, 6.78722486e-02f, -1.50529295e-01f, -7.21198767e-02f,
  -2.19118502e-02f, -4.52539995e-02f, 2.28224751e-02f, 3.62378173e-02f, -9.34394598e-02f, -1.58508256e-01f, 1.17776515e-02f, -1.22196451e-01f, 3.12224794e-02f, -5.65981567e-02f,
  2.55638752e-02f, -5.64894080e-02f, -1.42859995e-01f, 6.42422065e-02f, -1.83014154e-01f, 8.98064673e-02f, 8.13674405e-02f, 7.20768124e-02f, -1.14331469e-01f, 3.57289650e-02f,
  -6.01956388e-03f, -4.70620506e-02f, -1.27150908e-01f, -4.27668430e-02f, 8.55948683e-03f, -6.56788284e-03f, -3.76442373e-02f, 3.07507422e-02f, -8.34510997e-02f, -1.12653784e-01f,
  8.47962871e-03f, -5.86670600e-02f, -1.36413008e-01f, -1.02861658e-01f, 1.04489818e-01f, -1.23387752e-02f, -7.01083690e-02f, -8.94256160e-02f, -2.94176862e-02f, 9.72418860e-02f,
  2.97160912e-02f, -2.32886579e-02f, 4.39803042e-02f, 1.56999156e-01f, -9.26633738e-03f, -1.23511344e-01f, -1.41151711e-01f, -7.57592842e-02f, 1.67532384e-01f, -1.01799436e-01f,
  6.40770793e-02f, -9.76742059e-02f, -1.04116060e-01f, -4.32105400e-02f, -4.99619283e-02f, 7.17731193e-02f, -2.80560851e-02f, 1.09590366e-02f, -1.57151699e-01f, 8.58363211e-02f,
  -1.20517053e-01f, 1.84186678e-02f, -1.36340886e-01f, 1.03458472e-01f, 5.08903526e-03f, -2.99639646e-02f, -9.99400765e-03f, -1.58687398e-01f, 5.26457094e-02f, 4.06242609e-02f,
  7.23848939e-02f, 1.07556567e-01f, -3.34368348e-02f, 1.40141636e-01f, 2.06376035e-02f, 3.78442258e-02f, -8.65036547e-02f, -4.87702573e-03f, -3.78851481e-02f, 4.21531778e-03f,
  2.05450840e-02f, -1.23424031e-01f, -1.08564131e-01f, 6.70259148e-02f, -2.25306153e-02f, -1.49218980e-02f, -1.22158296e-01f, -2.71281954e-02f, 6.17670119e-02f, -8.66679028e-02f,
  2.12930832e-02f, -3.18913125e-02f, 2.06627809e-02f, 7.10268617e-02f, 1.21134803e-01f, -2.98887342e-02f, 2.25483999e-01f, 8.50524083e-02f, 1.48078606e-01f, 2.34710220e-02f,
  -1.41754583e-01f, 5.31082638e-02f, -8.01913324e-04f, -1.02544471e-03f, -2.41526831e-02f, -7.29066133e-02f, -1.09960668e-01f, -2.37493478e-02f, 1.99529789e-02f, 1.08131617e-01f,
  5.92351146e-03f, -1.59039013e-02f, -1.12535477e-01f, 9.78570953e-02f, 6.01714551e-02f, -5.67287020e-02f, -5.22174314e-03f, -2.16613966e-03f, 9.25652310e-02f, -3.37713100e-02f,
  -8.22705589e-03f, 8.36857855e-02f, 1.65565491e-01f, -2.51573622e-02f, 4.69778404e-02f, 4.19552103e-02f, 3.76400836e-02f, 7.15977773e-02f, 5.87501116e-02f, -2.70890426e-02f,
  -7.56834000e-02f, -6.24990314e-02f, -6.74787834e-02f, 6.97603673e-02f, 8.47219154e-02f, -8.11147466e-02f, 5.46588339e-02f, 2.87496112e-02f, -2.21482888e-01f, 1.10363975e-01f,
  8.00239965e-02f, -4.25693132e-02f, -9.10092294e-02f, -7.73832276e-02f, -8.40396211e-02f, 3.68901081e-02f, -1.42914936e-01f, 9.91164371e-02f, -5.19215269e-03f, -9.04231519e-02f,
  -8.69418159e-02f, 8.05246979e-02f, -4.80635315e-02f, 6.74189925e-02f, 2.06132252e-02f, 4.16764840e-02f, -8.87326058e-03f, 2.23361161e-02f, -2.67081968e-02f, 1.42600328e-01f,
  1.32932484e-01f, 1.43281996e-01f, 1.03372030e-01f, 7.09559247e-02f, -8.89375433e-02f, 1.32814411e-03f, -1.03747807e-01f, -1.57577753e-01f, -1.51581354e-02f, -6.26478205e-03f,
  6.32925034e-02f, -4.43264805e-02f, -4.32082415e-02f, -2.76758592e-03f, 1.08795926e-01f, -4.51093875e-02f, -2.05977887e-01f, 3.07244789e-02f, 5.55747189e-03f, 1.69014722e-01f,
  -1.35450780e-01f, 8.52051899e-02f, 1.22330766e-02f, 4.08574492e-02f, -8.36367160e-02f, 4.20183502e-02f, 2.54481696e-02f, -1.00782186e-01f, 2.20268294e-02f, 1.63495898e-01f,
  2.04243995e-02f, 1.73840802e-02f, 1.12243064e-01f, 5.41148409e-02f, 7.67442882e-02f, 4.23130654e-02f, -4.86436449e-02f, -7.16858134e-02f, 1.12262152e-01f, -9.53161120e-02f,
  7.66768828e-02f, 5.93722612e-02f, -1.89448386e-01f, 9.59482864e-02f, -3.77708441e-03f, -5.95981292e-02f, 9.24230814e-02f, -9.96650010e-03f, -1.02171272e-01f, 1.52710661e-01f,
  -1.07139446e-01f, 1.04020974e-02f, -7.16467295e-03f, 3.16357166e-02f, -1.21610373e-01f, -3.00877541e-02f, 1.00833789e-01f, -4.68825996e-02f, -1.77892707e-02f, 1.52689442e-02f,
  1.53217375e-01f, 1.26115605e-01f, 1.07417047e-01f, 6.24457598e-02f, -2.80647539e-02f, -7.00506717e-02f, 1.35402068e-01f, 1.43685997e-01f, -1.25129461e-01f, 5.78745194e-02f,
  -6.12088926e-02f, 2.98316311e-02f, 1.29768401e-01f, 1.18207030e-01f, -7.34386593e-02f, -2.07109917e-02f, 1.47924107e-02f, 1.31526634e-01f, 1.16040379e-01f, -1.19065925e-01f,
  7.48352557e-02f, -8.33240058e-03f, -3.35968770e-02f, 1.23258904e-01f, 6.68998510e-02f, 2.21788343e-02f, 3.36621073e-03f, 6.75179213e-02f, -1.64941605e-02f, -2.78915390e-02f,
  7.48300329e-02f, -9.46162120e-02f, 1.20878391e-01f, 1.61025748e-01f, -1.35126069e-01f, -1.67584196e-01f, -8.65672622e-03f, -7.60026053e-02f, 1.17591068e-01f, -1.17025487e-01f,
  5.50666302e-02f, -1.59260318e-01f, 1.08024932e-01f, -2.51645651e-02f, 1.55210763e-01f, -1.02383845e-01f, 4.90702642e-03f, 5.81265651e-02f, -3.65525968e-02f, 9.84532982e-02f,
  6.22354588e-03f, 1.22211181e-01f, -2.30519380e-02f, 9.80179459e-02f, -1.28387257e-01f, 1.73556898e-02f, -1.12418458e-01f, -7.87415132e-02f, -1.03261121e-01f, 8.48790854e-02f,
  -4.25551124e-02f, -1.37539536e-01f, 7.28064254e-02f, -1.24504410e-01f, -9.99943390e-02f, -9.21378359e-02f, -6.34843707e-02f, 4.29228926e-03f, -4.16204445e-02f, 8.04109573e-02f,
  -1.40974461e-03f, 3.65997888e-02f, -1.77256897e-01f, 9.91983488e-02f, 5.51412515e-02f, -1.00345127e-01f, -1.71011582e-01f, -1.34128407e-02f, 3.79468054e-02f, -1.64908096e-01f,
  8.35416988e-02f, -4.70315143e-02f, 4.24856432e-02f, 1.66908637e-01f, -1.23194247e-01f, -9.10128430e-02f, -1.80183679e-01f, 7.12066822e-06f, 9.86422226e-02f, -9.48516931e-03f,
  5.30577525e-02f, 1.70758963e-01f, -1.01263531e-01f, -9.06109959e-02f, 9.83566791e-02f, -6.37788028e-02f, 1.74212039e-01f, 8.57561640e-03f, -1.04002103e-01f, 2.12147161e-02f,
  9.93362740e-02f, -8.08058903e-02f, -5.23695257e-03f, 1.02586113e-01f, -4.61629368e-02f, 6.91997260e-02f, 5.04057780e-02f, -1.38574511e-01f, 7.07042441e-02f, -4.94192168e-02f,
  7.08334893e-03f, 1.08263165e-01f, 5.36695309e-02f, 1.29037974e-02f, 1.10513166e-01f, -2.17181840e-03f, -1.27883747e-01f, 7.74906576e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -3.72011662e-02f, 9.59607735e-02f, 4.04213183e-02f, -4.75802869e-02f, 1.99341640e-01f, 1.46259770e-01f, 5.15000708e-02f, -8.75838697e-02f, -7.97794610e-02f, 7.25967214e-02f,
  -5.67627028e-02f, 9.30476785e-02f, 1.05857082e-01f, -1.41582284e-02f, -2.69324005e-01f, -1.88225031e-01f, 1.97715923e-01f, 1.79952551e-02f, -9.31475535e-02f, -2.66008586e-01f,
  -5.32800751e-03f, 8.79513770e-02f, 1.12947658e-01f, 7.92925507e-02f, -2.62139469e-01f, 3.60961646e-01f, 1.28170684e-01f, -2.65501916e-01f, 1.26277506e-01f, -1.24347627e-01f,
  3.06091815e-01f, 8.45900178e-02f, 2.80045211e-01f, -2.78692339e-02f, 2.14614168e-01f, 1.37509152e-01f, -9.20835584e-02f, 2.48151809e-01f, 5.34419855e-03f, 2.74370968e-01f,
  -1.62448183e-01f, -5.00709005e-02f, 2.37245888e-01f, 4.76693287e-02f, 1.46208256e-02f, 2.37354919e-01f, -1.64248824e-01f, 1.12645775e-01f, 1.37968585e-01f, 1.64385751e-01f,
  -5.68986721e-02f, -2.02362508e-01f, 8.43147188e-02f, 2.40856692e-01f, 7.51632303e-02f, 1.03162356e-01f, 1.37078762e-01f, 6.13292418e-02f, -1.43651620e-01f, 2.36318544e-01f,
  1.08361490e-01f, 4.85345274e-02f, 9.66813117e-02f, 5.36665469e-02f, 2.35593647e-01f, 1.73231915e-01f, 1.48072109e-01f, 1.71699464e-01f, 8.34891945e-02f, -2.00592116e-01f,
  2.23554354e-02f, 1.95864305e-01f, 3.81841995e-02f, 1.68061346e-01f, -1.98659766e-02f, -6.01617200e-03f, -1.08429991e-01f, 4.11516502e-02f, -2.25612640e-01f, 1.76105827e-01f,
  -2.54404932e-01f, -5.00563905e-02f, 1.85606837e-01f, 1.00624710e-01f, 1.19885750e-01f, 1.34388566e-01f, 6.67382181e-02f, 1.40166998e-01f, 1.94100231e-01f, 5.94497584e-02f,
  -1.48346975e-01f, -7.48624876e-02f, -2.77218610e-01f, 1.54170617e-01f, 1.12918809e-01f, -1.91877261e-01f, -1.56479683e-02f, 4.62927185e-02f, 1.92200363e-01f, -7.75377378e-02f,
  -1.60336077e-01f, -2.83703864e-01f, 3.10216267e-02f, -2.76546460e-02f, 2.18804330e-01f, 1.96219251e-01f, 5.67306355e-02f, 4.40137014e-02f, 5.94980828e-02f, -1.33833900e-01f,
  3.17409560e-02f, -7.80106382e-03f, -5.86670823e-02f, 2.88987428e-01f, 2.84552693e-01f, 2.78420061e-01f, -1.42947152e-01f, 3.41272317e-02f, 9.22547057e-02f, 1.70983404e-01f,
  1.00109212e-01f, 2.30482548e-01f, 2.13212632e-02f, 7.60059655e-02f, 1.08371399e-01f, 8.83489789e-04f, 1.87240601e-01f, -1.08330101e-01f, 1.53889090e-01f, 2.16489464e-01f,
  7.93890879e-02f, 8.52820873e-02f, 5.20421043e-02f, 1.81451023e-01f, 2.15150341e-01f, 8.50797966e-02f, 1.38033181e-01f, 1.04052769e-02f, 1.73692375e-01f, -2.76033375e-02f,
  2.37703584e-02f, -7.63140097e-02f, 3.59557942e-03f, -2.05743566e-01f, 1.82485461e-01f, 2.04323754e-02f, -3.29804569e-01f, -1.57451794e-01f, 1.54239060e-02f, 1.45320937e-01f,
  2.21971422e-01f, 2.76814532e-02f, 1.23883657e-01f, 2.19300613e-01f, -8.60926658e-02f, 2.52757788e-01f, 1.71147943e-01f, -2.91114599e-01f, 2.01957449e-01f, 2.32395902e-02f,
  -3.58989313e-02f, 1.89234853e-01f, 1.85993299e-01f, 5.61981425e-02f, 3.09815764e-01f, 7.02996776e-02f, 2.08308190e-01f, 2.26886079e-01f, -2.17892975e-01f, -2.46850654e-01f,
  2.17884123e-01f, 2.52512276e-01f, -9.60975289e-02f, -2.25224681e-02f, -2.74321046e-02f, 1.05876654e-01f, 1.61536753e-01f, -3.89580689e-02f, 1.88056469e-01f, -1.40632927e-01f,
  -3.85922268e-02f, -2.79933929e-01f, 1.14337802e-01f, -1.73010722e-01f, -5.91363162e-02f, 2.15911061e-01f, -1.20029002e-01f, -4.08909284e-03f, 1.68845043e-01f, 1.32316172e-01f,
  -5.47551597e-03f, 1.29509076e-01f, 1.07883692e-01f, 1.20377079e-01f, 1.00567549e-01f, 2.20633652e-02f, 6.61467537e-02f, 1.05675593e-01f, 6.21590614e-02f, 4.97775227e-02f,
  1.54420003e-01f, 1.35319114e-01f, -7.25339502e-02f, -2.57399455e-02f, -1.61357179e-01f, 2.19082367e-02f, 6.52512982e-02f, -1.38615239e-02f, 1.57549962e-01f, -4.89391312e-02f,
  -2.73317635e-01f, 1.00439265e-01f, 3.01927269e-01f, 1.74639627e-01f, -2.67858263e-02f, 1.10559694e-01f, 1.01652838e-01f, -2.15497807e-01f, 1.63591921e-01f, 3.94314900e-02f,
  -1.93527102e-01f, -2.25075766e-01f, 8.60697627e-02f, -9.08149853e-02f, -1.99514642e-01f, -2.14562595e-01f, 1.34432644e-01f, -8.10703635e-02f, -1.21831233e-02f, -1.90191612e-01f,
  9.54559818e-02f, -8.41673538e-02f, -1.65450901e-01f, 1.62400112e-01f, 2.98034161e-01f, 1.18047692e-01f, 3.01953834e-02f, -1.09133609e-01f, -1.08754762e-01f, -1.37891993e-01f,
  -1.37447670e-01f, 1.03761137e-01f, 1.76508248e-01f, 1.94770560e-01f, 7.18870535e-02f, 4.04876135e-02f, 2.91354698e-03f, -1.72393292e-01f, 2.74358988e-02f, 1.84801042e-01f,
  9.46640223e-02f, -1.60382763e-01f, 1.25175416e-01f, 7.47750849e-02f, -6.89093396e-02f, 2.05085855e-02f, 8.52809325e-02f, 2.33668402e-01f, 8.80741104e-02f, 6.99839294e-02f,
  1.41598964e-02f, -4.70395796e-02f, 9.37325805e-02f, 1.87494189e-01f, 2.41031617e-01f, -4.44952436e-02f, 2.23947629e-01f, 7.23517090e-02f, 7.62519389e-02f, -1.04259126e-01f,
  1.72452301e-01f, 1.75824642e-01f, -1.48646533e-01f, -2.62671560e-01f, 1.18027091e-01f, -2.36119390e-01f, -1.16762310e-01f, 6.65217787e-02f, -5.64598031e-02f, -1.80104822e-01f,
  1.49173498e-01f, 2.94462815e-02f, -2.99526658e-02f, -6.55428991e-02f, 1.93354145e-01f, 1.59275621e-01f, -1.32637620e-01f, 2.09344909e-01f, -6.24902137e-02f, 3.20065737e-01f,
  -9.08063576e-02f, 2.46475399e-01f, 2.82087207e-01f, 1.12582162e-01f, 6.45131245e-02f, 2.12994784e-01f, 1.27894729e-01f, -9.83984396e-02f, -1.56761602e-01f, 2.62545794e-01f,
  1.03541322e-01f, 1.12395816e-01f, 1.97306588e-01f, 2.43733972e-02f, 1.56374484e-01f, 2.11653905e-03f, 1.47040933e-02f, 1.67392507e-01f, 2.07525920e-02f, -6.62452728e-02f,
  -5.89516833e-02f, 9.30761546e-02f, -8.11091252e-03f, -3.16811027e-04f, 2.81116478e-02f, 1.76108882e-01f, 4.12678160e-02f, 4.29439396e-02f, 1.12423688e-01f, 9.31759551e-02f,
  -9.49675068e-02f, 5.95869757e-02f, -2.38868501e-02f, 6.25806227e-02f, 1.20976970e-01f, 1.44924313e-01f, 1.30702525e-01f, -2.52942517e-02f, -9.45571586e-02f, -2.01112330e-02f,
  7.18565658e-02f, -1.75597630e-02f, -4.92791235e-02f, -2.46646732e-01f, 2.00511776e-02f, -1.69430092e-01f, -1.00589871e-01f, -1.21809594e-01f, 6.60397783e-02f, 1.41369522e-01f,
  -5.12097068e-02f, -1.96552351e-01f, 2.08038390e-01f, -8.47461075e-02f, 1.20325491e-01f, -1.72543302e-01f, 7.33655393e-02f, 2.53844768e-01f, 2.54882693e-01f, -4.92685810e-02f,
  1.60105392e-01f, 1.94209307e-01f, 7.49738440e-02f, 1.27014499e-02f, -1.21188648e-01f, -1.91654116e-01f, 9.68051478e-02f, 1.64202124e-01f, -3.97387147e-02f, -3.94479781e-02f,
  3.48825365e-01f, -7.24625885e-02f, -2.15934873e-01f, -1.19300611e-01f, 4.85681780e-02f, 2.95634270e-02f, 9.38403085e-02f, 1.99665725e-01f, 1.89591154e-01f, -2.28998676e-01f,
  -5.57377785e-02f, -1.44511625e-01f, 8.93572867e-02f, -2.80118510e-02f, 1.05056249e-01f, -2.84920275e-01f, 8.15397128e-02f, -1.62677258e-01f, 2.40930915e-01f, 1.23659410e-01f,
  6.80756941e-02f, 1.11466989e-01f, 1.33416057e-01f, -2.13083122e-02f, -1.11066978e-02f, 1.06352530e-01f, 1.35060355e-01f, -1.04485624e-01f, -4.26727682e-02f, 1.75768118e-02f,
  8.73605534e-02f, -1.02893956e-01f, -8.81240368e-02f, 6.82537109e-02f, 7.03157336e-02f, -1.59429554e-02f, -5.20593785e-02f, -3.16324532e-02f, 2.79253006e-01f, 8.53452738e-03f,
  2.88323909e-02f, 9.05827284e-02f, 1.71627760e-01f, -8.03591982e-02f, 1.65925473e-01f, -8.22076201e-02f, -9.69453827e-02f, -2.28829950e-01f, 1.38812840e-01f, -6.53216913e-02f,
  2.94750720e-01f, -2.05722302e-01f, 2.90049732e-01f, 2.40533277e-01f, -3.51376645e-02f, 7.95766488e-02f, 1.77344233e-01f, 5.34826852e-02f, -6.57305866e-02f, 1.00633010e-01f,
  2.11576834e-01f, 1.63928181e-01f, 1.36770904e-01f, 1.06437981e-01f, 1.88083015e-02f, 3.96919809e-02f, 3.99887841e-03f, -1.60249118e-02f, 9.30337086e-02f, 1.24387324e-01f,
  2.11513162e-01f, 4.26903442e-02f, 8.64687115e-02f, -2.43629336e-01f, 3.37377377e-02f, 2.08899245e-01f, 2.92300582e-01f, 1.63239002e-01f, -2.74933130e-01f, 1.77551750e-02f,
  -1.40179753e-01f, -1.13986231e-01f, 1.54841557e-01f, 2.42820308e-01f, 1.23368287e-02f, -1.60516858e-01f, 9.72994696e-03f, 3.15858349e-02f, -3.91539223e-02f, 3.05587407e-02f,
  8.37486535e-02f, 4.08659726e-02f, 1.12208553e-01f, -1.81318924e-01f, 1.13027185e-01f, -1.49306096e-03f, 9.60378274e-02f, 9.35949758e-02f, 1.64438561e-01f, 9.19534937e-02f,
  -1.14039600e-01f, -7.08258376e-02f, -3.63607220e-02f, 4.54280674e-02f, -1.07872523e-01f, -3.06823373e-01f, 1.80428073e-01f, -4.50253934e-02f, -2.96439715e-02f, -1.84306383e-01f,
  1.39660940e-01f, -1.15379520e-01f, -8.46968666e-02f, -7.27580711e-02f, 6.05879240e-02f, -9.00412574e-02f, 1.28614381e-02f, 2.33033091e-01f, -1.38777301e-01f, 1.76203504e-01f,
  -1.48615483e-02f, 3.18578243e-01f, -1.42744064e-01f, 9.62927490e-02f, 9.68274102e-03f, -1.05162142e-02f, 1.17530778e-01f, 1.73088983e-01f, 2.00421706e-01f, -1.85900018e-01f,
  -1.86120823e-01f, 1.00372590e-01f, 2.11443707e-01f, 2.21947595e-01f, 2.73135275e-01f, 2.37620130e-01f, 1.71704873e-01f, 6.40862957e-02f, -5.84496073e-02f, 1.18802741e-01f,
  7.67157972e-02f, -3.83866988e-02f, -4.04695496e-02f, -2.99016126e-02f, -3.84031460e-02f, 3.97538394e-02f, 2.10282862e-01f, 6.74550161e-02f, -9.54557210e-03f, 9.73970536e-03f,
  1.73159897e-01f, 3.08893472e-02f, 3.65038589e-02f, -1.56988930e-02f, -3.23471799e-02f, -2.76557654e-02f, -1.48197249e-01f, -8.36759657e-02f, 8.54084045e-02f, -7.37452582e-02f,
  2.96596903e-02f, -8.82892087e-02f, 5.94728673e-03f, 1.08097911e-01f, -8.63343328e-02f, -1.56911820e-01f, -1.56160504e-01f, -4.99146096e-02f, -2.24556297e-01f, -1.48859233e-01f,
  2.32896313e-01f, 9.09439009e-03f, -1.80274434e-02f, -1.09918796e-01f, 6.19476214e-02f, 5.31729273e-02f, 9.56599563e-02f, -7.21320510e-03f, 1.05607897e-01f, -1.44470990e-01f,
  -2.67058313e-01f, 2.58992434e-01f, 5.76433130e-02f, -9.60461609e-03f, 1.62260458e-01f, 6.01214450e-03f, 7.27341995e-02f, -1.80039614e-01f, -1.57129094e-01f, -1.99618787e-01f,
  4.48559225e-02f, 3.13052908e-02f, 2.04343289e-01f, 1.09866440e-01f, -1.27482131e-01f, -1.05414242e-01f, 2.13335097e-01f, -1.86971982e-03f, 1.44308105e-01f, 5.23140021e-02f,
  1.79902148e-02f, -7.42352307e-02f, 5.80330677e-02f, 9.63662844e-03f, -1.11274742e-01f, 3.17858607e-01f, -5.22116870e-02f, -1.69248715e-01f, 3.10616404e-01f, -2.05274060e-01f,
  1.88043520e-01f, 1.50942672e-02f, 9.33657363e-02f, 5.45609184e-03f, 2.53143907e-01f, -1.00522742e-01f, 3.10650885e-01f, -7.66395330e-02f, 9.91329402e-02f, 1.49862185e-01f,
  2.02595845e-01f, 1.76295359e-02f, 1.05681732e-01f, 1.53297856e-01f, 1.09982312e-01f, -8.73757154e-03f, -6.92557245e-02f, 1.16401136e-01f, -7.28835613e-02f, -1.07692853e-01f,
  -2.14218885e-01f, -1.46290272e-01f, -1.39789701e-01f, -1.88897148e-01f, 3.46984621e-03f, -9.12606642e-02f, -4.93624732e-02f, 2.22464889e-01f, 1.21196508e-01f, 7.64069334e-02f,
  -7.87925720e-02f, 1.74667627e-01f, -4.51351292e-02f, 3.76084112e-02f, -1.66195765e-01f, 4.07479443e-02f, 2.14105204e-01f, -9.47340205e-02f, -1.17468186e-01f, -3.79737131e-02f,
  1.08025253e-01f, -1.04846857e-01f, -2.19658569e-01f, -1.14228286e-01f, 1.31698027e-01f, -3.35850194e-02f, -1.41172290e-01f, 4.25501429e-02f, 2.20545921e-02f, -1.04199320e-01f,
  9.18775350e-02f, 2.12856866e-02f, -1.38025120e-01f, 1.46216959e-01f, -7.11510554e-02f, 2.03787804e-01f, 1.02274609e-03f, -2.15033870e-02f, -1.15336627e-01f, 2.75237799e-01f,
  2.20517710e-01f, -3.86468507e-02f, 1.56679913e-01f, 6.64092079e-02f, 1.41093388e-01f, 5.05088978e-02f, 1.89468712e-02f, 1.82620719e-01f, 2.96039111e-03f, -1.31149188e-01f,
  -4.90053631e-02f, -3.43326889e-02f, 5.55919297e-02f, 3.32496651e-02f, 1.51222553e-02f, 2.62283325e-01f, 1.29489467e-01f, 3.91808823e-02f, 1.62554443e-01f, -9.76406485e-02f,
  -7.12110102e-02f, 1.35514541e-02f, 1.37924269e-01f, -8.55424628e-02f, -3.82111855e-02f, -7.08167776e-02f, 2.01759160e-01f, 5.36540002e-02f, -1.16122693e-01f, 7.40045607e-02f,
  -3.28271091e-02f, 1.92742094e-01f, 1.45610034e-01f, 2.07121924e-01f, 1.18028313e-01f, 1.55523136e-01f, 7.94832110e-02f, -1.71816573e-02f, -2.51667649e-01f, 1.37998359e-02f,
  7.33483210e-02f, 9.96521190e-02f, 4.46585715e-02f, -2.95759618e-01f, 1.94671407e-01f, -2.02527836e-01f, 6.16942644e-02f, 1.81605294e-02f, -8.34758505e-02f, 1.76666766e-01f,
  2.95638479e-02f, 1.48867801e-01f, 2.60804445e-02f, -1.45758763e-01f, 2.03859918e-02f, -2.41561100e-01f, 1.22205738e-03f, 8.54259953e-02f, 1.03277870e-01f, 1.75186619e-01f,
  4.90460359e-02f, -9.17747915e-02f, -7.16017857e-02f, 1.61095947e-01f, 1.06347494e-01f, -3.93045813e-01f, 2.33925402e-01f, -1.82943884e-02f, -2.88359150e-02f, -3.56251933e-02f,
  1.98273271e-01f, 1.45101950e-01f, 4.42490987e-02f, -1.59120142e-01f, 2.23870613e-02f, 1.48922652e-01f, 1.94624588e-02f, 1.32650271e-01f, -1.00544922e-01f, 2.12148860e-01f,
  -1.81361586e-01f, 7.45106339e-02f, 4.51833829e-02f, -1.17835701e-01f, 1.23014133e-02f, 6.67328313e-02f, 1.23702353e-02f, 5.35917655e-02f, 1.60230651e-01f, -1.43759444e-01f,
  1.72822833e-01f, 9.59897190e-02f, -1.61241636e-01f, -1.33359015e-01f, 2.76264638e-01f, 3.80566083e-02f, -8.73630792e-02f, 1.99205011e-01f, 1.12786271e-01f, 1.89134389e-01f,
  6.62463009e-02f, -8.96701217e-02f, 1.29755169e-01f, 1.92611143e-01f, -1.13211691e-01f, -5.49386032e-02f, -5.64656146e-02f, -1.15044467e-01f, 6.19190224e-02f, 1.43525302e-01f,
  1.07364945e-01f, 1.04330473e-01f, 1.44318685e-01f, -2.66834255e-02f, -6.01451471e-02f, 1.53567702e-01f, 1.80474803e-01f, 6.81544095e-02f, 9.06743780e-02f, 1.46588191e-01f,
  -7.09789842e-02f, -1.89815581e-01f, -1.42095447e-01f, 9.99188870e-02f, 6.28982261e-02f, 1.72813416e-01f, -3.98584306e-02f, 9.88845378e-02f, -1.69809923e-01f, -4.45777699e-02f,
  1.48695439e-01f, 4.55778390e-02f, -9.27689523e-02f, -2.20447388e-02f, 2.49677718e-01f, 9.68485326e-02f, -8.42216536e-02f, 4.53726351e-02f, -1.99175589e-02f, 6.93918988e-02f,
  2.80028339e-02f, 9.21897963e-02f, -1.45901710e-01f, -1.82306707e-01f, 4.42887330e-03f, -1.29653007e-01f, 1.31426066e-01f, 2.10767630e-02f, 1.39710560e-01f, 3.97375040e-02f,
  -8.57252032e-02f, 2.59527415e-01f, -6.12390265e-02f, 3.03459823e-01f, -6.43158853e-02f, -2.01465949e-01f, -8.61759558e-02f, 2.14760631e-01f, 9.21174418e-03f, -8.42513517e-02f,
  -1.78937480e-01f, -3.98052894e-02f, 7.98726976e-02f, -4.65323143e-02f, -1.64531738e-01f, 1.49548709e-01f, -3.74145396e-02f, -8.60119686e-02f, -1.64994434e-01f, -2.81459726e-02f,
  -1.98747800e-03f, 2.41189539e-01f, 8.58192984e-03f, 1.72152981e-01f, 1.42001301e-01f, -1.72904402e-01f, 1.33095756e-01f, 2.74919253e-02f, -1.60857826e-01f, 2.31471583e-01f,
  5.35658002e-02f, 1.70253739e-01f, 7.12774172e-02f, 8.10259208e-02f, 3.06520551e-01f, 7.27051347e-02f, 1.06318407e-01f, 6.80562407e-02f, 8.24595317e-02f, 2.94452012e-01f,
  1.58409536e-01f, -2.51403511e-01f, -1.61174864e-01f, 2.36824378e-01f, -1.76796213e-01f, 1.84664086e-01f, 1.05309330e-01f, 2.49265224e-01f, -4.37360443e-02f, 2.43247841e-02f,
  9.02965888e-02f, 1.45007119e-01f, 1.52510494e-01f, 9.43023860e-02f, 1.22046724e-01f, -2.85354517e-02f, 2.16970772e-01f, 3.84011343e-02f, 1.73145339e-01f, 1.00234710e-01f,
  1.46193296e-01f, 2.96954382e-02f, 1.31407127e-01f, -8.76986701e-03f, 2.46370628e-01f, -1.94839135e-01f, -2.05358982e-01f, -1.81621253e-01f, 7.49455169e-02f, 3.44047248e-02f,
  -9.04788673e-02f, -2.57137775e-01f, 1.26967728e-02f, 2.29323596e-01f, 1.40525654e-01f, -2.83765178e-02f, -1.45449221e-01f, 3.39316636e-01f, -1.49256781e-01f, -1.34134606e-01f,
  1.08227320e-01f, -2.60249108e-01f, 2.18046889e-01f, 1.51827276e-01f, 8.28068629e-02f, 1.32495686e-01f, -3.29241231e-02f, 2.60331154e-01f, -3.36271673e-02f, 1.02128707e-01f,
  -6.03211205e-03f, 2.35723674e-01f, -1.30894378e-01f, 6.17666692e-02f, 1.00552790e-01f, 1.78854600e-01f, -8.42809677e-02f, 2.67794192e-01f, -8.07531551e-02f, 5.37532046e-02f,
  5.15609644e-02f, 9.52758547e-03f, 5.90746142e-02f, -8.69967416e-02f, 6.76141679e-02f, 2.02084720e-01f, -1.11621115e-02f, 1.39346525e-01f, 1.45961374e-01f, 1.91895291e-01f,
  5.87360337e-02f, 1.76551327e-01f, -8.79641250e-02f, 9.64495763e-02f, 5.71533330e-02f, 6.98768720e-02f, -6.13967255e-02f, 8.80925134e-02f, -6.69044480e-02f, 6.48919418e-02f,
  -3.59381028e-02f, 3.28969434e-02f, -1.85460374e-02f, 1.27678379e-01f, 2.09140722e-02f, 6.89203739e-02f, 1.13742463e-01f, 1.43739119e-01f, 5.88420145e-02f, 7.79926255e-02f,
  -1.60546139e-01f, 2.81966180e-01f, -8.34356993e-02f, -2.12668166e-01f, -1.84051245e-01f, 2.11847305e-01f, 1.39233395e-02f, -5.93495741e-02f, -1.48541078e-01f, 1.75198451e-01f,
  3.83074284e-02f, -3.28780524e-02f, -2.56082773e-01f, 2.46026084e-01f, -2.34002545e-02f, -3.00302692e-02f, 4.81212214e-02f, -8.38421285e-02f, -1.58037156e-01f, -8.04412812e-02f,
  2.50175178e-01f, 1.54815301e-01f, -4.65099514e-02f, -1.83982328e-01f, 2.55966216e-01f, 5.96688055e-02f, -1.13121077e-01f, 3.87949422e-02f, 1.40004367e-01f, 1.37855634e-01f,
  -4.97788750e-02f, -1.04837894e-01f, -5.04486300e-02f, -1.41099142e-02f, 1.13583170e-01f, 2.56703198e-01f, 3.12374741e-01f, 1.04000434e-01f, 6.41130209e-02f, -2.33835712e-01f,
  1.78113624e-01f, 1.79968417e-01f, 1.67696223e-01f, 2.37721086e-01f, 6.28739446e-02f, -1.07726306e-01f, 1.74564570e-01f, 4.97099198e-02f, 1.62738010e-01f, -1.39836641e-02f,
  2.84878463e-01f, 2.69213747e-02f, 7.49057159e-02f, 2.26941839e-01f, 1.75110519e-01f, 4.17731218e-02f, 1.58118412e-01f, 1.61787510e-01f, 4.38273102e-02f, 3.40410415e-03f,
  4.66438942e-02f, 5.33408932e-02f, -2.40240275e-04f, -1.55944005e-01f, -1.18101865e-01f, -1.24493800e-01f, -2.10083887e-01f, -9.95430499e-02f, -1.56515669e-02f, -5.83719164e-02f,
  -6.26530498e-02f, -1.05040796e-01f, 1.78912818e-01f, 2.26102859e-01f, 1.86372921e-01f, 5.30354381e-02f, 1.28336743e-01f, 1.68946385e-02f, -2.35424325e-01f, 1.20933384e-01f,
  1.77127764e-01f, 7.24231005e-02f, 1.11187147e-02f, -1.24099642e-01f, 1.19228370e-01f, 1.49437599e-03f, 5.49402228e-03f, -1.89025238e-01f, -2.62673199e-02f, -2.89253108e-02f,
  2.96651304e-01f, 8.41037780e-02f, -1.41878679e-01f, 8.68840888e-03f, 2.25097328e-01f, -2.29154825e-01f, -4.04537655e-02f, 4.37002406e-02f, -5.14888167e-02f, 1.58700749e-01f,
  -6.07030233e-03f, 1.12191746e-02f, -1.10284388e-01f, 1.55209437e-01f, 2.62167335e-01f, -2.72852153e-01f, 2.95125872e-01f, -1.25435246e-02f, 2.13154987e-01f, -6.27640560e-02f,
  2.20465258e-01f, 1.04784638e-01f, 1.00809172e-01f, 1.09674539e-02f, 2.19547182e-01f, -1.50889680e-02f, 1.31939426e-01f, 1.69954866e-01f, 5.12906387e-02f, -1.29625067e-01f,
  5.11588976e-02f, 3.17944847e-02f, 6.85937926e-02f, 4.41560075e-02f, 1.10944845e-01f, 4.96770106e-02f, -6.33762106e-02f, 2.35397816e-01f, -7.33692497e-02f, 1.88307896e-01f,
  -1.27099216e-01f, -1.87554006e-02f, -1.44549519e-01f, 9.34146270e-02f, 3.53299677e-01f, 2.30865180e-01f, -6.05021454e-02f, 2.63036112e-03f, -2.63176626e-03f, -7.07382932e-02f,
  3.06280106e-02f, -2.44421232e-02f, -3.18783998e-01f, 1.41014799e-01f, 1.01808514e-02f, -1.54696122e-01f, -7.30681643e-02f, -4.36244458e-02f, 5.77270277e-02f, 2.00156674e-01f,
  -6.07987307e-02f, -2.42892113e-02f, 1.40963390e-01f, -3.80125865e-02f, -3.71802449e-02f, 3.36853623e-01f, 1.67099223e-01f, -3.33621874e-02f, 7.57924318e-02f, 9.12108868e-02f,
  -2.06193309e-02f, -2.13607162e-01f, -1.25781596e-01f, 7.30109289e-02f, 3.63383740e-02f, 2.58191288e-01f, -3.49043193e-03f, 7.49480054e-02f, -1.06069252e-01f, 2.05568656e-01f,
  -1.76406968e-02f, 1.70909464e-01f, -5.51537536e-02f, -3.23018320e-02f, 1.33093715e-01f, 1.54602841e-01f, 1.41247049e-01f, -1.08285740e-01f, -1.12662315e-01f, -1.07647434e-01f,
  9.46090892e-02f, 1.61253195e-02f, -1.62168995e-01f, 6.40540011e-03f, 2.89650708e-02f, -2.99525615e-02f, 7.78601244e-02f, -5.88731002e-03f, -1.76720675e-02f, -8.06852207e-02f,
  -6.57766014e-02f, 2.26084292e-02f, 1.76427588e-01f, 1.00552082e-01f, -3.12990649e-03f, 7.00443611e-02f, -1.84103921e-01f, 2.51662135e-01f, 5.00133969e-02f, -4.12637964e-02f,
  -2.32216343e-01f, 1.15823574e-01f, 1.54118955e-01f, -2.29193911e-01f, 2.48545587e-01f, 1.87395394e-01f, 8.48087445e-02f, -2.05106616e-01f, -2.23355636e-01f, 1.93810582e-01f,
  -1.79353923e-01f, -5.02472371e-02f, 5.51931970e-02f, -2.76846774e-02f, 1.59069225e-01f, 7.52026960e-02f, 1.33081958e-01f, 1.26256660e-01f, -2.93228894e-01f, -3.03994794e-03f,
  3.74227166e-02f, -3.27198356e-02f, -6.02671839e-02f, -5.21848910e-02f, 1.43179327e-01f, -1.23212980e-02f, -4.46674861e-02f, 1.17754854e-01f, 2.49592081e-01f, 5.25524616e-02f,
  3.74833122e-02f, -2.24555895e-01f, 4.23267782e-02f, -2.86471304e-02f, -3.13496053e-01f, 1.47619426e-01f, 5.24786115e-02f, -7.95498788e-02f, 1.93788797e-01f, 3.49063911e-02f,
  -2.69285906e-02f, 2.40951300e-01f, 7.98066705e-02f, 2.71075647e-02f, 1.06960721e-01f, 2.83450216e-01f, 1.92981809e-01f, -4.20182981e-02f, 9.75032225e-02f, 2.14336738e-01f,
  1.42048463e-01f, 2.26917848e-01f, 1.76105082e-01f, 7.33000785e-02f, 3.48106176e-02f, -2.51688976e-02f, -2.55351752e-01f, 1.46459173e-02f, -2.11938247e-01f, -1.19087838e-01f,
  -1.15465097e-01f, -1.35850042e-01f, -3.32888573e-01f, 2.06003323e-01f, 2.81417638e-01f, 1.99348763e-01f, 1.10538714e-01f, 2.45868102e-01f, -2.30543047e-01f, 6.31232336e-02f,
  -2.32192710e-01f, -7.48492107e-02f, 1.02489330e-01f, -1.20763600e-01f, 3.48146744e-02f, 1.22507783e-02f, 8.99010524e-03f, -4.07730639e-02f, -1.31469872e-02f, -4.28790227e-02f,
  -4.87741381e-02f, 4.21500579e-02f, 4.17041779e-02f, -4.71584983e-02f, -5.32202199e-02f, 5.21924309e-02f, 1.49951339e-01f, 2.92392708e-02f, 1.21162862e-01f, 2.59392470e-01f,
  1.29772142e-01f, 8.86149108e-02f, 3.15133148e-05f, -1.23089865e-01f, -1.39661834e-01f, -3.09513006e-02f, 7.10598975e-02f, -1.09354369e-01f, 1.13947310e-01f, 1.33881986e-01f,
  2.03270018e-01f, -7.27703497e-02f, 6.86121881e-02f, 1.31448045e-01f, 1.88909709e-01f, -4.16531824e-02f, 4.97333193e-03f, 2.16006227e-02f, -1.11001886e-01f, 2.06241338e-03f,
  7.01116771e-02f, -1.31709687e-02f, 2.83296313e-02f, -1.24850288e-01f, -3.89076624e-04f, -1.60375789e-01f, -9.35248435e-02f, 9.97122079e-02f, -4.35523543e-06f, 8.72648135e-02f,
  1.66763902e-01f, -1.73048720e-01f, -6.55432232e-03f, -1.50076961e-02f, 6.21756129e-02f, -1.69486418e-01f, -2.09370986e-01f, -8.58310685e-02f, -1.50003821e-01f, -9.03960392e-02f,
  -1.00597203e-01f, -7.10050687e-02f, 2.95620710e-01f, -1.03516981e-01f, -2.32044265e-01f, -1.03839254e-03f, -4.87406701e-02f, 2.30093449e-01f, 1.86575904e-01f, 7.37323612e-02f,
  -2.46680707e-01f, -1.35330707e-01f, -1.23688225e-02f, 1.92510903e-01f, -6.04305416e-02f, 2.32636645e-01f, -1.70494422e-01f, -1.26950189e-01f, -1.32986054e-01f, 3.83825181e-03f,
  1.91515669e-01f, 5.12422137e-02f, 1.06145665e-01f, 7.15312660e-02f, 7.72988722e-02f, -2.26823270e-01f, -2.54020303e-01f, 7.08515570e-02f, 6.98695555e-02f, 1.35372967e-01f,
  -3.22625116e-02f, -1.12735413e-01f, -1.38950674e-02f, -1.48442149e-01f, 1.86437622e-01f, 2.33171910e-01f, -7.12677240e-02f, -1.65826321e-01f, 1.01027943e-01f, 1.28680721e-01f,
  1.37277422e-02f, -6.37402236e-02f, -3.76236364e-02f, -4.47507203e-03f, -1.63439929e-01f, -1.76290125e-01f, 1.04937576e-01f, 2.19181657e-01f, 1.34016871e-01f, -1.29880458e-01f,
  -5.26864007e-02f, 1.68953300e-01f, -2.80270696e-01f, 7.53366873e-02f, 2.35919302e-04f, 1.74493417e-01f, -1.76658005e-01f, -1.67620763e-01f, 1.98008209e-01f, 7.18903393e-02f,
  -9.05297101e-02f, -2.49178782e-01f, -1.78591818e-01f, -5.89513853e-02f, 2.27355257e-01f, -1.18493676e-01f, 2.00664714e-01f, 4.68617305e-02f, -3.12198102e-01f, 4.71698135e-01f,
  -9.02542770e-02f, -1.06840655e-01f, -2.10019708e-01f, 5.19498959e-02f, -7.52609922e-03f, 7.65253305e-02f, -1.29727945e-01f, 4.29120213e-02f, 2.28081942e-02f, 6.77808225e-02f,
  2.94426292e-01f, 2.08082154e-01f, -1.40085161e-01f, -2.20223039e-01f, 3.29249799e-01f, -7.82902818e-03f, 1.57644600e-01f, 7.32272491e-02f, -6.29686401e-04f, 1.75891668e-02f,
  -2.06626626e-03f, 3.42865437e-01f, 9.70226675e-02f, 1.07097112e-01f, 1.31898180e-01f, 1.47183239e-01f, 2.27379903e-01f, -1.11435860e-01f, 9.33115929e-02f, 1.88773766e-01f,
  -1.05258767e-02f, -5.85911125e-02f, 1.93355620e-01f, 1.04334496e-01f, 7.00772703e-02f, 1.54616758e-01f, 1.31586924e-01f, 2.26061255e-01f, 1.43991664e-01f, -1.78635418e-01f,
  1.70771196e-01f, 3.76314931e-02f, 5.84181398e-03f, -8.43508765e-02f, 1.89824641e-01f, -3.84977572e-02f, -5.64642437e-02f, -9.50499624e-03f, -2.24816486e-01f, 1.76201820e-01f,
  -2.61312813e-01f, -1.65950119e-01f, 2.81064175e-02f, 7.62494802e-02f, -5.73738366e-02f, 1.19499333e-01f, 4.31647487e-02f, 6.45445585e-02f, 1.38315158e-02f, 1.80339307e-01f,
  -1.08337022e-01f, 1.24109201e-01f, -1.59644589e-01f, 2.14963704e-01f, 2.08039600e-02f, -1.08895265e-01f, -2.33438864e-01f, -4.86375727e-02f, 1.64043903e-01f, 1.69943869e-02f,
  -1.82399660e-01f, -9.77262408e-02f, -3.23900655e-02f, -7.05596283e-02f, 3.18881959e-01f, 1.24266848e-01f, -1.29910380e-01f, 7.09793121e-02f, 2.40201160e-01f, -7.47402906e-02f,
  2.07651466e-01f, 4.28150110e-02f, -9.38954577e-02f, 2.38633692e-01f, 1.84233859e-01f, 4.66769412e-02f, -1.40818670e-01f, 9.64424163e-02f, 1.55877993e-01f, 1.84490919e-01f,
  3.14769417e-01f, -1.05727911e-01f, 1.80616185e-01f, 1.17040329e-01f, 5.43933921e-02f, 1.72642749e-02f, 2.09879428e-02f, 7.17349127e-02f, 7.59830996e-02f, 4.37523611e-02f,
  1.38950258e-01f, 8.17296952e-02f, -5.16507998e-02f, 5.63698933e-02f, 9.43946838e-02f, 1.08718298e-01f, -8.69794283e-03f, -6.98178411e-02f, -6.39215708e-02f, 4.73987684e-02f,
  1.18071906e-01f, 1.31498592e-03f, 8.85696113e-02f, -8.60549361e-02f, 1.23306960e-01f, 1.90504089e-01f, -1.08832538e-01f, -2.52892792e-01f, -1.72956765e-01f, -8.58770013e-02f,
  -1.53193802e-01f, -1.66207120e-01f, -4.68940288e-02f, 1.96725186e-02f, 2.00010408e-02f, -2.32493669e-01f, 1.27566412e-01f, -4.02819291e-02f, -1.02961555e-01f, 8.39476511e-02f,
  1.79207042e-01f, 2.49546215e-01f, -1.53698951e-01f, 1.67367637e-01f, 1.32247165e-01f, 3.26345444e-01f, 1.55975521e-01f, 8.27561021e-02f, -8.37802365e-02f, -8.26396868e-02f,
  3.83875594e-02f, 2.47430518e-01f, 2.46417597e-02f, 2.45563045e-01f, 1.06383242e-01f, 2.41644233e-02f, 2.35209495e-01f, -7.09140822e-02f, -1.21614367e-01f, -9.85431075e-02f,
  1.87040403e-01f, 8.06587264e-02f, 6.34250697e-03f, 1.87487945e-01f, -1.69144079e-01f, -1.15450338e-01f, -8.15641950e-04f, 2.20409617e-01f, 3.61092351e-02f, 1.54619053e-01f,
  9.38647240e-02f, 1.53692424e-01f, -3.67300622e-02f, 8.62055644e-03f, 1.33970469e-01f, 1.83229402e-01f, 5.72743341e-02f, 2.30925754e-02f, 1.73103616e-01f, -5.45819476e-02f,
  1.99182346e-01f, 5.29294275e-03f, 2.66959239e-02f, 1.39142856e-01f, -9.03345048e-02f, -2.06240401e-01f, 2.75868684e-01f, 3.37732993e-02f, -9.82654095e-02f, -4.18813266e-02f,
  -1.86320215e-01f, 8.17488357e-02f, -6.28010854e-02f, -1.39772832e-01f, 1.33501440e-01f, -1.52663365e-01f, 1.70081705e-01f, -1.00797050e-01f, -1.21432543e-01f, 3.29262644e-01f,
  1.36963159e-01f, -2.88279712e-01f, -7.76567534e-02f, 2.85149336e-01f, -8.05048048e-02f, 1.49703041e-01f, 5.21890670e-02f, 2.01445103e-01f, 2.54805595e-01f, 5.40682562e-02f,
  1.39409095e-01f, 1.72100291e-01f, -4.70294710e-03f, 5.67730330e-02f, 9.87329781e-02f, 2.39662826e-01f, 1.44796938e-01f, -2.74090488e-02f, 1.94634005e-01f, -4.62518707e-02f,
  2.48641193e-01f, -1.64984986e-01f, 3.55113633e-02f, 5.42061478e-02f, 2.95805931e-01f, -1.91286191e-01f, -6.10022955e-02f, 1.52188854e-03f, -1.79208487e-01f, 3.57883424e-02f,
  3.04764379e-02f, 1.47300243e-01f, 1.22272402e-01f, 7.24939927e-02f, -9.98816825e-03f, 3.33154857e-01f, -1.44898370e-01f, -1.48419887e-01f, 5.87674454e-02f, 6.31542206e-02f,
  -7.98046440e-02f, 6.31391024e-03f, 7.83956721e-02f, -1.39473602e-01f, -1.28565237e-01f, -8.32031481e-03f, -1.29895762e-01f, 1.03677042e-01f, 1.80909708e-01f, 5.90465404e-02f,
  -6.91069812e-02f, 4.83538164e-03f, 1.43210232e-01f, 2.13569067e-02f, -1.31578699e-01f, -1.08174279e-01f, 1.52903065e-01f, 1.96472377e-01f, -2.53840804e-01f, -3.75193246e-02f,
  -2.12851048e-01f, 7.47275427e-02f, -1.71943307e-01f, -1.71136051e-01f, 1.13778554e-01f, -2.33503014e-01f, -6.08111955e-02f, -3.24534699e-02f, 2.53228128e-01f, 1.10910246e-02f,
  1.45744920e-01f, 1.27058834e-01f, -1.02471020e-02f, -1.85822304e-02f, 2.50479043e-01f, 9.24409404e-02f, -1.52260259e-01f, 2.35286295e-01f, 1.43958792e-01f, 1.90676719e-01f,
  -1.29131004e-01f, 2.56085187e-01f, -1.03410929e-01f, -4.75888699e-03f, 4.46603559e-02f, 2.14151084e-01f, 2.23332673e-01f, 3.78920101e-02f, 2.87741702e-02f, -3.04940566e-02f,
  -4.04406004e-02f, 3.22499812e-01f, -2.04585314e-01f, 1.55552089e-01f, -2.02066109e-01f, 1.87442690e-01f, 2.09438372e-02f, 2.11228862e-01f, 7.74545446e-02f, 4.34392765e-02f,
  -7.76648521e-02f, -1.00434951e-01f, 1.29112378e-01f, 1.37478545e-01f, -8.82466044e-03f, 1.17398940e-01f, 1.04578927e-01f, -7.16854632e-02f, -7.94927254e-02f, 1.99969225e-02f,
  9.89794033e-04f, -5.06204069e-02f, 1.21402368e-01f, -1.71358377e-01f, 1.05106048e-02f, -1.39196143e-01f, -6.23568520e-02f, -1.69833973e-01f, 1.45567641e-01f, -1.43066868e-01f,
  -1.76905230e-01f, 4.91345152e-02f, 1.29308283e-01f, -1.00701451e-02f, -1.46969005e-01f, 3.11627060e-01f, 5.18892296e-02f, -7.78885335e-02f, 1.96589291e-01f, 4.53110151e-02f,
  1.02444142e-02f, 3.88068259e-02f, 2.51474768e-01f, 3.25484931e-01f, -8.71094391e-02f, 9.05357525e-02f, 1.57873839e-01f, 1.48811355e-01f, -1.02628455e-01f, 2.55202770e-01f,
  -1.34613752e-01f, -2.57088363e-01f, -8.62686038e-02f, 1.35750309e-01f, 7.47187287e-02f, 3.11339289e-01f, 1.47515461e-01f, 1.71055615e-01f, 2.94877440e-01f, -6.04067370e-02f,
  -1.32027179e-01f, -5.85266165e-02f, 1.26858205e-01f, 9.52710956e-02f, 4.30559665e-02f, 2.36382589e-01f, 2.42061436e-01f, -3.33317220e-02f, 1.38420671e-01f, 1.41144931e-01f,
  -1.74463198e-01f, 1.24800988e-01f, 2.90428251e-01f, 8.79071951e-02f, 3.88739142e-03f, -5.34387585e-03f, -5.31743243e-02f, 8.19178969e-02f, 5.82325943e-02f, 2.16868296e-02f,
  6.93715066e-02f, -1.01723336e-01f, -7.86782950e-02f, -3.31402421e-02f, 9.88810137e-02f, 1.09572336e-01f, 9.30704400e-02f, -4.74059284e-02f, -3.44325125e-01f, 2.57513020e-02f,
  -1.36119053e-01f, -5.39716892e-02f, 1.17740721e-01f, -6.60591274e-02f, -2.87036121e-01f, -4.55974750e-02f, -1.93765406e-02f, 7.45555907e-02f, -1.64115012e-01f, 2.47823536e-01f,
  -1.25912398e-01f, -8.86395201e-02f, -3.40592653e-01f, -1.23685403e-02f, 2.11864173e-01f, -1.37112901e-01f, 1.85927585e-01f, 2.23259255e-01f, -3.54455188e-02f, -1.39234290e-01f,
  -4.36222274e-03f, -1.93117142e-01f, -1.16086416e-02f, 8.81224126e-02f, 2.29160991e-02f, -2.10782498e-01f, -2.12642595e-01f, 5.84709924e-03f, -2.73095910e-02f, 6.39402643e-02f,
  9.51775610e-02f, 2.85437256e-01f, 1.88001156e-01f, 3.81947942e-02f, 2.05491539e-02f, -8.03516582e-02f, 2.21737102e-02f, 1.14514746e-01f, 1.52053446e-01f, 6.88939840e-02f,
  1.36422694e-01f, 4.42192182e-02f, 1.72093868e-01f, 1.67472169e-01f, -4.11244184e-02f, 5.34089953e-02f, 2.21270502e-01f, -1.85117185e-01f, -7.02667460e-02f, -2.30877340e-01f,
  -6.28829524e-02f, 9.64834020e-02f, 4.81623113e-02f, -2.18927749e-02f, -4.93996516e-02f, 1.74100205e-01f, -2.00907305e-01f, 4.60334830e-02f, -4.04442787e-01f, -1.51404053e-01f,
  3.71365882e-02f, -2.32022971e-01f, -1.61308751e-01f, -2.63418674e-01f, 2.08684877e-02f, -2.06152424e-02f, 1.79748181e-02f, 2.97546368e-02f, -1.18302904e-01f, 4.00792286e-02f,
  1.18196659e-01f, 7.36551210e-02f, 9.32887718e-02f, 2.96943367e-01f, 1.43090919e-01f, 6.50794879e-02f, 2.52451617e-02f, 6.88469410e-02f, 8.71506110e-02f, 2.57594623e-02f,
  -1.83736905e-02f, -2.14266181e-01f, 1.41198337e-01f, -3.30258340e-01f, -2.26542011e-01f, 6.79275114e-03f, -1.41353756e-01f, -3.09508853e-02f, 4.39205110e-01f, 1.03763796e-01f,
  1.27430022e-01f, -2.25060016e-01f, 6.92794546e-02f, -2.33011305e-01f, -4.27983887e-02f, 2.05792129e-01f, 1.11447774e-01f, 5.42214997e-02f, 8.92273411e-02f, -1.83369830e-01f,
  -6.79178014e-02f, 2.86189675e-01f, 2.57775664e-01f, -1.71883225e-01f, 1.88296914e-01f, 2.12403126e-02f, -3.83767905e-03f, -2.31285244e-01f, 6.41692951e-02f, 1.42238304e-01f,
  1.73489712e-02f, -1.05935596e-01f, 3.85894403e-02f, -3.53974998e-02f, -3.10209347e-03f, -1.11400850e-01f, 1.12166673e-01f, 1.36369869e-01f, 1.29272908e-01f, -6.31231368e-02f,
  -2.12966688e-02f, -2.79888362e-02f, -1.88701466e-01f, 4.11790982e-02f, 1.22743361e-01f, -2.32211187e-01f, -1.26382291e-01f, -2.42242441e-01f, 1.32937700e-01f, -8.20677057e-02f,
  -3.81740704e-02f, 8.27056766e-02f, -3.88566583e-01f, 5.80560565e-02f, 4.19499576e-02f, -1.10534523e-02f, 7.04957619e-02f, 1.28919795e-01f, -6.09177388e-02f, 2.20276639e-01f,
  -6.42591044e-02f, -1.39576763e-01f, 2.41963506e-01f, -4.84632924e-02f, 3.06296945e-02f, -9.24272686e-02f, 5.26671112e-02f, -3.66866924e-02f, -7.30830058e-03f, -5.69427982e-02f,
  -1.21935988e-02f, 2.24636033e-01f, -1.44800588e-01f, -2.70891041e-01f, -9.08662826e-02f, 6.58932030e-02f, 1.59384176e-01f, 5.18783964e-02f, -8.29729661e-02f, 3.37669164e-01f,
  1.19771324e-01f, 7.13297725e-02f, 2.41793040e-02f, -1.50141388e-01f, 7.84762949e-02f, 3.98882432e-03f, 2.99636364e-01f, -1.52467653e-01f, 1.95033908e-01f, 3.91789638e-02f,
  -6.62959218e-02f, -8.45824033e-02f, 3.42214592e-02f, 1.50399148e-01f, 1.11036338e-01f, -3.55814248e-02f, -1.06056385e-01f, 1.09332636e-01f, 4.30940688e-02f, 4.86785769e-02f,
  -8.09813365e-02f, 2.46154629e-02f, 9.62226614e-02f, -4.36525792e-02f, 1.67533338e-01f, 7.41586983e-02f, 2.16305658e-01f, 1.26483828e-01f, -1.73030823e-01f, 1.52749196e-01f,
  3.49491477e-01f, 3.86012793e-02f, -1.23356037e-01f, -1.50469378e-01f, 8.94082859e-02f, 3.76578490e-03f, 2.84308285e-01f, 2.49478011e-03f, -1.46608323e-01f, 3.09831277e-02f,
  3.32608819e-01f, -2.30814070e-01f, 5.95663907e-03f, 3.15001220e-01f, 1.73964314e-02f, -2.39937734e-02f, -8.90372843e-02f, 2.61080533e-01f, -1.44295499e-01f, -3.62054408e-02f,
  6.43821508e-02f, -1.33041069e-02f, 3.76014262e-01f, 7.86960274e-02f, 2.76421756e-01f, 1.42412230e-01f, 6.07055165e-02f, -1.39194997e-02f, 1.07871346e-01f, 6.46609673e-03f,
  1.99401155e-01f, -6.58254251e-02f, 5.70452809e-02f, -3.01829148e-02f, 1.01460174e-01f, -9.80526581e-02f, 2.39178434e-01f, 2.20797509e-01f, 2.23603189e-01f, -4.15764563e-02f,
  8.38856176e-02f, -1.58295020e-01f, -1.98407978e-01f, 5.89302555e-03f, 1.81057513e-01f, 1.08091235e-01f, 1.97279230e-01f, -3.56299034e-03f, -7.72007331e-02f, 1.56013235e-01f,
  -2.39782757e-03f, -1.56700149e-01f, 1.02070011e-02f, 2.11946890e-02f, -4.77558561e-02f, 1.82519536e-02f, 1.85036168e-01f, -6.65371865e-02f, 4.86679748e-03f, 9.73782316e-02f,
  -4.25689854e-02f, 6.11910559e-02f, 8.17663521e-02f, -2.71764666e-01f, -1.04568429e-01f, -1.49445996e-01f, 1.46270156e-01f, -2.52360199e-02f, -3.54333743e-02f, -5.22271805e-02f,
  -2.79465497e-01f, 4.47940342e-02f, 1.95925999e-02f, 9.77421999e-02f, -1.20122470e-01f, 2.21039519e-01f, -1.37932077e-01f, 2.35069275e-01f, -1.10308617e-01f, -1.88706458e-01f,
  2.25284949e-01f, 7.52805397e-02f, -3.91955301e-02f, 5.46806417e-02f, 7.42622167e-02f, -1.45942658e-01f, -1.08047560e-01f, -1.00469947e-01f, -1.14518456e-01f, 2.28695691e-01f,
  -1.92495674e-01f, -2.23839432e-01f, -1.46820694e-01f, 2.31101178e-02f, 9.42813456e-02f, -3.67708467e-02f, 8.50814581e-02f, 3.21690381e-01f, 1.56600252e-01f, 3.03833224e-02f,
  -1.06164522e-01f, -6.91813976e-02f, 7.21005648e-02f, -3.36447135e-02f, 1.61424741e-01f, -7.42927939e-02f, 2.73600906e-01f, -1.67378739e-01f, 1.51285246e-01f, 2.34209076e-02f,
  -4.85950569e-03f, 1.07098676e-01f, 1.48956195e-01f, 1.07003622e-01f, 1.26231611e-01f, -3.42042185e-02f, 6.27617911e-02f, 1.13621019e-01f, 9.33040977e-02f, -9.94459689e-02f,
  4.74791182e-03f, 1.21181577e-01f, 7.96117354e-03f, 6.65678829e-02f, 3.96302938e-02f, 8.25220644e-02f, 3.23545821e-02f, 1.80931747e-01f, 4.46731001e-02f, 9.24098119e-02f,
  -8.24631900e-02f, 1.18005695e-02f, -1.38275936e-01f, 1.52549252e-01f, 1.41042918e-01f, 1.64206609e-01f, -9.13445130e-02f, 7.38559738e-02f, 4.06335071e-02f, -1.21487796e-01f,
  1.04919694e-01f, 1.66680858e-01f, 6.46300148e-03f, 4.26865071e-02f, -3.89274879e-04f, -7.04107946e-03f, -6.03060350e-02f, -9.25567299e-02f, 5.00156209e-02f, 7.89712891e-02f,
  2.22353205e-01f, 2.08984226e-01f, 2.26305574e-01f, 3.21477130e-02f, -1.95251256e-01f, 1.46713242e-01f, 3.04472268e-01f, 1.17018923e-01f, -1.75657034e-01f, 9.00389254e-02f,
  7.96387158e-03f, -8.22201744e-02f, -9.12883878e-02f, 1.66980416e-01f, 1.01968177e-01f, 2.66035318e-01f, 1.80714250e-01f, -9.04105231e-02f, -5.94112948e-02f, 6.77852035e-02f,
  -9.46368575e-02f, 1.00355506e-01f, -5.54496571e-02f, -6.63676113e-02f, -1.98383145e-02f, 1.77406877e-01f, 5.80360852e-02f, 2.56168783e-01f, 2.68070698e-01f, 1.20967440e-01f,
  7.73781240e-02f, 1.84985995e-01f, 1.26086965e-01f, 1.70963302e-01f, -7.19552040e-02f, 1.72216222e-01f, -3.58727053e-02f, 2.34806761e-02f, -8.82332493e-03f, -3.76605392e-02f,
  4.28670086e-02f, -8.85435045e-02f, -1.77886620e-01f, 3.50196287e-02f, 4.43622842e-02f, -5.14898486e-02f, -1.23735793e-01f, -1.62255690e-01f, 9.05610844e-02f, 1.78091168e-01f,
  9.55435559e-02f, 9.62669924e-02f, -5.90489171e-02f, 1.66348964e-01f, -1.79558188e-01f, 7.43588731e-02f, -1.27049880e-02f, -1.71012908e-01f, 2.93236107e-01f, -1.27732661e-02f,
  -9.05306041e-02f, -1.01520494e-02f, 2.56405592e-01f, -4.19686958e-02f, 6.61525279e-02f, -9.70938131e-02f, -4.79442030e-02f, 1.07290804e-01f, -1.08194992e-01f, -1.12585604e-01f,
  2.07590207e-01f, 1.20297402e-01f, -1.22101828e-01f, -5.46391383e-02f, -1.67113185e-01f, -5.15989736e-02f, -5.47674708e-02f, 1.96833357e-01f, 1.17575377e-01f, 4.95957211e-02f,
  -1.23462744e-01f, 2.36591715e-02f, 1.35886848e-01f, -1.06341250e-01f, 6.74327463e-02f, 1.58906996e-01f, 2.32064165e-02f, -1.11141428e-01f, 2.19175279e-01f, 1.58974409e-01f,
  5.71031943e-02f, 1.09100878e-01f, -6.49064407e-02f, -1.88536927e-01f, -1.47873983e-01f, -4.67233285e-02f, -2.04766408e-01f, -2.71150291e-01f, -1.83683231e-01f, -1.24752279e-02f,
  -1.49581447e-01f, -1.24123901e-01f, -2.75903583e-01f, 4.70334776e-02f, -1.00976497e-01f, -7.20970100e-03f, 8.44083577e-02f, 7.61716142e-02f, -2.21018821e-01f, -1.97243523e-02f,
  1.02316692e-01f, -1.25931412e-01f, 7.05248192e-02f, -2.10176170e-01f, -1.87366620e-01f, -2.15777472e-01f, 1.00023575e-01f, -6.20961599e-02f, 3.21115583e-01f, -1.27275720e-01f,
  -2.74679452e-01f, 3.66976887e-01f, 2.05501355e-02f, 4.82208328e-03f, -1.38289919e-02f, -3.42891105e-02f, -1.22291625e-01f, -7.01817274e-02f, -5.06020933e-02f, 1.97930321e-01f,
  -1.22336015e-01f, 8.93426165e-02f, -2.30734363e-01f, -2.14346428e-03f, -1.99462790e-02f, -2.68742070e-02f, 9.83726308e-02f, 2.09884066e-02f, 9.13109854e-02f, -5.66023588e-02f,
  5.84800169e-02f, 1.02543738e-02f, -2.46400192e-01f, 2.25563943e-02f, 3.70078161e-02f, 1.81615353e-01f, 7.53711984e-02f, 1.13580503e-01f, 8.41041058e-02f, -2.59146899e-01f,
  5.79494201e-02f, 7.45221674e-02f, -4.45574373e-02f, -2.48181239e-01f, -4.95013483e-02f, -8.62345397e-02f, -2.30588838e-02f, 1.62314475e-01f, 9.59895030e-02f, 4.59070168e-02f,
  -1.91960372e-02f, -1.27591327e-01f, 1.55201759e-02f, 6.81508258e-02f, 7.16900900e-02f, 3.23264711e-02f, 6.98969886e-02f, 1.53759345e-01f, -1.41072035e-01f, -9.43727791e-02f,
  5.45990728e-02f, 1.48990959e-01f, -7.11323172e-02f, -1.16705053e-01f, 8.46719816e-02f, 5.82617484e-02f, -6.29417151e-02f, -1.34654984e-01f, -1.52325138e-01f, 7.57981837e-02f,
  2.45450199e-01f, 6.70088828e-02f, -2.52738851e-03f, 1.96270272e-01f, -1.70787960e-01f, 2.24928603e-01f, 9.31977574e-03f, 7.90152177e-02f, -1.10429160e-01f, -1.33323759e-01f,
  9.50732604e-02f, 4.37784716e-02f, -1.07558500e-02f, 4.31243330e-02f, 1.24871567e-01f, 6.02925271e-02f, 1.28533602e-01f, 1.17935904e-03f, 1.57227255e-02f, 1.47855673e-02f,
  1.49208859e-01f, 4.05818864e-05f, 1.96062416e-01f, 1.66904237e-02f, -2.08724965e-03f, -9.43991095e-02f, 1.92396920e-02f, 2.65531638e-03f, -3.74207878e-03f, -2.13979080e-01f,
  8.57059881e-02f, -1.96831122e-01f, 7.51613900e-02f, -1.15577862e-01f, 5.41506670e-02f, -1.23699196e-02f, 2.38498181e-01f, 4.55806330e-02f, -9.90975052e-02f, 1.82846785e-01f,
  1.46274656e-01f, 1.84709653e-01f, 1.24210358e-01f, 1.81456842e-02f, -7.36729009e-03f, 2.11399332e-01f, -1.35807097e-01f, 1.21439904e-01f, -6.45655245e-02f, -7.01459870e-02f,
  1.65140703e-02f, 9.76284072e-02f, 1.01417974e-01f, 5.33102229e-02f, 1.70232177e-01f, -1.00869797e-01f, -4.30992059e-02f, -8.30132514e-02f, 1.46455005e-01f, -1.40990213e-01f,
  2.10745752e-01f, -7.67186806e-02f, 8.68457630e-02f, 1.85088664e-01f, 1.78511992e-01f, 8.81008804e-02f, 1.13423198e-01f, -1.17123723e-01f, 9.53899100e-02f, 7.64976665e-02f,
  7.07766786e-02f, 1.38610721e-01f, 2.09594294e-01f, -3.01921427e-01f, 1.39301330e-01f, -4.77747917e-02f, -7.60669112e-02f, 9.07483175e-02f, -1.08852126e-02f, 6.56599402e-02f,
  2.15000764e-01f, 1.09794252e-01f, -6.26745168e-03f, 1.64691824e-02f, 1.68264523e-01f, -2.18773186e-01f, -4.90815639e-02f, -1.28846258e-01f, -9.73256752e-02f, -1.01264261e-01f,
  -1.47111714e-02f, -6.29302561e-02f, 3.32420990e-02f, 1.97373912e-01f, -1.37253879e-02f, -2.41133258e-01f, -5.66188246e-02f, 1.57848656e-01f, 1.17646508e-01f, -4.05639745e-02f,
  4.66276631e-02f, 1.66526482e-01f, -5.21487519e-02f, -3.90756018e-02f, -6.06596917e-02f, 3.02993376e-02f, -6.44817203e-03f, -1.07353389e-01f, 1.54357282e-02f, 1.71128452e-01f,
  -1.54442983e-02f, -5.68952039e-02f, -3.77445780e-02f, -5.82812540e-02f, -8.31993148e-02f, -4.67838943e-02f, -3.01381834e-02f, -3.85263842e-03f, 9.90026891e-02f, -1.89790502e-01f,
  6.52452325e-03f, 1.23410165e-01f, 2.51095086e-01f, -3.88185717e-02f, 7.94459730e-02f, 5.50889298e-02f, 7.97433108e-02f, -2.40945891e-01f, -3.35030966e-02f, 5.91109581e-02f,
  2.55868584e-01f, -9.36697349e-02f, 3.40737849e-01f, 2.28772730e-01f, -1.09775886e-01f, 1.15106232e-01f, 1.29414320e-01f, 8.47524256e-02f, -2.18423814e-01f, 1.57915130e-01f,
  -6.01754114e-02f, 1.52242273e-01f, -1.33892342e-01f, -2.66666822e-02f, 1.77495643e-01f, 5.42471856e-02f, -1.75080553e-01f, 5.04722558e-02f, 1.54746696e-01f, 8.74911323e-02f,
  2.13512331e-02f, 6.47606999e-02f, -3.58548313e-02f, -2.88646102e-01f, -1.78614646e-01f, 1.58877596e-01f, 1.92565918e-01f, 1.82208925e-01f, -2.73552656e-01f, 1.52861834e-01f,
  -1.38761178e-01f, -3.93180177e-02f, 1.24795750e-01f, 1.02694362e-01f, 8.30960721e-02f, -8.06118250e-02f, 9.35485363e-02f, 5.18438034e-03f, -1.47411630e-01f, -8.15370958e-03f,
  1.12615712e-01f, -1.83004245e-01f, 4.77637053e-02f, 1.72652438e-01f, 5.66902012e-02f, -1.41175553e-01f, -4.08995114e-02f, -1.62949175e-01f, 1.02990242e-02f, -1.34770080e-01f,
  1.91115081e-01f, -3.65679637e-02f, -4.47641127e-02f, -1.40864491e-01f, 1.43585682e-01f, 2.18106940e-01f, -3.06686550e-01f, -1.36926487e-01f, -5.92686944e-02f, 2.48127982e-01f,
  -7.00825602e-02f, -2.90468894e-02f, -1.28639668e-01f, 1.56974003e-01f, -6.13354966e-02f, -2.94456370e-02f, 5.61333355e-03f, -2.73883343e-01f, 1.61170408e-01f, 3.77556384e-02f,
  1.10053504e-02f, -1.91093072e-01f, 7.22555146e-02f, 1.65964793e-02f, -1.36578307e-01f, 1.68054342e-01f, 1.51310027e-01f, 5.00343107e-02f, -1.72611311e-01f, 4.37937453e-02f,
  2.14302778e-01f, 5.52377813e-02f, -2.70703416e-02f, 6.12198608e-03f, -2.13878557e-01f, 3.26817259e-02f, -1.21785849e-01f, 1.31702378e-01f, 2.53531020e-02f, 6.66518062e-02f,
  2.60920431e-02f, 1.29189953e-01f, -9.86170992e-02f, 3.75997834e-02f, 1.00132294e-01f, 2.26821065e-01f, -2.68236995e-01f, 4.76777069e-02f, 1.70328543e-02f, 1.87297851e-01f,
  -1.65790170e-01f, -1.93048507e-01f, -1.05176926e-01f, -5.49329631e-02f, -1.33203883e-02f, -5.07321283e-02f, 2.50477511e-02f, -1.15984090e-01f, -1.30848438e-01f, 4.26144376e-02f,
  6.67149499e-02f, 3.05436850e-02f, -1.62279248e-01f, -1.28345117e-01f, -1.90827712e-01f, 2.26679951e-01f, 1.13816120e-01f, 3.78824547e-02f, 4.19174396e-02f, -5.31064980e-02f,
  -1.71010688e-01f, 1.26408637e-01f, 2.83861548e-01f, 1.38625935e-01f, -2.34007966e-02f, -6.12689592e-02f, 9.07970294e-02f, -2.32509553e-01f, 2.24560022e-01f, 1.48964882e-01f,
  5.04904017e-02f, -7.82205462e-02f, 7.16835111e-02f, 1.97147746e-02f, -9.78653282e-02f, -1.49751469e-01f, 1.64296210e-01f, -1.64530799e-02f, -4.80833761e-02f, 1.73683628e-01f,
  1.46837667e-01f, 1.67501140e-02f, -2.26589784e-01f, 3.01744729e-01f, 2.87146032e-01f, 3.29903327e-02f, 3.31529900e-02f, 5.15462570e-02f, 4.08247225e-02f, -2.43307099e-01f,
  -2.28072897e-01f, 1.07058980e-01f, 1.37168661e-01f, 1.50449201e-01f, -6.31481931e-02f, 9.06298533e-02f, -6.65334240e-02f, 1.86103225e-01f, -3.26131493e-01f, 5.53378165e-02f,
  -4.17339914e-02f, 4.74005081e-02f, 1.01268902e-01f, 1.66052938e-01f, -2.33013496e-01f, -5.29995896e-02f, -6.89990968e-02f, 5.46606034e-02f, 1.54089496e-01f, 1.46173194e-01f,
  -7.39714950e-02f, 1.48547217e-02f, 8.77543017e-02f, 1.02836303e-01f, -1.06476434e-01f, -6.94371574e-03f, 4.24417704e-02f, 1.19654745e-01f, -2.04512283e-01f, -1.38737813e-01f,
  4.72153164e-02f, -3.18132192e-02f, -1.26889244e-01f, -1.27009973e-01f, 9.14045200e-02f, 1.05165623e-01f, -1.52792856e-02f, -1.96738049e-01f, 2.18743965e-01f, 1.48776054e-01f,
  2.29068980e-01f, -2.19933525e-01f, -1.90434009e-02f, 2.33942837e-01f, -1.43683016e-01f, -2.36545037e-02f, -1.97872496e-03f, 6.03332408e-02f, 9.90049690e-02f, -1.40567631e-01f,
  1.39726430e-01f, -2.21728563e-01f, 1.31953910e-01f, -1.34225637e-01f, 1.91060454e-01f, -3.74809913e-02f, 1.53044909e-01f, 3.73328328e-02f, -3.41756456e-02f, -1.33400753e-01f,
  2.50299603e-01f, -2.77621567e-01f, 9.41805765e-02f, 2.11830512e-01f, 5.06807752e-02f, -1.59138918e-01f, 2.51600564e-01f, 3.11334617e-02f, 9.50166509e-02f, 9.75243375e-02f,
  2.34669849e-01f, -2.89168149e-01f, 3.08289789e-02f, -1.20962135e-01f, 1.77508190e-01f, -5.64383157e-02f, 1.34599239e-01f, 1.54919669e-01f, 1.77091211e-01f, -7.24049285e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -5.04500372e-03f, -2.53527071e-02f, -7.48707214e-03f, -2.13357760e-03f, 9.81792212e-02f, 8.25642943e-02f, 4.38413247e-02f, 9.94522497e-02f, 1.15697742e-01f, 1.57174598e-02f,
  1.98689044e-01f, 1.04393177e-01f, 1.27496824e-01f, 1.34311810e-01f, 1.74873188e-01f, 1.02284603e-01f, 1.31928205e-01f, 8.62703770e-02f, -3.77116315e-02f, 8.97561312e-02f,
  -1.58184413e-02f, 7.10596815e-02f, 1.12436637e-01f, 9.61086228e-02f, 1.16339259e-01f, 1.33558095e-01f, -4.08539958e-02f, 5.48943616e-02f, 8.34110305e-02f, 1.10897973e-01f,
  1.07932501e-01f, 1.39870137e-01f, -7.07032084e-02f, -7.58453980e-02f, -4.80914339e-02f, -3.22993062e-02f, -5.04688881e-02f, 1.05367983e-02f, -3.76041122e-02f, 1.50039166e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.61391397e-03f, 1.42130964e-02f, 9.64875519e-02f, -1.22451730e-01f, 3.40039842e-02f, 9.32608843e-02f, -8.97930712e-02f, 2.41194647e-02f, -1.50771573e-01f, -1.54601187e-01f,
  -1.97359957e-02f, 4.05173339e-02f, -4.89885323e-02f, 1.67983994e-01f, 7.71469697e-02f, -1.67784110e-01f, 1.69747710e-01f, 1.33120846e-02f, 1.78410381e-01f, -1.28231734e-01f,
  5.84210232e-02f, 9.32128504e-02f, -8.56279805e-02f, 9.70710069e-02f, 1.86261609e-01f, -1.72327369e-01f, 9.45699587e-02f, -1.86488986e-01f, 4.00217138e-02f, -3.29905957e-01f,
  4.62823100e-02f, 6.22666860e-03f, -1.54686153e-01f, -1.59415022e-01f, -2.46534184e-01f, 1.52878657e-01f, 3.10244635e-02f, 6.22407719e-02f, 9.88423079e-02f, -3.12708408e-01f,
  -5.86959273e-02f, -3.01038120e-02f, -2.53803849e-01f, -2.98742622e-01f, -2.99434572e-01f, -3.62445772e-01f, 1.05793297e-01f, 3.17358859e-02f, 1.44761041e-01f, 9.55291092e-02f,
  -1.49772450e-01f, 3.63029130e-02f, -1.02321588e-01f, -3.82263511e-02f, -3.14291805e-01f, 1.18409805e-01f, 8.86113346e-02f, -1.14331469e-01f, 2.33532931e-03f, 3.95809440e-03f,
  -3.39322686e-02f, 1.11654751e-01f, -5.06753847e-02f, -2.10335836e-01f, 1.09878950e-01f, 8.78021237e-05f, -3.04900985e-02f, 1.87668398e-01f, 7.82083869e-02f, 4.64988239e-02f,
  9.13248137e-02f, 1.25511825e-01f, 5.83993234e-02f, -1.52253449e-01f, -1.78229660e-02f, -2.15086162e-01f, -1.79710969e-01f, -2.55381018e-01f, 2.18920663e-01f, 2.17985302e-01f,
  2.20023423e-01f, 1.47619009e-01f, 1.97573483e-01f, 8.73996764e-02f, 9.08525437e-02f, 1.22817449e-01f, 1.64930582e-01f, -1.73480228e-01f, 5.96064404e-02f, -2.76569545e-01f,
  6.05939440e-02f, -1.85282364e-01f, 1.90181106e-01f, 7.40607828e-02f, 1.14462703e-01f, 1.77338660e-01f, -1.78636700e-01f, -3.06248903e-01f, -2.45905623e-01f, -2.02819973e-01f,
  1.91858336e-02f, 1.76679030e-01f, -3.02776277e-01f, -3.26076061e-01f, -2.43507475e-01f, -2.19294995e-01f, 4.81146723e-02f, 3.07191890e-02f, -1.98111013e-01f, -1.22577153e-01f,
  8.03383738e-02f, 9.82733965e-02f, -2.02425243e-03f, 2.26021469e-01f, 3.16619202e-02f, -1.55076936e-01f, -1.55419251e-02f, -1.77283306e-02f, 4.51383181e-02f, -1.73350260e-01f,
  -1.74249753e-01f, -3.39242160e-01f, -1.32101655e-01f, -6.37419596e-02f, 1.59057200e-01f, -1.92852855e-01f, -2.12499455e-01f, -7.73725733e-02f, -1.13747627e-01f, -1.29292592e-01f,
  -1.62716016e-01f, -6.44335002e-02f, 1.03999466e-01f, -5.34965619e-02f, 8.85602161e-02f, -2.76441826e-03f, 7.83735048e-03f, 1.04463667e-01f, -4.13220190e-02f, -1.70096248e-01f,
  4.28273045e-02f, 2.46720649e-02f, 1.03416100e-01f, 1.97110027e-01f, -8.61090496e-02f, 3.68462205e-02f, 6.46669883e-03f, 1.03378035e-01f, -9.06228572e-02f, -1.40231475e-01f,
  -7.06803128e-02f, 2.67880727e-02f, 1.45894334e-01f, -3.17155689e-01f, -1.54811382e-01f, -1.77826494e-01f, -1.93591341e-01f, 2.08461717e-01f, 2.86104362e-02f, 4.28758152e-02f,
  1.76471695e-01f, 9.50939432e-02f, 5.37026264e-02f, -2.42041558e-01f, -2.93844163e-01f, 4.52103652e-02f, -3.43495250e-01f, 7.33212009e-02f, -1.76349338e-02f, -1.70294926e-01f,
  -2.16648746e-02f, 2.13323012e-01f, -2.17238534e-02f, -1.70643359e-01f, 3.24032344e-02f, -1.30757153e-01f, -1.19577810e-01f, 1.51628509e-01f, 1.38770819e-01f, 6.01209030e-02f,
  1.24274701e-01f, -1.85794726e-01f, 1.40857920e-01f, -3.40459466e-01f, -2.69988645e-02f, 8.46196711e-02f, -1.15144812e-01f, 7.81328082e-02f, 8.51738155e-02f, -3.98363099e-02f,
  -3.82143296e-02f, 1.39588043e-01f, -2.32865978e-02f, 2.83986726e-03f, 1.68022394e-01f, -9.18901339e-02f, -1.49608282e-02f, 5.50147668e-02f, -2.94202473e-02f, -9.16399136e-02f,
  -1.15273833e-01f, -1.81010421e-02f, -3.22392397e-02f, -3.86867523e-02f, -1.08513245e-02f, 2.23626256e-01f, -1.24056779e-01f, -1.17032833e-01f, -1.25496268e-01f, 1.60175666e-01f,
  -5.07999118e-03f, -1.23642618e-02f, 8.80810469e-02f, 1.84126928e-01f, 1.05114512e-01f, -1.21515431e-01f, -3.65769744e-01f, 2.05438249e-02f, 3.58611345e-02f, 1.54546037e-01f,
  -1.22805402e-01f, -1.09177895e-01f, 1.39334602e-02f, -2.93834489e-02f, -3.01875859e-01f, -3.85083228e-01f, -9.54766497e-02f, -5.43543510e-02f, 1.71870276e-01f, -3.68133754e-01f,
  1.63701937e-01f, -1.60051867e-01f, 1.10414051e-01f, 3.18906367e-01f, -1.95357919e-01f, -2.00042546e-01f, -8.67638439e-02f, -1.40347883e-01f, -1.56297520e-01f, 4.60063554e-02f,
  3.16281542e-02f, -3.64077359e-01f, -3.78658362e-02f, -1.71971232e-01f, -2.15442777e-01f, 1.87034264e-01f, -3.10443938e-01f, 8.41353387e-02f, -4.49297279e-02f, -1.27712777e-02f,
  5.55829741e-02f, 2.40389910e-03f, -2.82914080e-02f, -1.35635644e-01f, 1.43190175e-01f, 9.59318280e-02f, 1.37999013e-01f, 4.84616645e-02f, 4.89412956e-02f, 1.72089376e-02f,
  1.09811373e-01f, 1.56254381e-01f, 8.70059654e-02f, 6.40433580e-02f, 7.57399574e-02f, 1.86487898e-01f, -1.11643068e-01f, 1.60562575e-01f, 2.12029979e-01f, 2.02871501e-01f,
  -1.71733141e-01f, -1.64672788e-02f, 8.04707687e-03f, -2.39209130e-01f, -3.83753777e-02f, -1.44121453e-01f, -1.81371376e-01f, -2.30234742e-01f, 1.82502195e-01f, 2.54117399e-01f,
  2.29941159e-02f, 2.61984803e-02f, 1.65202916e-01f, 1.88392833e-01f, -6.18612878e-02f, -7.81308673e-03f, -1.46548733e-01f, -1.10746518e-01f, -1.69163927e-01f, 1.81642771e-01f,
  9.87835005e-02f, 1.17726229e-01f, -1.68884248e-01f, 6.62632808e-02f, -3.78308930e-02f, 1.66920900e-01f, 1.75543427e-01f, -1.31007121e-03f, 1.16894223e-01f, 3.16389352e-02f,
  -2.18732402e-01f, -2.17791274e-02f, -7.13813454e-02f, -1.46169681e-02f, -9.08434689e-02f, -2.78593481e-01f, -2.87731826e-01f, 1.43535314e-02f, -4.69105951e-02f, 3.04523166e-02f,
  -1.96380123e-01f, 9.39667299e-02f, 1.82171643e-01f, -8.94916132e-02f, -1.63508020e-02f, 9.35534313e-02f, 4.74312268e-02f, -5.44140069e-03f, 6.59808666e-02f, 6.66167736e-02f,
  -4.67539057e-02f, -5.01524545e-02f, 9.27195624e-02f, -1.22843310e-01f, 2.26540044e-02f, 3.51893832e-03f, 1.46355376e-01f, 1.12875119e-01f, -4.34095338e-02f, 2.20666617e-01f,
  3.86311077e-02f, 6.67430647e-03f, -3.75296548e-03f, 6.67175325e-03f, -1.12553500e-01f, -9.86154657e-03f, 1.27293304e-01f, 1.44985408e-01f, 7.20901554e-03f, 1.66988689e-02f,
  -1.28214404e-01f, 1.11498674e-02f, 4.00977433e-02f, -1.92580670e-01f, 4.14456688e-02f, 1.44496724e-01f, 6.93228841e-02f, -1.90768376e-01f, 1.17681347e-01f, -2.63828844e-01f,
  -1.04231507e-01f, 1.28684640e-01f, 1.63353886e-02f, 1.20645270e-01f, -1.42218903e-01f, -5.60141020e-02f, 1.54118910e-01f, 8.83972198e-02f, 1.19711563e-01f, 3.48900561e-03f,
  1.41870916e-01f, -3.20623100e-01f, 1.54194176e-01f, -7.16141239e-02f, 4.97167632e-02f, 1.41839579e-01f, 1.76349487e-02f, -9.06002671e-02f, -6.30747806e-03f, 1.00634493e-01f,
  1.79803118e-01f, -3.81283134e-01f, -5.97734116e-02f, -1.11510508e-01f, -3.92568186e-02f, -6.72297105e-02f, 4.20898721e-02f, -4.10697386e-02f, 4.22948360e-04f, -9.11037475e-02f,
  -2.57279426e-01f, -1.05907522e-01f, -3.01967680e-01f, -1.05278060e-01f, 4.60791513e-02f, 3.38313878e-02f, 5.82091920e-02f, 1.64291918e-01f, 6.31670281e-02f, 2.52194982e-02f,
  -1.27144903e-01f, -1.23679852e-02f, -4.15634625e-02f, 6.26226142e-02f, 1.38791814e-01f, 3.42064537e-02f, -4.99500260e-02f, -2.56619245e-01f, 9.40375030e-02f, 1.80518497e-02f,
  7.36107603e-02f, -4.61829118e-02f, -1.35961846e-01f, -9.59463418e-02f, 5.11721335e-02f, 2.24125776e-02f, 1.70537587e-02f, -3.47426943e-02f, 1.06615117e-02f, 7.77619854e-02f,
  -1.63210630e-01f, -2.27956250e-01f, -1.21601798e-01f, 1.35318041e-01f, -3.42799067e-01f, 6.36799112e-02f, 1.13694057e-01f, 1.94124296e-01f, -1.31123485e-02f, -1.86581552e-01f,
  -2.39584118e-01f, -1.17960520e-01f, 8.85262042e-02f, 2.00391620e-01f, -1.78294197e-01f, -6.86584935e-02f, 1.61391824e-01f, -1.67615116e-01f, 1.10309623e-01f, 1.38764635e-01f,
  -2.74206698e-01f, -2.15996355e-01f, -2.44899735e-01f, 5.31958006e-02f, 1.38004884e-01f, 1.55116960e-01f, 1.09743387e-01f, -2.22169831e-01f, 1.96535215e-01f, -1.71167418e-01f,
  5.81953414e-02f, -1.71604350e-01f, 4.10517976e-02f, -5.75274564e-02f, -2.53367752e-01f, -2.86880583e-01f, -8.23973268e-02f, 9.45372507e-02f, 7.23842010e-02f, -5.54791279e-02f,
  -9.62051526e-02f, -3.08750030e-02f, 7.03185331e-03f, 6.61244467e-02f, 8.06670040e-02f, 6.07512854e-02f, 2.63535623e-02f, -1.15063861e-01f, -9.70440134e-02f, 9.00105014e-03f,
  -1.59709573e-01f, 1.11745834e-01f, 8.96161497e-02f, -4.34312820e-02f, -1.14498340e-01f, -1.60935894e-01f, -1.02294095e-01f, 2.18362138e-01f, -1.40684083e-01f, -1.15875296e-01f,
  -2.59498209e-01f, 1.56527907e-01f, -5.18574659e-03f, 1.20841987e-01f, -2.49040172e-01f, 3.51497382e-02f, -2.15605170e-01f, -9.27272588e-02f, -1.21756978e-01f, -1.36607423e-01f,
  -9.85912830e-02f, 1.30392775e-01f, -2.33627617e-01f, 2.60521267e-02f, 1.74013630e-01f, 1.42701576e-02f, 1.06938444e-01f, -2.18562588e-01f, 2.35364273e-01f, -1.51436245e-02f,
  -2.18282104e-01f, -1.30161107e-01f, 1.58439681e-01f, 1.21049084e-01f, -9.16380584e-02f, -1.71644151e-01f, 2.16671079e-01f, -1.25999868e-01f, -1.43447012e-01f, -6.45081978e-03f,
  -2.08819643e-01f, -1.48005128e-01f, -1.06909312e-01f, 1.25322670e-01f, 2.13562865e-02f, -5.97772300e-02f, -2.75354087e-01f, -2.65484899e-01f, -1.33576989e-02f, 1.68192297e-01f,
  2.54437298e-01f, -2.89457023e-01f, -1.13967992e-01f, -1.03398301e-01f, -8.68061185e-02f, 3.01721059e-02f, 6.04995601e-02f, -3.48398648e-02f, 2.69669704e-02f, -6.16003200e-02f,
  -9.46900323e-02f, -1.33299038e-01f, -6.95391446e-02f, 1.34703755e-01f, -6.93190917e-02f, -1.35216713e-02f, 1.32665402e-04f, -1.10632762e-01f, -2.06214651e-01f, 1.03314795e-01f,
  -1.62918285e-01f, -1.12766229e-01f, 1.76563207e-03f, 1.02175452e-01f, -2.60741949e-01f, -2.42134780e-02f, -4.69508581e-02f, -1.95096999e-01f, -3.11058998e-01f, -1.82203025e-01f,
  1.58522919e-01f, -1.17274038e-01f, 1.98659226e-01f, 1.62497833e-01f, -4.47500497e-02f, -4.16407399e-02f, -2.41103292e-01f, 6.69312850e-02f, 7.33305886e-02f, -1.94234520e-01f,
  -2.93299943e-01f, -2.37258047e-01f, 8.02822486e-02f, 5.81137501e-02f, -2.64491498e-01f, 1.72371149e-01f, 1.74925596e-01f, -2.31551118e-02f, 1.39888763e-01f, 3.24002095e-02f,
  -2.22955778e-01f, 2.25378014e-02f, -4.78685573e-02f, -2.05310695e-02f, -2.62444675e-01f, 5.05311377e-02f, -1.45369485e-01f, -4.46316004e-02f, -1.85189754e-01f, 1.68509752e-01f,
  9.12056640e-02f, 1.08762234e-02f, 2.09437847e-01f, -1.63957626e-01f, 7.62687773e-02f, -8.29324797e-02f, -5.01483008e-02f, 4.15653102e-02f, 1.16597764e-01f, 1.67551264e-01f,
  -2.71993615e-02f, -7.52791688e-02f, 1.68608755e-01f, -4.68450487e-02f, -7.12929666e-02f, -1.01810619e-01f, -5.40907346e-02f, 1.07015401e-01f, -2.54151613e-01f, 1.08135872e-01f,
  -1.64799795e-01f, -1.14407493e-02f, 1.06069274e-01f, 3.04296818e-02f, 4.15781178e-02f, 1.64503470e-01f, -8.28428715e-02f, -5.58828525e-02f, 6.82564080e-02f, -4.25090194e-02f,
  2.49251261e-01f, -4.86914581e-03f, 1.27611831e-01f, -1.47147346e-02f, -3.43481213e-01f, -2.12153733e-01f, -9.57286134e-02f, -2.80391395e-01f, -5.85740656e-02f, 9.10307169e-02f,
  2.33690128e-01f, 5.07619493e-02f, -2.29247868e-01f, -1.12584531e-02f, 7.61099458e-02f, -8.72268341e-03f, -4.76265550e-02f, -4.14920926e-01f, 5.36799729e-02f, -1.35530367e-01f,
  -2.73196429e-01f, 2.55643148e-02f, -2.95559224e-02f, -3.78408283e-01f, 4.89580780e-02f, -1.54703334e-02f, 7.32600689e-02f, 1.44727319e-01f, 1.56250104e-01f, -3.80145222e-01f,
  1.90887719e-01f, -1.32119238e-01f, 1.24702297e-01f, 6.68330565e-02f, -4.85444488e-03f, 5.67272566e-02f, -4.92616296e-02f, 2.79842138e-01f, -1.00160949e-01f, -7.23660216e-02f,
  -1.81701437e-01f, 2.25537121e-02f, -9.88386944e-02f, 1.28498480e-01f, 4.22447994e-02f, -8.15746263e-02f, 8.58709775e-03f, -1.84065521e-01f, -2.22051493e-03f, -2.72380188e-02f,
  -6.22508004e-02f, 5.59937842e-02f, 5.65221682e-02f, -1.96391881e-01f, 1.70667067e-01f, -1.20360982e-02f, -5.48416041e-02f, 1.61775351e-01f, -1.75640941e-01f, -6.35209680e-02f,
  1.08847849e-01f, 7.39562288e-02f, 1.60434917e-01f, 9.41358805e-02f, -3.08034480e-01f, -1.93538487e-01f, 1.13192886e-01f, -1.08560070e-01f, 4.84967604e-02f, 2.32049212e-01f,
  -1.54193407e-02f, 8.21464509e-02f, -6.62081093e-02f, -1.75441831e-01f, -3.79226208e-02f, -1.30316570e-01f, 1.11646354e-01f, -1.94852769e-01f, 1.15879485e-02f, -2.42224988e-02f,
  -2.51415670e-01f, 7.11838305e-02f, 9.00161173e-03f, -4.38198168e-03f, 8.48917067e-02f, 9.44497064e-02f, -2.99342033e-02f, 1.98962405e-01f, -2.36889258e-01f, 1.47073148e-02f,
  2.04844330e-03f, -2.18894303e-01f, 1.20056301e-01f, 5.91259487e-02f, 1.76052809e-01f, -6.09366782e-02f, -2.29317173e-02f, -1.15104288e-01f, 1.23587146e-01f, -1.05145760e-01f,
  -1.67919978e-01f, -2.93454509e-02f, -1.48365930e-01f, 1.47477612e-01f, -1.38715416e-01f, 1.58495607e-03f, 1.50641128e-01f, -1.33878231e-01f, -1.28195256e-01f, 1.25911504e-01f,
  -1.37912542e-01f, -3.92562188e-02f, 1.52146891e-01f, 1.20026223e-01f, -7.92168751e-02f, -5.63669018e-02f, 1.61115840e-01f, -8.91845822e-02f, 1.22983605e-01f, -1.20067760e-01f,
  -1.30316019e-01f, -2.55100634e-02f, -1.09316021e-01f, -1.20748021e-01f, -8.92160758e-02f, -2.76740462e-01f, -2.03242645e-01f, 3.40918638e-02f, -3.39532673e-01f, 1.34044975e-01f,
  -2.98204154e-01f, -1.65639855e-02f, 2.90934723e-02f, 9.31148455e-02f, 1.03150666e-01f, 5.14461733e-02f, 2.20110506e-01f, -8.02880824e-02f, 1.43352553e-01f, 1.39465660e-01f,
  -4.81423177e-02f, -3.09777379e-01f, -7.84212649e-02f, 1.46964520e-01f, 1.21913418e-01f, -1.80066377e-01f, -4.96326312e-02f, -1.43580794e-01f, 1.55283585e-01f, 1.56326458e-01f,
  -2.15585485e-01f, -6.60691038e-02f, -2.36654446e-01f, -7.47637823e-02f, -1.53886914e-01f, 1.88435148e-02f, -2.94430256e-01f, 7.66133815e-02f, -2.19292313e-01f, -1.70951784e-01f,
  -1.42993644e-01f, -1.13207415e-01f, 1.10364489e-01f, 2.34004661e-01f, 1.00864999e-01f, -2.21351609e-01f, -7.39912540e-02f, 1.78557754e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  7.40526468e-02f, -4.38981503e-02f, 4.65301387e-02f, 2.65408102e-02f, 3.32981460e-02f, 2.09799353e-02f, -7.65840039e-02f, -8.42807740e-02f, -1.15162194e-01f, -6.78371219e-03f,
  -4.12017629e-02f, -2.45687123e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    