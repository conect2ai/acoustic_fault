/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.55736280e-02f, -5.55978835e-01f, -1.23599358e-01f, -1.79058444e-02f, -1.60631180e-01f, 8.05359036e-02f, -1.10660672e-01f, 2.61983395e-01f, 1.06182680e-01f, -2.21930631e-02f,
  -2.72630006e-01f, -3.12144812e-02f, 3.37334760e-02f, 7.15448484e-02f, 1.63304180e-01f, 1.35536399e-02f, -1.93215571e-02f, 5.17345518e-02f, 2.83209354e-01f, 2.08501965e-01f,
  4.79351506e-02f, -2.32606772e-02f, 2.96616536e-02f, 7.92517588e-02f, -6.52538538e-02f, 2.00820357e-01f, -4.78523262e-02f, -2.34685406e-01f, 5.51672839e-02f, -1.85947865e-01f,
  -2.12008327e-01f, -2.77245313e-01f, 2.03288034e-01f, -7.32591674e-02f, -2.15137228e-02f, 7.40937367e-02f, 7.71396756e-02f, 2.04698276e-02f, -2.17141174e-02f, -5.19997403e-02f,
  -1.98956221e-01f, -8.84977728e-02f, -1.06764860e-01f, 5.34511022e-02f, -6.35414124e-02f, -3.92488316e-02f, -2.78107449e-02f, -4.57036421e-02f, 3.53931040e-02f, 1.00017674e-02f,
  -9.98752341e-02f, -1.57970473e-01f, -1.16700344e-01f, 4.71214689e-02f, 4.14078869e-02f, 1.07237525e-01f, 2.78043058e-02f, 4.73428033e-02f, 4.90816720e-02f, 7.01618865e-02f,
  6.01515546e-02f, -3.81086394e-02f, -2.08910350e-02f, 3.31290886e-02f, -3.66312712e-02f, -6.23230152e-02f, -9.89810843e-03f, -2.75664367e-02f, -6.34631002e-03f, 5.44634834e-02f,
  -1.44189633e-02f, 9.36847553e-02f, -5.14747985e-02f, 1.28840478e-02f, 4.18680422e-02f, -7.38650411e-02f, 5.36121242e-02f, -3.72670479e-02f, -5.08674681e-02f, -8.15195367e-02f,
  -9.42546967e-03f, 2.88901236e-02f, -5.12211770e-02f, -3.42935212e-02f, -2.04249043e-02f, -5.50948456e-03f, 4.91646081e-02f, 1.33677199e-01f, -4.51100208e-02f, -4.63786498e-02f,
  3.72484624e-02f, 4.30968218e-02f, 9.29338709e-02f, -8.12455863e-02f, -2.69874651e-02f, 1.54599519e-02f, -8.00602213e-02f, -1.23462761e-02f, 3.38714314e-03f, -1.33061260e-01f,
  6.90559670e-02f, -4.01168503e-02f, -8.09113309e-02f, 7.47139454e-02f, -4.04859446e-02f, 2.65522469e-02f, -1.33872792e-01f, 3.47866490e-02f, 1.47034854e-01f, -3.93577442e-02f,
  2.60128286e-02f, 1.02009535e-01f, 1.33737132e-01f, 9.29661095e-03f, 2.91622449e-02f, 1.66313738e-01f, 1.48124292e-01f, 1.35407090e-01f, 2.58909613e-01f, 2.95315504e-01f,
  1.41893759e-01f, -1.12111326e-02f, 9.20949057e-02f, -1.71972379e-01f, 1.72154188e-01f, 2.31296331e-01f, 3.78831297e-01f, 2.44827598e-01f, -2.52449848e-02f, 5.36375232e-02f,
  1.40432686e-01f, -9.12307873e-02f, -2.06122160e-01f, -1.06824748e-01f, -5.78744919e-04f, -7.97191411e-02f, -2.75826216e-01f, -1.95335239e-01f, -1.14913926e-01f, 9.53688398e-02f,
  -1.74163207e-01f, -1.52910417e-02f, -6.28713295e-02f, -3.98170017e-02f, -3.44093405e-02f, 3.83967906e-02f, 1.91046342e-01f, 2.67619751e-02f, 1.04390696e-01f, -5.31916261e-01f,
  -6.85564280e-02f, 2.15143800e-01f, 4.56878624e-04f, -7.54367933e-02f, 1.46612525e-01f, -2.96181031e-02f, -5.89397212e-04f, -7.47016892e-02f, 4.53768224e-02f, -7.30107427e-02f,
  -1.76226476e-03f, 4.51050065e-02f, -4.42514308e-02f, -2.30259579e-02f, 7.55256861e-02f, 1.77452713e-02f, -3.67484353e-02f, 2.83777043e-02f, 6.22340431e-03f, 9.74637046e-02f,
  -3.14285159e-02f, 1.32611006e-01f, 2.26681441e-01f, 2.14639343e-02f, 5.97740673e-02f, -5.13572572e-03f, 1.46145031e-01f, 5.10128699e-02f, 9.43228602e-02f, -4.93945442e-02f,
  5.07761026e-04f, -3.79328476e-03f, -5.73122613e-02f, 1.93586908e-02f, -2.37795580e-02f, -3.64320306e-03f, -6.64269775e-02f, 2.00949889e-02f, -1.28839374e-01f, 2.01418251e-02f,
  2.29831245e-02f, -4.53930236e-02f, 3.91219221e-02f, 6.54064640e-02f, -1.49152679e-02f, -5.07069984e-03f, 1.80729795e-02f, -2.66152956e-02f, 2.52331514e-02f, -9.39904060e-03f,
  -4.54799570e-02f, 9.97306127e-03f, -1.87850855e-02f, -2.76679290e-03f, -2.19616108e-02f, 4.47991900e-02f, 3.32686342e-02f, -3.75456177e-03f, -4.77179363e-02f, 9.57911238e-02f,
  -8.74793679e-02f, 6.23973012e-02f, -1.30336463e-01f, -1.48015758e-02f, 2.54341923e-02f, -6.51703924e-02f, -1.43641662e-02f, -3.02531254e-02f, 5.64777181e-02f, 6.21908121e-02f,
  8.29629377e-02f, 1.29257694e-01f, -3.95404990e-04f, 2.29681656e-02f, -7.22164139e-02f, 1.29599482e-01f, -3.55219282e-02f, 5.32244407e-02f, -4.64916192e-02f, 1.18425578e-01f,
  1.32842371e-02f, 8.10089335e-02f, 9.19952765e-02f, 1.42992362e-01f, 6.96606711e-02f, 5.86773194e-02f, 6.96641346e-03f, 4.86952625e-02f, 2.46412858e-01f, 1.30577400e-01f,
  -2.01263297e-02f, -1.14268869e-01f, -5.85384488e-01f, -3.70069116e-01f, -2.79029250e-01f, -7.68479258e-02f, -1.21148124e-01f, -3.55378948e-02f, -2.06961110e-02f, -2.08330434e-02f,
  -2.12184846e-01f, -6.86798571e-03f, -1.14883102e-01f, 4.72725071e-02f, -6.99280649e-02f, 5.99649474e-02f, -2.22313449e-01f, -1.33231491e-01f, -1.75928801e-01f, -8.40166286e-02f,
  -1.88754946e-02f, -2.53590167e-01f, -2.09222168e-01f, -1.19706858e-02f, -1.03863396e-01f, 2.36459877e-02f, -1.59918696e-01f, -2.48526722e-01f, 2.30305642e-02f, 6.46844432e-02f,
  1.15292989e-01f, -2.07503676e-01f, -7.64640793e-02f, -1.59719706e-01f, -1.24940842e-01f, -4.82805185e-02f, -1.92405194e-01f, -8.06751549e-02f, 3.30473781e-02f, 1.06727965e-02f,
  -2.39139408e-01f, -1.71585828e-01f, -3.36598605e-02f, -7.17780143e-02f, -5.51968478e-02f, -1.42964914e-01f, 2.71813553e-02f, -2.19030321e-01f, -2.56705016e-01f, 9.40572936e-03f,
  -6.83371052e-02f, -1.77778959e-01f, -1.89708304e-02f, 3.55242826e-02f, 1.36703076e-02f, 5.44604007e-03f, -2.34013591e-02f, -4.16338108e-02f, -8.86069834e-02f, 6.24915846e-02f,
  -1.06267609e-01f, 8.66081938e-02f, -1.75525472e-02f, -2.18200106e-02f, 9.02932137e-03f, 3.17906812e-02f, 1.18333384e-01f, 1.47568453e-02f, 8.09094012e-02f, 5.30095324e-02f,
  -4.95011434e-02f, -5.97208329e-02f, 5.51565439e-02f, -1.24420762e-01f, 7.93819055e-02f, -8.27119425e-02f, 7.58387446e-02f, -2.58846618e-02f, 5.82149699e-02f, 9.28020626e-02f,
  -5.93554825e-02f, -2.94366898e-03f, -1.84325892e-02f, 1.47415206e-01f, -4.54433188e-02f, -5.40653653e-02f, -2.51100548e-02f, 1.24241963e-01f, 8.51364713e-03f, -1.28553063e-01f,
  -4.92574945e-02f, -1.01753473e-01f, 1.54914826e-01f, -4.28043455e-02f, 2.93438733e-02f, 1.98415667e-01f, 3.63211334e-02f, 1.76591590e-01f, -5.41299731e-02f, 5.86513579e-02f,
  3.50631475e-02f, 5.51896542e-02f, 2.80003948e-03f, 3.65858376e-02f, -1.40061714e-02f, 7.12170079e-02f, 9.00667012e-02f, 7.84940422e-02f, -3.06165665e-02f, 1.32906258e-01f,
  5.06924652e-02f, 1.26024917e-01f, 2.59917051e-01f, 5.11003695e-02f, 8.61180350e-02f, 4.63782847e-02f, 1.68628320e-01f, 1.42303512e-01f, 1.24450974e-01f, 1.36351272e-01f,
  5.55236042e-01f, 5.31582795e-02f, 1.27816051e-02f, 5.90802014e-01f, 1.01295561e-02f, -1.32203951e-01f, -6.76081628e-02f, -5.46367932e-03f, 2.46013895e-01f, 1.56589169e-02f,
  -4.02426161e-02f, -2.76573170e-02f, 4.41761650e-02f, -5.52626736e-02f, -5.89631908e-02f, -4.37242463e-02f, 9.72749144e-02f, 1.64378703e-01f, -2.61308730e-01f, -2.80168712e-01f,
  1.60598576e-01f, 3.27884883e-01f, 1.39080375e-01f, 9.36272964e-02f, 4.05382775e-02f, 9.59649868e-03f, -4.94078323e-02f, -2.34435461e-02f, -3.26466262e-01f, 2.41467163e-01f,
  -4.24657799e-02f, -8.40588287e-02f, 9.99512225e-02f, 1.05637215e-01f, -1.21329211e-01f, -6.80365115e-02f, -1.03119984e-01f, -7.75659829e-02f, -5.41171916e-02f, -1.07689518e-02f,
  8.72059241e-02f, -5.16957566e-02f, 8.33937675e-02f, -3.67836244e-02f, 3.38949598e-02f, -2.81403642e-02f, -1.26567641e-02f, 1.86505876e-02f, 4.05614488e-02f, -4.03271653e-02f,
  7.23740980e-02f, 4.52179648e-02f, -8.49782377e-02f, -6.13229796e-02f, -3.10530066e-02f, 1.47308111e-01f, -8.98608938e-02f, 7.13135526e-02f, -8.22801441e-02f, 1.51399463e-01f,
  -2.45946292e-02f, -3.86354476e-02f, -7.56251859e-03f, -1.75610762e-02f, 2.24454366e-02f, 5.61153851e-02f, -9.32613760e-02f, -1.75381079e-02f, 2.44485103e-02f, -4.69927751e-02f,
  -4.56307344e-02f, 5.92065102e-04f, -3.96505632e-02f, 1.95944682e-03f, -4.87554120e-03f, 3.97126190e-02f, -7.58111523e-03f, -2.11542682e-03f, -3.13268160e-03f, 7.41606802e-02f,
  3.84996161e-02f, 7.41080288e-03f, -7.83247873e-02f, -4.99924384e-02f, 5.58865033e-02f, -2.03964766e-02f, 2.87406370e-02f, -1.18456520e-01f, -5.78339659e-02f, -2.38371044e-02f,
  -1.77509394e-02f, -3.26067097e-02f, 1.49987161e-01f, 1.80373862e-02f, 4.19973442e-03f, -2.39764014e-03f, 1.15790509e-01f, 3.90601978e-02f, 3.11448961e-03f, 8.06760937e-02f,
  -9.58801154e-03f, -1.26010343e-01f, 5.97046874e-02f, -8.95600617e-02f, 1.68440752e-02f, 3.53762321e-02f, 5.59391491e-02f, -3.00265513e-02f, 6.51913062e-02f, 9.26277861e-02f,
  4.55793515e-02f, -1.25116212e-02f, -4.11044806e-02f, -7.56366935e-05f, -3.31353955e-02f, -1.07776240e-01f, -1.99001968e-01f, -1.47314370e-01f, -1.32331461e-01f, -7.56417587e-02f,
  6.96434290e-05f, -4.19885486e-01f, 1.29900515e-01f, -7.98172280e-02f, -3.26511748e-02f, 6.18270487e-02f, -2.55100846e-01f, -1.32073209e-01f, 1.37189040e-02f, -1.72729328e-01f,
  -3.48375253e-02f, -1.92611143e-02f, 1.43220171e-01f, -8.37822184e-02f, 7.77975544e-02f, -1.67596206e-01f, 2.89190859e-02f, 1.86097845e-01f, 3.67319137e-01f, -4.96942289e-02f,
  -2.74367362e-01f, -8.92669186e-02f, 1.51043355e-01f, 8.80100057e-02f, -3.20161551e-01f, 7.01708496e-02f, -3.59401144e-02f, 1.62184797e-02f, -7.06673553e-03f, -6.31404519e-01f,
  6.23887824e-03f, -3.19694877e-01f, 1.85722813e-01f, -8.00182000e-02f, -1.73996724e-02f, 7.03668594e-02f, 3.54837179e-02f, -4.34426814e-02f, 1.63589157e-02f, 4.54989746e-02f,
  -2.03364138e-02f, -5.09398244e-03f, -4.75368574e-02f, 1.10341990e-02f, -5.90524287e-04f, 2.34418865e-02f, 3.60016376e-02f, 3.97230498e-02f, 3.43958922e-02f, -2.49212608e-02f,
  -1.22394063e-01f, -1.29601344e-01f, -1.05551057e-01f, -1.57004073e-02f, 1.72921289e-02f, 9.06722471e-02f, -9.78427306e-02f, -1.02639183e-01f, 2.85044964e-02f, -4.61155623e-01f,
  6.24695495e-02f, -3.25507461e-03f, -4.71184449e-03f, -5.78617863e-03f, 2.02430226e-03f, -1.07427714e-02f, 7.04505946e-03f, -1.32291187e-02f, -2.37888470e-03f, 7.85134640e-03f,
  2.60278732e-02f, 3.87506895e-02f, -3.36980708e-02f, 6.60897568e-02f, -6.88133091e-02f, 3.10260314e-03f, -1.19663682e-02f, -7.16475351e-03f, 3.03177200e-02f, 1.23967109e-02f,
  -4.09202054e-02f, 2.01146845e-02f, -5.74210696e-02f, -2.50875833e-03f, -8.67926851e-02f, -1.38161760e-02f, 3.27349640e-02f, -7.57153258e-02f, 4.43131030e-02f, 2.94740796e-02f,
  1.32013947e-01f, 1.80295885e-01f, -4.89737317e-02f, -4.52716649e-03f, -4.07846831e-02f, 2.52489466e-02f, -6.12140372e-02f, 5.24074696e-02f, 2.67853346e-02f, -5.36960363e-02f,
  -4.16186191e-02f, 4.59626392e-02f, 9.92620643e-03f, -6.59276769e-02f, 6.68307990e-02f, 1.56350359e-02f, 3.54445502e-02f, 3.80250663e-02f, 4.47851606e-03f, -8.92222375e-02f,
  6.91603869e-02f, 2.28475444e-02f, 1.01143368e-01f, 2.34339517e-02f, -2.35193241e-02f, 7.03135729e-02f, 7.88517073e-02f, 9.31573659e-02f, 1.62997037e-01f, 1.80811331e-01f,
  7.78899968e-01f, -1.68348804e-01f, 1.32498875e-01f, 1.53100878e-01f, -2.73158967e-01f, -8.51239339e-02f, -4.59894598e-01f, -2.51099840e-03f, 8.17594975e-02f, -2.22422481e-02f,
  -1.67824375e-03f, 3.83319706e-02f, 5.99807873e-02f, -7.13542290e-03f, 1.19661957e-01f, -1.99516103e-01f, -1.44305870e-01f, 3.20916325e-01f, 3.68410647e-02f, -2.16447383e-01f,
  -2.59392202e-01f, 9.52694565e-02f, 4.46628928e-01f, -1.46704707e-02f, -5.39375320e-02f, -1.14649221e-01f, -7.44817406e-02f, 1.04216427e-01f, -8.87147412e-02f, 1.07911304e-01f,
  8.10949951e-02f, 9.25054401e-02f, -5.44391759e-02f, 2.41414607e-02f, 8.98116548e-03f, 8.35589916e-02f, -1.92611199e-02f, 7.70349056e-02f, -6.92252442e-03f, -5.57866180e-03f,
  2.72311065e-02f, 4.23641168e-02f, -1.47327194e-02f, -3.85817364e-02f, 2.20101550e-02f, -4.04157043e-02f, 8.06157291e-02f, 5.91910072e-02f, 2.31755823e-02f, -3.82746011e-03f,
  -7.39293024e-02f, 1.35742994e-02f, -6.56452309e-03f, -8.46726447e-02f, -2.10519265e-02f, 2.45040655e-02f, -2.23563630e-02f, 4.03919704e-02f, 7.32741281e-02f, -1.46413790e-02f,
  1.43980300e-02f, 2.74058208e-02f, -6.37440616e-03f, -3.18821073e-02f, -6.46549789e-03f, 1.97960949e-03f, 1.40632978e-02f, -3.99385616e-02f, -4.51417044e-02f, 7.56401792e-02f,
  -9.88269597e-03f, 8.87232134e-04f, 4.59330855e-03f, -1.43636353e-02f, 1.60346907e-02f, -1.10641611e-03f, 3.05027384e-02f, -1.21573685e-02f, 1.53424544e-03f, 1.10211025e-03f,
  -1.36720929e-02f, 1.17932521e-02f, 3.12141310e-02f, -8.92330799e-03f, -7.75753846e-03f, 4.50030975e-02f, 2.56903060e-02f, 1.64540915e-03f, 8.47000556e-05f, 2.63419114e-02f,
  -9.63537991e-02f, -6.42583221e-02f, 1.53025379e-02f, 1.43526802e-02f, 3.18811387e-02f, 1.08812237e-02f, 6.03373279e-04f, -5.14714532e-02f, 4.02203798e-02f, 2.62163742e-03f,
  -1.29311513e-02f, 6.88109249e-02f, -2.22945400e-02f, 2.27648951e-02f, -5.42268753e-02f, 1.39335520e-03f, -1.00300014e-02f, -2.46537384e-02f, -4.45350669e-02f, -1.46572161e-02f,
  1.25504658e-02f, -2.39812154e-02f, -3.53733674e-02f, -3.05311773e-02f, 1.76289678e-02f, 1.11644284e-03f, -2.76425723e-02f, 1.12252189e-02f, -5.10977730e-02f, -1.31645247e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.89435017e-02f, -4.47110832e-03f, -9.35735941e-01f, 1.91710189e-01f, -3.58305007e-01f, -2.34638184e-01f, 8.69798362e-02f, 3.38179976e-01f, 2.64609139e-02f, -1.61769986e-01f,
  1.34921134e-01f, 3.15647483e-01f, -1.53882280e-01f, 2.44821776e-02f, 1.81466430e-01f, -4.65866774e-01f, -5.43165386e-01f, -4.53499943e-01f, -2.90944725e-02f, 5.39715350e-01f,
  2.58599222e-01f, 1.00048877e-01f, 1.21636145e-01f, 2.01626435e-01f, -9.41663533e-02f, -6.18855767e-02f, -5.96592247e-01f, -4.55328852e-01f, -8.04472789e-02f, -8.74746382e-01f,
  -3.85872811e-01f, -2.48790961e-02f, 2.18971875e-02f, 2.32884839e-01f, 4.12476771e-02f, 2.11353246e-02f, 4.25685346e-02f, 4.57333252e-02f, 2.58483976e-01f, 2.12249197e-02f,
  9.61760506e-02f, 2.87919015e-01f, -1.40312672e-01f, 9.59774014e-03f, 2.29675397e-02f, -1.18533947e-01f, -1.27520934e-02f, -6.13547750e-02f, -9.21686515e-02f, 9.11301076e-02f,
  1.19963855e-01f, -6.58950396e-03f, -3.25214237e-01f, -1.17162848e-02f, -1.02131814e-01f, -1.63887501e-01f, 9.91460402e-03f, -1.70406595e-01f, -2.78717995e-01f, -1.04500167e-01f,
  1.27342641e-01f, -1.03969507e-01f, -8.48735869e-02f, 3.95076424e-02f, 2.30542812e-02f, 3.25961001e-02f, -3.63666564e-02f, -6.55808598e-02f, 5.62055744e-02f, 2.31122356e-02f,
  8.60838071e-02f, -8.89745131e-02f, 2.81004496e-02f, 1.29343597e-02f, -9.24824253e-02f, -5.62046021e-02f, -2.12004054e-02f, -5.61731942e-02f, 6.02241121e-02f, 4.04694565e-02f,
  1.73691241e-03f, -6.74541518e-02f, -1.08637298e-02f, 1.01794079e-01f, -1.32404104e-01f, 6.09246716e-02f, -7.66536221e-02f, 8.97166952e-02f, 1.55791283e-01f, -1.34886671e-02f,
  3.49230558e-01f, -1.25297040e-01f, -2.49494184e-02f, 6.04120791e-02f, -4.70735468e-02f, 5.78361712e-02f, -8.07681084e-02f, -7.68757146e-03f, -2.28338744e-02f, 3.83495390e-02f,
  1.26405269e-01f, -3.41999270e-02f, 1.04563665e-02f, 5.62976561e-02f, 9.30039734e-02f, 3.73407528e-02f, 1.53219432e-01f, -1.29405528e-01f, 1.00304037e-01f, -9.60461143e-03f,
  1.84218511e-02f, 1.26422942e-01f, 9.62696411e-03f, 2.56443769e-02f, 3.16098444e-02f, -8.40258822e-02f, 6.77098557e-02f, -1.68416798e-02f, -2.82043740e-02f, 3.97741407e-01f,
  -1.72241300e-01f, -8.56201164e-03f, 1.62408054e-01f, -1.75793126e-01f, 3.66057575e-01f, -2.07007095e-01f, -4.02975053e-01f, -3.93673331e-01f, 9.87350419e-02f, -1.71874762e-02f,
  4.14007008e-01f, 1.34146795e-01f, 1.43274650e-01f, 2.00028226e-01f, -5.56201160e-01f, -3.64898205e-01f, -1.33974522e-01f, -3.99148256e-01f, -4.17446643e-01f, 3.34236361e-02f,
  -7.22748265e-02f, -1.24739692e-01f, -1.19894676e-01f, -1.02827758e-01f, 2.61538208e-01f, 2.45448500e-02f, 4.80639040e-01f, 2.45845422e-01f, 5.93560785e-02f, 7.39551410e-02f,
  2.53397482e-03f, 6.02552444e-02f, -1.67933386e-02f, 1.45559132e-01f, 1.89743459e-01f, -8.30065459e-02f, -7.08603486e-02f, -5.88955469e-02f, 5.23613095e-02f, -1.10414445e-01f,
  3.63675416e-01f, 1.38596416e-01f, 9.54342782e-02f, -1.00630343e-01f, -1.14300437e-01f, -1.24589577e-01f, -1.35704741e-01f, -3.15061450e-01f, -8.93547088e-02f, 7.91987106e-02f,
  2.21466366e-02f, 1.82731971e-01f, 6.46678433e-02f, -1.25329554e-01f, -7.17839599e-02f, 1.86325952e-01f, 1.45110056e-01f, 4.80672345e-03f, -4.37593833e-02f, -2.03889310e-01f,
  4.31565419e-02f, -7.22041354e-03f, 1.03820205e-01f, -6.21024296e-02f, -9.91415512e-03f, 2.90258452e-02f, -4.56720293e-02f, -7.72955492e-02f, -5.47910295e-02f, -6.50761202e-02f,
  2.81234435e-03f, 6.37790635e-02f, -4.00730893e-02f, 2.01386865e-02f, -3.16274203e-02f, -2.35139187e-02f, 7.58142620e-02f, -9.25701708e-02f, -5.84320538e-02f, 6.26912788e-02f,
  -1.51370272e-01f, 1.41755462e-01f, -6.86889216e-02f, -1.13934599e-01f, 2.00446453e-02f, 9.99497846e-02f, 5.87449111e-02f, 9.24954191e-02f, 2.56614573e-03f, 6.46185800e-02f,
  -1.02152027e-01f, 1.83092892e-01f, -5.34618683e-02f, 4.71331067e-02f, -9.10735875e-02f, 3.49132605e-02f, 9.87063572e-02f, -5.58271408e-02f, 1.90144524e-01f, -7.69914240e-02f,
  3.73811759e-02f, -3.20922211e-02f, 4.82249632e-02f, 1.14352413e-01f, -1.59253597e-01f, 5.19302674e-02f, -5.28009273e-02f, 1.31726116e-01f, -1.22971702e-02f, 7.66888857e-02f,
  -7.07894415e-02f, -2.08617881e-01f, -2.36926168e-01f, -2.16601029e-01f, 9.09075886e-02f, -5.72526455e-02f, -1.57603487e-01f, 7.04484293e-03f, -1.68745220e-01f, -4.42994803e-01f,
  -6.28979504e-01f, 9.27990451e-02f, -1.78438351e-02f, -4.02779371e-01f, 1.90824717e-01f, 1.85890928e-01f, 2.05434293e-01f, 1.70707360e-01f, 4.52231131e-02f, 6.04283959e-02f,
  1.74376383e-01f, -2.35621393e-01f, -2.03123569e-01f, 4.85612303e-02f, -1.49987683e-01f, 2.66719013e-01f, -2.02413961e-01f, -4.31469619e-01f, -2.02823371e-01f, 2.01570928e-01f,
  -1.64426997e-01f, -6.09336555e-01f, -5.20187259e-01f, -2.77371466e-01f, -2.13928670e-02f, -4.18008327e-01f, -1.38066694e-01f, -4.01206225e-01f, 7.77907893e-02f, -3.52301240e-01f,
  9.74367782e-02f, 8.89339671e-02f, 1.62258297e-01f, -2.67624736e-01f, -1.26524001e-01f, 2.17466429e-01f, -2.25784350e-02f, -6.44773170e-02f, 2.63004396e-02f, -5.19095212e-02f,
  5.71708009e-02f, 4.02233541e-01f, -2.47318998e-01f, -2.61051357e-02f, -8.00214037e-02f, 9.73992050e-02f, 9.92229432e-02f, 1.14980787e-01f, 8.94861761e-03f, 1.93242922e-01f,
  1.40402868e-01f, -2.73454599e-02f, 1.29898591e-02f, 3.89309675e-01f, 2.14146793e-01f, -6.75165653e-02f, 1.93375349e-01f, 1.76578656e-01f, 2.13865757e-01f, -1.57616466e-01f,
  -3.65719907e-02f, 1.60458814e-02f, -6.91113621e-03f, -5.38510969e-03f, -1.55963365e-03f, 2.59742737e-02f, -3.88810560e-02f, -1.40074790e-02f, -1.12577632e-01f, -1.51643261e-01f,
  1.00612789e-01f, 3.64559479e-02f, -9.05798450e-02f, -9.48993042e-02f, 4.16830890e-02f, 2.36690193e-02f, -1.65774822e-02f, -1.00456595e-01f, 1.33516714e-01f, 3.16725820e-02f,
  -7.58549497e-02f, 9.78121087e-02f, -7.49741793e-02f, -2.74029113e-02f, 1.49364829e-01f, -8.95143226e-02f, 1.21585362e-01f, 6.13733046e-02f, -2.43408307e-02f, 2.42006537e-02f,
  -4.75458413e-01f, -1.37842581e-01f, 1.83203630e-03f, 1.29970133e-01f, 1.05193220e-02f, -3.82233262e-02f, -1.68701351e-01f, 8.44004080e-02f, -9.15081874e-02f, -8.64892751e-02f,
  9.50638875e-02f, -8.66452157e-02f, -1.56685561e-01f, -6.45326525e-02f, -9.00910795e-02f, 7.85763934e-02f, 2.09787712e-01f, -2.46546999e-01f, 1.40937760e-01f, -4.24462594e-02f,
  3.88969034e-02f, -1.81599125e-01f, -3.56337875e-01f, -5.28729632e-02f, -2.16203600e-01f, -3.64827156e-01f, -3.90742838e-01f, -2.85626113e-01f, -8.68849680e-02f, -7.72006512e-01f,
  5.70941627e-01f, -9.70015675e-02f, -3.43241960e-01f, 9.05739143e-02f, -2.29469001e-01f, 4.82810810e-02f, -1.30333424e-01f, 1.72618106e-01f, 3.72489057e-02f, -1.09379794e-02f,
  1.99219078e-01f, 4.18359488e-01f, 3.82993340e-01f, 2.76642174e-01f, 3.33642542e-01f, -2.65439779e-01f, -3.34747672e-01f, 8.85267258e-02f, 1.59748420e-01f, 4.66204807e-03f,
  -1.33767828e-01f, -1.11951590e-01f, 4.88675945e-02f, 1.89229883e-02f, -2.54752398e-01f, 1.72807172e-01f, -2.25593597e-01f, -2.02634618e-01f, 1.70576349e-02f, -2.64190257e-01f,
  -8.65318105e-02f, 1.11392833e-01f, 6.04635011e-03f, 1.78839386e-01f, -5.08657508e-02f, 6.67763352e-02f, -9.32683647e-02f, -7.30521306e-02f, 2.30865628e-02f, -7.48937130e-02f,
  1.34516448e-01f, 4.48365510e-02f, 7.74510503e-02f, 1.06341233e-02f, -1.92588925e-01f, 8.88508782e-02f, 1.72848732e-03f, 7.04141334e-03f, 1.49484023e-01f, 3.03300638e-02f,
  -2.24224236e-02f, -3.69975865e-02f, -8.03770199e-02f, 3.40648890e-02f, 1.70025319e-01f, 9.84378383e-02f, -8.28326866e-02f, 1.00350454e-01f, 1.07775994e-01f, -5.95295727e-02f,
  1.79442652e-02f, -4.47068065e-02f, -6.30688593e-02f, -7.65258670e-02f, 7.98651651e-02f, -6.55376092e-02f, -5.88279180e-02f, 2.68784314e-02f, -1.29273077e-02f, -6.72289804e-02f,
  -5.05085401e-02f, 9.46969017e-02f, -2.48903167e-02f, -1.68639719e-02f, 7.84097984e-02f, 6.05753111e-03f, -6.43583462e-02f, 4.44344543e-02f, 9.41146258e-03f, -8.01144168e-02f,
  3.62175219e-02f, 2.17187256e-02f, -7.89436996e-02f, 3.70196402e-02f, -3.48809250e-02f, 1.34082302e-01f, 1.12120338e-01f, 9.42275152e-02f, -1.61144156e-02f, -1.46703407e-01f,
  7.20691383e-02f, 1.59597382e-01f, -1.12947291e-02f, 6.01851158e-02f, 6.09388622e-03f, -2.03219339e-01f, 2.14721300e-02f, -2.66037975e-02f, 3.32506858e-02f, 4.44704555e-02f,
  6.58588931e-02f, 5.08946255e-02f, 3.50686572e-02f, -1.04577998e-02f, -7.74185453e-03f, 3.37577164e-02f, -6.65816665e-02f, 8.71783793e-02f, 1.00694150e-01f, -1.70859769e-02f,
  -1.61623191e-02f, 4.75956202e-02f, 9.28852484e-02f, 1.47299260e-01f, 3.32997739e-02f, 9.81898010e-02f, 7.98035413e-03f, 1.79848820e-02f, 1.43914744e-01f, -6.15381636e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.43010178e-01f, 2.20039025e-01f, -3.61075521e-01f, 4.86409068e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.16964936e-01f, 2.91238427e-01f, -1.50046960e-01f, -3.19837213e-01f, 3.04565560e-02f, -8.01462457e-02f, 1.52812690e-01f, 3.28583330e-01f, 2.86666453e-01f, -3.59098166e-01f,
  4.13786441e-01f, -3.12007427e-01f, -6.86421385e-03f, -1.37544692e-01f, 3.74508761e-02f, 3.97130281e-01f, 1.22951400e-02f, 9.97206718e-02f, -8.47913548e-02f, -1.64052874e-01f,
  8.17266330e-02f, 3.80165815e-01f, 9.07962546e-02f, 2.25251079e-01f, -6.54352754e-02f, 1.42035320e-01f, 3.66530776e-01f, 1.14669055e-01f, 3.05663526e-01f, -3.84362966e-01f,
  -2.37884462e-01f, 3.14936906e-01f, 4.28009368e-02f, -5.13434708e-02f, 2.60576367e-01f, -4.38464016e-01f, -3.69316968e-03f, -4.42075878e-01f, -2.90713966e-01f, -4.75772619e-01f,
  -3.38557303e-01f, 1.78168342e-01f, -2.12349236e-01f, -3.84836048e-01f, -5.20793021e-01f, 2.80321449e-01f, -9.70346555e-02f, -3.28535765e-01f, 1.58469662e-01f, 2.23733500e-01f,
  2.07522400e-02f, 5.32391779e-02f, 1.97348908e-01f, 5.05319715e-01f, 3.46196175e-01f, -1.60987094e-01f, 6.68671587e-03f, -2.53560930e-01f, 9.54187155e-01f, 2.51763463e-01f,
  1.55932561e-01f, -1.35616988e-01f, -3.41718614e-01f, 1.79129511e-01f, -3.09015095e-01f, -1.08029470e-01f, 1.45318955e-01f, -2.85972983e-01f, 2.79568881e-01f, 5.09959519e-01f,
  -2.20163107e-01f, 3.16308707e-01f, 1.25158709e-02f, 1.95501633e-02f, 1.93315879e-01f, -3.59235823e-01f, -2.07235441e-01f, 5.28520763e-01f, 2.09798768e-01f, -3.62196177e-01f,
  -2.82431602e-01f, 8.57436284e-03f, 1.24009801e-02f, 2.54356295e-01f, -2.06521958e-01f, 6.70082211e-01f, -8.56056884e-02f, 3.21669996e-01f, -8.92881006e-02f, 1.17773019e-01f,
  2.81758476e-02f, 1.18666625e+00f, -8.67177621e-02f, 3.07645828e-01f, -9.58614573e-02f, -1.22297876e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.21031247e-01f, 2.22784251e-01f, 7.53628537e-02f, 1.03719234e-01f, 8.85951519e-02f, -5.37794888e-01f, -1.30721271e-01f, -4.37084645e-01f, 6.04445003e-02f, 1.11069590e-01f,
  -5.44063926e-01f, -1.65251508e-01f, 2.47493386e-01f, -2.94709444e-01f, -2.36232415e-01f, 8.55424404e-02f, 6.81374818e-02f, 4.92744416e-01f, -2.09473953e-01f, -4.15672213e-01f,
  2.77338058e-01f, 2.24534184e-01f, 3.08987826e-01f, -1.80515032e-02f, 3.12615216e-01f, -2.35109389e-01f, 4.84801419e-02f, -9.10201430e-01f, 5.47541261e-01f, 3.36584687e-01f,
  5.36501944e-01f, -2.44021043e-01f, -7.26338327e-02f, 1.71673954e-01f, -5.30049503e-02f, -1.92468762e-01f, 2.03689083e-01f, 3.40260118e-01f, 3.76300544e-01f, 6.14972830e-01f,
  5.96057996e-02f, -1.81710824e-01f, -7.07684681e-02f, -5.01529932e-01f, 6.75748110e-01f, 5.69344200e-02f, 3.65168869e-01f, -2.92592347e-01f, 4.22983438e-01f, 4.49420899e-01f,
  -4.63478118e-01f, -3.45026374e-01f, -3.75590026e-01f, -1.88201115e-01f, 3.75810154e-02f, -1.17426060e-01f, -1.11780502e-01f, -3.85069773e-02f, -5.84967285e-02f, 5.05464673e-02f,
  1.83841690e-01f, -4.18207854e-01f, -3.60097647e-01f, 5.56680501e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.20391124e-01f, -1.06798545e-01f, 4.75942701e-01f, 4.51075196e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.64852010e-02f, -9.10191312e-02f, -4.60503757e-01f, 3.25138122e-01f, -2.99075633e-01f, 3.31653297e-01f, -6.03566766e-01f, -4.37325627e-01f, 6.99392974e-01f, -3.65770310e-01f,
  -4.20981705e-01f, 3.36817026e-01f, 3.76728773e-01f, -2.38533854e-01f, -4.00478870e-01f, -8.04644972e-02f, 1.77840088e-02f, 1.74589053e-01f, -1.97115049e-01f, 4.79040027e-01f,
  -2.52276212e-01f, -3.59920084e-01f, -1.47959264e-02f, -7.01389253e-01f, -4.90606725e-01f, -7.04132378e-01f, 3.80010903e-01f, -2.51653381e-02f, -2.88712569e-02f, 5.60692064e-02f,
  -2.68144384e-02f, -1.87889531e-01f, 3.89784396e-01f, 5.16902089e-01f, 2.48708174e-01f, -1.18990958e-01f, 2.43109688e-01f, -1.05774747e-02f, -6.57197535e-01f, -3.62064034e-01f,
  4.54126805e-01f, -1.45690963e-01f, 4.66880053e-02f, 7.78508604e-01f, 2.85818845e-01f, 2.31480729e-02f, -2.46144697e-01f, -2.37513408e-01f, -2.11123735e-01f, -1.23611800e-01f,
  1.98610544e-01f, -1.32728264e-01f, -5.73191047e-02f, 8.72428268e-02f, -2.20008433e-01f, 4.52185512e-01f, 3.58874321e-01f, -1.54070273e-01f, -6.27755284e-01f, 5.48290610e-01f,
  -2.59191543e-01f, -5.05171597e-01f, -9.75347683e-02f, -3.42511851e-03f, -7.19115615e-01f, -3.91386569e-01f, 2.53840774e-01f, -5.10370731e-02f, -3.02356392e-01f, -3.18585485e-01f,
  2.68919230e-01f, -1.86693251e-01f, 3.26050997e-01f, -2.51358241e-01f, -2.81830132e-01f, -9.31837499e-01f, 2.92111456e-01f, -2.34631728e-02f, -9.08626840e-02f, 4.00419950e-01f,
  -2.16836184e-01f, 1.62512228e-01f, 1.54354483e-01f, 7.55338222e-02f, -5.70315681e-02f, -1.54744133e-01f, 2.84057349e-01f, -4.27100152e-01f, -7.67435849e-01f, -1.38429016e-01f,
  5.56433976e-01f, 4.79557365e-01f, -4.05218571e-01f, 5.41981868e-02f, -8.83646756e-02f, -9.10171792e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.49204671e-01f, 8.14486444e-01f, 1.13379128e-01f, 4.69759494e-01f, 2.23987281e-01f, 3.48245539e-02f, 1.93711296e-01f, -1.83247432e-01f, -4.31918874e-02f, -1.19637799e+00f,
  1.19116455e-01f, 4.43500221e-01f, 1.90441534e-01f, 4.73761916e-01f, 4.67265069e-01f, -3.25060993e-01f, 5.75569451e-01f, 6.16185427e-01f, 3.30571175e-01f, 6.25716671e-02f,
  -1.97893102e-02f, 2.13206321e-01f, -8.46200809e-02f, -3.83156419e-01f, -8.64720881e-01f, -3.40265214e-01f, 9.21136439e-01f, 6.05812490e-01f, -8.48889232e-01f, -5.55111989e-02f,
  -4.88015339e-02f, -9.74309206e-01f, 4.62773800e-01f, 1.61650106e-02f, 6.97928248e-03f, 3.92270476e-01f, 1.93104297e-01f, 5.71933806e-01f, 1.13172241e-01f, 4.77417469e-01f,
  -2.70944182e-02f, 1.20711946e+00f, 6.12603486e-01f, -8.77872948e-03f, -4.06784475e-01f, 3.94328117e-01f, 5.51672876e-01f, -4.39784437e-01f, 8.82334888e-01f, 4.95956242e-01f,
  -2.62728304e-01f, 4.61583346e-01f, 4.13951725e-01f, 3.99402082e-01f, 2.41288319e-01f, 1.98149800e-01f, -2.14438960e-01f, 1.85902596e-01f, 6.41922534e-01f, 1.08516321e-01f,
  5.04635759e-02f, 6.67073429e-01f, 5.87946415e-01f, -7.21522868e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  6.24838829e-01f, 4.61074024e-01f, -1.54869258e-01f, -1.11227393e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -8.83576393e-01f, 1.56936243e-01f, -2.34593183e-01f, -6.36210263e-01f, 5.73462427e-01f, 2.93165799e-02f, 3.47305059e-01f, 4.95993882e-01f, 6.48931742e-01f, 8.85488927e-01f,
  1.17676787e-01f, 3.31897914e-01f, 2.77912706e-01f, -3.80535483e-01f, -1.16402782e-01f, 1.27304241e-01f, 3.37960750e-01f, -2.50278234e-01f, 6.15194559e-01f, 5.74710499e-03f,
  -2.68078059e-01f, -3.05798829e-01f, 5.35378218e-01f, 1.06835616e+00f, 3.86656314e-01f, -1.12985954e-01f, -2.06257790e-01f, 4.54079270e-01f, 8.74103904e-02f, 4.29559976e-01f,
  -1.20380022e-01f, 2.98287988e-01f, -5.56982458e-01f, 5.41116297e-01f, 2.39305198e-01f, -9.81540084e-02f, 3.75544697e-01f, 4.96701241e-01f, 7.80160367e-01f, -2.32649848e-01f,
  -5.21028452e-02f, 1.40349165e-01f, 5.67036152e-01f, -5.95342755e-01f, -1.97167054e-01f, -6.43819273e-01f, 2.32129887e-01f, 1.76077951e-02f, -2.92072147e-01f, 5.31722069e-01f,
  -1.08606227e-01f, 2.26642117e-01f, -1.88701272e-01f, 7.02867329e-01f, 5.98987818e-01f, -3.82510051e-02f, 4.92748208e-02f, -5.18270545e-02f, 2.24866971e-01f, 2.72597641e-01f,
  -2.01891243e-01f, 6.21580720e-01f, 1.37582757e-02f, -3.78782272e-01f, -1.66511819e-01f, 6.48539484e-01f, 4.12313819e-01f, 3.19351196e-01f, -2.98977166e-01f, -5.37909865e-01f,
  -2.98712641e-01f, -3.06135684e-01f, -1.02197617e-01f, -1.06043017e+00f, 4.62402813e-02f, -1.06194246e+00f, -5.75915724e-02f, -6.81312501e-01f, 1.38848752e-01f, 2.19234645e-01f,
  6.12100400e-02f, 4.73318011e-01f, -9.50005054e-02f, 3.45690817e-01f, 3.63280386e-01f, 1.94951758e-01f, -1.48063421e-01f, -5.61393440e-01f, -1.83289424e-01f, 4.11076099e-01f,
  -2.70594269e-01f, -1.21529520e-01f, 3.76538932e-01f, -1.52321339e-01f, -4.66909468e-01f, -4.91250902e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.56559683e-02f, -3.63039702e-01f, 4.50280681e-02f, -3.75500053e-01f, -1.41858682e-01f, -4.34517145e-01f, -1.70209795e-01f, -3.17941636e-01f, -2.09404286e-02f, -2.59415627e-01f,
  -2.96585381e-01f, -8.71679112e-02f, 6.72798529e-02f, -1.75077438e-01f, -1.56982079e-01f, -2.24700034e-01f, -6.03722155e-01f, 2.45865986e-01f, 9.72562373e-01f, -9.25864100e-01f,
  -4.16889668e-01f, -9.00618881e-02f, -8.34182054e-02f, -5.11048794e-01f, -2.08048150e-01f, -8.36575150e-01f, -3.37429196e-01f, -6.21157363e-02f, 4.82715070e-01f, 2.15482023e-02f,
  1.23497200e+00f, 1.22379720e+00f, -3.49283256e-02f, 6.53612137e-01f, -4.89379585e-01f, 8.32685232e-01f, 1.85202599e+00f, 6.95487142e-01f, 1.29860640e+00f, 1.00553632e+00f,
  4.94075924e-01f, -3.69777858e-01f, 1.13093007e+00f, 4.05383915e-01f, 1.12773359e+00f, -1.78912252e-01f, -5.21840274e-01f, -1.20822817e-01f, -4.04069036e-01f, -1.57296121e-01f,
  -2.22256914e-01f, -2.63708740e-01f, 1.09929703e-02f, -7.07763135e-02f, -2.11948931e-01f, 9.92921412e-01f, 5.82068443e-01f, 1.43793154e+00f, -1.07245052e+00f, 1.85954249e+00f,
  9.53196228e-01f, 1.57766664e+00f, -8.84241462e-02f, 1.48065031e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  -3.81679684e-02f, -8.57342780e-02f, 8.16034079e-01f, 1.12344861e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.62696624e-01f, -4.37562577e-02f, -4.82203454e-01f, -9.76207852e-01f, -1.05412722e+00f, 5.27784169e-01f, 1.10240626e+00f, 9.76653278e-01f, 1.01250112e+00f, 5.19651353e-01f,
  5.89542508e-01f, 1.62136817e+00f, 1.56156898e-01f, 4.07819122e-01f, -8.56030047e-01f, -3.72732073e-01f, 1.30058348e-01f, -1.49329171e-01f, 9.21682000e-01f, 7.06884414e-02f,
  1.37638462e+00f, 5.36174178e-01f, -1.21904647e+00f, -1.18868220e+00f, 6.77413404e-01f, -1.08423829e+00f, 1.89408526e-01f, 1.16893625e+00f, -2.94312954e-01f, -3.65631133e-01f,
  -3.01403075e-01f, -8.45773399e-01f, -3.40283662e-01f, 1.38151908e+00f, -7.55566180e-01f, 2.93898642e-01f, 8.82009268e-02f, 1.29544449e+00f, -9.01751518e-01f, 5.27464926e-01f,
  -7.66639054e-01f, 1.68178296e+00f, -1.93318307e+00f, 4.76676971e-01f, -1.93563271e-02f, -4.49122280e-01f, -1.26173365e+00f, 4.72612470e-01f, -6.88796461e-01f, -7.68838465e-01f,
  6.96188927e-01f, -3.75461668e-01f, -5.47330976e-01f, -1.00834429e+00f, 2.79344708e-01f, 2.26464123e-02f, -4.36628491e-01f, -2.72139162e-01f, -6.78830206e-01f, -8.43592435e-02f,
  -9.97376382e-01f, -6.21573813e-02f, 3.00486535e-01f, 6.79120496e-02f, 1.47643372e-01f, -4.33352917e-01f, -4.14520442e-01f, 3.68806630e-01f, -6.04641102e-02f, -4.40087393e-02f,
  1.07854640e+00f, -7.66400516e-01f, 3.81583780e-01f, -1.21656704e+00f, -2.03713790e-01f, 3.25315058e-01f, 1.83027029e-01f, 5.06362915e-02f, -1.73347354e+00f, 6.26959562e-01f,
  -6.08171403e-01f, 4.46933538e-01f, 8.14051151e-01f, -1.69717216e+00f, -1.12458670e+00f, -3.63184094e-01f, -8.06218743e-01f, -3.68082136e-01f, -1.05053596e-01f, -3.26312661e-01f,
  2.54714519e-01f, -1.28893244e+00f, -5.31415701e-01f, 5.14386058e-01f, -7.81010687e-01f, -1.49907982e+00f, -1.02756286e+00f, 3.70220959e-01f, -3.01971108e-01f, 4.08188045e-01f,
  7.26137936e-01f, -1.49652648e+00f, 7.61347413e-01f, -1.57839251e+00f, 1.04697049e+00f, 5.10635674e-01f, -5.71453452e-01f, -9.22014713e-02f, 5.41619398e-03f, -8.08522940e-01f,
  5.63030422e-01f, 2.64024567e-02f, 7.73303032e-01f, 6.08715177e-01f, 1.37148678e-01f, 2.45225549e-01f, -3.70613366e-01f, 1.06023586e+00f, 1.00587976e+00f, 9.20287371e-01f,
  2.83127517e-01f, 1.59379974e-01f, 7.50569224e-01f, 4.41504687e-01f, -2.45776996e-02f, -5.14611661e-01f, 7.82295346e-01f, -9.43886876e-01f, -2.12809332e-02f, -3.11809093e-01f,
  2.83096880e-01f, 1.06812644e+00f, 5.01085043e-01f, -1.12072837e+00f, -8.36880565e-01f, 1.32022512e+00f, -1.12217832e+00f, 1.12667406e+00f, 1.29991114e+00f, -9.55948830e-01f,
  -5.78269623e-02f, 2.69404173e-01f, -1.23845458e+00f, -1.97562482e-02f, -3.03853780e-01f, -2.12577194e-01f, 1.03923607e+00f, -8.47386479e-01f, -5.17201781e-01f, 1.84439346e-02f,
  9.39711034e-01f, 1.11545134e+00f, -1.45655024e+00f, 4.49407905e-01f, -7.76737511e-01f, 6.77556276e-01f, -8.65929186e-01f, -1.23150301e+00f, 5.39073408e-01f, 3.78930211e-01f,
  1.24625695e+00f, 7.74881020e-02f, -1.84027791e+00f, 1.16295230e+00f, 7.62949109e-01f, -8.75397980e-01f, 1.37049997e+00f, -2.01712072e-01f, 7.58436441e-01f, -8.51506054e-01f,
  4.18633282e-01f, -1.78866410e+00f, -5.51953852e-01f, 2.11396500e-01f, 1.07657444e-02f, -4.55571681e-01f, 1.19997787e+00f, -1.33288848e+00f, -8.47900987e-01f, 8.35657418e-01f,
  -5.56131124e-01f, 2.92909503e-01f, -8.38448942e-01f, -5.14829159e-01f, 8.33564222e-01f, 3.82642925e-01f, -1.27296731e-01f, -9.90658104e-02f, -1.09822083e+00f, -7.42242336e-01f,
  -1.20584071e-02f, 7.20588923e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.19769979e-01f, 6.26468658e-01f, 5.25376201e-01f, -6.11070096e-01f, 1.34811342e-01f, 4.95838411e-02f, -9.96386781e-02f, 2.76981562e-01f, -2.46373951e-01f, -4.76492979e-02f,
  5.48704825e-02f, -6.38996949e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    