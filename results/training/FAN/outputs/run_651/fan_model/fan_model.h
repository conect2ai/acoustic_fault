/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.36988115e-01f, -4.95857626e-01f, -1.93375815e-02f, -7.34544843e-02f, 1.87960520e-01f, 8.55549350e-02f, -1.96286276e-01f, -1.46884322e-01f, -9.17656943e-02f, -1.62533060e-01f,
  -9.43667663e-04f, 3.41940582e-01f, 2.15872839e-01f, 1.32960796e-01f, 1.06380312e-02f, -1.91869795e-01f, -1.73864327e-02f, 1.04477338e-01f, 3.63109708e-01f, 1.67531863e-01f,
  7.83324167e-02f, 9.01314616e-02f, 7.79826380e-03f, 9.22652613e-03f, -1.15684249e-01f, 2.01852366e-01f, -8.25737417e-02f, -8.49491730e-02f, -8.51045251e-02f, -2.55176902e-01f,
  1.13600023e-01f, -4.13104385e-01f, 8.10767934e-02f, -6.08552992e-02f, -1.13384224e-01f, -7.74245933e-02f, -3.43694375e-03f, -1.53237313e-01f, -5.79258241e-02f, -6.81806728e-02f,
  -1.10668428e-01f, -7.51597015e-03f, 1.96849764e-03f, -2.06516292e-02f, -7.45154992e-02f, -1.00765660e-01f, -1.52650580e-01f, -1.17460348e-01f, 9.41195898e-03f, -6.04775660e-02f,
  -4.58207130e-02f, 1.54853761e-02f, -2.83542406e-02f, -5.99487722e-02f, -2.77600270e-02f, 1.12720907e-01f, -1.81226149e-01f, -1.18966743e-01f, -2.65878189e-04f, -2.01569185e-01f,
  1.40637085e-01f, 1.69482961e-01f, 4.60776277e-02f, -2.92111821e-02f, 8.23386237e-02f, 4.21365835e-02f, 7.69997910e-02f, 3.04085761e-02f, -9.63744428e-03f, 4.01386395e-02f,
  6.05675951e-02f, 1.01673752e-01f, 1.47941858e-02f, 4.39878330e-02f, 8.40782449e-02f, 3.79258692e-02f, 6.75045326e-02f, 4.77228500e-02f, 9.19469818e-02f, -3.85783873e-02f,
  -8.66327807e-03f, -9.72327869e-03f, -9.52106193e-02f, -2.14967933e-02f, -1.14120275e-01f, 3.70228589e-02f, 4.49407147e-03f, 9.31165442e-02f, 3.65021154e-02f, -1.22807370e-02f,
  -7.05103129e-02f, 1.55482113e-01f, -5.73727973e-02f, -1.62967145e-01f, -2.76780296e-02f, -1.41971648e-01f, 3.14121135e-02f, -1.42733427e-02f, -4.25218344e-02f, -8.62197354e-02f,
  -6.68581501e-02f, -2.25175126e-03f, 2.22741421e-02f, -6.99859038e-02f, -1.89949237e-02f, 3.11780684e-02f, -8.98270085e-02f, -1.44030629e-02f, -1.47936223e-02f, -1.36775225e-01f,
  -1.16309948e-01f, -5.98913282e-02f, 6.79322258e-02f, -1.93892401e-02f, -3.83021608e-02f, 1.01219937e-01f, 1.26760021e-01f, -4.69072498e-02f, 3.26945558e-02f, -8.45128447e-02f,
  -2.81781286e-01f, 9.82109979e-02f, -1.83749765e-01f, -8.73170421e-02f, -8.26165006e-02f, -9.41563174e-02f, -7.13056475e-02f, 1.25172764e-01f, 1.33820310e-01f, 6.28785640e-02f,
  1.98109552e-01f, 1.68354958e-01f, 5.11696041e-02f, 2.22957853e-04f, 7.10116997e-02f, 4.55046166e-03f, -1.69053450e-01f, -2.49693990e-01f, -1.55232638e-01f, 5.28368540e-02f,
  -8.86211097e-02f, -1.71672478e-01f, -7.43426606e-02f, 6.08356930e-02f, -1.68327302e-01f, 8.59703310e-03f, 1.17503256e-02f, -1.27602160e-01f, 6.78139850e-02f, -1.16881900e-01f,
  -1.23991981e-01f, -9.97394547e-02f, 4.07497548e-02f, -2.53148172e-02f, 8.57690945e-02f, 1.28112948e-02f, -3.23260464e-02f, 3.87539454e-02f, 4.88024913e-02f, 1.22786045e-01f,
  -2.54019704e-02f, 1.35281654e-02f, -2.80878190e-02f, -2.10612197e-03f, -1.97390001e-02f, 5.64991347e-02f, 8.66520479e-02f, -3.29998462e-03f, 4.99032959e-02f, 3.43859568e-03f,
  2.13792939e-02f, -4.32756990e-02f, -7.50700533e-02f, 9.75504890e-03f, 6.99374825e-02f, -1.08424731e-01f, 3.11618112e-02f, 4.49507684e-02f, -4.38472927e-02f, -3.71837094e-02f,
  1.38052262e-03f, 6.39426336e-02f, -5.49867339e-02f, 7.11650075e-03f, 4.72060259e-04f, 6.67868480e-02f, 1.82018038e-02f, -3.06852143e-02f, 4.28460129e-02f, 4.88444529e-02f,
  2.75150388e-02f, -3.04602273e-02f, -1.61383152e-02f, -2.88861468e-02f, 3.69175114e-02f, -6.64548948e-02f, -2.93922480e-02f, -1.22063011e-02f, 5.07145859e-02f, 4.43407148e-03f,
  -1.19722178e-02f, -2.17296518e-02f, -1.30531818e-01f, -6.80442229e-02f, -4.35390435e-02f, -1.67529453e-02f, -7.74894804e-02f, -3.00318934e-03f, -3.85256149e-02f, -3.20387483e-02f,
  5.16974889e-02f, -1.01862341e-01f, 7.71020427e-02f, 6.78302348e-02f, 5.80722978e-03f, 9.20647532e-02f, 5.47150448e-02f, 2.17031818e-02f, -5.81119508e-02f, -6.74987063e-02f,
  -3.47117521e-03f, -3.60998362e-02f, 1.46989524e-03f, 2.20712498e-02f, 1.29389614e-01f, 3.70735861e-02f, 1.08184077e-01f, -2.72446498e-02f, -6.53273836e-02f, 4.14079390e-02f,
  7.57667795e-02f, 4.41330485e-02f, 6.64312094e-02f, 1.22226879e-01f, -2.28023529e-02f, -4.84834872e-02f, 3.65961604e-02f, 8.95006880e-02f, -9.91526023e-02f, 1.71484664e-01f,
  6.45013573e-03f, -5.78411408e-02f, -6.43840060e-02f, 1.03390515e-01f, 1.93549559e-01f, 1.80046335e-01f, 8.95468742e-02f, 1.20608456e-01f, 1.34029999e-01f, -7.37275779e-02f,
  1.33465692e-01f, 3.79632205e-01f, 1.83288857e-01f, 2.37575218e-01f, 7.16038197e-02f, 1.27114067e-02f, -1.19507037e-01f, -2.30290778e-02f, 3.02626252e-01f, 1.62153468e-01f,
  7.42392018e-02f, 5.97090200e-02f, 6.41048849e-02f, 2.49119345e-02f, 4.11234908e-02f, 1.94532439e-01f, -1.88078329e-01f, -1.38504356e-01f, -5.61982542e-02f, -8.40112865e-02f,
  5.87048754e-03f, -9.38832015e-02f, 2.30469480e-01f, 1.88877091e-01f, 8.94274786e-02f, 1.62729397e-01f, 2.34325975e-01f, 5.70975542e-02f, 1.85824230e-01f, 7.02293962e-02f,
  9.81553048e-02f, 1.85231984e-01f, 2.37700596e-01f, 1.09629825e-01f, 1.11144334e-01f, 1.34176031e-01f, 4.75228988e-02f, 7.52347857e-02f, 1.24473043e-01f, 1.04992911e-01f,
  1.81843966e-01f, 1.04653247e-01f, 3.61486301e-02f, 9.79241505e-02f, -8.75503477e-03f, 2.21820161e-01f, 8.42338949e-02f, 5.27794734e-02f, -3.94253200e-03f, -4.58814017e-02f,
  -2.58493014e-02f, 1.09262414e-01f, 1.72023233e-02f, -5.86765334e-02f, -3.15648019e-02f, 8.90949145e-02f, -3.09970044e-02f, -7.60382926e-03f, 2.91764289e-02f, -4.13098931e-02f,
  6.91298023e-02f, -1.80563722e-02f, 1.20423259e-02f, 8.86798557e-03f, -7.54437596e-02f, -1.08507037e-01f, 4.61336598e-02f, -3.46094812e-03f, -4.04995829e-02f, -3.75075378e-02f,
  9.53104172e-05f, -5.66487499e-02f, 2.22104834e-03f, 2.13201605e-02f, -7.11997226e-02f, -1.45376265e-01f, -1.27401305e-02f, -7.54795969e-02f, -9.63044912e-02f, 2.74927635e-02f,
  1.27598107e-01f, 1.55034631e-01f, 1.61442578e-01f, 9.09523666e-02f, 4.23853919e-02f, 1.04160167e-01f, 1.31659359e-01f, 1.00258023e-01f, 1.34953395e-01f, 8.16386640e-02f,
  1.68071836e-01f, 1.81191593e-01f, 8.92665759e-02f, 1.28105894e-01f, 1.91198215e-01f, 1.61829472e-01f, 1.20307870e-01f, 1.00769989e-01f, 1.56462625e-01f, 3.77158336e-02f,
  4.08458430e-03f, 1.00758657e-01f, 1.39565334e-01f, 1.70786589e-01f, 1.27515808e-01f, 1.53783411e-01f, 1.94501668e-01f, 9.07836854e-02f, 1.65618986e-01f, 1.25043839e-01f,
  -5.13276756e-01f, 5.59847541e-02f, 1.49291292e-01f, -8.68005827e-02f, 3.78443271e-01f, 3.58305097e-01f, 3.08619708e-01f, 1.63333759e-01f, 9.14137810e-02f, 1.22335166e-01f,
  6.03879094e-02f, 2.51293425e-02f, -2.67979857e-02f, 3.09572909e-02f, 8.85571390e-02f, 2.60684639e-01f, 3.20803910e-01f, -5.42543903e-02f, -9.00568143e-02f, 1.41369268e-01f,
  2.49796063e-01f, 8.86421204e-02f, -1.76880345e-01f, -1.56691726e-02f, 1.05605088e-01f, 1.30769983e-01f, 1.43965304e-01f, 9.13892537e-02f, 3.09110582e-01f, 3.13951671e-01f,
  -1.85453251e-01f, -4.04262505e-02f, 9.00963992e-02f, 1.09369859e-01f, 1.52108848e-01f, 1.27009414e-02f, 1.36898831e-01f, -8.57202802e-03f, 1.22149363e-01f, 1.04176447e-01f,
  7.18016997e-02f, 7.28589967e-02f, 9.09619555e-02f, 4.31932695e-02f, 1.37970954e-01f, 3.38211246e-02f, -1.46285938e-02f, 9.50174115e-04f, 8.82852003e-02f, 1.28817512e-02f,
  1.76506206e-01f, 1.70233682e-01f, 1.09387264e-01f, 9.72920433e-02f, 1.67892426e-01f, 2.03131959e-01f, 9.73412320e-02f, 1.46298036e-01f, 6.99340701e-02f, 1.29489794e-01f,
  2.24670302e-02f, -4.82799299e-03f, -1.07622936e-01f, -1.30195990e-01f, -1.27117172e-01f, -6.56145588e-02f, -8.98337662e-02f, 8.17610766e-04f, -8.20773840e-02f, -7.46577382e-02f,
  -7.52946958e-02f, -1.71553791e-02f, -1.46175176e-01f, -1.09421462e-01f, -5.73424809e-02f, -1.19189344e-01f, -4.16929647e-02f, -7.11791292e-02f, -2.38604080e-02f, -1.58396661e-01f,
  -7.81275854e-02f, -1.40724614e-01f, -7.62358978e-02f, -1.04321353e-01f, -1.32929638e-01f, -1.10854603e-01f, -7.47293234e-02f, -6.20164685e-02f, -8.55966285e-02f, -1.03573002e-01f,
  -1.65139943e-01f, 1.00929439e-01f, 8.44614282e-02f, 1.34591237e-01f, 1.63100958e-01f, 9.68262479e-02f, 1.10572308e-01f, 8.34880695e-02f, 1.96862668e-01f, 9.14235041e-02f,
  7.70021230e-02f, 1.30936936e-01f, 4.19345647e-02f, 1.65864721e-01f, 1.35777518e-01f, 1.21449195e-01f, 5.26803844e-02f, 1.28884137e-01f, 1.01773910e-01f, 1.55723721e-01f,
  1.18385196e-01f, 1.73395857e-01f, 7.74742290e-02f, 2.00821236e-01f, 1.61950961e-01f, 1.23892002e-01f, 9.16231871e-02f, 1.05874926e-01f, 1.72601417e-01f, 1.34801805e-01f,
  -2.14459091e-01f, -1.40888184e-01f, 3.61045331e-01f, -1.65468723e-01f, 2.14053020e-01f, 2.56481975e-01f, 1.49909317e-01f, -1.06681630e-01f, -1.17210455e-01f, -1.58217922e-01f,
  -1.12037301e-01f, 2.50838958e-02f, 1.02338552e-01f, 1.01319902e-01f, 3.50757204e-02f, -1.35765700e-02f, 9.07392874e-02f, 2.70395160e-01f, 1.88050926e-01f, 1.20450780e-01f,
  1.45375684e-01f, -5.70844002e-02f, -8.83131698e-02f, -4.68162484e-02f, -4.09027189e-03f, 8.79623890e-02f, -3.77128134e-03f, 3.18280980e-02f, 5.51395230e-02f, 1.29704192e-01f,
  2.34392166e-01f, -1.15847327e-01f, -1.27654839e-02f, -3.64199691e-02f, 8.24918970e-02f, -5.09725176e-02f, -1.02024544e-02f, -1.11935206e-03f, -2.14095991e-02f, -1.32771377e-02f,
  -5.86283244e-02f, -3.23557705e-02f, 1.17529891e-01f, 5.74849080e-04f, -4.50678729e-02f, -3.81798223e-02f, -1.94192246e-01f, 5.80259552e-03f, 5.06227314e-02f, -6.65972978e-02f,
  4.05795276e-02f, -3.58732347e-03f, -4.37900312e-02f, -5.73515892e-02f, -5.07538356e-02f, 9.48285609e-02f, -4.85754833e-02f, -1.19890133e-02f, -3.56049910e-02f, -5.19910753e-02f,
  4.07609344e-02f, 4.28764857e-02f, 3.53854448e-02f, 1.39812054e-02f, 5.30588552e-02f, -2.88698301e-02f, 1.30186994e-02f, -4.05668616e-02f, -2.62072906e-02f, -2.71850824e-02f,
  7.03815296e-02f, 4.18238230e-02f, 6.69228286e-02f, -5.17071709e-02f, -3.84262167e-02f, 8.36126953e-02f, 6.85575942e-04f, -8.73972923e-02f, -2.37286594e-02f, 1.18528828e-02f,
  1.80376489e-02f, 1.67775471e-02f, 1.45034178e-03f, -4.53923978e-02f, -2.37979405e-02f, -1.67272380e-03f, 4.01360681e-03f, 9.10789818e-02f, -6.20139912e-02f, 3.26294042e-02f,
  3.13797646e-04f, 7.45766088e-02f, -5.63993305e-02f, -1.19922467e-01f, 3.28491926e-02f, -5.71320280e-02f, -5.11910915e-02f, 3.28664705e-02f, -1.44076543e-02f, 2.63684113e-02f,
  -5.73571445e-03f, -5.31958528e-02f, 2.54711285e-02f, -3.06136403e-02f, 3.23987976e-02f, -8.64855200e-03f, -4.07667309e-02f, -2.70148716e-03f, -6.00111969e-02f, -4.04314622e-02f,
  -1.62788212e-01f, 1.00943588e-01f, 1.20652027e-01f, 7.62062296e-02f, 1.25356987e-01f, 1.36560693e-01f, 1.46207586e-01f, 1.01922818e-01f, 7.59699866e-02f, 4.34177779e-02f,
  -1.01527035e-01f, 2.44294312e-02f, -1.07743159e-01f, 1.06558822e-01f, 1.85460344e-01f, 1.05070606e-01f, 1.86168194e-01f, 4.66757501e-03f, -2.35501789e-02f, 3.47144417e-02f,
  -5.46738058e-02f, -1.59013227e-01f, -2.53631204e-01f, -1.62493572e-01f, -2.32808396e-01f, 5.74084371e-02f, 2.56478548e-01f, 7.66979065e-03f, -1.35090992e-01f, -2.84987018e-02f,
  9.42779034e-02f, -1.78624615e-02f, -1.29947677e-01f, -9.54227298e-02f, 2.33036265e-01f, -8.63286778e-02f, 8.03804845e-02f, -5.20712845e-02f, 2.91961432e-02f, 3.45446974e-01f,
  -1.52165592e-01f, -2.07307801e-01f, -5.89006990e-02f, -8.76166224e-02f, -5.27200289e-02f, -1.04594029e-01f, -1.22456759e-01f, -7.77174905e-02f, -3.09162606e-02f, -9.26268771e-02f,
  -2.92714145e-02f, -1.25421628e-01f, -4.88673784e-02f, 5.56324376e-03f, -2.58354992e-02f, -8.74764770e-02f, -1.53651148e-01f, -1.46472141e-01f, -1.05073705e-01f, -1.53952464e-01f,
  5.56108251e-04f, -1.14697665e-02f, -4.25441153e-02f, 1.16112819e-02f, -1.04713567e-01f, 8.75196978e-02f, -8.30042586e-02f, -6.12059757e-02f, -2.06897054e-02f, -3.70268226e-02f,
  -2.69570556e-02f, 5.88854924e-02f, 7.46510699e-02f, 4.09180149e-02f, 6.73831180e-02f, 4.18096669e-02f, 9.79296044e-02f, 1.07441302e-02f, 9.23726484e-02f, 8.75178054e-02f,
  2.20864564e-02f, 2.54692677e-02f, 5.03860749e-02f, -2.88035534e-02f, 1.15991250e-01f, 4.12347466e-02f, 9.23827365e-02f, 5.09080775e-02f, -1.38250321e-01f, 4.90760319e-02f,
  -4.16118093e-02f, 1.97515395e-02f, -6.46107495e-02f, -4.98757213e-02f, 8.22413713e-03f, 6.78107664e-02f, -1.23050995e-02f, 5.22686867e-03f, 4.38586622e-02f, 7.57420212e-02f,
  -9.42619890e-02f, -2.10813954e-01f, -4.80160601e-02f, -6.35304451e-02f, -8.83767530e-02f, -8.26809481e-02f, -8.33480805e-02f, -6.13466352e-02f, -1.14779582e-03f, -1.36171490e-01f,
  -1.44152865e-01f, -9.66564193e-02f, -1.42433628e-01f, -2.97117587e-02f, -2.88887732e-02f, -2.63766907e-02f, -5.77279218e-02f, -4.78379391e-02f, -1.20634459e-01f, -1.74141172e-02f,
  -7.73419365e-02f, -4.43812385e-02f, 8.36287718e-03f, -6.48834407e-02f, -3.37784849e-02f, 2.44405083e-02f, 4.13197316e-02f, -5.23393340e-02f, -4.84285988e-02f, -1.94627966e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.65283319e-02f, 4.16727960e-02f, 3.94870132e-01f, 8.80400091e-02f, 7.01481756e-03f, -4.11508560e-01f, -6.40268683e-01f, -4.68558371e-01f, -5.73534593e-02f, -2.13972460e-02f,
  -1.00531615e-01f, -3.62790525e-02f, 1.09138824e-01f, -1.93391684e-02f, -1.62613988e-01f, -4.68888842e-02f, 2.19987422e-01f, 3.10741127e-01f, -1.09416828e-01f, -3.86231989e-01f,
  -7.42834955e-02f, 7.17243254e-02f, 1.60942093e-01f, -1.93162798e-03f, 1.00301653e-01f, -1.54360130e-01f, 2.63382137e-01f, 1.96187600e-01f, -2.54436061e-02f, 5.08912742e-01f,
  3.89389664e-01f, 1.16388619e-01f, -2.85534211e-03f, -4.41255048e-02f, 2.07327798e-01f, 8.40246007e-02f, -1.21286742e-01f, 3.57463419e-01f, 3.49437967e-02f, 8.49168450e-02f,
  2.14486316e-01f, -2.83853762e-04f, 1.19219743e-01f, 5.59643954e-02f, -6.12295559e-03f, -1.23470493e-01f, 6.80337474e-02f, 2.19844759e-01f, 6.82982244e-03f, -2.14688312e-02f,
  2.95341201e-03f, 2.44527794e-02f, -2.38830727e-02f, -1.66656524e-01f, -1.56808030e-02f, 3.27533334e-02f, -1.71284378e-01f, -1.01467364e-01f, -1.41536161e-01f, 7.14963228e-02f,
  -1.51782259e-02f, 6.14910461e-02f, 1.11408150e-02f, 1.00166462e-01f, -4.10187840e-02f, 9.43924636e-02f, 1.83663577e-01f, 1.38230296e-03f, -9.52446237e-02f, -1.08236775e-01f,
  -2.93858033e-02f, 7.39714429e-02f, 7.35320002e-02f, 2.57640071e-02f, -8.73478949e-02f, 3.23066637e-02f, -1.36684865e-01f, 1.86144691e-02f, 8.84982795e-02f, -4.81677102e-03f,
  2.95224460e-03f, 5.06051667e-02f, 7.30778873e-02f, -3.69154252e-02f, 1.10883914e-01f, 8.83245543e-02f, 8.39989781e-02f, -6.59725666e-02f, -2.83544362e-02f, 1.63713008e-01f,
  -1.13931611e-01f, 4.48659137e-02f, -2.99684107e-02f, 1.10954940e-02f, 1.86360776e-01f, -7.99294040e-02f, 9.51256510e-03f, 3.63844372e-02f, -3.50944810e-02f, -1.82733536e-01f,
  -2.79651165e-01f, -1.31103814e-01f, 6.97792172e-02f, -1.53803090e-02f, -1.63412765e-02f, -1.02769665e-01f, -5.37953898e-02f, -9.90457088e-02f, -1.60252303e-01f, -8.55895802e-02f,
  -1.13937616e-01f, -3.43437403e-01f, -3.40489864e-01f, -9.23179016e-02f, -1.95579663e-01f, -3.06542218e-01f, -2.99181908e-01f, -2.61411875e-01f, -2.75934696e-01f, -3.48871708e-01f,
  -5.29277086e-01f, -2.68802457e-02f, 3.33373994e-02f, 2.14635000e-01f, 1.96743742e-01f, -4.51988161e-01f, -7.51916051e-01f, -4.56430942e-01f, 9.91675630e-03f, -8.61106347e-03f,
  3.13839942e-01f, 5.75710177e-01f, 2.29015410e-01f, -6.26864880e-02f, -6.86704874e-01f, -5.55522323e-01f, -5.05983293e-01f, -4.98237222e-01f, -4.00839120e-01f, -3.52307111e-02f,
  7.89498985e-02f, 3.87669951e-02f, -6.48034317e-03f, -2.66242940e-02f, 3.29310060e-01f, 3.21614891e-01f, 1.79008514e-01f, 1.24078996e-01f, -2.25267038e-02f, 1.86579347e-01f,
  4.74733323e-01f, -5.96286952e-02f, -1.82898775e-01f, -1.73013791e-01f, 2.15637594e-01f, -7.57761449e-02f, -5.44363372e-02f, -1.65177602e-02f, 5.16800806e-02f, -1.04543865e-01f,
  1.13859840e-01f, 4.35531698e-02f, 1.73821468e-02f, 2.22608507e-01f, -7.68895552e-05f, 1.22722555e-02f, -6.68559149e-02f, -2.57374018e-01f, -1.07294336e-01f, 1.88751549e-01f,
  2.13740662e-01f, 2.90308092e-02f, 1.96586531e-02f, -1.09099701e-01f, -1.27350852e-01f, 8.61304440e-03f, 1.05304055e-01f, -1.38492575e-02f, -2.03995794e-01f, 7.33326226e-02f,
  -1.41349390e-01f, 8.22671428e-02f, 1.12916119e-01f, 8.46109018e-02f, -9.72119905e-03f, 8.84473547e-02f, 3.51518393e-02f, 6.47009462e-02f, -1.33776844e-01f, 7.63973892e-02f,
  4.77245338e-02f, 3.91370691e-02f, -4.30546030e-02f, -1.48679996e-02f, 1.44489825e-01f, 4.65499163e-02f, -6.16140477e-02f, -1.06118005e-02f, 1.76160969e-02f, -3.70292924e-02f,
  -7.30554014e-02f, -5.72282039e-02f, 7.43780062e-02f, 9.84682585e-04f, -1.41365737e-01f, -5.92951626e-02f, 1.23156933e-02f, -7.16633920e-04f, 6.11355640e-02f, -8.75001475e-02f,
  3.06738257e-01f, -4.01044458e-01f, 1.09605148e-01f, -5.47055006e-02f, 9.74029303e-02f, 7.10525513e-02f, 2.51911610e-01f, 4.03805748e-02f, 1.12308890e-01f, 3.62718627e-02f,
  4.26418893e-02f, 3.99964787e-02f, 1.52285367e-01f, 1.25319913e-01f, -6.29603416e-02f, 8.84881467e-02f, 2.93727238e-02f, 4.20771092e-02f, -1.38407812e-01f, 1.43580407e-01f,
  -1.40236095e-01f, -2.81844735e-01f, -3.77074629e-02f, 6.76038340e-02f, -7.67780766e-02f, -3.79469022e-02f, 1.92767844e-01f, 1.11602873e-01f, -2.27656648e-01f, -9.35451314e-02f,
  5.71483374e-01f, 2.36723229e-01f, 1.30210817e-01f, 2.76243299e-01f, 1.56498611e-01f, 1.87869325e-01f, 2.12953404e-01f, 1.95961580e-01f, 1.40453175e-01f, 3.33520621e-01f,
  3.29740345e-01f, 3.27084512e-01f, 2.66475648e-01f, 2.62909740e-01f, 2.00218678e-01f, 8.04932043e-02f, 1.16304994e-01f, -3.03187431e-03f, 9.91997048e-02f, 2.25926787e-01f,
  1.61963537e-01f, 5.44506311e-02f, 1.02811582e-01f, 1.03430539e-01f, 3.09779346e-02f, 2.00397119e-01f, 7.60694668e-02f, 6.85338899e-02f, 1.24411613e-01f, -4.40809578e-02f,
  2.45180443e-01f, 1.30927265e-01f, -1.59032539e-01f, -1.55049756e-01f, -1.12430371e-01f, -2.14536428e-01f, -5.75999990e-02f, -1.04802266e-01f, -8.82016793e-02f, -1.31724328e-01f,
  -1.64183408e-01f, -2.22657137e-02f, 5.73452748e-02f, -8.89725462e-02f, -2.21345693e-01f, -1.75050437e-01f, -8.60018209e-02f, 1.45249218e-01f, 7.86683783e-02f, 4.93861474e-02f,
  -9.72526055e-03f, 1.40685871e-01f, 6.56908527e-02f, -2.13505737e-02f, 1.31793693e-01f, -4.90355212e-03f, -2.51392517e-02f, 4.61786613e-02f, 6.57870620e-02f, -8.28502420e-03f,
  -1.40311733e-01f, -9.83474962e-03f, 1.57007590e-01f, 2.39206985e-01f, 1.52588889e-01f, 1.19244218e-01f, 5.70200309e-02f, 7.06855208e-02f, 1.50518745e-01f, -1.17668726e-01f,
  -1.92805141e-01f, 5.41736931e-02f, 1.50762558e-01f, 7.93370008e-02f, 5.94025031e-02f, 1.74235448e-01f, -2.71163881e-02f, 5.40706217e-02f, 6.63058981e-02f, 2.31561325e-02f,
  1.39369145e-01f, -1.03483507e-02f, -1.27243161e-01f, -1.04165385e-02f, 9.19122472e-02f, 8.13203976e-02f, 8.55862647e-02f, 3.69503163e-02f, -3.62764625e-03f, -1.13895446e-01f,
  5.21047637e-02f, 2.45598331e-01f, 1.14667237e-01f, -1.59157682e-02f, -7.30909929e-02f, -2.63364553e-01f, 1.74973533e-01f, -9.75255668e-02f, -2.49787882e-01f, -2.08309721e-02f,
  -2.89757345e-02f, 1.83069371e-02f, -6.60620481e-02f, 4.55217808e-02f, -1.76325843e-01f, -5.68745695e-02f, 7.35498145e-02f, 1.24968179e-01f, 6.43675104e-02f, -2.01607645e-02f,
  -8.44816305e-03f, 5.58907539e-02f, -1.09569645e-02f, -7.77037889e-02f, -6.39734194e-02f, -6.19040467e-02f, -5.89038543e-02f, -1.92001045e-01f, -1.29370928e-01f, -1.64375931e-01f,
  5.81492782e-01f, 1.82703555e-01f, 2.13143602e-01f, -5.43821743e-03f, -7.04088733e-02f, -3.80971402e-01f, -4.17405307e-01f, -2.45747432e-01f, -1.63477421e-01f, 4.06892337e-02f,
  -9.45396274e-02f, -9.61072445e-02f, -5.40799387e-02f, 2.16343701e-02f, -1.80847645e-02f, 1.24445735e-02f, 1.62822798e-01f, 2.86541373e-01f, 4.88962270e-02f, -2.82660872e-02f,
  -6.84702918e-02f, 2.83078462e-01f, 3.39006186e-01f, 1.65218245e-02f, 2.26148531e-01f, -8.56145397e-02f, 9.99444053e-02f, 1.42011076e-01f, 1.59930870e-01f, 4.01398957e-01f,
  2.11056501e-01f, 3.48776996e-01f, -1.79424867e-01f, 9.35253650e-02f, 1.20729014e-01f, 1.10775180e-01f, -2.04250421e-02f, 4.85816300e-02f, -1.12430565e-01f, -1.90692917e-02f,
  1.26775175e-01f, 1.74847618e-01f, 9.36023369e-02f, -2.98399143e-02f, 3.71685401e-02f, -3.80269662e-02f, -3.65021639e-03f, 1.01871021e-01f, -1.05896421e-01f, 1.20244054e-02f,
  -1.16446249e-01f, 8.53711292e-02f, 2.74492279e-02f, -2.28484914e-01f, -5.14738709e-02f, -9.05914977e-02f, 5.30104116e-02f, -9.26051103e-03f, -8.46440643e-02f, -4.60212082e-02f,
  -1.23113938e-01f, 2.37768948e-01f, 9.74143222e-02f, -1.14754513e-01f, -7.56206512e-02f, -1.16732001e-01f, -8.04659054e-02f, -3.21846902e-02f, -9.20211002e-02f, -1.84308477e-02f,
  -1.52509853e-01f, -1.95827305e-01f, -1.22232758e-01f, 4.51799063e-03f, -3.34978737e-02f, 7.20646605e-02f, -2.33474676e-03f, 2.80475467e-02f, -1.59382835e-01f, 6.77563921e-02f,
  2.88535710e-02f, -5.67964390e-02f, 1.65598001e-02f, 8.47499594e-02f, 3.18008289e-02f, -3.17614302e-02f, -3.02401595e-02f, -6.81544617e-02f, 9.36847478e-02f, -7.03160046e-03f,
  -2.56382912e-01f, -1.95158884e-01f, 1.24350712e-02f, 1.81888208e-01f, 1.15833588e-01f, 1.19056739e-01f, 3.42352279e-02f, -2.95682196e-02f, -6.78252429e-02f, -1.25941813e-01f,
  1.54803142e-01f, 8.52900669e-02f, 6.74814731e-02f, 4.45493832e-02f, -1.11315809e-01f, -5.27252518e-02f, 2.48762183e-02f, 2.84349322e-02f, -1.14030927e-01f, 6.44554794e-02f,
  -2.54058000e-02f, -1.04170419e-01f, -1.44212037e-01f, -3.10174763e-01f, -1.98185444e-01f, -1.87127829e-01f, -3.85087058e-02f, 6.36950508e-02f, -1.76135480e-01f, -3.11909914e-01f,
  9.21603858e-01f, -1.58764869e-01f, -6.90540731e-01f, 3.33820403e-01f, -3.83523524e-01f, -3.60821307e-01f, -4.72239196e-01f, 2.19950229e-01f, 3.53950083e-01f, -1.94136605e-01f,
  -1.69973865e-01f, 1.22003183e-01f, 2.37450581e-02f, -7.77365267e-02f, 1.38186306e-01f, -2.89009660e-01f, -2.37587884e-01f, -2.42196694e-01f, -7.31107816e-02f, -3.23592722e-02f,
  -3.50507833e-02f, 1.52402565e-01f, 3.39940280e-01f, 2.41257608e-01f, -1.88789114e-01f, 2.72809155e-03f, -3.68153751e-01f, -2.40759879e-01f, -3.56812179e-01f, -3.96137774e-01f,
  -3.68072331e-01f, 4.57134135e-02f, -1.63849860e-01f, 2.85315722e-01f, -1.73844159e-01f, 1.62173852e-01f, -1.16306115e-02f, -3.60787921e-02f, 1.33090436e-01f, 8.01098868e-02f,
  2.08707824e-02f, -6.54676929e-02f, 6.42851964e-02f, -9.96604785e-02f, -3.51263322e-02f, -7.19624683e-02f, -1.72389485e-02f, -2.39415723e-03f, -2.15402208e-02f, -4.24585901e-02f,
  -1.81741938e-02f, -1.95481345e-01f, -3.04166019e-01f, -2.26698890e-01f, -1.24250889e-01f, -8.88694972e-02f, -2.83139437e-01f, -2.55694687e-01f, -3.73919368e-01f, -2.30418593e-02f,
  2.86409650e-02f, -1.98781658e-02f, -9.72487926e-02f, 1.34224579e-01f, 1.72027230e-01f, 2.43769679e-02f, 1.52658194e-01f, -8.10113773e-02f, 6.53159767e-02f, -9.46267247e-02f,
  6.16872460e-02f, -1.33382315e-02f, 3.23466808e-02f, 8.69174004e-02f, 2.15224996e-02f, -8.29699114e-02f, 4.67620930e-03f, -1.67994313e-02f, 3.34015824e-02f, 1.72203872e-02f,
  -2.18699332e-02f, -1.57483146e-02f, 9.30618681e-03f, 1.10348180e-01f, 2.29990203e-03f, 6.32659048e-02f, -7.66718164e-02f, -3.02062482e-02f, 8.08743984e-02f, 2.37088818e-02f,
  3.51513326e-01f, -1.28792524e-01f, 1.59188762e-01f, 1.89693347e-02f, -1.23611882e-01f, -1.94586366e-02f, 4.36582156e-02f, -4.90720123e-02f, 6.19319379e-02f, -8.98993835e-02f,
  -1.01273440e-01f, 7.01024011e-02f, 5.59501424e-02f, -9.39244181e-02f, 2.65396554e-02f, -8.26535076e-02f, 8.00903514e-02f, -8.06748718e-02f, -1.75394882e-02f, 9.22403261e-02f,
  1.98296279e-01f, 6.50794581e-02f, 1.16030455e-01f, -7.53799826e-02f, 4.15981282e-03f, 1.01968162e-01f, -1.85614228e-01f, -9.49674249e-02f, 1.73236115e-03f, 2.97849327e-01f,
  -4.07834023e-01f, 1.40226945e-01f, -5.69624484e-01f, 1.63811654e-01f, 4.30243611e-01f, 9.08318609e-02f, 6.96824072e-03f, -4.95114103e-02f, 1.51588440e-01f, -7.26749375e-02f,
  -2.90606543e-03f, 2.24982098e-01f, 1.84640333e-01f, 9.53069180e-02f, -2.72711813e-01f, 1.20611064e-01f, 2.56631970e-01f, -7.80858099e-02f, -3.96792650e-01f, -1.93451896e-01f,
  2.63999373e-01f, 5.83992936e-02f, -3.62267256e-01f, -4.04332429e-02f, 2.56821781e-01f, 1.28948435e-01f, -8.79970044e-02f, -4.00225036e-02f, 2.99556237e-02f, 4.87022638e-01f,
  -5.55536509e-01f, -1.43238544e-01f, -9.93834957e-02f, 2.65464783e-01f, -1.00663446e-01f, -1.62875995e-01f, -3.05171728e-01f, -1.56259999e-01f, 7.91045353e-02f, -1.38757810e-01f,
  1.73958659e-01f, -6.59550205e-02f, 2.54390031e-01f, 6.11059554e-02f, -6.04571626e-02f, -1.43673927e-01f, -1.39521137e-01f, -2.69871980e-01f, -1.99062601e-01f, -1.86888874e-01f,
  5.22438943e-01f, 1.93169907e-01f, -1.76461279e-01f, -1.29879624e-01f, -2.38443628e-01f, 1.33763880e-01f, -1.88250318e-01f, -6.68630898e-02f, -4.25666302e-01f, -1.86348557e-01f,
  -4.82205190e-02f, -8.20599794e-02f, 2.34658755e-02f, -1.89743191e-02f, 4.71455604e-02f, 7.76367262e-02f, -4.60593067e-02f, 1.02528967e-01f, 3.62698697e-02f, -1.25255808e-01f,
  -5.04568182e-02f, -1.27284750e-01f, -2.50215959e-02f, -1.82272702e-01f, 4.74451445e-02f, 2.56964024e-02f, 1.70296524e-02f, -3.46651338e-02f, -1.78357124e-01f, -1.77753240e-01f,
  3.33051607e-02f, -6.81546405e-02f, -6.03134073e-02f, 1.62566021e-01f, -3.98763828e-02f, -1.17494911e-01f, 1.47519723e-01f, -3.59238312e-02f, 7.27149397e-02f, -5.59119396e-02f,
  -7.20153600e-02f, -2.01415449e-01f, -1.20329365e-01f, -4.10597920e-02f, 9.02734324e-03f, -2.83298865e-02f, 1.00568747e-02f, -6.37130216e-02f, 9.28609222e-02f, -1.65335715e-01f,
  -2.99438704e-02f, -1.77137211e-01f, 3.35051753e-02f, 7.38497823e-02f, -9.50909927e-02f, -7.72302831e-03f, 8.03372487e-02f, 1.22783720e-01f, -1.21705020e-02f, 1.89290643e-02f,
  1.47154303e-02f, -7.02017397e-02f, -9.01450738e-02f, -2.08765343e-02f, 1.58650771e-01f, -5.16395830e-02f, -7.57637471e-02f, -1.16433844e-01f, -3.41912299e-01f, -2.45404512e-01f,
  1.99289009e-01f, -4.18369502e-01f, 2.90722072e-01f, 2.52399296e-02f, -3.24245617e-02f, 1.32997930e-01f, -3.15114498e-01f, 1.11645073e-01f, -8.99290491e-04f, -3.05833727e-01f,
  1.16848804e-01f, 1.27563417e-01f, 1.61193162e-01f, 1.85983956e-01f, 2.85740644e-01f, -2.96278059e-01f, -2.62554228e-01f, 2.83708364e-01f, 6.64767921e-01f, 1.52974546e-01f,
  -1.90331563e-01f, -2.16483921e-01f, 1.84666246e-01f, -4.52696122e-02f, -6.44470513e-01f, -7.61124492e-02f, -3.89541090e-01f, -3.16608608e-01f, -2.23248690e-01f, -7.44435072e-01f,
  -1.88847095e-01f, 1.42750904e-01f, 1.61647454e-01f, 6.10201061e-02f, -3.33619751e-02f, 6.86235726e-02f, 4.66606580e-02f, -1.57716110e-01f, -8.10284466e-02f, -8.56580883e-02f,
  -7.62878284e-02f, 8.85255933e-02f, -4.79685143e-02f, -7.29417801e-02f, -4.12342660e-02f, -3.59549224e-02f, 1.58663630e-01f, 9.25217271e-02f, 8.56826976e-02f, -6.81299418e-02f,
  -2.48752207e-01f, -2.82956779e-01f, 1.03121996e-02f, 7.89609030e-02f, 9.90125835e-02f, 2.61681098e-02f, -4.44352701e-02f, -2.57295091e-02f, 5.38054258e-02f, -6.47260368e-01f,
  -1.52630163e-02f, 2.20023096e-03f, 1.96143880e-01f, -8.83589126e-03f, 3.36575769e-02f, -8.07170942e-02f, 6.03693984e-02f, -1.42652094e-01f, -3.84547971e-02f, -1.84049364e-02f,
  9.30972174e-02f, -6.55273069e-03f, -1.11130718e-02f, -1.99767634e-01f, -3.89214568e-02f, -2.99094617e-01f, -4.96021807e-02f, -7.14193583e-02f, -6.31754547e-02f, -2.66973674e-02f,
  6.10469840e-02f, 8.04399475e-02f, -7.32194036e-02f, 1.20256238e-01f, 1.57710444e-02f, -2.41361652e-02f, 1.98145118e-03f, 7.84963742e-02f, -1.20607130e-02f, -1.19817264e-01f,
  -1.55047432e-01f, 4.16069835e-01f, -3.03211004e-01f, 1.57211915e-01f, 1.22619465e-01f, -4.61069085e-02f, -6.69133365e-02f, 1.64204642e-01f, 1.18754238e-01f, 1.01528093e-01f,
  5.50239943e-02f, -5.20660393e-02f, -5.39660715e-02f, 3.30884494e-02f, 1.25047922e-01f, -6.36031255e-02f, 1.89536270e-02f, 4.37647365e-02f, -3.66601087e-02f, -1.10696018e-01f,
  6.43541515e-02f, -1.70925915e-01f, -1.68944240e-01f, -7.15930611e-02f, -2.85104692e-01f, -4.61684056e-02f, -7.77584761e-02f, -2.42631346e-01f, -3.62676308e-02f, -5.77711642e-01f,
  -1.56546339e-01f, 2.28774361e-02f, -3.75654623e-02f, -9.20318067e-02f, -9.66469478e-03f, 1.25580505e-02f, -1.99449450e-01f, 1.51441038e-01f, 3.44389200e-01f, -6.23201989e-02f,
  1.36324987e-01f, -3.88085656e-02f, -7.16349995e-03f, -2.93789357e-01f, -4.87579465e-01f, -3.67189378e-01f, -4.18317765e-01f, -4.73072261e-01f, -3.54106098e-01f, -1.69905588e-01f,
  -1.71860456e-01f, -2.04387411e-01f, -3.33416432e-01f, -4.19051275e-02f, 1.16021946e-01f, 1.04151130e-01f, 1.27621099e-01f, -3.83586325e-02f, 3.15701254e-02f, 5.10892877e-03f,
  1.25398468e-02f, 1.22755267e-01f, -3.10804825e-02f, 5.85531071e-02f, 1.10862300e-01f, -1.32754948e-02f, 7.77825788e-02f, 3.78573537e-02f, 1.21038772e-01f, 7.50631690e-02f,
  -3.08742151e-02f, 1.29501432e-01f, -6.65190816e-02f, -1.04886508e-02f, 9.74763706e-02f, -2.29498029e-01f, -1.69015061e-02f, -1.99759558e-01f, -2.18548313e-01f, -1.92419946e-01f,
  -3.02784622e-01f, -1.28046393e-01f, -2.11122096e-01f, -1.10067517e-01f, 2.87949368e-02f, -2.69030649e-02f, 8.29119310e-02f, 1.56595215e-01f, 1.47428557e-01f, 1.70919389e-01f,
  -1.50501914e-02f, 1.49865840e-02f, -5.15595265e-02f, -8.34859759e-02f, -4.64850999e-02f, 1.25134781e-01f, -5.59167825e-02f, -1.16936401e-01f, 1.47714447e-02f, -2.85214018e-02f,
  3.13366838e-02f, 1.54260844e-01f, 1.34511247e-01f, -7.50659630e-02f, 4.14572693e-02f, -6.57289568e-03f, -1.71092987e-01f, -2.31467128e-01f, -4.29833010e-02f, 5.60521372e-02f,
  1.28610894e-01f, 4.67033908e-02f, 2.06499532e-01f, 5.87212965e-02f, -4.75019142e-02f, -7.76159624e-03f, 1.85852855e-01f, 4.59695272e-02f, 1.41485766e-01f, 8.43703598e-02f,
  -5.48762865e-02f, -3.17176402e-01f, -2.72073802e-02f, 1.85720585e-02f, -3.94609049e-02f, 7.33000636e-02f, 2.84534097e-02f, -2.14385670e-02f, 1.76706567e-01f, -2.47892663e-01f,
  -4.38688248e-02f, -9.87076480e-03f, 1.03965513e-02f, -2.92937197e-02f, -1.62690897e-02f, -2.90315241e-01f, -1.96337521e-01f, -9.74222869e-02f, -1.28930777e-01f, -1.27194270e-01f,
  -2.48854488e-01f, -1.42539173e-01f, -4.16624457e-01f, -1.27996370e-01f, -7.27692270e-04f, -9.84133929e-02f, -1.13004886e-01f, 1.31919488e-01f, -2.16953561e-01f, -2.11212054e-01f,
  5.60325384e-01f, -3.20234776e-01f, 4.65434164e-01f, 3.45930636e-01f, 5.49731851e-01f, 5.42525053e-01f, 6.06544614e-01f, 2.31351867e-01f, 1.13793537e-01f, 1.33739293e-01f,
  -2.41322771e-01f, -2.77360231e-01f, -1.50714576e-01f, -1.92248821e-01f, -9.97158885e-02f, 1.08723573e-01f, 1.80363357e-01f, 1.78692490e-01f, 2.33280003e-01f, 1.88892871e-01f,
  -6.90645352e-02f, 1.46686867e-01f, 5.69867566e-02f, -6.28982931e-02f, 4.67529893e-03f, 4.18113433e-02f, 3.13180014e-02f, -3.68884243e-02f, -9.81323570e-02f, -1.58065021e-01f,
  -5.22726595e-01f, 2.20908314e-01f, 2.41506044e-02f, -2.88168073e-01f, -5.22630662e-02f, -1.02931365e-01f, -5.69258444e-02f, -8.49904343e-02f, -4.60405611e-02f, -5.30982949e-03f,
  -1.73510402e-01f, -1.12892948e-01f, -1.27750963e-01f, -3.20362113e-02f, 4.49105650e-02f, -6.86805099e-02f, -5.31630963e-02f, 1.14052601e-01f, -1.40501380e-01f, -1.51822090e-01f,
  -6.88600168e-02f, 8.81407186e-02f, 1.24948077e-01f, 2.30302960e-02f, 1.53067112e-01f, -2.88165603e-02f, -4.47014607e-02f, 1.14795186e-01f, 9.14545059e-02f, 1.26707882e-01f,
  -5.62502891e-02f, 1.27127409e-01f, -5.72121851e-02f, 4.16493118e-02f, 1.27236471e-01f, 1.26043379e-01f, 7.68120289e-02f, 9.43147093e-02f, 2.85108350e-02f, 9.90149193e-03f,
  -2.36404538e-02f, -9.47710201e-02f, -2.75216457e-02f, -1.05798602e-01f, -2.42621407e-01f, -3.69328111e-02f, 6.88564479e-02f, -2.59475529e-01f, -1.64097756e-01f, -8.24532211e-02f,
  1.78497620e-02f, 1.06455401e-01f, -1.16137475e-01f, -1.72091186e-01f, -2.00060546e-01f, 6.24779053e-03f, -9.96543020e-02f, -1.64404362e-01f, -6.38570860e-02f, 6.71140105e-02f,
  -4.25356120e-01f, -2.40635768e-01f, -7.14101195e-02f, -3.48295867e-02f, 7.19540790e-02f, -1.05562732e-01f, -4.56517451e-02f, -1.48157910e-01f, -3.55760530e-02f, -6.53850660e-02f,
  -6.76200315e-02f, -4.15461063e-02f, -8.51328000e-02f, 3.79573740e-02f, 2.95440137e-01f, -3.47487070e-02f, 1.40743749e-03f, 4.51129079e-02f, 7.93332979e-03f, -5.37883490e-02f,
  -1.27852783e-01f, 9.23496559e-02f, 1.53255248e-02f, 1.07759848e-01f, 9.90638286e-02f, 7.37302899e-02f, 1.08771242e-01f, 7.49197230e-03f, 8.06666352e-03f, 1.82163790e-01f,
  1.82389960e-01f, -8.44733790e-03f, -1.48692325e-01f, 1.22365706e-01f, -8.04328918e-02f, -4.08730745e-01f, -5.00313044e-01f, -4.25556421e-01f, 1.50700323e-02f, -2.72841845e-02f,
  -1.18723027e-01f, 1.68570355e-01f, 3.26951989e-03f, 8.18752721e-02f, -2.32457444e-02f, -7.95162991e-02f, 1.90918669e-01f, 3.38337928e-01f, -6.90981969e-02f, -4.96202558e-02f,
  3.08894098e-01f, 2.30376273e-01f, 2.12324917e-01f, 1.24957850e-02f, 1.04918651e-01f, 7.56786317e-02f, 3.80603299e-02f, 1.32427245e-01f, 4.88984063e-02f, 4.59919333e-01f,
  -1.53620526e-01f, -7.20565543e-02f, -1.81606319e-02f, 1.07295305e-01f, 5.48508530e-03f, -3.55706513e-02f, -6.58399835e-02f, -9.52715427e-03f, -1.05953984e-01f, 4.36365716e-02f,
  1.00158826e-01f, -1.51338065e-02f, -1.26774669e-01f, -3.48933740e-03f, 9.79132280e-02f, -5.79969920e-02f, -8.07310790e-02f, -4.80473377e-02f, -1.27519041e-01f, -7.40697309e-02f,
  8.41627717e-02f, 4.62814048e-02f, -1.78109005e-01f, -2.68014133e-01f, -1.43763304e-01f, 1.51663885e-01f, -7.56995156e-02f, -6.70424029e-02f, -1.63158342e-01f, 6.09072298e-02f,
  -1.10756233e-01f, -3.26075517e-02f, -3.58478315e-02f, 9.88694206e-02f, 4.80439477e-02f, -6.55694529e-02f, 1.10229209e-01f, 6.82791695e-02f, 6.79345056e-02f, -1.98126212e-02f,
  1.79050043e-02f, -5.37443347e-02f, -3.10455356e-02f, 8.70878901e-03f, 3.79203521e-02f, 7.84493536e-02f, 9.74401459e-03f, 7.78188035e-02f, 1.25680700e-01f, -3.64722349e-02f,
  3.59148942e-02f, -3.54786366e-02f, 1.35906143e-02f, 2.02882644e-02f, -3.48113850e-02f, 5.33361696e-02f, 7.07511231e-02f, 8.71899724e-02f, 7.97962025e-02f, 1.56478137e-01f,
  -1.33639544e-01f, -9.06177610e-02f, 1.02583677e-01f, 2.23980658e-02f, 4.64618169e-02f, -1.22118378e-02f, 7.94699707e-04f, -2.51869000e-02f, 1.75782278e-01f, 1.66495368e-02f,
  -5.40485047e-02f, -5.95694147e-02f, -7.91038424e-02f, -6.51494563e-02f, 4.49338183e-03f, 4.87916768e-02f, 7.70690292e-02f, -1.42276809e-01f, 5.07124811e-02f, 4.03510407e-02f,
  -6.21809326e-02f, -1.30930185e-01f, -2.58536756e-01f, -1.58867717e-01f, -3.13098878e-02f, -4.80157249e-02f, 6.46642819e-02f, 4.31264788e-02f, -2.31669426e-01f, -1.35609746e-01f,
  4.01376009e-01f, 5.63659430e-01f, -4.47975248e-02f, -2.01797172e-01f, -2.30298176e-01f, -1.27018392e-01f, 4.03611034e-01f, 1.70579046e-01f, -1.87199965e-01f, 2.80693471e-01f,
  1.20552763e-01f, -3.65788728e-01f, -2.58510232e-01f, -1.31625161e-01f, 4.69662286e-02f, 2.18803793e-01f, 1.04548037e-01f, -5.87391779e-02f, -2.98086822e-01f, -7.82887563e-02f,
  -1.31387850e-02f, -9.05316547e-02f, 7.58983120e-02f, 1.22454017e-03f, -7.37392157e-02f, -3.97910178e-01f, 7.06904307e-02f, 3.71944569e-02f, 1.16998866e-01f, 1.89425826e-01f,
  -5.05785632e-04f, 2.22929806e-01f, -3.48947048e-01f, -7.96925928e-03f, -4.64295149e-02f, 1.82696924e-01f, 1.10141233e-01f, 4.44682464e-02f, -9.97869112e-03f, 3.99859622e-02f,
  -9.82272774e-02f, 1.74073234e-01f, 4.97696064e-02f, -8.64624418e-03f, -2.67959423e-02f, -5.91815263e-02f, 1.37075171e-01f, 1.31899804e-01f, 2.89672259e-02f, 5.47877625e-02f,
  -1.23387305e-02f, 1.16221223e-03f, -2.55031418e-02f, 4.03382489e-03f, 5.53527884e-02f, -1.70554981e-01f, -3.72497737e-02f, 4.06527705e-02f, -1.21734338e-02f, 2.61757553e-01f,
  2.20052704e-01f, 1.57234505e-01f, -1.59230456e-02f, 1.70622319e-01f, 6.94448575e-02f, -6.69178786e-03f, -7.71748601e-04f, 5.17570153e-02f, 8.47239979e-03f, 1.15909241e-01f,
  -3.24207991e-02f, 2.70727109e-02f, 1.08942509e-01f, 2.41157450e-02f, -2.04268545e-01f, -6.89261854e-02f, -4.03312743e-02f, 1.19074926e-01f, -8.88836477e-03f, 6.52684495e-02f,
  -1.83746666e-02f, 1.32830599e-02f, -3.06078270e-02f, 1.28990769e-01f, 3.72092091e-02f, -7.27291629e-02f, 2.01282222e-02f, 8.19763690e-02f, -1.63665749e-02f, -9.91410241e-02f,
  -6.13257825e-01f, -2.74133891e-01f, 9.27182063e-02f, -4.23921384e-02f, -5.93587523e-03f, -1.89110771e-01f, -9.50416997e-02f, 6.57611266e-02f, 1.57840401e-02f, 1.75052434e-01f,
  -7.40744993e-02f, 2.05027573e-02f, 4.74427976e-02f, 8.45572874e-02f, -7.70289227e-02f, -4.55324315e-02f, 1.68904081e-01f, -6.65389746e-02f, -1.54367521e-01f, -1.44929573e-01f,
  9.50735956e-02f, -2.67242119e-02f, -1.17798612e-01f, -1.98200271e-02f, 3.68552059e-02f, -1.07506014e-01f, 1.60897896e-02f, -1.09496057e-01f, -1.11662343e-01f, 1.36806577e-01f,
  6.10686541e-01f, -3.87882203e-01f, -4.00583804e-01f, -1.14315651e-01f, -2.78322339e-01f, -1.70913368e-01f, -3.15183759e-01f, -3.19739990e-02f, 6.11838214e-02f, -3.15058410e-01f,
  -1.03001967e-01f, 2.61305124e-01f, 2.77825119e-03f, -3.12182633e-03f, 1.33326128e-01f, -3.75148356e-01f, -3.26292843e-01f, 1.03394270e-01f, 3.76755834e-01f, 6.32248521e-02f,
  -1.27186015e-01f, 1.69916861e-02f, 2.03131855e-01f, 1.47766307e-01f, -3.95765275e-01f, -1.27363019e-02f, -3.95165235e-01f, -1.76155627e-01f, -1.53949872e-01f, -4.24741417e-01f,
  -4.52769309e-01f, 7.75535628e-02f, 5.30564934e-02f, -2.76331846e-02f, -7.08611533e-02f, 1.08041279e-01f, -4.51135971e-02f, 1.13867648e-01f, 9.59082916e-02f, -4.93807206e-03f,
  9.32359137e-04f, 1.39887065e-01f, 2.04736322e-01f, 7.54910102e-03f, -2.81184297e-02f, -4.50556614e-02f, -2.10503358e-02f, 1.06674999e-01f, 4.60564974e-04f, -1.10221371e-01f,
  -1.55405656e-01f, 9.52753499e-02f, 1.61743075e-01f, 4.81245108e-02f, 5.83544597e-02f, 7.35083669e-02f, 2.38952716e-03f, 8.07867423e-02f, 1.27100959e-01f, -1.19302422e-01f,
  -1.94847122e-01f, -7.19544068e-02f, 2.94362120e-02f, 3.07307672e-02f, 1.19578876e-01f, 2.55707018e-02f, 6.95555657e-02f, -2.54434962e-02f, 9.78558138e-02f, 6.33957237e-02f,
  -5.58322780e-02f, 2.24017184e-02f, 3.37045193e-02f, 2.48511378e-02f, -5.81793971e-02f, 1.09187238e-01f, -2.55122129e-02f, -7.22026601e-02f, 1.24032937e-01f, 1.59247831e-01f,
  5.64656556e-02f, 3.81712094e-02f, -3.50344740e-02f, -7.16479449e-03f, -7.34001994e-02f, -4.20565754e-02f, -5.95438220e-02f, 1.76383927e-01f, -4.49809134e-02f, 1.40095465e-02f,
  -6.21548221e-02f, 1.57435611e-01f, -1.18283585e-01f, 2.12531090e-02f, 5.94118088e-02f, -6.40022978e-02f, -1.26028970e-01f, -2.38373149e-02f, 4.99262065e-02f, -8.64647254e-02f,
  6.98611140e-02f, -9.68148001e-03f, 5.77265322e-02f, -9.20880735e-02f, 8.24105889e-02f, 2.29127146e-02f, -1.97489504e-02f, 4.03729640e-02f, 9.13166776e-02f, -1.03277214e-01f,
  -1.54280275e-01f, 4.69598733e-02f, 1.79274946e-01f, 2.75165271e-02f, -1.46317268e-02f, 1.73830330e-01f, 2.63680387e-02f, -4.30270508e-02f, 1.51539579e-01f, -1.93862498e-01f,
  -5.97282350e-01f, -1.05185106e-01f, 1.61520109e-01f, -4.49977547e-01f, 7.12128431e-02f, 1.69878200e-01f, 1.44736007e-01f, -1.79882810e-01f, -3.45963508e-01f, 2.09212497e-01f,
  2.23289981e-01f, -7.50194564e-02f, -4.32642847e-02f, 1.86093777e-01f, 7.03599155e-02f, 3.37909251e-01f, 2.78719276e-01f, -4.72102873e-03f, -2.92021453e-01f, -1.51011333e-01f,
  7.28397295e-02f, -3.10043156e-01f, -2.51065850e-01f, -3.05373222e-01f, -1.72181457e-01f, -3.18103641e-01f, 3.16351727e-02f, -1.68544557e-02f, 2.18773440e-01f, 3.66050661e-01f,
  1.50124310e-02f, -1.14181474e-01f, 9.47643891e-02f, -1.42115891e-01f, -1.82428926e-01f, -6.31158575e-02f, -9.48497653e-02f, -4.28488515e-02f, 2.15349365e-02f, 1.05430365e-01f,
  4.80258167e-02f, 1.37142420e-01f, -6.01749308e-02f, -5.20174429e-02f, -5.40674627e-02f, -9.21302512e-02f, 1.77415870e-02f, -1.10523686e-01f, -1.33103848e-01f, 9.20181945e-02f,
  2.87061691e-01f, 2.71204393e-02f, -1.42784983e-01f, -1.92452483e-02f, -1.08732432e-01f, -8.66305158e-02f, -5.96636012e-02f, -7.39595369e-02f, -3.35772447e-02f, -1.80701584e-01f,
  -5.13186259e-03f, 7.05995634e-02f, 8.39495808e-02f, 6.05748631e-02f, 2.38082111e-02f, 6.41700923e-02f, 1.04231991e-01f, 3.12501900e-02f, 1.13386838e-02f, -3.43346298e-02f,
  -2.09202804e-02f, 1.92743167e-02f, -1.03862761e-02f, -7.75894448e-02f, 8.06178153e-02f, -1.01303160e-02f, -2.77319141e-02f, -1.45947998e-02f, 1.64277609e-02f, 4.97191213e-02f,
  -1.38438448e-01f, 3.59404385e-02f, -1.06104113e-01f, 3.87810245e-02f, 1.83580182e-02f, -1.06972910e-01f, 4.43068705e-02f, -6.90644532e-02f, 2.00229865e-02f, -7.33611081e-03f,
  -2.58441418e-01f, 3.35048705e-01f, -1.15237936e-01f, 2.13825051e-02f, 3.12784268e-03f, 6.74104095e-02f, 6.85034096e-02f, -1.21980630e-01f, 7.80996382e-02f, 8.51266831e-03f,
  1.24703376e-02f, -5.94341047e-02f, 3.04836668e-02f, 5.97100146e-02f, -9.29016545e-02f, -9.37095843e-03f, -2.69594397e-02f, -2.02319622e-01f, -3.94017436e-02f, 6.45128563e-02f,
  1.66339148e-02f, -1.69245645e-01f, -2.84104884e-01f, -9.70989615e-02f, -1.86246678e-01f, -2.54783958e-01f, -1.52571112e-01f, -6.73766062e-02f, -1.31776422e-01f, -2.82189399e-01f,
  4.03087914e-01f, 5.18527150e-01f, -9.75199789e-03f, 1.17520228e-01f, 1.10749761e-02f, 4.94996049e-02f, 5.51972210e-01f, 3.01596850e-01f, -1.11435883e-01f, 5.56978360e-02f,
  1.78247526e-01f, -2.53637403e-01f, -1.25205547e-01f, -2.27042615e-01f, 1.40797243e-01f, 9.25554633e-02f, -9.74103436e-02f, -2.17515722e-01f, -1.78552270e-01f, 1.97518636e-02f,
  -1.59322649e-01f, 3.13653201e-01f, 3.78063798e-01f, 1.06506169e-01f, 1.10518955e-01f, -1.72811553e-01f, 2.20180601e-01f, 1.84559762e-01f, 6.25042841e-02f, -4.96968091e-01f,
  -2.02047437e-01f, 3.25989962e-01f, -4.32705224e-01f, 1.76041856e-01f, 8.26572254e-02f, -4.67332490e-02f, -4.34135720e-02f, -1.37997985e-01f, -1.10239394e-01f, 1.02246758e-02f,
  3.58276181e-02f, 6.68836832e-02f, 1.17828706e-02f, 6.20475225e-02f, 1.39571398e-01f, -3.49864587e-02f, 1.53725266e-01f, -1.39795477e-02f, -3.62212732e-02f, -9.50064138e-02f,
  -4.25567664e-02f, -1.88243166e-02f, 3.81006785e-02f, -5.32015376e-02f, -1.20015085e-01f, -2.00898916e-01f, 6.52423128e-03f, 3.98767591e-02f, -1.34363398e-01f, -1.18882135e-01f,
  -3.36905837e-01f, 5.19521423e-02f, 6.48140460e-02f, -3.24996933e-02f, 5.68282492e-02f, 8.77609663e-03f, -1.23890303e-01f, -1.91292912e-02f, 3.72303464e-02f, 1.48913518e-01f,
  -1.13679208e-01f, -2.84271017e-02f, -1.53326824e-01f, 2.06926502e-02f, -9.75262225e-02f, -1.12619922e-02f, -4.03159820e-02f, 7.67307580e-02f, -1.41476974e-01f, 5.22670746e-02f,
  5.04140183e-02f, -9.65344608e-02f, 2.12494880e-01f, -9.94381160e-02f, -4.59965207e-02f, -7.18103796e-02f, -1.29551053e-01f, 3.98580208e-02f, 8.01988784e-03f, 1.59155890e-01f,
  2.61500955e-01f, -8.81740525e-02f, -3.18322212e-01f, -9.63476896e-02f, 8.17710906e-02f, 8.50281911e-04f, -4.99581024e-02f, -1.59827724e-01f, 3.01555451e-02f, 6.17715530e-02f,
  1.37706548e-01f, -1.31520033e-01f, -9.36889835e-03f, 1.38223603e-01f, -6.26305193e-02f, -2.77231040e-04f, -1.12322420e-02f, -1.87662929e-01f, -2.04107771e-03f, -6.95371255e-02f,
  6.65127262e-02f, -9.04074870e-03f, -7.52346516e-02f, -1.23379894e-01f, -2.32281938e-01f, -1.66093439e-01f, -4.53677364e-02f, -7.45792761e-02f, 9.76326782e-03f, 1.29320607e-01f,
  -2.27049544e-01f, 1.99273452e-01f, -5.44940382e-02f, 2.17188373e-01f, 1.22391514e-01f, 6.99308217e-02f, 1.81723654e-01f, 1.32561132e-01f, 1.27590865e-01f, 1.79897308e-01f,
  1.97198749e-01f, 2.18137816e-01f, 1.44934282e-01f, 2.56548107e-01f, 1.29060194e-01f, 1.66213408e-01f, 1.41481042e-01f, 6.73445761e-02f, -1.43529043e-01f, -1.55514088e-02f,
  1.15959495e-01f, 2.85620019e-02f, -2.86450218e-02f, 1.07319511e-01f, 1.77966580e-01f, 9.21627283e-02f, -1.14345700e-02f, 6.28722757e-02f, 2.36236900e-01f, 4.51959312e-01f,
  1.30475894e-01f, 4.47242297e-02f, -3.77033018e-02f, 9.30796713e-02f, 6.72241598e-02f, 6.47160932e-02f, 8.76597613e-02f, 1.60996858e-02f, 1.22429602e-01f, 2.53877118e-02f,
  1.23853095e-01f, 2.84564812e-02f, 8.69288221e-02f, 7.24950582e-02f, 1.29120816e-02f, -5.77805117e-02f, 2.77494770e-02f, 1.56634912e-01f, 1.46696001e-01f, 8.05063397e-02f,
  1.38824224e-01f, 8.84288028e-02f, 1.45277694e-01f, 1.86655045e-01f, 1.41729429e-01f, 7.83936232e-02f, -1.33579262e-02f, 1.51490256e-01f, 7.75315762e-02f, 1.37419343e-01f,
  6.10727072e-02f, 6.73379079e-02f, -1.18089677e-03f, -8.42028335e-02f, -5.83851933e-02f, -5.79673760e-02f, -3.16037200e-02f, -8.93177167e-02f, 6.23959787e-02f, 1.42732067e-02f,
  -1.16328979e-02f, 2.02795997e-01f, 1.03945985e-01f, -1.77458152e-01f, 1.42635256e-02f, 6.17875941e-02f, 1.44168371e-02f, 7.18250964e-03f, 3.73033211e-02f, 3.63847241e-02f,
  8.89833346e-02f, -1.08719096e-01f, -2.64160126e-01f, -6.61101490e-02f, -1.06402211e-01f, 3.31918336e-02f, -1.58834353e-01f, -1.10635169e-01f, -1.60684347e-01f, -3.63004580e-02f,
  3.86342615e-01f, 8.93576592e-02f, 1.78138748e-01f, 2.62835711e-01f, 1.70537680e-01f, 4.11976539e-02f, 2.78950661e-01f, 3.02672293e-02f, 1.15076073e-01f, 4.27238122e-02f,
  1.53062884e-02f, -1.03873916e-01f, 1.17420971e-01f, 1.47163095e-02f, -7.73491636e-02f, 7.53893107e-02f, 2.17327982e-01f, 1.85399815e-01f, 1.24179073e-01f, 1.18988603e-02f,
  1.13531929e-02f, 1.10801421e-01f, 8.91664624e-02f, 1.27553433e-01f, 5.00298887e-02f, -1.41102463e-01f, -4.80148271e-02f, -7.01960698e-02f, -1.92833453e-01f, -2.40495443e-01f,
  -3.02917957e-01f, -2.54252911e-01f, -3.05741787e-01f, -1.61567256e-01f, 1.44697145e-01f, 1.09287389e-01f, -3.64497900e-02f, -1.22673791e-02f, 9.76411998e-02f, -2.50956081e-02f,
  -4.56586406e-02f, 8.84781107e-02f, 7.31860250e-02f, 2.00797275e-01f, 8.72693732e-02f, 1.64517425e-02f, 1.85720444e-01f, 1.03219606e-01f, 1.01301432e-01f, 2.71168560e-01f,
  3.40565383e-01f, 2.39804894e-01f, 4.29828465e-03f, 1.04945250e-01f, 2.00149313e-01f, 6.28127605e-02f, -1.20473079e-01f, 4.48139571e-02f, 2.22400323e-01f, 3.06435108e-01f,
  -6.17652357e-01f, -1.46626294e-01f, -3.06071751e-02f, 7.29308501e-02f, -2.11270824e-02f, 1.28293643e-02f, 1.51727898e-02f, -1.72656581e-01f, -2.74461359e-02f, -5.94904236e-02f,
  8.94977152e-02f, 7.98096508e-02f, -5.88090718e-02f, 8.10535178e-02f, -6.26798719e-02f, -3.99926342e-02f, -1.78620711e-01f, -1.97005644e-01f, -1.59241840e-01f, -7.16665313e-02f,
  3.41908902e-01f, 1.29308820e-01f, -3.36150229e-01f, -1.68289006e-01f, -1.99727282e-01f, -1.08858116e-01f, -2.36721113e-01f, -1.04210675e-01f, -2.74170756e-01f, -1.78871915e-01f,
  -1.34770619e-02f, 4.89399619e-02f, -7.10507184e-02f, -3.06557678e-02f, 2.98446137e-02f, -9.80523154e-02f, -1.82115380e-02f, 1.44304752e-01f, 4.50693369e-02f, -1.90531000e-01f,
  -2.40041353e-02f, -5.92697710e-02f, 7.26030990e-02f, -1.62022799e-01f, -6.76813349e-02f, -1.36550501e-01f, 9.39781964e-02f, 1.49879754e-02f, 8.12346265e-02f, -5.80129623e-02f,
  2.23733205e-02f, -1.56411827e-02f, -5.28127216e-02f, 1.48980796e-01f, -9.09322724e-02f, -1.91814045e-03f, -1.78016424e-02f, 1.53132062e-02f, -1.35169417e-01f, -3.41390050e-03f,
  -3.44394684e-01f, 1.23951733e-01f, -1.70715570e-01f, -1.34619430e-01f, -5.60576394e-02f, 7.46276602e-02f, -2.04173073e-01f, -1.37083098e-01f, -2.45507658e-02f, -4.90497202e-02f,
  -1.04032457e-01f, -6.58702403e-02f, -2.89888352e-01f, -2.78418642e-02f, 8.19242373e-02f, -8.13747570e-02f, -1.12813994e-01f, -2.06263155e-01f, -8.83264840e-02f, 7.15796426e-02f,
  -1.20559730e-01f, -1.57379285e-01f, -3.52151603e-01f, -2.21103847e-01f, -1.17101461e-01f, -2.75288492e-01f, -2.02732652e-01f, -3.05167824e-01f, -4.49465543e-01f, -4.22130644e-01f,
  -2.83773303e-01f, -5.13546348e-01f, -8.29367191e-02f, -3.08911651e-01f, -3.11717004e-01f, -2.09123418e-02f, -2.47583926e-01f, 8.05516243e-02f, 1.89242229e-01f, -2.44780898e-01f,
  -9.73738804e-02f, -2.29602367e-01f, -7.64912367e-02f, -2.21057441e-02f, 5.81861921e-02f, -1.98542237e-01f, -1.47466019e-01f, 1.20859452e-01f, 3.23765635e-01f, 2.29732484e-01f,
  5.88257015e-02f, 7.51803815e-02f, 3.34311813e-01f, 4.41497505e-01f, 6.08513132e-02f, 1.74871027e-01f, 2.99297541e-01f, 8.14015344e-02f, -2.18166169e-02f, -3.84055078e-01f,
  -3.37240815e-01f, -4.26827781e-02f, 2.59941638e-01f, -1.41661406e-01f, -1.03329159e-01f, 1.17250755e-01f, 9.82181951e-02f, 2.44811580e-01f, -4.84905718e-03f, 5.97023480e-02f,
  -1.75627023e-01f, 6.57075867e-02f, -4.61199172e-02f, -5.41026182e-02f, -2.05498785e-02f, 7.45473281e-02f, 1.05835550e-01f, 1.99148223e-01f, 1.93260163e-02f, -6.56346185e-03f,
  -2.63849825e-01f, -3.85678038e-02f, -2.92621255e-01f, 1.21447645e-01f, 1.73055530e-02f, 2.07345318e-02f, -1.90696085e-03f, 9.39204842e-02f, 2.67786950e-01f, -4.44073193e-02f,
  8.43126476e-02f, 4.83545661e-03f, -2.39941701e-01f, -9.54332575e-02f, -3.09624150e-02f, -1.22276165e-01f, -1.11941949e-01f, -9.50423405e-02f, 6.67290483e-03f, -1.11445032e-01f,
  -1.46042630e-01f, -1.65451430e-02f, 8.12698975e-02f, 3.60686556e-02f, 5.00621796e-02f, 3.15643405e-03f, 1.33073248e-03f, 4.71252017e-02f, 8.03292021e-02f, -3.11937034e-02f,
  -7.24199787e-02f, 2.68701725e-02f, -6.26055747e-02f, 1.24612898e-01f, -8.59771073e-02f, 7.04887211e-02f, -6.89933747e-02f, 6.48745000e-02f, 1.19292565e-01f, 4.00027772e-03f,
  -2.27322489e-01f, 1.87204003e-01f, -2.26214528e-01f, -2.79958937e-02f, -1.57472476e-01f, 9.54046752e-03f, -2.99328595e-01f, -3.06978766e-02f, -1.83414653e-01f, -7.03934133e-02f,
  -2.09936544e-01f, -1.37294039e-01f, -1.68765754e-01f, -9.14214477e-02f, -9.79265273e-02f, -2.23157272e-01f, -4.10111666e-01f, -1.20451927e-01f, -9.65784118e-02f, -5.19066043e-02f,
  1.48364669e-02f, -1.77381858e-01f, -6.41907036e-01f, -3.49625409e-01f, -1.06945589e-01f, -1.91366896e-01f, -1.63788915e-01f, -2.44928859e-02f, -1.61011472e-01f, -2.72788346e-01f,
  -6.31382346e-01f, -1.55027837e-01f, -2.35814750e-01f, -5.44334292e-01f, -2.30937600e-01f, -7.12185502e-02f, -3.39859068e-01f, -4.82108369e-02f, -1.04499020e-01f, -3.48394096e-01f,
  -9.19556022e-02f, 7.97299519e-02f, -2.68279132e-03f, -1.11529402e-01f, -2.61374086e-01f, -3.20826173e-01f, -3.54941159e-01f, -2.30378419e-01f, 1.68871004e-02f, 1.28277138e-01f,
  -2.74062268e-02f, -3.81522655e-01f, -2.61760026e-01f, -1.23482272e-01f, -1.34297267e-01f, -1.76127166e-01f, -2.39408791e-01f, -1.98856652e-01f, 6.68088943e-02f, -4.21084583e-01f,
  1.34574041e-01f, 5.86476475e-02f, 7.07973540e-02f, -2.50006182e-04f, -6.01957329e-02f, 8.83395150e-02f, -7.40847737e-02f, -4.49079229e-03f, 1.59162488e-02f, 4.99369353e-02f,
  3.41700241e-02f, 3.84779200e-02f, 4.50681075e-02f, 5.38511202e-02f, -1.81924850e-02f, 9.68474671e-02f, 1.63620830e-01f, 4.19400670e-02f, -7.63040502e-03f, 1.86707094e-01f,
  2.09698200e-01f, 2.06181873e-02f, 4.08701152e-02f, 2.50025779e-01f, 2.68737227e-01f, 2.03969423e-02f, 1.32498354e-01f, 2.91949660e-01f, 2.34282225e-01f, 1.54294625e-01f,
  -2.55415309e-02f, 1.50762886e-01f, 8.99614468e-02f, 1.02141805e-01f, 9.36535075e-02f, 1.35473192e-01f, 3.03594017e-04f, 1.29156662e-02f, -1.45524936e-02f, -8.19015726e-02f,
  3.35525745e-03f, 4.76355851e-02f, 5.67409508e-02f, -1.00510731e-01f, -4.60224673e-02f, -2.63048261e-02f, 5.79019124e-03f, -1.77218132e-02f, -1.72226056e-02f, -7.70924613e-02f,
  -4.56240885e-02f, 5.03972806e-02f, -1.04561776e-01f, 1.50318801e-01f, 1.13355689e-01f, -6.74953908e-02f, 3.54053304e-02f, -6.99545257e-03f, 3.67927807e-03f, -2.19393279e-02f,
  -9.59000662e-02f, -5.12305163e-02f, -1.97490335e-01f, 1.34027293e-02f, -1.35524362e-01f, 5.87323792e-02f, -5.82147837e-02f, -6.92206249e-02f, -1.66439608e-01f, -4.59604934e-02f,
  1.15835458e-01f, 5.63837290e-02f, 1.04528023e-02f, 6.95438609e-02f, -5.86127676e-02f, 1.09602749e-01f, -2.16349848e-02f, -1.62719056e-01f, 5.90164550e-02f, 6.50065169e-02f,
  1.00471638e-01f, -2.55951826e-02f, -1.32991031e-01f, -5.14190597e-03f, 9.64194015e-02f, -5.74067459e-02f, 1.90750174e-02f, 6.84408844e-02f, 1.90565567e-02f, -1.43861920e-01f,
  8.03255320e-01f, 1.77633047e-01f, 4.23234433e-01f, 4.13622051e-01f, 3.11833531e-01f, 2.79265165e-01f, 3.38624835e-01f, 1.82851776e-01f, -1.97230349e-03f, 9.25485864e-02f,
  -8.91703740e-03f, -2.15169345e-03f, 6.34372234e-02f, -8.20702016e-02f, -2.96475757e-02f, -3.67635041e-02f, 6.80273697e-02f, 6.22140840e-02f, 1.48926288e-01f, 1.02433063e-01f,
  -8.13959315e-02f, 9.40873250e-02f, 3.81923020e-02f, 6.78653503e-03f, 9.31260437e-02f, -6.61175139e-03f, 2.49819160e-02f, -4.50145714e-02f, -3.22165973e-02f, 6.76774234e-02f,
  5.27440459e-02f, 3.91476929e-01f, 5.91406561e-02f, 4.63460274e-02f, 8.75090584e-02f, -7.61247277e-02f, 4.57934998e-02f, -2.19833036e-03f, -1.43209800e-01f, -1.60142541e-01f,
  -7.37286657e-02f, -7.19137937e-02f, 2.40259599e-02f, -3.05053126e-02f, -3.60224955e-02f, 8.74484831e-04f, -4.58019152e-02f, 4.74755131e-02f, -5.53054623e-02f, -6.51836693e-02f,
  4.03279588e-02f, 1.29683793e-01f, 1.91657916e-02f, 9.64029785e-03f, 1.09047502e-01f, 2.07843296e-02f, 1.18619941e-01f, 1.25674680e-01f, 1.02297002e-02f, 1.51776865e-01f,
  1.82904780e-01f, 1.03601977e-01f, -5.96747268e-03f, -5.86487278e-02f, -6.41983002e-02f, -3.18460427e-02f, 1.02356533e-02f, -7.53588080e-02f, 7.58566931e-02f, -1.17697194e-02f,
  -1.11494996e-01f, -3.71408053e-02f, 3.31984535e-02f, 5.24893850e-02f, 7.79673308e-02f, 2.23266371e-02f, -2.46665906e-02f, -3.02456990e-02f, 7.83583149e-02f, -1.03196763e-01f,
  -4.06799316e-02f, -5.66990599e-02f, -1.26296446e-01f, 4.59858775e-03f, 4.64991778e-02f, 2.41421700e-01f, 3.55467312e-02f, 4.94798943e-02f, 9.12062228e-02f, 5.69099076e-02f,
  -6.25435710e-01f, 1.34407640e-01f, 8.50900263e-02f, -9.74689871e-02f, -2.29582493e-03f, 6.07665209e-03f, 1.01496689e-01f, -5.63206077e-02f, -1.59397200e-01f, -8.76149461e-02f,
  -2.14094564e-01f, -7.02394620e-02f, 1.12132192e-01f, -9.14623067e-02f, -1.12121694e-01f, -2.21021786e-01f, -2.04900086e-01f, -3.14628780e-02f, -1.34360313e-01f, -1.46080121e-01f,
  9.52746067e-03f, -1.62162125e-01f, -3.77447307e-02f, -1.04261078e-01f, -8.60551149e-02f, -1.12337261e-01f, -1.73416138e-01f, -5.48211560e-02f, 1.59890447e-02f, 7.16059096e-03f,
  -2.54642516e-01f, 2.52154410e-01f, 4.74399447e-01f, -1.90067351e-01f, 1.79285705e-01f, 3.43089044e-01f, 3.99143726e-01f, 1.54968679e-01f, -1.18316501e-01f, 1.87229395e-01f,
  2.30986401e-01f, -3.95748526e-01f, -1.50014222e-01f, -2.09337577e-01f, -4.80296724e-02f, 4.49282855e-01f, 3.96183655e-02f, -1.37130901e-01f, -4.18783456e-01f, -1.95129097e-01f,
  -2.25221500e-01f, -3.85539800e-01f, -2.36662343e-01f, -1.97820857e-01f, -2.97309607e-01f, -5.44038653e-01f, 5.56533746e-02f, -1.22273769e-02f, 1.34996891e-01f, -9.43926573e-02f,
  7.95347765e-02f, 1.28736138e-01f, -9.28053334e-02f, -2.68433720e-01f, 9.61570740e-02f, -8.53348747e-02f, -4.25340757e-02f, -8.18940252e-03f, 1.43542901e-01f, 1.97630540e-01f,
  -2.69025955e-02f, 2.41224375e-02f, 3.65136042e-02f, -8.51837471e-02f, 1.34438248e-02f, 1.21890448e-01f, 1.17847562e-01f, 1.22080430e-01f, 1.67509988e-01f, 1.88514933e-01f,
  7.34147504e-02f, 1.71443984e-01f, 2.21106708e-01f, 1.60726592e-01f, 2.96906263e-01f, -1.29562309e-02f, 1.40631527e-01f, -3.79690006e-02f, 4.24334593e-02f, -2.23319709e-01f,
  -1.62333027e-02f, -6.68789148e-02f, -7.33808801e-02f, 2.05261772e-03f, -9.07446444e-02f, -3.22521180e-02f, -4.88599911e-02f, 5.37845530e-02f, 6.35128170e-02f, -1.75201036e-02f,
  8.44627321e-02f, 1.35194182e-01f, 2.42699124e-02f, 1.43509403e-01f, 4.57225963e-02f, 6.47280067e-02f, -1.56723466e-02f, 5.15230633e-02f, 1.36668861e-01f, -1.49464589e-02f,
  -3.36895399e-02f, 9.06490758e-02f, 7.54059702e-02f, -9.84602123e-02f, 1.32214114e-01f, -2.55759470e-02f, 3.24582122e-02f, -6.28043041e-02f, -7.87670463e-02f, 1.23641893e-01f,
  -2.76857972e-01f, 3.05019498e-01f, -6.22849986e-02f, -1.35626435e-01f, 7.53407776e-02f, -3.28390300e-03f, -9.63636413e-02f, -1.04265422e-01f, 5.17607369e-02f, -2.07346259e-03f,
  2.45856978e-02f, -3.79057638e-02f, 1.62923470e-01f, 1.48747480e-02f, -8.62363577e-02f, 7.27934614e-02f, -4.15970795e-02f, -1.81597039e-01f, 2.54470645e-03f, 7.73801282e-02f,
  -5.47486879e-02f, 7.35593140e-02f, -2.90098518e-01f, -1.80430084e-01f, 2.05949675e-02f, -2.01223329e-01f, -2.54399210e-01f, -2.03128859e-01f, -1.17213644e-01f, -4.71818864e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.55120540e-01f, 5.06795347e-01f, 4.28280681e-01f, 2.12261751e-01f, 2.02391326e-01f, -1.97449639e-01f, 4.42921609e-01f, 8.55036899e-02f, 4.13045794e-01f, 2.23081842e-01f,
  4.79676604e-01f, 3.48861068e-02f, 2.29152694e-01f, 1.58629403e-01f, -3.53011847e-01f, 4.29886907e-01f, 3.01243365e-01f, 2.75536865e-01f, 5.64741433e-01f, 3.48976463e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.33957991e-01f, 4.78714071e-02f, 7.73561299e-02f, 7.49140605e-02f, 1.06110744e-01f, -9.12125483e-02f, 1.96875826e-01f, 1.85648575e-01f, 1.94854394e-01f, 3.24354731e-02f,
  2.47936592e-01f, -1.59189239e-01f, -3.92149389e-01f, -9.30020679e-03f, 7.37839937e-02f, -3.29306543e-01f, 2.87986398e-01f, 7.41803795e-02f, 1.68364465e-01f, -3.66820092e-03f,
  4.94617084e-03f, 2.06914738e-01f, -3.45922023e-01f, 1.66951954e-01f, -1.23172328e-01f, -1.65087298e-01f, -7.63467997e-02f, 2.38679305e-01f, -4.46555875e-02f, -2.54311897e-02f,
  -4.67592515e-02f, -1.69811219e-01f, -1.46705076e-01f, 1.85636491e-01f, 4.83945943e-02f, 2.63735533e-01f, -6.70579746e-02f, 2.91881651e-01f, 1.87316358e-01f, 9.71386284e-02f,
  3.52330208e-02f, -2.01860353e-01f, 3.41034979e-02f, 5.15139736e-02f, 1.09688729e-01f, 5.23974776e-01f, 9.40132141e-02f, 1.19728364e-01f, 2.60303617e-01f, -7.37489611e-02f,
  -1.32656336e-01f, 2.52102077e-01f, -1.32168904e-01f, 7.01907128e-02f, -2.60792613e-01f, 2.50400435e-02f, -4.09953296e-01f, 3.21027070e-01f, -2.03257293e-01f, 4.76206243e-02f,
  -1.10482909e-01f, 7.66620263e-02f, -2.59744078e-01f, -1.31268427e-01f, 1.03310928e-01f, 5.99711901e-03f, 5.31593859e-02f, 5.49210235e-02f, 4.84409258e-02f, -1.65276099e-02f,
  -1.59318417e-01f, 2.03108773e-01f, 2.91060451e-02f, 3.20086658e-01f, -3.58869284e-02f, 7.61708652e-04f, -1.95504218e-01f, -1.70848951e-01f, -2.87299752e-01f, -4.58340943e-02f,
  -3.20230812e-01f, 1.01089209e-01f, 4.26660031e-02f, 2.09006250e-01f, -7.91612267e-02f, -2.42154628e-01f, 1.85072362e-01f, -2.47263417e-01f, 4.33412403e-01f, -2.84993857e-01f,
  2.50500470e-01f, -2.11313963e-01f, 7.39601552e-02f, 1.62153319e-01f, 2.84436066e-02f, 2.26054236e-01f, 1.09164678e-02f, -8.97440463e-02f, -8.93890262e-02f, 1.43419996e-01f,
  -2.09657270e-02f, -1.08418673e-01f, 1.53357759e-01f, -7.86548257e-02f, -5.83442822e-02f, 3.14766057e-02f, 7.48128220e-02f, 1.13206506e-01f, 4.07631934e-01f, 5.16794398e-02f,
  -1.01352759e-01f, -8.84834453e-02f, -2.31507197e-01f, 2.20458955e-01f, -2.09893391e-01f, -2.65665743e-02f, 8.96933302e-02f, 4.82632741e-02f, 2.42255300e-01f, -1.75991043e-01f,
  3.41777176e-01f, -1.90561056e-01f, 2.57559955e-01f, -9.36179757e-02f, -2.21399575e-01f, -5.51276542e-02f, 9.31931660e-02f, 3.75538133e-02f, -1.48964271e-01f, 5.54007739e-02f,
  1.15633920e-01f, 1.05900288e-01f, -8.95717815e-02f, 5.02700768e-02f, -6.50751218e-02f, -6.08640425e-02f, 3.52128781e-02f, -1.63263991e-01f, 4.67978939e-02f, 1.65451333e-01f,
  4.48587418e-01f, 1.38980001e-01f, -1.58130769e-02f, 3.89500335e-02f, -9.59941596e-02f, 3.13405991e-01f, -1.74038231e-01f, 5.28805070e-02f, 1.13273785e-01f, 9.01089832e-02f,
  -1.20925777e-01f, -2.60124713e-01f, -2.63544414e-02f, -1.14635549e-01f, 2.83749759e-01f, -7.82922506e-02f, -3.96789491e-01f, -2.56118774e-01f, -5.45830652e-03f, 3.38570401e-02f,
  3.60035747e-02f, 3.31784301e-02f, 4.20665368e-02f, 1.08700447e-01f, -2.98308935e-02f, -1.15371563e-01f, 2.83823013e-01f, -3.66729498e-03f, 7.77702853e-02f, -1.33583218e-01f,
  2.84633398e-01f, -6.88261772e-03f, -4.04940277e-01f, -1.71597183e-01f, 1.89658910e-01f, -2.26611570e-01f, -9.52790026e-03f, 3.42560589e-01f, 1.91054150e-01f, -1.02306575e-01f,
  2.36765295e-02f, -1.89982623e-01f, -1.54863745e-01f, 3.05777460e-01f, -1.35144979e-01f, -4.26191449e-01f, -1.14702489e-02f, 1.32063210e-01f, 2.33224347e-01f, 1.93579048e-01f,
  1.35339916e-01f, -4.43068147e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.54045478e-01f, 1.62567243e-01f, 1.55072019e-01f, 1.63616151e-01f, 3.48283648e-01f, 2.76904523e-01f, 2.08398402e-01f, 7.16449842e-02f, 1.21232077e-01f, 8.74382351e-03f,
  -4.23298553e-02f, 1.84914544e-02f, -9.74254459e-02f, 4.51287657e-01f, -2.62006581e-01f, -3.96216244e-01f, 4.70497400e-01f, 5.11263669e-01f, 2.49000296e-01f, 3.98031652e-01f,
  -3.40959549e-01f, 2.71255558e-04f, 1.66707143e-01f, 1.93309914e-02f, -2.21841767e-01f, 3.09213787e-01f, 5.52596413e-02f, 4.45191830e-01f, 1.53477833e-01f, 2.82521337e-01f,
  -7.24274591e-02f, -9.27277878e-02f, 1.16775230e-01f, 1.53372645e-01f, 4.61098040e-03f, 2.32201010e-01f, -5.53856492e-02f, -1.73511654e-01f, 1.87479168e-01f, -2.74547309e-01f,
  -5.45027442e-02f, 1.67572051e-01f, 1.96132094e-01f, 2.21863315e-01f, 7.55024701e-02f, -5.37772894e-01f, -7.53521919e-02f, -4.45269942e-01f, 1.20289877e-01f, 1.96509749e-01f,
  2.81546831e-01f, -3.09528500e-01f, 4.18565720e-01f, -1.35803208e-01f, -3.05286765e-01f, 5.98701060e-01f, 2.36194938e-01f, 5.51789626e-03f, -1.74031422e-01f, 2.94895411e-01f,
  1.54484296e-02f, -2.07911506e-01f, 1.62851900e-01f, 1.48834288e-01f, 1.87352806e-01f, 1.59307897e-01f, 9.15766582e-02f, 1.65296555e-01f, 2.04619184e-01f, 3.36663090e-02f,
  -5.97189404e-02f, -1.45767614e-01f, 2.37583011e-01f, 2.12775059e-02f, -6.44565523e-02f, -8.78485758e-03f, 1.23622768e-01f, 6.29998982e-01f, 3.46668005e-01f, 2.54026681e-01f,
  1.96366519e-01f, 2.32954472e-01f, -3.31800282e-01f, 1.69604912e-01f, -2.19129696e-01f, 3.40634286e-01f, -1.27438694e-01f, -1.99734926e-01f, -6.97404295e-02f, -5.06513059e-01f,
  1.95585310e-01f, 3.30610126e-01f, 5.67672476e-02f, -6.41729981e-02f, 9.64799598e-02f, -5.21939337e-01f, -1.44119374e-03f, 2.48263597e-01f, 3.74567032e-01f, 5.22636414e-01f,
  1.69202462e-01f, 4.90804881e-01f, -1.75783917e-01f, 5.34224845e-02f, -2.10745305e-01f, -1.74255803e-01f, -9.56998467e-02f, 1.55812025e-01f, 8.19476902e-01f, 3.83553386e-01f,
  -1.18713036e-01f, 5.40091395e-01f, 1.68342292e-01f, -4.20552373e-01f, 5.46078086e-02f, 3.27477962e-01f, 4.46366286e-03f, 9.67668742e-02f, 1.05835728e-01f, -3.11107635e-01f,
  -4.74439263e-02f, 5.85976660e-01f, -1.36647478e-01f, -8.52480754e-02f, 4.28274006e-01f, -8.89136568e-02f, 7.68213496e-02f, 2.93338180e-01f, -8.79905224e-02f, -1.59422234e-01f,
  7.29249045e-02f, 3.04132283e-01f, 3.32107916e-02f, 2.55660295e-01f, -3.54447246e-01f, 4.62047607e-01f, -6.74401298e-02f, 2.36056298e-01f, -4.77393240e-01f, 2.52253860e-01f,
  1.37175769e-01f, 4.25114870e-01f, -1.32264867e-01f, -3.24644774e-01f, 7.70288229e-01f, 1.15880691e-01f, 2.44289264e-02f, 4.65687215e-01f, 2.98784692e-02f, -2.99448997e-01f,
  3.12762976e-01f, 3.16179603e-01f, 9.20174550e-03f, 5.57243347e-01f, -7.96568990e-02f, -1.49405736e-03f, 2.04994187e-01f, 7.21329218e-03f, -5.06373309e-02f, 1.64867893e-01f,
  2.67284423e-01f, 3.47530574e-01f, 3.12952667e-01f, 1.59077197e-01f, 1.70621186e-01f, 2.00271815e-01f, -2.74826199e-01f, 1.38103298e-03f, -1.65456653e-01f, 1.45244166e-01f,
  3.32290456e-02f, 1.94168285e-01f, 4.47623342e-01f, -1.96199238e-01f, -1.35768354e-01f, 3.01176667e-01f, -3.00808817e-01f, -1.12827308e-01f, 2.71335661e-01f, 3.19310367e-01f,
  -6.57080263e-02f, 1.32064581e-01f, 4.95121002e-01f, -3.11442912e-01f, 7.27444112e-01f, 4.99007940e-01f, -6.82016686e-02f, 4.91333038e-01f, 1.87489703e-01f, 2.26702362e-01f,
  2.15397850e-02f, 6.43714488e-01f, 1.74149379e-01f, 4.75741267e-01f, 5.17025068e-02f, 1.44022033e-01f, 1.72937483e-01f, 2.43725479e-01f, 5.85758567e-01f, -3.59265469e-02f,
  2.46696353e-01f, 1.40514905e-02f, 2.10593611e-01f, -4.22978282e-01f, -1.64066583e-01f, -1.56902134e-01f, 7.21221641e-02f, -1.62261780e-02f, -1.98797435e-01f, -4.33362126e-01f,
  6.22692168e-01f, 2.22061947e-02f, 2.26925150e-01f, -4.27237079e-02f, -5.60780883e-01f, 3.97127151e-01f, -9.35098454e-02f, -4.51608837e-01f, -2.87787288e-01f, 1.96632370e-01f,
  3.09155613e-01f, 2.31003210e-01f, -4.52701226e-02f, -1.22942450e-02f, 1.35572210e-01f, 2.40132794e-01f, 1.75740257e-01f, 2.13882029e-01f, 2.57383317e-01f, 2.18040496e-01f,
  3.61316293e-01f, -9.93336216e-02f, 8.67268071e-03f, -5.95010165e-03f, -4.50370908e-02f, 7.23382756e-02f, 7.26824580e-03f, 3.23194712e-01f, -1.74686953e-01f, -2.73301542e-01f,
  4.61863130e-01f, -4.17252988e-01f, -2.54270509e-02f, 6.24321066e-02f, 2.60636419e-01f, -8.08157846e-02f, -2.13319600e-01f, 3.27578455e-01f, -3.75552058e-01f, 2.63472706e-01f,
  -4.08191010e-02f, 1.59682557e-02f, 2.80544877e-01f, 1.97575837e-01f, 1.44169420e-01f, 1.89177413e-02f, 3.92577946e-01f, 1.21650681e-01f, 1.47394300e-01f, 2.43292004e-01f,
  -4.57797721e-02f, 1.28437936e-01f, 4.62912135e-02f, -3.36605936e-01f, 5.02430946e-02f, 2.17218623e-01f, 4.29267436e-01f, 4.17565644e-01f, -2.12065503e-01f, -8.07949528e-02f,
  -1.60885230e-01f, -3.76577042e-02f, -5.79126000e-01f, -3.08693975e-01f, -5.40711403e-01f, 1.92010149e-01f, 4.41335440e-01f, -3.55168998e-01f, -4.98515703e-02f, 2.02935487e-01f,
  5.37157297e-01f, 9.55379829e-02f, -3.58222365e-01f, 1.05275840e-01f, -2.31044859e-01f, 1.88761726e-01f, 2.74548065e-02f, 2.93924630e-01f, -1.95793211e-02f, 5.14935441e-02f,
  1.92853674e-01f, -1.19527251e-01f, 9.25017893e-02f, 1.53905749e-01f, -4.03531566e-02f, -1.68364733e-01f, 1.27306625e-01f, 1.35350019e-01f, -2.97404621e-02f, -5.20925373e-02f,
  9.56458673e-02f, -4.67202514e-01f, -2.69275997e-02f, 5.25618672e-01f, 2.39645422e-01f, -4.86185759e-01f, 6.73269212e-01f, 1.45518124e-01f, -1.39717281e-01f, -1.83321878e-01f,
  4.24706250e-01f, 2.88842648e-01f, 2.21531346e-01f, 1.85182080e-01f, 6.19141459e-02f, 1.22174568e-01f, 2.19211385e-01f, 3.67580026e-01f, 3.97643238e-01f, 4.04513985e-01f,
  -1.68745413e-01f, 5.79179712e-02f, -1.39042243e-01f, 5.43503501e-02f, -5.72175607e-02f, -2.02180758e-01f, 1.93983451e-01f, -3.49255353e-02f, 8.83323997e-02f, -9.37161297e-02f,
  -5.17608598e-02f, -7.18079656e-02f, -2.92623699e-01f, 2.36965686e-01f, 4.27552491e-01f, -1.74230888e-01f, 1.95169464e-01f, 2.34531060e-01f, 3.19777131e-01f, 1.68655083e-01f,
  5.76277710e-02f, -2.00647846e-01f, -6.13249838e-01f, 2.96870202e-01f, -3.56647134e-01f, -3.87456685e-01f, 6.82959557e-02f, 1.11007169e-01f, 1.84302151e-01f, 1.99431762e-01f,
  1.54038206e-01f, -3.23783815e-01f, 2.22043097e-01f, 4.93493289e-01f, 2.14462221e-01f, 3.52280468e-01f, 2.96105176e-01f, 2.05993295e-01f, 2.96292901e-01f, -8.22489485e-02f,
  5.13481488e-03f, -1.06227361e-01f, 3.38017464e-01f, -1.80457696e-01f, 4.49812561e-01f, -1.26972497e-01f, -8.82492438e-02f, 4.65183467e-01f, -2.45964259e-01f, -5.14964104e-01f,
  7.81653821e-01f, 5.03215156e-02f, -4.12405044e-01f, 2.82020479e-01f, 8.85556117e-02f, 5.23944981e-02f, 3.48583519e-01f, -5.94700873e-01f, -3.16009186e-02f, 2.20500171e-01f,
  5.47619641e-01f, 4.60345119e-01f, -7.55062420e-03f, 3.03105503e-01f, 2.75539547e-01f, 4.13787603e-01f, 3.33679020e-01f, 2.55005330e-01f, 1.50944322e-01f, 1.20717809e-01f,
  -1.74803585e-01f, -8.17189962e-02f, -8.64868090e-02f, -6.31931946e-02f, 1.79394409e-02f, 1.93011716e-01f, 3.16554248e-01f, -3.36557120e-01f, -1.85790053e-03f, 2.44425192e-01f,
  8.99545252e-02f, 3.34199518e-01f, -3.38259697e-01f, -1.96562946e-01f, 2.26359546e-01f, 4.30559516e-01f, 5.89048445e-01f, 2.16863781e-01f, 3.09575945e-01f, 1.72578439e-01f,
  -6.28146678e-02f, 3.60856295e-01f, 2.84877211e-01f, 8.47122073e-02f, 2.32483119e-01f, 3.13411534e-01f, 3.20791066e-01f, 2.62626559e-01f, 4.11858670e-02f, 1.51607364e-01f,
  1.48054883e-01f, 1.94839969e-01f, -3.84634405e-01f, 7.52845630e-02f, -1.79023985e-02f, -8.65467042e-02f, -1.82790667e-01f, 1.02742113e-01f, -2.26286173e-01f, -4.13311899e-01f,
  1.99640185e-01f, 1.28375188e-01f, 5.34532487e-01f, -5.16703546e-01f, -3.89774412e-01f, -3.45151007e-01f, 4.72677916e-01f, -4.43857402e-01f, 5.40130377e-01f, 3.31962913e-01f,
  -4.43579108e-01f, 6.14815116e-01f, -3.93919386e-02f, -2.92649031e-01f, -7.14280233e-02f, 9.73901823e-02f, 3.48692834e-01f, 4.33885217e-01f, 3.04359645e-01f, 2.81167090e-01f,
  1.64077476e-01f, 3.05643737e-01f, 2.90612549e-01f, 1.32193342e-01f, 4.31529403e-01f, -5.18814176e-02f, -9.40908864e-02f, 2.94100404e-01f, 5.68441331e-01f, 6.49324283e-02f,
  1.18605718e-01f, 6.58226013e-01f, -2.29920164e-01f, 1.02131702e-01f, -5.43058574e-01f, 4.29159701e-01f, -2.14323342e-01f, 2.13787049e-01f, 3.32187444e-01f, 1.46978438e-01f,
  -2.07116991e-01f, -2.22106010e-01f, 4.28601027e-01f, -5.48955977e-01f, -1.84370071e-01f, 2.66776592e-01f, -1.96337998e-01f, 2.76158065e-01f, -8.30161944e-02f, 1.49121201e-02f,
  2.78919488e-01f, 1.82450116e-01f, 3.32152665e-01f, 3.19157779e-01f, 2.65385062e-01f, 3.64125937e-01f, 3.77263129e-01f, 2.72676740e-02f, -3.19420965e-03f, -2.35707343e-01f,
  1.68106005e-01f, -2.84797788e-01f, 8.21215063e-02f, 1.86711952e-01f, 8.03571865e-02f, -4.43546772e-01f, 6.10938489e-01f, -1.46350116e-01f, 2.42228195e-01f, 2.33745784e-01f,
  7.52739981e-02f, -2.65838087e-01f, -4.34762985e-01f, 2.75784940e-01f, -4.48274910e-01f, -1.85167808e-02f, -1.41991660e-01f, -7.71533772e-02f, -9.46443677e-02f, 7.88112637e-03f,
  2.53991574e-01f, -3.93864542e-01f, 9.65780672e-03f, -9.07872021e-02f, -1.04269855e-01f, -3.57885696e-02f, -1.21678010e-01f, -1.15751043e-01f, -1.74909011e-01f, 5.54887541e-02f,
  -8.85516107e-02f, 5.10981023e-01f, -4.22298871e-02f, 1.28106341e-01f, 3.47531810e-02f, 3.13165694e-01f, -2.09215969e-01f, -8.68586898e-02f, -1.58067822e-01f, -1.15880996e-01f,
  2.82175094e-01f, 6.08539522e-01f, -8.41808543e-02f, -4.20623749e-01f, -1.00074904e-02f, -2.63760209e-01f, 3.38797837e-01f, -1.00800442e-02f, -7.41906911e-02f, 2.50853211e-01f,
  3.18412691e-01f, 5.09728968e-01f, -9.16673243e-02f, 6.09439433e-01f, 7.82815814e-02f, 7.07646385e-02f, 1.92683086e-01f, 1.83086302e-02f, 1.12003520e-01f, 1.91322476e-01f,
  -4.31956172e-01f, -1.11988284e-01f, 1.40312510e-02f, -3.87074873e-02f, -3.14716578e-01f, 1.02779143e-01f, -8.93305708e-03f, 1.49082288e-01f, 1.77385032e-01f, 2.47871652e-01f,
  -2.13714585e-01f, 8.78284454e-01f, -4.83977884e-01f, -6.15974106e-02f, -1.01619158e-02f, 2.28504479e-01f, 3.97652686e-01f, -1.64152369e-01f, 2.35238999e-01f, -2.01768968e-02f,
  7.33782575e-02f, 4.05082494e-01f, -3.62579346e-01f, -5.56638598e-01f, 3.11252140e-02f, 7.60046765e-02f, 7.43523836e-02f, 1.06639750e-01f, 4.52080779e-02f, 2.20825002e-01f,
  6.84504211e-02f, -1.62499696e-01f, 7.69213662e-02f, -3.22114855e-01f, 1.19205475e-01f, 1.40518352e-01f, -2.42594332e-02f, -4.61250059e-02f, -3.19036931e-01f, -4.99358237e-01f,
  1.34555385e-01f, -7.97868893e-02f, -1.74359426e-01f, -2.20696721e-02f, 5.69893897e-01f, -1.70623899e-01f, 8.31826925e-02f, -4.72242862e-01f, -1.45483643e-01f, 3.26302886e-01f,
  1.50472531e-02f, 3.40728819e-01f, -1.60930321e-01f, -2.74057746e-01f, -6.97383344e-01f, 8.07189271e-02f, 5.77969491e-01f, 5.10520875e-01f, 4.33914095e-01f, 2.85782516e-01f,
  2.82461703e-01f, 3.45014870e-01f, 2.77801882e-02f, 4.43269499e-02f, 4.27715510e-01f, -2.63192236e-01f, 8.73376653e-02f, -1.04121305e-01f, 5.31753935e-02f, -6.62034154e-02f,
  1.99917808e-01f, 4.33061987e-01f, -8.14707652e-02f, -4.17057574e-02f, 3.69547486e-01f, 4.93437558e-01f, -6.04014061e-02f, -2.24780619e-01f, 1.01194240e-01f, 3.24937999e-01f,
  -3.24572146e-01f, 6.08506858e-01f, -5.60835600e-02f, -3.96239042e-01f, -1.21743448e-01f, 3.19535702e-01f, 2.31925063e-02f, -1.29539475e-01f, 1.73257396e-01f, -4.50193167e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.28228703e-01f, 2.51214117e-01f, 3.00852776e-01f, 4.11671281e-01f, -4.59397323e-02f, 2.56609827e-01f, 3.37972701e-01f, 1.92085654e-01f, 2.23048314e-01f, 5.12560867e-02f,
  -1.17507741e-01f, 1.14246055e-01f, 2.79769808e-01f, 3.79812986e-01f, 5.35044670e-01f, 5.03363073e-01f, -1.44036949e-01f, 6.60020486e-02f, 4.18312848e-01f, 2.23316193e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.98048741e-01f, -2.32143775e-01f, 1.40663564e-01f, 7.22044110e-02f, -4.68574129e-02f, 1.55583337e-01f, 1.71497166e-02f, -5.11653014e-02f, 3.62736791e-01f, 2.34206662e-01f,
  1.81099251e-01f, 3.33233714e-01f, 1.41015828e-01f, 1.67025194e-01f, 9.22937877e-03f, -4.12214659e-02f, 1.32133424e-01f, -3.10139591e-03f, -1.42569676e-01f, 1.67034730e-01f,
  1.88159809e-01f, -3.03264380e-01f, -1.69013306e-01f, -1.91503301e-01f, -1.06203537e-02f, -2.16796864e-02f, 4.27491218e-01f, -2.26698548e-01f, 1.33356690e-01f, 5.11921290e-03f,
  1.04823969e-02f, 2.16067195e-01f, -1.21325240e-01f, 3.26242335e-02f, 6.60749059e-03f, -9.11462232e-02f, 1.68351308e-01f, -3.83953214e-01f, 3.74187864e-02f, 1.37712723e-02f,
  3.29529732e-01f, -2.72250086e-01f, 2.88282745e-02f, -8.92564282e-02f, -7.80918300e-02f, -1.50792086e-02f, -8.66701230e-02f, 7.53102750e-02f, -5.36004715e-02f, 1.17236994e-01f,
  1.47025332e-01f, 9.33393463e-02f, -2.62003750e-01f, 1.15187787e-01f, 2.08949387e-01f, 1.10309526e-01f, -2.82973886e-01f, 1.96599036e-01f, -4.18820322e-01f, -1.08452946e-01f,
  1.25406325e-01f, 2.10661218e-02f, 7.22672641e-02f, -3.24035674e-01f, -2.72268541e-02f, 1.24204390e-01f, 2.71656662e-01f, 4.36452240e-01f, -2.51771379e-02f, 2.16693878e-02f,
  4.38709334e-02f, -2.28119373e-01f, -3.54250558e-02f, -2.31332570e-01f, -2.40677342e-01f, -2.40183204e-01f, -1.51172608e-01f, -1.70612291e-01f, 2.23164439e-01f, -2.80503724e-02f,
  -7.95817152e-02f, -1.12950662e-02f, -1.45704433e-01f, -2.11965084e-01f, -2.27675989e-01f, -1.31316949e-02f, -9.00600180e-02f, -5.54553680e-02f, 1.37725830e-01f, 1.57795846e-01f,
  -7.46181086e-02f, 7.50411898e-02f, -1.98546544e-01f, 1.16369464e-01f, -1.94115192e-01f, -9.60182995e-02f, 1.91160500e-01f, -3.32346410e-02f, 2.18746081e-01f, -5.94746433e-02f,
  -4.71835285e-01f, -1.65238529e-01f, 3.31088215e-01f, -5.79534508e-02f, -1.30103916e-01f, 2.37232409e-02f, 6.90145344e-02f, 2.45838106e-01f, 3.96238640e-02f, -1.54864669e-01f,
  2.01706037e-01f, -3.41871262e-01f, 1.06800292e-02f, 8.92376751e-02f, 1.86357811e-01f, -1.21450417e-01f, -2.13465810e-01f, -1.05674230e-01f, 2.12047905e-01f, 9.53240395e-02f,
  4.15116409e-03f, -1.50351301e-01f, 7.62885362e-02f, 1.58819333e-01f, 1.15200467e-02f, 2.00513676e-01f, 4.10031900e-02f, 1.08230576e-01f, -3.46521139e-01f, -5.64827882e-02f,
  -1.66739240e-01f, -3.24808747e-01f, 5.33469617e-02f, -3.63183022e-01f, 1.72330573e-01f, -1.42425761e-01f, -5.66568255e-01f, -1.43822029e-01f, -1.86973177e-02f, 1.85705617e-01f,
  7.43804919e-03f, 1.84962347e-01f, -1.15462579e-01f, 4.33757342e-02f, -8.32882747e-02f, -7.67193213e-02f, 1.90752059e-01f, 8.13559666e-02f, -3.81727755e-01f, 1.34067088e-01f,
  -1.66040845e-02f, 2.09621012e-01f, -1.02409668e-01f, -8.57477076e-03f, -3.44406873e-01f, 6.98028356e-02f, 5.00512123e-02f, 2.15555634e-03f, 1.30172983e-01f, -5.76445600e-03f,
  -1.45400733e-01f, 8.96097440e-03f, 2.63947132e-03f, -2.48021141e-01f, 3.79417211e-01f, -2.89085567e-01f, -2.76529491e-02f, 3.41234684e-01f, 2.37899244e-01f, -1.85855418e-01f,
  9.95202661e-02f, -8.22316334e-02f, 2.45565429e-01f, -7.31941983e-02f, 1.93951458e-01f, 1.95909590e-01f, -3.79029922e-02f, 1.76115826e-01f, 1.01023264e-01f, 1.25745371e-01f,
  -2.22526863e-01f, -7.43250102e-02f, 2.04765692e-01f, 1.40739352e-01f, -7.53306523e-02f, -2.60813981e-02f, -2.07150564e-01f, -1.22417044e-02f, -8.59129801e-02f, -8.96557644e-02f,
  -1.71014488e-01f, -1.80332080e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  7.63221905e-02f, 3.21535282e-02f, -2.83593573e-02f, 1.10875994e-01f, 3.69828008e-02f, 1.09445095e-01f, -1.26300931e-01f, -1.79421529e-01f, -3.19317192e-01f, 3.02282065e-01f,
  3.29935730e-01f, -3.62985522e-01f, -3.30045104e-01f, -8.35782439e-02f, 1.93685330e-02f, 5.49987316e-01f, -4.42056954e-01f, 2.91863173e-01f, 1.36486525e-02f, -1.82434037e-01f,
  -4.08563852e-01f, 4.27713767e-02f, -4.60917056e-01f, 4.12154555e-01f, 3.72200519e-01f, -2.61126403e-02f, -1.77338630e-01f, -1.20886110e-01f, -3.98398101e-01f, 1.00381613e-01f,
  -3.69761795e-01f, 3.63101989e-01f, 1.21897928e-01f, -5.94820321e-01f, 1.07598841e+00f, -6.71929270e-02f, 1.14344023e-01f, -1.16619483e-01f, 6.31567091e-02f, 7.84550086e-02f,
  3.36319774e-01f, -1.13046624e-01f, 1.87226892e-01f, 7.56965995e-01f, 2.59837598e-01f, 4.03319150e-01f, -6.46526143e-02f, -2.99837172e-01f, 3.63309175e-01f, 4.47086841e-02f,
  1.70327555e-02f, 1.55043259e-01f, -2.82441705e-01f, -1.33842200e-01f, 3.23664963e-01f, -2.17055097e-01f, 1.01966038e-01f, 5.36952972e-01f, 1.45099029e-01f, 5.97283781e-01f,
  1.06868416e-01f, 2.88901806e-01f, 5.21552205e-01f, 7.96634257e-02f, -3.23025644e-01f, 3.37058231e-02f, -1.96382910e-01f, -2.15345070e-01f, -7.65758038e-01f, -3.37513387e-01f,
  1.65509969e-01f, 7.13579059e-02f, -5.28057516e-01f, 1.82770476e-01f, -1.10009633e-01f, 4.38219517e-01f, 3.77221741e-02f, 1.05562121e-01f, -1.99625924e-01f, -1.04705282e-01f,
  -3.61493155e-02f, -1.95955768e-01f, 5.45630991e-01f, -1.49071544e-01f, -5.86817265e-01f, 2.75983304e-01f, 2.39077225e-01f, 4.50614572e-01f, 5.34262098e-02f, -6.33752570e-02f,
  -2.83542007e-01f, 2.29994163e-01f, -1.46336585e-01f, -1.21985555e-01f, 5.23992300e-01f, 2.94804424e-01f, 3.09607595e-01f, 3.27430129e-01f, 5.13452999e-02f, 2.04983070e-01f,
  -1.76426634e-01f, -1.47595331e-01f, -6.96053356e-02f, -2.51698405e-01f, -4.28035378e-01f, 1.93995267e-01f, 3.09333622e-01f, -8.83309022e-02f, -3.90703857e-01f, 1.55053064e-01f,
  5.41902846e-03f, 9.15591940e-02f, -1.26492694e-01f, 4.73523766e-01f, -2.15814650e-01f, -3.89761239e-01f, 4.49460387e-01f, 1.23945691e-01f, -5.19003510e-01f, 1.96335927e-01f,
  2.42229506e-01f, -3.06271221e-02f, 3.02764893e-01f, -3.80115032e-01f, -1.68848839e-02f, 3.83830249e-01f, 2.01360494e-01f, 3.29757482e-01f, 2.33729035e-01f, 5.72453663e-02f,
  -3.68002981e-01f, -2.19308101e-02f, 1.22420378e-02f, -7.56101310e-02f, -2.18062341e-01f, 5.59469499e-02f, 2.53194928e-01f, 4.67837341e-02f, -5.30331671e-01f, -2.38840938e-01f,
  1.11944601e-01f, -7.43325949e-02f, -5.88388834e-03f, 3.87346685e-01f, 4.83732909e-01f, 5.75514846e-02f, 6.90639094e-02f, 2.76290387e-01f, -5.06536007e-01f, 2.31179625e-01f,
  2.31520906e-01f, 3.42215866e-01f, 5.69507331e-02f, 8.77463445e-02f, -4.27990198e-01f, -2.82694437e-02f, 3.26921016e-01f, -1.48441866e-01f, 1.17936783e-01f, 1.35726541e-01f,
  1.23391196e-01f, 1.45781636e-01f, 4.76204962e-01f, 5.50173819e-01f, 4.96922791e-01f, 5.21525800e-01f, 4.09959942e-01f, 3.67378235e-01f, -1.80811301e-01f, -5.27131632e-02f,
  -1.80434674e-01f, 4.96176571e-01f, 7.32105300e-02f, 3.60060751e-01f, 1.31605947e-02f, 4.46776934e-02f, -2.81449258e-02f, -2.77241170e-01f, 3.06195080e-01f, 3.54158282e-01f,
  1.99572146e-01f, -3.75654072e-01f, -6.81192502e-02f, 7.83803090e-02f, -1.02914438e-01f, 3.29872876e-01f, 1.96994662e-01f, 6.82632685e-01f, -3.33248734e-01f, -4.21461254e-01f,
  -3.79352234e-02f, 4.50392425e-01f, 3.48183922e-02f, 6.94439888e-01f, -2.96410829e-01f, 1.15327157e-01f, -3.44662219e-01f, -2.34789494e-02f, -7.61124957e-03f, -4.14544553e-01f,
  -5.84172308e-01f, -3.51007693e-02f, -7.52381189e-03f, -1.32876039e-01f, -2.09442675e-01f, -8.54799226e-02f, -1.45968899e-01f, 9.63129178e-02f, -3.05549175e-01f, 3.49950701e-01f,
  1.57632008e-01f, -2.41978213e-01f, 1.98247686e-01f, 2.49471396e-01f, -4.49098647e-01f, 3.33807051e-01f, 3.09408396e-01f, -8.33786950e-02f, 2.39964575e-01f, -3.17748785e-01f,
  9.51303020e-02f, 9.99222510e-03f, -8.56036171e-02f, -2.52121985e-01f, -1.37420937e-01f, 1.35921970e-01f, 3.19785148e-01f, -1.74981132e-01f, -5.72572529e-01f, 1.50197893e-02f,
  1.14667937e-01f, -5.92818065e-03f, -3.23404521e-01f, 1.94531292e-01f, 6.08962536e-01f, 2.27145508e-01f, 1.31676972e-01f, 3.80762339e-01f, 2.57715613e-01f, -7.02807605e-02f,
  6.77739978e-02f, 5.38185798e-03f, 1.16927564e-01f, 1.47873908e-01f, -1.79323956e-01f, 3.33422035e-01f, 3.01994115e-01f, -2.12779865e-01f, 3.78303349e-01f, 8.40514749e-02f,
  -2.73509115e-01f, 2.90199995e-01f, -1.46345869e-01f, 3.51463675e-01f, 2.25419298e-01f, 6.09018147e-01f, -6.59704432e-02f, -1.51379984e-02f, 4.80165094e-01f, 2.47648418e-01f,
  5.97213805e-01f, 3.60935301e-01f, 4.12126869e-01f, 5.40249050e-01f, 6.02922775e-02f, -1.45963088e-01f, -4.63672817e-01f, -2.54708320e-01f, 1.42335489e-01f, 6.22559339e-02f,
  7.14702159e-02f, 4.86076742e-01f, 4.02341187e-01f, -1.42714322e-01f, -1.11741148e-01f, 4.08814609e-01f, -5.33238769e-01f, -1.82509467e-01f, -1.24786258e-01f, -1.06933564e-02f,
  1.46528021e-01f, 1.45790830e-01f, -9.00152400e-02f, 5.86757362e-01f, -2.36652151e-01f, -2.92699575e-01f, -6.46108389e-01f, 4.30189937e-01f, -1.86521765e-02f, 1.37825720e-02f,
  -3.34213138e-01f, 4.97353226e-01f, 6.84098423e-01f, -1.47978246e-01f, -5.65870225e-01f, 9.74725857e-02f, 1.61641642e-01f, 8.05186555e-02f, -6.55557290e-02f, -5.74356496e-01f,
  -2.09894150e-01f, -2.24208608e-01f, 1.35474786e-01f, 5.45583487e-01f, 7.68657168e-03f, 2.99334764e-01f, -3.08919966e-01f, 2.76777651e-02f, -4.33581114e-01f, 2.03237832e-01f,
  -8.79957825e-02f, 8.41495022e-02f, 7.95396566e-02f, 4.33838606e-01f, -2.15503633e-01f, 1.34304352e-02f, -5.01576811e-02f, 3.79944295e-02f, 2.24266589e-01f, -5.92821650e-02f,
  2.25907797e-03f, -8.18265080e-02f, -7.40078017e-02f, -5.11285104e-02f, -4.22561347e-01f, 1.85698420e-01f, -4.36554104e-02f, -1.86322704e-01f, -5.03746308e-02f, 3.10099721e-01f,
  1.35238633e-01f, 2.53749669e-01f, 1.31726876e-01f, -1.37076303e-01f, -2.48927101e-02f, -1.14254974e-01f, 3.37488167e-02f, -1.78358182e-01f, -5.73196262e-02f, -9.81475636e-02f,
  7.11703300e-02f, -2.90974975e-01f, -1.26166165e-01f, 7.33522475e-02f, -2.19238952e-01f, -1.58223718e-01f, -2.87268132e-01f, 4.60810624e-02f, -9.82438214e-03f, 3.97126153e-02f,
  -1.66666329e-01f, -3.05495206e-02f, 5.05173326e-01f, -3.27325426e-02f, -2.13490665e-01f, 2.74741612e-02f, -4.12386119e-01f, -1.83699906e-01f, 2.83049028e-02f, 3.46804075e-02f,
  -9.21703875e-02f, 1.65662020e-02f, 1.83029339e-01f, -3.18190068e-01f, 1.79648846e-01f, -2.19698504e-01f, 1.52000099e-01f, 8.87453258e-02f, 3.34815323e-01f, -1.69218615e-01f,
  -4.49548125e-01f, 5.96041232e-02f, -1.79294005e-01f, -2.06576735e-01f, -1.96727142e-01f, 6.81918040e-02f, 2.88087130e-02f, -6.30960763e-01f, 2.38919169e-01f, 2.80597638e-02f,
  -1.99310422e-01f, 2.72762835e-01f, -1.23661228e-01f, 5.98323643e-01f, 7.90645331e-02f, -1.63272798e-01f, 6.49956644e-01f, 1.35327548e-01f, 2.46144265e-01f, 5.53958230e-02f,
  3.15611623e-02f, -1.36531904e-01f, 2.49148086e-01f, 1.89133286e-01f, 7.67315328e-02f, 3.09438795e-01f, -3.70930545e-02f, 4.36278284e-01f, -1.89279839e-01f, 1.96146250e-01f,
  5.72505444e-02f, 9.33930557e-03f, 5.81725001e-01f, 7.16695413e-02f, 6.20138943e-01f, -1.96351767e-01f, 3.23464453e-01f, 2.55347580e-01f, -2.08110854e-01f, -4.60863471e-01f,
  5.28883398e-01f, 2.39437103e-01f, 2.58800805e-01f, -2.92108536e-01f, 3.96419019e-01f, -5.14973179e-02f, 5.62040985e-01f, -6.96167499e-02f, 1.10753298e-01f, 1.06373191e-01f,
  -6.10687137e-02f, 4.37535852e-01f, 2.76123881e-01f, 3.05802703e-01f, 7.66217053e-01f, -8.14214572e-02f, -2.57081240e-01f, -3.32076162e-01f, 6.41816199e-01f, -4.32830125e-01f,
  1.54614430e-02f, 5.20306885e-01f, 3.86055022e-01f, 4.39093292e-01f, 4.58121032e-01f, 2.32619390e-01f, -1.74404427e-01f, 8.94707888e-02f, 1.11953564e-01f, 5.04356980e-01f,
  -1.06676400e-01f, -5.61689734e-01f, 6.37489378e-01f, -1.58062994e-01f, 7.92130709e-01f, -3.83049786e-01f, -4.73009527e-01f, 1.38326451e-01f, 2.57178783e-01f, 9.68934670e-02f,
  -1.70764223e-01f, -1.53629273e-01f, -2.39874676e-01f, 1.88577458e-01f, 1.16715670e-01f, -3.94096792e-01f, -2.41887465e-01f, 2.10710838e-01f, 1.69974774e-01f, 6.36979342e-02f,
  -4.76356689e-03f, 3.64088714e-01f, 1.59217298e-01f, -2.47762334e-02f, -2.78496176e-01f, 3.42644453e-01f, 2.21729025e-01f, -2.81728804e-02f, -4.02560055e-01f, 8.45331103e-02f,
  -2.47108415e-01f, 2.11473688e-01f, 3.69979203e-01f, -4.29530948e-01f, -6.78922161e-02f, -4.86860722e-01f, -2.51285464e-01f, 1.32639378e-01f, -3.87201905e-01f, 3.91474754e-01f,
  9.48899426e-03f, 3.33841771e-01f, 2.22449630e-01f, 7.29700327e-02f, -1.72229782e-01f, 4.41631436e-01f, 2.41930991e-01f, -3.62210184e-01f, -6.72285378e-01f, 2.49176815e-01f,
  2.01121986e-01f, 4.51735556e-01f, -1.69862136e-01f, 5.11658788e-01f, -3.24305713e-01f, -1.24622926e-01f, 5.23137487e-02f, 8.73637944e-02f, 5.25003910e-01f, 4.35824573e-01f,
  7.05461562e-01f, 2.24308833e-01f, 3.59596051e-02f, -8.31919163e-02f, 1.76250666e-01f, 5.40066302e-01f, -2.85147339e-01f, 3.16846490e-01f, -1.32769033e-01f, -3.04374725e-01f,
  7.71821737e-01f, 2.76823282e-01f, 2.80430824e-01f, -2.56243348e-02f, 2.15771422e-01f, 3.41416240e-01f, 2.42749766e-01f, 3.37356865e-01f, -2.47261032e-01f, -8.80136937e-02f,
  -3.48884910e-01f, 7.11831093e-01f, 4.29678112e-01f, 5.38691282e-02f, -1.25589743e-01f, -1.37277576e-03f, 5.65283656e-01f, 1.05368122e-01f, -2.81821728e-01f, -9.06025022e-02f,
  1.33546263e-01f, 1.57150358e-01f, 1.03075519e-01f, -2.91843086e-01f, 2.19811156e-01f, 1.72802493e-01f, 1.67847648e-02f, -1.69882417e-01f, 7.04351485e-01f, 3.71552408e-02f,
  -1.04107633e-01f, 2.29925960e-01f, -2.45021164e-01f, 5.65164268e-01f, -7.11742565e-02f, -1.20980062e-01f, 3.85388322e-02f, -9.14828181e-02f, -2.98517913e-01f, 3.00574392e-01f,
  4.03149754e-01f, 5.30192256e-02f, 8.82247165e-02f, -2.93317139e-01f, -3.26022506e-01f, 3.96555275e-01f, 1.41188711e-01f, 2.14688275e-02f, -4.11034562e-03f, 6.13087192e-02f,
  2.98693448e-01f, -5.80953015e-03f, 4.78728451e-02f, 3.16319525e-01f, -5.21048129e-01f, 4.06507432e-01f, -9.11260024e-02f, 2.83934861e-01f, 1.76273748e-01f, 1.94267035e-01f,
  -4.59776580e-01f, 3.04820567e-01f, 9.83653814e-02f, -8.25613365e-02f, 1.41073093e-01f, -1.47769451e-01f, 4.17843848e-01f, 3.84169489e-01f, -1.74599037e-01f, 4.58389968e-01f,
  2.13647142e-01f, -6.33527040e-02f, -1.29998267e-01f, -1.51238190e-02f, 3.33905041e-01f, -6.55682012e-03f, -1.99634612e-01f, -4.79517698e-01f, -9.45669487e-02f, 1.99786469e-01f,
  -4.18153018e-01f, 3.74554515e-01f, 2.31410906e-01f, 3.38032126e-01f, -1.57390863e-01f, 9.78056863e-02f, 7.49392211e-01f, -6.17836304e-02f, -4.61672634e-01f, 1.60714209e-01f,
  4.20154423e-01f, 3.97044867e-01f, 3.33010525e-01f, -1.14542030e-01f, 1.65184811e-01f, -1.72424421e-01f, 1.05062567e-01f, -2.00414240e-01f, 1.32435128e-01f, 4.00684565e-01f,
  -2.36826226e-01f, 4.27567869e-01f, -4.16793436e-01f, 3.44676256e-01f, 2.36904293e-01f, -2.46763214e-01f, -2.65137553e-01f, 3.58133502e-02f, -3.09801400e-01f, 2.13739246e-01f,
  2.08281558e-02f, 1.23774350e-01f, 9.92774069e-02f, -2.80334413e-01f, -1.39926344e-01f, 6.41355515e-02f, 5.79648018e-01f, 8.47067013e-02f, 7.50742495e-01f, 2.87296653e-01f,
  1.61461011e-01f, 4.22346666e-02f, -9.25218910e-02f, 2.81792402e-01f, 2.72332132e-01f, 2.30716214e-01f, 9.46952924e-02f, -2.68183589e-01f, 6.66774035e-01f, -7.08517656e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  6.50015995e-02f, 8.63564759e-02f, -1.51277527e-01f, -1.91820890e-03f, -7.10147992e-03f, 4.96608794e-01f, 2.09885091e-01f, 2.12854877e-01f, 3.31813425e-01f, 3.19844723e-01f,
  6.36205971e-02f, -3.32140297e-01f, -4.43479456e-02f, -8.52372050e-02f, 3.82856429e-01f, 9.82566774e-02f, 2.50207007e-01f, 1.16927072e-01f, 1.43025637e-01f, -1.03911169e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.56178910e-01f, -3.74465495e-01f, 3.19497377e-01f, -5.05440533e-01f, -4.96400744e-01f, -3.49756688e-01f, -6.12238087e-02f, -5.85986972e-01f, 1.22185141e-01f, -2.89940666e-02f,
  -1.27240911e-01f, -3.03219050e-01f, -1.80980876e-01f, 2.07992896e-01f, 3.40937257e-01f, -3.96775335e-01f, 1.34336069e-01f, -4.15423691e-01f, -5.05031049e-01f, 8.45647380e-02f,
  -1.16304949e-01f, -6.65884554e-01f, 6.93947375e-02f, 4.93061960e-01f, 2.40403816e-01f, 2.53885746e-01f, -7.56426668e-03f, 3.95727642e-02f, -5.32292902e-01f, 2.14677826e-01f,
  -5.27788877e-01f, -1.70645339e-03f, 1.68788254e-01f, -1.27588987e-01f, -3.05065393e-01f, -1.80837616e-01f, -3.34306747e-01f, 3.17176014e-01f, -3.91360670e-01f, 6.71286047e-01f,
  2.28734925e-01f, 6.41835451e-01f, 7.13824183e-02f, 2.44676381e-01f, -2.39868194e-01f, 2.61343032e-01f, 5.87569416e-01f, -3.12552080e-02f, 4.16877941e-04f, 3.47983688e-01f,
  -1.90088704e-01f, 2.59548604e-01f, -1.14637546e-01f, -1.45336881e-01f, -2.87295014e-01f, -1.49581373e-01f, -3.34607512e-02f, -4.52353835e-01f, -3.63023937e-01f, 3.33165199e-01f,
  -2.11358622e-01f, 1.98067531e-01f, -1.00322711e+00f, 2.31190771e-01f, 3.33188653e-01f, 1.82266548e-01f, 1.14012361e-01f, 1.65542752e-01f, 1.08426020e-01f, -5.07301018e-02f,
  -5.03589213e-01f, -7.50220194e-03f, -4.91147369e-01f, 1.73048049e-01f, 4.95997757e-01f, 4.70614463e-01f, 2.79518694e-01f, -5.69129586e-01f, 3.76341105e-01f, -2.92496353e-01f,
  9.14798528e-02f, 8.82842243e-02f, 1.36304766e-01f, -1.05010115e-01f, 1.75717413e-01f, -1.17228352e-01f, 2.49003872e-01f, -6.03967309e-01f, -2.00137198e-02f, 8.59089568e-02f,
  3.13261688e-01f, 1.34453520e-01f, 1.06410779e-01f, -6.29729405e-02f, -1.27830654e-01f, -6.69085234e-02f, -1.61146373e-01f, -8.99382010e-02f, -3.06950510e-01f, 2.76345998e-01f,
  -1.32007912e-01f, 3.83504890e-02f, 1.06960081e-01f, 1.81292340e-01f, 1.57280471e-02f, -3.65628791e-03f, -8.57520178e-02f, 3.42676371e-01f, -3.04186583e-01f, -2.47381434e-01f,
  3.29408310e-02f, 8.08269307e-02f, 5.20150922e-02f, -2.52386272e-01f, 4.23957497e-01f, -8.86757970e-01f, -8.56103420e-01f, -2.56341964e-01f, 1.80645272e-01f, 9.66299400e-02f,
  3.40441950e-02f, 2.42476150e-01f, -4.55871671e-02f, -5.77451065e-02f, -5.96561730e-01f, 8.62749293e-02f, 3.42707098e-01f, 2.58213967e-01f, -8.44385102e-02f, -6.03133678e-01f,
  -3.40463817e-01f, -3.23644549e-01f, 2.88749784e-01f, -5.06143034e-01f, 1.97220277e-02f, 2.77225465e-01f, 1.72203168e-01f, -1.89589992e-01f, 2.45019898e-01f, -2.61440426e-01f,
  -4.10487920e-01f, 2.69285500e-01f, -4.22440529e-01f, -4.36142653e-01f, 2.64158547e-01f, -4.28219467e-01f, -4.00296658e-01f, -3.11040252e-01f, 2.18948405e-02f, 3.52598399e-01f,
  -1.29841873e-02f, -1.57760799e-01f, 1.48291484e-01f, 3.14830631e-01f, -6.57937706e-01f, -5.74775994e-01f, 2.59364620e-02f, 2.85839289e-02f, 1.73215359e-01f, -1.94992572e-01f,
  3.07466000e-01f, 1.47743210e-01f, 5.53224385e-01f, 4.51947063e-01f, 4.87249106e-01f, 2.31964141e-01f, 1.76628619e-01f, 3.93934369e-01f, -3.62825900e-01f, -2.17073485e-01f,
  5.39166868e-01f, 4.45150942e-01f, -2.17089146e-01f, 2.74400383e-01f, -8.35508585e-01f, -4.24009562e-01f, 7.89434835e-02f, 3.08293968e-01f, -5.99182010e-01f, -3.32716852e-02f,
  6.37809455e-01f, 1.85767580e-02f, -1.19864434e-01f, 1.40291592e-03f, -7.29057491e-01f, -4.12502848e-02f, -1.83229908e-01f, 1.51032433e-01f, -4.06694949e-01f, 3.53499323e-01f,
  -7.62110017e-03f, -1.10009573e-01f, -2.61259258e-01f, 3.32052380e-01f, -2.04018161e-01f, 1.91116527e-01f, 2.27359220e-01f, -7.05264807e-02f, -6.95945144e-01f, 7.04312265e-01f,
  3.61049533e-01f, -4.08759534e-01f, 2.63756067e-01f, 3.24873596e-01f, 5.03079116e-01f, -6.49921477e-01f, -3.55952621e-01f, 2.95698792e-01f, -1.44493699e-01f, -1.67383492e-01f,
  4.16565269e-01f, 4.59695794e-02f, 4.34556678e-02f, 4.10101771e-01f, -9.93608013e-02f, -7.59701729e-01f, -5.76978207e-01f, -5.91225505e-01f, 1.44112229e-01f, -4.47704524e-01f,
  6.67880550e-02f, -1.65485397e-01f, 1.27821743e-01f, -7.12504804e-01f, -8.51352885e-02f, -1.45068064e-01f, -9.07103643e-02f, -2.66994745e-01f, -1.76953282e-02f, 1.13772504e-01f,
  1.09256700e-01f, -4.55524594e-01f, 1.62728131e-01f, -2.21884102e-02f, -1.89713284e-01f, -4.31801558e-01f, 4.96274978e-02f, 4.73711193e-01f, -3.76693845e-01f, 1.79487050e-01f,
  -5.12646854e-01f, -5.07438898e-01f, -1.16206892e-01f, 3.91015708e-01f, -3.44105870e-01f, -4.90624487e-01f, 2.00058088e-01f, -3.09415340e-01f, 3.86147678e-01f, -3.09580714e-01f,
  3.52567881e-01f, -1.52398512e-01f, 2.13796929e-01f, -4.41848814e-01f, -7.04758465e-02f, -3.03050965e-01f, -3.13347489e-01f, 3.41665819e-02f, 4.35944796e-02f, 3.69552523e-01f,
  5.36623150e-02f, -2.19739348e-01f, 7.65116453e-01f, -5.05634725e-01f, -6.64328456e-01f, -8.28525841e-01f, -2.64604986e-01f, -5.67108274e-01f, -4.46796179e-01f, -9.79137048e-02f,
  -3.77430528e-01f, -1.91967681e-01f, -1.57252267e-01f, 3.77951831e-01f, -2.89114326e-01f, 1.29356310e-01f, -2.74956048e-01f, -1.93244338e-01f, -1.19155921e-01f, -2.97602326e-01f,
  4.09079403e-01f, -1.01806200e+00f, -4.06563729e-01f, 3.64011437e-01f, 3.11545968e-01f, -4.82957065e-01f, 2.69101411e-01f, 2.82901287e-01f, 4.11575049e-01f, -1.62774622e-01f,
  4.82090831e-01f, 4.20629755e-02f, -3.69805306e-01f, 1.41220763e-01f, 4.94932681e-01f, -8.16315234e-01f, 4.53808717e-02f, 2.56999850e-01f, -4.14780736e-01f, 9.51549932e-02f,
  2.35741228e-01f, -7.17046678e-01f, -2.64691889e-01f, 2.43633658e-01f, -7.87077695e-02f, -4.12554413e-01f, 2.65682302e-02f, 9.39073134e-03f, 1.13209017e-01f, 2.48437822e-02f,
  2.14664161e-01f, 6.53682053e-01f, -7.07193673e-01f, 1.26592025e-01f, 6.42751455e-02f, -6.99161708e-01f, 3.14396888e-01f, -4.97695953e-01f, -7.80664682e-02f, -5.63453913e-01f,
  -3.74799520e-01f, 1.88126057e-01f, -6.54434264e-02f, 5.88300042e-02f, -1.61482796e-01f, 3.59293699e-01f, 2.24719644e-01f, -8.47102284e-01f, -3.87846142e-01f, 2.02042535e-01f,
  -4.87918228e-01f, 5.86063147e-01f, -5.70620716e-01f, 1.86449766e-01f, -4.84187126e-01f, -4.95314568e-01f, -3.58563662e-01f, 4.94172573e-01f, -3.96615207e-01f, -7.59394705e-01f,
  3.29952866e-01f, -5.67453742e-01f, -1.83422968e-01f, -3.78954560e-01f, 5.35982907e-01f, 2.46186078e-01f, -5.85203052e-01f, -3.35748404e-01f, 4.49969083e-01f, -3.14343214e-01f,
  -3.57019812e-01f, 9.80901718e-03f, -2.55650908e-01f, -4.42735702e-01f, 3.82466525e-01f, -1.60492077e-01f, -1.25272989e-01f, 1.66321099e-01f, -3.34797204e-01f, -2.76965145e-02f,
  1.87055483e-01f, -3.36976171e-01f, 2.67770439e-01f, -3.81193399e-01f, 7.96955973e-02f, 7.50293806e-02f, -5.81165031e-02f, 1.76179156e-01f, -3.18435170e-02f, -5.50300121e-01f,
  6.76728487e-02f, -1.02187656e-01f, -4.09865558e-01f, 4.12319779e-01f, 1.55496553e-01f, 1.05053529e-01f, -5.44122875e-01f, -3.11033458e-01f, -4.24080640e-01f, 4.31642711e-01f,
  -6.92628860e-01f, 1.93393294e-04f, 4.41251069e-01f, 1.52515722e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.13829607e-01f, -1.37147000e-02f, 1.23959929e-01f, -1.89188763e-01f, -1.66991092e-02f, -2.07172260e-02f, 1.54209331e-01f, -7.34518394e-02f, -2.58936100e-02f, -7.38113374e-02f,
  2.38975793e-01f, -1.30548790e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    