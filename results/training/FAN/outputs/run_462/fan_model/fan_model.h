/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.59544873e-01f, -3.32243107e-02f, -2.83641756e-01f, -2.19024509e-01f, -3.43896560e-02f, 1.81909591e-01f, 3.20807099e-02f, 3.67093310e-02f, 8.73956457e-03f, 6.14427552e-02f,
  8.43931809e-02f, -2.27020696e-01f, 9.29806083e-02f, -1.03715770e-01f, -6.86196685e-02f, 2.82538176e-01f, -6.85348809e-02f, -8.26426521e-02f, 3.00864950e-02f, -6.82950914e-02f,
  -1.93317980e-03f, -5.09732626e-02f, -1.65479094e-01f, -1.50602087e-02f, -1.46717623e-01f, -1.14698425e-01f, -1.34417966e-01f, 1.01505648e-02f, -1.22293696e-01f, 8.02934095e-02f,
  1.35422964e-02f, 6.94932565e-02f, -7.04711080e-02f, 4.26189974e-02f, 5.41918259e-03f, 2.26828903e-02f, -7.93100297e-02f, 3.96720693e-02f, 4.40359861e-03f, 4.64227609e-02f,
  4.63011749e-02f, -6.58305809e-02f, 4.78355438e-02f, 3.62622067e-02f, -3.84696685e-02f, -3.24850567e-02f, -1.24543488e-01f, -2.49323845e-02f, -4.06951830e-03f, 1.05977670e-04f,
  -1.38624266e-01f, 3.21632903e-03f, -6.48830235e-02f, 6.96910322e-02f, -7.80681893e-02f, -2.40294021e-02f, 4.19600960e-03f, -6.74921721e-02f, 2.14902320e-04f, -4.70803455e-02f,
  3.14001702e-02f, 1.90233942e-02f, -9.22450516e-03f, -5.05449530e-03f, -1.53152775e-02f, 2.58530099e-02f, -2.66651064e-02f, 1.04742616e-01f, 5.37392497e-03f, 1.95534378e-02f,
  -1.14062307e-02f, 5.91992363e-02f, 1.80865694e-02f, -2.29644589e-02f, -3.28753376e-03f, 3.05592753e-02f, 2.01505180e-02f, -3.68764549e-02f, -7.07615465e-02f, -3.46917734e-02f,
  5.43560050e-02f, 1.92149878e-02f, -4.98600453e-02f, -2.16662437e-02f, 5.81735149e-02f, -8.87007162e-04f, -1.94714479e-02f, -3.95635776e-02f, 4.23937961e-02f, 3.59404497e-02f,
  2.36470513e-02f, 5.83749339e-02f, 1.08621493e-02f, 2.04690974e-02f, 8.89287665e-02f, 4.98027578e-02f, 4.00682241e-02f, -1.48064531e-02f, -1.57690328e-02f, 4.24901731e-02f,
  -6.29547015e-02f, -1.16361650e-02f, 3.81261446e-02f, -6.65502325e-02f, -9.46074259e-03f, 4.91712540e-02f, -1.42111881e-02f, -6.22784952e-03f, -4.92917523e-02f, -1.27239451e-02f,
  -5.62120155e-02f, 2.66776979e-02f, 3.09586041e-02f, -2.59786490e-02f, 1.17484247e-02f, -1.41223958e-02f, 2.63723023e-02f, -4.74954136e-02f, 2.26189364e-02f, -1.84112675e-02f,
  1.12838507e-01f, -8.89238566e-02f, -7.23028407e-02f, 1.05270237e-01f, -1.88086957e-01f, 3.46438408e-01f, 2.70683855e-01f, -2.15881601e-01f, 2.91434266e-02f, 3.87490168e-02f,
  8.06332156e-02f, 1.02144673e-01f, 2.79397257e-02f, 2.57130921e-01f, 3.04563493e-01f, 1.56413928e-01f, 2.48919755e-01f, 2.41952345e-01f, -9.93839744e-03f, 2.23679002e-03f,
  8.80231187e-02f, 1.71620309e-01f, 7.05758855e-02f, -1.69211432e-01f, -1.64795905e-01f, -1.73918843e-01f, -5.47220297e-02f, -7.18846619e-02f, 3.62462811e-02f, 1.05375476e-01f,
  7.61216655e-02f, -9.33215618e-02f, -8.07535574e-02f, -1.58351120e-02f, -3.25747170e-02f, 1.32973343e-02f, 9.49204527e-03f, -4.12577353e-02f, -5.10448590e-02f, 5.33601455e-03f,
  -4.52593304e-02f, -3.29128094e-03f, -3.29288617e-02f, -4.32649739e-02f, -7.86168594e-03f, -6.97383564e-03f, -6.73665479e-02f, -4.67378609e-02f, -3.66623304e-03f, -4.76774760e-02f,
  -7.17588812e-02f, -6.80982042e-03f, 2.85729417e-03f, 1.05844826e-01f, 9.24703199e-04f, 2.41768714e-02f, -4.86056728e-04f, -8.11089203e-03f, -5.83290718e-02f, 7.25207618e-03f,
  -2.74557918e-02f, -4.81357388e-02f, -1.79512948e-02f, 4.77270260e-02f, 8.08390006e-02f, -1.05842859e-01f, 1.57778598e-02f, 5.48693985e-02f, -2.30434141e-03f, 1.96786728e-02f,
  -7.83734769e-02f, 6.23592697e-02f, -9.80277639e-03f, -3.70408874e-03f, 2.22596917e-02f, 2.62440406e-02f, -1.78018771e-02f, -1.17501216e-02f, 3.20068933e-02f, 1.17960591e-02f,
  3.23587433e-02f, 5.57014309e-02f, -3.62624563e-02f, 1.36493403e-03f, 1.24327816e-01f, -7.75991157e-02f, -9.71231982e-03f, -1.01360343e-01f, 4.33594137e-02f, -2.41351370e-02f,
  2.00506821e-01f, 7.07163438e-02f, 5.81868109e-04f, 3.65023240e-02f, 9.70000327e-02f, 8.53363276e-02f, 4.52096276e-02f, 1.93608541e-03f, 2.66995747e-02f, -7.48569071e-02f,
  3.13642621e-02f, -5.54586500e-02f, 1.74542551e-03f, 2.55270954e-02f, 5.10750413e-02f, 2.96893511e-02f, 5.42665832e-02f, 1.57379806e-02f, 1.46319782e-02f, 1.18777528e-02f,
  1.24833349e-03f, -2.89400760e-02f, -2.43460797e-02f, -1.03482179e-01f, 6.91538304e-02f, 1.00615276e-02f, 8.47158283e-02f, 2.20987070e-02f, -2.98504215e-02f, 2.04668753e-02f,
  5.22120833e-01f, -1.64178073e-01f, 2.18232915e-01f, 1.02986731e-01f, -2.11455747e-02f, -8.87429118e-02f, 1.40842184e-01f, 4.41883393e-02f, 2.09848061e-01f, -6.45172084e-03f,
  8.74138772e-02f, -4.38997783e-02f, 1.15398966e-01f, -7.45696798e-02f, 1.46814793e-01f, 7.38085881e-02f, 6.11952804e-02f, 6.58081472e-02f, -3.86625715e-02f, -8.24803710e-02f,
  7.59673715e-02f, -1.01789176e-01f, 7.85411075e-02f, -1.49961606e-01f, -1.79136917e-02f, 3.11724702e-03f, 3.23598669e-03f, 6.08335771e-02f, -1.24094099e-01f, -6.39415160e-02f,
  1.66324750e-02f, 6.03685454e-02f, 7.84033909e-02f, 5.57949487e-03f, 8.87484550e-02f, 3.83084826e-02f, 4.19956110e-02f, -2.65284674e-04f, -2.15525809e-03f, 7.93804601e-03f,
  -3.73841934e-02f, -2.55976338e-02f, 2.70444043e-02f, 8.62957984e-02f, 3.30604911e-02f, -3.78934331e-02f, -6.10966310e-02f, 8.30155564e-04f, -3.17044221e-02f, -1.77150443e-02f,
  -6.10494167e-02f, -2.51132175e-02f, -3.26032937e-02f, 1.91935189e-02f, -2.48465668e-02f, 3.78303006e-02f, 2.64091510e-02f, -7.12007657e-02f, -5.84265636e-03f, 4.36692424e-02f,
  3.15950401e-02f, 4.33095768e-02f, -2.28586495e-02f, -7.55351328e-04f, 1.22211557e-02f, 1.72611941e-02f, 3.95880081e-02f, -4.39632088e-02f, 9.55369847e-04f, 3.21639031e-02f,
  2.34895889e-02f, 6.65417612e-02f, 2.68815588e-02f, 7.50905499e-02f, 3.45750153e-02f, 3.42762172e-02f, -2.43261121e-02f, 7.76306959e-03f, -3.09373531e-02f, -7.49430899e-03f,
  5.43508455e-02f, 1.32463230e-02f, 1.64332129e-02f, -2.44803373e-02f, 1.87432989e-02f, 1.99734829e-02f, 9.33205988e-03f, -1.85384173e-02f, 2.84211729e-02f, 2.94138538e-03f,
  -8.85637328e-02f, 1.22460939e-01f, 3.22009102e-02f, -1.14101113e-03f, 1.70218702e-02f, 5.17601557e-02f, 4.49934825e-02f, -7.08775744e-02f, -3.31101790e-02f, 2.71518044e-02f,
  3.96236312e-03f, -5.52292354e-03f, -1.17526797e-03f, -1.53143201e-02f, 6.62438795e-02f, 6.71549216e-02f, 2.35922765e-02f, -2.54522040e-02f, -2.96490081e-02f, -1.10085495e-03f,
  8.90279263e-02f, 3.76985930e-02f, -1.16347913e-02f, -7.85795972e-02f, -2.17851941e-02f, 3.67228617e-03f, 4.52260524e-02f, 3.74999940e-02f, -1.28853530e-01f, 4.44719614e-03f,
  -2.80948877e-01f, -2.45148525e-01f, -3.83746594e-01f, -2.58908808e-01f, 2.10284755e-01f, 2.32846975e-01f, -1.97126776e-01f, -6.50846511e-02f, -3.40905458e-01f, 8.75530243e-02f,
  2.55702585e-01f, -2.57646412e-01f, -1.25590131e-01f, 2.50157923e-01f, -4.52170596e-02f, -5.09769209e-02f, 1.96912847e-02f, 4.71300483e-02f, -1.29179955e-01f, -6.46546856e-02f,
  -1.27531976e-01f, 3.32572430e-01f, -2.17404850e-02f, 2.16423750e-01f, 1.65816724e-01f, -1.25664413e-01f, 1.48887828e-01f, -2.11702846e-02f, 1.64278537e-01f, -4.59565707e-02f,
  1.24001585e-01f, -2.32810387e-03f, -1.48142921e-02f, -3.85763422e-02f, -1.92820281e-02f, 8.54533762e-02f, 7.00534210e-02f, 4.92659248e-02f, -8.04632008e-02f, -7.02959523e-02f,
  -5.44698816e-03f, 2.85891686e-02f, 3.96992192e-02f, -3.88852395e-02f, 8.08330602e-04f, 1.61415208e-02f, 3.05287028e-03f, -9.12941247e-03f, -6.07562177e-02f, 1.68111753e-02f,
  -3.89613099e-02f, -1.54694384e-02f, 4.80445288e-02f, 1.17043322e-02f, -3.32772136e-02f, -2.40161698e-02f, 1.32946931e-02f, 5.44083212e-03f, 1.81978699e-02f, -8.42653662e-02f,
  3.87407243e-02f, -7.30620474e-02f, -2.56224666e-02f, 2.90118787e-03f, -3.51115945e-04f, 5.36456332e-02f, -8.71012174e-03f, -1.80636700e-02f, -1.23440430e-01f, -6.39412459e-03f,
  2.54798890e-03f, -1.29121803e-02f, -5.25395386e-02f, 3.62632722e-02f, -4.98655625e-03f, 2.52572298e-02f, -1.22341318e-02f, 4.67574364e-03f, -4.66069281e-02f, 4.23525609e-02f,
  -2.92900659e-04f, -2.19588596e-02f, 2.50172652e-02f, -2.12575775e-03f, 7.43408948e-02f, -2.29672366e-03f, 2.53223837e-03f, -2.36973399e-03f, 5.26351202e-03f, 3.27322036e-02f,
  -9.44238678e-02f, -2.03708515e-01f, 1.05230985e-02f, -5.12059219e-03f, -2.21729241e-02f, 1.21693261e-01f, -3.43596600e-02f, -5.81596605e-03f, 2.65655182e-02f, 1.21994931e-02f,
  1.96989421e-02f, 1.63017195e-02f, -3.64932939e-02f, 4.35510501e-02f, -6.32661432e-02f, 3.50630358e-02f, -3.78476232e-02f, 5.44443540e-03f, 9.39485710e-03f, 3.38582732e-02f,
  7.12532625e-02f, 1.04639195e-01f, -5.30871861e-02f, 4.78950851e-02f, 1.03592768e-01f, 4.30545583e-02f, -8.13849643e-03f, -7.20308572e-02f, 4.99336515e-03f, 8.78281146e-03f,
  2.82019943e-01f, -3.11505497e-01f, 1.89545676e-01f, -1.96347415e-01f, 9.58471522e-02f, -3.00979227e-01f, -2.65803009e-01f, -1.26643270e-01f, -8.87266845e-02f, -4.13025558e-01f,
  -1.22162558e-01f, -1.50471300e-01f, -2.01571405e-01f, -2.57004946e-01f, 7.52569595e-03f, -2.05458790e-01f, -1.93569548e-02f, -1.48897484e-01f, -1.55280158e-02f, -4.64756265e-02f,
  -3.56838256e-02f, -6.83507249e-02f, 8.01142752e-02f, -3.15850116e-02f, 6.53576404e-02f, 6.13548197e-02f, 6.39749244e-02f, 1.55960470e-01f, -3.67483422e-02f, -6.24093786e-03f,
  -5.94884716e-02f, 4.56448346e-02f, 1.25730172e-01f, 8.91235247e-02f, 4.63803746e-02f, 6.53551891e-02f, 6.45230412e-02f, 1.10793106e-01f, 5.56558408e-02f, -1.03640361e-02f,
  1.81207794e-03f, 5.65255545e-02f, -5.55405132e-02f, 7.15476498e-02f, 4.37039249e-02f, 1.84833668e-02f, 1.23563884e-02f, -2.18377132e-02f, -5.83703332e-02f, 1.81254465e-02f,
  -1.57747213e-02f, 3.75451474e-03f, -2.24634167e-02f, -1.00448327e-02f, 4.39263918e-02f, -2.87073683e-02f, -9.62222740e-02f, 8.54617283e-02f, -4.48879860e-02f, 7.73076760e-03f,
  -1.38168428e-02f, 8.03106744e-03f, 5.60485125e-02f, 1.85343381e-02f, 2.20013550e-03f, 2.18471754e-02f, -1.04290828e-01f, 1.70843806e-02f, 5.72472140e-02f, -6.61288276e-02f,
  -5.11713438e-02f, 1.06702549e-02f, -3.48007083e-02f, -6.12388887e-02f, -5.90943582e-02f, 3.17259040e-03f, -1.70719940e-02f, -2.73118224e-02f, -1.19803110e-02f, -4.68199849e-02f,
  -5.39614931e-02f, -4.42826599e-02f, -4.45649922e-02f, -7.71643147e-02f, -9.14508253e-02f, -6.24928717e-03f, -2.64779218e-02f, -4.96721603e-02f, 6.92313313e-02f, -7.39975658e-04f,
  -1.72502860e-01f, -3.08339238e-01f, -1.16783582e-01f, 5.04993275e-02f, -1.06738359e-02f, 1.88518204e-02f, -1.73855461e-02f, -5.62320054e-02f, -1.13193877e-01f, 3.46837603e-02f,
  3.79037261e-02f, -9.11823753e-03f, 7.12852702e-02f, -1.17522376e-02f, -7.64569715e-02f, -4.49392274e-02f, -6.25147149e-02f, -2.04399768e-02f, -6.09125122e-02f, -8.02362561e-02f,
  -3.49688046e-02f, -5.77835925e-02f, 7.71743730e-02f, 3.40288766e-02f, 5.52039640e-03f, -1.06292954e-02f, 6.55648205e-03f, 8.44034553e-03f, 8.72688368e-03f, -7.84221813e-02f,
  4.34187442e-01f, -1.58804983e-01f, 6.04173988e-02f, 5.07827476e-02f, 2.40612909e-01f, 2.45963931e-01f, 2.33937457e-01f, -8.39366578e-03f, -2.02021338e-02f, -6.04731180e-02f,
  1.26666334e-02f, -8.23004618e-02f, -4.37999517e-02f, -2.11745381e-01f, 2.51922399e-01f, -7.86548257e-02f, 1.04654156e-01f, -2.29906403e-02f, -7.39994496e-02f, 5.65373376e-02f,
  -1.18855166e-03f, 6.41762838e-02f, -6.32335851e-03f, -8.99573788e-02f, 2.03282870e-02f, -1.10068526e-02f, -2.20706705e-02f, -1.24666266e-01f, -6.90228641e-02f, 4.12041061e-02f,
  1.45179659e-01f, -9.38418731e-02f, -3.66651639e-02f, -7.10606799e-02f, 1.69291809e-01f, 5.46753705e-02f, -4.82595013e-03f, -2.52736988e-03f, -1.42620467e-02f, -2.68378551e-03f,
  -2.38851961e-02f, 4.21291590e-03f, 3.77634577e-02f, -6.57124892e-02f, -2.52882540e-02f, -1.20811373e-01f, -6.50831498e-04f, -8.67237058e-03f, 1.53842969e-02f, -1.98943410e-02f,
  -5.87742068e-02f, 1.70611162e-02f, -5.35094813e-02f, 2.92891692e-02f, -6.50075125e-03f, -6.63093943e-03f, 1.68162119e-03f, -3.46680940e-03f, 5.78169653e-04f, 2.48015299e-02f,
  -3.19828689e-02f, -1.66148990e-02f, 6.23528995e-02f, -1.90157443e-02f, -2.82119103e-02f, 5.16014136e-02f, -3.61506119e-02f, 2.13539039e-04f, -7.72612393e-02f, 1.80763789e-02f,
  9.78957415e-02f, -3.35495174e-03f, -4.79206368e-02f, 3.82480491e-03f, -1.08885125e-03f, 2.88689639e-02f, -2.38901358e-02f, 3.77679281e-02f, 5.80553487e-02f, 5.42872436e-02f,
  -3.30012105e-02f, 2.71671358e-02f, -2.61528557e-03f, 4.07159738e-02f, -2.42628679e-02f, -1.32503444e-02f, -9.81946215e-02f, -7.21425489e-02f, 3.97373736e-02f, 7.19405636e-02f,
  -4.64880746e-03f, 7.69995302e-02f, 2.50657648e-02f, 1.62129719e-02f, -1.13820001e-01f, -3.76695246e-02f, -1.37081128e-02f, -2.01478433e-02f, -1.18034277e-02f, -2.81380471e-02f,
  -5.52735012e-03f, 7.87730608e-03f, 6.64491281e-02f, -1.29426401e-02f, -8.93224925e-02f, 1.56478249e-02f, 6.89653531e-02f, 6.67080879e-02f, 7.49945343e-02f, -1.56803168e-02f,
  2.70368643e-02f, 5.46422452e-02f, 1.19693121e-02f, 2.07154751e-02f, -3.29327285e-02f, 4.01122645e-02f, 6.66923299e-02f, -4.11321921e-03f, 6.60481527e-02f, 6.48306310e-03f,
  3.98200214e-01f, -1.09860472e-01f, -1.05391197e-01f, 2.84350216e-01f, -9.41128433e-02f, -1.12665862e-01f, -6.13728771e-03f, -2.93411482e-02f, 1.46059394e-01f, -1.12222776e-01f,
  1.49924070e-01f, 2.28767693e-02f, -1.57873798e-03f, 2.58325726e-01f, 3.86259764e-01f, 1.75911024e-01f, 3.51652026e-01f, 8.23830515e-02f, 1.47101164e-01f, -1.31525202e-02f,
  3.80121507e-02f, 6.46543652e-02f, -2.84390748e-02f, -7.13484138e-02f, -9.86731127e-02f, -1.93165481e-01f, 3.85581097e-03f, -1.97366744e-01f, 1.08126305e-01f, 8.62265192e-03f,
  -2.78703254e-02f, -2.00414658e-03f, -1.12739459e-01f, -4.81575914e-03f, -2.12741625e-02f, -2.63991114e-02f, -2.70923879e-02f, 6.30630925e-02f, 3.07052042e-02f, 3.44964676e-02f,
  5.47863990e-02f, 2.94988286e-02f, 1.28749851e-02f, 3.20577272e-03f, -1.73302107e-02f, 1.99500490e-02f, 2.02756710e-02f, -4.38275337e-02f, 3.74455228e-02f, 3.82715873e-02f,
  -1.11489054e-02f, 1.96762215e-02f, 1.12477869e-01f, 1.93653200e-02f, -6.45056516e-02f, 3.68861966e-02f, 2.81836502e-02f, -4.85017449e-02f, 1.05754614e-01f, 4.73813750e-02f,
  9.59157422e-02f, 2.92292871e-02f, 6.08649012e-03f, 4.60673831e-02f, -3.16542163e-02f, -1.67145748e-02f, 1.02606751e-01f, 3.50675918e-02f, 4.63796640e-03f, -1.19041596e-02f,
  8.93949568e-02f, -2.96183093e-03f, -2.94462759e-02f, 1.41421724e-02f, 3.16547044e-02f, -1.26181990e-02f, 5.21994829e-02f, -9.00881737e-02f, -4.03490625e-02f, -1.33868232e-02f,
  -5.16002905e-03f, -8.03346932e-03f, -5.91421537e-02f, 2.44579539e-02f, 7.41506973e-03f, -1.60029884e-02f, 1.31561672e-02f, -3.79962884e-02f, 8.77576973e-03f, 5.54899983e-02f,
  -1.90058723e-03f, 1.85780842e-02f, -5.96647849e-03f, -3.34978923e-02f, -2.54542641e-02f, 1.96682308e-02f, 6.17657267e-02f, -3.56684960e-02f, -3.61624882e-02f, -1.88250523e-02f,
  -9.07755718e-02f, -2.55737890e-04f, -5.91088831e-02f, 5.67748444e-03f, 4.57323529e-02f, -2.55679935e-02f, -9.62564908e-03f, -1.03790564e-02f, -2.27388879e-03f, 1.64380353e-02f,
  2.63712164e-02f, -5.49658872e-02f, 9.98825859e-03f, -9.35786124e-03f, 3.37120667e-02f, -6.42005056e-02f, -3.23531143e-02f, -4.52015270e-03f, 8.45922604e-02f, -2.04820279e-02f,
  3.55035394e-01f, -6.20728396e-02f, -1.02135837e-01f, 1.26616359e-01f, -1.21703029e-01f, -1.37881249e-01f, 9.57742706e-02f, -1.13067538e-01f, 1.03621423e-01f, -1.11076534e-01f,
  4.30983454e-02f, 6.82019666e-02f, 1.52665928e-01f, -1.74869478e-01f, 2.97696948e-01f, -8.15477315e-03f, -6.79316223e-02f, 1.27799794e-01f, -5.92737943e-02f, 5.80691453e-03f,
  2.02749223e-02f, 2.68085743e-03f, 1.47974426e-02f, -9.55949277e-02f, -8.96284953e-02f, -1.39737323e-01f, 9.64762643e-02f, 5.12321517e-02f, -1.40008122e-01f, -8.84346105e-03f,
  3.96083146e-02f, 1.16609097e-01f, -6.81307986e-02f, 4.35122736e-02f, 1.19507387e-02f, -1.73492637e-02f, 6.85395226e-02f, 4.23499905e-02f, 2.34273300e-02f, 2.76336782e-02f,
  9.05218124e-02f, -1.13662397e-02f, -5.36027402e-02f, 6.24281988e-02f, -6.39193654e-02f, 1.06360000e-02f, -1.22457400e-01f, -5.86813726e-02f, -1.03838027e-01f, -1.01576567e-01f,
  -2.90635731e-02f, -5.11097349e-03f, 2.67155841e-02f, 2.12297142e-02f, 2.84003261e-02f, -1.60391722e-02f, -7.14500695e-02f, 1.02092270e-02f, 2.27866378e-02f, -2.83864588e-02f,
  1.80682521e-02f, -4.78397720e-02f, -1.09238941e-02f, -2.66577024e-02f, 6.27653906e-03f, -1.44760907e-02f, -6.88222051e-02f, 3.33473422e-02f, 1.05425389e-02f, -3.63241173e-02f,
  1.50651522e-02f, -3.94537151e-02f, 1.63352471e-02f, 2.28737108e-02f, -6.02697730e-02f, 8.97550434e-02f, 2.45613344e-02f, 1.18726566e-02f, -8.48177001e-02f, -4.45670885e-04f,
  3.93833257e-02f, 3.75576988e-02f, 7.94358365e-03f, -5.64878667e-03f, 5.16485348e-02f, 4.78884056e-02f, 1.60194538e-03f, 2.86538024e-02f, -2.26887129e-02f, 4.65543531e-02f,
  1.40577078e-01f, 4.41234350e-01f, -1.05712026e-01f, 6.49541244e-02f, -1.07182376e-03f, -1.33856488e-02f, -1.35892387e-02f, -2.65816990e-02f, 1.48517892e-01f, 3.15308608e-02f,
  -1.59825515e-02f, -1.38055952e-02f, 7.38671124e-02f, -3.09872460e-02f, 2.62573939e-02f, -1.02272168e-01f, -1.24287829e-02f, 4.02269289e-02f, 7.21250777e-04f, -2.34068022e-03f,
  4.32627797e-02f, 8.67757946e-02f, 3.37152034e-02f, 3.81830782e-02f, -4.77884859e-02f, 1.39749888e-02f, 4.33988832e-02f, -2.90365890e-02f, -3.00487392e-02f, -2.74542868e-02f,
  6.20363727e-02f, 2.14793012e-01f, -1.26477063e-01f, 1.74102426e-01f, -3.49340737e-02f, 2.26194620e-01f, 1.77950971e-02f, 2.17577610e-02f, 1.44574985e-01f, 8.38892013e-02f,
  2.76477709e-02f, -1.82643995e-01f, -6.62100390e-02f, 1.66190267e-01f, -1.40945241e-01f, -5.21586537e-02f, 1.74655914e-01f, 2.91810203e-02f, -4.34578117e-03f, 3.46982405e-02f,
  -4.08947617e-02f, 1.75139830e-01f, 1.20963365e-01f, 1.54860109e-01f, 5.99350855e-02f, 3.30365309e-03f, 8.61752033e-03f, -8.86182562e-02f, 1.98512211e-01f, -9.22093987e-02f,
  4.05558906e-02f, 3.62858102e-02f, 5.48221171e-02f, 5.27891330e-02f, 1.22654967e-01f, -7.16930330e-02f, 1.52601963e-02f, -7.25814477e-02f, 1.55795682e-02f, 3.91590483e-02f,
  -2.30802521e-02f, 6.26416355e-02f, -7.60797262e-02f, -3.31382379e-02f, 1.57161001e-02f, 8.90751481e-02f, 3.11921388e-02f, 1.24473602e-01f, 1.96476802e-02f, -2.84287687e-02f,
  -3.73832555e-03f, 8.71601626e-02f, 1.04545631e-01f, -7.06626743e-04f, -5.31426743e-02f, -2.68165916e-02f, -1.06125213e-01f, -2.27831602e-02f, 5.15833534e-02f, -1.16825337e-02f,
  -7.36879632e-02f, 4.77830544e-02f, 5.98018505e-02f, 1.25994394e-02f, 6.01368658e-02f, -7.33952597e-03f, 7.54228793e-03f, 2.59149051e-03f, 2.08524112e-02f, -6.74712658e-03f,
  1.06368445e-01f, -5.41219721e-03f, -2.25187149e-02f, -8.25478788e-03f, -7.00230291e-03f, 4.38560583e-02f, 7.62075651e-03f, -2.89152786e-02f, 5.01568653e-02f, -1.10799726e-02f,
  -1.16773685e-02f, 4.39789779e-02f, 7.48889297e-02f, 7.66252307e-03f, 1.77019581e-04f, -3.91884334e-02f, -6.57725986e-03f, -3.89584340e-02f, -9.44821443e-03f, -9.98671651e-02f,
  2.22339332e-01f, 3.41578163e-02f, 2.34040897e-02f, 2.76877545e-02f, 8.07274692e-03f, 4.96424101e-02f, 2.76983008e-02f, 3.90173891e-03f, 3.15726511e-02f, 2.18793433e-02f,
  -3.98270451e-02f, 8.07067472e-03f, -7.77362194e-03f, 4.06448450e-03f, 3.54445055e-02f, 2.67328899e-02f, -3.65246460e-02f, 9.08864811e-02f, 6.05058633e-02f, -2.93143392e-02f,
  1.55388251e-01f, -9.00398642e-02f, -7.46492818e-02f, 7.01981559e-02f, 2.51087826e-02f, -5.71621768e-02f, -5.83614595e-02f, 4.02630679e-02f, -9.16326046e-02f, 2.58520264e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.41042173e-01f, 3.33752304e-01f, -2.01677307e-01f, 6.29236028e-02f, 3.62509266e-02f, 4.31628525e-01f, 3.52945477e-01f, -4.14660852e-03f, 1.20024584e-01f, 3.31519544e-01f,
  4.55771051e-02f, 6.94482625e-02f, -8.18957984e-02f, 3.14413965e-01f, 3.84156294e-02f, 1.30136266e-01f, 4.03502107e-01f, 2.37570971e-01f, -2.36546155e-03f, 1.87628493e-01f,
  -7.61073530e-02f, 3.32109809e-01f, -1.71433985e-01f, 2.65270248e-02f, 4.03416082e-02f, -1.64790303e-01f, -9.37715173e-02f, -2.29788512e-01f, 1.73631441e-02f, 9.26271230e-02f,
  3.90053168e-02f, 9.58348997e-03f, -4.66221236e-02f, -1.35072563e-02f, -2.78821271e-02f, -1.33038694e-02f, 7.53472298e-02f, -2.14955937e-02f, -1.23942271e-01f, -5.95136881e-02f,
  5.41414134e-02f, 3.90794985e-02f, 1.14064582e-01f, -6.75318614e-02f, 1.73614564e-04f, -9.70656201e-02f, -6.47485852e-02f, -9.65575650e-02f, -9.03781205e-02f, -4.31773402e-02f,
  -5.28419130e-02f, 1.55652137e-02f, -3.41515057e-02f, 4.56322692e-02f, -8.89674723e-02f, 9.45928469e-02f, 1.22560956e-01f, 3.59544065e-03f, 5.09850420e-02f, 1.07230462e-01f,
  6.80546137e-03f, 8.25349540e-02f, 7.63278455e-02f, -6.37623668e-03f, -4.18757387e-02f, -6.12365566e-02f, -2.30693500e-02f, 8.09609517e-03f, -4.25901003e-02f, 5.88632328e-03f,
  2.05269903e-02f, -4.29770499e-02f, -2.91553326e-02f, 2.75964160e-02f, 1.17359579e-01f, 5.58690280e-02f, -6.97197244e-02f, 7.85123110e-02f, 1.47998042e-03f, -9.31599457e-03f,
  7.58889038e-03f, -1.07816234e-02f, 2.22156160e-02f, -1.46731399e-02f, -2.13923547e-02f, -3.10467072e-02f, 4.94079776e-02f, -5.26263891e-03f, -4.90879267e-02f, 3.71936001e-02f,
  1.70712933e-01f, 2.91046113e-01f, -4.35250588e-02f, -7.06249988e-03f, 4.63079698e-02f, 1.28055895e-02f, 7.17155561e-02f, 5.73544167e-02f, 1.20784957e-02f, 1.11962177e-01f,
  6.81903288e-02f, -3.28179672e-02f, -2.91262870e-03f, -1.60052460e-02f, 1.96729470e-02f, 1.01185098e-01f, 1.07297324e-01f, -1.71668790e-02f, 4.75993417e-02f, 4.21133265e-02f,
  -4.73723449e-02f, 6.19448498e-02f, 3.91499437e-02f, -3.12835835e-02f, 8.90700594e-02f, 1.39999557e-02f, 4.33046706e-02f, -3.66455540e-02f, -2.88458429e-02f, 2.54683886e-02f,
  -3.90556395e-01f, -1.67594522e-01f, -4.50617194e-01f, -2.57227957e-01f, 2.52929717e-01f, 1.87712416e-01f, -1.78715467e-01f, -3.43465321e-02f, -3.75903934e-01f, 1.75264388e-01f,
  -2.32427269e-02f, -1.44021362e-01f, -3.14860076e-01f, -1.23977378e-01f, -2.05154091e-01f, -4.05271679e-01f, 1.28589243e-01f, -3.56575735e-02f, -2.26035953e-01f, 7.18740001e-03f,
  -1.28486753e-01f, 8.89224336e-02f, -4.00179952e-01f, 1.57880530e-01f, -8.66578240e-03f, -2.68804599e-02f, 3.78681272e-01f, 5.94406836e-02f, 2.00878486e-01f, 9.09778029e-02f,
  -4.09244560e-02f, -1.88746303e-01f, -6.49431497e-02f, -5.59846573e-02f, 1.02852724e-01f, 1.27022386e-01f, 1.44871265e-01f, 9.57274437e-03f, -5.97505346e-02f, -8.85155275e-02f,
  8.82046446e-02f, -4.98694591e-02f, 4.00671437e-02f, 1.98840294e-02f, 1.02455576e-03f, 2.22411565e-02f, -1.21494606e-01f, -2.61889603e-02f, -1.44721176e-02f, -1.64049447e-01f,
  -1.33063734e-01f, 2.34932210e-02f, 8.79883692e-02f, -3.46440412e-02f, -9.08465907e-02f, -7.87389278e-02f, 6.15171194e-02f, 2.56086551e-02f, 1.30370006e-01f, -1.33941779e-02f,
  3.89775373e-02f, 1.38174266e-01f, -5.22059388e-02f, -4.01224159e-02f, 5.97226026e-04f, -2.38225758e-02f, -3.21740359e-02f, 6.77968040e-02f, -1.12422585e-01f, 9.92875826e-03f,
  3.95778130e-04f, -6.66212216e-02f, 2.52179801e-02f, -5.64646209e-03f, -4.66918433e-03f, 2.63875443e-02f, 7.32986256e-02f, -3.30340974e-02f, -3.58567201e-02f, -5.12770228e-02f,
  4.64824513e-02f, 2.74672583e-02f, 1.96116045e-02f, 5.40201366e-02f, 9.86821130e-02f, -7.75991892e-03f, 6.16154633e-02f, -9.25242603e-02f, -1.73280446e-03f, 1.47220287e-02f,
  1.39575183e-01f, 9.50184837e-02f, -1.06235407e-01f, 3.14698592e-02f, -4.37169299e-02f, 1.60523448e-02f, 3.69444489e-03f, 5.42082675e-02f, -1.53046558e-02f, -5.16432822e-02f,
  1.50182784e-01f, 1.82552680e-01f, 8.42074454e-02f, -9.49221626e-02f, 3.45108099e-02f, -1.33792451e-02f, 3.23765166e-02f, 4.54477184e-02f, 1.36997491e-01f, 8.76443163e-02f,
  9.42304358e-02f, 9.98109505e-02f, 4.13785763e-02f, 1.73368901e-02f, 1.04255296e-01f, 3.64782363e-02f, 4.28931229e-02f, -3.74861285e-02f, 1.01885234e-03f, -4.12603356e-02f,
  5.29227734e-01f, -3.05894285e-01f, -2.61088610e-01f, 2.15933427e-01f, 3.62148374e-01f, 2.66510934e-01f, 2.16100276e-01f, 1.68303221e-01f, 2.33318165e-01f, -2.33507499e-01f,
  6.70595467e-02f, -1.76078558e-01f, -1.74128547e-01f, 8.46120045e-02f, 3.91945004e-01f, -1.23733841e-01f, 1.99515298e-01f, -8.07881281e-02f, 1.05438223e-02f, -5.04190587e-02f,
  2.08467066e-01f, 3.25990319e-01f, -1.59009900e-02f, 5.27831428e-02f, 1.65876061e-01f, -9.17561874e-02f, -6.95260167e-02f, -1.72344401e-01f, 1.81039162e-02f, 7.07964450e-02f,
  1.13402218e-01f, 5.08110598e-02f, 9.65315029e-02f, -3.91260646e-02f, -6.46846369e-02f, -4.07896154e-02f, -2.54440829e-02f, -3.14694606e-02f, 8.86070356e-02f, -5.55956289e-02f,
  -1.04046725e-02f, 6.46914542e-02f, 8.16869363e-03f, 7.90588260e-02f, 3.48986685e-02f, 9.45694968e-02f, -3.59616615e-02f, -1.54586686e-02f, -4.51664478e-02f, -3.81014384e-02f,
  2.21001729e-02f, -9.41691175e-02f, 2.38700937e-02f, -8.88725817e-02f, -4.98086363e-02f, 3.57510569e-03f, -5.98720312e-02f, -9.81225669e-02f, -3.36501636e-02f, 6.18684525e-03f,
  3.82471457e-02f, -6.72752969e-03f, -5.34713455e-02f, 1.94811653e-02f, -8.50088242e-03f, -1.81562118e-02f, 9.11095738e-03f, -9.67124384e-03f, -4.45046928e-03f, 7.86835048e-03f,
  5.85810579e-02f, 1.04604997e-01f, 5.25571173e-03f, 4.60930616e-02f, -4.41955104e-02f, 7.88973197e-02f, 2.56656036e-02f, -5.36724888e-02f, -1.42134801e-02f, 1.75220966e-02f,
  -1.05605703e-02f, 2.42956094e-02f, -2.48675942e-02f, -3.95924449e-02f, -4.32943143e-02f, 3.51220928e-02f, 1.56826898e-02f, 1.02455951e-02f, -1.47364661e-02f, -2.98321191e-02f,
  -7.84707516e-02f, -2.69276917e-01f, -1.11508705e-01f, -7.64570059e-03f, -9.85717177e-02f, 5.70793031e-03f, 2.85663661e-02f, 8.10985938e-02f, -4.31025960e-02f, 3.78380506e-03f,
  5.20034730e-02f, -1.15807611e-03f, -5.88486195e-02f, 7.62498705e-03f, 3.97458598e-02f, 5.86459711e-02f, -8.69238973e-02f, -4.20210660e-02f, -1.39941229e-02f, 5.57552837e-03f,
  -4.15651910e-02f, -5.18542826e-02f, -2.68983226e-02f, 6.52687997e-02f, 2.31984742e-02f, -9.82771665e-02f, -2.65287664e-02f, -1.80296134e-02f, -8.99033770e-02f, -4.07710001e-02f,
  -3.47370774e-01f, 1.43193454e-01f, -1.63203835e-01f, 3.69917527e-02f, -1.62129670e-01f, -4.08206910e-01f, 4.36515249e-02f, 1.54526919e-01f, -1.89999044e-01f, 3.52543622e-01f,
  2.62528241e-01f, -3.74386728e-01f, 3.10758173e-01f, 8.48227143e-02f, -3.76005679e-01f, -2.63227951e-02f, 3.67348082e-02f, -3.22999060e-02f, -1.93159163e-01f, 1.02426358e-01f,
  -6.44228384e-02f, 5.29307835e-02f, -2.44501177e-02f, 1.29520521e-01f, -3.78813110e-02f, 8.00263584e-02f, 3.55105668e-01f, 3.10883205e-02f, 9.02288705e-02f, -1.82156250e-01f,
  -6.30051494e-02f, 2.01630309e-01f, 1.92112830e-02f, -1.60575375e-01f, -1.62125155e-02f, 1.29131600e-02f, 6.82301298e-02f, -7.02472031e-02f, -4.62486856e-02f, -8.51010382e-02f,
  -1.07387483e-01f, -7.44490474e-02f, -2.75582522e-02f, -9.34940502e-02f, -7.30662271e-02f, -5.78441471e-02f, -1.46638572e-01f, -1.28342882e-01f, -1.16527811e-01f, -1.63604826e-01f,
  -2.88508423e-02f, -5.20387180e-02f, -1.86751620e-03f, -3.41408923e-02f, -5.67908399e-02f, -4.63162027e-02f, -5.89120016e-02f, -8.20345897e-03f, -2.54806671e-02f, -7.73360133e-02f,
  -5.45920208e-02f, -6.38377219e-02f, 3.09438352e-02f, -5.13576306e-02f, 1.26418784e-01f, 4.47703041e-02f, -1.18785212e-02f, 4.17371914e-02f, -1.07944340e-01f, 2.30019279e-02f,
  -1.12377843e-02f, -6.99067581e-03f, -5.85823692e-02f, 5.90206012e-02f, -7.36991689e-03f, 6.08706661e-02f, -1.80922262e-02f, 5.18832691e-02f, -3.62589136e-02f, 4.25856225e-02f,
  1.67249627e-02f, -1.83077324e-02f, -1.52717661e-02f, 9.92881507e-02f, -5.34210950e-02f, -1.05934998e-03f, -1.09204106e-01f, -3.36346105e-02f, 1.13925561e-01f, 4.45541032e-02f,
  4.20587994e-02f, 2.65386164e-01f, 1.18544497e-01f, -4.53977846e-02f, 9.51403379e-02f, -2.56492030e-02f, -9.34901983e-02f, -1.05337337e-01f, 5.10399118e-02f, -7.33245239e-02f,
  2.26651672e-02f, 5.27317747e-02f, -5.23503385e-02f, 4.37836312e-02f, -4.62621301e-02f, 6.56968504e-02f, 9.54896361e-02f, 3.27721909e-02f, 6.15950264e-02f, 1.17484003e-01f,
  1.09804377e-01f, -1.25324400e-03f, -1.14608556e-01f, 1.30850179e-02f, 7.32831731e-02f, -1.94594562e-02f, 3.52051891e-02f, -8.40234831e-02f, 3.60452347e-02f, -1.05100572e-01f,
  2.40351975e-01f, -2.35341355e-01f, -1.54812261e-01f, 3.08598697e-01f, 1.08770691e-01f, -1.18588850e-01f, -2.16621578e-01f, 2.13138968e-01f, -5.29493056e-02f, -2.46564433e-01f,
  6.17271513e-02f, -1.57753885e-01f, -1.82508886e-01f, 2.41678417e-01f, 3.27325940e-01f, -2.66533941e-01f, 7.57749528e-02f, 5.82040139e-02f, -6.29819110e-02f, 8.01179092e-03f,
  1.88581467e-01f, 1.94022477e-01f, 2.36464694e-01f, 2.74065435e-01f, 7.21654370e-02f, 2.31669217e-01f, 2.39523545e-01f, -4.24132422e-02f, 3.02271336e-01f, 1.53118297e-01f,
  -7.69221112e-02f, -1.71597824e-02f, -4.77532744e-02f, -7.72076473e-02f, 6.54053092e-02f, -1.22779816e-01f, -1.30407333e-01f, -1.03151212e-02f, -1.55665223e-02f, 8.92683957e-03f,
  -6.94096237e-02f, 4.73835133e-02f, 1.73138231e-01f, -5.32236770e-02f, -2.04752963e-02f, 1.75306089e-02f, -1.08199529e-02f, -3.08974627e-02f, 4.02310118e-02f, 4.63382117e-02f,
  -9.14597437e-02f, 7.01480508e-02f, 3.33814160e-03f, 7.92341009e-02f, 1.04459651e-01f, 8.99365842e-02f, 4.14846428e-02f, 3.43912421e-03f, -6.91060051e-02f, 3.28304917e-02f,
  -2.56828051e-02f, -3.27397175e-02f, 5.93261681e-02f, 1.47236260e-02f, 7.99209625e-02f, -9.56130996e-02f, 3.82965021e-02f, 1.78749524e-02f, -1.93174127e-02f, -6.55178875e-02f,
  1.73773058e-02f, 8.08225200e-02f, 4.48595919e-02f, 7.58613367e-03f, -6.55432406e-04f, 5.33435531e-02f, 4.29653823e-02f, 1.04470238e-01f, -1.41883204e-02f, 2.42468081e-02f,
  -2.74544228e-02f, 9.23723280e-02f, 1.33622279e-02f, 7.16474801e-02f, 4.01593596e-02f, 3.25490572e-02f, -1.75177902e-02f, 1.63942240e-02f, -3.56246978e-02f, 2.44380701e-02f,
  -1.95641682e-01f, -6.18272983e-02f, 9.97679085e-02f, 7.78134614e-02f, -5.40117547e-03f, -9.23103467e-02f, -7.91663229e-02f, 1.25020109e-02f, -6.11578748e-02f, 1.69985201e-02f,
  -9.01253596e-02f, 3.05278767e-02f, -6.44995924e-03f, 9.75477546e-02f, 3.68783697e-02f, -6.65221438e-02f, -2.78017670e-02f, -6.67639747e-02f, -2.86859982e-02f, 1.01243243e-01f,
  -3.51947099e-02f, -2.18341649e-02f, -3.63738611e-02f, 1.11562526e-02f, -4.07465594e-03f, -4.99236472e-02f, 6.78550377e-02f, -4.72655930e-02f, 4.27885726e-02f, -1.19713806e-01f,
  4.18029100e-01f, 7.56761357e-02f, 3.01604539e-01f, 2.82650918e-01f, 1.77571531e-02f, -2.01333180e-01f, 1.32156769e-03f, 6.49053678e-02f, 2.72745579e-01f, -1.37609228e-01f,
  -6.13925084e-02f, 2.00388074e-01f, -2.37884745e-01f, 8.47747102e-02f, -1.55828074e-01f, -1.77602842e-01f, 7.03765824e-02f, 7.60864466e-02f, 1.63777143e-01f, 2.02182025e-01f,
  1.31751150e-01f, -1.90986067e-01f, 5.73831052e-02f, -1.65549859e-01f, 1.27615303e-01f, 1.34392768e-01f, -2.45402008e-01f, -2.00444505e-01f, -6.24633394e-03f, -2.53827602e-01f,
  7.41460621e-02f, 1.56121403e-01f, 5.59321679e-02f, 3.26349540e-03f, 2.15745904e-02f, -5.37856743e-02f, -1.07433408e-01f, -2.45766118e-01f, 9.15407240e-02f, 1.28063969e-02f,
  -4.78537343e-02f, 1.63220875e-02f, 4.65648659e-02f, 8.06176756e-03f, 5.79528371e-03f, 1.33903340e-01f, 9.30876434e-02f, 9.16965604e-02f, 1.46040469e-01f, 1.13734201e-01f,
  1.46081433e-01f, 1.07548505e-01f, 9.66776982e-02f, -1.66205704e-01f, 2.32042316e-02f, 4.74078432e-02f, -2.99435817e-02f, 5.62157948e-03f, 1.01780109e-01f, 7.68012255e-02f,
  -1.47212058e-01f, -1.35231450e-01f, -2.34523304e-02f, 1.49365127e-01f, -5.62944710e-02f, 8.88924859e-03f, -6.63228631e-02f, 2.94016711e-02f, -5.05990684e-02f, -4.02070861e-03f,
  3.39419618e-02f, 3.30164582e-02f, 1.21911904e-02f, 8.80489871e-02f, -4.32828180e-02f, 6.61369786e-02f, 5.14652729e-02f, -4.41348879e-03f, 2.71289628e-02f, -1.68310180e-02f,
  6.67280778e-02f, -2.19156854e-02f, 4.76586483e-02f, 6.46188930e-02f, -2.01118737e-02f, -8.08872804e-02f, 6.81009665e-02f, 5.50867582e-04f, 2.59887688e-02f, -5.44149876e-02f,
  -2.00671047e-01f, -3.28997582e-01f, -7.13250116e-02f, -5.12028337e-02f, 3.31297927e-02f, 3.08463275e-02f, 4.46884781e-02f, 1.02189623e-01f, -6.83092326e-02f, -5.26536256e-02f,
  1.48064494e-02f, 2.75599975e-02f, -5.54879904e-02f, 5.25311008e-02f, -2.88612451e-02f, 4.81185839e-02f, -1.33005545e-01f, -1.82659015e-01f, -9.36868712e-02f, -3.47930305e-02f,
  -4.90298718e-02f, -1.07385650e-01f, -6.39525652e-02f, -1.05479953e-03f, 5.39712347e-02f, -8.92225578e-02f, 1.38246536e-01f, 1.69998333e-02f, -1.03460439e-01f, -6.51054382e-02f,
  4.57432657e-01f, -1.14783850e-02f, -1.70947120e-01f, 6.20523356e-02f, 1.43627733e-01f, 2.70204037e-01f, 2.37822458e-01f, 1.37536913e-01f, 1.06650360e-01f, 7.23864883e-02f,
  1.16202913e-01f, -1.91531017e-01f, 2.10293382e-02f, 2.43701428e-01f, 3.76615822e-02f, -4.47098017e-02f, 9.00239497e-02f, 2.13049911e-02f, 1.95948072e-02f, 1.64884120e-01f,
  1.21031836e-01f, 2.47822016e-01f, -1.38459235e-01f, -9.40978900e-02f, 1.99243814e-01f, -2.02565372e-01f, -1.28514186e-01f, -1.84911042e-01f, -2.07877368e-01f, -1.66624546e-01f,
  5.79624660e-02f, 1.09098367e-01f, -6.10399581e-02f, -2.55522635e-02f, 2.70031095e-02f, 3.78444344e-02f, -6.86807707e-02f, -1.12866640e-01f, -9.65217948e-02f, -1.91041585e-02f,
  -2.40562521e-02f, -6.50876090e-02f, 7.05220029e-02f, -5.97819164e-02f, 1.08705334e-01f, -1.09722830e-01f, -6.61501288e-02f, 5.43169305e-03f, -1.11866549e-01f, 4.55965735e-02f,
  -2.31061038e-02f, -1.01193041e-01f, -3.12163103e-02f, -1.38099477e-01f, -4.21786588e-03f, -4.56094258e-02f, -1.00785598e-01f, 3.48878987e-02f, -4.32857908e-02f, -6.08544312e-02f,
  7.39251077e-02f, -2.63099354e-02f, 3.85642946e-02f, -4.75917151e-03f, 1.35836884e-01f, 7.33363256e-02f, -7.07770213e-02f, -5.30118793e-02f, 5.09385765e-02f, 4.12458219e-02f,
  -6.89463913e-02f, 1.38758719e-02f, 7.16692358e-02f, 2.90773846e-02f, 7.78863281e-02f, -2.78448816e-02f, 2.35799216e-02f, -1.07298996e-02f, -6.51611984e-02f, -4.86662835e-02f,
  -2.07939222e-02f, 6.26336485e-02f, -1.81028266e-02f, 9.52651538e-03f, 1.11410751e-04f, -7.18239099e-02f, 6.87133297e-02f, -4.09154147e-02f, 9.00881216e-02f, 1.17866173e-02f,
  3.69280577e-02f, -1.20607577e-02f, 7.54603669e-02f, 3.60931978e-02f, -6.68974826e-03f, 2.94544958e-02f, -6.29487634e-02f, 4.06470150e-02f, -1.35300323e-01f, 7.35920966e-02f,
  1.57598592e-03f, 1.19116006e-03f, -1.43832210e-02f, 1.82738435e-02f, -1.78658560e-01f, 4.53060530e-02f, 3.90452109e-02f, -1.06333010e-01f, -1.50616253e-02f, -1.12116434e-01f,
  -7.53093660e-02f, 7.89229050e-02f, -1.07778497e-01f, 4.06645378e-03f, -1.10459905e-02f, -1.72785372e-02f, 3.56498696e-02f, -7.23507255e-02f, -2.72968523e-02f, -5.09089157e-02f,
  -6.33288145e-01f, -6.19956851e-03f, 3.49979043e-01f, -3.83305728e-01f, 3.13924253e-03f, 4.46515501e-01f, 4.06919450e-01f, -7.38059208e-02f, -4.22707289e-01f, -5.35623915e-02f,
  -3.67144570e-02f, -6.98243603e-02f, 3.63113642e-01f, -2.14750972e-03f, 3.16951513e-01f, 2.18645394e-01f, 2.48680077e-02f, -1.29383616e-02f, -7.99463838e-02f, -1.88110888e-01f,
  -4.77785207e-02f, -4.87500839e-02f, 3.13557386e-01f, -1.29009724e-01f, -7.56263658e-02f, -2.61498332e-01f, -1.47187173e-01f, 1.92678899e-01f, -1.37943849e-01f, 7.37186521e-02f,
  -3.69235337e-01f, -3.43067318e-01f, -1.32701501e-01f, 5.20877726e-02f, 5.61449304e-02f, 1.11456309e-02f, 7.02836439e-02f, 1.45471171e-01f, -1.22953705e-01f, -3.22952233e-02f,
  4.66869324e-02f, 1.80179868e-02f, -1.41286746e-01f, 8.69836938e-03f, -1.07206970e-01f, -6.88820928e-02f, -3.25587057e-02f, -2.46474780e-02f, 1.48689812e-02f, 1.13104284e-01f,
  1.26489758e-01f, 2.92222854e-02f, 6.91535920e-02f, -9.23035741e-02f, 6.70197010e-02f, -2.05730554e-02f, 5.32828737e-03f, 7.93872774e-02f, -3.49475481e-02f, -1.26078844e-01f,
  8.75433162e-02f, 9.99851823e-02f, 7.24442601e-02f, -4.47295457e-02f, 6.35570958e-02f, -8.67219716e-02f, -5.16625792e-02f, 3.37398462e-02f, -1.75836924e-02f, -2.40973085e-02f,
  -5.40631339e-02f, -3.10172699e-02f, -2.44068317e-02f, 7.52511900e-04f, 1.18419027e-03f, -2.49982607e-02f, 1.35263577e-01f, -5.92116863e-02f, -1.08221620e-02f, -1.82481911e-02f,
  1.80996563e-02f, -3.29688974e-02f, 6.54569790e-02f, 2.28591263e-02f, 5.90673834e-02f, 4.34623510e-02f, -4.39320914e-02f, 5.30415550e-02f, -1.90317780e-02f, 4.24507223e-02f,
  -4.22509015e-01f, -2.29302645e-01f, 1.00394459e-02f, -4.48691249e-02f, -1.06509782e-01f, 4.76503707e-02f, 8.49383101e-02f, -6.46497821e-03f, -1.33883685e-01f, -7.22579211e-02f,
  -1.30377069e-01f, -2.16630939e-02f, -2.95685008e-02f, 6.00868315e-02f, 7.02246428e-02f, -3.78674939e-02f, -2.02758070e-02f, -1.16484016e-01f, -6.70591071e-02f, -6.08977415e-02f,
  -5.72394431e-02f, -1.55404909e-02f, -2.19208561e-02f, -4.73488085e-02f, 5.44546135e-02f, -5.07195927e-02f, -1.54642686e-01f, 3.32109723e-03f, -1.56409349e-02f, 1.60046555e-02f,
  1.63691595e-01f, -6.94159418e-02f, -6.47739619e-02f, 7.05064386e-02f, -1.60795435e-01f, -3.03400069e-01f, -2.74099797e-01f, 1.87011316e-01f, -3.40888232e-01f, -5.27951904e-02f,
  1.36334747e-01f, -1.31852999e-01f, -2.06378981e-01f, -1.44026484e-02f, 1.47395477e-01f, -2.77660400e-01f, 1.84580207e-01f, 1.89649668e-02f, -1.98958963e-01f, 3.09092194e-01f,
  2.39004612e-01f, 2.00114086e-01f, 2.07793459e-01f, 3.10660392e-01f, 2.09518522e-02f, 3.40695143e-01f, 4.31398064e-01f, 1.30992336e-02f, 4.31855619e-01f, 4.98775318e-02f,
  2.12110225e-02f, -9.00340304e-02f, -6.36264011e-02f, -5.96510507e-02f, 1.53847322e-01f, 7.29604289e-02f, -6.60994202e-02f, -1.28012404e-01f, 8.62377435e-02f, 2.64417361e-02f,
  -2.00640619e-01f, 5.48422933e-02f, 1.43335387e-02f, 3.03051304e-02f, -9.44763124e-02f, -4.93658893e-02f, -1.01155788e-01f, -5.15323728e-02f, -5.98379970e-02f, 7.70645440e-02f,
  -1.21125028e-01f, -1.08628668e-01f, -3.69665027e-02f, -2.88135726e-02f, -1.12446709e-04f, 6.29517483e-03f, 1.92732259e-03f, -2.34571788e-02f, -4.14978154e-03f, 9.60615799e-02f,
  1.29759356e-01f, 1.65660549e-02f, -1.53811295e-02f, -6.67138547e-02f, 1.26680844e-02f, 5.85473739e-02f, -3.49258073e-02f, 1.47044403e-03f, 1.15182504e-01f, 1.71204228e-02f,
  5.33094630e-02f, 6.48029372e-02f, -6.03558496e-03f, 5.84083423e-03f, 5.78780286e-02f, -1.40820563e-01f, -2.23283563e-02f, -4.01615873e-02f, 4.04530391e-02f, -8.52423534e-02f,
  -3.70249264e-02f, 6.36996031e-02f, 6.87057059e-03f, -3.19585204e-02f, -4.72088717e-02f, 1.82289779e-02f, 8.78923386e-02f, -6.95715472e-02f, -3.81668881e-02f, -4.52363789e-02f,
  5.28713427e-02f, 3.04140568e-01f, -7.76077155e-03f, -8.66074786e-02f, 5.88091835e-02f, 6.91964924e-02f, -2.92450115e-02f, 6.33376092e-02f, -5.33515215e-03f, -1.87816676e-02f,
  1.38568595e-01f, -1.96199119e-02f, -2.48000212e-02f, 2.70241965e-02f, 1.39306203e-01f, 3.00575905e-02f, 8.35468471e-02f, 1.42177492e-01f, -5.82138682e-03f, 7.12793991e-02f,
  -5.83404535e-03f, -7.59306252e-02f, 7.18071386e-02f, -6.74926043e-02f, -5.29867550e-03f, 1.70256663e-02f, 1.36535997e-02f, 1.19276538e-01f, -4.35046740e-02f, -4.55134409e-03f,
  -1.16700351e-01f, 9.28435028e-02f, -9.26027447e-02f, -8.18180814e-02f, 8.93633533e-03f, -4.83973980e-01f, -2.57298917e-01f, -6.83600828e-02f, 5.06787077e-02f, 1.83761269e-01f,
  -2.00522825e-01f, 1.51913375e-01f, 7.07629099e-02f, -3.14903975e-01f, -5.43221116e-01f, -3.09407204e-01f, -4.78976607e-01f, -2.07664073e-01f, -4.81646806e-02f, -1.17387436e-01f,
  -2.72633582e-01f, -3.01149011e-01f, -1.96746901e-01f, -2.81257983e-02f, -1.78594783e-01f, 1.75661653e-01f, 8.45301822e-02f, 1.64032802e-02f, 2.23281123e-02f, 2.75334204e-03f,
  1.33679025e-02f, 1.55268863e-01f, 1.39783171e-03f, 9.89155695e-02f, -3.60532962e-02f, 1.41089223e-03f, -3.11439596e-02f, -8.78506824e-02f, 6.78123310e-02f, 3.51531967e-03f,
  1.31772026e-01f, 1.56557020e-02f, -3.39569189e-02f, -5.27455583e-02f, -4.15422842e-02f, 9.67516676e-02f, 6.89411685e-02f, 2.73888707e-02f, 4.98502217e-02f, 6.40681460e-02f,
  -3.64097767e-02f, 1.05345401e-03f, 4.10197228e-02f, -6.97114365e-03f, -2.46787425e-02f, 2.25072610e-03f, -3.79639468e-03f, 5.10660931e-02f, 3.58100645e-02f, 1.39301103e-02f,
  3.72551917e-03f, -6.13298640e-02f, -3.41885560e-03f, -4.98178750e-02f, -1.28223762e-01f, 1.82917379e-02f, -1.12245955e-01f, -6.73066303e-02f, 9.03083012e-03f, -2.45184377e-02f,
  3.73458564e-02f, 4.51260107e-03f, 4.36917618e-02f, 3.38936201e-03f, -3.10040805e-02f, -2.60170437e-02f, -1.15215719e-01f, 7.53147453e-02f, -6.04610220e-02f, -1.53057486e-01f,
  7.14307800e-02f, 2.29976457e-02f, -5.73683940e-02f, 3.72676514e-02f, -4.85725403e-02f, 1.17088528e-02f, 5.02800234e-02f, -1.92779712e-02f, -4.72291447e-02f, -1.95569778e-03f,
  2.21820250e-02f, 1.31509930e-01f, 3.15177627e-02f, 8.70504826e-02f, -2.68443860e-02f, 1.21982740e-02f, -8.27110261e-02f, 1.26817939e-03f, -8.25396627e-02f, 3.60683985e-02f,
  4.39100638e-02f, -7.82713443e-02f, 4.48561215e-04f, -4.05878108e-03f, -4.02949192e-02f, -7.50567913e-02f, -1.49802957e-02f, 4.15858217e-02f, 5.17623164e-02f, -2.69920602e-02f,
  8.16800296e-02f, 1.06334507e-01f, 8.20705108e-03f, -6.32851198e-02f, -5.84581820e-03f, 4.17705439e-02f, 7.10669393e-03f, 1.06036730e-01f, 6.51079714e-02f, 6.07188381e-02f,
  1.07954331e-01f, -8.42266530e-03f, 1.25527799e-01f, 2.06817955e-01f, -5.60835563e-02f, -4.31029975e-01f, -1.01177834e-01f, -1.59558535e-01f, -2.44736165e-01f, -1.64862216e-01f,
  9.73922312e-02f, 1.20546013e-01f, 1.91976145e-01f, -7.17764869e-02f, 2.42363185e-01f, 1.08848363e-02f, -6.98076636e-02f, -1.59709290e-01f, -1.15281269e-01f, 7.97843412e-02f,
  4.45492007e-02f, -1.81335032e-01f, 2.06803858e-01f, -1.12166658e-01f, -2.02081744e-02f, 1.30301327e-01f, 5.44107616e-01f, 1.32718846e-01f, 1.26842156e-01f, 4.04448584e-02f,
  -2.20520318e-01f, -1.10857384e-02f, -1.54978298e-02f, -5.19642942e-02f, -3.33784223e-02f, -9.59982444e-03f, 7.70559758e-02f, 1.07756078e-01f, -5.12129534e-03f, -1.25648016e-02f,
  -1.95061844e-02f, -2.73423325e-02f, -5.12572937e-02f, 2.61415634e-03f, -1.34567291e-01f, 7.20578283e-02f, 6.22508191e-02f, -3.76497023e-02f, 6.26710728e-02f, 6.49113208e-02f,
  7.81703368e-02f, -3.36327627e-02f, 6.11095764e-02f, -5.75220287e-02f, 2.50289261e-01f, -2.03462213e-01f, 3.48607749e-02f, 1.05163604e-01f, 7.48507772e-03f, 1.44797852e-02f,
  5.19715808e-02f, 2.43826658e-02f, -2.35086977e-02f, -9.17254984e-02f, -1.56529713e-02f, -6.18374981e-02f, 1.02530926e-01f, 5.77411540e-02f, 4.03067619e-02f, -4.48973589e-02f,
  -1.42838585e-03f, 3.78416572e-03f, 7.63773825e-03f, -1.05178989e-01f, -3.50357927e-02f, -1.49023337e-02f, -1.63595341e-02f, -4.98099439e-02f, -1.29318945e-02f, 7.88514838e-02f,
  5.27461693e-02f, -5.93612157e-02f, 2.27698833e-02f, 1.45764872e-01f, -7.82634616e-02f, 6.04859665e-02f, 1.02855459e-01f, -6.09402321e-02f, 9.24325585e-02f, 1.05729207e-01f,
  8.92551690e-02f, 2.82980710e-01f, -1.67631432e-02f, -7.93615282e-02f, -5.28830253e-02f, -6.40409486e-03f, -1.24422938e-01f, 4.79147136e-02f, 3.29893455e-02f, -4.68155444e-02f,
  -2.54986789e-02f, 1.38813136e-02f, -2.64315698e-02f, -7.51433596e-02f, -6.10121898e-02f, 1.76330313e-01f, 5.74946105e-02f, 1.37307733e-01f, 7.42523894e-02f, 9.54466239e-02f,
  5.85993044e-02f, -8.95201266e-02f, -9.30529907e-02f, -6.77060559e-02f, 4.22283821e-02f, 4.76766415e-02f, -6.69867769e-02f, -8.34539086e-02f, 8.27817023e-02f, -1.07816078e-01f,
  -2.77079828e-02f, -1.02860421e-01f, -3.58474821e-01f, -2.65341103e-01f, -1.35467499e-01f, -4.07256752e-01f, -2.65988827e-01f, -1.46410182e-01f, 6.38898313e-02f, -6.86697066e-02f,
  -2.04191968e-01f, 1.69988707e-01f, 2.73255080e-01f, -2.49363706e-01f, -3.11941486e-02f, 1.58081219e-01f, -4.18594480e-01f, -9.33193862e-02f, 1.19244173e-01f, -2.47523427e-01f,
  -2.33886354e-02f, -1.65577427e-01f, -2.43437111e-01f, -1.03215678e-02f, -3.52818370e-01f, -9.38178524e-02f, -9.03951004e-02f, -8.77299756e-02f, -3.13307971e-01f, -1.19113386e-01f,
  -2.02327803e-01f, -4.80814688e-02f, -6.49896488e-02f, -1.16266996e-01f, -1.75722867e-01f, 1.77821945e-02f, -2.00983629e-01f, 9.47137102e-02f, 2.32910170e-04f, 9.55158786e-04f,
  2.83106621e-02f, 3.65198031e-02f, 3.76812294e-02f, 1.28189772e-01f, 1.30926043e-01f, -8.24132934e-02f, -1.17634378e-01f, -1.35867268e-01f, -8.60547572e-02f, 1.51361246e-02f,
  -1.20287128e-01f, -4.31154706e-02f, -2.38665968e-01f, 1.13189612e-02f, -4.59758602e-02f, -5.25527149e-02f, -9.38922241e-02f, 8.65402222e-02f, -1.55793831e-01f, -6.42159358e-02f,
  -1.10855903e-02f, 1.89439692e-02f, -4.35798280e-02f, 3.11910026e-02f, 1.09340325e-01f, 2.70836311e-03f, 9.36621353e-02f, 1.43992733e-02f, 1.13117881e-03f, 4.60228361e-02f,
  5.42382011e-03f, 3.24916057e-02f, -1.53310942e-02f, -1.17541492e-01f, -5.23715168e-02f, 4.29930054e-02f, 1.64331749e-01f, -7.09309289e-03f, 1.33826369e-02f, -5.64082451e-02f,
  -1.71926301e-02f, 5.97725250e-03f, 2.93386895e-02f, -9.05285254e-02f, -5.61130829e-02f, 5.42497337e-02f, 3.51423933e-03f, 1.32053113e-02f, -6.91680387e-02f, -1.03232702e-02f,
  -1.94755211e-01f, -1.62232652e-01f, 5.71751259e-02f, -7.54559562e-02f, 1.15004785e-01f, -1.40891269e-01f, -2.86654988e-03f, -8.54822621e-02f, -2.89772637e-02f, -5.20607531e-02f,
  -1.06230192e-01f, 1.19672470e-01f, -5.72436042e-02f, 6.43718317e-02f, 3.87845002e-02f, -1.20549299e-01f, 2.44663935e-02f, 8.58152285e-02f, -4.12607305e-02f, -5.22165559e-02f,
  4.35433090e-02f, 4.48693596e-02f, 6.31115362e-02f, -5.55318668e-02f, -9.15854126e-02f, -6.17066845e-02f, -4.40318184e-03f, -7.29165897e-02f, -7.76216388e-02f, 6.56619743e-02f,
  5.01994267e-02f, 5.75061068e-02f, -3.22130442e-01f, -9.89082456e-02f, -4.43095148e-01f, -3.75769615e-01f, -9.85720530e-02f, -2.30954856e-01f, -1.52543277e-01f, 3.70337874e-01f,
  1.89523846e-01f, -8.77691507e-02f, 2.25753576e-01f, 6.96250871e-02f, -3.55076566e-02f, 3.21281075e-01f, -5.08948648e-03f, 1.37081534e-01f, -7.25421980e-02f, -5.56399859e-02f,
  -3.92071791e-02f, 2.39725679e-01f, -1.39767611e-02f, 2.48932261e-02f, -4.41933870e-02f, -1.06771089e-01f, 1.06882297e-01f, -3.00754189e-01f, -2.89546195e-02f, -1.40822262e-01f,
  -1.58187747e-02f, -9.50886235e-02f, -8.34706947e-02f, -9.61741805e-02f, -4.00875546e-02f, -4.89288867e-02f, -1.87192056e-02f, -5.20947613e-02f, 1.04040736e-02f, -3.22949365e-02f,
  1.46248499e-02f, 2.46571265e-02f, -3.50707285e-02f, 5.48634827e-02f, -1.15091987e-01f, -6.62449300e-02f, 9.11702029e-03f, -5.99632971e-02f, 1.41091555e-01f, -2.36536823e-02f,
  -9.28067118e-02f, -2.77201198e-02f, -6.48188812e-04f, 1.61920443e-01f, -1.17211841e-01f, -5.77600785e-02f, -6.36359211e-03f, -4.11360972e-02f, -7.97689855e-02f, -6.90765679e-02f,
  -5.80374226e-02f, 6.26246482e-02f, 2.87529081e-02f, 2.66840104e-02f, -8.58749896e-02f, 2.54354775e-02f, -4.55904864e-02f, -2.32041869e-02f, -1.80351958e-02f, 5.89737436e-03f,
  -7.51569634e-04f, -5.00124507e-02f, -2.69729327e-02f, 8.05534348e-02f, -1.65138897e-02f, -1.09410845e-03f, 1.49862422e-02f, -4.86313552e-02f, 1.31734461e-02f, -8.89544487e-02f,
  1.08752713e-01f, -5.97057045e-02f, 5.15354238e-02f, -5.97635284e-03f, -1.99447777e-02f, 2.43829153e-02f, 2.55095996e-02f, 2.83887307e-03f, 5.76958321e-02f, -1.09926745e-01f,
  6.91242442e-02f, -2.46084347e-01f, -4.12371941e-02f, 4.36062030e-02f, -7.34014958e-02f, -2.94155851e-02f, 5.88002242e-02f, -3.05882213e-03f, -8.55319053e-02f, -1.05660081e-01f,
  -2.67655514e-02f, -6.34552017e-02f, 1.59265511e-02f, -1.55118685e-02f, -7.97355473e-02f, 2.57065035e-02f, 9.87038687e-02f, 2.90761265e-04f, -3.36750410e-02f, -6.48878440e-02f,
  -7.95235392e-03f, 2.71658842e-02f, 1.65994570e-01f, -6.83443397e-02f, 1.16574079e-01f, 1.25067726e-01f, -6.29282668e-02f, -9.96909142e-02f, -1.62785873e-01f, -9.49573293e-02f,
  4.64903325e-01f, 2.95333683e-01f, 2.87956327e-01f, 3.75588149e-01f, -6.64027929e-02f, 1.04482286e-02f, 2.26776246e-02f, 8.52205008e-02f, 3.91725868e-01f, 1.08980775e-01f,
  -2.72429615e-01f, 2.88241386e-01f, -3.45465422e-01f, 1.79004788e-01f, -2.39177927e-01f, -1.60666406e-01f, 2.08206013e-01f, 1.03613928e-01f, 3.68438428e-03f, 8.13830942e-02f,
  1.67395175e-01f, -2.83129603e-01f, -2.34714508e-01f, -2.69205928e-01f, 1.66894898e-01f, 1.44358575e-01f, -4.03139949e-01f, -2.69139022e-01f, 9.17029940e-03f, -2.11976454e-01f,
  5.48483729e-02f, 2.08602790e-02f, 8.68071094e-02f, 6.81208372e-02f, 1.05206259e-02f, 2.71929055e-02f, 4.81793918e-02f, -1.49735227e-01f, -2.02443241e-03f, 1.89202465e-02f,
  6.97053596e-02f, -6.15768433e-02f, 5.56476787e-02f, -2.71918215e-02f, 2.36298572e-02f, -6.05772203e-03f, 2.58216262e-02f, 1.46091118e-01f, -7.42427260e-02f, -9.23602097e-03f,
  9.17096436e-02f, 1.11601576e-01f, 6.09329939e-02f, 5.70770055e-02f, 2.19432656e-02f, 1.09447883e-02f, 3.46821621e-02f, 1.32350146e-03f, 7.97308832e-02f, -2.45480556e-02f,
  8.37375522e-02f, -3.13824825e-02f, -5.65112978e-02f, -8.87147430e-03f, 5.80387330e-03f, 3.52909416e-02f, -6.70710504e-02f, -9.59664658e-02f, 1.12171017e-01f, -4.22004759e-02f,
  -3.36850584e-02f, 1.97907314e-02f, -1.30874338e-03f, 5.97667210e-02f, 8.50048736e-02f, 3.75568941e-02f, 6.32426813e-02f, 8.36199522e-02f, 1.70929164e-01f, 4.51975409e-03f,
  -1.15833111e-01f, 2.72025317e-02f, -1.03718564e-01f, -9.18238834e-02f, -2.23254636e-02f, -3.33521590e-02f, 5.89911044e-02f, 7.03405216e-02f, -6.13736846e-02f, -6.97818696e-02f,
  -1.75526440e-02f, 3.25833622e-04f, 8.99807960e-02f, 7.00171143e-02f, 9.44515981e-04f, 7.77840940e-03f, 3.49950604e-02f, 5.45895621e-02f, 2.06232723e-03f, -4.47469279e-02f,
  2.36948151e-02f, -1.96081977e-02f, 2.06151288e-02f, -5.82568068e-03f, 7.64091639e-03f, -1.06933787e-01f, 2.34433543e-02f, -1.23640653e-02f, 6.52798265e-02f, -1.30843222e-02f,
  -7.68652046e-03f, 1.40381837e-02f, 5.96058730e-04f, 5.06405793e-02f, 1.07327066e-01f, -1.06585324e-01f, 5.18761016e-02f, 4.56832089e-02f, -3.67657989e-02f, -4.95266132e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.66146570e-01f, 1.55577317e-01f, 3.26052636e-01f, 4.10037965e-01f, 1.26226991e-01f, 1.42608210e-01f, 1.60938531e-01f, 2.84964621e-01f, 2.07722649e-01f, 2.45089531e-01f,
  3.02638024e-01f, 4.15993705e-02f, 9.52286720e-02f, 2.50978380e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.72556210e-01f, -8.49004313e-02f, 1.46895822e-03f, -1.52330384e-01f, -2.30248883e-01f, -9.44473222e-02f, 9.95130241e-02f, 1.11347064e-01f, 3.34246531e-02f, 6.71067610e-02f,
  1.91442043e-01f, 2.66811311e-01f, 1.70775980e-01f, -3.08855921e-01f, 2.72822559e-01f, 1.56851023e-01f, -3.64736319e-01f, 2.18239591e-01f, 1.12570889e-01f, -1.96812227e-01f,
  3.71341288e-01f, -1.24242745e-01f, 1.18568443e-01f, -1.67207092e-01f, 2.76312679e-01f, 2.89675862e-01f, -2.14984007e-02f, -3.39366853e-01f, -3.04132730e-01f, -1.84360370e-01f,
  2.22352147e-01f, 8.96762013e-02f, 3.15806538e-01f, 1.93687201e-01f, -5.68353310e-02f, 4.33480814e-02f, -1.77034602e-01f, -9.73621607e-02f, 1.59617335e-01f, 5.12784871e-04f,
  1.48997726e-02f, 3.22215825e-01f, -6.59085661e-02f, 2.37385035e-01f, 2.15755478e-01f, -8.09735209e-02f, 9.29922611e-02f, -1.82177365e-01f, -3.11815351e-01f, 9.24209878e-02f,
  1.06820673e-01f, -3.27099115e-01f, 3.51614535e-01f, -2.23767851e-02f, -8.98904875e-02f, -3.69170792e-02f, 2.22866476e-01f, 1.56632319e-01f, -1.38017356e-01f, -2.24585354e-01f,
  -1.80987716e-01f, -1.76728249e-01f, 8.79192725e-02f, -3.08253199e-01f, -2.04522148e-01f, -2.20089540e-01f, 1.37168840e-01f, 3.11086148e-01f, -9.67235118e-02f, -2.95509428e-01f,
  -2.28924700e-03f, 3.78533406e-03f, -1.21190563e-01f, 1.15939252e-01f, 2.97706127e-01f, -1.61577240e-02f, -2.13934943e-01f, -6.20137751e-02f, -5.41366458e-01f, -2.30321154e-01f,
  -2.47945726e-01f, -2.09895521e-01f, -1.61469787e-01f, -3.75173390e-01f, -2.31384426e-01f, 1.60839796e-01f, -1.77700639e-01f, -9.59758610e-02f, -3.01822841e-01f, 4.89102185e-01f,
  -3.09804291e-01f, 1.22602083e-01f, 2.09461544e-02f, 1.89398542e-01f, 1.31324902e-01f, 1.09376073e-01f, -4.54146415e-02f, 5.50772622e-02f, -1.63438737e-01f, 9.88357961e-02f,
  -1.03298143e-01f, -1.90283790e-01f, 1.00106493e-01f, -2.45218858e-01f, -1.74903229e-01f, 1.36815682e-01f, 1.23934202e-01f, -5.22561092e-03f, 4.27678794e-01f, 2.48647019e-01f,
  -2.94978350e-01f, -7.78277367e-02f, -9.55062509e-02f, -1.88720986e-01f, -2.19024643e-01f, -1.40380964e-01f, -9.80718508e-02f, 4.71938550e-02f, -1.06229626e-01f, 1.14973793e-02f,
  -6.79079071e-02f, 3.66944760e-01f, -2.00097010e-01f, 2.71402001e-01f, 1.19396001e-02f, 1.96342483e-01f, 1.81314811e-01f, -8.93738940e-02f, 3.20159286e-01f, 4.04792100e-01f,
  6.74604671e-03f, 1.70054540e-01f, 2.99157232e-01f, 2.40067124e-01f, 8.37037526e-03f, 3.80280465e-02f, 2.52808165e-02f, -2.23813623e-01f, -2.12672919e-01f, 2.18519047e-01f,
  -2.37988770e-01f, 1.28821075e-01f, 3.31681460e-01f, -2.30138525e-01f, -8.36871266e-02f, -2.68434137e-01f, -1.66804940e-01f, -3.02475482e-01f, 1.39704049e-01f, -3.83919656e-01f,
  -1.48231447e-01f, 2.35482201e-01f, -1.84060127e-01f, 2.39482552e-01f, -2.44399920e-01f, -1.35319665e-01f, -7.27401525e-02f, -3.18509996e-01f, -1.06960021e-01f, 1.56934440e-01f,
  2.42564932e-01f, -3.93343419e-02f, -1.16986945e-01f, -2.61213034e-01f, -2.38798037e-01f, -6.61373660e-02f, -3.04367151e-02f, -9.18562990e-03f, 1.85381398e-01f, 1.81401521e-01f,
  2.43154258e-01f, -2.86125153e-01f, 3.38836908e-01f, -3.74342382e-01f, -4.51344065e-02f, -1.01423502e-01f, -4.67323005e-01f, 2.24806428e-01f, 1.95565730e-01f, -4.40819971e-02f,
  1.88380122e-01f, -2.52196372e-01f, 4.97374050e-02f, -2.58308917e-01f, -2.16924287e-02f, 1.33738536e-02f, 5.06031103e-02f, -1.07780166e-01f, -3.15840125e-01f, -3.59787047e-02f,
  1.23596258e-01f, -5.39231300e-02f, -2.53198564e-01f, 9.11960602e-02f, -2.54554115e-02f, -2.94927321e-02f, -2.67550528e-01f, 1.06227338e-01f, 3.33770186e-01f, -1.83745369e-01f,
  -2.42089301e-01f, -1.26533702e-01f, 3.02381933e-01f, 1.15757674e-01f, -4.81396377e-01f, -4.14617330e-01f, -1.88666910e-01f, 3.27603906e-01f, 3.04201335e-01f, 1.71954725e-02f,
  8.69076177e-02f, -2.39468783e-01f, -3.00978810e-01f, -4.97074872e-02f, -5.51877469e-02f, -2.08728909e-01f, -3.93099785e-02f, -5.75756421e-03f, 1.21731780e-01f, -9.67583582e-02f,
  3.26809168e-01f, 2.05816180e-01f, 9.76663902e-02f, 5.59651293e-03f, -1.64906550e-02f, -1.73148271e-02f, 4.80886847e-02f, 1.24783896e-01f, -2.53142953e-01f, -1.53383777e-01f,
  -1.73045278e-01f, 1.94259211e-01f, -1.84065536e-01f, -1.98795170e-01f, 3.37462962e-01f, 3.48877281e-01f, 1.01196067e-02f, -1.13288112e-01f, 3.42775166e-01f, 2.19385728e-01f,
  3.29319179e-01f, 1.29490584e-01f, 1.04057714e-01f, 1.73111886e-01f, 3.99216384e-01f, 2.45664895e-01f, 2.08962411e-01f, -1.69445813e-01f, 4.26264584e-01f, 2.89968699e-02f,
  2.57764578e-01f, -2.40867689e-01f, 1.59211591e-01f, -3.25558007e-01f, 1.19742799e-04f, -1.96576074e-01f, 7.54259974e-02f, 6.64413795e-02f, 1.67917058e-01f, 1.06004560e-02f,
  1.17029011e-01f, 3.43748510e-01f, 1.30996495e-01f, 3.27814102e-01f, 3.33092004e-01f, -2.17597559e-01f, -2.11205170e-01f, -5.84329963e-02f, -9.27702263e-02f, 1.60363406e-01f,
  3.27045619e-01f, 5.89837246e-02f, -1.22840509e-01f, -3.17646503e-01f, -2.90784210e-01f, -3.87914618e-03f, 6.22363836e-02f, -3.35626304e-01f, 4.95303571e-02f, 3.51732552e-01f,
  -1.39215887e-01f, 1.90230772e-01f, 1.48032838e-02f, -8.84522032e-03f, -2.45370209e-01f, -3.47294778e-01f, -2.64443576e-01f, 1.67211369e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.50336260e-01f, 4.45137978e-01f, 3.03179622e-01f, 2.35915065e-01f, 4.82833654e-01f, 2.91193783e-01f, 3.34211141e-01f, 3.94567065e-02f, 3.36088061e-01f, 1.52236059e-01f,
  -1.95906878e-01f, -9.25929919e-02f, -3.26717563e-04f, 3.47939879e-01f, 1.61780939e-01f, -3.72726709e-01f, -3.75597877e-03f, -4.51077491e-01f, -6.09614968e-01f, -2.48121947e-01f,
  2.60392815e-01f, -5.82881927e-01f, -1.85338020e-01f, 4.42094564e-01f, 1.07201636e-01f, 6.01115048e-01f, -1.77912608e-01f, -1.76752061e-01f, -1.03745824e-02f, -3.10682505e-01f,
  -2.52590954e-01f, -3.51564810e-02f, 1.96480751e-01f, -8.52244422e-02f, 1.31059930e-01f, 7.45792466e-04f, 2.15746120e-01f, 2.65372425e-01f, 3.15836281e-01f, 1.13633677e-01f,
  3.53933305e-01f, -3.70553732e-01f, 4.36028033e-01f, 4.48036104e-01f, -1.49436146e-01f, 1.91018730e-01f, 5.70540845e-01f, 5.66812396e-01f, 2.55859196e-01f, -2.03090698e-01f,
  2.37383559e-01f, -1.14524342e-01f, 7.13153481e-01f, -1.35869145e-01f, 4.61387932e-01f, -1.57277629e-01f, 1.93027005e-01f, -8.16030707e-03f, 1.45304143e-01f, -1.03839993e-01f,
  7.60281608e-02f, 6.28282428e-02f, 1.40223764e-02f, 5.10901660e-02f, -6.17806390e-02f, 1.77412316e-01f, -2.24073399e-02f, -1.37562066e-01f, 3.09400976e-01f, 4.98167455e-01f,
  3.50058414e-02f, 1.88439637e-01f, 1.27153963e-01f, -5.00009835e-01f, -4.96583313e-01f, -4.34599929e-02f, -4.50555608e-03f, 4.02492046e-01f, 1.99786231e-01f, 2.03418285e-02f,
  -2.23448649e-01f, 6.37303665e-02f, -5.40506281e-02f, 4.67300743e-01f, 3.18080157e-01f, 9.03135538e-02f, 2.91136354e-01f, 6.29439175e-01f, 1.27818763e-01f, -6.34172380e-01f,
  2.13271886e-01f, 1.53581612e-02f, 3.97085696e-02f, -2.35817209e-01f, 6.04460388e-02f, 5.53481936e-01f, 2.15564087e-01f, 1.48501381e-01f, 5.46509504e-01f, 2.18801335e-01f,
  2.84578800e-01f, 1.92466497e-01f, 5.71122766e-01f, 1.26551136e-01f, 1.42303497e-01f, -2.37335667e-01f, 1.24759249e-01f, 4.00354177e-01f, -5.82865596e-01f, 3.01041454e-01f,
  7.55193233e-02f, -7.40472153e-02f, 1.95795879e-01f, -1.92997873e-01f, 3.55627947e-02f, -3.30161721e-01f, -1.08939655e-01f, -2.50094771e-01f, -6.12209588e-02f, -1.10507961e-02f,
  -2.58638978e-01f, 4.76259500e-01f, -4.48319495e-01f, 2.19494253e-01f, 4.36049610e-01f, 5.87471664e-01f, 2.33569667e-01f, 3.64758343e-01f, 3.04164320e-01f, 1.42354012e-01f,
  3.84759545e-01f, -7.24803507e-02f, 2.21114345e-02f, 4.76815134e-01f, 3.52238789e-02f, 4.97011751e-01f, 3.09836984e-01f, -2.60100901e-01f, 3.86345349e-02f, -1.04969420e-01f,
  5.63026786e-01f, 1.14593126e-01f, 3.86460721e-01f, 3.07169139e-01f, -6.70057163e-02f, 1.75115183e-01f, 3.63038540e-01f, 5.67118406e-01f, 6.06660008e-01f, -7.66729861e-02f,
  4.78213936e-01f, -1.19271696e-01f, 2.27458000e-01f, -6.38063401e-02f, 3.43281329e-01f, -1.26857892e-01f, 4.16375436e-02f, -2.95881897e-01f, 4.23003770e-02f, 1.36222199e-01f,
  4.00119722e-01f, 2.12117150e-01f, 2.77730852e-01f, 4.92133498e-01f, 1.46145448e-01f, -1.91134349e-01f, -2.98594516e-02f, 7.76511356e-02f, 1.51548460e-01f, 5.18886268e-01f,
  -5.13283871e-02f, -7.13975579e-02f, 2.51949191e-01f, 3.59732993e-02f, -3.21384728e-01f, -2.64063478e-01f, -3.03741693e-01f, -1.59791902e-01f, 1.29025504e-01f, 2.18749538e-01f,
  -2.75402404e-02f, 4.25401419e-01f, -2.09171280e-01f, -1.98275924e-01f, 1.13542683e-01f, 3.05922389e-01f, -2.22163543e-01f, 3.82197767e-01f, 2.47102782e-01f, 3.24450016e-01f,
  4.07284826e-01f, -5.58127463e-01f, 1.18749283e-01f, 3.29495579e-01f, 3.48601550e-01f, -1.39910271e-02f, -1.71850055e-01f, 2.22194135e-01f, 7.08571374e-01f, 2.11835429e-01f,
  2.46832773e-01f, 1.01746827e-01f, 9.46366787e-02f, 4.47415747e-02f, -4.86621946e-01f, -7.60736585e-01f, -2.13504538e-01f, 1.07473157e-01f, -2.48165071e-01f, 3.92276496e-01f,
  7.25651205e-01f, -3.38751137e-01f, 8.90867785e-02f, 1.21801019e-01f, -2.84588665e-01f, 5.04167378e-01f, 3.53425264e-01f, 3.68975336e-03f, 3.25880468e-01f, 6.77230060e-02f,
  -2.30694981e-03f, 6.87092617e-02f, 3.16394836e-01f, 7.31249750e-01f, -3.05778384e-01f, 2.60672867e-01f, 3.37118953e-01f, 2.42261030e-02f, 4.57029462e-01f, 5.57922363e-01f,
  -2.00644024e-02f, 9.63972434e-02f, 1.53162718e-01f, -3.78153920e-01f, -2.08216846e-01f, -1.91603139e-01f, -2.37748563e-01f, 3.50163691e-02f, -3.51465702e-01f, -3.24287377e-02f,
  2.64513582e-01f, -1.01299085e-01f, -2.52651405e-02f, 2.31395721e-01f, -3.18160653e-01f, 3.92522275e-01f, 1.45912454e-01f, 3.47502470e-01f, -4.80466247e-01f, -2.07018390e-01f,
  4.70031202e-01f, 5.71016490e-01f, 3.64949405e-01f, 3.62464368e-01f, -4.56354134e-02f, 3.41391236e-01f, 3.74004275e-01f, 1.49653077e-01f, 1.46536663e-01f, 3.08824271e-01f,
  1.71237335e-01f, 2.22102791e-01f, -1.54942214e-01f, 2.11952269e-01f, 3.67029458e-01f, 3.65560621e-01f, -2.07973078e-01f, -4.53980356e-01f, 5.13148725e-01f, -3.47088575e-02f,
  -5.23378134e-01f, -3.60706389e-01f, -3.92784208e-01f, -1.47837341e-01f, 1.21517479e-01f, 6.03748262e-02f, -4.57812473e-02f, 2.51542866e-01f, 1.03619672e-01f, -2.69798860e-02f,
  -1.96948200e-01f, 3.72173727e-01f, -3.19204152e-01f, 3.75440747e-01f, -2.37402409e-01f, 3.30861717e-01f, 3.07527006e-01f, -2.41124228e-01f, 1.51606962e-01f, 1.26114309e-01f,
  3.58811945e-01f, 5.70408702e-02f, 2.38145381e-01f, 3.76890510e-01f, 1.92031100e-01f, 2.28313848e-01f, 3.64397228e-01f, -5.35923898e-01f, -9.81529281e-02f, 2.57586151e-01f,
  3.22984815e-01f, 4.05972898e-01f, 3.24728608e-01f, 1.49551824e-01f, 3.78565758e-01f, -3.13067377e-01f, -6.14093468e-02f, 2.97431499e-01f, 3.89879972e-01f, 2.09193468e-01f,
  5.74421823e-01f, 6.04235008e-02f, -1.81187149e-02f, 1.20720200e-01f, 3.69218320e-01f, 4.62976620e-02f, 6.87108576e-01f, 2.99357146e-01f, 1.32616684e-01f, -1.30574137e-01f,
  3.38606656e-01f, 9.48897451e-02f, 3.49809915e-01f, 1.05228171e-01f, -2.94551194e-01f, 4.27231371e-01f, 2.93048173e-01f, 2.01596349e-01f, 2.35243931e-01f, 1.57574952e-01f,
  2.01659873e-01f, -9.97836068e-02f, 8.77851099e-02f, -5.92910230e-01f, -8.21755379e-02f, 6.01800382e-01f, 4.05391157e-01f, 3.93936604e-01f, 6.74608588e-01f, 1.63789108e-01f,
  1.91044807e-02f, 2.68791050e-01f, 2.26752404e-02f, -5.67869484e-01f, 1.65640056e-01f, 1.36540294e-01f, 3.13395530e-01f, 2.69641668e-01f, 5.09137511e-01f, 3.78130049e-01f,
  5.69145083e-01f, -2.48804972e-01f, 1.92859828e-01f, 2.79960394e-01f, 4.64206874e-01f, 2.16510326e-01f, 4.62142341e-02f, 1.82230517e-01f, 5.07834256e-01f, 1.14823315e-05f,
  1.17403001e-01f, 2.94471890e-01f, 5.15708447e-01f, 3.02662581e-01f, -4.93562758e-01f, -1.55314311e-01f, 1.41439170e-01f, 2.99078763e-01f, 3.62340868e-01f, -3.14582318e-01f,
  2.87229180e-01f, -2.39965454e-01f, -1.45388529e-01f, -2.52404720e-01f, -1.33270726e-01f, -2.89916217e-01f, -1.39122367e-01f, 5.94903767e-01f, -3.50895315e-01f, -1.04063392e-01f,
  5.77128083e-02f, 3.06167483e-01f, 9.29441079e-02f, 9.50047076e-02f, 9.19916853e-02f, 2.58917570e-01f, 2.66190648e-01f, 3.20948243e-01f, 3.81012142e-01f, -2.02077538e-01f,
  3.91792923e-01f, 4.38230813e-01f, 3.14541757e-01f, -4.66628045e-01f, -1.07251190e-01f, 5.41112721e-01f, -4.26916569e-01f, 5.73926926e-01f, 2.43837744e-01f, 1.27965137e-01f,
  4.70300674e-01f, -3.03655148e-01f, -1.01660453e-01f, -3.73394787e-01f, 3.68836761e-01f, 1.25427470e-01f, 1.55711472e-01f, 4.65782344e-01f, 1.46000654e-01f, 3.89283687e-01f,
  8.10919181e-02f, -2.81360656e-01f, 4.32328224e-01f, -2.78035611e-01f, -2.59263247e-01f, 3.43044817e-01f, 3.51310313e-01f, -6.12893589e-02f, 3.23798358e-02f, 7.65277669e-02f,
  2.33267069e-01f, 4.54897970e-01f, -1.74754634e-01f, 1.50996834e-01f, 4.68133628e-01f, 3.70004147e-01f, -2.22187266e-01f, -4.74637091e-01f, 3.06233197e-01f, -6.14628382e-02f,
  -4.22139376e-01f, -4.82488066e-01f, -5.18919945e-01f, -2.05674227e-02f, 5.34274988e-02f, 4.53847080e-01f, -6.07271716e-02f, 4.91579443e-01f, 5.82924634e-02f, 1.09564640e-01f,
  -2.34848484e-01f, 2.79784679e-01f, 2.16087341e-01f, 8.52834582e-02f, -6.83261380e-02f, -6.58152625e-02f, -3.28957476e-02f, -9.83502599e-04f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.09094493e-01f, 1.10405006e-01f, 1.21339470e-01f, 4.39248115e-01f, 2.97843069e-01f, 4.32892352e-01f, 2.49200702e-01f, 2.55831867e-01f, 1.88936695e-01f, 3.63692403e-01f,
  3.71176422e-01f, 7.74987489e-02f, 8.49821121e-02f, 4.39581037e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.64719269e-02f, -7.72761405e-02f, 1.88312590e-01f, 1.60453930e-01f, 6.46432266e-02f, 4.82787751e-02f, 2.62514442e-01f, 1.66593626e-01f, 5.26038185e-02f, 2.89501697e-01f,
  3.89965236e-01f, 2.11562708e-01f, 2.92601325e-02f, 1.35222524e-01f, 9.25334692e-02f, 1.11225896e-01f, -6.77912012e-02f, -2.89438497e-02f, 3.31532478e-01f, -1.09519117e-01f,
  -3.88668835e-01f, 3.26883495e-02f, -1.07803583e-01f, 2.79342663e-02f, -8.67969915e-02f, -1.47728920e-01f, 9.45805833e-02f, -1.26102269e-01f, 1.09212011e-01f, 4.58865874e-02f,
  4.76027019e-02f, 2.47838214e-01f, 4.18917835e-02f, -1.33974791e-01f, -3.43388133e-02f, 7.61790648e-02f, 2.37833918e-03f, -2.80797239e-02f, -1.57043077e-02f, -3.54069144e-01f,
  -5.66302091e-02f, -3.20608884e-01f, -1.90576967e-02f, 7.99645558e-02f, 1.90987080e-01f, 9.67116207e-02f, -5.92753850e-02f, -3.54433358e-01f, -3.56625408e-01f, -1.98882341e-01f,
  3.05106699e-01f, -5.83012477e-02f, -4.26776782e-02f, -9.80353728e-02f, -2.16915563e-01f, 1.16110574e-02f, 7.94625133e-02f, 6.59165308e-02f, 1.92806453e-01f, -1.79534137e-01f,
  -4.80631180e-02f, -3.47428888e-01f, 3.89121771e-02f, 1.57310426e-01f, -1.45635769e-01f, -1.97807819e-01f, -1.52341157e-01f, -1.05679914e-01f, 1.89266130e-01f, -3.37884054e-02f,
  -3.02309632e-01f, -1.14546292e-01f, -6.19992353e-02f, -2.76761472e-01f, -4.03955549e-01f, -2.52986342e-01f, -2.06989005e-01f, -3.76933664e-02f, -2.73084044e-01f, 3.13319504e-01f,
  -4.55567911e-02f, 8.15010518e-02f, -2.86188871e-01f, 3.91699634e-02f, 1.78160980e-01f, -8.95934703e-04f, 2.60593947e-02f, 2.22460534e-02f, -2.16355652e-01f, 1.99407756e-01f,
  -8.58495981e-02f, 5.72823063e-02f, -4.74471860e-02f, -2.77829710e-02f, 5.04808351e-02f, 3.12250573e-02f, -1.01829402e-01f, 1.76308289e-01f, -2.88770050e-01f, 1.89580917e-01f,
  4.93786037e-02f, -9.58234742e-02f, 5.34052253e-02f, 2.05634624e-01f, 6.68737590e-02f, 2.65659034e-01f, 2.34383017e-01f, -3.07581931e-01f, -8.49206969e-02f, -2.27373820e-02f,
  3.93992513e-01f, -2.36476704e-01f, 1.90208465e-01f, 1.45256117e-01f, 1.85861006e-01f, -1.43208727e-01f, 1.88367695e-01f, -3.48732561e-01f, 2.86823273e-01f, -1.16726279e-01f,
  9.21258703e-02f, -7.83630759e-02f, -8.71140137e-02f, 4.57860380e-02f, 4.44687158e-02f, -7.15071782e-02f, -1.76271558e-01f, 1.33915603e-01f, 3.84181924e-02f, 1.31984174e-01f,
  -3.19802202e-02f, -1.02344029e-01f, -1.32470474e-01f, -2.35250905e-01f, 4.51570712e-02f, -1.43636465e-01f, 1.28758559e-02f, 1.36919871e-01f, 3.40763777e-02f, 2.56357461e-01f,
  4.04093927e-03f, 1.57916397e-01f, 4.36026454e-01f, 1.32617652e-01f, -2.28040993e-01f, -2.34587595e-01f, -1.37542218e-01f, 3.76076475e-02f, 1.31234288e-01f, 2.15727404e-01f,
  4.77588549e-02f, -5.97040616e-02f, 3.01622927e-01f, -1.24916188e-01f, -1.47687979e-02f, -2.28647754e-01f, 9.55917761e-02f, 6.89056935e-03f, -4.35029566e-01f, -1.52392909e-01f,
  -8.09785649e-02f, 4.44104075e-02f, 1.60072654e-01f, -2.02533737e-01f, -4.64278460e-02f, 1.02864884e-01f, 8.37385654e-02f, 1.20532557e-01f, 4.16028872e-02f, 1.35674596e-01f,
  1.38845369e-01f, 3.03187668e-01f, 3.06928664e-01f, 1.13808885e-01f, 2.26551697e-01f, -2.32862625e-02f, 1.15720727e-01f, -1.49330586e-01f, 5.51053397e-02f, -2.34451480e-02f,
  -2.87407972e-02f, 1.67087391e-01f, -1.87766418e-01f, 2.61289597e-01f, 1.31256297e-01f, -3.32457006e-01f, -1.73041914e-02f, -1.54902458e-01f, 4.63028029e-02f, 2.49935433e-01f,
  1.82618722e-01f, -1.30640164e-01f, -1.69576451e-01f, 5.33960201e-02f, 1.14854947e-02f, -1.89238906e-01f, -1.20990857e-01f, -1.11991949e-01f, -4.69749793e-02f, 3.35029840e-01f,
  5.37581705e-02f, 3.15034270e-01f, 1.72790438e-01f, 1.35794058e-01f, -1.42121270e-01f, -3.70407589e-02f, 1.02477841e-01f, 2.31274605e-01f, 3.46473724e-01f, -2.42038220e-01f,
  1.28180757e-02f, -1.24422848e-01f, -2.25348204e-01f, 2.81482544e-02f, -1.47271641e-02f, -7.01350272e-02f, 1.95502117e-01f, -1.47396907e-01f, -1.84481815e-01f, 8.64713117e-02f,
  1.65595978e-01f, 2.14927167e-01f, 2.86485516e-02f, -2.11313546e-01f, 1.15640640e-01f, 1.42812580e-01f, 6.32532090e-02f, 6.61887899e-02f, 5.73906787e-02f, 2.96527207e-01f,
  1.07567012e-01f, 5.99222519e-02f, 1.22667648e-01f, 2.20518187e-01f, -5.68990596e-02f, 4.28455889e-01f, 1.92540243e-01f, 7.81364515e-02f, 3.69682133e-01f, -3.91951054e-01f,
  1.00382872e-01f, 2.74516910e-01f, -1.23012327e-01f, 1.81555226e-01f, -1.55663267e-01f, 1.76990796e-02f, 5.21738790e-02f, 1.44870967e-01f, -7.83191100e-02f, 1.12947717e-01f,
  2.23039910e-01f, -4.04705293e-02f, -2.96265811e-01f, -1.23196445e-01f, -3.42124142e-02f, 3.14942420e-01f, 2.51603443e-02f, -1.19717745e-02f, -1.71772614e-02f, -4.78723720e-02f,
  -1.83448747e-01f, -1.82757135e-02f, 2.13157281e-01f, 2.22534919e-03f, 1.26295844e-02f, 7.89454356e-02f, 2.94882208e-01f, 3.12357306e-01f, 1.59121722e-01f, 2.06606388e-01f,
  1.93190545e-01f, -2.80378252e-01f, -2.61840552e-01f, -2.12358415e-01f, -8.69407728e-02f, -2.61857301e-01f, -4.62306216e-02f, 4.66728657e-02f, -9.72750187e-02f, -3.69129609e-03f,
  3.08097392e-01f, -7.16125369e-02f, 2.83361554e-01f, -2.32127398e-01f, -1.92211896e-01f, -2.88147867e-01f, 2.34660983e-01f, 1.84646755e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  9.06224400e-02f, 4.12488520e-01f, 9.50000901e-03f, 2.09788904e-02f, 1.04935557e-01f, 3.41759056e-01f, 3.71566772e-01f, 2.42014214e-01f, 8.49811509e-02f, 6.21114731e-01f,
  -1.67125035e-02f, -4.93869156e-01f, -6.30483389e-01f, -2.24626884e-02f, 1.89723149e-01f, 7.62347952e-02f, 5.75615644e-01f, 3.00631285e-01f, -8.82684663e-02f, 9.30781841e-01f,
  3.60726327e-01f, 9.74354669e-02f, 6.45102382e-01f, -4.70761478e-01f, 4.33539808e-01f, -2.79845268e-01f, -6.62557602e-01f, 3.61360490e-01f, 3.25506032e-01f, 2.81592846e-01f,
  5.62928438e-01f, -4.54746962e-01f, 1.48951709e-01f, 1.73064962e-01f, -7.27124512e-02f, 2.97305256e-01f, 2.75209621e-02f, 2.32985094e-01f, 2.12896660e-01f, -6.92729577e-02f,
  1.19701594e-01f, 3.17273885e-01f, -3.06682680e-02f, -4.71967995e-01f, -5.29141486e-01f, 2.03927666e-01f, -2.88616806e-01f, -3.14122796e-01f, 3.59297127e-01f, 4.71304446e-01f,
  5.14533579e-01f, 3.17048997e-01f, 5.61325312e-01f, -1.45404160e-01f, 6.56573176e-01f, -1.12290613e-01f, -1.47665396e-01f, 3.18386197e-01f, -3.01943481e-01f, 6.06056094e-01f,
  -5.63080935e-03f, 3.76429148e-02f, 7.00027585e-01f, 1.93733051e-01f, 4.00356203e-01f, 2.60217309e-01f, 6.03859305e-01f, 2.87257433e-01f, 1.08724730e-02f, 1.34136468e-01f,
  1.01570666e-01f, 4.79174554e-01f, 2.25958556e-01f, 4.04201388e-01f, 2.71151364e-01f, 2.84067124e-01f, 4.23288047e-01f, 4.62834060e-01f, 3.50457169e-02f, 5.66449225e-01f,
  1.18313811e-03f, 1.94402173e-01f, 5.99847734e-01f, 4.26611863e-02f, -7.07608521e-01f, 5.04679739e-01f, -2.36476079e-01f, 1.60443187e-01f, 1.21228978e-01f, -2.13615060e-01f,
  1.81499571e-01f, 1.21422797e-01f, 2.22725630e-01f, 7.36948431e-01f, 6.76377565e-02f, -1.47091737e-02f, -3.19877237e-01f, 1.69083044e-01f, 9.55818817e-02f, 3.67535561e-01f,
  6.27146959e-02f, 6.83841035e-02f, 2.56904483e-01f, 3.60714883e-01f, 2.23296762e-01f, 3.03020805e-01f, 1.91515326e-01f, -2.57396623e-02f, 2.40381494e-01f, -5.86257219e-01f,
  4.28889960e-01f, 5.58174491e-01f, 3.27643871e-01f, -4.39967453e-01f, -3.10783148e-01f, 4.70662639e-02f, -4.70228374e-01f, 3.21589619e-01f, 3.94439131e-01f, 6.21517956e-01f,
  4.70414877e-01f, -6.07095435e-02f, 4.51953411e-01f, 7.71146938e-02f, 8.87961328e-01f, 4.92537618e-01f, -3.42051059e-01f, 3.06940705e-01f, 6.10994063e-02f, 2.59021580e-01f,
  1.30498201e-01f, 2.73345202e-01f, 1.99718118e-01f, 2.47453600e-01f, 2.19124347e-01f, 3.59250128e-01f, 3.21937174e-01f, 1.75654516e-01f, 3.04837137e-01f, 2.85183012e-01f,
  2.29197413e-01f, 1.46475777e-01f, 4.82648671e-01f, -1.74216017e-01f, -1.58579633e-01f, 7.91175738e-02f, 2.39750311e-01f, -4.93745506e-01f, -2.25102380e-01f, 1.25926182e-01f,
  -2.74345040e-01f, 4.81989056e-01f, 4.06246752e-01f, 2.77904302e-01f, 6.75948501e-01f, -3.06236386e-01f, 8.60472396e-02f, 3.33400726e-01f, -3.48218083e-01f, 7.30227590e-01f,
  3.17398220e-01f, -1.47636846e-01f, 3.02134305e-01f, -1.76347330e-01f, 3.43929082e-01f, 1.12456053e-01f, -9.97561216e-02f, 2.99046189e-01f, 6.74723312e-02f, -4.34396625e-01f,
  -6.22626901e-01f, -2.13223428e-01f, -2.66618937e-01f, -2.07566231e-01f, -5.57059467e-01f, 6.24923825e-01f, 1.09505802e-01f, 2.44610772e-01f, -5.50132453e-01f, -6.19369522e-02f,
  2.44402453e-01f, 4.48950499e-01f, 5.05175814e-02f, -2.73119986e-01f, 2.62092620e-01f, 7.67058194e-01f, -3.08015674e-01f, 2.26271704e-01f, 2.03237131e-01f, 3.16597074e-01f,
  -5.71115455e-03f, -3.21871825e-02f, -1.72222972e-01f, -3.30986232e-02f, -3.14426750e-01f, -1.47525564e-01f, -1.09637052e-01f, -1.68456197e-01f, 7.68140778e-02f, -1.69720426e-01f,
  -2.07457528e-01f, -2.83945590e-01f, 3.38525958e-02f, 1.72374412e-01f, -1.61509141e-01f, -2.42008805e-01f, 6.43763766e-02f, -1.65700927e-01f, -1.87801525e-01f, 2.41919048e-02f,
  -1.78754330e-01f, 3.24879289e-02f, 2.24304110e-01f, 5.02041765e-02f, -1.30490467e-01f, -1.75441027e-01f, -1.90137461e-01f, -5.07079661e-02f, -9.62269399e-03f, -1.20055944e-01f,
  -1.04995169e-01f, -3.37909251e-01f, -1.31231561e-01f, 1.38276801e-01f, 1.86211988e-01f, -1.27671100e-02f, 2.05817297e-01f, 1.67419136e-01f, 6.46016300e-02f, -8.49063620e-02f,
  1.44246921e-01f, -2.59061724e-01f, 1.22242853e-01f, -4.45941716e-01f, -6.91468567e-02f, 6.92008436e-02f, 4.85128164e-01f, -4.04885076e-02f, -1.72013640e-01f, -1.95747957e-01f,
  -7.32414842e-01f, -4.45658565e-01f, 9.23506245e-02f, -5.03108025e-01f, 2.70870984e-01f, 1.14896178e-01f, -7.42897242e-02f, 6.11274719e-01f, 4.43737447e-01f, 4.38012838e-01f,
  6.80341840e-01f, 1.59678116e-01f, 3.34336370e-01f, -2.79453456e-01f, -3.59446883e-01f, 6.79511964e-01f, 4.81067359e-01f, 2.84670621e-01f, 5.29959202e-02f, 2.22029373e-01f,
  1.25153884e-01f, 3.06212693e-01f, 2.10652471e-01f, -1.67983398e-01f, -1.23781122e-01f, -2.70246528e-02f, 2.33344287e-01f, 1.13432772e-01f, 5.81628919e-01f, 6.11285508e-01f,
  -4.63798791e-01f, -9.29893136e-01f, -4.54086691e-01f, 4.18452829e-01f, 8.06338847e-01f, 2.33031020e-01f, 1.42358214e-01f, 5.05967438e-01f, 1.77744880e-01f, 3.09077710e-01f,
  -5.46721458e-01f, 2.31345330e-04f, 4.03572083e-01f, 2.80115128e-01f, -3.69419962e-01f, -7.68098515e-03f, 3.48497272e-01f, 2.17701837e-01f, -9.30002853e-02f, -1.32954478e-01f,
  7.22149089e-02f, -8.88343453e-02f, 1.16683412e-02f, -2.56526828e-01f, 2.15160102e-01f, -1.61167875e-01f, 1.15927160e-01f, -4.94937271e-01f, -3.52551132e-01f, 1.82665676e-01f,
  2.51008570e-01f, -7.42838085e-02f, -7.89118052e-01f, 6.01620555e-01f, -3.43476087e-01f, -5.32112658e-01f, -5.23357764e-02f, 1.69148132e-01f, 1.58430766e-02f, 6.13959074e-01f,
  -4.63492602e-01f, 1.07550770e-01f, 5.80021441e-02f, 5.59714973e-01f, -4.09730189e-02f, 4.16588306e-01f, 2.87132025e-01f, 1.28974497e-01f, 5.21089196e-01f, -2.89189458e-01f,
  2.50791609e-01f, -1.57315060e-01f, 1.74871728e-01f, 2.62702048e-01f, 2.06470579e-01f, 8.50417987e-02f, 3.73456106e-02f, 1.81204990e-01f, 1.58853754e-02f, 3.45506072e-02f,
  -1.66754693e-01f, -5.26719987e-01f, -1.06523842e-01f, 5.14293909e-01f, -4.64335948e-01f, -2.84508795e-01f, -4.50001866e-01f, 6.19198680e-01f, 4.81960922e-01f, -2.43357405e-01f,
  8.41935873e-01f, -9.84781757e-02f, 3.81409883e-01f, -1.66278988e-01f, 2.94576168e-01f, 3.71389478e-01f, -3.51075269e-02f, 1.71234474e-01f, -3.29521656e-01f, -3.65627587e-01f,
  4.61972296e-01f, 4.50699091e-01f, 2.98032880e-01f, 3.47355068e-01f, 2.88210660e-01f, 2.62685180e-01f, -6.32583871e-02f, 2.77509868e-01f, 2.91117728e-01f, -2.76721805e-01f,
  6.50881007e-02f, -5.91309667e-01f, -1.42084360e-01f, 2.73383290e-01f, 6.56844437e-01f, 3.02737743e-01f, -5.12923717e-01f, -3.04054707e-01f, -4.03092682e-01f, -1.55551024e-02f,
  2.87683338e-01f, -1.84798256e-01f, -4.30153638e-01f, 5.59462845e-01f, -2.50743598e-01f, 6.29556000e-01f, -4.37892884e-01f, 3.37013632e-01f, 5.17805219e-01f, 1.52466759e-01f,
  1.52071267e-01f, 3.46576869e-01f, 2.08143577e-01f, 4.86955404e-01f, -3.62991542e-01f, 5.51116802e-02f, -2.60283232e-01f, 1.63324147e-01f, 3.47555488e-01f, 1.18191294e-01f,
  -5.15746027e-02f, -9.92047638e-02f, 1.94051594e-01f, -1.35729238e-01f, -4.07087952e-01f, 1.26646981e-01f, 3.59024890e-02f, -7.74668992e-01f, 6.64106965e-01f, -6.30687535e-01f,
  1.81045696e-01f, -2.40981072e-01f, -5.94738722e-01f, 7.30355531e-02f, 3.50278080e-01f, -7.29890287e-01f, 5.69891036e-01f, 2.25182906e-01f, -1.10260271e-01f, 2.54452378e-01f,
  6.62716687e-01f, 4.90416467e-01f, 3.49780023e-01f, -3.54179412e-01f, -5.14843285e-01f, 4.22282249e-01f, 5.04098177e-01f, 1.54929891e-01f, 4.28490281e-01f, 1.74675494e-01f,
  1.02424510e-01f, 2.79325485e-01f, 2.54707076e-02f, 2.42003668e-02f, -1.15719944e-01f, 2.64532547e-02f, -1.29939631e-01f, 5.88955805e-02f, 2.09037423e-01f, 8.16534042e-01f,
  -3.96629572e-01f, 2.52588034e-01f, -4.03970957e-01f, 5.35898089e-01f, 5.93402863e-01f, 6.40310794e-02f, 3.49465638e-01f, 5.69963038e-01f, -1.94317684e-01f, -7.31157064e-02f,
  6.28356695e-01f, 1.81514978e-01f, -1.79300949e-01f, -1.15372695e-01f, -7.03375787e-02f, 5.94386518e-01f, 2.54154831e-01f, -2.16470987e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.54651695e-01f, 1.58305928e-01f, 3.54133129e-01f, 2.56317347e-01f, 2.74819195e-01f, -1.03604838e-01f, -2.00410932e-01f, 2.34795436e-01f, 3.22595417e-01f, -1.10720061e-01f,
  -1.67445950e-02f, 1.00937746e-01f, 1.44752160e-01f, 6.47801682e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -1.95095584e-01f, 1.81104779e-01f, -1.20709985e-01f, 4.42947075e-02f, -8.13459679e-02f, -3.19074810e-01f, -6.34661922e-03f, 1.39339507e-01f, 7.33876303e-02f, 3.38194281e-01f,
  -4.08243239e-01f, -3.72467875e-01f, 1.09353662e-01f, 4.52222675e-01f, 3.13860565e-01f, 3.86930525e-01f, 4.02938306e-01f, 4.17740405e-01f, -3.33510518e-01f, -5.56992531e-01f,
  2.81528383e-01f, 4.75843579e-01f, 3.44909847e-01f, -4.75769609e-01f, 2.27196991e-01f, 4.28652540e-02f, -5.94590366e-01f, -3.31380904e-01f, -5.48463106e-01f, -1.11642145e-01f,
  1.35453254e-01f, -4.37664300e-01f, 2.44584382e-01f, 1.49540603e-01f, 2.08121240e-01f, -4.52201784e-01f, -1.44197792e-01f, 3.32928300e-01f, 2.30799228e-01f, 2.05788851e-01f,
  1.02295965e-01f, -3.09999675e-01f, -3.97334605e-01f, -5.33883274e-01f, 2.25389346e-01f, 4.67519969e-01f, -2.01578498e-01f, 4.41559970e-01f, -3.92549843e-01f, -4.23749119e-01f,
  3.87279898e-01f, 1.66496009e-01f, -6.08479977e-01f, 4.05498207e-01f, -2.92760760e-01f, -4.00898516e-01f, -6.39129952e-02f, -1.85615513e-02f, -7.52718031e-01f, -4.03081626e-01f,
  -4.06400263e-01f, -4.72491682e-01f, 3.02961051e-01f, -5.67238569e-01f, -3.56181115e-02f, -5.25756925e-02f, -6.68970868e-02f, -3.40438634e-01f, 1.14868551e-01f, -4.20195848e-01f,
  -9.97707527e-03f, -2.77479023e-01f, -2.58532912e-01f, -6.52062297e-02f, -2.29205452e-02f, 4.23413545e-01f, -4.20122221e-02f, -4.20337886e-01f, 2.80384161e-02f, -5.32264113e-01f,
  5.55579245e-01f, -4.65335213e-02f, 3.06005955e-01f, 3.58936667e-01f, -3.58711630e-01f, -4.58725154e-01f, -3.57396334e-01f, 2.13002600e-02f, -1.60354242e-01f, -5.52719712e-01f,
  1.06612004e-01f, -7.64200389e-01f, 1.06237300e-01f, -4.48332429e-01f, 4.45865065e-01f, -6.22623384e-01f, 2.08979547e-01f, -4.73259896e-01f, 3.87209833e-01f, -2.55023926e-01f,
  2.41668582e-01f, 4.50725973e-01f, -3.99964601e-01f, -3.10352921e-01f, -1.61478803e-01f, 3.99500668e-01f, 3.26081395e-01f, 3.79237756e-02f, -6.29700959e-01f, -4.09111708e-01f,
  -3.20358016e-02f, -2.77659565e-01f, -1.76707402e-01f, 3.91973525e-01f, -3.07699710e-01f, -6.91576958e-01f, -3.67475063e-01f, -2.31323428e-02f, 2.79998928e-01f, -4.26087648e-01f,
  -2.98208117e-01f, 2.21361697e-01f, 8.11482370e-02f, 1.18857481e-01f, -4.37757939e-01f, 3.72672081e-01f, 1.57294959e-01f, -5.78896582e-01f, -2.36134753e-01f, 4.68731001e-02f,
  -1.83224916e-01f, 1.77949131e-01f, 2.57375240e-01f, 2.23906830e-01f, 3.47665638e-01f, -1.67105362e-01f, 1.05360383e-02f, 2.06005052e-01f, 3.20944160e-01f, -3.91044378e-01f,
  1.83982313e-01f, -7.38571286e-02f, 2.83455729e-01f, -5.88762522e-01f, 2.51236826e-01f, 3.34071100e-01f, -6.83822095e-01f, -8.97256210e-02f, 4.19528842e-01f, -1.52047113e-01f,
  4.11147088e-01f, -6.34404063e-01f, 8.62878561e-02f, 1.70291469e-01f, 2.97870666e-01f, -5.58093011e-01f, 2.99081028e-01f, 1.51064768e-01f, -5.02347767e-01f, 3.12805921e-01f,
  1.63579941e-01f, -2.91578650e-01f, -3.47973034e-02f, 2.35160798e-01f, 2.52577603e-01f, -5.97734451e-02f, -2.42477134e-01f, 2.73934573e-01f, 6.34910688e-02f, 8.20800103e-03f,
  2.73258593e-02f, -2.12624282e-01f, 3.61470394e-02f, 5.54846585e-01f, 2.55763382e-01f, 4.05715793e-01f, -1.51889008e-02f, -3.45174253e-01f, 3.84302199e-01f, -1.43290371e-01f,
  3.23205799e-01f, 2.04336315e-01f, 1.67047814e-01f, 4.83276069e-01f, 6.74381554e-02f, -5.34830689e-01f, -7.68552303e-01f, -6.67745620e-02f, -3.37096184e-01f, -3.13019514e-01f,
  -6.44631028e-01f, 3.51794660e-01f, 6.35903627e-02f, 4.35844548e-02f, 2.31783658e-01f, -7.91969597e-02f, -2.21654270e-02f, 3.38986278e-01f, 1.97647482e-01f, 2.90495336e-01f,
  3.79894435e-01f, -3.64324510e-01f, -3.94648045e-01f, -6.28259555e-02f, 3.56866747e-01f, -4.44771796e-01f, -2.17589829e-02f, 3.51210758e-02f, -9.83561128e-02f, -3.12680244e-01f,
  3.76122057e-01f, 4.18841034e-01f, -2.68746436e-01f, -8.15234780e-01f, -3.76457423e-01f, -2.76257634e-01f, 9.57717150e-02f, -5.45511425e-01f, 9.04396325e-02f, -1.55620709e-01f,
  3.25101554e-01f, -6.43514931e-01f, -7.06028640e-01f, 1.10771626e-01f, 1.33079052e-01f, 8.21435973e-02f, -5.06761745e-02f, -2.57303685e-01f, -1.68660466e-04f, -8.94538388e-02f,
  3.07253361e-01f, -7.64271244e-03f, -2.09918413e-02f, -3.12442094e-01f, -1.30365774e-01f, 4.82568800e-01f, -9.39060375e-03f, 1.87272713e-01f, 2.78751925e-02f, 1.46906957e-01f,
  -4.27697659e-01f, -4.55391467e-01f, -5.32665491e-01f, -4.68094617e-01f, 1.27457649e-01f, 5.04575856e-02f, -1.79135278e-01f, 4.16025996e-01f, 1.45164236e-01f, 1.14207126e-01f,
  -2.68987119e-01f, 5.02483130e-01f, -6.09313786e-01f, 2.06831500e-01f, -3.37275952e-01f, 1.88829601e-01f, -9.11079869e-02f, 1.18439920e-01f, -3.84115964e-01f, 2.72901058e-01f,
  -2.60090739e-01f, -3.89955580e-01f, 1.09229937e-01f, -2.77409656e-03f, -2.69402117e-01f, -1.72798365e-01f, -1.95719585e-01f, 1.74674883e-01f, 1.08345397e-01f, -2.67134726e-01f,
  -1.18233822e-02f, -1.66848287e-01f, -3.73087734e-01f, -1.83891520e-01f, 7.16422722e-02f, 2.80815870e-01f, -4.09987301e-01f, -2.15791225e-01f, -3.45427990e-01f, 4.71753120e-01f,
  1.20276242e-01f, -4.51398827e-02f, -7.87994027e-01f, 3.92788500e-01f, 1.66433275e-01f, -2.20598355e-01f, -1.48277521e-01f, -2.91803777e-01f, 2.76692957e-02f, -1.36287943e-01f,
  -9.80725884e-02f, -6.43531531e-02f, -1.23950168e-01f, 3.51101570e-02f, 1.08037308e-01f, 5.36165163e-02f, 1.74159668e-02f, 4.72531766e-01f, -1.19932353e-01f, -2.11077929e-01f,
  -4.91898179e-01f, -1.85771391e-01f, 1.61503889e-02f, 1.55177414e-01f, 1.60038903e-01f, -6.76690340e-02f, 6.24832846e-02f, 1.72146022e-01f, 4.19395566e-01f, -1.41370073e-01f,
  -3.76997679e-01f, -2.74383128e-01f, 1.47883981e-01f, -7.41602778e-01f, 4.16590124e-01f, 2.91778386e-01f, -3.23184222e-01f, 3.39806765e-01f, -4.17419463e-01f, 1.38502195e-02f,
  7.96671063e-02f, 1.99393436e-01f, -9.33967829e-02f, -1.12695480e-02f, -3.73876363e-01f, -4.49926108e-01f, -2.04323947e-01f, -3.16614844e-02f, 2.29886174e-01f, -1.00064486e-01f,
  3.84650707e-01f, 4.53150749e-01f, 2.11050987e-01f, -2.37382874e-01f, -9.49174762e-02f, -2.04211935e-01f, 2.66734481e-01f, -2.67238230e-01f, -7.46389449e-01f, 1.87307835e-01f,
  -4.88829792e-01f, 9.41089019e-02f, 6.45984709e-02f, 1.32245451e-01f, -6.81366473e-02f, 6.32834211e-02f, -1.47948951e-01f, -4.86926436e-01f, 3.76534551e-01f, 1.69458371e-02f,
  2.87417203e-01f, -4.81383055e-01f, -1.05128020e-01f, 1.67414218e-01f, 1.21245503e-01f, 7.92938545e-02f, 2.11212322e-01f, 4.54750024e-02f, -2.93051392e-01f, 7.08874613e-02f,
  5.73501661e-02f, -4.24216002e-01f, 3.10704410e-01f, 3.08513939e-01f, -2.96418875e-01f, 9.03842151e-02f, -2.86751419e-01f, -3.89562935e-01f, 1.19772844e-01f, 4.13483322e-01f,
  -3.32772791e-01f, -8.91333595e-02f, -2.17066213e-01f, -6.86646938e-01f, -1.28530666e-01f, 2.69162148e-01f, -6.07946888e-02f, 1.76455468e-01f, 1.10290252e-01f, 2.16974065e-01f,
  5.15883565e-01f, -3.48202251e-02f, -5.24099767e-01f, 4.58688021e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  8.01755339e-02f, -4.69186194e-02f, -7.10208714e-02f, -8.09208602e-02f, -2.90795881e-03f, 1.53062612e-01f, 3.49296890e-02f, 1.09835103e-01f, -1.38640672e-01f, 4.29942124e-02f,
  -1.33122608e-01f, -1.45645738e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    