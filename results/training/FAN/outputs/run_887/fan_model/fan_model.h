/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.42506769e-02f, -1.64461173e-02f, -1.30804241e-01f, -7.22223818e-02f, 4.32095006e-02f, 9.65447202e-02f, 9.69969705e-02f, 3.88994366e-02f, -3.36313881e-02f, 2.20323224e-02f,
  -1.29291058e-01f, -1.45030081e-01f, -7.17473030e-02f, 2.11661551e-02f, 4.71307989e-03f, 6.28818274e-02f, 6.62228512e-03f, -8.10857937e-02f, 1.39664486e-01f, 1.35784205e-02f,
  2.59480402e-02f, -7.91452155e-02f, -6.88510686e-02f, 5.05501553e-02f, -4.17117961e-02f, -1.16765402e-01f, -5.23878522e-02f, -1.48004502e-01f, -1.66348547e-01f, -2.64370024e-01f,
  -2.09535077e-01f, -4.98989150e-02f, 7.56609514e-02f, -9.78213176e-02f, -4.96324711e-02f, -6.89882739e-03f, -5.28339623e-03f, -1.08921334e-01f, 2.52171308e-02f, -4.66712862e-02f,
  -9.68864709e-02f, -4.24680598e-02f, -7.44386613e-02f, -3.95785756e-02f, -7.99777210e-02f, -5.12251034e-02f, -2.66969781e-02f, -5.57564609e-02f, -1.15668006e-01f, 6.17650561e-02f,
  -4.53613289e-02f, -4.23434898e-02f, -9.10353363e-02f, 3.31774317e-02f, -5.04458174e-02f, -9.77961197e-02f, 1.00521659e-02f, -1.45362735e-01f, -7.23666623e-02f, 3.86850573e-02f,
  3.01555987e-03f, -4.77115065e-02f, 3.29627059e-02f, -4.13058847e-02f, 6.84486255e-02f, 4.83757481e-02f, 3.62163037e-03f, -3.43654975e-02f, 4.67406213e-02f, -3.99610549e-02f,
  1.01015031e-01f, -2.89180735e-03f, 5.98189719e-02f, -3.16226296e-02f, -2.39505749e-02f, -1.82368439e-02f, 7.62861148e-02f, -4.30456251e-02f, -2.24419087e-02f, -4.86236699e-02f,
  -1.16215959e-01f, 1.66812409e-02f, -8.63776803e-02f, -4.08777110e-02f, -2.90308762e-02f, -1.12591229e-01f, 3.26129235e-03f, 3.36033478e-02f, 1.10036358e-01f, 2.18098667e-02f,
  9.07207876e-02f, -1.33778244e-01f, -6.95182234e-02f, 6.07614778e-02f, 1.10286037e-02f, -7.95880184e-02f, -7.38002062e-02f, 6.69985339e-02f, -5.38269915e-02f, -5.08523621e-02f,
  -2.31527481e-02f, 1.47425998e-02f, 7.23183230e-02f, -6.19773660e-03f, 1.36961684e-01f, 2.45112628e-02f, 7.78733045e-02f, 4.22853269e-02f, 3.33846137e-02f, -1.40147032e-02f,
  4.19529639e-02f, 5.25304973e-02f, 6.78488463e-02f, 1.07479610e-01f, -1.89878773e-02f, 1.09710954e-01f, 1.48880109e-01f, 8.84784535e-02f, 1.34648085e-01f, 2.00266451e-01f,
  5.30543923e-02f, -1.95181578e-01f, -1.79192677e-01f, 1.31696060e-01f, -7.23418817e-02f, -1.05911851e-01f, -4.57610816e-01f, -3.05267591e-02f, 9.28504542e-02f, -2.30787948e-01f,
  2.82815825e-02f, 1.27759784e-01f, 5.72627373e-02f, 3.31033804e-02f, -1.05572835e-01f, -2.92590886e-01f, -2.18826830e-01f, 9.22471806e-02f, 3.89536992e-02f, 1.59693249e-02f,
  -1.10307455e-01f, 1.02323696e-01f, 1.92075983e-01f, 1.64677218e-01f, -3.19099263e-03f, 7.39487335e-02f, -1.85516067e-02f, 5.60640246e-02f, -6.73829094e-02f, -1.73178703e-01f,
  -3.54994297e-01f, -1.24165483e-01f, 1.37270764e-02f, 8.88469815e-03f, 1.59439426e-02f, -5.26440106e-02f, -8.59300569e-02f, 8.59313831e-02f, -1.00968163e-02f, 2.60846764e-02f,
  -3.96198630e-02f, -1.39018772e-02f, 1.65606245e-01f, -4.20513079e-02f, -7.66550191e-03f, -7.68372566e-02f, 9.52661112e-02f, -2.83663478e-02f, 1.53021235e-02f, -5.81550188e-02f,
  2.69918684e-02f, -1.17095530e-01f, 4.09516087e-03f, 3.73238288e-02f, 6.70242533e-02f, 1.01351582e-01f, -2.09819730e-02f, 1.71019379e-02f, 7.73732271e-03f, -9.25462767e-02f,
  -2.61347722e-02f, 4.14302163e-02f, -2.89272470e-03f, 2.70497818e-02f, -1.31678930e-03f, -4.17298591e-03f, 7.82877486e-03f, -2.51590796e-02f, 7.17263445e-02f, 4.63109091e-02f,
  -2.77974177e-02f, -3.91771831e-02f, -2.56892573e-02f, -4.90234829e-02f, -3.89089575e-04f, 4.02378328e-02f, -5.84980920e-02f, 3.73313539e-02f, -2.83821207e-02f, 3.14973295e-02f,
  5.97012267e-02f, 1.55597338e-02f, 3.34794782e-02f, 5.10045774e-02f, -3.86279374e-02f, -4.62976284e-02f, -4.26407680e-02f, 3.96232158e-02f, 5.12585603e-02f, -7.82155059e-03f,
  2.21169725e-01f, 1.15593344e-01f, -1.77652061e-01f, 6.15830533e-02f, 4.94943857e-02f, 6.57002348e-03f, -3.22475694e-02f, 4.94212285e-02f, 4.14381102e-02f, -9.26150903e-02f,
  2.00092029e-02f, 6.52331039e-02f, -2.01906469e-02f, 1.96172651e-02f, -3.90211418e-02f, 2.75502820e-02f, -5.36344387e-02f, 5.77934906e-02f, -4.12967149e-03f, 3.02942190e-02f,
  1.32606085e-02f, 7.45911198e-03f, -1.67198130e-03f, -5.56689650e-02f, 4.48924787e-02f, -2.30706669e-02f, -1.75570026e-02f, -9.97929461e-03f, 2.67334655e-02f, -2.00794294e-01f,
  -6.21098697e-01f, 1.34878427e-01f, -2.02785850e-01f, -1.64350495e-01f, 4.39807437e-02f, 1.87889338e-02f, 1.77998915e-01f, 4.73487042e-02f, 8.05967860e-03f, 4.07612026e-02f,
  1.30249590e-01f, -1.04901962e-01f, -1.08642787e-01f, -1.37628131e-02f, -1.65874869e-01f, -5.88225666e-03f, -1.45313693e-02f, -2.63297588e-01f, -3.08846980e-01f, 8.37217569e-02f,
  8.28406289e-02f, -4.87459376e-02f, -2.72265106e-01f, -9.01849046e-02f, 2.10831866e-01f, 7.71806315e-02f, 4.57281843e-02f, -1.00553147e-01f, 5.20892516e-02f, 1.31725380e-02f,
  -4.93486710e-02f, -3.89731787e-02f, 3.35133709e-02f, -1.74409095e-02f, 1.77083779e-02f, -6.33098483e-02f, -2.75796670e-02f, -4.19620387e-02f, 9.80147645e-02f, 4.41523343e-02f,
  1.92365590e-02f, -3.81939858e-02f, 2.03116387e-02f, 6.13613911e-02f, -1.14126049e-01f, -5.71165346e-02f, 4.74269083e-03f, -1.38378128e-01f, -4.97597344e-02f, 1.12602107e-01f,
  1.30161181e-01f, 1.46318106e-02f, -1.17545471e-01f, 6.33502305e-02f, 1.20129706e-02f, -1.03129201e-01f, 4.07867655e-02f, -6.26151934e-02f, -1.12947278e-01f, 1.67581905e-03f,
  4.08082455e-03f, -3.93812098e-02f, 1.13244474e-01f, -5.71726775e-03f, 2.06596088e-02f, -1.35699101e-02f, 3.52437794e-02f, 5.54639958e-02f, -3.69105767e-03f, -4.24529873e-02f,
  1.51147563e-02f, 2.97844619e-03f, 5.17258532e-02f, 3.20262415e-03f, -4.45905700e-02f, 5.79602532e-02f, -2.92532407e-02f, -6.94221212e-03f, -4.52640466e-02f, -2.66549625e-02f,
  -1.19825751e-02f, -5.19814901e-02f, 6.08447865e-02f, 4.61910032e-02f, 1.36453137e-02f, -5.22342883e-02f, -5.99132366e-02f, 4.74756770e-03f, 2.17252579e-02f, 1.84873939e-02f,
  -1.03008030e-02f, -2.46575341e-01f, -4.15215120e-02f, -1.20483581e-02f, 3.62342037e-02f, 7.55240619e-02f, 7.10549438e-03f, 4.38625328e-02f, 2.18936112e-02f, 3.18369791e-02f,
  1.59757454e-02f, 6.21255934e-02f, -6.31558597e-02f, -2.66859271e-02f, 3.23961042e-02f, 5.01292981e-02f, 6.67671710e-02f, -2.21677907e-02f, 1.20413586e-01f, 5.46083525e-02f,
  -4.80590612e-02f, 1.05370721e-02f, -2.07851529e-02f, 9.38481987e-02f, 4.87224311e-02f, -7.70331025e-02f, 1.17226839e-01f, 1.05521500e-01f, -6.64551929e-02f, 1.45436212e-01f,
  3.39408129e-01f, -3.33116055e-01f, -3.20044905e-01f, -1.51204243e-02f, -6.45423215e-03f, 8.45681503e-02f, -1.38207814e-02f, 8.63700733e-02f, 9.46467519e-02f, -1.72576066e-02f,
  -2.24678516e-02f, 1.03012942e-01f, 4.91784550e-02f, -6.66148216e-02f, 3.19115855e-02f, -1.67744175e-01f, -1.73944041e-01f, 8.38692933e-02f, 1.85365543e-01f, 1.62706122e-01f,
  -4.33865413e-02f, -2.63621621e-02f, 1.16559260e-01f, 5.87238967e-02f, -1.53079763e-01f, 8.62692744e-02f, -8.11086968e-02f, -5.67173958e-02f, -6.31155670e-02f, -3.46215308e-01f,
  -2.35724136e-01f, -1.46039193e-02f, 1.10436276e-01f, 5.12864143e-02f, -1.60554927e-02f, 8.87235701e-02f, -2.31333859e-02f, -6.36305436e-02f, -4.54242527e-02f, -6.71448410e-02f,
  -5.29046319e-02f, -1.39942276e-03f, -4.56973761e-02f, -2.25268546e-02f, 1.72555111e-02f, 3.62907611e-02f, -1.41973451e-01f, 4.42848355e-02f, 2.76961289e-02f, -6.62180856e-02f,
  -2.12243468e-01f, 2.66577471e-02f, 9.28839445e-02f, -1.29612973e-02f, -8.16318542e-02f, 9.13845822e-02f, -6.04383722e-02f, 4.77018245e-02f, 9.82926562e-02f, -1.04014039e-01f,
  2.62152944e-02f, -1.45461094e-02f, 1.62388533e-02f, -3.26835662e-02f, 7.55780116e-02f, -6.86027482e-02f, -6.04761243e-02f, -1.32575640e-02f, 5.45769334e-02f, -2.30602883e-02f,
  -4.26624417e-02f, -1.19273616e-02f, -6.48449957e-02f, 4.74893637e-02f, -3.91201526e-02f, 1.32412063e-02f, -1.72300301e-02f, 1.95800979e-02f, -6.20766580e-02f, 1.93469096e-02f,
  2.61242371e-02f, 8.49490538e-02f, -3.57638784e-02f, -6.35674000e-02f, -7.99262617e-03f, -6.85670367e-03f, 4.35127877e-02f, 6.73561841e-02f, -6.02517910e-02f, 1.56369265e-02f,
  2.19096959e-01f, -3.80244218e-02f, -2.06451882e-02f, 9.07436162e-02f, 3.48410830e-02f, 1.64043289e-02f, -2.36812681e-02f, 1.03087336e-01f, -2.08991114e-02f, -1.08668292e-02f,
  3.88689712e-02f, 5.87179617e-04f, -6.18963540e-02f, -7.17453472e-03f, 3.50576863e-02f, 3.90792685e-03f, 6.44482821e-02f, -1.37662450e-02f, 4.87344675e-02f, -9.65048820e-02f,
  3.55844684e-02f, 1.13358878e-01f, 2.60196596e-01f, -3.32097006e-05f, 1.03251807e-01f, 1.92695767e-01f, 3.61179560e-02f, 1.34414732e-01f, 2.30166167e-01f, 1.95928395e-01f,
  -1.76836848e-02f, -4.20665383e-01f, 7.54346102e-02f, -1.67090688e-02f, -1.45058692e-01f, -7.21715912e-02f, -3.16240281e-01f, -5.09207621e-02f, 3.52872871e-02f, -1.15138747e-01f,
  -7.17892349e-02f, 1.67390719e-01f, 2.15670928e-01f, 2.41489455e-01f, 1.09331168e-01f, -1.24038972e-01f, -9.31560695e-02f, 1.49013594e-01f, 2.40135223e-01f, 8.62238780e-02f,
  -9.69772562e-02f, -1.40203983e-01f, 5.24432361e-02f, 1.27873197e-01f, -2.62254149e-01f, 3.09349727e-02f, -5.87017350e-02f, -1.23413496e-01f, -1.70916513e-01f, -2.95196801e-01f,
  1.53619498e-01f, -2.07249746e-01f, 1.75038323e-01f, -7.24014789e-02f, -1.23430965e-02f, 8.39853659e-02f, 7.64114037e-02f, 7.41113499e-02f, 5.17442711e-02f, 7.20101297e-02f,
  -1.21214204e-01f, -5.67701086e-02f, -6.62713796e-02f, -3.48578691e-02f, -2.41666604e-02f, 1.36880964e-01f, 4.54272404e-02f, 1.49476781e-01f, 2.01906189e-01f, 1.30752653e-01f,
  -1.11776009e-01f, -2.13078290e-01f, -2.85841990e-02f, 1.32673443e-03f, 7.67043233e-02f, 6.70873299e-02f, -2.92160790e-02f, -4.13445160e-02f, 1.74710080e-01f, -3.17001739e-03f,
  2.82742605e-02f, -6.65281042e-02f, -1.59566291e-02f, 1.43473968e-02f, -6.74671680e-02f, 7.78657869e-02f, -6.92878962e-02f, -7.60742351e-02f, 4.34361957e-02f, -3.21767367e-02f,
  9.26116705e-02f, 4.92445305e-02f, 8.99954736e-02f, 2.39346735e-02f, -1.20236361e-02f, -1.40127959e-02f, -4.22881953e-02f, 6.84998697e-03f, 4.14514728e-02f, 1.24356523e-02f,
  -2.98667625e-02f, -1.77471433e-02f, 3.26797515e-02f, 3.80775705e-02f, -3.96348275e-02f, 5.32603562e-02f, -2.44001132e-02f, 4.27827239e-02f, 5.16886450e-02f, -6.87426850e-02f,
  2.06583112e-01f, 1.16368234e-01f, 2.46123951e-02f, 2.96404790e-02f, -1.54554518e-02f, 3.08481511e-02f, -2.88197696e-02f, 1.65271398e-03f, -3.82472500e-02f, 1.77882742e-02f,
  -2.99344175e-02f, 7.41808340e-02f, 1.87154375e-02f, 6.21743500e-02f, -9.37862042e-03f, 2.87443120e-02f, -1.15871198e-01f, -6.21596910e-02f, 6.09351508e-02f, 3.73178795e-02f,
  2.08293018e-03f, -3.92062142e-02f, 8.27464759e-02f, 8.72952566e-02f, 1.73465032e-02f, 7.62034580e-02f, -1.37171159e-02f, -4.23042476e-02f, 9.78014320e-02f, -5.48629053e-02f,
  8.77379626e-02f, 1.08751968e-01f, -6.25387132e-02f, -1.18913941e-01f, -1.05654329e-01f, -1.22487389e-01f, -2.00545136e-02f, 9.98221338e-03f, -4.26635146e-02f, -4.15235721e-02f,
  -5.96079649e-03f, -5.69240786e-02f, -1.12679482e-01f, -8.77423435e-02f, 2.05685664e-02f, -6.76353276e-02f, -1.25482082e-01f, -1.49338752e-01f, -1.99201703e-01f, -1.73690513e-01f,
  -1.98268428e-01f, -5.65489978e-02f, -5.09340018e-02f, -1.03833534e-01f, -1.50841206e-01f, -1.15052082e-01f, 5.41432835e-02f, -4.45717387e-02f, -8.14427286e-02f, -2.23685965e-01f,
  -2.95439154e-01f, 1.21673994e-01f, -2.13702116e-02f, 3.11516486e-02f, 5.92036881e-02f, 1.15139596e-02f, 8.81470889e-02f, 8.63375664e-02f, 3.53570469e-02f, -3.40621658e-02f,
  5.24223186e-02f, 2.13089883e-02f, -3.10694519e-03f, -3.72391976e-02f, 1.08010843e-02f, -8.39044154e-02f, 9.00835916e-02f, -2.55510584e-02f, -7.91199319e-03f, 3.78952101e-02f,
  -3.16465385e-02f, 7.54643753e-02f, 7.55648911e-02f, 1.34230837e-01f, -1.53673356e-02f, -2.79301833e-02f, 1.26467884e-01f, 4.03856207e-03f, -3.12113902e-03f, 4.78058010e-02f,
  4.81930412e-02f, 1.47882653e-02f, -2.02854071e-02f, 1.10965269e-03f, 3.78573276e-02f, -1.38295116e-02f, -2.35970709e-02f, 9.72560607e-03f, -3.00875064e-02f, 6.37356043e-02f,
  6.44381940e-02f, -4.60304283e-02f, 5.19020297e-02f, 1.42675508e-02f, 2.20485814e-02f, -6.16497360e-02f, 1.09869204e-02f, 1.18726669e-02f, 3.54053155e-02f, 1.63253285e-02f,
  -1.54242162e-02f, -8.67793523e-03f, -4.77925204e-02f, 6.06220253e-02f, -3.34981680e-02f, 3.47893126e-02f, -2.30785348e-02f, -4.63335700e-02f, -5.26370155e-03f, 5.92627004e-02f,
  -8.58352482e-02f, 2.00570226e-01f, -3.00181378e-03f, -4.47211380e-04f, 4.14495403e-03f, 2.94574779e-02f, 8.73285383e-02f, 3.41967680e-02f, -1.90589745e-02f, -3.96737121e-02f,
  4.40449789e-02f, -1.50261065e-02f, -6.24221638e-02f, -5.35740964e-02f, -1.11448064e-01f, -3.72982677e-03f, 3.56071070e-02f, -5.89410029e-02f, 1.55246407e-02f, 7.64226094e-02f,
  5.79393357e-02f, 7.30100870e-02f, -1.11471415e-02f, 2.96048410e-02f, 7.88456351e-02f, 1.42674977e-02f, -1.34522514e-02f, 3.22468393e-02f, -2.34167259e-02f, -6.02833517e-02f,
  -1.73495039e-01f, 2.52864569e-01f, 2.00475961e-01f, -2.56970152e-02f, 2.50975609e-01f, 3.41821253e-01f, 4.22777086e-01f, 1.11209288e-01f, -1.47908762e-01f, 7.13651702e-02f,
  -8.12129900e-02f, -2.04026252e-01f, -1.54432744e-01f, -1.47326261e-01f, -1.78408436e-02f, 3.15980315e-01f, 1.83755189e-01f, -1.42575234e-01f, -3.69297750e-02f, -7.88627416e-02f,
  -6.01724163e-02f, 1.33626843e-02f, -2.25506470e-01f, -1.40824959e-01f, -4.37372742e-04f, -5.03808667e-04f, 1.65087327e-01f, 1.23137176e-01f, 7.18714744e-02f, -5.25775962e-02f,
  1.49873331e-01f, 7.17586502e-02f, 5.87561447e-03f, -1.96908042e-01f, 7.51885772e-02f, -2.30810996e-02f, 1.75704935e-03f, -2.11267942e-03f, -6.93035051e-02f, -5.66466711e-02f,
  -9.38890129e-02f, -5.08113205e-02f, -6.16539195e-02f, -6.64509386e-02f, 5.44917025e-02f, 1.77853219e-02f, -9.00843963e-02f, -3.51839233e-03f, -1.48174558e-02f, -2.78469585e-02f,
  -1.14129193e-01f, -6.45325780e-02f, 6.14800751e-02f, 1.29266962e-01f, 9.06435177e-02f, -5.55314794e-02f, 6.01437837e-02f, 5.98444082e-02f, 7.25100338e-02f, 7.37710446e-02f,
  -1.85363311e-02f, 5.70234358e-02f, -8.70382264e-02f, 1.84868008e-03f, -9.10224207e-03f, 2.05563940e-02f, -1.00559108e-02f, 2.15309244e-02f, -6.38243603e-03f, 3.76589298e-02f,
  -3.81331667e-02f, 3.48215178e-02f, -2.85206083e-02f, 2.02754745e-03f, -9.27269980e-02f, 1.26042096e-02f, -4.13490795e-02f, 4.06586528e-02f, -9.12735835e-02f, -4.24239486e-02f,
  -6.78984895e-02f, 7.84836411e-02f, 4.66515832e-02f, -4.67261970e-02f, -3.46917063e-02f, -1.85942184e-02f, -5.73847955e-03f, 2.61013483e-04f, -8.89546797e-02f, 2.48310645e-03f,
  3.77904400e-02f, 8.01659301e-02f, 1.57296713e-02f, 9.52573959e-03f, -2.69981883e-02f, -6.60288110e-02f, -5.30483713e-03f, -3.52370217e-02f, 2.15474050e-02f, 8.30805227e-02f,
  6.86950758e-02f, 5.68655021e-02f, 5.08815385e-02f, 4.34054211e-02f, 2.40772050e-02f, 1.92642752e-02f, 8.00239146e-02f, -5.00134453e-02f, -7.02858418e-02f, 1.55628461e-03f,
  1.16660543e-01f, 1.37676457e-02f, -5.25785908e-02f, 1.35106951e-01f, 6.81793019e-02f, 4.14858349e-02f, 1.51352033e-01f, 1.69120029e-01f, 1.32067874e-01f, 2.44287103e-01f,
  -3.51881862e-01f, -2.42953375e-01f, 3.40557136e-02f, -2.73985803e-01f, -1.13666169e-01f, 1.97046846e-01f, 6.48022294e-02f, 1.26204059e-01f, -1.35378823e-01f, -1.91758901e-01f,
  -6.74750954e-02f, 1.51024489e-02f, 1.15714923e-01f, 3.00477237e-01f, 3.88334751e-01f, 1.02537803e-01f, 8.13715905e-02f, 3.13695520e-01f, 4.78353620e-01f, 2.99065232e-01f,
  1.13375671e-01f, -6.80722892e-02f, -1.03073880e-01f, 1.22438617e-01f, -1.62315845e-01f, -3.25748213e-02f, -2.06263989e-01f, -1.17247820e-01f, -1.11150322e-02f, -3.10275227e-01f,
  -6.96048960e-02f, -2.32246488e-01f, 2.48790398e-01f, -1.67674909e-03f, -3.08718178e-02f, -3.54877976e-03f, 3.54465023e-02f, -7.67362129e-04f, 1.91727048e-03f, -6.47969171e-03f,
  3.73518541e-02f, 6.33294284e-02f, 1.26877045e-02f, 7.94770941e-02f, 6.17704578e-02f, 4.48458046e-02f, 1.18685506e-01f, 9.43528041e-02f, 1.02706313e-01f, 4.63245101e-02f,
  -6.41266927e-02f, 4.69785035e-02f, 3.24132368e-02f, 1.03329591e-01f, 2.34576873e-02f, 1.07217006e-01f, -1.31414961e-02f, -3.19736637e-02f, -4.70646803e-04f, -2.20731810e-01f,
  -7.22189783e-04f, 1.59843713e-02f, 3.35408957e-03f, -5.83440550e-02f, -3.31601910e-02f, 2.57539302e-02f, 1.85519725e-03f, 1.63800362e-02f, 1.04004228e-02f, 2.11353824e-02f,
  7.08649680e-03f, -8.67832080e-02f, 4.35930025e-03f, -7.65560493e-02f, -6.20433725e-02f, -4.33484986e-02f, 3.34598571e-02f, 3.11711151e-02f, 4.71238010e-02f, -7.60100186e-02f,
  6.48356006e-02f, 2.54004472e-03f, -9.13937688e-02f, 4.74746116e-02f, 3.72597463e-02f, 2.48395074e-02f, 4.48607141e-03f, -1.72519572e-02f, 7.51895411e-03f, -6.58528581e-02f,
  -1.37905613e-01f, 2.94631422e-01f, -7.84474686e-02f, 8.59938487e-02f, -3.11806966e-02f, -4.53840122e-02f, -1.27752870e-01f, 2.59976368e-02f, -1.22020483e-01f, 4.26332429e-02f,
  1.10811442e-01f, -4.60069068e-03f, -8.38642344e-02f, 3.26483808e-02f, 3.05983685e-02f, -2.15416979e-02f, -1.00169376e-01f, 2.25849934e-02f, 1.09780923e-01f, -1.34651497e-01f,
  8.36250838e-03f, 1.25905890e-02f, 1.41644463e-01f, -1.93319824e-02f, -1.57808026e-04f, 4.96576540e-02f, 6.58895522e-02f, 3.48370411e-02f, 1.66370869e-01f, -6.17765561e-02f,
  -1.79531518e-02f, 9.51868445e-02f, -7.05509931e-02f, 4.39638868e-02f, 2.38336280e-01f, 1.64490268e-01f, 2.00456932e-01f, 1.21156402e-01f, 8.42626542e-02f, -5.94252013e-02f,
  9.75770950e-02f, 1.08057626e-01f, -6.37224270e-03f, 5.02238572e-02f, -4.02573012e-02f, -1.59971379e-02f, -1.68670163e-01f, -4.19849381e-02f, -1.99140497e-02f, 1.21562950e-01f,
  1.40383571e-01f, -2.38963198e-02f, -1.50685281e-01f, -8.75157341e-02f, -9.18364078e-02f, -1.61746070e-01f, -1.57492623e-01f, -1.18468761e-01f, -1.20374016e-01f, -2.50154972e-01f,
  -1.96939975e-01f, 1.65107712e-01f, -9.89372283e-02f, 1.71911251e-02f, -7.22694257e-03f, -2.78060976e-02f, 5.24976589e-02f, -1.06218625e-02f, -2.80300472e-02f, 8.87827668e-03f,
  6.50977790e-02f, -6.92887511e-03f, -6.59895390e-02f, 3.60131897e-02f, -7.12717464e-03f, 1.64071587e-03f, 4.02924512e-03f, -5.76004609e-02f, -6.56773075e-02f, -4.15463336e-02f,
  7.79763311e-02f, 1.32444844e-01f, 8.11219886e-02f, -1.73929483e-02f, -9.14224908e-02f, 7.97230303e-02f, 2.41134148e-02f, -3.62511054e-02f, -1.33894116e-01f, -2.23686054e-01f,
  -9.49510708e-02f, 2.14677509e-02f, -5.61140291e-02f, -1.66258961e-02f, -8.92297737e-03f, -8.60516448e-03f, -4.40745205e-02f, 4.45119739e-02f, 1.29879769e-02f, 1.62301455e-02f,
  -8.66692886e-03f, 4.27719690e-02f, -4.31061238e-02f, -4.58789915e-02f, -6.21335842e-02f, -5.84805980e-02f, -6.42258395e-03f, -3.77733782e-02f, 8.76808316e-02f, -3.88524234e-02f,
  5.36856167e-02f, -7.65852481e-02f, -1.86810344e-02f, -3.13750505e-02f, 6.30790517e-02f, 3.03503126e-03f, 2.61717588e-02f, 4.83971685e-02f, 1.45029768e-01f, -2.01638993e-02f,
  1.17843237e-03f, -1.99565431e-03f, -1.20754838e-01f, 2.12046746e-02f, -4.52512093e-02f, 1.37197776e-02f, -2.44521517e-02f, -3.27989869e-02f, 1.13998488e-01f, 9.35444012e-02f,
  2.33228207e-02f, -1.09958291e-01f, 4.69980091e-02f, -8.18379372e-02f, 7.90151283e-02f, 1.21376449e-02f, -4.87123504e-02f, -7.78875351e-02f, 4.60823486e-03f, 1.25065356e-01f,
  6.69542253e-02f, 5.23392968e-02f, 8.33112001e-02f, -8.00875947e-03f, 4.98513989e-02f, -1.03738289e-02f, 9.36456583e-03f, -8.42789859e-02f, -1.03705131e-01f, -8.02707672e-02f,
  -7.83181787e-02f, -1.40352651e-01f, 2.21323725e-02f, -1.45937189e-01f, -5.15254959e-02f, -9.57520902e-02f, -3.07897329e-01f, -8.64697620e-02f, -1.07313469e-01f, -1.70616105e-01f,
  -1.51475631e-02f, 2.68437676e-02f, -9.84337530e-04f, 8.76003057e-02f, -2.05400616e-01f, -1.52855143e-01f, -2.80045986e-01f, -8.22458044e-02f, -3.86426672e-02f, -4.30364199e-02f,
  -3.06132492e-02f, -1.46762570e-02f, 1.01236561e-02f, 6.10875618e-03f, -7.42739588e-02f, 7.12629408e-02f, -3.33759561e-02f, 8.28071013e-02f, 4.09117863e-02f, -8.20214394e-03f,
  1.67665616e-01f, 1.28051452e-02f, 7.14387223e-02f, -7.84486979e-02f, 8.37645009e-02f, 3.11586168e-02f, 2.23364551e-02f, 8.61829333e-03f, 9.34639722e-02f, -1.52252559e-02f,
  7.81230722e-03f, -2.98464932e-02f, 4.71867714e-03f, -4.12437990e-02f, -3.93713042e-02f, -5.01739271e-02f, -2.28239726e-02f, -6.40909448e-02f, 2.67007370e-02f, -7.71349147e-02f,
  -1.11636162e-01f, -3.92668284e-02f, 1.64423036e-05f, 1.67603008e-02f, -7.32669905e-02f, -1.17762173e-02f, 2.21807286e-02f, 5.66207394e-02f, 5.69470413e-02f, 7.42555130e-03f,
  -4.46830206e-02f, 1.25906631e-01f, -2.12494954e-02f, -5.69777489e-02f, -2.63252053e-02f, -8.27634055e-03f, -3.26060806e-03f, -4.66769487e-02f, -4.08750288e-02f, -5.21054864e-02f,
  4.26168106e-02f, -4.19221595e-02f, 3.21959183e-02f, -8.60502943e-02f, -2.64674537e-02f, -4.57344316e-02f, -8.72741733e-03f, -1.13491938e-01f, 3.96828912e-02f, 3.50716827e-03f,
  5.48705691e-03f, 7.55121559e-02f, 4.87573631e-02f, -4.68394719e-02f, 5.47370734e-03f, -6.86936527e-02f, 3.92887415e-03f, 6.72971010e-02f, 8.80878791e-02f, 1.62430368e-02f,
  2.43976675e-02f, 8.40340778e-02f, 6.70335144e-02f, -1.14048794e-01f, -2.60340665e-02f, 5.57337105e-02f, 6.98701385e-03f, 2.27038860e-02f, 5.21466322e-02f, 3.84926312e-02f,
  -6.16971462e-04f, -7.71889882e-03f, -2.74570510e-02f, 2.74025723e-02f, 3.83498855e-02f, -3.33309621e-02f, -1.24530114e-01f, 1.52894424e-03f, 3.62877478e-03f, 3.80708836e-02f,
  -1.81853756e-01f, -4.72560339e-02f, -2.04638895e-02f, 3.98517102e-02f, -2.23038141e-02f, 2.74406113e-02f, -1.89543143e-02f, 9.85015780e-02f, 6.05968386e-02f, -1.09235995e-01f,
  -3.77801776e-01f, 1.94046333e-01f, -1.03451520e-01f, -1.24173306e-01f, 1.62725165e-01f, 1.14143237e-01f, 2.38048062e-01f, -2.37487387e-02f, 1.68148242e-02f, 6.98838905e-02f,
  8.55236277e-02f, -1.00253962e-01f, -1.29124016e-01f, -4.70219105e-02f, -1.20724127e-01f, 2.17928782e-01f, 1.94062606e-01f, -1.11453719e-01f, -3.29224616e-01f, -4.30261232e-02f,
  1.29026562e-01f, -1.07867634e-02f, -2.37465426e-01f, -1.07037239e-01f, 1.47627890e-01f, -1.11204140e-01f, 1.28925254e-03f, 7.99269453e-02f, 9.93509293e-02f, 2.45223895e-01f,
  -5.60012609e-02f, -1.04366608e-01f, -5.16059436e-02f, 8.32361430e-02f, 5.61284199e-02f, -4.72432338e-02f, 5.79064451e-02f, -1.12618960e-01f, -9.65549201e-02f, -4.79820231e-03f,
  -1.59528814e-02f, -5.33648022e-02f, -1.14544863e-02f, -2.23611984e-02f, -8.22247788e-02f, -7.55394325e-02f, -6.22271448e-02f, -1.68158084e-01f, -8.78367648e-02f, -3.87838334e-02f,
  1.25905037e-01f, 8.05636048e-02f, -1.53135791e-01f, 1.54795507e-02f, -1.01777509e-01f, -1.17275506e-01f, -6.89539313e-02f, 4.95390333e-02f, -3.85212488e-02f, -6.50144666e-02f,
  5.14769256e-02f, -6.03624731e-02f, -8.40133522e-03f, -3.43823843e-02f, 2.36723628e-02f, 4.99833375e-02f, -3.93097177e-02f, 3.90585661e-02f, -5.66587448e-02f, 2.71140994e-03f,
  -3.80457491e-02f, 2.55753603e-02f, -6.84699267e-02f, -5.51704317e-02f, 1.62704568e-02f, 1.63244233e-02f, -8.59736428e-02f, 7.49166533e-02f, -9.15011242e-02f, 8.09905864e-03f,
  2.81035546e-02f, 2.99130566e-03f, -1.05234170e-02f, 8.93991673e-05f, 9.42261964e-02f, 7.13162310e-03f, 2.79185493e-02f, 9.53682046e-03f, 5.20171113e-02f, -5.28127067e-02f,
  -1.52021438e-01f, 3.97776812e-02f, -1.05891591e-02f, -1.98026397e-03f, -8.79855230e-02f, 3.13829742e-02f, -3.43395770e-02f, -2.41234731e-02f, -9.71297454e-03f, -1.03006154e-01f,
  -1.94132198e-02f, -2.09042877e-02f, -2.01887321e-02f, -2.06515398e-02f, 4.93961051e-02f, -8.72468483e-03f, 9.36416835e-02f, -4.44192402e-02f, 8.08048099e-02f, -4.22502309e-02f,
  1.12708770e-01f, -3.84658054e-02f, -1.81630421e-02f, -6.01479039e-02f, 2.60665864e-02f, -2.31760535e-02f, -2.46166512e-02f, -8.56240913e-02f, -5.71625009e-02f, 9.04566329e-03f,
  1.88325778e-01f, 1.29425466e-01f, 3.87247540e-02f, 8.43902230e-02f, -1.37082368e-01f, -3.17806005e-01f, -2.49023244e-01f, -1.38387263e-01f, 1.35877982e-01f, -1.84026435e-02f,
  -2.67374590e-02f, 1.90002359e-02f, 1.38561975e-03f, -3.17106619e-02f, -4.77550663e-02f, -6.97082728e-02f, 1.46745041e-01f, 4.23930250e-02f, -7.44537413e-02f, -2.04838410e-01f,
  -2.99317315e-02f, 5.69256395e-02f, 1.97906747e-01f, 2.52593588e-02f, 1.86149329e-01f, -1.15372837e-01f, 1.71721652e-01f, 1.97565347e-01f, 7.53365681e-02f, 2.69837439e-01f,
  1.31754309e-01f, 1.46154329e-01f, -1.51125714e-01f, 5.94776459e-02f, 6.99437689e-03f, 7.18767419e-02f, -9.08354670e-02f, 1.13773525e-01f, -1.51977260e-02f, 2.10461542e-02f,
  4.62136455e-02f, 6.80002868e-02f, 6.98254630e-02f, -4.44203056e-02f, 4.57896180e-02f, 1.07427062e-02f, 1.90994143e-01f, 8.50808546e-02f, 8.33992958e-02f, 7.89474323e-03f,
  -1.48229692e-02f, 1.22061431e-01f, -1.99878938e-03f, -8.19219425e-02f, -9.39005837e-02f, -8.53366125e-03f, 4.38294262e-02f, 1.02196023e-01f, -8.75085592e-02f, 1.66034743e-01f,
  -3.70706879e-02f, -2.58984733e-02f, 3.88835929e-02f, 3.16380486e-02f, -5.09598888e-02f, -1.07208332e-02f, 6.29703514e-03f, -1.07752718e-02f, 1.87500902e-02f, 2.98452582e-02f,
  -3.30015109e-03f, -5.49805760e-02f, 2.70639416e-02f, -2.89876647e-02f, 3.99634466e-02f, 1.03173731e-03f, -2.93409359e-02f, 3.22719142e-02f, 3.61550786e-02f, -2.90771201e-02f,
  -4.06246334e-02f, -2.20431350e-02f, 5.45076211e-04f, -4.75683175e-02f, -2.26013884e-02f, -1.36641096e-02f, -3.30502391e-02f, 3.84047925e-02f, 2.91502997e-02f, 3.99238542e-02f,
  8.38404670e-02f, -9.18670893e-02f, -3.70027386e-02f, 2.89686909e-03f, 5.33924811e-02f, 8.61727633e-03f, 3.47821712e-02f, -1.84749672e-03f, 4.81344387e-02f, 2.91598886e-02f,
  -2.90674530e-02f, 4.60196892e-03f, -2.29026582e-02f, 6.30455837e-02f, -4.25626114e-02f, -1.80769269e-03f, -3.20321806e-02f, -7.10216176e-04f, -9.19838157e-03f, -1.88380610e-02f,
  1.17254164e-03f, -1.26835451e-01f, -2.72219628e-02f, -7.97170997e-02f, -5.87376393e-02f, -1.19354524e-01f, -1.09297223e-01f, -3.84227708e-02f, -1.34845361e-01f, -1.00945644e-01f,
  4.14057486e-02f, -1.00769904e-02f, 1.54676244e-01f, -1.11500986e-01f, 2.73277834e-02f, 2.24947929e-01f, 1.08738489e-01f, 9.22333896e-02f, -1.13912530e-01f, -6.84047565e-02f,
  -9.64835882e-02f, -1.36998594e-01f, -1.39108866e-01f, -1.45200998e-01f, -8.51983204e-02f, 8.18653777e-02f, 1.14753060e-01f, 7.85063133e-02f, 1.90137476e-01f, 3.77414897e-02f,
  -1.13137640e-01f, 8.58229585e-03f, -6.47617802e-02f, -1.02764785e-01f, 6.61650300e-02f, -1.23365978e-02f, -4.47294302e-03f, -6.11556359e-02f, 5.91548346e-02f, 2.03783996e-02f,
  1.52740717e-01f, 5.26173636e-02f, 1.06644079e-01f, -1.17730759e-01f, -5.02723977e-02f, 5.62529406e-03f, -2.68354882e-02f, 5.01138978e-02f, 3.96026894e-02f, -3.82611267e-02f,
  3.44011001e-02f, -7.24357292e-02f, 5.82960844e-02f, -3.39968987e-02f, 1.74111463e-02f, -3.03895883e-02f, -4.97771241e-02f, -2.08030697e-02f, 3.23711969e-02f, -7.24876747e-02f,
  -1.77722722e-01f, -5.05570658e-02f, 4.92249057e-02f, -8.92077833e-02f, 6.39116857e-04f, 4.32713330e-02f, -2.22660098e-02f, 4.71231453e-02f, 6.63284957e-02f, -5.97126186e-02f,
  1.54545717e-02f, -2.09304746e-02f, 2.29320005e-02f, -1.13576725e-02f, 4.93803732e-02f, 6.77529797e-02f, -8.31231922e-02f, -7.76876956e-02f, 8.30911621e-02f, -4.95671146e-02f,
  1.57599859e-02f, -6.52817339e-02f, -1.28330309e-02f, -8.87738392e-02f, 6.31636893e-03f, -4.07345071e-02f, -5.75167360e-03f, -8.43117461e-02f, -1.86138228e-02f, -1.24353329e-02f,
  2.31921878e-02f, 4.53342423e-02f, 4.77418937e-02f, 8.10449719e-02f, -1.04836456e-01f, -4.92272414e-02f, 7.92032406e-02f, -4.74833325e-02f, -1.30358055e-01f, -6.55311421e-02f,
  9.62717608e-02f, -1.13136806e-02f, 6.18155599e-02f, 6.73833042e-02f, 3.75934155e-03f, -3.57836648e-03f, -1.02063669e-02f, -1.81192011e-02f, 6.43455004e-03f, 6.16268069e-03f,
  8.75099674e-02f, 6.80731833e-02f, -1.45672131e-02f, 2.39606034e-02f, 7.61821344e-02f, 1.64870217e-01f, -3.58030498e-02f, 6.95287734e-02f, 2.68639647e-03f, -2.73772888e-02f,
  -6.59764111e-02f, 1.00370824e-01f, 9.38499793e-02f, 1.19211406e-01f, 1.27200067e-01f, 1.27203599e-01f, 1.15498543e-01f, 1.36532456e-01f, 6.17954880e-02f, 1.27827317e-01f,
  -2.48367891e-01f, 5.48337735e-02f, -3.04119643e-02f, 2.83486024e-02f, 3.74742113e-02f, 5.09931147e-03f, -7.41895288e-03f, 1.00461565e-01f, 5.67721352e-02f, -1.28207067e-02f,
  2.33120933e-01f, 1.55555621e-01f, 1.12245880e-01f, 7.79456720e-02f, 4.49170694e-02f, -1.80963427e-01f, -1.05015621e-01f, -8.23622718e-02f, -7.17340708e-02f, -4.17472832e-02f,
  2.61360575e-02f, -7.37832487e-02f, 2.99945212e-04f, 3.43344621e-02f, 9.02896747e-03f, 9.10784453e-02f, -2.98468638e-02f, 1.81550663e-02f, -6.65706536e-03f, -1.06018763e-02f,
  -1.92533303e-02f, 1.42438710e-01f, 9.85280871e-02f, 2.78226193e-02f, 8.59627798e-02f, -3.21530998e-02f, 2.53144614e-02f, 8.37970600e-02f, 4.16928604e-02f, 5.47809303e-02f,
  1.51319787e-01f, 1.22418635e-01f, 1.27998203e-01f, 3.19379568e-03f, 7.85798505e-02f, 1.73412059e-02f, 4.23609875e-02f, -1.13288052e-01f, -7.16782287e-02f, 4.89274934e-02f,
  1.55468524e-01f, -5.23558538e-03f, 8.13787896e-03f, -2.01249141e-02f, 8.52898359e-02f, 3.96236021e-04f, 6.23469576e-02f, 4.32934538e-02f, 9.71261819e-04f, 2.47780234e-02f,
  4.33364447e-04f, 4.27041352e-02f, 2.56005451e-02f, -6.78224862e-02f, -8.95525292e-02f, 5.96567951e-02f, 4.43574088e-03f, -1.29287830e-02f, 2.18304228e-02f, -9.82832164e-02f,
  -1.14935273e-02f, -6.29475191e-02f, 3.69002298e-02f, -5.77247031e-02f, -3.02709057e-03f, 1.23190433e-01f, 1.93253644e-02f, -6.94232509e-02f, -6.67251125e-02f, 1.15934864e-01f,
  -7.25906808e-03f, 4.06605266e-02f, -2.49106996e-02f, 6.06411807e-02f, -6.20563440e-02f, 5.46095036e-02f, -6.69179410e-02f, -4.13661636e-03f, -1.99199021e-02f, 5.11918329e-02f,
  3.93034443e-02f, 1.61357641e-01f, -9.27685723e-02f, -3.18971253e-03f, 4.91864346e-02f, -4.83478308e-02f, -6.69346899e-02f, -3.11858170e-02f, 8.55669454e-02f, -1.01814047e-01f,
  1.33128315e-01f, 6.47352189e-02f, 4.27294197e-03f, 4.68065478e-02f, 5.10913413e-03f, -3.57644097e-03f, -1.46082789e-02f, -7.60075375e-02f, -2.48455931e-03f, -5.80322519e-02f,
  -5.39555550e-02f, -1.56882390e-01f, -1.25378981e-01f, -8.09455737e-02f, 1.00359149e-01f, -9.05381069e-02f, -4.51806337e-02f, 2.35719122e-02f, -7.34273791e-02f, -2.70963669e-01f,
  1.88658983e-01f, -1.03403971e-01f, 2.48725131e-01f, 2.94807613e-01f, 1.22807719e-01f, 1.24721788e-01f, 7.71350563e-02f, -7.85459280e-02f, 3.86621989e-02f, -3.33207101e-03f,
  -1.35816678e-01f, -2.69724131e-01f, -1.27551034e-01f, -1.40297621e-01f, -9.48575791e-03f, 4.54277694e-02f, 1.82533607e-01f, 1.53654277e-01f, 8.04524869e-02f, -9.29020941e-02f,
  -7.86618590e-02f, 2.25978350e-04f, 1.12492375e-01f, -5.79773858e-02f, 1.15425445e-01f, 3.18905525e-02f, 2.48782709e-02f, 1.37570098e-01f, 3.76581820e-03f, 8.48981589e-02f,
  -9.07852203e-02f, 6.85888827e-02f, 3.19032781e-02f, -1.47671938e-01f, -4.92446870e-02f, -8.12186226e-02f, 2.80782953e-02f, 1.21438922e-02f, -7.46248066e-02f, 8.11399519e-02f,
  8.71073380e-02f, -1.84068754e-02f, 7.76935667e-02f, 3.71483900e-02f, 8.98268297e-02f, -4.39698771e-02f, 5.97776137e-02f, -8.55401903e-03f, -1.18169002e-02f, -3.40373777e-02f,
  -1.47808746e-01f, -6.03246549e-03f, 9.29098576e-02f, 6.39334023e-02f, 1.79784782e-02f, 4.94853891e-02f, 8.36253446e-03f, 1.53701548e-02f, -9.95908454e-02f, -6.70861900e-02f,
  -6.06157184e-02f, 5.44269290e-03f, -7.02497289e-02f, 9.49671306e-03f, -1.91130489e-02f, 4.34321575e-02f, 2.69997325e-02f, 1.20307142e-02f, -7.31684491e-02f, 6.26320690e-02f,
  2.21033581e-02f, -4.99727950e-02f, 1.99301019e-02f, 8.90357327e-03f, -7.99469054e-02f, 2.27894373e-02f, 5.90261165e-03f, -3.85706313e-02f, -1.14882551e-02f, 5.55395745e-02f,
  -4.90072742e-03f, 5.29756248e-02f, 2.10598460e-03f, 3.21257785e-02f, -9.75938141e-02f, -3.13074724e-03f, 4.68198247e-02f, 2.60052718e-02f, -3.62159945e-02f, 3.04984618e-02f,
  -1.40175432e-01f, -1.59068052e-02f, 1.29026370e-02f, -2.23481916e-02f, 1.02153555e-01f, -2.25478988e-02f, 4.35478985e-02f, -7.76192322e-02f, -2.38262443e-03f, 5.67279644e-02f,
  -1.00225665e-01f, -4.21791134e-04f, -4.71119545e-02f, 3.40737998e-02f, -6.52742833e-02f, 2.40056179e-02f, -1.43382564e-01f, 4.80959984e-03f, -1.73887182e-02f, 6.65710643e-02f,
  6.77754823e-03f, 5.65222614e-02f, 5.99981360e-02f, -6.38526008e-02f, -2.66282726e-02f, 5.69188595e-03f, -1.95856467e-02f, 3.99973914e-02f, 6.02838490e-03f, -1.21440530e-01f,
  -4.26739186e-01f, -3.25622084e-03f, -1.03926964e-01f, -2.72303462e-01f, -2.16511026e-01f, -1.31451532e-01f, -6.74413890e-02f, 1.47451060e-02f, 2.05752738e-02f, -1.76025972e-01f,
  9.57858264e-02f, 1.42909020e-01f, 8.97625387e-02f, 8.81815404e-02f, 1.37420133e-01f, -1.16497628e-01f, -1.68808356e-01f, -1.37683883e-01f, 2.46891566e-02f, 7.61153083e-03f,
  1.59137603e-02f, -8.09031874e-02f, -1.04669429e-01f, -2.02410743e-02f, -1.10299237e-01f, -5.27121797e-02f, -1.09392881e-01f, -9.24791619e-02f, 8.50443095e-02f, -2.16502007e-02f,
  -1.54387457e-02f, 2.92539727e-02f, 1.25508942e-02f, -1.61744040e-02f, -5.72466403e-02f, 2.48029712e-03f, -3.45674679e-02f, 6.35138825e-02f, 5.28034493e-02f, 2.05082484e-02f,
  -1.01342676e-02f, 1.04806691e-01f, 1.93701945e-02f, -1.87279414e-02f, -1.02519043e-01f, 6.83398917e-02f, 5.49859144e-02f, 1.28290966e-01f, 2.22475175e-02f, 3.83782480e-03f,
  5.31617068e-02f, -1.20394319e-01f, -2.33292412e-02f, 3.69694717e-02f, 1.22139104e-01f, -2.35030428e-04f, 3.19026075e-02f, 1.05830498e-01f, 6.36085719e-02f, -3.16446461e-02f,
  -1.00532115e-01f, -2.37717442e-02f, -1.13125350e-02f, 2.56402344e-02f, -2.26303078e-02f, -2.16250028e-02f, -7.64777437e-02f, -2.78501231e-02f, 9.23072745e-04f, -5.64623475e-02f,
  -9.71486792e-03f, -2.24517006e-03f, 2.79444400e-02f, 5.90246730e-02f, 7.55025297e-02f, -6.67673498e-02f, -8.26053619e-02f, 6.93194848e-03f, -8.88113584e-03f, -1.35340905e-02f,
  -9.73316189e-03f, 5.80881126e-02f, -6.08021803e-02f, 9.94430259e-02f, -5.62721826e-02f, 3.24962363e-02f, 1.51765402e-02f, 1.93080306e-02f, -4.67493460e-02f, -1.59329008e-02f,
  -2.03596577e-02f, 1.74161062e-01f, -7.94192255e-02f, 2.83731446e-02f, -8.91606808e-02f, 1.55389793e-02f, -2.29163356e-02f, -3.72419991e-02f, 2.48451512e-02f, 3.11332718e-02f,
  -1.86630990e-02f, -1.71828493e-02f, -1.13664120e-01f, 6.46202341e-02f, -6.10047951e-02f, 1.67271718e-02f, -8.67232159e-02f, 6.61667660e-02f, 2.44479254e-02f, 1.97012071e-02f,
  -1.86038315e-02f, -1.03235707e-01f, -8.51694196e-02f, 6.78584278e-02f, 8.28049555e-02f, 1.41081242e-02f, 4.22087461e-02f, -5.52847609e-02f, 8.05589557e-03f, -1.16541483e-01f,
  5.17323673e-01f, 5.58181070e-02f, 4.67475653e-02f, 1.94550224e-03f, -1.02273569e-01f, -2.86795255e-02f, 5.11990972e-02f, 2.15395764e-01f, 6.59667654e-03f, -6.33302405e-02f,
  -9.18262228e-02f, -1.97969496e-01f, -1.80702820e-01f, -1.35097444e-01f, 1.27091721e-01f, -2.53717471e-02f, -1.41703576e-01f, 2.17524916e-02f, 8.30843374e-02f, -1.04980290e-01f,
  -6.10996187e-02f, -4.18223478e-02f, 2.18921885e-01f, 2.54784077e-02f, -1.21904626e-01f, -2.49058649e-01f, -1.30679443e-01f, 4.89716558e-03f, -7.56404549e-02f, -2.14635268e-01f,
  -2.56457269e-01f, 2.78643370e-01f, -1.25435695e-01f, -5.97773232e-02f, 5.01582725e-03f, 8.71888474e-02f, -7.57790497e-03f, 1.17330424e-01f, 2.69438941e-02f, 3.63571160e-02f,
  -4.76969182e-02f, 7.08857253e-02f, -5.40114157e-02f, -4.73197363e-02f, 3.64445075e-02f, 3.23394984e-02f, 1.67722814e-02f, 9.37160403e-02f, 5.77390343e-02f, 3.29670906e-02f,
  -1.10074870e-01f, 2.32216232e-02f, 9.64795500e-02f, 1.10681839e-01f, 1.41731426e-01f, -1.04690254e-01f, 4.10231315e-02f, -5.76040056e-03f, 1.09259278e-01f, -1.37517480e-02f,
  -1.39426836e-03f, -1.47431726e-02f, 2.68328730e-02f, 2.91953683e-02f, -1.53814489e-02f, 2.23665126e-02f, -9.77627337e-02f, -5.13224527e-02f, -2.07697204e-03f, 4.34848107e-02f,
  -2.44104816e-03f, -4.22110036e-02f, 6.81967614e-03f, -2.86448319e-02f, -5.12674600e-02f, -3.50430608e-02f, 3.28283384e-02f, -3.40795666e-02f, 1.11807918e-03f, 6.35193214e-02f,
  -2.02761684e-02f, -4.92312480e-03f, -2.51358710e-02f, -2.51981765e-02f, -7.78160021e-02f, 1.67489834e-02f, 1.09116314e-02f, 3.53101902e-02f, -4.19400893e-02f, 2.04994883e-02f,
  -1.23458900e-01f, 9.01910439e-02f, -2.27280669e-02f, 2.08833870e-02f, -4.73334547e-03f, 5.59824966e-02f, -1.20592713e-01f, 8.50366801e-03f, -1.29383150e-02f, 3.74936871e-02f,
  -8.18711612e-03f, 2.45085470e-02f, 2.24804971e-02f, -2.03927793e-02f, 1.53588634e-02f, -1.06535377e-02f, 2.31106230e-03f, -7.20283166e-02f, -1.07100867e-02f, 6.39142543e-02f,
  3.07931509e-02f, 2.58728657e-02f, -7.43301883e-02f, -3.76021117e-02f, -2.34377440e-02f, -9.19627696e-02f, -9.67785195e-02f, -7.99449906e-02f, -3.09942365e-02f, -4.48910668e-02f,
  4.72407669e-01f, -2.40303457e-01f, 1.78307474e-01f, 1.14746213e-01f, -2.48209864e-01f, -1.79866865e-01f, -1.99477419e-01f, -5.06608235e-03f, 6.86668679e-02f, -1.23954959e-01f,
  -2.47539416e-01f, 5.94670735e-02f, 6.70111999e-02f, 1.34332642e-01f, 1.57829627e-01f, -7.55631644e-03f, 1.71276361e-01f, 3.75324547e-01f, 2.89495707e-01f, -4.34303805e-02f,
  -7.33279511e-02f, -3.48701999e-02f, 2.42962867e-01f, 4.92569543e-02f, -1.55613378e-01f, -4.15566862e-02f, -9.91183594e-02f, -1.22454755e-01f, -1.30427748e-01f, -4.48118821e-02f,
  -7.69957853e-03f, 9.77852475e-03f, 1.36054829e-01f, 2.18914356e-02f, -3.58166243e-03f, 1.15431570e-01f, 5.94736040e-02f, 7.44931102e-02f, 8.78799893e-03f, -4.99263778e-02f,
  1.44611550e-02f, -3.57860997e-02f, 7.07781911e-02f, -5.98595329e-02f, -8.00998360e-02f, -2.69621555e-02f, -1.88641734e-02f, 1.49428487e-01f, 6.90751597e-02f, -8.39587972e-02f,
  -9.80085358e-02f, -9.34920758e-02f, 4.65349853e-03f, -1.74300410e-02f, 5.87437488e-02f, 1.07046336e-01f, -7.56184831e-02f, -4.83865924e-02f, 1.54396659e-02f, 7.11876526e-02f,
  3.95317003e-02f, -1.88893266e-02f, 1.43988496e-02f, -4.78654318e-02f, -1.62338391e-02f, 1.05455285e-02f, -3.41449715e-02f, -3.65756429e-03f, -2.71673240e-02f, -1.25887580e-02f,
  -3.48792933e-02f, 6.61127195e-02f, -3.68081890e-02f, -3.10603082e-02f, 2.74797957e-02f, -2.27064011e-03f, 2.13638488e-02f, 5.13657108e-02f, -3.44219245e-02f, 8.51645321e-03f,
  6.93997517e-02f, -6.05692975e-02f, -7.00672269e-02f, -2.64509860e-03f, 9.96970851e-03f, 4.21135277e-02f, -1.58837456e-02f, -5.33271283e-02f, 3.18940990e-02f, -1.57086104e-02f,
  -1.47332311e-01f, 5.07140439e-03f, 5.35357883e-03f, 3.78807411e-02f, -9.58107635e-02f, 1.60975440e-03f, -5.11665009e-02f, 2.40819659e-02f, 1.10780746e-02f, 9.52107646e-03f,
  -9.14361477e-02f, 6.83903918e-02f, -3.50907780e-02f, 1.16593111e-02f, 1.07479244e-02f, -2.35986430e-02f, -9.16408747e-02f, 2.76924204e-02f, -2.49571912e-02f, -1.09122090e-01f,
  -7.07760304e-02f, -4.34694402e-02f, 3.28385159e-02f, 4.27743644e-02f, -2.77800914e-02f, 7.90733844e-02f, 5.53523749e-03f, 5.83793037e-02f, 7.01741641e-03f, -1.34538502e-01f,
  1.40872464e-01f, 6.92380890e-02f, 2.61959910e-01f, 1.67771086e-01f, 7.34140351e-02f, 1.37340069e-01f, 2.55532563e-01f, 1.19208969e-01f, 4.60398570e-02f, 1.17655717e-01f,
  -1.47707194e-01f, -2.17242226e-01f, -1.27520949e-01f, -7.51490146e-02f, -1.81827340e-02f, 2.48473436e-01f, 2.88167059e-01f, 1.35124922e-01f, -1.03419628e-02f, -1.07667767e-01f,
  -1.61381945e-01f, -6.73744306e-02f, 1.05863757e-01f, -1.54579272e-02f, -9.83786676e-03f, -7.39392638e-02f, 1.77953932e-02f, -1.72032788e-02f, -7.29387999e-02f, 3.55433933e-02f,
  -1.31327495e-01f, 1.36488944e-01f, 2.79232096e-02f, -9.33487192e-02f, -1.19059891e-01f, 9.23334435e-02f, -4.33283485e-02f, 2.39154045e-02f, 4.24103513e-02f, 6.94343001e-02f,
  -4.60915491e-02f, -4.24772911e-02f, 4.28728871e-02f, -8.07552561e-02f, -4.74988967e-02f, 6.14587776e-02f, 6.68228865e-02f, 1.19749419e-01f, 1.18239194e-01f, 5.00159822e-02f,
  4.52770479e-02f, 8.82750601e-02f, 1.55855268e-01f, -4.92009632e-02f, 8.21895599e-02f, -9.48781967e-02f, -4.62784804e-02f, 4.34534103e-02f, 6.15286529e-02f, 4.19704206e-02f,
  -3.03542558e-02f, 5.23806959e-02f, -9.71294474e-03f, -7.13714510e-02f, -3.22770402e-02f, -2.13891920e-02f, 3.13950912e-03f, -5.53981774e-02f, 6.99536577e-02f, -3.76064442e-02f,
  -1.00174561e-01f, 6.94197640e-02f, -8.49556476e-02f, 7.99038273e-04f, 1.07533224e-01f, 8.59936252e-02f, 3.65461670e-02f, 2.46717259e-02f, 3.37012447e-02f, 4.61534224e-02f,
  -3.32431532e-02f, 1.36616370e-02f, 5.20078540e-02f, -2.98228227e-02f, 2.54908334e-02f, 6.02121837e-02f, 3.29552293e-02f, -1.20812714e-01f, 3.53981145e-02f, 9.26218703e-02f,
  -1.69097126e-01f, 3.07724103e-02f, 8.73493031e-02f, -6.20692372e-02f, 8.60364810e-02f, -5.15344851e-02f, -2.05320213e-02f, 4.48302627e-02f, 1.87274683e-02f, -4.31205705e-02f,
  -6.99778870e-02f, -7.10674748e-03f, -2.71119783e-03f, 1.01565741e-01f, -8.60200897e-02f, 1.28675386e-01f, 8.41078386e-02f, 1.01602942e-01f, 1.13756594e-03f, 1.04254477e-01f,
  9.78077650e-02f, 9.12837312e-02f, 5.51944375e-02f, 1.25679523e-01f, 1.10107698e-02f, -5.29299006e-02f, 5.69665097e-02f, -4.11146209e-02f, 1.40496222e-02f, -9.42576956e-03f,
  2.30831295e-01f, -2.37588704e-01f, -9.85736921e-02f, 1.45662799e-01f, -7.83041585e-03f, -3.13096792e-01f, -3.13610971e-01f, -1.34479627e-01f, 1.90161869e-01f, -6.84302077e-02f,
  2.98211016e-02f, 9.21649262e-02f, 2.93139853e-02f, 3.12588587e-02f, -1.51184127e-01f, -1.29283249e-01f, -3.90706509e-02f, -4.87557501e-02f, 1.20847426e-01f, -1.47273451e-01f,
  2.43043844e-02f, 1.08290941e-01f, 2.18366370e-01f, 1.19913906e-01f, 9.30517018e-02f, 1.59098774e-01f, 8.29939395e-02f, -6.78308383e-02f, -7.82238320e-02f, 6.53245524e-02f,
  -9.27476063e-02f, -9.42481384e-02f, 3.45734172e-02f, 2.09537167e-02f, 7.99856242e-03f, -2.35325675e-02f, -3.81795093e-02f, -3.93991210e-02f, -6.47299411e-03f, -5.67692630e-02f,
  2.44600195e-02f, -2.27641333e-02f, 5.12653552e-02f, 6.61867261e-02f, -3.25441994e-02f, -8.52051973e-02f, 1.70577634e-02f, -6.63310066e-02f, -5.02666496e-02f, -1.34735882e-01f,
  4.69288556e-03f, -8.21259916e-02f, -2.12930534e-02f, 1.84835587e-02f, 2.34782565e-02f, 4.40571792e-02f, -1.04302682e-01f, 3.04613672e-02f, -4.67080809e-02f, -6.65873811e-02f,
  -7.54353106e-02f, 5.33924177e-02f, -5.00324070e-02f, -3.58620957e-02f, 4.42887284e-03f, 9.78548303e-02f, -2.36491510e-03f, 4.35050614e-02f, -2.08038799e-02f, -9.94207803e-03f,
  7.00735450e-02f, -5.89660071e-02f, 8.44640285e-03f, 6.00702763e-02f, -1.44684473e-02f, -1.28892832e-03f, -5.02670258e-02f, -1.79095864e-02f, -2.05960181e-02f, -3.45837139e-02f,
  -2.77261958e-02f, -5.23998961e-02f, 6.40125573e-02f, 2.59046592e-02f, 1.65026803e-02f, 3.44374031e-02f, 3.72799188e-02f, -1.71868727e-02f, 7.48530775e-02f, -3.89629342e-02f,
  1.95048779e-01f, -1.05815612e-01f, 3.82598080e-02f, 1.40743954e-02f, -2.08148882e-02f, 3.49734873e-02f, -2.80702449e-02f, -6.31212667e-02f, 2.73946989e-02f, -2.12358683e-02f,
  4.41812575e-02f, 7.21836239e-02f, -6.36924729e-02f, -1.85643937e-02f, 8.87140110e-02f, 2.28222292e-02f, 7.33084381e-02f, -3.00252195e-02f, -8.51800814e-02f, -1.14484787e-01f,
  -2.38953121e-02f, -7.04873502e-02f, -1.70845874e-02f, -9.16341171e-02f, 7.01124743e-02f, 4.69050668e-02f, 6.19246997e-02f, -1.84691809e-02f, -1.09855093e-01f, -8.53307545e-02f,
  6.45314336e-01f, 1.91683739e-01f, 9.40817073e-02f, 1.37903377e-01f, -2.23620713e-01f, -5.49145937e-02f, -2.20936276e-02f, -4.59098518e-02f, 4.47096629e-03f, 1.83953624e-02f,
  -6.90945163e-02f, -1.29850730e-01f, -8.82198662e-02f, -3.04474924e-02f, 1.73446741e-02f, -4.16206196e-03f, 1.66577678e-02f, 7.70365894e-02f, -1.27299294e-01f, -1.09762371e-01f,
  -4.78997491e-02f, 1.31491527e-01f, 2.39202917e-01f, 6.91027865e-02f, 6.98292162e-03f, -1.66674405e-01f, -2.22752634e-02f, 1.29847050e-01f, -1.77949145e-01f, 1.72009356e-02f,
  6.56818077e-02f, 2.09280565e-01f, -1.99336916e-01f, -7.08777383e-02f, -2.68428661e-02f, -1.77989192e-02f, 5.77155612e-02f, 5.06297648e-02f, 3.23732989e-03f, 9.21460018e-02f,
  4.58394997e-02f, -5.08400537e-02f, -2.20029596e-02f, -3.20213810e-02f, 1.01408176e-02f, 9.06625092e-02f, 1.21772215e-01f, 8.06378424e-02f, 8.18679780e-02f, -3.77276577e-02f,
  -1.78048655e-01f, 7.25702103e-03f, 9.70811099e-02f, 1.92902535e-02f, -4.38989066e-02f, 1.21862916e-02f, 6.16011880e-02f, -2.25984231e-02f, 1.14031769e-01f, 2.28387818e-01f,
  -3.62069942e-02f, 2.39067134e-02f, 2.05918420e-02f, 7.36825634e-03f, -1.29525103e-02f, -2.25410108e-02f, -5.30275814e-02f, -1.96485426e-02f, 2.70079682e-03f, -2.92149512e-03f,
  1.18358956e-04f, -1.80518497e-02f, 1.08848862e-01f, 5.61471991e-02f, -8.29118863e-02f, 7.09007680e-02f, -6.34486601e-03f, 3.94651107e-03f, 2.60142460e-02f, -1.49602462e-02f,
  4.96995673e-02f, -1.23748975e-02f, 3.44988927e-02f, 9.55587905e-03f, 5.11736199e-02f, 4.06152681e-02f, -3.37836123e-03f, -3.96271572e-02f, 3.93105485e-02f, -1.65996645e-02f,
  8.47476646e-02f, -7.41072819e-02f, 1.61030970e-03f, 8.44341218e-02f, -8.03257897e-03f, -3.17232460e-02f, -4.80410345e-02f, -4.89444882e-02f, -8.69894847e-02f, 5.71283549e-02f,
  -1.45233171e-02f, 2.20995471e-02f, 8.26151446e-02f, -2.67755184e-02f, 1.60664655e-02f, -4.91492040e-02f, 4.02989462e-02f, -3.07371709e-02f, -3.63582186e-02f, 8.38798191e-03f,
  2.32047681e-02f, 8.63371696e-03f, 1.02494927e-02f, 3.32786143e-02f, 3.96246603e-03f, -9.64234844e-02f, -3.81116085e-02f, -2.78274380e-02f, 6.16577789e-02f, 1.31020397e-01f,
  -1.63589582e-01f, 9.10695493e-02f, -5.52656986e-02f, -9.13496092e-02f, -1.22448526e-01f, 1.79685419e-03f, 5.95221408e-02f, -5.73552512e-02f, 5.20547619e-03f, -3.15324776e-02f,
  1.91613629e-01f, 2.31303442e-02f, -5.59060685e-02f, -4.30469774e-02f, -7.29717314e-02f, -1.41188875e-01f, -2.73630172e-01f, -2.53536612e-01f, -1.41539276e-01f, 6.72956230e-03f,
  -6.55100718e-02f, -6.74780384e-02f, -1.43613040e-01f, -2.08100267e-02f, -9.99194160e-02f, 3.98367941e-02f, -4.83360812e-02f, 3.56230475e-02f, -1.19754449e-02f, -2.36232921e-01f,
  -1.47712633e-01f, 6.25259057e-02f, 2.66808290e-02f, 7.72113428e-02f, 8.13021436e-02f, 2.62929816e-02f, 7.34006613e-02f, 5.56715429e-02f, 5.54857664e-02f, 7.68038705e-02f,
  5.49535416e-02f, -1.91651713e-02f, 3.02939061e-02f, 1.16697401e-02f, -7.08706006e-02f, -5.45750186e-02f, -6.34711459e-02f, -9.28513054e-03f, -2.08532121e-02f, 3.11896689e-02f,
  -2.89633945e-02f, 2.49825679e-02f, -4.86314297e-02f, 1.27337137e-02f, 4.28504776e-03f, -7.01897368e-02f, 3.68634984e-02f, -1.04752113e-03f, 7.27582052e-02f, 2.88440790e-02f,
  3.72514278e-02f, -3.00414469e-02f, 8.44659954e-02f, -2.44341101e-02f, -4.46978435e-02f, 4.85816263e-02f, 2.86058728e-02f, -1.00312084e-01f, -2.51058303e-02f, 3.36412676e-02f,
  6.20661415e-02f, -7.28283823e-02f, 2.22944729e-02f, -6.22671172e-02f, -4.71365489e-02f, -2.97842603e-02f, 5.80478832e-02f, 6.40445203e-03f, 3.57980169e-02f, -8.56489700e-04f,
  -1.71926972e-02f, 1.37982005e-02f, -2.03190017e-02f, 4.38606441e-02f, -5.79216145e-02f, -6.33713081e-02f, -5.95216490e-02f, 1.17934667e-01f, 4.28808071e-02f, 2.68334895e-02f,
  9.89251360e-02f, 1.52786508e-01f, -1.26075536e-01f, -8.34185705e-02f, -7.32527152e-02f, 2.65179784e-03f, 2.51244977e-02f, 5.08578075e-03f, 4.09054570e-02f, -9.58819315e-03f,
  7.51160458e-02f, -6.35931864e-02f, 4.25245985e-02f, 9.81700271e-02f, -2.75529046e-02f, 1.31117329e-02f, 5.30224219e-02f, -7.54533410e-02f, -2.52359267e-02f, -4.80840988e-02f,
  -2.31227316e-02f, -2.32729223e-02f, 5.23547493e-02f, 3.14721987e-02f, -5.25244884e-02f, -5.76781034e-02f, 2.53182016e-02f, 3.55930701e-02f, -2.33352892e-02f, 1.02022059e-01f,
  -3.97287101e-01f, -1.99981444e-02f, -2.88831532e-01f, 7.63264671e-02f, 2.28833452e-01f, -4.04952392e-02f, -1.09076731e-01f, 5.79360053e-02f, 2.09803004e-02f, 3.34822163e-02f,
  3.82794701e-02f, 1.52895719e-01f, 1.07521405e-02f, 5.33084646e-02f, -1.61557123e-01f, -7.88391102e-03f, -5.68344481e-02f, -8.23740065e-02f, -1.64407149e-01f, 1.30318224e-01f,
  1.46899119e-01f, -7.79857859e-02f, -1.26705512e-01f, -2.19396707e-02f, 1.15899153e-01f, 1.12984478e-01f, -2.71970909e-02f, -4.57458161e-02f, 7.28265122e-02f, 2.06333354e-01f,
  -1.31929561e-01f, -9.39763039e-02f, 9.76978019e-02f, 8.11147392e-02f, -3.35868634e-02f, -1.63959414e-02f, -3.71580049e-02f, 2.11937334e-02f, -8.35896209e-02f, -3.52516323e-02f,
  -4.51947078e-02f, 1.02337874e-01f, -5.14022820e-02f, -4.83884523e-03f, 9.06926487e-03f, -5.37961312e-02f, -1.37854218e-01f, -2.89703105e-02f, -1.06231406e-01f, -1.06594441e-02f,
  4.20644172e-02f, -9.92495194e-03f, -1.91031754e-01f, -5.89687191e-02f, -1.16524220e-01f, -1.94071531e-02f, 4.77554016e-02f, -3.66327092e-02f, -8.30603912e-02f, -9.72225964e-02f,
  1.75751075e-02f, 2.00317390e-02f, -9.62573588e-02f, -2.84892246e-02f, 2.55335458e-02f, 3.09475847e-02f, -2.34737843e-02f, 1.32063637e-03f, -4.76812124e-02f, -2.82072239e-02f,
  7.25806085e-03f, -1.32669536e-02f, 3.69754843e-02f, -7.93080311e-03f, 8.37776810e-02f, -6.32490292e-02f, 5.35378382e-02f, -6.06232835e-03f, -3.13275196e-02f, -5.67960329e-02f,
  3.59466635e-02f, -4.68017198e-02f, -1.71104372e-02f, -5.85748488e-03f, -1.03599757e-01f, 1.86452325e-02f, -4.03374545e-02f, -1.52502768e-02f, 4.00118437e-03f, -3.28346528e-03f,
  -1.87340379e-02f, -5.58713712e-02f, -1.26187745e-02f, 4.91735674e-02f, 1.28185153e-02f, -7.43343979e-02f, -1.99907999e-02f, -4.10712324e-02f, -1.31069452e-01f, -3.10376938e-02f,
  -6.13395795e-02f, -1.16330534e-01f, 2.11315639e-02f, 8.76915827e-02f, -5.07376865e-02f, 4.42228653e-03f, -1.26841977e-01f, -1.73336864e-02f, -6.01850040e-02f, -3.87860127e-02f,
  2.76553333e-02f, -1.32832482e-01f, -1.78899094e-01f, -1.01075329e-01f, -1.14429360e-02f, -3.12293172e-02f, -4.84368578e-02f, -7.59068057e-02f, -2.01719254e-01f, -2.09769875e-01f,
  1.18071683e-01f, -1.13285638e-01f, 4.01352532e-02f, -1.23582833e-01f, -2.37305705e-02f, -6.56351596e-02f, -1.36505365e-02f, -3.25061352e-04f, 5.94928972e-02f, -4.17269347e-03f,
  -1.91974640e-02f, 6.37051389e-02f, 1.54182479e-01f, 6.35859519e-02f, 8.58102217e-02f, 8.22770298e-02f, -2.37131473e-02f, 8.64472911e-02f, 1.72328934e-01f, 1.17912479e-01f,
  3.56791802e-02f, -3.87491547e-02f, 3.97623843e-03f, 1.06606577e-02f, -1.26504488e-02f, 8.93623233e-02f, -3.65338698e-02f, -4.34480831e-02f, -4.09459397e-02f, -3.10757387e-05f,
  2.57232159e-01f, -9.67513248e-02f, 7.19189346e-02f, 1.13474570e-01f, -1.12420537e-01f, 5.44032417e-02f, 6.35505766e-02f, -5.00094555e-02f, -1.32156357e-01f, -9.59104374e-02f,
  -9.84302461e-02f, -8.30164552e-02f, -7.71358311e-02f, 4.29340117e-02f, 1.14506623e-02f, -4.89438549e-02f, -7.99591169e-02f, -7.69862160e-02f, 6.15608618e-02f, -4.93399650e-02f,
  4.55729384e-03f, -8.86544734e-02f, -3.06283236e-02f, 2.47516204e-02f, -5.64558767e-02f, 4.22694115e-03f, -5.68800718e-02f, 6.19385280e-02f, 2.58484427e-02f, 1.05463803e-01f,
  -3.32846232e-02f, 9.45796259e-03f, -1.38773932e-03f, -5.47446832e-02f, -2.17180606e-02f, -7.81768858e-02f, -5.01158237e-02f, 4.60301451e-02f, -2.56215855e-02f, -6.14558998e-03f,
  -2.84378249e-02f, -1.56819187e-02f, 2.70929132e-02f, 7.89910331e-02f, 1.31984032e-03f, 2.78624296e-02f, -3.16973366e-02f, 1.07911550e-01f, -9.76469368e-02f, -1.33644296e-02f,
  9.09723267e-02f, -5.75612858e-02f, -7.68205523e-02f, 2.95996713e-03f, -1.60978120e-02f, 6.92622811e-02f, -1.35651268e-02f, 1.10532949e-02f, 8.69786292e-02f, 9.39109772e-02f,
  1.70072675e-01f, 7.32651129e-02f, 1.69145197e-01f, 6.35196781e-03f, 1.00510754e-01f, 4.17051278e-02f, 5.27642444e-02f, 3.91973592e-02f, 5.43444902e-02f, 1.05930649e-01f,
  1.47497114e-02f, 4.99661360e-03f, 2.61776913e-02f, 6.21568970e-02f, 1.11755997e-01f, 6.56024087e-03f, -6.32317886e-02f, 2.60973424e-02f, -6.76605105e-02f, -1.24608830e-01f,
  1.00888414e-02f, 1.36829183e-01f, 9.64063779e-02f, 1.37518480e-01f, -3.73166129e-02f, 1.40728414e-01f, 1.66639268e-01f, 2.21741736e-01f, 2.05323011e-01f, 1.43349394e-01f,
  -3.10462445e-01f, 1.09043047e-01f, -5.08734677e-03f, -1.46929650e-02f, 1.62679881e-01f, 7.33967796e-02f, 4.81465505e-03f, -1.37242034e-01f, -9.93984789e-02f, 2.45926250e-02f,
  8.13411102e-02f, -8.10722783e-02f, -5.62394783e-02f, 3.31258699e-02f, -1.11925803e-01f, 9.52778235e-02f, 1.46102697e-01f, -9.92026832e-03f, -2.96027035e-01f, -1.33763596e-01f,
  1.09141827e-01f, -6.98709786e-02f, -1.78639501e-01f, -7.80373812e-02f, 1.37693733e-01f, 6.17155321e-02f, -1.08475275e-02f, 4.78494726e-02f, 1.37976587e-01f, 3.28555346e-01f,
  9.71894339e-02f, 2.24527717e-01f, -3.99551764e-02f, -7.14515597e-02f, 9.49191526e-02f, -3.36924978e-02f, -2.25468259e-02f, 2.51079574e-02f, -3.84254195e-02f, -2.60620788e-02f,
  8.66493657e-02f, -6.01639040e-04f, 3.57224382e-02f, -1.41518237e-02f, -7.99545348e-02f, -9.43591371e-02f, -3.77949104e-02f, 2.83459062e-03f, -7.71909356e-02f, 6.84140399e-02f,
  4.57472801e-02f, 1.91560119e-01f, -5.27836122e-02f, 4.43844497e-02f, -7.58781470e-03f, 5.13251834e-02f, 7.15166107e-02f, 7.72266313e-02f, 1.63354985e-02f, -1.58879161e-02f,
  -4.60884981e-02f, 1.00765213e-01f, 8.11274573e-02f, 2.15731058e-02f, -3.85861583e-02f, 2.34765224e-02f, -4.72940766e-04f, 2.12199171e-03f, 5.67376949e-02f, -8.44902247e-02f,
  -6.95130974e-02f, 1.92805510e-02f, -3.52966599e-02f, -5.74035756e-02f, -4.17960882e-02f, 7.85567388e-02f, 1.76195540e-02f, -1.86071526e-02f, -6.21436797e-02f, -6.69293222e-04f,
  -2.04677265e-02f, 9.66322497e-02f, 3.86298331e-03f, 1.56358108e-02f, 9.93809402e-02f, -6.58313185e-03f, 5.92724197e-02f, 7.70405307e-03f, -6.96620196e-02f, 2.43453924e-02f,
  -3.18519175e-01f, 5.56144305e-02f, 3.82363982e-02f, 8.60806555e-03f, 2.26898193e-02f, -1.93298738e-02f, 3.77737992e-02f, 5.37283644e-02f, 1.35641277e-01f, -5.77960908e-02f,
  9.15074442e-03f, -1.06001817e-01f, 1.56220626e-02f, -3.50800436e-03f, -9.59395543e-02f, 2.52270307e-02f, -1.40601601e-02f, -7.05462173e-02f, -1.81765817e-02f, -1.21291983e-03f,
  -8.15231353e-02f, -2.63858020e-01f, -2.87403882e-01f, -9.45672169e-02f, -3.95196257e-03f, -1.92447171e-01f, -1.96371511e-01f, -4.51224744e-02f, -2.60451734e-01f, -4.18003857e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.46151507e-01f, 1.69681266e-01f, 8.13463032e-02f, 1.89136013e-01f, 2.11720929e-01f, 2.59581476e-01f, 3.01227242e-01f, 2.05064744e-01f, 1.07564561e-01f, 1.58090591e-01f,
  1.48635030e-01f, 3.49461213e-02f, 1.28299102e-01f, 3.35586108e-02f, 9.79364812e-02f, 1.30489960e-01f, 5.62739000e-02f, -5.62108196e-02f, -3.50228068e-03f, 1.41954511e-01f,
  7.91573152e-02f, 4.31298986e-02f, -3.92173901e-02f, 1.11654513e-01f, -1.41682746e-02f, 4.22390774e-02f, -2.79073548e-02f, -1.20501081e-02f, 5.86613156e-02f, -6.28210977e-02f,
  -1.53733909e-01f, 2.32229948e-01f, -8.52437615e-02f, -3.42733487e-02f, -5.39126992e-02f, -1.11752614e-01f, 7.05968663e-02f, -1.27203703e-01f, 8.09547976e-02f, 5.98798208e-02f,
  -1.79919619e-02f, -1.46367729e-01f, -6.01889975e-02f, -3.50958332e-02f, -6.18438087e-02f, -4.68233489e-02f, 1.27652548e-02f, 2.06610207e-02f, 7.59898126e-02f, -1.49467103e-02f,
  1.71116721e-02f, 1.17453463e-01f, 1.15043446e-01f, 4.24906202e-02f, 1.23323157e-01f, 3.53147350e-02f, 8.43552202e-02f, -7.77616426e-02f, 7.00996518e-02f, -6.79814303e-03f,
  -8.77340734e-02f, 4.49405350e-02f, 7.09734708e-02f, -4.34758961e-02f, 2.22594664e-02f, -5.04835397e-02f, -7.25731403e-02f, -1.20693423e-01f, -2.48659402e-02f, -1.10229868e-02f,
  3.10896225e-02f, 1.01597868e-01f, 6.91033006e-02f, 2.63542701e-02f, 3.06786411e-02f, -2.22636051e-02f, -3.75200585e-02f, 3.32492180e-02f, -7.71708414e-02f, 5.55999391e-03f,
  2.64141634e-02f, 7.67461360e-02f, -3.97368297e-02f, 2.52232794e-02f, 7.54599795e-02f, 1.64007824e-02f, -1.01075750e-02f, -1.01324646e-02f, 3.66997607e-02f, 3.16746011e-02f,
  -1.53928446e-02f, 4.00081538e-02f, -1.29768044e-01f, -7.80817121e-02f, 1.82926804e-02f, 4.36709151e-02f, -8.38758945e-02f, 7.89957773e-03f, -9.21204314e-02f, 2.90617310e-02f,
  5.77472001e-02f, -1.64607745e-02f, -3.95505913e-02f, -6.49229363e-02f, -4.25949991e-02f, 3.72988842e-02f, -9.74373519e-03f, 9.71450063e-04f, 1.92873869e-02f, -8.51086304e-02f,
  1.86317265e-02f, 3.14563746e-03f, 1.00476667e-01f, 1.11654498e-01f, -3.35022509e-02f, -1.68742128e-02f, 3.46921310e-02f, 3.83135229e-02f, -4.43844544e-03f, -1.20914979e-02f,
  1.30861491e-01f, -1.91813558e-01f, -7.94888139e-02f, -1.44052491e-01f, -5.12718828e-03f, 7.76988221e-03f, -4.04251181e-03f, 1.14646435e-01f, -2.59469617e-02f, -2.75845472e-02f,
  -1.40720427e-01f, 1.01812687e-02f, -8.50117358e-04f, -2.47123670e-02f, -5.82616217e-02f, -1.83084756e-01f, -1.39164016e-01f, -8.20503745e-04f, 4.09267917e-02f, 9.71389115e-02f,
  -6.80502653e-02f, -3.30008082e-02f, 7.32898638e-02f, 3.16663012e-02f, -1.29112527e-01f, 7.55320191e-02f, -1.15960181e-01f, 1.34069622e-02f, -1.10236809e-01f, -1.83559179e-01f,
  -1.27384797e-01f, 1.24372758e-01f, 6.33352548e-02f, 9.45891365e-02f, -9.50190276e-02f, 6.82040071e-03f, 6.70623481e-02f, 6.32685646e-02f, -5.30325854e-03f, -5.24556227e-02f,
  5.36229685e-02f, -2.38795467e-02f, 2.27807071e-02f, 5.98580837e-02f, -6.17567566e-04f, -4.89121750e-02f, -1.84365530e-02f, 3.87772359e-02f, 8.17549080e-02f, 2.97454931e-03f,
  -1.35601878e-01f, -5.42279780e-02f, 5.08725969e-03f, -5.50971255e-02f, 8.85315463e-02f, 1.49437319e-03f, 3.71388942e-02f, 1.03884019e-01f, -5.54380640e-02f, -4.16665152e-02f,
  -1.99049828e-03f, -4.23412286e-02f, 8.87239259e-03f, 8.69822055e-02f, 6.48674294e-02f, 1.31067280e-02f, 8.34129471e-03f, -1.50926625e-02f, 1.90595146e-02f, -3.73949744e-02f,
  -4.36838195e-02f, -3.52933928e-02f, 4.18513678e-02f, -8.34142193e-02f, -2.47621015e-02f, -4.15621959e-02f, -3.45168151e-02f, -7.18914121e-02f, -1.49048809e-02f, -1.54354144e-02f,
  1.48867387e-02f, 1.21976985e-02f, 7.78249651e-02f, 2.14201007e-02f, -2.30688211e-02f, 4.27341238e-02f, 6.82742894e-02f, 1.02649219e-02f, -5.01759015e-02f, -7.97041580e-02f,
  -1.17083505e-01f, 1.08772308e-01f, -1.53683713e-02f, 8.30852166e-02f, 2.28264574e-02f, -7.31267259e-02f, -1.02493554e-01f, -6.39039949e-02f, 5.47700562e-03f, 7.06942081e-02f,
  7.16987923e-02f, 8.96096751e-02f, -6.40797317e-02f, 5.91737730e-03f, -6.60822773e-03f, 5.50850928e-02f, -7.40789101e-02f, -8.93755108e-02f, 2.84163374e-02f, 2.00089980e-02f,
  -2.79594176e-02f, 6.30774796e-02f, 3.34038176e-02f, -7.41200848e-03f, 5.04092425e-02f, -2.53555439e-02f, 1.09636281e-02f, 4.91353385e-02f, 1.30917048e-02f, -1.39311135e-01f,
  1.06031954e-01f, -1.15045145e-01f, 9.32454765e-02f, 7.44872466e-02f, -1.90165147e-01f, -1.21020906e-01f, -5.43273613e-02f, -1.28629461e-01f, 1.44970333e-02f, -5.24629913e-02f,
  5.64317405e-03f, 4.24491130e-02f, 6.87587038e-02f, 5.08751273e-02f, 7.57536516e-02f, 4.76184934e-02f, -6.14990108e-02f, 1.61259875e-01f, 1.92934796e-01f, 2.54446585e-02f,
  1.74003337e-02f, 1.03869945e-01f, 1.80183321e-01f, 7.70832822e-02f, -4.58469577e-02f, 5.74123599e-02f, 3.15927938e-02f, 5.73119745e-02f, -4.28520754e-04f, 9.80192199e-02f,
  -6.50473014e-02f, 6.52390048e-02f, 6.08344637e-02f, 8.08933005e-02f, -6.55884296e-02f, 3.81646976e-02f, 3.64761390e-02f, 6.68581724e-02f, -4.42137234e-02f, -5.19932806e-02f,
  5.48778987e-03f, 7.65098259e-02f, -3.93300951e-02f, -3.46681103e-02f, -7.32867718e-02f, -3.32113840e-02f, 7.23265558e-02f, 1.31691083e-01f, 9.19689536e-02f, -9.05719697e-02f,
  3.75641510e-02f, 8.42177961e-03f, -1.19207494e-01f, 2.23919936e-02f, 1.85471810e-02f, -2.18444248e-03f, 3.51239480e-02f, 6.30288795e-02f, 6.50641024e-02f, -3.82205617e-04f,
  -2.16374584e-02f, 2.18461361e-02f, 1.28257554e-03f, -5.77085391e-02f, -7.62926638e-02f, 1.25687439e-02f, 3.92886959e-02f, 6.31611422e-02f, -5.15758134e-02f, 2.17970330e-02f,
  -9.89877805e-03f, 5.84509969e-02f, 1.59871280e-02f, 4.11136039e-02f, -4.48574238e-02f, -9.64164920e-03f, 2.61986791e-03f, 2.87164040e-02f, -2.99768150e-02f, -3.64524983e-02f,
  9.61546376e-02f, 8.47884715e-02f, 3.62663232e-02f, 8.77638906e-02f, 7.53115192e-02f, -5.52925318e-02f, -2.52663903e-02f, 2.32849419e-02f, -2.97479331e-02f, 4.68759350e-02f,
  -2.01161191e-01f, 1.72532842e-01f, -1.45596452e-02f, 2.28941329e-02f, -1.30140306e-02f, 9.87133011e-03f, 4.70983237e-02f, -1.28153488e-02f, -3.74231711e-02f, 5.11905365e-02f,
  -4.06948701e-02f, -3.33280005e-02f, -5.24277538e-02f, -4.47136648e-02f, 6.03546090e-02f, 1.93754565e-02f, -5.58046289e-02f, -4.43515666e-02f, 6.70616776e-02f, 4.16707620e-02f,
  5.14852963e-02f, 1.32039804e-02f, -1.15731232e-01f, -3.23465988e-02f, 9.48213972e-03f, -5.00225239e-02f, 5.76575808e-02f, -2.04017516e-02f, -3.18867899e-02f, 8.58648308e-03f,
  1.00384988e-01f, 3.04672774e-03f, -9.79520231e-02f, 1.04504853e-01f, 7.37605095e-02f, -1.16517588e-01f, -1.44497454e-01f, -2.78141163e-02f, -7.33080879e-02f, 9.96658579e-02f,
  -4.07992899e-02f, 8.56061652e-02f, 4.37003151e-02f, 3.17409225e-02f, -1.75198182e-01f, -8.73150453e-02f, -9.03539807e-02f, -1.35238305e-01f, -5.37563115e-02f, -2.71521080e-02f,
  -7.94648826e-02f, 8.85592103e-02f, -4.11588177e-02f, -9.46871191e-02f, 1.19750269e-01f, 2.24417783e-02f, -2.85468660e-02f, 7.22233653e-02f, -7.93221220e-02f, 5.03025018e-03f,
  -1.94737799e-02f, 6.78935200e-02f, 1.98502820e-02f, 3.76644805e-02f, 2.44974699e-02f, -5.01305014e-02f, 1.39945420e-03f, 2.92137507e-02f, -4.24502976e-02f, -6.40620440e-02f,
  4.29761671e-02f, -4.73017693e-02f, 9.56023410e-02f, 5.27557917e-02f, 7.13252202e-02f, -1.04675464e-01f, -6.64520487e-02f, -4.90021445e-02f, -2.48058569e-02f, -7.73056895e-02f,
  -5.43792620e-02f, -4.42548506e-02f, 2.72817556e-02f, 4.01731506e-02f, -4.13096957e-02f, -6.32890612e-02f, 7.19483420e-02f, 8.10127258e-02f, -1.06890067e-01f, -2.01576427e-02f,
  7.96166733e-02f, 4.40711901e-02f, 5.08279214e-03f, 1.40944635e-02f, 2.04337500e-02f, 3.54927406e-02f, 3.92996110e-02f, -6.71343133e-02f, 7.44677475e-03f, 4.67667729e-02f,
  2.93781806e-04f, -1.40286200e-02f, -1.90349366e-03f, -1.01415642e-01f, -5.77669479e-02f, -6.15024343e-02f, -6.61545992e-02f, -2.46901195e-02f, 1.55908000e-02f, 4.11254019e-02f,
  -4.92715696e-03f, 6.05794676e-02f, 2.50082724e-02f, -4.33295369e-02f, 5.32886758e-02f, -1.46868611e-02f, -1.55820372e-02f, -3.42461579e-02f, -5.23537509e-02f, -5.34017831e-02f,
  -4.93209250e-03f, -1.37380734e-01f, 3.78918462e-02f, 4.25898237e-03f, -5.20935515e-03f, 1.03236670e-02f, 1.08864695e-01f, 4.14362848e-02f, 9.22075808e-02f, -1.39922993e-02f,
  4.45812531e-02f, -3.40882465e-02f, -6.43850490e-03f, 5.24630323e-02f, -5.60651273e-02f, 2.91376305e-03f, 1.08688295e-01f, 6.35899231e-03f, -8.50823522e-02f, 5.36314175e-02f,
  3.26971747e-02f, -7.66787603e-02f, 1.79969007e-03f, 3.00651211e-02f, 4.88511138e-02f, -9.55365375e-02f, -6.12735674e-02f, -2.75420658e-02f, -5.72208278e-02f, -5.93762957e-02f,
  -3.21854390e-02f, 2.60260161e-02f, 1.15973897e-01f, 3.38836089e-02f, -7.67747387e-02f, 7.40128085e-02f, 2.97462866e-02f, 1.12308376e-01f, -1.40771298e-02f, 6.60447329e-02f,
  3.40921059e-02f, -9.12323818e-02f, 2.36067232e-02f, -7.24348472e-03f, -5.10860905e-02f, -3.03998832e-02f, -9.95777920e-02f, -4.28049937e-02f, -9.62660387e-02f, -3.98668796e-02f,
  3.68644670e-02f, -6.82092905e-02f, -1.34677395e-01f, -4.11689207e-02f, 2.39733126e-04f, 1.51534900e-02f, -7.11496919e-02f, -5.87745383e-02f, -1.59002317e-03f, -1.08953148e-01f,
  1.79923311e-01f, 1.56598568e-01f, -9.78552923e-02f, -3.25567126e-02f, 8.64432603e-02f, 4.88524251e-02f, -3.05573754e-02f, -3.69854122e-02f, 4.98873852e-02f, 2.67587751e-02f,
  -1.24461809e-02f, 6.27562404e-02f, -3.59271728e-02f, -1.34400604e-02f, 1.30262598e-02f, 3.31339277e-02f, 1.65507346e-02f, 4.00812142e-02f, 1.08783364e-01f, 1.30496725e-01f,
  -1.44462949e-02f, 6.21644184e-02f, 1.13846146e-01f, 1.03871979e-01f, -5.00972266e-04f, 2.29380224e-02f, 6.13503829e-02f, 7.30048865e-02f, 4.60653938e-02f, 4.40251082e-02f,
  -9.10454690e-02f, -7.19226524e-02f, 4.92120348e-02f, -7.25858808e-02f, 3.22649889e-02f, -5.71466088e-02f, 2.54915631e-03f, -6.27825260e-02f, -4.92202938e-02f, -8.80292803e-03f,
  3.64444181e-02f, -2.63395440e-02f, -2.26560999e-02f, -5.76291345e-02f, -6.67527616e-02f, 1.22910682e-02f, 3.37454863e-02f, 8.66528675e-02f, -5.42334355e-02f, -1.30448937e-02f,
  -6.39571697e-02f, 7.38080069e-02f, -1.00947460e-02f, 4.15122211e-02f, 1.53350281e-02f, 1.16373755e-01f, 1.09193429e-01f, 2.24460103e-02f, 4.19306606e-02f, 1.10276647e-01f,
  9.39756632e-02f, 2.31487565e-02f, -2.11984701e-02f, -1.03732355e-01f, -8.07867758e-03f, 1.46342460e-02f, 2.47001722e-02f, -5.81007544e-03f, 8.66641998e-02f, 1.12944379e-01f,
  1.05898671e-01f, 3.33547890e-02f, 5.14782220e-02f, 2.33175582e-03f, 2.22366024e-02f, 1.72926683e-03f, 3.85383293e-02f, 7.96276890e-03f, 8.22569057e-02f, -6.82426542e-02f,
  -1.04632765e-01f, -3.80426608e-02f, 7.88745433e-02f, 3.88820916e-02f, 3.48148458e-02f, -7.73493722e-02f, 7.78508857e-02f, 5.64948022e-02f, 5.32090366e-02f, -1.16000183e-01f,
  -1.20555706e-01f, 3.77325751e-02f, -5.02064116e-02f, 1.48702702e-02f, -9.82554629e-02f, -1.20976947e-01f, -7.42587224e-02f, -3.63085233e-02f, -7.06368685e-02f, -1.27645954e-01f,
  6.47062808e-02f, -1.91652849e-02f, -1.00864507e-01f, 2.76294574e-02f, -1.33727249e-02f, -1.28422529e-01f, -1.34167537e-01f, -5.33507802e-02f, -1.08014926e-01f, -9.05359816e-03f,
  -1.15730904e-01f, -5.85433356e-02f, -2.10230015e-02f, -7.00038334e-04f, 4.21250761e-02f, 3.26817185e-02f, -1.03604063e-01f, -9.09585357e-02f, 2.03129016e-02f, -3.15946667e-03f,
  -4.32764478e-02f, 4.48290724e-03f, 6.61872625e-02f, -1.90546853e-03f, -7.84401894e-02f, -5.66431992e-02f, 6.79184720e-02f, -5.10338917e-02f, -2.73467563e-02f, -6.43502250e-02f,
  8.23904648e-02f, -7.92354196e-02f, -1.06912673e-01f, 2.26957649e-02f, 1.76881813e-02f, 3.89775671e-02f, 6.37146309e-02f, 6.72666728e-02f, -7.82433618e-03f, 1.29371762e-01f,
  9.40566435e-02f, 1.01125561e-01f, -1.19903283e-02f, 6.68752864e-02f, 3.62585718e-03f, 1.07762694e-01f, -1.92960445e-02f, 8.65805969e-02f, 1.25418842e-01f, 1.29052132e-01f,
  7.17997700e-02f, 4.33332473e-03f, -4.66623642e-02f, 7.57439733e-02f, -4.95305732e-02f, -2.24633291e-02f, -5.57230562e-02f, -5.94131537e-02f, 1.37807615e-02f, -1.10844625e-02f,
  -3.96066420e-02f, -4.12985459e-02f, -6.21065497e-02f, 3.60450149e-02f, -1.43855315e-04f, 8.56065080e-02f, 8.64690021e-02f, -4.29387838e-02f, -5.45504168e-02f, 4.20198962e-02f,
  -5.11089005e-02f, 4.09684777e-02f, -1.63260512e-02f, -1.95340943e-02f, 7.32426867e-02f, -3.20852757e-03f, 1.97780542e-02f, 2.34381035e-02f, -3.53704840e-02f, 2.32549682e-02f,
  -9.44766626e-02f, -3.39235030e-02f, -6.99648634e-02f, 2.51257364e-02f, 4.75481786e-02f, 5.57529069e-02f, 4.95403148e-02f, 5.86833581e-02f, -3.22291888e-02f, -8.59324634e-02f,
  -6.53947219e-02f, 3.45056690e-02f, -1.23780016e-02f, 6.05461933e-02f, -8.63952786e-02f, -7.35872099e-03f, -3.28298546e-02f, -3.34664136e-02f, 3.36316675e-02f, 8.04761946e-02f,
  -9.17548779e-03f, 3.51347774e-02f, 5.27254045e-02f, 6.44227788e-02f, 3.45764533e-02f, -1.00868344e-01f, 3.53554934e-02f, 9.60544124e-02f, -2.14150641e-02f, -6.96588680e-02f,
  2.64434628e-02f, -2.72165090e-01f, -2.19380334e-01f, 4.42373520e-03f, -8.00915286e-02f, 1.83332302e-02f, 3.13731730e-02f, 6.96818233e-02f, 2.73675434e-02f, -1.50435597e-01f,
  -2.14810167e-02f, 5.65861128e-02f, 2.80806944e-02f, -6.36048615e-02f, -1.30457124e-02f, -1.04058102e-01f, -1.52879268e-01f, 1.08008936e-01f, 2.12396443e-01f, 5.18137682e-03f,
  8.57108608e-02f, -5.26546501e-02f, -7.34515414e-02f, -5.45596797e-03f, 4.05144412e-03f, 2.90071331e-02f, -4.02142741e-02f, -1.08565457e-01f, -5.26596420e-02f, -3.18485796e-02f,
  -2.24088684e-01f, -7.49639943e-02f, 1.42569793e-02f, -1.94901507e-02f, -1.01980180e-01f, 4.87876125e-02f, -7.95663819e-02f, 1.86022855e-02f, 1.60188340e-02f, -8.14030468e-02f,
  -6.71201497e-02f, -2.95924339e-02f, 1.43734301e-02f, -5.30998111e-02f, -5.94616160e-02f, 8.24060850e-03f, -1.21945590e-02f, -2.49685925e-02f, -7.86142349e-02f, 3.36492881e-02f,
  -7.53483698e-02f, -3.84545177e-02f, 6.46887869e-02f, 7.63577688e-03f, -6.09675422e-02f, 4.61719297e-02f, -1.13410853e-01f, -6.90143332e-02f, 2.80345115e-03f, -5.60436882e-02f,
  3.80933397e-02f, 7.15422817e-03f, 6.18649982e-02f, -3.85252535e-02f, -3.44799794e-02f, 2.08035503e-02f, 5.00179864e-02f, -1.52291516e-02f, 1.20447561e-01f, 2.22897399e-02f,
  -3.54588926e-02f, -7.49543682e-02f, -3.43078375e-02f, 4.33272235e-02f, -4.75439330e-04f, 9.35901403e-02f, -1.92758013e-02f, -6.72011599e-02f, 4.23223041e-02f, 5.50636463e-02f,
  2.65944991e-02f, 5.09808259e-03f, -1.54976426e-02f, -3.53488028e-02f, -3.62656116e-02f, -6.49032965e-02f, -2.31232699e-02f, 9.40805823e-02f, -1.63481534e-02f, 6.03126138e-02f,
  2.91078780e-02f, 7.98356682e-02f, 1.41292927e-03f, 1.04711272e-01f, -3.08602583e-02f, -1.90774221e-02f, 3.25827152e-02f, -7.37163126e-02f, -7.84397125e-02f, 7.78582692e-02f,
  -6.05068244e-02f, -4.60577719e-02f, 1.93995118e-04f, -6.71960711e-02f, -1.06693776e-02f, 6.37535304e-02f, -7.32732117e-02f, 1.30641954e-02f, 7.38789439e-02f, 3.61958034e-02f,
  2.95208376e-02f, 1.62094772e-01f, 1.29415497e-01f, 9.95825455e-02f, -3.15164998e-02f, 4.86474484e-03f, -8.12751800e-02f, 3.71736586e-02f, 2.80150026e-02f, -6.47328719e-02f,
  4.60733194e-03f, -1.09835848e-01f, 1.05134062e-01f, -1.99424643e-02f, -1.18511297e-01f, -1.43550053e-01f, -5.34673110e-02f, -1.17284060e-01f, 1.68171655e-02f, -1.02305114e-01f,
  2.26842647e-04f, 4.16340046e-02f, 2.55402699e-02f, 1.70276891e-02f, 2.57500121e-03f, -5.93426265e-02f, 1.42040148e-01f, 1.68561965e-01f, 4.34000753e-02f, 5.38728461e-02f,
  -6.39533475e-02f, -3.89160290e-02f, 1.08537838e-01f, -2.06258278e-02f, -5.60570210e-02f, 2.68998388e-02f, -2.92557217e-02f, 1.11131810e-01f, -4.87137511e-02f, 1.32632539e-01f,
  4.01395857e-02f, 5.02348766e-02f, 2.97204442e-02f, 2.25288402e-02f, 9.74977836e-02f, -3.87789402e-03f, -5.77024110e-02f, 1.07517175e-01f, 3.13162021e-02f, 1.12807721e-01f,
  -4.27013524e-02f, -4.06518346e-04f, 2.91337445e-02f, 2.83237044e-02f, 5.21668643e-02f, -3.85490246e-02f, -6.37581274e-02f, 1.62478536e-02f, 3.21161449e-02f, -3.25831249e-02f,
  4.83084656e-02f, -2.06420049e-02f, 2.88897031e-03f, 3.83378239e-03f, -5.29989488e-02f, 2.11837590e-02f, -3.87542509e-02f, 4.68794294e-02f, 7.28031248e-02f, -6.61067665e-02f,
  -8.63548890e-02f, 6.42394125e-02f, -2.91546248e-02f, -2.43724063e-02f, -8.30992460e-02f, -4.63262461e-02f, 1.88350044e-02f, -2.09379252e-02f, -5.95697425e-02f, -8.38048235e-02f,
  8.30785409e-02f, -3.03362645e-02f, 8.55810791e-02f, 2.82353926e-02f, -4.80788462e-02f, -6.66215345e-02f, 6.57552332e-02f, -6.72631040e-02f, -4.13186550e-02f, -7.09175766e-02f,
  -6.68932721e-02f, 2.08848268e-02f, 3.12826559e-02f, 6.17410056e-02f, 2.04135068e-02f, 4.05056663e-02f, 8.53534639e-02f, -4.74888198e-02f, -8.93871263e-02f, -1.30703608e-02f,
  4.25659604e-02f, -7.21939206e-02f, 4.19243351e-02f, -5.58236279e-02f, 6.73322356e-04f, 2.66921008e-03f, 2.85607725e-02f, -3.64734512e-03f, 5.26768491e-02f, -2.38303710e-02f,
  9.76716653e-02f, 6.89362586e-02f, -2.32316144e-02f, -6.32316917e-02f, 4.67254268e-03f, -1.98245347e-02f, 5.52869290e-02f, 6.91068694e-02f, 2.65017711e-02f, 3.29462178e-02f,
  -1.01851150e-01f, 6.77979663e-02f, -2.02793907e-02f, -7.31575936e-02f, 4.88364138e-02f, -6.75150901e-02f, 2.44472511e-02f, 1.05833583e-01f, 4.22592983e-02f, -4.26021367e-02f,
  -1.29105091e-01f, -5.60946576e-02f, -2.75701016e-01f, -2.41401240e-01f, -6.47429377e-02f, 2.06692554e-02f, 5.23830466e-02f, 1.12679027e-01f, -9.75745842e-02f, -1.91557273e-01f,
  -2.28633657e-02f, -1.11798257e-01f, -2.92963311e-02f, 1.29700303e-02f, -3.45849805e-02f, -4.59803417e-02f, -2.04908758e-01f, -1.74105793e-01f, -1.60606354e-02f, 1.14403151e-01f,
  5.36584808e-03f, -1.14726581e-01f, -9.55765694e-02f, -5.67643496e-04f, -1.13243565e-01f, -7.59223402e-02f, -1.98205411e-01f, -4.62674946e-02f, -3.26837413e-02f, -9.38959047e-02f,
  -2.69439310e-01f, -6.89112172e-02f, -2.09183339e-02f, 9.31062847e-02f, -1.31809041e-01f, 3.36583219e-02f, -7.19607100e-02f, -9.77258310e-02f, -9.01915971e-03f, -1.41310036e-01f,
  -1.38293281e-02f, 1.17363550e-01f, -1.15369864e-01f, 2.29791515e-02f, 1.03713730e-02f, -3.67092481e-03f, -7.19857868e-03f, -6.82235584e-02f, -3.37883532e-02f, 7.70306513e-02f,
  9.70568657e-02f, 8.77284538e-03f, -1.05191007e-01f, 5.03543541e-02f, 1.02743497e-02f, -6.95748553e-02f, 1.03982382e-01f, -6.83307229e-03f, 1.11296102e-01f, 2.27122698e-02f,
  5.66888824e-02f, -4.30190051e-03f, 7.66592845e-02f, -2.67193615e-02f, -2.23987494e-02f, 1.66845061e-02f, 2.99478862e-02f, -1.15751689e-02f, 1.40412170e-02f, 2.86597423e-02f,
  1.54526075e-02f, -3.82972229e-03f, 3.82108688e-02f, 1.69588365e-02f, -8.62770602e-02f, 5.67187220e-02f, -3.08672916e-02f, 3.42777409e-02f, 7.03234982e-04f, -8.93721730e-03f,
  -1.12742567e-02f, 7.85025060e-02f, -8.51059332e-02f, 6.09908737e-02f, 4.37755287e-02f, -6.53613433e-02f, 1.03400938e-01f, 1.78454164e-02f, -1.72549281e-02f, -6.30244911e-02f,
  -2.40686044e-01f, 6.06225282e-02f, -6.89046830e-02f, -2.50789579e-02f, -9.60507244e-02f, 2.34849472e-02f, -1.17237940e-01f, -3.26437838e-02f, 2.54879855e-02f, 3.70929651e-02f,
  2.58006752e-02f, -4.13028486e-02f, -4.51639257e-02f, 8.29669014e-02f, 1.30303530e-02f, -1.51926810e-02f, 9.83232707e-02f, 5.69220749e-04f, 5.76319955e-02f, 1.89673454e-02f,
  -3.66591439e-02f, -1.86049670e-03f, 6.35801554e-02f, -1.29150748e-02f, -4.48954478e-02f, -1.65609811e-02f, -7.71376267e-02f, -3.26415827e-03f, 5.63212186e-02f, -4.32694852e-02f,
  -3.34257297e-02f, 2.04809774e-02f, 3.42649482e-02f, 5.18941954e-02f, 2.02942118e-02f, 2.36321446e-02f, -1.66129351e-01f, -1.34800509e-01f, -1.17460936e-02f, -6.72153458e-02f,
  6.41921684e-02f, -6.32470325e-02f, 2.74826400e-02f, 1.00443132e-01f, 3.36347194e-03f, 3.93987261e-02f, 9.35435481e-03f, 1.10027008e-03f, -2.23515090e-02f, 1.18841708e-01f,
  1.60737976e-03f, -2.52265483e-02f, 8.90102610e-02f, 1.33351833e-01f, 1.95749253e-02f, 1.05713949e-01f, 1.06746800e-01f, 1.04693167e-01f, 1.19974248e-01f, 1.93548590e-01f,
  -2.94890348e-02f, -3.41586433e-02f, -5.28829033e-03f, 1.56439710e-02f, 1.28629029e-01f, -6.15984164e-02f, -5.14794216e-02f, -2.51902007e-02f, -3.94543782e-02f, 8.70814100e-02f,
  8.14068913e-02f, 7.32983556e-03f, -1.68533325e-02f, -4.55796681e-02f, -1.88909825e-02f, 5.80304787e-02f, 3.02716494e-02f, 5.07014729e-02f, -7.57476464e-02f, 1.59883231e-03f,
  -2.22449768e-02f, 2.20153444e-02f, -4.71044742e-02f, -6.65227547e-02f, -2.29263976e-02f, 1.25141859e-01f, 3.33041921e-02f, -3.90263926e-03f, -4.28120941e-02f, 5.16417138e-02f,
  4.53929529e-02f, 1.65567342e-02f, 2.43852902e-02f, -4.15154397e-02f, -6.12526201e-02f, 5.81757948e-02f, 1.63809843e-02f, -4.52621765e-02f, 2.55449861e-02f, 5.02268784e-02f,
  -3.95685900e-03f, -2.59666312e-02f, -2.80053690e-02f, -5.13976030e-02f, -1.45141920e-02f, 7.01430589e-02f, -3.14608291e-02f, 5.37857367e-03f, 4.86284755e-02f, -4.36313190e-02f,
  8.22395086e-02f, -4.79447059e-02f, -9.66009311e-03f, 4.98935841e-02f, -7.20156059e-02f, 5.43476045e-02f, 8.91007483e-02f, 7.29026124e-02f, 1.86028350e-02f, 8.38344097e-02f,
  -1.05899140e-01f, -5.58487773e-02f, 8.57234299e-02f, -4.69957218e-02f, -4.68867319e-03f, 7.70978406e-02f, 1.16939032e-02f, -2.96653882e-02f, 2.63237972e-02f, 6.00491092e-02f,
  -5.53509705e-02f, -1.92581285e-02f, -6.60791341e-03f, 6.74714968e-02f, 1.39798252e-02f, 4.30071279e-02f, 7.67534673e-02f, -3.30310687e-02f, -2.63043977e-02f, -4.40243147e-02f,
  -3.82090881e-02f, -7.14404285e-02f, -1.14111915e-01f, 2.52031200e-02f, -7.81164914e-02f, 8.75780359e-02f, -6.60997629e-03f, 7.32562095e-02f, -2.19595470e-02f, -8.69135037e-02f,
  -7.59432688e-02f, 6.36096392e-03f, -9.98972133e-02f, -6.53473362e-02f, -6.10287115e-02f, -1.06037602e-01f, -4.45577577e-02f, -5.80721051e-02f, -7.37842172e-02f, -5.86761758e-02f,
  2.90469695e-02f, 1.01769576e-02f, 8.77292976e-02f, 8.08060691e-02f, -2.03836709e-02f, -3.62739936e-02f, -5.76275587e-03f, -8.69948119e-02f, 3.17146815e-02f, -2.21583601e-02f,
  2.50871386e-02f, -1.95777193e-02f, -6.99900836e-02f, -1.31363496e-02f, -8.87084156e-02f, -9.84220430e-02f, -6.60543665e-02f, -4.18305174e-02f, -1.97466370e-02f, -8.57173577e-02f,
  -6.82574511e-02f, 2.06093360e-02f, 8.11350420e-02f, -2.45863441e-02f, 8.81531090e-03f, 5.68411276e-02f, -2.44206563e-02f, 5.20624667e-02f, 7.05857053e-02f, -6.42496645e-02f,
  1.12051927e-02f, 1.04251066e-02f, 4.23235781e-02f, -6.36607632e-02f, -8.08351934e-02f, -5.65843061e-02f, -4.71741706e-02f, -1.87852164e-03f, 5.32329381e-02f, -3.31670605e-02f,
  9.34914919e-04f, 4.25093388e-03f, 2.39884593e-02f, 7.21741421e-03f, 8.13397672e-03f, -1.42946339e-03f, 6.16083574e-03f, 1.90847367e-02f, -7.52321184e-02f, -4.69479039e-02f,
  -2.61029117e-02f, -3.70370969e-03f, 6.73687682e-02f, -6.71541691e-02f, 4.88534686e-04f, -3.14503424e-02f, -9.65057407e-03f, 5.84353842e-02f, -1.58420466e-02f, 2.53315438e-02f,
  7.75546879e-02f, 3.58563550e-02f, -8.16615224e-02f, -5.69011196e-02f, -6.80578500e-02f, -5.59109971e-02f, -7.13941008e-02f, 6.24568053e-02f, 6.82098940e-02f, 2.79911589e-02f,
  -5.94819598e-02f, -5.66601828e-02f, -5.04277870e-02f, 7.21351290e-03f, -8.78150687e-02f, -5.70324063e-02f, 6.94303438e-02f, 9.77974683e-02f, -9.59373266e-03f, 7.77910352e-02f,
  6.68894202e-02f, 1.05760701e-01f, -7.93660339e-03f, -7.04039335e-02f, 8.12396258e-02f, 9.34145898e-02f, -5.11780679e-02f, -6.07180670e-02f, 9.03408378e-02f, -7.89117664e-02f,
  5.22527918e-02f, -2.97983456e-02f, 5.93711399e-02f, -6.91665784e-02f, -5.45755611e-04f, 5.63591607e-02f, -7.70314559e-02f, -6.17142804e-02f, 4.20251209e-03f, 5.21226674e-02f,
  4.70296331e-02f, -4.52884212e-02f, 3.70534025e-02f, 5.17418562e-03f, 8.87239128e-02f, 1.49656665e-02f, -1.01565070e-01f, -1.11035258e-01f, 2.20358209e-03f, 3.71448323e-03f,
  -9.01865363e-02f, -4.03260626e-03f, -5.94874471e-02f, 9.93578210e-02f, -4.36798669e-02f, -1.98797345e-01f, -2.07821816e-01f, -1.27804518e-01f, -3.88538651e-02f, -2.00341716e-02f,
  3.05803143e-03f, 2.92787757e-02f, -2.75952891e-02f, -8.42773914e-02f, -2.36976549e-01f, -1.99271232e-01f, -1.71867236e-01f, -1.62357584e-01f, -1.56664357e-01f, -1.56913012e-01f,
  -1.40119955e-01f, -4.60356139e-02f, -1.27863720e-01f, -1.20579734e-01f, 4.21246104e-02f, 1.14366539e-01f, -9.55185965e-02f, 1.77874640e-02f, -1.92591920e-02f, -8.20083767e-02f,
  -4.15029526e-02f, 3.58475596e-02f, -8.64147171e-02f, 4.88289073e-02f, 1.61858443e-02f, 6.15411885e-02f, -8.99133906e-02f, -3.57543491e-02f, -3.25792804e-02f, -4.39068154e-02f,
  2.75009479e-02f, -6.65759668e-02f, -3.68668623e-02f, -1.03971539e-02f, -4.20452617e-02f, -3.24117462e-03f, -3.93179571e-03f, -1.42951254e-02f, -8.22383687e-02f, 6.16266690e-02f,
  2.78462768e-02f, -1.11197382e-01f, -4.33579870e-02f, 4.13908288e-02f, -5.11890501e-02f, 7.81751722e-02f, 4.66343500e-02f, 4.40759584e-02f, 1.03226185e-01f, 8.30148384e-02f,
  2.70200223e-02f, -6.85000047e-02f, -7.20819458e-02f, -4.35833037e-02f, -2.80782320e-02f, 5.26725762e-02f, -5.12933992e-02f, -4.78414148e-02f, 5.54897301e-02f, 1.72756277e-02f,
  -9.24523696e-02f, 1.69678160e-03f, 4.18504588e-02f, -4.38616946e-02f, -7.41662309e-02f, -9.06947777e-02f, 2.38681640e-02f, -2.81962240e-03f, -9.30396020e-02f, -1.14525426e-02f,
  6.39560819e-02f, 2.83878967e-02f, -5.95746338e-02f, 2.40857787e-02f, -4.00013141e-02f, -3.03246751e-02f, 8.30221474e-02f, -5.97429387e-02f, -2.56656413e-03f, 7.80229568e-02f,
  6.35002404e-02f, -1.60811171e-01f, 4.83721271e-02f, 5.09532616e-02f, -9.32503715e-02f, -3.17476802e-02f, -1.84415095e-02f, 8.99885520e-02f, -2.38563884e-02f, -6.28566518e-02f,
  -2.87266839e-02f, -8.01867396e-02f, -3.62069979e-02f, 1.13722822e-02f, 1.91038214e-02f, 4.99334000e-02f, -8.49207193e-02f, 3.83979939e-02f, 3.81679041e-03f, -3.45014222e-02f,
  -3.73872481e-02f, -1.44470036e-01f, -4.37231064e-02f, -5.78175224e-02f, -4.02907990e-02f, -1.27483848e-02f, -1.44945784e-03f, 9.09959450e-02f, -8.27805996e-02f, 3.55761983e-02f,
  -9.73931029e-02f, -8.74132290e-02f, 4.97235470e-02f, -2.91655548e-02f, 1.04632825e-01f, 6.58901408e-02f, -4.54218611e-02f, 3.28401215e-02f, -3.56723927e-02f, -1.74821503e-02f,
  5.70748597e-02f, 1.93103075e-01f, 1.66035488e-01f, 8.85005593e-02f, 9.22173336e-02f, 4.34874967e-02f, 1.55348405e-02f, 1.42401949e-01f, 2.14168236e-01f, 1.35948434e-01f,
  7.34758601e-02f, -6.72667697e-02f, -9.74077433e-02f, -2.01662220e-02f, 4.77324203e-02f, 1.16985343e-01f, 2.47099181e-03f, 4.49263770e-03f, -1.79210044e-02f, -8.15339163e-02f,
  2.07034275e-01f, -2.00542435e-01f, 1.69130862e-01f, -3.40121463e-02f, 2.01678257e-02f, 1.18615841e-02f, 1.00470044e-01f, -1.34293333e-01f, -1.29118964e-01f, 1.64059959e-02f,
  -1.85052659e-02f, -2.47912705e-02f, -1.09116092e-01f, -1.24819413e-01f, -8.45472366e-02f, -1.96835827e-04f, -9.49976593e-02f, -6.34781942e-02f, 3.28888930e-03f, -4.94058942e-03f,
  9.37333424e-03f, -3.42495404e-02f, 3.45695764e-02f, 9.61824283e-02f, -3.75088342e-02f, 1.74767300e-02f, -2.01281998e-02f, 1.04376622e-01f, 8.73721391e-02f, 5.29197082e-02f,
  6.56109527e-02f, -5.65307550e-02f, 6.25975579e-02f, 2.31861100e-02f, 6.29034042e-02f, 4.21107076e-02f, 7.69216418e-02f, 1.20870220e-02f, 2.79514231e-02f, 3.98726016e-02f,
  4.73577380e-02f, 1.11037731e-01f, -2.53833141e-02f, -1.60049554e-02f, -1.27340294e-02f, -2.61914097e-02f, -5.61262742e-02f, -6.77976757e-02f, 4.59083840e-02f, -2.71501765e-02f,
  -5.62982187e-02f, -4.39485386e-02f, -2.30329167e-02f, -1.85998231e-02f, -1.27356872e-02f, -2.36251559e-02f, -4.14311439e-02f, 5.24003394e-02f, -9.97388512e-02f, -1.28110936e-02f,
  1.05074264e-01f, 1.40504003e-01f, 1.64532661e-02f, -8.05748552e-02f, -9.75279976e-03f, -1.18846275e-01f, 2.62329653e-02f, -3.58157679e-02f, -1.89729650e-02f, -1.90065932e-02f,
  -8.44139457e-02f, 7.89540168e-03f, 8.23064521e-03f, -9.44487154e-02f, -2.18874793e-02f, 7.53383040e-02f, -1.89911705e-02f, 1.48031823e-02f, -4.38805036e-02f, 4.01921496e-02f,
  -1.16576001e-01f, 6.07536323e-02f, 6.35032356e-02f, 1.17341645e-01f, 9.80129465e-02f, 1.80593058e-01f, 8.47308547e-04f, 2.48041451e-02f, 1.16472796e-01f, 1.34847194e-01f,
  -2.15005398e-01f, -1.21642567e-01f, 4.55979183e-02f, 4.54025120e-02f, 1.00392215e-01f, 1.22457117e-01f, 1.07455805e-01f, -1.79970954e-02f, -2.23270734e-03f, 1.84666049e-02f,
  -7.90146121e-04f, 1.56488508e-01f, 1.98975727e-01f, 4.58435118e-02f, 1.47517547e-01f, 1.04392745e-01f, 1.51183352e-01f, 4.45674993e-02f, 3.27370912e-02f, 2.27867328e-02f,
  3.97034176e-02f, 5.82481362e-02f, -5.13352826e-02f, 6.30997270e-02f, 1.77930985e-02f, 1.54049858e-01f, -4.84293550e-02f, -8.57971385e-02f, 1.11486927e-01f, 1.11122103e-03f,
  -5.66575825e-02f, -1.50663182e-01f, 9.33418944e-02f, 5.59451096e-02f, -1.62257217e-02f, -9.08105075e-02f, 2.42753737e-02f, -1.07532339e-02f, -5.72359599e-02f, -3.60344979e-03f,
  -2.60304902e-02f, -1.52967572e-02f, 5.59662841e-02f, -1.59472565e-03f, -2.23159976e-02f, -1.01109609e-01f, 1.35706449e-02f, 2.96796672e-02f, -1.43890344e-02f, -2.10226954e-05f,
  -2.56391726e-02f, -4.27803025e-03f, -3.12281568e-02f, 8.23635459e-02f, -3.81074250e-02f, 3.05364262e-02f, 2.85157189e-02f, -9.15871710e-02f, 9.07025579e-03f, -8.04660246e-02f,
  -1.72456093e-02f, 6.05228310e-03f, 8.22124332e-02f, 6.01550378e-02f, 4.61460650e-02f, 7.51806870e-02f, -5.14841527e-02f, -3.51787135e-02f, -4.26024804e-03f, -2.80336943e-03f,
  -2.69521289e-02f, 1.71183422e-02f, -4.67397235e-02f, -7.02645853e-02f, 3.66895311e-02f, -2.12983824e-02f, 1.21040817e-03f, 8.96172896e-02f, -8.37895647e-02f, -3.63286063e-02f,
  -8.37591216e-02f, 4.41303439e-02f, 2.05113944e-02f, -5.76373795e-03f, -3.82544799e-03f, 6.94545975e-04f, 4.10675108e-02f, 4.71733399e-02f, 4.06648032e-02f, 1.75767299e-02f,
  3.81263196e-02f, 3.77945863e-02f, 1.20030306e-01f, 2.59888340e-02f, -1.78657752e-02f, -4.13237177e-02f, -2.17168592e-02f, 3.31479870e-02f, 2.71803904e-02f, 1.60829052e-02f,
  -1.08324029e-01f, 1.27213756e-02f, -9.43726450e-02f, -1.51436767e-02f, -5.65249799e-03f, -7.47780651e-02f, 4.60810494e-03f, 1.60972252e-02f, 9.09226239e-02f, 9.33340285e-03f,
  7.94655755e-02f, -5.56892157e-03f, 6.79320619e-02f, -5.98141886e-02f, -1.13734538e-02f, 3.16143371e-02f, 2.73410883e-02f, -5.01492769e-02f, 7.23080710e-02f, -8.30606520e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.97128698e-01f, 2.97865923e-02f, 3.45149487e-02f, -2.40245257e-02f, 5.63570224e-02f, -5.29660285e-02f, 1.57759205e-01f, -3.86219025e-02f, 7.66739771e-02f, 4.25704382e-02f,
  3.03216372e-02f, 1.74814805e-01f, 1.31590754e-01f, 3.12635638e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.32903937e-02f, -2.48027995e-01f, 1.98865175e-01f, -1.44969985e-01f, -1.17100932e-01f, 1.75574303e-01f, -2.11842626e-01f, 4.41586897e-02f, -1.51140600e-01f, 5.55177517e-02f,
  2.67161727e-02f, 8.34375843e-02f, -1.15250446e-01f, -1.21731848e-01f, -5.62349707e-02f, 5.21828756e-02f, -1.05426073e-01f, -2.86549237e-03f, -1.97148994e-01f, 7.23537877e-02f,
  -1.11043736e-01f, 1.38359219e-01f, -7.07515255e-02f, -1.32720303e-02f, -5.09341769e-02f, 2.84402549e-01f, 2.22807840e-01f, 1.78026304e-01f, 4.30550754e-01f, 2.14702561e-01f,
  2.61884481e-01f, 1.05299026e-01f, 4.91750464e-02f, 2.07411662e-01f, 1.62999809e-01f, -2.73712307e-01f, -1.25827268e-01f, 1.16586901e-01f, -8.14807490e-02f, -6.45973114e-03f,
  1.31072417e-01f, 2.76149899e-01f, 1.28938705e-02f, -6.94112480e-02f, 7.07336664e-02f, -3.73959206e-02f, 2.27419034e-01f, -1.23358697e-01f, -7.36625269e-02f, -4.02065396e-01f,
  -8.90828595e-02f, 2.38170505e-01f, -4.68184017e-02f, 3.55299823e-02f, -3.64765897e-02f, -8.91767740e-02f, 6.32600784e-02f, -7.09130764e-02f, 5.34287002e-03f, -2.97597144e-02f,
  -8.69445652e-02f, 2.45971177e-02f, -8.22441727e-02f, -1.12869017e-01f, 1.00440279e-01f, -1.72405615e-01f, 8.68945718e-02f, -8.11608061e-02f, -1.01425216e-01f, -7.30390847e-02f,
  -1.80478677e-01f, 2.07816511e-01f, 1.90499760e-02f, -1.00360774e-01f, 3.36001404e-02f, 9.33928564e-02f, -1.19451649e-01f, 5.64149208e-02f, -1.63403228e-01f, -2.79856631e-05f,
  -7.10731884e-03f, -5.22413589e-02f, -6.21557273e-02f, -1.61562301e-02f, -2.04358265e-01f, 5.95951267e-02f, 2.61963606e-02f, 3.02636214e-02f, 6.98919520e-02f, 2.98982617e-02f,
  1.52610525e-01f, -2.37646088e-01f, 1.39396012e-01f, 2.10728357e-03f, -5.44902757e-02f, 1.47660617e-02f, 2.58230478e-01f, 1.74347311e-01f, -1.59427509e-01f, -1.50158271e-01f,
  -1.76423714e-02f, -6.32601455e-02f, 1.00804083e-01f, 9.54341069e-02f, -7.84666166e-02f, 3.57278794e-01f, 1.79284513e-01f, 1.75959185e-01f, 5.66255003e-02f, 1.13840394e-01f,
  -1.76098898e-01f, -1.45638689e-01f, -2.64639296e-02f, 2.47532595e-02f, 6.49847910e-02f, 2.51238376e-01f, 1.13776870e-01f, -5.35137020e-02f, 2.66020838e-02f, -7.08394200e-02f,
  1.76873162e-01f, -6.92489222e-02f, 1.61742479e-01f, 2.37295553e-02f, -1.02267154e-01f, -2.29060158e-01f, -1.45143032e-01f, 2.55965237e-02f, 6.31236508e-02f, -7.22865239e-02f,
  -4.26380485e-02f, -9.56212282e-02f, 2.17315704e-02f, -1.40513182e-01f, -2.87644356e-03f, 1.99526325e-01f, -3.86097506e-02f, 2.03759987e-02f, -3.40198874e-02f, 9.69110653e-02f,
  -3.70649546e-02f, 2.76252590e-02f, -5.11388220e-02f, -1.86683267e-01f, -8.44431743e-02f, 4.53429818e-02f, 2.93021761e-02f, -4.23850194e-02f, -1.40234251e-02f, -1.27125680e-01f,
  4.26546335e-02f, -1.50459126e-01f, -3.24679259e-03f, 2.80533195e-01f, -3.99627723e-02f, 7.51623660e-02f, 2.68338799e-01f, 3.72240424e-01f, -1.41007245e-01f, 8.77325684e-02f,
  4.33600336e-01f, 4.70543355e-02f, -6.91682473e-02f, -1.84745919e-02f, -4.41587120e-01f, 1.77384093e-01f, -1.61410663e-02f, -1.69636786e-01f, 1.07733861e-01f, -1.36888757e-01f,
  7.60572478e-02f, -7.87866116e-03f, -3.03306524e-02f, -3.14916432e-01f, 1.89652294e-01f, -3.22444066e-02f, 2.30116576e-01f, -3.50956202e-01f, 3.04031540e-02f, -3.40899602e-02f,
  1.62607932e-03f, 5.73614240e-02f, -4.62577976e-02f, 6.03031479e-02f, 1.52714059e-01f, -1.33411705e-01f, 2.19207611e-02f, 1.79196335e-02f, 3.50694582e-02f, -1.40038291e-02f,
  1.87597319e-01f, -8.48401934e-02f, 3.49832922e-02f, 1.43276975e-01f, 5.38551211e-02f, -1.77135944e-01f, 3.28281932e-02f, -1.09794937e-01f, -8.25168639e-02f, 1.63826510e-01f,
  4.66586053e-02f, -1.32746026e-01f, -1.11694552e-01f, -5.03261648e-02f, -1.51904866e-01f, -1.08343191e-01f, -1.74508929e-01f, -9.64310318e-02f, -2.56070048e-02f, -4.10221666e-02f,
  -3.98615189e-02f, 1.02186792e-01f, -1.46841347e-01f, -1.74921621e-02f, -1.27352670e-01f, -6.01396337e-03f, -1.22640826e-01f, 2.39168052e-02f, -2.73697048e-01f, -1.87779982e-02f,
  -1.41146645e-01f, -2.02329978e-01f, -2.87942469e-01f, 1.19869910e-01f, 2.10226774e-01f, -1.25615656e-01f, -7.62160569e-02f, 1.09569579e-01f, -1.02952406e-01f, 1.84795320e-01f,
  -1.46732762e-01f, 7.09638670e-02f, -1.63880199e-01f, -1.93695858e-01f, 8.65676552e-02f, 1.65777653e-01f, -1.44563988e-01f, -8.43636319e-02f, -3.53461027e-01f, 4.61582298e-04f,
  6.67204261e-02f, 8.02820474e-02f, -1.57525063e-01f, 2.65338141e-02f, -9.32215527e-02f, -2.02992037e-01f, 1.91698417e-01f, -1.65510610e-01f, 4.82250191e-02f, 1.99095950e-01f,
  -1.30870327e-01f, 9.61555988e-02f, -5.62351383e-02f, -1.00896195e-01f, 3.85853834e-02f, 3.88288647e-02f, -7.02548176e-02f, 2.24379331e-01f, 2.37030559e-03f, -1.15169816e-01f,
  5.74190309e-03f, -3.50068160e-03f, 4.04964127e-02f, -4.46696617e-02f, 7.84991235e-02f, 5.28771207e-02f, -6.89073727e-02f, -1.85930431e-01f, 9.62623488e-03f, -1.12977736e-01f,
  1.60815287e-02f, 1.30479500e-01f, 1.42310649e-01f, 7.31174499e-02f, 1.01136900e-02f, -1.15055412e-01f, -1.40492216e-01f, 1.31424457e-01f, 2.04001199e-02f, -4.23188396e-02f,
  -1.15186021e-01f, -9.70163420e-02f, -3.04245830e-01f, -1.93582878e-01f, -1.40998617e-01f, -3.11742038e-01f, 4.83028544e-03f, 1.17107786e-01f, -9.80350748e-02f, -2.60697156e-02f,
  -2.92922974e-01f, 1.94534689e-01f, 1.74728841e-01f, -8.15769434e-02f, -5.93149848e-02f, 5.64436615e-02f, -1.44316524e-01f, 2.18836784e-01f, -6.29046261e-02f, 8.62546042e-02f,
  -1.80494100e-01f, 2.29991332e-01f, -1.07058607e-01f, -6.92879632e-02f, -2.77686249e-02f, 4.37554084e-02f, 1.90345377e-01f, 8.03245977e-02f, 1.20072447e-01f, -1.87021755e-02f,
  -9.49904844e-02f, -2.22225282e-02f, 5.64224692e-03f, -1.26537591e-01f, 6.23120402e-04f, -1.81225408e-02f, -1.29886463e-01f, -3.51096392e-02f, -1.96406767e-01f, -1.21330760e-01f,
  -1.16625555e-01f, -6.89808428e-02f, 8.19939375e-02f, 1.45292193e-01f, -3.62745225e-02f, -6.35263859e-04f, 1.22221872e-01f, -1.83827467e-02f, -9.13200527e-02f, 1.82001814e-01f,
  2.21255377e-01f, -5.40080182e-02f, -9.40791368e-02f, -1.84314102e-01f, -1.80048272e-01f, -6.30264357e-02f, 7.20300004e-02f, -3.30083817e-02f, -1.83459539e-02f, 4.88182940e-02f,
  1.20875882e-02f, -7.18820170e-02f, -2.18273420e-02f, 1.11208454e-01f, 3.85495275e-02f, 2.76870787e-01f, -9.05790702e-02f, 1.00944899e-01f, 2.75669605e-01f, -1.88587010e-01f,
  8.98530856e-02f, 3.67601514e-01f, -2.69556850e-01f, -4.78813127e-02f, -2.03292742e-01f, -4.62485179e-02f, -9.20272991e-02f, 2.08244026e-01f, -2.20350593e-01f, 1.63586095e-01f,
  -2.41105229e-01f, 3.16854328e-01f, -6.93747476e-02f, 2.52773076e-01f, -1.54852301e-01f, 3.44287097e-01f, 4.62480448e-03f, -8.01446140e-02f, 4.32645157e-02f, -2.60077566e-01f,
  2.57757664e-01f, 1.03347912e-01f, -1.52441666e-01f, -6.74998611e-02f, 9.78340432e-02f, -1.19157828e-01f, -6.57798126e-02f, -1.09029360e-01f, -8.89908597e-02f, -1.98763356e-01f,
  2.42881500e-03f, 7.04962462e-02f, -2.28420109e-01f, -1.66895077e-01f, -4.73151766e-02f, -1.22001655e-01f, -7.17008412e-02f, -6.01652497e-03f, 9.52285901e-02f, 7.64887547e-03f,
  1.61232486e-01f, -1.75138503e-01f, -1.28045321e-01f, -1.68507144e-01f, 2.16885686e-01f, 1.14630096e-01f, 1.77473709e-01f, 1.40986249e-01f, 1.21420451e-01f, 6.91595972e-02f,
  1.45533979e-01f, -1.17661461e-01f, 1.60158217e-01f, 1.06874846e-01f, 5.60351498e-02f, -1.35800857e-02f, 1.17363244e-01f, -5.87622151e-02f, 3.76483798e-02f, -4.80061956e-02f,
  3.25009972e-01f, -1.28535047e-01f, -1.59021784e-02f, 3.27937275e-01f, 1.10834338e-01f, -4.34128314e-01f, -1.49453059e-01f, -1.02113485e-02f, 5.79468794e-02f, -1.38254076e-01f,
  2.89976329e-01f, -1.29541293e-01f, 7.32109025e-02f, -1.53850883e-01f, 1.59713522e-01f, -2.34530810e-02f, 1.15402304e-01f, -3.62574123e-02f, 2.34719172e-01f, -1.87942907e-02f,
  3.73632275e-02f, 7.70249218e-02f, 8.85917991e-02f, -7.33598992e-02f, -1.81984618e-01f, 3.85984145e-02f, 9.97597948e-02f, 9.05989930e-02f, 4.78090867e-02f, -2.78775617e-02f,
  -5.66176288e-02f, 1.41755342e-01f, -6.03868216e-02f, 3.81387398e-02f, 9.83507186e-02f, 1.94387063e-01f, 2.79188287e-02f, -9.80352536e-02f, 1.36877134e-01f, 5.95076196e-02f,
  1.88407257e-01f, -7.39939883e-02f, 6.67580813e-02f, -2.10899450e-02f, 4.15870734e-02f, -1.77679639e-02f, 6.65442972e-03f, 1.56895481e-02f, -4.88246419e-02f, 2.47224644e-01f,
  -7.34124035e-02f, -1.60149306e-01f, -3.47759947e-02f, 4.88542840e-02f, -3.27540115e-02f, 1.53423458e-01f, -1.61510948e-02f, 2.31548604e-02f, 1.99572697e-01f, 2.11695135e-01f,
  1.50162533e-01f, -5.47698624e-02f, -5.73984496e-02f, 2.49463901e-01f, 5.46481013e-02f, -7.63369165e-03f, 2.45567068e-01f, -1.30773216e-01f, 1.15340156e-02f, 3.05921346e-01f,
  -1.77317429e-02f, -4.40344140e-02f, -1.34136826e-01f, -5.48136197e-02f, -1.51079744e-01f, 1.11475945e-01f, -3.10169518e-01f, 3.85386497e-03f, -2.53628135e-01f, -1.64365768e-01f,
  -1.40653759e-01f, 1.74242198e-01f, 9.96072814e-02f, -6.89800084e-02f, 1.42405391e-01f, -1.25360712e-01f, 1.32061228e-01f, -3.81928921e-01f, 1.33700714e-01f, -1.27415836e-01f,
  -1.14212193e-01f, -3.00142225e-02f, -5.04300557e-02f, -1.13053076e-01f, 1.31402358e-01f, 1.63531117e-02f, -9.40239727e-02f, -1.36494532e-01f, -1.26708657e-01f, -2.29355507e-02f,
  -1.35448743e-02f, 1.12786345e-01f, 9.48122218e-02f, -1.92341566e-01f, -1.39035089e-02f, 2.86084190e-02f, -4.48886817e-03f, 6.61111772e-02f, -1.63684234e-01f, -2.25779079e-02f,
  -5.35558462e-02f, -2.64676400e-02f, 1.68715537e-01f, 6.13191240e-02f, 3.32315415e-02f, 1.30916402e-01f, 3.73139940e-02f, 5.31274043e-02f, -8.59665200e-02f, -7.43763000e-02f,
  -9.14673656e-02f, -1.21257510e-02f, 1.98820159e-01f, -3.49236690e-02f, -1.66043490e-02f, -1.43719181e-01f, 1.25855684e-01f, 2.38108307e-01f, 1.05985910e-01f, -3.85897309e-02f,
  2.61974007e-01f, 3.76499563e-01f, 1.14173010e-01f, 1.39601529e-01f, 1.62147969e-01f, 1.83889456e-02f, -2.85202190e-02f, -2.44379088e-01f, -2.10329488e-01f, 2.08262205e-01f,
  1.03575792e-02f, -5.65940998e-02f, 1.28330916e-01f, 7.16453344e-02f, 2.63043076e-01f, -3.25039886e-02f, 1.07284486e-01f, -1.23062149e-01f, 1.96620096e-02f, -3.12242836e-01f,
  2.19324023e-01f, -3.54702234e-01f, 5.79003282e-02f, 1.85786977e-01f, -5.38226888e-02f, -1.16736598e-01f, -2.10264493e-02f, 5.07771708e-02f, 2.08866581e-01f, -5.11380807e-02f,
  -4.13452983e-02f, -5.54536059e-02f, -2.48714946e-02f, -1.18779102e-02f, 2.38179207e-01f, -2.33455338e-02f, 3.15322131e-02f, 6.87828213e-02f, -9.20135081e-02f, -6.23542368e-02f,
  1.59463361e-01f, -3.97619791e-02f, 1.16251141e-01f, 1.58102944e-01f, 1.75693799e-02f, 1.49997100e-01f, 4.04139347e-02f, 2.28258083e-04f, 6.19937992e-03f, -1.17194690e-01f,
  9.44863781e-02f, 9.35171023e-02f, 1.70768395e-01f, -6.58428222e-02f, 1.72951818e-01f, -2.38454584e-02f, -5.53923361e-02f, -2.08990369e-02f, 1.83739856e-01f, 1.42427653e-01f,
  -1.29962325e-01f, 1.47657841e-01f, -3.38513777e-02f, -2.70038724e-01f, 2.29135945e-01f, 3.13158900e-01f, -3.89129147e-02f, -2.40583777e-01f, 1.41417623e-01f, -2.77229249e-01f,
  -8.39471444e-02f, -9.11339447e-02f, 1.30376145e-02f, 3.90327461e-02f, -1.35677293e-01f, 5.67761324e-02f, 3.39150466e-02f, -8.65196111e-04f, 4.04824167e-01f, 1.21501923e-01f,
  5.62818646e-02f, 6.03012927e-02f, -1.26066446e-01f, -6.87253103e-02f, 2.20128655e-01f, -3.08057666e-01f, -1.69614583e-01f, 5.76106226e-03f, 1.77162677e-01f, 7.56772049e-03f,
  -8.63328949e-02f, 4.42206450e-02f, 1.00454703e-01f, 2.10491195e-01f, -1.15284637e-01f, 3.96666341e-02f, -2.55643334e-02f, -2.86312550e-02f, 3.76857743e-02f, 3.14861201e-02f,
  1.77050084e-02f, 5.44273965e-02f, -1.06274433e-01f, 1.79359287e-01f, -2.00987011e-02f, 6.82642162e-02f, 6.47147074e-02f, 2.93865532e-01f, -4.06976752e-02f, 1.14670880e-01f,
  1.89323649e-01f, 7.09149614e-02f, -2.78970227e-02f, 4.61262763e-02f, -8.89509246e-02f, -2.51068082e-02f, -1.28910318e-01f, 5.86402006e-02f, 1.42063424e-02f, 8.77318084e-02f,
  1.45996943e-01f, 9.77912098e-02f, 3.61699127e-02f, -7.46022910e-03f, 5.88538423e-02f, 1.47419199e-01f, -4.39343639e-02f, 2.55517453e-01f, 3.51064235e-01f, 1.39732450e-01f,
  1.47562742e-01f, 9.30403695e-02f, 1.31062001e-01f, 2.37154603e-01f, 1.60717089e-02f, 7.02766329e-02f, -6.84331059e-02f, 2.85706818e-02f, 4.02847491e-02f, -2.27782160e-01f,
  9.19117406e-03f, -1.02885529e-01f, -2.71168321e-01f, 4.86797607e-03f, 2.42730919e-02f, -1.90208286e-01f, 3.30592215e-01f, -8.29413310e-02f, 6.30545616e-02f, -3.59590054e-01f,
  1.73876762e-01f, 7.46818259e-02f, -1.43854365e-01f, -6.69276118e-02f, 5.97503632e-02f, 8.96417201e-02f, -2.94580329e-02f, 3.38699743e-02f, 2.40902677e-01f, -1.22507237e-01f,
  1.49326757e-01f, 9.52752307e-02f, 2.02421397e-02f, -5.50174303e-02f, 4.58560996e-02f, 1.15743577e-01f, 1.49089202e-01f, 1.99766204e-01f, -1.60471588e-01f, 1.68113604e-01f,
  -1.62335932e-01f, -1.32923856e-01f, 6.99623525e-02f, -6.30486682e-02f, 1.36206225e-01f, 1.63372055e-01f, -1.17507465e-01f, -2.04566754e-02f, -1.19621083e-01f, 6.56933635e-02f,
  -2.52418250e-01f, 1.80263549e-01f, -3.46389711e-02f, 5.32709248e-02f, 1.07895091e-01f, 2.25405648e-01f, -8.54553841e-03f, -1.02353625e-01f, -4.45399061e-02f, 2.78670080e-02f,
  4.15401049e-02f, 2.24530231e-02f, -1.69467926e-01f, 2.67357267e-02f, -1.51930526e-01f, 3.46297026e-01f, -9.81059298e-02f, 2.40815785e-02f, 5.47940657e-02f, 8.46990501e-04f,
  -1.67878103e-02f, 1.75262131e-02f, 1.16755888e-01f, 5.16547896e-02f, -1.57147780e-01f, -2.08912879e-01f, -2.08634660e-01f, -1.27666712e-01f, -1.03240632e-01f, -1.39233321e-01f,
  4.45776880e-02f, -2.33704317e-02f, 8.54837149e-02f, 1.15351994e-02f, -9.97948721e-02f, -1.22576132e-01f, -9.52079147e-02f, 5.32814078e-02f, 3.51507813e-02f, -1.42020836e-01f,
  -1.06304534e-01f, 1.01262957e-01f, -2.32020035e-01f, 1.04554497e-01f, 1.84817668e-02f, -3.25080529e-02f, -3.42445052e-03f, 1.22417528e-02f, -5.98279163e-02f, -1.03191659e-01f,
  -2.12295949e-01f, -1.12628147e-01f, 7.41693974e-02f, -3.10662203e-02f, 3.32421601e-01f, 1.07731216e-01f, -1.87637173e-02f, -8.48105103e-02f, -9.94209852e-03f, -6.44039512e-02f,
  1.34538248e-01f, 1.59902716e-04f, 3.00035924e-02f, 7.08827227e-02f, 1.09418511e-01f, -7.73414969e-02f, 1.91771433e-01f, 4.35116440e-02f, -3.20821144e-02f, -9.15758833e-02f,
  1.07474349e-01f, -2.86670923e-02f, 2.15666927e-02f, 1.65955812e-01f, -1.89865097e-01f, -1.77316487e-01f, -1.57859176e-02f, 1.49625808e-01f, 1.17152005e-01f, -1.33293957e-01f,
  1.67942628e-01f, -8.53154436e-03f, -8.09705034e-02f, -3.63594070e-02f, -1.91887364e-01f, -3.36677730e-02f, -7.20508173e-02f, -1.12460822e-01f, 4.07646857e-02f, 1.35287911e-01f,
  2.33765155e-01f, 5.11388257e-02f, -1.50645852e-01f, 1.68705776e-01f, 4.17849235e-02f, -1.89583018e-01f, 2.24149913e-01f, -2.02698246e-01f, 2.26913750e-01f, -1.35044651e-02f,
  -2.13156994e-02f, -4.83419038e-02f, 1.86644450e-01f, -3.13443094e-02f, -7.22248405e-02f, 4.96065095e-02f, 1.46793649e-01f, -1.63025886e-01f, 1.29414231e-01f, 8.84007756e-03f,
  -8.70050937e-02f, 6.12408556e-02f, 1.66500006e-02f, -1.23738453e-01f, 2.05036804e-01f, -2.42758408e-01f, 6.17486872e-02f, -5.24880104e-02f, -3.56011502e-02f, -3.83351184e-03f,
  -3.80483754e-02f, -1.75004490e-02f, -8.28484595e-02f, 8.35155100e-02f, -9.68022570e-02f, -3.10157668e-02f, -2.70064287e-02f, -2.33845711e-02f, 4.12464701e-02f, 1.56590194e-01f,
  -9.26397219e-02f, 1.27844175e-03f, -4.94192764e-02f, -8.67276490e-02f, 5.55861592e-02f, 7.35639781e-02f, -5.01563847e-02f, 2.39970237e-01f, 3.13990474e-01f, 1.22236326e-01f,
  2.62078345e-01f, 4.67021391e-02f, 2.64172614e-01f, -1.31019086e-01f, 7.36197159e-02f, 1.57458320e-01f, 1.90748215e-01f, -9.93986875e-02f, -2.44973861e-02f, 1.01203419e-01f,
  4.54020174e-03f, -1.52051300e-01f, 1.42010301e-01f, 6.22906052e-02f, -6.87159821e-02f, 1.12513252e-01f, 2.61600941e-01f, 5.85605502e-02f, 2.19585463e-01f, -1.08956605e-01f,
  1.75987091e-02f, -1.01453014e-01f, -1.80888847e-01f, 1.73719049e-01f, 5.48699200e-02f, 2.87970882e-02f, -1.03004821e-01f, 2.37792358e-02f, 1.77854210e-01f, -4.15258408e-02f,
  1.29797265e-01f, 6.83314577e-02f, 1.38122097e-01f, 8.35876986e-02f, -1.87139124e-01f, -1.23692907e-01f, 7.59493485e-02f, 2.53578536e-02f, -9.24977884e-02f, 1.51688352e-01f,
  -2.09119886e-01f, 3.35025787e-02f, -1.35191083e-01f, -2.01813325e-01f, -8.36598799e-02f, -1.08553909e-01f, -5.19841276e-02f, 4.07840572e-02f, -2.22734082e-02f, 5.95798194e-02f,
  3.41866054e-02f, 6.79852292e-02f, -2.43245512e-01f, -7.39853084e-02f, -5.41605502e-02f, 6.05833642e-02f, 1.64459571e-01f, -1.60983056e-01f, -1.28933862e-01f, -4.74101193e-02f,
  -1.36770913e-02f, -6.83720931e-02f, -2.86448915e-02f, 4.28437680e-01f, -1.13510661e-01f, -1.36016384e-01f, -4.37130891e-02f, 2.41711549e-02f, -7.31551051e-02f, 1.80388495e-01f,
  1.06786177e-01f, 9.91400853e-02f, -9.37375203e-02f, 5.04934974e-02f, 1.77123114e-01f, -2.16718838e-01f, 1.90144405e-01f, -3.89377981e-01f, -3.69783700e-01f, -1.47482648e-01f,
  2.94036348e-03f, -2.16733664e-01f, 1.73023462e-01f, 2.56520659e-01f, 1.88804476e-03f, 5.73653989e-02f, -6.54525608e-02f, -9.23586860e-02f, -1.90682560e-01f, 8.29949677e-02f,
  1.72940910e-01f, -3.01668160e-02f, -5.26173115e-02f, 1.43162198e-02f, -7.74794891e-02f, -9.05001834e-02f, -7.99405798e-02f, 2.00491473e-01f, 9.46801230e-02f, 6.15254939e-02f,
  1.27772167e-01f, 3.00584175e-02f, -3.95787023e-02f, -6.69283569e-02f, -1.32777750e-01f, -1.68152899e-01f, -7.87063912e-02f, -8.18069801e-02f, -9.79600754e-03f, -2.96716869e-01f,
  -2.03475565e-01f, 1.57431409e-01f, 8.67374055e-03f, 9.58211571e-02f, 8.36517755e-03f, -5.93612790e-02f, -1.75819874e-01f, -1.45801589e-01f, -3.32409665e-02f, 5.08882441e-02f,
  5.99976853e-02f, -1.04214877e-01f, -1.87508240e-01f, -6.00718930e-02f, -1.93307802e-01f, 1.21593401e-02f, 7.04443157e-02f, 1.60107538e-01f, -1.50719628e-01f, 3.20537955e-01f,
  -2.05653951e-01f, -7.13540390e-02f, 2.16628820e-01f, -5.06980158e-03f, 2.09847116e-03f, -1.08288363e-01f, -1.16263807e-01f, 1.04541136e-02f, 2.44941097e-02f, -1.97923854e-02f,
  2.92632133e-01f, -3.97582263e-01f, -4.08162512e-02f, -2.48221114e-01f, 1.71921045e-01f, -3.19767177e-01f, 5.17248847e-02f, 1.02314107e-01f, 2.04588085e-01f, 2.68562268e-02f,
  -4.55927514e-02f, -3.03716678e-02f, -3.43209729e-02f, -9.22911763e-02f, -6.14287481e-02f, -8.84124860e-02f, 1.74284697e-01f, 5.47931455e-02f, 3.40060592e-02f, -2.49935221e-02f,
  5.16790003e-02f, 1.28818259e-01f, 1.12003632e-01f, 7.99051896e-02f, -9.44527462e-02f, -5.35033382e-02f, -1.47610502e-02f, 2.35796288e-01f, -4.19646949e-02f, -8.74304399e-03f,
  1.11296766e-01f, -1.73807576e-01f, 1.28990903e-01f, 1.58891603e-01f, 2.18338922e-01f, -2.08589248e-02f, 1.03453502e-01f, -1.34667516e-01f, 7.68209696e-02f, 2.00510323e-01f,
  -7.40450174e-02f, -4.59462740e-02f, 7.87748173e-02f, -8.94061625e-02f, 1.14640094e-01f, 1.51461303e-01f, 1.16180114e-01f, 4.53085527e-02f, 1.16004057e-01f, -1.36454046e-01f,
  1.20878145e-01f, -2.75320202e-01f, -1.47817180e-01f, -7.28585720e-02f, 4.93428037e-02f, -1.15146138e-01f, -3.19429785e-01f, -1.54652476e-01f, -8.64330158e-02f, -4.46414575e-02f,
  3.84937853e-01f, -2.08906725e-01f, -1.65656149e-01f, 8.42833072e-02f, -2.51023639e-02f, 7.51593942e-03f, 9.32116136e-02f, -8.70453045e-02f, 2.17594847e-01f, 3.40243727e-01f,
  8.27398598e-02f, -9.90846679e-02f, 1.08018294e-01f, -1.64187744e-01f, -1.51339561e-01f, -2.57517755e-01f, 1.96588356e-02f, 9.47591811e-02f, -1.61200598e-01f, -8.95758495e-02f,
  -2.03680545e-01f, 4.22772132e-02f, -2.76931614e-01f, -7.88989514e-02f, -8.43876600e-02f, 4.73965481e-02f, -1.58158079e-01f, -1.72709078e-01f, -5.36122471e-02f, -5.46678230e-02f,
  1.37816355e-01f, -2.49438405e-01f, 1.47991061e-01f, -1.57201678e-01f, 6.67108893e-02f, 1.49989286e-02f, 5.83591014e-02f, 1.69876486e-01f, -7.52413133e-03f, -2.27412567e-01f,
  -1.11769646e-01f, -1.74081653e-01f, -4.66552600e-02f, -3.52494903e-02f, 1.44104436e-01f, 1.34242475e-01f, -1.08160958e-01f, -1.04057625e-01f, 2.25344263e-02f, -1.11463390e-01f,
  2.89183892e-02f, 1.83452498e-02f, -1.18744679e-01f, 2.17817025e-04f, -9.71165821e-02f, -7.82385767e-02f, -1.93213262e-02f, -1.39998823e-01f, -2.36380592e-01f, 5.79296201e-02f,
  -9.74864662e-02f, -8.83616582e-02f, -4.34025824e-02f, 6.66655824e-02f, 9.14788917e-02f, 4.10968810e-02f, -2.38114998e-01f, 9.28456038e-02f, -3.19634259e-01f, 7.20333606e-02f,
  2.71431655e-01f, 1.46648943e-01f, 1.13906130e-01f, 1.15417100e-01f, -2.30965450e-01f, -2.97700092e-02f, 1.25062451e-01f, -1.62471831e-01f, -1.49985760e-01f, -1.10292479e-01f,
  6.66817650e-03f, 3.35001573e-02f, -1.93842247e-01f, -8.82744789e-02f, 1.61551878e-01f, 1.83608010e-01f, 4.72910553e-02f, -1.49123389e-02f, -3.37307341e-02f, -1.43429413e-01f,
  5.97653911e-02f, -1.47929238e-02f, 4.49100845e-02f, -1.49077594e-01f, -2.02219002e-02f, -1.13199674e-01f, -1.36851281e-01f, 1.50748298e-01f, 4.78859022e-02f, -2.03399248e-02f,
  4.43567559e-02f, 5.29807657e-02f, -1.44769982e-01f, -1.68643937e-01f, -1.62175879e-01f, -6.60176724e-02f, -8.85241851e-02f, 1.78714797e-01f, -7.55833602e-03f, -8.17328542e-02f,
  9.55779031e-02f, 1.22355789e-01f, -1.63106367e-01f, -6.75472096e-02f, 2.28219572e-02f, 1.00840919e-01f, 9.53009650e-02f, -5.94849549e-02f, -1.22790476e-02f, -3.24575067e-01f,
  -1.42651916e-01f, -8.45922753e-02f, -8.65773577e-03f, 1.88151255e-01f, 3.45102511e-02f, -2.21039280e-01f, -1.40490711e-01f, -6.30914420e-02f, 1.13233462e-01f, 9.34073851e-02f,
  -2.10366368e-01f, 3.11710447e-01f, -2.18743891e-01f, 3.97195041e-01f, 3.06176186e-01f, 2.75956273e-01f, -1.41088590e-01f, 2.03579038e-01f, -2.63050228e-01f, -1.50273353e-01f,
  -2.01397985e-01f, 1.27429694e-01f, -2.64087897e-02f, -9.34648961e-02f, 5.85652143e-02f, -4.47876938e-02f, -6.53454736e-02f, -1.66142344e-01f, -1.03561863e-01f, 1.45640180e-01f,
  -1.61299810e-01f, -4.45217192e-02f, -8.74707103e-02f, -1.31502643e-01f, -1.15900829e-01f, -1.00122176e-01f, -1.75878346e-01f, -3.60204987e-02f, 1.89555362e-02f, 1.69903070e-01f,
  3.21888104e-02f, 8.12803805e-02f, 9.10444409e-02f, 1.31077409e-01f, -1.83949158e-01f, -1.01633832e-01f, -2.93267909e-02f, -1.59204930e-01f, -7.41124302e-02f, 6.07972294e-02f,
  -6.49070516e-02f, -1.38261855e-01f, -5.26391789e-02f, 1.61880598e-04f, 1.36457339e-01f, -7.93672726e-02f, -1.70076862e-01f, -5.22064157e-02f, -3.12137362e-02f, 9.86475274e-02f,
  -1.32663414e-01f, -1.44001335e-01f, -8.55879635e-02f, 1.94971055e-01f, -1.38629913e-01f, -8.06119964e-02f, -1.17164515e-01f, -3.34872097e-01f, 1.14244275e-01f, -1.28017217e-01f,
  7.13264942e-03f, 1.80340379e-01f, 1.09716050e-01f, -2.29027495e-01f, 9.01855752e-02f, -1.29793644e-01f, 2.49787003e-01f, -1.28834188e-01f, -7.95862228e-02f, -2.01120436e-01f,
  4.65277918e-02f, -1.46378756e-01f, 3.71044986e-02f, 3.65910530e-01f, -7.17819929e-02f, 1.71959028e-01f, -2.00601548e-01f, 8.33229944e-02f, 8.30063075e-02f, 4.80203032e-02f,
  -8.57569501e-02f, -5.40386401e-02f, -1.07813448e-01f, -8.70372579e-02f, 1.85345426e-01f, 1.97850481e-01f, 7.69065097e-02f, 8.91293362e-02f, -6.06968515e-02f, 8.30483437e-02f,
  1.14251703e-01f, 2.40209084e-02f, -8.35748464e-02f, -1.49866462e-01f, 5.24438694e-02f, -6.59541786e-02f, -5.24610057e-02f, -9.57037956e-02f, -1.07922651e-01f, -5.40367588e-02f,
  -1.14636950e-01f, 1.30536944e-01f, 9.01729017e-02f, 1.00224830e-01f, 8.19906071e-02f, 6.08940348e-02f, 5.44362254e-02f, -1.24734022e-01f, 1.31221503e-01f, 1.95785508e-01f,
  -6.96011493e-03f, -9.03365240e-02f, 1.82966411e-01f, 4.61226441e-02f, 1.23909540e-01f, -8.08333084e-02f, 6.89814314e-02f, -2.50012368e-01f, -1.06451608e-01f, 1.97632954e-01f,
  -1.90401986e-01f, -1.70983866e-01f, 2.64838040e-01f, -2.67535895e-01f, 2.09899113e-01f, -3.21089983e-01f, 1.94109716e-02f, 2.32755747e-02f, -9.47189182e-02f, 9.61275473e-02f,
  9.27357748e-02f, 5.08501828e-02f, 2.76627094e-01f, -6.56792596e-02f, 1.23291627e-01f, 1.79488659e-01f, 2.39786878e-02f, -2.32599929e-01f, 1.14172608e-01f, -1.89864896e-02f,
  -7.05270329e-03f, 1.04128920e-01f, 6.81881458e-02f, -4.00011539e-02f, 8.39417055e-02f, -1.39858201e-02f, -2.76260674e-02f, 1.07937105e-01f, -1.95614606e-01f, -2.13274937e-02f,
  1.00083053e-01f, -3.77297290e-02f, 7.95590058e-02f, 1.11437008e-01f, 3.94825265e-02f, 6.56676143e-02f, 8.76399502e-02f, -3.50847840e-03f, -9.62645411e-02f, 4.72342446e-02f,
  -1.33455237e-02f, 2.44898155e-01f, 1.96753457e-01f, 4.71938821e-03f, -1.48540989e-01f, 2.30365079e-02f, -3.83521393e-02f, -7.76842684e-02f, -1.88365683e-01f, -1.03638865e-01f,
  -1.16774723e-01f, 1.50295617e-02f, -1.89942524e-01f, 1.38156578e-01f, -3.73868784e-03f, -9.06041451e-03f, -5.11767296e-03f, 1.95382871e-02f, -2.96097361e-02f, 3.47262204e-01f,
  -2.77834952e-01f, 3.18216711e-01f, 1.00026699e-02f, -1.95082977e-01f, -4.95230183e-02f, 4.73389894e-01f, 1.74261883e-01f, 9.12722200e-02f, -4.98166308e-02f, 1.62976891e-01f,
  -3.59616131e-01f, 2.18170121e-01f, 1.28962621e-02f, -7.33559057e-02f, -7.69911259e-02f, -2.24362954e-01f, -3.50722253e-01f, 2.05647759e-02f, -2.23174229e-01f, -2.22659230e-01f,
  9.13782697e-03f, -5.20140454e-02f, 1.72757998e-01f, -1.38174206e-01f, 8.92008469e-03f, -7.67359063e-02f, -2.57935941e-01f, 2.45505758e-02f, -3.10718771e-02f, -1.49848342e-01f,
  -1.28906751e-02f, -4.08347473e-02f, 1.00120850e-01f, -1.09252267e-01f, -3.87104712e-02f, -1.76940680e-01f, 1.57249525e-01f, 5.57173267e-02f, -1.12196594e-01f, 2.00634420e-01f,
  -9.27163735e-02f, 8.29116106e-02f, 4.23851423e-02f, -2.14489952e-01f, 1.65521890e-01f, -2.10676998e-01f, 7.05729588e-04f, -7.22984299e-02f, -1.32055450e-02f, 1.07537806e-01f,
  9.35038626e-02f, -5.12098223e-02f, 1.59408242e-01f, 7.01881573e-02f, 7.69607723e-02f, 1.44357979e-01f, 1.05563290e-01f, -1.95813447e-01f, -6.17747866e-02f, -7.02024475e-02f,
  -1.65292934e-01f, 5.93198417e-03f, -1.75511420e-01f, -1.45775482e-01f, 2.15968806e-02f, 3.59882712e-01f, -9.86091048e-02f, -2.88740546e-01f, 2.09766433e-01f, 7.91378617e-02f,
  -3.28764826e-01f, 2.00477764e-01f, -1.46553084e-01f, 2.77604401e-01f, 6.77467212e-02f, -1.92547396e-01f, 2.40987465e-01f, -1.66473076e-01f, 1.89613670e-01f, 1.25519987e-02f,
  -3.88328791e-01f, -3.96872945e-02f, -1.10089906e-01f, -3.10434010e-02f, 1.87993661e-01f, 2.22512841e-01f, -9.62608457e-02f, 1.94848910e-01f, 1.18277624e-01f, -5.23959510e-02f,
  -1.70419842e-01f, 1.60593897e-01f, 6.22270852e-02f, 1.83599010e-01f, -5.37483320e-02f, -1.62034586e-01f, 1.33421898e-01f, -1.11162052e-01f, 7.17828423e-02f, -8.21105912e-02f,
  -1.65137365e-01f, 9.55112875e-02f, -1.14290707e-01f, 1.71209827e-01f, 5.47561981e-02f, 4.73060049e-02f, 1.54289782e-01f, 5.03613241e-03f, 8.75836834e-02f, 4.81712669e-02f,
  -1.56489350e-02f, 9.64434594e-02f, 3.37673835e-02f, -4.25632782e-02f, -9.04475600e-02f, -4.26876778e-03f, -1.34889215e-01f, 1.68750565e-02f, -6.63100556e-02f, -1.54818237e-01f,
  -1.25578836e-01f, -4.91470583e-02f, 4.05594185e-02f, -2.43568812e-02f, 1.76536381e-01f, -5.11026978e-02f, 2.05443185e-02f, -1.76549673e-01f, -1.43854529e-01f, -1.05744310e-01f,
  -1.03814356e-01f, -2.45829951e-02f, -1.84673876e-01f, 1.25314847e-01f, -1.37698233e-01f, -9.71973538e-02f, -8.66599232e-02f, 6.97446689e-02f, 9.33686569e-02f, 2.00374216e-01f,
  2.06698310e-02f, 1.74692675e-01f, -2.90903330e-01f, -1.24172285e-01f, 1.61994129e-01f, 1.24749236e-01f, -7.40084052e-02f, 1.71685830e-01f, -2.55805016e-01f, -2.19408460e-02f,
  1.54831499e-01f, -5.88169619e-02f, 1.70679465e-01f, -5.24754869e-03f, 6.18935525e-02f, 2.16633920e-02f, 1.40007704e-01f, -2.52941474e-02f, -1.42686963e-01f, 3.36814336e-02f,
  -7.93101192e-02f, 1.02451175e-01f, -4.49188128e-02f, -1.64343059e-01f, 1.50394157e-01f, -6.71094134e-02f, 7.05009550e-02f, 2.67804325e-01f, 5.34489043e-02f, -2.97170449e-02f,
  1.37768425e-02f, -1.08431540e-01f, 1.59458727e-01f, -1.92852080e-01f, 1.71517376e-02f, -1.20890066e-01f, -3.69615704e-02f, -6.94968030e-02f, 1.09947160e-01f, -5.97623624e-02f,
  5.02449833e-02f, 1.60328999e-01f, -6.45568967e-02f, -2.30022836e-02f, 1.26842096e-01f, -1.07573964e-01f, -2.84879822e-02f, 1.10422336e-01f, 9.31984093e-03f, 4.95746657e-02f,
  -1.00130305e-01f, -1.90749779e-01f, -2.02912539e-01f, 1.85085520e-01f, -2.06315801e-01f, -3.80318612e-01f, 1.25670373e-01f, 9.94347632e-02f, -4.18715030e-01f, -1.98243737e-01f,
  -2.44243175e-01f, 2.55051315e-01f, 2.18879238e-01f, -2.57555023e-02f, -9.77093279e-02f, 7.51490891e-02f, -2.22580358e-01f, 9.17801410e-02f, -1.52315050e-01f, 2.88031437e-02f,
  -5.79038486e-02f, 1.71210423e-01f, -1.99609473e-01f, -4.37155366e-02f, -2.24269897e-01f, 2.13052511e-01f, 1.27635896e-02f, -2.53383458e-01f, -4.87339199e-02f, 1.39353452e-02f,
  -2.42740568e-02f, -1.34148732e-01f, -1.08813681e-01f, 5.87915778e-02f, -1.97012007e-01f, 1.28325686e-01f, -7.01274425e-02f, 1.34910658e-01f, -2.11419523e-01f, -1.33615702e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.31246194e-02f, 2.12281853e-01f, 7.12607056e-02f, -6.53805286e-02f, 2.48524230e-02f, 3.74374427e-02f, -1.83373064e-01f, -1.69471607e-01f, -2.12549255e-03f, 4.45897784e-03f,
  1.68721214e-01f, 1.12220317e-01f, -1.22914076e-01f, 9.35526863e-02f, 8.19466636e-02f, -7.92755410e-02f, 1.16161123e-01f, 2.13121131e-01f, 4.53311801e-02f, 6.24237843e-02f,
  9.59545299e-02f, 1.21296141e-02f, -1.06239937e-01f, 1.20948128e-01f, -3.57752666e-02f, -2.47546315e-01f, 1.11861289e-01f, -3.64444070e-02f, -1.91048294e-01f, -1.35710895e-01f,
  1.03267878e-01f, -1.42509602e-02f, -3.09168905e-01f, 7.03598261e-02f, 1.17571935e-01f, -2.01299437e-03f, 2.45464012e-01f, 6.47476539e-02f, 1.95924506e-01f, 1.12642348e-01f,
  -1.30830973e-01f, -1.67549938e-01f, -5.47425561e-02f, -2.89213797e-03f, 4.44270670e-03f, -2.15116460e-02f, 9.69462842e-03f, 1.42447755e-01f, 9.90965813e-02f, 2.75921077e-01f,
  6.76182956e-02f, 2.78851073e-02f, -7.99350664e-02f, 1.20729186e-01f, 5.24676852e-02f, -2.66000889e-02f, -1.36256041e-02f, -3.20728086e-02f, -1.39507592e-01f, 1.81254789e-01f,
  1.00135989e-01f, 1.76075801e-01f, 3.43546793e-02f, -1.13300264e-01f, 1.68411080e-02f, 1.79319143e-01f, 1.12547725e-01f, 7.83874765e-02f, 2.16106698e-02f, -6.42963946e-02f,
  1.37359530e-01f, -6.02100231e-02f, 1.38764262e-01f, 7.29137585e-02f, -2.55467165e-02f, -5.51212281e-02f, 1.18460327e-01f, 9.20225531e-02f, 5.30884005e-02f, 2.91044861e-01f,
  6.26475289e-02f, 1.75663546e-01f, 1.78164572e-01f, 1.60080194e-01f, 1.06125914e-01f, 7.73146227e-02f, 4.45582680e-02f, 8.36978108e-02f, -1.06869310e-01f, -1.59745187e-01f,
  -1.60608850e-02f, -2.87108980e-02f, -9.01433825e-02f, 9.32042375e-02f, -1.78970665e-01f, -2.50486910e-01f, -5.03265299e-02f, -3.15496892e-01f, -6.84998930e-02f, -6.35511130e-02f,
  2.93745041e-01f, -9.58613306e-02f, -7.56261647e-02f, -7.05438107e-03f, -6.60919771e-02f, -2.64576912e-01f, 2.02761263e-01f, -1.89338341e-01f, 1.09816387e-01f, -6.70257816e-03f,
  -2.11126089e-01f, 1.22535884e-01f, -5.46250567e-02f, -1.85128618e-02f, -5.60923703e-02f, -4.74377051e-02f, 1.83797926e-02f, 8.98679271e-02f, -1.64758638e-01f, 3.87102328e-02f,
  -8.12093690e-02f, -3.82449515e-02f, 2.19165925e-02f, 1.29050195e-01f, -8.92978683e-02f, 7.41563588e-02f, -3.14847892e-03f, 1.37885377e-01f, 4.63751033e-02f, 4.92019281e-02f,
  -1.15145832e-01f, -1.32983655e-01f, -8.91994983e-02f, -1.42186298e-03f, 1.47926778e-01f, 1.66819960e-01f, 1.75724059e-01f, -1.30479068e-01f, -1.15405813e-01f, 2.80655324e-02f,
  1.52869806e-01f, 1.85787261e-01f, -5.14592342e-02f, 1.38107985e-01f, 9.78982821e-02f, 6.72416538e-02f, 5.31312414e-02f, -2.73074061e-02f, -6.26529679e-02f, 2.50422526e-02f,
  -1.24391966e-01f, 4.99700978e-02f, -1.57588139e-01f, -5.25554679e-02f, 6.76414277e-03f, 1.33598238e-01f, -2.16667354e-01f, -2.92331073e-03f, -1.31545261e-01f, 1.76795974e-01f,
  1.25873998e-01f, 2.03410178e-01f, -1.83715507e-01f, 2.62959450e-01f, -1.91142038e-01f, -9.10322666e-02f, -1.16661880e-02f, -3.24698016e-02f, 2.29603685e-02f, -1.01889513e-01f,
  -7.72917271e-02f, 4.27556485e-02f, -1.43461183e-01f, -6.51155487e-02f, 4.04351354e-02f, 6.37948588e-02f, -1.90683305e-01f, 1.01821125e-01f, 2.25272492e-01f, -1.06284088e-02f,
  -2.30594371e-02f, -1.82466749e-02f, -3.06756832e-02f, -1.15326336e-02f, -5.65622412e-02f, -6.25907034e-02f, -2.98119783e-02f, 2.88887694e-03f, -5.40895993e-03f, -2.21531782e-02f,
  1.05632819e-01f, 1.69251800e-01f, 1.90388724e-01f, 1.44465953e-01f, -1.79806072e-02f, -1.65599510e-01f, -6.18254356e-02f, -1.86331626e-02f, -2.07657702e-02f, 1.13900810e-01f,
  2.29873620e-02f, -1.40292183e-01f, -1.10702418e-01f, 2.11151958e-01f, 5.97187392e-02f, 1.99918494e-01f, -4.73137759e-02f, 1.19286701e-01f, 1.53954970e-02f, -3.72308157e-02f,
  6.13216981e-02f, 1.55023083e-01f, -2.46291724e-03f, 3.91426422e-02f, -3.37259173e-02f, 3.59872356e-02f, -4.50851396e-02f, -3.07180360e-02f, -1.34430468e-01f, -8.26695003e-03f,
  2.43366230e-02f, 4.38552462e-02f, -1.92788154e-01f, 1.63611099e-01f, 3.06343496e-01f, -2.94132009e-02f, -8.20060223e-02f, 1.49852544e-01f, -9.30236503e-02f, 7.68354237e-02f,
  -9.07278359e-02f, 2.03251749e-01f, -1.71992749e-01f, -1.67614311e-01f, -8.24476033e-02f, 1.70269921e-01f, 8.42081755e-02f, 3.93578339e-05f, -2.37883002e-01f, -2.81205103e-02f,
  1.22710302e-01f, 2.70050243e-02f, 2.00232640e-01f, -8.67556632e-02f, 7.99769983e-02f, -9.05087739e-02f, -6.79386258e-02f, -1.28757864e-01f, 8.04555118e-02f, -7.60463178e-02f,
  -6.00519881e-04f, -8.04245323e-02f, 3.03255618e-02f, -6.91291550e-03f, 1.99728519e-01f, 2.57452756e-01f, -8.01392719e-02f, 3.02501768e-01f, -1.04474992e-01f, 1.72482952e-01f,
  1.17579721e-01f, 1.37734070e-01f, 1.04039244e-01f, 1.25687644e-01f, 7.05626756e-02f, 2.81790078e-01f, 9.37509164e-03f, -6.73498735e-02f, 9.68382135e-02f, 1.07097835e-03f,
  1.83535479e-02f, -2.97943670e-02f, 5.62598445e-02f, -6.52286038e-02f, 1.02265410e-01f, 3.39143127e-02f, -6.42557889e-02f, 1.81690797e-01f, 2.02856734e-01f, 1.41334847e-01f,
  -8.16743672e-02f, 1.81543007e-01f, -2.36526191e-01f, 1.67809576e-01f, -3.35007533e-02f, 8.67906511e-02f, -1.80763118e-02f, 8.05981308e-02f, 9.95609239e-02f, 9.87472162e-02f,
  1.60958663e-01f, 2.53442317e-01f, -2.32173428e-01f, 1.63706586e-01f, -1.84224710e-01f, -2.59865761e-01f, 1.03394784e-01f, -1.47400782e-01f, -2.85718173e-01f, -1.13292329e-01f,
  -2.89484769e-01f, 5.48046175e-03f, 2.00331360e-01f, 1.11913584e-01f, 4.72269841e-02f, 7.11186379e-02f, -4.98555116e-02f, -1.99044514e-02f, 8.65994394e-03f, -1.44188762e-01f,
  1.71789341e-02f, 1.65528432e-01f, 2.13827342e-02f, -1.15199842e-01f, 1.91293716e-01f, -5.11380471e-02f, -1.31186638e-02f, -9.91108362e-03f, -4.81534675e-02f, -4.24450524e-02f,
  1.51421458e-01f, -7.11705089e-02f, 1.00816965e-01f, 7.34493583e-02f, -4.72815372e-02f, -3.16787101e-02f, -1.48120860e-03f, 1.21982191e-02f, 4.47138958e-02f, -1.66811198e-02f,
  -5.12009561e-02f, 1.17992140e-01f, 6.70478940e-02f, 1.38617270e-02f, -7.60451332e-02f, 9.04689282e-02f, -9.67603177e-02f, -2.44928920e-03f, -2.55590538e-03f, 6.55364543e-02f,
  -3.46604474e-02f, -1.23982064e-01f, 3.08641959e-02f, 1.15117349e-01f, -2.14477070e-02f, 1.37933835e-01f, 1.81371886e-02f, 2.04777777e-01f, 7.20215738e-02f, -1.07847840e-01f,
  2.87333243e-02f, 1.03640653e-01f, -9.06071812e-02f, 1.58571348e-01f, -1.32377028e-01f, 1.90566733e-01f, 3.82025633e-03f, -1.39138013e-01f, -8.10630918e-02f, 9.49436277e-02f,
  1.24736242e-01f, -6.07844181e-02f, -1.56617939e-01f, -9.97222513e-02f, -1.14560395e-01f, -1.25940561e-01f, 2.90160701e-02f, -4.02805060e-02f, -8.09396878e-02f, 2.94193216e-02f,
  -1.52837550e-02f, 6.56076968e-02f, -7.85891190e-02f, -6.91420734e-02f, -2.21463330e-02f, 7.92971477e-02f, 4.41273078e-02f, -4.52079959e-02f, 2.09566385e-01f, -1.43157970e-02f,
  1.18466035e-01f, 1.44806877e-01f, 1.12922452e-01f, 1.31355226e-01f, 1.43832050e-03f, 8.44503790e-02f, 6.72889054e-02f, -5.81161045e-02f, 1.40780196e-01f, -1.00002073e-01f,
  -8.97478685e-02f, -9.85201225e-02f, 1.44529358e-01f, 4.12374083e-03f, 6.15485981e-02f, 1.27017712e-02f, -4.29700464e-02f, -6.90910220e-03f, 8.45112279e-02f, 9.55012515e-02f,
  4.49204519e-02f, 1.58612803e-01f, 5.58174513e-02f, -1.80660971e-02f, 3.37001346e-02f, 4.48884480e-02f, 1.62565738e-01f, 5.33068292e-02f, 1.18958496e-01f, 4.03796136e-02f,
  -6.78334087e-02f, -3.43878679e-02f, 7.80977383e-02f, -9.31625627e-03f, 5.67847211e-03f, -7.23600984e-02f, -1.71032012e-01f, -2.33363211e-02f, 3.09439171e-02f, -1.46103799e-01f,
  3.82144079e-02f, 5.74891940e-02f, 1.41581260e-02f, -8.93546920e-03f, -1.33251548e-01f, 8.20350498e-02f, 1.61147323e-02f, -1.00444295e-01f, 1.18589334e-01f, 1.55137196e-01f,
  9.20359120e-02f, -1.84424371e-02f, -3.39077935e-02f, -1.60731584e-01f, 1.39752761e-01f, 6.02655811e-03f, -8.34866837e-02f, 9.29258466e-02f, 5.05421497e-02f, 8.54099616e-02f,
  -5.30405082e-02f, -7.06335455e-02f, 7.52367750e-02f, 9.93500277e-02f, 9.50697288e-02f, 1.51548043e-01f, -1.40583434e-03f, 1.49668595e-02f, -3.16412859e-02f, -5.55260442e-02f,
  6.57627359e-02f, 1.47657711e-02f, 2.90086097e-03f, -4.01813611e-02f, -1.22829251e-01f, 1.75232843e-01f, 6.57068267e-02f, 1.36529714e-01f, 1.36679307e-01f, -6.70933072e-03f,
  1.93164781e-01f, 5.49481884e-02f, 2.76962277e-02f, 8.28139707e-02f, 1.88375145e-01f, 1.95567116e-01f, -2.72129066e-02f, -3.87116484e-02f, 1.11868232e-01f, 1.89562634e-01f,
  3.62003967e-02f, 1.39021054e-01f, 8.01112130e-02f, -1.55365570e-02f, 7.64699653e-02f, -9.09056515e-02f, 2.88224667e-01f, 1.64986312e-01f, 9.50744450e-02f, 3.20616364e-02f,
  1.29743427e-01f, 2.08137318e-01f, -1.17389478e-01f, -1.38452917e-01f, -2.15261966e-01f, -2.75650844e-02f, -2.36317758e-02f, -4.86050211e-02f, 1.07767895e-01f, 2.33230233e-01f,
  1.09923959e-01f, 1.12207532e-01f, 4.48140502e-02f, 1.09109059e-01f, 5.50334528e-03f, 1.10302143e-01f, -1.64805248e-01f, -7.33857602e-02f, 2.24240020e-01f, 1.82790346e-02f,
  1.43883616e-01f, 6.73712045e-02f, -1.36483267e-01f, -5.02755046e-02f, 2.22742125e-01f, -1.16234325e-01f, 1.35574624e-01f, -9.02534574e-02f, 2.86434218e-02f, 1.40768170e-01f,
  -3.10486294e-02f, -3.30913439e-02f, 3.23457718e-02f, -1.92356743e-02f, -4.89422679e-02f, 1.01045378e-01f, -3.65469093e-03f, 4.07369211e-02f, -8.59468058e-02f, 1.12738900e-01f,
  -8.25823024e-02f, 1.50116891e-01f, 1.04775265e-01f, 4.78477702e-02f, 7.13534048e-03f, -6.68970048e-02f, -1.43877221e-02f, 5.60641624e-02f, 1.68075502e-01f, 8.49878863e-02f,
  3.54101993e-02f, 1.70026973e-01f, 3.10249701e-02f, -5.42952716e-02f, -1.58569142e-02f, 1.02618136e-01f, 4.45297137e-02f, 3.80371734e-02f, -1.69712566e-02f, 3.70933227e-02f,
  7.08651319e-02f, 6.35693148e-02f, -1.22033939e-01f, -2.43296232e-02f, -1.67901844e-01f, -6.01871386e-02f, -3.12905647e-02f, -2.34210137e-02f, 4.84368205e-02f, 5.37046120e-02f,
  -1.88230798e-01f, 1.64682940e-01f, -1.35809883e-01f, 1.94658831e-01f, -7.37322718e-02f, 3.37316729e-02f, 2.43897159e-02f, 1.47304669e-01f, -8.55972543e-02f, 3.59496363e-02f,
  2.33380478e-02f, 3.25947925e-02f, 1.28011942e-01f, 6.03146330e-02f, 2.75720973e-02f, -6.23655878e-02f, 1.62496418e-01f, -1.00560822e-02f, -7.32326582e-02f, -1.83698740e-02f,
  5.76150939e-02f, -3.21294628e-02f, -5.55648506e-02f, 3.76799218e-02f, -1.48700073e-01f, -4.91623841e-02f, -3.50278057e-02f, -1.15863144e-01f, -8.32341984e-02f, -2.97849365e-02f,
  -4.38071378e-02f, -8.12900215e-02f, -1.58006034e-03f, -7.00786114e-02f, -8.57512206e-02f, -1.16782160e-02f, 1.39705734e-02f, -9.24579650e-02f, -1.11513644e-01f, 1.05405003e-01f,
  4.93252557e-03f, 2.01731287e-02f, 3.14293727e-02f, 5.30523770e-02f, 5.10190353e-02f, -2.86379550e-02f, 5.48378518e-03f, 6.27321601e-02f, -1.94900520e-02f, 1.02324933e-01f,
  -5.57514243e-02f, 7.00691435e-03f, 8.46115276e-02f, -1.34104609e-01f, 9.30521116e-02f, 1.30183995e-01f, 7.78421806e-03f, 1.41302079e-01f, -8.69097635e-02f, 1.38428494e-01f,
  8.44606757e-03f, -2.76437234e-02f, 8.00318196e-02f, -1.70013290e-02f, -9.92143750e-02f, 5.53122461e-02f, 1.05229355e-01f, -1.00262128e-01f, -2.35374402e-02f, -4.61650304e-02f,
  4.27277163e-02f, 9.19175968e-02f, -4.27949429e-02f, -8.81790891e-02f, -1.01152383e-01f, -4.00233455e-02f, 2.04791188e-01f, -4.75550955e-03f, 7.83295482e-02f, -8.78250077e-02f,
  -7.87391812e-02f, -1.23281255e-01f, 1.01007946e-01f, 4.90528382e-02f, -1.18616484e-01f, -5.65340603e-03f, 9.06155929e-02f, -3.78577076e-02f, 5.80639672e-03f, 8.85645971e-02f,
  -2.73447242e-02f, 8.14041682e-03f, -5.49627878e-02f, 1.12813972e-01f, 2.09612157e-02f, 1.42286867e-01f, -1.32798150e-01f, -8.89499411e-02f, 1.08023703e-01f, 1.23028025e-01f,
  9.09254700e-02f, -3.33962403e-02f, -3.36412489e-02f, -3.71442027e-02f, 6.20326623e-02f, -7.77973309e-02f, -1.04337305e-01f, 5.98820932e-02f, -5.78674600e-02f, 1.27512902e-01f,
  -9.73896608e-02f, 2.77227536e-02f, -8.97124410e-03f, 8.97608548e-02f, 7.93927312e-02f, 8.06219131e-02f, 1.89790681e-01f, 5.72247505e-02f, 3.97104770e-03f, -8.62208977e-02f,
  -2.43920702e-02f, -1.39382422e-01f, 4.99691144e-02f, -2.55677048e-02f, 3.60658728e-02f, 7.60795102e-02f, 7.87445083e-02f, -1.20023405e-02f, 1.26263797e-01f, -8.20268020e-02f,
  -2.81041209e-02f, 6.43922687e-02f, 8.78769383e-02f, 5.42147718e-02f, 1.34559467e-01f, 8.34705366e-04f, 1.33546278e-01f, 9.41106211e-03f, -1.79183215e-01f, 7.78869614e-02f,
  6.40961453e-02f, -7.95196965e-02f, -4.30168174e-02f, -6.84193056e-03f, 5.65029047e-02f, -1.35152517e-02f, 1.26877204e-01f, 1.13108456e-01f, -3.12756747e-02f, -2.14037877e-02f,
  5.85631505e-02f, 1.43272579e-01f, 3.83133702e-02f, -5.16573265e-02f, 1.08335972e-01f, 2.04320163e-01f, 2.07638498e-02f, 6.20655678e-02f, -3.88980545e-02f, 2.95847338e-02f,
  7.12725669e-02f, 3.64657789e-02f, 9.39668864e-02f, -5.84200732e-02f, 2.17569545e-02f, 1.42881691e-01f, 1.16602473e-01f, 3.93568873e-02f, 1.48353174e-01f, -4.90382016e-02f,
  8.31967518e-02f, 8.09219107e-02f, 5.89192510e-02f, -2.89843120e-02f, -6.80222511e-02f, 7.33272284e-02f, 1.26146093e-01f, 5.06183505e-02f, -1.20845988e-01f, 6.55245036e-02f,
  -1.27329096e-01f, 1.31979853e-01f, -1.93495199e-01f, -1.27183080e-01f, 1.23609733e-02f, 1.90121323e-01f, -1.94250569e-01f, -6.72502220e-02f, -1.19531795e-01f, 1.23698507e-02f,
  7.26809725e-02f, -7.01702088e-02f, 1.24764062e-01f, -2.51841098e-02f, -1.66579351e-01f, -3.66816334e-02f, -1.06816135e-01f, 3.29978727e-02f, -1.19247049e-01f, 1.31343260e-01f,
  7.26002976e-02f, 9.16558653e-02f, -2.01297566e-01f, 1.96300030e-01f, 1.30958661e-01f, -1.06625281e-01f, -7.22018033e-02f, 3.00785322e-02f, 1.27484024e-01f, -3.93014811e-02f,
  -5.74216433e-02f, -1.30593525e-02f, -7.47951418e-02f, 1.09333865e-01f, -1.25880003e-01f, 8.03647116e-02f, -1.42112389e-01f, -8.81230235e-02f, -3.99243161e-02f, 1.63747258e-02f,
  2.14138106e-01f, 8.56498107e-02f, 1.14976205e-01f, 1.72348879e-02f, -2.27140069e-01f, -7.21250698e-02f, 1.41447470e-01f, -1.25043824e-01f, 2.48809844e-01f, 1.52110439e-02f,
  -6.61546960e-02f, -3.24561000e-02f, 1.60781905e-01f, -1.06425829e-01f, 2.63268277e-02f, 7.92449936e-02f, -1.48304448e-01f, 1.00811772e-01f, 2.49894634e-01f, 1.24093793e-01f,
  -5.95069379e-02f, -3.59712020e-02f, 6.85444027e-02f, 7.49072582e-02f, 2.80687869e-01f, 1.10370383e-01f, 1.96089968e-01f, 2.77049630e-03f, 9.62663516e-02f, -2.53906578e-01f,
  -3.09183151e-01f, 3.29819322e-02f, 1.02709040e-01f, -2.98830979e-02f, 8.33321214e-02f, -4.45659384e-02f, 6.66656047e-02f, 1.61787774e-03f, -9.42372009e-02f, -1.29669411e-02f,
  -7.41775259e-02f, -1.85395643e-01f, 3.54475141e-01f, 4.12166677e-02f, 2.26115853e-01f, 8.34223256e-02f, 3.55701670e-02f, 2.51367912e-02f, -7.53899440e-02f, 5.70964627e-02f,
  -9.63076856e-03f, 1.88984454e-01f, 1.35539576e-01f, 1.00723624e-01f, 8.43068212e-02f, 1.13093287e-01f, 1.26771340e-02f, -2.89219171e-02f, 1.77113470e-02f, 3.07835728e-01f,
  7.85649270e-02f, 6.87838569e-02f, 1.10903859e-01f, 2.20586225e-01f, -1.41016226e-02f, 1.59463555e-01f, 9.80653390e-02f, 5.51804714e-02f, 1.97645202e-01f, 1.65192485e-02f,
  -3.94802503e-02f, -1.02128964e-02f, -6.62486553e-02f, 8.50074738e-02f, 1.44647181e-01f, 7.97977149e-02f, 1.32192180e-01f, -4.36741337e-02f, -3.21757197e-02f, -4.89980616e-02f,
  1.67524919e-01f, 1.08854078e-01f, 6.81247469e-03f, -4.40441631e-02f, 1.15674175e-01f, 5.46785817e-03f, -1.76240988e-02f, 3.87588590e-02f, 4.08446118e-02f, 2.45098576e-01f,
  -7.48186512e-03f, 8.16511661e-02f, 4.47521396e-02f, 6.86274692e-02f, 3.81763093e-02f, 7.75368288e-02f, 2.91849370e-03f, 5.80930747e-02f, -1.61759242e-01f, -6.16182666e-03f,
  -5.69003262e-03f, -1.98800683e-01f, 2.06007600e-01f, -5.37656955e-02f, -1.11053251e-01f, 4.23514061e-02f, -1.26813784e-01f, -1.97696298e-01f, 1.76006958e-01f, 8.21973234e-02f,
  4.02474925e-02f, -2.93835662e-02f, 1.62748650e-01f, -1.39405429e-01f, -1.53026450e-02f, 2.26421040e-02f, 1.00133598e-01f, 5.94199598e-02f, 7.55496025e-02f, -7.59773925e-02f,
  1.03960730e-01f, -7.66430646e-02f, 1.45993605e-02f, -9.85808112e-03f, 1.89530075e-01f, 3.07693910e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.79689765e-01f, 1.50903314e-01f, 1.48466919e-02f, 3.27453800e-02f, 9.22321752e-02f, 1.00480981e-01f, 8.45845975e-03f, 5.84139824e-02f, -3.75016481e-02f, -5.19851372e-02f,
  -5.77588938e-02f, 9.22049806e-02f, 2.19779223e-01f, -2.44252365e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.98365182e-01f, 3.12634617e-01f, 7.49522373e-02f, -1.57098368e-01f, -3.28073293e-01f, 2.38173157e-02f, 9.35033429e-03f, 1.13055386e-01f, 2.02513933e-02f, 1.45735815e-01f,
  -2.90676057e-01f, -3.02385502e-02f, 8.95783491e-03f, -3.92327428e-01f, 3.78264859e-02f, 1.30787119e-01f, -3.14901501e-01f, -1.65460616e-01f, -2.91343540e-01f, -8.94671530e-02f,
  -7.56838471e-02f, 2.97629870e-02f, 1.66869372e-01f, -3.42313826e-01f, -6.06217682e-01f, 5.29653192e-01f, 1.37113065e-01f, 3.24018985e-01f, -1.23976702e-02f, -1.07268006e-01f,
  -9.94449258e-02f, 2.67205060e-01f, -4.06228095e-01f, 3.50989223e-01f, -3.05756837e-01f, 2.55786404e-02f, -1.15261316e-01f, -2.73601741e-01f, 1.29087493e-01f, 1.09914765e-01f,
  1.70594901e-01f, -4.16124910e-01f, -5.91399297e-02f, -1.67346261e-02f, 3.24871749e-01f, -7.28349984e-02f, -4.42439280e-02f, 2.59556621e-01f, -1.77491412e-01f, -3.20588112e-01f,
  -1.53939724e-01f, -2.55259752e-01f, -1.58638686e-01f, -1.59601599e-01f, -1.36038572e-01f, 1.76182076e-01f, 2.68283822e-02f, 3.45585436e-01f, 9.52022746e-02f, 1.65119569e-03f,
  1.99851379e-01f, -2.26735204e-01f, 4.27322745e-01f, -4.17370051e-02f, -2.85856813e-01f, 2.00252280e-01f, 1.59917861e-01f, 8.23313817e-02f, -7.76703190e-03f, 4.47321117e-01f,
  9.51821264e-03f, 2.14008555e-01f, -3.59909862e-01f, -2.28298694e-01f, 7.57506788e-02f, -1.10198416e-01f, -4.00867999e-01f, -5.05809069e-01f, -3.83210299e-03f, 2.21705988e-01f,
  3.35659981e-02f, 3.34397018e-01f, 1.34112656e-01f, -7.33725876e-02f, -3.18045229e-01f, 2.98618793e-01f, 2.25203391e-02f, -2.69844294e-01f, -3.80419880e-01f, 3.59071717e-02f,
  2.35565022e-01f, 6.17717981e-01f, -2.60555089e-01f, -6.08385280e-02f, -1.48051023e-01f, 2.10673854e-01f, 3.57505381e-01f, 3.09316039e-01f, 2.36887619e-01f, 1.99020788e-01f,
  -3.67341787e-01f, 4.93293315e-01f, -1.31868333e-01f, -4.30618793e-01f, 2.41433993e-01f, -1.54261753e-01f, -7.46302083e-02f, -3.02131891e-01f, -4.38997030e-01f, 4.90595698e-01f,
  -3.82061511e-01f, -5.82694113e-01f, -1.58834904e-01f, -3.47578257e-01f, -2.01650023e-01f, -5.25699928e-02f, 8.84528533e-02f, 2.50814021e-01f, -2.29582027e-01f, -1.81650549e-01f,
  7.57045820e-02f, 2.74680644e-01f, -1.39575705e-01f, 2.13525921e-01f, -1.72014058e-01f, -2.75474489e-01f, -4.01821360e-02f, 7.49704689e-02f, 3.07965100e-01f, 1.86950609e-01f,
  2.74601191e-01f, -2.20290963e-02f, 9.89165604e-02f, -2.18451768e-01f, -3.79505515e-01f, 2.97255009e-01f, 2.69105405e-01f, -1.33430466e-01f, 3.33119065e-01f, -9.77542344e-03f,
  1.79203749e-01f, 1.71445236e-01f, -1.13717221e-01f, 1.83014065e-01f, -2.24740446e-01f, 5.22710606e-02f, 3.79984707e-01f, 1.45329356e-01f, -3.04848343e-01f, -5.41095316e-01f,
  -3.16739716e-02f, 2.54260987e-01f, 2.18854100e-01f, -3.67406398e-01f, 1.33465171e-01f, -4.37271208e-01f, -3.54515344e-01f, -4.01919872e-01f, -4.80797231e-01f, 2.93628991e-01f,
  -1.22859366e-01f, 1.76220357e-01f, 2.16073960e-01f, -6.17290698e-02f, -2.96842642e-02f, -3.76848690e-02f, -7.76158124e-02f, -3.01209837e-01f, -1.18260816e-01f, 4.05435234e-01f,
  -2.23803803e-01f, 1.29027292e-01f, 6.23266920e-02f, 2.99637169e-01f, -4.43078190e-01f, -4.46495056e-01f, -2.08562911e-01f, -2.21222311e-01f, -1.84878975e-01f, 2.33596206e-01f,
  -2.55926609e-01f, -7.48247728e-02f, -1.56891480e-01f, -1.31935656e-01f, -1.80276513e-01f, 1.33670196e-01f, -9.19708312e-02f, -2.47230977e-02f, 9.10826847e-02f, -2.80745149e-01f,
  -1.00612737e-01f, -1.51093245e-01f, 1.83131248e-01f, -1.52319223e-01f, 2.44061768e-01f, 1.97530940e-01f, 2.26890087e-01f, -1.06716305e-01f, 3.42801869e-01f, -1.51871191e-02f,
  -7.05759786e-03f, 1.06074430e-01f, -1.44139037e-01f, 7.62883574e-02f, 7.46981939e-03f, 2.72072494e-01f, 1.06451318e-01f, 2.15260372e-01f, -2.79605418e-01f, -1.42050296e-01f,
  -2.66904145e-01f, -3.33831072e-01f, -2.60890592e-02f, 9.17069986e-02f, -1.89569205e-01f, -4.90517244e-02f, 2.62193561e-01f, -1.58954263e-01f, -2.03938499e-01f, 1.25648305e-01f,
  -3.19845110e-01f, -6.26612548e-03f, -4.63256240e-02f, -1.57083943e-01f, -3.57009739e-01f, -3.23515892e-01f, -1.66401893e-01f, 2.22931966e-01f, -2.94327587e-01f, 1.99225664e-01f,
  1.15471140e-01f, 2.19244465e-01f, 7.46730492e-02f, -4.95539278e-01f, -1.62863433e-01f, -2.35599399e-01f, 4.30586904e-01f, -3.52109700e-01f, 5.22779226e-01f, 4.15564537e-01f,
  -3.52491468e-01f, -2.14449853e-01f, -2.30198786e-01f, -2.71021724e-01f, 2.03755870e-01f, -1.83168530e-01f, 7.17486322e-01f, 1.78588450e-01f, -2.82578915e-01f, -5.29964082e-03f,
  -7.10721686e-02f, -9.79024842e-02f, -1.27034381e-01f, 5.23286127e-02f, -4.97321159e-01f, 2.95089245e-01f, 3.92041802e-01f, -3.44069898e-01f, 3.56152579e-02f, -3.47141504e-01f,
  -5.14260940e-02f, 6.69695511e-02f, -3.77488434e-01f, 1.19722933e-01f, 2.65649289e-01f, 7.56856725e-02f, 2.38397345e-01f, 1.69948265e-01f, 1.36696920e-01f, 1.53808638e-01f,
  -2.80087292e-01f, -5.36873601e-02f, 5.19849420e-01f, -3.03896129e-01f, -2.71690905e-01f, 5.36742955e-02f, 1.05897486e-01f, -8.09780695e-03f, -4.11317021e-01f, -1.58847734e-01f,
  4.00090158e-01f, -1.86004154e-02f, -3.53715092e-01f, -3.42893660e-01f, -1.36641145e-01f, -5.76119497e-02f, -3.43428701e-02f, 8.97757709e-02f, -3.53305072e-01f, -1.18256949e-01f,
  -4.74461287e-01f, 3.56571227e-01f, 1.56474859e-01f, -3.46439272e-01f, 3.24683994e-01f, 4.64369625e-01f, 1.09564178e-01f, 8.13004896e-02f, -1.56893581e-01f, -2.10886747e-01f,
  1.92044005e-01f, 3.18916105e-02f, -4.57035750e-01f, 4.21091944e-01f, -2.51455337e-01f, 1.80447251e-01f, 3.08836043e-01f, -1.22730903e-01f, -8.59390348e-02f, -1.07357152e-01f,
  -8.24353471e-02f, 4.66327891e-02f, 4.67050672e-02f, -2.77731419e-01f, -4.45461497e-02f, 3.74105424e-02f, 8.09469149e-02f, 1.04116194e-01f, 3.54002327e-01f, 1.48783475e-01f,
  1.45734861e-01f, 5.56956679e-02f, 5.31138301e-01f, -1.86631322e-01f, 2.18822092e-01f, 9.20614973e-02f, 2.07469970e-01f, -1.91895068e-01f, 3.80132318e-01f, 1.27062753e-01f,
  -2.41348997e-01f, 9.72492341e-03f, -6.83911070e-02f, -9.59800631e-02f, 2.53290743e-01f, -2.27825865e-01f, 4.77192067e-02f, 2.65046299e-01f, 3.65778096e-02f, 9.39382911e-02f,
  2.95005053e-01f, 4.61286217e-01f, 4.62087065e-01f, 4.31823134e-02f, 4.77293491e-01f, 3.35501045e-01f, -2.33517766e-01f, 4.23369260e-04f, -2.71570295e-01f, 9.53639373e-02f,
  5.35884261e-01f, 1.88770846e-01f, 5.07874787e-01f, 2.18419984e-01f, 3.53358030e-01f, 4.03694272e-01f, -1.71058103e-01f, 1.56451106e-01f, 3.26408803e-01f, -2.95191675e-01f,
  -3.47442985e-01f, 4.68315572e-01f, 5.44929840e-02f, -3.72277409e-01f, -1.69849783e-01f, -1.75409123e-01f, -5.42578176e-02f, 2.83335596e-01f, -1.31093472e-01f, 9.59571451e-02f,
  -2.76177227e-01f, 1.35623649e-01f, -9.83637199e-02f, -2.03431249e-01f, 1.32037044e-01f, 1.10184461e-01f, 1.91846803e-01f, 2.12958321e-01f, 1.22787647e-01f, -1.09882290e-02f,
  5.23761436e-02f, 1.02532832e-02f, 1.44207090e-01f, 7.03324229e-02f, -3.77247781e-01f, 9.25417393e-02f, -4.39367563e-01f, 2.34495699e-01f, -2.18799219e-01f, 4.17613029e-01f,
  2.37920910e-01f, 7.25428686e-02f, -9.35650766e-02f, -6.80544302e-02f, -2.13832662e-01f, 6.32319972e-02f, -3.46802659e-02f, -9.65366289e-02f, -4.44764972e-01f, -3.29977781e-01f,
  -2.04435349e-01f, -1.23765148e-01f, -5.18775284e-01f, 1.16617985e-01f, -2.03112692e-01f, -4.83767182e-01f, 7.50876665e-02f, -1.86785311e-01f, -2.24967077e-01f, -8.17878246e-02f,
  9.50279459e-02f, -1.89773783e-01f, 3.00461322e-01f, 3.15566033e-01f, 1.73352614e-01f, 1.66518301e-01f, -3.73273194e-01f, -3.12503606e-01f, 3.85687381e-01f, -4.60392892e-01f,
  -4.20753509e-01f, 1.25760928e-01f, -2.76041061e-01f, -2.14107484e-01f, -1.75123557e-01f, 1.94296539e-01f, 2.80037612e-01f, 5.78539610e-01f, -5.94463162e-02f, 2.95471936e-01f,
  -3.12974483e-01f, -3.20979118e-01f, 3.54499727e-01f, 1.95824593e-01f, -9.15448815e-02f, 3.29954416e-01f, -1.78748295e-01f, -6.28437921e-02f, -6.47202581e-02f, -1.26154155e-01f,
  -3.69340181e-02f, -1.45700470e-01f, 2.35934123e-01f, 1.23190768e-02f, 6.19013794e-03f, 8.46361294e-02f, -2.74413913e-01f, -1.71033308e-01f, -4.69970375e-01f, -2.70270742e-02f,
  1.61202312e-01f, -1.69783324e-01f, -3.12057929e-03f, -9.40008163e-02f, 4.43162309e-04f, 1.24395363e-01f, -2.48160750e-01f, -9.25313085e-02f, -7.82858394e-03f, 4.59878966e-02f,
  5.66631369e-02f, 1.20615009e-02f, 1.99499339e-01f, 2.25308225e-01f, -1.18904941e-01f, -1.64438710e-02f, 1.59450725e-01f, 7.89977089e-02f, 1.00692414e-01f, -4.56150062e-02f,
  -2.45335288e-02f, 1.51549771e-01f, -2.35180363e-01f, -2.14137778e-01f, 1.17756687e-01f, -1.86912358e-01f, 5.17172575e-01f, 4.70025316e-02f, -3.05165827e-01f, -4.05533046e-01f,
  3.99036333e-02f, -1.63149208e-01f, -2.48138100e-01f, -3.13092947e-01f, 1.29039884e-01f, -1.80621624e-01f, -1.37618795e-01f, 2.53159940e-01f, 5.51439404e-01f, -4.85013723e-01f,
  2.91872472e-02f, 1.52040109e-01f, 1.63494781e-01f, -1.13257416e-01f, 3.88837457e-01f, 3.55388075e-01f, -8.12866017e-02f, 2.91951686e-01f, -7.00011477e-02f, 1.42277539e-01f,
  4.78937209e-01f, 4.59591627e-01f, -2.36962482e-01f, 2.53425330e-01f, -2.40413964e-01f, -1.97753578e-01f, -1.73603699e-01f, 7.15251341e-02f, -7.29535893e-02f, 1.92591444e-01f,
  -1.63670376e-01f, 3.90757322e-02f, 1.72368556e-01f, 4.64987494e-02f, 1.71395734e-01f, -8.50502402e-03f, 1.00181341e-01f, -1.70997307e-01f, -1.31595088e-02f, -4.49334413e-01f,
  -1.43426016e-01f, -4.20075692e-02f, 2.19309419e-01f, 3.37728187e-02f, 1.89077929e-01f, 2.22865582e-01f, -1.16550483e-01f, -4.53641936e-02f, 1.06261760e-01f, -9.51394439e-03f,
  9.60139260e-02f, -4.48912531e-01f, 7.64103532e-02f, -1.36671126e-01f, -4.33438838e-01f, -2.46660132e-02f, 2.33402342e-01f, 2.97852635e-01f, 1.28816977e-01f, 2.87198484e-01f,
  6.55777037e-01f, 1.61493644e-01f, 5.05822420e-01f, -5.12041569e-01f, 2.97653496e-01f, 2.00812921e-01f, 3.08304459e-01f, 8.52229968e-02f, 2.90705711e-01f, -7.60975927e-02f,
  -7.79556334e-02f, -2.56021351e-01f, -2.67617732e-01f, -2.11664036e-01f, 5.23403525e-01f, 3.52971494e-01f, -2.08335921e-01f, 8.41347128e-02f, 3.96841258e-01f, -4.17994380e-01f,
  3.72908443e-01f, -1.51449114e-01f, 3.55663449e-02f, -1.68062940e-01f, -6.97244555e-02f, 3.37643921e-01f, 1.17090307e-02f, -3.81689444e-02f, -1.52208619e-02f, 1.39798373e-01f,
  1.96804434e-01f, 2.98576728e-02f, -2.73464620e-02f, -9.32721570e-02f, 3.69440354e-02f, -2.44599804e-01f, -2.68498272e-01f, -6.70147166e-02f, -4.02657181e-01f, 6.97123408e-02f,
  1.45733565e-01f, -2.96378374e-01f, 1.35914996e-01f, 1.23426482e-01f, -2.72666872e-01f, 2.87304908e-01f, 1.37937009e-01f, -1.00546069e-01f, -2.49665916e-01f, 4.13029417e-02f,
  3.57586950e-01f, 1.86432675e-01f, -1.38839111e-01f, 1.65387273e-01f, 4.74579811e-01f, -4.34158146e-02f, 8.38804841e-02f, -2.37269998e-01f, 2.15642720e-01f, 7.81453680e-03f,
  -2.99403502e-04f, 9.73391067e-03f, -2.79971480e-01f, -2.11673558e-01f, -9.26325750e-03f, 1.63874760e-01f, -4.92000222e-01f, 1.63426682e-01f, -2.67291218e-01f, -4.00337994e-01f,
  -1.61182210e-01f, -4.12251741e-01f, 8.87552723e-02f, -3.94701809e-01f, -1.61334276e-01f, -3.16134803e-02f, -1.42976150e-01f, 3.22179317e-01f, 1.82686940e-01f, -1.15360044e-01f,
  3.39839160e-01f, -1.66452900e-01f, -4.26909745e-01f, 2.56402642e-01f, 6.92946836e-02f, 3.97583425e-01f, 4.47023213e-01f, 3.97225887e-01f, -1.55142352e-01f, -2.01415613e-01f,
  -1.04093000e-01f, -1.97603717e-01f, 2.70651840e-02f, -2.07146019e-01f, -4.08449844e-02f, -7.37466440e-02f, 7.28863627e-02f, -3.09308916e-02f, 2.49900624e-01f, -3.22501749e-01f,
  -3.37586813e-02f, -2.59964764e-01f, -1.41511455e-01f, 2.92233765e-01f, -2.18063280e-01f, 1.07079804e-01f, 2.56690592e-01f, -9.09769684e-02f, -1.95812881e-01f, 1.74248829e-01f,
  -2.92404413e-01f, -2.85796314e-01f, 1.66524887e-01f, 2.69828737e-01f, 5.71817085e-02f, 2.16896478e-02f, 9.47229192e-02f, -1.09298751e-01f, -3.80237043e-01f, 2.50247151e-01f,
  1.09351322e-01f, -4.17574972e-01f, 1.86157703e-01f, 2.56185681e-01f, -2.67196889e-03f, 9.25311595e-02f, -3.72474283e-01f, 4.50754106e-01f, -4.10841145e-02f, -1.78401262e-01f,
  -6.05213456e-02f, -2.13254634e-02f, 3.88962775e-01f, 3.15299690e-01f, 1.33578300e-01f, 6.69369400e-02f, 5.62072098e-01f, 5.61637878e-02f, -6.33299202e-02f, 6.05079174e-01f,
  3.73374283e-01f, -7.53014684e-02f, -1.03297524e-01f, -4.01556641e-01f, -1.79070085e-01f, 1.14619300e-01f, 5.76453984e-01f, -4.66154665e-01f, -6.82810098e-02f, -2.65309691e-01f,
  -1.32182315e-01f, 2.51203496e-02f, -1.29960999e-01f, 1.14152720e-03f, 3.70947570e-01f, 3.74133997e-02f, -1.11469641e-01f, -2.82786041e-01f, -1.34474993e-01f, -2.48572472e-02f,
  -1.24308258e-01f, -9.64755490e-02f, -1.09007575e-01f, 2.34804183e-01f, 1.65298313e-01f, 6.01692796e-02f, -2.19745278e-01f, 6.24627136e-02f, -2.66789466e-01f, 5.60053214e-02f,
  1.27673015e-01f, 1.89925492e-01f, 2.01776296e-01f, 1.42531306e-01f, 2.16992781e-01f, -5.81082106e-02f, 2.40444943e-01f, -4.23896499e-02f, -3.22753011e-04f, -5.74510992e-01f,
  1.83002174e-01f, 1.46111071e-01f, -9.92999822e-02f, -2.17549413e-01f, 2.38145947e-01f, 2.34549433e-01f, 2.26322278e-01f, 8.08251128e-02f, -1.90753952e-01f, -2.08945349e-01f,
  3.73894691e-01f, -5.06779850e-01f, -5.52817099e-02f, 3.24966043e-01f, 6.69808507e-01f, -4.87268537e-01f, 2.13497669e-01f, -3.12904686e-01f, -5.10650754e-01f, -3.01682930e-02f,
  2.28538603e-01f, -1.31987659e-02f, -1.19663678e-01f, -2.11234957e-01f, -2.79422343e-01f, 2.44059741e-01f, -2.46689320e-01f, 4.55874413e-01f, -4.12750155e-01f, -2.01041386e-01f,
  -8.69934633e-03f, 1.55548051e-01f, 3.10757309e-01f, 4.00435507e-01f, 1.53413370e-01f, -3.51110309e-01f, 1.64263733e-02f, -6.91664070e-02f, -5.76213449e-02f, 5.35417646e-02f,
  -3.36130373e-02f, 1.18466638e-01f, 8.87609124e-02f, 6.15944453e-02f, 1.83433089e-02f, 3.36275756e-01f, -2.61139810e-01f, -1.67644069e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.79652600e-02f, 1.41188115e-01f, -1.68056950e-01f, -4.65463335e-03f, 2.03347802e-02f, -6.60306513e-02f, 1.25097051e-01f, -3.47378179e-02f, -5.65741807e-02f, -3.35019715e-02f,
  3.44245955e-02f, 1.01927601e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    