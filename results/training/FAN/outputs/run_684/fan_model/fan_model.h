/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.84648293e-02f, 7.79470131e-02f, 9.90276858e-02f, -3.64825726e-02f, -8.45654905e-02f, -9.31731910e-02f, 4.86214422e-02f, -8.96212310e-02f, -7.69626200e-02f, -9.05317720e-03f,
  -1.52613431e-01f, -3.87097418e-01f, -3.08343470e-01f, -3.25769305e-01f, -2.26883039e-01f, 3.41054238e-02f, -8.72792676e-02f, -1.19946435e-01f, -2.37685636e-01f, -2.33538657e-01f,
  -1.44523844e-01f, -3.97129320e-02f, -9.79649927e-03f, -9.22154263e-02f, 5.79344574e-03f, -1.35698527e-01f, 8.36103559e-02f, 2.49022655e-02f, -1.43839806e-01f, -4.16479632e-02f,
  -5.92550859e-02f, 3.71110439e-02f, -2.93675154e-01f, -2.90923595e-01f, -1.69855639e-01f, -1.47243395e-01f, -1.31072298e-01f, -1.98612928e-01f, -1.59107983e-01f, -1.48958236e-01f,
  -1.64400369e-01f, -1.86520025e-01f, -2.91471630e-01f, -1.23571195e-01f, -1.23090103e-01f, -8.60706046e-02f, -3.48505415e-02f, -8.94788951e-02f, -1.39007509e-01f, -1.40051275e-01f,
  -2.50622809e-01f, -1.88214555e-01f, -7.10372105e-02f, -7.94830322e-02f, -1.90444544e-01f, -2.22565472e-01f, -1.54734269e-01f, -1.73890054e-01f, -1.26838356e-01f, 4.68604267e-02f,
  -1.25515416e-01f, 8.41401294e-02f, 9.57200229e-02f, 2.26359248e-01f, 1.81670189e-01f, 2.12058917e-01f, 1.47759378e-01f, 1.31157517e-01f, 1.60334557e-01f, 1.84954897e-01f,
  2.05247506e-01f, 1.97696239e-01f, 2.22763166e-01f, 1.11849196e-01f, 1.27468958e-01f, 9.81130078e-02f, 1.93687186e-01f, 1.77239716e-01f, 2.07891017e-01f, 1.77542478e-01f,
  1.92627624e-01f, 2.20666036e-01f, 1.66859791e-01f, 1.12150423e-01f, 1.69654697e-01f, 1.21790774e-01f, 2.05803245e-01f, 9.33312252e-02f, 1.13883957e-01f, 1.46337584e-01f,
  -1.26279667e-01f, -2.73125172e-01f, -6.92346916e-02f, -1.77017063e-01f, -1.77932799e-01f, -1.34011313e-01f, -2.02200174e-01f, -1.40954316e-01f, -1.81213558e-01f, -1.80228695e-01f,
  -1.80220380e-01f, -2.50427991e-01f, -7.79319853e-02f, -2.14143738e-01f, -9.97736976e-02f, -1.58207431e-01f, -1.30712390e-01f, -1.15526125e-01f, -1.90596625e-01f, -1.22832872e-01f,
  -1.32907972e-01f, -2.87687313e-02f, -1.85698897e-01f, -1.90797329e-01f, -1.66474029e-01f, -3.19575459e-01f, -1.31754130e-01f, -3.68113965e-02f, -2.22085059e-01f, 9.07858387e-02f,
  5.93296513e-02f, -1.32636875e-01f, 1.87457651e-01f, 9.01694149e-02f, -1.17681809e-01f, -1.35929376e-01f, -1.22842230e-01f, -1.28872022e-01f, -3.65944952e-02f, 4.88450658e-03f,
  -1.16871305e-01f, -3.05635501e-02f, 2.39550285e-02f, -7.78050348e-02f, 6.31877035e-02f, 4.78467643e-02f, 7.40733892e-02f, 9.90524888e-02f, 4.06327024e-02f, -1.89377278e-01f,
  -1.67731270e-01f, -2.09551398e-02f, -2.32338291e-02f, -1.34580610e-02f, -8.26753750e-02f, -2.25448795e-02f, -1.55004086e-02f, -1.51372343e-01f, -1.89233884e-01f, 1.69419236e-02f,
  2.19250217e-01f, -1.05837695e-01f, -3.64620686e-02f, -1.41146526e-01f, -1.08972453e-01f, -2.80941501e-02f, -6.12439737e-02f, 9.34932660e-03f, -1.01410374e-01f, -1.16106786e-01f,
  -1.01594388e-01f, -1.51204437e-01f, -1.15864035e-02f, -1.64115056e-01f, -1.18704990e-01f, -8.82479772e-02f, -1.43088907e-01f, -2.21704058e-02f, -6.66203424e-02f, -1.20973043e-01f,
  -1.14444755e-01f, -1.09549865e-01f, -3.27348933e-02f, -1.41088575e-01f, -7.15143830e-02f, -9.22853127e-02f, -4.36804183e-02f, -2.02285618e-01f, -1.80416629e-02f, -9.46761444e-02f,
  2.13070232e-02f, 1.81583948e-02f, 1.16090234e-02f, 4.99885567e-02f, -4.15633656e-02f, 3.94631736e-02f, 6.11764677e-02f, 1.68620963e-02f, 1.24639627e-02f, 1.79064844e-03f,
  4.06163223e-02f, 1.93658303e-02f, 4.52732742e-02f, 8.61590505e-02f, -1.37510393e-02f, 2.73994803e-02f, 1.43952109e-02f, -2.01638676e-02f, -4.75665927e-02f, -3.13886208e-03f,
  -5.45825846e-02f, 1.95610933e-02f, 7.30961561e-02f, 3.07703018e-02f, -4.10401775e-03f, 1.50085213e-02f, -1.48758134e-02f, -6.08487204e-02f, 7.43977949e-02f, -8.94937292e-02f,
  2.15653121e-01f, -1.59965307e-02f, 3.38205136e-02f, -6.56886548e-02f, -9.90551803e-03f, 6.55722665e-03f, 5.28366631e-03f, -8.06303881e-03f, -3.15927416e-02f, -5.62383570e-02f,
  -3.59174944e-02f, -2.36904006e-02f, -1.65936144e-04f, -2.98805218e-02f, -9.76827517e-02f, -8.76632482e-02f, 3.59640792e-02f, -1.28495265e-02f, -1.10967152e-01f, -2.60159802e-02f,
  -1.62427325e-03f, -8.21882710e-02f, 8.89698416e-02f, 3.95972989e-02f, -1.10828824e-01f, 1.04871765e-01f, 8.47077221e-02f, 2.94021629e-02f, 9.61663872e-02f, 1.59162983e-01f,
  1.34064540e-01f, -8.98935869e-02f, -9.24362615e-02f, -6.90492988e-03f, -1.06821604e-01f, -1.86412379e-01f, -2.33068272e-01f, -1.11218847e-01f, -5.39714918e-02f, -7.29327798e-02f,
  -5.29449526e-03f, 7.72625953e-02f, -5.61761223e-02f, -1.92547962e-01f, -2.05519736e-01f, -3.09186161e-01f, -1.94178194e-01f, -2.15972215e-01f, -1.62519813e-01f, -5.08707799e-02f,
  -1.28426226e-02f, -7.88629875e-02f, -2.75889318e-03f, -5.09696230e-02f, -1.48672879e-01f, -1.82568029e-01f, -1.50388822e-01f, 1.52641675e-02f, -7.64527395e-02f, -1.91386208e-01f,
  1.51555184e-02f, 1.25682548e-01f, -1.48026839e-01f, -1.02042459e-01f, -1.08438343e-01f, -7.37982765e-02f, -1.13575578e-01f, -2.50838846e-02f, -7.90577456e-02f, -1.24435715e-01f,
  4.80482504e-02f, 2.23890394e-02f, -1.31625254e-02f, -3.46609717e-03f, -6.15744106e-02f, -4.89960052e-02f, -1.14321976e-03f, -5.10072112e-02f, -1.70842096e-01f, -5.10130636e-02f,
  -7.28623942e-02f, -6.16965257e-02f, -3.23039144e-02f, -1.47013247e-01f, -9.77069288e-02f, -1.12865649e-01f, -5.15929163e-02f, -2.21458226e-02f, -1.26453802e-01f, -1.47687510e-01f,
  -4.09377851e-02f, 7.08106309e-02f, 8.91181156e-02f, 1.47546262e-01f, 9.61019322e-02f, 1.18035786e-01f, 1.39249519e-01f, 6.47219121e-02f, 7.57701993e-02f, 4.51867394e-02f,
  1.45430222e-01f, -1.10770026e-02f, 1.47488520e-01f, 5.34535199e-02f, 1.02395155e-01f, 6.51242509e-02f, 8.49929005e-02f, 6.18058033e-02f, 1.16618536e-01f, 1.36660516e-01f,
  5.25498018e-02f, 1.25432283e-01f, 1.84637949e-01f, 1.59924813e-02f, 1.31806388e-01f, 9.04613882e-02f, 1.75824389e-01f, 1.52928263e-01f, 1.13995902e-01f, 1.60827249e-01f,
  -1.54442349e-02f, -1.43149570e-01f, -1.00912325e-01f, -9.66342986e-02f, -9.61785465e-02f, -8.57328773e-02f, 3.71103524e-03f, -3.17305326e-02f, -3.67249176e-03f, 1.08659845e-02f,
  -6.74785748e-02f, -6.11561723e-02f, -1.18447177e-01f, -1.06453672e-02f, -4.94030789e-02f, -6.62665293e-02f, -1.01584941e-01f, -9.99364331e-02f, -2.35937200e-02f, -2.58004256e-02f,
  -5.88788763e-02f, -1.79214239e-01f, -1.43026605e-01f, -1.91425428e-01f, -1.55208915e-01f, -2.06050768e-01f, -1.86703950e-01f, -1.76470652e-01f, -2.76204258e-01f, -2.58747280e-01f,
  -1.50608510e-01f, -1.11612760e-01f, 1.68581922e-02f, -3.32194678e-02f, 7.32656866e-02f, 1.33079842e-01f, 7.56815597e-02f, 1.25565633e-01f, 6.01763390e-02f, 4.57847677e-02f,
  9.23714489e-02f, 1.81316376e-01f, 1.83853582e-01f, 1.77423224e-01f, 7.54813254e-02f, 6.62304386e-02f, 1.58207379e-02f, 3.18701030e-03f, 2.20355809e-01f, 3.75919454e-02f,
  1.97753962e-03f, -7.79083446e-02f, -4.10682261e-02f, 2.87111662e-02f, -3.93670686e-02f, 5.09696417e-02f, 8.56292397e-02f, -8.13366398e-02f, 4.39454988e-02f, -6.69017956e-02f,
  2.26405591e-01f, 1.04872994e-01f, 1.98468015e-01f, 6.44721761e-02f, 1.40599459e-01f, 8.96867141e-02f, 1.74442008e-01f, 1.60204321e-01f, 6.25402331e-02f, 1.72389373e-01f,
  -9.46051162e-03f, 1.76411644e-01f, 1.34481251e-01f, 8.14493746e-02f, 6.40552938e-02f, 1.11618415e-01f, 1.14452548e-01f, 1.42772123e-01f, 1.61753982e-01f, 1.57459721e-01f,
  1.72558404e-03f, 5.48395608e-03f, 1.90315455e-01f, 2.18323037e-01f, 8.94170329e-02f, 1.26447916e-01f, 1.21885456e-01f, 2.05522045e-01f, 1.31075770e-01f, 1.14301823e-01f,
  1.43577680e-02f, -2.07259625e-01f, -4.84922864e-02f, -9.30668190e-02f, -1.65350541e-01f, -3.85184325e-02f, -7.37001002e-02f, -4.88528386e-02f, -4.48017456e-02f, -1.29533932e-01f,
  -2.46122163e-02f, -3.20449881e-02f, -6.09374493e-02f, -6.77649975e-02f, -1.02840222e-01f, -3.91262807e-02f, -6.73293471e-02f, -1.30423322e-01f, -5.28253429e-02f, -1.03878751e-01f,
  -6.80645183e-02f, -3.73640023e-02f, -1.55482098e-01f, -2.23700125e-02f, -1.32882699e-01f, -4.51835208e-02f, -5.49921691e-02f, -8.51249844e-02f, -1.27825633e-01f, -6.76898435e-02f,
  1.92779407e-01f, 2.06241474e-01f, 1.76308706e-01f, 1.70565560e-01f, 2.29070596e-02f, 1.38432980e-01f, 1.05483256e-01f, 1.04633614e-01f, 3.98818143e-02f, 1.00272879e-01f,
  1.31760597e-01f, 1.44814685e-01f, 8.70907009e-02f, 1.25905052e-01f, 8.27901587e-02f, 1.63484693e-01f, 8.05833340e-02f, 1.63828671e-01f, 1.20493494e-01f, 7.62838274e-02f,
  5.97904772e-02f, 1.01146407e-01f, 1.74376622e-01f, 1.36585742e-01f, 1.14496231e-01f, 1.63369983e-01f, 1.98409572e-01f, 2.35864565e-01f, 1.70217514e-01f, 2.37847254e-01f,
  2.17870906e-01f, -2.83523500e-01f, -2.06693545e-01f, 1.44006819e-01f, -2.22556572e-03f, -5.75670041e-02f, -1.52728662e-01f, 1.50552997e-02f, 7.38057420e-02f, -1.41515389e-01f,
  -1.02291726e-01f, 4.41144444e-02f, 1.12435773e-01f, -3.78846787e-02f, -5.22050299e-02f, -4.61066142e-02f, -1.18708588e-01f, 6.96448460e-02f, 1.19172268e-01f, 3.96874547e-02f,
  1.21932387e-01f, 1.56321213e-01f, 1.35676026e-01f, 9.24533531e-02f, -7.11169839e-02f, 1.22426331e-01f, -1.24016114e-01f, -8.51998478e-02f, -1.91576600e-01f, -2.06869483e-01f,
  -1.73724100e-01f, -2.53476650e-01f, -4.56667393e-02f, -2.57427222e-03f, -5.29013947e-02f, -8.15173909e-02f, -4.44819741e-02f, 1.64335854e-02f, 3.34847830e-02f, -1.31155968e-01f,
  -9.32848230e-02f, 6.40060008e-03f, -5.10266721e-02f, -9.88526363e-03f, -3.40968147e-02f, -1.11739308e-01f, -1.28978997e-01f, -4.82271798e-02f, -9.75350887e-02f, -1.77717328e-01f,
  -3.11354492e-02f, -4.87408116e-02f, -1.44720972e-01f, -5.74251376e-02f, -1.58040330e-01f, -8.54481757e-02f, -1.12352438e-01f, -1.60928190e-01f, -1.36889562e-01f, 3.79108787e-02f,
  1.33924007e-01f, 7.24228425e-03f, -2.19939202e-02f, 2.79469192e-02f, 4.16054428e-02f, -5.80113847e-03f, -2.49327291e-02f, 1.66464373e-02f, -1.23334704e-02f, 1.22715104e-02f,
  2.58021597e-02f, 3.09140198e-02f, 2.46768352e-02f, 2.10303310e-02f, 9.65294242e-02f, -3.30047645e-02f, 5.99597767e-02f, -1.00503145e-02f, -6.55958988e-03f, -2.55336016e-02f,
  3.72313187e-02f, -1.05006218e-01f, 1.31046353e-02f, -2.79319901e-02f, 1.67660173e-02f, -6.88254088e-02f, 5.85696176e-02f, 5.74585237e-02f, 6.89773411e-02f, -2.22139880e-02f,
  1.76140994e-01f, 1.31361382e-02f, -1.08968034e-01f, -3.98472212e-02f, -8.01331326e-02f, -2.30960194e-02f, -6.32860139e-02f, -6.23977594e-02f, -4.17706370e-02f, -4.07787487e-02f,
  -8.68420601e-02f, -4.63266149e-02f, -7.32525960e-02f, -1.35450006e-01f, 6.51786663e-03f, -3.81906740e-02f, -2.70674308e-03f, -9.42165684e-03f, -2.40540579e-02f, -8.39074180e-02f,
  -1.28166735e-01f, 3.67675871e-02f, 5.76938391e-02f, 4.45763431e-02f, -1.14699811e-01f, 8.74283463e-02f, -3.51423547e-02f, -1.53527400e-02f, 2.37966590e-02f, 1.81510583e-01f,
  1.55889094e-01f, 2.11837277e-01f, 9.60525051e-02f, 1.05080575e-01f, 1.16159730e-02f, 1.67929590e-01f, 2.12442771e-01f, 1.15889616e-01f, -3.51884514e-02f, -3.34884524e-02f,
  -6.59919456e-02f, -2.23542243e-01f, -1.49829507e-01f, -1.33015394e-01f, 3.86730731e-02f, 1.32982224e-01f, 2.19188169e-01f, 6.87076971e-02f, 3.56332771e-02f, 8.36313330e-03f,
  5.13400733e-02f, -2.04998329e-02f, 8.37273151e-02f, -5.23470007e-02f, 4.89115454e-02f, -8.11943263e-02f, 8.26743022e-02f, 1.20646350e-01f, 3.11064553e-02f, 7.61801302e-02f,
  -9.72535014e-02f, 2.20344797e-01f, -3.80436331e-02f, 6.84378445e-02f, 2.86569949e-02f, -2.62532663e-02f, -2.38180645e-02f, 1.16605245e-01f, -5.75188883e-02f, 2.23246496e-02f,
  4.33269236e-03f, 3.84153649e-02f, 1.01175055e-01f, 4.23115026e-03f, 1.25517771e-01f, 5.00340424e-02f, 1.31081626e-01f, 1.74693819e-02f, 1.39074728e-01f, -3.74102108e-02f,
  9.66976359e-02f, 7.89703652e-02f, 1.20460123e-01f, 1.53008029e-01f, 1.15341745e-01f, 5.53511456e-02f, 8.54117274e-02f, 1.67780980e-01f, 9.79425013e-02f, 1.06719330e-01f,
  -1.06005408e-01f, -5.56805283e-02f, 3.59535292e-02f, 4.28092778e-02f, -4.26318981e-02f, 4.37312536e-02f, -3.57231796e-02f, -1.01137444e-01f, -8.89641047e-02f, -5.17285392e-02f,
  7.45291356e-03f, -1.12214804e-01f, -3.24602798e-02f, 1.23599535e-02f, -1.13619514e-01f, -4.49045673e-02f, -6.82412609e-02f, -9.84974504e-02f, -2.04006042e-02f, -5.75259142e-02f,
  -3.73902395e-02f, 2.05387804e-03f, -9.29804891e-02f, -3.25997844e-02f, -5.85216060e-02f, -8.32917839e-02f, -1.04235180e-01f, -3.69174406e-02f, 1.19598163e-02f, -7.67725846e-03f,
  -1.18334293e-01f, 2.91964598e-02f, 1.94467045e-03f, 2.20810674e-04f, 4.47730534e-02f, 7.99034070e-03f, 4.41189520e-02f, 1.27274394e-02f, -2.89022997e-02f, 7.79679939e-02f,
  8.19705427e-02f, 7.89458975e-02f, 2.25673374e-02f, 3.07335593e-02f, 3.02592237e-02f, 1.86860729e-02f, 5.82686700e-02f, 1.31099194e-01f, -3.44690531e-02f, 4.53552678e-02f,
  5.52752279e-02f, 1.18134797e-01f, 1.82044461e-01f, 1.29390687e-01f, 5.84379248e-02f, -1.04076741e-03f, -1.59544516e-02f, 8.43106806e-02f, 3.99909727e-02f, 1.60527036e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.74376088e-01f, -7.92554319e-01f, 4.31809813e-01f, 2.70448010e-02f, 1.56046763e-01f, 9.55837294e-02f, 6.24169111e-02f, 1.67537332e-02f, -2.27999184e-02f, -1.58159465e-01f,
  -2.30614826e-01f, -1.78751439e-01f, -8.19719732e-02f, -5.81304282e-02f, -8.59287307e-02f, 5.33478186e-02f, 1.78366855e-01f, 3.40722322e-01f, 4.18508679e-01f, -7.99904615e-02f,
  -2.99689084e-01f, -1.03847366e-02f, 5.98343499e-02f, 1.13743082e-01f, -7.30713606e-02f, 5.98589145e-02f, 8.41997098e-03f, -9.75615755e-02f, -1.23950042e-01f, -7.92998970e-02f,
  2.55856246e-01f, -2.72232354e-01f, 1.40421271e-01f, -8.53737816e-02f, -8.56512189e-02f, -2.22828574e-02f, 1.89025626e-02f, -5.45859383e-03f, -2.13799719e-02f, 5.52245229e-02f,
  -9.58347470e-02f, -8.67216960e-02f, -5.55298803e-03f, -4.55187336e-02f, -4.05520760e-02f, 4.33963723e-02f, 5.25342999e-03f, -3.47949453e-02f, -2.29009762e-02f, -4.46339743e-03f,
  -2.86321163e-01f, -8.22608843e-02f, 1.57669723e-01f, -7.76259229e-02f, -6.85534030e-02f, 3.56411114e-02f, -1.29683182e-01f, -1.29653051e-01f, 8.60345457e-03f, -7.22704008e-02f,
  -3.55009809e-02f, 5.93756065e-02f, -1.57572087e-02f, 1.03861183e-01f, -1.15678258e-01f, 9.08852220e-02f, 3.43982450e-04f, -1.72971152e-02f, 2.89883129e-02f, 1.33607700e-01f,
  -5.90571249e-03f, 2.43949499e-02f, -1.72383562e-02f, 1.89972576e-02f, -5.91913648e-02f, -5.59200719e-02f, 1.40002802e-01f, -1.64587930e-01f, -7.00900257e-02f, 9.08961296e-02f,
  8.33025873e-02f, -1.51259517e-02f, 5.31108081e-02f, -2.41287705e-02f, -2.28957701e-02f, 4.89499094e-03f, 1.04246307e-02f, -2.43068635e-02f, -8.26659205e-04f, -6.42387643e-02f,
  3.94514501e-02f, -3.91673408e-02f, 1.23572864e-01f, -1.38080701e-01f, -1.29707679e-02f, -1.61375076e-01f, -6.35662302e-02f, -5.46665080e-02f, -6.54731914e-02f, -1.81115884e-02f,
  -7.22283572e-02f, 9.37687382e-02f, -4.97005843e-02f, -6.66913986e-02f, 7.81478584e-02f, -9.91522521e-03f, -1.01781964e-01f, 4.86841202e-02f, -1.11236736e-01f, 2.59256735e-02f,
  -7.83152357e-02f, 5.78074269e-02f, 2.40305066e-01f, 1.53714061e-01f, -1.47651419e-01f, 2.95452267e-01f, 8.92447680e-02f, -5.96030941e-03f, 2.03057125e-01f, 2.17903942e-01f,
  3.06515843e-01f, -1.03422023e-01f, 3.36698800e-01f, 9.39459130e-02f, -3.76208931e-01f, -3.64212573e-01f, -4.94572461e-01f, -2.53219754e-01f, -3.60936597e-02f, -1.46168694e-01f,
  -1.10639334e-01f, 2.05586795e-02f, 1.36028424e-01f, 6.24022745e-02f, 1.66437566e-01f, -6.81371689e-02f, 1.30642921e-01f, 4.23279911e-01f, 3.41212898e-01f, 4.71158847e-02f,
  8.36505964e-02f, 2.23156855e-01f, 4.18457150e-01f, 1.59304306e-01f, 1.09561132e-02f, 5.49471341e-02f, 1.59435406e-01f, 5.75873964e-02f, 9.59769636e-02f, 2.72614539e-01f,
  2.25041091e-01f, -1.84329316e-01f, 2.18092389e-02f, -5.50530804e-03f, 4.26405482e-02f, 5.87247014e-02f, 1.81268957e-02f, 1.54529124e-01f, -1.45320162e-01f, 3.27624753e-02f,
  1.30833155e-02f, -5.21187223e-02f, -1.13799952e-01f, 4.08359468e-02f, -6.11786395e-02f, -5.89370020e-02f, 8.14050362e-02f, 1.80359662e-01f, 9.79833901e-02f, 6.29020706e-02f,
  -1.26317099e-01f, -6.82183132e-02f, -2.68300056e-01f, -2.03612670e-01f, -1.06933914e-01f, -3.14377397e-02f, -1.37812391e-01f, -1.13687836e-01f, -2.51891352e-02f, 1.36683762e-01f,
  -1.22838534e-01f, -5.40940836e-03f, -3.80860791e-02f, -3.93089168e-02f, -5.20240478e-02f, -1.02477372e-01f, 1.31363822e-02f, -5.88276610e-02f, 2.38625240e-02f, 2.62001734e-02f,
  -1.17816776e-01f, 6.49648383e-02f, -1.64718088e-02f, -6.68252930e-02f, -1.34528913e-02f, -5.41248545e-02f, -6.74802884e-02f, 1.79113392e-02f, -6.11435845e-02f, 8.11246876e-03f,
  4.92103323e-02f, -2.29475629e-02f, 5.56588732e-02f, -3.66028324e-02f, 1.03015630e-02f, 4.85514626e-02f, 7.64666265e-03f, -6.47940040e-02f, -4.19199020e-02f, -2.19601765e-02f,
  -6.69033453e-02f, -1.51810884e-01f, 6.78057671e-02f, 1.69792041e-01f, 5.43841720e-02f, 4.15718518e-02f, 1.86854564e-02f, 3.97832394e-02f, -1.31540924e-01f, 8.60889778e-02f,
  2.59531885e-02f, 4.60824631e-02f, 5.06127402e-02f, 5.02862334e-02f, -4.49845009e-02f, -4.57780585e-02f, -3.83322611e-02f, -4.52463254e-02f, -5.00715747e-02f, -2.96337670e-03f,
  5.88897197e-03f, -1.82094201e-01f, -1.92912787e-01f, -1.59903258e-01f, -9.40000787e-02f, -1.53707042e-01f, -1.18979797e-01f, -2.67448276e-02f, -2.22599000e-01f, -1.72418028e-01f,
  1.40473291e-01f, -3.15000653e-01f, -1.94021508e-01f, 1.46096036e-01f, -2.14836210e-01f, -3.20722938e-01f, -2.51399696e-01f, 4.25627604e-02f, 6.59390241e-02f, -3.00912708e-01f,
  -3.51026893e-01f, -1.33624136e-01f, -1.21242322e-01f, -3.04405093e-02f, -2.75450163e-02f, -2.06754893e-01f, -1.46742582e-01f, 1.47689134e-01f, 1.57198042e-01f, -3.78332213e-02f,
  -3.92585434e-02f, 1.41072929e-01f, 3.74439031e-01f, 2.07935244e-01f, 1.79731790e-02f, 7.14890659e-02f, 1.16497651e-01f, -3.55490553e-03f, -1.78077355e-01f, -1.34463891e-01f,
  -2.77547389e-01f, -4.32345420e-02f, -3.60681675e-02f, 1.00087680e-01f, -4.29413393e-02f, -1.31784737e-01f, -2.17908382e-01f, 1.07535824e-01f, -1.79963872e-01f, -4.29861695e-02f,
  -1.12069659e-01f, -7.54262879e-02f, -1.59814820e-01f, -4.48876545e-02f, 3.39414030e-02f, 8.04263800e-02f, 7.27057531e-02f, 1.45820916e-01f, 1.35122404e-01f, -3.87241505e-02f,
  -1.88475788e-01f, -9.81121808e-02f, -1.30432174e-01f, -2.72868332e-02f, 5.60970604e-02f, -4.35572863e-02f, 5.56103922e-02f, 5.34644015e-02f, 1.55680805e-01f, -7.34938532e-02f,
  6.06476441e-02f, 1.10583128e-02f, -9.33774039e-02f, -9.14455354e-02f, -5.30609302e-02f, -2.46740412e-02f, 1.30042076e-01f, 5.74795380e-02f, 3.08041405e-02f, 2.95176152e-02f,
  3.02865803e-02f, 2.69893203e-02f, 4.86831740e-02f, 1.08383000e-01f, -4.65463055e-03f, 4.71280888e-02f, 3.93854529e-02f, -3.97574203e-03f, -1.86281353e-02f, -9.44420919e-02f,
  4.61158715e-02f, 5.89715540e-02f, 9.58422758e-03f, 2.66529508e-02f, -1.08026892e-01f, 1.33946866e-01f, 5.99094406e-02f, -1.00380555e-01f, -3.10812723e-02f, 1.26432022e-02f,
  1.55195087e-01f, 3.04493327e-02f, -1.76667184e-01f, -2.41067652e-02f, 1.70145277e-02f, -9.05666351e-02f, -1.12472914e-01f, 6.20628968e-02f, 5.44943567e-03f, -7.78697953e-02f,
  -1.22705579e-01f, -2.98070200e-02f, -1.71592399e-01f, -1.08442508e-01f, -1.84757467e-02f, -6.87852427e-02f, -1.80877760e-01f, -9.30524543e-02f, -7.71657526e-02f, -6.32717237e-02f,
  -2.94588841e-02f, -1.43071517e-01f, -1.37869909e-01f, -1.31054208e-01f, -1.95147470e-02f, -1.60533056e-01f, -4.60498035e-02f, 2.30011623e-02f, -4.19069193e-02f, -1.83094934e-01f,
  2.65298486e-01f, 3.03174198e-01f, 2.30246991e-01f, 5.65942228e-02f, 1.39021307e-01f, 8.77854526e-02f, 3.11285816e-02f, -7.78219989e-03f, -1.62822425e-01f, 6.63551763e-02f,
  7.56270066e-02f, -2.11584464e-01f, -8.07852894e-02f, -1.56259358e-01f, -8.15337375e-02f, -1.06022805e-02f, 1.13253087e-01f, -8.29770863e-02f, -1.45001188e-01f, -2.06105724e-01f,
  -1.20792493e-01f, 3.55287902e-02f, 3.04364953e-02f, -4.01180014e-02f, 2.56086625e-02f, -1.27724081e-01f, 1.69237971e-01f, 2.21842632e-01f, 3.44497152e-02f, 1.77999690e-01f,
  7.38585414e-03f, 3.22947174e-01f, -2.86310345e-01f, -8.80034119e-02f, 1.21002860e-01f, -4.43307571e-02f, -9.34910849e-02f, -2.98898537e-02f, -3.43855247e-02f, 7.43089691e-02f,
  -3.88390012e-02f, 6.12038821e-02f, 3.26015875e-02f, -3.33827212e-02f, -6.26264066e-02f, -1.29204854e-01f, -2.62440927e-02f, -6.71264678e-02f, -9.20989886e-02f, 9.35353860e-02f,
  -2.94386763e-02f, 2.38060549e-01f, 2.29568571e-01f, 4.72350558e-03f, 1.19176723e-01f, -1.56776249e-01f, 5.89226447e-02f, 1.91092715e-02f, 4.26968150e-02f, 1.64489359e-01f,
  4.34922948e-02f, -2.19696891e-02f, 5.20909615e-02f, 1.29796425e-03f, -3.76613997e-02f, -5.45313470e-02f, 4.21158485e-02f, 8.85192826e-02f, 4.59375791e-02f, 8.11881479e-03f,
  1.31980469e-02f, 4.64232415e-02f, 1.46266883e-02f, 7.95035586e-02f, -8.22609738e-02f, 1.01317018e-01f, -6.39746487e-02f, 1.71248354e-02f, -1.14163253e-02f, 1.02604747e-01f,
  -1.25150383e-01f, 5.24149723e-02f, 1.13597531e-02f, -3.10852844e-02f, 6.92080185e-02f, -3.77815515e-02f, 4.39848341e-02f, 4.94479537e-02f, 1.27335057e-01f, 1.57066658e-01f,
  -2.44020686e-01f, -1.40248939e-01f, -1.06659412e-01f, -7.29403868e-02f, -3.21366303e-02f, 4.02770238e-03f, 1.67029630e-02f, -1.04186922e-01f, 5.19900844e-02f, 4.25119102e-02f,
  1.48926020e-01f, -3.37725244e-02f, 9.13046896e-02f, -1.99556217e-01f, -1.17142968e-01f, -4.30193432e-02f, -6.51471391e-02f, -8.72848630e-02f, -1.05906591e-01f, 7.89361000e-02f,
  -7.41659626e-02f, -1.42163783e-01f, -7.53077865e-02f, -4.34389599e-02f, 1.80620812e-02f, -9.81184617e-02f, -9.75295454e-02f, -2.35717118e-01f, -1.98279545e-01f, -8.06997642e-02f,
  -9.26503912e-02f, 1.02506086e-01f, 1.16019100e-01f, 2.49696642e-01f, 1.68860406e-01f, 3.09274048e-01f, 3.05504978e-01f, 1.95074961e-01f, 1.19804621e-01f, 6.95369616e-02f,
  1.60431802e-01f, 8.86213630e-02f, 9.18337777e-02f, 3.82990437e-03f, 1.86511651e-01f, 1.16198525e-01f, 1.51010692e-01f, -7.19928071e-02f, -5.15072383e-02f, 1.71192142e-03f,
  5.33101410e-02f, -5.56457564e-02f, -1.19741440e-01f, -1.22194536e-01f, 1.22250408e-01f, 3.01143266e-02f, 5.08549027e-02f, 1.98163345e-01f, 4.01913039e-02f, 3.41391228e-02f,
  6.73662275e-02f, 2.01987311e-01f, -1.30532146e-01f, 2.03258377e-02f, -1.11689866e-01f, -1.39352754e-01f, -7.62247890e-02f, -1.84964359e-01f, -8.86327997e-02f, -1.11267105e-01f,
  -5.81114832e-03f, -6.58215210e-03f, 8.63754675e-02f, -1.12628140e-01f, -2.07412299e-02f, -2.46983953e-02f, -1.45584106e-01f, 4.08964558e-03f, 1.67118058e-01f, 1.15511648e-01f,
  2.63141915e-02f, 1.11873358e-01f, 1.14707477e-01f, 1.66300878e-01f, 1.97991148e-01f, 5.58737516e-02f, 2.47816630e-02f, -7.57324323e-02f, -3.48037966e-02f, -1.90900862e-02f,
  6.41388521e-02f, 1.15480371e-01f, 9.05537754e-02f, 5.55594526e-02f, -2.38893870e-02f, -4.27262299e-03f, 9.73195489e-03f, 8.58443901e-02f, 6.69670403e-02f, -4.93045337e-02f,
  -3.20494547e-02f, 4.37542722e-02f, 7.45457560e-02f, -6.17762804e-02f, 3.91424410e-02f, 1.10424608e-02f, -9.75707322e-02f, 5.54631045e-03f, -1.21370647e-02f, -1.76801085e-02f,
  3.02324165e-02f, -4.97023501e-02f, -1.12958327e-01f, -6.73338398e-02f, -1.05558939e-01f, -3.36649716e-02f, -8.35570768e-02f, -2.29959544e-02f, -1.04088008e-01f, -7.07864016e-02f,
  -1.39984870e-02f, 3.51187825e-01f, 2.63487156e-02f, 6.16906397e-02f, -6.16902858e-02f, -2.26974905e-01f, 1.24623761e-01f, 2.00133063e-02f, -5.95817529e-02f, -7.16737211e-02f,
  -1.06853582e-01f, -1.42122954e-01f, 2.26899553e-02f, -5.20448163e-02f, -1.08350620e-01f, -1.94051787e-01f, 3.90693620e-02f, 6.44302443e-02f, -5.31276539e-02f, 1.27645966e-04f,
  -3.73039804e-02f, -1.03425942e-01f, -1.33773051e-02f, -2.23195348e-02f, 4.45689447e-02f, 5.73641527e-03f, -8.73409659e-02f, -4.22357433e-02f, -2.81741042e-02f, -2.37671241e-01f,
  -2.47869611e-01f, -1.21022366e-01f, 2.75602620e-02f, -1.13590539e-01f, -7.59430788e-03f, -6.24084510e-02f, -2.24815935e-01f, -2.54512317e-02f, 9.35130566e-02f, 1.06028989e-02f,
  2.73219589e-02f, -1.26668122e-02f, -7.84271583e-02f, -6.71939254e-02f, -2.50209391e-01f, -1.89804539e-01f, -1.73919097e-01f, -1.07237697e-01f, -2.00422406e-01f, -4.02922742e-02f,
  -1.21888086e-01f, -1.13558598e-01f, -1.26137927e-01f, 1.10962838e-02f, 2.12889463e-02f, -6.19711317e-02f, 9.48179215e-02f, 3.05733532e-02f, -3.32219899e-02f, -1.37686223e-01f,
  -2.24062279e-01f, 5.06849438e-02f, 6.52413815e-02f, -1.30198851e-01f, 5.76867256e-03f, 6.15655668e-02f, 1.91059057e-02f, 9.19785909e-03f, 2.70848721e-02f, -1.28108785e-02f,
  -5.52843884e-02f, 8.74334872e-02f, -2.29164027e-02f, -4.23680656e-02f, -1.15426267e-02f, -3.81499566e-02f, -1.15090914e-01f, -1.19404137e-01f, -9.35644135e-02f, 1.81963928e-02f,
  -1.21007897e-01f, -3.55238803e-02f, -1.13070928e-01f, 6.71937456e-03f, 7.71673918e-02f, -2.22621169e-02f, 8.17800164e-02f, 2.45245337e-03f, 3.07304785e-02f, -6.81141093e-02f,
  5.84779978e-02f, 9.03480425e-02f, 6.59612939e-02f, 1.98349776e-03f, 5.95981954e-03f, 1.05277032e-01f, -5.81189469e-02f, -1.77813634e-01f, 4.07581925e-02f, 6.22568876e-02f,
  9.60839316e-02f, -2.72044039e-04f, 9.48380828e-02f, 4.26024459e-02f, -5.76459356e-02f, -2.39181504e-01f, -9.68481302e-02f, -6.05334267e-02f, 7.93758407e-03f, 5.72872572e-02f,
  -6.05364405e-02f, -6.84085190e-02f, -7.68617168e-02f, -8.80900100e-02f, -4.60460708e-02f, -6.67541474e-02f, 1.01307146e-01f, 6.98633865e-02f, -1.16574258e-01f, -6.98704571e-02f,
  -1.40618593e-01f, 1.02221638e-01f, -4.78910021e-02f, -1.25124261e-01f, -3.57331783e-02f, 9.43607464e-02f, 6.01183884e-02f, -1.98427625e-02f, -1.19871842e-02f, -1.35391518e-01f,
  -3.51491570e-02f, -9.98445377e-02f, -1.14115188e-02f, -2.04463825e-02f, -4.86277938e-02f, 1.65229682e-02f, -2.21294120e-01f, -1.20098509e-01f, -1.11382395e-01f, -5.16221449e-02f,
  -1.41364336e-01f, -2.26857305e-01f, -1.85571641e-01f, -9.17336270e-02f, 2.68624444e-02f, -1.12936527e-01f, -7.02697188e-02f, -3.84454094e-02f, -1.99980680e-02f, -1.50057182e-01f,
  4.90153372e-01f, -2.50007302e-01f, -4.77409601e-01f, 6.91885278e-02f, -3.79033267e-01f, -3.18247527e-01f, -3.37744594e-01f, -1.00689316e-02f, 2.31189132e-01f, -1.86625794e-01f,
  -9.09602493e-02f, 8.30922872e-02f, -4.46975045e-02f, -1.41050845e-01f, -6.45531565e-02f, -2.60498881e-01f, -3.56606752e-01f, -1.99474737e-01f, -1.71512291e-01f, -2.42747828e-01f,
  -1.47479817e-01f, -6.87472001e-02f, 1.52944863e-01f, -1.00366108e-01f, -1.63835287e-01f, -1.32754549e-01f, -4.12534297e-01f, -2.51244903e-01f, -2.84359485e-01f, -3.98551792e-01f,
  -3.65655512e-01f, -4.18417752e-02f, -1.32861570e-01f, 9.09307227e-02f, -9.99928713e-02f, 1.47250742e-01f, -4.13384326e-02f, 2.51661893e-02f, 1.30190045e-01f, 3.74108292e-02f,
  -8.54661614e-02f, 5.26480116e-02f, 1.36660188e-01f, -1.31033152e-01f, -7.99638927e-02f, -1.59028023e-02f, 4.59650252e-03f, 1.48057211e-02f, -5.69306500e-02f, -5.92803769e-02f,
  2.41225082e-02f, -7.68176978e-03f, 4.53398377e-02f, -3.41924205e-02f, -9.91315171e-02f, 3.06566749e-02f, -2.34960645e-01f, -2.30397820e-01f, -7.27196187e-02f, -1.01929329e-01f,
  9.11569670e-02f, 6.15125187e-02f, -1.06839210e-01f, -8.57687928e-03f, -1.76694877e-02f, -6.58062920e-02f, 5.46999313e-02f, -1.83405560e-02f, 1.07938098e-02f, 3.94393057e-02f,
  -3.69697772e-02f, -8.77898093e-03f, 1.62056331e-02f, 4.68306467e-02f, -1.14183471e-01f, 9.94274542e-02f, 1.66148059e-02f, -5.76837547e-02f, -2.06180476e-02f, -1.54932225e-02f,
  -2.56881937e-02f, 2.28033233e-02f, 7.39926891e-03f, 1.42250126e-02f, -1.05741583e-01f, 3.25707942e-02f, 2.37824265e-02f, -5.63247800e-02f, -4.09447439e-02f, 8.08317363e-02f,
  1.20271295e-01f, -7.45138749e-02f, 2.76015438e-02f, -2.55225971e-02f, -7.74664283e-02f, -4.56762202e-02f, -5.23870736e-02f, 8.87209643e-03f, 7.67018199e-02f, 1.92619842e-02f,
  -1.04492642e-01f, -9.22131240e-02f, -5.19906841e-02f, -9.35870558e-02f, -6.65516257e-02f, 3.02692074e-02f, -4.46262322e-02f, 4.49217483e-02f, 4.95579094e-03f, -6.56125471e-02f,
  -3.80715318e-02f, 1.40534222e-01f, 1.75420448e-01f, 7.05837905e-02f, 1.15593545e-01f, 8.79578441e-02f, -6.31211996e-02f, -1.39478222e-01f, 6.43435791e-02f, 2.08728746e-01f,
  -6.30762503e-02f, 2.12857887e-01f, 1.13178596e-01f, -2.16858275e-02f, -1.53739125e-01f, -2.13846788e-01f, 3.26296575e-02f, -2.36075558e-03f, -8.26636255e-02f, 1.76503330e-01f,
  2.51423046e-02f, -3.13570559e-01f, -2.24331319e-01f, -1.28325328e-01f, -5.93646094e-02f, 2.60665506e-01f, 1.67620897e-01f, -6.58978224e-02f, -4.30421978e-01f, -4.09169465e-01f,
  -2.55236894e-01f, -1.58304051e-01f, -1.30713478e-01f, -1.10442214e-01f, -4.37778085e-02f, -3.71124655e-01f, 7.77273700e-02f, 2.47045550e-02f, -5.74164465e-02f, -1.04341786e-02f,
  7.97368810e-02f, 8.93981159e-02f, -1.10378511e-01f, -7.29741082e-02f, 4.87548066e-03f, 8.52132216e-02f, -2.56150365e-02f, 2.11902224e-02f, 4.85986955e-02f, 7.32662380e-02f,
  -2.45076662e-04f, -1.12819135e-01f, 2.18268987e-02f, -3.69884446e-02f, 3.37529369e-03f, 8.70192572e-02f, 1.70641720e-01f, 1.26314312e-01f, 7.14664459e-02f, 7.54974186e-02f,
  1.11248083e-01f, 6.78233989e-03f, 1.53443620e-01f, 7.75394216e-02f, 1.39108926e-01f, -8.32630601e-03f, -1.02419883e-01f, -1.16127230e-01f, 4.25566845e-02f, 1.49448082e-01f,
  -1.44794909e-02f, -6.66524395e-02f, -1.87839210e-01f, -3.29043530e-02f, -3.94902267e-02f, 5.45241274e-02f, -1.56042827e-02f, 8.96122232e-02f, 4.68178056e-02f, 2.74065770e-02f,
  1.39163481e-02f, 1.67642117e-01f, 1.07823156e-01f, 8.56980383e-02f, 2.23825290e-03f, -3.88229415e-02f, 1.13519348e-01f, 1.10504761e-01f, 1.28200561e-01f, 1.48385065e-02f,
  -2.01803516e-03f, -7.33143389e-02f, 2.71579567e-02f, -5.27836382e-02f, 1.26636192e-01f, -1.82250962e-02f, 1.33160114e-01f, 7.42250830e-02f, 8.07991698e-02f, 5.72721753e-03f,
  -1.22852609e-01f, 1.08702719e-01f, 6.81142956e-02f, -1.30416945e-01f, -3.40276212e-02f, -6.77307397e-02f, -9.86957774e-02f, 4.32515219e-02f, -7.90420249e-02f, 3.50108519e-02f,
  -4.70002033e-02f, -5.02818264e-02f, 7.90180191e-02f, -4.92910780e-02f, -1.36162281e-01f, -1.13853775e-01f, 1.82690024e-01f, -5.34376912e-02f, 6.59035286e-03f, 5.14050499e-02f,
  1.70362234e-01f, 7.53204525e-02f, 5.87507971e-02f, 6.38626292e-02f, -6.61695674e-02f, -2.64288057e-02f, -1.55019984e-01f, -2.75754221e-02f, -1.07610695e-01f, 1.05678111e-01f,
  -4.58749563e-01f, -8.76093432e-02f, 4.02156785e-02f, -3.57093886e-02f, 1.93508253e-01f, -2.10971430e-01f, -4.78847951e-01f, -2.72565961e-01f, 1.38227148e-02f, -2.29563396e-02f,
  1.15148939e-01f, 1.69202000e-01f, 1.08817197e-01f, 2.13809274e-02f, -3.18838805e-01f, -1.82182372e-01f, -2.46250536e-02f, -1.25174582e-01f, -1.42795937e-02f, -9.04197395e-02f,
  7.92627484e-02f, -5.94541244e-02f, -5.57219349e-02f, 5.30639105e-03f, 1.54049367e-01f, 1.06800757e-01f, 1.24335237e-01f, 5.85621549e-03f, 5.91193922e-02f, 2.63320189e-02f,
  -3.80470827e-02f, -2.34479263e-01f, 5.67529947e-02f, 9.49626043e-02f, 2.31991559e-01f, -2.75708027e-02f, -3.63364704e-02f, 6.85367733e-03f, -1.03863254e-02f, -5.53193502e-02f,
  1.06038369e-01f, -5.01301093e-03f, 1.02118693e-01f, 1.17629997e-01f, -5.86869754e-02f, -1.37805685e-01f, -3.13649997e-02f, -1.49471670e-01f, -2.49981299e-01f, -1.08976446e-01f,
  5.07310033e-03f, -5.60516026e-03f, -1.55190602e-01f, -1.76592276e-01f, -1.23140693e-01f, 8.61827061e-02f, -9.61933360e-02f, -3.17348577e-02f, -1.91575274e-01f, -2.38391533e-01f,
  -6.16714917e-02f, 2.84780078e-02f, 1.03063554e-01f, 4.45179176e-03f, 2.89854649e-02f, 5.03242873e-02f, -3.43289902e-03f, -9.06075910e-03f, 1.00572363e-01f, -9.86842588e-02f,
  -5.28316945e-02f, -8.36346969e-02f, 3.62611525e-02f, -3.28464955e-02f, -3.49128805e-02f, -4.56818193e-02f, -5.33522740e-02f, -2.06582267e-02f, 1.52901867e-02f, -1.46646220e-02f,
  1.59756020e-02f, 2.77332831e-02f, 1.56149983e-01f, -8.53675455e-02f, 6.15783073e-02f, 3.65480594e-02f, 5.52650122e-03f, 5.58260791e-02f, -7.70828221e-03f, 2.22043283e-02f,
  -6.94965944e-02f, 1.27864078e-01f, -7.35206157e-02f, -9.69754905e-03f, 3.04531977e-02f, 2.18412559e-02f, -4.00707014e-02f, 6.10791743e-02f, 6.59303144e-02f, -2.19675922e-03f,
  -1.73563547e-02f, -9.76021513e-02f, -2.10793614e-02f, 1.75944790e-02f, 8.46148189e-03f, 1.09502636e-01f, -1.07953101e-01f, 6.17833342e-03f, -1.39459342e-01f, 6.68374375e-02f,
  -8.83070529e-02f, -2.15352297e-01f, -1.85929134e-01f, -2.37343833e-01f, -9.89796221e-02f, -3.37346792e-02f, -4.63244654e-02f, -1.16998143e-01f, -2.40241379e-01f, -3.59448552e-01f,
  -2.73093343e-01f, -5.94487488e-02f, -1.29245341e-01f, -3.90810639e-01f, -4.52784151e-02f, 2.53014535e-01f, 3.03301662e-01f, 1.14910513e-01f, -5.28047681e-02f, -1.96750954e-01f,
  -5.02238832e-02f, -5.77937923e-02f, -9.12148133e-02f, 8.80860612e-02f, 8.11839551e-02f, -5.09345755e-02f, -8.34780112e-02f, -3.56048346e-02f, 2.94643879e-01f, 3.68589401e-01f,
  1.90017253e-01f, -4.22835648e-02f, 6.36049286e-02f, -6.22661486e-02f, -2.39078432e-01f, -9.01659429e-02f, -1.94482416e-01f, -1.10464931e-01f, -8.10852721e-02f, -3.27956975e-01f,
  -1.68680310e-01f, -2.07401276e-01f, 1.32247671e-01f, -4.70369915e-03f, -6.46628737e-02f, -1.56576119e-04f, 2.36487370e-02f, -6.16954640e-02f, -2.80219000e-02f, -1.12856157e-01f,
  -1.73831776e-01f, 2.33042166e-02f, -1.34019524e-01f, -1.01285866e-02f, 5.11216559e-02f, 1.07263803e-01f, 4.26635593e-02f, 4.78475243e-02f, -3.25039849e-02f, 1.44687191e-01f,
  -7.97542408e-02f, -7.99627826e-02f, -2.29351029e-01f, 8.57891887e-02f, -1.61742829e-02f, -6.76488876e-02f, 1.84458811e-02f, 7.00402632e-02f, -4.91522513e-02f, -2.00226396e-01f,
  6.31596297e-02f, 3.51939425e-02f, 2.97807250e-02f, -7.18956590e-02f, -3.70637630e-03f, 5.28653935e-02f, -1.15095042e-02f, 9.50254966e-03f, 5.20725325e-02f, -3.06347124e-02f,
  5.58209196e-02f, 3.92789096e-02f, 8.00462812e-02f, -8.47108066e-02f, 2.30959151e-02f, 1.88194483e-03f, -2.26885676e-02f, -1.12092569e-01f, 1.61862206e-02f, 2.59219836e-02f,
  -1.32292947e-02f, -7.11217299e-02f, -1.11997165e-01f, 2.82318238e-03f, -2.39858609e-02f, -1.86241120e-02f, -6.96418295e-03f, 1.23629980e-01f, -5.85597605e-02f, 1.16206102e-01f,
  -2.47557789e-01f, 2.05478117e-01f, -1.97532132e-01f, 4.55730502e-03f, -1.62621483e-01f, 1.75989643e-02f, -1.40538156e-01f, -2.11330364e-03f, -1.60084516e-01f, -5.15115969e-02f,
  1.14093661e-01f, -1.53221622e-01f, -1.10453792e-01f, 1.09452784e-01f, 1.29810467e-01f, -8.52386747e-03f, -9.83941257e-02f, -1.14886887e-01f, 1.41241997e-02f, -1.05467469e-01f,
  -7.57325441e-02f, -2.52238847e-02f, -1.99762702e-01f, -8.41898993e-02f, -6.10362478e-02f, -2.26013169e-01f, -2.49029435e-02f, -9.74287167e-02f, -7.30433911e-02f, -2.64890760e-01f,
  -5.29133379e-02f, -6.90013990e-02f, 8.19520801e-02f, 2.95520425e-01f, 2.06523493e-01f, 2.50226676e-01f, 1.10264532e-01f, 2.34459996e-01f, 2.84504086e-01f, 1.79614902e-01f,
  -8.85488018e-02f, 3.22785750e-02f, 2.05714390e-01f, 6.45977631e-02f, 1.83631688e-01f, 2.78938115e-01f, 3.02625686e-01f, 1.64493456e-01f, 1.79445505e-01f, 1.89411938e-01f,
  1.40020296e-01f, 1.02770001e-01f, 3.10411882e-02f, 8.95908326e-02f, 1.50902793e-01f, 1.23533711e-01f, 1.30272806e-01f, 8.19620416e-02f, 7.69862756e-02f, 6.40113130e-02f,
  -1.65724128e-01f, -2.23151594e-01f, 1.51324263e-02f, -1.27128422e-01f, -2.14245334e-01f, -1.67094797e-01f, -2.55872812e-02f, -8.09913352e-02f, -7.40012452e-02f, -3.23454477e-02f,
  1.90963000e-02f, -9.69852954e-02f, -6.83025792e-02f, -1.36763737e-01f, -1.41933203e-01f, -8.83804634e-02f, -1.39420062e-01f, 1.34697899e-01f, 1.52282566e-01f, 1.50187863e-02f,
  3.52944732e-02f, -5.15533909e-02f, 6.85531422e-02f, 6.01882264e-02f, 1.32511273e-01f, -5.63370474e-02f, -5.17780781e-02f, -1.05369508e-01f, 6.31999411e-03f, 4.44047973e-02f,
  2.28081644e-01f, 1.07843697e-01f, -4.03219461e-02f, -5.27965873e-02f, 3.80542092e-02f, 7.22801604e-04f, 6.07530177e-02f, 1.57454044e-01f, 1.21542446e-01f, 1.20330515e-04f,
  -4.89056204e-03f, 8.55711102e-02f, -5.59000485e-02f, 2.90980693e-02f, 1.46845803e-02f, -5.93031459e-02f, 7.32394960e-03f, -6.56255707e-02f, -1.86739936e-01f, -1.72059685e-01f,
  -1.08359605e-01f, -3.32277641e-02f, -1.97094351e-01f, -1.08171590e-01f, -1.13903932e-01f, -1.01210266e-01f, 7.60837272e-02f, -1.68964818e-01f, -9.77229606e-03f, -8.94518271e-02f,
  6.97023273e-02f, -1.52778536e-01f, 1.26855090e-01f, 5.08552007e-02f, -5.01053706e-02f, -2.15523317e-01f, 7.88371637e-02f, -7.50289485e-02f, 1.93011910e-02f, -1.49671612e-02f,
  4.06361893e-02f, 3.42288911e-02f, -9.45136026e-02f, -5.76501414e-02f, -2.48757824e-02f, 1.86746083e-02f, -8.49099532e-02f, 6.60721362e-02f, 1.16887763e-01f, -6.79710060e-02f,
  -2.82486575e-03f, 9.41765383e-02f, 8.46070424e-02f, 3.83833386e-02f, 1.28212109e-01f, 1.25956565e-01f, -1.63134467e-02f, 5.09788804e-02f, 7.93905277e-03f, 4.57410887e-02f,
  2.29672372e-01f, 2.17837349e-01f, -6.60081744e-01f, 3.31236005e-01f, -1.35502055e-01f, -1.55679569e-01f, -5.10277376e-02f, 8.57535973e-02f, 1.84543326e-01f, 2.64586419e-01f,
  3.88770103e-02f, -3.04111000e-02f, 6.20220751e-02f, -1.21223349e-02f, -2.25831613e-01f, -8.31505135e-02f, -1.62667379e-01f, -2.55683571e-01f, -3.70146424e-01f, 9.56184193e-02f,
  3.72639388e-01f, 2.13968247e-01f, 1.93101913e-01f, 6.55273572e-02f, 6.62314296e-02f, 3.60386409e-02f, 1.72014534e-02f, 2.47147363e-02f, -1.25457183e-01f, 4.10478413e-02f,
  -2.77379453e-01f, -1.16383739e-01f, -2.93718904e-01f, -8.69733617e-02f, -2.55020201e-01f, 5.27189374e-02f, -3.07704159e-03f, -1.80026472e-01f, -1.09531537e-01f, -4.15595397e-02f,
  -1.00849725e-01f, 1.91919282e-02f, -1.26076221e-01f, 1.08795680e-01f, 4.88784835e-02f, -3.40444557e-02f, -1.21489493e-02f, -1.24548785e-01f, -1.57064021e-01f, -2.13783801e-01f,
  1.44406199e-01f, -2.30604813e-01f, -3.53765339e-01f, -1.82411999e-01f, -2.36952871e-01f, -1.97644070e-01f, -2.64984220e-01f, -2.70614982e-01f, -2.81317979e-01f, 1.14839621e-01f,
  4.13209051e-02f, -1.99351041e-03f, 4.15805243e-02f, 4.57014367e-02f, 1.08547442e-01f, 5.96681163e-02f, -4.24841307e-02f, -9.64918360e-03f, 3.38783227e-02f, 9.65990946e-02f,
  -1.50275052e-01f, -4.71773222e-02f, -4.46454529e-03f, 4.74826135e-02f, -3.70801950e-04f, -2.05993764e-02f, -5.29611185e-02f, 3.81042324e-02f, -8.13274384e-02f, 4.12755534e-02f,
  -8.00057650e-02f, -1.28927482e-02f, 3.61348242e-02f, -2.42974367e-02f, -1.08945452e-01f, -8.01716279e-03f, -2.84952242e-02f, -3.78974155e-02f, 8.82411972e-02f, 5.86020164e-02f,
  3.49603266e-01f, -5.86994551e-02f, 4.06236947e-02f, -4.19471599e-02f, -3.66628431e-02f, -4.72838990e-02f, 3.58536690e-02f, -1.54475838e-01f, 3.05730440e-02f, 5.37398495e-02f,
  -1.52933538e-01f, 4.47837228e-04f, 1.51320482e-02f, 7.14139119e-02f, 6.79674596e-02f, 8.16578642e-02f, 1.06106356e-01f, -8.34144652e-02f, 1.65170189e-02f, 1.27321869e-01f,
  1.77722543e-01f, 2.65915804e-02f, 7.22412616e-02f, -7.91810900e-02f, 1.53180659e-02f, 5.18589877e-02f, 3.42710055e-02f, 3.26451380e-03f, -5.59544303e-02f, 4.51083094e-01f,
  2.04112172e-01f, -4.49148208e-01f, -3.70880097e-01f, -3.45344871e-01f, -2.51396418e-01f, -1.91790193e-01f, -3.34649473e-01f, -1.38290629e-01f, -7.51503035e-02f, -2.54134685e-01f,
  3.60566266e-02f, 8.75300840e-02f, 9.25789997e-02f, -2.38667056e-02f, -2.99184155e-02f, -2.30982170e-01f, -3.63098502e-01f, 1.67374779e-03f, -2.14417819e-02f, -8.66393000e-02f,
  -2.01851174e-01f, -2.52275795e-01f, -7.17683807e-02f, -1.06660515e-01f, -1.34721816e-01f, 1.88366789e-02f, -1.08516186e-01f, -1.87016666e-01f, -1.47589236e-01f, -1.69284120e-01f,
  -7.15969279e-02f, 2.36687869e-01f, 2.44267564e-02f, 4.19377089e-02f, 4.86929305e-02f, 1.18198656e-01f, 8.61022919e-02f, 7.11040795e-02f, -3.79182175e-02f, -2.96947211e-02f,
  5.06357215e-02f, -2.26089060e-02f, 1.48867726e-01f, 2.63897311e-02f, 5.37446849e-02f, 1.11229450e-01f, 1.43698812e-01f, 2.83458293e-03f, 3.61099727e-02f, -3.68408188e-02f,
  1.10862002e-01f, 1.97586000e-01f, 1.90341800e-01f, 8.84888992e-02f, 2.34733567e-01f, 1.19948506e-01f, 3.38449217e-02f, 2.60968149e-01f, 2.43462577e-01f, 1.75627351e-01f,
  -3.51264724e-03f, 6.19731694e-02f, 1.68227896e-01f, 9.76958126e-02f, 2.01020077e-01f, 1.50197193e-01f, -2.33950131e-02f, -6.35851324e-02f, 3.56329121e-02f, 1.21130168e-01f,
  -1.13886513e-01f, 4.56595123e-02f, -6.10420443e-02f, -8.16790462e-02f, -1.56743880e-02f, 6.35569170e-02f, 8.51462316e-03f, 4.66888361e-02f, 1.76542044e-01f, 7.12769330e-02f,
  1.35003343e-01f, -4.90639955e-02f, -6.93258792e-02f, 4.27670367e-02f, -6.46440387e-02f, 2.08096206e-02f, 6.17401451e-02f, 1.21009231e-01f, -1.37752574e-02f, -3.06989234e-02f,
  -1.09759286e-01f, 2.44170323e-01f, -3.19127403e-02f, 8.35420266e-02f, -1.39259519e-02f, -5.59201092e-02f, 4.00541350e-03f, -1.49873644e-01f, -3.46234329e-02f, -3.52709033e-02f,
  9.76338834e-02f, 1.28942961e-02f, -7.65025392e-02f, -2.46175509e-02f, -3.21996883e-02f, 5.01899049e-02f, 9.18052122e-02f, -5.51563688e-02f, -1.69091823e-03f, -4.63933572e-02f,
  -9.55363084e-03f, 7.89700449e-02f, 2.48082895e-02f, 9.87171531e-02f, 1.17885657e-01f, 1.06788270e-01f, 1.18821524e-01f, 4.64148149e-02f, 1.36452764e-01f, -1.07744314e-01f,
  2.24427208e-01f, -3.18446398e-01f, 1.38730749e-01f, -2.20914990e-01f, 6.38556574e-03f, 2.26535380e-01f, 1.75537840e-02f, -7.87125807e-03f, -1.04103774e-01f, -9.93657038e-02f,
  1.03412628e-01f, 1.63445547e-01f, 1.45335808e-01f, 7.85257891e-02f, 1.63870499e-01f, -1.84150130e-01f, -3.60130332e-02f, 1.81338489e-01f, 3.36424053e-01f, 1.26049161e-01f,
  -9.31920260e-02f, -2.60976315e-01f, -1.47514388e-01f, -1.98715582e-01f, -4.42437708e-01f, 7.33019635e-02f, -2.01351359e-01f, -1.63236186e-01f, 2.75791287e-02f, -4.02172029e-01f,
  7.89581314e-02f, -2.67666159e-03f, 6.54059052e-02f, 7.71869123e-02f, -8.81819278e-02f, 4.67911735e-02f, 1.22127451e-01f, -1.15014344e-01f, -1.32322023e-02f, -9.72882807e-02f,
  2.05630455e-02f, -8.82764012e-02f, 4.07597935e-03f, -4.88507189e-02f, -2.57484280e-02f, -1.50395045e-02f, -1.78307503e-01f, -6.57445714e-02f, -1.16681522e-02f, -1.20602325e-01f,
  -1.68517485e-01f, -1.10482991e-01f, -2.82769389e-02f, -4.71554138e-02f, -2.39715930e-02f, 5.96724711e-02f, -4.83259112e-02f, -2.62828618e-02f, 8.31949860e-02f, -2.77162880e-01f,
  -1.10529236e-01f, -2.82770372e-03f, 1.39730358e-02f, -1.96710639e-02f, -3.43370326e-02f, 1.46605482e-03f, 5.55689298e-02f, 6.65985420e-02f, -5.82007393e-02f, -8.04055855e-02f,
  -8.42044279e-02f, 4.71701473e-03f, 3.09807211e-02f, -7.16391578e-02f, -1.70122180e-02f, -3.22160907e-02f, -7.22727031e-02f, -2.82004047e-02f, 9.37710777e-02f, -7.69364042e-03f,
  -5.43218292e-03f, -9.62735433e-03f, 3.88256200e-02f, 5.82906790e-02f, -1.89246591e-02f, 5.38185760e-02f, -4.25344855e-02f, 6.13454580e-02f, 6.18089130e-03f, 4.87422273e-02f,
  -9.96879041e-02f, 2.83417135e-01f, 1.23625249e-02f, 7.67202526e-02f, 7.53219575e-02f, -3.70585360e-02f, 9.30302292e-02f, 5.97644150e-02f, 5.71045093e-02f, 8.46382305e-02f,
  2.34365631e-02f, 7.23547861e-02f, -7.85247597e-04f, -6.01492263e-02f, 5.77292815e-02f, 1.04224212e-01f, -9.86311585e-02f, -1.14017669e-02f, 4.47978154e-02f, -1.66549832e-01f,
  -1.71991542e-01f, 9.89010707e-02f, 1.69953033e-01f, 2.56010443e-02f, -6.35655597e-02f, 2.07610860e-01f, 1.13199949e-01f, 7.09226355e-02f, 1.46747351e-01f, -5.11465780e-02f,
  4.28036630e-01f, 2.55992919e-01f, 2.47342467e-01f, 1.43662512e-01f, 6.36612475e-02f, 1.15955040e-01f, 2.15530962e-01f, 8.17386359e-02f, 3.30274105e-02f, 1.19769357e-01f,
  -3.20246257e-02f, -4.37005199e-02f, -3.98930535e-02f, 2.04827450e-02f, 1.65995896e-01f, 1.63358767e-02f, 2.82987189e-02f, 1.21493444e-01f, 1.60180241e-01f, 1.04819983e-01f,
  -1.19419117e-02f, 2.53687594e-02f, 1.29751891e-01f, 3.90600637e-02f, 9.35704410e-02f, -6.39318824e-02f, -4.41798158e-02f, -2.63168802e-03f, 9.65796262e-02f, -1.26998136e-02f,
  2.44407281e-02f, 2.85655826e-01f, -1.76983878e-01f, -1.26560405e-01f, -6.53244928e-02f, -9.47858468e-02f, 4.21011671e-02f, -2.92969514e-02f, -9.00102928e-02f, -9.16893929e-02f,
  -2.46493146e-02f, -1.82136614e-02f, 2.10940726e-02f, 2.83362791e-02f, 2.19414812e-02f, -6.45650504e-03f, -3.24595496e-02f, 3.95859033e-02f, -6.79716794e-03f, -3.19260266e-03f,
  -1.35348991e-01f, 3.15869674e-02f, 1.55984938e-01f, 8.08927640e-02f, 5.63136116e-02f, -9.97861251e-02f, 8.68169963e-02f, 9.50243548e-02f, 1.88117307e-02f, 5.34332171e-03f,
  -1.32624879e-01f, 2.32360680e-02f, 8.13241675e-02f, 1.13119148e-02f, -5.40248565e-02f, -1.37031078e-01f, 7.40363151e-02f, 5.16124517e-02f, -3.29705025e-03f, -4.90656774e-03f,
  5.00006117e-02f, -3.82392146e-02f, 5.26673310e-02f, 1.50673334e-02f, 1.38262231e-02f, 8.81474018e-02f, -2.02710498e-02f, -1.55843291e-02f, -1.65388063e-02f, -1.21002533e-01f,
  -4.56167869e-02f, -2.35119183e-02f, 2.11355742e-02f, 7.26584345e-02f, -1.39486045e-01f, 5.51171228e-02f, 2.21193191e-02f, 1.89574924e-03f, -5.54538071e-02f, -1.25438467e-01f,
  -3.34291130e-01f, -1.84620515e-01f, -1.71064094e-01f, -7.69150853e-02f, -5.05919568e-02f, -1.01271696e-01f, -3.53271514e-02f, -2.95045171e-02f, -7.76025802e-02f, -5.19978032e-02f,
  9.56037939e-02f, 3.77396233e-02f, -8.80872533e-02f, -5.26211113e-02f, -1.50872126e-01f, -1.28721580e-01f, -1.59578890e-01f, -9.89083201e-02f, -2.59402748e-02f, -7.50777051e-02f,
  -5.64457886e-02f, -6.51204064e-02f, -6.55214712e-02f, 4.38763835e-02f, -6.42398968e-02f, -1.61710545e-01f, -4.51634787e-02f, -9.16377977e-02f, 3.71350050e-02f, -6.44631609e-02f,
  -3.36364865e-01f, -3.12025785e-01f, -9.18185487e-02f, -4.25097674e-01f, -2.62329161e-01f, -1.38034329e-01f, -2.05214754e-01f, -6.66676089e-02f, -1.41199648e-01f, -3.14040035e-01f,
  -2.17079133e-01f, -4.56225611e-02f, 5.13229817e-02f, 1.55709311e-01f, 2.96733618e-01f, -1.23872228e-01f, 3.19442376e-02f, 3.05435717e-01f, 4.76280898e-01f, 9.43729002e-03f,
  1.61760133e-02f, -1.06149249e-01f, 2.34340280e-01f, 9.98045430e-02f, -3.89108717e-01f, -1.31792977e-01f, -9.40355062e-02f, -1.08558536e-01f, -4.86609004e-02f, -3.51178586e-01f,
  -2.66354203e-01f, -1.10560119e-01f, 7.29759112e-02f, 1.64188165e-02f, -1.06274605e-01f, 9.85133275e-02f, -4.29076999e-02f, -1.43000513e-01f, 1.49635421e-02f, 4.35244897e-03f,
  -3.44157219e-02f, 1.29288863e-02f, -1.20190217e-03f, 1.55363437e-02f, -1.78563595e-01f, -4.98785116e-02f, -3.88069488e-02f, 2.53325589e-02f, 2.39679422e-02f, 4.45153750e-02f,
  -1.07080661e-01f, 4.00323942e-02f, 2.23553088e-03f, 9.96226221e-02f, 3.68553847e-02f, 1.36523530e-01f, -6.68003410e-02f, 9.69805568e-02f, 1.24130651e-01f, -1.83533609e-01f,
  5.78124030e-03f, -9.75645483e-02f, -1.02240749e-01f, 1.27028301e-01f, -6.44857064e-04f, -8.29290375e-02f, 1.19454544e-02f, 4.76532988e-03f, -3.69154885e-02f, 3.98408026e-02f,
  -2.18816735e-02f, 1.18938498e-02f, 9.48542506e-02f, -2.44882721e-02f, -4.75300588e-02f, -2.91238800e-02f, -3.57821286e-02f, -1.02838501e-01f, -2.09825411e-02f, 8.06601904e-03f,
  -1.61845349e-02f, 9.43514705e-03f, 4.84573618e-02f, -1.25610912e-02f, 1.42771944e-01f, 2.85133882e-03f, -1.43161118e-02f, 8.09758157e-02f, -9.08674300e-03f, -9.95823182e-03f,
  -2.77591020e-01f, 2.60765970e-01f, -1.78072259e-01f, 5.85665219e-02f, -5.78287467e-02f, -6.44955188e-02f, -9.53495130e-02f, 7.36256018e-02f, -2.58617308e-02f, -5.11919260e-02f,
  3.20981853e-02f, -2.45469920e-02f, 1.10139442e-03f, 1.55196665e-03f, -4.57883775e-02f, -2.07624063e-02f, -9.43125039e-03f, 4.79732901e-02f, 1.39022917e-01f, 1.02411341e-02f,
  7.52162114e-02f, 1.16024844e-01f, 6.94656931e-03f, -6.33607581e-02f, -6.21338673e-02f, 1.48666546e-01f, -5.82848005e-02f, -6.99302405e-02f, 6.43101558e-02f, -2.74518043e-01f,
  3.88295174e-01f, 1.74638897e-01f, 2.81290054e-01f, 1.02035124e-02f, 2.89077256e-02f, 9.00605321e-02f, 1.50023341e-01f, 1.23351403e-01f, -2.78561041e-02f, -4.07474898e-02f,
  -1.06081739e-01f, -1.57377616e-01f, -9.85471234e-02f, -1.32016778e-01f, 9.06525180e-02f, 3.40052508e-02f, 1.32384002e-01f, 2.62227237e-01f, 8.18454176e-02f, 8.64263400e-02f,
  -5.18105645e-03f, 7.26040006e-02f, 3.07599634e-01f, 1.88507527e-01f, 4.28334996e-03f, -1.21298030e-01f, 1.19294524e-01f, 1.05435677e-01f, 5.30906916e-02f, -4.66569848e-02f,
  1.68718249e-01f, 2.06470087e-01f, -2.66434960e-02f, -5.85683547e-02f, 4.99838181e-02f, 3.76793928e-02f, 1.14301890e-01f, -3.28204036e-02f, -3.47133875e-02f, -9.25509781e-02f,
  -3.67417857e-02f, -2.10891180e-02f, 4.14059497e-02f, 1.32509144e-02f, 1.44189939e-01f, 4.51550372e-02f, 3.74588147e-02f, 1.15991995e-01f, 2.50162221e-02f, 8.04410651e-02f,
  -7.54861981e-02f, 6.01071492e-02f, 5.38759539e-03f, 8.73102900e-03f, 1.14443354e-01f, 5.25810570e-02f, 8.35720152e-02f, -5.31343976e-03f, 1.08107314e-01f, -2.60260664e-02f,
  3.10361460e-02f, 5.70641644e-02f, -2.43375488e-02f, 1.17205828e-01f, -2.95167975e-02f, 1.82248093e-02f, 3.82825844e-02f, -7.44309127e-02f, 1.70364141e-01f, 1.56453282e-01f,
  -2.09637377e-02f, -3.69488671e-02f, 1.42518908e-01f, 3.69662531e-02f, -3.39059643e-02f, 5.53875193e-02f, 5.40071726e-02f, -7.56111322e-03f, 6.39034733e-02f, -3.62950489e-02f,
  -5.06166369e-02f, 2.34880242e-02f, 2.66188625e-02f, 9.98562425e-02f, 3.36472265e-04f, 5.26625104e-02f, -2.46200748e-02f, -3.92947122e-02f, 4.15697806e-02f, 9.73751992e-02f,
  -7.93141052e-02f, 1.70935560e-02f, -8.49187747e-02f, 9.01227668e-02f, 1.03274003e-01f, -4.83339466e-03f, -1.18122414e-01f, -1.59414500e-01f, -7.48688653e-02f, -9.86325741e-02f,
  -3.84557843e-02f, 4.85320166e-02f, 8.69549960e-02f, 9.05990973e-02f, -3.33645232e-02f, 4.25743125e-03f, -6.49756193e-02f, -4.62011360e-02f, -1.17365777e-01f, -1.20534614e-01f,
  -1.16636381e-01f, -8.61851722e-02f, -1.18695296e-01f, -7.22154751e-02f, -4.35880851e-03f, -2.08002739e-02f, -1.05170570e-01f, 2.89856307e-02f, -3.65496390e-02f, -4.38040867e-02f,
  2.40810856e-01f, 2.20989361e-01f, 2.18795344e-01f, 2.02601075e-01f, -9.98365730e-02f, -1.80362329e-01f, -1.57198325e-01f, -1.14530940e-02f, 2.28460774e-01f, 1.45262852e-01f,
  2.76351906e-02f, -1.40388563e-01f, -5.27989194e-02f, -2.03304559e-01f, -2.55938202e-01f, 4.23656479e-02f, 9.37713236e-02f, -1.46083489e-01f, -3.71649593e-01f, -3.37383449e-01f,
  -1.81695759e-01f, -8.61240402e-02f, 2.23767459e-02f, 5.53813204e-02f, 1.46654919e-01f, -1.43000349e-01f, 1.39571056e-01f, -1.83575470e-02f, 5.95089346e-02f, 2.82499164e-01f,
  2.41521344e-01f, 1.61976337e-01f, -1.90869346e-01f, -4.07257639e-02f, 3.63679440e-03f, 1.41887531e-01f, 4.11162972e-02f, 1.25611097e-01f, 1.23572499e-01f, 1.35985821e-01f,
  1.22150317e-01f, 1.29614815e-01f, -6.00864878e-03f, -2.78775170e-02f, 8.74723569e-02f, 7.19588948e-03f, 1.34819329e-01f, -2.54190862e-02f, 3.23178321e-02f, 1.08838595e-01f,
  -1.68887209e-02f, -1.22307196e-01f, -1.14150606e-01f, -4.08177301e-02f, -3.56827118e-02f, -1.91429242e-01f, 2.85533350e-02f, 4.79212077e-03f, -2.68613100e-02f, 1.38013497e-01f,
  -1.33077189e-01f, 1.10159911e-01f, -5.22889420e-02f, -6.71432540e-02f, -4.77954932e-02f, 6.44951314e-02f, -1.35541251e-02f, -2.81524230e-02f, -1.25457987e-01f, 2.43920591e-02f,
  1.26943201e-01f, -1.25580207e-01f, -1.94113161e-02f, -7.07797781e-02f, 7.08867759e-02f, 4.25211750e-02f, 7.74846524e-02f, -8.25365111e-02f, 1.08333938e-02f, 1.24266766e-01f,
  -8.44434872e-02f, 1.11810230e-01f, 3.60203348e-02f, 2.59467307e-02f, -1.42262764e-02f, 4.53470927e-03f, -6.63913265e-02f, -5.00662401e-02f, 7.04165325e-02f, 2.04279162e-02f,
  -4.61055040e-02f, -4.23612475e-01f, 1.17498018e-01f, 1.69506669e-01f, 8.92492980e-02f, 2.08082244e-01f, 7.44572207e-02f, 2.81259082e-02f, 8.92916024e-02f, -3.39835063e-02f,
  -1.05295099e-01f, 1.17500909e-01f, 5.04344516e-02f, 1.18855551e-01f, -7.99003169e-02f, -4.54193652e-02f, 3.49364616e-02f, 1.21693239e-01f, 3.40870917e-02f, 2.44576558e-01f,
  1.82006657e-01f, -8.86569619e-02f, -1.57770142e-01f, -2.01580748e-02f, -9.63793024e-02f, -2.23289520e-01f, -6.79135695e-02f, -3.90007794e-02f, -9.59141180e-02f, -1.98069915e-01f,
  -5.11631250e-01f, -2.54026502e-01f, 3.39174159e-02f, -2.94876367e-01f, -6.20062836e-02f, 3.45779061e-02f, 1.69026926e-01f, -1.34592190e-01f, -3.26396734e-01f, -1.74154952e-01f,
  -2.63315558e-01f, -2.82036781e-01f, -2.49966413e-01f, -1.42603457e-01f, -2.60245204e-01f, -3.70337218e-02f, 1.85227059e-02f, -3.58631425e-02f, 1.18785188e-01f, -6.32172674e-02f,
  -1.51592597e-01f, -1.72134116e-01f, -2.43847281e-01f, -2.32164189e-01f, -3.22026424e-02f, -1.33931205e-01f, -1.21399008e-01f, -2.10755542e-01f, -6.53383955e-02f, -9.02957842e-02f,
  2.62032241e-01f, -3.83090436e-01f, 7.93355852e-02f, -1.70591250e-01f, -1.26850247e-01f, -1.26373217e-01f, -1.84914634e-01f, 1.73943036e-03f, -7.68050626e-02f, 2.02803425e-02f,
  -1.60582498e-01f, 1.73132624e-02f, -9.74738412e-03f, -3.23866308e-02f, -9.39252675e-02f, 3.69541571e-02f, -4.33991253e-02f, -2.12551896e-02f, -9.25707370e-02f, 3.19209062e-02f,
  -1.20438389e-01f, -7.02444464e-02f, 4.38427366e-02f, 1.83820017e-02f, -1.11162849e-01f, -4.87496182e-02f, 3.39723378e-02f, -2.56585069e-02f, 6.49996251e-02f, 1.51534239e-02f,
  1.37990713e-01f, 9.13416073e-02f, -1.06032990e-01f, -8.37481916e-02f, 4.10119444e-02f, 5.35549186e-02f, -2.60998914e-03f, -5.04406877e-02f, -9.75548998e-02f, -1.13763802e-01f,
  7.32117444e-02f, -2.90387385e-02f, -9.03973728e-02f, -1.06176451e-01f, -1.13006860e-01f, -1.17184043e-01f, -6.45427331e-02f, -1.79741383e-02f, 1.09274546e-02f, -1.21411726e-01f,
  -1.40991688e-01f, -5.12167700e-02f, -1.30484283e-01f, -1.06262311e-01f, -1.70484241e-02f, -1.11762807e-01f, -3.53387035e-02f, -1.75876737e-01f, 1.14533007e-02f, -1.24802209e-01f,
  9.21882316e-02f, -1.13021158e-01f, 1.52273968e-01f, -7.67546147e-02f, 6.34848550e-02f, -6.28767833e-02f, -9.00102034e-02f, 4.48745899e-02f, -6.03135303e-02f, -5.28654978e-02f,
  -1.90259799e-01f, 5.58609404e-02f, 2.05513425e-02f, 3.15337330e-02f, 3.77355553e-02f, 4.72277887e-02f, 5.49995282e-04f, 1.58070460e-01f, 9.33264419e-02f, 1.90914702e-03f,
  7.88984522e-02f, 1.11537561e-01f, 1.94123358e-01f, 1.71985626e-01f, 7.96193108e-02f, 2.01490909e-01f, 2.17737719e-01f, 6.12736084e-02f, 2.21163124e-01f, 3.43610018e-01f,
  -7.29396403e-01f, 1.90840259e-01f, -9.25815329e-02f, -5.00231028e-01f, -2.91345537e-01f, -1.28301576e-01f, 5.13891652e-02f, -5.47680371e-02f, -1.56791657e-01f, 1.27055764e-01f,
  2.12346330e-01f, 3.71395126e-02f, -6.40249699e-02f, 7.28651732e-02f, -9.82744712e-03f, 5.42146713e-02f, -1.97641358e-01f, -3.40008974e-01f, -3.14964205e-01f, -4.34970343e-03f,
  -5.36733232e-02f, -3.92417431e-01f, -4.06949669e-01f, -1.06666766e-01f, -3.78006650e-03f, -1.03100002e-01f, -1.07295185e-01f, -1.31571501e-01f, 1.72736440e-02f, -1.02861367e-01f,
  2.80400157e-01f, -3.03040326e-01f, -1.14373378e-01f, -1.81672886e-01f, -6.37854412e-02f, 1.78605262e-02f, -8.39627609e-02f, -1.36559546e-01f, -2.95010917e-02f, 1.10029094e-02f,
  -1.95457518e-01f, 3.36182788e-02f, -5.79873212e-02f, -5.71203046e-03f, -1.84828602e-02f, -1.76741444e-02f, 4.91099544e-02f, -1.23847812e-01f, 2.50149909e-02f, 2.51290649e-01f,
  8.43511149e-02f, -1.32645100e-01f, -5.42090796e-02f, 1.87919855e-01f, 1.19788557e-01f, -1.28651246e-01f, 1.99334249e-01f, 9.50942785e-02f, -1.15954969e-02f, 9.45002735e-02f,
  7.25802779e-02f, 8.73145536e-02f, -1.19860955e-02f, 2.14293343e-03f, -3.67658623e-02f, 5.53219058e-02f, -1.60940345e-02f, 2.26557180e-02f, -2.76879333e-02f, 2.91687082e-02f,
  -1.93951577e-02f, 4.63399962e-02f, 1.06928619e-02f, -1.53136015e-01f, 3.71829122e-02f, -6.13626279e-02f, -1.05295852e-01f, 1.73478216e-01f, -7.87567254e-03f, -3.08536831e-02f,
  -2.80381683e-02f, 6.80467263e-02f, -7.35124201e-02f, 2.71066595e-02f, 6.97236806e-02f, -8.28599557e-02f, -5.40271141e-02f, 2.04803236e-02f, 9.43574384e-02f, -8.37445855e-02f,
  7.32301921e-02f, -2.78581351e-01f, -5.48177585e-02f, 4.32829112e-02f, -6.87567741e-02f, 1.63620800e-01f, 6.95243999e-02f, -5.45166582e-02f, -1.11924753e-01f, 9.16718133e-03f,
  3.46210524e-02f, -2.60391459e-02f, -4.77392739e-03f, 1.40122607e-01f, 3.51339690e-02f, 3.09358425e-02f, 1.03633031e-01f, -7.45413750e-02f, 4.54288162e-02f, 1.67593971e-01f,
  1.62523195e-01f, 4.42285510e-03f, 8.90931487e-02f, 8.35530013e-02f, 5.54622784e-02f, -1.68317452e-01f, 1.25964552e-01f, 4.94622886e-02f, 6.53240606e-02f, 2.05530882e-01f,
  2.64223784e-01f, 1.41597778e-01f, 5.90055101e-02f, 2.99848288e-01f, 1.04786359e-01f, -2.03641251e-01f, -2.93306381e-01f, -3.43519092e-01f, -6.45432025e-02f, 1.14316009e-01f,
  1.93436801e-01f, -4.87133488e-02f, 1.67879239e-02f, -1.12734094e-01f, -3.70417506e-01f, -9.59601253e-02f, -1.18729502e-01f, -2.57651329e-01f, -4.22852248e-01f, -2.17839777e-01f,
  2.55999863e-02f, 5.27287796e-02f, -2.46238708e-02f, -7.55181685e-02f, 2.05864966e-01f, 7.54077211e-02f, 1.82815477e-01f, 1.71577811e-01f, 1.77967772e-01f, 3.52996320e-01f,
  3.26233685e-01f, 1.14111267e-01f, -2.65435666e-01f, -2.92490162e-02f, 1.69436693e-01f, -8.97111557e-03f, 1.83334872e-02f, -2.84403525e-02f, -1.16817333e-01f, 1.94931068e-02f,
  2.14169458e-01f, -1.55539010e-02f, 1.67212248e-01f, 3.33186723e-02f, 6.42194925e-03f, -2.41415307e-01f, -1.26971826e-01f, -2.00102955e-01f, -6.77253380e-02f, 5.40251546e-02f,
  1.24852881e-02f, 2.77880222e-01f, 8.88190493e-02f, -2.90574014e-01f, -1.33704588e-01f, 3.98160890e-03f, -1.25792120e-02f, 1.81091111e-02f, -1.53964564e-01f, 2.16986760e-01f,
  -2.96166502e-02f, -8.24419633e-02f, 5.72966114e-02f, 1.19899176e-01f, -1.66462045e-02f, 4.30542380e-02f, 4.37464565e-02f, 2.62149628e-02f, -6.11166768e-02f, -3.58028561e-02f,
  -1.03629209e-01f, -1.54146552e-02f, 2.49162912e-02f, -7.62509461e-03f, 2.48595327e-02f, 4.82102670e-02f, -5.32903522e-02f, -7.51251131e-02f, -8.71575065e-03f, 4.68836874e-02f,
  2.91486550e-02f, -4.97405678e-02f, 5.60540967e-02f, -1.16514109e-01f, 1.02774166e-01f, -8.26961547e-02f, -1.80376042e-02f, 3.14735062e-02f, -4.28333059e-02f, -1.73536353e-02f,
  -3.69024314e-02f, -1.38306186e-01f, 1.34020329e-01f, -1.42239094e-01f, 4.56025265e-02f, 3.13503668e-02f, 3.59622315e-02f, -9.91340280e-02f, 1.23014987e-01f, -1.29880711e-01f,
  -5.55644967e-02f, -1.15728313e-02f, 8.12597126e-02f, -9.63354930e-02f, -5.49502037e-02f, -4.96742800e-02f, -3.55400778e-02f, -5.01269959e-02f, -1.52780041e-01f, 1.45944608e-02f,
  -3.84949706e-02f, -1.59978881e-01f, -3.96207459e-02f, -6.23539053e-02f, 8.17254856e-02f, -1.47719815e-01f, -9.10267830e-02f, -5.88949919e-02f, -2.20760182e-01f, -2.03224108e-01f,
  -5.36158867e-02f, 4.48277369e-02f, -2.04973653e-01f, 5.37535436e-02f, -2.35162556e-01f, -2.45261267e-01f, -1.81386352e-01f, 8.23683292e-02f, 1.07242018e-01f, 5.56928590e-02f,
  -8.44655558e-02f, 1.08043633e-01f, 1.32696763e-01f, 1.73295274e-01f, 1.11246482e-01f, 5.96338697e-02f, 2.97545642e-01f, 1.54278100e-01f, 9.14710313e-02f, 6.19431958e-02f,
  1.96011931e-01f, 4.63034250e-02f, 2.01836288e-01f, 1.54707804e-01f, 1.47364900e-01f, 4.77821603e-02f, 1.03014603e-01f, 5.05156927e-02f, -4.18085791e-02f, 3.04845780e-01f,
  -2.50507355e-01f, -6.03923798e-02f, -1.18070811e-01f, -6.38618246e-02f, -1.88931420e-01f, 1.06065623e-01f, -4.34226468e-02f, 1.14754163e-01f, 4.34095412e-02f, -6.58625690e-03f,
  -2.22982764e-02f, 3.61108943e-03f, 5.63096814e-02f, 1.00823790e-02f, 5.14895283e-03f, -9.94278863e-02f, 9.72779319e-02f, 1.55085459e-01f, 6.64140657e-02f, -1.38409957e-01f,
  4.03393582e-02f, -1.20342962e-01f, -1.81421414e-01f, -1.74012959e-01f, -1.29613101e-01f, -1.48320779e-01f, -1.08197011e-01f, -4.65882123e-02f, -2.48987749e-01f, 8.40143859e-02f,
  2.48149037e-02f, -4.52181846e-02f, 1.77959539e-02f, 2.55003646e-02f, 4.93088178e-02f, -3.58853079e-02f, 2.56289691e-02f, 3.90418582e-02f, 6.91401213e-02f, 2.05758866e-02f,
  -1.13094207e-02f, -7.71140158e-02f, 3.21492143e-02f, -1.74802598e-02f, 8.04135203e-02f, -3.39297131e-02f, -3.50494199e-02f, 2.42844522e-02f, -5.57406945e-03f, -1.30041480e-01f,
  3.30176614e-02f, -9.31226090e-02f, 7.42561743e-02f, 1.33441225e-01f, -1.32076908e-02f, 7.77452365e-02f, 5.73644415e-02f, 5.18292096e-03f, -8.46529379e-03f, 2.94308122e-02f,
  -2.26733625e-01f, -2.28498682e-01f, 7.76100606e-02f, 1.69877589e-01f, -1.10327013e-01f, -6.68914691e-02f, -4.78386171e-02f, -1.33953793e-02f, -1.15037717e-01f, 3.10402624e-02f,
  -1.87810332e-01f, -3.71424407e-02f, -5.88142723e-02f, -4.49649058e-03f, 4.18380089e-03f, -1.76851094e-01f, -6.15900122e-02f, -1.09738410e-01f, -2.05654316e-02f, -1.12095967e-01f,
  3.56169720e-03f, -1.05978161e-01f, -2.32043862e-01f, -1.76699519e-01f, -9.84158218e-02f, -1.48611531e-01f, -1.53641552e-01f, -2.08911970e-01f, -2.07923576e-01f, -1.62037417e-01f,
  -7.95880675e-01f, -1.72943577e-01f, 3.19077581e-01f, -1.54327139e-01f, 9.93219670e-04f, 6.39828891e-02f, 3.25777009e-02f, -1.14334635e-01f, -1.18987441e-01f, 3.72413709e-03f,
  -1.95766345e-01f, -1.02681100e-01f, -5.20029664e-02f, -3.88385132e-02f, 8.62898678e-02f, 1.02891736e-01f, 1.49425238e-01f, 1.66806430e-01f, 1.10928267e-01f, 1.69565380e-01f,
  5.81186563e-02f, 8.51199552e-02f, -1.25141978e-01f, -7.33325630e-02f, -3.19181214e-04f, -5.29893711e-02f, 2.85719801e-02f, 9.37215760e-02f, 1.20838270e-01f, 1.45434618e-01f,
  5.46310723e-01f, -1.12448446e-01f, -1.33958962e-02f, -3.09331436e-02f, -3.89948674e-02f, -1.35931954e-01f, -6.26022145e-02f, 3.97668630e-02f, 5.19513711e-02f, 7.59964511e-02f,
  3.83262783e-02f, 2.86615714e-02f, -7.19955266e-02f, -3.87348980e-02f, 5.95933273e-02f, 4.94406596e-02f, -1.65891245e-01f, -4.34034765e-02f, 1.19981140e-01f, 3.19365300e-02f,
  -3.46226208e-02f, 7.40831420e-02f, 1.10003628e-01f, -1.11597069e-02f, -1.11207657e-01f, 4.84904908e-02f, 6.76340684e-02f, -6.31547794e-02f, -3.77969705e-02f, -5.64505309e-02f,
  -2.10418813e-02f, -1.11933500e-01f, -1.16440907e-01f, -9.15008113e-02f, -2.15049803e-01f, -5.61199598e-02f, 1.58441588e-01f, 7.91824833e-02f, -8.02784860e-02f, -1.00975610e-01f,
  5.84415272e-02f, 6.54471293e-02f, 5.67717776e-02f, 1.38492510e-01f, -4.22440097e-02f, -8.19055550e-03f, -7.27146119e-02f, 4.92367595e-02f, 5.63341826e-02f, -1.42776981e-01f,
  -1.48725733e-02f, 1.13704711e-01f, 6.59157336e-02f, 1.95647016e-01f, 1.37613893e-01f, 1.02899581e-01f, 8.65438953e-02f, -7.00362623e-02f, -3.26578170e-02f, -4.33405302e-02f,
  3.62511694e-01f, -1.48445934e-01f, -5.13428356e-03f, -8.41676071e-02f, 7.60253891e-02f, -9.25284401e-02f, 1.48779321e-02f, 4.13912572e-02f, 1.65803149e-01f, 2.21554458e-01f,
  5.49172312e-02f, -3.04863639e-02f, 3.28067839e-02f, -5.33091947e-02f, 8.78750309e-02f, -2.37300321e-02f, -7.67007396e-02f, 7.86009878e-02f, 5.22747226e-02f, 1.04234308e-01f,
  -5.21799251e-02f, 1.21424779e-01f, 1.42216533e-01f, 7.26039335e-02f, -1.22616871e-03f, 1.22838005e-01f, 1.78841934e-01f, 6.34622723e-02f, 1.08252794e-01f, 6.09758981e-02f,
  3.36497217e-01f, 3.34886163e-01f, 1.46610979e-02f, -6.47146329e-02f, 1.59025848e-01f, 5.62649630e-02f, 3.46657932e-01f, -8.84931255e-03f, -1.50927097e-01f, 7.91133642e-02f,
  6.60745800e-03f, -3.00452620e-01f, -9.05598179e-02f, -1.52693003e-01f, -4.57247086e-02f, 1.33432537e-01f, 1.04184687e-01f, -4.94829230e-02f, -1.17753185e-02f, -1.56192333e-02f,
  -7.68268853e-02f, 1.49678096e-01f, 1.68585896e-01f, -3.11885849e-02f, 1.80679094e-02f, -1.28342137e-01f, -3.15110162e-02f, 5.18887900e-02f, 4.40500788e-02f, -7.51183331e-02f,
  -1.52888834e-01f, 2.13724121e-01f, -1.88789174e-01f, -9.98733044e-02f, 3.48296687e-02f, -1.64788157e-01f, -7.12105185e-02f, -3.21336798e-02f, -6.51793629e-02f, 3.38299945e-02f,
  1.12229675e-01f, -3.29341507e-03f, 1.47012666e-01f, -5.61489649e-02f, 4.25803177e-02f, -3.58204283e-02f, 4.38175797e-02f, -2.91737784e-02f, -1.10229686e-01f, -4.54997197e-02f,
  -6.95821419e-02f, 1.77367777e-01f, 1.81626230e-01f, -5.23381531e-02f, -8.73802304e-02f, -1.98838875e-01f, 7.25501254e-02f, 6.98920898e-03f, -3.99845392e-02f, 4.26028529e-03f,
  -1.95624337e-01f, -3.17498669e-02f, -6.44042417e-02f, -8.81083086e-02f, -7.97747076e-02f, 6.21935911e-02f, -7.62865469e-02f, -1.83101892e-02f, -1.07085429e-01f, 4.94481437e-02f,
  -1.92118198e-01f, -1.47733435e-01f, -1.96599036e-01f, -7.59921372e-02f, -2.58986384e-01f, 2.71916483e-03f, -5.38761355e-02f, -1.40285119e-01f, -1.54057264e-01f, 3.02261170e-02f,
  4.27642558e-03f, -8.85771587e-02f, -4.40879837e-02f, -1.37003273e-01f, -1.23350829e-01f, -9.61423069e-02f, -2.44305670e-01f, -1.13541491e-01f, -1.65666230e-02f, 4.91500534e-02f,
  -2.34409660e-01f, -6.90078214e-02f, -1.12316921e-01f, 4.41745259e-02f, 5.16813509e-02f, -2.72224490e-02f, -2.80578196e-01f, -1.32620081e-01f, -6.59792423e-02f, -5.39270900e-02f,
  1.92546487e-01f, -6.12424947e-02f, -3.30798738e-02f, -1.12188786e-01f, -2.12991685e-02f, -6.55185729e-02f, -9.29327756e-02f, 7.56486505e-02f, -1.61213502e-01f, -9.02080312e-02f,
  7.34954001e-03f, 5.29250782e-03f, -2.31490843e-02f, -2.20592216e-01f, -1.05925225e-01f, -2.45864362e-01f, -2.08669044e-02f, 3.99445649e-03f, -1.08686246e-01f, 1.58861335e-02f,
  -4.00727093e-02f, -3.66380751e-01f, -2.36232877e-01f, 2.79194444e-01f, 1.70111164e-01f, -2.51466990e-01f, -4.05396730e-01f, -3.41940343e-01f, 5.55169843e-02f, -7.39768893e-02f,
  2.91969702e-02f, 2.40137339e-01f, 7.71865575e-03f, 1.07980985e-03f, -3.06737065e-01f, -2.17631042e-01f, -7.21141398e-02f, -6.80438206e-02f, 2.54341029e-02f, 1.08465455e-01f,
  1.84240043e-01f, 2.22857445e-01f, 2.18802333e-01f, 3.48737240e-02f, 2.28509650e-01f, 1.32232264e-01f, 6.62470981e-03f, 1.87987655e-01f, -4.82183620e-02f, 1.26407966e-01f,
  1.15191311e-01f, -5.26721729e-03f, -1.07920200e-01f, 1.57789394e-01f, 2.40010023e-01f, -2.59650294e-02f, -8.30972716e-02f, 7.00978711e-02f, 6.43756166e-02f, -1.09901249e-01f,
  1.82660237e-01f, 3.15909497e-02f, 9.66235399e-02f, 4.10356894e-02f, 1.83139235e-01f, -1.71429679e-01f, -1.20116733e-01f, -5.47910333e-02f, -1.19988531e-01f, -5.23555093e-03f,
  2.47622490e-01f, 1.65409952e-01f, -1.45215020e-01f, -1.83730721e-01f, -1.94212481e-01f, 5.94788194e-02f, -9.25784484e-02f, 6.79683313e-02f, -1.66311622e-01f, -1.50054544e-01f,
  -1.72290520e-03f, 8.48817974e-02f, 4.58287857e-02f, -1.01184025e-01f, -9.98687968e-02f, 1.10669553e-01f, 4.42877552e-03f, -1.88635979e-02f, -2.84278188e-02f, -3.89917418e-02f,
  -3.77846695e-02f, -5.14226174e-03f, 7.81237558e-02f, 1.10000633e-02f, -2.54136529e-02f, 4.20813598e-02f, -8.17028433e-02f, -2.45181248e-02f, -2.09204340e-03f, -4.61350903e-02f,
  1.27352104e-02f, -6.71463162e-02f, 1.29311711e-01f, 2.97789704e-02f, -1.07948974e-01f, -4.29280363e-02f, -4.45994623e-02f, -8.80186334e-02f, 6.04395047e-02f, 3.35074915e-03f,
  -4.85236347e-02f, -1.60625070e-01f, -5.23458682e-02f, 4.57198126e-04f, -1.84716901e-03f, -6.16965853e-02f, 8.09641033e-02f, -3.53224240e-02f, -1.98216438e-02f, -3.41905393e-02f,
  -1.75336823e-02f, -1.36595324e-01f, -2.40885969e-02f, 4.27029245e-02f, -2.84954235e-02f, 5.85947633e-02f, -1.09925710e-01f, -6.61445931e-02f, -3.62934940e-03f, 2.96731107e-02f,
  -1.88993067e-01f, -1.63937822e-01f, -2.14009643e-01f, -3.26533884e-01f, 8.60039145e-03f, -1.16693251e-01f, -2.30935574e-01f, -8.82865041e-02f, -2.80225456e-01f, -4.64696944e-01f,
  3.74634236e-01f, -2.63733715e-02f, -5.18098235e-01f, 1.38413936e-01f, -2.52359122e-01f, -2.96626061e-01f, -1.80154979e-01f, 1.12708986e-01f, 9.50780734e-02f, -4.66443636e-02f,
  -1.14221923e-01f, -4.92035449e-02f, -3.55751552e-02f, -1.42426252e-01f, -9.05626416e-02f, -1.97225168e-01f, -3.15855414e-01f, -1.54482529e-01f, -1.94222599e-01f, -2.82462332e-02f,
  -6.51375651e-02f, -1.21180266e-02f, 7.71061331e-02f, 3.17912698e-02f, -9.24137980e-02f, -1.15619786e-01f, -2.85029143e-01f, -1.52979463e-01f, -2.74259418e-01f, -2.94913977e-01f,
  -2.87546128e-01f, -5.50611950e-02f, -2.53241276e-03f, 1.67593248e-02f, 6.70184791e-02f, 1.19979773e-02f, 7.75085483e-03f, -1.68265104e-02f, 4.02451027e-03f, 1.20376209e-02f,
  -9.22027789e-03f, -3.97071913e-02f, -1.00985140e-01f, -7.45032430e-02f, -4.88125486e-03f, 2.24632397e-02f, -2.60573085e-02f, -1.51401341e-01f, -5.76978028e-02f, -1.47833630e-01f,
  -1.50335059e-01f, -2.74039060e-01f, -1.22904450e-01f, -7.74942786e-02f, -1.19798109e-01f, -5.27524315e-02f, -4.84080873e-02f, -8.97250697e-02f, -1.37909442e-01f, 1.20493509e-01f,
  8.92187282e-02f, 2.42830124e-02f, -5.50249480e-02f, 3.34393494e-02f, 2.14158557e-02f, -4.64924537e-02f, -5.03214076e-02f, 2.66193785e-02f, -1.66909769e-02f, -6.88872673e-03f,
  -4.02075239e-02f, -6.84785694e-02f, -1.49577493e-02f, 3.61905620e-02f, -8.38992670e-02f, -3.69734168e-02f, -5.20727970e-02f, -2.04904322e-02f, 2.17816792e-02f, 4.30302024e-02f,
  6.10842928e-02f, -1.07360631e-03f, 7.31899887e-02f, 9.69386324e-02f, -8.99824947e-02f, -9.57318954e-03f, -6.66912124e-02f, -5.86336218e-02f, -5.77846961e-03f, -5.28181158e-03f,
  2.38171831e-01f, -1.90738320e-01f, 1.34969145e-01f, 6.16099350e-02f, 3.04745771e-02f, -1.08971491e-01f, -2.42311899e-02f, 9.90495235e-02f, 3.24468012e-03f, 1.03629380e-01f,
  6.25534216e-03f, 9.35187712e-02f, -4.98290844e-02f, 2.65441146e-02f, -1.25202723e-02f, -1.69316247e-01f, 2.15591919e-02f, -1.36038378e-01f, -1.07809208e-01f, 8.10424387e-02f,
  -1.23676995e-03f, 1.78048096e-03f, 1.83928937e-01f, 1.03689529e-01f, 3.97053212e-02f, 1.06096901e-01f, 9.76964012e-02f, 4.78170402e-02f, 5.77198230e-02f, 3.22094351e-01f,
  4.61365551e-01f, -1.54835954e-02f, 1.48590654e-01f, 3.70238163e-02f, -7.23996479e-03f, 9.68825221e-02f, 6.38275892e-02f, 4.42812666e-02f, 5.08563593e-02f, 5.10947965e-02f,
  2.06710789e-02f, -6.04579896e-02f, -2.24411907e-03f, 3.02325040e-02f, -5.51001308e-03f, -5.96577190e-02f, 1.52011821e-02f, 6.72890916e-02f, 1.02348797e-01f, -2.32417434e-02f,
  -7.84090161e-02f, 5.51287942e-02f, 2.08963066e-01f, 5.37978448e-02f, -1.29569262e-01f, -6.59296140e-02f, -7.05784261e-02f, -9.42384154e-02f, 1.05712917e-02f, 3.83732580e-02f,
  -1.53564274e-01f, 1.29811749e-01f, 2.44355313e-02f, 3.81677300e-02f, -1.15045428e-01f, 5.35772257e-02f, -6.78687021e-02f, -7.49636889e-02f, -9.79671031e-02f, -2.13468308e-03f,
  -5.63478470e-02f, -1.32458419e-01f, -1.68605551e-01f, -1.27954274e-01f, -6.94323257e-02f, -4.00020890e-02f, -1.01491295e-01f, -1.25206620e-01f, -1.51504248e-01f, -7.67633393e-02f,
  -4.81332541e-02f, -2.71920785e-02f, -1.21116623e-01f, -1.27778322e-01f, -9.20577869e-02f, -1.12783834e-01f, -1.64949764e-02f, -1.24045037e-01f, -7.41823241e-02f, 1.13666216e-02f,
  -1.52916521e-01f, -1.64949134e-01f, -1.71929359e-01f, -2.12201267e-01f, -8.90879184e-02f, -3.25884647e-03f, -4.38083410e-02f, -8.31609219e-02f, -1.35397121e-01f, -9.75451320e-02f,
  -3.88154760e-02f, -1.64838582e-01f, -8.28449875e-02f, 5.86162396e-02f, -1.22558698e-02f, -2.04197451e-01f, -3.03568393e-02f, -1.57779172e-01f, -2.33986154e-01f, -9.24940184e-02f,
  -1.22769037e-02f, -1.25871062e-01f, -1.43487364e-01f, -1.22382358e-01f, -5.09835407e-02f, -1.25953496e-01f, -1.55515820e-01f, -1.41860187e-01f, -6.93580285e-02f, -3.19770048e-03f,
  -3.41166228e-01f, -6.27677962e-02f, 1.13404728e-01f, 9.46474448e-02f, 9.28732231e-02f, 1.01055428e-01f, 6.79784045e-02f, -5.85683063e-02f, 2.64089964e-02f, -5.30738430e-03f,
  1.42473862e-01f, 4.93415482e-02f, 8.65473691e-03f, -1.77418981e-02f, 6.45791972e-03f, 3.23869810e-02f, 5.91591112e-02f, 7.09535256e-02f, 3.12669873e-02f, 6.57704601e-04f,
  -1.00626200e-01f, 8.30861256e-02f, 3.10651902e-02f, 8.05248246e-02f, 6.06330782e-02f, 5.00733256e-02f, -7.60687236e-03f, -4.42670919e-02f, 5.87194376e-02f, 1.19010769e-01f,
  5.17109692e-01f, -2.80274749e-01f, -3.62360269e-01f, 9.99915302e-02f, -1.67332888e-01f, -2.04641297e-01f, -2.40844697e-01f, 7.67726451e-02f, 2.38858223e-01f, -2.00183898e-01f,
  -1.07672259e-01f, 2.80688614e-01f, 1.52792945e-03f, 1.66315794e-01f, 1.28840238e-01f, -2.58282274e-01f, -3.65546316e-01f, 3.66114974e-02f, 2.34315217e-01f, 2.18649074e-01f,
  7.10894167e-02f, 1.96324781e-01f, 2.43838221e-01f, 1.09660186e-01f, -1.19331464e-01f, 8.18710402e-02f, -2.37451166e-01f, -1.20334513e-01f, -1.80169433e-01f, -2.30444536e-01f,
  -8.87178928e-02f, 5.50162457e-02f, -1.44898957e-02f, 1.42232195e-01f, -1.17017433e-01f, 9.36957374e-02f, -1.36255324e-01f, -8.79595056e-02f, -1.20066091e-01f, -2.06563529e-02f,
  -5.59953712e-02f, 6.27557412e-02f, -9.94347930e-02f, 6.19635358e-02f, 1.06659167e-01f, 6.08360954e-02f, -1.25399670e-02f, 1.06121473e-01f, -1.09010354e-01f, -7.54161850e-02f,
  -2.05361739e-01f, -2.47633994e-01f, -1.54155150e-01f, -1.14915393e-01f, 7.92088807e-02f, -8.80694762e-02f, -5.53796925e-02f, 6.96790889e-02f, -4.43609320e-02f, -1.80951118e-01f,
  -9.70085487e-02f, -1.07716069e-01f, -1.62868172e-01f, 4.28961217e-03f, 2.08216794e-02f, -3.85767482e-02f, 1.34972052e-03f, -5.60801243e-03f, -4.75162175e-03f, -1.03226833e-01f,
  7.49472603e-02f, 1.65910069e-02f, -1.79580767e-02f, -1.37594283e-01f, 3.86429355e-02f, -1.26920253e-01f, -9.24358889e-02f, -1.15108751e-01f, -1.15542691e-02f, -1.82484183e-02f,
  -1.16933368e-01f, -5.55129685e-02f, -7.19898045e-02f, 6.19468056e-02f, -4.14427556e-03f, -2.52583064e-02f, 3.81172355e-03f, 3.21674830e-04f, 8.03025886e-02f, -4.42259237e-02f,
  1.70571521e-01f, -4.29412425e-02f, -1.59741640e-01f, 9.44667459e-02f, -6.17912114e-02f, 2.62744594e-02f, -3.04372404e-02f, -1.08937053e-02f, 4.07044776e-02f, 4.59292643e-02f,
  1.57043629e-03f, 1.03899702e-01f, -5.31641282e-02f, -2.37222873e-02f, -1.92447484e-03f, -7.44714681e-03f, -1.49204805e-02f, -1.71249770e-02f, -1.17905423e-01f, 8.13439116e-02f,
  -6.69040829e-02f, -9.36980247e-02f, 9.98854488e-02f, -7.87768140e-02f, -5.80682829e-02f, 5.89051135e-02f, -1.61870077e-01f, -1.12254150e-01f, -1.15700282e-01f, -2.42904276e-01f,
  -1.66105852e-01f, -3.82744730e-01f, 4.51485738e-02f, -1.79143101e-01f, 1.62052050e-01f, 2.59462476e-01f, 1.31486818e-01f, 7.66039938e-02f, -5.75498305e-02f, -8.85106847e-02f,
  -2.94403613e-01f, -2.91916370e-01f, -3.44312459e-01f, -1.50618508e-01f, -7.10409433e-02f, 9.90465358e-02f, 1.16144724e-01f, 1.10204577e-01f, 1.95230141e-01f, 2.55462438e-01f,
  1.47995457e-01f, -1.30671591e-01f, -2.93064211e-02f, -1.40324265e-01f, -2.75892854e-01f, -1.00246429e-01f, -1.47408485e-01f, -1.18659027e-01f, -1.81273650e-02f, -1.76884353e-01f,
  -2.21192852e-01f, -1.33634791e-01f, 1.15519889e-01f, -6.52866289e-02f, -1.22661762e-01f, -8.41362104e-02f, 3.01098102e-03f, -9.62860137e-02f, 3.07132723e-03f, 3.29485424e-02f,
  -5.36432043e-02f, -7.12777674e-03f, -5.29512055e-02f, -1.05525032e-02f, -9.79031529e-03f, 1.56124225e-02f, -1.14779584e-01f, -9.49007571e-02f, -1.17496178e-01f, 2.91906316e-02f,
  3.32231028e-03f, 9.41585824e-02f, -2.79793190e-03f, 6.05093800e-02f, -4.26201969e-02f, 2.97778239e-03f, -1.28385127e-01f, 7.21229464e-02f, -1.30240200e-02f, -8.99922848e-03f,
  2.97142625e-01f, -8.68361145e-02f, -4.51439321e-02f, -4.20610197e-02f, 6.44865111e-02f, 5.79991611e-03f, -1.47773447e-02f, -3.02297603e-02f, -1.32726863e-01f, -6.33629486e-02f,
  -7.67489672e-02f, 5.34847975e-02f, 1.18590686e-02f, -5.11588342e-02f, -5.35315685e-02f, -1.61151931e-01f, 4.53809574e-02f, -1.48669854e-01f, -9.50444117e-02f, -1.51173295e-02f,
  -7.54934922e-02f, 7.41558373e-02f, -3.16338539e-02f, -2.41854265e-02f, 8.45500305e-02f, -7.96593279e-02f, 3.31557915e-02f, 3.08383745e-03f, 3.18745896e-02f, -2.80982703e-02f,
  -4.01873708e-01f, 6.62510023e-02f, -5.23557961e-02f, -1.05531685e-01f, -8.52193162e-02f, -3.68964635e-02f, -7.02393726e-02f, -3.46540287e-02f, 3.50785665e-02f, 5.25833108e-02f,
  3.22139040e-02f, -1.38480272e-02f, 1.48044517e-02f, -8.75353366e-02f, 1.46830648e-01f, 3.58333103e-02f, 6.06111921e-02f, 9.49076097e-03f, 5.90832084e-02f, 5.46631403e-02f,
  8.58495161e-02f, 1.93798497e-01f, 1.53527036e-01f, -1.33130290e-02f, 1.73703045e-01f, 2.23042384e-01f, 7.53889605e-02f, 1.67417005e-01f, 1.60607964e-01f, 8.06848407e-02f,
  -3.95758212e-01f, 1.53977975e-01f, 6.54725805e-02f, -2.61750460e-01f, 1.81625355e-02f, 1.42142788e-01f, 1.25667632e-01f, -6.12893291e-02f, -8.39672014e-02f, 1.00382753e-01f,
  1.77541867e-01f, -8.55662897e-02f, -7.78996274e-02f, -1.92828402e-02f, -7.41762891e-02f, 4.78306040e-02f, -1.15999334e-01f, -9.45049152e-02f, -1.36310622e-01f, -8.88712052e-03f,
  -6.68298975e-02f, -1.73593298e-01f, -3.01744223e-01f, -1.32483900e-01f, -1.89103335e-01f, -1.63028657e-01f, 2.39773337e-02f, -1.69840008e-01f, 2.49814950e-02f, -1.57388579e-02f,
  -3.07834893e-02f, -7.78293684e-02f, -2.91364193e-02f, -1.88010916e-01f, 4.96029258e-02f, -8.83869827e-02f, -3.74476463e-02f, -7.87477419e-02f, 3.03661115e-02f, -5.15076797e-03f,
  -1.60915464e-01f, 4.02321704e-02f, -6.92052245e-02f, 7.51581602e-03f, -9.47323292e-02f, -9.01367217e-02f, -1.06955387e-01f, -6.77090734e-02f, -9.48504135e-02f, 1.32535230e-02f,
  -9.88399163e-02f, -1.19976066e-01f, -2.11067706e-01f, -6.25359043e-02f, -9.18536037e-02f, -6.42239898e-02f, 1.86713319e-02f, -7.90213048e-02f, -1.02280140e-01f, -1.18531786e-01f,
  -1.80278569e-02f, -7.30428193e-03f, 6.19072374e-03f, 1.04089163e-03f, 3.31780575e-02f, 1.13041274e-01f, -6.18108734e-02f, -9.49137807e-02f, -8.64963327e-03f, -1.07520737e-01f,
  1.42573595e-01f, 2.15841562e-01f, 4.79003936e-02f, 8.05144310e-02f, 1.75722037e-02f, -7.98562169e-02f, -7.69934952e-02f, -5.97238354e-03f, -7.59488642e-02f, -3.41744125e-02f,
  7.20062992e-03f, -7.94730633e-02f, 5.51559031e-02f, 1.60038508e-02f, 5.74474037e-03f, -1.58190187e-02f, 1.59810245e-01f, 1.29649788e-01f, 1.40415847e-01f, 1.27157316e-01f,
  -3.71603109e-02f, 1.33471087e-01f, -8.74380469e-02f, -7.06315115e-02f, 6.60352111e-02f, 9.87066072e-04f, 1.57040209e-02f, -1.29123731e-02f, -2.60940455e-02f, 2.56097224e-02f,
  -3.04783750e-02f, -5.40055037e-02f, -5.14444262e-02f, -2.67348792e-02f, -4.65968391e-03f, -8.05619881e-02f, -6.28621280e-02f, -9.19239782e-03f, 1.45335514e-02f, -3.36160958e-02f,
  -1.27170295e-01f, -1.81758627e-01f, -2.28398830e-01f, -9.94393378e-02f, -1.07464150e-01f, -9.60815102e-02f, -1.51237532e-01f, -5.16589917e-02f, -2.96585914e-02f, -1.50762856e-01f,
  -1.34320796e-01f, 2.59400129e-01f, 7.50217447e-03f, 1.01104602e-01f, -3.99131440e-02f, -7.08759278e-02f, -5.13858646e-02f, -5.85038289e-02f, 1.12846203e-01f, 1.83513507e-01f,
  1.19978651e-01f, 3.14235725e-02f, 6.37699664e-02f, -4.99749333e-02f, -3.04468721e-01f, -3.75955924e-02f, -3.28066945e-02f, -2.13205948e-01f, -3.99837554e-01f, -3.58552039e-01f,
  -1.36914765e-02f, -7.70967603e-02f, -2.54181236e-01f, -1.44967854e-01f, 2.13659659e-01f, 1.41051397e-01f, 1.35449812e-01f, 1.09880403e-01f, -2.15798374e-02f, 1.86815292e-01f,
  1.51954979e-01f, -4.59730364e-02f, -1.43570945e-01f, -2.88559318e-01f, 2.47520402e-01f, -2.14790687e-01f, -9.88529995e-02f, 1.43049136e-01f, -6.04448281e-02f, 2.53942553e-02f,
  2.07190886e-02f, -2.26831079e-01f, -5.74504286e-02f, -2.02581838e-01f, -1.40584618e-01f, -2.03589201e-01f, -1.04107849e-01f, -2.23587662e-01f, -1.23722352e-01f, -9.95627567e-02f,
  -8.41729064e-03f, -2.25896039e-03f, -6.82623545e-03f, 7.03266710e-02f, -2.87003126e-02f, -1.52445454e-02f, 1.11543313e-01f, -6.89827232e-03f, -9.69153196e-02f, 1.84350759e-01f,
  -1.17808484e-01f, -6.82977363e-02f, -6.37561306e-02f, 8.75712857e-02f, -3.28761376e-02f, 1.39343560e-01f, 4.40476537e-02f, -7.14754611e-02f, -4.82818075e-02f, -4.36713034e-03f,
  -7.65374629e-03f, 8.65399390e-02f, 6.57145455e-02f, -3.48077305e-02f, -5.72790839e-02f, -1.01608634e-02f, -2.04965845e-01f, -2.75024083e-02f, -5.41982055e-02f, -6.80436641e-02f,
  -2.95971762e-02f, -1.96414087e-02f, 1.61935464e-01f, 3.12096719e-02f, -2.87159793e-02f, -5.86353876e-02f, -5.08421995e-02f, 3.08220927e-02f, 8.98212660e-03f, -2.51363963e-03f,
  1.69597238e-01f, -2.12360263e-01f, 1.05059989e-01f, -1.15057632e-01f, 7.83849582e-02f, -1.60703719e-01f, 1.24875031e-01f, -6.20518625e-02f, -3.57747898e-02f, -1.10738724e-01f,
  -2.52406240e-01f, -4.34831623e-03f, 2.02541590e-01f, -9.82097685e-02f, -2.06650853e-01f, -3.20266113e-02f, -1.83702841e-01f, 1.10360933e-02f, 3.03586922e-03f, 1.00439638e-01f,
  8.20997451e-03f, -6.94410652e-02f, 8.43449906e-02f, 1.76795244e-01f, 1.31812841e-01f, -7.09974095e-02f, 1.84402272e-01f, 1.15725890e-01f, -1.17871001e-01f, 1.08462088e-01f,
  4.41153869e-02f, 3.20649557e-02f, 3.04316163e-01f, 1.40624715e-03f, -2.17574507e-01f, -4.02234614e-01f, -5.08307755e-01f, -2.40807772e-01f, 3.23292241e-02f, 3.17027010e-02f,
  -1.51457936e-01f, -2.04743057e-01f, 7.21991211e-02f, 1.18286442e-02f, -1.60494491e-01f, 2.75741369e-02f, 2.50232130e-01f, 1.14403725e-01f, -1.00168817e-01f, -3.82414162e-01f,
  -2.47027069e-01f, 3.05796620e-02f, 5.68852313e-02f, -2.51251440e-02f, 2.05984309e-01f, 2.60070711e-02f, 2.60806978e-01f, 9.62984413e-02f, 1.07685708e-01f, 3.43721628e-01f,
  2.60492116e-01f, 8.16244408e-02f, -2.74201538e-02f, -5.52858710e-02f, -1.10807531e-02f, 4.86273430e-02f, -1.24973558e-01f, 1.73414052e-01f, -5.86140864e-02f, 8.62455890e-02f,
  -9.12198648e-02f, -1.77633360e-01f, 5.70182949e-02f, 6.74160346e-02f, -5.42007424e-02f, -1.99254155e-01f, 1.47587016e-01f, 8.87468308e-02f, 5.24827242e-02f, 2.10776571e-02f,
  -1.56563953e-01f, -9.28481519e-02f, 1.28969038e-02f, -5.70210256e-03f, -8.10956806e-02f, 3.63907255e-02f, -6.97575957e-02f, 5.26628271e-02f, 1.83186457e-02f, 1.56834319e-01f,
  -4.66379011e-03f, 4.14210893e-02f, 2.56683361e-02f, 1.81498658e-02f, -1.50156319e-01f, 9.04798210e-02f, 6.08439855e-02f, -6.01247363e-02f, -1.43945338e-02f, -4.98060510e-02f,
  -1.51756287e-01f, -6.10484108e-02f, 3.24385017e-02f, 5.69550507e-02f, 4.63048890e-02f, -1.71932615e-02f, -1.29678532e-01f, 1.05508924e-01f, 8.87721702e-02f, -6.71874061e-02f,
  -7.06739351e-02f, -5.85731864e-02f, 4.52384725e-02f, 7.50548914e-02f, 4.50300463e-02f, 1.23313941e-01f, -1.90047063e-02f, -7.22791776e-02f, 4.77611087e-02f, 8.29187334e-02f,
  -1.54441476e-01f, -4.66835052e-02f, 1.60447024e-02f, -6.41725063e-02f, -8.21559355e-02f, -4.88501489e-02f, 1.24883339e-01f, -9.21906978e-02f, 9.87169072e-02f, -8.05606321e-02f,
  -1.02563754e-01f, -7.94892833e-02f, 3.43205817e-02f, 5.67901768e-02f, -2.07699612e-01f, -2.52566189e-02f, -1.01409614e-01f, -7.95985609e-02f, -5.16846627e-02f, -1.01918736e-02f,
  -6.97568730e-02f, -3.40841860e-01f, -2.93289483e-01f, -1.23900138e-01f, -8.70153829e-02f, -2.55661756e-01f, -1.02152124e-01f, -9.47705507e-02f, -2.87383318e-01f, -2.92766184e-01f,
  4.53306764e-01f, 4.35497276e-02f, -2.75236011e-01f, 2.50917971e-01f, 7.27148652e-02f, -1.07373632e-01f, 5.94728328e-02f, 4.13107872e-02f, 4.94583212e-02f, 1.42494738e-01f,
  -1.04589246e-01f, -2.91753262e-01f, -1.91070482e-01f, -2.94932872e-01f, -2.64372408e-01f, -2.02750843e-02f, 1.46971038e-02f, -1.03178978e-01f, -1.31763235e-01f, -7.22840354e-02f,
  1.62039604e-02f, 1.78153098e-01f, 1.19990900e-01f, -7.63543472e-02f, -3.16635408e-02f, -3.13232802e-02f, -4.15929519e-02f, 9.89842974e-03f, -9.76076573e-02f, 1.40005024e-02f,
  -3.44681472e-01f, -9.77144390e-02f, -7.10583553e-02f, -7.89088849e-03f, 1.81521341e-01f, 1.82132572e-01f, 3.48872766e-02f, 1.32382914e-01f, 1.31822705e-01f, -1.61199421e-02f,
  -6.44648597e-02f, -7.80246109e-02f, -6.97642043e-02f, -1.32777438e-01f, -2.01111436e-02f, -1.24094740e-01f, -4.35606204e-02f, 2.53749406e-03f, -9.95884389e-02f, 1.23332702e-02f,
  -3.81991267e-02f, -9.34322476e-02f, -1.05393514e-01f, -8.97270627e-03f, -9.14692804e-02f, 5.07363258e-03f, -1.95895657e-01f, -1.09600350e-01f, -2.28000924e-01f, 1.15695775e-01f,
  6.14279062e-02f, 8.54981095e-02f, 1.51501372e-01f, 1.47501901e-01f, 1.02883860e-01f, 1.15691744e-01f, 5.60859777e-02f, 1.48798646e-02f, 5.11280932e-02f, 1.04729109e-01f,
  -5.65979909e-03f, 1.46545932e-01f, 2.70994976e-02f, 9.73590389e-02f, -7.00900257e-02f, 1.76628064e-02f, -6.39895035e-04f, 1.12741087e-02f, 3.20796855e-02f, 1.26031116e-01f,
  -2.24658661e-02f, -7.83101767e-02f, 7.35658258e-02f, -4.61003929e-03f, -5.64641505e-02f, 1.50643438e-02f, -2.32395045e-02f, -3.17645036e-02f, 1.62134767e-02f, 5.33061393e-04f,
  -8.31512809e-02f, -2.04794884e-01f, 4.39308994e-02f, -1.05012447e-01f, 8.33725482e-02f, 1.30872458e-01f, -3.97827663e-03f, 1.82317257e-01f, 1.47947177e-01f, 8.32832512e-03f,
  -8.35173279e-02f, -2.92502646e-03f, -1.54704928e-01f, -5.12420908e-02f, 1.44262791e-01f, -4.06909781e-03f, 1.03735939e-01f, 4.02522422e-02f, -1.22748651e-01f, 9.66215506e-02f,
  2.18203310e-02f, 1.52093709e-01f, 1.80604219e-01f, 1.38993531e-01f, 2.35069282e-02f, -1.31094987e-02f, 6.74840584e-02f, 3.37715782e-02f, 3.24889198e-02f, 3.82258624e-01f,
  -3.91713500e-01f, -3.45738009e-02f, 1.69619396e-02f, 1.48541480e-01f, 2.09052548e-01f, 2.57417321e-01f, 3.19916278e-01f, 1.64408669e-01f, 8.72696415e-02f, -5.90319410e-02f,
  -2.14783624e-01f, -1.99362159e-01f, -8.51333067e-02f, -7.76568847e-03f, -3.38217989e-02f, 2.07105070e-01f, 3.31711888e-01f, 1.21823745e-02f, -6.08741343e-02f, 7.38908350e-02f,
  1.71106860e-01f, 4.88094836e-02f, -1.42442748e-01f, 3.44324447e-02f, 1.52895316e-01f, 2.03598384e-02f, 1.70852870e-01f, -8.51292387e-02f, 4.78267036e-02f, 1.79849401e-01f,
  -2.89179683e-01f, -3.16060066e-01f, 1.51435181e-01f, -1.87374532e-01f, -1.24553040e-01f, -9.29086134e-02f, 6.30131643e-03f, -1.60724178e-01f, -1.79726839e-01f, 1.39739262e-02f,
  -1.76912710e-01f, -2.29353443e-01f, -1.71133414e-01f, 5.69968298e-02f, 4.58850712e-03f, -1.66717544e-01f, -1.37278453e-01f, -1.12735540e-01f, -1.51592374e-01f, -2.24422842e-01f,
  -8.40975717e-02f, -1.31842569e-01f, -1.48577541e-01f, 1.17726609e-01f, -1.05782107e-01f, -1.02264531e-01f, -1.68190837e-01f, -9.15983468e-02f, -9.59641933e-02f, -9.27741975e-02f,
  -1.72405347e-01f, -1.82545243e-03f, -8.05513654e-03f, 7.38321692e-02f, 8.64900872e-02f, 2.45117452e-02f, 1.23110496e-01f, 9.76081043e-02f, 1.39889911e-01f, 3.04027610e-02f,
  1.14114307e-01f, 6.54783770e-02f, -2.93680783e-02f, 3.35103017e-03f, 5.38795851e-02f, 6.24863356e-02f, 5.87740093e-02f, -3.31928506e-02f, 4.03289823e-03f, 3.84912826e-02f,
  -2.19422225e-02f, 2.42078882e-02f, -9.65128019e-02f, -2.25458071e-02f, 2.42673513e-02f, -5.43217640e-03f, 5.45743816e-02f, -6.54491112e-02f, 6.00758716e-02f, -6.19118847e-02f,
  3.94763350e-01f, -1.04985319e-01f, 5.32027148e-02f, 5.47232553e-02f, -2.48412136e-02f, -3.62021625e-02f, 1.46161336e-02f, -2.78149992e-02f, 4.67220023e-02f, 6.21062843e-03f,
  -1.11519761e-01f, -1.30875066e-01f, -5.53423427e-02f, 1.82867408e-01f, 1.57608807e-01f, 4.62082103e-02f, 7.51085654e-02f, 1.66858569e-01f, 9.62321833e-02f, 6.56928048e-02f,
  3.45790423e-02f, 1.47550300e-01f, 1.18557453e-01f, 2.58022606e-01f, 1.72620833e-01f, 1.44742608e-01f, 1.80067971e-01f, 9.33868960e-02f, 1.34834796e-01f, 3.14108044e-01f,
  7.18857229e-01f, 2.43948400e-01f, -3.28135610e-01f, 1.58777282e-01f, -1.36371389e-01f, -1.20397791e-01f, -8.70482158e-03f, 6.63083717e-02f, 1.55333310e-01f, 7.33568147e-02f,
  1.56782240e-01f, 1.90262347e-01f, 1.18469439e-01f, 6.60251081e-02f, 4.91750687e-02f, -1.75427333e-01f, -1.47076905e-01f, -9.01637450e-02f, -1.18317060e-01f, -2.96423268e-02f,
  4.26959321e-02f, -1.25326544e-01f, -1.88520458e-02f, -6.14103153e-02f, -6.62101209e-02f, -5.03452569e-02f, -8.59091282e-02f, -9.62568596e-02f, -2.15446606e-01f, -2.35768571e-01f,
  -4.06802833e-01f, -3.28040542e-03f, 1.37739673e-01f, 1.24639953e-02f, 6.43128855e-03f, 1.18274033e-01f, -4.33549732e-02f, 2.27130949e-02f, 1.37198582e-01f, -8.84570256e-02f,
  -1.48181629e-03f, -1.26790851e-01f, -7.93165416e-02f, -1.00462541e-01f, -1.07816562e-01f, -6.21944815e-02f, 1.14334635e-02f, 1.25413373e-01f, -2.07035728e-02f, -1.47360228e-02f,
  7.26263374e-02f, -1.02581093e-02f, -7.80080408e-02f, -2.76428908e-02f, 8.60757679e-02f, 3.80767882e-02f, 1.82626827e-03f, 4.52809110e-02f, 7.26330951e-02f, 1.35583162e-01f,
  -8.24267324e-03f, 8.05458277e-02f, -6.97176382e-02f, 6.00033142e-02f, 3.00919414e-02f, 1.13242649e-01f, 1.87655520e-02f, -8.16862062e-02f, 1.12783136e-02f, -2.29829806e-03f,
  -9.80812088e-02f, -1.36575520e-01f, -7.88511783e-02f, 1.13964768e-03f, -1.65637564e-02f, -1.17265485e-01f, -1.15049846e-01f, 2.99053057e-03f, -1.00421511e-01f, -4.59075570e-02f,
  -1.18413746e-01f, -9.57375988e-02f, -1.70155875e-02f, -1.36082277e-01f, -4.52842265e-02f, -7.79171428e-03f, -1.51945487e-01f, -3.47335786e-02f, -1.15761608e-01f, -1.59900784e-01f,
  -1.18439747e-02f, -1.01103783e-01f, 5.15400693e-02f, 2.86325365e-02f, -8.23407024e-02f, 9.23919678e-02f, 2.62261946e-02f, -7.26977810e-02f, -1.08166508e-01f, -6.15500882e-02f,
  -4.87956032e-02f, 6.87585026e-03f, 3.91643606e-02f, -8.45952798e-03f, -5.87264895e-02f, 2.38858759e-02f, 2.59516478e-01f, 2.46486347e-02f, -4.34337407e-02f, -4.81636748e-02f,
  8.47873688e-02f, 1.41617596e-01f, 1.87556326e-01f, 7.19369948e-02f, 1.26384929e-01f, 1.64748788e-01f, 4.37240601e-02f, 1.01098329e-01f, -3.24116834e-02f, 1.47757441e-01f,
  -1.15368500e-01f, -6.96093068e-02f, -3.39414567e-01f, -2.65160739e-01f, -4.36107606e-01f, -2.93848515e-01f, -2.26783216e-01f, -1.64566204e-01f, -1.97111517e-01f, -1.39987662e-01f,
  1.06204025e-01f, 3.29638094e-01f, 1.75513998e-01f, 1.90277323e-01f, 1.77952886e-01f, -8.34155902e-02f, -2.88215131e-01f, -1.31755784e-01f, 1.53465599e-01f, 1.28086552e-01f,
  1.96941160e-02f, -6.17817640e-02f, -3.94121483e-02f, -1.22173212e-01f, -8.91269520e-02f, 9.02751759e-02f, -1.51381820e-01f, -2.00671181e-01f, -1.45053402e-01f, -1.71152100e-01f,
  3.50974590e-01f, -3.28856558e-01f, -6.30983785e-02f, -4.17778715e-02f, 9.62933805e-03f, -9.06405449e-02f, 6.04891814e-02f, -5.67796193e-02f, 6.70032427e-02f, -7.31123462e-02f,
  -1.22918554e-01f, -7.90649727e-02f, -5.33647370e-03f, -4.83129136e-02f, -1.94797330e-02f, 6.25337139e-02f, 2.96437927e-02f, 3.24377976e-02f, -8.04245993e-02f, -2.75179604e-03f,
  4.37521562e-02f, -2.12442763e-02f, 1.08399626e-03f, 4.18162998e-03f, -1.32960305e-02f, 6.14640675e-03f, 9.30952579e-02f, 5.36109172e-02f, 1.64988320e-02f, 2.77295080e-03f,
  -2.85244063e-02f, 1.01462200e-01f, 9.44076031e-02f, 2.07044668e-02f, 1.05472840e-01f, 7.75327757e-02f, -1.90345626e-02f, 5.95716685e-02f, -1.18205110e-02f, 1.23131357e-01f,
  2.66905949e-02f, -7.34643638e-02f, 1.70074441e-02f, 5.79074845e-02f, 8.51837173e-02f, 7.39468411e-02f, 1.64783858e-02f, 7.27471635e-02f, 2.67248936e-02f, 5.53938523e-02f,
  -1.16471641e-01f, -1.26976175e-02f, 2.56810300e-02f, -2.13811686e-03f, -3.09282765e-02f, -1.05578333e-01f, 5.92793571e-03f, -6.02825470e-02f, 7.61996880e-02f, -4.61942442e-02f,
  3.05322558e-01f, -1.50346115e-01f, 4.39502448e-02f, 1.17547192e-01f, -7.97015727e-02f, -2.41830181e-02f, -2.41181348e-02f, 1.95476282e-02f, -1.15537122e-01f, 3.41268778e-02f,
  1.98988393e-02f, 9.56145748e-02f, 7.30622560e-02f, 6.12803213e-02f, -5.85392825e-02f, -2.58500054e-02f, -1.12587037e-02f, 1.17144987e-01f, 1.39323585e-02f, 1.06474191e-01f,
  -6.97747385e-03f, 4.32792939e-02f, 2.50501454e-01f, 1.31228998e-01f, 2.95010824e-02f, 1.53192565e-01f, 1.42255351e-01f, -9.69283096e-03f, 5.01064472e-02f, 1.85499191e-01f,
  6.88129306e-01f, -1.50797203e-01f, 1.99771062e-01f, 1.24175452e-01f, -1.80635929e-01f, -1.81022555e-01f, -1.55168682e-01f, -7.26531893e-02f, 1.55333327e-02f, 5.00683449e-02f,
  -2.38260794e-02f, 1.73011735e-01f, 1.37314022e-01f, 1.73049167e-01f, 2.56231785e-01f, -9.91844833e-02f, 2.25030351e-02f, 2.35790759e-01f, 3.10417235e-01f, -1.87790040e-02f,
  -3.26621942e-02f, -4.67485785e-02f, 2.29173854e-01f, 5.60621917e-02f, -1.91478193e-01f, 1.04826592e-01f, 1.74117777e-02f, -1.43758193e-01f, -1.39144212e-01f, -1.62264869e-01f,
  -1.07019857e-01f, 2.07099151e-02f, 1.21759370e-01f, 4.64530177e-02f, -1.56122774e-01f, 9.53999385e-02f, 4.25536595e-02f, 4.12886776e-02f, 5.16508631e-02f, -1.19634159e-01f,
  -5.56696169e-02f, 3.01430766e-02f, -6.23893514e-02f, -1.02764234e-01f, -4.55611981e-02f, -1.11786433e-01f, -3.50066386e-02f, 1.52538851e-01f, 1.17281668e-01f, -4.16949317e-02f,
  -1.24159887e-01f, 2.11275909e-02f, -1.70375295e-02f, -9.88192111e-02f, 7.68155307e-02f, 3.07433754e-02f, -9.89673510e-02f, -6.31518709e-03f, 1.32775813e-01f, -2.91671641e-02f,
  -3.27667221e-02f, 5.27253263e-02f, 4.82543707e-02f, 2.33028233e-02f, 1.32976696e-01f, 7.50392675e-02f, -3.63576412e-02f, -4.09497060e-02f, 3.71945314e-02f, -4.92869951e-02f,
  -8.53577349e-03f, 9.42280143e-02f, -1.43201335e-03f, 3.39651071e-02f, 3.07561010e-02f, -2.06909906e-02f, -8.87894630e-02f, -5.08730002e-02f, 9.06238556e-02f, 9.58746858e-03f,
  1.38017818e-01f, -5.62754124e-02f, -8.46788436e-02f, 4.12146859e-02f, -6.52668774e-02f, 3.23213525e-02f, 7.12703168e-03f, -1.04007035e-01f, -9.93960816e-03f, -3.41855548e-02f,
  -2.82325447e-01f, 1.53122768e-01f, 3.11290193e-03f, -4.42313887e-02f, -1.38066128e-01f, -1.04237333e-01f, -1.26923434e-02f, -5.67603745e-02f, -1.27669871e-01f, -5.03711216e-02f,
  -1.58370510e-01f, 1.23856599e-02f, -6.69905767e-02f, -7.95877203e-02f, 2.28738561e-02f, -6.61143661e-03f, -8.21906179e-02f, 6.31984994e-02f, 3.54740322e-02f, -1.93734944e-01f,
  2.51743663e-02f, -2.99790781e-02f, 8.27220231e-02f, 1.00118384e-01f, 9.09510255e-03f, 5.19174933e-02f, 3.73403244e-02f, -2.76698973e-02f, 1.68417409e-01f, 7.22502992e-02f,
  -8.68917443e-03f, -3.35689992e-01f, -1.46926299e-01f, -7.65908509e-02f, -1.14336878e-01f, -1.13044590e-01f, -3.44057709e-01f, -2.36434281e-01f, -4.33920547e-02f, -3.71830791e-01f,
  -5.17793074e-02f, 2.84299105e-01f, 2.42674965e-02f, -3.53256911e-02f, -5.40452451e-02f, -3.68371814e-01f, -2.20988438e-01f, 1.05607606e-01f, 1.93691954e-01f, 6.47029281e-02f,
  1.01139747e-01f, 1.22665770e-01f, 2.60615289e-01f, 1.92062229e-01f, -1.82638153e-01f, 1.60169341e-02f, -4.84162346e-02f, -1.03750788e-01f, -1.02301985e-01f, -1.93226606e-01f,
  -3.08657527e-01f, -2.53855050e-01f, 1.31071448e-01f, 1.56911343e-01f, 1.11895345e-01f, -4.60179411e-02f, 1.18717831e-03f, 1.72639936e-01f, 1.70394182e-01f, -8.78205970e-02f,
  -1.41403256e-02f, 3.73790525e-02f, 2.19664238e-02f, 1.04839243e-02f, -8.10306072e-02f, -4.64723520e-02f, 4.64054830e-02f, -1.39024463e-02f, -1.60453897e-02f, -5.71992546e-02f,
  -6.36170208e-02f, -2.17648186e-02f, -1.11442283e-01f, -6.16268627e-02f, -1.73782155e-01f, 3.10572069e-02f, -7.06675723e-02f, -5.99434786e-02f, -8.29695836e-02f, -3.07343930e-01f,
  2.15664096e-02f, 3.28980424e-02f, 2.27586385e-02f, 2.39060074e-02f, -2.33132336e-02f, 1.84013806e-02f, -8.21525306e-02f, -7.97653645e-02f, 7.08585083e-02f, -5.36948955e-03f,
  1.14036798e-02f, -4.47494797e-02f, -1.43993208e-02f, -2.42399592e-02f, -1.56925488e-02f, 1.23323001e-01f, 9.26514938e-02f, -8.74807760e-02f, 4.79134768e-02f, 2.20170245e-02f,
  7.49584883e-02f, -8.43012631e-02f, 8.29529241e-02f, 7.01027215e-02f, 2.32152455e-02f, -4.70734388e-02f, -7.25163519e-02f, 6.39939830e-02f, 4.97666858e-02f, -7.58239813e-03f,
  5.88620566e-02f, 1.74340189e-01f, -2.62775689e-01f, -3.62245291e-02f, -7.05252960e-02f, 7.60201514e-02f, -3.69130820e-02f, 5.49997911e-02f, -5.03517650e-02f, -9.79563370e-02f,
  -8.12858418e-02f, -1.47272781e-01f, -1.23383410e-01f, 5.43910731e-03f, -6.54043704e-02f, -6.98475987e-02f, -8.14352706e-02f, 2.24712640e-02f, 6.03534095e-02f, -2.79412027e-02f,
  -7.04695731e-02f, -1.37908027e-01f, -1.25322640e-01f, -1.18726507e-01f, -6.91148862e-02f, 1.33014042e-02f, -9.13275033e-02f, -1.30980343e-01f, -3.01852208e-02f, -2.93282986e-01f,
  -4.27609950e-01f, -1.07480362e-01f, -3.64717811e-01f, -1.71665978e-02f, 3.72718453e-01f, 8.00622031e-02f, 5.94208278e-02f, -5.77273518e-02f, -7.62838917e-03f, 7.41204014e-03f,
  1.55478701e-01f, 1.65123925e-01f, 8.34051445e-02f, 5.31635396e-02f, -1.16014540e-01f, 6.96691349e-02f, 2.65406314e-02f, -1.31471947e-01f, -1.01627909e-01f, 1.12293825e-01f,
  2.23788232e-01f, -6.42233640e-02f, -3.32435668e-01f, -9.70174223e-02f, 1.62377983e-01f, 9.69663337e-02f, -2.90499758e-02f, 7.02930987e-02f, 1.84462279e-01f, 1.89974457e-01f,
  -2.45430693e-02f, -2.25554809e-01f, 8.11838284e-02f, 1.59304351e-01f, 3.06822527e-02f, -6.09585419e-02f, -8.41820091e-02f, -1.63488925e-01f, 6.93299547e-02f, -1.02386750e-01f,
  1.13691270e-01f, -6.80201873e-03f, 6.48319572e-02f, 4.22230847e-02f, -3.08399964e-02f, -7.87936226e-02f, -1.31620929e-01f, -2.74184078e-01f, -2.28265166e-01f, -2.24823967e-01f,
  3.52869540e-01f, 8.10343698e-02f, -2.24971369e-01f, -1.61152899e-01f, -2.37737536e-01f, -1.04765728e-01f, -2.03076556e-01f, -1.60432130e-01f, -2.90840983e-01f, -3.53516519e-01f,
  -2.92973127e-02f, -3.42783295e-02f, -8.98917019e-02f, -1.19602844e-01f, -3.88170173e-03f, 4.88604084e-02f, 2.76438612e-02f, 4.81038578e-02f, 2.66939271e-02f, -1.31198019e-02f,
  7.31569827e-02f, -9.66311693e-02f, -4.62400056e-02f, 4.59784977e-02f, 6.00889325e-02f, -1.56873034e-03f, 6.22633845e-03f, -1.17386959e-01f, 1.00348294e-02f, -1.12316594e-01f,
  1.03148066e-01f, -7.36262500e-02f, -1.03267273e-02f, -8.33578780e-02f, -2.53015477e-02f, -9.18075219e-02f, 1.62612759e-02f, -8.58028084e-02f, -5.49266636e-02f, 1.60331745e-02f,
  -9.04613435e-02f, -1.12992600e-01f, -4.42575701e-02f, -1.80577133e-02f, 6.48810118e-02f, 2.20573228e-02f, -1.97725948e-02f, 5.00269905e-02f, 1.69403814e-02f, -1.12669840e-01f,
  -8.28150734e-02f, -2.75761634e-02f, -1.13766007e-02f, -8.03613439e-02f, -6.94050938e-02f, 3.02605378e-03f, -4.81242873e-02f, 5.14937739e-04f, -7.24083632e-02f, 3.06321178e-02f,
  -1.02651939e-01f, -1.03191786e-01f, -2.02809066e-01f, -5.33533096e-02f, -7.71315247e-02f, -6.44848496e-02f, -6.72312155e-02f, -6.65030181e-02f, -1.42831430e-01f, -3.03574920e-01f,
  3.22560728e-01f, 3.56686451e-02f, 3.30297559e-01f, 2.77045727e-01f, 1.65347561e-01f, 2.55279332e-01f, 1.00773975e-01f, 1.91211611e-01f, 5.95528744e-02f, 6.97678328e-02f,
  1.45694360e-01f, 3.75559218e-02f, 9.31188092e-02f, 4.76174615e-03f, 1.06366754e-01f, 5.17285801e-02f, 8.26464370e-02f, 1.25102192e-01f, 2.01963723e-01f, 1.26832247e-01f,
  8.83670300e-02f, 1.29081622e-01f, 2.23711923e-01f, 8.20692331e-02f, 2.74135657e-02f, -3.06767318e-02f, 1.52018234e-01f, -5.38773984e-02f, 1.35661196e-02f, -7.92741701e-02f,
  -1.97651088e-01f, 7.84431845e-02f, 1.14430301e-01f, -1.09604396e-01f, 5.48653714e-02f, -8.47155880e-03f, -1.99651495e-02f, 8.38192031e-02f, -5.28447106e-02f, 6.49898946e-02f,
  -1.13034412e-01f, -1.20525949e-01f, 4.26881723e-02f, -8.83464217e-02f, -6.95508868e-02f, 5.93010895e-02f, -6.96079880e-02f, 6.16864152e-02f, -2.24999767e-02f, -6.40785471e-02f,
  -3.82838175e-02f, -6.29031956e-02f, 5.58566228e-02f, -9.27252397e-02f, -4.15362492e-02f, -3.00543886e-02f, -2.35438403e-02f, -1.32219970e-01f, -5.38649336e-02f, -6.04083650e-02f,
  1.65795952e-01f, -1.24939218e-01f, -1.17302626e-01f, -5.99027164e-02f, -1.41434208e-01f, -1.93940476e-01f, -8.00533071e-02f, -4.99065779e-02f, -1.20801246e-02f, 4.69828025e-02f,
  -3.25748920e-02f, 4.55358960e-02f, -8.54013190e-02f, 5.42380735e-02f, 1.11404605e-01f, -6.02733977e-02f, -1.89024918e-02f, -4.83323783e-02f, 4.27292567e-03f, 2.17153057e-02f,
  -1.00655161e-01f, 3.39931324e-02f, 1.00427873e-01f, 1.35810943e-02f, 4.58505889e-03f, 1.43818006e-01f, 7.33437017e-02f, 7.52330497e-02f, 6.49299398e-02f, 1.77285478e-01f,
  -1.88266873e-01f, 2.61941493e-01f, -1.19126230e-01f, -4.97531556e-02f, -1.22920379e-01f, -1.46694519e-02f, -8.07461888e-02f, 1.65078267e-02f, -1.70647223e-02f, 2.17944197e-03f,
  -1.38222456e-01f, -2.65480531e-03f, -2.38568895e-02f, -8.76712576e-02f, -5.88753261e-02f, -5.98484986e-02f, -1.64544284e-01f, -1.37456998e-01f, -3.74657437e-02f, -1.60320461e-01f,
  -1.44777983e-01f, -9.68340710e-02f, -1.56424940e-01f, -4.64561395e-02f, -1.19401231e-01f, 1.43527454e-02f, 7.40788644e-03f, -7.12195858e-02f, -7.88879842e-02f, -6.81921393e-02f,
  4.30846989e-01f, 1.60244346e-01f, 2.29304388e-01f, 2.27320064e-02f, -1.19680390e-02f, 6.31560087e-02f, 1.75608605e-01f, 1.57689705e-01f, 2.14890409e-02f, 1.35432914e-01f,
  3.91615517e-02f, -9.69763696e-02f, 6.02689863e-04f, 1.69748478e-02f, 2.19505996e-01f, 1.41860873e-01f, 9.32201892e-02f, 9.50035304e-02f, 4.58268449e-02f, 6.70797899e-02f,
  -7.82085955e-02f, 5.65857254e-02f, 2.05888301e-01f, 1.43227458e-01f, -4.91761155e-02f, -1.65244028e-01f, 8.15048888e-02f, 8.90957639e-02f, -2.83831023e-02f, -7.44196028e-02f,
  6.65082261e-02f, 3.17312270e-01f, -2.38585889e-01f, -1.80233151e-01f, 2.71034744e-02f, 6.30397201e-02f, -4.72593680e-02f, 1.62811372e-02f, -3.52351330e-02f, -8.87537375e-02f,
  -1.56697229e-01f, -4.84579876e-02f, 3.85491326e-02f, 4.24664542e-02f, 2.16564722e-02f, 4.41650189e-02f, 1.73858106e-01f, 1.81829304e-01f, 1.14507832e-01f, -5.47297671e-02f,
  -6.03545122e-02f, -1.06433861e-01f, -2.09233724e-02f, -4.50189449e-02f, 5.76433018e-02f, -2.02834010e-01f, 1.97822992e-02f, 3.52522023e-02f, -5.66643253e-02f, -1.04262672e-01f,
  -1.33630082e-01f, -1.30180791e-01f, 5.86047359e-02f, -4.39988868e-03f, 1.05136521e-01f, -4.58623022e-02f, 1.06584109e-01f, -7.06622228e-02f, 1.51832812e-02f, 4.66252081e-02f,
  2.58844122e-02f, 8.54341015e-02f, 1.46319434e-01f, 1.03741564e-01f, -5.76242507e-02f, 5.89722320e-02f, 3.97419110e-02f, 1.00330204e-01f, 1.18467912e-01f, 1.25808522e-01f,
  -6.37932569e-02f, -3.03184483e-02f, -8.19510967e-02f, 9.84083191e-02f, 2.18830369e-02f, 1.02306128e-01f, 9.82731134e-02f, 6.26243651e-02f, -6.08253665e-02f, -2.55657267e-02f,
  -6.16076775e-02f, 8.53305161e-02f, -6.76020607e-02f, 5.79914935e-02f, -4.29208577e-02f, -1.68096721e-02f, -7.06965104e-03f, -3.61267035e-03f, -4.72561531e-02f, -5.01162559e-02f,
  -3.35638858e-02f, -8.50611646e-03f, 8.16559717e-02f, 6.44102469e-02f, -1.36766061e-01f, -9.62690488e-02f, -1.54519752e-01f, -1.48345172e-01f, -7.90219456e-02f, -8.27418119e-02f,
  -1.08068593e-01f, -2.10437104e-01f, -1.18187182e-01f, -2.51378894e-01f, -1.53068855e-01f, -2.10244238e-01f, -1.97419539e-01f, -1.19247995e-01f, -6.94504529e-02f, -7.30591714e-02f,
  5.25025487e-01f, 3.67489923e-03f, 2.01556101e-01f, 1.56344980e-01f, 1.99981853e-01f, 1.95943892e-01f, 1.87153548e-01f, 1.56227767e-01f, 1.41864017e-01f, 1.58592820e-01f,
  1.53245896e-01f, 2.89208032e-02f, -2.65439507e-02f, -6.15248531e-02f, 3.39314044e-02f, -1.09197693e-02f, -4.36192378e-02f, 1.00659139e-01f, 1.47042379e-01f, 1.25310346e-01f,
  -9.50015485e-02f, 4.89838049e-02f, 1.80316374e-01f, -3.48030850e-02f, -6.77677020e-02f, -6.88721985e-02f, -8.39609373e-03f, 1.66278740e-03f, -5.12395203e-02f, -1.10567339e-01f,
  1.45477653e-01f, 1.08402081e-01f, -5.96142001e-02f, -1.61750779e-01f, 8.04845244e-03f, 4.48818803e-02f, 2.73893848e-02f, 3.87871638e-02f, -1.25059962e-01f, -8.61182734e-02f,
  -1.18367128e-01f, -6.41245991e-02f, 9.89547223e-02f, 4.46792133e-02f, 4.09327485e-02f, 4.89622355e-02f, -5.74223138e-03f, 5.91846779e-02f, -1.03654183e-01f, -2.07067784e-02f,
  -9.39893425e-02f, 1.46590039e-01f, 1.46874130e-01f, -9.85311903e-03f, 2.09337026e-02f, -3.68988630e-03f, 3.09703089e-02f, 1.17797926e-01f, -1.57311512e-03f, 1.02942765e-01f,
  -9.46624950e-03f, 1.66098014e-01f, 1.62883162e-01f, 1.25450850e-01f, 3.20158824e-02f, 7.81321824e-02f, 3.41815576e-02f, -4.33618687e-02f, 7.71760866e-02f, 1.13101497e-01f,
  7.02992640e-03f, 9.43146795e-02f, 1.50592536e-01f, 1.54947355e-01f, 9.40285474e-02f, 1.91104516e-01f, 1.03029609e-01f, 8.31202865e-02f, 1.06231406e-01f, 9.77825597e-02f,
  9.42601860e-02f, 1.30291194e-01f, 4.00858037e-02f, 3.78938974e-03f, 1.03992440e-01f, 1.70692623e-01f, 1.46064579e-01f, -9.25633404e-03f, 1.35930806e-01f, 7.26956800e-02f,
  -1.10975951e-01f, 4.76541631e-02f, 2.40856521e-02f, -1.35436803e-01f, -4.39413190e-02f, 2.43183710e-02f, -1.45807238e-02f, -1.68653086e-01f, -1.38231978e-01f, -4.29431871e-02f,
  -2.61049066e-02f, -1.84840299e-02f, 1.87583100e-02f, 5.62050566e-02f, 1.39439628e-01f, 5.81768379e-02f, 9.55021847e-03f, 6.04221039e-02f, -1.75625980e-01f, -6.31993487e-02f,
  -1.04094408e-01f, 2.68711988e-03f, 1.18390523e-01f, 6.24253862e-02f, 1.32248588e-02f, 8.82172287e-02f, 4.04426344e-02f, -7.70594850e-02f, -1.96675919e-02f, -3.82542945e-02f,
  4.92935330e-01f, 1.98616348e-02f, 2.60875136e-01f, 7.05550835e-02f, 6.11514188e-02f, 3.37996855e-02f, -2.36857850e-02f, -6.08489327e-02f, 1.04693234e-01f, 8.30399767e-02f,
  7.12600574e-02f, 1.70296401e-01f, 1.24665149e-01f, 7.15815127e-02f, 1.22852579e-01f, -6.15117280e-03f, -3.44864316e-02f, 8.68607610e-02f, 1.36925936e-01f, -9.09867883e-03f,
  -3.35023925e-02f, -3.89943123e-02f, 7.78740346e-02f, 7.32666552e-02f, 6.06503561e-02f, -9.12043266e-03f, 2.18963232e-02f, -4.67568599e-02f, 9.56573412e-02f, 5.60075929e-03f,
  2.79782832e-01f, 2.42263407e-01f, -2.86519323e-02f, 9.83876642e-03f, 3.31019200e-02f, 4.66642901e-02f, -6.95199613e-03f, -3.50022763e-02f, -1.66210845e-01f, -1.86731189e-01f,
  3.26789804e-02f, 6.74736798e-02f, 2.96287294e-02f, -1.27772644e-01f, -4.19723094e-02f, 6.29262477e-02f, 1.50717027e-03f, -1.10007823e-01f, -5.15640993e-03f, 5.52681871e-02f,
  -2.65563186e-02f, -5.44538684e-02f, 4.47744317e-02f, -5.63046429e-03f, 9.01814476e-02f, -1.17297005e-02f, 9.24728364e-02f, -1.40455905e-02f, 1.41010091e-01f, -4.84161973e-02f,
  2.20852092e-01f, 2.70869303e-02f, 8.84106308e-02f, -2.43722685e-02f, -2.43292600e-02f, -6.91848695e-02f, -6.79418072e-03f, -6.69279695e-02f, 3.42618376e-02f, 1.22374082e-02f,
  -1.20942779e-01f, 3.42185646e-02f, 1.73750892e-02f, -8.61100480e-02f, 1.66094273e-01f, -1.94725804e-02f, 3.23630348e-02f, 4.29057553e-02f, 1.16553992e-01f, 4.08061482e-02f,
  5.83532006e-02f, -8.54698643e-02f, -9.39275604e-03f, 2.38360427e-02f, -2.17049364e-02f, 1.70256197e-02f, -7.42308199e-02f, -9.43862572e-02f, -9.56279878e-03f, -2.39363760e-02f,
  -6.23252895e-03f, 3.62693131e-01f, 3.87184769e-02f, 4.51511517e-02f, 5.32896854e-02f, -2.41370536e-02f, 1.70035392e-01f, 4.13626581e-02f, -1.64717376e-01f, -5.03721833e-02f,
  4.82570268e-02f, 1.12209164e-01f, 6.45500645e-02f, -1.51985124e-01f, -5.39692231e-02f, -8.55207909e-03f, 2.28465460e-02f, -6.95936903e-02f, 5.41726016e-02f, -4.06022556e-02f,
  1.34330038e-02f, -3.84869776e-03f, -9.32982489e-02f, 2.77948733e-02f, 6.89904019e-02f, 7.98956752e-02f, -8.48972127e-02f, -9.93077084e-02f, 1.24646015e-01f, -1.55514628e-01f,
  -1.02975726e-01f, 1.05251200e-01f, 1.74194500e-01f, 1.62485331e-01f, 2.85041988e-01f, 2.89710373e-01f, 3.60453099e-01f, 1.34055957e-01f, 1.64871812e-02f, 8.06561485e-02f,
  6.62535653e-02f, -1.21875413e-01f, -8.69895220e-02f, -6.28982708e-02f, 5.33445440e-02f, 1.35012358e-01f, 1.19248673e-01f, 2.05029901e-02f, 5.69135277e-03f, 2.66486146e-02f,
  -3.98644246e-02f, 1.15932129e-01f, -1.86025947e-02f, -4.19362597e-02f, -3.17116007e-02f, -3.99973802e-02f, 1.44564867e-01f, 1.80639133e-01f, 7.66420066e-02f, -3.46654677e-04f,
  5.85332401e-02f, 3.69895063e-02f, -1.50802374e-01f, -4.05616239e-02f, -5.11681326e-02f, -7.57055283e-02f, -5.10441186e-03f, 6.02430813e-02f, 1.15001529e-01f, 4.53730114e-03f,
  -7.70555995e-03f, 1.40142348e-02f, 1.20204970e-01f, 1.26324937e-01f, 1.83424503e-01f, 7.19284127e-03f, 4.49497662e-02f, -1.09889992e-02f, 1.26222998e-01f, -2.11966392e-02f,
  -2.28727460e-02f, 1.54937625e-01f, 2.95468032e-01f, 1.09509140e-01f, -7.16464296e-02f, -5.49022891e-02f, 7.54874125e-02f, 2.63007842e-02f, 1.06912851e-01f, 4.77615371e-02f,
  1.08323552e-01f, -1.17946953e-01f, 2.43820772e-02f, 3.86822559e-02f, -4.91125248e-02f, 2.61040386e-02f, -3.93869877e-02f, -3.37473974e-02f, -3.75692360e-02f, -3.44732143e-02f,
  -2.37889960e-03f, 1.43526690e-02f, 7.77548030e-02f, 6.51351176e-04f, -3.05229630e-02f, 1.28296524e-01f, 6.63757883e-03f, -5.75465672e-02f, 1.77310649e-02f, -3.75621989e-02f,
  5.42301908e-02f, 7.07046762e-02f, -4.22926396e-02f, -1.44459810e-02f, 5.01890443e-02f, 8.62851888e-02f, 8.62743333e-02f, -1.84872877e-02f, 8.41958541e-03f, -5.67693189e-02f,
  2.20293388e-01f, 5.14030829e-02f, -2.55826265e-01f, -1.56275958e-01f, -1.07571438e-01f, -1.60625592e-01f, -1.11026943e-01f, -2.20729806e-03f, -3.06891985e-02f, 6.57808706e-02f,
  6.11886531e-02f, -7.59342611e-02f, -7.53146857e-02f, -5.71206659e-02f, -7.10274056e-02f, 5.76696359e-02f, -1.82880118e-01f, 8.84784609e-02f, -4.69262712e-02f, 3.86302508e-02f,
  -1.61762789e-01f, 1.31420359e-01f, 1.44073695e-01f, -3.47498581e-02f, -3.51342261e-02f, -7.30970800e-02f, 4.50953729e-02f, -1.02092646e-01f, -3.43618449e-03f, -4.11199220e-02f,
  -4.84214991e-01f, -1.09115243e-01f, 1.26431249e-02f, -3.91563833e-01f, -1.77277118e-01f, 1.52747650e-02f, -2.18554363e-01f, -3.52448002e-02f, -7.86029622e-02f, -2.84126610e-01f,
  -1.27801120e-01f, -1.51684910e-01f, -1.22617163e-01f, -9.49256420e-02f, -2.75068849e-01f, -4.48085099e-01f, -3.50254416e-01f, -2.46431053e-01f, -1.36420503e-01f, -9.55927670e-02f,
  -1.99651703e-01f, -3.66183102e-01f, -2.25445211e-01f, -1.51337981e-02f, -1.03361808e-01f, -8.43315274e-02f, -1.10446922e-01f, -2.00032517e-01f, -9.86331925e-02f, -2.51352578e-01f,
  -3.28875661e-01f, 1.15132518e-01f, 8.41544122e-02f, 4.21944335e-02f, -1.10845074e-01f, 1.21177077e-01f, -8.38472601e-03f, 3.88268605e-02f, 8.15679505e-02f, -1.20511100e-01f,
  -8.52071717e-02f, 2.08710656e-02f, -5.57699278e-02f, -1.12921335e-02f, -6.81616217e-02f, -4.82771806e-02f, 1.90657127e-04f, -2.07506549e-02f, 7.06833526e-02f, 4.95606065e-02f,
  -4.22518887e-02f, -9.88422781e-02f, 3.43734287e-02f, 3.09119038e-02f, 2.37561882e-01f, 4.05845158e-02f, 1.18501157e-01f, 7.82232434e-02f, 1.89433590e-01f, -1.17102362e-01f,
  -1.00234570e-02f, -5.11013009e-02f, 3.69579978e-02f, 7.73883089e-02f, 5.92282228e-02f, -3.68353538e-02f, -9.39328745e-02f, -1.26751542e-01f, 1.68601684e-02f, -1.49381444e-01f,
  -2.86000408e-02f, -1.91429965e-02f, -5.54634891e-02f, -2.07767412e-02f, -4.51599807e-02f, -1.21080317e-01f, -5.44007085e-02f, -1.87155548e-02f, -6.40790761e-02f, -1.05004385e-02f,
  -5.35956770e-02f, 1.22943282e-01f, -9.97423008e-02f, -5.81658743e-02f, -7.45126754e-02f, -8.92192796e-02f, -4.14160155e-02f, -1.41471811e-03f, 8.54315516e-03f, -3.42188701e-02f,
  -2.93072939e-01f, 3.49254608e-02f, -2.87671804e-01f, 5.17754033e-02f, -4.95861061e-02f, 1.29975453e-01f, -2.41364595e-02f, 5.69138080e-02f, 2.68411916e-02f, -1.11362711e-01f,
  1.69929847e-01f, 3.44810332e-03f, 4.02394310e-02f, 6.12300262e-02f, -8.72722417e-02f, 2.77365576e-02f, -1.19752005e-01f, -1.48425728e-01f, 1.73736840e-01f, 1.63442776e-01f,
  6.03124592e-03f, -1.20737217e-01f, -1.54435307e-01f, -5.49451150e-02f, 9.38115083e-03f, -1.61728457e-01f, -1.26496106e-01f, -1.34270703e-02f, -5.98057210e-02f, -3.54874969e-01f,
  4.38099831e-01f, 7.82011524e-02f, -1.25092521e-01f, 1.75728172e-01f, -2.45639980e-01f, -1.49042487e-01f, -3.16621602e-01f, -2.92042550e-02f, 1.37682883e-02f, 1.15284175e-01f,
  3.63567136e-02f, 1.24068886e-01f, 1.78637374e-02f, 1.39054298e-01f, 4.98694591e-02f, -1.02159128e-01f, -1.04058646e-01f, -3.21106240e-02f, 5.09852218e-03f, 1.70116365e-01f,
  1.49823308e-01f, 1.03299595e-01f, 1.01948485e-01f, -6.02237359e-02f, 1.23340696e-01f, 1.13036104e-01f, 5.88077679e-02f, 2.40999684e-02f, 2.11694632e-02f, 1.18338235e-01f,
  3.50394517e-01f, 6.60065338e-02f, 1.78068783e-02f, -9.94690415e-03f, 1.95825323e-02f, -3.24970707e-02f, 1.08460903e-01f, -9.71692428e-02f, -2.91165616e-02f, 1.81204677e-02f,
  -1.00115441e-01f, 3.59064788e-02f, -8.47141892e-02f, 3.55883501e-02f, 2.91860010e-02f, 1.21875061e-02f, 3.29131000e-02f, -9.03277099e-02f, -1.06715530e-01f, 9.72882882e-02f,
  4.39748261e-03f, -1.38473034e-01f, -1.77187860e-01f, -1.31886154e-01f, -2.54473928e-02f, 1.04106311e-03f, -1.10491447e-01f, -3.17467302e-02f, -3.51658128e-02f, 1.05313972e-01f,
  5.97951040e-02f, 6.67518703e-04f, 1.10272564e-01f, -2.01698206e-02f, 1.30149856e-01f, -4.23008725e-02f, -4.99833301e-02f, -4.86196876e-02f, 8.92473236e-02f, -8.01489037e-03f,
  4.45070490e-02f, 9.53408107e-02f, 4.99553531e-02f, -1.99912880e-02f, 3.71577442e-02f, -6.75478671e-03f, 1.07328139e-01f, 1.29082695e-01f, 8.66313651e-02f, -1.82667654e-02f,
  -4.48307246e-02f, -2.07009036e-02f, 5.64236231e-02f, -8.28258246e-02f, -5.78561099e-03f, 9.73175541e-02f, 1.02229379e-01f, 5.44734932e-02f, 8.13939348e-02f, 7.57594332e-02f,
  8.28849673e-02f, -2.79878795e-01f, 1.28711626e-01f, -2.86077373e-02f, -6.84058294e-02f, 1.59890167e-02f, 9.41181779e-02f, -4.61568981e-02f, -6.28035292e-02f, 3.84303145e-02f,
  -3.89740728e-02f, 4.17745486e-02f, -8.17544386e-02f, -4.63949256e-02f, 2.81132311e-02f, -2.62313560e-02f, -2.57839952e-02f, -1.10273011e-01f, -7.17628226e-02f, 8.27631913e-03f,
  -9.92277861e-02f, -1.79213226e-01f, -1.15634929e-02f, -1.45971209e-01f, -1.19282685e-01f, 1.52435536e-02f, -6.71706572e-02f, -3.18323658e-03f, -1.25808388e-01f, 5.16137630e-02f,
  1.69007818e-03f, 1.83782965e-01f, -1.01992473e-01f, -1.78416800e-02f, 1.48120612e-01f, 1.33545011e-01f, 1.14155225e-01f, -4.73766774e-02f, 1.68730468e-02f, 1.63232186e-03f,
  1.80599287e-01f, 1.39712200e-01f, -1.76366791e-02f, -4.41552373e-03f, -8.63575488e-02f, -8.67136717e-02f, -1.48236692e-01f, -1.36180043e-01f, -1.13229752e-01f, -1.39265209e-02f,
  6.33651167e-02f, 6.76374584e-02f, -1.16436537e-02f, -5.78813143e-02f, 5.17225899e-02f, 6.02656975e-02f, -4.73536178e-02f, 1.44956499e-01f, 4.12514396e-02f, -4.60524522e-02f,
  8.04094598e-02f, 1.04175657e-01f, -4.62068394e-02f, 4.25448827e-02f, 4.01857197e-02f, -1.23993248e-01f, -9.69526991e-02f, 9.58635006e-03f, -3.96124739e-03f, -9.50887986e-03f,
  -5.32554053e-02f, -3.45880874e-02f, 7.47468024e-02f, -3.73636857e-02f, 3.90476808e-02f, -7.65283033e-02f, -2.99772434e-02f, -9.68912393e-02f, -6.36494532e-02f, 5.05317673e-02f,
  1.38008362e-02f, 1.16337582e-01f, 8.57267454e-02f, -5.67601761e-03f, -5.97571954e-02f, -1.21969888e-02f, -6.19235262e-02f, -8.20728093e-02f, -1.41228810e-02f, -1.61247104e-01f,
  4.39522937e-02f, 1.34160640e-02f, -1.06248558e-02f, 7.66056404e-02f, 5.73288426e-02f, -8.34050775e-03f, 5.39006144e-02f, 9.43346024e-02f, -4.12323140e-02f, -8.88453275e-02f,
  4.94837947e-02f, 1.16420887e-01f, 6.89503998e-02f, 1.92503557e-01f, 5.94486184e-02f, 1.33754209e-01f, 1.20858178e-01f, 1.00122064e-01f, 7.13107660e-02f, 1.62908845e-02f,
  2.22587623e-02f, 9.16304365e-02f, 4.72297445e-02f, -4.92908098e-02f, 1.20962068e-01f, 8.96486733e-03f, 1.41212314e-01f, 1.06853627e-01f, 5.98675609e-02f, 1.19869374e-01f,
  1.38913214e-01f, 1.35090560e-01f, -8.25272724e-02f, -7.56560192e-02f, -6.31862581e-02f, -7.68729821e-02f, -3.50790657e-02f, 8.51957723e-02f, 1.06741376e-01f, 1.91809610e-02f,
  5.02513908e-02f, 1.39636977e-04f, -5.40484004e-02f, -2.88062654e-02f, -5.45934625e-02f, 3.47784497e-02f, -1.21721125e-03f, -2.34278515e-02f, -1.71928108e-02f, 1.76265631e-02f,
  -4.32192162e-02f, 2.03418341e-02f, -3.69955115e-02f, 1.08350469e-02f, -1.67552438e-02f, 1.97320357e-02f, 2.27358621e-02f, -3.83347925e-03f, -8.15051943e-02f, -1.33026510e-01f,
  -2.08413824e-01f, 1.40124202e-01f, 3.18318337e-01f, -2.29972824e-01f, -2.31300205e-01f, -1.84727207e-01f, -5.59860356e-02f, -1.63402528e-01f, 5.53098544e-02f, 8.19103941e-02f,
  2.87532341e-02f, -1.91761449e-01f, 4.09327298e-02f, 5.18872775e-02f, 1.77924260e-02f, 2.10344240e-01f, 1.74109876e-01f, -2.45735161e-02f, -3.05687159e-01f, -4.65688258e-01f,
  -2.53286064e-01f, -2.58679658e-01f, -1.80198297e-01f, -2.81228293e-02f, 9.69442055e-02f, 8.80811829e-03f, 3.32624555e-01f, 9.11128595e-02f, 7.31634200e-02f, 3.04393470e-01f,
  8.90833288e-02f, -3.71046439e-02f, -1.22622825e-01f, -1.03934713e-01f, 1.33958682e-01f, 2.03540903e-02f, -1.04046986e-01f, 1.45787224e-01f, -1.03102297e-01f, 1.20813057e-01f,
  -2.10929185e-01f, -6.23969920e-02f, -2.94291060e-02f, -1.87433809e-02f, -1.19282953e-01f, -2.11857602e-01f, 6.52666092e-02f, 4.33156677e-02f, 2.03436371e-02f, -1.22909978e-01f,
  -2.29051828e-01f, -1.12284146e-01f, -7.85500258e-02f, -8.54578465e-02f, 1.82147548e-02f, -8.86309668e-02f, 6.43292293e-02f, -1.07532412e-01f, 1.08066536e-01f, 8.20768625e-02f,
  7.51965269e-02f, 5.18656243e-03f, 1.35622352e-01f, 1.11370742e-01f, -2.92201973e-02f, 1.12812109e-01f, 3.82318310e-02f, -7.68955722e-02f, -4.30507399e-03f, -5.26034944e-02f,
  -1.07563466e-01f, 2.41064839e-02f, 9.46115609e-03f, 7.96475783e-02f, -4.06019092e-02f, 1.06337346e-01f, -9.40547734e-02f, 1.12825103e-01f, 9.41675529e-03f, 2.55727544e-02f,
  2.19717203e-03f, -1.20824417e-02f, 1.14000194e-01f, -2.32360214e-02f, 1.35277465e-01f, 8.47851411e-02f, -8.42386559e-02f, -9.59762856e-02f, 4.20169495e-02f, 2.74504512e-03f,
  -1.07918814e-01f, 1.51013300e-01f, 1.31680369e-01f, -2.76159844e-03f, -6.65416494e-02f, 7.08410367e-02f, 7.70916492e-02f, -2.77026054e-02f, 2.20836680e-02f, -1.03979193e-01f,
  -6.97893351e-02f, -3.76120619e-02f, 1.41615942e-01f, 3.35321529e-03f, -2.07972437e-01f, -3.17857191e-02f, -1.57276288e-01f, -1.53696209e-01f, -5.20222671e-02f, -1.48578107e-01f,
  -1.40593991e-01f, -2.32013598e-01f, -3.33298981e-01f, -1.25858724e-01f, -3.38145457e-02f, -1.93868399e-01f, -1.70611337e-01f, -1.16823711e-01f, -1.63028017e-01f, -1.36365488e-01f,
  4.37697619e-01f, -5.00689089e-01f, 3.02320331e-01f, 1.48088798e-01f, 4.13392857e-02f, 1.51114196e-01f, 2.38098893e-02f, 1.11691235e-02f, 1.02811225e-01f, -1.81366831e-01f,
  -1.33528188e-01f, 1.07108075e-02f, -1.03507444e-01f, -1.05438888e-01f, 8.42894390e-02f, 8.01442191e-02f, 1.06964596e-01f, 3.69721681e-01f, 2.58211792e-01f, 1.38961598e-01f,
  -1.43870160e-01f, 7.22395256e-02f, 6.29567429e-02f, 9.02342722e-02f, -1.82671979e-01f, 6.94705248e-02f, -6.69729114e-02f, -1.30102232e-01f, -7.18508735e-02f, -1.77604347e-01f,
  -1.04796380e-01f, -6.92717582e-02f, 7.94773921e-02f, -6.79603145e-02f, -1.07284330e-01f, -9.95815769e-02f, 4.44486365e-02f, -6.64873794e-02f, -1.16799526e-01f, -7.19915107e-02f,
  -7.92834312e-02f, -5.25356121e-02f, 1.06631527e-02f, -2.47950573e-02f, 3.44288498e-02f, -1.50650181e-02f, -7.46354312e-02f, -8.94720927e-02f, -9.24393814e-03f, -9.59456190e-02f,
  -1.35409474e-01f, 9.13735330e-02f, 1.13501526e-01f, 6.49534538e-02f, 3.70140299e-02f, 1.16062380e-01f, -1.22072704e-01f, 7.88053870e-03f, 7.24580139e-02f, -4.52265441e-02f,
  2.27187127e-02f, -4.71798424e-03f, 2.51980294e-02f, 1.93274152e-02f, 7.69147649e-02f, 7.79603720e-02f, 4.96646166e-02f, -2.86706109e-02f, 1.48490131e-01f, -3.31739224e-02f,
  -8.97586346e-02f, 1.05606973e-01f, 2.69611217e-02f, -6.46489412e-02f, 2.47097742e-02f, 4.27240543e-02f, -4.62016501e-02f, -2.84881704e-02f, 4.54753712e-02f, -7.38740638e-02f,
  1.22674704e-01f, -6.05530329e-02f, 7.53890797e-02f, -1.20629944e-01f, -1.41738608e-01f, -1.33094732e-02f, 7.52424598e-02f, -2.30241846e-02f, -3.17381099e-02f, 7.29420856e-02f,
  -3.54590654e-01f, 2.25492015e-01f, 1.77050028e-02f, 4.66504134e-02f, 4.81051542e-02f, 3.90435979e-02f, 3.10976501e-03f, -1.93623733e-02f, -5.23074754e-02f, -1.79619715e-02f,
  -4.91317995e-02f, 1.01106696e-01f, 3.15284468e-02f, -3.84586002e-03f, 7.33270794e-02f, 6.21864833e-02f, -3.07533368e-02f, -1.48349544e-02f, -1.02362975e-01f, -1.71272844e-01f,
  -6.02513142e-02f, 9.20800120e-02f, 1.86283156e-01f, 6.90599084e-02f, 7.99649432e-02f, 2.35322997e-01f, 1.59921106e-02f, 1.24148950e-01f, 2.40358800e-01f, -4.39018384e-02f,
  1.76619347e-02f, -2.60481536e-02f, -2.69846879e-02f, 2.39552319e-01f, 1.12444758e-01f, -8.48544315e-02f, -9.63729620e-02f, -1.35120034e-01f, 1.04046047e-01f, 6.90924376e-02f,
  6.35668486e-02f, 2.42385373e-01f, 5.27781025e-02f, 1.56860679e-01f, 3.27626429e-02f, 1.30169779e-01f, 2.20152184e-01f, 9.33590904e-02f, 6.62057474e-02f, 1.76136822e-01f,
  9.43827182e-02f, 1.38796821e-01f, 1.32948577e-01f, 1.46613076e-01f, 2.86553174e-01f, 1.29722103e-01f, 1.14966430e-01f, 8.85608494e-02f, 2.12621018e-01f, 3.19673806e-01f,
  1.08426735e-01f, 1.00504920e-01f, 2.97470047e-04f, 6.13127127e-02f, 1.87528729e-02f, 8.47077277e-03f, -9.48956469e-04f, -1.67892431e-03f, 8.32912102e-02f, -9.80599225e-02f,
  4.03049821e-03f, -3.66016179e-02f, 5.17417416e-02f, 1.57193244e-02f, -8.13316479e-02f, 4.02354710e-02f, 6.26886114e-02f, 5.63086867e-02f, -5.65483272e-02f, -1.49964653e-02f,
  2.56251156e-01f, 4.70152125e-02f, -3.12337298e-02f, -1.00499928e-01f, -2.59641297e-02f, 1.24551527e-01f, 3.54374312e-02f, 3.84874381e-02f, -1.01181999e-01f, 4.20399606e-02f,
  1.15015388e-01f, 4.69425246e-02f, 1.02096751e-01f, 1.17238671e-01f, 1.35526732e-01f, 1.11665651e-01f, 8.80615041e-02f, 1.35474011e-01f, 1.65351421e-01f, -4.66648191e-02f,
  1.16432369e-01f, 6.30096197e-02f, -3.10154147e-02f, 8.14639404e-03f, 1.61372170e-01f, 2.70019565e-02f, 5.94867282e-02f, 4.86640930e-02f, 5.42107178e-03f, 4.10632342e-02f,
  1.06254369e-01f, -3.02650426e-02f, 8.80044475e-02f, 6.67096227e-02f, 6.53509721e-02f, 9.41846296e-02f, 1.89050436e-02f, 9.16749015e-02f, -5.96652292e-02f, 5.46602421e-02f,
  -4.32010919e-01f, -2.61020839e-01f, 3.18546854e-02f, 4.77672815e-02f, 9.57098156e-02f, -1.39342912e-04f, -1.56604610e-02f, -1.25465304e-01f, 2.28380058e-02f, -1.23122446e-01f,
  -1.06414177e-01f, -1.43005908e-01f, -1.60652667e-01f, -7.31309578e-02f, -6.06764778e-02f, 1.54636882e-03f, 7.64408633e-02f, 2.37916838e-02f, -9.61634368e-02f, -4.77977172e-02f,
  -1.10050216e-01f, -1.66585326e-01f, -2.04773486e-01f, -1.40679345e-01f, -1.29969656e-01f, -6.42763600e-02f, -9.53687951e-02f, -1.01168118e-01f, -1.85146257e-01f, -2.59821236e-01f,
  -4.53262031e-01f, 1.27543077e-01f, -6.85682595e-02f, -7.68447518e-02f, 2.48011291e-01f, 2.65650809e-01f, 3.21936965e-01f, 4.64891233e-02f, -2.84444541e-03f, 1.02779500e-01f,
  2.81854160e-02f, 9.84115619e-03f, 2.44123656e-02f, 1.03339151e-01f, -6.09986670e-02f, 1.41672641e-01f, 2.62541771e-01f, 6.52214338e-04f, -1.90526679e-01f, 3.41490991e-02f,
  1.64832994e-01f, 1.53497234e-02f, -2.75352240e-01f, -1.08535744e-01f, 1.26039106e-02f, -2.54403856e-02f, -6.65886775e-02f, 1.02361217e-02f, 1.83347195e-01f, 1.43653125e-01f,
  -3.78938407e-01f, -2.67071456e-01f, -4.05716114e-02f, -2.12648716e-02f, -1.97727955e-03f, -1.54412851e-01f, -1.50310606e-01f, -1.67569846e-01f, 6.66133836e-02f, -4.78730686e-02f,
  3.60029452e-02f, -6.90593645e-02f, 7.01971874e-02f, -7.75451511e-02f, -1.90191716e-01f, -4.03801575e-02f, -8.68572220e-02f, -1.86065823e-01f, -2.17278391e-01f, -1.42244413e-01f,
  3.23052227e-01f, 4.39300388e-02f, -1.26945123e-01f, 3.80676053e-02f, -1.95920184e-01f, -1.33166879e-01f, -1.31833375e-01f, -1.12676129e-01f, -2.15946957e-01f, -3.98475081e-01f,
  -1.35650886e-02f, 5.23268320e-02f, 5.94186932e-02f, -2.72175707e-02f, 6.73123300e-02f, 8.21471214e-02f, 4.19323593e-02f, 7.74837285e-02f, 2.25206255e-03f, -6.03414513e-02f,
  1.99197093e-03f, -4.20947373e-02f, -8.94642994e-02f, -2.18577571e-02f, 8.04846808e-02f, 6.92732260e-03f, 2.32386757e-02f, -5.50141633e-02f, -7.57472403e-03f, 2.24130787e-02f,
  -7.92384446e-02f, 4.02907282e-03f, -1.21013254e-01f, 4.14900929e-02f, 5.00151776e-02f, 8.91190395e-02f, -1.36322761e-02f, -3.59306671e-02f, -7.58020356e-02f, -4.96734977e-02f,
  -2.53608644e-01f, 6.49896637e-02f, -1.32306650e-01f, 3.66312414e-02f, -1.20436609e-01f, -6.49295002e-03f, -3.82992998e-02f, 7.46152252e-02f, -5.28308786e-02f, -1.08385324e-01f,
  -7.15107769e-02f, -7.90610462e-02f, 3.37352566e-02f, -3.64829451e-02f, -5.39720431e-02f, 2.82558110e-02f, 1.02200493e-01f, 1.90416992e-01f, -3.51430587e-02f, -7.49391392e-02f,
  2.23578021e-01f, -8.37388411e-02f, -2.00506911e-01f, -7.43771419e-02f, 2.05791350e-02f, -2.04313681e-01f, -2.07714871e-01f, -1.32692575e-01f, -2.14627877e-01f, -1.95540383e-01f,
  -7.45170414e-02f, 3.76030177e-01f, 1.53188810e-01f, -2.41236255e-01f, 1.49381921e-01f, 3.54853749e-01f, 4.87760484e-01f, 1.58781350e-01f, -1.58279672e-01f, 9.60381851e-02f,
  1.28667518e-01f, -2.95595825e-01f, -2.26899818e-01f, -1.70031294e-01f, -2.44490262e-02f, 3.00758690e-01f, 5.20968549e-02f, -8.10232852e-03f, -1.46950141e-01f, 3.76506895e-02f,
  -6.14256635e-02f, -1.30042240e-01f, -1.84610978e-01f, -1.27406105e-01f, -3.22604626e-02f, -2.01319799e-01f, 2.27109455e-02f, 9.06416699e-02f, 2.29775101e-01f, -7.40908608e-02f,
  -4.57179435e-02f, 2.20843241e-01f, -2.69797117e-01f, -1.62088126e-01f, 3.73000838e-02f, -1.43552527e-01f, 4.39332500e-02f, 2.71581084e-04f, 1.65108833e-02f, 4.47952822e-02f,
  2.13894993e-03f, 6.80619925e-02f, -2.20099092e-02f, 9.57220346e-02f, 1.23799600e-01f, -2.28028856e-02f, 1.62972230e-02f, -9.29809082e-03f, -1.58786044e-01f, 1.11322418e-01f,
  3.84421233e-04f, 6.04385026e-02f, 1.48251221e-01f, -3.65538634e-02f, -1.15800695e-02f, -2.68491775e-01f, 7.16791973e-02f, 2.45956313e-02f, 9.16148722e-02f, -1.11548357e-01f,
  -8.94472077e-02f, 1.26123488e-01f, 2.10104078e-01f, 3.21975611e-02f, -2.73351613e-02f, 3.68863493e-02f, -1.90975945e-02f, -1.72445197e-02f, 1.12634301e-01f, 1.12696312e-01f,
  -7.99071789e-02f, 3.39476205e-02f, -2.64699813e-02f, 5.37382327e-02f, -5.82213961e-02f, -5.54143563e-02f, 1.29866928e-01f, -2.46722419e-02f, -2.72781365e-02f, 9.76960436e-02f,
  -5.53447194e-02f, -1.09569810e-04f, -6.89763948e-02f, 6.57871598e-04f, 2.51937900e-02f, -6.81701824e-02f, -1.14598289e-01f, -5.94323091e-02f, -6.80797398e-02f, -1.62075479e-02f,
  -2.76334286e-01f, 1.17470980e-01f, -2.26261348e-01f, 1.09833360e-01f, 1.30421102e-01f, 1.45562291e-02f, -2.29901541e-02f, 1.02267914e-01f, 5.06199896e-02f, -4.89385724e-02f,
  1.10478655e-01f, -1.64988507e-02f, -6.00402504e-02f, 2.51549818e-02f, -9.58543345e-02f, -4.75743860e-02f, 6.52473271e-02f, -1.16210975e-01f, -4.37714383e-02f, -2.08407957e-02f,
  -1.01559170e-01f, -1.11704797e-01f, -2.89385796e-01f, -1.90439448e-01f, -1.80389628e-01f, -3.48278463e-01f, -1.09522410e-01f, -7.79635981e-02f, -1.86280012e-02f, -1.49750963e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.88178402e-01f, 2.87845165e-01f, 2.83870578e-01f, 4.00140464e-01f, 9.88499895e-02f, 2.46295437e-01f, 2.60722071e-01f, 2.88891554e-01f, 2.33967975e-01f, 2.13574275e-01f,
  1.53644502e-01f, 2.98606843e-01f, -8.74777213e-02f, 3.15334201e-01f, 1.46241859e-01f, 3.30390662e-01f, 3.10589224e-01f, 3.49535942e-01f, 3.81186128e-01f, 3.36419612e-01f,
  2.82915413e-01f, 1.59672692e-01f, 2.05123261e-01f, 2.75132626e-01f, 2.51217276e-01f, 2.43472382e-01f, 7.50029609e-02f, 3.15399617e-01f, 2.93227702e-01f, 2.46179447e-01f,
  3.20918322e-01f, 2.40769193e-01f, 3.86682242e-01f, 3.80948305e-01f, -1.10189663e-02f, 3.56899023e-01f, 4.94178981e-01f, 2.25243166e-01f, 3.01730543e-01f, 3.57926399e-01f,
  2.61217833e-01f, 1.11163817e-01f, -1.26691356e-01f, 8.25148262e-03f, 1.66066095e-01f, 3.46762866e-01f, -5.57635240e-02f, 3.49070221e-01f, 4.22481030e-01f, 1.41249299e-01f,
  1.25375837e-01f, 3.94549489e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.21919984e-02f, -9.67772026e-03f, 1.93686355e-02f, -8.70968997e-02f, -4.88213170e-03f, 2.14996058e-02f, 1.84092954e-01f, 2.57225875e-02f, 9.52648465e-04f, 2.98383329e-02f,
  6.28875270e-02f, 1.69603899e-01f, 6.83326423e-02f, -1.82017475e-01f, -1.58354744e-01f, -1.60608031e-02f, 9.44677666e-02f, -1.13391079e-01f, -3.01399231e-02f, 5.61682582e-02f,
  -5.96121997e-02f, 5.87766655e-02f, 1.07046468e-02f, -2.22827166e-01f, 9.79885533e-02f, 1.97245210e-01f, 5.60912453e-02f, 2.11589932e-02f, -1.30771324e-01f, -2.62917012e-01f,
  -1.87309042e-01f, -7.57802948e-02f, -1.18847579e-01f, -4.08623964e-02f, 1.46692172e-01f, 3.39382701e-02f, -2.45844424e-01f, -1.21721923e-01f, 6.43743575e-02f, -8.27642828e-02f,
  1.83718465e-02f, -2.49406025e-02f, -1.33140936e-01f, -5.86615279e-02f, -1.50913402e-01f, -8.61403197e-02f, 7.21389726e-02f, 7.16530234e-02f, 6.43053725e-02f, -4.70938571e-02f,
  -7.17536127e-03f, 1.89162269e-01f, -2.38606744e-02f, 2.80605834e-02f, 1.42643780e-01f, 3.37088890e-02f, -1.21956123e-02f, -1.78119838e-01f, -2.80177090e-02f, 3.83391255e-03f,
  1.87653303e-01f, -5.29898778e-02f, 2.35434905e-01f, 2.86734581e-01f, -8.29966273e-03f, -7.32101724e-02f, -2.63716597e-02f, -4.47783209e-02f, 2.65599377e-02f, -4.91886139e-02f,
  -1.63554810e-02f, -6.20537773e-02f, 4.73094396e-02f, 2.57439949e-02f, 1.56280082e-02f, 6.67073950e-02f, -3.40838730e-01f, 1.81053445e-01f, 2.69653261e-01f, 7.60569097e-03f,
  -1.99392457e-02f, 8.24666545e-02f, -4.68722470e-02f, -3.06674801e-02f, 8.63995850e-02f, 3.26462761e-02f, 2.21592933e-02f, -7.91453868e-02f, -4.19953577e-02f, -1.07587889e-01f,
  3.35673220e-04f, -9.26628113e-02f, 2.21467596e-02f, 1.46743566e-01f, -2.20920861e-01f, 4.80259731e-02f, -2.55437437e-02f, 2.35010758e-01f, 1.70297801e-01f, -2.09590733e-01f,
  1.43459588e-01f, 3.64957713e-02f, -8.56786743e-02f, 1.60345033e-01f, -1.29587039e-01f, -9.63390321e-02f, -9.27428678e-02f, 6.79377690e-02f, 3.87089774e-02f, 7.35187978e-02f,
  1.02595985e-01f, -4.47914265e-02f, -1.14459313e-01f, 9.86761078e-02f, -8.69027972e-02f, -1.34966984e-01f, -4.83665764e-02f, -1.69712856e-01f, -2.02944763e-02f, -9.46844295e-02f,
  -2.89511811e-02f, 1.63776442e-01f, -5.19262142e-02f, -1.02266990e-01f, -6.79477677e-02f, 7.81050026e-02f, 1.26588531e-02f, -1.24956653e-01f, 1.18629172e-01f, 2.94523221e-02f,
  7.15784281e-02f, -1.70395672e-02f, 5.88584580e-02f, -1.44009843e-01f, 8.92190710e-02f, -4.41226028e-02f, 4.70568193e-03f, -1.08557329e-01f, 2.84386650e-02f, -1.78114194e-02f,
  -1.00037895e-01f, 2.32775986e-01f, 8.36300030e-02f, 2.54168570e-01f, -1.08172193e-01f, -2.25135200e-02f, 1.91125736e-01f, 2.38494009e-01f, -1.53632641e-01f, -2.27492511e-01f,
  -1.90579832e-01f, 2.03354001e-01f, -5.32441325e-02f, -1.50636390e-01f, 7.00340746e-03f, -2.50062019e-01f, 1.93636730e-01f, 1.03002928e-01f, -9.02353227e-03f, -2.05961555e-01f,
  2.14834064e-01f, 4.78597581e-02f, -4.15661484e-02f, 1.62982151e-01f, 1.11872584e-01f, 2.25706454e-02f, 1.60744399e-01f, -7.24133179e-02f, -7.10150134e-03f, -2.40504984e-02f,
  -5.86747192e-03f, 9.43208933e-02f, 2.02001393e-01f, -2.27854043e-01f, 1.79555178e-01f, -1.51484057e-01f, -5.29708900e-02f, 4.11551893e-02f, -2.46522009e-01f, 4.11408320e-02f,
  6.63179383e-02f, 8.61292258e-02f, 5.58544025e-02f, -8.08504224e-02f, -2.50014961e-01f, 6.87139854e-02f, -8.70867446e-02f, -7.21717328e-02f, -8.76327083e-02f, 1.25063583e-01f,
  -2.00094879e-01f, -1.92202374e-01f, -1.56341586e-02f, 1.33775184e-02f, -5.77158034e-02f, 5.38460165e-02f, 6.49752319e-02f, -1.98890343e-02f, 9.74552855e-02f, 1.41996695e-02f,
  1.63308859e-01f, -1.99348480e-01f, -2.06196159e-01f, 6.42438477e-04f, -6.09266646e-02f, 7.28251711e-02f, 1.40399307e-01f, 9.11808684e-02f, -3.46113369e-02f, 2.39177532e-02f,
  -1.94456726e-02f, 2.39936799e-01f, 5.54698892e-02f, -1.79126412e-01f, -1.78456202e-01f, 3.68570723e-02f, 9.07166395e-03f, -2.69499809e-01f, 1.16186263e-03f, -1.09398484e-01f,
  3.87937506e-03f, 2.43855894e-01f, -1.73053406e-02f, -4.35216166e-02f, 1.24504440e-01f, 2.36470923e-01f, -1.34120405e-01f, 5.21585308e-02f, 6.99900463e-02f, -1.16710402e-01f,
  -2.18691945e-01f, -9.10724699e-02f, 6.95048273e-02f, -1.04345977e-01f, 1.69982448e-01f, 3.47193033e-01f, -4.09057969e-03f, 4.42376696e-02f, -2.22525559e-02f, -1.61992371e-01f,
  -8.21107477e-02f, -1.06894381e-01f, -8.46828073e-02f, 7.01805428e-02f, 5.70589378e-02f, -6.49221614e-02f, -1.40806600e-01f, -7.70044280e-05f, -8.50182325e-02f, 1.51455845e-03f,
  -9.55515206e-02f, 3.17647070e-01f, -1.20456610e-03f, 1.03334755e-01f, -1.22445695e-01f, -1.19232886e-01f, -6.03068769e-02f, 1.06060468e-01f, 1.60369337e-01f, -9.44233984e-02f,
  -4.82358448e-02f, 5.06691709e-02f, 2.06207946e-01f, -2.33280193e-03f, -8.52118880e-02f, 1.23455010e-01f, 6.03175536e-02f, 1.15471251e-01f, 1.50270179e-01f, -1.12027809e-01f,
  6.43833429e-02f, 1.77110493e-01f, 6.22475073e-02f, 3.01852170e-02f, 8.10891539e-02f, 8.31597969e-02f, -2.87590623e-01f, -8.10298473e-02f, -5.61380573e-02f, -2.83670664e-01f,
  9.25920978e-02f, 7.93923363e-02f, 1.41590804e-01f, 9.70818549e-02f, 1.88428126e-02f, 3.61057930e-02f, -2.59451300e-01f, -1.21359795e-01f, -5.01505286e-02f, -1.01171374e-01f,
  -8.81110057e-02f, 3.08605552e-01f, -1.47940576e-01f, -1.56512618e-01f, 3.48048322e-02f, -7.34575540e-02f, 7.55511448e-02f, -1.70214802e-01f, -1.12128206e-01f, 4.80883494e-02f,
  -3.31654772e-02f, -2.23545477e-01f, 5.72070368e-02f, -9.36695263e-02f, 1.65923193e-01f, 4.77387803e-03f, -2.82698065e-01f, 1.34212121e-01f, 2.83627599e-01f, 5.16814590e-02f,
  -6.71559274e-02f, 1.75956741e-01f, 3.29269022e-02f, -1.53154284e-02f, -7.29706213e-02f, 1.51594684e-01f, 1.50023937e-01f, -1.18597195e-01f, -2.57848382e-01f, 1.47590250e-01f,
  -3.42286453e-02f, 1.62074491e-01f, -9.88784283e-02f, -1.82466190e-02f, 1.10384729e-02f, -1.64814666e-02f, -3.10514439e-02f, -1.50934637e-01f, 4.04324047e-02f, 1.21362887e-01f,
  -9.68627930e-02f, -1.01528950e-01f, 7.71417469e-02f, -2.41056412e-01f, 6.58600330e-02f, 1.01773560e-01f, -2.21178755e-02f, 1.42562002e-01f, 1.03063941e-01f, 1.21858694e-01f,
  -8.29235986e-02f, 4.64260839e-02f, -1.91630855e-01f, -2.29639392e-02f, 1.33612797e-01f, 1.06525391e-01f, -2.21469961e-02f, 4.76992950e-02f, -3.83765139e-02f, 4.16675061e-02f,
  1.88658625e-01f, 2.82334864e-01f, -5.02110505e-03f, -5.90715483e-02f, -4.43946458e-02f, -8.92585590e-02f, -9.68260095e-02f, 1.79468170e-01f, -1.48793489e-01f, -8.60164389e-02f,
  1.17118336e-01f, 1.24123648e-01f, 1.42644599e-01f, -1.31061137e-01f, 4.30431403e-03f, -9.79570076e-02f, -6.39449283e-02f, 2.93636173e-01f, -9.80100185e-02f, 1.58657134e-01f,
  -1.66097209e-01f, 3.53686251e-02f, -7.45184720e-02f, -1.23688862e-01f, -5.89802898e-02f, -4.55262419e-03f, -2.76436564e-02f, -1.81352884e-01f, 2.92322002e-02f, -4.06768732e-02f,
  6.79064244e-02f, 2.53271870e-02f, -6.92000166e-02f, 9.97420773e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.15959771e-01f, 2.61072308e-01f, 1.39365688e-01f, -2.94356653e-03f, 1.51580229e-01f, 3.19864005e-01f, -4.57075387e-02f, 2.42064282e-01f, 1.41979940e-02f, 3.87037639e-03f,
  1.33474201e-01f, -2.46162370e-01f, 1.73838027e-02f, 3.58189315e-01f, 1.48107052e-01f, -1.92100972e-01f, 9.55088437e-02f, -1.44851774e-01f, 9.87548288e-03f, 7.73656964e-02f,
  -1.02592014e-01f, -2.16617566e-02f, 6.09999150e-02f, 4.74701852e-01f, -5.57284243e-02f, -1.94923375e-02f, 4.13292524e-04f, 1.09534696e-01f, -1.46238052e-03f, -2.60997325e-01f,
  1.94988593e-01f, 1.29217386e-01f, 5.93768097e-02f, 3.01800340e-01f, -3.61814648e-02f, -1.67816970e-02f, 6.32719472e-02f, 1.74863413e-01f, 4.38224487e-02f, 9.44934264e-02f,
  -2.04265177e-01f, -9.94372144e-02f, 2.32108057e-01f, 1.19814724e-01f, -7.42697194e-02f, 1.17833748e-01f, 8.91420916e-02f, 2.96309769e-01f, 2.86661893e-01f, 9.14006084e-02f,
  3.46747860e-02f, 3.65361094e-01f, 1.78437456e-01f, -1.36498749e-01f, -1.34000450e-01f, -2.98636779e-02f, -2.58628875e-01f, 2.77321577e-01f, 4.17373925e-02f, -6.20249063e-02f,
  -1.85906023e-01f, 2.09320366e-01f, -8.90923813e-02f, -3.67174476e-01f, 1.52316123e-01f, 5.95935807e-02f, 5.92996404e-02f, 6.02362566e-02f, 3.11524719e-01f, 1.18218765e-01f,
  -2.89989728e-02f, 1.92275301e-01f, -1.50843099e-01f, 3.13624628e-02f, 3.86958234e-02f, 8.86442140e-02f, 3.47335696e-01f, 3.31486156e-03f, -2.67676383e-01f, 2.81515062e-01f,
  -1.56344384e-01f, -4.35691774e-02f, -3.14871818e-01f, -4.23755497e-02f, 3.11726063e-01f, -3.04309279e-02f, -1.02230683e-01f, -2.94994593e-01f, -8.93618390e-02f, 1.85493335e-01f,
  1.06207468e-01f, -3.04285586e-02f, 1.42382726e-01f, 2.04407081e-01f, 4.85201031e-01f, 2.06987351e-01f, 4.33630437e-01f, 4.60619153e-03f, 3.01806390e-01f, 2.29858056e-01f,
  2.78220087e-01f, -1.83578044e-01f, 5.72105795e-02f, -5.02902150e-01f, 1.69310033e-01f, 1.80822402e-01f, 2.84811586e-01f, 3.48641649e-02f, 1.70658827e-02f, 8.73792097e-02f,
  -2.23052144e-01f, 4.73996066e-02f, -1.56943649e-01f, -1.24683408e-02f, 2.78940052e-01f, 6.17054887e-02f, -1.22975767e-01f, 1.01396091e-01f, -1.37418970e-01f, 5.11647090e-02f,
  8.74248371e-02f, -3.76727544e-02f, 5.67596070e-02f, 2.95249760e-01f, 1.80437356e-01f, -2.01712791e-02f, 9.54083279e-02f, 3.57846886e-01f, 7.37029314e-02f, 2.32142851e-01f,
  4.95465957e-02f, 1.59944668e-01f, 1.99432731e-01f, -5.05576544e-02f, 1.18927062e-01f, -2.26135418e-01f, 6.53778687e-02f, 1.35967180e-01f, -1.98960118e-02f, -1.56767163e-02f,
  -2.18991742e-01f, -2.06552241e-02f, 1.38786301e-01f, 3.10050964e-01f, 1.85893953e-01f, 1.37643978e-01f, -9.21869874e-02f, 3.39698792e-01f, 1.66722879e-01f, 2.70960927e-01f,
  -1.83334693e-01f, -1.93815708e-01f, 6.67038709e-02f, -1.28189626e-03f, 1.25860631e-01f, -2.36704350e-02f, 1.79899931e-01f, 1.76424876e-01f, -1.34712398e-01f, 1.71723202e-01f,
  -3.60339917e-02f, -2.03173339e-01f, -6.07756479e-03f, 3.96460630e-02f, -1.74519382e-02f, 5.42867817e-02f, -3.43976989e-02f, -6.12592176e-02f, -2.99393926e-02f, 2.08346233e-01f,
  1.47820368e-01f, 7.80494884e-02f, -4.13563102e-02f, -2.24010557e-01f, -1.79478861e-02f, -1.15623578e-01f, -1.12807758e-01f, 8.05038810e-02f, -3.66294645e-02f, 5.28161228e-02f,
  2.44419470e-01f, 1.34373963e-01f, 1.78903028e-01f, 2.58545220e-01f, 2.25242123e-01f, -4.72397245e-02f, 2.62465458e-02f, 2.28440851e-01f, -1.54574469e-01f, -2.72170842e-01f,
  -1.25873283e-01f, 3.60749632e-01f, -4.86930348e-02f, 7.27888048e-02f, -8.32841322e-02f, 2.16981769e-01f, 2.17932165e-01f, 3.69241857e-03f, 1.70599550e-01f, 1.40332609e-01f,
  -1.28826186e-01f, -1.21928845e-02f, 1.39633477e-01f, 1.29624963e-01f, 3.30042839e-01f, -6.72901049e-02f, 1.17597422e-02f, 1.11955129e-01f, 7.69189596e-02f, 7.14281350e-02f,
  2.34793037e-01f, 9.94497314e-02f, 7.30947107e-02f, -6.46897033e-02f, 1.03583718e-02f, -1.57114357e-01f, 1.45202667e-01f, 2.37096027e-01f, 1.26150653e-01f, 1.56572595e-01f,
  1.52000174e-01f, -1.59731712e-02f, 1.39985874e-01f, -1.32218702e-02f, -1.55554879e-02f, -3.08850259e-01f, -2.21256465e-01f, 1.43666565e-01f, -1.92120761e-01f, -3.06056459e-02f,
  1.67759895e-01f, -1.05147742e-01f, 2.65695333e-01f, 1.85021684e-02f, -1.06210649e-01f, -3.33675332e-02f, -6.37055980e-03f, 1.03241377e-01f, -1.14186361e-01f, 9.31900889e-02f,
  2.32393950e-01f, 9.22718570e-02f, -2.35924013e-02f, 1.91540718e-01f, 6.26232624e-02f, 2.06544563e-01f, 4.76917960e-02f, 5.78858964e-02f, 1.25066146e-01f, 3.32072824e-02f,
  -5.78487851e-02f, 6.63060322e-02f, 3.36589217e-01f, -1.26996085e-01f, -4.20992635e-02f, 1.85415879e-01f, 2.05337152e-01f, 2.87619650e-01f, 1.19621560e-01f, 1.25198796e-01f,
  3.89832854e-02f, 7.79713020e-02f, 6.32213205e-02f, 5.76191247e-02f, -1.35719180e-01f, -1.14885189e-01f, 2.89005022e-02f, 2.24038437e-01f, 3.10330540e-01f, 1.40322000e-01f,
  3.24387819e-01f, 1.37812153e-01f, -5.74721172e-02f, -1.41361520e-01f, 5.70286624e-03f, 1.42269328e-01f, -1.55210346e-01f, -2.77803261e-02f, -5.21852933e-02f, 2.29092240e-01f,
  -1.84405729e-01f, -1.91069901e-01f, 6.59729317e-02f, 2.35947184e-02f, 2.29499429e-01f, 2.36103863e-01f, 1.36108682e-01f, -1.48461312e-01f, -1.63657874e-01f, -1.44411296e-01f,
  -1.00417901e-02f, 4.35758501e-01f, -9.80320275e-02f, 3.76971997e-02f, 3.43178622e-02f, -4.95659076e-02f, 3.85383487e-01f, 4.17332835e-02f, -5.51317073e-02f, 1.92427225e-02f,
  3.26320440e-01f, 3.43651593e-01f, -8.52015987e-02f, -1.12270273e-01f, 8.27848539e-02f, -1.20599367e-01f, -2.96291709e-01f, 2.51106650e-01f, 2.17571065e-01f, -1.83814354e-02f,
  -2.86731452e-01f, 6.04928061e-02f, -2.86465585e-01f, 1.69781409e-02f, -7.72374943e-02f, 1.23039007e-01f, 2.11550608e-01f, -2.10659593e-01f, 2.20419411e-02f, 3.27765286e-01f,
  7.10216388e-02f, 1.45701259e-01f, 1.54786289e-01f, 9.54813957e-02f, 5.26992083e-02f, 7.75764138e-02f, 1.20269582e-01f, -2.24734051e-03f, 4.22352031e-02f, 5.49762882e-02f,
  1.22664340e-01f, -3.15260328e-02f, -5.40315136e-02f, 1.25975469e-02f, 1.16193444e-01f, -2.64265835e-01f, -3.96862142e-02f, -4.59070392e-02f, 1.35157600e-01f, -7.06302822e-02f,
  -1.92622487e-02f, 1.77662641e-01f, 8.97739977e-02f, 3.84952724e-01f, -6.72783181e-02f, -3.80438454e-02f, -1.26450717e-01f, -2.78075546e-01f, -4.09370065e-02f, 1.92716625e-02f,
  2.30194986e-01f, 1.75588071e-01f, -1.90562293e-01f, 8.30983222e-02f, -6.07708171e-02f, 3.71957682e-02f, -4.96429671e-03f, 3.40076506e-01f, -8.30654353e-02f, 2.46889681e-01f,
  -1.29511416e-01f, -2.38121022e-03f, 1.48615584e-01f, -2.99352407e-01f, 2.22275257e-01f, 1.11682639e-01f, 7.61476532e-02f, 2.77252376e-01f, -1.30160134e-02f, -5.65107614e-02f,
  -8.34658649e-03f, 1.13793947e-01f, 1.11939333e-01f, -2.59055803e-03f, -2.86155134e-01f, -7.75447339e-02f, -4.56925295e-02f, 1.66727319e-01f, 9.70646888e-02f, -2.97667742e-01f,
  -3.10125083e-01f, 5.08603267e-02f, -1.37856603e-01f, -2.96365112e-01f, 9.32237357e-02f, 1.12122990e-01f, 2.41193324e-01f, -3.36133316e-02f, 7.01095164e-03f, 2.80176327e-02f,
  9.24939439e-02f, 1.00475885e-01f, 5.32339886e-03f, -8.12553167e-02f, -7.64032826e-02f, 2.24583268e-01f, 2.81990804e-02f, 2.02253908e-01f, 2.43423849e-01f, 2.13904202e-01f,
  -1.56440004e-03f, -2.23850027e-01f, -8.17829072e-02f, 7.17619807e-03f, -2.45797157e-01f, -5.79151921e-02f, 7.76640996e-02f, 2.10454501e-02f, -2.24718079e-01f, 9.03325062e-03f,
  1.56146303e-01f, 4.95912284e-02f, 1.87694840e-02f, 3.68135661e-01f, -9.25834328e-02f, -1.03364952e-01f, 1.12072945e-01f, 1.85253188e-01f, -2.59254314e-03f, 2.13581145e-01f,
  -1.59187883e-01f, -6.81075156e-02f, 3.94483358e-02f, -9.39211696e-02f, 6.31552041e-02f, -5.99565543e-02f, -1.73158385e-02f, 2.23374069e-01f, 7.06014857e-02f, 3.95145230e-02f,
  -9.64553282e-02f, 1.08099086e-02f, 6.89515425e-03f, -6.08207993e-02f, -2.79940158e-01f, -1.11648932e-01f, 1.76204562e-01f, -1.61422148e-01f, 1.09152734e-01f, -2.29371220e-01f,
  -9.31978822e-02f, 9.52378958e-02f, -6.77535534e-02f, 1.87204301e-01f, 9.22166929e-02f, -1.13604911e-01f, -4.46631722e-02f, 2.98453063e-01f, 2.00465862e-02f, 5.47678210e-02f,
  6.61080927e-02f, 1.25126272e-01f, 1.00798286e-01f, 9.29325521e-02f, -4.85471971e-02f, -6.19216189e-02f, 1.21129058e-01f, -5.62837832e-02f, -1.86451614e-01f, -8.89902562e-03f,
  -1.79105639e-01f, 3.10855150e-01f, 1.80924740e-02f, 3.37477833e-01f, -3.08898035e-02f, 1.70044348e-01f, -1.25897760e-02f, 1.42491505e-01f, 1.28132448e-01f, 2.25260824e-01f,
  -1.48912460e-01f, -1.39181077e-01f, -7.03086928e-02f, -2.77377702e-02f, -9.82284918e-03f, 2.85153538e-02f, -1.96391698e-02f, 1.96062937e-01f, -2.68409844e-03f, 6.67603612e-02f,
  2.30786741e-01f, 1.74214274e-01f, -9.80141573e-03f, 2.77289718e-01f, 8.36266801e-02f, -1.16432264e-01f, 1.55327842e-01f, -8.55800509e-02f, 1.16221361e-01f, 1.76699460e-01f,
  -4.25942726e-02f, 2.19140574e-01f, -2.66656261e-02f, -2.49577001e-01f, -1.77642256e-01f, -1.70914799e-01f, -2.00819135e-01f, 2.44781841e-02f, 3.39585282e-02f, -2.17863172e-02f,
  1.12246297e-01f, 1.21399157e-01f, -1.40320033e-01f, -1.27082676e-01f, 2.30991781e-01f, 2.17982143e-01f, 1.34444922e-01f, 9.36703235e-02f, 1.09313354e-02f, -3.53493132e-02f,
  -3.47076133e-02f, 3.77309918e-01f, -7.84970298e-02f, 5.02738245e-02f, -1.31521732e-01f, 9.53436717e-02f, 1.80304095e-01f, -1.46229073e-01f, 1.49759039e-01f, -1.01711042e-01f,
  -1.51915401e-01f, 1.36394098e-01f, -4.35014591e-02f, 1.18943982e-01f, -1.79669857e-01f, -1.25360310e-01f, 6.95440918e-02f, 3.26160416e-02f, 1.01879902e-01f, 1.55780464e-01f,
  3.84075381e-02f, -5.05530350e-02f, 9.79202166e-02f, 1.58592775e-01f, 8.17406550e-02f, 1.53746784e-01f, 2.54266828e-01f, -1.49945632e-01f, -2.15221979e-02f, -2.19911560e-01f,
  -2.37211697e-02f, 2.04151511e-01f, -3.16347135e-03f, 3.13048989e-01f, 6.89050108e-02f, 2.41335824e-01f, 2.79946059e-01f, -6.40324876e-02f, 4.09936756e-02f, 1.42165065e-01f,
  -2.05487445e-01f, -9.39484015e-02f, -4.36035879e-02f, 2.35311911e-01f, 3.51596624e-01f, 1.19482718e-01f, -5.16867526e-02f, 3.46132547e-01f, -1.05531558e-01f, -6.58545569e-02f,
  -3.61315638e-01f, -1.64934713e-02f, 3.53284061e-01f, 3.52587365e-02f, -2.00282107e-03f, -2.70566374e-01f, -1.72256008e-01f, -3.84900011e-02f, 2.09778175e-01f, -4.75636423e-02f,
  -1.57807410e-01f, 2.79909849e-01f, -3.53244916e-02f, 1.65530369e-01f, 1.98412389e-01f, 2.25236751e-02f, 1.38206944e-01f, 2.29779556e-01f, 1.89316139e-01f, 1.43280685e-01f,
  2.18701348e-01f, 1.01702161e-01f, -2.09049452e-02f, 2.29754880e-01f, 2.23351456e-02f, -2.05900427e-02f, -7.81703833e-03f, -1.33426204e-01f, -1.66303590e-01f, 2.97411174e-01f,
  6.10489734e-02f, 2.14248970e-01f, -1.51653975e-01f, -7.97737762e-02f, -6.24174662e-02f, 4.04421508e-01f, -1.48668751e-01f, 1.33929783e-02f, -8.07949454e-02f, 2.00288266e-01f,
  -3.12939920e-02f, -1.76397599e-02f, 1.62230581e-01f, -2.68398710e-02f, 2.28240460e-01f, -9.07321367e-03f, 3.07801902e-01f, 3.54115844e-01f, 3.24329734e-02f, 2.28399150e-02f,
  1.20603561e-01f, 2.25884154e-01f, -1.76970273e-01f, 3.97992209e-02f, 4.15797494e-02f, -3.64556044e-01f, -5.22547625e-02f, 1.25989020e-01f, 1.82718366e-01f, 3.81610960e-01f,
  7.39793628e-02f, -2.00672285e-03f, -5.00972271e-02f, 3.93343046e-02f, -2.62247417e-02f, -1.77240595e-01f, -1.97747171e-01f, 2.54207939e-01f, 1.01516508e-01f, -3.78690921e-02f,
  -8.20510387e-02f, -2.12323070e-01f, -1.33208856e-01f, 2.30013505e-01f, -2.00445671e-03f, 4.13882345e-01f, -8.90115947e-02f, 6.54979497e-02f, -1.94750160e-01f, 1.46814540e-01f,
  1.33557543e-01f, 8.69681165e-02f, 1.22882776e-01f, 1.37262002e-01f, 4.44568135e-02f, 1.04795858e-01f, 3.27934355e-01f, 1.84619948e-01f, -1.75303146e-01f, 5.95783480e-02f,
  2.60076940e-01f, 3.42579037e-02f, 2.67371416e-01f, 1.58532694e-01f, 1.53866976e-01f, 1.92192812e-02f, -2.00403571e-01f, -3.39494534e-02f, 1.30231649e-01f, 2.04874486e-01f,
  -9.09748524e-02f, -2.67531335e-01f, 1.52783602e-01f, 3.69233459e-01f, -1.38850287e-01f, -1.26957223e-01f, -6.42692819e-02f, -1.07114077e-01f, 1.34653479e-01f, 2.78741777e-01f,
  2.57187545e-01f, -2.15814915e-02f, 2.59956475e-02f, 1.18349798e-01f, -3.72072868e-02f, 9.08634588e-02f, -1.51263744e-01f, 2.78403461e-01f, 1.96495727e-01f, -2.89807152e-02f,
  2.32724324e-02f, 1.11479703e-02f, 1.71627566e-01f, 1.55930430e-01f, 3.08279335e-01f, 2.55048662e-01f, 6.32263198e-02f, 7.45763853e-02f, 2.21693724e-01f, 3.53586823e-02f,
  -1.92913383e-01f, 1.67708889e-01f, -9.50394012e-03f, -2.37632003e-02f, -1.68546498e-01f, 3.24290283e-02f, -4.14923914e-02f, 3.31865996e-02f, -1.77469745e-01f, 2.52701908e-01f,
  9.27160308e-02f, -1.76497594e-01f, -1.04424611e-01f, -2.62168556e-01f, 5.20708747e-02f, 1.06054053e-01f, -5.81325814e-02f, -5.18933721e-02f, 1.08280160e-01f, -1.10914014e-01f,
  2.28375606e-02f, -7.12703690e-02f, -1.19195387e-01f, -1.56119568e-02f, 1.61129117e-01f, 1.02901198e-01f, 2.30158985e-01f, -1.17654145e-01f, -1.62487611e-01f, 1.18284151e-01f,
  2.16925427e-01f, -2.26047020e-02f, 8.06251634e-03f, 2.30343509e-02f, 3.06467758e-03f, 6.05155001e-05f, 2.48878598e-01f, -1.67903423e-01f, -4.22709845e-02f, 9.30361897e-02f,
  1.88327506e-01f, -3.31656598e-02f, 8.62306952e-02f, -4.05018151e-01f, 2.61697322e-02f, -2.69685060e-01f, -1.58944964e-01f, -1.14854023e-01f, 4.35636044e-02f, 1.57561794e-01f,
  -3.64080295e-02f, -3.84345017e-02f, -5.67758456e-03f, 3.46571915e-02f, 2.70111430e-02f, -4.92027663e-02f, -1.18621275e-01f, -3.02179903e-01f, -3.34871449e-02f, 1.65003330e-01f,
  -9.59409252e-02f, -9.28227529e-02f, 1.11540467e-01f, -4.91675809e-02f, 1.53167963e-01f, 3.04046739e-02f, 6.59176856e-02f, 2.51311779e-01f, 8.85888934e-02f, 2.77808756e-01f,
  3.58621916e-03f, -7.26430565e-02f, 9.04327333e-02f, -1.73514634e-01f, 1.69504851e-01f, -3.54908854e-02f, 2.33464614e-01f, 3.01950365e-01f, 5.80476187e-02f, 1.18886046e-01f,
  1.54952794e-01f, 6.83500245e-02f, 3.82862752e-03f, 4.23235781e-02f, -5.63519076e-02f, -1.12824261e-01f, 4.77828644e-02f, 5.72458766e-02f, -2.28512049e-01f, -3.50591615e-02f,
  -1.79392219e-01f, 6.84473813e-02f, -1.68864459e-01f, 6.60695732e-02f, 1.91912055e-01f, 4.71346825e-02f, -2.30165273e-01f, 2.39272758e-01f, 5.85903078e-02f, 1.23604514e-01f,
  4.90891188e-02f, -2.47495472e-01f, -1.10029122e-02f, 1.86901852e-01f, 3.23823057e-02f, 3.28810990e-01f, 1.71237066e-01f, -2.76253879e-01f, 3.47355723e-01f, 2.84170359e-01f,
  -1.99497238e-01f, -1.50868790e-02f, 5.49689345e-02f, 1.73826009e-01f, -2.21717238e-01f, -1.54446498e-01f, 1.89158004e-02f, -3.09147537e-01f, 3.57428998e-01f, 2.12964937e-01f,
  -4.26460505e-02f, -1.97521701e-01f, -1.01719670e-01f, 2.57531554e-01f, -2.42141008e-01f, 6.29388988e-02f, -1.50464714e-01f, 5.46207912e-02f, 1.57653689e-01f, 5.47794960e-02f,
  1.27300054e-01f, -1.24829255e-01f, -5.27705364e-02f, -4.92667556e-02f, 1.54272109e-01f, -9.01005417e-02f, 7.38003701e-02f, 6.69144839e-02f, 8.31677094e-02f, -7.29466882e-03f,
  2.85276949e-01f, 3.04217607e-01f, 8.10575262e-02f, 2.10360885e-01f, 4.45002317e-02f, 8.38049576e-02f, 1.44633800e-01f, 1.71742678e-01f, -1.25094295e-01f, 5.08124335e-03f,
  -3.41850221e-02f, -4.57138829e-02f, -2.11699113e-01f, 1.57859311e-01f, -8.70440081e-02f, 3.03384773e-02f, 2.19064131e-01f, 2.45689511e-01f, 6.47224635e-02f, 1.66887552e-01f,
  -1.38679296e-01f, -3.50770615e-02f, 9.91293639e-02f, 2.28752494e-01f, -1.35181069e-01f, -3.12771171e-01f, -1.40421107e-01f, 7.71123990e-02f, 5.70938848e-02f, 2.69277930e-01f,
  1.17151715e-01f, 1.60726219e-01f, 1.04911759e-01f, 1.73723280e-01f, 8.16319808e-02f, -6.78058714e-02f, -1.69406325e-01f, 2.43048683e-01f, 7.85066783e-02f, -3.01124781e-01f,
  4.74241050e-03f, -7.59424418e-02f, 7.10275844e-02f, 2.42267966e-01f, 2.60145038e-01f, 1.91366628e-01f, -7.63346106e-02f, 5.14197908e-02f, -2.33472452e-01f, -1.33241922e-01f,
  -1.57115459e-01f, 9.80791077e-02f, 1.63074866e-01f, 3.37128043e-02f, 1.28688872e-01f, -1.22779325e-01f, -1.24520242e-01f, 1.03665972e-02f, 3.37409377e-01f, -6.89323545e-02f,
  -2.54126787e-02f, 3.25579971e-01f, -4.62402031e-02f, 9.78600010e-02f, 2.43950590e-01f, 4.30100381e-01f, 2.94821598e-02f, 9.26328301e-02f, 1.88335981e-02f, 6.89000357e-03f,
  2.48157397e-01f, 1.74013786e-02f, -1.34503052e-01f, -1.43421471e-01f, -4.93254811e-02f, 1.04787037e-01f, -2.66021900e-02f, -2.43896544e-01f, -8.02109614e-02f, -3.13813798e-02f,
  -2.05940694e-01f, 1.25999555e-01f, 1.23219118e-01f, 1.65227175e-01f, 1.85624622e-02f, 1.90590292e-01f, 2.70907879e-01f, -4.85526025e-02f, 5.21766432e-02f, 2.14937165e-01f,
  -2.31754005e-01f, -5.09215407e-02f, -1.79627597e-01f, -2.87424982e-01f, -2.80710101e-01f, 1.61114454e-01f, 3.70137572e-01f, 2.51059949e-01f, 3.45597416e-01f, -2.91283112e-02f,
  1.90663636e-01f, -1.48784876e-01f, 2.24047512e-01f, 1.00483231e-01f, -1.21268660e-01f, -2.38082662e-01f, 6.16855808e-02f, 1.93923548e-01f, 4.16076332e-01f, 1.27487332e-01f,
  1.26015404e-02f, 2.61293083e-01f, 1.96623243e-02f, 2.26334646e-01f, -1.47668272e-01f, -6.81400448e-02f, 4.26202625e-01f, -1.31676733e-01f, -5.76477349e-02f, -1.78575039e-01f,
  -3.41248438e-02f, 1.30055085e-01f, 5.36274202e-02f, -9.18140337e-02f, 9.59106386e-02f, 2.30485097e-01f, -1.41323343e-01f, 1.51360080e-01f, 3.14061791e-01f, 1.67779803e-01f,
  -8.15200210e-02f, -5.43564707e-02f, -9.23469290e-02f, 9.27559957e-02f, 6.05280772e-02f, -7.43365139e-02f, 2.17833854e-02f, -1.36312097e-01f, -1.82786267e-02f, 1.48986727e-01f,
  -1.69618607e-01f, 9.90581512e-02f, -2.60046065e-01f, 9.80318040e-02f, 1.20128542e-01f, 2.77360022e-01f, 2.63668364e-03f, 1.30545646e-01f, 1.91783067e-02f, 1.91274837e-01f,
  1.32513300e-01f, 9.58696753e-02f, -4.62845154e-02f, -2.17628300e-01f, 1.15880780e-02f, -1.21414773e-01f, 1.82443827e-01f, -7.52694234e-02f, 6.09884076e-02f, 3.19878042e-01f,
  7.84237012e-02f, 2.73948014e-01f, 2.02450767e-01f, 5.55767529e-02f, -8.16790536e-02f, 2.28751317e-01f, 2.05543071e-01f, -4.98174783e-03f, 3.93946841e-02f, 4.80878726e-02f,
  1.02238446e-01f, 1.98914841e-01f, 1.46721795e-01f, 2.39797667e-01f, -2.37738267e-01f, -2.35803023e-01f, -2.17597544e-01f, -1.78192474e-03f, -2.00715780e-01f, -5.18459305e-02f,
  1.20006904e-01f, -2.80715618e-03f, 4.16631885e-02f, 9.03971642e-02f, -1.37172058e-01f, -5.59276156e-02f, 3.37737322e-01f, 1.84708405e-02f, 8.32818151e-02f, 1.11599684e-01f,
  -5.86713180e-02f, -1.00749498e-03f, -2.36666858e-01f, 2.25076452e-01f, 2.90315002e-02f, 1.36875391e-01f, 2.17233911e-01f, 6.13828301e-02f, 1.44553054e-02f, 7.21341744e-02f,
  3.09336279e-02f, -1.50633156e-01f, -1.50390327e-01f, -2.35385001e-02f, -1.81480855e-01f, -1.97788677e-03f, 1.85827240e-01f, 1.34163007e-01f, -9.11914185e-02f, 9.66181606e-02f,
  -8.30733851e-02f, 1.36850283e-01f, -1.11902349e-01f, 2.58111835e-01f, -5.85076911e-03f, 2.24617198e-01f, 1.14124222e-02f, -2.88429707e-01f, 6.01458475e-02f, 5.69743626e-02f,
  -2.40671709e-02f, 3.51523519e-01f, 8.45700428e-02f, -5.90775497e-02f, 1.76173896e-01f, -3.27279009e-02f, -1.76521167e-01f, -7.32251555e-02f, 1.39780745e-01f, 1.28443733e-01f,
  -2.53817588e-01f, -2.15963721e-01f, -1.32047623e-01f, -2.55084395e-01f, 4.04099703e-01f, 1.23733222e-01f, -6.23689108e-02f, 1.46876737e-01f, -9.01944097e-03f, 3.86682332e-01f,
  -3.68417390e-02f, -8.34156126e-02f, -7.62653053e-02f, 9.88582745e-02f, 7.32983202e-02f, 9.53523815e-02f, 7.46432468e-02f, -1.84245016e-02f, -1.27043277e-01f, 1.44864544e-01f,
  1.24484554e-01f, -1.27721563e-01f, 7.50669017e-02f, 2.29325384e-01f, 1.78286448e-01f, -1.09648086e-01f, 3.44653606e-01f, 4.16704476e-01f, 9.20422226e-02f, 2.00033233e-01f,
  -4.06903550e-02f, 1.14864916e-01f, 6.27906248e-02f, -2.51021031e-02f, -1.77193567e-01f, -2.12700963e-01f, 5.57195432e-02f, -1.00537494e-01f, -1.01953045e-01f, -7.67011866e-02f,
  -2.64801443e-01f, -1.53146133e-01f, 9.25874710e-02f, 7.48343170e-02f, 2.04707980e-01f, 2.74851412e-01f, 1.74800485e-01f, 2.88804650e-01f, 2.51742482e-01f, 1.04762517e-01f,
  -2.66813576e-01f, 6.09933138e-02f, 2.15351284e-02f, -1.90298542e-01f, 7.11456388e-02f, -3.12572241e-01f, 2.60458533e-02f, 9.55667719e-02f, -2.60623664e-01f, -2.15098970e-02f,
  2.19086289e-01f, -1.97815061e-01f, -7.51062855e-02f, 3.17122698e-01f, 3.50375056e-01f, 1.55577481e-01f, 3.19996178e-02f, -2.37800609e-02f, 6.11428544e-02f, 1.16978124e-01f,
  2.89281875e-01f, -1.26957558e-02f, 1.56913437e-02f, -1.51923448e-01f, -1.97126478e-01f, 4.33543287e-02f, -2.38889232e-01f, 1.38996035e-01f, 1.51633933e-01f, 2.71317452e-01f,
  9.70773101e-02f, 8.16780701e-02f, 6.49088435e-03f, 1.05003886e-01f, 1.92338377e-01f, -4.52572033e-02f, 2.59377837e-01f, 7.40632936e-02f, -8.91385078e-02f, -3.76961082e-02f,
  -4.97804396e-02f, 1.28367603e-01f, 8.45635310e-02f, 9.70252752e-02f, 1.19075201e-01f, 1.75600760e-02f, 1.25132397e-01f, 7.68662393e-02f, -1.02165624e-01f, -1.36497810e-01f,
  1.44151628e-01f, -1.28155157e-01f, -1.98902473e-01f, 1.29201934e-01f, -1.25004679e-01f, 2.13736489e-01f, -7.92248398e-02f, 2.22509772e-01f, 1.60542838e-02f, -1.17628962e-01f,
  -1.11546583e-01f, 1.47837937e-01f, -7.09154308e-02f, -1.15814760e-01f, -4.10847142e-02f, -2.43405011e-02f, -1.10046506e-01f, -6.17604293e-02f, 1.90113842e-01f, -2.00905293e-01f,
  1.32469177e-01f, 3.03071856e-01f, 4.74531837e-02f, -2.44643614e-01f, 3.35339218e-01f, 1.54533073e-01f, -1.96122736e-01f, 2.38232791e-01f, 1.83059514e-01f, -6.23778738e-02f,
  2.23646417e-01f, 3.31786573e-02f, -1.64702743e-01f, -1.11601666e-01f, 2.71401126e-02f, 5.89431971e-02f, 9.65410993e-02f, -1.33562312e-01f, -6.34968572e-04f, -1.12874940e-01f,
  -7.18721896e-02f, -2.24056110e-01f, 2.11928472e-01f, -5.47224917e-02f, 2.31178492e-01f, 1.50666595e-01f, 5.90820471e-03f, -6.39693663e-02f, 3.31463143e-02f, 1.90790966e-01f,
  1.36680901e-02f, -9.89158899e-02f, -3.47853340e-02f, 2.24780455e-01f, 8.73555243e-02f, 1.67438239e-01f, 5.91932759e-02f, 1.44792855e-01f, 1.90748021e-01f, 2.18432337e-01f,
  1.22050501e-01f, 4.89876010e-02f, -1.12199940e-01f, -1.16635427e-01f, 1.06157325e-01f, 6.65454268e-02f, -4.07056883e-02f, -3.26976627e-02f, 8.48535672e-02f, 4.84818280e-01f,
  1.94023609e-01f, -6.15967587e-02f, -1.81884483e-01f, -9.85251181e-03f, -1.47516921e-01f, -1.28758550e-01f, 9.76460502e-02f, 2.93226540e-01f, 5.55372871e-02f, -2.87572324e-01f,
  -4.63512540e-02f, 9.47420821e-02f, 3.93443089e-03f, 3.24331105e-01f, 3.24593455e-01f, -1.51772827e-01f, 1.01423882e-01f, 1.18716709e-01f, -2.71346897e-01f, 2.65390277e-01f,
  1.25177741e-01f, -1.97457656e-01f, 1.98665142e-01f, -1.70971313e-03f, -1.59298375e-01f, 1.16996080e-01f, 2.26120383e-01f, 7.81305432e-02f, -2.39558309e-01f, 3.67117189e-02f,
  -1.18179500e-01f, -3.80456855e-04f, -2.17354208e-01f, 4.05136198e-02f, 9.73951519e-02f, 1.36649132e-01f, -3.03907562e-02f, 6.66568577e-02f, 1.92684785e-01f, -1.08060449e-01f,
  -2.14864865e-01f, 9.54213552e-03f, 2.04626396e-01f, -1.94009878e-02f, -1.78617045e-01f, -3.24857719e-02f, 2.16063648e-01f, 1.71667099e-01f, -6.78303242e-02f, 5.34118004e-02f,
  3.67161669e-02f, 7.85911307e-02f, -1.93492100e-01f, 9.35782269e-02f, 8.85758027e-02f, -9.44088474e-02f, -1.33485302e-01f, -1.18779086e-01f, -9.94934291e-02f, -1.06844597e-01f,
  2.59804904e-01f, -1.26531413e-02f, -2.89634794e-01f, -4.71366644e-02f, 2.13004023e-01f, 6.29380122e-02f, 8.38792250e-02f, 2.90283952e-02f, 2.08055019e-01f, -1.42576784e-01f,
  2.67470539e-01f, 3.68882157e-03f, 1.19304880e-01f, 5.16630292e-01f, 4.27673869e-02f, -3.35958332e-01f, -2.03736335e-01f, -1.30894259e-01f, -7.20934942e-02f, -1.49996683e-01f,
  -8.26527849e-02f, -7.05457181e-02f, 8.03524554e-02f, 1.23851009e-01f, -2.19181970e-01f, 4.95935790e-02f, 4.72433388e-01f, 2.06760392e-01f, 1.58417933e-02f, 1.61578044e-01f,
  1.62452623e-01f, 6.03013262e-02f, 2.88093984e-01f, -8.78716931e-02f, 2.13875473e-01f, 4.48088199e-01f, 3.61300558e-02f, -2.33637709e-02f, -2.00227708e-01f, 2.31429487e-01f,
  3.29429418e-01f, 1.18315548e-01f, -1.00192122e-01f, -1.39045045e-01f, -1.99384287e-01f, -5.09312712e-02f, 1.86040252e-02f, 3.02193724e-02f, 5.79620525e-02f, -2.78219253e-01f,
  -9.53831151e-02f, 1.14940628e-01f, 2.15504006e-01f, -2.16792122e-01f, 9.29017738e-02f, 1.18834138e-01f, -1.21726235e-02f, 1.75999179e-01f, 1.30627662e-01f, 4.33197059e-02f,
  2.57860065e-01f, 2.09482573e-02f, 1.57293886e-01f, 1.13376901e-02f, 2.39273518e-01f, 1.76644437e-02f, -8.20562616e-02f, -1.68582844e-03f, 1.25439763e-01f, -7.13629834e-03f,
  -1.38134211e-01f, 1.30483627e-01f, 1.79179162e-01f, 4.80053015e-02f, 6.31480440e-02f, -5.56761138e-02f, -3.06637306e-02f, 4.78436798e-01f, -1.54634774e-01f, -3.49239737e-01f,
  -2.40437388e-01f, -4.81232017e-01f, -6.07552053e-03f, 2.52512336e-01f, 2.24274714e-02f, 1.84985906e-01f, 2.78626800e-01f, -1.62627712e-01f, 4.40204330e-02f, -6.96078464e-02f,
  2.76820421e-01f, 1.97819501e-01f, 6.49177879e-02f, 1.16940580e-01f, -3.07013188e-02f, -9.89661179e-03f, 2.69021899e-01f, 9.63420719e-02f, 2.89463162e-01f, -6.18946366e-02f,
  2.91125089e-01f, 1.29306659e-01f, -2.23483041e-01f, 1.21513382e-01f, 8.52642432e-02f, -8.08810294e-02f, -2.57083446e-01f, 8.71889368e-02f, -9.45465788e-02f, 8.06962997e-02f,
  1.59471538e-02f, 2.16351688e-01f, 1.44282877e-01f, -6.71329647e-02f, -2.66549259e-01f, -4.67975065e-02f, -9.19357464e-02f, -2.02904508e-01f, 7.08487481e-02f, -2.55239867e-02f,
  -2.26600803e-02f, -1.00393720e-01f, 1.45693764e-01f, 2.53538471e-02f, -7.12304562e-02f, 3.30741107e-02f, -1.55778723e-02f, 2.05647454e-01f, 3.26313302e-02f, 8.24837480e-04f,
  3.47727507e-01f, -1.00091554e-01f, -1.23850361e-01f, -1.64269596e-01f, 2.52358258e-01f, -1.50968745e-01f, -1.05867311e-01f, -2.33092159e-01f, 6.56877533e-02f, -6.45085499e-02f,
  6.83569908e-02f, -9.16051567e-02f, -3.73551808e-02f, 1.05456240e-01f, 1.07943103e-01f, -5.70185557e-02f, -1.08916491e-01f, -2.68484682e-01f, 9.63250548e-02f, 1.98656335e-01f,
  -1.23190679e-01f, 1.24854073e-01f, 1.60670251e-01f, -4.45720144e-02f, -7.24238381e-02f, -2.49951612e-02f, -1.12584569e-01f, -1.39596358e-01f, -1.70142442e-01f, -2.60219537e-02f,
  1.65511787e-01f, -1.09420888e-01f, -1.96826547e-01f, 1.96200565e-01f, -1.06350966e-01f, 3.61399531e-01f, 1.10254981e-01f, -3.49916965e-02f, 1.84546947e-01f, -6.12404384e-03f,
  -7.26202726e-02f, -5.08009968e-03f, 1.16729714e-01f, 2.64311939e-01f, -2.00202525e-01f, -9.13599692e-03f, -9.40496996e-02f, -6.72993660e-02f, 9.60689187e-02f, 1.81771323e-01f,
  2.76728958e-01f, -4.58838940e-02f, 1.91860218e-02f, 1.76248968e-01f, 1.64530873e-01f, 1.76849931e-01f, 1.79728180e-01f, 8.00824910e-02f, 1.70131654e-01f, -4.22954075e-02f,
  -2.08687648e-01f, 4.80626635e-02f, -6.28863946e-02f, -4.70655672e-02f, 1.27019092e-01f, -2.42314011e-01f, -2.22721010e-01f, 6.93125278e-02f, 2.37110481e-02f, -5.45952190e-03f,
  -6.71585381e-04f, 2.58308858e-01f, 1.08435757e-01f, 1.80123955e-01f, 1.92699000e-01f, 2.63855219e-01f, -3.09113383e-01f, -9.02799517e-02f, 3.53758298e-02f, 1.85309034e-02f,
  -2.64762100e-02f, -1.19783193e-01f, 3.20101649e-01f, 3.15042526e-01f, -9.01039913e-02f, -1.07673950e-01f, 2.58934081e-01f, 2.02323645e-01f, -3.00432712e-01f, 6.85943738e-02f,
  -9.84586179e-02f, -3.71498346e-01f, 1.27502084e-01f, 2.59745568e-01f, 3.08660954e-01f, -1.05060838e-01f, 1.80355981e-01f, 4.69098002e-01f, -9.14129317e-02f, 1.97560981e-01f,
  -1.31239459e-01f, -1.93399012e-01f, 3.16506237e-01f, 8.45739767e-02f, 5.83105981e-02f, 3.85289304e-02f, -5.15958592e-02f, 2.16351628e-01f, -9.90283955e-03f, -1.81004673e-01f,
  -4.14544754e-02f, 3.21052074e-01f, -4.12907600e-02f, -1.42163306e-01f, 4.05974865e-01f, 3.70692879e-01f, 5.84063120e-02f, 4.62691262e-02f, -7.67158270e-02f, 5.33076935e-02f,
  1.10494653e-02f, -7.10962936e-02f, 1.35969343e-02f, -1.58955306e-01f, 9.67672914e-02f, 7.15329545e-03f, -2.99326293e-02f, -8.94450992e-02f, -3.19987327e-01f, -1.49589102e-03f,
  -1.83326844e-03f, 4.91849817e-02f, -1.90716574e-03f, 1.83559433e-01f, 7.99376294e-02f, -8.46179053e-02f, 1.10299028e-01f, 2.92606086e-01f, 5.61832041e-02f, -1.38868541e-01f,
  1.12416849e-01f, 5.48773305e-03f, -1.89699128e-01f, -9.22443345e-03f, -8.40562433e-02f, -1.76183227e-02f, 5.33152036e-02f, 1.05290309e-01f, 1.20878063e-01f, 1.10470474e-01f,
  -9.54206362e-02f, -1.00775165e-02f, 3.82589847e-01f, -8.19621235e-02f, -1.39394149e-01f, 4.34107222e-02f, 3.28723729e-01f, 1.57702953e-01f, -3.68763357e-02f, -1.82937291e-02f,
  -9.57375541e-02f, -1.43961655e-02f, -1.35760710e-01f, -1.48101717e-01f, -2.42425635e-01f, 2.03056350e-01f, 3.97025198e-01f, 1.64264124e-02f, -1.29177362e-01f, 2.57107355e-02f,
  -9.95630547e-02f, -1.19685996e-02f, 1.53024077e-01f, 2.88054924e-02f, 1.70061752e-01f, -1.30198106e-01f, -6.66742995e-02f, 2.06010804e-01f, 2.85501897e-01f, 2.47286841e-01f,
  1.91444144e-01f, -3.02556646e-03f, 2.38721907e-01f, 1.25926808e-01f, 3.43421963e-03f, 1.23561047e-01f, -9.47279707e-02f, 5.80141433e-02f, 1.09955594e-02f, -7.64178112e-02f,
  1.66916832e-01f, -1.87056102e-02f, -1.32117599e-01f, -1.35883972e-01f, 1.33001432e-01f, -5.29145636e-02f, 8.43982249e-02f, 3.26920301e-02f, 2.09328055e-01f, -4.04625013e-02f,
  -1.25684336e-01f, 2.26326928e-01f, 2.01841593e-01f, 2.50561863e-01f, 3.36187966e-02f, 1.16761789e-01f, 1.95354357e-01f, 1.32826596e-01f, 1.41380206e-01f, -3.42966706e-01f,
  6.31468296e-02f, 1.65139455e-02f, -3.44565630e-01f, 2.07872346e-01f, -1.63044751e-01f, 1.10047229e-01f, -1.49113238e-01f, 2.29422346e-01f, 9.00085568e-02f, 2.07762137e-01f,
  3.44386175e-02f, 2.36011706e-02f, -1.68600500e-01f, -3.60095501e-01f, -6.13022521e-02f, 2.70249009e-01f, -6.84662461e-02f, 2.14026511e-01f, 8.69399458e-02f, 6.39605075e-02f,
  9.57034528e-02f, 2.51491040e-01f, 4.83242199e-02f, -6.16892725e-02f, -8.12884420e-02f, -2.23605130e-02f, 1.04307696e-01f, -1.61970221e-02f, -1.94666199e-02f, -3.17959607e-01f,
  6.80586994e-02f, 1.55618072e-01f, 5.13180308e-02f, 6.62746504e-02f, 2.00043991e-01f, 2.16064379e-01f, 6.10694699e-02f, 1.43702462e-01f, 8.12068507e-02f, 3.78222466e-02f,
  7.66815394e-02f, -4.59355302e-02f, -7.91085213e-02f, -1.31266698e-01f, 1.33304492e-01f, 1.92266449e-01f, 3.25350046e-01f, 4.38208669e-01f, 2.63970822e-01f, 3.50527726e-02f,
  -2.82923579e-01f, -1.04969017e-01f, -2.46263787e-01f, -1.03465334e-01f, 1.78988874e-01f, 6.17003366e-02f, 1.23075247e-01f, 3.95838916e-03f, -1.53410181e-01f, 3.59420851e-03f,
  -1.88963320e-02f, 1.05424188e-01f, -6.14923015e-02f, -1.23609483e-01f, 3.57010186e-01f, -3.57010990e-01f, 8.49919021e-02f, 2.40582585e-01f, 1.43096924e-01f, 1.23696458e-02f,
  2.96975315e-01f, -1.24293782e-01f, 1.44572213e-01f, 5.83190762e-04f, 3.24247748e-01f, -8.10197517e-02f, -2.41393596e-01f, 2.02951834e-01f, 3.09380352e-01f, 3.08005512e-01f,
  -1.93968434e-02f, -2.06537634e-01f, -2.87778676e-02f, 2.74410874e-01f, 5.11625297e-02f, 1.78522989e-01f, -1.20606057e-01f, -1.08318366e-01f, -7.48874098e-02f, -1.46974161e-01f,
  -3.38994145e-01f, 8.36268440e-02f, -1.55502617e-01f, 3.90843265e-02f, 2.54851103e-01f, 1.90923080e-01f, 1.13656849e-01f, -1.67381018e-02f, 1.55457050e-01f, 1.95510954e-01f,
  1.12184711e-01f, 9.27665383e-02f, 8.72636288e-02f, 1.64077096e-02f, -7.51216039e-02f, -9.94297862e-02f, -1.22858293e-01f, -2.07642794e-01f, -1.84830539e-02f, 1.41540721e-01f,
  -1.44270942e-01f, -2.02919707e-01f, -9.83400121e-02f, 2.16408744e-01f, 1.69911787e-01f, 8.28869715e-02f, 7.95329511e-02f, 4.69828755e-01f, 1.58969939e-01f, -1.24397129e-02f,
  3.04459501e-02f, 4.61892128e-01f, 3.80830304e-03f, -2.42172092e-01f, 6.13146201e-02f, -2.75094509e-02f, 5.87390959e-02f, -9.68200713e-02f, 1.52786881e-01f, -1.67943519e-02f,
  -7.14468732e-02f, -2.93286480e-02f, -5.59575632e-02f, 2.42037833e-01f, -1.47493392e-01f, 9.68373194e-03f, -3.56712006e-02f, -2.75998414e-01f, 1.51419848e-01f, 1.44782946e-01f,
  1.57013416e-01f, -1.67762473e-01f, 3.25423390e-01f, 3.97217304e-01f, 9.64754447e-03f, -5.19995242e-02f, -1.26604125e-01f, 4.36977344e-03f, 1.84933558e-01f, 1.96983397e-01f,
  1.00769810e-01f, 7.26999268e-02f, -2.37178102e-01f, -3.44874128e-03f, -7.19442070e-02f, -2.40049273e-01f, 1.58409551e-02f, 2.48376384e-01f, -1.17561653e-01f, -1.46320850e-01f,
  2.46991456e-01f, 3.48742962e-01f, 6.84665218e-02f, 8.48599523e-02f, 2.79618502e-01f, 1.11482613e-01f, 9.27349105e-02f, 2.46626720e-01f, 6.98508322e-02f, 1.29908204e-01f,
  1.33283198e-01f, 3.53644080e-02f, -8.01010504e-02f, -5.87633513e-02f, -6.21983595e-02f, 2.98711419e-01f, 2.52025306e-01f, -2.25825533e-02f, -9.16181412e-03f, 7.69258142e-02f,
  1.54478639e-01f, -1.49505967e-02f, -1.30076617e-01f, -1.42440833e-02f, 1.64607674e-01f, -1.40984371e-01f, 1.95404068e-01f, 1.78480133e-01f, 9.61834937e-02f, 2.93218464e-01f,
  4.60684970e-02f, 2.18296275e-01f, -1.08193763e-01f, 9.61210877e-02f, -1.70989871e-01f, 2.24833727e-01f, -2.71300614e-01f, -2.35242784e-01f, -1.91799581e-01f, 5.69563061e-02f,
  4.68478501e-02f, 2.52295136e-01f, -1.19719788e-01f, -8.32689810e-04f, -8.29098597e-02f, 3.91662478e-01f, -1.87295005e-01f, -2.36664429e-01f, 2.60331571e-01f, 6.29991964e-02f,
  3.85057688e-01f, 8.00664499e-02f, -2.55367428e-01f, 1.42547309e-01f, 2.34639570e-01f, 9.11429226e-02f, 9.64031443e-02f, -1.40186816e-01f, 1.74850434e-01f, 9.79207363e-03f,
  -1.42785832e-01f, 3.33120733e-01f, 1.94335729e-01f, 3.74015830e-02f, -2.52157390e-01f, -1.40604720e-01f, 4.63151447e-02f, 1.23707563e-01f, 7.29664490e-02f, 1.50849083e-02f,
  1.67277992e-01f, 2.24996522e-01f, -1.14242379e-02f, -1.64488539e-01f, 1.00048952e-01f, -9.79899168e-02f, -3.08200657e-01f, -5.17255180e-02f, -2.61360019e-01f, 1.23605207e-01f,
  -7.31833875e-02f, 3.35673749e-01f, 6.73782006e-02f, 2.06664503e-01f, -1.85613453e-01f, 3.50660175e-01f, 2.30772216e-02f, -4.37739752e-02f, -1.49386659e-01f, -1.78202271e-01f,
  7.11244941e-02f, 2.28146743e-02f, 1.71765313e-01f, -4.26210128e-02f, 6.87366799e-02f, 4.42530483e-01f, -1.79447517e-01f, 1.08045908e-02f, 4.03009444e-01f, -6.93904934e-03f,
  3.05934437e-02f, 2.74604410e-01f, 3.05044595e-02f, -1.09207571e-01f, -1.65889859e-01f, -1.92477956e-01f, -1.64384589e-01f, 1.76557705e-01f, 1.69355810e-01f, 4.70932752e-01f,
  -2.01729745e-01f, -7.81978518e-02f, -3.09987038e-01f, -6.34520501e-02f, -1.19127415e-01f, 7.43748546e-02f, 1.91496655e-01f, -2.84226928e-02f, 8.48359540e-02f, -5.56365028e-02f,
  8.25894028e-02f, 1.31998034e-02f, 5.34324758e-02f, 5.95886558e-02f, -4.64702025e-02f, 3.62648249e-01f, -6.89710081e-02f, 1.19057611e-01f, 2.11534888e-01f, 2.93683231e-01f,
  5.07893711e-02f, 2.06936315e-01f, 3.75762470e-02f, -5.54384897e-04f, 1.31689385e-01f, 1.45758301e-01f, 4.28384822e-03f, 2.19918787e-01f, -7.30434954e-02f, 1.59249842e-01f,
  1.42394722e-01f, -1.38471648e-01f, 3.72949451e-01f, 1.22142754e-01f, 2.02097699e-01f, -2.14608118e-01f, -2.07628254e-02f, 1.43930659e-01f, 7.10959509e-02f, -3.66957366e-01f,
  6.30645305e-02f, 1.25706121e-01f, 4.12573777e-02f, 1.47765893e-02f, 6.09675422e-02f, 4.04820263e-01f, -9.62630510e-02f, 2.46543348e-01f, -2.52164039e-03f, -3.37878078e-01f,
  1.54986665e-01f, 1.44618168e-01f, -2.74871022e-01f, -2.04479650e-01f, 1.14920244e-01f, -1.17491059e-01f, 7.91784078e-02f, 1.39035732e-01f, 4.81433421e-02f, 3.10742617e-01f,
  -3.89424600e-02f, 1.78678289e-01f, -1.23561598e-01f, -2.91202575e-01f, -1.19535647e-01f, 6.38412079e-03f, -2.02225253e-01f, 3.84657413e-01f, 2.32177660e-01f, 1.29433826e-01f,
  7.32070208e-02f, 2.26511478e-01f, 5.02069369e-02f, 1.13403536e-01f, -9.92697850e-02f, -1.16053790e-01f, 2.05529109e-01f, 1.15043625e-01f, -4.87185344e-02f, -2.23551229e-01f,
  2.47189164e-01f, -3.04088015e-02f, -1.22753702e-01f, -1.37805166e-02f, 8.45089927e-02f, 1.01671569e-01f, -2.24038921e-02f, 1.33627221e-01f, 2.62633353e-01f, 9.72112641e-02f,
  2.31365729e-02f, 1.07354842e-01f, -3.98178659e-02f, 4.07097163e-03f, -1.26648918e-01f, -7.00677708e-02f, 1.39873743e-01f, 6.70890436e-02f, 5.77281453e-02f, 1.30172536e-01f,
  -1.84398115e-01f, 1.76784217e-01f, -1.06833130e-01f, -2.61294935e-03f, 1.96137130e-01f, -2.56661803e-01f, -1.00539356e-01f, 7.83486441e-02f, -3.02861985e-02f, -1.58703104e-02f,
  -1.47234723e-01f, -2.25288063e-01f, -1.17833756e-01f, 1.72603369e-01f, 1.80111319e-01f, 2.71095127e-01f, 2.84756809e-01f, -7.78799802e-02f, 2.00819209e-01f, -9.33431312e-02f,
  3.55365783e-01f, -6.02495931e-02f, 1.67351514e-02f, 5.94547316e-02f, -3.24914634e-01f, 2.97872163e-02f, 3.81659687e-01f, 3.58655065e-01f, -2.06237398e-02f, -5.30077294e-02f,
  -6.73509240e-02f, 1.43989086e-01f, -2.65719235e-01f, 1.15197338e-02f, -8.06603488e-03f, -1.34370118e-01f, -1.82509735e-01f, 8.57910840e-04f, -1.00238100e-01f, -1.09634630e-01f,
  5.12513854e-02f, 2.32169688e-01f, 7.96222501e-03f, 1.37483001e-01f, -2.09353864e-01f, 8.34567249e-02f, -1.72291845e-01f, -3.85886699e-01f, 4.71812226e-02f, -2.52379719e-02f,
  -8.46252814e-02f, 3.43858078e-02f, 2.31944174e-01f, 1.99418396e-01f, -1.68531969e-01f, 2.43803933e-01f, 1.77230239e-01f, -2.44415905e-02f, 7.08222464e-02f, 2.14748774e-02f,
  4.71563756e-01f, 2.23290339e-01f, 1.30985141e-01f, -8.29138607e-02f, 1.21569350e-01f, -6.41132295e-02f, 2.32152045e-01f, -6.87977076e-02f, 1.13106862e-01f, -1.94486961e-01f,
  1.84157446e-01f, -4.42152172e-01f, 2.30263025e-01f, 2.69171804e-01f, 9.03191939e-02f, 2.79574662e-01f, 1.22232765e-01f, -3.14293504e-01f, 1.67579353e-02f, -3.95232230e-01f,
  1.09206423e-01f, -1.23394607e-02f, -6.83081746e-02f, -7.54127949e-02f, 1.08680584e-01f, 1.02912048e-02f, 7.52573758e-02f, 1.20395981e-01f, 9.04873833e-02f, -4.37017418e-02f,
  -9.98803973e-02f, 3.66489321e-01f, -9.61288735e-02f, 1.34766519e-01f, -1.15469009e-01f, -2.23864816e-04f, 2.71465361e-01f, 3.04488003e-01f, 8.31922367e-02f, -7.87192912e-05f,
  -1.24461941e-01f, 1.31802678e-01f, 8.15722253e-03f, 3.10067330e-02f, 8.50488245e-02f, -1.72507893e-02f, -2.24893607e-04f, 1.12824529e-01f, 4.09665853e-01f, 1.96775079e-01f,
  1.58391133e-01f, -2.45815128e-01f, 7.70250037e-02f, -1.90856475e-02f, -2.82049496e-02f, -5.01143560e-02f, 6.28776029e-02f, 7.22693056e-02f, -2.12636217e-01f, 1.53719172e-01f,
  -1.15723275e-01f, 1.48724586e-01f, 8.68694857e-02f, 6.83535589e-03f, 4.36532855e-01f, -1.03495445e-03f, -1.99851245e-02f, -1.22210011e-01f, -6.87718987e-02f, 6.00060560e-02f,
  1.25995800e-01f, -2.95039177e-01f, -6.00605179e-03f, 1.73547328e-01f, 1.50655406e-02f, -3.70278716e-01f, 8.58207792e-02f, 3.42195213e-01f, 1.04944631e-01f, 2.00669140e-01f,
  1.01545677e-01f, -3.77139747e-01f, 2.75231823e-02f, -6.88638240e-02f, -3.53467792e-01f, -9.74359214e-02f, -1.30745158e-01f, -7.90913589e-03f, 7.97291622e-02f, 3.69327958e-03f,
  -1.11154683e-01f, 2.34695107e-01f, 2.14160562e-01f, -5.71953021e-02f, -3.18471074e-01f, -2.68033355e-01f, -1.67965919e-01f, 7.29371235e-02f, -7.85530657e-02f, 8.84939879e-02f,
  1.40185192e-01f, 2.81715721e-01f, -5.48044443e-02f, 9.94200706e-02f, 6.34315610e-03f, 2.14285895e-01f, -3.82548926e-04f, -1.21937126e-01f, 2.55621582e-01f, 7.07475469e-02f,
  9.36018154e-02f, -4.63248789e-01f, 1.81032851e-01f, 2.24997908e-01f, -1.24365315e-01f, -2.10390553e-01f, 1.86618745e-01f, 8.67868513e-02f, -9.37303677e-02f, 3.85795487e-04f,
  6.60273386e-03f, -2.10727248e-02f, 5.68078943e-02f, 1.68251380e-01f, 7.69683123e-02f, -3.91372392e-04f, -6.27724007e-02f, 1.16411984e-01f, 2.08555222e-01f, 3.48879471e-02f,
  -3.89256105e-02f, 6.93791956e-02f, 1.54228047e-01f, -5.16456328e-02f, 3.04866046e-01f, -4.91847768e-02f, -1.78949863e-01f, -4.49724169e-03f, 3.17771025e-02f, -1.24448180e-01f,
  1.56376183e-01f, 2.69259900e-01f, 2.84800768e-01f, -6.74039498e-02f, 8.73565301e-02f, -1.23734355e-01f, 2.83187963e-02f, -2.74073005e-01f, 8.51923898e-02f, -1.26305953e-01f,
  -2.26204678e-01f, 1.14004381e-01f, 1.05976798e-01f, 1.61464274e-01f, 6.09018765e-02f, 2.36591339e-01f, 9.58231911e-02f, -7.48611614e-02f, -9.99140143e-02f, -2.98352182e-01f,
  1.15095310e-01f, -2.08650269e-02f, -1.04460500e-01f, 1.25741884e-01f, 7.50246421e-02f, -2.54048943e-03f, -1.21204719e-01f, -2.80335941e-03f, 1.39630631e-01f, 2.86021203e-01f,
  -7.71993101e-02f, 1.03408135e-01f, 2.83645391e-01f, 2.66927034e-01f, 1.48538783e-01f, -3.41953546e-01f, 2.92259365e-01f, 2.02235505e-01f, -1.82549044e-01f, 2.04931438e-01f,
  -2.29859464e-02f, 1.07070670e-01f, 1.55397072e-01f, 5.02747744e-02f, 3.99230421e-02f, -1.03671305e-01f, 1.09774679e-01f, 2.66591776e-02f, 1.24519151e-02f, 1.68345377e-01f,
  8.47553387e-02f, -1.20599411e-01f, -3.08592111e-01f, -2.38939628e-01f, 1.48452044e-01f, -5.94715141e-02f, -1.47312075e-01f, 1.22314528e-01f, 2.69524008e-01f, 1.64261252e-01f,
  3.03091537e-02f, 1.37182221e-01f, 1.67720482e-01f, 4.69167471e-01f, 2.01726124e-01f, -1.72504701e-03f, -1.20216303e-01f, 1.29852340e-01f, -3.70502383e-01f, -6.68630973e-02f,
  -8.64651650e-02f, 3.12691927e-01f, -1.69172838e-01f, 5.14367446e-02f, -9.99485031e-02f, -1.11265831e-01f, -6.51945695e-02f, 3.27663869e-01f, -1.71907529e-01f, 3.58430386e-01f,
  2.85716224e-02f, 1.72145978e-01f, 4.20156419e-02f, -2.11458221e-01f, 1.65771261e-01f, 3.85919809e-02f, 3.28865200e-01f, 2.23245829e-01f, 8.30859542e-02f, 5.24598733e-02f,
  1.63098611e-02f, 1.46614201e-02f, -1.76123261e-01f, 3.76891904e-02f, -2.26434439e-01f, 7.62552768e-02f, 9.82837677e-02f, 3.98585424e-02f, -7.23412856e-02f, -1.36783719e-01f,
  6.13027439e-02f, -1.71095759e-01f, -6.07014783e-02f, -8.56964365e-02f, 6.29192963e-02f, 9.79723856e-02f, 2.77690310e-02f, 6.63074926e-02f, 2.16652364e-01f, 1.66008115e-01f,
  -1.24968976e-01f, -1.70586649e-02f, 1.71450004e-01f, 9.39896423e-03f, 1.72285944e-01f, -4.43444699e-02f, 2.29349360e-02f, 8.91762879e-03f, 8.90686959e-02f, 3.11656483e-02f,
  2.51011644e-03f, -1.96998683e-03f, 3.22352618e-01f, 1.51302025e-01f, 2.26546913e-01f, -2.33592615e-01f, -2.58549422e-01f, 3.36392879e-01f, 2.50356704e-01f, 3.76448929e-02f,
  -2.22435668e-01f, -2.74326593e-01f, -2.96404868e-01f, 1.99781224e-01f, 1.25276312e-01f, 4.15054001e-02f, 3.61495644e-01f, -1.16326340e-01f, 8.26703291e-03f, 2.81760953e-02f,
  2.32075721e-01f, 3.14066589e-01f, -7.17127472e-02f, 1.14441693e-01f, -8.60257298e-02f, -5.05413301e-03f, 3.11622679e-01f, 4.10324261e-02f, 2.49323368e-01f, -6.77204281e-02f,
  3.67359258e-02f, 2.52375185e-01f, -6.87403753e-02f, 1.93215311e-01f, 2.06574902e-01f, -8.60699862e-02f, -2.55103052e-01f, 1.03111915e-01f, -2.29485378e-01f, -2.97713816e-01f,
  -1.05082661e-01f, 6.00820370e-02f, 1.08321980e-01f, -7.72799477e-02f, -1.63033769e-01f, 8.47417340e-02f, -2.69727614e-02f, -3.71297210e-01f, 1.55438706e-02f, 2.76545230e-02f,
  1.43829212e-01f, 1.80550978e-01f, -9.80659854e-03f, 2.22485811e-02f, 4.86266380e-03f, -7.30841309e-02f, -1.32954583e-01f, 6.61633611e-02f, -9.60526988e-02f, 7.33705238e-02f,
  -1.66192889e-01f, -1.13637343e-01f, 1.48008138e-01f, -9.00363028e-02f, -1.48360282e-01f, 3.24959308e-01f, 1.45118639e-01f, 5.92681020e-02f, 2.69677073e-01f, 2.19110891e-01f,
  -2.84940809e-01f, -2.77649134e-01f, 5.75747371e-01f, 1.01904824e-01f, -2.90344916e-02f, 2.89384186e-01f, -6.30769506e-02f, 2.37154260e-01f, 3.20698542e-04f, 4.26660687e-01f,
  -1.15522243e-01f, 3.15147154e-02f, -8.89033228e-02f, -1.89191997e-01f, 4.58357716e-03f, 1.34782204e-02f, -2.58233577e-01f, 9.59955975e-02f, 2.51517594e-01f, 3.12707245e-01f,
  8.40512291e-03f, 1.74276993e-01f, -1.85228109e-01f, 2.76351767e-03f, 7.80175403e-02f, 9.45765376e-02f, 5.67795932e-02f, 3.12958688e-01f, 1.29983798e-01f, -1.49993673e-02f,
  -2.74119433e-02f, -1.19333364e-01f, 6.46729544e-02f, -2.36170571e-02f, 3.86681408e-01f, -1.60417691e-01f, -2.30264485e-01f, 2.37602860e-01f, 5.18576093e-02f, 3.98054272e-02f,
  1.29547060e-01f, 7.68266991e-02f, 6.13023564e-02f, 7.36975530e-03f, 1.39949709e-01f, 3.70211154e-02f, 5.67820817e-02f, 9.54756141e-02f, -1.45613849e-01f, -4.57056332e-03f,
  -1.24779552e-01f, 5.82600720e-02f, 4.88050766e-02f, -1.62955120e-01f, -5.87540008e-02f, 4.22896892e-02f, 1.84383616e-01f, -2.88726479e-01f, 1.62467182e-01f, 1.26019523e-01f,
  2.76783437e-01f, -2.74581403e-01f, 6.16629422e-02f, 1.64190337e-01f, -4.40760627e-02f, 2.18120903e-01f, 3.68650585e-01f, 1.09751008e-01f, 1.25292063e-01f, 2.00843409e-01f,
  1.04737334e-01f, -2.51181781e-01f, 4.12374325e-02f, -1.19691148e-01f, -3.55606586e-01f, -2.17695981e-02f, 3.84957604e-02f, 5.74414479e-03f, 1.09547570e-01f, 1.29858404e-01f,
  3.78007106e-02f, 3.68863136e-01f, 9.78366286e-03f, 2.88646854e-02f, -1.72788024e-01f, -3.21980119e-01f, -2.35288939e-03f, -1.60601456e-02f, 9.11467820e-02f, 1.04335755e-01f,
  2.10559562e-01f, 2.43958831e-01f, -8.11165869e-02f, 3.30750972e-01f, 1.19367287e-01f, -1.53494194e-01f, 3.32561284e-02f, 1.38201937e-01f, 4.23449138e-03f, -1.13638923e-01f,
  9.07802209e-02f, -1.70068383e-01f, 1.29952922e-01f, 4.45333272e-02f, 1.81254670e-01f, -2.88494766e-01f, 1.11988403e-01f, 1.13603957e-01f, 8.80670398e-02f, 7.58350566e-02f,
  8.68515968e-02f, 1.67703137e-01f, -1.59416616e-01f, -5.27662039e-02f, 1.15265563e-01f, -8.87722299e-02f, 3.00910454e-02f, -4.99982983e-02f, -1.77813843e-01f, 3.70289356e-01f,
  2.32115850e-01f, -3.51234861e-02f, -1.38508782e-01f, 1.76292390e-01f, -1.12861417e-01f, 1.03769422e-01f, 5.38752340e-02f, 1.82991147e-01f, -1.53214544e-01f, -1.30390570e-01f,
  1.57656688e-02f, -1.01054050e-01f, 1.45483807e-01f, 9.74483043e-02f, 1.53393671e-01f, 1.79838121e-01f, -9.53106880e-02f, 3.46050523e-02f, 9.82463956e-02f, 2.34458074e-01f,
  -7.55083412e-02f, -1.11188054e-01f, 3.43068182e-01f, -3.19023915e-02f, -4.64672893e-02f, 1.49206474e-01f, 4.42142300e-02f, 3.45212594e-03f, -8.10719132e-02f, 3.28920603e-01f,
  -2.33081486e-02f, -2.40786001e-01f, -3.11661243e-01f, -2.38933302e-02f, 5.47200441e-03f, 1.90702364e-01f, 1.73132159e-02f, 8.56249779e-02f, 4.97681387e-02f, -2.13972647e-02f,
  -2.00822666e-01f, -1.93526790e-01f, 2.08362550e-01f, 2.99036354e-01f, 1.54994978e-02f, 2.02563226e-01f, 1.76036712e-02f, 2.21062183e-01f, -4.44013625e-02f, -1.02315500e-01f,
  8.52188319e-02f, -6.66045174e-02f, -1.73045341e-02f, 2.27814484e-02f, 8.38186368e-02f, 1.92374691e-01f, -1.81016654e-01f, 1.63581356e-01f, 3.74499969e-02f, 1.23223215e-01f,
  -7.63905421e-02f, -2.79671568e-02f, 1.59293294e-01f, 1.90559044e-01f, -3.15340519e-01f, -4.25884649e-02f, 3.66277359e-02f, -2.87225723e-01f, -2.58181132e-02f, -1.76587686e-01f,
  2.14238614e-02f, -2.34958708e-01f, 1.82230324e-01f, 3.10161151e-02f, -1.39755029e-02f, 3.93253826e-02f, -8.76887441e-02f, -7.08903000e-02f, 5.18966503e-02f, -1.82650208e-01f,
  1.80978015e-01f, 1.12169065e-01f, 8.75593945e-02f, 2.02906966e-01f, 1.82820082e-01f, -7.01720342e-02f, 1.59390256e-01f, 4.74950904e-03f, 2.33255744e-01f, -9.87769738e-02f,
  8.65467191e-02f, 7.33497143e-02f, 1.04699239e-01f, 7.05907419e-02f, 5.05927876e-02f, 3.53386670e-01f, -2.01485096e-03f, 1.70654476e-01f, 8.08762759e-02f, -1.13480695e-01f,
  1.47890881e-01f, -6.14126353e-03f, -2.15466842e-02f, -3.01477741e-02f, -6.25953218e-03f, -1.55869350e-01f, -2.27558047e-01f, 7.21843243e-02f, 2.42295358e-02f, -8.37759376e-02f,
  1.45968243e-01f, 2.95543581e-01f, 1.35769531e-01f, -1.63374841e-01f, -7.24431220e-03f, 1.51148317e-02f, -3.92985232e-02f, 6.97309896e-02f, 1.17427809e-02f, -2.12044045e-01f,
  -2.00112849e-01f, -2.33332664e-01f, 3.18159647e-02f, 3.13975066e-02f, 9.09958705e-02f, -3.86258140e-02f, -3.80870759e-01f, -1.66068003e-01f, 4.64990698e-02f, 2.02040151e-02f,
  2.17673242e-01f, 1.41468406e-01f, 1.23718776e-01f, -2.41540834e-01f, 4.94043753e-02f, 5.24601825e-02f, 1.84541613e-01f, 1.55102685e-01f, 3.25299114e-01f, 7.61415139e-02f,
  1.45657614e-01f, 2.25210607e-01f, -2.82977875e-02f, -1.45225987e-01f, -2.34277964e-01f, 9.76426303e-02f, 8.82438719e-02f, 5.53797185e-02f, -1.33575261e-01f, -2.15696581e-02f,
  2.60728419e-01f, 2.45045677e-01f, -1.22867227e-01f, 3.00535589e-01f, 1.49783641e-01f, 1.99807454e-02f, 5.05978502e-02f, -2.77737767e-01f, -1.47756353e-01f, 1.54622868e-01f,
  1.09925620e-01f, 7.47966692e-02f, -1.24242939e-01f, 4.81109954e-02f, 3.67682040e-01f, -1.48245888e-02f, -8.58637504e-03f, -1.19129799e-01f, -1.35589853e-01f, -4.86363098e-02f,
  1.72050387e-01f, -8.63811448e-02f, 4.86590341e-03f, -1.64172977e-01f, 1.17349923e-01f, 1.96048409e-01f, 3.25452030e-01f, 1.34512678e-01f, 2.03541234e-01f, 1.21756062e-01f,
  4.64546345e-02f, 1.59829423e-01f, 2.54668683e-01f, 2.94178337e-01f, 6.61225431e-03f, -2.23947745e-02f, 1.40123904e-01f, -3.52126881e-02f, -1.32334515e-01f, 9.27980021e-02f,
  3.75723183e-01f, 3.01079959e-01f, 2.79746085e-01f, 3.64277750e-01f, -1.77985534e-01f, 1.26851156e-01f, -7.02226311e-02f, 2.18265176e-01f, 1.67463303e-01f, -4.52033021e-02f,
  -1.68111682e-01f, -3.05283248e-01f, -3.35480161e-02f, -1.14088923e-01f, 8.26456174e-02f, 1.72537312e-01f, 1.39395118e-01f, 4.40933317e-01f, -4.00403179e-02f, -7.66405165e-02f,
  2.07648888e-01f, 2.54461151e-02f, 1.33496121e-01f, 1.64178073e-01f, 1.60850599e-01f, -1.79514334e-01f, 5.09851165e-02f, -6.45407438e-02f, -1.83814436e-01f, -2.64867004e-02f,
  1.86580017e-01f, 4.19502497e-01f, -2.00680122e-01f, 3.05438731e-02f, -1.89379409e-01f, -1.11319967e-01f, 1.21894248e-01f, -1.28072978e-03f, -2.37287492e-01f, -4.44051549e-02f,
  1.55935064e-01f, 1.27837911e-01f, -4.85793613e-02f, 5.38454950e-02f, 1.86019376e-01f, -1.38898224e-01f, -1.97012603e-01f, 3.95767421e-01f, 3.10620844e-01f, 1.15161240e-01f,
  -1.79846495e-01f, 7.96866938e-02f, 8.05997625e-02f, -6.16498627e-02f, 4.51281667e-02f, 1.26482308e-01f, 1.01285867e-01f, 2.43403032e-01f, -2.74631083e-01f, -2.79812701e-02f,
  2.37107258e-02f, -2.21566372e-02f, 8.29004720e-02f, -6.27309904e-02f, -8.31576139e-02f, 2.35633940e-01f, 2.80082107e-01f, -6.41460251e-03f, -9.72760096e-03f, 4.26613018e-02f,
  3.08898807e-01f, -6.64488673e-02f, 1.32063448e-01f, -5.55243716e-02f, 3.86616215e-02f, 1.62327215e-01f, 3.71023476e-01f, 7.38637522e-02f, 4.07758951e-02f, 1.62063003e-01f,
  1.11590279e-02f, 2.39713803e-01f, -1.92892253e-01f, -2.34549478e-01f, 5.23372255e-02f, 2.80749947e-01f, 1.18683867e-01f, -1.72755793e-01f, 3.72989982e-01f, 1.46321401e-01f,
  2.40118667e-01f, 5.10909975e-01f, -2.93185078e-02f, -1.33664742e-01f, -7.82582536e-02f, 7.72656277e-02f, 9.76181626e-02f, 3.28028463e-02f, 2.51491398e-01f, 2.81203911e-03f,
  1.17353462e-01f, 2.20286578e-01f, 6.34866655e-02f, 1.55320495e-01f, 9.98716056e-02f, -6.55812994e-02f, 1.48794651e-01f, -4.36626896e-02f, 4.53103753e-03f, 2.29732066e-01f,
  -1.03826948e-01f, -1.57543764e-01f, 4.07688618e-02f, 2.64981687e-01f, 3.84726115e-02f, -2.34572098e-01f, 1.38664648e-01f, 1.25307038e-01f, 1.05297320e-01f, 1.59300625e-01f,
  -2.74219681e-02f, 1.77553236e-01f, -1.95460677e-01f, -9.87857655e-02f, 5.00648394e-02f, -5.64476065e-02f, 2.20729448e-02f, -2.44846880e-01f, -1.16000831e-01f, 8.41298178e-02f,
  1.75058469e-01f, -8.37500319e-02f, 1.78863294e-02f, 9.41324681e-02f, 1.87187687e-01f, -7.14822784e-02f, 8.96672253e-03f, 2.88600266e-01f, -1.87416017e-01f, -2.21243590e-01f,
  3.98887902e-01f, 2.97726989e-01f, -5.86568080e-02f, 4.66697544e-01f, 3.13867889e-02f, -2.31231079e-01f, 2.41386853e-02f, 5.85155934e-03f, -4.39754069e-01f, 5.74995801e-02f,
  -3.72060388e-02f, -3.41579407e-01f, -9.10987109e-02f, -2.43165828e-02f, -1.30427808e-01f, 4.59303230e-01f, 1.78257689e-01f, 1.11170940e-01f, -3.36101145e-01f, -8.92664418e-02f,
  -1.12102523e-01f, -3.96870106e-01f, 1.01486251e-01f, 1.06037803e-01f, 3.11061949e-01f, 1.70402676e-01f, -5.31327836e-02f, 1.90241098e-01f, 1.62220597e-01f, 5.24299666e-02f,
  6.00893311e-02f, -1.04693711e-01f, 2.13029951e-01f, -1.63616791e-01f, -8.29002932e-02f, 3.90420705e-02f, 2.44849697e-01f, 1.25634894e-02f, 1.51683807e-01f, 1.17454017e-02f,
  1.86688416e-02f, 1.27149135e-01f, 8.63098875e-02f, 1.99272372e-02f, 5.03145754e-02f, 8.66943151e-02f, -7.04137459e-02f, 9.68732461e-02f, 9.89519730e-02f, 9.69569236e-02f,
  9.83552411e-02f, -1.86057746e-01f, -3.18228789e-02f, 1.26260817e-01f, 1.78222582e-02f, -3.05041783e-02f, 7.84765631e-02f, -3.74873057e-02f, 3.44380498e-01f, -1.21817090e-01f,
  -7.44783878e-02f, 6.71998691e-03f, -2.76636109e-02f, 3.25342655e-01f, -1.85642764e-02f, 7.60713294e-02f, 6.99607208e-02f, 9.78578907e-03f, 1.35532962e-02f, 1.40402094e-01f,
  -1.00195855e-02f, -2.12211367e-02f, 1.59293458e-01f, 2.43343085e-01f, -7.70925507e-02f, 3.50501761e-02f, 1.24949217e-01f, 2.34481588e-01f, 2.27921814e-01f, 3.29303592e-01f,
  -6.72180355e-02f, -9.00449604e-02f, 1.25224069e-01f, 3.33384313e-02f, 2.10934356e-01f, 1.24553740e-02f, 1.04003064e-01f, 2.95730293e-01f, 1.29831806e-01f, 1.32535666e-01f,
  6.60072565e-02f, 2.18620494e-01f, 1.50723651e-01f, 9.16208029e-02f, 3.91362906e-02f, -1.57403871e-01f, -8.22722986e-02f, 1.44732341e-01f, 1.23501197e-01f, -2.04876974e-01f,
  -9.44433082e-03f, 1.36742666e-01f, -2.06360787e-01f, -4.28613961e-01f, 1.47732258e-01f, -8.57848674e-03f, 9.68532413e-02f, 7.09525868e-02f, 1.90295741e-01f, 1.41558852e-02f,
  1.18583990e-02f, -1.15263484e-01f, 9.82342288e-02f, 6.34903461e-02f, -6.26719967e-02f, 1.38452590e-01f, -1.33682206e-01f, 1.23607688e-01f, 4.30802722e-03f, 3.45431000e-01f,
  8.04442167e-02f, 7.36254528e-02f, 3.00923139e-01f, 2.22132996e-01f, -2.18485355e-01f, -1.97484702e-01f, -4.46068943e-02f, 1.43533677e-01f, -1.27137929e-01f, 5.85657405e-03f,
  2.53299594e-01f, -1.46320671e-01f, 1.69862717e-01f, 2.12159574e-01f, -2.52612412e-01f, 5.46916574e-02f, 2.88265616e-01f, 4.23492864e-02f, -9.17568505e-02f, 2.60719508e-01f,
  5.68591803e-02f, 2.16230392e-01f, 1.74077719e-01f, 3.00809056e-01f, -1.68327779e-01f, -1.34197995e-01f, 1.03576370e-01f, 9.92406607e-02f, 7.46377930e-02f, -3.18533748e-01f,
  1.85058296e-01f, 1.41027365e-02f, 1.56178787e-01f, -2.15828076e-01f, -1.07183717e-01f, 1.06005847e-01f, 2.41456136e-01f, 2.64494032e-01f, -1.73623152e-02f, 3.74839790e-02f,
  9.59220976e-02f, 2.21856773e-01f, -3.87273133e-02f, -5.36439233e-02f, 8.32437538e-03f, 1.87178954e-01f, -1.90018758e-01f, 1.90710664e-01f, 6.09003715e-02f, -1.12065114e-02f,
  -4.74441275e-02f, 6.22600375e-04f, 6.19180966e-03f, 1.00437172e-01f, -9.76225659e-02f, 1.93432212e-01f, -3.28924768e-02f, 7.51194507e-02f, 1.76009741e-02f, -1.70632184e-01f,
  2.90466726e-01f, -8.31387844e-03f, -3.64708751e-01f, -2.40606666e-02f, 2.80853659e-01f, -1.55410960e-01f, -2.49806698e-02f, -7.71483481e-02f, -1.57367773e-02f, -1.34104952e-01f,
  9.62439701e-02f, -3.15094411e-01f, 9.73785073e-02f, 4.05840456e-01f, 9.18793976e-02f, 9.92302448e-02f, -6.27529025e-02f, -2.57260203e-01f, 1.67259455e-01f, 1.75136372e-01f,
  4.12081331e-02f, -1.24656081e-01f, -7.96668753e-02f, 1.18657937e-02f, -4.62189829e-03f, 2.23652786e-03f, -4.35370281e-02f, -1.15984138e-02f, 2.74780616e-02f, 1.81972068e-02f,
  4.96684052e-02f, -2.07019791e-01f, -1.39984921e-01f, 1.15180805e-01f, -1.62338361e-01f, 3.14887255e-01f, 1.02834836e-01f, 2.77777407e-02f, 2.59596884e-01f, 5.61886467e-02f,
  1.24313071e-01f, 1.75882220e-01f, 2.89108492e-02f, 3.58481742e-02f, 6.09298423e-02f, 1.37996316e-01f, 2.28098363e-01f, -1.16147704e-01f, 2.86627829e-01f, 1.05931461e-01f,
  2.42448196e-01f, -2.88617816e-02f, -9.12038237e-02f, 1.96773455e-01f, -3.41043919e-02f, 8.84126574e-02f, 2.15465054e-02f, 1.57839835e-01f, -2.38377955e-02f, -7.70820007e-02f,
  -1.93013474e-01f, -6.87472597e-02f, -5.26154749e-02f, 1.22114457e-01f, -1.48577135e-04f, -8.85544419e-02f, 9.96169969e-02f, 2.55194426e-01f, 1.26598075e-01f, -1.09314784e-01f,
  2.58660883e-01f, 1.21885963e-01f, -1.64191648e-01f, -1.78539574e-01f, 2.95354128e-01f, 3.10127050e-01f, -2.17803404e-01f, -7.28865415e-02f, -7.84955472e-02f, -1.39135480e-01f,
  1.00171499e-01f, 3.92848961e-02f, -4.95188795e-02f, -1.76535636e-01f, 2.20316336e-01f, 9.33042914e-02f, 6.91605806e-02f, 1.16411760e-01f, -1.22012742e-01f, 2.87451178e-01f,
  3.88642251e-02f, -3.69808823e-02f, 5.13490662e-03f, -4.41376045e-02f, 3.29415649e-01f, 1.68141931e-01f, 2.45211706e-01f, 1.10650040e-01f, -3.52036692e-02f, 1.05713159e-02f,
  -9.22103375e-02f, -1.69618830e-01f, 1.06439002e-01f, 4.11638319e-02f, 1.74519777e-01f, -1.94370255e-01f, 9.75917503e-02f, 1.00354150e-01f, -1.68854326e-01f, -1.41230419e-01f,
  -1.78736448e-01f, 2.51253664e-01f, -7.58065209e-02f, 3.63541394e-03f, 1.94495887e-01f, 2.70970583e-01f, 5.76012507e-02f, 6.01238292e-03f, 1.24134429e-01f, 2.60720272e-02f,
  9.78831425e-02f, -1.81858409e-02f, -1.59866229e-01f, -1.06783258e-02f, -1.09833635e-01f, -6.51585013e-02f, -1.31389141e-01f, 9.46712866e-03f, -1.54769674e-01f, -2.72609778e-02f,
  -1.73569489e-02f, 2.61114806e-01f, 1.57654986e-01f, -8.67740884e-02f, 4.08147648e-02f, 1.63100157e-02f, -2.68703282e-01f, -6.36206567e-02f, 3.97182137e-01f, 2.66004711e-01f,
  -1.72105849e-01f, -4.29605022e-02f, 2.19973400e-01f, -9.56984833e-02f, 6.87803328e-02f, -1.17209360e-01f, -1.76750287e-01f, -7.57630244e-02f, -1.02758385e-01f, 1.55089319e-01f,
  2.46362183e-02f, 9.57982689e-02f, -1.27544686e-01f, -1.86590699e-03f, 1.72980241e-02f, 1.96420908e-01f, -1.19382523e-01f, 3.98817956e-02f, 5.30319549e-02f, -3.03264856e-02f,
  -1.14282466e-01f, 1.82937235e-01f, 9.98979528e-03f, 1.02238054e-03f, 1.65818512e-01f, -2.45425835e-01f, 1.07461505e-01f, 1.75113872e-01f, 3.04928929e-01f, -1.54333889e-01f,
  1.60606042e-01f, 4.49795760e-02f, -1.55410901e-01f, 5.97316176e-02f, 3.80712412e-02f, 1.17378645e-01f, -7.42934719e-02f, 1.29999131e-01f, 2.15247318e-01f, 1.28898963e-01f,
  1.68335631e-01f, 9.64331627e-02f, 1.62248209e-01f, 1.34306282e-01f, -1.24533530e-02f, 1.71606541e-01f, -1.48031518e-01f, 7.02906623e-02f, 4.71992940e-02f, 7.73759885e-03f,
  -4.50224988e-02f, 7.69596845e-02f, 2.39072934e-01f, -1.83545426e-02f, 5.67310676e-02f, 5.98854385e-02f, 2.05176681e-01f, -5.43824285e-02f, 1.77538231e-01f, 6.87553063e-02f,
  -2.79535875e-02f, -3.80955860e-02f, 4.04762886e-02f, -2.60685891e-01f, 9.56710726e-02f, 1.80519000e-01f, 3.27980034e-02f, 2.46456116e-01f, 1.22976273e-01f, -1.77262291e-01f,
  -3.41027305e-02f, -2.76013613e-01f, -1.00016654e-01f, -2.32881512e-02f, -3.14920917e-02f, 1.60313949e-01f, -8.56823027e-02f, -4.04160731e-02f, 1.86236370e-02f, 1.28093973e-01f,
  -5.76585308e-02f, -7.77510256e-02f, -1.33919895e-01f, -3.23814712e-02f, -2.13641562e-02f, -5.87699004e-02f, -3.02667860e-02f, -1.52199948e-02f, 1.57240883e-01f, 1.89466059e-01f,
  -2.18076602e-01f, 7.06621706e-02f, 1.61827326e-01f, 5.13297208e-02f, 6.06397465e-02f, 1.43219292e-01f, 1.64932206e-01f, 4.96914349e-02f, 7.24613741e-02f, -5.33390604e-02f,
  2.49374270e-01f, 7.84187168e-02f, -7.29974583e-02f, 2.18195692e-01f, 4.21545953e-02f, 1.39626116e-01f, 2.55253818e-02f, 9.02108252e-02f, 1.01968125e-01f, 1.60200387e-01f,
  9.51649174e-02f, -3.36786993e-02f, -2.08133869e-02f, -2.59516425e-02f, -1.27421189e-02f, 1.91773072e-01f, 6.18195608e-02f, 1.73959192e-02f, -1.34175003e-03f, 2.10872814e-01f,
  -8.71558189e-02f, 1.44103868e-02f, 3.07340920e-01f, 4.33200598e-01f, -1.81950897e-01f, -1.67494193e-01f, 5.71627915e-02f, 3.60380918e-01f, -4.87831496e-02f, -6.41411096e-02f,
  1.86154112e-01f, -2.70348132e-01f, 1.07107209e-02f, 2.87699997e-01f, 8.29958320e-02f, -1.82010174e-01f, 2.96933204e-01f, 8.18485767e-02f, -4.41215411e-02f, 2.47075140e-01f,
  1.30865738e-01f, 2.58274883e-01f, 1.35704577e-01f, 1.01468541e-01f, 5.87928593e-02f, -1.47766992e-01f, 7.15512335e-02f, 1.73650697e-01f, 4.66798306e-01f, -4.83724871e-05f,
  -1.16234019e-01f, -1.16714217e-01f, -3.41383833e-03f, -1.29450604e-01f, -1.77389234e-01f, 1.77713960e-01f, 2.10386813e-01f, 3.48623008e-01f, -7.40486234e-02f, 1.22324575e-03f,
  -1.07502900e-01f, 3.29255909e-01f, 1.60728782e-01f, 2.14660689e-02f, 8.60857740e-02f, 1.51144296e-01f, -2.75832802e-01f, 3.81879397e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.89147040e-01f, 1.86856464e-01f, -3.32881138e-03f, 2.36568630e-01f, 1.45572603e-01f, 2.00100332e-01f, 4.10464592e-02f, 2.00389266e-01f, 9.11260396e-02f, 2.17179924e-01f,
  2.09441766e-01f, 4.34202217e-02f, 4.70414199e-02f, 1.47113830e-01f, 5.18877842e-02f, 3.52530591e-02f, 1.08237877e-01f, 1.70866266e-01f, 5.09776846e-02f, 3.89334671e-02f,
  1.11899719e-01f, 2.51924098e-01f, 1.12589464e-01f, 9.90543514e-02f, -8.91276356e-03f, -4.23372388e-02f, 1.97127283e-01f, 2.85525024e-01f, 1.38885200e-01f, 1.91502124e-01f,
  2.29424059e-01f, 2.79528290e-01f, 1.40019447e-01f, 1.68318853e-01f, 5.91971688e-02f, 1.71042234e-01f, 1.27525687e-01f, 1.31768286e-01f, -8.91464110e-03f, 1.29705518e-01f,
  1.36854127e-01f, -1.98764214e-03f, 1.88059017e-01f, 2.60530025e-01f, 2.28909686e-01f, 8.69976655e-02f, 2.23943427e-01f, 1.73733488e-01f, 6.22407608e-02f, 1.60148725e-01f,
  1.06064722e-01f, 9.92870778e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.84285098e-01f, -2.53015280e-01f, -1.30028233e-01f, -2.58733690e-01f, -2.17255041e-01f, -1.05940197e-02f, -2.35810116e-01f, -4.71441410e-02f, -1.82869568e-01f, -1.18447684e-01f,
  -1.17587321e-01f, 3.75276208e-02f, -2.05354631e-01f, -4.20398831e-01f, 1.17037959e-01f, -1.34582311e-01f, -1.45083413e-01f, 1.67289168e-01f, 6.81814924e-02f, -4.06907722e-02f,
  9.67671424e-02f, -3.98030698e-01f, -3.96345943e-01f, -2.46110305e-01f, -7.37043247e-02f, -5.71556799e-02f, -1.75053462e-01f, 7.39339292e-02f, -1.45620421e-01f, 7.25315139e-02f,
  -3.05425644e-01f, 2.73769259e-01f, 2.71663249e-01f, 6.02567755e-02f, -9.27554443e-02f, -2.34099582e-01f, 2.03430131e-01f, 1.33152485e-01f, -1.49395287e-01f, -2.94673800e-01f,
  -4.98785963e-03f, -3.05934995e-01f, 2.11269632e-01f, -1.08033486e-01f, -2.74987429e-01f, 1.03619933e-01f, 1.65431537e-02f, 2.48681873e-01f, 6.09273044e-03f, 2.21029758e-01f,
  2.28053659e-01f, 1.14535891e-01f, -4.08626109e-01f, 2.57874340e-01f, -3.99688959e-01f, 1.96235612e-01f, 2.04591036e-01f, -1.15377903e-02f, -3.44463699e-02f, -1.72067821e-01f,
  -5.25930941e-01f, -3.21076632e-01f, -4.74444628e-02f, -2.08097383e-01f, 7.59365410e-02f, 1.56348586e-01f, 2.00582534e-01f, -3.84983450e-01f, 3.66938412e-02f, -2.31405571e-01f,
  1.95864454e-01f, -1.99784189e-01f, -2.21366271e-01f, -2.35791534e-01f, 1.90344274e-01f, -2.51160562e-01f, 1.24249026e-01f, -5.26698828e-01f, -2.36024901e-01f, 2.51377344e-01f,
  -2.88052499e-01f, -8.76641273e-02f, -1.71533883e-01f, -3.67097110e-01f, -6.00293636e-01f, -2.15568572e-01f, -3.81674692e-02f, 6.79483488e-02f, -3.62813950e-01f, -4.34730858e-01f,
  -4.12417799e-01f, -3.37352604e-01f, -2.04053998e-01f, -3.29528958e-01f, 9.19749215e-02f, -2.07253873e-01f, -3.54193956e-01f, -1.66547760e-01f, 1.59548339e-03f, -3.00163209e-01f,
  -4.39337850e-01f, 1.41214535e-01f, -2.58393973e-01f, -5.09015322e-01f, 2.30268031e-01f, -1.33608758e-01f, 2.92082995e-01f, -2.73140103e-01f, 2.28559479e-01f, 2.61862069e-01f,
  2.46674672e-01f, 1.59167036e-01f, 1.56084806e-01f, 7.52926692e-02f, 1.90355465e-01f, -2.49588579e-01f, 4.65812348e-02f, 1.01910301e-01f, -2.99785793e-01f, 1.71210930e-01f,
  3.52235943e-01f, 1.22278079e-01f, 9.38862115e-02f, 2.34630585e-01f, -1.20334886e-01f, 1.63540274e-01f, 1.59056202e-01f, 3.65026109e-02f, -1.55737856e-02f, 1.02873236e-01f,
  2.71196216e-01f, 8.85283872e-02f, 1.05967067e-01f, 2.73657173e-01f, 6.17209859e-02f, 2.71093190e-01f, 1.50613517e-01f, 2.05844358e-01f, 3.09408978e-02f, -1.87505245e-01f,
  1.91732407e-01f, -3.19294222e-02f, 1.25436917e-01f, 1.84044726e-02f, 4.74074576e-03f, -3.37266266e-01f, -6.46990612e-02f, -4.34326306e-02f, -2.70234138e-01f, 7.03066066e-02f,
  -2.13330667e-02f, -1.82950318e-01f, 1.36883352e-02f, 1.80638775e-01f, -2.04318300e-01f, -3.05893391e-01f, 1.04675531e-01f, -3.96544933e-02f, -2.99356878e-01f, 4.37174469e-01f,
  -3.20362188e-02f, -3.18830870e-02f, 3.51126585e-03f, -4.03148592e-01f, -1.06234908e-01f, -2.02292517e-01f, 3.40295970e-01f, -1.47501960e-01f, 2.27116957e-01f, 2.33234018e-01f,
  1.10827707e-01f, 4.66026086e-03f, 3.37755859e-01f, 8.59464034e-02f, -4.27964717e-01f, -3.14774603e-01f, -2.67533213e-01f, 1.18688069e-01f, 1.75280854e-01f, 2.43305326e-01f,
  -3.88449356e-02f, -4.60149437e-01f, 4.00599211e-01f, 1.77109301e-01f, 2.93629199e-01f, -1.38088092e-01f, -1.39615551e-01f, -2.76552528e-01f, -4.78378356e-01f, -5.96433043e-01f,
  1.39102966e-01f, -3.66950929e-01f, 2.51692116e-01f, -1.18030817e-04f, -2.78236568e-01f, 4.77173701e-02f, -7.30657578e-03f, 5.59939854e-02f, -6.88353553e-02f, -8.27443674e-02f,
  -5.66183031e-02f, -1.95167646e-01f, -1.45249099e-01f, 5.36405966e-02f, -4.31805283e-01f, 1.35791853e-01f, 1.60064191e-01f, 1.39225230e-01f, -5.51335588e-02f, -1.97967440e-01f,
  -5.47882877e-02f, 1.54212236e-01f, 1.90447606e-02f, 2.06891075e-01f, -3.70276272e-01f, -1.77507117e-01f, 5.46936989e-01f, 1.69659987e-01f, 1.61489382e-01f, 5.83338551e-02f,
  4.76203531e-01f, -1.08759059e-02f, -2.22748622e-01f, 1.96802765e-01f, -4.09201741e-01f, -1.87522098e-01f, -3.14155936e-01f, 3.57149214e-01f, 1.98237643e-01f, -1.10722430e-01f,
  -1.62553966e-01f, 2.17366457e-01f, -8.42977837e-02f, 1.79354846e-01f, -6.21153880e-03f, -3.90402377e-01f, -4.84618306e-01f, -1.40290752e-01f, -2.77011335e-01f, 6.05518278e-03f,
  -2.76640952e-01f, 1.87412098e-01f, -1.92287877e-01f, 5.35850748e-02f, -1.80220976e-01f, -3.77190975e-03f, -2.41684973e-01f, -6.42862201e-01f, 1.86330646e-01f, -4.74198729e-01f,
  -4.15720671e-01f, 7.91800022e-02f, -2.64842272e-01f, -2.32525051e-01f, -1.81536645e-01f, -3.86911660e-01f, -2.23154306e-01f, 1.86477378e-01f, 2.90777951e-01f, 3.60324681e-01f,
  -1.01846069e-01f, -2.36490205e-01f, -1.01182982e-01f, 1.83859989e-01f, -2.93086767e-01f, 4.07422096e-01f, -6.99335784e-02f, 5.04763067e-01f, -4.07236487e-01f, 5.69386892e-02f,
  1.75733879e-01f, 1.31478272e-02f, -2.77181059e-01f, -7.72212595e-02f, -2.72829503e-01f, 2.40118019e-02f, 1.31360635e-01f, 3.58266123e-02f, 1.30018294e-02f, 1.93021834e-01f,
  -2.15855271e-01f, 7.27523491e-02f, 2.37726748e-01f, 2.56479144e-01f, -1.82016373e-01f, 2.11937159e-01f, -1.67581558e-01f, -2.07135350e-01f, 2.62875333e-02f, 1.64317504e-01f,
  8.14907476e-02f, -4.01127897e-03f, 1.72986090e-02f, -4.55299348e-01f, -5.68766177e-01f, -9.59688500e-02f, 6.58377558e-02f, 1.98375791e-01f, -7.79725984e-02f, 2.86957145e-01f,
  -4.68796957e-03f, -2.36359984e-01f, -2.82581210e-01f, 2.06010304e-02f, 1.71469763e-01f, 9.13452208e-02f, -1.47400245e-01f, 9.89407673e-02f, -1.04271635e-01f, 1.00401528e-02f,
  2.21555799e-01f, -1.47807211e-01f, -1.64749071e-01f, -1.24149330e-01f, 9.40670595e-02f, -1.73494160e-01f, 1.05242275e-01f, 1.60542831e-01f, -7.30233081e-03f, -9.67117958e-04f,
  -1.32147551e-01f, 5.89191839e-02f, 7.35765994e-02f, 3.69144887e-01f, -8.02339539e-02f, 2.19842009e-02f, -2.57101953e-01f, -4.79884408e-02f, 4.46237653e-01f, 3.85674126e-02f,
  -9.28777307e-02f, 3.64924937e-01f, 3.54969680e-01f, -5.48095584e-01f, -1.54094249e-01f, 3.64016555e-02f, 2.93627441e-01f, 3.70297879e-01f, -1.80124700e-01f, -2.59799659e-01f,
  -1.95176020e-01f, 1.88132122e-01f, 3.69973570e-01f, -1.17716186e-01f, -4.21807736e-01f, -5.26947856e-01f, -6.33175066e-03f, -3.23629290e-01f, -2.07805008e-01f, 7.97243416e-02f,
  -1.19714826e-01f, -3.93363088e-01f, 3.00259560e-01f, 2.73034304e-01f, -3.07380527e-01f, 9.44305435e-02f, -2.62318462e-01f, 1.26648739e-01f, -2.12207958e-02f, 4.66558188e-01f,
  -8.16787183e-02f, -4.03398067e-01f, -5.93883693e-02f, -8.89353454e-02f, -3.63120317e-01f, -4.77466464e-01f, -7.41155446e-02f, 2.69708127e-01f, 2.57612020e-01f, -1.63256541e-01f,
  6.28281087e-02f, -3.60295549e-02f, 3.32272463e-02f, -1.17941834e-01f, -5.25380194e-01f, 3.20389904e-02f, -1.53877452e-01f, 1.29887402e-01f, 6.05305173e-02f, -3.24386597e-01f,
  5.56638278e-02f, 8.61072317e-02f, -1.61202654e-01f, 3.21928024e-01f, 5.69122098e-02f, -1.12556212e-01f, -1.45100698e-01f, -1.41959772e-01f, 1.86103895e-01f, -2.21476942e-01f,
  -2.49770716e-01f, 2.02379152e-01f, -1.45118669e-01f, 1.22056521e-01f, 4.24816340e-01f, -2.32551262e-01f, 7.92638510e-02f, -1.42051652e-01f, -6.87820837e-02f, -3.16890985e-01f,
  1.36865139e-01f, -5.99829815e-02f, 4.39565957e-01f, 1.60134166e-01f, -2.03647822e-01f, 2.73196608e-01f, 8.81096348e-02f, -3.60099345e-01f, -2.93381304e-01f, 1.93814561e-02f,
  -3.67399246e-01f, 3.62974182e-02f, -2.54311711e-01f, -2.93772817e-01f, 2.60594875e-01f, 1.30597502e-01f, -5.32869220e-01f, -1.34134546e-01f, -3.73093665e-01f, -5.48119307e-01f,
  -4.17403072e-01f, -1.20206073e-01f, 1.21633094e-02f, -4.15097654e-01f, 3.09205681e-01f, 1.89844474e-01f, -3.72109115e-01f, -1.65801480e-01f, -8.75318944e-02f, -2.61951327e-01f,
  -4.98878323e-02f, -3.54322158e-02f, -5.98511755e-01f, -5.19433677e-01f, -4.34314698e-01f, 2.71483213e-01f, -3.94443609e-02f, -3.73345882e-01f, 2.19480917e-01f, 1.63182274e-01f,
  -3.64121437e-01f, 1.47084326e-01f, 2.64495701e-01f, -4.61284727e-01f, 1.42912194e-02f, 8.85124654e-02f, -4.34841029e-02f, 2.15077117e-01f, 4.00355179e-03f, 1.13436647e-01f,
  -9.09131244e-02f, -1.33910850e-01f, -4.28189076e-02f, -9.15762931e-02f, 3.91731650e-01f, 1.64589167e-01f, -3.56825262e-01f, -3.30761187e-02f, -1.79382265e-01f, -3.81675601e-01f,
  -4.96424511e-02f, -5.04996590e-02f, -2.00748682e-01f, -3.82434815e-01f, -5.39084710e-02f, -1.53633833e-01f, -1.57037713e-02f, -1.32997841e-01f, 4.29290295e-01f, -3.01886231e-01f,
  -2.41058320e-01f, 7.57736638e-02f, 9.04148966e-02f, 1.92298993e-01f, 3.64418775e-01f, -2.72390187e-01f, 6.26948178e-02f, -1.44057035e-01f, 4.08918336e-02f, -3.48797977e-01f,
  3.27927291e-01f, -3.70938659e-01f, 1.34365946e-01f, 2.90409029e-01f, 7.43032023e-02f, 1.50056958e-01f, -6.92318976e-02f, 2.98901975e-01f, -3.88263583e-01f, 1.80371374e-01f,
  -3.74580234e-01f, -1.98107585e-01f, 8.93203542e-03f, -2.15909213e-01f, -2.05131754e-01f, -2.15351269e-01f, -6.85248151e-02f, -1.91238105e-01f, -3.10849473e-02f, -1.51677519e-01f,
  6.85206801e-02f, 2.34828010e-01f, -2.53711820e-01f, -1.29332859e-03f, -2.97374725e-01f, -2.40529299e-01f, -1.46689400e-01f, -1.23584094e-02f, 1.82366282e-01f, 2.25710541e-01f,
  1.72785353e-02f, -2.49606505e-01f, 8.39615986e-03f, -2.85776049e-01f, -2.24400349e-02f, 5.16143665e-02f, 6.93598166e-02f, 2.44594172e-01f, 5.32877371e-02f, -1.03551455e-01f,
  -1.44566417e-01f, -1.12671077e-01f, 2.19409421e-01f, -2.76911468e-03f, -3.49496186e-01f, 4.14751977e-01f, -2.81394035e-01f, 3.03059787e-01f, 3.78883332e-01f, -2.25580007e-01f,
  2.63451170e-02f, -2.38698289e-01f, -1.60940126e-01f, -2.03532830e-01f, 1.96201071e-01f, 1.96352467e-01f, -4.59657349e-02f, -2.01843202e-01f, -1.67185411e-01f, -2.72093296e-01f,
  1.91752747e-01f, -2.27833167e-01f, -1.05131924e-01f, 1.46914840e-01f, 4.45809625e-02f, -2.91430414e-01f, 5.43753393e-02f, 1.62789807e-01f, -6.99939728e-02f, -7.39201605e-02f,
  3.81808311e-01f, 3.90992761e-02f, -4.78207380e-01f, -2.34809220e-01f, 1.82436362e-01f, -2.67196357e-01f, 2.24302411e-01f, 2.79998183e-01f, 1.73934668e-01f, -4.59403217e-01f,
  -2.45913029e-01f, -2.68592417e-01f, -1.57236755e-01f, -2.23029390e-01f, 1.01818971e-01f, -2.48376191e-01f, 6.00500368e-02f, -2.01263785e-01f, -3.70473385e-01f, -2.07379401e-01f,
  -1.93185210e-01f, 1.41969532e-01f, -1.16876408e-01f, -2.25878879e-01f, 4.91585769e-02f, 1.19670056e-01f, -5.53672127e-02f, 1.48268119e-01f, -2.63308108e-01f, -9.29868668e-02f,
  2.43622705e-01f, 2.19907805e-01f, 8.50298703e-02f, 2.74780005e-01f, 4.21628475e-01f, 1.58092961e-01f, -5.35160303e-01f, -2.46086702e-01f, 4.24771942e-02f, 2.48817325e-01f,
  -1.54176459e-01f, -3.06649864e-01f, -4.88408566e-01f, -2.71174192e-01f, -1.83274746e-01f, 1.34279385e-01f, -7.97892213e-02f, -3.28683108e-02f, -2.88124740e-01f, -9.40993354e-02f,
  -1.26336321e-01f, -1.11778542e-01f, 3.38246346e-01f, -6.78235292e-02f, -3.90551060e-01f, 2.03295290e-01f, 2.35000119e-01f, -2.66500264e-02f, 3.11230481e-01f, 3.88660491e-01f,
  -1.07064150e-01f, -4.41218942e-01f, 2.20597893e-01f, -1.77149534e-01f, 1.33464888e-01f, -2.88373560e-01f, -2.81937391e-01f, 1.97671428e-01f, -4.67370361e-01f, 2.69006401e-01f,
  8.49960893e-02f, -1.44897580e-01f, 7.95348140e-04f, -6.86299443e-01f, 3.31813902e-01f, -5.54755032e-01f, -1.62180021e-01f, 1.98309064e-01f, 1.94619134e-01f, 9.78577137e-02f,
  -6.51778281e-02f, 2.62778372e-01f, -3.28421503e-01f, 1.30078197e-01f, 1.06373534e-01f, 1.91677120e-02f, -1.26243338e-01f, -1.53953180e-01f, -1.72390312e-01f, 1.37842536e-01f,
  1.90385953e-01f, 3.48438360e-02f, -4.09497283e-02f, 5.23803681e-02f, -1.57433420e-01f, -3.20397951e-02f, -1.71888068e-01f, -1.39518648e-01f, -2.66177237e-01f, -1.88252598e-01f,
  -1.44398227e-01f, 8.45208243e-02f, 3.92975688e-01f, 3.90122026e-01f, -2.46724501e-01f, -1.17603391e-01f, -2.37359345e-01f, 2.77873427e-01f, -2.44399309e-02f, -2.32284948e-01f,
  7.98841938e-02f, 3.60928327e-01f, -4.68675531e-02f, -3.28571200e-01f, 1.80410728e-01f, -5.74331582e-02f, 2.76869625e-01f, -2.26694465e-01f, -2.25437239e-01f, -2.90017575e-01f,
  -7.62173906e-02f, -9.09894984e-03f, -2.85687238e-01f, -3.84948589e-02f, 4.11211103e-01f, 3.08448136e-01f, -2.94890821e-01f, -1.64382175e-01f, -1.92253530e-01f, -2.34651193e-01f,
  -2.66220152e-01f, -1.47640347e-01f, 3.36611897e-01f, 4.19630587e-01f, -2.66793519e-01f, -1.03356009e-02f, -1.39368817e-01f, -1.12895645e-01f, 6.61396757e-02f, -2.34932423e-01f,
  -1.77440733e-01f, -1.94171235e-01f, 2.98725903e-01f, -2.94899911e-01f, -2.18723044e-01f, -5.44466197e-01f, -2.52172828e-01f, 2.36340594e-02f, -3.34525526e-01f, 3.61185998e-01f,
  -1.60033479e-01f, -7.57751912e-02f, -2.63353884e-01f, -4.33698565e-01f, 1.94713667e-01f, -2.28059408e-03f, -1.07887819e-01f, 2.01431423e-01f, -2.42319793e-01f, 1.73524991e-01f,
  3.81835610e-01f, -2.64921546e-01f, 2.20143765e-01f, -3.63539606e-02f, 1.80661827e-01f, -2.28367653e-02f, -2.02830836e-01f, 2.78206557e-01f, 3.05867791e-01f, 1.67276129e-01f,
  2.19809100e-01f, -2.03201398e-01f, 1.44552305e-01f, 1.64955512e-01f, -4.45894599e-01f, 6.34747893e-02f, -3.22494715e-01f, 1.24250025e-01f, 1.68754905e-03f, 2.16423780e-01f,
  -1.12951517e-01f, 1.05118103e-01f, 6.48859665e-02f, 3.43921363e-01f, 1.85982630e-01f, -4.51659411e-01f, -2.38253042e-01f, -2.84364313e-01f, -2.57057786e-01f, -1.26770139e-02f,
  -2.34917194e-01f, -6.22100569e-02f, -3.48882109e-01f, 3.02833438e-01f, -3.93164009e-01f, 1.59248903e-01f, -3.61579835e-01f, -2.67929792e-01f, -1.23087727e-01f, -1.46112785e-01f,
  1.69383883e-01f, -1.92571178e-01f, -1.72186077e-01f, -3.29782575e-01f, -1.93702430e-01f, -1.31978691e-01f, -3.91564965e-01f, -2.62376200e-02f, 9.79835987e-02f, -2.15227336e-01f,
  -1.34409249e-01f, -2.01106519e-01f, 2.28486270e-01f, -2.89862957e-02f, 7.03858808e-02f, 7.01699480e-02f, 1.62549585e-01f, 2.05610737e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.60140440e-01f, 3.04351151e-02f, 3.12276967e-02f, 3.45985219e-02f, -6.70555681e-02f, 1.17333718e-01f, -2.24871002e-02f, 5.35820909e-02f, 3.29672024e-02f, 1.36123821e-01f,
  4.81088348e-02f, -8.08717508e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    