/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.54244357e-01f, 1.13088794e-01f, -2.54714370e-01f, 3.35466295e-01f, -1.36692077e-01f, -2.41628721e-01f, -1.21040255e-01f, 1.62181333e-02f, 3.52339327e-01f, 1.30803272e-01f,
  9.27991569e-02f, -4.89207804e-02f, 5.81341013e-02f, 8.33336636e-02f, 1.62265867e-01f, 2.79883474e-01f, 2.16953248e-01f, 9.26046446e-02f, 1.17947549e-01f, 5.63485697e-02f,
  7.24596381e-02f, -1.22656478e-02f, -1.74134001e-01f, -1.43737376e-01f, -1.35079861e-01f, -9.94542241e-02f, 1.24075040e-01f, -1.63678020e-01f, -1.36972725e-01f, -1.62600160e-01f,
  6.03903420e-02f, 5.46436943e-03f, -4.98341061e-02f, -9.74867716e-02f, 5.40963039e-02f, -3.41163315e-02f, 5.14400825e-02f, -1.08229525e-01f, -1.35312416e-02f, -2.42999122e-02f,
  2.23453101e-02f, -3.67612727e-02f, -4.25796472e-02f, 6.80232048e-02f, 3.97852845e-02f, -4.99668010e-02f, -7.58797303e-02f, 5.99124916e-02f, -1.61187634e-01f, -5.53561114e-02f,
  7.71307293e-03f, -1.53009355e-01f, 2.13822629e-02f, 4.33665104e-02f, -4.07877527e-02f, -5.91829307e-02f, -1.13410175e-01f, -1.20466217e-01f, 7.55046979e-02f, -1.55202104e-02f,
  1.09084524e-01f, 3.58703882e-02f, -1.74888998e-01f, -3.66507508e-02f, 2.71744225e-02f, -1.79083541e-01f, 8.82330444e-03f, -5.37103303e-02f, -1.09638743e-01f, 3.74797806e-02f,
  -4.12760563e-02f, 1.04992211e-01f, -7.65102729e-02f, -1.87662372e-04f, 1.91772229e-03f, 1.64445899e-02f, -3.03925499e-02f, -7.75869712e-02f, 5.77433147e-02f, 1.20160626e-02f,
  -3.30430381e-02f, 7.68961385e-02f, -1.04575492e-01f, 1.64802298e-02f, -2.20354311e-02f, 4.08278368e-02f, -1.26207963e-01f, 2.78525092e-02f, -8.03606235e-04f, 1.43687101e-03f,
  1.80681005e-01f, 1.76184550e-01f, 1.01436605e-03f, -8.35999399e-02f, 3.72607913e-03f, 5.76235950e-02f, -3.03358510e-02f, 3.89476679e-02f, 1.19564034e-01f, 6.24942034e-02f,
  -1.67950597e-02f, -6.56315163e-02f, 1.17460608e-01f, -8.02559629e-02f, -3.73177454e-02f, 6.32552579e-02f, -1.95592176e-02f, 3.57191637e-02f, 3.46254967e-02f, -4.24879044e-02f,
  6.85480759e-02f, 2.68838909e-02f, -5.36991768e-02f, -1.58377979e-02f, 4.78083007e-02f, -4.84676026e-02f, 9.99722928e-02f, -2.07157079e-02f, 2.13349145e-03f, -1.55992536e-02f,
  -4.15940106e-01f, 3.94764513e-01f, -2.73400813e-01f, -4.87024076e-02f, -8.31731632e-02f, 5.43217301e-01f, -7.18308613e-02f, 8.70959237e-02f, 3.44559997e-02f, 2.92124748e-01f,
  -8.73200297e-02f, -2.12512434e-01f, -2.50101238e-01f, 3.48137617e-01f, 1.86887473e-01f, 1.66715622e-01f, 3.40838343e-01f, 5.87683246e-02f, -6.23674889e-04f, 5.62026445e-03f,
  7.54935369e-02f, 4.51346040e-01f, -5.91592677e-02f, 2.63665080e-01f, -1.27518892e-01f, -1.03796214e-01f, -1.67399668e-03f, -2.17400819e-01f, 2.37529993e-01f, 6.93990961e-02f,
  -3.87134962e-02f, -2.52490014e-01f, -1.85351327e-01f, -3.71469408e-02f, 1.75703205e-02f, -4.17461097e-02f, -1.30782604e-01f, -1.04301371e-01f, -5.89990839e-02f, 1.38181951e-02f,
  -7.75461271e-02f, 6.13607913e-02f, 6.12535141e-02f, 2.58702692e-02f, -8.95564482e-02f, -4.09524143e-02f, 8.61910451e-03f, -4.50244173e-02f, -2.59990226e-02f, -9.77829248e-02f,
  -3.07426937e-02f, -5.90672642e-02f, -1.31392986e-01f, -2.75505483e-02f, -7.12788031e-02f, 7.64440596e-02f, 2.50700507e-02f, -2.26744059e-02f, 1.25917643e-02f, 6.95938170e-02f,
  -3.15549299e-02f, -6.33912981e-02f, -6.01242408e-02f, -7.31765777e-02f, -2.35041771e-02f, -7.92241693e-02f, -7.53938928e-02f, -3.33253294e-02f, -9.95784402e-02f, 3.29892971e-02f,
  7.85013661e-02f, -4.59147654e-02f, 3.45651992e-02f, 2.66423505e-02f, 4.64125816e-03f, -2.63474360e-02f, -5.33904657e-02f, 7.85487294e-02f, -5.67862801e-02f, 2.59277923e-03f,
  -3.67203541e-02f, 4.71489280e-02f, -4.66155075e-02f, -3.20325233e-02f, 4.11466658e-02f, -1.43796364e-02f, 3.83557775e-03f, -7.96253681e-02f, -7.20539391e-02f, -3.82346148e-03f,
  3.11258048e-01f, 2.74837285e-01f, 8.97814855e-02f, 2.90371496e-02f, 9.16304737e-02f, 4.15094085e-02f, 5.13958745e-02f, 1.18759811e-01f, 4.31721844e-02f, 9.21353772e-02f,
  3.20748128e-02f, 3.48874293e-02f, 6.20340742e-02f, 7.84804113e-03f, 9.22893882e-02f, 4.45603505e-02f, 1.63979940e-02f, 7.73742124e-02f, 2.70798965e-03f, 9.24248248e-02f,
  -3.18829119e-02f, 5.62134082e-04f, -2.28297580e-02f, 2.16369200e-02f, 8.75580609e-02f, -7.32315257e-02f, 1.97741352e-02f, -7.35803321e-03f, -2.69929171e-02f, 7.95650631e-02f,
  9.63114481e-03f, -3.19821119e-01f, 2.21399069e-01f, 3.58589850e-02f, 7.77828619e-02f, 2.93270200e-01f, -6.34549484e-02f, -2.69493535e-02f, -8.11878815e-02f, -2.61495978e-01f,
  -1.32480785e-01f, 8.18913355e-02f, -2.52455533e-01f, 1.87851969e-04f, 2.57792383e-01f, -9.71531942e-02f, -1.75518200e-01f, -7.26803243e-02f, 1.34422332e-02f, -2.49954492e-01f,
  8.31474960e-02f, -2.73577303e-01f, 2.24653572e-01f, -2.23621145e-01f, 1.15012005e-01f, 5.38095795e-02f, -2.35455096e-01f, -1.71540566e-02f, -2.38363445e-02f, 6.83263540e-02f,
  1.24495171e-01f, -1.38876662e-01f, 1.40330225e-01f, 6.14545420e-02f, 6.78629335e-03f, 6.71861414e-03f, 1.13521546e-01f, -1.57149939e-03f, 7.26712719e-02f, 3.22370902e-02f,
  9.45108458e-02f, 7.04874247e-02f, -9.75384936e-03f, -3.49659286e-02f, 1.09800354e-01f, 1.10240959e-01f, 8.54192451e-02f, 1.41522229e-01f, 8.68835896e-02f, 9.95038748e-02f,
  8.34932327e-02f, 1.65342629e-01f, 9.16601717e-02f, -1.51466308e-02f, 2.27221195e-02f, 5.15384115e-02f, 2.82742120e-02f, 1.55526564e-01f, 5.71350986e-03f, 1.24462768e-01f,
  -3.36190872e-03f, -4.91838939e-02f, -1.15538076e-01f, 1.07222898e-02f, -1.29085287e-01f, -3.23818810e-02f, -8.98814425e-02f, 4.09662770e-03f, 2.61295047e-02f, -3.76712494e-02f,
  -4.01284965e-03f, 2.57914886e-02f, -4.47322149e-03f, 4.65799030e-03f, 2.04079933e-02f, 4.87453938e-02f, 6.60300553e-02f, -3.41993831e-02f, -8.63611791e-03f, 6.48714527e-02f,
  1.54994642e-02f, 4.33486849e-02f, -4.45472151e-02f, 3.75301577e-02f, -3.85019593e-02f, 7.73930177e-02f, 1.34126535e-02f, 8.14937726e-02f, -4.28019166e-02f, -6.13602288e-02f,
  -1.99240088e-01f, -4.62887198e-01f, -1.03535645e-01f, 7.17002973e-02f, -6.00077771e-02f, 2.12947670e-02f, -5.67390397e-02f, 6.66032359e-02f, -8.88412297e-02f, -1.03903793e-01f,
  2.18757614e-02f, -1.19157298e-03f, -1.11831583e-01f, 1.49927344e-02f, 4.59048338e-02f, -7.81773999e-02f, -9.04105529e-02f, 3.78777906e-02f, -6.13646433e-02f, -5.11032492e-02f,
  -6.41049072e-02f, -4.24780697e-02f, 1.29327103e-02f, -2.53697410e-02f, 7.66396290e-03f, 6.72672759e-04f, 1.61981722e-03f, -2.82633677e-02f, 1.55655667e-02f, -1.14580113e-02f,
  -6.99461028e-02f, 2.70918399e-01f, 2.93906629e-01f, -3.58372808e-01f, 3.81890275e-02f, 1.69059455e-01f, 1.22173980e-01f, -5.77511229e-02f, 9.11136251e-03f, -2.35939875e-01f,
  -4.24209297e-01f, 3.20958704e-01f, 2.19236076e-01f, -4.06901777e-01f, 1.42179513e-02f, 8.55651647e-02f, -1.56037405e-01f, -2.12013535e-02f, 2.59492666e-01f, -2.26206571e-01f,
  -1.89693898e-01f, -3.26887250e-01f, -1.11384906e-01f, -9.53485966e-02f, -7.41987675e-02f, 1.19407520e-01f, -1.57293022e-01f, 2.93108910e-01f, -2.40602359e-01f, 4.82863560e-02f,
  -8.59669149e-02f, -7.60752857e-02f, 2.20186431e-02f, 5.35496585e-02f, -1.14369988e-01f, 7.12515637e-02f, -8.75065196e-03f, 7.97941908e-02f, 1.37699530e-01f, 3.66054326e-02f,
  -3.47986771e-03f, -9.52043980e-02f, -5.90660833e-02f, 7.00455830e-02f, 1.35759101e-03f, 5.09220874e-03f, -3.38969901e-02f, -7.74852186e-03f, -1.35508934e-02f, 4.73606400e-02f,
  -2.24730801e-02f, -1.12406492e-01f, -9.65191647e-02f, -6.28968105e-02f, 6.82843402e-02f, 9.02841091e-02f, 3.85134369e-02f, 2.16211211e-02f, -6.99249581e-02f, 8.89596418e-02f,
  -6.46653771e-02f, 5.86697981e-02f, -2.59612519e-02f, -4.60469462e-02f, -1.80967781e-03f, -1.50107175e-01f, 1.25764776e-02f, -1.11600690e-01f, 6.01880327e-02f, -7.02696666e-02f,
  -1.11149102e-01f, 3.33081372e-02f, -9.83573794e-02f, 6.39346763e-02f, -1.62127495e-01f, -2.57166363e-02f, -5.47443749e-04f, -4.32171747e-02f, -4.31819558e-02f, -4.56955470e-02f,
  -5.71077596e-03f, 2.97563570e-03f, 6.55763689e-03f, 1.38587579e-02f, 3.38027887e-02f, 2.64560543e-02f, -2.89960876e-02f, 3.72729972e-02f, 6.67282790e-02f, -1.57137611e-03f,
  -6.37046173e-02f, -1.20287664e-01f, 3.19956206e-02f, -2.34630182e-02f, 8.03697258e-02f, -6.34783432e-02f, 2.74610538e-02f, 3.32524478e-02f, 4.82284315e-02f, -2.42184214e-02f,
  -8.96437988e-02f, -3.13604553e-03f, -1.04334336e-02f, -9.37365443e-02f, -6.79180492e-03f, 6.90643564e-02f, 3.37846689e-02f, -5.84177449e-02f, -7.04182312e-02f, 1.46267535e-02f,
  -1.18028969e-01f, -4.88862023e-03f, -5.37216738e-02f, -8.57267603e-02f, -7.91074485e-02f, -4.37655039e-02f, 2.74314801e-03f, 6.37506098e-02f, -3.74895856e-02f, 4.52971756e-02f,
  -1.94841489e-01f, 2.10739151e-01f, -4.18423973e-02f, -1.78998142e-01f, -2.34571725e-01f, -2.24209845e-01f, 5.12682609e-02f, -2.40845442e-01f, 1.75454877e-02f, 2.80928314e-01f,
  -8.08455944e-02f, 2.75828063e-01f, 1.58783168e-01f, 1.02937393e-01f, -3.47097099e-01f, 1.35289416e-01f, -2.02840373e-01f, 9.13321972e-02f, -5.85060939e-02f, -2.58541703e-01f,
  -2.05740124e-01f, -1.39749706e-01f, -2.04416066e-01f, -1.30853921e-01f, 1.38392048e-02f, 7.99296796e-02f, 2.25215424e-02f, 1.09597147e-01f, 5.40658236e-02f, 8.19557086e-02f,
  -8.64909366e-02f, -8.70668143e-02f, 6.60491809e-02f, -4.25059423e-02f, -1.37021601e-01f, 8.69473964e-02f, 7.20401630e-02f, 9.21034962e-02f, 4.88485098e-02f, -1.05520658e-01f,
  9.02167857e-02f, -1.33009180e-01f, 1.32240236e-01f, 3.06020286e-02f, -5.67664914e-02f, 9.50969383e-02f, 3.55790295e-02f, -2.48274906e-03f, 7.41123483e-02f, -6.99279979e-02f,
  -3.48073505e-02f, -1.70064569e-02f, -3.73093560e-02f, 5.15976064e-02f, -1.02394342e-01f, 1.08416686e-02f, -2.32462939e-02f, 3.14863883e-02f, -1.23189986e-01f, 6.78094896e-03f,
  -1.53880604e-02f, 2.01203842e-02f, 2.09564492e-02f, -3.81843038e-02f, 1.49168177e-02f, -3.52810770e-02f, 2.57496517e-02f, 9.89931077e-02f, 1.52636245e-01f, -3.84103060e-02f,
  -1.59082711e-01f, 4.61506881e-02f, -1.84168164e-02f, -5.05600423e-02f, 3.39701995e-02f, 7.68212825e-02f, 1.01700630e-02f, 4.58419994e-02f, -1.02983952e-01f, -4.56435941e-02f,
  3.49734165e-02f, -1.26357868e-01f, 6.55348822e-02f, 3.51149216e-03f, 1.33683132e-02f, 3.12616453e-02f, 6.29653037e-02f, -3.94346900e-02f, 3.46609298e-03f, 1.90543365e-02f,
  -1.77701697e-01f, -1.03861362e-01f, 8.14253241e-02f, 2.71838754e-02f, 1.19040385e-01f, -2.86833886e-02f, 8.52695554e-02f, -7.44262785e-02f, -3.71410139e-02f, -2.09781721e-01f,
  -1.50707709e-02f, 4.35612537e-02f, -1.59659594e-01f, -1.45431776e-02f, 5.14808111e-02f, -5.86159155e-02f, -1.26115739e-01f, 4.46790792e-02f, -1.58917382e-01f, 5.51084196e-03f,
  -3.82666895e-03f, 4.36859801e-02f, 5.06123416e-02f, -3.63589227e-02f, 1.03390934e-02f, 3.97133194e-02f, 1.56860352e-02f, 2.73761544e-02f, -1.12127448e-02f, 4.56578434e-02f,
  1.97926745e-01f, 8.89889598e-02f, -1.93971500e-01f, -1.81659564e-01f, -2.25579232e-01f, -1.84641272e-01f, -2.31192708e-02f, -9.20181796e-02f, -2.11458802e-01f, 1.94595218e-01f,
  7.20707402e-02f, 2.33057797e-01f, 1.50652006e-01f, -1.77891821e-01f, 2.63333082e-01f, 1.18094273e-01f, -1.48934916e-01f, -3.73642482e-02f, -1.78665817e-01f, 1.04151107e-01f,
  -1.37660310e-01f, 1.16488613e-01f, -8.42367858e-02f, -1.70121789e-01f, -1.96040273e-02f, -2.22659364e-01f, 3.04820418e-01f, -2.07824260e-01f, 3.28282528e-02f, -2.32437644e-02f,
  -3.17043327e-02f, -2.30766479e-02f, -8.02202299e-02f, 3.81338820e-02f, -7.99169019e-03f, -1.06394589e-01f, 1.45295449e-02f, -3.38558145e-02f, -1.06405534e-01f, 4.21293117e-02f,
  1.13877513e-01f, 8.01580325e-02f, -1.31800445e-02f, 1.74479783e-02f, -8.35586786e-02f, -6.35371506e-02f, -5.10637164e-02f, -5.29986769e-02f, 4.17762157e-03f, 3.83764901e-03f,
  -4.89078052e-02f, -1.55560235e-02f, -3.52653749e-02f, 7.32778236e-02f, 7.25627840e-02f, -1.59280762e-01f, -5.56659736e-02f, 8.86659771e-02f, 1.02784641e-01f, -6.61143214e-02f,
  -1.18646681e-01f, -4.22525443e-02f, -3.49804647e-02f, 1.99577939e-02f, 4.39146459e-02f, -2.01087655e-03f, -1.20668672e-03f, 9.26864818e-02f, 2.65862755e-02f, 1.16739921e-01f,
  -1.83853041e-02f, -3.28634195e-02f, -2.27507949e-02f, -1.13582157e-01f, -2.34576184e-02f, -2.79127974e-02f, -1.05805788e-02f, 2.64232606e-02f, -2.01018378e-02f, -6.44389316e-02f,
  3.31407785e-03f, -8.76426976e-03f, 1.32930011e-01f, 1.93619803e-02f, 1.68686062e-02f, 9.01698098e-02f, 4.12100293e-02f, 8.24488350e-04f, -6.72664642e-02f, -5.62569965e-03f,
  3.07936579e-01f, 1.69305712e-01f, -3.82681973e-02f, 9.68973190e-02f, -7.72396401e-02f, 8.78758281e-02f, -8.33606124e-02f, -1.98278502e-02f, -1.98092237e-02f, 1.37192360e-03f,
  -3.63016464e-02f, 2.96067931e-02f, 4.23210338e-02f, -5.68739809e-02f, 8.30368027e-02f, 3.90747190e-02f, 5.96705303e-02f, 4.01842371e-02f, 6.27724305e-02f, 8.48118290e-02f,
  8.82506296e-02f, -7.60178501e-03f, -1.89769687e-03f, 5.11173345e-02f, 9.35829356e-02f, 3.42476666e-02f, 7.12709948e-02f, -1.66002989e-01f, 5.44691123e-02f, -6.32106960e-02f,
  3.70802492e-01f, -4.72922735e-02f, 3.44106928e-02f, 3.77591908e-01f, 2.51807541e-01f, -2.77536273e-01f, -2.04717308e-01f, 2.93934673e-01f, 1.74216300e-01f, -1.81009918e-01f,
  8.47838894e-02f, 4.85045202e-02f, -4.50320661e-01f, 2.16060966e-01f, 4.15171683e-02f, -4.52398270e-01f, 1.32950410e-01f, -2.05730908e-02f, 1.86885502e-02f, 9.71835554e-02f,
  2.28122756e-01f, 1.68448314e-01f, 1.46500409e-01f, -2.88481042e-02f, 3.00556064e-01f, 2.88839918e-02f, 9.18484926e-02f, -6.94791973e-02f, 1.78882554e-01f, -5.53621016e-02f,
  1.25030637e-01f, 1.35357410e-01f, 3.83934043e-02f, -1.63820963e-02f, 7.89064318e-02f, -6.02195710e-02f, -1.91409867e-02f, -5.30761704e-02f, 3.88450455e-03f, 1.02039035e-02f,
  -8.25869367e-02f, 1.30986467e-01f, -4.35904926e-03f, -8.10726285e-02f, 1.01589613e-01f, 1.02774449e-01f, 7.36127794e-02f, 8.59537348e-02f, 8.58220384e-02f, 8.68268088e-02f,
  -3.97927314e-02f, 4.32512909e-02f, 1.55392244e-01f, -5.28723150e-02f, 8.61542299e-02f, -2.20694859e-02f, -4.65531349e-02f, 5.95464138e-03f, 3.35305743e-02f, 1.26483709e-01f,
  -6.14304878e-02f, -1.10967420e-01f, -2.44861506e-02f, 4.16445881e-02f, -7.61290714e-02f, -1.42781325e-02f, -1.32139221e-01f, 7.45437369e-02f, -1.97631679e-02f, 2.61551409e-04f,
  6.99176416e-02f, 3.62959281e-02f, 2.62214076e-02f, -7.30393678e-02f, 9.70705412e-03f, -4.84376960e-02f, -5.10044433e-02f, -3.99657711e-03f, 4.42820527e-02f, 6.28411099e-02f,
  -9.28095169e-03f, 4.44747843e-02f, 3.84755023e-02f, -4.06944612e-03f, -5.51779009e-02f, 7.98952300e-03f, 4.10472639e-02f, -4.99857143e-02f, -5.84011562e-02f, -1.09120375e-02f,
  1.02281801e-01f, -3.96268768e-03f, -6.99705929e-02f, 3.76077518e-02f, -1.32181764e-01f, 3.02304495e-02f, -6.59500202e-03f, -7.95962736e-02f, -2.91565806e-03f, -3.67350765e-02f,
  5.51077425e-02f, 7.03165168e-03f, 1.48260474e-01f, -2.27695401e-03f, -6.80954801e-03f, -4.26072143e-02f, -1.01071954e-01f, 2.38050483e-02f, 1.28280237e-01f, 6.39751628e-02f,
  4.77470234e-02f, -2.06615180e-02f, -3.08224186e-02f, 1.07557118e-01f, -3.31891887e-02f, 8.92804563e-02f, -3.71308364e-02f, -9.53817833e-03f, 3.24382633e-03f, -3.10286097e-02f,
  6.33156478e-01f, -2.88619488e-01f, 1.17088459e-01f, 1.10015012e-01f, 1.83541507e-01f, -5.47309101e-01f, -1.25085130e-01f, 1.55117707e-02f, 1.49980932e-01f, -2.50062644e-01f,
  5.18855788e-02f, 1.14224419e-01f, -3.43035311e-02f, -3.73266786e-01f, -3.37376654e-01f, -2.83395380e-01f, -2.43120790e-01f, -9.07659531e-02f, 3.61415632e-02f, 1.21119648e-01f,
  -4.60293964e-02f, -1.96428046e-01f, -2.19393477e-01f, -8.59552249e-02f, 7.93148428e-02f, 2.17324629e-01f, -8.07167441e-02f, 1.41675159e-01f, -1.75132096e-01f, -1.11488979e-02f,
  2.13754866e-02f, 2.44125932e-01f, 4.20864895e-02f, 1.57402144e-04f, -2.06823833e-03f, 6.20153137e-02f, 8.75654519e-02f, 4.81919944e-02f, 7.20647350e-02f, 1.05195250e-02f,
  8.19180459e-02f, 2.45256554e-02f, -9.38537344e-02f, -7.16653615e-02f, 1.60451889e-01f, 9.08571631e-02f, -3.18392180e-02f, 5.53519689e-02f, 1.45255262e-02f, 8.68710410e-03f,
  4.12378497e-02f, -5.91700850e-03f, 1.00041218e-01f, -5.59896901e-02f, 6.82757720e-02f, 4.37981635e-02f, -1.08927362e-01f, 5.57946861e-02f, -1.92133337e-02f, -9.13347211e-03f,
  7.25504234e-02f, -2.75203474e-02f, 1.96083989e-02f, -1.60374139e-02f, -5.69484308e-02f, 6.95792735e-02f, -3.59288827e-02f, -6.22116700e-02f, 6.91209733e-02f, -3.43860239e-02f,
  2.20771637e-02f, 1.29807089e-02f, 1.67550109e-02f, 1.78003479e-02f, 4.52476293e-02f, -1.42504917e-02f, 6.99140728e-02f, 2.70400345e-02f, 9.66120735e-02f, 2.86484882e-03f,
  -3.17458138e-02f, -1.87893603e-02f, 3.66731584e-02f, -3.05992030e-02f, -1.05394825e-01f, -1.51553797e-02f, 1.43658863e-02f, 6.32074028e-02f, 4.93621193e-02f, -6.51405677e-02f,
  -2.16418818e-01f, -4.07599568e-01f, 1.58414841e-02f, -7.14522600e-02f, -1.01184607e-01f, 3.07775587e-02f, -7.99296126e-02f, -1.20257944e-01f, 1.84615387e-03f, 7.92283379e-03f,
  -2.05512140e-02f, -1.86806656e-02f, 6.87680840e-02f, 5.94783947e-02f, -1.44929603e-01f, -5.91799654e-02f, -4.90462221e-03f, -2.73617310e-03f, -4.77081388e-02f, -3.41913151e-03f,
  4.37383987e-02f, 2.22827327e-02f, -4.96681705e-02f, 1.87899247e-02f, -4.77266461e-02f, 4.67540585e-02f, 1.13250725e-01f, -1.09853111e-02f, -5.29928170e-02f, -3.49935815e-02f,
  3.58170241e-01f, -4.20180082e-01f, 1.56550869e-01f, 1.80147663e-02f, 6.73940703e-02f, 1.46514371e-01f, 1.82527587e-01f, -2.69531906e-01f, 9.76299495e-03f, -3.94018829e-01f,
  -2.35454097e-01f, -1.51747361e-01f, -1.50053263e-01f, -4.30980444e-01f, 3.73124272e-01f, -2.89348006e-01f, -8.26212242e-02f, -1.36499137e-01f, -6.17205724e-02f, -8.71926546e-02f,
  5.86999580e-02f, -3.79047424e-01f, -1.21063786e-02f, -2.11193055e-01f, -3.57972495e-02f, 1.17042474e-01f, -6.60884008e-02f, 6.76494977e-03f, -1.38519287e-01f, -1.19877970e-02f,
  -3.77009017e-03f, -4.79463711e-02f, 6.86959326e-02f, 3.30113322e-02f, 9.74435955e-02f, 5.12039363e-02f, 6.69207573e-02f, 1.11538999e-01f, 8.53737593e-02f, -1.28911855e-02f,
  2.85016093e-02f, -5.79079799e-02f, -8.02225843e-02f, -1.04440385e-02f, -4.19245027e-02f, 3.44386138e-02f, 1.88053604e-02f, 6.24127761e-02f, -9.12924930e-02f, 4.40944545e-02f,
  5.13044745e-03f, -7.56883621e-03f, 1.04752705e-01f, -4.76087667e-02f, 7.70865828e-02f, -1.75812449e-02f, 1.82105638e-02f, 9.63715240e-02f, -4.46937568e-02f, -4.43565054e-03f,
  -3.18394937e-02f, 4.34657335e-02f, -2.83831693e-02f, -2.25305296e-02f, -4.24248576e-02f, -2.10338701e-02f, -6.29999489e-02f, -2.34119259e-02f, 1.02302290e-01f, -3.72883491e-02f,
  1.69138480e-02f, -1.64468065e-02f, -6.79229274e-02f, -4.87682642e-03f, -1.27052087e-02f, -4.45844466e-03f, 4.50828373e-02f, -5.13230935e-02f, 1.92248635e-02f, 2.94617936e-02f,
  -3.28015089e-02f, 1.90993231e-02f, -5.70934415e-02f, 3.89654823e-02f, -4.61796001e-02f, 1.92925725e-02f, -3.66703756e-02f, -4.41958159e-02f, -3.05695124e-02f, 4.11194824e-02f,
  -1.49392575e-01f, -2.51338124e-01f, -5.58338091e-02f, -4.98981252e-02f, -3.99666913e-02f, -2.15978306e-02f, 2.92773955e-02f, -1.18008684e-02f, -4.58237678e-02f, -6.79562613e-02f,
  5.54828979e-02f, -1.74417961e-02f, 7.39745647e-02f, 2.54545230e-02f, 9.81989596e-03f, 5.78378653e-03f, -3.70572917e-02f, 3.50378603e-02f, 3.62099111e-02f, -9.80857462e-02f,
  2.68556853e-03f, 3.07997931e-02f, -3.03266142e-02f, 1.83278043e-02f, -2.92735379e-02f, 1.53685911e-02f, 3.63957398e-02f, -4.07102928e-02f, -1.81965224e-04f, -3.08913533e-02f,
  -1.15594799e-02f, -1.43564612e-01f, -1.75868481e-01f, 4.25701082e-01f, 3.17768976e-02f, 2.53823072e-01f, 3.93319845e-01f, -3.84439118e-02f, 1.94699720e-01f, 1.05353750e-01f,
  3.36289912e-01f, 1.88579485e-01f, 4.12953384e-02f, 4.48768735e-01f, 4.10248548e-01f, 3.12143564e-02f, 4.28953499e-01f, 2.62512445e-01f, -5.22652715e-02f, 8.86383727e-02f,
  6.02345429e-02f, 3.09845358e-01f, -3.34323547e-03f, -1.98666543e-01f, -1.10285707e-01f, -2.33459115e-01f, 3.10442094e-02f, -2.02064469e-01f, 9.11894441e-02f, 5.81713300e-03f,
  2.90651284e-02f, 5.47741633e-03f, 3.86318006e-02f, -4.65103686e-02f, 4.93074805e-02f, -7.26556182e-02f, -6.39717560e-03f, 3.25768925e-02f, -6.48620538e-03f, -3.38723511e-02f,
  1.19110886e-02f, -2.42949463e-02f, 2.46497560e-02f, -3.30595649e-03f, -1.00096883e-02f, -1.34169608e-01f, -7.12746307e-02f, -1.42499348e-02f, -1.47770448e-02f, -1.46320825e-02f,
  2.21001469e-02f, -7.57087916e-02f, 7.37008974e-02f, -5.13940258e-03f, -3.51343416e-02f, 1.23053305e-01f, -1.07830456e-02f, 2.11111805e-03f, -4.47600596e-02f, -6.84228726e-03f,
  -7.51824453e-02f, 1.35640090e-04f, -1.33799538e-02f, -6.36035427e-02f, 8.94699991e-02f, -6.19841032e-02f, 4.00102064e-02f, 2.70941630e-02f, -6.90030456e-02f, 3.50136720e-02f,
  5.33091277e-02f, 2.58144345e-02f, -6.69361977e-03f, 4.02595550e-02f, 6.16680682e-02f, -6.47257315e-03f, -8.74967687e-03f, 1.62473153e-02f, 1.18291592e-02f, 2.65638251e-02f,
  3.12209837e-02f, 3.38642299e-02f, 3.01733650e-02f, -4.60016988e-02f, 9.99319479e-02f, -1.78149156e-02f, 4.89149569e-03f, -4.99041714e-02f, 5.65158715e-03f, 2.22477503e-02f,
  2.84457002e-02f, 1.33023471e-01f, 4.77688983e-02f, 1.14029599e-03f, 3.44716050e-02f, 2.54500546e-02f, 4.77162600e-02f, 7.41887651e-03f, -7.98423812e-02f, -3.19000557e-02f,
  1.15659703e-02f, 6.57159276e-03f, -6.65598437e-02f, -6.42627180e-02f, 1.65674593e-02f, 8.91595110e-02f, 4.83483002e-02f, 7.04752002e-03f, 9.87276435e-02f, 2.14663185e-02f,
  -2.15231199e-02f, 1.38524929e-02f, -2.93161403e-02f, -1.30728062e-03f, 2.70089507e-02f, -4.73317727e-02f, 7.01157749e-02f, -1.01794414e-01f, -1.39326472e-02f, 6.63594976e-02f,
  -1.89180806e-01f, 1.24718929e-02f, 1.44388571e-01f, -3.91435400e-02f, 2.05507572e-03f, 6.58555850e-02f, 1.91893458e-01f, -9.49094221e-02f, 4.83614905e-03f, 4.92023528e-02f,
  3.16015966e-02f, -3.29319417e-01f, 2.64881909e-01f, 2.47154664e-02f, -1.60590529e-01f, 2.73222327e-01f, -1.02709625e-02f, -3.49956676e-02f, -1.06899254e-02f, -2.05620244e-01f,
  -7.97061808e-03f, -2.37155363e-01f, 2.33041182e-01f, -2.51431137e-01f, -9.45360363e-02f, -1.45535320e-01f, -2.57518649e-01f, 5.44330198e-03f, -2.13276759e-01f, -1.37138203e-01f,
  1.63596869e-02f, 1.85098257e-02f, 7.64732659e-02f, 2.88071688e-02f, -8.13335255e-02f, -2.11636387e-02f, 1.53608741e-02f, 3.76302898e-02f, -3.08617391e-02f, 3.02179847e-02f,
  3.23969722e-02f, -2.86792908e-02f, -2.29392722e-02f, -1.57829752e-04f, 9.15850699e-03f, -2.83116382e-02f, 1.26446411e-01f, 9.68876947e-03f, -1.40655674e-02f, 2.54273266e-02f,
  2.02786103e-02f, 2.97006331e-02f, -1.62827726e-02f, 1.48939062e-02f, -2.20312960e-02f, 2.72413976e-02f, -4.86120628e-03f, 1.75811965e-02f, -6.08228520e-02f, -6.32999763e-02f,
  4.22847979e-02f, -5.64462580e-02f, -5.73162735e-03f, -5.67539074e-02f, -1.09107189e-01f, -8.01785514e-02f, 6.51314994e-03f, -3.40524241e-02f, -5.38857132e-02f, 1.80740338e-02f,
  -5.67591339e-02f, -6.24924749e-02f, 3.77368368e-02f, 2.20627245e-02f, -9.36556086e-02f, -2.33480483e-02f, 6.11265562e-02f, -6.34493977e-02f, 7.56864175e-02f, 5.83058558e-02f,
  5.54640852e-02f, -2.23325454e-02f, 1.31302234e-03f, 6.39300868e-02f, 2.40248218e-02f, 5.00140004e-02f, -7.15933368e-02f, -4.37995745e-03f, 1.09246440e-01f, 2.82938057e-03f,
  -2.77100861e-01f, -4.04797465e-01f, 4.75960486e-02f, -1.24453165e-01f, -6.47312254e-02f, -5.51638333e-03f, -5.77725731e-02f, 9.51081738e-02f, -2.96278670e-02f, -7.12425932e-02f,
  2.98315566e-02f, 1.44228730e-02f, -4.63026837e-02f, -5.65438680e-02f, -6.18841033e-03f, -8.72056708e-02f, -1.17469812e-02f, -6.85502738e-02f, -1.35830492e-01f, -6.67800903e-02f,
  -8.23772177e-02f, -7.66148716e-02f, -6.36614161e-03f, 4.09524180e-02f, -5.39306179e-03f, 1.15713542e-02f, -1.46704867e-01f, -4.18733992e-03f, -4.38105874e-03f, 2.06426921e-04f,
  2.49272108e-01f, -8.98396522e-02f, -3.12155783e-01f, -1.11533115e-02f, 3.48759681e-01f, 1.22564882e-01f, -2.38628671e-01f, 1.49362057e-01f, -4.77036536e-02f, 2.86288317e-02f,
  3.32619250e-01f, -3.05425584e-01f, -1.43120304e-01f, 2.23995179e-01f, 1.97626263e-01f, -9.57898796e-02f, 6.53902069e-02f, -5.83786964e-02f, -1.00198954e-01f, 1.89777333e-02f,
  1.12325028e-01f, 3.06181908e-01f, -8.15760717e-02f, 8.38548094e-02f, 1.86721057e-01f, -1.92778856e-01f, 1.94235787e-01f, -3.12877953e-01f, 5.93787767e-02f, 7.48442411e-02f,
  1.72573179e-01f, 1.07284784e-02f, -2.10258923e-02f, -1.07171208e-01f, 9.90395918e-02f, -1.88302761e-03f, -1.18024059e-01f, -1.38604119e-01f, -6.60933852e-02f, -1.13427036e-01f,
  -8.71340707e-02f, 6.45247027e-02f, 2.12949608e-02f, -1.03227861e-01f, 6.31404221e-02f, -7.14187846e-02f, -2.15877574e-02f, 8.98394659e-02f, -1.09834853e-03f, 6.66512847e-02f,
  -5.52313663e-02f, 4.02920833e-03f, 3.68590727e-02f, -4.19912599e-02f, -1.00928105e-01f, 2.06285119e-02f, -3.11954487e-02f, -9.11021456e-02f, 3.85414660e-02f, 5.74455634e-02f,
  -3.20639201e-02f, -5.19338623e-02f, -2.41704620e-02f, 7.30534419e-02f, 3.86320725e-02f, 7.40294158e-02f, -2.46075485e-02f, -2.60592774e-02f, -1.28300264e-01f, 1.88063830e-02f,
  1.19108364e-01f, 3.75973061e-02f, 5.88152781e-02f, 3.80454003e-04f, 1.01147918e-02f, 1.12384092e-02f, -6.66723251e-02f, 8.18439424e-02f, 7.77995288e-02f, 5.28016761e-02f,
  -9.95807648e-02f, 9.30492729e-02f, -5.05335592e-02f, 2.47264132e-02f, -2.80174497e-03f, -2.85751391e-02f, -3.16717327e-02f, -2.25654300e-02f, -3.16684432e-02f, -2.58382950e-02f,
  2.41748959e-01f, -1.51757509e-01f, 9.73982178e-03f, 9.65134129e-02f, -1.14461035e-02f, 4.82412614e-02f, -6.36164919e-02f, 4.92400490e-02f, -1.08095154e-01f, 7.23420084e-02f,
  6.56523788e-03f, 7.54717067e-02f, 3.95954698e-02f, 6.08380847e-02f, -4.29689065e-02f, 5.74604571e-02f, -4.91142124e-02f, -4.30963077e-02f, 6.02436326e-02f, 1.30961508e-01f,
  -3.55815664e-02f, -1.01263233e-01f, -6.90222904e-02f, 4.65930626e-02f, 7.53193721e-02f, -5.25349379e-03f, -2.54093446e-02f, -6.04171455e-02f, -3.13360430e-03f, -8.40972811e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.96104252e-01f, -4.88619447e-01f, -6.50608659e-01f, -2.61911064e-01f, 4.37480450e-01f, 4.67622489e-01f, -4.47655730e-02f, -1.91819165e-02f, -4.36058134e-01f, -4.54881527e-02f,
  3.01192224e-01f, -6.73050657e-02f, -2.75312662e-01f, 1.59882650e-01f, 4.66417491e-01f, -5.54558337e-01f, 1.72659144e-01f, 1.67301923e-01f, -2.60834992e-01f, 1.15493096e-01f,
  3.53048779e-02f, 5.32117248e-01f, -2.40171745e-01f, 1.54261112e-01f, 4.76605177e-01f, -9.33388174e-02f, 4.14021164e-01f, -1.06531106e-01f, 3.48087490e-01f, 3.57285798e-01f,
  -1.35172075e-02f, 2.03875769e-02f, 4.43350570e-03f, 3.59773301e-02f, -4.72623259e-02f, 4.39101495e-02f, 1.80931017e-02f, 2.04392895e-01f, -1.04574978e-01f, -6.03843480e-02f,
  1.43407568e-01f, 7.63089061e-02f, 1.04438834e-01f, 7.84743391e-03f, 2.65959185e-02f, -3.35732624e-02f, -1.85454845e-01f, 7.98173994e-02f, -2.73489594e-01f, -2.07116306e-02f,
  -1.08056068e-01f, 1.68554969e-02f, 5.42742424e-02f, 1.82996802e-02f, -1.81118727e-01f, -1.41800061e-01f, -4.25435714e-02f, -7.07843229e-02f, 8.24503824e-02f, -3.68752852e-02f,
  5.99805415e-02f, 4.66905385e-02f, 5.31152003e-02f, -2.50996426e-02f, -1.38215467e-01f, -9.44409594e-02f, 1.23724729e-01f, -9.52987298e-02f, -9.42150131e-02f, -9.52027217e-02f,
  -6.85979649e-02f, 2.19932441e-02f, 1.80874653e-02f, 8.49373080e-03f, 8.04162100e-02f, 1.33829294e-02f, 7.04800114e-02f, -2.19356436e-02f, -9.21717733e-02f, -8.73983651e-02f,
  -3.54399383e-02f, -7.88312554e-02f, -8.61906186e-02f, 1.70051660e-02f, -1.03204422e-01f, -8.24980810e-03f, 1.13173546e-02f, -2.03579515e-02f, -8.74018744e-02f, 1.05656177e-01f,
  1.00614140e-02f, -1.09575375e-03f, -1.70140147e-01f, 4.21965271e-02f, -1.57232508e-01f, 1.10731520e-01f, -5.01519851e-02f, 9.98788252e-02f, 1.04788408e-01f, -8.81822631e-02f,
  1.59293547e-01f, -5.37750358e-03f, 2.66102292e-02f, 4.55397144e-02f, 4.00994755e-02f, 2.67705936e-02f, 6.89366981e-02f, 1.91027578e-02f, 3.52125354e-02f, -1.47414133e-02f,
  1.01614922e-01f, -5.52435294e-02f, 7.33445808e-02f, 3.32421018e-03f, 3.52893099e-02f, 1.10574193e-01f, 5.06401286e-02f, -9.89620835e-02f, 1.20029584e-01f, -5.09238578e-02f,
  2.60352612e-01f, 1.50095597e-01f, -2.53499568e-01f, 1.84088707e-01f, 1.01364873e-01f, 5.28095722e-01f, 5.08404255e-01f, 2.14253187e-01f, 5.01555502e-01f, 1.67056426e-01f,
  -2.89290726e-01f, 3.17980289e-01f, -2.57240713e-01f, 6.41500354e-02f, 2.10895553e-01f, 8.18461995e-04f, 2.29188904e-01f, 3.39116156e-01f, 6.74865022e-02f, 2.87493706e-01f,
  7.85712712e-03f, 3.56745392e-01f, -3.39219511e-01f, 3.47911716e-02f, 7.39111658e-03f, -1.73591971e-01f, -4.36262429e-01f, -6.70763999e-02f, -1.31481424e-01f, 1.42143980e-01f,
  -5.64074889e-02f, 3.17261219e-02f, -1.74590379e-01f, -2.49295551e-02f, 2.96388343e-02f, 3.29421908e-02f, 5.23801707e-02f, -6.21552095e-02f, -7.75276795e-02f, -5.81164621e-02f,
  4.06786129e-02f, 6.56120256e-02f, 1.76368102e-01f, -2.97380444e-02f, 1.03089638e-01f, 5.93498461e-02f, -9.80897322e-02f, -3.28324139e-02f, -2.92562367e-03f, -9.93582308e-02f,
  -2.06351072e-01f, -1.13420211e-01f, 2.95363204e-03f, 6.61331117e-02f, -9.29628611e-02f, 9.18491632e-02f, 1.70381904e-01f, 2.88739726e-02f, -4.56326790e-02f, 2.04587623e-01f,
  -3.37135084e-02f, 6.17856681e-02f, 4.56615537e-02f, -1.13249242e-01f, 7.00592017e-03f, -7.81520307e-02f, 3.18200663e-02f, -1.18281646e-02f, 5.91067411e-02f, 5.53064533e-02f,
  5.90143837e-02f, -9.96770523e-03f, 1.09081985e-02f, 7.88077489e-02f, 9.89211276e-02f, 1.46310359e-01f, -7.10891113e-02f, -7.10977986e-02f, 3.79178440e-03f, -6.71123639e-02f,
  3.22361067e-02f, 1.30264377e-02f, -6.98243231e-02f, -1.49186477e-01f, 7.43392259e-02f, -4.55061719e-02f, -2.07158718e-02f, -6.81629106e-02f, -1.91041723e-01f, 2.39926297e-02f,
  1.82503462e-01f, 3.65771145e-01f, -4.07305770e-02f, -5.68440445e-02f, -2.43867412e-02f, 6.58686981e-02f, 5.82460724e-02f, 1.30594045e-01f, 1.84306204e-01f, 1.82368755e-01f,
  2.69432552e-02f, -1.59610528e-02f, 1.63802058e-01f, -4.35751341e-02f, -6.58531499e-05f, 1.36551201e-01f, 2.73119509e-02f, -5.19170761e-02f, 6.86244145e-02f, -8.54432862e-03f,
  -1.82050705e-01f, 1.34404004e-01f, 1.58740450e-02f, 1.19688131e-01f, 2.12962162e-02f, -1.45107498e-02f, 1.83513150e-01f, -1.67937577e-01f, -1.45511225e-01f, -3.85239236e-02f,
  1.91514939e-01f, -8.49170685e-02f, -9.26318672e-03f, 4.09107268e-01f, -5.56828491e-02f, -3.98099363e-01f, -5.43075979e-01f, -2.44834766e-01f, 1.08650789e-01f, -4.44653094e-01f,
  -2.80488938e-01f, 4.10501473e-02f, -5.13710320e-01f, 2.25842938e-01f, 4.94799674e-01f, 8.82568583e-02f, 2.98681319e-01f, 2.08356250e-02f, 3.14223021e-01f, -2.02474482e-02f,
  4.09613818e-01f, 4.35792714e-01f, 2.66107023e-01f, 2.24552140e-01f, 6.06996864e-02f, 3.09267879e-01f, 3.85154486e-01f, -6.06336221e-02f, 1.45950556e-01f, 2.20390216e-01f,
  -2.94506960e-02f, 1.96925312e-01f, 1.95039122e-03f, 8.99850354e-02f, 1.57320663e-01f, -9.63426679e-02f, -4.27202024e-02f, -3.28412764e-02f, -8.28755461e-03f, 2.87871566e-02f,
  -1.27490824e-02f, 1.66845266e-02f, 8.05800408e-02f, -1.02739083e-03f, 1.78529155e-02f, 8.83345604e-02f, 1.05502516e-01f, -9.16979536e-02f, -1.65135294e-01f, -6.25269711e-02f,
  -1.88302491e-02f, 5.52855283e-02f, -4.29355614e-02f, 1.45607948e-01f, 1.02691673e-01f, 4.57331650e-02f, -7.63349142e-03f, -2.05364805e-02f, 7.26601556e-02f, 2.38736585e-01f,
  3.73235494e-02f, -8.14820305e-02f, 1.85022689e-02f, -1.39601842e-01f, 6.78491443e-02f, 1.13917455e-01f, 1.06860436e-01f, -6.90680742e-02f, 1.10233299e-01f, -2.06282912e-05f,
  9.93882269e-02f, 5.79059264e-03f, 3.16442251e-02f, -9.55183432e-02f, 2.53020376e-02f, 4.14508022e-02f, -1.25823840e-01f, 3.77375372e-02f, 4.15733606e-02f, -8.71510506e-02f,
  -4.10809442e-02f, -3.03006787e-02f, -2.51074173e-02f, -2.36832872e-02f, 3.28490846e-02f, -1.35386318e-01f, -1.80116463e-02f, -4.65575680e-02f, -1.51845217e-02f, 2.19384348e-03f,
  1.65635586e-01f, 2.90691346e-01f, -5.74308708e-02f, 5.51438034e-02f, 1.37749508e-01f, -5.14693893e-02f, 8.46893489e-02f, 9.84045640e-02f, 1.54294610e-01f, 5.12514561e-02f,
  3.03895064e-02f, 4.43014950e-02f, 5.86179160e-02f, -3.67860794e-02f, 1.28216401e-01f, 3.65124159e-02f, 3.95312868e-02f, 2.15659410e-01f, 1.85388640e-01f, -8.27451125e-02f,
  -3.84743884e-02f, -1.74510926e-01f, 9.11312550e-02f, 1.76758140e-01f, -3.52036953e-02f, -7.06052929e-02f, 5.43277860e-02f, -6.72795018e-03f, 2.58962661e-02f, 1.36398952e-02f,
  -4.80383217e-01f, 2.49064431e-01f, -4.17973846e-01f, -2.66662985e-01f, 4.56816763e-01f, -4.91743118e-01f, -6.16891868e-02f, 4.17564325e-02f, -2.82468975e-01f, 3.52293730e-01f,
  -6.52862564e-02f, -9.08397585e-02f, -1.35861605e-01f, -4.13866937e-01f, -7.17972815e-01f, -6.06126964e-01f, -5.43891788e-01f, -2.83843338e-01f, -2.90308505e-01f, 3.48640326e-03f,
  -2.16370046e-01f, 1.61056086e-01f, -4.41173792e-01f, 4.83905941e-01f, 3.39167506e-01f, 3.69379640e-01f, 2.93692738e-01f, 3.49586844e-01f, 2.95223057e-01f, 4.14331071e-03f,
  -1.86851531e-01f, 1.75308939e-02f, 4.73841354e-02f, 8.96183960e-03f, -1.47432834e-01f, 8.25607777e-02f, -3.08986902e-02f, -8.81641060e-02f, -1.00907318e-01f, -5.88081889e-02f,
  5.84136099e-02f, 1.29688494e-02f, -9.65599157e-03f, -2.63369419e-02f, 1.35973006e-01f, -1.78831350e-02f, -7.13773444e-02f, -1.62343860e-01f, -7.95041211e-03f, -1.73987284e-01f,
  -1.31277889e-01f, -1.08844437e-01f, -1.19356759e-01f, -3.77815142e-02f, -1.00862615e-01f, -8.61675367e-02f, -1.60484597e-01f, 1.81642659e-02f, -1.38059920e-02f, -9.97052714e-02f,
  1.20361194e-01f, 4.38653724e-03f, -1.01054348e-01f, -7.19191730e-02f, -3.77214253e-02f, 8.50618407e-02f, -6.42026812e-02f, 6.54817210e-04f, -1.14902863e-02f, 2.85135377e-02f,
  1.38502400e-02f, 1.54075157e-02f, 7.35721514e-02f, 1.67123396e-02f, 3.78707238e-03f, 2.25904062e-02f, 4.66233045e-02f, 3.50275189e-02f, -7.35468371e-03f, -1.04874827e-01f,
  9.26189199e-02f, -5.98448105e-02f, -3.07717291e-03f, 9.25858021e-02f, -1.68178350e-01f, 2.46754773e-02f, 1.00219212e-01f, -9.27652493e-02f, -3.66052724e-02f, -2.20347475e-02f,
  -6.67065091e-04f, 1.53985664e-01f, 4.86387126e-02f, 1.94796264e-01f, -2.04627658e-03f, -1.35463560e-02f, -9.69296694e-02f, 2.22924147e-02f, -3.93200852e-02f, 2.92969365e-02f,
  6.87015103e-03f, 1.95024714e-01f, 1.42400861e-01f, 8.89721587e-02f, -3.67149450e-02f, -7.42002204e-02f, 9.58936568e-03f, 1.10597000e-01f, 1.39985383e-01f, -1.25804879e-02f,
  2.36458078e-01f, 8.70739669e-02f, -5.85278161e-02f, 1.73903704e-01f, 1.73478395e-01f, -2.19683768e-03f, 9.52045172e-02f, -5.12020104e-02f, -2.57020909e-02f, 7.32472911e-02f,
  -9.51283276e-02f, -6.79449379e-01f, -4.53236163e-01f, -4.84604500e-02f, 4.35250491e-01f, 5.02073586e-01f, 2.66049244e-02f, 6.46423176e-02f, -3.43929201e-01f, -1.25384390e-01f,
  6.36151955e-02f, -5.65270305e-01f, -6.31824434e-01f, -3.33098471e-01f, -2.16575071e-01f, -6.22599244e-01f, 1.52814984e-01f, -3.71739119e-02f, -4.08857942e-01f, -3.84013988e-02f,
  -1.13494471e-01f, 1.70747042e-01f, -2.60168821e-01f, 4.16598976e-01f, 2.09168419e-01f, 1.99208647e-01f, 5.83735764e-01f, 1.04238778e-01f, 4.45414513e-01f, 5.71291000e-02f,
  -9.08071268e-03f, -4.09503847e-01f, -3.55511904e-02f, 3.33543420e-02f, 2.60502577e-01f, 1.79966658e-01f, 2.51158774e-01f, -3.33573334e-02f, 1.30132847e-02f, -1.77766487e-01f,
  7.51036033e-02f, -1.51852027e-01f, -8.56466293e-02f, -1.10670969e-01f, 7.27771744e-02f, -2.33004764e-02f, -9.00264010e-02f, 1.18599743e-01f, -1.02385834e-01f, -3.10298234e-01f,
  -3.12406927e-01f, -1.19956732e-02f, 7.14511350e-02f, 5.05595282e-02f, -9.81832072e-02f, -2.44187489e-02f, -2.45309304e-02f, -9.86599596e-04f, 1.11098759e-01f, 3.56870592e-02f,
  4.57765050e-02f, 6.94769807e-03f, -1.75154936e-02f, -4.96280976e-02f, -7.68080130e-02f, 1.45783707e-01f, 1.31277502e-01f, -8.53559282e-03f, 7.04072714e-02f, 1.08939812e-01f,
  1.35825440e-01f, 5.55143617e-02f, 1.59273893e-02f, 7.70759434e-02f, -2.89143380e-02f, -1.93234123e-02f, 7.97959343e-02f, -1.07737206e-01f, 3.96421505e-03f, -2.73487344e-02f,
  2.73356698e-02f, 4.02049813e-03f, -4.18326259e-02f, 3.01601458e-02f, -8.58357027e-02f, -6.96680024e-02f, 6.23820797e-02f, 1.19854622e-02f, 3.30675803e-02f, 1.53861985e-01f,
  1.34569034e-01f, -5.45459911e-02f, -1.84065774e-01f, -9.24140513e-02f, -2.09614038e-02f, 1.24859199e-01f, -1.01854660e-01f, -1.29677474e-01f, 8.90926421e-02f, 8.46699986e-04f,
  2.01455995e-01f, 1.38027087e-01f, 2.61938006e-01f, -4.64266278e-02f, 2.16446072e-01f, 4.85010445e-02f, 1.95252076e-02f, 2.57817119e-01f, 3.02690029e-01f, 4.65304926e-02f,
  6.70597181e-02f, 1.14505008e-01f, 3.14341038e-02f, -8.06375220e-03f, 1.15955353e-01f, 3.35567854e-02f, 1.68670304e-02f, 7.12514594e-02f, 2.81372387e-02f, 5.65347262e-02f,
  -2.50861675e-01f, 4.21964675e-01f, 5.29442549e-01f, -1.10815160e-01f, 1.65280461e-01f, 3.91614854e-01f, 3.22621644e-01f, -2.40053341e-01f, -4.81033474e-01f, 1.42755657e-01f,
  -1.18819520e-01f, 3.04240763e-01f, 1.34983599e-01f, -3.18914764e-02f, -3.83803934e-01f, -3.11347872e-01f, -9.63413045e-02f, 8.81625265e-02f, -2.05280349e-01f, 1.14356577e-02f,
  -2.59047687e-01f, -3.95168960e-01f, -2.47129098e-01f, -3.97753209e-01f, 4.56529438e-01f, 1.61067352e-01f, -2.37848744e-01f, -6.57191426e-02f, 3.67693081e-02f, -9.24334899e-02f,
  1.04904301e-01f, -4.62907143e-02f, 1.80790529e-01f, 1.44002706e-01f, 3.71463336e-02f, 1.16380021e-01f, 3.36829990e-01f, -1.46425381e-01f, -9.47509259e-02f, -3.47580090e-02f,
  1.31590053e-01f, 3.82233434e-03f, -1.72391590e-02f, -9.36474055e-02f, -9.18034371e-03f, 1.48020331e-02f, 6.82588890e-02f, 2.83759713e-01f, 7.88133219e-02f, 1.60727337e-01f,
  2.10047245e-01f, 3.49078745e-01f, 6.96599185e-02f, 2.06198115e-02f, -1.00511670e-01f, -6.14646040e-02f, 2.08572019e-03f, 2.15920717e-01f, 2.44584650e-01f, -1.52544945e-01f,
  -9.76473466e-02f, 1.33756518e-01f, 2.88281411e-01f, 1.19422331e-01f, -8.05007070e-02f, 1.73336137e-02f, 4.78403755e-02f, -5.92418872e-02f, -2.15979755e-01f, 1.32999057e-02f,
  -1.12039216e-01f, 1.35595098e-01f, -6.21367618e-02f, -1.40465781e-01f, -2.02891648e-01f, 3.26375477e-02f, 7.47042522e-02f, 1.72983766e-01f, 3.27931531e-03f, 4.11331840e-02f,
  -4.24518250e-02f, -1.25210807e-01f, -8.10238346e-02f, 1.48512915e-01f, 2.07714751e-01f, -1.97680801e-01f, -2.26791441e-01f, 3.25086489e-02f, -2.78934896e-01f, 8.98570940e-02f,
  1.48239583e-01f, -1.32614434e-01f, -1.56676129e-01f, 1.28197417e-01f, 3.36169899e-02f, 1.46656930e-01f, 2.90875416e-02f, -1.46648034e-01f, -1.47332191e-01f, -3.08746751e-02f,
  1.03425443e-01f, -1.13648959e-02f, 7.40865245e-02f, -1.20107129e-01f, -1.72073752e-01f, -3.12638916e-02f, 6.96578547e-02f, 1.99096147e-02f, 7.02299103e-02f, 6.88227415e-02f,
  4.40982208e-02f, -4.87473346e-02f, -1.07055008e-01f, 6.15958730e-03f, 3.10035851e-02f, 1.81169197e-01f, -3.68250273e-02f, -8.79180506e-02f, 2.94846803e-01f, -6.42823651e-02f,
  -1.20883115e-01f, 1.55727372e-01f, 1.55345146e-02f, -3.97454083e-01f, -1.58960134e-01f, 2.01600179e-01f, -2.68697590e-01f, 1.78302780e-01f, -4.87306267e-01f, 1.83029965e-01f,
  1.90483555e-01f, -4.72714454e-01f, 3.19024056e-01f, -1.35918081e-01f, -8.71691853e-03f, 7.13018924e-02f, 2.32012585e-01f, 4.79291342e-02f, 3.24351154e-02f, 4.72991019e-01f,
  2.69171208e-01f, 3.05165529e-01f, 3.72027636e-01f, 4.67661798e-01f, 2.70078123e-01f, 2.37191767e-01f, 4.35839653e-01f, 2.03035370e-01f, 2.45756850e-01f, -2.26237878e-01f,
  6.60317764e-02f, 6.37552813e-02f, 9.37764198e-02f, -1.09576061e-01f, 3.99535418e-01f, 7.09645972e-02f, 6.23793192e-02f, -2.03076184e-01f, -7.73011222e-02f, -1.28843069e-01f,
  -1.07837826e-01f, 5.94303058e-03f, 1.34437450e-03f, -2.94103920e-01f, -1.06131740e-01f, -4.57192101e-02f, 5.15230279e-03f, -3.00641600e-02f, -1.13919698e-01f, 2.07788318e-01f,
  1.01873048e-01f, -3.42512205e-02f, -2.25526956e-03f, -6.57728910e-02f, -1.20352365e-01f, 8.22340995e-02f, -2.77979784e-02f, 1.85686469e-01f, -1.09325722e-01f, -3.65786254e-02f,
  7.65784923e-03f, 5.19311875e-02f, 1.03818834e-01f, -7.28048906e-02f, -4.62855138e-02f, 1.11601604e-02f, -9.72649902e-02f, 1.23716062e-02f, -1.18406089e-02f, 6.00721315e-02f,
  -1.58485435e-02f, -1.16863502e-02f, -1.01760989e-02f, 5.06685339e-02f, 1.07835773e-02f, -1.26500309e-01f, 1.40867447e-02f, 2.39059534e-02f, 8.88142362e-02f, 3.88344303e-02f,
  -1.81542367e-01f, 5.42598404e-02f, 1.40326202e-01f, 1.34103438e-02f, -9.45391580e-02f, 1.00645982e-01f, 4.92181592e-02f, 6.53270772e-03f, 1.55853584e-01f, -4.48979810e-02f,
  1.83922827e-01f, 4.00457621e-01f, 8.72675329e-02f, -1.76707819e-01f, 7.18232244e-02f, 1.09327257e-01f, -2.99979951e-02f, 9.63315070e-02f, 3.54724936e-02f, 1.78921267e-01f,
  2.02678978e-01f, -1.77791771e-02f, 1.00260109e-01f, -5.71221337e-02f, -1.13258883e-01f, 3.60600650e-01f, 1.08430833e-01f, -2.30352893e-01f, -1.64198093e-02f, 2.13028118e-01f,
  6.02656752e-02f, 9.75371897e-02f, -4.24789563e-02f, 7.36174434e-02f, 6.93123511e-05f, 1.06720835e-01f, 6.82998449e-02f, 6.19481169e-02f, 1.09995576e-02f, -7.35367686e-02f,
  1.56354666e-01f, -8.63843337e-02f, -7.37536967e-01f, -3.28461170e-01f, -1.39936462e-01f, 2.72124648e-01f, 4.18821603e-01f, -1.11649394e-01f, -1.33384600e-01f, 4.99991626e-01f,
  5.56540608e-01f, -2.16118127e-01f, 4.88192558e-01f, 5.76081455e-01f, -4.21860486e-01f, 3.98225188e-01f, 3.13260168e-01f, 2.23487332e-01f, -1.93243578e-01f, -1.78420749e-02f,
  -3.18791032e-01f, 5.21820188e-01f, -6.68233708e-02f, -1.55702621e-01f, 2.50819027e-01f, -4.36019450e-01f, 2.91606158e-01f, -1.63564578e-01f, 2.43082821e-01f, 8.99122283e-02f,
  9.84771624e-02f, -4.82380986e-02f, -1.94484461e-02f, -1.03777044e-01f, -9.84233767e-02f, -2.74979998e-03f, 4.65952493e-02f, -9.75549892e-02f, -1.06686145e-01f, -6.91733807e-02f,
  -1.46535998e-02f, -1.61642626e-01f, -1.15313537e-01f, -1.88951418e-01f, 4.45657372e-02f, -2.68134885e-02f, -9.17572677e-02f, 5.88107342e-03f, -7.06907436e-02f, 2.11370550e-02f,
  -1.13295816e-01f, -3.14689614e-02f, 5.89276031e-02f, -3.45158093e-02f, -3.24784033e-02f, 6.05990365e-03f, -6.49732053e-02f, 3.14374380e-02f, -6.10695104e-04f, -9.58358496e-02f,
  -1.58553068e-02f, -2.34829616e-02f, 2.39940286e-02f, 7.10650906e-02f, -5.55559993e-02f, 5.11176400e-02f, 8.96312948e-03f, 1.97353497e-01f, -9.30945799e-02f, 5.35303876e-02f,
  -2.87019126e-02f, -1.61706135e-01f, 8.08968246e-02f, 5.63109145e-02f, -9.98989958e-03f, 9.07659810e-03f, -1.61901936e-02f, 1.35761090e-02f, -3.60157713e-02f, -1.19124530e-02f,
  5.29165864e-02f, -9.53717604e-02f, 6.60675839e-02f, 1.77639395e-01f, 7.69886896e-02f, -5.74134961e-02f, 4.83797826e-02f, -3.13422270e-02f, 5.80527484e-02f, -1.07131125e-02f,
  -1.52323321e-02f, -1.29077002e-01f, 4.39402871e-02f, -2.12965580e-03f, 1.76868774e-02f, 8.56118556e-03f, -3.68161649e-02f, -1.62275940e-01f, -1.61605161e-02f, 6.51250556e-02f,
  -2.11867504e-02f, -2.23628953e-02f, 4.86141890e-02f, -5.28244823e-02f, -1.44364998e-01f, 1.42577976e-01f, 7.32152760e-02f, -6.74112886e-02f, 1.22241504e-01f, 6.15736358e-02f,
  -4.90369275e-03f, 1.12082076e-03f, -8.58552158e-02f, 1.78166069e-02f, -2.70610042e-02f, 1.04366012e-01f, -6.53752238e-02f, -1.58584237e-01f, -3.54340952e-03f, -4.17359024e-02f,
  2.23967388e-01f, -3.62179190e-01f, -1.57039762e-01f, -1.34452060e-01f, -7.05789849e-02f, -7.97594860e-02f, -4.68136184e-03f, -2.00997621e-01f, 3.73688012e-01f, -5.96736610e-01f,
  -3.87270153e-01f, -2.13290211e-02f, 2.57998377e-01f, -4.42898631e-01f, 5.69972634e-01f, 4.26607817e-01f, -7.90846348e-02f, -7.40016848e-02f, 1.50879398e-01f, -2.49077678e-01f,
  5.65825179e-02f, -3.91461700e-01f, -7.77101517e-02f, -5.37750721e-01f, -3.62247497e-01f, -2.61978835e-01f, -1.20057367e-01f, -8.77447948e-02f, -5.63986063e-01f, 4.55114171e-02f,
  -1.15375727e-01f, 1.13122769e-01f, 2.19977759e-02f, -5.85915036e-02f, -6.00193813e-02f, -6.88225105e-02f, -1.81997716e-01f, 9.93641913e-02f, 2.30918109e-01f, -1.38249462e-02f,
  1.17521375e-01f, -2.07845643e-02f, 5.60572408e-02f, 3.51882726e-02f, 4.31265496e-02f, -9.41328704e-02f, 6.12579957e-02f, -1.21353023e-01f, -4.59378064e-02f, -6.84483424e-02f,
  1.58110857e-02f, 1.77726522e-02f, 2.32926048e-02f, -3.32040861e-02f, 1.29710376e-01f, 3.33570456e-03f, -6.44331351e-02f, 7.30094239e-02f, 6.03166930e-02f, 9.29644238e-03f,
  -1.00734651e-01f, 4.45510596e-02f, -4.01486345e-02f, -1.19665101e-01f, 1.38824955e-01f, -4.65956703e-02f, -6.31316938e-03f, -7.29237571e-02f, 8.87104198e-02f, 2.62187365e-02f,
  3.63143943e-02f, 1.93840843e-02f, 1.14793494e-01f, 6.18918166e-02f, -1.42901167e-01f, -1.19619751e-02f, -6.14687726e-02f, 1.08150877e-01f, -1.41105235e-01f, -1.21053919e-01f,
  -1.15067869e-01f, 3.90536450e-02f, 1.89251885e-01f, -7.86898956e-02f, -2.05162019e-02f, 1.55022070e-01f, -1.46082237e-01f, -6.60667643e-02f, -3.62566374e-02f, 1.59309849e-01f,
  -6.29166048e-03f, 8.64316802e-03f, 1.41811997e-01f, -1.25250109e-02f, -5.38560078e-02f, -1.19355507e-01f, -3.03305760e-02f, -8.56860280e-02f, 1.40545011e-01f, -5.57322986e-02f,
  -2.28927538e-01f, -5.01104183e-02f, -1.04902372e-01f, -1.65144041e-01f, -1.25363752e-01f, -8.24469849e-02f, 1.70154516e-02f, 4.07768264e-02f, 4.31024395e-02f, -1.06116451e-01f,
  -1.75698232e-02f, 3.00777610e-03f, 1.23233855e-01f, 8.27584695e-03f, -1.14172190e-01f, -1.20010348e-02f, -8.83475319e-02f, 1.48273170e-01f, 5.34669459e-02f, -1.71193369e-02f,
  -4.76456195e-01f, 1.55995131e-01f, 1.51275083e-01f, 6.50503576e-01f, -4.76510465e-01f, -4.00752872e-01f, 2.31780782e-01f, -1.44739538e-01f, -1.84653383e-02f, 3.70139927e-01f,
  4.21475083e-01f, -2.99762040e-01f, 3.85643810e-01f, 4.19589311e-01f, 1.59423910e-02f, 4.34076846e-01f, 4.37447876e-01f, 9.04789418e-02f, -1.84198186e-01f, 8.32213387e-02f,
  1.89820454e-02f, 2.82069385e-01f, 3.30823928e-01f, -1.87011465e-01f, -3.31585817e-02f, -5.60147129e-03f, 4.71592247e-01f, -1.71570078e-01f, 2.27331556e-02f, -2.44826585e-01f,
  -3.20868194e-01f, 2.97520369e-01f, 6.89437240e-02f, -1.85815990e-01f, 6.96498826e-02f, 1.58205405e-02f, -4.78207953e-02f, 4.02239040e-02f, 6.29649088e-02f, -1.61486361e-02f,
  -1.70019493e-01f, -2.03646407e-01f, -1.77396625e-01f, 5.85880205e-02f, -1.69412017e-01f, -1.12440780e-01f, -1.05120413e-01f, 6.52663261e-02f, -4.27897498e-02f, -1.08217992e-01f,
  1.02024049e-01f, 3.94878723e-02f, 1.92198321e-01f, 3.97581495e-02f, 4.19492647e-02f, 3.92088853e-02f, 6.19716272e-02f, -3.75928059e-02f, -9.35345814e-02f, -7.93522447e-02f,
  3.64371538e-02f, 7.84771815e-02f, 8.82603526e-02f, -3.22245210e-02f, -1.16232716e-01f, 6.63323654e-03f, 9.33481902e-02f, -2.35751718e-02f, -3.38859782e-02f, -3.32314111e-02f,
  -2.86063943e-02f, 2.72356090e-03f, -6.93990737e-02f, 1.89122558e-02f, -1.21979844e-02f, 1.04807623e-01f, -2.65726186e-02f, -1.66018665e-01f, 1.07537340e-02f, 4.27778214e-02f,
  3.29008736e-02f, -1.26394182e-01f, -1.05762504e-01f, -5.29257655e-02f, -8.93361121e-03f, 2.45757960e-02f, 1.93077445e-01f, 5.69234453e-02f, 1.47418156e-01f, -4.48864140e-02f,
  -1.94309205e-01f, 1.71239600e-01f, 1.15175331e-02f, -1.66700304e-01f, 4.18069959e-02f, -4.35811356e-02f, 1.06523857e-01f, -1.62324369e-01f, 1.18341343e-02f, 6.48448989e-03f,
  -2.92300470e-02f, 8.29274654e-02f, -1.12489983e-01f, 8.80780350e-03f, 1.35299964e-02f, 5.45740779e-03f, 8.92991573e-02f, -4.44118083e-02f, 1.11548774e-01f, -9.49778035e-02f,
  1.39383852e-01f, -8.97634402e-02f, 4.75247316e-02f, -8.42287838e-02f, 9.69938189e-02f, -1.45465164e-02f, -1.55918866e-01f, -8.67786780e-02f, -1.36471093e-01f, 5.65881990e-02f,
  8.72268975e-01f, 6.47215992e-02f, 3.52694988e-01f, 4.43171024e-01f, 4.99177873e-02f, 2.50264227e-01f, 7.13081598e-01f, -2.67234355e-01f, 5.71049392e-01f, -2.90589660e-01f,
  -3.13432008e-01f, 4.15833831e-01f, -8.76944140e-02f, -1.75727859e-01f, 1.66201722e-02f, -7.52260163e-02f, 1.20932095e-01f, 1.59301862e-01f, 7.41732940e-02f, 1.66859880e-01f,
  1.72748879e-01f, -2.67409176e-01f, -9.79305431e-02f, -5.04099548e-01f, 1.72268942e-01f, 1.51000440e-01f, -4.93165076e-01f, -1.01861380e-01f, -3.46067429e-01f, -2.36134201e-01f,
  5.16370609e-02f, -2.48170178e-02f, 3.41512561e-02f, -1.90199446e-02f, 4.42363508e-02f, 9.98172089e-02f, -4.82654804e-03f, 8.03893954e-02f, 4.14399616e-02f, -2.64559761e-02f,
  1.76371053e-01f, -8.20141286e-02f, 3.42317969e-02f, -6.56712055e-02f, 1.37308076e-01f, 3.85206230e-02f, 3.82672139e-02f, 5.82433417e-02f, -2.54340414e-02f, 1.20270163e-01f,
  2.44223192e-01f, 9.42132398e-02f, -2.05008723e-02f, -5.62345888e-03f, 5.42091280e-02f, 4.48487960e-02f, -4.89369081e-03f, 2.28400826e-02f, 4.39259186e-02f, 1.17014140e-01f,
  -2.68193800e-02f, 5.46183102e-02f, -1.06010921e-01f, -1.98949128e-02f, -5.77871166e-02f, -2.80751567e-02f, -1.88691448e-02f, -1.79717094e-01f, 4.16590534e-02f, -6.48017302e-02f,
  5.45070395e-02f, -1.54414121e-03f, 4.93414663e-02f, 3.70785482e-02f, 7.00070411e-02f, 1.86623503e-02f, -4.41958122e-02f, -9.02476162e-02f, 1.29951239e-01f, 1.23534799e-01f,
  -9.14188102e-02f, 6.97890483e-03f, 9.82062891e-02f, -2.34303288e-02f, 2.54141074e-02f, -3.22045088e-02f, -3.23750786e-02f, 1.08942874e-01f, -1.41710956e-02f, -7.13283420e-02f,
  -9.93204415e-02f, -1.73950344e-01f, 2.72759125e-02f, -1.08849611e-02f, 8.33072700e-03f, -2.18651928e-02f, 2.22920533e-02f, -2.01265309e-02f, 3.89838070e-02f, 2.97167804e-02f,
  -8.65659490e-02f, 1.28891289e-01f, -7.57631706e-03f, -1.22875877e-01f, -4.79989238e-02f, -8.20750669e-02f, 6.55933768e-02f, -3.86465713e-02f, 8.31701159e-02f, -2.12400630e-01f,
  -3.66369486e-02f, 2.72742491e-02f, -1.63753629e-02f, 5.36399931e-02f, -2.78863423e-02f, -4.12250459e-02f, 5.49320094e-02f, -4.19525504e-02f, 4.75514904e-02f, 8.72216895e-02f,
  -2.31087431e-02f, 1.37057900e-01f, 2.55540073e-01f, -6.70822799e-01f, -2.00219765e-01f, 1.81654498e-01f, -6.04831219e-01f, 6.21444024e-02f, -2.09401846e-02f, -2.02877745e-02f,
  -4.05851126e-01f, 6.63690791e-02f, 3.67179364e-02f, -4.08085942e-01f, 8.34543884e-01f, 4.00352806e-01f, -1.59161940e-01f, -4.82232153e-01f, -1.26301885e-01f, -5.05584478e-01f,
  -2.52562344e-01f, -5.98629117e-01f, -1.65185530e-03f, -3.13424647e-01f, -5.16083241e-01f, -8.57922360e-02f, -2.42903978e-01f, -2.46771619e-01f, -3.69942307e-01f, 3.00691910e-02f,
  -7.07437918e-02f, -1.40608460e-01f, 3.02585270e-02f, 1.96904555e-01f, 1.22172780e-01f, 2.85814311e-02f, -7.03744441e-02f, 5.51077016e-02f, -1.29949033e-01f, -2.37349104e-02f,
  2.62198634e-02f, 1.45034686e-01f, -4.11361121e-02f, 2.96633616e-02f, -2.44013190e-01f, 5.03938794e-02f, 7.65957907e-02f, 2.01383848e-02f, 1.15382314e-01f, 1.02699965e-01f,
  -2.86712982e-02f, 1.82908148e-01f, -4.27369885e-02f, -1.17170522e-02f, -8.81016552e-02f, -5.98605536e-02f, 2.91272234e-02f, 4.04624874e-03f, 6.62596896e-02f, 7.85222277e-02f,
  3.99556048e-02f, -3.58149335e-02f, 1.83179956e-02f, -4.24923711e-02f, -1.85741633e-02f, -1.12184107e-01f, 4.66338135e-02f, -9.02704597e-02f, 8.21464211e-02f, -1.21882878e-01f,
  -7.45374933e-02f, 8.21611658e-03f, -2.04908654e-01f, -4.93939221e-02f, -1.14555433e-01f, -2.23238626e-03f, 6.19197935e-02f, -2.78721098e-02f, -4.14316822e-03f, 1.17389806e-01f,
  -2.27190644e-01f, -2.65209284e-02f, -2.03635469e-01f, -1.39595166e-01f, 1.17732612e-02f, 5.90188019e-02f, 5.45285568e-02f, 2.03011319e-01f, 2.14465298e-02f, 2.78360657e-02f,
  1.48920119e-01f, 1.49464188e-02f, -7.63465837e-03f, -3.25722955e-02f, 1.03638679e-01f, 1.48545101e-01f, 1.05422609e-01f, -8.49058628e-02f, 1.75616276e-02f, 2.06147600e-02f,
  7.83728659e-02f, -6.54102266e-02f, 5.36275133e-02f, -3.83605924e-03f, -4.29437496e-02f, 1.74516052e-01f, -2.40393341e-01f, 2.48655733e-02f, 1.19523155e-02f, 1.01876922e-01f,
  -1.00021809e-01f, -8.48620906e-02f, 1.16151005e-01f, -1.28969461e-01f, -1.00193948e-01f, 1.33144915e-01f, -4.66733724e-02f, 2.90760938e-02f, -6.83372021e-02f, -3.31549384e-02f,
  -1.06428909e+00f, 4.07583892e-01f, -1.88866585e-01f, -3.33080292e-01f, -1.10881671e-01f, -2.42569089e-01f, -1.39339298e-01f, -2.15503454e-01f, 7.38756545e-03f, 3.16969872e-01f,
  1.93707868e-01f, 2.79869861e-03f, 3.33319277e-01f, 2.25668415e-01f, -4.14089322e-01f, 4.12597716e-01f, -2.35205650e-01f, -4.18114588e-02f, 1.96833462e-01f, -2.94707596e-01f,
  -1.22334152e-01f, 1.38427436e-01f, 7.91269541e-02f, 1.97699696e-01f, -1.86211288e-01f, -1.53848588e-01f, -1.74707592e-01f, 1.96626887e-01f, -1.33970872e-01f, 8.27364624e-02f,
  -5.23635745e-01f, -3.26075673e-01f, -3.84050816e-01f, -2.68943161e-01f, -2.91163623e-01f, -1.83625236e-01f, -3.04061562e-01f, 7.54972994e-02f, -9.58576500e-02f, -7.89367557e-02f,
  -2.13462580e-03f, 1.21611901e-01f, 4.40231562e-02f, 1.56662196e-01f, -1.03975758e-01f, -2.51793787e-02f, 1.17684752e-01f, -2.41861995e-02f, 8.14343616e-02f, 4.03949134e-02f,
  7.26158321e-02f, 9.11419988e-02f, -1.28542706e-01f, 9.29838493e-02f, -2.46969219e-02f, -8.85761250e-03f, 1.17359413e-02f, -9.74951163e-02f, -1.31066859e-01f, -1.72698095e-01f,
  -3.34377959e-02f, 5.48672862e-03f, -5.01735955e-02f, 1.09561812e-02f, 7.33043104e-02f, 9.03557017e-02f, -5.29743806e-02f, 3.97558510e-02f, 9.03146062e-03f, 4.11301898e-03f,
  5.54620055e-03f, -9.84141827e-02f, -1.42519236e-01f, -1.14403673e-01f, -8.45444947e-03f, -1.31389782e-01f, 3.21002537e-03f, -5.40316142e-02f, 2.66158208e-02f, -1.25450492e-01f,
  2.51694843e-02f, -3.29353660e-02f, -2.71425694e-02f, 4.47079912e-03f, -8.26369822e-02f, 2.16203718e-03f, 2.28909757e-02f, -3.55297253e-02f, -5.58330305e-02f, -8.40388983e-02f,
  -7.69257128e-01f, -6.16185308e-01f, -5.46366051e-02f, -1.00208014e-01f, -3.32540609e-02f, -5.32804728e-02f, 1.02495469e-01f, -6.93395212e-02f, -1.57121152e-01f, -1.06175609e-01f,
  -9.80251953e-02f, -9.84970853e-02f, -1.50377408e-01f, -4.62837406e-02f, 5.55443168e-02f, 2.54930519e-02f, -5.86337633e-02f, -2.33267359e-02f, -1.77364215e-01f, -4.64971438e-02f,
  5.97267691e-03f, -4.35694717e-02f, 2.35095993e-02f, -3.82971093e-02f, -9.69449431e-02f, -7.53645450e-02f, -1.55905724e-01f, 8.03221986e-02f, -1.31770000e-01f, 1.18866764e-01f,
  -4.56640214e-01f, 4.27489251e-01f, -3.76646668e-01f, 3.97281319e-01f, -3.70355815e-01f, 4.05796021e-01f, 5.71139872e-01f, 1.25024348e-01f, 4.54110622e-01f, 5.44241250e-01f,
  8.95685777e-02f, 2.04702049e-01f, 1.95573345e-01f, 4.10881877e-01f, 2.84761917e-02f, 4.93726820e-01f, 4.86848325e-01f, 4.26617503e-01f, 7.46366307e-02f, 9.26488712e-02f,
  -2.35929731e-02f, 3.33789855e-01f, -3.22853208e-01f, -1.07489958e-01f, -2.04025835e-01f, -3.15748513e-01f, -2.84606904e-01f, -2.36882403e-01f, -8.29320773e-02f, -5.75890131e-02f,
  -5.48232086e-02f, 9.27120894e-02f, -1.83821261e-01f, 1.48559352e-02f, -7.73787349e-02f, -1.76869363e-01f, -4.59494442e-02f, -1.26866743e-01f, -1.33563071e-01f, 4.29298393e-02f,
  3.45637277e-02f, 1.43107101e-02f, 1.23165779e-01f, -9.57219221e-04f, -4.10863049e-02f, -8.55859891e-02f, -1.01263322e-01f, -1.44215435e-01f, 7.11135343e-02f, -2.10336298e-01f,
  -1.14082225e-01f, -1.27161860e-01f, -3.34974863e-02f, 1.32082909e-01f, -3.77748683e-02f, 8.68546665e-02f, 1.18202575e-01f, -1.41821235e-01f, 5.28832711e-02f, 9.48577672e-02f,
  -3.96748818e-02f, 1.24424413e-01f, 5.56784123e-02f, -7.36038163e-02f, -4.65312041e-02f, -8.17619488e-02f, -3.06815784e-02f, -1.44939404e-02f, -8.55840091e-03f, -4.24195230e-02f,
  -7.23298937e-02f, -1.24079257e-01f, 2.74765100e-02f, -3.25349011e-02f, 5.85428402e-02f, -1.28996577e-02f, -7.92251676e-02f, 3.97121795e-02f, 3.63288336e-02f, -8.95822719e-02f,
  8.78390521e-02f, 9.26499888e-02f, 8.55965018e-02f, -5.89347184e-02f, 9.80177745e-02f, -1.00670774e-02f, 2.60199048e-02f, -4.21614200e-02f, -8.35132226e-02f, -4.27517109e-02f,
  4.14186746e-01f, 5.81225753e-01f, 1.34821013e-01f, 6.40639886e-02f, 6.70689577e-03f, -2.69354656e-02f, 3.17840539e-02f, -8.60882476e-02f, 1.09674610e-01f, 1.06453471e-01f,
  -4.85565327e-02f, 1.03031561e-01f, -1.68948680e-01f, -1.14379324e-01f, -1.21093374e-02f, 8.58313292e-02f, 2.10164875e-01f, 3.92594654e-03f, 5.16293012e-02f, -7.30356276e-02f,
  -7.43800178e-02f, 5.17967045e-02f, -2.86971312e-02f, 1.07979355e-02f, -1.65494885e-02f, -4.42811381e-03f, 3.32896449e-02f, -2.99789608e-02f, -1.05604544e-01f, 6.70433640e-02f,
  -9.64761138e-01f, 6.47916973e-01f, 2.53014356e-01f, -2.79050916e-01f, -1.66501522e-01f, 1.43826798e-01f, -1.90754339e-01f, 6.39915392e-02f, -2.50838578e-01f, 2.72062540e-01f,
  1.57256611e-02f, -2.79972136e-01f, 2.02701613e-01f, 3.12169015e-01f, -6.10810399e-01f, 4.25166637e-01f, 2.07610816e-01f, -3.66250798e-02f, -8.43923315e-02f, -1.99591517e-01f,
  -1.27310842e-01f, -2.41706342e-01f, 2.14560390e-01f, 2.61131555e-01f, -5.23801930e-02f, -5.92691544e-03f, -1.74609274e-01f, 2.10146178e-02f, 1.52265906e-01f, 3.76681499e-02f,
  -5.16101778e-01f, -4.47177917e-01f, -1.79550990e-01f, 2.70324890e-02f, -8.93866345e-02f, -1.00780562e-01f, -9.63552073e-02f, -1.41378999e-01f, -1.47903472e-01f, 7.04209358e-02f,
  -1.18284397e-01f, -4.49318066e-02f, -1.20501891e-01f, -7.60011077e-02f, 1.77208334e-02f, 4.16228585e-02f, 2.04570696e-01f, 1.78030789e-01f, -6.23973683e-02f, 6.04047813e-02f,
  1.96699917e-01f, 1.98727801e-01f, 9.77847502e-02f, 1.49683326e-01f, 3.15197557e-02f, -8.81556794e-03f, 7.11103082e-02f, 2.84571555e-02f, 4.83479537e-02f, 2.73441635e-02f,
  7.94534013e-02f, -1.18769422e-01f, 5.39196134e-02f, -5.14653735e-02f, 2.76137027e-03f, 6.26276582e-02f, 8.56452584e-02f, -4.64050621e-02f, 2.72809714e-02f, 3.33223888e-03f,
  -4.87862900e-02f, -1.91383455e-02f, -9.54503268e-02f, 8.32611471e-02f, 1.78406779e-02f, -6.10080808e-02f, 4.13977429e-02f, -1.00457063e-02f, 5.18755503e-02f, 8.05886388e-02f,
  -9.41274464e-02f, 3.86174731e-02f, 1.19357824e-01f, -4.70848270e-02f, -4.65287082e-03f, 1.49153424e-02f, -5.40467165e-03f, 1.98992014e-01f, -4.17518020e-02f, -1.25421822e-01f,
  -8.04197311e-01f, -6.08144760e-01f, -1.40694320e-01f, -1.71436563e-01f, -3.32739577e-02f, -1.33081870e-02f, -4.47206199e-02f, 4.11966778e-02f, -1.78975500e-02f, -1.32145390e-01f,
  -5.79460450e-02f, 7.63932317e-02f, -7.71068335e-02f, -8.73734802e-02f, -5.32389209e-02f, -1.03457950e-01f, -1.72705337e-01f, -7.36474022e-02f, -2.46087149e-01f, -6.80076703e-02f,
  -3.29762772e-02f, -1.49303854e-01f, 1.11364536e-01f, -1.45997163e-02f, -1.00015299e-02f, -1.61346868e-01f, -1.47289783e-01f, 1.50745371e-02f, 3.42010893e-02f, 7.76061937e-02f,
  2.06067577e-01f, -3.40847373e-01f, 3.27623695e-01f, 5.04734874e-01f, -5.26499189e-02f, -5.00434101e-01f, -3.12049985e-01f, 1.53110817e-01f, 1.70418203e-01f, -5.17036021e-01f,
  -2.73800462e-01f, 1.68799028e-01f, -4.85595554e-01f, 4.10684079e-01f, 2.13381186e-01f, -4.20660466e-01f, 3.69149625e-01f, 9.45729911e-02f, 2.43691862e-01f, 3.13620836e-01f,
  4.00094122e-01f, 1.54197901e-01f, 2.11494252e-01f, 8.62233490e-02f, 1.08627327e-01f, 4.15719658e-01f, 8.08532164e-02f, 1.74264479e-02f, 2.81233341e-01f, 2.07794271e-02f,
  -3.43705684e-01f, 2.83671558e-01f, 1.57450035e-01f, -1.43212527e-01f, 6.02025259e-03f, -4.36489135e-02f, 9.03746262e-02f, -7.01795369e-02f, 8.62105489e-02f, -5.66519089e-02f,
  -1.58046335e-01f, 1.25841364e-01f, 2.26265833e-01f, -9.55777802e-03f, -8.10079277e-02f, 1.13550782e-01f, -5.73230498e-02f, -9.27867591e-02f, -6.12146407e-02f, -2.74742171e-02f,
  -1.65009834e-02f, 1.30276959e-02f, 1.23598017e-01f, -9.05919634e-03f, 8.13412666e-02f, 4.86742519e-03f, 1.43698916e-01f, -2.34407708e-02f, 7.07567409e-02f, 1.05184376e-01f,
  4.33404446e-02f, -8.85017216e-02f, -1.23270333e-01f, -2.87610702e-02f, 1.52696781e-02f, 2.02872790e-02f, 4.59784567e-02f, 6.18037395e-02f, 1.01604953e-03f, -7.01625049e-02f,
  -2.40675639e-03f, 2.96913013e-02f, 3.05623319e-02f, -5.64460605e-02f, 2.78784754e-03f, 9.69711915e-02f, 7.35570118e-02f, -4.20578942e-02f, 4.08844016e-02f, 2.22548470e-02f,
  -4.40268574e-04f, -9.36819017e-02f, -2.42266413e-02f, 1.39867952e-02f, -1.01627558e-01f, 9.09307040e-03f, 9.47971083e-03f, -2.51188315e-02f, 3.73311079e-04f, -6.78352639e-02f,
  -7.10249245e-01f, -2.54460156e-01f, -2.19421778e-02f, -1.81118578e-01f, -8.85553844e-03f, -8.23983848e-02f, 7.32010901e-02f, 5.36345318e-02f, -1.31853953e-01f, -6.42718095e-03f,
  -5.91787174e-02f, -5.12261391e-02f, -8.17127079e-02f, 2.13379767e-02f, -6.98329210e-02f, -9.41369012e-02f, -3.78770120e-02f, -1.08323663e-01f, -1.16654309e-02f, 5.21528535e-02f,
  -3.44040953e-02f, -2.40229047e-03f, 9.11880583e-02f, 3.22159268e-02f, 2.99597494e-02f, -1.13686152e-01f, -8.81936960e-03f, 1.10255405e-01f, 4.05830182e-02f, 1.08887322e-01f,
  2.58002192e-01f, 4.62991923e-01f, 3.54314059e-01f, 3.23086739e-01f, -5.24451315e-01f, -1.02181971e-01f, 9.26278979e-02f, 1.70101061e-01f, 4.51772690e-01f, 3.57794732e-01f,
  -3.59257549e-01f, 4.86704916e-01f, -1.41155288e-01f, 1.78329781e-01f, -3.79417479e-01f, -1.91456869e-01f, -1.35891214e-01f, 2.15247169e-01f, 4.83191349e-02f, -3.99614461e-02f,
  -2.67156124e-01f, -5.41003525e-01f, -1.82483763e-01f, -2.91955024e-01f, 1.40078053e-01f, 2.69348383e-01f, -4.20002192e-01f, -1.36367023e-01f, 1.63959473e-01f, -1.97745144e-01f,
  2.67394066e-01f, 1.69759452e-01f, 2.84502715e-01f, 3.07910711e-01f, 9.03928205e-02f, -6.01227283e-02f, 6.17695041e-02f, 2.51834020e-02f, 4.14984450e-02f, 2.26624921e-01f,
  3.89360189e-02f, 1.66636147e-03f, 1.46835595e-01f, -1.25671610e-01f, 1.04498500e-02f, 9.46754068e-02f, 8.42284709e-02f, 1.12816937e-01f, 1.04304492e-01f, -7.96446204e-02f,
  9.63560641e-02f, 2.47686312e-01f, -1.49076000e-01f, 9.91691202e-02f, -5.40265925e-02f, 2.83639133e-02f, -3.79399061e-02f, -1.42224401e-01f, 1.76361769e-01f, 4.22974713e-02f,
  -2.29468167e-01f, -9.28191692e-02f, 9.99881700e-03f, 4.15634662e-02f, -3.83628043e-03f, 3.64201777e-02f, 1.01412870e-01f, -1.69531092e-01f, 9.39079672e-02f, -3.49360192e-03f,
  -2.66323369e-02f, 1.34856209e-01f, -1.03813797e-01f, -5.91080599e-02f, -6.53218329e-02f, 8.31676498e-02f, -1.58321768e-01f, 8.11100006e-02f, 6.57573938e-02f, -5.88316210e-02f,
  -1.14978395e-01f, -2.05464974e-01f, 1.06139496e-01f, -4.35853153e-02f, 6.96902201e-02f, 2.00986420e-03f, -5.79086877e-03f, 8.72452930e-02f, -2.78040599e-02f, -4.07464147e-01f,
  5.68335541e-02f, -2.33889490e-01f, 1.71075821e-01f, 3.31638843e-01f, 9.16700214e-02f, -5.74570969e-02f, -1.66813046e-01f, 9.42232460e-02f, 2.39806920e-02f, -4.79675941e-02f,
  -1.20938145e-01f, 1.06866129e-01f, -5.71142770e-02f, -2.07667202e-02f, 3.93486954e-02f, -1.69744045e-01f, -4.14610729e-02f, -6.80842847e-02f, -1.27085671e-01f, -1.84235629e-02f,
  -6.00051656e-02f, -8.39041546e-02f, -7.16405809e-02f, -3.54781486e-02f, -3.47577222e-02f, -7.34042823e-02f, -6.86056167e-02f, 1.07295968e-01f, -2.27259696e-01f, -5.44543341e-02f,
  8.95099491e-02f, -2.72748977e-01f, 4.09779072e-01f, 2.19207376e-01f, 5.25541246e-01f, 2.27921829e-02f, 1.89269498e-01f, 3.60551268e-01f, 5.69002628e-01f, -4.06817436e-01f,
  1.14462890e-01f, -3.70075673e-01f, 1.45392045e-01f, -1.07357576e-01f, -2.09070191e-01f, 1.56714395e-02f, -2.37117529e-01f, -1.45452917e-01f, 2.90239483e-01f, 2.60374308e-01f,
  1.00987824e-02f, -1.49783984e-01f, -1.82159707e-01f, 9.33114067e-02f, 7.58950263e-02f, -5.80379032e-02f, -4.20965761e-01f, 7.51255378e-02f, -4.89580572e-01f, -4.69577014e-02f,
  -1.41710967e-01f, 2.11134374e-01f, -1.42581120e-01f, -2.33466864e-01f, -6.18159138e-02f, -1.79977030e-01f, -1.36456460e-01f, 6.38646856e-02f, 1.53601253e-02f, 2.20863763e-02f,
  -9.89879295e-02f, -7.26751909e-02f, -8.78055245e-02f, 4.11062054e-02f, 5.93587458e-02f, -9.33632895e-04f, 7.24800453e-02f, -3.67953889e-02f, 1.47319272e-01f, 8.42410848e-02f,
  7.48790875e-02f, -4.98573668e-02f, 1.35726348e-01f, -1.61225989e-01f, -5.72821610e-02f, 3.11603826e-02f, 8.04735199e-02f, -5.61648048e-02f, -4.52232622e-02f, -8.74464214e-02f,
  1.89556703e-01f, 5.83389252e-02f, 7.22568482e-02f, 5.84095418e-02f, 1.11932810e-02f, 4.69536409e-02f, -1.13884658e-02f, -8.34210142e-02f, -1.06351506e-02f, -1.65715776e-02f,
  6.96681067e-02f, -6.39924556e-02f, 1.73469990e-01f, 1.49514169e-01f, -6.74720258e-02f, 9.30551589e-02f, 5.14151901e-02f, 1.59177169e-01f, -2.96309758e-02f, -5.89361638e-02f,
  1.09751888e-01f, 1.02194743e-02f, 7.83327594e-02f, 1.02149574e-02f, -8.76324996e-02f, 4.44415063e-02f, 8.59377440e-03f, 2.26499602e-01f, 5.35488501e-02f, -1.13668270e-01f,
  -5.81007123e-01f, -3.80963504e-01f, -1.61024243e-01f, -1.33792758e-01f, -9.81394351e-02f, -9.04983953e-02f, 1.56964920e-02f, -1.62670086e-03f, -2.35208273e-01f, -3.55363882e-04f,
  3.76295485e-03f, -3.20368707e-02f, -3.03914621e-02f, -2.59151664e-02f, -3.03918988e-01f, 1.68109555e-02f, -5.86826503e-02f, -8.05637762e-02f, -2.19900861e-01f, -1.43181562e-01f,
  -1.69225380e-01f, 3.06759663e-02f, 5.90364300e-02f, -4.88306675e-03f, 2.45905835e-02f, -3.90290804e-02f, -2.09367517e-02f, -3.76373762e-03f, -6.21641241e-02f, -8.96405801e-02f,
  -3.45452636e-01f, 4.93930787e-01f, 5.94981611e-01f, -3.97196636e-02f, 2.72516310e-01f, 7.62638211e-01f, 5.52682459e-01f, 3.78005058e-01f, 3.39268357e-01f, -7.43311793e-02f,
  -2.94320345e-01f, -3.06800995e-02f, 2.76960582e-01f, -1.33865029e-01f, 6.40597701e-01f, 3.84159803e-01f, 1.22776106e-01f, -2.20320672e-02f, 2.30913714e-01f, -7.08438084e-03f,
  2.47074172e-01f, -1.51344866e-01f, 9.71030295e-02f, -1.83509931e-01f, -1.46852314e-01f, -2.20297173e-01f, -4.05892044e-01f, 4.53898340e-01f, -2.94228345e-01f, 3.30600798e-01f,
  2.29215939e-02f, -5.84245399e-02f, -3.17726731e-01f, -1.00863405e-01f, -1.21877857e-01f, -5.64234555e-02f, 5.84023707e-02f, 1.77733138e-01f, 4.83372584e-02f, 6.44363388e-02f,
  -1.24801949e-01f, -9.91216972e-02f, -4.56639752e-02f, 7.97598287e-02f, 8.59939605e-02f, -1.06454916e-01f, 8.07772949e-02f, -1.45082176e-01f, 6.15933910e-02f, 1.52808368e-01f,
  -3.40112634e-02f, -7.72106722e-02f, -1.44748688e-01f, 9.33139119e-03f, 1.10809818e-01f, -1.16906382e-01f, 4.97205183e-02f, 1.14312254e-01f, 1.31748049e-02f, 7.73200393e-02f,
  -1.60143878e-02f, 1.87377200e-01f, -1.62928402e-02f, 2.23519150e-02f, 4.28371653e-02f, 9.84892529e-03f, -6.91948161e-02f, -8.67637098e-02f, 8.84900093e-02f, -1.21069536e-01f,
  -1.88722104e-01f, -1.79176852e-01f, -5.80151342e-02f, -5.92838675e-02f, -6.78442344e-02f, -1.03302501e-01f, -6.20038956e-02f, -1.06504902e-01f, -1.72055103e-02f, -1.04660295e-01f,
  8.10574815e-02f, 7.56656379e-02f, -1.98865443e-01f, -1.09581277e-01f, -5.06358743e-02f, 6.39662445e-02f, -1.01124577e-01f, 4.06570584e-02f, -1.32843092e-01f, 1.21360339e-01f,
  1.52657434e-01f, 3.63224357e-01f, -2.90800501e-02f, -1.74786732e-01f, 2.19636876e-02f, -8.85442048e-02f, 7.13039264e-02f, -8.37144163e-03f, 3.08485031e-01f, -1.39090307e-02f,
  -1.48093402e-01f, -1.09706424e-01f, -3.75876389e-02f, -3.40113305e-02f, 1.08575642e-01f, 4.19039093e-02f, 4.56214994e-02f, 2.90003754e-02f, 9.50520337e-02f, -1.64030604e-02f,
  -1.16483860e-01f, -3.21443267e-02f, -5.77548780e-02f, -1.20413728e-01f, -2.20445514e-01f, -1.16472729e-01f, -9.41002145e-02f, -8.38147327e-02f, 2.18154266e-02f, 3.01660448e-02f,
  -3.20719667e-02f, -4.25120652e-01f, 2.76603729e-01f, -2.07394645e-01f, -2.96284124e-05f, 1.44778565e-01f, 5.34282982e-01f, -3.52449745e-01f, -6.04637325e-01f, -2.86669374e-01f,
  3.07727486e-01f, -4.48093452e-02f, 5.19774735e-01f, -4.02936526e-02f, 4.91166681e-01f, 2.22851530e-01f, -6.59887046e-02f, 1.65015861e-01f, -1.49312407e-01f, 1.53932840e-01f,
  1.27430961e-01f, 2.83652674e-02f, 6.23684227e-01f, -1.44712374e-01f, 7.90866166e-02f, -1.02418356e-01f, 2.17030182e-01f, 4.52907413e-01f, -1.88802823e-01f, 5.48370816e-02f,
  7.37599656e-02f, -1.12913921e-01f, 1.59763724e-01f, -7.78980702e-02f, 2.74918526e-01f, 2.44110689e-01f, 2.32265636e-01f, 2.85147876e-01f, -6.65136874e-02f, 1.14256024e-01f,
  1.44682124e-01f, -9.79207680e-02f, -2.66805112e-01f, 6.41999394e-02f, -2.37395167e-01f, -1.79034799e-01f, -1.93938792e-01f, 1.50035126e-02f, 1.69952922e-02f, 1.29064932e-01f,
  1.36375949e-02f, -5.64721078e-02f, -9.12060663e-02f, -1.36602506e-01f, -6.80883229e-02f, -2.63942122e-01f, 5.71687631e-02f, 1.88387319e-01f, -2.09907070e-01f, -6.73476830e-02f,
  -7.73012638e-02f, 4.67674620e-02f, 5.53402444e-03f, -4.05893006e-05f, 1.38747960e-01f, -3.64973545e-02f, -6.59924820e-02f, 5.75360917e-02f, -2.76417611e-03f, -5.51701896e-02f,
  -5.27522638e-02f, 1.05888106e-01f, -1.37234345e-01f, -6.89919665e-02f, 6.74331710e-02f, -8.46139044e-02f, 2.65195727e-01f, 2.33026724e-02f, -7.00293034e-02f, 6.06784225e-02f,
  6.02839179e-02f, -5.70012443e-02f, 1.26981974e-01f, 1.32483747e-02f, -7.56427795e-02f, 1.99638709e-01f, -1.38575658e-01f, -3.19661647e-02f, -5.60854748e-02f, 1.71578124e-01f,
  1.17939554e-01f, -1.46902159e-01f, 9.80108753e-02f, -1.06284238e-01f, 1.90308496e-01f, 1.45119233e-02f, -3.25838216e-02f, -1.69418171e-01f, -1.20687939e-03f, 1.17065497e-01f,
  9.16074738e-02f, -1.95703693e-02f, -1.15190461e-01f, 1.12344272e-01f, -8.71642586e-03f, -2.18542796e-02f, 6.59157187e-02f, 1.66140348e-02f, 6.69319034e-02f, -1.33741677e-01f,
  -1.13650002e-01f, -1.98731590e-02f, -1.29268810e-01f, -2.03407422e-01f, -1.51364818e-01f, -4.26888689e-02f, 4.21116762e-02f, -2.28336528e-02f, -1.52150363e-01f, -1.49700508e-01f,
  5.61557174e-01f, -1.07927024e-01f, -4.07346010e-01f, 1.04203448e-01f, 4.08209950e-01f, 2.39634439e-01f, -3.24580491e-01f, 1.25232413e-01f, -4.47346538e-01f, -4.07647043e-01f,
  1.96822673e-01f, -3.51861894e-01f, -3.05857658e-01f, 5.43418646e-01f, 5.56646526e-01f, -9.18800905e-02f, 3.60414416e-01f, 1.30638465e-01f, 1.40945971e-01f, 4.28621799e-01f,
  2.07155302e-01f, 5.69879949e-01f, 1.96962655e-01f, 4.08631057e-01f, 4.71992552e-01f, -5.89413568e-02f, 1.25060603e-01f, -1.49336264e-01f, 1.77471831e-01f, 9.45747718e-02f,
  1.73176602e-02f, 1.06613033e-01f, -1.46727869e-02f, -1.69299319e-01f, 2.84235179e-02f, -3.05175763e-02f, -2.03782424e-01f, -2.98291091e-02f, -2.54365429e-02f, -1.42345399e-01f,
  -8.95703137e-02f, 2.15264056e-02f, 1.08841330e-01f, 2.34622024e-02f, 4.57085334e-02f, -4.81804274e-02f, 1.64622471e-01f, -3.85005251e-02f, -9.80321988e-02f, 1.51076883e-01f,
  -4.91028875e-02f, -6.75131157e-02f, -5.33895083e-02f, -5.90910576e-02f, -3.63948941e-02f, -1.45974711e-01f, -1.86225176e-01f, -1.95413485e-01f, -1.87338125e-02f, -2.57314947e-02f,
  1.80730924e-01f, -6.64990246e-02f, 6.40024990e-02f, 2.27850266e-02f, -4.44785431e-02f, 2.46963017e-02f, 3.81867327e-02f, 5.56389987e-02f, -4.57768142e-02f, 7.51397833e-02f,
  1.84742808e-02f, -9.77396592e-03f, 6.86539784e-02f, -6.48960993e-02f, 1.64635982e-02f, -4.00412679e-02f, -9.08060931e-03f, 1.32105500e-01f, 8.66517704e-03f, 2.40157060e-02f,
  -7.64989406e-02f, 7.05711916e-02f, -1.74755175e-02f, -9.44596380e-02f, -4.70651425e-02f, -8.48657116e-02f, 1.34223610e-01f, 5.08169131e-03f, -1.46113811e-02f, 6.95234314e-02f,
  -5.28029315e-02f, 9.88916233e-02f, -5.54973669e-02f, -8.84193853e-02f, -4.47805040e-02f, 2.09595069e-01f, -9.03182998e-02f, 1.04070753e-01f, -6.62399083e-02f, 2.07070857e-01f,
  -7.79121220e-02f, -1.18770227e-01f, -1.67401075e-01f, 6.02809489e-02f, 4.61997129e-02f, 3.32521759e-02f, -1.07797295e-01f, -2.83484310e-01f, -1.21557206e-01f, 5.19381762e-02f,
  9.55830980e-03f, 8.26167017e-02f, -1.35466143e-01f, 5.68291061e-02f, 6.81427792e-02f, -6.05150871e-02f, 1.08230330e-01f, -7.32815713e-02f, 9.01734009e-02f, -2.38869309e-01f,
  5.02539910e-02f, 3.96526247e-01f, 3.11376989e-01f, 5.69917142e-01f, -3.15840393e-01f, -6.04214430e-01f, -4.96369660e-01f, 5.07257953e-02f, 3.49114269e-01f, -7.43651018e-02f,
  1.51442317e-02f, 4.34152544e-01f, 1.10112496e-01f, 1.21875238e-02f, -2.40437865e-01f, -7.87177403e-03f, -2.58998275e-01f, -1.91598296e-01f, 2.46496052e-01f, 1.22508936e-01f,
  9.40944850e-02f, 3.06228120e-02f, 2.20727816e-01f, 1.09952930e-02f, -3.64891961e-02f, 2.54712552e-01f, 4.15111631e-01f, 1.07893378e-01f, -1.40620947e-01f, -6.70440048e-02f,
  -2.60571182e-01f, 2.99010903e-01f, 3.85364629e-02f, -3.54400016e-02f, -2.43973490e-02f, -1.58759072e-01f, -1.45477057e-01f, -7.06810737e-03f, -4.81719570e-03f, 1.05128065e-02f,
  4.13825475e-02f, -5.30190170e-02f, 8.24335292e-02f, 1.14209212e-01f, -1.12799376e-01f, 6.49969131e-02f, -1.13771893e-02f, -1.37787610e-01f, 9.06526372e-02f, -1.30654569e-03f,
  -4.77305502e-02f, -7.87130222e-02f, -4.38099541e-03f, 1.15440883e-01f, 1.51090145e-01f, -8.62279758e-02f, -1.55349076e-02f, 2.98760962e-02f, -1.52016748e-02f, 9.26202238e-02f,
  -1.53253943e-01f, 4.61285096e-03f, 1.09255403e-01f, 1.26010925e-01f, 1.76131614e-02f, 1.72463700e-03f, 3.96159627e-02f, -1.69323757e-02f, 5.90571128e-02f, 5.31499647e-02f,
  -9.35379863e-02f, 1.14760004e-01f, -1.31368086e-01f, 1.35408167e-03f, 7.86153898e-02f, 6.79801702e-02f, 3.42318858e-03f, -4.14812975e-02f, -5.58902659e-02f, 7.38856494e-02f,
  1.37715608e-01f, -7.40789920e-02f, 1.07280850e-01f, -2.50375867e-01f, -1.36525974e-01f, 1.38763711e-01f, 5.64555749e-02f, -7.50755444e-02f, 4.47717495e-02f, 2.69264653e-02f,
  -1.19732149e-01f, 5.27613819e-01f, -4.19926494e-02f, -4.74790744e-02f, -5.13788871e-02f, 1.58331692e-02f, 3.63911949e-02f, -2.89511606e-02f, 1.62639111e-01f, -3.18074934e-02f,
  -6.42297491e-02f, -5.41471690e-02f, 2.76421439e-02f, -5.61783016e-02f, -5.38146347e-02f, -1.23464949e-02f, 1.47617877e-01f, 1.83738321e-01f, 8.70645493e-02f, 1.11199901e-01f,
  8.94331560e-02f, -1.56103037e-02f, -2.13278793e-02f, -8.00206140e-02f, -2.33012706e-01f, 8.35634843e-02f, 2.34508188e-03f, -6.78227395e-02f, 2.96300501e-02f, 7.07361698e-02f,
  -7.26514161e-01f, -4.55318153e-01f, 2.58104298e-02f, -2.02676415e-01f, -6.49362337e-03f, 5.80103457e-01f, 4.69562232e-01f, -2.70058870e-01f, -5.73401272e-01f, -4.85305153e-02f,
  1.43692702e-01f, 3.79073732e-02f, 4.09942687e-01f, 3.47480237e-01f, 6.16610110e-01f, 3.52872968e-01f, 2.46931970e-01f, 2.00183958e-01f, -1.82380676e-01f, -3.32458287e-01f,
  -1.45038217e-01f, 2.31674820e-01f, 3.79138052e-01f, -3.73708069e-01f, -1.67138129e-01f, -4.22748864e-01f, 9.60206892e-03f, 1.40787616e-01f, 2.61613637e-01f, 3.42874378e-01f,
  -2.91043580e-01f, -6.92217529e-01f, -4.09950539e-02f, -3.43243554e-02f, -1.20766118e-01f, -1.01972803e-01f, 6.61165118e-02f, 2.22558618e-01f, -1.75190847e-02f, -6.65164813e-02f,
  -4.98005003e-02f, -1.37152866e-01f, -1.11747451e-01f, 2.84930877e-02f, -1.63962215e-01f, -9.98636559e-02f, -2.46988013e-02f, 5.41842654e-02f, -7.65237585e-02f, -8.59922357e-03f,
  7.60155171e-02f, -8.96521062e-02f, -2.64279805e-02f, 2.73596551e-02f, 1.18775815e-01f, -6.71602860e-02f, 7.96544254e-02f, 1.51403621e-01f, 5.30835055e-02f, -8.92215148e-02f,
  9.19602290e-02f, -2.71771773e-04f, 3.52557264e-02f, 1.44258291e-02f, 1.07030660e-01f, 1.95194148e-02f, 1.88274711e-01f, 6.87916130e-02f, 3.54092643e-02f, 9.38674435e-02f,
  1.28954435e-02f, -3.20944190e-02f, -1.59038022e-01f, 8.72474387e-02f, -1.45810368e-02f, -7.97485262e-02f, 1.03883199e-01f, -1.46118626e-01f, -1.39566779e-01f, 8.43071118e-02f,
  2.34294627e-02f, -4.86899614e-02f, 1.13174438e-01f, -4.84910384e-02f, -1.95344742e-02f, 6.82562441e-02f, -1.31970733e-01f, -2.62764748e-02f, -1.74983051e-02f, 1.01473175e-01f,
  -4.91231769e-01f, -5.51914513e-01f, -9.05225333e-03f, -3.67644466e-02f, 1.71736125e-02f, -8.41427073e-02f, -7.70842284e-02f, -1.26999646e-01f, 6.29076327e-04f, -1.38781831e-01f,
  -1.82588294e-01f, 6.36681989e-02f, -5.58149628e-02f, -8.69401470e-02f, 7.31584802e-02f, 3.15727033e-02f, 4.68793325e-03f, -1.00780316e-01f, 3.11196838e-02f, -1.38523400e-01f,
  -9.53879356e-02f, 4.68556769e-03f, 1.29774839e-01f, -6.27744570e-02f, 1.01712914e-02f, 5.34064807e-02f, -2.74467796e-01f, -8.05734396e-02f, 2.07709223e-02f, -5.31280925e-03f,
  -2.64504611e-01f, -1.09281053e-03f, -5.01541734e-01f, -4.22610492e-01f, 1.98855668e-01f, -5.81934810e-01f, -3.85707617e-01f, -1.32150009e-01f, -2.48689637e-01f, 3.70858580e-01f,
  -8.93925726e-02f, -7.76502490e-02f, 6.99574947e-02f, -5.82650840e-01f, -5.26519597e-01f, -3.77797604e-01f, -4.01719421e-01f, -1.89763650e-01f, -7.91889355e-02f, 6.79781847e-03f,
  -1.42296076e-01f, -2.28244379e-01f, -4.84298378e-01f, 2.59673208e-01f, -9.11414549e-02f, 3.00758004e-01f, 3.09694082e-01f, 1.63937643e-01f, -1.71569195e-02f, -1.76230669e-01f,
  -2.85045534e-01f, -5.49657382e-02f, -6.78196028e-02f, -7.02303723e-02f, 1.49147222e-02f, 1.80691466e-01f, 1.55572994e-02f, -5.26838563e-02f, 1.73385325e-03f, -1.02058999e-01f,
  8.55528712e-02f, -2.03104895e-02f, 3.82801257e-02f, 2.27263421e-02f, 9.29419920e-02f, -5.14450967e-02f, -7.39538223e-02f, 1.22867012e-02f, -8.13655406e-02f, -2.22808585e-01f,
  -1.74926683e-01f, -8.24809149e-02f, -4.07242998e-02f, 4.12534326e-02f, 5.43888062e-02f, -3.86917368e-02f, -5.49776517e-02f, 3.46659943e-02f, -2.00380012e-02f, -7.24766776e-02f,
  5.27284741e-02f, 7.12390766e-02f, -1.44840181e-01f, -1.23381233e-02f, -5.92625625e-02f, 1.44359767e-02f, 1.42715042e-02f, 4.46295254e-02f, 1.91589221e-02f, 3.46834809e-02f,
  -3.59002012e-03f, -2.96821538e-02f, -4.44637388e-02f, 1.75405992e-03f, 5.79748629e-03f, 2.58224010e-02f, -1.07314344e-02f, 1.11135706e-01f, -6.86175749e-02f, -8.32447931e-02f,
  -2.81010591e-03f, 1.88916270e-02f, -1.54551603e-02f, 6.47202656e-02f, -1.44188985e-01f, -3.03831063e-02f, 7.93682411e-02f, -5.14732972e-02f, -6.09502420e-02f, 3.26693580e-02f,
  -3.02420277e-02f, 4.42061909e-02f, 4.44411151e-02f, 1.18232489e-01f, 2.48278379e-02f, 1.83383748e-02f, -3.92520651e-02f, -1.07459100e-02f, -1.29102275e-01f, 4.38372567e-02f,
  1.29552677e-01f, 1.53716415e-01f, 1.58702403e-01f, 2.68771220e-02f, 3.62686813e-02f, -9.33358073e-02f, 1.27327293e-01f, 1.50813147e-01f, 7.39233419e-02f, -1.94195919e-02f,
  1.05998822e-01f, 9.77207944e-02f, 5.90872243e-02f, 1.13457413e-02f, 1.22383878e-01f, 9.93360803e-02f, 1.71216913e-02f, 1.44049209e-02f, 7.26691261e-02f, 8.17726478e-02f,
  7.27760717e-02f, 4.63839561e-01f, 1.42896473e-01f, -2.50596493e-01f, 1.08417362e-01f, -6.14019513e-01f, -3.57571214e-01f, 1.60252526e-01f, 1.71503723e-01f, 1.95845693e-01f,
  -4.70881648e-02f, 4.29064393e-01f, 1.52653292e-01f, -1.16504937e-01f, -5.11871219e-01f, -8.58093128e-02f, -5.33008754e-01f, -2.70568937e-01f, 3.26640122e-02f, -1.58382311e-01f,
  -2.58793086e-01f, -1.68345377e-01f, -7.75728747e-02f, 2.13407874e-01f, -6.81011379e-02f, 8.02208483e-02f, -3.61728609e-01f, 2.36464515e-01f, -1.90253109e-01f, 5.88581637e-02f,
  1.74406692e-01f, 3.62610400e-01f, 2.32204556e-01f, 5.39902262e-02f, -1.93243831e-01f, -6.35548234e-02f, -1.13138184e-01f, 7.39617422e-02f, 6.80990070e-02f, -9.83817736e-04f,
  1.65690687e-02f, -2.27858275e-02f, -2.85563767e-02f, 2.14114055e-01f, 1.76836267e-01f, 1.76292166e-01f, 5.38137816e-02f, -5.84586635e-02f, 8.31404179e-02f, 3.46682146e-02f,
  6.90766573e-02f, -4.92329299e-02f, -8.37360993e-02f, -9.83673260e-02f, -1.66901723e-02f, 8.26956108e-02f, -1.93870321e-01f, -4.77731638e-02f, -5.55225350e-02f, 2.64029950e-02f,
  -5.06020933e-02f, -1.87683746e-01f, -7.82851279e-02f, 1.32394433e-01f, 3.17834504e-02f, 2.69773938e-02f, 4.80998345e-02f, 4.95507196e-02f, 7.11905817e-03f, -3.00225802e-02f,
  -1.90558344e-01f, 4.54138592e-02f, 1.18529312e-01f, -1.68601722e-01f, -1.14990182e-01f, 4.75435406e-02f, -9.49019641e-02f, 3.52111720e-02f, -2.28080705e-01f, -9.65321660e-02f,
  1.42600670e-01f, -7.78291672e-02f, 4.54176255e-02f, -8.02718252e-02f, -5.43730408e-02f, 7.84785226e-02f, -8.86497051e-02f, 1.28363132e-01f, -7.22112358e-02f, -1.39114574e-01f,
  -2.36849606e-01f, -1.39012607e-02f, 4.33826372e-02f, 8.87344629e-02f, 9.12379399e-02f, 5.31842932e-02f, -6.35526478e-02f, 1.70230474e-02f, -7.82481954e-02f, 2.13588979e-02f,
  -1.52295738e-01f, -8.81258994e-02f, -1.36800155e-01f, 1.18340746e-01f, -4.39653061e-02f, -1.05650231e-01f, -1.81428716e-01f, -4.33827639e-02f, -1.98677883e-01f, -3.52678001e-02f,
  8.11330319e-05f, -1.42912969e-01f, -3.62808593e-02f, -4.01741751e-02f, -5.94072491e-02f, -5.93869388e-02f, -1.76366847e-02f, 1.80474713e-01f, -1.88327730e-01f, -1.85376659e-01f,
  7.34168172e-01f, 5.05789220e-01f, -7.50948340e-02f, 3.21509421e-01f, 6.89545423e-02f, 4.64573294e-01f, 4.59763438e-01f, -2.18561329e-02f, 5.76175511e-01f, 1.84984088e-01f,
  -2.02937201e-02f, 3.02886039e-01f, -3.56599063e-01f, 5.78177691e-01f, -2.16821536e-01f, -1.53058723e-01f, 4.96084809e-01f, 3.27238619e-01f, 5.99291585e-02f, 2.86803365e-01f,
  4.66917418e-02f, 9.01923478e-02f, -2.88251042e-01f, -1.08113565e-01f, 3.92399728e-01f, -4.65025045e-02f, -5.03119767e-01f, -4.19113070e-01f, -1.21625446e-01f, -9.33816731e-02f,
  7.38623142e-02f, 1.31780252e-01f, 6.90762047e-03f, 1.41640808e-02f, 3.25046331e-02f, -1.74601246e-02f, -1.14538603e-01f, -1.93704218e-01f, -1.73277959e-01f, 2.44734045e-02f,
  1.87072337e-01f, -8.09758902e-02f, 2.43953932e-02f, -1.19533539e-01f, 2.20932856e-01f, 2.36854479e-02f, 1.02605805e-01f, 1.51377572e-02f, 8.92651305e-02f, 8.86674970e-02f,
  2.30711728e-01f, 8.29582885e-02f, 1.79210052e-01f, -1.20302945e-01f, -4.01684307e-02f, -1.98477674e-02f, 7.25861788e-02f, -3.74966785e-02f, 5.56744225e-02f, 1.27093449e-01f,
  -3.58133912e-02f, 6.60298169e-02f, 2.68073697e-02f, 2.61896215e-02f, 4.04889025e-02f, -1.15914069e-01f, 1.61140580e-02f, -1.24449834e-01f, 1.12918364e-02f, 9.54426378e-02f,
  -3.18979364e-05f, -5.85523620e-03f, 1.15767010e-01f, -3.47206462e-03f, 6.72186837e-02f, 1.48328394e-01f, -1.19834803e-01f, -1.23054646e-01f, 3.18515301e-02f, -8.31468496e-03f,
  -1.36153027e-01f, 1.31096035e-01f, 4.33672249e-04f, -6.66604862e-02f, -2.55748965e-02f, -1.37215018e-01f, 2.08672229e-02f, 5.11362627e-02f, 3.91871519e-02f, -3.96260396e-02f,
  7.50434548e-02f, 1.74779594e-01f, 2.58971304e-02f, -8.60826224e-02f, -3.84259000e-02f, 1.31304249e-01f, 3.86473425e-02f, 1.53262690e-01f, 1.86030157e-02f, -2.70863827e-02f,
  2.97065098e-02f, 8.81260484e-02f, -5.41200815e-03f, 5.70993125e-03f, -9.15832743e-02f, 8.32075551e-02f, -8.69582444e-02f, -2.14619115e-02f, -8.06810260e-02f, -5.83878122e-02f,
  1.81455612e-02f, 1.22099124e-01f, 1.22413181e-01f, 1.11770734e-01f, 3.03341951e-02f, -7.60431886e-02f, 1.90994382e-01f, -2.91922484e-02f, -1.30721539e-01f, -4.23193388e-02f,
  -3.54139537e-01f, -1.03841864e-01f, -1.53392747e-01f, -4.27895635e-01f, 2.63985008e-01f, 1.49742112e-01f, -3.43241572e-01f, 1.61404058e-01f, 1.06496345e-02f, 2.74312645e-01f,
  5.57045788e-02f, -3.60418588e-01f, 1.91845298e-01f, -3.92732352e-01f, -4.57114697e-01f, -2.75122732e-01f, -5.01792014e-01f, -4.20500189e-01f, -6.08061161e-03f, -1.95475876e-01f,
  -2.50213295e-01f, -1.56911537e-01f, -2.76637256e-01f, 2.87562191e-01f, -2.03732759e-01f, 5.47670610e-02f, 1.06068246e-01f, 1.82105005e-01f, -2.59780914e-01f, -1.89284787e-01f,
  -2.31287032e-02f, 4.99026552e-02f, -6.59838691e-02f, -7.29413256e-02f, 1.38786193e-02f, -3.86026455e-03f, -4.96265255e-02f, -9.55457091e-02f, 2.21616309e-02f, -6.21152259e-02f,
  -1.03497736e-01f, 9.70131438e-03f, -1.22205712e-01f, -9.19634663e-03f, -3.11222579e-02f, -4.61065434e-02f, -1.57114491e-01f, 1.45201758e-01f, -4.37310599e-02f, -1.82859451e-01f,
  -2.07791165e-01f, -3.42584588e-02f, 1.90099273e-02f, -2.12022606e-02f, -1.26496583e-01f, 5.94607182e-03f, 6.55214638e-02f, -1.66056752e-01f, -2.40168814e-02f, 6.35725930e-02f,
  -9.90351662e-03f, 1.45832688e-01f, -7.63643980e-02f, 1.29007474e-01f, -8.69986117e-02f, 4.40808423e-02f, 4.96455729e-02f, 1.15677774e-01f, -3.74324154e-03f, -5.35211936e-02f,
  1.77309602e-01f, -1.97217446e-02f, -1.33820415e-01f, -2.59299949e-02f, 7.78800920e-02f, -1.31410792e-01f, -1.26758456e-01f, 5.93680106e-02f, -1.36221454e-01f, 1.06936344e-03f,
  -3.39134671e-02f, -7.80133978e-02f, 3.41658257e-02f, 1.62463725e-01f, -7.56565668e-03f, -4.69024573e-03f, 7.95398057e-02f, -1.02038467e-02f, 4.66121100e-02f, -1.38757015e-02f,
  9.43829119e-02f, 2.17876881e-01f, 1.08311787e-01f, 7.94858634e-02f, 4.98363338e-02f, 4.40436378e-02f, 3.76078114e-02f, -1.36872500e-01f, 1.73746552e-02f, -5.23703769e-02f,
  -5.07938676e-02f, -6.88626841e-02f, 1.14245638e-01f, -3.66822891e-02f, 2.87517440e-03f, -6.96329549e-02f, -2.33460348e-02f, 5.56843244e-02f, 1.45083830e-01f, 7.34785646e-02f,
  2.49520149e-02f, 1.27482340e-01f, 1.67467088e-01f, 6.06173240e-02f, 6.00244626e-02f, 3.26418094e-02f, 9.76905003e-02f, -1.78850502e-01f, -4.74766381e-02f, 1.26283497e-01f,
  -1.26902740e-02f, 7.37421541e-03f, 1.30547946e-02f, -2.38142442e-02f, -6.18512213e-01f, -6.91566244e-02f, -6.11985847e-02f, -3.14568818e-01f, 3.91145676e-01f, 2.38974527e-01f,
  -3.27299267e-01f, 1.31874934e-01f, 2.57116258e-01f, -7.15426430e-02f, 3.74967515e-01f, 6.89628720e-01f, 1.20742150e-01f, 2.37283662e-01f, -1.50290560e-02f, -2.60649711e-01f,
  -1.29560769e-01f, -4.42208767e-01f, -2.07398415e-01f, -4.48501140e-01f, -5.91222525e-01f, -2.24259719e-01f, -2.79431522e-01f, -3.36369038e-01f, -3.74024391e-01f, -2.24642411e-01f,
  -3.61101061e-01f, -3.27958107e-01f, -8.35477188e-02f, 1.95676714e-01f, -8.63708034e-02f, 3.10591143e-02f, -7.79776946e-02f, -1.02918930e-01f, -1.32749617e-01f, -4.87340614e-02f,
  2.35787407e-01f, -9.10583213e-02f, -8.72877315e-02f, 1.46230504e-01f, -1.00153293e-02f, -7.94614404e-02f, -1.54753044e-01f, 3.43558714e-02f, -8.03980827e-02f, -1.50527610e-02f,
  6.21665455e-02f, -2.15627607e-02f, 4.14875410e-02f, 3.11213762e-01f, -1.20725803e-01f, -7.46592060e-02f, 1.71887055e-01f, 2.29972005e-02f, 4.98930775e-02f, -1.27330989e-01f,
  -2.25268099e-02f, 1.06427036e-02f, 2.40386892e-02f, -7.13210925e-02f, -5.99441007e-02f, -1.56143576e-01f, 4.67818305e-02f, 1.39062116e-02f, 1.12020425e-01f, -1.76384337e-02f,
  1.53205646e-02f, -7.50576481e-02f, 1.11256458e-01f, 1.38266921e-01f, -6.14911728e-02f, 2.30468273e-01f, 9.98522788e-02f, 7.67922029e-02f, 1.20779037e-01f, -5.66346161e-02f,
  -6.34058416e-02f, 5.03770001e-02f, -1.00246482e-01f, -1.53593849e-02f, -1.32965386e-01f, -1.03019610e-01f, 4.91403230e-02f, 1.35026485e-01f, 1.27275527e-01f, -1.30079612e-01f,
  -2.44513139e-01f, -1.57897137e-02f, -1.97403654e-01f, -5.05453274e-02f, 2.71026082e-02f, -1.43907815e-02f, 1.33958206e-01f, -1.25300267e-03f, -1.54666021e-01f, 1.52430370e-01f,
  7.85449296e-02f, 7.05801770e-02f, 7.85164684e-02f, -2.05244217e-02f, 8.29890892e-02f, -1.20467618e-02f, -1.29994331e-02f, 1.45434335e-01f, -1.80128545e-01f, -1.27214402e-01f,
  6.67569786e-02f, 3.83635201e-02f, 6.87206686e-02f, -2.73015145e-02f, 1.07121862e-01f, -7.64962658e-02f, 7.30513260e-02f, -3.02875787e-02f, -8.44128579e-02f, 2.54151784e-02f,
  -5.39882541e-01f, 8.95052329e-02f, -6.06041014e-01f, -2.84641206e-01f, 1.72465265e-01f, -6.49586141e-01f, -3.02193671e-01f, -4.20404188e-02f, -8.51402134e-02f, 4.32969749e-01f,
  1.93277285e-01f, -2.66802669e-01f, 2.58741736e-01f, -3.82724166e-01f, -5.83083451e-01f, 5.44612249e-03f, -4.72853959e-01f, -2.65695602e-01f, -6.91595897e-02f, -2.39968091e-01f,
  -2.11005628e-01f, 2.23375559e-01f, -2.75908977e-01f, 3.67516696e-01f, -2.00800046e-01f, -2.85873394e-02f, 4.94602084e-01f, 3.52865726e-01f, -2.32307509e-01f, 1.57179199e-02f,
  -1.10424444e-01f, 1.04874425e-01f, 7.06682354e-03f, -4.99799997e-02f, -3.02823875e-02f, 1.09636262e-01f, -1.50992321e-02f, -1.89235508e-02f, 1.69279501e-02f, -3.96351442e-02f,
  -6.00680429e-03f, -1.22549413e-02f, -1.54419273e-01f, 6.32428750e-02f, -5.49161509e-02f, 1.38573602e-01f, -7.72590041e-02f, -1.19363785e-01f, 9.26127285e-03f, -1.51604846e-01f,
  -7.73362443e-02f, -2.16936916e-01f, -1.36923254e-01f, 3.62927793e-03f, -1.14506878e-01f, 1.18508749e-03f, -1.86143234e-01f, -1.68276504e-02f, -6.55555278e-02f, -7.22304508e-02f,
  -9.91264880e-02f, -4.90773767e-02f, 9.85111222e-02f, 1.39767274e-01f, 1.57193269e-03f, 9.28439200e-02f, 4.88274954e-02f, 2.21423190e-02f, 8.75724703e-02f, -1.70144066e-02f,
  -6.63289204e-02f, 2.52454039e-02f, 1.21839248e-01f, 8.92833248e-03f, -7.51532242e-02f, -5.18171676e-02f, -1.07374251e-01f, -1.69498418e-02f, -2.62455139e-02f, 1.05681298e-02f,
  1.21023357e-01f, -8.77081305e-02f, 3.61759029e-02f, 2.67153513e-02f, 4.85059433e-02f, 4.19444442e-02f, -3.75639349e-02f, -6.10513613e-02f, -3.61721441e-02f, -5.33172153e-02f,
  1.43376514e-01f, 9.37430337e-02f, 1.49014711e-01f, 5.70402406e-02f, 6.26798421e-02f, 1.84890088e-02f, -7.20909983e-02f, -1.13319695e-01f, 2.27725394e-02f, 2.27120873e-02f,
  3.69517095e-02f, -1.73018239e-02f, 1.70762166e-02f, -2.48153545e-02f, -5.48916012e-02f, 5.68825975e-02f, 1.09088179e-02f, -2.87648719e-02f, 6.44654632e-02f, -4.39291671e-02f,
  1.76152766e-01f, 1.24715716e-01f, -3.24965194e-02f, 4.28880379e-02f, 4.26941253e-02f, 5.12956381e-02f, 8.25711936e-02f, 4.54669036e-02f, 2.79751662e-02f, 5.56414239e-02f,
  6.87806547e-01f, -2.38198385e-01f, -3.69843602e-01f, 4.65895116e-01f, 1.78556174e-01f, 1.55496046e-01f, 2.90508538e-01f, 3.19882393e-01f, 5.06180406e-01f, 8.09620246e-02f,
  4.23090845e-01f, -5.51446974e-01f, -1.67621195e-01f, 4.31484312e-01f, -9.23054218e-02f, 1.80895686e-01f, 2.72107750e-01f, 3.31535265e-02f, 2.07024649e-01f, -4.20113979e-03f,
  2.32185826e-01f, 2.96996742e-01f, -2.79526800e-01f, -1.79322809e-01f, 1.68985561e-01f, -1.21106289e-01f, -3.26861054e-01f, -2.99838871e-01f, -2.67233253e-01f, -2.05547377e-01f,
  2.92579293e-01f, 4.12887365e-01f, 4.88036200e-02f, 4.59817648e-02f, 1.19486839e-01f, 4.81254570e-02f, -1.83540851e-01f, -1.82149231e-01f, 1.93862319e-02f, 1.39441073e-01f,
  -1.38730139e-01f, -1.07062958e-01f, 1.08862519e-01f, -2.06066873e-02f, 6.17657155e-02f, 3.05879209e-02f, 6.11665994e-02f, 1.49046883e-01f, -1.24037936e-01f, -1.71963163e-02f,
  3.13582048e-02f, 1.05458521e-03f, 9.36040506e-02f, -9.07960087e-02f, -6.32220879e-02f, 3.05790436e-02f, -2.04418734e-01f, -2.06238762e-01f, -1.67541444e-01f, 1.52921364e-01f,
  -1.03636660e-01f, 1.17015243e-01f, 1.27760366e-01f, 1.20568201e-01f, 5.22138737e-02f, 7.90933594e-02f, -2.57690847e-02f, -5.86874709e-02f, 3.87349017e-02f, -7.94766992e-02f,
  -5.90471476e-02f, 1.04462445e-01f, 1.02803931e-01f, -3.72513756e-02f, 1.87870324e-01f, 1.23539403e-01f, -1.83122680e-01f, -4.20479886e-02f, 1.25940278e-01f, -3.20795327e-02f,
  7.86092281e-02f, 1.09374579e-02f, 8.40497240e-02f, 2.14493927e-02f, -3.74558233e-02f, -4.57564481e-02f, 3.12138312e-02f, 3.79232019e-02f, 3.62414159e-02f, -1.54369608e-01f,
  -1.04644299e-01f, -3.04920048e-01f, 8.82429183e-02f, 2.94072018e-03f, -2.09780633e-01f, 1.14151068e-01f, 5.41601628e-02f, 3.76406237e-02f, -6.35415837e-02f, 1.24317192e-01f,
  -6.08157478e-02f, 8.61744881e-02f, -1.10879868e-01f, -5.66947646e-03f, -4.99221496e-02f, 6.81287050e-02f, -9.07147378e-02f, 5.18376790e-02f, -2.01396629e-01f, -1.58601955e-01f,
  -1.40269041e-01f, -2.46999878e-02f, -8.52073580e-02f, 2.22203836e-01f, -1.39236659e-01f, -1.02166822e-02f, -1.02290176e-01f, -5.97179458e-02f, -1.16410650e-01f, -1.07202709e-01f,
  1.33095279e-01f, -1.42394518e-02f, -4.36080813e-01f, -9.94859636e-03f, 6.95169494e-02f, 2.98826933e-01f, 6.10274933e-02f, 5.77297732e-02f, -2.80402184e-01f, 3.53806406e-01f,
  2.99818724e-01f, -1.72708139e-01f, -2.60566562e-01f, 6.25140965e-01f, 2.40339503e-01f, 4.01422866e-02f, 3.97074878e-01f, 3.86111051e-01f, -1.00271337e-01f, 6.44797236e-02f,
  1.73860360e-02f, 6.21417284e-01f, -5.45057794e-03f, 2.30768323e-01f, 2.21502706e-01f, -3.10935855e-01f, 1.40910476e-01f, -4.26290035e-01f, 3.67207915e-01f, 1.60631880e-01f,
  1.29539609e-01f, -4.67054807e-02f, -8.74881446e-02f, 6.30519539e-02f, 6.26785904e-02f, 5.14058992e-02f, -3.91058298e-03f, -7.40438178e-02f, -1.49845868e-01f, -7.41510391e-02f,
  -5.88029847e-02f, -8.66184682e-02f, 2.38316074e-01f, -7.04934150e-02f, 5.34931943e-02f, 7.53041804e-02f, -1.60814002e-02f, -7.21833110e-02f, -6.61621317e-02f, -9.22997743e-02f,
  -2.28854671e-01f, 8.78051817e-02f, -3.28545347e-02f, 1.01597002e-02f, -1.66454196e-01f, -2.64960490e-02f, -6.79967925e-02f, -9.11559388e-02f, 1.34518445e-01f, 1.08848378e-01f,
  5.15890494e-02f, 4.03165221e-02f, 4.58315164e-02f, 1.47535190e-01f, 9.05297101e-02f, 9.21764076e-02f, -5.15337044e-04f, -7.58661283e-03f, -6.36590421e-02f, 2.11954098e-02f,
  -1.05202878e-02f, -3.41145135e-02f, -1.57671142e-02f, 5.64328674e-03f, 4.53234725e-02f, 7.20466673e-02f, -9.30681601e-02f, 2.68657263e-02f, -1.26846731e-02f, 2.80114543e-02f,
  -1.38945714e-01f, -4.93587693e-03f, 2.83716377e-02f, 3.07064429e-02f, 1.26532555e-01f, -6.32924661e-02f, 1.54877916e-01f, 2.45205797e-02f, -2.86181159e-02f, -2.49633081e-02f,
  1.00821771e-01f, 1.31960556e-01f, 3.44853327e-02f, 3.90674621e-02f, 8.49111527e-02f, 6.29311055e-02f, 1.14218973e-01f, 6.20221160e-02f, -7.39554781e-03f, 5.17633790e-03f,
  1.17639199e-01f, -1.11042848e-03f, 9.15930495e-02f, 4.44711745e-03f, 2.78960541e-02f, 4.49662730e-02f, -4.98744920e-02f, -1.68130808e-02f, -1.06181726e-02f, 1.58346921e-01f,
  8.42469484e-02f, 8.12835933e-04f, -5.25778495e-02f, 6.78325891e-02f, 1.59802064e-01f, 5.23758605e-02f, 5.56963459e-02f, -4.11072820e-02f, 9.49432179e-02f, -4.43196744e-02f,
  6.58583283e-01f, -8.80595386e-01f, 2.43989944e-01f, 5.94832778e-01f, 3.76132309e-01f, 1.10240743e-01f, 3.90595466e-01f, 3.00901793e-02f, 2.70121992e-01f, -5.81789553e-01f,
  -8.10947493e-02f, -2.25450292e-01f, -3.79851788e-01f, 9.05860588e-02f, 5.50083160e-01f, -1.07064262e-01f, 1.68251038e-01f, 1.17567427e-01f, 2.33179405e-01f, -7.70534128e-02f,
  3.60027522e-01f, 8.74519423e-02f, 2.22335413e-01f, -1.16919614e-01f, -5.78461289e-02f, -7.50405574e-03f, 6.51995689e-02f, 1.98216401e-02f, 7.82758966e-02f, 1.02104641e-01f,
  -2.73546189e-01f, 4.32062559e-02f, -6.69923425e-02f, -7.79423788e-02f, 1.49274373e-03f, -6.42165616e-02f, 1.98093075e-02f, 1.27671346e-01f, 1.73668876e-01f, -8.69403500e-03f,
  -8.52305293e-02f, 8.64506736e-02f, 6.09271824e-02f, 5.39285950e-02f, -4.95136995e-03f, 9.53139812e-02f, -6.33311123e-02f, -7.55295232e-02f, -6.00523269e-03f, -1.32750738e-02f,
  -2.05945019e-02f, -2.40084119e-02f, 2.30037216e-02f, -7.08045810e-02f, 5.42490222e-02f, 3.66466828e-02f, 1.65840775e-01f, -6.25349358e-02f, -1.70804709e-01f, 9.98199061e-02f,
  6.58117160e-02f, -9.36020748e-04f, -9.65837911e-02f, -2.81074690e-03f, 4.24286947e-02f, 9.22522172e-02f, 2.26387810e-02f, -3.28296907e-02f, -4.86799292e-02f, -7.82295391e-02f,
  1.32248187e-02f, -4.88281213e-02f, -5.37940189e-02f, -3.80460657e-02f, 4.27317061e-02f, 2.49238238e-02f, 3.48873399e-02f, -3.73389684e-02f, -1.15464572e-02f, 9.70029309e-02f,
  -6.69008344e-02f, 6.79806471e-02f, -8.08532462e-02f, 4.59070466e-02f, 3.12359701e-03f, -9.69329998e-02f, -3.50262225e-02f, -1.50024574e-02f, -1.14045637e-02f, -2.89674588e-02f,
  -8.24257314e-01f, -5.52126706e-01f, -8.99854526e-02f, -5.31925000e-02f, -4.25345972e-02f, -4.87992205e-02f, 7.78740495e-02f, 4.06314284e-02f, -1.08086690e-01f, 9.49495509e-02f,
  -6.24381714e-02f, 1.02018714e-01f, -1.12899475e-01f, 1.26049489e-01f, -7.87823126e-02f, -5.99999130e-02f, 7.83048687e-04f, -1.66650981e-01f, -1.61087751e-01f, -1.91367138e-02f,
  -6.14981316e-02f, -2.68978290e-02f, 6.72184303e-02f, 5.20216189e-02f, -1.63939479e-03f, 2.09334940e-02f, -6.18372075e-02f, 7.56952688e-02f, 3.29448539e-03f, -6.85659647e-02f,
  -6.76812828e-01f, 4.84539807e-01f, 3.12670857e-01f, -4.15222406e-01f, 4.89600182e-01f, 3.60657424e-01f, -5.88522069e-02f, 4.20823604e-01f, 4.38588113e-02f, -2.77112890e-02f,
  -1.76665056e-02f, -1.81559920e-01f, 3.65519762e-01f, -1.16726935e-01f, -9.64592397e-02f, 1.30283773e-01f, -1.70376584e-01f, -3.49197298e-01f, 2.86094427e-01f, -3.86215821e-02f,
  -4.96990979e-03f, 1.30775750e-01f, 1.19804248e-01f, 4.97013092e-01f, 1.88987628e-01f, -1.48955613e-01f, -2.24678323e-01f, 3.97119701e-01f, -1.49591535e-01f, 1.46631122e-01f,
  -5.25580347e-02f, -1.33494273e-01f, 1.56164289e-01f, 1.29542634e-01f, 5.20451404e-02f, -8.59022364e-02f, -1.35127515e-01f, 9.58950147e-02f, -7.09199384e-02f, 2.73748906e-03f,
  7.31854960e-02f, 5.97381778e-02f, -4.08178456e-02f, 9.08588171e-02f, 1.13706589e-01f, 6.37578070e-02f, 1.48060635e-01f, 1.57570586e-01f, 2.14824170e-01f, 1.04435049e-01f,
  2.01962665e-01f, 1.54238930e-02f, 3.43532376e-02f, -6.26702979e-02f, 1.59721166e-01f, 4.78653014e-02f, -1.24557659e-01f, -4.12113592e-02f, 2.37078071e-02f, -7.69406855e-02f,
  -6.61438778e-02f, -6.97311014e-02f, 5.02884155e-03f, 3.11930086e-02f, 9.85242277e-02f, 3.76469120e-02f, -5.02346046e-02f, -8.46236423e-02f, -1.00061893e-01f, 5.63750826e-02f,
  -4.26672362e-02f, -2.60726940e-02f, 5.86206540e-02f, -1.52599037e-01f, -6.85734749e-02f, -9.53663960e-02f, -1.27027497e-01f, -1.57426983e-01f, -2.16183905e-02f, -1.48080783e-02f,
  -1.16763890e-01f, -6.78876117e-02f, 5.06812707e-02f, -2.59424336e-02f, 8.85829329e-02f, 5.50706536e-02f, 9.21530128e-02f, 2.81719305e-02f, 2.72519607e-02f, 2.23784451e-03f,
  -2.32263744e-01f, -4.87971723e-01f, 7.41634071e-02f, -2.96625644e-02f, -1.50803089e-01f, 9.00459141e-02f, 7.68087655e-02f, -4.45387848e-02f, 5.96416667e-02f, -3.23825479e-02f,
  -4.99453805e-02f, -6.28567114e-02f, -1.73217982e-01f, -7.07557276e-02f, -1.26677111e-01f, 1.61396846e-01f, -1.92407444e-01f, -1.59149736e-01f, -4.90639657e-02f, -1.12125181e-01f,
  2.41313167e-02f, -1.15897693e-01f, -1.14339218e-01f, 6.77354261e-02f, -1.27199173e-01f, -1.07406259e-01f, -1.37824088e-01f, -2.86301654e-02f, -4.94743139e-02f, 8.55306312e-02f,
  -5.84206730e-02f, 6.48716271e-01f, 1.73759192e-01f, -3.55205208e-01f, -6.13537394e-02f, -3.28748941e-01f, -4.79724944e-01f, -1.21180229e-01f, -1.95881292e-01f, -1.09582648e-01f,
  -3.48260462e-01f, 3.03615570e-01f, 3.22081447e-02f, -2.26583570e-01f, -2.39021778e-01f, 9.24536306e-03f, -4.34080988e-01f, -1.35082141e-01f, 2.44294763e-01f, -1.76058367e-01f,
  -6.36539012e-02f, -5.29886723e-01f, -2.54370389e-04f, -1.36146113e-01f, -2.00137824e-01f, 1.53390720e-01f, -1.60094336e-01f, -2.19445303e-02f, -1.48427129e-01f, 1.18029475e-01f,
  -3.92005056e-01f, -2.62992978e-01f, -1.22072890e-01f, 7.27007315e-02f, -1.72837928e-01f, -1.61502864e-02f, 2.82473210e-02f, -3.04048248e-02f, -1.33118913e-01f, 3.01260632e-02f,
  1.57257617e-01f, -2.08781026e-02f, -1.33949947e-02f, 1.39996663e-01f, -7.34385177e-02f, 8.30446258e-02f, 9.61897075e-02f, 4.06762436e-02f, 1.64726060e-02f, 1.82089046e-01f,
  1.20913669e-01f, 2.09769219e-01f, -1.14783995e-01f, 9.08958167e-02f, 8.33072513e-02f, -1.17253117e-01f, 5.61035872e-02f, 1.52275249e-01f, 6.14995547e-02f, 1.85729600e-02f,
  -6.71769632e-03f, -3.11688930e-02f, 1.27218336e-01f, -1.08257949e-01f, -1.90914467e-01f, 1.41183641e-02f, 1.59825515e-02f, 9.21197906e-02f, -4.58667912e-02f, -8.27982128e-02f,
  -2.03946512e-02f, 1.32243946e-01f, -8.87174532e-02f, -1.08356051e-01f, 4.01329435e-02f, -1.54258339e-02f, -3.30924615e-02f, -1.19227506e-02f, -2.29145810e-02f, -2.62588579e-02f,
  -1.22656347e-02f, -1.76539253e-02f, 3.50718237e-02f, 5.32237478e-02f, 5.61187081e-02f, -1.00166149e-01f, -5.00517674e-02f, 1.27564579e-01f, -1.51492521e-01f, -6.08024225e-02f,
  -7.12054610e-01f, -8.00060630e-01f, -1.15060449e-01f, -3.67912389e-02f, -1.08583152e-01f, -1.79841369e-02f, -2.47945031e-03f, 8.31960440e-02f, -2.20481843e-01f, -2.19612986e-01f,
  -1.18508741e-01f, 1.50249135e-02f, -1.24014020e-01f, -6.38412610e-02f, 4.42087650e-02f, -1.51618376e-01f, -8.41112211e-02f, -7.96637088e-02f, -1.51897565e-01f, 3.46817560e-02f,
  -9.79866162e-02f, -1.00797489e-01f, 6.22698329e-02f, -1.81594566e-02f, 3.05534266e-02f, -8.83100107e-02f, -6.83465526e-02f, 2.12541446e-01f, -8.16775113e-02f, -3.23873647e-02f,
  3.51895571e-01f, 2.00041205e-01f, -1.01433091e-01f, -1.15601906e-04f, -1.24921627e-01f, 9.42705795e-02f, -4.02142286e-01f, -2.44536661e-02f, -2.92089641e-01f, 9.91158858e-02f,
  -1.07918754e-01f, 2.40147993e-01f, -5.05018473e-01f, 2.47029424e-01f, -1.57946214e-01f, -4.83220100e-01f, 4.60379303e-01f, 9.73067582e-02f, -1.56143665e-01f, 3.35563749e-01f,
  -1.25259891e-01f, 2.61896074e-01f, -2.81066120e-01f, 2.52637476e-01f, 3.68152857e-01f, 3.11694562e-01f, 2.77140260e-01f, -2.30032895e-02f, 5.89936912e-01f, 1.45120814e-01f,
  -4.51962389e-02f, 2.21790262e-02f, 2.36874353e-02f, -3.87042426e-02f, 5.13845645e-02f, -5.30829169e-02f, 3.30879129e-02f, -8.02140832e-02f, -1.02100067e-01f, 3.85555215e-02f,
  2.25396585e-02f, 8.19673687e-02f, 4.26710546e-02f, 2.05000471e-02f, 3.51080671e-04f, 5.25650755e-02f, -5.70359938e-02f, -1.20430037e-01f, 1.40682049e-02f, 5.89251965e-02f,
  -1.30384609e-01f, -3.88406254e-02f, 1.11401200e-01f, 5.00952564e-02f, 6.50985260e-03f, 1.06645040e-01f, 5.71477301e-02f, 1.14804789e-01f, 2.02452973e-01f, 2.22935915e-01f,
  4.34975438e-02f, 6.34643435e-02f, 7.67761245e-02f, -9.52791125e-02f, 6.36621639e-02f, -2.70729270e-02f, -9.85185057e-02f, -3.45673598e-03f, 7.06030056e-03f, 6.72015455e-03f,
  -9.01154354e-02f, 4.81359921e-02f, 2.12548370e-03f, 6.96161240e-02f, 1.42163247e-01f, -8.08107108e-02f, -1.26925781e-01f, 1.08057238e-01f, -8.25929865e-02f, -1.20179988e-01f,
  -6.47332966e-02f, 5.91782555e-02f, 8.79287496e-02f, -3.54038738e-02f, -1.02037035e-01f, -8.28477740e-02f, 2.08127826e-01f, 7.51392692e-02f, -1.34727359e-01f, -1.00446291e-01f,
  1.27082974e-01f, 2.39512354e-01f, -5.29744066e-02f, -8.39918852e-03f, -6.91528693e-02f, 1.15579635e-01f, 5.58105595e-02f, 3.74266990e-02f, 1.76203668e-01f, 7.24104494e-02f,
  1.02362089e-01f, -1.38313472e-01f, 1.31608129e-01f, -6.55387715e-02f, -1.38762919e-02f, 1.35553494e-01f, 3.36626731e-02f, -4.29189727e-02f, 2.50683911e-03f, 1.61607966e-01f,
  3.85260098e-02f, -1.21038698e-01f, 8.35377797e-02f, -1.08542837e-01f, 6.24669231e-02f, 4.97832820e-02f, 1.08122237e-01f, 3.82416649e-03f, -4.37906161e-02f, 1.60010114e-01f,
  2.66944587e-01f, 3.83236110e-01f, 2.52861738e-01f, 3.61360967e-01f, -1.95069537e-01f, -4.21024710e-01f, -2.86716729e-01f, 5.64054996e-02f, 1.91866517e-01f, 1.57882765e-01f,
  -2.76525855e-01f, 5.01835227e-01f, -2.37916216e-01f, -2.79365718e-01f, -3.44811022e-01f, -4.61930543e-01f, 2.82882210e-02f, -1.63445380e-02f, 2.51871441e-02f, 3.98522198e-01f,
  2.47439682e-01f, -3.41308862e-01f, 1.35159150e-01f, -1.24613279e-02f, 2.13923126e-01f, 4.11590427e-01f, 1.75650731e-01f, -3.21095586e-02f, 2.22250134e-01f, -4.56582725e-01f,
  -1.27261311e-01f, 1.30128711e-01f, 1.41028687e-01f, -5.87616302e-02f, 2.09715471e-01f, -4.10747379e-02f, -3.10549960e-02f, -2.35321805e-01f, 1.11836791e-02f, 2.77657341e-02f,
  6.60530180e-02f, 5.04428856e-02f, -8.09015334e-03f, -1.32819831e-01f, -4.75043394e-02f, 1.20540313e-01f, 3.72166629e-03f, 1.99619472e-01f, -4.21568155e-02f, 3.13847861e-03f,
  1.91504985e-01f, 1.65468082e-01f, 1.43754601e-01f, 1.06183529e-01f, 1.18374832e-01f, -7.24428594e-02f, 1.17491879e-01f, 1.02080263e-01f, 2.52521294e-03f, 8.67225677e-02f,
  8.06991756e-02f, 1.22957360e-02f, -4.79757339e-02f, -1.20737091e-01f, -2.53627019e-04f, 3.78741473e-02f, -2.68066060e-02f, -1.55097321e-01f, -6.54410059e-03f, 3.46535444e-02f,
  3.27209738e-04f, -7.50642549e-03f, -2.36690566e-01f, 8.48000646e-02f, 1.25762329e-01f, -1.37049761e-02f, -5.72661161e-02f, 1.16793230e-01f, 1.70945764e-01f, 8.25767592e-02f,
  -1.56159267e-01f, -1.40654579e-01f, 3.92052568e-02f, -3.57483700e-02f, -2.83033371e-01f, 5.19523174e-02f, 5.06533980e-02f, 6.91801161e-02f, -6.83170557e-02f, -1.62425209e-02f,
  1.50684610e-01f, 3.11964959e-01f, 1.91917896e-01f, -5.28166927e-02f, 1.10612484e-02f, -5.61667569e-02f, -2.46404707e-01f, 5.68474308e-02f, 7.40690157e-02f, -1.07904106e-01f,
  2.18937546e-01f, 7.92347118e-02f, -1.46858711e-02f, -1.19170532e-01f, -3.44505608e-02f, 9.80235040e-02f, 4.52126563e-02f, 1.21746987e-01f, 1.40109733e-01f, 1.27039045e-01f,
  2.17931136e-01f, 1.24264069e-01f, 3.42452079e-02f, 1.08636238e-01f, 9.03721079e-02f, 1.48522645e-01f, 9.21768695e-02f, 1.10384829e-01f, 1.11346389e-03f, 1.19125498e-02f,
  4.68982100e-01f, -5.57411313e-01f, -2.75762707e-01f, -1.85160324e-01f, 1.17499672e-01f, -7.60777220e-02f, 1.30281121e-01f, -5.33405781e-01f, -3.05748791e-01f, -4.14319068e-01f,
  -1.94416437e-02f, 1.93521440e-01f, 1.44864500e-01f, -3.02001834e-01f, 7.76077867e-01f, 2.52473384e-01f, -3.11252415e-01f, -2.52169799e-02f, -6.61356524e-02f, -2.12319881e-01f,
  1.42483145e-03f, -5.59322312e-02f, -6.73161820e-02f, -4.02463108e-01f, -1.63335904e-01f, -2.64297277e-01f, 1.09862588e-01f, 1.69610277e-01f, -2.63542145e-01f, 3.48694086e-01f,
  -8.61648296e-04f, -1.11310504e-01f, -2.69704331e-02f, -1.16061384e-03f, -2.76324712e-02f, 6.45874441e-02f, 9.70085487e-02f, 2.84574509e-01f, 3.84848714e-02f, -8.95263329e-02f,
  9.31430981e-02f, 1.98304057e-01f, -1.91046953e-01f, 2.52942979e-01f, -2.35865954e-02f, -1.57319903e-01f, -5.72579093e-02f, -8.79635811e-02f, -8.94809142e-02f, 3.52972856e-04f,
  8.99139792e-04f, -1.30045176e-01f, -1.65065918e-02f, 1.19812964e-02f, -5.74616194e-02f, 2.77534351e-02f, -2.18077451e-02f, 1.15807941e-02f, -6.60617352e-02f, -7.23827109e-02f,
  -1.81137268e-02f, 1.45080239e-01f, -1.35222822e-02f, 3.72012183e-02f, 6.34075329e-02f, -3.33224535e-02f, -6.78377897e-02f, -2.24848166e-02f, 4.35211584e-02f, 2.52409913e-02f,
  1.63208582e-02f, -9.29066166e-02f, -6.38042688e-02f, -7.12438077e-02f, 2.51046382e-02f, -2.41285358e-02f, 1.05953708e-01f, 1.70030929e-02f, -6.52050078e-02f, -1.02426827e-01f,
  5.95218092e-02f, -2.84946095e-02f, -2.94728596e-02f, 3.36675718e-02f, 3.93098481e-02f, 1.22711271e-01f, -1.26004815e-01f, -1.09894909e-01f, -4.35501263e-02f, 1.77905466e-02f,
  -1.41001418e-01f, -3.13742012e-01f, -9.09134224e-02f, -4.83004525e-02f, 2.65906546e-02f, -1.70172844e-02f, -1.09171905e-02f, -1.25302240e-01f, -4.55466844e-02f, -2.21716929e-02f,
  -1.23191744e-01f, 6.35540560e-02f, -1.38076305e-01f, 7.23343268e-02f, -2.74021877e-03f, -2.26521477e-01f, 4.59969789e-02f, -5.55393659e-03f, -3.11265495e-02f, -9.08953473e-02f,
  3.99239478e-04f, -6.25176588e-03f, 1.70056403e-01f, -6.41045868e-02f, -1.48158357e-01f, 1.39615685e-01f, 5.07683344e-02f, -2.11857110e-02f, -2.28133169e-03f, -9.04267579e-02f,
  -4.33608383e-01f, 2.28431225e-01f, -2.06103668e-01f, -4.83807802e-01f, 2.76172042e-01f, 2.35280216e-01f, 1.92083288e-02f, 4.83951390e-01f, 2.26387382e-01f, 6.54433370e-02f,
  -1.09184913e-01f, -2.92676002e-01f, 3.45032841e-01f, -4.02418137e-01f, -3.19137454e-01f, 1.86283384e-02f, -3.39995593e-01f, -3.27519506e-01f, 3.90352845e-01f, -1.32578462e-01f,
  5.53630553e-02f, -2.77623385e-01f, -2.17918471e-01f, 3.44158858e-01f, -1.63006604e-01f, 1.64712220e-01f, -2.75921613e-01f, 2.58713424e-01f, -3.55965436e-01f, 2.95882691e-02f,
  -1.79798566e-02f, 1.03600599e-01f, 1.03152312e-01f, 8.39343891e-02f, -1.39916930e-02f, -4.63703759e-02f, -9.20123160e-02f, -9.73725226e-03f, 6.15958171e-03f, 7.41697997e-02f,
  -9.09502357e-02f, -2.19340362e-02f, 2.08388548e-02f, 1.15500800e-01f, 7.52484947e-02f, -1.41495332e-01f, -9.48402509e-02f, -7.96936452e-02f, -1.01227162e-03f, -7.10584447e-02f,
  -1.42954379e-01f, -3.64193730e-02f, -1.56526223e-01f, -1.42009780e-01f, -2.68279109e-02f, 1.79162230e-02f, -3.53105459e-03f, -2.58330733e-01f, -6.26975447e-02f, -1.26604259e-01f,
  7.07954308e-03f, 1.80222973e-01f, 4.34794165e-02f, 1.52050229e-02f, -3.16453055e-02f, 3.65477316e-02f, -5.70955090e-02f, -4.61913198e-02f, 1.29024103e-01f, -8.17767996e-03f,
  -4.12577391e-02f, 4.62602563e-02f, 6.01909384e-02f, -2.31290217e-02f, -1.93848848e-01f, 9.69031360e-04f, -8.36493447e-02f, -8.46246928e-02f, 1.10786678e-02f, -4.88926470e-02f,
  1.56242952e-01f, -4.36730087e-02f, -1.23060487e-01f, 6.58516735e-02f, -5.44001954e-03f, 4.68047224e-02f, 1.79954529e-01f, -2.70915359e-01f, 8.37915167e-02f, 1.58098377e-02f,
  2.50937045e-02f, 1.38223842e-01f, 1.95961297e-01f, 1.46261781e-01f, 8.88276324e-02f, 2.49310955e-02f, -5.62335216e-02f, 4.04723771e-02f, -1.02041870e-01f, 1.68756917e-01f,
  4.87463847e-02f, 3.04361396e-02f, -4.16632220e-02f, -7.21065626e-02f, 5.17129600e-02f, -1.49608210e-01f, -2.24784955e-01f, 6.68074414e-02f, -3.16310562e-02f, 1.10713437e-01f,
  -2.38123592e-02f, 1.04469776e-01f, -1.43730789e-01f, 5.57888336e-02f, -1.65333953e-02f, -1.28223196e-01f, 4.72130328e-02f, 7.31184930e-02f, -2.94800103e-02f, 5.11603802e-02f,
  6.13080800e-01f, -6.54023170e-01f, 3.78786325e-01f, 6.79588258e-01f, 3.60639721e-01f, -3.58391315e-01f, 2.42526129e-01f, 9.44425985e-02f, 4.22473609e-01f, -5.66833079e-01f,
  -1.31278828e-01f, 5.35809509e-02f, -3.87991816e-01f, 7.22517222e-02f, 4.79149759e-01f, -3.78531367e-01f, 1.18231967e-01f, -8.90412703e-02f, 2.51227945e-01f, 4.21398059e-02f,
  3.53839219e-01f, -1.90636575e-01f, 2.25113690e-01f, -2.68313676e-01f, 1.59965560e-01f, 8.64850208e-02f, -1.94581538e-01f, -4.35158350e-02f, -8.63817632e-02f, 3.87826152e-02f,
  9.93872210e-02f, 1.49580538e-01f, 1.83558375e-01f, 1.74512831e-03f, 2.82251555e-02f, -7.59643614e-02f, 8.57399926e-02f, -2.78832223e-02f, 3.45253736e-01f, -4.93220091e-02f,
  -1.39490440e-01f, 4.19722982e-02f, -8.90207291e-03f, -9.60837826e-02f, 2.17006370e-01f, 1.07493646e-01f, 1.30429447e-01f, 7.31213242e-02f, 3.79764587e-02f, 1.23432726e-01f,
  1.54712051e-01f, 5.85040227e-02f, 1.50988281e-01f, -1.77876234e-01f, 1.45832628e-01f, 4.66500670e-02f, 4.37100194e-02f, -1.07716493e-01f, 3.35114151e-02f, 1.39026001e-01f,
  -2.52031714e-01f, 5.97418658e-02f, 9.74611118e-02f, 9.92403850e-02f, 8.29228908e-02f, 1.45249516e-01f, 4.79969084e-02f, 2.60608215e-02f, 1.22352958e-01f, -5.35545349e-02f,
  9.57961776e-04f, 4.30031009e-02f, 1.79706693e-01f, 5.20568080e-02f, -8.93112924e-03f, 1.50587201e-01f, 2.57074554e-02f, -7.11155236e-02f, -2.18512081e-02f, 3.71031836e-02f,
  -8.56506601e-02f, 1.26078576e-01f, -1.52560845e-01f, 1.20045915e-01f, -7.60734677e-02f, -2.89175939e-02f, -4.36551236e-02f, -1.10569760e-01f, 1.00678861e-01f, -2.25047991e-02f,
  -3.72589320e-01f, -6.91411853e-01f, -7.58553147e-02f, -6.16940297e-02f, -1.49839818e-01f, -1.47050038e-01f, -1.27612213e-02f, -1.37003399e-02f, -5.42492513e-03f, 2.29640752e-02f,
  4.59688455e-02f, 5.74519783e-02f, -3.12039386e-02f, 7.50555545e-02f, -9.14571583e-02f, -4.07548957e-02f, -1.12247817e-01f, -1.86833501e-01f, -3.13508548e-02f, -1.88562218e-02f,
  -5.69762476e-02f, -1.08850718e-01f, -6.23081699e-02f, 8.66775513e-02f, -1.47503167e-02f, 3.72784622e-02f, 2.34769867e-03f, -5.02269380e-02f, -1.49733294e-02f, -1.16063459e-02f,
  2.02255011e-01f, 2.91067152e-03f, 3.64010394e-01f, 4.56956267e-01f, 1.24475211e-01f, -4.26735014e-01f, -3.92450273e-01f, 2.73162425e-01f, 3.94418657e-01f, -5.21376252e-01f,
  -2.25688592e-01f, 9.56595019e-02f, -3.60709101e-01f, 3.96826267e-01f, -7.70311132e-02f, -4.12229389e-01f, 5.01423478e-01f, -1.96146313e-02f, 7.65573680e-02f, 2.32914224e-01f,
  2.23971501e-01f, -7.97350332e-02f, 2.45938823e-01f, 1.63847655e-01f, 2.61554301e-01f, 3.16418260e-01f, 1.50924876e-01f, 3.60857658e-02f, 3.71652573e-01f, -5.77522591e-02f,
  8.68775919e-02f, 1.34500846e-01f, 3.08755368e-01f, 5.47866039e-02f, 1.36012226e-01f, 5.12103587e-02f, 2.23229863e-02f, -1.66437432e-01f, 2.59905532e-02f, -3.88173349e-02f,
  -1.84593000e-03f, 1.09187625e-01f, 1.27302021e-01f, -4.40097228e-02f, 2.67477602e-01f, 1.50388703e-01f, 1.56194508e-01f, 1.16001032e-01f, 2.05053225e-01f, -3.31385918e-02f,
  6.25271350e-02f, -2.76740491e-02f, 1.65971532e-01f, 9.62532386e-02f, 5.75613640e-02f, 1.63273484e-01f, -4.82943356e-02f, 3.90752368e-02f, 3.35823074e-02f, 1.75474420e-01f,
  -5.55795543e-02f, -1.16032362e-01f, -1.48152232e-01f, 4.72524613e-02f, -8.30423012e-02f, 1.11262225e-01f, -3.24623957e-02f, -7.32855126e-02f, -5.30239008e-02f, -1.15521602e-01f,
  1.24978855e-01f, 1.60382941e-01f, 9.37220380e-02f, 4.81320135e-02f, -2.82560033e-03f, 1.00183390e-01f, -6.61715940e-02f, -1.33152798e-01f, 1.52207687e-01f, -5.20464443e-02f,
  8.97299200e-02f, 7.14345509e-03f, -1.16490006e-01f, 2.84409951e-02f, 4.08255029e-03f, -2.32591238e-02f, -7.59935454e-02f, 1.01337796e-02f, 5.08073193e-04f, 1.08982250e-02f,
  5.13615236e-02f, -2.50247475e-02f, -1.00828055e-02f, 2.19790284e-02f, 5.94585761e-02f, -9.31746066e-02f, -7.60479225e-03f, 2.01141641e-01f, 5.34762368e-02f, -1.53042048e-01f,
  1.00372896e-01f, -5.25664836e-02f, -7.79213309e-02f, -1.02078607e-02f, 8.98365453e-02f, -2.34883302e-03f, -2.78972052e-02f, 4.83459383e-02f, 1.95295110e-01f, 1.60858542e-01f,
  -4.97872792e-02f, -1.67928085e-01f, 7.99583644e-02f, 2.06741281e-02f, 3.18712601e-03f, -7.58416063e-05f, -1.54231951e-01f, -7.02648563e-03f, -1.83839202e-02f, 4.12040614e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.15406525e-01f, 4.56945211e-01f, 3.19854110e-01f, 3.92680943e-01f, 5.05246043e-01f, 5.60720503e-01f, 4.70340073e-01f, 2.85622090e-01f, 4.91011143e-01f, 1.73870876e-01f,
  7.21974671e-01f, 4.58951175e-01f, 3.97685617e-01f, 4.02255446e-01f, 3.68095368e-01f, 3.77384692e-01f, 3.63862038e-01f, 4.01900202e-01f, 5.83778083e-01f, 4.23196405e-01f,
  3.87463689e-01f, 5.13943553e-01f, 5.41447401e-01f, 3.52023512e-01f, 2.65048414e-01f, 6.17328763e-01f, 5.20092309e-01f, 5.58820784e-01f, 4.70026046e-01f, 2.96688229e-01f,
  2.64517546e-01f, 4.08727616e-01f, 3.33838016e-01f, 4.50368941e-01f, 6.80848241e-01f, 5.92677176e-01f, 5.17027020e-01f, 5.72118402e-01f, 3.68598372e-01f, 4.21034217e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  4.26228866e-02f, -8.76546428e-02f, -5.23418784e-02f, -1.14149079e-01f, -1.33940890e-01f, 5.26764281e-02f, -3.05250287e-01f, -2.79084355e-01f, -2.51787543e-01f, -1.51941463e-01f,
  -3.12136143e-01f, 3.66263874e-02f, 1.30813822e-01f, 1.63408354e-01f, -1.87161401e-01f, -3.83544654e-01f, 3.50182563e-01f, -1.06121108e-01f, -1.42963946e-01f, -8.23274031e-02f,
  -2.33072296e-01f, 2.97691792e-01f, 3.99944782e-01f, -2.66703218e-02f, -5.56060135e-01f, -4.52352375e-01f, -1.26595765e-01f, -1.70452297e-01f, -1.95243120e-01f, 3.19260657e-01f,
  1.67186469e-01f, 5.58806121e-01f, -3.70709211e-01f, 7.02928543e-01f, -4.88450170e-01f, -7.86679626e-01f, 3.88471931e-01f, 4.20246989e-01f, 5.66674173e-01f, -2.02924728e-01f,
  1.49404541e-01f, -5.39511800e-01f, -3.49236429e-01f, 2.10950851e-01f, -7.76878536e-01f, -3.19456011e-01f, 4.74494427e-01f, -1.56702116e-01f, -4.04950768e-01f, -1.45015985e-01f,
  -2.87237316e-01f, 2.96595156e-01f, 1.80342078e-01f, 3.05725634e-01f, 3.51277381e-01f, -1.58158854e-01f, -2.22614959e-01f, -3.32077950e-01f, -3.99585128e-01f, -3.88977170e-01f,
  -5.45929492e-01f, -3.84423763e-01f, -3.52884620e-01f, -2.20745280e-01f, 1.30626215e-02f, -1.72348753e-01f, 9.27104056e-02f, -1.79063648e-01f, 1.47670567e-01f, -1.77585647e-01f,
  3.70544374e-01f, -1.39647990e-01f, 3.48286587e-03f, -2.81864107e-01f, 5.43455929e-02f, -5.64999104e-01f, 2.68205255e-01f, 5.63149042e-02f, -3.74715328e-01f, -4.53780860e-01f,
  -3.87221694e-01f, 4.79157656e-01f, 3.95067990e-01f, -2.17044890e-01f, -4.31855649e-01f, -8.31722766e-02f, -4.51988488e-01f, 5.61113238e-01f, 5.99295795e-01f, 3.41274768e-01f,
  -2.30371207e-02f, -3.55094939e-01f, 1.13953561e-01f, 9.53340605e-02f, 1.57203525e-01f, 5.19527495e-01f, -2.69148409e-01f, -2.30073467e-01f, -1.69507772e-01f, -1.11861363e-01f,
  -5.27273953e-01f, 1.98108494e-01f, -5.29964626e-01f, -8.57485116e-01f, -5.55380523e-01f, -4.61132318e-01f, -4.22185659e-03f, 8.58800113e-02f, 6.34111285e-01f, -5.90107024e-01f,
  1.40090138e-02f, -2.03805432e-01f, -4.12024884e-03f, 4.27961588e-01f, -4.48109269e-01f, -8.22312891e-01f, -3.31555396e-01f, 3.59819353e-01f, 5.37799180e-01f, -4.26433593e-01f,
  -6.63644895e-02f, -2.74353087e-01f, 3.12540382e-01f, -4.38955784e-01f, 2.55851030e-01f, -5.03171623e-01f, -7.53450155e-01f, -4.70395595e-01f, -1.36267826e-01f, 2.03473121e-02f,
  6.21898249e-02f, -2.83215642e-01f, -8.55737925e-02f, -1.21456496e-01f, -1.76773131e-01f, 1.65186860e-02f, 1.83294922e-01f, -8.11806228e-03f, -6.89712167e-02f, -6.29273131e-02f,
  -3.55151057e-01f, 4.17217791e-01f, 3.96386176e-01f, -2.98358470e-01f, -2.02269867e-01f, -2.18987256e-01f, 6.59887269e-02f, -1.95000954e-02f, 2.78831780e-01f, 2.08870143e-01f,
  -3.04463238e-01f, 2.09293336e-01f, 4.78580356e-01f, -8.39850008e-02f, 3.99648130e-01f, 2.63397306e-01f, 4.93262649e-01f, -5.29588223e-01f, -5.84902942e-01f, -4.71970022e-01f,
  -4.53551888e-01f, -3.51937175e-01f, -6.85303628e-01f, -1.81283593e-01f, -2.57251412e-01f, -4.42031711e-01f, -2.50083715e-01f, 5.78276098e-01f, -1.65686548e-01f, -5.33011079e-01f,
  -6.24691427e-01f, -2.28148282e-01f, 3.73982459e-01f, -6.07829213e-01f, 3.23968381e-01f, -1.92821234e-01f, -1.90287203e-01f, -5.06389141e-01f, -1.77600250e-01f, -2.68902302e-01f,
  -3.19948912e-01f, -8.78722444e-02f, 3.30446750e-01f, 4.51520920e-01f, -4.36110795e-01f, -2.96142310e-01f, 1.92230240e-01f, -4.21003968e-01f, 2.06949517e-01f, -3.34485501e-01f,
  2.59615749e-01f, 3.74138027e-01f, 4.92195636e-02f, -1.75645858e-01f, -1.71147674e-01f, -1.43660501e-01f, -3.61860782e-01f, -1.24506569e-02f, -2.32741818e-01f, -9.76800248e-02f,
  -2.75905281e-01f, -1.07365541e-01f, -5.00678681e-02f, -1.08001843e-01f, -2.53455251e-01f, -1.38184026e-01f, -4.10707533e-01f, -1.16287870e-02f, 1.70989871e-01f, -1.18379883e-01f,
  -2.48339340e-01f, 2.87431479e-01f, -4.37794149e-01f, -1.55396700e-01f, 1.45719677e-01f, -1.65495932e-01f, -5.67788064e-01f, 7.88833946e-03f, -1.92626879e-01f, 4.67779994e-01f,
  -7.52793312e-01f, -1.91164210e-01f, -4.53943312e-01f, 6.26428798e-02f, -2.15818495e-01f, 2.57943254e-02f, -4.11922991e-01f, -5.24073005e-01f, 5.07800877e-01f, -2.08608150e-01f,
  1.83062032e-01f, -3.31082523e-01f, 5.81720583e-02f, 2.64720291e-01f, -3.70515466e-01f, -4.85068828e-01f, -1.63206905e-01f, 3.12924087e-01f, -4.99678969e-01f, 3.00333381e-01f,
  6.49525940e-01f, -3.57084215e-01f, 2.39388928e-01f, -4.30574715e-01f, 5.38742363e-01f, 2.57749036e-02f, -4.79809940e-01f, -1.96439192e-01f, 4.02074277e-01f, 1.53773502e-01f,
  -2.03996554e-01f, -1.69494316e-01f, -1.91804379e-01f, 4.06857044e-01f, -3.70037764e-01f, -5.07480383e-01f, 1.26324281e-01f, 3.26041192e-01f, 5.97471856e-02f, -3.83563060e-03f,
  2.89034307e-01f, 8.58818963e-02f, 1.40282020e-01f, 9.57925320e-02f, 1.71482250e-01f, 3.03248733e-01f, -1.08671091e-01f, 1.96846858e-01f, -4.24979985e-01f, 3.48663419e-01f,
  3.66216242e-01f, 3.89158368e-01f, -1.49796039e-01f, -3.92436057e-01f, -3.71041238e-01f, -5.57269096e-01f, 1.34715766e-01f, -5.12292385e-01f, 3.73502791e-01f, -2.93416381e-01f,
  -3.91893744e-01f, -3.50730211e-01f, -4.58304659e-02f, -7.25618720e-01f, -1.72925964e-01f, 2.01537207e-01f, 4.27322298e-01f, -4.30814564e-01f, -1.46447241e-01f, -5.42831898e-01f,
  -3.68842542e-01f, 5.65256476e-01f, 3.44701022e-01f, -4.53264207e-01f, 6.31525576e-01f, 3.68513875e-02f, 1.00463539e-01f, 1.88993514e-01f, 4.96862113e-01f, 2.28281453e-01f,
  3.02403152e-01f, -6.11114025e-01f, 2.49046728e-01f, -6.38534248e-01f, 5.68446033e-02f, -4.65833068e-01f, 8.31633657e-02f, -4.15035859e-02f, -2.12639958e-01f, -3.09740067e-01f,
  -3.05058181e-01f, -2.93564916e-01f, 6.59989119e-01f, 2.17468336e-01f, -2.42712393e-01f, -4.17578906e-01f, -3.28065634e-01f, 2.44221166e-01f, -3.25356930e-01f, -8.36818144e-02f,
  1.19439915e-01f, 3.16027030e-02f, 3.27896327e-01f, 2.73334980e-01f, 3.95799041e-01f, -3.71706150e-02f, 4.67325300e-02f, 8.75062272e-02f, 4.94692087e-01f, -1.72799304e-02f,
  2.62321144e-01f, 3.74613762e-01f, 4.61154908e-01f, 5.95862925e-01f, -3.41204941e-01f, 2.89834976e-01f, -1.33111492e-01f, -2.07897142e-01f, -4.37316746e-01f, -5.71677744e-01f,
  -6.40128925e-02f, 6.45707548e-01f, -3.39931518e-01f, -3.83786976e-01f, -5.44199765e-01f, 5.85761368e-01f, 3.18755180e-01f, -4.02292758e-01f, -2.69571215e-01f, -1.39826760e-01f,
  -1.63694978e-01f, -3.61784726e-01f, 1.75847799e-01f, -1.79400802e-01f, 4.07613605e-01f, 1.43286794e-01f, -2.74453193e-01f, 6.14675045e-01f, -6.06284380e-01f, -3.70220184e-01f,
  1.16555527e-01f, -1.89569332e-02f, 6.90983832e-01f, -5.73413372e-01f, -7.57632136e-01f, 2.13998556e-02f, -2.80009359e-01f, -2.77026415e-01f, -6.35211706e-01f, 4.14662719e-01f,
  -7.28359744e-02f, 4.61173505e-01f, -5.13290167e-01f, 1.01392986e-02f, -2.93635368e-01f, -1.83361456e-01f, -2.24013776e-01f, -5.65727115e-01f, 1.77854151e-01f, 1.60900831e-01f,
  -2.95635134e-01f, 2.90574104e-01f, -3.63433242e-01f, 1.44358333e-02f, 3.66579890e-02f, 2.03003824e-01f, -5.43456115e-02f, 1.49655595e-01f, -1.74579322e-01f, -2.53110498e-01f,
  -1.62481070e-01f, -4.69623990e-02f, -3.26039284e-01f, 4.08865288e-02f, 3.54923047e-02f, -2.32076868e-02f, 7.48226345e-02f, -5.07258117e-01f, 1.92687333e-01f, -2.00227216e-01f,
  -4.11839664e-01f, -2.98683017e-01f, 5.75075626e-01f, 6.10857129e-01f, 4.16572392e-01f, -1.00727975e-01f, 2.54836082e-01f, 3.72754425e-01f, -2.86005199e-01f, 7.41433576e-02f,
  3.82472798e-02f, -2.16954201e-01f, 1.19392216e-01f, -5.42285919e-01f, -2.94579148e-01f, -2.78766870e-01f, 2.34657213e-01f, -6.68839738e-02f, 4.88604724e-01f, -3.31373572e-01f,
  -6.02588534e-01f, -2.96942770e-01f, -5.38979709e-01f, 2.99014449e-01f, -6.29798993e-02f, 6.23764753e-01f, -1.68248162e-01f, -5.29652715e-01f, 1.03216223e-01f, -2.90666699e-01f,
  -6.22234344e-01f, -2.39839330e-01f, -1.06484018e-01f, 3.15596849e-01f, -1.42113745e-01f, 6.44173548e-02f, 1.17095038e-02f, 7.31331527e-01f, -5.59630036e-01f, 4.96985584e-01f,
  1.83662444e-01f, -6.67888522e-01f, -7.02508450e-01f, -6.12799749e-02f, -1.44440964e-01f, 1.80695444e-01f, 6.07156992e-01f, 2.74920464e-01f, -2.50008017e-01f, -9.21815336e-02f,
  2.28470359e-02f, -1.79662243e-01f, -8.76869261e-02f, -3.03427875e-01f, -2.45500341e-01f, -7.61779696e-02f, -1.76708043e-01f, -2.78253466e-01f, -2.21310128e-02f, -1.21348433e-01f,
  3.30035150e-01f, -1.63975433e-01f, 1.25644042e-03f, 4.84958254e-02f, 1.10876486e-01f, 3.51261467e-01f, 2.00415328e-01f, 4.08775061e-02f, 8.53741765e-02f, -1.46401539e-01f,
  -1.39474943e-01f, 1.36857992e-02f, 1.51233319e-02f, -2.49735087e-01f, 3.28095973e-01f, -4.36019212e-01f, -3.23208213e-01f, -5.48486531e-01f, -3.38593483e-01f, -1.92621633e-01f,
  4.72514987e-01f, -4.49202210e-01f, -1.66115224e-01f, 5.51886320e-01f, 1.37542650e-01f, -3.39948237e-01f, -4.37226556e-02f, -1.50824776e-02f, -1.62831336e-01f, -1.43486306e-01f,
  -2.43627921e-01f, -4.56897199e-01f, -3.73794198e-01f, 3.14108670e-01f, -1.53053880e-01f, 1.90412492e-01f, 1.13802865e-01f, -3.24923009e-01f, 1.93191975e-01f, 4.23348516e-01f,
  2.13365063e-01f, -1.07612357e-01f, -3.05823505e-01f, -2.04082668e-01f, -5.50338089e-01f, 4.60612327e-01f, -9.50646326e-02f, 3.00576538e-02f, 4.31057841e-01f, 1.17186308e-01f,
  -9.47175846e-02f, -2.37083659e-01f, 1.13003008e-01f, 2.50599980e-02f, -2.67946482e-01f, -2.18816027e-01f, -1.46371290e-01f, 1.77924018e-02f, -3.04840297e-01f, -1.82403296e-01f,
  -1.72527015e-01f, 2.24785563e-02f, -2.10076094e-01f, 1.94073349e-01f, 1.98654741e-01f, -6.16545789e-02f, -2.87234813e-01f, -1.86472312e-01f, -1.34814233e-01f, 3.22261810e-01f,
  2.32160568e-01f, -4.49809954e-02f, -3.75305802e-01f, 1.82595551e-01f, -1.85148627e-01f, -9.71885696e-02f, -7.70521769e-03f, -3.89719665e-01f, 4.36056525e-01f, -2.88085975e-02f,
  -3.67068440e-01f, -5.29672742e-01f, 2.88943350e-01f, -5.17679691e-01f, -1.73773721e-01f, 5.69489717e-01f, -3.67227554e-01f, 9.32534132e-03f, -3.09495389e-01f, -1.42741442e-01f,
  -5.33786379e-02f, 3.37585449e-01f, -2.87693053e-01f, -2.13977426e-01f, 3.01339347e-02f, 1.43427357e-01f, 2.12781891e-01f, 5.93219340e-01f, -4.51519787e-01f, -2.25602388e-01f,
  -1.54371530e-01f, -3.88949573e-01f, -2.94416547e-01f, -2.65054435e-01f, -6.09832928e-02f, -4.89214867e-01f, -5.06500539e-04f, -7.34695792e-02f, -1.48575991e-01f, -3.14882368e-01f,
  2.86513329e-01f, 5.55593908e-01f, -3.96654874e-01f, -4.00751770e-01f, 6.84155338e-03f, 4.80352849e-01f, -6.93838857e-03f, -4.26270179e-02f, 8.59456509e-03f, 1.86299592e-01f,
  8.74193683e-02f, 1.70407295e-01f, 1.29853114e-01f, 2.90505081e-01f, -3.26996058e-01f, 2.95248479e-01f, 8.42167959e-02f, 3.70081738e-02f, -3.14343661e-01f, -5.32658994e-01f,
  4.06658620e-01f, 3.77138585e-01f, 8.15322548e-02f, 1.78687349e-01f, -3.44861209e-01f, 2.41602927e-01f, 4.25558746e-01f, 3.07041585e-01f, 2.81602353e-01f, -4.00429279e-01f,
  2.89456457e-01f, -2.54185736e-01f, -3.57445657e-01f, -4.31355715e-01f, -6.56677410e-02f, 3.14794570e-01f, -4.25726950e-01f, -1.87776261e-03f, 3.75017822e-01f, 9.25577208e-02f,
  2.92373061e-01f, -1.85179692e-02f, -3.50923955e-01f, -6.09996557e-01f, -6.43130243e-01f, -1.55919939e-01f, -5.86076379e-01f, -1.41725009e-02f, 3.66928637e-01f, 7.44210184e-01f,
  -1.32920086e-01f, -1.73698649e-01f, 6.65248513e-01f, -2.42337480e-01f, -4.25769031e-01f, -7.29900897e-01f, -5.34856617e-01f, 1.04103856e-01f, -2.48043224e-01f, -5.67866027e-01f,
  -5.74845433e-01f, 3.16788226e-01f, -1.75573900e-01f, -1.47580028e-01f, -3.65858704e-01f, -5.57193398e-01f, 7.48031974e-01f, -6.68245971e-01f, 1.89842030e-01f, -7.78900862e-01f,
  -6.99918941e-02f, 2.00902715e-01f, -4.02819440e-02f, 2.84078747e-01f, 3.01695704e-01f, 2.15254888e-01f, 2.18395144e-01f, -6.66926503e-02f, 2.43403599e-01f, -1.07199684e-01f,
  7.10632280e-02f, 1.98565319e-01f, -1.16406024e-01f, -3.94982249e-02f, -3.43905926e-01f, -2.16426998e-01f, -1.35739341e-01f, 1.27897143e-01f, 4.47889790e-02f, 1.92010775e-01f,
  1.78552836e-01f, -3.02040011e-01f, -3.02798361e-01f, 1.47389978e-01f, 3.47128272e-01f, 4.11419570e-02f, -5.92332125e-01f, 5.06905138e-01f, 7.64309943e-01f, 2.44951501e-01f,
  4.01935577e-01f, 8.50047320e-02f, -4.91991162e-01f, -3.76811713e-01f, -1.81245416e-01f, -1.66633040e-01f, -7.44401276e-01f, -4.96048152e-01f, -3.13216954e-01f, -5.68362832e-01f,
  -5.88772058e-01f, -2.93261886e-01f, -4.59961623e-01f, 2.65623685e-02f, -4.58236396e-01f, -2.78234243e-01f, -3.82485211e-01f, 5.50812185e-01f, -4.42733109e-01f, -2.09678635e-01f,
  3.56667638e-01f, -8.27436522e-02f, 3.84420007e-01f, -4.88020658e-01f, -2.51221418e-01f, -2.80422568e-01f, -4.24130648e-01f, -5.74635506e-01f, 2.71319985e-01f, 3.65855753e-01f,
  -1.36714727e-01f, 1.87796757e-01f, -4.09579426e-01f, -1.76985487e-01f, -1.00626471e-02f, -1.54186755e-01f, 1.26550034e-01f, 1.12870783e-01f, 1.03541031e-01f, 6.07787035e-02f,
  9.20422673e-02f, -1.54351726e-01f, 1.42982394e-01f, 1.72210425e-01f, -4.54343632e-02f, -5.32173477e-02f, -1.45671755e-01f, -3.31591368e-01f, 2.93106169e-01f, 3.25679421e-01f,
  4.25772935e-01f, -2.07242832e-01f, 3.58612925e-01f, 3.95157963e-01f, 1.05880037e-01f, -2.98288405e-01f, -1.24021834e-02f, -3.50994259e-01f, -3.07090938e-01f, -1.09936535e-01f,
  -6.84557378e-01f, 2.64310762e-02f, -3.48891050e-01f, 4.53546256e-01f, -2.92390704e-01f, -2.47742236e-01f, -5.84953249e-01f, -2.69921511e-01f, 4.69342738e-01f, -8.80141631e-02f,
  -2.97141999e-01f, -4.45048153e-01f, 2.68885165e-01f, 2.72060990e-01f, 6.31891608e-01f, -1.22919492e-01f, -4.83935833e-01f, -3.12047511e-01f, -3.50262821e-01f, 2.52331674e-01f,
  -4.16168571e-01f, 4.40210402e-02f, 3.59268337e-01f, 3.99189353e-01f, -3.92136037e-01f, 2.65811700e-02f, -6.04740024e-01f, -2.83865482e-01f, -4.11077887e-01f, -4.62685853e-01f,
  -2.65284956e-01f, 4.67659056e-01f, 3.09872270e-01f, 5.40606201e-01f, -4.73484993e-01f, -2.49435723e-01f, 1.64780468e-01f, 3.87834519e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.02938339e-01f, 1.55390218e-01f, -1.48897737e-01f, -2.55543202e-01f, 2.03857943e-01f, 1.35296702e-01f, -9.86967459e-02f, -5.54258004e-02f, 1.52588887e-02f, 1.95995569e-01f,
  4.05765846e-02f, -3.40803675e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    