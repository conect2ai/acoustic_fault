/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.43337119e-01f, -1.31254062e-01f, -2.37015054e-01f, 1.40596256e-02f, -1.53829217e-01f, -8.22277963e-02f, -4.24113423e-02f, 7.22204968e-02f, -1.15779694e-02f, -1.05425201e-01f,
  1.00364119e-01f, 3.91803086e-02f, 4.32094187e-02f, -1.26652136e-01f, -4.53949235e-02f, -2.38121867e-01f, -2.34953865e-01f, -2.85978854e-01f, -1.40935019e-01f, -4.08655629e-02f,
  -1.32950604e-01f, -1.89733148e-01f, -1.16621785e-01f, -6.54884055e-02f, -2.56773025e-01f, -2.31946632e-01f, -1.41582236e-01f, -2.29140267e-01f, -2.40254298e-01f, -3.47144485e-01f,
  -2.20421568e-01f, 1.51420563e-01f, -9.09286886e-02f, -8.47480670e-02f, -1.28688484e-01f, -1.24226697e-01f, -1.03033938e-01f, -1.42779142e-01f, -9.64070782e-02f, -8.03874582e-02f,
  -7.97468349e-02f, -2.90001892e-02f, -4.03207876e-02f, -5.48113436e-02f, -1.12073563e-01f, -7.65586644e-02f, 1.80373471e-02f, -1.16922215e-01f, -7.59716928e-02f, -1.14302270e-01f,
  -8.86700451e-02f, -2.01406434e-01f, -1.51984274e-01f, -9.75049511e-02f, -8.95410106e-02f, -8.36771429e-02f, -1.71098247e-01f, -6.33244067e-02f, -1.26509359e-02f, -8.42410550e-02f,
  1.66857187e-02f, 4.40914705e-02f, 1.66505218e-01f, 2.25400180e-01f, 1.95141524e-01f, 1.57605782e-01f, 1.63594157e-01f, 1.49690453e-02f, 1.15639895e-01f, 2.41731435e-01f,
  9.04115140e-02f, 2.26113468e-01f, 1.23444930e-01f, 1.03459500e-01f, 1.22772790e-01f, 1.29970238e-01f, 9.96751040e-02f, 9.71841514e-02f, 1.77067444e-01f, 1.73038542e-01f,
  1.34262249e-01f, 6.21496774e-02f, 1.51504532e-01f, 1.95680723e-01f, 1.84540138e-01f, 1.12572439e-01f, 1.09316967e-01f, 1.61748216e-01f, 2.08937883e-01f, 8.64312202e-02f,
  1.39242873e-01f, -5.49178682e-02f, -2.15992033e-02f, -4.31398377e-02f, -9.36915427e-02f, -5.54087348e-02f, -6.66817501e-02f, -1.52592316e-01f, -4.87191118e-02f, -6.25566542e-02f,
  -1.06288709e-01f, -1.01202562e-01f, -4.99159843e-02f, -9.05442685e-02f, -1.41406581e-01f, -8.75981599e-02f, 1.12650702e-02f, -1.73007876e-01f, -1.38552368e-01f, -6.82618469e-02f,
  -1.23128451e-01f, -3.24159786e-02f, -9.03966129e-02f, -3.57659021e-03f, -4.62091863e-02f, -1.21359602e-01f, -1.05730020e-01f, -9.81474072e-02f, -1.06475420e-01f, -3.07824314e-02f,
  -3.63680780e-01f, 6.06023706e-02f, 2.20565587e-01f, -4.62681614e-02f, -1.29961610e-01f, -1.86063364e-01f, -1.29835203e-01f, -1.09184176e-01f, 4.96550873e-02f, -7.34013170e-02f,
  8.21345747e-02f, -1.60320252e-01f, -5.54324202e-02f, -1.65336132e-01f, -1.86839610e-01f, -4.80998307e-02f, -7.52619421e-03f, -1.79375365e-01f, -2.81834900e-01f, -1.99511945e-01f,
  -1.08295538e-01f, -2.63879657e-01f, -1.49159640e-01f, -6.61029443e-02f, -1.81792211e-02f, 6.09498136e-02f, 6.05046414e-02f, -5.70073389e-02f, 6.88195601e-02f, 9.39981733e-03f,
  -4.96230163e-02f, 5.83696663e-02f, -4.66855429e-02f, -2.31806412e-02f, 7.62336776e-02f, 9.62890014e-02f, 5.20994999e-02f, 9.92184207e-02f, 2.58109923e-02f, 1.19751371e-01f,
  5.23654036e-02f, -3.87142189e-02f, -4.10078838e-02f, 3.10699716e-02f, 1.82969123e-02f, -5.60810119e-02f, 2.75937817e-03f, -8.95255432e-03f, 1.44331411e-01f, 2.42936872e-02f,
  5.57075515e-02f, -5.63202873e-02f, 1.39161780e-01f, 1.28984943e-01f, -1.53373433e-02f, 4.74137925e-02f, 1.46220401e-01f, 7.85706565e-02f, 4.46676202e-02f, 6.70007989e-02f,
  -3.59000340e-02f, -5.23439758e-02f, -3.83132603e-03f, 1.04202412e-01f, 7.60444552e-02f, 1.08642422e-01f, 8.41539130e-02f, 3.87062803e-02f, -1.42939230e-02f, 1.08220764e-01f,
  1.47712361e-02f, 1.18224271e-01f, 7.92654082e-02f, -1.71166006e-02f, -4.84934598e-02f, 2.56518200e-02f, -4.69511794e-03f, 8.59379545e-02f, 9.42032132e-03f, 6.09803274e-02f,
  2.55078245e-02f, 1.34732395e-01f, 9.26981717e-02f, 3.03443074e-02f, 6.00588582e-02f, -5.98521084e-02f, -2.93977447e-02f, 1.38104692e-01f, 4.33541723e-02f, 5.57146110e-02f,
  -1.25577236e-02f, 8.75191242e-02f, -1.04249403e-01f, -9.14226621e-02f, 7.80450404e-02f, 2.22669020e-02f, 8.63717776e-03f, 1.42702207e-01f, 3.80925424e-02f, -7.92591926e-03f,
  5.80824837e-02f, 5.49639836e-02f, 1.98020749e-02f, -4.23906818e-02f, 2.59539690e-02f, -9.91474837e-03f, 7.85361677e-02f, -5.96809983e-02f, 9.24916491e-02f, 8.02139714e-02f,
  2.37674825e-02f, -3.56559604e-02f, 1.38269896e-02f, 1.52153730e-01f, 8.63448717e-03f, -1.53063294e-02f, 9.35399234e-02f, 3.06421816e-02f, 2.47478336e-02f, 4.64032143e-02f,
  -3.19307566e-01f, 1.60444751e-01f, 3.01243603e-01f, 5.43243289e-02f, 2.76503712e-01f, 3.27659756e-01f, 3.22422713e-01f, 2.30204687e-01f, 2.27286927e-02f, 2.08690733e-01f,
  2.24682223e-02f, 2.33990736e-02f, -1.26458639e-02f, 1.06590256e-01f, 8.00685734e-02f, 2.33625054e-01f, 2.48208001e-01f, 1.82665035e-01f, 6.81745708e-02f, 6.63396716e-02f,
  2.29449689e-01f, 1.03547513e-01f, -1.20511912e-01f, 6.86838403e-02f, 1.90624774e-01f, 1.23822361e-01f, 2.32818976e-01f, 4.25836928e-02f, 2.61377871e-01f, 1.88583225e-01f,
  2.60726839e-01f, 1.59849793e-01f, 2.27604911e-01f, 1.03201419e-01f, 1.14281431e-01f, 1.69174910e-01f, 2.66874045e-01f, 1.83637768e-01f, 1.90102622e-01f, 1.87603533e-01f,
  1.72865748e-01f, 6.82523623e-02f, 2.18212485e-01f, 1.19745888e-01f, 6.62503317e-02f, 1.88528225e-01f, 1.78255171e-01f, 7.50380307e-02f, 1.72590181e-01f, 1.89028874e-01f,
  1.32655755e-01f, 1.67078972e-01f, 2.06498757e-01f, 2.66782045e-01f, 1.87646940e-01f, 1.77586466e-01f, 1.88624114e-01f, 2.38967448e-01f, 9.67732072e-02f, 1.32940933e-01f,
  -1.80374920e-01f, -1.62470743e-01f, -9.38249752e-02f, -1.87940389e-01f, -2.01540411e-01f, -1.33336052e-01f, -1.47609413e-01f, -1.59505922e-02f, -7.03864023e-02f, -2.98003200e-02f,
  -5.16308062e-02f, -1.60640523e-01f, -9.64854807e-02f, -1.05097979e-01f, -1.19534694e-01f, -3.32309343e-02f, -8.12042579e-02f, -1.32729173e-01f, -7.07816929e-02f, -1.20253794e-01f,
  -1.51824385e-01f, -1.05326369e-01f, -9.57774743e-02f, -4.28180443e-03f, -1.03960246e-01f, -4.19233693e-03f, -1.18135594e-01f, -1.21496722e-01f, -8.25960562e-03f, -6.35174885e-02f,
  6.79977834e-02f, 4.10793498e-02f, 1.66006833e-01f, 1.98439807e-01f, 2.40081176e-01f, 1.50014982e-01f, 1.93826810e-01f, 9.96157378e-02f, 1.84327021e-01f, 1.92796975e-01f,
  1.50556609e-01f, 8.96200687e-02f, 1.83347613e-01f, 2.05227494e-01f, 2.16186300e-01f, 2.40076616e-01f, 1.24456540e-01f, 1.37278304e-01f, 2.03459799e-01f, 1.95489109e-01f,
  1.77247033e-01f, 2.38018230e-01f, 1.99761897e-01f, 2.16813132e-01f, 2.82440156e-01f, 2.33771935e-01f, 2.71644294e-01f, 3.23458612e-01f, 2.67311543e-01f, 3.44187737e-01f,
  -1.86678022e-01f, 3.06185484e-01f, -2.87670661e-02f, -1.85250774e-01f, -1.76246554e-01f, -1.01976424e-01f, -3.35901976e-03f, 3.97623107e-02f, -4.14112806e-02f, 1.93283777e-03f,
  -2.95957420e-02f, 1.68049708e-02f, 1.57672331e-01f, 2.95533866e-01f, 3.66325408e-01f, 1.85297117e-01f, 2.32381478e-01f, 1.76777855e-01f, 1.01078168e-01f, -3.38296010e-03f,
  9.01153460e-02f, 1.25069275e-01f, 1.81236595e-01f, 1.11881442e-01f, -1.59014925e-01f, 1.57303903e-02f, 1.10694595e-01f, -1.47614777e-01f, 4.12314013e-02f, -8.65823925e-02f,
  -7.44835213e-02f, -1.38768002e-01f, -5.20354882e-03f, 1.23445699e-02f, -1.43790767e-01f, 5.35628162e-02f, -4.55264514e-03f, 9.00672451e-02f, -3.76626365e-02f, 5.18378280e-02f,
  -1.71122313e-01f, -1.36493482e-02f, -8.32727402e-02f, -1.51522299e-02f, -7.36079291e-02f, 1.90435573e-02f, 1.42021656e-01f, 9.76096168e-02f, 1.08015083e-01f, 3.04685626e-02f,
  -3.67492847e-02f, -2.01341063e-01f, -2.40721256e-01f, -1.60905346e-02f, -6.02122620e-02f, -1.81976128e-02f, 2.63297521e-02f, -1.12082243e-01f, 1.58348605e-02f, 7.55059421e-02f,
  -3.18735950e-02f, 3.44443135e-02f, 8.72827414e-03f, -4.50999476e-04f, 8.45524296e-02f, -4.93882922e-04f, 4.33592536e-02f, -1.08809713e-02f, 2.67419312e-02f, 2.19020247e-02f,
  4.44537364e-02f, -7.66110327e-03f, 7.24386051e-02f, 5.53932413e-02f, 7.69585669e-02f, -3.03809326e-02f, -5.55756642e-03f, 3.50854062e-02f, -1.03623345e-02f, 1.18062021e-02f,
  4.23279628e-02f, -4.86247912e-02f, 6.86905161e-02f, 1.00495234e-01f, 4.98148464e-02f, -1.53178861e-02f, -2.01639850e-02f, 9.55291837e-02f, 3.28850299e-02f, 3.95018123e-02f,
  1.33373678e-01f, -3.30154155e-03f, -4.85475734e-02f, 2.78613553e-03f, -1.88513696e-01f, -4.16271314e-02f, -5.17356731e-02f, -1.31576657e-02f, -7.25804046e-02f, -3.34285316e-03f,
  -2.61022840e-02f, -3.21323462e-02f, -5.53606302e-02f, -1.49676157e-02f, -1.45097718e-01f, -4.30792980e-02f, -7.27417618e-02f, -1.40773371e-01f, -9.04833246e-03f, -2.27312092e-02f,
  3.76463048e-02f, -1.64446384e-01f, -1.11181155e-01f, 4.45230026e-03f, -1.63706213e-01f, -2.00917915e-01f, -3.65749896e-02f, -3.22167613e-02f, -1.53746560e-01f, 1.34830058e-01f,
  3.63082796e-01f, -1.02580860e-01f, -1.21955335e-01f, -1.76079735e-01f, -2.11524516e-02f, 2.80980408e-01f, 2.09983870e-01f, 3.05158615e-01f, -3.53986807e-02f, 8.01354870e-02f,
  3.48187312e-02f, -1.16052434e-01f, -1.46653414e-01f, 8.89228750e-03f, 1.49287820e-01f, -6.45051822e-02f, -1.12421565e-01f, -7.93823674e-02f, 6.15321882e-02f, 6.60465732e-02f,
  -1.44680142e-01f, -1.60510451e-01f, -1.22525007e-01f, -1.97026357e-01f, -2.55014390e-01f, -1.43522933e-01f, -2.14864522e-01f, -1.50460467e-01f, -1.14188813e-01f, -2.24465162e-01f,
  -2.42671430e-01f, 1.25525489e-01f, 4.85063046e-02f, -1.44981220e-01f, -2.09756643e-01f, 6.37942925e-02f, 8.53235424e-02f, -6.27515689e-02f, 4.48989011e-02f, -3.76137607e-02f,
  -8.31512064e-02f, -1.02185905e-02f, -1.03910029e-01f, -1.21220611e-01f, 6.22967631e-03f, 6.76563755e-02f, -1.03121325e-01f, -7.85337240e-02f, 1.64155103e-02f, 5.32888956e-02f,
  1.79067627e-02f, -5.69559336e-02f, 3.32351513e-02f, -3.37435678e-02f, -4.94304150e-02f, 8.54623411e-03f, -6.80159628e-02f, 1.89811829e-02f, -2.79704705e-02f, -8.30227435e-02f,
  6.99433386e-02f, 5.33976685e-03f, -1.04911290e-01f, -2.40670927e-02f, -8.19825605e-02f, -2.00258475e-02f, -7.11362958e-02f, -4.32400368e-02f, 5.29700704e-03f, -9.58079174e-02f,
  -5.55877350e-02f, -6.72070459e-02f, -5.14631234e-02f, -8.99050683e-02f, -1.39518335e-01f, -7.27682039e-02f, -1.26984239e-01f, -1.21905379e-01f, -4.52147201e-02f, -5.34991734e-02f,
  -5.92048243e-02f, 9.40872915e-03f, -1.43517494e-01f, -1.42585710e-01f, -1.64144132e-02f, -7.50866905e-02f, -4.74528410e-02f, -4.29398231e-02f, -2.98287924e-02f, 5.02343774e-02f,
  -2.41030067e-01f, 1.50621003e-02f, 9.25111622e-02f, 7.69182891e-02f, -3.18093561e-02f, -6.75449744e-02f, -7.61637092e-02f, -3.01878508e-02f, -6.15705959e-02f, 5.35398163e-02f,
  5.79798780e-02f, 8.99161622e-02f, 3.33225951e-02f, -6.19850829e-02f, 9.18008015e-03f, 3.79204936e-02f, -3.70793454e-02f, -9.95425954e-02f, -8.68844520e-03f, 8.62083733e-02f,
  -3.04400232e-02f, 1.19762175e-01f, 9.50333774e-02f, -3.74945849e-02f, 5.40338270e-02f, 1.12874568e-01f, -1.11755304e-01f, 3.04157417e-02f, 1.25882179e-01f, 1.67205762e-02f,
  3.22982013e-01f, 1.46272182e-01f, 2.74015099e-01f, -1.06677361e-01f, -1.64915279e-01f, 9.25837308e-02f, 5.21958917e-02f, -4.64629978e-02f, -7.16521442e-02f, 8.12026337e-02f,
  8.08100551e-02f, -5.77554107e-03f, 6.68905303e-02f, 1.57067049e-02f, 1.81146845e-01f, 6.25265241e-02f, -7.63734942e-03f, 1.93956584e-01f, 5.77189587e-02f, -4.18532267e-02f,
  -1.67763352e-01f, -1.55021504e-01f, -2.60830838e-02f, -5.23896469e-03f, -1.91722974e-01f, -3.49035300e-02f, 1.51559692e-02f, 4.52745892e-02f, 2.25530080e-02f, -2.31278874e-02f,
  1.42180800e-01f, 7.47647509e-02f, 3.74946892e-02f, -8.10010806e-02f, -6.32660985e-02f, -5.63682355e-02f, 6.19538948e-02f, -1.31282648e-02f, -6.81017572e-03f, 4.77710068e-02f,
  -3.59881707e-02f, -1.11622959e-02f, 1.76734384e-02f, -4.47946154e-02f, -3.10390312e-02f, -1.13586644e-02f, -8.65780711e-02f, 1.24896085e-02f, 5.06685525e-02f, -6.01987131e-02f,
  -1.65346131e-01f, -2.35596355e-02f, 7.28059933e-02f, -4.03957143e-02f, 3.97066772e-02f, 1.07580259e-01f, 1.23670347e-01f, -1.40258092e-02f, 9.37212557e-02f, 7.61900470e-02f,
  -3.35814171e-02f, -2.78978841e-03f, -5.27984230e-03f, 4.63412516e-02f, -1.87700577e-02f, 6.45359829e-02f, -5.50627969e-02f, 9.71544385e-02f, -3.60172102e-03f, -6.18476979e-02f,
  -2.04234812e-02f, 1.12322047e-01f, -8.62101838e-02f, 6.55959966e-03f, -9.00280401e-02f, 2.81870477e-02f, 3.28792073e-02f, 3.02132275e-02f, 1.66583676e-02f, -1.73116382e-03f,
  4.36029471e-02f, 8.75628591e-02f, -6.38835207e-02f, -8.49026963e-02f, 6.10064194e-02f, 7.04583451e-02f, 7.91958869e-02f, 2.42559109e-02f, 8.10231119e-02f, 3.22746374e-02f,
  -1.43997669e-01f, 1.46989703e-01f, 9.48533639e-02f, 1.14228129e-02f, -5.45973741e-02f, -3.73753384e-02f, -2.86086779e-02f, 1.97944278e-03f, 7.77365267e-02f, 8.48682374e-02f,
  1.96569040e-02f, 6.29195273e-02f, -4.44966368e-02f, -1.03900790e-01f, 1.75314806e-02f, 2.19922252e-02f, -1.35334730e-01f, -3.02145034e-02f, -4.38959710e-03f, -3.77546102e-02f,
  -1.15618799e-02f, 8.29156637e-02f, 1.08203955e-01f, 1.33214235e-01f, 4.17044871e-02f, 1.10578023e-01f, 2.58673802e-02f, 5.89414313e-02f, 2.47984856e-01f, 5.21828141e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.03684616e+00f, -2.76063532e-01f, 3.00465614e-01f, -5.32491267e-01f, 4.18817960e-02f, 2.25625798e-01f, 2.31225446e-01f, -2.42633432e-01f, -3.58658046e-01f, -1.92579255e-01f,
  -2.66845793e-01f, -2.50529438e-01f, -2.04146832e-01f, -2.23519728e-02f, -1.70559943e-01f, 2.22562760e-01f, 6.54673204e-02f, 7.73982098e-03f, 1.30417958e-01f, 1.42536953e-01f,
  -3.61227617e-02f, -2.44377792e-01f, -3.01514089e-01f, -1.48974270e-01f, -1.36274964e-01f, -1.58747565e-02f, -7.17847273e-02f, -1.35593891e-01f, 1.60793915e-01f, -3.30989622e-02f,
  3.86512220e-01f, -4.82362241e-01f, -1.25459388e-01f, -3.50317866e-01f, -8.38671848e-02f, -2.12537304e-01f, -1.20485201e-01f, -1.54893279e-01f, -2.77534127e-01f, -3.25839520e-02f,
  -2.21807182e-01f, -1.22594967e-01f, 6.34394074e-03f, -4.38688025e-02f, -7.22978413e-02f, -3.93876880e-02f, -1.26272246e-01f, -7.40941316e-02f, 9.85466465e-02f, -9.89833497e-04f,
  -1.09003223e-02f, 1.70268845e-02f, 4.11503613e-02f, -1.16328876e-02f, -9.14378986e-02f, -2.14188267e-02f, 6.75516725e-02f, -1.30265072e-01f, 6.01809584e-02f, -1.45850003e-01f,
  1.46854773e-01f, -1.10683344e-01f, -4.09517847e-02f, -4.30904627e-02f, -8.19785595e-02f, -1.06793858e-01f, 8.94256458e-02f, -1.96822528e-02f, 1.25882411e-02f, -2.68870927e-02f,
  -2.09394153e-02f, 1.14369757e-01f, 1.04134986e-02f, -6.32839054e-02f, 4.45305333e-02f, -2.44812686e-02f, -1.30112946e-01f, -3.17814872e-02f, 2.13884972e-02f, -1.86235666e-01f,
  -8.82119760e-02f, 5.44604752e-03f, 3.84329781e-02f, 1.00623541e-01f, 1.05622880e-01f, -5.47315553e-02f, -4.05716114e-02f, -1.86254666e-03f, -5.40860882e-03f, -6.94224313e-02f,
  1.49191722e-01f, 1.39582725e-02f, 5.86706549e-02f, -8.54736790e-02f, -4.23901379e-02f, 1.05348630e-02f, 3.36210318e-02f, 7.90686086e-02f, -7.71244243e-02f, 1.87407091e-01f,
  -5.35740005e-03f, 5.52164391e-02f, 7.69066736e-02f, -5.16326465e-02f, 1.64009869e-01f, 8.78840163e-02f, -1.04949571e-01f, -4.93712313e-02f, 6.34119287e-02f, 6.34367391e-02f,
  -4.86359932e-03f, -5.20428792e-02f, 1.35132983e-01f, 1.64772391e-01f, -4.05684188e-02f, 1.98136792e-01f, 2.59381115e-01f, 1.30478576e-01f, 2.29116797e-01f, 1.47118822e-01f,
  -7.23401368e-01f, -2.32724641e-02f, -5.04812360e-01f, -8.19002092e-01f, -2.62307227e-01f, 1.92472726e-01f, 6.00580394e-01f, 1.10104449e-01f, -4.68201756e-01f, -1.31517380e-01f,
  -6.86886087e-02f, -2.10262552e-01f, -4.93057877e-01f, -9.04461145e-02f, 2.65600443e-01f, 1.87027648e-01f, -1.68096200e-01f, -2.96371013e-01f, 1.32822871e-01f, 4.06912982e-01f,
  1.81969330e-01f, -2.95046717e-01f, -2.48684645e-01f, -1.75728783e-01f, -4.35969293e-01f, -2.73173273e-01f, -5.46205878e-01f, -3.86797279e-01f, -7.92339742e-02f, -4.15557534e-01f,
  1.49196818e-01f, -2.41485685e-01f, 7.76966065e-02f, -1.27901688e-01f, -1.33736953e-01f, 1.03648596e-01f, 2.37143278e-01f, -2.92900413e-01f, -1.20494500e-01f, -1.21852428e-01f,
  -1.73520893e-01f, -8.70988145e-03f, -1.64617151e-01f, 8.76681507e-02f, -1.53212890e-01f, 1.21610425e-01f, -2.87807494e-01f, -1.23878390e-01f, -1.96256801e-01f, 2.02772230e-01f,
  8.34199116e-02f, 2.18493268e-02f, -1.04393447e-02f, 1.24720812e-01f, 1.66038021e-01f, -1.76125064e-01f, 1.43031657e-01f, 1.62717089e-01f, 3.25449258e-02f, -1.05720498e-01f,
  1.56600848e-01f, -1.09393805e-01f, 3.58253904e-02f, 2.47638170e-02f, 1.16571583e-01f, 1.04118381e-02f, -6.16957955e-02f, 1.04585625e-01f, 7.01930448e-02f, 7.76860788e-02f,
  -6.55934215e-03f, 5.90209961e-02f, 2.43512802e-02f, -1.37268111e-01f, 5.36107318e-03f, -1.26102448e-01f, 5.74311055e-02f, 4.37453352e-02f, -3.92832011e-02f, -1.52436212e-01f,
  -3.68066914e-02f, -4.24400121e-02f, -2.27471769e-01f, 1.59960147e-02f, 2.64689140e-02f, -1.50884390e-01f, 8.57327948e-04f, 1.29647300e-01f, -1.24562167e-01f, -1.26606245e-02f,
  -1.86627522e-01f, 1.36811003e-01f, -1.49025664e-01f, 1.13280572e-01f, -8.26104134e-02f, -8.73056054e-02f, -1.15157224e-01f, -1.70271359e-02f, -2.67711461e-01f, 1.75021097e-01f,
  1.38375863e-01f, 3.86778638e-02f, -1.81795880e-01f, 3.05752046e-02f, 1.82252020e-01f, 6.86285645e-02f, 1.29478842e-01f, -8.04325342e-02f, 1.93686746e-02f, 4.17300947e-02f,
  7.96642900e-02f, 2.96145618e-01f, 2.15286747e-01f, 1.62382126e-01f, 1.81628853e-01f, 4.63015959e-02f, 2.01281413e-01f, 2.01858535e-01f, 2.83100843e-01f, 2.86364764e-01f,
  3.11071455e-01f, -3.28002155e-01f, -5.46322405e-01f, 1.96147934e-02f, -3.23965937e-01f, -4.50843036e-01f, -6.57408297e-01f, -5.87534085e-02f, 1.51167037e-02f, -3.42764020e-01f,
  -3.48697960e-01f, 5.29646985e-02f, -3.60849530e-01f, 2.37422460e-03f, -1.39800861e-01f, -2.98480332e-01f, -1.77780315e-01f, 2.17613317e-02f, 4.17863369e-01f, 5.05736887e-01f,
  3.51911962e-01f, 3.34107101e-01f, 3.50738794e-01f, 4.03034210e-01f, 3.53498369e-01f, 5.41520715e-02f, -3.10025007e-01f, 7.41075575e-02f, -3.23345140e-02f, 1.34219080e-01f,
  -1.82111353e-01f, 1.46738142e-01f, -7.37694502e-02f, 1.53145984e-01f, 5.67661747e-02f, 2.73504168e-01f, 1.54513359e-01f, 3.09833348e-01f, 9.74167362e-02f, 1.49498016e-01f,
  -1.26456141e-01f, 2.50065625e-01f, 9.13255736e-02f, 6.70384392e-02f, 1.21406332e-01f, 5.39087467e-02f, 2.40321547e-01f, 3.84434573e-02f, -1.86386630e-01f, 5.90679683e-02f,
  -1.04547024e-01f, -1.10775046e-01f, -4.09712613e-01f, -3.31446052e-01f, -2.17571557e-02f, -1.67400628e-01f, -1.37238443e-01f, 2.56098032e-01f, -2.26779699e-01f, -4.27387357e-02f,
  1.56104431e-01f, -3.43257631e-03f, -2.52883621e-02f, 8.36753845e-02f, 1.38124544e-02f, -2.96378471e-02f, 1.07773766e-02f, -1.74024209e-01f, 4.48123701e-02f, -1.58957895e-02f,
  -5.23980223e-02f, -1.08639494e-01f, 1.07633121e-01f, 3.40996161e-02f, 7.23911002e-02f, -6.03786446e-02f, -7.13344365e-02f, -6.75728321e-02f, -4.19873148e-02f, 4.21211459e-02f,
  -9.86143202e-02f, -1.74981833e-01f, -3.55701074e-02f, 1.46578297e-01f, -1.06677329e-02f, 5.26885726e-02f, 7.17391148e-02f, 2.08976194e-01f, 3.01799155e-03f, 3.05090845e-02f,
  -1.60770148e-01f, -1.93554938e-01f, -7.20757246e-02f, -3.85507569e-03f, -1.32354945e-01f, 2.56581493e-02f, -5.72619066e-02f, -2.77365744e-02f, -1.75431669e-01f, 1.19153544e-01f,
  2.24162880e-02f, -8.08022991e-02f, -4.83551323e-02f, 9.76459458e-02f, 1.44469351e-01f, 9.11676213e-02f, -5.47872274e-04f, -3.21879655e-01f, -2.23298788e-01f, 3.35317217e-02f,
  -1.67109653e-01f, -4.52624887e-01f, -5.17782092e-01f, -5.67203045e-01f, -6.71054125e-02f, -3.72971952e-01f, -2.33944058e-01f, -1.86023042e-01f, -4.19914752e-01f, -4.84913856e-01f,
  6.76373005e-01f, 3.13295931e-01f, 1.25558317e-01f, 2.02531815e-02f, -7.56350905e-02f, 1.34572396e-02f, 2.88580328e-01f, 2.92489737e-01f, -5.04372269e-02f, 5.60113788e-02f,
  -4.07967240e-01f, -6.32430792e-01f, -4.19085652e-01f, -3.87474060e-01f, -5.81518970e-02f, 1.89957261e-01f, 1.71687528e-01f, 3.10518574e-02f, 3.86646800e-02f, -6.71987459e-02f,
  -1.81882188e-01f, 2.75126278e-01f, 3.45885396e-01f, 1.28536046e-01f, -2.47121807e-02f, -2.71861196e-01f, 4.52256985e-02f, 1.26174271e-01f, 6.45279661e-02f, 9.63882431e-02f,
  -1.04350507e-01f, 4.54798311e-01f, -3.35002482e-01f, -2.28230059e-01f, -1.85072616e-01f, -9.97725800e-02f, -1.54628843e-01f, -1.14136130e-01f, -1.40713111e-01f, 7.71190897e-02f,
  -3.88645642e-02f, -1.50519550e-01f, -1.23623893e-01f, -5.58971353e-02f, 1.45637184e-01f, 1.00634377e-02f, -1.60317365e-02f, 9.46052447e-02f, -1.70135155e-01f, -1.90423369e-01f,
  -2.10169524e-01f, 7.83200935e-02f, 5.09350002e-02f, -3.11239045e-02f, -1.04963794e-01f, -1.88434541e-01f, 1.34656299e-02f, -6.20804057e-02f, 1.47190113e-02f, 2.18477145e-01f,
  -3.83306026e-01f, -6.48644343e-02f, 1.59091894e-02f, 4.84583229e-02f, -6.22068485e-03f, -3.09459604e-02f, -2.90497951e-03f, -4.34384570e-02f, -1.15826717e-02f, 9.76323187e-02f,
  -1.19103886e-01f, -1.44560724e-01f, -6.46005198e-02f, -1.66906472e-02f, -2.19627872e-01f, 1.56324599e-02f, 5.19363806e-02f, -3.74845155e-02f, -1.09993435e-01f, 3.72878052e-02f,
  1.71871856e-03f, 3.64628583e-02f, 2.77560353e-02f, 9.24191251e-02f, -4.41743657e-02f, -2.52541211e-02f, -8.92733037e-02f, -1.39906898e-01f, -4.83122803e-02f, 1.02636367e-01f,
  -9.05536264e-02f, -3.93000931e-01f, -2.05155406e-02f, -4.77748141e-02f, 9.06237364e-02f, -6.19108118e-02f, -2.31133848e-01f, -1.56600267e-01f, -3.32294554e-02f, 6.39424250e-02f,
  3.32448371e-02f, -8.97390693e-02f, -1.31970206e-02f, -5.50269112e-02f, 1.34632373e-02f, -4.21285592e-02f, -1.01802520e-01f, -1.40160039e-01f, -1.09692372e-01f, 6.86319917e-03f,
  -1.40286116e-02f, 1.05754875e-01f, 5.92141747e-02f, -1.04553565e-01f, -7.14659393e-02f, -2.25801721e-01f, 5.64818718e-02f, 1.70284603e-02f, 1.13394894e-01f, 2.13536516e-01f,
  -9.30910110e-02f, -3.27829182e-01f, 5.14109612e-01f, 4.49740559e-01f, -1.58538505e-01f, -2.42137119e-01f, -3.95733356e-01f, 2.74346862e-03f, 1.03700817e-01f, -2.21354887e-01f,
  -4.59607720e-01f, 4.53846380e-02f, 2.10070059e-01f, 2.82417178e-01f, 2.07817197e-01f, 2.00243071e-01f, 5.64801753e-01f, 6.76181436e-01f, 3.90853316e-01f, -5.66590279e-02f,
  -6.59522489e-02f, 2.76758105e-01f, 3.71817112e-01f, 3.01532060e-01f, 2.65078306e-01f, 3.45916361e-01f, 2.50976980e-01f, -3.11482660e-02f, 3.96945402e-02f, 5.60424984e-01f,
  -2.12104350e-01f, -3.41682553e-01f, 6.50160760e-02f, -2.08366781e-01f, -1.68539390e-01f, 1.42585963e-01f, 3.66115645e-02f, 2.64399275e-02f, -6.94643930e-02f, 7.93019906e-02f,
  -1.30106015e-02f, -4.91597094e-02f, 3.39973234e-02f, -1.13950923e-01f, -1.96614429e-01f, -2.50154674e-01f, 9.93357599e-02f, 2.10227862e-01f, 1.38025165e-01f, -1.54231831e-01f,
  1.58971567e-02f, -2.88999796e-01f, -2.60309786e-01f, -6.36129901e-02f, -6.12085946e-02f, 1.16595395e-01f, -2.11009070e-01f, -5.14877252e-02f, -9.96222198e-02f, 3.23280692e-02f,
  -1.48029208e-01f, -1.20429844e-01f, 4.34160121e-02f, 1.22446297e-02f, 4.23513539e-02f, 4.73672524e-02f, 7.55237341e-02f, 2.13805195e-02f, -4.39334810e-02f, 9.13511291e-02f,
  1.05015106e-01f, 2.87024248e-02f, 2.64536589e-02f, 2.98838206e-02f, 1.77838966e-01f, 3.63811404e-02f, -4.10685129e-02f, 1.31576672e-01f, -1.19611314e-02f, -2.95446807e-04f,
  -7.82562569e-02f, 1.26898676e-01f, 6.16108105e-02f, 2.32783660e-01f, 9.42413211e-02f, 2.15259373e-01f, 1.84929714e-01f, -7.53757805e-02f, 2.09496617e-02f, -2.14575112e-01f,
  -1.65395856e-01f, -1.28412023e-01f, -5.19646183e-02f, 4.06925753e-02f, -2.13051513e-01f, -1.17056251e-01f, -5.55850007e-02f, -1.53456749e-02f, -7.21705556e-02f, 9.08738822e-02f,
  -1.24157593e-01f, 2.35695336e-02f, -6.55886903e-02f, 7.19762444e-02f, -2.29590967e-01f, -2.56117046e-01f, -9.59422588e-02f, 9.93670896e-02f, -2.23109145e-02f, -1.15354702e-01f,
  1.83696866e-01f, -2.47064665e-01f, -2.36736715e-01f, -2.21296370e-01f, -3.81311655e-01f, -1.56016022e-01f, -9.87142175e-02f, -1.72234207e-01f, -2.80432135e-01f, -4.49706107e-01f,
  -3.60303938e-01f, 5.62584758e-01f, 4.63460863e-01f, -3.85623932e-01f, 3.01060706e-01f, 3.45238358e-01f, 5.69175243e-01f, 9.76371914e-02f, -2.96441525e-01f, 3.19717944e-01f,
  5.23892641e-01f, -3.80908698e-01f, -2.27216735e-01f, -2.61438578e-01f, -1.50423855e-01f, 2.87185252e-01f, 1.44295216e-01f, -2.82169878e-01f, -4.86238271e-01f, -4.48622733e-01f,
  -2.16683641e-01f, -2.92172670e-01f, -2.75164694e-01f, -2.71804154e-01f, -1.26150876e-01f, -2.61908114e-01f, 4.11998361e-01f, 2.32515886e-01f, 3.73229355e-01f, -2.13705510e-01f,
  1.49292111e-01f, 4.89484549e-01f, -3.66077691e-01f, -8.98254216e-02f, 8.38038921e-02f, -2.13233501e-01f, -9.26699396e-03f, -4.62957062e-02f, 1.09909289e-01f, -1.50403693e-01f,
  1.85525790e-01f, 8.93582478e-02f, 9.67153609e-02f, 1.00373983e-01f, 2.10996166e-01f, 4.56845164e-02f, 1.57433540e-01f, -1.79916576e-01f, -5.35566434e-02f, 1.33004591e-01f,
  5.93258403e-02f, 3.10206145e-01f, 2.85851687e-01f, 1.80370748e-01f, 4.12902161e-02f, -4.00425136e-01f, 2.48586044e-01f, -1.40213743e-01f, 1.41596243e-01f, -3.33190680e-01f,
  -1.47917166e-01f, 1.15164936e-01f, -6.38054637e-03f, 3.07025947e-02f, -2.39724349e-02f, 8.56516287e-02f, 5.59244528e-02f, 6.74656555e-02f, -8.05045962e-02f, 4.10324372e-02f,
  7.37719238e-02f, 5.37014529e-02f, 8.15687031e-02f, 2.28821695e-01f, -9.09052938e-02f, 5.44716343e-02f, 6.02299199e-02f, 7.00247735e-02f, 8.33015591e-02f, 9.35042202e-02f,
  -7.46404529e-02f, 5.86513914e-02f, 7.32649639e-02f, -7.29579031e-02f, 9.67153758e-02f, 1.80221811e-01f, -9.31869969e-02f, -1.58264097e-02f, -7.19772652e-03f, 3.23846996e-01f,
  -3.19433153e-01f, 5.03252447e-01f, -2.94755101e-01f, 3.66259180e-02f, 2.39394665e-01f, 1.33013362e-02f, 7.11612627e-02f, -6.25188723e-02f, -5.66328818e-04f, -6.89593256e-02f,
  -1.35752447e-02f, -1.17406525e-01f, 1.49285346e-01f, 4.69402298e-02f, -2.09989771e-01f, -1.08938858e-01f, 9.39455852e-02f, -6.46523610e-02f, -1.54095173e-01f, 3.42601128e-02f,
  5.99823434e-05f, -1.92138523e-01f, -3.82827938e-01f, -1.82434380e-01f, -1.90278023e-01f, -4.16345716e-01f, -1.50790095e-01f, -1.08390555e-01f, -1.50732040e-01f, -3.89937222e-01f,
  4.72497910e-01f, 2.03036383e-01f, -8.16792436e-03f, 1.70181662e-01f, 1.51513144e-01f, 1.30681708e-01f, 1.12700731e-01f, 1.38010662e-02f, 2.16453403e-01f, 1.82059243e-01f,
  2.36509576e-01f, 2.27206275e-01f, 2.07724601e-01f, 2.14060694e-01f, 1.05800353e-01f, 1.83651850e-01f, 1.77456453e-01f, 1.48902431e-01f, -3.42840627e-02f, 1.96852848e-01f,
  8.16184878e-02f, 1.71068981e-01f, 8.34375620e-02f, 9.35984179e-02f, 2.29795635e-01f, 1.36198774e-01f, 9.45002958e-02f, 9.25747827e-02f, 2.18228936e-01f, 2.90187359e-01f,
  -7.73374550e-03f, 6.08531274e-02f, -2.95768026e-02f, 4.83301748e-03f, -7.85270259e-02f, -8.91244337e-02f, -8.00932869e-02f, -1.58428594e-01f, -9.62513015e-02f, -1.41312182e-01f,
  6.97454717e-03f, -1.11242473e-01f, -1.03853725e-01f, -8.49633887e-02f, -3.81226987e-02f, 3.45361396e-03f, -6.93838671e-02f, 6.06423840e-02f, -7.28078699e-03f, 4.89243120e-02f,
  5.98855168e-02f, -1.14761665e-01f, -1.15710758e-01f, -1.48021922e-01f, 2.59029437e-02f, 4.32371125e-02f, 1.40402755e-02f, -1.52416481e-03f, -1.18844010e-01f, 2.21085325e-02f,
  2.97173351e-01f, 1.11765608e-01f, 1.43393070e-01f, 3.35866451e-01f, 2.59875089e-01f, 1.20792545e-01f, 5.68616875e-02f, 7.22992122e-02f, 7.08502457e-02f, 2.82184165e-02f,
  -3.16564254e-02f, 1.28849983e-01f, 3.95429842e-02f, -2.06864364e-02f, 1.24974720e-01f, -1.14943441e-02f, 6.30373368e-04f, -8.35186094e-02f, 4.58089262e-02f, 5.80633096e-02f,
  -2.25439779e-02f, -9.01677832e-02f, -6.77861422e-02f, 1.24338139e-02f, -2.93023326e-02f, -5.72377406e-02f, 9.41204932e-03f, -9.57820937e-02f, -3.50264125e-02f, -3.58197652e-03f,
  -3.73997182e-01f, -3.12922537e-01f, 1.35219604e-01f, -4.62708436e-02f, -3.63544598e-02f, -1.42431244e-01f, -1.08326729e-02f, -1.03742518e-01f, -9.82982814e-02f, -4.18933965e-02f,
  -7.62858987e-02f, -1.43523261e-01f, -3.06808278e-02f, -7.63633326e-02f, -4.52744737e-02f, -1.79549918e-01f, 6.82048872e-02f, -1.26943152e-04f, -1.25689074e-01f, -2.00731993e-01f,
  -1.68088317e-01f, -2.52822280e-01f, -2.25877926e-01f, -1.95734441e-01f, -1.60210077e-02f, -1.20523587e-01f, -2.56130159e-01f, -1.43235102e-01f, -2.58893877e-01f, -1.78531289e-01f,
  -6.51997387e-01f, -9.40429270e-02f, -2.69002229e-01f, -4.31097806e-01f, 1.95828915e-01f, 2.39736468e-01f, 2.15337142e-01f, 6.84524402e-02f, -2.29878351e-01f, -1.79874346e-01f,
  7.40534663e-02f, -6.73914552e-02f, -2.55364805e-01f, -1.40767265e-02f, -1.43146336e-01f, -2.17987120e-01f, -2.69584298e-01f, -3.78646165e-01f, -3.82826924e-02f, 3.67979497e-01f,
  3.05394590e-01f, -2.02679828e-01f, -3.11279416e-01f, -4.55681272e-02f, 2.55971793e-02f, -8.62409025e-02f, -1.64674699e-01f, -2.47402713e-01f, 1.11883894e-01f, -2.84086972e-01f,
  -3.63950968e-01f, -1.79396734e-01f, 2.64589995e-01f, 1.02839842e-01f, -6.20507486e-02f, -1.51091278e-01f, 4.16817218e-02f, -1.47848010e-01f, 1.05762683e-01f, -2.05435097e-01f,
  -8.07531700e-02f, 2.25238159e-01f, -3.26839741e-03f, 3.46744508e-02f, -5.38676977e-03f, -1.43620446e-02f, -2.40408853e-02f, -8.92311409e-02f, -2.34855205e-01f, 2.85455864e-02f,
  1.96027428e-01f, -2.84886695e-02f, -3.19547176e-01f, 7.16508925e-02f, 8.68867859e-02f, -1.77790374e-01f, 1.05648264e-01f, 6.27119541e-02f, -1.94711342e-01f, -4.73712415e-01f,
  5.42028695e-02f, 4.64095697e-02f, 7.95213282e-02f, 1.24531254e-01f, -1.66919213e-02f, -5.77938333e-02f, -3.31354770e-03f, -3.47211882e-02f, 1.07039988e-01f, -1.58901960e-01f,
  3.24354582e-02f, 3.52679566e-02f, 2.71441676e-02f, -1.70121733e-02f, -6.30006567e-02f, -1.10319242e-01f, -1.35562956e-01f, -4.02853191e-02f, -5.52085005e-02f, 5.04070288e-03f,
  -7.09117902e-03f, -4.44266796e-02f, 5.11364453e-02f, 4.10974994e-02f, 6.24507032e-02f, -2.95640691e-03f, 1.18728904e-02f, 2.19499823e-02f, -1.27156023e-02f, -4.38303873e-02f,
  -3.36104870e-01f, 7.98256695e-02f, -3.18182588e-01f, 1.46282539e-01f, 5.46466373e-02f, 5.65211326e-02f, -1.68023080e-01f, 7.23164603e-02f, -4.27111536e-02f, 3.44403796e-02f,
  1.36487260e-01f, -2.34452374e-02f, -1.81881696e-01f, 9.88108739e-02f, -1.64916739e-02f, -5.07196970e-03f, -6.05821609e-02f, -2.57069021e-01f, 3.44911441e-02f, 9.09179598e-02f,
  -2.33281419e-01f, -3.35549116e-01f, -5.41485846e-01f, -2.56520391e-01f, -4.10557771e-03f, -4.00976241e-01f, -2.88332611e-01f, -1.60483256e-01f, -2.21565738e-01f, -4.85549152e-01f,
  9.51283649e-02f, -8.67369175e-02f, -3.37291770e-02f, 2.97901571e-01f, 2.34172449e-01f, -8.87919813e-02f, -4.75899607e-01f, 1.25981020e-02f, 3.03050935e-01f, -3.18044722e-01f,
  1.00300282e-01f, 2.96469301e-01f, 4.89683934e-02f, -2.13025764e-01f, -5.89584708e-01f, -6.24297559e-01f, -5.49517870e-01f, -2.85741925e-01f, -8.56964439e-02f, -2.11205155e-01f,
  -1.24014840e-01f, -2.78993230e-02f, -2.70519346e-01f, -2.12836444e-01f, 2.48733059e-01f, 1.20018691e-01f, -4.74426039e-02f, 3.83234099e-02f, -2.84457624e-01f, -1.28447846e-01f,
  -8.41003805e-02f, 2.87069112e-01f, -3.95325609e-02f, -2.29786374e-02f, 1.24527909e-01f, -4.40511778e-02f, 2.87850648e-02f, 4.27570604e-02f, -1.30819288e-04f, -1.56970218e-01f,
  3.77321569e-03f, 5.73438369e-02f, -7.72225931e-02f, 9.11088958e-02f, -1.25008300e-01f, -4.26762551e-02f, -8.20412487e-02f, -8.75580385e-02f, -6.23322800e-02f, 3.11108865e-02f,
  -2.79901605e-02f, -7.61130750e-02f, -8.73929709e-02f, -9.18361321e-02f, -9.71521959e-02f, -2.94671692e-02f, -4.74587455e-02f, 5.09510748e-02f, -3.74921262e-01f, -2.32708618e-01f,
  -1.37236774e-01f, 1.74695868e-02f, -3.12118623e-02f, 8.99640769e-02f, -1.31452098e-01f, 6.05233051e-02f, 4.86728251e-02f, -1.49022117e-01f, 2.28796862e-02f, 2.16587316e-02f,
  9.01988819e-02f, -4.16059121e-02f, -3.43646184e-02f, -1.93877563e-01f, -9.24797803e-02f, -2.67767385e-02f, -1.39608547e-01f, -2.36591011e-01f, -1.64035395e-01f, -1.20503575e-01f,
  -1.32098785e-02f, -4.89639230e-02f, 1.04306482e-01f, -1.53515399e-01f, -1.61279321e-01f, -2.01458901e-01f, 9.29029733e-02f, 1.03227168e-01f, 1.08239032e-01f, -3.31352428e-02f,
  1.74701497e-01f, -2.41285846e-01f, -1.01456374e-01f, -1.67814940e-01f, 5.60740046e-02f, 8.76129121e-02f, 5.13137802e-02f, 1.68755222e-02f, 1.73017204e-01f, 1.65247303e-02f,
  -1.12066500e-01f, -1.31390005e-01f, -1.14508450e-01f, -4.39003855e-02f, -1.14097469e-01f, -2.97185243e-03f, -3.44460040e-01f, -8.06763675e-03f, -2.14808032e-01f, 9.72815901e-02f,
  -1.64105773e-01f, -3.93169373e-01f, -2.94085264e-01f, -1.20065153e-01f, -1.97399884e-01f, -1.16390198e-01f, -2.43394211e-01f, -1.89089999e-01f, -5.69454014e-01f, -5.77564061e-01f,
  -7.27053165e-01f, -2.35886484e-01f, 6.19703054e-01f, -3.11218679e-01f, -5.28945774e-02f, -7.83519149e-02f, -4.67151225e-01f, 1.33058116e-01f, 1.24045551e-01f, -2.32939214e-01f,
  -1.17446639e-01f, -1.34338737e-02f, 2.73149639e-01f, 4.11295369e-02f, -1.90782487e-01f, -3.32380146e-01f, -1.20201677e-01f, 2.57548857e-02f, -1.11288935e-01f, -5.50861061e-01f,
  -5.10356247e-01f, -3.07296634e-01f, -7.79816881e-02f, -5.41615114e-02f, -7.23796291e-03f, 3.77270505e-02f, 2.76397377e-01f, -7.71546513e-02f, -5.35209849e-02f, -1.06219478e-01f,
  1.30544275e-01f, 1.42362118e-01f, 7.24194050e-02f, 5.77495806e-03f, 5.14749959e-02f, -1.23862065e-01f, 2.90465401e-03f, 1.43361747e-01f, -1.47854909e-01f, 6.03474118e-03f,
  -1.26860008e-01f, -4.02476266e-02f, -7.44382218e-02f, -6.41077235e-02f, -1.14420407e-01f, -1.18358299e-01f, -2.81692203e-03f, 1.76568508e-01f, 1.40955091e-01f, 1.24505036e-01f,
  -4.86118704e-01f, -3.94227743e-01f, 2.46075138e-01f, 3.33945125e-01f, 2.07723707e-01f, -8.25016424e-02f, 2.69176841e-01f, 1.48506567e-01f, 1.63771912e-01f, 4.33377884e-02f,
  -5.08417897e-02f, 1.72797412e-01f, -7.64080063e-02f, 3.64724733e-02f, -1.04422934e-01f, 4.95226756e-02f, -5.49810417e-02f, -1.87629402e-01f, 2.83339090e-04f, 3.77872959e-02f,
  3.91058512e-02f, 6.52033240e-02f, 1.24685794e-01f, -1.02715105e-01f, -2.08839239e-03f, -1.70573458e-01f, -1.20033287e-01f, -1.03228584e-01f, -1.02577120e-01f, -2.42512599e-02f,
  -1.74454153e-01f, -2.96042878e-02f, 2.33918503e-02f, -1.03261389e-01f, -9.38850120e-02f, -4.33946378e-04f, -1.96912467e-01f, 9.32598114e-02f, -5.51523119e-02f, -1.03987217e-01f,
  2.75313646e-01f, 8.51096883e-02f, -2.74993688e-01f, 6.39360249e-02f, -1.54109001e-02f, 4.06170897e-02f, -8.37954953e-02f, -9.84360580e-04f, -6.67186640e-03f, -2.76590008e-02f,
  2.16504708e-02f, -4.62692305e-02f, -2.84562744e-02f, -3.99391986e-02f, -1.42455831e-01f, -1.28887266e-01f, -5.66156566e-01f, -1.34385973e-01f, -1.09679610e-01f, -2.16064483e-01f,
  -3.16938579e-01f, -5.73233485e-01f, -3.39655727e-01f, -1.87718257e-01f, -4.62300554e-02f, -8.74702558e-02f, 1.65284425e-01f, 5.83943091e-02f, -7.57493153e-02f, -4.33523923e-01f,
  -7.03590930e-01f, -2.45785162e-01f, 2.72497058e-01f, -4.35311854e-01f, 3.68495405e-01f, 5.18796206e-01f, 6.23067439e-01f, 3.22059959e-01f, -2.76885688e-01f, 8.61202255e-02f,
  -5.10547832e-02f, -3.63650590e-01f, -3.74911875e-01f, -3.00933532e-02f, 2.10243836e-01f, 4.43950623e-01f, 5.37494540e-01f, 2.34642953e-01f, 1.65506452e-01f, 3.15720767e-01f,
  1.10481001e-01f, -2.48975605e-02f, -2.03166768e-01f, -6.19186163e-02f, -2.01322913e-01f, -1.74638107e-01f, -3.07146236e-02f, -1.11977205e-01f, 3.10867697e-01f, -1.77676618e-01f,
  -4.98040468e-01f, -2.78495073e-01f, 3.60506266e-01f, 1.85158029e-02f, 1.63758751e-02f, -5.06117567e-03f, -4.67552291e-03f, 1.25746265e-01f, 8.37929919e-02f, -4.52630594e-02f,
  8.43134299e-02f, -9.87360999e-02f, -6.98038116e-02f, 1.01943441e-01f, -1.91348389e-01f, 7.71528631e-02f, 3.83715369e-02f, 5.93007803e-02f, -1.11962758e-01f, 9.35232565e-02f,
  1.26749247e-01f, 8.10838714e-02f, -4.14190777e-02f, 2.76614338e-01f, -5.97064719e-02f, 9.01091918e-02f, -1.81900058e-03f, -1.51018366e-01f, -1.51071977e-02f, -3.33409607e-01f,
  -6.36928231e-02f, 1.56563323e-03f, 2.01735254e-02f, -2.26061627e-01f, -1.56741410e-01f, -7.56978467e-02f, -1.59652427e-01f, -7.26294965e-02f, -2.77074352e-02f, -1.54048145e-01f,
  -6.39840215e-02f, -8.59981328e-02f, -2.51333117e-01f, -2.28887707e-01f, -2.38853529e-01f, -6.22339882e-02f, 8.78769457e-02f, -1.01268895e-01f, 7.31787132e-03f, 2.20229980e-02f,
  -1.56288967e-01f, -4.03886922e-02f, -1.21461146e-01f, -8.37797225e-02f, 3.36368829e-02f, -3.81780267e-02f, -1.51300088e-01f, -2.18458191e-01f, -2.15816557e-01f, 1.17568914e-02f,
  -5.08967042e-01f, 5.38287938e-01f, -3.88981104e-01f, -5.94672821e-02f, -1.25652596e-01f, 8.61080736e-02f, 1.06901871e-02f, 5.84354885e-02f, -2.86560040e-02f, -1.61342844e-01f,
  1.11812942e-01f, -1.04483560e-01f, -2.08061397e-01f, 1.05305284e-01f, 9.96875614e-02f, -5.94879426e-02f, 2.46212110e-01f, 6.29606172e-02f, 1.35605350e-01f, -1.05384067e-02f,
  1.48750305e-01f, 9.42312405e-02f, -2.12557763e-01f, -1.48307815e-01f, -1.55298024e-01f, -1.41078785e-01f, -1.04160793e-01f, -1.20293595e-01f, 1.81133866e-01f, -2.56842766e-02f,
  1.51531726e-01f, -1.81259900e-01f, -5.74572384e-01f, -2.27473095e-01f, -3.36983740e-01f, -2.55262762e-01f, -1.10896915e-01f, 1.92538887e-01f, 3.73606011e-02f, -9.97322947e-02f,
  2.63133943e-01f, 8.76307368e-01f, 6.10067010e-01f, 5.53906620e-01f, 4.35929984e-01f, -4.26034063e-01f, -6.29188716e-01f, -5.74246757e-02f, 3.89940500e-01f, 3.08668196e-01f,
  9.11683962e-02f, -1.08922958e-01f, 8.26198831e-02f, 1.67270247e-02f, -3.90909076e-01f, -3.67949754e-02f, -4.59692687e-01f, -4.94166762e-01f, -3.55541229e-01f, -7.60447145e-01f,
  2.51567483e-01f, -3.06736410e-01f, 8.26044753e-02f, -1.27531245e-01f, -2.05776244e-01f, 1.70823544e-01f, 4.21627276e-02f, -1.37221366e-01f, -6.66811690e-02f, -1.72177002e-01f,
  -7.75749087e-02f, 2.03291653e-03f, 3.24129104e-03f, 1.99903045e-02f, -2.28348628e-01f, -2.82122847e-03f, -1.77177772e-01f, -1.41017482e-01f, -6.16848953e-02f, -9.86664090e-03f,
  -1.26735941e-01f, -4.36924905e-01f, -3.24883252e-01f, -1.75886810e-01f, -3.05671599e-02f, -7.98358172e-02f, -9.28112939e-02f, -2.77425200e-01f, -7.27433786e-02f, -3.41525823e-01f,
  7.43257329e-02f, 2.19897851e-02f, -1.38342425e-01f, -2.88795177e-02f, 1.09130822e-01f, 5.51027507e-02f, -8.37320909e-02f, -1.64613515e-01f, 4.93572047e-03f, 6.44148588e-02f,
  -3.77109908e-02f, -4.30380926e-02f, 3.90208699e-02f, -7.89248794e-02f, 2.95176879e-02f, -2.14047551e-01f, -7.09957704e-02f, 1.37231633e-01f, -8.76603927e-03f, 3.79026867e-02f,
  3.51262353e-02f, -1.41563103e-01f, -8.91205594e-02f, -1.02819372e-02f, -5.15279546e-03f, -1.07424609e-01f, 6.57856613e-02f, 1.19730502e-01f, 6.19393401e-02f, -5.86130619e-02f,
  4.64035928e-01f, 9.83461887e-02f, 4.53535132e-02f, -1.05787478e-02f, -3.20984274e-01f, -2.01345095e-03f, -6.54943436e-02f, 4.23711725e-02f, -1.76852697e-03f, 9.49722305e-02f,
  1.23555390e-02f, 1.92661837e-01f, 6.95540607e-02f, -1.19123176e-01f, -2.99895909e-02f, 3.97545956e-02f, 8.82300660e-02f, 1.27105378e-02f, -3.47896628e-02f, -3.11607216e-02f,
  -1.24672115e-01f, -9.33130905e-02f, 1.12203382e-01f, 9.62253213e-02f, -8.00671875e-02f, 1.74239099e-01f, 6.76013604e-02f, 1.30897492e-01f, 1.77390024e-01f, 1.11353479e-01f,
  3.82168949e-01f, -2.16036126e-01f, 3.88615881e-03f, -1.91937447e-01f, 1.24151260e-01f, 2.39879787e-01f, 2.89945692e-01f, 8.22491851e-03f, -7.20178112e-02f, -4.18495759e-02f,
  -9.44974124e-02f, -2.51427680e-01f, -2.42900044e-01f, -2.04908177e-01f, -6.95950389e-02f, -1.23555062e-03f, -6.29205303e-03f, 8.42476264e-02f, 7.19774067e-02f, 9.15771350e-02f,
  -1.48203954e-01f, -2.67108291e-01f, -4.57693078e-02f, -1.41717508e-01f, -4.13195848e-01f, -2.12960333e-01f, -2.46299952e-01f, -1.58483222e-01f, -8.21312703e-03f, -3.30127895e-01f,
  -2.56918937e-01f, 1.43167451e-01f, 7.12602437e-02f, -9.67213511e-02f, -1.22848898e-01f, 5.80598935e-02f, -3.25184092e-02f, -2.40180213e-02f, -8.30433592e-02f, 2.98487265e-02f,
  -1.36409342e-01f, -3.77718695e-02f, 2.45858841e-02f, 2.15420965e-02f, -4.70580459e-02f, 8.84401724e-02f, 3.37347463e-02f, 7.27653205e-02f, 1.23905614e-02f, -1.04803920e-01f,
  -7.43090287e-02f, 1.04361139e-01f, 2.42543891e-01f, 2.03552157e-01f, 2.50169158e-01f, 1.20758094e-01f, 3.72725911e-03f, 6.90308958e-02f, 1.54399231e-01f, 9.86458510e-02f,
  -1.06745899e-01f, 1.72797088e-02f, 3.84322694e-03f, -3.39368470e-02f, 2.08992273e-01f, 1.83391199e-01f, -3.52156088e-02f, 3.67014147e-02f, 1.84010550e-01f, 1.39795169e-02f,
  6.10323399e-02f, 1.35660321e-01f, 4.68408354e-02f, 2.23697051e-02f, -3.02249435e-02f, -8.31454545e-02f, 1.57562539e-01f, 1.29290372e-02f, -2.31248755e-02f, 2.84942314e-02f,
  6.35830760e-02f, -1.12177553e-02f, -5.29323965e-02f, -6.21911371e-03f, -2.87415236e-02f, 5.42534776e-02f, -4.56052534e-02f, 6.42286837e-02f, -3.13239358e-02f, -6.53527603e-02f,
  -2.25714579e-01f, 3.42699766e-01f, -5.24607934e-02f, -1.56480893e-01f, 3.01517434e-02f, -1.29653150e-02f, 2.48692464e-02f, -1.62217587e-01f, -2.16576770e-01f, -4.39389423e-03f,
  -9.22057629e-02f, -8.07299539e-02f, -1.03489034e-01f, -2.13094726e-02f, 1.04186326e-01f, 1.08146459e-01f, 1.51164278e-01f, 1.28131688e-01f, 3.68385464e-02f, -2.09014729e-01f,
  -5.10825180e-02f, 2.24871233e-01f, 7.67731890e-02f, 6.76290393e-02f, 2.02375934e-01f, 2.04736888e-01f, 4.23477218e-02f, 1.14228077e-01f, 2.17501014e-01f, 5.46539389e-02f,
  -8.41096640e-01f, 5.39180696e-01f, 1.53566614e-01f, -2.78004020e-01f, 5.77099249e-02f, 1.25242755e-01f, 2.62703329e-01f, -2.24156886e-01f, -5.73108196e-02f, 2.84391701e-01f,
  1.28767788e-01f, -8.48234519e-02f, 2.69429713e-01f, 8.87717009e-02f, -1.92860648e-01f, 4.57406789e-01f, 3.79059523e-01f, -1.81995347e-01f, -6.96172059e-01f, -6.02523744e-01f,
  -3.94613408e-02f, -2.75523037e-01f, -5.63610077e-01f, -2.06162885e-01f, 1.58798307e-01f, -1.62198022e-02f, 3.54360163e-01f, -6.02183826e-02f, 1.21196143e-01f, 3.69582087e-01f,
  2.52583861e-01f, -3.63344669e-01f, -2.72535235e-02f, -2.43484050e-01f, 1.53425336e-01f, -1.27054319e-01f, -8.91852900e-02f, 1.63010787e-02f, -2.22023800e-02f, 1.34188354e-01f,
  5.16891666e-03f, -5.85732348e-02f, 1.28168434e-01f, -2.50692456e-03f, -7.76768401e-02f, -2.90484816e-01f, -1.73692852e-01f, -4.25649911e-01f, -3.21405053e-01f, -2.38826916e-01f,
  1.83306068e-01f, -3.52110863e-01f, -2.35048279e-01f, -1.12145483e-01f, -1.36529222e-01f, -2.31640860e-01f, -1.76660091e-01f, -5.09297788e-01f, -3.29684854e-01f, -2.69372493e-01f,
  -3.77394482e-02f, -1.51432250e-02f, -5.02005108e-02f, -6.40302226e-02f, 3.52223814e-02f, 1.43620446e-01f, 2.00255871e-01f, 6.00498095e-02f, 1.58970812e-04f, -6.98878020e-02f,
  2.44345376e-03f, -7.68890381e-02f, -6.70588985e-02f, 7.66924769e-02f, 2.35740356e-02f, -1.45947561e-01f, -1.38591845e-02f, 8.78415555e-02f, -1.08937286e-02f, -4.07906063e-03f,
  7.46515393e-03f, -5.34136668e-02f, -1.97539423e-02f, -3.18198279e-02f, 1.02738433e-01f, 4.87621911e-02f, -6.57947361e-02f, -5.84243760e-02f, -1.20643206e-01f, -5.39875217e-02f,
  -1.60950154e-01f, -2.24270046e-01f, 1.53135970e-01f, 1.50556108e-02f, 8.39728937e-02f, 1.03442922e-01f, 9.72184762e-02f, -1.54024586e-02f, 2.06087828e-01f, -6.35763677e-03f,
  -1.29494488e-01f, -1.72855216e-03f, 3.20428312e-01f, 4.37491126e-02f, -1.77574128e-01f, 1.04318164e-01f, 8.90508816e-02f, -6.96154311e-02f, -5.63654862e-02f, 7.79548718e-04f,
  7.71672800e-02f, -3.09624761e-01f, -1.44441739e-01f, 1.66315958e-01f, -9.03634578e-02f, -1.92859486e-01f, 2.32031271e-02f, -2.68010020e-01f, -1.24150231e-01f, 1.59909856e-03f,
  -4.50576156e-01f, -1.38406247e-01f, -1.53249562e-01f, -4.51724052e-01f, 6.59421086e-02f, 9.97387916e-02f, 5.37895598e-02f, -1.18597718e-02f, -1.51576832e-01f, -4.25540417e-01f,
  1.60102785e-01f, 1.17555477e-01f, -4.59060758e-01f, -1.75376773e-01f, -2.96119213e-01f, -6.57066047e-01f, -6.08365715e-01f, -3.75122219e-01f, 5.25767319e-02f, 4.22567189e-01f,
  2.32346788e-01f, -1.49931967e-01f, -1.84924886e-01f, -8.55926201e-02f, -1.67228207e-01f, -9.58321542e-02f, -2.07515672e-01f, -8.82209539e-02f, 7.37892613e-02f, -2.15622008e-01f,
  -2.58797228e-01f, 2.20455542e-01f, 2.87474424e-01f, 4.80033569e-02f, -1.11254245e-01f, 4.52382490e-02f, 2.39414033e-02f, -4.45189513e-02f, 1.25837520e-01f, -2.20884174e-01f,
  4.94820289e-02f, 2.73258448e-01f, 2.90917605e-02f, 1.85087860e-01f, -6.63661361e-02f, 6.14484213e-02f, -1.51576102e-01f, -1.08350299e-01f, -1.44982785e-01f, 2.63915807e-01f,
  1.80739060e-01f, -8.07150453e-02f, -2.60948569e-01f, 1.32742837e-01f, 3.45202454e-04f, -1.12778984e-01f, 8.95582438e-02f, 3.27487081e-01f, -5.19521385e-02f, -2.04575405e-01f,
  -2.03367658e-02f, -1.39026836e-01f, 8.75267312e-02f, 1.43541276e-01f, -1.07722193e-01f, -1.23487590e-02f, -1.03437968e-01f, -3.56018730e-02f, 1.97773725e-01f, -6.60641957e-03f,
  1.98314292e-03f, 1.08842224e-01f, 1.08912930e-01f, -4.14670072e-02f, -5.96894100e-02f, -6.25218153e-02f, -1.67064160e-01f, -5.82574718e-02f, -3.29289734e-02f, -4.84260842e-02f,
  -1.24263121e-02f, -4.37310822e-02f, -1.51963115e-01f, -9.65175033e-02f, 1.95893630e-01f, -9.63168293e-02f, -6.58828113e-03f, 1.84758782e-01f, 5.23769855e-03f, 4.79729325e-02f,
  -4.44227785e-01f, 1.05175883e-01f, -3.34737301e-01f, 9.24172699e-02f, -1.45082608e-01f, 8.13501626e-02f, -2.64150761e-02f, 5.31672053e-02f, -1.25261769e-01f, 3.78169641e-02f,
  2.83629268e-01f, -1.24220252e-01f, -3.73935401e-01f, 7.10002482e-02f, 1.06497146e-01f, 3.82238105e-02f, -1.24790795e-01f, -1.14979304e-01f, -5.37200533e-02f, -2.77494323e-02f,
  -2.52211481e-01f, -2.56700903e-01f, -4.69676226e-01f, -2.70830363e-01f, -4.83997166e-02f, -2.97645688e-01f, -1.44462004e-01f, 8.57755542e-02f, -3.63265902e-01f, -5.45358956e-01f,
  -3.35433632e-01f, -4.44778353e-02f, -5.20450056e-01f, 5.66671431e-01f, 3.70261729e-01f, -1.85793102e-01f, -4.81890559e-01f, -3.00202966e-01f, 4.42893147e-01f, -4.20158990e-02f,
  1.99564159e-01f, 2.96368837e-01f, 2.98431605e-01f, -6.94365278e-02f, -5.03122926e-01f, -8.45484734e-02f, 1.19375400e-01f, -3.83006126e-01f, -5.64889312e-01f, -3.19543898e-01f,
  1.63992748e-01f, 1.82629913e-01f, -2.31729344e-01f, -8.07359591e-02f, 5.74537754e-01f, 1.73224851e-01f, 2.58506387e-01f, 1.95741534e-01f, -1.13725357e-01f, 3.25025439e-01f,
  -3.36435318e-01f, -2.87154078e-01f, -3.06696028e-01f, 2.11649626e-01f, 1.20110512e-01f, -3.11288476e-01f, -2.62248784e-01f, -9.46978405e-02f, 4.10670601e-02f, -5.84530011e-02f,
  1.59219235e-01f, -1.17919274e-01f, 3.11599582e-01f, 1.12333847e-02f, 1.38135672e-01f, -2.16200784e-01f, -1.02030180e-01f, -4.18801457e-01f, -3.58708113e-01f, -3.58362138e-01f,
  2.30332181e-01f, -4.01100889e-02f, -3.78231585e-01f, -2.74287701e-01f, -3.47724050e-01f, -3.60528678e-02f, -3.79867494e-01f, -3.57367396e-01f, -5.48700809e-01f, -2.60331511e-01f,
  -1.05831176e-01f, -6.12535588e-02f, 8.68865699e-02f, 7.27034435e-02f, 2.02741977e-02f, 6.55960590e-02f, 1.92331642e-01f, -3.53233702e-02f, 9.98204350e-02f, -9.63028371e-02f,
  -6.07477874e-02f, -1.66158900e-01f, -1.20445676e-02f, -6.35777116e-02f, 1.71717927e-01f, -6.50002137e-02f, -8.91502798e-02f, -1.65891811e-01f, -1.58357099e-01f, -6.60917163e-02f,
  -3.38206552e-02f, -1.05556309e-01f, 2.59280622e-01f, -1.05362862e-01f, -1.00178108e-01f, -1.32371753e-01f, -1.50393592e-02f, -4.27026972e-02f, 2.07574964e-02f, -1.06562572e-02f,
  2.43181691e-01f, -1.67736307e-01f, -4.92757969e-02f, -2.14927286e-01f, 9.19790287e-03f, 2.28853188e-02f, 9.64442641e-03f, -1.01629741e-01f, 9.16980803e-02f, -8.94562602e-02f,
  -2.96156913e-01f, -1.69061601e-01f, 3.87491792e-01f, -7.40794316e-02f, -6.82209507e-02f, 3.70775573e-02f, 1.68847758e-02f, 2.93744281e-02f, -1.19360991e-01f, 6.88994229e-02f,
  3.17111433e-01f, -2.54161477e-01f, -2.12342247e-01f, -2.22146705e-01f, 1.04917616e-01f, -9.89118963e-02f, -1.27555832e-01f, -2.56491333e-01f, -3.97358626e-01f, -3.97761136e-01f,
  -2.68586606e-01f, -6.69163465e-01f, 4.55452263e-01f, 1.28353044e-01f, 3.37722272e-01f, 2.72120446e-01f, -1.19765913e-02f, -6.78005815e-02f, 3.01882103e-02f, 3.81842777e-02f,
  -2.22375512e-01f, -1.10899508e-01f, -1.43171087e-01f, -3.53519544e-02f, -2.03255549e-01f, 2.09639490e-01f, 2.60656595e-01f, 3.33578080e-01f, 4.48585629e-01f, 2.50935256e-01f,
  8.07116479e-02f, 1.11955084e-01f, -1.06678054e-01f, 6.35644700e-03f, 7.79834166e-02f, 2.14664757e-01f, -1.66151151e-02f, 5.24562560e-02f, 9.10354704e-02f, 1.76413447e-01f,
  5.47738135e-01f, -4.57047254e-01f, 1.06333390e-01f, -2.95850635e-01f, -6.11647591e-02f, -7.27358237e-02f, 7.68363774e-02f, -5.88926785e-02f, -1.15719937e-01f, -1.32005913e-02f,
  1.94168668e-02f, -1.40971184e-01f, -7.23327277e-03f, -4.26988080e-02f, 6.56881332e-02f, -2.85413640e-04f, -8.11364725e-02f, -7.77523369e-02f, -1.88775614e-01f, -1.67555317e-01f,
  -7.76454583e-02f, -2.88265143e-02f, 2.10209236e-01f, -3.28133404e-02f, -2.07283899e-01f, 7.78962225e-02f, 4.30403696e-03f, -1.11608319e-01f, 1.39671843e-02f, -1.08257219e-01f,
  1.50808826e-01f, 4.01093028e-02f, 1.16438068e-01f, 2.24912446e-02f, 5.86343743e-02f, 1.33410558e-01f, 1.46948844e-01f, 5.91126271e-02f, 5.57307480e-03f, 9.83281210e-02f,
  1.57930359e-01f, 1.29984453e-01f, -1.48215331e-02f, -9.09822155e-03f, 1.52756825e-01f, 2.11068168e-01f, 2.28629157e-01f, -6.67596906e-02f, 9.87473205e-02f, 1.54596185e-02f,
  1.30007625e-01f, 6.43790662e-02f, -4.38113734e-02f, -4.08762172e-02f, -4.74507473e-02f, 1.17494754e-01f, 9.95559394e-02f, -7.45864511e-02f, 3.89988124e-02f, 3.53411324e-02f,
  2.91013360e-01f, -4.18542892e-01f, 1.60183325e-01f, -5.53055666e-04f, -9.43425577e-03f, -1.27898708e-01f, -5.30089587e-02f, 4.00827713e-02f, 1.08533494e-01f, 5.93060851e-02f,
  9.09845065e-03f, -1.42307580e-01f, -5.21087386e-02f, 1.28604872e-02f, 1.84592947e-01f, 2.48064343e-02f, -1.55443728e-01f, 7.88718462e-02f, -1.46658465e-01f, -1.28784299e-01f,
  -3.90502885e-02f, 1.42961115e-01f, 2.27087021e-01f, 2.28595346e-01f, 1.34715941e-02f, 2.60856926e-01f, 1.65036112e-01f, 1.65138200e-01f, 1.22384511e-01f, 3.36975344e-02f,
  4.99953955e-01f, 4.02785569e-01f, -2.01091394e-01f, 4.20602918e-01f, 5.14459670e-01f, 2.26132870e-01f, 1.39425948e-01f, -5.71438782e-02f, 1.29349157e-01f, 3.72531444e-01f,
  4.76114243e-01f, 3.52337062e-01f, 2.72751033e-01f, 1.42910779e-02f, -2.34221712e-01f, -2.48129115e-01f, -2.04008967e-01f, -3.39389980e-01f, -1.49052083e-01f, 2.63187587e-01f,
  2.69005895e-01f, 2.62938172e-01f, 1.67417794e-01f, -5.22064837e-03f, 1.76450089e-01f, 2.86839783e-01f, 2.04043731e-01f, 2.98488110e-01f, 2.31163472e-01f, -1.60526142e-01f,
  -1.08052105e-01f, 1.39900237e-01f, -1.67561769e-01f, 1.90045625e-01f, 1.29414171e-01f, -2.36438110e-01f, 8.99831764e-03f, -2.72383362e-01f, -1.08130639e-02f, -1.42989129e-01f,
  -9.72862239e-04f, 4.49401475e-02f, 9.78329033e-02f, -1.44273832e-01f, 7.69397430e-03f, -1.54310927e-01f, -1.50823981e-01f, -3.99102867e-01f, -2.80402273e-01f, -1.54596224e-01f,
  8.93290788e-02f, 2.84471810e-01f, 3.14664319e-02f, -1.22963414e-01f, -2.54579186e-01f, 5.81022687e-02f, -4.33760211e-02f, -1.66680083e-01f, -1.93710655e-01f, -2.59644836e-01f,
  -9.72456113e-02f, -2.16535125e-02f, 3.79320122e-02f, -2.68268194e-02f, 1.85317323e-01f, -3.47600020e-02f, -2.10650545e-02f, 7.34693259e-02f, 8.87131840e-02f, -4.52207923e-02f,
  -1.36867717e-01f, -1.40997753e-01f, -2.75744349e-01f, 4.68484797e-02f, 8.83237924e-03f, 4.75750351e-03f, 2.88781105e-03f, -7.34950081e-02f, -5.35084456e-02f, -2.09974032e-02f,
  9.50547680e-02f, -1.13735370e-01f, 2.63853204e-02f, -1.45268828e-01f, -6.54406622e-02f, 9.21530556e-03f, 2.64587700e-02f, 9.86287147e-02f, 1.95401609e-01f, 1.07842907e-01f,
  1.12754785e-01f, 3.15909535e-01f, -1.37131184e-01f, -1.85363099e-01f, -5.02207652e-02f, 1.63303688e-02f, 9.68214124e-02f, 8.09499715e-03f, 2.69840732e-02f, -2.35686786e-02f,
  8.04535449e-02f, -6.11693747e-02f, 4.30874601e-02f, -6.81383163e-02f, -2.91149318e-02f, -8.52064043e-02f, -5.59895486e-02f, -1.99907720e-01f, -1.42521456e-01f, -2.06605867e-01f,
  -1.29632920e-01f, -4.05397750e-02f, -4.07750607e-02f, -2.04752728e-01f, -2.12663800e-01f, 6.25447035e-02f, -9.48233530e-02f, -4.73950580e-02f, -8.85905772e-02f, -1.43041119e-01f,
  -7.11580336e-01f, -2.28022024e-01f, -4.70783263e-02f, -4.04180825e-01f, 2.86924571e-01f, 5.82931861e-02f, 1.02913328e-01f, -2.31982827e-01f, -9.65334848e-02f, -2.05572993e-01f,
  1.43207416e-01f, 1.72186628e-01f, 1.78060770e-01f, 2.89287478e-01f, 1.28863737e-01f, 2.83924192e-01f, 3.15077245e-01f, 1.27994746e-01f, -1.80381555e-02f, -3.07405349e-02f,
  1.89963460e-01f, -2.54041940e-01f, -3.86986732e-01f, 2.71672830e-02f, -7.59413466e-02f, 1.11387968e-01f, -3.43518630e-02f, -4.89365123e-02f, 7.73131773e-02f, 7.19609112e-02f,
  -3.02862287e-01f, -3.41100186e-01f, 2.32290536e-01f, 1.79000393e-01f, 1.93485588e-01f, -2.27090821e-01f, -2.55286515e-01f, -2.00365052e-01f, 1.05055384e-01f, -8.54338184e-02f,
  2.70350184e-02f, 5.01184203e-02f, 1.31861344e-01f, 4.25351188e-02f, -1.91904858e-01f, -7.55563676e-02f, -6.42268779e-03f, -1.34537384e-01f, -9.86685082e-02f, -1.91963017e-01f,
  4.79887635e-01f, 4.23191162e-03f, -1.77447021e-01f, -2.73948573e-02f, -1.21829592e-01f, 3.35529894e-02f, -2.23732680e-01f, -4.12363082e-01f, -3.98290604e-01f, -4.98917997e-01f,
  5.03638899e-03f, -3.34385061e-03f, 4.41751592e-02f, -4.49443310e-02f, 2.84319860e-03f, -1.53132677e-02f, 8.18039030e-02f, 2.09518597e-01f, 7.23116249e-02f, -1.48329064e-01f,
  1.69627264e-01f, 5.19186594e-02f, -3.58301774e-02f, -1.67132929e-01f, 3.63776274e-02f, -3.88416648e-02f, -1.55186616e-02f, -5.80369122e-02f, 3.89894806e-02f, -3.44525352e-02f,
  -1.38266638e-01f, 1.70533303e-02f, -1.34832978e-01f, 8.18252191e-02f, 5.32837808e-02f, 2.30358671e-02f, -1.30591616e-01f, 4.80286963e-02f, -1.87432289e-01f, -7.50317425e-02f,
  -3.56534421e-01f, 2.19343096e-01f, -3.51049304e-01f, -5.21470457e-02f, 1.02218844e-01f, 1.25211075e-01f, 4.94895019e-02f, 1.51484385e-01f, 1.62153728e-02f, -9.40988883e-02f,
  -1.74646050e-01f, -1.44602403e-01f, 2.27370346e-03f, 4.75229733e-02f, -6.34188056e-02f, -1.76585406e-01f, 8.46371949e-02f, 1.27227947e-01f, -1.61463059e-02f, -9.63038132e-02f,
  -5.11392839e-02f, -1.97083220e-01f, -3.04173440e-01f, -6.86835349e-02f, -3.03200573e-01f, -2.13560939e-01f, -3.55644971e-01f, -2.88739413e-01f, -3.57682168e-01f, -5.64112425e-01f,
  6.55314863e-01f, -9.92676094e-02f, 3.80127430e-01f, 2.53928840e-01f, 4.16626245e-01f, 4.21926916e-01f, 5.01156628e-01f, 1.90653160e-01f, -3.65749560e-02f, -2.54177582e-02f,
  -2.07815766e-01f, -3.90968055e-01f, -2.68980622e-01f, -2.99243271e-01f, -1.68578297e-01f, -6.47966564e-02f, 9.36912522e-02f, 2.25553140e-01f, 1.75236747e-01f, 1.84153229e-01f,
  -1.25039130e-01f, 3.48963559e-01f, 3.21474910e-01f, 1.37582108e-01f, -2.21301317e-01f, -1.90260723e-01f, 1.42483413e-01f, 2.00016275e-01f, -8.90095681e-02f, -2.11490273e-01f,
  -1.32395282e-01f, 1.95829108e-01f, -7.71840438e-02f, -2.50241935e-01f, 4.34590243e-02f, 2.89944280e-02f, 3.18157077e-02f, 1.35861054e-01f, 7.03251958e-02f, 2.06142627e-02f,
  -9.45033729e-02f, -9.75378975e-02f, 3.88098434e-02f, -3.62806804e-02f, 2.40019202e-01f, 4.25763540e-02f, -4.58151326e-02f, 7.47677460e-02f, -1.13706149e-01f, -1.04799971e-01f,
  -3.28078061e-01f, 9.31924134e-02f, 2.49188796e-01f, 5.92499860e-02f, -2.90382169e-02f, -7.63751566e-02f, -2.09109131e-02f, -8.67239013e-02f, 8.65528267e-03f, -1.15504935e-01f,
  2.42486689e-02f, 1.18097983e-01f, 1.73813701e-01f, 2.12773964e-01f, 7.67349526e-02f, 1.05816051e-01f, 1.13525182e-01f, 7.56312832e-02f, 2.29235083e-01f, 2.98737228e-01f,
  1.96201861e-01f, 2.95934528e-01f, 4.38223302e-01f, 2.96739608e-01f, 4.95237112e-02f, 9.71441120e-02f, 1.52863592e-01f, -1.74894333e-02f, 1.20557547e-01f, 2.76741982e-01f,
  1.22973345e-01f, 2.47386992e-01f, 2.10373655e-01f, 1.26466438e-01f, 3.76297198e-02f, 8.29880685e-02f, 1.14026368e-01f, 8.82345811e-02f, 3.70311178e-02f, 2.48208314e-01f,
  -3.91459875e-02f, 1.29985452e-01f, -2.59584039e-01f, -2.94752687e-01f, 2.29206122e-03f, -7.88660198e-02f, -1.33177981e-01f, -3.31528746e-02f, -2.57372446e-02f, 6.60529807e-02f,
  5.14314324e-02f, -5.66028990e-03f, 8.78452510e-02f, 4.84686717e-02f, 1.38127387e-01f, 7.92293549e-02f, -1.41442597e-01f, 4.58768047e-02f, -1.20297067e-01f, -1.49338856e-01f,
  -9.34566036e-02f, 1.36007816e-02f, 1.41514704e-01f, 2.68281577e-03f, -2.48570647e-02f, -2.11423393e-02f, 4.17665392e-02f, 3.59066762e-02f, 5.24893105e-02f, 3.34193595e-02f,
  -5.16484439e-01f, 7.15601742e-02f, -1.09392069e-01f, 1.23369269e-01f, 3.29339355e-01f, 3.78597975e-01f, 3.69793653e-01f, 2.16973707e-01f, 1.41779825e-01f, 1.86145276e-01f,
  1.98441878e-01f, 2.74851859e-01f, 3.28620315e-01f, 2.04498053e-01f, 3.00758451e-01f, 3.58952761e-01f, 3.17396075e-01f, -5.69021627e-02f, -1.14502698e-01f, 1.83235258e-01f,
  2.70786792e-01f, 8.90930146e-02f, -2.35352829e-01f, -5.04611880e-02f, 1.30085588e-01f, 2.52626508e-01f, 1.41586512e-01f, 2.06383348e-01f, 1.10677592e-01f, 3.48709077e-02f,
  7.23100873e-03f, -1.10270724e-01f, -7.72829801e-02f, -3.32622267e-02f, -2.17482701e-01f, -1.72315434e-01f, -3.17812413e-02f, -2.35397801e-01f, -4.95435633e-02f, -3.89987938e-02f,
  -5.90735972e-02f, -1.42431736e-01f, 5.93928387e-03f, -4.97038476e-03f, -3.39185782e-02f, -4.78866734e-02f, -1.64977461e-01f, 1.39814494e-02f, 1.13006048e-01f, 1.01454712e-01f,
  1.40831172e-01f, 1.41246468e-01f, 1.36399657e-01f, 1.30407274e-01f, 2.02054791e-02f, -3.15316431e-02f, 3.52968066e-03f, -6.57187477e-02f, -1.04433829e-02f, -8.11980218e-02f,
  1.84788167e-01f, -4.74720262e-03f, 1.19754128e-01f, 8.06074589e-02f, 9.81196761e-02f, 1.35262404e-03f, -6.42530713e-03f, 1.62732363e-01f, 3.14604677e-02f, -6.56927302e-02f,
  -3.00055463e-02f, 1.53123155e-01f, 2.70985700e-02f, 8.22783560e-02f, -9.91144478e-02f, -2.34060865e-02f, 6.48144353e-03f, 4.34811711e-02f, -1.09134607e-01f, 2.65913922e-02f,
  6.15870289e-04f, 3.64117064e-02f, -2.46767238e-01f, -5.67120090e-02f, 4.77028899e-02f, -6.41221087e-03f, 5.61881028e-02f, 7.70220384e-02f, 6.37565255e-02f, -9.87664014e-02f,
  3.23531240e-01f, 1.57719702e-01f, -6.76345676e-02f, -8.56540352e-02f, -1.45376369e-01f, -2.60170221e-01f, -5.04108965e-02f, -1.79862589e-01f, -1.02138273e-01f, 2.48150621e-02f,
  5.74245974e-02f, -1.18643701e-01f, -4.39517163e-02f, 8.68818536e-03f, -1.68030322e-01f, -1.37036517e-01f, 1.34128355e-03f, 3.10823750e-02f, 1.89780638e-01f, -2.00136732e-02f,
  6.64205104e-02f, 2.40333863e-02f, 8.15447047e-02f, 7.56520927e-02f, 1.39999583e-01f, 6.14417978e-02f, -7.64667243e-02f, -1.35388106e-01f, 3.28173973e-02f, -2.06304803e-01f,
  -4.17772889e-01f, -2.25658208e-01f, -6.77037358e-01f, -1.41883671e-01f, -2.16745324e-02f, 7.83490613e-02f, 1.91604033e-01f, 2.23545104e-01f, -3.71382525e-03f, -1.35033756e-01f,
  -2.06203431e-01f, -2.89145317e-02f, -2.41685167e-01f, -3.09411855e-03f, 1.07063204e-01f, -1.27650157e-01f, -6.46803752e-02f, -1.39073581e-01f, 2.04458281e-01f, 5.42799234e-01f,
  3.64224881e-01f, 2.02842951e-01f, 6.35805875e-02f, 5.59075773e-02f, -2.71493644e-02f, -7.79371485e-02f, -2.96739578e-01f, -6.24489412e-02f, -1.01631477e-01f, -2.39009559e-01f,
  -5.58301866e-01f, -2.81323791e-01f, 6.32230490e-02f, -6.32662550e-02f, -1.14447378e-01f, -2.52925307e-01f, -3.64787132e-02f, -3.23656589e-01f, -1.50758430e-01f, -2.11259320e-01f,
  -9.79256108e-02f, -8.56771544e-02f, -2.65430391e-01f, -3.35376263e-02f, -8.91716927e-02f, -1.83284003e-02f, -9.18781459e-02f, -1.73739120e-01f, -2.40071073e-01f, -1.92840710e-01f,
  2.05112591e-01f, -1.27536699e-01f, -4.69502449e-01f, -5.43928444e-02f, -7.61443889e-03f, -2.62111783e-01f, -8.15475807e-02f, 4.88995276e-02f, -1.57252714e-01f, -3.01219165e-01f,
  -6.81735482e-03f, -1.34338394e-01f, -9.47571546e-02f, -7.70199904e-03f, 1.70271680e-01f, -1.90866180e-02f, 1.22324400e-01f, 9.73382667e-02f, -1.06584474e-01f, -7.27018295e-03f,
  -1.12239368e-01f, -1.08387753e-01f, -1.35911331e-02f, -3.71133760e-02f, 4.96759564e-02f, -9.00271535e-02f, 8.75381753e-02f, 2.39197552e-01f, 1.29791466e-03f, 4.37354967e-02f,
  3.62921357e-02f, 6.44927025e-02f, 1.25863910e-01f, 2.13001102e-01f, -5.93139082e-02f, 5.86635508e-02f, 3.60093713e-02f, 1.26569252e-02f, -9.32875052e-02f, -4.26292643e-02f,
  1.74837485e-01f, 2.48474255e-01f, -3.95933956e-01f, 7.02899545e-02f, -1.72827572e-01f, -3.17523396e-03f, -4.67355223e-03f, -4.39861082e-02f, -2.62516350e-01f, -1.87638868e-02f,
  -4.46992368e-02f, 9.53079760e-03f, -8.80254060e-02f, 2.07368191e-02f, -6.91092387e-02f, -9.11607891e-02f, 5.16493805e-03f, -2.88296312e-01f, -3.14683616e-02f, -1.15228131e-01f,
  5.86133488e-02f, 2.03542069e-01f, -2.80872971e-01f, -1.52754292e-01f, -6.01871274e-02f, -9.94665176e-02f, -3.13887656e-01f, 3.87972780e-02f, -9.29388553e-02f, -4.16004471e-02f,
  6.42732441e-01f, 1.65660344e-02f, 2.03505933e-01f, 2.06241950e-01f, 2.00866491e-01f, 1.60468459e-01f, 6.68893307e-02f, 6.50548413e-02f, 5.15049882e-02f, 9.14346203e-02f,
  1.47845075e-01f, 5.95893264e-02f, 1.61885709e-01f, 8.19680467e-02f, -4.79197316e-03f, -6.82661459e-02f, -1.26810715e-01f, 2.11148635e-02f, 1.21624917e-01f, 1.75242722e-01f,
  6.63216831e-03f, -4.14441265e-02f, 1.13190180e-02f, 5.69515824e-02f, -1.05303042e-01f, -5.24203246e-03f, -4.89155985e-02f, -6.05155975e-02f, -6.18769117e-02f, -3.31945390e-01f,
  -1.51573285e-01f, 1.26755722e-02f, -1.43574607e-02f, 6.90689823e-03f, 4.92775328e-02f, 5.54569736e-02f, -6.99688792e-02f, -8.98323506e-02f, -7.92040303e-02f, -2.46653095e-01f,
  -1.81180120e-01f, -5.27297892e-02f, -3.56811956e-02f, -6.94373697e-02f, 1.38576538e-03f, 1.24377003e-02f, -2.43256204e-02f, -1.24480851e-01f, -7.69574419e-02f, 3.39257158e-02f,
  2.36948691e-02f, 1.64705858e-01f, 4.87388857e-03f, 6.19757362e-03f, 4.48239110e-02f, 1.27711311e-01f, 3.79391089e-02f, 1.12912543e-01f, 1.03968434e-01f, -7.43185505e-02f,
  -1.74528360e-02f, 3.92570525e-01f, 3.16647261e-01f, 2.22666547e-01f, 1.29137011e-02f, 7.71584511e-02f, 5.95960282e-02f, -2.58636717e-02f, 1.04834437e-02f, 1.47398204e-01f,
  -1.33410692e-01f, 1.70279648e-02f, 1.35795325e-01f, 1.74714904e-02f, 2.21620694e-01f, 8.83535370e-02f, 3.27612422e-02f, 3.77179272e-02f, 8.62724148e-03f, -1.71112977e-02f,
  3.50611620e-02f, 6.10418133e-02f, 1.40647873e-01f, -1.01508945e-01f, 7.53092095e-02f, 8.37925524e-02f, 1.84511498e-01f, 1.00783139e-01f, 1.08273879e-01f, 8.35569724e-02f,
  -3.98624092e-01f, 8.17091390e-02f, -4.57723811e-02f, -1.47554830e-01f, -5.32407872e-02f, 2.92934515e-02f, -4.78056557e-02f, -1.07567973e-01f, -2.08576441e-01f, -2.99264759e-01f,
  -2.18372092e-01f, -1.11034987e-02f, -1.36222214e-01f, -8.67875963e-02f, -1.06870182e-01f, 1.10582858e-02f, 4.67829518e-02f, 3.37238573e-02f, -1.27584279e-01f, -1.24658592e-01f,
  1.08949235e-02f, 4.47179228e-02f, 7.23885894e-02f, 6.11234680e-02f, 7.99254701e-03f, 5.71811348e-02f, 5.71086183e-02f, -8.42191949e-02f, 1.45000935e-01f, 9.24681686e-03f,
  6.92974687e-01f, -2.08497107e-01f, -7.87065029e-01f, 8.79120305e-02f, -5.41734397e-01f, -4.73908007e-01f, -4.29012448e-01f, -1.19593218e-01f, 1.47450373e-01f, -3.96070540e-01f,
  -3.33678067e-01f, 1.29176930e-01f, 2.99025234e-02f, -2.03330636e-01f, -8.70584100e-02f, -3.83778155e-01f, -4.55102026e-01f, -3.32691282e-01f, -3.94215316e-01f, -4.88003850e-01f,
  -3.15401107e-01f, -1.84870198e-01f, 4.23686020e-02f, -4.62011546e-02f, -3.04761231e-01f, -3.07909369e-01f, -4.75492507e-01f, -3.66108865e-01f, -4.15500790e-01f, -3.71832639e-01f,
  -4.26141828e-01f, -1.81668222e-01f, -1.55296028e-01f, 8.71439725e-02f, -1.55661821e-01f, 8.55767131e-02f, -5.71636818e-02f, -2.88016908e-02f, 1.42251864e-01f, 4.75050136e-02f,
  -1.88642383e-01f, -6.22576289e-02f, 9.41873491e-02f, -1.52407810e-01f, -1.00311860e-01f, -6.07112572e-02f, -2.58477896e-01f, -2.67274052e-01f, -1.96674347e-01f, -3.35560203e-01f,
  -3.88935953e-01f, -2.43454590e-01f, -1.00001262e-03f, -6.32450953e-02f, -2.27774307e-01f, 4.45589460e-02f, -3.55486810e-01f, -3.01013261e-01f, -1.46023914e-01f, 8.04606751e-02f,
  7.41396919e-02f, -1.29506420e-02f, -1.44280106e-01f, -9.31048095e-02f, 1.11941837e-01f, 1.99174676e-02f, 1.60535440e-01f, 6.84124306e-02f, 1.16468696e-02f, 3.88873667e-02f,
  -1.14241995e-01f, -8.09174106e-02f, 2.95653138e-02f, -5.15687279e-04f, -6.46629836e-04f, 6.15035333e-02f, 6.78176805e-02f, 5.37303239e-02f, 1.04355708e-01f, 1.16490372e-01f,
  -5.25147803e-02f, -7.81686231e-02f, 5.04899696e-02f, 9.63442475e-02f, -1.67293936e-01f, -1.18660867e-01f, 2.79896837e-02f, -4.19379137e-02f, 1.36387914e-01f, -6.68221265e-02f,
  5.57925761e-01f, -1.13887444e-01f, 3.11999083e-01f, 1.17931522e-01f, -1.19066648e-01f, -5.87992705e-02f, 8.03933218e-02f, 5.24013154e-02f, 1.82514966e-01f, -5.77968694e-02f,
  -1.50307685e-01f, 2.11076401e-02f, 6.16305284e-02f, -6.04511127e-02f, -7.26384073e-02f, -1.49177298e-01f, -9.83189717e-02f, -8.48276988e-02f, -9.46735963e-02f, -1.87417850e-01f,
  -6.48968220e-02f, 2.32017383e-01f, 3.60272944e-01f, 3.25895041e-01f, 5.40791079e-02f, 2.84478307e-01f, 8.73365626e-02f, -4.43656817e-02f, 7.60930404e-02f, 4.32689011e-01f,
  2.40457565e-01f, 3.24187167e-02f, 5.59120357e-01f, -1.54233277e-01f, -6.15889788e-01f, -5.01168013e-01f, -5.87387025e-01f, -3.69853407e-01f, -2.30378181e-01f, -2.59687267e-02f,
  -3.14723581e-01f, -4.90457475e-01f, 1.22306071e-01f, -7.31277280e-04f, 1.26973346e-01f, 2.87129015e-01f, 3.30341607e-01f, 4.53624099e-01f, -1.41715825e-01f, -6.15943015e-01f,
  -4.84650582e-01f, -7.30028525e-02f, 2.83475190e-01f, 2.17942804e-01f, 1.84006631e-01f, -5.29315360e-02f, 5.02765000e-01f, 2.05096692e-01f, 2.60592103e-01f, 4.23795760e-01f,
  4.12150621e-01f, 3.61322165e-01f, -1.74892157e-01f, -1.70037121e-01f, 6.99646398e-02f, 7.54659399e-02f, 4.93631093e-03f, 3.24455917e-01f, -1.36964425e-01f, 2.62185097e-01f,
  -2.38632381e-01f, 5.32011082e-03f, -1.37613833e-01f, -1.87307503e-02f, -1.40211374e-01f, -1.94314837e-01f, 3.16256791e-01f, 2.48510063e-01f, 3.58296186e-01f, 7.27235759e-03f,
  -5.09103298e-01f, -3.78665119e-01f, 6.11880468e-03f, -1.47736415e-01f, 1.48810267e-01f, -4.63403314e-02f, 1.57805637e-01f, 5.60135543e-02f, 2.66656876e-01f, 3.54726195e-01f,
  6.20532688e-03f, 7.41586536e-02f, 9.17070080e-03f, 2.69232746e-02f, -1.75428659e-01f, -3.23433392e-02f, -2.53757313e-02f, -1.33940443e-01f, 7.96660036e-02f, -1.13127679e-01f,
  -4.74085324e-02f, 1.92398150e-02f, -8.67977068e-02f, -5.63200284e-03f, 1.21811999e-03f, 5.74896261e-02f, -4.98062074e-02f, 1.30976558e-01f, 1.33391827e-01f, 9.97388735e-02f,
  -4.53018993e-02f, 1.96722597e-02f, 1.60950050e-01f, -2.05498282e-02f, 1.75939858e-01f, 2.35009551e-01f, 1.19113497e-01f, -3.01261880e-02f, 7.30733108e-03f, 5.50404303e-02f,
  -3.35283428e-01f, 3.07395775e-02f, -6.99061602e-02f, 2.18271948e-02f, -9.24955532e-02f, 4.80200872e-02f, -9.14123189e-03f, -4.10473496e-02f, -3.98938023e-02f, -5.20672090e-02f,
  -1.11404389e-01f, -7.41060898e-02f, -4.71242145e-02f, -3.61127891e-02f, -3.56345952e-01f, -2.40324691e-01f, -1.47024900e-01f, -2.75018632e-01f, -2.60283679e-01f, -2.37965092e-01f,
  -2.09491074e-01f, -5.73123455e-01f, -4.69861954e-01f, -4.42109317e-01f, -3.01417649e-01f, -3.99344951e-01f, -2.34418228e-01f, -3.33533198e-01f, -2.70709723e-01f, -3.32158446e-01f,
  6.05991960e-01f, 3.80230069e-01f, -1.79454044e-01f, 3.95441473e-01f, -8.78241137e-02f, -5.41326821e-01f, -5.70497930e-01f, -3.05339515e-01f, 6.87152222e-02f, 3.52320820e-01f,
  1.57035351e-01f, -6.96482286e-02f, 5.86075429e-03f, -3.35561246e-01f, -4.56932873e-01f, -1.75704211e-02f, -1.16737690e-02f, -3.80697101e-01f, -7.26475239e-01f, -4.22476649e-01f,
  -9.79027748e-02f, 2.27862164e-01f, 1.58877388e-01f, -3.36268358e-02f, 4.56363380e-01f, -3.55390236e-02f, 2.52545744e-01f, 2.49383315e-01f, -4.26274091e-02f, 3.96660030e-01f,
  2.63582945e-01f, 2.11606905e-01f, -4.19144452e-01f, 1.24402121e-01f, 2.37806842e-01f, 5.96395843e-02f, -1.42700359e-01f, 2.27610003e-02f, -2.51779377e-01f, -8.86804909e-02f,
  7.18801692e-02f, -1.04592636e-01f, -8.91203657e-02f, -2.04584867e-01f, 3.25697027e-02f, -2.64205992e-01f, 5.80557771e-02f, -3.49201322e-01f, -1.98384508e-01f, -7.67260492e-02f,
  -8.74880180e-02f, 1.28422558e-01f, -9.93084684e-02f, -2.84822732e-01f, -3.45398933e-01f, -3.34568143e-01f, -1.74356103e-01f, -2.66093105e-01f, -2.98916310e-01f, 3.62642586e-01f,
  -1.11655749e-01f, 2.42259037e-02f, 4.61334325e-02f, 5.48573807e-02f, 1.72504336e-02f, -7.10295662e-02f, -7.09087253e-02f, -1.05590269e-01f, -3.67875509e-02f, -7.03445226e-02f,
  -5.35418978e-04f, 5.71278296e-03f, -8.40179040e-04f, 8.29097256e-02f, -2.78325565e-02f, -6.66865557e-02f, -1.15901418e-01f, 5.11746928e-02f, 7.76015967e-02f, -2.87121609e-02f,
  -1.03563361e-01f, -3.83347049e-02f, 1.74138889e-01f, -5.67183234e-02f, 3.78233790e-02f, -4.32258733e-02f, 1.17676705e-01f, -2.57742196e-01f, -1.20090812e-01f, 6.61150441e-02f,
  1.94307208e-01f, -4.52430308e-01f, 2.93081254e-01f, -1.70940354e-01f, 1.21220939e-01f, 8.57505016e-03f, 1.05936669e-01f, -1.75156698e-01f, 1.37736602e-02f, -2.60694355e-01f,
  -2.95156121e-01f, -1.45952925e-01f, 1.09357387e-01f, -2.06252024e-01f, -2.56867170e-01f, -4.31687608e-02f, 2.51714528e-01f, -1.37771487e-01f, -1.69404343e-01f, 2.97000669e-02f,
  1.86735064e-01f, -1.14265315e-01f, 3.71176302e-02f, -1.08380631e-01f, 1.06981173e-01f, -1.10679492e-01f, -2.28691071e-01f, -3.75670493e-01f, -3.36307257e-01f, 1.81410193e-01f,
  5.63588858e-01f, 2.96689570e-01f, 1.56546891e-01f, -9.26776603e-03f, -1.89903360e-02f, -1.53328985e-01f, -9.37778354e-02f, -4.40779775e-02f, -1.28856018e-01f, -2.63086744e-02f,
  2.06475481e-01f, -2.66155731e-02f, 1.68131571e-02f, -2.04645786e-02f, -4.97701354e-02f, -1.07986592e-01f, -1.55579969e-01f, 1.30710185e-01f, 6.90078512e-02f, -1.81554824e-01f,
  -2.30049014e-01f, -5.51742651e-02f, 1.17270663e-01f, 1.03688665e-01f, -7.16732163e-03f, -8.90034884e-02f, -9.34799537e-02f, 5.23762442e-02f, -4.28228788e-02f, -1.25549182e-01f,
  1.19930565e-01f, 4.60167736e-01f, 1.17115937e-02f, 6.09681867e-02f, 1.96513325e-01f, 1.58212423e-01f, 6.27348274e-02f, 1.28567830e-01f, 4.96640429e-02f, -1.37196958e-01f,
  -2.72944905e-02f, 1.49316266e-01f, 1.23647295e-01f, 1.40537815e-02f, 7.37277791e-02f, 5.10260016e-02f, 2.21133783e-01f, 7.91798458e-02f, 5.96689284e-02f, 2.90740877e-02f,
  1.53912812e-01f, 5.38485460e-02f, 1.01049416e-01f, -4.04091403e-02f, 5.38574867e-02f, 1.21569805e-01f, 1.76624060e-01f, 1.39001608e-01f, 7.58304074e-02f, -1.06991246e-01f,
  1.16734907e-01f, 2.05874071e-02f, 2.50313073e-01f, -2.63708010e-02f, -8.46634358e-02f, -1.95760541e-02f, -1.54713765e-01f, -2.05922469e-01f, -1.21382670e-02f, -6.49691969e-02f,
  -9.25662965e-02f, -1.36310523e-02f, 9.76139158e-02f, -1.30383536e-01f, 1.35850742e-01f, 1.48899511e-01f, 1.33493720e-02f, 1.34466231e-01f, 9.26073790e-02f, 6.12477101e-02f,
  -2.93148477e-02f, -3.68486010e-02f, 4.01799344e-02f, 1.38458610e-01f, 2.22782474e-02f, 9.92822181e-03f, -6.50786757e-02f, -3.42805609e-02f, -7.21944422e-02f, -1.19492583e-01f,
  -7.86735937e-02f, 3.73088628e-01f, -1.55474737e-01f, 2.74887141e-02f, -1.76947284e-03f, 1.56238183e-01f, 5.53152189e-02f, 5.72549067e-02f, -1.28882259e-01f, -3.17861103e-02f,
  1.46995038e-02f, -7.63676614e-02f, 3.55872326e-03f, 7.69231915e-02f, -1.54580250e-01f, 3.59247848e-02f, 3.61401662e-02f, -3.19218934e-02f, 2.24348158e-02f, -1.69927962e-02f,
  1.17809484e-02f, -7.79603124e-02f, -1.76385209e-01f, -4.36704531e-02f, -1.38717949e-01f, -1.41851351e-01f, -8.64928812e-02f, 7.02925958e-03f, -1.88691709e-02f, -1.27265409e-01f,
  -5.35716042e-02f, -6.15739048e-01f, 1.32964373e-01f, 9.18125436e-02f, 1.32595077e-01f, 1.80154219e-01f, 1.94332711e-02f, 4.07658964e-02f, 2.24635258e-01f, -1.56097189e-02f,
  -6.40366226e-02f, 1.58424646e-01f, 2.62184113e-01f, 1.93809956e-01f, 1.78520590e-01f, 1.26714215e-01f, 3.83378029e-01f, 3.53371650e-01f, 2.37275138e-01f, -5.44848805e-03f,
  -3.79976183e-02f, 2.00965218e-02f, 2.59621050e-02f, 9.78342146e-02f, -1.59576982e-01f, 2.16130450e-01f, 1.11670449e-01f, -8.33051354e-02f, -1.35685176e-01f, 1.55493701e-02f,
  -1.08588822e-01f, -2.36461952e-01f, 2.75544584e-01f, 3.12689021e-02f, -2.49070495e-01f, -1.18152790e-01f, -7.90560246e-03f, -1.17502108e-01f, -6.01206794e-02f, -1.04193553e-01f,
  2.88395509e-02f, -1.49505213e-01f, 1.69263054e-02f, -1.92704678e-01f, -1.90734789e-01f, -3.78229059e-02f, -7.30403960e-02f, -3.73200104e-02f, 1.57993183e-01f, -1.28163114e-01f,
  -1.36480331e-01f, -2.13829800e-02f, 9.95099428e-04f, 6.35038987e-02f, 1.70159444e-01f, 1.76478550e-01f, -3.36683989e-02f, -7.85144791e-02f, 3.15741636e-02f, -1.92196161e-01f,
  9.07642245e-02f, 1.05167091e-01f, 1.05233997e-01f, 1.25184625e-01f, 1.06490374e-01f, 8.75262916e-02f, 4.31739762e-02f, 1.33524001e-01f, 1.85736537e-01f, 1.25895068e-01f,
  6.43012524e-02f, 2.44210809e-01f, 1.18414104e-01f, 2.53799465e-02f, 3.30880098e-02f, -8.80767256e-02f, -1.10553473e-01f, -2.09088884e-02f, 1.10033169e-01f, 4.37057093e-02f,
  2.05573559e-01f, 3.65616567e-02f, -4.96517047e-02f, -8.16397555e-03f, -1.96211468e-02f, 1.27264813e-01f, 9.50883701e-02f, 7.52631202e-02f, -8.21069777e-02f, 3.69113758e-02f,
  -5.85336871e-02f, 4.83835578e-01f, 2.46093675e-01f, 1.36440575e-01f, -7.76590332e-02f, -1.11260526e-01f, 7.35350400e-02f, -1.09646626e-01f, -8.06218609e-02f, -3.84948291e-02f,
  -1.08073853e-01f, -1.06386073e-01f, 1.49528487e-02f, -6.78260401e-02f, 1.13196030e-01f, 7.22772554e-02f, -1.91990614e-01f, 3.40768918e-02f, 1.61002323e-01f, 3.38459462e-02f,
  2.17492394e-02f, 6.05559386e-02f, 1.62657782e-01f, 1.74116552e-01f, 1.84411168e-01f, 1.95508778e-01f, 5.64731993e-02f, -6.15615547e-02f, 1.75797299e-01f, -2.17175670e-02f,
  6.85200870e-01f, -5.60837567e-01f, 3.66267443e-01f, 1.10214744e-02f, -1.61519453e-01f, -5.56565030e-03f, -2.78077304e-01f, -2.09572703e-01f, -3.12256943e-02f, -3.56633902e-01f,
  -3.16872478e-01f, -2.89523482e-01f, -1.85423404e-01f, 1.12236589e-02f, 1.52018443e-01f, 7.12498929e-03f, 1.13651276e-01f, 5.58999896e-01f, 5.59533417e-01f, 5.88674136e-02f,
  -2.58897424e-01f, 4.13038060e-02f, 4.08399045e-01f, 2.01956466e-01f, -2.67404944e-01f, -4.65435795e-02f, 2.78335400e-02f, -1.99027508e-01f, -2.96439320e-01f, -2.24803671e-01f,
  -1.85518771e-01f, -1.50355607e-01f, 1.90399334e-01f, -7.87797049e-02f, 5.68108745e-02f, 4.78462763e-02f, 8.34565759e-02f, -1.76723991e-02f, -6.65822029e-02f, -4.85877395e-02f,
  -1.38894618e-02f, 8.67067650e-02f, 3.89473489e-03f, -1.61729649e-01f, -2.35721301e-02f, 1.05299622e-01f, -5.25194071e-02f, -8.33160281e-02f, -1.02768242e-01f, -1.05065845e-01f,
  -3.13929260e-01f, -9.03856978e-02f, 1.48100853e-02f, -8.72008037e-03f, 4.50683013e-02f, 6.57110214e-02f, -6.79215118e-02f, 1.27339531e-02f, 1.24268942e-01f, -9.74223912e-02f,
  6.01613559e-02f, 6.50092363e-02f, 3.09064779e-02f, 2.64543761e-02f, 8.58362988e-02f, 9.33857933e-02f, -5.44145480e-02f, -1.26135780e-03f, 1.38758525e-01f, 1.86217315e-02f,
  -1.86295554e-01f, -1.41887218e-01f, 6.90364540e-02f, 2.66654696e-02f, 9.36639532e-02f, 3.09848413e-02f, 2.10074778e-03f, -8.64731595e-02f, 1.17140591e-01f, -7.89924711e-02f,
  2.11090054e-02f, 3.19175608e-02f, 3.34272683e-02f, -1.68392435e-01f, -1.97705343e-01f, -8.66398439e-02f, 3.21303084e-02f, 2.11500805e-02f, 1.03900820e-01f, -9.15624872e-02f,
  -4.60245013e-01f, 3.72876495e-01f, 5.06591722e-02f, -4.18341234e-02f, 4.78504933e-02f, -6.18488863e-02f, -5.59485219e-02f, -1.99734757e-04f, -5.46041876e-02f, -1.17803127e-01f,
  -6.68279082e-02f, 6.65319189e-02f, -1.09152332e-01f, 4.16916683e-02f, 2.00676158e-01f, 8.91617984e-02f, -5.06348200e-02f, -1.17178246e-01f, -8.13636035e-02f, -1.60971135e-01f,
  -1.22143075e-01f, 1.08943112e-01f, 3.06838639e-02f, 3.17740371e-03f, 5.66738918e-02f, 2.38055378e-01f, 7.53196850e-02f, -3.77040878e-02f, 1.22360058e-01f, 7.38331825e-02f,
  4.54016089e-01f, 4.38884735e-01f, 9.19459015e-02f, 3.14806551e-01f, -8.30249190e-02f, 1.32472059e-02f, 1.99101046e-01f, 2.20782563e-01f, 6.57960698e-02f, 1.11567058e-01f,
  4.52582166e-02f, 1.59200311e-01f, 2.35277265e-01f, 1.77412421e-01f, 2.64323384e-01f, 6.34958148e-02f, 1.28862888e-01f, 6.62619025e-02f, 8.20534155e-02f, 4.88678999e-02f,
  4.18038666e-02f, 3.95665504e-02f, 6.16777427e-02f, 2.94059422e-02f, 1.61354318e-01f, 9.86524597e-02f, 3.20812203e-02f, 1.23844787e-01f, 1.22726776e-01f, 1.60389572e-01f,
  -1.83550730e-01f, 1.13894105e-01f, -2.26331994e-01f, -1.24922380e-01f, -3.19356769e-02f, 1.99715104e-02f, 1.06207281e-02f, -8.15089699e-03f, -3.56408730e-02f, 2.37986725e-02f,
  -1.05750836e-01f, -1.03301913e-01f, 5.84749915e-02f, -2.89385449e-02f, -1.22668728e-01f, -1.09264612e-01f, 8.20736680e-03f, 1.12481132e-01f, 1.45671487e-01f, -4.39099707e-02f,
  -6.37080073e-02f, -9.37058926e-02f, -1.24779142e-01f, 7.72243217e-02f, 1.99095204e-01f, -1.06796496e-01f, 5.28156422e-02f, 5.70209771e-02f, 1.92359053e-02f, 4.14462127e-02f,
  7.54568130e-02f, 1.92159310e-01f, 1.71421736e-01f, 3.24658394e-01f, 1.54055536e-01f, 4.13682647e-02f, 6.28571212e-02f, 2.72248629e-02f, 6.60953820e-02f, 2.58422736e-02f,
  -5.32465763e-02f, -2.45743729e-02f, 9.17628929e-02f, 8.74318108e-02f, -1.09915901e-02f, -4.55645137e-02f, -1.36265993e-01f, 7.06595555e-02f, -2.84946952e-02f, -1.19650260e-01f,
  4.00047973e-02f, -1.34046003e-01f, -1.18791521e-01f, 1.92204788e-02f, -1.37641385e-01f, 1.99941881e-02f, 2.41533890e-02f, -2.52152793e-02f, 1.66629329e-02f, -2.61585619e-02f,
  -2.64186442e-01f, -1.03793629e-02f, -2.26035371e-01f, -8.58938470e-02f, -2.41332268e-03f, -7.77969062e-02f, 2.87309997e-02f, -9.93794724e-02f, -5.52556328e-02f, -1.49546474e-01f,
  -1.93499401e-01f, -2.08055563e-02f, 3.65349837e-02f, 2.30930597e-02f, -1.87143013e-01f, -1.34839997e-01f, -7.53244013e-02f, -1.37697950e-01f, -1.13016091e-01f, -1.06108181e-01f,
  -1.71329990e-01f, -2.62752324e-01f, -1.68636233e-01f, -1.15994468e-01f, -6.34377822e-02f, -2.15908021e-01f, -1.56058848e-01f, -1.96713582e-01f, -9.38132033e-02f, -1.66197807e-01f,
  6.11183167e-01f, -5.92963934e-01f, 1.50963470e-01f, 5.20272963e-02f, -1.00597478e-02f, -1.80337299e-02f, -2.58209050e-01f, -1.06683202e-01f, 3.78612429e-04f, -1.55626997e-01f,
  -1.92415684e-01f, -3.82704996e-02f, -4.25831182e-04f, 1.87439900e-02f, 9.68105532e-03f, -2.15086043e-01f, 4.82945936e-03f, 1.56405330e-01f, 2.68326133e-01f, 1.66436583e-02f,
  -1.59155294e-01f, 2.12042797e-02f, 1.56207904e-01f, -2.59170402e-02f, -2.26465434e-01f, 4.06185873e-02f, -4.92594950e-02f, -2.30974615e-01f, -3.30196708e-01f, -3.03380787e-01f,
  -2.70958871e-01f, -2.19230764e-02f, 1.80603385e-01f, -1.23694308e-01f, 4.18426432e-02f, 1.82943102e-02f, 1.07158013e-01f, -1.44205451e-01f, -1.49456799e-01f, -7.86751956e-02f,
  3.42278602e-03f, 8.35296214e-02f, -1.12639116e-02f, 1.31242117e-02f, -9.19309556e-02f, -7.93722123e-02f, -4.11434919e-02f, -3.47238667e-02f, -1.06398202e-02f, -5.90505563e-02f,
  -1.68482080e-01f, -2.61628795e-02f, -5.05450666e-02f, 8.31782967e-02f, 1.32124230e-01f, 1.04834072e-01f, -4.27863561e-02f, 2.31776088e-02f, 3.41757834e-02f, -9.30743739e-02f,
  4.32181843e-02f, 9.72284190e-03f, 1.58591524e-01f, 1.84668422e-01f, 1.88830748e-01f, 1.03531955e-02f, 7.43506402e-02f, -7.74290487e-02f, 1.39921010e-01f, 2.49819886e-02f,
  -1.10551342e-01f, -1.47202695e-02f, 8.66628587e-02f, -3.91730666e-02f, 6.22075349e-02f, 3.03046927e-02f, 5.09014875e-02f, -1.74143910e-02f, -5.26293414e-03f, 1.58910006e-02f,
  9.73243490e-02f, -1.30452693e-01f, -5.34569882e-02f, -6.72483221e-02f, -5.11270650e-02f, -2.49444488e-02f, -8.05552229e-02f, -1.18416376e-01f, 4.94989827e-02f, -8.12268257e-02f,
  -2.64340729e-01f, 3.59181523e-01f, 6.25098646e-02f, -8.84331688e-02f, 7.03590885e-02f, -9.65975411e-03f, 1.10294327e-01f, -1.49464101e-01f, -2.39047527e-01f, -1.07208133e-01f,
  -3.83049883e-02f, 4.91051674e-02f, -1.37196347e-01f, -6.96202591e-02f, 9.37272385e-02f, 1.22511879e-01f, -5.32462634e-02f, -7.71719143e-02f, -6.60536885e-02f, -2.53412753e-01f,
  -6.66559637e-02f, 6.24854937e-02f, 1.47027552e-01f, 9.36298296e-02f, 6.65179864e-02f, 7.30358735e-02f, -3.73768173e-02f, -5.09136990e-02f, 5.59035763e-02f, 3.07004806e-02f,
  -8.58885467e-01f, 1.77092656e-01f, 2.52831250e-01f, -2.40149811e-01f, 3.35449219e-01f, 3.41587327e-02f, -1.88621312e-01f, -4.81869400e-01f, -3.51078004e-01f, -6.86005577e-02f,
  1.77933678e-01f, -8.74252524e-04f, -8.98315571e-03f, 3.09266075e-02f, -1.94658980e-01f, 1.18324198e-01f, 3.09439957e-01f, 2.25000933e-01f, 5.69868134e-03f, -1.66549243e-03f,
  2.36768022e-01f, -1.47211298e-01f, -1.24095142e-01f, -1.50791734e-01f, 1.16675213e-01f, 9.51690599e-02f, 7.11170435e-02f, 1.42304763e-01f, 2.49258235e-01f, 5.00805974e-01f,
  -2.49896143e-02f, -3.02329600e-01f, 1.61314644e-02f, 1.38241157e-01f, 3.25514168e-01f, -4.69649971e-01f, -1.70151219e-01f, -3.59197222e-02f, 1.33528754e-01f, -8.17687809e-02f,
  2.97878414e-01f, 1.00983918e-01f, 2.65066862e-01f, -5.57184070e-02f, -1.86628774e-01f, -3.58789057e-01f, -1.46656007e-01f, -3.13850939e-01f, -3.21394712e-01f, -1.99918553e-01f,
  5.38542569e-01f, 4.51530844e-01f, 8.18084776e-02f, -1.29913002e-01f, -4.36236233e-01f, -1.91506743e-02f, -1.75597697e-01f, -2.58730173e-01f, -5.51351249e-01f, -4.95559037e-01f,
  3.28391045e-02f, 1.24683358e-01f, 1.27333939e-01f, -1.34057924e-01f, -3.20708491e-02f, 4.64120843e-02f, 1.35704622e-01f, 1.12268329e-01f, -8.19936618e-02f, 4.02775370e-02f,
  -8.80506411e-02f, -9.09428895e-02f, -5.30710667e-02f, -1.65485933e-01f, -4.28869985e-02f, 2.71891593e-03f, -6.68639466e-02f, 8.86397623e-03f, 9.10862610e-02f, -2.11714238e-01f,
  -9.48814824e-02f, 2.79359706e-03f, 2.24845856e-02f, -1.51056737e-01f, 8.37940127e-02f, 1.02433965e-01f, -8.23383406e-02f, 3.40994075e-02f, -1.23267747e-01f, 7.38168508e-02f,
  -3.81165832e-01f, 3.99914235e-01f, -1.58672258e-01f, 4.14945111e-02f, 8.68224725e-02f, 1.36849042e-02f, -3.53925712e-02f, 1.41453370e-01f, 1.09190606e-01f, -1.14581570e-01f,
  3.43528837e-02f, -1.28541335e-01f, -1.06621049e-01f, -1.08792959e-02f, -2.00176667e-02f, -1.06192239e-01f, 2.54506379e-01f, 6.47859499e-02f, -2.95498967e-02f, -1.06482618e-01f,
  4.01708893e-02f, -1.50539115e-01f, -3.73235255e-01f, -2.31323451e-01f, -1.63244322e-01f, -3.05722982e-01f, -2.66851634e-01f, -3.60599488e-01f, -4.16963071e-01f, -5.98265171e-01f,
  8.14759016e-01f, -1.98491320e-01f, -6.34144306e-01f, 6.07599542e-02f, -3.88982773e-01f, -5.34586072e-01f, -4.91115808e-01f, -7.47898668e-02f, 1.78626329e-01f, -3.35988790e-01f,
  -1.80952221e-01f, 1.95017502e-01f, -1.23789273e-01f, -1.78671435e-01f, -2.20903322e-01f, -5.64650416e-01f, -5.12758911e-01f, -4.75964814e-01f, -2.30663389e-01f, 4.31886576e-02f,
  1.83386236e-01f, 2.10124165e-01f, 1.72556356e-01f, -2.94348300e-02f, -1.76014453e-02f, -1.41131714e-01f, -3.76950592e-01f, -1.92486480e-01f, -2.48754710e-01f, -3.78344357e-01f,
  -4.77853596e-01f, -2.55219132e-01f, -1.94477960e-01f, 8.88011083e-02f, -1.92253329e-02f, 1.53947860e-01f, -5.40741645e-02f, -4.38380893e-03f, 1.54386565e-01f, -3.70188206e-02f,
  4.43824306e-02f, 6.64172843e-02f, 9.05468315e-02f, -1.03697173e-01f, 8.56921002e-02f, 5.51232137e-02f, 4.57702391e-02f, -1.97332546e-01f, -6.37723505e-02f, -1.29781663e-01f,
  -1.83695890e-02f, -1.62441954e-01f, -1.97556272e-01f, -1.58790946e-01f, -2.55550683e-01f, -2.32280348e-03f, -2.90910006e-01f, -1.46141753e-01f, -2.45930567e-01f, 5.06817214e-02f,
  -5.19591644e-02f, -1.20813489e-01f, -5.36550395e-02f, 6.86273649e-02f, 1.02996133e-01f, -1.47807121e-01f, -8.83624032e-02f, -1.49986506e-01f, 4.93881945e-03f, -1.13590382e-01f,
  -7.30110481e-02f, -1.42624170e-01f, 3.02327611e-02f, -8.58359933e-02f, -1.55100748e-01f, -1.97842956e-01f, -1.68757081e-01f, -9.76217315e-02f, -9.34889987e-02f, 6.76929802e-02f,
  -1.15545340e-01f, -1.60451308e-01f, 1.66813587e-03f, 7.54832327e-02f, -2.62468576e-01f, -7.85358027e-02f, -5.68796992e-02f, -1.23653151e-02f, 8.36833715e-02f, 2.96204234e-03f,
  3.09132755e-01f, -3.30531955e-01f, 8.10744166e-02f, 9.43200011e-03f, -1.30936056e-01f, -2.63535492e-02f, 8.36932138e-02f, 9.66729447e-02f, 1.74519811e-02f, 2.72218771e-02f,
  -1.33822635e-01f, 5.33921309e-02f, 1.19674049e-01f, -4.50116359e-02f, 3.88983712e-02f, -3.61046232e-02f, 1.17495239e-01f, -1.65073872e-01f, -4.18120101e-02f, -3.26127484e-02f,
  -4.52101976e-02f, 1.74318738e-02f, 1.77200928e-01f, 1.68820024e-01f, 9.89426672e-03f, 1.36805475e-01f, -7.42620155e-02f, -6.12125918e-02f, -1.24880122e-02f, 2.44154513e-01f,
  2.18206897e-01f, 7.31854066e-02f, -7.15903461e-01f, -4.29588072e-02f, -4.36070085e-01f, -4.96931672e-01f, 5.81391994e-03f, 1.92422822e-01f, 1.16453424e-01f, 2.15870112e-01f,
  -7.79164955e-02f, -1.93650231e-01f, -2.33277529e-01f, -2.19808787e-01f, -1.00462390e-02f, -4.10632864e-02f, -2.86733985e-01f, -4.87219751e-01f, -4.97072011e-01f, -1.86071202e-01f,
  4.99587394e-02f, 5.66815585e-02f, 3.05739907e-03f, -1.42008558e-01f, -2.32315913e-01f, -3.64021242e-01f, -3.35988343e-01f, -2.66488552e-01f, -3.62178802e-01f, -3.86128366e-01f,
  -3.70436192e-01f, -3.78106564e-01f, -6.78242445e-02f, 1.16956562e-01f, -4.68034390e-03f, -3.77465375e-02f, -1.32791445e-01f, -3.52537036e-02f, 8.04849118e-02f, 1.40676081e-01f,
  -2.65442938e-01f, 2.08444428e-02f, -2.00685367e-01f, -2.15781108e-01f, -1.05622850e-01f, -8.97714645e-02f, 9.16443691e-02f, -1.57100633e-01f, -1.12998910e-01f, -2.05382574e-02f,
  -9.60718095e-02f, -5.31983256e-01f, -5.89145482e-01f, -1.82876527e-01f, -3.05959791e-01f, -3.75799090e-01f, -3.41143638e-01f, -4.69094694e-01f, -5.03294051e-01f, 1.07649624e-01f,
  1.90565333e-01f, -2.05153935e-02f, 1.16013147e-01f, 1.95262894e-01f, 3.24986964e-01f, 2.06303634e-02f, -1.00966105e-02f, 1.11329950e-01f, 7.23930523e-02f, 8.58557597e-02f,
  2.54673716e-02f, 3.78893316e-02f, 2.87460387e-02f, -3.56512726e-04f, -4.05480638e-02f, -1.57346398e-01f, 1.19160235e-01f, 1.21225074e-01f, 3.97919789e-02f, 1.07009545e-01f,
  -1.37359560e-01f, -1.36232331e-01f, -1.95690557e-01f, 7.41382018e-02f, -1.51785556e-02f, -2.24626139e-02f, 1.18101962e-01f, 1.19472146e-01f, 9.04446617e-02f, 2.51971632e-02f,
  3.76465291e-01f, 1.25322968e-01f, 5.29961400e-02f, 6.96965456e-02f, -7.93837383e-02f, 1.53047089e-02f, 1.07023187e-01f, 1.86820328e-01f, -1.81750819e-01f, -7.00009242e-02f,
  -3.93981524e-02f, 9.69539583e-02f, 6.20033890e-02f, -4.35954854e-02f, 6.15674220e-02f, -1.66090056e-01f, 1.14247799e-01f, -1.87879711e-01f, -4.89586107e-02f, 6.43164963e-02f,
  3.16915780e-01f, 1.26464009e-01f, 1.14759028e-01f, 3.04796081e-02f, 3.07668522e-02f, -9.07470137e-02f, -9.76232663e-02f, -5.07887416e-02f, -2.31879130e-02f, 4.53760713e-01f,
  -3.60658228e-01f, 7.30768502e-01f, 3.64693284e-01f, -4.55936551e-01f, -1.77868679e-02f, 3.64006728e-01f, 7.61307836e-01f, 2.60211676e-01f, -2.34918091e-02f, 6.37035966e-01f,
  5.60356855e-01f, -4.51561153e-01f, -2.04221845e-01f, -1.71337053e-01f, 8.09215233e-02f, 5.92104435e-01f, 6.72465712e-02f, -5.63711822e-01f, -6.41593933e-01f, -2.33328864e-01f,
  -3.32053572e-01f, -4.66221213e-01f, -3.68182868e-01f, -4.11400914e-01f, -3.17811847e-01f, -5.47849059e-01f, 1.44478217e-01f, -1.12134054e-01f, 3.97946648e-02f, -4.35945421e-01f,
  -2.86216050e-01f, 1.21043436e-01f, -4.96420830e-01f, -5.24889350e-01f, -9.36628208e-02f, -3.23384702e-01f, 6.34250268e-02f, -1.54606830e-02f, 1.13261022e-01f, 2.30438054e-01f,
  -2.78517958e-02f, 1.28848016e-01f, 7.86332339e-02f, -1.79695785e-01f, 6.40532449e-02f, -1.46473706e-01f, -8.66215229e-02f, -1.61743745e-01f, -1.33911803e-01f, 2.00424150e-01f,
  8.21932629e-02f, -5.99866025e-02f, 1.45011574e-01f, 3.17476958e-01f, 3.11935663e-01f, -2.78724343e-01f, 1.47293001e-01f, -2.11011514e-01f, -1.92483783e-01f, -1.92457542e-01f,
  -2.48032380e-02f, 1.31341800e-01f, 7.47098699e-02f, 1.56383738e-01f, 1.07389420e-01f, -7.64224678e-02f, 8.61998927e-03f, -1.38708279e-02f, 7.21310675e-02f, -8.91680717e-02f,
  1.27546623e-01f, 1.99506149e-01f, 1.06789604e-01f, 1.99292004e-01f, -8.88274759e-02f, 2.79488452e-02f, 2.51157228e-02f, 1.03021570e-01f, 1.22420974e-01f, 5.82409538e-02f,
  -1.04542993e-01f, -5.33123314e-02f, -9.56917033e-02f, -1.21425971e-01f, 1.37320906e-01f, 1.42153949e-01f, -5.96193690e-03f, 7.09702000e-02f, -6.18179468e-03f, 2.18599737e-01f,
  -6.42377734e-01f, -1.74004119e-02f, -3.92998397e-01f, -2.15614304e-01f, -4.45219614e-02f, -1.71936259e-01f, -9.95747298e-02f, 5.89890406e-02f, 1.68929189e-01f, 1.88098073e-01f,
  1.98789701e-01f, 5.40987924e-02f, 1.53416112e-01f, -4.86077890e-02f, -1.24479853e-01f, 1.67497262e-01f, 1.80348605e-01f, -2.95847058e-01f, -1.14874803e-01f, 7.43822604e-02f,
  7.62170404e-02f, -1.02511691e-02f, -2.60418922e-01f, -1.27839372e-01f, -1.49466060e-02f, -3.25309366e-01f, -3.23913515e-01f, -4.15675670e-01f, -3.25054020e-01f, -4.06834096e-01f,
  -8.70980442e-01f, -2.65141964e-01f, -2.11143523e-01f, -6.80012882e-01f, -7.17166901e-01f, -3.07993859e-01f, -3.15492272e-01f, -2.48867214e-01f, -3.74309897e-01f, -3.66729796e-01f,
  1.24819474e-02f, 1.10295519e-01f, 1.32282063e-01f, 7.70597830e-02f, 1.16464652e-01f, -1.66252077e-01f, -2.60605663e-01f, -3.96930844e-01f, -2.06844255e-01f, -2.42603555e-01f,
  -3.31116349e-01f, -5.67039251e-01f, -4.21235591e-01f, -3.65035981e-01f, -3.08363587e-01f, -1.97887585e-01f, -3.32877994e-01f, -4.73081499e-01f, -1.88643679e-01f, -3.71181369e-01f,
  1.61715016e-01f, -2.49646559e-01f, -1.28266439e-01f, -4.43436913e-02f, -2.02216610e-01f, -1.99737940e-02f, -9.76961255e-02f, -1.92570210e-01f, -3.33767831e-02f, -8.09688568e-02f,
  -6.85687959e-02f, -2.76018642e-02f, -1.60418391e-01f, -2.25370247e-02f, -1.90952033e-01f, -1.31761700e-01f, 6.71848208e-02f, -1.62479088e-01f, 5.81980012e-02f, 2.09156245e-01f,
  2.34331667e-01f, -1.04721725e-01f, 1.01337969e-01f, 2.06483200e-01f, 2.09071383e-01f, -4.55768481e-02f, 1.20581053e-01f, 1.10690795e-01f, 7.30524212e-02f, -2.14675218e-01f,
  -2.06260964e-01f, 5.49311414e-02f, 5.76496124e-02f, 1.86156426e-02f, 2.05573644e-02f, 4.11228761e-02f, -5.33154719e-02f, -3.66261899e-02f, 2.79966649e-03f, -4.24495190e-02f,
  -1.19985260e-01f, 1.96042970e-01f, -6.19670264e-02f, -2.03287289e-01f, 7.54863471e-02f, 8.56333040e-03f, 6.36140928e-02f, 1.62765384e-02f, 4.05902751e-02f, -6.17409237e-02f,
  9.91556272e-02f, 7.73567110e-02f, -4.40379456e-02f, 9.09704491e-02f, 2.33736169e-02f, -3.43581513e-02f, 4.98048402e-02f, 9.11276862e-02f, 1.07753642e-01f, 1.64133888e-02f,
  -9.34086516e-02f, 1.55249894e-01f, -8.65160823e-02f, 9.98632684e-02f, 2.11463938e-03f, 1.30628034e-01f, 9.50974524e-02f, 7.49266520e-03f, -9.46659371e-02f, -1.38562620e-01f,
  1.46280810e-01f, 5.70861213e-02f, -3.45232151e-02f, 6.71764091e-02f, -8.47130343e-02f, 1.32818341e-01f, 1.03536420e-01f, -3.27877365e-02f, 2.61936665e-01f, 1.81592464e-01f,
  1.88226253e-01f, 5.90489581e-02f, 4.71477099e-02f, 1.02914333e-01f, 9.70883444e-02f, 5.83819561e-02f, 1.88878283e-01f, 1.63704976e-01f, 8.64380524e-02f, -1.02198064e-01f,
  3.29191148e-01f, -6.49090409e-01f, 1.28060523e-02f, -3.44322920e-01f, -2.63964951e-01f, -2.19292343e-01f, -5.35538495e-01f, -3.48496705e-01f, -1.19239286e-01f, -3.59265000e-01f,
  1.74937069e-01f, 7.78505921e-01f, 6.33982718e-01f, 5.95748603e-01f, 4.30988371e-01f, -5.30853927e-01f, -3.45941007e-01f, 5.68684638e-01f, 6.44322872e-01f, -3.90294157e-02f,
  -1.19473286e-01f, -1.09599486e-01f, 2.68621385e-01f, 3.88644226e-02f, -8.18171263e-01f, 1.01262040e-01f, -4.08590645e-01f, -3.10238272e-01f, -9.35968459e-02f, -4.05816883e-01f,
  -2.12178260e-01f, -2.08387360e-01f, 2.42179513e-01f, 3.72203559e-01f, 3.72412354e-02f, 4.97321505e-03f, -1.61789209e-01f, -1.71086058e-01f, 1.57423969e-02f, -1.92761466e-01f,
  1.46166801e-01f, 1.46032006e-01f, 1.30123854e-01f, -1.82954252e-01f, -1.78396121e-01f, -1.30374998e-01f, -1.80692226e-01f, 4.54729609e-02f, 9.44566056e-02f, -2.30916858e-01f,
  -6.81253076e-02f, 1.69246256e-01f, 6.75611123e-02f, -2.24296257e-01f, -4.57930893e-01f, 3.13452512e-01f, -5.33401132e-01f, -2.78866470e-01f, -4.14343774e-02f, -7.47391999e-01f,
  -9.13249515e-03f, 2.90057771e-02f, -3.15971533e-03f, -4.38635051e-02f, -3.18356194e-02f, 6.06956743e-02f, -7.29847848e-02f, -7.10015446e-02f, 3.49526703e-02f, -1.02743551e-01f,
  7.59705901e-02f, 4.02672403e-02f, 2.12126046e-01f, -1.13496944e-01f, 1.87953524e-02f, -1.40302792e-01f, 4.89560626e-02f, -6.23844005e-02f, -2.23882329e-02f, 4.41129729e-02f,
  1.40228331e-01f, -1.85250696e-02f, -3.55922617e-02f, 3.85615751e-02f, 1.35542482e-01f, 8.61212909e-02f, -7.28898570e-02f, 1.06833376e-01f, -1.52374849e-01f, -9.00114253e-02f,
  -1.29346043e-01f, 5.11934936e-01f, -1.19123414e-01f, 7.62351155e-02f, -3.37260254e-02f, 8.54621604e-02f, -9.53721702e-02f, 3.27342702e-03f, 1.19716138e-01f, -2.85275765e-02f,
  9.69345507e-04f, -1.76896416e-02f, -1.29901767e-01f, -1.26992598e-01f, 6.98519051e-02f, -9.30057392e-02f, -3.32375392e-02f, 2.07712650e-01f, 4.88931388e-02f, -1.63139090e-01f,
  -2.50828266e-01f, 2.32158434e-02f, 1.36899799e-01f, -5.03001101e-02f, -1.71458736e-01f, 2.34171256e-01f, -3.33744675e-01f, -3.23776186e-01f, 3.00452083e-01f, -5.27077138e-01f,
  -3.71285915e-01f, -2.73574024e-01f, 1.73374817e-01f, -3.03367287e-01f, -5.40006280e-01f, -5.20610631e-01f, -3.89298588e-01f, -3.76058817e-01f, -4.72366869e-01f, -3.40597391e-01f,
  -9.85734537e-02f, 3.42995554e-01f, 4.40274447e-01f, 3.55341017e-01f, 3.68361861e-01f, -1.16619162e-01f, -1.38070241e-01f, 4.43875641e-01f, 2.98693806e-01f, -2.48427704e-01f,
  -2.87473589e-01f, -3.49188410e-02f, 1.60154730e-01f, 5.17115109e-02f, -3.80872995e-01f, 3.75338979e-02f, -1.77657977e-01f, -2.61643916e-01f, -1.65500164e-01f, -3.40446234e-01f,
  3.54303032e-01f, -4.29403216e-01f, 9.19506997e-02f, -6.46925196e-02f, -1.52762130e-01f, -3.47668603e-02f, -8.11683834e-02f, -2.11394262e-02f, -1.70234293e-02f, -2.80625727e-02f,
  -1.67427719e-01f, -1.14872865e-02f, -5.67528978e-02f, 6.14225827e-02f, -1.59884661e-01f, -1.45981684e-01f, 3.42651345e-02f, 1.05121672e-01f, -4.60129827e-02f, -2.52271611e-02f,
  -9.16679204e-02f, -1.96870327e-01f, 3.28853168e-02f, 2.06350647e-02f, -1.19082399e-01f, 6.51080310e-02f, 5.31001799e-02f, -1.26068547e-01f, 2.14211382e-02f, -4.25626300e-02f,
  -1.57642663e-01f, 4.79754582e-02f, -7.59964660e-02f, 3.94564830e-02f, -1.05091622e-02f, -5.00243381e-02f, 4.29972485e-02f, -4.58870344e-02f, -4.32580374e-02f, 7.05008209e-02f,
  -1.66862216e-02f, -2.49916390e-02f, 3.59294824e-02f, -1.25572711e-01f, 7.28668347e-02f, -3.71114239e-02f, 4.44230903e-03f, 9.56816450e-02f, -9.98069644e-02f, -1.55264819e-02f,
  -5.24893776e-02f, -8.79654810e-02f, 1.47560369e-02f, 1.14446938e-01f, -8.02059770e-02f, 1.78686772e-02f, -1.09881125e-01f, 7.60288984e-02f, -1.51180141e-02f, -2.14470997e-01f,
  4.97743756e-01f, 1.60528883e-01f, 4.18309197e-02f, 7.33129010e-02f, -1.39328718e-01f, -3.20357867e-02f, -3.01296245e-02f, -6.65849447e-02f, -1.34659233e-02f, 7.16627017e-02f,
  -8.10801983e-02f, 8.80481750e-02f, 6.17507547e-02f, -3.90800741e-03f, -1.28591736e-03f, -1.27711952e-01f, 5.06280959e-02f, -5.47144935e-02f, -1.60276536e-02f, -1.10729896e-01f,
  -2.91023031e-02f, -7.41849318e-02f, 1.34781972e-01f, 2.11213917e-01f, -3.72029357e-02f, 6.98283613e-02f, 2.39426151e-01f, -4.84640300e-02f, 1.68833166e-01f, 3.62800620e-02f,
  6.68315172e-01f, 6.23413682e-01f, 1.99913263e-01f, 1.37746319e-01f, 1.71735771e-02f, -9.36742648e-02f, -1.82792649e-01f, 5.54587096e-02f, -6.52867407e-02f, 1.17742762e-01f,
  -8.01851824e-02f, -1.00605235e-01f, -6.44832402e-02f, -2.62549669e-02f, -1.12895049e-01f, -1.19152507e-02f, 1.11906484e-01f, 2.29712557e-02f, -9.50059593e-02f, -4.55374531e-02f,
  -2.41933344e-03f, 1.45562619e-01f, -2.33330932e-02f, -3.25783864e-02f, 3.82476866e-01f, -1.13268040e-01f, 6.63498044e-02f, 2.19532177e-01f, 7.40038306e-02f, 4.48726028e-01f,
  1.14918694e-01f, 4.86014754e-01f, -4.79579359e-01f, -2.25717667e-02f, 3.59458029e-02f, 6.08058125e-02f, -5.64293973e-02f, 2.08530411e-01f, -4.89978231e-02f, 4.66027707e-02f,
  1.13406241e-01f, 1.24747500e-01f, 8.13150853e-02f, 1.46251857e-01f, 1.26364410e-01f, -5.23945615e-02f, 7.94182271e-02f, 7.75940195e-02f, -9.48049799e-02f, 9.33811590e-02f,
  -5.38736628e-03f, 7.98435882e-02f, 1.15649492e-01f, -1.32887468e-01f, 8.57216418e-02f, -1.56794071e-01f, 2.66198236e-02f, 1.01376459e-01f, -2.49279857e-01f, 2.10108832e-01f,
  3.34863737e-02f, 9.24814567e-02f, 8.58301297e-02f, 2.06969947e-01f, -6.39908239e-02f, 2.58189328e-02f, 2.85158485e-01f, 3.68651040e-02f, -2.81618051e-02f, 1.87634468e-01f,
  -2.10055653e-02f, -1.17348142e-01f, 2.49140840e-02f, 9.01042223e-02f, 2.18581967e-02f, 2.59762853e-01f, -1.12315174e-02f, -1.27915328e-03f, -7.39414394e-02f, 3.58500332e-03f,
  -3.94631959e-02f, -9.15816650e-02f, 2.32272316e-02f, 1.50022298e-01f, 7.40639865e-02f, 1.11652151e-01f, -2.71300748e-02f, 4.37533706e-02f, 9.85627547e-02f, 1.23125158e-01f,
  -4.55597550e-01f, -4.62425143e-01f, -3.04764399e-04f, 2.10151255e-01f, 2.87815690e-01f, -7.43302479e-02f, 1.26504555e-01f, -1.32833898e-01f, 1.61857959e-02f, 3.75802852e-02f,
  -1.78456664e-01f, -2.24947222e-02f, 1.59040932e-02f, -7.05485269e-02f, -1.24798581e-01f, -1.29448488e-01f, 1.13861054e-01f, -6.03465810e-02f, -9.32791233e-02f, 3.16610098e-01f,
  -5.10541499e-02f, -3.43885064e-01f, -3.85445774e-01f, -2.42634684e-01f, -1.38870656e-01f, -4.44318742e-01f, -4.10956711e-01f, -3.76435786e-01f, -6.02350235e-01f, -5.44113576e-01f,
  -5.99929035e-01f, -2.03783780e-01f, 2.44855002e-01f, -7.28911087e-02f, -2.85820421e-02f, -3.76098812e-01f, -3.36447179e-01f, -3.74954909e-01f, -2.48516321e-01f, -9.27255973e-02f,
  -1.81386787e-02f, 1.96750581e-01f, 2.48472676e-01f, -9.97918844e-02f, -2.07779825e-01f, -1.62183210e-01f, -3.41377288e-01f, -1.32872403e-01f, -2.08211899e-01f, -1.37890935e-01f,
  -9.09537300e-02f, 5.04797287e-02f, -2.31446847e-01f, -2.14601472e-01f, 1.41435847e-01f, 9.76944491e-02f, 1.12586334e-01f, -2.52144132e-02f, -1.09087184e-01f, 1.73105463e-01f,
  4.99522060e-01f, -2.02196121e-01f, 1.08848186e-02f, -2.21058980e-01f, -1.46855131e-01f, -2.41932780e-01f, -1.94096547e-02f, -4.62495498e-02f, -1.26868039e-01f, -7.74410143e-02f,
  -6.48180321e-02f, -4.61091138e-02f, -8.88798609e-02f, -2.48157755e-02f, -5.11811152e-02f, 5.99117652e-02f, -1.11329526e-01f, -1.29236192e-01f, -1.50817990e-01f, 5.98256942e-03f,
  -9.46701765e-02f, -1.22826114e-01f, 9.29332152e-03f, -4.45359275e-02f, -9.82097164e-02f, -1.42485097e-01f, -2.69003604e-02f, -1.74435079e-01f, -2.35015735e-01f, 8.35051015e-02f,
  -1.73122421e-01f, -6.83502182e-02f, -1.86091498e-01f, 3.96441817e-02f, 9.04546529e-02f, -6.47778660e-02f, 6.65142611e-02f, -3.11343651e-02f, -1.07361227e-01f, 6.14239760e-02f,
  -3.61170545e-02f, 7.05600381e-02f, 9.38349664e-02f, -4.32870314e-02f, -7.11501837e-02f, -1.24680579e-01f, -1.75229892e-01f, -4.57328185e-02f, -8.09902847e-02f, -1.50752580e-02f,
  -7.62214586e-02f, 1.01740491e-02f, 6.32708818e-02f, 6.51357844e-02f, -1.89697772e-01f, -1.57032296e-01f, -1.40322536e-01f, 6.40882272e-03f, -9.86867398e-02f, -1.23699397e-01f,
  4.10749525e-01f, -1.95994973e-01f, 3.04160386e-01f, -1.00061379e-01f, 2.45790426e-02f, -1.53118312e-01f, 5.89856738e-03f, -6.97362199e-02f, -5.22552431e-02f, -6.44981069e-03f,
  -2.03993008e-01f, -2.03244723e-02f, 1.51196986e-01f, 3.07609439e-02f, 7.24244714e-02f, 1.13320984e-01f, -1.52439594e-01f, 3.68422307e-02f, -1.30150884e-01f, 2.67110113e-02f,
  -7.34080598e-02f, -1.15353830e-01f, 1.57805547e-01f, 1.37073487e-01f, -2.43430808e-02f, 4.64902408e-02f, 2.21568704e-01f, 8.05168226e-02f, 5.25182262e-02f, 2.49625951e-01f,
  -4.07034785e-01f, -3.48923892e-01f, -1.63624093e-01f, 1.51161272e-02f, 3.29839408e-01f, -4.20292258e-01f, -6.99768364e-01f, -7.21841991e-01f, 7.50010833e-02f, 2.99506094e-02f,
  5.48983634e-01f, 5.78401744e-01f, 3.22100639e-01f, -1.33155575e-02f, -5.63211858e-01f, -5.01326561e-01f, -4.88520265e-01f, -2.99896538e-01f, -3.02554280e-01f, -8.84149969e-03f,
  2.70055026e-01f, 1.50293950e-02f, -1.63558707e-01f, -3.56271751e-02f, 5.39962232e-01f, 5.41815579e-01f, 1.75602674e-01f, 2.50199705e-01f, 1.82965711e-01f, 3.97038549e-01f,
  5.56378067e-01f, -1.54184088e-01f, 1.67607777e-02f, 1.26326844e-01f, 1.64565042e-01f, -1.17847338e-01f, 3.13726664e-02f, -1.52045324e-01f, -3.87917049e-02f, 6.69534057e-02f,
  4.21996295e-01f, -5.98990060e-02f, -3.06406189e-02f, 1.28928125e-01f, 1.82144102e-02f, -1.36608304e-02f, -1.58844694e-01f, -3.51756752e-01f, -2.48257861e-01f, 7.71448687e-02f,
  2.87833065e-01f, 1.36830285e-01f, 8.12082067e-02f, -8.84489790e-02f, -4.30745631e-02f, 1.94168776e-01f, 9.86076295e-02f, 7.84966350e-02f, -1.77448496e-01f, 5.30342665e-03f,
  8.70375931e-02f, 2.07674727e-01f, 1.02855936e-01f, -3.63585874e-02f, 1.53033435e-01f, 1.11578733e-01f, 2.49500647e-02f, 1.46309122e-01f, 7.12965727e-02f, 4.80959602e-02f,
  -3.36485058e-02f, -1.91390067e-02f, -5.85011542e-02f, -1.79742217e-01f, 1.27187356e-01f, 1.18999839e-01f, 2.14846939e-01f, 8.86384398e-02f, 5.36197461e-02f, 7.21992850e-02f,
  8.05004835e-02f, 1.34807527e-01f, 2.08780557e-01f, 1.34249358e-02f, 3.11066080e-02f, 1.18092120e-01f, 1.45923436e-01f, 8.16854760e-02f, 4.07600105e-02f, 1.26474798e-01f,
  3.41347426e-01f, -3.57369930e-01f, 1.83793560e-01f, -6.48198649e-02f, 1.29385823e-02f, -4.88790916e-03f, 2.03147456e-01f, -1.18225493e-01f, 1.62356794e-01f, 1.38065755e-01f,
  4.90775816e-02f, 5.33884540e-02f, -7.24440292e-02f, -5.11227064e-02f, -5.19849248e-02f, 1.51916370e-01f, -1.54017627e-01f, 1.75776407e-01f, -1.28901079e-01f, 1.80302858e-01f,
  -1.89108476e-01f, -1.74987540e-01f, -1.22683682e-01f, -3.03698648e-02f, -5.81805259e-02f, 1.91772189e-02f, 7.27898180e-02f, 1.18087940e-01f, -1.60426468e-01f, -1.47292912e-01f,
  -6.05744600e-01f, -7.22383082e-01f, 3.02868132e-02f, -4.58106518e-01f, -2.41246596e-01f, -2.68455714e-01f, -6.73675478e-01f, -2.93529242e-01f, -6.20102175e-02f, -8.43968987e-01f,
  -4.56062198e-01f, -1.18711829e-01f, -6.75150752e-02f, -9.12320465e-02f, -3.44999850e-01f, -7.90968835e-01f, -4.94200975e-01f, 6.06652237e-02f, 1.73567027e-01f, -1.69654503e-01f,
  -4.27403510e-01f, -2.96263129e-01f, -8.10083374e-02f, 1.52351588e-01f, -2.05089971e-01f, 6.76097795e-02f, 6.55495152e-02f, -5.46622463e-02f, 1.57173201e-02f, -3.39020789e-01f,
  -3.98384899e-01f, 3.15055549e-02f, 2.61184543e-01f, 4.14570756e-02f, -3.20830166e-01f, -8.41928348e-02f, -1.13452598e-01f, 1.88533857e-01f, 5.54917827e-02f, -2.57067114e-01f,
  -8.36625397e-02f, -1.42311081e-01f, 5.58712706e-02f, -1.92084551e-01f, -2.83530265e-01f, -9.86099616e-02f, -1.37189021e-02f, 2.37632915e-02f, -2.04817969e-02f, -2.23745063e-01f,
  -2.81042218e-01f, -8.10087174e-02f, 2.27683097e-01f, 2.64718980e-01f, 1.92559808e-01f, 7.67192021e-02f, 1.11740835e-01f, 1.73836946e-01f, 3.05040330e-01f, -3.37568611e-01f,
  -8.46146643e-02f, -6.84926957e-02f, 5.35228737e-02f, 6.33926690e-02f, -2.65969229e-05f, 1.72448307e-01f, -3.53562944e-02f, -1.00954406e-01f, 3.17355320e-02f, -1.04333833e-01f,
  -1.41311064e-01f, -1.35905206e-01f, -1.36745408e-01f, -2.23744307e-02f, -5.30108549e-02f, -1.25617161e-02f, -9.22557190e-02f, -3.89684625e-02f, 1.28375009e-01f, -5.06308675e-02f,
  2.10854933e-02f, -8.54452141e-03f, 1.76571950e-01f, -5.34419902e-02f, -1.93435326e-02f, -8.59631971e-02f, 4.96503972e-02f, 4.48623113e-02f, -6.17015846e-02f, 3.02279200e-02f,
  -2.08927855e-01f, 3.35873455e-01f, -4.12425876e-01f, 7.28082359e-02f, -6.74555525e-02f, 1.80590630e-01f, -5.39563708e-02f, 7.44199902e-02f, 1.38765469e-01f, -2.37342432e-01f,
  3.83228958e-02f, -4.08211917e-01f, -6.04366921e-02f, -3.74927884e-03f, -1.00068688e-01f, 7.39614144e-02f, -2.64399439e-01f, -1.49380818e-01f, 2.44068563e-01f, -7.06940442e-02f,
  -1.64009213e-01f, -1.69423670e-01f, -3.12234163e-01f, -6.88790828e-02f, -1.10742254e-02f, -4.45672423e-02f, -6.70389384e-02f, 4.99509424e-02f, -2.13990398e-02f, -6.22238457e-01f,
  3.78960133e-01f, 2.88899094e-02f, -5.89440644e-01f, 3.10847789e-01f, -1.15612529e-01f, -2.92847782e-01f, -3.72767270e-01f, 4.47650142e-02f, 2.81633735e-01f, -1.45211145e-02f,
  -1.87792331e-01f, -2.29337037e-01f, -2.11710751e-01f, -3.69774461e-01f, -5.11224270e-01f, -3.68840992e-01f, -2.90535748e-01f, -6.42190933e-01f, -5.49626231e-01f, -3.00890923e-01f,
  -2.41631359e-01f, -2.92519569e-01f, -2.92271286e-01f, -2.04686105e-01f, 4.66485806e-02f, -2.31759369e-01f, -2.57056683e-01f, -2.38767743e-01f, -2.84224987e-01f, -1.98350564e-01f,
  -3.72685492e-01f, -1.86202570e-03f, 2.61872169e-02f, 8.60608742e-02f, 9.10433754e-02f, 1.61759302e-01f, -6.10674471e-02f, 3.37655872e-01f, 1.75832212e-01f, 2.24165529e-01f,
  3.56841087e-02f, 1.31004099e-02f, -5.67577332e-02f, 5.49740763e-03f, 6.20658845e-02f, 4.47733440e-02f, 2.61499524e-01f, 1.24237396e-01f, 9.22989771e-02f, 2.33601227e-01f,
  1.02788635e-01f, 3.45417522e-02f, 4.70983312e-02f, 1.47171855e-01f, 1.18260004e-01f, 1.40936358e-03f, 6.07582554e-02f, 1.59859002e-01f, 1.12088844e-02f, 3.17832083e-01f,
  -6.35288805e-02f, 7.61448294e-02f, -2.50750408e-02f, -3.04842517e-02f, 8.45770612e-02f, 7.83849955e-02f, 1.37170389e-01f, 6.86825737e-02f, -9.94365066e-02f, -3.13206352e-02f,
  1.11375131e-01f, 5.56763634e-03f, -3.99552658e-03f, -7.98940286e-02f, -8.02831426e-02f, 5.83263347e-03f, -3.54630388e-02f, 7.18301581e-03f, -6.90440834e-02f, 1.03851244e-01f,
  3.03106569e-02f, 1.73050780e-02f, -9.34734568e-03f, -8.33723973e-03f, -2.91578807e-02f, 2.67002098e-02f, -3.44163515e-02f, -1.25258222e-01f, -1.44677330e-02f, 8.24618340e-03f,
  -6.26952350e-02f, -3.12600642e-01f, 9.68274078e-04f, 1.54166520e-02f, 6.31177947e-02f, 1.88746110e-01f, 1.25497326e-01f, 9.79514346e-02f, 1.61115497e-01f, 9.89877433e-02f,
  -1.04896665e-01f, 5.93247898e-02f, -1.43653629e-02f, 1.32149264e-01f, -1.39120594e-01f, 5.63613027e-02f, 2.26014093e-01f, 8.64854008e-02f, -2.49143923e-03f, 2.55125374e-01f,
  2.68821001e-01f, 1.33919939e-01f, 1.76948592e-01f, 1.16950989e-01f, 5.85891381e-02f, -1.47599459e-01f, -1.62037641e-01f, -1.37126995e-02f, -1.66748196e-01f, 2.21390054e-01f,
  -2.03529462e-01f, 1.37491018e-01f, 4.36116010e-01f, -1.13645501e-01f, -2.70696640e-01f, -4.61082727e-01f, -5.68400145e-01f, -2.50343591e-01f, 1.52650252e-01f, 1.98343009e-01f,
  6.24206550e-02f, -1.77917853e-01f, 8.03683177e-02f, -1.12734236e-01f, -3.57000798e-01f, 3.15372087e-02f, 2.43239135e-01f, -5.24611361e-02f, -4.08345968e-01f, -5.77962339e-01f,
  -3.31842870e-01f, -1.90614760e-01f, -3.16475295e-02f, -9.62775142e-04f, 3.17680180e-01f, 1.64947927e-01f, 5.02541065e-01f, 1.26485541e-01f, 1.36526406e-01f, 4.72057253e-01f,
  2.76231498e-01f, 1.00543618e-01f, -1.89595371e-01f, -9.01716128e-02f, 1.63885653e-01f, 2.11400867e-01f, -1.73177212e-01f, 2.87092149e-01f, -9.32180211e-02f, 5.71215078e-02f,
  -2.75651831e-02f, 6.48368001e-02f, -1.44793838e-01f, -3.90022732e-02f, -1.21055722e-01f, -2.62136281e-01f, 1.59810949e-02f, -7.67847225e-02f, 4.65057492e-02f, 1.35109812e-01f,
  -2.48452365e-01f, -2.72794425e-01f, -1.42051294e-01f, -4.05601412e-02f, 5.70594817e-02f, -1.80795472e-02f, -8.81887525e-02f, -4.39896286e-02f, 3.16422060e-02f, 2.46309876e-01f,
  1.72602072e-01f, 9.15664956e-02f, -1.17472254e-01f, 1.71067789e-02f, 2.05874396e-03f, 3.95566039e-02f, 1.00002423e-01f, 8.49001203e-03f, -7.07880706e-02f, 3.79998647e-02f,
  4.07869630e-02f, -6.42452622e-03f, 8.07355717e-02f, 6.45338669e-02f, -5.30197611e-03f, 5.87968454e-02f, -1.27043158e-01f, -5.80733083e-02f, 2.31607240e-02f, 8.36391300e-02f,
  6.98974240e-04f, -6.43505901e-02f, 1.13949917e-01f, -1.56146418e-02f, 5.26868775e-02f, 2.99876742e-02f, 6.17945828e-02f, -8.73697642e-03f, 2.68451474e-03f, 5.47312275e-02f,
  -2.89497226e-02f, -1.30096450e-01f, 9.08065289e-02f, -1.09137952e-01f, -5.62063418e-02f, 2.38680303e-01f, 1.81132853e-01f, 3.62170339e-02f, 4.95176464e-02f, 4.68794169e-04f,
  -1.82618245e-01f, -2.37947218e-02f, 5.58931194e-02f, 8.11997056e-03f, -2.79555708e-01f, -1.78422049e-01f, -1.48569405e-01f, -2.09320843e-01f, -2.46268228e-01f, 6.29168376e-02f,
  -2.97554936e-02f, -3.67402971e-01f, -3.25690091e-01f, -2.51384854e-01f, -1.81681082e-01f, -3.51729542e-01f, -1.44870639e-01f, -2.50533104e-01f, -2.82175601e-01f, -1.75681621e-01f,
  2.74612814e-01f, 3.75680834e-01f, -3.07387054e-01f, 1.59034505e-01f, -1.43661380e-01f, -1.04232728e-01f, 1.95908323e-01f, 1.50994465e-01f, 1.62111238e-01f, 7.92160034e-02f,
  -5.73268672e-03f, -5.29115200e-02f, -6.67057633e-02f, 3.51179130e-02f, 8.48074034e-02f, 8.23217481e-02f, -3.00669633e-02f, -1.73236549e-01f, -1.03519849e-01f, 1.13592528e-01f,
  1.97176486e-01f, 1.42161310e-01f, 9.39543992e-02f, 2.62798946e-02f, 1.11535363e-01f, 2.70374604e-02f, 8.85149091e-03f, -6.48029987e-03f, -4.61662970e-02f, 5.75066656e-02f,
  -8.41328949e-02f, -3.44555914e-01f, -8.68884996e-02f, -9.04085115e-02f, -8.03902447e-02f, 1.19067676e-01f, 2.60417853e-02f, 1.09422483e-01f, 4.24073115e-02f, 5.97008392e-02f,
  1.97795779e-02f, -1.50166169e-01f, -8.17016289e-02f, 4.70121987e-02f, 2.06778441e-02f, -9.93131623e-02f, -6.01737276e-02f, 1.19078450e-01f, -4.32273112e-02f, -4.56112484e-03f,
  -8.76096562e-02f, -1.22976854e-01f, 6.19869726e-03f, -1.04065068e-01f, -2.36559674e-01f, -1.96691930e-01f, -3.36050279e-02f, -1.99739914e-02f, -2.39172161e-01f, 5.11335991e-02f,
  -8.93093273e-02f, 1.11540914e-01f, -1.91408381e-01f, -1.67545795e-01f, -3.37221101e-02f, -6.39915019e-02f, 5.18517867e-02f, -4.00810037e-03f, -5.16245365e-02f, 1.65404789e-02f,
  1.32293459e-02f, -1.17643595e-01f, -8.65068436e-02f, -3.44310030e-02f, -1.69397250e-01f, -5.05814031e-02f, -1.02664262e-01f, 1.42415976e-02f, -2.21547827e-01f, -1.05046108e-01f,
  -6.71949163e-02f, 1.51772350e-01f, -5.31356893e-02f, -1.45924920e-02f, 6.93878829e-02f, -1.24026507e-01f, -1.74040869e-02f, -3.85604315e-02f, -1.15848228e-01f, 1.50442317e-01f,
  2.68043756e-01f, -5.74986041e-01f, 4.62003462e-02f, 6.74154684e-02f, 7.57848471e-02f, 2.03340314e-02f, -1.42704606e-01f, 1.16306301e-02f, 2.03410491e-01f, 9.75335985e-02f,
  -2.07158029e-02f, 1.08248346e-01f, 7.69803897e-02f, 4.60579358e-02f, 5.67866974e-02f, 1.08390329e-02f, 8.88821930e-02f, 4.61104847e-02f, 1.40858188e-01f, 1.12553522e-01f,
  1.34634286e-01f, 5.03522158e-02f, 1.04072385e-01f, 1.06049418e-01f, 4.40819561e-02f, -3.78358103e-02f, 1.53365299e-01f, 9.70640182e-02f, 1.43883172e-02f, 2.95439839e-01f,
  -2.90215462e-01f, 4.37024653e-01f, 4.50023681e-01f, -3.60993981e-01f, 3.14948440e-01f, 2.18636528e-01f, 2.34113142e-01f, -4.86022949e-01f, -4.10437852e-01f, 4.01531756e-01f,
  3.82630527e-01f, -2.69881129e-01f, -1.13383189e-01f, -3.51677656e-01f, -5.94369709e-01f, -7.49893636e-02f, -7.15033263e-02f, -3.97758216e-01f, -6.20364487e-01f, -4.63111848e-01f,
  -2.15486765e-01f, -3.08428407e-01f, -2.85746008e-01f, -3.17273498e-01f, 6.68644486e-03f, -1.06748052e-01f, 2.76576161e-01f, 1.94981202e-01f, 3.20951819e-01f, 1.30194023e-01f,
  3.00716728e-01f, 1.03005394e-01f, -1.60653085e-01f, -2.37403020e-01f, 7.76130855e-02f, -1.87296033e-01f, -5.11071365e-03f, -1.49864495e-01f, -1.21830581e-02f, -3.92355509e-02f,
  1.38297305e-01f, -1.51990026e-01f, -2.67257146e-03f, -4.00553010e-02f, -1.93456233e-01f, -3.46954763e-01f, -4.34666455e-01f, -3.67633849e-01f, -2.74452001e-01f, 1.10408455e-01f,
  2.08565384e-01f, 3.93684119e-01f, 1.15996942e-01f, -1.18722975e-01f, -2.28318885e-01f, -9.58620757e-02f, 2.62516320e-01f, 5.76786287e-02f, 5.01937941e-02f, -6.91752732e-02f,
  -1.66045457e-01f, 6.45170435e-02f, 5.47892302e-02f, 2.09387038e-02f, -9.60397944e-02f, 3.35303731e-02f, -1.19888760e-01f, -7.25803897e-02f, -2.54537985e-02f, -7.73287117e-02f,
  -6.21136017e-02f, 2.06155762e-01f, 3.30974571e-02f, -3.98215503e-02f, -1.06451251e-02f, -5.29092252e-02f, 1.17681623e-01f, 4.10435162e-02f, -1.33565003e-02f, 2.26497184e-02f,
  -1.09605361e-02f, 5.11271413e-03f, 1.35872990e-01f, -5.32374233e-02f, 1.43034622e-01f, 2.04699952e-03f, 8.36716890e-02f, 8.37845355e-02f, -8.66117850e-02f, -4.82062884e-02f,
  -3.67987573e-01f, 3.80157912e-03f, 5.28553277e-02f, -4.25682843e-01f, 3.46349701e-02f, -2.77201813e-02f, 1.32349774e-01f, -8.23204368e-02f, 1.17450081e-01f, -7.67827407e-02f,
  -3.90765583e-03f, -4.44382615e-02f, 8.75546411e-02f, -1.04527481e-01f, -1.33125275e-01f, -2.76534315e-02f, -2.38802671e-01f, -2.92993169e-02f, 1.24473812e-03f, 1.43398434e-01f,
  -2.29270533e-02f, -5.37442118e-02f, -2.69591391e-01f, -2.00592101e-01f, -4.69252653e-02f, -1.88039035e-01f, 3.08360215e-02f, -3.59495766e-02f, -1.26759961e-01f, -1.82163566e-01f,
  4.33929592e-01f, 3.49799484e-01f, 3.27420175e-01f, 7.70492777e-02f, -1.30187988e-01f, 9.54969227e-03f, 1.96047589e-01f, -9.72754657e-02f, -2.66210943e-01f, 7.50885084e-02f,
  -1.18889764e-01f, -2.93756038e-01f, -2.50107467e-01f, -1.76196799e-01f, 1.16528414e-01f, 1.85843170e-01f, 5.37817217e-02f, 1.59557715e-01f, 4.26953323e-02f, 1.21857658e-01f,
  7.35710934e-02f, 2.55786866e-01f, 2.51304895e-01f, 9.39711109e-02f, 2.62096763e-01f, 5.29409712e-03f, 6.98760077e-02f, 1.69234395e-01f, 1.45099878e-01f, 3.96587640e-01f,
  1.15615509e-01f, 2.95322150e-01f, -4.30920452e-01f, -2.28728637e-01f, 1.24657182e-02f, 3.46656218e-02f, -3.84939238e-02f, -7.57107884e-02f, -1.15637429e-01f, -7.86420107e-02f,
  5.71170375e-02f, -6.74120244e-03f, 1.25794932e-02f, -2.68284697e-02f, -1.01380393e-01f, -5.48245721e-02f, -4.05472666e-02f, 5.56289665e-02f, -1.56609714e-01f, 7.29714409e-02f,
  -9.42348316e-02f, 1.57115906e-01f, -2.05047932e-02f, -2.02593550e-01f, -6.05395585e-02f, -2.76089609e-01f, -2.13846453e-02f, 6.97681010e-02f, -1.14679307e-01f, -1.77829210e-02f,
  -4.38362747e-01f, -3.18671465e-02f, -2.13801470e-02f, -1.37814686e-01f, -3.17568332e-02f, -1.46363616e-01f, -2.70127915e-02f, -4.39799801e-02f, 1.87378693e-02f, -4.43243459e-02f,
  -1.07740678e-01f, -1.29924685e-01f, -1.71008512e-01f, -1.17527246e-01f, -1.56601295e-01f, 2.96468623e-02f, 3.40775424e-03f, -6.04303367e-02f, -5.30626662e-02f, 4.41330150e-02f,
  9.41967184e-04f, 6.91445768e-02f, -1.05361529e-01f, -3.71272229e-02f, -4.77911085e-02f, -2.52090275e-01f, -2.17012987e-01f, -1.72239929e-01f, -1.68359861e-01f, -9.76800919e-02f,
  -1.86470509e-01f, -1.56727657e-01f, -1.76242013e-02f, 2.26984337e-01f, 2.86873728e-01f, -5.21209054e-02f, 1.07531220e-01f, 1.35520220e-01f, 7.98735023e-02f, 3.32340561e-02f,
  7.08456263e-02f, 4.73971441e-02f, 2.26508901e-02f, 3.46787310e-05f, -1.86782509e-01f, -2.86441118e-01f, 1.04253516e-02f, 2.79000010e-02f, 7.69989006e-03f, -5.58137009e-03f,
  8.36148672e-03f, -1.89459041e-01f, -2.20038891e-01f, -4.06947434e-01f, -1.79771051e-01f, -4.18990850e-01f, -1.44458339e-01f, -1.96351588e-01f, -2.09479541e-01f, -3.13946694e-01f,
  8.44431698e-01f, 5.00823557e-02f, -8.43199849e-01f, 4.59095329e-01f, -2.08476231e-01f, -4.80959743e-01f, -5.75737119e-01f, -4.19145338e-02f, 2.88232088e-01f, -1.55389860e-01f,
  -1.97744578e-01f, 1.25066325e-01f, 1.32567674e-01f, -2.29996219e-01f, -3.69896293e-01f, -4.74516064e-01f, -5.10599911e-01f, -4.62760329e-01f, -4.90490973e-01f, -5.25102019e-01f,
  -2.31269181e-01f, -9.27392673e-03f, -9.87124071e-02f, -2.04352990e-01f, 5.78148328e-02f, 5.10577438e-03f, -2.80458361e-01f, -1.67957902e-01f, -3.85326356e-01f, -2.99082249e-01f,
  -6.94490016e-01f, -2.97880899e-02f, -2.54421774e-02f, 8.28663781e-02f, 3.49083841e-02f, 1.25071838e-01f, -3.31951212e-03f, 1.77473724e-01f, 2.01578945e-01f, 7.24465400e-02f,
  4.74772230e-02f, 1.22569978e-01f, 7.20285922e-02f, -5.97299337e-02f, -7.13565713e-03f, -7.33538717e-02f, -5.48422635e-02f, 3.36567387e-02f, 6.57192692e-02f, -7.24327415e-02f,
  -1.68197304e-01f, -9.85274091e-02f, -8.98296665e-03f, 4.94113266e-02f, -1.16290465e-01f, 1.24370968e-02f, -3.96333225e-02f, -8.67306963e-02f, -4.97938432e-02f, 2.45706543e-01f,
  -1.34059787e-01f, 7.84441158e-02f, -2.42242636e-03f, 3.05920262e-02f, 1.08444117e-01f, 1.70520738e-01f, 4.65898328e-02f, 6.91620633e-02f, 5.61386831e-02f, 1.48202822e-01f,
  1.54385388e-01f, 3.51824313e-02f, -2.91369241e-02f, 5.16032218e-04f, -6.25875071e-02f, 6.52203634e-02f, -6.70187688e-03f, 8.83809663e-03f, 3.49048413e-02f, 6.05782159e-02f,
  1.08971573e-01f, -1.77650678e-03f, -1.54729020e-02f, -1.52812704e-01f, -1.18766718e-01f, -7.94024542e-02f, 5.68711990e-03f, -6.73122332e-02f, -5.63794300e-02f, -1.73311383e-02f,
  2.31177613e-01f, -1.66707769e-01f, 1.16205029e-01f, 1.17835246e-01f, -5.32695698e-03f, -1.25817209e-02f, -9.62323993e-02f, 3.58233117e-02f, 5.32214232e-02f, -4.27982621e-02f,
  -2.03349233e-01f, -2.28859317e-02f, -6.98607340e-02f, -2.81299166e-02f, -2.54151542e-02f, -1.18076518e-01f, -2.15439834e-02f, 2.65523754e-02f, -1.48874208e-01f, -6.56196624e-02f,
  -5.85446842e-02f, 4.66572726e-03f, 9.46192145e-02f, 1.13483831e-01f, 3.32274996e-02f, 4.27045636e-02f, -3.19237038e-02f, 1.29627455e-02f, -1.86454356e-01f, 1.31689057e-01f,
  -1.34639919e-01f, 3.13635916e-01f, -4.10101980e-01f, 3.52726340e-01f, 9.20019597e-02f, 7.68678859e-02f, 5.86786449e-01f, 3.42968613e-01f, 3.63273621e-01f, 3.45023453e-01f,
  -2.78924286e-01f, -6.00229740e-01f, -3.76598090e-01f, -3.99056911e-01f, -3.93669903e-01f, 5.56249917e-01f, 5.51015437e-01f, -4.08392519e-01f, -4.82653677e-01f, -1.75772652e-01f,
  2.74059385e-01f, 3.58599514e-01f, -2.10626140e-01f, -4.97587509e-02f, 1.93082929e-01f, -6.96075931e-02f, 2.87564278e-01f, -8.43607113e-02f, -4.75685596e-02f, 1.30045861e-01f,
  -4.45567220e-01f, -3.36387813e-01f, -6.74715042e-02f, -3.52326594e-02f, -1.91567332e-01f, -7.77500942e-02f, 5.66782877e-02f, -2.07647994e-01f, -1.32847324e-01f, -3.22875828e-02f,
  -2.63931870e-01f, -2.46767402e-01f, -3.66181046e-01f, -1.14591725e-01f, -1.16689399e-01f, -2.84025639e-01f, 1.07661076e-02f, -2.69528031e-01f, -7.87847340e-02f, -2.97473758e-01f,
  -1.44230157e-01f, -4.65268344e-01f, -4.90810931e-01f, 3.12722325e-02f, -3.64971101e-01f, -3.63828361e-01f, -2.28602856e-01f, -4.13886726e-01f, -4.45819348e-01f, 4.54628021e-01f,
  2.31748134e-01f, 3.47145386e-02f, -2.17763223e-02f, 1.79789945e-01f, 1.28541455e-01f, 3.60221565e-02f, 2.29079071e-02f, 2.41954364e-02f, -3.95849720e-02f, -1.34649652e-03f,
  -1.64259985e-01f, -1.01157436e-02f, -1.33316040e-01f, 4.54391874e-02f, -5.35020679e-02f, -3.80667076e-02f, 3.73529308e-02f, 1.29884198e-01f, -5.85778989e-02f, 3.42589393e-02f,
  -2.02304125e-02f, -1.53233066e-01f, -2.87128426e-02f, -1.89497042e-02f, -1.92805920e-02f, -1.02652177e-01f, 1.17224678e-01f, -4.25348356e-02f, -4.50312300e-03f, 1.40733987e-01f,
  5.20952284e-01f, -2.38174900e-01f, 1.91340998e-01f, 8.63816813e-02f, 1.29560068e-01f, -9.29280818e-02f, -2.41302866e-02f, 1.52158011e-02f, -1.18328497e-01f, -1.15817510e-01f,
  -2.54389435e-01f, -3.43080610e-01f, -2.57111728e-01f, 3.33114527e-02f, -6.60634115e-02f, -5.22579290e-02f, 1.27142027e-01f, 1.11404598e-01f, 1.34003550e-01f, 4.37864400e-02f,
  3.30706209e-01f, 3.63546640e-01f, 1.96539581e-01f, 2.87685901e-01f, 8.41834620e-02f, 9.81565118e-02f, 2.53180057e-01f, 2.23068923e-01f, -5.61305359e-02f, 1.03494477e+00f,
  5.27960062e-01f, -3.25357795e-01f, 4.72825207e-02f, 1.40115365e-01f, 2.59837151e-01f, 1.91416711e-01f, 3.81221459e-03f, 4.70664687e-02f, 1.29889054e-02f, -3.72508429e-02f,
  -1.09853774e-01f, -5.13185151e-02f, 2.43395679e-02f, 3.76063175e-02f, 7.50611871e-02f, -1.99077930e-02f, 3.44974082e-03f, 1.59201771e-01f, 2.61893988e-01f, 5.46662584e-02f,
  -4.44105752e-02f, 1.05465293e-01f, 1.28385887e-01f, -5.47034256e-02f, -2.05295235e-01f, 3.92310470e-02f, -3.04652080e-02f, -6.80059940e-03f, -9.65485424e-02f, -2.47264758e-01f,
  -1.65973425e-01f, -1.60855979e-01f, 6.94184229e-02f, -3.90743949e-02f, -3.60611826e-02f, -3.50808837e-02f, 4.50537540e-02f, 1.12295961e-02f, 8.69990364e-02f, -4.52272035e-02f,
  4.47146073e-02f, -7.92989209e-02f, 1.98972300e-02f, -2.42010225e-02f, -4.47110273e-02f, -8.53476375e-02f, 5.65486727e-03f, -9.16237850e-03f, -1.23436444e-01f, -1.86242655e-01f,
  -1.90053672e-01f, -4.22184169e-02f, -8.74691978e-02f, -1.75496340e-02f, -9.58175585e-03f, 1.24715835e-01f, -1.23533525e-01f, 1.63508523e-02f, 4.16799784e-02f, -5.24578691e-02f,
  -1.73262805e-01f, -1.47033945e-01f, -1.20813645e-01f, -1.57739803e-01f, 7.81122223e-03f, 3.94032784e-02f, 5.32828756e-02f, 5.80836460e-02f, 4.54915352e-02f, -4.73788641e-02f,
  -6.34710267e-02f, 1.50954193e-02f, -1.35986954e-01f, -6.57520443e-02f, -5.27809281e-03f, -2.15455204e-01f, -3.19746658e-02f, -1.42639354e-01f, -6.87726066e-02f, 2.63618547e-02f,
  5.24238460e-02f, -7.37458169e-02f, -1.21556900e-01f, -1.30675226e-01f, -1.20848656e-01f, -6.41370043e-02f, -7.97830001e-02f, -1.13058485e-01f, -5.28024249e-02f, -5.51845133e-02f,
  -1.43175781e-01f, 1.41460896e-02f, 1.01497874e-01f, -2.94310320e-02f, 1.00760851e-02f, -9.99091715e-02f, 6.42070919e-02f, 1.37602717e-01f, 1.99603010e-02f, 1.28377497e-01f,
  -8.43701959e-02f, -2.16845982e-03f, -1.34330109e-01f, -1.02344684e-01f, 8.85242596e-02f, 8.81458297e-02f, 4.11021411e-02f, 5.79737350e-02f, -7.55756125e-02f, -1.50258124e-01f,
  -4.21423465e-02f, 9.74637046e-02f, 9.92199555e-02f, 5.43490984e-02f, 2.19410975e-02f, 2.44639561e-01f, 1.40282318e-01f, 6.66973591e-02f, 2.08512098e-01f, 3.12758207e-01f,
  9.75996912e-01f, -5.46886504e-01f, -3.22778702e-01f, 1.89799473e-01f, -2.07533881e-01f, -3.93610626e-01f, -5.99320948e-01f, -3.45246285e-01f, -9.88644511e-02f, -2.32611552e-01f,
  5.83404563e-02f, 6.17818058e-01f, 3.60381246e-01f, 3.16238046e-01f, 1.92798316e-01f, -5.17792344e-01f, -2.90069938e-01f, 4.11032587e-01f, 5.81183016e-01f, 3.71786058e-01f,
  1.94827378e-01f, 2.90182978e-01f, 5.32818973e-01f, 2.47284502e-01f, -1.01674303e-01f, 2.60532975e-01f, -2.70805836e-01f, -4.39757807e-03f, -8.43502954e-02f, -8.58487329e-04f,
  7.75110424e-02f, -1.90548750e-03f, 2.43024565e-02f, 4.35012668e-01f, 7.65656382e-02f, -6.46302849e-02f, -7.56057501e-02f, -5.39960340e-03f, -1.33178034e-03f, -1.45711958e-01f,
  2.42357999e-02f, 1.64039746e-01f, 9.18709263e-02f, -4.35544997e-02f, 6.00990839e-02f, -6.05847389e-02f, 5.43192551e-02f, 8.98524821e-02f, 9.99196395e-02f, 3.36702690e-02f,
  -7.19262520e-03f, 6.67382255e-02f, 1.52752046e-02f, -1.46615416e-01f, -1.24800108e-01f, 3.59002382e-01f, -3.77654135e-02f, 1.31267637e-01f, 1.15276694e-01f, -1.09945284e-02f,
  -3.32228839e-02f, 1.25999048e-01f, -1.13014109e-03f, -5.69134057e-02f, -3.34448507e-03f, -1.75336197e-01f, -5.44809438e-02f, 1.02939857e-02f, 1.35964528e-01f, -8.26113746e-02f,
  4.52953465e-02f, 1.75803974e-01f, 6.53242990e-02f, -2.71508731e-02f, 9.97551307e-02f, 5.05568832e-02f, 3.72121409e-02f, 1.16236985e-01f, 9.48418602e-02f, 1.03813820e-01f,
  1.52054802e-01f, -3.60954665e-02f, 7.24566057e-02f, 9.50021818e-02f, -9.86923091e-03f, 1.54200837e-01f, 9.02625099e-02f, 1.05206914e-01f, 1.69663221e-01f, 3.74799259e-02f,
  -1.77689537e-01f, 1.24256429e-03f, -1.16884820e-01f, 1.90453440e-01f, -1.03669733e-01f, -1.07539698e-01f, 9.65753756e-03f, 1.49779394e-01f, 5.46108671e-02f, -3.22697498e-02f,
  -5.00503518e-02f, -7.62975365e-02f, -1.84261307e-01f, -1.36676043e-01f, -7.52595961e-02f, -1.18365519e-01f, -6.90916041e-03f, 1.43979639e-01f, -2.64623035e-02f, -6.20515868e-02f,
  -1.05884388e-01f, -1.22978330e-01f, -2.52490323e-02f, -2.37471089e-01f, -1.70586318e-01f, 2.38460630e-01f, -2.79774368e-01f, -2.91034698e-01f, -8.61949846e-02f, -3.97371739e-01f,
  4.32729274e-01f, 1.03585735e-01f, -1.46590084e-01f, 3.03752542e-01f, 2.44377315e-01f, 3.16997081e-01f, 4.29561377e-01f, 5.11446834e-01f, 3.79998207e-01f, 3.60248476e-01f,
  2.38159195e-01f, 3.54789197e-01f, 2.76337773e-01f, 1.84154525e-01f, 1.75532967e-01f, 2.66727000e-01f, 2.34911337e-01f, 1.06595390e-01f, 7.99866915e-02f, 2.17007831e-01f,
  1.76734850e-01f, 1.14004180e-01f, -2.18869913e-02f, 1.49591252e-01f, 1.11781843e-01f, 3.07269692e-01f, 2.35764161e-01f, 7.70500302e-02f, 9.13828984e-02f, 1.75985590e-01f,
  -3.91082048e-01f, -8.08424205e-02f, -1.40799768e-03f, -5.59900515e-02f, -2.19491020e-01f, -1.73399411e-02f, 6.91015273e-02f, 3.27162519e-02f, -9.28829610e-02f, 1.34255467e-02f,
  -7.84463212e-02f, -6.72472687e-03f, -2.31524259e-02f, -3.53289060e-02f, -1.39029801e-01f, -9.49040800e-02f, -1.29477546e-01f, 1.52686715e-01f, 8.97308588e-02f, -1.40151277e-01f,
  4.55317609e-02f, -3.05151530e-02f, 6.69641048e-02f, 2.82242661e-03f, 1.05769448e-01f, 7.37559563e-03f, 1.61151662e-02f, -3.00203986e-03f, 1.11340322e-01f, 9.71485972e-02f,
  5.82506433e-02f, 7.62525499e-02f, -1.68350875e-01f, 3.82761620e-02f, 7.07211792e-02f, -1.00071989e-01f, -6.43960014e-02f, 1.72144081e-02f, 9.82456133e-02f, -4.37594159e-03f,
  -6.39007092e-02f, 6.04402162e-02f, 4.87513803e-02f, -6.46878481e-02f, -8.90697986e-02f, -1.26673967e-01f, -9.78641063e-02f, -1.94919229e-01f, -4.20500338e-01f, -1.91785663e-01f,
  -2.11016014e-01f, -9.63729471e-02f, -2.15158880e-01f, -2.15206742e-01f, -1.75539434e-01f, -5.62552251e-02f, -6.98462650e-02f, -1.06978148e-01f, -1.35955319e-01f, -1.14751443e-01f,
  2.60984134e-02f, -2.68684700e-02f, 2.51665879e-02f, 1.63155124e-01f, -7.07523748e-02f, -1.64599493e-01f, -4.04984541e-02f, -1.28927246e-01f, -5.57452366e-02f, -8.33361447e-02f,
  -6.33608699e-02f, -8.64370912e-02f, -2.12432906e-01f, -1.44549003e-02f, -1.55734643e-02f, -9.95516926e-02f, 4.55546826e-02f, 2.54451692e-01f, 1.38181625e-02f, -5.28360270e-02f,
  1.63283460e-02f, 1.88759640e-01f, 7.44072646e-02f, 1.89628839e-01f, 1.91710204e-01f, 8.18774551e-02f, 4.65736315e-02f, 6.31323457e-02f, -1.26525247e-02f, 1.56571910e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.35768032e-01f, 3.28160256e-01f, 5.32403588e-01f, 8.12963903e-01f, 5.38878560e-01f, 5.36111653e-01f, 2.19299510e-01f, 1.23355813e-01f, -1.26749232e-01f, 3.66950184e-01f,
  7.65821636e-01f, 6.93902135e-01f, 3.42705876e-01f, 4.81528729e-01f, -6.50166497e-02f, 2.92426020e-01f, 5.55335164e-01f, 5.61213553e-01f, 3.12012970e-01f, 7.88608015e-01f,
  2.40089744e-01f, 2.12991387e-01f, 3.43929201e-01f, 2.93733835e-01f, 5.90265930e-01f, 5.48815370e-01f, 1.19335040e-01f, 5.58304906e-01f, 6.85820639e-01f, 3.11109364e-01f,
  4.94768053e-01f, 4.86060023e-01f, 3.50877881e-01f, 5.61075985e-01f, 7.16955781e-01f, 3.96820158e-01f, 4.87850815e-01f, 6.80495739e-01f, 4.52063084e-01f, 4.26103830e-01f,
  3.76388133e-01f, 2.04487190e-01f, 4.81831908e-01f, 3.79251838e-01f, 3.44921261e-01f, 4.62689668e-01f, 2.75276303e-01f, 4.40482527e-01f, 8.56378794e-01f, 6.52623594e-01f,
  8.20287406e-01f, 1.91441104e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.96800882e-01f, -5.01366518e-02f, -4.33291495e-02f, -6.69194087e-02f, -2.78684050e-01f, -1.87312692e-01f, 6.49732426e-02f, -1.44854650e-01f, 1.04358774e-02f, -1.44573390e-01f,
  1.44555330e-01f, -3.67320865e-01f, -3.84360254e-01f, 3.08856755e-01f, 6.15913033e-01f, -2.93097883e-01f, -9.97499898e-02f, -4.83486950e-01f, -4.01111469e-02f, 3.71540546e-01f,
  2.75982618e-01f, 1.82922501e-02f, -4.85322811e-02f, 1.79488629e-01f, 2.08712563e-01f, -8.46750617e-01f, 4.89036828e-01f, -8.86727348e-02f, -2.02941284e-01f, -3.57481420e-01f,
  1.58715528e-02f, -3.79888803e-01f, -2.48024002e-01f, 7.35227346e-01f, -8.80795866e-02f, 8.44225809e-02f, -9.74627972e-01f, -5.02218604e-01f, 1.91884190e-01f, -4.32792842e-01f,
  -8.44049677e-02f, -8.25663209e-02f, 1.06849983e-01f, -3.81536752e-01f, 3.13521057e-01f, 1.69259623e-01f, -6.82329386e-02f, -2.44728345e-02f, 1.01862893e-01f, -1.94760486e-01f,
  -4.28666085e-01f, -3.67711008e-01f, 2.69351937e-02f, 3.08755726e-01f, 2.11151466e-01f, -5.53821146e-01f, -5.50637245e-02f, -4.21901822e-01f, -4.68915462e-01f, -5.64306155e-02f,
  -6.87626004e-01f, -4.10018325e-01f, 2.86506772e-01f, -2.88937628e-01f, -9.90949422e-02f, -5.08760251e-02f, 5.96066713e-02f, 8.35830346e-02f, 2.36275159e-02f, -3.16326246e-02f,
  1.36489525e-01f, -6.04295619e-02f, -2.36582935e-01f, -1.77960381e-01f, 3.64781260e-01f, 4.23247844e-01f, -5.19063115e-01f, -7.62039572e-02f, -9.37170088e-01f, -3.72769624e-01f,
  -5.36812209e-02f, -5.78846991e-01f, 3.50158989e-01f, -6.71694815e-01f, -2.66650897e-02f, -4.62661497e-02f, -7.67236412e-01f, 5.10594010e-01f, 1.17627107e-01f, -4.23228860e-01f,
  -3.46916020e-01f, -6.77748561e-01f, -1.88387156e-01f, 3.36133391e-01f, -1.77040458e-01f, -1.75318122e-01f, 8.54548998e-03f, -4.72303569e-01f, 2.95406371e-01f, 4.66998488e-01f,
  -5.90830266e-01f, -6.39729559e-01f, -9.67695843e-03f, 2.17692524e-01f, 2.90363848e-01f, 2.60348320e-01f, 3.83672506e-01f, -5.86712420e-01f, 3.35894883e-01f, -7.60558341e-03f,
  -1.12724352e+00f, 2.94553004e-02f, 9.74559605e-01f, 2.76677758e-01f, -3.89895380e-01f, -1.95565253e-01f, -4.93134528e-01f, 3.86205047e-01f, -4.20313329e-02f, -7.31478989e-01f,
  -1.57884583e-01f, -5.74591160e-01f, -8.96078348e-02f, 2.19289929e-01f, -1.28279436e+00f, 1.95301473e-01f, 5.20730317e-01f, 5.60381152e-02f, 5.50584272e-02f, 1.08380973e-01f,
  -6.77954182e-02f, -9.32084918e-02f, -3.08824833e-02f, 1.07583679e-01f, -1.77390635e-01f, 1.57687947e-01f, -3.60280216e-01f, 3.68756950e-01f, -3.12190592e-01f, -1.48821743e-02f,
  6.87288418e-02f, -6.78621292e-01f, 1.17019556e-01f, -5.35372078e-01f, 5.92249751e-01f, -2.30084389e-01f, -5.06663918e-01f, -1.75197110e-01f, -1.88874975e-01f, 4.77517933e-01f,
  4.54298675e-01f, -4.48800951e-01f, -2.10895047e-01f, -4.40733582e-01f, -3.23757797e-01f, -1.22270174e-01f, -6.67017996e-02f, -6.27158880e-01f, 4.18802232e-01f, -1.05870083e-01f,
  -5.08560002e-01f, 6.59041777e-02f, -1.02369897e-01f, -5.17533302e-01f, 4.49277461e-01f, -5.02213120e-01f, 2.18045354e-01f, 2.97119290e-01f, 4.73894924e-01f, -2.02913299e-01f,
  1.90740362e-01f, 4.37406868e-01f, -2.72636443e-01f, -2.45869219e-01f, -2.90277928e-01f, 2.16054171e-02f, 6.87952816e-01f, 4.76040900e-01f, -4.82956201e-01f, -1.08649433e-01f,
  -4.63844031e-01f, 5.00158072e-01f, -3.68138462e-01f, 2.79998362e-01f, -1.99878529e-01f, -5.29505670e-01f, -3.06699514e-01f, -2.82943219e-01f, -6.24116421e-01f, 1.07571967e-01f,
  5.73432922e-01f, -5.76820612e-01f, 1.11776866e-01f, -2.24528089e-01f, 8.13323481e-04f, -1.33773953e-01f, -1.07705131e-01f, 1.11035094e-01f, -9.17794108e-02f, 1.01590797e-01f,
  1.19336218e-01f, 1.84769616e-01f, 2.46394053e-01f, 5.07562943e-02f, 6.04514122e-01f, 6.67589426e-01f, -5.28659225e-01f, -4.52818632e-01f, -3.34698170e-01f, 5.16416609e-01f,
  -3.14489871e-01f, 3.38202268e-01f, -1.98267639e-01f, 2.75122561e-02f, 6.96025431e-01f, -2.06013009e-01f, 3.95281672e-01f, 4.49160248e-01f, 2.52097696e-01f, -4.35829580e-01f,
  -3.98397535e-01f, -6.56506181e-01f, 4.34296161e-01f, -4.58425879e-01f, -1.23520859e-01f, 8.67514908e-02f, 1.10019118e-01f, -3.77877086e-01f, 5.01811691e-02f, -5.29370129e-01f,
  -4.76868004e-01f, -7.58285150e-02f, -2.63074726e-01f, -1.98744431e-01f, -5.33932745e-01f, 3.40202093e-01f, -4.81462181e-01f, 4.79209684e-02f, 5.37704647e-01f, 4.01058197e-01f,
  3.42877656e-02f, -3.66443098e-01f, -7.22306073e-01f, -6.21700823e-01f, -4.62432712e-01f, 1.29180476e-01f, -1.90236062e-01f, 8.25373530e-02f, -4.59389091e-01f, 4.26100731e-01f,
  -2.82151222e-01f, -8.40041399e-01f, 5.26852086e-02f, -2.53826261e-01f, -7.50938416e-01f, -2.61666507e-01f, -1.55377433e-01f, -3.42935324e-01f, -4.42016907e-02f, -1.80818096e-01f,
  -5.30548431e-02f, 6.83881566e-02f, 2.52711833e-01f, 4.18976247e-01f, -2.23292664e-01f, -2.98115820e-01f, -2.67357141e-01f, -1.03012808e-01f, -3.11490506e-01f, -8.09624434e-01f,
  -2.11297989e-01f, -1.76006094e-01f, -5.91595888e-01f, 2.13432953e-01f, -2.40205556e-01f, -3.64292935e-02f, 3.46916258e-01f, 4.11932319e-01f, -6.45309329e-01f, -3.13749790e-01f,
  -3.34986389e-01f, 2.94978082e-01f, -1.25148654e-01f, 4.48164463e-01f, -1.19646266e-01f, -4.79795694e-01f, -1.23762764e-01f, -4.53874081e-01f, 1.09138086e-01f, -5.51803648e-01f,
  8.63776430e-02f, 1.43796755e-02f, 4.12781358e-01f, 4.17258799e-01f, 8.25481862e-02f, -1.75847739e-01f, -6.37914300e-01f, -9.26103070e-02f, -2.56411910e-01f, -1.84750989e-01f,
  -1.40811592e-01f, -4.05114368e-02f, 1.85242742e-01f, 3.66833359e-01f, -3.62824678e-01f, -3.59055370e-01f, 1.52576998e-01f, -5.17503992e-02f, 3.99191380e-01f, 2.51736671e-01f,
  3.45807433e-01f, 6.07721686e-01f, 2.70429216e-02f, 3.19161981e-01f, -2.42053002e-01f, 1.50050938e-01f, -1.80572703e-01f, -2.38874525e-01f, -1.09330320e+00f, 1.59012035e-01f,
  -5.34883998e-02f, 1.04136191e-01f, 2.26966292e-01f, 1.53509602e-01f, 2.83446640e-01f, 3.11249554e-01f, 3.09393317e-01f, 2.02917621e-01f, -3.14395756e-01f, 3.11702460e-01f,
  5.24219237e-02f, -2.25404054e-01f, -5.75906396e-01f, 1.46265939e-01f, 1.82877406e-01f, 1.74614981e-01f, -1.61858976e-01f, -6.03235722e-01f, -8.50753337e-02f, -3.80707055e-01f,
  -3.79761189e-01f, -6.72303975e-01f, 5.95625630e-03f, 7.47897178e-02f, -1.38277307e-01f, -9.75586921e-02f, -8.39086235e-01f, 2.74625331e-01f, -5.05492389e-01f, 4.77809191e-01f,
  -6.90211713e-01f, 1.63804248e-01f, -9.58894342e-02f, 4.43651497e-01f, -1.38171405e-01f, 3.95298809e-01f, -2.90138900e-01f, 5.60367584e-01f, -6.54578134e-02f, -4.68656212e-01f,
  -1.14296779e-01f, -2.81669814e-02f, -2.95623928e-01f, -8.05107772e-01f, 4.16454405e-01f, 6.99159563e-01f, 8.89054537e-02f, -2.84825772e-01f, -7.84140229e-01f, -1.51460364e-01f,
  -6.26913428e-01f, -9.65957046e-02f, -2.36916304e-01f, -5.99201262e-01f, 3.46264243e-01f, -1.72450423e-01f, 4.52129602e-01f, -2.97978520e-01f, -4.29172009e-01f, 5.17314613e-01f,
  1.00552273e+00f, 8.33514929e-02f, -2.18671069e-01f, 1.50109306e-01f, 4.33969088e-02f, 3.26045975e-02f, 1.62135239e-03f, -3.57898138e-02f, 1.64892152e-01f, -7.51479939e-02f,
  -9.98774916e-02f, -3.31361353e-01f, 9.70531069e-03f, 3.50105464e-01f, -7.30421320e-02f, 2.01810285e-01f, -6.42997384e-01f, -1.86559871e-01f, 5.24688780e-01f, 6.36492848e-01f,
  3.33062768e-01f, -2.79459059e-01f, 2.92426139e-01f, -5.98012805e-01f, -5.16599834e-01f, -3.63244355e-01f, -8.93178523e-01f, -4.63850379e-01f, -6.91784322e-01f, -4.46464747e-01f,
  -6.34848177e-01f, -6.92609191e-01f, -2.30125725e-01f, -6.82613552e-01f, -7.42221177e-01f, -5.34243584e-02f, -5.38195312e-01f, -3.34223628e-01f, -3.15340787e-01f, -2.89572328e-01f,
  6.75891936e-01f, 2.38921583e-01f, 6.21407814e-02f, -3.76882702e-01f, 1.02837846e-01f, 3.07560980e-01f, -7.51730725e-02f, -3.75518531e-01f, -6.22494757e-01f, -4.67054397e-01f,
  -3.53762209e-01f, -2.03659475e-01f, -5.85836649e-01f, -1.45668954e-01f, 6.33563757e-01f, -2.82392204e-01f, -9.75361764e-01f, -5.10065973e-01f, -3.42745692e-01f, 4.07559484e-01f,
  2.34155193e-01f, -6.36210561e-01f, 5.14802158e-01f, -5.57408512e-01f, -2.90014088e-01f, -3.97501513e-02f, 2.07573950e-01f, -8.68290216e-02f, -1.10666260e-01f, -1.14398766e-02f,
  -2.05786109e-01f, 6.76114038e-02f, 4.12270427e-02f, -5.18316984e-01f, -2.11520314e-01f, -1.93757266e-01f, 3.95131201e-01f, 1.44308284e-01f, -5.62346205e-02f, -3.18588674e-01f,
  5.86734489e-02f, -4.03243542e-01f, -6.53534412e-01f, -2.21934631e-01f, 1.20403051e-01f, 1.34902552e-01f, 8.20277780e-02f, 3.23949397e-01f, -1.08357407e-01f, -1.72224641e-01f,
  3.75696063e-01f, -8.11875224e-01f, -3.12997431e-01f, 5.78424871e-01f, -1.48607075e-01f, 5.17788351e-01f, -4.45408700e-03f, -2.70175457e-01f, 4.92027760e-01f, -6.57372415e-01f,
  4.41921502e-01f, 4.36812103e-01f, -4.71171975e-01f, -2.17411041e-01f, -6.55567467e-01f, -2.35095412e-01f, -2.33947691e-02f, 3.88847440e-01f, -6.77889645e-01f, 1.11076191e-01f,
  -4.00633305e-01f, 3.04189414e-01f, -1.97846532e-01f, -4.99123931e-01f, 9.22724158e-02f, -3.29588145e-01f, -5.19507349e-01f, -1.11724652e-01f, 1.19247148e-02f, 9.09816008e-04f,
  -3.24461579e-01f, -2.33343154e-01f, -4.09573197e-01f, -2.59440899e-01f, 3.67330015e-02f, -3.10711771e-01f, -1.61060676e-01f, -7.55690485e-02f, 6.96339607e-01f, -3.39493215e-01f,
  -6.94347799e-01f, 1.58293664e-01f, 1.49424359e-01f, 1.98106095e-01f, -1.46050930e-01f, 3.24530266e-02f, -1.85060054e-02f, 1.56405762e-01f, -7.64768422e-02f, -1.39466941e-01f,
  1.91924527e-01f, -3.67797077e-01f, 2.56202787e-01f, 2.78274179e-01f, 2.43645519e-01f, 4.20292243e-02f, -1.37965024e-01f, 5.85756719e-01f, 2.00048372e-01f, -4.59506959e-01f,
  -2.29846045e-01f, -2.21907273e-01f, -3.06105465e-01f, -6.14033878e-01f, 5.85594237e-01f, -5.31604290e-01f, 1.58108681e-01f, -3.72922331e-01f, -3.80408466e-01f, -3.79269183e-01f,
  6.14140749e-01f, -2.52676666e-01f, -2.84104019e-01f, 5.19977808e-01f, -1.33670673e-01f, -2.82682866e-01f, 9.78887156e-02f, -5.38453758e-02f, -4.17643517e-01f, -4.31829035e-01f,
  -4.02325064e-01f, 2.40668982e-01f, 6.01752222e-01f, -5.47950029e-01f, 3.25793028e-01f, 1.65855408e-01f, -4.17708606e-01f, -6.65338099e-01f, -2.96024442e-01f, -6.98268712e-01f,
  -6.01440787e-01f, -2.74859995e-01f, -3.54977399e-01f, -3.41331847e-02f, -1.71510190e-01f, -2.35409170e-01f, -4.27070230e-01f, -3.85180622e-01f, -1.04446955e-01f, -5.00809848e-01f,
  -1.28228500e-01f, -2.69616932e-01f, 9.23890412e-01f, 4.27954793e-01f, -2.77159363e-01f, 2.06964407e-02f, -2.33634114e-01f, 1.78314224e-01f, -1.75757974e-01f, 3.20402719e-02f,
  -1.89047381e-01f, -2.04442188e-01f, -9.32641178e-02f, 1.57822132e-01f, -1.70884833e-01f, -4.11680967e-01f, -3.22147220e-01f, -3.61990243e-01f, 1.22764215e-01f, -3.22882742e-01f,
  2.19254971e-01f, -7.10679471e-01f, -1.05998240e-01f, -1.89403385e-01f, 1.47540957e-01f, -2.60763437e-01f, 4.47795153e-01f, -7.97209382e-01f, -4.12532300e-01f, -6.86851740e-01f,
  -4.02234882e-01f, 9.48650390e-03f, 1.82000607e-01f, 4.93564099e-01f, 2.84608126e-01f, 4.04419422e-01f, 1.53837368e-01f, -4.66827333e-01f, -2.31211707e-01f, -3.11184853e-01f,
  5.51923774e-02f, -3.31958234e-01f, -1.12764888e-01f, 4.67840463e-01f, 9.88348499e-02f, -3.41628373e-01f, -3.58361840e-01f, -1.76721931e-01f, -1.96643904e-01f, 6.08516991e-01f,
  2.86638886e-01f, -2.69026458e-01f, -8.31315756e-01f, -7.10311294e-01f, 1.24290779e-01f, -5.70873797e-01f, 2.86140800e-01f, 2.89991409e-01f, 1.00400746e+00f, -6.44316971e-01f,
  -1.40412077e-02f, 2.09422380e-01f, 1.28034726e-01f, 4.75924075e-01f, 5.69368042e-02f, 1.18792169e-01f, -5.69318891e-01f, 9.53872949e-02f, 4.21316981e-01f, -3.19367617e-01f,
  -2.65984535e-02f, 1.05426185e-01f, 7.08792284e-02f, 9.20804068e-02f, -3.29681598e-02f, 1.89477712e-01f, 5.05577512e-02f, 2.56194383e-01f, 3.86921227e-01f, 3.17415744e-01f,
  -3.53757411e-01f, 2.85665780e-01f, 5.44671774e-01f, 3.84490967e-01f, -3.70481223e-01f, -3.46414566e-01f, -1.48398444e-01f, -3.23634595e-01f, -2.44653627e-01f, -3.19201052e-01f,
  -3.73868197e-01f, 2.70786643e-01f, -4.12829220e-01f, 4.07249719e-01f, -4.76747483e-01f, 4.31037009e-01f, -5.91943800e-01f, -5.11963904e-01f, 3.21675509e-01f, -3.56194466e-01f,
  -3.05495083e-01f, -4.00892317e-01f, 8.42062160e-02f, -3.93299997e-01f, -2.58491844e-01f, 8.58341902e-02f, -4.10067886e-01f, -6.14840865e-01f, -5.52857280e-01f, -2.88539201e-01f,
  -4.59149301e-01f, -1.24055669e-01f, -5.51353991e-01f, -2.45015845e-01f, -2.85566598e-01f, -6.43828809e-02f, -5.16681552e-01f, 4.24888015e-01f, -4.81322348e-01f, 7.70434618e-01f,
  -1.77174717e-01f, 5.34388661e-01f, 4.54482049e-01f, -5.46950877e-01f, -5.66215217e-01f, -1.52728274e-01f, 1.02687836e-01f, -3.71137857e-02f, -2.60601372e-01f, -4.53142107e-01f,
  2.90436000e-01f, -7.13628158e-02f, -4.75666612e-01f, -2.58594394e-01f, 1.28064483e-01f, 3.16825025e-02f, 4.91716787e-02f, -8.03957060e-02f, 5.13751693e-02f, 7.37209320e-02f,
  -4.30834554e-02f, 3.24890971e-01f, 7.46812392e-03f, -3.34362566e-01f, 3.12542081e-01f, 3.94929469e-01f, -3.30079585e-01f, 6.60679191e-02f, -7.74249792e-01f, 6.35972440e-01f,
  -6.50022447e-01f, 7.98862755e-01f, -2.47688144e-02f, -1.27687603e-01f, -2.92230278e-01f, -4.30466011e-02f, 1.68140575e-01f, -4.91646439e-01f, 2.17045844e-01f, -7.69034475e-02f,
  -5.21264225e-03f, -2.98647553e-01f, -6.57959223e-01f, 4.91800696e-01f, -4.68185812e-01f, 5.65326214e-01f, 6.03634156e-02f, -2.70510197e-01f, 1.63217708e-01f, -2.79346466e-01f,
  -4.22909521e-02f, 1.40900701e-01f, -5.28662140e-03f, -5.79823852e-01f, -5.06070435e-01f, 2.04382613e-01f, -3.44729930e-01f, 1.13782808e-01f, -3.09159368e-01f, -4.13395852e-01f,
  6.54591918e-01f, -1.72087699e-01f, -2.17070520e-01f, -3.06957126e-01f, 3.42380524e-01f, -4.77511764e-01f, -5.58298647e-01f, -2.89634645e-01f, -1.68511257e-01f, -5.31497657e-01f,
  -4.08320278e-01f, 6.17468238e-01f, 4.42242712e-01f, -3.68982464e-01f, -5.42018414e-01f, -6.94301799e-02f, -2.59498030e-01f, -2.35965163e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.99167663e-01f, -2.01912522e-02f, 1.36345208e-01f, -1.60151020e-01f, -2.08967552e-02f, 1.29908845e-01f, 9.02487710e-02f, -9.44762751e-02f, 1.78197131e-01f, 1.73139468e-01f,
  3.08058858e-02f, -1.49974292e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    