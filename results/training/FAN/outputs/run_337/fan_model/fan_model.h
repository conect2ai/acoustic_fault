/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.03941388e-01f, 1.98533177e-01f, 2.50663310e-02f, -1.50906190e-01f, -2.20968843e-01f, -1.26602232e-01f, -7.09558800e-02f, 3.01447455e-02f, -4.52075750e-02f, 2.21805513e-01f,
  -6.30696490e-02f, 8.92876685e-02f, 1.17544435e-01f, -8.89472589e-02f, -1.40579224e-01f, 1.15446426e-01f, -2.70859487e-02f, 8.42857063e-02f, -1.37275057e-02f, -6.59464672e-02f,
  -7.71420673e-02f, -1.49730295e-01f, 1.24764726e-01f, -4.98178154e-02f, -8.34216401e-02f, 9.17857289e-02f, 7.55639002e-03f, -4.90278266e-02f, 1.04512170e-01f, 2.41891341e-03f,
  5.72637171e-02f, -1.93130504e-02f, -6.21390678e-02f, 2.84556821e-02f, -1.82439538e-03f, 4.65106890e-02f, 8.21008459e-02f, -1.04927339e-01f, -6.98413774e-02f, -5.09370156e-02f,
  8.10266705e-04f, -1.67455748e-02f, 3.74255069e-02f, -5.49785700e-03f, 1.49170868e-02f, 1.91596914e-02f, 5.96878454e-02f, -2.42319033e-02f, 1.71975009e-02f, -2.91051660e-02f,
  2.35181320e-02f, 1.96695067e-02f, -4.36334312e-02f, 8.64559188e-02f, -1.27720796e-02f, -5.49096102e-03f, 1.02077514e-01f, -4.20450717e-02f, 7.45269656e-03f, -2.64541842e-02f,
  -4.98404820e-03f, -7.80840591e-02f, 3.15708704e-02f, 4.86080460e-02f, -7.48091191e-02f, -1.45838745e-02f, -2.93457834e-03f, 1.34995785e-02f, -5.34048378e-02f, 9.31639131e-03f,
  2.78225299e-02f, 4.82776538e-02f, 3.18058990e-02f, 1.48418860e-03f, -3.70514393e-02f, 3.82597856e-02f, 7.68045802e-03f, 7.60983899e-02f, 1.46641890e-02f, 7.25500286e-02f,
  3.35351005e-02f, 2.10842863e-02f, -1.55769512e-02f, 9.39325467e-02f, -5.68745844e-02f, -1.85949486e-02f, 1.28048407e-02f, 9.71135125e-02f, 6.37313724e-02f, -7.94799253e-02f,
  -1.93841793e-02f, 3.86315361e-02f, 2.49883067e-02f, 5.93292788e-02f, 6.94007352e-02f, 3.23524401e-02f, -5.74231781e-02f, -7.20636128e-03f, -4.92702276e-02f, 2.66813468e-02f,
  1.54860141e-02f, 3.52501087e-02f, -7.44336843e-02f, -7.69521222e-02f, -4.78922352e-02f, -6.01719208e-02f, 2.36466583e-02f, -2.76221782e-02f, -1.39744412e-02f, -3.38921733e-02f,
  5.62291183e-02f, -5.74984960e-02f, 1.32616470e-03f, -3.96786854e-02f, 2.23076586e-02f, -5.27102314e-02f, -7.08677918e-02f, -7.59413978e-03f, -3.79869365e-03f, 5.95029518e-02f,
  2.70951033e-01f, -2.48943284e-01f, -2.10597411e-01f, 2.25723565e-01f, 1.35328650e-01f, 2.15787470e-01f, 1.06651165e-01f, 3.48468721e-02f, -2.09589489e-02f, 2.04212926e-02f,
  1.45771265e-01f, -1.70411512e-01f, -3.24272394e-01f, 1.05112813e-01f, 1.70055106e-02f, -1.95275337e-01f, 1.56759933e-01f, 7.85620660e-02f, -7.41762668e-02f, 6.20838813e-02f,
  1.17042914e-01f, 1.49934649e-01f, -2.05895349e-01f, 5.24660349e-02f, 1.37021706e-01f, 7.28973001e-03f, -1.02940388e-02f, -1.62697554e-01f, 1.14714555e-01f, 1.58276893e-02f,
  3.11928615e-02f, -4.16317247e-02f, -3.07947546e-02f, -7.66428560e-02f, 5.16029671e-02f, 6.49980828e-02f, -1.02947764e-02f, -6.24704212e-02f, -4.97641452e-02f, 3.95407528e-02f,
  -8.12407397e-03f, -5.53450324e-02f, 2.73056459e-02f, -1.00529701e-01f, 9.08268318e-02f, -3.12330388e-02f, 9.48347989e-03f, 2.66311597e-02f, -6.95528835e-02f, -4.39331830e-02f,
  -1.86018050e-02f, -2.95425989e-02f, 9.63511169e-02f, -1.35301137e-02f, 6.42220816e-03f, 2.01081652e-02f, 2.07131319e-02f, 1.44145172e-02f, 6.84362724e-02f, 5.98239116e-02f,
  1.01880759e-01f, -7.95731600e-03f, -5.30991443e-02f, -5.95535487e-02f, -1.30918222e-02f, -1.43781502e-03f, 7.43799610e-05f, 7.98917469e-03f, -3.34852301e-02f, 5.40543348e-02f,
  -4.53147776e-02f, 1.88502781e-02f, 7.27649331e-02f, -9.24856402e-03f, 9.85669643e-02f, 2.12749485e-02f, -6.93216035e-03f, 2.73470040e-02f, 8.82273093e-02f, 6.64896506e-04f,
  -6.26718625e-02f, -6.20491430e-03f, -4.55664285e-02f, 1.67706348e-02f, 3.58504020e-02f, -4.13882639e-03f, 3.97563959e-03f, -2.17881538e-02f, -3.03103700e-02f, 6.36925697e-02f,
  1.09011434e-01f, -6.87922388e-02f, -1.00606773e-02f, -7.69047008e-04f, -6.84728101e-02f, 2.83059385e-02f, 2.05632523e-02f, 5.19224070e-02f, -3.00497022e-02f, -8.08561500e-03f,
  5.32891825e-02f, 8.95355791e-02f, 2.66303588e-02f, 1.97032038e-02f, -2.30104905e-02f, 8.63647833e-03f, 5.53027401e-03f, 5.44236391e-04f, 4.91045676e-02f, 4.65317778e-02f,
  -1.40803345e-02f, 5.45609631e-02f, 3.17037441e-02f, 1.03158154e-01f, 3.45863439e-02f, 3.59858125e-02f, -1.95240066e-03f, -5.03816009e-02f, -3.15699577e-02f, -6.42780885e-02f,
  5.74110262e-02f, -4.81938235e-02f, 1.80483982e-01f, 4.38652970e-02f, -4.25746217e-02f, 3.18017662e-01f, 3.62077445e-01f, 1.08815380e-03f, -1.76250115e-01f, -8.33470561e-03f,
  2.94634476e-02f, -9.55002904e-02f, 3.08228135e-02f, 2.61188477e-01f, 4.11061823e-01f, 1.78791210e-01f, 2.99464315e-01f, 1.16024621e-01f, -1.38510495e-01f, -2.72277165e-02f,
  3.00991628e-02f, 9.35333148e-02f, 1.76885128e-01f, -1.86181977e-01f, 3.89018655e-02f, -9.85791311e-02f, -5.17467558e-02f, -3.84548940e-02f, 6.47201240e-02f, 4.06730920e-02f,
  2.20458269e-01f, -1.45912409e-01f, -1.29355043e-02f, -2.83210352e-02f, 2.62979027e-02f, 6.57474622e-02f, 9.11807790e-02f, 8.32271427e-02f, -4.22494002e-02f, -2.54154336e-02f,
  -2.00049113e-02f, -3.47467288e-02f, -2.18276102e-02f, -5.67485653e-02f, -2.23524049e-02f, 1.24865817e-02f, 2.81603988e-02f, 7.20705017e-02f, -2.37653982e-02f, -3.19203213e-02f,
  3.34220636e-03f, 5.16920388e-02f, -3.33122537e-02f, -2.54933219e-02f, 5.99030890e-02f, -1.14467144e-02f, 8.66409317e-02f, 4.41140048e-02f, 1.59423612e-02f, -4.67411242e-02f,
  -3.55566805e-03f, 1.32150184e-02f, 3.27644162e-02f, 2.36072503e-02f, 1.16356378e-02f, -1.96274947e-02f, -5.13159856e-02f, 1.82082243e-02f, -3.64541039e-02f, -1.24037815e-02f,
  1.03777619e-02f, -5.23338048e-03f, 2.40979902e-03f, -1.11714015e-02f, 1.99978948e-02f, -9.51560587e-03f, 5.68598844e-02f, -4.19450141e-02f, -2.49179378e-02f, -6.00312790e-03f,
  1.16738779e-02f, -2.68124556e-03f, -6.18490800e-02f, 4.46311533e-02f, 3.84364789e-03f, -2.03218125e-02f, -4.14621681e-02f, -3.85433398e-02f, -5.45159774e-03f, 5.56593426e-02f,
  2.48054098e-02f, -7.93175995e-02f, -9.27318633e-02f, 2.16205120e-02f, 3.12833190e-02f, -2.47627031e-02f, 4.17755209e-02f, -7.11532757e-02f, -1.53380465e-02f, -2.34737825e-02f,
  -7.71128759e-03f, -2.47890898e-03f, 1.23722702e-02f, -8.41392204e-03f, -2.09069550e-02f, 6.40860002e-04f, 4.68625166e-02f, -5.53900562e-03f, 2.22875708e-04f, 1.67962629e-02f,
  -1.84803903e-02f, -4.24104463e-03f, -3.74681526e-03f, 1.97269022e-02f, 5.53442538e-03f, -1.41716879e-02f, -4.52152528e-02f, -3.08161462e-03f, -1.73705779e-02f, 1.35241793e-02f,
  3.16725492e-01f, -2.15684194e-02f, 1.64018884e-01f, 1.80585459e-01f, 7.10271904e-03f, 1.88414693e-01f, 1.38433248e-01f, 4.48843725e-02f, 6.08737953e-02f, -2.17186525e-01f,
  4.61831093e-02f, 1.74436793e-02f, 1.10736452e-01f, -4.41951007e-02f, 1.76055714e-01f, 6.78915605e-02f, 2.67674495e-02f, -8.57281499e-03f, -1.37643295e-03f, 1.71981618e-01f,
  3.44728678e-02f, -1.95953273e-03f, 3.64529155e-02f, -8.43535364e-02f, 6.54016659e-02f, -9.40375924e-02f, -1.53337568e-01f, 6.50130510e-02f, -1.47834182e-01f, -3.82192619e-02f,
  1.09600931e-01f, 6.67199343e-02f, 1.39618013e-02f, 3.12162768e-02f, -1.94320399e-02f, 2.46312208e-02f, 3.90927009e-02f, -3.73894684e-02f, 5.71488850e-02f, -9.87930223e-04f,
  1.08315414e-02f, -1.51355779e-02f, -6.67953119e-02f, -4.41980036e-03f, 7.37828761e-02f, -5.99939600e-02f, -6.11581095e-02f, -5.41444607e-02f, 6.15658127e-02f, 6.67974949e-02f,
  7.57251829e-02f, 3.12290899e-02f, -6.26192018e-02f, -5.68619110e-02f, -8.42367485e-03f, -3.80024835e-02f, -3.22219655e-02f, 5.16803786e-02f, 2.18492821e-02f, 3.96023579e-02f,
  -5.31768315e-02f, 1.50028979e-02f, 4.72457558e-02f, 2.23268382e-02f, 4.65039955e-03f, 2.18913052e-02f, 6.47753254e-02f, -6.57793880e-02f, -6.88582063e-02f, 3.79867628e-02f,
  2.90479865e-02f, -1.46369580e-02f, 5.56371845e-02f, -1.63636040e-02f, -3.00130267e-02f, 1.09808771e-02f, 2.42974497e-02f, 7.20169395e-03f, -5.09475321e-02f, -1.72860851e-03f,
  6.97907284e-02f, 1.03650950e-01f, -2.94519048e-02f, -6.79307356e-02f, -3.83788906e-02f, 6.02320619e-02f, -2.92649101e-02f, 1.70941465e-02f, -5.27132116e-02f, 6.73162714e-02f,
  1.59999818e-01f, 6.69552758e-02f, 3.47128138e-02f, -3.95649932e-02f, -1.14214949e-01f, -1.01305820e-01f, -4.76323441e-02f, 5.47373556e-02f, 6.86762929e-02f, 2.74366420e-02f,
  5.51402979e-02f, 1.92108415e-02f, 2.18684282e-02f, 3.56076844e-02f, 2.61670724e-02f, 7.51725212e-03f, 3.41549632e-04f, -5.81895560e-02f, -7.22181937e-03f, -8.03992897e-02f,
  2.68845204e-02f, -4.53110375e-02f, 1.38914101e-02f, 4.05216366e-02f, -1.12292066e-01f, 1.84621979e-02f, -4.96616475e-02f, -3.24547999e-02f, -1.43316472e-02f, 5.58810346e-02f,
  2.83815265e-01f, 4.25487459e-02f, -7.49725699e-02f, 1.01109833e-01f, 1.10923670e-01f, -8.89209136e-02f, 2.08627023e-02f, 4.18009795e-02f, 1.86276153e-01f, -5.72058780e-04f,
  -6.33585677e-02f, 1.04310334e-01f, -1.79034755e-01f, 6.38824776e-02f, 9.62890014e-02f, -2.06337199e-01f, 4.13585566e-02f, 7.17294738e-02f, 3.79164815e-02f, 1.51253998e-01f,
  7.95053169e-02f, 1.35721758e-01f, -1.20052226e-01f, 6.72220811e-02f, 1.99954703e-01f, 4.90086228e-02f, 1.13032140e-01f, -1.45075247e-01f, 1.28510192e-01f, 1.35804787e-02f,
  1.43546835e-01f, 1.34223983e-01f, -4.72716913e-02f, -6.14230074e-02f, -2.89036967e-02f, 2.52128877e-02f, 2.27513704e-02f, -9.04320627e-02f, -6.08339794e-02f, 6.89651817e-03f,
  1.20285675e-02f, 1.14537859e-02f, 3.42643037e-02f, -7.80741721e-02f, 5.86291291e-02f, 2.96634668e-03f, 1.30916573e-02f, -3.80173586e-02f, -3.05366218e-02f, -4.32541557e-02f,
  -1.82057358e-02f, -7.30159134e-03f, -7.34948507e-03f, -3.69926095e-02f, -6.65075630e-02f, 2.79686060e-02f, -5.49784452e-02f, -6.81878552e-02f, -2.51302924e-02f, 9.76269320e-02f,
  -7.57974684e-02f, 7.48182386e-02f, -8.15716013e-03f, 4.91478629e-02f, -2.65127067e-02f, 3.47937085e-02f, -8.74339640e-02f, -2.46383641e-02f, -5.33651821e-02f, 3.78006953e-03f,
  -9.30973511e-06f, -1.59189962e-02f, 5.47702871e-02f, -7.67023191e-02f, -4.94475737e-02f, 7.00740814e-02f, -4.98688733e-03f, -2.26172805e-02f, -1.02590362e-03f, 4.13502418e-02f,
  1.72547624e-03f, 7.51066953e-02f, -7.09719490e-03f, 4.02566344e-02f, 2.90498473e-02f, -6.46263883e-02f, -4.36382927e-02f, -2.73724645e-02f, -4.60035689e-02f, 6.38387650e-02f,
  1.62875146e-01f, 2.33682558e-01f, -3.24359834e-02f, 3.77871469e-02f, -2.71781348e-02f, -2.01441273e-02f, -4.90021110e-02f, 5.75704174e-03f, 3.38369422e-02f, 6.44956203e-03f,
  -4.20893840e-02f, -6.67389529e-03f, -2.14665905e-02f, 5.41918492e-03f, 2.41543557e-02f, 2.59349495e-02f, 6.25472367e-02f, 6.17098249e-02f, 5.54377548e-02f, 7.13243335e-02f,
  3.57198268e-02f, -2.11872160e-02f, 2.37619914e-02f, -1.54390838e-02f, 5.89072444e-02f, 5.15358932e-02f, 7.83557519e-02f, -5.04960939e-02f, 5.29171107e-03f, -3.90705615e-02f,
  -2.35139881e-03f, 7.88174197e-02f, 1.55973420e-01f, 2.61746585e-01f, -1.45765841e-01f, -3.30521190e-03f, 2.96115607e-01f, -1.18308827e-01f, 1.42077208e-01f, 1.69319212e-02f,
  5.45267724e-02f, 8.33786130e-02f, 5.06247655e-02f, 2.29941875e-01f, -2.75818944e-01f, -7.74304494e-02f, 1.56819988e-02f, 5.26679270e-02f, 1.08670015e-02f, -3.28216376e-03f,
  -3.31838273e-05f, -4.55796421e-02f, 1.49986455e-02f, -8.79831687e-02f, 1.53702617e-01f, 4.95241843e-02f, -1.24995835e-01f, 2.59655453e-02f, -1.20153405e-01f, -4.38818187e-02f,
  1.09143756e-01f, 1.03920229e-01f, 1.17442429e-01f, -1.53216599e-02f, -2.65971255e-02f, -5.99968210e-02f, -1.98720172e-02f, 2.02295911e-02f, 1.10232897e-01f, 3.84373814e-02f,
  4.61030100e-03f, -3.93307172e-02f, -2.70308219e-02f, -5.00094965e-02f, 1.05316266e-02f, 3.97018790e-02f, 2.59097554e-02f, -1.14698103e-02f, 9.29217041e-02f, 2.16301307e-02f,
  6.38907403e-02f, -1.87596269e-02f, 2.29631867e-02f, -8.37967247e-02f, -6.55583143e-02f, 4.61520404e-02f, -7.58153871e-02f, 4.16377373e-02f, -9.64875426e-03f, -3.58342528e-02f,
  -7.50523955e-02f, 3.74660306e-02f, 7.09114000e-02f, 2.10908297e-02f, -5.94790876e-02f, 4.39959615e-02f, 1.08161783e-02f, -3.31273191e-02f, 3.25340927e-02f, -2.38130875e-02f,
  -4.79081348e-02f, 8.14061016e-02f, 3.41543704e-02f, 1.78036075e-02f, -4.27011512e-02f, 2.28336453e-02f, -2.55510565e-02f, 1.29869562e-02f, 9.07378122e-02f, -3.17819491e-02f,
  -4.84418822e-03f, -4.21278272e-03f, 1.18842889e-02f, 6.94410503e-02f, -1.72721166e-02f, 5.34912497e-02f, -8.45346972e-03f, 2.83250771e-02f, 2.34201225e-03f, -5.85993864e-02f,
  -1.32467911e-01f, -9.27110314e-02f, -3.28422077e-02f, 6.84776902e-02f, -2.59723738e-02f, -7.29129240e-02f, -7.66578922e-03f, 3.31509672e-02f, -6.70724586e-02f, -2.75520086e-02f,
  -7.22061619e-02f, 9.58501920e-02f, -7.22874478e-02f, -8.66210833e-02f, -4.88623567e-02f, -1.87882390e-02f, -4.22679521e-02f, 1.02437148e-02f, -7.17425495e-02f, -8.98652151e-02f,
  -4.62385751e-02f, -4.13347843e-05f, 4.32225168e-02f, -2.20521186e-02f, -7.65558630e-02f, -6.15113357e-04f, 3.50033455e-02f, -7.07679465e-02f, -5.22483811e-02f, -1.79680139e-02f,
  -1.47918344e-01f, 1.28172338e-01f, 1.50383756e-01f, -3.58181796e-03f, -2.59518474e-01f, 1.37504756e-01f, 2.66262919e-01f, -1.42622501e-01f, 1.15999199e-01f, 1.07658980e-02f,
  -2.10100085e-01f, 1.75121561e-01f, 1.29194245e-01f, 5.71995638e-02f, 1.66915327e-01f, 3.42994183e-01f, 2.22211611e-02f, 1.74577236e-01f, 1.01741001e-01f, -9.40933526e-02f,
  -4.90694754e-02f, -2.81935930e-01f, 4.04131748e-02f, -2.08208695e-01f, -1.26694545e-01f, -6.62870109e-02f, -3.10819417e-01f, -5.35784364e-02f, -1.15941517e-01f, -4.09954451e-02f,
  1.47380635e-01f, -5.37760109e-02f, -1.30411312e-02f, 1.37766898e-01f, 1.10874418e-02f, -7.74349459e-03f, 2.22288184e-02f, -7.71585666e-03f, 5.76746389e-02f, 3.19845565e-02f,
  7.60004222e-02f, -4.65143621e-02f, -3.62528153e-02f, 3.61778736e-02f, 6.69179112e-03f, 2.86786463e-02f, 6.01670193e-03f, 2.46455614e-02f, 9.76283848e-03f, -2.51581836e-02f,
  8.09786692e-02f, -1.32465735e-03f, -5.09110354e-02f, 7.65132857e-03f, 2.19233111e-02f, -5.82338031e-03f, -1.69548653e-02f, 5.94589971e-02f, 2.56322138e-02f, 4.28795330e-02f,
  -2.30583157e-02f, 1.56817809e-02f, 2.14095842e-02f, 4.26662490e-02f, 1.85419265e-02f, -3.31879407e-02f, 7.96475336e-02f, 3.38083208e-02f, 3.78809422e-02f, -2.90924478e-02f,
  4.41695936e-02f, -3.23401392e-02f, -5.53969257e-02f, 2.21765554e-03f, -4.37120162e-03f, 3.38762850e-02f, 8.36936831e-02f, -4.31984365e-02f, 6.30903989e-02f, -4.83956607e-03f,
  2.89161317e-02f, 3.26101743e-02f, 4.11881916e-02f, -3.58783379e-02f, 5.65642864e-02f, 1.05367778e-02f, -1.38371466e-02f, 6.37885183e-03f, -1.49167068e-02f, -1.28479209e-02f,
  5.97840436e-02f, -1.19499080e-01f, 4.24428806e-02f, -3.66533659e-02f, 5.12379110e-02f, -2.25208774e-02f, 9.05951187e-02f, -4.91228141e-03f, -9.96817485e-04f, -2.58484725e-02f,
  -7.76970983e-02f, 4.61229123e-02f, -4.98077124e-02f, -2.61761583e-02f, 6.46349341e-02f, -6.79633617e-02f, 1.48218649e-03f, -8.96722020e-04f, -7.27227330e-02f, -4.11162972e-02f,
  -1.42134726e-01f, -1.13977557e-02f, 2.48886514e-02f, 5.31963632e-02f, -4.48799618e-02f, -6.18590601e-02f, 1.25198048e-02f, -7.36602407e-04f, -5.75749353e-02f, 5.41910715e-02f,
  -2.17701361e-01f, 2.62083143e-01f, 1.19331444e-03f, -3.81869704e-01f, -1.14192134e-02f, 1.52889475e-01f, -4.30717915e-02f, 9.07984301e-02f, 3.31748724e-02f, 6.82052597e-02f,
  8.32147002e-02f, -3.31213884e-02f, 2.24577680e-01f, -1.83016717e-01f, -2.36574665e-01f, 2.13883355e-01f, -8.05605128e-02f, -8.31118152e-02f, 9.89660323e-02f, -1.23369113e-01f,
  -1.46144062e-01f, -6.05870709e-02f, -6.54035807e-02f, 1.23129420e-01f, -1.02753848e-01f, -1.32820725e-01f, -1.56369433e-01f, 1.61231965e-01f, -1.64178431e-01f, -2.50060223e-02f,
  7.84158781e-02f, 1.85181983e-02f, 8.16803193e-04f, -2.28171865e-03f, -4.03591320e-02f, 1.75842866e-02f, 1.40006812e-02f, -4.01820950e-02f, -4.05096151e-02f, 2.31667981e-02f,
  -2.65880395e-02f, 4.17749892e-04f, 4.51908680e-03f, 2.87851784e-03f, -1.96179543e-02f, -5.05166762e-02f, -4.77638096e-03f, -2.70791613e-02f, 5.49860001e-02f, -3.14891040e-02f,
  1.63628981e-02f, 4.40883450e-02f, -6.01743720e-02f, -2.74408348e-02f, -2.17079185e-02f, 8.37605298e-02f, -5.72074242e-02f, -6.12176023e-02f, -2.30469033e-02f, -1.91792957e-02f,
  7.13220462e-02f, -6.15708390e-03f, 1.20921666e-02f, 8.49220902e-03f, 2.92658564e-02f, -1.01659149e-02f, -3.71839143e-02f, -3.63980718e-02f, 4.97201234e-02f, 9.72198136e-03f,
  -1.55043034e-02f, -2.55995728e-02f, -6.27880963e-03f, -3.59360911e-02f, -3.83346081e-02f, -6.46047741e-02f, -6.79711401e-02f, 7.21266419e-02f, -6.69300705e-02f, -3.75582725e-02f,
  2.11691260e-02f, 2.05639396e-02f, -9.71986540e-03f, -2.90809479e-02f, 5.10233082e-02f, -1.96850058e-02f, -4.34485637e-02f, -1.64498128e-02f, -7.94435665e-02f, -3.79459336e-02f,
  1.56250224e-01f, 2.88761817e-02f, 3.77890468e-02f, 9.42792520e-02f, -1.78878084e-02f, -6.38004690e-02f, -2.35569328e-02f, -3.73731740e-03f, 2.62271967e-02f, 5.27477339e-02f,
  -1.52686471e-02f, 6.75046875e-04f, 3.33784730e-03f, -4.88184579e-02f, 5.06456988e-03f, 7.64185712e-02f, -9.83443670e-03f, -1.63336303e-02f, -7.46725947e-02f, 4.17822562e-02f,
  -3.46113034e-02f, -2.50283512e-03f, -1.59309637e-02f, -2.88077607e-03f, 4.75347154e-02f, -2.13254821e-02f, 1.17382016e-02f, 3.21138836e-02f, 2.91161099e-03f, 3.67687121e-02f,
  -1.12988830e-01f, 3.56128067e-01f, 6.43138364e-02f, -5.78825660e-02f, -8.97607356e-02f, 1.06154390e-01f, 4.96735331e-03f, 7.39680752e-02f, -1.73458597e-03f, 2.47262031e-01f,
  1.25315841e-02f, 5.89828528e-02f, -7.09246518e-03f, 9.98456553e-02f, -3.63667369e-01f, -5.06999977e-02f, 5.78185618e-02f, 2.04631761e-02f, 8.13729465e-02f, 9.05730501e-02f,
  -8.70709643e-02f, -2.19688624e-01f, -2.70226859e-02f, 1.60035312e-01f, 4.03340384e-02f, 7.63253123e-02f, -8.23201686e-02f, -6.29639253e-02f, 1.56133370e-02f, -1.73027720e-02f,
  -5.51727191e-02f, -4.23835702e-02f, 7.76664987e-02f, 6.54926756e-03f, 9.30676386e-02f, 8.75356793e-02f, 2.82045808e-02f, -5.46845868e-02f, -1.16783030e-01f, -2.06298288e-02f,
  8.14441405e-03f, -1.38233816e-02f, 9.95973274e-02f, -1.69615373e-02f, 5.11222295e-02f, -2.93780807e-02f, 5.80348037e-02f, -9.39377025e-03f, 6.82612881e-02f, -2.62720659e-02f,
  8.75916779e-02f, 3.53478119e-02f, 2.94150468e-02f, 8.04060623e-02f, -6.19086176e-02f, -9.52042919e-03f, 6.10280894e-02f, -6.67391419e-02f, 3.47366817e-02f, 1.08004520e-02f,
  -8.26656148e-02f, 6.39382675e-02f, -6.21088548e-03f, 1.65551882e-02f, -1.17879417e-02f, -8.65817145e-02f, -3.69998626e-02f, 2.27437895e-02f, -6.93761483e-02f, -3.76279801e-02f,
  1.64152328e-02f, 4.31274921e-02f, 3.99381481e-02f, 6.35745823e-02f, 2.07538391e-03f, -4.00152728e-02f, -4.06231098e-02f, 2.04918291e-02f, 3.63529399e-02f, -4.14478891e-02f,
  -2.49509942e-02f, -3.38974446e-02f, 2.27538440e-02f, 6.14372082e-02f, -4.36599553e-03f, 1.20087655e-03f, -3.39370184e-02f, 1.90019216e-02f, -9.35142452e-04f, -2.57973708e-02f,
  8.34655240e-02f, -9.74207278e-03f, -4.07879986e-02f, 4.05001752e-02f, 6.90655634e-02f, 4.92397659e-02f, -3.09798438e-02f, 4.79726531e-02f, 3.01466435e-02f, 1.12319393e-02f,
  7.68153369e-03f, -3.14380899e-02f, -3.19595970e-02f, -4.68894690e-02f, -1.93610266e-02f, 7.04580247e-02f, -5.50917424e-02f, 5.23615815e-02f, -5.30494824e-02f, 8.84631872e-02f,
  -6.03250340e-02f, 5.48201427e-03f, 1.04461443e-02f, -3.82881239e-02f, 5.40712960e-02f, -5.34417443e-02f, -1.71785876e-02f, 6.05364069e-02f, -1.16238734e-02f, 7.96361342e-02f,
  3.16906236e-02f, -3.26240584e-02f, -1.17939621e-01f, -2.27447689e-01f, 1.33503735e-01f, 2.92968512e-01f, 1.70938894e-01f, -1.28884226e-01f, -2.55767405e-01f, -3.69949341e-02f,
  -1.49996700e-02f, 4.57648411e-02f, 3.74995321e-02f, 7.10473731e-02f, 3.06140304e-01f, -2.71373428e-03f, 1.72559470e-02f, 7.56655112e-02f, -6.37925267e-02f, -4.91920002e-02f,
  -6.84083328e-02f, 5.37360050e-02f, -5.82190529e-02f, -2.06212476e-02f, 2.20506284e-02f, -1.37389794e-01f, 3.20652090e-02f, -1.06031664e-01f, 1.01678744e-01f, 1.72774196e-01f,
  1.11359455e-01f, -1.41039684e-01f, -5.39348014e-02f, 5.65613667e-03f, 7.01854825e-02f, 5.76583184e-02f, 6.34152666e-02f, 4.25105467e-02f, -4.02737185e-02f, 6.07007882e-03f,
  3.89723927e-02f, -3.77441794e-02f, -2.04673987e-02f, 2.06123106e-02f, -8.33550543e-02f, -1.15918748e-01f, -4.97753173e-02f, 5.20025427e-03f, -1.67672392e-02f, -3.64413261e-02f,
  -8.73006135e-02f, 2.06724331e-02f, -8.80582184e-02f, -2.95310169e-02f, -8.20850134e-02f, -2.40601823e-02f, 2.06284970e-02f, 9.71148536e-02f, 5.85924312e-02f, -1.20398821e-02f,
  -4.98573184e-02f, -4.01024558e-02f, 7.44659966e-03f, 3.64777967e-02f, 3.96253392e-02f, -4.84751947e-02f, 2.46511810e-02f, 6.11300617e-02f, -5.70688630e-03f, 4.52740416e-02f,
  1.90085117e-02f, -1.65255752e-03f, -8.18101540e-02f, -1.01801464e-02f, -3.91735956e-02f, -6.08537868e-02f, 4.88750786e-02f, 4.19563018e-02f, -6.33745175e-03f, -9.82611720e-03f,
  -5.11995368e-02f, -8.08557495e-04f, -3.70840989e-02f, 7.00576231e-02f, 6.08592480e-02f, -4.38395850e-02f, -3.57486382e-02f, 3.65462415e-02f, 5.60080521e-02f, 3.02415360e-02f,
  2.65876114e-01f, 5.74651025e-02f, 2.91876923e-02f, 4.53158058e-02f, 3.10415849e-02f, 8.20593014e-02f, -3.92775461e-02f, 3.61170694e-02f, 3.29959244e-02f, 6.92635626e-02f,
  -1.30351298e-02f, 1.25996014e-02f, 6.72826543e-02f, -3.30751538e-02f, 9.36229527e-02f, 3.64996195e-02f, -1.02515602e-02f, 3.86746824e-02f, 3.49113569e-02f, 1.03573166e-02f,
  -5.49871027e-02f, 7.45507628e-02f, 3.31456810e-02f, -4.42835838e-02f, -1.40042650e-02f, 3.65038402e-02f, 3.79535407e-02f, -6.97897077e-02f, 8.75087529e-02f, -7.39232823e-03f,
  8.23098049e-02f, -2.74248351e-03f, 2.04726174e-01f, -2.31498957e-01f, -2.44397461e-01f, -3.34075719e-01f, -2.19384491e-01f, -2.18215227e-01f, -3.36701542e-01f, -6.66379333e-02f,
  -1.65629476e-01f, 5.60709722e-02f, 1.59739941e-01f, -2.54709363e-01f, -3.94108891e-02f, -4.52591712e-03f, -2.76604176e-01f, -1.56888917e-01f, -7.23920763e-02f, 1.53447529e-02f,
  -4.21147980e-02f, -2.29108602e-01f, 1.10487096e-01f, -6.03575408e-02f, -1.08392403e-01f, 7.63264224e-02f, 1.03742763e-01f, 2.32045650e-01f, -9.84625332e-03f, -4.64182273e-02f,
  -7.46294409e-02f, -7.96023533e-02f, -6.85661361e-02f, 5.93095012e-02f, -7.62333814e-03f, 7.40785003e-02f, 8.30976814e-02f, 5.46445139e-02f, -3.15289125e-02f, -1.90552752e-02f,
  6.58943802e-02f, 3.18693072e-02f, 4.86369571e-03f, -1.78965088e-02f, -3.28704864e-02f, -2.52304748e-02f, -2.39912444e-03f, -5.08636795e-02f, -6.97098598e-02f, 8.23497772e-03f,
  2.41580084e-02f, -1.20488945e-02f, -4.24523465e-02f, -1.64741073e-02f, -5.15052900e-02f, -5.07088527e-02f, 9.53772571e-03f, 9.98319313e-02f, -4.04553227e-02f, -8.35535303e-02f,
  -4.71020304e-02f, 6.11970164e-02f, 2.23289914e-02f, -2.31296252e-02f, -5.82213374e-03f, 3.32130380e-02f, -3.86162638e-03f, 1.91277117e-02f, 2.62000579e-02f, 1.60406791e-02f,
  -6.63274601e-02f, -3.18782032e-02f, 1.29139861e-02f, -3.29504721e-02f, 1.45577509e-02f, -1.02393124e-02f, 6.02372214e-02f, 3.11403424e-02f, -9.52093899e-02f, -7.47207627e-02f,
  4.78546863e-05f, -3.24648805e-02f, -4.91142320e-03f, 1.05205728e-02f, 2.28631962e-02f, -1.01484740e-02f, 9.11580771e-03f, 1.86508987e-02f, 2.90418379e-02f, -5.89951454e-03f,
  -1.02311105e-01f, -7.74817988e-02f, -6.87562525e-02f, -2.68463306e-02f, 1.66807827e-02f, -4.00372148e-02f, -3.32835838e-02f, -3.38820890e-02f, 3.03477757e-02f, -3.73329297e-02f,
  3.12836356e-02f, -4.81787845e-02f, -3.50770094e-02f, 1.14240199e-02f, -9.56232753e-03f, -2.29421128e-02f, 8.69447961e-02f, -3.65803801e-02f, 1.07592074e-02f, 1.49995806e-02f,
  2.14171559e-02f, -1.29951769e-02f, 4.88514714e-02f, -5.13552204e-02f, 3.62590104e-02f, 4.50765640e-02f, -1.31040029e-02f, -5.60223451e-03f, 8.82691368e-02f, -1.38098476e-02f,
  1.37875587e-01f, -2.71827161e-01f, -2.05212226e-03f, 4.22667190e-02f, -3.59570384e-02f, 1.64011553e-01f, 8.58643800e-02f, -1.53520033e-01f, -2.01622009e-01f, -1.18437693e-01f,
  5.96553534e-02f, -7.57349357e-02f, 5.18781580e-02f, 2.55591393e-01f, 3.64333332e-01f, 9.64205712e-02f, 1.51056871e-01f, 1.29432410e-01f, -8.49122256e-02f, -3.15609351e-02f,
  1.24849193e-02f, 1.86283141e-01f, 1.63343802e-01f, -6.11367114e-02f, 9.37053710e-02f, -1.85753614e-01f, 2.52638776e-02f, -4.89646122e-02f, 9.48351845e-02f, 1.41751871e-01f,
  8.48191902e-02f, -1.08346902e-01f, -2.11593322e-02f, 1.72202233e-02f, -1.12629104e-02f, 1.03152050e-02f, -6.56134114e-02f, 8.06374699e-02f, 2.32298356e-02f, -6.86479062e-02f,
  -4.34315205e-02f, 4.01215479e-02f, 1.23731922e-02f, 2.97590625e-02f, -1.91138294e-02f, -6.71063066e-02f, 2.89741140e-02f, -3.66351418e-02f, 1.94290094e-02f, 5.79393608e-03f,
  -4.36190180e-02f, -3.14758532e-02f, -1.95648149e-02f, -4.13608775e-02f, -1.47285108e-02f, -4.29246807e-03f, -1.19585348e-02f, -3.67266573e-02f, -5.83022088e-02f, -2.55997069e-02f,
  -4.23435401e-03f, 5.94157875e-02f, 8.15225020e-03f, 1.66595336e-02f, 2.48721913e-02f, 6.31632004e-03f, 4.03121412e-02f, -2.38474943e-02f, 2.51740050e-02f, -8.41926131e-03f,
  -2.93763820e-02f, 1.16051058e-03f, 1.68945957e-02f, 1.07430527e-02f, 1.14920326e-02f, 2.55364999e-02f, 1.53778614e-02f, -5.39421476e-02f, 4.18674834e-02f, -6.93997070e-02f,
  -4.00637556e-03f, 4.80194278e-02f, 1.50072016e-02f, -1.97845437e-02f, 2.25186571e-02f, 2.31064800e-02f, -3.12254187e-02f, -2.98465639e-02f, 1.13014150e-02f, 1.02225989e-01f,
  -6.34350032e-02f, -9.84518155e-02f, -5.32734655e-02f, -1.84062067e-02f, -2.01163981e-02f, 2.84787696e-02f, 5.91078252e-02f, -7.87463039e-03f, 3.91782746e-02f, 1.84181463e-02f,
  -4.37520817e-02f, -5.57271987e-02f, -1.03551317e-02f, 7.80815184e-02f, 6.41783839e-03f, -5.37616983e-02f, 2.16036905e-02f, 2.14221347e-02f, -3.78258564e-02f, -4.35197018e-02f,
  -2.80560576e-03f, -3.97807583e-02f, 8.83703865e-03f, -3.14170793e-02f, -1.21441521e-02f, -2.67667957e-02f, -6.23183027e-02f, 3.66705959e-03f, 5.64578772e-02f, -3.69424466e-03f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.20312750e-01f, 2.54269779e-01f, 1.02841958e-01f, 1.11597583e-01f, 5.22250421e-02f, -1.09454535e-01f, -1.01525255e-01f, 1.03420563e-01f, 1.14544496e-01f, 4.10451926e-02f,
  -2.05485662e-03f, 1.48983061e-01f, 9.79686342e-03f, 6.30129501e-02f, -2.07950667e-01f, -6.86011985e-02f, -6.34544343e-02f, 3.22075076e-02f, 1.04831107e-01f, 5.44416942e-02f,
  -8.79278183e-02f, -4.46626879e-02f, -9.11506116e-02f, 1.35790274e-01f, -9.19734761e-02f, -2.14374401e-02f, -1.62878782e-01f, 6.25477731e-02f, -6.44601360e-02f, -4.16387096e-02f,
  -5.94897494e-02f, 7.62459710e-02f, -9.17207822e-02f, -1.94947086e-02f, -4.99188974e-02f, 6.05628418e-04f, -6.07501157e-02f, 6.30943477e-02f, -3.05626821e-02f, -3.25996764e-02f,
  -7.00183883e-02f, 3.68556343e-02f, 9.05419327e-03f, 1.03084937e-01f, 1.66763980e-02f, 6.12304918e-03f, 9.85655561e-02f, -1.03035551e-02f, 1.06801912e-01f, -3.89561243e-02f,
  -3.85887660e-02f, -5.04098199e-02f, -9.44895148e-02f, 3.11889462e-02f, 7.19166324e-02f, 1.57647990e-02f, 6.17807508e-02f, 1.47404782e-02f, 3.20446454e-02f, 1.37701361e-02f,
  -6.54835626e-02f, -3.07235979e-02f, 1.49504310e-02f, -5.02084643e-02f, -5.32844104e-02f, -1.92623641e-02f, -4.56849346e-03f, -5.91643937e-02f, 2.50774901e-02f, 4.77804430e-02f,
  -1.17245071e-01f, 3.09251677e-02f, 5.76984324e-02f, 1.01080509e-02f, 5.61675727e-02f, -7.53058344e-02f, 6.03157505e-02f, -3.99125963e-02f, -4.47470397e-02f, 4.75079864e-02f,
  -1.94003079e-02f, 1.39065133e-02f, -5.99085279e-02f, -5.24038672e-02f, -4.46346067e-02f, 2.13231612e-02f, -7.94056356e-02f, 3.16033177e-02f, 8.39051306e-02f, 3.43081616e-02f,
  -1.70637742e-01f, -9.58347917e-02f, 4.11424525e-02f, 5.15209697e-02f, 2.36944240e-02f, 4.31979410e-02f, -6.60739392e-02f, 6.57295361e-02f, 3.66738699e-02f, 3.00398059e-02f,
  1.36979725e-02f, 1.04805594e-03f, 5.18013239e-02f, 4.71465439e-02f, 7.32406303e-02f, 5.06204404e-02f, -8.97609629e-03f, -5.89606650e-02f, -6.89369068e-02f, 6.23151213e-02f,
  2.29611360e-02f, -7.84585476e-02f, -9.43042412e-02f, -8.67953897e-02f, -9.26317833e-03f, -9.70240235e-02f, -7.71083161e-02f, 9.51255560e-02f, -3.47082242e-02f, 5.80899641e-02f,
  -1.60086960e-01f, 2.44960152e-02f, -5.77949286e-02f, -1.72872126e-01f, 1.38685526e-02f, -1.21946000e-01f, -1.03098631e-01f, -9.72417444e-02f, 1.13926840e-03f, 1.33253589e-01f,
  3.63994427e-02f, -1.27237573e-01f, 2.89720134e-03f, 4.03761491e-02f, -4.86501791e-02f, 1.24555670e-01f, -9.39744338e-02f, 1.63154211e-03f, 2.16618665e-02f, -2.02644259e-01f,
  -4.71777143e-03f, 2.76932288e-02f, -6.30693734e-02f, -1.53208422e-02f, -3.44817601e-02f, -5.36528900e-02f, 8.82904008e-02f, 5.08102588e-02f, -5.98798953e-02f, -2.51342170e-02f,
  -7.06462264e-02f, -1.73513427e-01f, -5.17938323e-02f, -4.37017642e-02f, -1.00480497e-01f, -2.07000058e-02f, -1.93115268e-02f, 1.12804314e-02f, -5.19630462e-02f, -1.00978471e-01f,
  5.33186495e-02f, -6.52068406e-02f, 8.97596776e-02f, 9.77812260e-02f, -3.78589220e-02f, 4.39281911e-02f, 8.35393220e-02f, -3.49850915e-02f, -5.61717711e-02f, -8.65988061e-02f,
  -5.55467531e-02f, -2.54269522e-02f, 6.48867786e-02f, 3.87916043e-02f, -5.59046753e-02f, -3.29161510e-02f, 7.36256167e-02f, 3.82815078e-02f, -1.80613827e-02f, -3.45345959e-03f,
  -4.13800851e-02f, 2.77963225e-02f, -6.76584989e-02f, -8.17768183e-03f, -4.96793278e-02f, 7.28676841e-02f, 3.55584100e-02f, -3.05919480e-02f, -1.13497153e-02f, -6.60246015e-02f,
  -4.47170548e-02f, 6.58469498e-02f, -7.27033392e-02f, 4.46735648e-03f, -6.65933415e-02f, -1.33552309e-03f, -6.68752845e-03f, -5.42954169e-02f, 4.82697189e-02f, -1.21853082e-02f,
  -6.29875883e-02f, 5.84305190e-02f, 2.75932904e-02f, 5.08820580e-04f, 3.92455868e-02f, -6.47340417e-02f, 2.05935426e-02f, 6.96965307e-02f, 7.56363720e-02f, 6.74724504e-02f,
  -1.64905533e-01f, -1.07416272e-01f, -5.14632240e-02f, -5.28335683e-02f, 1.13703348e-02f, -4.45978157e-02f, -3.91610246e-03f, -2.52261814e-02f, -5.81639931e-02f, -2.10282635e-02f,
  -2.24038586e-02f, 1.08697172e-02f, -2.97774579e-02f, -5.92033379e-02f, -4.18346887e-03f, -4.11385782e-02f, -8.44236687e-02f, -9.28635336e-03f, -7.13599920e-02f, -3.61403488e-02f,
  7.43272202e-03f, 1.61531158e-02f, -1.09037217e-02f, -4.38304804e-02f, 9.51597318e-02f, -1.01549551e-02f, -4.37618345e-02f, 5.85697964e-02f, -2.71558948e-02f, 2.54630577e-02f,
  3.84763926e-02f, -1.64252400e-01f, 8.76274928e-02f, 7.98975229e-02f, 4.48161662e-02f, 1.42577186e-01f, 1.56615347e-01f, 3.21897641e-02f, 2.54850626e-01f, -1.84422180e-01f,
  -1.04538165e-01f, -9.41307098e-02f, -9.37790237e-03f, -1.64216593e-01f, -9.09127668e-03f, 5.91007434e-02f, -2.94744093e-02f, -8.53283852e-02f, 1.29604056e-01f, 2.55944245e-02f,
  -3.70606966e-02f, -1.91465154e-01f, 8.74036516e-04f, -1.79362401e-01f, -1.33909106e-01f, 7.08668167e-03f, -1.99858248e-01f, -8.81486908e-02f, -6.60286397e-02f, -3.25715058e-02f,
  4.74904515e-02f, 5.16089126e-02f, 4.72304923e-03f, 5.01234904e-02f, 5.81520870e-02f, -2.76527982e-02f, -1.35613263e-01f, -3.42005119e-02f, -2.79235337e-02f, -2.40722969e-02f,
  -4.20765346e-03f, 7.54085556e-02f, 3.31814177e-02f, -3.35249933e-03f, 1.92240216e-02f, 3.47989500e-02f, -6.19727187e-02f, 7.21164495e-02f, 5.21334969e-02f, -7.59683270e-03f,
  4.93041426e-02f, 3.00857611e-02f, -3.47826630e-02f, 9.65372566e-03f, -6.43065572e-02f, 9.98468027e-02f, -6.94314092e-02f, 4.08876427e-02f, 1.85888857e-02f, -2.43350565e-02f,
  -1.20253794e-01f, 6.40552863e-02f, -7.12280571e-02f, 9.33642760e-02f, -3.97108123e-02f, 5.10035492e-02f, -4.34430502e-02f, 2.87512597e-03f, 9.77030471e-02f, 4.12742570e-02f,
  -1.51637511e-03f, -4.53189202e-02f, 7.02278595e-03f, -1.21144997e-02f, 6.79783197e-03f, 2.47259196e-02f, -9.27582011e-02f, -8.54538232e-02f, 1.86323803e-02f, -2.15416681e-02f,
  -2.51465272e-02f, -4.27486561e-03f, -7.64344335e-02f, 6.79135621e-02f, 2.12562010e-02f, -2.70827468e-02f, 1.74125191e-02f, 5.59464209e-02f, -2.10900139e-02f, 1.79659650e-02f,
  2.01697797e-02f, 6.51199669e-02f, -8.05476829e-02f, -3.14657688e-02f, -6.15815073e-02f, 4.22368534e-02f, -9.35559124e-02f, -3.03791203e-02f, -2.32197810e-02f, 2.99161393e-02f,
  -8.02962556e-02f, 8.00177604e-02f, 6.16966151e-02f, 6.37654960e-02f, 4.00800481e-02f, 8.06171447e-02f, 4.67550978e-02f, 3.78660560e-02f, -7.21421242e-02f, 1.20478841e-02f,
  -5.38746677e-02f, -4.74694259e-02f, -2.87613533e-02f, -2.81349011e-02f, -9.12315175e-02f, 4.27379422e-02f, -5.73378466e-02f, 4.89561819e-02f, 6.24400936e-02f, 2.75307847e-03f,
  5.31768762e-02f, 1.53930336e-01f, 7.07084406e-03f, 6.40906170e-02f, 1.75115224e-06f, 3.19614485e-02f, 1.06625259e-01f, 4.46491167e-02f, 1.64524451e-01f, 6.79359958e-03f,
  -1.11722715e-01f, 5.07813059e-02f, 1.61567237e-02f, 9.38626379e-02f, -7.80244321e-02f, 1.46304688e-03f, -4.86022793e-03f, 3.87366377e-02f, 9.22192540e-03f, 1.10109217e-01f,
  -8.04467499e-02f, -8.58459622e-02f, 6.32660696e-03f, -2.20966134e-02f, -8.31670761e-02f, 3.98651697e-02f, -3.15730721e-02f, -6.22585602e-03f, -5.48745580e-02f, 1.63936019e-02f,
  7.35934600e-02f, 1.43349409e-01f, -2.14572139e-02f, 8.67814496e-02f, 1.95093919e-02f, -1.23769745e-01f, -8.61549452e-02f, -8.71605352e-02f, -3.88687104e-02f, 6.15070462e-02f,
  -3.74503247e-02f, -6.97538555e-02f, -2.75286511e-02f, 3.28707844e-02f, -6.14583977e-02f, 2.49089394e-02f, -7.28738680e-02f, 5.56405857e-02f, -8.76223817e-02f, 5.96364588e-02f,
  -6.62871003e-02f, 7.36374035e-02f, -1.77523040e-03f, 2.21802555e-02f, -7.74813965e-02f, 4.13561091e-02f, -2.44933087e-03f, -1.85171515e-02f, 4.85789077e-03f, -1.64228100e-02f,
  2.15803310e-02f, -8.87676999e-02f, 6.78525120e-02f, -9.31108966e-02f, 8.89071599e-02f, -1.22880116e-02f, 4.79243472e-02f, -1.00670964e-01f, 3.07199489e-02f, -1.22729328e-03f,
  -3.32274325e-02f, 7.56516457e-02f, 5.00087738e-02f, -1.98429897e-02f, 3.48535515e-02f, -6.30178377e-02f, 2.23566759e-02f, 7.23467693e-02f, 8.28035250e-02f, -5.63659109e-02f,
  7.28808418e-02f, -3.95572595e-02f, -9.15344357e-02f, 4.10125516e-02f, 1.74323600e-02f, -6.71635345e-02f, 3.29450853e-02f, -9.23000127e-02f, 6.04871400e-02f, -4.28850725e-02f,
  8.38628039e-04f, 2.03705028e-01f, -1.28869631e-03f, -2.75488757e-02f, 7.53764436e-02f, -6.30199984e-02f, -2.80857794e-02f, -5.91924340e-02f, 2.91634761e-02f, 5.31497151e-02f,
  -4.67771105e-02f, -8.71168822e-02f, 8.05549324e-02f, 5.21073639e-02f, -1.80009417e-02f, -9.84645933e-02f, -2.35162005e-02f, 4.67566475e-02f, 2.46003456e-02f, -9.76007432e-02f,
  -2.39881240e-02f, -4.99613024e-02f, -3.52470279e-02f, 3.66549455e-02f, -4.07513678e-02f, -2.91512571e-02f, -1.90894343e-02f, 2.27803621e-03f, -1.84723642e-02f, 1.70323830e-02f,
  -1.80176139e-01f, -3.79855409e-02f, 8.17786437e-03f, 2.16961540e-02f, 4.82891798e-02f, -8.40789899e-02f, -1.90314338e-01f, 2.80401818e-02f, -9.47818346e-03f, -3.54627683e-03f,
  7.31596351e-02f, -1.30489185e-01f, 8.86133611e-02f, 2.44968459e-02f, -1.70794383e-01f, -1.25932261e-01f, -1.22571975e-01f, -1.89394169e-02f, -6.85208067e-02f, 7.86051229e-02f,
  1.12356413e-02f, 2.02617094e-01f, 1.32928133e-01f, 1.87433317e-01f, 7.97477588e-02f, 6.01785667e-02f, 2.03719139e-01f, 6.23803884e-02f, 1.56230316e-01f, 7.44754225e-02f,
  3.79521511e-02f, 1.15354106e-01f, -6.08334644e-03f, -7.33505860e-02f, -2.50419024e-02f, 4.66903113e-03f, 1.16001265e-02f, -3.46104875e-02f, 3.14122103e-02f, 4.61129881e-02f,
  5.06846569e-02f, 2.73234416e-02f, 4.64925580e-02f, 5.26955053e-02f, -1.64379328e-02f, -4.57208715e-02f, -2.86212359e-02f, -4.20207456e-02f, 5.76017834e-02f, 1.23648206e-02f,
  3.26812156e-02f, -8.20508972e-02f, 4.55778465e-02f, 9.08995867e-02f, -4.57083769e-02f, -8.76488537e-02f, 4.65916209e-02f, 5.71064837e-02f, 7.49498140e-03f, 8.08093399e-02f,
  2.24663932e-02f, -6.72546774e-02f, -2.99325064e-02f, -5.98644726e-02f, -3.04042511e-02f, 9.59444884e-03f, 5.13912514e-02f, -4.51968722e-02f, -7.72806704e-02f, -7.71799684e-02f,
  2.18013208e-02f, -3.07122637e-02f, 3.40168104e-02f, -3.88820916e-02f, -1.90217886e-02f, 5.45848496e-02f, -3.97902466e-02f, 7.00949207e-02f, 5.99397682e-02f, 5.92399389e-02f,
  -7.15678334e-02f, 4.58969772e-02f, 6.31380081e-02f, -2.94862911e-02f, -4.55199257e-02f, 2.97708008e-02f, 3.14603895e-02f, 4.41435017e-02f, -2.12156922e-02f, -1.47785498e-02f,
  -4.99129929e-02f, 1.37731612e-01f, 2.78729536e-02f, 1.31388027e-02f, 5.09445481e-02f, -1.17553920e-02f, 3.80545226e-03f, -1.99433267e-02f, 4.10027318e-02f, -3.62877771e-02f,
  -4.53596562e-02f, 1.98589079e-02f, -7.78962076e-02f, 5.84233515e-02f, 7.49939531e-02f, 7.71004334e-02f, 8.49513859e-02f, 1.04020536e-01f, -1.83305442e-02f, 5.56217730e-02f,
  1.17054991e-01f, -7.20293671e-02f, 2.68546701e-03f, -7.30304047e-03f, 8.42819139e-02f, 3.59764919e-02f, 6.37399182e-02f, 6.28155917e-02f, -4.35900828e-03f, -4.33827899e-02f,
  -5.93409277e-02f, 2.00132921e-01f, 1.35419995e-01f, 2.84383800e-02f, -1.00397199e-01f, 9.21081826e-02f, 4.03900212e-03f, -9.08151502e-04f, 1.14872254e-01f, 9.31214616e-02f,
  -1.26851484e-01f, 1.46475539e-01f, 5.63246310e-02f, 5.76788485e-02f, -6.68560490e-02f, -1.35052115e-01f, 7.37121776e-02f, 5.01483269e-02f, 1.22209683e-01f, 6.13561459e-02f,
  -7.86971971e-02f, -5.66151850e-02f, -8.80929828e-02f, 1.09569719e-02f, -1.04505364e-02f, 4.46146959e-03f, -1.69468760e-01f, -6.74533425e-03f, 6.23318627e-02f, -4.78816144e-02f,
  3.80911231e-02f, -4.30565560e-03f, 1.62997544e-02f, 1.13414871e-02f, 3.39975208e-02f, -2.93561444e-02f, -6.23875409e-02f, 1.31121399e-02f, 7.47217759e-02f, 6.49060961e-03f,
  4.75313747e-03f, -8.51434469e-02f, 4.82417867e-02f, 6.67655244e-02f, 8.72450098e-02f, 6.31794855e-02f, -1.47560909e-02f, -6.00623712e-02f, -5.53708971e-02f, -4.36962880e-02f,
  -4.56818528e-02f, 9.87428948e-02f, -3.19630392e-02f, 3.10540907e-02f, -2.75713392e-03f, 1.87742163e-03f, 8.18042383e-02f, 8.98528025e-02f, -4.15296592e-02f, 1.06515260e-02f,
  1.07356049e-01f, -2.63060071e-02f, -5.46776354e-02f, -6.82131276e-02f, 4.28435989e-02f, -9.09128860e-02f, -1.79077759e-02f, 2.97946967e-02f, 2.22502127e-02f, -4.56973761e-02f,
  -4.16024029e-02f, -3.23981009e-02f, -4.77377735e-02f, 4.79118451e-02f, -3.08883432e-02f, -5.96859977e-02f, -8.23686644e-03f, -1.98162757e-02f, -4.18907497e-03f, 6.58703148e-02f,
  -9.07125100e-02f, 1.08447066e-02f, 7.66083226e-02f, -7.19404072e-02f, -1.11065991e-02f, -1.03082567e-01f, -7.69682750e-02f, -6.31044358e-02f, 3.69482003e-02f, 1.31818578e-02f,
  -2.65248567e-02f, 1.10811464e-01f, -4.33552265e-02f, 6.97701350e-02f, 2.33433768e-02f, -6.09422685e-04f, 6.64847046e-02f, -8.34102407e-02f, 9.80863273e-02f, 3.55275422e-02f,
  6.89785033e-02f, 8.46602693e-02f, -3.50384861e-02f, -6.69917837e-02f, 3.35670635e-02f, -4.44220705e-03f, 9.63766780e-03f, -6.92808703e-02f, 5.38513064e-02f, -6.41802847e-02f,
  6.24825656e-02f, -1.78973768e-02f, -5.39422967e-02f, -2.18571983e-02f, -4.37567644e-02f, -6.78793862e-02f, 7.00529367e-02f, 1.35874411e-03f, -5.02879508e-02f, -4.74461615e-02f,
  5.74401170e-02f, 2.75846664e-02f, -1.41964138e-01f, -9.75702927e-02f, -2.96551604e-02f, 4.84369174e-02f, -1.90706924e-01f, 3.63857076e-02f, -1.58314452e-01f, -1.53836668e-01f,
  -1.76823493e-02f, -7.81529844e-02f, -6.74500614e-02f, 7.98425451e-02f, 1.11173384e-01f, 4.43975329e-02f, 3.16053778e-02f, -1.65284257e-02f, 1.91451281e-01f, -3.02628707e-02f,
  1.90574169e-01f, 1.08469531e-01f, 1.28675222e-01f, 1.39209390e-01f, -5.00054993e-02f, 1.01044923e-02f, -5.46885096e-02f, -7.06060324e-03f, -6.77286787e-03f, 7.50265494e-02f,
  8.45606923e-02f, 3.83994617e-02f, -7.49026164e-02f, -6.37051165e-02f, -2.92208474e-02f, -8.17445964e-02f, -1.61464009e-02f, -2.29597930e-02f, -7.27469549e-02f, 7.87656009e-02f,
  -1.19670048e-01f, 8.41078386e-02f, 8.56451225e-03f, -2.54285317e-02f, -9.60628986e-02f, 3.84483822e-02f, -3.20934132e-02f, 8.13390762e-02f, -6.65063709e-02f, 8.32912624e-02f,
  3.28131616e-02f, -5.29944431e-03f, -3.41841206e-02f, 4.49524261e-02f, -6.55710176e-02f, -6.60379827e-02f, 3.55400257e-02f, -4.28789556e-02f, -7.35162571e-02f, -5.03270514e-02f,
  -7.49009196e-03f, -3.25210914e-02f, 2.33769380e-02f, -1.07991719e-03f, -8.00334439e-02f, -9.51694995e-02f, 4.80440818e-03f, -4.06633727e-02f, -3.48870680e-02f, 4.30475426e-04f,
  -3.81391943e-02f, -3.20717692e-02f, 2.02372372e-02f, 2.12950427e-02f, 9.49857086e-02f, 9.81883705e-02f, -3.00154742e-03f, 6.80096000e-02f, 7.97156319e-02f, 3.15600112e-02f,
  -6.22952245e-02f, -3.94149534e-02f, 2.97960732e-02f, 3.58895250e-02f, -2.42090840e-02f, -5.57322353e-02f, -7.98841286e-03f, 9.59427282e-02f, -6.44903183e-02f, -2.58387383e-02f,
  6.48052469e-02f, 8.52268487e-02f, 3.11940536e-02f, -3.42562869e-02f, 3.59379277e-02f, -1.51464278e-02f, 8.30222294e-02f, 7.07601458e-02f, 5.31315096e-02f, -8.85794163e-02f,
  -9.49614495e-02f, -6.37471676e-02f, 5.39097302e-02f, -5.96967153e-02f, -5.49581088e-02f, 3.41247045e-03f, 2.21982859e-02f, 1.10277673e-02f, -3.01050637e-02f, 8.80536437e-02f,
  7.92504754e-03f, -4.47424641e-03f, -4.84170653e-02f, -2.70023737e-02f, 1.41936075e-02f, -9.38953310e-02f, -6.31656945e-02f, 5.41874543e-02f, 1.65181719e-02f, 7.95585737e-02f,
  1.00189254e-01f, 8.25947300e-02f, 1.02927731e-02f, 7.76668489e-02f, -1.78921083e-03f, -5.79845384e-02f, -8.30739853e-04f, 4.97416966e-02f, 2.51736045e-02f, 8.56423974e-02f,
  -1.15761096e-02f, 7.11676702e-02f, -1.35707080e-01f, -5.66296317e-02f, -2.99719393e-01f, -2.57626653e-01f, -1.14515342e-01f, -7.63790915e-03f, -3.96261886e-02f, -1.17472978e-02f,
  -8.66378844e-02f, -6.67225271e-02f, -2.93051619e-02f, 6.67764172e-02f, 1.25959709e-01f, 2.20275626e-01f, 8.11424106e-02f, 1.06444675e-02f, 1.32508337e-01f, 2.67847683e-02f,
  -2.75250850e-03f, -4.67148535e-02f, 8.45643356e-02f, -1.44381737e-02f, 4.71457541e-02f, 8.76937509e-02f, -6.93599693e-03f, -4.69025373e-02f, 3.99836898e-02f, -6.91033006e-02f,
  -3.17865214e-03f, 3.11528472e-03f, 6.94986656e-02f, -1.33462381e-02f, 1.04642928e-01f, 2.50800364e-02f, 5.34007251e-02f, 5.73306233e-02f, 6.94423318e-02f, 7.34658465e-02f,
  9.90982205e-02f, 6.25893241e-03f, 1.78750362e-02f, 5.15562110e-02f, -4.44681235e-02f, -5.60449213e-02f, 4.03625108e-02f, 1.02370203e-01f, 6.99445605e-02f, 5.11909537e-02f,
  5.13063557e-02f, 6.30375184e-03f, 2.57292222e-02f, -2.59240102e-02f, 6.03443831e-02f, -2.53261197e-02f, -1.93034448e-02f, 6.38463572e-02f, -2.50557791e-02f, -3.14930156e-02f,
  2.41915998e-03f, 8.50533023e-02f, -8.36422294e-02f, 8.14462360e-03f, -4.23951820e-02f, 8.85793846e-03f, -5.88976704e-02f, -2.21276302e-02f, 4.85321917e-02f, -6.53844923e-02f,
  -3.20572406e-02f, -3.08563393e-02f, -2.89275369e-04f, -5.80213440e-04f, 1.65138301e-02f, -1.86171592e-03f, 6.14991225e-02f, 9.73021053e-03f, 2.50320770e-02f, 7.93214217e-02f,
  -7.06055090e-02f, -4.40609604e-02f, -7.43852258e-02f, -7.37634897e-02f, -6.00472912e-02f, 4.65088971e-02f, 4.21313718e-02f, -7.16082826e-02f, 1.03744194e-02f, -7.80284107e-02f,
  1.22727744e-01f, -2.87365112e-02f, -7.01053441e-02f, -4.02155966e-02f, -2.47863680e-03f, -5.94511954e-03f, -3.41744721e-02f, 7.09001571e-02f, 2.77827028e-02f, 8.65142271e-02f,
  1.09954700e-01f, -4.08720002e-02f, 1.72243547e-02f, 8.01607668e-02f, -4.54917960e-02f, 7.02265352e-02f, -6.07422590e-02f, 6.85108602e-02f, -6.04281994e-03f, 5.88675728e-03f,
  7.64210299e-02f, 6.19373508e-02f, 8.77599567e-02f, 3.68197896e-02f, -9.66260880e-02f, -2.10507903e-02f, 5.15051670e-02f, 1.56562552e-02f, -1.03478692e-02f, -6.20477460e-02f,
  -8.15968812e-02f, 5.94447143e-02f, -8.67208615e-02f, -3.70779447e-02f, -4.99430485e-02f, 6.01777099e-02f, -7.95932859e-02f, 9.57658514e-03f, 3.32809649e-02f, 8.48813653e-02f,
  1.40017038e-02f, 1.42269991e-02f, 6.42955005e-02f, -2.47728769e-02f, 4.58277352e-02f, -2.40834728e-02f, -1.31493270e-01f, -1.05135299e-01f, -5.62760159e-02f, 5.63459061e-02f,
  4.01110388e-02f, 5.07160537e-02f, 4.10984941e-02f, 3.61100510e-02f, -1.21316258e-02f, 7.10927099e-02f, 6.73485994e-02f, -1.89387463e-02f, 6.25733659e-02f, 2.72523370e-02f,
  1.40276728e-02f, -8.96248408e-03f, -7.33749270e-02f, -8.35320279e-02f, -8.46484117e-03f, 2.31818575e-02f, -8.06629956e-02f, 7.38382488e-02f, -2.45950129e-02f, 8.13118443e-02f,
  -8.28713253e-02f, -3.04575637e-02f, -3.58999819e-02f, 7.03852996e-02f, 5.10429665e-02f, 5.50483260e-03f, -5.34856282e-02f, -3.93639021e-02f, 2.59897634e-02f, 8.18022899e-03f,
  1.00787103e-01f, 1.30521273e-02f, 1.32592665e-02f, -2.82453392e-02f, -8.53769705e-02f, -5.27579524e-02f, -5.23846187e-02f, 6.05495647e-02f, 7.80892745e-02f, 2.31224555e-03f,
  -2.20060758e-02f, -2.34992281e-02f, -8.20856318e-02f, 6.69710562e-02f, -8.22973624e-02f, 7.79302567e-02f, 4.18415703e-02f, 2.77621318e-02f, -2.56492272e-02f, -8.62402692e-02f,
  -5.61397411e-02f, 2.01252475e-03f, 4.18177322e-02f, -3.47648561e-02f, -2.01940984e-02f, -2.33064853e-02f, 2.34391564e-03f, 4.23235856e-02f, -7.08852783e-02f, -6.20355420e-02f,
  -8.71186852e-02f, -3.21737342e-02f, 7.07788020e-03f, 7.10598081e-02f, 1.01091616e-01f, 9.31712985e-02f, -3.88600938e-02f, -1.62262078e-02f, -6.03773855e-02f, -2.31751278e-02f,
  -3.32328752e-02f, -4.59898300e-02f, 2.17193440e-02f, -7.34894723e-02f, -2.33017709e-02f, 9.84129496e-03f, 1.56211415e-02f, -4.41700071e-02f, -8.86572972e-02f, 6.97217509e-02f,
  5.52106183e-03f, -8.57295990e-02f, -6.64403513e-02f, -1.59762911e-02f, -1.86501127e-02f, 3.88960093e-02f, -7.28707165e-02f, -4.26651277e-02f, -5.46823721e-03f, 7.68483430e-02f,
  -9.16116908e-02f, 1.56435326e-01f, 1.11538760e-01f, -1.76959559e-01f, 5.83178140e-02f, -1.33465633e-01f, -1.46599963e-01f, -1.30151203e-02f, 1.59627348e-02f, 1.60224244e-01f,
  -1.01534471e-01f, 8.68167132e-02f, -1.29980939e-02f, -1.07789189e-01f, -4.62812394e-01f, -1.99102923e-01f, -1.72496244e-01f, -1.34826273e-01f, -6.96994811e-02f, -3.96428667e-02f,
  -1.19587637e-01f, -2.84600437e-01f, -9.53646079e-02f, -4.04713154e-02f, 6.71482384e-02f, 1.56642601e-01f, -1.05122074e-01f, 4.44737598e-02f, 8.81115198e-02f, -8.46874341e-02f,
  -8.07147473e-02f, 1.15156032e-01f, 4.85487543e-02f, -3.33451517e-02f, -2.87359897e-02f, 1.09967042e-03f, 4.52588312e-02f, -4.42205817e-02f, -8.04726556e-02f, -1.55940289e-02f,
  4.53643426e-02f, 4.82986085e-02f, -2.95388382e-02f, -3.47850770e-02f, 2.08112057e-02f, 3.95323597e-02f, 6.00814372e-02f, -2.62803771e-02f, 1.67303830e-02f, 1.76891983e-02f,
  1.93854291e-02f, 8.96099359e-02f, -7.54057569e-03f, 5.09686321e-02f, -7.19726011e-02f, 4.68172915e-02f, 1.82458218e-02f, 7.17790127e-02f, 7.16231614e-02f, -1.28183747e-02f,
  -5.52980788e-03f, -7.71624967e-02f, 5.04720807e-02f, 3.67114916e-02f, -1.27552338e-02f, -1.60867684e-02f, 2.16008251e-04f, 5.21635525e-02f, 5.48179261e-02f, -3.25889327e-02f,
  1.45710437e-02f, 7.31388927e-02f, -3.28839235e-02f, -3.40678059e-02f, -5.62138818e-02f, 3.74795757e-02f, 3.48450243e-02f, -4.75936979e-02f, 1.68693047e-02f, -4.22550477e-02f,
  8.21483582e-02f, -6.66496009e-02f, 1.08923865e-02f, 2.93107256e-02f, -5.69085702e-02f, -9.40931670e-04f, 4.68106642e-02f, 8.87688473e-02f, 4.38756719e-02f, -7.06052035e-02f,
  -5.79019934e-02f, -1.33867845e-01f, 9.24124792e-02f, 7.94854760e-02f, 3.04148681e-02f, -2.45836172e-02f, -4.44875956e-02f, 3.52219753e-02f, -3.51465754e-02f, -4.61205840e-02f,
  5.21168066e-03f, 4.02970538e-02f, 1.63693577e-02f, 3.61613594e-02f, 4.65234779e-02f, 9.00966395e-03f, -2.65725935e-03f, 1.50349848e-02f, 1.25187205e-03f, -2.28987001e-02f,
  2.80165914e-02f, -6.73292810e-03f, 5.44236079e-02f, 2.57105920e-02f, 5.48391603e-03f, 4.24748212e-02f, 6.99454248e-02f, 9.34462547e-02f, -4.62555587e-02f, 1.10319757e-03f,
  9.05359909e-02f, -2.13979017e-02f, -5.13425656e-02f, -1.45394370e-01f, 1.16489261e-01f, 1.37648210e-01f, 4.16769795e-02f, 4.25363258e-02f, -1.47626683e-01f, 5.45167290e-02f,
  9.69679877e-02f, 2.58149188e-02f, 9.50754583e-02f, 3.62377092e-02f, 6.26008138e-02f, 1.07044458e-01f, -8.05137083e-02f, -4.49092574e-02f, -1.08344987e-01f, -1.78394448e-02f,
  -8.29704776e-02f, 4.78018168e-03f, -7.32103586e-02f, -1.64996851e-02f, -8.36341381e-02f, -4.54582684e-02f, 1.88756213e-02f, 7.56005570e-03f, -2.85506318e-03f, 8.27813968e-02f,
  -8.16296041e-03f, 2.30448283e-02f, -8.62890631e-02f, -2.40009334e-02f, 8.00136477e-02f, 4.60280590e-02f, -2.24164072e-02f, 2.78953742e-02f, -2.15626135e-02f, 1.42937964e-02f,
  4.78220396e-02f, -5.21141253e-02f, 1.84870511e-03f, 2.71586282e-03f, 3.08166537e-02f, -6.77538291e-02f, -6.10912777e-02f, -3.61134075e-02f, -6.68181702e-02f, -1.37051949e-02f,
  6.42548800e-02f, -7.37677440e-02f, -9.01488960e-02f, -7.23315477e-02f, 7.62473717e-02f, -3.61754969e-02f, -2.66960990e-02f, 3.29855382e-02f, -7.55737275e-02f, -6.40698597e-02f,
  1.81507021e-02f, 4.34343405e-02f, -5.04073054e-02f, 1.78499185e-02f, 5.19788899e-02f, -8.07558671e-02f, -6.15470782e-02f, 2.61356533e-02f, 3.76550369e-02f, -1.38036273e-02f,
  -8.68020654e-02f, -6.60002083e-02f, -1.48560815e-02f, 3.01803201e-02f, -7.95693044e-03f, 9.11852643e-02f, 6.44705594e-02f, -1.81393009e-02f, -1.49374614e-02f, -5.13387099e-02f,
  -6.71708882e-02f, 3.97030376e-02f, 9.71122831e-03f, 6.42869482e-03f, -5.91487959e-02f, -3.07878442e-02f, -6.86626509e-02f, 4.28479910e-02f, -1.27709121e-03f, 8.94316211e-02f,
  6.82822093e-02f, 8.92805606e-02f, 4.60852608e-02f, -2.45072227e-02f, 1.45242205e-02f, 2.00091116e-02f, -8.67829844e-03f, 5.64178377e-02f, 4.25252458e-03f, -4.96281981e-02f,
  -1.45122157e-02f, -8.18535537e-02f, -4.51807976e-02f, 5.63880354e-02f, -8.14800803e-03f, 5.37698381e-02f, -3.38616525e-03f, -1.66064277e-02f, -1.00065202e-01f, 1.65619068e-02f,
  1.02744056e-02f, 2.12384183e-02f, 3.30191962e-02f, 4.73329574e-02f, -1.78157240e-02f, 3.44117027e-04f, -5.63765913e-02f, 2.25831438e-02f, 6.62814677e-02f, -6.37028664e-02f,
  2.76972800e-01f, -2.74520129e-01f, 1.37833759e-01f, 2.23320350e-01f, 1.71950340e-01f, 5.46621047e-02f, 2.32939020e-01f, 9.83226895e-02f, 3.05770725e-01f, -2.33616069e-01f,
  -1.15105852e-01f, -6.18483573e-02f, -2.79967617e-02f, -1.87927455e-01f, 2.34599620e-01f, 3.66632082e-02f, 1.68594550e-02f, -1.19947784e-01f, 2.59722787e-04f, 2.03670524e-02f,
  1.46896765e-01f, -2.19195217e-01f, -5.67336902e-02f, -2.09863499e-01f, -1.00297175e-01f, -1.22976921e-01f, -1.11449838e-01f, -1.36684710e-02f, -3.15833837e-01f, -4.28831652e-02f,
  -1.39646754e-01f, 5.48876673e-02f, 3.76157835e-02f, 2.46962681e-02f, 6.53401688e-02f, 6.70360448e-03f, 1.98735148e-02f, -3.83370854e-02f, -2.64179613e-03f, 7.81923458e-02f,
  1.43603571e-02f, -3.65844220e-02f, -2.04761233e-02f, 3.59826423e-02f, -3.11665889e-02f, -7.91555047e-02f, -5.44043817e-02f, 6.04042970e-02f, -4.28046071e-04f, 5.15814796e-02f,
  9.61647555e-02f, -4.11821082e-02f, -4.86289263e-02f, -1.59528218e-02f, 7.89198652e-02f, -1.64148565e-02f, 7.41189718e-02f, -4.80495952e-02f, 2.72317021e-03f, 6.95510283e-02f,
  -5.18898070e-02f, -7.08112046e-02f, -2.73726042e-02f, 4.87008393e-02f, 3.29806581e-02f, -1.83246192e-02f, -3.26333828e-02f, 3.60187218e-02f, 3.09134722e-02f, -5.91291785e-02f,
  2.81018089e-04f, 6.50134310e-02f, 1.39169199e-02f, -2.93406546e-02f, 1.49984434e-02f, 2.84523144e-03f, -1.23154307e-02f, 2.34080758e-02f, -6.53669937e-03f, 6.22936860e-02f,
  2.69197728e-02f, -1.42937806e-02f, -4.88898009e-02f, 4.96284254e-02f, -6.11929689e-03f, 2.96535101e-02f, -1.06109031e-01f, 4.55352999e-02f, 9.46312547e-02f, 1.05117401e-02f,
  -2.20812067e-01f, -2.72990376e-01f, -5.06860241e-02f, -7.89158568e-02f, -7.65459007e-03f, -1.01971313e-01f, -3.64839435e-02f, 5.76840565e-02f, -6.31417558e-02f, 5.57759888e-02f,
  -7.96986073e-02f, -1.88349281e-02f, -1.23592779e-01f, -1.61374290e-03f, -7.62970299e-02f, 3.66415605e-02f, -5.79926036e-02f, -7.98295587e-02f, -5.55060953e-02f, -9.11426544e-02f,
  -2.92028375e-02f, 7.08205700e-02f, 7.97302723e-02f, 5.06237894e-02f, -7.65487552e-02f, -4.02986929e-02f, 6.10375516e-02f, -5.51773980e-02f, -5.64633980e-02f, -7.96907768e-02f,
  1.45265907e-01f, -1.17830761e-01f, 1.62730575e-01f, -3.36218365e-02f, -7.85938799e-02f, -8.49867463e-02f, 2.62206048e-01f, -1.68727249e-01f, -1.78841472e-01f, -1.88821524e-01f,
  4.38089855e-02f, 1.18742265e-01f, 1.65646538e-01f, 4.22006175e-02f, 2.42185965e-01f, 5.29581942e-02f, -6.35101348e-02f, 5.68528771e-02f, -2.27270015e-02f, 4.01690714e-02f,
  -6.31602556e-02f, 7.49706253e-02f, 1.34100199e-01f, -3.35174836e-02f, -1.39025981e-02f, 8.48960783e-03f, -1.56762395e-02f, 1.61951974e-01f, -1.06532291e-01f, 8.66091624e-02f,
  -7.42548853e-02f, -1.05682416e-02f, 3.88668245e-03f, -8.77306685e-02f, 2.36584842e-02f, -6.99078068e-02f, 3.39114890e-02f, 8.89223367e-02f, -1.97900040e-03f, 4.45681512e-02f,
  7.91371837e-02f, -8.67809206e-02f, -1.26126602e-01f, 3.85565050e-02f, -4.15638536e-02f, -9.63945389e-02f, -1.45117296e-02f, -1.32226320e-02f, -5.14095016e-02f, -1.19025372e-02f,
  -5.84155470e-02f, -1.49668651e-02f, 3.09571507e-03f, -4.77660298e-02f, -2.58440170e-02f, 2.51552202e-02f, 8.79686326e-02f, 2.74696555e-02f, -5.77333309e-02f, -7.46905804e-02f,
  3.24932346e-03f, -1.52899260e-02f, 6.67318031e-02f, -3.72391008e-02f, -6.55156076e-02f, -1.15954161e-01f, 8.59194323e-02f, -5.35730645e-02f, -6.35046810e-02f, 3.69013217e-03f,
  2.12756880e-02f, -3.12158465e-02f, 8.39998247e-05f, 6.30889758e-02f, -3.07491552e-02f, 8.62230733e-02f, -1.81181077e-02f, -4.80746329e-02f, 2.94481497e-02f, -5.71831595e-03f,
  -6.92248493e-02f, -4.96181287e-02f, 4.45903093e-02f, 3.98081988e-02f, 6.94338754e-02f, 7.42587820e-02f, -3.57177258e-02f, 3.16570587e-02f, -5.42774536e-02f, 2.87695490e-02f,
  1.43250953e-02f, 1.32031366e-01f, -4.86943461e-02f, -2.30859853e-02f, -7.08584413e-02f, 4.35393378e-02f, 7.28012025e-02f, -4.38365825e-02f, -5.51634021e-02f, -2.64133066e-02f,
  3.64091843e-02f, 8.21186975e-03f, 3.71129513e-02f, 7.24404007e-02f, -1.93990450e-02f, 2.21645720e-02f, 3.39148529e-02f, -2.82605477e-02f, 5.41246310e-02f, -8.17826986e-02f,
  5.19852638e-02f, -1.15558282e-02f, -1.12146130e-02f, -9.27151293e-02f, -5.13590537e-02f, 4.09589969e-02f, -5.60650951e-04f, 8.05041790e-02f, -7.31241656e-03f, 5.42642623e-02f,
  6.34072497e-02f, -4.47912030e-02f, 1.39399059e-02f, 2.24058822e-01f, 1.36334121e-01f, 5.59704341e-02f, 2.29053006e-01f, 4.62226905e-02f, 3.13965678e-01f, -1.42409906e-01f,
  -7.77795911e-02f, -4.26858403e-02f, -5.99861406e-02f, 2.51878630e-02f, -1.62234809e-02f, 1.09724738e-02f, 6.11615777e-02f, 1.14606999e-01f, 1.55581415e-01f, -6.83801770e-02f,
  3.01933363e-02f, 7.58957043e-02f, 4.15141433e-02f, -1.45164803e-01f, 6.10598028e-02f, -7.78683573e-02f, -1.58284351e-01f, -3.94090414e-02f, 1.96691491e-02f, -5.19336760e-02f,
  -2.59289760e-02f, 6.52503967e-02f, 5.52155152e-02f, -8.05853978e-02f, -5.95319904e-02f, 8.81441012e-02f, -5.43060154e-02f, -2.36951038e-02f, -1.49318250e-02f, -5.63495979e-02f,
  -2.07967851e-02f, 3.62810504e-04f, 9.21251159e-03f, -4.81071733e-02f, 9.57791656e-02f, -1.96838174e-02f, 3.57776036e-04f, 9.31411311e-02f, -2.75979619e-02f, 4.99092713e-02f,
  2.07046736e-02f, -7.04568923e-02f, 2.84467451e-02f, -1.92644019e-02f, 1.20271463e-02f, 7.01563805e-02f, 8.00073892e-02f, -1.47268008e-02f, 1.13713425e-02f, 1.56100867e-02f,
  5.38832974e-03f, -1.81424934e-02f, -7.80795068e-02f, -3.72019038e-02f, -1.77703500e-02f, -2.70904135e-03f, -6.85696006e-02f, -4.89667896e-03f, -4.33578268e-02f, 9.20622237e-03f,
  6.20968416e-02f, -6.98096454e-02f, -2.00574249e-02f, -3.76334153e-02f, -7.58558661e-02f, 6.67981058e-02f, -2.47580633e-02f, 3.28389555e-02f, 7.64935315e-02f, 8.16199258e-02f,
  -8.33938494e-02f, -6.79831281e-02f, -5.12969606e-02f, -3.96632627e-02f, -1.66695192e-02f, -8.52498934e-02f, -8.42396729e-03f, 5.13253883e-02f, 5.10100722e-02f, -6.30098730e-02f,
  2.41599865e-02f, -2.13747397e-02f, -2.83940416e-02f, -1.16815511e-02f, -6.96384087e-02f, -2.70883441e-02f, 9.93464794e-03f, -7.27250427e-02f, -4.84320037e-02f, 3.25102061e-02f,
  -2.74517033e-02f, -7.74309412e-02f, 2.04398911e-02f, 6.46259030e-03f, 1.16951959e-02f, 8.14183056e-03f, -7.11780339e-02f, 4.26455364e-02f, -5.30029424e-02f, -9.48930308e-02f,
  2.81965844e-02f, -7.09646568e-02f, -3.35140526e-02f, 3.40315960e-02f, 7.33714551e-02f, -1.07503701e-02f, -7.59437680e-02f, -8.09453800e-02f, 4.43760678e-03f, 6.97999746e-02f,
  -4.60448086e-01f, 1.59119204e-01f, -3.61627154e-02f, -1.11383878e-01f, 5.53457215e-02f, -6.85666800e-02f, 4.33855802e-02f, 9.60919261e-02f, -3.62891145e-02f, 2.47908384e-01f,
  1.55251309e-01f, -1.52046874e-01f, 2.02264473e-01f, 2.19775051e-01f, -2.61192620e-01f, 8.65377784e-02f, 3.23189683e-02f, 2.09846953e-03f, 8.20521824e-03f, 7.31942942e-03f,
  -7.38798380e-02f, 8.22497904e-02f, 1.01699419e-01f, 1.65826738e-01f, -9.95709822e-02f, -1.83282226e-01f, -1.59028247e-02f, -2.18101647e-02f, 1.96675900e-02f, -1.88592041e-03f,
  -5.42295240e-02f, -1.25587940e-01f, -5.07900938e-02f, 6.65332132e-04f, -6.25340864e-02f, -5.18941060e-02f, -5.11865951e-02f, 2.47481484e-02f, -3.23889777e-02f, -8.21496993e-02f,
  -6.30725250e-02f, 2.41048615e-02f, -3.85492183e-02f, 8.58718082e-02f, -6.22078478e-02f, -6.34245649e-02f, 1.78221203e-02f, -7.26896664e-03f, 3.18766944e-02f, -4.99858707e-02f,
  -9.77640413e-03f, -1.22081470e-02f, -5.33285178e-02f, 6.32708846e-03f, -4.62106913e-02f, -1.75444453e-04f, -6.00429177e-02f, 1.09779835e-02f, -2.66392212e-02f, -7.39112198e-02f,
  1.58834662e-02f, -2.28163823e-02f, 1.06118634e-01f, -5.66740632e-02f, 3.59993912e-02f, 6.52553439e-02f, -2.21742038e-02f, -3.38043235e-02f, -9.85933468e-02f, 1.63091011e-02f,
  4.35577929e-02f, -7.08543509e-02f, 4.67424057e-02f, 2.93432549e-02f, -7.24605471e-02f, -6.12569973e-02f, -2.94214226e-02f, 6.00923263e-02f, -5.17752133e-02f, 5.78324832e-02f,
  2.68601589e-02f, -1.08519578e-02f, 7.64278695e-03f, -5.51288424e-04f, 2.55986657e-02f, -1.31883752e-02f, 6.94099888e-02f, 3.50081525e-03f, 5.23182228e-02f, -3.79626900e-02f,
  -1.75885171e-01f, -1.33406311e-01f, -3.09780389e-02f, -4.42471132e-02f, 3.55794504e-02f, -4.47872989e-02f, 4.10068221e-02f, -2.11478863e-02f, -7.62032568e-02f, -1.89941116e-02f,
  -4.06860374e-02f, 2.35496499e-02f, -9.46061462e-02f, 4.37505096e-02f, -2.49938276e-02f, -2.11403612e-02f, -6.06493913e-02f, -3.19131725e-02f, -8.59354064e-02f, 3.83224934e-02f,
  3.61745171e-02f, -1.17012660e-03f, 1.28152873e-02f, 6.86208904e-02f, 3.39718163e-02f, -2.22262051e-02f, -7.31776357e-02f, 3.40326615e-02f, -4.06034328e-02f, 4.85160528e-03f,
  -3.83611798e-01f, 2.27500752e-01f, -6.26439080e-02f, -1.03019871e-01f, -8.13379139e-02f, -6.09442145e-02f, -7.61930123e-02f, 6.75460175e-02f, -3.50765325e-02f, 1.31816670e-01f,
  6.41995519e-02f, -5.15246298e-03f, 1.43560246e-01f, 8.96621719e-02f, -1.63194224e-01f, 6.41025230e-02f, 4.26973123e-03f, 4.90362477e-03f, 5.74343316e-02f, -9.04695541e-02f,
  -1.08222127e-01f, 8.96568522e-02f, 5.19383661e-02f, 8.93087164e-02f, -5.49738891e-02f, 5.59250882e-04f, -9.35186893e-02f, 5.46583682e-02f, -1.11268774e-01f, -4.57981825e-02f,
  -9.07141864e-02f, -1.85064435e-01f, -1.00142822e-01f, -1.33498833e-01f, -1.08388133e-01f, -1.65823791e-02f, -7.58715048e-02f, 1.82712134e-02f, 4.12873849e-02f, -2.74463817e-02f,
  1.31111743e-03f, 3.81661346e-03f, -6.74152747e-02f, 9.84511375e-02f, 3.52371745e-02f, -1.76801309e-02f, 3.28018405e-02f, 1.38774309e-02f, -3.71524878e-02f, -6.06752522e-02f,
  1.70429470e-03f, -7.05123320e-02f, -2.80238059e-03f, -1.92515086e-02f, 1.56986937e-02f, 6.96355999e-02f, 5.54944463e-02f, 2.65130550e-02f, -5.10501005e-02f, -7.64930621e-03f,
  5.24798632e-02f, -4.38847812e-03f, 7.10106827e-03f, -1.34598427e-02f, 8.56125653e-02f, 1.25000859e-03f, 1.68844219e-02f, 8.24983865e-02f, 6.19922318e-02f, -6.67546764e-02f,
  -1.46021089e-02f, -1.19623952e-02f, 4.03897762e-02f, -7.53239170e-02f, -1.56465527e-02f, -2.53713075e-02f, 6.90472573e-02f, -3.81335244e-02f, -3.30990478e-02f, -3.89711075e-02f,
  -6.15772605e-02f, -8.36022943e-02f, 3.15097757e-02f, 7.12982044e-02f, 3.56436409e-02f, -2.72700135e-02f, 2.12582890e-02f, -4.95098680e-02f, -3.15889679e-02f, -4.30842154e-02f,
  -1.94564611e-01f, -1.54339552e-01f, -9.59499404e-02f, -1.67719387e-02f, -2.00322941e-02f, -1.47149544e-02f, 6.23270944e-02f, 9.07549448e-03f, -9.10387486e-02f, -3.27874022e-03f,
  -5.79277873e-02f, -1.66972727e-02f, -4.52328250e-02f, -6.30169734e-02f, 2.20654402e-02f, -2.12365054e-02f, -4.99288738e-02f, -3.69066335e-02f, -7.24823549e-02f, -8.50694105e-02f,
  -6.31711036e-02f, -2.20219158e-02f, -5.05195335e-02f, -6.40811026e-02f, -5.84319718e-02f, 2.44971109e-03f, -8.99814740e-02f, -3.93621027e-02f, -3.17474715e-02f, -7.47282803e-02f,
  3.08074802e-02f, -3.18473876e-02f, 1.61542132e-01f, 1.62271783e-01f, -4.64452654e-02f, -9.03119445e-02f, -3.60817015e-02f, -2.39942223e-03f, -2.94445343e-02f, -1.50991067e-01f,
  2.59705260e-02f, 1.17056025e-02f, -6.10661954e-02f, 1.06491037e-01f, 1.67062938e-01f, -4.36301120e-02f, 1.45120388e-02f, 3.27980667e-02f, -6.60051126e-03f, 1.52112646e-02f,
  1.23009741e-01f, 4.68282698e-04f, 1.18407279e-01f, -1.12449676e-01f, -2.73426194e-02f, 9.86366645e-02f, 7.77110979e-02f, 7.55824745e-02f, 4.62515652e-02f, 6.12529330e-02f,
  -4.57598232e-02f, 3.38774472e-02f, 4.72074486e-02f, -7.14206770e-02f, 3.95853184e-02f, 5.84966987e-02f, -5.04321754e-02f, 1.04492970e-01f, -3.09927929e-02f, -9.40568894e-02f,
  8.63177702e-02f, -7.16973022e-02f, -2.48317495e-02f, -3.05632632e-02f, 9.76126548e-03f, -6.66062310e-02f, -1.16151776e-02f, 1.24105755e-02f, -8.63734558e-02f, -2.88099889e-02f,
  -3.11822761e-02f, -8.01546425e-02f, 2.13212799e-02f, 6.92965463e-02f, 7.62802064e-02f, 6.40169233e-02f, -1.03107482e-01f, 9.92760956e-02f, 6.46565333e-02f, 1.72329489e-02f,
  -2.67313886e-03f, 4.12230678e-02f, 1.00168139e-02f, -7.77603686e-02f, 4.44698073e-02f, -8.54574069e-02f, -7.62096941e-02f, 6.33741096e-02f, 7.83779770e-02f, 7.56227821e-02f,
  -1.49830170e-02f, 7.42600635e-02f, 4.14239010e-03f, -6.76298365e-02f, -3.57599482e-02f, 3.89969498e-02f, -2.92449165e-03f, -1.28448242e-02f, -1.05459597e-02f, 5.95719144e-02f,
  -1.16194999e-02f, -5.22574177e-03f, 7.01893866e-02f, 6.78282604e-02f, 8.26802384e-03f, 1.65561419e-02f, -6.51185960e-02f, -2.76129153e-02f, 2.44468753e-03f, -5.36360592e-02f,
  5.56828566e-02f, 8.31561759e-02f, 3.22005413e-02f, 6.01214319e-02f, 7.37677068e-02f, 8.04756209e-02f, -3.55003886e-02f, -2.62091644e-02f, 6.47055358e-02f, 2.17023455e-02f,
  4.61219288e-02f, 2.31176075e-02f, -4.36821096e-02f, 6.37388788e-03f, -1.23436400e-03f, 7.60934651e-02f, 6.86564744e-02f, 6.36028685e-03f, -2.20161323e-02f, -7.86240026e-02f,
  -5.66471145e-02f, 7.09427819e-02f, 8.13562796e-02f, -7.33303279e-02f, 2.09830701e-02f, 8.70997086e-02f, -8.67282674e-02f, 2.41385102e-02f, 3.53547782e-02f, 8.19659457e-02f,
  2.09057152e-01f, 1.12158865e-01f, -5.41167371e-02f, -4.55396511e-02f, -1.24658555e-01f, 7.75490627e-02f, -3.34166028e-02f, 1.12489894e-01f, -1.27108425e-01f, 8.00443515e-02f,
  -6.57872204e-03f, -5.27342670e-02f, -9.03060511e-02f, 1.80013895e-01f, 7.76959807e-02f, 2.03236733e-02f, 1.95496023e-01f, 1.11653604e-01f, -2.16617435e-02f, 6.99043721e-02f,
  2.16293186e-02f, 1.82774857e-01f, 7.79517442e-02f, 1.28614500e-01f, 8.56798664e-02f, 7.41052926e-02f, -7.44415522e-02f, -3.41863669e-02f, 3.60344909e-02f, -7.05979615e-02f,
  1.00978576e-01f, 1.19864419e-01f, 6.89348429e-02f, -6.75293505e-02f, -4.35640477e-02f, 4.31539044e-02f, -3.45462002e-02f, -2.94848885e-02f, -9.17814597e-02f, -8.69840607e-02f,
  6.22002445e-02f, 4.75517474e-02f, 7.64073357e-02f, -8.89764130e-02f, 6.91810176e-02f, -6.34564385e-02f, -1.86527073e-02f, -7.77333230e-02f, 7.81449024e-03f, 1.23966165e-01f,
  -5.47430888e-02f, -7.01869354e-02f, -8.30944106e-02f, 2.03945991e-02f, -1.18408889e-01f, -1.75912138e-02f, 6.02495745e-02f, -2.80731563e-02f, -4.11754772e-02f, 4.32070857e-03f,
  3.70716825e-02f, -4.78881039e-03f, 4.45351154e-02f, 2.54732128e-02f, 5.21683646e-03f, 4.82732691e-02f, 2.43248083e-02f, -9.70460568e-03f, 5.63901402e-02f, 4.67801243e-02f,
  -4.00988907e-02f, -6.15527816e-02f, 5.78384399e-02f, -4.62233387e-02f, 4.73860726e-02f, -6.52719662e-02f, -4.29885052e-02f, -3.44425924e-02f, 2.47701835e-02f, 1.17050977e-02f,
  -1.12359561e-01f, 2.80175172e-02f, 5.10975346e-02f, -8.03062133e-03f, -1.99282188e-02f, -9.88425612e-02f, 6.95236819e-03f, -9.34133958e-03f, 8.43953248e-03f, -4.41128798e-02f,
  2.22249068e-02f, 3.28779779e-02f, -1.36121865e-02f, -7.58986026e-02f, 3.58981527e-02f, 1.65064588e-01f, -6.39436720e-03f, 1.17959484e-01f, 3.74275185e-02f, 1.20045632e-01f,
  -2.34148260e-02f, 2.31129304e-03f, -1.17899443e-03f, -3.04862577e-02f, -1.15262635e-01f, 5.04945330e-02f, -3.15273479e-02f, -2.11949088e-02f, -1.79371163e-02f, -5.56593612e-02f,
  2.86795069e-02f, 1.56168574e-02f, -4.51677963e-02f, -8.49545747e-02f, -5.80469519e-02f, -9.96251255e-02f, -7.69088119e-02f, -1.80202909e-02f, 4.46536066e-03f, -1.31288562e-02f,
  6.39176667e-02f, 8.01041424e-02f, 4.78476621e-02f, 6.76136911e-02f, -9.76708829e-02f, -6.57069758e-02f, -4.43115383e-02f, -5.11664839e-04f, -1.84409171e-01f, -5.11726625e-02f,
  7.37080351e-02f, -9.72866639e-02f, 1.06309280e-01f, 8.38979259e-02f, 4.08402868e-02f, 9.74622555e-03f, 5.83294779e-02f, -4.47688736e-02f, -3.91090736e-02f, 1.05590641e-01f,
  1.16041318e-01f, 1.67250589e-01f, 1.14212357e-01f, 1.58270895e-01f, 5.10112979e-02f, 5.04413396e-02f, 7.90910497e-02f, 1.26505375e-01f, -9.52159055e-03f, 2.16477048e-02f,
  4.04002750e-03f, 8.29940513e-02f, -1.87283456e-02f, 8.18303134e-03f, 5.41048609e-02f, 1.01191148e-01f, -5.92814945e-03f, 1.81258377e-02f, 6.28598109e-02f, 1.22832283e-02f,
  8.22302252e-02f, 1.50571791e-02f, 4.90105115e-02f, -5.20941056e-02f, -5.88610023e-02f, 6.25703186e-02f, 6.03284836e-02f, -6.51454553e-02f, -6.67791218e-02f, 1.11489452e-01f,
  2.70258095e-02f, 2.56048720e-02f, -1.44533152e-02f, -5.89386411e-02f, 4.24948595e-02f, -8.85716528e-02f, 2.82964986e-02f, 1.59732644e-02f, 6.96396902e-02f, -9.49400961e-02f,
  4.73681316e-02f, 6.96834028e-02f, -2.51765251e-02f, -4.11601476e-02f, -7.92821404e-03f, -4.09649860e-04f, 6.67940304e-02f, -7.89317414e-02f, -3.74542326e-02f, 2.50286306e-03f,
  6.83866218e-02f, 3.05399634e-02f, -7.05440342e-02f, 7.39693120e-02f, 9.88327060e-03f, -1.46772061e-02f, 4.82112058e-02f, -9.74565744e-03f, 6.11818172e-02f, -4.74205278e-02f,
  -1.03138173e-02f, -3.45206298e-02f, -8.15177187e-02f, -9.32676494e-02f, -3.96275409e-02f, -6.80760294e-02f, -5.25279641e-02f, -1.18002342e-02f, 6.06205873e-02f, 8.84706378e-02f,
  -1.35864737e-02f, 8.48547369e-02f, 6.95030987e-02f, -9.36968401e-02f, -3.77931669e-02f, 9.66103002e-03f, -5.40943108e-02f, -6.40864000e-02f, 7.30635524e-02f, -8.75820406e-03f,
  -4.14188765e-02f, -5.81511594e-02f, -2.72896755e-02f, -5.99805452e-02f, 2.97359750e-02f, 6.19296245e-02f, 7.08479062e-02f, -7.78976306e-02f, -3.79857682e-02f, -2.38658804e-02f,
  -5.86563013e-02f, -5.17774411e-02f, 1.90012157e-03f, -3.68032418e-02f, 6.35042638e-02f, 7.04749078e-02f, 7.67615624e-03f, 9.29975975e-03f, 3.68514955e-02f, 4.11994308e-02f,
  1.51382297e-01f, -4.18812752e-01f, 1.63473830e-01f, 1.86034501e-01f, 8.61506835e-02f, 1.27672136e-01f, 1.81354433e-01f, -6.46542832e-02f, -9.08142924e-02f, -3.54771107e-01f,
  6.75504804e-02f, -1.12860650e-01f, -3.39726396e-02f, 1.36749707e-02f, 1.93584487e-01f, -5.78190573e-03f, -5.80429705e-03f, 6.18387498e-02f, 1.40278051e-02f, 1.87086575e-02f,
  6.26470596e-02f, -6.49057655e-03f, 6.08098507e-02f, -1.87784448e-01f, 5.58236316e-02f, -6.81539550e-02f, -9.58058238e-03f, 1.20331042e-01f, 3.62215415e-02f, 1.14345558e-01f,
  -8.63616839e-02f, -8.16937760e-02f, -5.46642058e-02f, -5.16333207e-02f, -1.29568174e-01f, -7.16324523e-02f, 5.71121387e-02f, 1.16127782e-01f, 2.25556307e-02f, -2.74574813e-02f,
  -5.17665558e-02f, 8.12333226e-02f, 4.42481451e-02f, -1.94259975e-02f, 5.26461266e-02f, -1.99441388e-02f, 1.08089270e-02f, -5.12518436e-02f, 1.01076335e-01f, 7.94792175e-02f,
  1.55004654e-02f, -2.42073555e-02f, 2.68767569e-02f, -8.15285295e-02f, 2.90528107e-02f, 2.03186441e-02f, -4.57582623e-03f, 1.53745059e-02f, -7.86741003e-02f, 1.88438687e-02f,
  8.12039524e-02f, -5.14787361e-02f, -4.30915318e-02f, 6.39610663e-02f, 2.90282872e-02f, -1.87427849e-02f, -8.48289877e-02f, -2.71523148e-02f, -3.46055888e-02f, -2.88838539e-02f,
  -1.95235498e-02f, -4.38952707e-02f, 1.27534885e-02f, 2.85619739e-02f, 3.38634588e-02f, 2.96975467e-02f, 8.57457612e-03f, 5.03484011e-02f, 9.75194387e-03f, 2.39748545e-02f,
  -2.37268694e-02f, -3.80526073e-02f, 1.98242273e-02f, -1.06740035e-02f, -1.50753204e-02f, 1.89986713e-02f, -4.46393453e-02f, -8.38092342e-02f, 4.63805944e-02f, 5.53047322e-02f,
  -2.36275256e-01f, -1.29586816e-01f, -8.68193060e-03f, 2.81513538e-02f, -6.48888946e-02f, -2.65726130e-02f, -3.17332819e-02f, -8.76075178e-02f, 1.53510440e-02f, 2.28310004e-02f,
  -4.19089198e-02f, -4.62310314e-02f, -2.35981308e-02f, -6.44031763e-02f, 3.28830667e-02f, -5.63903339e-02f, 4.28223005e-03f, -8.61779079e-02f, -8.44628140e-02f, 2.54624225e-02f,
  3.06208227e-02f, -4.39380631e-02f, -3.98280546e-02f, -6.20025024e-02f, 2.86973938e-02f, -8.16193074e-02f, -1.41293695e-02f, 6.15894273e-02f, -2.79893260e-02f, 2.87485216e-03f,
  2.09497988e-01f, -1.57972977e-01f, -1.01374410e-01f, -3.86034064e-02f, 2.31721491e-01f, 1.84702352e-01f, -3.53968181e-02f, 9.91441086e-02f, 4.17851508e-02f, -5.89594431e-02f,
  1.87301964e-01f, -1.59289062e-01f, -2.71308601e-01f, 1.10525250e-01f, 6.99183047e-02f, -1.20883271e-01f, 1.63409978e-01f, -2.69989874e-02f, 4.66552339e-02f, 1.07856870e-01f,
  5.38055077e-02f, 1.36889711e-01f, -4.73285802e-02f, 1.02916047e-01f, 1.69227585e-01f, -7.04122037e-02f, 8.51408243e-02f, -1.27209187e-01f, 7.68268704e-02f, 8.61174837e-02f,
  8.09936896e-02f, -6.14038743e-02f, -9.06928480e-02f, -1.09415371e-02f, 8.06416124e-02f, -1.09760063e-02f, -1.03859544e-01f, 4.03439328e-02f, -3.02381888e-02f, 8.29540566e-02f,
  3.55871022e-02f, -3.14797275e-02f, 6.26699477e-02f, -6.08847197e-03f, 1.41440019e-01f, -4.63935696e-02f, 2.23287977e-02f, -2.52086166e-02f, -8.60560220e-03f, -7.91625381e-02f,
  2.46302504e-02f, 2.58430354e-02f, 3.19111787e-05f, -1.55575685e-02f, -2.19379906e-02f, 8.44372883e-02f, -4.26564850e-02f, -2.11103018e-02f, 7.43827969e-02f, 4.98040440e-03f,
  8.27430785e-02f, -6.77571148e-02f, -2.00832263e-03f, 5.69322407e-02f, 6.10880405e-02f, 1.08092196e-01f, -2.23972282e-04f, -1.59182362e-02f, 2.13326048e-02f, 4.01049443e-02f,
  4.56798263e-02f, -3.03592570e-02f, 5.06465994e-02f, 2.27607079e-02f, -2.30234712e-02f, -1.80773288e-02f, 2.94271354e-02f, -7.01912791e-02f, -3.28566246e-02f, -6.02617376e-02f,
  -1.85950007e-02f, -5.45471720e-02f, 8.83058384e-02f, 1.74184199e-02f, 2.54971385e-02f, -3.85962240e-02f, -2.96026189e-02f, 3.14179948e-03f, 6.29273131e-02f, -4.70325127e-02f,
  4.64731567e-02f, -2.21818518e-02f, -1.09353282e-01f, 1.30679132e-02f, 9.72261361e-04f, 1.59894973e-01f, 2.23202761e-02f, 2.84093935e-02f, -4.86148223e-02f, 9.94978696e-02f,
  7.31933909e-03f, -4.51994054e-02f, -4.10583317e-02f, -8.29610750e-02f, 1.74703076e-02f, 7.39688873e-02f, -4.26588319e-02f, -4.99543026e-02f, 5.19696809e-02f, -4.45069093e-03f,
  -5.56000844e-02f, 4.42064777e-02f, 7.14157969e-02f, 2.73443311e-02f, 4.22510505e-03f, 5.02842106e-02f, -3.76362354e-02f, -3.33831981e-02f, -1.05331372e-02f, -3.69297192e-02f,
  1.39536485e-01f, -5.03696762e-02f, 2.44417906e-01f, 1.31301746e-01f, 6.75506443e-02f, 1.53381303e-01f, 1.99964300e-01f, -3.48673426e-02f, 1.40735447e-01f, -2.18955606e-01f,
  -1.64744630e-01f, 2.27245539e-01f, -5.31613966e-03f, -1.54491691e-02f, 2.41832174e-02f, 5.30448519e-02f, 3.44684198e-02f, 1.20345809e-01f, 1.40463993e-01f, 6.41652569e-02f,
  -8.00513923e-02f, -1.08738519e-01f, 3.72832417e-02f, -2.03711718e-01f, -1.81586610e-03f, -7.99952000e-02f, -1.00887574e-01f, 6.42269775e-02f, -1.55704618e-01f, -3.76752242e-02f,
  5.85773624e-02f, 3.30559164e-02f, 4.50684652e-02f, 7.26499110e-02f, -1.23371124e-01f, 2.18198989e-02f, 7.19494000e-02f, 5.85120171e-02f, 3.64060141e-02f, -8.29249844e-02f,
  -3.63486931e-02f, 2.70048566e-02f, -3.20875458e-02f, 7.99082518e-02f, 1.61163637e-03f, -5.72728775e-02f, -2.16894969e-02f, 3.25252041e-02f, 1.16025403e-01f, 4.10479680e-02f,
  -2.98097581e-02f, -8.96816142e-03f, 4.53798249e-02f, 9.01275054e-02f, 8.49880055e-02f, 5.96701466e-02f, 6.31243140e-02f, 2.40768064e-02f, -1.67602208e-02f, -1.18651660e-02f,
  -4.46099468e-04f, 4.16746885e-02f, -2.45384350e-02f, -5.02646118e-02f, 5.50493710e-02f, -6.28413334e-02f, 3.68302763e-02f, -1.72062013e-02f, -5.14374338e-02f, -7.80162495e-03f,
  1.33618368e-02f, 2.67385319e-02f, -4.41849697e-03f, 6.95185876e-03f, -7.67828804e-03f, -4.98750471e-02f, -5.37052676e-02f, 4.06278484e-02f, 8.26525502e-03f, -3.08780354e-02f,
  -7.99917728e-02f, 1.32467169e-02f, -1.72424782e-02f, -4.71734628e-02f, -5.29264770e-02f, 1.00955237e-02f, -1.19518243e-01f, 5.59000634e-02f, 4.09039715e-03f, 1.44518400e-02f,
  3.41139212e-02f, -2.58120298e-02f, -3.10945679e-02f, -2.94112018e-03f, 3.30700092e-02f, -4.49855141e-02f, 8.58177617e-02f, -2.78721172e-02f, 9.93671492e-02f, 2.73150392e-02f,
  -1.53322490e-02f, 1.76177286e-02f, 2.18386538e-02f, -6.74345568e-02f, 5.11837751e-02f, -9.86587703e-02f, 2.42666877e-03f, 9.43760760e-03f, -5.49197011e-02f, 1.65080465e-02f,
  2.80521996e-03f, 7.28745311e-02f, -2.24525686e-02f, -9.31806862e-02f, 1.06031829e-02f, 2.54366416e-02f, 3.14411633e-02f, -2.49138288e-02f, -5.72435819e-02f, 7.93072432e-02f,
  -7.89640546e-02f, 1.94321021e-01f, -2.14790136e-01f, 2.75955703e-02f, 6.17881641e-02f, 1.11206286e-01f, 1.61966354e-01f, 1.11657299e-01f, 1.32804140e-01f, 2.37663448e-01f,
  7.97047392e-02f, 9.72450152e-02f, 6.99768811e-02f, 2.36588061e-01f, 1.02359332e-01f, 1.43387333e-01f, 2.73231983e-01f, 1.76057681e-01f, 6.09918684e-02f, 5.94017915e-02f,
  -4.76686470e-03f, 1.66313484e-01f, -1.33541152e-01f, 6.82460219e-02f, -2.15493571e-02f, -1.11120008e-01f, -2.75814477e-02f, -1.63729683e-01f, -1.20804384e-02f, 8.19083396e-03f,
  -4.39589731e-02f, 6.39135465e-02f, -4.68533523e-02f, 1.60595495e-02f, -1.43588539e-02f, -5.94327338e-02f, -3.15089733e-03f, -6.63498417e-02f, 5.83658274e-03f, -8.13221335e-02f,
  -5.88157400e-02f, 1.07890442e-02f, 1.19152695e-01f, 6.46006688e-02f, 2.70044468e-02f, -1.20433280e-02f, -7.19254315e-02f, -8.64079893e-02f, 2.77374219e-02f, -1.67346504e-02f,
  -6.49730116e-02f, 6.64984584e-02f, -8.94398317e-02f, -6.15971116e-03f, -7.49544352e-02f, -4.87918332e-02f, 1.87867191e-02f, 1.74241122e-02f, 1.60707496e-02f, 3.75546440e-02f,
  -1.06840366e-02f, 5.60403196e-03f, -5.13247475e-02f, 3.89803178e-03f, 5.52730598e-02f, -5.44616841e-02f, 6.15241565e-02f, -5.40998988e-02f, -9.08225700e-02f, 8.48762598e-03f,
  -3.54661196e-02f, 1.49608459e-02f, 1.93164628e-02f, 2.89182048e-02f, 2.80402377e-02f, -4.33278363e-03f, -1.63760334e-02f, 6.11205101e-02f, 4.29484844e-02f, -8.21585432e-02f,
  -6.88461736e-02f, 8.37423503e-02f, -8.37252289e-03f, -1.28825093e-02f, -2.07949281e-02f, -2.30700970e-02f, 9.37725380e-02f, -2.81526055e-02f, 2.57519949e-02f, 1.59554742e-02f,
  1.48247048e-01f, 8.32520947e-02f, 1.61509681e-02f, -5.01982272e-02f, -8.57746974e-02f, -5.27044199e-03f, 5.46987029e-03f, -5.34894206e-02f, 5.96571378e-02f, 4.23691198e-02f,
  2.09365040e-02f, -5.03038801e-03f, -1.78527534e-02f, -6.71365932e-02f, -4.38065790e-02f, 5.21663986e-02f, 3.15431841e-02f, -1.36341183e-02f, 3.39582488e-02f, -6.09022900e-02f,
  6.59422809e-03f, 2.36885622e-02f, 4.88886759e-02f, -2.71713361e-02f, -1.72955319e-02f, 3.68748754e-02f, 8.16126242e-02f, -6.78625926e-02f, 1.13351475e-02f, -5.07275164e-02f,
  -1.19524717e-01f, -1.24822922e-01f, 4.12544934e-03f, -2.42037460e-01f, 1.84668064e-01f, 5.38421720e-02f, -9.25138965e-02f, -1.02622658e-02f, -2.48845547e-01f, -4.33988273e-02f,
  -2.84812748e-02f, -1.51478708e-01f, 9.40668434e-02f, -1.24720477e-01f, -1.28373802e-01f, -1.29218102e-01f, -5.47969528e-02f, 3.17328684e-02f, -9.82717574e-02f, 7.81011283e-02f,
  -1.38343163e-02f, -6.13749400e-02f, -7.67207472e-03f, 1.25235274e-01f, 1.81799233e-02f, 7.88442865e-02f, 1.05770759e-01f, 7.78074116e-02f, 1.21580578e-01f, -9.81572643e-02f,
  -4.86513413e-02f, -1.11870080e-01f, -2.94683757e-03f, 3.93893607e-02f, 3.69452313e-02f, 3.65302227e-02f, 1.82226989e-02f, -6.67291433e-02f, -2.23652516e-02f, -2.12303065e-02f,
  4.81870063e-02f, 8.94812569e-02f, 4.25477466e-03f, -6.88722655e-02f, -9.14890245e-02f, 6.30723014e-02f, 1.83635429e-02f, -7.61487260e-02f, -1.68573298e-03f, -5.68177998e-02f,
  -2.26927102e-02f, 8.38441178e-02f, -9.63069126e-02f, 4.50990908e-02f, 2.34219347e-04f, -3.56975757e-02f, 7.02699348e-02f, 8.81218016e-02f, 6.05580769e-02f, 4.87886593e-02f,
  8.77940357e-02f, 1.07222043e-01f, -1.05585875e-02f, -9.01705772e-02f, -1.58782024e-02f, -5.18565029e-02f, 6.21255897e-02f, 8.59688446e-02f, 5.97141162e-02f, -2.33265925e-02f,
  -7.21262321e-02f, 1.11696646e-02f, -3.02005913e-02f, 2.20978707e-02f, 8.00462961e-02f, -4.35618917e-03f, 5.09838723e-02f, 7.10107833e-02f, 7.42620304e-02f, -7.00889602e-02f,
  -1.07554317e-01f, 3.10544129e-02f, -2.49016639e-02f, -6.10067509e-02f, -3.07700859e-04f, -7.54423300e-03f, 4.56828251e-02f, -7.47422352e-02f, -6.17914014e-02f, 8.66216645e-02f,
  6.78992271e-02f, 1.13906972e-01f, 3.44925784e-02f, -1.76740587e-02f, 1.80440303e-02f, 9.09091085e-02f, -6.00564154e-03f, -3.39766033e-02f, 7.61272386e-03f, -2.14108080e-02f,
  -3.56593765e-02f, -1.75583716e-02f, 2.25789808e-02f, -5.57893217e-02f, 7.54624754e-02f, 9.23887193e-02f, -3.21547873e-02f, -6.80041919e-03f, 2.56226510e-02f, 5.52519187e-02f,
  -4.21388000e-02f, -1.01942848e-02f, -1.00735538e-01f, -6.03781119e-02f, -5.75341694e-02f, 8.58269483e-02f, 5.43080866e-02f, 5.01662344e-02f, -6.53677271e-04f, -5.69872335e-02f,
  -1.38640970e-01f, 2.19901934e-01f, 2.53782541e-01f, -5.53067178e-02f, 5.01471162e-02f, 3.20390463e-02f, -7.41916001e-02f, 1.13478906e-01f, 2.32909083e-01f, 6.76405355e-02f,
  -1.31077334e-01f, 1.13845326e-01f, -4.75506037e-02f, 7.60177597e-02f, -9.14789364e-02f, -9.79638398e-02f, 3.09885200e-02f, -1.60823613e-02f, -4.03280975e-03f, -8.15939717e-03f,
  -1.03364959e-01f, -3.06538921e-02f, 7.74998665e-02f, 4.28254046e-02f, 4.16869344e-03f, -2.86229309e-02f, -2.04634234e-01f, 1.31920666e-01f, -2.43091080e-02f, -2.64070034e-02f,
  6.49002613e-03f, -1.17559647e-02f, 8.08558241e-02f, 1.41029432e-01f, 7.62559520e-03f, 5.19656390e-02f, -9.32788029e-02f, -7.57346675e-02f, -3.97288129e-02f, 2.87155714e-02f,
  -1.33197457e-02f, 2.46173572e-02f, -3.91695984e-02f, 7.74363056e-02f, 5.66255078e-02f, 3.21919695e-02f, 1.34488579e-03f, 1.10615352e-02f, 8.00485760e-02f, 1.29903764e-01f,
  -1.91694370e-03f, -4.97959815e-02f, -2.81570647e-02f, -7.74328634e-02f, 8.89831483e-02f, 5.56061789e-02f, -6.55954480e-02f, -4.50025573e-02f, 6.93783164e-02f, 8.19184929e-02f,
  7.78574497e-02f, 3.40810195e-02f, -2.72811782e-02f, 1.58403330e-02f, -1.89112965e-02f, -1.25511304e-01f, 5.74095473e-02f, -7.88010582e-02f, 4.47177887e-02f, 5.96611910e-02f,
  5.03659397e-02f, -5.61820306e-02f, -2.65407506e-02f, -9.24829170e-02f, 5.87745085e-02f, 1.60639193e-02f, -7.43439570e-02f, -9.78148952e-02f, 2.99657434e-02f, 7.78451562e-02f,
  -5.42315980e-03f, 1.95973273e-02f, 7.71782622e-02f, -1.26141712e-01f, 5.21462709e-02f, 3.42786983e-02f, 8.86498988e-02f, 3.35243084e-02f, 2.92200204e-02f, -1.94868017e-02f,
  -4.22804169e-02f, -2.62815189e-02f, 7.91154616e-03f, 4.92908694e-02f, 1.68454200e-02f, -5.79479598e-02f, 3.15221064e-02f, 1.08656576e-02f, -8.71728454e-03f, 7.06403702e-02f,
  -8.10113475e-02f, -4.00571264e-02f, 2.37628035e-02f, -8.69261399e-02f, -8.88540670e-02f, -8.86521190e-02f, -1.06669620e-01f, -7.45112300e-02f, -8.75806063e-02f, -3.92161869e-02f,
  4.22521196e-02f, 1.75837800e-02f, -7.35760704e-02f, -7.84259066e-02f, -7.06341788e-02f, -9.80524868e-02f, 2.57221479e-02f, -1.35080935e-02f, -2.97568757e-02f, 7.78755620e-02f,
  -1.44922078e-01f, 9.15588513e-02f, 3.06916386e-01f, -1.84870094e-01f, 1.17849886e-01f, 2.61892438e-01f, 6.88887239e-02f, -3.50224413e-02f, -1.83331892e-01f, -1.80044189e-01f,
  -8.14495385e-02f, -1.07656987e-02f, -1.02795660e-02f, -1.03222774e-02f, 9.28536728e-02f, 4.44071181e-02f, -4.48365100e-02f, -6.91744685e-02f, 1.13108456e-01f, -2.61869673e-02f,
  2.19146889e-02f, -1.20057970e-01f, 1.90169215e-01f, -2.07805056e-02f, -8.40980709e-02f, -1.88207135e-01f, -2.40486965e-01f, 5.79694174e-02f, -5.60886189e-02f, -1.68945990e-03f,
  -9.71994847e-02f, -6.92625567e-02f, -8.84919986e-02f, 1.26164015e-02f, -1.20178692e-01f, -6.00148886e-02f, 6.44658580e-02f, 4.03551124e-02f, 2.37974748e-02f, 4.33094576e-02f,
  -1.26769036e-01f, 8.72605592e-02f, 7.06452224e-03f, 1.36982305e-02f, 1.47892060e-02f, -5.28827533e-02f, 3.13013904e-02f, 6.47723675e-02f, 7.90897533e-02f, 1.03155836e-01f,
  6.08757213e-02f, -1.94099247e-02f, 6.22708462e-02f, 3.65758650e-02f, 1.11749182e-02f, 5.87494299e-02f, 3.24694030e-02f, 8.41412842e-02f, 1.10638954e-01f, 8.81485045e-02f,
  6.73455521e-02f, -2.23959666e-02f, -3.32172140e-02f, 3.15141976e-02f, -2.00168248e-02f, 6.22558780e-02f, -7.23734573e-02f, -7.00123757e-02f, -2.85300455e-04f, 6.00196458e-02f,
  -9.14573446e-02f, -6.51337132e-02f, -3.10484739e-03f, 8.38515237e-02f, -9.72799659e-02f, -7.45238811e-02f, 9.69917998e-02f, -4.21995856e-02f, 5.10912463e-02f, -4.67502140e-02f,
  -5.76013550e-02f, 1.15729570e-01f, -5.81764355e-02f, 4.51942161e-02f, -4.91372682e-02f, -2.99687963e-02f, -4.65373099e-02f, 9.95656773e-02f, -7.41932821e-03f, -4.52490039e-02f,
  -9.86841395e-02f, -1.36791334e-01f, -6.86704218e-02f, -1.23408288e-01f, -6.06423803e-02f, 2.04000957e-02f, -3.61357443e-02f, -1.40222479e-02f, -6.81921169e-02f, -7.34532475e-02f,
  3.78600545e-02f, 3.77340359e-03f, 6.39129728e-02f, 6.22803159e-02f, 6.48612529e-02f, -1.64501779e-02f, -2.47634873e-02f, -4.59757708e-02f, -4.66957949e-02f, 5.29035181e-02f,
  -3.08038909e-02f, -6.38585165e-02f, 5.78591563e-02f, -8.73150006e-02f, -6.40846491e-02f, -5.92821799e-02f, -5.55681586e-02f, -2.10177042e-02f, 8.56695026e-02f, -4.06756923e-02f,
  -1.26711354e-02f, -1.10946417e-01f, -1.63789123e-01f, -5.82295097e-02f, -1.37497082e-01f, -7.74547830e-02f, 1.08054399e-01f, -1.86508223e-01f, -2.25792024e-02f, 1.38953239e-01f,
  2.30727792e-02f, -2.61988919e-02f, 1.21917143e-01f, 1.03594244e-01f, 4.96742362e-03f, 2.42371008e-01f, 4.92511429e-02f, 1.24523059e-01f, -2.94129569e-02f, -4.21461500e-02f,
  -6.62255436e-02f, -1.23693421e-02f, 1.00950569e-01f, -2.11039022e-01f, -1.03616923e-01f, -1.79854378e-01f, 7.16972128e-02f, -1.02660120e-01f, 1.22557608e-02f, -5.42580448e-02f,
  -1.43487275e-01f, -1.78362891e-01f, 4.79940958e-02f, -8.00779462e-02f, -3.93296555e-02f, 2.33991928e-02f, 6.19416200e-02f, 6.80323616e-02f, 2.13680528e-02f, 2.71057780e-03f,
  -4.42096516e-02f, 1.66875965e-04f, -1.23226769e-01f, -4.34518270e-02f, -5.46185374e-02f, -8.24919268e-02f, -8.36524740e-02f, 4.86273542e-02f, -2.10552495e-02f, -4.14206348e-02f,
  -6.05330989e-02f, -5.99967688e-02f, -6.65057749e-02f, 1.08477242e-01f, 4.50570360e-02f, 3.47289853e-02f, 2.06302255e-02f, -3.98169458e-02f, -8.48455355e-03f, -3.98099832e-02f,
  4.94268015e-02f, 1.05213948e-01f, 7.36364648e-02f, 5.96504398e-02f, -1.39326714e-02f, 3.09672412e-02f, -4.84600924e-02f, 7.92930648e-02f, -5.17564379e-02f, 3.86198945e-02f,
  -3.45868021e-02f, -1.15472130e-01f, -5.66310994e-02f, -7.10387975e-02f, 3.11676413e-02f, 6.34227395e-02f, 4.95175906e-02f, -7.87360594e-02f, -1.86069810e-03f, 2.22309213e-02f,
  5.89678138e-02f, -3.59048024e-02f, 3.51752974e-02f, -2.57070996e-02f, 6.74419180e-02f, 8.69614258e-02f, -8.67284983e-02f, 2.52934769e-02f, -7.37184063e-02f, 3.08683328e-02f,
  -1.15815386e-01f, -1.88339025e-01f, -6.93372115e-02f, -6.17218092e-02f, 4.25402634e-02f, -3.04127485e-02f, 5.56436479e-02f, 2.15495601e-02f, 1.97471324e-02f, 3.12313456e-02f,
  3.71519476e-02f, 4.05646712e-02f, -1.51922274e-02f, 8.91689137e-02f, -3.02963406e-02f, -7.35660791e-02f, 8.25844333e-02f, 1.71432626e-02f, 3.57077345e-02f, 9.01628169e-04f,
  -3.54457125e-02f, 1.91210713e-02f, -7.17987716e-02f, -8.13736618e-02f, -5.99898258e-03f, 5.58450073e-02f, -8.53292644e-03f, -6.01838306e-02f, -1.16006602e-02f, -6.73151687e-02f,
  1.15467608e-01f, 1.18974254e-01f, 1.13760762e-01f, 1.41494736e-01f, 3.41321155e-02f, 4.27564345e-02f, 3.94516140e-02f, -6.58524856e-02f, -1.62514374e-02f, 2.65297070e-02f,
  -2.14394461e-02f, 1.93203822e-01f, -7.13099865e-03f, 2.76670381e-02f, -7.90749565e-02f, -2.61660535e-02f, -1.12623073e-01f, 9.74038243e-02f, -2.42050812e-02f, 6.30276948e-02f,
  -6.65115938e-02f, -1.97308362e-01f, -4.94764410e-02f, -1.72452599e-01f, 1.34988219e-01f, 8.26023445e-02f, -1.70308724e-01f, -1.17279235e-02f, 6.85887039e-02f, 1.02655089e-04f,
  -9.90194827e-03f, -1.53563097e-02f, 7.66912624e-02f, -3.63140367e-02f, -6.43563867e-02f, 3.16595212e-02f, 1.14974745e-01f, 6.71918169e-02f, 9.56058968e-03f, -8.71891342e-03f,
  1.34733357e-02f, -7.28211775e-02f, -6.61244988e-02f, -1.26403533e-02f, 4.91836518e-02f, -2.06652880e-02f, 9.14177746e-02f, -1.16446074e-02f, 8.91622901e-02f, 9.15633962e-02f,
  1.96707118e-02f, 1.11040570e-01f, -3.67556252e-02f, 5.16604036e-02f, -6.96306229e-02f, -1.79845244e-02f, 1.95288621e-02f, 1.04593530e-01f, 5.30277677e-02f, 4.87706214e-02f,
  3.85124125e-02f, -4.74256743e-03f, -3.96088883e-02f, 1.76563673e-02f, 2.52341590e-04f, -1.23880701e-02f, 2.88711283e-02f, -8.59639198e-02f, -1.79268867e-02f, 2.19218917e-02f,
  -2.10906416e-02f, -2.60252412e-02f, 1.67729519e-02f, -4.93522398e-02f, 3.55411135e-02f, 7.23308101e-02f, -5.64712137e-02f, -4.77632973e-03f, 5.58504499e-02f, 8.90041217e-02f,
  -4.78958488e-02f, 6.25549182e-02f, 8.02753866e-03f, 7.29604959e-02f, 5.31830229e-02f, 4.00998816e-03f, 3.65867652e-02f, 5.66840991e-02f, -2.43994202e-02f, 4.94173951e-02f,
  2.95289457e-02f, 2.40803044e-03f, 3.26071046e-02f, 4.62596072e-03f, 3.18595208e-02f, -7.08324760e-02f, -6.45247400e-02f, 4.14160751e-02f, -9.87725556e-02f, -6.31806031e-02f,
  -2.73606870e-02f, 8.48741308e-02f, -5.18700108e-02f, -7.05822185e-02f, -6.67484105e-02f, -7.44472165e-03f, -3.76853384e-02f, 7.41322190e-02f, -5.22860326e-02f, 4.47918512e-02f,
  -4.38920967e-02f, 8.40812624e-02f, 3.18738632e-02f, -4.70704511e-02f, -4.94980514e-02f, 2.16744691e-02f, 5.19478098e-02f, 7.26204887e-02f, 5.18054236e-03f, -7.82241672e-02f,
  3.64150405e-02f, -1.69741455e-02f, -1.58592209e-01f, -1.12953305e-01f, -2.93967724e-02f, -1.10866204e-01f, -6.60539120e-02f, -1.07656807e-01f, 1.03360862e-01f, 1.24793276e-01f,
  3.23087610e-02f, 6.95297644e-02f, 2.53864620e-02f, -1.69185355e-01f, -1.45365313e-01f, -4.53855433e-02f, -2.30059385e-01f, -9.98575613e-02f, 1.69666726e-02f, -8.98931548e-02f,
  -6.30913153e-02f, -3.79066579e-02f, -1.55236498e-01f, 8.51429030e-02f, -1.15295775e-01f, -6.91105500e-02f, 1.83566269e-02f, -6.15714258e-03f, -1.31669596e-01f, -8.40968043e-02f,
  -1.18083572e-02f, 9.31564346e-02f, -3.76601629e-02f, -1.02081701e-01f, -6.49644211e-02f, 4.34859209e-02f, -4.87318970e-02f, 6.16270490e-02f, -1.58283338e-02f, -4.60047740e-04f,
  8.22517648e-02f, -1.86510198e-02f, -2.06590649e-02f, -2.86112111e-02f, 7.59748966e-02f, 6.38543665e-02f, -5.52194007e-03f, -6.38332739e-02f, 8.34142324e-03f, -8.47219750e-02f,
  1.60019342e-02f, -1.07185198e-02f, 3.67828086e-02f, 1.17532397e-02f, 6.27579838e-02f, 7.23724253e-03f, -4.16974239e-02f, 4.21548150e-02f, -8.37115869e-02f, 2.39939671e-02f,
  8.69982585e-04f, 3.80045921e-02f, -7.37173632e-02f, 6.58827573e-02f, 8.58991817e-02f, -5.56241460e-02f, -4.27659489e-02f, -7.41228610e-02f, 7.80026838e-02f, 9.52058509e-02f,
  -6.06916770e-02f, 3.12508307e-02f, -2.32874099e-02f, 3.91437858e-02f, -2.72332933e-02f, -4.16540392e-02f, -2.56591290e-02f, 6.57202601e-02f, 1.85736939e-02f, -1.07027464e-01f,
  -2.66080815e-02f, -3.65575552e-02f, 1.53443338e-02f, 8.57129917e-02f, 4.62939925e-02f, -1.51913203e-02f, -7.28820041e-02f, -6.43453673e-02f, 7.43819699e-02f, 7.91179165e-02f,
  4.32075933e-02f, -2.60715149e-02f, -9.89114051e-04f, 7.88919702e-02f, -6.87420815e-02f, 6.92049861e-02f, 4.54436727e-02f, -3.21802609e-02f, -6.13924563e-02f, -1.37178856e-03f,
  4.13432494e-02f, -2.00410243e-02f, 4.54404876e-02f, 1.20284921e-02f, 2.66513298e-03f, -9.58082080e-02f, 8.77270699e-02f, 4.39402573e-02f, 7.33409449e-02f, 6.90537691e-02f,
  9.19498056e-02f, 7.59473303e-03f, -1.23542333e-02f, 5.86509071e-02f, 3.67430672e-02f, 3.18058021e-02f, 8.93188342e-02f, -5.84224351e-02f, 2.60206982e-02f, 1.60841439e-02f,
  1.80679142e-01f, -6.54584095e-02f, -2.49874353e-01f, -1.12191461e-01f, 4.77540903e-02f, 4.77639697e-02f, -6.00668825e-02f, -4.21189591e-02f, -4.03514467e-02f, 7.22436681e-02f,
  1.36295244e-01f, -2.95856427e-02f, -1.43636584e-01f, 5.72957508e-02f, 1.33545220e-01f, 8.04503448e-03f, 1.79045409e-01f, 1.70645893e-01f, -7.04680905e-02f, 1.25024058e-02f,
  -1.76309235e-02f, 2.38876253e-01f, 1.38947731e-02f, 4.02510054e-02f, 3.56319733e-02f, -9.95980576e-02f, 1.07457682e-01f, -1.05819434e-01f, 1.60231084e-01f, 1.88544363e-01f,
  -2.25273147e-02f, -6.47789687e-02f, -2.02101842e-02f, -2.15834267e-02f, -3.72944474e-02f, -6.90923557e-02f, -7.76062384e-02f, 4.24472801e-02f, 5.50969131e-02f, -3.24644819e-02f,
  1.36888623e-02f, -1.46631096e-02f, 1.02852598e-01f, 9.43367481e-02f, -4.40744832e-02f, -5.30305989e-02f, -3.87855209e-02f, 5.20464890e-02f, 7.93929864e-03f, 2.48075780e-02f,
  -2.98378859e-02f, -9.66095999e-02f, -1.22936117e-03f, 5.46260318e-03f, 2.35484987e-02f, 2.52309460e-02f, -2.09196862e-02f, 1.07412599e-02f, 4.92542423e-02f, 5.24981245e-02f,
  1.28070503e-01f, -1.96767841e-02f, 7.26023540e-02f, 6.85568079e-02f, 5.81490584e-02f, -8.03917870e-02f, 7.12216496e-02f, -7.68385231e-02f, -4.19533364e-02f, -3.99003327e-02f,
  -7.04161823e-02f, -7.33213797e-02f, -1.89386867e-03f, 3.08286399e-02f, 1.88334016e-04f, -6.66400120e-02f, -5.37171550e-02f, 2.08010506e-02f, 1.83031447e-02f, -1.22606814e-01f,
  -4.80269752e-02f, -1.46942576e-02f, -4.57030870e-02f, -9.44134817e-02f, 1.93104066e-03f, -2.33216621e-02f, 1.28759217e-04f, -3.07944436e-02f, 6.93885749e-03f, -3.11462488e-02f,
  9.02874619e-02f, 4.39767465e-02f, -9.87291560e-02f, 4.77915481e-02f, 1.49356376e-03f, -6.97522098e-03f, 4.94462810e-02f, -8.11722279e-02f, 3.63200903e-02f, -9.52949375e-02f,
  -6.69654906e-02f, 3.22691686e-02f, -5.08646443e-02f, 8.31908640e-03f, -5.32232933e-02f, 5.00599518e-02f, 9.65825915e-02f, 2.63217837e-02f, -2.97820698e-02f, -1.39325866e-02f,
  2.30604149e-02f, -9.69653800e-02f, -3.11065596e-02f, -6.23168750e-03f, 9.93911698e-02f, 4.74736327e-03f, -2.87362235e-03f, -6.22851737e-02f, -7.27626905e-02f, -3.09765749e-02f,
  -2.09505349e-01f, 8.08090940e-02f, -2.66912766e-02f, -4.64234613e-02f, 4.08324823e-02f, 3.78743745e-03f, -6.72391281e-02f, 3.65279987e-02f, 2.88228951e-02f, 1.88125506e-01f,
  9.17897075e-02f, -6.43956475e-03f, 1.45249411e-01f, -5.91449738e-02f, -1.58375129e-01f, -1.49185151e-01f, -1.30653143e-01f, -1.11037195e-01f, -4.34750356e-02f, -6.13375828e-02f,
  -1.49137795e-01f, -9.79334787e-02f, -1.99385837e-01f, 1.05806492e-01f, -1.04169928e-01f, 9.13797878e-03f, 3.50780711e-02f, 1.05629377e-01f, -4.48420234e-02f, 7.39502627e-03f,
  -7.20587522e-02f, -6.46353289e-02f, 2.99418624e-03f, 8.83466527e-02f, 8.67115930e-02f, 6.50495887e-02f, 8.85605626e-03f, -5.09301648e-02f, 2.47019064e-02f, -2.29220260e-02f,
  9.59435776e-02f, 4.62506749e-02f, -1.20469049e-01f, -2.27477867e-02f, 1.59812830e-02f, -2.89547816e-02f, 3.31744142e-02f, 1.04445092e-01f, -6.51509827e-03f, 4.61999215e-02f,
  1.43661322e-02f, 4.59432937e-02f, -3.81240919e-02f, -4.64633070e-02f, -7.20711499e-02f, -1.47630638e-02f, -7.87459686e-02f, -6.74545541e-02f, 4.85606305e-02f, -2.69639734e-02f,
  4.96495925e-02f, -6.01120181e-02f, -3.11916582e-02f, 1.00667402e-02f, -1.16655461e-01f, 2.69713588e-02f, -7.32350871e-02f, -7.25994259e-02f, -5.94365001e-02f, 8.02875161e-02f,
  -2.45597437e-02f, -7.62795508e-02f, 3.93446125e-02f, -5.29962294e-02f, -1.23617649e-02f, 6.30393326e-02f, 6.73226863e-02f, -3.69542204e-02f, -1.05948886e-02f, -6.93562999e-03f,
  1.70785058e-02f, -2.33920291e-04f, -1.24835782e-02f, -3.19024101e-02f, -6.06028326e-02f, -5.86709194e-02f, 4.19546030e-02f, -4.37367409e-02f, 9.02119726e-02f, -3.26328911e-02f,
  1.34712189e-01f, 1.22955769e-01f, 6.92244098e-02f, 1.28072605e-01f, 9.26080421e-02f, -5.42584732e-02f, 2.33965311e-02f, 2.43441500e-02f, 5.11391424e-02f, 5.65487053e-03f,
  5.45715317e-02f, -2.87542436e-02f, 3.88221107e-02f, -5.95860891e-02f, -2.47523608e-03f, -9.18262452e-02f, -2.93558724e-02f, 7.06101395e-03f, -4.07881215e-02f, 8.68388359e-03f,
  3.73128690e-02f, 9.61308256e-02f, 6.23744056e-02f, -4.60242927e-02f, 5.30258827e-02f, 6.83290139e-02f, 6.06863722e-02f, -5.53077348e-02f, 1.00449637e-01f, -3.49250510e-02f,
  2.30405018e-01f, -2.48308942e-01f, -9.08058435e-02f, -2.02703942e-02f, 1.25865459e-01f, -1.60202365e-02f, -2.74614766e-02f, -1.01062231e-01f, 7.06083775e-02f, -2.57192612e-01f,
  -1.22884035e-01f, -7.59770647e-02f, -2.02145353e-01f, -1.32554993e-01f, 1.15722835e-01f, -4.53410819e-02f, -8.07161182e-02f, -6.25904053e-02f, -1.04817655e-02f, -1.46356598e-01f,
  1.23068191e-01f, -9.74638984e-02f, 4.01493609e-02f, -3.66749950e-02f, -1.15335084e-01f, 5.67596406e-02f, -5.71236983e-02f, -7.89099708e-02f, -6.79024160e-02f, -8.20448995e-02f,
  3.59334499e-02f, 5.30031770e-02f, -2.95497142e-02f, 8.12178031e-02f, -4.46786657e-02f, -7.76171219e-04f, 3.97141054e-02f, 2.65985690e-02f, 1.02116063e-01f, -6.57412112e-02f,
  -3.96818295e-02f, 3.17594297e-02f, -7.35081360e-02f, -4.11246866e-02f, -2.01542005e-02f, -1.12142153e-02f, 3.38103510e-02f, 8.83965492e-02f, -6.09216243e-02f, -3.44045386e-02f,
  -1.03749476e-01f, 2.69798897e-02f, -4.13517281e-02f, -3.70107144e-02f, -6.59211054e-02f, 5.54157943e-02f, 2.61795279e-02f, 8.15129001e-03f, -3.85814370e-03f, -3.38162035e-02f,
  -7.46159926e-02f, 7.65823945e-02f, -1.68232098e-02f, -2.19510403e-02f, -2.06477642e-02f, -2.41321027e-02f, 6.55884817e-02f, -2.46001054e-02f, 6.26265481e-02f, -9.27837566e-02f,
  4.14681025e-02f, 1.28184480e-03f, -1.45954983e-02f, -7.36766979e-02f, 9.64368209e-02f, 6.25352263e-02f, -1.19667128e-02f, -1.79903209e-02f, -4.44693044e-02f, -4.23709117e-02f,
  4.64702165e-03f, 9.66402218e-02f, -8.32322389e-02f, -5.42265587e-02f, 3.77422222e-03f, 2.15707086e-02f, -9.03592817e-03f, -7.18381163e-03f, 1.05375372e-01f, 5.42109227e-03f,
  -1.49286371e-02f, -1.89069778e-01f, -3.24895941e-02f, 1.64825618e-02f, 9.10038408e-03f, 5.66660911e-02f, -5.00603728e-02f, 4.01683822e-02f, -2.35616835e-03f, 1.20009680e-03f,
  1.42795332e-02f, -2.89961156e-02f, 8.59149322e-02f, -5.43539859e-02f, 1.66862905e-02f, -4.25323285e-02f, -9.50593799e-02f, -5.29580899e-02f, -3.81701179e-02f, 4.08475241e-03f,
  3.50142345e-02f, -5.52931018e-02f, -9.82427783e-03f, -1.72876520e-03f, -8.10528547e-03f, -4.93168421e-02f, 2.64109913e-02f, -5.12424819e-02f, -1.47160366e-02f, -3.44494320e-02f,
  2.93248892e-02f, 1.52359173e-01f, 1.97359324e-02f, 4.94203679e-02f, 7.05622509e-02f, -1.22945905e-01f, 5.33660799e-02f, 3.77345976e-04f, -1.10408388e-01f, 1.14720717e-01f,
  -5.84757365e-02f, 7.72504359e-02f, 2.17852425e-02f, 4.96059023e-02f, -1.79290831e-01f, -1.72944874e-01f, -6.00822717e-02f, -6.85435534e-02f, 5.36094122e-02f, 1.17123365e-01f,
  -3.51779386e-02f, -8.07648525e-02f, 1.42660942e-02f, -2.07578894e-02f, 8.80139396e-02f, 1.54076532e-01f, 7.83600807e-02f, -1.54111171e-02f, 1.44497693e-01f, -8.63237381e-02f,
  6.72885254e-02f, 9.99461412e-02f, 5.40515035e-02f, -2.33338922e-02f, -4.72595692e-02f, 7.79819712e-02f, -3.92507501e-02f, -1.03569269e-01f, -9.90651548e-03f, -5.32396287e-02f,
  1.12696610e-01f, 1.73489060e-02f, -8.31080526e-02f, 6.58054128e-02f, 4.65858448e-03f, 9.94790867e-02f, 8.97755176e-02f, 6.34118319e-02f, 3.80386338e-02f, -1.41970394e-02f,
  -2.37940438e-02f, 6.85418993e-02f, 7.15639722e-03f, 6.92911167e-03f, 3.38436775e-02f, -9.55259707e-03f, -3.00076902e-02f, 4.24936749e-02f, 9.49972570e-02f, 5.94702959e-02f,
  9.79320630e-02f, -1.03375446e-02f, -7.17208609e-02f, 7.71065876e-02f, 1.35086104e-02f, 2.89049763e-02f, -5.16274311e-02f, -4.85963114e-02f, -7.56481811e-02f, -5.37261255e-02f,
  -1.85602494e-02f, 8.88559371e-02f, -5.87070733e-02f, -8.47325176e-02f, 6.12953342e-02f, 3.38826701e-02f, 3.16669047e-02f, 5.79800084e-02f, -7.49466047e-02f, 2.65665743e-02f,
  1.09995967e-02f, 1.52760521e-02f, -8.44676197e-02f, 2.64072884e-02f, 1.17016798e-02f, -4.95943464e-02f, 7.71421939e-02f, 7.21583888e-02f, 1.44569455e-02f, -3.22870053e-02f,
  -5.15492074e-02f, -4.26064106e-03f, -1.19307572e-02f, 4.50255089e-02f, -5.66021316e-02f, 6.70119599e-02f, -8.32696259e-02f, -8.18138346e-02f, 2.57592797e-02f, 8.03348375e-04f,
  9.75246429e-02f, -5.31362966e-02f, 7.07880780e-02f, 7.40837529e-02f, -2.68824566e-02f, 5.53615876e-02f, -9.81051475e-03f, -4.73578228e-03f, 1.28213968e-02f, -6.26325980e-02f,
  6.77584782e-02f, 5.42028099e-02f, 3.01075149e-02f, -3.15486342e-02f, 7.46003613e-02f, 2.88651884e-02f, -1.40638296e-02f, 7.54744783e-02f, 6.92659393e-02f, 4.25069295e-02f,
  1.23107456e-01f, 1.31203040e-01f, 1.94460019e-01f, 1.50461420e-01f, -5.13384193e-02f, -1.42954767e-01f, -1.37375131e-01f, 3.74540165e-02f, 3.85685563e-02f, 9.89459977e-02f,
  -8.33393708e-02f, 2.33007565e-01f, -8.98386836e-02f, 9.09949020e-02f, -6.48503052e-03f, -3.48151289e-02f, -3.70935462e-02f, -4.01555263e-02f, -1.51790837e-02f, 1.07868254e-01f,
  1.72727257e-02f, -7.50976279e-02f, 8.12037066e-02f, 4.46704030e-02f, 1.14342712e-01f, 2.06745401e-01f, -2.73905322e-02f, -6.44091610e-03f, 1.38799176e-01f, -5.82302585e-02f,
  -1.13205180e-01f, 6.72641024e-02f, 6.35033995e-02f, 2.39297803e-02f, -7.82965124e-02f, -8.67915303e-02f, 4.55676876e-02f, 2.10050661e-02f, 4.26521860e-02f, 3.69917825e-02f,
  4.98020323e-03f, 1.69850457e-02f, -4.80144694e-02f, -6.74453452e-02f, 4.64841723e-02f, -1.45504000e-02f, 9.05140340e-02f, 2.45402046e-02f, 3.70748267e-02f, -4.44126092e-02f,
  -5.18648885e-03f, 4.25539948e-02f, -2.61381380e-02f, -1.55529184e-02f, -1.92036051e-02f, -5.51046357e-02f, 9.80009884e-02f, -4.05249298e-02f, 6.52604213e-04f, 6.64100200e-02f,
  -3.16543318e-02f, -1.10271588e-01f, -4.85920087e-02f, -8.02964121e-02f, 1.93465445e-02f, 4.98139746e-02f, 3.81404273e-02f, 3.03548146e-02f, 7.21338764e-02f, -5.50570153e-02f,
  -7.96543714e-03f, -3.25751789e-02f, -7.92240500e-02f, -1.57362074e-02f, -2.03245934e-02f, -1.29486443e-02f, -3.71799506e-02f, 7.54366517e-02f, 2.76430752e-02f, 6.16747886e-02f,
  1.62159428e-02f, -8.20249841e-02f, 9.07673612e-02f, -3.34754139e-02f, -2.52308100e-02f, -8.94211326e-03f, 7.06974790e-02f, 9.35950056e-02f, 5.06514199e-02f, -8.43088776e-02f,
  -6.62777722e-02f, 1.61100999e-01f, -8.21152627e-02f, 7.14995563e-02f, 5.17595001e-02f, -5.23535497e-02f, 4.74325679e-02f, 7.22985789e-02f, -5.77461906e-02f, -7.81461596e-02f,
  -6.92304000e-02f, -3.24773714e-02f, 3.67639028e-02f, -6.47035465e-02f, -4.00111750e-02f, -2.64632553e-02f, 5.37984371e-02f, 8.04323331e-03f, 2.14536656e-02f, -3.71358469e-02f,
  8.00628066e-02f, -1.85605101e-02f, 4.10904624e-02f, 3.91639434e-02f, -4.85637970e-02f, -7.14857057e-02f, -3.35822664e-02f, 9.18288380e-02f, 1.49811180e-02f, -4.93926462e-03f,
  4.96158227e-02f, -6.01750240e-02f, -1.29749954e-01f, -7.81619549e-02f, 3.20340972e-03f, 1.70857489e-01f, 2.29801089e-02f, 6.16665045e-03f, -1.58674538e-01f, 7.73983225e-02f,
  3.17045338e-02f, -2.08245188e-01f, -1.39186978e-01f, -4.07967493e-02f, -1.35028198e-01f, -7.92291239e-02f, -8.75956267e-02f, -1.37819424e-02f, -8.63959715e-02f, 6.74779192e-02f,
  -1.06645875e-01f, 1.71444714e-02f, -1.21963501e-01f, 1.24659821e-01f, 7.83385262e-02f, 8.32712501e-02f, 1.02355622e-01f, 7.44768754e-02f, 7.17479438e-02f, -3.37779894e-02f,
  4.75336909e-02f, -7.11289868e-02f, -6.81281686e-02f, 3.42883430e-02f, 3.06295250e-02f, 7.80741870e-02f, 1.11210838e-01f, -3.60013209e-02f, 1.03414310e-02f, -7.90759474e-02f,
  -4.59913388e-02f, 7.44166076e-02f, -6.70232847e-02f, 1.66961877e-03f, 7.49183521e-02f, -6.71015605e-02f, -3.98286320e-02f, 5.03592677e-02f, -9.52377170e-02f, -6.97186887e-02f,
  -7.35846236e-02f, 2.66590454e-02f, 1.31508205e-02f, -5.91581240e-02f, -3.06397956e-02f, -9.76071358e-02f, -8.70521590e-02f, 5.00760935e-02f, -3.38588189e-03f, -5.77603132e-02f,
  5.05719744e-02f, 1.35889113e-01f, 7.07477629e-02f, -4.78250645e-02f, 6.81031793e-02f, -7.18709975e-02f, -1.51503249e-03f, -8.65454152e-02f, 2.36021355e-03f, -4.02212627e-02f,
  -7.54661858e-02f, -3.62874866e-02f, -7.59162381e-02f, 9.09389257e-02f, -5.45451455e-02f, 5.75302243e-02f, 2.97632683e-02f, -7.58529976e-02f, -6.62435144e-02f, 8.57527405e-02f,
  6.37714416e-02f, -5.87744899e-02f, -3.53659876e-02f, -1.78616680e-02f, -3.01258061e-02f, -6.26938418e-03f, 6.19891658e-02f, -5.52019030e-02f, -3.07539478e-02f, -4.22427766e-02f,
  2.82810237e-02f, 5.15064299e-02f, 6.89088851e-02f, 2.68436074e-02f, -6.88345805e-02f, 9.99229699e-02f, 8.34710225e-02f, 3.44030745e-02f, -7.66895637e-02f, -7.01898411e-02f,
  -2.04212461e-02f, 6.42051846e-02f, -2.67912820e-02f, 7.65135065e-02f, -5.05449697e-02f, -5.41939773e-03f, 2.53300858e-03f, 4.68055122e-02f, 2.20059766e-03f, -5.88538051e-02f,
  3.66416685e-02f, 4.43893746e-02f, -8.43518153e-02f, 4.36070142e-03f, -5.24134897e-02f, 6.71054944e-02f, 6.05014563e-02f, -3.83712053e-02f, -2.30374876e-02f, -5.66117913e-02f,
  1.40977651e-02f, 2.23105267e-01f, 2.15717748e-01f, -2.33270396e-02f, 2.49847975e-02f, 7.45005682e-02f, -7.47954175e-02f, 1.10149039e-02f, 1.08038731e-01f, 5.54886572e-02f,
  -1.29976422e-01f, 1.49852678e-01f, -1.23408943e-01f, -6.65188134e-02f, -5.83769158e-02f, -2.33964529e-02f, 5.88102750e-02f, 5.80119081e-02f, -1.02855889e-02f, -6.31511286e-02f,
  -6.37874603e-02f, -1.91491291e-01f, -9.81040746e-02f, -1.71602502e-01f, -8.11425783e-03f, 1.92232504e-02f, -9.97140929e-02f, -1.18226364e-01f, -3.22110504e-02f, 4.35145907e-02f,
  5.52593395e-02f, -3.94853242e-02f, 5.69875613e-02f, 1.16396084e-01f, 5.80754988e-02f, 3.03991865e-02f, -3.43243964e-02f, 6.99121654e-02f, 3.14613283e-02f, 8.54301900e-02f,
  5.26537485e-02f, -6.64044842e-02f, 7.95797557e-02f, -8.87084380e-02f, -3.92042585e-02f, 9.32831913e-02f, -2.71091051e-02f, 1.49895493e-02f, -3.62919532e-02f, 7.82972351e-02f,
  1.17323734e-01f, 7.99311046e-03f, 2.86892988e-02f, -1.23618748e-02f, -1.95823424e-02f, 6.18146919e-02f, 8.96387850e-04f, 1.22243591e-01f, 7.23281428e-02f, -6.47225901e-02f,
  -6.20652735e-02f, 1.84019879e-02f, -5.40809371e-02f, 5.44934943e-02f, -3.12860273e-02f, -8.09660703e-02f, -5.59985861e-02f, -7.28085935e-02f, -2.54480168e-02f, -4.24448255e-04f,
  2.09633317e-02f, -1.08770402e-02f, -4.75964323e-02f, 5.82212321e-02f, -4.74735126e-02f, 4.88952175e-03f, 4.10122536e-02f, 4.19762880e-02f, -2.02498864e-02f, -6.18471652e-02f,
  -1.38534635e-01f, -3.24794538e-02f, 3.54566723e-02f, 4.12727380e-03f, 2.42139809e-02f, 4.27332111e-02f, -8.80866603e-04f, 5.18017299e-02f, -8.85904655e-02f, -1.59048717e-02f,
  -4.61617261e-02f, 3.24563719e-02f, -1.44062890e-02f, 1.62595361e-02f, -9.52780545e-02f, 5.39747812e-02f, -2.59794686e-02f, 5.73834181e-02f, 2.18524970e-02f, -6.37334073e-03f,
  7.25620016e-02f, 6.08443208e-02f, 1.35582136e-02f, 5.49450889e-02f, 2.55898223e-03f, 7.36571401e-02f, -4.03261259e-02f, -7.41954073e-02f, -6.91964552e-02f, 2.95256190e-02f,
  8.72663632e-02f, -7.82167986e-02f, -3.98021080e-02f, 5.11196330e-02f, -1.11763570e-02f, -4.21378762e-02f, -2.61055846e-02f, 1.03317872e-01f, -2.73561478e-02f, 8.57098475e-02f,
  -7.28138834e-02f, 7.37335859e-03f, -1.67989776e-01f, 4.25028354e-02f, 4.99512963e-02f, 2.12289199e-01f, 3.34223062e-01f, -1.47809118e-01f, -1.41144231e-01f, 2.55038083e-01f,
  2.12036580e-01f, -6.85845241e-02f, 1.97732106e-01f, 1.70712247e-01f, 5.32024540e-02f, 2.13984355e-01f, 2.30113983e-01f, 2.37002999e-01f, -3.24452296e-02f, -9.03100893e-02f,
  -8.78500119e-02f, 9.90834981e-02f, 3.48994769e-02f, -8.40059146e-02f, 4.10877280e-02f, -2.19806015e-01f, -2.60386132e-02f, -2.64065377e-02f, 2.02692300e-02f, -2.19347291e-02f,
  8.28644261e-02f, 8.26660451e-03f, 9.08404123e-04f, -3.39207202e-02f, -5.42312339e-02f, 2.12394428e-02f, 1.10397398e-01f, 5.12412079e-02f, -2.73440266e-03f, -1.89866554e-02f,
  -2.27028616e-02f, 1.22998364e-03f, -3.21570262e-02f, 2.10312288e-02f, -7.65608251e-02f, -1.19992681e-01f, -7.44028389e-02f, 6.68244585e-02f, 3.64360167e-03f, -3.98936532e-02f,
  5.59053868e-02f, 2.22537983e-02f, -1.70359053e-02f, 7.55843669e-02f, -5.03038950e-02f, -7.52020553e-02f, 1.11576850e-02f, 9.63817537e-02f, -8.40105209e-03f, -6.83970228e-02f,
  -1.85678080e-02f, -2.56801629e-03f, -2.44317111e-02f, -2.28877529e-03f, 1.40797859e-02f, -5.16359434e-02f, 1.03457220e-01f, 2.56957114e-02f, -5.44218011e-02f, 1.01939090e-01f,
  5.03830649e-02f, 2.63949595e-02f, 3.81883699e-03f, -6.57449886e-02f, 2.29069660e-03f, 6.51473086e-03f, 3.93663794e-02f, 7.50332922e-02f, 6.02986105e-02f, -6.71872273e-02f,
  5.06177172e-02f, 1.53486645e-02f, 6.55770227e-02f, -5.02416156e-02f, 4.13453393e-02f, -2.78944913e-02f, -4.70182635e-02f, -1.64317768e-02f, 1.43140787e-02f, -8.10133014e-03f,
  5.83649091e-02f, -2.58054491e-02f, -1.34944944e-02f, -9.96699464e-03f, 1.97257884e-02f, 3.94712761e-02f, -5.52946329e-02f, -3.28638516e-02f, 3.83027568e-02f, 8.58372357e-03f,
  -2.56522167e-02f, 5.75013906e-02f, 6.28025457e-02f, 4.46437933e-02f, 1.54459970e-02f, 1.21710658e-01f, 4.18135747e-02f, -8.98346826e-02f, 2.82673445e-02f, -6.41977862e-02f,
  3.80617492e-02f, -3.62063497e-02f, -3.27384844e-02f, -5.62433153e-02f, -1.09113622e-02f, 5.18607534e-02f, 2.70784902e-03f, 6.24418519e-02f, -5.55726327e-02f, -2.98614688e-02f,
  -6.56596795e-02f, -2.91722625e-01f, -1.10757329e-01f, 1.46703869e-02f, 2.23838650e-02f, 4.04634662e-02f, -8.95877406e-02f, -1.56368583e-01f, -1.01349294e-01f, -1.49552643e-01f,
  -9.58917961e-02f, 8.05392787e-02f, -2.30138183e-01f, 2.26659223e-01f, 1.11619726e-01f, -4.01519313e-02f, 1.26930952e-01f, 4.61791642e-02f, 1.06471777e-01f, -1.19117893e-01f,
  5.03358878e-02f, 1.32485762e-01f, 7.01254606e-02f, 1.63391992e-01f, 2.62375325e-02f, 9.36580524e-02f, 1.85142476e-02f, -8.71471316e-02f, 2.36172765e-01f, 1.86813280e-01f,
  -1.67565830e-02f, -1.02052815e-01f, -9.49775521e-03f, -1.37193818e-02f, -3.88255753e-02f, -2.92530358e-02f, 8.90216380e-02f, -1.95387807e-02f, 7.67417103e-02f, -5.56000508e-02f,
  -1.58917364e-02f, 4.46568914e-02f, 9.68297124e-02f, 4.28781705e-03f, -7.22722267e-04f, 6.34934083e-02f, -5.68539053e-02f, -8.90343860e-02f, -5.82553893e-02f, 2.47639278e-03f,
  -9.26561840e-03f, -1.83545519e-02f, 2.50036307e-02f, 9.97537598e-02f, 4.95292544e-02f, 2.71779709e-02f, 4.33917604e-02f, 2.70228703e-02f, 8.68111625e-02f, -4.72445562e-02f,
  6.63767159e-02f, 4.03832868e-02f, 2.64080260e-02f, 6.38486398e-03f, 5.31445853e-02f, -3.26449834e-02f, 2.04083752e-02f, 6.21903613e-02f, 3.21023166e-03f, 7.78833264e-03f,
  -1.05798487e-02f, 4.87267710e-02f, 4.53119427e-02f, 2.55056866e-03f, 6.71016946e-02f, -4.88177463e-02f, 6.71582948e-03f, -4.52451333e-02f, -5.09644523e-02f, 6.96118176e-02f,
  -6.75681308e-02f, -3.18295211e-02f, -2.48322263e-02f, 7.78491646e-02f, -3.76483100e-03f, -5.02094850e-02f, -6.66061714e-02f, -5.02842590e-02f, -3.22799310e-02f, -5.60726486e-02f,
  -2.95279443e-01f, -2.97084242e-01f, -4.76733930e-02f, -9.72200707e-02f, -7.49395043e-02f, -7.97073618e-02f, -1.80716012e-02f, -2.94992756e-02f, -8.05467218e-02f, -6.06484525e-02f,
  -4.02688608e-02f, 2.24002916e-02f, -5.00827804e-02f, 1.16759734e-02f, 3.21682468e-02f, -2.32086144e-02f, -6.35630488e-02f, -5.80968373e-02f, -4.55369465e-02f, -6.19628131e-02f,
  -8.43092725e-02f, 2.67886426e-02f, 8.12531263e-02f, -5.16889431e-02f, 5.43755218e-02f, -6.85871765e-02f, -3.56381498e-02f, 2.34648213e-02f, 4.25748043e-02f, 7.71597028e-02f,
  -1.57205731e-01f, 1.33472666e-01f, -4.61775903e-03f, -6.97517884e-04f, 1.56062096e-03f, 1.27536263e-02f, -5.54113165e-02f, 5.81830516e-02f, -1.80404067e-01f, -2.02242937e-02f,
  -7.10713416e-02f, -7.15930536e-02f, 5.51708229e-03f, -4.01711538e-02f, 6.10234737e-02f, 2.78350636e-02f, 7.34660178e-02f, -9.79103893e-02f, 3.65592167e-02f, 1.30767882e-01f,
  9.82184112e-02f, -1.53484754e-02f, 5.72770424e-02f, 1.56447619e-01f, 4.97209057e-02f, 1.07934944e-01f, 4.54132035e-02f, 1.01527654e-01f, 3.10203545e-02f, -2.98797973e-02f,
  1.22489212e-02f, -6.10544719e-02f, -6.82817176e-02f, -1.49394590e-02f, 5.03271036e-02f, -7.10897967e-02f, 5.44574037e-02f, -6.45782128e-02f, -7.91186467e-02f, 3.40017714e-02f,
  3.51313781e-03f, 7.03437999e-02f, -9.78418067e-02f, -3.42894136e-03f, -1.57738477e-02f, 9.03156586e-03f, 2.49442575e-03f, 2.12338101e-02f, -7.33712763e-02f, 1.39693888e-02f,
  -5.46669140e-02f, -3.76535766e-02f, 9.08509493e-02f, -8.24330002e-02f, 3.86304259e-02f, 7.44137093e-02f, 1.86710395e-02f, -4.53356318e-02f, 6.43304810e-02f, 2.31500342e-02f,
  7.61720166e-03f, 3.39879394e-02f, 9.48112551e-03f, 4.35648561e-02f, -7.15789422e-02f, -7.42154717e-02f, -3.13694123e-03f, -2.66815163e-02f, -9.63078290e-02f, -3.77936438e-02f,
  3.57427471e-03f, 2.92502139e-02f, -5.38874138e-03f, 5.44379465e-03f, 1.36296805e-02f, 3.17464862e-03f, -5.90685569e-02f, -6.95503056e-02f, -7.59263756e-03f, 4.81291935e-02f,
  -2.18296517e-02f, 2.72205826e-02f, -2.98374649e-02f, 2.15024725e-02f, -1.04321837e-02f, 3.29215266e-02f, 5.51833399e-03f, -8.13177824e-02f, -1.95913948e-02f, 6.68609068e-02f,
  9.80518758e-02f, 5.20205423e-02f, -7.37669170e-02f, 4.73157596e-03f, -5.56119755e-02f, -2.54840925e-02f, -3.55786607e-02f, 4.37921807e-02f, -3.81816328e-02f, -2.67204084e-02f,
  -5.81870340e-02f, 3.34643051e-02f, -7.60608688e-02f, -8.79718289e-02f, 5.20454831e-02f, 3.17086279e-02f, -6.70734420e-02f, 1.12702232e-03f, -1.13957793e-01f, 1.97517257e-02f,
  5.12466803e-02f, -6.07178509e-02f, 1.59303993e-02f, -5.78680448e-02f, 5.08689471e-02f, 6.66578561e-02f, -1.18420776e-02f, -4.10238430e-02f, 3.84773277e-02f, -4.21665646e-02f,
  -9.01148934e-03f, 2.60020196e-02f, -6.20731525e-02f, -1.75321802e-01f, 9.30215344e-02f, -1.58975944e-01f, -9.01743919e-02f, 8.17846041e-03f, 6.04235753e-02f, -5.26317358e-02f,
  3.84174101e-02f, -7.10794553e-02f, 1.14737272e-01f, -5.79720773e-02f, 5.66719249e-02f, 5.67707270e-02f, -2.33383611e-01f, -1.05405070e-01f, -8.40498433e-02f, -1.99585691e-01f,
  -9.89347324e-02f, -6.38287514e-02f, -6.89880624e-02f, -5.36445752e-02f, -1.57635570e-01f, 2.57026535e-02f, -4.18388881e-02f, 1.05663829e-01f, -1.21657707e-01f, 3.38231996e-02f,
  -1.74822897e-01f, 1.12439049e-02f, -4.23792712e-02f, 2.79295221e-02f, -1.30530134e-01f, -7.83039704e-02f, -4.67020534e-02f, 7.57376030e-02f, -2.96090115e-02f, 1.22166174e-02f,
  -1.74220372e-02f, 3.91449109e-02f, -6.67878017e-02f, 6.25150800e-02f, 2.21359842e-02f, -2.92708706e-02f, 4.88751009e-02f, 4.18316424e-02f, -4.42439839e-02f, 7.64504224e-02f,
  -4.94819619e-02f, -6.15158118e-02f, 6.01968020e-02f, 5.28246863e-03f, -3.19746621e-02f, -5.15882522e-02f, 4.00762632e-03f, -2.83060614e-02f, -5.09096608e-02f, -1.70939714e-02f,
  1.72439672e-03f, -4.91301604e-02f, -2.23501101e-02f, -3.23710069e-02f, -4.80286665e-02f, 5.49394786e-02f, -1.20156510e-02f, -4.50894088e-02f, -5.83135746e-02f, 3.01493146e-02f,
  -1.56672597e-02f, -7.14411363e-02f, 5.61370179e-02f, -2.80399807e-02f, -1.60889644e-02f, -5.97063042e-02f, -1.01067154e-02f, 6.95752501e-02f, 2.66118795e-02f, -2.83800121e-02f,
  4.03498560e-02f, -2.79879272e-02f, 2.05293186e-02f, -5.05874716e-02f, 6.60961345e-02f, 9.42820683e-02f, -3.15987431e-02f, 3.87264043e-02f, 1.07306121e-02f, 8.19538310e-02f,
  -2.09550843e-01f, -9.72806215e-02f, -7.61292353e-02f, 3.53903770e-02f, -9.40603763e-02f, -3.69649567e-02f, 3.10608018e-02f, -1.55765414e-02f, -4.85938527e-02f, -1.57583470e-03f,
  3.99990268e-02f, -8.95190686e-02f, -7.05767572e-02f, -6.52840212e-02f, -4.90964763e-02f, 4.69399095e-02f, -8.76049995e-02f, 3.11116595e-02f, -1.54891154e-02f, -4.08585630e-02f,
  -6.04038918e-03f, 3.95955071e-02f, -2.73758285e-02f, -5.96975200e-02f, -8.96769464e-02f, -9.82901976e-02f, -4.14066687e-02f, -5.04572392e-02f, -4.55086343e-02f, -1.83380563e-02f,
  7.09491596e-02f, 6.06059004e-03f, -2.57677082e-02f, -2.36074887e-02f, -3.69746126e-02f, -2.56944671e-02f, 7.29254261e-02f, -5.30109927e-03f, 7.59018073e-03f, -9.73503739e-02f,
  2.94450633e-02f, 5.61773367e-02f, 1.63095474e-01f, -1.03846736e-01f, 8.19533914e-02f, 1.63158432e-01f, -1.23836108e-01f, -1.11714251e-01f, -6.45724535e-02f, -9.96993780e-02f,
  -5.38343675e-02f, -7.42868185e-02f, -1.19518854e-01f, -3.42232697e-02f, -1.48787796e-01f, -1.14438877e-01f, 2.57610604e-02f, 1.18226826e-01f, -6.83570057e-02f, 4.46886308e-02f,
  -1.40747204e-01f, -1.11875564e-01f, -5.86533993e-02f, 3.65289524e-02f, -3.30655761e-02f, -9.53547880e-02f, -4.74559292e-02f, 8.48521739e-02f, -3.58138643e-02f, -5.13189919e-02f,
  1.59817580e-02f, 1.04930483e-01f, -2.04321370e-02f, 5.25433458e-02f, -9.59902331e-02f, 3.86793874e-02f, -6.96933344e-02f, -5.16148936e-03f, -6.72696084e-02f, 5.65929059e-03f,
  -5.71597926e-03f, -9.68069397e-03f, -4.52923812e-02f, -2.21457612e-02f, -7.34193996e-02f, -9.33719128e-02f, -6.45498037e-02f, -3.21769714e-02f, -6.58108518e-02f, 4.80210371e-02f,
  2.89955549e-02f, 7.11115601e-04f, 4.72858455e-03f, -7.15505630e-02f, -3.79003473e-02f, 6.96299821e-02f, -5.01003005e-02f, 8.76876935e-02f, -3.67922857e-02f, -3.12547907e-02f,
  1.16695073e-02f, 9.99638718e-03f, 8.78471956e-02f, -9.16808620e-02f, 1.70566197e-02f, -7.41143674e-02f, -3.06997988e-02f, 5.91761805e-02f, -3.81172784e-02f, 3.95590551e-02f,
  8.95079598e-02f, -1.76604502e-02f, 9.63880122e-02f, 1.46613689e-02f, -2.83555612e-02f, 3.19314338e-02f, -1.86947025e-02f, 4.80746515e-02f, -4.35710549e-02f, -5.43570742e-02f,
  -9.28509012e-02f, -5.61439469e-02f, -7.12740421e-02f, -9.78688989e-03f, -4.61159348e-02f, 6.63571954e-02f, -2.55479906e-02f, -6.03477517e-03f, -1.54085346e-02f, -6.41856119e-02f,
  -1.90877169e-02f, -2.80921441e-02f, -4.03094552e-02f, -2.61192303e-02f, 3.56449373e-02f, 3.05686891e-02f, -2.87891999e-02f, -2.24354956e-02f, -2.85556652e-02f, -2.56735235e-02f,
  7.16923103e-02f, 2.48573124e-02f, -2.34369822e-02f, 4.37332317e-02f, 4.45088707e-02f, 3.04697324e-02f, -9.21371300e-03f, 5.12287486e-03f, -9.00476426e-03f, 4.38093841e-02f,
  3.79357897e-02f, -5.89823648e-02f, 4.00643889e-03f, -1.81251280e-02f, 1.21796481e-01f, 8.93346071e-02f, -1.84869915e-02f, 4.22321111e-02f, -9.77736712e-02f, -6.11822084e-02f,
  -8.09867010e-02f, -1.04519002e-01f, -9.32864919e-02f, 4.28847671e-02f, -1.30400598e-01f, -5.42732179e-02f, 3.28937620e-02f, -3.28461826e-02f, -8.19344148e-02f, -1.08844535e-02f,
  1.48712576e-03f, 1.24116518e-01f, -1.66993141e-02f, 6.87533766e-02f, 2.29628384e-02f, 7.33669265e-04f, 1.32381013e-02f, 7.80481324e-02f, 1.47041142e-01f, 3.46861482e-02f,
  -8.09887871e-02f, -1.27866268e-01f, -6.38995618e-02f, -8.58099535e-02f, 1.03405625e-01f, -3.39131393e-02f, -2.41419468e-02f, -2.25089453e-02f, -5.75412139e-02f, -8.83900374e-02f,
  6.65380135e-02f, -1.21412948e-02f, 3.49953063e-02f, -8.41284543e-02f, 7.98552781e-02f, -3.35151330e-02f, 8.29631314e-02f, 8.26415196e-02f, 3.61857712e-02f, -9.93188545e-02f,
  -3.15843485e-02f, -6.44343123e-02f, 9.57202911e-03f, 3.13314050e-02f, -1.47706857e-02f, -1.57288741e-02f, -2.15167515e-02f, -4.99077626e-02f, 7.75903240e-02f, -2.04287283e-02f,
  6.16843440e-02f, 9.91555005e-02f, 3.94515544e-02f, 3.05695646e-02f, -2.41715070e-02f, -2.70376750e-03f, 2.94674020e-02f, -7.05347359e-02f, 5.33405319e-02f, -5.04615866e-02f,
  -2.13112105e-02f, -7.13962317e-02f, 4.47385497e-02f, 5.79414554e-02f, 1.12145906e-02f, 1.35219162e-02f, 4.42013331e-02f, 8.58405903e-02f, 4.47139181e-02f, 7.85335973e-02f,
  6.77711368e-02f, 3.95155977e-03f, 2.14329399e-02f, -7.31063560e-02f, -8.31614807e-02f, -1.95660144e-02f, 1.44753829e-02f, 4.55714064e-03f, 7.62048811e-02f, 7.26927668e-02f,
  9.66704823e-03f, 3.24587040e-02f, -3.72883305e-02f, 2.55241599e-02f, 9.17486176e-02f, 1.08097635e-01f, 6.46887124e-02f, -7.76712820e-02f, 6.84787259e-02f, 4.64926325e-02f,
  -3.55386510e-02f, -7.92134553e-03f, -4.35072044e-03f, 7.37124979e-02f, -1.44824469e-02f, 6.33580238e-02f, -5.15691098e-03f, 8.24600011e-02f, 8.00309628e-02f, 1.23785008e-02f,
  1.03477351e-01f, 3.31075490e-02f, 4.26165834e-02f, 9.70464423e-02f, -1.27162598e-02f, 7.49952868e-02f, 6.38081953e-02f, 3.33835334e-02f, 4.12153043e-02f, 7.16481060e-02f,
  1.05534568e-02f, -1.67910963e-01f, 1.12870649e-01f, 6.81116283e-02f, 1.96427345e-01f, 1.69364870e-01f, 1.35663435e-01f, 5.77305891e-02f, -1.53346986e-01f, -1.45185977e-01f,
  3.49575095e-02f, -4.06812243e-02f, -1.30482912e-01f, -3.56289558e-02f, 3.05273116e-01f, 6.72229454e-02f, 1.18509037e-02f, 6.58705458e-02f, -5.41732237e-02f, -1.10748008e-01f,
  -4.57190089e-02f, 6.73923641e-03f, 8.93834457e-02f, -4.99473512e-02f, 1.44777909e-01f, -1.17574096e-01f, 3.88862714e-02f, 1.16933517e-01f, 4.42397855e-02f, 1.80837959e-01f,
  9.42218006e-02f, -1.43782631e-01f, -9.64732096e-03f, -1.89822987e-02f, 6.66749701e-02f, 7.94380307e-02f, 3.70466821e-02f, 1.51054099e-01f, -1.09283682e-02f, 1.99926421e-02f,
  -4.38209958e-02f, 7.45715275e-02f, 1.73025783e-02f, 2.22661463e-03f, -9.58460271e-02f, 6.84835389e-02f, -2.78591085e-02f, -5.97647652e-02f, -8.51653218e-02f, 6.09368458e-02f,
  3.78523581e-02f, 3.95661779e-02f, 8.33595693e-02f, 9.80285779e-02f, 9.20710489e-02f, -7.47554824e-02f, -1.03099681e-02f, -2.24764831e-02f, -4.96290103e-02f, -2.00293381e-02f,
  -2.29612999e-02f, -7.90158287e-02f, 1.64707135e-02f, -1.47946214e-03f, -1.97542310e-02f, 5.64618334e-02f, -5.14372326e-02f, -2.99598556e-02f, -4.33866978e-02f, -3.99226276e-03f,
  -3.59141156e-02f, 1.01713181e-01f, 4.19145152e-02f, 1.94334481e-02f, 2.11957153e-02f, -6.50394335e-02f, -1.91662628e-02f, 7.13956431e-02f, -4.79229838e-02f, -1.24833388e-02f,
  -1.47826616e-02f, -5.87693751e-02f, 5.58202118e-02f, 2.37431712e-02f, -3.44386920e-02f, -8.03408995e-02f, 4.58531926e-04f, 4.72744144e-02f, -1.03172205e-01f, 9.92972180e-02f,
  -1.62520394e-01f, -2.84410924e-01f, -3.17890979e-02f, -5.38285859e-02f, -2.32191347e-02f, -2.25601867e-02f, -5.15559576e-02f, 3.57833207e-02f, -1.17481515e-01f, -6.42985851e-02f,
  6.04894049e-02f, -5.30291395e-03f, 6.22117519e-02f, -2.48854645e-02f, 2.42381673e-02f, 5.31689636e-02f, -6.74984306e-02f, 2.99275964e-02f, 1.13246357e-02f, -2.78551243e-02f,
  7.37390518e-02f, -8.61863866e-02f, 9.78195444e-02f, 9.02576372e-02f, -7.50349984e-02f, -6.90893456e-02f, 7.98082277e-02f, 1.14817042e-02f, 7.79855922e-02f, 5.39935119e-02f,
  -5.30619323e-02f, 1.12121657e-01f, -6.92972690e-02f, 4.97204624e-02f, 8.63418505e-02f, -1.69523135e-01f, -9.37042385e-02f, 7.48602673e-02f, 8.38604644e-02f, 9.08709466e-02f,
  1.58202983e-02f, -1.50379026e-02f, -2.77165323e-02f, -1.10971421e-01f, -3.74057144e-01f, -2.61748582e-01f, -2.58631766e-01f, -1.67795718e-01f, -6.95915148e-02f, -6.28300160e-02f,
  -1.51358619e-01f, 1.28636897e-01f, -1.42254040e-01f, 1.08042717e-01f, 1.61960945e-01f, 1.74122095e-01f, 3.71957421e-02f, 2.11215943e-01f, 6.67273402e-02f, -1.81447882e-02f,
  1.99624337e-02f, 8.72030631e-02f, -2.25288924e-02f, -5.94465397e-02f, -1.36302020e-02f, 4.93948422e-02f, 3.14458599e-03f, 2.53839288e-02f, 3.08561493e-02f, 6.05641864e-03f,
  -6.20739944e-02f, 6.18128665e-02f, 9.05941799e-02f, -2.18232535e-02f, 1.28966033e-01f, 2.34924592e-02f, -5.56186736e-02f, -2.12170556e-02f, -6.72267517e-03f, -2.38312408e-02f,
  1.49746351e-02f, -1.52508086e-02f, 1.87275354e-02f, -9.29786041e-02f, -8.20120499e-02f, 1.18602319e-02f, -7.63625875e-02f, -9.33128595e-02f, 4.09651697e-02f, -6.99727982e-02f,
  2.89446320e-02f, 3.68554965e-02f, 2.39057168e-02f, 1.02192663e-01f, 2.03445125e-02f, 6.73580617e-02f, 9.14846659e-02f, -6.93806112e-02f, 8.63825381e-02f, -2.20861076e-03f,
  9.11407098e-02f, -5.74823804e-02f, -3.76258902e-02f, -7.00996956e-03f, -1.80713627e-02f, -2.74264044e-03f, -4.87596095e-02f, -2.77178716e-02f, -2.82069650e-02f, -5.74313439e-02f,
  8.90288427e-02f, -5.46822436e-02f, -2.52408870e-02f, -3.85519154e-02f, 4.24860902e-02f, 2.79632453e-02f, -2.64326315e-02f, -7.03899330e-03f, -1.56597490e-03f, 9.72816721e-03f,
  -1.11409232e-01f, -8.74861851e-02f, 9.16325450e-02f, 1.28984675e-01f, -3.71737257e-02f, -1.92535091e-02f, -3.72696109e-02f, 4.41586562e-02f, 1.11273509e-02f, -2.83222646e-02f,
  -6.90089017e-02f, 1.88319031e-02f, -3.71682644e-02f, -1.09000644e-02f, -1.37164164e-02f, 3.14823650e-02f, 2.80545391e-02f, -4.23752628e-02f, 1.63664054e-02f, -3.79442759e-02f,
  -2.22695861e-02f, 9.70146954e-02f, -3.92073914e-02f, 8.27662349e-02f, 8.22701082e-02f, -4.31629345e-02f, 4.10343632e-02f, -3.95624712e-02f, 3.44523378e-02f, 8.03454220e-03f,
  3.17792036e-02f, -2.90255714e-02f, 1.66278984e-02f, -1.27724394e-01f, 4.48695868e-02f, -3.12539972e-02f, -3.53438631e-02f, -2.41805408e-02f, -4.48824205e-02f, 1.43365175e-01f,
  1.05158173e-01f, -1.94522701e-02f, 5.83544113e-02f, 4.94054928e-02f, 3.49335819e-02f, 5.98271005e-02f, 5.83966412e-02f, 1.08729653e-01f, 2.95496043e-02f, -6.42950982e-02f,
  -2.64304243e-02f, 7.16411695e-02f, 3.02070118e-02f, 5.57876378e-02f, 1.02195032e-01f, -3.69907469e-02f, -6.92603663e-02f, -1.16965182e-01f, 1.40731651e-02f, -6.92921877e-02f,
  1.14893019e-01f, 1.89071912e-02f, 2.88408343e-02f, -8.49129036e-02f, 1.11575864e-01f, 1.04847535e-01f, 6.61460683e-02f, 2.40691826e-02f, -5.23073226e-03f, -6.03467114e-02f,
  6.18087500e-02f, 3.07160746e-02f, -4.32101674e-02f, -1.22109251e-02f, -8.37189108e-02f, -7.81217068e-02f, -1.10031129e-03f, 8.11267868e-02f, 7.40722194e-02f, -2.49102917e-02f,
  3.89070362e-02f, 5.23732479e-06f, 6.24391362e-02f, -3.32478695e-02f, 4.06266339e-02f, -2.28583603e-03f, -3.64584029e-02f, 7.22428411e-02f, 2.05415543e-02f, 3.38639715e-04f,
  -4.61791344e-02f, 2.62997989e-02f, -1.60064567e-02f, -5.58557399e-02f, -6.50029406e-02f, -8.77018087e-03f, 3.59899700e-02f, 4.89147156e-02f, -1.16586499e-01f, -6.92181066e-02f,
  3.10287881e-03f, 2.28190813e-02f, -3.62942889e-02f, -9.07896534e-02f, -4.55914661e-02f, -5.21432310e-02f, -7.44535327e-02f, 4.55291867e-02f, 1.88149174e-03f, 4.74615656e-02f,
  -3.13397241e-03f, -5.09755239e-02f, 2.72535086e-02f, -1.35811064e-02f, 8.79535154e-02f, 1.30690911e-04f, 2.92332401e-03f, 5.75829372e-02f, -4.60866280e-02f, -1.61874201e-02f,
  1.49722556e-02f, -3.83927561e-02f, 6.86905608e-02f, 1.30833648e-02f, -5.42839542e-02f, 7.87728950e-02f, 7.29329884e-02f, -2.02290807e-02f, -4.73605916e-02f, 1.01787120e-01f,
  -5.02393469e-02f, -3.07686273e-02f, 7.91056976e-02f, -7.37331212e-02f, 3.60978581e-02f, 1.10813394e-01f, 5.22726662e-02f, -9.75052938e-02f, 2.65683606e-02f, -5.30304760e-02f,
  -5.02638929e-02f, 3.28435041e-02f, -8.66066739e-02f, -3.60870324e-02f, -1.03731807e-02f, 6.35599270e-02f, 6.04426749e-02f, 4.29073796e-02f, 3.53233553e-02f, 5.09610809e-02f,
  -2.08553895e-01f, 1.59821689e-01f, 8.15647542e-02f, -3.05044577e-02f, -2.52927113e-02f, -7.18928054e-02f, -2.16726810e-02f, -4.87937331e-02f, -6.99784681e-02f, 1.80245284e-02f,
  3.94318588e-02f, -1.44043677e-02f, 2.83282511e-02f, 1.12930588e-01f, 6.37076497e-02f, 1.25657246e-01f, 9.68488604e-02f, 2.66133007e-02f, 8.74079484e-03f, 2.15705577e-02f,
  8.33111256e-02f, -8.03432195e-04f, 1.60157278e-01f, 1.08421095e-01f, 1.20290697e-01f, -3.44787836e-02f, 3.41272391e-02f, 9.88841206e-02f, 1.00296456e-02f, 1.48856062e-02f,
  -1.19590446e-01f, -8.30327123e-02f, 7.45780170e-02f, 7.87486807e-02f, 9.03330371e-02f, 4.99853827e-02f, -4.29029614e-02f, -2.05353945e-02f, -1.18865948e-02f, -2.11275518e-02f,
  1.89746860e-02f, 6.50597736e-02f, -1.12087575e-04f, -3.95500921e-02f, 5.05224951e-02f, 3.47129814e-03f, -3.33561637e-02f, 3.04250438e-02f, 4.14747298e-02f, 2.18528253e-03f,
  9.79409069e-02f, -4.51540400e-04f, -3.51936333e-02f, 4.27301787e-02f, -1.89557932e-02f, 1.97705962e-02f, -1.60470400e-02f, 2.52281353e-02f, 1.73775796e-02f, 3.88475209e-02f,
  2.47747060e-02f, -4.16004397e-02f, 2.97500715e-02f, -2.22810805e-02f, -4.31187674e-02f, -6.42673522e-02f, 7.95597509e-02f, 3.36087123e-02f, 3.00393607e-02f, 4.42567579e-02f,
  -5.06948195e-02f, 5.67200640e-03f, 3.78310937e-03f, -7.10642636e-02f, -3.83406878e-02f, 3.16858403e-02f, 8.14450830e-02f, 2.77349390e-02f, -1.75287891e-02f, 6.62540197e-02f,
  -2.11534910e-02f, -5.87657429e-02f, -5.09753637e-02f, 7.41873682e-02f, -4.09981869e-02f, -4.41357940e-02f, 6.24044016e-02f, -1.00015523e-02f, -7.01705292e-02f, 1.61881130e-02f,
  -1.31305650e-01f, -6.81979433e-02f, -4.16154675e-02f, -1.72083098e-02f, -3.81287299e-02f, -6.20286129e-02f, 3.62428580e-03f, 1.56277195e-02f, -3.27009186e-02f, -2.33972864e-03f,
  5.57715772e-03f, 5.18503860e-02f, -3.42622399e-02f, 1.41292559e-02f, -5.04254438e-02f, -7.00603649e-02f, 7.40135834e-02f, 1.46139609e-02f, -7.39927888e-02f, 5.45403659e-02f,
  -4.08326723e-02f, 1.98325794e-02f, 4.51567061e-02f, 2.08587740e-02f, -1.70236975e-02f, 1.59915853e-02f, -6.30691350e-02f, -5.03516793e-02f, -7.06304684e-02f, -4.21069153e-02f,
  1.73019677e-01f, 1.73356906e-02f, 1.26927584e-01f, -4.50860430e-03f, 2.71016117e-02f, 1.11613916e-02f, 1.12842776e-01f, -1.47268981e-01f, -7.20297843e-02f, 7.50019327e-02f,
  4.27235551e-02f, 1.55312300e-01f, 1.04837194e-01f, -2.39119548e-02f, -3.04588173e-02f, -8.93150363e-03f, -6.56352043e-02f, 1.12892926e-01f, -8.23408738e-02f, -4.37927060e-02f,
  3.44627746e-03f, -7.78484121e-02f, -8.29263404e-02f, -1.67549670e-01f, 1.03622667e-01f, 7.09996298e-02f, -3.66975330e-02f, 5.87342083e-02f, 1.03926435e-01f, 2.23461371e-02f,
  5.29728085e-02f, -1.06040828e-01f, -4.68006870e-03f, -2.79772282e-03f, 4.05197544e-03f, -5.79859242e-02f, -1.91261284e-02f, -8.32147300e-02f, -1.02517903e-01f, -5.48352823e-02f,
  2.02651434e-02f, 3.25115398e-02f, -2.55003441e-02f, -6.28033802e-02f, -9.11823437e-02f, -1.06135951e-02f, 2.57785581e-02f, -3.43824103e-02f, -1.02397613e-01f, 5.46781160e-02f,
  3.63770016e-02f, 2.66538355e-02f, 5.83081506e-02f, 8.77035633e-02f, -2.67414805e-02f, 5.91961779e-02f, -8.86509269e-02f, 1.06948614e-02f, -2.42209416e-02f, -1.16125502e-01f,
  7.55464891e-03f, -2.40522996e-02f, -3.78225967e-02f, -6.40842095e-02f, -3.04791648e-02f, 7.14975148e-02f, 6.90620691e-02f, -3.50546911e-02f, 8.83424953e-02f, -5.83550446e-02f,
  -5.59663847e-02f, -1.07715148e-02f, 2.74046119e-02f, 7.98083097e-03f, 3.68902795e-02f, 7.32377321e-02f, 1.18003814e-02f, -2.56117191e-02f, -6.41975254e-02f, -1.31201465e-02f,
  -4.70653996e-02f, -4.18672189e-02f, -4.37882394e-02f, -4.10756133e-02f, -6.18184023e-02f, -4.75945771e-02f, -1.80085972e-02f, -4.29941714e-03f, -8.42033401e-02f, -6.18798546e-02f,
  -5.40624224e-02f, -2.08088607e-02f, 5.03421389e-02f, -8.05585235e-02f, 7.78257381e-03f, -1.75442882e-02f, -2.56676902e-03f, -9.22957808e-02f, 3.57471593e-02f, -4.90360297e-02f,
  -2.89734621e-02f, -2.87139649e-03f, 8.46222863e-02f, 3.56735699e-02f, 4.22413083e-04f, -8.35393444e-02f, -8.71805754e-03f, 7.63722211e-02f, 3.98481339e-02f, 1.20162340e-02f,
  4.18289192e-02f, -6.79538473e-02f, -3.78045179e-02f, -8.71842206e-02f, -9.48290154e-03f, -7.45742768e-02f, -6.76754937e-02f, 3.87846231e-02f, 8.84527564e-02f, -7.45526552e-02f,
  -3.27464268e-02f, -1.31980926e-01f, -4.30424251e-02f, 1.85721248e-01f, 2.24267408e-01f, 9.47898701e-02f, 9.47859660e-02f, 1.86886758e-01f, 2.74114162e-01f, -2.30345689e-02f,
  -1.88723430e-02f, -9.74310338e-02f, -1.74487576e-01f, 1.17604002e-01f, -6.13023378e-02f, 3.12061198e-02f, 7.00649712e-03f, 1.01546250e-01f, 6.84925020e-02f, 6.18767925e-02f,
  1.28485471e-01f, 1.17721530e-02f, -1.65704072e-01f, -8.06230307e-02f, 1.19747631e-02f, -9.14526805e-02f, -9.51957256e-02f, -5.07308021e-02f, -1.28183603e-01f, 9.48049780e-03f,
  5.83907813e-02f, -8.58623348e-03f, -1.19620658e-01f, 4.50764596e-02f, 5.05839325e-02f, -1.65412016e-02f, 3.77995856e-02f, -4.60948274e-02f, -5.80528416e-02f, 3.03784143e-02f,
  1.49136502e-02f, 3.06316204e-02f, 1.87671781e-02f, -2.55658291e-02f, 4.63631563e-02f, -5.67102171e-02f, -2.78055295e-02f, 4.07382026e-02f, -5.26529662e-02f, -2.60389503e-02f,
  6.40778467e-02f, -1.75513551e-02f, -4.26776148e-02f, -4.35093045e-02f, 4.17951196e-02f, -3.35257761e-02f, -6.90668523e-02f, 4.33237590e-02f, 3.50422077e-02f, 1.64750256e-02f,
  2.05779709e-02f, 8.96948129e-02f, 2.92736590e-02f, 3.55585315e-03f, 6.47137985e-02f, -7.96075761e-02f, -5.29243378e-04f, -4.34287786e-02f, 5.97619973e-02f, -2.92517506e-02f,
  8.77461955e-02f, -6.33774400e-02f, 3.03313360e-02f, -5.88273536e-03f, -1.72367750e-03f, 4.11316268e-02f, 5.42899668e-02f, -2.02028733e-02f, 5.07714711e-02f, 4.21759347e-03f,
  3.33053432e-02f, 3.63124199e-02f, 6.79353112e-03f, 5.44274040e-02f, -5.68033233e-02f, 4.85455059e-02f, 6.76163360e-02f, 1.04631865e-02f, 5.90669177e-02f, -4.20750454e-02f,
  -6.73350238e-04f, 1.36163771e-01f, -9.11881477e-02f, 1.67780425e-02f, -8.15855339e-02f, -2.66129933e-02f, 3.64763988e-03f, 1.52491964e-02f, 6.70761392e-02f, -2.99071763e-02f,
  4.86467555e-02f, 4.83235866e-02f, 5.51901050e-02f, -6.28516749e-02f, -1.19275436e-01f, 5.54082543e-02f, 7.98279420e-02f, -5.46798930e-02f, -4.25652973e-02f, -6.34953380e-02f,
  4.49292026e-02f, 1.17490173e-03f, 3.39951739e-02f, 8.28741044e-02f, 3.94000411e-02f, -7.78131140e-03f, -2.12556403e-03f, 1.57444980e-02f, -5.03502451e-02f, 4.99410834e-03f,
  3.08805704e-02f, 5.52706383e-02f, -2.12114260e-01f, 5.29110804e-02f, -5.93423983e-03f, -2.43954547e-02f, -8.33606496e-02f, 2.89236493e-02f, 3.07050925e-02f, 1.14236690e-01f,
  2.07439527e-01f, -8.98348540e-02f, -5.50136566e-02f, 1.84914827e-01f, 9.84557122e-02f, 1.15428314e-01f, 2.46317774e-01f, 4.18342203e-02f, -1.02396319e-02f, 1.31541580e-01f,
  1.63342860e-02f, 2.68633097e-01f, -5.96757866e-02f, 1.01230212e-01f, 2.47388426e-02f, -4.84970920e-02f, 5.85097708e-02f, -1.81848869e-01f, 9.85796750e-02f, 9.16567966e-02f,
  6.42064512e-02f, -4.17030454e-02f, 3.25457677e-02f, -1.40199229e-01f, -1.91042218e-02f, -7.92647079e-02f, -8.64128470e-02f, 2.81331111e-02f, -2.01579873e-02f, -3.75952758e-02f,
  -7.80675709e-02f, 1.30427303e-02f, 9.01212320e-02f, -4.84228972e-03f, 6.21868297e-03f, -5.41259497e-02f, 4.13980559e-02f, -3.35117728e-02f, -4.10747230e-02f, -6.79751709e-02f,
  4.56559239e-03f, 7.13286251e-02f, -1.29253045e-02f, 2.84055043e-02f, 5.29583842e-02f, 5.95895536e-02f, -7.99670145e-02f, 5.29283704e-03f, 2.52190139e-02f, 8.94544926e-03f,
  -2.32935101e-02f, -4.82957112e-03f, -3.32852714e-02f, -5.43174781e-02f, 4.01621163e-02f, -3.64281759e-02f, 6.46217316e-02f, 7.59937391e-02f, -6.61788285e-02f, -7.06317229e-03f,
  -5.33453822e-02f, 7.61602148e-02f, 7.65825855e-03f, 2.39253193e-02f, 7.11253509e-02f, -2.77734641e-02f, -2.45392956e-02f, 7.91785046e-02f, -9.79705527e-02f, 6.27501383e-02f,
  -3.50904651e-02f, 6.32715970e-02f, 3.79428454e-02f, 1.89606864e-02f, 5.87972403e-02f, 7.72814732e-03f, 3.95224057e-02f, -5.27473986e-02f, -1.79126281e-02f, 7.34743178e-02f,
  -1.95092782e-02f, 1.86006054e-01f, -2.49175960e-03f, 2.63309833e-02f, -7.99332336e-02f, 2.70164888e-02f, -5.03018685e-02f, -9.86442864e-02f, -2.65335981e-02f, -7.65793845e-02f,
  6.04688413e-02f, -1.36158383e-02f, -2.20739152e-02f, -5.47426157e-02f, 1.04286056e-03f, 1.05785802e-01f, 2.37533599e-02f, 3.98964733e-02f, -5.08711152e-02f, 3.30955610e-02f,
  -8.33264440e-02f, -3.56773175e-02f, -6.20475747e-02f, -1.04424559e-01f, -4.17056344e-02f, 1.12023614e-02f, 4.38302159e-02f, 4.47383672e-02f, 9.74098593e-02f, 3.48519087e-02f,
  -8.52700844e-02f, 1.41569544e-02f, 2.34035820e-01f, 2.82623246e-02f, -6.74883500e-02f, -8.94594118e-02f, 3.56427878e-02f, 5.28076589e-02f, 7.89294168e-02f, -1.26211107e-01f,
  -1.74000919e-01f, 5.81989586e-02f, 9.47156101e-02f, 5.66788539e-02f, 9.13377628e-02f, 5.21395802e-02f, 8.32046643e-02f, -4.85548154e-02f, 6.71562403e-02f, 1.55080155e-01f,
  9.60901380e-02f, 3.56389806e-02f, 6.39427975e-02f, 7.14972988e-02f, -9.92385000e-02f, -6.34790882e-02f, 4.15119007e-02f, 4.88410182e-02f, -5.05738445e-02f, 3.80684584e-02f,
  -1.13460384e-01f, -1.88661776e-02f, -3.45830194e-04f, -5.05080856e-02f, -3.76578867e-02f, -4.33777645e-02f, -1.61788631e-02f, 7.12902918e-02f, 4.10907194e-02f, 1.76812708e-02f,
  3.79840992e-02f, -6.33522123e-03f, 5.25073260e-02f, -8.88439268e-02f, 9.23966616e-02f, 5.90606853e-02f, 7.72021264e-02f, 6.19518012e-02f, 2.91136950e-02f, -8.53011683e-02f,
  5.78225404e-02f, 6.05360977e-02f, -1.50025338e-02f, -3.11122574e-02f, 4.05456424e-02f, -9.07943919e-02f, 3.51445489e-02f, 6.89629689e-02f, -5.48314974e-02f, -4.71103638e-02f,
  7.07053840e-02f, -7.91059956e-02f, 4.70529273e-02f, 5.95297813e-02f, -4.39322591e-02f, -3.22690681e-02f, -7.24198371e-02f, -9.63275284e-02f, 1.13395512e-01f, -7.05702305e-02f,
  4.50618826e-02f, -6.85599223e-02f, 3.64254974e-02f, -8.05459023e-02f, -6.07723668e-02f, 8.46781954e-02f, 7.31471479e-02f, 2.14167330e-02f, -4.21111425e-03f, 5.30918539e-02f,
  -5.98457865e-02f, -1.72577763e-03f, -2.57741231e-02f, -1.04112759e-01f, 3.22589837e-02f, -1.95130967e-02f, -8.71205423e-03f, -2.79601738e-02f, 8.05993900e-02f, 6.29436970e-02f,
  -5.10686636e-03f, 1.15685359e-01f, -5.85859381e-02f, -1.82058234e-02f, 4.58299788e-03f, -4.37769666e-02f, 5.30390888e-02f, -8.29129666e-02f, 9.36373696e-02f, 1.31385038e-02f,
  2.38913111e-02f, -6.64893165e-02f, 1.44110331e-02f, -6.48871809e-02f, 1.10958340e-02f, -5.89961931e-02f, 9.19028819e-02f, 6.00156821e-02f, 6.38198629e-02f, -9.99268666e-02f,
  4.78140563e-02f, 4.26030979e-02f, 6.45160675e-02f, -4.38703969e-02f, -4.25688550e-02f, -8.61894190e-02f, -3.64513397e-02f, -6.93129152e-02f, -1.62471775e-02f, -5.96755929e-02f,
  7.77830705e-02f, -2.88443062e-02f, -2.84428924e-01f, -6.98595643e-02f, -1.86160162e-01f, 6.64608404e-02f, 9.26350728e-02f, 7.51019716e-02f, 3.77174653e-03f, 2.48660251e-01f,
  9.17778686e-02f, 2.33715754e-02f, 1.18823737e-01f, 1.63768783e-01f, -1.53764309e-02f, 1.20659880e-01f, 1.16868302e-01f, 1.78349465e-01f, 3.95454690e-02f, -8.68486892e-03f,
  -7.68495202e-02f, 1.51327953e-01f, -1.34177133e-01f, 1.69069762e-03f, -2.51937211e-02f, -1.86149418e-01f, 1.66108143e-02f, -7.11804777e-02f, 9.45321564e-03f, -1.06410056e-01f,
  5.60783669e-02f, 1.53878201e-02f, -3.72242704e-02f, 6.23502098e-02f, -8.12243000e-02f, -9.94093567e-02f, -3.47469486e-02f, -1.66999791e-02f, -8.82581174e-02f, 3.89299658e-03f,
  -3.52450684e-02f, 4.81581986e-02f, 8.83940458e-02f, 5.37479063e-03f, -1.77452676e-02f, -1.09916158e-01f, 5.20045869e-03f, -4.28354042e-03f, 2.78087314e-02f, -3.66136804e-02f,
  -5.75147159e-02f, -9.27625149e-02f, -2.42024995e-02f, 8.70969445e-02f, -4.04077061e-02f, -8.56506359e-03f, 3.80367599e-02f, -7.92752355e-02f, 2.26767045e-02f, -5.30689955e-03f,
  -4.73762043e-02f, 7.24526793e-02f, -1.05355550e-02f, 2.41947509e-02f, -5.36131375e-02f, 2.95725074e-02f, -4.61039804e-02f, 8.10978487e-02f, -2.58853976e-02f, -2.47350764e-02f,
  -2.03849711e-02f, -9.15476605e-02f, 4.92291078e-02f, -3.98665220e-02f, 1.00740440e-01f, 1.76761877e-02f, 2.18878668e-02f, 3.90961068e-03f, -6.52850866e-02f, -2.70659141e-02f,
  5.25682941e-02f, 1.19598117e-02f, 5.09265959e-02f, -8.23117513e-03f, 4.45438772e-02f, -1.08977566e-02f, 5.50365821e-02f, 6.68212548e-02f, 2.70560533e-02f, -7.23208860e-02f,
  1.72517821e-02f, 4.67525087e-02f, -1.64636802e-02f, -6.91181868e-02f, -8.97445828e-02f, -2.67043822e-02f, 4.04919647e-02f, 5.05170552e-04f, -3.98370288e-02f, 5.76486997e-02f,
  2.59688795e-02f, -1.05728852e-02f, -7.40904966e-03f, -4.25816663e-02f, -6.30664080e-02f, 1.18805626e-02f, 6.03966266e-02f, 8.63065273e-02f, 5.29988259e-02f, 5.98705048e-03f,
  -8.38008896e-02f, 1.09433355e-02f, 3.37611064e-02f, 3.63240913e-02f, 8.47187638e-02f, 1.81583744e-02f, 4.21240442e-02f, -9.73526761e-02f, 4.57501551e-03f, 6.36146143e-02f,
  1.01430565e-02f, 1.03823148e-01f, 1.41448915e-01f, -1.90934297e-02f, -1.22037768e-01f, -1.52521700e-01f, -1.59901932e-01f, -5.61163537e-02f, -8.73041525e-02f, -5.16609102e-02f,
  -1.00949183e-02f, 2.21804738e-01f, 1.50622919e-01f, -1.16994657e-01f, -1.75602555e-01f, -1.02774538e-01f, -1.57143489e-01f, -3.04210614e-02f, 9.59986821e-03f, -1.34203970e-01f,
  -7.70974085e-02f, -1.53114527e-01f, 3.90512757e-02f, -9.85543877e-02f, -6.22770982e-04f, -6.95320889e-02f, -2.46957000e-02f, 9.67434198e-02f, -1.22165851e-01f, 4.83488180e-02f,
  -5.43046556e-02f, -9.80357751e-02f, 2.46523004e-02f, 4.54901494e-02f, -1.48120984e-01f, 2.50680428e-02f, -1.62017830e-02f, 6.20944723e-02f, -1.25188217e-01f, -3.68687660e-02f,
  3.38394567e-02f, -5.42637035e-02f, -6.63677678e-02f, 1.29973507e-02f, -8.57153907e-02f, 9.30485800e-02f, -1.53566357e-02f, 7.68190995e-02f, 1.79495048e-02f, 9.66186225e-02f,
  5.09953275e-02f, 4.37758006e-02f, -7.09532015e-03f, -3.94600071e-02f, -7.38806203e-02f, -5.30931689e-02f, -2.32413821e-02f, 1.04581781e-01f, 7.77234137e-02f, 1.56337041e-02f,
  4.74186707e-03f, 2.02471521e-02f, -1.07818013e-02f, -5.11366986e-02f, -1.81423174e-03f, -3.43714170e-02f, 3.27368011e-03f, 2.81966887e-02f, -3.70421037e-02f, -7.27074221e-02f,
  -6.13878183e-02f, -1.18070003e-02f, 1.59485694e-02f, 1.84705872e-02f, 1.94938835e-02f, -1.08994124e-02f, -1.98923852e-02f, -7.90235400e-02f, 2.48179939e-02f, -1.50454661e-03f,
  1.93615556e-02f, -7.59430230e-02f, 5.66413552e-02f, -3.58797647e-02f, 2.64099427e-02f, 2.38154326e-02f, 6.57220790e-03f, -1.02748081e-01f, 7.71029964e-02f, 1.68320965e-02f,
  -1.48878172e-01f, -1.52435765e-01f, -5.97853214e-02f, 4.30766605e-02f, -8.73932838e-02f, -1.14237733e-01f, 5.51982457e-03f, -6.23818533e-03f, -1.02314442e-01f, -7.49163106e-02f,
  3.65442000e-02f, 2.83076451e-03f, -6.75983801e-02f, 4.68314774e-02f, 2.26227362e-02f, 5.29961940e-03f, -8.29364508e-02f, -9.41360220e-02f, -4.66476791e-02f, 4.67824377e-02f,
  5.53688267e-03f, -6.37559295e-02f, -1.08123384e-02f, -7.49084800e-02f, -6.04769737e-02f, -7.48417303e-02f, 1.76480282e-02f, 1.45812359e-04f, -5.00173420e-02f, 9.41372942e-03f,
  1.60268508e-02f, 2.79387813e-02f, 3.10444552e-02f, 6.83549568e-02f, -6.88931942e-02f, -1.22702636e-01f, -1.49335712e-01f, -8.93445760e-02f, -7.52352774e-02f, 2.04179976e-02f,
  4.92560975e-02f, 1.37509227e-01f, -7.79981613e-02f, -1.44350007e-02f, 8.06718320e-02f, 5.29254265e-02f, -1.36354854e-02f, 4.55421247e-02f, 6.19961768e-02f, 8.66704211e-02f,
  1.44828018e-02f, 1.22618768e-02f, 1.62065029e-01f, -1.73495535e-03f, 2.61962973e-02f, 2.93834601e-02f, 1.59587935e-01f, 2.41649598e-02f, 1.04038820e-01f, 6.96659684e-02f,
  5.02171135e-03f, 1.82402581e-02f, -1.42343240e-02f, -5.58303893e-02f, -3.80098410e-02f, 7.04744607e-02f, 9.23632383e-02f, 7.28464797e-02f, 8.57714936e-02f, -6.84091449e-02f,
  -5.49820922e-02f, 6.64783940e-02f, 7.40169361e-02f, -7.45103359e-02f, 4.44884747e-02f, 8.05967450e-02f, 7.07407147e-02f, 3.17911766e-02f, 9.68549121e-03f, 1.83542799e-02f,
  7.26341922e-03f, -5.89699671e-02f, -1.55685134e-02f, 5.56775108e-02f, 3.15933004e-02f, 1.84683234e-03f, 4.14918363e-03f, 9.37044621e-02f, 6.24901382e-03f, -5.92456795e-02f,
  8.39845743e-03f, 3.31357494e-03f, -5.86483441e-02f, -8.90166610e-02f, 1.94335394e-02f, -3.51782739e-02f, 6.92180246e-02f, 3.15517299e-02f, 6.55459166e-02f, -2.86302958e-02f,
  8.29029158e-02f, -5.33788465e-02f, -3.85253765e-02f, 2.74808053e-02f, 6.84001595e-02f, -8.31835065e-03f, 6.31187633e-02f, 8.89236107e-02f, -8.24027807e-02f, 3.87041122e-02f,
  6.40169159e-02f, 4.43747267e-02f, -1.82543583e-02f, -1.04807261e-02f, -9.56579596e-02f, 4.97305021e-02f, -3.29012461e-02f, 3.58262509e-02f, 7.11581632e-02f, 4.38954011e-02f,
  1.08918339e-01f, 2.81243082e-02f, 6.23642616e-02f, -6.03721626e-02f, -4.51920629e-02f, -6.34748936e-02f, -5.25691546e-02f, -7.38007948e-02f, -5.44745550e-02f, -3.84535678e-02f,
  -8.55442360e-02f, -5.37421554e-02f, 8.29085112e-02f, -4.99600284e-02f, 2.52251681e-02f, -2.72816401e-02f, -5.08821607e-02f, 9.57173258e-02f, -2.28642095e-02f, -1.78672429e-02f,
  9.46882069e-02f, -7.50095248e-02f, -6.32625222e-02f, 3.63326445e-02f, 8.94478615e-03f, 4.94633196e-03f, 7.04120025e-02f, 6.46620840e-02f, 5.20814881e-02f, 9.72749069e-02f,
  -1.54111907e-01f, 1.66417852e-01f, -1.21433616e-01f, -1.44027919e-01f, -5.18634059e-02f, 1.53911011e-02f, -1.74879469e-02f, -5.22069931e-02f, -4.83169667e-02f, 8.52789208e-02f,
  -2.30845828e-02f, -1.67673454e-01f, 7.79473037e-02f, 1.36432767e-01f, 1.08085172e-02f, 1.96971595e-01f, 5.69990929e-03f, 9.01862979e-02f, -6.46321774e-02f, 1.81069504e-02f,
  2.69563813e-02f, 9.51843560e-02f, 7.04402253e-02f, 4.75482568e-02f, -9.75603145e-03f, -9.92984101e-02f, -7.55768688e-03f, 1.70490425e-02f, 6.78262040e-02f, 1.97175350e-02f,
  7.95547590e-02f, -1.11978598e-01f, -3.85182276e-02f, 5.20082153e-02f, 2.76624132e-03f, -2.29415391e-02f, 3.52664776e-02f, 4.65923622e-02f, -8.59294385e-02f, 7.36811059e-03f,
  -1.23623252e-01f, -1.13800205e-02f, 3.77805308e-02f, -3.25267948e-02f, -1.06489714e-02f, 2.95066601e-03f, 4.67976928e-03f, 1.00259837e-02f, -1.06435463e-01f, 5.71356118e-02f,
  -5.10198250e-02f, 7.49927089e-02f, -8.71249810e-02f, 6.57694265e-02f, 1.16965538e-02f, -9.54535604e-03f, -5.39916456e-02f, -8.44557732e-02f, -6.00738637e-02f, 3.62586081e-02f,
  -8.02637637e-02f, 1.08222915e-02f, 3.85573506e-02f, 8.70896596e-03f, -2.44402774e-02f, -6.09077280e-03f, -1.11304764e-02f, 6.86032511e-03f, 2.97248960e-02f, 6.47438169e-02f,
  -2.48663332e-02f, -1.59169622e-02f, -1.47643788e-02f, -3.09868995e-02f, 6.06673807e-02f, -5.63160665e-02f, 8.49239752e-02f, -3.68677266e-02f, -2.58121975e-02f, 2.37577930e-02f,
  2.35470431e-03f, -7.62608554e-03f, -7.25242943e-02f, 4.43886630e-02f, -4.29250114e-02f, -8.90921429e-02f, 2.13212334e-02f, -4.44774702e-02f, 7.67852813e-02f, 2.22043116e-02f,
  8.86040702e-02f, -9.95354354e-02f, 6.58655986e-02f, 2.75307931e-02f, 2.83138398e-02f, -4.62721139e-02f, -5.86426258e-02f, -6.47363737e-02f, -6.79866299e-02f, -1.81584421e-03f,
  5.69260046e-02f, -6.29872680e-02f, -4.00018133e-02f, -5.64874597e-02f, 3.56037654e-02f, -5.96118383e-02f, -3.39285135e-02f, -9.40798223e-02f, 1.32714100e-02f, -2.79276539e-03f,
  7.76740834e-02f, 1.97141226e-02f, 1.76797174e-02f, -6.33465275e-02f, 6.23373948e-02f, -8.36708386e-06f, -9.97492392e-03f, -7.68271927e-03f, 2.49357168e-02f, 6.62597939e-02f,
  3.50504043e-03f, 2.29328088e-02f, -1.90470472e-03f, -1.00541256e-01f, 2.39087418e-02f, -6.85220510e-02f, -9.22593772e-02f, 1.37572467e-01f, 1.76176533e-01f, 9.97639671e-02f,
  1.05763875e-01f, -9.75623876e-02f, 9.37165767e-02f, -2.75565088e-02f, -6.72858059e-02f, 7.11793005e-02f, -1.25001922e-01f, -1.24393947e-01f, 7.67890815e-05f, -5.50330430e-02f,
  -1.26470644e-02f, 1.70601066e-02f, -1.56034067e-01f, 1.19834334e-01f, 1.64867006e-02f, -3.50367837e-02f, -7.42344260e-02f, 1.09383367e-01f, -1.31400451e-01f, -9.54878032e-02f,
  -3.48132774e-02f, 1.32002831e-01f, -8.36414695e-02f, -6.03048876e-02f, 2.24912502e-02f, 1.81437172e-02f, -8.98976177e-02f, 1.74930412e-02f, 5.98713681e-02f, -7.46657550e-02f,
  -4.49803323e-02f, -6.98620975e-02f, 6.27188012e-02f, 5.46460412e-02f, 1.08466670e-01f, 3.81641574e-02f, 1.52667728e-03f, -9.00526717e-02f, -8.90518725e-03f, 1.13800690e-02f,
  5.25340438e-03f, -5.01701236e-02f, 9.30890068e-03f, 9.15600583e-02f, -2.40429565e-02f, 5.04153408e-02f, -2.09432002e-02f, -8.10877308e-02f, -6.18367940e-02f, 3.23830023e-02f,
  5.10781258e-03f, -5.16629964e-02f, 2.91010346e-02f, 4.53488976e-02f, 9.70602036e-02f, -4.98313531e-02f, -1.31802550e-02f, 2.21248548e-02f, 4.47337218e-02f, -8.71787518e-02f,
  7.30102733e-02f, 3.88245005e-03f, -2.24755611e-02f, 8.06130003e-03f, 3.85202914e-02f, 9.54996347e-02f, -1.16656497e-02f, -4.72820960e-02f, -5.16131297e-02f, -3.17322724e-02f,
  -5.89355119e-02f, 7.14705652e-03f, -8.69076606e-03f, 6.74166977e-02f, -2.28052400e-02f, 8.45332593e-02f, 6.38200939e-02f, 6.82312250e-02f, 7.77473599e-02f, 1.55310589e-03f,
  5.18684536e-02f, -2.21102703e-02f, -1.08745638e-02f, 7.42061958e-02f, -2.79088095e-02f, -5.40880039e-02f, 6.68248162e-02f, -4.92018312e-02f, 3.46152037e-02f, 2.19015665e-02f,
  -4.10581157e-02f, 5.59147634e-02f, 5.97440638e-02f, 1.44478530e-02f, 8.10123421e-03f, 2.19232999e-02f, 5.80297671e-02f, 4.70985658e-02f, -8.04130659e-02f, -1.16832964e-02f,
  6.11079065e-03f, 6.91296980e-02f, 9.62955132e-02f, 2.73377858e-02f, -5.32128811e-02f, -1.43809291e-02f, 2.85832724e-03f, -1.48142781e-02f, -8.25777352e-02f, -9.29165557e-02f,
  -7.66096413e-02f, -1.09274397e-02f, 5.73917991e-03f, 1.59587219e-01f, -6.94688037e-02f, -9.93772820e-02f, -1.03056736e-01f, -4.98685278e-02f, 6.28647283e-02f, -1.13838613e-01f,
  -9.33075249e-02f, 6.21727481e-02f, -4.73828204e-02f, -1.70845576e-02f, 9.23571661e-02f, -6.23146221e-02f, 1.29100084e-01f, -7.60274157e-02f, -5.57366833e-02f, 5.18279001e-02f,
  1.73976511e-01f, 6.28845021e-02f, 1.88169986e-01f, 1.08283125e-01f, -5.11671556e-03f, 2.07472786e-01f, 2.32994840e-01f, -1.96410492e-02f, 1.87013924e-01f, -7.40989018e-03f,
  -6.07464015e-02f, 9.42195356e-02f, -5.29987589e-02f, -9.09184813e-02f, 1.10375332e-02f, -7.88240209e-02f, 8.27193782e-02f, 5.69321886e-02f, -5.83555661e-02f, 6.42408011e-03f,
  5.54224588e-02f, 2.73237135e-02f, 1.19189307e-01f, 4.11291309e-02f, -1.96144935e-02f, 1.01105832e-01f, -3.39871012e-02f, 7.21274465e-02f, 2.27370244e-02f, -7.04705296e-03f,
  -2.40787417e-02f, -5.44030294e-02f, -1.06257694e-02f, -7.75079243e-03f, 5.70236780e-02f, -2.50482671e-02f, 5.52980346e-04f, 8.35356489e-03f, 1.50580530e-03f, 4.02322784e-02f,
  6.94141537e-02f, 5.67666888e-02f, 1.71910692e-02f, 7.87526071e-02f, -3.70401032e-02f, -6.35511950e-02f, 5.38863316e-02f, 5.39960563e-02f, 1.98254921e-02f, -4.75811725e-03f,
  4.13370598e-03f, 5.76973893e-02f, 5.00508212e-03f, 2.26509906e-02f, 3.54235061e-02f, 5.85573316e-02f, 5.15383147e-02f, 8.24259669e-02f, 6.80618966e-03f, 2.43608654e-02f,
  3.43119912e-02f, 3.08286436e-02f, 7.31470510e-02f, -4.91532385e-02f, -8.37003589e-02f, -8.02883413e-04f, -4.04135510e-02f, 2.04378460e-02f, 6.51471317e-02f, 3.89245339e-03f,
  6.17277883e-02f, 2.58865029e-01f, 2.00308729e-02f, -7.29687214e-02f, 6.84424862e-02f, -2.91539803e-02f, -1.09219057e-02f, 1.10079013e-02f, 4.86035347e-02f, 7.84148052e-02f,
  9.91675071e-03f, -1.19531117e-02f, -3.39084342e-02f, 2.38518957e-02f, 4.99281101e-02f, 2.63279192e-02f, 9.19997320e-02f, -4.10148054e-02f, -2.27723029e-02f, 2.48237476e-02f,
  -4.70505701e-03f, -5.64135276e-02f, 1.05525218e-01f, 7.08929598e-02f, 7.51895607e-02f, 1.03797227e-01f, 5.55176055e-03f, -4.34884056e-03f, -2.99019814e-02f, -3.34903933e-02f,
  -1.20019436e-01f, 3.57295312e-02f, -5.50746247e-02f, -3.30623053e-02f, -9.18100625e-02f, -5.94412424e-02f, 1.22217938e-01f, -1.85697321e-02f, 8.80470574e-02f, 1.25624627e-01f,
  5.15206121e-02f, -5.04056290e-02f, 9.15738195e-02f, 4.78057787e-02f, -1.16983525e-01f, 4.85188775e-02f, 1.52788922e-01f, 1.22771405e-01f, -4.60182726e-02f, -7.29795545e-02f,
  -3.23777571e-02f, -7.33464062e-02f, 7.20290616e-02f, -4.05319110e-02f, -3.68473269e-02f, 2.14366033e-03f, -7.82687142e-02f, -8.69433656e-02f, -3.17048542e-02f, -1.10290483e-01f,
  -5.77535778e-02f, -1.09765446e-02f, -7.92057440e-02f, -4.87705767e-02f, -9.32349712e-02f, 9.19681117e-02f, -6.76015317e-02f, -8.75083655e-02f, -8.41989145e-02f, -8.14474896e-02f,
  5.88773042e-02f, -1.82065777e-02f, 8.91373381e-02f, -6.10547327e-02f, -5.46989888e-02f, 3.65098640e-02f, 3.29176821e-02f, -3.48777175e-02f, 6.96482137e-02f, -5.20338342e-02f,
  7.81381503e-02f, -7.62732849e-02f, 5.49783446e-02f, 3.45913065e-03f, 1.71549972e-02f, 1.90642979e-02f, -1.37566961e-02f, -3.92057933e-02f, -7.78510049e-02f, 5.62937409e-02f,
  2.30731256e-02f, 6.72204196e-02f, 8.66779014e-02f, 5.23939691e-02f, -3.08770519e-02f, 1.30774425e-02f, 6.13473095e-02f, -3.72953527e-02f, -1.31025165e-02f, 3.95382382e-02f,
  -4.73246388e-02f, 2.17162524e-05f, -6.11170894e-03f, 8.38043019e-02f, -6.46817982e-02f, -5.86695187e-02f, -2.86197271e-02f, 6.32240623e-02f, 2.30137892e-02f, -3.65487374e-02f,
  -3.82095240e-02f, -4.63537835e-02f, 2.17288639e-02f, -4.72358875e-02f, -6.96912408e-02f, -6.06547780e-02f, 3.20678465e-02f, -6.42791316e-02f, 8.92689452e-02f, 2.08891612e-02f,
  2.74540071e-04f, -7.84348175e-02f, 7.33265802e-02f, -8.13903958e-02f, -6.12417236e-02f, 7.23456070e-02f, 5.08806482e-03f, -8.88286978e-02f, -4.11501788e-02f, 1.01707177e-02f,
  3.79267521e-02f, -5.69656491e-02f, -1.05735781e-02f, -7.88335130e-02f, 3.37955765e-02f, -6.86112866e-02f, -2.69740243e-02f, -4.57199030e-02f, 4.10308577e-02f, 3.24809812e-02f,
  7.50833303e-02f, 3.26821543e-02f, -4.43065651e-02f, 2.40587979e-03f, -4.45063151e-02f, -5.33362478e-03f, -8.69467854e-02f, -2.70693786e-02f, -5.62867299e-02f, 3.51749882e-02f,
  5.78619987e-02f, -6.09392263e-02f, 4.04164679e-02f, 1.25605598e-01f, 7.12328628e-02f, -1.49682850e-01f, -1.10434726e-01f, 1.42610639e-01f, -7.20911771e-02f, -1.21178757e-02f,
  -4.24803570e-02f, -3.07335928e-02f, -1.47673681e-01f, -1.03314012e-01f, 2.30882615e-02f, -5.28046042e-02f, 1.42230421e-01f, -1.19928211e-01f, 1.25406861e-01f, 5.78017309e-02f,
  1.72137693e-01f, 1.20012887e-01f, 1.95640728e-01f, 7.67192841e-02f, 1.25863090e-01f, 2.27463692e-01f, 2.17865080e-01f, 7.87464380e-02f, 1.66953862e-01f, -9.81640965e-02f,
  -7.02376962e-02f, -4.76235896e-02f, 4.73400280e-02f, 5.29126935e-02f, 1.09567493e-01f, 1.98879819e-02f, 4.87071052e-02f, -1.11933509e-02f, 9.99742448e-02f, 7.46361315e-02f,
  3.29668745e-02f, 4.93669175e-02f, 2.22535711e-02f, -9.30955857e-02f, 5.89371547e-02f, -1.76961143e-02f, -1.65354665e-02f, -3.55603104e-03f, 8.36221203e-02f, 1.72125585e-02f,
  4.32310477e-02f, -2.30539497e-02f, 8.62317011e-02f, -4.70899567e-02f, -2.98492089e-02f, -5.54586984e-02f, 3.22541445e-02f, 7.12900162e-02f, -5.95587026e-03f, 2.37062257e-02f,
  -3.36280605e-03f, 4.72227931e-02f, -7.93886483e-02f, 1.52823217e-02f, -6.67382330e-02f, 5.83457090e-02f, 8.03289935e-02f, -3.80548500e-02f, -5.58742397e-02f, 7.06200534e-03f,
  -6.63903654e-02f, -4.25621159e-02f, -5.94212785e-02f, 2.95534302e-02f, -4.15162817e-02f, -9.90615562e-02f, -6.90793968e-04f, 6.91590607e-02f, -1.91823090e-03f, 1.67453121e-02f,
  -2.35111862e-02f, -7.73887262e-02f, 5.24941757e-02f, -6.57055005e-02f, -5.08653373e-02f, -2.68154382e-03f, 9.87884402e-02f, -2.08697859e-02f, 1.32922335e-02f, -8.20884481e-03f,
  3.21264146e-03f, 9.27381516e-02f, -9.08070616e-03f, -9.88191366e-02f, 7.28322342e-02f, -2.04141401e-02f, 6.83861449e-02f, 7.78017119e-02f, 6.88381195e-02f, -2.97995098e-02f,
  1.20507553e-01f, -4.19496000e-02f, -2.37828661e-02f, -5.23291305e-02f, 5.98117709e-02f, 8.98720995e-02f, 3.37373689e-02f, -1.08072814e-02f, 3.34182009e-02f, 1.17851853e-01f,
  -1.39395020e-03f, 7.70982802e-02f, -5.22324666e-02f, -1.53554091e-02f, 7.32391179e-02f, -9.39739682e-03f, 8.13098475e-02f, -2.87661217e-02f, 4.01287638e-02f, -2.78899521e-02f,
  3.38655636e-02f, 1.38020329e-03f, 3.44570577e-02f, 1.56570375e-01f, 1.46279186e-01f, 7.11014867e-02f, 1.18527915e-02f, -4.47697230e-02f, 1.19681098e-01f, -1.04357474e-01f,
  -7.54218325e-02f, 5.61354309e-02f, -1.83010116e-01f, 6.20739721e-02f, 1.44595668e-01f, 6.70079887e-03f, 1.25957251e-01f, 1.27269223e-01f, 6.22316748e-02f, 2.61495337e-02f,
  -4.59776446e-02f, -5.89457862e-02f, 8.40135291e-03f, -5.60339913e-02f, 2.28364915e-02f, -4.49873433e-02f, -1.61317736e-02f, -6.95000589e-02f, 3.55880745e-02f, 5.71536273e-03f,
  1.10239245e-01f, -4.09345375e-03f, -4.16927505e-03f, 8.17736015e-02f, -3.13629746e-03f, 8.07593241e-02f, -1.49408896e-02f, -2.51656072e-03f, 8.32207054e-02f, 2.05962695e-02f,
  9.24861524e-04f, 9.64213088e-02f, 1.15216359e-01f, 1.47984503e-03f, 1.02868296e-01f, 6.82839751e-02f, -3.58509384e-02f, 2.93016993e-02f, -6.52713850e-02f, -6.46246150e-02f,
  -3.47735621e-02f, 1.56659745e-02f, 1.08218184e-02f, -8.59858319e-02f, 1.95026752e-02f, 2.85117188e-03f, -6.70537129e-02f, -2.40081754e-02f, 3.57351415e-02f, -4.37223166e-02f,
  6.00766428e-02f, 4.23091911e-02f, 7.25184828e-02f, -4.74745743e-02f, -7.04150796e-02f, -1.78456455e-02f, 5.45512028e-02f, 4.33794931e-02f, -4.74789031e-02f, -3.33741569e-04f,
  8.07724744e-02f, -2.43316870e-02f, -3.05475891e-02f, -4.87485789e-02f, 1.00705447e-02f, -7.98018575e-02f, -5.80334514e-02f, -2.07559895e-02f, -3.51959132e-02f, -1.98308239e-03f,
  -5.81616126e-02f, 3.02406959e-02f, 6.14636689e-02f, -2.50476189e-02f, 8.74560401e-02f, -8.32407027e-02f, -8.36319029e-02f, 4.94871140e-02f, 1.96510144e-02f, 4.68668640e-02f,
  -9.82843060e-03f, -7.00870156e-02f, 7.63944210e-03f, 6.72250316e-02f, 6.62779585e-02f, 1.90629307e-02f, 1.05069309e-01f, -1.79984737e-02f, 5.24939522e-02f, -6.79063424e-02f,
  -8.25087205e-02f, 1.95152331e-02f, -8.39344040e-02f, 8.46325830e-02f, 8.67631733e-02f, -3.98164615e-02f, -3.79222296e-02f, 5.39418161e-02f, 5.03050573e-02f, -6.70785978e-02f,
  4.18524109e-02f, 1.02710761e-02f, 4.24688794e-02f, 8.02074298e-02f, 3.52357812e-02f, 2.16224813e-04f, -6.14713244e-02f, 1.71135254e-02f, -4.45839278e-02f, -8.49080309e-02f,
  8.03254619e-02f, -3.27484347e-02f, 1.53759539e-01f, 1.51942909e-01f, 6.97046295e-02f, -7.70604312e-02f, 6.11144081e-02f, 5.86449392e-02f, 1.99287489e-01f, -4.36038151e-02f,
  -1.40768096e-01f, 1.35848477e-01f, -9.70647335e-02f, 4.12244163e-02f, -3.39999935e-03f, -8.03461298e-03f, 1.18314646e-01f, -3.26786935e-02f, 5.97134754e-02f, 5.26525974e-02f,
  9.61394086e-02f, -8.51119086e-02f, -1.05581850e-01f, -1.31845325e-01f, -3.76394540e-02f, 4.55103442e-03f, -5.12065031e-02f, -4.30455357e-02f, 2.17343401e-02f, -1.18377497e-02f,
  -4.39493805e-02f, 6.64975587e-03f, 2.65122745e-02f, 2.40472946e-02f, -6.21595085e-02f, -6.36490434e-02f, 5.07392436e-02f, -6.73336387e-02f, 3.09672183e-03f, 1.76700689e-02f,
  9.14451256e-02f, 4.17068563e-02f, -1.29562588e-02f, -2.11806633e-02f, 3.05677075e-02f, 6.37664422e-02f, 6.69684336e-02f, -7.45451823e-02f, -5.59506714e-02f, 1.08844284e-02f,
  1.75048653e-02f, 4.88026850e-02f, 1.34420407e-03f, 5.84930601e-03f, 9.30987149e-02f, -3.97994881e-03f, -5.60226180e-02f, -3.31905372e-02f, 7.73850903e-02f, 1.09587580e-01f,
  -6.54154941e-02f, 1.71942990e-02f, -9.61264670e-02f, -2.05766689e-02f, -3.45173702e-02f, -2.56327093e-02f, 6.13914505e-02f, -3.45213860e-02f, 5.93849421e-02f, -2.30798405e-02f,
  -5.24395816e-02f, 5.72031774e-02f, 5.67934103e-02f, 3.88143696e-02f, 1.11844437e-02f, 1.11584384e-02f, -2.27793673e-04f, 2.28011585e-03f, -7.98822716e-02f, -2.68163737e-02f,
  -9.06756073e-02f, 5.53899966e-02f, -8.46129954e-02f, -4.91765924e-02f, -7.15400651e-02f, 2.17252430e-02f, 4.96684909e-02f, -6.35940656e-02f, -6.47993535e-02f, -4.43034358e-02f,
  -5.01328371e-02f, -2.54826769e-02f, 8.00143778e-02f, -2.13691909e-02f, -7.28778094e-02f, -5.32077178e-02f, -1.33532367e-03f, -4.14272537e-03f, -7.05079883e-02f, -6.35483786e-02f,
  3.30346152e-02f, 1.00949383e-03f, -7.82458764e-03f, 8.60072449e-02f, -4.91154864e-02f, 8.11620522e-03f, -4.51498032e-02f, -5.45306988e-02f, 8.31478760e-02f, -3.56331915e-02f,
  -4.40217815e-02f, -7.97406659e-02f, -6.13762103e-02f, -1.03542931e-01f, -4.95092310e-02f, -8.20959359e-02f, 1.02342710e-01f, 5.84166162e-02f, 4.41553220e-02f, 3.73927914e-02f,
  3.15304510e-02f, 1.23713627e-01f, -4.96884994e-02f, 3.18332948e-02f, -7.68744573e-02f, -2.69408803e-02f, 1.15949782e-02f, 1.22274861e-01f, 1.52824163e-01f, 9.90310311e-02f,
  1.28805479e-02f, 1.59623802e-01f, -5.16025759e-02f, 1.29433230e-01f, -9.58092883e-02f, -8.90306607e-02f, 2.80424356e-02f, 3.34495567e-02f, -1.39839796e-03f, 8.92641023e-02f,
  6.45009056e-02f, 1.43345773e-01f, -9.96388718e-02f, 2.81690750e-02f, 7.23236948e-02f, -4.46275100e-02f, -4.27681841e-02f, -7.47005492e-02f, -6.94344565e-02f, -4.29160194e-03f,
  1.39911741e-03f, 2.68449504e-02f, 6.53830320e-02f, -3.49607132e-02f, 6.82827756e-02f, 1.34245362e-02f, -5.85782789e-02f, -2.48138607e-03f, 5.17633697e-03f, 6.79460093e-02f,
  -2.30691079e-02f, 2.81933565e-02f, 1.04143195e-01f, -4.81009893e-02f, -6.19504675e-02f, -2.05142889e-02f, -6.59221560e-02f, 3.52594443e-02f, 6.18061125e-02f, -8.51222947e-02f,
  6.29913360e-02f, 5.85298464e-02f, -7.97905922e-02f, -6.66580349e-02f, -6.00608438e-02f, 6.32257834e-02f, 4.34355699e-02f, 4.35551442e-02f, 3.48362066e-02f, -2.12918110e-02f,
  7.12102577e-02f, 4.37348336e-02f, -6.21875264e-02f, -5.85796237e-02f, -2.11317483e-02f, -1.06873155e-01f, 3.30240913e-02f, -2.14883015e-02f, 4.83371206e-02f, -6.37295321e-02f,
  2.90307235e-02f, 5.07074594e-02f, -3.95403393e-02f, -3.14783342e-02f, 4.72219661e-02f, -2.80195451e-03f, -3.54038738e-02f, -4.48751114e-02f, -1.18720703e-01f, 5.60368970e-02f,
  -3.03110722e-02f, 4.03098157e-03f, 3.60674970e-02f, -1.11398904e-03f, -8.04358348e-02f, -1.28818559e-03f, 4.14060913e-02f, 3.69633660e-02f, -8.27041939e-02f, -7.82843865e-03f,
  -2.36004330e-02f, 5.40748276e-02f, 1.15651265e-01f, -3.23451683e-02f, -5.20338006e-02f, -5.88353574e-02f, -2.05826256e-02f, -1.46715185e-02f, -6.77908659e-02f, 5.09539656e-02f,
  3.04140225e-02f, -2.04743817e-02f, 4.04432453e-02f, -4.93429750e-02f, -7.39678144e-02f, 4.45195548e-02f, 6.09257296e-02f, 2.50094831e-02f, -5.19105494e-02f, 8.29184502e-02f,
  8.78125504e-02f, 1.76685993e-02f, 5.11004822e-04f, -9.53421593e-02f, 8.43557492e-02f, 6.37662783e-02f, 1.16474442e-01f, -3.96155640e-02f, -1.90299414e-02f, -8.74893963e-02f,
  2.25969646e-02f, 1.32229343e-01f, 1.17280021e-01f, -1.57993827e-02f, 3.67437974e-02f, -1.13065012e-01f, -5.30786067e-02f, -2.34940834e-02f, 1.65715273e-02f, -4.92448844e-02f,
  -1.99268945e-02f, 1.43305324e-02f, 1.53497253e-02f, 1.30134786e-03f, -6.15196042e-02f, 4.43187319e-02f, -1.33296013e-01f, -4.90693375e-02f, -4.99174073e-02f, 2.61345133e-02f,
  -8.01799521e-02f, -1.69682186e-02f, -2.06977725e-02f, -5.70051298e-02f, 1.91958621e-02f, 6.86965957e-02f, -1.01251751e-01f, 9.15794298e-02f, -2.43457370e-02f, -5.39433509e-02f,
  -2.38514170e-02f, -1.04127601e-01f, 9.66018140e-02f, 1.43059641e-02f, 3.40063162e-02f, -1.11552179e-02f, 7.59532303e-02f, -5.76778091e-02f, -5.45505509e-02f, 6.90130219e-02f,
  -5.56738377e-02f, -4.47509773e-02f, 2.19244435e-02f, 9.23361350e-03f, 7.64185190e-02f, -8.66845772e-02f, -7.48502612e-02f, 6.79033771e-02f, 6.56582788e-02f, 9.51883420e-02f,
  6.15927987e-02f, 1.84821449e-02f, -4.05499712e-03f, -6.27493039e-02f, 6.73629493e-02f, 4.24880534e-02f, -2.62311529e-02f, -4.95069697e-02f, -6.41519129e-02f, -4.37498949e-02f,
  -8.39522928e-02f, -8.29720348e-02f, 3.32184508e-03f, 5.91699295e-02f, 5.31906635e-03f, -4.62828279e-02f, 6.37294427e-02f, -6.38805404e-02f, 9.08786803e-03f, -9.44126323e-02f,
  -5.24406210e-02f, 9.23053548e-02f, 9.02744196e-03f, -7.09270388e-02f, -6.92951202e-04f, -2.74820719e-02f, -1.62493624e-02f, -2.08686404e-02f, 4.93263230e-02f, -8.04614425e-02f,
  -4.88731861e-02f, 7.05823079e-02f, 4.45951335e-02f, 5.06944433e-02f, -2.77302153e-02f, 6.09453721e-03f, 3.44467349e-02f, 5.70040792e-02f, 2.59682778e-02f, 5.65389618e-02f,
  -6.68699220e-02f, -4.18508165e-02f, -4.48200516e-02f, 7.43147060e-02f, 8.46492685e-03f, 2.63175163e-02f, -5.31219356e-02f, 1.87221002e-02f, -8.24862942e-02f, 6.39667585e-02f,
  -4.99856053e-03f, -8.62916932e-03f, -9.40211490e-02f, -1.62314512e-02f, 8.75701681e-02f, 7.54707307e-02f, -5.33156730e-02f, -5.76100834e-02f, -4.29652557e-02f, -6.24066964e-03f,
  7.48229697e-02f, 9.23956279e-03f, -1.14327632e-02f, 1.38588063e-02f, 8.19027945e-02f, 8.19827691e-02f, 7.07745776e-02f, 3.98672298e-02f, -9.02672671e-03f, 2.35162526e-02f,
  2.88486779e-01f, -9.11568180e-02f, -1.08172130e-02f, 2.00020149e-01f, 5.50984703e-02f, 9.69079696e-03f, 4.75117862e-02f, -1.14861988e-01f, 1.56202316e-01f, -1.55115306e-01f,
  -8.72422010e-02f, 8.32752958e-02f, 6.23797476e-02f, -1.77308358e-02f, -2.01956443e-02f, -2.70036957e-03f, -3.17135379e-02f, 1.56946778e-02f, 4.38981652e-02f, -6.40869141e-02f,
  -2.61132848e-02f, -1.56582609e-01f, -4.59150486e-02f, -2.83400327e-01f, -1.04357608e-01f, 6.98109269e-02f, -1.89126521e-01f, -1.01301700e-01f, -5.25847934e-02f, -1.40034676e-01f,
  7.01687858e-02f, -2.45261863e-02f, 5.77489510e-02f, -4.27803099e-02f, 2.64948718e-02f, 5.29109165e-02f, 2.90487800e-02f, -6.94615096e-02f, 5.13499975e-02f, 2.27900874e-02f,
  -1.38794985e-02f, -4.83540595e-02f, 6.07993081e-02f, 2.05580499e-02f, 7.17977285e-02f, 6.54310882e-02f, 7.03481957e-02f, 8.52112398e-02f, -3.31397168e-02f, 7.94425309e-02f,
  1.28198147e-01f, 7.50532821e-02f, -3.34224962e-02f, 4.42610309e-02f, 6.60573691e-02f, -1.37358969e-02f, 2.47659683e-02f, 1.13697112e-01f, 7.81463310e-02f, -5.74297383e-02f,
  -2.70015411e-02f, 6.21528961e-02f, -4.18256298e-02f, -4.57621664e-02f, -9.89253074e-03f, 6.78661913e-02f, -4.50596362e-02f, -8.42074826e-02f, -4.54540737e-02f, -1.61807816e-02f,
  -5.48586659e-02f, 8.12021717e-02f, 6.42934535e-03f, 4.49039228e-02f, 5.05670533e-03f, -2.13556681e-02f, -5.36761545e-02f, -4.91657890e-02f, -3.55799459e-02f, 1.20148631e-02f,
  1.89264957e-02f, 5.65755554e-02f, 7.87588283e-02f, -2.19804812e-02f, -3.17259021e-02f, -6.37945309e-02f, 2.22618673e-02f, -6.57018870e-02f, 1.27680134e-03f, -2.79531777e-02f,
  4.64014523e-02f, -6.47639111e-02f, 3.95531617e-02f, -3.77074964e-02f, -5.27709536e-02f, -9.47204307e-02f, -7.57296234e-02f, 3.02363969e-02f, 4.58340906e-02f, -6.73302636e-02f,
  -8.48314539e-03f, -6.73636794e-02f, -4.79632169e-02f, 2.56756190e-02f, -6.90176338e-02f, -4.40601073e-02f, -7.98004121e-03f, -3.71612012e-02f, -3.57332975e-02f, -7.75742307e-02f,
  1.88689586e-02f, -7.32398927e-02f, 7.99355954e-02f, 3.13767493e-02f, -9.70048532e-02f, -2.04741322e-02f, 5.90034872e-02f, 6.21734336e-02f, 4.20553684e-02f, -4.87365574e-02f,
  -3.37355316e-01f, 1.55596584e-01f, 3.04007586e-02f, -2.14358479e-01f, -1.17973432e-01f, 2.04896145e-02f, 2.35077488e-04f, 1.52641190e-02f, 1.68241430e-02f, 2.03580484e-01f,
  1.10465273e-01f, -1.69150621e-01f, 1.74997121e-01f, 5.45826228e-03f, -1.13115557e-01f, 2.20179498e-01f, 6.21898510e-02f, -2.35187691e-02f, -1.07719921e-01f, -1.37124464e-01f,
  -1.12617299e-01f, -4.68635149e-02f, 7.25445598e-02f, 1.47135472e-02f, -9.52477381e-02f, -1.25543460e-01f, -6.24038391e-02f, 6.52599940e-03f, -6.93468153e-02f, 7.82335028e-02f,
  -9.03286622e-04f, -3.91163975e-02f, -7.10304379e-02f, -9.09086019e-02f, -1.16814844e-01f, -1.46871144e-02f, 1.88816397e-03f, -8.68588313e-02f, -9.17902403e-03f, 4.31064665e-02f,
  -5.18267788e-02f, -5.58005236e-02f, 3.80954891e-02f, -5.84323853e-02f, -5.11770090e-03f, 5.90101779e-02f, -2.25192797e-03f, -2.92794053e-02f, 5.05323820e-02f, 6.00854680e-02f,
  8.45473483e-02f, 5.42300455e-02f, 3.28239538e-02f, 1.04848873e-02f, 7.37626925e-02f, 8.73351023e-02f, -5.59103861e-02f, 3.59157063e-02f, -8.35659727e-02f, 1.61444098e-02f,
  -1.94393527e-02f, 2.34824531e-02f, -3.77753787e-02f, 5.70638962e-02f, 6.02604449e-02f, -2.57892273e-02f, 9.52718128e-03f, -5.62709831e-02f, -4.33364213e-02f, -7.56168514e-02f,
  -6.42636269e-02f, -3.57305165e-03f, -6.66367710e-02f, 5.64331487e-02f, -1.01934560e-01f, -3.05442046e-02f, -4.74799499e-02f, -6.42355382e-02f, 7.74414837e-02f, 4.09350917e-02f,
  -1.77151915e-02f, 5.45625910e-02f, 2.84653232e-02f, -7.24012554e-02f, 7.02263564e-02f, 4.19630893e-02f, 5.94552979e-02f, 4.04239930e-02f, 1.11958263e-02f, 5.93809225e-02f,
  -2.05786258e-01f, -1.43152118e-01f, -2.66305711e-02f, 4.37733764e-03f, -6.90245926e-02f, 6.61481536e-05f, 3.20098363e-02f, -4.98486422e-02f, 1.98718514e-02f, 1.79512128e-02f,
  -7.35913739e-02f, -8.23545456e-02f, 5.01161395e-03f, 6.74874485e-02f, -5.15833609e-02f, -5.75731210e-02f, 1.33384513e-02f, -1.64085440e-02f, -3.35788056e-02f, -4.23909724e-02f,
  1.10994121e-02f, -9.51290578e-02f, -1.36573624e-04f, -3.09545845e-02f, -8.89684558e-02f, 8.11587721e-02f, -1.10125586e-01f, -1.93508249e-02f, 1.05823707e-02f, -7.23995492e-02f,
  -5.46037368e-02f, -1.94421411e-01f, -1.49750039e-01f, 2.93791369e-02f, 5.22984341e-02f, 8.17180350e-02f, -7.50295538e-03f, -6.79916814e-02f, -2.49057814e-01f, -3.69094498e-02f,
  4.99187689e-03f, 3.11812330e-02f, -8.32697675e-02f, -2.90801153e-02f, 3.40536609e-03f, -9.73420814e-02f, 9.68143046e-02f, 1.07090600e-01f, -1.10612012e-01f, 4.89044972e-02f,
  -5.78778274e-02f, 3.28034423e-02f, 3.27738859e-02f, -9.53542441e-03f, -2.74805333e-02f, 1.14454873e-01f, 1.65122986e-01f, 6.86950013e-02f, 1.65594026e-01f, 1.36200383e-01f,
  6.69889748e-02f, 1.09856762e-02f, -1.37722977e-02f, 4.47146688e-03f, 3.49950418e-02f, 5.63898459e-02f, 1.20351449e-01f, 1.00193180e-01f, 7.77099878e-02f, 5.88278212e-02f,
  2.05334220e-02f, 2.93017998e-02f, 6.55098557e-02f, -3.43301371e-02f, -5.38959503e-02f, -6.94385618e-02f, -1.14043348e-01f, 4.08724025e-02f, 6.32848442e-02f, -1.92233920e-02f,
  -1.16385452e-01f, 7.12416470e-02f, -6.55966699e-02f, 1.88969430e-02f, -9.18499604e-02f, -4.71330397e-02f, 1.68886930e-02f, 8.41628239e-02f, 7.04550296e-02f, 1.19214440e-02f,
  3.25594768e-02f, -1.70494448e-02f, -8.46047699e-02f, -8.31955671e-02f, 5.43877594e-02f, -1.11626205e-03f, 6.68571964e-02f, 7.86466673e-02f, -4.00507124e-03f, -4.28686850e-02f,
  -2.64562424e-02f, 7.22420737e-02f, -5.27192242e-02f, 5.17761037e-02f, -4.43874747e-02f, 1.28338509e-03f, 6.49234056e-02f, 8.05246830e-02f, 3.40203904e-02f, -8.35199207e-02f,
  9.92767606e-03f, 3.03495191e-02f, 4.92574321e-03f, 4.94481996e-02f, -4.82449494e-02f, 2.45113708e-02f, 4.66239937e-02f, 2.89270114e-02f, -1.29892314e-02f, 1.71164591e-02f,
  -2.68211458e-02f, -5.78079782e-02f, -1.03956066e-01f, 1.85086019e-02f, 2.24421406e-03f, -4.29006247e-03f, -5.66745102e-02f, -6.31896034e-02f, -9.15143825e-03f, 2.11895835e-02f,
  5.32001741e-02f, -4.88305790e-03f, -3.97784635e-02f, -3.58693153e-02f, 7.17520714e-02f, -5.99860959e-02f, 3.61981094e-02f, 8.13453421e-02f, -1.37337297e-03f, 2.31164638e-02f,
  2.84081213e-02f, -4.25822511e-02f, 5.70811033e-02f, -4.01248783e-02f, -6.94153309e-02f, 1.05083697e-01f, -7.04429392e-03f, 5.19208387e-02f, 1.56838237e-03f, -5.29423058e-02f,
  -4.91158888e-02f, -3.82250175e-02f, 8.05960670e-02f, 1.25680745e-01f, 3.77328545e-02f, -1.45998403e-01f, 7.97390640e-02f, -2.60824375e-02f, 2.60605011e-02f, -1.84361562e-01f,
  8.40574205e-02f, -2.84608491e-02f, -8.31867903e-02f, -3.73616293e-02f, 1.60366535e-01f, -3.75143848e-02f, 8.37280154e-02f, -1.11064399e-02f, 7.56200999e-02f, 4.56737056e-02f,
  1.81746840e-01f, 9.73214358e-02f, 4.74255942e-02f, -1.07612945e-02f, 9.71904323e-02f, 1.14697643e-01f, 1.09319702e-01f, -2.78607197e-02f, 4.01779602e-04f, 2.03094687e-02f,
  9.26140398e-02f, 9.12448764e-02f, 6.53341562e-02f, 2.04132516e-02f, -2.09279358e-02f, 2.06812900e-02f, -4.87455837e-02f, -6.82975650e-02f, 9.82182398e-02f, 4.59528007e-02f,
  2.62944456e-02f, -5.94981499e-02f, 1.78989843e-02f, -4.86348271e-02f, 9.00528058e-02f, -4.84788939e-02f, 4.47772667e-02f, 4.16433029e-02f, -2.26730797e-02f, -7.72293657e-02f,
  -2.19293851e-02f, 3.32359225e-02f, 3.21132652e-02f, -1.68046709e-02f, -3.66497263e-02f, 7.26836398e-02f, 3.50627792e-03f, -8.78277346e-02f, -3.85378338e-02f, -1.61445867e-02f,
  -1.09458202e-02f, -1.76390465e-02f, -1.34470896e-03f, -1.74449496e-02f, 3.19916047e-02f, 1.08506598e-01f, 7.38884434e-02f, -2.92231254e-02f, -2.61316951e-02f, 3.24693061e-02f,
  8.94042328e-02f, 3.20110843e-02f, -4.54073921e-02f, 6.28373073e-03f, 2.80216187e-02f, -6.49365783e-02f, 1.33652566e-02f, -8.22287723e-02f, 1.17583061e-03f, 6.30358607e-02f,
  4.34151925e-02f, 3.64246145e-02f, -1.77145749e-02f, 3.84228826e-02f, 7.49920458e-02f, -4.71193157e-02f, -8.66660625e-02f, -9.38291997e-02f, 7.95418322e-02f, 7.63593540e-02f,
  3.69177759e-02f, -5.25478758e-02f, 1.00517891e-01f, 9.25970227e-02f, 3.64003889e-02f, -8.11493397e-02f, 2.22600903e-02f, -4.32517193e-02f, -4.91364226e-02f, -3.47494595e-02f,
  -7.92016927e-03f, 1.54263815e-02f, 1.00667197e-02f, 8.73975754e-02f, -1.59938131e-02f, 5.54683581e-02f, 4.94615063e-02f, -3.48163210e-02f, 8.27073827e-02f, -2.71217655e-02f,
  -7.56478608e-02f, -6.49243817e-02f, -5.09263091e-02f, 9.55490395e-03f, 5.15909493e-02f, 3.25666666e-02f, 9.63892415e-03f, -5.78686036e-03f, -1.22550819e-02f, 5.28279804e-02f,
  -5.98408543e-02f, 2.80049182e-02f, 1.46024283e-02f, -9.44466610e-03f, 1.17635898e-01f, -1.81271322e-02f, -9.47741941e-02f, 1.12833768e-01f, 8.75235163e-03f, -5.41747995e-02f,
  -7.17035905e-02f, 2.39052866e-02f, -1.72089547e-01f, 1.04198894e-02f, -2.37431154e-02f, 3.30151282e-02f, 4.31174263e-02f, 1.22588230e-02f, 1.82812698e-02f, 3.70252430e-02f,
  1.64948925e-02f, -6.75686309e-03f, 1.06007673e-01f, 5.38064092e-02f, -6.53846189e-02f, 5.33325076e-02f, -7.87736196e-03f, 7.34829605e-02f, 9.17010382e-02f, 5.01999222e-02f,
  4.22138982e-02f, -8.32576752e-02f, -6.28787428e-02f, -1.03528783e-01f, -7.58097693e-02f, -1.62603091e-02f, 5.05112372e-02f, 9.65460390e-02f, 3.86777538e-04f, -7.30584189e-02f,
  -1.06503084e-01f, 5.59877604e-02f, 5.17304018e-02f, -2.69517582e-02f, -3.86058986e-02f, -3.46705616e-02f, 7.90602118e-02f, 6.52727857e-02f, -2.56748088e-02f, -2.20720060e-02f,
  7.72725046e-02f, -4.34415229e-02f, 5.66299744e-02f, 8.94419029e-02f, 1.11223338e-02f, 2.33935900e-02f, -3.23599689e-02f, -3.94659713e-02f, 8.17660987e-02f, 8.42572600e-02f,
  2.36844420e-02f, -5.32111991e-03f, -3.60719003e-02f, -6.23578988e-02f, 1.91610605e-02f, -7.27095641e-03f, 7.83078223e-02f, 6.35408163e-02f, -2.76669990e-02f, 3.99035215e-02f,
  -5.74249886e-02f, 5.45010194e-02f, 1.95843894e-02f, 6.66774586e-02f, 5.16907685e-02f, 1.92667115e-02f, 6.52218312e-02f, -3.42405662e-02f, 7.23402426e-02f, -1.96854565e-02f,
  -5.06269224e-02f, 6.17655627e-02f, -8.73896405e-02f, 6.75927624e-02f, 6.15898743e-02f, 6.82110637e-02f, -8.70809108e-02f, 1.82338096e-02f, 2.02595592e-02f, -6.70801848e-02f,
  -6.26086593e-02f, -1.47266909e-01f, -3.54935937e-02f, 6.07693382e-02f, -9.74222943e-02f, -6.90249773e-03f, 3.39338966e-02f, 1.02310227e-02f, -5.57302758e-02f, 1.43510997e-02f,
  -8.23263265e-03f, -6.36237115e-02f, -7.43786022e-02f, -1.88660715e-02f, 3.85516211e-02f, -4.99318428e-02f, -8.31980929e-02f, 2.33397987e-02f, -7.70020559e-02f, -3.25487927e-03f,
  1.55098066e-02f, 7.40207955e-02f, -6.15449138e-02f, 7.20953569e-02f, 8.53360295e-02f, -2.55653895e-02f, 8.14060494e-02f, 4.03346531e-02f, 6.43042475e-02f, -3.28032486e-02f,
  -3.98464240e-02f, 1.14719979e-02f, 6.90382272e-02f, 7.77682895e-03f, 1.86786160e-01f, 8.89973119e-02f, 9.57905948e-02f, 1.31797314e-01f, 1.43570125e-01f, -2.14910079e-02f,
  5.24390750e-02f, -1.16729252e-01f, -1.26681998e-01f, -7.54934028e-02f, 4.96183708e-02f, -4.43964340e-02f, 4.72922288e-02f, -4.97697145e-02f, 7.82459155e-02f, -3.48985307e-02f,
  -4.20852788e-02f, 1.18723633e-02f, -3.44304629e-02f, 1.53578143e-03f, 6.24548160e-02f, -5.40837198e-02f, -9.73865539e-02f, 2.83403900e-02f, -4.50097322e-02f, 6.41984269e-02f,
  3.35055292e-02f, -7.43118254e-03f, -4.38264199e-02f, 4.66179326e-02f, 7.00824186e-02f, 5.65302335e-02f, -4.00347449e-02f, 3.95016745e-02f, -1.19104851e-02f, 1.49832247e-02f,
  -9.16172713e-02f, -5.97264282e-02f, 9.93325375e-03f, 9.64377355e-03f, -3.21873762e-02f, -6.61503002e-02f, 5.21664843e-02f, 3.57177444e-02f, 9.35424045e-02f, -3.37463282e-02f,
  -6.64775744e-02f, -7.40226209e-02f, -1.72392856e-02f, -8.87557194e-02f, 4.00567427e-02f, -4.80026379e-02f, 5.65348603e-02f, -5.12659736e-02f, -7.37523586e-02f, 4.57002558e-02f,
  -1.39883370e-03f, -2.24228576e-02f, 9.50680487e-03f, -9.81028378e-02f, 2.24959161e-02f, -3.97145450e-02f, 2.52828584e-04f, 7.74036273e-02f, -5.30058593e-02f, -4.75226864e-02f,
  -1.76270809e-02f, 1.07221967e-04f, -3.33507545e-02f, 7.22410381e-02f, -8.22290778e-03f, -5.55988699e-02f, 2.71572899e-02f, -7.56796449e-03f, 9.47598815e-02f, 3.70935053e-02f,
  1.46842992e-03f, 6.17453530e-02f, 3.86163741e-02f, -1.70488991e-02f, 1.72451437e-02f, -1.86514705e-02f, -7.27341324e-02f, -2.15665866e-02f, -2.44273283e-02f, -1.00498635e-03f,
  -2.23947167e-02f, 1.06057808e-01f, -9.88662802e-03f, -6.94146976e-02f, 3.91636565e-02f, 3.65403891e-02f, -7.34717995e-02f, 2.83155702e-02f, 1.00129575e-01f, 6.50957897e-02f,
  1.51227117e-02f, 1.74260233e-02f, -5.37033677e-02f, -1.84932072e-02f, 4.40217070e-02f, 6.82438985e-02f, -3.42658050e-02f, 4.75979187e-02f, 1.27558216e-01f, -1.46436719e-02f,
  -1.05773903e-01f, 3.51890363e-02f, -2.09816825e-02f, 9.43405405e-02f, -2.22712196e-02f, 6.15805760e-02f, 8.33643973e-02f, -2.82966197e-02f, -6.81363642e-02f, 3.71500403e-02f,
  3.64297144e-02f, 4.64148931e-02f, 1.87137034e-02f, -7.89593533e-02f, -1.26767367e-01f, -9.87861454e-02f, -1.68997467e-01f, -2.86299381e-02f, -4.91995104e-02f, 1.26379281e-02f,
  2.16694195e-02f, 1.25731463e-02f, 1.32432774e-01f, 9.83898193e-02f, 1.08185761e-01f, 7.06431121e-02f, -2.35723574e-02f, -7.99703225e-02f, 3.38804745e-03f, 1.03478014e-01f,
  1.72780737e-01f, 9.26750228e-02f, 2.18456641e-01f, 1.12993836e-01f, 4.91449833e-02f, 1.00069575e-01f, 8.57721344e-02f, 5.44146150e-02f, -6.24014251e-02f, 4.79310155e-02f,
  -1.80857461e-02f, 1.32377759e-01f, -1.41328359e-02f, -7.98674300e-02f, -6.45454694e-03f, 5.07748313e-02f, 2.61192303e-02f, 1.15037495e-02f, 3.11855748e-02f, -2.53213421e-02f,
  -1.09142274e-01f, 6.96541816e-02f, -2.13330183e-02f, 6.39434755e-02f, 2.83177514e-02f, 6.69888631e-02f, 4.50933501e-02f, 2.55192425e-02f, -1.01640172e-01f, 1.15233220e-01f,
  3.84501368e-02f, 3.61343026e-02f, 6.14665747e-02f, -7.68648386e-02f, 6.17156364e-02f, 1.60225779e-02f, -1.97853092e-02f, 1.95532087e-02f, 1.57271232e-02f, 2.69835291e-04f,
  7.02229217e-02f, -1.45683130e-02f, -6.95804060e-02f, 6.12621643e-02f, 4.24202830e-02f, 6.08037226e-03f, -1.90550424e-02f, 4.47936095e-02f, 4.02297080e-02f, -6.30352199e-02f,
  -8.79726466e-03f, -5.91677651e-02f, -4.27850895e-02f, -6.83284625e-02f, -2.41265334e-02f, 6.02972880e-02f, -7.28134289e-02f, -8.01881850e-02f, -8.77548680e-02f, 3.84371094e-02f,
  6.21291921e-02f, 8.58878437e-03f, -7.29042813e-02f, 8.72728750e-02f, -2.03778455e-03f, -7.29834512e-02f, -1.94434002e-02f, -8.24599862e-02f, 1.94654576e-02f, -5.22780046e-02f,
  9.31687355e-02f, 1.44645020e-01f, 6.41864762e-02f, -4.36908193e-02f, 9.39094573e-02f, 8.74613449e-02f, 3.73801216e-02f, -1.73147265e-02f, 9.51459035e-02f, 2.10309532e-02f,
  5.95345683e-02f, -5.88468425e-02f, 1.74183436e-02f, -7.27935731e-02f, 4.64183949e-02f, -1.01800926e-01f, -6.47432208e-02f, -5.70540726e-02f, 1.31930336e-02f, 5.17873801e-02f,
  9.60320234e-02f, -5.29151596e-02f, -8.14956613e-04f, 7.56508345e-03f, -4.50549163e-02f, -5.32558598e-02f, 5.09877019e-02f, 6.32106438e-02f, 5.58129363e-02f, -5.25150858e-02f,
  -2.13294432e-01f, 7.85228983e-03f, 1.48145735e-01f, -8.35855156e-02f, 1.04737505e-01f, 3.60072553e-02f, 1.50050461e-01f, 1.55761195e-02f, 1.98347420e-02f, -1.43580273e-01f,
  -9.24369320e-02f, -7.50904083e-02f, 7.21081719e-02f, -2.00530235e-02f, -5.33828326e-03f, 1.77963416e-03f, -1.20739736e-01f, 2.36105174e-02f, 8.73715356e-02f, -3.75741050e-02f,
  -6.95435777e-02f, 3.52092125e-02f, 9.73589644e-02f, 6.28771186e-02f, 1.20907798e-02f, -1.41960576e-01f, -1.23289272e-01f, 1.61787108e-01f, 2.16394593e-03f, -2.31023077e-02f,
  -7.75214061e-02f, -4.09672409e-03f, 4.46655788e-02f, -6.52681366e-02f, -6.31199405e-02f, -4.74450216e-02f, -1.42098516e-02f, -1.25528201e-02f, -6.72006309e-02f, -4.00563069e-02f,
  2.06606183e-02f, 4.16602381e-02f, -6.56619444e-02f, -5.92063777e-02f, -4.31308337e-02f, 3.17923054e-02f, -2.16993485e-02f, 5.42367287e-02f, -2.68625263e-02f, 8.15202743e-02f,
  5.81316054e-02f, 3.76530774e-02f, -6.39673993e-02f, 5.43206781e-02f, -4.45261877e-03f, 4.85153496e-02f, -4.39251438e-02f, -1.52663104e-02f, -6.88971952e-02f, -3.29819955e-02f,
  1.14849452e-02f, 4.42176312e-03f, -3.34888026e-02f, 8.40706974e-02f, -2.63209804e-03f, -3.02457251e-02f, 7.62512311e-02f, 1.99336931e-03f, 2.85931416e-02f, -2.67878547e-02f,
  2.76793148e-02f, 4.26277108e-02f, 9.83175710e-02f, 2.24449839e-02f, 8.36528931e-03f, -6.77954964e-03f, -1.53397620e-02f, -7.61982501e-02f, -4.10688929e-02f, 4.10121121e-02f,
  4.61734906e-02f, 7.15832189e-02f, 9.64217931e-02f, 5.73323630e-02f, -9.55351219e-02f, 7.61897787e-02f, -1.39471767e-02f, -1.85086727e-02f, 1.69984549e-02f, 4.16870229e-02f,
  -1.38948366e-01f, -1.30918190e-01f, -3.09049990e-02f, 7.15984777e-02f, -8.46607611e-02f, 2.24080365e-02f, -9.70819667e-02f, -1.05099745e-01f, 1.60677768e-02f, -4.38478775e-02f,
  -3.98658104e-02f, 2.99342908e-02f, -9.21761617e-02f, 2.99789198e-02f, 5.38028330e-02f, 5.73851019e-02f, -3.97669785e-02f, 1.85527932e-02f, -5.47708571e-02f, -2.28696261e-02f,
  -2.24420149e-03f, -6.54224977e-02f, 9.18331519e-02f, 5.75287603e-02f, -4.44414048e-03f, -2.60493346e-02f, -9.76640359e-02f, -3.73370759e-02f, 3.70400026e-02f, -7.14657977e-02f,
  -1.36845082e-01f, 9.41418633e-02f, 2.02923790e-01f, 3.84617783e-02f, 1.30634606e-01f, 4.78111841e-02f, 6.10108525e-02f, 1.66860193e-01f, -6.29997328e-02f, -1.41826332e-01f,
  -8.95055458e-02f, -6.68255687e-02f, -2.47288700e-02f, 6.37313202e-02f, 9.45323438e-04f, -7.23140538e-02f, -6.74511567e-02f, 1.10998899e-02f, 6.88318312e-02f, -1.86457541e-02f,
  6.75597647e-03f, -1.50003091e-01f, 4.93788868e-02f, -4.59941402e-02f, 1.07764445e-01f, 7.92525150e-03f, -1.23121627e-01f, -5.90948053e-02f, -3.80819812e-02f, -7.68634826e-02f,
  2.19641756e-02f, -9.42312777e-02f, 5.75527898e-04f, 9.04126465e-02f, -5.80709651e-02f, 3.31171229e-02f, -2.26683449e-02f, 4.16736901e-02f, 2.80937552e-02f, -5.29588759e-02f,
  -1.32327685e-02f, -5.23075312e-02f, -6.17997870e-02f, 4.26308364e-02f, 6.05816171e-02f, 5.83349951e-02f, 7.95284435e-02f, 5.13104610e-02f, 6.93477765e-02f, 2.32209750e-02f,
  1.36973307e-01f, 1.16858855e-01f, 2.47042645e-02f, -3.59409750e-02f, 3.65484692e-02f, -2.54452620e-02f, 8.28310698e-02f, -1.01787774e-02f, 6.71191439e-02f, -7.14585464e-03f,
  9.64827649e-03f, -4.88703214e-02f, -1.31520804e-03f, -5.22027127e-02f, 6.24600649e-02f, 2.44032498e-02f, 6.75366297e-02f, 6.77888170e-02f, -3.72582786e-02f, 4.06117626e-02f,
  4.22486328e-02f, 7.87341781e-03f, 3.57808433e-02f, -3.60660739e-02f, -3.91606875e-02f, -6.22080564e-02f, 8.38380365e-04f, 9.00707543e-02f, -3.73060554e-02f, -5.34695797e-02f,
  6.00752756e-02f, -3.67155261e-02f, -1.78761687e-02f, 4.33771610e-02f, 2.79441047e-02f, 5.75881749e-02f, 1.67107694e-02f, -2.33029258e-02f, 8.29213578e-03f, -4.62470613e-02f,
  -7.53691420e-02f, -1.61229715e-01f, -5.06982114e-03f, -3.24257873e-02f, -6.19891770e-02f, -3.81831005e-02f, 5.62081747e-02f, -3.25604752e-02f, 3.65193859e-02f, 4.25407402e-02f,
  1.20322919e-02f, -1.45406807e-02f, 2.74426881e-02f, -7.74418786e-02f, -3.95561419e-02f, -6.69673532e-02f, -7.54699484e-02f, -9.44980383e-02f, 6.99676201e-02f, -2.32022963e-02f,
  -4.07262109e-02f, -5.74637875e-02f, -6.20223805e-02f, -5.03166020e-02f, 2.40156264e-03f, -5.87136634e-02f, -2.23301374e-03f, -3.78070362e-02f, -4.50724363e-02f, -7.52393156e-03f,
  -1.05305403e-01f, 1.59772530e-01f, -3.88738364e-02f, 1.23787209e-01f, -6.29661381e-02f, 4.89100888e-02f, 3.03688226e-03f, -1.53579060e-02f, 8.97337496e-03f, 1.93747461e-01f,
  8.11230242e-02f, -7.78225157e-03f, 1.15324281e-01f, 7.81253651e-02f, 2.53984854e-02f, 1.13195077e-01f, 1.97444871e-01f, 1.28209502e-01f, -6.85745478e-02f, 7.48444945e-02f,
  1.04829436e-02f, 1.25136554e-01f, 9.41130444e-02f, 8.78100321e-02f, -7.24975672e-03f, -3.47636715e-02f, 1.42492414e-01f, -9.52664912e-02f, 3.09772436e-02f, 3.69535685e-02f,
  4.15131189e-02f, 4.67196479e-02f, 2.26978194e-02f, -8.63176510e-02f, 4.05923650e-03f, 2.44800653e-02f, -6.26206547e-02f, -1.12011261e-01f, 5.77253215e-02f, -3.71132120e-02f,
  -9.32127684e-02f, -1.04130566e-01f, -7.44646713e-02f, 6.37462288e-02f, -7.85230622e-02f, -4.35115919e-02f, -5.45314029e-02f, -5.54873459e-02f, 7.36317486e-02f, -2.72122435e-02f,
  5.66719919e-02f, -5.53929619e-02f, -3.71101722e-02f, 7.96862096e-02f, -4.96348217e-02f, 5.26823476e-02f, -2.42951736e-02f, -1.10762529e-02f, 7.03819469e-02f, 5.48526235e-02f,
  -2.19548792e-02f, -8.51522759e-02f, -6.84477463e-02f, -1.02259599e-01f, -5.54610416e-02f, 4.95751984e-02f, -5.14083467e-02f, -1.80840548e-02f, -2.15185829e-03f, 9.28012952e-02f,
  -5.97242266e-02f, -4.33848761e-02f, -5.36975339e-02f, 2.28183228e-04f, 1.98382903e-02f, 1.43189332e-03f, -3.06737404e-02f, -3.38407531e-02f, 5.72108999e-02f, -9.51826870e-02f,
  5.79211535e-03f, 5.61771281e-02f, 5.50038889e-02f, 4.40710597e-03f, -1.84900034e-02f, -2.55435295e-02f, -3.05786207e-02f, -1.44827701e-02f, 1.67681556e-02f, -8.29425007e-02f,
  1.71511788e-02f, 1.63734242e-01f, -5.68731613e-02f, 4.68651839e-02f, 2.86269709e-02f, -5.94063811e-02f, 3.16085480e-02f, 7.69137917e-03f, 4.65651266e-02f, 8.45909417e-02f,
  8.54686126e-02f, -7.57155195e-02f, 2.87547484e-02f, 5.65124415e-02f, 8.23238268e-02f, 1.39878467e-02f, 7.46186450e-02f, 8.03159103e-02f, 3.30211185e-02f, 5.48626930e-02f,
  -6.92033246e-02f, 5.85402660e-02f, 2.57134382e-02f, 3.18382159e-02f, 4.52175774e-02f, 6.85151517e-02f, -7.74364918e-02f, 1.13417590e-02f, 5.05680144e-02f, 4.11167415e-03f,
  6.35146126e-02f, -8.11899081e-02f, 1.77338406e-01f, 8.89378041e-02f, 1.46220520e-01f, 3.62728797e-02f, 3.33931297e-02f, 1.09811328e-01f, 3.21584605e-02f, -4.46159244e-02f,
  -4.64538559e-02f, -1.37796521e-01f, 6.36777356e-02f, -1.02655768e-01f, -4.60711606e-02f, 5.01432642e-02f, -1.30277187e-01f, -1.24454759e-01f, 2.00594142e-02f, -1.32045744e-03f,
  1.36869019e-02f, -9.43621844e-02f, 7.79760024e-03f, -9.79398340e-02f, 1.43434387e-02f, 8.83666575e-02f, -8.75205621e-02f, 3.96394469e-02f, -1.29329264e-02f, -4.70997505e-02f,
  3.71952616e-02f, 1.47937646e-03f, 8.22629556e-02f, 4.15830985e-02f, -2.79184412e-02f, -4.47925515e-02f, -8.68178159e-02f, 1.10559491e-02f, 1.21884227e-01f, 4.58796136e-02f,
  -1.10552140e-01f, 6.97183907e-02f, -8.20902735e-02f, 1.78975135e-03f, -4.98609804e-02f, 8.50916952e-02f, 1.69088189e-02f, 4.01621424e-02f, -7.51289502e-02f, -3.79243493e-02f,
  -1.64903793e-02f, -1.85229480e-02f, 8.89688283e-02f, -5.26077859e-02f, -5.83412461e-02f, 3.64336930e-02f, -3.13581270e-03f, -1.65647231e-02f, -1.22589879e-02f, -2.82532629e-02f,
  -1.12164706e-01f, -9.24866498e-02f, 2.40290724e-02f, 6.77232519e-02f, 3.71132483e-05f, -1.81042645e-02f, 7.44292587e-02f, -6.12491369e-02f, -2.41754986e-02f, -6.69139102e-02f,
  2.91815959e-02f, -2.91179493e-02f, 2.69658025e-02f, 7.14276033e-03f, 1.05035994e-02f, -7.14932103e-03f, -6.64882408e-03f, 8.83531496e-02f, -6.66827485e-02f, -1.85396820e-02f,
  -9.56918076e-02f, 3.99813652e-02f, 9.53788985e-04f, 2.11121254e-02f, -3.99800241e-02f, -6.41595274e-02f, -4.00195345e-02f, 5.57811409e-02f, -4.65509016e-03f, -7.65221417e-02f,
  -4.31636050e-02f, -5.94934635e-02f, -2.84582954e-02f, -5.34855425e-02f, -1.12870550e-02f, 3.21426988e-02f, 1.76623482e-02f, -1.33117400e-02f, -3.00041083e-02f, 5.50772771e-02f,
  -3.82666029e-02f, -5.19680157e-02f, 1.55522218e-02f, 8.83712322e-02f, -2.05677599e-02f, -1.60158928e-02f, -1.05941169e-01f, -6.89548403e-02f, -3.76522988e-02f, -6.75205216e-02f,
  -8.01412016e-03f, 4.28150557e-02f, 6.76994696e-02f, -5.33091277e-02f, -7.12637901e-02f, -1.00605704e-01f, 8.48724768e-02f, -8.94077420e-02f, 2.30026096e-02f, 1.24666383e-02f,
  2.77748462e-02f, 1.15254857e-02f, -2.07634389e-01f, -1.66938230e-01f, -9.58991274e-02f, -1.50885627e-01f, -2.69835144e-01f, -1.37456238e-01f, 2.07601041e-02f, -1.43790105e-02f,
  -6.98557943e-02f, 3.09375357e-02f, 3.33847739e-02f, -2.43832096e-01f, 5.40683009e-02f, 3.42857838e-02f, -6.78354204e-02f, -1.13880627e-01f, 5.59256636e-02f, -1.96684320e-02f,
  -3.09066400e-02f, -2.06025198e-01f, -2.01761127e-01f, -2.06855759e-02f, -1.27329841e-01f, -3.74844484e-02f, 8.82220641e-02f, -2.54111048e-02f, -6.42092824e-02f, -2.48618368e-02f,
  -3.01074833e-02f, -5.08704074e-02f, -7.13259205e-02f, 4.59586978e-02f, -3.00016198e-02f, 7.42164701e-02f, 4.19973470e-02f, 4.96607311e-02f, 2.06662179e-03f, 8.01347941e-02f,
  2.45885178e-02f, -4.98594046e-02f, -6.55585676e-02f, 3.56376506e-02f, -2.15402748e-02f, -3.23360860e-02f, -1.07790962e-01f, 8.36529881e-02f, -6.26425073e-02f, -8.03619474e-02f,
  -4.14188998e-03f, 6.22374900e-02f, 1.59242395e-02f, 5.18543012e-02f, -3.70461345e-02f, 2.35140026e-02f, -6.86209276e-02f, -4.67064790e-02f, 4.54878211e-02f, 5.71535435e-03f,
  8.89773071e-02f, -4.43007760e-02f, -4.64861244e-02f, -1.11123957e-02f, -1.74232293e-02f, -7.86253139e-02f, 2.19209325e-02f, 4.46431413e-02f, 5.21917343e-02f, -5.44056185e-02f,
  6.34991378e-02f, 1.94370244e-02f, -6.36872463e-03f, -2.74873096e-02f, 4.90244478e-02f, 5.24830744e-02f, 4.44148593e-02f, 7.84973577e-02f, 1.94884259e-02f, 6.08640648e-02f,
  5.00167161e-02f, 9.54982752e-05f, -7.63214082e-02f, 7.07150772e-02f, -7.74969161e-02f, -6.06571585e-02f, 3.31350253e-03f, -1.28203155e-02f, -7.33833760e-02f, 3.71566676e-02f,
  1.18204774e-02f, 9.28642303e-02f, -2.97563113e-02f, 4.82335314e-02f, 3.01436521e-02f, 3.69114093e-02f, 5.69737814e-02f, 2.24926136e-02f, -5.77563420e-02f, 6.59328839e-03f,
  8.97496417e-02f, 4.70872298e-02f, -2.85076275e-02f, -2.71585546e-02f, 8.79774150e-03f, 3.98382582e-02f, 3.39753889e-02f, 3.17003056e-02f, 3.70381400e-02f, 1.07410215e-02f,
  -9.86033864e-03f, -6.59837350e-02f, 1.10673390e-01f, 9.60889608e-02f, -1.24063818e-02f, -3.30745019e-02f, 1.02255389e-01f, 5.92178665e-02f, -5.60141169e-02f, 4.33239043e-02f,
  4.41545248e-02f, 1.19077861e-01f, -8.28061625e-02f, 1.50516788e-02f, 1.53158024e-01f, 4.78861816e-02f, 8.64506364e-02f, 1.20391779e-01f, 7.12596029e-02f, 6.20947499e-03f,
  2.83720698e-02f, 5.88931441e-02f, 3.35017107e-02f, 9.32519659e-02f, 3.20593975e-02f, 5.51423430e-02f, 1.08424686e-01f, 3.22840847e-02f, -3.27672586e-02f, 2.45432425e-02f,
  -7.49587342e-02f, 7.13813230e-02f, -1.77711114e-01f, 4.63578478e-02f, 6.92030862e-02f, -5.36649451e-02f, -8.51406455e-02f, 1.25919431e-02f, -6.62412941e-02f, -5.32475812e-03f,
  -3.26362178e-02f, 7.35449791e-02f, -3.08563095e-02f, 3.94383371e-02f, -9.63919144e-03f, -2.21038703e-02f, -1.41106138e-03f, -5.16637601e-02f, -9.37815607e-02f, 9.64041054e-02f,
  5.13277426e-02f, 1.01049677e-01f, 3.10933962e-02f, 2.95109581e-02f, -2.74122716e-03f, -1.33647406e-02f, -3.59791517e-02f, -4.37744381e-03f, -3.21362953e-04f, 4.78072800e-02f,
  -1.03406988e-01f, 3.06977779e-02f, 3.04312147e-02f, -4.24043164e-02f, -1.86302420e-02f, 3.83095443e-02f, 2.49669747e-03f, 1.67239201e-03f, -2.07563527e-02f, 1.11244649e-01f,
  -3.81672308e-02f, -3.97587568e-02f, 5.39998151e-02f, 6.07775636e-02f, 6.23384630e-03f, -1.00674359e-02f, 1.21416356e-02f, -9.82136652e-03f, -2.85653006e-02f, -6.52833432e-02f,
  -1.98447499e-02f, 1.75037794e-02f, 8.03311318e-02f, 8.96741264e-03f, -1.76161658e-02f, 3.90221104e-02f, -2.60141380e-02f, 7.06402287e-02f, 2.12952290e-02f, 7.98783228e-02f,
  -4.61014435e-02f, 3.84739079e-02f, -1.04072466e-02f, -7.50113726e-02f, -7.38664046e-02f, 1.76354423e-02f, 7.99124762e-02f, -6.09012507e-02f, -1.79403555e-02f, -5.73532544e-02f,
  -1.65677052e-02f, 8.09422210e-02f, -3.45327780e-02f, -4.75477092e-02f, 1.90537535e-02f, 9.07957777e-02f, 4.30894233e-02f, 8.18141103e-02f, 2.59123147e-02f, 4.46118228e-02f,
  -1.02290913e-01f, 6.15546778e-02f, -4.69661243e-02f, 6.72583953e-02f, 5.00322320e-02f, 1.09080769e-01f, -4.85024508e-03f, -4.93478253e-02f, -8.68115053e-02f, -4.55995277e-02f,
  7.22386390e-02f, 6.86657578e-02f, -9.60795209e-02f, -5.15405163e-02f, 5.05011082e-02f, -3.52622941e-02f, -6.29612803e-02f, -4.67734747e-02f, -9.13634747e-02f, -2.94706617e-02f,
  -5.81389777e-02f, -3.86440642e-02f, -2.00217128e-01f, -2.53067184e-02f, -7.69330282e-03f, 1.50580943e-01f, 4.82011139e-02f, 2.62460783e-02f, -1.83352798e-01f, 2.06120804e-01f,
  1.42671719e-01f, -1.37887120e-01f, -5.59845008e-02f, -2.27754880e-02f, -2.77772516e-01f, -1.22922845e-01f, 7.44416267e-02f, 1.39580652e-01f, -1.26627073e-01f, 6.86497390e-02f,
  -8.11923668e-02f, -2.51153316e-02f, -1.70019250e-02f, 8.78867209e-02f, 1.06124029e-01f, -1.43881068e-02f, 1.61927953e-01f, 7.54481107e-02f, 9.77197476e-03f, -1.41359540e-02f,
  1.36378093e-03f, -6.45809919e-02f, 4.81363647e-02f, 3.52890678e-02f, 1.46127582e-01f, 1.09044276e-01f, 1.17023326e-01f, -2.07507797e-03f, -2.35405713e-02f, -5.54787852e-02f,
  4.40971293e-02f, 4.12348136e-02f, -5.54117523e-02f, -4.92036641e-02f, 5.74794002e-02f, 4.62773219e-02f, -1.33055791e-01f, 1.95162520e-02f, -7.41987973e-02f, 3.29443403e-02f,
  -5.84387258e-02f, 1.40696457e-02f, 9.98593122e-02f, -2.28844732e-02f, -9.22147930e-02f, -2.94093117e-02f, 2.46412661e-02f, -1.05027286e-02f, 6.50100857e-02f, -6.61572665e-02f,
  -2.27654018e-02f, 9.34155732e-02f, 5.40206954e-02f, -1.09689094e-01f, -7.98326507e-02f, 4.76812907e-02f, -5.23677245e-02f, -6.46367148e-02f, -3.78509462e-02f, 5.66351647e-03f,
  5.72590567e-02f, -6.18564375e-02f, 9.53883212e-03f, -1.61608495e-02f, 6.51367307e-02f, 4.71104495e-02f, 1.68944169e-02f, 1.86753143e-02f, -3.69302519e-02f, -7.60917589e-02f,
  4.04526992e-03f, -1.21255568e-03f, 3.77146304e-02f, 1.84107050e-02f, 3.44538651e-02f, 8.69103074e-02f, -6.13413639e-02f, -1.62273813e-02f, -9.61885881e-03f, 9.38249156e-02f,
  1.12549467e-02f, 2.91519258e-02f, -1.00067668e-01f, -7.70656997e-03f, 6.69301152e-02f, 4.38282304e-02f, 2.55389586e-02f, -8.65620673e-02f, -4.70040515e-02f, -4.49526086e-02f,
  7.21469522e-02f, -2.36808346e-03f, 7.76876807e-02f, 4.92244214e-02f, -7.77562484e-02f, 5.79584129e-02f, 7.56788701e-02f, 4.55729216e-02f, -3.94999236e-02f, -2.93135997e-02f,
  5.54223321e-02f, -3.41360420e-02f, 5.77929877e-02f, -7.65651837e-02f, 8.78029689e-03f, -1.01174396e-02f, -9.91000235e-03f, -4.85318452e-02f, -7.52661675e-02f, -6.96016126e-04f,
  -1.71911374e-01f, 1.96539432e-01f, -1.09383032e-01f, 1.69555634e-01f, -1.35547698e-01f, -9.33665037e-02f, 1.51676327e-01f, 1.19127147e-02f, -1.04092816e-02f, 2.61020929e-01f,
  2.13432282e-01f, -1.39850480e-02f, 9.44468901e-02f, 1.48538217e-01f, -2.15950925e-02f, 1.64589092e-01f, 2.08319783e-01f, 4.75647002e-02f, -5.75029589e-02f, 7.70481080e-02f,
  4.30263318e-02f, 9.16131064e-02f, 1.32390618e-01f, -3.72009762e-02f, 6.25585839e-02f, -1.14293672e-01f, 1.23631889e-02f, -5.50618283e-02f, 1.12466507e-01f, -8.14719591e-04f,
  5.42637296e-02f, 8.01953375e-02f, -1.09719999e-01f, -4.33427915e-02f, -5.63605130e-02f, -3.11348382e-02f, -3.49337868e-02f, -2.59847082e-02f, -5.92015907e-02f, 8.76167789e-02f,
  4.62640077e-02f, -4.30576727e-02f, -5.49480282e-02f, 4.32010591e-02f, -8.72942805e-02f, -1.32592665e-02f, -6.20477349e-02f, -3.73699218e-02f, -3.40983011e-02f, -6.33194372e-02f,
  2.54760534e-02f, -2.55784746e-02f, 7.76401013e-02f, 4.48600650e-02f, -7.26073906e-02f, -7.08477497e-02f, -5.16032726e-02f, 9.46760178e-03f, -4.64521199e-02f, 3.91466450e-03f,
  -6.48270696e-02f, 7.90825486e-02f, -2.57796105e-02f, 5.14471978e-02f, -3.37156001e-03f, -3.99616063e-02f, -5.60864108e-03f, -1.16294902e-02f, 3.97129692e-02f, 9.07917917e-02f,
  1.35373138e-03f, -1.68597940e-02f, 2.14252784e-03f, 4.47424613e-02f, 8.49537402e-02f, 5.98754026e-02f, 1.17129628e-02f, -3.91738862e-02f, 1.86782647e-02f, 2.37587970e-02f,
  -3.71286832e-02f, 4.91761640e-02f, -1.89153180e-02f, 2.39875056e-02f, -3.76164131e-02f, -4.09344099e-02f, 2.19373335e-03f, -8.13972298e-03f, 1.21682724e-02f, 3.09950802e-02f,
  6.37352467e-02f, 1.68740585e-01f, 3.36788855e-02f, -2.21158639e-02f, -4.24532145e-02f, -6.72250614e-02f, -3.73590365e-02f, 2.60962024e-02f, 1.17911875e-01f, -8.30614194e-02f,
  4.96859150e-03f, 5.02257496e-02f, -2.41275225e-02f, 1.96162499e-02f, 1.04287844e-02f, 8.97844285e-02f, 5.21013280e-03f, 5.83465621e-02f, 6.13321438e-02f, 7.78291523e-02f,
  -2.01771315e-02f, 7.33708078e-03f, 2.22457759e-02f, 2.61279698e-02f, -4.44430262e-02f, 5.71341068e-02f, 6.41353801e-03f, 3.25001514e-04f, 2.97633111e-02f, 2.54383869e-02f,
  -2.00884849e-01f, 2.73590773e-01f, 7.75545388e-02f, -4.42881212e-02f, -8.79643485e-02f, 1.32974684e-01f, 8.85382295e-02f, 1.48668289e-01f, 2.44617566e-01f, 3.05903926e-02f,
  -1.95131943e-01f, 8.40043556e-03f, -4.32472080e-02f, -1.12727880e-02f, 7.89252594e-02f, 1.31118923e-01f, 1.42631024e-01f, 6.88539892e-02f, 1.89304024e-01f, -1.22680478e-01f,
  -4.32696976e-02f, -1.89494759e-01f, -4.90903258e-02f, -9.32238922e-02f, -2.18678162e-01f, -5.11377119e-02f, -2.41790101e-01f, 8.45755190e-02f, -1.36813253e-01f, -2.83559319e-02f,
  5.53769283e-02f, -8.60473663e-02f, -4.98214662e-02f, -3.34988385e-02f, -2.35528555e-02f, -3.62026952e-02f, -3.99899529e-03f, 4.70552221e-02f, -2.87157726e-02f, -5.52076995e-02f,
  1.14042712e-02f, 3.93472388e-02f, -4.21101339e-02f, 5.02808057e-02f, 5.71693182e-02f, -4.90647890e-02f, 2.39989292e-02f, 1.95867009e-02f, -1.69109218e-02f, -6.25686720e-02f,
  -1.02108493e-01f, -1.55568179e-02f, -7.54073188e-02f, -3.94697441e-03f, -6.67981710e-03f, -9.08681601e-02f, 4.34501842e-02f, -9.90964174e-02f, 2.15180758e-02f, -1.69697497e-02f,
  -4.78122868e-02f, 8.89919400e-02f, -9.02642980e-02f, -1.33718373e-02f, -1.49678104e-02f, 2.52888780e-02f, 5.32553941e-02f, 3.99633124e-02f, 1.13566183e-01f, -9.72998962e-02f,
  -3.21764648e-02f, 8.87895760e-04f, -4.26089428e-02f, -6.53229840e-03f, -2.51357183e-02f, 5.01194596e-02f, -1.04109824e-01f, -3.90793011e-02f, -4.76091690e-02f, -4.05722447e-02f,
  -7.40271360e-02f, -2.48695314e-02f, 7.45705701e-03f, 5.17122336e-02f, -2.46843919e-02f, -8.12377110e-02f, -9.55632925e-02f, -1.01440093e-02f, -8.56038406e-02f, -1.14401325e-03f,
  1.41854897e-01f, 1.84025213e-01f, 7.30296820e-02f, 3.42805050e-02f, -2.95224898e-02f, -1.75784566e-02f, 4.19299752e-02f, -2.08769599e-03f, 2.24090577e-03f, 2.95282584e-02f,
  1.01358509e-02f, 3.69847901e-02f, -1.10368617e-01f, -1.37740681e-02f, 4.90944982e-02f, 1.94526855e-02f, -8.48178752e-03f, 7.79904649e-02f, -2.72707194e-02f, -1.76050458e-02f,
  -2.73040738e-02f, 5.61720021e-02f, -8.78257528e-02f, 4.43437044e-03f, 2.03575380e-02f, -8.51998404e-02f, 5.36001995e-02f, 9.22537297e-02f, -5.80193773e-02f, -3.35652352e-04f,
  1.42294437e-01f, -1.00138091e-01f, -9.80141237e-02f, 4.52721231e-02f, -3.03156711e-02f, 6.94156811e-02f, -5.78216463e-02f, -1.81877054e-02f, -2.31996365e-02f, -2.82997694e-02f,
  -1.14425486e-02f, 5.15538007e-02f, -2.00395525e-01f, 2.26890370e-01f, 9.88758728e-02f, -1.89941432e-02f, 1.09044060e-01f, 6.50452599e-02f, -5.38046695e-02f, 5.75535186e-02f,
  9.24960673e-02f, 1.59038261e-01f, 1.16174713e-01f, 1.81414172e-01f, 9.51598957e-02f, -2.48333495e-02f, -1.05976406e-02f, -1.87055636e-02f, 1.98465973e-01f, 1.84726551e-01f,
  -1.94806028e-02f, -1.05910391e-01f, -5.23810573e-02f, 6.37283325e-02f, 4.74334024e-02f, 2.55174469e-02f, 1.80384871e-02f, 6.54549897e-02f, -2.27100514e-02f, -6.69377968e-02f,
  -2.11822614e-03f, -3.22123654e-02f, 4.15331572e-02f, -1.64074339e-02f, -6.11811467e-02f, -3.24108042e-02f, 2.39593703e-02f, -1.08488940e-01f, 4.91841510e-02f, 2.41955500e-02f,
  -1.40181063e-02f, -3.74804735e-02f, 5.10318726e-02f, 2.21590120e-02f, -3.68396454e-02f, -3.51157486e-02f, 6.72416389e-02f, -4.95979525e-02f, 7.36458600e-02f, 2.10485957e-03f,
  -5.98311648e-02f, -4.94443215e-02f, -7.74871483e-02f, -3.20744999e-02f, -6.57546222e-02f, -2.93787699e-02f, -6.30346760e-02f, 4.06191126e-03f, 3.58285978e-02f, -1.79067366e-02f,
  -1.48703931e-02f, -5.27900346e-02f, -5.62517159e-02f, -4.05307785e-02f, -2.37297956e-02f, -3.25786620e-02f, 5.68403602e-02f, -2.09028441e-02f, 1.25671150e-02f, -3.78893763e-02f,
  -2.50703399e-03f, 5.04253618e-02f, 1.26422383e-02f, 5.07664420e-02f, -4.42664418e-03f, 4.69552912e-02f, 7.99896717e-02f, -8.23085681e-02f, -5.04006632e-02f, 1.58235524e-03f,
  4.88841012e-02f, 5.11038229e-02f, 4.14479114e-02f, 5.55074848e-02f, 3.21324505e-02f, -4.96701896e-02f, 4.28608321e-02f, 1.05955176e-01f, 6.83327913e-02f, 4.84394655e-02f,
  4.19627614e-02f, -5.51035777e-02f, -3.92526910e-02f, 9.50784832e-02f, 8.55744705e-02f, 4.31958809e-02f, -7.59954900e-02f, -6.95369765e-02f, -8.36234447e-03f, 7.28084147e-02f,
  -2.73352638e-02f, -2.76817698e-02f, -4.03732285e-02f, -3.44826952e-02f, -5.27118556e-02f, -2.92723887e-02f, 7.00636506e-02f, -3.62907574e-02f, -1.74109195e-03f, -2.77731549e-02f,
  -1.61561549e-01f, 6.83422312e-02f, 1.35931417e-01f, -2.53389850e-02f, -1.12039655e-01f, 9.48483124e-03f, 1.27075419e-01f, -7.67065883e-02f, -1.13479190e-01f, 7.23083392e-02f,
  2.46805530e-02f, -1.05128057e-01f, 2.18145728e-01f, 1.71249300e-01f, -4.72280942e-02f, 2.12081924e-01f, 1.46134600e-01f, 1.21299647e-01f, -4.94059324e-02f, -1.07438840e-01f,
  -1.33735838e-03f, 7.41596222e-02f, 8.68991837e-02f, -6.50929287e-02f, 1.57496706e-03f, -2.31257267e-02f, -5.74108995e-02f, -1.46215232e-02f, 4.65462776e-03f, -8.98865163e-02f,
  -1.19997904e-01f, -8.77472758e-03f, -7.24943429e-02f, -4.02317010e-03f, 1.20434053e-02f, -8.38860795e-02f, -3.93453911e-02f, 4.73714396e-02f, -8.16774145e-02f, 3.85683849e-02f,
  4.09629196e-02f, -7.90022239e-02f, -6.23351000e-02f, -1.14366347e-02f, -1.61351555e-03f, -4.31777947e-02f, -1.05259195e-01f, 1.79464482e-02f, -2.35351846e-02f, 2.19143312e-02f,
  7.23491469e-03f, 1.03393957e-01f, 7.00664148e-02f, 5.67021333e-02f, 8.45979899e-02f, -2.93858093e-03f, 8.46919566e-02f, 3.69330356e-03f, -3.24691162e-02f, 4.79567796e-02f,
  -4.88573797e-02f, 1.39252162e-02f, -3.61053906e-02f, -7.38922879e-02f, 1.58421360e-02f, -1.86674725e-02f, 7.31932223e-02f, 1.53594483e-02f, 2.76507996e-02f, 4.58732666e-03f,
  -5.22835478e-02f, -4.90987785e-02f, -9.80229154e-02f, 4.48573269e-02f, 1.01705892e-02f, -2.96186972e-02f, -6.20198399e-02f, -1.00361012e-01f, 4.24535871e-02f, -1.14104450e-02f,
  8.29819515e-02f, -9.44170281e-02f, 7.10727274e-02f, 4.15962413e-02f, -1.16052823e-02f, 4.23810333e-02f, 7.44180977e-02f, 3.18937711e-02f, 3.48537788e-02f, 8.48767683e-02f,
  -1.42039910e-01f, -8.22250545e-03f, -1.80500131e-02f, -3.30952369e-02f, -5.04640490e-02f, -3.59133352e-03f, 6.71838596e-02f, 3.76998931e-02f, -6.32720813e-02f, -1.33680468e-02f,
  2.10679024e-02f, 5.77052385e-02f, -8.97425041e-02f, 6.53327480e-02f, 1.28349915e-01f, -1.66715607e-02f, 1.85607746e-02f, 5.75421751e-02f, -8.30700621e-02f, -4.47544344e-02f,
  -2.62382217e-02f, -2.79453378e-02f, -9.36680008e-04f, -1.29090352e-02f, 3.92576009e-02f, -2.49447320e-02f, 1.52890114e-02f, -3.33540104e-02f, 6.85411915e-02f, 9.70684066e-02f,
  9.66511667e-02f, 1.78364590e-01f, 1.72305241e-01f, 1.42260239e-01f, 7.87113328e-03f, 2.62227934e-02f, -1.35059774e-01f, 3.41380462e-02f, 1.39572695e-01f, 1.02146445e-02f,
  -4.63134609e-03f, 2.15104148e-01f, -1.60246238e-01f, -1.81543864e-02f, -7.46097490e-02f, -1.08056188e-01f, -2.98317485e-02f, 2.07553506e-02f, 1.15302973e-03f, 3.79326232e-02f,
  -3.83561552e-02f, 9.61744692e-03f, -1.11122606e-02f, 5.47544546e-02f, -3.83935124e-02f, 4.44885194e-02f, -9.84489322e-02f, -3.50112505e-02f, 1.09916903e-01f, 4.57910672e-02f,
  -2.12357212e-02f, 4.28361967e-02f, 1.17662624e-02f, -4.71765734e-02f, -1.51170446e-02f, 2.67982092e-02f, 6.12531938e-02f, -6.50899438e-03f, -1.16379661e-02f, -6.35238886e-02f,
  3.77062298e-02f, 2.35925172e-03f, 8.77652764e-02f, -3.31383236e-02f, 2.73710256e-03f, -7.85142258e-02f, 4.88447770e-02f, 2.46648695e-02f, 8.15582052e-02f, 8.63498300e-02f,
  7.69369304e-02f, 6.13816418e-02f, -5.02395891e-02f, 1.31128291e-02f, -4.82634716e-02f, -6.54891431e-02f, 7.31936246e-02f, -6.80970550e-02f, -6.84162974e-02f, -5.21776788e-02f,
  8.58756751e-02f, 2.26127524e-02f, 2.07638368e-02f, 7.20880032e-02f, -8.40550661e-03f, 8.55066329e-02f, 3.53828967e-02f, -9.65330750e-02f, -2.41261646e-02f, -8.74264836e-02f,
  -7.61509985e-02f, -3.22581306e-02f, 4.79016127e-03f, -1.84297059e-02f, 4.33470048e-02f, 1.49861667e-02f, 2.26939633e-03f, 6.69687539e-02f, 7.69862682e-02f, 4.07022424e-02f,
  4.80954051e-02f, -4.86304164e-02f, -2.45051794e-02f, -2.88689174e-02f, 3.29358876e-02f, -5.63887544e-02f, 4.00606692e-02f, 4.43750881e-02f, -6.44667968e-02f, -4.24641594e-02f,
  3.02913394e-02f, 1.24149896e-01f, 4.06198315e-02f, -3.43354940e-02f, 2.46483926e-02f, -7.50933886e-02f, -2.66853143e-02f, -3.43848877e-02f, 6.56513423e-02f, 2.73453146e-02f,
  -8.92669484e-02f, 5.27103692e-02f, 3.40378359e-02f, 1.06263682e-01f, -6.95433393e-02f, -9.75135490e-02f, -2.25860737e-02f, 4.74880934e-02f, 4.29148711e-02f, 5.17297834e-02f,
  -3.17484774e-02f, -7.65148923e-02f, 3.19989100e-02f, -5.82038239e-02f, 6.86806887e-02f, 1.00143053e-01f, -5.04696183e-02f, -6.08842224e-02f, 6.05674572e-02f, 2.19512843e-02f,
  7.67488182e-02f, 1.90620452e-01f, 1.21543415e-01f, 8.49309862e-02f, 2.87459698e-02f, 4.44832556e-02f, -1.35431454e-01f, 8.60755220e-02f, 1.90351635e-01f, -1.20997667e-01f,
  -1.81815132e-01f, 2.02464119e-01f, -1.64505959e-01f, 3.88167277e-02f, -4.40889597e-03f, 1.05520515e-02f, 8.09459165e-02f, -4.38222736e-02f, 5.57262860e-02f, 1.28813833e-02f,
  7.46797100e-02f, -1.77226692e-01f, -3.11940163e-02f, -1.44081756e-01f, 3.25589254e-02f, 1.28260508e-01f, -2.14099914e-01f, -6.71520904e-02f, -5.28741926e-02f, 3.83792631e-03f,
  8.81879628e-02f, 6.78988695e-02f, -3.03430147e-02f, -3.19020450e-02f, 3.26956362e-02f, 5.36464043e-02f, 9.44492593e-02f, 7.52917007e-02f, -8.26646239e-02f, 9.57230031e-02f,
  2.41150446e-02f, 3.39243859e-02f, 7.48189166e-02f, -8.65613967e-02f, -2.83330400e-02f, 6.87676296e-02f, 1.13202617e-01f, 7.91538507e-02f, 1.86640508e-02f, 1.38333037e-01f,
  8.71152878e-02f, 6.03761487e-02f, 1.17198370e-01f, 9.44595933e-02f, 1.17610963e-02f, 5.48834503e-02f, -5.69617599e-02f, -3.62742208e-02f, 6.27334565e-02f, 7.75191933e-02f,
  4.17944044e-02f, 2.98361965e-02f, -2.44295914e-02f, -2.25603595e-04f, 3.37430350e-02f, 7.28668571e-02f, -7.90259242e-02f, 5.96530139e-02f, -1.41999479e-02f, -3.88145037e-02f,
  -6.63666520e-03f, -3.30792479e-02f, 3.14604118e-02f, -7.32495915e-03f, 3.16316485e-02f, 3.05856392e-02f, -3.14778872e-02f, -6.35851771e-02f, 8.04786384e-02f, 2.77194455e-02f,
  -6.98620006e-02f, 4.74506542e-02f, -8.06144550e-02f, -9.59698204e-03f, 2.68424582e-02f, 2.14968659e-02f, 1.53126670e-02f, 3.39919850e-02f, 7.19345585e-02f, 3.05299461e-02f,
  -3.81851904e-02f, -1.45602942e-01f, -3.37871946e-02f, 2.03123149e-02f, 3.97139750e-02f, -2.51644943e-02f, -3.73310298e-02f, 3.24401160e-04f, 3.96813601e-02f, 3.38624604e-02f,
  6.41849712e-02f, -6.04216382e-02f, 4.49710041e-02f, -3.35603207e-03f, 5.13286004e-03f, -6.47045970e-02f, 8.91542807e-03f, 2.61477474e-02f, -7.13293033e-04f, -1.60006490e-02f,
  -2.75829695e-02f, 9.20951813e-02f, 1.16276247e-02f, 6.90005869e-02f, -4.94201556e-02f, -4.43201773e-02f, 7.91224241e-02f, -3.29130627e-02f, -9.58608091e-02f, -3.23694646e-02f,
  -6.75084889e-02f, -1.34439677e-01f, -2.95930058e-01f, -1.76051594e-02f, 2.32820250e-02f, 1.86461046e-01f, -3.44964154e-02f, 3.50280777e-02f, -8.41478631e-02f, 1.82985365e-01f,
  2.10161179e-01f, -9.32822153e-02f, -1.86796397e-01f, 2.36664817e-01f, 1.12724165e-02f, -1.48208961e-01f, 2.38782451e-01f, 1.45935073e-01f, -1.13211803e-01f, 2.51036193e-02f,
  3.89559753e-02f, 1.68937206e-01f, -1.09067768e-01f, 8.70501846e-02f, 6.83777779e-02f, -3.34567241e-02f, 1.59185287e-02f, -1.06370486e-01f, 2.01286227e-01f, 2.21617464e-02f,
  7.01129884e-02f, -7.02826753e-02f, 1.26620043e-05f, -8.43505282e-03f, 3.51143144e-02f, 9.51129720e-02f, -5.70343062e-02f, -3.32457088e-02f, 5.61755802e-03f, -5.93519397e-02f,
  -3.34430337e-02f, -9.46057886e-02f, -5.83959632e-02f, -8.59419331e-02f, 7.23417625e-02f, 6.95357546e-02f, 1.74713728e-03f, -2.24257223e-02f, -4.31772284e-02f, -2.67830100e-02f,
  2.37982497e-02f, 6.04924597e-02f, -7.62139335e-02f, 5.88050969e-02f, 4.08790670e-02f, -1.43931573e-02f, -4.50558774e-02f, -2.55942787e-03f, 1.07515171e-01f, 6.80046007e-02f,
  -2.87083518e-02f, -3.62805910e-02f, -8.84946436e-02f, 6.11437373e-02f, -6.25164062e-02f, -1.82547905e-02f, 4.32624817e-02f, 5.47076985e-02f, 2.44028904e-02f, 8.30599591e-02f,
  6.80763945e-02f, -1.93045344e-02f, 8.72478709e-02f, 4.92320806e-02f, 6.32699355e-02f, 8.92354455e-03f, -8.07421654e-03f, -7.47704878e-03f, -1.54357599e-02f, 4.51806337e-02f,
  -3.19040567e-02f, -5.75749576e-02f, -2.71701533e-02f, 8.03986099e-03f, 2.43429802e-02f, -4.50627096e-02f, 1.59280561e-02f, 4.21866868e-03f, 1.52763780e-02f, -6.66921288e-02f,
  6.25725165e-02f, -6.68365061e-02f, -6.29696175e-02f, -8.85958970e-03f, -7.01644048e-02f, 2.59742644e-02f, 8.54264870e-02f, -5.38738035e-02f, 3.52085941e-02f, -5.74954636e-02f,
  1.64841320e-02f, 3.33268754e-02f, 5.14478721e-02f, 4.11277497e-03f, 2.51040980e-02f, -2.26781145e-03f, -2.35256553e-02f, -2.20820028e-02f, 6.99639926e-03f, 4.87190597e-02f,
  1.47439567e-02f, 5.35942391e-02f, -1.03177233e-02f, -3.97045948e-02f, 6.31864071e-02f, -1.48374373e-02f, 7.51214027e-02f, -6.35739863e-02f, 1.42846555e-02f, 1.76805928e-02f,
  8.66646394e-02f, 6.16710410e-02f, 2.58725107e-01f, 1.95901543e-01f, -2.88683660e-02f, -4.59879711e-02f, -3.57138589e-02f, -6.86139613e-02f, -1.15395889e-01f, -2.93055903e-02f,
  -1.18389331e-01f, 1.54862508e-01f, 3.41815911e-02f, -5.57977296e-02f, 1.08289167e-01f, -1.88550532e-01f, -1.14891306e-02f, 1.90586410e-02f, -3.26498151e-02f, 7.64033124e-02f,
  7.06859231e-02f, -8.02289024e-02f, 1.34302601e-01f, -4.07736301e-02f, 1.61318943e-01f, 4.81912903e-02f, 9.60615724e-02f, -3.61673310e-02f, 2.07216591e-02f, 7.72080868e-02f,
  -1.55122587e-02f, -4.25468013e-02f, 5.71768284e-02f, 7.90888593e-02f, -5.43164834e-02f, 7.96218365e-02f, -5.62979653e-02f, -4.04178873e-02f, 8.22589919e-02f, 6.49047270e-02f,
  1.00679010e-01f, 5.46747632e-02f, -6.49724081e-02f, 7.21162651e-04f, 1.46303198e-03f, -5.35695581e-03f, -4.44354005e-02f, 1.03286132e-01f, 4.38944511e-02f, 1.03665493e-01f,
  7.64709562e-02f, -4.35709674e-03f, 7.87623748e-02f, 7.20300600e-02f, -7.84108602e-03f, 3.53396572e-02f, 1.65483356e-02f, -5.57772676e-03f, -1.06126601e-02f, -2.51826253e-02f,
  -9.21861529e-02f, 4.07318883e-02f, 5.93225621e-02f, 7.08479062e-02f, -2.91905906e-02f, 1.29238442e-02f, -3.44620235e-02f, 5.88621534e-02f, 9.84491184e-02f, 2.07376592e-02f,
  9.26781818e-02f, -2.50789244e-03f, 5.46256863e-02f, -2.26700287e-02f, -3.91320027e-02f, -7.20961839e-02f, 9.33021531e-02f, -3.32042314e-02f, 8.32103267e-02f, 1.50116179e-02f,
  -3.55806313e-02f, 1.93785876e-02f, -1.79160591e-02f, -6.33569136e-02f, -5.11635654e-02f, -1.04199434e-02f, 1.60721615e-02f, 8.65077153e-02f, 4.82773483e-02f, -5.84138148e-02f,
  -1.11467525e-01f, -6.31626621e-02f, -1.33830328e-02f, -1.51545350e-02f, -2.96479948e-02f, -8.30445662e-02f, 2.05657650e-02f, -8.26562196e-03f, -4.01781909e-02f, -5.63848391e-02f,
  -9.38672796e-02f, 1.46293845e-02f, -4.90827672e-02f, -2.40696259e-02f, -8.99553299e-02f, -1.83693022e-02f, 6.91753551e-02f, -4.30204570e-02f, -3.28766108e-02f, -2.67266408e-02f,
  6.14712089e-02f, -3.23407054e-02f, 1.41978159e-03f, 5.57045676e-02f, 2.49751955e-02f, 5.67297153e-02f, -6.29248098e-02f, -5.63964508e-02f, -2.76195575e-02f, 1.57920942e-02f,
  2.36864109e-03f, -3.99739146e-02f, 6.01910427e-02f, 2.53414549e-02f, -1.76125318e-01f, 6.88101351e-02f, 1.37217611e-01f, -1.40543789e-01f, -9.51184798e-03f, -6.29389612e-03f,
  2.14987863e-02f, 1.29283890e-01f, 4.42860462e-03f, 1.14353932e-02f, 6.14191741e-02f, 6.67366982e-02f, 8.19036290e-02f, 1.38316453e-01f, -6.79647271e-03f, 2.11255327e-02f,
  1.24042365e-03f, -1.25885040e-01f, -7.83086345e-02f, -6.34981841e-02f, -9.19550136e-02f, -1.43405929e-01f, -1.16644613e-01f, -1.14755426e-02f, -1.34157106e-01f, -1.35286808e-01f,
  -6.29228503e-02f, -3.82522829e-02f, 3.52998152e-02f, 1.40769593e-02f, 1.17947413e-02f, -4.09981422e-02f, 3.38650197e-02f, -3.26949731e-02f, 5.47751561e-02f, -1.44152809e-02f,
  1.19986922e-01f, -9.86894220e-02f, -5.84083460e-02f, 4.05599624e-02f, -3.53667177e-02f, -5.54840863e-02f, -8.07007030e-02f, -1.73628498e-02f, 9.96477082e-02f, -7.64365792e-02f,
  8.51896927e-02f, 8.17027912e-02f, 9.24563557e-02f, 8.01329035e-03f, -4.01089117e-02f, 2.49924734e-02f, 7.37595484e-02f, -3.48163769e-02f, -2.76991539e-02f, 8.95543993e-02f,
  2.91258339e-02f, 6.29724711e-02f, 8.02133791e-03f, -7.93914124e-02f, 6.78596348e-02f, 3.72767933e-02f, -7.15883970e-02f, 7.66513345e-04f, -8.65302980e-03f, 4.46768962e-02f,
  -1.60209332e-02f, -6.71382472e-02f, -7.05546290e-02f, -3.33565883e-02f, -1.22423405e-02f, -1.73020586e-02f, -7.03149512e-02f, 5.36131337e-02f, 7.67452568e-02f, -5.79702221e-02f,
  5.78680784e-02f, 6.74983859e-03f, -7.03403205e-02f, -8.59811306e-02f, 3.18532856e-03f, -8.14327374e-02f, -1.04823664e-01f, -5.39453886e-02f, 8.56700167e-02f, 8.39027092e-02f,
  -6.71439171e-02f, 9.29018036e-02f, -4.53936402e-03f, 4.49893586e-02f, -3.89331132e-02f, -2.17307676e-02f, 7.15052010e-03f, 3.44625711e-02f, 8.42225999e-02f, -2.57047173e-02f,
  -4.41847928e-02f, 6.24235980e-02f, -1.09673827e-03f, 1.96987186e-02f, 1.81602128e-02f, -1.63641404e-02f, 1.09647021e-01f, 7.91134462e-02f, 4.80986349e-02f, -4.34828103e-02f,
  -3.78915071e-02f, 4.78430279e-02f, 9.29352082e-03f, -5.85800782e-02f, -6.95358776e-03f, -3.58332805e-02f, -7.08746761e-02f, -4.34441119e-02f, 5.24324328e-02f, 8.12993199e-02f,
  -2.86236465e-01f, 1.46255895e-01f, -7.69518465e-02f, -3.10273498e-01f, 1.90157890e-01f, 3.40515748e-02f, -6.33627772e-02f, 4.39681746e-02f, -4.21145335e-02f, 1.43289536e-01f,
  6.51225969e-02f, -1.09283566e-01f, 1.28796861e-01f, -1.49167836e-01f, -3.57272118e-01f, -2.45484114e-02f, -1.06494233e-01f, -1.90043867e-01f, 8.92189220e-02f, 5.74513301e-02f,
  -1.42444894e-01f, 5.53114600e-02f, -5.46982251e-02f, 2.75551558e-01f, 1.55060971e-02f, 8.42896402e-02f, -6.44821599e-02f, 1.95200011e-01f, -1.12209059e-01f, 3.58242914e-02f,
  6.17102757e-02f, -1.14920802e-01f, -1.58734694e-02f, -8.62447321e-02f, -9.25184712e-02f, -2.52107754e-02f, -2.65733656e-02f, -3.06757856e-02f, 7.45634064e-02f, -4.63581346e-02f,
  6.21945597e-02f, -4.29774970e-02f, -9.62974578e-02f, -4.02322672e-02f, -6.78280219e-02f, 1.57815386e-02f, -4.51944321e-02f, 4.11607176e-02f, 5.51622212e-02f, -6.80021718e-02f,
  -6.26698416e-03f, -9.40226242e-02f, -8.89583305e-02f, -1.16536327e-01f, -8.70494694e-02f, -1.37238658e-03f, -7.14800358e-02f, -2.06347555e-02f, -5.98592572e-02f, 2.26469859e-02f,
  2.39533768e-03f, -2.61912532e-02f, 5.51811159e-02f, -6.71990067e-02f, -3.16099748e-02f, -3.24425623e-02f, 2.81300787e-02f, -5.20263426e-03f, 7.02692792e-02f, 3.08073051e-02f,
  -1.34559004e-02f, -4.09427807e-02f, 7.67437741e-02f, -7.41342306e-02f, -8.06961209e-02f, 1.89844295e-02f, 7.28755817e-03f, 1.67390425e-02f, 7.01204687e-03f, 1.89601667e-02f,
  2.68916991e-02f, -8.06414112e-02f, 6.77261353e-02f, -6.54220507e-02f, 1.23468852e-02f, -5.04567176e-02f, -5.93356742e-03f, -4.57616858e-02f, -3.94162834e-02f, -3.18669192e-02f,
  -8.83661304e-03f, -5.74058555e-02f, 1.93139184e-02f, 7.50414431e-02f, 6.14329651e-02f, 5.35324626e-02f, 2.28269678e-02f, -3.37935016e-02f, -8.68660063e-02f, 6.59123212e-02f,
  -5.27398661e-03f, -5.11861742e-02f, 1.67013090e-02f, 7.98456445e-02f, -6.52884552e-03f, 5.57871908e-02f, 8.06132182e-02f, 7.66267953e-03f, -5.20349964e-02f, -4.96245623e-02f,
  3.50828236e-03f, 1.35182738e-02f, 8.33833590e-03f, 6.95962273e-03f, -5.64966388e-02f, -3.65609415e-02f, 4.91947541e-03f, -9.89390351e-03f, -3.96752805e-02f, -2.12401915e-02f,
  3.17382766e-03f, 8.94045159e-02f, -2.35981077e-01f, -2.14941744e-02f, -5.85301919e-03f, -9.22066644e-02f, 5.55263534e-02f, 6.71721026e-02f, 2.61138715e-02f, 2.08545700e-01f,
  1.74276888e-01f, -2.26372760e-03f, 1.38289943e-01f, 2.65977122e-02f, -1.29163370e-01f, -5.79787455e-02f, 5.56171387e-02f, 1.06211752e-01f, -1.17940873e-01f, 1.40626207e-01f,
  2.15301365e-02f, 1.96868926e-01f, -6.69875741e-02f, 2.18103044e-02f, -1.54088652e-02f, -4.89684753e-04f, 2.29273558e-01f, 5.17219715e-02f, 4.84825484e-02f, -6.54219985e-02f,
  3.45033631e-02f, -6.50418326e-02f, 1.94584094e-02f, -1.18441386e-02f, -7.36480504e-02f, 6.12954609e-02f, -7.28611052e-02f, -8.15289170e-02f, -2.30678618e-02f, -8.69433433e-02f,
  3.92839015e-02f, 4.23715031e-03f, 2.68007740e-02f, -3.99770886e-02f, 2.17036121e-02f, -5.13729937e-02f, -1.13578616e-02f, -6.55545890e-02f, 2.67442744e-02f, 3.51777524e-02f,
  -3.12892571e-02f, 4.87383641e-02f, 2.00838298e-02f, -4.32273410e-02f, -3.16481218e-02f, -2.91906092e-02f, -4.85127047e-02f, 1.16804950e-02f, 4.50723208e-02f, 5.58373369e-02f,
  1.19332209e-01f, -6.63295239e-02f, -4.77899471e-03f, -9.88477990e-02f, 4.54656258e-02f, -5.58457412e-02f, 3.44668590e-02f, 5.53000793e-02f, 5.43023571e-02f, -1.03950407e-02f,
  -1.03620261e-01f, 2.04224698e-02f, -2.15754146e-03f, -4.61908914e-02f, 7.04203248e-02f, -8.00196454e-02f, -7.96460956e-02f, 4.91696112e-02f, -3.95679697e-02f, 2.87157800e-02f,
  -5.40842004e-02f, 7.70564228e-02f, -1.18815387e-02f, 9.23582911e-02f, -7.85218850e-02f, -4.42462005e-02f, -1.28364749e-02f, -4.71341498e-02f, 4.31940407e-02f, 7.19500259e-02f,
  6.75378516e-02f, 1.55914113e-01f, 6.14606701e-02f, -1.06589846e-01f, 5.32753766e-03f, -5.87833785e-02f, -3.76820825e-02f, -9.83681753e-02f, -5.35438061e-02f, 1.78109035e-02f,
  1.12030685e-01f, 2.97196880e-02f, 9.88796633e-03f, -2.64327303e-02f, 1.82929151e-02f, 1.34671554e-01f, 3.83161902e-02f, -4.95143831e-02f, 1.97179150e-02f, 8.96558166e-02f,
  9.80954710e-03f, 1.30680338e-01f, -4.50029708e-02f, 2.47782003e-02f, 5.75128496e-02f, -2.59820130e-02f, 1.26761924e-02f, -1.49690956e-02f, -8.35165754e-03f, 8.14521918e-04f,
  -9.69673097e-02f, -2.18970589e-02f, 2.56178491e-02f, 4.64071147e-02f, 5.80082610e-02f, 1.16615131e-01f, 1.54422715e-01f, 6.17022961e-02f, 1.81952436e-02f, -1.05339736e-02f,
  5.08382842e-02f, 8.17116257e-03f, 1.12340800e-01f, 7.49943033e-02f, 1.07205853e-01f, -1.66523755e-02f, -4.88878824e-02f, -9.42500308e-02f, 8.55611414e-02f, -5.09255845e-03f,
  -5.68577414e-03f, -5.31477332e-02f, -5.35929091e-02f, 6.34849770e-03f, 6.35410994e-02f, 6.29567131e-02f, 4.19373810e-02f, 1.08596303e-01f, -7.04487190e-02f, 9.84690413e-02f,
  -4.52921726e-02f, -1.04911774e-01f, -4.41596173e-02f, 3.50850299e-02f, -5.90360574e-02f, 4.56901640e-02f, -6.09713793e-02f, 1.06766135e-01f, 4.12713476e-02f, 1.86267570e-02f,
  -5.63330613e-02f, -3.63190323e-02f, -8.53721574e-02f, -6.17307387e-02f, -9.08610597e-02f, -5.33562601e-02f, -4.00440469e-02f, -4.60482612e-02f, -5.67853190e-02f, -2.91170407e-04f,
  9.69098806e-02f, -8.89542252e-02f, -1.41468914e-02f, -3.02751046e-02f, 6.84515461e-02f, -7.34631270e-02f, 6.58110306e-02f, 7.08939955e-02f, -4.62609753e-02f, -1.73754860e-02f,
  8.49921480e-02f, 3.56350988e-02f, -5.59350587e-02f, 4.01169211e-02f, -3.01797409e-02f, 7.79516175e-02f, -8.25373530e-02f, 3.84624936e-02f, 1.74794309e-02f, -8.32218491e-03f,
  -1.53899584e-02f, 1.42594771e-02f, -6.11638241e-02f, 2.55812239e-02f, 6.51188046e-02f, -6.39687758e-03f, -6.51087835e-02f, 2.17122585e-02f, 3.66065837e-02f, 8.36460292e-02f,
  -1.31073752e-02f, 6.74344823e-02f, -5.89933731e-02f, 4.43578698e-02f, -6.11224212e-02f, -8.27311575e-02f, 5.16055152e-02f, 6.43528178e-02f, 2.34547444e-02f, 7.46109337e-02f,
  -1.08399309e-01f, -1.73001185e-01f, 1.65240765e-02f, 1.36936503e-02f, -9.37574133e-02f, -5.19516729e-02f, 4.65810150e-02f, 4.91475165e-02f, 3.11622452e-02f, -5.20472303e-02f,
  5.53302616e-02f, 3.51524428e-02f, 8.23937729e-03f, -3.03034708e-02f, -3.42068411e-02f, -7.23081920e-03f, 8.63623768e-02f, -5.42661771e-02f, -6.76585361e-02f, -9.65696871e-02f,
  -1.83541123e-02f, 4.45338003e-02f, 7.22059235e-02f, 3.63368317e-02f, -7.60555267e-02f, 6.62481762e-04f, 5.71832433e-02f, -2.49061119e-02f, -5.52456044e-02f, -1.93018131e-02f,
  2.33712774e-02f, 9.12693366e-02f, 1.86382122e-02f, 1.19252943e-01f, -1.23407334e-01f, -1.41887099e-01f, 4.03993726e-02f, -3.05966381e-02f, 1.76259071e-01f, -3.72591093e-02f,
  -4.18484993e-02f, 6.42727390e-02f, 8.26361254e-02f, -3.80273834e-02f, 1.09834872e-01f, 6.69688731e-02f, 1.39818326e-01f, -7.52845705e-02f, 1.04134537e-01f, -2.23219711e-02f,
  -9.01518241e-02f, 1.64285563e-02f, -8.42221901e-02f, -4.57669124e-02f, -7.18074804e-03f, 5.32454252e-02f, -1.65138897e-02f, -2.60087550e-02f, -1.52021170e-01f, 8.13241675e-02f,
  2.89025139e-02f, 1.27673224e-01f, -2.40216963e-02f, -9.05360747e-03f, 6.52368739e-02f, -1.29230320e-01f, -2.19907798e-02f, 1.42359370e-02f, 5.29372878e-02f, 6.89916611e-02f,
  3.72795798e-02f, -7.77928233e-02f, -1.15543883e-03f, -5.73567934e-02f, 5.86805539e-03f, -1.05486810e-01f, -6.94680065e-02f, -9.03632268e-02f, 4.29529510e-02f, -6.20987266e-02f,
  -1.04412429e-01f, -4.79594339e-03f, -3.74902673e-02f, 2.58257594e-02f, -3.24219353e-02f, 8.02186653e-02f, 4.99654002e-02f, 5.59391677e-02f, 8.60319510e-02f, 1.24375112e-01f,
  5.82020022e-02f, 5.89798838e-02f, 4.83635105e-02f, 4.01379727e-02f, 1.04469783e-03f, 4.40372862e-02f, -5.87910339e-02f, -7.31609464e-02f, 2.77893580e-02f, -4.36841249e-02f,
  -3.67504619e-02f, 6.27549067e-02f, -7.01326784e-03f, 5.96462190e-02f, -4.27101962e-02f, 8.00585898e-04f, 4.85782437e-02f, -1.06361220e-02f, 4.46339287e-02f, -1.23767026e-01f,
  7.09639909e-03f, -1.92706995e-02f, -9.04294029e-02f, -7.57560804e-02f, 7.58622121e-03f, -2.19572671e-02f, 6.98044896e-02f, 5.29068708e-02f, 2.34472863e-02f, -5.73991761e-02f,
  3.20323333e-02f, 3.83312553e-01f, -9.19677615e-02f, -1.61919147e-02f, 7.61328861e-02f, -5.43503314e-02f, 8.58617201e-02f, 5.04340008e-02f, 8.28020573e-02f, 3.77325937e-02f,
  -9.01056752e-02f, -1.81340296e-02f, -5.74451461e-02f, 4.08521220e-02f, -5.16352355e-02f, 7.22515285e-02f, -1.87867247e-02f, 6.45592660e-02f, -3.78172062e-02f, 3.27141993e-02f,
  -2.26344708e-02f, -5.88771142e-02f, 2.56573781e-02f, -9.13088024e-03f, -7.14585856e-02f, -4.28370088e-02f, 3.74661908e-02f, 6.36439547e-02f, 9.24381614e-02f, -2.36791633e-02f,
  4.98333089e-02f, -2.88365006e-01f, 5.71584329e-02f, 1.38969898e-01f, 1.38166279e-01f, 3.22356485e-02f, 3.54522243e-02f, -6.03419803e-02f, -1.43608088e-02f, -2.27781177e-01f,
  -1.08508371e-01f, 3.07159834e-02f, -2.08346263e-01f, -5.11146635e-02f, 4.60226536e-02f, -1.13503940e-01f, -1.18884537e-02f, 4.64202575e-02f, 1.88840739e-02f, -1.13837034e-01f,
  3.69260721e-02f, 2.73801386e-02f, 1.42548848e-02f, 9.02178604e-03f, 8.12414661e-02f, 1.21724397e-01f, 7.73098087e-03f, 2.01769522e-03f, 7.06204697e-02f, 9.22693312e-02f,
  1.72967464e-02f, -4.72635552e-02f, 7.53517151e-02f, 1.77567974e-02f, -7.96039179e-02f, -5.80404475e-02f, 4.96217944e-02f, 9.99544561e-02f, -2.77662575e-02f, -9.53366756e-02f,
  8.18641260e-02f, -5.92753515e-02f, 1.67657025e-02f, 3.80135179e-02f, 1.16104648e-01f, 3.05012967e-02f, -2.40418110e-02f, 2.89057344e-02f, 1.13615751e-01f, -6.06855862e-02f,
  2.20669881e-02f, -7.18072355e-02f, 2.42498815e-02f, -5.95580898e-02f, 5.65037392e-02f, 4.40152250e-02f, 1.08011693e-01f, -5.45966253e-02f, -1.10826418e-01f, 1.49335561e-03f,
  -5.75650521e-02f, 3.32185836e-03f, -1.01298494e-02f, 4.32778113e-02f, -3.59814242e-02f, -4.07703295e-02f, -5.89990839e-02f, 8.54002684e-02f, 1.83323584e-02f, -8.09421390e-03f,
  -2.40716692e-02f, 2.17788853e-02f, 6.98872954e-02f, 5.41053340e-02f, 6.40812591e-02f, 8.39209780e-02f, 3.68552469e-02f, -7.39272460e-02f, 4.49377820e-02f, 1.16311563e-02f,
  2.31721532e-03f, 1.65150280e-03f, -5.28327413e-02f, 6.25483245e-02f, -6.65562004e-02f, -1.79066753e-03f, 2.86546014e-02f, 1.05928900e-02f, -3.17233466e-02f, 2.10183393e-02f,
  -1.66752979e-01f, -9.85599831e-02f, -2.33973539e-03f, -7.86104873e-02f, 3.16318646e-02f, -3.82941328e-02f, 3.63658629e-02f, -1.78312343e-02f, -3.65748070e-02f, -5.70975356e-02f,
  -7.86255524e-02f, -5.25869615e-02f, 1.00840852e-02f, 2.99466513e-02f, 1.30135296e-02f, 4.00144756e-02f, 3.86487953e-02f, 8.09114613e-03f, -2.73950491e-02f, -6.29339591e-02f,
  -9.27946419e-02f, -4.29797173e-02f, 8.23700503e-02f, -2.61907373e-02f, 1.00203291e-01f, -9.26649570e-03f, -6.23292923e-02f, 4.01469097e-02f, -8.03416502e-03f, 4.31330577e-02f,
  1.54722333e-02f, 2.34175277e-05f, -1.15357779e-01f, -8.24075118e-02f, -2.87680347e-02f, -2.69390702e-01f, -1.77212387e-01f, -8.69942158e-02f, -5.74868061e-02f, 7.74450507e-03f,
  -1.21964507e-01f, 1.21525772e-01f, 2.97146402e-02f, -8.51866826e-02f, -1.41653478e-01f, 4.71843332e-02f, -2.15881318e-01f, -2.50716899e-02f, 5.96433356e-02f, -1.40990749e-01f,
  -1.75836906e-01f, -8.79190490e-02f, -1.55179230e-02f, -1.01566248e-01f, -1.00330859e-01f, 6.13143630e-02f, 7.37177357e-02f, -6.71064407e-02f, -1.57443613e-01f, -1.57233439e-02f,
  -8.62083808e-02f, 3.36064287e-02f, -3.86933386e-02f, 7.27024004e-02f, -6.19376153e-02f, -8.59923847e-03f, 7.90295079e-02f, 9.10919067e-03f, -5.20659722e-02f, 3.78515236e-02f,
  -2.58388761e-02f, 8.41237232e-02f, -7.83025324e-02f, -2.33909152e-02f, 1.47020156e-02f, -1.08095273e-01f, 1.55432541e-02f, 7.36415237e-02f, -4.42738682e-02f, 4.05312292e-02f,
  2.78354553e-03f, 3.57496142e-02f, -6.67552650e-02f, 9.86672044e-02f, 2.85977572e-02f, -6.92765787e-02f, 3.31748248e-04f, -3.86720262e-02f, 3.64836417e-02f, -4.64910455e-02f,
  6.33814111e-02f, 2.02189758e-02f, 2.10743453e-02f, 3.60302217e-02f, 4.08406593e-02f, -1.44053064e-03f, 3.17001878e-03f, 2.64479425e-02f, -3.25811021e-02f, -1.31121241e-02f,
  -5.90092912e-02f, 6.51931390e-02f, 2.20721005e-03f, -2.15475261e-02f, -1.02350257e-01f, -5.38456626e-03f, -3.41623276e-02f, -6.17714487e-02f, -3.82988788e-02f, 4.92435023e-02f,
  -3.58537063e-02f, -1.36914551e-02f, 6.50743246e-02f, -1.47449551e-02f, -2.58720536e-02f, 3.53532545e-02f, 1.01063997e-01f, -5.12985177e-02f, 7.34005868e-02f, 7.08623827e-02f,
  -1.51582221e-02f, -9.61623415e-02f, -5.04834391e-02f, 8.89606625e-02f, -4.24690865e-04f, -4.02204283e-02f, 1.38596315e-02f, 3.34837139e-02f, -3.15641873e-02f, -8.65791887e-02f,
  -4.27663438e-02f, -6.89627826e-02f, -7.91661888e-02f, -4.79455814e-02f, 4.33387840e-03f, -4.16953526e-02f, 3.19341496e-02f, 1.78641384e-03f, -5.57864048e-02f, -4.36595455e-02f,
  9.27783642e-03f, 2.87666172e-02f, 7.33773112e-02f, -4.19724323e-02f, -8.81928671e-03f, 3.01385093e-02f, -4.52806689e-02f, -5.55270761e-02f, 6.63623586e-02f, -4.91428450e-02f,
  2.21207812e-01f, 2.77693756e-02f, 1.56057552e-01f, 3.52195114e-01f, -6.70119300e-02f, -3.16266239e-01f, -1.68415293e-01f, 3.37736160e-02f, 2.51136273e-01f, -1.93579927e-01f,
  -1.13665238e-01f, 1.24502964e-01f, -1.48244962e-01f, 5.08588329e-02f, 6.17739260e-02f, -6.16674498e-02f, -4.75761816e-02f, -1.15505233e-01f, 1.06456548e-01f, -3.11336145e-02f,
  1.91698328e-01f, -1.05994031e-01f, 2.72082426e-02f, 4.28541303e-02f, -3.46968211e-02f, 1.73038989e-01f, 1.69090498e-02f, -8.35425034e-02f, 4.71517891e-02f, -1.50184810e-01f,
  -1.06347561e-01f, 1.59376889e-01f, 1.03853811e-02f, -4.04939502e-02f, 2.68777944e-02f, -7.32279047e-02f, -4.83510606e-02f, -1.08995996e-01f, 6.22984916e-02f, -4.81141359e-02f,
  -3.81956771e-02f, 3.63970250e-02f, 2.51021292e-02f, 6.13734201e-02f, -7.44143054e-02f, 8.27010795e-02f, 1.41904708e-02f, -6.55069649e-02f, 4.80976738e-02f, -1.58250462e-02f,
  7.65572861e-02f, 7.52895400e-02f, 5.22575751e-02f, -7.20653459e-02f, 5.52428514e-02f, 1.75463948e-02f, -5.23551628e-02f, 1.46680223e-02f, 5.70414215e-02f, 1.10829793e-01f,
  3.50346901e-02f, -5.63851744e-02f, -2.43764259e-02f, 7.66598210e-02f, 3.04328930e-02f, 1.08737722e-02f, 3.30814347e-02f, 9.27845668e-03f, -5.44438064e-02f, 3.58841382e-02f,
  -9.16946083e-02f, 5.73455803e-02f, 8.49053904e-04f, -3.70247364e-02f, -1.07064517e-02f, -5.80591671e-02f, 4.84391078e-02f, -3.97146605e-02f, 3.82650346e-02f, -5.53519279e-02f,
  -1.69531405e-02f, -6.31882949e-03f, 1.25749316e-02f, -2.97953188e-03f, -3.49446908e-02f, 1.24157108e-02f, -5.11578396e-02f, -2.40239501e-03f, 1.96489505e-03f, -1.46978926e-02f,
  -1.91734165e-01f, -2.73751728e-02f, -4.66851257e-02f, -4.92927693e-02f, -4.91986237e-02f, -8.13155621e-02f, -5.00224717e-02f, 3.84097099e-02f, -8.15996677e-02f, 6.29987493e-02f,
  -4.47520390e-02f, 1.55757628e-02f, -7.97862280e-03f, 4.65083309e-02f, -6.47475645e-02f, 5.72084226e-02f, -2.29588225e-02f, 5.69476224e-02f, -8.71912315e-02f, -1.03932815e-02f,
  -5.34098968e-02f, -3.78589369e-02f, -5.72548900e-03f, -9.92269162e-03f, -4.34405655e-02f, 3.97745240e-03f, -2.76251417e-02f, 2.54107043e-02f, 5.19391289e-03f, -4.42248993e-02f,
  -2.20138654e-01f, 1.55996829e-01f, 4.82202880e-02f, -8.64597186e-02f, -2.00605933e-02f, 1.73372090e-01f, 1.03826925e-01f, 6.91928491e-02f, 1.02101609e-01f, 4.11995500e-02f,
  -3.16267647e-02f, -4.84040268e-02f, 1.10363387e-01f, 4.42926362e-02f, -6.16018400e-02f, 9.99617130e-02f, 7.45465085e-02f, 5.02830334e-02f, 6.15968108e-02f, -5.90008311e-02f,
  -4.42567281e-02f, -2.91074906e-03f, -2.70739966e-03f, 1.04253320e-02f, -2.09792498e-02f, -1.54950589e-01f, -9.31865573e-02f, -2.79807094e-02f, -8.05537999e-02f, 7.89412409e-02f,
  -6.40132800e-02f, 2.51261238e-03f, 4.42095548e-02f, 5.19675948e-02f, 8.52848366e-02f, -4.16213237e-02f, -8.26466009e-02f, 1.69431083e-02f, -1.19937700e-04f, -5.09980544e-02f,
  -5.25347888e-02f, 4.20760289e-02f, 7.60208408e-04f, -7.04504997e-02f, -1.05256155e-01f, 6.57759830e-02f, -2.92602219e-02f, -8.42119306e-02f, 8.82208124e-02f, -3.25066745e-02f,
  -4.05379608e-02f, 5.04703145e-04f, -2.54242513e-02f, 9.07985792e-02f, -5.16119301e-02f, 9.73578393e-02f, -2.04822700e-02f, -1.57325342e-02f, -6.10131845e-02f, -4.57240120e-02f,
  -6.87447712e-02f, -6.59128092e-03f, -4.71099243e-02f, 3.37740332e-02f, -8.39115083e-02f, 5.35837151e-02f, -4.84772548e-02f, 1.34002157e-02f, -6.66332990e-02f, -7.37603474e-03f,
  2.52901316e-02f, 4.99931797e-02f, -8.34515467e-02f, -6.60489127e-02f, -4.28771228e-02f, 4.45783138e-03f, 7.41747301e-03f, -7.04596983e-03f, -4.23086844e-02f, -4.72826883e-03f,
  -7.24240392e-02f, 6.36559725e-02f, -2.73926537e-02f, 1.23132635e-02f, -1.45574780e-02f, 4.41147685e-02f, 1.67583823e-02f, -1.52359912e-02f, -1.04544252e-01f, -3.80022116e-02f,
  8.89279097e-02f, 2.91867815e-02f, 6.45981878e-02f, -5.44416625e-03f, -1.77471749e-02f, 7.65392780e-02f, -1.13822911e-02f, -2.29152283e-04f, 8.22737068e-02f, -2.96191201e-02f,
  6.59917891e-02f, 5.99581152e-02f, 9.56384763e-02f, 5.34237847e-02f, -8.90003517e-02f, -6.62121624e-02f, 6.76462874e-02f, 2.73635834e-02f, -4.86486740e-02f, -5.55757657e-02f,
  9.71478876e-03f, -4.46565337e-02f, 7.79267475e-02f, 3.74171920e-02f, -2.47410275e-02f, -4.14395891e-02f, 4.67931926e-02f, -4.83422130e-02f, -3.80479097e-02f, -1.42684132e-02f,
  -2.85533428e-01f, 2.44854197e-01f, 1.23769883e-02f, -3.36294807e-02f, 1.02365173e-01f, 1.40128940e-01f, 1.00394428e-01f, 8.20039734e-02f, 9.95645374e-02f, -5.10482490e-03f,
  -3.91932465e-02f, -1.08453028e-01f, 1.56668443e-02f, 3.61062549e-02f, -9.32216737e-03f, 1.12404928e-01f, -4.10653129e-02f, 7.83922374e-02f, 1.07499264e-01f, -3.97397429e-02f,
  -2.21781433e-03f, -8.92617926e-02f, 8.56349766e-02f, 5.02258465e-02f, -6.53908849e-02f, 1.93082094e-02f, -1.23511516e-01f, 1.51217952e-01f, 3.89176756e-02f, 1.21557407e-01f,
  -1.00578733e-01f, -6.96178079e-02f, -1.10277154e-01f, -9.76994261e-02f, -9.28513631e-02f, -1.16190977e-01f, -8.18198398e-02f, 2.33688601e-03f, -4.30421382e-02f, -7.52520189e-03f,
  -9.94991660e-02f, -4.13023159e-02f, 4.33290284e-03f, 6.65141940e-02f, -3.74178588e-02f, 1.83766615e-02f, -2.24516349e-04f, -8.02250504e-02f, -2.46459059e-02f, 9.80515704e-02f,
  -3.46149281e-02f, 4.30664308e-02f, -2.12895144e-02f, 1.13068912e-02f, 4.60008681e-02f, -1.83096956e-02f, -4.14066203e-02f, 7.68917650e-02f, 4.31470349e-02f, -5.25281988e-02f,
  6.29345402e-02f, 7.07476400e-03f, -4.63039726e-02f, 2.08816398e-02f, -4.36913073e-02f, 7.59146810e-02f, -7.08014145e-02f, -4.06863503e-02f, -3.82815860e-02f, -3.14446911e-02f,
  -5.38648060e-03f, -6.04793131e-02f, -5.20287976e-02f, -5.34926243e-02f, 9.25216451e-02f, 2.79234685e-02f, -6.01899996e-02f, 3.28287296e-02f, 5.69160208e-02f, -4.37449776e-02f,
  7.08529800e-02f, -5.79784662e-02f, -9.46572423e-02f, -6.63557053e-02f, 5.30892089e-02f, -5.31303100e-02f, -8.56939480e-02f, 3.54340523e-02f, -6.07586615e-02f, -2.83911694e-02f,
  3.33917849e-02f, 4.72594686e-02f, 2.53996402e-02f, -1.20788053e-01f, 7.01432452e-02f, -1.82310194e-02f, 7.28581399e-02f, -1.59118455e-02f, -3.58459614e-02f, -6.66718334e-02f,
  -6.22482300e-02f, -9.01277810e-02f, -4.48518023e-02f, 1.40800821e-02f, 1.03293478e-01f, 7.41608590e-02f, 2.90854722e-02f, 2.11097132e-02f, -4.02697176e-03f, 1.31541668e-02f,
  4.79181819e-02f, 1.10281771e-03f, 1.81077365e-02f, 5.59134968e-03f, 4.61229049e-02f, -6.07631020e-02f, -5.02095893e-02f, -3.41961682e-02f, -2.42497623e-02f, 2.88555622e-02f,
  -3.85146099e-03f, 4.16882262e-02f, -6.36954978e-02f, 4.53373529e-02f, 7.62042105e-02f, 8.30702484e-02f, 1.33783191e-01f, -1.19723335e-01f, 4.83996943e-02f, 2.86673065e-02f,
  -1.49851784e-01f, 9.07828808e-02f, -1.73512146e-01f, -5.10340482e-02f, 4.72240523e-03f, 5.56124491e-04f, 1.38843939e-01f, 1.47504210e-01f, -1.92127526e-02f, 6.61079511e-02f,
  -6.20174482e-02f, -8.42584446e-02f, -1.90697074e-01f, -9.31402594e-02f, 6.35684952e-02f, 1.14654796e-02f, -2.20280848e-02f, 3.44462432e-02f, 3.30112614e-02f, 1.15727889e-03f,
  -5.77119477e-02f, -5.64385159e-03f, 4.88914025e-04f, 6.96862340e-02f, -1.54841524e-02f, -7.08693638e-03f, -7.91431870e-03f, 2.47362871e-02f, 4.71159965e-02f, 1.73020381e-02f,
  1.24049015e-01f, 7.26706684e-02f, 1.83417241e-03f, -4.45011519e-02f, -6.62045330e-02f, -4.26730290e-02f, -6.50484264e-02f, -6.43933490e-02f, -8.50595813e-03f, 2.54920572e-02f,
  7.64318407e-02f, -1.67113710e-02f, -5.61362989e-02f, 7.96843469e-02f, 2.86132805e-02f, 9.65369120e-02f, 1.13251507e-01f, 1.08418323e-01f, 7.51293451e-02f, 6.03655092e-02f,
  -4.44389880e-02f, 8.45425949e-02f, -3.35439369e-02f, 8.83085746e-03f, 3.18673700e-02f, 5.43172006e-03f, -2.24823467e-04f, 1.17021464e-02f, -2.57776435e-02f, -3.57422105e-04f,
  -3.65654826e-02f, 5.34022786e-02f, 6.45613149e-02f, 6.78607449e-02f, -1.35307219e-02f, -3.76884341e-02f, 8.34486634e-02f, -5.21757528e-02f, 2.20747516e-02f, -6.09928630e-02f,
  -2.30622049e-02f, 1.37035996e-02f, -5.32633392e-03f, -2.17178147e-02f, -6.23621643e-02f, -8.07192456e-03f, -4.36102506e-03f, -5.47546744e-02f, 4.54182439e-02f, 5.19927256e-02f,
  9.18670464e-03f, 1.51192605e-01f, -3.58429700e-02f, 5.81516214e-02f, 6.35303706e-02f, 3.33188325e-02f, 9.96706709e-02f, -3.05429734e-02f, 9.02111903e-02f, 6.02505207e-02f,
  4.12614085e-04f, -1.11627011e-02f, 2.34882869e-02f, 1.53128179e-02f, 9.34967473e-02f, -4.55939397e-02f, -2.30557267e-02f, 6.98711947e-02f, 2.30315942e-02f, -1.34903770e-02f,
  5.95091097e-02f, -3.58352475e-02f, -1.58689264e-02f, 1.17825391e-02f, -3.77053022e-02f, 1.04015164e-01f, 6.70688599e-02f, -3.52437943e-02f, -2.66801063e-02f, 1.02952033e-01f,
  -1.53911188e-01f, 8.08293000e-03f, -1.71186365e-02f, -1.00675948e-01f, 1.45863131e-01f, -3.68331894e-02f, 6.65194392e-02f, 1.15155624e-02f, -3.62642296e-02f, 5.52460924e-02f,
  8.04718584e-02f, -1.24705791e-01f, -9.20960382e-02f, -1.11132152e-01f, -2.10684270e-01f, -1.59049496e-01f, -1.09541398e-02f, -1.26390219e-01f, -1.42269060e-01f, -2.93885320e-02f,
  -2.81571336e-02f, -2.68420745e-02f, 4.55144979e-02f, 1.06985562e-01f, 5.53618483e-02f, 3.74516137e-02f, 1.17173359e-01f, 7.41779208e-02f, -2.95869838e-02f, -7.29035540e-03f,
  9.29796770e-02f, -8.00686479e-02f, 8.74224212e-03f, -3.71409468e-02f, -4.91217040e-02f, 8.71754214e-02f, 2.14193929e-02f, -2.71839276e-02f, 1.88147388e-02f, 3.89042683e-02f,
  -7.97124300e-03f, 4.74187471e-02f, -4.86146398e-02f, 5.32804132e-02f, -2.38689315e-02f, -7.51965642e-02f, 7.34852701e-02f, 4.20561805e-02f, -6.65684864e-02f, -1.05770677e-01f,
  -8.92492011e-02f, -8.69776239e-04f, -5.95986731e-02f, -8.22404101e-02f, 6.80749714e-02f, -5.78914508e-02f, -7.38171414e-02f, 5.02703860e-02f, -6.66455105e-02f, -6.05301932e-02f,
  -2.47180142e-04f, 1.49865905e-02f, -4.93276156e-02f, 2.79971883e-02f, 5.26118232e-03f, 6.62453705e-03f, -4.85705249e-02f, 6.42453954e-02f, 4.60247844e-02f, -4.25423272e-02f,
  6.94571957e-02f, 1.06558213e-02f, -6.18752688e-02f, 3.80297229e-02f, -6.42526569e-03f, -8.27505067e-02f, -1.88845675e-02f, -6.21756613e-02f, 7.04892576e-02f, -5.48958592e-02f,
  8.05976465e-02f, -5.07772202e-03f, -4.01163846e-02f, 2.88510583e-02f, -1.31806796e-02f, -3.91868912e-02f, 1.05361370e-02f, -4.54636104e-02f, 6.88808411e-02f, 2.58842427e-02f,
  5.71589544e-02f, 3.61493193e-02f, -1.25541296e-02f, 9.52721685e-02f, 8.99818838e-02f, -3.13321017e-02f, 4.99707162e-02f, -3.54981907e-02f, -7.20469058e-02f, 4.24489155e-02f,
  5.32010496e-02f, 6.45820610e-03f, 3.61499861e-02f, -6.86580613e-02f, -4.34202030e-02f, -6.66148439e-02f, 7.05384044e-03f, 3.11511420e-02f, 1.25690398e-03f, 3.76214972e-03f,
  -5.57261566e-03f, 8.99001062e-02f, -6.37222305e-02f, 9.53457654e-02f, -6.34400249e-02f, -1.52799152e-02f, -1.97876301e-02f, 2.86237709e-02f, 7.64242411e-02f, 4.34586108e-02f,
  -1.04703560e-01f, -5.66809140e-02f, -2.96338368e-02f, 1.74611449e-01f, 3.98878157e-02f, -9.01589096e-02f, -4.42978553e-02f, -1.09123021e-01f, -1.77786425e-01f, -1.48938835e-01f,
  5.61667569e-02f, -2.74477284e-02f, -1.48354709e-01f, 6.46998510e-02f, 6.41199201e-02f, -9.66932848e-02f, -1.17931413e-02f, 7.82452747e-02f, -1.14810407e-01f, -1.43538406e-02f,
  5.67076392e-02f, 1.55899718e-01f, 1.43249388e-04f, 2.27399364e-01f, 1.01137839e-01f, 1.80894032e-01f, 2.18957201e-01f, 1.43347368e-01f, 3.11063856e-01f, 1.20848149e-01f,
  -9.85018387e-02f, -3.35708121e-03f, -5.46345264e-02f, 3.21255438e-02f, 7.40231527e-03f, -2.17655413e-02f, -1.02780312e-02f, 4.24053706e-02f, 3.10732685e-02f, 3.19929197e-02f,
  4.51747812e-02f, 7.62267262e-02f, -6.10569939e-02f, 4.84013073e-02f, -5.68188056e-02f, 8.59252550e-03f, -8.59660134e-02f, 3.29160094e-02f, -3.27738374e-02f, -5.66067211e-02f,
  -4.09329310e-02f, 6.54693097e-02f, 4.12583053e-02f, 8.72858167e-02f, 5.92331635e-03f, 6.90669343e-02f, 3.73934694e-02f, 7.82461930e-03f, -2.99032265e-03f, 6.53568357e-02f,
  -4.44518104e-02f, 2.38112826e-02f, -1.05060026e-01f, -8.62306058e-02f, -1.35336174e-02f, 7.71639450e-03f, -1.18954442e-02f, 2.46452540e-02f, -8.58007744e-02f, -4.17344607e-02f,
  7.22330734e-02f, -6.26978725e-02f, -1.17092235e-02f, 2.79340409e-02f, -7.56729916e-02f, -1.18769661e-01f, -8.89448375e-02f, -4.21889909e-02f, -6.28884211e-02f, 2.99463496e-02f,
  6.69371616e-03f, 6.00637197e-02f, 7.51126185e-02f, 4.86990027e-02f, 2.37688255e-02f, 5.66308061e-03f, 9.34306011e-02f, -7.19897598e-02f, 1.99561361e-02f, -2.62779742e-02f,
  1.43391833e-01f, 1.89134777e-01f, -6.10481855e-03f, 5.10311089e-02f, -2.69576535e-02f, 1.40187079e-02f, 1.37605267e-02f, 1.44233229e-02f, 6.44140020e-02f, -2.81540435e-02f,
  8.08303431e-02f, 8.79509524e-02f, 8.60412121e-02f, 2.58921348e-02f, 8.84446427e-02f, -5.33186784e-03f, 9.47039202e-02f, -1.55622503e-02f, 1.42120242e-01f, 7.19028264e-02f,
  1.10659651e-01f, -3.60181183e-02f, -6.58311099e-02f, -9.41591710e-02f, 8.55594054e-02f, 6.62192479e-02f, 7.12899342e-02f, -2.39000209e-02f, -4.45877127e-02f, 1.14876181e-01f,
  -4.17259485e-02f, 7.37387985e-02f, 1.40842944e-01f, 1.50820374e-01f, -2.26297498e-01f, 1.90092288e-02f, 1.10374056e-02f, -4.89522591e-02f, 7.52311349e-02f, 8.77976716e-02f,
  -1.90851092e-02f, 6.47835294e-03f, 5.41051440e-02f, 8.34997371e-02f, -5.74869476e-02f, -2.94059403e-02f, 4.77983877e-02f, 7.68107325e-02f, -2.95272041e-02f, 1.07481442e-01f,
  -1.88925639e-02f, -4.11844887e-02f, 5.64610958e-03f, 4.04874608e-02f, -2.44802795e-02f, 7.89674092e-03f, -6.25832602e-02f, -9.07064155e-02f, 8.54566023e-02f, -1.36480987e-01f,
  -1.03602424e-01f, -8.93866457e-03f, 9.98815075e-02f, -3.53876054e-02f, 7.50190914e-02f, 8.10666103e-03f, -6.20747991e-02f, -4.56907041e-02f, 8.47235918e-02f, 4.59657051e-03f,
  -2.72735767e-03f, 4.56221588e-02f, -5.87821240e-03f, -1.51180578e-02f, -6.86197579e-02f, 1.71335097e-02f, -4.79607917e-02f, -7.68653583e-04f, -3.78164090e-02f, -6.96606934e-02f,
  1.13231633e-02f, 3.54830474e-02f, 8.84745212e-04f, 8.15989152e-02f, 6.15750290e-02f, 3.31086740e-02f, 1.64497253e-02f, 3.64617072e-02f, -2.28256602e-02f, -8.37326348e-02f,
  4.64151129e-02f, -2.68219952e-02f, -3.19721065e-02f, -8.44410900e-03f, -9.71561968e-02f, 1.26498230e-02f, 4.23886860e-03f, -3.39506827e-02f, 5.61298952e-02f, -2.48644222e-02f,
  1.08015826e-02f, -9.10351202e-02f, -5.99893108e-02f, -1.72365252e-02f, 6.09385930e-02f, -8.16379562e-02f, -4.38034348e-02f, -5.12358509e-02f, 5.20323664e-02f, 7.96492919e-02f,
  4.72797453e-02f, -3.88784669e-02f, -4.55471575e-02f, 5.76658472e-02f, -5.92594966e-02f, -3.60945202e-02f, -3.29174548e-02f, 6.23537861e-02f, 1.14651881e-02f, 2.00187247e-02f,
  6.34904429e-02f, 3.69454473e-02f, -4.03803997e-02f, 3.61500122e-02f, -2.08598766e-02f, 4.87776250e-02f, 2.50257123e-02f, -2.00373475e-02f, 1.25625022e-02f, -5.27391024e-02f,
  2.03408562e-02f, -6.93708006e-03f, 5.18661067e-02f, -8.65956098e-02f, 8.99808034e-02f, -2.90514007e-02f, 6.06264882e-02f, 4.03418019e-02f, -4.89887223e-02f, 8.71816054e-02f,
  1.06041804e-01f, 5.32922260e-02f, 9.87756103e-02f, 7.93543831e-02f, 9.11089480e-02f, -1.50425434e-02f, 7.24329948e-02f, 8.27603638e-02f, 6.67530373e-02f, -6.44744709e-02f,
  -2.23676418e-03f, 1.79422379e-01f, 1.85674042e-01f, 1.20879831e-02f, -1.52863458e-01f, -1.33269295e-01f, -7.33831301e-02f, -1.00034311e-01f, -7.33787939e-02f, -1.87357666e-03f,
  2.68562473e-02f, 1.22047409e-01f, -8.84615108e-02f, 6.49238500e-05f, -9.68825668e-02f, -5.82393110e-02f, -9.36437026e-02f, 1.16481587e-01f, 2.02439190e-03f, -3.62118403e-03f,
  1.81179512e-02f, -6.55654743e-02f, 1.22812249e-01f, 9.40083247e-03f, 9.90148336e-02f, 1.05030648e-01f, 2.60589309e-02f, 1.02717750e-01f, -1.57202594e-02f, 1.24122249e-02f,
  -1.02281839e-01f, -4.97536510e-02f, 7.65737379e-03f, -6.94313273e-03f, -3.63555029e-02f, 2.06244830e-02f, 4.58274558e-02f, 7.77639672e-02f, 2.60786358e-02f, 4.66752835e-02f,
  7.34360367e-02f, 6.88915849e-02f, 5.53722754e-02f, -6.27595175e-04f, 1.81135666e-02f, 1.50909936e-02f, -3.19764242e-02f, 2.53268834e-02f, 1.07881710e-01f, 7.31077269e-02f,
  9.45204273e-02f, 7.24342838e-02f, -4.12695296e-02f, -5.49133904e-02f, 6.01786114e-02f, 6.44375235e-02f, 5.09779751e-02f, -4.42411471e-03f, 9.04604718e-02f, -6.14469238e-02f,
  1.37558337e-02f, -2.41459068e-02f, -6.07369952e-02f, 8.15389957e-03f, 1.14709036e-02f, -1.45292385e-02f, 7.70922527e-02f, 5.01609258e-02f, -3.78080532e-02f, 8.15833686e-04f,
  -4.02837470e-02f, 8.08917060e-02f, 2.70998869e-02f, 4.72294092e-02f, -5.89381419e-02f, 1.78324971e-02f, -1.98646281e-02f, -2.34317537e-02f, -1.93004385e-02f, -6.95310161e-02f,
  7.60461017e-02f, -8.62954333e-02f, -8.14420357e-02f, -1.06995674e-02f, -3.55657563e-02f, 7.25291744e-02f, -3.28993015e-02f, -5.86306080e-02f, -4.54330742e-02f, 1.04801863e-01f,
  -6.12668172e-02f, 4.68834722e-03f, 8.38087127e-02f, -7.09798411e-02f, -6.05542539e-03f, 8.22312534e-02f, 4.67492566e-02f, -1.69301182e-02f, -7.27300495e-02f, -1.08626015e-01f,
  5.52151771e-03f, 2.80057285e-02f, -5.90438470e-02f, -8.16536173e-02f, -8.54392201e-02f, 2.60353722e-02f, -8.88121873e-02f, -8.12810939e-03f, 6.39113486e-02f, 7.50039890e-02f,
  6.34647608e-02f, 4.15110439e-02f, -1.88618973e-02f, 5.95161505e-02f, 3.99080701e-02f, 2.66191214e-02f, -2.50561647e-02f, 4.23129052e-02f, 5.48443012e-02f, 1.03451386e-01f,
  8.83086324e-02f, -1.63797572e-01f, -3.03903725e-02f, 9.83460154e-03f, -1.30408478e-03f, -1.90803155e-01f, -2.25115150e-01f, -8.05380172e-04f, 2.34675914e-01f, 9.30238608e-03f,
  -1.23928323e-01f, -7.83895515e-03f, -3.33958901e-02f, -1.16095543e-01f, 1.89076364e-01f, 2.12512419e-01f, -7.07806647e-02f, 6.03536051e-03f, 9.49141011e-02f, -2.73363665e-02f,
  -4.60069685e-04f, -1.03147201e-01f, -8.45708773e-02f, -1.91459611e-01f, -2.58587331e-01f, -1.14508718e-01f, -8.01532418e-02f, -1.92037910e-01f, -1.93824425e-01f, -7.07428083e-02f,
  -1.64471224e-01f, -1.93279572e-02f, -6.93958923e-02f, -1.25016630e-01f, -1.16796888e-01f, 5.64974062e-02f, -7.25515187e-02f, -1.32412557e-02f, 3.30318362e-02f, 4.54547890e-02f,
  3.47782709e-02f, -2.44917837e-03f, 7.65835401e-03f, -2.17467756e-03f, 5.18440595e-03f, -8.25160071e-02f, 1.53127853e-02f, -3.36365663e-02f, -7.01125637e-02f, -3.32883075e-02f,
  -1.04325458e-01f, -6.35190383e-02f, 8.06219801e-02f, 2.42478568e-02f, 4.95747551e-02f, 5.54111786e-02f, -1.80646367e-02f, -7.87304118e-02f, 7.61203468e-03f, -3.67818698e-02f,
  5.51894531e-02f, -1.76513344e-02f, -1.40836006e-02f, 2.26448663e-03f, -8.50322992e-02f, -6.19291440e-02f, -6.11191876e-02f, 3.30198966e-02f, 4.14612629e-02f, -6.54075146e-02f,
  -1.79993026e-02f, -5.49175702e-02f, 5.84716722e-02f, -3.20988968e-02f, 2.56214850e-02f, 8.83348957e-02f, -6.79321513e-02f, 7.69651309e-02f, 1.07162379e-01f, 9.26681161e-02f,
  7.98528735e-03f, 1.04463756e-01f, -7.91710615e-02f, 1.73717532e-02f, 3.94850364e-03f, -4.26137354e-03f, 3.42968218e-02f, 5.14434017e-02f, -1.03858998e-02f, -7.60263428e-02f,
  -1.42838523e-01f, -6.70370460e-02f, -4.30456921e-02f, 3.02716196e-02f, -3.55771482e-02f, -4.76297513e-02f, -1.33400522e-02f, -5.11999708e-03f, -2.46948488e-02f, -3.89736108e-02f,
  3.02111376e-02f, -1.49563355e-02f, 5.03675304e-02f, -5.08679077e-02f, 5.44049554e-02f, 4.30858172e-02f, 2.63373442e-02f, -7.69720450e-02f, -6.12377301e-02f, 6.67808354e-02f,
  -1.07094593e-01f, 4.37462144e-02f, -8.35272297e-02f, -1.63883623e-02f, 4.98073921e-02f, -4.53572571e-02f, 5.64624779e-02f, 6.65496439e-02f, -8.51013288e-02f, -4.39192392e-02f,
  -3.33009548e-02f, -1.65525824e-02f, -1.05186574e-01f, 5.74109964e-02f, 1.07938699e-01f, -8.94395113e-02f, 5.83390798e-03f, 3.24294493e-02f, 1.79925542e-02f, -3.52809168e-02f,
  7.42878318e-02f, -1.08459622e-01f, -1.83067650e-01f, -6.65674433e-02f, -1.02773055e-01f, -2.10758343e-01f, -1.23045973e-01f, -7.64963999e-02f, -1.98995392e-03f, 6.05342910e-02f,
  -8.31802860e-02f, 5.35081513e-02f, -6.85956776e-02f, 1.50185823e-01f, 5.07713705e-02f, 6.85654953e-02f, 3.93981934e-02f, 5.88190630e-02f, 8.19868669e-02f, -4.44175899e-02f,
  -3.28879468e-02f, -8.61404389e-02f, 3.43756238e-03f, -1.81420278e-02f, 3.74011360e-02f, 3.00877132e-02f, -5.31820692e-02f, -1.53460093e-02f, 8.74922723e-02f, -1.43793803e-02f,
  -6.42614886e-02f, 7.42505565e-02f, 9.28333402e-02f, 5.31684384e-02f, 6.72407523e-02f, 3.27579491e-02f, 3.57179646e-03f, -3.83464396e-02f, 1.98031086e-02f, -1.16837651e-01f,
  -8.65867808e-02f, -2.60388907e-02f, -8.01889896e-02f, 3.09287012e-02f, -8.84020105e-02f, -5.58265392e-03f, -6.76392317e-02f, -9.65664014e-02f, 1.73269231e-02f, 8.91836639e-03f,
  -3.15455832e-02f, -9.28656757e-03f, -9.81655642e-02f, 5.46200015e-03f, 8.72232020e-02f, -1.82684027e-02f, 5.21782190e-02f, 3.19072604e-03f, -4.72392403e-02f, -1.87671576e-02f,
  -5.64078428e-02f, -1.88301001e-02f, 5.37470877e-02f, -8.47920030e-02f, -3.49630006e-02f, 7.10848197e-02f, 5.33204235e-04f, -1.85358226e-02f, 6.64507374e-02f, -4.29362878e-02f,
  9.36237946e-02f, -1.20538650e-02f, -1.17520746e-02f, -3.97523167e-03f, -1.54307289e-02f, 6.80941716e-02f, 6.97464310e-03f, 1.15392590e-02f, -3.26413736e-02f, 7.07404763e-02f,
  -1.59846961e-01f, -1.46865532e-01f, 2.59712320e-02f, -9.81740374e-03f, -5.62298149e-02f, -8.78130496e-02f, 3.26284468e-02f, -5.35197780e-02f, -2.56184228e-02f, -2.73599662e-02f,
  -4.79474664e-02f, 7.08539411e-02f, -2.19825432e-02f, -4.71328348e-02f, 8.56751576e-03f, -1.27006117e-02f, -3.74324508e-02f, -8.31784084e-02f, -4.02658470e-02f, 3.97423049e-03f,
  8.83524269e-02f, 8.26140791e-02f, -3.21644871e-03f, 8.07414502e-02f, 5.86075941e-03f, 1.14259593e-01f, -7.13885278e-02f, 2.72678453e-02f, -4.07753959e-02f, -9.57999304e-02f,
  1.17560476e-02f, -6.93306029e-02f, 1.43823937e-01f, 6.89644925e-03f, -1.09686833e-02f, 1.18831195e-01f, 2.04159543e-02f, -3.41797975e-04f, -1.84837244e-02f, -1.26311397e-02f,
  -1.53578743e-02f, -3.68554331e-02f, 4.14046310e-02f, -1.14285663e-01f, 1.19363628e-01f, 4.46256213e-02f, -8.82332847e-02f, -1.08577147e-01f, -5.84104061e-02f, -7.64268935e-02f,
  -6.27302229e-02f, 9.84708220e-03f, 6.05338439e-02f, -7.66833946e-02f, -5.68177588e-02f, -8.40227976e-02f, -6.26045987e-02f, 1.49715155e-01f, 7.37036839e-02f, -1.50083322e-02f,
  2.87876502e-02f, 5.43290458e-04f, -6.46358654e-02f, 5.71281649e-02f, 3.45627032e-02f, 6.41682968e-02f, 7.06375167e-02f, 3.59175261e-03f, 6.54691234e-02f, -8.52212235e-02f,
  3.61666419e-02f, 1.75303612e-02f, 4.25355248e-02f, 9.60501209e-02f, -6.66973516e-02f, -7.45505020e-02f, 8.11860897e-03f, 1.74723717e-03f, 5.59283383e-02f, -2.72092540e-02f,
  3.97666208e-02f, 4.05008160e-02f, -2.30000005e-03f, 2.00528972e-04f, 5.94813563e-02f, 2.13390030e-02f, -7.25655258e-02f, 3.90376449e-02f, -9.51668471e-02f, 2.26012599e-02f,
  5.43830581e-02f, 3.29055861e-02f, -2.20901929e-02f, -3.23698334e-02f, -5.90247922e-02f, -3.69523205e-02f, -4.66869809e-02f, -4.48686890e-02f, -6.75936043e-02f, 7.54551403e-03f,
  -2.11353544e-02f, -6.05442282e-03f, -4.15900461e-02f, -7.39803836e-02f, 1.68248247e-02f, -2.18481082e-03f, 3.62764634e-02f, 1.46743217e-02f, 2.85097249e-02f, 9.17002335e-02f,
  -9.44334865e-02f, 5.89814931e-02f, -4.92406562e-02f, -7.75519013e-02f, 7.84293413e-02f, 7.35497400e-02f, -4.94833253e-02f, 1.74853038e-02f, -4.14392762e-02f, -2.71120593e-02f,
  4.09701020e-02f, -1.29865319e-01f, -4.83088121e-02f, 5.48150167e-02f, 5.63993230e-02f, 8.14043880e-02f, 5.34789935e-02f, 1.67424269e-02f, 4.84400317e-02f, -4.46159542e-02f,
  -3.43371704e-02f, 5.53408498e-03f, -5.49138337e-03f, -7.67142326e-02f, 1.32474583e-03f, -4.38752733e-02f, 3.64153460e-02f, 5.01819924e-02f, -2.36286595e-02f, -8.39180592e-03f,
  -5.26158437e-02f, 3.46049890e-02f, -5.17564826e-02f, -8.01532194e-02f, 4.87144925e-02f, -1.24829262e-02f, -4.58520725e-02f, 1.96631043e-03f, -3.91149521e-02f, -4.63864058e-02f,
  5.75790033e-02f, 2.40813196e-01f, -1.51286483e-01f, 8.74400139e-02f, -1.41883865e-01f, 2.14855388e-01f, 1.46897495e-01f, -5.77980131e-02f, 1.32667258e-01f, 1.19596310e-01f,
  4.45999764e-02f, 1.20457947e-01f, 9.07052308e-02f, 2.06302494e-01f, 1.49068728e-01f, 1.84316456e-01f, 2.40476191e-01f, 1.55965894e-01f, -4.04110365e-02f, 1.39218852e-01f,
  -1.95146762e-02f, 1.70921266e-01f, -1.22434683e-01f, -1.28921792e-01f, -4.29706052e-02f, -1.34141237e-01f, -4.86291237e-02f, -1.63601398e-01f, -8.42215493e-02f, -1.33394478e-02f,
  -6.64940029e-02f, 7.27095976e-02f, -9.53613371e-02f, 5.75043522e-02f, -5.10073863e-02f, 1.00222565e-01f, -7.78471902e-02f, -8.33646059e-02f, -9.07966271e-02f, -5.11491019e-03f,
  -3.00149228e-02f, -1.92069579e-02f, 1.25198156e-01f, -1.72928721e-02f, 7.40401587e-03f, 4.88641672e-02f, -3.14680040e-02f, 4.25663823e-03f, -9.05373618e-02f, -5.02395723e-03f,
  4.33465242e-02f, -1.01424351e-01f, 5.15620485e-02f, 1.11203045e-02f, 2.85536814e-02f, -1.10286651e-02f, 3.98268960e-02f, 1.03269797e-02f, 9.33336541e-02f, -1.24229789e-02f,
  6.82042167e-02f, 5.36638126e-02f, 9.34111178e-02f, -2.47198902e-02f, 3.86534855e-02f, -1.50443297e-02f, -6.77147433e-02f, -4.06568423e-02f, 4.41069249e-03f, -6.14232104e-03f,
  -1.67802684e-02f, -1.30368918e-02f, -1.56092551e-02f, 2.03746501e-02f, -8.61843582e-03f, 9.97809600e-03f, -5.17816395e-02f, 1.72284208e-02f, 2.07551979e-02f, -8.58775303e-02f,
  2.83858329e-02f, 4.61987145e-02f, 3.02812154e-03f, 2.95569864e-03f, 8.59043673e-02f, -8.94174632e-03f, 1.00572683e-01f, -5.33786137e-03f, 2.19619274e-02f, 2.76995846e-03f,
  1.67830855e-01f, 2.02642649e-01f, -2.44731195e-02f, -6.83076540e-03f, 3.32817584e-02f, 8.58904980e-03f, 1.06300183e-01f, 5.47283068e-02f, 3.60764638e-02f, 1.05855927e-01f,
  5.80499433e-02f, -4.46553566e-02f, -1.58502348e-02f, -4.61265482e-02f, 2.09925231e-02f, 1.10841423e-01f, 9.26388949e-02f, -4.82446738e-02f, 2.61995895e-03f, 3.73953325e-03f,
  -2.87897401e-02f, 7.41490796e-02f, 1.83536448e-02f, 5.09259244e-03f, -1.84575431e-02f, 2.13286234e-03f, -6.47929087e-02f, -6.24551736e-02f, -1.96254123e-02f, -1.02300348e-03f,
  -7.33861104e-02f, 8.37458745e-02f, -5.85761219e-02f, 3.71396467e-02f, -1.97880730e-01f, 9.03716758e-02f, 1.96847737e-01f, 3.67138088e-02f, 2.25724310e-01f, 1.71299294e-01f,
  -2.08283253e-02f, 1.17008813e-01f, 1.13224067e-01f, 3.49226631e-02f, 4.73567136e-02f, 2.06189275e-01f, 7.40091428e-02f, 8.86859298e-02f, -4.82991673e-02f, 1.03886478e-01f,
  -1.77507531e-02f, 1.02361143e-01f, -1.04630388e-01f, -1.36904001e-01f, -1.43990666e-01f, -8.21321160e-02f, -1.58489764e-01f, -8.11836794e-02f, 9.57746990e-03f, -3.94772738e-02f,
  -2.09024865e-02f, 3.68351713e-02f, -3.12983096e-02f, -8.44184905e-02f, -3.64919589e-03f, -4.33151349e-02f, 5.91534078e-02f, -3.92242670e-02f, -4.91267890e-02f, -3.93528603e-02f,
  -5.39681613e-02f, 2.02634893e-02f, -4.67337780e-02f, 4.91458215e-02f, -5.45467250e-02f, 9.41652991e-03f, -3.26253735e-02f, -1.01504594e-01f, 5.39177970e-04f, -1.00411259e-01f,
  -3.24735641e-02f, -3.50317359e-02f, 3.33763771e-02f, 9.72180516e-02f, -5.80232292e-02f, -3.17120627e-02f, 7.26095662e-02f, -3.95560404e-03f, 8.61141682e-02f, 7.42914081e-02f,
  1.51971253e-02f, 7.68208951e-02f, -2.40921490e-02f, -6.96900114e-02f, -9.16353017e-02f, -6.99941954e-03f, -3.06810495e-02f, -2.01768684e-03f, 4.94691357e-03f, 3.96178942e-03f,
  -3.60224545e-02f, 3.93115431e-02f, 8.27319399e-02f, 7.45950788e-02f, 7.48005509e-02f, 3.02826874e-02f, -6.70780018e-02f, -8.42544809e-02f, 3.01834680e-02f, 3.40362731e-03f,
  4.58958112e-02f, -3.19622308e-02f, 1.85800791e-02f, -4.50606346e-02f, 8.82055536e-02f, 6.14477731e-02f, -8.15688595e-02f, 1.14853345e-02f, 2.67798509e-02f, 5.88365197e-02f,
  6.70995563e-02f, 5.16056158e-02f, 3.55120413e-02f, 2.23949607e-02f, 8.43904987e-02f, 5.33608869e-02f, 7.57098868e-02f, -4.96943444e-02f, 8.23744535e-02f, 3.49016786e-02f,
  -3.53320874e-03f, 1.93463992e-02f, 1.77031811e-02f, -6.76442385e-02f, 8.42357501e-02f, 6.69534877e-02f, 1.06661975e-01f, 1.89006887e-02f, 8.95073861e-02f, -3.26582305e-02f,
  -2.78367605e-02f, 3.09546571e-03f, 1.00025058e-01f, 5.26940357e-03f, 9.78616700e-02f, -1.06254984e-02f, 6.35951981e-02f, -2.52046436e-02f, -4.94097061e-02f, 7.04996809e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  1.49732202e-01f, 1.41973123e-01f, 2.16399580e-01f, 3.93500030e-02f, 1.57794416e-01f, 6.46461993e-02f, 7.66700506e-02f, 6.10904098e-02f, -3.13790366e-02f, 2.76491821e-01f,
  1.41820461e-01f, 2.04745427e-01f, 5.41711859e-02f, 1.73873857e-01f, 6.51719794e-02f, 1.35070428e-01f, -6.06847461e-04f, 1.17030248e-01f, 9.91501659e-03f, 5.36393970e-02f,
  1.56815663e-01f, 1.85695529e-01f, 1.94410205e-01f, 1.41205773e-01f, 2.07068592e-01f, 1.83552384e-01f, 9.15017948e-02f, 7.83860460e-02f, 1.39378816e-01f, 1.20399855e-01f,
  1.25629082e-01f, 2.20396355e-01f, 7.71184936e-02f, 3.03404462e-02f, 1.92480360e-03f, 1.35481209e-01f, 6.52624145e-02f, 1.48369139e-02f, -2.40734797e-02f, 7.63252676e-02f,
  9.15421546e-02f, -3.39984521e-02f, 1.14143968e-01f, 1.34198561e-01f, -2.01388318e-02f, 5.77795804e-02f, 7.83042088e-02f, 3.70660797e-02f, 1.94169477e-01f, 9.51954722e-02f,
  1.44554272e-01f, 9.75285694e-02f, 9.59747434e-02f, 1.58071473e-01f, 2.92752348e-02f, 3.44769061e-02f, 1.12950906e-01f, 1.04914866e-01f, 9.52373538e-03f, 2.85765138e-02f,
  4.83242013e-02f, -5.52914152e-03f, 1.48298889e-01f, 7.80511498e-02f, 1.27239078e-01f, 3.91609669e-02f, -4.02121060e-02f, 2.12190915e-02f, 8.97563845e-02f, 7.92337209e-02f,
  1.54426038e-01f, 1.01359747e-01f, 7.54401013e-02f, 9.51839536e-02f, -1.39744459e-02f, 1.49435028e-01f, 7.07312226e-02f, 6.63852543e-02f, 1.29993677e-01f, 4.99287061e-02f,
  1.90035272e-02f, 1.94245681e-01f, 2.00177491e-01f, 1.43143401e-01f, 2.60386355e-02f, 1.23661622e-01f, 1.23331241e-01f, -3.77305225e-02f, 1.46893069e-01f, 6.10602386e-02f,
  8.52825493e-02f, 3.02614123e-01f, -8.68275110e-03f, 7.58602694e-02f, 7.62753710e-02f, 7.28240311e-02f, 1.81479424e-01f, 7.88470060e-02f, 1.32822216e-01f, 1.05093256e-01f,
  1.79023057e-01f, 6.69796579e-03f, 2.06421673e-01f, 4.48693670e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.41958773e-01f, 1.52995232e-02f, -2.07420692e-01f, -1.77994505e-01f, -7.24867657e-02f, -4.46443073e-02f, -7.61236399e-02f, -4.83172014e-02f, -2.59386748e-02f, -6.48966655e-02f,
  -2.91256309e-02f, 3.08232848e-02f, 2.63191074e-01f, 2.63997912e-02f, 2.82159925e-01f, -2.30638191e-01f, -3.13747823e-01f, 3.30706269e-01f, 3.48232061e-01f, 3.92945409e-02f,
  1.98372245e-01f, -9.69279036e-02f, -2.95677423e-01f, 1.35214970e-01f, -4.42975480e-03f, 1.90458715e-01f, -1.49219245e-01f, -5.32958582e-02f, -1.46181565e-02f, -5.66895455e-02f,
  -3.48355919e-02f, -9.33514312e-02f, -8.45525041e-02f, -1.51465610e-01f, 2.03647744e-02f, -2.41334021e-01f, -1.17814183e-01f, 5.69710024e-02f, 4.80500638e-01f, 3.12121749e-01f,
  -1.44720435e-01f, 2.63092648e-02f, -6.90269331e-03f, -1.25224069e-01f, -1.02011420e-01f, -2.39529535e-01f, 1.96731046e-01f, -1.70008883e-01f, -1.20971166e-01f, -1.24919236e-01f,
  3.94239306e-01f, -7.91013464e-02f, -5.68793304e-02f, -2.62575187e-02f, 3.66541147e-02f, -9.93361622e-02f, -1.30555958e-01f, -1.53739020e-01f, -4.23914529e-02f, -1.34156317e-01f,
  5.36645830e-01f, 8.15580040e-02f, -6.41175807e-02f, -9.29806232e-02f, -1.04761355e-01f, -3.83643731e-02f, -1.64105281e-01f, -1.68523893e-01f, 1.21018149e-01f, 1.35056034e-01f,
  4.06271890e-02f, -4.33712080e-02f, 1.88008770e-01f, -1.49413466e-01f, 3.25565487e-01f, -1.19551115e-01f, -2.46851780e-02f, 3.14324468e-01f, -8.89841318e-02f, -7.51424804e-02f,
  2.91967601e-01f, -1.78172559e-01f, -1.11492410e-01f, -1.34716243e-01f, -1.10515811e-01f, -3.68104391e-02f, -1.12945974e-01f, 4.29897189e-01f, -8.47441982e-03f, -3.76579240e-02f,
  -9.65601653e-02f, -1.71088949e-01f, -4.46627997e-02f, -1.48766981e-02f, -6.59754723e-02f, 2.87247956e-01f, -1.56463251e-01f, -1.48964256e-01f, -2.97549032e-02f, 2.10568801e-01f,
  3.90013427e-01f, 3.96265611e-02f, -8.82388279e-02f, 4.19597536e-01f, -1.87224910e-01f, -2.43417814e-01f, 1.78632602e-01f, -1.27797708e-01f, 1.02044277e-01f, -4.16649431e-02f,
  1.13097019e-01f, -6.48357421e-02f, -8.14471096e-02f, -7.57928491e-02f, -2.90545281e-02f, -1.25245526e-01f, 1.47490978e-01f, 9.47672054e-02f, -1.22784391e-01f, 6.23889491e-02f,
  -1.81322530e-01f, 1.67248368e-01f, -1.52710369e-02f, -9.46754217e-02f, 2.36065350e-02f, -5.63204475e-02f, 2.03499377e-01f, 2.13427514e-01f, 2.31157150e-02f, -1.19942181e-01f,
  6.16741143e-02f, 8.59041065e-02f, 6.34761294e-03f, 9.10519287e-02f, 5.44700548e-02f, 3.54557604e-01f, 1.07977115e-01f, -2.58905798e-01f, -5.23861527e-01f, -1.15608901e-01f,
  -1.21439092e-01f, 4.49447662e-01f, 2.33173981e-01f, 1.90431029e-01f, 4.30431873e-01f, -2.05523580e-01f, -3.38962793e-01f, -1.03583969e-01f, -2.91977208e-02f, 4.07411218e-01f,
  -4.17918600e-02f, 2.95145750e-01f, -1.03573240e-01f, -1.10418528e-01f, -2.44574800e-01f, -8.76182392e-02f, -4.48870286e-02f, -6.04437031e-02f, 1.38747066e-01f, -1.08886093e-01f,
  6.63599744e-02f, -2.03337252e-01f, 2.14363828e-01f, -2.19484553e-01f, 6.52481616e-02f, 1.92085188e-02f, -3.42548043e-02f, -1.28772974e-01f, -7.94808939e-02f, 4.03792560e-01f,
  1.67127073e-01f, -2.70204186e-01f, 3.89707416e-01f, -2.00717360e-01f, 4.30288076e-01f, -1.09744556e-02f, -8.22165087e-02f, -1.96973592e-01f, -3.51430736e-02f, -8.01069960e-02f,
  -8.93321931e-02f, 4.60697532e-01f, -2.10193738e-01f, 4.07794565e-02f, 3.79082561e-02f, -1.90868214e-01f, 1.85142189e-01f, 1.60851434e-03f, 3.11996400e-01f, -2.13912800e-01f,
  -4.72468100e-02f, -1.21019520e-01f, -2.44050678e-02f, -7.27513526e-03f, 8.46749172e-02f, -1.15198895e-01f, 1.34300962e-01f, -6.79513514e-02f, 6.33827150e-02f, 2.01283678e-01f,
  4.47383970e-01f, -2.50578433e-01f, 3.52948427e-01f, -1.74067900e-01f, -8.98262858e-02f, 5.28646708e-02f, -9.19114053e-02f, -1.40488476e-01f, -1.15788341e-01f, -7.35886320e-02f,
  1.86739247e-02f, -7.91286379e-02f, 1.63124397e-01f, -1.23041861e-01f, -6.63323998e-02f, -9.56435874e-02f, 4.29419279e-02f, -1.91229984e-01f, -6.01404421e-02f, 8.51153135e-02f,
  1.18531823e-01f, -2.11658478e-02f, -8.72568712e-02f, 1.72944441e-01f, -1.59831613e-01f, 3.63527387e-02f, 2.58740395e-01f, 2.39738762e-01f, 1.57649815e-01f, -1.24486730e-01f,
  1.89316690e-01f, -1.32559285e-01f, -5.76718859e-02f, -8.59527141e-02f, 3.91338915e-01f, -2.05257744e-01f, -1.33524567e-01f, -8.14130008e-02f, 2.74869859e-01f, -1.26046380e-02f,
  -1.27906795e-04f, -2.56940305e-01f, 3.15105915e-02f, -2.97145665e-01f, 6.48263097e-02f, -6.84363842e-02f, 5.81931919e-02f, -1.29689083e-01f, -1.23135723e-01f, -1.35390505e-01f,
  -1.98782861e-01f, -1.75879523e-01f, -1.64470300e-01f, -9.93395820e-02f, 3.75029892e-01f, 8.79031122e-02f, -7.73747191e-02f, -1.53922528e-01f, 1.02478303e-02f, 4.43956628e-02f,
  -9.38034281e-02f, -1.79617461e-02f, -7.31537119e-02f, -2.62403220e-01f, -7.61666223e-02f, -5.87980151e-02f, 4.23173383e-02f, -2.35435769e-01f, -1.58430412e-01f, 3.73600811e-01f,
  2.09454715e-01f, -2.62196332e-01f, 1.07633732e-01f, -1.32563949e-01f, -1.30350962e-01f, -3.33997518e-01f, -2.14488074e-01f, 1.78415284e-01f, -3.17926347e-01f, 3.83866698e-01f,
  -8.71819258e-02f, 7.92646855e-02f, -2.07985088e-01f, -1.78833872e-01f, 1.03954412e-01f, -1.60619080e-01f, 5.71812652e-02f, 7.09125549e-02f, -4.14096415e-02f, -1.33220941e-01f,
  -1.70497373e-01f, -2.53787220e-01f, -1.60667732e-01f, -3.96729400e-03f, -2.29600444e-02f, -4.53128330e-02f, 2.03382783e-02f, 6.86682807e-03f, -2.50756200e-02f, 2.39115283e-01f,
  2.88443744e-01f, -4.26209643e-02f, 3.06847375e-02f, 2.04908308e-02f, -1.49287999e-01f, 2.02840455e-02f, -2.78083682e-02f, -1.21286452e-01f, -1.47635475e-01f, 2.46400669e-01f,
  -1.71213999e-01f, 2.12740287e-01f, -1.19944490e-01f, -1.81599031e-03f, 8.24736357e-02f, -1.86478421e-01f, -1.42339870e-01f, 6.53947294e-01f, -6.09032549e-02f, -5.94470091e-02f,
  -1.87912714e-02f, 1.59003407e-01f, 2.93531090e-01f, 1.64062068e-01f, -1.20555572e-01f, -2.02038791e-02f, -1.68293789e-01f, -1.66440196e-03f, 1.71557054e-01f, -1.09231569e-01f,
  -2.24434212e-03f, -7.80932084e-02f, 5.59689999e-02f, -5.11389272e-03f, -1.35030836e-01f, 1.72854289e-01f, -1.50301546e-01f, 1.49854913e-01f, 1.90432966e-01f, -1.26395030e-02f,
  -6.26245588e-02f, -8.71072710e-02f, -1.72120064e-01f, -1.00105293e-01f, 2.91605622e-01f, 1.54827386e-01f, 1.54965475e-01f, -4.30164225e-02f, -1.10752754e-01f, -1.14776485e-01f,
  -5.83892688e-02f, -1.12209640e-01f, -1.30794257e-01f, -5.06983362e-02f, -2.91706845e-02f, -1.01579474e-02f, -1.85811251e-01f, -7.05829114e-02f, 3.75107229e-01f, -1.58669010e-01f,
  3.97897251e-02f, -2.29399744e-02f, 2.97622263e-01f, 2.75261048e-02f, -1.09533228e-01f, -8.30900222e-02f, -2.13430330e-01f, -4.71596792e-02f, -1.99571848e-01f, 3.00172895e-01f,
  -9.52127278e-02f, 2.51404457e-02f, -1.13537341e-01f, -2.99291741e-02f, 2.29805466e-02f, 1.28867179e-01f, 3.74921054e-01f, -8.76088217e-02f, -7.63822198e-02f, -8.28916673e-03f,
  2.40053609e-01f, 8.48922506e-03f, -1.23365730e-01f, -1.84043050e-01f, -1.14172399e-01f, -9.24376398e-02f, -4.22004044e-01f, -7.80078545e-02f, 3.86390537e-02f, 3.03920563e-02f,
  1.16349205e-01f, -2.58339018e-01f, -3.56358178e-02f, -1.89401045e-01f, 7.77776837e-02f, -1.75517112e-01f, 2.55055707e-02f, -3.37413311e-01f, -4.40731198e-01f, -1.34509563e-01f,
  -8.80163833e-02f, 1.49955541e-01f, -2.63805658e-01f, 3.08402002e-01f, 8.52251705e-03f, -3.08029234e-01f, 1.98270470e-01f, -1.62550554e-01f, 3.25534701e-01f, 1.92554504e-01f,
  -1.35728627e-01f, 1.04306459e-01f, 1.85678914e-01f, 3.51706822e-03f, -1.42839044e-01f, 1.80253647e-02f, -4.55186353e-04f, 3.53250206e-01f, 4.25789766e-02f, -2.19669461e-01f,
  -4.61571142e-02f, -9.34701562e-02f, 4.16121393e-01f, 4.18365359e-01f, -1.20755248e-01f, -1.55046329e-01f, -3.34339514e-02f, -3.81807201e-02f, -1.89688265e-01f, -1.11933172e-01f,
  -4.72773910e-02f, -2.57992242e-02f, 1.72666490e-01f, -1.95541635e-01f, -8.27997625e-02f, -9.78305787e-02f, 2.17180461e-01f, -7.83754662e-02f, 2.60581911e-01f, -1.95445418e-01f,
  2.02901885e-02f, 7.60546625e-02f, -3.72188203e-02f, -2.02357158e-01f, -8.84489566e-02f, -6.50955811e-02f, -1.03947200e-01f, 2.18275100e-01f, 1.55920640e-01f, -9.10949036e-02f,
  -2.25136593e-01f, 4.93113369e-01f, -6.75911978e-02f, 3.16337906e-02f, -8.86860862e-02f, -3.99350598e-02f, 1.72824841e-02f, -3.99517193e-02f, 8.48715380e-03f, 2.21901223e-01f,
  -7.56774247e-02f, 4.20555323e-02f, 2.58369893e-01f, -1.04186103e-01f, 1.01192808e-02f, -2.51018673e-01f, -6.89780638e-02f, -1.75467104e-01f, 7.52492025e-02f, 1.21348679e-01f,
  -2.50042975e-01f, 1.87049404e-01f, -1.40799701e-01f, -8.60998482e-02f, -1.96304787e-02f, -5.33452444e-02f, 6.90614805e-02f, 1.82673514e-01f, -1.04601353e-01f, -8.01013857e-02f,
  6.27859533e-02f, -2.36163437e-02f, 1.20706655e-01f, -3.81700285e-02f, -5.15707582e-02f, 2.64140237e-02f, -1.13362029e-01f, -9.44675207e-02f, -3.69908800e-03f, -2.62027144e-01f,
  -2.01903284e-01f, -1.81575522e-01f, -1.81417182e-01f, 5.87966263e-01f, 5.07506579e-02f, 3.91490571e-02f, 1.05658799e-01f, -5.16984146e-04f, 2.03907430e-01f, -4.62909341e-02f,
  6.85119182e-02f, 1.16195291e-01f, -1.03734307e-01f, 1.25480995e-01f, -1.39709681e-01f, -1.47839606e-01f, 1.69457626e-02f, -1.27958089e-01f, 2.67733037e-01f, -1.19568475e-01f,
  -1.68032631e-01f, -4.50907350e-02f, 1.63369521e-01f, 7.33675137e-02f, 4.13707286e-01f, 1.71864614e-01f, -3.98119837e-02f, 9.88249555e-02f, 1.90691218e-01f, -8.39804485e-02f,
  1.16763093e-01f, 6.91104904e-02f, 2.09617242e-01f, 1.91776901e-01f, 5.02390079e-02f, -4.34839964e-01f, 2.31837153e-01f, 7.04753697e-02f, -4.80001658e-01f, -1.16800547e-01f,
  4.58872885e-01f, 5.03545284e-01f, 2.09800839e-01f, 4.11686115e-03f, 3.64704542e-02f, -4.34456132e-02f, 1.31985992e-01f, 1.00753568e-01f, 1.14670053e-01f, -3.66262607e-02f,
  -9.16062370e-02f, -5.07309241e-03f, 2.97568321e-01f, -1.55259907e-01f, 8.07781667e-02f, 5.16410582e-02f, 8.54999498e-02f, -1.22512169e-02f, -9.76767093e-02f, -8.13856125e-02f,
  2.13493511e-01f, 2.28438690e-01f, -8.79078284e-02f, 5.13888225e-02f, 1.07944258e-01f, -5.19597977e-02f, -3.01579889e-02f, -1.19120693e-02f, -1.48160085e-01f, 1.95544645e-01f,
  3.12437326e-01f, 6.24693573e-01f, -2.02868089e-01f, -3.88960391e-02f, -1.73649058e-01f, -1.70731291e-01f, 1.00601889e-01f, 4.40642536e-02f, -1.74712867e-01f, -1.16786800e-01f,
  7.60385916e-02f, 1.90842599e-01f, -1.17336929e-01f, 7.53419995e-02f, 2.33108088e-01f, 1.37692943e-01f, 6.83212057e-02f, -1.46878632e-02f, 1.60728365e-01f, -2.83348888e-01f,
  1.19641870e-01f, 1.88586801e-01f, -1.06048703e-01f, -5.03417328e-02f, -1.18394025e-01f, 1.50571510e-01f, -2.18783766e-01f, 4.38795649e-02f, -7.39048570e-02f, 1.72858804e-01f,
  -7.62005076e-02f, -1.39348090e-01f, -2.61166021e-02f, -6.18232647e-03f, -1.10311009e-01f, -5.75526580e-02f, -2.00276449e-01f, 5.15600741e-02f, -1.43417239e-01f, 3.50765437e-01f,
  -1.43747449e-01f, -1.56634822e-02f, 1.40386060e-01f, 7.29025826e-02f, 1.55522138e-01f, 3.31092536e-01f, 3.48306865e-01f, -3.72583494e-02f, 1.88945785e-01f, -1.46186233e-01f,
  -4.41177655e-03f, -3.55474725e-02f, -1.76933452e-01f, 2.71370858e-01f, -1.27440710e-02f, 7.87252709e-02f, -8.93722028e-02f, 1.05482742e-01f, -1.57964990e-01f, -3.83908711e-02f,
  -1.26666650e-01f, 2.07431242e-01f, -2.51889199e-01f, 1.00038439e-01f, -6.88904747e-02f, -1.34849980e-01f, -1.08764872e-01f, -1.85305163e-01f, 1.73280582e-01f, 3.74783933e-01f,
  -2.31426299e-01f, 3.41922194e-02f, -1.52048498e-01f, -4.42913920e-02f, -2.21547065e-03f, -9.83183756e-02f, -9.85990763e-02f, 1.67860761e-01f, -3.03733826e-01f, -1.74271002e-01f,
  8.96409079e-02f, 1.76276073e-01f, 1.49189249e-01f, 1.43627644e-01f, 1.20694414e-01f, 1.07058644e-01f, -1.31180689e-01f, 6.18290342e-02f, 1.33181274e-01f, 1.68812469e-01f,
  -7.19071925e-02f, 2.52385139e-01f, -6.17120881e-03f, -2.19109301e-02f, 7.47475922e-02f, 2.50939101e-01f, 1.35089248e-01f, 6.84267282e-02f, 4.25292969e-01f, 2.16714501e-01f,
  1.10832356e-01f, 1.43856153e-01f, -3.26406747e-01f, -1.32822707e-01f, 7.13689700e-02f, -2.25587100e-01f, 1.51366353e-01f, 2.01001331e-01f, -2.10362315e-01f, 2.35827789e-01f,
  -1.00646093e-01f, -1.84643045e-01f, 9.17090252e-02f, -3.05612504e-01f, 3.94552387e-03f, 2.42690109e-02f, 2.82121897e-02f, 2.38865435e-01f, -1.44807488e-01f, -6.13241121e-02f,
  3.99746783e-02f, 5.04767746e-02f, -9.54698771e-02f, -2.11554781e-01f, -1.55945107e-01f, 3.01561117e-01f, 2.80265808e-01f, -1.13007873e-01f, 1.78106129e-01f, -3.41299549e-02f,
  -4.19800952e-02f, 4.18959856e-02f, 2.55400874e-03f, -2.18152907e-02f, 6.53316379e-02f, -2.32762635e-01f, -1.67248547e-01f, 8.84497911e-02f, -1.40167251e-01f, 1.56332657e-01f,
  1.43645173e-02f, -1.77725926e-01f, -1.54546395e-01f, -1.89803362e-01f, 5.38661182e-02f, -9.80024859e-02f, -2.62425333e-01f, -1.72887877e-01f, -4.17002328e-02f, -1.87103838e-01f,
  -3.20698582e-02f, 2.84024715e-01f, -2.01857071e-02f, 1.73892826e-01f, 2.30335370e-01f, -2.46936589e-01f, -6.17226250e-02f, -9.91584733e-02f, 4.38544415e-02f, 1.32893682e-01f,
  9.26861838e-02f, -6.34651110e-02f, 1.19793847e-01f, 2.07330242e-01f, 1.18871793e-01f, -9.42289829e-02f, 7.10830092e-02f, -7.21170157e-02f, -1.39589444e-01f, -6.53543174e-02f,
  -5.09533584e-02f, 1.60547763e-01f, -1.39193296e-01f, -1.54272705e-01f, -7.50800297e-02f, 1.01218782e-01f, -1.60256758e-01f, 4.09695692e-02f, 1.57602832e-01f, -2.78513998e-01f,
  3.13933752e-02f, 5.86999238e-01f, 2.84265466e-02f, -5.41291684e-02f, 1.07558087e-01f, 9.11139399e-02f, -2.09263682e-01f, -1.32970810e-01f, 2.48344824e-01f, -1.16462283e-01f,
  -6.96503669e-02f, -1.18424796e-01f, 4.00683552e-01f, -1.18988283e-01f, -1.78995892e-01f, -1.18010350e-01f, 1.94516093e-01f, 2.49257326e-01f, 3.26829612e-01f, -5.00180162e-02f,
  1.19707808e-02f, 1.33558586e-01f, -2.00382218e-01f, 9.75213274e-02f, -9.59448516e-02f, -6.58179745e-02f, 4.94623244e-01f, 4.91070002e-01f, -7.08316118e-02f, -5.67983836e-02f,
  2.03709602e-01f, -9.09550861e-02f, 5.58336936e-02f, -9.63110328e-02f, 1.56828642e-01f, 6.58254251e-02f, 1.28699750e-01f, 1.13448622e-02f, -1.08445235e-01f, 1.70077518e-01f,
  -2.87490159e-01f, 4.01765555e-01f, 6.80380017e-02f, 2.22397476e-01f, 2.02212438e-01f, 2.62850463e-01f, -9.37670246e-02f, -3.34853470e-01f, -2.11333945e-01f, -3.72003168e-01f,
  -4.98589605e-01f, 9.08814464e-03f, -1.65484790e-02f, -7.89492205e-02f, 3.23994488e-01f, -1.09227337e-02f, -1.26218498e-01f, -9.03535411e-02f, -1.69491898e-02f, 7.17080478e-03f,
  8.31855983e-02f, -2.05580518e-01f, -1.21807851e-01f, 6.63793921e-01f, -1.99035853e-01f, 4.18778419e-01f, -6.12850711e-02f, -2.31321633e-01f, 4.24015336e-02f, -3.16471071e-03f,
  -3.08420379e-02f, 3.01909864e-01f, 2.83963680e-01f, 2.10360974e-01f, -1.39997765e-01f, -2.00516999e-01f, 3.36039551e-02f, -7.33963624e-02f, -1.71976984e-01f, -3.94136459e-03f,
  1.55201275e-02f, -1.85403973e-01f, -2.11238161e-01f, 3.22219819e-01f, -2.14465335e-02f, -8.34704116e-02f, -1.37508549e-02f, -1.03332601e-01f, -1.48590609e-01f, -7.89147541e-02f,
  -1.02794133e-01f, -3.41086946e-02f, -9.43507925e-02f, -4.37072776e-02f, 5.69256172e-02f, 1.18664630e-01f, -4.72325273e-02f, -1.48586392e-01f, -9.49555561e-02f, 3.84362876e-01f,
  -8.48854706e-02f, 1.40200853e-02f, -8.12867880e-02f, -2.12122455e-01f, -2.05970541e-01f, -1.48232013e-01f, 2.49093249e-02f, -1.75664630e-02f, 5.29794395e-03f, 1.35550499e-01f,
  1.92608297e-01f, 2.52758265e-01f, -6.65780343e-03f, -2.80773006e-02f, 3.41929018e-01f, -2.22280502e-01f, -2.42686585e-01f, 1.95760697e-01f, 1.20409774e-02f, 1.99852109e-01f,
  -2.50369906e-02f, 7.38779083e-02f, 1.21210434e-01f, -1.84371024e-01f, 2.80933172e-01f, -1.48862094e-01f, 9.63376686e-02f, -6.94805160e-02f, -2.08510026e-01f, -5.91766573e-02f,
  -1.59573853e-01f, -1.60766065e-01f, -1.02238372e-01f, 2.15147868e-01f, -8.66712406e-02f, 4.62978473e-03f, -1.49188489e-02f, -1.27128154e-01f, -1.42681196e-01f, 4.70350198e-02f,
  -5.36576621e-02f, 2.31256112e-01f, -1.42178223e-01f, 3.71568680e-01f, -1.46464899e-01f, -1.45705089e-01f, -9.14358646e-02f, 5.89492656e-02f, -3.09471071e-01f, -4.96193720e-03f,
  -2.24072784e-01f, 2.34764054e-01f, 2.11854875e-01f, -6.79158941e-02f, 1.01525867e-02f, -7.20139816e-02f, -1.66906402e-01f, -1.16723657e-01f, -1.99366495e-01f, -1.08906381e-01f,
  -1.42201900e-01f, -2.21857473e-01f, 3.27067710e-02f, -8.68526697e-02f, -5.90986274e-02f, 2.06998270e-02f, -2.85865843e-01f, 7.00422153e-02f, 1.62228853e-01f, -2.47050971e-01f,
  -3.23993742e-01f, -8.14202800e-02f, -7.56550580e-02f, -3.30855936e-01f, 5.04403785e-02f, -1.47574311e-02f, -1.66822314e-01f, -9.82305706e-02f, 3.25282365e-01f, -1.15920410e-01f,
  -3.78227457e-02f, 2.57995546e-01f, 1.57267138e-01f, -2.54165530e-02f, -1.25741437e-01f, -1.91633493e-01f, 1.23502322e-01f, -8.96853656e-02f, 1.96781214e-02f, 8.13046545e-02f,
  8.28641802e-02f, 2.36234710e-01f, -9.81255472e-02f, -1.60236686e-01f, -1.56654805e-01f, 3.67545672e-02f, -7.22226724e-02f, -1.77444369e-01f, -1.76692858e-01f, -6.77926838e-02f,
  -8.66603777e-02f, -8.05108473e-02f, -5.44645973e-02f, -6.40567988e-02f, -2.18305796e-01f, -7.40871876e-02f, 1.63110986e-01f, -6.14344850e-02f, 2.72604674e-01f, 8.25365186e-02f,
  2.51620244e-02f, 3.03998291e-01f, -1.60640553e-01f, 5.45394560e-03f, -5.93801215e-02f, 2.05188449e-02f, -1.24513999e-01f, 6.42885044e-02f, -9.46021900e-02f, 3.52709442e-01f,
  2.52358079e-01f, -1.44592613e-01f, -1.82318419e-01f, -1.19964741e-01f, -2.47498453e-02f, -4.31334265e-02f, 3.10772136e-02f, -4.60950397e-02f, 3.94563563e-02f, -6.11676462e-02f,
  1.07571892e-01f, 2.56973207e-01f, 1.26073867e-01f, 3.21377032e-02f, 6.08052388e-02f, 4.45609763e-02f, -4.61447798e-02f, 1.54327846e-03f, -1.04547739e-01f, 3.58314030e-02f,
  -1.58367664e-01f, 4.94194776e-02f, 2.22036019e-01f, 1.28649428e-01f, -4.50283699e-02f, -1.09820165e-01f, -4.76032272e-02f, -1.47211879e-01f, 9.52482224e-02f, -1.26131043e-01f,
  -1.54030874e-01f, -1.00408942e-01f, 1.03612833e-01f, 4.83990699e-01f, -7.73597881e-02f, -2.16989055e-01f, -1.24933474e-01f, 9.21758190e-02f, -1.26297429e-01f, -9.39279497e-02f,
  -1.56787299e-02f, 3.80770415e-02f, -9.16907266e-02f, -3.87732126e-02f, 3.75918346e-03f, -1.27068326e-01f, -3.89086492e-02f, -1.53213277e-01f, 1.26656547e-01f, 1.33518167e-02f,
  4.35065657e-01f, 2.99004763e-01f, -3.92611995e-02f, -2.08923206e-01f, -6.69074953e-02f, -8.61353576e-02f, -8.05709064e-02f, -1.74439382e-02f, 3.91986258e-02f, 5.52587926e-01f,
  -4.55689132e-02f, -1.99485966e-03f, -1.59500595e-02f, 5.89848757e-02f, -1.00441247e-01f, 3.55722867e-02f, 9.41144899e-02f, 3.49433273e-02f, -1.32747054e-01f, -7.84257725e-02f,
  -1.24607623e-01f, -9.43743438e-02f, -7.46083036e-02f, -1.10552996e-01f, 2.78385840e-02f, 1.12344146e-01f, 4.22335714e-02f, -1.34022936e-01f, 1.02280481e-02f, 6.17488511e-02f,
  1.91981211e-01f, -6.13427274e-02f, -3.62100601e-01f, -2.44683027e-01f, -9.50264186e-02f, -2.04738334e-01f, 1.77499413e-01f, 2.98020486e-02f, 2.69597974e-02f, -1.45087361e-01f,
  -1.96193859e-01f, 6.66685961e-03f, 3.18105370e-01f, -6.55016601e-02f, 1.14119068e-01f, 1.16974339e-02f, -8.24596733e-03f, -2.24202201e-01f, -9.06155333e-02f, -1.82311952e-01f,
  1.54287472e-01f, -2.06404343e-01f, -1.12116389e-01f, -5.45162931e-02f, 2.51325160e-01f, 1.25826344e-01f, 3.28302860e-01f, -4.29602526e-02f, -9.23195332e-02f, -6.75735995e-02f,
  2.10145507e-02f, 3.82364122e-03f, 8.66321381e-03f, -9.93669182e-02f, -1.98517844e-01f, -1.11963585e-01f, -2.21730754e-01f, 1.07756928e-02f, -1.33475825e-01f, -2.12786630e-01f,
  1.08109802e-01f, 3.00839335e-01f, -2.24402472e-01f, -1.67325675e-01f, -2.02271178e-01f, -1.90083981e-01f, 1.34492010e-01f, -7.65077993e-02f, -3.10465507e-02f, -8.48593265e-02f,
  -1.56926304e-01f, -1.27790913e-01f, -4.12488095e-02f, 1.26335815e-01f, -9.47555304e-02f, -5.85353263e-02f, 2.30616882e-01f, 2.11621344e-01f, -1.48904428e-01f, -4.50630859e-02f,
  2.30405197e-01f, -1.21054891e-02f, -7.57146478e-02f, 4.54901785e-01f, -1.38059601e-01f, 4.28234100e-01f, -8.45007971e-02f, 3.41805369e-02f, 7.95451924e-02f, -4.35545184e-02f,
  -6.14476092e-02f, 8.84586305e-04f, -4.18757973e-03f, 1.74448207e-01f, -6.64232522e-02f, -1.38467282e-01f, 3.55081826e-01f, -9.64224413e-02f, -9.66757908e-02f, 2.79932827e-01f,
  4.05935459e-02f, -5.44793196e-02f, -5.31178601e-02f, -1.33533224e-01f, 2.14584112e-01f, -1.26952335e-01f, 8.94174725e-02f, 6.79724813e-02f, 6.40883073e-02f, 1.43025967e-03f,
  -1.68323979e-01f, 1.79842055e-01f, -5.41556180e-02f, -9.41019356e-02f, 1.95759043e-01f, -7.02023432e-02f, 2.19675198e-01f, -1.38207272e-01f, -6.52862415e-02f, 3.53577644e-01f,
  -1.12388536e-01f, -1.37821119e-02f, -1.02566674e-01f, -4.16790210e-02f, 3.27934057e-01f, 1.71286583e-01f, 1.52514532e-01f, -1.16597764e-01f, -8.34384784e-02f, -2.63147205e-02f,
  4.75456789e-02f, -4.26197015e-02f, 1.26644254e-01f, 2.61784762e-01f, -8.86246711e-02f, -1.28154695e-01f, 1.33736938e-01f, 1.04679160e-01f, 4.80385311e-02f, 1.49809629e-01f,
  -1.22317001e-01f, -6.89389475e-04f, 3.39164555e-01f, -8.30336437e-02f, -1.90819323e-01f, -1.26553535e-01f, 4.73726273e-01f, 2.38633424e-01f, -2.49762848e-01f, 9.14339498e-02f,
  2.38246337e-01f, -1.76702067e-01f, -3.94582421e-01f, 3.47843647e-01f, 3.35483044e-01f, 5.00731170e-01f, -2.40182057e-01f, -5.48976548e-02f, 9.85421464e-02f, -1.65637806e-01f,
  -1.21501319e-01f, -1.26765639e-01f, -2.37804711e-01f, -1.13754801e-01f, 7.11665452e-02f, -2.05866739e-01f, 1.49653301e-01f, 4.02315557e-01f, 4.90178108e-01f, 8.66171438e-03f,
  -2.43318528e-01f, -1.63094342e-01f, 1.40218049e-01f, -2.41586968e-01f, 2.61535794e-02f, 5.10392368e-01f, -2.20701590e-01f, 3.39565337e-01f, -2.97270417e-01f, -2.60396209e-02f,
  -1.93778470e-01f, 2.78860390e-01f, 2.03904986e-01f, 1.33247778e-01f, -1.78493597e-02f, -3.11149321e-02f, -8.87200087e-02f, 1.84556052e-01f, -1.02849908e-01f, -9.76758450e-02f,
  -1.11754321e-01f, -1.02809630e-01f, 2.64599681e-01f, 6.72108755e-02f, -1.11980915e-01f, 6.31840676e-02f, 2.39828959e-01f, -1.49135172e-01f, 3.90580863e-01f, -1.66440964e-01f,
  -8.45157951e-02f, -2.95446999e-02f, 2.29530469e-01f, -1.14170410e-01f, -2.65347302e-01f, 7.53552467e-02f, -1.40824124e-01f, 1.65997624e-01f, 1.72848590e-02f, -1.09373078e-01f,
  -1.73218593e-01f, -1.26888976e-01f, -8.38721544e-02f, -1.56628489e-01f, 8.58189538e-03f, -4.02525030e-02f, -1.34187356e-01f, 3.06121111e-02f, 1.67754948e-01f, -2.74002794e-02f,
  1.55194238e-01f, 8.62650480e-03f, -1.37200624e-01f, -7.87815899e-02f, -6.65163621e-02f, 2.05073670e-01f, -8.46974552e-03f, -1.03680559e-01f, 1.02321468e-01f, -8.33403692e-02f,
  -1.60758048e-01f, -5.16380668e-02f, -1.48125604e-01f, -1.39670983e-01f, -5.83158396e-02f, 9.66406390e-02f, -1.73660040e-01f, -1.36546746e-01f, -2.87466288e-01f, 1.71304613e-01f,
  2.12295175e-01f, -2.16908649e-01f, -1.21809043e-01f, 1.97736591e-01f, -1.60539355e-02f, 1.62648812e-01f, 2.45189555e-02f, -2.07993448e-01f, -9.09478888e-02f, -6.19648509e-02f,
  1.17996885e-02f, -4.64519002e-02f, -4.24628370e-02f, -3.42559442e-02f, 3.12700607e-02f, -5.85152097e-02f, -1.14100099e-01f, 1.98715240e-01f, -1.32270947e-01f, -1.34579092e-02f,
  1.10528871e-01f, 1.21673085e-01f, 6.77417293e-02f, 1.49431884e-01f, 1.40403464e-01f, 1.66224778e-01f, -9.39984322e-02f, 2.97738463e-01f, 6.37491867e-02f, 1.98198438e-01f,
  9.10818875e-02f, -1.62557773e-02f, -1.40839210e-02f, 3.42712998e-01f, -5.17827094e-01f, -2.10594073e-01f, 1.22192986e-01f, -2.56191790e-01f, -4.69899267e-01f, 1.60562977e-01f,
  1.43733248e-01f, 8.09430778e-02f, 1.87901214e-01f, -4.52094465e-01f, -2.24742860e-01f, 2.38358304e-02f, -1.72636211e-02f, -1.23681881e-01f, 1.87704831e-01f, 1.08519690e-02f,
  -1.41256854e-01f, 2.41977379e-01f, -1.40481785e-01f, 2.47086361e-01f, 8.48842338e-02f, -1.81247786e-01f, -1.75377965e-01f, -1.40323550e-01f, -9.45755020e-02f, -1.25726134e-01f,
  -8.38227570e-02f, -1.79557428e-01f, 2.53413320e-02f, -1.37395114e-01f, 8.70786011e-02f, -2.25791514e-01f, -1.67823389e-01f, 4.64983046e-01f, -1.87049001e-01f, -1.64041162e-01f,
  -1.22245759e-01f, -1.48364184e-02f, 1.55845717e-01f, 2.76545389e-03f, 3.36621374e-01f, 5.32829994e-03f, 1.44222945e-01f, -1.30512387e-01f, 3.42280328e-01f, -6.73308522e-02f,
  -2.99152024e-02f, -2.22592980e-01f, 1.21911608e-01f, -1.51072279e-01f, -1.58064485e-01f, 1.47216067e-01f, -1.80525631e-01f, 2.32755914e-01f, -7.85961971e-02f, -1.71719819e-01f,
  4.92100604e-02f, 1.03409700e-01f, -8.40869453e-03f, -1.95883840e-01f, -3.52825015e-03f, -1.59770742e-01f, -3.11123971e-02f, -3.11648995e-02f, -3.95412855e-02f, 4.35329303e-02f,
  7.01120403e-03f, 1.52405664e-01f, -1.78920776e-01f, -1.01186454e-01f, -4.70259786e-02f, -2.53778566e-02f, -6.70819134e-02f, -1.42121851e-01f, 2.41317362e-01f, -8.67364332e-02f,
  -7.75052086e-02f, 6.60340115e-02f, -1.53985962e-01f, -1.36609435e-01f, -6.47999421e-02f, 3.83650325e-02f, 5.98522509e-03f, 1.46004722e-01f, -1.07828632e-01f, 4.62277502e-01f,
  -6.90354705e-02f, -1.55541271e-01f, -1.70343503e-01f, -1.68223605e-01f, -9.48731825e-02f, -9.41983461e-02f, 1.61849588e-01f, -4.86396328e-02f, -4.13797460e-02f, 2.91476727e-01f,
  2.30185047e-01f, -1.13121092e-01f, -2.10358992e-01f, -4.86572608e-02f, 2.87548658e-02f, -3.01693887e-01f, -2.17302572e-02f, -9.78937596e-02f, 1.21652231e-01f, 3.49526316e-01f,
  2.57729113e-01f, 3.81476618e-02f, -2.05873065e-02f, -1.40604064e-01f, 1.84397981e-01f, -2.80682482e-02f, -1.97202653e-01f, -1.20620124e-01f, -1.26549870e-01f, -5.41768852e-04f,
  1.41505867e-01f, 1.05405807e-01f, -7.56733178e-04f, -8.86508822e-02f, 1.21278681e-01f, 8.91264752e-02f, -1.25538170e-01f, 4.87677811e-04f, 1.01096220e-01f, 2.02814394e-04f,
  1.83707744e-01f, -9.07590687e-02f, -2.31079072e-01f, -1.16635459e-02f, 7.99843147e-02f, 3.52278173e-01f, 1.82502851e-01f, -7.84833729e-02f, 3.21527541e-01f, -1.57056957e-01f,
  2.15793461e-01f, -3.09511542e-01f, 2.23578632e-01f, -1.48041442e-01f, -2.61440556e-02f, 4.03511673e-02f, -1.52131572e-01f, 2.46927112e-01f, -1.72988117e-01f, 3.81609499e-01f,
  2.03543678e-01f, 4.59193736e-01f, -1.15382887e-01f, -7.80602545e-02f, -1.12875402e-01f, 3.61566506e-02f, -2.42190659e-01f, -9.89355072e-02f, -4.15976271e-02f, 9.05541703e-03f,
  -1.03375711e-01f, -1.64725497e-01f, -1.91613704e-01f, 1.91393599e-01f, -1.70453548e-01f, -1.12102807e-01f, 2.52852201e-01f, 7.85396323e-02f, -1.54427364e-01f, 3.99642766e-01f,
  -3.50248106e-02f, -1.87992603e-01f, 2.32193642e-03f, -2.18220111e-02f, 2.99285293e-01f, 3.46666962e-01f, -1.13776796e-01f, 3.40701550e-01f, -7.24134147e-02f, 2.55770814e-02f,
  -5.72064519e-02f, -2.23398566e-01f, -1.79034054e-01f, -7.88614675e-02f, -5.12290932e-02f, 1.40792653e-01f, 4.17354144e-02f, 3.94390821e-02f, 2.77322710e-01f, -1.03055105e-01f,
  -1.34224489e-01f, 1.01991706e-02f, -1.31237775e-01f, 2.59772778e-01f, 7.88955539e-02f, -1.92898452e-01f, -1.81945696e-01f, -9.16034207e-02f, 2.48720730e-03f, -3.61049697e-02f,
  5.52239344e-02f, 1.72385797e-01f, 1.72397539e-01f, 1.64344266e-01f, 2.42276236e-01f, -1.71169549e-01f, -2.32335720e-02f, -1.17838956e-01f, 2.18587890e-02f, -1.75151885e-01f,
  -7.87314028e-02f, -5.89564629e-02f, 1.51895359e-01f, -5.64063080e-02f, 3.16600986e-02f, -9.76569578e-03f, -9.38721448e-02f, 4.88926992e-02f, -1.12117298e-01f, -1.77834556e-02f,
  -9.49728861e-03f, -8.97768363e-02f, 3.32858264e-01f, 3.96161050e-01f, -8.08041077e-03f, 3.12822074e-01f, 1.17859598e-02f, -2.00427398e-01f, -9.63227302e-02f, -1.24018177e-01f,
  -1.26003742e-01f, 5.61490841e-02f, 1.14659883e-01f, 2.51141489e-01f, -1.45674080e-01f, -1.08891509e-01f, 8.32700133e-02f, -1.10545538e-01f, -2.01712549e-01f, 1.93365008e-01f,
  2.90919363e-01f, -1.79411888e-01f, 1.16096465e-02f, 2.95549235e-03f, -1.77408442e-01f, -3.47827859e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.35141411e-02f, 7.31963292e-02f, -1.07563816e-01f, -2.90567931e-02f, 1.36565864e-01f, 1.15789972e-01f, 9.54580531e-02f, -1.03975562e-02f, -8.42563659e-02f, 1.38936415e-01f,
  5.37021235e-02f, -1.84407569e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    