/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.03692415e-02f, 7.11082742e-02f, 8.76990631e-02f, 1.22327834e-01f, 1.07658044e-01f, 1.72289893e-01f, 2.09934771e-01f, 1.05025977e-01f, 7.81995282e-02f, 8.65729619e-03f,
  -5.27679324e-02f, -1.39608085e-01f, 5.34829907e-02f, 9.84289572e-02f, 6.54435754e-02f, 1.70775875e-01f, 1.71158135e-01f, 2.06945330e-01f, 1.09697200e-01f, 1.57284737e-01f,
  1.66935578e-01f, 1.01680107e-01f, 1.38440698e-01f, 1.05645694e-01f, 2.01952696e-01f, 9.83333215e-02f, 1.72767609e-01f, 1.44335419e-01f, 1.30398840e-01f, 2.48553663e-01f,
  -6.78514391e-02f, -8.79872683e-03f, 1.19906679e-01f, 1.50776088e-01f, 8.42731819e-02f, 5.41740023e-02f, 6.02198727e-02f, 1.44857869e-01f, -1.50790252e-02f, 5.10838293e-02f,
  6.10224046e-02f, 1.05607145e-01f, 1.25525549e-01f, 1.09910160e-01f, 1.12383887e-01f, 1.22462839e-01f, 5.41167632e-02f, 9.97950733e-02f, 1.19505428e-01f, 5.01394272e-03f,
  1.22024026e-02f, 4.44224365e-02f, 7.30613098e-02f, 5.48345223e-02f, 2.03685239e-02f, 1.05536781e-01f, 1.06524900e-01f, 1.76724449e-01f, 1.21251136e-01f, 1.68638527e-01f,
  6.08463511e-02f, -4.40805685e-03f, -8.12706575e-02f, -1.56335533e-01f, -1.35171443e-01f, -1.29920796e-01f, -1.43015191e-01f, -7.23481411e-03f, -3.13232802e-02f, -1.30187497e-01f,
  -1.94237307e-01f, -7.11166486e-02f, -1.29310176e-01f, -2.13398878e-02f, -5.31921647e-02f, -2.32902691e-02f, -3.14490125e-02f, -6.50019273e-02f, -1.70203388e-01f, -7.37215877e-02f,
  -1.14402071e-01f, -2.16911789e-02f, -1.20509177e-01f, -3.33226100e-02f, -5.59906140e-02f, -1.01689398e-01f, -1.18808620e-01f, -1.36426941e-01f, -4.97963578e-02f, -1.62609190e-01f,
  -4.98176478e-02f, -2.73718182e-02f, 8.78798962e-03f, 1.46567464e-01f, 1.54592201e-01f, -9.97269154e-03f, 6.96378425e-02f, 1.20251272e-02f, -2.15061437e-02f, 4.29462381e-02f,
  7.20352381e-02f, 1.23341411e-01f, 2.29685530e-02f, 1.46744503e-02f, 1.36437386e-01f, 1.07001148e-01f, 6.74628019e-02f, 5.54602034e-02f, 1.09978840e-01f, 9.21708643e-02f,
  1.24812216e-01f, 2.07915738e-01f, 1.39927924e-01f, 1.56542495e-01f, 6.58721402e-02f, 3.83014418e-02f, 1.66933775e-01f, 1.78291544e-01f, 7.38459378e-02f, 1.59615055e-01f,
  -3.65133405e-01f, -2.15413228e-01f, -2.07672060e-01f, -1.48000687e-01f, 2.10227475e-01f, 5.21624684e-02f, 1.29452750e-01f, -7.80498683e-02f, -5.79119176e-02f, -3.71203497e-02f,
  2.39854958e-03f, 5.00325263e-02f, -3.06117516e-02f, -7.28711411e-02f, -8.31301361e-02f, -9.01938900e-02f, -7.39850774e-02f, -1.29196420e-01f, 6.49945363e-02f, 1.28595874e-01f,
  8.75883847e-02f, -4.18116860e-02f, -2.45902851e-01f, -1.97257787e-01f, -4.36889492e-02f, 9.94895995e-02f, -1.82546481e-01f, -6.13649786e-02f, -7.85485432e-02f, -1.69542849e-01f,
  -8.29572044e-03f, -1.65344954e-01f, 2.74145156e-02f, -7.42163807e-02f, -6.83424547e-02f, -1.12396955e-01f, 2.88722087e-02f, -1.53456867e-01f, -7.08096176e-02f, -4.16771248e-02f,
  -7.13118166e-02f, 1.97243225e-03f, 2.43129791e-03f, -1.35284051e-01f, -8.79705418e-03f, -8.88221115e-02f, -1.87678307e-01f, -1.83035672e-01f, -9.69294384e-02f, -6.47017583e-02f,
  9.25523043e-03f, -1.18994862e-02f, -1.63776055e-01f, -8.88099745e-02f, -1.24195166e-01f, -4.19297926e-02f, -1.04364187e-01f, -1.49868336e-02f, -4.63358201e-02f, -1.52845934e-01f,
  7.03958124e-02f, 1.86014604e-02f, 6.67387759e-03f, 4.38147634e-02f, 4.12624180e-02f, 7.17872940e-03f, 6.02439791e-02f, 7.61515833e-03f, 4.21781726e-02f, 4.52300757e-02f,
  1.23049589e-02f, -5.86716831e-03f, -1.12086395e-02f, 1.31357843e-02f, 7.82258064e-02f, 1.46931196e-02f, -3.12697925e-02f, 4.11494859e-02f, -7.41260201e-02f, 9.80054867e-03f,
  -2.93730441e-02f, 5.46369841e-03f, 2.43407059e-02f, -5.66543937e-02f, 6.51882514e-02f, 3.48279290e-02f, 2.26848591e-02f, 6.33745342e-02f, 1.20076612e-02f, 2.41146628e-02f,
  1.11596659e-02f, 4.53600548e-02f, 4.02552709e-02f, -7.44668916e-02f, 4.53999313e-03f, -5.16521856e-02f, -2.57730279e-02f, -2.68958118e-02f, -1.03597185e-02f, -5.50092794e-02f,
  -4.28217351e-02f, -3.60580608e-02f, -2.49916930e-02f, -6.86781257e-02f, 2.81826290e-03f, 6.44205958e-02f, -1.30562233e-02f, -6.07861169e-02f, -7.18567371e-02f, -1.27696604e-01f,
  -8.33941549e-02f, -1.73894018e-02f, 9.66413394e-02f, 6.57880679e-02f, -5.40560372e-02f, 9.79680344e-02f, 2.63816118e-02f, 4.03354764e-02f, 9.36647132e-02f, 1.17604569e-01f,
  -7.40579516e-02f, -5.83515950e-02f, -1.88969672e-01f, -1.87155437e-02f, 5.90134365e-03f, -2.05708370e-01f, -3.43381494e-01f, -1.04128294e-01f, -1.94058921e-02f, 9.40687489e-03f,
  2.41550565e-01f, 3.18046212e-01f, 1.26027644e-01f, 3.82334962e-02f, -9.90535617e-02f, -1.90738633e-01f, -1.69030756e-01f, -1.61080688e-01f, -5.10453098e-02f, -3.56406011e-02f,
  1.01290077e-01f, -2.31824517e-02f, 4.12052358e-03f, -2.81102490e-02f, -5.90629391e-02f, 2.84292214e-02f, -1.52198792e-01f, 7.07456435e-04f, -6.82522729e-02f, -3.87352146e-02f,
  7.88522363e-02f, 7.33211264e-02f, 4.54873778e-02f, 1.78265616e-01f, 6.42325878e-02f, -1.25206038e-02f, -8.27890076e-03f, -2.70015420e-03f, 8.26977715e-02f, -2.59755999e-02f,
  1.17970154e-01f, 7.32355118e-02f, 2.93812808e-02f, 9.53366309e-02f, -2.16367897e-02f, -8.16771835e-02f, 3.78737710e-02f, 1.48430048e-02f, -1.83645673e-02f, 2.51192860e-02f,
  1.76093310e-01f, 1.62669927e-01f, 3.61540765e-02f, 1.82151161e-02f, -9.91755817e-03f, 1.25009626e-01f, 6.93268478e-02f, 4.71103340e-02f, -6.56505078e-02f, -9.32291374e-02f,
  -4.94259968e-02f, -1.04515895e-01f, -8.74608606e-02f, -2.36167293e-02f, -1.31656468e-01f, -8.93219411e-02f, -1.04673266e-01f, 2.50493679e-02f, -1.11855634e-01f, -7.24693164e-02f,
  -2.15078257e-02f, -3.94549854e-02f, -6.08605742e-02f, -1.81949586e-01f, 2.38037314e-02f, -9.51699093e-02f, -1.07921943e-01f, -7.08987787e-02f, -5.96483005e-03f, -6.15876913e-02f,
  1.13785584e-02f, -1.14879265e-01f, -5.13032898e-02f, -1.12755094e-02f, -8.30423683e-02f, -1.20284431e-01f, -7.81379640e-02f, -2.52361540e-02f, -3.29180919e-02f, -1.06678322e-01f,
  1.01606742e-01f, 1.25876784e-01f, 2.62796553e-03f, 9.37794298e-02f, 1.14494748e-01f, 9.41336006e-02f, 1.59775913e-01f, 1.13427289e-01f, 1.30032390e-01f, -1.85906403e-02f,
  1.26472205e-01f, 5.23861609e-02f, 2.93950178e-02f, 3.17740925e-02f, 5.91383427e-02f, 7.64686018e-02f, 6.02802783e-02f, -1.76289883e-02f, 5.97274192e-02f, 1.83640048e-02f,
  6.35097548e-03f, 1.96175929e-02f, 9.63679235e-03f, -6.81705475e-02f, 4.62313071e-02f, 1.09541856e-01f, -1.84392817e-02f, -6.91282377e-02f, 7.59528019e-03f, -2.16011897e-01f,
  3.23303819e-01f, -9.44178551e-02f, -2.47447118e-02f, 8.36201236e-02f, -8.57015997e-02f, -1.29851505e-01f, -1.82134464e-01f, -2.16252692e-02f, 1.60114869e-01f, -1.13514580e-01f,
  8.51025879e-02f, 1.45408168e-01f, 5.80729395e-02f, 1.14165045e-01f, 9.54975840e-03f, -1.96304515e-01f, -1.44730672e-01f, -4.75294851e-02f, 1.38927519e-01f, -1.34041589e-02f,
  -1.46976085e-02f, 1.09074272e-01f, 1.90580264e-01f, 1.29247621e-01f, 8.46904740e-02f, 6.37757629e-02f, -3.28424238e-02f, 1.32242531e-01f, -1.44581478e-02f, -9.70458984e-02f,
  -1.14469938e-01f, 1.83364615e-01f, 1.41047269e-01f, 2.06597745e-01f, 1.26013517e-01f, 1.74334064e-01f, 1.18141823e-01f, 1.62738770e-01f, 1.26959473e-01f, 1.29627198e-01f,
  1.18355185e-01f, 7.59529918e-02f, 9.66240689e-02f, 1.04980849e-01f, 1.24996915e-01f, 1.16933323e-02f, 4.21577469e-02f, 7.43273646e-02f, 1.31997094e-01f, 1.04973435e-01f,
  1.24194443e-01f, 9.52621400e-02f, 1.47963222e-02f, 1.48981571e-01f, 9.21993256e-02f, 7.18820319e-02f, 9.19422805e-02f, 1.82314038e-01f, 1.99410543e-01f, 2.62251147e-03f,
  -7.07691833e-02f, -9.78057683e-02f, -7.68673792e-02f, -1.39123335e-01f, -5.85952252e-02f, -1.43845215e-01f, -1.53967515e-01f, -1.87042519e-01f, -1.01292208e-01f, -1.30211845e-01f,
  -2.07025021e-01f, -8.29665884e-02f, -1.53516561e-01f, -1.17364764e-01f, -1.23119824e-01f, -1.66330785e-01f, -9.01090130e-02f, -7.31992796e-02f, -6.71962127e-02f, -1.12512395e-01f,
  -1.22904345e-01f, -1.49078786e-01f, -8.36948231e-02f, -9.07836333e-02f, -1.65784717e-01f, -4.92711589e-02f, -1.11264981e-01f, -8.81336257e-02f, -1.46297351e-01f, -7.53561556e-02f,
  1.95226707e-02f, 1.24560997e-01f, 1.14170760e-02f, 2.56988648e-02f, 1.35030240e-01f, 1.23131901e-01f, 9.33792815e-02f, 1.08482800e-01f, 9.54561606e-02f, 2.98667513e-02f,
  8.78836960e-02f, 6.19397163e-02f, 1.17782481e-01f, 7.65134990e-02f, 1.00083657e-01f, 1.15368068e-01f, 7.59416074e-02f, 3.89146209e-02f, 1.28074005e-01f, 1.37715220e-01f,
  7.74396807e-02f, 7.17177838e-02f, 5.78796491e-02f, -3.37115582e-03f, 4.09586132e-02f, 3.47893797e-02f, -4.62331288e-02f, 1.23520777e-01f, 2.46524885e-02f, -6.62152171e-02f,
  -2.47400075e-01f, 2.90285975e-01f, -3.50284249e-01f, -9.38357338e-02f, -2.02573035e-02f, 7.38871749e-04f, 3.03269122e-02f, 6.76492080e-02f, 1.16217241e-01f, 2.97589451e-02f,
  7.21096992e-02f, 1.06745651e-02f, 3.36894356e-02f, -1.52070709e-02f, 6.11457080e-02f, -2.76873112e-02f, 4.97172922e-02f, -2.98139244e-01f, -2.29057580e-01f, -1.19458232e-02f,
  5.61012067e-02f, 3.69788222e-02f, -4.69241254e-02f, 3.68916616e-02f, -3.17595676e-02f, -1.00639448e-01f, 5.73096275e-02f, -1.36452600e-01f, 6.46470562e-02f, -2.29619846e-01f,
  -3.41420174e-01f, -1.61599427e-01f, -1.37942538e-01f, 3.19222286e-02f, -5.71075492e-02f, -5.38032316e-02f, 1.52725610e-04f, -5.87126650e-02f, -9.51612089e-03f, -1.17667876e-01f,
  -1.50249422e-01f, -8.20542052e-02f, -4.06201705e-02f, 2.57432051e-02f, -6.48470297e-02f, -7.43540749e-02f, -1.05818417e-02f, -6.60275817e-02f, -9.79553983e-02f, -2.42010914e-02f,
  4.96937260e-02f, -8.04258161e-04f, -1.74069747e-01f, 7.18419328e-02f, -8.31427947e-02f, -4.72408421e-02f, -3.82866077e-02f, -1.58018589e-01f, -1.48228437e-01f, -8.33067819e-02f,
  9.30035785e-02f, 3.00709940e-02f, 7.05920830e-02f, 1.06671326e-01f, 1.35914147e-01f, 1.94511674e-02f, 1.83370747e-02f, 6.31588846e-02f, 5.74346147e-02f, 6.97873384e-02f,
  1.09170489e-01f, 5.24812192e-02f, 9.85179394e-02f, 8.66921544e-02f, 1.73098184e-02f, 9.94444713e-02f, -2.08434220e-02f, 1.63772598e-01f, 5.22299334e-02f, 8.12498704e-02f,
  7.35250264e-02f, -6.90222532e-02f, 3.22462283e-02f, -3.65347490e-02f, 6.68693483e-02f, 2.47793477e-02f, -2.45882459e-02f, 1.28814355e-01f, 1.09804735e-01f, 1.14211060e-01f,
  8.70310739e-02f, 2.82818619e-02f, -1.08913600e-01f, -4.61384319e-02f, -1.10934786e-01f, -8.35371483e-03f, -4.40422781e-02f, -1.06509857e-01f, -7.49881417e-02f, -5.39568998e-02f,
  -3.07431649e-02f, -4.37106378e-02f, 2.03678552e-02f, -6.65447563e-02f, -8.23806375e-02f, 1.41232675e-02f, 2.59769578e-02f, -9.97331664e-02f, -6.63650259e-02f, 3.28279994e-02f,
  9.96331424e-02f, -3.23381238e-02f, -2.33038310e-02f, 1.73154157e-02f, -1.23218952e-05f, -6.59119934e-02f, -9.47263613e-02f, -8.91192928e-02f, -9.30296257e-02f, 2.96535324e-02f,
  -1.47339657e-01f, 4.35110973e-03f, 1.03897884e-01f, -9.29098725e-02f, -2.01003645e-02f, -3.70944738e-02f, -8.95357057e-02f, -1.24177553e-01f, -2.80959345e-02f, -1.44574400e-02f,
  3.09591532e-01f, 2.67843664e-01f, 1.29162759e-01f, 1.44396707e-01f, 1.98480397e-01f, -1.05843201e-01f, -9.87497270e-02f, 4.47766706e-02f, 9.37393010e-02f, 5.88599965e-03f,
  -9.24257264e-02f, -5.22928946e-02f, -5.90811186e-02f, -7.40256086e-02f, -4.54166941e-02f, 5.03886230e-02f, 6.48400113e-02f, 5.38227893e-02f, 1.54191017e-01f, -8.19753557e-02f,
  3.21394920e-01f, 7.59156793e-02f, 5.27136959e-02f, 5.12803309e-02f, 2.35403538e-01f, 7.18250275e-02f, 1.16038367e-01f, 2.63379421e-02f, 1.10642165e-01f, 2.57312935e-02f,
  1.94249928e-01f, 1.66994095e-01f, 8.06237310e-02f, 1.38016582e-01f, 3.59959435e-03f, -9.80365369e-03f, 5.39810583e-02f, 6.89536408e-02f, 1.38768077e-01f, 1.80078357e-01f,
  5.84269688e-03f, 1.56629056e-01f, 4.80467752e-02f, 1.49736896e-01f, 1.48092687e-01f, 1.76508337e-01f, 1.20839968e-01f, 1.23328164e-01f, 1.55496478e-01f, -4.54551056e-02f,
  -1.86243672e-02f, 9.03965533e-03f, -1.86642306e-03f, -1.19139008e-01f, -1.22870684e-01f, 5.63881248e-02f, -5.90011012e-03f, 2.28420142e-02f, -3.83907035e-02f, -1.01034038e-01f,
  -4.56906222e-02f, -5.58499545e-02f, -9.22291800e-02f, -2.67055165e-02f, 1.25984140e-02f, -2.60584541e-02f, -9.03663188e-02f, -9.68349054e-02f, -2.57761404e-02f, -9.91144329e-02f,
  -1.81470159e-02f, 1.69742852e-02f, 2.57040630e-03f, -2.67360471e-02f, -1.11923292e-02f, -1.09817840e-01f, -1.07778139e-01f, -4.26511429e-02f, -1.86386444e-02f, -1.81799214e-02f,
  -1.29062105e-02f, 8.46390203e-02f, 2.09737979e-02f, 7.41381347e-02f, 1.20678201e-01f, 9.82529074e-02f, 1.03764862e-01f, 1.59793034e-01f, 1.82000130e-01f, 4.61649522e-02f,
  7.16211870e-02f, 2.81053483e-02f, 1.30985692e-01f, 8.24321434e-02f, 3.81945521e-02f, 1.43883273e-01f, 8.82406756e-02f, 1.15920566e-01f, 1.43700212e-01f, 9.40197334e-02f,
  2.60239020e-02f, 6.06155628e-03f, 1.36475265e-02f, 3.85698788e-02f, 9.28241685e-02f, 1.28864050e-01f, 8.86244327e-02f, 1.14178471e-01f, 3.68411392e-02f, -2.46460401e-02f,
  3.57989311e-01f, 4.18680608e-02f, 3.35492313e-01f, -6.72081783e-02f, -2.14443535e-01f, 1.69108771e-02f, 1.28974774e-04f, -4.41681733e-03f, -4.19447981e-02f, -1.33448064e-01f,
  -1.69765219e-01f, -1.86321318e-01f, 3.71057317e-02f, 3.57486978e-02f, 1.47302002e-01f, 1.58749118e-01f, 8.98438767e-02f, 2.82673866e-01f, 2.75814176e-01f, -8.64303634e-02f,
  -1.84946343e-01f, -7.94602707e-02f, 1.56496778e-01f, 9.35177952e-02f, -1.47282571e-01f, -6.64994791e-02f, 1.10961683e-01f, 7.96941221e-02f, 2.00376343e-02f, -8.32923725e-02f,
  1.89821780e-01f, 2.18502104e-01f, 1.09136105e-01f, 9.97135788e-03f, -6.43910542e-02f, 1.28514364e-01f, 7.49082789e-02f, 1.09319903e-01f, 4.95553613e-02f, 8.40434358e-02f,
  3.08704060e-02f, 1.48375826e-02f, 1.11291157e-02f, -7.68622383e-02f, 7.61525035e-02f, 4.72316369e-02f, -1.60034802e-02f, 2.22900152e-01f, 1.44359857e-01f, -3.35661322e-02f,
  -1.94839552e-01f, 2.11224873e-02f, 1.66861951e-01f, 6.20181598e-02f, 8.22084099e-02f, 1.56501904e-01f, 9.69170183e-02f, 8.80368352e-02f, 1.06716461e-01f, 6.78843111e-02f,
  -1.13067836e-01f, 5.97161055e-03f, -3.41696814e-02f, 2.39549689e-02f, -8.66004974e-02f, -5.53196110e-02f, -2.04697158e-02f, -7.47401863e-02f, -7.35688880e-02f, 1.39154019e-02f,
  5.04287444e-02f, -5.71932271e-02f, -1.67451650e-02f, 4.92601618e-02f, -5.12671061e-02f, 4.65524942e-02f, -2.22640596e-02f, -5.28610349e-02f, 8.93140659e-02f, -1.21908635e-02f,
  9.09260288e-02f, 4.16136272e-02f, -2.23146807e-02f, 4.90990318e-02f, 1.00533627e-01f, 3.51244919e-02f, -4.36612293e-02f, 1.91051625e-02f, -3.11868805e-02f, 6.14444390e-02f,
  -1.32387787e-01f, 1.46138892e-01f, 8.68002549e-02f, 9.74339917e-02f, 5.13113663e-02f, 7.95931220e-02f, 3.02949771e-02f, 7.23006800e-02f, 7.96599463e-02f, 2.23716088e-02f,
  3.08617968e-02f, 1.56571716e-01f, 8.40876922e-02f, 2.08008848e-03f, -2.69501992e-02f, -1.69147062e-03f, -9.65478197e-02f, 5.33847623e-02f, 1.13571353e-01f, -1.36000179e-02f,
  3.84504050e-02f, 6.62852749e-02f, 3.72871533e-02f, 4.37349156e-02f, 7.64603615e-02f, 8.63995329e-02f, 7.75647238e-02f, 3.71131375e-02f, 1.90836072e-01f, -2.62525566e-02f,
  -2.81262875e-01f, 4.78163064e-02f, -1.21181890e-01f, -1.00013912e-01f, -2.05085784e-01f, -1.46450385e-01f, -1.58651561e-01f, -1.24366917e-01f, -3.04752160e-02f, 5.81538677e-02f,
  1.74757227e-01f, 2.29833648e-01f, 1.96213484e-01f, 8.47703740e-02f, -1.50464743e-01f, -1.71427175e-01f, -2.80760109e-01f, -2.49039307e-01f, -1.78414091e-01f, -7.36417547e-02f,
  -8.38870406e-02f, -1.67712972e-01f, -1.09930359e-01f, -7.82942399e-02f, 1.78917125e-02f, 6.41579032e-02f, -2.88273697e-03f, 4.08688039e-02f, 2.93017756e-02f, -2.03500055e-02f,
  8.64874497e-02f, -7.21509510e-04f, 2.21287012e-02f, 1.18540213e-01f, 4.88366559e-02f, 5.77551275e-02f, 1.75677892e-02f, 1.12772912e-01f, 4.82212938e-03f, -3.78847569e-02f,
  3.92788500e-02f, 6.08708635e-02f, -1.97112653e-02f, -5.54911159e-02f, -1.33302659e-01f, 1.54557414e-02f, 3.30066979e-02f, 6.05735853e-02f, -4.31474857e-02f, 5.32316342e-02f,
  2.15991102e-02f, -2.95458864e-02f, -6.87685907e-02f, -3.16880569e-02f, 6.83330595e-02f, 5.31006791e-03f, 2.68332381e-02f, 2.90484391e-02f, 2.95336489e-02f, 2.64181625e-02f,
  -1.20409809e-01f, -5.74251972e-02f, -5.72460182e-02f, 3.70459072e-02f, -5.90657406e-02f, 7.33676367e-03f, 4.13555987e-02f, 4.23623919e-02f, -1.31333089e-02f, -6.06004708e-02f,
  1.19123794e-02f, 4.61760052e-02f, 6.35870099e-02f, 4.06917818e-02f, -1.69658009e-02f, -5.58345253e-03f, -1.43338256e-02f, 4.14082073e-02f, -9.04399343e-03f, 3.83399762e-02f,
  3.04438453e-03f, -2.37388145e-02f, 2.79136915e-02f, -2.58032093e-03f, -2.84210574e-02f, -6.28021359e-02f, 2.91985627e-02f, 2.21128073e-02f, 4.31404896e-02f, -2.37080269e-02f,
  1.08955711e-01f, 3.84242535e-02f, 9.20129120e-02f, 3.73192132e-02f, -3.40376422e-02f, 7.19545782e-02f, 4.82652672e-02f, -3.68421711e-02f, 3.06179188e-02f, 9.14463624e-02f,
  3.86427492e-02f, 5.16788708e-03f, 2.91952956e-02f, 6.87524080e-02f, -4.61033620e-02f, -4.95025180e-02f, -2.16306876e-02f, -1.62737146e-02f, 4.02274281e-02f, -6.37010485e-03f,
  -9.03909504e-02f, -8.37929249e-02f, -2.47569755e-02f, -9.03466344e-03f, 1.44395065e-02f, -8.83484185e-02f, 4.01845835e-02f, -6.59620017e-02f, -1.41900882e-01f, -7.04290196e-02f,
  2.61992067e-01f, 1.88758403e-01f, 5.80948703e-02f, -8.03272352e-02f, -1.00509629e-01f, -7.76989907e-02f, 7.65555277e-02f, -1.99699059e-01f, -1.48978487e-01f, 4.67278175e-02f,
  -1.07737452e-01f, -1.72028124e-01f, -1.98828742e-01f, -1.44076988e-01f, -1.72215074e-01f, 2.27042418e-02f, -2.94838715e-02f, 1.19878957e-02f, -1.03566870e-01f, -2.35442653e-01f,
  -9.04017091e-02f, -5.84587865e-02f, -2.39319429e-02f, -6.84859976e-02f, 3.47812809e-02f, -1.16777033e-01f, -3.32452543e-02f, 2.16862243e-02f, 8.51887651e-03f, 1.54621139e-01f,
  -8.83523896e-02f, 6.09234497e-02f, -1.26781449e-01f, -6.60921335e-02f, -4.38903831e-02f, -3.55627649e-02f, -3.44011225e-02f, -7.02149570e-02f, -1.05158389e-01f, -7.75889819e-03f,
  -3.90363745e-02f, -1.43007040e-01f, -2.23904252e-02f, 3.01084423e-04f, -2.37203054e-02f, -8.63688812e-02f, 6.04479127e-02f, -5.83266653e-02f, -3.67234945e-02f, -6.78691864e-02f,
  1.59312319e-02f, 4.21414189e-02f, -2.13724542e-02f, -7.19946548e-02f, -1.23666599e-01f, 5.20947352e-02f, 2.32109893e-02f, -3.07221059e-02f, -1.83520019e-02f, 1.23676464e-01f,
  -1.84376184e-02f, -1.32627413e-02f, 6.35454133e-02f, 7.21406564e-02f, -5.03378324e-02f, 1.37413219e-02f, 6.08088486e-02f, 3.75364125e-02f, 5.05141616e-02f, -1.19202724e-02f,
  -4.26815003e-02f, -2.76173204e-02f, 1.83909032e-02f, 2.34394763e-02f, -6.76079914e-02f, 5.80621250e-02f, 5.53525984e-02f, -7.11280927e-02f, 7.24392235e-02f, 8.15958064e-03f,
  5.50092161e-02f, -2.80318763e-02f, -8.78267339e-04f, -2.26438884e-02f, -4.33096141e-02f, -5.29188244e-03f, 2.28578970e-02f, -3.73901092e-02f, 3.74742737e-03f, 7.28594139e-02f,
  -3.08618039e-01f, -6.98716566e-02f, -6.50361180e-03f, -1.03282169e-01f, -8.21278766e-02f, -2.56917365e-02f, 1.46211926e-02f, -7.12064952e-02f, 1.44915720e-02f, -1.12718165e-01f,
  -9.15747657e-02f, -4.42145281e-02f, -1.08715713e-01f, -9.11953822e-02f, -2.56532021e-02f, -9.97670740e-02f, 9.30962786e-02f, -7.33169168e-02f, -1.13190031e-02f, -5.93232103e-02f,
  -8.20606872e-02f, 3.60229574e-02f, -4.75751087e-02f, -3.99655923e-02f, -2.97428221e-02f, 4.80441712e-02f, 4.19427156e-02f, -1.36432052e-01f, -4.99194786e-02f, 9.30762440e-02f,
  1.64112225e-01f, 4.07023802e-02f, -1.32846564e-01f, 2.30271071e-01f, 3.21776792e-02f, -1.24840222e-01f, -1.80272728e-01f, -5.42825498e-02f, 8.05541873e-02f, -1.59354042e-02f,
  1.47222385e-01f, 2.06102669e-01f, 1.10621965e-02f, 4.89679761e-02f, -3.56316939e-02f, -8.09477270e-02f, 1.90989021e-02f, -1.11260436e-01f, -5.23710735e-02f, -3.55256349e-02f,
  -4.58967465e-04f, 4.26106341e-02f, -7.28918705e-03f, -7.31650963e-02f, 8.69569704e-02f, -2.41923351e-02f, -6.28761128e-02f, 9.25478190e-02f, -9.66100693e-02f, 1.30077600e-01f,
  8.49244446e-02f, 1.34932622e-01f, -1.00174181e-01f, 2.32177041e-02f, 9.28241163e-02f, 4.25890721e-02f, -6.00437969e-02f, -4.12525460e-02f, -2.32048873e-02f, -1.88211259e-02f,
  1.08540691e-02f, 2.40270630e-03f, 1.91778541e-02f, 3.07094716e-02f, -3.93372290e-02f, 2.35994370e-03f, -1.39749914e-01f, -1.05920747e-01f, -5.39170355e-02f, -4.61250581e-02f,
  1.18165240e-01f, 5.77945684e-05f, 8.91834423e-02f, -1.54788762e-01f, 6.77260160e-02f, 6.20641410e-02f, -4.68451157e-02f, 4.45004217e-02f, -1.13846704e-01f, -1.06667072e-01f,
  -4.79578450e-02f, 4.59582433e-02f, -2.37048026e-02f, -4.49509434e-02f, 1.24386875e-02f, -9.76317376e-03f, 3.29096876e-02f, -4.09117788e-02f, -4.91338484e-02f, -8.70307758e-02f,
  5.42063825e-02f, -1.43110514e-01f, 3.87544818e-02f, -2.73918975e-02f, -5.69343530e-02f, -5.36370501e-02f, -9.23534390e-03f, -7.11894408e-02f, -3.60951871e-02f, -2.25356817e-02f,
  3.22555117e-02f, -4.83007878e-02f, -1.09834269e-01f, -9.19308364e-02f, -8.59503821e-03f, 9.57866490e-04f, -9.45706069e-02f, 5.54214604e-02f, -6.82696328e-02f, 5.89347221e-02f,
  -3.13391583e-03f, -1.95288315e-01f, -5.63211106e-02f, -6.81405067e-02f, -2.22134925e-02f, -5.22510037e-02f, -6.31957315e-03f, 5.88214323e-02f, 2.37799808e-02f, -4.32714075e-03f,
  2.65548956e-02f, -5.96296079e-02f, 6.23475648e-02f, 2.16227882e-02f, -1.09472200e-02f, -1.29904702e-01f, -5.54927066e-02f, -6.36535883e-02f, -5.95071614e-02f, -3.50782946e-02f,
  -5.52655309e-02f, -1.22823164e-01f, -5.99849112e-02f, -2.10604966e-02f, -3.02506890e-02f, 2.99312435e-02f, -1.39512703e-01f, -1.74335241e-02f, -1.81766167e-01f, -1.72129780e-01f,
  -2.48732388e-01f, 1.59604758e-01f, 4.01841626e-02f, -9.30793583e-02f, -4.97140586e-02f, -5.19317687e-02f, 1.43323496e-01f, -1.41684473e-01f, -2.07894817e-01f, -8.25554412e-03f,
  5.60534112e-02f, -6.24551773e-02f, -1.29232168e-01f, -5.16531430e-02f, -4.07671370e-02f, 5.46421856e-02f, 9.13118720e-02f, -1.83384240e-01f, -1.86403602e-01f, -1.41315117e-01f,
  2.83803046e-02f, -6.83479533e-02f, -1.71392277e-01f, -7.19644800e-02f, 1.85824886e-01f, 1.11586660e-01f, 2.02168599e-01f, 7.61132911e-02f, 2.22740918e-01f, 2.39682406e-01f,
  9.86273661e-02f, -6.69818297e-02f, -2.87425928e-02f, 6.94913492e-02f, 6.46634251e-02f, 8.31665657e-03f, 8.17225277e-02f, -1.38537837e-02f, 4.80968393e-02f, 1.13322744e-02f,
  3.33215073e-02f, -4.70474958e-02f, -7.70501867e-02f, 3.85423489e-02f, 7.27857798e-02f, -2.06933785e-02f, 8.32457691e-02f, -1.12202577e-01f, 4.16903868e-02f, 4.91639320e-03f,
  7.57676885e-02f, 1.59214720e-01f, -2.85247080e-02f, -9.17807408e-03f, -4.42259721e-02f, -5.19558527e-02f, 1.41135722e-01f, 7.13796020e-02f, 9.49606895e-02f, 2.26780176e-01f,
  7.58791296e-03f, -6.09077774e-02f, -1.58267379e-01f, 1.47557096e-03f, -2.26612221e-02f, -2.81817187e-02f, -8.55696127e-02f, 2.01110765e-02f, -3.16341557e-02f, 1.65035762e-02f,
  -5.23188077e-02f, -5.21793291e-02f, 3.09655368e-02f, 7.21341744e-02f, -1.93903372e-02f, -3.76414582e-02f, 3.10654044e-02f, 1.33746583e-02f, 8.84830132e-02f, -3.94855998e-02f,
  -6.04469627e-02f, -1.57855395e-02f, -4.09288369e-02f, -2.78300457e-02f, 1.00781824e-02f, -9.44402441e-02f, 5.02418280e-02f, -7.21982345e-02f, -4.94979545e-02f, 5.13019189e-02f,
  -6.79312572e-02f, -4.04166579e-02f, 8.03013593e-02f, -2.71322615e-02f, -1.28491856e-02f, 1.59113202e-02f, 7.58378133e-02f, 3.72079685e-02f, -4.26667370e-02f, -1.45402895e-02f,
  1.22687533e-01f, 7.97094777e-02f, 1.10008135e-01f, 5.80347665e-02f, 1.36825508e-02f, 6.62347749e-02f, 1.39686301e-01f, -3.58651802e-02f, 8.14142376e-02f, 4.83568199e-02f,
  6.50840029e-02f, -5.39954230e-02f, 3.79366204e-02f, 7.58451298e-02f, 2.82467920e-02f, 5.21652475e-02f, 1.36344388e-01f, 1.45911664e-01f, 9.49557684e-03f, 2.46317416e-01f,
  -3.31266248e-03f, -1.91249669e-01f, -1.42232403e-01f, 9.07013416e-02f, 1.18712354e-02f, -9.75444391e-02f, -2.04814240e-01f, -8.28614011e-02f, -8.82586613e-02f, -1.26718596e-01f,
  -2.58907735e-01f, -1.61994070e-01f, -2.03082412e-01f, -2.31995076e-01f, -1.65601358e-01f, -1.01409607e-01f, -1.16546236e-01f, -1.00492783e-01f, -2.70398892e-02f, 3.65918465e-02f,
  -3.59601900e-02f, 5.52652068e-02f, -5.75273763e-03f, -5.54283150e-03f, 1.44860238e-01f, 6.41902238e-02f, -3.19819637e-02f, 1.09661736e-01f, -2.74041910e-02f, 1.54959843e-01f,
  -8.19472447e-02f, -9.77497697e-02f, -1.00213170e-01f, -1.02580033e-01f, -1.93954378e-01f, -5.73152900e-02f, -1.07741684e-01f, -1.58883154e-01f, -1.16991304e-01f, -9.87078920e-02f,
  -1.78977057e-01f, -1.19831964e-01f, -5.89668043e-02f, -5.29055968e-02f, -1.77583173e-01f, -9.58225802e-02f, -1.67945802e-01f, -5.81587777e-02f, -4.33165394e-02f, -9.62569118e-02f,
  -1.13737006e-02f, 6.94504827e-02f, 3.50013934e-02f, -1.03948519e-01f, -9.99626666e-02f, -1.77098066e-01f, -7.04861581e-02f, 3.74149010e-02f, -1.05544023e-01f, 7.32347444e-02f,
  -1.03883902e-02f, 5.10596000e-02f, 4.22334969e-02f, 1.15511306e-01f, 9.68641043e-02f, -3.20382556e-03f, 9.13876891e-02f, 1.18509404e-01f, 3.54363285e-02f, 1.21361643e-01f,
  4.30849604e-02f, -5.08870929e-04f, 8.04652721e-02f, 2.63775382e-02f, 7.51009285e-02f, 1.18883505e-01f, 7.55735189e-02f, 3.08260247e-02f, 6.87885657e-02f, 1.29826680e-01f,
  9.69339814e-03f, 3.25906873e-02f, 8.50750282e-02f, 3.22935660e-03f, 2.76267994e-02f, 1.37905870e-02f, 1.11620866e-01f, 9.27610844e-02f, 5.18828966e-02f, 9.09747481e-02f,
  -1.31923154e-01f, -3.10078979e-01f, -7.45087638e-02f, -5.90386502e-02f, -1.20006725e-01f, -1.69908151e-01f, -1.59924373e-01f, -1.45996168e-01f, -7.85292387e-02f, -6.07446767e-02f,
  -3.23164389e-02f, -1.79817617e-01f, -2.02248394e-01f, -7.43511543e-02f, -7.72465095e-02f, -7.52102956e-02f, -1.43758953e-01f, -1.90997019e-01f, -7.59943724e-02f, -5.05365692e-02f,
  -1.60735607e-01f, -6.39977977e-02f, -1.27564237e-01f, -8.35969970e-02f, -3.14292312e-02f, -3.45804356e-02f, -7.80057237e-02f, -1.56121418e-01f, -1.17186293e-01f, -1.65658936e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.86557150e-01f, -6.24710560e-01f, 4.75309370e-03f, -5.55950880e-01f, -2.90551275e-01f, -1.72620371e-01f, -4.05573785e-01f, -1.20736763e-01f, -1.97818160e-01f, -5.42379618e-01f,
  -3.17863554e-01f, -2.39639566e-03f, -1.12760160e-02f, 1.80053145e-01f, 1.64942473e-01f, -3.73116314e-01f, -1.15452424e-01f, 2.25402832e-01f, 5.24896026e-01f, 1.55358896e-01f,
  -1.48611084e-01f, -6.31428435e-02f, 2.48047233e-01f, 2.19205365e-01f, -4.32825893e-01f, -6.71742577e-03f, -1.35971442e-01f, -7.07745925e-02f, -2.02387050e-02f, -4.06210423e-01f,
  -2.86097378e-01f, -3.14725131e-01f, 1.51664391e-01f, 7.83131421e-02f, -1.46021008e-01f, 1.01370312e-01f, -9.79152098e-02f, 6.62452262e-03f, 1.05807208e-01f, -3.79290767e-02f,
  -1.46602213e-01f, 5.31108417e-02f, 8.16424098e-03f, -1.32028980e-03f, -1.34863615e-01f, -6.55408725e-02f, 7.34525546e-02f, 1.70619443e-01f, 2.89931502e-02f, -1.26868084e-01f,
  -1.71846207e-02f, -3.47732268e-02f, 1.12407826e-01f, 1.93480074e-01f, 1.11673027e-01f, 2.51888603e-01f, 1.00123577e-01f, 1.78971201e-01f, 1.83913827e-01f, -3.60571802e-01f,
  1.57011636e-02f, -1.91232525e-02f, 5.78116812e-03f, 3.64335291e-02f, 2.94964649e-02f, -3.16610653e-03f, -8.29776227e-02f, -3.45458612e-02f, -2.59093521e-03f, -2.30708309e-02f,
  5.02642952e-02f, -4.13360707e-02f, -2.75058094e-02f, -1.14298813e-01f, 3.68468612e-02f, 2.22788658e-02f, -4.19453532e-02f, -2.73521096e-02f, 2.53722467e-03f, 6.52064532e-02f,
  8.67175236e-02f, 6.89798892e-02f, -1.62254199e-02f, 4.25729081e-02f, 4.41837870e-02f, 6.22853115e-02f, 2.93885488e-02f, 7.03446120e-02f, -6.97217137e-02f, -3.49407606e-02f,
  -1.92617700e-01f, 3.97032559e-01f, -3.25314194e-01f, 3.87329683e-02f, -1.14058085e-01f, 1.06506288e-01f, -7.43270665e-02f, 5.92109561e-02f, -6.98257163e-02f, -1.12384699e-01f,
  3.55589278e-02f, -9.61493850e-02f, -5.14278486e-02f, 1.83693767e-02f, -7.18512610e-02f, 5.34889959e-02f, -3.95018086e-02f, -9.54796746e-02f, 1.59456417e-01f, -8.25641677e-02f,
  6.17069677e-02f, 1.08224340e-02f, -1.06954068e-01f, -4.59289066e-02f, 2.15414562e-03f, 6.54249415e-02f, -2.83350386e-02f, -3.75564583e-02f, 9.28419530e-02f, -4.33183253e-01f,
  2.89502412e-01f, 1.28928706e-01f, 2.07624868e-01f, 1.30578488e-01f, -1.07863061e-01f, -1.95921332e-01f, -1.60044700e-01f, 2.40102727e-02f, -9.47856978e-02f, 9.29067135e-02f,
  -2.30092779e-01f, -1.50706023e-01f, 1.29135270e-02f, 1.18746728e-01f, 1.64913490e-01f, 2.37054631e-01f, 2.19461158e-01f, 3.48872304e-01f, 1.78532511e-01f, 1.50670722e-01f,
  5.43222688e-02f, 1.29634395e-01f, 1.35333508e-01f, 2.07534924e-01f, 1.37835816e-01f, 1.48212851e-03f, 6.79663345e-02f, 7.39579275e-02f, 2.24584457e-03f, 4.44040149e-01f,
  7.54950419e-02f, -2.55402345e-02f, -2.52723247e-01f, -1.20721078e-02f, -9.66506312e-04f, 3.47768739e-02f, -3.05455662e-02f, -6.43905066e-03f, -1.27974097e-02f, 7.59917572e-02f,
  -1.42816314e-02f, 1.18609015e-02f, -2.97123007e-02f, -4.84438613e-02f, 1.17518688e-02f, -3.57813910e-02f, 4.91994806e-02f, 1.79436430e-01f, 6.61241710e-02f, 1.36731416e-01f,
  8.39720815e-02f, -5.67767955e-02f, -1.58257663e-01f, -7.48977438e-02f, 1.32824639e-02f, -1.60263255e-01f, -1.59434751e-01f, 3.82929593e-02f, -1.45599723e-01f, 1.61072195e-01f,
  -9.51880738e-02f, -1.21792667e-01f, -3.45341302e-02f, 8.60491693e-02f, 7.55443349e-02f, 7.01713115e-02f, 7.82518685e-02f, 2.84805223e-02f, 3.78061756e-02f, 1.27203465e-01f,
  -2.74895616e-02f, 7.80116692e-02f, 8.40103924e-02f, 1.60595179e-02f, -1.30810216e-01f, -3.01996004e-02f, 2.51503140e-02f, -8.54724571e-02f, -2.91678086e-02f, -5.54316156e-02f,
  6.43302575e-02f, 9.46431160e-02f, 3.19946334e-02f, 1.06786892e-01f, -2.53820699e-02f, -1.64045338e-02f, -6.27484024e-02f, -6.12507984e-02f, -1.03559770e-01f, -4.77220491e-02f,
  -2.90297598e-01f, -2.87037104e-01f, -3.90980989e-02f, 2.35343762e-02f, -3.09244897e-02f, -7.70399421e-02f, -1.99881256e-01f, -2.58854795e-02f, -4.56302091e-02f, 4.11800183e-02f,
  -4.92543653e-02f, -6.16833195e-02f, -1.78932399e-02f, -4.22139559e-03f, -5.81434444e-02f, -1.17165722e-01f, -8.18836614e-02f, 1.93943605e-02f, 7.07513606e-03f, 5.85052110e-02f,
  7.18215033e-02f, -1.73782438e-01f, -1.65893734e-01f, -1.62909254e-01f, -1.77468777e-01f, -3.46201718e-01f, -2.73058027e-01f, -1.76882058e-01f, -3.97560596e-01f, -1.57143757e-01f,
  5.25252402e-01f, 1.61387950e-01f, 2.84040868e-01f, -7.22450539e-02f, 9.09117162e-02f, 2.96764225e-01f, 3.54152352e-01f, 3.34837586e-02f, -8.45285878e-02f, 4.35504206e-02f,
  1.87889814e-01f, -1.18910030e-01f, -6.65259361e-02f, -1.83927134e-01f, 5.94076216e-02f, 7.54070329e-03f, -1.26518726e-01f, 2.01697182e-03f, 1.21638469e-01f, -7.99867138e-02f,
  -1.60528794e-01f, 8.57535377e-02f, 1.92303479e-01f, 2.24522408e-02f, -4.89040315e-02f, -2.04853833e-01f, 2.30374653e-02f, 1.10030554e-01f, 5.71458340e-02f, -2.24033013e-01f,
  -5.57463393e-02f, 3.26423705e-01f, -1.94562942e-01f, -6.03996255e-02f, 1.21459335e-01f, -6.51772693e-02f, 5.24289720e-02f, 1.99792068e-02f, -1.18140556e-01f, -9.43764672e-02f,
  -5.27092777e-02f, -2.81650089e-02f, 7.19260275e-02f, 4.17038128e-02f, 1.30788192e-01f, 4.83917557e-02f, -8.19728523e-03f, 8.37202817e-02f, -5.25605604e-02f, -8.09283406e-02f,
  -9.29218978e-02f, 1.33021489e-01f, 2.66351432e-01f, 3.53839658e-02f, 9.02950913e-02f, 1.56630985e-02f, 8.89752358e-02f, 1.18028253e-01f, 1.49163023e-01f, -9.75088179e-02f,
  -2.89536789e-02f, 1.12299450e-01f, 4.87111472e-02f, -1.33348741e-02f, 1.47686619e-02f, 5.98456850e-03f, -3.77603248e-02f, 1.06357783e-01f, 3.01686698e-03f, 6.96670413e-02f,
  2.02531368e-01f, 7.91605040e-02f, 6.64341524e-02f, 1.35304227e-01f, -1.26788318e-02f, 7.71389902e-02f, 5.62478043e-02f, 8.55548531e-02f, 4.28855233e-02f, 1.06039755e-01f,
  1.18904538e-01f, 7.64739513e-02f, 1.58974111e-01f, 1.34819940e-01f, 1.01164840e-02f, 1.79274738e-01f, 3.06356233e-02f, 2.08748337e-02f, 9.15381163e-02f, 1.82353362e-01f,
  -3.18192065e-01f, 3.13420504e-01f, -9.04354379e-02f, -9.17217508e-02f, 3.52012776e-02f, -6.72651804e-04f, -3.83634530e-02f, -1.49623185e-01f, -1.13638721e-01f, -1.31598905e-01f,
  1.55801307e-02f, 8.89152214e-02f, 1.40336737e-01f, 1.17200218e-01f, 2.01858692e-02f, -1.27065226e-01f, -6.65879762e-03f, -6.82524359e-03f, -3.83108109e-02f, -1.49989739e-01f,
  -1.50399953e-01f, -5.61001301e-02f, 5.12282290e-02f, -1.05139725e-01f, 3.43715250e-02f, -3.42866369e-02f, -6.58368468e-02f, -1.56276429e-03f, 1.14530973e-01f, -1.62596479e-01f,
  -2.67280936e-01f, -2.57305712e-01f, -3.15559775e-01f, 1.33442611e-01f, 2.06373394e-01f, -1.79600373e-01f, -4.01087493e-01f, -2.34108835e-01f, 1.91109866e-01f, -1.29157051e-01f,
  1.52372703e-01f, 3.56233418e-01f, 1.33931965e-01f, 7.59218857e-02f, -3.06758374e-01f, -1.74644217e-01f, -3.72285917e-02f, -9.42889825e-02f, 5.86692356e-02f, 1.85735613e-01f,
  2.86568403e-01f, 1.69113398e-01f, 1.98048912e-02f, 1.36051521e-01f, 1.72945768e-01f, 1.28527895e-01f, 7.69483224e-02f, 1.25190482e-01f, -4.42796499e-02f, -1.23979852e-01f,
  -1.95807174e-01f, -2.89307356e-01f, 6.76249042e-02f, 2.04936191e-01f, 1.07773043e-01f, -2.20369354e-01f, -9.65756103e-02f, -4.13245521e-02f, -2.07815487e-02f, -2.25063600e-02f,
  1.21057890e-01f, -9.83520527e-04f, 1.29494235e-01f, -8.28728359e-03f, 1.31011590e-01f, -1.92506284e-01f, -5.76866008e-02f, -1.85040265e-01f, -1.77896723e-01f, -2.43471280e-01f,
  6.43960088e-02f, 8.06954354e-02f, -2.42613778e-01f, -1.78497225e-01f, -2.96259910e-01f, 3.00830882e-02f, -2.07910255e-01f, -1.36926785e-01f, -2.51951456e-01f, -2.98749775e-01f,
  -6.70683235e-02f, 2.07210593e-02f, -3.16416211e-02f, -7.77459145e-02f, 7.62932375e-02f, 2.28661932e-02f, -2.74480619e-02f, 1.78049803e-02f, 9.67843235e-02f, -1.50243968e-01f,
  -7.15263013e-04f, 4.83808406e-02f, 1.89368073e-02f, -1.48298230e-03f, 6.78703636e-02f, 5.91138899e-02f, 1.18118552e-02f, -8.85351561e-03f, 4.60991003e-02f, -5.38435765e-02f,
  2.81326799e-03f, -1.58446934e-02f, 8.67994800e-02f, -9.21782851e-03f, -1.40631229e-01f, -1.22250147e-01f, -8.56216531e-03f, -2.22174656e-02f, 1.76854152e-02f, -4.48010191e-02f,
  1.53629735e-01f, 1.31706133e-01f, -5.14152236e-02f, -2.93966029e-02f, 6.33298233e-02f, 1.42479748e-01f, 4.43158001e-02f, 2.12200861e-02f, 3.99854295e-02f, -1.89136341e-01f,
  -6.56024143e-02f, -1.11839779e-01f, 1.07582077e-01f, -3.15432213e-02f, -1.09964199e-02f, -5.32350093e-02f, 3.15741785e-02f, -2.55769510e-02f, 8.13142657e-02f, 1.05091125e-01f,
  -2.52011772e-02f, -9.59301963e-02f, -1.67293921e-01f, -2.79606104e-01f, -3.19841430e-02f, 4.32955585e-02f, -9.88492295e-02f, -8.12464505e-02f, -1.84671193e-01f, -3.27993751e-01f,
  -4.52036649e-01f, -1.57364994e-01f, -4.25750129e-02f, -3.61713678e-01f, 9.50368866e-03f, 1.78987220e-01f, 1.77440897e-01f, 1.07400380e-01f, -1.25918120e-01f, -1.02849364e-01f,
  2.31532510e-02f, -1.15612052e-01f, -1.76643014e-01f, 9.80375186e-02f, 1.09522402e-01f, -6.97348686e-03f, -6.92575872e-02f, 4.01286930e-02f, 2.56563216e-01f, 2.87902147e-01f,
  7.79418573e-02f, -2.63055302e-02f, -1.50154129e-01f, -7.20079467e-02f, -2.63471007e-01f, -8.13177079e-02f, -1.87189370e-01f, -1.32603943e-01f, -2.17565335e-02f, -3.44898045e-01f,
  -9.16176289e-02f, -9.46675539e-02f, 2.04869732e-01f, -7.41166174e-02f, -1.33527309e-01f, -5.05737402e-03f, 6.44385889e-02f, -1.01340942e-01f, -2.98055983e-03f, 1.01746833e-02f,
  -8.70769769e-02f, 8.08538422e-02f, -1.04556471e-01f, 1.34908006e-01f, 4.01382521e-02f, 5.27375303e-02f, 2.48143654e-02f, 6.05448522e-02f, -1.01351321e-01f, 9.35978591e-02f,
  -3.33501361e-02f, -1.92311674e-01f, -1.99492306e-01f, -2.02937666e-02f, -5.14963875e-03f, -3.95206958e-02f, 2.52143238e-02f, -1.00355670e-01f, -6.98718652e-02f, -2.56311625e-01f,
  5.16954176e-02f, 8.71221125e-02f, 1.50693730e-01f, -5.13644740e-02f, -9.59392563e-02f, -8.13441947e-02f, -7.38606825e-02f, 4.26186528e-03f, 9.28723291e-02f, 1.80134606e-02f,
  6.22550771e-02f, 8.08246732e-02f, -1.72568150e-02f, -1.62627071e-01f, -2.56080702e-02f, -5.96159063e-02f, -2.51549501e-02f, -1.01254314e-01f, -1.34810776e-01f, 6.17713260e-04f,
  -4.43057865e-02f, -3.81490625e-02f, -1.57016158e-01f, -3.69214937e-02f, 1.68737781e-03f, -8.86690691e-02f, 5.61871976e-02f, 1.75324336e-01f, 6.34533763e-02f, -3.97781432e-02f,
  -2.37373263e-01f, 7.14883134e-02f, -1.39576063e-01f, 2.72338279e-02f, -6.24964274e-02f, -1.89479161e-02f, -9.95234177e-02f, 6.97437599e-02f, -3.51472683e-02f, -1.50849773e-02f,
  7.77099505e-02f, -4.63845953e-02f, -1.37205869e-01f, 6.72103241e-02f, 1.63586307e-02f, -1.92507729e-03f, -5.27255163e-02f, -1.36561498e-01f, 2.96251290e-02f, -2.96306014e-02f,
  -7.50957951e-02f, -1.58125758e-01f, -2.81154484e-01f, -1.57363340e-01f, -8.84814709e-02f, -1.63685083e-01f, -1.57990083e-01f, -1.30913034e-01f, -6.89474046e-02f, -2.77462900e-01f,
  6.04064226e-01f, -5.27935587e-02f, -4.75362569e-01f, 3.06986392e-01f, -2.78559864e-01f, -3.57163161e-01f, -4.50332910e-01f, -5.64913601e-02f, 2.07837328e-01f, -2.25407988e-01f,
  -1.78944290e-01f, 1.11483790e-01f, 5.71554676e-02f, -2.82774065e-02f, -8.25172011e-03f, -3.64980102e-01f, -2.92847335e-01f, -2.15794593e-01f, -1.90001816e-01f, -1.72419012e-01f,
  2.73729116e-03f, 1.09756172e-01f, 1.43875346e-01f, -7.35293375e-03f, -3.03497706e-02f, 5.16786613e-02f, -2.49517754e-01f, -1.07031263e-01f, -2.46503145e-01f, -1.83965638e-01f,
  -2.52897918e-01f, -1.23214601e-02f, -2.69013017e-01f, 1.27060696e-01f, -1.53592721e-01f, 1.34554476e-01f, -5.43136485e-02f, 6.31456636e-03f, 2.76331045e-02f, 2.09270883e-02f,
  -6.29264042e-02f, -9.24219564e-02f, 1.27365673e-02f, -9.53401178e-02f, 1.53952111e-02f, 4.50376309e-02f, 4.97975945e-03f, -4.85633425e-02f, -4.34071086e-02f, -1.77485153e-01f,
  -1.14255503e-01f, -1.79659858e-01f, -1.51119024e-01f, -5.45260310e-02f, -3.38938199e-02f, -3.85476723e-02f, -1.25177309e-01f, -4.82395180e-02f, -1.14305250e-01f, 2.99071260e-02f,
  -1.19749017e-01f, -1.62151843e-01f, -6.46457523e-02f, -5.31655811e-02f, 2.97924466e-02f, -4.38983552e-02f, 2.82235146e-02f, -9.48396102e-02f, -9.91553143e-02f, -4.57258597e-02f,
  -1.64156891e-02f, -6.78665936e-02f, -1.33345826e-02f, 4.33347933e-02f, 1.29341998e-03f, -3.01125906e-02f, -4.83571514e-02f, -4.61142585e-02f, -7.70970583e-02f, -1.47314416e-02f,
  -9.04106498e-02f, -8.45417976e-02f, 6.59301579e-02f, 7.62090757e-02f, -7.27857873e-02f, -1.12480894e-01f, 7.02252984e-02f, -6.02258220e-02f, 3.98499034e-02f, 2.02027075e-02f,
  2.20405057e-01f, -1.51547566e-01f, 1.58585962e-02f, -2.51992606e-02f, -1.17589384e-01f, -9.79249999e-02f, -1.58288091e-01f, -3.62771004e-02f, 5.70195168e-02f, -5.57612744e-04f,
  -3.32922667e-01f, 6.37340993e-02f, 7.49877794e-03f, 2.09007339e-04f, -6.05838038e-02f, -2.57680640e-02f, 6.99509308e-03f, -1.33741036e-01f, -8.73897821e-02f, 2.17097849e-02f,
  3.09905466e-02f, -8.29111636e-02f, 1.88411802e-01f, 1.59122813e-02f, 1.57754328e-02f, 1.06527746e-01f, -3.38276140e-02f, -7.69206733e-02f, 5.47584631e-02f, 1.76549062e-01f,
  4.19226140e-01f, 1.34526879e-01f, -1.07152186e-01f, 2.46960551e-01f, 4.93787192e-02f, -3.09957713e-01f, -3.10152233e-01f, -1.36802942e-01f, 2.36504957e-01f, 1.17295809e-01f,
  1.81819294e-02f, 4.39162813e-02f, 2.20428277e-02f, -9.65862051e-02f, -4.08204556e-01f, -1.68854713e-01f, -1.34336308e-01f, -2.20213100e-01f, -4.41675156e-01f, -3.91653746e-01f,
  -1.75699219e-01f, -6.42663464e-02f, -1.61556333e-01f, -9.65384990e-02f, 2.84230262e-01f, 6.53681532e-02f, 1.63414106e-01f, -2.00125426e-02f, -1.47201866e-01f, 1.96391314e-01f,
  -2.42401864e-02f, 1.43862486e-01f, -1.73184440e-01f, 2.13878322e-02f, 4.96602207e-02f, 3.09250914e-02f, -4.94556539e-02f, -2.13749241e-02f, 6.72963411e-02f, -1.57474242e-02f,
  2.37884168e-02f, 4.39161994e-02f, -2.92647835e-02f, -5.51659763e-02f, -9.51827243e-02f, -7.40369782e-02f, -7.31149092e-02f, -7.35015571e-02f, 5.02459221e-02f, 3.16986404e-02f,
  -9.04279947e-02f, -1.43292248e-01f, -1.32837780e-02f, -2.33422033e-02f, -8.44225362e-02f, 1.80338845e-02f, -7.35482872e-02f, -3.52316946e-02f, -1.72253810e-02f, 2.66911387e-01f,
  1.08826220e-01f, 1.17439963e-01f, 6.66703209e-02f, 1.28801435e-01f, 6.34473860e-02f, 4.13801894e-02f, 5.15963472e-02f, 5.22418655e-02f, -3.23365852e-02f, 6.26680702e-02f,
  5.48158027e-02f, 5.07838391e-02f, 5.83965844e-03f, -4.33381973e-03f, 6.03065044e-02f, 6.34255111e-02f, 2.02590469e-02f, -1.41584687e-02f, -2.93356217e-02f, 6.11806996e-02f,
  -2.50153411e-02f, -1.51798539e-02f, 4.24953364e-02f, -1.13551676e-01f, 2.36524679e-02f, 1.05843678e-01f, -2.68884189e-02f, -3.34328227e-02f, 1.13468550e-01f, 3.79700996e-02f,
  1.68451935e-01f, -2.41034642e-01f, 2.68143594e-01f, -1.50336519e-01f, -3.46704647e-02f, 9.02985856e-02f, 1.53750151e-01f, -4.56225611e-02f, 1.46494016e-01f, 1.38984602e-02f,
  -1.18709616e-01f, 8.99746120e-02f, 1.47006251e-02f, -4.89598177e-02f, -1.40942842e-01f, 4.25495803e-02f, -3.98457684e-02f, -9.88222882e-02f, -1.67478636e-01f, 2.18148548e-02f,
  1.83165874e-02f, -5.70890680e-02f, -9.41239148e-02f, 1.65369995e-02f, 9.99393538e-02f, 4.06428427e-02f, -6.53995723e-02f, -6.56393617e-02f, -1.79034293e-01f, 4.60293926e-02f,
  -8.18914533e-01f, -8.57647732e-02f, 3.58068764e-01f, -3.59240621e-01f, 2.30481126e-03f, 5.06323054e-02f, 2.58661415e-02f, -2.05830470e-01f, -1.54414549e-01f, 5.98459803e-02f,
  6.74444623e-03f, -1.96185812e-01f, -1.02468498e-01f, -1.36846796e-01f, -1.71289578e-01f, 1.07279405e-01f, 1.89640708e-02f, -2.00522631e-01f, -1.47204414e-01f, 4.37117517e-02f,
  -1.25622600e-01f, -2.79323936e-01f, -4.22991604e-01f, -2.57016808e-01f, -1.30913948e-04f, -1.59285739e-01f, 3.73931602e-02f, -6.80596977e-02f, -7.85498768e-02f, 7.82125518e-02f,
  4.36610162e-01f, -1.95602745e-01f, -1.72094163e-02f, -1.61622733e-01f, 2.09084805e-02f, -5.81436232e-02f, -1.47419378e-01f, 3.90463024e-02f, -5.94781935e-02f, -8.76653716e-02f,
  -1.60199270e-01f, -1.37753591e-01f, 3.87636088e-02f, 4.69262116e-02f, -1.50715103e-02f, 4.41506170e-02f, 2.37848815e-02f, 9.24601313e-03f, 9.29991379e-02f, 6.78239688e-02f,
  6.45149946e-02f, -9.41001698e-02f, 9.62832719e-02f, 5.22587523e-02f, -4.07868698e-02f, -1.25666335e-01f, 8.28740094e-03f, -9.30806845e-02f, 1.87794138e-02f, -7.55927935e-02f,
  6.99659660e-02f, -1.50093250e-02f, -3.46576683e-02f, -2.54102647e-02f, -4.65253815e-02f, 7.00821504e-02f, -1.54371280e-02f, 1.17906835e-02f, -1.72085762e-01f, -8.03503990e-02f,
  -1.40880677e-03f, -3.73594463e-02f, 2.54425053e-02f, -2.98947375e-03f, 2.30392925e-02f, -6.78654388e-02f, -1.96749866e-02f, 1.10635506e-02f, -3.57023366e-02f, -1.51875302e-01f,
  -3.75464074e-02f, 4.44289930e-02f, 5.92101850e-02f, 8.59088749e-02f, -6.40613809e-02f, -1.13258533e-01f, -2.60724835e-02f, -1.23939827e-01f, -9.01464447e-02f, -9.36267823e-02f,
  1.93616226e-01f, -2.70461906e-02f, 7.16679320e-02f, -2.49574222e-02f, 1.17501821e-02f, -4.71669808e-02f, -9.07285064e-02f, 9.89515781e-02f, -7.27009550e-02f, 6.79079220e-02f,
  -3.37457955e-02f, 3.33336145e-02f, 5.41062169e-02f, 8.38464573e-02f, 1.69515144e-02f, 5.44031896e-02f, 2.39440519e-03f, 5.05059324e-02f, 1.20160304e-01f, 1.14183933e-01f,
  6.38253987e-02f, -6.98641641e-03f, 4.20218371e-02f, 1.21015802e-01f, 4.51444760e-02f, 6.38565868e-02f, 1.74612343e-01f, 1.46084413e-01f, 1.62731752e-01f, 1.63917437e-01f,
  -2.34245285e-02f, -1.74597234e-01f, 8.02251473e-02f, -8.26408565e-02f, 4.50252891e-02f, 8.90894309e-02f, 3.46062030e-03f, 2.88167540e-02f, -7.27909952e-02f, 4.67478349e-05f,
  -4.41791963e-05f, 6.19478114e-02f, 6.58007860e-02f, 4.94777970e-02f, 7.25805908e-02f, 9.69974399e-02f, 4.50326316e-02f, 1.17234915e-01f, 1.17803618e-01f, 3.59210558e-02f,
  1.34046242e-01f, 1.40862372e-02f, -1.45319896e-02f, -2.99774501e-02f, -1.12152055e-01f, 7.78292567e-02f, -1.19309135e-01f, -1.38432473e-01f, -5.14544547e-02f, -1.33734673e-01f,
  1.23742178e-01f, -3.02962184e-01f, -3.02628730e-03f, -1.31754205e-01f, -2.33069956e-02f, 1.60828903e-02f, -1.66853275e-02f, -1.33194685e-01f, -8.45571235e-02f, -3.55088450e-02f,
  -8.47185403e-02f, -2.57320460e-02f, -1.08317167e-01f, -6.24236465e-02f, -1.29132509e-01f, -2.80910842e-02f, -1.37182832e-01f, -2.32740808e-02f, -2.70731538e-03f, -1.20247222e-01f,
  -9.33580771e-02f, -1.04670413e-01f, 9.51918513e-02f, 3.27662267e-02f, -8.11422840e-02f, -4.24371473e-02f, -1.19031481e-01f, -1.25065163e-01f, 6.74757957e-02f, 2.44069081e-02f,
  2.30309227e-03f, 9.15141851e-02f, 6.36428967e-02f, -7.02172071e-02f, 1.48999020e-01f, 1.05248980e-01f, 9.98628438e-02f, 1.36275187e-01f, 6.43069521e-02f, 3.01667973e-02f,
  3.28793451e-02f, 8.97848532e-02f, 1.31534249e-01f, 4.69278693e-02f, -8.10925588e-02f, -7.37755820e-02f, -4.38013114e-03f, -6.24792986e-02f, -2.50589326e-02f, 3.55675295e-02f,
  7.36321881e-02f, -4.94266152e-02f, -1.24601401e-01f, 4.12349775e-02f, -1.38185501e-01f, -1.36712855e-02f, -4.56443839e-02f, -9.81024187e-03f, -2.92206872e-02f, -7.84374475e-02f,
  2.63454705e-01f, -3.05273179e-02f, 6.91407248e-02f, 5.42772226e-02f, -8.87066573e-02f, -1.01849757e-01f, 1.51172113e-02f, -1.82775259e-02f, -1.13232825e-02f, -5.01019284e-02f,
  -1.01101518e-01f, 8.61194655e-02f, -6.79665478e-03f, 5.05875377e-03f, 6.59683868e-02f, 6.04503881e-03f, -9.14257318e-02f, 4.58857277e-03f, 5.74055910e-02f, 9.30344313e-02f,
  6.99325502e-02f, 1.55119926e-01f, 3.19342434e-01f, 1.78278252e-01f, 1.04979940e-01f, 1.38648152e-01f, 2.11365163e-01f, 1.34609848e-01f, 1.68834507e-01f, 2.09390029e-01f,
  3.40397805e-01f, -1.85255408e-02f, 6.47808164e-02f, 1.18775241e-01f, -1.60792053e-01f, -3.83253425e-01f, -4.84702229e-01f, -2.90997833e-01f, 9.39750820e-02f, -1.58897080e-02f,
  1.08419016e-01f, 6.95855841e-02f, 9.88776609e-02f, 4.60449010e-02f, -1.21223234e-01f, -1.10543489e-01f, -2.26882577e-01f, -5.92292659e-02f, -9.60836560e-02f, -1.96047813e-01f,
  -8.00172314e-02f, -3.63645032e-02f, 1.44573599e-01f, -6.28514364e-02f, 1.41450897e-01f, -7.42058223e-03f, -2.97800656e-02f, -5.37750088e-02f, -1.11137569e-01f, 1.25993803e-01f,
  1.38757169e-01f, 1.41507551e-01f, 1.08268030e-01f, -2.71479040e-02f, 5.92246978e-03f, 1.07608780e-01f, 1.05472825e-01f, 8.21055993e-02f, 3.25733237e-02f, -1.41610093e-02f,
  -8.76290277e-02f, 3.87761071e-02f, -1.83505751e-02f, -8.94649550e-02f, -5.18360324e-02f, 8.78057927e-02f, 1.59340184e-02f, -2.82159876e-02f, -4.45110537e-02f, -4.50760834e-02f,
  4.41534445e-02f, -1.33593142e-01f, -1.88185319e-01f, -1.20751657e-01f, -8.25405791e-02f, 1.18290223e-02f, -7.47523457e-02f, -4.70779315e-02f, -1.02409661e-01f, 1.31736502e-01f,
  -4.46557589e-02f, 3.18981186e-02f, 1.17270589e-01f, 7.73102939e-02f, -3.94421518e-02f, -5.08288145e-02f, -1.49449527e-01f, -2.13388890e-01f, -1.56039789e-01f, -2.15062946e-02f,
  -3.91049087e-02f, -1.92070426e-03f, -2.33071465e-02f, 1.61119848e-02f, 5.89032695e-02f, -6.05366267e-02f, -3.66917960e-02f, -7.26531958e-03f, 8.57639387e-02f, -6.90861046e-03f,
  -5.68441972e-02f, -1.32009968e-01f, 4.72066551e-02f, 6.91553438e-03f, 6.60646632e-02f, -6.08309023e-02f, -5.22310473e-02f, 6.19009659e-02f, -1.22274213e-01f, -1.72093123e-01f,
  3.04705929e-02f, 8.23049769e-02f, 2.38359183e-01f, 1.57292113e-01f, 7.52967298e-02f, 2.30604038e-01f, 2.21986726e-01f, -2.11631656e-02f, -7.43026286e-02f, -5.37840202e-02f,
  1.63538028e-02f, 1.36355326e-01f, 1.40056804e-01f, 6.92545697e-02f, -1.85810868e-02f, 8.31237882e-02f, 1.87741190e-01f, 3.39006707e-02f, 1.04696378e-02f, -1.36603788e-02f,
  3.12781595e-02f, -1.17745981e-01f, -4.68028113e-02f, -9.36806872e-02f, -5.72185330e-02f, -2.37288307e-02f, 3.85998610e-05f, 1.13465171e-02f, -1.00407852e-02f, -6.53848574e-02f,
  -5.36984682e-01f, 2.92630434e-01f, -3.88518870e-02f, -3.94356072e-01f, 1.38433650e-02f, 2.79520154e-02f, 3.76305938e-01f, 8.90961662e-02f, -3.32712792e-02f, 3.25012624e-01f,
  8.80123302e-02f, -1.41190067e-01f, 4.05573994e-02f, 7.27151558e-02f, 1.76075101e-01f, 4.94524032e-01f, 3.38399589e-01f, -2.07850859e-01f, -4.08976287e-01f, -1.52630255e-01f,
  9.81325731e-02f, -1.94543347e-01f, -4.34487522e-01f, -1.06375545e-01f, 3.56513262e-02f, -1.35163292e-01f, 6.23174086e-02f, -9.59549695e-02f, 1.35876387e-01f, -6.35214299e-02f,
  -5.75726852e-02f, -1.99470595e-01f, 1.68193728e-01f, -2.33149812e-01f, -3.84285711e-02f, -3.28637064e-02f, -2.32343990e-02f, -4.89490926e-02f, 1.52720353e-02f, 6.21217601e-02f,
  -2.18866214e-01f, -5.98826297e-02f, -9.04091597e-02f, 4.02234634e-03f, -1.76774785e-01f, -1.33375779e-01f, -1.82053689e-02f, -1.66036010e-01f, -7.63692185e-02f, -7.38480613e-02f,
  2.26320803e-01f, -1.96298301e-01f, -2.54253536e-01f, 1.13977119e-01f, -3.74242198e-03f, -3.01334616e-02f, -5.19153774e-02f, -1.75143078e-01f, -1.94500729e-01f, -7.34880790e-02f,
  -3.78260091e-02f, -3.47941853e-02f, -6.23378269e-02f, 7.96798170e-02f, 1.59446374e-01f, 3.33398804e-02f, 6.99108094e-02f, -4.12972569e-02f, -6.16575480e-02f, -9.40217972e-02f,
  -2.95969862e-02f, 8.26290324e-02f, -7.03442981e-03f, -2.54619364e-02f, -1.53636718e-02f, -7.50723435e-03f, -5.75500317e-02f, 1.03365391e-01f, 7.09782839e-02f, 9.66596901e-02f,
  -3.74173000e-02f, -3.37181762e-02f, 4.58590239e-02f, 1.68036320e-03f, 1.73434950e-02f, 2.92996969e-02f, -2.03976966e-03f, -1.29778858e-03f, -1.67258922e-02f, 2.74626613e-02f,
  8.82930309e-02f, 1.33493468e-01f, 7.97960609e-02f, 7.85747766e-02f, -1.15353003e-01f, 2.48126127e-02f, 4.67433520e-02f, -2.41011102e-02f, -1.87530071e-02f, -9.95886549e-02f,
  -5.50140552e-02f, -5.66419438e-02f, 1.03014909e-01f, 6.50214702e-02f, -2.03413561e-01f, -3.61334980e-02f, 1.47434548e-01f, -1.61941797e-01f, 4.27943049e-03f, -8.50933790e-02f,
  2.37048045e-01f, -6.59927074e-03f, -1.00736611e-01f, 7.94991478e-02f, 6.56728521e-02f, -9.83329024e-03f, -2.92010792e-02f, 4.21414897e-02f, -1.99331176e-02f, 2.55450904e-01f,
  1.14671938e-01f, 1.08829908e-01f, -1.44706398e-01f, 8.69088173e-02f, -2.73255315e-02f, 7.65497750e-03f, 1.06405072e-01f, 6.82448149e-02f, 1.43973917e-01f, 9.68610942e-02f,
  2.49392048e-01f, 2.78707951e-01f, 1.30124450e-01f, 2.06671968e-01f, 1.77302420e-01f, 3.62550169e-02f, 1.73353928e-03f, -3.36476453e-02f, -4.44704667e-02f, 6.10709488e-02f,
  6.67838454e-02f, 4.23245430e-02f, 3.79688889e-02f, -7.21654445e-02f, -5.39108850e-02f, 1.47669420e-01f, 8.01387131e-02f, -4.12153453e-02f, 5.55630252e-02f, 7.49365687e-02f,
  2.62115896e-01f, -3.42745185e-02f, 1.05986945e-01f, -1.54288756e-02f, -1.07755385e-01f, -7.18492493e-02f, 5.45309633e-02f, -6.76326081e-03f, 1.61904823e-02f, 1.35937274e-01f,
  4.12251875e-02f, -1.49106488e-01f, -7.86773041e-02f, -6.70454726e-02f, -4.87174205e-02f, -9.04841870e-02f, 2.23241728e-02f, 1.44806057e-01f, 2.31620759e-01f, 1.09319296e-02f,
  -4.21204977e-02f, 6.92222789e-02f, 5.08682318e-02f, 8.76641497e-02f, -2.34692823e-02f, 9.34847146e-02f, 5.75003820e-03f, 3.60823348e-02f, -1.82195306e-02f, 3.97840748e-03f,
  1.46307245e-01f, -7.59676239e-03f, -1.25829801e-01f, -1.32715136e-01f, -5.59223741e-02f, -2.62984782e-02f, -6.47242442e-02f, 6.39307639e-03f, -3.70319337e-02f, -2.13439345e-01f,
  4.58197296e-03f, 8.53691325e-02f, 2.98908558e-02f, -4.71355356e-02f, -1.20397910e-01f, -1.00363404e-01f, 3.89430076e-02f, -6.22435100e-02f, -9.20200869e-02f, 3.16017717e-02f,
  -3.61468606e-02f, 6.92833140e-02f, -2.20470831e-01f, -1.16484493e-01f, 5.04985154e-02f, 2.69148615e-03f, -2.65839826e-02f, 5.54944109e-03f, -1.39719501e-01f, -2.22383365e-02f,
  2.02051878e-01f, -9.68504325e-02f, 1.07354410e-02f, 8.76928642e-02f, -5.92686497e-02f, -1.54324230e-02f, -3.56376142e-04f, 6.02779277e-02f, 1.01846404e-01f, 2.65585557e-02f,
  -1.06783966e-02f, -1.26358464e-01f, -7.55719393e-02f, -1.61683753e-01f, -6.07668199e-02f, -4.87138331e-02f, 3.39397639e-02f, 1.78178370e-01f, 1.60485595e-01f, 1.10114753e-01f,
  -1.47867827e-02f, 1.51057020e-01f, 1.83104023e-01f, 1.60877675e-01f, 7.34306052e-02f, 4.40519340e-02f, -5.78274541e-02f, 2.47990154e-02f, -6.50859922e-02f, -9.21926741e-03f,
  2.48428822e-01f, -8.24005008e-02f, -2.84591258e-01f, 1.90372635e-02f, 5.10476604e-02f, 1.15277186e-01f, 2.81553477e-01f, 2.36066729e-01f, 9.89496410e-02f, 1.99746579e-01f,
  -2.23440945e-01f, -2.34969169e-01f, -3.65368515e-01f, -1.76695094e-01f, -2.74991486e-02f, 1.45635232e-01f, 5.82209900e-02f, -1.26001313e-01f, -5.25012687e-02f, 9.68514979e-02f,
  2.62086898e-01f, 2.29665026e-01f, 9.71116871e-02f, -7.28059709e-02f, -8.97435695e-02f, 2.90991329e-02f, 7.79681327e-03f, -8.68786797e-02f, -8.37025717e-02f, -7.19089508e-02f,
  -2.45877132e-01f, -2.85885096e-01f, -3.41354683e-02f, -6.04881234e-02f, -1.12257421e-01f, 8.47202074e-03f, -2.39079297e-02f, -6.38497695e-02f, -1.46855637e-01f, -5.22866622e-02f,
  -2.15455979e-01f, -9.31470841e-02f, -3.10869515e-01f, -1.67621449e-01f, -6.86199516e-02f, 3.11632715e-02f, -7.07149655e-02f, -8.06180537e-02f, -1.09527133e-01f, -2.22883552e-01f,
  -1.14256516e-01f, -1.68448046e-01f, -1.11296073e-01f, 3.89093943e-02f, -1.82352766e-01f, -2.28261217e-01f, -1.60786107e-01f, -1.09918185e-01f, -1.02117844e-01f, 1.63634226e-01f,
  7.48543441e-02f, -2.93396953e-02f, 9.53214150e-03f, 8.35235417e-02f, -2.51309387e-03f, -2.68861409e-02f, -8.74533430e-02f, -2.55218183e-04f, -5.09400591e-02f, -4.77077663e-02f,
  -6.07524812e-02f, 2.34087068e-03f, -3.19805257e-02f, -6.49580453e-03f, 5.13859605e-03f, -1.28548384e-01f, -2.72851139e-02f, 2.28811484e-02f, 6.00927323e-02f, 8.81974921e-02f,
  -8.82679597e-02f, -5.86730801e-02f, 5.61773032e-02f, -3.22005078e-02f, 3.30939367e-02f, -2.26139259e-02f, -6.44971132e-02f, 2.88141100e-03f, -5.07501438e-02f, -2.13797987e-02f,
  2.98501134e-01f, -2.07563013e-01f, 6.98399693e-02f, 1.16074711e-01f, -2.02215649e-02f, 4.15778682e-02f, 4.51880097e-02f, -2.28118449e-02f, -1.52594581e-01f, 2.53801160e-02f,
  -9.01351571e-02f, -1.03486352e-01f, -1.20408960e-01f, 1.82108302e-02f, 4.68176790e-02f, -1.89362951e-02f, 9.08893868e-02f, 5.14503233e-02f, 5.58539480e-02f, 1.62361220e-01f,
  1.16936252e-01f, 1.50806904e-01f, 3.05075079e-01f, 2.12100610e-01f, 1.14536118e-02f, 1.55119255e-01f, 1.70621842e-01f, 4.10451666e-02f, 1.79402679e-01f, 4.24550623e-01f,
  5.69820642e-01f, 2.92302549e-01f, 1.75470579e-02f, 1.92195520e-01f, 2.62688324e-02f, -1.74563259e-01f, -7.32111484e-02f, -1.06916085e-01f, 1.20899361e-02f, 8.09444636e-02f,
  1.35609984e-01f, 1.55411869e-01f, 1.04079254e-01f, 7.45572746e-02f, 5.38338758e-02f, -1.88344587e-02f, 6.35073185e-02f, 6.82507306e-02f, -3.75332721e-02f, 8.38046819e-02f,
  1.96993485e-01f, 1.13600187e-01f, 1.70656040e-01f, 1.13974899e-01f, 1.80079237e-01f, 9.46160778e-02f, 3.81709896e-02f, -1.94725767e-02f, 8.48229304e-02f, 2.60713011e-01f,
  2.28611124e-03f, 1.88399598e-01f, -1.00721993e-01f, 3.24902721e-02f, 1.01965435e-01f, 7.54683167e-02f, 1.04349889e-01f, -3.67104337e-02f, 1.62888430e-02f, -3.14130597e-02f,
  8.04052427e-02f, 1.11474268e-01f, -1.52159892e-02f, -2.84470078e-02f, -1.11226998e-01f, -7.83783346e-02f, -6.15005977e-02f, -4.85980250e-02f, -7.74070024e-02f, -4.95276935e-02f,
  -3.01299859e-02f, -1.39143869e-01f, -1.22989707e-01f, -2.33127415e-01f, -6.36222139e-02f, -9.29341167e-02f, -7.39633739e-02f, -1.30891735e-02f, -1.15893021e-01f, 1.46642691e-02f,
  -5.79070337e-02f, 2.14076824e-02f, -7.70637169e-02f, -4.14686501e-02f, -5.71008734e-02f, -1.26590714e-01f, -1.03337213e-01f, -6.31941203e-03f, -7.56118447e-02f, -9.23703611e-02f,
  -7.51573369e-02f, -9.61906686e-02f, -1.03097685e-01f, -1.86174512e-01f, -4.39925566e-02f, 3.99201065e-02f, -2.61729695e-02f, -1.35947734e-01f, -1.08988419e-01f, -8.08479264e-02f,
  -4.79213186e-02f, -1.21726580e-01f, -4.75696437e-02f, -3.14177200e-02f, -4.77843247e-02f, -1.19323701e-01f, 3.35010439e-02f, -5.70422821e-02f, 5.62330931e-02f, -3.19789127e-02f,
  -2.12986872e-01f, -2.68934786e-01f, 1.86205879e-01f, 1.19717486e-01f, 1.38782248e-01f, 1.29160717e-01f, 2.24552467e-01f, 3.25047374e-02f, 1.04929440e-01f, -5.14294468e-02f,
  -1.90833490e-02f, 1.51561826e-01f, 1.00019194e-01f, 2.59252824e-03f, -8.69514868e-02f, -1.72256887e-01f, 4.67064828e-02f, -4.93325219e-02f, 1.83861982e-02f, 2.65421513e-02f,
  7.09451362e-03f, -2.18870193e-01f, -1.41435683e-01f, -1.15425132e-01f, -1.24999516e-01f, -4.92346808e-02f, -2.10078165e-01f, -1.19327597e-01f, -1.18807375e-01f, -2.36743003e-01f,
  -2.45062277e-01f, 2.18622401e-01f, -1.09288663e-01f, 8.70493203e-02f, 3.72582942e-01f, 2.63410002e-01f, 2.89914131e-01f, -4.63419035e-02f, -5.91467656e-02f, -6.36695942e-04f,
  3.06472238e-02f, 2.51997188e-02f, 1.39302900e-02f, 4.52384874e-02f, 2.95742974e-02f, 1.70334131e-01f, 1.76070943e-01f, -8.31833035e-02f, -1.71337754e-01f, 4.52411361e-02f,
  2.19082624e-01f, -2.04296168e-02f, -1.68914035e-01f, -7.97828957e-02f, 1.44517377e-01f, 6.08505532e-02f, 1.57728605e-02f, 7.78076202e-02f, 2.50797719e-01f, 2.05453470e-01f,
  -2.20200494e-01f, -1.32494837e-01f, -5.59720173e-02f, 3.06858793e-02f, -1.15061691e-02f, -2.19283223e-01f, -1.20425522e-01f, -1.70461401e-01f, 8.83751661e-02f, -1.54467002e-01f,
  1.21869400e-01f, -4.28331830e-02f, 2.47762099e-01f, 1.02143250e-02f, -6.24271519e-02f, -8.46736878e-03f, -8.07377473e-02f, -1.34403005e-01f, -2.04844907e-01f, -3.01486608e-02f,
  3.45401853e-01f, 1.86216056e-01f, 6.58268481e-02f, 1.51156932e-01f, -7.75469914e-02f, -1.42110093e-02f, -1.16205007e-01f, -1.07964113e-01f, -1.51410639e-01f, -2.35936046e-01f,
  1.31521776e-01f, 7.73467794e-02f, 3.74815241e-02f, 4.97225299e-02f, 4.74984273e-02f, -7.19356984e-02f, 1.63350739e-02f, 7.59123042e-02f, 3.94768268e-02f, -3.47046740e-02f,
  -6.97533339e-02f, -1.51282907e-01f, -1.75855309e-01f, -3.01905852e-02f, -4.42038700e-02f, 7.44775534e-02f, -1.56675614e-02f, -1.09195709e-01f, -2.40380280e-02f, -1.15730032e-01f,
  6.58872649e-02f, -1.23144098e-01f, -1.81631491e-01f, -1.70407072e-01f, -5.73991612e-03f, -1.15239255e-01f, -9.64264870e-02f, -4.83967550e-02f, -8.39089230e-02f, 7.78784528e-02f,
  -3.15177113e-01f, -2.20152363e-02f, -1.95888698e-01f, 2.57223174e-02f, 1.10665783e-02f, -3.69243883e-02f, -3.80766043e-03f, -5.99980690e-02f, 5.14937006e-02f, -2.04514842e-02f,
  1.17023207e-01f, -1.18259817e-01f, -1.81985945e-02f, -1.29616365e-01f, -1.07427239e-01f, -3.39349918e-02f, 1.37464046e-01f, 1.45096347e-01f, -7.00811297e-03f, 9.34160966e-03f,
  3.61402519e-02f, -5.48923481e-03f, -2.67190412e-02f, 4.50256765e-02f, 5.07682376e-02f, -2.09933929e-02f, -1.45490348e-01f, -1.84511673e-02f, -1.87029004e-01f, -1.97835580e-01f,
  -1.96194991e-01f, -9.33595151e-02f, -4.33972105e-02f, 4.66776565e-02f, 1.24449022e-01f, -1.35512024e-01f, -3.33140790e-01f, -1.78641573e-01f, 4.11991961e-02f, -3.89557704e-02f,
  1.64377794e-01f, 1.63008526e-01f, 5.48022352e-02f, -8.23843032e-02f, -4.84171361e-01f, -3.61993372e-01f, -2.49546930e-01f, -2.31379822e-01f, -2.42470935e-01f, -5.20271175e-02f,
  5.28062582e-02f, -7.79469460e-02f, -1.77900851e-01f, -1.21455528e-01f, 1.45297080e-01f, -6.24645129e-03f, 8.62646326e-02f, 4.14594030e-03f, -4.30239290e-02f, 1.17896110e-01f,
  2.73920912e-02f, -7.09265321e-02f, 3.56028825e-02f, 1.15210318e-03f, 2.02069044e-01f, 1.70029756e-02f, -6.50636703e-02f, 5.26990183e-02f, 1.11244537e-01f, -1.21824548e-03f,
  1.90939695e-01f, -1.18183335e-02f, 7.96161443e-02f, 8.18689242e-02f, -1.25220453e-03f, -7.85434619e-02f, -8.21237788e-02f, -1.27446547e-01f, -1.16803028e-01f, -6.50206730e-02f,
  3.65690552e-02f, 2.31467299e-02f, -1.18681669e-01f, -8.93903151e-02f, -6.27449006e-02f, -7.89620057e-02f, -6.95763603e-02f, 3.45497094e-02f, -1.42470360e-01f, -1.13108285e-01f,
  5.10957167e-02f, 4.87967990e-02f, 2.73190476e-02f, -1.80165786e-02f, 1.09281084e-02f, 1.05515860e-01f, 4.16348614e-02f, -1.08514354e-01f, 3.91799165e-03f, -1.35663580e-02f,
  -4.11405861e-02f, -2.46161353e-02f, -2.34119482e-02f, -5.47711700e-02f, -1.11051194e-01f, -3.68804708e-02f, -5.89155331e-02f, -1.25868484e-01f, -1.27946228e-01f, 5.04408292e-02f,
  6.15133420e-02f, 8.36836100e-02f, 1.81582317e-01f, -3.76270860e-02f, 3.62424403e-02f, -1.91920698e-02f, 9.91916433e-02f, 4.02926318e-02f, -3.13038044e-02f, -9.83323529e-03f,
  8.71634763e-03f, -4.24823947e-02f, -2.98428796e-02f, -1.17084213e-01f, -2.62524951e-02f, 5.09824939e-02f, 4.36653709e-03f, -4.42404747e-02f, 8.79474953e-02f, 8.87106825e-03f,
  -5.79475006e-03f, -1.25957211e-03f, 2.24091355e-02f, -1.40777528e-02f, -2.77135689e-02f, -3.14655788e-02f, -1.64142191e-01f, -3.39900777e-02f, -8.43997598e-02f, 1.05843514e-01f,
  -9.76014584e-02f, -3.27284276e-01f, -2.64506459e-01f, -2.18725979e-01f, -2.48954631e-02f, -1.37160748e-01f, -1.66809738e-01f, -1.03870258e-01f, -2.66535193e-01f, -3.30675840e-01f,
  -1.55364901e-01f, 3.65210325e-01f, -1.09783910e-01f, 7.70943835e-02f, 1.50519609e-01f, 3.31731021e-01f, 4.71430689e-01f, 2.89113611e-01f, 4.80887331e-02f, 1.40995637e-01f,
  1.37411520e-01f, -8.29488561e-02f, 6.82442449e-03f, 6.78833425e-02f, 1.20538399e-01f, 1.82123929e-01f, 7.61961862e-02f, -2.10531458e-01f, -1.55061334e-01f, 9.44970176e-02f,
  8.94611180e-02f, 7.02890456e-02f, -1.62638187e-01f, -9.01868492e-02f, -4.39737774e-02f, -9.56127644e-02f, 1.32349044e-01f, 6.06209971e-02f, 6.89685121e-02f, -9.79506671e-02f,
  -3.86566132e-01f, 1.53811082e-01f, -1.35281548e-01f, -1.40941679e-01f, -1.76842033e-03f, -9.90613177e-02f, -1.73742755e-03f, -7.73674995e-02f, 2.90232543e-02f, -6.60470799e-02f,
  -3.39187086e-02f, -3.62400920e-03f, 7.39855915e-02f, 1.08960792e-01f, 2.72475672e-03f, 1.32145244e-03f, -2.22957300e-04f, -7.86128193e-02f, -1.41522855e-01f, -1.42646790e-01f,
  1.16073713e-03f, -1.46081252e-02f, 2.78751105e-02f, 2.04846896e-02f, 5.38740270e-02f, -1.13618605e-01f, -2.38178279e-02f, -8.31577629e-02f, -1.14887312e-01f, -2.23836541e-01f,
  -9.60655361e-02f, -4.67581935e-02f, 5.75807989e-02f, 6.51309192e-02f, 4.20168005e-02f, 6.02742247e-02f, 9.10385028e-02f, 2.54350621e-02f, -2.89044250e-03f, 7.25567043e-02f,
  -4.81965393e-02f, -1.26470938e-01f, -1.78839713e-01f, -3.53654511e-02f, -7.91149959e-02f, 5.23141436e-02f, -8.18259344e-02f, -9.35171098e-02f, -2.31505299e-04f, -3.42567414e-02f,
  -1.08312862e-02f, 1.42455529e-02f, -2.83909012e-02f, -6.96593290e-03f, -1.28333673e-01f, -1.61347389e-01f, -1.19332135e-01f, -8.18140060e-02f, -3.79205234e-02f, 6.21070201e-03f,
  -4.14834358e-03f, 6.32792339e-02f, -3.28599840e-01f, -4.50356677e-02f, 3.13974954e-02f, 2.77758781e-02f, -4.64883670e-02f, -8.99684727e-02f, 7.71633685e-02f, -4.51883338e-02f,
  8.59530717e-02f, 2.91484538e-02f, 3.21308747e-02f, 5.03630303e-02f, -9.07348916e-02f, -5.55663221e-02f, 8.14824253e-02f, 2.82513839e-03f, -4.82842587e-02f, -8.63049999e-02f,
  1.52533995e-02f, -1.48169354e-01f, -1.51952252e-01f, -5.12188897e-02f, -2.05126047e-01f, -1.55275092e-01f, -1.12600580e-01f, -1.48362041e-01f, -6.39437065e-02f, -5.79909422e-02f,
  2.41785213e-01f, -2.59381950e-01f, -5.44630438e-02f, -1.16588786e-01f, -3.89185473e-02f, -3.48137021e-02f, -1.00551821e-01f, 3.08233313e-02f, -7.54132420e-02f, -9.78128091e-02f,
  4.83871885e-02f, 1.82520568e-01f, 1.09005652e-01f, 7.77817219e-02f, -8.06953683e-02f, -1.78203970e-01f, -1.73486978e-01f, -2.08294764e-02f, 8.15784484e-02f, 3.81296910e-02f,
  -2.07617640e-01f, -2.69201875e-01f, -6.57989532e-02f, -8.45378339e-02f, -1.23653568e-01f, -1.60707414e-01f, -1.65451363e-01f, -1.48584262e-01f, -2.05896094e-01f, -3.47214043e-01f,
  9.37012732e-02f, 4.02674615e-01f, 1.45105228e-01f, 2.14964390e-01f, 9.31076333e-02f, 5.70853651e-02f, 5.27072065e-02f, 3.59799061e-03f, -7.49255344e-02f, -4.05630320e-02f,
  6.55386150e-02f, 1.10191226e-01f, 4.23915051e-02f, 4.45198938e-02f, 1.06004439e-01f, 1.58982992e-01f, 1.83579102e-01f, 9.40291658e-02f, 5.12713892e-03f, 1.39171835e-02f,
  9.72337946e-02f, 7.61586726e-02f, 7.15787858e-02f, 1.16597101e-01f, 4.84017469e-02f, 1.45301044e-01f, 8.12504292e-02f, 1.97605118e-01f, 1.98511481e-01f, 8.44264403e-02f,
  5.66157289e-02f, -1.01993658e-01f, 9.65547040e-02f, 7.60608539e-02f, 4.50060517e-02f, 6.67808875e-02f, 5.93343154e-02f, 6.92049488e-02f, 5.09583689e-02f, -2.71468293e-02f,
  -6.20344169e-02f, -4.15896773e-02f, 1.33387059e-01f, -9.72629264e-02f, 1.36732563e-01f, -2.22347360e-02f, -2.55433042e-02f, 3.16187814e-02f, 1.72854796e-01f, 8.70274529e-02f,
  2.25586221e-02f, -7.16274008e-02f, -4.87985946e-02f, 1.63015611e-02f, 6.84142485e-02f, 4.12494596e-03f, 6.37473688e-02f, -2.33549550e-02f, -1.10806555e-01f, -1.72926202e-01f,
  -2.08147064e-01f, 2.89542228e-01f, -8.39303806e-02f, 4.94350940e-02f, 4.45598252e-02f, 7.65117705e-02f, 3.74767408e-02f, -1.27553761e-01f, -8.40827748e-02f, 3.15536484e-02f,
  -7.62363430e-03f, 5.95354661e-02f, 2.19026916e-02f, -1.10406175e-01f, 1.65432487e-02f, 5.04551157e-02f, 9.48901772e-02f, -1.10520206e-01f, -5.14035635e-02f, -1.28508722e-02f,
  -5.42301796e-02f, -4.62540612e-02f, 5.52127995e-02f, 3.39063369e-02f, -1.18472762e-02f, 1.02874361e-01f, -6.46178648e-02f, 9.50158760e-02f, 1.25794038e-01f, -1.90980926e-01f,
  -5.21800220e-01f, 2.60746092e-01f, 4.01363112e-02f, -2.39661425e-01f, 2.27807853e-02f, -7.65630230e-02f, -1.03398301e-01f, -5.27399369e-02f, -3.59054953e-02f, -1.14931054e-01f,
  -5.41878529e-02f, -2.27597550e-01f, -1.19505443e-01f, -2.46290952e-01f, -4.32778597e-01f, -2.88051993e-01f, -1.51517317e-01f, -4.43283319e-01f, -5.24597108e-01f, -3.50030780e-01f,
  -3.16240966e-01f, -3.08653414e-01f, -4.40660208e-01f, -2.11919442e-01f, 2.20028728e-01f, -3.13754678e-02f, 3.08242943e-02f, -4.41571064e-02f, 4.64993082e-02f, 1.43636703e-01f,
  -7.98912123e-02f, 1.16458917e-02f, -1.47652492e-01f, -1.29531920e-01f, 1.40933663e-01f, 1.07780732e-01f, -5.83411977e-02f, -2.42344402e-02f, 4.64970656e-02f, -2.34119892e-02f,
  -1.02626540e-01f, 5.78325167e-02f, 1.36874313e-03f, -4.84965779e-02f, -9.63391662e-02f, -1.05164781e-01f, -9.83888581e-02f, -1.14278249e-01f, 1.37184630e-03f, 1.63708195e-01f,
  9.05357376e-02f, 5.50446995e-02f, 5.21954009e-03f, 1.39689192e-01f, 1.39932454e-01f, -7.95548409e-02f, 1.62572190e-01f, 1.15196146e-01f, 1.66494176e-01f, 1.76683143e-01f,
  1.75074227e-02f, 7.53886253e-02f, -2.64535807e-02f, -7.78396055e-02f, -7.45873973e-02f, -3.11607663e-02f, 3.49652255e-03f, -5.23609072e-02f, -4.83112708e-02f, -1.20764785e-01f,
  2.22706366e-02f, -5.77504635e-02f, -9.89714712e-02f, -8.64472240e-03f, -1.87286604e-02f, -2.65684840e-03f, -3.03516760e-02f, -4.43615299e-03f, -2.96601988e-02f, 9.73132532e-03f,
  -6.84284344e-02f, 4.07812446e-02f, -4.35971431e-02f, 2.43512746e-02f, 1.09139867e-01f, -2.96661537e-02f, 3.35494727e-02f, -4.16570939e-02f, 1.02408258e-02f, 3.23362760e-02f,
  -2.39175573e-01f, -3.21537375e-01f, -1.55170143e-01f, 5.04319742e-03f, 8.63928869e-02f, 1.48153290e-01f, 5.03107719e-02f, -1.18119232e-02f, -6.15714863e-03f, -7.31592029e-02f,
  -5.21476977e-02f, -6.35393104e-03f, -6.44228086e-02f, 1.04965441e-01f, -1.14862345e-01f, -5.02941618e-03f, -6.61429018e-02f, -1.07172973e-01f, 6.10627793e-02f, 2.13476390e-01f,
  9.11339745e-02f, -8.16608444e-02f, -1.19412735e-01f, 5.06404266e-02f, 1.58803314e-01f, -1.60571799e-01f, 7.29880482e-02f, 1.25180513e-01f, -3.64690349e-02f, 8.11378136e-02f,
  4.90414351e-01f, 7.13497177e-02f, 4.21103358e-01f, 2.01687351e-01f, 4.24523830e-01f, 4.29431111e-01f, 4.16838437e-01f, 2.41887629e-01f, 1.14775352e-01f, 2.22900167e-01f,
  1.27023622e-01f, 6.26910403e-02f, 6.04149811e-02f, -1.96083505e-02f, -4.23925295e-02f, 7.18574552e-03f, -1.00623399e-01f, -5.58675416e-02f, 1.47474274e-01f, 1.48241028e-01f,
  -7.56434351e-02f, 1.03685260e-02f, -1.36231305e-02f, -8.52688774e-02f, -3.39283831e-02f, 7.29910331e-03f, 1.33616075e-01f, 4.42651622e-02f, 8.93388987e-02f, -2.78269053e-01f,
  -5.76352235e-03f, 2.70042807e-01f, -3.36966030e-02f, -1.54124692e-01f, -5.09723313e-02f, -1.33647844e-01f, -3.18641141e-02f, -1.72186732e-01f, -8.40928778e-02f, -1.52467072e-01f,
  -1.73475023e-03f, -1.13179810e-01f, 2.58420482e-02f, -1.08508497e-01f, -7.11718053e-02f, -2.75543449e-03f, -7.92351514e-02f, -9.91989002e-02f, -5.94331883e-03f, 7.65439272e-02f,
  -1.59863159e-01f, 1.82115585e-01f, 2.72600472e-01f, 4.55200784e-02f, 6.86832145e-02f, 1.23939952e-02f, 5.64365052e-02f, -1.28113916e-02f, 4.13175598e-02f, -1.36373490e-01f,
  -1.01985000e-01f, 5.97885437e-02f, 2.22767647e-02f, 9.46396291e-02f, -2.05724891e-02f, 1.49711808e-02f, -3.55836898e-02f, -8.99618771e-03f, 1.39724508e-01f, 3.99815571e-03f,
  -3.44624482e-02f, 9.96444747e-02f, 5.71001247e-02f, 5.44278845e-02f, -4.75309193e-02f, 1.20794944e-01f, -9.26319975e-03f, -4.87806760e-02f, -3.48750278e-02f, -1.29650794e-02f,
  3.09819146e-03f, 2.34179031e-02f, -1.41903922e-01f, -1.54202878e-01f, -1.09849788e-01f, 6.14654087e-02f, -3.53676565e-02f, -6.12085313e-03f, -6.36839792e-02f, -1.04177542e-01f,
  -9.34231728e-02f, 1.92930460e-01f, -1.00171678e-01f, -1.35050043e-01f, -8.15778077e-02f, -1.46281704e-01f, 4.82630655e-02f, -3.42288725e-02f, -5.11272298e-03f, 6.74008280e-02f,
  7.64805749e-02f, -1.11702383e-01f, -6.77908189e-04f, -2.47866269e-02f, 3.69313471e-02f, -7.63504580e-02f, -1.09038465e-01f, -1.75704639e-02f, 1.65240373e-02f, -4.23041321e-02f,
  -1.29412338e-01f, 2.78028604e-02f, 1.81376845e-01f, 6.59663230e-02f, -1.13416530e-01f, 6.90087304e-02f, -7.07690269e-02f, -7.83586800e-02f, 1.83892652e-01f, 8.91161524e-03f,
  6.20439529e-01f, 3.41027528e-01f, 9.98962075e-02f, 8.36989284e-02f, 4.33206931e-02f, 1.58680722e-01f, 1.82535663e-01f, 1.29925549e-01f, 1.19642414e-01f, 4.30403501e-02f,
  -5.60383610e-02f, -1.56480640e-01f, -3.27732749e-02f, -1.11858383e-01f, 7.48221278e-02f, 1.89137235e-01f, 1.34430736e-01f, 1.96516335e-01f, 4.99099679e-02f, 5.03733084e-02f,
  -3.84454131e-02f, 1.32458210e-01f, 2.51183927e-01f, 1.22869447e-01f, 2.14863457e-02f, -5.53015620e-02f, -2.45910920e-02f, 1.19520567e-01f, 1.31978169e-02f, 2.14092404e-01f,
  -7.75887892e-02f, 1.19156644e-01f, 3.78049165e-02f, -9.79804173e-02f, -1.57064602e-01f, 5.51727191e-02f, -3.53073254e-02f, -7.42098242e-02f, -9.37582329e-02f, 1.64815933e-02f,
  1.91051122e-02f, -3.66444066e-02f, -6.05423190e-02f, -1.86062127e-01f, -5.70811667e-02f, -1.20119624e-01f, -1.63835302e-01f, 1.73989087e-02f, 1.72397064e-03f, -1.38871193e-01f,
  -1.80687681e-01f, -2.09045373e-02f, 3.84145528e-02f, -1.16692409e-01f, -8.56410787e-02f, -1.26869887e-01f, -1.24476023e-01f, -2.08122544e-02f, -1.27926201e-01f, 2.99313348e-02f,
  -1.37667805e-01f, 6.74817562e-02f, -1.77561685e-01f, -2.01046854e-01f, -1.73425809e-01f, -2.58593503e-02f, -1.21575199e-01f, -5.37772253e-02f, -1.29784187e-02f, -1.58863701e-02f,
  -7.76500702e-02f, -2.14978874e-01f, -1.08980559e-01f, -2.48732567e-02f, -1.30532220e-01f, -6.57471968e-03f, 7.07492931e-03f, -1.55204758e-01f, -2.18202874e-01f, -2.21479386e-02f,
  -1.54687271e-01f, 5.86011223e-02f, -5.25085852e-02f, -2.69540809e-02f, -1.01832673e-01f, -1.96184292e-01f, -8.12949911e-02f, -1.23040333e-01f, 1.22130392e-02f, 4.51011024e-02f,
  -1.87989399e-01f, -2.79218733e-01f, 1.51179824e-02f, 1.14668794e-01f, 3.71809490e-02f, 2.87303720e-02f, 1.00572268e-02f, 6.47460157e-03f, 2.87191551e-02f, -1.94468852e-02f,
  3.05535980e-02f, -7.92500470e-03f, 1.00171799e-02f, -2.37024166e-02f, -4.23318893e-02f, 4.90576914e-03f, 1.31364297e-02f, 3.62450927e-02f, -3.39630544e-02f, -5.01780584e-03f,
  -2.56012157e-02f, -3.80185395e-02f, -2.87500024e-03f, 7.28647709e-02f, 6.94741085e-02f, 8.63658413e-02f, -7.27821365e-02f, 1.02653950e-01f, 8.54882970e-02f, -2.57857181e-02f,
  -3.24919343e-01f, 3.09995502e-01f, 3.80135566e-01f, -4.35892045e-01f, 9.05285701e-02f, 2.97725290e-01f, 2.66864330e-01f, 2.35692356e-02f, -1.06608890e-01f, 8.31440315e-02f,
  2.17527941e-01f, -8.80282074e-02f, -8.97158384e-02f, -1.85887620e-01f, -9.07026008e-02f, 8.44352171e-02f, -6.59788176e-02f, -1.13338873e-01f, -1.12416230e-01f, -4.91940742e-03f,
  -1.34135917e-01f, -1.75753370e-01f, -2.04132408e-01f, -1.82064161e-01f, -3.04902107e-01f, -2.28094503e-01f, -1.04314895e-05f, -1.28573075e-01f, 1.17055506e-01f, -2.56099075e-01f,
  -9.20067355e-02f, 1.65116042e-01f, -1.05229221e-01f, -9.03514177e-02f, 1.29938990e-01f, -4.22358997e-02f, 6.83001801e-02f, -7.64148533e-02f, 4.85768914e-03f, 4.89737913e-02f,
  -2.02409048e-02f, 7.91973248e-02f, -8.73587504e-02f, -2.66764332e-02f, -5.80295175e-02f, -3.82614881e-02f, -6.15681894e-02f, -9.15478021e-02f, -1.06302574e-01f, 9.67912152e-02f,
  -6.09851517e-02f, -1.12896115e-02f, 2.13071611e-02f, 5.63892052e-02f, -2.09046789e-02f, -3.68433855e-02f, 4.27513532e-02f, -1.00491196e-01f, 6.33485708e-03f, -1.99323803e-01f,
  -4.38066460e-02f, 5.68362884e-02f, 1.37923229e-02f, -3.15770097e-02f, -3.82707193e-02f, 4.56139998e-04f, 1.57358963e-02f, 2.27182023e-02f, -8.99350718e-02f, -1.19909339e-01f,
  8.85465518e-02f, 8.59400406e-02f, 6.37388378e-02f, 6.79148035e-03f, -6.76910505e-02f, 1.37975626e-02f, -6.40384341e-03f, 2.02465989e-02f, 3.91282793e-03f, 2.93273274e-02f,
  -1.04817897e-01f, -1.10696785e-01f, 1.07632848e-02f, -4.51562069e-02f, 4.28564996e-02f, 5.85970022e-02f, -5.30248545e-02f, -4.01654206e-02f, -1.01928756e-01f, 1.16868056e-01f,
  -4.38261062e-01f, 1.88239142e-01f, -1.86902896e-01f, -3.61112244e-02f, -5.95117733e-02f, 2.12372956e-03f, 7.11581483e-02f, 4.80052233e-02f, -1.45655088e-02f, 3.19531523e-02f,
  9.69288871e-02f, -3.05260215e-02f, -1.23186313e-01f, -2.70280801e-03f, -9.51159820e-02f, 2.89604198e-02f, -1.05795272e-01f, -1.62722766e-01f, -4.70944680e-02f, -4.72948886e-02f,
  -1.55129015e-01f, -1.37710825e-01f, -2.91641593e-01f, -1.22165643e-01f, -1.59106046e-01f, -1.83578774e-01f, -1.85359418e-01f, -1.44485682e-01f, -3.71379368e-02f, -3.30404669e-01f,
  -1.19782068e-01f, -6.52693391e-01f, -8.34335983e-02f, -1.25335202e-01f, 2.01132044e-01f, 2.45945349e-01f, 1.20064527e-01f, 1.48646504e-01f, -9.44114327e-02f, -1.14098728e-01f,
  -2.46820614e-01f, -5.42546175e-02f, -2.09581167e-01f, -2.67000291e-02f, -6.93650544e-02f, -8.61545205e-02f, -1.27919942e-01f, 1.27128124e-01f, 5.03901005e-01f, 3.74112695e-01f,
  9.92333964e-02f, 7.06281513e-02f, 1.48970960e-02f, -3.82328555e-02f, -1.73994914e-01f, 2.81103365e-02f, -2.23126948e-01f, -1.62953302e-01f, -1.76218152e-01f, -4.47836846e-01f,
  7.04867542e-02f, -1.59818843e-01f, 2.89166719e-02f, -1.35145679e-01f, -4.95827273e-02f, -6.97577149e-02f, -1.32226534e-02f, -5.17022610e-02f, -6.71380609e-02f, -3.86702493e-02f,
  -4.16945517e-02f, 7.25128204e-02f, -2.77606100e-02f, 2.27064546e-02f, 7.66417086e-02f, -2.99756937e-02f, -8.68885070e-02f, -1.16958998e-01f, -2.40917757e-01f, -1.30653799e-01f,
  -2.50759006e-01f, -5.05378097e-02f, 6.20382838e-02f, 2.07419340e-02f, 4.94103227e-03f, -1.77676082e-02f, -3.79072614e-02f, -4.34263200e-02f, -1.11861788e-02f, 2.56093312e-02f,
  4.57030423e-02f, 9.20562372e-02f, 2.83912998e-02f, 2.38257311e-02f, 1.07175685e-01f, 7.91519582e-02f, 4.75795865e-02f, -6.19786279e-03f, 5.60731739e-02f, 6.71480000e-02f,
  -1.13474891e-01f, -4.23489474e-02f, -9.12063122e-02f, -1.16685688e-01f, -1.18098803e-01f, -2.05172296e-03f, -5.61249331e-02f, -9.69165191e-02f, -1.26433834e-01f, -1.10012822e-01f,
  -2.60719322e-02f, -2.63845883e-02f, -8.02395567e-02f, -1.20368656e-02f, -1.34086177e-01f, -1.20142832e-01f, -6.08131960e-02f, 3.31688896e-02f, 9.87235233e-02f, -7.98073336e-02f,
  1.22303583e-01f, -2.02303350e-01f, 8.80690292e-02f, -2.08587013e-02f, -1.36848525e-04f, -1.63703963e-01f, -6.25184253e-02f, 2.35094596e-02f, -2.10267194e-02f, 9.93572101e-02f,
  -4.01934087e-02f, 1.51721597e-01f, -8.92461538e-02f, -5.88734746e-02f, 2.29129240e-01f, 1.49926797e-01f, -2.09445562e-02f, -3.68610607e-03f, -3.94070372e-02f, -7.41892159e-02f,
  -8.24795216e-02f, 9.56410244e-02f, 1.63165823e-01f, 1.22230858e-01f, 2.34567851e-01f, 3.05212915e-01f, 1.34444684e-01f, 2.27474093e-01f, 1.27093136e-01f, 2.10680485e-01f,
  9.77302268e-02f, -4.81613353e-02f, 3.67615163e-01f, -5.96498745e-03f, -2.64316887e-01f, -3.75017434e-01f, -4.53806669e-01f, -1.77809894e-01f, -2.04810016e-02f, -6.03206716e-02f,
  -5.58491945e-02f, -5.90874590e-02f, 6.54098243e-02f, -3.77231762e-02f, -4.92032729e-02f, -4.95158881e-02f, 1.42442659e-01f, 2.79394776e-01f, 4.70422655e-02f, -2.37120762e-01f,
  -3.03584784e-01f, -2.04415321e-02f, 2.22777784e-01f, 1.00298397e-01f, 9.53358635e-02f, 2.16093031e-03f, 2.13088095e-01f, 1.23101421e-01f, 4.70481180e-02f, 2.26046637e-01f,
  5.23964427e-02f, 1.39519036e-01f, -9.73825157e-02f, -6.25847355e-02f, -8.39017183e-02f, -2.47307811e-02f, -1.03698358e-01f, 2.11985514e-01f, -2.28813030e-02f, 5.72954342e-02f,
  -1.84807703e-01f, -9.34834406e-02f, -8.47902820e-02f, -1.31685242e-01f, -1.52934253e-01f, -1.54039010e-01f, 1.54426709e-01f, 1.60248816e-01f, 1.99413747e-01f, -3.90263908e-02f,
  -3.46723229e-01f, -1.29272178e-01f, 1.21920429e-01f, -3.92668396e-02f, 1.07365943e-01f, 4.74100821e-02f, 8.94423872e-02f, -5.28759845e-02f, 6.18568845e-02f, 2.64158081e-02f,
  9.29938816e-03f, 7.46314377e-02f, 1.67460330e-02f, 5.85902222e-02f, -7.70077109e-02f, 9.04726703e-03f, 8.24378133e-02f, -9.14723203e-02f, 1.93798803e-02f, 1.33176986e-02f,
  -1.90005135e-02f, 4.65135500e-02f, 6.36753514e-02f, 1.58004295e-02f, -7.19593791e-03f, 1.99239794e-02f, -1.61337987e-01f, 3.94710153e-02f, 2.90064532e-02f, 4.52518538e-02f,
  -3.28279249e-02f, -3.70716602e-02f, 1.57673247e-02f, -4.07649614e-02f, 3.92222814e-02f, 6.79884925e-02f, -6.05134144e-02f, -6.01367280e-02f, 9.25301462e-02f, 9.20504704e-02f,
  -1.65880248e-01f, 8.86247456e-02f, -1.70678556e-01f, -7.31840357e-02f, -1.28244357e-02f, 7.30284397e-03f, -2.08043903e-02f, -4.11089249e-02f, -5.98732084e-02f, -2.33898754e-03f,
  -1.27027616e-01f, -5.23058958e-02f, 2.09259074e-02f, 1.53138507e-02f, -1.87713295e-01f, -1.17498510e-01f, -2.61215627e-01f, -1.39036521e-01f, -1.53362408e-01f, -7.55772293e-02f,
  -6.51530772e-02f, -2.91448265e-01f, -2.77837902e-01f, -2.15807930e-01f, -1.82793036e-01f, -2.35825956e-01f, -1.50208712e-01f, -1.73938468e-01f, -2.46343523e-01f, -3.06452453e-01f,
  -5.20062447e-01f, -1.82203218e-01f, 4.86639738e-02f, 1.90398574e-01f, 1.46637961e-01f, 1.28387913e-01f, 9.18220878e-02f, 1.53157577e-01f, 1.17007636e-01f, 1.13363266e-01f,
  -1.93660462e-03f, -1.66004613e-01f, -8.40439741e-03f, -1.16965458e-01f, -7.55061060e-02f, 1.62789047e-01f, 9.65971798e-02f, -1.13283008e-01f, -7.12605640e-02f, -8.80151764e-02f,
  5.65545633e-02f, 5.26344106e-02f, -2.55376063e-02f, 2.16383934e-02f, 1.25667930e-01f, 1.26368953e-02f, 1.77773610e-01f, 8.11224058e-02f, 5.76435253e-02f, 7.29550570e-02f,
  -2.50102967e-01f, -1.57186419e-01f, 3.72460708e-02f, -6.90808445e-02f, -1.08486205e-01f, -8.18129182e-02f, -8.12657028e-02f, 1.06602788e-01f, 6.22547753e-02f, 1.22885801e-01f,
  6.02489002e-02f, -9.14923549e-02f, -6.41138628e-02f, -4.23308909e-02f, 6.61180615e-02f, -3.43242399e-02f, -5.12554161e-02f, -1.01188026e-01f, -6.86458200e-02f, -4.95921783e-02f,
  -2.58970596e-02f, -3.25423814e-02f, -3.06190178e-02f, 5.32229468e-02f, -1.25698656e-01f, -8.27472359e-02f, -5.93247823e-02f, -6.45023808e-02f, -1.22871704e-01f, 5.25543168e-02f,
  -1.50011957e-01f, -5.76570723e-03f, -8.87611508e-02f, 1.87740680e-02f, -2.47074477e-02f, 3.78759913e-02f, 1.93871871e-01f, 1.93589494e-01f, 8.94000381e-02f, 1.62208021e-01f,
  1.07700422e-01f, 6.66730925e-02f, 2.12221429e-01f, 1.69213682e-01f, 2.03389190e-02f, 5.18056788e-02f, 4.21438068e-02f, 9.25011262e-02f, 2.16260672e-01f, 1.97813079e-01f,
  1.35620207e-01f, 1.66500404e-01f, 1.04915559e-01f, 1.30730763e-01f, 1.16964988e-01f, 1.70521393e-01f, 1.07623994e-01f, 1.59030393e-01f, 2.41859592e-02f, 3.97306010e-02f,
  3.42144608e-01f, -7.08964244e-02f, -3.73419411e-02f, 1.25495613e-01f, 6.32543489e-02f, 3.57017554e-02f, 2.31554639e-02f, 9.30200890e-02f, 1.32528454e-01f, 2.07457855e-01f,
  1.75167665e-01f, 1.18928337e-02f, -5.60069717e-02f, 1.43972188e-01f, 1.48924053e-01f, 1.50034994e-01f, 1.32434547e-01f, 1.17324136e-01f, 2.89640166e-02f, -2.52014399e-03f,
  5.07381707e-02f, 6.62994608e-02f, 1.95547625e-01f, 7.45242238e-02f, -1.66129656e-02f, -6.21630140e-02f, -6.91024810e-02f, -5.12816245e-03f, 3.55104394e-02f, 1.97497785e-01f,
  -2.83942401e-01f, 5.16019017e-02f, -3.41137618e-01f, 2.64423430e-01f, 1.76782593e-01f, 1.43729791e-01f, 6.57371208e-02f, 9.28487778e-02f, 2.35473081e-01f, 8.24342445e-02f,
  1.42128900e-01f, 2.18016714e-01f, 2.41644248e-01f, 9.83740613e-02f, 1.81456938e-01f, 2.08932519e-01f, 1.92260176e-01f, -4.24627289e-02f, 5.04110642e-02f, 4.25521880e-02f,
  3.16839367e-01f, 1.76247612e-01f, -7.39008561e-02f, 6.27955943e-02f, 6.22991733e-02f, 2.26413026e-01f, 9.46992487e-02f, 4.75225854e-04f, 1.35027748e-02f, 1.49503112e-01f,
  -1.76764011e-01f, -2.11230829e-01f, 6.22716770e-02f, 5.27951606e-02f, -2.22446904e-01f, -1.63333833e-01f, -7.34173283e-02f, -9.38590318e-02f, -4.48013283e-02f, 5.28607592e-02f,
  -1.02496684e-01f, -3.57495770e-02f, 2.35795621e-02f, 2.35572900e-03f, -5.17253578e-02f, -1.70131810e-02f, -1.04196183e-01f, -5.48933521e-02f, 6.57243580e-02f, -3.06755360e-02f,
  4.71419059e-02f, -3.29649746e-02f, -1.97676092e-01f, -5.00936713e-03f, 7.51666352e-02f, 6.20017089e-02f, -1.27355009e-01f, -4.92071658e-02f, -3.95410843e-02f, -5.73294163e-02f,
  3.04326773e-01f, 7.34153390e-02f, -4.28254567e-02f, -5.37688248e-02f, 3.69947627e-02f, 5.20986058e-02f, -4.18462865e-02f, -3.05055361e-02f, -5.49497567e-02f, -4.44061728e-03f,
  -7.29255378e-02f, 1.12319671e-01f, -7.53864795e-02f, 7.24505261e-02f, 1.38425544e-01f, -1.02308787e-01f, -1.65827990e-01f, 2.62737449e-04f, -1.34977266e-01f, -6.21000379e-02f,
  5.04686274e-02f, -1.12223290e-01f, -5.33337928e-02f, -7.77994022e-02f, -6.75433595e-03f, -1.48823969e-02f, -1.68208347e-03f, 3.27484794e-02f, 3.42583507e-02f, 1.17125779e-01f,
  1.13921843e-01f, 1.17524683e-01f, 6.82722107e-02f, -2.56126747e-02f, -1.70921192e-01f, -1.26845792e-01f, 1.05954193e-01f, -1.00735545e-01f, -1.28895730e-01f, 2.20147427e-02f,
  -6.87791854e-02f, -8.88023302e-02f, -1.23326648e-02f, -5.35497256e-02f, -1.04458602e-02f, 1.82269869e-05f, -2.13457420e-02f, 9.85162985e-03f, 9.48743373e-02f, -1.57565385e-01f,
  3.39337662e-02f, 1.97848957e-02f, -5.54470867e-02f, -2.01423485e-02f, 2.21757852e-02f, 2.32377406e-02f, 1.25126773e-02f, -1.99070107e-02f, -6.71894923e-02f, 7.29640201e-02f,
  4.29147899e-01f, -4.06097472e-01f, 1.46256283e-01f, 1.44494370e-01f, 1.74136922e-01f, 2.10116953e-01f, 7.98159838e-02f, 2.42732704e-01f, 2.25654438e-01f, 5.91167510e-02f,
  -1.00447975e-01f, 6.27884408e-03f, 5.45237623e-02f, 2.42565293e-04f, -5.24287932e-02f, -1.09635782e-03f, 9.43348482e-02f, 1.52633056e-01f, 3.22975636e-01f, 2.54169822e-01f,
  1.56414218e-03f, -5.97368926e-02f, 5.66090383e-02f, 8.96166638e-02f, 1.72218438e-02f, 1.10295512e-01f, -1.41104143e-02f, -4.78975773e-02f, -2.05202159e-02f, -4.38113371e-03f,
  -1.66470796e-01f, -1.92734614e-01f, 1.31748825e-01f, -1.40033334e-01f, -2.17594191e-01f, 2.78364494e-02f, 1.05622569e-02f, -9.94770229e-02f, -1.10094868e-01f, 5.12943778e-04f,
  -6.22535981e-02f, -6.21664301e-02f, -9.01744217e-02f, -7.26309791e-02f, -1.11310966e-02f, -1.13299474e-01f, -7.20507503e-02f, 7.22890766e-03f, -1.03574373e-01f, -1.12579674e-01f,
  -1.38043165e-01f, 1.02198273e-01f, -2.98906378e-02f, 4.77633886e-02f, -5.11753606e-04f, 2.67410260e-02f, -2.77663525e-02f, 7.28953481e-02f, 1.13690691e-02f, 1.51198238e-01f,
  8.37276205e-02f, -6.37466609e-02f, -3.00832558e-02f, 1.06722921e-01f, -4.24004309e-02f, 6.72914609e-02f, 6.06904402e-02f, 5.81936501e-02f, 4.21234556e-02f, -4.17647064e-02f,
  3.84318829e-02f, 7.63275940e-03f, 9.30931494e-02f, 6.68358281e-02f, -9.52127501e-02f, 5.72156906e-03f, 4.21355478e-03f, -1.68799117e-01f, -2.22651213e-01f, -1.40591472e-01f,
  -1.03714332e-01f, 8.96316096e-02f, -5.31026460e-02f, -9.38299000e-02f, -1.02425560e-01f, 2.42714360e-02f, 5.17267026e-02f, -1.02150485e-01f, 8.24616030e-02f, 3.46424207e-02f,
  -3.37390155e-01f, -1.45489246e-01f, 1.78453639e-01f, 4.78198044e-02f, -3.34757939e-02f, -1.23744622e-01f, -1.11668952e-01f, -9.81008410e-02f, -7.38283098e-02f, -1.25488147e-01f,
  -6.32774755e-02f, 6.83545098e-02f, -6.37983829e-02f, 6.30990118e-02f, 1.59709036e-01f, -1.20539945e-02f, -5.63956127e-02f, 1.71148151e-01f, -1.63709745e-02f, -7.07869977e-02f,
  8.09081551e-03f, 1.97842151e-01f, 1.59374341e-01f, 1.83029234e-01f, 6.55924231e-02f, 1.74739346e-01f, 1.53749539e-02f, 1.20846510e-01f, 1.32524133e-01f, 1.77188203e-01f,
  -1.82100981e-02f, 1.95932463e-01f, 1.65362686e-01f, 9.83183533e-02f, 9.71236899e-02f, 2.31345743e-01f, 3.26810479e-01f, 1.47663862e-01f, -4.53165062e-02f, 9.22929272e-02f,
  1.40375450e-01f, 6.17577173e-02f, 2.23383233e-01f, 1.94955140e-01f, 2.17725173e-01f, 9.71421897e-02f, 1.07311197e-01f, 2.88573140e-03f, -5.14220633e-03f, -4.33192402e-03f,
  6.82188421e-02f, 2.27033962e-02f, -5.88209666e-02f, 4.67883870e-02f, 5.83388172e-02f, -5.21343155e-03f, 1.59980342e-01f, 1.94437966e-01f, 2.38779187e-01f, -5.26805520e-02f,
  3.39788407e-01f, 2.20997065e-01f, -1.03569008e-01f, -1.03023857e-01f, 8.47218558e-02f, -1.88347042e-01f, -1.41193479e-01f, -1.56919315e-01f, -1.66227177e-01f, -2.50356663e-02f,
  3.67441177e-02f, -1.19754493e-01f, 5.13574667e-02f, -1.32062018e-01f, -6.81823790e-02f, -7.30521828e-02f, -3.73695977e-02f, -4.22567576e-02f, 8.19132254e-02f, 1.64606571e-01f,
  -4.38437089e-02f, 1.26578435e-01f, 1.68162405e-01f, 1.03528872e-01f, 5.30877970e-02f, -4.96472269e-02f, 1.12116762e-01f, 7.08789229e-02f, 7.81545863e-02f, -6.84409961e-02f,
  -8.30078789e-05f, 6.07443899e-02f, 1.66472271e-01f, -4.89911251e-02f, 1.18201800e-01f, -9.45580471e-03f, -4.94602770e-02f, 1.86561104e-02f, 1.75828636e-02f, -8.98398012e-02f,
  -3.16090956e-02f, 2.73949325e-01f, 8.10434446e-02f, -1.08673379e-01f, -7.68148825e-02f, 6.43691719e-02f, -4.52377610e-02f, 3.13123390e-02f, 1.33233234e-01f, 1.00992918e-01f,
  5.69071881e-02f, -4.76881629e-03f, -2.54854187e-02f, 5.42507693e-03f, -1.22541927e-01f, -9.78109241e-02f, -1.16066240e-01f, 1.18652429e-03f, -5.90898618e-02f, -2.79139020e-02f,
  1.79293528e-01f, 4.95529890e-01f, 5.01100719e-02f, 1.81017537e-02f, -4.20963503e-02f, -1.29166871e-01f, 1.19946949e-01f, 2.84119267e-02f, -4.83533964e-02f, -4.29478511e-02f,
  3.67203429e-02f, -1.93305194e-01f, -1.81986950e-02f, -1.07978441e-01f, -1.09626263e-01f, -1.46111831e-01f, -5.69330528e-02f, -2.53247470e-02f, 1.12876520e-01f, 5.83994985e-02f,
  -3.25051844e-02f, -7.74021074e-02f, -6.24663495e-02f, 2.45711524e-02f, 3.83322053e-02f, 2.22637448e-02f, 2.97797434e-02f, -5.61741590e-02f, -2.14390140e-02f, -2.58400917e-01f,
  2.63279408e-01f, -1.58545092e-01f, 6.69501573e-02f, 1.11386724e-01f, 4.12689373e-02f, 6.51620924e-02f, -6.28402606e-02f, 3.10946740e-02f, 7.40845129e-02f, 1.20767124e-01f,
  7.84444883e-02f, 2.75110066e-01f, 1.84530511e-01f, 1.50415465e-01f, 6.13742582e-02f, 8.06831289e-03f, 4.06038463e-02f, 4.23406102e-02f, 1.30142927e-01f, 1.06455557e-01f,
  7.53189921e-02f, 8.15931037e-02f, 8.45690072e-02f, -1.02846352e-02f, -1.15814053e-01f, 9.44116190e-02f, 3.57488506e-02f, 2.99897685e-04f, -3.43600474e-02f, -6.02457486e-02f,
  3.89333665e-01f, -2.02452287e-01f, 4.79536764e-02f, 8.23495851e-04f, -1.38278738e-01f, -1.39198050e-01f, 3.67577821e-02f, -1.37161821e-01f, -2.00591102e-01f, -1.29848361e-01f,
  -6.79411665e-02f, -4.85992245e-02f, -1.10078663e-01f, -1.65181324e-01f, -1.00275703e-01f, -2.46482366e-03f, -1.47166297e-01f, -2.82281376e-02f, -1.05794119e-02f, -2.43791100e-02f,
  -8.40694830e-02f, -1.11317471e-01f, -4.27925587e-02f, -5.76016195e-02f, -7.98505079e-03f, 7.36992061e-02f, -1.72536522e-01f, -2.21481808e-02f, -3.82310487e-02f, -1.25115111e-01f,
  9.03007090e-02f, -2.74164081e-02f, 1.29405288e-02f, -8.59357119e-02f, -7.38962041e-03f, 1.31937683e-01f, -1.95489079e-02f, 3.35770883e-02f, 9.33526680e-02f, -8.16613510e-02f,
  1.03410825e-01f, 4.93468903e-02f, 2.10035779e-02f, 1.44319847e-01f, 1.31683215e-01f, 1.42598338e-02f, 3.58809605e-02f, -1.74047332e-02f, 3.66329029e-03f, -7.84440339e-03f,
  2.00952455e-01f, 6.01438666e-03f, 3.45651507e-02f, -7.74736656e-03f, 2.66583674e-02f, -5.52858412e-02f, 7.29305819e-02f, 5.24688652e-03f, 1.23728048e-02f, 4.82496843e-02f,
  1.36626571e-01f, -4.08425853e-02f, 1.45596430e-01f, -1.67654641e-02f, -2.09070608e-01f, -6.42669350e-02f, 4.77120057e-02f, -3.89917381e-02f, -1.29874021e-01f, -6.89353570e-02f,
  1.45689026e-02f, -2.65057590e-02f, -9.82500613e-02f, 1.86788160e-02f, 3.16263326e-02f, 1.24671608e-01f, -4.94554415e-02f, -5.48719987e-02f, -1.13444375e-02f, 1.00581842e-02f,
  -3.50548215e-02f, -4.61402535e-02f, 1.89316839e-01f, 1.87107082e-02f, 4.54408824e-02f, 2.22372696e-01f, 1.18621230e-01f, 1.25358745e-01f, 1.16474673e-01f, 1.02880865e-01f,
  -1.20402523e-03f, -1.92161431e-04f, -2.92774532e-02f, -3.49963188e-01f, -3.42872858e-01f, -1.93125084e-01f, -8.58892687e-03f, -2.28570387e-01f, -3.47419143e-01f, -5.65550402e-02f,
  5.23287505e-02f, 1.40852839e-01f, 1.04831569e-01f, 5.27934395e-02f, 1.63225144e-01f, 1.28245458e-01f, -1.37503399e-02f, 4.21246141e-02f, 1.79957420e-01f, -9.97888669e-02f,
  -1.05569012e-01f, -5.01761027e-02f, -1.10609159e-01f, -1.36728838e-01f, -2.46309057e-01f, 4.10548449e-02f, -1.27289444e-01f, -2.48007596e-01f, -1.83262214e-01f, -1.44941464e-01f,
  4.35314566e-01f, -2.66126186e-01f, -2.88675372e-02f, 2.24460065e-02f, -7.91962147e-02f, 5.96844591e-02f, 2.81523969e-02f, -5.10977730e-02f, -9.92501825e-02f, -9.22802165e-02f,
  -1.19768262e-01f, -8.58004466e-02f, 6.41813204e-02f, -2.87429467e-02f, -4.65210900e-03f, -3.11047235e-03f, -6.39344454e-02f, -1.04813486e-01f, -1.25213712e-01f, 4.99651942e-04f,
  2.80247461e-02f, -5.56334592e-02f, 8.12024549e-02f, -7.11562112e-02f, -5.38758598e-02f, -5.36739314e-03f, -2.48284116e-02f, -1.01305045e-01f, -9.02386308e-02f, 1.68209001e-02f,
  -4.88031516e-03f, 3.66223827e-02f, -2.32457090e-03f, 6.21820129e-02f, -5.41416630e-02f, -4.02619764e-02f, 3.49912941e-02f, 1.30733997e-01f, 6.75206929e-02f, 2.38773506e-02f,
  -8.04077163e-02f, -2.77571063e-02f, -3.49061973e-02f, -1.58924032e-02f, 6.54328242e-02f, -3.26932333e-02f, -1.60251260e-02f, -3.06794588e-02f, -5.93634434e-02f, -8.35426748e-02f,
  -9.80775058e-02f, -7.27653652e-02f, -4.16176841e-02f, 7.92267472e-02f, -1.97165995e-03f, -3.99579741e-02f, -3.06965914e-02f, 9.17848125e-02f, 3.92557755e-02f, 8.38939473e-03f,
  3.16564798e-01f, -4.05173264e-02f, 1.19042344e-01f, 1.92738678e-02f, -1.45083172e-02f, 2.06600223e-02f, -4.20399606e-02f, 2.91406438e-02f, -4.79787588e-02f, -4.39805537e-02f,
  -1.43868864e-01f, 4.21665870e-02f, -2.65627764e-02f, 3.76569703e-02f, 4.38909531e-02f, 3.87683623e-02f, 1.50923934e-02f, 6.41235635e-02f, -5.07198162e-02f, 3.15185152e-02f,
  -1.16863422e-01f, 8.76069516e-02f, 1.49549857e-01f, 2.01751739e-01f, -7.87623823e-02f, 2.24031687e-01f, 1.49022967e-01f, 6.67638183e-02f, 1.91983148e-01f, 3.13119650e-01f,
  7.10253358e-01f, -5.10241330e-01f, 2.30074953e-02f, 2.65066028e-01f, 7.65460134e-02f, 6.68918118e-02f, -8.42097774e-03f, 1.12218358e-01f, 1.05060644e-01f, -5.69279194e-02f,
  4.47152816e-02f, 2.06520677e-01f, 1.44651875e-01f, 1.10151075e-01f, 9.42242518e-02f, -1.64244741e-01f, -1.60364628e-01f, 1.98189527e-01f, 3.78130674e-01f, 1.44490689e-01f,
  -1.66438535e-01f, -1.37858689e-01f, 1.05874188e-01f, 2.28176881e-02f, -1.35613382e-01f, 1.78060122e-02f, -1.47498235e-01f, -1.40534565e-01f, -2.18994737e-01f, -3.46980184e-01f,
  -7.24861249e-02f, -2.16496568e-02f, 1.61060646e-01f, 4.54147812e-03f, -7.09854066e-02f, 8.51696134e-02f, 1.31391808e-02f, -1.36435583e-01f, -6.61025580e-04f, -1.86777696e-01f,
  -3.86276394e-02f, -7.40165263e-02f, 6.52844831e-02f, 6.97362749e-03f, -9.70194787e-02f, 1.10742822e-03f, -4.69230600e-02f, -6.31067082e-02f, -4.24266234e-02f, -1.13367356e-01f,
  -1.13063812e-01f, 2.26826919e-03f, -5.37980944e-02f, -7.05847815e-02f, 1.28959626e-01f, 1.14217177e-01f, -7.85996243e-02f, -4.58437018e-03f, 3.29855201e-03f, -3.71535569e-02f,
  2.57845409e-02f, 5.84982671e-02f, 3.04293502e-02f, -1.86642073e-02f, 1.13537818e-01f, 1.18880138e-01f, -1.84613056e-02f, -5.43884598e-02f, 5.31636700e-02f, -7.12105408e-02f,
  -6.98811412e-02f, 6.04617149e-02f, 1.04432099e-01f, 1.25963958e-02f, 9.28057581e-02f, -1.04465196e-02f, 7.09974766e-02f, -8.19411054e-02f, -6.69566635e-03f, -1.53459413e-02f,
  7.14052618e-02f, 3.11457012e-02f, -2.64904015e-02f, -1.31692782e-01f, -1.13004804e-01f, -5.24763251e-03f, -1.98755395e-02f, 6.45954022e-03f, -5.72803952e-02f, -7.52646476e-02f,
  -2.46277839e-01f, 1.64135113e-01f, 5.56734018e-03f, -5.59125468e-02f, 1.05692446e-02f, -1.02996394e-01f, 1.55183941e-01f, -8.05291981e-02f, -1.25277609e-01f, -2.54532620e-02f,
  -4.26767534e-03f, -1.24145327e-02f, -6.54611588e-02f, -4.88388054e-02f, 3.77860963e-02f, 3.86444777e-02f, -2.16475129e-02f, 1.70712788e-02f, 6.56029135e-02f, -5.73809259e-02f,
  -1.53656915e-01f, 1.94027070e-02f, 1.35633945e-01f, 1.90292269e-01f, 3.26505229e-02f, 2.40956560e-01f, 7.87079632e-02f, 2.12125927e-02f, 2.18533382e-01f, -6.38828520e-03f,
  2.56602466e-01f, -3.66415024e-01f, -2.44625762e-01f, 2.64606699e-02f, -1.03162117e-01f, -1.39397979e-02f, -2.99349517e-01f, 5.94276376e-02f, -8.42786394e-03f, -2.16357723e-01f,
  1.44477844e-01f, 3.98392946e-01f, 2.85098016e-01f, 2.39611089e-01f, 1.79529801e-01f, -3.03016126e-01f, -3.36670786e-01f, 1.48586974e-01f, 2.98405647e-01f, 2.73779452e-01f,
  6.30922988e-03f, -5.62150702e-02f, 1.58501089e-01f, 1.79839015e-01f, -1.70501530e-01f, 8.91296491e-02f, -2.39328817e-01f, -1.30620301e-01f, -1.11971267e-01f, -4.51491624e-01f,
  -8.37324634e-02f, -1.13565549e-01f, 2.39763007e-01f, 1.35617778e-01f, -1.21743590e-01f, 7.01300846e-03f, -3.71063761e-02f, -9.17726308e-02f, -5.27313678e-03f, -1.07360177e-01f,
  -7.48288780e-02f, 1.36820972e-01f, 5.01633622e-02f, -4.34872992e-02f, -1.13659138e-02f, 4.23315652e-02f, -4.64213379e-02f, 2.66472958e-02f, 7.88365528e-02f, -7.77917877e-02f,
  -1.60760090e-01f, -1.41553298e-01f, -9.79018286e-02f, -9.86324772e-02f, 5.53135313e-02f, 1.70685649e-01f, 1.50871370e-02f, -7.00240396e-03f, 1.18826218e-02f, -3.04948568e-01f,
  -1.01181827e-02f, -3.12061347e-02f, -2.30948776e-02f, -7.52602890e-02f, 8.12404975e-02f, -3.86496037e-02f, -2.74654310e-02f, 6.63350895e-02f, 5.21583632e-02f, -7.75201023e-02f,
  -2.78055891e-02f, -2.36782078e-02f, -2.75942869e-03f, -3.03321332e-02f, -2.76805162e-02f, -4.13454957e-02f, -2.35150773e-02f, -5.23436964e-02f, 1.14057921e-01f, -4.84610610e-02f,
  1.38291404e-01f, -5.28228059e-02f, -1.37624098e-02f, 1.49923563e-01f, -3.04562245e-02f, -4.48129587e-02f, -3.93309779e-02f, 6.71642125e-02f, 6.91817254e-02f, -5.23503907e-02f,
  1.37814641e-01f, 1.97321743e-01f, -3.39345820e-02f, 1.24836154e-01f, -1.09289736e-01f, 2.36971602e-02f, -6.14352152e-02f, 5.06013110e-02f, 6.68891221e-02f, 3.95510942e-02f,
  1.23176448e-01f, 3.75542305e-02f, -1.18677996e-01f, 2.97400188e-02f, 1.23723540e-02f, 6.54422343e-02f, -9.56231505e-02f, 1.12118581e-02f, 1.11673355e-01f, -6.35555759e-02f,
  -6.52026907e-02f, -1.76970974e-01f, 6.57110512e-02f, -2.39812620e-02f, 4.33019325e-02f, 8.21580440e-02f, -4.80217151e-02f, 5.17333252e-03f, 1.11481994e-01f, -2.70030260e-01f,
  4.61522758e-01f, 1.03865460e-01f, 1.76237468e-02f, 2.12702587e-01f, -4.98069786e-02f, -2.42007017e-01f, -3.35594833e-01f, -1.59712806e-01f, 3.72891426e-02f, 1.11873530e-01f,
  1.22102797e-01f, 2.20688179e-01f, 2.86923766e-01f, 1.81403294e-01f, -3.48743573e-02f, -4.94009927e-02f, 1.15831830e-01f, 2.88326114e-01f, 2.24657759e-01f, 2.75859773e-01f,
  2.45926932e-01f, 1.87925994e-01f, 2.13313803e-01f, 8.32198039e-02f, 2.02505887e-01f, 2.84256309e-01f, 1.20821819e-01f, 2.19047040e-01f, 7.75714964e-02f, 4.01224196e-01f,
  2.52054155e-01f, 9.69355628e-02f, 5.06633520e-02f, 1.08360715e-01f, 9.97301340e-02f, 1.01171888e-01f, 7.10879220e-03f, -4.97910678e-02f, -8.71325657e-02f, -2.52278708e-02f,
  2.90602688e-02f, 6.89605251e-02f, 2.16532834e-02f, 8.74894932e-02f, 4.62943176e-03f, 8.20118040e-02f, 1.40867000e-02f, -2.94323172e-02f, -6.72489479e-02f, 8.53071436e-02f,
  1.02953307e-01f, 4.90348674e-02f, -2.14919209e-01f, -2.21700341e-01f, -9.82802734e-02f, 3.55060548e-02f, -3.54586430e-02f, 1.32349908e-01f, -8.49530008e-03f, 5.92491217e-02f,
  1.46677002e-01f, 4.17123884e-02f, 2.19499156e-01f, 1.38553217e-01f, 1.32384986e-01f, 6.12928718e-02f, 1.78924333e-02f, -9.24381241e-03f, 9.82299298e-02f, 1.44879982e-01f,
  9.88737270e-02f, 4.78661731e-02f, -5.11378087e-02f, 8.42699185e-02f, 7.31915161e-02f, 1.34961218e-01f, -7.00301304e-02f, 1.00026347e-01f, 6.23989478e-02f, 2.99382377e-02f,
  1.59260780e-01f, -4.12034467e-02f, -2.81382855e-02f, -1.66589692e-02f, -5.35663031e-02f, 1.28298998e-01f, 2.03295961e-01f, 3.15591618e-02f, 1.64395317e-01f, 1.40796497e-01f,
  -2.07643062e-01f, -1.53202936e-01f, 2.60324568e-01f, 2.68837288e-02f, -6.41351566e-02f, 4.47813198e-02f, 2.21806075e-02f, -2.53918655e-02f, -7.72714987e-02f, 3.02788951e-02f,
  -8.53684470e-02f, 3.24413590e-02f, -1.07275560e-01f, -1.13809332e-01f, -1.03196137e-01f, 1.14400797e-02f, -5.85044771e-02f, -1.40666455e-01f, -4.16603312e-02f, -3.67223248e-02f,
  -1.53912976e-01f, -2.46578977e-01f, -1.92800179e-01f, -2.59898275e-01f, -1.05405264e-01f, -2.35674474e-02f, -1.56113625e-01f, -1.03764296e-01f, -1.80451319e-01f, -9.24792215e-02f,
  -1.83070049e-01f, 2.60462463e-02f, -1.54366314e-01f, -2.81103346e-02f, -6.88142329e-02f, -2.51378804e-01f, -2.22862199e-01f, -4.22303043e-02f, 7.89453238e-02f, 7.66826496e-02f,
  1.23277560e-01f, 1.10410735e-01f, 6.83293417e-02f, -7.34910369e-02f, -2.52147615e-01f, -2.59740233e-01f, -1.99364752e-01f, -3.21409285e-01f, -1.51355058e-01f, -4.69060354e-02f,
  4.35825661e-02f, 7.61191323e-02f, -9.05125290e-02f, -7.23301619e-02f, 1.43159881e-01f, 7.11325109e-02f, 5.35933487e-02f, 5.45679405e-02f, -2.34132577e-02f, -3.18341255e-02f,
  1.96494833e-01f, -5.16768247e-02f, -4.77426723e-02f, -8.02466050e-02f, 7.13005662e-02f, -6.70270771e-02f, -4.48685624e-02f, -4.30064101e-05f, -5.70416823e-02f, -3.44300792e-02f,
  -6.53567072e-03f, -8.23793188e-02f, -1.12110898e-02f, 2.65535079e-02f, -8.72876942e-02f, -1.25694796e-01f, -5.95607907e-02f, -1.33409366e-01f, -1.20373666e-01f, -1.04397917e-02f,
  -1.03756022e-02f, -1.79263785e-01f, -7.94478506e-02f, 7.83128012e-03f, -1.83164403e-02f, -2.99410224e-02f, 7.03328475e-02f, 9.92472172e-02f, 4.44113724e-02f, 1.23177372e-01f,
  -4.41058073e-03f, 1.26736224e-01f, 2.42932746e-03f, 4.18931395e-02f, -8.63655470e-03f, 7.15811402e-02f, -1.00466330e-02f, -3.89482118e-02f, -5.93775176e-02f, 9.42881256e-02f,
  5.39068207e-02f, -9.11256589e-04f, 5.14328480e-02f, -1.11433946e-01f, -4.23260257e-02f, -1.47281485e-02f, -1.98273167e-01f, -2.08081249e-02f, -6.81949034e-02f, -2.39557270e-02f,
  -1.50288930e-02f, -4.27959114e-03f, 9.84324440e-02f, 3.24407825e-03f, -1.60096988e-01f, -9.27508548e-02f, -6.65694028e-02f, 4.30692099e-02f, 1.90648739e-03f, -1.57371730e-01f,
  3.38889539e-01f, -2.63324678e-01f, -3.69425118e-02f, -7.19832629e-02f, -1.69350542e-02f, 1.06166475e-01f, -6.63985088e-02f, -6.92304447e-02f, -7.90236145e-02f, 2.68823225e-02f,
  -7.12714046e-02f, -1.05444575e-02f, -2.93794703e-02f, 2.49705873e-02f, -9.87958238e-02f, 5.89241460e-02f, -2.28767004e-02f, 5.71854152e-02f, -1.80239737e-01f, 1.00648530e-01f,
  -7.54657611e-02f, -1.85737699e-01f, -5.32598346e-02f, 3.46022099e-02f, 8.92763957e-02f, -1.08743273e-01f, 1.51112840e-01f, 6.70600832e-02f, -8.45804289e-02f, 2.17344970e-01f,
  3.50037903e-01f, -7.00725336e-03f, -6.38656676e-01f, -6.14628829e-02f, -1.99934319e-01f, -6.07663672e-03f, 1.15319066e-01f, 3.07365507e-01f, 2.81019658e-01f, 2.24397723e-02f,
  1.92489494e-02f, 1.17120057e-01f, -1.10926799e-01f, 9.62348469e-03f, -4.54770476e-02f, -2.53676683e-01f, -2.61927038e-01f, -1.48074090e-01f, -1.13264760e-02f, 2.24875286e-01f,
  9.12097469e-02f, -8.70375112e-02f, -7.71091431e-02f, -7.25265145e-02f, -1.08551010e-01f, -1.70394778e-01f, -3.38900268e-01f, -9.77728441e-02f, -2.37312600e-01f, -4.17222768e-01f,
  -5.10619164e-01f, -2.20662087e-01f, -6.75258180e-03f, 1.71025798e-01f, -7.84926489e-02f, 1.40168086e-01f, 6.99468851e-02f, -1.41916182e-02f, 2.53146470e-01f, -2.91717872e-02f,
  -2.47790832e-02f, 2.70121805e-02f, -1.72031000e-02f, 1.05609065e-02f, -1.01785302e-01f, 3.42188850e-02f, 5.22340573e-02f, 5.13840020e-02f, 4.78333570e-02f, 3.40360776e-02f,
  1.14236020e-01f, 6.32377788e-02f, 5.03821149e-02f, 1.21909566e-01f, 1.04641832e-01f, -7.83042908e-02f, -2.35731583e-02f, 5.96889295e-02f, -6.77030757e-02f, 1.56257540e-01f,
  4.65193298e-03f, -3.62459160e-02f, -2.04656851e-02f, 1.04610026e-01f, 9.79636163e-02f, 9.48713794e-02f, -7.75072575e-02f, 7.52896443e-02f, -1.29347974e-02f, 5.68879806e-02f,
  1.04398564e-01f, -1.18652107e-02f, -3.33996937e-02f, -9.93832275e-02f, -2.37697348e-01f, -9.61457565e-03f, -1.47876544e-02f, -2.59559527e-02f, -9.56499651e-02f, -3.28712910e-02f,
  -1.35426037e-02f, 7.75697902e-02f, -1.01067014e-01f, -1.22232422e-01f, -1.01230718e-01f, -1.18581820e-02f, -1.22862510e-01f, -9.24460776e-03f, 3.14141214e-02f, 5.16003370e-02f,
  -5.26093245e-02f, -1.18774198e-01f, -6.03544479e-03f, -3.15876193e-02f, -8.70049447e-02f, 1.79631577e-03f, -1.73324674e-01f, 1.21606980e-02f, 2.33997442e-02f, -1.05303027e-01f,
  -1.81128234e-02f, -1.21511018e-03f, -1.44173265e-01f, 3.61801311e-02f, -3.33748981e-02f, -5.02987429e-02f, 1.45192668e-01f, 7.14141726e-02f, -4.32391241e-02f, -2.97019202e-02f,
  6.89290985e-02f, 2.00999200e-01f, 1.48977861e-01f, 5.10376543e-02f, 1.42252296e-01f, 6.64518997e-02f, -1.85961335e-03f, 4.41036224e-02f, -4.38321047e-02f, 2.13655025e-01f,
  -1.50726348e-01f, 9.66388732e-02f, -5.23736954e-01f, -2.01901078e-01f, -2.45574772e-01f, -1.35221839e-01f, 1.34116098e-01f, 1.76552460e-01f, 1.40964957e-02f, -7.73511678e-02f,
  -1.00594372e-01f, -1.69155136e-01f, -2.23985910e-01f, -5.48852161e-02f, -7.79692084e-03f, -1.48773208e-01f, -2.12955579e-01f, -2.73657084e-01f, -1.19144998e-01f, 1.50909171e-01f,
  1.81400418e-01f, 4.55728173e-02f, 7.07994029e-02f, 1.59147680e-02f, -5.79247549e-02f, -1.46999568e-01f, -1.81936935e-01f, -1.84165597e-01f, -9.59588960e-02f, -2.56808162e-01f,
  -3.42088401e-01f, -8.72721598e-02f, 1.04521550e-02f, 9.77883190e-02f, -3.23496498e-02f, 3.90057787e-02f, 9.34562385e-02f, -7.43138567e-02f, 7.43126869e-02f, -6.59144744e-02f,
  -1.03375815e-01f, 4.53815907e-02f, -3.55689451e-02f, 1.05370749e-02f, -8.24228525e-02f, 2.49962527e-02f, -7.80726224e-02f, -1.04803786e-01f, -5.93728684e-02f, 1.19338527e-01f,
  1.02067344e-01f, 2.41842195e-02f, -1.24874406e-01f, 1.22931749e-01f, 7.01086074e-02f, -7.29782581e-02f, 2.44267695e-02f, 1.29765123e-01f, 5.45069203e-02f, 6.87527508e-02f,
  1.69806287e-01f, -1.22855846e-02f, -1.14893634e-02f, 9.87926349e-02f, 3.85427289e-02f, 2.49042772e-02f, -3.36521231e-02f, 4.31676172e-02f, 3.45207602e-02f, 5.34012020e-02f,
  -3.46917361e-02f, -1.06896171e-02f, 8.96579698e-02f, 2.34213956e-02f, -5.88043705e-02f, -9.20581222e-02f, 7.85017759e-02f, 1.18978597e-01f, -1.79335438e-02f, 9.00352839e-03f,
  9.21134278e-02f, 7.54475147e-02f, -7.05085471e-02f, 1.40426651e-01f, -7.05181295e-03f, 5.51629439e-02f, -6.41586110e-02f, 1.36338577e-01f, -5.42590506e-02f, -4.37207632e-02f,
  -1.19753890e-01f, -8.70454162e-02f, -4.09867279e-02f, -9.63068977e-02f, 2.99191056e-03f, 2.65550036e-02f, -1.24599069e-01f, 1.18633263e-01f, -8.14686716e-03f, -1.37826754e-02f,
  9.44410041e-02f, -8.18593253e-05f, -8.44506845e-02f, 5.58932908e-02f, 2.09348481e-02f, 3.66584188e-03f, 9.01874825e-02f, -5.99974096e-02f, 8.57358798e-02f, 2.96551306e-02f,
  1.06698394e-01f, 7.11662024e-02f, 1.04095072e-01f, -3.61689180e-02f, 1.25992358e-01f, -7.60403574e-02f, 6.18469901e-02f, 7.39403218e-02f, 9.41068341e-04f, 2.46016786e-01f,
  5.68277061e-01f, -1.89071760e-01f, -4.30283368e-01f, -3.64394411e-02f, -2.25972101e-01f, -6.28919825e-02f, -1.22203678e-01f, 6.54103309e-02f, 4.07767184e-02f, -2.32518524e-01f,
  -8.27720165e-02f, 1.52142555e-01f, 6.42663762e-02f, 9.70454291e-02f, 2.09310234e-01f, -1.83474123e-01f, -1.69347823e-01f, 6.77525550e-02f, 1.74634710e-01f, 9.78276879e-02f,
  -1.58660673e-02f, 9.03015286e-02f, 1.45714790e-01f, 1.70937199e-02f, -1.82520330e-01f, -4.29884195e-02f, -3.08010638e-01f, -5.32609485e-02f, -1.36298299e-01f, -3.08898240e-01f,
  -6.20654151e-02f, -8.69000927e-02f, 4.61303219e-02f, 8.01506191e-02f, -2.97725629e-02f, 1.24726526e-01f, -3.67904268e-02f, -6.91855177e-02f, 1.13483248e-02f, -1.15573086e-01f,
  3.00869793e-02f, -1.01283994e-02f, 1.65767856e-02f, -1.23141229e-01f, -2.09238455e-02f, 4.70203757e-02f, -1.25824481e-01f, -7.23167136e-02f, -6.59284964e-02f, -5.32828234e-02f,
  -1.01027362e-01f, -4.52569127e-02f, -6.13453686e-02f, -8.72891694e-02f, -1.21724159e-01f, -5.75034767e-02f, -1.97273344e-01f, -1.31672204e-01f, -3.92630557e-03f, -1.74142286e-01f,
  1.69282239e-02f, -7.06861839e-02f, -1.19582966e-01f, -2.42800135e-02f, 1.60997566e-02f, -6.60440549e-02f, 1.04477359e-02f, 2.68463958e-02f, -3.52141261e-02f, 1.06676400e-01f,
  1.64723638e-02f, -4.71723154e-02f, -2.46747453e-02f, -1.22010289e-02f, -2.97373105e-02f, 3.48972566e-02f, 1.67510081e-02f, 1.99725572e-02f, 7.79894888e-02f, 1.52895585e-01f,
  2.02161632e-02f, -6.16779365e-02f, 3.84099036e-02f, 6.13794662e-02f, 1.83304455e-02f, -5.39992042e-02f, 5.11737131e-02f, -2.85505001e-02f, 1.38921719e-02f, 7.53546208e-02f,
  2.57445604e-01f, -1.57651752e-02f, -3.59567665e-02f, 8.31062123e-02f, 9.16365162e-02f, -2.25547161e-02f, -8.24635327e-02f, -3.63574736e-02f, 4.98524308e-03f, 1.23896994e-01f,
  -4.74939607e-02f, 7.48361200e-02f, 2.10928861e-02f, -1.76644977e-02f, 2.91467533e-02f, -6.58172071e-02f, 5.81684224e-02f, 1.20892905e-01f, -1.74603541e-03f, -7.51159340e-02f,
  3.62040028e-02f, 1.13334030e-01f, 1.97942644e-01f, 4.76331003e-02f, 2.24664733e-02f, 1.48101479e-01f, -1.45048320e-01f, -6.84051439e-02f, 1.71083227e-01f, 1.35251194e-01f,
  3.80889088e-01f, -5.00562415e-02f, -3.32360983e-01f, 1.29324263e-02f, -1.84516862e-01f, -1.85473591e-01f, -1.64012015e-01f, 5.19470423e-02f, 5.53989895e-02f, -9.51953381e-02f,
  4.92775962e-02f, 2.09844992e-01f, 1.07261300e-01f, -4.14281115e-02f, -1.01918476e-02f, -2.70261586e-01f, -2.99950302e-01f, -1.60514772e-01f, -1.10432461e-01f, -6.62920699e-02f,
  -1.09576315e-01f, -1.28119051e-01f, 7.25030303e-02f, -4.28787358e-02f, -7.15775341e-02f, -1.77610844e-01f, -2.95411617e-01f, -2.27472410e-01f, -2.33842701e-01f, -2.59132475e-01f,
  -1.53851479e-01f, 4.52977372e-03f, -1.25719402e-02f, 9.44446847e-02f, -7.59036392e-02f, 1.70943603e-01f, 2.63216384e-02f, 6.84945881e-02f, 1.78181544e-01f, -1.82631426e-02f,
  -1.92630775e-02f, 1.09869361e-01f, 1.45513602e-02f, -8.72275606e-02f, -1.01318195e-01f, 2.48227194e-02f, 8.73584952e-03f, 8.01834017e-02f, 6.37868717e-02f, 1.75783283e-03f,
  1.35837272e-01f, 4.60430048e-02f, 1.10959157e-03f, 1.70067903e-02f, 4.27259468e-02f, -2.52403710e-02f, -1.20930947e-01f, -1.31371349e-01f, -8.76400098e-02f, -1.60587057e-01f,
  9.99239236e-02f, 1.04915068e-01f, 2.12695114e-02f, 7.13308230e-02f, 1.10205889e-01f, 1.50925651e-01f, 2.07319800e-02f, 1.90581884e-02f, 1.54001554e-02f, -1.79418251e-02f,
  1.71497073e-02f, 1.87814049e-02f, 8.57357457e-02f, 7.45916143e-02f, 8.01623426e-03f, 3.09431646e-02f, 1.96653623e-02f, 2.03924384e-02f, 1.17236845e-01f, 9.57595631e-02f,
  4.13421765e-02f, 4.58051935e-02f, -3.17554511e-02f, -3.84544171e-02f, -5.82219101e-03f, 2.99085886e-03f, 6.62272424e-02f, 2.37685535e-02f, 9.64927003e-02f, 7.78178405e-03f,
  3.05737127e-02f, 9.65737700e-02f, 7.90872797e-03f, 1.67901553e-02f, -4.63818349e-02f, -4.16678265e-02f, 5.75221740e-02f, 8.38842019e-02f, -5.89093529e-02f, 2.81394254e-02f,
  -3.91889140e-02f, 4.68038470e-02f, 1.13632612e-01f, 5.04988506e-02f, 1.48847848e-02f, -1.99431740e-02f, 9.66115594e-02f, 5.37354052e-02f, 1.14659443e-01f, -3.29463854e-02f,
  1.80942446e-01f, 1.07901812e-01f, 1.47967637e-01f, 1.91498343e-02f, 5.01460768e-02f, 1.38559058e-01f, 1.42910825e-02f, -6.22761995e-02f, -1.22952908e-02f, 5.47439419e-02f,
  3.00341755e-01f, 5.86239062e-02f, 1.60681486e-01f, -6.40549883e-02f, -2.02281564e-01f, -2.73409728e-02f, -2.93250401e-02f, -5.16081229e-02f, -2.19844375e-02f, 2.23068390e-02f,
  -8.98201987e-02f, -2.55889148e-02f, 4.17689756e-02f, 2.78485268e-02f, 8.76211822e-02f, 2.96022147e-02f, 3.39552388e-03f, 1.70638293e-01f, 1.50110066e-01f, -6.82473257e-02f,
  -1.30273074e-01f, -6.02005050e-02f, 1.39387816e-01f, 7.27908537e-02f, 4.75031361e-02f, -3.95156555e-02f, -1.89121906e-02f, -1.27641130e-02f, -1.39329757e-03f, 6.37169322e-03f,
  1.93107158e-01f, 9.51402560e-02f, -2.85874996e-02f, -4.45596725e-02f, -1.45447208e-02f, 1.80321056e-02f, 2.38894559e-02f, -5.08225411e-02f, -6.26497194e-02f, -3.68749499e-02f,
  -1.77119281e-02f, -7.49578252e-02f, -1.09803654e-01f, -2.06213035e-02f, -1.13862008e-01f, -2.49665566e-02f, 8.47668946e-03f, -4.86906767e-02f, 2.01798975e-02f, -7.45373173e-03f,
  -1.47863761e-01f, -3.45917419e-02f, -1.00118835e-02f, 9.42464394e-04f, -5.63523062e-02f, -7.93775246e-02f, -4.08550166e-02f, -3.23415361e-02f, 6.92226067e-02f, -1.09326160e-02f,
  -3.44661586e-02f, 8.88722986e-02f, -1.13775637e-02f, 1.73305608e-02f, -2.88301744e-02f, -5.67853637e-02f, -8.38236734e-02f, 2.39547864e-02f, -3.70908063e-03f, -3.62889506e-02f,
  -3.20237912e-02f, -8.57081935e-02f, -4.41391356e-02f, 5.01076430e-02f, 3.36775966e-02f, -4.88186181e-02f, -4.78476100e-02f, 2.10026167e-02f, -1.62028316e-02f, -3.67035605e-02f,
  4.49707638e-03f, -5.17403074e-02f, 5.07538430e-02f, -3.47309723e-03f, -1.28581952e-02f, -1.32852106e-03f, -9.00540799e-02f, 1.03464965e-02f, -8.86989832e-02f, 1.29277091e-02f,
  -1.01487376e-01f, -3.79188359e-02f, -9.05082822e-02f, 7.27678314e-02f, -2.61509269e-02f, -1.34050287e-02f, 2.68862769e-02f, -2.36287918e-02f, -1.53398318e-02f, 5.02239205e-02f,
  -1.54686561e-02f, 3.49110998e-02f, 5.72093129e-02f, -7.83411935e-02f, -6.87237503e-03f, -1.05155878e-01f, -5.12977391e-02f, 1.35610662e-02f, -5.37505075e-02f, 1.28632654e-02f,
  -6.43388480e-02f, -5.82377948e-02f, -1.17126636e-01f, -8.27401802e-02f, -1.33621469e-02f, -8.22781473e-02f, 1.58463828e-02f, -5.00900522e-02f, -6.45430163e-02f, -7.08913803e-02f,
  -3.72589350e-01f, 4.76866327e-02f, 3.00517865e-02f, 2.32315749e-01f, 1.55264929e-01f, -6.35783896e-02f, -3.10791939e-01f, -1.71180218e-01f, -2.02055052e-02f, -4.80915047e-02f,
  -8.82623438e-03f, 6.46543354e-02f, 1.25744000e-01f, 1.25747576e-01f, -1.31613851e-01f, 3.50288004e-02f, 2.16428578e-01f, 5.49040437e-02f, -1.11878745e-01f, -1.94510855e-02f,
  1.43343538e-01f, 1.23056248e-01f, -3.93554345e-02f, 6.35882914e-02f, 2.89860696e-01f, 7.72769600e-02f, 1.00987598e-01f, 1.24448299e-01f, 8.47079158e-02f, 3.68753135e-01f,
  3.17655667e-03f, -1.18543297e-01f, 6.96021542e-02f, 5.88806830e-02f, -6.48559108e-02f, -1.51232213e-01f, -4.10643555e-02f, 5.09908088e-02f, 1.51442643e-02f, -5.82817979e-02f,
  9.07099247e-02f, -9.85605940e-02f, 4.21131700e-02f, -4.86283191e-02f, -1.24053292e-01f, -2.98698068e-01f, -1.29747286e-01f, -1.04227453e-01f, -1.63102359e-01f, -2.09687531e-01f,
  1.15517922e-01f, 1.03638187e-01f, -9.54785347e-02f, -2.24888071e-01f, -1.89103708e-01f, -5.17424792e-02f, -2.22834691e-01f, -2.03009322e-01f, -3.73408258e-01f, -1.18313968e-01f,
  -1.54933423e-01f, -1.30946532e-01f, -4.66167592e-02f, 4.93148156e-02f, -1.43267721e-01f, 5.11731617e-02f, 1.12348475e-01f, 5.83853237e-02f, 4.23039449e-03f, 4.27010842e-02f,
  -1.55709055e-03f, -3.01709026e-02f, 1.18700415e-02f, -3.93316709e-02f, 7.52437785e-02f, 9.90562364e-02f, 2.74675321e-02f, -1.89268719e-02f, -8.90329704e-02f, -1.18890606e-01f,
  4.94238734e-02f, 1.23135008e-01f, 1.51527286e-01f, 3.07811406e-02f, -2.61516590e-02f, 2.93702539e-03f, 9.11062770e-03f, -2.78625861e-02f, -7.35981837e-02f, -7.36388341e-02f,
  -1.05092756e-01f, -5.71218086e-03f, 6.29412904e-02f, -4.54824138e-03f, 1.47960354e-02f, -8.22745487e-02f, 6.90325582e-03f, 9.32132825e-03f, -1.69027355e-02f, -1.50755018e-01f,
  -1.05589792e-01f, -1.28538102e-01f, 8.45545456e-02f, 2.63397302e-02f, -7.48882368e-02f, 4.71709296e-02f, -9.57735404e-02f, 5.17610870e-02f, 1.01128696e-02f, -4.55550291e-02f,
  6.65681884e-02f, -6.57405704e-02f, -4.35639024e-02f, -1.10888541e-01f, -6.05797954e-02f, -7.84040615e-02f, -2.39069723e-02f, -2.71227267e-02f, -2.34523609e-01f, -2.32887164e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.70543206e-01f, 1.82573557e-01f, 3.05820227e-01f, 2.52810001e-01f, 2.57800370e-01f, 2.96901077e-01f, 2.76752770e-01f, 2.77221918e-01f, 2.65038520e-01f, 3.83563668e-01f,
  4.36725408e-01f, -2.91695267e-01f, 3.46475810e-01f, 2.91558266e-01f, 2.27554858e-01f, 1.34948939e-01f, 3.21284711e-01f, 1.45042129e-02f, 2.04556137e-01f, 1.54563412e-01f,
  2.42842406e-01f, 3.32190275e-01f, 3.75982910e-01f, 4.08368468e-01f, 2.58910030e-01f, 1.29029438e-01f, -1.44029465e-02f, 3.09145689e-01f, 1.30116254e-01f, 2.86044180e-01f,
  3.70766163e-01f, 3.15776944e-01f, 3.09315085e-01f, 3.86032224e-01f, 2.46165767e-01f, 2.58686453e-01f, 1.19321562e-01f, 2.81935811e-01f, 8.80638063e-02f, 2.45429784e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.82120179e-02f, 3.29984725e-02f, -1.94361364e-03f, 2.77311374e-02f, -1.47035465e-01f, -6.59863353e-02f, 4.28924374e-02f, 1.21631913e-01f, -1.26641631e-01f, -2.25588474e-02f,
  2.55898014e-02f, 3.39532159e-02f, -2.89495271e-02f, -8.99854302e-03f, 1.41840458e-01f, 7.27351010e-02f, 1.27761394e-01f, 6.06787950e-02f, -1.39195248e-01f, 1.80234388e-01f,
  3.90833169e-02f, 6.81274682e-02f, 1.53200462e-01f, 7.20388070e-02f, -3.74538720e-01f, -9.36667994e-03f, 3.06701334e-03f, 1.89765200e-01f, -2.17056334e-01f, 1.22297302e-01f,
  1.78219825e-01f, -2.11141147e-02f, 7.99937770e-02f, -7.81399198e-03f, 1.03595912e-01f, -1.47563338e-01f, -1.30127864e-02f, 6.80257380e-02f, 1.79645702e-01f, 1.92857355e-01f,
  7.86907002e-02f, 2.40374766e-02f, -3.34737487e-02f, -7.13833794e-02f, -1.47243723e-01f, -2.75921822e-01f, -6.71401769e-02f, 5.60057089e-02f, 6.16452917e-02f, 2.00298801e-01f,
  -5.50038889e-02f, -1.41960099e-01f, -5.06779402e-02f, 6.71114540e-04f, -1.53518930e-01f, -2.94203103e-01f, 8.00042301e-02f, 1.25802979e-01f, 9.24706534e-02f, -1.28279194e-01f,
  -9.76149812e-02f, 3.90610881e-02f, -2.45592538e-02f, 2.22042426e-01f, -2.73701791e-02f, 1.20428339e-01f, -6.93135113e-02f, -4.48289514e-02f, -5.99742979e-02f, 2.28383821e-02f,
  2.32830904e-02f, -4.70739007e-02f, -8.38097185e-02f, -4.86147963e-02f, -1.20366618e-01f, 7.33121019e-03f, -1.05608061e-01f, 1.08421490e-01f, 6.52579367e-02f, -7.51733407e-02f,
  4.88682017e-02f, 7.19135813e-03f, -6.98131742e-03f, 9.28839073e-02f, -9.67635363e-02f, 6.20212778e-02f, -3.33726080e-03f, -6.23886809e-02f, -8.53657871e-02f, -1.98242277e-01f,
  -8.64196476e-03f, 1.13900706e-01f, 2.53060367e-02f, 1.63277909e-01f, 1.30612599e-02f, -6.25351965e-02f, 1.27836421e-01f, -1.33896276e-01f, -3.22974354e-01f, 9.14137959e-02f,
  1.19194508e-01f, 3.50343948e-03f, -1.74087852e-01f, 1.17022591e-03f, -2.34789848e-01f, -3.57464068e-02f, -1.47852570e-01f, 1.51664838e-01f, 1.27016008e-01f, -1.02445140e-01f,
  1.94315374e-01f, -2.19730705e-01f, -1.04871765e-01f, -1.62099712e-02f, 1.50303200e-01f, 1.51904896e-01f, 1.87495276e-01f, 7.32644722e-02f, 1.15573667e-01f, 2.57540673e-01f,
  -5.17862029e-02f, 1.14641748e-01f, 3.14846337e-02f, 2.14965388e-01f, 1.87948510e-01f, 1.14565104e-01f, -5.37779257e-02f, -1.25687718e-01f, -6.15495592e-02f, -6.27456307e-02f,
  1.20709486e-01f, -3.94517779e-02f, -3.87170576e-02f, 8.55563208e-02f, 2.80582495e-02f, 8.33251700e-02f, 8.84213019e-03f, 5.21386601e-02f, -4.94210273e-02f, -1.34572074e-01f,
  -3.66201885e-02f, 7.19447108e-03f, 1.57699451e-01f, -9.42292213e-02f, 1.50059611e-01f, -1.48453452e-02f, -5.21650985e-02f, 1.64298654e-01f, 9.22929794e-02f, 9.23165008e-02f,
  -3.28183025e-02f, -5.63111566e-02f, 9.40436423e-02f, -1.61269516e-01f, -9.98138189e-02f, 2.55223393e-01f, 1.48480654e-01f, 1.26535147e-01f, 2.04775594e-02f, -7.12908581e-02f,
  -3.89921889e-02f, 2.13107392e-01f, -2.33405875e-03f, 1.63745716e-01f, -1.14250578e-01f, 7.56844580e-02f, 1.07866101e-01f, 1.02647424e-01f, -1.31915182e-01f, 1.16250232e-01f,
  7.79416561e-02f, -1.57276750e-01f, 4.18860689e-02f, 5.82676120e-02f, -2.27262750e-01f, -8.62829909e-02f, 3.00038625e-02f, 1.13622516e-01f, -1.04476167e-02f, 5.10722771e-02f,
  2.03841385e-02f, -1.71212003e-01f, 1.24828639e-02f, 7.65095502e-02f, 1.35690704e-01f, 3.45570706e-02f, 1.56652033e-01f, 2.06441313e-01f, 6.16635941e-02f, 8.60064104e-02f,
  -7.87595659e-02f, 1.45573139e-01f, 8.29946399e-02f, -7.17518106e-02f, -9.82380733e-02f, 1.03778113e-02f, -5.70648536e-02f, 4.33736816e-02f, -5.30731119e-02f, 8.71258676e-02f,
  -4.06151935e-02f, 5.38473986e-02f, -1.66686922e-01f, -6.24168478e-02f, 1.66499149e-03f, 2.34641492e-01f, -8.30099657e-02f, -5.53262457e-02f, 6.27903268e-02f, -6.47034943e-02f,
  -5.80701679e-02f, 1.11815646e-01f, -1.88274026e-01f, -6.65528998e-02f, 8.19595084e-02f, 5.69325909e-02f, 5.57149462e-02f, -2.10683852e-01f, -2.06503674e-01f, 8.21650103e-02f,
  8.87157246e-02f, -1.54167050e-02f, -2.30796531e-01f, -1.29216313e-01f, 8.94215703e-02f, -1.05472639e-01f, 2.36523394e-02f, -5.88198677e-02f, 1.93161041e-01f, 8.26082453e-02f,
  -1.11990653e-01f, -6.96360841e-02f, -1.14823103e-01f, -5.25246412e-02f, -5.15361503e-02f, 1.08148314e-01f, -6.25889525e-02f, 1.79933049e-02f, 3.09355319e-01f, -2.44913086e-01f,
  -8.71438086e-02f, 1.40046611e-01f, 1.78208262e-01f, -2.87972484e-02f, 5.04184030e-02f, 1.59858927e-01f, 3.34391385e-01f, 1.85838923e-01f, -9.11220014e-02f, -5.50866537e-02f,
  5.14232107e-02f, 2.32170239e-01f, 1.36589214e-01f, 1.13259159e-01f, -8.38383511e-02f, -1.30320609e-01f, 2.97251274e-03f, -4.43568975e-02f, -7.91448429e-02f, 3.18224393e-02f,
  6.36752811e-05f, -1.20007254e-01f, -2.89989896e-02f, -6.41851500e-02f, -1.14246709e-02f, 6.48515448e-02f, 6.88247457e-02f, -1.45637905e-02f, 4.53985818e-02f, -1.30825549e-01f,
  -6.77142143e-02f, -6.71059117e-02f, -4.12612408e-02f, 1.98335797e-02f, 5.54401502e-02f, -5.16815111e-02f, -3.52278054e-02f, -5.70980869e-02f, 1.36309102e-01f, -3.99768390e-02f,
  1.32977486e-01f, 1.68857664e-01f, 1.13459162e-01f, -3.68531466e-01f, 8.43131468e-02f, -2.40336329e-01f, -2.20744744e-01f, 1.09492369e-01f, 9.55405608e-02f, -7.46858865e-02f,
  2.55552918e-01f, -1.25161365e-01f, -5.30247055e-02f, 1.02565989e-01f, -9.16186906e-03f, -2.14572251e-01f, 5.33829965e-02f, 5.15903793e-02f, -2.26502523e-01f, -8.47728848e-02f,
  1.20551512e-01f, 6.56087697e-02f, 2.23092511e-01f, 1.84658214e-01f, 5.97517490e-02f, -1.84547544e-01f, -9.18372571e-02f, 7.10217431e-02f, -8.12032223e-02f, 2.42632285e-01f,
  2.68863086e-02f, -1.74932823e-01f, -6.50008321e-02f, -1.54555470e-01f, -1.95280373e-01f, -1.54302627e-01f, -1.39006406e-01f, -1.73770651e-01f, 3.23269106e-02f, 6.19926006e-02f,
  -4.94730994e-02f, -1.16085380e-01f, -1.24043658e-01f, -1.38409406e-01f, -4.27896231e-02f, -5.33462465e-02f, -2.72505917e-02f, -1.44791856e-01f, 1.02077000e-01f, -4.30691577e-02f,
  -1.81161940e-01f, -1.00333437e-01f, -7.45163634e-02f, -1.08234258e-03f, -5.50557785e-02f, -1.02401331e-01f, 4.12420444e-02f, 1.14535384e-01f, 2.10227873e-02f, 2.60236710e-01f,
  -1.43413380e-01f, -5.53838126e-02f, 5.02874255e-02f, -8.32011476e-02f, 7.85138160e-02f, -4.12079096e-02f, -2.07787588e-01f, 4.28473082e-04f, 2.55770534e-01f, -2.06382692e-01f,
  -2.83405297e-02f, 1.47165269e-01f, -9.14749131e-02f, -1.69428587e-01f, 1.99821204e-01f, 6.63576573e-02f, -2.51673087e-02f, -1.08916955e-02f, -2.61192564e-02f, 4.80899885e-02f,
  3.03365174e-03f, -1.76908717e-01f, 1.63524747e-01f, 2.79774312e-02f, -9.23484042e-02f, 8.92891362e-02f, -3.18582240e-03f, -2.22941503e-01f, 9.82920304e-02f, 2.94230431e-01f,
  6.86563691e-03f, 1.46606058e-01f, -1.02949977e-01f, -1.59454253e-02f, -1.07040308e-01f, 5.18904515e-02f, -1.72854766e-01f, 1.16232902e-01f, 7.01528043e-03f, 1.49170935e-01f,
  -1.28531277e-01f, -1.64619833e-02f, -5.75987585e-02f, -2.61004455e-02f, -6.54993281e-02f, -2.59557297e-03f, -1.84743628e-01f, 1.67762101e-01f, -3.58870514e-02f, 3.20648625e-02f,
  -5.72682954e-02f, 1.01206288e-01f, 6.19202591e-02f, 8.54956061e-02f, 1.80740166e-03f, 1.89431608e-01f, 7.11561367e-02f, -9.07611176e-02f, -2.91867107e-02f, 9.98211578e-02f,
  2.77764909e-02f, -1.21292271e-01f, -3.47451940e-02f, -1.45729482e-01f, 3.21015231e-02f, -1.34596556e-01f, -7.74273872e-02f, 3.57646979e-02f, 1.66985601e-01f, -8.68725479e-02f,
  3.51667888e-02f, 2.32957244e-01f, 1.59397900e-01f, 6.76680878e-02f, -6.94707781e-02f, -1.39333323e-01f, -1.95851028e-01f, -1.02506638e-01f, -2.95294244e-02f, 6.35339553e-03f,
  4.77917269e-02f, -1.26711234e-01f, -2.70116422e-02f, -1.87590141e-02f, 1.37622803e-01f, 1.30134940e-01f, 5.84911928e-02f, 1.28709190e-02f, -1.75511790e-03f, 8.78392756e-02f,
  8.99302289e-02f, -8.09994191e-02f, 3.18495817e-02f, -2.87591964e-02f, -7.27985334e-03f, -1.77492052e-01f, -9.52279046e-02f, -7.32793957e-02f, 1.39714152e-01f, 9.08475369e-02f,
  -1.00278944e-01f, -7.76478574e-02f, 2.08014250e-01f, 1.31917581e-01f, 1.88067928e-01f, -1.13627464e-02f, -5.87016679e-02f, -1.12371705e-01f, -1.38037419e-02f, 1.58561495e-04f,
  2.20578592e-02f, -3.13383080e-02f, 6.86888397e-02f, -9.98107418e-02f, 3.23383398e-02f, 1.30613700e-01f, 2.51007043e-02f, 7.22022057e-02f, 1.03642337e-03f, 6.63521439e-02f,
  -1.83836669e-02f, -1.30994633e-01f, 8.61913636e-02f, 6.54704347e-02f, 3.92381661e-02f, -5.00301644e-02f, -2.03996021e-02f, -1.48745170e-02f, -6.90987259e-02f, 9.58371311e-02f,
  -1.14488147e-01f, 4.72970121e-03f, 2.05558628e-01f, 9.73920003e-02f, -1.85896590e-01f, 6.35431483e-02f, 3.84925045e-02f, 2.65944183e-01f, 2.00172160e-02f, -1.73139170e-01f,
  -3.02099083e-02f, 2.14009434e-01f, -2.84914047e-01f, 3.81105989e-02f, -1.72971580e-02f, -1.58918723e-02f, -1.88190088e-01f, -2.45154798e-02f, 2.39593387e-02f, 4.39982582e-03f,
  -5.37162870e-02f, -1.81641966e-01f, -1.24571428e-01f, -1.63727984e-01f, -1.50417656e-01f, 4.07755598e-02f, -1.67796776e-01f, 7.61074498e-02f, -1.08817875e-01f, -5.78781627e-02f,
  2.39732727e-01f, -1.03724442e-01f, 1.49358675e-01f, 2.61902720e-01f, 2.05974936e-01f, 2.46515330e-02f, 2.27503434e-01f, 1.43979505e-01f, 9.93052348e-02f, 8.54854286e-02f,
  9.93215442e-02f, -6.40353411e-02f, 1.42481208e-01f, 1.32351285e-02f, 1.91164017e-02f, 7.89894443e-03f, -8.70132539e-03f, -2.00477447e-02f, 3.14990878e-02f, 2.39685904e-02f,
  5.51654678e-03f, 4.74227779e-02f, -5.51801268e-03f, 3.65496688e-02f, 5.17554432e-02f, -9.01303887e-02f, -7.70830270e-03f, 2.91554015e-02f, -1.82253525e-01f, 1.75256319e-02f,
  1.47184893e-01f, -4.28201109e-02f, -1.88357774e-02f, 4.47732508e-02f, -1.94003712e-02f, 3.95631492e-02f, 3.08785170e-01f, 1.73589930e-01f, 1.04957692e-01f, -2.27324322e-01f,
  -4.79822755e-02f, 1.96069032e-01f, -8.44334960e-02f, -3.05249065e-01f, 1.85071696e-02f, 5.24510723e-03f, -2.67736673e-01f, 9.44079012e-02f, -1.07015498e-01f, 1.18866935e-01f,
  -2.88568258e-01f, -1.47864103e-01f, -2.36307144e-01f, -8.87783617e-02f, -2.85676032e-01f, 4.62383777e-03f, 1.97074875e-01f, -2.12973468e-02f, 4.53832969e-02f, 2.37950072e-01f,
  -1.26164421e-01f, -1.11355640e-01f, 1.89729542e-01f, 3.96780819e-02f, 5.26421368e-02f, 3.33608203e-02f, 1.60813749e-01f, 1.48979887e-01f, 1.00631520e-01f, -8.19132254e-02f,
  4.93432917e-02f, -8.46901685e-02f, 1.77191243e-01f, 5.90850823e-02f, 6.52259635e-03f, -1.64432853e-01f, -6.35026246e-02f, 1.37020037e-01f, 7.26122409e-02f, 1.61870327e-02f,
  -1.19673191e-02f, 1.46461517e-01f, -6.56994730e-02f, -3.82304825e-02f, 1.49487123e-01f, 2.93013025e-02f, -7.01680174e-03f, 1.76068302e-02f, -5.84223531e-02f, 5.85693978e-02f,
  1.95558041e-01f, 1.58147011e-02f, 1.24524549e-01f, 4.84153368e-02f, -1.76855236e-01f, 1.23491384e-01f, 9.08117462e-03f, 1.33973043e-02f, -1.84193645e-02f, 5.91571666e-02f,
  1.76191166e-01f, -2.11131319e-01f, -1.37069002e-02f, 2.53949583e-01f, 6.26452342e-02f, 1.35021374e-01f, -5.76356892e-03f, -1.09139889e-01f, 2.95621250e-02f, -6.62172865e-03f,
  -3.06386501e-01f, 8.56523365e-02f, -1.88575968e-01f, -4.88208421e-02f, 2.22092941e-02f, 1.25838801e-01f, 2.68253256e-02f, 1.21334992e-01f, 8.67828503e-02f, 7.42271617e-02f,
  -6.91672340e-02f, 1.65330052e-01f, -5.28038479e-02f, -4.85257916e-02f, -2.62482405e-01f, 9.79033560e-02f, -4.84431088e-02f, 9.36940834e-02f, -9.29325912e-03f, -7.59746805e-02f,
  2.66630948e-02f, 3.09755802e-01f, 4.28576097e-02f, -1.14821130e-02f, 3.30915041e-02f, 2.19213396e-01f, 4.84539606e-02f, 1.39219865e-01f, -1.22345805e-01f, 5.64034320e-02f,
  1.96563210e-02f, 5.13585247e-02f, -1.35113318e-02f, -1.55218393e-01f, 7.88303763e-02f, 9.18843299e-02f, 4.78882827e-02f, -4.56224941e-02f, 1.23503111e-01f, -1.15241773e-01f,
  9.96615142e-02f, -2.09595207e-02f, -6.08856119e-02f, -8.74481350e-02f, 7.82402083e-02f, -1.32226348e-01f, 9.25601199e-02f, 1.42683297e-01f, -1.79602370e-01f, 1.35180011e-01f,
  -7.79305920e-02f, 6.77904934e-02f, 4.94409353e-02f, -1.19835101e-01f, 1.29311532e-01f, -1.40605316e-01f, 5.06236814e-02f, 1.92268372e-01f, 1.18213184e-01f, -1.19347438e-01f,
  6.79713711e-02f, 2.98680633e-01f, 5.29268896e-03f, -8.34210142e-02f, 1.24776289e-01f, 6.24869131e-02f, -2.01302662e-01f, -2.08947193e-02f, 2.92561948e-01f, 1.55087709e-01f,
  7.40758181e-02f, 6.83274877e-04f, 2.90670902e-01f, 6.35902286e-02f, -2.27889046e-01f, 1.75462440e-01f, -5.49925156e-02f, -1.17551714e-01f, 1.69440463e-01f, 1.11265361e-01f,
  -2.07606643e-01f, 1.23608485e-01f, -1.03844352e-01f, -7.33600482e-02f, -2.24835604e-01f, 3.44979577e-02f, -1.81876048e-01f, 8.19784403e-02f, 1.59071125e-02f, 6.55342340e-02f,
  -1.75314695e-01f, -1.12668774e-03f, -1.88841615e-02f, 1.58520356e-01f, -6.93664104e-02f, 1.18700555e-02f, -1.14173710e-01f, -1.73541889e-01f, -2.13777229e-01f, -1.76912174e-02f,
  5.24409488e-02f, 2.94827968e-02f, -1.18472263e-01f, 6.18780442e-02f, -5.60616702e-03f, -4.08792449e-03f, 1.70291096e-01f, 2.75280755e-02f, 6.97807223e-02f, 5.98554723e-02f,
  1.30395293e-01f, -7.33043924e-02f, -2.94792831e-01f, 6.30022436e-02f, -3.15081216e-02f, 5.47190085e-02f, 1.89648211e-01f, 7.67914206e-02f, -2.37249613e-01f, -8.55973437e-02f,
  -5.33390418e-02f, 2.91731596e-01f, -1.28707260e-01f, 7.97017589e-02f, 2.08150059e-01f, -7.38222599e-02f, -1.82394817e-01f, -1.52378641e-02f, -4.89636231e-03f, -1.30221933e-01f,
  1.93587542e-01f, 2.04966478e-02f, 1.22021504e-01f, 1.29980326e-01f, 2.00249672e-01f, -8.20119530e-02f, 1.18784178e-02f, -3.54511775e-02f, -9.06701237e-02f, -1.16398104e-01f,
  1.60287485e-01f, -1.70952320e-01f, 7.82767609e-02f, 1.63155168e-01f, -1.02499477e-03f, -6.75370470e-02f, -1.24802448e-01f, -2.18197986e-01f, -1.45455524e-01f, -1.07212417e-01f,
  -5.02426550e-02f, 1.48285985e-01f, 8.89368206e-02f, 1.18245766e-01f, -7.70589486e-02f, 2.95274891e-02f, -1.54781744e-01f, 1.84281364e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.49624851e-02f, 1.28831193e-01f, 6.98873848e-02f, 8.06196779e-02f, 2.21666142e-01f, 1.83991432e-01f, 5.19033782e-02f, 8.85309279e-02f, -8.35361425e-03f, 7.70873204e-02f,
  7.97100291e-02f, 1.96732908e-01f, 3.92571613e-02f, -1.57341272e-01f, 3.59916314e-02f, 1.05678461e-01f, -1.53842539e-01f, -1.78010121e-01f, -6.93863556e-02f, -1.83391254e-02f,
  8.61973315e-03f, 6.44262061e-02f, 5.34461550e-02f, 1.63046181e-01f, -1.29334182e-01f, 2.00438991e-01f, -2.83004820e-01f, 3.14807862e-01f, -1.52996257e-01f, 2.19995439e-01f,
  4.52904403e-01f, 2.77464479e-01f, -4.47923765e-02f, 2.90562332e-01f, 4.34632078e-02f, -7.70099014e-02f, 2.24453434e-02f, 1.67780995e-01f, 4.30407971e-02f, 2.52235323e-01f,
  -1.13083288e-01f, -1.87814921e-01f, 1.30000487e-01f, -4.39315200e-01f, 9.90218446e-02f, -8.60852376e-02f, 6.16228348e-03f, 2.79169917e-01f, 2.90304214e-01f, 1.72530472e-01f,
  -1.05234059e-02f, -2.44562719e-02f, 1.47626167e-02f, -7.80173913e-02f, -3.39817822e-01f, -2.04391167e-01f, 1.65492967e-01f, 2.17331469e-01f, -2.22428724e-01f, -1.31572425e-01f,
  -5.92295937e-02f, 1.01051852e-01f, -1.92666370e-02f, 5.49096048e-01f, 2.74111070e-02f, -9.30121243e-02f, -8.01790059e-02f, -1.60317540e-01f, -1.42747967e-03f, -7.68674389e-02f,
  -8.89319479e-02f, -3.61562818e-02f, 2.14289725e-02f, -1.46004017e-02f, -1.08168952e-01f, 1.06502607e-01f, -5.52738719e-02f, 1.19370192e-01f, 1.75959110e-01f, 3.88418883e-02f,
  3.21703069e-02f, -3.50995325e-02f, -1.64949074e-02f, 1.86869040e-01f, -9.21627581e-02f, 4.56058234e-02f, -4.47699502e-02f, 1.96996648e-02f, 2.73981273e-01f, -5.38635664e-02f,
  -5.76625168e-02f, 1.04070306e-01f, 8.64088386e-02f, 5.39789200e-01f, 7.20371008e-02f, -2.63331175e-01f, 2.08685684e-04f, -1.01082459e-01f, -2.68800825e-01f, -2.22126082e-01f,
  -3.21825333e-02f, -6.22736439e-02f, -9.68845114e-02f, 1.17634267e-01f, -7.95463994e-02f, 1.00219935e-01f, 8.53996053e-02f, -1.39718533e-01f, -1.34833410e-01f, -8.94927531e-02f,
  2.48164177e-01f, -2.25112572e-01f, -2.03775272e-01f, -5.66119403e-02f, -2.10128039e-01f, -1.50193349e-01f, -3.47583555e-02f, 1.48791119e-01f, 2.14658961e-01f, 2.81178981e-01f,
  -1.66454777e-01f, 1.38181612e-01f, 2.13973433e-01f, 1.46858558e-01f, 3.50217253e-01f, 2.22831160e-01f, -4.47678156e-02f, -1.14613406e-01f, 1.41298652e-01f, -1.21975295e-01f,
  1.22509032e-01f, 7.23704100e-02f, 7.80874416e-02f, 1.71043184e-02f, 1.40247956e-01f, 2.54215628e-01f, -6.66067973e-02f, 1.23703890e-01f, 5.80916889e-02f, -6.14966825e-03f,
  1.16786761e-02f, -1.60580873e-01f, -1.21101506e-01f, 1.44865289e-01f, 1.58648342e-01f, -1.25856474e-01f, 1.00350074e-01f, -1.82601109e-01f, 1.91311032e-01f, -8.07487741e-02f,
  6.62691817e-02f, 5.33822291e-02f, 9.31223202e-03f, 1.50437325e-01f, -1.44423485e-01f, -1.94965169e-01f, -5.81951998e-02f, 1.25292614e-01f, 1.14166349e-01f, -5.25123626e-02f,
  8.68712068e-02f, 8.64675194e-02f, 3.47406328e-01f, 4.07032110e-02f, 2.42299885e-01f, 2.63429523e-01f, -1.06189482e-01f, -1.88569546e-01f, 5.13148978e-02f, -1.81167513e-01f,
  7.49400165e-03f, -2.77748406e-01f, 2.17099294e-01f, -1.75893772e-02f, -4.18221578e-02f, 2.03375906e-01f, -9.43473876e-02f, 6.32145181e-02f, 1.00152425e-01f, -2.77546227e-01f,
  -2.23718397e-02f, 4.36838344e-02f, -2.37738162e-01f, -2.74317712e-01f, 2.24994794e-01f, -7.93269649e-02f, 2.81938314e-01f, 1.95649683e-01f, 4.21761675e-03f, 1.37102455e-01f,
  2.19162017e-01f, -7.67924711e-02f, 1.22117504e-01f, 1.40109643e-01f, -1.41793340e-01f, 2.39603326e-01f, 2.49599665e-01f, 1.48084670e-01f, 1.27430335e-01f, 1.09244868e-01f,
  5.71102463e-02f, -4.40724427e-03f, 1.63753375e-01f, 4.16200310e-02f, 1.56225726e-01f, -1.58377901e-01f, -1.07018583e-01f, -2.65766885e-02f, -1.52263194e-01f, 1.36550546e-01f,
  -4.53415886e-03f, -2.48899624e-01f, 5.98881394e-02f, -2.08237872e-01f, 2.69509107e-01f, 1.97668597e-01f, 2.62405217e-01f, 2.66195953e-01f, 2.37571150e-02f, -1.85520589e-01f,
  1.61904588e-01f, -3.99004191e-01f, -2.24313036e-01f, 3.15453917e-01f, 1.66447610e-01f, 1.04056090e-01f, 1.81386575e-01f, -2.00818703e-01f, 3.57255071e-01f, 2.79964637e-02f,
  5.78064546e-02f, -5.61600691e-03f, -2.04447672e-01f, -1.40567526e-01f, 4.78461981e-02f, -8.28374922e-03f, 1.33029327e-01f, 3.59374166e-01f, 3.45643789e-01f, 4.35958415e-01f,
  -4.66209166e-02f, -3.31811875e-01f, 1.73782557e-01f, -7.00133666e-02f, -1.60408840e-02f, 1.15692019e-01f, 5.38669936e-02f, -3.63473266e-01f, 2.56530553e-01f, -2.28007033e-01f,
  1.04183815e-01f, 1.20931780e-02f, -1.82907119e-01f, -1.71703309e-01f, -5.58514334e-02f, 1.55871332e-01f, -1.30059347e-01f, 5.83439367e-03f, -7.44683668e-02f, -1.08905375e-01f,
  -9.16856620e-03f, 4.57093269e-02f, 8.39381292e-02f, -1.89033613e-01f, -1.23975806e-01f, -7.06827675e-04f, -2.08330471e-02f, 9.66526493e-02f, -1.26208775e-02f, -1.25496879e-01f,
  6.34849146e-02f, 1.54943755e-02f, 2.32530758e-02f, 6.87898486e-04f, 1.69187114e-01f, 1.16420351e-01f, -7.82119185e-02f, 5.25303967e-02f, -2.12356508e-01f, -9.81451645e-02f,
  2.13587239e-01f, -2.13721991e-01f, -1.31105512e-01f, 6.14399463e-02f, 1.26649842e-01f, 2.08960667e-01f, 1.33741468e-01f, -2.16151536e-01f, -5.23678325e-02f, -8.02076757e-02f,
  -1.12505794e-01f, 1.24856248e-01f, -1.89032912e-01f, -3.91596928e-02f, -2.36423478e-01f, 2.00964868e-01f, -1.94660246e-01f, 9.38254744e-02f, 1.45705193e-01f, 3.14026326e-01f,
  -1.18341781e-01f, 3.18062045e-02f, -1.22283332e-01f, 2.06519663e-01f, 8.38206112e-02f, 1.15406856e-01f, 9.77571085e-02f, 3.65124434e-01f, -2.98398379e-02f, -3.05735506e-02f,
  5.14597856e-02f, 1.37212008e-01f, -2.66500354e-01f, 2.26260677e-01f, -2.10178941e-02f, -3.89355458e-02f, 3.64861153e-02f, 1.53134495e-01f, 4.80062589e-02f, -1.22390417e-02f,
  5.07461987e-02f, 1.96814984e-01f, 1.46730334e-01f, 1.63275942e-01f, -1.16193974e-02f, 8.92122239e-02f, 2.93371435e-02f, 6.27080053e-02f, 8.59212577e-02f, 2.67715361e-02f,
  2.15055749e-01f, 3.74001861e-02f, -4.41150665e-02f, -2.23804060e-02f, 2.38335788e-01f, 7.97739178e-02f, 1.97032347e-01f, 1.30618826e-01f, -9.25136581e-02f, 1.41656652e-01f,
  1.63002893e-01f, 9.41351652e-02f, 5.11511751e-02f, -7.71525204e-02f, -1.82216018e-01f, -4.34754901e-02f, 2.84990072e-01f, 5.01789115e-02f, -2.58823633e-01f, 2.92024255e-01f,
  3.37462485e-01f, -2.31505245e-01f, -4.35741432e-02f, -3.03764958e-02f, -2.28944302e-01f, -1.54279456e-01f, -8.70719701e-02f, 2.30470553e-01f, 3.32499519e-02f, 3.64299752e-02f,
  1.15753770e-01f, -8.42006058e-02f, 1.01279870e-01f, 1.28915265e-01f, -1.47554651e-02f, 2.44888067e-02f, -3.54990929e-01f, -1.66173160e-01f, 2.63662543e-03f, 1.39380366e-01f,
  8.69874731e-02f, 1.06733285e-01f, 3.43574509e-02f, 1.67843819e-01f, 2.02986583e-01f, 1.79563969e-01f, 3.02730352e-01f, 1.36963595e-02f, 1.99204743e-01f, 1.93443388e-01f,
  1.80025473e-01f, 3.41410339e-01f, -3.96128483e-02f, -1.71419919e-01f, 2.87470650e-02f, 1.16500385e-01f, 1.61913604e-01f, 4.99561131e-02f, 2.26391554e-02f, 5.88002540e-02f,
  6.66726232e-02f, 7.70215839e-02f, 1.57517497e-03f, 6.61825836e-02f, -1.09144971e-01f, 6.81494400e-02f, 3.01309600e-02f, 1.49042709e-02f, 1.76470757e-01f, -3.90932225e-02f,
  9.60486531e-02f, -5.09891473e-02f, 1.22351581e-02f, 1.86248422e-01f, -5.84813133e-02f, 4.92006801e-02f, 3.43067832e-02f, -4.89978492e-02f, 8.24375600e-02f, -4.74406146e-02f,
  -3.05117574e-02f, 1.83116898e-01f, 2.25329503e-01f, 1.93876654e-01f, -1.09102450e-01f, 8.86182860e-02f, 1.03545271e-01f, -5.84194995e-02f, 1.00190215e-01f, 1.45564049e-01f,
  1.29786223e-01f, -1.29653424e-01f, 7.60396123e-02f, -4.96951267e-02f, -3.44567038e-02f, 1.47127435e-01f, 2.67600156e-02f, 4.92002219e-02f, -7.37047493e-02f, 3.65229174e-02f,
  3.65786478e-02f, -1.64358914e-01f, -1.73707306e-01f, 2.55741060e-01f, 1.48043424e-01f, -4.52537462e-02f, -7.70417750e-02f, 7.90401623e-02f, 1.10696763e-01f, 2.55563676e-01f,
  2.75839150e-01f, 1.39850646e-01f, 3.43487263e-01f, 1.65462986e-01f, 2.25907385e-01f, 1.37260765e-01f, -2.04411731e-03f, -2.62878160e-03f, 1.63168669e-01f, 7.76093453e-02f,
  -5.29000442e-03f, 6.97458610e-02f, 9.62049216e-02f, 1.98626742e-01f, 1.13411188e-01f, 1.51085019e-01f, 1.48693368e-01f, -4.54336368e-02f, 3.27161252e-02f, 8.04109275e-02f,
  -7.22103193e-02f, -6.28578886e-02f, 3.01009595e-01f, 2.36901775e-01f, -1.23386003e-01f, 1.65876061e-01f, 7.06996769e-02f, -3.51963053e-03f, -2.41363823e-01f, 2.39640161e-01f,
  -2.82967716e-01f, 1.23749174e-01f, 5.06813884e-01f, 3.99657845e-01f, 2.10097328e-01f, 6.84807682e-03f, 1.64889209e-02f, 2.70999938e-01f, -4.16698977e-02f, -2.20908672e-01f,
  -2.19281558e-02f, 1.48379847e-01f, -3.85224521e-01f, -1.54403299e-01f, -4.18017566e-01f, 2.19955757e-01f, 1.28461525e-01f, -7.38409208e-03f, -1.82067409e-01f, 1.95036978e-01f,
  -2.45729551e-01f, -1.45394206e-01f, -7.77611434e-02f, -8.34647790e-02f, 1.71628296e-02f, 2.06959873e-01f, -2.04796731e-01f, 9.68884211e-03f, 2.78886128e-02f, 8.36596340e-02f,
  9.57904905e-02f, 9.17861387e-02f, 2.17690140e-01f, 4.85969722e-01f, 4.79365289e-01f, 2.12033093e-02f, 1.13284208e-01f, -2.34267265e-02f, 2.35237479e-01f, 1.24340221e-01f,
  -1.13252765e-02f, 1.62601531e-01f, 1.14832424e-01f, -1.11928754e-01f, -8.64793882e-02f, 9.73155126e-02f, 2.26738974e-01f, -1.02946103e-01f, 1.03706218e-01f, 6.44354969e-02f,
  1.83188036e-01f, 2.86898334e-02f, 1.22918710e-01f, 1.58910587e-01f, 1.70232952e-01f, 5.03674671e-02f, -1.97001100e-01f, -6.84524477e-02f, -2.22179890e-01f, -1.73294142e-01f,
  2.79287905e-01f, -3.05352330e-01f, 2.45449215e-01f, -3.06290179e-01f, 3.13171521e-02f, 9.12274495e-02f, -2.07165912e-01f, 3.04327130e-01f, 1.92527997e-03f, -3.67027670e-01f,
  -1.18603267e-01f, 4.03572209e-02f, 6.54800236e-03f, -7.63925016e-02f, 4.01563533e-02f, -6.65724874e-02f, 3.79447592e-03f, 1.01555534e-01f, 4.31480229e-01f, 1.64426327e-01f,
  -1.95360214e-01f, -2.89368182e-01f, -8.81086141e-02f, -1.31979197e-01f, -1.68925911e-01f, -1.37636289e-01f, 8.75298455e-02f, -2.27249905e-01f, 2.38368407e-01f, 2.90908337e-01f,
  1.17810957e-01f, -1.61294546e-03f, 5.85691258e-02f, -2.07496852e-01f, -4.79606092e-02f, -2.29692031e-02f, 8.88882950e-02f, -4.45187569e-01f, 1.53307930e-01f, -9.93659571e-02f,
  1.78397611e-01f, -6.76382333e-02f, 1.24330722e-01f, -1.50390595e-01f, 2.12590937e-02f, 6.15532026e-02f, -4.55364101e-02f, 1.14970922e-01f, 1.09779350e-01f, -7.23947734e-02f,
  8.27465728e-02f, 2.10043207e-01f, 1.78175405e-01f, 1.50743991e-01f, 7.12232813e-02f, 4.98383818e-03f, 5.94961047e-02f, 9.18580219e-02f, 3.98757048e-02f, -5.57432920e-02f,
  5.17938435e-02f, -6.53579235e-02f, -4.94974442e-02f, -6.21481165e-02f, 9.41536799e-02f, 1.32114897e-02f, 4.65513058e-02f, -1.94311365e-02f, -1.87283278e-01f, -7.51112700e-02f,
  2.05634877e-01f, -1.12081334e-01f, -1.42882049e-01f, 1.78716198e-01f, -4.25082110e-02f, 1.77496940e-01f, 2.89735079e-01f, 4.09965292e-02f, -2.91253217e-02f, 9.99371037e-02f,
  -9.16126594e-02f, -8.42423365e-02f, -6.70590103e-02f, -1.10896342e-01f, -1.49287164e-01f, 1.63703203e-01f, -1.97746307e-02f, -1.16831392e-01f, 1.99770942e-01f, -1.59282982e-01f,
  -1.23935089e-01f, -8.25619400e-02f, -2.81929165e-01f, 4.07521904e-01f, 2.71800190e-01f, 2.80639194e-02f, -7.34348968e-02f, -1.35542750e-01f, -5.94021715e-02f, -1.71320289e-01f,
  6.94179609e-02f, -1.91046670e-02f, -1.23743467e-01f, 7.81786963e-02f, -1.47619799e-01f, -2.14956209e-01f, -1.20097607e-01f, 7.88086355e-02f, 5.98542741e-04f, 1.87578812e-01f,
  1.24753594e-01f, 1.18147641e-01f, -3.10169253e-02f, 1.19383335e-01f, 4.32441495e-02f, 1.14087239e-01f, -1.02128744e-01f, 1.69838354e-01f, 7.61755556e-02f, 4.79873866e-02f,
  1.39984250e-01f, -2.20425278e-02f, 7.28842393e-02f, 1.70293987e-01f, -1.23200096e-01f, 9.92238671e-02f, 9.23297703e-02f, -1.70899332e-01f, -1.57291852e-02f, -1.40837267e-01f,
  2.11392250e-02f, -4.36728038e-02f, -1.15428999e-01f, -3.78828496e-03f, 4.30190936e-02f, -3.29620019e-02f, -1.70439959e-01f, 1.49874270e-01f, 6.42233575e-03f, 4.16159034e-01f,
  -6.74329624e-02f, -2.75391251e-01f, 5.93142584e-02f, -1.28272459e-01f, -1.81939632e-01f, -8.00352395e-02f, 3.67551953e-01f, 1.35028392e-01f, 1.16603613e-01f, -7.87576586e-02f,
  6.18765019e-02f, -1.62727475e-01f, -1.61191523e-01f, 1.94017112e-01f, 1.66906118e-01f, -3.25121343e-01f, 3.32443357e-01f, -3.50945741e-01f, -2.94854548e-02f, 2.16114864e-01f,
  1.76661491e-01f, -2.30325758e-01f, 2.06155963e-02f, 4.68323752e-02f, 3.95548731e-01f, 2.39306644e-01f, 1.29373252e-01f, -2.61070170e-02f, 3.62522751e-01f, 2.61673570e-01f,
  3.94190162e-01f, 3.21040064e-01f, -1.00681111e-01f, 8.16117525e-02f, 1.90640837e-01f, 3.16240899e-02f, 5.24955988e-02f, 6.78287819e-02f, 9.29283798e-02f, 8.47699121e-03f,
  9.10944641e-02f, 2.45900884e-01f, 7.42108002e-02f, 2.20495209e-01f, 4.94861528e-02f, 2.35616602e-02f, -3.20551135e-02f, -1.78253315e-02f, -5.82294576e-02f, 1.50748134e-01f,
  2.44526282e-01f, -4.53743972e-02f, -7.50292540e-02f, -2.06997860e-02f, 1.12904169e-01f, 6.10659160e-02f, 1.32035002e-01f, -3.80411744e-02f, -7.58070201e-02f, -2.09090933e-01f,
  4.29658383e-01f, 4.68863584e-02f, 2.26868704e-01f, 1.47590294e-01f, -1.16069995e-01f, -7.07972199e-02f, -9.79699641e-02f, -1.81160390e-01f, 1.00731909e-01f, -9.88017619e-02f,
  2.43583977e-01f, 1.40469313e-01f, 3.11981171e-01f, 2.02667937e-02f, 5.44635952e-01f, -3.40767577e-02f, 1.44925103e-01f, 2.79418558e-01f, 1.66966040e-02f, 3.24580252e-01f,
  -6.13285936e-02f, -2.43834406e-01f, -4.85581486e-03f, -2.32890397e-02f, -4.53332186e-01f, 2.16775477e-01f, -1.55777112e-01f, -9.70953852e-02f, -2.99857169e-01f, 7.69771487e-02f,
  -1.53331205e-01f, 5.86404987e-02f, 1.82816893e-01f, 4.48863029e-01f, 5.54856919e-02f, 2.64055133e-01f, 1.63438134e-02f, -2.57766783e-01f, 5.19882850e-02f, 1.07117772e-01f,
  8.22306052e-02f, 6.72325790e-02f, 1.24025092e-01f, 5.45038991e-02f, 3.00403424e-02f, 4.47408631e-02f, 1.23693325e-01f, -7.91327879e-02f, 1.29847005e-01f, 1.34391189e-01f,
  -9.24165919e-02f, -1.45644084e-01f, 3.74140888e-02f, 2.46606357e-02f, -1.22751467e-01f, 3.32665071e-02f, 6.15777932e-02f, -8.38562399e-02f, 4.90055270e-02f, 3.39493342e-02f,
  4.57163341e-02f, -1.22396816e-02f, 5.30434959e-02f, 2.17602894e-01f, 1.74194783e-01f, 7.44950399e-03f, -5.59496582e-02f, -5.88436313e-02f, 2.50350803e-01f, 4.50650863e-02f,
  1.55087039e-01f, 1.60280988e-02f, -2.78507285e-02f, -2.64114290e-01f, 9.80543494e-02f, 2.56551355e-02f, 7.89012387e-02f, 1.32675827e-01f, 1.33736134e-01f, -1.17110133e-01f,
  1.09951580e-02f, -5.95406070e-02f, 4.18190397e-02f, 2.27705967e-02f, 2.16878191e-01f, 3.35791737e-01f, -6.91993767e-03f, -1.60567418e-01f, 1.62269428e-01f, -4.07936536e-02f,
  -1.72366761e-02f, 1.03066914e-01f, 6.52150437e-02f, -2.00108096e-01f, 2.85082787e-01f, 1.06635697e-01f, -9.24371183e-02f, -2.33580858e-01f, -5.05262017e-02f, -4.11624163e-02f,
  2.02500056e-02f, 3.59806329e-01f, -1.86070334e-03f, 1.24693222e-01f, 1.98719963e-01f, 2.03685492e-01f, 1.22442484e-01f, -2.06337310e-03f, 2.04381064e-01f, 5.94124980e-02f,
  1.61124676e-01f, 5.17896079e-02f, 3.05616278e-02f, 1.20392948e-01f, 6.92684576e-02f, -1.43629551e-01f, -1.02496788e-01f, -4.34335396e-02f, -1.21517070e-01f, -2.05117445e-02f,
  7.10624233e-02f, -4.59383279e-02f, 2.68296927e-01f, -2.14741379e-02f, -2.86906380e-02f, 4.72154953e-02f, -5.18233538e-01f, 1.61970988e-01f, 2.18438908e-01f, -4.94023524e-02f,
  -2.07639560e-01f, 3.04473221e-01f, 3.27920169e-01f, -2.26128384e-01f, -1.33227766e-01f, -5.15625514e-02f, 1.20076779e-02f, 8.17319676e-02f, 3.03636193e-01f, 3.68605733e-01f,
  1.40976444e-01f, 3.30916233e-02f, 3.44907165e-01f, -7.98152909e-02f, 4.54700254e-02f, 1.21979184e-01f, 2.31159508e-01f, 1.68891400e-02f, 1.87961161e-01f, 1.00399159e-01f,
  2.55674034e-01f, 8.63560364e-02f, 1.49696767e-01f, -1.02884725e-01f, -2.73550022e-02f, -1.21413678e-01f, -6.67917356e-02f, -2.93974966e-01f, 1.18250661e-01f, 3.45196319e-03f,
  2.00980827e-01f, 1.39808416e-01f, 2.19624881e-02f, 2.71191120e-01f, -4.07922408e-03f, -3.09267994e-02f, 1.15766466e-01f, 1.92591041e-01f, 1.30183890e-01f, -1.42174020e-01f,
  1.02175519e-01f, -5.45639172e-02f, -1.57575727e-01f, 1.67289540e-01f, 2.34786138e-01f, 1.21003404e-01f, 1.64936379e-01f, 7.43845925e-02f, 1.49835065e-01f, 1.85744748e-01f,
  -4.41681370e-02f, -1.96147189e-01f, 2.05047205e-01f, 1.33597821e-01f, -1.03987105e-01f, -2.47072697e-01f, 1.12781063e-01f, 2.80681867e-02f, -1.98289175e-02f, 2.67220731e-03f,
  -1.57619655e-01f, 7.32587278e-02f, -6.09885789e-02f, 1.66475698e-01f, 4.43897918e-02f, -1.06642600e-02f, -1.46174263e-02f, 1.50290713e-01f, 2.53883898e-01f, -2.72066891e-01f,
  2.18702659e-01f, 1.54208541e-02f, 2.51215369e-01f, -1.19449280e-01f, 3.27098876e-01f, -2.61727497e-02f, 1.39947414e-01f, -1.31834745e-01f, -6.43442199e-02f, 1.70978438e-02f,
  1.45239696e-01f, -1.58310935e-01f, 2.94654220e-01f, -2.26696134e-01f, 2.68106580e-01f, 2.02229634e-01f, -6.14314433e-03f, 1.07997410e-01f, 1.23413816e-01f, 1.61839843e-01f,
  -5.64477779e-02f, -3.67996544e-02f, -1.68704778e-01f, -3.52793448e-02f, 1.82625443e-01f, 1.25277087e-01f, 1.74436092e-01f, 2.22118478e-02f, -1.57895863e-01f, 2.63161123e-01f,
  1.61781743e-01f, 1.40732005e-01f, -1.24852555e-02f, 1.09662488e-01f, 2.25475565e-01f, 1.02265306e-01f, 1.53137967e-01f, 1.71488062e-01f, 1.29192129e-01f, -9.99223292e-02f,
  2.01564938e-01f, 2.36317098e-01f, -7.10725114e-02f, -1.32390559e-01f, 1.32163137e-01f, 4.75584567e-02f, -1.86370373e-01f, -2.61440277e-02f, 5.05676027e-03f, -5.02832271e-02f,
  -1.57536790e-01f, 2.08513454e-01f, -1.04505681e-01f, 6.60504028e-02f, 1.56331643e-01f, 1.47192627e-01f, 1.21353172e-01f, 2.81831592e-01f, -6.90857992e-02f, 3.11267704e-01f,
  2.63278723e-01f, -6.91402853e-02f, 1.46469072e-01f, 4.29105192e-01f, -4.05281335e-01f, 2.90308427e-03f, -5.58128394e-02f, 1.38057441e-01f, 2.34131087e-02f, 1.73126280e-01f,
  -2.56881833e-01f, 1.34028971e-01f, -6.12601042e-02f, -9.47143510e-02f, 1.20307237e-01f, -7.20597804e-02f, 2.73095340e-01f, 2.42079213e-01f, -2.37651132e-02f, -1.47358969e-01f,
  -2.97375992e-02f, -8.26123133e-02f, 7.98698291e-02f, -2.81480402e-02f, 3.48485738e-01f, 3.28227609e-01f, 4.41449970e-01f, 1.81847423e-01f, -2.05229293e-03f, 1.69655110e-03f,
  9.48708057e-02f, 5.21736220e-02f, 5.54523468e-02f, 8.98468792e-02f, 1.94405075e-02f, 1.29924446e-01f, -4.63932566e-02f, -2.90672947e-02f, 4.38903570e-02f, 8.78118873e-02f,
  -5.87884188e-02f, 3.79714146e-02f, 1.13151371e-02f, 3.14963236e-02f, -4.84380387e-02f, -3.96040045e-02f, 1.81413084e-01f, 2.86104202e-01f, 1.23106591e-01f, 1.56027833e-02f,
  -1.11117095e-01f, 2.13472486e-01f, 2.11727135e-02f, 3.35412957e-02f, -2.65744179e-01f, -2.72939317e-02f, -1.98394179e-01f, 4.86779213e-02f, 6.52599096e-01f, 1.71631858e-01f,
  2.22383261e-01f, 6.08820915e-02f, 2.98333466e-01f, -7.38758361e-03f, -4.26319361e-01f, 7.57566765e-02f, 1.02851540e-01f, 5.55512160e-02f, -1.79005377e-02f, -4.05863412e-02f,
  -1.45386860e-01f, -5.52694350e-02f, 1.71334207e-01f, -8.00472051e-02f, -1.30570859e-01f, 2.01070279e-01f, -1.15851080e-02f, 1.00270234e-01f, -1.75764009e-01f, 1.88965932e-01f,
  2.99751937e-01f, -1.00871943e-01f, 2.24001482e-02f, 1.42806098e-01f, -8.25662725e-03f, 1.72606818e-02f, 2.13178143e-01f, 1.31573856e-01f, 3.01357865e-01f, 3.56701523e-01f,
  1.69553518e-01f, -1.52936459e-01f, 2.11520493e-02f, -3.95129919e-02f, 2.42049813e-01f, -1.00332670e-01f, 4.76491675e-02f, 3.71561907e-02f, -3.90672982e-02f, 2.93017346e-02f,
  1.14654504e-01f, 1.05319783e-01f, 3.81880179e-02f, -4.92656417e-02f, 1.43185526e-01f, 5.52601367e-03f, -2.27184407e-03f, -9.71081182e-02f, 1.92820594e-01f, 4.64199930e-02f,
  1.12619974e-01f, 9.82020125e-02f, 1.16314523e-01f, -1.34730741e-01f, -7.57036954e-02f, 9.41380560e-02f, -3.02115411e-01f, -1.18003506e-02f, -1.46963418e-01f, 2.53176868e-01f,
  1.12508915e-01f, 1.92765221e-01f, -3.22460055e-01f, 1.19358294e-01f, 1.28756985e-01f, 6.96781576e-02f, -1.00707024e-01f, 1.33510947e-01f, 2.48776957e-01f, 5.09896725e-02f,
  -4.08904031e-02f, 1.08888887e-01f, -1.16456235e-02f, 7.49111027e-02f, -2.72994161e-01f, 2.55153209e-01f, 3.29271257e-01f, 2.48488754e-01f, 9.41824317e-02f, -1.38213098e-01f,
  6.56015426e-02f, 9.52023491e-02f, 6.00382946e-02f, 1.58119686e-02f, -2.23798528e-01f, 1.36252763e-02f, -1.10053979e-01f, 2.15999916e-01f, -7.22800270e-02f, 2.98092782e-01f,
  -7.39230216e-03f, -2.58987993e-02f, -5.04291318e-02f, -2.21269429e-01f, 2.93194443e-01f, 1.14562400e-01f, -8.72105062e-02f, -1.30870342e-01f, -5.32433130e-02f, 1.24221809e-01f,
  -1.07715279e-01f, 2.30101079e-01f, -1.10883415e-02f, 2.05337584e-01f, 2.19220787e-01f, 3.30404267e-02f, 1.28790110e-01f, 7.15840161e-02f, 2.35151842e-01f, 2.30554670e-01f,
  1.56166971e-01f, 2.09214523e-01f, 1.90113708e-01f, 2.01903790e-01f, -2.63887877e-03f, 1.69329420e-02f, 2.86978725e-02f, -4.43951897e-02f, 8.07238743e-03f, -1.27378069e-02f,
  1.04349695e-01f, -5.41594476e-02f, -2.64195185e-02f, -1.39652878e-01f, -1.18631963e-02f, -1.55587912e-01f, 1.81167677e-01f, -2.07681701e-01f, 2.46666446e-01f, 3.70296463e-02f,
  -1.43396221e-02f, -5.36272936e-02f, -1.84512079e-01f, 1.65512100e-01f, 4.07636091e-02f, -2.38152910e-02f, 1.21552281e-01f, -7.96240047e-02f, 2.50741303e-01f, -1.96856465e-02f,
  -8.24343562e-02f, -1.47606030e-01f, 1.15240425e-01f, -1.78172886e-01f, -3.18769366e-02f, 1.13947213e-01f, -8.31909571e-03f, 1.56397954e-01f, 9.88307670e-02f, 5.63237742e-02f,
  5.33741303e-02f, 2.73527838e-02f, -1.24966033e-01f, 4.35736813e-02f, 8.47043097e-02f, 3.68334085e-01f, 2.06741765e-01f, 2.65147924e-01f, -5.81595823e-02f, 1.33349240e-01f,
  -3.86834480e-02f, -3.36328000e-02f, 1.31066859e-01f, -4.34501171e-02f, -1.26558803e-02f, -1.17218114e-01f, 1.36673495e-01f, 1.15800060e-01f, 6.53179288e-02f, 4.77682874e-02f,
  3.23527642e-02f, 5.16081713e-02f, 8.67899060e-02f, 1.56602889e-01f, 2.28553921e-01f, 2.97421724e-01f, -1.31051848e-02f, 6.76255971e-02f, 1.34274349e-01f, 2.94650327e-02f,
  -2.33704504e-02f, 3.82556170e-02f, 1.13301158e-01f, -3.38078253e-02f, -1.13052756e-01f, -5.35003543e-02f, -5.74193224e-02f, 2.68370891e-03f, 1.15548167e-02f, 4.50335406e-02f,
  3.95527124e-01f, -5.05980179e-02f, 2.09844828e-01f, 2.87759840e-01f, 3.96469444e-01f, -1.86838195e-01f, -2.72335321e-01f, 1.85057533e-03f, -1.64145797e-01f, -1.70737818e-01f,
  2.47774139e-01f, -2.60467947e-01f, 8.95407945e-02f, -8.55704024e-02f, 3.36920500e-01f, 6.12958483e-02f, 3.70249540e-01f, 3.16150635e-02f, -5.81281334e-02f, 6.07153028e-02f,
  8.09114575e-02f, 1.71426401e-01f, 7.94341415e-02f, -6.44888077e-03f, 1.70731097e-01f, 1.11581899e-01f, -3.06290329e-01f, 4.41428460e-02f, -3.02494645e-01f, -2.66554892e-01f,
  -3.00900161e-01f, 1.66900814e-01f, 1.90104768e-02f, -6.01830147e-02f, 4.63455953e-02f, 2.58091599e-01f, -6.59209415e-02f, -9.17342827e-02f, -5.99852726e-02f, 9.04799476e-02f,
  4.81264479e-02f, 1.48355022e-01f, 2.08975866e-01f, 9.78484377e-02f, 7.55131617e-02f, 1.08350836e-01f, 1.60079926e-01f, 1.53086588e-01f, 6.27655089e-02f, 1.42082572e-01f,
  1.51946330e-02f, 1.67573780e-01f, -6.69775670e-03f, -2.44592130e-02f, 2.75202449e-02f, 9.32597145e-02f, 2.16115788e-01f, -1.26525164e-01f, -2.14663297e-01f, 4.43313904e-02f,
  -5.02578169e-02f, 5.04406989e-02f, -1.00511745e-01f, -1.08138233e-01f, -2.48303130e-01f, -1.27372563e-01f, -1.91046417e-01f, 4.24756795e-01f, -2.32930295e-02f, 3.28450441e-01f,
  2.21258283e-01f, -6.82246163e-02f, -1.26773054e-02f, 1.67377174e-01f, -6.11060895e-02f, -1.15543202e-01f, 2.77369350e-01f, 5.15874401e-02f, -2.88545817e-01f, 1.07793830e-01f,
  -1.53588414e-01f, -1.66241676e-01f, 1.01779319e-01f, -1.18353866e-01f, -1.08250864e-01f, -1.58232749e-01f, 2.75662895e-02f, 5.50469495e-02f, 1.01647384e-01f, 2.01877698e-01f,
  -2.99184918e-01f, 8.57274309e-02f, 1.54846922e-01f, 7.26276264e-02f, -7.15244487e-02f, 1.51129693e-01f, 2.84483016e-01f, 3.84925604e-01f, 1.21632606e-01f, 1.61923945e-01f,
  -2.41753850e-02f, 1.04558945e-01f, -1.89273208e-02f, 3.30540128e-02f, 2.55448092e-02f, 1.08694643e-01f, 5.25138690e-04f, 5.70495613e-03f, -7.47556239e-02f, 7.12833405e-02f,
  2.74549760e-02f, 1.66644659e-02f, 9.10876393e-02f, 1.03036538e-01f, 6.82485253e-02f, -1.16972132e-02f, 1.23327971e-02f, -1.34589598e-02f, 3.52213345e-02f, 3.26113366e-02f,
  1.01243332e-01f, -5.21501824e-02f, -6.44637942e-02f, -6.06956556e-02f, -6.35812804e-02f, 4.41618301e-02f, -1.25275642e-01f, -2.06573103e-02f, 4.59191710e-01f, 1.32997423e-01f,
  -1.37343332e-01f, 3.21372449e-01f, 3.41402382e-01f, -1.08089238e-01f, -1.12529203e-01f, 1.36136845e-01f, -1.22059509e-01f, -2.18626142e-01f, 3.64065886e-01f, -2.36502126e-01f,
  -5.83266988e-02f, 7.68752769e-02f, 2.86623657e-01f, 2.72647768e-01f, 2.80733466e-01f, -3.19113745e-03f, 2.45564550e-01f, -2.95146704e-01f, -1.52689949e-01f, 3.55888277e-01f,
  -3.08469422e-02f, 6.75169006e-02f, 1.27241492e-01f, 2.67029971e-01f, 1.48230419e-01f, -4.91660498e-02f, -2.24702194e-01f, -3.46928477e-01f, -1.48882225e-01f, -1.45401852e-02f,
  -4.57818471e-02f, -3.82575504e-02f, 1.38924032e-01f, 1.44924223e-01f, -1.88647479e-01f, -2.91150920e-02f, -1.26932770e-01f, 1.89775586e-01f, 2.36675125e-02f, 1.34063408e-01f,
  1.06337275e-02f, 4.31972891e-02f, 1.40368491e-01f, 8.60125199e-02f, -6.48016036e-02f, -1.06050275e-01f, -2.36405712e-02f, 6.35925978e-02f, 1.02964871e-01f, 5.29901683e-03f,
  1.64302170e-01f, -1.00784935e-01f, -1.52828619e-01f, 2.36509182e-02f, -6.18070066e-02f, -9.07191187e-02f, 1.90468699e-01f, -1.48662075e-01f, 1.05748130e-02f, -6.55205622e-02f,
  -1.21420868e-01f, 8.65776092e-02f, 1.93652809e-01f, 2.40901142e-01f, 1.91916451e-01f, -3.85717988e-01f, -1.29432172e-01f, 9.55081433e-02f, -1.80075049e-01f, 6.71880785e-03f,
  2.02026531e-01f, -1.93041086e-01f, -7.58673530e-04f, -9.96136665e-02f, 2.54927725e-01f, 1.38903826e-01f, 7.54295290e-02f, -2.27794081e-01f, 1.63340822e-01f, 6.14508726e-02f,
  -1.90816432e-01f, 2.96256602e-01f, 1.00399092e-01f, -1.66543871e-02f, 1.57679975e-01f, 4.06066589e-02f, 1.70065969e-01f, 5.70225343e-02f, 2.26199552e-01f, 2.75338322e-01f,
  1.37774507e-02f, 4.90138642e-02f, 2.64565587e-01f, 1.04039744e-03f, 2.71412954e-02f, -2.68066317e-01f, 1.34016816e-02f, -4.80227619e-02f, 2.45224118e-01f, 1.14070870e-01f,
  5.62051982e-02f, 6.30265027e-02f, 3.27061653e-01f, 1.62366033e-01f, 2.04099998e-01f, 6.51348606e-02f, 1.29952461e-01f, 2.89398730e-02f, 2.61092931e-02f, 2.84387529e-01f,
  3.00995529e-01f, 1.58338860e-01f, 1.10829398e-01f, 4.89149839e-02f, -6.11177757e-02f, -1.09104462e-01f, -1.10368796e-01f, 3.98654602e-02f, -5.53787909e-02f, 9.28158537e-02f,
  1.44735217e-01f, -1.76354483e-01f, 1.12411819e-01f, 1.37368664e-01f, 3.88143212e-02f, 6.22949414e-02f, 3.80776078e-01f, 1.36465773e-01f, 3.56504381e-01f, -5.27777374e-02f,
  1.66461080e-01f, -2.77841091e-01f, -1.31452968e-02f, 5.93268946e-02f, -1.87717214e-01f, -1.32892340e-01f, 2.67237991e-01f, -7.93478936e-02f, -1.43606618e-01f, 1.92241222e-01f,
  3.16331610e-02f, 8.64540339e-02f, 2.41205841e-01f, 1.99988872e-01f, 1.74878374e-01f, 1.56297937e-01f, 1.37553662e-01f, 4.85038996e-01f, -3.75011861e-01f, 4.66654956e-01f,
  -5.54707386e-02f, -3.27978015e-01f, -2.24594936e-01f, 2.89967984e-01f, -3.79063964e-01f, -1.17426790e-01f, -8.76052976e-02f, -2.84755081e-02f, -2.44817778e-01f, -1.29532874e-01f,
  -2.37860665e-01f, 1.06764156e-02f, -2.58456767e-01f, 8.09622705e-02f, 1.55238837e-01f, -1.96763918e-01f, -7.28596151e-02f, -1.76862050e-02f, -7.09275976e-02f, -1.03464589e-01f,
  1.32822454e-01f, 1.82719901e-01f, -3.81745920e-02f, 1.28590956e-01f, 6.80300817e-02f, 1.06637545e-01f, -1.50182515e-01f, 4.30849120e-02f, -5.04959673e-02f, -2.19236597e-01f,
  4.39094603e-02f, 9.65165049e-02f, 1.34896129e-01f, 1.53277572e-02f, -9.79620069e-02f, -3.19998562e-02f, 2.32762527e-02f, 1.14063039e-01f, -5.98073192e-02f, -7.10368156e-02f,
  4.64106470e-01f, -1.25191184e-02f, -1.45626351e-01f, 3.65337521e-01f, 2.93026567e-01f, 9.16971266e-02f, 1.47118056e-02f, -4.56521346e-04f, -2.35810578e-01f, 4.08347696e-02f,
  -8.70505720e-02f, -2.15067025e-02f, -5.97800799e-02f, -1.33736968e-01f, -5.54166175e-02f, 3.21926326e-01f, 7.41494298e-02f, 2.49250263e-01f, 1.99043438e-01f, -2.45631471e-01f,
  -2.53339201e-01f, 2.60042280e-01f, 8.98131654e-02f, 3.07117790e-01f, 2.84215491e-02f, -3.55930328e-02f, -2.97290415e-01f, -1.04751237e-01f, -1.83032826e-02f, -3.45101178e-01f,
  6.28131861e-03f, 1.49095193e-01f, -9.13856328e-02f, 1.69619486e-01f, 1.01932384e-01f, 5.07613383e-02f, -6.81835189e-02f, -4.70836041e-03f, -4.71075326e-02f, 1.25376701e-01f,
  1.43066570e-01f, -6.90996423e-02f, 1.31237227e-02f, 2.08330065e-01f, -2.06709467e-02f, 6.45541623e-02f, 2.53713429e-01f, 1.07901037e-01f, -2.87879782e-04f, 2.75321007e-01f,
  -1.02983035e-01f, 9.49771479e-02f, 3.09034740e-03f, 1.85968354e-02f, -6.28294796e-02f, 9.86065492e-02f, 1.96884513e-01f, -1.15756784e-02f, 1.27697423e-01f, 1.03102438e-01f,
  6.96982145e-02f, -3.50462981e-02f, -5.11902943e-02f, -9.28850845e-02f, 2.04460338e-01f, 1.53641775e-01f, -1.07992440e-01f, -4.81030084e-02f, 8.59793574e-02f, 2.72477269e-01f,
  -2.00111456e-02f, 6.03519157e-02f, 1.22131273e-01f, 9.54807475e-02f, 8.51639584e-02f, 1.55344784e-01f, 3.77955176e-02f, 2.79255956e-01f, -3.37617546e-01f, -2.81232417e-01f,
  -2.29724795e-02f, 1.19658403e-01f, -1.88048378e-01f, -7.23696426e-02f, 1.72613502e-01f, -2.52864301e-01f, 9.12212357e-02f, 1.84639186e-01f, -1.45594865e-01f, 1.40309483e-01f,
  -4.32470404e-02f, -1.58270001e-01f, 6.49941713e-02f, 3.13226074e-01f, 5.17838970e-02f, 3.36952090e-01f, 2.14549139e-01f, 9.26003903e-02f, 2.14778930e-01f, 9.14858356e-02f,
  2.21110255e-01f, 3.15382816e-02f, 1.46980807e-01f, -2.08685905e-01f, 1.60603337e-02f, 1.28757775e-01f, 1.19593590e-01f, 5.51715419e-02f, 2.51283441e-02f, -2.58070007e-02f,
  1.85986385e-02f, -3.95993926e-02f, 5.91996163e-02f, 6.29798770e-02f, 1.69388354e-01f, -1.02992117e-01f, 5.83715700e-02f, -6.28908500e-02f, 3.03068478e-03f, 6.27784431e-02f,
  1.65452495e-01f, -4.94621620e-02f, 1.01306044e-01f, -1.73604742e-01f, -2.55620796e-02f, 6.34960309e-02f, -1.52974382e-01f, -9.62607190e-02f, -1.46650389e-01f, 1.57919377e-01f,
  2.76861012e-01f, -1.84290916e-01f, -2.22022519e-01f, 2.49966413e-01f, 1.78123731e-02f, -1.85493976e-01f, 8.12553391e-02f, -4.34762798e-02f, 8.40085968e-02f, 3.94434147e-02f,
  1.68762803e-01f, 1.40115455e-01f, 1.62551552e-01f, -2.27145165e-01f, 2.94216543e-01f, -4.54877913e-02f, 9.06705558e-02f, 2.50609010e-01f, 1.71218261e-01f, 2.27253474e-02f,
  -4.36125211e-02f, -1.48525432e-01f, -9.17394385e-02f, 1.28627047e-01f, 3.03308070e-01f, 2.52162069e-01f, 1.25074059e-01f, -6.42188638e-02f, 2.30866492e-01f, 3.59784812e-02f,
  1.20563013e-02f, -1.67608872e-01f, 2.21083447e-01f, 5.11926645e-03f, 2.40167812e-01f, 3.32610518e-01f, 6.01525558e-03f, -1.35869712e-01f, -5.17755263e-02f, 1.56352863e-01f,
  8.12062100e-02f, -7.30047449e-02f, 8.69756639e-02f, 1.78425640e-01f, -5.07432632e-02f, -1.09485470e-01f, -4.92633246e-02f, -1.37874931e-01f, 3.36939543e-02f, 2.22952187e-01f,
  1.28236592e-01f, -3.13976482e-02f, 1.15881607e-01f, 7.78601915e-02f, -6.37307242e-02f, -9.18968096e-02f, 2.29817443e-02f, 1.50236785e-01f, -1.60149932e-01f, 2.05642700e-01f,
  -8.22964311e-02f, -1.28355110e-02f, 3.79429273e-02f, -8.89399322e-04f, 1.86670005e-01f, 1.69754192e-01f, 3.51778092e-03f, 2.51623094e-01f, 1.83411911e-01f, -1.29537359e-01f,
  1.23011749e-02f, 6.43974096e-02f, -1.94551483e-01f, 6.81380183e-02f, -5.77397980e-02f, 9.91144702e-02f, 1.23853618e-02f, 2.40511492e-01f, -6.08591922e-02f, 6.48293793e-02f,
  1.02763638e-01f, 2.38003790e-01f, 4.44113575e-02f, -1.29900545e-01f, -3.29043455e-02f, 6.32085577e-02f, 8.36762637e-02f, -1.12289749e-02f, 8.64236355e-02f, 1.11917816e-01f,
  1.37489229e-01f, -6.84500784e-02f, 2.91666925e-01f, 2.66661227e-01f, 2.13650540e-01f, 1.78228140e-01f, 1.73742712e-01f, -1.08670160e-01f, 2.00247243e-01f, 9.46884006e-02f,
  5.98863177e-02f, 8.59616026e-02f, 1.55701369e-01f, 1.32167116e-01f, 1.16550900e-01f, 8.08281973e-02f, 9.76184905e-02f, 1.53675660e-01f, 8.18287209e-02f, 4.22042608e-03f,
  8.74029938e-03f, -1.59413174e-01f, 1.10825285e-01f, -1.94361627e-01f, -1.31324098e-01f, -6.66601211e-02f, 1.07544802e-01f, 7.12676570e-02f, -3.90049741e-02f, 1.43207461e-01f,
  -1.36485890e-01f, 1.49221539e-01f, 2.20901608e-01f, 1.58641115e-01f, 8.13175216e-02f, 2.31714007e-02f, -2.04942122e-01f, 2.17415661e-01f, 6.00216053e-02f, -2.38319766e-02f,
  -3.40132564e-02f, -1.89036518e-01f, 3.53530735e-01f, 2.20935553e-01f, -1.09121501e-01f, 2.51780361e-01f, 1.34683579e-01f, -1.10176884e-01f, -1.36871696e-01f, 1.96252674e-01f,
  2.34081689e-02f, 2.37056985e-01f, -1.10643275e-01f, -3.60202268e-02f, 4.00800288e-01f, -1.80676743e-01f, 1.58958808e-01f, 2.07944825e-01f, -3.55080664e-01f, 2.71461695e-01f,
  1.48057655e-01f, -1.19669452e-01f, -2.27493495e-01f, 3.05111259e-02f, -2.32680384e-02f, -1.78068832e-01f, -2.40259364e-01f, -2.94039458e-01f, 1.63607463e-01f, 9.50867385e-02f,
  -1.27175137e-01f, -8.93998966e-02f, -3.29185367e-01f, 1.91299859e-02f, -3.61646526e-02f, 2.09964141e-01f, 2.64011733e-02f, 7.63226300e-02f, 1.89195901e-01f, 1.49144426e-01f,
  1.54660255e-01f, 2.47335918e-02f, 1.59697726e-01f, -9.94853303e-03f, 1.32164389e-01f, 1.66621327e-01f, 4.13613301e-03f, 2.51756050e-02f, -6.35922477e-02f, -2.56196298e-02f,
  6.14528023e-02f, -1.66068077e-02f, 1.97607670e-02f, 6.68756664e-02f, -4.38664816e-02f, 1.12880923e-01f, 1.80805288e-02f, -1.59685001e-01f, 1.44964131e-02f, -4.65775765e-02f,
  2.87135780e-01f, 5.42409495e-02f, 2.02857018e-01f, -3.88089865e-02f, 2.50772595e-01f, -4.53326881e-01f, -2.27522150e-01f, 3.55835915e-01f, 2.64159292e-01f, -1.26953080e-01f,
  3.76823485e-01f, -1.16503701e-01f, 3.26760672e-02f, 3.66436131e-02f, -2.56438199e-02f, 1.53682269e-02f, -1.82952993e-02f, -7.92411268e-02f, 1.29207253e-01f, 2.96376552e-02f,
  -1.26819313e-01f, 2.53836244e-01f, 1.33199364e-01f, 1.97993517e-01f, -1.69897359e-02f, -7.11759254e-02f, -4.21889834e-02f, 9.54357311e-02f, -7.80295804e-02f, 2.25489676e-01f,
  -1.84100643e-01f, 7.86070526e-02f, -1.24937342e-02f, 4.48642783e-02f, -8.81827921e-02f, 8.20101574e-02f, -2.14695692e-01f, -8.75350907e-02f, 8.56978595e-02f, -4.12366875e-02f,
  8.25467408e-02f, 2.32372344e-01f, 7.22071156e-02f, 7.97346085e-02f, 1.38148636e-01f, 1.04473352e-01f, 6.06228672e-02f, -6.83609098e-02f, 1.30126327e-01f, -6.04940578e-02f,
  2.35251442e-01f, 9.18004662e-02f, -2.64517423e-02f, 1.33809343e-01f, -4.27595526e-02f, -3.25470082e-02f, -8.09067711e-02f, 4.27880995e-02f, -2.44306177e-02f, -3.20467018e-02f,
  -1.50776029e-01f, -2.36308187e-01f, 1.96269140e-01f, -3.37544419e-02f, -1.79428786e-01f, -9.21369195e-02f, -1.14388600e-01f, 2.47301504e-01f, 9.66721326e-02f, -1.97369009e-01f,
  9.03873965e-02f, 4.81239408e-01f, 1.92538068e-01f, 5.07292012e-03f, 2.94956356e-01f, -7.25369677e-02f, 3.07765216e-01f, -3.99134755e-02f, 1.33237004e-01f, 2.99170822e-01f,
  1.35725532e-02f, -9.24548730e-02f, 3.61281723e-01f, -2.81900875e-02f, 6.01295196e-02f, -2.43753735e-02f, 3.38016391e-01f, -3.00203618e-02f, 3.28171283e-01f, -5.98610044e-02f,
  1.78939342e-01f, -2.10178912e-01f, 2.12606400e-01f, 1.56040475e-01f, -2.80914363e-02f, -2.75289565e-01f, 6.33294657e-02f, 2.80183822e-01f, -3.48614082e-02f, -4.98380549e-02f,
  -8.55038464e-02f, -7.14561567e-02f, -1.17580190e-01f, 4.07643080e-01f, 1.62241369e-01f, 2.73020938e-02f, 2.20490426e-01f, 6.49993271e-02f, 8.54142904e-02f, 1.86681390e-01f,
  -2.11451091e-02f, 6.58543259e-02f, 3.56165767e-02f, 2.55193204e-01f, 1.04094826e-01f, -3.10657336e-03f, 2.01357976e-02f, 4.51020561e-02f, -8.75939280e-02f, -2.78405190e-01f,
  8.88602510e-02f, 1.57662615e-01f, -1.94600865e-01f, 1.32054806e-01f, -1.34502530e-01f, -1.06200576e-01f, 1.16072640e-01f, -8.71727839e-02f, -5.89209050e-02f, 4.79801856e-02f,
  -3.22878093e-01f, 4.90253568e-02f, 1.30853161e-01f, -2.25417510e-01f, -1.19267143e-01f, 3.87248546e-01f, 2.52568424e-01f, -2.13113740e-01f, 4.17053312e-01f, 1.03015199e-01f,
  2.16895953e-01f, -9.51783508e-02f, 3.68547589e-01f, -1.43940359e-01f, 1.27461031e-01f, -2.52821118e-01f, 2.70976815e-02f, -6.78375661e-02f, -9.71817896e-02f, -5.59574105e-02f,
  1.68199521e-02f, -2.50197709e-01f, 2.04868987e-01f, 3.17228824e-01f, -8.99323523e-02f, 2.80410647e-01f, 1.38328984e-01f, 4.25021619e-01f, -4.23476398e-01f, -1.41884536e-01f,
  -8.71307179e-02f, 1.96466610e-01f, -1.11268118e-01f, 1.60685986e-01f, 5.04450239e-02f, -2.46623009e-02f, -3.55654471e-02f, 3.66941601e-01f, -1.49680585e-01f, 1.32539719e-01f,
  6.08123876e-02f, 8.25989619e-02f, -3.15774158e-02f, 2.12113827e-01f, 1.34858787e-01f, 3.18955593e-02f, 6.10991046e-02f, 7.91737512e-02f, 3.40672471e-02f, 5.28837368e-02f,
  1.70403682e-02f, -1.82533458e-01f, -4.28884439e-02f, 2.25106329e-02f, 1.45234779e-01f, 2.33420767e-02f, -5.62970750e-02f, -4.73909313e-03f, 5.25330044e-02f, -2.68412810e-02f,
  -7.40294084e-02f, -4.77752797e-02f, 3.56420338e-01f, -1.65357098e-01f, -3.41377050e-01f, 8.07821378e-02f, 2.31059968e-01f, 7.67443106e-02f, 1.08966470e-01f, 2.18210705e-02f,
  7.05156252e-02f, 2.74849441e-02f, 1.98899850e-01f, -3.79826389e-02f, 1.10595763e-01f, -2.29079723e-01f, -1.57165900e-01f, 4.26970609e-02f, -6.53108507e-02f, 2.07639232e-01f,
  4.27407920e-01f, -3.41143906e-01f, -1.64823607e-01f, 2.73455530e-01f, -1.53718978e-01f, 2.94785947e-01f, 1.40287876e-01f, -1.99135151e-02f, 2.27050837e-02f, -1.54632419e-01f,
  -4.52440158e-02f, -2.64616627e-02f, -2.24955752e-02f, 1.03628077e-01f, -3.13218415e-01f, 1.99223801e-01f, 4.66244042e-01f, 2.58669496e-01f, 5.23571633e-02f, 1.57258838e-01f,
  -6.50501996e-02f, 3.56672471e-03f, -2.18796749e-02f, -5.98044950e-04f, -3.76911797e-02f, 8.86521637e-02f, 1.35207728e-01f, 8.56696069e-02f, 1.61864966e-01f, 2.23502107e-02f,
  1.91397041e-01f, 7.17597008e-02f, 2.65779078e-01f, 5.25796451e-02f, 1.88049480e-01f, -1.92169137e-02f, -1.44574329e-01f, -8.43973074e-04f, -2.44216278e-01f, -1.39795378e-01f,
  2.07290471e-01f, -2.80149311e-01f, -1.89705547e-02f, -2.85765558e-01f, 9.89337359e-03f, 1.17142893e-01f, 2.35187948e-01f, 2.17467442e-01f, 3.38659048e-01f, -3.84799540e-01f,
  -4.42168750e-02f, 3.66344303e-02f, -1.44600898e-01f, -4.28349189e-02f, -3.73555571e-02f, 4.59330864e-02f, -1.49408922e-01f, -2.09941089e-01f, 1.22155204e-01f, 1.94658965e-01f,
  -6.67952560e-03f, -3.06145698e-01f, 1.28461882e-01f, 4.69582491e-02f, -5.08075655e-02f, 2.61116892e-01f, -6.41612858e-02f, 4.38397005e-03f, 8.36238191e-02f, 2.00905249e-01f,
  1.14970721e-01f, -2.31222101e-02f, 1.93470076e-01f, 1.44148804e-02f, 1.34123908e-02f, 1.51779637e-01f, 2.85218060e-01f, 8.88889506e-02f, 5.00776805e-02f, -1.90827698e-01f,
  -3.90831418e-02f, -1.69102415e-01f, 1.62578315e-01f, -4.71110037e-03f, 8.20030198e-02f, -1.14935793e-01f, -4.95397660e-04f, -5.38542401e-03f, -4.06503007e-02f, 1.94846675e-01f,
  6.71821088e-02f, 1.96654573e-01f, 2.74329670e-02f, -1.89511567e-01f, 5.89255169e-02f, -7.83892628e-03f, -4.67225499e-02f, -1.12696653e-02f, -1.74830049e-01f, -1.98759716e-02f,
  8.15130174e-02f, 1.08113334e-01f, 6.20448031e-02f, -4.05739546e-02f, -9.29422006e-02f, 1.12998962e-01f, 2.02623487e-01f, 1.81854770e-01f, -7.89888650e-02f, -3.65200825e-02f,
  9.75968130e-03f, -1.97982371e-01f, -2.02683844e-02f, 2.13471234e-01f, 2.29988575e-01f, 2.07531936e-02f, 2.90744931e-01f, 2.18529537e-01f, -3.14549357e-01f, -1.95334166e-01f,
  1.92922071e-01f, 4.60749045e-02f, -3.79353985e-02f, 7.97847658e-02f, 3.44039053e-01f, 3.24660510e-01f, 3.72194737e-01f, 1.04996599e-01f, 5.17822385e-01f, 2.11581677e-01f,
  2.24612560e-02f, 4.21852827e-01f, -3.86758894e-01f, 3.57412198e-03f, 1.34137839e-01f, 7.95129463e-02f, -4.47712131e-02f, 1.20787106e-01f, -1.54165789e-01f, -3.50507319e-01f,
  -3.46998036e-01f, -3.97004895e-02f, -1.02940135e-01f, 1.74685866e-01f, 1.64588824e-01f, 2.12712243e-01f, -1.21279016e-01f, 2.05272391e-01f, -9.36043262e-02f, 3.18196453e-02f,
  2.94570655e-01f, 1.16953120e-01f, 1.33952513e-01f, -5.17621152e-02f, 2.12258637e-01f, 1.57465145e-01f, 6.14378508e-03f, 2.97507793e-01f, 1.47386357e-01f, 1.36215732e-01f,
  1.94664210e-01f, 4.44366597e-02f, 1.12624094e-01f, -1.44020930e-01f, 8.04154426e-02f, 9.24095288e-02f, -1.81362152e-01f, -7.04062805e-02f, 1.47478536e-01f, -1.67447835e-01f,
  2.26657629e-01f, 1.30468324e-01f, 4.02881503e-02f, 1.59880117e-01f, 2.40654498e-01f, 2.98304707e-01f, 1.42641068e-01f, 7.99579397e-02f, -5.80494851e-02f, 3.73679698e-02f,
  1.15555289e-04f, -3.39349478e-01f, -2.44166076e-01f, 8.36713910e-02f, -1.49417683e-01f, 6.41919896e-02f, -1.20598517e-01f, 1.94314644e-01f, -7.55284121e-03f, 3.91559340e-02f,
  7.45508894e-02f, 1.26223236e-01f, -2.79854357e-01f, -1.33839488e-01f, 4.40825559e-02f, 8.01258907e-02f, -3.70132059e-01f, 3.80497217e-01f, -5.95781021e-02f, -1.05394840e-01f,
  -3.64402384e-01f, 3.22987467e-01f, -2.52635419e-01f, -1.41333848e-01f, -3.10783774e-01f, -2.07208861e-02f, 5.19831255e-02f, -2.96143126e-02f, -4.05589700e-01f, -1.14399679e-01f,
  -1.34334728e-01f, -1.71899586e-03f, 1.07450619e-01f, 5.71760945e-02f, 3.43449898e-02f, 2.29484633e-01f, 2.24369168e-01f, 1.73617154e-01f, 1.34017542e-01f, 1.42231360e-01f,
  1.33875728e-01f, 1.29448548e-01f, 1.96533069e-01f, 2.63415337e-01f, 1.20247178e-01f, 1.94926232e-01f, -1.25047743e-01f, 8.04165192e-03f, -4.66074981e-03f, -3.15243676e-02f,
  3.83327156e-02f, 5.72740547e-02f, 1.41783014e-01f, -1.01747401e-01f, 8.69432241e-02f, -1.37281969e-01f, -2.17878469e-03f, -1.12193383e-01f, 1.35846108e-01f, -1.40521109e-01f,
  3.33322734e-01f, -4.56876419e-02f, -1.42818704e-01f, 2.65785694e-01f, -4.76157479e-02f, -1.49050266e-01f, 3.13874707e-02f, -1.72699820e-02f, -1.28432736e-01f, -2.27514550e-01f,
  1.38484061e-01f, 9.34509486e-02f, -1.87596697e-02f, -2.40177751e-01f, 2.24109277e-01f, -1.77044809e-01f, -1.40465900e-01f, 3.58132303e-01f, 1.46005303e-01f, -7.36578926e-02f,
  2.87950076e-02f, 7.61599317e-02f, 9.05126408e-02f, 1.06126703e-01f, -6.53508231e-02f, 1.30443156e-01f, 1.08518302e-01f, 3.12296331e-01f, 3.24409783e-01f, 3.16116184e-01f,
  -1.06893517e-01f, -7.03360885e-02f, 1.58202082e-01f, 7.13862553e-02f, 3.14814478e-01f, 2.61536568e-01f, -4.16020527e-02f, -3.02704453e-01f, 1.13835461e-01f, 1.28913164e-01f,
  2.17907012e-01f, -5.23840189e-02f, 1.41332269e-01f, 3.01770642e-02f, 3.27958241e-02f, 1.85300425e-01f, 3.01007624e-03f, 4.44698036e-02f, 2.67007977e-01f, 7.05913827e-02f,
  6.92870840e-02f, -1.35571286e-01f, 5.91738820e-02f, 7.49837467e-03f, 2.54770875e-01f, -2.21461952e-01f, -1.72048256e-01f, 2.89527979e-02f, 1.14161573e-01f, 9.80931744e-02f,
  1.98483750e-01f, 1.47590404e-02f, -7.12577760e-01f, 7.55566955e-02f, -2.84257710e-01f, 3.46225291e-01f, -3.83161604e-01f, 4.20278639e-01f, 5.54203808e-01f, -5.05270669e-03f,
  -7.15033412e-02f, 2.98363090e-01f, 2.74910778e-01f, -1.52061567e-01f, 4.22588706e-01f, 3.14099714e-02f, 1.63386047e-01f, 2.55458444e-01f, 1.70858458e-01f, -3.48524570e-01f,
  2.05104742e-02f, -2.61397004e-01f, 4.71405201e-02f, -3.76892895e-01f, -7.54750594e-02f, 3.48216519e-02f, 2.95112908e-01f, 2.69907743e-01f, -1.42121330e-01f, -1.26720950e-01f,
  -4.97166775e-02f, -3.20663229e-02f, -3.42585146e-01f, -3.04107070e-01f, 2.90718406e-01f, 3.74858230e-01f, 7.12890550e-02f, 1.52877733e-01f, 4.57463004e-02f, 1.66527838e-01f,
  -1.10801563e-01f, 3.38147849e-01f, -3.91030535e-02f, 9.00098905e-02f, 1.79148629e-01f, 1.16007261e-01f, 9.58821997e-02f, 5.13477251e-02f, 1.54823139e-01f, 7.42113292e-02f,
  3.60292271e-02f, 1.23292968e-01f, 2.54662279e-02f, 9.02990848e-02f, -1.09780289e-01f, -4.32202630e-02f, 1.60464346e-01f, -8.22569802e-02f, 2.02313289e-02f, 6.62992746e-02f,
  -3.83381955e-02f, 2.11711735e-01f, -2.61926316e-02f, -1.22515589e-01f, 6.32730275e-02f, 4.31054505e-03f, 2.75385797e-01f, -7.30524585e-02f, -3.86670567e-02f, -6.07813001e-02f,
  1.16659023e-01f, -1.47107961e-02f, 6.76155910e-02f, 3.15841973e-01f, 9.25132334e-02f, -1.19671300e-02f, 2.71135509e-01f, -5.40539809e-03f, -6.55498058e-02f, -5.18261306e-02f,
  -1.81129932e-01f, -5.62733039e-03f, -5.18503822e-02f, -6.83143362e-02f, 3.53016704e-01f, -9.99726430e-02f, -1.73761204e-01f, 2.25896597e-01f, 1.07018165e-01f, 2.40573511e-01f,
  9.13671106e-02f, -4.66423817e-02f, -2.06339702e-01f, -1.11916460e-01f, -3.51774916e-02f, 3.47266674e-01f, -1.31379515e-01f, 8.07036832e-02f, -1.00924939e-01f, 3.40845853e-01f,
  7.86719695e-02f, 4.28002812e-02f, 1.04332492e-02f, 1.88511685e-01f, -4.19203900e-02f, -7.40075335e-02f, 5.38123846e-02f, 1.60071895e-01f, -2.51642289e-03f, -2.88314670e-02f,
  1.41421393e-01f, -2.00917218e-02f, -9.39238518e-02f, -1.17246352e-01f, 1.02711841e-01f, 5.55689409e-02f, 1.23263493e-01f, 8.07835385e-02f, 1.05548553e-01f, 8.65330696e-02f,
  -1.53825849e-01f, -9.97964013e-03f, 1.21841982e-01f, -4.54884768e-02f, 7.09010754e-03f, -1.85819566e-02f, -1.61188543e-01f, -2.96231836e-01f, 1.77503973e-01f, 2.60201730e-02f,
  5.83047643e-02f, -2.40506306e-02f, -2.74421517e-02f, 1.19427830e-01f, 3.87333184e-01f, -2.54377067e-01f, 3.06527447e-02f, 3.69828194e-01f, 1.69675201e-01f, -1.83119044e-01f,
  4.87807363e-01f, -1.51763424e-01f, 3.43749046e-01f, -1.37209311e-01f, 2.00707704e-01f, 9.91361216e-02f, 1.63005054e-01f, -1.79133549e-01f, 3.00776005e-01f, 7.54854009e-02f,
  3.66117619e-02f, 1.18310101e-01f, 4.14483517e-01f, -1.85594290e-01f, 1.98485583e-01f, 2.13509738e-01f, 8.54125991e-02f, -2.47153062e-02f, 1.66172050e-02f, 5.43823130e-02f,
  -8.31843615e-02f, -1.07566409e-01f, -1.82862386e-01f, 1.91782892e-01f, 2.12381184e-01f, 1.20885029e-01f, -6.03615865e-02f, -1.50857329e-01f, -7.48566389e-02f, 1.38632253e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  3.32834035e-01f, -1.02643989e-01f, 6.93633184e-02f, 2.56157100e-01f, -2.32877152e-04f, 9.94797647e-02f, 8.81128609e-02f, 3.73354256e-02f, 1.11265972e-01f, 1.47280708e-01f,
  1.19450204e-01f, 1.40925795e-01f, 2.33193889e-01f, 2.02280238e-01f, 8.51441026e-02f, 1.70101404e-01f, 4.80401143e-02f, 1.81319848e-01f, 1.80043101e-01f, 1.22847736e-01f,
  1.54047951e-01f, 5.17843440e-02f, 1.56165227e-01f, 2.03829750e-01f, 1.73579872e-01f, 4.99504805e-02f, 2.50933409e-01f, -5.50809875e-02f, 3.08917105e-01f, 1.25160843e-01f,
  2.25169092e-01f, 1.59485742e-01f, 9.76501405e-02f, 1.71048939e-01f, 1.09168701e-01f, 3.50990832e-01f, 2.27433532e-01f, 2.98804969e-01f, 1.71375543e-01f, 1.37797341e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.94589779e-01f, -2.31797740e-01f, -5.56116225e-03f, -2.57126838e-01f, -1.94605604e-01f, -7.08972802e-03f, -3.20023537e-01f, -2.82204717e-01f, 1.70625970e-01f, -6.84400694e-03f,
  -2.16277540e-01f, 2.50917356e-02f, -2.46024624e-01f, 1.83927491e-01f, -3.17189507e-02f, 3.18552703e-01f, 1.52387083e-01f, 2.46976346e-01f, -9.75988805e-02f, -1.87281415e-01f,
  -1.03709839e-01f, -4.60576564e-01f, 8.69607106e-02f, 2.61664361e-01f, -2.47475550e-01f, 3.02046478e-01f, -4.03053939e-01f, -3.67932200e-01f, 1.21650547e-01f, -1.64614484e-01f,
  1.94486663e-01f, 1.52280957e-01f, -8.45333561e-02f, -1.63991481e-01f, 1.80400535e-01f, 1.88339189e-01f, -3.77323627e-01f, -3.22329462e-01f, -1.11254103e-01f, 9.65225995e-02f,
  1.51408449e-01f, -4.58744049e-01f, -9.66188759e-02f, 2.24786267e-01f, 1.23627134e-01f, 1.12252548e-01f, -4.09667492e-01f, -3.45359772e-01f, 3.20913762e-01f, 1.11421943e-01f,
  -3.04013461e-01f, 1.12759285e-01f, -4.87981319e-01f, -1.20131373e-01f, -2.20828548e-01f, -2.33373448e-01f, 1.60530776e-01f, -2.13385016e-01f, 3.48504670e-02f, -4.39829379e-02f,
  -1.91616356e-01f, -3.25785547e-01f, 3.93330082e-02f, 1.61957428e-01f, -1.33532688e-01f, -4.42979574e-01f, -2.56042201e-02f, -1.24832178e-02f, -2.34797457e-03f, -2.34234030e-03f,
  -7.71361589e-03f, -1.36695072e-01f, -5.13932049e-01f, -2.08741024e-01f, 1.45119488e-01f, -9.49774012e-02f, -3.63963127e-01f, 2.27774382e-01f, 2.84079164e-01f, 2.36049831e-01f,
  -3.55235666e-01f, -1.43559039e-01f, 3.51952687e-02f, 2.91381869e-02f, 2.86470532e-01f, 1.01853177e-01f, -1.73322529e-01f, -3.78000885e-01f, -4.11644638e-01f, 4.75067109e-01f,
  -1.18524350e-01f, -5.31456888e-01f, -3.35376598e-02f, 3.14140975e-01f, 1.19896300e-01f, 3.59657586e-01f, -2.33568922e-01f, -5.72795197e-02f, 3.08207393e-01f, -1.48390964e-01f,
  -2.19847605e-01f, -9.37969163e-02f, 1.76422335e-02f, 1.78808630e-01f, 2.25643009e-01f, 7.50589967e-02f, 8.96940455e-02f, -6.20763302e-01f, -1.54197797e-01f, -4.69686270e-01f,
  1.05128326e-01f, -3.16844434e-01f, -1.11380443e-01f, 1.45863652e-01f, 1.64359435e-01f, 1.44522473e-01f, -1.69883519e-01f, -4.01846886e-01f, -4.24973130e-01f, -3.04896206e-01f,
  1.25638694e-02f, 1.84109315e-01f, -4.47072655e-01f, -4.39738363e-01f, 2.75180548e-01f, -5.58187723e-01f, 4.88568805e-02f, -5.15365303e-01f, 7.89192840e-02f, -3.76515277e-02f,
  -8.47454742e-03f, 1.07378438e-01f, 1.78738981e-01f, -9.80360731e-02f, 1.39905915e-01f, -4.10854295e-02f, -5.01519218e-02f, -3.59681360e-02f, 3.03215593e-01f, -7.93473646e-02f,
  -1.21308625e-01f, -2.25457951e-01f, 1.22847348e-01f, -2.76280493e-01f, 5.72806820e-02f, -2.33300671e-01f, 1.82745054e-01f, 2.92731911e-01f, 2.45883897e-01f, 2.94516414e-01f,
  8.95162374e-02f, -1.34316206e-01f, 2.81945020e-02f, -4.95086402e-01f, -8.36631879e-02f, 1.93526313e-01f, -6.29727170e-02f, -3.13798040e-01f, -7.69422902e-03f, 2.33268395e-01f,
  -1.94249779e-01f, 4.27813441e-01f, -1.39124900e-01f, -4.17558610e-01f, 1.29436553e-01f, -3.30734164e-01f, -1.03386752e-01f, 2.43705332e-01f, 2.33473212e-01f, -3.68903309e-01f,
  1.10531062e-01f, 3.43162268e-01f, -6.49791732e-02f, 2.09176525e-01f, -1.99483320e-01f, 3.56432289e-01f, 1.83038548e-01f, 1.30857706e-01f, -2.42547393e-01f, -2.03910936e-02f,
  -2.71579146e-01f, 9.10190716e-02f, -6.13061711e-02f, -2.82691002e-01f, -6.49153069e-02f, -3.94764058e-02f, -4.95285213e-01f, 2.98671991e-01f, 8.04850161e-02f, -4.08751100e-01f,
  1.00149577e-02f, -3.37362945e-01f, -1.61195070e-01f, -6.26278818e-02f, -1.82420284e-01f, 6.24338984e-02f, 2.28616223e-01f, -7.98001289e-02f, -2.31240224e-02f, 1.16441362e-01f,
  -8.42920505e-03f, -1.36596426e-01f, -6.80041537e-02f, 1.48630947e-01f, -1.84894025e-01f, -2.51279712e-01f, 7.15821087e-02f, 1.42468885e-01f, -1.68654114e-01f, -2.35872762e-03f,
  2.70664066e-01f, -1.21430583e-01f, -4.42247055e-02f, 2.13456839e-01f, 2.42539085e-02f, -1.32271111e-01f, -4.54348564e-01f, -4.04434115e-01f, 1.13181315e-01f, 4.32902485e-01f,
  -1.64780661e-01f, -1.30787268e-01f, 5.04293069e-02f, -4.46234554e-01f, -1.16399698e-01f, -1.95580661e-01f, -1.80936322e-01f, 2.53922880e-01f, -2.80493349e-01f, -5.34387648e-01f,
  -4.57991064e-02f, -4.47293878e-01f, 7.74829611e-02f, -3.71695459e-01f, 2.72497125e-02f, 2.71241248e-01f, -2.18580827e-01f, 3.30048323e-01f, -7.17400834e-02f, 4.39695835e-01f,
  -1.25358428e-03f, -2.05875844e-01f, -2.49043748e-01f, -5.47192395e-01f, 1.11127295e-01f, 4.12264049e-01f, 3.73133458e-02f, 3.68734002e-02f, 1.59589142e-01f, -1.49066940e-01f,
  1.72005042e-01f, -2.50955671e-01f, -1.99248374e-01f, -6.19426548e-01f, 1.27530515e-01f, 2.28002831e-01f, 2.22475216e-01f, 5.08676946e-01f, 7.55679533e-02f, 2.48864412e-01f,
  -3.11843157e-01f, 2.64018267e-01f, 1.84498653e-01f, 2.49941662e-01f, -1.99504331e-01f, -2.48540714e-01f, -1.63969666e-01f, 9.19022188e-02f, 3.05146664e-01f, -3.47646505e-01f,
  1.50058642e-01f, -3.15857828e-01f, -1.01213671e-01f, 2.88411885e-01f, 1.19064070e-01f, 8.55242535e-02f, -5.90244591e-01f, 4.53805737e-02f, -4.82421853e-02f, 2.72423029e-01f,
  2.66142637e-01f, -1.65937796e-01f, -2.33579963e-01f, -2.34129742e-01f, 2.74805069e-01f, -6.52077124e-02f, -9.30553898e-02f, -4.04375911e-01f, -5.60880266e-02f, 4.97608572e-01f,
  -5.62362909e-01f, -1.62350461e-01f, -3.49765047e-02f, 3.68640609e-02f, -3.01647007e-01f, -8.28099251e-02f, -2.30920836e-01f, -3.21946740e-02f, -9.70266089e-02f, -2.96266466e-01f,
  6.74695075e-02f, 8.31518024e-02f, 7.19087273e-02f, -6.41401336e-02f, 1.62484393e-01f, -8.92968699e-02f, 6.49106130e-02f, 1.32570788e-01f, 2.94477969e-01f, -1.34982258e-01f,
  1.19451657e-01f, -3.81719798e-01f, 1.69270381e-01f, 7.29733184e-02f, 2.49413610e-01f, -3.41906160e-01f, -3.24630469e-01f, 1.06855862e-01f, 2.19642237e-01f, 4.33630496e-02f,
  2.14275524e-01f, 2.40457468e-02f, 1.57641023e-02f, 9.07581896e-02f, -2.34602004e-01f, 1.45361766e-01f, -4.93337773e-02f, 6.60740286e-02f, 9.44071934e-02f, 1.93834618e-01f,
  1.36927351e-01f, 8.23053643e-02f, 2.82248557e-01f, 3.00007343e-01f, 2.18227297e-01f, 1.94756463e-01f, -2.75620967e-01f, -2.04272658e-01f, 2.17778936e-01f, 3.06799948e-01f,
  -1.58250853e-01f, 2.80545890e-01f, 2.11758111e-02f, 4.01261479e-01f, -1.39006853e-01f, -6.85621351e-02f, 2.30558544e-01f, -2.67073035e-01f, -1.97128326e-01f, 1.87413275e-01f,
  1.68485433e-01f, -5.23414671e-01f, 1.58314705e-01f, 8.63762759e-03f, 3.49058717e-01f, 3.04795176e-01f, -2.35018224e-01f, 2.39971846e-01f, 1.68763757e-01f, -6.67783394e-02f,
  -4.86698091e-01f, -1.96707487e-01f, 1.22392558e-01f, -7.68642351e-02f, 3.91391784e-01f, -2.25787982e-01f, -1.44460291e-01f, -3.94785970e-01f, -2.88146615e-01f, 2.04753950e-01f,
  1.08189464e-01f, -8.72169361e-02f, -4.97446001e-01f, -3.46865624e-01f, -2.34065410e-02f, -1.09291062e-01f, 8.62146541e-02f, -2.36222237e-01f, -2.13536635e-01f, -2.72462547e-01f,
  1.60124019e-01f, 6.65433109e-01f, -6.90237666e-03f, -2.32240353e-02f, 3.03007931e-01f, -1.71125337e-01f, 2.86887616e-01f, -3.04694511e-02f, -3.11741270e-02f, -8.51428285e-02f,
  -9.22816917e-02f, -1.49505334e-02f, -4.02710050e-01f, 6.79548234e-02f, -1.99151531e-01f, 1.46977693e-01f, 9.92605686e-02f, -8.87879729e-02f, -7.60845691e-02f, -8.38665515e-02f,
  3.28361690e-01f, -1.84352871e-03f, -2.40771323e-01f, 3.02908897e-01f, 2.79567740e-03f, -4.44124103e-01f, -4.61107790e-01f, -3.82180244e-01f, 1.56796604e-01f, 2.04196014e-02f,
  3.29711080e-01f, 2.94582665e-01f, -1.10237643e-01f, -8.04969221e-02f, -3.74475360e-01f, 1.87053084e-01f, 3.11616331e-01f, -2.35985965e-01f, -1.49341539e-01f, -5.06022334e-01f,
  1.66212127e-01f, 1.34552702e-01f, -4.14848268e-01f, 1.08537763e-01f, -4.09636706e-01f, 3.84862646e-02f, -3.04098368e-01f, -4.47963446e-01f, -2.29568765e-01f, -3.39860916e-01f,
  2.97161378e-02f, 1.02279365e-01f, -4.92094696e-01f, 1.45363927e-01f, -3.52261774e-02f, -7.95881599e-02f, 1.53703764e-01f, -1.00831464e-01f, -6.77851319e-01f, -4.18430060e-01f,
  -3.15565825e-01f, 2.01841205e-01f, -3.85410756e-01f, 3.00070226e-01f, -1.81240901e-01f, 1.48865774e-01f, -3.25437129e-01f, -2.33987868e-01f, -1.75282747e-01f, -2.99961656e-01f,
  -1.52320683e-01f, 9.09773409e-02f, 7.77023584e-02f, 1.06162275e-03f, -3.66882123e-02f, 7.41524696e-02f, -3.65709923e-02f, 3.38080823e-02f, -2.69424796e-01f, -2.78100133e-01f,
  1.58339664e-01f, 8.07303712e-02f, 2.05212496e-02f, -2.84097999e-01f, 8.69103149e-02f, 1.27940685e-01f, -2.11466268e-01f, -3.15452367e-01f, -8.75284001e-02f, -6.45252615e-02f,
  2.51083046e-01f, 2.24971578e-01f, 1.69143409e-01f, 1.84935448e-03f, -4.40060124e-02f, -2.33340368e-01f, 1.50588229e-01f, -3.46323580e-01f, -1.52215296e-02f, -1.28982112e-01f,
  -1.53427482e-01f, -8.25169608e-02f, 1.95837002e-02f, -5.70724420e-02f, -2.12013652e-03f, -3.51903997e-02f, 3.05588067e-01f, -5.28738856e-01f, -6.69768825e-02f, 1.62493259e-01f,
  -3.20435971e-01f, 2.92927802e-01f, -4.68389660e-01f, 4.15167123e-01f, 9.83539969e-02f, -1.69869289e-02f, -2.42091700e-01f, -1.22875229e-01f, 1.25517830e-01f, -1.76435933e-02f,
  -2.21991971e-01f, -2.20957384e-01f, 4.24916595e-02f, 4.07604992e-01f, -3.98755968e-01f, -2.17843011e-01f, 8.00049212e-03f, 7.58769596e-03f, -4.06806827e-01f, 2.66876787e-01f,
  -3.87021393e-01f, 3.11712295e-01f, -1.20865136e-01f, -1.58694163e-02f, -1.07537666e-02f, 5.15439212e-02f, 1.60000831e-01f, 1.11514017e-01f, 1.42828882e-01f, 1.74931467e-01f,
  6.73408583e-02f, 8.17974061e-02f, -1.33256204e-02f, 1.39386311e-01f, -2.25286350e-01f, 1.96529850e-01f, -4.50294673e-01f, 2.68622428e-01f, 3.49276304e-01f, -2.02209100e-01f,
  1.90222561e-01f, -4.12601948e-01f, 2.60944813e-01f, -3.69136274e-01f, -3.94755661e-01f, -1.41140878e-01f, 5.10630496e-02f, -1.63801819e-01f, -2.50933111e-01f, 4.36624587e-01f,
  -2.28990108e-01f, -2.58370280e-01f, -2.98629642e-01f, -3.15515012e-01f, 3.43456000e-01f, -1.29729584e-01f, 3.15815568e-01f, -5.27594030e-01f, 1.60968453e-01f, 9.95343551e-02f,
  2.09630921e-01f, 4.52917907e-03f, 1.22307949e-01f, -2.30672896e-01f, 1.39019623e-01f, -2.30955273e-01f, -4.88986969e-01f, -1.68298304e-01f, 2.79747128e-01f, -3.33616525e-01f,
  -1.52010262e-01f, -3.78616601e-01f, -6.59825420e-03f, -9.38774273e-03f, -2.45944038e-01f, -2.58821517e-01f, 3.15038681e-01f, -2.21289009e-01f, -3.36955279e-01f, 3.42931658e-01f,
  -1.47389740e-01f, -3.59286517e-01f, 9.74352434e-02f, -2.13715672e-01f, -4.68469650e-01f, 3.69873703e-01f, -2.06366897e-01f, 2.73296654e-01f, -2.80183971e-01f, -1.80027679e-01f,
  6.46723583e-02f, 1.81901623e-02f, -4.70756926e-02f, -2.05151234e-02f, 5.13334394e-01f, 1.71824947e-01f, 3.23862731e-01f, 9.78516489e-02f, 2.12496325e-01f, -1.19505189e-01f,
  8.54413435e-02f, -3.82743657e-01f, -4.33574766e-01f, -3.38643461e-01f, -1.57975212e-01f, 2.04286829e-01f, -5.21610156e-02f, 4.41825956e-01f, 1.09453164e-01f, 2.44743049e-01f,
  4.17647034e-01f, -1.19932443e-01f, -1.61473334e-01f, -4.49125934e-03f, -3.57180178e-01f, 2.31779844e-01f, -9.47358459e-02f, 1.53621837e-01f, -4.01917875e-01f, -2.59263553e-02f,
  -1.06199704e-01f, -2.44235262e-01f, 1.85838059e-01f, -7.82416165e-02f, -5.31866290e-02f, 2.97575414e-01f, -2.11758807e-01f, 2.15905637e-01f, -5.12340844e-01f, -9.94566381e-02f,
  1.21758677e-01f, -5.69312982e-02f, -4.13811743e-01f, -1.55889392e-01f, -1.32514760e-01f, -2.40547404e-01f, -2.89410830e-01f, 1.22749373e-01f, 2.98151255e-01f, -3.83449495e-01f,
  9.48054418e-02f, -5.45978323e-02f, -6.71704352e-01f, -4.15883094e-01f, 2.18269639e-02f, 1.33958131e-01f, -3.22963923e-01f, 3.35647643e-01f, -2.33769462e-01f, -5.39061487e-01f,
  4.71262746e-02f, 6.12915903e-02f, 2.00644404e-01f, 2.29542684e-02f, 1.08198235e-02f, 1.09201550e-01f, 5.95618635e-02f, 6.93719164e-02f, 3.12973149e-02f, 4.08719294e-03f,
  -3.03781219e-02f, 4.72159503e-04f, -8.94543342e-03f, 2.72456378e-01f, -1.69466272e-01f, 1.62665531e-01f, 2.79398799e-01f, 2.88758546e-01f, -3.15077156e-01f, -2.36498713e-01f,
  -2.92421758e-01f, -1.57166675e-01f, 3.10215890e-01f, -1.65987328e-01f, -2.13147849e-02f, -1.91685557e-01f, -2.67337799e-01f, 7.26552680e-02f, -1.80057153e-01f, -2.14568511e-01f,
  3.61513458e-02f, -1.03234261e-01f, -1.67447999e-01f, -2.78310895e-01f, -3.86042893e-01f, -2.92733997e-01f, 3.07309628e-02f, -4.14532870e-01f, 6.71857819e-02f, -1.86919302e-01f,
  9.04174745e-02f, -1.29537418e-01f, 3.45473349e-01f, -1.87059999e-01f, 6.06338866e-02f, -4.59614277e-01f, -1.61883876e-01f, -3.87844384e-01f, -4.27621216e-01f, 1.81535929e-01f,
  -4.89228755e-01f, -3.10635298e-01f, -1.30627066e-01f, 5.06407440e-01f, 2.64950216e-01f, 4.70489293e-01f, -2.09430844e-01f, -1.00782372e-01f, -4.87883985e-01f, -1.08358443e-01f,
  6.16970360e-02f, -7.08740950e-03f, 3.96006435e-01f, 3.06897581e-01f, 5.92610762e-02f, 1.79018572e-01f, 9.19182673e-02f, -1.07487574e-01f, 5.81631735e-02f, -1.01470448e-01f,
  1.39787719e-01f, 6.64680153e-02f, 3.44495885e-02f, 1.92248106e-01f, 7.58214071e-02f, 1.34411231e-01f, -1.98386848e-01f, -1.61228210e-01f, -2.93960154e-01f, -3.04931253e-01f,
  3.88446391e-01f, -9.40499976e-02f, 1.74074527e-02f, -4.11982507e-01f, 1.07550904e-01f, 2.53219288e-02f, 1.50907725e-01f, -1.37075827e-01f, -4.57058638e-01f, 3.38391634e-03f,
  -2.19100043e-01f, 4.96104471e-02f, -4.68176812e-01f, 1.40633896e-01f, -3.85244399e-01f, -1.30972356e-01f, -3.20140332e-01f, -1.99272901e-01f, -2.32205316e-01f, 6.68841720e-01f,
  6.29111677e-02f, 1.44458801e-01f, -3.92335728e-02f, -1.42998576e-01f, -2.43016869e-01f, 1.49499858e-02f, 1.56681478e-01f, 2.77287930e-01f, -3.85719210e-01f, -2.57842392e-01f,
  6.58540726e-02f, 5.66037834e-01f, -1.76473409e-01f, -3.95421267e-01f, 1.15603149e-01f, -7.18836039e-02f, 1.19283302e-02f, 1.11235529e-01f, -4.24941182e-01f, -2.94967234e-01f,
  -3.18488151e-01f, 1.46780238e-01f, 1.72778681e-01f, 2.42750183e-01f, 2.98532188e-01f, -4.11584735e-01f, -1.07754692e-01f, -1.71913117e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.76812276e-01f, -6.38859943e-02f, 1.48075640e-01f, -3.27929184e-02f, -8.58212560e-02f, -1.20019130e-02f, 6.25275522e-02f, -3.54579557e-03f, -9.32293162e-02f, 1.42934993e-01f,
  4.76445034e-02f, 3.59349325e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    