/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.32813939e-01f, 3.65112185e-01f, 6.40599549e-01f, -2.81892478e-01f, -1.15291625e-01f, -2.63131768e-01f, -7.30317980e-02f, -1.68296248e-01f, -3.03385526e-01f, 8.78562853e-02f,
  9.13169309e-02f, -1.35180697e-01f, 1.04445495e-01f, 3.37168053e-02f, -1.20154746e-01f, 1.55856028e-01f, 6.72665462e-02f, 2.31658667e-01f, -2.19754979e-01f, -4.08649057e-01f,
  -2.87740171e-01f, 2.07664251e-01f, 2.60750979e-01f, -4.48940806e-02f, -6.28804183e-03f, -2.11753920e-01f, 2.26445705e-01f, 1.98655084e-01f, 4.15843874e-02f, 3.85771930e-01f,
  4.41264451e-01f, 1.07529797e-01f, -1.43200248e-01f, -7.64875337e-02f, 1.97009102e-01f, -3.23420130e-02f, -9.05569941e-02f, 1.16110556e-01f, -3.26943286e-02f, -3.45803015e-02f,
  3.83360460e-02f, 4.09186706e-02f, -1.12475986e-02f, 8.32419991e-02f, -2.92878430e-02f, 1.71363223e-02f, 4.60162014e-02f, 5.38898073e-02f, -4.34327424e-02f, 9.39743593e-03f,
  3.66016552e-02f, 5.51611073e-02f, 3.59963626e-02f, -9.79738161e-02f, -1.76938757e-01f, -5.83456717e-02f, 4.01367322e-02f, -1.06827393e-01f, -6.49122819e-02f, -4.65695746e-02f,
  -2.04878151e-02f, 9.39295907e-03f, -1.05582170e-01f, 1.58767551e-02f, 4.89153080e-02f, -4.19053696e-02f, -5.84479161e-02f, 1.32547608e-02f, -4.97410558e-02f, 2.11164188e-02f,
  1.39999343e-02f, 3.73387523e-02f, 3.24285701e-02f, 1.41493920e-02f, 9.03011560e-02f, 1.50979655e-02f, 1.18710781e-02f, 7.36952759e-03f, 1.63186900e-02f, 3.22162434e-02f,
  -1.96318757e-02f, -3.25236097e-02f, 5.98876700e-02f, 2.03596931e-02f, -1.12471636e-02f, 3.91392820e-02f, -2.01177597e-02f, 1.87402070e-02f, 3.51259820e-02f, -1.18697928e-02f,
  -9.46090221e-02f, -1.13153793e-01f, 4.93091047e-02f, -1.05344402e-02f, -3.30932699e-02f, 8.31095353e-02f, 6.31353855e-02f, -5.61737753e-02f, 5.73486164e-02f, -3.80801186e-02f,
  -7.41165802e-02f, 2.92038862e-02f, 6.89176098e-02f, -1.89890601e-02f, 5.84767433e-04f, -3.46707851e-02f, -4.16301787e-02f, -7.10721966e-03f, -6.41836897e-02f, 6.41467571e-02f,
  5.73804826e-02f, -1.30059063e-01f, -1.06875926e-01f, 1.19823078e-02f, -6.71681911e-02f, -1.35128587e-01f, 1.89926296e-01f, 3.58556360e-02f, -5.23713045e-02f, 1.23215830e-02f,
  1.03244402e-01f, 4.22352374e-01f, -6.58599973e-01f, 4.43515420e-01f, -1.37202963e-01f, -2.39770666e-01f, -1.94191813e-01f, -1.00695752e-01f, 1.47837639e-01f, 1.10702306e-01f,
  1.46181166e-01f, 2.95427948e-01f, 2.23281801e-01f, 7.29837120e-02f, -2.97803581e-01f, 1.52934436e-02f, -2.29121849e-01f, -3.22037548e-01f, -3.92796427e-01f, -1.10021293e-01f,
  1.58872947e-01f, 1.62043169e-01f, -1.82080865e-01f, 4.54392917e-02f, 4.62912261e-01f, 2.34439954e-01f, -6.19070940e-02f, -6.82964697e-02f, -9.19541717e-02f, 8.98265764e-02f,
  1.03578746e-01f, -1.66675806e-01f, -1.35538563e-01f, 1.30302645e-02f, 3.34666693e-03f, -7.74758309e-02f, 1.22638103e-02f, -1.81424599e-02f, 9.45183039e-02f, 4.90233302e-02f,
  2.67508887e-02f, -5.25157601e-02f, -5.19950613e-02f, 3.16236690e-02f, -3.03926598e-02f, -2.00583115e-02f, -6.69650286e-02f, -2.02456236e-01f, -7.34312683e-02f, 7.78039359e-03f,
  1.72597408e-01f, -7.87768289e-02f, -2.05303878e-01f, -1.02095589e-01f, -7.37389177e-02f, -2.42258124e-02f, -1.11148320e-01f, -1.03006005e-01f, -1.60530150e-01f, 1.46160215e-01f,
  8.49883780e-02f, 8.02541748e-02f, -5.51544651e-02f, 2.06580497e-02f, 9.09109935e-02f, 5.71866930e-02f, -2.25390885e-02f, 5.40380478e-02f, -2.48961002e-02f, 5.70186712e-02f,
  -9.04250816e-02f, 6.53379783e-02f, -5.21212537e-03f, -2.67686765e-03f, 8.69208574e-02f, -6.18165433e-02f, -6.55861199e-02f, 1.18183576e-01f, 4.91723903e-02f, -1.38167012e-02f,
  -2.15583052e-02f, -8.90308321e-02f, 4.34459597e-02f, -2.79530212e-02f, -8.87430385e-02f, -3.59099470e-02f, -2.62592472e-02f, -3.27489153e-02f, 5.10429442e-02f, -4.76367138e-02f,
  3.66239041e-01f, -3.04132849e-01f, 2.90389061e-01f, -1.60894226e-02f, 6.24955557e-02f, -1.17232660e-02f, 5.18086813e-02f, 3.31597701e-02f, 8.68435353e-02f, 4.37645316e-02f,
  -8.99846628e-02f, -4.94465120e-02f, 8.35558400e-02f, -2.28523575e-02f, -1.63273129e-03f, -1.36866746e-02f, 1.12223826e-01f, 1.20546728e-01f, 5.62378997e-03f, 6.54155985e-02f,
  6.14789955e-04f, 1.22822702e-01f, 1.63625956e-01f, 1.92465529e-01f, 1.20164357e-01f, 1.76938642e-02f, 3.01318001e-02f, 6.07430413e-02f, -1.07382528e-01f, 3.21435720e-01f,
  8.06165576e-01f, -2.91157335e-01f, -2.00618029e-01f, 6.02452934e-01f, -4.97001350e-01f, -3.08491439e-01f, -6.97857380e-01f, -3.73778120e-02f, 3.57248008e-01f, -6.86042830e-02f,
  -2.53620744e-01f, 1.87590495e-01f, 1.66580722e-01f, 6.31906912e-02f, -2.28090957e-03f, -2.91024297e-01f, 3.00616119e-02f, 3.25950176e-01f, 2.01102421e-02f, -3.21813315e-01f,
  -1.40931934e-01f, 1.79084256e-01f, 5.62885225e-01f, 1.89089954e-01f, -2.83059068e-02f, 1.07917726e-01f, 8.38589147e-02f, 1.24450671e-02f, -3.29296023e-01f, 2.55315781e-01f,
  -1.38737664e-01f, -6.27492890e-02f, 2.72404496e-02f, 8.57953802e-02f, -5.54256402e-02f, 1.52095884e-01f, 1.52857406e-02f, 7.38925710e-02f, -6.70920778e-03f, 3.81152853e-02f,
  5.92909381e-02f, 3.53147835e-02f, 4.14337590e-02f, -3.54636461e-02f, -7.02581927e-02f, -6.69388175e-02f, 1.14492290e-01f, 1.43660069e-01f, 6.39653280e-02f, -8.21608752e-02f,
  -1.29951224e-01f, -9.22057778e-02f, -2.28122130e-01f, -1.19183794e-01f, 5.31991571e-02f, 1.11877173e-02f, -8.88226146e-04f, -4.73620892e-02f, -1.04073457e-01f, 1.46316677e-01f,
  -1.29684992e-02f, -3.38266976e-02f, -5.79198822e-02f, 2.72535756e-02f, -3.52746584e-02f, -5.53728873e-03f, 1.62975322e-02f, -3.31205502e-02f, -7.13653490e-02f, 5.23798764e-02f,
  -5.54831214e-02f, -9.43585858e-03f, -1.82526335e-02f, 4.25714664e-02f, 4.25649323e-02f, 2.87525523e-02f, 6.54071895e-03f, 3.79443094e-02f, -1.36700757e-02f, 4.40486148e-02f,
  -3.91253904e-02f, -1.73090175e-02f, 7.16856793e-02f, -3.51406038e-02f, -7.95373023e-02f, 4.07538190e-02f, 7.20132962e-02f, -5.65733612e-02f, 2.40124315e-02f, 8.12054053e-03f,
  1.22380055e-01f, -3.35753895e-02f, 1.15316585e-01f, -5.58558553e-02f, 1.46642365e-02f, 4.74127345e-02f, -4.66939919e-02f, -2.36179736e-02f, -1.52152153e-02f, 4.05651033e-02f,
  -6.41289949e-02f, 5.52169383e-02f, -1.26047628e-02f, 1.72708724e-02f, 1.29886661e-02f, -2.43114792e-02f, -2.08400879e-02f, -9.01877061e-02f, -4.46640141e-02f, 7.03896433e-02f,
  8.64125267e-02f, 4.50448096e-02f, 1.00058382e-02f, 2.82773301e-02f, 6.38151616e-02f, -3.29704657e-02f, -5.27099259e-02f, 3.93781923e-02f, -1.08420551e-01f, 7.04017878e-02f,
  6.75635457e-01f, -2.24913880e-01f, -6.06779814e-01f, -8.07423666e-02f, -3.06743443e-01f, -1.38350844e-01f, -3.37984592e-01f, 1.68223470e-01f, 8.91023502e-02f, -2.41069689e-01f,
  3.67625169e-02f, 2.73453206e-01f, 8.00192058e-02f, 1.26217812e-01f, 1.13800772e-01f, -3.70942295e-01f, -5.36654055e-01f, -1.65868662e-02f, 4.34175760e-01f, 3.90469104e-01f,
  1.53188765e-01f, 4.33435477e-02f, 3.16671103e-01f, -4.81374841e-03f, -1.77704617e-01f, 9.21051502e-02f, -3.42031837e-01f, 1.04637541e-01f, 1.52689628e-02f, -4.08840716e-01f,
  -7.70414993e-02f, 3.42031382e-02f, 3.27219255e-02f, 4.45532314e-02f, -3.31672616e-02f, 1.87060311e-01f, 1.53020635e-01f, 8.43710452e-02f, 5.94229735e-02f, 1.06395306e-02f,
  -2.51757074e-02f, 5.72063997e-02f, 5.57751618e-02f, 6.10251650e-02f, 1.98293738e-02f, 5.38279004e-02f, -7.07288878e-03f, 5.50325625e-02f, -8.02517682e-02f, 1.80528723e-02f,
  -4.98804413e-02f, -1.07339807e-01f, -9.28249359e-02f, -6.09893426e-02f, 5.26572503e-02f, -3.78209651e-02f, -1.12850241e-01f, 1.26467317e-01f, 3.46697979e-02f, 1.11761548e-01f,
  -7.78134819e-03f, -6.57024831e-02f, -3.83573584e-02f, -3.63425426e-02f, 7.09022880e-02f, -3.69401425e-02f, -7.28653222e-02f, 1.67083871e-02f, 1.19078886e-02f, 4.85121086e-02f,
  -1.48055051e-02f, -5.99836037e-02f, 2.65784040e-02f, -4.03553098e-02f, -3.58417369e-02f, -2.65101101e-02f, -2.53534056e-02f, -5.60718663e-02f, 1.35433034e-03f, 3.62146571e-02f,
  8.84464532e-02f, 1.55524714e-02f, -8.59439000e-02f, 9.75638777e-02f, -5.83245568e-02f, -5.44893518e-02f, 2.68190168e-02f, -2.61336681e-03f, 3.69440801e-02f, -2.11531855e-02f,
  1.93472639e-01f, -1.50406480e-01f, -8.41329899e-03f, 2.00999677e-01f, -4.90367636e-02f, 3.02289799e-03f, -7.34538585e-02f, -1.89837031e-02f, -1.77036617e-02f, 6.58938438e-02f,
  8.50688368e-02f, 6.95251003e-02f, -8.78828764e-02f, 9.76707414e-03f, 6.74747899e-02f, 2.26111617e-02f, 4.98148650e-02f, -1.91040500e-03f, 3.77156436e-02f, 2.37600822e-02f,
  -7.12828860e-02f, 1.79475453e-02f, 1.65634975e-01f, 2.99456101e-02f, 8.12367275e-02f, 5.23178764e-02f, 5.82160130e-02f, -1.57191474e-02f, 4.59480509e-02f, 3.58885117e-02f,
  2.39574149e-01f, -3.17944139e-01f, -5.38627729e-02f, 3.51774283e-02f, 9.89245400e-02f, -3.12524997e-02f, -5.31033814e-01f, -1.20061465e-01f, 1.27082124e-01f, -3.51259291e-01f,
  2.81560153e-01f, 5.14424682e-01f, 2.00566962e-01f, 2.85745680e-01f, 1.14818597e-02f, -5.20362556e-01f, -3.41883779e-01f, 2.05192804e-01f, 4.12788391e-01f, 2.40819857e-01f,
  -1.82091049e-03f, 4.96023335e-02f, 1.94160432e-01f, 1.96298957e-01f, -2.94737518e-01f, 1.78418830e-01f, -3.03946048e-01f, 5.08359894e-02f, -1.05199687e-01f, -2.21345142e-01f,
  8.31852108e-02f, -3.37994881e-02f, 1.68544576e-01f, 2.06393182e-01f, 1.59185603e-01f, 4.69121262e-02f, 5.83925191e-03f, 2.90350728e-02f, 1.27438024e-01f, -1.25161894e-02f,
  1.80357978e-01f, 1.52713388e-01f, 1.85934871e-01f, 1.09883770e-01f, 5.03003299e-02f, 7.85566494e-02f, 4.66887578e-02f, 1.32203102e-01f, 1.23227991e-01f, 6.42945021e-02f,
  1.06234536e-01f, 2.12745816e-01f, 5.86607084e-02f, 9.59544629e-03f, 4.45846394e-02f, 2.33392343e-01f, 2.39392668e-02f, -1.12890620e-02f, 1.43158913e-01f, -2.17717022e-01f,
  6.50197715e-02f, 5.13866134e-02f, 3.38816084e-02f, -1.06686443e-01f, -5.08012697e-02f, -1.76057555e-02f, 9.89702065e-03f, -5.62956668e-02f, 1.84648056e-02f, -5.62174991e-02f,
  1.11640450e-02f, -5.74845076e-02f, 7.41234422e-02f, -2.47381069e-02f, 5.89938164e-02f, 4.38364595e-02f, 2.81993486e-02f, -4.75096330e-02f, 1.12493061e-01f, -9.32644531e-02f,
  2.85277180e-02f, 2.37387512e-03f, -4.26998511e-02f, 1.39464131e-02f, 5.13679311e-02f, 5.97642735e-04f, 2.29496323e-02f, 2.81400066e-02f, 1.34177823e-02f, 3.38319759e-03f,
  -2.58601340e-03f, 3.27735215e-01f, -2.63881478e-02f, 9.79427099e-02f, 4.53358144e-02f, 1.38555214e-01f, 1.20895945e-01f, 1.29869536e-01f, 1.35251775e-01f, 3.75422416e-04f,
  1.64913431e-01f, 1.03578240e-01f, 6.36509880e-02f, 8.29466060e-02f, 1.19024746e-01f, 2.02591941e-02f, 6.64974451e-02f, 1.18118905e-01f, 7.52658173e-02f, 3.98534685e-02f,
  3.75516101e-04f, -5.67855537e-02f, 3.73875126e-02f, 2.42009945e-02f, 1.41410545e-01f, 1.51276201e-01f, -1.82815511e-02f, 1.53050106e-02f, 3.34624648e-02f, -3.61332476e-01f,
  -4.23188031e-01f, -3.44592452e-01f, 6.29493967e-02f, -1.61548272e-01f, -1.72004476e-01f, -2.11215392e-01f, -5.52346528e-01f, -1.19415455e-01f, 9.54191834e-02f, -3.08772683e-01f,
  3.88354287e-02f, 4.24114466e-01f, 3.40621769e-01f, 2.99947619e-01f, -4.33727726e-02f, -3.87874782e-01f, -2.16100439e-01f, 6.97393492e-02f, 9.49502513e-02f, -1.64834753e-01f,
  -8.07847977e-02f, -3.21438432e-01f, -3.77347320e-02f, 1.15516316e-02f, -8.83922949e-02f, 2.28244662e-01f, 3.99007984e-02f, 5.98728359e-02f, 9.23626870e-02f, 3.20495367e-01f,
  1.45112500e-01f, 2.16317140e-02f, 1.53468296e-01f, 5.69841415e-02f, -6.27811207e-03f, 3.50833796e-02f, 3.47117260e-02f, 4.59401831e-02f, 1.36150010e-02f, 2.34988667e-02f,
  7.91592300e-02f, 2.62763985e-02f, -3.64230201e-02f, 1.32375926e-01f, -6.59043491e-02f, 6.64686859e-02f, 4.63482961e-02f, 6.56690374e-02f, 6.53749630e-02f, 3.76314623e-03f,
  3.80554982e-02f, -1.29264062e-02f, -1.37160182e-01f, 1.30609171e-02f, -1.75545514e-02f, 3.98886465e-02f, 3.16354749e-03f, 9.72523540e-02f, 3.74165922e-02f, -3.13353203e-02f,
  -3.04217786e-02f, 3.98215838e-02f, -2.75576822e-02f, -3.26842777e-02f, 1.26447005e-03f, 4.88484092e-02f, 1.19057205e-03f, -8.87024552e-02f, 5.26670106e-02f, -3.02095562e-02f,
  1.33466907e-02f, -3.37361693e-02f, 2.47523334e-04f, -3.86353135e-02f, 1.89731736e-02f, -5.03707044e-02f, -5.06562702e-02f, -5.11503452e-03f, 3.62967215e-02f, -7.13165523e-03f,
  -1.27324117e-02f, 4.04491015e-02f, -3.13818716e-02f, 3.23985815e-02f, 1.32940505e-02f, -2.79787108e-02f, 4.48737759e-03f, 1.99649427e-02f, -6.62745908e-02f, -2.42392346e-02f,
  -7.08222985e-02f, 8.86964872e-02f, 9.01677064e-04f, 8.58305860e-03f, -5.06220572e-02f, -1.09775725e-03f, 1.05648628e-02f, -1.39742652e-02f, 3.28619219e-02f, -3.28673460e-02f,
  -9.80209908e-04f, -7.29585662e-02f, 9.24355257e-03f, -1.83389634e-02f, -1.01478636e-01f, 1.99131649e-02f, -1.28854379e-01f, 2.56279111e-02f, -2.40172874e-02f, -4.58342321e-02f,
  -9.50359851e-02f, -1.04583420e-01f, -6.93777669e-03f, 1.77266113e-02f, -8.48905370e-03f, -2.36206204e-02f, -2.03691870e-02f, -7.68499263e-03f, -3.23756528e-03f, -2.06634790e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.27544436e-02f, 3.30667436e-01f, -8.71858776e-01f, 2.51453221e-01f, -6.53565705e-01f, -4.27524865e-01f, -1.84304208e-01f, 9.08669531e-01f, 6.18783355e-01f, -5.73729314e-02f,
  4.35731001e-02f, -6.45922542e-01f, -6.36981785e-01f, -2.94150442e-01f, -3.52772832e-01f, -5.18643141e-01f, -1.19246960e+00f, -1.36040938e+00f, -1.34347486e+00f, -9.50668380e-02f,
  -1.70597821e-01f, -1.06777027e-01f, 8.71505141e-02f, 1.73242837e-01f, -3.57547492e-01f, -6.27318084e-01f, -3.05516303e-01f, -6.69353604e-01f, -2.37056851e-01f, -1.49526465e+00f,
  -1.31872046e+00f, 1.56123832e-01f, 5.14391214e-02f, 9.54225808e-02f, -3.25381719e-02f, -1.92775071e-01f, 1.84149861e-01f, -1.74590364e-01f, 1.13431014e-01f, -1.59935981e-01f,
  -1.29417717e-01f, -8.25235918e-02f, -3.83865386e-01f, -2.74485141e-01f, -4.62427810e-02f, -8.39162767e-02f, -2.32304409e-02f, 1.18333019e-01f, -1.67771623e-01f, 1.89106390e-01f,
  -1.64450601e-01f, -4.87774938e-01f, -2.36349240e-01f, 4.00335282e-01f, 2.61155099e-01f, 4.20109704e-02f, 4.58867580e-01f, -1.01528026e-03f, 8.12861025e-02f, -1.31985292e-01f,
  1.03910260e-01f, -1.34074479e-01f, -3.53088453e-02f, 1.11952029e-01f, 3.83248590e-02f, 3.63705978e-02f, -8.01766142e-02f, -1.83832049e-01f, 1.28469869e-01f, -1.46803349e-01f,
  8.47114921e-02f, 1.03245795e-01f, -2.57818284e-03f, 1.17632009e-01f, -1.52283907e-01f, -2.11270466e-01f, -1.15160778e-01f, -7.48653486e-02f, 8.94487947e-02f, 6.80132732e-02f,
  -2.06872493e-01f, -1.10317051e-01f, -1.05701298e-01f, -3.35348654e-03f, -6.73442185e-02f, 3.88356633e-02f, 5.82808517e-02f, 1.97030455e-01f, 1.61716044e-01f, 3.86008739e-01f,
  2.60437042e-01f, 7.63683245e-02f, -1.48148566e-01f, 2.39349782e-01f, -4.05614138e-01f, -8.53355601e-02f, -5.92503399e-02f, -3.16479313e-03f, -2.95956135e-01f, -6.12307945e-03f,
  -1.19725605e-02f, -3.01900283e-02f, 4.09499370e-02f, 9.19987038e-02f, 6.88974606e-03f, 1.14185341e-01f, -8.03409517e-02f, -4.38597739e-01f, -4.20800745e-02f, 1.59043670e-01f,
  3.57457101e-01f, -2.21906051e-01f, -3.13326746e-01f, -2.94685841e-01f, -1.32117525e-01f, -3.12337518e-01f, -1.43761173e-01f, -1.03114925e-01f, -2.01615855e-01f, 3.25425029e-01f,
  6.91677034e-01f, -1.31014359e+00f, 1.10191971e-01f, -3.88565473e-02f, -8.22725222e-02f, 1.13875099e-01f, -1.46421745e-01f, -1.77378178e-01f, -1.50695831e-01f, -4.33438659e-01f,
  -3.73836458e-01f, 2.31337234e-01f, 3.10968935e-01f, 1.87044829e-01f, 4.06448126e-01f, -9.10022929e-02f, -2.11187992e-02f, 7.78186202e-01f, 1.07813227e+00f, 1.30892530e-01f,
  -3.32206488e-01f, 8.94516930e-02f, 4.24305260e-01f, 2.30175331e-01f, -5.65335453e-01f, 2.56715864e-01f, -3.48785013e-01f, -4.66296554e-01f, -6.17655814e-01f, -1.12569201e+00f,
  -2.11623847e-01f, -8.68514180e-01f, 4.77249742e-01f, 3.16826403e-02f, -2.00108618e-01f, -4.08921763e-02f, 9.31566432e-02f, -1.87941238e-01f, -4.33500782e-02f, -1.45030886e-01f,
  -1.52870476e-01f, -1.00851499e-01f, -3.91562469e-02f, -3.57103869e-02f, -5.35995588e-02f, -4.41548713e-02f, -8.08487460e-02f, -7.55232871e-02f, -6.60024285e-02f, -2.50763625e-01f,
  -2.70900428e-01f, -5.26765168e-01f, -2.03937829e-01f, -6.81596696e-02f, -1.19752817e-01f, 2.20562115e-01f, -2.74552494e-01f, -4.21668589e-01f, -1.91769511e-01f, -3.30931664e-01f,
  9.19778049e-02f, -3.82342897e-02f, -7.53442794e-02f, 6.53747022e-02f, 1.07706763e-01f, -8.52395520e-02f, -1.06135104e-02f, 8.19108076e-03f, 1.28187180e-01f, 4.49568070e-02f,
  -1.35978371e-01f, 8.81597772e-02f, 5.29900528e-02f, -5.08140288e-02f, 8.00404176e-02f, -2.36101121e-01f, 1.20081091e-02f, -1.07152993e-02f, 1.99820846e-02f, 9.61883441e-02f,
  -7.00255260e-02f, 3.40168439e-02f, -2.34457515e-02f, -4.80329022e-02f, -2.26946354e-01f, -5.03981188e-02f, -5.22253998e-02f, -5.22717694e-03f, 3.18156295e-02f, -6.75138608e-02f,
  1.20102756e-01f, 4.30101037e-01f, 3.24047841e-02f, -4.79652546e-03f, -9.41220149e-02f, -1.16420411e-01f, -1.62722953e-02f, -2.59085521e-02f, -1.35488719e-01f, -1.08731642e-01f,
  -1.48825541e-01f, 1.52690299e-02f, -2.34114006e-02f, -4.78145666e-02f, 3.93660784e-01f, 8.06994215e-02f, -9.86311659e-02f, 1.95787475e-01f, 4.78408001e-02f, -6.09168410e-03f,
  -8.25458393e-02f, 1.63065046e-01f, 4.30874467e-01f, 2.76598006e-01f, -6.74316064e-02f, 5.79582572e-01f, 1.69656008e-01f, 2.26646066e-01f, 5.32411277e-01f, 4.85786855e-01f,
  1.70962298e+00f, 5.48082769e-01f, 2.26547062e-01f, 6.96732998e-01f, 2.08445445e-01f, -2.29801446e-01f, -1.36367694e-01f, -1.31992340e-01f, 5.82965203e-02f, 2.60621220e-01f,
  3.09492141e-01f, 4.45399106e-01f, 2.26438597e-01f, 1.75158501e-01f, 7.26794302e-02f, -3.90675068e-02f, -1.50356174e-01f, 1.00785442e-01f, 1.72719106e-01f, 2.75239021e-01f,
  4.11872476e-01f, 8.39901567e-02f, 2.15923667e-01f, 4.26048599e-02f, 2.47428954e-01f, 1.87590107e-01f, -1.36559740e-01f, -2.24846546e-02f, 1.68715283e-01f, 4.70283508e-01f,
  3.94254118e-01f, 4.47193295e-01f, -1.72632352e-01f, 4.75501157e-02f, -1.16397269e-01f, -1.67721927e-01f, -2.44601583e-03f, -1.91135451e-01f, -1.25640422e-01f, -1.12615585e-01f,
  -3.97938443e-03f, 8.62669498e-02f, 1.48486912e-01f, -9.54898074e-02f, -1.35026857e-01f, -1.24312066e-01f, -7.40102977e-02f, 1.27510101e-01f, 9.97013301e-02f, -2.33282801e-03f,
  2.93306321e-01f, 7.69911855e-02f, -6.73602968e-02f, -1.19488053e-01f, 1.43514320e-01f, 7.60022104e-02f, -1.04191028e-01f, -2.64610685e-02f, -7.85187706e-02f, 2.34057888e-01f,
  9.78518426e-02f, 2.07514152e-01f, 2.44289219e-01f, 9.05761309e-03f, 2.07966551e-01f, -9.93576571e-02f, -1.25643328e-01f, 5.68499602e-03f, 2.42419988e-01f, 5.50017022e-02f,
  -1.35409623e-01f, 8.26073289e-02f, -1.76202208e-01f, -4.98814136e-02f, 9.87849087e-02f, 1.68502778e-02f, -1.39107063e-01f, -1.06391698e-01f, 7.69717097e-02f, -1.90104410e-01f,
  2.70533204e-01f, -1.63862899e-01f, 2.87651531e-02f, 1.53486338e-02f, -2.72389531e-01f, 8.62256140e-02f, 1.62212104e-01f, 1.08985856e-01f, 1.80518553e-02f, 1.67571306e-01f,
  -1.15277553e+00f, -1.28719822e-01f, 2.86775500e-01f, -4.49677967e-02f, -6.34380206e-02f, -3.93861160e-03f, 3.66715312e-01f, -1.48779124e-01f, -1.73989207e-01f, -4.47163805e-02f,
  -1.47675186e-01f, 2.00189531e-01f, 1.63681284e-01f, -1.62446778e-02f, -2.07136288e-01f, -2.41993845e-01f, 4.04412746e-02f, -4.91989814e-02f, -2.60747492e-01f, -2.43237048e-01f,
  -8.44442695e-02f, -3.41029406e-01f, -2.67389983e-01f, -1.60131603e-01f, -1.27349764e-01f, -1.60749465e-01f, -2.50696242e-01f, -4.07233447e-01f, -3.16219985e-01f, -2.72436142e-01f,
  -2.10229349e+00f, -2.59876668e-01f, -7.30639219e-01f, 2.82812398e-02f, 9.82960343e-01f, -1.37525171e-01f, -6.34541333e-01f, -8.14846396e-01f, 2.89138444e-02f, -6.40610605e-02f,
  1.48529008e-01f, 4.53881115e-01f, 1.27189741e-01f, 8.37188810e-02f, -7.07164228e-01f, 7.67574012e-02f, 8.23262513e-01f, -3.24003607e-01f, -5.63880384e-01f, 2.79364586e-02f,
  7.46388495e-01f, -3.00984848e-02f, -7.59968460e-01f, -2.19831660e-01f, 4.16133046e-01f, 4.21925277e-01f, 2.40442455e-01f, -2.03708485e-01f, 1.77256331e-01f, 7.17501104e-01f,
  -6.87342167e-01f, -1.18019211e+00f, 5.57316244e-01f, 4.23151284e-01f, 2.77606491e-02f, -4.52171743e-01f, -2.79597640e-01f, -9.93847772e-02f, 1.11947998e-01f, -1.62479937e-01f,
  1.57605305e-01f, -3.17554958e-02f, 4.33690369e-01f, 2.42987704e-02f, 3.97015177e-02f, -3.72984588e-01f, -2.58292705e-01f, -6.88043237e-01f, -5.69776118e-01f, -3.34339559e-01f,
  9.27446127e-01f, 6.07832111e-02f, -6.15924478e-01f, 4.92495410e-02f, -2.51685679e-01f, 5.29112220e-01f, -3.85968029e-01f, -4.51134622e-01f, -8.44293058e-01f, -8.24243546e-01f,
  9.68764164e-03f, 3.22887748e-02f, -6.16596974e-02f, -1.36446476e-01f, 5.69076873e-02f, 1.23813059e-02f, 1.95450455e-01f, 1.74741372e-01f, 6.16463274e-02f, -1.72639981e-01f,
  5.20094782e-02f, 1.73908472e-01f, 1.12673258e-02f, -9.86191854e-02f, 2.06301529e-02f, 4.60316129e-02f, -6.51831329e-02f, 3.43849398e-02f, -2.02918753e-01f, 9.59171951e-02f,
  -7.09233731e-02f, -2.34217361e-01f, 1.43968374e-01f, -4.55203168e-02f, 2.91185603e-02f, -2.82971680e-01f, -4.94567454e-02f, 2.69663762e-02f, -1.87209114e-01f, 8.19566026e-02f,
  -1.61910459e-01f, 6.52249455e-01f, -1.97136432e-01f, -2.47080609e-01f, 4.97182757e-02f, 2.66685873e-01f, 2.17234164e-01f, -8.26098323e-02f, -4.65442427e-02f, -2.38212481e-01f,
  -8.69255364e-02f, -1.44863486e-01f, -8.74775425e-02f, 1.78526983e-01f, -3.17479074e-02f, -1.29060196e-02f, 2.34807897e-02f, 9.34648290e-02f, 3.44951339e-02f, 2.13563517e-01f,
  1.12344883e-01f, -4.96892869e-01f, -6.59045398e-01f, -2.62810767e-01f, -2.61359870e-01f, -4.21521872e-01f, -3.03851634e-01f, -5.47858775e-01f, -7.18150556e-01f, -7.89847791e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.69123220e+00f, 1.85281289e+00f, 7.82043040e-01f, 1.10611248e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.55949497e+00f, 3.77109647e-01f, 7.04492450e-01f, -2.27751136e+00f, -1.07635248e+00f, -5.14924765e-01f, -9.76164699e-01f, -2.01993585e-01f, -4.85463947e-01f, 2.82524556e-01f,
  3.06417793e-01f, 4.37100470e-01f, 5.36139071e-01f, -4.68196630e-01f, -1.03675604e+00f, 2.63245199e-02f, -1.08031189e+00f, 5.83291292e-01f, -1.61734253e-01f, -1.42221165e+00f,
  -6.55153751e-01f, -8.50284845e-02f, -1.57064688e+00f, 3.15016955e-01f, 1.02343190e+00f, 4.17076498e-01f, 1.03330398e+00f, 8.93513560e-01f, -1.74295947e-01f, 7.82893181e-01f,
  7.78420269e-01f, -2.50930333e+00f, 2.19904721e-01f, -5.49960136e-01f, -4.67309922e-01f, 8.00833523e-01f, -5.19444883e-01f, 2.82566577e-01f, 1.29863930e+00f, -1.67060602e+00f,
  1.55684400e+00f, -5.82599282e-01f, 1.00023103e+00f, 1.15479052e+00f, -1.02050090e+00f, 6.39643848e-01f, -8.34994614e-01f, 4.46824491e-01f, 4.11955535e-01f, 4.68165457e-01f,
  -3.14080358e+00f, 4.10266548e-01f, -2.96310801e-02f, 3.32077920e-01f, -3.90992433e-01f, -1.49961746e+00f, -1.07781589e+00f, -1.16141057e+00f, -1.86467603e-01f, 1.24846190e-01f,
  3.18197012e-01f, -1.20364153e+00f, -1.34702051e+00f, 4.11615789e-01f, 1.06978834e+00f, 2.25153789e-01f, 2.35880899e+00f, 1.37017059e+00f, -2.13130161e-01f, -9.11770403e-01f,
  7.59455204e-01f, 1.22383666e+00f, -1.40931368e-01f, -7.58125111e-02f, 9.92844030e-02f, 4.18238550e-01f, 4.15337890e-01f, -1.66922402e+00f, -9.43461835e-01f, 2.05383524e-01f,
  1.01440869e-01f, -1.40674686e+00f, 2.73340166e-01f, 2.44502760e-02f, 6.51446939e-01f, 7.50693440e-01f, -1.11661553e+00f, 1.07159019e+00f, 1.50905478e+00f, 1.17004168e+00f,
  -1.02184260e+00f, -1.66718197e+00f, 2.35060275e-01f, 1.22810528e-02f, -1.26098469e-01f, -6.08565569e-01f, -3.00686628e-01f, 1.11973310e+00f, -1.68744183e+00f, 1.19657147e+00f,
  3.24435622e-01f, 1.27363348e+00f, 1.46150005e+00f, -4.51112330e-01f, 2.07339883e+00f, 5.85288890e-02f, -4.43004161e-01f, -4.14262325e-01f, -1.66987157e+00f, -1.54758906e+00f,
  3.60552341e-01f, -1.57206476e+00f, 4.88351025e-02f, -4.26631659e-01f, 1.82131112e-01f, -1.18527293e+00f, -8.51555705e-01f, -6.82918012e-01f, -1.54105949e+00f, 3.35386954e-02f,
  -1.35458601e+00f, 1.21694006e-01f, -7.56221116e-01f, -4.32088822e-01f, -1.90394986e+00f, -9.98193920e-01f, -1.34475708e-01f, 1.20417714e+00f, -3.27729344e-01f, 2.92519987e-01f,
  8.11349452e-01f, 9.57803428e-02f, 1.92432806e-01f, -7.51307189e-01f, -1.20023465e+00f, -1.37189078e+00f, -6.28255129e-01f, -2.26741180e-01f, -7.57694781e-01f, -1.27947986e+00f,
  -2.05186939e+00f, 1.28426123e+00f, -4.49600101e-01f, -5.83809674e-01f, 1.61214605e-01f, 2.71269023e-01f, 4.70479816e-01f, -6.21982366e-02f, 3.45784277e-01f, 5.85408092e-01f,
  1.27846813e+00f, 1.76380801e+00f, 1.48439276e+00f, 2.40084864e-02f, 1.08231914e+00f, 1.01595068e+00f, -5.72972953e-01f, -1.81961429e+00f, 6.10945150e-02f, 7.88823903e-01f,
  3.15437943e-01f, -6.01739101e-02f, -6.57074928e-01f, 6.53331101e-01f, 4.20846015e-01f, 4.06783253e-01f, 2.02313423e+00f, 1.44910359e+00f, -2.48425651e+00f, 3.52569014e-01f,
  -7.47810781e-01f, 1.23537016e+00f, -6.73466921e-01f, 8.63644302e-01f, -1.67616260e+00f, -4.64152247e-01f, 9.48682606e-01f, -4.86208230e-01f, 2.38748282e-01f, -4.17324603e-02f,
  3.72801572e-01f, -1.05053437e+00f, 1.22902775e+00f, -1.36814392e+00f, -2.15928102e+00f, -9.66007650e-01f, -4.64428961e-01f, -5.21341205e-01f, 1.30455241e-01f, -1.70335770e+00f,
  3.15008134e-01f, -1.18983793e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.26150250e-01f, 8.24485049e-02f, -1.46256849e-01f, -4.28758323e-01f, 1.82651710e-02f, -1.10115699e-01f, -2.38530278e-01f, 2.55461246e-01f, -2.47616455e-01f, -3.92604023e-01f,
  -1.69144675e-01f, 4.45857823e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    