/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.67090178e-01f, -2.02219337e-02f, 3.72079283e-01f, 1.75549775e-01f, 1.00078866e-01f, -8.67408663e-02f, -4.04796237e-03f, -4.15800214e-02f, 3.31822336e-02f, -3.14305156e-01f,
  -3.74229588e-02f, 1.73459336e-01f, -2.21626639e-01f, -1.20178826e-01f, 6.48632407e-01f, -1.55280605e-01f, -9.24794190e-03f, -2.66966317e-02f, 4.45245393e-02f, -1.19167315e-02f,
  1.75949991e-01f, -1.14122748e-01f, 2.27302790e-01f, -1.29841626e-01f, 2.90890485e-01f, 5.27403466e-02f, 6.27541691e-02f, 7.14169741e-02f, 5.92937432e-02f, 9.39455777e-02f,
  -8.92850629e-04f, -9.84471887e-02f, 4.59206067e-02f, -1.03976838e-01f, -3.53212506e-02f, -8.85496438e-02f, 2.24579219e-02f, 7.13604987e-02f, 1.02108516e-01f, -2.03648638e-02f,
  4.78550084e-02f, 4.34909165e-02f, -6.12754598e-02f, 6.55845255e-02f, -2.51857806e-02f, 3.62571850e-02f, 1.02248788e-01f, 1.33350231e-02f, -3.36906612e-02f, 5.62994890e-02f,
  2.68648509e-02f, 5.47645837e-02f, 3.17429043e-02f, -5.57408370e-02f, 6.50155991e-02f, -2.51378808e-02f, -2.63925605e-02f, 5.67800216e-02f, 1.84007138e-02f, 1.91642288e-02f,
  -2.97427550e-02f, 8.38899985e-04f, 3.07507589e-02f, 2.31459718e-02f, 8.32575485e-02f, -7.07028955e-02f, 3.56819965e-02f, -4.81761545e-02f, 6.56913146e-02f, 1.04038836e-03f,
  2.55265031e-02f, 1.05057610e-02f, -1.61240771e-02f, -1.03815505e-02f, 1.05176177e-02f, -2.48703212e-02f, 1.96920447e-02f, -6.78820685e-02f, -2.00662687e-02f, 5.66501543e-02f,
  -4.37619649e-02f, -3.05713732e-02f, 1.72636844e-02f, -9.03300941e-02f, -4.12763506e-02f, 3.64917181e-02f, 3.15755680e-02f, -9.67638288e-03f, 4.30130400e-02f, 5.43461703e-02f,
  -1.03908151e-01f, -1.46079838e-01f, -1.37703307e-02f, 2.43833158e-02f, -1.01786656e-02f, 5.01588956e-02f, 2.21841335e-02f, 3.77630517e-02f, -7.96927586e-02f, 2.37705465e-03f,
  -5.25124706e-02f, -6.70809373e-02f, 4.79856832e-03f, -1.85816083e-02f, 5.59046119e-02f, -6.26936331e-02f, -1.14631891e-01f, -7.66123459e-03f, 2.70373523e-02f, -4.45595651e-05f,
  1.70093812e-02f, -1.01300031e-02f, 1.94352135e-04f, -4.50097956e-02f, 1.04897339e-02f, 3.75481159e-03f, 7.25775957e-02f, 6.77153654e-03f, -3.12356418e-03f, -5.26515469e-02f,
  -8.87147427e-01f, -1.00656264e-01f, -3.14578652e-01f, -2.33399451e-01f, -3.31561625e-01f, 6.72536045e-02f, 2.02016663e-02f, -3.50407392e-01f, -2.52284467e-01f, -1.08819216e-01f,
  -3.06908607e-01f, 2.28967130e-01f, -1.74394980e-01f, 1.13646463e-02f, -8.40455890e-02f, 5.16880117e-02f, -3.74868780e-01f, -9.32804346e-02f, 6.87706172e-02f, -2.52190650e-01f,
  -1.18181258e-01f, 3.05832662e-02f, -1.04402974e-01f, 1.68703616e-01f, -2.24906921e-01f, -2.13863030e-01f, -1.85066894e-01f, 2.06551388e-01f, -3.73305418e-02f, 2.00536355e-01f,
  1.35082111e-01f, -5.30198477e-02f, -1.08246416e-01f, -9.26295668e-02f, -1.67141363e-01f, -8.62586871e-03f, 1.57100111e-02f, 1.20426811e-01f, 8.49374160e-02f, 5.05187083e-03f,
  -1.51048461e-02f, 5.97898848e-02f, 5.26987351e-02f, 4.77251820e-02f, -6.80784211e-02f, -4.27861214e-02f, 4.90199290e-02f, -6.57538772e-02f, 3.17319743e-02f, -6.40194342e-02f,
  -6.18913844e-02f, 1.21181617e-02f, -1.38943553e-01f, 2.43921597e-02f, -4.26351093e-02f, 3.83452363e-02f, 3.69895883e-02f, 8.80024303e-03f, -1.99651606e-02f, 6.44863537e-03f,
  -2.38742288e-02f, 5.43716773e-02f, -3.11778784e-02f, -1.76328439e-02f, 1.07412105e-02f, -1.89074054e-02f, 6.13244958e-02f, 1.56978890e-02f, 2.23271236e-01f, -9.45380330e-02f,
  3.59991007e-02f, -7.51076788e-02f, -2.00655814e-02f, 4.65174429e-02f, 1.22142313e-02f, -3.12242750e-02f, -4.70834039e-02f, -1.16757350e-03f, -1.31525829e-01f, -1.76346265e-02f,
  4.72738706e-02f, -2.43330542e-02f, 8.22559465e-03f, -6.74301088e-02f, 7.91856125e-02f, -2.21064338e-03f, 1.53724011e-03f, -1.30520761e-01f, 4.67893593e-02f, 5.15555739e-02f,
  -3.95387501e-01f, -2.02867478e-01f, 3.01082822e-04f, 1.67052060e-01f, 7.01001883e-02f, 2.10844353e-02f, -6.71334118e-02f, -6.18258342e-02f, 5.20083196e-02f, -8.70622098e-02f,
  -2.20010057e-02f, -1.00040361e-01f, -5.43013327e-02f, -4.51996960e-02f, 1.15494691e-02f, -9.75114033e-02f, -3.70883718e-02f, 1.67124718e-02f, -7.58086368e-02f, -5.64596578e-02f,
  -4.26250622e-02f, 2.70635504e-02f, 9.68489200e-02f, -1.42811328e-01f, 3.73434499e-02f, -9.70548615e-02f, -1.50448918e-01f, 6.63045570e-02f, 6.37744442e-02f, 4.19664979e-02f,
  -2.32769065e-02f, -7.58280307e-02f, -3.76860738e-01f, -1.53635517e-01f, -1.22488096e-01f, -2.32032120e-01f, 3.12187850e-01f, -1.92113489e-01f, -1.31912539e-02f, 2.29352757e-01f,
  1.61671028e-01f, 1.88298319e-02f, 3.03416461e-01f, -3.89468893e-02f, 2.99882710e-01f, 2.07215786e-01f, -5.58998808e-02f, -8.73818621e-03f, -8.45097378e-02f, -1.03463538e-01f,
  -1.16576061e-01f, 1.40003502e-01f, -1.35010988e-01f, -1.68469518e-01f, -1.42794982e-01f, -8.03983882e-02f, 3.81276757e-01f, 8.93170573e-03f, -1.40939862e-01f, 7.73010701e-02f,
  -1.35528341e-01f, -2.45887756e-01f, -1.05339937e-01f, -3.15209478e-02f, -6.60226494e-02f, 6.71153367e-02f, -2.47822963e-02f, 9.03336778e-02f, -5.33964895e-02f, -2.82520484e-02f,
  7.31487125e-02f, -1.61291048e-01f, 2.46467516e-02f, 2.83662677e-02f, -7.86664262e-02f, -9.15820152e-02f, -7.08403289e-02f, -6.20252304e-02f, -1.86729565e-01f, -8.82516652e-02f,
  -7.44828656e-02f, -1.31923020e-01f, 6.11770786e-02f, 2.49462761e-03f, -1.19820284e-03f, -1.10747576e-01f, -3.35570127e-02f, 2.11978238e-02f, -2.57336926e-02f, -1.44890994e-01f,
  1.33808970e-01f, 6.26804084e-02f, -8.76903906e-02f, 4.67560478e-02f, -5.78254983e-02f, -1.30580505e-02f, -1.95797328e-02f, -9.08353254e-02f, -1.99945047e-02f, -1.66012230e-03f,
  -5.57268448e-02f, -3.88055108e-02f, 1.13461874e-01f, -3.89054045e-02f, 7.27066770e-02f, -5.24465274e-03f, 3.42664793e-02f, 4.66270894e-02f, 8.96792263e-02f, -4.43640836e-02f,
  1.46177392e-02f, -1.77148357e-02f, 4.80933301e-02f, -4.18652184e-02f, -3.95631865e-02f, 1.01741120e-01f, -5.12082800e-02f, -6.32138625e-02f, 9.29800887e-03f, 6.97252005e-02f,
  2.81755805e-01f, 4.02153492e-01f, 1.36432007e-01f, -1.01874918e-01f, 3.45612876e-02f, -4.94400300e-02f, 9.34774950e-02f, -5.90302609e-02f, 1.52095571e-01f, -3.96782234e-02f,
  -8.27153102e-02f, 7.26027694e-03f, 4.08604257e-02f, -6.78156363e-03f, 8.33412185e-02f, 1.49994995e-02f, 7.65995160e-02f, 7.29416981e-02f, 1.81229800e-01f, 3.32111940e-02f,
  -9.58243944e-03f, -1.42056094e-02f, -7.43716434e-02f, -3.52365635e-02f, 2.47071777e-02f, 2.07307041e-02f, 1.16656832e-01f, 7.24933520e-02f, -5.83692268e-02f, 3.52284163e-02f,
  -6.37146890e-01f, -3.14369529e-01f, 1.36653394e-01f, -3.64820659e-01f, 1.14245459e-01f, -2.60115921e-01f, -6.73461854e-02f, -8.91506076e-02f, -2.33357996e-01f, -2.69509465e-01f,
  1.56865731e-01f, -3.52728993e-01f, 1.36465549e-01f, -1.59502953e-01f, 2.50097424e-01f, 6.82312399e-02f, -1.03671230e-01f, -2.22904474e-01f, -4.01273482e-02f, -9.57017168e-02f,
  -5.83849736e-02f, 5.35239279e-02f, 2.72127092e-01f, 4.01003361e-02f, -8.39300677e-02f, -8.31588507e-02f, 7.37860873e-02f, 7.70206824e-02f, -3.68303247e-02f, 2.78917234e-02f,
  2.37983942e-01f, -3.38430665e-02f, -7.75634274e-02f, -2.93460786e-02f, 1.97884627e-02f, -1.57161593e-03f, -1.16852839e-02f, 8.01091865e-02f, 3.63419540e-02f, -4.74962257e-02f,
  -1.21729160e-02f, -4.82552685e-02f, 3.48390010e-03f, 9.50742140e-03f, -1.26858979e-01f, -4.57706675e-02f, 4.42161486e-02f, 6.75331848e-03f, -2.26248410e-02f, 8.33188072e-02f,
  2.69397832e-02f, 7.51770511e-02f, -3.06223854e-02f, -3.71839069e-02f, 5.62111437e-02f, -1.18533216e-01f, 7.86069594e-03f, 9.21401605e-02f, -5.42518497e-02f, -7.56558552e-02f,
  -3.89885753e-02f, -6.35141656e-02f, -1.05695426e-02f, 4.00931127e-02f, 3.37213161e-04f, 4.43215743e-02f, -7.85604119e-02f, 2.47357283e-02f, -1.25452936e-01f, 1.65609643e-02f,
  -1.41946431e-02f, -3.91475819e-02f, 6.18859194e-02f, -8.72180611e-02f, -3.51643451e-02f, -5.62631898e-02f, 1.60987563e-02f, 3.90233323e-02f, 1.00045511e-02f, 6.87112808e-02f,
  1.25524011e-02f, 3.13845137e-03f, -1.30958967e-02f, 7.88123310e-02f, -1.37931565e-02f, 1.88187677e-02f, -8.64123702e-02f, -3.48114595e-02f, 9.80838686e-02f, 1.47476168e-02f,
  -4.81413715e-02f, -2.85775632e-01f, 5.37699871e-02f, -8.85999948e-03f, -5.49957044e-02f, -6.25972822e-02f, 4.96127196e-02f, -6.30122572e-02f, -8.07036236e-02f, 1.91387851e-02f,
  -7.36294985e-02f, 2.59289183e-02f, -6.29567653e-02f, -4.08714078e-02f, 1.03603207e-01f, 3.42918076e-02f, 1.98174939e-02f, -2.99580153e-02f, -2.88735069e-02f, -3.11248414e-02f,
  -3.76468301e-02f, -1.35479748e-01f, -2.89230961e-02f, 4.61260639e-02f, -8.49246830e-02f, 1.05140574e-01f, -2.68732458e-02f, -1.29527017e-01f, 1.25601087e-02f, -3.02386228e-02f,
  2.38361791e-01f, -6.61406159e-01f, -3.75570893e-01f, 2.32009031e-02f, 1.35257870e-01f, -2.14621320e-01f, -2.46410325e-01f, -1.52204931e-01f, -1.06125161e-01f, -3.56127247e-02f,
  -9.73605886e-02f, 2.39555165e-02f, -2.80520141e-01f, -1.00318149e-01f, -1.37516007e-01f, -3.87023658e-01f, -1.12491310e-01f, 2.79370267e-02f, -2.24140614e-01f, -1.27505306e-02f,
  -4.39392868e-03f, -5.63842133e-02f, -1.17999136e-01f, -6.88795075e-02f, -1.00626916e-01f, 1.34317018e-02f, 1.43097267e-01f, -9.63345990e-02f, 2.17767984e-01f, -4.92481561e-03f,
  9.75324884e-02f, -1.03062578e-01f, -2.84168292e-02f, -1.05620511e-01f, -5.75082898e-02f, 6.97477162e-02f, 4.23929840e-02f, -5.35081187e-03f, 8.43271166e-02f, -5.76862805e-02f,
  -1.74926899e-04f, 6.57545999e-02f, -1.07559480e-01f, 1.65021606e-02f, 4.08549942e-02f, 4.52194437e-02f, 2.45597307e-03f, 8.12057629e-02f, 1.67380441e-02f, -8.92558135e-03f,
  -9.19535663e-03f, 4.02846187e-02f, 3.75015773e-02f, 1.81922484e-02f, -2.15578042e-02f, -1.47660062e-01f, -4.35760692e-02f, 1.14927599e-02f, -7.30203092e-02f, 1.32871149e-02f,
  7.91294947e-02f, 2.92490143e-03f, -2.45384849e-03f, 1.01597130e-01f, 3.40859964e-02f, 2.67599486e-02f, 7.60163963e-02f, 4.11240682e-02f, -5.03359251e-02f, 5.06608970e-02f,
  9.32097435e-02f, -2.52992343e-02f, 5.64620122e-02f, 5.80710955e-02f, 7.86998644e-02f, 7.31697083e-02f, 3.53581756e-02f, -3.45480964e-02f, 7.24859536e-02f, 1.09399604e-02f,
  5.41682504e-02f, -2.84756708e-04f, 7.43735954e-03f, 2.97469366e-02f, -7.21673220e-02f, 8.60439166e-02f, 1.72391403e-02f, -3.52602005e-02f, 1.88424077e-03f, -4.46739979e-03f,
  -2.46145234e-01f, -4.73248720e-01f, -2.34475192e-02f, 5.45547381e-02f, 4.60325927e-02f, -1.34328213e-02f, 2.52620894e-02f, -4.01392765e-02f, -3.49015966e-02f, -6.42832816e-02f,
  9.13680866e-02f, -8.14991817e-02f, 1.81476459e-01f, 1.10217817e-01f, -2.47540716e-02f, -9.19750333e-02f, 7.77334049e-02f, 2.57782824e-02f, -1.94952693e-02f, -2.04309542e-02f,
  6.58562258e-02f, 1.32555356e-02f, 7.61846453e-02f, -1.73938852e-02f, 4.17213105e-02f, 1.14159852e-01f, 7.13901073e-02f, 2.17084810e-02f, 3.65723781e-02f, -5.57046756e-02f,
  1.86482057e-01f, 4.76165116e-01f, 2.18877658e-01f, 4.87626582e-01f, -3.02527994e-01f, 3.18092018e-01f, 2.80830860e-02f, 1.01115882e-01f, -1.08659968e-01f, 1.06748916e-01f,
  2.12872792e-02f, 7.61798397e-02f, 8.68729651e-02f, 4.58428711e-01f, -5.76636642e-02f, 9.33942199e-02f, 3.28579009e-01f, 2.13847905e-01f, -1.20513074e-01f, 1.67182922e-01f,
  4.39124145e-02f, 1.15330346e-01f, 1.32334918e-01f, -3.73667628e-02f, 6.99312240e-02f, 4.00652438e-02f, 4.23599109e-02f, -9.89215299e-02f, 2.86035836e-01f, 3.38006653e-02f,
  6.93489611e-02f, -7.03048930e-02f, -1.63564004e-03f, 5.03942743e-02f, 3.15156206e-02f, 7.30571002e-02f, 1.41897677e-02f, -3.36393192e-02f, -3.88292186e-02f, 2.47062203e-02f,
  -1.38091728e-01f, -9.36018676e-02f, 4.35651764e-02f, -2.56147645e-02f, -2.83267591e-02f, -2.81838328e-03f, -2.70711575e-02f, 1.69384927e-02f, -8.96712914e-02f, 6.06965460e-02f,
  -7.36189783e-02f, 1.28072858e-01f, -8.83934461e-03f, 1.21151067e-01f, 3.28329243e-02f, -3.19955796e-02f, 1.27440933e-02f, -2.11472772e-02f, -1.45574724e-02f, 1.34829031e-02f,
  6.42587319e-02f, -8.23256269e-04f, -4.12530713e-02f, -6.36438420e-03f, -4.64491509e-02f, 2.29253419e-04f, -2.17397027e-02f, 2.68531125e-02f, -5.58940247e-02f, 8.33979063e-03f,
  -9.23485029e-03f, -1.30097074e-02f, 5.20036779e-02f, 1.26758143e-02f, 6.21958375e-02f, 1.69028416e-02f, -9.00937468e-02f, -2.14527245e-03f, -1.31418630e-02f, 6.56315777e-03f,
  -5.45529602e-03f, -2.20483337e-02f, -3.48979495e-02f, 4.70687635e-02f, 5.00031449e-02f, 2.64371596e-02f, 1.42014204e-02f, -2.53104456e-02f, -1.87254418e-02f, 8.07617232e-03f,
  7.40008503e-02f, 1.43581569e-01f, 2.33363360e-04f, -6.47564651e-04f, -5.21247787e-03f, -9.50739682e-02f, 7.22348243e-02f, 5.54060861e-02f, 6.95454404e-02f, -4.59259283e-03f,
  7.95370117e-02f, 5.81231900e-02f, -1.54687492e-02f, 4.54922430e-02f, -8.47378687e-04f, 3.77621176e-03f, 6.83531016e-02f, -4.35189269e-02f, 1.06769212e-01f, -4.87726089e-03f,
  6.39857538e-03f, -1.21642411e-01f, -1.75313540e-02f, -8.18609223e-02f, 6.26897067e-02f, 5.49985878e-02f, -2.12520119e-02f, -4.06092033e-02f, 4.05742303e-02f, 7.45708030e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.44347680e+00f, 5.02519548e-01f, 3.03675473e-01f, -7.78390467e-01f, -1.03162801e+00f, -7.74853051e-01f, -5.01159430e-01f, -1.82464659e-01f, -7.32516125e-02f, 7.91772902e-01f,
  -2.74599493e-01f, 8.08597565e-01f, 3.84653479e-01f, -2.06918269e-02f, -4.29238468e-01f, 8.81948113e-01f, -4.05675396e-02f, 2.73449212e-01f, -1.87060192e-01f, -4.78990555e-01f,
  -5.54138303e-01f, -6.88577533e-01f, 7.80311152e-02f, -5.56021214e-01f, -8.56211185e-01f, -1.76666662e-01f, -6.00512505e-01f, -3.18787217e-01f, -3.63972843e-01f, -3.32610041e-01f,
  -6.84061885e-01f, -1.52719676e-01f, 2.34246314e-01f, 3.34978163e-01f, -2.78938532e-01f, -1.83911934e-01f, -1.33517563e-01f, -1.34677561e-02f, 1.47817573e-02f, -4.76281494e-02f,
  1.99822441e-01f, -1.32847264e-01f, -1.33397788e-01f, 1.86704785e-01f, -6.73537180e-02f, -1.15311414e-01f, -3.45947407e-02f, -1.11177631e-01f, 1.44321308e-01f, 2.10571736e-01f,
  1.61822736e-01f, 6.42375648e-02f, -1.47137970e-01f, 1.16051644e-01f, -2.19041109e-01f, -9.31883156e-02f, 1.39728799e-01f, 1.78886484e-02f, -9.26071256e-02f, -3.18427831e-01f,
  -7.98986480e-02f, 3.71334911e-03f, 7.95956627e-02f, 2.33280793e-01f, 8.80866349e-02f, -1.95960060e-01f, 1.12243943e-01f, -1.31708831e-01f, -4.62020114e-02f, -4.02760059e-02f,
  -2.21341133e-01f, 4.80030142e-02f, 8.37281048e-02f, 5.05115055e-02f, -5.81273660e-02f, 1.74018279e-01f, 9.73342061e-02f, -4.92423140e-02f, 1.02165319e-01f, -1.56904563e-01f,
  7.97207430e-02f, -4.89666089e-02f, 1.37140572e-01f, -1.91989690e-01f, -1.53547674e-01f, 1.61657967e-02f, -1.05734482e-01f, 9.72753242e-02f, -1.29922017e-01f, -4.08977240e-01f,
  -5.84793091e-01f, -1.23884547e+00f, -4.45163017e-03f, -7.27606714e-02f, -2.82098390e-02f, -1.73645929e-01f, 5.43814600e-02f, -1.15419559e-01f, -3.06606591e-01f, -1.36819303e-01f,
  1.19252346e-01f, 5.16381301e-02f, -3.51162732e-01f, -4.69078980e-02f, 4.56388481e-02f, -4.76892740e-02f, -2.09458575e-01f, -1.23042360e-01f, -3.20665866e-01f, -4.63747084e-02f,
  9.05913934e-02f, 3.27783078e-02f, 1.76020324e-01f, -1.26461565e-01f, -2.57752184e-02f, -2.53154431e-02f, -4.91756201e-02f, 1.79769069e-01f, -1.34602651e-01f, 1.85701232e-02f,
  -1.15811157e+00f, 1.74509895e+00f, 8.66920769e-01f, -3.37598592e-01f, 1.14673460e-02f, -8.99171472e-01f, -4.86318707e-01f, 7.14165986e-01f, -4.92264807e-01f, 5.73355913e-01f,
  -1.46671921e-01f, 4.27237958e-01f, 6.13245666e-01f, -5.50525129e-01f, -1.37409043e+00f, -4.91127729e-01f, -8.70922267e-01f, -1.54020742e-01f, -2.51077890e-01f, 2.03683108e-01f,
  -3.79494220e-01f, -5.96641719e-01f, 4.62391190e-02f, 3.80775064e-01f, 3.03207248e-01f, 6.54542208e-01f, 1.45898089e-01f, 7.04960585e-01f, -3.96751240e-02f, -9.66803581e-02f,
  -3.30131143e-01f, 3.49695057e-01f, 3.54167610e-01f, 8.44275355e-02f, -1.04353711e-01f, 9.24956501e-02f, 4.31143194e-02f, -3.45810838e-02f, -7.60076568e-02f, -2.59738173e-02f,
  5.23890816e-02f, 5.74535429e-02f, -3.07476223e-02f, 1.89212114e-01f, 4.77443449e-02f, 2.94001848e-01f, 2.44388446e-01f, 2.32460573e-02f, 6.59134751e-03f, 1.97497830e-01f,
  2.24215448e-01f, 2.33368248e-01f, 1.13883764e-01f, -1.38483405e-01f, 3.43876958e-01f, 1.42882532e-02f, -2.80403137e-01f, 3.00495297e-01f, 1.61488965e-01f, -1.04151018e-01f,
  -1.42277833e-02f, -3.70276496e-02f, 1.11784087e-02f, 1.70722231e-03f, -1.20780885e-01f, -2.70306505e-02f, -1.20913424e-01f, -1.01846449e-01f, -4.93870080e-02f, 3.20235342e-02f,
  -2.81100839e-01f, 8.84874314e-02f, -6.62537515e-02f, -9.15435553e-02f, -2.58609474e-01f, -1.39440615e-02f, 9.75255519e-02f, 2.08337963e-01f, -2.33082119e-02f, -2.50631452e-01f,
  7.38115609e-02f, -2.08092779e-01f, 1.67002618e-01f, -4.37914096e-02f, 1.84133742e-02f, 3.09245974e-01f, 1.11303501e-01f, 2.46057883e-01f, 1.15088202e-01f, 1.26184210e-01f,
  -2.55800873e-01f, 3.14000189e-01f, -7.44240135e-02f, -1.92089528e-01f, -3.98766957e-02f, -1.56525120e-01f, -4.97656092e-02f, 8.40525329e-02f, 1.22669406e-01f, -2.34732643e-01f,
  1.47696763e-01f, -1.10523812e-01f, -1.23939924e-01f, -1.39184043e-01f, -1.53597951e-01f, -2.30146691e-01f, -8.89116824e-02f, -1.13497868e-01f, -7.77392313e-02f, 6.60869181e-02f,
  2.06605107e-01f, -8.30707923e-02f, -1.21799320e-01f, -6.54385537e-02f, -1.98110536e-01f, -2.30434369e-02f, 1.85078055e-01f, 2.89899483e-02f, -8.78588706e-02f, 9.12855789e-02f,
  1.92532092e-01f, -3.98487031e-01f, -1.81898445e-01f, -7.49078035e-01f, 6.79679438e-02f, 1.23183513e+00f, 1.15238667e+00f, -3.20421964e-01f, -1.08540618e+00f, 4.53097373e-01f,
  5.06863534e-01f, -1.40346572e-01f, 6.08827472e-01f, 1.36807039e-01f, 2.19096333e-01f, 1.65402874e-01f, 3.51609409e-01f, 6.93081141e-01f, -5.20462811e-01f, 4.61085774e-02f,
  -1.88407779e-01f, 4.32715625e-01f, 2.79013216e-01f, -2.25496575e-01f, 2.67383218e-01f, -6.49674118e-01f, 1.31491423e-01f, 1.97561204e-01f, 1.49005026e-01f, 6.85671344e-02f,
  1.00244120e-01f, -3.43340933e-01f, -1.41792044e-01f, 3.03821377e-02f, 1.23908058e-01f, 2.02666670e-01f, 2.13151157e-01f, 2.80673653e-01f, -1.70863345e-01f, -7.95293301e-02f,
  3.25204656e-02f, 1.18955260e-03f, -3.18541616e-01f, 2.50141080e-02f, -7.90584236e-02f, -2.11502969e-01f, -3.07823598e-01f, -1.08412318e-01f, -2.15043962e-01f, 9.58345383e-02f,
  -2.33045663e-03f, -8.64072517e-02f, -2.92135812e-02f, -1.50536029e-02f, -1.19784035e-01f, -1.02522977e-01f, 7.62935504e-02f, 1.76756561e-01f, 9.63664576e-02f, 1.14629196e-03f,
  3.96223068e-02f, 1.21048987e-01f, 1.95367441e-01f, -1.89658359e-01f, 4.12129834e-02f, -1.17022000e-01f, 6.36231303e-02f, 6.05884083e-02f, -1.75440107e-02f, 6.77818656e-02f,
  -1.77902982e-01f, 7.04059303e-02f, 4.91447793e-03f, 4.08196412e-02f, 8.65959153e-02f, -1.07314780e-01f, 2.25689501e-01f, -1.02864206e-02f, 5.09673613e-04f, -1.35872737e-01f,
  -1.26742214e-01f, 1.07206441e-02f, 1.33841157e-01f, 9.02949944e-02f, 5.25505394e-02f, -1.29849806e-01f, 7.36277923e-02f, -1.52784809e-01f, 7.38637447e-02f, -2.42592264e-02f,
  -7.30564222e-02f, -1.90459356e-01f, -1.69043869e-01f, -7.05486760e-02f, -1.35930806e-01f, 6.03850000e-02f, -2.07570478e-01f, -1.55488133e-01f, 1.15202507e-02f, 4.85179424e-02f,
  2.38804147e-01f, 1.39065951e-01f, 4.18845005e-02f, 7.20087215e-02f, -5.91849573e-02f, 8.98469761e-02f, 1.25870273e-01f, -1.18595101e-01f, 1.04711324e-01f, 3.01590767e-02f,
  7.17892498e-02f, 3.22048277e-01f, 3.93717689e-03f, -7.09867850e-02f, -7.89822713e-02f, 1.49642587e-01f, -8.56376886e-02f, 5.96677698e-03f, 4.92039360e-02f, 9.80524048e-02f,
  7.39098012e-01f, -3.25092852e-01f, 1.03175640e+00f, 5.14962435e-01f, 1.84940845e-01f, 3.85514855e-01f, 9.67503548e-01f, -2.68396258e-01f, 1.09691381e+00f, -9.01605606e-01f,
  -9.85647082e-01f, 6.06595874e-01f, 4.15170014e-01f, -7.40387261e-01f, 7.24049211e-01f, 1.63409203e-01f, -1.64828137e-01f, 7.00763687e-02f, 1.63971975e-01f, -9.89997461e-02f,
  -7.44983107e-02f, -1.22005415e+00f, -9.27211940e-02f, -1.25585115e+00f, -3.83326918e-01f, -1.16027288e-01f, -7.73539066e-01f, 3.82249355e-01f, -1.19720030e+00f, -2.23536834e-01f,
  -1.72964528e-01f, 6.72991038e-04f, -1.99427694e-01f, 1.59031406e-01f, -9.90987942e-02f, 1.25513569e-01f, 4.79449444e-02f, 2.86111891e-01f, 2.73721099e-01f, 6.11636825e-02f,
  8.27948302e-02f, -4.92504872e-02f, -2.03087568e-01f, 2.44982138e-01f, 1.12648077e-01f, -7.32442513e-02f, 1.36055261e-01f, -7.87037462e-02f, 4.07761894e-02f, 3.35290700e-01f,
  1.94494799e-01f, -3.45697962e-02f, 2.52672117e-02f, 1.36537418e-01f, 2.38954037e-01f, 3.27669196e-02f, 5.02254628e-02f, 3.09131354e-01f, -3.60709578e-02f, 1.99300662e-01f,
  -7.59429708e-02f, 2.82745570e-01f, 1.56138688e-01f, -3.06185216e-01f, 2.19595022e-02f, -3.11074048e-01f, 1.11337036e-01f, -7.68489987e-02f, 1.69769540e-01f, 3.55914831e-02f,
  -1.28587991e-01f, 1.61052018e-01f, 2.23386154e-01f, -1.79896317e-02f, -1.56003416e-01f, -7.38433599e-02f, 1.03771932e-01f, -4.10046689e-02f, 2.02638984e-01f, -1.24908954e-01f,
  6.83761016e-02f, 1.48039982e-01f, -6.51472956e-02f, 3.92158255e-02f, 1.65549926e-02f, 2.74600029e-01f, -2.12232560e-01f, 2.30809003e-01f, 4.37123589e-02f, 4.56214324e-02f,
  -1.50670841e-01f, -2.09595278e-01f, -2.73096085e-01f, -2.39014253e-01f, -4.56468388e-02f, -3.67692590e-01f, 2.88091868e-01f, -2.50459790e-01f, 9.56269801e-02f, -9.81264338e-02f,
  -5.89098819e-02f, -7.19235539e-02f, -1.33944990e-03f, -3.45813446e-02f, 1.12665035e-02f, -1.88820615e-01f, 1.32890251e-02f, -2.92274922e-01f, -9.72853154e-02f, -2.77215749e-01f,
  -1.95270523e-01f, 1.33099928e-01f, 1.58768803e-01f, -3.03187788e-01f, -4.42020595e-01f, 1.10559817e-02f, 1.48115769e-01f, -3.77616920e-02f, -5.13259135e-03f, -4.38228138e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.33134460e+00f, 1.83824408e+00f, 1.54618180e+00f, 1.65398335e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.80618548e+00f, 1.00339937e-03f, -1.89123556e-01f, 7.49132991e-01f, -1.39248490e-01f, -8.96001995e-01f, -1.71687448e+00f, 1.17215562e+00f, 1.03941607e+00f, 1.17794168e+00f,
  -6.97561204e-01f, 1.62471449e+00f, 7.86343396e-01f, -1.02626717e+00f, 6.08208776e-01f, -1.47691524e+00f, 1.49313760e+00f, -1.64383128e-01f, -1.09524369e+00f, 7.27697611e-01f,
  9.68507111e-01f, 4.12183702e-02f, -5.45427263e-01f, -9.19099212e-01f, 1.20507812e+00f, -2.08953476e+00f, -1.46472633e+00f, 1.11642945e+00f, -2.11803365e+00f, -1.88385499e+00f,
  1.56373382e+00f, -2.01134467e+00f, -9.09163535e-01f, 1.50460041e+00f, 7.18456566e-01f, 1.51073372e+00f, -1.58679509e+00f, 1.56139350e+00f, 2.30234766e+00f, 1.36395240e+00f,
  -1.21116817e+00f, 9.61082101e-01f, 2.32229733e+00f, 1.98626804e+00f, -1.18717635e+00f, -1.25221646e+00f, 2.77866066e-01f, -1.51021397e+00f, -2.34599352e+00f, -1.10815847e+00f,
  -8.41127113e-02f, -7.74634123e-01f, 2.87265003e-01f, -1.39515388e+00f, -8.73836458e-01f, 1.64649558e+00f, -7.19220579e-01f, 9.32153523e-01f, -4.26401168e-01f, -1.74597394e+00f,
  3.09109330e-01f, 1.04306436e+00f, -1.20867431e+00f, -1.34960222e+00f, 1.93227363e+00f, -8.59141886e-01f, 2.06619650e-01f, -1.02805233e+00f, -1.86613083e-01f, 1.44300771e+00f,
  -9.17987883e-01f, 1.62974334e+00f, -1.98965359e+00f, 2.18973660e+00f, -2.31271386e+00f, -1.51918519e+00f, 3.04548353e-01f, -1.44950431e-02f, -7.77769834e-03f, -1.63240600e-02f,
  8.27098012e-01f, 1.00006354e+00f, 1.10840523e+00f, -9.44911599e-01f, -1.84812450e+00f, 1.08590400e+00f, -1.16084743e+00f, -7.22703040e-01f, 1.31088853e+00f, -2.45101619e+00f,
  -1.94848228e+00f, 1.10674632e+00f, 3.04499745e-01f, -1.62629807e+00f, -4.78720188e-01f, 6.19204462e-01f, -1.66365057e-01f, -1.36849928e+00f, -1.35622585e+00f, 1.13509309e+00f,
  1.44946039e+00f, 9.95173633e-01f, 1.29045856e+00f, -2.10834408e+00f, -2.09899330e+00f, -3.31575334e-01f, 6.29687846e-01f, -1.48195195e+00f, -1.47250617e+00f, -1.67044318e+00f,
  -1.11723018e+00f, 1.00373483e+00f, 7.09861398e-01f, -8.92697275e-01f, -1.28143823e+00f, -7.14009106e-02f, -7.66910315e-01f, -2.34903836e+00f, -3.99203114e-02f, 9.78599966e-01f,
  1.78645456e+00f, 2.79080123e-01f, 1.63396406e+00f, -8.21040928e-01f, 1.21727991e+00f, -9.74506259e-01f, -1.86307132e+00f, 1.96932569e-01f, -7.63870999e-02f, -1.48989522e+00f,
  8.93947363e-01f, 9.26365197e-01f, 6.54786348e-01f, -1.47999108e+00f, 2.18707180e+00f, -1.51766706e+00f, 5.26954651e-01f, -5.67286670e-01f, -1.79981613e+00f, 1.76998854e+00f,
  -1.72112441e+00f, 8.55225027e-01f, -1.34520888e+00f, -1.89377761e+00f, -1.12543631e+00f, 9.63269651e-01f, 4.15139437e-01f, -5.79567492e-01f, 2.61576870e-03f, -1.70898139e-01f,
  1.23285627e+00f, 8.94000828e-01f, 1.07027030e+00f, 2.29198551e+00f, 2.18899056e-01f, -9.74310637e-01f, -4.99806195e-01f, -1.11774623e+00f, 7.36307442e-01f, 8.01546156e-01f,
  -5.96429169e-01f, 1.18390250e+00f, 1.25863135e+00f, 6.18213475e-01f, 1.75199598e-01f, 5.97109258e-01f, -2.29191208e+00f, -1.05134857e+00f, 4.99228925e-01f, -2.84816083e-02f,
  1.66728878e+00f, -1.96011293e+00f, -1.65530288e+00f, 6.54469788e-01f, 5.65559983e-01f, -1.55108571e+00f, 4.92034554e-01f, 7.50726700e-01f, -1.55178380e+00f, -2.34632707e+00f,
  6.96703136e-01f, 7.56812766e-02f, 1.03925061e+00f, -5.69000542e-01f, -1.47779465e+00f, -1.80792046e+00f, 1.00441825e+00f, 1.28748298e+00f, 2.99181312e-01f, 7.27072597e-01f,
  -9.19297099e-01f, -2.59966612e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.44813693e-01f, 6.70605123e-01f, 1.43680573e+00f, -6.15432978e-01f, -2.05383096e-02f, 2.41173565e-01f, 2.08610699e-01f, 4.10533369e-01f, 1.00243449e+00f, -1.35274041e+00f,
  1.88960522e-01f, -7.43814647e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    