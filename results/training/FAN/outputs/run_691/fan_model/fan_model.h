/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.68751812e-01f, -9.49169248e-02f, -2.06417903e-01f, -1.79241732e-01f, 1.05354168e-01f, -2.14831904e-02f, 7.85484761e-02f, 4.47196029e-02f, 2.07540765e-02f, 9.15890485e-02f,
  1.91591322e-01f, 1.14267781e-01f, 4.26022857e-02f, 7.68665820e-02f, -7.73476670e-03f, -2.93502156e-02f, -6.78020716e-02f, -2.61994570e-01f, -9.27341357e-02f, 4.34789807e-02f,
  -1.90641684e-03f, -2.15746626e-01f, -2.03719854e-01f, -8.70428309e-02f, 1.25902658e-02f, 7.07823709e-02f, 6.39668480e-02f, 1.03137391e-02f, 5.94610497e-02f, 6.55026585e-02f,
  -1.35321870e-01f, -1.62502602e-01f, -2.73358473e-03f, -8.83656088e-03f, -1.16334381e-02f, -2.84249317e-02f, -6.61018789e-02f, -6.65361881e-02f, 2.75622103e-02f, -9.35987756e-02f,
  4.16845754e-02f, -7.65933618e-02f, 1.22534344e-03f, 1.00540303e-01f, -4.60177995e-02f, -1.03950158e-01f, -4.74907598e-03f, -2.57079434e-02f, -1.09668508e-01f, 3.68394479e-02f,
  4.51360606e-02f, -1.12749711e-01f, -2.10289448e-01f, -5.29538980e-03f, 3.62733267e-02f, -8.28759149e-02f, -5.54837883e-02f, 3.51167805e-02f, 9.43950936e-03f, -1.72809809e-02f,
  5.47168218e-02f, 1.02908770e-02f, -4.34414111e-02f, -6.82704300e-02f, 3.33684757e-02f, -2.12320033e-03f, -1.85177196e-02f, -1.20887475e-03f, 3.75905000e-02f, -5.16034439e-02f,
  2.46244445e-02f, 9.68780369e-03f, -8.44306648e-02f, 1.12949172e-02f, 3.77410240e-02f, -4.94383238e-02f, -6.13343939e-02f, 2.46495306e-02f, -1.68657433e-02f, -1.09040372e-01f,
  -9.50362012e-02f, 1.15719009e-02f, -2.56384239e-02f, 6.79475814e-02f, 1.98810007e-02f, 3.83328050e-02f, -3.56432684e-02f, -5.64563833e-03f, -1.31672136e-02f, -4.65668924e-02f,
  -6.22048900e-02f, -6.20143935e-02f, -6.15664572e-02f, -5.15030418e-03f, -3.43257412e-02f, -1.82938166e-02f, 1.94277242e-02f, -9.96118933e-02f, 6.02546893e-03f, -7.25226775e-02f,
  -6.21654764e-02f, -8.38022679e-02f, -2.08377466e-02f, -1.27539057e-02f, 2.75105573e-02f, -3.08079645e-03f, 2.30898918e-03f, -3.98365520e-02f, -2.09232140e-02f, -5.82510643e-02f,
  3.78778949e-02f, -1.51137903e-01f, -2.09397554e-01f, -8.11919644e-02f, -4.84496690e-02f, -6.63174242e-02f, -9.44058299e-02f, -7.44610652e-02f, -5.99827431e-02f, -1.44108325e-01f,
  5.38740456e-01f, 7.25196376e-02f, -1.98457703e-01f, 8.62911567e-02f, -2.54059076e-01f, -1.43181056e-01f, -1.73546538e-01f, 4.76553999e-02f, 6.32580295e-02f, -4.13574837e-02f,
  -7.66100883e-02f, 3.35456245e-02f, -2.47378927e-02f, 3.19977812e-02f, 1.52554691e-01f, -1.10592574e-01f, -1.95015892e-01f, 8.18858072e-02f, 8.37712437e-02f, -6.43602153e-03f,
  9.30563081e-03f, 2.34802872e-01f, 2.14577183e-01f, 1.18952654e-01f, -8.72857347e-02f, 5.48480451e-02f, -1.18794665e-01f, 7.34447129e-03f, -6.35219440e-02f, -1.84854120e-01f,
  3.22336070e-02f, 1.16224989e-01f, -1.96564030e-02f, 6.73799962e-02f, -6.22962974e-02f, 1.62406325e-01f, 6.97849691e-03f, 8.14052597e-02f, 2.28685662e-02f, 3.80365318e-03f,
  -4.01393324e-02f, 3.69545110e-02f, 1.84479123e-03f, 2.58400291e-02f, 5.35333082e-02f, 3.90247293e-02f, 9.04618576e-02f, 1.08863905e-01f, -3.34954895e-02f, -2.76376195e-02f,
  -2.25849804e-02f, -4.85454779e-03f, 8.37784484e-02f, -4.49238494e-02f, 1.71838608e-02f, -8.97889119e-03f, 3.27048786e-02f, 8.24148243e-04f, -1.68591123e-02f, 1.14212902e-02f,
  -5.98707460e-02f, -7.80481771e-02f, -9.69175175e-02f, -7.43859038e-02f, 3.51494402e-02f, -1.16994351e-01f, -2.88713984e-02f, 1.81179661e-02f, -5.50147891e-02f, -4.56594341e-02f,
  -1.27178868e-02f, -7.86998868e-02f, 1.07636396e-02f, -5.87044619e-02f, -9.66092646e-02f, -2.86518480e-03f, -4.85700741e-02f, 3.71940583e-02f, -4.33760919e-02f, 1.14470497e-02f,
  -2.23206934e-02f, -5.29732816e-02f, 1.99517421e-02f, 8.96697026e-03f, -1.30649209e-02f, -6.76644966e-02f, 3.79822939e-03f, -5.72892427e-02f, 3.88964056e-03f, 3.71453986e-02f,
  2.57885873e-01f, 4.25359681e-02f, -2.12114528e-02f, 3.90371308e-02f, 3.16717289e-02f, -2.17904691e-02f, 2.87463069e-02f, 7.17426371e-03f, 8.81797597e-02f, 1.37788979e-02f,
  4.81648520e-02f, 8.81539211e-02f, -3.36799324e-02f, 4.33609709e-02f, 6.12470470e-02f, 4.26110346e-03f, 2.72150841e-02f, 4.21726331e-02f, -3.88414189e-02f, 1.02058416e-02f,
  5.59833832e-02f, 9.76833925e-02f, 7.33321384e-02f, 8.24560076e-02f, -5.62250502e-02f, 9.76493135e-02f, -1.94645127e-05f, -1.59875359e-02f, 9.43353325e-02f, 2.10434780e-01f,
  -2.22780228e-01f, 1.94904104e-01f, -1.64276257e-01f, -2.06562672e-02f, -2.09625904e-03f, -1.17378570e-01f, -1.57359734e-01f, -2.08923340e-01f, 1.15376012e-02f, -2.11066213e-02f,
  5.11354282e-02f, 1.08179897e-02f, 8.49527307e-03f, -1.51312083e-01f, -1.96605548e-01f, -5.94513714e-02f, -3.61277163e-02f, -1.28374159e-01f, -3.08338761e-01f, -4.16893438e-02f,
  3.81839201e-02f, 6.76307082e-02f, -3.80798392e-02f, 2.84214523e-02f, 2.40324795e-01f, -2.11722758e-02f, 1.08865686e-01f, 9.18711796e-02f, 5.22234524e-03f, 2.77262539e-01f,
  -6.63783550e-02f, -2.63566580e-02f, -1.26109555e-01f, 8.93998295e-02f, 2.27094758e-02f, -2.66969465e-02f, -1.27221309e-02f, 3.26232873e-02f, -2.65255347e-02f, 5.67240901e-02f,
  7.35321492e-02f, 7.12436363e-02f, -2.37205997e-02f, -8.97032302e-03f, 6.14511333e-02f, -8.86378437e-02f, 5.79887405e-02f, -5.33130653e-02f, -1.38252676e-01f, -5.68499602e-02f,
  1.88024372e-01f, -1.28214052e-02f, -1.48453370e-01f, -1.25013366e-01f, 2.88362056e-03f, -1.95699595e-02f, -9.17373076e-02f, -5.95250092e-02f, -5.81909604e-02f, 2.24845875e-02f,
  3.46516892e-02f, 1.68047715e-02f, -7.20053241e-02f, 2.62121223e-02f, -4.83394377e-02f, 3.57512087e-02f, 1.31209763e-02f, -2.63506244e-03f, 5.28066084e-02f, -3.81702073e-02f,
  -5.18975183e-02f, -3.04104462e-02f, -2.60810591e-02f, -1.31807802e-02f, 7.83578213e-03f, 2.51791328e-02f, -5.81255555e-02f, 3.81043786e-03f, -5.24706468e-02f, -7.31297806e-02f,
  -1.80272274e-02f, -3.16884331e-02f, 7.11807460e-02f, 9.81372129e-03f, 8.45544506e-03f, 1.11209787e-02f, -4.87194434e-02f, -7.13595469e-03f, 1.10100652e-03f, -9.03767571e-02f,
  -5.04777860e-03f, -8.31413195e-02f, -9.69659258e-03f, -4.55953833e-03f, -3.18346880e-02f, 2.02487316e-02f, -1.24275056e-03f, -4.15006243e-02f, 2.19057109e-02f, -4.69680782e-03f,
  8.08373466e-03f, -6.39053062e-02f, -4.10722941e-02f, 3.48316915e-02f, -5.81122823e-02f, 2.99447533e-02f, 3.85071002e-02f, -1.19798735e-01f, -3.36786211e-02f, -5.63844070e-02f,
  -3.99229713e-02f, -1.05167381e-01f, -2.00792372e-01f, -9.91695151e-02f, -1.34935245e-01f, -2.35559165e-01f, -8.55166838e-02f, -5.81565946e-02f, -2.71608353e-01f, -1.97764114e-01f,
  -1.83480322e-01f, 1.31648451e-01f, -1.34185731e-01f, -2.73238551e-02f, 4.88337036e-03f, 7.86234587e-02f, 9.33994576e-02f, -7.17125135e-03f, 4.08511683e-02f, 4.77303490e-02f,
  -5.30972034e-02f, -5.07930554e-02f, 3.67826000e-02f, 2.56616455e-02f, 8.21586475e-02f, 1.86129421e-01f, 9.53060985e-02f, 7.22303148e-03f, -1.22799143e-01f, 9.49874520e-02f,
  2.21763864e-01f, 1.55112877e-01f, 3.16441208e-02f, 1.27933964e-01f, -3.93623812e-03f, -3.24189886e-02f, -9.65582498e-04f, -1.01921577e-02f, 1.99142396e-02f, 2.03559831e-01f,
  -1.68444738e-01f, -2.29403842e-02f, -2.46302579e-02f, 1.02912650e-01f, -3.86940222e-03f, -1.68554522e-02f, 8.06238279e-02f, 4.62556072e-02f, 8.14230293e-02f, 4.67223451e-02f,
  7.04078190e-03f, 7.06568286e-02f, 8.12481903e-03f, -4.00453769e-02f, -1.15283486e-03f, -7.73776649e-03f, -1.40121179e-02f, -6.52001277e-02f, -9.01721641e-02f, 5.31378575e-02f,
  1.30102277e-01f, 3.62566002e-02f, 6.53921440e-02f, 5.01110032e-02f, -1.82519555e-02f, 1.21543385e-01f, 2.95648072e-02f, 4.98090871e-02f, -1.83786778e-03f, 3.94023322e-02f,
  1.00075126e-01f, -2.90230438e-02f, -8.53334144e-02f, 1.28056882e-02f, 2.48124506e-02f, 3.21208616e-03f, 1.56533550e-02f, -7.91634340e-03f, 1.72541924e-02f, -1.38718905e-02f,
  -1.12274438e-01f, -7.81462044e-02f, -2.10167170e-02f, -2.39832290e-02f, -5.29119978e-03f, -5.18405847e-02f, -2.48388797e-02f, -3.06842178e-02f, 9.81258787e-03f, 3.47012579e-02f,
  -2.44389884e-02f, -7.43087828e-02f, 1.30184107e-02f, -1.10548414e-01f, 1.01289982e-02f, -6.15058802e-02f, 5.35057783e-02f, -1.52179915e-02f, -1.21495686e-02f, 3.81067805e-02f,
  -1.77896976e-01f, 5.96314808e-03f, -1.88462138e-02f, -1.73014160e-02f, 2.04996532e-03f, 3.68741602e-02f, 2.36797407e-02f, 5.32278642e-02f, -4.80218278e-03f, 6.90147141e-03f,
  4.81834449e-02f, -7.55355656e-02f, 1.00167478e-02f, -6.96605518e-02f, -2.51491176e-04f, -7.24096689e-03f, 2.61059161e-02f, 9.34476629e-02f, 1.03025049e-01f, 1.78818163e-02f,
  2.51289308e-02f, 6.73142970e-02f, -7.05075040e-02f, -4.38502394e-02f, -7.31645972e-02f, 3.95088233e-02f, 2.40384918e-02f, -3.48580163e-03f, -1.11897923e-01f, 1.68414302e-02f,
  -2.97234450e-02f, -1.20146824e-02f, -5.94691783e-02f, -5.33289053e-02f, 7.22851604e-02f, 1.51261464e-01f, 1.13153890e-01f, 5.59120253e-02f, 1.92990090e-04f, -1.39395103e-01f,
  -1.58477753e-01f, -1.79534569e-01f, -1.41070068e-01f, -1.70889184e-01f, 4.32916824e-03f, 1.63742378e-01f, 1.42171279e-01f, 8.22181925e-02f, -1.02323540e-01f, 4.97577377e-02f,
  5.61568178e-02f, -4.47174571e-02f, 3.48805562e-02f, -1.21355131e-01f, 4.13201116e-02f, -1.65024623e-01f, -9.02331248e-02f, -3.77447866e-02f, -8.83890241e-02f, 9.25915986e-02f,
  -3.27220023e-01f, -2.61246245e-02f, -1.76732942e-01f, -1.45835236e-01f, -1.92583472e-01f, -1.62756473e-01f, -8.83872360e-02f, -1.91637889e-01f, -1.17311617e-02f, -1.12096637e-01f,
  -1.37702987e-01f, -1.94570243e-01f, -4.98119779e-02f, -6.23379909e-02f, -1.04292557e-01f, -1.51114225e-01f, -6.03664033e-02f, -9.52345207e-02f, -2.94658840e-02f, -1.30009502e-01f,
  -2.08472200e-02f, -2.44697873e-02f, 3.15692388e-02f, -1.09842412e-01f, -1.20408416e-01f, -8.62642676e-02f, -5.71223833e-02f, 1.75531674e-02f, -2.09163669e-02f, -8.82110000e-02f,
  4.36868779e-02f, 1.36630878e-01f, 3.48114707e-02f, 3.33183296e-02f, 1.21762477e-01f, 2.91335210e-03f, -6.37056259e-03f, 9.25337523e-02f, 4.63944562e-02f, 7.39903674e-02f,
  2.94345245e-02f, 1.69060566e-02f, -6.64954036e-02f, 2.13903803e-02f, 3.42645459e-02f, 2.27296893e-02f, -1.94107816e-02f, -1.21441716e-03f, 5.03875986e-02f, 7.06061274e-02f,
  7.20410123e-02f, 2.93630399e-02f, -2.23375410e-02f, 4.17789817e-02f, 4.55979817e-02f, 9.81463026e-03f, 7.80613422e-02f, 9.59190950e-02f, -3.01250480e-02f, 9.07394215e-02f,
  -3.26866806e-01f, -1.74851611e-01f, -6.46205842e-02f, -3.33501846e-02f, -2.02934235e-01f, -1.36629358e-01f, -1.65697306e-01f, -6.94142357e-02f, -1.35127902e-01f, -1.13138042e-01f,
  -9.81781185e-02f, -2.00874463e-01f, -1.22158386e-01f, -3.42685729e-02f, -1.77457314e-02f, -1.37899034e-02f, -1.21235974e-01f, 1.92423128e-02f, -8.81108120e-02f, -1.35472208e-01f,
  -5.11427075e-02f, 1.36897527e-02f, -1.61191542e-02f, -5.49811944e-02f, 3.64591368e-02f, -1.08389566e-02f, -8.38091895e-02f, -1.60951555e-01f, -1.14464276e-01f, -3.23797427e-02f,
  -1.32086903e-01f, -1.49138704e-01f, -1.35406539e-01f, -1.70553923e-01f, -1.04483590e-01f, -1.56517506e-01f, -1.68320909e-01f, -9.32016149e-02f, -5.67574464e-02f, -9.07178074e-02f,
  9.84068438e-02f, 1.22428074e-01f, 1.21607080e-01f, 1.10188067e-01f, 1.01933271e-01f, -4.68952842e-02f, -1.93266988e-01f, -7.87887797e-02f, 7.47855827e-02f, -1.86626818e-02f,
  -4.72318269e-02f, -1.77168906e-01f, -1.00512102e-01f, -4.89178300e-02f, -6.38712943e-02f, 8.26394558e-02f, -5.49351424e-02f, -1.75977096e-01f, -6.18728995e-02f, -7.94238374e-02f,
  -1.06212739e-02f, -1.54485285e-01f, -3.78832072e-02f, 2.81999502e-02f, 6.04115017e-02f, 2.34998949e-02f, -1.80072822e-02f, -2.50685271e-02f, 1.61792282e-02f, -4.16202210e-02f,
  -5.30362464e-02f, 5.48380427e-02f, -6.97637573e-02f, -2.30807029e-02f, -5.56805916e-02f, 1.94844101e-02f, 1.48180816e-02f, 2.77139228e-02f, -7.12110475e-02f, -1.00374281e-01f,
  1.15364825e-03f, -1.65844813e-01f, -9.69810635e-02f, 1.03726108e-02f, 6.54450431e-02f, -2.01925952e-02f, 2.00061742e-02f, -9.93244071e-03f, -9.69450548e-03f, -9.38260928e-02f,
  -4.33391035e-02f, 1.46682244e-02f, -2.24958993e-02f, -9.54587385e-02f, -4.39531803e-02f, -1.93985719e-02f, 5.03871739e-02f, 7.34191854e-03f, -4.83833067e-02f, 1.44056173e-03f,
  6.09381869e-02f, -5.02201244e-02f, 4.38695624e-02f, -9.92862880e-02f, -2.20545214e-02f, -1.51958019e-01f, -7.18002487e-03f, -3.31008434e-03f, -1.03666242e-02f, 1.17290411e-02f,
  -4.51025330e-02f, -7.96076432e-02f, -5.39760813e-02f, 3.74325290e-02f, -1.65123139e-02f, 1.89011898e-02f, -4.90352772e-02f, -3.12089883e-02f, -1.38686597e-02f, -1.18368044e-01f,
  2.06330314e-01f, 1.08788550e-01f, 2.44976114e-02f, 8.17300305e-02f, -2.18946747e-02f, 3.54729034e-02f, -1.35240667e-02f, 2.75460295e-02f, 6.98806122e-02f, -8.48790109e-02f,
  -5.54097444e-02f, 9.04891919e-03f, 1.98822618e-02f, 3.87873091e-02f, -9.55977477e-03f, -9.74791497e-02f, -4.66447696e-02f, -1.10807903e-01f, 2.75814813e-02f, -1.20215744e-01f,
  -6.60000890e-02f, -1.30984664e-01f, -1.39112547e-01f, 1.38278604e-02f, -1.10525109e-01f, 1.21486364e-02f, 1.03842290e-02f, -1.05939865e-01f, 8.34445003e-03f, -5.45136780e-02f,
  -5.95614851e-01f, -2.63903588e-01f, 1.90772891e-01f, -1.95675477e-01f, 1.95188165e-01f, 2.77710199e-01f, 2.79353529e-01f, -2.71243230e-03f, -5.47780544e-02f, -3.42010222e-02f,
  -1.62150592e-01f, -1.10106044e-01f, -1.26179829e-01f, 6.93562627e-02f, 5.02635762e-02f, 2.88704842e-01f, 3.40123653e-01f, 2.75638044e-01f, 1.89098448e-01f, 1.56743482e-01f,
  -3.97511534e-02f, -7.30905011e-02f, -1.93723321e-01f, 3.87269743e-02f, -1.81719601e-01f, -9.02354419e-02f, 2.35106889e-02f, -1.70026690e-01f, -1.35417432e-01f, -1.67102084e-01f,
  -5.34144714e-02f, -4.43098038e-01f, 1.21169038e-01f, -1.17211938e-01f, -1.07866898e-01f, -1.23796962e-01f, -8.39462355e-02f, -1.60889924e-01f, -6.57163039e-02f, -8.17423537e-02f,
  -1.11699678e-01f, -8.33659917e-02f, -1.02531888e-01f, -8.50038007e-02f, -1.09357670e-01f, -1.31353080e-01f, -6.18410408e-02f, -1.35338798e-01f, -4.90136705e-02f, -1.44763947e-01f,
  -4.49991077e-02f, -1.69386819e-01f, 1.48156090e-04f, -3.66774909e-02f, -3.13785719e-03f, -1.01661399e-01f, -2.38677599e-02f, -1.58216223e-01f, -2.05894541e-02f, -1.87552124e-01f,
  -8.78309906e-02f, 8.03198740e-02f, 6.33872673e-02f, 1.95681658e-02f, 6.89381436e-02f, 6.19808175e-02f, 2.83709038e-02f, 1.04244672e-01f, 9.89322513e-02f, -3.40892933e-03f,
  3.98997851e-02f, 8.49421471e-02f, 3.91902961e-02f, 1.60669498e-02f, 3.70097458e-02f, 1.30105754e-02f, 9.87707898e-02f, -4.40720702e-03f, 4.34940308e-02f, 8.69183044e-04f,
  -8.76982603e-03f, 6.74054101e-02f, 4.51146103e-02f, 8.74518155e-05f, 9.44129080e-02f, 1.09755889e-01f, 2.93022767e-02f, 4.69771363e-02f, 6.53773397e-02f, 2.98539246e-03f,
  -1.17525235e-01f, -8.09125528e-02f, -1.36874676e-01f, -7.56884217e-02f, -7.96542764e-02f, -2.05595000e-03f, -1.60063490e-01f, -7.79422745e-02f, -1.19279198e-01f, 7.88732152e-03f,
  -7.72339031e-02f, -8.96064490e-02f, -5.00082746e-02f, -3.22568640e-02f, -8.26453418e-03f, 2.04968043e-02f, -1.33744091e-01f, 5.88212796e-02f, -7.74479806e-02f, -4.93977778e-02f,
  -1.06134735e-01f, 5.18160686e-02f, 5.48191257e-02f, 6.44576997e-02f, -1.39844298e-01f, 5.44959493e-02f, 6.52194992e-02f, -3.05053443e-02f, 1.16654091e-01f, 4.50798981e-02f,
  -1.55201316e-01f, -1.86707541e-01f, -1.49963826e-01f, -1.60430387e-01f, -1.27316922e-01f, -1.18797617e-02f, 6.38001366e-03f, 1.36995777e-01f, 1.16224065e-02f, -1.37117535e-01f,
  -1.23729892e-01f, 7.41457508e-04f, -2.80668661e-02f, 6.10997118e-02f, 2.24278152e-01f, -1.67392450e-03f, -6.39503123e-03f, 9.07835513e-02f, 9.00174603e-02f, -1.99928437e-03f,
  6.98972959e-03f, -1.14097551e-03f, 6.84272051e-02f, 1.85374767e-02f, -2.87607074e-01f, -8.11795220e-02f, -1.80319920e-01f, -6.12802505e-02f, -1.06636927e-01f, -2.86974490e-01f,
  -2.49698102e-01f, -1.90618575e-01f, -4.89431014e-03f, 7.51677807e-03f, -1.55177698e-01f, -7.71138370e-02f, -4.34374101e-02f, -5.11797741e-02f, -1.16809830e-01f, -2.57004444e-02f,
  -1.08676836e-01f, 2.73555610e-02f, -7.81125203e-02f, 5.46311587e-03f, 5.22491802e-03f, 5.66053391e-02f, -2.88765561e-02f, 1.07080914e-01f, -4.01337035e-02f, -5.69512546e-02f,
  -6.71755075e-02f, -1.01409681e-01f, -1.38511106e-01f, 6.16129600e-02f, 5.15488423e-02f, -1.66171938e-02f, -1.22016948e-02f, -1.32102638e-01f, 1.38209658e-02f, -1.87480316e-01f,
  8.78443941e-03f, -2.12940276e-02f, 9.78029445e-02f, -2.84438413e-02f, 7.22447112e-02f, 3.01820389e-03f, 8.85418132e-02f, -3.23924422e-02f, 1.06156953e-01f, -1.34205753e-02f,
  1.03666864e-01f, -2.20366772e-02f, -1.69602502e-02f, 4.04430702e-02f, 6.36810213e-02f, 1.52658373e-02f, 5.18946275e-02f, 2.72583924e-02f, 7.54422843e-02f, 1.49300294e-02f,
  6.93153515e-02f, -2.24277209e-02f, -6.07766472e-02f, 8.81063193e-02f, -1.32968789e-03f, 1.36783049e-01f, 5.42378016e-02f, 6.46624565e-02f, 9.08093750e-02f, -5.40700220e-02f,
  -1.73203573e-01f, 5.65201929e-03f, -9.67308581e-02f, 4.09204215e-02f, -1.47949800e-01f, -2.68792473e-02f, -9.43564326e-02f, -3.27310562e-02f, -7.63044134e-02f, -8.75318348e-02f,
  -5.76469395e-03f, -6.17802516e-02f, -3.61552313e-02f, 1.19251069e-02f, -8.03470090e-02f, -2.24415436e-02f, 3.43739241e-02f, -4.94193397e-02f, -2.93702651e-02f, -1.47268981e-01f,
  7.52156042e-03f, -8.82189944e-02f, -5.87106608e-02f, -8.96471292e-02f, -8.44438374e-02f, -7.35073611e-02f, -4.72498126e-02f, -6.69703037e-02f, 8.98440077e-04f, -1.37202024e-01f,
  -2.67481267e-01f, -3.20009053e-01f, 1.05308272e-01f, -9.53965336e-02f, -1.16051637e-01f, -1.60377339e-01f, -2.78083384e-01f, -2.19534680e-01f, 4.37633283e-02f, -1.21092260e-01f,
  -2.17725765e-02f, 2.58875906e-01f, 1.70174360e-01f, 8.88694897e-02f, 1.25088831e-02f, -1.70899257e-01f, -1.30838782e-01f, 1.98808998e-01f, 1.52359873e-01f, 6.71687946e-02f,
  5.32387346e-02f, 5.46440966e-02f, 4.49884757e-02f, -2.67650839e-02f, -4.07172516e-02f, 8.59217048e-02f, -2.29148939e-02f, -3.29970196e-02f, -9.53612477e-02f, 4.87919599e-02f,
  2.43004858e-01f, -1.69869378e-01f, 1.78444572e-02f, 3.25914880e-04f, 4.91039604e-02f, 2.63925437e-02f, 2.43686568e-02f, -8.29528496e-02f, 4.42168303e-02f, -4.35226224e-03f,
  2.70500053e-02f, -5.09128347e-02f, -1.31281748e-01f, 6.07078411e-02f, -1.07588172e-01f, -9.15599093e-02f, -9.38906148e-02f, 3.30063961e-02f, -9.83771402e-03f, 4.65299040e-02f,
  -6.52602315e-02f, -1.10606425e-01f, -7.22306296e-02f, -3.10203899e-02f, -1.37010172e-01f, 1.35330269e-02f, -7.00185001e-02f, -1.29964173e-01f, -1.04133226e-01f, -7.94539899e-02f,
  1.70435756e-02f, -1.13835499e-01f, -7.91790057e-03f, -7.84221664e-02f, -2.16251593e-02f, 2.36568656e-02f, 2.63868328e-02f, -4.88343388e-02f, 8.92044324e-03f, -4.45949100e-02f,
  2.34314445e-02f, 3.17186629e-03f, -3.17859612e-02f, 4.06324230e-02f, 1.32597864e-01f, -8.63734931e-02f, 1.17769865e-02f, -1.77451596e-02f, 6.95920289e-02f, -1.00983568e-01f,
  -7.65150506e-03f, 1.57177206e-02f, 7.47118443e-02f, 9.33125541e-02f, -4.01770920e-02f, -1.65271871e-02f, -2.33944729e-02f, 1.25884814e-02f, -1.64219290e-02f, -6.99427202e-02f,
  1.05231948e-01f, 1.56584233e-01f, 2.39930656e-02f, 1.35182170e-02f, -3.81852612e-02f, 4.02080081e-03f, 3.37864272e-02f, -1.13106165e-02f, 1.74167212e-02f, -5.15566170e-02f,
  -3.54864337e-02f, 4.40712087e-02f, 6.98950887e-03f, -6.22452120e-04f, 4.56072902e-03f, -1.72757730e-02f, 6.51269928e-02f, 1.79186859e-03f, 5.91112971e-02f, -1.04168765e-01f,
  -1.41257129e-03f, -1.82893779e-02f, -6.83355611e-03f, 2.42363364e-02f, 1.92976613e-02f, -7.03274906e-02f, -3.05361161e-03f, 4.34365608e-02f, -3.06134876e-02f, 1.89727917e-02f,
  -2.04984516e-01f, -2.64062643e-01f, 2.25163072e-01f, -1.32242978e-01f, 3.15702975e-01f, 1.96182892e-01f, 2.62723356e-01f, 1.47879139e-01f, -3.62837836e-02f, -1.17526598e-01f,
  -2.00835944e-04f, -3.16309445e-02f, -1.51996896e-01f, 5.30358775e-05f, 9.61279403e-03f, -4.32991050e-02f, 1.35252893e-01f, 9.37090218e-02f, 1.48030773e-01f, 8.90732929e-02f,
  -3.07517145e-02f, -1.67374700e-01f, -1.58051580e-01f, -1.15772836e-01f, -2.25476086e-01f, -1.02453455e-02f, -2.38415096e-02f, 5.76027334e-02f, 9.29911360e-02f, -9.35434401e-02f,
  -2.27847099e-01f, 1.64997742e-01f, 5.05354963e-02f, -2.63929889e-02f, -1.62400678e-02f, 7.26916874e-03f, -1.90567644e-03f, -6.66915327e-02f, 1.25264034e-01f, -2.62783356e-02f,
  -2.67953668e-02f, 1.47684440e-02f, 1.26517296e-01f, 7.99668953e-03f, -4.64288257e-02f, 9.03614610e-02f, -2.13927999e-02f, -7.13685900e-02f, -5.58037795e-02f, -2.28523836e-02f,
  5.69445230e-02f, 1.79904729e-01f, 1.68061465e-01f, 3.09694726e-02f, 5.05410694e-02f, 9.54006240e-02f, 1.09824557e-02f, 1.02476254e-01f, 1.05588146e-01f, -1.32666782e-01f,
  6.92419708e-02f, -1.77248400e-02f, 3.35161341e-04f, 1.06515186e-02f, 2.36698538e-02f, -7.14971349e-02f, -5.59409522e-02f, -4.57290225e-02f, 1.48384506e-03f, -1.09733582e-01f,
  -3.95254046e-02f, -5.77254929e-02f, -2.93815471e-02f, 4.42482717e-03f, -1.36167049e-01f, 3.28787714e-02f, -1.09114543e-01f, -6.58685789e-02f, -4.77407239e-02f, -5.53244501e-02f,
  -1.61157027e-02f, 6.30208328e-02f, -3.04099657e-02f, -4.37239856e-02f, -1.96858053e-03f, -4.12540063e-02f, 8.13881960e-03f, -7.01545179e-02f, -2.57275384e-02f, -6.55384269e-03f,
  -3.61142099e-01f, 2.15577900e-01f, -1.63479701e-01f, 1.93289518e-02f, 4.07547913e-02f, 2.35066544e-02f, -1.58596672e-02f, 1.71402078e-02f, -2.27404945e-02f, 4.16460596e-02f,
  8.24124068e-02f, 5.06101735e-03f, -2.42484566e-02f, -5.60894795e-02f, 7.73246512e-02f, -1.73204895e-02f, 2.55758762e-02f, 3.79496403e-02f, -1.42776361e-02f, 2.38055456e-02f,
  8.50243866e-03f, -4.69629765e-02f, -7.96801820e-02f, -6.24978030e-03f, 2.56595016e-02f, 5.22389971e-02f, -4.66480702e-02f, -6.92831650e-02f, 6.54323921e-02f, -1.53368562e-01f,
  2.23476946e-01f, -2.69650578e-01f, -4.36982512e-02f, -1.22018151e-01f, -4.72516902e-02f, 3.01602166e-02f, -8.11828598e-02f, -4.07188805e-03f, 2.25906668e-04f, -5.18454537e-02f,
  7.53895193e-02f, 2.36254141e-01f, 6.79823607e-02f, 7.64127895e-02f, 2.51858030e-03f, -1.90158799e-01f, -1.13266192e-01f, -1.65145956e-02f, 2.20308155e-01f, 7.30089024e-02f,
  8.27570781e-02f, 1.13435891e-02f, -4.86577004e-02f, -5.64440340e-02f, -9.11140442e-02f, -6.36897683e-02f, -1.18389264e-01f, -8.89010914e-03f, -8.69269371e-02f, -7.72074461e-02f,
  1.79754242e-01f, 3.91762108e-02f, 4.24673595e-02f, -1.69941969e-02f, -2.74673197e-02f, -2.75559835e-02f, 4.40529063e-02f, -1.38229460e-01f, -2.06076968e-02f, -4.53998931e-02f,
  -1.81861641e-03f, -3.70287709e-02f, -1.16030045e-01f, -5.04827388e-02f, -1.38812929e-01f, 2.70491000e-02f, -1.89231187e-01f, -1.94650456e-01f, -1.44728661e-01f, 6.00059144e-02f,
  -1.02525368e-01f, -1.33780345e-01f, -1.52218491e-01f, -1.78401709e-01f, -6.84630647e-02f, 1.97508987e-02f, -1.68312296e-01f, -1.69233873e-01f, -7.79795051e-02f, -2.80097544e-01f,
  -1.09545439e-01f, 9.78618935e-02f, 1.45642370e-01f, 2.27653719e-02f, 9.16879326e-02f, 8.61053094e-02f, 4.57065701e-02f, 2.03173198e-02f, 1.49726450e-01f, -5.25495186e-02f,
  1.15222096e-01f, -1.00194691e-02f, 9.00075585e-02f, -3.08074220e-03f, -3.51510127e-03f, 7.31082037e-02f, 1.53867090e-02f, 1.18933851e-02f, 7.01472461e-02f, 2.52441745e-02f,
  1.28056511e-01f, 9.03222412e-02f, -4.41779532e-02f, -1.97880939e-02f, 7.98142329e-02f, 1.56349279e-02f, 6.53775111e-02f, 1.17063500e-01f, 2.00912450e-02f, 7.91776255e-02f,
  -1.00052029e-01f, 6.62484467e-02f, 2.00264174e-02f, -5.88796102e-02f, -6.47803470e-02f, -2.57975403e-02f, 7.48785660e-02f, -5.09155653e-02f, 7.79562816e-03f, 9.84246749e-03f,
  8.46378133e-02f, 8.19353983e-02f, -6.72658011e-02f, 3.23147923e-02f, -7.49394391e-03f, -6.76751062e-02f, -7.28092045e-02f, -8.00077021e-02f, 3.33516076e-02f, 9.15412083e-02f,
  -8.09075609e-02f, -9.53743160e-02f, 4.27785963e-02f, 1.46724144e-02f, -5.92144132e-02f, 3.09066214e-02f, 4.56567816e-02f, -6.50250819e-04f, -6.27408326e-02f, -2.04255134e-01f,
  4.93754029e-01f, 2.00480521e-01f, 2.31789172e-01f, 2.11739972e-01f, -3.92468348e-02f, -8.01146254e-02f, -1.35718379e-02f, 1.03441343e-01f, 1.77656844e-01f, 1.73108011e-01f,
  4.88636605e-02f, 9.20636356e-02f, 2.17414424e-01f, 1.66006744e-01f, 1.90979853e-01f, 1.36417687e-01f, 1.16244346e-01f, 2.43572280e-01f, 1.63236678e-01f, -7.07010971e-03f,
  7.78224841e-02f, 1.53212994e-01f, 2.86958098e-01f, 3.34831290e-02f, 1.13476850e-01f, 1.78283364e-01f, 5.26958816e-02f, 6.22857250e-02f, -1.24993566e-02f, 1.82434797e-01f,
  4.31657851e-01f, 8.96597877e-02f, 1.03800625e-01f, 6.87063113e-02f, 4.78950329e-02f, 2.20701292e-01f, 1.67409211e-01f, 2.22609907e-01f, 9.42685604e-02f, 2.34605968e-01f,
  1.61956787e-01f, 6.55473098e-02f, 1.78349048e-01f, 1.52308851e-01f, 1.10835165e-01f, 1.48290977e-01f, 8.01340491e-02f, 1.78166702e-01f, 2.03863427e-01f, 7.90048689e-02f,
  9.85994264e-02f, 9.21127275e-02f, 1.66864768e-01f, 1.20124452e-01f, 9.54481065e-02f, 1.44303009e-01f, 8.19047540e-02f, 1.71715111e-01f, 1.31686091e-01f, 3.56128156e-01f,
  -1.28409043e-01f, -1.92670912e-01f, -2.22872466e-01f, -3.16332206e-02f, -1.50254443e-01f, -1.80679932e-01f, -2.05666259e-01f, -9.92149115e-02f, -1.77938595e-01f, -1.69089973e-01f,
  -1.58827782e-01f, -1.30136371e-01f, -2.34075531e-01f, -1.45081699e-01f, -2.77147830e-01f, -1.72173157e-01f, -1.35675579e-01f, -2.76016947e-02f, -1.79894626e-01f, -6.37048855e-02f,
  -1.48225173e-01f, -7.16681629e-02f, -5.96876107e-02f, -7.62023032e-02f, -1.10916957e-01f, -9.91567224e-02f, -7.45321438e-02f, -1.47133127e-01f, -7.90454894e-02f, -1.82602435e-01f,
  3.51962596e-01f, 1.18416520e-02f, 2.62978494e-01f, 1.33084401e-01f, 1.87768832e-01f, 7.13934526e-02f, 2.36024365e-01f, 1.67213529e-01f, 1.24688536e-01f, 1.97026893e-01f,
  1.64829433e-01f, 2.02437550e-01f, 1.64785683e-01f, 5.46952374e-02f, 1.64127514e-01f, 1.53527245e-01f, 6.64471015e-02f, 1.07126079e-01f, 1.95404470e-01f, 5.40008917e-02f,
  1.26617864e-01f, 2.07057610e-01f, 2.70787477e-01f, 1.68096453e-01f, 1.36247352e-01f, 2.44085997e-01f, 1.95670918e-01f, 2.63128161e-01f, 2.87380964e-01f, 4.55127180e-01f,
  4.57299948e-01f, -2.45860457e-01f, -3.07852447e-01f, 2.90765703e-01f, -2.03138683e-02f, -2.83555351e-02f, -1.03213303e-01f, 1.23682879e-01f, 2.16113687e-01f, 9.05878395e-02f,
  -7.75125921e-02f, 2.32003048e-01f, 1.76000819e-02f, 6.14306480e-02f, -8.25971216e-02f, -7.59523585e-02f, -1.30366981e-01f, -8.96414593e-02f, 9.40044150e-02f, 2.01003611e-01f,
  7.85585195e-02f, 8.91953111e-02f, 4.39662021e-03f, 3.55839394e-02f, 3.74993682e-02f, 7.86757693e-02f, -1.39557585e-01f, 2.36900430e-02f, -1.62838340e-01f, -5.62313162e-02f,
  -1.49798423e-01f, -7.60020465e-02f, -3.74039845e-03f, 8.24497547e-03f, -1.04369849e-01f, 5.66297583e-02f, -4.02946770e-02f, -4.32714522e-02f, 4.53402214e-02f, -5.22801280e-02f,
  -8.88916403e-02f, 4.25805748e-02f, -5.06739356e-02f, -5.99603206e-02f, 4.31845710e-02f, -6.75179735e-02f, -1.82222247e-01f, -1.08440168e-01f, -1.27411559e-01f, -1.51542444e-02f,
  -1.37494937e-01f, -9.79492888e-02f, -1.10754997e-01f, -8.76450911e-02f, -6.43448085e-02f, -6.73074573e-02f, -1.96326360e-01f, 9.34840459e-03f, -9.01186168e-02f, -2.90985107e-02f,
  -6.84782863e-02f, -3.95666473e-02f, -6.07497692e-02f, 1.12778423e-02f, 4.05471697e-02f, -9.40190442e-03f, 1.08190458e-02f, -2.38039941e-02f, -2.49494761e-02f, 4.73597087e-03f,
  -5.90913184e-03f, -5.93782254e-02f, -1.57750454e-02f, 7.77497441e-02f, -1.27202552e-02f, 6.29127212e-03f, 4.87635247e-02f, -7.35043287e-02f, -2.19494775e-02f, 1.72269680e-02f,
  4.85283174e-02f, -6.34756312e-02f, 1.28962658e-02f, 2.63476241e-02f, -6.45966381e-02f, 8.28668289e-03f, -3.70823108e-02f, 3.05433106e-02f, 9.91916806e-02f, 9.54662543e-03f,
  1.46800563e-01f, -2.23764643e-01f, 9.28362533e-02f, -3.30286548e-02f, -1.10390326e-02f, -5.07670045e-02f, -9.24535096e-02f, -9.29023772e-02f, -6.09957576e-02f, 4.78659309e-02f,
  -6.96121305e-02f, -3.18918930e-04f, -6.51685596e-02f, -5.10850400e-02f, -1.36239803e-03f, 3.81437391e-02f, -6.07257858e-02f, -1.18473461e-02f, 1.00065675e-02f, -5.00893891e-02f,
  -9.23697427e-02f, -1.23595614e-02f, 1.39293253e-01f, -5.20619154e-02f, 5.00740781e-02f, 5.83969578e-02f, 1.41327130e-02f, 5.12480848e-02f, -1.32042076e-03f, 1.12316474e-01f,
  4.33850944e-01f, -3.40825409e-01f, -5.15537672e-02f, -8.07834044e-03f, 9.59061235e-02f, 1.35751590e-01f, -8.93521309e-02f, 5.89871183e-02f, -2.17915494e-02f, -2.06852347e-01f,
  -3.25988270e-02f, 1.19827300e-01f, 6.45096153e-02f, 6.89934334e-03f, 5.74199744e-02f, -1.68277577e-01f, -2.15744331e-01f, 1.15647554e-01f, 3.31525505e-01f, 1.70749292e-01f,
  -4.42879647e-02f, -5.10480814e-02f, 7.35641038e-03f, 1.18296988e-01f, -1.93174288e-01f, -1.15559541e-01f, -2.31191814e-01f, -6.92981184e-02f, -1.89450637e-01f, -3.62546712e-01f,
  -2.93465462e-02f, -7.74886906e-02f, 1.37416888e-02f, -4.20565344e-02f, 4.08503860e-02f, 8.45973045e-02f, 3.72964367e-02f, 5.70470877e-02f, 3.17587666e-02f, -1.62142515e-02f,
  2.39272006e-02f, -1.55121852e-02f, -4.73224446e-02f, -3.24101821e-02f, 5.50704040e-02f, -4.94151115e-02f, -4.27875249e-03f, -3.96208502e-02f, -2.63360469e-03f, -4.44427729e-02f,
  -1.22708954e-01f, 3.24257985e-02f, 1.51853701e-02f, 7.64250150e-03f, -2.12776754e-02f, 8.86632726e-02f, -5.81797697e-02f, 1.01327458e-02f, -2.11432334e-02f, -1.35969743e-01f,
  -1.89880142e-03f, 1.36409868e-02f, -1.28444480e-02f, -5.08658439e-02f, -7.92614222e-02f, -4.67945635e-02f, -3.31228115e-02f, -1.13226838e-01f, 1.34862838e-02f, -1.02869272e-01f,
  -6.59120828e-02f, 7.73626892e-03f, -2.18631718e-02f, 4.09927778e-03f, -5.40686548e-02f, -1.09680988e-01f, -3.81438881e-02f, -4.80748750e-02f, -2.74553970e-02f, -8.65180865e-02f,
  -5.81794754e-02f, 1.55213960e-02f, -4.19941694e-02f, -1.44820670e-02f, -5.18776290e-02f, -6.12065010e-02f, -1.40355043e-02f, 3.67715321e-02f, -6.96481168e-02f, 7.09459558e-03f,
  -2.16538226e-03f, 5.82889020e-02f, -1.43082265e-03f, -3.43134739e-02f, 2.36024577e-02f, 6.60466263e-03f, 6.15748577e-03f, 3.86981368e-02f, -2.26310063e-02f, 2.82673147e-02f,
  -1.63387377e-02f, 9.17815194e-02f, -2.43164748e-02f, -5.92594407e-02f, 1.12122990e-01f, -3.02228443e-02f, 6.34108018e-03f, -1.20332437e-02f, 6.18686862e-02f, -9.30677652e-02f,
  -9.84439030e-02f, 4.02393602e-02f, 1.64678261e-01f, -6.67113904e-03f, -2.83971131e-02f, 8.95525366e-02f, -8.32167864e-02f, 2.23392751e-02f, 1.85569093e-01f, -3.16419378e-02f,
  2.92247206e-01f, 9.46199074e-02f, 2.72064239e-01f, 3.79192770e-01f, 1.45963833e-01f, 6.46959320e-02f, -1.07773917e-03f, -1.45432111e-02f, 1.51829705e-01f, 1.42661110e-01f,
  -2.29245164e-02f, 1.13238424e-01f, 1.62932992e-01f, -2.35482468e-03f, 1.03359990e-01f, 2.38861650e-01f, 2.42103487e-01f, 1.75697327e-01f, 1.48191988e-01f, 1.65739551e-01f,
  9.51163620e-02f, 3.41249377e-01f, 3.24647337e-01f, 2.29281947e-01f, 2.23159298e-01f, 1.26140341e-01f, 2.71882296e-01f, 2.86198109e-01f, 2.05955449e-02f, 3.16559583e-01f,
  1.50543943e-01f, 2.18856826e-01f, 8.89742449e-02f, 5.27040996e-02f, 3.42543088e-02f, 5.76376356e-02f, 9.06195790e-02f, 9.49153379e-02f, 6.51334450e-02f, 8.01837668e-02f,
  1.50646120e-01f, 9.80060101e-02f, 1.30125344e-01f, 8.74597952e-02f, 1.45310208e-01f, 9.20585766e-02f, 1.07517943e-01f, 1.00127414e-01f, 6.24193028e-02f, 1.19112410e-01f,
  2.81674974e-02f, 1.47533730e-01f, 2.50441451e-02f, 3.61846946e-02f, 1.58242181e-01f, 1.06703632e-01f, 3.71102132e-02f, -5.16862003e-03f, 8.28384981e-02f, -2.11920682e-02f,
  -7.28631485e-03f, -1.79929867e-01f, -6.39474541e-02f, -7.12556615e-02f, -6.01515919e-02f, -1.20473199e-01f, -4.26903926e-02f, -5.44155315e-02f, -4.30607051e-02f, -1.26369819e-01f,
  -1.37518987e-01f, -6.51761983e-03f, -7.03495964e-02f, -3.53238508e-02f, -1.42996258e-04f, -7.20177963e-02f, -1.49462461e-01f, -3.30802575e-02f, -3.64542305e-02f, -9.42850038e-02f,
  -4.61052395e-02f, -9.43683535e-02f, -6.91537559e-02f, -5.14856465e-02f, -1.95895135e-02f, -7.11551495e-03f, -9.76622701e-02f, -1.82821974e-01f, -1.23142131e-01f, -1.45664603e-01f,
  1.07009403e-01f, 5.92232272e-02f, 8.85082558e-02f, 3.26567292e-02f, 5.58846928e-02f, 5.39971665e-02f, 5.80815822e-02f, 2.78716311e-02f, 1.20411776e-01f, 7.01495633e-02f,
  1.35361115e-02f, 9.49125439e-02f, 8.71263370e-02f, -5.30013517e-02f, 3.08497269e-02f, 1.16929285e-01f, 9.87821668e-02f, 6.92916811e-02f, 9.63307396e-02f, 7.04225805e-03f,
  2.64788587e-02f, 4.20178548e-02f, -4.28863838e-02f, -1.03193941e-02f, 1.80991385e-02f, 1.08367793e-01f, 2.74152495e-02f, -2.79643126e-02f, 1.09735377e-01f, -4.74910736e-02f,
  3.87734324e-02f, 7.24647045e-02f, 3.95830363e-01f, 5.54139093e-02f, 1.72252983e-01f, 2.21129641e-01f, 2.25547835e-01f, 4.72719036e-02f, -1.28901675e-01f, 1.36179239e-01f,
  1.78363752e-02f, -5.77695593e-02f, -1.35384332e-02f, 5.63867837e-02f, 1.41655132e-01f, 1.24637671e-01f, 2.31484696e-01f, 1.32228076e-01f, 3.18729319e-02f, 1.02424547e-01f,
  2.35174433e-03f, 4.63014916e-02f, -9.13690180e-02f, 7.77073801e-02f, -2.64477544e-03f, -7.28024542e-02f, 9.14471895e-02f, 2.94415839e-02f, -3.89474668e-02f, -6.19635684e-03f,
  2.42758781e-01f, 5.12046218e-02f, 5.23473397e-02f, -6.15618005e-02f, 9.17742848e-02f, 8.86039734e-02f, 9.23889726e-02f, -3.44639197e-02f, 3.61188576e-02f, 9.21935663e-02f,
  -1.70785422e-03f, -5.10119125e-02f, 5.72499968e-02f, -7.36709610e-02f, 8.09536353e-02f, -4.76907417e-02f, -5.63936345e-02f, 4.43485454e-02f, 9.74258557e-02f, -1.34056658e-02f,
  4.26012743e-03f, -3.88548337e-02f, -2.37228274e-02f, 5.67038031e-03f, -2.82228459e-02f, 3.34888548e-02f, -2.92454548e-02f, 2.10234541e-02f, 1.34037375e-01f, -4.32957038e-02f,
  5.97032942e-02f, 4.87369038e-02f, -7.08572194e-02f, -1.10455707e-01f, -2.63091847e-02f, -9.99776199e-02f, 1.09379820e-04f, -2.37605479e-02f, -5.49106598e-02f, -9.06421691e-02f,
  -8.03616643e-02f, 6.36845678e-02f, 5.33228256e-02f, -3.01404148e-02f, -5.95717283e-04f, 1.89776849e-02f, -3.08491234e-02f, -2.77281031e-02f, -2.48607974e-02f, -3.66069265e-02f,
  -1.02287106e-01f, -1.49887018e-02f, -6.33196160e-02f, -4.94952798e-02f, 4.06916030e-02f, 4.07996885e-02f, -3.21738347e-02f, 4.83652353e-02f, -2.57464368e-02f, -6.82478696e-02f,
  -1.38279259e-01f, 1.04901575e-01f, 9.96686146e-03f, 3.60163786e-02f, -6.91034365e-04f, -5.67753389e-02f, 2.60660052e-02f, -1.57922984e-03f, -1.23234950e-02f, 1.14184264e-02f,
  -5.30783460e-02f, 1.41225448e-02f, 6.42760843e-02f, 3.98939252e-02f, 6.86600134e-02f, -4.21277201e-03f, 2.50102375e-02f, 5.75385354e-02f, -2.18348987e-02f, 4.84906510e-03f,
  -4.27524820e-02f, -1.53326022e-04f, -8.16629454e-02f, -1.89203285e-02f, 7.65083591e-03f, 4.16181516e-03f, 6.90012798e-02f, -1.76682801e-03f, 5.50402179e-02f, -2.39743609e-02f,
  3.51165801e-01f, -2.09616363e-01f, 1.52766809e-01f, -3.63066420e-02f, 1.33660987e-01f, 2.52035171e-01f, 2.06032515e-01f, 4.17184317e-03f, 9.83713847e-03f, -4.97726128e-02f,
  3.74629088e-02f, -1.03210069e-01f, -1.40661165e-01f, -9.28956550e-03f, 2.68525817e-02f, -7.27806389e-02f, 8.78107622e-02f, 2.86861658e-01f, 2.83546716e-01f, 3.02280039e-01f,
  7.50836432e-02f, 7.24709332e-02f, 2.01903537e-01f, 2.17698850e-02f, -7.96641707e-02f, -1.79729182e-02f, -1.56985000e-01f, -4.29498032e-02f, 9.07516703e-02f, -5.39183579e-02f,
  -8.62421095e-02f, -1.30490866e-02f, 1.58595160e-01f, 2.63988283e-02f, 8.02434608e-02f, 1.67308763e-01f, 1.39269590e-01f, 9.87883061e-02f, 9.32903588e-02f, 9.72128883e-02f,
  3.80432382e-02f, 1.96377896e-02f, 1.22031160e-02f, 7.65096620e-02f, 2.01897416e-02f, 6.36588559e-02f, 4.48493361e-02f, -7.68834166e-03f, 5.51669486e-02f, 5.17251529e-02f,
  -2.12119352e-02f, 1.87348649e-01f, 1.69892788e-01f, 7.12408200e-02f, 2.59065675e-03f, 2.06399933e-01f, 1.98574997e-02f, 9.60074663e-02f, 7.84114003e-02f, -1.98914520e-02f,
  3.35435793e-02f, -3.99641246e-02f, 4.37377729e-02f, -2.81456318e-02f, -6.65562004e-02f, -3.17295268e-03f, -1.02783278e-01f, -9.53502133e-02f, -3.83434109e-02f, 4.42734547e-03f,
  -7.52857374e-03f, -3.84529680e-02f, -8.63793790e-02f, 1.90458912e-02f, -7.45507032e-02f, -4.89577698e-03f, -7.93433711e-02f, -9.82090235e-02f, -6.45407140e-02f, 1.89601090e-02f,
  -1.24286249e-01f, -1.47722960e-02f, -1.48992673e-01f, -9.96330380e-02f, -4.27627340e-02f, 7.19775679e-03f, -1.25154793e-01f, -6.47792146e-02f, -7.33645558e-02f, -3.93963531e-02f,
  -2.11489111e-01f, 1.48568064e-01f, 7.80094275e-03f, -1.63720753e-02f, 7.89155737e-02f, -6.57443283e-03f, -4.66081165e-02f, 2.22990625e-02f, -1.26868971e-02f, -4.23533246e-02f,
  6.96936995e-02f, 9.48912054e-02f, 1.70451961e-02f, 4.99034934e-02f, 1.84557781e-01f, 1.33494183e-01f, 2.39616968e-02f, 6.26185313e-02f, 2.52216663e-02f, -5.65320663e-02f,
  4.99363467e-02f, 1.46182790e-01f, 1.00408599e-01f, -9.37189441e-03f, 4.20252234e-02f, 2.19746307e-01f, 6.80794269e-02f, 3.70588293e-03f, 1.79935858e-01f, -2.65733469e-02f,
  -1.98120087e-01f, 1.08371288e-01f, 1.87453672e-01f, -7.78292492e-02f, 1.28139541e-01f, 1.36060879e-01f, 3.05736542e-01f, 5.06079011e-02f, 5.77927427e-03f, 1.70482770e-02f,
  -5.09062260e-02f, -2.57529169e-01f, -1.53052405e-01f, -2.96509087e-01f, -2.73690045e-01f, 1.37868389e-01f, 2.62093067e-01f, -1.66455999e-01f, -1.96692541e-01f, -1.18448496e-01f,
  8.95530954e-02f, 6.18672706e-02f, -1.24243453e-01f, -2.60759220e-02f, 5.60775287e-02f, -1.72729380e-02f, 1.80217341e-01f, 9.73448902e-02f, 8.55832472e-02f, 8.66371691e-02f,
  -3.88941169e-02f, 1.29071131e-01f, -3.08740232e-02f, -1.01383582e-01f, -1.64264683e-02f, -7.65271708e-02f, -3.87372798e-03f, -1.43354073e-01f, -8.16374123e-02f, -1.10080898e-01f,
  -5.57920448e-02f, -4.61502746e-02f, -1.68624297e-01f, -7.34005347e-02f, -4.47366759e-02f, -6.60191178e-02f, -6.70392648e-04f, -1.59106866e-01f, -1.20091587e-01f, -7.40202069e-02f,
  5.66896349e-02f, 5.80798043e-03f, 9.69794467e-02f, 2.43901927e-02f, -6.36178330e-02f, 9.69336182e-03f, 6.80209026e-02f, -2.11782157e-02f, 2.32324861e-02f, -6.84569543e-03f,
  1.42932579e-01f, 7.39026815e-02f, 3.86607572e-02f, 7.44893700e-02f, 1.33982692e-02f, 5.84786087e-02f, -9.53276735e-03f, 5.88348992e-02f, -6.78115338e-03f, 2.80317683e-02f,
  -9.37366411e-02f, -2.85720471e-02f, 5.20365871e-03f, 1.35499500e-02f, -2.03913711e-02f, 8.72569066e-03f, -8.53644684e-03f, -9.89752542e-03f, -6.15802146e-02f, 4.49112989e-02f,
  5.09469174e-02f, 1.55076226e-02f, 2.12906720e-03f, -8.98167640e-02f, -1.54597294e-02f, -2.42489623e-03f, -4.17539338e-03f, -8.86721835e-02f, -5.97234033e-02f, 8.75538066e-02f,
  -1.10283770e-01f, -1.58121303e-01f, -5.59218973e-02f, -9.08494648e-03f, 1.30708903e-01f, -7.17503428e-02f, 1.08186202e-03f, 6.59846514e-03f, -2.94847670e-03f, -3.02868825e-03f,
  1.72723196e-02f, -8.65511149e-02f, -7.03689829e-02f, 3.61499898e-02f, -2.17032637e-02f, 3.22812423e-02f, -1.62420478e-02f, -5.84086701e-02f, -7.74610564e-02f, 2.38591470e-02f,
  1.40765356e-02f, 1.34425819e-01f, -6.64886385e-02f, 1.66200735e-02f, 7.69048035e-02f, -7.35558718e-02f, -4.54130583e-02f, 2.20900904e-02f, -9.61942598e-02f, 1.08719461e-01f,
  -2.33765930e-01f, 1.87706098e-01f, 1.40942454e-01f, -1.68286413e-01f, 9.11287069e-02f, 1.10068485e-01f, 2.95030605e-02f, -4.39600740e-03f, -1.90546870e-01f, 8.51105377e-02f,
  9.76181850e-02f, 2.88767256e-02f, -1.12194065e-02f, 1.28539344e-02f, 3.71431783e-02f, 4.50074822e-02f, -6.22146502e-02f, -6.18751533e-02f, -1.67750210e-01f, 1.10469107e-02f,
  -2.05327272e-02f, -1.20045438e-01f, -1.42115101e-01f, -2.35707336e-03f, 1.28411219e-01f, -1.02587208e-01f, 4.85104136e-02f, 7.03499764e-02f, 2.02059403e-01f, 2.58873731e-01f,
  1.44182071e-02f, 2.52484739e-01f, -7.25229755e-02f, 4.33522165e-02f, 5.03762662e-02f, -7.41924159e-03f, 8.27666745e-02f, -7.84284323e-02f, 4.04901337e-03f, 2.74118185e-02f,
  1.25199541e-01f, 7.40232393e-02f, 6.35049259e-03f, 1.22059043e-02f, 4.64768037e-02f, -4.58922386e-02f, 1.98441073e-02f, 2.54061949e-02f, 3.17649990e-02f, 3.15422229e-02f,
  1.84547335e-01f, 2.41024047e-01f, 1.64292410e-01f, -2.16111331e-03f, 1.07247829e-01f, 7.31424391e-02f, 1.25540614e-01f, 5.43436185e-02f, 6.53198734e-02f, 3.28763085e-03f,
  4.68194783e-02f, -1.70258665e-03f, 3.27606238e-02f, -7.59184584e-02f, -7.70626888e-02f, -1.38481501e-02f, -1.23106046e-02f, -5.92069291e-02f, 3.46928975e-03f, -3.65371928e-02f,
  -5.34512568e-03f, 2.83483062e-02f, -1.40131433e-02f, -4.48035263e-02f, -3.03837992e-02f, -9.76939872e-03f, 1.50622893e-02f, 2.81048715e-02f, -1.08663756e-02f, -1.02764890e-01f,
  -7.22373575e-02f, 4.42303792e-02f, -9.66216028e-02f, -1.70992203e-02f, -3.12043093e-02f, -1.63356513e-02f, -2.67108697e-02f, -1.75630283e-02f, -3.26506644e-02f, 1.89579688e-02f,
  -2.37406641e-01f, 1.26978025e-01f, -4.18729633e-02f, 3.53513695e-02f, 3.64492498e-02f, -5.95851988e-02f, -3.81167941e-02f, -5.51982448e-02f, 8.80552363e-03f, -3.77478339e-02f,
  1.27247334e-01f, 1.62770960e-03f, 8.84433538e-02f, 6.97459131e-02f, -1.33444905e-01f, 2.81111468e-02f, 1.17568737e-02f, -9.58021879e-02f, 1.19643118e-02f, 1.30361253e-02f,
  4.53489497e-02f, -1.35478944e-01f, -1.42333880e-01f, -5.27265742e-02f, 6.01506606e-02f, -1.59532607e-01f, -8.95310268e-02f, -1.10783711e-01f, -9.55472216e-02f, -1.80757537e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.93285930e-01f, 1.41788185e-01f, 5.94076440e-02f, -2.93321639e-01f, -1.91198453e-01f, -2.53331870e-01f, -1.07073203e-01f, -1.61515355e-01f, -2.61427402e-01f, 6.25286996e-02f,
  6.80665076e-02f, 2.05096975e-02f, -5.83929643e-02f, -1.91970557e-01f, -3.29434007e-01f, -1.88575774e-01f, -3.01860631e-01f, -4.35719699e-01f, -4.26100433e-01f, -3.22624594e-01f,
  -2.38666564e-01f, -4.79606599e-01f, -5.18586218e-01f, -2.00500235e-01f, 1.30503193e-01f, 3.49203870e-02f, 1.30874202e-01f, -1.41755551e-01f, -1.57512218e-01f, 3.92131209e-02f,
  2.18684644e-01f, -2.53783554e-01f, -1.27646253e-01f, -7.58995637e-02f, 7.30908364e-02f, -6.50067776e-02f, -1.25259385e-01f, 3.23253870e-02f, 4.68758531e-02f, 5.66128828e-02f,
  5.34213372e-02f, -5.52020073e-02f, -6.97576553e-02f, 7.59995356e-02f, -3.34692076e-02f, 2.75139958e-02f, 1.32961854e-01f, -8.08550864e-02f, 1.24397926e-01f, 2.99151510e-01f,
  1.22848727e-01f, 4.59292494e-02f, 5.46792112e-02f, 1.31568685e-01f, 1.08845653e-02f, -6.78829327e-02f, 1.50751978e-01f, 1.48563534e-01f, 5.36645064e-03f, 1.36655062e-01f,
  -6.64210916e-02f, 9.15393531e-02f, 3.09441667e-02f, -4.41179238e-02f, -2.68383604e-02f, 6.66394234e-02f, -1.59418527e-02f, 8.41381028e-02f, -1.43377213e-02f, 1.03932120e-01f,
  1.21844247e-01f, -5.25460914e-02f, 3.83356623e-02f, 6.76375479e-02f, 2.88674440e-02f, -3.03237699e-02f, -1.00964777e-01f, 1.10490434e-01f, 1.53969169e-01f, -3.35842595e-02f,
  -7.40143061e-02f, 2.89527085e-02f, 3.93801965e-02f, -3.00088488e-02f, 6.49956614e-02f, 1.52253911e-01f, 2.13291403e-02f, -8.63493010e-02f, -6.80861548e-02f, -1.37548849e-01f,
  1.09946817e-01f, -3.33618551e-01f, -6.73134923e-02f, -5.91592351e-03f, 4.96185608e-02f, 1.44817486e-01f, 8.23287517e-02f, -2.39802971e-02f, 2.91692540e-02f, -1.03274193e-02f,
  3.03507689e-02f, -4.78662886e-02f, 4.06357087e-02f, 1.01278350e-01f, -2.88638044e-02f, -1.11157177e-02f, 1.32606998e-01f, 2.51052715e-02f, 1.08245641e-01f, 1.60870239e-01f,
  1.64467424e-01f, -6.45920681e-03f, 5.58902621e-02f, 1.64565742e-01f, 8.45640823e-02f, -1.80739895e-01f, 1.07454918e-01f, 1.11097530e-01f, -3.92973907e-02f, 1.35114491e-01f,
  -4.97451544e-01f, -4.43194807e-01f, 1.63713738e-01f, -5.25222838e-01f, -1.70022890e-01f, -1.09964542e-01f, -3.69151026e-01f, -2.01306641e-01f, -1.94536954e-01f, -2.67019540e-01f,
  -1.32968739e-01f, -7.60987103e-02f, -4.74159345e-02f, 2.88580917e-02f, 1.49568290e-01f, -4.29443121e-02f, -9.57157388e-02f, 2.50422120e-01f, 4.23047513e-01f, 7.05696419e-02f,
  -1.97601616e-01f, -1.99527159e-01f, 1.38303161e-01f, 7.60705024e-02f, -4.19453412e-01f, -1.55046225e-01f, -1.15374334e-01f, -1.61185175e-01f, 1.17561333e-01f, -4.94186044e-01f,
  -1.82114422e-01f, -2.82640159e-01f, 1.84518680e-01f, -2.56924815e-02f, -8.19907784e-02f, -4.26581055e-02f, -4.22861092e-02f, 6.47645071e-02f, 5.75981848e-02f, -5.59458416e-03f,
  -1.41928598e-01f, 2.12961100e-02f, -1.01814270e-01f, -1.30465329e-01f, -1.49796665e-01f, -7.86816925e-02f, -3.87886688e-02f, 8.44307914e-02f, 2.71754637e-02f, 4.65997085e-02f,
  -1.63296521e-01f, -2.49208175e-02f, 3.81911434e-02f, 6.76155910e-02f, 3.23173478e-02f, 1.81533948e-01f, 6.59406483e-02f, -4.93035205e-02f, 1.89229801e-01f, -3.63781214e-01f,
  -6.69434369e-02f, 6.02168962e-02f, 9.03478116e-02f, -5.69051877e-03f, 2.76081208e-02f, 9.10565034e-02f, 1.26148807e-03f, -1.16157860e-01f, -1.77926905e-02f, -5.84763139e-02f,
  1.25340186e-03f, -6.78656716e-03f, -4.98400033e-02f, -3.13487016e-02f, 3.04394495e-02f, -1.04064457e-01f, -5.60125820e-02f, 1.15178145e-01f, 8.46220404e-02f, -4.44016838e-03f,
  -1.62649788e-02f, -2.61061583e-02f, 4.97118980e-02f, 2.65570600e-02f, 3.71617600e-02f, 1.30784570e-03f, -3.41598690e-02f, 1.95171982e-02f, -8.14055279e-02f, 1.13738373e-01f,
  -3.35076720e-01f, 4.24670726e-01f, -3.18358213e-01f, 3.44517417e-02f, -5.35842218e-02f, 1.21281385e-01f, -4.68360446e-02f, 1.92421317e-01f, -1.11162357e-01f, -2.08169281e-01f,
  8.54835100e-03f, -2.51489043e-01f, -6.16727620e-02f, -1.28904767e-02f, -3.43344882e-02f, -3.75477150e-02f, 1.70651022e-02f, -1.81748390e-01f, 7.35890493e-02f, -1.37787849e-01f,
  -1.99498096e-03f, 1.01708272e-03f, -1.29022673e-01f, -8.35376531e-02f, -1.79705396e-01f, -9.41272709e-04f, -8.72730911e-02f, -1.13309830e-01f, 3.00593544e-02f, -3.09953630e-01f,
  5.44904411e-01f, -1.49226591e-01f, 2.68359452e-01f, 1.30319849e-01f, -2.09863484e-01f, -3.53550225e-01f, -3.99490684e-01f, -2.66225547e-01f, -3.47314440e-02f, -8.98687616e-02f,
  6.42758459e-02f, 1.37909368e-01f, 5.11468090e-02f, 2.00436726e-01f, 1.15405329e-01f, -9.48127732e-02f, 1.08632617e-01f, 3.52179170e-01f, 3.35789680e-01f, 9.82352495e-02f,
  1.00633569e-01f, 2.40757644e-01f, 3.65915239e-01f, 2.08510786e-01f, 2.89727032e-01f, 1.12545386e-01f, 1.84368819e-01f, 2.59330839e-01f, 1.72627151e-01f, 3.75449866e-01f,
  2.91723549e-01f, 1.91253796e-01f, 9.52150524e-02f, 1.75304562e-01f, 1.27229780e-01f, -4.63447943e-02f, -7.17822090e-02f, 7.16394559e-02f, -8.26131254e-02f, -9.34759900e-02f,
  2.09339578e-02f, 6.94056153e-02f, 2.79121641e-02f, 3.27700153e-02f, -1.75569970e-02f, -3.52285579e-02f, 7.13474378e-02f, 6.44361526e-02f, 5.46642989e-02f, -7.24145770e-02f,
  1.25676356e-02f, 1.14288889e-01f, -6.16921820e-02f, -2.52805948e-01f, -1.29034827e-02f, 1.43574476e-01f, -4.46622148e-02f, 2.40926240e-02f, 6.98375180e-02f, 1.23031363e-01f,
  2.39184394e-01f, 6.09258302e-02f, 1.53561547e-01f, 2.53701061e-02f, 6.85453117e-02f, 2.88861208e-02f, 3.39917578e-02f, 4.81960513e-02f, 7.56478533e-02f, 1.10606417e-01f,
  1.13151528e-01f, 1.28658917e-02f, -1.01718210e-01f, 4.38546054e-02f, 8.34017918e-02f, -3.51377614e-02f, -7.89609402e-02f, 1.02376807e-02f, 9.33963526e-03f, -2.83017270e-02f,
  5.68743348e-02f, 3.13227065e-02f, -8.09219573e-03f, 2.72037052e-02f, 2.95950733e-02f, 1.20876610e-01f, 1.99244777e-03f, -3.65024582e-02f, 1.42236622e-02f, 2.81874109e-02f,
  -5.14560580e-01f, -2.30045412e-02f, 1.30188093e-01f, 3.06628607e-02f, -7.12698847e-02f, 1.78484451e-02f, 1.00151658e-01f, -2.99684461e-02f, -1.71099439e-01f, -1.07551023e-01f,
  -1.22614009e-02f, -3.36662233e-02f, -9.30013359e-02f, -9.02100801e-02f, -1.02286495e-01f, -9.19332877e-02f, -8.50112438e-02f, -7.45831430e-02f, -1.67041272e-01f, -9.05538797e-02f,
  -5.44028915e-02f, -2.31530398e-01f, -1.39119282e-01f, -1.73304453e-01f, -1.32678390e-01f, -3.00353374e-02f, -1.04792111e-01f, -1.50237992e-01f, -1.57663316e-01f, -9.17970091e-02f,
  -2.80018598e-01f, -2.17035949e-01f, -7.88825899e-02f, -2.83926994e-01f, 2.48356094e-03f, -9.42992568e-02f, -3.40763092e-01f, -7.13397935e-02f, 8.48654937e-03f, -2.28094935e-01f,
  3.08047645e-02f, 7.32735097e-02f, -8.73856395e-02f, -9.43846777e-02f, -1.69512436e-01f, -3.76374125e-01f, -2.90067136e-01f, -1.18097879e-01f, 8.05699229e-02f, 1.85043618e-01f,
  1.89175345e-02f, 1.24618802e-02f, 5.04846126e-02f, 1.16096012e-01f, -3.45047601e-02f, 1.96302142e-02f, -1.75270796e-01f, -1.41811371e-01f, -6.67513013e-02f, -1.98088482e-01f,
  -1.07964925e-01f, -5.42372093e-02f, 1.05050266e-01f, 3.62902693e-02f, 1.35982987e-02f, 1.66107388e-03f, -9.48400050e-02f, 1.46231363e-02f, -9.89032164e-03f, -8.64018351e-02f,
  3.78305689e-02f, 1.47284701e-01f, -4.08678502e-03f, 5.92873842e-02f, 2.37295553e-02f, -5.93982115e-02f, -2.42968109e-02f, -3.38877961e-02f, -1.26429543e-01f, -5.23368642e-02f,
  -7.52001926e-02f, -6.14393614e-02f, -1.77275762e-01f, -1.08359016e-01f, -1.09203197e-01f, -5.43994680e-02f, -2.42195074e-02f, 5.09393960e-02f, -1.17046252e-01f, -2.21685171e-01f,
  9.46389735e-02f, 1.46802922e-03f, 3.08139604e-02f, -5.43755181e-02f, 4.76252511e-02f, -4.56392467e-02f, -1.10821575e-01f, -1.04179360e-01f, 3.19032930e-02f, -6.27200305e-02f,
  -3.80969942e-02f, 7.35438019e-02f, 1.14487410e-01f, -4.92919162e-02f, -5.04791699e-02f, -2.53525954e-02f, -8.82900581e-02f, -2.19248123e-02f, 3.50264125e-02f, -3.50165665e-02f,
  -9.29016545e-02f, 1.18687125e-02f, -1.20760664e-01f, -9.72838327e-03f, -9.36702490e-02f, -1.43886283e-01f, -1.95564441e-02f, -1.90275405e-02f, -8.76839906e-02f, -7.04978555e-02f,
  -2.73842156e-01f, 9.67337340e-02f, -7.09756836e-02f, -7.17091793e-03f, -1.16034942e-02f, -1.52838752e-02f, -8.92014131e-02f, 5.74142188e-02f, 5.38399369e-02f, 2.21397858e-02f,
  2.68981550e-02f, -8.87021050e-02f, -7.94204548e-02f, -2.36416273e-02f, -3.72627564e-02f, 6.24890788e-04f, -1.57339320e-01f, -2.80628894e-02f, 1.81253385e-02f, 7.88646564e-02f,
  -9.54084769e-02f, -6.93047717e-02f, -2.12728545e-01f, -2.30881155e-01f, -1.60708074e-02f, -1.37629837e-01f, -1.19385645e-01f, -1.24575458e-01f, -2.00777575e-01f, -3.95547181e-01f,
  -1.21630758e-01f, 1.54185623e-01f, -8.47799778e-02f, 3.01277936e-01f, 1.56007871e-01f, 2.77702976e-02f, -1.30160339e-02f, -1.72809958e-02f, 2.28486255e-01f, 1.81625500e-01f,
  1.67304039e-01f, 3.30767572e-01f, 1.53395236e-01f, 2.27859184e-01f, 7.06167612e-03f, 1.24332190e-01f, 1.93399489e-01f, -3.98210697e-02f, -1.04823753e-01f, 8.07787105e-02f,
  2.14967027e-01f, -2.27419380e-02f, -1.65430188e-01f, 8.67892709e-03f, 2.27710053e-01f, 9.72153768e-02f, -2.26856228e-02f, 1.45237923e-01f, 1.03890821e-01f, 3.35073560e-01f,
  8.84222612e-02f, 7.59024592e-03f, -2.11620033e-01f, 4.53841053e-02f, -9.98129100e-02f, -1.71862496e-03f, -1.11621141e-01f, -1.28508300e-01f, -3.90919074e-02f, -7.01474622e-02f,
  9.56655964e-02f, 3.09256036e-02f, 6.18679374e-02f, -5.95647693e-02f, -9.43323895e-02f, -1.60067841e-01f, -1.09714277e-01f, -1.31389037e-01f, -7.74277747e-02f, -6.70142025e-02f,
  2.89241433e-01f, 4.59747314e-02f, -2.32774273e-01f, -1.85568497e-01f, -1.10035360e-01f, -1.34121835e-01f, -2.27858335e-01f, -1.13360591e-01f, -3.54771525e-01f, -2.08587915e-01f,
  -4.90268599e-03f, -8.16478357e-02f, -5.45462593e-02f, -1.41799692e-02f, 1.01566151e-01f, -1.27621170e-03f, 1.20263152e-01f, 7.69396424e-02f, -5.69036081e-02f, -1.67362452e-01f,
  1.23970911e-01f, -5.13977744e-02f, -1.17404573e-01f, 2.06312556e-02f, 5.36067672e-02f, -6.94921473e-03f, 7.79686421e-02f, 4.14109975e-02f, -2.50733346e-02f, -7.10801408e-02f,
  -5.82430977e-04f, -9.85752977e-03f, -6.74312711e-02f, 8.86389613e-02f, 8.64936486e-02f, -8.58424604e-02f, -8.34108051e-03f, -6.10540472e-02f, -1.69053227e-01f, -1.32092655e-01f,
  -1.96565557e-02f, -2.12569326e-01f, -2.14963183e-02f, -9.60493088e-03f, -2.02840064e-02f, -5.67725822e-02f, 2.75503136e-02f, -1.76663082e-02f, -6.94116717e-03f, 6.72487989e-02f,
  -9.68912989e-02f, -1.27199396e-01f, -1.25690158e-02f, -4.54007909e-02f, 3.88660543e-02f, -9.60914269e-02f, 1.16222247e-01f, 1.84729397e-01f, 2.80844513e-02f, -1.81252919e-02f,
  -1.38814086e-02f, -1.07514404e-01f, -8.02553967e-02f, -1.69028029e-01f, -1.21507183e-01f, -2.03870922e-01f, -2.87606269e-01f, -2.45434791e-01f, -3.32363218e-01f, -3.83207977e-01f,
  6.28766418e-01f, 2.36038134e-01f, -1.19237654e-01f, 3.10341179e-01f, -3.23054083e-02f, -2.45322868e-01f, -5.57546802e-02f, 4.33615223e-02f, -1.70772672e-02f, 2.35012785e-01f,
  -3.42170484e-02f, -4.65504736e-01f, -1.18888587e-01f, -3.34031582e-01f, -3.11788917e-01f, 1.64071560e-01f, 1.13501102e-01f, -1.96289212e-01f, -5.64144671e-01f, -3.92489702e-01f,
  7.27657182e-03f, 1.98446065e-01f, 2.00773701e-01f, -8.29036459e-02f, 3.15725446e-01f, -6.31030798e-02f, 1.84521049e-01f, 1.11346036e-01f, -1.75869316e-01f, 2.20585272e-01f,
  -8.09464902e-02f, 2.32268959e-01f, -3.03926796e-01f, 7.70401396e-03f, 3.92442346e-02f, 4.81139868e-02f, -1.13222331e-01f, 2.97627486e-02f, -1.25203773e-01f, -9.62184668e-02f,
  -1.28203824e-01f, -2.04348847e-01f, -2.13600099e-01f, -2.19104797e-01f, -4.27977256e-02f, -5.98782338e-02f, 1.60608843e-01f, -5.79553768e-02f, -6.13303259e-02f, -1.33495569e-01f,
  -1.03416085e-01f, -7.81878009e-02f, -4.70482465e-03f, -9.11160484e-02f, -1.04932725e-01f, -1.24442779e-01f, -4.16815616e-02f, -8.79191607e-02f, -1.65612936e-01f, 3.85343760e-01f,
  2.83587500e-02f, -4.67582010e-02f, 2.87944041e-02f, 9.57347155e-02f, 7.38632306e-02f, -7.02290908e-02f, -7.02027380e-02f, 7.93845765e-03f, -1.25091702e-01f, 5.04497737e-02f,
  -7.03984126e-02f, 1.66124448e-01f, -1.32127851e-01f, 3.42590250e-02f, -5.71182333e-02f, -4.75380979e-02f, -1.41358435e-01f, 9.88882184e-02f, 1.11668572e-01f, 2.58002598e-02f,
  -8.51530880e-02f, 1.52191250e-02f, 8.90719742e-02f, -8.66946876e-02f, -4.73587513e-02f, -7.08946362e-02f, -5.28170951e-02f, -5.77350473e-03f, 2.60946453e-02f, 3.54065821e-02f,
  -1.30512344e-03f, -3.09283704e-01f, 1.27427652e-01f, -1.37684569e-01f, -9.48558375e-02f, -5.66754080e-02f, 6.15568496e-02f, 4.27366607e-03f, -8.06037039e-02f, -4.14608829e-02f,
  -1.21710807e-01f, -6.06113411e-02f, -6.80566356e-02f, -3.26061733e-02f, -1.72086358e-02f, 7.81948492e-02f, 2.06199169e-01f, -1.01565167e-01f, -8.32192376e-02f, -3.53840292e-02f,
  1.82233125e-01f, -8.12830999e-02f, 1.44914007e-02f, 8.39884281e-02f, -4.94682640e-02f, -1.94941070e-02f, 1.20209623e-02f, -1.48758620e-01f, -2.24458113e-01f, 3.49147469e-01f,
  -2.02083902e-04f, 1.50592159e-02f, 9.58097801e-02f, 3.38771284e-01f, 4.26313639e-01f, 4.29945439e-01f, 3.97144288e-01f, 3.20698798e-01f, 2.75245965e-01f, 2.68639863e-01f,
  2.19698668e-01f, 1.89152017e-01f, 2.84548163e-01f, 1.74825341e-01f, 1.27213031e-01f, 2.35841632e-01f, 1.43725485e-01f, 4.82245721e-02f, 1.19325221e-01f, 2.00837269e-01f,
  2.45193332e-01f, 9.41262245e-02f, 9.59229842e-02f, 1.39233202e-01f, 1.54881358e-01f, 1.13870487e-01f, 1.27607524e-01f, 1.22918665e-01f, 2.03265399e-01f, -9.67454463e-02f,
  -1.96448863e-01f, -7.76817277e-02f, -8.53649713e-03f, 9.99904703e-03f, -2.29571778e-02f, -1.40645221e-01f, -6.06581233e-02f, -8.52212086e-02f, -1.03585087e-01f, -1.68786943e-01f,
  -2.92596649e-02f, -1.48278862e-01f, -1.13714086e-02f, -8.54263976e-02f, -8.07351917e-02f, 2.63172816e-02f, 1.69142671e-02f, 6.58305734e-02f, -3.52777243e-02f, -6.38461187e-02f,
  1.16005011e-01f, 1.80141777e-02f, 8.71713087e-02f, 1.89056635e-01f, 1.14174709e-01f, -3.97926793e-02f, -4.17550206e-02f, -7.77087435e-02f, 7.46503547e-02f, -1.10660531e-01f,
  2.93548226e-01f, 2.84191333e-02f, 1.30696269e-03f, 1.00196257e-01f, 6.90399036e-02f, 6.30381852e-02f, -6.87714294e-02f, -2.26385705e-03f, 1.14706703e-01f, 8.68755430e-02f,
  8.88784006e-02f, 1.32383674e-01f, -2.39286665e-02f, 1.02244064e-01f, 1.74817294e-02f, 8.41073226e-03f, -1.34053439e-01f, -1.56822816e-01f, -1.06945582e-01f, -1.16250664e-01f,
  6.10701069e-02f, -8.86827707e-02f, -3.43105085e-02f, -5.74380942e-02f, -1.07663292e-02f, 9.83334854e-02f, -7.16003627e-02f, 8.22819993e-02f, 1.49280787e-01f, -1.94402039e-02f,
  6.15787618e-02f, 3.85162205e-01f, -7.78006017e-02f, -1.19850613e-01f, -1.09309770e-01f, -1.86002851e-01f, 2.01797467e-02f, -1.94517598e-01f, -2.28357852e-01f, -1.33557126e-01f,
  -4.99483757e-02f, -4.58965078e-02f, 7.06492811e-02f, -3.19630131e-02f, -1.19033568e-01f, -4.28355336e-02f, -3.43045853e-02f, 3.96244752e-04f, 3.30263153e-02f, -2.04292893e-01f,
  -3.52679044e-02f, 8.47781356e-03f, -1.68249700e-02f, 1.72543619e-02f, -2.53111054e-03f, -3.20888460e-02f, -1.46726385e-01f, 3.75195295e-02f, -6.97890520e-02f, 4.95358296e-02f,
  2.89289147e-01f, -5.97471297e-01f, 2.60578215e-01f, 2.66962618e-01f, 2.02280656e-01f, 2.05135494e-01f, -5.70602603e-02f, 9.42989364e-02f, 1.87860727e-01f, -9.65290144e-02f,
  -1.46629572e-01f, 4.35713269e-02f, -1.85746886e-02f, 9.54915509e-02f, 7.69637078e-02f, 2.16425434e-02f, 1.40777066e-01f, 3.50270331e-01f, 2.81318426e-01f, 5.16197756e-02f,
  4.51962464e-02f, -1.16179481e-01f, -5.34939133e-02f, 8.46166164e-02f, -1.31301478e-01f, 7.75536522e-02f, -2.08667554e-02f, 1.20983403e-02f, -8.35612789e-02f, -1.31466329e-01f,
  1.47123039e-02f, -1.49668336e-01f, 1.44363374e-01f, -1.21092379e-01f, -1.83964327e-01f, -1.39732361e-01f, 7.69135505e-02f, -1.37501493e-01f, -4.31275554e-02f, -7.38720447e-02f,
  -2.99041476e-02f, -8.47779363e-02f, -8.85251164e-02f, -1.28148451e-01f, -2.96188984e-02f, -6.63109422e-02f, -1.98603254e-02f, 1.52369589e-01f, 7.74025545e-02f, -7.39320740e-02f,
  -9.10667256e-02f, 3.36808562e-02f, 1.77030981e-01f, 1.64865941e-01f, 5.16720302e-02f, 1.25724152e-01f, -7.50034824e-02f, -3.56643572e-02f, 3.31401862e-02f, 1.18380621e-01f,
  6.52141720e-02f, 4.40554842e-02f, -2.84913182e-03f, 9.97276604e-02f, 1.19981259e-01f, 4.99568544e-02f, 1.72404155e-01f, 6.70177117e-02f, 7.54834786e-02f, -6.53368467e-03f,
  -1.58137467e-04f, 1.78550899e-01f, 4.40379567e-02f, 6.56183138e-02f, 1.74736534e-03f, -4.78956215e-02f, 6.32628873e-02f, -1.15536965e-01f, -4.05671187e-02f, -2.91669685e-02f,
  1.99034568e-02f, -2.76498571e-02f, -5.57115190e-02f, -6.83259889e-02f, -1.15319289e-01f, 6.60633445e-02f, -4.38995175e-02f, -1.17216051e-01f, -5.17945252e-02f, -2.46323948e-03f,
  -7.77949765e-02f, 2.64396995e-01f, 1.33815497e-01f, 2.35225540e-03f, 2.47490127e-04f, -1.25806272e-01f, 5.09790331e-02f, -3.69002856e-02f, 4.52078767e-02f, 1.68428235e-02f,
  -5.09532653e-02f, -1.75120533e-02f, -1.17421828e-01f, -1.19116455e-01f, 3.41936871e-02f, 1.30289823e-01f, 2.96489000e-02f, 1.80048123e-01f, 4.66243513e-02f, -1.07713208e-01f,
  -2.53107138e-02f, 2.71485865e-01f, 2.58345068e-01f, 2.91400701e-01f, 1.13236502e-01f, 2.58875012e-01f, 1.43204123e-01f, 5.49455732e-02f, 1.09484881e-01f, 1.49806933e-02f,
  7.22467184e-01f, -2.88931966e-01f, 1.46598056e-01f, 2.27828413e-01f, 9.75337997e-02f, 5.46769574e-02f, -1.74116492e-02f, 9.08493698e-02f, 8.45197067e-02f, -3.42393927e-02f,
  1.64631978e-02f, 2.15355635e-01f, 1.10371709e-01f, 2.00017611e-03f, 4.63764593e-02f, -1.81378812e-01f, -1.40873626e-01f, 2.54714519e-01f, 1.84448898e-01f, 6.45743012e-02f,
  -6.47175089e-02f, -6.04775995e-02f, 1.53293371e-01f, -7.02146590e-02f, -2.64806956e-01f, 3.89525294e-02f, -8.56541544e-02f, -2.21771061e-01f, -1.52623862e-01f, -2.14702904e-01f,
  -8.11280981e-02f, 9.63933915e-02f, 1.41916424e-01f, 1.54484808e-02f, 3.05118673e-02f, 1.06498577e-01f, 1.32918200e-02f, -4.77888994e-02f, -4.69977595e-02f, -6.26045931e-03f,
  -3.56035791e-02f, -8.81488260e-04f, 2.54474096e-02f, -2.68431138e-02f, 1.47034740e-02f, -3.05657741e-02f, -1.01741473e-03f, -4.79603671e-02f, -1.07709132e-01f, -9.42793041e-02f,
  -1.33408770e-01f, 4.04303446e-02f, -7.65037490e-03f, 6.68700412e-02f, 1.38408288e-01f, 7.79321343e-02f, 5.31925783e-02f, 1.24279866e-02f, 9.92057147e-04f, 8.74736905e-02f,
  1.33490324e-01f, 2.17629597e-02f, 7.38933086e-02f, 1.26106784e-01f, 5.68217896e-02f, 1.16022684e-01f, -4.09112126e-02f, 3.80720124e-02f, 7.10053816e-02f, 6.17150925e-02f,
  -1.10684589e-01f, 4.81298789e-02f, 3.21079232e-02f, 7.40652606e-02f, 6.48375452e-02f, -5.69445342e-02f, 4.74708676e-02f, -5.39122485e-02f, -2.07431242e-03f, -4.96036671e-02f,
  8.83501023e-03f, -1.48992985e-01f, -6.24522939e-03f, 9.52968840e-04f, -8.92940685e-02f, 3.56040038e-02f, -3.48495208e-02f, -9.29882303e-02f, -8.05824399e-02f, -1.21256925e-01f,
  -3.41241300e-01f, 2.84795105e-01f, -6.00204766e-02f, -2.07089297e-02f, -1.01135902e-01f, 2.53718067e-02f, 1.77778117e-02f, -1.50692254e-01f, -1.89751267e-01f, -1.48044348e-01f,
  -4.34693582e-02f, 1.24257602e-01f, -8.73403251e-02f, -5.59592098e-02f, 1.22374095e-01f, 5.07816300e-02f, -1.84856001e-02f, 8.03619698e-02f, -6.48900345e-02f, -6.30611852e-02f,
  -5.05734943e-02f, 5.68113625e-02f, 9.72088948e-02f, 1.45231828e-01f, 1.77959695e-01f, 1.26328215e-01f, 1.59460589e-01f, 9.01835337e-02f, 9.92166623e-02f, 1.26370728e-01f,
  5.09788096e-02f, 2.04628095e-01f, 1.54595122e-01f, 2.19509080e-02f, -1.84828743e-01f, -8.45508724e-02f, 3.59608904e-02f, -7.74137601e-02f, -6.56402931e-02f, 1.56456977e-01f,
  -1.43599622e-02f, -3.72481138e-01f, -1.97545528e-01f, -8.00921246e-02f, 5.44587933e-02f, 3.00855219e-01f, 1.58716977e-01f, -6.77715093e-02f, -3.30026180e-01f, -3.57979447e-01f,
  -2.55894214e-01f, -7.39149973e-02f, 2.32586334e-03f, -1.05657093e-01f, -7.84038380e-02f, -3.72484356e-01f, 1.62661433e-01f, 1.61542054e-02f, -4.44309711e-02f, 1.67107657e-01f,
  1.83874577e-01f, 7.72140250e-02f, -1.45959914e-01f, -3.11578251e-02f, 7.07005411e-02f, 1.04743786e-01f, 1.06825978e-01f, 1.16178431e-01f, 5.72827533e-02f, 1.50075138e-01f,
  8.02823901e-02f, 5.31740822e-02f, 6.52656630e-02f, 6.89682141e-02f, 5.35915196e-02f, 3.04668583e-02f, 6.33758903e-02f, 7.17764571e-02f, -5.64148352e-02f, 1.31870629e-02f,
  -1.18211396e-01f, -3.41402777e-02f, -5.71138784e-02f, -1.05956877e-02f, -5.23557551e-02f, -1.71829939e-01f, 1.67350005e-02f, 3.00612375e-02f, -7.30576739e-02f, 9.18477848e-02f,
  8.33019465e-02f, 1.06797844e-01f, -9.30937007e-02f, 8.41638073e-02f, 1.58014268e-01f, 9.83518437e-02f, 6.55034184e-02f, 5.01648039e-02f, 1.66998535e-01f, 2.02602953e-01f,
  1.18847936e-01f, -5.14764432e-03f, 2.21134484e-01f, 1.47033408e-01f, 5.04335277e-02f, 6.55726790e-02f, 1.20125011e-01f, -1.42340483e-02f, -1.07195973e-01f, 9.30167586e-02f,
  -3.80185954e-02f, -7.37968534e-02f, 4.38116379e-02f, -2.70878188e-02f, 1.03111789e-01f, 1.14903294e-01f, -1.31967599e-02f, 3.12913395e-02f, -4.42375168e-02f, 9.62883905e-02f,
  -1.97417080e-01f, 7.74444863e-02f, 9.75838527e-02f, 2.51257978e-03f, 4.28077020e-02f, 1.06392048e-01f, 9.96773690e-02f, 7.45537430e-02f, 1.15688920e-01f, 1.87079847e-01f,
  4.58200350e-02f, 1.25501528e-01f, 1.27651319e-01f, 1.42281756e-01f, 2.68438514e-02f, 6.02851529e-03f, -5.33652538e-03f, -1.49099112e-01f, -4.17737328e-02f, 8.03717300e-02f,
  -1.35444134e-01f, -8.61173868e-02f, -9.34900865e-02f, -7.46732131e-02f, -6.63094819e-02f, -2.33270958e-01f, -3.63731012e-02f, 3.01766526e-02f, -8.88197869e-02f, -9.06891972e-02f,
  -9.19030681e-02f, -4.24367547e-01f, -3.03779393e-01f, -3.83324832e-01f, -2.67670989e-01f, -4.83769216e-02f, -1.42919406e-01f, -1.48908749e-01f, -2.00380713e-01f, -3.32559645e-01f,
  -7.36365765e-02f, 1.51625663e-01f, 1.42374501e-01f, 6.22328110e-02f, 1.28516182e-01f, -3.19053203e-01f, -4.48223531e-01f, -1.76595077e-01f, 1.75393134e-01f, 9.42220837e-02f,
  -1.19529992e-01f, -1.92161798e-01f, -4.31495197e-02f, -2.00139597e-01f, -2.88170129e-01f, -5.81102967e-02f, -2.95099854e-01f, -2.74880171e-01f, -1.73959196e-01f, -3.32992673e-01f,
  6.86215237e-02f, 1.79674327e-01f, 1.24233872e-01f, 8.69240165e-02f, -7.33810337e-03f, 5.86940572e-02f, 9.56079662e-02f, -8.33116621e-02f, 1.16528021e-02f, -6.16016844e-03f,
  -4.96747941e-02f, 9.98498946e-02f, 1.82774011e-02f, -8.25137924e-03f, -7.53400400e-02f, 1.33608103e-01f, 4.46924977e-02f, -6.63248077e-02f, -1.21373937e-01f, 7.94789754e-03f,
  -2.55942252e-02f, 1.22764036e-01f, 5.03215790e-02f, 9.07450318e-02f, 1.02649644e-01f, 2.56004900e-01f, 1.32875770e-01f, 1.23828791e-01f, 1.25127867e-01f, 1.19617932e-01f,
  2.08886992e-02f, -6.90697059e-02f, 1.30348578e-02f, 2.09955946e-01f, 7.77668431e-02f, 7.01009110e-02f, -3.78071442e-02f, -3.29391696e-02f, 4.99266423e-02f, 3.42480019e-02f,
  1.03176190e-02f, -8.64964426e-02f, 3.90516222e-02f, -2.18450017e-02f, -1.29530475e-01f, -3.44775468e-02f, -1.07743256e-01f, 1.57660879e-02f, 3.22762243e-02f, -4.19825735e-03f,
  1.02468394e-03f, -1.00450106e-02f, -2.13967353e-01f, -9.92761403e-02f, -5.00092171e-02f, -7.53042698e-02f, -2.39153090e-03f, 7.14809746e-02f, -5.70609868e-02f, -5.85630983e-02f,
  2.29054019e-02f, 2.13894442e-01f, -2.01147404e-02f, 1.88105647e-02f, -9.31581203e-03f, -3.66711281e-02f, -1.27558699e-02f, -1.32886052e-01f, -2.30630096e-02f, 2.69887096e-04f,
  2.65080854e-02f, -2.06928737e-02f, -1.23328371e-02f, 5.37473001e-02f, 1.35816440e-01f, 1.35299638e-01f, 6.87052459e-02f, -5.80731630e-02f, -6.52197897e-02f, -1.71733871e-01f,
  -1.50391296e-01f, 9.54288021e-02f, 1.93306118e-01f, 1.85937017e-01f, 2.10749447e-01f, 1.70967609e-01f, 4.27365527e-02f, 5.67208491e-02f, 6.90598562e-02f, -8.36068094e-02f,
  -3.09961855e-01f, 2.65690774e-01f, -7.66862854e-02f, 1.65990025e-01f, 1.21963270e-01f, -1.06492527e-01f, -1.38058811e-01f, -1.92362517e-01f, 1.10479794e-01f, 6.58727065e-02f,
  -1.42795861e-01f, 2.12207939e-02f, 2.18870014e-01f, 1.14448734e-01f, -2.15572521e-01f, 8.66565183e-02f, 2.92577773e-01f, -1.94987744e-01f, -4.18940037e-01f, -2.91384757e-01f,
  5.47641441e-02f, -3.12231444e-02f, -3.29877317e-01f, -2.34571889e-01f, 3.43953609e-01f, -9.73661467e-02f, 8.56173187e-02f, 2.36711383e-01f, 2.49584436e-01f, 5.92601061e-01f,
  5.95352836e-02f, 1.25227109e-01f, -8.13734755e-02f, 8.92397910e-02f, 9.50821862e-02f, -5.20931818e-02f, -8.78982097e-02f, 1.07786477e-01f, 1.03458479e-01f, 6.73799589e-02f,
  5.83049171e-02f, 3.20532061e-02f, 1.32584527e-01f, 3.32612172e-03f, -1.66192710e-01f, -2.52234012e-01f, -1.33114040e-01f, -1.18465751e-01f, -7.88702667e-02f, -9.76982191e-02f,
  2.52830327e-01f, 8.97737313e-03f, -1.44391447e-01f, -5.86568713e-02f, 7.40377605e-02f, -1.80744633e-01f, -8.28648582e-02f, -5.87949641e-02f, -2.23875284e-01f, 4.14661467e-02f,
  -1.02889471e-01f, 4.23482247e-02f, 5.19414656e-02f, 1.22947179e-01f, -1.00565895e-01f, 2.19337139e-02f, 2.13987902e-01f, -6.55930862e-02f, 4.62318258e-03f, -1.16117284e-01f,
  -2.68997485e-03f, -9.20950100e-02f, 2.38138773e-02f, 3.35550159e-02f, -5.27151152e-02f, -8.12503770e-02f, -9.49151590e-02f, -1.09120004e-01f, -9.90667120e-02f, -4.60288972e-02f,
  1.01110898e-02f, 3.96416374e-02f, 6.86856806e-02f, -7.99292922e-02f, 1.32667825e-01f, 1.49756204e-02f, 2.61522569e-02f, 4.82574925e-02f, 1.64438672e-02f, 5.68688326e-02f,
  -6.28267154e-02f, -7.70404413e-02f, -7.25268805e-03f, -1.30005796e-02f, 5.78465238e-02f, -8.04472566e-02f, 1.69261888e-01f, -4.52966467e-02f, 1.30466178e-01f, -1.65887892e-01f,
  -1.38153523e-01f, -1.22913085e-01f, 1.92155257e-01f, -7.04708546e-02f, -2.42103979e-01f, -2.00896487e-02f, 2.28112768e-02f, 7.53204599e-02f, -7.10847601e-02f, -3.77570651e-02f,
  -1.18629895e-02f, -3.05810869e-01f, -4.02144015e-01f, -1.90179139e-01f, 1.75145455e-02f, -3.03870469e-01f, -2.29088411e-01f, -1.28905147e-01f, -2.38928378e-01f, -2.93884575e-01f,
  -5.11763930e-01f, 2.82586366e-02f, -1.63774192e-01f, -2.51471609e-01f, 1.59634262e-01f, 3.44475687e-01f, 2.77938515e-01f, 3.05383891e-01f, 3.73429097e-02f, -7.28640258e-02f,
  -1.65622507e-03f, -7.97280744e-02f, -1.97011381e-01f, 5.82823083e-02f, 4.16487418e-02f, -1.84954714e-03f, -2.39962146e-01f, -2.17689291e-01f, 7.81898648e-02f, 3.48727554e-01f,
  1.30569801e-01f, -1.39218435e-01f, -2.14049131e-01f, -1.09135121e-01f, -1.31297842e-01f, -1.94733679e-01f, -2.92670220e-01f, -2.37159595e-01f, -1.47633255e-01f, -4.03336912e-01f,
  -2.30849907e-01f, 4.58803810e-02f, 1.90600440e-01f, -1.27105027e-01f, -1.07139364e-01f, -2.14798264e-02f, -2.06575431e-02f, -1.49806878e-02f, 1.88047644e-02f, -2.98849475e-02f,
  -9.89251509e-02f, 1.22483701e-01f, -4.87540700e-02f, 8.61515626e-02f, 1.03078164e-01f, 7.65893012e-02f, 7.31803700e-02f, 1.15505286e-01f, -6.72935992e-02f, 1.25563949e-01f,
  -1.37822900e-03f, -1.86774924e-01f, -2.12678909e-01f, 3.46102864e-02f, 1.29278898e-01f, -1.58051655e-01f, -6.41457066e-02f, -2.35550832e-02f, -2.14499071e-01f, -3.53413910e-01f,
  6.15239330e-02f, 3.95450508e-03f, 1.12730712e-01f, 4.02641445e-02f, 6.16785663e-04f, -6.62298128e-02f, 9.95211024e-03f, 4.20461372e-02f, 9.13616717e-02f, -9.06260386e-02f,
  8.76963809e-02f, 8.69359374e-02f, -2.80422205e-03f, -1.19480513e-01f, -1.15105204e-01f, -8.86146948e-02f, -5.26671559e-02f, -1.51670992e-01f, -1.19319938e-01f, -1.05830140e-01f,
  -1.02685578e-02f, 1.20775634e-02f, 4.15523425e-02f, 5.06884139e-03f, -2.15313286e-02f, -5.52928858e-02f, 2.10483093e-02f, 1.85913697e-01f, 7.52519891e-02f, -2.28465199e-02f,
  -3.20596099e-01f, -1.18968084e-01f, -2.28560373e-01f, 9.15506259e-02f, -9.11706500e-03f, -7.02340752e-02f, -2.43189186e-01f, 5.97353987e-02f, 3.59770469e-02f, 4.80845459e-02f,
  1.52658850e-01f, 1.78695917e-02f, -1.29555196e-01f, 1.06328860e-01f, 1.55288190e-01f, 2.91024242e-02f, 2.84269918e-02f, -3.57679389e-02f, 3.88984047e-02f, 7.17047229e-02f,
  -2.09007952e-02f, -1.46844342e-01f, -2.04242453e-01f, -5.54406904e-02f, -1.68571658e-02f, -2.40807474e-01f, -3.14266056e-01f, -1.31667852e-01f, -3.14649403e-01f, -4.84120905e-01f,
  -1.32179812e-01f, 3.30697596e-01f, -7.63115436e-02f, 3.29360999e-02f, -1.80589318e-01f, -8.28435421e-02f, 1.49009377e-01f, 1.48065075e-01f, 1.12064727e-01f, 6.24934845e-02f,
  -4.88107093e-02f, 1.74986139e-01f, 1.22071229e-01f, 2.01787278e-01f, 1.91824079e-01f, 2.02109441e-01f, 1.26632735e-01f, 3.04854736e-02f, -5.36830314e-02f, 1.43546090e-01f,
  1.41029522e-01f, 1.09412167e-02f, 3.98210175e-02f, 9.21642929e-02f, 7.38012567e-02f, -4.30010930e-02f, 6.74385726e-02f, 3.66418064e-02f, -4.18919399e-02f, 1.63235337e-01f,
  2.89341003e-01f, -2.04967767e-01f, 6.28130957e-02f, 1.03248753e-01f, -1.05847597e-01f, 6.89922050e-02f, 1.44994594e-02f, 9.19376314e-02f, 6.11724481e-02f, 1.63427398e-01f,
  -6.68846518e-02f, -1.30524635e-01f, -2.26013064e-01f, 1.62992310e-02f, -5.71923181e-02f, -1.21793658e-01f, 1.31061794e-02f, 8.59252587e-02f, 2.04614431e-01f, 6.91829473e-02f,
  5.33806607e-02f, -6.15837574e-02f, -1.90226641e-02f, -6.32734457e-03f, -2.90747639e-02f, -7.89814889e-02f, 7.42881596e-02f, -9.06143785e-02f, -9.39059705e-02f, 8.94450247e-02f,
  2.87087888e-01f, 2.13400409e-01f, -2.22872989e-03f, 6.56017885e-02f, 1.65120065e-02f, -7.14460984e-02f, 3.83774638e-02f, 6.18451238e-02f, 7.98684359e-02f, -1.05798997e-01f,
  -2.21898220e-03f, -9.89738777e-02f, -9.39141959e-03f, -1.49775520e-02f, -1.86977640e-01f, -9.68966261e-02f, -6.67801425e-02f, -8.89733434e-04f, -2.21653521e-01f, -1.42336592e-01f,
  -2.28254199e-01f, 7.45314658e-02f, -1.82255268e-01f, -8.64784643e-02f, -1.08403817e-01f, -1.10404156e-01f, -3.91853750e-02f, -9.66028199e-02f, 6.56449841e-03f, -1.24042846e-01f,
  3.91866714e-01f, -3.67491573e-01f, 3.06257103e-02f, 8.67673680e-02f, -1.67285189e-01f, -1.45977452e-01f, -1.18267536e-01f, -4.71948199e-02f, 8.22771117e-02f, 1.04157254e-01f,
  -1.03995398e-01f, -7.36437738e-02f, -6.88308291e-03f, 1.56904329e-02f, -1.69935584e-01f, -1.40329301e-01f, -2.62966305e-02f, 1.80214971e-01f, 1.98592886e-01f, 1.16483182e-01f,
  1.06196240e-01f, 7.72441700e-02f, 4.52396199e-02f, -8.87247398e-02f, -4.99625318e-02f, -6.44579530e-02f, -2.93045640e-02f, -3.36109847e-02f, 5.76631911e-02f, 1.00448675e-01f,
  -1.69847459e-01f, -8.14336985e-02f, 3.21328500e-03f, -1.38211042e-01f, -1.46433696e-01f, -2.13874280e-01f, 3.38658914e-02f, -1.10940173e-01f, -1.48664892e-01f, 1.60046652e-01f,
  -8.97684768e-02f, -2.44666263e-01f, -9.27086473e-02f, -1.85161695e-01f, -1.86297372e-01f, 1.21486180e-01f, -1.24303512e-02f, -3.21120098e-02f, -1.27690792e-01f, -2.55242854e-01f,
  -1.25963628e-01f, -1.63531080e-02f, -1.99989274e-01f, -1.94892690e-01f, -4.58346754e-02f, -1.43294141e-01f, 4.80463775e-03f, -1.90921962e-01f, -1.71432555e-01f, 2.20382512e-02f,
  2.86765963e-01f, -3.26143593e-01f, 2.55195405e-02f, -1.19343355e-01f, 1.50570124e-02f, -2.56101135e-02f, -1.25932828e-01f, 5.00021018e-02f, 1.25733063e-01f, 1.01923063e-01f,
  -7.05150217e-02f, -4.19805311e-02f, 1.53922215e-02f, 2.03222055e-02f, 3.76197882e-02f, 1.95144769e-02f, 2.53221877e-02f, -1.18785635e-01f, -1.28319815e-01f, -5.16729131e-02f,
  -1.57288238e-01f, -1.32689819e-01f, 2.32223794e-03f, -7.14233890e-02f, -2.50382245e-01f, -8.29257965e-02f, -1.86064988e-02f, -2.60666788e-01f, -2.64570028e-01f, 9.08367634e-02f,
  2.48780958e-02f, 1.21086724e-01f, -9.79266595e-03f, -3.97390723e-02f, 1.47037841e-02f, 1.06147937e-01f, -4.63930704e-03f, 5.38698286e-02f, -2.10800711e-02f, 3.91289704e-02f,
  7.29511008e-02f, -1.72132969e-01f, -1.41617432e-01f, 5.10435551e-02f, -1.40444979e-01f, -1.08577557e-01f, 5.96250687e-03f, -6.56694472e-02f, -9.57931280e-02f, -1.23117052e-01f,
  -1.90843895e-01f, -1.33246273e-01f, -1.01977430e-01f, -3.18885930e-02f, -2.34592259e-01f, -1.79059356e-01f, -3.67069356e-02f, -1.59163713e-01f, -3.15994024e-02f, -1.38585633e-02f,
  1.81238353e-01f, -2.39340216e-01f, 3.04942518e-01f, -2.20008567e-02f, -4.15561013e-02f, 1.43876327e-02f, -2.68089026e-01f, -1.63304836e-01f, 6.64123371e-02f, -7.96876177e-02f,
  -1.53517783e-01f, -5.20543233e-02f, 1.47019356e-01f, 6.47213385e-02f, 1.12810060e-01f, -6.33862317e-02f, -3.61782722e-02f, 1.15017831e-01f, 3.46414521e-02f, 6.90139607e-02f,
  1.04086243e-01f, 1.13015220e-01f, 2.16349006e-01f, 1.97237343e-01f, 1.29075944e-01f, 1.64095014e-01f, 2.15899006e-01f, 1.55457228e-01f, 1.17714241e-01f, 3.27763557e-01f,
  2.80313730e-01f, -2.99353735e-03f, -4.39439774e-01f, 1.66659668e-01f, -3.41488838e-01f, -3.04870993e-01f, -1.90900341e-01f, 1.37768000e-01f, 1.89137131e-01f, -1.55025527e-01f,
  -1.84675679e-01f, -3.69738266e-02f, -8.16796273e-02f, -1.30125463e-01f, -1.02956519e-01f, -2.35321835e-01f, -2.24194139e-01f, -3.12038302e-01f, -2.48054311e-01f, -1.92438304e-01f,
  -1.97533250e-01f, -1.57629132e-01f, -5.57302982e-02f, -1.27062574e-01f, -1.23826265e-01f, -2.31413081e-01f, -2.99190462e-01f, -2.59974003e-01f, -4.08037871e-01f, -4.08456475e-01f,
  -2.98705548e-01f, -1.61663443e-02f, -1.58849299e-01f, -1.10226637e-02f, -3.44558209e-02f, -3.25426459e-02f, -7.47841150e-02f, -4.39211493e-03f, 9.70099960e-03f, -5.63884201e-03f,
  -8.22577532e-03f, 9.24739335e-03f, -4.33635190e-02f, -1.41774699e-01f, -1.16452068e-01f, 3.88007681e-03f, -3.70846665e-03f, -5.51432110e-02f, -1.54999122e-02f, -8.70641097e-02f,
  -6.67521879e-02f, -1.79005340e-01f, -8.70803222e-02f, -3.79187502e-02f, 1.12693803e-02f, -6.12744354e-02f, -1.14033967e-01f, -1.19370550e-01f, -1.32421687e-01f, -1.03483446e-01f,
  2.44177416e-01f, 7.78012201e-02f, -1.19265139e-01f, 1.07896097e-01f, 1.64731045e-03f, 6.48145080e-02f, -4.10040990e-02f, -9.88734663e-02f, -3.34167033e-02f, 3.57672609e-02f,
  8.84901062e-02f, -1.86225995e-02f, 7.31765628e-02f, -8.42618644e-02f, -1.04739308e-01f, -6.90193698e-02f, -2.38875058e-02f, -1.37189925e-01f, -1.46272659e-01f, -1.18291572e-01f,
  -5.53765707e-02f, -1.01715043e-01f, 2.16304269e-02f, -1.10893279e-01f, -6.33745268e-02f, -2.72925477e-02f, -5.63820004e-02f, 4.29437542e-03f, 3.99853289e-02f, -8.40549543e-02f,
  2.19443813e-01f, -7.40068220e-03f, 5.87076358e-02f, -3.04887556e-02f, -8.62177741e-03f, -9.95509401e-02f, -1.00783564e-01f, -8.37704458e-04f, 3.51569355e-02f, -2.15507112e-02f,
  -2.71262620e-02f, -4.29045111e-02f, -7.01132044e-03f, -4.48252708e-02f, -4.23206016e-02f, -7.41512654e-03f, 4.18442339e-02f, -1.33580267e-01f, -1.06679544e-01f, 8.01688880e-02f,
  1.20178491e-01f, 8.89055780e-04f, 1.93280011e-01f, 6.57174317e-03f, 1.05905816e-01f, 1.29298791e-02f, -1.08923726e-02f, -1.30250948e-02f, 2.24281345e-02f, 1.01975672e-01f,
  -9.05116200e-01f, 3.27702105e-01f, 3.29850614e-02f, -7.75997162e-01f, -1.76623806e-01f, 2.57706523e-01f, 5.08834898e-01f, -5.08914283e-03f, -3.00155699e-01f, 6.99968040e-02f,
  5.90945631e-02f, -1.94181874e-01f, -9.94411483e-02f, 1.91970959e-01f, 1.67447522e-01f, 2.28270680e-01f, -7.40655325e-03f, -1.71973482e-01f, -2.09076494e-01f, 9.79802310e-02f,
  8.56012329e-02f, -3.46724480e-01f, -4.19657171e-01f, -2.82787532e-01f, -1.78403094e-01f, -1.02680601e-01f, 7.15526640e-02f, -1.39132097e-01f, 2.98993260e-01f, 3.37967686e-02f,
  2.79167712e-01f, -2.31204227e-01f, 4.05852348e-02f, -1.36513099e-01f, -5.79914115e-02f, -6.21304587e-02f, -5.06381541e-02f, -1.14000268e-01f, -1.67312771e-01f, -8.14100727e-02f,
  -2.40418226e-01f, -7.70130828e-02f, -1.58069432e-01f, 6.60751313e-02f, -2.48513862e-01f, 1.34834321e-02f, 6.67521078e-03f, -1.59468818e-02f, 1.46427745e-04f, 2.99920321e-01f,
  1.35077387e-01f, -6.43540919e-02f, -9.52875093e-02f, 2.00931504e-01f, 6.62042499e-02f, -1.06474444e-01f, 2.12377220e-01f, 4.22283597e-02f, 1.88059613e-01f, 4.63289507e-02f,
  1.05768085e-01f, 5.66080436e-02f, -6.84404094e-03f, 6.61897734e-02f, -1.83551926e-02f, 2.72272551e-03f, -3.39916795e-02f, -2.07597334e-02f, -1.81530905e-03f, 4.46905233e-02f,
  -6.57029152e-02f, 1.18355304e-01f, -6.95709791e-03f, 9.88053307e-02f, 5.96908629e-02f, -7.75608718e-02f, -1.51258511e-02f, -3.01327575e-02f, -2.03676075e-02f, -7.67530426e-02f,
  -7.03854114e-02f, -3.01948376e-02f, -4.44422886e-02f, 1.98890436e-02f, 1.78906564e-02f, -1.69703767e-01f, 1.30358385e-02f, 6.69454113e-02f, 5.38598895e-02f, 2.70167552e-02f,
  4.30904552e-02f, -4.71719876e-02f, -9.59765464e-02f, -3.92033868e-02f, -1.91469267e-01f, -2.63563264e-02f, -8.65004957e-02f, -2.61055790e-02f, -1.23176843e-01f, 3.07458695e-02f,
  -4.63737100e-02f, -7.93132260e-02f, -4.65561710e-02f, 1.03527762e-01f, 7.73020461e-03f, -9.68608484e-02f, 2.46220181e-04f, -4.31436813e-03f, 2.46959608e-02f, 5.50233163e-02f,
  1.10880382e-01f, 4.88877445e-02f, -7.10033774e-02f, 9.58247781e-02f, 1.45955563e-01f, -9.63962823e-02f, 1.57377467e-01f, 9.87134501e-02f, 3.58493254e-02f, 2.48160556e-01f,
  5.01988649e-01f, 2.34261930e-01f, 2.73822248e-01f, 1.31809309e-01f, -2.61026680e-01f, -1.93105251e-01f, -3.25377911e-01f, -1.01950556e-01f, 7.16643631e-02f, -2.82730591e-02f,
  -1.66874789e-02f, -7.01896176e-02f, 8.81526247e-02f, 1.08186424e-01f, -6.07260549e-03f, -4.25497517e-02f, -1.41843408e-01f, 2.13426620e-01f, 9.24049690e-02f, -8.34613591e-02f,
  -8.77754390e-02f, 3.91075462e-02f, 1.50084406e-01f, 4.08346578e-02f, 2.19043121e-02f, -4.12776768e-02f, -1.06275454e-02f, -1.80768758e-01f, -1.12039652e-02f, 2.18547732e-01f,
  3.70483577e-01f, 2.43706509e-01f, 1.48318142e-01f, 1.21906279e-02f, 4.35718670e-02f, 2.26350799e-01f, 9.61883292e-02f, 7.32940808e-02f, -3.29987928e-02f, -3.55781958e-05f,
  1.49463583e-02f, -1.41324820e-02f, -1.14775889e-01f, 3.18746492e-02f, -1.16664201e-01f, 1.29200518e-02f, 1.21165803e-02f, -1.85985658e-02f, 1.55880302e-02f, 4.86931317e-02f,
  -4.56431992e-02f, -1.68169871e-01f, -5.86571023e-02f, -1.38984412e-01f, -6.20351806e-02f, -7.76936412e-02f, -6.81613833e-02f, 9.32544842e-02f, -6.81920797e-02f, 6.38753101e-02f,
  -1.30036190e-01f, -9.45062116e-02f, -4.69218212e-05f, -9.16525945e-02f, -1.47834376e-01f, 2.05419119e-02f, -1.32813007e-01f, -1.45057544e-01f, -8.81150961e-02f, -1.11705422e-01f,
  -1.84600517e-01f, -5.48337735e-02f, -3.28486636e-02f, -1.37634203e-02f, 1.64821446e-01f, 4.35081013e-02f, 7.23946141e-03f, 5.17965704e-02f, 5.30661941e-02f, 2.43643671e-02f,
  -4.48268317e-02f, 3.17901298e-02f, 8.51081610e-02f, 3.57436389e-02f, 5.03273383e-02f, 5.78438677e-02f, -6.77475855e-02f, -5.18173724e-02f, -3.91215123e-02f, -6.48449287e-02f,
  4.69915904e-02f, 6.80774823e-02f, 1.39078498e-01f, 6.53731972e-02f, 7.53527135e-02f, 2.27900192e-01f, 2.23346114e-01f, 1.83916420e-01f, 3.75555977e-02f, 1.11076944e-01f,
  1.47715941e-01f, 1.66822001e-01f, 4.39705998e-02f, 6.42133653e-02f, -8.68287906e-02f, 2.80185305e-02f, 3.61071415e-02f, 9.63313729e-02f, 1.69148117e-01f, 1.63889974e-01f,
  1.20396823e-01f, -3.49734202e-02f, -7.10298419e-02f, -8.49090889e-02f, -7.03593269e-02f, -3.66783552e-02f, -3.02618905e-03f, -1.55600198e-02f, -4.86674383e-02f, -1.72168866e-01f,
  6.85714543e-01f, -1.36776000e-01f, -8.46883595e-01f, 1.46633771e-03f, -3.57898653e-01f, -1.44694254e-01f, -1.36719018e-01f, 1.59674719e-01f, 5.91489002e-02f, -2.85892636e-01f,
  1.12328166e-02f, 3.27944785e-01f, -2.36100517e-02f, -4.20553386e-02f, 7.82002956e-02f, -4.15049046e-01f, -4.51198667e-01f, -8.28505084e-02f, 1.69839025e-01f, 2.06009746e-01f,
  1.88445061e-01f, 1.42080650e-01f, 2.84492403e-01f, 1.56939477e-01f, -1.69125870e-01f, -9.07515511e-02f, -4.73256141e-01f, -1.43855169e-01f, -1.24217466e-01f, -4.84858781e-01f,
  -4.29939389e-01f, -1.80848241e-01f, 6.12163357e-03f, 1.87203452e-01f, -6.49226457e-02f, 1.37097910e-01f, -8.60876753e-04f, -4.13236097e-02f, 4.81623374e-02f, -9.32494327e-02f,
  -1.42848238e-01f, -1.23724155e-03f, 1.77478299e-01f, -6.53250739e-02f, 5.37654012e-02f, 9.54394713e-02f, -7.62728080e-02f, -2.22690590e-02f, 7.73019344e-02f, -7.38114491e-02f,
  -3.92702669e-02f, -9.46374759e-02f, 3.18130627e-02f, -8.51449668e-02f, -4.57970379e-03f, -9.72259790e-03f, -8.10359344e-02f, -3.59874126e-03f, 3.14535163e-02f, -1.04532376e-01f,
  -6.85683191e-02f, 2.51819547e-02f, 2.51272097e-02f, 1.06609035e-02f, 1.74378365e-01f, -1.20183704e-02f, 6.98292404e-02f, 1.28130332e-01f, 9.64075774e-02f, 6.84586987e-02f,
  -7.19952285e-02f, 2.31744777e-02f, 2.49022432e-02f, 5.79193048e-02f, -7.94791132e-02f, -1.38782365e-02f, -8.19443017e-02f, 4.60086167e-02f, 2.49971859e-02f, 5.68897873e-02f,
  8.54430795e-02f, 1.13920225e-02f, -5.07360734e-02f, 5.23701385e-02f, 2.69965138e-02f, -2.41601598e-02f, -1.20702103e-01f, 1.53435394e-01f, 3.34300883e-02f, -1.73929315e-02f,
  1.69861302e-01f, -4.42201048e-02f, 1.17882416e-02f, 5.68570718e-02f, -1.20223977e-01f, -1.31365851e-01f, -5.84028549e-02f, 1.85673516e-02f, 1.61388163e-02f, 9.62465536e-03f,
  -2.09874343e-02f, 9.85909924e-02f, 1.54388091e-02f, -3.95632349e-02f, 7.01833516e-02f, 5.99031150e-03f, 1.49558991e-01f, -2.81336787e-03f, 9.42194611e-02f, 2.79577486e-02f,
  9.39972047e-03f, 2.33369082e-01f, 1.65549621e-01f, -3.15865725e-02f, -5.65896183e-03f, 5.70113994e-02f, -7.60392100e-02f, -1.10237233e-01f, 5.20676151e-02f, 9.90343615e-02f,
  -3.16117316e-01f, -6.17898345e-01f, 3.43039691e-01f, 8.88863653e-02f, 3.46577108e-01f, -6.79055452e-02f, -4.02304351e-01f, -5.63103914e-01f, -2.78936863e-01f, -9.17281136e-02f,
  -1.95735265e-02f, 1.67169735e-01f, -4.42458354e-02f, -2.31794536e-01f, -3.56542796e-01f, -1.39203936e-01f, 3.43508180e-03f, 5.59458062e-02f, 2.03965351e-01f, 2.49954477e-01f,
  1.67464674e-01f, 1.44462422e-01f, 3.40883471e-02f, -5.04849367e-02f, 1.48299202e-01f, 2.47620508e-01f, 6.93633929e-02f, 1.00736348e-02f, 2.31123082e-02f, 1.79547638e-01f,
  4.61293459e-01f, -2.57996261e-01f, -1.15004331e-02f, -5.40104918e-02f, 1.45939991e-01f, -2.85675377e-01f, 3.65824625e-03f, -6.36587888e-02f, -6.78843185e-02f, -1.05578162e-01f,
  4.56091352e-02f, -7.66425580e-02f, -5.54160550e-02f, 8.47075507e-03f, 2.52213608e-02f, 5.98020991e-03f, -1.37560681e-01f, -1.93663344e-01f, -2.93499321e-01f, 7.77120590e-02f,
  7.53875226e-02f, 1.99928254e-01f, 8.62026140e-02f, -3.04207027e-01f, -2.25815579e-01f, 1.61898732e-02f, -1.57314092e-01f, -1.44842595e-01f, -1.45494938e-01f, -1.60649881e-01f,
  9.58337449e-03f, -6.92660809e-02f, -2.86958925e-02f, -3.51483598e-02f, 1.40406145e-03f, -9.36249644e-03f, 1.17937149e-02f, 2.50536692e-03f, -1.64707139e-01f, 3.50114703e-02f,
  -1.16378084e-01f, 2.56045964e-02f, -1.86302606e-02f, -1.46079352e-02f, -9.97389778e-02f, -8.63027945e-02f, -7.05250632e-03f, -6.78640679e-02f, 3.51906158e-02f, -1.46605417e-01f,
  -7.77592137e-02f, -1.17394976e-01f, -1.83393583e-02f, -9.94242132e-02f, -6.05638139e-02f, -1.28418475e-01f, 3.19176191e-03f, -1.27170637e-01f, -3.40951644e-02f, -4.09821868e-02f,
  2.58437563e-02f, -1.43176004e-01f, 1.54751912e-01f, -9.66114178e-02f, 1.03444792e-01f, -6.29303157e-02f, 6.47092089e-02f, -7.34185753e-03f, 9.40397307e-02f, -3.57090053e-03f,
  1.41048720e-02f, -1.15995132e-03f, 6.65792227e-02f, -5.17126732e-02f, 9.52651799e-02f, 1.10356711e-01f, -5.49480580e-02f, 1.11737505e-01f, -9.53580588e-02f, 2.42876215e-03f,
  -1.39010340e-01f, 1.63422357e-02f, 1.11280814e-01f, -6.71600997e-02f, 1.14590181e-02f, 1.22603014e-01f, 2.19690561e-01f, 8.29944834e-02f, 4.03124429e-02f, 2.07993135e-01f,
  4.65294838e-01f, 4.79079723e-01f, 2.67391294e-01f, -1.29828349e-01f, -2.85737425e-01f, -2.24526636e-02f, 3.41452956e-01f, 1.15089133e-01f, -2.04849139e-01f, -3.83949168e-02f,
  -1.69768646e-01f, -4.40961272e-01f, -3.64410877e-02f, -6.12133853e-02f, 2.06306711e-01f, 1.93875447e-01f, 1.17843971e-01f, 2.42671534e-01f, 8.18843171e-02f, -1.71711311e-01f,
  -1.74186960e-01f, 1.61599088e-02f, 2.69960374e-01f, 1.18794851e-01f, 5.86722232e-02f, -1.46665424e-01f, 1.38832211e-01f, 7.04490021e-02f, 5.54402955e-02f, 2.05174554e-02f,
  3.09113692e-02f, 3.40439171e-01f, -2.79960275e-01f, -1.73258722e-01f, -2.71020010e-02f, 1.70579329e-02f, -1.27541553e-02f, 6.90159574e-02f, -8.07859190e-03f, 1.36313066e-02f,
  6.30403962e-03f, -4.28999076e-03f, 4.55462523e-02f, 7.94673041e-02f, 1.02391958e-01f, -4.31466550e-02f, 1.68143719e-01f, 2.51647800e-01f, 1.36231408e-01f, 3.88439074e-02f,
  -2.31970266e-01f, -1.90051019e-01f, 7.73776695e-02f, 5.04665077e-04f, 1.94797933e-01f, -1.97534725e-01f, 1.22030517e-02f, 5.88895567e-02f, 2.31030241e-01f, 1.49393408e-02f,
  -2.64509976e-01f, -8.77246335e-02f, 1.76910833e-01f, -4.03952971e-02f, -1.64702088e-01f, -5.07884249e-02f, -1.10956885e-01f, -4.61129732e-02f, -1.69578772e-02f, 2.93165874e-02f,
  -9.47426856e-02f, -6.41971976e-02f, -1.28113970e-01f, 1.20244306e-02f, -9.39289927e-02f, 7.52521530e-02f, 9.11226347e-02f, 5.16952462e-02f, -6.74731005e-03f, 1.80341657e-02f,
  -2.06831712e-02f, 4.38282602e-02f, -4.91946973e-02f, 1.29047990e-01f, 1.57781243e-02f, -6.66499585e-02f, -1.50639459e-01f, 8.51830561e-03f, 2.19869632e-02f, -4.92356978e-02f,
  -2.69854814e-03f, -7.40114674e-02f, -8.52399692e-02f, 1.11139022e-01f, 1.61452934e-01f, -3.44621055e-02f, -3.92670520e-02f, -1.18123204e-01f, -5.71080744e-02f, -5.96883409e-02f,
  5.14234118e-02f, -6.80253329e-03f, 1.17781118e-01f, 1.28119662e-01f, -2.09847912e-01f, -5.38824424e-02f, -8.54985788e-02f, -2.12694090e-02f, -3.61839421e-02f, -4.68503423e-02f,
  -8.11641067e-02f, -1.24160081e-01f, -2.11189896e-01f, -1.45052671e-01f, -2.37901419e-01f, -4.56617415e-01f, -9.64740068e-02f, -7.75802508e-02f, -1.89026643e-03f, -1.14348186e-02f,
  -7.33606368e-02f, 4.17065889e-01f, 3.12613606e-01f, -2.81183094e-01f, 2.89018065e-01f, 3.25587660e-01f, 5.02480030e-01f, 1.57363027e-01f, -1.18264526e-01f, 1.31358638e-01f,
  2.39952475e-01f, -2.80359894e-01f, -2.42995158e-01f, -1.81559056e-01f, 5.92026040e-02f, 1.99705973e-01f, 1.18316421e-02f, -2.42476597e-01f, -2.08645865e-01f, 1.46919861e-02f,
  -1.44787788e-01f, -1.23711072e-01f, -2.07010403e-01f, -1.69143096e-01f, -1.28456801e-01f, -2.19832405e-01f, -3.99577394e-02f, 9.44797471e-02f, 2.52800524e-01f, -2.69625574e-01f,
  2.01132879e-01f, 3.32504451e-01f, -2.71730155e-01f, -5.19858114e-02f, 1.26192987e-01f, -1.33665770e-01f, -1.90678462e-02f, 2.80649378e-03f, -2.01160628e-02f, 7.17644244e-02f,
  5.87695651e-02f, 1.05582215e-02f, 1.07874379e-01f, -2.38430616e-03f, 2.02772796e-01f, 8.88231546e-02f, 8.62727910e-02f, 5.65500967e-02f, 4.50213663e-02f, 2.73059644e-02f,
  -3.45970155e-03f, 2.94357181e-01f, 3.65412474e-01f, 1.52761683e-01f, 3.08237467e-02f, -5.79464920e-02f, 1.99350923e-01f, 3.27203721e-02f, 9.77497846e-02f, -1.37546390e-01f,
  -1.15549840e-01f, -5.39254546e-02f, 7.69073218e-02f, -6.00429140e-02f, -7.89751485e-02f, 4.08501104e-02f, 2.58895699e-02f, 1.90735869e-02f, -6.55805320e-02f, -4.12365235e-02f,
  1.05406731e-01f, 1.47957299e-02f, 2.76241116e-02f, -3.02433241e-02f, -1.14699483e-01f, 7.00665340e-02f, 5.12831397e-02f, 5.47653623e-02f, 8.11698847e-03f, 2.14293506e-02f,
  3.75075191e-02f, 1.86564215e-02f, 5.52429818e-02f, 5.25655001e-02f, 1.48351967e-01f, -2.72051636e-02f, -4.10088375e-02f, 6.14148937e-02f, 4.01130691e-03f, 5.24440221e-03f,
  -1.33528840e-02f, 3.26050818e-01f, -2.70724714e-01f, -8.72332156e-02f, -3.16227563e-02f, -1.97033118e-02f, -3.90845388e-02f, -8.52969592e-04f, 1.45941377e-01f, 1.08553413e-02f,
  1.52466416e-01f, -8.07627141e-02f, 2.61065792e-02f, 3.23619545e-02f, -1.47619948e-01f, -2.78110374e-02f, -1.81492418e-02f, -9.06334743e-02f, 5.56362346e-02f, 1.21427618e-01f,
  -4.90499055e-03f, -8.74989778e-02f, -1.53125957e-01f, -1.62821189e-01f, -2.49731734e-01f, -2.00006649e-01f, -4.47648577e-02f, -1.23815708e-01f, -2.86795408e-03f, -2.11601794e-01f,
  1.53121069e-01f, -7.96840116e-02f, -2.47560173e-01f, 7.56946504e-02f, 1.97993070e-01f, -2.10169002e-01f, -4.98928070e-01f, -2.21822798e-01f, 2.42334813e-01f, -2.41605386e-01f,
  1.23272531e-01f, 1.73450649e-01f, -1.06557988e-01f, -2.02527836e-01f, -6.24105513e-01f, -6.47009432e-01f, -5.52806258e-01f, -4.04540926e-01f, -2.77420878e-01f, 6.50888532e-02f,
  1.81438461e-01f, 6.28780648e-02f, -9.67498645e-02f, 1.63820665e-02f, 3.78475249e-01f, 2.41279259e-01f, 6.57592192e-02f, 1.42256007e-01f, -8.75960514e-02f, 1.29320055e-01f,
  -4.88184392e-02f, 1.56273291e-01f, 3.18031237e-02f, -2.86402218e-02f, 1.33187205e-01f, 2.52549518e-02f, 6.07159510e-02f, -1.74467228e-02f, -2.61111557e-03f, -1.45675186e-02f,
  2.69608438e-01f, 2.02230010e-02f, 2.81052619e-01f, 1.55365402e-02f, 4.28354740e-02f, -3.49549353e-02f, -6.22012541e-02f, -2.44183153e-01f, -2.59692706e-02f, 1.23001032e-01f,
  -1.19779734e-02f, 7.76932854e-03f, -1.42441913e-01f, -2.12806270e-01f, -3.62886824e-02f, -1.41611658e-02f, 1.85122088e-01f, 1.80936754e-01f, -1.04222432e-01f, 5.38946390e-02f,
  1.36252651e-02f, 1.44553095e-01f, 5.70244826e-02f, -5.21960147e-02f, -1.32254371e-02f, 6.27951697e-02f, -5.24444021e-02f, -9.97431427e-02f, 7.53376409e-02f, 4.84625772e-02f,
  -5.50423786e-02f, 1.87670067e-02f, 4.02558111e-02f, 3.87097001e-02f, -3.55341248e-02f, 5.17987013e-02f, 2.22373493e-02f, -8.22718516e-02f, -2.87544006e-03f, -3.00919805e-02f,
  -2.61854213e-02f, 1.49101883e-01f, 1.46428421e-01f, 1.02587603e-02f, -1.52158692e-01f, -1.35445803e-01f, 6.29958734e-02f, 4.46817987e-02f, 6.75141364e-02f, 7.87805915e-02f,
  7.97674134e-02f, -2.26479113e-01f, 1.27168428e-02f, -1.73070073e-01f, 2.71660630e-02f, 6.39729649e-02f, 1.28004238e-01f, -7.69981965e-02f, 8.23992714e-02f, -1.80280991e-02f,
  6.06082939e-02f, -5.91513813e-02f, 8.81693587e-02f, -7.19724223e-02f, -6.52093813e-02f, -4.28679250e-02f, -1.87632680e-01f, -2.39718258e-02f, -8.77127200e-02f, 2.41484210e-01f,
  -1.13861196e-01f, -2.48713017e-01f, -2.86686808e-01f, -2.88555443e-01f, 8.67638215e-02f, -8.87456089e-02f, -8.64550192e-03f, 8.65600333e-02f, -1.76074445e-01f, -2.39907101e-01f,
  1.76425114e-01f, -2.97849119e-01f, -3.54663953e-02f, -8.77155811e-02f, 6.83906535e-03f, -1.42562956e-01f, -5.73545039e-01f, -2.92722702e-01f, -6.73838332e-02f, -4.61859375e-01f,
  -1.79973692e-01f, 2.85134017e-01f, 3.68267968e-02f, 1.42443016e-01f, -1.08516902e-01f, -4.86569822e-01f, -1.52368039e-01f, 2.77001917e-01f, 3.80688697e-01f, 1.19902501e-02f,
  -5.34895994e-02f, 1.24666236e-01f, 2.63118327e-01f, 6.35197610e-02f, -1.24380723e-01f, 2.17633862e-02f, -2.40205303e-01f, 6.63132593e-02f, -1.16068691e-01f, -1.46685079e-01f,
  -2.93580517e-02f, -2.21253291e-01f, -7.15874285e-02f, 1.45502970e-01f, 1.17519330e-02f, -2.25926135e-02f, -4.15166952e-02f, 2.02011503e-02f, 9.96698975e-04f, -4.68694791e-02f,
  1.03974305e-01f, 6.64631575e-02f, 8.15484673e-02f, -1.66853017e-03f, 3.12141292e-02f, 1.00238465e-01f, 5.49557284e-02f, 7.11383000e-02f, -1.82146505e-02f, -1.73898727e-01f,
  2.15013251e-02f, 4.51100618e-02f, -2.26454413e-03f, -1.15059137e-01f, -8.16646293e-02f, 2.06252798e-01f, -1.14642631e-03f, 1.89346343e-01f, 8.75455979e-03f, -2.72125632e-01f,
  -2.91409530e-02f, 7.58410841e-02f, -3.25247422e-02f, 7.58873373e-02f, -9.03071538e-02f, -2.03268901e-02f, -2.82831229e-02f, -2.99736280e-02f, -2.80866250e-02f, 4.09361161e-02f,
  1.92734674e-02f, -1.51443789e-02f, -3.05377021e-02f, -1.20467804e-02f, 7.49245938e-03f, 8.14579427e-02f, 7.66702965e-02f, -1.18941382e-01f, 5.27280532e-02f, 7.28320777e-02f,
  1.33333594e-01f, 7.80933872e-02f, 8.39794651e-02f, 1.75423026e-02f, -6.19272888e-02f, 3.40542383e-03f, 1.16793528e-01f, -5.54433502e-02f, -1.76439378e-02f, 3.70598771e-02f,
  -8.62109214e-02f, 1.78794906e-01f, -2.40284041e-01f, 1.75097652e-04f, 1.66176185e-02f, -2.70292573e-02f, -6.00850508e-02f, 7.78635917e-03f, 1.63727164e-01f, -7.03993440e-02f,
  -2.63601225e-02f, -1.23053111e-01f, -1.31354630e-01f, 6.06021844e-02f, -1.44746110e-01f, 5.15034702e-03f, 1.20159481e-02f, 5.44990115e-02f, 1.03423469e-01f, 1.16954118e-01f,
  1.16560580e-02f, -1.65973157e-01f, -1.19789578e-01f, -5.61023951e-02f, -5.71200624e-02f, 9.48498324e-02f, 1.24261044e-02f, -6.96717277e-02f, -1.35775646e-02f, -4.44492728e-01f,
  3.66299421e-01f, -7.05841333e-02f, 3.65099400e-01f, 3.08242743e-03f, -3.80263507e-01f, -4.55228031e-01f, -4.02101129e-01f, -4.00335621e-03f, 7.19057582e-03f, -1.16438426e-01f,
  -1.64145723e-01f, 6.67887321e-03f, 5.94530441e-02f, 1.27200827e-01f, 2.64140040e-01f, 3.54566909e-02f, 1.22086227e-01f, 5.04365861e-01f, 3.43664050e-01f, -9.49086472e-02f,
  -2.96081752e-01f, 9.56654176e-02f, 3.83193463e-01f, 2.59722114e-01f, -6.83522820e-02f, -1.07654542e-01f, 6.81127533e-02f, -2.46394034e-02f, -1.64823085e-01f, 2.09072232e-01f,
  2.65798241e-01f, 1.41987234e-01f, -2.02071100e-01f, -9.21090245e-02f, -1.01385815e-02f, -2.93503087e-02f, -3.23990849e-03f, 2.34431997e-01f, 2.56136376e-02f, -4.31792391e-03f,
  -1.16563886e-02f, 6.39774799e-02f, -6.86444044e-02f, 3.26371044e-02f, 3.48899588e-02f, -1.11709930e-01f, 2.38555655e-01f, 3.02841604e-01f, 2.59361446e-01f, 4.75448221e-02f,
  -2.69610286e-01f, -2.16097131e-01f, 6.28971830e-02f, -1.71402603e-01f, 1.19814314e-01f, 3.00712083e-02f, 3.79926115e-02f, -3.39738578e-02f, 3.67798954e-02f, 1.41645536e-01f,
  6.24198467e-02f, 4.63783816e-02f, 4.60873060e-02f, 1.09872840e-01f, -3.66127095e-03f, -2.50390228e-02f, 1.33538783e-01f, 3.33195962e-02f, -1.91647187e-02f, 7.98676461e-02f,
  1.19190905e-02f, 7.23014995e-02f, 2.49246061e-01f, -3.69355865e-02f, -9.21550915e-02f, -5.98304197e-02f, -2.03997985e-01f, 6.76771477e-02f, -4.59308475e-02f, -7.59836137e-02f,
  8.31416398e-02f, -1.77098755e-02f, 5.41057764e-03f, 1.80474579e-01f, -5.38723879e-02f, 8.74793753e-02f, -1.23704419e-01f, -7.17667043e-02f, -2.12232955e-02f, 1.06987366e-02f,
  -2.39278942e-01f, -3.86924595e-02f, -8.23677555e-02f, 1.85123775e-02f, -4.75862399e-02f, -1.41698316e-01f, -1.59875229e-01f, -1.19985893e-01f, -1.60374925e-01f, -2.41966126e-03f,
  -1.28761441e-01f, 1.23326480e-01f, 2.53862254e-02f, -2.25314051e-02f, -9.71605182e-02f, -1.53694198e-01f, -1.73812494e-01f, -6.90432563e-02f, -5.71598895e-02f, 3.61850932e-02f,
  -1.22311018e-01f, -2.81640410e-01f, -1.30383193e-01f, -2.56690919e-01f, -1.73201472e-01f, -1.95872709e-01f, -1.07542820e-01f, -2.28049591e-01f, -1.80874735e-01f, -2.92371213e-01f,
  -4.45300430e-01f, -2.77593374e-01f, 2.68583119e-01f, 1.76554695e-02f, 2.83030361e-01f, 3.24699700e-01f, 3.41335326e-01f, 1.09676197e-01f, -4.67530601e-02f, -1.10056207e-01f,
  -1.32921249e-01f, -2.19472170e-01f, -3.15102309e-01f, -2.01578125e-01f, 1.51557056e-02f, 2.21400410e-01f, 2.40060091e-01f, 1.25978768e-01f, 6.61267415e-02f, 9.51110572e-02f,
  -3.99995446e-02f, 7.43280202e-02f, -1.12391233e-01f, 8.79616663e-03f, 2.54638344e-02f, -9.11960304e-02f, 2.78027710e-02f, 1.46059543e-01f, 3.55016440e-02f, -2.61368603e-02f,
  3.92796338e-01f, -8.32138136e-02f, -2.63727196e-02f, -2.53232479e-01f, -6.76918328e-02f, -2.61946023e-01f, 3.40138525e-02f, -2.61637960e-02f, -1.43490881e-01f, 1.16825677e-01f,
  -3.06439362e-02f, -8.00010264e-02f, -4.50606681e-02f, -1.04480855e-01f, 8.70305449e-02f, -1.80716254e-02f, -1.60252094e-01f, -6.98193982e-02f, 1.49741126e-02f, -2.74227057e-02f,
  -1.47738501e-01f, 9.60465446e-02f, 1.72885045e-01f, 2.78549120e-02f, -8.49317759e-03f, -8.06612670e-02f, -6.95698634e-02f, -4.78088222e-02f, -1.31021151e-02f, -6.59737438e-02f,
  -5.65170310e-04f, -2.47095600e-02f, -4.83968928e-02f, 3.70820202e-02f, 4.76895310e-02f, 2.20660716e-02f, 4.51290645e-02f, 1.10514775e-01f, 1.00294173e-01f, 1.58377308e-02f,
  9.63873118e-02f, 6.74568117e-02f, 1.02372788e-01f, 1.48282452e-02f, -1.92640424e-01f, -1.09084770e-01f, 8.68921950e-02f, -1.19549870e-01f, -4.13870104e-02f, -3.49208936e-02f,
  -4.22749631e-02f, 1.35487765e-01f, -6.08594678e-02f, -3.62746306e-02f, 2.63841692e-02f, 3.08166370e-02f, -3.29767354e-02f, -8.50461572e-02f, 6.09713886e-03f, 3.65477651e-02f,
  1.99362934e-01f, 6.56861365e-02f, 3.87956984e-02f, -2.88802497e-02f, 1.31326586e-01f, -1.86748371e-01f, 6.52555842e-03f, 4.85706702e-03f, 1.41571820e-01f, 1.60314590e-01f,
  -2.12795753e-02f, 1.11995088e-02f, -3.51925492e-02f, 1.11400664e-01f, 7.84610882e-02f, -2.52467319e-02f, -1.80690438e-01f, 6.33040071e-02f, 5.47303408e-02f, -2.07614470e-02f,
  -1.61575861e-02f, 1.46429390e-01f, 2.09107324e-01f, 2.18201414e-01f, 9.93503481e-02f, 1.95984349e-01f, 6.76677451e-02f, 9.88174230e-02f, 1.72680050e-01f, 7.17682689e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.17084035e-01f, 4.46241558e-01f, 3.16380709e-01f, 1.95168138e-01f, 3.16781998e-01f, 5.88653982e-01f, 1.91685066e-01f, 1.15546703e-01f, 1.74855292e-01f, 4.20851618e-01f,
  -6.19929545e-02f, 3.11874479e-01f, -2.63205543e-02f, -4.10303026e-02f, 3.69017333e-01f, 3.15501004e-01f, 3.13619107e-01f, 2.31744330e-02f, 2.55022645e-01f, 4.45465267e-01f,
  3.49988014e-01f, 1.90631300e-01f, 2.97237560e-02f, 3.04756731e-01f, 3.05990100e-01f, 2.81587332e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.00672752e-01f, 1.37816265e-01f, -2.63020724e-01f, -1.14082314e-01f, 3.73267978e-02f, 5.38655892e-02f, -5.47312796e-02f, -1.26725137e-01f, -3.91313024e-02f, -5.36029004e-02f,
  1.47317331e-02f, 8.63440931e-02f, -8.25317949e-03f, 1.04273260e-02f, 1.41240321e-02f, 7.36147985e-02f, -1.47305712e-01f, 1.92200970e-02f, 3.42948996e-02f, -5.11916950e-02f,
  -8.92829672e-02f, -5.62348925e-02f, -9.94595662e-02f, -2.84690149e-02f, -1.41651869e-01f, 2.39026994e-02f, -1.67813972e-01f, 1.45765081e-01f, 2.62573622e-02f, 7.28980824e-02f,
  7.30381757e-02f, 1.29118815e-01f, 2.00173501e-02f, -7.41298497e-02f, 3.04744132e-02f, -3.45947221e-02f, 1.06848143e-01f, -1.60087571e-01f, -1.26473168e-02f, -3.08010727e-01f,
  2.18343604e-02f, 3.46544050e-02f, 1.22629546e-01f, -7.76173249e-02f, 5.19850175e-04f, 2.21481808e-02f, -1.01063810e-01f, -1.04537182e-01f, 1.21361420e-01f, 1.12055667e-01f,
  -1.28279984e-01f, -1.69105813e-01f, 2.31599174e-02f, -1.15731820e-01f, -2.32201770e-01f, -2.35395506e-02f, -1.45165130e-01f, 3.66783828e-01f, -3.96639973e-01f, -9.85452235e-02f,
  2.87688643e-01f, 1.10838667e-01f, -1.87767267e-01f, 2.89970189e-01f, -7.18386844e-02f, 4.95644584e-02f, -1.50696069e-01f, 2.90067103e-02f, -2.88448054e-02f, 1.49429617e-02f,
  -1.01991072e-01f, -1.15155876e-01f, -8.63366574e-03f, -8.41545835e-02f, 5.00306450e-02f, -2.10096911e-01f, 1.20057583e-01f, -1.19134806e-01f, -1.70861240e-02f, 1.58981644e-02f,
  -1.02972470e-01f, -1.94841713e-01f, -9.05881077e-02f, -1.72189102e-04f, -2.48975933e-01f, -1.31777599e-02f, 3.19961645e-02f, -4.40609120e-02f, 8.36567581e-02f, 1.41448900e-01f,
  -2.50127334e-02f, 3.08310818e-02f, 3.19018662e-01f, 5.75764179e-02f, -1.23355100e-02f, -2.63922065e-01f, 5.11159413e-02f, 3.90521362e-02f, 7.85682499e-02f, 9.01839137e-02f,
  6.84396923e-02f, 1.37754694e-01f, -1.26408696e-01f, 1.91116855e-01f, -3.04309309e-01f, -1.54976631e-02f, 2.79528610e-02f, -1.00200549e-01f, 3.01048905e-01f, 2.83144623e-01f,
  1.61037758e-01f, -8.76510516e-02f, 2.72996426e-02f, 2.58593023e-01f, -1.49234712e-01f, 5.61050288e-02f, 2.53884159e-02f, -1.01009212e-01f, 3.37365232e-02f, 4.66372743e-02f,
  -3.85491014e-01f, -2.24492490e-01f, 1.14156410e-01f, 2.84605950e-01f, -4.16843109e-02f, 7.64247105e-02f, -1.67799339e-01f, 1.71502471e-01f, -1.08541198e-01f, 4.35086265e-02f,
  1.73367217e-01f, 7.23399445e-02f, 1.25839323e-01f, 2.74757408e-02f, 6.18480481e-02f, -5.21300025e-02f, 7.82894194e-02f, 6.17813691e-02f, 2.54837330e-02f, 1.00075245e-01f,
  -4.50867191e-02f, 1.85632259e-01f, 5.28482273e-02f, 1.74724251e-01f, 1.94778182e-02f, 1.10355303e-01f, -1.50913239e-01f, -4.03983779e-02f, 6.36864603e-02f, 3.32641043e-02f,
  2.07070515e-01f, 5.18306121e-02f, 4.62782606e-02f, 2.58680791e-01f, -3.36472429e-02f, 1.07441127e-01f, -1.10250436e-01f, -7.03759268e-02f, 3.99518460e-02f, -8.18915516e-02f,
  -3.09392288e-02f, -1.04141387e-03f, 2.26896862e-03f, -1.10348072e-02f, 1.12216331e-01f, 8.18321332e-02f, -1.95848301e-01f, 6.21931218e-02f, -9.09470171e-02f, -1.48077965e-01f,
  -1.98746324e-01f, 1.70149043e-01f, -4.24080491e-02f, -2.03371421e-01f, 4.32196259e-02f, 2.59534568e-01f, -5.66118024e-02f, 1.06795251e-01f, -1.87849313e-01f, -4.91916612e-02f,
  2.49518603e-01f, -2.48790160e-01f, 1.87026352e-01f, 3.53981252e-03f, -1.33584291e-01f, 2.34846175e-01f, 2.86272675e-01f, 1.66355267e-01f, -2.18297645e-01f, -5.79308867e-02f,
  4.54201028e-02f, 2.15285257e-01f, 6.37503341e-03f, -1.12105250e-01f, 7.67111555e-02f, -7.74573237e-02f, -1.07716769e-01f, -6.55858815e-02f, -1.61932986e-02f, -1.28934324e-01f,
  2.25986429e-02f, -1.84283867e-01f, 2.10454836e-02f, 1.17155217e-01f, -5.52820452e-02f, -9.78076272e-03f, -6.98079169e-02f, 2.98146829e-02f, 5.24648018e-02f, -3.70900482e-02f,
  -1.55947298e-01f, 7.20677227e-02f, 1.60816014e-02f, 3.44061814e-02f, 1.49215817e-01f, 2.36277193e-01f, -1.98149174e-01f, -8.59795958e-02f, -6.78270906e-02f, -4.66068536e-02f,
  3.32407840e-02f, -2.11509317e-01f, 6.49615843e-03f, -7.01774210e-02f, -2.82030195e-01f, 7.95987025e-02f, -7.31461719e-02f, -1.14026621e-01f, 3.25523436e-01f, 1.62896469e-01f,
  1.00891598e-01f, -1.44593000e-01f, -1.00646995e-01f, -2.34027371e-01f, 4.36137728e-02f, 3.20680767e-01f, -6.86755311e-03f, -1.63805962e-01f, -1.58656299e-01f, 1.12331808e-01f,
  -4.00234461e-02f, 1.40185416e-01f, -1.47389352e-01f, -8.49818513e-02f, 2.31792659e-01f, -5.17942980e-02f, -9.42419618e-02f, -7.69800767e-02f, -8.16576853e-02f, -4.08892602e-01f,
  2.83717513e-01f, 9.73566994e-02f, -2.71048546e-01f, -2.95168042e-01f, 4.34256494e-02f, -8.96776691e-02f, -1.23508178e-01f, -2.24288106e-02f, 1.72069982e-01f, -1.35442153e-01f,
  1.09182388e-01f, -6.86556250e-02f, -1.83179025e-02f, 9.86408815e-03f, 7.24867033e-03f, -9.71241146e-02f, 1.28419459e-01f, 1.16201742e-02f, 2.93234512e-02f, 8.24283063e-02f,
  -1.41992643e-01f, 1.49451628e-01f, -1.23116851e-01f, 1.82873309e-02f, 7.20892176e-02f, -6.64583291e-04f, -1.31912949e-02f, 1.16047807e-01f, 1.31434068e-01f, 1.58497319e-01f,
  -1.09048381e-01f, 1.97711319e-01f, 6.76927064e-03f, -6.89032376e-02f, 6.28359094e-02f, -1.17655382e-01f, -1.31249532e-01f, -1.39773771e-01f, 3.67253181e-03f, 5.49331680e-02f,
  -2.78654657e-02f, 7.23031461e-02f, 2.96372265e-01f, 4.29830775e-02f, -2.83997059e-01f, 1.62840083e-01f, 3.13731432e-02f, -8.78778845e-02f, -1.90355584e-01f, 1.83612898e-01f,
  4.21928838e-02f, 1.34100050e-01f, 1.25555113e-01f, 1.75987914e-01f, -2.77606905e-01f, 2.08084986e-01f, -3.31771038e-02f, 1.54615298e-01f, 1.45529374e-01f, -8.80714878e-02f,
  -1.09919913e-01f, 3.52654122e-02f, -2.01945081e-01f, -6.36684373e-02f, 2.58674681e-01f, -1.66279912e-01f, -1.87424511e-01f, 5.77436341e-03f, 1.86173618e-01f, 1.46507517e-01f,
  7.44603947e-02f, 3.31656039e-02f, 7.85068944e-02f, 4.43208143e-02f, -1.01169668e-01f, 1.00221038e-02f, 1.01248525e-01f, 1.24013275e-01f, 3.11442055e-02f, 7.55831748e-02f,
  6.84544444e-02f, 9.94580891e-03f, -1.23404991e-02f, 9.23533887e-02f, -1.12306751e-01f, 6.98457137e-02f, 7.38461614e-02f, -2.07865443e-02f, 3.87057699e-02f, -1.64932236e-01f,
  1.33047640e-01f, -2.15661272e-01f, -1.35207042e-01f, -1.72568575e-01f, 8.04204121e-02f, -2.67159432e-01f, -1.56534404e-01f, -2.14421079e-02f, -1.62453622e-01f, 1.15672484e-01f,
  1.95621382e-02f, 1.48093805e-01f, 1.27190024e-01f, 2.78958194e-02f, 7.87900165e-02f, -2.16571987e-01f, -1.09704204e-01f, -1.78377721e-02f, -2.29634166e-01f, 4.17235009e-02f,
  -7.63287246e-02f, -1.89871758e-01f, 2.56575504e-03f, 8.12460855e-02f, -1.39107630e-01f, 6.02760129e-02f, 1.00534171e-01f, 1.52036445e-02f, 7.92833120e-02f, -1.58415079e-01f,
  -2.88496971e-01f, 1.28062010e-01f, 3.01069707e-01f, -1.10850550e-01f, -1.04361713e-01f, 1.90459907e-01f, 6.32951409e-02f, 9.64302346e-02f, 4.10356037e-02f, 5.59094213e-02f,
  -3.44818868e-02f, 8.93055052e-02f, 3.42029840e-01f, 2.04372361e-01f, -1.48958221e-01f, -2.76812911e-02f, -8.78801644e-02f, -1.95552539e-02f, 1.25545219e-01f, 7.99345598e-02f,
  1.04774011e-03f, -7.79414410e-03f, -2.72682197e-02f, -7.57232830e-02f, -1.69480760e-02f, -1.00981453e-02f, -1.25188112e-01f, -6.70873187e-03f, -2.50380789e-03f, -3.01890559e-02f,
  1.32459283e-01f, -5.55338897e-02f, 6.81000128e-02f, 5.15766740e-02f, -4.21790518e-02f, -1.56021966e-02f, 1.57012567e-01f, 9.76452883e-03f, 4.82725501e-02f, 2.80163556e-01f,
  7.86153004e-02f, -3.43502909e-02f, 2.13547692e-01f, -3.51606421e-02f, -1.15412429e-01f, -1.86678439e-01f, 9.92739052e-02f, 1.14893481e-01f, 2.07812726e-01f, 2.56530464e-01f,
  1.24377251e-01f, 1.61266923e-01f, -2.65033484e-01f, 2.42262453e-01f, 2.41708845e-01f, 1.89912245e-01f, 6.35518730e-02f, -1.74244270e-01f, -8.27986524e-02f, 2.37560540e-01f,
  1.47232369e-01f, -1.52576745e-01f, 1.49204850e-01f, -8.08919072e-02f, 9.39574018e-02f, -1.03902295e-01f, -2.14778647e-01f, -5.13378233e-02f, -6.41780049e-02f, -2.34245155e-02f,
  8.74515399e-02f, 2.01888114e-01f, -2.37422705e-01f, 4.18261886e-01f, 1.35830909e-01f, 2.80583531e-01f, -1.29357994e-01f, 2.89637625e-01f, 2.12308075e-02f, -1.79995820e-02f,
  -2.01303922e-02f, -7.55553693e-02f, -1.26504377e-01f, -4.07507755e-02f, -1.61988914e-01f, -3.55343968e-02f, 1.55541319e-02f, -5.88998161e-02f, 8.58879536e-02f, -6.75432160e-02f,
  -4.39688452e-02f, -1.11189120e-01f, -1.84322614e-02f, -6.92072464e-03f, -3.97591107e-02f, 3.31638269e-02f, -1.30073592e-01f, -3.53817120e-02f, 1.37551025e-01f, 1.38840452e-01f,
  -8.85385647e-02f, 2.91831400e-02f, -1.71408787e-01f, -7.30527856e-04f, -1.92005172e-01f, -1.19446985e-01f, 5.72003126e-02f, -4.10434062e-04f, 5.58321029e-02f, -1.11216210e-01f,
  9.12119597e-02f, 1.22475497e-01f, 1.15588546e-01f, 6.41297251e-02f, 1.75216019e-01f, 4.06588539e-02f, -2.54602760e-01f, 8.03902969e-02f, -6.94595426e-02f, -6.92762360e-02f,
  -1.13094024e-01f, 2.36100689e-01f, 1.99637815e-01f, 1.04515679e-01f, -7.18838477e-04f, 7.94357732e-02f, -3.72211114e-02f, -4.28667245e-03f, -2.52352417e-01f, 1.53175265e-01f,
  9.81786847e-02f, 5.57284383e-03f, -4.12711531e-01f, -7.94620216e-02f, -1.18720502e-01f, -1.51544929e-01f, 1.65099919e-01f, -7.98802003e-02f, -9.39613953e-02f, 1.57689869e-01f,
  1.08088352e-01f, 5.15158437e-02f, -8.40935335e-02f, 5.50615415e-02f, 2.72274893e-02f, 5.35503477e-02f, 6.93963394e-02f, 3.63955386e-02f, 1.69580448e-02f, 7.22529665e-02f,
  1.16754118e-02f, 1.51497066e-01f, -3.12014017e-02f, -2.88946908e-02f, 3.41941267e-02f, -1.17356002e-01f, -5.80825247e-02f, 4.56713848e-02f, -2.43379772e-02f, 1.57991424e-01f,
  1.35392740e-01f, -3.16587044e-03f, -6.25151992e-02f, -4.43871766e-02f, -1.53063973e-02f, -3.79742682e-02f, 1.22645475e-01f, 1.19252346e-01f, 1.99523009e-02f, 9.68756527e-02f,
  2.11867005e-01f, 1.49840534e-01f, -4.90038842e-02f, 3.14549915e-02f, 2.27641612e-01f, 2.62209028e-02f, 3.82662341e-02f, 1.29217550e-01f, -3.14287871e-01f, 2.45983712e-02f,
  4.28289212e-02f, 3.32599074e-01f, -7.81784859e-03f, 1.79354593e-01f, 1.08449742e-01f, -4.26236272e-01f, -1.56857334e-02f, 1.02088004e-01f, 1.15550786e-01f, -1.98425785e-01f,
  -5.16019203e-02f, -3.64178896e-01f, 2.80376136e-01f, 9.22866240e-02f, -1.81927398e-01f, 3.34654488e-02f, 1.38191327e-01f, 1.11734048e-01f, 7.60662034e-02f, -4.48640734e-02f,
  -1.31872237e-01f, 9.50428471e-02f, -1.15015864e-01f, 3.85819614e-01f, 2.58343309e-01f, 3.81109491e-02f, 4.09835316e-02f, 3.66514139e-02f, 8.33043605e-02f, 4.91019897e-02f,
  2.58574802e-02f, 1.12363666e-01f, -1.09833647e-02f, 8.32849070e-02f, 6.92361072e-02f, -2.94783805e-03f, -1.60772027e-03f, -6.83897138e-02f, -4.84873690e-02f, -1.65291250e-01f,
  -5.92858717e-02f, -1.71708018e-02f, 9.56028178e-02f, -8.93122982e-03f, 4.44862470e-02f, 1.33926541e-01f, 3.05334032e-02f, -3.56461592e-02f, 1.55232754e-02f, -1.89882234e-01f,
  2.98603386e-01f, 1.33107841e-01f, 5.96353896e-02f, 1.12462692e-01f, 4.19582389e-02f, 1.42588049e-01f, -1.10109579e-02f, -6.26012310e-02f, 5.61729670e-02f, -1.15041241e-01f,
  -2.95941103e-02f, -5.92296310e-02f, -1.97702453e-01f, 5.00710756e-02f, 7.42675439e-02f, 1.44886672e-01f, 8.73493254e-02f, 1.25260621e-01f, 1.59771722e-02f, -4.13187295e-01f,
  1.98358685e-01f, 1.27977937e-01f, 1.05294451e-01f, -2.22408384e-01f, 3.51554267e-02f, -2.00403795e-01f, 1.36660099e-01f, -1.02225453e-01f, -1.06620006e-01f, -3.04751080e-02f,
  3.35637093e-01f, -1.07991345e-01f, 1.88840926e-01f, 1.08585656e-01f, -4.29357648e-01f, -1.97351769e-01f, 6.06205910e-02f, 9.34963971e-02f, -1.96550488e-01f, -8.61590877e-02f,
  -9.31423903e-02f, 1.37210473e-01f, 1.95153095e-02f, 9.07133669e-02f, 4.79714833e-02f, -7.88278803e-02f, -9.78051871e-02f, -1.46052063e-01f, -9.95879155e-03f, 1.44123808e-01f,
  -7.24743977e-02f, -4.76270802e-02f, -1.06600672e-02f, -6.37789220e-02f, 1.35930106e-01f, 7.45314434e-02f, -7.57366642e-02f, 8.81166011e-02f, 1.20092072e-01f, 1.48049548e-01f,
  -1.92988351e-01f, 5.80153391e-02f, -1.54672107e-02f, -4.62233014e-02f, 3.14026698e-02f, 1.80560306e-01f, 2.64982320e-02f, 4.07326296e-02f, 2.45069135e-02f, -5.08540589e-03f,
  -6.05761856e-02f, -8.19117501e-02f, 3.24353464e-02f, 2.80233137e-02f, -1.92338657e-02f, -4.00845371e-02f, -1.15154423e-01f, -9.13268235e-03f, 9.78660360e-02f, 4.70288172e-02f,
  1.90161526e-01f, 1.22325987e-01f, -6.18168712e-02f, -2.47422591e-01f, -1.23910218e-01f, -1.58198271e-02f, -8.44008476e-02f, -1.83831230e-01f, 1.05384840e-02f, -3.25719528e-02f,
  2.40628585e-01f, -2.30592284e-02f, 1.02970533e-01f, -2.81035602e-01f, 4.74548154e-02f, -8.09936896e-02f, -1.75504029e-01f, 4.49027717e-01f, -5.36301255e-01f, -1.52082771e-01f,
  2.53323674e-01f, 2.46634021e-01f, -4.23206091e-02f, 1.05474181e-01f, -1.35887209e-02f, -1.03829607e-01f, 1.78036034e-01f, 7.70244226e-02f, -6.98516294e-02f, -1.63724527e-01f,
  -3.74674685e-02f, -5.28785475e-02f, 5.85386902e-02f, -3.38046402e-02f, 1.90417338e-02f, -1.91802040e-01f, 8.04244876e-02f, -1.60711810e-01f, -6.61387965e-02f, 3.18034515e-02f,
  2.02574551e-01f, -4.04552519e-02f, -9.61319059e-02f, -1.01897217e-01f, 1.00526236e-01f, 1.64367750e-01f, 5.73901087e-03f, 8.05181190e-02f, -4.55473643e-03f, -2.60533929e-01f,
  1.56973332e-01f, -4.05245274e-02f, 1.83850721e-01f, 2.81786267e-02f, -4.81641293e-02f, -1.21209726e-01f, 2.16474980e-01f, 1.66833460e-01f, 1.56233907e-01f, 2.65756994e-01f,
  -5.50760850e-02f, 1.32282495e-01f, -1.54747412e-01f, 2.27051795e-01f, -3.87769658e-04f, 8.61652792e-02f, 3.02232075e-02f, -7.02154264e-02f, 1.36908650e-01f, -6.77156122e-03f,
  5.19153923e-02f, -9.91745852e-04f, 5.72235622e-02f, 1.01548508e-02f, -6.42037243e-02f, -6.25250787e-02f, -2.08223015e-01f, -7.39192450e-03f, -1.01750501e-01f, 9.01371539e-02f,
  8.21003988e-02f, -3.53228301e-01f, 2.52840221e-01f, 2.21664935e-01f, -1.69311449e-01f, 1.63705602e-01f, 1.86447084e-01f, 2.80312598e-02f, 1.69109568e-01f, -6.19163923e-02f,
  -1.91294447e-01f, -1.05041035e-01f, -8.83778185e-02f, 1.15655273e-01f, -1.48372874e-01f, 1.14693172e-01f, -8.88576061e-02f, -2.73189340e-02f, 4.43377096e-04f, -1.00682184e-01f,
  7.45168179e-02f, -1.74480215e-01f, -4.00912613e-02f, -1.50142998e-01f, 8.97264853e-02f, -6.68319389e-02f, 1.78521983e-02f, 4.91663404e-02f, -8.16529617e-02f, 1.15650967e-01f,
  8.27337429e-02f, 2.57553421e-02f, -1.08860001e-01f, -1.07240938e-01f, 1.15410648e-02f, -9.33357999e-02f, 6.26302063e-02f, 7.43432939e-02f, -1.44205064e-01f, 3.62386294e-02f,
  -7.02363104e-02f, 4.60063517e-02f, 7.91605338e-02f, 4.88100126e-02f, -1.39214933e-01f, 1.46695703e-01f, -9.56877321e-02f, -4.62647416e-02f, -1.19676337e-01f, 1.39764100e-01f,
  2.34150082e-01f, -2.43464321e-01f, 2.17521936e-01f, -1.82536282e-02f, 6.89823031e-02f, -6.41641766e-02f, -2.45375969e-02f, 8.73297453e-02f, 2.50309944e-01f, 8.95647481e-02f,
  -2.66664356e-01f, -4.59876209e-02f, 6.07974716e-02f, 6.30994812e-02f, 2.35405028e-01f, -4.76376973e-02f, -3.54987204e-01f, 3.86157408e-02f, 1.90061063e-01f, 4.45509776e-02f,
  -4.54155415e-01f, 5.25702722e-02f, -6.77117184e-02f, -7.39924908e-02f, 1.72896594e-01f, -5.28164580e-02f, 1.86231127e-03f, -8.80977437e-02f, -8.48940834e-02f, -2.77011022e-02f,
  -4.45156582e-02f, 9.54192132e-02f, -6.22882284e-02f, -2.64738649e-02f, -8.97408053e-02f, 3.37190107e-02f, -6.06420748e-02f, 8.84442329e-02f, -2.36005392e-02f, -7.15896860e-02f,
  1.05789952e-01f, -2.14574877e-02f, -6.06762208e-02f, 1.24754027e-01f, 1.51282117e-01f, -4.92827520e-02f, 5.50912879e-02f, -1.97137699e-01f, 1.81987777e-01f, 6.81362450e-02f,
  6.50551766e-02f, -3.44014280e-02f, -7.28486478e-02f, -6.34911507e-02f, -1.10127322e-01f, 2.83452198e-02f, 3.15077690e-04f, 2.78128386e-02f, 5.28175803e-03f, 1.21939287e-01f,
  9.02675092e-02f, 1.94637235e-02f, 3.40543240e-01f, 1.65798068e-01f, 1.72215223e-01f, -2.53023595e-01f, -4.51048389e-02f, -1.62593260e-01f, -4.09586802e-02f, -1.62465617e-01f,
  1.04738019e-01f, -1.41193410e-02f, 3.68036002e-01f, -1.13036390e-02f, -1.90879047e-01f, -1.15071133e-01f, 6.80509359e-02f, -8.42508972e-02f, 4.74731140e-02f, -2.24507645e-01f,
  6.96828514e-02f, -1.04875334e-01f, 6.32049516e-02f, 4.05810736e-02f, 3.84297781e-02f, -2.65422285e-01f, 7.59522840e-02f, -1.04287840e-01f, 6.69192746e-02f, -1.28640197e-02f,
  5.94415925e-02f, -3.44189629e-02f, 1.40999798e-02f, -6.94505405e-03f, 7.80330226e-02f, -3.95424888e-02f, -6.39034733e-02f, 7.72630572e-02f, -1.07142687e-01f, -8.66563618e-02f,
  9.92950704e-03f, -1.27637699e-01f, -6.85471401e-04f, -5.38282953e-02f, -2.80613229e-02f, -8.99717491e-03f, 2.12285578e-01f, -1.13150440e-01f, -1.74904037e-02f, -4.95697074e-02f,
  4.51184735e-02f, -1.28890038e-01f, -2.89431587e-02f, -2.47869462e-01f, -8.12372118e-02f, -2.20803767e-02f, -1.73689015e-02f, 1.41132250e-01f, 1.43566236e-01f, 6.83881389e-03f,
  8.56147259e-02f, 8.99836048e-02f, 1.54117450e-01f, -6.84785992e-02f, -4.51182276e-02f, -6.48257807e-02f, -3.09466064e-01f, -7.28849769e-02f, 2.11978294e-02f, 2.10940227e-01f,
  9.36299413e-02f, 1.39106750e-01f, 1.27722099e-01f, -1.07298963e-01f, -7.03101279e-03f, 1.62009895e-02f, 1.99480042e-01f, 1.61504164e-01f, -1.26892045e-01f, 1.23232841e-01f,
  -2.86863774e-01f, 1.11011602e-01f, 2.56027728e-01f, -1.91786155e-01f, 2.93480568e-02f, 1.34989023e-01f, 1.58566222e-01f, -1.12133473e-01f, -1.44410804e-01f, 1.45097613e-01f,
  -7.08016381e-02f, 4.03303493e-05f, -1.43003330e-01f, 7.21107274e-02f, -1.49393052e-01f, -4.43247845e-03f, -1.49882838e-01f, 1.72343001e-01f, 1.69197306e-01f, -1.40474245e-01f,
  -2.36670882e-01f, 4.51580361e-02f, 1.79249853e-01f, 2.49875337e-02f, -1.41129419e-01f, -5.29105216e-02f, 1.43728489e-02f, 1.28648832e-01f, -1.10802114e-01f, -2.08356574e-01f,
  8.14236179e-02f, -1.07855543e-01f, -7.22171366e-02f, -4.23316918e-02f, -3.79936583e-02f, 3.56698781e-02f, -2.09904224e-01f, 6.36008009e-02f, -2.29375988e-01f, 8.69875588e-03f,
  -3.09012216e-02f, 2.35957071e-01f, -5.56047522e-02f, -1.14247851e-01f, -2.42229961e-02f, -2.12674305e-01f, -5.14663607e-02f, 9.76786576e-03f, -2.89310720e-02f, -3.62082005e-01f,
  -3.25071290e-02f, -1.50335163e-01f, 1.76117152e-01f, 1.59507692e-01f, -7.96421766e-02f, -3.74972671e-02f, 1.11462921e-01f, 5.90456789e-03f, 2.51427740e-01f, 1.48545414e-01f,
  -1.33662850e-01f, 1.82702079e-01f, 9.38786939e-02f, 3.37048993e-02f, -2.35845596e-01f, 1.16598397e-01f, 1.39236048e-01f, 1.92531303e-01f, -1.85530826e-01f, -1.50659159e-01f,
  1.69910844e-02f, -3.81966196e-02f, -7.20530301e-02f, 4.83862385e-02f, -1.68824047e-02f, -2.21806206e-02f, 2.53215246e-02f, -4.82313521e-02f, 7.24404678e-02f, 2.10314486e-02f,
  5.44560328e-02f, 3.11691463e-02f, 1.11560971e-01f, 7.51508027e-02f, 6.03476912e-02f, -3.60029414e-02f, -2.89061777e-02f, 1.39894448e-02f, -7.55807087e-02f, 1.74361393e-01f,
  5.63731492e-02f, 7.07215965e-02f, -2.47394871e-02f, -9.13989991e-02f, -4.83460948e-02f, -1.65713474e-01f, -1.60919935e-01f, -3.15175653e-02f, 7.58709684e-02f, 2.61473149e-01f,
  1.15325645e-01f, 1.99225530e-01f, -4.15030541e-03f, -1.03200927e-01f, 1.05939209e-02f, -2.13483095e-01f, 9.55349877e-02f, 1.19297631e-01f, 1.61788478e-01f, 5.98338544e-02f,
  -9.66425389e-02f, -5.97718060e-02f, -4.64178510e-02f, 2.66692787e-01f, 8.15362930e-02f, -1.08107097e-01f, -2.52772495e-02f, -2.99004942e-01f, -1.29296765e-01f, 1.47144675e-01f,
  -7.42733032e-02f, -9.01257768e-02f, 1.98974997e-01f, -2.23903880e-01f, 7.80692324e-02f, 1.56233117e-01f, 1.21735230e-01f, -1.73266992e-01f, 1.75200611e-01f, 4.56559844e-02f,
  -1.06618972e-02f, -1.69478863e-01f, 6.90787956e-02f, -9.34903696e-02f, -3.45863789e-01f, 2.23741829e-02f, 3.37028921e-01f, 1.13303684e-01f, -1.34319708e-01f, 1.99492320e-01f,
  5.92853315e-02f, -1.29396915e-01f, -1.06574722e-01f, -1.51304938e-02f, -1.08146645e-01f, -5.93944378e-02f, -2.47059464e-01f, -1.29880145e-01f, -1.18949048e-01f, 2.19768356e-03f,
  1.20416895e-01f, -3.52007784e-02f, 9.07175243e-03f, -1.11188434e-01f, -6.12833537e-02f, 6.59584254e-02f, -6.66538402e-02f, 1.68133795e-01f, -4.79847714e-02f, 2.51163602e-01f,
  4.41601919e-03f, -2.62702759e-02f, -1.35838822e-01f, -2.26979956e-01f, -1.66957736e-01f, 1.10533707e-01f, -2.05436483e-01f, -2.41044592e-02f, -1.00791685e-01f, -9.04946625e-02f,
  -1.60963133e-01f, 1.06488466e-01f, -5.64998165e-02f, -1.64301410e-01f, -3.80495749e-02f, 2.18566626e-01f, 1.01585597e-01f, -1.80213183e-01f, 1.82789862e-01f, -2.54243687e-02f,
  -1.23919006e-02f, 1.83884963e-01f, -1.15049288e-01f, -1.04429767e-01f, -2.79766731e-02f, 5.89140914e-02f, -1.91522494e-01f, 1.79196924e-01f, 9.48510244e-02f, 1.79190308e-01f,
  2.88313860e-03f, -2.22416744e-02f, -1.90593094e-01f, 1.85139015e-01f, -3.40999067e-01f, 2.26679910e-02f, 7.47786239e-02f, -3.27409267e-01f, 2.28492662e-01f, -1.48403049e-01f,
  1.17663629e-01f, 2.52474956e-02f, 9.93657932e-02f, -1.10431425e-01f, 1.41004056e-01f, -4.83153015e-02f, 1.57276109e-01f, 1.31393552e-01f, 1.03331178e-01f, 1.22581780e-01f,
  -1.66867614e-01f, -1.47613019e-01f, 1.09817497e-01f, -1.02014132e-02f, -6.09617569e-02f, -1.66160896e-01f, 8.75452310e-02f, -1.35397360e-01f, 1.55848414e-01f, -1.07280612e-01f,
  4.13848236e-02f, -4.86595789e-03f, 2.13861734e-01f, -1.07236773e-01f, -1.16589159e-01f, 7.88392499e-03f, -4.41398472e-02f, -2.61775821e-01f, 1.97689533e-02f, 6.48650108e-03f,
  -5.96843585e-02f, 1.49511099e-01f, -3.65328789e-02f, 1.75564587e-02f, 2.03444809e-02f, -5.76141551e-02f, -1.45895466e-01f, 8.86844620e-02f, -8.56140777e-02f, 1.79641753e-01f,
  5.82852736e-02f, 1.65692251e-02f, 2.75933564e-01f, 2.27919668e-01f, 1.94447103e-03f, -2.16207858e-02f, 2.63608955e-02f, -1.36280030e-01f, 4.53283563e-02f, -1.50606260e-01f,
  1.25564352e-01f, -2.74309844e-01f, 9.41993371e-02f, 1.54561428e-02f, -1.19178094e-01f, 1.79402158e-01f, -3.21033075e-02f, 1.21920191e-01f, 3.27137709e-01f, -1.44398570e-01f,
  -1.58834502e-01f, 2.70007968e-01f, 2.12660208e-01f, 1.57782003e-01f, 1.61619484e-02f, -2.58247554e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.93772125e-02f, 1.66273430e-01f, -1.18732408e-01f, -1.19484933e-02f, 1.22006267e-01f, 1.58490881e-01f, 4.30273600e-02f, -5.07475100e-02f, -1.60394862e-01f, 6.87199757e-02f,
  1.24076664e-01f, 1.00511797e-02f, 1.93425670e-01f, 1.16047621e-01f, 2.09140658e-01f, 2.30537593e-01f, -1.40591878e-02f, 1.36489987e-01f, 2.27688760e-01f, 3.77288997e-01f,
  -4.14849102e-01f, 2.32127681e-01f, 8.45648423e-02f, -1.08650610e-01f, 1.49355590e-01f, 1.10221192e-01f, -4.85567525e-02f, 3.32257330e-01f, 1.04112566e-01f, 1.02591636e-02f,
  -2.21011683e-01f, -1.45024747e-01f, -1.65367216e-01f, -1.00870088e-01f, -1.61275640e-01f, -1.49166241e-01f, 2.60812342e-02f, 2.96701610e-01f, 3.04411888e-01f, 3.06220263e-01f,
  9.49252397e-02f, 3.05213332e-01f, 3.37729931e-01f, -1.00434661e-01f, -1.73694305e-02f, 3.04507688e-02f, -3.48664731e-01f, 6.32748827e-02f, -3.19547504e-02f, 4.89300340e-01f,
  4.25589412e-01f, -6.54922277e-02f, -7.70661160e-02f, -3.76264714e-02f, 3.22581828e-01f, -1.66458964e-01f, -4.63310957e-01f, 4.31024909e-01f, -4.34535056e-01f, 9.74920765e-02f,
  4.60671753e-01f, 3.61365080e-01f, -6.29079640e-02f, -1.17701963e-01f, 1.65182590e-01f, 1.59365147e-01f, -1.12990320e-01f, 2.75221281e-03f, 1.59458786e-01f, 1.08621292e-01f,
  8.54288563e-02f, -9.42572728e-02f, 1.28868923e-01f, 8.44590086e-03f, 1.70403674e-01f, 7.19971582e-02f, 1.55801401e-01f, 1.69656724e-01f, 5.04696481e-02f, 1.65574282e-01f,
  6.81911483e-02f, 7.63226524e-02f, 2.33692154e-02f, 1.18578270e-01f, -7.85606503e-02f, 2.78146952e-01f, 1.87186211e-01f, 2.11308524e-01f, -1.50356382e-01f, -3.11109394e-01f,
  -1.88021854e-01f, -2.55691439e-01f, -3.22251707e-01f, -9.81196612e-02f, -1.40260860e-01f, -1.07084913e-02f, -2.24413216e-01f, -1.25516787e-01f, -1.72739282e-01f, -2.28649110e-01f,
  3.01619947e-01f, 3.93566005e-02f, 2.61478245e-01f, -3.56128305e-01f, 1.41033635e-01f, -2.00223364e-02f, 2.96361804e-01f, 7.47346103e-01f, -4.95081507e-02f, -2.05851823e-01f,
  -2.46136978e-01f, 5.17867148e-01f, -2.42265284e-01f, 7.48862386e-01f, -1.43367872e-01f, -2.10563745e-03f, 2.32691124e-01f, 2.29055256e-01f, -1.47248477e-01f, 2.14276373e-01f,
  -1.68881819e-01f, 1.05201654e-01f, 1.12835407e-01f, -2.29470953e-01f, 2.71971226e-01f, -1.71162874e-01f, 3.55277993e-02f, -2.30936289e-01f, 1.09355986e-01f, -1.78982809e-01f,
  -5.85606731e-02f, -1.04088113e-01f, -8.53631422e-02f, 2.18144208e-01f, 9.72915441e-02f, -9.20177698e-02f, 1.27804279e-01f, 5.63259684e-02f, 1.34112611e-01f, 2.95378678e-02f,
  -3.37451920e-02f, -2.07486264e-02f, 3.43013629e-02f, -1.55733386e-02f, 2.82141771e-02f, 4.17914912e-02f, 7.33427033e-02f, 8.38640332e-02f, -1.78699270e-01f, 7.82272592e-02f,
  2.51171198e-02f, 3.17109711e-02f, -7.66674280e-02f, 2.10503843e-02f, 1.56477481e-01f, 5.11263572e-02f, 4.92669679e-02f, 1.77845173e-02f, -1.54424245e-02f, -9.23174173e-02f,
  -1.63493767e-01f, 2.21249953e-01f, 1.38913900e-01f, -1.86978936e-01f, -7.43125677e-02f, 6.27253950e-02f, -2.39677891e-01f, -3.46598953e-01f, 6.06469736e-02f, -4.70608659e-02f,
  4.65047628e-01f, -9.43614691e-02f, 5.10349452e-01f, 2.30462715e-01f, 1.59774780e-01f, -3.70545864e-01f, -3.29654992e-01f, 2.19081968e-01f, 2.07542852e-01f, 1.86106458e-01f,
  -1.39551193e-01f, 1.25955701e-01f, -5.05605303e-02f, -7.42207319e-02f, 1.68715045e-01f, 1.55176416e-01f, -2.53972769e-01f, -1.63479187e-02f, 1.32935315e-01f, -1.02582030e-01f,
  -3.87763739e-01f, 1.92241073e-01f, 5.54356612e-02f, 1.36065811e-01f, -8.32861066e-02f, 1.00228243e-01f, 1.49049282e-01f, 7.10826134e-03f, 1.40558854e-01f, -5.81728183e-02f,
  -4.55218032e-02f, 1.81783557e-01f, 8.24155137e-02f, 1.90211795e-02f, 1.43883154e-01f, 4.83951420e-02f, 3.33353761e-03f, 2.29937017e-01f, 3.84782813e-02f, 6.30831718e-02f,
  1.16992205e-01f, 8.69710371e-02f, -2.28839964e-01f, 1.84286460e-01f, 1.35598883e-01f, 1.99844576e-02f, -1.28077203e-02f, -1.02278464e-01f, -7.00355768e-02f, -1.88603401e-02f,
  2.12943450e-01f, 7.97171611e-03f, -3.35431192e-03f, -3.00228357e-01f, -1.79323122e-01f, 7.32660666e-03f, -5.62656485e-02f, 3.84375341e-02f, -3.43953893e-02f, 3.34756017e-01f,
  1.10292919e-01f, 1.93655834e-01f, 3.09069365e-01f, 2.82670468e-01f, 3.32550526e-01f, 1.20160900e-01f, -1.53197780e-01f, -1.34969503e-01f, -1.08225562e-01f, 3.14288706e-01f,
  -1.83249593e-01f, 5.22335529e-01f, -1.95479561e-02f, -2.94322252e-01f, -1.43010572e-01f, -6.82184249e-02f, -3.80175896e-02f, -6.71585947e-02f, -5.07905543e-01f, 1.59171596e-01f,
  1.62479535e-01f, 4.06539351e-01f, 2.20424533e-01f, 2.61454880e-01f, 2.86030501e-01f, -2.24324167e-01f, 2.52671510e-01f, 3.15904558e-01f, 2.56391346e-01f, 2.43746102e-01f,
  8.86936560e-02f, 2.01086491e-01f, 3.17371339e-01f, 8.02875534e-02f, 1.13161363e-01f, 5.75908348e-02f, 1.04523920e-01f, 5.35490178e-02f, 3.85280214e-02f, 1.17668591e-01f,
  3.07610221e-02f, -9.51907225e-03f, 3.07949692e-01f, 2.46485874e-01f, 1.17505789e-01f, -8.32348466e-02f, 3.84912848e-01f, 1.31953895e-01f, 2.48602778e-03f, 2.91911140e-02f,
  -1.48883741e-02f, -3.01956117e-01f, -4.74328101e-02f, 9.71691310e-02f, -3.69660586e-01f, 4.06432934e-02f, -1.14772104e-01f, -1.39273241e-01f, -1.01790980e-01f, 1.71854734e-01f,
  3.73064466e-02f, -1.26330718e-01f, -2.80662924e-01f, -1.05064332e-01f, -2.23656192e-01f, 9.33963731e-02f, 3.61134797e-01f, 8.77082199e-02f, 2.05220044e-01f, 4.65954036e-01f,
  -1.76725954e-01f, -2.85475075e-01f, 1.91743691e-02f, 2.57062823e-01f, -2.22541884e-01f, 3.93551514e-02f, -2.36462101e-01f, 3.11863776e-02f, 6.26466721e-02f, 2.68830031e-01f,
  -2.22923473e-01f, 3.28489602e-01f, 3.49383056e-01f, -1.91022918e-01f, 2.66926885e-01f, -5.22751398e-02f, 2.51272656e-02f, 3.12746406e-01f, 5.85864723e-01f, -2.51203537e-01f,
  9.92697477e-02f, 7.77395815e-02f, 3.70634377e-01f, 1.20029710e-01f, 2.13435203e-01f, 4.11099233e-02f, 9.68201086e-02f, 1.86885491e-01f, -1.81200296e-01f, -7.82631636e-02f,
  2.35584341e-02f, 5.96244819e-02f, -1.32620260e-01f, 2.74778128e-01f, -9.50083975e-03f, -1.49844944e-01f, 1.56318247e-01f, 1.49088847e-02f, -1.20314226e-01f, -2.70342063e-02f,
  1.55906871e-01f, -7.59146065e-02f, 1.05392076e-01f, 1.18986927e-01f, -2.53399074e-01f, -2.33217582e-01f, -6.40086308e-02f, -2.82989472e-01f, 2.52147138e-01f, -1.37693614e-01f,
  -5.30968830e-02f, -2.26333123e-02f, -4.53251451e-02f, -1.83991212e-02f, 1.04238033e-01f, 1.88860446e-01f, 3.32332581e-01f, 2.33319387e-01f, -5.49339084e-03f, 8.56482834e-02f,
  -5.63409962e-02f, -7.80510083e-02f, -1.23348035e-01f, 6.31270707e-01f, 2.03444585e-01f, -4.55509424e-01f, -1.81528211e-01f, 3.27931255e-01f, -1.33526072e-01f, -1.64745331e-01f,
  2.24453986e-01f, -4.36807573e-02f, 1.10746801e-01f, 2.83489347e-01f, 2.65068322e-01f, -1.57405153e-01f, 4.09035295e-01f, -2.63870269e-01f, 5.02886891e-01f, 4.97084826e-01f,
  -3.12902004e-01f, -4.22553360e-01f, 8.03833753e-02f, 1.72054544e-02f, 1.15203559e-02f, 1.69166088e-01f, -1.22431077e-01f, -5.38661703e-02f, -1.23837991e-02f, 4.95434999e-02f,
  6.76702037e-02f, -3.88812460e-02f, -3.45803052e-02f, 2.36713767e-01f, -8.49982947e-02f, 1.06398508e-01f, -1.70026515e-02f, 1.82713475e-02f, 4.28611860e-02f, -7.62087926e-02f,
  3.30476230e-03f, 5.82147166e-02f, 7.02551156e-02f, 2.09703192e-01f, -2.02194944e-01f, -2.54623536e-02f, -1.01715066e-01f, -6.57744333e-02f, 1.81630686e-01f, -4.05300856e-02f,
  3.33031663e-03f, 7.54815266e-02f, 7.32381791e-02f, 3.31476657e-03f, -1.15464181e-01f, -8.56684521e-02f, 2.38288287e-02f, -1.91483274e-01f, -9.04470533e-02f, -1.40931040e-01f,
  1.66484877e-01f, 8.14724714e-02f, 5.93357801e-01f, 2.24695772e-01f, -2.07916006e-01f, 2.01929197e-01f, -1.41197458e-01f, -1.58428550e-01f, -1.48298442e-01f, -3.73358309e-01f,
  -3.28289002e-01f, 1.18224442e-01f, 9.91539881e-02f, 7.06397444e-02f, 1.52200446e-01f, -7.70739764e-02f, 1.60651758e-01f, 1.37375742e-01f, 3.77590090e-01f, -1.15339234e-01f,
  -4.22880292e-01f, 9.77040753e-02f, 4.28727977e-02f, 1.12476811e-01f, 3.61278027e-01f, -9.69517305e-02f, -7.54665136e-02f, 2.47849990e-02f, 1.51651606e-01f, -2.58269496e-02f,
  1.30486697e-01f, -8.17500707e-03f, -8.09537247e-02f, 1.07349552e-01f, 1.02463886e-01f, 2.06783921e-01f, 4.98778708e-02f, 7.87760764e-02f, 1.41786680e-01f, 9.12498310e-02f,
  4.44632061e-02f, 6.25521764e-02f, 3.16339135e-02f, -6.62233606e-02f, 1.36187911e-01f, -5.99057134e-03f, 1.59162983e-01f, 8.04807767e-02f, 1.68347001e-01f, -4.01301175e-01f,
  -1.38068914e-01f, -1.88338190e-01f, 2.13882625e-01f, -4.48899686e-01f, -9.37279221e-03f, 3.06630164e-01f, -3.26091021e-01f, 2.21025705e-01f, 7.07217008e-02f, 3.79057735e-01f,
  1.21057570e-01f, -5.53526320e-02f, -8.75205919e-02f, -7.44387507e-02f, -2.80655742e-01f, -1.84406027e-01f, 2.27610439e-01f, -2.21421450e-01f, -8.53175670e-03f, 1.14319935e-01f,
  3.74777585e-01f, 1.11916624e-01f, 3.87113184e-01f, -8.08392614e-02f, 6.46472499e-02f, -4.99574244e-02f, 1.20985508e-01f, 4.03237045e-02f, 2.87757143e-02f, -1.20883614e-01f,
  2.31888741e-01f, 5.84024727e-01f, 6.53574392e-02f, -1.62127152e-01f, 6.79935336e-01f, -4.45809506e-04f, -1.30316645e-01f, -2.89556384e-01f, 4.08029586e-01f, 7.87847117e-02f,
  -4.95827883e-01f, -3.10886860e-01f, -2.91070584e-02f, -1.70793101e-01f, 1.43596977e-01f, 6.32962435e-02f, -1.67784452e-01f, 2.46915117e-01f, -1.08999550e-01f, 2.63846070e-01f,
  1.38194606e-01f, 1.54021695e-01f, -1.75147671e-02f, -4.43996862e-02f, 3.21135968e-02f, 1.11490890e-01f, 1.73475686e-02f, 2.58301944e-01f, -3.71971056e-02f, -2.67730025e-03f,
  7.92368352e-02f, 1.00750498e-01f, -1.87537417e-01f, -1.08845599e-01f, 8.97721350e-02f, -2.56782789e-02f, -6.14701435e-02f, 3.44081193e-01f, 7.43946955e-02f, 1.90499365e-01f,
  1.81679428e-01f, -1.88584760e-01f, -1.83480039e-01f, -2.19086796e-01f, -2.61373401e-01f, 2.49040067e-01f, 3.19086999e-01f, -1.83951944e-01f, 5.10759130e-02f, 4.90312651e-02f,
  5.36677763e-02f, 1.23045407e-01f, 1.31744742e-01f, -7.10549727e-02f, 4.67666090e-01f, -4.09113467e-01f, 2.26583973e-01f, 1.06131630e-02f, -7.99674764e-02f, -1.13322854e-01f,
  1.87469497e-02f, 2.23105446e-01f, 3.40675950e-01f, 7.49832913e-02f, 2.08711773e-01f, -1.01154387e-01f, 7.42787063e-01f, -2.50109166e-01f, -4.16616397e-03f, -3.98134813e-02f,
  -1.41464502e-01f, -5.06690517e-02f, -4.38798785e-01f, -3.15088570e-01f, -5.28745174e-01f, 2.11413369e-01f, 7.55350664e-02f, 2.41766647e-02f, 6.04527742e-02f, 7.78249204e-02f,
  1.85540877e-02f, 3.70366871e-02f, 1.51858211e-01f, 1.58077434e-01f, 2.92737409e-02f, 2.66661830e-02f, 7.40053877e-02f, 8.92683491e-02f, 9.44588892e-03f, 1.30546361e-01f,
  3.97242084e-02f, -1.76374048e-01f, -1.59945693e-02f, -3.27628218e-02f, 4.74250279e-02f, -3.59682925e-02f, 2.60579407e-01f, -6.36471584e-02f, -4.31401916e-02f, 7.75913894e-02f,
  -5.56427054e-02f, -6.58379272e-02f, 3.76181379e-02f, -4.34486493e-02f, -1.78946123e-01f, -6.18950017e-02f, 1.87396795e-01f, 3.15464228e-01f, 2.58697748e-01f, -3.72448303e-02f,
  -7.15122521e-02f, 1.58160284e-01f, -1.70371473e-01f, -3.29687506e-01f, -1.11995665e-02f, -4.94985655e-02f, -1.95557624e-01f, 1.34232759e-01f, 8.74269083e-02f, 7.09939599e-02f,
  1.86629608e-01f, 7.57804140e-02f, 2.41091758e-01f, -6.06220998e-02f, 2.70577461e-01f, -1.86582997e-01f, 1.66949421e-01f, 1.75435036e-01f, 8.15593228e-02f, 3.36502552e-01f,
  -2.69826859e-01f, -1.51831493e-01f, 4.56796795e-01f, -1.78259671e-01f, -9.83086005e-02f, -2.22815484e-01f, 2.46645778e-01f, 1.50268719e-01f, -2.45825574e-01f, 6.95848092e-02f,
  -1.45145759e-01f, -2.30355212e-03f, -7.90042281e-02f, -2.03967355e-02f, -4.39840294e-02f, -1.11200191e-01f, 2.39118971e-02f, 1.42812997e-01f, 9.58986878e-02f, 1.18088685e-01f,
  -6.49626926e-02f, -3.48725133e-02f, 8.34458321e-02f, 1.43155381e-01f, -7.27044046e-02f, -5.58281969e-03f, 1.41624823e-01f, 8.06921124e-02f, 1.74543500e-01f, 1.13115773e-01f,
  -3.15123975e-01f, -1.51247066e-03f, 1.46341160e-01f, 1.99198693e-01f, -1.75568968e-01f, 1.75116673e-01f, -1.65720716e-01f, -1.51994303e-01f, 1.37104601e-01f, -4.54899520e-02f,
  -9.57507640e-02f, -3.34706992e-01f, -1.42400101e-01f, -7.61002600e-02f, 1.88420251e-01f, -3.50883626e-03f, 2.75221974e-01f, 3.28810006e-01f, 1.32804334e-01f, 9.55402255e-02f,
  3.02909821e-01f, 4.39443886e-02f, 3.39942813e-01f, 2.13855773e-01f, 3.10201436e-01f, 2.37464368e-01f, -4.89949435e-02f, 2.36865535e-01f, -6.49544820e-02f, 4.79012549e-01f,
  1.56755760e-01f, -1.09909028e-01f, 2.30813064e-02f, -4.60168999e-03f, 2.50177145e-01f, -1.55892640e-01f, -3.83058578e-01f, 5.71394600e-02f, 2.21202523e-01f, 2.01294631e-01f,
  4.89255674e-02f, -2.60797679e-01f, -7.81817362e-02f, 1.94380015e-01f, 1.85201809e-01f, 1.52579471e-01f, 3.56012173e-02f, 4.72025871e-02f, 2.66161412e-01f, 9.97959748e-02f,
  1.60976529e-01f, 8.80544633e-02f, 1.60346568e-01f, 1.84784442e-01f, 5.54854982e-02f, 1.91386133e-01f, 2.10686624e-01f, -4.36211526e-02f, 4.41813879e-02f, 7.16473833e-02f,
  1.50548503e-01f, 1.50743276e-01f, 1.24273740e-01f, -3.90487134e-01f, 1.34126037e-01f, 1.49539828e-01f, 1.68561354e-01f, 9.28615183e-02f, -1.18412368e-01f, -8.42103958e-02f,
  -6.09125057e-03f, -2.33947989e-02f, -1.46329001e-01f, 7.22243041e-02f, 1.61128342e-01f, 2.34507531e-01f, 1.30694166e-01f, 1.59338266e-01f, 9.88938585e-02f, 2.05048874e-01f,
  -5.46344742e-02f, -2.37185597e-01f, -4.32641208e-01f, -9.13041905e-02f, 3.90767902e-01f, 8.87309089e-02f, 3.19670200e-01f, 4.49061096e-01f, -1.49696827e-01f, 3.03700659e-02f,
  8.55007172e-02f, 2.18480974e-01f, 1.76675871e-01f, 1.20974854e-01f, -8.02004486e-02f, -9.73611698e-02f, 3.68621439e-01f, 1.70483232e-01f, -3.19821328e-01f, 1.29517317e-01f,
  4.42483306e-01f, 4.64542896e-01f, 2.82654725e-02f, -3.88723671e-01f, 2.78083026e-01f, 4.43520367e-01f, 3.97565097e-01f, 2.15294018e-01f, 1.90366864e-01f, 1.00846045e-01f,
  1.68764487e-01f, 1.14178039e-01f, 3.19605060e-02f, 1.91301152e-01f, -3.57239060e-02f, 1.19122945e-01f, 2.50114338e-03f, 6.21831119e-02f, 1.83923915e-01f, -1.72647939e-03f,
  1.38198882e-01f, 2.44475469e-01f, 6.98800981e-02f, 1.26559213e-01f, -3.42272520e-02f, 1.22106425e-01f, 1.79975122e-01f, 2.62468219e-01f, -1.46522000e-01f, 1.27816021e-01f,
  1.68446019e-01f, -3.46638188e-02f, -5.43048233e-02f, 5.99578582e-02f, -2.17874140e-01f, 5.86136654e-02f, -2.90710926e-01f, 1.01218484e-01f, 6.51114732e-02f, -3.81364971e-02f,
  -2.25765005e-01f, -2.08493024e-01f, -2.79773295e-01f, -1.79399788e-01f, 1.42982394e-01f, -7.33736902e-02f, 5.41984260e-01f, -2.79684603e-01f, -3.51118803e-01f, -1.02443404e-01f,
  1.57088310e-01f, 4.17757034e-01f, 6.93237707e-02f, 1.16129918e-02f, -1.01352088e-01f, 4.20210123e-01f, -1.77856177e-01f, 5.31356812e-01f, 4.03142860e-03f, 2.14160889e-01f,
  3.34961832e-01f, 1.45366982e-01f, 3.42736334e-01f, -7.47404546e-02f, -1.28368631e-01f, 1.09162778e-01f, -3.34185362e-01f, 1.13713015e-02f, 2.74142176e-01f, -3.70490462e-01f,
  -2.94026077e-01f, 5.85760213e-02f, -9.06307921e-02f, -4.46239188e-02f, 1.83188096e-01f, -1.06044896e-02f, -2.80803218e-02f, 2.01339908e-02f, -2.24780235e-02f, 9.85351740e-04f,
  -6.57641366e-02f, 1.14349596e-01f, -1.87634910e-03f, 2.72211973e-02f, 2.19269395e-02f, 1.06548421e-01f, 9.30333212e-02f, 8.68494213e-02f, 1.32263154e-01f, 5.14676012e-02f,
  1.09088436e-01f, 1.89390898e-01f, -1.37502283e-01f, 1.73189789e-01f, 2.42726490e-01f, 3.87748890e-02f, -3.52077046e-03f, 3.18812020e-02f, 1.44415855e-01f, -2.05672190e-01f,
  4.10164684e-01f, -1.50391310e-01f, -1.12147681e-01f, -2.16045797e-01f, 3.14569809e-02f, -2.26262957e-02f, 7.18653128e-02f, 1.84912030e-02f, 2.94876575e-01f, 3.10360849e-01f,
  -1.06213447e-02f, 3.78341824e-01f, -1.78030610e-01f, 3.14426035e-01f, 2.59279996e-01f, -1.17396586e-01f, 1.47186041e-01f, -2.53937304e-01f, -1.61568895e-01f, 2.63928305e-02f,
  7.54112974e-02f, 2.00370759e-01f, 6.61845088e-01f, -8.72415528e-02f, -9.07705724e-02f, 8.16849023e-02f, 3.27011943e-01f, -2.50184923e-01f, 3.04405149e-02f, -2.98224390e-01f,
  2.33241245e-01f, 5.03583908e-01f, 1.48469046e-01f, -4.08072807e-02f, -1.62357926e-01f, -5.32576069e-02f, 1.33518398e-01f, 7.39631578e-02f, 3.16727817e-01f, 1.64109483e-01f,
  -1.40040979e-01f, 3.21539640e-02f, 2.34986588e-01f, 1.50516540e-01f, 5.20909354e-02f, 1.75727874e-01f, 2.69125074e-01f, 5.82099669e-02f, 7.06080049e-02f, 2.65169710e-01f,
  4.14831974e-02f, 1.87472776e-02f, -5.06984890e-02f, 1.47394389e-01f, 1.84526950e-01f, 7.56002888e-02f, 2.97983050e-01f, -1.18643522e-01f, 7.98811615e-02f, -1.29791513e-01f,
  2.40914330e-01f, -5.15081696e-02f, 7.51007423e-02f, 3.37006897e-01f, -2.58220285e-01f, 2.97843777e-02f, 2.35342413e-01f, 1.36361286e-01f, 4.81220186e-02f, -1.04517795e-01f,
  -3.73117141e-02f, -2.35507712e-01f, -3.73158634e-01f, -1.91288948e-01f, 1.97253283e-03f, 2.24741131e-01f, 1.92653969e-01f, 1.68223418e-02f, 2.65566725e-02f, -1.66348621e-01f,
  1.27641127e-01f, -8.63257647e-02f, 2.81398505e-01f, -1.72510937e-01f, 3.68442178e-01f, -2.88595915e-01f, -1.58260334e-02f, 9.68126804e-02f, 1.12526916e-01f, 2.80518502e-01f,
  -7.93090835e-02f, 7.40367267e-03f, 3.75911683e-01f, -8.82801414e-02f, 2.05375791e-01f, -1.68223336e-01f, -1.18309371e-01f, 2.28876561e-01f, 2.83287585e-01f, -1.43409476e-01f,
  -1.48176447e-01f, -4.92716171e-02f, 8.01463276e-02f, -2.37982590e-02f, -4.77074785e-03f, 1.15545735e-01f, 2.16494381e-01f, 2.45918900e-01f, 1.02994010e-01f, 1.31449819e-01f,
  -4.33405675e-02f, -1.66581757e-02f, -1.30191748e-03f, 7.29235187e-02f, 1.07565381e-01f, 6.79828450e-02f, 2.41181433e-01f, -1.46767683e-02f, 1.33621857e-01f, -1.00223627e-02f,
  -4.55487482e-02f, -5.58175147e-02f, 6.60453141e-02f, 4.64362092e-02f, -1.15683295e-01f, 3.57591033e-01f, 2.29061604e-01f, -1.41046733e-01f, 3.06815028e-01f, -8.88359398e-02f,
  -7.84768760e-02f, -2.01602355e-01f, 1.31225049e-01f, 1.95552275e-01f, 1.30147457e-01f, 8.22585598e-02f, 1.42452896e-01f, 2.12628126e-01f, -8.90524536e-02f, 5.42120218e-01f,
  1.88004911e-01f, 3.68627645e-02f, 1.82572961e-01f, 4.67465166e-03f, 1.03569277e-01f, 8.22493359e-02f, 8.30103904e-02f, 7.70954043e-02f, -9.37971622e-02f, 1.40796259e-01f,
  1.84079155e-01f, -1.88081600e-02f, -1.04887262e-01f, -3.98394391e-02f, 3.03750485e-01f, -6.49525970e-02f, -1.81630030e-01f, -3.68281722e-01f, 3.60721707e-01f, 9.27579626e-02f,
  -3.56366485e-01f, -1.13776691e-01f, 2.07868069e-01f, 2.62711346e-01f, 2.84774095e-01f, 1.26765445e-01f, 1.60443872e-01f, 2.92235255e-01f, 2.53220320e-01f, 1.30506217e-01f,
  2.29311854e-01f, 2.93259174e-01f, 2.81044066e-01f, -5.15713915e-02f, 1.86979353e-01f, 1.66488796e-01f, 1.12701066e-01f, 1.35498494e-01f, 2.06923652e-02f, 1.74662858e-01f,
  -7.11066797e-02f, 4.07058746e-01f, 6.25623986e-02f, -1.68918148e-01f, 2.11513087e-01f, -2.85783093e-02f, -5.75844534e-02f, -5.13153300e-02f, -8.78450796e-02f, 3.95999223e-01f,
  -2.61547882e-02f, 7.12136785e-03f, -2.29744866e-01f, 1.75221078e-02f, 1.77890018e-01f, 2.47215346e-01f, 1.63249627e-01f, -1.87391937e-02f, 3.17147300e-02f, 1.01329789e-01f,
  4.51490022e-02f, -3.70478958e-01f, 5.84167615e-02f, 1.25196576e-01f, -1.85088336e-01f, -2.26738989e-01f, -1.51236817e-01f, 2.52216160e-01f, 1.42711541e-02f, 1.73891753e-01f,
  1.05601341e-01f, 1.28127456e-01f, 9.12037939e-02f, -8.38731751e-02f, -3.86539191e-01f, 3.86636704e-02f, 5.00133395e-01f, -1.84711665e-02f, 1.69656411e-01f, -1.99502856e-01f,
  1.04909368e-01f, 2.33827129e-01f, -3.70319113e-02f, -4.32791829e-01f, -3.75429362e-01f, 8.58769864e-02f, 1.37541682e-01f, 1.87680811e-01f, 4.90334220e-02f, 1.82533666e-01f,
  1.25828192e-01f, 8.13097805e-02f, 1.54533386e-01f, -9.37308595e-02f, 1.80411488e-02f, -2.01907586e-02f, 7.04226866e-02f, 7.42047355e-02f, 8.49784017e-02f, 2.05334082e-01f,
  1.70364678e-01f, 7.61887431e-02f, 1.22637369e-01f, 3.52045558e-02f, 1.23615943e-01f, 1.57306865e-01f, 1.55091673e-01f, 1.46834046e-01f, 1.02135934e-01f, 2.38325864e-01f,
  1.87980920e-01f, 1.93208203e-01f, 3.19762342e-02f, -2.01897100e-01f, 1.22635245e-01f, 2.61458922e-02f, -1.14932001e-01f, -8.49315524e-02f, -1.85590789e-01f, -1.04289651e-01f,
  -3.38311158e-02f, 1.36753753e-01f, -1.15033545e-01f, 1.49601116e-03f, -1.44460902e-01f, -4.90012504e-02f, 2.85572797e-01f, 3.53873819e-01f, 2.51620620e-01f, 2.30541885e-01f,
  3.93904969e-02f, 2.01701716e-01f, -2.56912827e-01f, 2.15051826e-02f, 1.55139640e-01f, 9.48623195e-02f, 4.85430248e-02f, 5.60577086e-04f, 1.60401419e-01f, 8.93515646e-02f,
  7.42078498e-02f, 2.84216404e-01f, -2.22320199e-01f, 3.13157231e-01f, 3.24286520e-02f, -2.31555223e-01f, 2.37748340e-01f, -1.00847244e-01f, 2.29789540e-01f, 2.56760180e-01f,
  6.31107628e-01f, -3.40352356e-01f, 1.68378264e-01f, 6.91153556e-02f, 2.81589627e-01f, 9.69957113e-02f, 1.17737621e-01f, 2.79718369e-01f, 2.39406198e-01f, 6.42997473e-02f,
  -9.47359018e-03f, -1.22273602e-01f, 1.15298830e-01f, 5.70940133e-03f, 1.80432610e-02f, 4.00068015e-01f, 1.17409721e-01f, 2.96872497e-01f, 3.14515404e-04f, 1.53119221e-01f,
  -2.45946646e-02f, -2.45498940e-02f, 3.94551754e-02f, 1.30128860e-01f, 2.59955339e-02f, -1.70126215e-01f, 1.17296711e-01f, 1.43531263e-01f, -1.55715108e-01f, 1.41655222e-01f,
  -4.36719328e-01f, -2.17367150e-02f, 4.21650670e-02f, 8.18224624e-02f, -2.23566741e-01f, -1.83124483e-01f, -1.96396664e-01f, -1.77408382e-01f, 1.91492587e-01f, -2.13556737e-01f,
  1.46556988e-01f, -1.71260983e-01f, -1.43851399e-01f, -1.24065623e-01f, -1.08216800e-01f, 4.65986013e-01f, 3.73047799e-01f, -5.60809970e-01f, -1.70664936e-01f, 3.47593397e-01f,
  -2.48882875e-01f, -4.89961095e-02f, -2.27040172e-01f, 1.15714818e-01f, 2.21738696e-01f, 6.13604337e-02f, 2.56230056e-01f, -2.94629395e-01f, 3.54291052e-02f, 3.85654211e-01f,
  -2.70466283e-02f, 3.32598388e-01f, 1.40607834e-01f, -1.68796480e-01f, -2.78849304e-01f, 1.14620179e-01f, 1.19681031e-01f, 8.48293863e-03f, 8.28028247e-02f, 2.40213528e-01f,
  6.66926429e-02f, -4.53842804e-02f, 1.83714360e-01f, 1.30044565e-01f, 1.30581021e-01f, 2.36087054e-01f, 5.31171300e-02f, -2.11174879e-02f, 5.59356511e-02f, 1.32686347e-01f,
  5.11173718e-02f, -1.47868663e-01f, 1.57862887e-01f, 1.09959126e-01f, 6.72406480e-02f, 6.99105263e-02f, 1.57873452e-01f, -1.18454777e-01f, -7.32235163e-02f, -8.09616502e-03f,
  -1.06636584e-01f, 2.02100873e-01f, 2.85225004e-01f, -1.02035344e-01f, 4.96338367e-01f, -2.30358653e-02f, -1.14652112e-01f, 4.76524532e-02f, 2.40793034e-01f, 5.25156148e-02f,
  1.04577959e-01f, 3.23758870e-01f, 1.47283584e-01f, -9.79615003e-02f, -1.46530300e-01f, 4.44063693e-01f, 1.25008360e-01f, 2.82831460e-01f, -2.22261235e-01f, -1.77630950e-02f,
  3.36690128e-01f, -4.29236405e-02f, 1.57678977e-01f, 5.84569722e-02f, 4.88539673e-02f, -5.03803849e-01f, 2.59423226e-01f, -2.73906112e-01f, -1.00465678e-02f, 2.81687856e-01f,
  7.71043077e-02f, -1.24733202e-01f, 4.93286997e-01f, 2.25167032e-02f, 2.55348980e-01f, 3.66769493e-01f, -2.61735544e-03f, 3.01031947e-01f, -8.57151076e-02f, 7.52430186e-02f,
  2.43383214e-01f, 2.54331052e-01f, 1.04108036e-01f, 1.42969847e-01f, 1.78711161e-01f, -4.52821217e-02f, 2.02469811e-01f, 2.03578085e-01f, -1.00247800e-01f, 1.45479232e-01f,
  1.66056737e-01f, -1.81795936e-02f, 1.52843460e-01f, 1.69522852e-01f, -4.49600406e-02f, 7.81743452e-02f, 5.47448955e-02f, 8.96424726e-02f, 1.20417908e-01f, 5.05970120e-02f,
  -8.23466629e-02f, -1.57465160e-01f, -4.61553112e-02f, -1.82645559e-01f, 9.48070064e-02f, -1.53479993e-01f, 9.47251543e-02f, 1.70248941e-01f, -1.76284969e-01f, 1.39411777e-01f,
  1.86942831e-01f, -2.58532733e-01f, 7.99389556e-02f, -9.28319693e-02f, 1.30546838e-02f, -1.05823711e-01f, -3.01916420e-01f, 9.27303135e-02f, 2.78697103e-01f, 3.51034552e-01f,
  6.76305532e-01f, 2.26689473e-01f, 1.14275485e-01f, -4.08063084e-01f, -1.04511127e-01f, -2.12168470e-01f, 1.09203406e-01f, 3.62083800e-02f, 3.73829097e-01f, -2.91207582e-01f,
  1.10117286e-01f, -5.65191619e-02f, -1.32073164e-01f, 6.92527443e-02f, 3.51087183e-01f, 4.70336713e-02f, 1.56186465e-02f, 3.95268738e-01f, 2.63768077e-01f, 3.58204067e-01f,
  1.18173331e-01f, 3.70454401e-01f, 3.88762206e-01f, -7.42274746e-02f, 3.92120704e-03f, 2.86854804e-01f, -4.28675003e-02f, 2.53733933e-01f, 2.53736645e-01f, -3.49426754e-02f,
  6.27620220e-02f, 5.56173138e-02f, 3.34573537e-02f, 2.59045273e-01f, 1.17341146e-01f, 9.15950388e-02f, 2.23327726e-01f, 1.53025433e-01f, 4.60105315e-02f, 3.49745631e-01f,
  -3.66802849e-02f, 2.20450282e-01f, 8.54480341e-02f, 3.18357274e-02f, -5.79658635e-02f, -2.78873295e-02f, -1.15114048e-01f, -4.24149856e-02f, -2.07066536e-01f, 2.07935527e-01f,
  -1.71872184e-01f, -1.58949241e-01f, 3.93297285e-01f, -1.19439535e-01f, -4.95863073e-02f, -1.94940433e-01f, 8.36339816e-02f, -4.32170630e-02f, 2.56879747e-01f, -3.91384820e-03f,
  4.37964439e-01f, 2.96721254e-02f, 3.32930535e-01f, 2.21721828e-01f, -3.04582328e-01f, -3.71723250e-02f, -1.66061580e-01f, 3.27490598e-01f, 1.28979329e-03f, -6.22330457e-02f,
  4.65093926e-02f, 3.82102042e-01f, 2.32242867e-02f, 2.63218462e-01f, 3.48207690e-02f, -5.82332127e-02f, 3.37242633e-01f, -8.33695456e-02f, 3.64866823e-01f, -2.22531021e-01f,
  -5.64151406e-01f, 2.05072477e-01f, 5.08969426e-01f, 4.59430277e-01f, -5.36987558e-02f, -2.75562674e-01f, 2.20024541e-01f, 3.88400614e-01f, 3.49180028e-02f, 3.38095397e-01f,
  -1.60377268e-02f, 1.95729420e-01f, 2.95723945e-01f, 1.04323104e-01f, 3.49118933e-02f, 8.37905407e-02f, -2.37131189e-03f, 1.61287025e-01f, 1.40803888e-01f, 5.05268052e-02f,
  2.88537383e-01f, 2.39764154e-01f, 1.28142834e-01f, 1.12761363e-01f, 9.01745856e-02f, 1.60557538e-01f, 1.01639470e-03f, -2.85411775e-01f, 7.58359805e-02f, 3.53426516e-01f,
  1.92559138e-01f, 6.85789883e-02f, -3.67185682e-01f, 1.05997100e-01f, -1.00953840e-01f, -8.78159851e-02f, 1.46597698e-01f, -2.85719559e-02f, -4.22183350e-02f, -2.46850196e-02f,
  9.25433263e-02f, 1.35991469e-01f, 1.76072624e-02f, 2.09369034e-01f, 1.66608259e-01f, 1.47861671e-02f, -3.36472601e-01f, -2.93146938e-01f, 1.30245358e-01f, 4.90411706e-02f,
  4.77983281e-02f, 4.26076025e-01f, -9.06932577e-02f, 1.17613763e-01f, -4.84101735e-02f, 2.86612928e-01f, -1.20673083e-01f, 1.40125424e-01f, -2.49731600e-01f, -2.43633494e-01f,
  1.44748285e-01f, -3.94234419e-01f, -4.45320070e-01f, 9.61181615e-03f, 1.25141451e-02f, 6.98897064e-01f, -1.66874245e-01f, 1.97522447e-01f, 2.96714514e-01f, 3.05703640e-01f,
  1.88590869e-01f, 3.17006081e-01f, 4.00753990e-02f, 3.37164849e-02f, 1.58680335e-01f, 9.89142880e-02f, 1.14447035e-01f, 8.56473818e-02f, 7.02554435e-02f, 6.75717592e-02f,
  -7.47158304e-02f, 1.41212806e-01f, 6.29380867e-02f, 1.23831021e-04f, -2.05477998e-02f, 1.17489055e-01f, 1.47400931e-01f, -1.64797828e-02f, 2.16703564e-01f, 1.13525197e-01f,
  -1.73269548e-02f, 9.95485261e-02f, -1.58282071e-01f, 3.99812311e-02f, 1.08486049e-01f, 1.29547298e-01f, 3.10717914e-02f, -4.06770734e-03f, -5.95464930e-03f, -2.63579458e-01f,
  1.95185214e-01f, 5.11743836e-02f, -1.52730152e-01f, 9.64756012e-02f, -2.03228910e-02f, 4.28978130e-02f, -5.78863136e-02f, 7.70725086e-02f, 2.40769461e-01f, 9.93814245e-02f,
  4.50968951e-01f, 9.07257721e-02f, -4.78047699e-01f, 1.45937040e-01f, 1.28923446e-01f, 1.87667847e-01f, 1.51982233e-01f, -1.08448133e-01f, -1.96464762e-01f, 1.16289653e-01f,
  9.89613682e-03f, 2.44370297e-01f, 4.92596239e-01f, 1.04365826e-01f, -3.52430157e-02f, 3.78192216e-02f, 4.54345822e-01f, -9.82475746e-03f, 5.15180379e-02f, -3.79493117e-01f,
  2.71409273e-01f, 6.55582964e-01f, 2.77107924e-01f, -2.72978961e-01f, -4.00349498e-01f, 2.79513240e-01f, -1.43320531e-01f, 8.09702501e-02f, -1.96133092e-01f, 5.10211997e-02f,
  1.72385857e-01f, 1.91969797e-01f, 1.70141533e-01f, 1.19783007e-01f, 1.43966958e-01f, 2.12613475e-02f, -1.82164684e-02f, 1.82763394e-02f, 1.34064518e-02f, -1.37084320e-01f,
  1.07319355e-01f, 7.37568922e-03f, 1.82336509e-01f, 9.45487767e-02f, 1.58131957e-01f, 3.47153544e-02f, -1.15079004e-02f, -1.72421455e-01f, -3.94078679e-02f, -4.56396453e-02f,
  6.82303160e-02f, -7.49911042e-03f, -1.53447399e-02f, 6.99388981e-02f, 2.41956562e-01f, 8.59712511e-02f, -2.56604459e-02f, 2.06862584e-01f, 2.35910848e-01f, 1.72197875e-02f,
  -1.82712123e-01f, 1.92531332e-01f, -1.86033502e-01f, -2.68720724e-02f, 4.07636613e-02f, 3.28624517e-01f, 3.39204311e-01f, 3.46437216e-01f, 2.62689590e-01f, -3.42054844e-01f,
  2.04903930e-01f, 1.51982486e-01f, 2.64780492e-01f, -2.23406404e-01f, 4.75186884e-01f, -9.59624872e-02f, 2.51858205e-01f, -1.63331047e-01f, -7.15280846e-02f, 2.76939303e-01f,
  -2.00321048e-01f, 2.17532497e-02f, 4.21182215e-01f, 9.59469602e-02f, -3.36849332e-01f, -2.98893042e-02f, 3.67721349e-01f, 5.34865856e-01f, -2.33223677e-01f, -1.18795577e-02f,
  -2.60349587e-02f, -1.04330108e-02f, 4.84976964e-03f, -2.53753588e-02f, -4.67416737e-03f, 2.25287187e-03f, 1.70036659e-01f, 1.97433636e-01f, 1.43049538e-01f, 7.49361515e-02f,
  8.68321105e-04f, 8.54430795e-02f, -9.67264324e-02f, -4.57181484e-02f, -1.23877622e-01f, 1.34281024e-01f, 1.93009689e-01f, 6.26746267e-02f, 1.09186560e-01f, -2.08769113e-01f,
  3.58717749e-03f, 2.49029007e-02f, -9.05138105e-02f, 2.07129568e-02f, -1.04212593e-02f, -3.66287500e-01f, 1.27652824e-01f, -1.77725345e-01f, -2.35058829e-01f, -6.05501272e-02f,
  -7.21092969e-02f, -1.50294244e-01f, -1.77378088e-01f, 1.59343481e-01f, 1.42996028e-01f, -1.26053259e-01f, -1.25444889e-01f, 1.12723865e-01f, 1.41346604e-01f, -5.53446531e-01f,
  2.36696631e-01f, -2.43463486e-01f, 3.93236309e-01f, 4.70234603e-01f, 4.50775214e-02f, -1.77186783e-02f, -2.80564815e-01f, 1.36379555e-01f, -2.07979709e-01f, 4.21689808e-01f,
  1.21910550e-01f, 2.62863934e-01f, -6.37185946e-02f, 1.20603316e-01f, -9.93075892e-02f, 1.42182902e-01f, 9.65632051e-02f, 4.74696932e-03f, 2.26418346e-01f, -5.41827939e-02f,
  2.65260249e-01f, -4.12539616e-02f, 2.74361581e-01f, 1.34766936e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.27398652e-02f, 1.98567137e-01f, 7.41231889e-02f, 1.60428345e-01f, 1.83268711e-01f, 1.06661275e-01f, 1.00313254e-01f, 1.68965951e-01f, 1.57353565e-01f, 1.44330516e-01f,
  1.46875411e-01f, 2.03783214e-01f, 1.59995988e-01f, 6.62453696e-02f, -2.28690058e-02f, 2.30879962e-01f, 1.05946399e-01f, -7.88981211e-04f, 1.74433514e-01f, 2.84256160e-01f,
  3.20240110e-02f, 2.19762340e-01f, 2.11012855e-01f, 1.16374120e-01f, 9.12726074e-02f, 3.35581303e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  4.55933101e-02f, -2.91139305e-01f, -3.80058408e-01f, 1.53113517e-03f, -2.24047288e-01f, -8.59438442e-03f, -1.20281488e-01f, -2.46905401e-01f, -5.91485985e-02f, -3.88347983e-01f,
  -2.80142426e-01f, 2.45410234e-01f, -6.39159307e-02f, -2.39738360e-01f, 3.44064385e-02f, 9.97561291e-02f, 2.11891264e-01f, -6.27665967e-02f, 4.96442849e-03f, -3.69514041e-02f,
  1.24154724e-01f, -4.92846519e-02f, 2.67261118e-01f, 1.30338952e-01f, -4.97191325e-02f, 1.33119717e-01f, -2.69122589e-02f, -3.64253193e-01f, 8.46635252e-02f, 1.80940136e-01f,
  -1.90531373e-01f, 2.20797628e-01f, 2.41005629e-01f, 1.90116137e-01f, -6.83752000e-02f, -2.85311639e-01f, -2.89608032e-01f, -3.71265382e-01f, 6.24225773e-02f, -4.65761691e-01f,
  -4.82630908e-01f, -2.56435245e-01f, -2.17426643e-01f, -1.13422148e-01f, 6.30205795e-02f, 2.11204514e-01f, -2.59887993e-01f, 2.49087572e-01f, -7.61789083e-01f, -1.92207307e-01f,
  -1.78989768e-01f, 1.72120571e-01f, 1.47853568e-01f, -3.53844821e-01f, -5.61925530e-01f, 9.73650739e-02f, -3.57474893e-01f, 2.41907179e-01f, 1.85495451e-01f, -4.82959419e-01f,
  4.20990102e-02f, 1.39483377e-01f, 3.11105788e-01f, -1.69987708e-01f, 2.69326776e-01f, -3.54494452e-02f, 3.30028348e-02f, -3.51771593e-01f, -1.32497415e-01f, -2.92720675e-01f,
  2.16419712e-01f, -3.11597213e-02f, -4.72498238e-01f, -3.44654471e-02f, 1.67346954e-01f, 7.11226091e-02f, -1.53951094e-01f, 1.91306457e-01f, -5.54152839e-02f, 1.55661717e-01f,
  2.43764639e-01f, -2.13633776e-01f, -8.75675529e-02f, -2.69923866e-01f, -6.97052181e-02f, -5.20961523e-01f, -1.74195722e-01f, -3.02704573e-01f, 2.81384408e-01f, 1.98714033e-01f,
  7.03474656e-02f, 3.29286337e-01f, 4.05596733e-01f, -3.84524316e-01f, 3.72466117e-01f, 2.79009879e-01f, -4.41324592e-01f, 5.68531416e-02f, 4.54518288e-01f, 5.25020897e-01f,
  7.33657181e-02f, 1.95664410e-02f, -8.60456467e-01f, -8.53134513e-01f, 1.25166163e-01f, -3.19226563e-01f, 3.72988917e-02f, -4.76871759e-01f, -2.38136902e-01f, 5.04590213e-01f,
  1.33400664e-01f, 2.67288923e-01f, 5.96442223e-02f, 2.37971749e-02f, -3.70355368e-01f, -5.53366005e-01f, 2.84135014e-01f, 1.02340080e-01f, -3.84595282e-02f, -4.90055531e-02f,
  -4.83494490e-01f, 2.53013462e-01f, 9.47610065e-02f, -5.32901168e-01f, -4.43403035e-01f, -5.49462616e-01f, 3.69000226e-01f, -1.06741585e-01f, -9.51507092e-02f, 7.51274452e-02f,
  1.09581560e-01f, -1.66145757e-01f, 1.75129119e-02f, -2.15348485e-03f, -1.27206281e-01f, 1.81213126e-01f, -5.95143795e-01f, 1.16498597e-01f, 5.84098883e-02f, -1.02520175e-01f,
  -1.92914009e-01f, 1.29122570e-01f, -2.27267489e-01f, -2.60135055e-01f, -1.56537428e-01f, 1.99760020e-01f, -8.19843784e-02f, -2.35749677e-01f, 6.16235696e-02f, 2.09539890e-01f,
  -1.85311511e-01f, 3.45970035e-01f, -1.27477109e-01f, 2.17354476e-01f, -7.83806592e-02f, -1.97246611e-01f, 1.61782652e-01f, 3.89235258e-01f, 3.68913449e-02f, -1.27985671e-01f,
  2.67216235e-01f, -3.86301398e-01f, -4.68425333e-01f, 3.92014891e-01f, -1.81400344e-01f, 1.46682844e-01f, 3.46494168e-01f, -3.85457546e-01f, -3.42099726e-01f, 2.97386825e-01f,
  2.47532293e-01f, -3.41292411e-01f, -4.54612702e-01f, -6.96099341e-01f, -4.03459013e-01f, -2.12280363e-01f, -4.05455977e-01f, 2.72041950e-02f, -2.87764430e-01f, -9.23205838e-02f,
  1.48688272e-01f, 8.97226036e-02f, 1.59488291e-01f, 2.72955656e-01f, -1.99364290e-01f, 1.02424040e-01f, 2.02644274e-01f, -1.53156325e-01f, 6.25100210e-02f, -2.29174852e-01f,
  9.51881334e-02f, -4.08860773e-01f, -3.43607694e-01f, 2.04718143e-01f, 1.98050261e-01f, 4.14950959e-02f, 1.58277676e-01f, -2.31689364e-01f, -1.18184082e-01f, -1.33616000e-01f,
  -2.24690795e-01f, -1.29990235e-01f, 3.29109654e-02f, 2.50976980e-01f, 1.79068372e-02f, -2.80431025e-02f, 9.81774107e-02f, -4.14892077e-01f, -5.75112663e-02f, -3.31377804e-01f,
  3.81671414e-02f, -1.70203999e-01f, 1.09418936e-01f, -1.79879051e-02f, -1.78229451e-01f, -1.36447951e-01f, -1.52973264e-01f, 2.85065234e-01f, 1.15393035e-01f, -8.16614628e-02f,
  1.78896978e-01f, 2.87131637e-01f, -1.18474476e-01f, 2.49647766e-01f, 2.80489713e-01f, -3.52416575e-01f, -2.97526330e-01f, 2.77022392e-01f, -2.35348091e-01f, 1.17928751e-01f,
  1.58146605e-01f, -1.50853187e-01f, -7.52567589e-01f, 7.66057670e-02f, -7.03086197e-01f, 9.98942405e-02f, 1.45907894e-01f, -1.97073773e-01f, 1.72964156e-01f, -3.20220232e-01f,
  2.18394473e-01f, -8.43038142e-01f, 1.10468000e-01f, 2.88954169e-01f, -3.55343491e-01f, 3.96612883e-01f, -2.53618449e-01f, -1.94624215e-01f, -3.32567155e-01f, 8.17110315e-02f,
  7.15427175e-02f, 2.86373883e-01f, -3.60299766e-01f, 2.72366792e-01f, -2.64000203e-02f, -1.01512825e+00f, 9.70096216e-02f, 1.84060603e-01f, -1.02124698e-01f, -3.22368890e-02f,
  8.41739178e-02f, 9.14566815e-02f, -2.85999384e-04f, -2.49059901e-01f, 1.45097911e-01f, 2.81170517e-01f, -8.73815566e-02f, -1.36526272e-01f, 2.11959362e-01f, 3.81134361e-01f,
  -7.93273970e-02f, 6.88141584e-02f, -1.47328824e-01f, 2.00320706e-01f, -4.47185105e-03f, -3.84042300e-02f, -3.95806372e-01f, -4.24294829e-01f, 3.32765505e-02f, -4.01216298e-01f,
  -3.71621490e-01f, -2.19992742e-01f, -4.52664912e-01f, 9.75924507e-02f, -5.40696643e-02f, 3.00291806e-01f, -3.16226959e-01f, -3.82903516e-01f, -3.41221839e-02f, 9.30202156e-02f,
  -1.75920129e-01f, -4.28830147e-01f, 4.12481934e-01f, 2.02736616e-01f, 2.70159215e-01f, 3.87433976e-01f, 2.21454352e-01f, 2.80968338e-01f, -1.86341107e-01f, -3.80593777e-01f,
  3.38663280e-01f, -5.02751628e-03f, -1.06777382e+00f, 2.66639758e-02f, 5.40588144e-03f, -4.66994315e-01f, 2.45330051e-01f, -8.15336481e-02f, -4.05126959e-02f, -1.53783932e-01f,
  -3.63676637e-01f, 9.59410705e-03f, -1.56660482e-01f, -1.50609612e-01f, -7.31475577e-02f, 1.93735048e-01f, -6.25882566e-01f, 6.99977726e-02f, 3.83700356e-02f, 5.70386760e-02f,
  -2.02346891e-02f, -4.38310295e-01f, 9.74281728e-02f, 2.97741234e-01f, 2.83938497e-01f, 2.54876524e-01f, -7.60504082e-02f, -1.48275420e-01f, 4.60344881e-01f, 1.72527283e-01f,
  -8.96044821e-03f, -1.23026140e-03f, -2.34734282e-01f, 5.00532538e-02f, 8.62576738e-02f, 2.21312806e-01f, 4.30822402e-01f, 4.14609984e-02f, 1.08095080e-01f, -2.45363146e-01f,
  4.51818854e-02f, -4.29454669e-02f, -1.48469985e-01f, 4.48611118e-02f, -1.36307804e-02f, -4.84775305e-01f, -6.38865381e-02f, -2.82304615e-01f, -1.22262813e-01f, -3.15038741e-01f,
  -2.20113277e-01f, 4.75192368e-02f, -1.99701816e-01f, 3.39083821e-01f, 1.29475266e-01f, -6.29232466e-01f, -2.41093308e-01f, 3.76991093e-01f, -5.36748171e-01f, 8.29353705e-02f,
  2.37738043e-02f, -5.74302375e-01f, 1.23028114e-01f, 4.08616960e-01f, -2.70535350e-01f, 3.07972133e-01f, -5.62492274e-02f, 2.75580913e-01f, -4.70103621e-01f, -7.79020339e-02f,
  3.36575478e-01f, -2.66172379e-01f, 1.45541474e-01f, -2.29647323e-01f, 2.25328788e-01f, -4.05965792e-03f, 5.07025719e-01f, -5.65760471e-02f, -2.48912022e-01f, -2.64786035e-01f,
  -1.90354571e-01f, -4.53409329e-02f, -2.07672358e-01f, 2.14607827e-02f, -1.98314056e-01f, 3.44665721e-02f, -2.41045300e-02f, 2.03940183e-01f, -4.04324800e-01f, -9.58641544e-02f,
  -1.10746853e-01f, 1.14759721e-01f, 1.78574249e-01f, -4.38720882e-01f, -2.16124102e-01f, -1.41694382e-01f, -2.52619803e-01f, -6.98899999e-02f, 1.11029096e-01f, -2.53522713e-02f,
  1.53954893e-01f, -2.09379137e-01f, 8.21033418e-02f, -4.27677959e-01f, -2.75418937e-01f, -2.14176886e-02f, 3.09114724e-01f, 1.09188132e-01f, 2.37824410e-01f, -4.49112445e-01f,
  3.64936382e-01f, 3.02553046e-02f, -1.13627285e-01f, -3.54589939e-01f, 2.02439830e-01f, -2.05964819e-01f, 1.50386378e-01f, -2.07064673e-02f, 1.79490790e-01f, 2.27079585e-01f,
  2.24432915e-01f, 2.48290345e-01f, -6.75440907e-01f, 3.79027277e-01f, -3.61999094e-01f, 9.18166488e-02f, 4.31706250e-01f, 3.03642675e-02f, -1.27892241e-01f, -6.79701030e-01f,
  -4.42573041e-01f, -1.10214457e-01f, -1.35898203e-01f, 2.54891187e-01f, -2.97415674e-01f, -3.44027907e-01f, -3.44604366e-02f, -7.11936429e-02f, -1.78194270e-01f, 2.15265974e-01f,
  -5.43371141e-01f, -4.74150538e-01f, 9.83779505e-03f, -1.54948428e-01f, 9.35772527e-03f, -6.76362514e-01f, -5.16814411e-01f, 3.12412947e-01f, 2.12233037e-01f, -1.26172289e-01f,
  -5.26924841e-02f, -1.88754588e-01f, -2.49025375e-01f, -9.29641500e-02f, 4.50532883e-02f, 4.27110270e-02f, 1.60417985e-02f, -2.85986662e-02f, -1.56189846e-02f, 2.07444150e-02f,
  -3.03005129e-01f, -1.15724720e-01f, 1.30778208e-01f, -8.46632347e-02f, -2.64151871e-01f, 3.14644910e-02f, -1.68217093e-01f, 5.36669381e-02f, 9.46667865e-02f, 9.68740657e-02f,
  1.90701112e-01f, -4.78749117e-03f, -4.12674546e-01f, 1.46341935e-01f, 2.17019290e-01f, -6.28383383e-02f, -9.17723626e-02f, -6.29648119e-02f, 1.78389668e-01f, 2.51853347e-01f,
  3.54108453e-01f, 1.06237188e-01f, 6.50957227e-02f, -1.54378042e-01f, 3.21171850e-01f, -3.82377028e-01f, 3.34678352e-01f, 1.05023593e-01f, 2.83218682e-01f, 1.21590577e-03f,
  -3.00195277e-01f, -4.53830421e-01f, -3.76234412e-01f, -6.62411898e-02f, 3.45292658e-01f, 1.37739759e-02f, 2.23147850e-02f, -1.76640660e-01f, 1.57016352e-01f, 3.93246680e-01f,
  -2.37194076e-01f, 1.29301026e-01f, -9.04504284e-02f, -5.59538305e-01f, -4.38993156e-01f, -4.49853867e-01f, -4.53162670e-01f, -7.35689998e-02f, -1.62188068e-01f, 2.18287155e-01f,
  -1.17982723e-01f, 2.34155253e-01f, 7.74427690e-03f, 1.43860444e-01f, 1.93531346e-02f, -8.76184627e-02f, -1.26494363e-01f, 6.53731897e-02f, -1.28891990e-01f, 2.31817275e-01f,
  2.32922077e-01f, 2.80674011e-01f, 1.08719401e-01f, 1.94769889e-01f, 2.88981169e-01f, -1.31050900e-01f, 1.97187766e-01f, 6.96075857e-02f, 3.42102461e-02f, -6.06412292e-02f,
  -1.96131080e-01f, 4.52493668e-01f, 4.14715856e-01f, 2.35141352e-01f, -2.33566687e-01f, 3.87883544e-01f, -2.02440433e-02f, 3.72336388e-01f, 3.81551534e-01f, 1.07885629e-01f,
  -9.16435719e-02f, 1.50145173e-01f, -1.86054215e-01f, -2.77201325e-01f, -3.05661291e-01f, 3.89935702e-01f, 1.65280893e-01f, 1.29926682e-01f, -2.40763530e-01f, -5.80869675e-01f,
  -2.70476341e-01f, -2.76430726e-01f, -1.67668805e-01f, -3.35880369e-01f, -5.40439188e-01f, -1.60506830e-01f, -4.08053100e-01f, -4.23062056e-01f, -1.16564527e-01f, 1.64559215e-01f,
  1.16823047e-01f, 2.97002792e-01f, -2.53881812e-01f, -3.77714872e-01f, -3.00417632e-01f, 9.08470824e-02f, 3.50215644e-01f, -5.80241084e-01f, -1.77465498e-01f, 3.50537270e-01f,
  -3.34199727e-01f, 3.75945687e-01f, 4.71492559e-01f, -2.38266438e-01f, 1.58165172e-01f, -3.85368913e-01f, 1.00598536e-01f, 7.33387694e-02f, 5.53419031e-02f, 1.03227444e-01f,
  3.28448862e-01f, 2.82179683e-01f, 3.76026779e-02f, 2.94854790e-01f, 2.78748244e-01f, 2.69177586e-01f, 3.24635178e-01f, 3.74744058e-01f, 4.63067204e-01f, -2.02154249e-01f,
  -2.34874323e-01f, -5.23936227e-02f, -2.75749385e-01f, -8.16019252e-02f, -1.01427129e-02f, 4.18179274e-01f, -4.44784202e-02f, -3.25236507e-02f, -3.38501185e-01f, 7.62763545e-02f,
  -1.95364170e-02f, 2.57448196e-01f, -2.67882347e-01f, 2.61721343e-01f, -3.99405509e-01f, 2.02237368e-01f, -1.71928667e-02f, 1.61244154e-01f, 2.91081686e-02f, -2.17695788e-01f,
  2.03611210e-01f, -4.42204088e-01f, 4.17279482e-01f, 2.86868840e-01f, 2.91257739e-01f, 3.24282914e-01f, -3.35231125e-02f, 2.50424176e-01f, 6.05979450e-02f, -7.10509002e-01f,
  -3.75983298e-01f, -3.09885833e-02f, -1.96184427e-01f, -3.44788194e-01f, -8.86206925e-02f, 3.26281667e-01f, 2.12741680e-02f, -3.28186393e-01f, -3.69603604e-01f, -5.70546508e-01f,
  -4.24118876e-01f, -3.01952455e-02f, -5.27849086e-02f, -5.44095457e-01f, 1.09561190e-01f, -4.84838814e-01f, 3.17829251e-01f, -4.67898577e-01f, 1.36825353e-01f, 1.27271548e-01f,
  1.05660282e-01f, 1.27709135e-01f, -2.47927487e-01f, -1.10443264e-01f, 1.35058224e-01f, -4.52067405e-02f, 4.22763713e-02f, -2.35199213e-01f, 2.21651793e-01f, -1.25259355e-01f,
  -4.64413464e-02f, -3.26967865e-01f, -3.92817780e-02f, -9.52228084e-02f, -1.39994413e-01f, 1.97073836e-02f, -2.35456437e-01f, 2.17624366e-01f, 2.11986184e-01f, 2.53981441e-01f,
  -1.35047540e-01f, 2.98683554e-01f, -2.61535585e-01f, -3.16461563e-01f, 3.29273641e-01f, -2.73357302e-01f, -1.16419196e-01f, 1.48315087e-01f, 3.32626194e-01f, 3.97496998e-01f,
  -9.29507315e-02f, -2.20492139e-01f, -2.80504346e-01f, -6.01092577e-01f, 2.15390503e-01f, 3.95886779e-01f, -9.81201977e-02f, -4.01997745e-01f, 1.43349320e-01f, -4.00189608e-01f,
  -3.63575101e-01f, -2.76583970e-01f, -1.96593165e-01f, -5.04978478e-01f, 1.16895996e-01f, 1.09650925e-01f, 2.95210153e-01f, -1.75090641e-01f, -2.66500175e-01f, -2.89586157e-01f,
  2.99013942e-01f, -3.90688419e-01f, 1.65887848e-01f, -3.32899779e-01f, 2.91828632e-01f, -7.38721430e-01f, 4.88139361e-01f, -3.27971429e-01f, 2.47281343e-01f, 2.13731289e-01f,
  -2.10294768e-01f, -5.19598052e-02f, -3.16300035e-01f, -5.53621724e-02f, -7.89665282e-02f, 2.12241367e-01f, -1.23741992e-01f, 8.97036213e-03f, -5.48371449e-02f, -3.81721631e-02f,
  -5.89314103e-02f, -6.98891580e-02f, 2.26883590e-01f, -2.86218762e-01f, -1.96809843e-01f, -3.29650760e-01f, 2.95391440e-01f, 2.37908751e-01f, 1.39912605e-01f, 7.96641572e-04f,
  1.40498161e-01f, 2.01931745e-01f, 9.38509218e-03f, -1.75725102e-01f, 4.28097993e-01f, 2.16039732e-01f, 4.48484033e-01f, 1.20581776e-01f, 1.62079111e-01f, 3.34376574e-01f,
  2.44371712e-01f, -1.25270948e-01f, -1.52963459e-01f, -1.02588519e-01f, 1.78991675e-01f, -5.99231347e-02f, -2.65307128e-01f, 3.27600986e-01f, -3.25682878e-01f, -3.31245333e-01f,
  -5.23466393e-02f, 3.99690092e-01f, -3.25796187e-01f, -2.09313244e-01f, -2.93125063e-01f, 1.94952011e-01f, 2.37845015e-02f, 6.10448420e-01f, -2.93188602e-01f, -3.62609029e-01f,
  -2.93589562e-01f, -3.15706670e-01f, 2.44943779e-02f, -2.28063345e-01f, -4.15652186e-01f, 3.66960883e-01f, -2.85692096e-01f, 2.62634382e-02f, -4.17842805e-01f, -4.08872008e-01f,
  9.04058218e-02f, 2.48549893e-01f, 6.85068741e-02f, 3.96191090e-01f, 1.40745923e-01f, 2.16415495e-01f, -4.36531156e-01f, 2.18953355e-03f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.77421406e-01f, 1.24991819e-01f, 3.63265090e-02f, -8.55894238e-02f, -1.22775957e-01f, 4.78357426e-04f, 2.85444614e-02f, 7.57914484e-02f, 1.01851247e-01f, 2.49883235e-02f,
  2.95305587e-02f, -6.42075837e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    