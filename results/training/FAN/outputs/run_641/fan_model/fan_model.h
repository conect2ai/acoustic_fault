/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.85752794e-01f, 1.72231525e-01f, -1.75504863e-01f, 1.28785431e-01f, -6.80812746e-02f, -2.43724555e-01f, -1.82508320e-01f, -8.92202631e-02f, -9.69350990e-03f, 2.89116986e-02f,
  -2.31183879e-02f, 5.07054180e-02f, -3.72258797e-02f, 2.52307374e-02f, -1.51165187e-01f, 7.07778186e-02f, 1.98956415e-01f, 1.10611701e-02f, -1.34854674e-01f, -6.96320757e-02f,
  1.91387519e-01f, 1.23003110e-01f, 4.69837971e-02f, 7.46807531e-02f, 3.63887817e-01f, 2.51043230e-01f, 2.11520158e-02f, -6.03854936e-03f, -4.03526947e-02f, 4.93558288e-01f,
  -6.02715574e-02f, -1.85412541e-01f, -1.87835936e-02f, 1.73322484e-01f, 5.43523729e-02f, 3.30989771e-02f, 3.54455747e-02f, 3.76265198e-02f, 3.17398533e-02f, 8.37511271e-02f,
  2.53886450e-02f, 1.23162180e-01f, 2.18028184e-02f, 1.08647786e-01f, -4.18634200e-03f, 6.55470639e-02f, -1.11397887e-02f, 5.32434620e-02f, 1.44752013e-02f, -5.75440377e-02f,
  1.97628513e-01f, 1.00207202e-01f, -5.07200025e-02f, -5.93499653e-02f, -1.38647497e-01f, -9.95508730e-02f, -1.40949100e-01f, -8.10424387e-02f, -5.51241264e-02f, 1.27091989e-01f,
  1.04078300e-01f, -1.19095176e-01f, -4.40475568e-02f, -1.66597385e-02f, -8.74784514e-02f, -7.32244998e-02f, -7.93163106e-02f, -4.17235903e-02f, -8.76415428e-03f, -3.90589572e-02f,
  -8.08308646e-02f, -4.35598455e-02f, -1.15721516e-01f, -8.87761712e-02f, 5.79245165e-02f, -9.06115919e-02f, -4.24015298e-02f, -7.36721754e-02f, -3.51566598e-02f, -2.56458689e-02f,
  -3.34650502e-02f, -1.16896793e-01f, -6.61495700e-02f, -2.05525924e-02f, 2.80519389e-02f, -7.18228668e-02f, -1.15800239e-02f, 1.27724288e-02f, -7.06175789e-02f, -1.07340410e-01f,
  6.74797818e-02f, -1.45541787e-01f, 1.40639916e-01f, -2.04304159e-02f, 5.90249337e-02f, -1.78445801e-02f, 3.94312590e-02f, 5.06213643e-02f, 2.11653579e-03f, 1.01715857e-02f,
  1.19084939e-02f, -9.77250114e-02f, -1.54012414e-02f, 6.81919679e-02f, -5.74353188e-02f, 3.32859829e-02f, 2.63198055e-02f, -2.27604117e-02f, -3.47355357e-03f, 4.58301455e-02f,
  7.31891394e-02f, -3.32416445e-02f, -1.12813726e-01f, -5.65823801e-02f, -9.20691248e-03f, 3.74985556e-03f, -2.28078589e-02f, 1.92886144e-02f, -1.04136236e-01f, 2.00442001e-02f,
  -1.87652484e-02f, -3.61678809e-01f, -3.25146854e-01f, -8.32041204e-02f, -9.76676568e-02f, -4.50151190e-02f, -2.92179227e-01f, 8.78128340e-04f, -3.43356542e-02f, -1.91815764e-01f,
  1.53567269e-01f, 2.89457947e-01f, 1.51626602e-01f, 3.33482400e-02f, -9.10758413e-03f, -3.44636440e-01f, -4.24469560e-01f, -1.68455824e-01f, 2.09141716e-01f, 1.89179063e-01f,
  9.07183439e-02f, -1.27552629e-01f, 3.76061872e-02f, -7.11214244e-02f, -1.63717628e-01f, 8.90200306e-03f, -2.21543074e-01f, -1.33309558e-01f, -1.35637686e-01f, -4.45871145e-01f,
  -1.29103065e-01f, -1.55098647e-01f, -3.92859383e-03f, -9.32234302e-02f, -2.49452945e-02f, -8.50594789e-02f, -1.23558119e-01f, -1.76494449e-01f, 9.97201540e-03f, -1.96832687e-01f,
  -4.07599173e-02f, 2.18758639e-02f, -1.32916361e-01f, -9.67082307e-02f, -1.25298768e-01f, -7.51017034e-02f, -2.03506574e-01f, -2.18420252e-01f, -7.85244778e-02f, -1.13446504e-01f,
  -6.21789694e-02f, -8.53842050e-02f, -1.13109954e-01f, -1.22232661e-01f, 2.39566844e-02f, 1.18194921e-02f, -4.86674048e-02f, -7.76973180e-03f, -3.71809490e-02f, -2.78004736e-01f,
  -5.76402545e-02f, 1.38091952e-01f, 1.43835545e-01f, 1.43405825e-01f, 1.23651445e-01f, 1.61562711e-01f, 6.18460476e-02f, 1.45576552e-01f, 1.34840280e-01f, 1.08454682e-01f,
  1.07647620e-01f, 1.31697163e-01f, 6.32322282e-02f, 1.06951587e-01f, 8.10092390e-02f, 6.57539964e-02f, 1.13644011e-01f, 7.77484998e-02f, 1.73407614e-01f, 1.07448973e-01f,
  1.54124528e-01f, 1.77261084e-01f, 2.81822830e-02f, 1.58951551e-01f, 6.22129478e-02f, 6.93988577e-02f, 6.52381480e-02f, 1.78362176e-01f, 1.42677069e-01f, 8.31139460e-02f,
  -1.65064201e-01f, -1.73474476e-02f, -1.99691176e-01f, -1.11219436e-01f, -1.78856447e-01f, -1.53739274e-01f, -1.15467116e-01f, -1.66173160e-01f, -9.98869166e-02f, -6.46683276e-02f,
  -5.11973575e-02f, -1.22457735e-01f, -6.85867593e-02f, -9.35559198e-02f, -7.95081183e-02f, -7.41101652e-02f, -1.60461321e-01f, -6.94208220e-02f, -9.17010605e-02f, -9.79186445e-02f,
  -1.58605933e-01f, -1.88803270e-01f, 3.75611670e-02f, -8.37799460e-02f, -1.82357114e-02f, 1.80517714e-02f, -1.75882638e-01f, -9.26938653e-02f, -3.59443426e-02f, -2.30576456e-01f,
  -3.35855663e-01f, 1.30339816e-01f, 3.04693013e-01f, -1.65971339e-01f, 1.40364408e-01f, 1.60058588e-01f, 1.73182935e-01f, -1.28334880e-01f, -2.46305421e-01f, 1.07425496e-01f,
  2.14154869e-01f, -1.38275728e-01f, -5.53135648e-02f, 6.73584454e-03f, 9.39847808e-03f, 1.00654289e-02f, 9.59817320e-02f, -6.39171451e-02f, -2.43232697e-01f, -1.72577232e-01f,
  -9.71216708e-02f, -6.90799728e-02f, -1.27104953e-01f, -1.50451392e-01f, 4.93521653e-02f, 1.30351596e-02f, 1.76705196e-01f, 1.14003919e-01f, 1.27699971e-01f, -3.37994620e-02f,
  1.95797861e-01f, 1.41489446e-01f, -4.63490933e-02f, -9.19157043e-02f, 1.46573409e-01f, 3.02262348e-03f, -4.85434905e-02f, 2.04501040e-02f, 9.47309509e-02f, -4.12445366e-02f,
  1.05555244e-01f, 5.70301898e-02f, 7.91571010e-03f, 4.71887104e-02f, 2.17702612e-02f, 4.98186098e-03f, -1.70608703e-02f, -2.36784783e-03f, 3.85340527e-02f, 1.05468221e-02f,
  7.21552372e-02f, 1.59205258e-01f, 1.53468728e-01f, 2.35162312e-04f, 8.95984247e-02f, 3.74393761e-02f, 1.84978217e-01f, -3.21858190e-02f, 1.66020274e-01f, -9.77263674e-02f,
  -4.02528457e-02f, -1.38245551e-02f, -3.01617235e-02f, -9.60761607e-02f, -7.89778084e-02f, -7.25100935e-02f, -4.53487560e-02f, 6.94338232e-03f, -9.16213915e-02f, -4.88637723e-02f,
  -5.40992841e-02f, -1.77759398e-02f, -3.44373845e-02f, -3.30989026e-02f, -3.66148353e-02f, -1.03728166e-02f, -5.97696751e-03f, -9.37377214e-02f, -5.29573150e-02f, 3.58095719e-03f,
  -6.92941472e-02f, 2.40292177e-02f, 6.15736004e-03f, -7.97998160e-02f, -4.95085539e-03f, -7.78951421e-02f, 1.49228191e-02f, -1.02206796e-01f, -2.14808770e-02f, 7.43628219e-02f,
  -1.02876790e-01f, 1.35716751e-01f, -1.34344548e-01f, 1.92451533e-02f, 4.85080518e-02f, 2.70221978e-02f, 3.31290253e-02f, 8.21319968e-02f, 5.97264543e-02f, 5.50413271e-03f,
  -6.15571532e-03f, -1.78253613e-02f, 1.95559505e-02f, 4.51533012e-02f, 1.43245468e-02f, -3.54015059e-03f, 6.92905262e-02f, 3.68632302e-02f, 1.04225755e-01f, 6.43038228e-02f,
  6.32750541e-02f, -3.27282809e-02f, -1.98881105e-02f, 1.07416257e-01f, -1.76447742e-02f, -2.06737574e-02f, 9.29581746e-02f, -4.68184464e-02f, 1.06958404e-01f, -8.93762037e-02f,
  8.00204352e-02f, -6.75990134e-02f, -4.21036571e-01f, -1.62624240e-01f, -1.95973143e-01f, -2.90336430e-01f, -2.72882730e-01f, -1.46011353e-01f, -3.63281481e-02f, -1.76441714e-01f,
  1.85214225e-02f, 1.67747717e-02f, -1.38489857e-01f, -1.53120980e-01f, -2.21993446e-01f, -2.66618192e-01f, -3.17326814e-01f, -2.59635359e-01f, -1.82874516e-01f, -2.82015294e-01f,
  -2.26294339e-01f, -1.00728966e-01f, -1.42373279e-01f, -5.34433909e-02f, -8.05340782e-02f, -1.45113125e-01f, -2.98975289e-01f, -1.80824623e-01f, -1.12512842e-01f, -1.45041823e-01f,
  -4.92187411e-01f, -1.85269311e-01f, -9.55585763e-02f, 1.11976443e-02f, -1.01863176e-01f, -1.11587808e-01f, -1.23031242e-02f, -5.63207257e-04f, 1.69397853e-02f, -1.80875063e-01f,
  -8.81555825e-02f, -9.35107470e-02f, -5.09277098e-02f, -1.24370590e-01f, -7.32149333e-02f, -1.21409319e-01f, -4.41890657e-02f, -2.22741246e-01f, -6.33540601e-02f, -8.87840763e-02f,
  1.67521033e-02f, -1.77330375e-02f, -1.32134348e-01f, -1.62061393e-01f, -1.52315304e-01f, 4.40805219e-02f, -1.07798755e-01f, -1.95856504e-02f, -1.32636251e-02f, -1.38030127e-01f,
  1.48590356e-01f, 5.92753999e-02f, -7.30302408e-02f, 6.57925829e-02f, 4.68622521e-03f, -1.54701816e-02f, -9.41746309e-03f, 3.69435665e-03f, 3.93969268e-02f, 1.23229986e-02f,
  -8.64687562e-02f, 9.48722009e-03f, 1.72154214e-02f, -1.13208771e-01f, -4.12020460e-02f, -3.66369002e-02f, 3.55960074e-04f, -3.81732732e-02f, -1.99872218e-02f, 9.00059287e-03f,
  -7.07732588e-02f, -7.70105571e-02f, -6.82599023e-02f, -4.65935692e-02f, -5.40018380e-02f, -6.76002651e-02f, -1.33076906e-01f, -8.21271837e-02f, -6.63679689e-02f, -4.79740910e-02f,
  -1.53936043e-01f, 6.49220422e-02f, -4.34667096e-02f, 8.77180472e-02f, -5.45564555e-02f, 1.05773300e-01f, 9.79614183e-02f, 2.38429587e-02f, 4.22073901e-02f, -5.95070869e-02f,
  4.26377431e-02f, 1.09758722e-02f, -4.93433997e-02f, -1.31543139e-02f, -4.25550826e-02f, -7.13415369e-02f, 2.02194806e-02f, -2.33570989e-02f, 4.40536179e-02f, 4.02748436e-02f,
  -3.15736234e-02f, -3.41235325e-02f, 3.18080559e-02f, -1.26805704e-03f, -6.39245100e-03f, 2.69536674e-02f, -1.13095552e-01f, -4.30338047e-02f, -8.72047246e-02f, -1.03943586e-01f,
  -2.44224831e-01f, 3.07803631e-01f, 9.97440815e-02f, 1.78484380e-01f, 1.79726690e-01f, 1.85716048e-01f, 1.72155932e-01f, 4.83032055e-02f, -4.26286645e-02f, 8.16036612e-02f,
  6.54435679e-02f, -1.17463030e-01f, -1.03515111e-01f, -1.26455128e-01f, -8.23044255e-02f, 1.55333802e-01f, 1.31003693e-01f, -1.86315868e-02f, -2.53013726e-02f, 4.70342115e-02f,
  1.35716841e-01f, 1.52898192e-01f, -8.63827094e-02f, 2.74611693e-02f, 1.02929048e-01f, 5.82748977e-03f, 1.39181674e-01f, 4.72733118e-02f, 8.31523091e-02f, 1.30030036e-01f,
  5.22122048e-02f, 1.60326302e-01f, -5.69654927e-02f, 1.11537445e-02f, 2.99076922e-02f, -2.23152991e-02f, -2.73870379e-02f, 4.76196036e-02f, 2.96580867e-04f, 3.46126617e-03f,
  7.46856071e-03f, 2.74429321e-02f, 6.77066967e-02f, -1.43049825e-02f, 7.64382929e-02f, 6.29026145e-02f, -5.45192249e-02f, -7.69996047e-02f, 6.45518815e-03f, -1.04994169e-02f,
  1.83250248e-01f, 2.05668613e-01f, 4.86581363e-02f, 7.59314448e-02f, -4.81330790e-03f, -3.99112739e-02f, 3.56355757e-02f, -7.75965899e-02f, 1.81830246e-02f, -8.56840983e-02f,
  -4.00579907e-02f, -2.35328041e-02f, -6.21628240e-02f, 3.14886160e-02f, -2.72933040e-02f, -5.28122066e-03f, 1.85131636e-02f, 6.91641048e-02f, -3.11965179e-02f, -5.28499596e-02f,
  -2.34860294e-02f, -1.67376306e-02f, 1.51623357e-02f, 8.51937383e-02f, -1.87862497e-02f, -5.00036590e-02f, 5.49105629e-02f, -1.76575594e-02f, 1.26031702e-02f, 3.40274163e-02f,
  -8.29692930e-02f, -5.36143258e-02f, 3.74254733e-02f, 2.47747451e-03f, -3.01828957e-03f, 9.51717520e-05f, -6.35920018e-02f, -4.10976671e-02f, -9.04157460e-02f, 2.86639780e-02f,
  -9.67636108e-02f, 1.16436891e-01f, 1.96251608e-02f, 4.13873568e-02f, 4.48163366e-03f, -2.08083261e-02f, 1.02771819e-01f, -1.53651531e-03f, 3.46742049e-02f, 7.51143843e-02f,
  4.21494469e-02f, 6.94829300e-02f, 2.59821792e-03f, 4.48590480e-02f, 5.59745915e-02f, 1.40847759e-02f, 1.62425488e-02f, 7.60590332e-03f, 1.22465387e-01f, 5.52551858e-02f,
  1.45571772e-02f, 9.72921867e-03f, 1.22443140e-01f, -2.37419959e-02f, 7.30286539e-02f, 2.99904001e-04f, 1.17645644e-01f, 6.70034587e-02f, -5.48894964e-02f, -3.99359781e-03f,
  1.20403834e-01f, 3.28497082e-01f, 1.20638117e-01f, -9.23408046e-02f, -2.41663512e-02f, 1.53273329e-01f, 2.92712092e-01f, -6.89844042e-02f, -8.08149204e-02f, 1.40544564e-01f,
  1.11076897e-02f, -1.83517069e-01f, -1.83343902e-01f, -1.77963987e-01f, -5.18633127e-02f, 1.36054248e-01f, 2.22033590e-01f, 7.17672408e-02f, -1.97769552e-01f, -2.04450428e-01f,
  -1.36481017e-01f, -9.00029987e-02f, -1.68063611e-01f, -8.96991715e-02f, 5.09016551e-02f, -2.23151874e-02f, 7.08789155e-02f, 6.69565648e-02f, 5.07010780e-02f, 2.92403102e-01f,
  2.57092947e-03f, -4.64044288e-02f, -1.69728860e-01f, -6.84727356e-02f, -1.62946984e-01f, -1.16655864e-01f, -8.37311596e-02f, -2.14430913e-01f, -7.85005465e-02f, -4.27419357e-02f,
  -1.26260042e-01f, -6.92285597e-02f, -1.03193983e-01f, -1.93247244e-01f, -8.26022029e-02f, -1.70788288e-01f, -1.05378605e-01f, -1.32312804e-01f, -1.95389897e-01f, -1.06382772e-01f,
  -8.26340318e-02f, -2.03069262e-02f, 2.46986784e-02f, -1.27751306e-01f, -7.40506053e-02f, -3.47831286e-02f, -1.12427853e-01f, -1.04639634e-01f, -3.16680521e-02f, 5.80647215e-02f,
  2.35949203e-01f, 1.43912166e-01f, 4.77390997e-02f, 1.79821685e-01f, 1.94004521e-01f, 7.44438991e-02f, 1.49000242e-01f, 1.91609532e-01f, 4.67360504e-02f, 1.59083620e-01f,
  1.23787366e-01f, 8.83472636e-02f, 5.46796210e-02f, 9.83706340e-02f, 3.73192281e-02f, 1.65356264e-01f, 1.28984347e-01f, 8.45738947e-02f, 4.62390110e-02f, 1.25694081e-01f,
  1.62691817e-01f, 9.41540301e-02f, 9.77003202e-02f, 2.79429592e-02f, 1.85560346e-01f, 6.17766827e-02f, 1.43111259e-01f, 8.61167535e-02f, 1.99041933e-01f, 2.17791125e-01f,
  -3.17650139e-01f, -2.17690170e-01f, -5.01044840e-02f, -1.23783670e-01f, -7.82778710e-02f, -1.47275180e-01f, -7.60578364e-02f, -1.48440778e-01f, -1.01141490e-01f, -5.92630282e-02f,
  -8.86328742e-02f, -4.25558724e-02f, -9.27470028e-02f, -1.04662269e-01f, -1.73340097e-01f, -6.03720658e-02f, -1.18187703e-01f, 1.72666200e-02f, -1.49004817e-01f, -1.15921780e-01f,
  -9.64624062e-02f, -2.31902883e-03f, 6.52486878e-03f, -5.82626574e-02f, -4.45460454e-02f, -4.23267409e-02f, -1.12160353e-03f, -1.07790552e-01f, 2.83128656e-02f, 4.16809469e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.46849084e-01f, -6.05545521e-01f, 7.60784447e-02f, 2.45446354e-01f, -2.78719980e-02f, 1.42158061e-01f, -5.25592500e-03f, 1.61510020e-01f, 1.19776055e-01f, 9.85142076e-04f,
  -1.52512893e-01f, -3.33833359e-02f, 6.03165366e-02f, 2.60919012e-04f, 1.21083200e-01f, -9.74236950e-02f, 5.23074344e-02f, 1.59504712e-01f, 1.24060258e-01f, -5.08475006e-02f,
  -2.88369924e-01f, -8.19545686e-02f, 1.11284658e-01f, 4.33531916e-03f, -1.83430374e-01f, 1.12870649e-01f, -4.66857702e-02f, -2.37825140e-01f, -2.35852703e-01f, -2.38323271e-01f,
  -8.40935409e-02f, -2.40726247e-01f, 1.11671716e-01f, -1.02213807e-01f, -2.15407640e-01f, 1.15689605e-01f, -1.99104566e-02f, -1.29164100e-01f, -4.75874394e-02f, -8.58280584e-02f,
  -9.11680609e-02f, -1.90309137e-01f, -1.21996850e-01f, -1.26018509e-01f, -1.75351650e-02f, 9.19439271e-02f, -1.59574777e-01f, -7.41081918e-03f, 4.56255898e-02f, -1.45771056e-01f,
  -4.60989267e-01f, -2.50944257e-01f, -4.96790037e-02f, -1.46767557e-01f, -1.83688834e-01f, 9.89816114e-02f, -1.15682691e-01f, -2.11647198e-01f, -1.32287323e-01f, -2.09239587e-01f,
  4.78349999e-02f, -4.00411263e-02f, -1.30796522e-01f, -1.56236412e-02f, 8.60378370e-02f, -1.04615308e-01f, -1.87285960e-01f, -1.66820794e-01f, 2.83291359e-02f, -4.25175909e-04f,
  -1.60152674e-01f, 1.74484447e-01f, 5.06573636e-03f, 9.24315304e-03f, 3.93748991e-02f, 1.07541736e-02f, -7.19181746e-02f, -1.25908405e-01f, -8.13951939e-02f, 2.15046078e-01f,
  3.96714285e-02f, 1.38696581e-02f, 8.17314908e-02f, 5.57994768e-02f, 2.12624773e-01f, -5.76391071e-02f, 1.23092994e-01f, 5.39422175e-03f, -4.32481505e-02f, 1.19591996e-01f,
  1.17799297e-01f, 8.70910808e-02f, 2.66149729e-01f, -2.43653823e-02f, -4.48986143e-02f, 3.62826772e-02f, 1.65025309e-01f, 3.75863314e-02f, 3.59957926e-02f, 6.97988123e-02f,
  -2.01107245e-02f, -1.62713684e-03f, 4.74798419e-02f, 2.14093179e-02f, 1.04605205e-01f, 1.12523615e-01f, -9.39014629e-02f, 1.40187427e-01f, 1.23910345e-01f, 3.26200132e-03f,
  -6.40223026e-02f, 6.81998432e-02f, 2.56053507e-01f, 1.65831983e-01f, -1.33242130e-01f, 2.25452885e-01f, 2.69994363e-02f, 7.95049146e-02f, 8.24346691e-02f, 2.72711992e-01f,
  -9.29807484e-01f, -1.93747059e-01f, 1.42901972e-01f, -3.71834934e-01f, 2.73944765e-01f, 5.84376633e-01f, 8.35133910e-01f, 2.50183403e-01f, 3.22722234e-02f, 2.46242553e-01f,
  -2.47372672e-01f, -4.79083955e-01f, -2.60667741e-01f, -1.25007167e-01f, 2.07230151e-02f, 4.94047582e-01f, 4.22692657e-01f, -2.04723403e-02f, -1.28989201e-02f, 1.36301085e-01f,
  1.78376645e-01f, -2.74516612e-01f, -5.17290890e-01f, -2.00946197e-01f, 8.34199041e-03f, 3.97703201e-02f, 1.04061479e-03f, -1.24792501e-01f, 6.54303953e-02f, -9.24684387e-03f,
  -3.08751136e-01f, -5.76680481e-01f, 1.04836151e-01f, -3.46774727e-01f, -3.20422977e-01f, -3.42726141e-01f, -1.89532474e-01f, -1.84613317e-01f, -7.32584596e-02f, 1.13380916e-01f,
  -2.53731638e-01f, -3.22730839e-01f, -3.72126162e-01f, 7.56382123e-02f, -1.34319603e-01f, 2.23677303e-03f, -1.50685638e-01f, -3.29693019e-01f, -2.78911054e-01f, -1.39780611e-01f,
  1.40059680e-01f, -3.64729434e-01f, -6.06681168e-01f, -1.40106855e-02f, -1.25741512e-01f, -1.59566402e-01f, -1.79680020e-01f, -3.94740015e-01f, -3.11484307e-01f, -2.31670842e-01f,
  1.67011797e-01f, 9.30636004e-02f, 6.03688918e-02f, 1.47733346e-01f, 6.34743124e-02f, -7.84788653e-02f, 5.54496720e-02f, 9.56109986e-02f, -1.58683375e-01f, 1.18093349e-01f,
  -1.20178692e-01f, -1.66186746e-02f, -1.02611624e-01f, 7.21197054e-02f, 2.08416637e-02f, -6.80607930e-02f, 7.41903260e-02f, 3.56887206e-02f, -6.72190934e-02f, 4.66159806e-02f,
  1.16140870e-02f, -7.49060810e-02f, -2.08205298e-01f, 1.38992697e-01f, 1.09281264e-01f, 1.45561444e-02f, -5.26791029e-02f, 6.37115017e-02f, -6.03880100e-02f, 1.18126266e-01f,
  -8.06132182e-02f, -3.28820720e-02f, -4.22095396e-02f, -1.30563267e-02f, -1.15578562e-01f, -1.50825456e-01f, -8.09833780e-03f, -1.06261559e-01f, -1.85860932e-01f, -1.94618940e-01f,
  2.44490542e-02f, -2.89653614e-02f, -9.77765396e-02f, 1.47638112e-01f, 9.71307382e-02f, 1.06470160e-01f, 3.73401232e-02f, 1.32302925e-01f, 3.51472534e-02f, 1.09249495e-01f,
  2.64464080e-01f, 2.97610819e-01f, 1.56584039e-01f, 1.31150186e-01f, 1.41712025e-01f, 1.86236538e-02f, 1.47961602e-01f, 1.65495694e-01f, 1.06166229e-01f, 5.37798405e-01f,
  -3.47187161e-01f, -2.58967221e-01f, -3.08673769e-01f, -3.97816032e-01f, -4.45889533e-01f, -5.15026569e-01f, -4.59348917e-01f, -1.92077190e-01f, -3.84348631e-01f, -4.89007056e-01f,
  3.30975384e-01f, 7.46246278e-01f, 4.89707738e-01f, 5.27476132e-01f, 5.11328697e-01f, -3.77026647e-01f, -6.11123681e-01f, 8.76139663e-03f, 6.07231796e-01f, 8.25887993e-02f,
  -7.57766366e-02f, -1.47431016e-01f, 1.29329907e-02f, -4.26531434e-02f, -4.11399782e-01f, 7.26846904e-02f, -5.09715319e-01f, -4.20749575e-01f, -1.40744254e-01f, -5.89505851e-01f,
  2.59154439e-01f, -3.02568257e-01f, -2.28598118e-02f, 2.69397162e-02f, -1.01425782e-01f, 9.26787630e-02f, 4.61483635e-02f, -1.37631223e-01f, -8.26117769e-02f, -1.38632014e-01f,
  -1.15379967e-01f, 1.69227354e-03f, -2.29240898e-02f, -4.44451496e-02f, -2.10475117e-01f, 5.12794666e-02f, -4.19309661e-02f, 8.87247771e-02f, -6.53125793e-02f, 1.61640216e-02f,
  -9.95757431e-02f, -8.07777196e-02f, 2.72867195e-02f, -5.73836379e-02f, -4.57609966e-02f, 2.00401414e-02f, -2.15421809e-04f, -2.94248573e-02f, -8.07828382e-02f, -3.37103486e-01f,
  -3.04591861e-02f, 8.42139050e-02f, -3.42992097e-02f, -1.44290224e-01f, -1.02088049e-01f, 3.73033285e-02f, 1.36094987e-02f, 2.76236311e-02f, -8.49927962e-02f, 6.71890527e-02f,
  1.00725532e-01f, -1.37128636e-01f, -6.28773049e-02f, -5.14083616e-02f, 5.12771793e-02f, -6.75378293e-02f, 2.40973774e-02f, 4.74302024e-02f, -8.39524642e-02f, -1.27898037e-01f,
  -1.40346177e-02f, -1.50189370e-01f, -8.59382525e-02f, 8.93359929e-02f, 4.09067981e-02f, -1.20654041e-02f, -5.06138764e-02f, 1.17926858e-01f, 4.18016408e-03f, -9.35011834e-04f,
  4.64695394e-01f, 6.18295558e-02f, 4.40334342e-02f, 1.00645289e-01f, -2.17480779e-01f, -2.69498266e-02f, -1.07975841e-01f, 1.40546948e-01f, 5.56265824e-02f, -1.21285148e-01f,
  -7.57308379e-02f, 3.22386585e-02f, -3.26095149e-02f, 2.40548812e-02f, -3.38415802e-02f, -5.88222370e-02f, -1.45928532e-01f, 2.15795025e-01f, -4.13468927e-02f, -8.73242691e-02f,
  -5.45912795e-02f, -1.29557177e-01f, 2.15957150e-01f, 1.37426972e-01f, -3.77460457e-02f, 1.54588312e-01f, 2.20872536e-01f, 1.54301211e-01f, 2.59921402e-01f, 6.91778287e-02f,
  -3.35672498e-01f, 1.54402792e-01f, -3.45047385e-01f, 3.76968056e-01f, 4.66298163e-01f, -7.38840997e-02f, -3.95099878e-01f, -4.38918114e-01f, 2.59375274e-01f, 1.67070985e-01f,
  3.83963495e-01f, 3.35835904e-01f, 2.01760978e-01f, -5.18882275e-03f, -4.23688978e-01f, -2.53314897e-02f, 2.05789402e-01f, -4.02194351e-01f, -6.51022375e-01f, -1.85399115e-01f,
  3.84991497e-01f, -4.88466173e-02f, -2.98041016e-01f, -1.45350114e-01f, 4.39233422e-01f, 1.33096099e-01f, 1.49108976e-01f, 1.21503793e-01f, 1.45025536e-01f, 1.82378963e-01f,
  -1.70944437e-01f, -3.46866101e-01f, -2.33923271e-01f, 1.36568010e-01f, 3.41638438e-02f, -2.13946819e-01f, -2.37330973e-01f, -2.81299025e-01f, 3.38086039e-02f, -1.74214125e-01f,
  1.28258631e-01f, -7.29911029e-02f, 2.73417205e-01f, -5.14945714e-03f, -4.11418863e-02f, -3.84060591e-01f, -2.69523203e-01f, -4.41800684e-01f, -4.67799693e-01f, -2.93057799e-01f,
  8.23702291e-02f, 4.85041961e-02f, -3.28726768e-01f, -1.37132525e-01f, -2.90881813e-01f, -2.08448425e-01f, -4.52083856e-01f, -2.89490253e-01f, -5.02051234e-01f, -5.88181436e-01f,
  -1.48430273e-01f, 7.05341576e-03f, 3.83365452e-02f, 1.14970095e-01f, -1.83488138e-03f, 1.03812464e-01f, 1.40111387e-01f, -4.05039266e-03f, 7.12074190e-02f, -9.96149555e-02f,
  4.06944156e-02f, 4.33722697e-02f, -1.33239195e-01f, 5.58271520e-02f, 2.76160445e-02f, -3.49236988e-02f, -3.35696153e-02f, -1.74128592e-01f, -6.60785660e-02f, -5.76604828e-02f,
  -7.30964094e-02f, 1.75268669e-03f, 2.09584355e-01f, -1.46194324e-01f, 2.41021514e-02f, -1.49052829e-01f, -8.51848274e-02f, -1.48316219e-01f, -6.60931990e-02f, -1.03848167e-01f,
  4.85639311e-02f, -2.15644836e-01f, -9.47440881e-03f, -2.23780826e-01f, 3.23780291e-02f, 1.86021551e-01f, -6.63027167e-02f, -2.23734975e-02f, 1.61554009e-01f, -1.33774027e-01f,
  -1.51151195e-01f, -1.82826236e-01f, 2.18410894e-01f, -7.26287859e-03f, -7.70710260e-02f, -1.12305663e-03f, 1.19860843e-01f, -3.60742919e-02f, 5.39529696e-02f, 8.60024169e-02f,
  -4.21858858e-03f, -2.45477706e-01f, -3.15239467e-02f, -1.00088902e-01f, -4.74772118e-02f, 1.36245629e-02f, -1.45665273e-01f, -1.92571372e-01f, -3.99448544e-01f, -2.78243661e-01f,
  1.59399584e-01f, 2.43834123e-01f, 3.34267408e-01f, -1.29250765e-01f, -7.61739491e-03f, -2.02930465e-01f, -2.32268050e-02f, -1.35565311e-01f, -2.41428494e-01f, 1.55084496e-02f,
  3.25839445e-02f, -1.29736587e-01f, -1.10442024e-02f, -3.80490050e-02f, 2.46462360e-01f, 2.22747624e-01f, 2.59445459e-01f, 5.16254723e-01f, 1.65053397e-01f, 4.57852371e-02f,
  1.46589607e-01f, 2.02179119e-01f, 2.24350378e-01f, 1.85752869e-01f, 1.34668246e-01f, -1.71776190e-01f, -1.27032679e-02f, 2.12479949e-01f, 2.06530690e-01f, 5.24131298e-01f,
  1.33757979e-01f, -1.19276345e-01f, -3.49637240e-01f, -5.94382845e-02f, 1.63621306e-02f, -1.16606057e-02f, -3.57488953e-02f, -1.88568801e-01f, -3.35520431e-02f, 7.87850320e-02f,
  6.55842423e-02f, 6.19025901e-02f, 8.31680894e-02f, 2.42265891e-02f, -9.36165731e-03f, -1.43095687e-01f, 8.24513361e-02f, 2.80006081e-01f, -5.97369261e-02f, 1.16183259e-01f,
  6.60711601e-02f, -3.10711879e-02f, 1.12658041e-02f, -1.73246726e-01f, -5.78593686e-02f, -6.71171397e-02f, 4.45546489e-03f, 3.30931284e-02f, -1.52291194e-01f, -1.92850046e-02f,
  -9.76598412e-02f, 1.35607466e-01f, 1.04270265e-01f, 1.94584802e-01f, 1.08788662e-01f, 2.32389085e-02f, 2.71799881e-02f, 1.07251666e-01f, 1.44744679e-01f, 9.07074809e-02f,
  -6.89952895e-02f, -1.57967284e-01f, -3.63525189e-02f, -2.14125067e-02f, -1.37460366e-01f, -1.30151123e-01f, -6.37256354e-02f, -7.91446045e-02f, -6.96304739e-02f, -1.02402143e-01f,
  6.35955706e-02f, -3.21448781e-02f, -1.98612601e-01f, -1.76462270e-02f, -1.82594359e-01f, -1.10909984e-01f, -3.55239436e-02f, -1.65826738e-01f, -1.48581445e-01f, -1.39126271e-01f,
  -4.24485356e-01f, -1.79896355e-01f, -6.84837252e-02f, 9.02813599e-02f, -1.11242225e-02f, 1.50016854e-02f, -1.70859575e-01f, -7.97014162e-02f, -1.54143110e-01f, -3.39157492e-01f,
  -6.73023015e-02f, -4.47089486e-02f, -9.08727795e-02f, 2.21734233e-02f, -3.53687733e-01f, -3.91330034e-01f, -7.33870789e-02f, -8.89158845e-02f, 2.31785867e-02f, 1.12676494e-01f,
  1.52545646e-01f, -5.26265621e-01f, -3.85537535e-01f, -4.24756140e-01f, -3.20789635e-01f, -6.30448580e-01f, -2.89397299e-01f, -4.87334043e-01f, -5.89394271e-01f, -3.91417205e-01f,
  8.73802185e-01f, 4.38557178e-01f, 3.50376278e-01f, 2.45417967e-01f, 4.78809029e-02f, 2.73107141e-01f, 3.91699016e-01f, 2.61308521e-01f, 7.51844272e-02f, 3.04010659e-01f,
  1.49637505e-01f, -7.90893734e-02f, -8.25121179e-02f, -4.20515239e-03f, 5.74062839e-02f, 7.24847242e-02f, -6.74376711e-02f, -2.23502461e-02f, 6.14854731e-02f, 9.17851850e-02f,
  -2.58812439e-02f, 1.50130168e-01f, 8.74531493e-02f, 1.86978579e-01f, 1.51168495e-01f, -8.15046802e-02f, 1.00932367e-01f, 2.11361125e-01f, 1.53179854e-01f, 1.97335631e-01f,
  -6.73914375e-03f, 4.76308376e-01f, -2.04985261e-01f, -2.16132879e-01f, -5.82417361e-02f, -3.72727867e-03f, 2.84691732e-02f, -1.00704022e-02f, -1.27897277e-01f, -1.18585907e-01f,
  -1.83593228e-01f, 3.01131085e-02f, 1.51847750e-01f, 2.03293368e-01f, 8.58258307e-02f, 4.73593622e-02f, 1.59365058e-01f, -3.27959470e-02f, 5.56047708e-02f, -2.29167845e-02f,
  3.28682698e-02f, 8.01497623e-02f, 1.08746029e-01f, -1.58305895e-02f, 9.64720473e-02f, -1.45326123e-01f, -1.76058337e-02f, -1.46989226e-02f, -4.85296547e-02f, 1.75118968e-01f,
  -3.31501067e-01f, -1.52661324e-01f, 1.05863348e-01f, 7.60154203e-02f, 3.19020860e-02f, 3.88721526e-02f, 5.38585298e-02f, 7.45076612e-02f, 1.58705071e-01f, 2.73511648e-01f,
  -7.22154528e-02f, 2.80240062e-03f, 1.77339107e-01f, 1.42337129e-01f, -9.95899588e-02f, 1.71812952e-01f, 2.37818733e-01f, 2.17629336e-02f, 2.84680855e-02f, -8.14828724e-02f,
  1.36458904e-01f, 4.32850718e-02f, 1.08064011e-01f, 3.04935187e-01f, -9.67179053e-03f, -7.62723163e-02f, 9.32641327e-02f, 1.05616465e-01f, 1.77229848e-02f, -6.48604408e-02f,
  -4.86086130e-01f, -1.77850559e-01f, 1.18809963e-04f, 8.25672150e-02f, -2.12924723e-02f, 8.35604034e-03f, -1.00702859e-01f, -2.47108996e-01f, -2.25642622e-01f, -1.64720967e-01f,
  -1.79417115e-02f, 4.85504232e-03f, -4.27541286e-02f, 2.47307159e-02f, -1.26009053e-02f, -2.41269786e-02f, 9.02477354e-02f, 3.72631364e-02f, -1.35747701e-01f, -3.76959629e-02f,
  -4.47445065e-02f, -7.01125860e-02f, -1.35515392e-01f, -9.22288820e-02f, -1.03198089e-01f, -2.26016238e-01f, -2.34279156e-01f, -1.80733595e-02f, -1.02593586e-01f, -1.13721438e-01f,
  -5.65199137e-01f, 3.20908248e-01f, 9.89013240e-02f, 5.40176928e-02f, -3.08191091e-01f, -4.34779316e-01f, -1.82341918e-01f, -7.03057349e-02f, 4.04032832e-03f, 4.18081433e-01f,
  1.47993013e-01f, -1.01034202e-01f, 2.37549275e-01f, -2.12999791e-01f, -2.43883714e-01f, 2.27868289e-01f, -1.48638263e-02f, -3.96303564e-01f, -7.50168741e-01f, -5.68502665e-01f,
  -3.85958701e-01f, -2.24302307e-01f, -3.59107614e-01f, -1.69547945e-01f, 2.12852463e-01f, -1.84757873e-01f, 2.09270656e-01f, -1.40784502e-01f, -2.60987580e-01f, 2.79268175e-02f,
  2.82070547e-01f, -3.01779777e-01f, -2.97583658e-02f, -2.51767516e-01f, 1.84489086e-01f, 2.55754367e-02f, 1.59445324e-03f, 1.80791318e-01f, 4.31559831e-02f, 2.66507566e-01f,
  -3.98063548e-02f, 1.30365579e-03f, -2.12480091e-02f, 6.00700378e-02f, 2.41127592e-02f, -1.09173380e-01f, 1.06852725e-01f, -5.77286854e-02f, -2.91175628e-03f, 1.48827851e-01f,
  -6.04542121e-02f, -2.30320603e-01f, -1.43429022e-02f, 2.60549262e-02f, -5.16427234e-02f, -2.55070508e-01f, 1.09160140e-01f, -1.53842226e-01f, -2.01141730e-01f, 2.66250938e-01f,
  4.42538932e-02f, 2.52384454e-01f, -2.76509859e-02f, 1.09139169e-02f, 1.50219113e-01f, 8.98666009e-02f, 5.45889921e-02f, 8.07138979e-02f, -3.77383712e-03f, 8.78400952e-02f,
  1.73484355e-01f, 4.87740561e-02f, 4.27451804e-02f, -1.92616321e-02f, -9.42559317e-02f, -4.70680073e-02f, -1.48961216e-01f, 1.52047733e-02f, 7.68619403e-02f, 1.37874722e-01f,
  -5.85919581e-02f, -3.53691466e-02f, 2.91971327e-03f, 6.02245331e-02f, -1.20553233e-01f, -1.77170709e-03f, -1.61926616e-02f, -1.21583775e-01f, -3.58288400e-02f, -9.26322863e-02f,
  2.53218085e-01f, -4.71812129e-01f, 2.88930655e-01f, -9.45522934e-02f, 4.27462347e-02f, 7.64979124e-02f, 8.72435868e-02f, -4.57717665e-02f, -2.24638786e-02f, -5.81282452e-02f,
  -1.83731899e-01f, 7.29577094e-02f, 1.01183586e-01f, 1.18864387e-01f, 2.78182589e-02f, -7.02782944e-02f, 6.34563118e-02f, 5.22339232e-02f, -1.39213815e-01f, 1.14779837e-01f,
  1.18874371e-01f, 3.31911333e-02f, 2.00673923e-01f, 1.79561153e-01f, -2.89635863e-02f, -1.36302143e-01f, 1.12341292e-01f, 1.26616895e-01f, -5.90357482e-02f, 5.56759655e-01f,
  1.25452489e-01f, 1.61265790e-01f, -7.09999144e-01f, 4.63648021e-01f, -1.08830526e-01f, -2.58770525e-01f, -2.13784635e-01f, 2.44286388e-01f, 4.39664930e-01f, 1.45588428e-01f,
  -2.72646636e-01f, -2.76441485e-01f, -1.42765403e-01f, -1.82958290e-01f, -4.10317808e-01f, -1.12661421e-01f, -2.14941189e-01f, -6.41480088e-01f, -5.76239169e-01f, -2.56826580e-02f,
  1.64071232e-01f, 1.92757696e-01f, -3.81258093e-02f, -8.63683075e-02f, 1.97342455e-01f, 1.74995475e-02f, 5.73573001e-02f, -8.53253007e-02f, -2.12380305e-01f, -2.02641889e-01f,
  -5.30364215e-01f, -5.18909376e-03f, -2.33813852e-01f, -1.03332721e-01f, -9.42584425e-02f, -1.85135737e-01f, -2.05545187e-01f, -1.47318885e-01f, -1.16112560e-01f, -1.71376914e-01f,
  -2.68500388e-01f, -1.46725595e-01f, -2.77860284e-01f, 3.88223454e-02f, -1.32453060e-02f, -3.58136773e-01f, 2.09396165e-02f, -2.66162992e-01f, -1.85712203e-01f, -1.57364383e-01f,
  -2.29555726e-01f, -4.01002854e-01f, -4.36292261e-01f, -9.01220366e-02f, -1.23933390e-01f, -2.23887950e-01f, -1.15409732e-01f, -1.05932131e-01f, -2.32574239e-01f, 2.36989871e-01f,
  2.49782056e-02f, 1.11988381e-01f, -1.55261472e-01f, 7.58051351e-02f, 1.72758043e-01f, -5.51667660e-02f, 9.83958244e-02f, -4.11745049e-02f, -1.26274854e-01f, -7.65127391e-02f,
  -2.03075223e-02f, 7.10870326e-02f, -3.68214697e-02f, 7.75455451e-03f, -7.90126622e-02f, -2.07125917e-02f, -1.14134789e-01f, -6.81578815e-02f, -3.04240696e-02f, 1.20583177e-02f,
  -1.45538419e-01f, -9.10665542e-02f, -1.42137706e-02f, 6.24541305e-02f, -3.89939807e-02f, -1.08982429e-01f, 2.96005737e-02f, 4.97573167e-02f, 1.83419928e-01f, -2.24188846e-02f,
  4.39260453e-01f, -1.66741699e-01f, 5.89543842e-02f, -1.63167089e-01f, -6.50312826e-02f, 1.04556471e-01f, 4.86648083e-02f, -1.33214109e-02f, 3.72439884e-02f, -5.69144450e-02f,
  -1.80960223e-01f, -1.10240340e-01f, 9.01130214e-02f, -8.22531432e-02f, -1.50172308e-01f, 2.59462016e-04f, 1.97327077e-01f, -9.70279202e-02f, -1.03680365e-01f, 1.28502399e-01f,
  2.95241743e-01f, -2.72346251e-02f, -5.48045002e-02f, 8.31763297e-02f, 6.67374628e-03f, -1.53320298e-01f, -1.52265998e-02f, 4.29968387e-02f, -1.42933041e-01f, 3.81227732e-01f,
  -8.99573982e-01f, -1.41059712e-01f, -1.94182694e-01f, -2.33798251e-01f, 1.29174903e-01f, 1.16196861e-02f, -7.85547718e-02f, -2.88155705e-01f, -1.95543081e-01f, -1.68594569e-01f,
  2.70073712e-02f, 2.15641141e-01f, 2.28487521e-01f, 2.10770145e-01f, 1.91695523e-02f, 6.11186400e-02f, 1.48886546e-01f, 1.52889013e-01f, 1.64614707e-01f, 1.10498138e-01f,
  5.10915577e-01f, 3.79099905e-01f, 8.86620432e-02f, -1.00892615e-02f, 1.74339086e-01f, 1.95394844e-01f, 3.23412828e-02f, 9.59163606e-02f, 9.09101367e-02f, 2.15090156e-01f,
  5.17455637e-01f, -4.37353164e-01f, -7.97616318e-02f, -7.72464275e-02f, -2.36481093e-02f, -2.33314231e-01f, 1.41277770e-02f, -8.61529186e-02f, -2.13630050e-01f, -1.10243917e-01f,
  -1.10701531e-01f, -2.66887695e-01f, 9.33949277e-02f, 1.68286771e-01f, -2.20957082e-02f, -1.50540441e-01f, -4.46372740e-02f, -2.10074887e-01f, -3.01056176e-01f, -1.10627683e-02f,
  2.59607136e-01f, -1.06447309e-01f, -3.50709021e-01f, -1.50392890e-01f, -1.65075004e-01f, -2.60993410e-02f, -3.82046476e-02f, -1.67754605e-01f, -2.41935104e-01f, -7.02337325e-02f,
  -1.58996925e-01f, -8.20874423e-02f, 1.67064115e-01f, 1.26359304e-02f, 6.47052079e-02f, 1.38848245e-01f, 1.07461207e-01f, 2.21290842e-01f, 2.48080254e-01f, 2.00637281e-01f,
  -6.60192892e-02f, -2.06193365e-02f, 6.54963329e-02f, -4.01542187e-02f, 1.00962356e-01f, 8.02662876e-03f, -3.37144770e-02f, 8.50278512e-02f, -1.13495864e-01f, -1.45824060e-01f,
  -1.53463185e-01f, -1.26282319e-01f, 1.62274063e-01f, 1.27444342e-01f, -1.36178553e-01f, -9.27675590e-02f, -1.12951286e-01f, 7.35411514e-03f, 5.60888536e-02f, -1.51312858e-01f,
  3.97350907e-01f, -3.68931592e-01f, -6.04076385e-02f, -1.20724633e-01f, -1.01749405e-01f, -9.94017255e-03f, 1.48975909e-01f, -1.63100690e-01f, -5.55777587e-02f, -6.82447152e-03f,
  -1.26230970e-01f, -1.38636470e-01f, 6.38962388e-02f, 5.41618131e-02f, 3.03281508e-02f, 4.64729741e-02f, 1.69502124e-01f, 1.56719387e-02f, -6.77865371e-02f, -5.76698519e-02f,
  -5.36515862e-02f, -1.32939711e-01f, 1.75275207e-02f, 6.40702667e-04f, -1.98649541e-02f, 7.10766017e-02f, 1.87330514e-01f, -1.89204812e-02f, -4.96940129e-02f, -1.47690400e-04f,
  -7.89394140e-01f, -6.04048848e-01f, -2.81360120e-01f, -6.00992560e-01f, -1.13371022e-01f, 2.07037449e-01f, -6.51032627e-02f, 5.30711971e-02f, -2.81259596e-01f, -4.27702576e-01f,
  -1.55291647e-01f, -1.04107454e-01f, -3.25773448e-01f, 1.09363474e-01f, -1.88552178e-02f, -3.21670592e-01f, -2.73171902e-01f, -2.98746284e-02f, 4.35520679e-01f, 4.93223578e-01f,
  6.43898994e-02f, -1.60622790e-01f, 8.18509907e-02f, 4.64307284e-03f, -6.09995067e-01f, -2.50276774e-01f, -4.25896496e-01f, -2.43641227e-01f, -9.95837376e-02f, -5.51917017e-01f,
  -5.38871229e-01f, -1.40590131e-01f, 2.88758427e-01f, 1.99645951e-01f, -1.74781501e-01f, 8.27987641e-02f, 9.19042081e-02f, -5.38305417e-02f, 2.61919992e-03f, -7.71012949e-03f,
  -1.23659529e-01f, 1.25681520e-01f, -1.47162043e-02f, 1.03994936e-01f, 1.17539816e-01f, 3.05918660e-02f, 8.76199901e-02f, 1.26943737e-01f, -8.07572529e-02f, 1.12862401e-01f,
  -7.46220201e-02f, -8.05074647e-02f, -1.22366965e-01f, 7.96504617e-02f, 1.17698878e-01f, 1.75022960e-01f, 1.49572894e-01f, 2.41303980e-01f, 2.46928275e-01f, -4.82556134e-01f,
  7.15914071e-02f, -1.36997085e-02f, 1.36810526e-01f, 5.87610453e-02f, -7.29346927e-03f, 2.02130992e-02f, -3.87783460e-02f, -3.35614965e-03f, 1.52543709e-01f, -3.63568664e-02f,
  1.31154940e-01f, 1.38054537e-02f, 1.09239243e-01f, -7.42237344e-02f, 6.01109071e-03f, -7.62638971e-02f, -1.60299227e-01f, -1.24684572e-01f, 4.19785678e-02f, 2.33286731e-02f,
  4.29531075e-02f, -9.32681337e-02f, -5.09274118e-02f, 1.13179296e-01f, 1.39502669e-02f, -7.00384453e-02f, -6.05413765e-02f, 2.39392415e-01f, -9.63267833e-02f, -8.50692689e-02f,
  -4.12046969e-01f, 4.38492656e-01f, -5.00539720e-01f, -1.01503229e-03f, -2.93264031e-01f, 5.92155196e-03f, -2.50593632e-01f, 4.99315783e-02f, -2.27143779e-01f, -2.84467787e-02f,
  1.53394431e-01f, -1.89033970e-01f, -1.73295021e-01f, 1.22916624e-01f, 1.39519855e-01f, -4.66872305e-02f, -1.20695874e-01f, -2.52816319e-01f, 9.98171195e-02f, 3.20020877e-02f,
  -1.46906704e-01f, -2.01852351e-01f, -2.17205539e-01f, -3.57264578e-01f, -1.88898250e-01f, -1.97829083e-01f, -4.64954525e-02f, -1.62916973e-01f, -1.64211839e-01f, -5.99565685e-01f,
  4.07948226e-01f, -8.32682788e-01f, 1.20235138e-01f, 8.42681527e-02f, 8.53686482e-02f, 2.56675452e-01f, -3.15261334e-02f, -2.78658837e-01f, -2.15479523e-01f, -2.73150295e-01f,
  -6.28888607e-01f, -3.47585380e-01f, -2.53658473e-01f, -2.41817772e-01f, -9.97457877e-02f, 6.68736026e-02f, 4.11373913e-01f, 5.47513247e-01f, 5.47469676e-01f, 8.35249946e-02f,
  -2.22387061e-01f, -7.82832205e-02f, 1.25825822e-01f, -8.62649083e-02f, -3.07354420e-01f, -1.84693597e-02f, -1.71627358e-01f, -2.64371485e-01f, -1.26865208e-01f, -3.84064704e-01f,
  1.31712869e-01f, -2.39227727e-01f, -2.92235035e-02f, -1.63383365e-01f, -1.64729685e-01f, -1.39696777e-01f, 1.89253055e-02f, -4.66846228e-02f, -4.89757769e-02f, -2.46638339e-02f,
  -1.08878247e-01f, -3.82166281e-02f, -5.88731132e-02f, -8.74063000e-02f, 4.56217416e-02f, -1.35266557e-01f, -1.39882624e-01f, -5.31372130e-02f, -1.58390701e-01f, -1.27578497e-01f,
  -3.09100300e-01f, -4.91568632e-02f, 1.78701609e-01f, 9.31663904e-03f, -8.96365643e-02f, 1.71698600e-01f, -1.64587781e-01f, -2.73744594e-02f, -2.57249959e-02f, -4.50853705e-02f,
  -7.68356174e-02f, 7.32685998e-02f, 1.54357245e-02f, -2.40072329e-02f, 8.08208361e-02f, 1.92686424e-01f, 1.45131022e-01f, 1.18513614e-01f, -9.29795131e-02f, -5.93922548e-02f,
  4.00221422e-02f, -5.28477654e-02f, 1.40299341e-02f, -2.57237107e-02f, -1.78914830e-01f, -7.42262080e-02f, 4.69561405e-02f, -1.21134564e-01f, -3.69956493e-02f, -1.89007353e-02f,
  -5.81533648e-02f, -8.57918710e-03f, 4.49507236e-02f, -4.08587828e-02f, -4.79742400e-02f, 5.71199432e-02f, -9.70697328e-02f, -1.31740138e-01f, -5.84384724e-02f, -6.02857172e-02f,
  2.74314862e-02f, 4.53919955e-02f, 5.28145432e-02f, -4.57702467e-04f, -2.94421259e-02f, -1.57663211e-01f, -9.68007222e-02f, -2.70389020e-02f, 1.86686181e-02f, 8.76428280e-03f,
  -1.50231615e-01f, 1.56610031e-02f, -8.28503743e-02f, -1.12874106e-01f, 1.74041912e-01f, -1.45326387e-02f, -1.32862553e-01f, 5.79405716e-03f, -2.78028846e-02f, -7.53459856e-02f,
  -1.50391340e-01f, 1.57483414e-01f, 3.04227531e-01f, 2.32610926e-01f, -1.53085375e-02f, 3.48220348e-01f, 1.27628043e-01f, 1.58604026e-01f, 3.26889873e-01f, 2.87413478e-01f,
  -2.80542523e-01f, 6.32732987e-01f, 4.35097635e-01f, -8.29521790e-02f, 5.72640359e-01f, 3.50700706e-01f, 4.62773442e-01f, -1.19841531e-01f, -1.95947856e-01f, 4.30361837e-01f,
  5.66841066e-01f, -1.09053850e-01f, 2.14330554e-02f, -2.53213823e-01f, -3.58064920e-01f, 1.90302208e-01f, 7.37366080e-02f, -3.64532471e-01f, -5.64072967e-01f, -3.66641939e-01f,
  -1.02037326e-01f, -3.04966241e-01f, -4.93278384e-01f, -3.65730584e-01f, 6.30069673e-02f, -1.86885580e-01f, 1.87175423e-01f, 3.33572887e-02f, 2.53270000e-01f, 1.74736738e-01f,
  4.00584459e-01f, 4.70300257e-01f, -2.99349338e-01f, -7.91212320e-02f, 1.43969089e-01f, -1.87665999e-01f, -2.76374612e-02f, -1.26151726e-01f, 2.16159858e-02f, -2.37775669e-02f,
  2.79649794e-01f, -2.68767308e-02f, 1.59450635e-01f, -1.60531700e-01f, -1.85043499e-01f, -1.16761714e-01f, -1.65220827e-01f, -3.35978806e-01f, -4.08103228e-01f, -1.69014320e-01f,
  3.47721539e-02f, 2.49884576e-01f, 1.84012979e-01f, -4.82143275e-02f, -2.04666689e-01f, -2.25810155e-01f, 8.26579705e-02f, -2.33154401e-01f, -2.28512093e-01f, -4.05152202e-01f,
  -6.92073442e-03f, 1.07892059e-01f, 2.00642288e-01f, 8.83436948e-02f, -1.31908627e-02f, 3.75391990e-02f, 3.83926220e-02f, 2.14910153e-02f, -1.83659762e-01f, -1.26654550e-01f,
  5.00023253e-02f, 1.13261642e-03f, -1.70070678e-01f, 1.32874802e-01f, -5.07825613e-02f, 5.04077896e-02f, 1.99452359e-02f, -1.14682287e-01f, 1.12442672e-02f, -1.33642077e-01f,
  -1.15504347e-01f, -8.69761035e-02f, -2.99742091e-02f, -1.68512419e-01f, 1.02294669e-01f, 1.69153735e-01f, 4.07653563e-02f, 7.41075203e-02f, -6.07816130e-02f, 2.04828292e-01f,
  -4.14152265e-01f, 2.62588382e-01f, -6.82491660e-02f, -9.05986279e-02f, 1.11443542e-01f, 1.08083291e-02f, 2.61116415e-01f, 6.52794689e-02f, 3.39952521e-02f, -9.14722830e-02f,
  1.28414109e-01f, -3.70925926e-02f, -3.20520112e-03f, -2.50613713e-03f, -1.07690178e-01f, 1.11949313e-02f, 4.78121787e-02f, -1.28684431e-01f, -2.96391189e-01f, -3.33176218e-02f,
  -1.93641648e-01f, -3.64473730e-01f, -4.17401195e-01f, -1.87610745e-01f, -1.86730325e-01f, -2.38055781e-01f, -5.83259650e-02f, -1.44067287e-01f, -2.62048990e-01f, -4.31665152e-01f,
  -5.30563056e-01f, -1.04799099e-01f, -9.41006839e-02f, 2.93910414e-01f, 4.17612702e-01f, 4.32542026e-01f, 3.15162688e-01f, 1.36944041e-01f, 8.23078081e-02f, 2.10005432e-01f,
  2.02550128e-01f, 2.81273127e-01f, 2.63564307e-02f, 1.58768490e-01f, 1.72088221e-01f, 2.67787725e-01f, 4.31317657e-01f, -2.26390157e-02f, -1.49868339e-01f, 2.64491856e-01f,
  2.92003512e-01f, 2.77257301e-02f, -1.85804009e-01f, 4.39880975e-02f, 2.19973579e-01f, 1.48735479e-01f, 2.18310699e-01f, 1.75891832e-01f, 1.81513831e-01f, 2.69488603e-01f,
  7.81508535e-02f, -1.47888988e-01f, 3.99065800e-02f, 3.12130488e-02f, -1.62421897e-01f, -2.21948594e-01f, 1.84379192e-03f, -1.12732343e-01f, -7.22215325e-02f, -9.27683264e-02f,
  5.13878390e-02f, -1.46748468e-01f, -1.01980403e-01f, -3.25668342e-02f, -1.24119915e-01f, -2.01578975e-01f, -1.42771125e-01f, -6.20971806e-03f, 2.16106042e-01f, 7.25079253e-02f,
  2.07524493e-01f, 1.43357396e-01f, 2.67485827e-01f, 1.21453077e-01f, 1.21168241e-01f, -1.01186242e-02f, -1.77443504e-01f, 6.47379411e-03f, -1.61931769e-03f, -6.59076646e-02f,
  1.27419010e-01f, 1.15593143e-01f, 9.31408480e-02f, 6.64252834e-03f, -9.04948041e-02f, 1.56120490e-02f, 1.26309693e-01f, 1.23802975e-01f, 1.18523121e-01f, -2.37546172e-02f,
  -2.00017095e-02f, 1.94373488e-01f, 8.97164345e-02f, -3.93402800e-02f, -2.26181727e-02f, 6.91869706e-02f, 3.29888165e-02f, 4.23609726e-02f, -1.99438334e-02f, -1.01174697e-01f,
  5.96856251e-02f, 7.10242167e-02f, -1.26315594e-01f, -5.63196838e-02f, 3.70170549e-02f, 1.55761033e-01f, 1.52571663e-01f, -5.80120273e-02f, 4.67933938e-02f, -5.89875989e-02f,
  3.88193548e-01f, 1.49181828e-01f, 5.64919487e-02f, 1.27606973e-01f, 8.25579762e-02f, -2.29435608e-01f, 5.59054166e-02f, -4.27911393e-02f, -5.54894879e-02f, -6.43235222e-02f,
  1.83772184e-02f, -2.88121492e-01f, -1.09912001e-01f, -1.56928087e-03f, -2.80795753e-01f, -7.24152550e-02f, 4.60638404e-02f, 1.49395019e-01f, 1.18346989e-01f, 1.03823967e-01f,
  -4.14235964e-02f, 1.00729600e-01f, 8.89161825e-02f, -5.09523042e-02f, -1.71941184e-02f, 7.06705451e-02f, -1.21289380e-01f, -1.50326520e-01f, -1.45380780e-01f, -1.05215333e-01f,
  6.21604443e-01f, -3.06463212e-01f, -1.34267807e-01f, 2.68448234e-01f, -1.50862619e-01f, -3.09855133e-01f, -5.45295358e-01f, -1.98934406e-01f, 1.14144862e-01f, 1.15293004e-01f,
  1.59296945e-01f, 5.06193817e-01f, 3.46790522e-01f, 2.74441332e-01f, 4.81226407e-02f, -1.31957144e-01f, 7.47362152e-02f, 1.81583747e-01f, 1.69956505e-01f, 1.51332080e-01f,
  2.69482911e-01f, 4.35675196e-02f, 2.15803459e-01f, 1.93868414e-01f, 7.03691989e-02f, 2.26842567e-01f, -7.58579373e-02f, 9.19755399e-02f, 2.23847091e-01f, 2.89329946e-01f,
  1.00919023e-01f, -7.15408027e-02f, 2.11124375e-01f, 2.20145255e-01f, -8.15827698e-02f, -3.87388878e-02f, 2.62282733e-02f, -1.44905269e-01f, -1.08705722e-01f, -7.90295452e-02f,
  3.99501920e-02f, 7.94750825e-02f, -3.10073420e-02f, 1.33054964e-02f, -1.16805196e-01f, -6.42769411e-02f, 7.17739835e-02f, 6.85101226e-02f, 1.40811518e-01f, -1.12240762e-01f,
  1.22410439e-01f, -3.23491879e-02f, -1.23921663e-01f, -8.21705014e-02f, -7.15510249e-02f, 2.06995010e-01f, -1.29938245e-01f, -8.91122222e-02f, -5.71283214e-02f, -5.61582223e-02f,
  2.43797421e-01f, 1.50077373e-01f, 1.57540545e-01f, 5.25439531e-02f, 1.56144023e-01f, 6.57766461e-02f, 5.81198260e-02f, 5.64126670e-02f, 6.41002730e-02f, -4.43650894e-02f,
  2.42265575e-02f, 8.23604912e-02f, 5.58092408e-02f, -1.11936167e-01f, 1.13019511e-01f, -1.10510096e-01f, -3.50487791e-02f, -2.81567536e-02f, -6.69426285e-03f, 4.33189869e-02f,
  1.66783351e-02f, -2.76893098e-02f, 9.21864249e-03f, -4.56504300e-02f, 1.19225979e-02f, 1.74214840e-02f, 3.08216754e-02f, 5.40627800e-02f, -1.18398070e-01f, -2.10878886e-02f,
  -4.25507873e-01f, 2.34994158e-01f, 1.98067576e-01f, -1.07360356e-01f, -5.51013164e-02f, -9.60538909e-02f, 6.89949468e-02f, -4.19332832e-02f, -7.01973438e-02f, -1.43319860e-01f,
  -1.22251637e-01f, -3.62514541e-03f, 5.31635955e-02f, -1.20543770e-01f, -1.05687499e-01f, -1.11168258e-01f, 2.04079319e-02f, 4.20108363e-02f, 7.30766505e-02f, -1.42742857e-01f,
  -1.20932631e-01f, -9.34154764e-02f, -8.96848366e-02f, -3.12715583e-02f, -9.44493786e-02f, 1.87563047e-01f, -1.21137299e-01f, -1.45978987e-01f, -4.40868624e-02f, -2.55339354e-01f,
  4.88439739e-01f, -2.05838811e-02f, -1.04660201e+00f, 3.06166887e-01f, -4.36350584e-01f, -3.61807048e-01f, -1.85719490e-01f, 2.16447726e-01f, 2.34712332e-01f, -1.88964903e-02f,
  -3.31448972e-01f, -2.93185622e-01f, -3.55448693e-01f, -2.50947177e-01f, -1.66783348e-01f, -2.33063519e-01f, -3.15980911e-01f, -4.87331539e-01f, -3.95392537e-01f, 9.36715119e-03f,
  -5.51442965e-04f, 1.91710666e-02f, -4.49391380e-02f, -5.71651235e-02f, -9.24764499e-02f, -3.23159128e-01f, -3.13930690e-01f, -2.63339281e-01f, -5.01340210e-01f, -5.17904639e-01f,
  -6.16779745e-01f, -1.43316239e-01f, -1.78627804e-01f, 3.42520028e-02f, -1.15651026e-01f, 3.91347073e-02f, -6.72540516e-02f, -5.46558062e-03f, 1.34934947e-01f, -4.84102927e-02f,
  -1.34999171e-01f, 1.10093847e-01f, -4.89828922e-02f, -2.07003459e-01f, -2.20853765e-03f, 1.89440250e-02f, 9.46596935e-02f, -1.72671556e-01f, -1.58311099e-01f, -5.27241826e-03f,
  -6.01438098e-02f, -2.82879949e-01f, -1.99686587e-01f, 2.58943364e-02f, -5.58119938e-02f, -1.35191411e-01f, -2.07445174e-01f, -6.28511459e-02f, -1.98461741e-01f, 1.36539951e-01f,
  9.02696177e-02f, -3.32729705e-02f, -1.17729582e-01f, 1.29129499e-01f, 1.54027432e-01f, -1.16735687e-02f, 4.03484479e-02f, 5.79973571e-02f, 7.42301866e-02f, 3.32083218e-02f,
  8.67499853e-04f, -3.11418679e-02f, 8.59508365e-02f, 6.63172901e-02f, 1.12988602e-03f, 6.73560798e-02f, 1.44536197e-01f, 1.20431818e-01f, 1.06595792e-02f, 1.03471607e-01f,
  -1.27158836e-01f, -3.50037590e-02f, 2.10074577e-02f, 9.68822092e-02f, -1.40813217e-01f, -5.58482297e-02f, -6.33828565e-02f, 1.61331818e-01f, 6.11076504e-02f, 4.62314226e-02f,
  2.77768403e-01f, -1.93507284e-01f, 9.47632194e-02f, -1.88751630e-02f, -7.79979974e-02f, -3.51178013e-02f, -3.47018354e-02f, 2.05273628e-01f, 3.87652963e-02f, 7.31371641e-02f,
  -5.58785871e-02f, 1.29117936e-01f, 3.28177623e-02f, -8.15878739e-04f, -1.94772333e-02f, -9.34593081e-02f, 2.25040331e-01f, -2.31150817e-02f, 2.72614304e-02f, 1.49454460e-01f,
  2.57913947e-01f, 2.38025054e-01f, 1.44781530e-01f, 6.53079525e-02f, 4.25249189e-02f, -3.90568711e-02f, -1.47965476e-01f, -8.84160101e-02f, -2.02451255e-02f, 4.17804182e-01f,
  -6.42261505e-01f, -1.62737504e-01f, -3.67138177e-01f, -5.46583176e-01f, -5.29984474e-01f, -2.24437952e-01f, -2.87324399e-01f, -7.39358291e-02f, -2.52221346e-01f, -3.78015727e-01f,
  -2.53184974e-01f, 5.70087917e-02f, -1.26517117e-01f, -1.70349777e-01f, -3.05840075e-01f, -5.15450656e-01f, -4.87278283e-01f, -4.94606733e-01f, -4.66970712e-01f, -1.09331645e-01f,
  -3.83308619e-01f, -5.63447893e-01f, -4.46421862e-01f, -1.54692337e-01f, 6.43902421e-02f, -1.79328144e-01f, -1.72781944e-01f, -1.49375126e-01f, -4.38562259e-02f, -1.97851792e-01f,
  -8.14195126e-02f, 8.05715248e-02f, -1.03486041e-02f, -1.75479770e-01f, -5.03520779e-02f, -2.82198098e-03f, 4.98766685e-03f, 1.82262268e-02f, -2.18392126e-02f, -6.44082353e-02f,
  -2.34261051e-01f, -3.12927999e-02f, -1.65828913e-01f, -4.88105565e-02f, -1.93371445e-01f, -1.16027236e-01f, -1.49986491e-01f, -1.99783936e-01f, -1.06140310e-02f, 1.45759225e-01f,
  -1.31559633e-02f, -7.56042674e-02f, 1.66173242e-02f, 1.75412335e-02f, 2.18208134e-01f, -9.95967612e-02f, 1.55242562e-01f, 1.74668029e-01f, 1.96188554e-01f, 2.10245550e-01f,
  -4.87027466e-02f, 9.08863917e-02f, 6.45078123e-02f, -1.14615196e-02f, -3.18615069e-03f, -1.09721728e-01f, -4.96872326e-06f, 2.07394864e-02f, -2.79680248e-02f, -7.03989640e-02f,
  -1.55103296e-01f, -2.08885372e-02f, 3.62065732e-02f, -3.68971005e-02f, -8.05230215e-02f, -3.37367468e-02f, -9.95502844e-02f, -2.70811692e-02f, -9.73453596e-02f, -1.32451847e-01f,
  -6.41994551e-02f, 5.17113097e-02f, 7.87314028e-04f, 4.31119762e-02f, -4.09537461e-03f, -1.56605333e-01f, -8.05099756e-02f, -8.27493984e-03f, -6.72914907e-02f, -1.78162143e-01f,
  -2.63870768e-02f, -2.62331337e-01f, -7.73556903e-02f, 1.39749661e-01f, -1.34271951e-02f, 2.68964656e-02f, 1.76327527e-01f, 1.13817252e-01f, -6.76480681e-02f, -6.14343397e-02f,
  -2.64164638e-02f, -7.52528161e-02f, -1.52587026e-01f, 1.23116978e-01f, -9.73190591e-02f, -1.09173760e-01f, -6.85501248e-02f, -1.27157494e-01f, 1.48744392e-03f, 2.21249685e-01f,
  -3.80595736e-02f, -5.74068092e-02f, -1.09207466e-01f, 8.38214979e-02f, 8.30950364e-02f, -7.95815364e-02f, 1.75856590e-01f, 2.26457283e-01f, 1.37721002e-01f, -2.74959598e-02f,
  -8.26530159e-01f, 2.05030799e-01f, 4.52085733e-01f, -6.85567975e-01f, -1.42354295e-01f, 2.81115416e-02f, -7.31045334e-03f, -3.07129800e-01f, -3.80872250e-01f, 1.10444523e-01f,
  1.29333884e-01f, -1.98130801e-01f, -1.89144015e-02f, -5.77189475e-02f, -1.29311368e-01f, 9.36645940e-02f, 1.09481297e-01f, -5.87329306e-02f, -2.29708344e-01f, -2.81353056e-01f,
  -6.80684000e-02f, -3.33898306e-01f, -3.05274367e-01f, -3.03582132e-01f, -2.15256244e-01f, -1.22019514e-01f, 1.24227494e-01f, -1.75205201e-01f, 2.11010009e-01f, 5.31182885e-02f,
  2.14707375e-01f, -2.80836701e-01f, 2.65025208e-03f, -4.03785221e-02f, 2.74165813e-02f, 9.07667130e-02f, -1.37475401e-01f, -1.46775469e-02f, 5.19825295e-02f, 2.52274908e-02f,
  -3.01127397e-02f, -3.53327729e-02f, -1.67330623e-01f, 1.05897456e-01f, -1.88150018e-01f, -1.84704065e-02f, -1.15519119e-02f, 5.30142523e-02f, 7.58781731e-02f, 2.68659413e-01f,
  2.11825833e-01f, 2.15936564e-02f, -4.31127800e-03f, 1.62684128e-01f, 3.82348634e-02f, 6.84486255e-02f, 9.03683677e-02f, 4.18834761e-02f, 1.47266179e-01f, -1.13081686e-01f,
  6.08300455e-02f, -2.98751500e-02f, 2.53525041e-02f, -1.26314044e-01f, -7.63583109e-02f, -8.87812078e-02f, -7.36828968e-02f, 7.11932662e-05f, -6.23672567e-02f, 1.55606801e-02f,
  1.20410621e-01f, 1.54749662e-01f, 2.18694173e-02f, 1.96833163e-02f, 9.93648767e-02f, 5.79456193e-03f, 1.15049273e-01f, 5.73201180e-02f, 6.39025792e-02f, -5.00257164e-02f,
  -1.60206661e-01f, -4.30913307e-02f, 2.13891193e-02f, 4.60420810e-02f, 1.14589751e-01f, -6.19570762e-02f, 1.49798736e-01f, 1.02427267e-01f, 1.08915634e-01f, 2.06280917e-01f,
  -3.67533535e-01f, 4.14048582e-01f, -7.89676681e-02f, -1.28035694e-01f, -1.13146678e-01f, 1.37684777e-01f, 1.36841023e-02f, -1.04405079e-02f, -1.60294816e-01f, -9.13207382e-02f,
  8.30886662e-02f, -1.61026597e-01f, 1.01513617e-01f, 1.11149929e-01f, -5.95539846e-02f, -3.84097807e-02f, 9.65973288e-02f, -3.91958803e-02f, 1.13181241e-01f, 4.58728001e-02f,
  1.44624308e-01f, -8.65725651e-02f, -1.65834531e-01f, -2.44660582e-03f, -2.45867446e-02f, -1.24372572e-01f, 4.43416759e-02f, -1.58919282e-02f, -8.68634786e-03f, -2.06199035e-01f,
  8.30375731e-01f, -5.93130924e-02f, 7.86165744e-02f, 3.82726312e-01f, 7.72666605e-03f, 1.09489299e-01f, -1.58452149e-02f, 1.85152277e-01f, 1.52281582e-01f, 1.28757536e-01f,
  1.05206445e-01f, 1.85834467e-01f, 2.29653820e-01f, 2.24561363e-01f, 2.32713386e-01f, -8.95274356e-02f, 7.96568766e-03f, 1.61382034e-01f, 2.30805755e-01f, 1.59326881e-01f,
  2.75475625e-03f, -1.10116117e-02f, 1.43870160e-01f, 9.17613804e-02f, -1.64803237e-01f, 1.62794679e-01f, -1.40817106e-01f, -2.33218595e-01f, -9.88228545e-02f, -1.88357845e-01f,
  -5.06858230e-01f, 6.29129820e-03f, 7.55155683e-02f, 1.26687571e-01f, -1.80038318e-01f, 8.17513689e-02f, 3.76856141e-02f, -8.73938501e-02f, -1.15022354e-01f, -1.71714257e-02f,
  -1.59996241e-01f, -5.96196204e-02f, -5.49453031e-03f, -8.47089291e-02f, -9.09342691e-02f, -3.16098817e-02f, -1.49158716e-01f, -6.03887141e-02f, 1.22494079e-01f, -6.03385828e-02f,
  -1.20238326e-01f, 6.31504208e-02f, 3.74166742e-02f, -3.77178891e-03f, 6.17578737e-02f, 2.97534335e-02f, -1.52922601e-01f, -1.47688657e-01f, 2.15845201e-02f, 3.60442325e-02f,
  -2.26965304e-02f, 1.16838679e-01f, 1.01173282e-01f, 4.85661700e-02f, 7.52412230e-02f, 3.98162939e-02f, -5.53522781e-02f, 4.75174896e-02f, 4.33624834e-02f, -6.81399629e-02f,
  -8.46764371e-02f, 1.35503680e-01f, 9.68624353e-02f, 3.65466326e-02f, 1.74008280e-01f, 1.30200312e-01f, -1.76628418e-02f, -3.14189233e-02f, 3.09911240e-02f, -5.87548725e-02f,
  3.64080332e-02f, -1.69680268e-02f, -1.46510750e-01f, -1.40453875e-01f, -1.02813996e-01f, 4.78898175e-03f, 5.53669631e-02f, 7.69980624e-02f, -1.01333246e-01f, 2.29490828e-02f,
  -3.12203616e-01f, 2.59503692e-01f, 9.75430235e-02f, -8.54890421e-02f, -9.56544355e-02f, -1.68462709e-01f, -4.08663973e-02f, -1.09461151e-01f, -1.95157841e-01f, -1.17333807e-01f,
  -1.80094004e-01f, 2.55201925e-02f, -1.27608687e-01f, -1.74608186e-01f, -1.07365981e-01f, -2.59465985e-02f, -1.06033064e-01f, -1.32933697e-02f, 5.54092266e-02f, -2.76710510e-01f,
  -1.71228781e-01f, 1.90044627e-01f, 8.95384401e-02f, 7.69239664e-02f, -1.55610070e-02f, 2.20765114e-01f, -1.24385811e-01f, -1.60395335e-02f, 1.97243631e-01f, 1.43050104e-01f,
  4.48673874e-01f, -1.20918013e-01f, 2.20147818e-01f, 4.18863267e-01f, 2.31840387e-02f, -5.15127838e-01f, -9.69398320e-01f, -5.93337774e-01f, 1.21418342e-01f, -1.85548827e-01f,
  -1.20153733e-01f, 2.07951337e-01f, 1.48518071e-01f, -3.43177579e-02f, -5.17671824e-01f, -4.70338106e-01f, -2.03067943e-01f, -4.19503078e-02f, -1.47790328e-01f, -1.88860923e-01f,
  -1.30569696e-01f, 1.34533629e-01f, 9.31891873e-02f, -3.20510902e-02f, 5.10463476e-01f, 2.19141319e-01f, 2.21146613e-01f, 2.81250894e-01f, -7.89296906e-03f, 6.50122464e-01f,
  4.53146607e-01f, 3.39687794e-01f, -1.51972637e-01f, -2.61621876e-03f, 2.80686975e-01f, 4.39546742e-02f, 3.04293968e-02f, 2.63073415e-01f, 1.07893892e-01f, 1.48231220e-02f,
  2.18431041e-01f, 1.10017397e-01f, 3.59107368e-02f, 2.33632460e-01f, 2.76960116e-02f, -1.31494313e-01f, -1.19516701e-01f, -2.28859380e-01f, -1.30888984e-01f, 2.73686387e-02f,
  -7.16814399e-02f, 2.19329204e-02f, -2.17266545e-01f, -2.17023686e-01f, -1.04218289e-01f, 4.55660373e-02f, 6.19254410e-02f, 1.82399377e-01f, -5.07594226e-03f, 1.77555218e-01f,
  -1.20247453e-01f, 4.68510203e-02f, -2.99362419e-03f, 1.00330733e-01f, -7.79328942e-02f, 6.79023415e-02f, 6.70816377e-02f, -7.65459388e-02f, -2.86777876e-02f, -2.89388727e-02f,
  -9.93382707e-02f, 6.78878650e-02f, 4.37859334e-02f, -5.70928911e-03f, 1.12382077e-01f, 1.77792072e-01f, 2.90018623e-03f, -1.63603321e-01f, -3.10103688e-02f, 2.76294909e-02f,
  5.53717092e-02f, -3.83075736e-02f, 2.01358616e-01f, -4.12323214e-02f, 5.00459317e-03f, 6.07340559e-02f, 1.19383097e-01f, 3.46809030e-02f, 1.45104349e-01f, 1.09841846e-01f,
  -2.30004519e-01f, -4.55737382e-01f, 1.70269847e-01f, -3.50738727e-02f, 2.08761934e-02f, -4.84869163e-03f, 7.08487853e-02f, 9.76731244e-05f, 2.56181777e-01f, -5.87558784e-02f,
  -1.40388787e-01f, -6.64535165e-02f, -7.18239173e-02f, -8.74657854e-02f, -1.68629229e-01f, 1.24278164e-03f, -2.60732949e-01f, -7.36119272e-03f, -1.50861546e-01f, 1.22366183e-01f,
  -2.29229972e-01f, -5.74620724e-01f, -5.60336947e-01f, -4.96383309e-01f, -8.03645030e-02f, -3.06697279e-01f, -3.95393781e-02f, -9.42312479e-02f, -4.45558429e-01f, -7.07993150e-01f,
  4.50088263e-01f, 1.89486474e-01f, 5.53372264e-01f, -4.12663259e-03f, -2.02079415e-01f, -2.83173323e-01f, -2.73013562e-01f, -8.17334428e-02f, -6.97771311e-02f, -2.32861657e-02f,
  -2.68319428e-01f, -2.90189475e-01f, 2.72708014e-02f, -1.48180854e-02f, 2.44435623e-01f, 2.35422894e-01f, 3.24300677e-01f, 6.82546675e-01f, 4.74031091e-01f, 3.92979989e-03f,
  -1.18768767e-01f, 3.75446886e-01f, 6.45148754e-01f, 3.99276555e-01f, 4.88970103e-03f, 6.12005889e-02f, 3.99564713e-01f, 3.23093921e-01f, 1.79128543e-01f, 3.57953399e-01f,
  -9.69268456e-02f, 8.90282542e-02f, -1.51512757e-01f, -2.88575888e-01f, 1.79933701e-02f, -3.55526689e-03f, -3.93771790e-02f, 9.11113396e-02f, -2.04149410e-01f, -1.93498302e-02f,
  -1.85035288e-01f, -1.34980723e-01f, -1.43633321e-01f, 4.43020742e-03f, -9.76591110e-02f, -2.28511781e-01f, 1.91956952e-01f, 2.58422285e-01f, 1.30145267e-01f, -1.13709785e-01f,
  -3.20700854e-01f, -2.08682731e-01f, 4.48078774e-02f, -6.68381751e-02f, 1.74367744e-02f, -9.41884741e-02f, 1.25516132e-01f, -4.16655876e-02f, 1.07090071e-01f, -1.21127861e-02f,
  -1.04157403e-01f, 2.82124370e-01f, 1.46807626e-01f, 1.44953102e-01f, -3.12268082e-02f, 2.99283750e-02f, -5.61515801e-03f, -5.94761670e-02f, 6.18505813e-02f, 3.36622223e-02f,
  -5.83443269e-02f, 1.29745618e-01f, 9.65354741e-02f, 6.77631050e-02f, -1.20861426e-01f, 7.42460117e-02f, -1.12697043e-01f, 2.31248457e-02f, 5.87024130e-02f, 3.17616016e-02f,
  4.57465053e-02f, 1.92094557e-02f, 5.15514761e-02f, 1.73068702e-01f, 4.22034450e-02f, 6.68679923e-02f, -5.56172356e-02f, -1.34505883e-01f, -5.71752191e-02f, -6.32056221e-02f,
  -3.75080913e-01f, 2.40390062e-01f, -2.65216321e-01f, -5.37815653e-02f, 4.66897450e-02f, -1.99525952e-02f, 3.77853476e-02f, -1.20887067e-02f, -1.18562160e-02f, -1.92053378e-01f,
  -2.26272479e-01f, 2.50010341e-02f, 6.03917725e-02f, 1.21521361e-01f, -1.81626320e-01f, -2.08207428e-01f, -1.28893033e-01f, -4.27345885e-03f, -1.15358651e-01f, -1.36717498e-01f,
  -1.43339396e-01f, -3.44231337e-01f, -3.62779289e-01f, -3.35060447e-01f, -2.80773848e-01f, -2.51683146e-01f, -6.56447336e-02f, -2.71525711e-01f, -1.61819130e-01f, -3.16518486e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.60505986e-01f, 9.27462518e-01f, 5.36237597e-01f, 3.68918031e-01f, 4.38928813e-01f, 6.59608603e-01f, 3.67829412e-01f, 4.79352772e-01f, 6.26771688e-01f, 4.79778677e-01f,
  8.66063833e-01f, 4.73843604e-01f, 2.03973874e-01f, 4.29086983e-01f, 3.51526111e-01f, 4.99664932e-01f, 7.46874273e-01f, 3.99080157e-01f, 4.59670335e-01f, 7.35871732e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.10810027e-02f, 2.08378613e-01f, -6.09139912e-02f, -7.41511956e-03f, 1.11838140e-01f, 2.76538227e-02f, -1.94424149e-02f, 2.12597176e-01f, 1.69900775e-01f, 1.29164249e-01f,
  4.64893058e-02f, -3.64482738e-02f, 2.39095926e-01f, -1.87767446e-01f, 2.23406792e-01f, 1.71762899e-01f, -2.19633326e-01f, -2.47343630e-01f, 2.27269247e-01f, 1.21494792e-02f,
  -5.75843379e-02f, 1.53825004e-02f, -4.21384722e-01f, 2.38994896e-01f, 1.50328889e-01f, 2.58055568e-01f, 1.24982566e-01f, 2.21626595e-01f, 3.07393581e-01f, 1.92767680e-01f,
  -3.22428703e-01f, -3.10532719e-01f, -5.78018185e-03f, -4.74940725e-02f, -7.74174370e-03f, -6.32764176e-02f, -9.76112951e-03f, 1.53003395e-01f, 4.58655916e-02f, -1.56535208e-01f,
  -1.08507946e-02f, -1.04409918e-01f, -4.31304350e-02f, 7.87703767e-02f, 2.51842767e-01f, 2.82741845e-01f, 2.98172534e-01f, 2.88753182e-01f, -2.11811662e-01f, -1.02607585e-01f,
  1.31481454e-01f, -2.86808871e-02f, 1.09963022e-01f, -3.80542547e-01f, 5.16488194e-01f, 1.27603784e-02f, 2.95732170e-01f, 3.92183959e-01f, -1.38927758e-01f, -5.84032685e-02f,
  -5.82223535e-02f, 8.18847641e-02f, 1.71097778e-02f, -3.62358987e-01f, -1.40798846e-02f, -1.91252291e-01f, 2.19716370e-01f, -9.87769365e-02f, 1.14813238e-01f, 6.97222203e-02f,
  1.96706861e-01f, -4.27483693e-02f, 3.54426652e-02f, -5.71078621e-04f, -1.55545007e-02f, -9.20345187e-02f, 3.46692950e-01f, -4.06562388e-01f, -3.71747613e-01f, 1.33396521e-01f,
  -2.58123279e-01f, 1.11855222e-02f, 1.77155375e-01f, 2.38029033e-01f, 3.46471416e-03f, -3.69313657e-01f, 1.07836328e-01f, -7.99129307e-02f, 7.35981539e-02f, 3.98685604e-01f,
  1.59138501e-01f, -1.73041672e-02f, -7.49990297e-03f, 2.35757276e-01f, 5.54526865e-01f, -5.42342246e-01f, -1.57545209e-01f, -7.99685866e-02f, -1.09604180e-01f, -1.54813334e-01f,
  -2.62522161e-01f, -2.74850160e-01f, 1.26528785e-01f, -1.49540856e-01f, -1.88643560e-01f, -6.75683841e-02f, -1.17593370e-01f, 2.21485067e-02f, 7.08404630e-02f, 1.61337033e-01f,
  1.57511145e-01f, -1.97118297e-01f, -4.55927178e-02f, -9.14305076e-02f, -3.36444497e-01f, 1.53430400e-03f, -1.86021835e-01f, 2.16927454e-02f, 3.46046686e-01f, -1.19464032e-01f,
  -1.29919976e-01f, -1.05935350e-01f, 1.35802865e-01f, -2.81427711e-01f, -3.34102511e-01f, 7.55499974e-02f, -1.57075420e-01f, 2.85289228e-01f, 1.00732327e-01f, 1.05415791e-01f,
  1.38137937e-01f, 9.31617692e-02f, 1.14514351e-01f, 2.05238517e-02f, -6.49880245e-02f, -4.27494720e-02f, -6.20367751e-02f, -9.00220647e-02f, -3.53451297e-02f, 3.95267867e-02f,
  -5.44899851e-02f, 2.63792962e-01f, -7.90319592e-02f, -3.95620644e-01f, 2.53424793e-01f, 7.53565878e-02f, -5.94082884e-02f, -1.22370072e-01f, 3.09174687e-01f, 3.02191287e-01f,
  1.33716062e-01f, -2.97715992e-01f, -2.90069133e-01f, -3.31161141e-01f, -1.59782276e-01f, 1.12213135e-01f, -3.46525878e-01f, -1.44929990e-01f, 2.22003549e-01f, 2.65707880e-01f,
  1.62762955e-01f, -2.02474594e-02f, 3.22741293e-03f, -7.06674084e-02f, 4.64642514e-03f, 5.13980426e-02f, -1.27799556e-01f, -7.88817257e-02f, -8.62978846e-02f, -2.89366525e-02f,
  -7.34541193e-02f, 6.87689632e-02f, -1.24132894e-01f, -4.83412087e-01f, -1.42358705e-01f, 2.19708309e-01f, -2.98164219e-01f, -1.15951933e-01f, 7.36854300e-02f, 2.33407602e-01f,
  6.61420748e-02f, -1.25128657e-01f, -2.46882185e-01f, -2.87308902e-01f, 2.11896285e-01f, 4.07974482e-01f, 3.61586720e-01f, 7.50737637e-02f, -3.77486318e-01f, 1.92188278e-01f,
  5.59343755e-01f, -1.77672341e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.29996492e-02f, 1.94973513e-01f, 3.04091752e-01f, 2.14160264e-01f, -3.12705599e-02f, 1.75434366e-01f, 2.23608851e-01f, -1.53817415e-01f, 3.49810511e-01f, 6.37235716e-02f,
  3.58728319e-01f, 6.06418997e-02f, -3.96113455e-01f, -1.67271778e-01f, -9.25253510e-01f, 9.63397682e-01f, 3.64626974e-01f, 2.55290836e-01f, -4.81187642e-01f, 1.58118755e-01f,
  2.91554004e-01f, -6.22941613e-01f, -8.54855895e-01f, 8.02146316e-01f, 3.03960383e-01f, 5.87056577e-01f, 2.02899188e-01f, -6.35321856e-01f, -4.54182982e-01f, 1.25333607e-01f,
  4.95363325e-01f, 1.47400647e-01f, 1.30813956e-01f, 3.49850148e-01f, 1.69139430e-01f, 2.03721508e-01f, 1.99223489e-01f, 3.17672461e-01f, -1.15195557e-01f, -1.52697086e-01f,
  1.08381011e-01f, -1.93650320e-01f, 2.40960211e-01f, 1.72347754e-01f, 2.53742725e-01f, -3.81320864e-01f, -4.64349836e-01f, -7.45207787e-01f, 4.15686309e-01f, 6.63331449e-01f,
  -4.06439334e-01f, -1.34073302e-01f, -7.54460752e-01f, -6.11716509e-01f, 2.99421817e-01f, 5.01025975e-01f, -7.14750364e-02f, -6.41811550e-01f, -4.18635815e-01f, -3.47995698e-01f,
  5.07548712e-02f, -1.19834550e-01f, -1.03051446e-01f, 5.76131701e-01f, 4.28956628e-01f, 1.76766202e-01f, 2.13102147e-01f, 2.13933155e-01f, 2.43126839e-01f, 2.07263321e-01f,
  3.12186062e-01f, -8.43157619e-02f, -3.49463314e-01f, 3.37400958e-02f, 1.61160111e-01f, 7.11746216e-02f, 5.51841035e-02f, 5.95296085e-01f, -4.09271121e-01f, 3.01670164e-01f,
  9.69121978e-02f, -2.22569391e-01f, 3.87740284e-01f, 7.19622731e-01f, 4.10197854e-01f, 1.82840228e-01f, 3.22157353e-01f, -8.61316323e-01f, -1.43261924e-01f, -1.28766764e-02f,
  6.56135917e-01f, -3.89292777e-01f, -6.73474967e-01f, 1.30933940e-01f, -1.20639347e-01f, 5.89172363e-01f, 2.09925428e-01f, 1.25610650e-01f, 2.57425517e-01f, 1.36882290e-01f,
  1.62944347e-01f, 1.87024817e-01f, -3.14762071e-02f, -5.94974170e-03f, -1.31641449e-02f, -2.40249053e-01f, -2.19981730e-01f, 4.97793667e-02f, 7.03304470e-01f, -3.98127943e-01f,
  6.58097148e-01f, -3.31284642e-01f, -2.90243834e-01f, 2.75841892e-01f, 4.71112162e-01f, 9.57164168e-02f, 1.05393857e-01f, -5.80506682e-01f, 3.20540071e-01f, -3.20596248e-01f,
  2.33717617e-02f, 4.46879745e-01f, 9.36200842e-03f, 4.25656587e-01f, -9.88111496e-02f, 3.03392589e-01f, -4.53009233e-02f, 1.22752301e-01f, -5.65005578e-02f, -2.77156144e-01f,
  2.60534585e-01f, -1.30833173e-02f, -6.90445304e-03f, -7.77101368e-02f, 1.32687226e-01f, -3.24390531e-01f, -6.14585221e-01f, -4.72186863e-01f, -1.62143279e-02f, 1.22924328e-01f,
  -5.16947806e-01f, 3.27618659e-01f, 3.03683639e-01f, -3.24450396e-02f, 4.65326309e-01f, 1.73729345e-01f, -6.48429334e-01f, 2.70768926e-02f, 4.66610640e-01f, 6.01838052e-01f,
  -1.29777789e-01f, -4.80799563e-02f, -3.58734131e-01f, 1.49545774e-01f, 6.72595128e-02f, 1.13578930e-01f, -4.13723171e-01f, -4.25750285e-01f, 6.87765330e-02f, 1.15489200e-01f,
  2.72722505e-02f, -9.49210525e-02f, 3.03456903e-01f, -3.66439000e-02f, 1.36623383e-01f, 1.56874776e-01f, -3.95568870e-02f, -8.38755369e-02f, 4.71494440e-03f, -2.29709178e-01f,
  -1.41754121e-01f, 1.45567104e-01f, 6.49356470e-02f, 7.76333392e-01f, 1.76627830e-01f, 2.93840379e-01f, -1.38189867e-01f, 7.68015906e-02f, 6.67445898e-01f, 2.78927833e-01f,
  9.61609781e-01f, -8.76356184e-01f, 4.58668530e-01f, 1.32236732e-02f, 4.26816523e-01f, -2.89678067e-01f, -1.76109940e-01f, 2.19164833e-01f, -1.73327476e-01f, -1.55142099e-01f,
  -1.28581136e-01f, -1.91766471e-01f, 7.20379278e-02f, -1.53724745e-01f, 1.77008703e-01f, -1.57039329e-01f, -5.29977269e-02f, -1.70304775e-01f, 1.40063697e-02f, -2.80586571e-01f,
  -2.58430600e-01f, -2.39329085e-01f, -2.79264916e-02f, 1.08809536e-02f, 4.83807802e-01f, 4.44264084e-01f, 1.78088713e-02f, 1.30246803e-01f, -1.40434414e-01f, 1.34899288e-01f,
  -6.93293571e-01f, -2.66511798e-01f, -6.71456233e-02f, -2.90241241e-01f, 5.91922462e-01f, -2.50939697e-01f, 6.08130991e-01f, 1.56953231e-01f, 1.98842809e-01f, 2.83539921e-01f,
  -5.12865186e-01f, 8.34720209e-02f, -5.59756100e-01f, -1.67836010e-01f, 1.26569182e-01f, 3.47436994e-01f, 3.35394830e-01f, 4.24781255e-02f, 4.11873549e-01f, 1.27341837e-01f,
  -1.19237423e-01f, -3.71442795e-01f, 1.92608520e-01f, -1.59116104e-01f, 9.45477039e-02f, 1.45854384e-01f, 3.26777428e-01f, 3.96462381e-02f, -2.06598371e-01f, -6.81061029e-01f,
  4.45021033e-01f, 3.80957037e-01f, 1.08363025e-01f, -6.26382977e-02f, -5.23463666e-01f, -3.31132382e-01f, 2.96142399e-01f, 3.50958586e-01f, -2.69898828e-02f, -3.85972053e-01f,
  -5.18361390e-01f, -3.25575843e-02f, 1.97159573e-01f, -1.87990561e-01f, -8.24023262e-02f, 3.87544036e-01f, 1.73279002e-01f, 1.76323831e-01f, 1.61893606e-01f, 1.63579822e-01f,
  -2.22815759e-02f, -1.12414524e-01f, -1.70257017e-01f, -2.06729263e-01f, -4.00387377e-01f, 4.32347208e-02f, -1.24108545e-01f, -9.41679254e-02f, 4.63766962e-01f, -7.03200758e-01f,
  3.74174505e-01f, 3.63584608e-01f, -5.19994497e-01f, 2.96134770e-01f, -4.76805009e-02f, 4.74187225e-01f, 1.26504868e-01f, 3.05521309e-01f, -1.39083266e-01f, -8.08228254e-02f,
  1.30909994e-01f, 3.65123987e-01f, 7.19122410e-01f, 2.85309970e-01f, -4.78602231e-01f, 3.29860777e-01f, 5.36174536e-01f, -2.35282868e-01f, 3.32167178e-01f, 3.71698469e-01f,
  3.27038378e-01f, 1.29206702e-02f, 3.83859038e-01f, 3.05958718e-01f, 2.49862328e-01f, -7.75278658e-02f, -2.48024449e-01f, -2.77593940e-01f, -1.20303385e-01f, 3.17048654e-02f,
  4.88810092e-01f, 2.69405276e-01f, 6.62989795e-01f, -5.95784426e-01f, 2.51789570e-01f, -1.99793100e-01f, -3.03936414e-02f, -2.93496609e-01f, 5.37104487e-01f, 2.79622853e-01f,
  6.30163848e-01f, -2.60036469e-01f, -2.38765791e-01f, 6.37519896e-01f, -4.49671298e-01f, -1.46557570e-01f, 2.54913211e-01f, 4.06891070e-02f, 4.08339560e-01f, 4.76196617e-01f,
  1.35747299e-01f, 2.38427669e-02f, 1.02739468e-01f, 1.04431726e-01f, 1.14203170e-01f, -1.92401260e-01f, -1.95762604e-01f, -1.19039498e-01f, 2.03449279e-01f, -1.27580628e-01f,
  -4.25960757e-02f, 1.05035856e-01f, 3.77596557e-01f, 7.19502807e-01f, 4.20580745e-01f, 2.32511714e-01f, 2.38031328e-01f, 2.06531256e-01f, -3.53818417e-01f, -5.24761140e-01f,
  -3.69851172e-01f, 1.04075909e+00f, 7.39666820e-01f, 9.13301587e-01f, 4.02815372e-01f, -1.76575035e-01f, -1.97106689e-01f, 3.58187109e-01f, 3.78046423e-01f, 2.00035691e-01f,
  -7.26403892e-01f, 4.94663045e-02f, 1.07789934e-01f, 1.88048124e-01f, 1.33738935e-01f, 3.15918297e-01f, 2.94319928e-01f, 1.37132123e-01f, -5.46414256e-02f, -1.57721177e-01f,
  2.30808426e-02f, -1.71902806e-01f, -1.66011862e-02f, 2.20149562e-01f, 4.47288334e-01f, 1.01504791e+00f, 4.80296701e-01f, -1.24095492e-02f, -3.57046753e-01f, -1.54826164e-01f,
  9.55299810e-02f, -1.39981419e-01f, 3.72033536e-01f, -1.01218298e-02f, 5.68687916e-01f, -2.08817318e-01f, -2.00076513e-02f, 9.66165587e-02f, 2.87798017e-01f, 2.52323121e-01f,
  1.26859978e-01f, 2.15633497e-01f, -1.23613930e+00f, 4.36029918e-02f, 1.50964856e-01f, 1.87489957e-01f, 2.65876442e-01f, 1.22699887e-01f, 2.51064986e-01f, 3.72638047e-01f,
  -4.41931009e-01f, 2.18133494e-01f, 4.91129002e-03f, 1.45317122e-01f, -2.77321041e-01f, -2.79114306e-01f, 5.46399117e-01f, -3.90723348e-01f, 4.86716062e-01f, -3.97834957e-01f,
  2.73506194e-01f, 1.95744887e-01f, -5.61713457e-01f, -3.54671568e-01f, -6.86173081e-01f, 8.09873760e-01f, 4.47051108e-01f, 1.01343177e-01f, -3.58530916e-02f, 7.26138890e-01f,
  2.88843632e-01f, -1.24174587e-01f, 3.38488877e-01f, 2.34719619e-01f, -1.05290875e-01f, 5.40046394e-01f, 2.93283701e-01f, 3.87214303e-01f, 1.23839267e-01f, 2.44188488e-01f,
  5.14306188e-01f, 6.08551577e-02f, -9.47131217e-03f, 7.08460156e-03f, 6.49153963e-02f, 3.50095443e-02f, -8.01269803e-03f, -6.53558001e-02f, -3.14258933e-01f, 6.25626445e-01f,
  -5.35929739e-01f, 7.23137856e-01f, -3.37483913e-01f, 1.37781620e-01f, 9.01906788e-01f, 8.15369964e-01f, 8.17410797e-02f, -2.16952443e-01f, -5.23333251e-01f, 3.99890751e-01f,
  -2.54266918e-01f, -1.58156708e-01f, 4.19161350e-01f, 3.79966199e-01f, 5.09965479e-01f, 1.77576736e-01f, -3.42875659e-01f, 3.20813656e-02f, -5.70146926e-02f, -1.38372272e-01f,
  3.21464926e-01f, 5.50950989e-02f, 6.74284324e-02f, -8.55079591e-02f, 1.75808638e-01f, -2.15613469e-01f, -2.03917116e-01f, -6.82273805e-02f, -2.65522897e-02f, -9.48524326e-02f,
  5.78990042e-01f, -7.72157848e-01f, 1.06305003e-01f, 3.43951792e-01f, -2.83263713e-01f, 5.27001560e-01f, 1.21030360e-01f, 4.99242365e-01f, -2.27572918e-01f, -1.34152979e-01f,
  2.13755071e-01f, -1.18699148e-01f, 1.31648242e-01f, -2.75710613e-01f, 5.00471175e-01f, 4.67834085e-01f, -3.86245131e-01f, 2.34243035e-01f, 3.24047238e-01f, 9.31275412e-02f,
  1.88438252e-01f, 1.63423605e-02f, 2.18130261e-01f, -2.24555228e-02f, 2.50112861e-01f, 1.00656435e-01f, -1.28036961e-01f, -1.04052573e-01f, 2.38962770e-01f, 6.33490607e-02f,
  9.34741274e-02f, 2.66700163e-02f, 3.40964139e-01f, 6.99468434e-01f, -7.86137938e-01f, 1.37533218e-01f, 3.29726517e-01f, 2.46567696e-01f, 3.73252362e-01f, 8.14331621e-02f,
  -7.77201355e-01f, -1.94727611e-02f, 5.65226078e-01f, 6.07402861e-01f, 3.32393609e-02f, -8.70648682e-01f, 5.37854135e-02f, 1.71818703e-01f, 4.31209654e-01f, -2.04538852e-01f,
  -2.16082022e-01f, 2.85432518e-01f, 2.04969347e-02f, 3.31352234e-01f, 1.48234099e-01f, 2.96202749e-01f, 1.10002138e-01f, 1.97786093e-01f, 5.31806201e-02f, -8.20148177e-03f,
  3.89448583e-01f, 1.43355057e-01f, 2.50663906e-01f, 1.08597666e-01f, -7.18934357e-01f, 1.98912576e-01f, -1.79798827e-01f, 4.70061958e-01f, 4.04510558e-01f, 4.04986273e-03f,
  1.99625045e-01f, -3.11930418e-01f, 1.67759210e-01f, -1.47086941e-03f, -2.68428087e-01f, 8.42812598e-01f, 2.16466598e-02f, -3.57799642e-02f, -2.76867449e-01f, 2.81973183e-01f,
  8.84467781e-01f, -4.89225447e-01f, 3.85300189e-01f, -6.79243952e-02f, 2.13166147e-01f, 2.15126052e-01f, 1.88340813e-01f, 2.90386647e-01f, 2.18482196e-01f, 2.83327132e-01f,
  -2.44138524e-01f, -1.35317836e-02f, 1.85544863e-01f, 8.69083107e-02f, -2.20901996e-01f, -1.94847472e-02f, 2.84180820e-01f, -1.41478628e-01f, 1.14051187e+00f, -2.95931417e-02f,
  8.56828988e-02f, -6.57219768e-01f, 2.15957850e-01f, -2.83953398e-02f, 4.17001128e-01f, 9.03759539e-01f, 1.85929447e-01f, 1.54510826e-01f, -1.08748123e-01f, 5.71582437e-01f,
  -7.61674196e-02f, 6.49028838e-01f, 1.10815060e+00f, 1.91565782e-01f, -1.69697300e-01f, 1.43657804e-01f, 3.18907797e-01f, 2.59251177e-01f, 3.50047588e-01f, 1.24607161e-01f,
  1.92528546e-01f, 1.44788191e-01f, 2.15184242e-02f, 2.19625980e-01f, 2.17763394e-01f, 1.19343780e-01f, -6.61530271e-02f, -2.75609475e-02f, -4.90398049e-01f, 1.98574334e-01f,
  -1.88550413e-01f, 4.35140401e-01f, 3.18932205e-01f, -2.47742549e-01f, 2.61696398e-01f, -4.11994942e-02f, 1.82486489e-01f, 1.53645128e-01f, -1.56818211e-01f, 3.88133645e-01f,
  2.21841231e-01f, 7.45925382e-02f, -3.14327478e-01f, 1.06279187e-01f, 7.13987470e-01f, -4.35741842e-01f, 9.90090430e-01f, 4.81072158e-01f, -1.60152704e-01f, -2.39086226e-01f,
  1.91973487e-03f, 1.44165725e-01f, 4.93319817e-02f, -1.31084463e-02f, 2.16790289e-01f, -5.55870309e-02f, 4.75754961e-02f, 1.29990324e-01f, 7.71433115e-02f, 5.76543026e-02f,
  -9.53557253e-01f, 5.95746875e-01f, 1.05888315e-01f, 5.79212785e-01f, 1.48749858e-01f, -1.50502636e-03f, -1.68044269e-01f, 2.26029292e-01f, 2.68011838e-01f, 5.06795287e-01f,
  -5.42487860e-01f, 5.10857880e-01f, 2.16375664e-01f, 1.77643716e-01f, 5.99621721e-02f, 3.33878756e-01f, 6.13870807e-02f, -5.49214900e-01f, 4.94064152e-01f, -4.48046416e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.32446694e-01f, 1.87447429e-01f, 5.54629982e-01f, 3.26777250e-01f, 3.60180140e-01f, -6.28544018e-02f, -4.71180826e-02f, 5.90058677e-02f, 3.38346153e-01f, 2.63226122e-01f,
  1.54581785e-01f, 6.93564862e-02f, 5.27520537e-01f, 2.47725304e-02f, 1.64263502e-01f, -6.37823865e-02f, 3.87387094e-03f, 3.71297121e-01f, 3.05708140e-01f, -1.74265534e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.19036385e-01f, -6.26411363e-02f, 2.71707773e-01f, -4.91348468e-02f, 4.05093163e-01f, 2.40132540e-01f, 2.92557895e-01f, -2.38902643e-01f, -4.40128416e-01f, -5.20701468e-01f,
  4.27792519e-01f, -8.05836320e-02f, -3.37423474e-01f, 8.41178745e-02f, 5.36845624e-02f, -1.57666847e-01f, 6.38840795e-01f, -8.29535663e-01f, -8.66148710e-01f, 4.95895855e-02f,
  3.81367058e-01f, -1.20317407e-01f, 1.27436340e-01f, -2.75395177e-02f, 1.16259873e-01f, 4.36192229e-02f, 1.77435040e-01f, -4.18750226e-01f, -6.15454674e-01f, 1.43754795e-01f,
  -3.45492482e-01f, 2.04243511e-01f, -3.09433583e-02f, 9.69411209e-02f, 2.28859529e-01f, 4.01611596e-01f, 2.06365049e-01f, 1.96264133e-01f, 3.88134301e-01f, 4.62545991e-01f,
  3.33528608e-01f, -1.14568044e-02f, -6.97952151e-01f, 4.88766491e-01f, 2.07215354e-01f, -1.05825141e-01f, -5.57235837e-01f, 4.39059913e-01f, -2.46671095e-01f, -2.19317272e-01f,
  1.58272550e-01f, -4.60618064e-02f, 1.63053721e-01f, 4.22299840e-02f, 1.11358784e-01f, 2.38565475e-01f, 4.81102675e-01f, -8.85877013e-01f, 9.47729424e-02f, -7.10210145e-01f,
  -5.22099376e-01f, 1.96501955e-01f, -6.12307370e-01f, -3.68954360e-01f, 1.38570949e-01f, 1.64232239e-01f, 3.84896755e-01f, 1.79481477e-01f, 1.16693325e-01f, 2.28071615e-01f,
  -5.55856049e-01f, -1.97202146e-01f, -5.64442992e-01f, 1.04572967e-01f, 4.24487948e-01f, 5.97531535e-02f, -7.13215232e-01f, -5.96501768e-01f, 5.53920090e-01f, -1.80170894e-01f,
  -9.50319543e-02f, -4.58541960e-01f, -3.37072730e-01f, -2.70333260e-01f, -2.81775683e-01f, 5.95065713e-01f, -1.45508647e-01f, -3.96743178e-01f, 4.44778413e-01f, -6.78740561e-01f,
  -6.07763648e-01f, -2.18757600e-01f, -2.06852034e-01f, 3.72931182e-01f, 3.39708298e-01f, -6.02143407e-01f, -3.86283621e-02f, -2.46981338e-01f, -5.03157020e-01f, -1.18149333e-01f,
  -6.41102552e-01f, -3.19726676e-01f, 1.15508780e-01f, 2.79787835e-02f, -8.34780395e-01f, 3.48137915e-01f, 2.19083190e-01f, -5.73427677e-01f, -6.25212073e-01f, -2.02381238e-01f,
  -8.16060543e-01f, -7.09370792e-01f, -3.55707407e-01f, -4.34479147e-01f, -2.13800505e-01f, -5.23698926e-01f, -3.86363357e-01f, -1.34898886e-01f, 3.83945853e-01f, 3.88079554e-01f,
  -1.79952279e-01f, 2.56906837e-01f, -5.94732881e-01f, 3.46227407e-01f, 2.37091407e-01f, 1.71709612e-01f, -1.30836954e-02f, 2.53239810e-01f, -3.63351375e-01f, -2.91027158e-01f,
  1.35572106e-01f, -6.75425589e-01f, -5.46735883e-01f, -3.25299166e-02f, -8.85451213e-02f, -7.39574805e-02f, 7.99076140e-01f, 1.25466451e-01f, -3.09927166e-01f, 3.83367062e-01f,
  -2.33379126e-01f, -1.30102351e-01f, -6.90390587e-01f, 1.15225017e-01f, -5.37718058e-01f, 1.33564457e-01f, 1.39751151e-01f, 2.39011087e-02f, 2.05536470e-01f, -3.65979046e-01f,
  -2.88453232e-02f, -7.06694782e-01f, -5.44893861e-01f, 2.53926694e-01f, 3.59812200e-01f, 1.03327490e-01f, 1.53053775e-01f, 1.21157669e-01f, 4.09944832e-01f, 1.64546594e-01f,
  1.88972533e-01f, 3.45562756e-01f, 2.81957202e-02f, 1.96888268e-01f, 2.38876060e-01f, 9.59769115e-02f, 1.74678013e-01f, 5.74810743e-01f, 7.38271534e-01f, -3.64130557e-01f,
  -5.56384325e-01f, 6.22595191e-01f, 1.48294838e-02f, -4.15518820e-01f, 9.70381558e-01f, 1.35527283e-01f, -5.85434616e-01f, 3.54994148e-01f, -7.47172311e-02f, -5.01585066e-01f,
  1.83265522e-01f, -2.93854058e-01f, -7.55651474e-01f, 2.60352671e-01f, -3.69763315e-01f, 3.76326859e-01f, 2.26810053e-01f, -2.74966042e-02f, -7.96665430e-01f, -1.68048292e-01f,
  -5.23877263e-01f, -3.40525687e-01f, -1.49990872e-01f, 2.82358199e-01f, 4.18786675e-01f, 3.11443776e-01f, -2.57242531e-01f, 4.88118678e-01f, 2.07924664e-01f, -5.44005156e-01f,
  -2.98851673e-02f, -3.73182520e-02f, 1.64919406e-01f, 3.36233526e-01f, 1.47333220e-01f, 4.18703020e-01f, 2.34255478e-01f, -1.23383045e-01f, 4.87510234e-01f, -6.96173131e-01f,
  -5.11434197e-01f, 3.55509758e-01f, -2.58771211e-01f, 2.80873597e-01f, -8.69891405e-01f, -6.13691509e-01f, 1.63718686e-01f, -2.22397298e-01f, -1.46421403e-01f, -1.46509781e-01f,
  -1.28153548e-01f, -8.69787514e-01f, 1.36013925e-02f, -3.14883918e-01f, -4.55029905e-01f, -2.05618039e-01f, -4.41939771e-01f, -1.65100738e-01f, -1.05092995e-01f, -5.19123733e-01f,
  -2.55673472e-02f, 2.53723800e-01f, -4.01000232e-01f, 8.95648971e-02f, -1.20441504e-01f, -3.32330525e-01f, 1.40166208e-01f, -7.08906770e-01f, 1.06604405e-01f, -4.16087359e-01f,
  1.90018311e-01f, 4.94378150e-01f, 2.94587225e-01f, -2.90792376e-01f, -3.78836781e-01f, -6.34604394e-01f, 3.23465586e-01f, -2.69410700e-01f, -5.30955672e-01f, -3.90130319e-02f,
  -4.28745031e-01f, -1.80130988e-01f, 5.96436411e-02f, -6.49169445e-01f, 2.07351163e-01f, 3.43914181e-01f, -1.24390759e-01f, -3.74168158e-01f, -4.40177917e-01f, -1.91889435e-01f,
  2.83294581e-02f, -2.62672693e-01f, -4.45987374e-01f, -8.71711895e-02f, 1.18572256e-02f, 7.50572681e-01f, 5.17192066e-01f, -6.76171303e-01f, -2.44710937e-01f, 2.38833398e-01f,
  1.44698083e-01f, 3.11040748e-02f, -3.78996909e-01f, 3.55383813e-01f, 3.44235897e-01f, 2.86325365e-01f, -3.27609092e-01f, 3.08091164e-01f, 2.67149776e-01f, 3.72791320e-01f,
  -1.01518057e-01f, -6.69213295e-01f, -2.22040657e-02f, 4.18408841e-01f, -5.95966935e-01f, -6.54819191e-01f, -7.87445188e-01f, -1.40691087e-01f, 1.22733079e-01f, 4.48522240e-01f,
  -3.01228881e-01f, -5.16234338e-01f, 5.07323921e-01f, 7.22963065e-02f, -7.08971798e-01f, -1.51993051e-01f, 3.30126405e-01f, -1.72738321e-02f, 2.93147981e-01f, 2.54284322e-01f,
  5.00816524e-01f, -5.67357838e-01f, -4.12724644e-01f, -5.33059597e-01f, -1.69220213e-02f, -4.83050197e-01f, -5.18371880e-01f, -5.47223687e-01f, 2.66815990e-01f, -6.92109168e-02f,
  -9.00469482e-01f, -5.78057230e-01f, -9.29600447e-02f, -3.16920102e-01f, -1.45855501e-01f, -5.78001857e-01f, 5.43862104e-01f, -2.95437843e-01f, 3.78006250e-01f, 4.88119900e-01f,
  -4.04178768e-01f, -4.45544451e-01f, -1.28121689e-01f, -3.04303199e-01f, -4.32250172e-01f, -4.93853778e-01f, 2.24802345e-01f, 1.85639352e-01f, -6.27197444e-01f, -1.40093654e-01f,
  4.77013856e-01f, -6.82001472e-01f, -5.04668891e-01f, -2.63440162e-01f, -5.61794996e-01f, 4.58484292e-01f, -2.57522106e-01f, 7.89153397e-01f, -5.83359420e-01f, -1.64079189e-01f,
  -4.72895950e-01f, 4.92256790e-01f, -2.79093325e-01f, 5.12696862e-01f, -6.56114876e-01f, -2.48144940e-01f, -3.64666998e-01f, -7.51526952e-01f, 1.31353328e-03f, 3.43182951e-01f,
  -1.97693169e-01f, -2.62709379e-01f, -2.08503500e-01f, -2.46257544e-01f, -5.29750288e-01f, -1.15443449e-02f, -7.24096224e-02f, -3.58931363e-01f, -5.86589158e-01f, -6.65439725e-01f,
  -5.82133591e-01f, -9.85799804e-02f, 2.22464129e-01f, -9.17155504e-01f, -3.92782576e-02f, 7.99471855e-01f, -4.95169878e-01f, -3.65434766e-01f, -4.77922380e-01f, -5.35647213e-01f,
  -4.08825904e-01f, 5.33728123e-01f, -3.49571496e-01f, -8.22934806e-01f, 4.34318393e-01f, -7.93351531e-01f, 6.64212778e-02f, 6.38401806e-02f, 1.31581262e-01f, 6.30489945e-01f,
  3.15322191e-01f, -3.16723168e-01f, -1.88338548e-01f, -3.53592724e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.49830091e-02f, 1.09713294e-01f, 1.18048541e-01f, -5.85872948e-01f, -3.28703001e-02f, 1.87950686e-01f, 4.27611507e-02f, -1.48764402e-01f, -5.20533323e-01f, 9.34717245e-03f,
  -3.45029414e-01f, -2.99854100e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    