/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.01192427e-01f, -1.30382683e-02f, -3.15128975e-02f, -3.35704200e-02f, -5.83342873e-02f, 5.98864332e-02f, 8.13788101e-02f, 8.06135982e-02f, 4.07211818e-02f, 1.93479061e-01f,
  1.16677366e-01f, 1.71863101e-02f, 5.32211997e-02f, 5.22924289e-02f, -1.01934616e-02f, -9.26114619e-02f, 3.51981893e-02f, 4.93667610e-02f, -3.92882377e-02f, 3.52507867e-02f,
  -5.18725514e-02f, -7.47103384e-03f, 1.26179052e-03f, -2.87887622e-02f, 3.05641908e-02f, -4.25425731e-03f, 1.92397460e-02f, 1.65318772e-02f, 7.07615986e-02f, -8.81919544e-03f,
  -7.05558760e-03f, 1.02017045e-01f, -1.26233995e-02f, 2.38625035e-02f, -1.20505586e-03f, -2.21121497e-02f, 9.30912234e-03f, -7.10886493e-02f, -3.94689478e-02f, 2.69188900e-02f,
  -4.23372462e-02f, -2.17892341e-02f, -1.48088811e-02f, -1.54110854e-02f, -1.45539762e-02f, 1.01724258e-02f, 2.15655658e-02f, -5.06798699e-02f, -9.36335139e-03f, 1.58007499e-02f,
  5.63784204e-02f, -4.71518338e-02f, 2.28342377e-02f, -1.22150593e-02f, 1.95743013e-02f, -6.68566022e-03f, 2.32865959e-02f, -9.78378463e-04f, 5.34472317e-02f, -1.60964672e-02f,
  1.42768966e-02f, -2.20699944e-02f, -3.56691964e-02f, 1.95323955e-02f, 2.65878942e-02f, 1.56908259e-02f, 4.05373201e-02f, 4.26707268e-02f, -2.27492154e-02f, -2.39371713e-02f,
  1.88925769e-02f, 1.63293555e-02f, 1.70056168e-02f, 2.10036561e-02f, 2.60813776e-02f, -1.81192439e-02f, 1.19660003e-02f, 6.50884733e-02f, 2.43745502e-02f, 1.63902026e-02f,
  2.27716677e-02f, -1.30430944e-02f, -3.67882475e-02f, 6.34782994e-03f, -1.77425537e-02f, -1.07913231e-02f, 6.04691394e-02f, 5.52357100e-02f, 4.60861400e-02f, -5.26857153e-02f,
  1.27687588e-01f, 2.05274820e-02f, 7.92010874e-02f, 2.55726203e-02f, 5.10138348e-02f, -3.90703464e-03f, -2.46814974e-02f, -5.90675585e-02f, 4.41166982e-02f, -4.53391373e-02f,
  3.44438333e-04f, -8.50670487e-02f, -2.54230872e-02f, 5.43486588e-02f, -6.02255284e-04f, 7.08254725e-02f, 6.17436692e-02f, 4.17639911e-02f, 2.68432833e-02f, 1.78114362e-02f,
  2.60313470e-02f, 1.75857171e-02f, -4.10353653e-02f, -2.89198328e-02f, -5.72249852e-02f, 2.75244303e-02f, -7.59689063e-02f, 3.28986011e-02f, -4.65782210e-02f, -1.50258606e-02f,
  -6.21989191e-01f, 1.63490698e-02f, -8.67474750e-02f, -5.57593629e-02f, -1.48887085e-02f, -4.63299267e-03f, 6.98675737e-02f, -9.27787423e-02f, -1.69685975e-01f, 3.91384363e-02f,
  1.15709290e-01f, -1.09138682e-01f, 6.01823218e-02f, 9.72272828e-02f, 3.01069375e-02f, 1.25002936e-01f, -6.37487918e-02f, -7.68171400e-02f, -8.32077041e-02f, -9.15604681e-02f,
  -5.45455553e-02f, 2.02870086e-01f, 6.37723804e-02f, 1.17882974e-01f, 6.22953326e-02f, 7.14169489e-03f, 1.63409323e-01f, 4.32174727e-02f, 1.31681874e-01f, 1.75271839e-01f,
  3.74015719e-02f, 5.76079711e-02f, -3.10293902e-02f, 2.71138716e-02f, 7.14106346e-03f, -2.46633478e-02f, 2.90517006e-02f, 9.49960649e-02f, -7.83518553e-02f, -1.43173961e-02f,
  2.55914479e-02f, 3.71454284e-02f, -2.88351090e-03f, 1.38490051e-02f, -1.63415056e-02f, -6.30709901e-02f, -4.72737215e-02f, -4.28431258e-02f, 2.92437561e-02f, 7.91887008e-03f,
  -4.89003696e-02f, 4.63049673e-02f, 1.30096469e-02f, 7.16721267e-02f, -4.38065641e-02f, 1.71451736e-02f, -1.14833852e-02f, 3.42221186e-02f, 2.18639225e-02f, -3.63024287e-02f,
  3.34112905e-02f, 4.52224538e-02f, 5.52375130e-02f, 5.23354188e-02f, 4.38939258e-02f, 9.07508750e-03f, 2.21797191e-02f, 4.47666980e-02f, -5.96569777e-02f, 6.92962632e-02f,
  -1.69122405e-02f, 6.51854044e-03f, 1.58716124e-02f, -5.03500514e-02f, 2.97161676e-02f, -2.85631325e-02f, -4.46807295e-02f, 4.15944196e-02f, -7.28394762e-02f, -2.81647667e-02f,
  9.09312814e-03f, -1.30269760e-02f, 5.05374894e-02f, 4.54438142e-02f, 6.11663610e-02f, 6.08019605e-02f, 2.20856573e-02f, -1.53386239e-02f, 3.71369906e-02f, -2.56047007e-02f,
  1.00452289e-01f, 3.20252329e-02f, 4.08192724e-02f, -1.26549660e-03f, 3.61896046e-02f, 2.06760434e-03f, 2.09911242e-02f, -2.81297211e-02f, -3.04140104e-03f, 1.89318061e-02f,
  -3.01355775e-03f, 2.28744894e-02f, 9.71828867e-03f, 2.16094777e-03f, 2.41670962e-02f, -4.59214300e-03f, 4.27238569e-02f, -2.54530571e-02f, 3.24351876e-03f, -4.31515723e-02f,
  1.75102297e-02f, -3.86897288e-02f, 3.22684762e-03f, -4.20834161e-02f, -2.31269542e-02f, 3.17918211e-02f, -6.67981654e-02f, -4.90445048e-02f, 6.30147057e-03f, -3.01743280e-02f,
  -1.15508147e-01f, 5.93253002e-02f, -3.62223297e-01f, -7.60799050e-02f, -1.07142910e-01f, -8.49954970e-03f, -1.42583922e-01f, -2.40121726e-02f, -4.59762514e-02f, 2.97694564e-01f,
  4.93375324e-02f, -1.20505579e-01f, 5.40240034e-02f, 4.92533445e-02f, -8.21506828e-02f, -1.46264751e-02f, 7.03520561e-03f, 9.23318490e-02f, -1.13942251e-01f, 4.79537286e-02f,
  -1.29601687e-01f, 1.52583972e-01f, -2.32543707e-01f, -2.30877381e-02f, -6.86115101e-02f, -1.31699473e-01f, 1.02653034e-01f, -1.33629739e-01f, -2.90660392e-02f, -1.17973804e-01f,
  7.84817934e-02f, -8.36467743e-02f, -4.51328643e-02f, -9.44359154e-02f, -2.69931760e-02f, 5.80005348e-03f, -9.99226514e-03f, -9.65522677e-02f, -4.73608710e-02f, -6.70756726e-03f,
  4.38042823e-03f, 2.11623199e-02f, -5.00776283e-02f, -1.11632068e-02f, 1.14687756e-02f, -4.60409299e-02f, -2.02636737e-02f, -3.50522771e-02f, -3.30900103e-02f, -6.04893826e-02f,
  -5.68334721e-02f, -3.98261733e-02f, -4.72455584e-02f, -5.63797913e-03f, -5.59554547e-02f, -2.15207483e-03f, -1.40013499e-02f, -7.25943819e-02f, -4.98504424e-03f, -4.77622598e-02f,
  -1.04413055e-01f, -6.92623034e-02f, -3.95606570e-02f, 4.27235439e-02f, -2.39842813e-02f, 3.40339541e-02f, 1.14695793e-02f, 9.03782621e-03f, 1.88390464e-02f, 2.08466500e-02f,
  -4.36716601e-02f, 3.43770571e-02f, 1.62833091e-02f, -2.71117054e-02f, 3.36350612e-02f, 3.61228362e-02f, -2.47220676e-02f, -2.90718153e-02f, 1.84183288e-03f, -3.59134860e-02f,
  6.23178706e-02f, -1.29792718e-02f, 3.64467688e-02f, -1.37458723e-02f, -2.59989873e-02f, -1.86148118e-02f, 4.45948765e-02f, -2.61903293e-02f, -4.09138668e-03f, -2.13672798e-02f,
  2.68857926e-01f, 1.08030267e-01f, 8.63837823e-03f, 9.00334492e-02f, 5.86201288e-02f, 7.08875954e-02f, -5.41061126e-02f, 2.75574718e-02f, 1.19326739e-02f, 2.05161572e-02f,
  3.03585287e-02f, 8.01596791e-03f, 5.31183034e-02f, -3.95219140e-02f, -3.40142474e-03f, 5.91117330e-02f, -5.83056435e-02f, 2.11732257e-02f, 7.15761781e-02f, -2.69174036e-02f,
  5.07612079e-02f, 2.77880803e-02f, 2.18634401e-02f, 1.71573181e-02f, 2.25953944e-02f, -4.36037183e-02f, 4.57677580e-02f, -8.10148269e-02f, 7.25676725e-03f, -5.78407489e-04f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.34151250e-01f, 1.49956301e-01f, 1.51194623e-02f, -3.42383347e-02f, -1.11534745e-01f, -4.97467250e-01f, -3.48079205e-01f, 9.71525088e-02f, -2.19039574e-01f, -1.81573614e-01f,
  -3.97755168e-02f, -1.25881480e-02f, 1.34730667e-01f, -1.36133596e-01f, -1.80063993e-01f, -3.40078995e-02f, -1.14888676e-01f, -1.58280805e-01f, 8.95100683e-02f, 1.25771359e-01f,
  4.52195108e-02f, 9.95289311e-02f, 2.41525427e-01f, 2.11814746e-01f, -7.65417144e-02f, 2.23152697e-01f, 3.43154073e-01f, 1.95748910e-01f, 5.43935150e-02f, 1.64406095e-02f,
  -2.21752331e-01f, -6.24612197e-02f, -9.53800827e-02f, -2.18116064e-02f, -4.84936079e-03f, -7.50015154e-02f, -4.98935804e-02f, -1.38940006e-01f, -6.67117015e-02f, -5.16878776e-02f,
  -2.96812989e-02f, 5.62129654e-02f, -8.82689655e-02f, 3.65383667e-03f, -4.22725827e-02f, 8.41081422e-03f, 7.96089098e-02f, -5.47609515e-02f, -2.64643226e-02f, 5.95134236e-02f,
  -1.87784173e-02f, -9.62057896e-03f, 1.64216310e-02f, -3.41982991e-02f, 6.71458170e-02f, -6.47766590e-02f, -4.02246974e-02f, -7.43431151e-02f, -8.47190544e-02f, 5.47134643e-03f,
  7.77679458e-02f, 1.40226400e-02f, -6.12956146e-03f, 1.41373202e-02f, 2.40479410e-02f, -3.12449746e-02f, 7.05011329e-03f, -6.26883795e-03f, -2.34024934e-02f, 1.77137461e-02f,
  -8.61414745e-02f, 1.02782257e-01f, -5.60674109e-02f, -2.65294462e-02f, 2.30717147e-03f, 5.68326302e-02f, -2.03663018e-02f, -3.42494845e-02f, 1.26247564e-02f, -5.70178824e-03f,
  -4.01523188e-02f, 2.12458670e-02f, -5.18089011e-02f, 3.35456952e-02f, -1.04452707e-01f, 9.04228687e-02f, 8.95540938e-02f, 2.15552412e-02f, 1.46775153e-02f, 1.55374063e-02f,
  1.06460474e-01f, 3.65712523e-01f, 2.35068724e-02f, -5.04027568e-02f, -5.57724852e-03f, -1.18291572e-01f, -5.65014221e-02f, 5.64859398e-02f, 1.10135369e-01f, 5.37264198e-02f,
  -3.11902980e-03f, -8.61588940e-02f, 1.78633928e-02f, -3.78783010e-02f, 1.95881929e-02f, 2.59438157e-02f, 1.41478226e-01f, 3.88205051e-02f, -4.59958985e-02f, 3.35656628e-02f,
  1.20762028e-01f, -2.39482075e-02f, -7.52348006e-02f, -4.62076254e-02f, -9.76133998e-03f, 7.67291524e-03f, -2.77349465e-02f, 6.20850250e-02f, 1.21268369e-01f, 3.73441465e-02f,
  -2.05408961e-01f, -9.65327770e-02f, -2.05025256e-01f, -2.07032576e-01f, 3.39875259e-02f, -3.36507373e-02f, -1.42986640e-01f, -1.71254966e-02f, -1.26131237e-01f, 1.33009017e-01f,
  -1.00696430e-01f, -7.56578445e-02f, 1.01317585e-01f, -2.60720849e-01f, -2.23728970e-01f, -1.10100321e-01f, -2.83510149e-01f, -9.70013440e-02f, -7.64145553e-02f, -9.02649760e-02f,
  -2.37246435e-02f, -1.89123750e-01f, -2.09972396e-01f, 1.11493897e-02f, -7.15584457e-02f, 5.16629368e-02f, 1.07961103e-01f, 1.06691122e-01f, 4.63423729e-02f, 2.50915568e-02f,
  -6.43613860e-02f, -6.01347871e-02f, 3.00332904e-02f, -1.34019675e-02f, 3.58301960e-02f, 1.04470193e-01f, -7.27313943e-03f, -1.23600904e-02f, 3.58199999e-02f, -8.08941498e-02f,
  5.42790964e-02f, -5.33195324e-02f, 2.18409766e-02f, 5.72631843e-02f, -4.26891744e-02f, -4.87376377e-02f, -9.98459309e-02f, -4.36229929e-02f, -3.53878289e-02f, -3.71405929e-02f,
  -5.53131811e-02f, 1.53552452e-02f, 2.87246564e-03f, -2.12029647e-03f, 3.62812728e-02f, -1.87377185e-02f, -1.02551028e-01f, -6.95126690e-03f, 6.06839021e-04f, -4.70139198e-02f,
  8.01325366e-02f, 7.40971342e-02f, -9.54851694e-03f, 2.11347733e-02f, -5.26502691e-02f, 4.94783856e-02f, 1.69476140e-02f, 6.34319484e-02f, 3.79852094e-02f, 5.27088381e-02f,
  7.19733012e-04f, 6.07969016e-02f, 7.33906403e-02f, 5.13384752e-02f, -1.80929282e-03f, 2.94668321e-03f, 2.40090098e-02f, 3.03413011e-02f, -7.91493505e-02f, -7.41467476e-02f,
  -2.66659743e-04f, 6.93890899e-02f, -1.29192527e-02f, 3.49700004e-02f, 5.08538894e-02f, 4.48711105e-02f, 2.86751762e-02f, 2.11625118e-02f, 4.23874818e-02f, 1.78025793e-02f,
  -1.24629261e-02f, 4.92508523e-02f, -7.29116872e-02f, -9.62304547e-02f, -5.52963866e-05f, 5.53143537e-03f, -5.33165000e-02f, 3.12192440e-02f, -4.77594789e-03f, 2.02139039e-02f,
  4.40419577e-02f, 2.71705054e-02f, 4.25399989e-02f, -3.47663015e-02f, -2.43121050e-02f, 1.50214601e-02f, 9.74367280e-03f, 9.65286195e-02f, 9.99045838e-03f, -4.28806916e-02f,
  -1.51522439e-02f, 6.21447377e-02f, -3.14203501e-02f, 2.30491646e-02f, -2.32264679e-02f, 2.87956223e-02f, 7.90494960e-03f, 3.38441059e-02f, -1.46741765e-02f, -1.35002809e-03f,
  -1.31869400e-02f, 1.24719394e-02f, -8.46268311e-02f, 3.03638637e-01f, 3.75918746e-02f, -7.80205382e-03f, -1.70073479e-01f, 2.04898372e-01f, -5.94523363e-02f, 3.35163474e-02f,
  2.42714450e-01f, 5.84180020e-02f, -9.68745276e-02f, 5.16207397e-01f, 3.13988119e-01f, 4.86778021e-02f, 3.37941408e-01f, 1.47027105e-01f, 2.18321383e-02f, 8.09339285e-02f,
  2.22227648e-01f, 3.03705931e-01f, 2.62491137e-01f, 2.61716455e-01f, 8.50064531e-02f, -5.96350841e-02f, 9.52495113e-02f, -9.25213471e-02f, 2.98302770e-01f, 1.26287162e-01f,
  7.40179941e-02f, 4.18502279e-02f, -7.34680071e-02f, -6.48122653e-02f, -2.57818867e-03f, -4.26068455e-02f, -3.93709429e-02f, -3.89390551e-02f, 9.62032378e-02f, 1.16840200e-02f,
  -8.45118687e-02f, -4.40047868e-03f, 1.25744417e-01f, 3.72942872e-02f, -4.30592801e-03f, 2.43456904e-02f, -6.53128792e-03f, 3.04036401e-02f, -4.34194170e-02f, -9.63319764e-02f,
  2.75371876e-02f, 5.29573895e-02f, 5.16590150e-03f, 7.67086865e-03f, 8.58773142e-02f, 1.25921834e-02f, -3.13911587e-02f, 2.48527378e-02f, 8.08694735e-02f, 1.50661639e-04f,
  6.65782392e-02f, -1.76113583e-02f, 2.97638755e-02f, 5.55604622e-02f, 1.32905245e-02f, 9.39662233e-02f, 7.68312216e-02f, -2.59553343e-02f, -2.38649305e-02f, 2.13493444e-02f,
  1.21545056e-02f, 1.42454598e-02f, -1.08901905e-02f, -7.44758919e-03f, 2.52555702e-02f, 9.33629833e-03f, -4.89549562e-02f, 4.04179422e-03f, -6.41080691e-03f, 8.44268128e-02f,
  -8.88487548e-02f, -1.11161275e-02f, 6.08766302e-02f, -7.64018968e-02f, 3.08392476e-03f, -6.39523417e-02f, 1.27422065e-01f, 4.48228382e-02f, 1.23177897e-02f, -5.94565785e-03f,
  5.93860224e-02f, 1.13038972e-01f, -5.54838181e-02f, 1.61474769e-03f, -7.82661326e-03f, 5.32328412e-02f, -3.61092314e-02f, 1.03418201e-01f, -2.26496495e-02f, 8.27540979e-02f,
  -4.86918874e-02f, -7.69941732e-02f, 1.19168423e-02f, 6.82738796e-02f, 1.07583202e-01f, 7.04279914e-02f, 6.25360385e-02f, 4.36790287e-03f, 4.58636172e-02f, 1.19796716e-01f,
  -3.22525203e-02f, -2.35077459e-02f, -3.18235569e-02f, -1.22299818e-02f, 8.98370892e-02f, -8.23451653e-02f, -4.86905836e-02f, -1.32345101e-02f, 2.02674549e-02f, 4.20921110e-02f,
  5.35683520e-02f, -1.11758888e-01f, -2.98189461e-01f, 7.74705261e-02f, 1.87409818e-02f, 6.58392832e-02f, 1.74443737e-01f, -7.84035213e-03f, -2.44499013e-01f, 6.92321137e-02f,
  2.45821595e-01f, 2.72381436e-02f, 5.87874278e-02f, 3.99368107e-01f, 1.75017476e-01f, 4.65181768e-02f, 2.80520767e-01f, 1.54069737e-01f, -3.26637030e-02f, -6.46342384e-03f,
  4.57476825e-02f, 3.56696069e-01f, 1.58449471e-01f, 1.38776377e-01f, 2.18590394e-01f, 1.43444445e-02f, 8.39270577e-02f, -5.67343719e-02f, 2.23078907e-01f, 1.85696200e-01f,
  1.75816134e-01f, -6.77483827e-02f, -5.76843806e-02f, -5.36501966e-02f, -2.68767308e-02f, -5.12486463e-03f, 4.38704267e-02f, 9.51835290e-02f, -5.89563325e-02f, -4.75529842e-02f,
  1.99482683e-02f, 1.04526356e-02f, -5.53156212e-02f, 2.78913844e-02f, 1.08706923e-02f, -2.30205636e-02f, -6.37655845e-03f, 6.20141290e-02f, -2.04536118e-04f, 3.48817761e-04f,
  -6.20258488e-02f, 2.30950061e-02f, -5.41157089e-02f, 2.68300176e-02f, -9.95479748e-02f, 3.98976244e-02f, 5.17790169e-02f, -5.18649407e-02f, -1.11117847e-01f, 4.40276302e-02f,
  -7.07493797e-02f, -8.23901873e-03f, -2.55441759e-02f, 2.70421188e-02f, 2.31696037e-03f, -3.99775431e-02f, 1.18276253e-01f, -4.31962684e-02f, 1.08890878e-02f, -6.62536025e-02f,
  1.62980659e-03f, -4.98258621e-02f, -3.92818414e-02f, 1.91690680e-02f, -6.11724257e-02f, -5.29213957e-02f, 1.82862468e-02f, 3.22960168e-02f, -1.17056884e-01f, -4.60089790e-03f,
  2.04746462e-02f, 4.79073003e-02f, -5.67118302e-02f, 9.85210836e-02f, -4.02457304e-02f, -1.94376204e-02f, -1.19602419e-02f, -1.02138646e-01f, -1.30351856e-01f, 2.09269039e-02f,
  -9.52875428e-03f, -1.19001485e-01f, -3.45257893e-02f, 8.35484862e-02f, -5.91209941e-02f, 8.33402108e-03f, -5.80853224e-03f, 5.32948039e-02f, -1.24722505e-02f, -2.49254573e-02f,
  2.31068954e-02f, 8.48236680e-02f, 3.66000012e-02f, -8.91745929e-03f, -2.50396580e-02f, -1.06958881e-01f, -3.45764421e-02f, 1.49098374e-02f, -3.67772067e-03f, 6.30666912e-02f,
  4.58576344e-02f, 4.01206315e-02f, -7.67612606e-02f, -2.09456608e-02f, -4.22520796e-03f, 6.81335405e-02f, 1.22272726e-02f, -7.87328631e-02f, 5.60870357e-02f, 4.92921919e-02f,
  2.11635470e-01f, 2.43937016e-01f, 1.75053373e-01f, 7.12575158e-03f, -1.49828449e-01f, -2.23634258e-01f, -1.05108723e-01f, -1.17118053e-01f, 3.05428002e-02f, 1.14981130e-01f,
  -1.09743007e-01f, 2.53870666e-01f, 7.45498808e-03f, 1.03484485e-02f, -2.64907241e-01f, -1.44200698e-01f, -1.42000794e-01f, 1.54889124e-02f, -5.93074262e-02f, -1.19336816e-02f,
  -3.98804434e-02f, -1.89746782e-01f, 1.00565247e-01f, -2.17257962e-02f, 1.69196680e-01f, 1.98639229e-01f, 3.86973396e-02f, 2.57594790e-02f, 1.23000406e-01f, -1.03847899e-01f,
  5.76752983e-02f, 9.06168018e-03f, 1.64245158e-01f, 8.08297768e-02f, 9.57437512e-03f, 1.81136709e-02f, 2.95339525e-02f, -9.19612299e-04f, 3.53713222e-02f, -6.50383905e-02f,
  -2.06279103e-03f, 4.80166301e-02f, -2.77031753e-02f, 2.73175649e-02f, 5.62595800e-02f, -3.86153646e-02f, 6.72698691e-02f, 4.34330814e-02f, 1.50887258e-02f, 1.06662195e-02f,
  1.53782740e-01f, -3.18406560e-02f, -5.62388599e-02f, 1.90199621e-03f, 7.57846534e-02f, -6.25216290e-02f, 3.93361971e-02f, 6.16639256e-02f, 4.34137098e-02f, 1.06346514e-02f,
  2.12868005e-02f, -1.17631182e-01f, -5.45696020e-02f, -2.02314984e-02f, -1.71630252e-02f, -7.53523186e-02f, -8.34402964e-02f, 2.00420115e-02f, -3.33838128e-02f, -4.98641990e-02f,
  -3.80202867e-02f, 7.17362240e-02f, -3.07178334e-03f, -4.83124107e-02f, -2.72944551e-02f, -3.16589996e-02f, 2.94777863e-02f, -3.93946841e-02f, 3.66481394e-02f, 7.32699335e-02f,
  -1.06983922e-01f, 5.67184994e-03f, -7.61408033e-03f, -6.82017133e-02f, -2.46884972e-02f, 6.47497997e-02f, 5.83883189e-02f, -4.55495007e-02f, 4.58809771e-02f, -6.48932904e-02f,
  -3.60756554e-02f, -1.23494188e-03f, 5.04518896e-02f, -8.69153999e-04f, -4.83263936e-03f, -9.12015326e-03f, -4.96575460e-02f, -2.95022018e-02f, -3.20914127e-02f, 6.13066694e-03f,
  2.89393440e-02f, -3.82758081e-02f, -2.23477148e-02f, 9.00793297e-04f, -2.50836276e-02f, -7.06274435e-02f, 5.48883528e-02f, -6.78496808e-02f, 3.00881080e-02f, 7.56973848e-02f,
  4.62045446e-02f, 1.26235317e-02f, 4.17131446e-02f, 4.76491936e-02f, -2.47272942e-02f, -4.39492501e-02f, -8.72898102e-02f, 4.41846065e-02f, 6.97132871e-02f, -6.47634268e-02f,
  4.88567762e-02f, -9.15108174e-02f, -1.12307696e-02f, 1.28468275e-02f, 9.93130952e-02f, 4.06676345e-02f, 1.47998869e-01f, -1.43004775e-01f, -9.44250673e-02f, -1.78073213e-01f,
  -8.33293702e-03f, -8.65127295e-02f, 3.69012542e-02f, -1.07407756e-01f, 1.11684941e-01f, -9.58115682e-02f, -5.04110046e-02f, -2.89411955e-02f, -3.74945179e-02f, -7.27812573e-02f,
  5.04400656e-02f, 5.00830188e-02f, -5.49331494e-02f, -3.26889716e-02f, -8.45245644e-02f, 6.36663102e-03f, 1.80887878e-02f, 4.81154025e-02f, 1.42375510e-02f, 8.51951838e-02f,
  3.82056497e-02f, 4.38737907e-02f, -1.43990917e-02f, -4.12422232e-02f, 8.97702798e-02f, 3.74521427e-02f, -6.75336495e-02f, -6.07615300e-02f, 1.00269444e-01f, -1.89863015e-02f,
  9.54409540e-02f, 6.94339350e-02f, -5.14595844e-02f, 1.34682972e-02f, 3.37251313e-02f, -5.26147187e-02f, -3.20868567e-02f, 9.53461528e-02f, -9.03240740e-02f, -6.31860644e-02f,
  5.75679168e-02f, 6.37685806e-02f, -3.18215266e-02f, -1.00155689e-01f, -4.35362756e-02f, 5.40057272e-02f, -4.89621274e-02f, -3.64022814e-02f, -3.80806178e-02f, -2.89044660e-02f,
  -8.04487169e-02f, 1.55065879e-02f, 1.92677584e-02f, 5.53160422e-02f, -1.61665294e-03f, 8.72420743e-02f, 1.87143665e-02f, 4.82315682e-02f, 2.44364589e-02f, 2.05891244e-02f,
  -2.52831522e-02f, 3.63567062e-02f, 2.04862300e-02f, -1.88561380e-02f, 7.77937844e-02f, 2.98936553e-02f, -1.00182630e-01f, 4.59531099e-02f, -3.45239490e-02f, 3.51709910e-02f,
  4.11444157e-02f, 1.87867060e-02f, -4.79334928e-02f, -5.49464263e-02f, -7.98392072e-02f, 3.10836155e-02f, -7.94645101e-02f, -5.44940494e-02f, -3.68186720e-02f, 4.55191955e-02f,
  6.39264435e-02f, -1.20633520e-01f, -7.98367411e-02f, -1.43496450e-02f, -5.57885915e-02f, -1.52315516e-02f, -8.01397637e-02f, -7.65084429e-03f, 1.20568220e-02f, 4.89171594e-02f,
  6.65324926e-02f, -3.92591916e-02f, 4.60876748e-02f, 7.22092763e-02f, 5.08042164e-02f, -3.58677423e-03f, 1.23939905e-02f, 1.61953419e-02f, 3.49503122e-02f, 2.30351444e-02f,
  -4.54906374e-02f, 3.20092328e-02f, -1.82772782e-02f, 5.09666726e-02f, -9.20004994e-02f, -3.72207984e-02f, 7.76311085e-02f, -4.65395227e-02f, -5.63501008e-02f, -9.10231750e-03f,
  -1.68552950e-01f, 5.85344732e-02f, -5.20526059e-02f, -2.23378152e-01f, 1.04053535e-01f, -1.13770336e-01f, -2.29054093e-01f, 5.74904457e-02f, -1.39673278e-01f, 2.80861743e-02f,
  -8.08041617e-02f, 4.53483015e-02f, 9.91832986e-02f, -2.22096816e-01f, -2.51030684e-01f, 1.60702448e-02f, -2.54378200e-01f, -1.68610007e-01f, 1.31688401e-01f, -5.99861071e-02f,
  -1.15879655e-01f, -6.77515939e-02f, -4.44539487e-02f, 6.09024912e-02f, -1.20857179e-01f, -2.67574638e-02f, 1.98934656e-02f, 8.53072554e-02f, -4.90346225e-03f, -1.64014064e-02f,
  -2.45293463e-03f, -1.13033794e-01f, -3.25104073e-02f, 3.13564166e-02f, -1.36182547e-01f, -7.42290914e-02f, -1.13279633e-01f, 6.21288195e-02f, 1.52558591e-02f, 3.96270156e-02f,
  5.24037071e-02f, -3.32293846e-02f, 7.77601674e-02f, 6.15782924e-02f, 3.27212438e-02f, 2.73141414e-02f, 8.17622170e-02f, 9.41222347e-03f, 4.06655557e-02f, -6.02082424e-02f,
  9.85321850e-02f, -1.88000929e-02f, 1.15270643e-02f, -4.75414917e-02f, -2.95261219e-02f, 5.87965772e-02f, -5.08511774e-02f, 4.72792238e-02f, 3.76950800e-02f, -6.31589144e-02f,
  -5.61050586e-02f, -6.48997948e-02f, -4.94921114e-04f, -3.40586044e-02f, -4.58054654e-02f, -1.07294716e-01f, 2.71130204e-02f, -4.11277898e-02f, -2.23733727e-02f, 2.79880315e-02f,
  2.53734980e-02f, -2.73548868e-02f, -2.16879067e-03f, -2.76285559e-02f, 1.32936351e-02f, -8.20876136e-02f, 9.40575376e-02f, -5.54900095e-02f, 1.72520580e-03f, 5.75507581e-02f,
  2.07957160e-02f, 5.62898666e-02f, -2.16504987e-02f, -2.68155169e-02f, 5.71531579e-02f, -9.53405816e-03f, 6.88948929e-02f, 3.09688840e-02f, -8.04426149e-02f, 8.03151354e-03f,
  -1.08137392e-01f, -9.35536996e-02f, -1.86278522e-02f, 4.46875803e-02f, 1.28145134e-02f, -3.32479528e-03f, 4.27919552e-02f, 4.28191051e-02f, -8.96523148e-02f, -8.88487175e-02f,
  -1.03061363e-01f, 7.61615261e-02f, -1.95350014e-02f, 4.99200001e-02f, -7.15426505e-02f, -4.64031622e-02f, -6.63602278e-02f, 2.86859702e-02f, -7.21031502e-02f, -7.45457783e-02f,
  -1.06331916e-03f, 3.96884829e-02f, -4.25175726e-02f, 6.12376444e-02f, 2.39095814e-03f, -4.46217991e-02f, 2.61153430e-02f, -5.52843474e-02f, 1.45376865e-02f, 4.77171037e-03f,
  8.96028429e-03f, -8.76722038e-02f, -4.77795377e-02f, -1.12391613e-01f, -4.08202522e-02f, -2.12512955e-01f, -8.74320045e-02f, -4.91875745e-02f, 2.19313428e-02f, -9.34333801e-02f,
  -4.54782471e-02f, 4.21998687e-02f, 7.42541030e-02f, -2.45120049e-01f, 9.31148455e-02f, 2.51773372e-02f, -2.14917257e-01f, -7.13706240e-02f, -1.78663004e-02f, -1.64533079e-01f,
  -3.20412475e-03f, -2.12363690e-01f, -2.68507581e-02f, -1.47247374e-01f, -1.52612314e-01f, -1.40053377e-01f, 1.37383521e-01f, -1.18501715e-01f, -3.90069559e-02f, -7.53359273e-02f,
  -7.49775097e-02f, -9.36870426e-02f, -2.45539546e-02f, -1.70198735e-02f, -7.10948184e-02f, 1.37040159e-03f, 3.75540257e-02f, -1.30494824e-02f, -6.33570403e-02f, -4.24866267e-02f,
  3.68331634e-02f, -4.46830392e-02f, -1.98432934e-02f, 3.17238979e-02f, 2.50047520e-02f, 2.74760425e-02f, -7.25152716e-02f, 7.96203315e-03f, -2.99491622e-02f, 4.11894955e-02f,
  2.01462377e-02f, 7.44998734e-03f, -3.91080603e-02f, 6.52646199e-02f, 7.31118768e-02f, -8.18848535e-02f, 3.97787429e-02f, 1.18548237e-01f, 5.56009151e-02f, 6.03927076e-02f,
  -7.58757070e-02f, 1.72209647e-02f, -2.91339960e-02f, 8.79503228e-03f, -6.59850463e-02f, -7.48317912e-02f, -9.19964239e-02f, 7.34910443e-02f, 8.82851556e-02f, -4.32532504e-02f,
  6.24382682e-02f, 9.86525640e-02f, -7.16887861e-02f, 9.75726917e-02f, -3.50431241e-02f, 2.91048307e-02f, -2.98904497e-02f, -3.02453600e-02f, -1.66851608e-03f, 7.90331513e-02f,
  1.75427506e-03f, -7.10680559e-02f, -1.62310693e-02f, 2.29756739e-02f, -5.58964200e-02f, -2.61890702e-02f, 3.83325964e-02f, -3.22702080e-02f, -3.39242704e-02f, 4.86509465e-02f,
  -1.78259358e-01f, -5.44515662e-02f, 1.97902545e-02f, 5.58810309e-02f, -6.78101853e-02f, 8.25707987e-03f, -2.82453801e-02f, -3.53225730e-02f, -8.35422426e-02f, 4.65244390e-02f,
  -5.78685142e-02f, 5.48167452e-02f, 2.46196869e-03f, 5.20907529e-02f, -3.03196553e-02f, -1.08353168e-01f, 3.60970595e-03f, -3.73657938e-04f, -8.76740203e-04f, 2.86858417e-02f,
  -2.28170827e-02f, -4.66048084e-02f, 4.30074567e-03f, -2.61014495e-02f, -2.19157655e-02f, -3.52803878e-02f, -1.78693812e-02f, 6.45455122e-02f, 2.83078067e-02f, 6.16266541e-02f,
  1.61168411e-01f, 3.01854927e-02f, -8.67244303e-02f, 7.21082464e-02f, -4.56185080e-02f, -1.42250896e-01f, -1.60290569e-01f, -3.83587703e-02f, 5.15886880e-02f, -6.54172376e-02f,
  4.01718318e-02f, -3.75670232e-02f, -2.16888860e-02f, -8.08377750e-03f, 2.39103869e-01f, 7.43268728e-02f, -4.39872295e-02f, -4.53170463e-02f, 8.32671449e-02f, 2.81882677e-02f,
  7.90168196e-02f, -2.67129093e-02f, -5.99676184e-02f, -1.24014497e-01f, -8.07757452e-02f, -7.00322464e-02f, 5.09191118e-02f, 1.98984402e-03f, -1.11453272e-01f, -3.64914350e-02f,
  -3.86203057e-03f, 4.35766317e-02f, -7.91611001e-02f, 2.30201264e-03f, -3.14158089e-02f, 3.92617565e-03f, 7.62772411e-02f, -5.15293032e-02f, 4.37692506e-03f, -2.09722519e-02f,
  3.80991548e-02f, 3.42412665e-03f, 3.22671756e-02f, 1.35965245e-02f, 2.39404030e-02f, 4.80797999e-02f, 5.39817214e-02f, -7.34403208e-02f, -3.81212421e-02f, 4.38385922e-03f,
  7.06874654e-02f, -9.88059118e-03f, 9.14963558e-02f, -3.26768011e-02f, -1.38290357e-02f, 2.23680697e-02f, -4.39143144e-02f, 3.92096825e-02f, 3.11365277e-02f, 1.19353786e-01f,
  1.49578005e-02f, 7.32640997e-02f, 4.51778714e-03f, -6.34048209e-02f, -3.24308649e-02f, -8.38173032e-02f, -1.70528945e-02f, 5.36515415e-02f, 7.99412578e-02f, -4.37507108e-02f,
  -6.89417645e-02f, -7.64872953e-02f, -3.69254244e-03f, -5.18486835e-02f, -2.69472208e-02f, -1.69855412e-02f, 5.36419488e-02f, -7.57762790e-02f, -2.40677153e-03f, 3.60673033e-02f,
  -1.09266220e-02f, -1.15109039e-02f, -9.95562300e-02f, 5.01048826e-02f, 1.66431405e-02f, -7.25685880e-02f, 2.44349744e-02f, -7.07386136e-02f, 5.34164980e-02f, 7.89809797e-04f,
  3.33049893e-02f, -2.64030695e-02f, -1.00862635e-02f, -7.95839652e-02f, 6.69497438e-03f, 6.06410690e-02f, -8.99937097e-03f, -3.98348831e-02f, -5.69381453e-02f, 7.60141714e-03f,
  6.44340590e-02f, 1.58216860e-02f, -5.15633263e-02f, 1.67413559e-02f, -5.04711159e-02f, -6.84131533e-02f, -1.55520327e-02f, 2.00098194e-02f, 3.36098745e-02f, 1.95932817e-02f,
  -4.86052036e-03f, 2.40327679e-02f, 7.46619850e-02f, -5.82460426e-02f, 5.74683510e-02f, -5.45394719e-02f, -5.05539291e-02f, -9.60001780e-04f, 3.88681442e-02f, 1.04374504e-02f,
  -7.51608312e-02f, 7.43716434e-02f, 5.54111181e-03f, 1.19728364e-01f, 5.09998538e-02f, -1.73507407e-01f, -2.18099654e-01f, 5.91345802e-02f, -3.26035351e-01f, 3.85015644e-02f,
  -1.37520134e-02f, -1.28101975e-01f, -7.58601278e-02f, -1.28381103e-01f, -9.65722464e-03f, -2.68261939e-01f, 2.34366953e-02f, -1.58472639e-02f, -1.64647624e-01f, 2.52632290e-01f,
  -2.41031797e-04f, 1.66869223e-01f, -4.60082246e-03f, 1.61539212e-01f, 1.63474426e-01f, 1.90920338e-01f, 4.37913477e-01f, -1.72538348e-02f, 1.58994526e-01f, 2.80021261e-02f,
  -9.85972658e-02f, -1.44584671e-01f, -4.28340472e-02f, -3.24969143e-02f, 1.29335672e-01f, 6.10402860e-02f, 4.65385354e-04f, -2.47903764e-02f, -2.73062456e-02f, -6.13653054e-03f,
  -8.54588300e-03f, -3.08725424e-02f, -9.35393870e-02f, -5.62496483e-02f, -4.55222428e-02f, -4.72925827e-02f, -1.11298628e-01f, 5.44895828e-02f, 4.44433540e-02f, 2.86116172e-02f,
  -3.02888472e-02f, 1.72707886e-02f, -2.47498835e-03f, 5.49547970e-02f, -3.13130282e-02f, 2.61612665e-02f, 1.68004096e-03f, 6.64838254e-02f, -3.62847908e-03f, -7.28645623e-02f,
  5.95815741e-02f, 4.86716032e-02f, -4.04507555e-02f, -2.10204020e-01f, 2.72411164e-02f, 4.05046344e-03f, -3.27009521e-02f, 7.90545419e-02f, -2.09475774e-02f, -4.77612652e-02f,
  4.05607894e-02f, -3.22609991e-02f, -1.34152457e-01f, 1.98833533e-02f, 8.35185200e-02f, -5.15855253e-02f, -1.70895252e-02f, 4.40121144e-02f, -1.43871568e-02f, -3.49610262e-02f,
  -4.06985916e-03f, -2.88197026e-02f, 1.22992676e-02f, -4.35336232e-02f, -5.30973896e-02f, 1.02793902e-01f, 6.08570278e-02f, -5.71121983e-02f, -8.15155134e-02f, 1.06894858e-02f,
  6.76330552e-02f, 2.49600053e-01f, 3.74349998e-03f, -2.89173704e-03f, -5.27890809e-02f, 8.14201310e-03f, 8.57682154e-03f, 9.47295036e-03f, 6.03749789e-02f, -1.08566741e-02f,
  1.05181098e-01f, 4.71934304e-02f, -1.12698274e-02f, -1.38412695e-02f, -2.95550823e-02f, 1.45555120e-02f, -1.01708493e-03f, -2.77419575e-02f, 7.25843236e-02f, -2.17492622e-03f,
  7.68902078e-02f, -1.45907793e-02f, 2.49539856e-02f, 2.64488021e-03f, -5.69357350e-03f, 7.33115769e-04f, -3.50295380e-02f, -4.73690629e-02f, 7.41022229e-02f, -9.21091735e-02f,
  -9.01250914e-02f, 4.42903414e-02f, -5.21853231e-02f, 2.12346334e-02f, 1.88125744e-02f, 1.60291329e-01f, 1.63953066e-01f, 8.37895721e-02f, 9.01645645e-02f, 1.68586060e-01f,
  6.49784282e-02f, -6.78972527e-02f, 1.26457969e-02f, 6.77041337e-02f, 2.22294908e-02f, 1.12282380e-01f, 2.35427305e-01f, 1.19511679e-01f, -1.45861790e-01f, -1.00459717e-02f,
  -1.35463579e-02f, 2.37395950e-02f, 3.47362421e-02f, -8.69162157e-02f, -2.43375171e-03f, -1.03905722e-01f, -9.31158103e-03f, -1.04530185e-01f, -1.15510315e-01f, -5.26370741e-02f,
  -7.26260943e-03f, 2.90715834e-03f, -1.57251433e-02f, -2.87095178e-02f, -5.58327325e-02f, -5.70657253e-02f, 3.33601683e-02f, 2.07609255e-02f, -1.97133310e-02f, 3.66670191e-02f,
  -1.16169285e-02f, -2.43759099e-02f, 4.11276706e-02f, 1.64982621e-02f, -6.47439389e-03f, -1.05854250e-01f, 1.48829026e-02f, 1.15262717e-02f, -5.48503622e-02f, 5.57745527e-03f,
  1.55123463e-02f, 8.55375454e-02f, -5.52578345e-02f, -1.35518359e-02f, -9.39892197e-04f, 5.42069077e-02f, 3.61681134e-02f, 3.93582974e-03f, -6.61001056e-02f, -4.43517836e-03f,
  -6.18053675e-02f, -5.50938584e-02f, -5.11231609e-02f, 1.23430183e-02f, -5.33093959e-02f, -3.62210497e-02f, 3.27249877e-02f, -8.02159775e-03f, -2.87449043e-02f, 9.89728794e-02f,
  -2.83424743e-02f, -5.36393635e-02f, 1.64587796e-02f, -2.60756873e-02f, 2.20857952e-02f, 1.73206553e-02f, -6.77987710e-02f, -3.83506641e-02f, 8.02645236e-02f, 1.59678031e-02f,
  4.96740006e-02f, 4.99464199e-02f, 5.67542091e-02f, -2.46669054e-02f, 3.43609601e-02f, -5.23487898e-03f, -1.19358040e-02f, 6.56452402e-02f, -3.69544737e-02f, 4.66724113e-02f,
  2.04099230e-02f, -7.72068426e-02f, -5.66105768e-02f, 5.78749292e-02f, -4.24141698e-02f, -9.09402315e-03f, -1.83633529e-03f, -6.93636984e-02f, -5.21962307e-02f, -6.97426498e-02f,
  7.90406018e-02f, -1.29463226e-02f, -2.42924737e-03f, -4.79741432e-02f, -3.20312418e-02f, 7.57919401e-02f, 2.31182482e-02f, -6.09110445e-02f, 5.43401316e-02f, 3.12529355e-02f,
  -4.44384702e-02f, -7.04410896e-02f, -1.13791991e-02f, -2.47868728e-02f, 9.83402207e-02f, 5.09265624e-02f, 3.86246555e-02f, 6.96665095e-03f, 9.11222249e-02f, -1.63939521e-02f,
  4.41841893e-02f, -3.54226440e-01f, -5.74834971e-03f, 9.38652605e-02f, 1.26091406e-01f, 1.88379630e-01f, 3.38403910e-01f, -1.89234450e-01f, -1.17370479e-01f, -3.14143717e-01f,
  3.95936780e-02f, -2.43761204e-02f, 6.51754960e-02f, -7.85576776e-02f, 3.26315135e-01f, 4.90421839e-02f, 6.40679896e-02f, -1.13110198e-02f, -2.25353651e-02f, -9.47550386e-02f,
  3.07891872e-02f, 7.58383796e-02f, 2.37556025e-01f, -6.22828230e-02f, 1.28691822e-01f, -4.63262461e-02f, 6.90899789e-02f, 1.77132338e-01f, 9.12492909e-03f, 1.71233639e-01f,
  -6.88230172e-02f, -8.09521005e-02f, 3.46308462e-02f, -7.73248374e-02f, 8.31561536e-03f, 3.28430533e-02f, 5.20681180e-02f, 1.96358353e-01f, 2.55679116e-02f, -4.41380702e-02f,
  -4.94346693e-02f, -4.66592796e-02f, 2.23194174e-02f, 8.41199979e-03f, -1.17497807e-02f, -2.79654823e-02f, -1.81724261e-02f, -9.38846823e-03f, 2.27247290e-02f, 8.53746235e-02f,
  6.51750294e-03f, -3.05491919e-03f, -2.65379027e-02f, 3.76610085e-02f, 2.98419464e-02f, 1.72805451e-02f, 4.91554104e-02f, 1.06127970e-01f, 2.15695556e-02f, -4.74842563e-02f,
  7.12416321e-02f, -5.15556009e-03f, 3.76785290e-03f, 2.83753891e-02f, 2.13489980e-02f, -5.38519956e-02f, -3.80550623e-02f, 1.01865850e-01f, 1.66731309e-02f, 3.40817645e-02f,
  -1.91653240e-02f, 1.78221464e-02f, -2.89851520e-02f, -5.54406904e-02f, -2.28850059e-02f, -7.77920038e-02f, 1.14118280e-02f, -2.61117555e-02f, -6.14505447e-03f, 8.12279806e-03f,
  2.18240265e-02f, -2.68131904e-02f, -6.29671430e-03f, 4.17435542e-02f, 4.94413227e-02f, 3.99403572e-02f, 1.91613976e-02f, -2.71331035e-02f, 1.30731966e-02f, 6.56806976e-02f,
  -3.80159557e-01f, -3.35628062e-01f, -6.51426613e-02f, -5.48258126e-02f, 2.21811458e-02f, -9.11227763e-02f, -5.00094052e-03f, -1.04061830e-04f, -4.04876731e-02f, -1.07969549e-02f,
  -6.59804940e-02f, 4.53850180e-02f, -8.04327652e-02f, 1.96417049e-02f, 4.00166661e-02f, -8.32304284e-02f, -1.22131780e-02f, -4.15965877e-02f, -2.67373044e-02f, -6.35687858e-02f,
  -7.05487803e-02f, -2.56180242e-02f, 6.83493614e-02f, -5.47211990e-02f, -4.74211425e-02f, -1.39330206e-02f, -8.42675716e-02f, -1.39274064e-03f, 6.93594515e-02f, -5.65452948e-02f,
  -5.12640066e-02f, -9.55789313e-02f, 2.75093615e-01f, -5.09498864e-02f, -4.24396843e-02f, 1.70889139e-01f, 2.79955417e-01f, -1.19341895e-01f, -9.52018276e-02f, 7.75434449e-02f,
  4.33328748e-02f, -4.70090918e-02f, 1.64583996e-01f, 7.54959285e-02f, 1.33323088e-01f, 1.51964650e-01f, -1.39990235e-02f, 1.88726261e-02f, -1.02438256e-01f, -2.09438458e-01f,
  -1.31185487e-01f, -3.95006798e-02f, 2.04807431e-01f, -1.32868618e-01f, 6.46495149e-02f, -9.54246745e-02f, 3.26047763e-02f, 1.42988130e-01f, -1.38447016e-01f, 6.67234659e-02f,
  -1.28859818e-01f, -1.82609782e-01f, -1.01401761e-01f, 3.14916410e-02f, -3.42994072e-02f, -5.94477765e-02f, 3.63015570e-02f, 3.09020579e-02f, 5.22832610e-02f, 4.91253398e-02f,
  -5.16583100e-02f, 2.88945064e-02f, -4.86450531e-02f, -3.91577594e-02f, -3.20643857e-02f, 4.17738520e-02f, 2.87469793e-02f, -1.74906198e-02f, 3.57097350e-02f, -2.96477154e-02f,
  -1.00036450e-02f, -5.13290353e-02f, 4.81745079e-02f, -7.66843557e-02f, 6.96701929e-02f, -2.02571061e-02f, 4.65627126e-02f, -2.75844522e-02f, -1.04021907e-01f, -2.11248011e-03f,
  1.02175288e-02f, 2.17292923e-02f, -5.55142127e-02f, -7.00670704e-02f, -3.61858159e-02f, -5.86158037e-03f, 2.89356671e-02f, -3.11847869e-02f, 2.11073570e-02f, 2.37659980e-02f,
  -4.54296172e-03f, 7.64955282e-02f, 3.39936931e-03f, 8.59344751e-02f, 6.37874603e-02f, 2.36918423e-02f, 5.15836589e-02f, -9.76687297e-02f, 4.72936081e-03f, 5.44672646e-03f,
  -3.46452147e-02f, 5.36513366e-02f, -6.81188479e-02f, -4.99591045e-02f, -3.53888646e-02f, -1.10582635e-02f, -1.03338726e-01f, -1.30588803e-02f, 3.54181160e-04f, -3.37323360e-02f,
  -1.04579262e-01f, -6.98966756e-02f, -2.87151486e-02f, 6.30554408e-02f, -5.12121730e-02f, 3.09383254e-02f, -2.19265893e-02f, 1.30786514e-02f, -2.33175308e-02f, -4.56554629e-02f,
  1.35054635e-02f, -6.79503987e-03f, -6.07968532e-02f, -1.50704561e-02f, 1.57038402e-02f, 1.51637234e-02f, -2.84014959e-02f, 5.04379161e-02f, -6.27685562e-02f, -1.30887963e-02f,
  7.63910189e-02f, -4.08078469e-02f, -1.73754599e-02f, -3.83734889e-02f, 2.37379223e-03f, 1.01578971e-02f, -9.43570286e-02f, -7.43452981e-02f, 4.27338891e-02f, 2.32364070e-02f,
  6.48346245e-02f, -1.98486727e-02f, 2.84138292e-01f, 7.48642758e-02f, 1.36465028e-01f, -3.56398746e-02f, -8.26905668e-02f, 9.38661098e-02f, 1.02204591e-01f, -8.88791382e-02f,
  3.22540216e-02f, 8.23958367e-02f, -8.87773372e-03f, 3.67037505e-02f, -2.54611492e-01f, -1.01392912e-02f, -1.29782245e-01f, -2.93307044e-02f, 7.03020245e-02f, 1.33575266e-02f,
  7.48672783e-02f, -1.06244192e-01f, -1.36718415e-02f, -4.09019627e-02f, 1.64320976e-01f, 7.40543902e-02f, -1.63963094e-01f, -1.52857214e-01f, -4.28279676e-02f, -1.96941830e-02f,
  -3.03155687e-02f, 1.09276034e-01f, -3.96284321e-03f, 3.39868851e-02f, -2.36258898e-02f, 3.08917239e-02f, 1.12124100e-01f, 3.13527249e-02f, 4.02072258e-03f, 7.60617927e-02f,
  1.19222611e-01f, -1.80106121e-03f, 9.02687609e-02f, 5.12993075e-02f, 5.42555340e-02f, 2.20813211e-02f, 1.83369830e-01f, 1.18987620e-01f, 3.76647711e-02f, 7.27847293e-02f,
  1.27500311e-01f, 6.30058125e-02f, 8.49846005e-02f, 4.40995023e-02f, 1.05150811e-01f, 4.67236415e-02f, 3.70200388e-02f, 6.23945445e-02f, 1.14384070e-02f, 1.83413774e-02f,
  -1.17753863e-01f, 6.98567694e-03f, -9.24678221e-02f, 3.68417613e-03f, 5.09763174e-02f, 2.76477244e-02f, 1.14032879e-01f, -6.08173274e-02f, -5.34376595e-03f, 1.43829472e-02f,
  3.02794110e-03f, -3.86751145e-02f, 6.83890795e-03f, 9.21966732e-02f, 1.63437948e-02f, -4.01978232e-02f, -8.91260654e-02f, -5.67342862e-02f, -7.79543370e-02f, -3.21475379e-02f,
  -7.95725361e-02f, -3.54599319e-02f, 7.09096044e-02f, 6.17560521e-02f, -7.48433322e-02f, 5.56056350e-02f, 6.89680725e-02f, 4.64728698e-02f, -4.70705144e-02f, -4.93134148e-02f,
  -2.20577531e-02f, -6.30659834e-02f, -1.52340168e-02f, 4.81127985e-02f, 9.14676562e-02f, -6.21700771e-02f, 2.51671150e-02f, -4.22355160e-02f, -2.50076558e-02f, -5.35809144e-04f,
  8.37036520e-02f, 1.50317531e-02f, 8.61433148e-02f, -2.51041222e-02f, -6.58337697e-02f, -6.98386750e-04f, -1.10141374e-02f, -9.53342691e-02f, 9.28896815e-02f, -4.58501354e-02f,
  5.18501662e-02f, 6.20616153e-02f, 1.58595406e-02f, -8.95863995e-02f, 9.23290104e-03f, -1.06618209e-02f, -2.32115742e-02f, -8.83442685e-02f, -7.05272555e-02f, -7.22780749e-02f,
  -1.13483079e-01f, -1.51019648e-01f, 1.59499362e-01f, -1.46553174e-01f, -7.25999400e-02f, 2.56199054e-02f, -9.37322679e-04f, 2.07080860e-02f, -1.37544423e-01f, -4.87587415e-02f,
  -7.36728907e-02f, -1.76521987e-02f, 3.59502099e-02f, -2.34558899e-02f, 1.49841100e-01f, 8.89037102e-02f, -7.73195475e-02f, 3.27268131e-02f, -4.84743901e-02f, -1.57945324e-02f,
  -2.91323625e-02f, -5.14941514e-02f, 2.74075158e-02f, -7.69575462e-02f, 1.66150760e-02f, -8.04970134e-03f, -2.34434716e-02f, -1.65971536e-02f, -6.95595071e-02f, -1.76607594e-02f,
  -8.17964748e-02f, -3.83261554e-02f, 2.95996554e-02f, 9.83160511e-02f, 4.36309204e-02f, -1.52334552e-02f, 6.47848770e-02f, 8.97255167e-02f, -4.66371588e-02f, 3.12711485e-02f,
  1.99274421e-02f, -6.55250102e-02f, 2.04740167e-02f, 2.89668404e-02f, -9.69300140e-03f, 1.89999472e-02f, 1.21170441e-02f, -3.02652922e-02f, 1.10632069e-02f, -6.00406155e-02f,
  -1.52408155e-02f, -5.99966682e-02f, -2.04879772e-02f, 3.46636288e-02f, 7.61934295e-02f, 1.27538079e-02f, -2.89033391e-02f, -5.30010797e-02f, -3.30854468e-02f, -4.89007384e-02f,
  -4.60428484e-02f, -9.20665190e-02f, 4.59681116e-02f, -2.93193199e-02f, -1.79714598e-02f, 4.13560793e-02f, -9.18645505e-03f, -1.01042688e-01f, -5.01053073e-02f, -5.58413416e-02f,
  -4.89336513e-02f, -1.75428521e-02f, 2.21521910e-02f, -2.97501627e-02f, -3.10036098e-03f, -4.33046110e-02f, 9.14348476e-03f, 4.37840261e-02f, -4.59354967e-02f, -1.31221544e-02f,
  5.03240414e-02f, 8.24282244e-02f, 6.60380349e-02f, -3.73864062e-02f, -6.22591749e-02f, -4.98187505e-02f, 5.48642129e-02f, -1.00620568e-01f, -4.60311882e-02f, 8.17643777e-02f,
  -7.21368864e-02f, -9.56665352e-02f, -3.38261463e-02f, -6.72232136e-02f, -7.05376267e-02f, -4.76611070e-02f, -8.71254876e-02f, -1.10589519e-01f, 4.24593799e-02f, -2.63814582e-04f,
  5.82581107e-03f, 1.49172973e-02f, -4.61728871e-02f, 8.82052816e-03f, -7.80949974e-03f, 5.92817217e-02f, 3.82695459e-02f, 7.72871822e-02f, 2.07562409e-02f, 3.00224368e-02f,
  -1.20637631e-02f, 1.93861965e-02f, 5.41852787e-02f, -2.34485194e-02f, 3.55114113e-03f, -3.26530561e-02f, -7.54355267e-02f, 3.75875533e-02f, -2.12417543e-02f, -3.53891067e-02f,
  -2.63977684e-02f, -1.55680373e-01f, -7.51875490e-02f, 4.90243267e-03f, 3.86918336e-02f, -8.11204389e-02f, -1.45239353e-01f, -3.75984535e-02f, -1.87082976e-01f, -2.63696779e-02f,
  8.45584366e-03f, -1.40964374e-01f, -7.83592239e-02f, -5.87070473e-02f, -2.56540235e-02f, -2.47693613e-01f, 2.33990029e-02f, -6.81758076e-02f, -7.86428824e-02f, -1.31731236e-03f,
  -4.59414870e-02f, 1.30709514e-01f, -7.04423040e-02f, 1.40334234e-01f, 2.36750599e-02f, 1.78197220e-01f, 2.02212647e-01f, 6.02916516e-02f, 1.29833013e-01f, 1.30563572e-01f,
  -6.61296993e-02f, -3.85643281e-02f, -8.00614879e-02f, -1.34412609e-02f, 4.98606004e-02f, 1.40090480e-01f, 1.20984033e-01f, 5.41310012e-02f, 1.48554388e-02f, 4.03324282e-03f,
  -1.96228530e-02f, 6.79885447e-02f, -4.59613502e-02f, -6.60965219e-02f, 3.35090645e-02f, 2.60415189e-02f, 6.38510659e-02f, -4.64461967e-02f, -5.65638468e-02f, 4.65399511e-02f,
  -9.60144848e-02f, -7.40985423e-02f, 1.03825398e-01f, 5.12370691e-02f, -2.98969653e-02f, 2.20681839e-02f, 1.19028598e-01f, -2.14551184e-02f, 7.14165345e-02f, -5.58635406e-02f,
  6.78766845e-03f, -3.74127068e-02f, 5.44497743e-03f, 1.99536495e-02f, -3.61878090e-02f, -8.20800588e-02f, 4.21912670e-02f, -8.18881765e-02f, 5.32562807e-02f, 5.51497564e-02f,
  5.91000319e-02f, 2.27586385e-02f, -1.22507866e-02f, 6.02435544e-02f, -5.09248786e-02f, -6.59212396e-02f, 1.35164866e-02f, 1.12449871e-02f, 5.93278706e-02f, 1.52731407e-02f,
  -2.91321110e-02f, 7.17378482e-02f, -8.82105976e-02f, 2.71376129e-02f, 3.63431266e-03f, -7.57196248e-02f, -6.02779463e-02f, -3.83774228e-02f, -7.59768626e-03f, 8.79278686e-03f,
  2.21427754e-02f, -5.04330918e-02f, 1.11219734e-02f, 2.41260268e-02f, -4.03325446e-02f, -2.92506218e-02f, 8.25424418e-02f, -3.80078740e-02f, 6.67363405e-02f, 1.46921733e-02f,
  3.91675718e-02f, 7.97901452e-02f, 8.59346613e-02f, -5.13088843e-03f, 3.24693993e-02f, -9.48096532e-03f, -6.29501864e-02f, 8.35842118e-02f, 1.05225213e-01f, 5.15455157e-02f,
  5.27563728e-02f, -1.17929004e-01f, 7.96961039e-02f, -1.57227796e-02f, -1.75191183e-02f, -1.10355178e-02f, 1.14710011e-01f, 9.40201133e-02f, -1.50345406e-02f, 2.80836243e-02f,
  -2.48116538e-01f, -1.16123855e-01f, 1.88979641e-01f, -2.30836138e-01f, -1.57788172e-01f, 1.73693046e-01f, 3.77029157e-03f, -1.23981386e-01f, -2.48148292e-01f, -1.04677513e-01f,
  -1.70597062e-01f, -6.96304739e-02f, 3.05983067e-01f, -9.00655836e-02f, 2.33700618e-01f, 1.45616278e-01f, -3.30445208e-02f, 2.94266455e-02f, -7.52028590e-03f, -1.68731250e-02f,
  -1.61703695e-02f, -1.26980394e-01f, 2.41047174e-01f, -1.05758511e-01f, -1.10629573e-01f, -1.64674073e-01f, 8.76411388e-04f, 1.15952473e-02f, -1.74323335e-01f, -9.58347917e-02f,
  -3.21606523e-03f, -1.37192309e-01f, -1.81204863e-02f, 3.49383466e-02f, 9.51699633e-03f, 6.50282949e-02f, 3.88673134e-02f, 9.01506618e-02f, 8.70407186e-03f, -3.07307653e-02f,
  2.18218956e-02f, 3.16435727e-03f, -7.53421262e-02f, 5.42899854e-02f, -1.86611526e-02f, -2.33143549e-02f, 2.34715920e-02f, 1.05458917e-02f, 1.65213495e-02f, 7.08199441e-02f,
  1.07122771e-01f, -1.01592597e-02f, 1.52059318e-02f, 5.12118675e-02f, -1.08502824e-02f, -7.12209642e-02f, -3.45367356e-03f, 3.38820629e-02f, -3.89894657e-02f, -3.26269977e-02f,
  5.03054149e-02f, -3.24897431e-02f, -7.05085471e-02f, -6.59365878e-02f, 5.29686287e-02f, -5.98988310e-02f, 3.81978266e-02f, 2.40003802e-02f, 4.78578731e-02f, -8.40170216e-03f,
  -4.59123924e-02f, -4.63536531e-02f, -7.54166814e-03f, 7.59342760e-02f, -5.04466482e-02f, -7.59430155e-02f, 3.38671617e-02f, -8.89286250e-02f, 1.88481752e-02f, -4.65467907e-02f,
  -5.98909054e-03f, 5.17985299e-02f, -4.26511839e-02f, 4.31158990e-02f, 3.58057693e-02f, 1.23712584e-01f, 5.65130971e-02f, 4.05671559e-02f, -5.70043251e-02f, 5.88055886e-02f,
  -3.80289629e-02f, -1.63129225e-01f, -3.57715301e-02f, -1.16336737e-02f, 5.96858934e-02f, 3.44028585e-02f, 1.94305973e-03f, -6.26596883e-02f, -3.15478668e-02f, 1.22267576e-02f,
  -1.72174778e-02f, 1.10359099e-02f, 4.93710861e-02f, -7.29898214e-02f, 3.07705589e-02f, -8.88418108e-02f, -4.56840545e-02f, 2.67535914e-02f, -8.25687721e-02f, 3.15130875e-02f,
  1.35213165e-02f, -2.57077031e-02f, 8.91316682e-02f, -1.22992629e-02f, 2.46916562e-02f, -4.88677137e-02f, -1.03052938e-02f, 6.90987259e-02f, 8.16219896e-02f, 2.62389295e-02f,
  -2.26025209e-01f, -1.85676724e-01f, -1.07845224e-01f, -2.72335887e-01f, 7.21913129e-02f, -2.37050742e-01f, -2.49453560e-01f, 4.17997688e-02f, 1.23964930e-02f, 1.33982778e-01f,
  -1.02462554e-02f, -1.12479664e-01f, 3.60496505e-03f, -3.21809947e-01f, -2.41415799e-01f, -1.60549328e-01f, -4.43972975e-01f, -1.30061284e-01f, -7.16727749e-02f, -1.69283599e-01f,
  -2.04352036e-01f, -1.83352411e-01f, -2.42367446e-01f, 3.59037258e-02f, -1.19255185e-01f, 1.14975192e-01f, 1.24917343e-01f, 7.65839815e-02f, -1.34857312e-01f, -5.69801666e-02f,
  -1.46920800e-01f, 1.12879999e-01f, 4.77342084e-02f, 6.95459545e-02f, 5.25173023e-02f, 5.80140278e-02f, 3.95477377e-02f, -8.18209082e-05f, 4.42654639e-02f, -1.77308510e-03f,
  3.01290527e-02f, 3.29591823e-03f, -5.74777685e-02f, -2.70306692e-02f, 5.27475923e-02f, 8.41326341e-02f, 5.41784316e-02f, 4.35548387e-02f, -6.89382153e-03f, -4.93376069e-02f,
  -8.90746713e-02f, -8.03179741e-02f, -5.35701886e-02f, 8.65992066e-03f, -7.26068616e-02f, -1.10230194e-02f, -3.52291875e-02f, 1.35386121e-02f, -7.54280314e-02f, -3.98489796e-02f,
  -8.59784260e-02f, 6.40613288e-02f, -4.52529006e-02f, 2.12551355e-02f, 2.05931831e-02f, 8.99940729e-02f, 1.54644232e-02f, -3.35865058e-02f, -8.48776754e-03f, -1.48916757e-02f,
  -3.10872812e-02f, -3.89337167e-02f, -9.38134547e-03f, -5.19046676e-04f, -1.03512339e-01f, -1.66213755e-02f, -5.08269370e-02f, 3.76782864e-02f, -5.13107516e-02f, -8.30632448e-03f,
  1.70263872e-02f, -5.02378643e-02f, 3.78207825e-02f, -2.32080054e-02f, 4.00614738e-03f, -5.67460060e-02f, -1.86498631e-02f, -1.82363335e-02f, -3.12638581e-02f, -4.10507321e-02f,
  -4.10029404e-02f, -5.58628365e-02f, 6.84080496e-02f, 5.54506741e-02f, -2.93896440e-02f, -4.33320850e-02f, -4.87070717e-02f, -4.93966788e-02f, -1.05816729e-01f, -1.71079002e-02f,
  2.54916754e-02f, -4.24999855e-02f, -5.56871742e-02f, -4.65952372e-03f, -3.23856808e-02f, 1.25549641e-03f, -2.72371564e-02f, 5.74602485e-02f, -7.96672851e-02f, 9.70084369e-02f,
  3.35987695e-02f, 1.51624102e-02f, -4.76680025e-02f, -9.62605253e-02f, 4.73924316e-02f, -1.74361151e-02f, 6.91097900e-02f, 2.04193797e-02f, 2.10555028e-02f, 4.35283268e-03f,
  2.42097750e-01f, 5.58300912e-02f, -2.43278533e-01f, -1.49929777e-01f, -9.52858552e-02f, -1.47454530e-01f, -2.93039471e-01f, -1.66258514e-01f, -1.24314427e-01f, -1.66337386e-01f,
  -5.91036528e-02f, 3.65448594e-02f, 5.64755872e-02f, -7.05949888e-02f, 1.31721005e-01f, 2.01066434e-01f, -1.41604498e-01f, 1.19206849e-02f, 3.15927453e-02f, -1.51463936e-03f,
  1.46350652e-01f, -9.47912931e-02f, 7.89707825e-02f, -5.57745583e-02f, -1.53060809e-01f, 7.66865090e-02f, 1.54409945e-01f, -8.96908864e-02f, -6.34529814e-02f, -1.50722817e-01f,
  7.75507763e-02f, 2.34940723e-02f, -6.05518073e-02f, -1.17996824e-03f, -3.40877473e-02f, 1.43110771e-02f, -1.67358872e-02f, 1.23185124e-02f, 7.27005377e-02f, -2.51844451e-02f,
  -2.12549251e-02f, 2.61029974e-02f, 1.65581219e-02f, -1.79269421e-03f, -3.99996452e-02f, -3.06055043e-02f, 5.94301708e-02f, 5.60891703e-02f, -4.05593812e-02f, 2.68841460e-02f,
  -2.99003515e-02f, -5.52520305e-02f, -3.68186831e-02f, -2.07730643e-02f, -6.28135130e-02f, -5.33297844e-02f, 4.84086610e-02f, -7.66336247e-02f, 8.40976015e-02f, -4.45978045e-02f,
  6.04657121e-02f, 1.68900546e-02f, 1.44635178e-02f, -4.66452837e-02f, 6.48814663e-02f, 6.11271523e-02f, -5.44889420e-02f, 2.07613241e-02f, 2.71950997e-02f, 3.97620723e-02f,
  4.02275398e-02f, 2.99888439e-02f, 3.01632434e-02f, -3.00343744e-02f, 8.61793235e-02f, -2.00465601e-02f, -2.99274065e-02f, -4.32048319e-03f, -2.14661434e-02f, -1.21783547e-01f,
  -7.13045592e-05f, 9.60564613e-03f, -1.94181763e-02f, -4.10824567e-02f, -1.11981248e-03f, 2.88956892e-02f, 4.14729454e-02f, 7.41145201e-03f, -2.92274468e-02f, 1.15199015e-03f,
  -2.23722197e-02f, -3.44533958e-02f, -3.57228704e-02f, -8.36442113e-02f, -7.77072273e-03f, 3.61181535e-02f, 4.75304723e-02f, -5.02110319e-03f, 4.54870462e-02f, 2.38562394e-02f,
  -1.20609123e-02f, 2.08059438e-02f, 3.40963155e-02f, -2.30923221e-02f, 2.26368997e-02f, -9.09782425e-02f, 1.51422666e-02f, 8.60358924e-02f, 2.70395167e-02f, 6.57330379e-02f,
  -6.06247932e-02f, -7.67647251e-02f, 9.68598872e-02f, -7.09025888e-03f, 4.11150567e-02f, 2.53417809e-03f, -3.11615430e-02f, 6.34904653e-02f, -3.56680080e-02f, -3.56555916e-02f,
  -2.61827826e-01f, 3.57769966e-01f, 1.68878794e-01f, -2.13003218e-01f, 9.01409388e-02f, 1.40869915e-01f, -1.64632220e-02f, -6.65375357e-03f, -6.52731583e-02f, -4.76375371e-02f,
  -1.35474712e-01f, 1.25239072e-02f, -1.54627208e-02f, -1.32876977e-01f, -3.23084444e-01f, -1.07900955e-01f, -1.53989702e-01f, -1.34154066e-01f, 2.03516766e-01f, 5.23422146e-03f,
  -5.16041927e-02f, -1.48735002e-01f, 8.55617598e-03f, 2.09115386e-01f, 1.42466426e-01f, 1.55715615e-01f, -1.84395835e-01f, 2.48658389e-01f, 3.97388712e-02f, 6.95747212e-02f,
  -3.22705992e-02f, -4.72495928e-02f, -7.52377212e-02f, 1.94971114e-02f, -1.20290600e-01f, -1.99924540e-02f, 1.23986937e-02f, 9.72849503e-03f, -5.22880629e-02f, 3.56433056e-02f,
  -3.43188159e-02f, 7.47989863e-02f, -4.44958210e-02f, 2.79652271e-02f, 4.78909984e-02f, 6.46960512e-02f, 2.97387075e-02f, 1.13129273e-01f, 6.63210675e-02f, 7.39406943e-02f,
  1.02725148e-01f, 1.79280061e-02f, -7.87166953e-02f, -1.24563858e-01f, -6.29280182e-03f, -2.06272844e-02f, -1.30820619e-02f, 4.07603569e-02f, 4.52387668e-02f, 4.94967215e-02f,
  5.71102276e-02f, -7.62169287e-02f, 2.72383932e-02f, 4.02034223e-02f, 4.91630360e-02f, -5.46983853e-02f, -2.06045453e-02f, -4.72018644e-02f, -4.09261063e-02f, 3.18078846e-02f,
  -9.52265412e-02f, 5.89065216e-02f, -1.87805910e-02f, 1.32847046e-02f, -5.21251149e-02f, -3.69388051e-02f, -4.91626449e-02f, 7.08571635e-04f, -8.06173868e-03f, -4.39931639e-03f,
  -3.89580876e-02f, -7.09958822e-02f, -1.04955444e-02f, -2.79235430e-02f, 8.93106870e-03f, 3.54723856e-02f, 7.63935670e-02f, -1.75878480e-02f, -3.99653427e-02f, -8.88084471e-02f,
  -1.63095206e-01f, -1.12597533e-01f, -3.96114811e-02f, 8.42436552e-02f, -1.16763907e-02f, -2.92541087e-02f, 3.80069092e-02f, -1.35483115e-03f, -4.85703200e-02f, 2.85142083e-02f,
  2.75075343e-03f, 1.44640906e-02f, -2.09617801e-03f, -7.70457834e-02f, 3.25892270e-02f, -7.40427822e-02f, -1.61540881e-01f, -9.54222828e-02f, -6.37288764e-02f, 4.73367870e-02f,
  4.62864973e-02f, -8.17560777e-02f, -5.55025674e-02f, 3.93220186e-02f, -5.21383360e-02f, 4.21315711e-03f, -6.07890896e-02f, -1.17295273e-02f, 4.70355041e-02f, -3.25150080e-02f,
  3.02626878e-01f, -2.75580019e-01f, -2.55038366e-02f, 1.94739312e-01f, 6.53362796e-02f, -9.25587397e-03f, -1.48256689e-01f, 7.80074671e-02f, 9.40900147e-02f, -1.68761894e-01f,
  -1.40771553e-01f, -3.42072278e-01f, -3.49240661e-01f, -7.56090358e-02f, -2.48514339e-02f, -3.61779928e-01f, -9.00271013e-02f, -1.41773596e-01f, -1.33206189e-01f, -4.05098349e-02f,
  3.18000540e-02f, 9.46804732e-02f, -1.92988664e-02f, 2.21959710e-01f, 1.05647475e-01f, 2.26461589e-01f, 2.55455971e-01f, 6.32202700e-02f, 2.65693307e-01f, -3.55655141e-03f,
  -3.02427057e-02f, -1.01695776e-01f, -2.61575840e-02f, -2.13982048e-03f, -2.19554361e-02f, 1.57577160e-03f, -4.57249060e-02f, -1.34193385e-02f, -4.42973487e-02f, -9.74824652e-02f,
  -1.01858534e-01f, -9.31777880e-02f, 1.21851303e-01f, 2.49270443e-02f, 1.23127222e-01f, 5.61517961e-02f, -5.17187528e-02f, 5.03090173e-02f, -1.84432417e-02f, -1.27308935e-01f,
  -5.76955527e-02f, -3.45112681e-02f, -1.30758509e-02f, -1.16266292e-02f, -7.20619932e-02f, -2.73346044e-02f, -7.08269626e-02f, 2.41894741e-02f, 5.59719093e-02f, 5.67347445e-02f,
  -2.33732760e-02f, 2.51333974e-02f, -3.37417647e-02f, 9.72067490e-02f, 3.24465730e-03f, 5.79288788e-02f, -8.84326994e-02f, -2.63410024e-02f, -8.67510363e-02f, -1.72854103e-02f,
  -1.60029009e-02f, 7.05305263e-02f, 5.46456277e-02f, -5.20972302e-03f, 7.03231543e-02f, -4.21972722e-02f, 1.10166753e-02f, 9.67106316e-03f, -1.59552041e-02f, 2.45013684e-02f,
  -5.16189337e-02f, -2.74942182e-02f, -4.55959365e-02f, 7.22351298e-02f, 1.14336926e-02f, 7.31311971e-03f, 5.47866374e-02f, -3.31544764e-02f, 5.37458137e-02f, -7.96834156e-02f,
  -8.04858059e-02f, -1.80925146e-01f, 3.27638327e-03f, -1.31724623e-03f, 9.73468181e-03f, -4.47876006e-02f, -3.77184115e-02f, -6.17991015e-02f, -9.81663316e-02f, -5.26047647e-02f,
  3.65410857e-02f, 7.26121441e-02f, 2.73490697e-02f, 1.12608716e-01f, 3.30566801e-02f, -1.48369014e-01f, 1.20468371e-01f, -3.98269294e-05f, 6.24240786e-02f, -3.10450103e-02f,
  -2.22862861e-03f, -5.44588231e-02f, -6.03825487e-02f, 7.67854303e-02f, 7.31000081e-02f, 3.46414000e-02f, 2.86764801e-02f, -4.63557430e-02f, -3.91734913e-02f, -1.13260681e-02f,
  -5.86515844e-01f, 1.82858720e-01f, -9.43589732e-02f, -1.17344268e-01f, -1.38847366e-01f, -2.14347139e-01f, -2.21709132e-01f, -1.52890101e-01f, -1.35914952e-01f, -1.21120447e-02f,
  -3.23858522e-02f, -1.36792749e-01f, 9.95350108e-02f, 6.98720217e-02f, -1.92143366e-01f, 2.35168219e-01f, -1.30891010e-01f, -1.71367347e-01f, 1.56958461e-01f, -1.60344765e-01f,
  -5.50979003e-02f, 1.47031154e-02f, 1.07017919e-01f, 1.06739447e-01f, -1.44382596e-01f, -9.36575755e-02f, 4.68034809e-03f, 8.51598829e-02f, -1.41786607e-02f, 4.82415520e-02f,
  -2.40012869e-01f, -2.41657302e-01f, -1.71748340e-01f, -8.64806771e-02f, -1.73361048e-01f, -9.53558758e-02f, -9.95509997e-02f, 6.42436324e-04f, 2.77668820e-03f, -8.59315246e-02f,
  -1.50297433e-02f, -4.53432165e-02f, -2.74455734e-02f, 5.12685953e-03f, -2.92765703e-02f, -1.93860512e-02f, 6.94424734e-02f, 4.26402166e-02f, -9.98164713e-03f, 6.05219789e-02f,
  -4.70273048e-02f, -4.62603532e-02f, -7.39588439e-02f, 2.47926991e-02f, -2.06844844e-02f, 3.81049737e-02f, 4.82249045e-04f, -8.30781087e-03f, -4.82448786e-02f, -8.37186798e-02f,
  1.59989316e-02f, -3.07524819e-02f, 6.97018728e-02f, -8.14914256e-02f, 1.61288271e-03f, 5.02626076e-02f, -3.53556201e-02f, -3.05048060e-02f, 2.71239970e-02f, -4.57116030e-02f,
  -1.69344917e-02f, -3.95269021e-02f, -4.74900454e-02f, -2.70917471e-02f, -6.58698156e-02f, 1.46119958e-02f, -1.02332151e-02f, -3.95423733e-02f, 5.93445860e-02f, -3.09474487e-02f,
  -3.49753983e-02f, -1.03532709e-02f, 2.43864767e-02f, -2.96210852e-02f, -5.71158566e-02f, 1.25784585e-02f, 2.33549029e-02f, 5.08097298e-02f, -7.03456327e-02f, -1.87531747e-02f,
  -3.83795649e-01f, -4.60898370e-01f, -1.89733207e-02f, -7.45910108e-02f, -2.15407722e-02f, -6.71731383e-02f, -4.51156721e-02f, -6.03347905e-02f, -6.40696734e-02f, -2.39440762e-02f,
  -3.31892669e-02f, -4.61424142e-03f, -7.75033161e-02f, -8.86794820e-04f, 2.10138671e-02f, 5.52906916e-02f, -5.09655476e-02f, -8.64048526e-02f, -3.92625071e-02f, -4.93096337e-02f,
  1.15630282e-02f, -1.14789084e-02f, 9.68809128e-02f, 6.79351091e-02f, 1.44382343e-02f, -5.60841337e-02f, -1.46145998e-02f, 2.82907523e-02f, -1.12550415e-01f, 4.08333689e-02f,
  -9.02975574e-02f, -4.18155193e-02f, -1.70985982e-01f, 7.76127353e-02f, -1.78607628e-01f, -1.73720300e-01f, -6.75709099e-02f, -3.78213241e-03f, -6.35243505e-02f, 1.09630510e-01f,
  -3.03974003e-02f, 6.63628653e-02f, 1.07841641e-02f, 1.08369671e-01f, -2.94930656e-02f, 1.47512361e-01f, -5.64217530e-02f, 7.01783895e-02f, -2.81383470e-02f, -8.59109759e-02f,
  6.23350441e-02f, -3.00037395e-03f, 5.40410075e-03f, 3.94069478e-02f, 6.39321888e-03f, -1.86745524e-02f, 4.10899296e-02f, -9.36469212e-02f, 7.54660508e-03f, 3.51211913e-02f,
  -7.29951337e-02f, 2.20976900e-02f, -1.50100023e-01f, -2.89546791e-02f, -1.11142017e-01f, 1.33161778e-02f, 6.64814003e-03f, 1.80609841e-02f, -1.91204604e-02f, -7.60326236e-02f,
  -9.05149877e-02f, -4.47330996e-02f, 2.71128062e-02f, -4.66585197e-02f, -7.33628720e-02f, 3.53004076e-02f, -1.81606207e-02f, -2.00638827e-02f, -8.77330229e-02f, 3.53996046e-02f,
  4.77295071e-02f, 7.40229487e-02f, -6.77342117e-02f, -1.35604860e-02f, 5.56177720e-02f, -1.25663513e-02f, 1.16628051e-01f, -8.78014639e-02f, -2.07977995e-04f, 8.03918168e-02f,
  5.74358702e-02f, -3.28947641e-02f, 2.46672258e-02f, -6.99530765e-02f, -7.36447275e-02f, -3.20657939e-02f, -4.57878178e-03f, -7.83614144e-02f, 3.22286077e-02f, -1.39035806e-02f,
  2.50299126e-02f, -1.51695972e-02f, 5.87628596e-02f, -4.91563324e-03f, -1.99504085e-02f, 8.56044739e-02f, -9.81380567e-02f, -2.79249325e-02f, -5.83137497e-02f, -3.31981704e-02f,
  -6.82533085e-02f, -9.25099626e-02f, -5.34634590e-02f, 1.01809315e-01f, 4.20256034e-02f, -8.41731485e-03f, -2.74475012e-02f, -5.25140623e-03f, 1.73311157e-03f, 5.72998635e-02f,
  6.92005455e-03f, -8.41544867e-02f, -1.83925629e-02f, 3.17112096e-02f, -8.17104522e-03f, -1.46955168e-02f, 8.30772519e-02f, -4.96697836e-02f, 1.02953307e-01f, 3.98806781e-02f,
  -1.08606413e-01f, -2.57618334e-02f, -5.02279773e-02f, -5.32343350e-02f, 8.60612020e-02f, 1.61457919e-02f, -4.29826565e-02f, 8.15056339e-02f, 3.19841653e-02f, -1.19666560e-02f,
  -2.60487832e-02f, 1.70050114e-02f, 3.60502601e-02f, 7.23735169e-02f, 7.68501535e-02f, -4.02272269e-02f, 4.94060069e-02f, -1.29722655e-02f, -3.70629132e-02f, -1.01332180e-01f,
  2.67884701e-01f, -2.58907706e-01f, -1.62879005e-01f, -1.06162615e-01f, -1.29830763e-01f, -2.23060131e-01f, -2.46411473e-01f, -1.09059401e-01f, -6.20757043e-02f, -1.17493652e-01f,
  -1.61357760e-01f, 5.10438569e-02f, 5.22442348e-02f, -2.67230034e-01f, 1.64017513e-01f, 1.16361432e-01f, -1.55190989e-01f, -1.26088247e-01f, 3.74523886e-02f, -1.09972402e-01f,
  1.18972786e-01f, -2.08286017e-01f, -2.68436279e-02f, -1.25088856e-01f, -1.42651767e-01f, -5.03271371e-02f, 5.61074913e-02f, 5.02037071e-02f, -1.19748093e-01f, -2.66187731e-02f,
  3.56263667e-02f, 7.80608654e-02f, -9.45018753e-02f, -1.53321289e-02f, 2.84597762e-02f, 7.31229316e-03f, 4.54671122e-02f, 5.14224684e-03f, -3.05309184e-02f, -3.05043850e-02f,
  2.71542016e-02f, 3.18827741e-02f, -3.00293025e-02f, 3.38381273e-03f, 9.84505098e-03f, 2.51900274e-02f, -5.51146306e-02f, 2.41806787e-02f, -1.02819502e-01f, 3.03804800e-02f,
  -4.67407852e-02f, -5.66297024e-03f, -8.54119807e-02f, -1.37943840e-02f, 1.40537997e-03f, -3.23845074e-02f, 3.19182128e-03f, 1.07066147e-01f, 2.72809491e-02f, 9.02176648e-03f,
  6.38002530e-02f, 8.56250226e-02f, -5.05755581e-02f, 4.29920293e-03f, -8.13457593e-02f, -1.13247591e-03f, -4.45160642e-02f, -2.15438865e-02f, -8.89708847e-02f, -4.79937606e-02f,
  -7.53390789e-02f, -4.33329027e-03f, 1.00235492e-02f, -7.66678201e-03f, -6.14327900e-02f, -1.76694226e-02f, -3.41668329e-03f, 4.23014611e-02f, -2.19044872e-02f, -2.30912901e-02f,
  2.92590875e-02f, 3.93453762e-02f, -3.73130068e-02f, 8.22290871e-03f, -7.09496671e-03f, 5.18572964e-02f, -7.15541467e-02f, -2.43793987e-02f, -2.83741597e-02f, 1.32594481e-02f,
  -2.63723638e-02f, -5.91437966e-02f, -3.96443419e-02f, -1.28814625e-02f, -1.62351765e-02f, 2.58726105e-02f, 3.06122936e-02f, 4.05219421e-02f, -3.96700948e-02f, -1.33852307e-02f,
  -2.92279087e-02f, -2.83169542e-02f, 2.26128381e-02f, 2.60479804e-02f, -3.34149636e-02f, -1.06469527e-01f, 5.17947488e-02f, -2.39983248e-03f, -1.23909060e-02f, -2.46975888e-02f,
  3.23759019e-02f, 8.04968849e-02f, -1.12330290e-02f, 5.95507361e-02f, 1.43786427e-02f, -7.95191377e-02f, -2.31869463e-02f, -1.87421578e-03f, 5.90651743e-02f, -2.92599499e-02f,
  -2.13952482e-01f, 1.97899833e-01f, -4.58111800e-02f, 6.77023828e-02f, 9.55126435e-02f, -5.47894388e-02f, -1.20997436e-01f, 3.76067795e-02f, -1.58657268e-01f, -7.14672506e-02f,
  -5.24103567e-02f, -1.99937783e-02f, 8.30455497e-02f, 6.59920722e-02f, -1.49539173e-01f, -6.16859421e-02f, -5.74085042e-02f, -1.33329973e-01f, -2.34287418e-02f, 1.26988679e-01f,
  -3.27089359e-03f, 5.64258471e-02f, 1.53148755e-01f, 2.37925470e-01f, -5.37478365e-03f, 1.19230285e-01f, 7.27973133e-02f, 1.70802891e-01f, 6.54188320e-02f, -4.56765331e-02f,
  -1.42260671e-01f, 4.62417416e-02f, -4.45536152e-02f, -8.21642503e-02f, -6.36314303e-02f, -3.30664627e-02f, -1.79516040e-02f, 2.85709891e-02f, -1.12566259e-02f, 1.55311367e-02f,
  -4.21192795e-02f, -1.08389882e-02f, -4.14998084e-03f, 3.00694015e-02f, 6.76101074e-02f, 8.93187895e-02f, 1.29478306e-01f, -1.48996143e-02f, 4.03548172e-03f, 5.78641817e-02f,
  1.01683609e-01f, 5.27632236e-02f, 5.16657121e-02f, -8.04137737e-02f, 2.70511825e-02f, -7.86881298e-02f, -3.90654840e-02f, -1.40684971e-03f, -3.50959003e-02f, -3.35828885e-02f,
  -1.11421272e-01f, -5.42710982e-02f, -6.41889274e-02f, 2.80802995e-02f, -4.64533605e-02f, 3.24252993e-02f, -5.88975213e-02f, 7.28322342e-02f, 6.20844541e-04f, 6.79393262e-02f,
  9.18469019e-03f, -3.89999822e-02f, 3.97952087e-02f, 4.13242280e-02f, 9.04288068e-02f, -6.94423765e-02f, 2.11793594e-02f, -4.46979143e-02f, 6.19612448e-02f, -9.69696045e-02f,
  2.76910327e-02f, -1.51507873e-02f, 3.96331511e-02f, 8.16970691e-02f, 1.77964326e-02f, -2.95862090e-02f, 2.92180050e-02f, 3.92575935e-02f, 3.00721265e-02f, 7.16784373e-02f,
  7.25505799e-02f, 1.52912974e-01f, 1.10182669e-02f, -3.41297896e-03f, -4.73860353e-02f, -8.30180664e-03f, 7.03443065e-02f, -2.77491696e-02f, 2.31469772e-03f, -8.17870274e-02f,
  2.82754079e-02f, -2.19404846e-02f, 3.98154855e-02f, 4.32871841e-02f, -2.98709027e-03f, -6.27990142e-02f, -4.31118943e-02f, 4.38387655e-02f, 1.18573857e-02f, 1.03304602e-01f,
  -1.23937372e-02f, 2.79756151e-02f, -1.15195155e-01f, 7.99417868e-02f, -4.18822430e-02f, -3.75254937e-02f, -7.25759491e-02f, 1.32444520e-02f, -7.47226551e-02f, 5.61117455e-02f,
  3.27605575e-01f, -2.60230809e-01f, -4.59852666e-02f, 2.44522750e-01f, 2.07666904e-01f, -4.54443693e-03f, 7.85447434e-02f, -7.85464793e-02f, 4.65439931e-02f, -2.44880840e-01f,
  9.31122005e-02f, -1.30136266e-01f, -1.38476044e-01f, 1.38629645e-01f, 3.23191911e-01f, -7.71024525e-02f, 6.23057447e-02f, -4.26249653e-02f, 4.97429632e-02f, 9.08256695e-02f,
  1.02095023e-01f, 4.12167944e-02f, 4.58888290e-03f, -9.05186087e-02f, 7.00478181e-02f, -2.35939361e-02f, 8.31980724e-03f, -6.40517026e-02f, 3.72885889e-03f, 1.38548408e-02f,
  -4.42001596e-02f, -3.35541517e-02f, 8.90727490e-02f, 3.88109237e-02f, -1.09599978e-01f, -4.10271771e-02f, -1.22078490e-02f, -1.95349995e-02f, 4.17279191e-02f, -4.18426655e-02f,
  -1.62170194e-02f, 1.43868834e-01f, -8.03837180e-03f, 2.27243919e-02f, 1.66436974e-02f, 1.05083048e-01f, 6.81687593e-02f, -3.07556596e-02f, -2.56439708e-02f, 4.21761675e-03f,
  -6.19318187e-02f, -2.96713840e-02f, -4.19990346e-02f, -1.38172016e-01f, 4.25822586e-02f, 3.62017611e-03f, -1.21421069e-01f, -1.07722044e-01f, -1.00648202e-01f, -5.72560579e-02f,
  -3.82003188e-02f, 1.37872028e-03f, -9.21173096e-02f, 4.16943878e-02f, 7.09012747e-02f, 7.62003139e-02f, 3.40677910e-02f, -2.38973424e-02f, 6.34154072e-03f, 5.93444332e-03f,
  3.06896828e-02f, -1.95438080e-02f, 1.43994996e-02f, -2.13137716e-02f, -2.03049630e-02f, -2.57847290e-02f, -3.36620770e-02f, -3.07062874e-03f, 4.02264902e-03f, -7.69449174e-02f,
  -1.59017947e-02f, -2.53290851e-02f, 2.99042347e-03f, -7.11445063e-02f, 6.47374988e-02f, 5.36852665e-02f, 6.89485669e-02f, -2.91683041e-02f, -3.19224484e-02f, -5.48068946e-03f,
  -6.90982267e-02f, -2.52124548e-01f, -8.26439634e-02f, 2.82554813e-02f, 1.05620064e-02f, -5.86142838e-02f, -3.36494185e-02f, -6.73736334e-02f, -3.92943583e-02f, -1.49642983e-02f,
  -4.33123782e-02f, 2.47528292e-02f, -8.51817578e-02f, 1.66262332e-02f, -9.98744927e-03f, 2.55106408e-02f, -5.89583553e-02f, 1.89577378e-02f, -5.65648898e-02f, -6.16810806e-02f,
  3.98728028e-02f, -1.00166172e-01f, 1.14545189e-02f, -4.08487022e-03f, -2.25768499e-02f, -6.13322109e-02f, -7.65415505e-02f, -6.50180355e-02f, -8.40974078e-02f, -6.76569119e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.07124203e-01f, 9.50640291e-02f, 1.78306937e-01f, 1.37637734e-01f, 2.03644544e-01f, -2.56896805e-04f, 6.43672049e-02f, -5.53127192e-02f, 5.02007157e-02f, 1.54519588e-01f,
  1.22190364e-01f, 3.78828794e-01f, 2.58815661e-02f, 1.25363573e-01f, 4.52765450e-02f, 5.84086441e-02f, 1.74067974e-01f, 2.15174884e-01f, 3.75220664e-02f, 2.77381033e-01f,
  2.62794942e-01f, 1.73531517e-01f, 2.78186034e-02f, -5.77864759e-02f, 2.38630354e-01f, 1.67604148e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.34678558e-01f, -9.08633769e-02f, 1.68055356e-01f, -1.94793597e-01f, -2.49712676e-01f, 4.07474451e-02f, -5.81727326e-02f, 1.70017377e-01f, -3.30494568e-02f, 5.36325350e-02f,
  -1.31293684e-01f, 8.57989267e-02f, 3.22111510e-02f, -2.67463744e-01f, -2.25476474e-02f, 2.09676638e-01f, -4.62855659e-02f, -5.86922653e-02f, -1.41461849e-01f, -1.08928174e-01f,
  -1.33991867e-01f, 2.53621250e-01f, -2.90105343e-01f, 9.44398716e-02f, -7.06667900e-02f, 1.17534712e-01f, 1.85674161e-01f, -1.23583294e-01f, -1.04815498e-01f, -3.54696840e-01f,
  1.41670913e-01f, 2.03007609e-01f, 5.22238202e-02f, -2.11926490e-01f, 9.36614946e-02f, -1.14585273e-01f, -3.59280288e-01f, -2.51019388e-01f, 3.05719614e-01f, 6.05636425e-02f,
  -2.28280276e-01f, -3.67244601e-01f, 1.88075989e-01f, 2.04106234e-03f, -3.83675732e-02f, -2.38743559e-01f, -9.82656106e-02f, 1.58536896e-01f, -6.16542958e-02f, -1.38009369e-01f,
  -2.44584277e-01f, 2.23417819e-01f, -2.10809231e-01f, -1.16223916e-01f, -2.39167109e-01f, -9.69782099e-03f, -1.28738120e-01f, 3.09695035e-01f, 1.09625638e-01f, 9.95255113e-02f,
  -4.08809297e-02f, -2.52814949e-01f, -1.05562387e-02f, -5.48219718e-02f, 1.10032953e-01f, -1.80172548e-01f, 1.35703683e-01f, 3.52885127e-02f, 2.85873562e-01f, -2.19650522e-01f,
  2.03759402e-01f, -3.67148481e-02f, 6.63685277e-02f, -1.69106051e-01f, -5.28826676e-02f, -1.03276543e-01f, 1.71318814e-01f, 5.40383300e-03f, -1.29955530e-01f, -1.50191128e-01f,
  -1.01011604e-01f, -2.40338445e-01f, -2.78636487e-03f, 4.09931615e-02f, 1.20066740e-01f, -6.96703345e-02f, 2.01025546e-01f, 1.95765629e-01f, 2.17714831e-01f, 1.39582008e-01f,
  -3.01936507e-01f, 3.55243266e-01f, 1.48175701e-01f, 2.23782621e-02f, 1.18556954e-01f, -3.12636763e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  8.66207033e-02f, 2.42815599e-01f, 7.62706473e-02f, -7.30140284e-02f, -2.42400333e-01f, -3.26196522e-01f, -1.62664413e-01f, -1.02772504e-01f, -1.45555452e-01f, 3.20552438e-02f,
  1.93248957e-01f, 1.55112073e-01f, 4.31062058e-02f, 3.51364315e-02f, 8.09912533e-02f, -1.35689765e-01f, 1.55413613e-01f, 4.73696917e-01f, 6.95114732e-02f, 2.53607810e-01f,
  -3.23183686e-02f, 1.24212667e-01f, 1.07406974e-01f, -1.88355848e-01f, 1.18638009e-01f, 1.22928329e-01f, 3.51404727e-01f, -9.63058993e-02f, -6.55699447e-02f, 1.84973970e-01f,
  -1.21571660e-01f, 7.91245550e-02f, 1.04817115e-01f, -4.33321521e-02f, 2.58522600e-01f, 3.03278188e-03f, -1.54740155e-01f, -2.91998297e-01f, -1.24417856e-01f, -1.38286680e-01f,
  1.27858192e-01f, -1.05019122e-01f, 2.72198439e-01f, 6.01608604e-02f, -3.21325958e-02f, -1.34236008e-01f, 6.68517128e-02f, -1.73709765e-01f, -9.68760718e-03f, 3.29196528e-02f,
  2.01366782e-01f, 2.78317958e-01f, 2.31176719e-01f, -1.86251685e-01f, -1.52846910e-02f, 7.90950954e-02f, 6.95933923e-02f, 2.18057707e-01f, -1.39567062e-01f, 2.21216857e-01f,
  1.07550375e-01f, -2.91160755e-02f, 3.25465500e-02f, 1.18847720e-01f, 3.20280850e-01f, 4.35592756e-02f, 2.50240803e-01f, -2.33897120e-01f, -4.57944989e-01f, -4.34928745e-01f,
  1.24015547e-01f, -5.57986572e-02f, 1.25034779e-01f, -1.06451847e-01f, -9.06393826e-02f, 2.59887069e-01f, -5.54043651e-02f, 7.16869384e-02f, 3.80886495e-02f, 2.80894637e-02f,
  -1.37979940e-01f, 4.81754750e-01f, 4.32534143e-02f, 2.98743486e-01f, -1.39522301e-02f, 1.51175618e-01f, -8.45331773e-02f, 9.49501023e-02f, -1.39054552e-01f, 2.69172609e-01f,
  5.54524481e-01f, -6.51810467e-02f, -5.47250872e-03f, -1.97132811e-01f, 2.07815155e-01f, 3.95978510e-01f, 4.74936813e-01f, -6.25048652e-02f, 1.86261967e-01f, -1.13554865e-01f,
  -4.37588274e-01f, -5.02684891e-01f, -2.26906493e-01f, -2.20187426e-01f, -1.55807972e-01f, -1.12530865e-01f, 3.29327524e-01f, 2.84977444e-02f, 7.74268433e-02f, 2.81199813e-02f,
  -8.14517662e-02f, -7.42054135e-02f, 2.18111888e-01f, 2.76706874e-01f, 2.86567539e-01f, 3.82948697e-01f, 2.37721622e-01f, -4.68905456e-02f, 1.97467372e-01f, -2.22697347e-01f,
  -1.17550686e-01f, 1.35867625e-01f, 3.07379812e-01f, -9.97384861e-02f, 6.42113462e-02f, -1.91226572e-01f, -1.34127766e-01f, 2.77646840e-01f, 1.13624975e-01f, 2.89421916e-01f,
  2.98384070e-01f, 1.93570763e-01f, 3.82529676e-01f, 2.03412369e-01f, 6.00130409e-02f, 2.01427937e-01f, -8.41005221e-02f, 2.53008455e-02f, -2.14526385e-01f, 1.61671713e-01f,
  2.90668398e-01f, -7.09254714e-03f, -1.80297852e-01f, 5.10271080e-02f, 2.69509554e-01f, 1.54810995e-01f, 2.73194201e-02f, 1.11151924e-02f, 5.23368679e-02f, -3.63518670e-02f,
  1.42316580e-01f, 1.26378566e-01f, -9.95050818e-02f, 2.69478858e-01f, -2.54095942e-02f, 3.62535894e-01f, 1.04881324e-01f, -3.28453109e-02f, -1.32798934e-02f, -2.27641135e-01f,
  3.62583905e-01f, 3.32461715e-01f, 2.08085164e-01f, -1.14733219e-01f, -1.13235071e-01f, 1.90096438e-01f, 4.02639955e-01f, 1.82919487e-01f, 4.37689483e-01f, 8.23767483e-02f,
  2.23813996e-01f, -1.62423104e-01f, -1.00009426e-01f, -9.34789032e-02f, -3.41733074e-04f, 2.97261477e-01f, 1.87022820e-01f, -1.89037681e-01f, -1.29743710e-01f, 8.06339234e-02f,
  -2.82578096e-02f, 1.91737890e-01f, -5.75800091e-02f, -3.57185341e-02f, 4.96219052e-03f, -1.13709629e-01f, 8.96057039e-02f, -2.93885052e-01f, 4.78755608e-02f, -1.54084295e-01f,
  8.25499147e-02f, 1.39160350e-01f, -1.31535321e-01f, -2.21994016e-02f, 7.81503841e-02f, -5.21603925e-03f, 1.67036131e-01f, 5.27049880e-03f, 1.69643879e-01f, 1.32874385e-01f,
  1.15269735e-01f, 1.51706815e-01f, -6.80674836e-02f, 1.68885395e-01f, -1.28423616e-01f, 3.34276780e-02f, -1.56810224e-01f, -3.94460559e-02f, 1.84392586e-01f, -3.62209342e-02f,
  -5.90984039e-02f, -6.92545902e-03f, -1.64119601e-01f, 1.98153809e-01f, 9.05721635e-02f, -1.60094753e-01f, 1.39531821e-01f, -9.78568569e-02f, 7.39351735e-02f, -1.29715696e-01f,
  1.66572649e-02f, -1.56496003e-01f, -6.07214682e-02f, -2.20437627e-02f, 3.89990136e-02f, 6.17088899e-02f, -8.79980177e-02f, 7.05001280e-02f, 3.16752672e-01f, 2.52845496e-01f,
  4.81057838e-02f, -1.20328851e-01f, 3.07549477e-01f, 1.88478291e-01f, 1.65083006e-01f, -6.99615031e-02f, 1.36578247e-01f, -2.02648919e-02f, 1.33860022e-01f, 1.03234082e-01f,
  2.14863062e-01f, 1.63682863e-01f, 1.97267178e-02f, 1.16279498e-01f, 1.33245513e-01f, -1.55052781e-01f, -1.16708703e-01f, -1.16365314e-01f, 5.38551100e-02f, -1.63656652e-01f,
  -1.68207660e-01f, 6.89286366e-02f, 2.62593269e-01f, -1.11262174e-02f, 1.83560297e-01f, 1.36190251e-01f, 2.54312068e-01f, -1.35939687e-01f, 2.07445752e-02f, -1.59558907e-01f,
  -1.70935951e-02f, -1.34901647e-02f, -1.47098124e-01f, -2.79626474e-02f, -9.35653374e-02f, -1.87340751e-01f, 3.54115844e-01f, -1.24230526e-01f, -3.93899307e-02f, -6.82202205e-02f,
  -1.76493436e-01f, 6.88767359e-02f, -6.96255192e-02f, -9.49136615e-02f, -1.32764339e-01f, 1.85577795e-01f, -1.13273039e-01f, 1.54760465e-01f, -1.93384081e-01f, 2.66971976e-01f,
  -1.70127064e-01f, 4.09884304e-02f, 5.53652197e-02f, 1.20306462e-01f, 5.78592420e-02f, -2.85703763e-02f, 2.18165860e-01f, -1.32931834e-02f, 1.82514995e-01f, 2.93709368e-01f,
  2.67091930e-01f, 4.10413779e-02f, 2.32464865e-01f, 2.46198207e-01f, 6.88856363e-01f, 5.59700191e-01f, 5.19621857e-02f, -4.31207232e-02f, 3.98512930e-01f, -7.01641962e-02f,
  5.45300543e-01f, 4.00288612e-01f, -8.32476765e-02f, 3.94797206e-01f, -1.95856363e-01f, -3.34081084e-01f, -2.17074677e-01f, 3.32698107e-01f, 1.88894067e-02f, 1.97059035e-01f,
  -7.44343996e-02f, 7.95713127e-01f, 1.68600813e-01f, 4.18008745e-01f, 2.82863323e-02f, 4.56497759e-01f, 2.39636913e-01f, 1.68587908e-01f, 3.29683602e-01f, -2.24041224e-01f,
  1.23422563e-01f, 2.38252312e-01f, 3.23326975e-01f, -2.41336655e-02f, -2.34775156e-01f, -1.84164383e-02f, 4.20806289e-01f, -1.10811777e-01f, 2.67839193e-01f, 1.44044220e-01f,
  -9.56462622e-02f, -1.52633116e-01f, -4.01966833e-02f, -8.95590186e-02f, 5.36264963e-02f, 3.03574681e-01f, 2.72301026e-02f, -6.27917647e-02f, -6.41280338e-02f, 6.92182779e-02f,
  -6.95427507e-02f, 1.61720857e-01f, -1.77383661e-01f, -7.58157670e-02f, 3.13027725e-02f, -1.84376046e-01f, -8.65865126e-02f, -2.59319901e-01f, 9.27476659e-02f, 7.40308985e-02f,
  1.96780726e-01f, 1.46568879e-01f, 1.23942576e-01f, 9.11315009e-02f, 4.81609553e-02f, -1.55734092e-01f, 2.63795465e-01f, -1.75218228e-02f, 1.92772582e-01f, 4.46000583e-02f,
  3.04580182e-01f, 3.11794788e-01f, 2.08926164e-02f, -9.82772410e-02f, 2.17791110e-01f, -4.76778038e-02f, -1.42146200e-01f, 5.33588044e-02f, -1.50678575e-01f, 3.90301555e-01f,
  1.82533279e-01f, -1.62059739e-01f, 1.64008662e-01f, 1.14293300e-01f, -9.07347910e-03f, -8.64733160e-02f, -9.28689092e-02f, 1.40161321e-01f, 8.54760557e-02f, 5.50249666e-02f,
  7.77667910e-02f, -2.18658715e-01f, 2.48633504e-01f, 2.10218593e-01f, 2.35741735e-01f, 1.93187654e-01f, 2.15459138e-01f, -5.25557362e-02f, 1.00510217e-01f, 1.34228766e-01f,
  1.79113597e-01f, -2.18218237e-01f, 1.39318243e-01f, 2.26312708e-02f, -3.36117260e-02f, -4.35805656e-02f, -1.56705886e-01f, -7.84411728e-02f, 9.29243565e-02f, 9.60116908e-02f,
  2.67951846e-01f, -1.77304689e-02f, 1.27654895e-01f, 8.25493932e-02f, 1.83913961e-01f, -2.12486878e-01f, 5.71432300e-02f, -1.46020293e-01f, 1.40971929e-01f, -1.77007243e-01f,
  -1.72223300e-01f, -7.68123195e-02f, 9.08149779e-02f, -1.52653128e-01f, 1.55096024e-01f, 1.44480601e-01f, 1.01947859e-01f, -1.74476400e-01f, 1.96633384e-01f, -9.71712917e-02f,
  2.51603246e-01f, 1.56482588e-02f, -3.41971554e-02f, -2.00403463e-02f, 1.16952509e-01f, -1.16315491e-01f, -1.13977186e-01f, 3.26965526e-02f, 8.94846022e-02f, -2.29217950e-03f,
  8.83282721e-03f, -1.96125865e-01f, -1.54663309e-01f, 1.36978626e-01f, 5.18907197e-02f, -1.03212662e-01f, 5.84491789e-02f, -1.05387680e-01f, -9.98159572e-02f, 2.85513848e-01f,
  6.19965717e-02f, 2.17951909e-01f, -2.02734113e-01f, 3.48374426e-01f, 1.17359281e-01f, 7.00831190e-02f, 1.33146159e-02f, -9.07213315e-02f, 1.73876211e-01f, 1.26387149e-01f,
  2.07323387e-01f, -1.88247547e-01f, -3.17431748e-01f, 2.27629066e-01f, 2.31377054e-02f, -5.99038973e-02f, 4.36089724e-01f, 2.71010488e-01f, 1.74188182e-01f, 5.67369200e-02f,
  -3.78798395e-02f, 1.44913778e-01f, 1.31677434e-01f, 2.04521328e-01f, 1.37561299e-02f, 2.77958453e-01f, 2.64327731e-02f, 1.55580221e-02f, -1.60792112e-01f, 2.52721697e-01f,
  -1.40486762e-01f, -9.63992625e-02f, 3.03682417e-01f, -1.35667413e-01f, 2.54258543e-01f, -2.80756354e-01f, 1.16360731e-01f, 1.65841207e-01f, -1.54086962e-01f, 3.79451185e-01f,
  -3.22279101e-03f, -1.20720804e-01f, -1.12068921e-01f, -1.26552239e-01f, -9.79132652e-02f, 2.57044900e-02f, -1.61470130e-01f, 8.80862772e-02f, 4.65457737e-02f, 6.71966895e-02f,
  2.84912740e-03f, 6.24233186e-02f, 3.25563774e-02f, -1.12230666e-01f, -5.74296229e-02f, -1.23814054e-01f, -1.15504429e-01f, 1.49473995e-02f, 7.50615122e-03f, -1.54741585e-01f,
  -1.87879115e-01f, -8.40341747e-02f, 9.83458683e-02f, 1.57752763e-02f, -9.37977582e-02f, 1.56267911e-01f, -9.54782665e-02f, 1.31764203e-01f, -1.12078816e-01f, 4.39161770e-02f,
  -1.83379382e-03f, 4.11770791e-02f, 1.26236692e-01f, -1.65145293e-01f, 1.12896934e-01f, -2.07204178e-01f, 4.55018468e-02f, -1.59270212e-01f, 3.89171354e-02f, 9.65787750e-03f,
  -7.02899098e-02f, 4.72511463e-02f, -1.30641192e-01f, 1.72103912e-01f, 2.93871220e-02f, 2.71163434e-01f, 2.39034325e-01f, -1.37579992e-01f, -6.37662783e-02f, 9.99081954e-02f,
  6.73537701e-02f, -4.36712056e-02f, 3.35670114e-02f, -4.00874615e-02f, 1.47904709e-01f, 1.60310626e-01f, 2.14066803e-01f, -1.01133035e-02f, 2.09618792e-01f, -1.43484473e-01f,
  1.96691051e-01f, 3.43742311e-01f, -1.52328253e-01f, 1.79341435e-01f, -1.63789585e-01f, 5.61036915e-02f, -1.35465503e-01f, 9.05138031e-02f, -2.78471746e-02f, 2.47166697e-02f,
  2.73978040e-02f, 2.22260445e-01f, 1.93772018e-02f, -9.72829834e-02f, 8.54770690e-02f, 1.49695709e-01f, 3.22931670e-02f, 6.24267980e-02f, 1.28607124e-01f, 8.02080184e-02f,
  1.19395249e-01f, 9.27320644e-02f, 6.05012216e-02f, -2.93961652e-02f, 5.42465672e-02f, -9.51846242e-02f, 7.66733848e-03f, 1.99687853e-01f, 2.01136962e-01f, -1.16110407e-01f,
  1.71813577e-01f, 1.09357134e-01f, -8.65408704e-02f, 9.92099494e-02f, -1.60735965e-01f, -3.92256863e-02f, 1.41769215e-01f, 6.70714071e-03f, -3.94406356e-02f, 2.37202078e-01f,
  2.84197032e-01f, 2.15918556e-01f, 1.13262497e-01f, -9.36960131e-02f, 2.67142653e-01f, 3.98884773e-01f, -1.01057097e-01f, -9.81044099e-02f, -9.43143144e-02f, -5.02841547e-03f,
  -1.33150533e-01f, -1.57901511e-01f, 1.30868554e-01f, -3.66469519e-03f, 2.07373127e-01f, -7.49636963e-02f, -8.96262601e-02f, -9.10836905e-02f, 3.65740657e-02f, 2.19115447e-02f,
  2.50596225e-01f, 1.40845865e-01f, 2.31728733e-01f, 3.72336000e-01f, 6.83639124e-02f, 1.00786380e-01f, 4.40807194e-02f, 2.11120784e-01f, -6.73013479e-02f, 7.77417049e-02f,
  4.44752723e-03f, 2.61446182e-02f, 2.92225601e-03f, 1.90841421e-01f, 3.55197996e-01f, 5.89188561e-02f, 4.62651104e-01f, 4.10576582e-01f, -5.46116419e-02f, 9.67210084e-02f,
  -7.87473395e-02f, -1.45844847e-01f, 2.28351116e-01f, 4.16157782e-01f, 2.19670013e-01f, 2.41325319e-01f, -1.03814349e-01f, 4.35952917e-02f, 6.15156926e-02f, -1.63924955e-02f,
  -1.06716566e-01f, -6.55708387e-02f, 1.58929467e-01f, -2.39562020e-01f, 2.32145295e-01f, -1.92425549e-01f, 1.48687497e-01f, 1.18817560e-01f, 1.44481942e-01f, 1.84769273e-01f,
  8.64844769e-02f, 2.81745911e-01f, 1.74658969e-01f, 6.50537983e-02f, -2.94282109e-01f, -1.19263254e-01f, -1.04937069e-01f, 7.72645324e-02f, -1.95924595e-01f, 1.14062250e-01f,
  -1.81007504e-01f, 1.43348604e-01f, -1.14661522e-01f, 1.50408477e-01f, -9.79609787e-02f, 1.04031968e-03f, -3.72882523e-02f, 3.31433058e-01f, 3.06793481e-01f, 6.64379671e-02f,
  -1.53606711e-03f, 3.14008333e-02f, 2.74999440e-01f, -1.06570404e-02f, -1.10848762e-01f, -1.43761206e-02f, 2.93708175e-01f, -1.79141685e-01f, 1.54317722e-01f, -9.73533913e-02f,
  1.21000372e-01f, 9.63252708e-02f, 2.75639147e-01f, 1.50061741e-01f, -8.55116397e-02f, 1.25506490e-01f, -1.56744882e-01f, -2.63239682e-01f, -2.14443933e-02f, -1.42893538e-01f,
  -7.90028572e-02f, 4.75474223e-02f, 1.53678864e-01f, -5.98023161e-02f, -6.20265864e-02f, -1.16735943e-01f, -1.84478685e-01f, -1.44928321e-01f, -9.14354771e-02f, 8.46217647e-02f,
  2.01816171e-01f, 3.52638625e-02f, -7.27484375e-02f, -7.91043267e-02f, 2.84689873e-01f, -6.74268603e-02f, 7.79978782e-02f, 2.46312246e-01f, 2.93703731e-02f, 3.31911445e-01f,
  1.03090629e-01f, -9.96858105e-02f, 1.94644809e-01f, -1.81013837e-01f, 1.13042802e-01f, 3.68476808e-01f, 2.60915071e-01f, 1.52877390e-01f, 4.46535915e-01f, -5.65655380e-02f,
  -2.36022398e-01f, -4.03363071e-02f, 1.04550861e-01f, 3.85543585e-01f, -8.21109414e-02f, 1.32276565e-01f, -9.96916294e-02f, 2.18488425e-01f, -1.57438323e-01f, -1.02090597e-01f,
  1.34618497e-02f, 2.80109823e-01f, 2.63593495e-01f, 4.20082211e-02f, 1.47309497e-01f, -1.89049974e-01f, 5.82481742e-01f, 1.07623518e-01f, 2.06796095e-01f, 1.04872786e-01f,
  -2.05940053e-01f, 5.60725152e-01f, 1.16744369e-01f, 2.52273411e-01f, 1.26412004e-01f, -4.66543399e-02f, 4.16974068e-01f, 2.76923716e-01f, 2.23605439e-01f, -6.05419884e-03f,
  -3.59533161e-01f, -2.20154047e-01f, 2.29348764e-01f, 7.00749308e-02f, 3.27136308e-01f, -1.13157369e-01f, 1.93813339e-01f, -1.70628607e-01f, 2.16941863e-01f, -1.91806510e-01f,
  -1.23571521e-02f, 4.79010969e-01f, -1.23895958e-01f, -1.53114960e-01f, -3.58005837e-02f, 1.98236272e-01f, -3.28178145e-02f, 2.16125935e-01f, -2.11291835e-02f, 1.06151238e-01f,
  -1.79553732e-01f, 4.11471814e-01f, 4.21559960e-01f, -1.62389457e-01f, -1.19230673e-01f, -1.46377653e-01f, 3.58411819e-01f, 4.33194786e-02f, 2.56065205e-02f, 1.89061508e-01f,
  1.62981957e-01f, -4.61602025e-03f, 1.55433565e-01f, -2.68058479e-02f, -3.19754565e-03f, -2.20835075e-01f, 3.07808399e-01f, 2.44751990e-01f, 2.65090335e-02f, -1.60216540e-01f,
  -1.94178492e-01f, -5.31412777e-04f, -7.09391839e-04f, -1.61360782e-02f, 8.13000202e-02f, 1.67947412e-01f, -8.77370983e-02f, -1.36757731e-01f, 1.02374703e-01f, 1.95498198e-01f,
  -1.41969576e-01f, -1.10741816e-01f, 1.79631058e-02f, -1.85022041e-01f, 1.76889330e-01f, -1.50447890e-01f, 5.90159968e-02f, -9.06241164e-02f, 9.94640887e-02f, -4.56149243e-02f,
  -2.41195168e-02f, -1.49794236e-01f, -7.92452991e-02f, 1.57959089e-01f, 9.58291143e-02f, -4.85042203e-03f, -5.30374348e-02f, 6.85132295e-02f, -3.50982323e-02f, -7.83634093e-03f,
  -6.14289828e-02f, -7.72924870e-02f, -1.50217980e-01f, 1.35528855e-02f, -7.41819441e-02f, 6.77170185e-03f, -5.35219498e-02f, -3.30866352e-02f, -7.70562440e-02f, 1.62621327e-02f,
  1.01212613e-01f, -1.13813207e-01f, -1.62922055e-01f, -3.02879009e-02f, 1.15711786e-01f, -1.62059292e-01f, -8.37078914e-02f, -1.01663567e-01f, -7.44491220e-02f, -6.32084906e-02f,
  -1.64816797e-01f, 1.44700512e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  8.50847811e-02f, 3.47242355e-01f, 3.11924428e-01f, 4.26918894e-01f, 3.63192052e-01f, 4.86074388e-02f, 3.97701599e-02f, -9.01672766e-02f, 1.06225863e-01f, 4.03427839e-01f,
  1.51242599e-01f, 3.43377180e-02f, 7.50637129e-02f, -6.83221444e-02f, 3.95395219e-01f, 4.12253439e-02f, -1.50159210e-01f, -6.48369715e-02f, -2.93381000e-03f, 1.43425882e-01f,
  3.16834867e-01f, 2.20318243e-01f, 4.75181103e-01f, 3.29602659e-01f, 8.08058232e-02f, 7.40209818e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.95073280e-02f, 2.50094980e-02f, 2.58436888e-01f, 3.66494626e-01f, 1.36909798e-01f, -4.00299579e-01f, 2.41482332e-01f, -2.21317440e-01f, 3.60738337e-01f, 2.37528086e-01f,
  1.40102535e-01f, -3.29845748e-03f, 9.55600590e-02f, -1.83814898e-01f, 8.27238932e-02f, -1.82214916e-01f, -1.57401443e-01f, -1.66216105e-01f, -2.19887599e-01f, -2.38146022e-01f,
  1.77386031e-01f, 1.02349557e-01f, -1.80298239e-01f, -8.63040835e-02f, 3.79109383e-02f, 1.37711251e-02f, 2.15198517e-01f, -1.37343317e-01f, -7.71582685e-03f, 1.06246560e-03f,
  -1.49208739e-01f, 1.58977985e-01f, 2.70303309e-01f, 7.30575845e-02f, 1.63428053e-01f, -2.90194035e-01f, -3.20124686e-01f, 4.13048595e-01f, 1.86965987e-02f, 4.44395654e-02f,
  1.10549822e-01f, 1.53706390e-02f, 1.46171644e-01f, -1.76890075e-01f, -7.25131333e-02f, 5.96095249e-02f, -1.77687749e-01f, -2.26046108e-02f, -2.25272834e-01f, -2.30088457e-01f,
  1.10364640e-02f, 1.85659558e-01f, 1.35688903e-02f, 1.57611758e-01f, 1.18045956e-02f, 2.14872509e-01f, 6.27057105e-02f, -2.47994363e-01f, -5.86265586e-02f, 1.01798333e-01f,
  3.57223570e-01f, -1.77114382e-01f, 1.71799734e-02f, -1.30303875e-01f, 1.56208783e-01f, -8.69274586e-02f, 5.48434630e-02f, -3.36464316e-01f, 9.49050672e-03f, 3.28427285e-01f,
  -2.55584810e-03f, 2.89148092e-01f, -1.38197303e-01f, 1.04836367e-01f, 1.10902816e-01f, -2.14827508e-02f, -1.25578597e-01f, -9.88287181e-02f, 1.07981190e-01f, 6.30513728e-02f,
  -2.72831798e-01f, -1.64956465e-01f, 9.46270600e-02f, 8.35295022e-02f, -1.78095251e-01f, 9.70687643e-02f, -3.34539525e-02f, 9.48439687e-02f, 1.52996898e-01f, -2.84808785e-01f,
  5.09665683e-02f, 4.84825075e-02f, 4.37074840e-01f, -1.27175733e-01f, -1.07597858e-01f, 1.35815367e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -8.20702463e-02f, -2.46563077e-01f, -1.76752374e-01f, -5.57684153e-02f, -2.48900607e-01f, 6.08540215e-02f, 2.47457344e-02f, -7.34438673e-02f, -3.04674715e-01f, -2.93591708e-01f,
  5.13920337e-02f, -1.15812406e-01f, 8.78306199e-03f, 3.01687628e-01f, 1.57628343e-01f, 5.53242385e-01f, -9.71435905e-02f, -7.93624893e-02f, 1.67284712e-01f, 1.85530335e-01f,
  6.62853047e-02f, 1.10801473e-01f, 2.14565154e-02f, 2.10746691e-01f, 3.52751821e-01f, 2.69346625e-01f, 2.24041566e-02f, -9.57431793e-02f, 2.27451608e-01f, -2.15867117e-01f,
  -1.13261878e-01f, 1.55559823e-01f, -1.49057180e-01f, -8.95593315e-02f, -8.29997808e-02f, 3.91844772e-02f, -1.28913507e-01f, -1.25709340e-01f, 4.08442914e-02f, -7.70002306e-02f,
  -1.28105775e-01f, 1.51683927e-01f, -6.56322166e-02f, -1.88404601e-02f, 7.06567094e-02f, 5.29485904e-02f, -1.68420091e-01f, -1.01856336e-01f, 1.20235302e-01f, 8.66277667e-04f,
  8.25299323e-02f, 1.58507288e-01f, -1.15059242e-01f, 1.67987481e-01f, 8.59838969e-04f, 1.15541920e-01f, 1.32695124e-01f, -1.49052020e-03f, -1.87119991e-01f, 2.33950354e-02f,
  -1.04551904e-01f, -1.36124730e-01f, 1.21162541e-01f, -1.12192214e-01f, -8.78382772e-02f, -2.81322569e-01f, 5.80901792e-03f, -4.84016761e-02f, -2.50459254e-01f, 1.06844611e-01f,
  8.67633056e-03f, -1.17097542e-01f, 1.13129742e-01f, -1.99149579e-01f, 1.06066905e-01f, 2.81006210e-02f, 7.24520311e-02f, -1.18144169e-01f, -1.14683338e-01f, 3.09416205e-01f,
  6.41863570e-02f, -9.83265862e-02f, -9.47240070e-02f, -9.80719700e-02f, 1.74371917e-02f, -8.79165083e-02f, 1.39108971e-01f, -5.53489216e-02f, -5.36815561e-02f, -1.45922974e-01f,
  1.70680583e-02f, -2.32788473e-01f, 3.78830992e-02f, -1.47906303e-01f, -8.90202150e-02f, 1.26573905e-01f, -1.50954887e-01f, -1.55968964e-01f, -2.35357732e-02f, -1.51812747e-01f,
  2.05221325e-02f, -1.16953090e-01f, -9.92311090e-02f, 1.68469504e-01f, -1.75610259e-01f, -7.05696270e-02f, -1.53265983e-01f, 5.56607805e-02f, -1.30125508e-01f, -2.92191934e-02f,
  -4.74530272e-02f, 4.87717846e-03f, -1.06854379e-01f, 6.28751963e-02f, -9.40814167e-02f, 7.71714002e-02f, -9.42167186e-04f, 2.84600127e-02f, -3.64724174e-02f, -1.93366073e-02f,
  1.39856547e-01f, -1.20815039e-01f, -9.79746506e-02f, -1.62843466e-01f, -1.12283016e-02f, 4.13079262e-02f, 1.39381602e-01f, -9.42251459e-02f, -5.55166826e-02f, 1.45532742e-01f,
  -4.31151018e-02f, -3.42369750e-02f, 6.46728650e-02f, -1.82805508e-01f, -9.36123356e-02f, -1.27510363e-02f, 5.60859405e-03f, -1.82841092e-01f, 4.57208753e-02f, 2.46426258e-02f,
  -1.70786545e-01f, 7.37110823e-02f, 9.94070917e-02f, -9.08660665e-02f, -2.40449142e-02f, 7.60137243e-03f, 5.44311889e-02f, 5.20115122e-02f, -5.19012511e-02f, -1.70959666e-01f,
  -1.43587023e-01f, -5.40399365e-02f, 1.08153373e-02f, -4.05695066e-02f, -5.75932562e-02f, 1.25991732e-01f, 1.93355680e-02f, -1.18667036e-01f, -1.24806929e-02f, 3.69767249e-02f,
  7.28832036e-02f, -1.81470752e-01f, -1.41704664e-01f, 9.47382078e-02f, -4.56705511e-01f, -3.72250468e-01f, 2.76556402e-01f, -1.22037977e-02f, 4.10164326e-01f, 1.42107815e-01f,
  -2.14856421e-03f, 1.27115741e-01f, -6.56086132e-02f, 3.90258655e-02f, -2.88466007e-01f, -5.29948294e-01f, 1.38577819e-01f, 4.34867203e-01f, 2.51723558e-01f, -1.10762432e-01f,
  4.69102859e-01f, -1.67040601e-01f, 1.51454195e-01f, 1.47128955e-01f, 1.92345783e-01f, 4.27122295e-01f, 3.50951195e-01f, -1.21472970e-01f, 2.14439049e-01f, 6.04042187e-02f,
  2.74905533e-01f, -1.52893648e-01f, 2.90095717e-01f, 4.14381981e-01f, 1.71317130e-01f, -1.20723866e-01f, 3.48789394e-02f, 3.29155058e-01f, 4.65122908e-01f, 4.20634359e-01f,
  4.88162160e-01f, 6.57664895e-01f, 1.11185186e-01f, -4.08851773e-01f, -1.33945301e-01f, 3.02134585e-02f, -3.26653458e-02f, -3.52948517e-01f, -4.36380394e-02f, 3.83690894e-01f,
  -3.38130742e-02f, 2.40461864e-02f, -2.40183026e-01f, -6.06227443e-02f, -9.47468057e-02f, -1.78793728e-01f, 2.67403483e-01f, -2.08129641e-02f, 3.37788254e-01f, 5.24757624e-01f,
  5.89783907e-01f, 5.68406470e-02f, -1.68268040e-01f, 6.66993633e-02f, 5.26846796e-02f, -1.31273553e-01f, -4.43716645e-02f, 2.46833190e-01f, 2.57803738e-01f, -2.66603768e-01f,
  2.15538234e-01f, -1.15680930e-04f, 4.10961062e-01f, 3.62979949e-01f, -2.60948479e-01f, -1.23076148e-01f, -6.87729642e-02f, -9.01040211e-02f, 1.19744264e-01f, -1.91206291e-01f,
  -1.37445897e-01f, 3.32539156e-02f, 6.76627159e-02f, -1.07874505e-01f, 2.39673138e-01f, 1.37486488e-01f, 1.96324006e-01f, -3.11426930e-02f, -1.12697877e-01f, 5.52060828e-02f,
  7.90297091e-02f, 1.25160873e-01f, -2.43333161e-01f, 1.47373855e-01f, -8.36390108e-02f, -1.66329986e-03f, -7.72644877e-02f, -1.25627220e-01f, -9.97665618e-03f, 9.23964307e-02f,
  -1.05807371e-01f, 4.39705700e-02f, 4.04858775e-02f, 9.74909291e-02f, -5.97180687e-02f, -1.23032622e-01f, -1.58820808e-01f, -1.74540672e-02f, 1.37141896e-02f, -8.32514092e-02f,
  -1.01661004e-01f, 5.56726903e-02f, 1.18596062e-01f, 5.81218824e-02f, 5.68612702e-02f, -6.57559484e-02f, -1.83249339e-01f, 1.66349605e-01f, 1.39873968e-02f, 6.94267824e-02f,
  9.13557559e-02f, 1.29047066e-01f, 9.16497856e-02f, -4.04380262e-02f, -1.45250544e-01f, -1.06012868e-02f, 1.38905749e-01f, -1.00312695e-01f, 1.14508178e-02f, 1.11001410e-01f,
  2.55352139e-01f, -1.34096831e-01f, -4.02560323e-01f, 1.37283355e-01f, -4.94717807e-02f, -4.85023484e-02f, -2.80756950e-01f, -8.15176293e-02f, 3.19862336e-01f, 1.96341932e-01f,
  -2.79080942e-02f, 2.31633276e-01f, -1.38918400e-01f, -1.11118488e-01f, 2.13517904e-01f, -1.47706851e-01f, 6.88814223e-02f, -1.64056018e-01f, 1.91740498e-01f, -1.67387858e-01f,
  5.49409166e-02f, -4.18366529e-02f, 1.20792978e-01f, 1.66710287e-01f, 2.62260854e-01f, 2.27868974e-01f, 3.03721607e-01f, -3.21253277e-02f, 9.04825702e-02f, 1.46245196e-01f,
  -2.70167384e-02f, -1.47644773e-01f, -2.30815366e-01f, -1.26437530e-01f, -2.11116485e-02f, 1.37975542e-02f, 1.22922353e-01f, -1.65462911e-01f, 8.80751908e-02f, 6.00217767e-02f,
  -2.02642947e-01f, -6.73239678e-02f, -3.10363318e-03f, -4.68204580e-02f, -2.10736394e-01f, -1.29805058e-02f, 2.34432146e-01f, 1.14615850e-01f, 3.32879834e-02f, -1.16748221e-01f,
  2.42957324e-01f, -1.07365297e-02f, 2.89612859e-01f, 7.74322599e-02f, 2.53881454e-01f, 8.45034122e-02f, -8.66203159e-02f, -9.32275206e-02f, 1.47771403e-01f, 4.84875515e-02f,
  -5.34140132e-02f, -5.49531206e-02f, 6.56761408e-01f, 4.27321792e-01f, 6.55096948e-01f, -2.61425942e-01f, 3.49189453e-02f, -1.72692791e-01f, 3.48870069e-01f, 3.99906307e-01f,
  3.86673324e-02f, 6.56502128e-01f, 3.59291062e-02f, -4.63067219e-02f, -1.44429430e-01f, -1.82983875e-02f, -1.58852190e-01f, -3.29331011e-01f, 7.65115917e-02f, -2.14758009e-01f,
  3.78302366e-01f, -2.58612297e-02f, 3.18581045e-01f, -1.18475527e-01f, -3.57668586e-02f, -1.52646169e-01f, 7.87913129e-02f, -1.58804163e-01f, 3.56541932e-01f, 1.00301802e-01f,
  1.05310127e-01f, 1.69716552e-02f, -8.59250948e-02f, -1.28740072e-01f, 1.39842480e-01f, 4.75090444e-02f, 6.26447573e-02f, 1.58396989e-01f, 3.23472172e-01f, -3.82682621e-01f,
  1.46630540e-01f, 1.16132431e-01f, 4.83993441e-01f, 2.84277350e-01f, -5.53597033e-01f, 6.02953196e-01f, 2.10543185e-01f, -6.50662705e-02f, 4.52662073e-02f, 2.09472135e-01f,
  4.92355615e-01f, 6.10119384e-03f, 5.17626069e-02f, -1.98697701e-01f, 6.85572803e-01f, 5.81879504e-02f, 7.41945654e-02f, 1.20420277e-01f, -1.44422576e-01f, 6.14354312e-01f,
  -1.15123071e-01f, -1.07381931e-02f, -5.35076559e-01f, 5.53368926e-01f, 2.56901532e-01f, 1.03211865e-01f, 4.47918400e-02f, -1.68167844e-01f, 1.25036225e-01f, 1.21055037e-01f,
  -9.87830311e-02f, 1.50719479e-01f, -3.59063745e-02f, 1.11996122e-01f, -1.39540091e-01f, 5.97229553e-03f, 1.94275990e-01f, 1.85033277e-01f, 1.64776713e-01f, 1.97359324e-02f,
  -1.53186068e-01f, -5.55510297e-02f, 6.26076311e-02f, 2.65695713e-02f, -1.30322233e-01f, -1.67861730e-02f, -9.35084894e-02f, -6.09085821e-02f, -1.36672392e-01f, -3.95072252e-02f,
  1.45945489e-01f, 1.61848456e-01f, -5.06413216e-03f, 2.55492236e-03f, 1.72753513e-01f, 7.94211850e-02f, 2.05921590e-01f, -8.54119658e-03f, 2.06921622e-01f, 2.53769159e-01f,
  3.02143812e-01f, 4.57287341e-01f, 5.45387745e-01f, 9.75131765e-02f, 5.83420210e-02f, 1.79424077e-01f, 3.54129672e-01f, 2.36716405e-01f, 1.26214504e-01f, 2.51395226e-01f,
  -1.79439574e-01f, -7.32545182e-02f, 4.42182630e-01f, 5.58898807e-01f, -4.59173024e-02f, 9.62032899e-02f, -2.55093873e-01f, 1.23519696e-01f, -8.94316360e-02f, 7.79955881e-03f,
  -3.24394345e-01f, 4.91659082e-02f, -2.31696635e-01f, -2.18822479e-01f, 8.09618682e-02f, 1.28029257e-01f, -2.96692431e-01f, 7.35336304e-01f, -1.47757828e-01f, -1.51666835e-01f,
  -1.45928159e-01f, -1.96681693e-01f, -1.89661339e-01f, -2.98972040e-01f, -3.26276749e-01f, 2.74533331e-02f, 1.38034657e-01f, 7.50656575e-02f, -9.96404737e-02f, 1.03999428e-01f,
  -1.10631794e-01f, -9.05799419e-02f, 1.78504542e-01f, 1.42759696e-01f, -1.07418932e-01f, 3.84682119e-01f, -1.69100642e-01f, 1.72343016e-01f, -1.49209753e-01f, 1.68879896e-01f,
  2.01296404e-01f, -8.42288509e-02f, 2.80223846e-01f, 2.28034928e-01f, -2.07849033e-02f, 2.40114346e-01f, -9.09722000e-02f, 1.29392147e-01f, 3.04153502e-01f, -1.06448561e-01f,
  -7.95591250e-03f, 1.24500096e-01f, 8.07380024e-03f, -1.71319544e-01f, -1.49084181e-01f, 1.59167409e-01f, -1.30295426e-01f, -1.36872098e-01f, -6.90848902e-02f, 2.75670271e-02f,
  1.57333791e-01f, 2.59248856e-02f, -1.01291999e-01f, 1.36661798e-01f, 1.19788110e-01f, -1.13191850e-01f, -3.50400023e-02f, -5.64443581e-02f, -1.36414230e-01f, -6.98371828e-02f,
  1.49623871e-01f, -1.01161398e-01f, -1.56130344e-01f, -1.55005231e-01f, 1.38834953e-01f, -1.25354245e-01f, 9.95935574e-02f, 5.47332037e-03f, -3.22962292e-02f, 1.58178225e-01f,
  -1.01739056e-01f, -1.31943807e-01f, -1.15791313e-01f, -1.27107492e-02f, 6.84036165e-02f, 3.37204397e-01f, 2.80911140e-02f, 3.01043868e-01f, 5.89638315e-02f, 1.50279224e-01f,
  -1.61821917e-01f, -4.67599593e-02f, 9.56437737e-03f, -9.43705887e-02f, 3.37677449e-01f, 3.39356512e-01f, 1.43798338e-02f, -1.32021055e-01f, 6.92857951e-02f, 7.49605477e-01f,
  3.18533778e-01f, 2.88089179e-02f, -1.29219636e-01f, 1.82740942e-01f, -8.60576630e-02f, 5.15618660e-02f, -2.17991203e-01f, 5.43511733e-02f, 2.79484317e-03f, 7.46273175e-02f,
  -7.97780305e-02f, -1.03716269e-01f, 2.67655868e-02f, 5.05049527e-01f, -2.04011332e-02f, -9.20794625e-03f, -1.20079093e-01f, 1.54353291e-01f, -1.50249988e-01f, -8.22248533e-02f,
  -2.94046365e-02f, -2.99714459e-03f, -1.12338938e-01f, -5.23778573e-02f, 9.04924572e-02f, -2.06422895e-01f, -5.04726656e-02f, 2.06273109e-01f, 2.06852388e-02f, 3.01589459e-01f,
  3.46555188e-02f, -4.43781428e-02f, 5.21700941e-02f, 2.68174917e-01f, 7.31411278e-02f, -1.45486251e-01f, 3.49982142e-01f, -1.12031035e-01f, 9.47821662e-02f, -1.38465017e-01f,
  1.96899414e-01f, 1.66079953e-01f, 5.49151935e-02f, -1.15463860e-01f, -1.59961600e-02f, 2.50944436e-01f, 3.06730002e-01f, -6.55292273e-02f, 2.87507206e-01f, 3.40650409e-01f,
  -1.05628647e-01f, -2.01495305e-01f, 7.63657540e-02f, 6.21629596e-01f, -1.51577190e-01f, 1.59780949e-01f, 6.50900155e-02f, -7.02324212e-02f, 3.56704444e-01f, 1.50717780e-01f,
  -2.67252023e-03f, 1.00305793e-03f, -1.31696552e-01f, 1.01626158e+00f, 2.16404662e-01f, 1.48637787e-01f, 7.49142980e-03f, 1.05589986e-01f, -3.89711738e-01f, -2.17926372e-02f,
  -3.19635160e-02f, -1.24838255e-01f, -4.50174175e-02f, 2.00389065e-02f, -2.04649970e-01f, 1.40424713e-01f, 2.08179086e-01f, 3.24066609e-01f, -1.91281855e-01f, 1.51832581e-01f,
  -1.09023258e-01f, -7.99966976e-02f, 1.30161643e-01f, -2.50807494e-01f, -1.58742324e-01f, -5.05174212e-02f, 1.54106081e-01f, -5.35077304e-02f, 4.10338044e-02f, -9.27615166e-02f,
  -4.98255230e-02f, -1.33312732e-01f, -5.19645028e-02f, -8.80099982e-02f, -1.74163386e-01f, -6.72972798e-02f, -4.70194891e-02f, 1.95582926e-01f, -3.12726982e-02f, 8.79967138e-02f,
  1.05026864e-01f, 8.60434696e-02f, 7.82812536e-02f, -9.77908447e-02f, -1.41934499e-01f, -7.89801478e-02f, 8.58806819e-02f, 1.89834103e-01f, 3.81081998e-02f, 3.96281108e-02f,
  8.34626425e-03f, 1.05216447e-02f, 3.27254057e-01f, 1.29706830e-01f, 1.19513817e-01f, -4.92835939e-02f, 2.35237479e-01f, 1.74244747e-01f, -5.35106752e-03f, 9.74080563e-02f,
  1.01713195e-01f, 3.00114840e-01f, -1.86785266e-01f, -7.22632855e-02f, -1.96192622e-01f, 2.98485421e-02f, 1.05208188e-01f, 7.37231150e-02f, 1.90125287e-01f, -8.61086249e-02f,
  9.14931819e-02f, -1.95383519e-01f, -2.89018378e-02f, 1.23585761e-01f, -1.04082689e-01f, -7.61763752e-02f, -2.52458483e-01f, -7.82688782e-02f, 9.25347731e-02f, 2.18816251e-01f,
  1.13218598e-01f, 3.10720295e-01f, -1.49857298e-01f, -1.42308205e-01f, 1.77950129e-01f, 3.72400492e-01f, 8.55688378e-02f, 1.84478581e-01f, -2.58516729e-01f, 7.59468228e-02f,
  -2.58754432e-01f, -1.63884416e-01f, -4.60057035e-02f, -2.66156614e-01f, 1.97996527e-01f, 3.50099266e-01f, -8.07889104e-02f, -4.22481634e-02f, -1.92411199e-01f, 3.59105051e-01f,
  2.55604655e-01f, 2.71829776e-02f, 3.53089094e-01f, -1.35283783e-01f, -3.12556922e-02f, -6.86820596e-03f, -1.40804112e-01f, -7.13283867e-02f, 1.27353802e-01f, 3.01663309e-01f,
  -1.33991644e-01f, -3.77479941e-02f, 2.42976218e-01f, 1.31951213e-01f, 2.72010956e-02f, 7.21079335e-02f, 4.35545295e-01f, 1.70426726e-01f, 3.70001227e-01f, -5.48200216e-03f,
  -4.02573347e-01f, 2.88387805e-01f, -1.42990023e-01f, 8.96950136e-04f, -2.54770845e-01f, 9.31569114e-02f, 3.64983737e-01f, -1.56121269e-01f, -4.94143106e-02f, 3.61141749e-02f,
  7.52231777e-02f, 5.14953136e-01f, -2.27690414e-01f, 2.09681913e-01f, 1.23109236e-01f, 1.62315682e-01f, -1.80288076e-01f, 1.79858327e-01f, -1.47905543e-01f, 1.28208324e-01f,
  2.08735928e-01f, -2.97930278e-02f, 5.84675483e-02f, 2.00213268e-01f, 3.73545915e-01f, -2.62461770e-02f, -1.99696764e-01f, -6.61974326e-02f, 1.61846608e-01f, 3.81003261e-01f,
  1.67893440e-01f, 2.05865055e-01f, -1.58943489e-01f, -2.08812594e-01f, 3.01228702e-01f, 1.35782808e-01f, 5.38796127e-01f, 3.92421395e-01f, -4.04907428e-02f, -7.93031454e-02f,
  -1.63523346e-01f, -3.22865665e-01f, -6.14178367e-02f, -8.89682099e-02f, 4.51226309e-02f, -8.46375450e-02f, -1.48584113e-01f, -1.60443097e-01f, 8.01835284e-02f, -1.36221483e-01f,
  1.26726881e-01f, 1.70530096e-01f, -2.89952278e-01f, -9.63781103e-02f, 4.82626021e-01f, 3.89250182e-02f, 2.29968399e-01f, 3.78693849e-01f, 3.90830226e-02f, 1.74507350e-01f,
  2.09470004e-01f, -1.61947787e-01f, 3.41199547e-01f, -1.90104276e-01f, -4.73745972e-01f, 5.10418438e-04f, -1.68129683e-01f, -3.43184806e-02f, -3.10984790e-01f, 2.18308792e-02f,
  3.14953178e-01f, 1.36627853e-02f, 2.19049111e-01f, 2.87571162e-01f, 8.14600736e-02f, -1.22117309e-03f, 8.85220096e-02f, 2.04129949e-01f, -1.58924889e-02f, 1.54878125e-01f,
  6.84845522e-02f, 1.51247516e-01f, 1.62025765e-02f, 4.75512967e-02f, 2.64050305e-01f, 2.78429240e-01f, -1.25564680e-01f, 5.40885516e-03f, 5.02235889e-01f, -1.14819705e-01f,
  1.96332648e-01f, -8.12877566e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  6.38937950e-02f, 7.14749098e-02f, 3.57135199e-02f, -2.77506411e-02f, -1.06743626e-01f, 2.04720884e-03f, 3.67604852e-01f, -7.97042996e-02f, -4.89989445e-02f, 3.75926644e-01f,
  1.91433191e-01f, 5.99681973e-01f, 1.41562611e-01f, -1.50305808e-01f, 1.66592747e-01f, -9.00712907e-02f, -1.18377268e-01f, 2.48381153e-01f, -7.40257576e-02f, 3.56379561e-02f,
  -1.36239186e-01f, 1.06928594e-01f, 1.97506353e-01f, 2.93836117e-01f, 2.37964272e-01f, 1.11421116e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.59776115e-01f, -9.86652821e-02f, -4.67537194e-02f, -4.11238521e-01f, 5.16091585e-01f, 3.80040079e-01f, 3.79879743e-01f, -3.99661362e-02f, -1.46520019e-01f, -4.22977023e-02f,
  -1.69345468e-01f, -1.57964334e-01f, 3.87288153e-01f, -1.42030358e-01f, -1.05893947e-01f, 4.96844053e-01f, -1.06151495e-02f, 9.27413106e-02f, -7.16962874e-01f, 2.29508504e-01f,
  -6.88111603e-01f, 1.41460747e-01f, 1.55639738e-01f, -2.71045893e-01f, 5.36181927e-02f, -5.27598746e-02f, 1.45373628e-01f, -1.82186857e-01f, 1.11374490e-01f, 5.95936179e-01f,
  -6.57636166e-01f, 6.94415629e-01f, 2.84526765e-01f, 4.95961815e-01f, 3.64995480e-01f, -1.98117713e-03f, -3.13122049e-02f, -6.60009801e-01f, 3.07799011e-01f, -9.26334485e-02f,
  9.18593109e-02f, -1.37425229e-01f, 6.74774870e-02f, 3.09980780e-01f, -4.68306899e-01f, -2.00077537e-02f, -1.43108860e-01f, 1.79260910e-01f, 2.37876400e-01f, -4.82068863e-03f,
  3.81554037e-01f, 1.70014635e-01f, -3.93462360e-01f, 2.68706411e-01f, 1.42197892e-01f, -5.17050773e-02f, 2.28327438e-01f, -3.73883069e-01f, -8.42875019e-02f, -2.73592144e-01f,
  2.83683240e-01f, 1.87228903e-01f, -3.34376812e-01f, 4.76148963e-01f, -3.65348130e-01f, -3.86931121e-01f, -4.67930853e-01f, 2.41449207e-01f, -2.76296198e-01f, -2.64195412e-01f,
  -7.46386945e-02f, 5.10015450e-02f, 1.36457443e-01f, 1.13173038e-01f, 1.46913230e-01f, 7.04351068e-01f, 7.94432685e-02f, 2.53400147e-01f, 1.04391605e-01f, -8.63227323e-02f,
  2.27200761e-01f, -3.78159434e-01f, 5.35173059e-01f, 7.71991387e-02f, 4.90760989e-02f, -9.36762318e-02f, -1.22826323e-01f, -1.55080274e-01f, 4.55648392e-01f, -4.47273582e-01f,
  4.05149870e-02f, -3.05564225e-01f, -2.00416699e-01f, -6.31185293e-01f, 1.24089040e-01f, 3.52449007e-02f, -1.90675721e-01f, 2.71455854e-01f, -1.30856588e-01f, -3.82630408e-01f,
  1.74182370e-01f, 6.09618425e-01f, 1.75896034e-01f, 4.21539173e-02f, -1.57011271e-01f, 6.09186627e-02f, 1.38158947e-01f, -1.04347393e-01f, -2.06917524e-01f, -6.70811012e-02f,
  -4.82486002e-02f, -4.27588791e-01f, -1.26367107e-01f, -5.46265423e-01f, -7.08213925e-01f, -3.12525108e-02f, 4.95651007e-01f, -1.44873291e-01f, 6.11720011e-02f, 4.28063571e-01f,
  -1.12970889e-01f, 6.26554072e-01f, 1.33187741e-01f, 3.12671736e-02f, 7.47785494e-02f, 3.34558457e-01f, -4.75117058e-01f, -9.67876390e-02f, 1.07379660e-01f, -2.49457791e-01f,
  -2.69014221e-02f, -1.17988192e-01f, 1.66880265e-01f, 3.26793730e-01f, -3.09115231e-01f, 1.54579684e-01f, -1.41954035e-01f, 1.31377637e-01f, 1.27110407e-01f, -2.99843222e-01f,
  7.91404963e-01f, -2.82678436e-02f, -4.76280265e-02f, 5.12429653e-03f, 9.00697801e-03f, -3.70113850e-02f, -6.04469001e-01f, 5.12968153e-02f, 2.16763727e-02f, 2.07107157e-01f,
  -9.96760428e-02f, 5.26946038e-02f, -8.89792293e-02f, 5.86025238e-01f, 3.23416479e-02f, 1.47748888e-01f, 7.05205798e-02f, 3.47821951e-01f, 2.14474365e-01f, -1.17345639e-01f,
  4.43165958e-01f, 4.33442563e-01f, 5.86339831e-01f, 3.38062763e-01f, 3.99910063e-01f, 4.10115272e-01f, -4.36139941e-01f, -1.84660763e-01f, -2.67274287e-02f, -1.24912620e-01f,
  -2.18532458e-02f, -2.50762701e-02f, 1.51396111e-01f, -2.71062493e-01f, 1.37525931e-01f, 4.33616281e-01f, -1.56178162e-01f, 9.17524457e-01f, -1.42596781e-01f, -1.09829329e-01f,
  3.88462394e-02f, -4.87312555e-01f, -6.50944486e-02f, -2.22233981e-02f, -2.08598915e-02f, -4.68268767e-02f, -6.77344501e-02f, 2.82811433e-01f, 2.59736896e-01f, 1.62189394e-01f,
  3.24939191e-01f, 1.58120856e-01f, -3.52206767e-01f, 2.05957711e-01f, 3.08077261e-02f, 2.12718800e-01f, -1.14815660e-01f, -6.38020396e-01f, -4.62804399e-02f, 1.08969420e-01f,
  -7.14077279e-02f, 4.30462621e-02f, 1.50965095e-01f, 1.27768174e-01f, 2.52187520e-01f, 6.64904654e-01f, -6.50115907e-02f, -3.71158242e-01f, 1.75051063e-01f, 5.22085786e-01f,
  4.97621924e-01f, -1.71024606e-01f, 2.22436011e-01f, -2.11859629e-01f, -1.40197754e-01f, -4.48993653e-01f, -1.59123167e-01f, -7.02561677e-01f, -1.93677008e-01f, 9.79981422e-02f,
  -3.63748282e-01f, -4.50026006e-01f, 4.61358696e-01f, -3.37084323e-01f, -4.08087283e-01f, -2.64508396e-01f, -1.72174528e-01f, -3.41856092e-01f, 3.82031083e-01f, 2.77890921e-01f,
  5.87652802e-01f, 6.87984228e-02f, 4.57352042e-01f, -9.21316072e-02f, 9.33392048e-02f, -2.93126106e-01f, -7.20248282e-01f, 3.69968712e-02f, 1.93263462e-03f, 8.26500356e-02f,
  1.85328111e-01f, -4.17571485e-01f, -2.04540372e-01f, -1.49326503e-01f, -4.14944053e-01f, 5.17936170e-01f, -4.71161194e-02f, 1.11711949e-01f, -9.77545902e-02f, 4.62053418e-01f,
  2.69678216e-02f, -2.32127815e-01f, 7.76440874e-02f, 1.79442763e-01f, -6.13273047e-02f, 2.79159069e-01f, -1.42065540e-01f, -5.55026352e-01f, -5.86738467e-01f, -4.84179705e-01f,
  -2.15362459e-01f, -1.88260987e-01f, -5.62473796e-02f, 4.25320230e-02f, -1.62395358e-01f, 4.45966087e-02f, -1.18336916e-01f, 8.14303607e-02f, -4.45375115e-01f, -1.89922616e-01f,
  6.20927699e-02f, -4.71140668e-02f, 1.18383147e-01f, -3.89451146e-01f, 6.73933387e-01f, 5.53966351e-02f, 2.74074543e-02f, -5.48985451e-02f, -3.98117770e-03f, 2.21260250e-01f,
  2.66503841e-01f, 2.66323179e-01f, 6.14629760e-02f, 1.61839142e-01f, 3.80482733e-01f, -4.78293061e-01f, -4.03410167e-01f, -1.69359758e-01f, -9.05599594e-02f, 1.30441174e-01f,
  5.46306632e-02f, 3.69780779e-01f, 1.57626227e-01f, 5.63547611e-02f, -2.52409339e-01f, -7.53002763e-02f, 7.41333440e-02f, 3.90519612e-02f, -1.04468232e-02f, 6.39254689e-01f,
  7.17537522e-01f, 3.76397115e-03f, 1.46725431e-01f, -2.08977908e-02f, 7.97816813e-02f, 4.81901318e-01f, -4.68980163e-01f, -9.89216566e-02f, -4.75034565e-01f, 2.70627230e-01f,
  6.78603277e-02f, -6.83163762e-01f, -2.55428404e-01f, -6.62618637e-01f, 3.23998094e-01f, 9.93323550e-02f, -4.60305363e-01f, 1.41248450e-01f, 3.30260068e-01f, -1.80024952e-02f,
  3.27734798e-01f, 3.88110839e-02f, 2.60531932e-01f, 3.21259588e-01f, -5.31580269e-01f, -4.72271860e-01f, -6.53657913e-02f, 6.31719306e-02f, -1.57754254e-02f, 1.62503839e-01f,
  -4.16876525e-02f, -4.54412490e-01f, -5.82103431e-01f, -2.58342892e-01f, -5.48980907e-02f, 5.47254691e-03f, -2.49397278e-01f, -5.69277108e-01f, 1.98539451e-01f, -3.41595188e-02f,
  5.84422946e-01f, -2.43595496e-01f, 1.46855101e-01f, 6.22979879e-01f, -1.32578194e-01f, 6.44735768e-02f, -1.71516445e-02f, -1.12625465e-01f, 3.19403768e-01f, 1.37889206e-01f,
  1.50093168e-01f, -2.17980757e-01f, -7.36382511e-03f, 1.90228999e-01f, 2.47068748e-01f, 2.72400618e-01f, -1.50483295e-01f, 1.85706586e-01f, -2.79106200e-01f, 9.62923095e-03f,
  -1.68619052e-01f, -1.46429062e-01f, -1.22140110e-01f, -7.10744917e-01f, 1.17287673e-01f, 2.33428523e-01f, 7.61253834e-02f, -3.19645494e-01f, -2.17646390e-01f, 2.43198991e-01f,
  5.04490972e-01f, -1.84307814e-01f, 8.82690012e-01f, -1.27766490e-01f, 1.02418065e-01f, 1.20745720e-02f, -2.74646193e-01f, -5.29928468e-02f, 1.35465935e-01f, 4.69663411e-01f,
  -4.06564176e-01f, 9.96864215e-03f, 5.51196001e-02f, -2.59849250e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.72250660e-02f, 2.83580661e-01f, -2.90114939e-01f, -1.56397164e-01f, -1.16441824e-01f, 3.50670844e-01f, -1.85084313e-01f, -2.28484930e-03f, -2.34538138e-01f, 1.89067259e-01f,
  1.87250704e-01f, -7.72368833e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    