/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.87865299e-01f, -1.50082484e-01f, 2.98494343e-02f, -2.44206741e-01f, -1.63825274e-01f, 2.12455960e-03f, -1.96332820e-02f, -1.63560808e-01f, -1.94352686e-01f, 3.62808467e-03f,
  8.04713592e-02f, -2.46512428e-01f, 3.44952762e-01f, -5.80722317e-02f, -3.08132470e-02f, 3.83376777e-01f, -2.17387587e-01f, -1.84281319e-02f, -1.89313560e-03f, -3.15420926e-01f,
  -6.93044588e-02f, -1.21270120e-01f, 4.26689535e-02f, -8.79177228e-02f, -1.80844918e-01f, -1.18807897e-01f, -5.42858690e-02f, 7.11865500e-02f, -5.43701127e-02f, 9.49166045e-02f,
  -5.78821599e-02f, -2.10553128e-02f, 1.45320501e-02f, 4.61980179e-02f, -9.87812802e-02f, 2.39586327e-02f, -4.16086800e-02f, 1.06179073e-01f, 5.94902225e-02f, 1.45147629e-02f,
  2.03463547e-02f, -2.85008848e-02f, -2.90795770e-02f, 8.78968313e-02f, -7.65028670e-02f, 5.94031718e-03f, 3.49295028e-02f, 2.07043346e-02f, -1.23088108e-02f, 2.09929440e-02f,
  5.08992709e-02f, 1.22877464e-01f, -3.85429710e-02f, 5.85875213e-02f, -1.10183773e-03f, 3.58848833e-02f, -2.42532156e-02f, 4.55400199e-02f, -6.99106371e-03f, -1.54338554e-01f,
  7.59241283e-02f, -5.61960079e-02f, 2.56598722e-02f, 4.69134450e-02f, 2.27825511e-02f, 2.04201937e-02f, -1.14484672e-02f, 1.24189472e-02f, -8.60879645e-02f, -2.34725159e-02f,
  -6.99438602e-02f, -2.77024060e-02f, -1.54561326e-02f, 1.24272732e-02f, -5.75090088e-02f, -2.95641609e-02f, 7.22991349e-03f, 3.73055488e-02f, -6.01902120e-02f, 4.72167656e-02f,
  2.95018498e-02f, -3.68396789e-02f, -8.92022997e-03f, 3.02613489e-02f, 3.57607752e-02f, 2.32857801e-02f, -5.11363987e-03f, -6.74604625e-03f, 3.38104293e-02f, -3.53648551e-02f,
  -2.38406688e-01f, -2.43224606e-01f, 1.47029767e-02f, -1.89697277e-02f, -1.57077517e-02f, -4.39507328e-02f, -4.46486622e-02f, -3.10656019e-02f, -1.63026322e-02f, -1.28717031e-02f,
  -1.03339870e-02f, -1.33791678e-02f, -7.62932077e-02f, -1.19539797e-02f, -1.52875185e-02f, -2.55219974e-02f, 1.45266866e-02f, -3.51165496e-02f, -8.71394128e-02f, -1.06026813e-01f,
  -6.41354769e-02f, -3.47571298e-02f, 1.55330589e-02f, -6.98185936e-02f, -6.31391723e-03f, -5.90692721e-02f, -6.57942742e-02f, -1.55405402e-02f, 8.32242444e-02f, -4.49450128e-02f,
  3.47891629e-01f, -6.78224638e-02f, 3.52335840e-01f, 2.12414369e-01f, -1.16077073e-01f, 3.46397698e-01f, 9.48616713e-02f, 2.00983267e-02f, 1.10248603e-01f, -3.04273546e-01f,
  -2.06042707e-01f, 8.37893263e-02f, -2.73539692e-01f, -4.97241784e-03f, 2.32062981e-01f, -1.02924712e-01f, 3.13627273e-01f, 4.83971573e-02f, -4.16992605e-02f, 1.02533840e-01f,
  9.80555043e-02f, -2.77217925e-01f, 8.77415985e-02f, -8.00321251e-03f, 9.28146020e-03f, 2.17637137e-01f, -2.23219216e-01f, 5.79418056e-03f, -3.55165191e-02f, -2.97808573e-02f,
  6.50369981e-03f, -1.50433570e-01f, -5.04502244e-02f, 4.19238433e-02f, 6.93374425e-02f, -2.00398196e-03f, 9.83061045e-02f, -3.52005176e-02f, 5.78747727e-02f, 1.93052348e-02f,
  4.79731746e-02f, 1.02215428e-02f, 3.25337909e-02f, -2.76589282e-02f, -1.21004013e-02f, 1.20107019e-02f, -2.84628514e-02f, 3.36463638e-02f, -5.93065098e-02f, 3.33177410e-02f,
  -1.32097518e-02f, 2.74162013e-02f, 1.04094930e-01f, -1.30640129e-02f, 4.55741100e-02f, 3.59567702e-02f, 5.20776026e-02f, 7.39609674e-02f, 5.06918244e-02f, 9.23560280e-03f,
  -6.84472024e-02f, -3.70982960e-02f, -2.76284311e-02f, -1.09582022e-02f, 2.47033741e-02f, -5.92649542e-02f, -4.44482379e-02f, -1.19557446e-02f, 1.08021557e-01f, 4.01617475e-02f,
  1.45203890e-02f, 2.26828828e-02f, -7.48445317e-02f, 1.51128294e-02f, -1.94320399e-02f, -1.09183099e-02f, 7.82921836e-02f, 9.63794254e-03f, 1.62686687e-02f, -2.45245975e-02f,
  -6.10285327e-02f, 6.61784410e-02f, -1.36283888e-02f, -4.95546460e-02f, 7.07189040e-03f, -2.16669100e-03f, -6.17903732e-02f, 5.87317087e-02f, 2.51917858e-02f, 3.86919752e-02f,
  9.50756595e-02f, -6.35683089e-02f, 7.77046243e-03f, -1.86921936e-02f, -1.49603682e-02f, 7.88864971e-04f, -2.47042570e-02f, 3.86855379e-02f, -1.81273986e-02f, -4.96243313e-02f,
  6.56242222e-02f, -3.36571634e-02f, 5.43653294e-02f, 4.20749001e-03f, 5.50320279e-03f, -4.87972572e-02f, 9.95725486e-03f, -4.05236781e-02f, 3.93398069e-02f, -1.36748701e-02f,
  -2.46723481e-02f, 7.39974715e-03f, 1.85754355e-02f, 7.60133099e-03f, -4.61800257e-03f, -1.60208046e-02f, 1.18434429e-01f, -2.65413988e-02f, -2.52708700e-02f, 1.68487243e-03f,
  3.40680391e-01f, -5.52712083e-01f, 1.64987072e-01f, -2.44914845e-01f, -8.41474719e-03f, 1.81603566e-01f, -7.75348395e-02f, -7.54998177e-02f, -1.74286403e-02f, -3.44179243e-01f,
  -1.30597025e-01f, -1.19891455e-02f, -1.75194696e-01f, -4.10332024e-01f, 3.80118340e-01f, -1.63463116e-01f, -2.93071531e-02f, -5.73754422e-02f, -1.21412019e-03f, -1.19298205e-01f,
  7.88797289e-02f, -2.50803709e-01f, -1.11992978e-01f, -1.07380398e-01f, -1.22973979e-01f, 1.31417453e-01f, 1.67864561e-02f, 9.51362401e-02f, -1.45653978e-01f, 6.44997060e-02f,
  -1.36733904e-01f, -2.41957724e-01f, -3.34190801e-02f, 5.21439388e-02f, 6.97195902e-02f, 2.42515728e-02f, 6.09096512e-02f, 4.52538058e-02f, 4.49094847e-02f, -4.22255769e-02f,
  6.58187792e-02f, 2.28272509e-02f, -8.11971501e-02f, -6.71922835e-03f, 1.39588742e-02f, -1.85718597e-03f, -1.74978301e-02f, 2.64964328e-04f, -9.90325436e-02f, -1.83149781e-02f,
  5.55896549e-04f, -1.32308863e-02f, 2.24142019e-02f, -2.36697793e-02f, 5.41705936e-02f, 5.58995735e-03f, 3.02177835e-02f, 8.03178921e-02f, 5.50090745e-02f, 3.64427678e-02f,
  6.56371564e-02f, 1.48533871e-02f, -1.58029888e-02f, -1.41229136e-02f, -7.37788007e-02f, -6.34760968e-03f, -4.75120507e-02f, -1.54839261e-02f, 1.15431570e-01f, -2.19212789e-02f,
  2.90061273e-02f, -3.26779895e-02f, -1.64520107e-02f, -1.44636994e-02f, 2.64384206e-02f, -4.16475870e-02f, 3.54319438e-02f, 1.09193753e-03f, 6.15392486e-03f, 1.34104025e-02f,
  -5.19115366e-02f, 4.89490852e-03f, -5.53556979e-02f, 6.87066140e-03f, -4.03089151e-02f, 2.11388208e-02f, -1.34918178e-02f, -4.33468930e-02f, 8.54780804e-03f, 6.07833154e-02f,
  -9.19580273e-03f, 7.52646253e-02f, -1.49580725e-02f, -5.83608337e-02f, -3.54095846e-02f, 3.35252564e-03f, 7.34434696e-03f, 3.19575369e-02f, -3.48542072e-02f, 8.17333290e-04f,
  5.22291362e-02f, -4.39092405e-02f, 1.14461899e-01f, 7.08599202e-03f, 2.07520742e-02f, -2.22121901e-03f, 1.94850713e-02f, -1.52705451e-02f, 9.48965698e-02f, -1.23730823e-02f,
  -2.41522491e-02f, 2.55204411e-03f, -3.80798392e-02f, -1.27193052e-02f, -2.35680547e-02f, -1.68231297e-02f, 4.36699465e-02f, -3.88640054e-02f, -2.76334886e-03f, -1.12790139e-02f,
  -4.69891220e-01f, 3.38879466e-01f, 1.40741274e-01f, -5.94052896e-02f, -6.66814148e-02f, -4.01270866e-01f, -2.61393845e-01f, 1.54184982e-01f, -9.59836468e-02f, 2.57466584e-01f,
  -1.20104872e-01f, 9.37395841e-02f, 3.71854715e-02f, -4.53365035e-02f, -4.59059745e-01f, -6.30881190e-02f, -1.65529579e-01f, -9.21400860e-02f, -3.82736027e-02f, -3.91881494e-03f,
  -9.01871622e-02f, -1.07517302e-01f, 5.55053763e-02f, 2.44809702e-01f, 4.85837087e-03f, 2.26021037e-01f, 6.07137457e-02f, 1.42805532e-01f, 2.59624179e-02f, -8.67892206e-02f,
  -5.96756861e-02f, 2.55832449e-02f, 6.90444633e-02f, 1.42400898e-02f, -7.29136392e-02f, -1.25773642e-02f, -2.42769569e-02f, 6.56035205e-04f, -3.96398902e-02f, 8.53085238e-03f,
  -4.57705334e-02f, -3.97982076e-02f, 2.53279507e-03f, 1.47618994e-03f, -1.77085977e-02f, 6.03317358e-02f, -7.88990594e-03f, -3.56624722e-02f, 2.14697104e-02f, -2.35682763e-02f,
  -6.89956034e-03f, -5.54806292e-02f, -4.97571714e-02f, -3.75110321e-02f, 1.95441265e-02f, -6.01373799e-03f, 1.45842498e-02f, -7.65745249e-03f, -2.46932786e-02f, -3.44009250e-02f,
  5.94802340e-03f, 2.72983704e-02f, 6.66927770e-02f, 9.70837921e-02f, -2.75022369e-02f, 6.96866289e-02f, 3.06339152e-02f, -4.64071035e-02f, 3.70309316e-02f, 2.18061749e-02f,
  -3.63768898e-02f, 2.06953660e-02f, 1.92550868e-02f, 2.45379675e-02f, 4.56890790e-03f, 4.41776626e-02f, -1.67763159e-02f, 2.71502417e-02f, -3.87620479e-02f, -1.34299118e-02f,
  3.16464305e-02f, -2.16577053e-02f, 3.42087224e-02f, -2.36113388e-02f, 1.72782894e-02f, 3.62508595e-02f, -2.92843586e-04f, 3.77551280e-02f, 4.57546115e-02f, -9.11381841e-02f,
  -8.91498998e-02f, 1.51065484e-01f, 8.74232501e-02f, -6.05135132e-03f, 7.89929777e-02f, 8.70094225e-02f, 1.09683834e-02f, 2.07963027e-03f, 3.73687558e-02f, -3.60022634e-02f,
  3.15040983e-02f, 1.97287202e-02f, 1.07375262e-02f, 6.07411424e-03f, -6.74022660e-02f, -4.15024012e-02f, -4.16453043e-03f, 4.14298438e-02f, -2.00026147e-02f, 1.92058869e-02f,
  3.48761640e-02f, -6.76227221e-03f, 1.40470294e-02f, -8.88769515e-03f, -1.88129880e-02f, -1.95826683e-02f, -4.61763330e-03f, 3.82935554e-02f, 1.73729134e-03f, 4.88546714e-02f,
  5.33768311e-02f, 8.90543833e-02f, -1.23258285e-01f, 5.40170260e-02f, 2.79516242e-02f, -1.42173439e-01f, -2.34008327e-01f, 5.80914430e-02f, -1.66414171e-01f, 4.67432849e-02f,
  -3.00157499e-02f, 2.25387350e-01f, -2.75688291e-01f, 1.20940708e-01f, -7.52686411e-02f, -3.16425741e-01f, 9.27225873e-02f, 5.19319288e-02f, -5.80891967e-02f, 1.85003772e-01f,
  -9.84703191e-03f, 2.37227395e-01f, -1.79206073e-01f, 1.09273031e-01f, 1.48139834e-01f, 8.52697715e-02f, 2.31986985e-01f, -2.75617912e-02f, 2.98774242e-01f, 1.69549976e-02f,
  -3.51453163e-02f, -4.66261096e-02f, -4.32900265e-02f, -2.97722444e-02f, 8.71608257e-02f, -5.14286049e-02f, 2.96430998e-02f, -8.63668621e-02f, -1.02732275e-02f, -4.04995866e-02f,
  3.64772673e-03f, 4.25023735e-02f, 9.85020474e-02f, -3.76198366e-02f, -1.82634387e-02f, -3.78610604e-02f, 1.33002838e-02f, -3.43394764e-02f, -2.01790985e-02f, -1.06812365e-01f,
  -5.18978611e-02f, -6.85159788e-02f, -2.93698832e-02f, 3.41246054e-02f, -3.41483727e-02f, -7.30738267e-02f, -5.62624000e-02f, -3.73226367e-02f, 1.20302113e-02f, 4.20498885e-02f,
  -5.64215183e-02f, -5.69385942e-03f, -1.52183538e-02f, 1.09844673e-02f, 3.56836468e-02f, 2.21755467e-02f, 2.50816103e-02f, 4.62843366e-02f, 5.13410792e-02f, -2.89757666e-03f,
  7.80312121e-02f, -3.90611310e-03f, 3.61558646e-02f, -9.17781591e-02f, 6.56025764e-03f, -1.19192749e-02f, -1.22960343e-03f, 6.99840039e-02f, 5.77522479e-02f, -4.04503979e-02f,
  -3.39301191e-02f, -4.22086790e-02f, 5.36520481e-02f, -4.57715355e-02f, -6.05801046e-02f, 9.83148441e-03f, 2.59982515e-02f, -9.99533106e-03f, -4.47369516e-02f, 7.56516075e-03f,
  2.87757099e-01f, 2.42224604e-01f, -4.20659687e-03f, 5.89289293e-02f, 4.40920182e-02f, 3.00387572e-02f, -1.94825069e-03f, -3.90097871e-02f, 5.32949455e-02f, 1.48311304e-02f,
  -9.76455137e-02f, 4.43255417e-02f, 1.01357214e-01f, -8.13765377e-02f, 3.13550048e-02f, -1.70316175e-02f, 7.97008425e-02f, 4.03208435e-02f, 6.15838654e-02f, 1.57525197e-01f,
  2.28013508e-02f, 5.90353981e-02f, -5.27138524e-02f, -3.60798351e-02f, -3.78608368e-02f, 3.92142124e-02f, 8.79152343e-02f, -4.96199988e-02f, 2.15529297e-02f, -3.32452878e-02f,
  2.54770011e-01f, 3.34089011e-01f, -2.33061656e-01f, 9.33383256e-02f, 1.69122279e-01f, -2.97941297e-01f, -1.20392665e-01f, 1.28048241e-01f, -1.11373169e-02f, 6.11950532e-02f,
  1.97250739e-01f, 1.08062230e-01f, 7.79193789e-02f, 2.03924835e-01f, -2.07234234e-01f, -1.23648450e-01f, -4.41349670e-02f, -1.44968331e-01f, -5.30789047e-03f, 1.35287911e-01f,
  1.74322143e-01f, 2.05121219e-01f, 4.46334528e-03f, 1.33346796e-01f, 1.21072635e-01f, 1.09678216e-01f, 9.15965736e-02f, -9.45895463e-02f, -1.71449948e-02f, -8.22541267e-02f,
  6.19102120e-02f, 2.04038724e-01f, 2.09093571e-01f, -6.31831586e-02f, -2.13327985e-02f, -3.74963209e-02f, -1.03696674e-01f, -1.45111054e-01f, -7.68160522e-02f, -4.55682017e-02f,
  6.56883940e-02f, -4.69785109e-02f, 4.91325259e-02f, -4.63069305e-02f, 2.37334538e-02f, 2.90440135e-02f, 2.62715798e-02f, -6.23930879e-02f, 7.78707713e-02f, -5.10295704e-02f,
  1.56752124e-01f, -3.11764218e-02f, 9.59437992e-03f, -1.12368828e-02f, 8.51917788e-02f, -3.25363353e-02f, -1.09262846e-01f, -7.71358013e-02f, -3.25785466e-02f, 1.30691491e-02f,
  -7.34433681e-02f, -3.15049812e-02f, 7.11079091e-02f, -1.23278201e-02f, 1.01815775e-01f, 1.35665476e-01f, -4.61735122e-04f, -1.97144151e-02f, -3.77676971e-02f, 6.56274557e-02f,
  -3.36664319e-02f, 6.00762777e-02f, 2.62050945e-02f, -8.52901489e-02f, 3.36357541e-02f, 4.40250859e-02f, -9.68706794e-03f, -8.22070315e-02f, -4.32225615e-02f, -5.23385219e-02f,
  2.78648827e-02f, -1.36148827e-02f, 1.98244136e-02f, -8.34069327e-02f, 2.77293399e-02f, 2.45892573e-02f, -4.28445498e-03f, -2.53439695e-02f, 2.16974672e-02f, -5.08404570e-03f,
  2.42915936e-02f, 4.18511108e-02f, 1.11374520e-01f, 1.26561746e-01f, 3.69288251e-02f, 3.67087461e-02f, -6.91970065e-02f, 1.66244134e-02f, -9.69263818e-03f, -1.45673938e-02f,
  -1.16594965e-02f, 3.52550559e-02f, -3.07730269e-02f, -2.86075585e-02f, -6.37768582e-02f, -3.51581238e-02f, 4.02613282e-02f, 2.91232280e-02f, 7.51359165e-02f, -4.80169291e-03f,
  1.12779193e-01f, -5.91202900e-02f, 8.75935331e-03f, 7.71961957e-02f, 2.37487024e-03f, 6.42938688e-02f, 3.22098695e-02f, -8.17246065e-02f, -9.00166258e-02f, -2.62706634e-02f,
  -1.36750311e-01f, 3.88772897e-02f, 1.96874127e-01f, -2.72602618e-01f, 5.31534329e-02f, -1.38147816e-01f, -5.47092184e-02f, -3.05590034e-02f, -3.16679865e-01f, -1.22038096e-01f,
  -3.41252908e-02f, 6.91523254e-02f, 2.35606909e-01f, -3.30789655e-01f, 1.48732170e-01f, -1.01043750e-02f, -2.93360651e-01f, -1.67972937e-01f, 1.76145975e-03f, 4.18249629e-02f,
  2.25201063e-03f, -2.30941713e-01f, 1.24982618e-01f, -5.53883575e-02f, -1.35815725e-01f, 2.95471051e-03f, 1.75168097e-01f, 1.32420734e-01f, -1.37091279e-01f, 2.65209880e-02f,
  -9.62444693e-02f, -1.41075164e-01f, -3.78388241e-02f, -8.73021632e-02f, 1.64184105e-02f, -7.40855858e-02f, 7.20723197e-02f, 7.63557926e-02f, -2.86456030e-02f, -3.32271643e-02f,
  2.82286536e-02f, 3.50917247e-03f, -6.13606982e-02f, 1.63721517e-02f, -1.45878077e-01f, -6.05087876e-02f, 1.28259407e-02f, 2.10523084e-02f, -7.51614049e-02f, -2.84881610e-03f,
  7.39263818e-02f, -5.49319051e-02f, -9.54146497e-03f, -3.16012539e-02f, 7.87675157e-02f, -3.28486599e-03f, 1.36153307e-02f, 1.57539830e-01f, -7.53781646e-02f, -6.15298040e-02f,
  5.82640816e-04f, -3.94254029e-02f, 2.97456570e-02f, -7.37264380e-02f, -1.00793958e-01f, 2.06965338e-02f, -7.41590932e-02f, -1.56188225e-02f, 6.45939931e-02f, 9.31664929e-03f,
  -2.72718724e-02f, 3.81081030e-02f, -1.36781052e-01f, -4.07290831e-02f, -4.40450385e-03f, -9.02790204e-02f, 1.62238907e-02f, 4.61590998e-02f, -9.94863827e-03f, -2.91745290e-02f,
  -1.78849995e-02f, -5.78496745e-03f, -3.87400831e-03f, -3.56896669e-02f, -9.87280905e-02f, 1.22480169e-01f, -6.77052978e-03f, 3.46185602e-02f, 6.25498360e-03f, -1.33201554e-02f,
  8.24653208e-02f, 1.76245391e-01f, -4.71537784e-02f, -5.11453077e-02f, -2.74059251e-02f, -2.40144618e-02f, -9.13538560e-02f, 1.30962729e-02f, 8.18268880e-02f, -3.13961953e-02f,
  6.56640232e-02f, -2.85205012e-03f, -4.18151869e-03f, -6.82187602e-02f, 1.27608767e-02f, 8.26842189e-02f, 6.58480972e-02f, 1.25120496e-02f, -3.73614393e-02f, 3.09106223e-02f,
  -1.01675792e-02f, -2.09391806e-02f, -3.84224812e-03f, -6.27389774e-02f, 4.43835789e-03f, 8.22112560e-02f, 2.24024002e-02f, 3.90466372e-03f, -1.62807945e-02f, -5.52594569e-03f,
  6.88055158e-02f, 2.07641482e-01f, 1.47655830e-01f, -2.98563570e-01f, 4.41720635e-02f, 4.92179766e-02f, -1.50180146e-01f, 3.16119455e-02f, 1.11505641e-02f, -7.10754022e-02f,
  -3.78187299e-01f, 1.18867874e-01f, 5.88030438e-04f, -3.86139840e-01f, -3.16358626e-01f, -1.89092681e-01f, -2.86276698e-01f, -7.32785836e-02f, 1.78655595e-01f, -7.62970224e-02f,
  4.82407920e-02f, -3.94144624e-01f, 3.59484833e-03f, 2.50697345e-01f, 9.87866952e-06f, 2.49162272e-01f, -1.14061758e-01f, 7.13935196e-02f, -7.33596683e-02f, 3.33974557e-03f,
  9.13039520e-02f, -1.85948253e-01f, 9.87731591e-02f, -2.12553218e-02f, -9.74633768e-02f, 1.57452915e-02f, 6.33227602e-02f, 8.95081647e-03f, 4.64791106e-03f, 3.74469943e-02f,
  -1.56749617e-02f, -3.15673985e-02f, -4.69133863e-03f, -5.20791039e-02f, 1.28835021e-02f, 1.34178614e-02f, 9.45009384e-03f, 8.62323791e-02f, 5.91587275e-02f, 9.28077661e-03f,
  -1.78443771e-02f, 4.09000218e-02f, -4.43765521e-02f, -2.24486124e-02f, 2.42305007e-02f, -1.10839799e-01f, 3.31019005e-03f, 4.15925160e-02f, 1.14826486e-02f, 6.83509186e-02f,
  -9.33784805e-03f, -4.84555699e-02f, -3.32090259e-02f, 9.90947261e-02f, -1.18458450e-01f, 1.36500135e-01f, -5.64982630e-02f, 7.04003945e-02f, 3.73432375e-02f, 3.76349650e-02f,
  4.22690548e-02f, 8.70514603e-04f, -2.11146642e-02f, -4.65584621e-02f, -7.56600946e-02f, 6.32662848e-02f, 1.90837812e-02f, -2.54916549e-02f, -1.69346407e-02f, 8.14364031e-02f,
  -5.93123250e-02f, -4.43604589e-02f, 6.93172812e-02f, 3.17058787e-02f, -6.69386014e-02f, -4.08249348e-02f, -4.34727482e-02f, -2.68250629e-02f, -9.01853759e-03f, -5.62521219e-02f,
  -1.46244049e-01f, -2.02902600e-01f, -3.71408835e-02f, 3.57825011e-02f, -3.25883701e-02f, -9.76694096e-03f, -7.79893249e-02f, 1.48093611e-01f, -2.28468198e-02f, 6.05318090e-03f,
  -2.81106099e-03f, 4.07577455e-02f, 2.35868664e-03f, -6.09455779e-02f, -7.00298026e-02f, -2.91076060e-02f, 1.55944889e-03f, 4.53787260e-02f, -4.98199761e-02f, 3.91500890e-02f,
  -4.39892570e-03f, -3.27814072e-02f, -1.87531710e-02f, 3.68409865e-02f, 6.34613112e-02f, 5.43510951e-02f, -6.91470550e-03f, 4.26047184e-02f, -5.87639771e-02f, -1.51881408e-02f,
  -4.50054526e-01f, 3.60848196e-02f, -1.91015095e-01f, 1.59550339e-01f, 7.00202212e-02f, 3.90315801e-02f, -9.36412662e-02f, 3.04527618e-02f, 9.79827791e-02f, -1.03906943e-02f,
  -9.76496655e-03f, -1.25841424e-01f, -1.86931506e-01f, 2.73736000e-01f, -6.16404936e-02f, 2.75019500e-02f, 1.57906607e-01f, -7.12109357e-02f, 1.75911963e-01f, -6.91416040e-02f,
  -4.21677306e-02f, 1.64018422e-01f, -1.00511640e-01f, 1.38869748e-01f, -1.24924302e-01f, 4.37341537e-03f, -1.52594253e-01f, -2.18648966e-02f, 7.96461757e-03f, 6.27312735e-02f,
  -3.44517455e-02f, -2.46608872e-02f, -6.98802844e-02f, -3.33996005e-02f, -1.19067162e-01f, -1.03106461e-01f, -1.06800437e-01f, 2.75477823e-02f, 3.57443690e-02f, 3.68700959e-02f,
  -3.01506855e-02f, 5.66421496e-03f, 1.08337007e-01f, 8.23221281e-02f, -4.78678197e-02f, -5.40967509e-02f, 8.15181136e-02f, -1.53733408e-02f, 6.50213845e-03f, 4.06119451e-02f,
  -6.44771680e-02f, 4.01452407e-02f, -8.33629817e-02f, 6.81195557e-02f, -4.33057956e-02f, 1.02379344e-01f, 6.37311786e-02f, -8.56203437e-02f, -7.33971372e-02f, 3.25129852e-02f,
  -3.39538939e-02f, -3.35038453e-02f, -1.18546700e-02f, -7.03355819e-02f, -3.73798818e-03f, -2.65580937e-02f, -5.31940274e-02f, -7.67283433e-04f, -6.18724041e-02f, -3.14910407e-03f,
  4.64288853e-02f, 1.88243315e-02f, 3.35301086e-02f, -2.28470843e-02f, 2.05942187e-02f, -3.02005075e-02f, -5.81673086e-02f, 1.36758829e-03f, 1.82071384e-02f, 5.29805794e-02f,
  4.37148474e-03f, -3.52517609e-03f, -4.13729362e-02f, -9.93680116e-03f, 2.94155884e-03f, -4.25688364e-02f, 5.40724257e-04f, 1.21931336e-03f, 6.11088797e-03f, -1.65941287e-02f,
  -1.53661400e-01f, -2.10278809e-01f, 3.41360122e-02f, -5.75248338e-02f, 4.48969863e-02f, 2.40371432e-02f, 7.80730322e-02f, 4.52727675e-02f, -3.07102278e-02f, -4.46696281e-02f,
  -5.85954217e-03f, -1.08979410e-02f, -8.45978111e-02f, -1.58378594e-02f, 6.16885722e-03f, -5.55467755e-02f, -4.34434786e-02f, -1.53916022e-02f, -1.39755085e-01f, -3.10547426e-02f,
  -8.31420869e-02f, -1.02080859e-01f, 7.19488114e-02f, 4.41740975e-02f, -2.40399763e-02f, -1.86337195e-02f, -9.55274850e-02f, 1.01641417e-01f, -8.86281487e-03f, -2.39713788e-02f,
  -2.23168969e-01f, 3.41059983e-01f, -2.01842889e-01f, -4.90875132e-02f, -1.50321066e-01f, -1.22354709e-01f, -1.69034258e-01f, 2.51703220e-03f, 1.53719515e-01f, 3.09190333e-01f,
  -7.52427652e-02f, 1.88002270e-02f, 4.27146964e-02f, 1.53816074e-01f, -2.74299145e-01f, 1.82172015e-01f, 1.21577434e-01f, 1.37838855e-01f, 1.02288276e-01f, -8.01616088e-02f,
  -1.09328426e-01f, 8.99105445e-02f, -2.78789759e-01f, 9.07321647e-02f, -1.00063995e-01f, -7.13928044e-02f, -7.11078048e-02f, -1.01981007e-01f, -1.02064580e-01f, -3.59250233e-02f,
  4.37448025e-02f, 1.33033007e-01f, -7.88421428e-04f, 2.70431992e-02f, -2.95440741e-02f, -3.91627848e-02f, -3.29577364e-02f, -5.93619160e-02f, -8.96245539e-02f, 3.14834975e-02f,
  5.49751855e-02f, 1.00460052e-02f, 7.31509477e-02f, -3.62741994e-03f, -1.83133502e-02f, -2.01908257e-02f, -1.69640444e-02f, -4.22120541e-02f, 1.31680015e-02f, -4.74158488e-02f,
  -1.04787201e-01f, -4.68052886e-02f, -1.97127145e-02f, 8.08758363e-02f, -5.45670688e-02f, -1.75156984e-02f, -6.17684573e-02f, -1.07173577e-01f, 1.02007449e-01f, -2.19648145e-02f,
  9.76184160e-02f, 3.31905521e-02f, -5.72973676e-02f, 2.76129786e-02f, -7.81047419e-02f, -1.36891629e-06f, 1.10893458e-01f, 2.19321474e-02f, -5.48938811e-02f, -3.49343661e-03f,
  -7.57368207e-02f, 2.31284718e-03f, 7.95674399e-02f, -4.36845459e-02f, -6.33683875e-02f, 5.74548822e-03f, -4.20789383e-02f, -9.08475835e-03f, -2.60059126e-02f, -7.55767226e-02f,
  7.89481401e-02f, -1.13758715e-02f, -1.62645541e-02f, 6.43237010e-02f, 6.64813295e-02f, -4.67954613e-02f, 6.88331947e-02f, -6.78560361e-02f, -4.05692793e-02f, -7.00774267e-02f,
  2.51458343e-02f, 1.47767469e-01f, 3.32617983e-02f, 2.87711434e-02f, 9.47260782e-02f, 3.33972126e-02f, 8.52192044e-02f, 1.68544147e-02f, -6.27381867e-03f, 5.27354330e-02f,
  -3.24240364e-02f, -4.55633961e-02f, 6.40419424e-02f, -9.33660474e-03f, -3.08805029e-04f, -7.58877546e-02f, 5.72802871e-02f, 5.25138900e-02f, 4.43237871e-02f, 4.51724604e-02f,
  -3.92267713e-03f, 3.11070285e-03f, -3.42393741e-02f, -2.14196127e-02f, 8.50466564e-02f, -3.61166075e-02f, -4.83915731e-02f, -7.73752108e-03f, -2.65696272e-02f, 1.19979545e-01f,
  -3.91888499e-01f, 2.26045445e-01f, 3.07103276e-01f, -2.08535325e-02f, -2.31733277e-01f, 7.09719583e-02f, 3.26672912e-01f, -1.19561665e-01f, -2.78111875e-01f, 1.52201012e-01f,
  2.78249159e-02f, 1.84537306e-01f, 1.35483310e-01f, -4.48109321e-02f, -3.42072815e-01f, -4.71654460e-02f, -1.32902890e-01f, 1.31118745e-01f, 8.43899846e-02f, 3.12912762e-02f,
  -1.74067453e-01f, -9.95959416e-02f, 2.62393169e-02f, -7.88276643e-02f, 2.82205064e-02f, 1.04669720e-01f, 8.30968376e-03f, 1.55045718e-01f, -3.65640931e-02f, 5.95404506e-02f,
  -3.33550200e-02f, -5.23492619e-02f, 1.24165051e-01f, 2.65813689e-03f, 2.34494787e-02f, 5.03404476e-02f, 1.27553731e-01f, 5.06481007e-02f, -2.25674082e-02f, -8.37650616e-03f,
  1.29976021e-02f, -1.41268685e-01f, -1.82224612e-03f, -2.61826180e-02f, -8.29424486e-02f, -1.46998456e-02f, -7.59041086e-02f, 4.22423221e-02f, 3.78011391e-02f, -9.53594968e-02f,
  3.37845497e-02f, 4.43946011e-03f, -5.40262796e-02f, 9.19921547e-02f, -5.99726476e-02f, -3.24109979e-02f, 2.07480974e-02f, 4.25983407e-03f, -4.86694984e-02f, -7.75045604e-02f,
  -1.50616795e-01f, 3.38424332e-02f, -6.87257759e-03f, 1.08836815e-02f, 2.54059955e-02f, 3.43473554e-02f, -1.91663690e-02f, 4.32728231e-02f, 1.09199591e-01f, -1.93274710e-02f,
  -8.94857720e-02f, -5.39793558e-02f, -2.01340597e-02f, -2.03187335e-02f, -5.66295125e-02f, -2.64914036e-02f, 7.71380812e-02f, 4.31825221e-02f, -2.61391699e-02f, 2.77219713e-02f,
  2.73953881e-02f, -4.58851680e-02f, 4.02294695e-02f, -5.98700065e-03f, 3.21273282e-02f, -6.68281093e-02f, 1.16341457e-01f, -4.93072681e-02f, 7.83647373e-02f, 1.53335731e-03f,
  -4.65827156e-03f, 1.62403733e-02f, 8.70279688e-03f, 6.42114729e-02f, 5.74485436e-02f, -6.85193837e-02f, 1.55877648e-03f, -1.42311007e-01f, -5.42270318e-02f, -1.96022578e-02f,
  -1.66448560e-02f, 2.47702803e-02f, 1.39351999e-02f, -1.21557927e-02f, 1.14179924e-02f, 6.14830516e-02f, 3.79748596e-03f, 1.41747640e-02f, -7.34898122e-03f, 2.28740368e-02f,
  3.55456881e-02f, -1.28679452e-02f, 1.22112960e-01f, 3.32248956e-02f, -6.53166100e-02f, 9.92387161e-02f, -2.47075036e-02f, -4.97435741e-02f, 2.42577791e-02f, 1.04616000e-03f,
  6.81035146e-02f, -3.17935288e-01f, 1.56561087e-03f, 2.70539492e-01f, 2.95079023e-01f, -3.77696902e-01f, -2.28570655e-01f, 6.52944371e-02f, -1.90314591e-01f, -2.44436249e-01f,
  2.28557825e-01f, -5.47223873e-02f, -1.57627329e-01f, -4.53622974e-02f, 8.04029927e-02f, -1.70363665e-01f, -1.20582893e-01f, -8.10477436e-02f, -5.00089675e-03f, 1.10306151e-01f,
  1.59886360e-01f, 1.20047994e-01f, 1.97097063e-01f, 2.22024620e-02f, 9.93532687e-02f, 7.14230910e-02f, 1.81380719e-01f, -1.41486079e-02f, 3.28486189e-02f, 6.64328551e-03f,
  -1.09022059e-01f, 4.32119370e-02f, 4.89316471e-02f, -1.26146942e-01f, 1.42988721e-02f, -2.47232579e-02f, -3.69341932e-02f, 1.16281658e-02f, 4.70520221e-02f, 4.62270016e-03f,
  -8.62536058e-02f, 5.73222116e-02f, 5.83161712e-02f, 3.04784775e-02f, -1.96675099e-02f, -1.48618408e-02f, -3.31279030e-03f, 1.31549081e-02f, 2.48448495e-02f, 3.76315787e-02f,
  -5.43079451e-02f, -4.11288952e-03f, -2.89978040e-03f, 2.52120569e-02f, 8.19617063e-02f, 5.05806366e-03f, 3.57635245e-02f, 5.88083267e-02f, -9.67863873e-02f, 3.04426043e-03f,
  -7.55892741e-03f, 5.54765314e-02f, 1.56476423e-02f, 2.11325847e-03f, -1.14760557e-02f, 3.02714538e-02f, -7.37617686e-02f, 3.72777693e-04f, -6.39111083e-03f, -2.32083518e-02f,
  7.67027810e-02f, 5.74359260e-02f, 7.98730273e-03f, 1.89359859e-02f, 1.52983554e-02f, 2.16310956e-02f, 4.17485973e-03f, -2.35118158e-02f, 5.75670740e-04f, 1.01765618e-01f,
  -4.08781506e-02f, -7.59301111e-02f, -4.36886996e-02f, -3.63918766e-02f, -1.24986425e-01f, 3.44466083e-02f, -2.99218576e-02f, -1.41844507e-02f, 4.21130359e-02f, 1.48923472e-02f,
  -2.00617358e-01f, -6.80190995e-02f, -4.07365784e-02f, -3.61360498e-02f, -1.00912094e-01f, 1.65066647e-03f, 1.34236086e-02f, 2.86636241e-02f, -1.10113755e-01f, -5.23646809e-02f,
  7.40292743e-02f, -2.63486058e-02f, -2.19530966e-02f, -2.24811770e-02f, -3.63354273e-02f, 8.53674300e-03f, -2.31386665e-02f, -1.06406771e-02f, 1.41904764e-02f, -2.21288577e-03f,
  6.96716234e-02f, 1.31833712e-02f, 2.73915064e-02f, 6.99568866e-03f, 1.46759134e-02f, -2.44307164e-02f, 4.67427820e-02f, 2.83850320e-02f, 4.09563370e-02f, -4.38470542e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.02190268e-01f, 5.88285685e-01f, -1.88865159e-02f, 1.66996792e-01f, 8.46847892e-02f, 5.84764302e-01f, 3.23721200e-01f, 1.92092434e-01f, 3.78560692e-01f, 2.49898389e-01f,
  -8.00752044e-02f, 4.62708980e-01f, -1.75611034e-01f, 2.63732046e-01f, 1.68720130e-02f, -3.70999314e-02f, 3.17167372e-01f, 3.48923922e-01f, 7.53511488e-02f, 2.08062842e-01f,
  -1.97627023e-02f, 1.03404954e-01f, -3.20936710e-01f, -5.25708944e-02f, 1.65924191e-01f, -1.65328354e-01f, -3.77354443e-01f, -2.05206946e-01f, 1.82380639e-02f, 5.01316637e-02f,
  -1.47166131e-02f, 1.29038900e-01f, 5.30181639e-03f, -2.76800971e-02f, -5.86191751e-02f, -3.05846017e-02f, -7.92071000e-02f, -6.79402202e-02f, -1.03771321e-01f, 3.54085639e-02f,
  4.95798625e-02f, -4.15193997e-02f, 6.50036708e-02f, 7.75252581e-02f, 1.76080748e-01f, 2.45980360e-02f, 2.84222066e-02f, 2.93187555e-02f, 8.51614475e-02f, 5.22458814e-02f,
  8.79844129e-02f, -2.12222394e-02f, 2.94767022e-02f, -1.58165134e-02f, 3.54922027e-03f, 7.67354369e-02f, 7.94681311e-02f, 3.86882410e-03f, 3.42072397e-02f, 1.94333956e-01f,
  2.08668262e-02f, 5.77720962e-02f, -5.22424933e-03f, 9.06379241e-03f, 3.58555131e-02f, -9.00751874e-02f, 7.33377486e-02f, -1.04535885e-01f, 2.49627442e-03f, 6.91551790e-02f,
  -6.23257505e-03f, -9.87182488e-04f, -5.08109154e-03f, 9.42607298e-02f, 6.42441064e-02f, 7.76240751e-02f, -1.99282821e-02f, -6.57395646e-03f, 7.00394288e-02f, -3.04395682e-03f,
  -8.55374187e-02f, 4.08382863e-02f, 9.47778895e-02f, -7.86140710e-02f, 1.24233747e-02f, -2.88753100e-02f, -3.83303575e-02f, 4.83115786e-04f, -4.39781249e-02f, 1.61647517e-02f,
  2.05037475e-01f, 3.20036590e-01f, 7.74972439e-02f, -8.65675136e-03f, -4.26835157e-02f, 5.35483882e-02f, -4.60364856e-02f, 1.40283540e-01f, 5.20205386e-02f, 4.56382371e-02f,
  1.66601199e-03f, 1.67646203e-02f, -4.44499627e-02f, -2.01911423e-02f, -2.34138928e-02f, 1.41038448e-01f, -4.25851047e-02f, -3.63300405e-02f, 5.37495082e-03f, -2.51230467e-02f,
  -3.02299671e-02f, 1.17116295e-01f, -6.46352544e-02f, 7.12213367e-02f, 5.41426986e-02f, -7.79781118e-02f, 1.93465680e-01f, -8.14253241e-02f, -6.70502335e-02f, -5.82161825e-03f,
  -6.96242809e-01f, 5.16085267e-01f, 2.80792743e-01f, -5.61450362e-01f, 2.66163647e-01f, 4.53485519e-01f, -2.92453647e-01f, 3.37438226e-01f, -2.18882516e-01f, -5.26976632e-03f,
  -2.05274209e-01f, -1.27694741e-01f, 1.32160753e-01f, -1.92184433e-01f, -1.67185247e-01f, -2.65074112e-02f, -2.55275339e-01f, -3.47624421e-01f, 9.89326313e-02f, -7.72501305e-02f,
  -1.45593777e-01f, -2.40295649e-01f, -2.19756868e-02f, 3.45540613e-01f, 2.71876659e-02f, 2.40089670e-02f, -2.73542613e-01f, 2.64173150e-01f, -2.73613888e-03f, 8.85074884e-02f,
  -2.80555692e-02f, -1.89875662e-01f, 8.15614164e-02f, 7.32311457e-02f, 4.20644693e-02f, 1.99083276e-02f, -2.57320348e-02f, -2.73265187e-02f, -4.04421203e-02f, 1.08071901e-01f,
  2.81717125e-02f, 1.52608484e-01f, 5.42591279e-03f, 6.19932823e-02f, 6.61883131e-02f, 1.40634328e-01f, 1.54799432e-01f, 7.70246983e-02f, 1.02714531e-01f, 9.94060338e-02f,
  5.77352494e-02f, 9.74529460e-02f, 4.14297096e-02f, -5.70563450e-02f, 7.15010390e-02f, 3.82870249e-02f, -4.03043479e-02f, 3.13863084e-02f, 9.99579765e-03f, 4.70927693e-02f,
  -2.66664028e-02f, 1.22521315e-02f, 3.68785709e-02f, 1.33571494e-02f, -4.77134585e-02f, 8.50100890e-02f, -9.72608849e-03f, -4.71581630e-02f, 2.99856719e-02f, 3.62397581e-02f,
  -7.72450343e-02f, 5.74490335e-03f, -4.12244909e-03f, -4.32691015e-02f, -4.43353057e-02f, -1.24545000e-01f, 1.50025478e-02f, -6.25799671e-02f, -3.84244137e-02f, 1.56993456e-02f,
  -4.17656489e-02f, -3.06971259e-02f, -7.58620352e-02f, 2.20837295e-02f, 7.80076608e-02f, 1.27422099e-04f, 4.48406637e-02f, 3.24288867e-02f, 1.45719266e-02f, -6.83533028e-02f,
  -9.86409709e-02f, -2.07845286e-01f, 3.04042250e-02f, 5.36985360e-02f, 3.67965549e-02f, 3.95940058e-02f, 1.68715622e-02f, 4.21721563e-02f, 2.03360431e-02f, 3.01432852e-02f,
  2.49812864e-02f, -3.17011327e-02f, 4.86010164e-02f, 9.20870400e-04f, 4.93535167e-03f, 5.86591922e-02f, -1.02547951e-01f, -1.38655946e-01f, -3.24708708e-02f, 9.02014077e-02f,
  -7.66216731e-03f, -4.71354723e-02f, -1.62099432e-02f, 5.05619943e-02f, -9.33331028e-02f, -1.20730959e-02f, -7.94586167e-02f, -7.60528166e-03f, 2.39645187e-02f, 4.77945358e-02f,
  2.69629776e-01f, -2.81717688e-01f, -2.40973219e-01f, 2.21223027e-01f, 3.95231962e-01f, 8.36945027e-02f, 9.69936475e-02f, 1.79909363e-01f, 1.96654513e-01f, -1.17389038e-01f,
  1.79363310e-01f, -4.26435798e-01f, -3.34835142e-01f, -5.31843156e-02f, -2.45146570e-04f, -4.90324527e-01f, 2.83229381e-01f, -1.28824711e-01f, 7.19238538e-04f, 2.29925826e-01f,
  1.26182854e-01f, 1.83049038e-01f, -9.12104622e-02f, 1.77829787e-01f, 1.63142979e-01f, 1.11011550e-01f, 2.52768278e-01f, -4.11214978e-02f, 9.33497772e-02f, -3.93370166e-02f,
  -6.80498928e-02f, -3.00502777e-03f, -1.54144559e-02f, -1.46707401e-01f, 2.60646313e-01f, 1.29055917e-01f, 3.10780350e-02f, -1.39802307e-01f, -1.06349736e-02f, -1.10257573e-01f,
  -1.77503610e-03f, -1.00609258e-01f, -1.11753568e-01f, -6.85978383e-02f, 7.57972151e-02f, 5.36934584e-02f, -6.14193566e-02f, 8.77697095e-02f, -2.11716816e-03f, -1.11152433e-01f,
  5.35680503e-02f, -1.76735092e-02f, 1.59912691e-01f, -2.00938731e-02f, -7.03364005e-03f, 2.75220107e-02f, -4.05318551e-02f, 2.60220701e-03f, -3.29142958e-02f, 1.34604946e-01f,
  2.23784931e-02f, 2.51205843e-02f, -5.01917936e-02f, -6.79566488e-02f, 7.30945468e-02f, 1.06256865e-01f, -1.11221871e-03f, -2.15973966e-02f, 2.48007942e-02f, 1.33009136e-01f,
  1.48906708e-01f, 4.06741723e-02f, 7.78771862e-02f, -8.70816708e-02f, 7.54570514e-02f, 2.45079063e-02f, 3.30608301e-02f, -7.54082575e-02f, 8.20863619e-02f, -7.53500983e-02f,
  -7.63485506e-02f, -1.35226399e-02f, -2.35402957e-03f, -3.74693051e-02f, 4.99654701e-03f, -2.47071367e-02f, 3.93337943e-02f, 1.39968917e-02f, 4.00474779e-02f, -1.25951013e-02f,
  1.27396509e-01f, 6.95122927e-02f, 1.50941731e-02f, 1.08611872e-02f, 3.65141593e-02f, 1.19990125e-01f, -2.24118978e-02f, -4.31974381e-02f, 1.07609192e-02f, 2.76487805e-02f,
  2.33956933e-01f, 6.21355698e-02f, 5.10810781e-03f, -4.50040735e-02f, -4.18854586e-04f, 1.67134538e-01f, 4.22876962e-02f, 1.26303449e-01f, 1.60584688e-01f, 2.25576293e-02f,
  1.12141706e-01f, 1.19725138e-01f, 1.32980183e-01f, 8.45813975e-02f, 7.00105801e-02f, 3.02338861e-02f, -2.04037572e-03f, 5.05399592e-02f, -1.19192507e-02f, -7.56613091e-02f,
  -1.90008171e-02f, -2.76885509e-01f, -2.64539242e-01f, -2.41922900e-01f, -2.26381496e-01f, -1.17371365e-01f, -2.50722349e-01f, -2.19965205e-01f, -2.60258913e-01f, 1.13457739e-01f,
  -3.86881173e-01f, -1.85109392e-01f, -7.26713762e-02f, -4.92270768e-01f, 1.43048018e-01f, 5.11064902e-02f, 7.65999109e-02f, 4.69566844e-02f, -1.83350921e-01f, -8.64720419e-02f,
  -1.65537223e-01f, -2.74541140e-01f, -9.09926146e-02f, -1.28231794e-01f, -2.92879522e-01f, -6.19053952e-02f, 2.50542790e-01f, -2.70019382e-01f, -4.84580323e-02f, -2.06656754e-01f,
  -1.85270131e-01f, -1.84218571e-01f, -4.03732695e-02f, 5.72351143e-02f, 9.82127413e-02f, -1.72742270e-02f, 3.31010260e-02f, -1.62238911e-01f, -1.87710911e-01f, -5.13012223e-02f,
  1.40337154e-01f, 2.56727729e-03f, -4.61612977e-02f, -8.01795125e-02f, -7.99766853e-02f, -8.79781544e-02f, -5.25969267e-02f, 1.26032367e-01f, -2.22308990e-02f, 3.63325723e-03f,
  -7.02793710e-04f, 1.02518603e-01f, 2.10062005e-02f, 9.36924964e-02f, -7.41779432e-02f, 8.50396045e-03f, 1.14772946e-01f, 9.50206257e-03f, 7.49031529e-02f, 2.36713737e-02f,
  4.74051163e-02f, 8.08544978e-02f, 3.12801041e-02f, -1.47538915e-01f, -1.24661185e-01f, -2.54988112e-02f, 7.86629915e-02f, -1.18873328e-01f, -9.11850929e-02f, 1.49370003e-02f,
  3.11417534e-04f, -6.39817864e-02f, -3.18483897e-02f, 1.33436322e-01f, 1.15422737e-02f, 3.62753086e-02f, -1.00054860e-01f, -1.71862300e-02f, -8.68115947e-03f, 1.83480531e-01f,
  -9.75077823e-02f, 1.59643870e-02f, -4.96603064e-02f, 7.51493350e-02f, 2.95045841e-02f, 8.23541358e-02f, 3.97791862e-02f, 1.10509554e-02f, 4.37984429e-02f, 1.20983191e-01f,
  1.58943698e-01f, 1.55528039e-01f, -3.97997126e-02f, -1.39648199e-01f, 1.11825079e-01f, 4.53195833e-02f, -3.72027606e-02f, -4.33119684e-02f, 3.28768324e-03f, 2.62324959e-02f,
  1.63210049e-01f, 1.36368973e-02f, 2.10468054e-01f, -7.56921843e-02f, -1.27637992e-02f, 8.21187720e-02f, 7.74526149e-02f, 1.05239026e-01f, 1.02873363e-01f, 9.47166011e-02f,
  1.38222888e-01f, 5.37116863e-02f, 6.18315712e-02f, 1.31588876e-01f, 8.27113688e-02f, 6.06094636e-02f, 8.22452009e-02f, -1.29128993e-01f, 1.01099916e-01f, -4.92139794e-02f,
  5.25262058e-01f, -3.32495570e-01f, -4.22035754e-01f, 7.22834393e-02f, 4.12831575e-01f, 3.41538042e-01f, 1.38120681e-01f, -3.61231342e-03f, -2.97551274e-01f, -1.45166621e-01f,
  1.71364442e-01f, 3.67085002e-02f, -2.19578668e-01f, 2.96719223e-01f, 3.97071242e-01f, -2.58417100e-01f, 2.34467685e-01f, 1.83198377e-01f, -1.77280530e-01f, 9.00825262e-02f,
  8.33950788e-02f, 4.25712109e-01f, -1.11936934e-01f, 1.42207127e-02f, 3.28259587e-01f, -2.00619191e-01f, 4.17296030e-02f, -1.96320459e-01f, 1.62378863e-01f, 2.08945900e-01f,
  1.38081476e-01f, -3.17894891e-02f, 4.71505821e-02f, -2.73301899e-02f, -5.75244538e-02f, 1.07780032e-01f, -4.32489626e-02f, 3.33898589e-02f, 1.35465851e-03f, -1.85924359e-02f,
  1.30005581e-02f, 6.50557205e-02f, 8.59217271e-02f, 3.75404134e-02f, 2.21509300e-02f, 3.83650772e-02f, -2.07692645e-02f, -5.11640683e-02f, -3.00674271e-02f, 8.29876810e-02f,
  -6.14069104e-02f, -2.46668570e-02f, 3.31396498e-02f, -5.21374606e-02f, -1.91746559e-02f, -4.45931517e-02f, -4.15857174e-02f, -3.65063213e-02f, -1.69542786e-02f, 5.65775894e-02f,
  3.37334126e-02f, -3.41416001e-02f, -2.07787696e-02f, 7.08925873e-02f, 1.85265280e-02f, -1.72811113e-02f, 6.71056136e-02f, 6.86684400e-02f, -9.87403914e-02f, 2.26737261e-02f,
  -4.05086242e-02f, 4.77637537e-02f, 6.23537228e-02f, -1.27115268e-02f, 5.04053831e-02f, 5.69721218e-03f, 3.19568180e-02f, 3.72828878e-02f, -3.07087619e-02f, -5.17536281e-03f,
  -1.76628232e-02f, -3.17257503e-03f, -3.22891735e-02f, -6.13403358e-02f, -7.84936175e-03f, -2.55234577e-02f, 2.87797991e-02f, 1.70864239e-02f, -9.96188745e-02f, 5.39318100e-02f,
  -1.08995669e-01f, -1.70854196e-01f, -1.46795020e-01f, 1.08732283e-03f, -9.49070677e-02f, 6.80248290e-02f, -2.49291118e-02f, 3.99233811e-02f, -5.54336831e-02f, 2.25670752e-03f,
  3.53983454e-02f, -7.71840811e-02f, -6.66226074e-02f, 2.39936309e-03f, -1.35916774e-03f, 2.47727726e-02f, -7.10416287e-02f, -5.89558259e-02f, 5.03701381e-02f, 6.10430026e-03f,
  -4.24885657e-03f, -4.39896025e-02f, 5.00632375e-02f, 1.88802537e-02f, -2.41489690e-02f, -1.56096490e-02f, 6.66164532e-02f, -3.07619069e-02f, 6.42461404e-02f, -6.19435422e-02f,
  -3.82545471e-01f, -3.09792340e-01f, -8.21208879e-02f, 1.16438724e-01f, 1.35780975e-01f, -1.81917042e-01f, -2.75057584e-01f, 1.72317419e-02f, -7.78160244e-02f, -2.99712628e-01f,
  -1.04528427e-01f, -2.29473367e-01f, -4.16223764e-01f, 7.10739568e-02f, 1.51454151e-01f, -2.42884845e-01f, 1.99401066e-01f, 1.29222888e-02f, 1.07627317e-01f, -9.16091949e-02f,
  1.96649864e-01f, 1.99013427e-01f, 7.52514824e-02f, 3.16941321e-01f, -3.99853438e-02f, 2.00859174e-01f, 2.36126840e-01f, 1.93886831e-01f, 3.08724523e-01f, 1.74254909e-01f,
  -4.97955829e-03f, -1.07413039e-01f, 9.65946168e-02f, 2.03019112e-01f, -8.22996497e-02f, -9.24829096e-02f, 3.80066186e-02f, -8.50014016e-03f, 1.40380323e-01f, 5.70262708e-02f,
  -1.06329247e-01f, 2.37399355e-01f, 3.63576338e-02f, 6.60165474e-02f, 1.07703350e-01f, 1.31245434e-01f, -1.22033721e-02f, -3.48926373e-02f, 1.00801453e-01f, -1.56207576e-01f,
  -1.48089185e-01f, -6.21689372e-02f, -6.69078678e-02f, 9.99246314e-02f, 6.29282594e-02f, 1.12427637e-01f, 8.60701576e-02f, -9.25891846e-02f, 3.77133978e-03f, -1.01212850e-02f,
  -1.38513148e-01f, 3.05673690e-03f, 6.43759442e-04f, -7.92499818e-03f, 6.26839772e-02f, 1.01277582e-01f, 4.82808203e-02f, 1.69654079e-02f, 8.39484707e-02f, -3.74893163e-04f,
  1.44984275e-01f, 3.11454963e-02f, 2.68316381e-02f, 1.96680781e-02f, -7.02846125e-02f, 2.83139311e-02f, 1.34622389e-02f, 1.21532138e-02f, -2.37572659e-02f, -5.91098629e-02f,
  -2.56435089e-02f, 1.15539081e-01f, -4.20480110e-02f, 2.83696577e-02f, 7.20237568e-02f, -1.00796036e-01f, -7.21347257e-02f, 3.07271112e-04f, -4.35420051e-02f, 2.49208906e-03f,
  -5.46588525e-02f, -2.69355881e-03f, 5.20466119e-02f, 1.99074194e-01f, 3.61392424e-02f, 3.76984365e-02f, 1.11951167e-02f, 2.81016286e-02f, 9.13777649e-02f, -5.50812818e-02f,
  6.57628477e-02f, 5.56923486e-02f, -2.32761446e-02f, 3.98247391e-02f, 9.45181325e-02f, -7.57985860e-02f, 2.92624328e-02f, 7.32233524e-02f, 1.41275451e-01f, 5.28188571e-02f,
  1.64330620e-02f, -1.06839769e-01f, 4.31785285e-02f, 9.34458524e-02f, 7.73838311e-02f, -7.65715688e-02f, -6.82233796e-02f, 4.30164896e-02f, -1.09858196e-02f, 3.04514207e-02f,
  -6.45864785e-01f, 7.92996213e-02f, -4.20058221e-01f, -1.19907334e-01f, 1.76000118e-01f, 2.75789797e-02f, -5.19877598e-02f, 2.08589323e-02f, -3.09408247e-01f, 2.89532900e-01f,
  1.57110259e-01f, -1.58828154e-01f, -2.45140627e-01f, 3.05302262e-01f, -3.18977207e-01f, -1.19551659e-01f, 1.06671691e-01f, 6.80607259e-02f, -1.01828039e-01f, -1.40084982e-01f,
  -1.69232011e-01f, 3.50948513e-01f, -2.13130221e-01f, 1.91965699e-01f, 6.74414486e-02f, 2.16555893e-02f, 8.90420079e-02f, -1.28719240e-01f, 3.29275340e-01f, 9.81489271e-02f,
  -1.02962121e-01f, -2.61785269e-01f, -2.58143083e-03f, -1.06952630e-01f, -7.49378279e-02f, 5.20835556e-02f, -8.27662423e-02f, -7.15541914e-02f, -5.35997227e-02f, -3.67359594e-02f,
  -4.58882675e-02f, -5.33849411e-02f, 9.17225480e-02f, -5.22645041e-02f, 1.62111185e-02f, 3.95513400e-02f, 2.50430889e-02f, -2.63235215e-02f, 7.09806308e-02f, -9.67040509e-02f,
  -1.26329258e-01f, 2.30799243e-02f, 3.46184755e-03f, 2.44600624e-02f, -1.48457941e-02f, -2.32768729e-02f, -3.86936381e-03f, -2.79537048e-02f, 9.43025500e-02f, 6.85105426e-03f,
  -2.36604526e-03f, -2.74022613e-02f, 3.16597112e-02f, -2.39114347e-03f, -2.52728257e-02f, 7.05675855e-02f, 4.87022512e-02f, 7.89033398e-02f, -3.91409807e-02f, -5.15853800e-02f,
  -1.04150567e-02f, 4.07726690e-02f, 5.00978157e-02f, -1.81926647e-03f, 2.23107748e-02f, 3.66918813e-03f, -3.50804701e-02f, -9.53595713e-03f, -4.01803069e-02f, 7.62225315e-02f,
  -9.59877148e-02f, -5.45624457e-02f, -2.40333769e-02f, 7.45301917e-02f, 2.27437187e-02f, -1.54076710e-01f, -2.21447404e-02f, -8.75368156e-03f, -3.78389284e-02f, -2.11655954e-03f,
  -2.30272666e-01f, -2.46223867e-01f, -1.81702301e-02f, 7.85891786e-02f, 1.03880987e-02f, -1.34287784e-02f, -3.22873821e-03f, 6.31540790e-02f, -6.59112558e-02f, -5.83475083e-02f,
  -1.03680559e-01f, 7.57396594e-02f, -2.03061923e-02f, -2.04252341e-04f, 3.50569971e-02f, -3.51514556e-02f, -4.28917557e-02f, -6.02741279e-02f, 3.64142954e-02f, 2.71530878e-02f,
  2.10332181e-02f, 5.43487817e-02f, 4.30488065e-02f, 3.66300233e-02f, 8.61392617e-02f, -9.35273152e-03f, -1.11862784e-02f, -3.26982290e-02f, 1.15300931e-01f, 1.13375254e-01f,
  4.12629604e-01f, 3.36763531e-01f, 6.56911358e-02f, 1.95699468e-01f, -2.89276719e-01f, -6.90829307e-02f, 9.77019817e-02f, -1.66779757e-01f, -5.84739931e-02f, 1.55586094e-01f,
  -8.07299465e-02f, 2.63237745e-01f, 2.10721761e-01f, 1.95550516e-01f, 3.27986032e-01f, 1.87702358e-01f, 1.43886894e-01f, -6.04514480e-02f, -6.55461252e-02f, 2.27721080e-01f,
  -4.83181365e-02f, 2.10173890e-01f, 1.48223341e-01f, -6.00912422e-02f, 2.20284790e-01f, -1.15330918e-02f, 2.48066813e-01f, -2.79391315e-02f, 4.89786118e-02f, 5.04303537e-02f,
  -6.27326891e-02f, 1.81773528e-01f, -6.15595914e-02f, -1.06499456e-02f, 1.35456085e-01f, -6.39441460e-02f, -3.25772278e-02f, 9.28829461e-02f, -5.63064814e-02f, 4.56752256e-02f,
  2.05582440e-01f, 7.18569895e-03f, 2.78995428e-02f, -8.51104409e-03f, -5.11245690e-02f, -2.25752965e-02f, -6.70218840e-02f, -1.61452487e-01f, -3.66426376e-03f, 8.01743343e-02f,
  2.53774673e-02f, 7.85638054e-04f, 7.04042381e-04f, 7.78616071e-02f, 9.69310477e-02f, 2.32391469e-02f, 3.92640270e-02f, 8.07404220e-02f, 1.06965028e-01f, 1.95673201e-02f,
  1.22372612e-01f, 2.13528723e-02f, 1.30641526e-02f, -4.71581742e-02f, 1.06935196e-01f, -8.93097743e-02f, -7.24507356e-03f, -7.50119165e-02f, -3.95392925e-02f, 1.10882156e-01f,
  -1.27054200e-01f, -1.03795473e-02f, 9.19084356e-04f, -4.18388881e-02f, 5.04570305e-02f, 1.50601014e-01f, -4.89288159e-02f, 7.41954520e-02f, -1.32359892e-01f, -1.46956176e-01f,
  3.51629779e-02f, 5.60271740e-02f, 6.74558133e-02f, -7.23357201e-02f, -1.27131283e-01f, 1.38603123e-02f, 1.29669890e-01f, 1.53858721e-01f, -1.33949876e-01f, 4.80214767e-02f,
  9.28128362e-02f, 5.50285041e-01f, 1.82357356e-02f, -4.21485081e-02f, 1.23823592e-02f, 2.49372218e-02f, 7.25396127e-02f, 1.10677093e-01f, 1.53348833e-01f, 1.24918163e-01f,
  6.15881234e-02f, -8.90292749e-02f, -5.51559851e-02f, -3.49856839e-02f, -2.65609622e-02f, 8.38217735e-02f, 6.01557866e-02f, -3.61901755e-03f, 6.39448985e-02f, -5.24345972e-02f,
  -1.94145720e-02f, 9.61160213e-02f, 8.09046626e-02f, -7.51720443e-02f, -2.29638964e-02f, 1.16175860e-02f, -4.14107479e-02f, -9.87689942e-02f, 1.21956348e-01f, 2.60321866e-03f,
  -1.03394054e-01f, 2.28363365e-01f, 2.55747408e-01f, 2.18364969e-01f, -1.14407979e-01f, -3.59443426e-01f, -2.48846665e-01f, 1.87782153e-01f, -1.61048278e-01f, 8.83271769e-02f,
  7.97167234e-03f, 3.48806530e-02f, 1.61738396e-02f, -2.10512400e-01f, -3.36092055e-01f, -3.76742572e-01f, -2.70120930e-02f, -9.20258760e-02f, -1.46799281e-01f, 2.91932315e-01f,
  1.71791926e-01f, -1.11153066e-01f, 2.63311148e-01f, 1.99461624e-01f, 1.37012288e-01f, 2.93064952e-01f, 3.03636551e-01f, 1.31879672e-01f, 2.91451603e-01f, -2.17383981e-01f,
  -1.99929804e-01f, 4.08051386e-02f, 1.05029486e-01f, -9.22202989e-02f, 1.66843832e-01f, 5.82648814e-02f, 9.22309980e-02f, -4.39616330e-02f, -2.77108904e-02f, 3.02194767e-02f,
  3.12125161e-02f, 1.33914836e-02f, -1.18744355e-02f, -8.66728723e-02f, -5.01333959e-02f, -8.37503374e-03f, 3.46563384e-03f, -7.36671640e-03f, 7.00935908e-03f, 1.00876257e-01f,
  9.60682854e-02f, 2.14003399e-02f, 5.71293849e-03f, -6.75344467e-02f, 2.32983902e-02f, 6.27546222e-04f, -2.85113640e-02f, 2.23126531e-01f, -4.39054668e-02f, 7.42737055e-02f,
  1.18388161e-01f, -2.60255467e-02f, -1.16205476e-02f, -1.60207123e-01f, -1.04438096e-01f, -2.07691044e-02f, -8.67532790e-02f, -4.03647460e-02f, -2.66114939e-02f, -6.83981404e-02f,
  1.31654134e-02f, 6.88407645e-02f, -1.79353982e-01f, 3.36703397e-02f, 8.27971101e-02f, -5.97083569e-02f, -2.60995934e-03f, 4.57738452e-02f, 9.01148543e-02f, 8.48948024e-03f,
  -7.23568276e-02f, -6.18139170e-02f, 1.30187348e-02f, 2.01520585e-02f, -1.78614005e-01f, 6.42717481e-02f, 1.04731075e-01f, -4.24539559e-02f, -3.35108154e-02f, 1.51432343e-02f,
  1.93859518e-01f, 2.97622174e-01f, 7.95506239e-02f, -8.47603008e-02f, -8.23108852e-02f, -3.36047783e-02f, -1.43804491e-01f, -1.72229633e-02f, 5.97529672e-02f, -7.92109445e-02f,
  1.88321486e-01f, 9.50158983e-02f, -2.52339523e-03f, -3.26227583e-02f, 3.38924527e-02f, 6.56145215e-02f, 2.29758061e-02f, 9.80491284e-03f, 1.26213580e-01f, 2.06220940e-01f,
  2.05092311e-01f, 2.85029709e-02f, 3.49574024e-03f, -8.95507634e-02f, 7.25070089e-02f, 1.98601410e-02f, -1.94779392e-02f, 9.89356712e-02f, -6.41951524e-03f, 5.48103079e-02f,
  -1.60382867e-01f, -1.03677705e-01f, -1.66418925e-01f, 1.57165557e-01f, 4.54908311e-01f, -3.62406075e-01f, 1.48157015e-01f, 3.05534124e-01f, 1.57426402e-01f, 1.00424755e-02f,
  1.77528318e-02f, -4.52434927e-01f, -1.79209057e-02f, -3.64294678e-01f, -6.53330505e-01f, -3.49741489e-01f, -4.72354352e-01f, -3.51366043e-01f, -5.09559475e-02f, -3.05544981e-03f,
  9.12866183e-03f, 1.93866134e-01f, -9.80658177e-03f, 4.31601942e-01f, 2.44238913e-01f, 3.11443388e-01f, 2.85601407e-01f, 3.51748735e-01f, -7.47608617e-02f, -1.00503892e-01f,
  -1.48232281e-01f, 8.35934058e-02f, 6.04607016e-02f, 2.32330449e-02f, 1.95138697e-02f, 2.56535467e-02f, -1.38633549e-01f, 5.17702736e-02f, 2.83174124e-02f, -2.26848871e-02f,
  -6.25133812e-02f, 2.21872819e-03f, -1.18001409e-01f, 3.39159407e-02f, 1.49003759e-01f, 1.08381836e-02f, -1.39538899e-01f, -3.61373872e-02f, 4.84059490e-02f, -1.90464556e-01f,
  -8.89406949e-02f, -1.27817675e-01f, -3.39643173e-02f, -1.46361634e-01f, -2.61284374e-02f, 4.28709760e-03f, -3.88856977e-02f, -1.55050755e-01f, -4.30803597e-02f, 3.53346802e-02f,
  -1.39120715e-02f, 3.03426869e-02f, 4.92086448e-02f, 7.93741271e-02f, 6.35920018e-02f, 4.04118299e-02f, 2.71244571e-02f, -3.56942043e-02f, -1.79751366e-02f, -1.74033847e-02f,
  9.74608213e-02f, 4.49649170e-02f, 5.12895733e-02f, -1.89263690e-02f, -2.75062155e-02f, 1.04934178e-01f, -2.10194252e-02f, -1.56520709e-01f, 5.27755693e-02f, 2.35259235e-02f,
  1.13588229e-01f, 5.32834493e-02f, 5.20208292e-02f, 2.68281922e-02f, -4.23670821e-02f, 1.46022150e-02f, 7.37587921e-03f, -3.94853689e-02f, -1.00466479e-02f, 6.82676956e-02f,
  -1.23193316e-01f, 7.02310912e-03f, 1.13551803e-01f, 1.14365630e-01f, -9.14951041e-02f, -8.24935511e-02f, -7.88376853e-02f, -4.42907475e-02f, 4.79142070e-02f, 3.35577987e-02f,
  1.44423749e-02f, 1.31941766e-01f, -1.10338219e-02f, -1.31708786e-01f, -5.56503702e-03f, -2.93315183e-02f, 4.39107381e-02f, 6.50129095e-02f, 1.13226727e-01f, -1.87795830e-03f,
  1.34640530e-01f, -5.95433488e-02f, 4.18167114e-02f, 1.90293238e-01f, -1.89924650e-02f, -4.05775057e-03f, -4.94627934e-03f, 2.69743800e-02f, -1.98316090e-02f, -1.30865723e-01f,
  -3.69431704e-01f, 4.97188978e-02f, -2.54722089e-01f, -2.44536474e-01f, -3.33744168e-01f, -2.51666427e-01f, -7.85335079e-02f, -2.94317538e-03f, 1.64211199e-01f, 2.63802648e-01f,
  6.09089527e-03f, 1.27396777e-01f, 4.40343171e-01f, -2.02109039e-01f, -2.38066241e-02f, 3.46839726e-01f, -2.04148963e-01f, 7.53826350e-02f, -3.37863788e-02f, 7.63050988e-02f,
  -1.24015607e-01f, 3.59823331e-02f, -1.83176950e-01f, -1.26725873e-02f, -4.06716645e-01f, -3.02129418e-01f, -1.12874970e-01f, -1.64357170e-01f, -4.17600125e-01f, -2.54892528e-01f,
  -3.72130066e-01f, -2.49430880e-01f, -5.73829859e-02f, -1.54010102e-01f, -1.73066631e-01f, 4.40053176e-03f, -2.16189221e-01f, 3.17527279e-02f, -4.59009372e-02f, -4.23410609e-02f,
  1.37304142e-01f, 3.93774500e-03f, -1.21994382e-02f, 1.65751904e-01f, -4.74041514e-02f, -1.60672337e-01f, -1.15471944e-01f, -2.05150217e-01f, -2.01472547e-02f, -5.70820235e-02f,
  -3.72674949e-02f, -1.00146316e-01f, -2.42300183e-01f, -1.24008946e-01f, -2.39608720e-01f, -1.50915816e-01f, -4.36586998e-02f, -1.30487770e-01f, -2.10444987e-01f, -1.57535344e-01f,
  6.64285645e-02f, 9.54918414e-02f, 8.90635978e-03f, 5.79064749e-02f, 1.31447474e-02f, -7.13044330e-02f, 6.99476618e-03f, 4.40505259e-02f, -2.69920304e-02f, -3.33732218e-02f,
  -3.41141783e-02f, -1.29605215e-02f, -7.24625662e-02f, -4.27579023e-02f, 8.03297833e-02f, 1.94059655e-01f, 6.73389807e-02f, -5.17979488e-02f, 2.31992908e-05f, -6.62877858e-02f,
  6.01394624e-02f, -5.97350001e-02f, -1.70225855e-02f, 1.73618607e-02f, -8.87899995e-02f, -1.34199355e-02f, -8.12492296e-02f, -5.00528179e-02f, 1.72333047e-02f, -5.84984235e-02f,
  -3.36830884e-01f, -2.94330478e-01f, 8.17277804e-02f, -1.00984596e-01f, 5.97637147e-02f, -1.43343713e-02f, 9.37036946e-02f, -5.43087721e-02f, -1.07734650e-01f, 1.40705645e-01f,
  4.14388925e-02f, 5.73050417e-03f, -1.09510645e-01f, 6.08105659e-02f, 1.78142324e-01f, 4.29710895e-02f, 5.94750270e-02f, -5.45237735e-02f, -1.21426350e-02f, -5.35615757e-02f,
  2.63922811e-02f, 1.29806876e-01f, 2.08729580e-01f, 5.70309833e-02f, 2.99639422e-02f, -5.81950396e-02f, -1.40119782e-02f, -4.06594388e-02f, -1.88111156e-01f, -1.76117639e-03f,
  -5.10601960e-02f, 2.66811103e-01f, 3.72783393e-02f, -2.07665991e-02f, -9.88755599e-02f, -2.77799785e-01f, -1.82770461e-01f, -1.19108528e-01f, 1.20782547e-01f, 2.29012892e-01f,
  -1.55728281e-01f, 4.45888668e-01f, 2.25871932e-04f, -2.09104091e-01f, -5.82320869e-01f, -2.99389124e-01f, -1.90369308e-01f, 4.95831855e-02f, 4.51132506e-02f, 6.69364259e-02f,
  -2.28114009e-01f, -2.83295751e-01f, -3.08017582e-01f, -5.21942182e-03f, 1.76537577e-02f, 2.84548312e-01f, -9.47993025e-02f, 9.45294872e-02f, 6.28648326e-02f, -1.34077013e-01f,
  8.82270653e-03f, 1.63166091e-01f, 9.30631608e-02f, 3.88630405e-02f, -3.95453423e-02f, 3.79521050e-03f, 8.49628076e-02f, -7.63891116e-02f, -4.56128642e-02f, 1.21303237e-04f,
  9.63729173e-02f, -2.10222285e-02f, 3.18732038e-02f, -4.27272357e-02f, 8.77593011e-02f, 7.58131370e-02f, 1.35774836e-01f, 1.22670770e-01f, 1.33092195e-01f, -6.95704967e-02f,
  1.28672849e-02f, 5.25948703e-02f, -8.64924863e-02f, 1.27751678e-01f, 2.80251987e-02f, -5.38196974e-02f, -1.35437986e-02f, 8.53737891e-02f, 2.12089151e-01f, -7.52438093e-03f,
  -7.97097161e-02f, -6.61683222e-03f, -2.03224700e-02f, -1.02473535e-01f, -6.38202131e-02f, -1.73491761e-02f, -1.26026392e-01f, -7.16542499e-03f, -1.88461563e-03f, 2.65987534e-02f,
  6.03137091e-02f, 1.28606811e-01f, -7.30619803e-02f, -1.78229418e-02f, -3.11376080e-02f, 4.11472246e-02f, -1.15602754e-01f, 1.42985851e-01f, -5.66928312e-02f, -2.99472585e-02f,
  1.42050788e-01f, -5.43761887e-02f, 7.93092921e-02f, -1.15330787e-02f, -1.20373912e-01f, 1.39363855e-02f, 1.44149335e-02f, -5.16395271e-02f, -2.57037859e-02f, -4.24216129e-02f,
  7.45692104e-02f, 1.39097393e-01f, 6.31535724e-02f, 1.01029903e-01f, 1.97651256e-02f, 2.96223704e-02f, -8.55322778e-02f, 4.62926254e-02f, 2.93057095e-02f, 3.10689141e-03f,
  -1.46859260e-02f, 3.53381410e-02f, 1.23423181e-01f, -8.32257271e-02f, -5.80874085e-02f, -1.27085686e-01f, 4.12350409e-02f, 1.07614703e-01f, 8.97751190e-03f, 2.89836917e-02f,
  6.12260178e-02f, 3.65948491e-02f, -5.76416217e-02f, 1.03205986e-01f, 4.76422533e-02f, 3.37441862e-02f, 7.55236000e-02f, -1.52044103e-03f, 5.64565547e-02f, 1.00082681e-01f,
  -3.80266398e-01f, -3.91359538e-01f, -1.28762648e-01f, -3.11378241e-01f, -8.97725672e-02f, 3.55582178e-01f, 3.34945887e-01f, -2.36504108e-01f, -4.85551327e-01f, -3.09118256e-03f,
  3.06933612e-01f, -2.13896424e-01f, 2.30661377e-01f, 1.57717273e-01f, 3.23237807e-01f, 2.32416019e-01f, 2.03578770e-01f, 2.75976121e-01f, 2.39588483e-03f, 4.82409187e-02f,
  1.40832409e-01f, 3.65677446e-01f, 3.76585513e-01f, 1.36392117e-01f, 4.22892272e-02f, -1.16031930e-01f, 1.32405236e-01f, 1.61713958e-01f, 2.46168688e-01f, 1.30410701e-01f,
  2.58882731e-01f, -2.29658335e-01f, 1.45031102e-02f, -3.94245721e-02f, 1.57660827e-01f, 8.75434950e-02f, 9.45628881e-02f, 1.32075667e-01f, -7.74481073e-02f, 7.45875165e-02f,
  -4.62889411e-02f, -8.41189101e-02f, -1.54823571e-01f, 7.44753480e-02f, -1.22916944e-01f, -1.37046278e-01f, -6.08187206e-02f, -7.90043559e-04f, 2.93733701e-02f, -3.06967795e-02f,
  -1.60738118e-02f, -1.79656483e-02f, -1.18740663e-01f, 5.62266111e-02f, -9.15280059e-02f, -1.02777645e-01f, 1.06890090e-02f, -2.07625609e-02f, -4.94625755e-02f, -1.06647857e-01f,
  3.65014970e-02f, -8.46491661e-03f, 4.75417897e-02f, 5.26958667e-02f, -2.60671619e-02f, 6.23919852e-02f, 3.82529781e-03f, 9.48453099e-02f, -9.04140323e-02f, 3.68086174e-02f,
  -2.06326228e-02f, 6.06847145e-02f, -1.93954501e-02f, -1.72641352e-02f, 2.91792564e-02f, -1.20289493e-02f, 1.70862466e-01f, -2.90451534e-02f, 2.37783859e-03f, 7.17234835e-02f,
  -2.94617508e-02f, -3.72914188e-02f, 4.40302305e-02f, 4.77394238e-02f, 2.96516716e-02f, 4.41611111e-02f, -1.06903076e-01f, 3.33704166e-02f, -7.90355057e-02f, 5.17853685e-02f,
  3.31994854e-02f, -2.47717470e-01f, -1.36155332e-03f, 2.72925384e-03f, 1.38297826e-01f, 3.09416559e-02f, -4.18097246e-03f, -5.31002022e-02f, -3.03065814e-02f, -2.29743551e-02f,
  7.09896684e-02f, 7.17496574e-02f, -9.09961015e-02f, 1.76731404e-02f, -4.44790684e-02f, -7.46011660e-02f, 8.53259787e-02f, -1.49534671e-02f, 1.03119891e-02f, -4.12872136e-02f,
  -1.29771903e-01f, -4.68923748e-02f, -1.21774301e-01f, 2.15632562e-02f, -1.67938709e-01f, 3.22723836e-02f, -6.48233071e-02f, -1.08181052e-01f, 3.09242122e-02f, -2.18881350e-02f,
  2.00760216e-02f, -1.89209774e-01f, -1.96081758e-01f, 3.14217865e-01f, -4.49370533e-01f, 1.21364601e-01f, 4.51686829e-01f, -2.85976708e-01f, 2.40822822e-01f, 1.31799072e-01f,
  1.18720673e-01f, -1.08771853e-01f, 3.01808625e-01f, 2.17881233e-01f, 1.39229402e-01f, 3.84436697e-01f, 3.32793921e-01f, 3.17918122e-01f, -6.04503639e-02f, 1.51205342e-02f,
  1.43452473e-02f, 1.55230996e-03f, 7.12224981e-03f, -3.41850549e-01f, -2.22122073e-01f, -2.87573308e-01f, -1.99587479e-01f, -1.89532176e-01f, -2.21627653e-01f, -1.79426759e-01f,
  1.13552280e-01f, 1.17408067e-01f, -8.45007692e-03f, 4.84962314e-02f, 1.68475248e-02f, 2.46179588e-02f, 3.36848083e-03f, 2.63094399e-02f, 9.45358053e-02f, 8.32547992e-02f,
  7.14135468e-02f, 2.55809980e-03f, 1.28187984e-02f, -6.54503629e-02f, -7.05660954e-02f, -1.04698807e-01f, 2.37140972e-02f, -2.21054256e-03f, -7.05082789e-02f, -4.14848104e-02f,
  4.73583601e-02f, -3.82173411e-03f, 5.13156801e-02f, 6.56718835e-02f, 4.16102782e-02f, 7.97581971e-02f, 3.48306336e-02f, -3.14005800e-02f, -8.31758007e-02f, -2.75557768e-02f,
  -1.58725604e-01f, 7.15936348e-02f, 1.05333656e-01f, 7.20809621e-04f, 2.27157329e-03f, -4.20575924e-02f, 5.56966662e-03f, 3.38874944e-03f, 4.36321460e-02f, 1.19625013e-02f,
  9.68421809e-03f, -1.48232449e-02f, -3.57939973e-02f, 3.51283252e-02f, 3.90434712e-02f, 5.44471294e-02f, 4.48375195e-02f, -8.90141129e-02f, 1.26471624e-01f, -6.02637418e-02f,
  1.74207166e-02f, 4.68698665e-02f, 1.92788895e-02f, -1.26451522e-03f, 7.53962100e-02f, -5.74739929e-03f, -6.56156428e-03f, -6.18553087e-02f, 7.51111284e-02f, -4.41318043e-02f,
  8.04965496e-02f, -4.75888848e-02f, 9.95461345e-02f, 1.02446675e-01f, 8.90538376e-03f, -1.22959107e-01f, 2.16140114e-02f, -7.50724971e-02f, -8.17308053e-02f, 3.26666310e-02f,
  -8.64219889e-02f, 7.09969103e-02f, -5.96612282e-02f, -2.85695773e-02f, 2.10396107e-02f, -2.99664754e-02f, 1.05216116e-01f, 1.80092193e-02f, -9.29537229e-03f, -1.56287909e-01f,
  3.37260403e-02f, 2.98240371e-02f, 1.02996193e-01f, 7.67982900e-02f, 5.08698747e-02f, 8.02224204e-02f, -1.34649575e-01f, -1.01434790e-01f, -3.43393236e-02f, 8.39773789e-02f,
  -2.31991112e-01f, 2.58497268e-01f, -1.41085461e-01f, 3.21612298e-01f, -1.19851291e-01f, 4.42173302e-01f, 3.74962211e-01f, 1.83133826e-01f, 4.77500677e-01f, 2.82904029e-01f,
  1.53056756e-01f, -1.49141952e-01f, 8.89808685e-02f, 3.59190017e-01f, 2.68335990e-03f, 4.07154441e-01f, 3.88626754e-01f, 3.46652240e-01f, 6.43899888e-02f, 7.49565735e-02f,
  2.62019243e-02f, 1.29947290e-01f, -1.46657005e-01f, -2.11875647e-01f, -5.54681867e-02f, -1.87012970e-01f, -2.03380540e-01f, -2.07350641e-01f, -2.71693468e-02f, -2.92581227e-02f,
  5.26622869e-02f, 5.16597182e-02f, -1.63988754e-01f, -5.52168712e-02f, 2.13048607e-02f, -4.64479104e-02f, 2.68925894e-02f, -1.34103820e-01f, -1.04835734e-01f, 2.65019033e-02f,
  -3.26712541e-02f, -1.06704064e-01f, 8.47169608e-02f, -4.25064228e-02f, -6.80287406e-02f, -8.88944492e-02f, -4.46675494e-02f, 2.90128253e-02f, -1.73390061e-02f, -5.75357638e-02f,
  -4.12440598e-02f, 2.11503021e-02f, 7.37468079e-02f, 3.43122147e-02f, -1.10486083e-01f, 2.34684478e-02f, 1.13832191e-01f, -1.00335572e-02f, -2.73332261e-02f, 3.60748880e-02f,
  -8.35257098e-02f, 1.20427646e-01f, 2.06115842e-03f, -9.04005300e-03f, 6.27295254e-03f, 3.63191292e-02f, 4.90668304e-02f, -1.55185005e-02f, -2.05661338e-02f, 7.12276921e-02f,
  9.01382491e-02f, -2.01952346e-02f, 1.06650524e-01f, -2.06346400e-02f, 5.89578673e-02f, 6.64990544e-02f, -6.44502416e-02f, 6.40185103e-02f, 7.55396932e-02f, 1.30472751e-02f,
  9.23522711e-02f, 6.46689907e-03f, -1.02704242e-01f, -6.50255382e-02f, 8.62901006e-03f, -6.18951432e-02f, 1.11658141e-01f, 3.01256380e-03f, -3.02068722e-02f, -1.04997009e-01f,
  3.48765314e-01f, 3.19053382e-01f, 1.27791017e-02f, -8.89629200e-02f, 3.61092128e-02f, -9.81928781e-04f, 2.40153577e-02f, 2.68436805e-03f, 9.50585585e-03f, 2.00263150e-02f,
  -6.87535331e-02f, -8.27447220e-04f, 4.24429104e-02f, -1.81312468e-02f, -1.53755082e-03f, 5.53415855e-03f, 7.36563727e-02f, 7.43812919e-02f, 6.13959022e-02f, -7.76884705e-02f,
  -1.22628093e-01f, 6.13661073e-02f, -4.85557541e-02f, 4.16629482e-03f, -3.26592177e-02f, -6.02599047e-02f, 1.55267548e-02f, -5.17367534e-02f, -4.17037085e-02f, 1.00279450e-01f,
  -3.43740731e-01f, 2.04512268e-01f, -2.67760992e-01f, -1.37804523e-01f, -7.10726306e-02f, -9.35041532e-02f, 1.50798172e-01f, 4.41338085e-02f, -2.95841187e-01f, 4.36091810e-01f,
  3.46399993e-01f, -3.49713266e-01f, 2.23305479e-01f, 1.34125635e-01f, -4.32003081e-01f, -1.77003015e-02f, 1.92059040e-01f, 1.79549724e-01f, -2.69687831e-01f, 1.67177230e-01f,
  -1.26651764e-01f, 5.91216013e-02f, 5.27716577e-02f, 1.30168228e-05f, 1.88402340e-01f, 1.23883169e-02f, 4.57034200e-01f, -2.58555673e-02f, 1.46901786e-01f, -1.82525337e-01f,
  6.41019121e-02f, -8.35584700e-02f, 5.15276864e-02f, -7.83649832e-02f, 5.42762093e-02f, 1.59792736e-01f, 1.37128308e-01f, -3.13149989e-02f, -9.78752673e-02f, -3.00188214e-02f,
  2.90750489e-02f, -9.81045291e-02f, -1.29215822e-01f, -8.16710740e-02f, -6.39469968e-03f, -6.86888695e-02f, -7.97656700e-02f, 8.40365421e-03f, -7.12517649e-02f, 5.83692966e-03f,
  -6.56740665e-02f, 1.05466582e-01f, 1.07323885e-01f, 1.35603510e-02f, -9.50636119e-02f, -4.70324839e-03f, -6.96338527e-03f, 1.17060848e-01f, 1.14823794e-02f, -1.10374965e-01f,
  5.87745421e-02f, 1.03145763e-02f, -1.54266935e-02f, -9.27499495e-03f, -1.20345548e-01f, 5.33848256e-02f, 1.19828656e-02f, 8.40622466e-03f, -7.10464343e-02f, -6.26907963e-03f,
  -3.30780596e-02f, -4.87561487e-02f, 6.14789827e-03f, 1.64214112e-02f, -2.58268546e-02f, -3.42862383e-02f, -1.42926648e-02f, 6.62880018e-02f, -2.38048937e-02f, 3.96255078e-03f,
  2.33793762e-02f, -4.27684560e-02f, 7.97279063e-04f, 1.76976666e-01f, 2.34792717e-02f, -4.31416929e-02f, -8.09875224e-03f, 3.70560661e-02f, 5.59551492e-02f, 4.46395986e-02f,
  1.86218768e-01f, 1.08604193e-01f, -2.15132851e-02f, -9.76724178e-02f, -1.72342379e-02f, 8.10677111e-02f, -3.66016328e-02f, -7.29586929e-02f, -3.00780926e-02f, -9.60868150e-02f,
  6.08342178e-02f, 1.40652850e-01f, 8.49307925e-02f, -4.47196774e-02f, -9.07150283e-02f, 8.08804706e-02f, 6.77217320e-02f, -9.60894376e-02f, 3.65496054e-02f, 7.42790475e-02f,
  7.85797164e-02f, -1.74757391e-02f, 1.75442314e-03f, -2.98643727e-02f, 1.67043786e-02f, 9.26230401e-02f, 1.91745255e-02f, -1.00923643e-01f, 9.01729167e-02f, 6.20472990e-02f,
  5.00100143e-02f, 5.10269701e-01f, -1.33876354e-01f, -1.89889237e-01f, -2.09048226e-01f, 6.89243138e-01f, 3.98081720e-01f, -5.06828614e-02f, -1.97274446e-01f, 4.43202645e-01f,
  8.72812569e-02f, -3.33686695e-02f, 1.94795012e-01f, 3.30562919e-01f, 4.06029150e-02f, 3.81402463e-01f, 3.98406714e-01f, 2.42987886e-01f, -1.88205063e-01f, -5.42381918e-03f,
  -1.06308758e-01f, 2.52770931e-01f, 1.79228764e-02f, -2.91488487e-02f, 1.33021176e-01f, -2.83178449e-01f, -2.93079853e-01f, -2.69482017e-01f, 7.33149098e-03f, -1.11008557e-02f,
  1.38944417e-01f, -5.49197644e-02f, -2.78079207e-03f, 9.66864675e-02f, 1.01800701e-02f, -4.23609000e-03f, -3.98344956e-02f, 1.05416598e-02f, -2.84530371e-01f, -1.16872758e-01f,
  -4.36905399e-02f, -3.67686637e-02f, 5.42987473e-02f, -1.41314715e-01f, -8.91405717e-02f, -7.44330734e-02f, -4.19226300e-04f, 1.79314762e-02f, -1.18011031e-02f, 1.07575752e-01f,
  2.13366672e-02f, -1.82887036e-02f, -3.09817977e-02f, 2.69565210e-02f, -1.33305281e-01f, -2.31304262e-02f, 1.42752603e-01f, 2.81827189e-02f, 1.09105080e-01f, -3.28673087e-02f,
  -6.08557947e-02f, 8.80121067e-02f, 1.81247056e-01f, 1.00174792e-01f, 6.55848533e-02f, -2.91924588e-02f, 3.67014520e-02f, 2.43715551e-02f, -6.25217184e-02f, 2.01781660e-01f,
  -9.06593502e-02f, 1.52366087e-02f, -5.84128387e-02f, 6.58539608e-02f, 6.57121986e-02f, 5.93322366e-02f, 4.73906510e-02f, -4.29203548e-02f, 3.72743420e-02f, 4.01813388e-02f,
  -1.57138631e-01f, -2.68503912e-02f, 7.54721463e-02f, -3.57153788e-02f, 7.95966834e-02f, -7.89474100e-02f, -5.22830710e-02f, 9.33329575e-03f, -5.39127663e-02f, -1.27342999e-01f,
  1.40494674e-01f, 6.58537596e-02f, -3.81756723e-02f, 7.50714988e-02f, 8.59166961e-03f, 1.60482097e-02f, -2.04367153e-02f, 6.75405040e-02f, 3.98548506e-02f, 2.67621651e-02f,
  -2.95631010e-02f, 4.73245494e-02f, 3.69926691e-02f, -9.61637497e-02f, -4.57621664e-02f, 1.76248953e-01f, 9.20367986e-02f, -1.20737791e-01f, -7.05500916e-02f, -2.14799196e-02f,
  -2.98450980e-02f, -5.72619475e-02f, 4.06581117e-03f, -2.93945288e-03f, -6.14427701e-02f, -3.23530054e-03f, 4.03110981e-02f, -7.69290421e-03f, -4.21449728e-02f, -4.04514894e-02f,
  4.37431842e-01f, -1.02489129e-01f, -1.78294167e-01f, 1.45421311e-01f, 2.68230855e-01f, 7.96685740e-02f, -1.64622124e-02f, 9.13752541e-02f, -1.05603017e-01f, -1.08118482e-01f,
  2.92484671e-01f, -1.93637237e-01f, -1.01119764e-01f, 2.75488019e-01f, 2.51088560e-01f, -2.68981129e-01f, 2.10143536e-01f, -3.08206026e-02f, -1.05986021e-01f, 2.39397183e-01f,
  1.02020554e-01f, 3.43817890e-01f, 1.70967374e-02f, 6.19642287e-02f, 1.49636850e-01f, -1.19837739e-01f, 1.95917308e-01f, -2.08840832e-01f, 5.81805371e-02f, 3.50566544e-02f,
  2.19804086e-02f, 5.75975291e-02f, -5.21229804e-02f, -1.30192772e-01f, 8.15826878e-02f, 3.69590148e-02f, -1.01624496e-01f, 2.99315192e-02f, -1.01626121e-01f, -1.73958372e-02f,
  -3.30697838e-03f, -3.90241598e-03f, 7.93280900e-02f, -2.04732213e-02f, 8.66242722e-02f, -2.85380874e-02f, -4.50193733e-02f, -1.35548368e-01f, -7.51645342e-02f, 2.95589603e-02f,
  -1.12671871e-02f, 3.69412415e-02f, 8.10651258e-02f, -6.82398826e-02f, -1.15759093e-02f, 8.14385116e-02f, -1.09310918e-01f, -1.68493148e-02f, -3.78833748e-02f, 6.36882037e-02f,
  7.64515698e-02f, 5.51343895e-03f, 2.58825831e-02f, -7.56259039e-02f, 2.54984889e-02f, 8.03533662e-03f, -3.25825587e-02f, -2.15027928e-02f, -4.15955149e-02f, 1.45028951e-02f,
  4.81956713e-02f, 4.68131667e-03f, -3.40799280e-02f, 1.73824094e-02f, 9.29770842e-02f, -3.84997204e-02f, -4.32067784e-03f, -2.89797671e-02f, 2.01753285e-02f, -3.57504003e-02f,
  -6.82038814e-02f, 1.13024889e-02f, -9.56064370e-03f, -1.75275654e-02f, -2.11964101e-02f, 4.01562043e-02f, 5.21328971e-02f, -1.59513671e-02f, -8.78828485e-03f, 3.94068845e-02f,
  3.45254019e-02f, 4.77886386e-02f, -5.02135456e-02f, -5.27228341e-02f, -7.10064769e-02f, 9.38084275e-02f, -9.22762901e-02f, 3.81142944e-02f, -8.49333331e-02f, 1.00881174e-01f,
  9.95978341e-02f, -3.37166861e-02f, 4.55127209e-02f, -3.62996035e-03f, -4.43914998e-03f, 1.15107886e-01f, 2.34239064e-02f, -1.07991390e-01f, 1.09319426e-02f, 9.04068723e-02f,
  1.10038724e-02f, 6.79447129e-02f, -7.68251941e-02f, 4.92735766e-02f, 5.79918884e-02f, 1.45306224e-02f, 6.08824864e-02f, -5.89747056e-02f, 5.44009767e-02f, -6.15387857e-02f,
  7.00911939e-01f, -4.05252516e-01f, -3.35512638e-01f, 2.85609901e-01f, 3.65006447e-01f, 2.97531337e-01f, 1.56110182e-01f, 2.32268780e-01f, 3.44970316e-01f, -1.74970314e-01f,
  1.36677876e-01f, -2.08634645e-01f, -3.43875974e-01f, 2.97753900e-01f, 3.38897169e-01f, -1.66169241e-01f, 2.73178011e-01f, 9.96482894e-02f, 1.08830333e-01f, 1.15616865e-01f,
  2.59762377e-01f, 4.22268510e-01f, -7.93160424e-02f, 1.39352810e-02f, 2.19448686e-01f, -7.39447400e-02f, -1.12966649e-01f, -2.71504730e-01f, -1.47933059e-03f, 1.14033371e-01f,
  8.02594498e-02f, 1.45743892e-01f, 4.72229309e-02f, -5.16700372e-02f, 2.31159870e-02f, -3.96196730e-02f, -7.05831721e-02f, -6.25919402e-02f, 6.31309152e-02f, -7.34863861e-04f,
  -6.56454340e-02f, 1.17284350e-01f, 1.23926125e-01f, 3.47984466e-03f, 1.10087790e-01f, 5.93574978e-02f, 2.46689487e-02f, -3.30150947e-02f, -5.07163182e-02f, -5.84776402e-02f,
  -2.99951695e-02f, 1.40916761e-02f, 3.01019754e-02f, -3.13985236e-02f, 2.23137848e-02f, 1.21076375e-01f, -9.76452455e-02f, -1.68135464e-01f, 2.60180496e-02f, 1.05260976e-01f,
  1.03245281e-01f, -6.77817613e-02f, -4.83702607e-02f, -3.85153815e-02f, -4.05237637e-02f, 4.39223163e-02f, 1.11540891e-02f, -4.53932583e-02f, -6.23521395e-03f, -5.19941449e-02f,
  8.29205289e-02f, 6.87585250e-02f, 9.75827351e-02f, -1.11442490e-03f, 8.98516327e-02f, 8.01986903e-02f, -9.27957818e-02f, 4.03012091e-04f, 7.32543459e-03f, 6.02178797e-02f,
  4.49763089e-02f, 6.54102713e-02f, -4.26841937e-02f, -1.62015483e-02f, 9.32979733e-02f, -4.23559360e-02f, -4.69371900e-02f, 2.39427369e-02f, -2.28989646e-02f, -3.72227021e-02f,
  -1.25375211e-01f, -2.00537816e-01f, -5.30662946e-03f, 5.44228330e-02f, -1.34471476e-01f, 4.50303704e-02f, 4.34156368e-03f, 9.37563553e-02f, -2.83881351e-02f, 7.43436515e-02f,
  2.78187636e-02f, 7.15776673e-03f, -9.83512551e-02f, -2.59072334e-02f, -1.06730551e-01f, 2.54906295e-03f, -5.77621534e-02f, 1.85916182e-02f, 5.44788614e-02f, -1.78761892e-02f,
  -6.31757900e-02f, -1.66327208e-02f, -1.99877322e-02f, 9.82723981e-02f, -1.88711565e-02f, -2.15597674e-02f, -2.41015442e-02f, -2.33078767e-02f, -4.45311703e-02f, -6.62597865e-02f,
  -8.15253928e-02f, -2.81761110e-01f, -5.32148421e-01f, -2.15514645e-01f, 4.34114456e-01f, 3.33355933e-01f, 1.47197753e-01f, -3.95951159e-02f, -2.29868814e-01f, 1.92745119e-01f,
  3.21286500e-01f, 6.27496168e-02f, -7.39930868e-02f, -1.23940213e-02f, -3.21886018e-02f, -1.70038208e-01f, -1.34564519e-01f, -4.39023823e-02f, -3.14800829e-01f, -3.34636904e-02f,
  -1.32872790e-01f, 2.47501597e-01f, -2.41955534e-01f, 1.54964581e-01f, 1.57892749e-01f, -6.31138384e-02f, 1.72859460e-01f, 2.16273919e-01f, 1.75541580e-01f, 2.68863976e-01f,
  -4.29038610e-03f, -4.05465439e-02f, -1.08138435e-01f, -7.60701671e-02f, 3.67421731e-02f, 5.74299432e-02f, 4.23438214e-02f, 1.19740963e-01f, 7.64532387e-02f, -6.82221027e-03f,
  1.51195034e-01f, -1.12529118e-02f, -2.99130958e-02f, -2.44663991e-02f, -7.01063946e-02f, 4.70703654e-02f, 1.43156471e-02f, -6.90778792e-02f, -1.26670852e-01f, -3.88581045e-02f,
  -5.85952662e-02f, -7.68362358e-02f, -9.28778201e-02f, -1.20879009e-01f, 3.93470144e-03f, -3.87814292e-03f, -1.45556122e-01f, 7.36843422e-02f, -2.52285730e-02f, 7.79533908e-02f,
  8.55131745e-02f, 2.67789327e-02f, -2.56307777e-02f, -7.26777166e-02f, 1.55667085e-02f, -2.11696047e-02f, -5.56214750e-02f, -1.20996637e-02f, -3.01412344e-02f, 9.09499526e-02f,
  2.89438013e-02f, 1.21077169e-02f, 9.59858298e-02f, -2.06976756e-02f, -4.23682407e-02f, -6.65859953e-02f, 1.33676510e-02f, 1.18357629e-01f, -5.09841517e-02f, -3.50502692e-02f,
  -1.11854887e-02f, -2.37165838e-02f, 1.43876597e-01f, -1.30918249e-01f, -4.40124143e-03f, 9.24384892e-02f, 7.59203956e-02f, 2.72941054e-03f, 2.35173982e-02f, 9.29638445e-02f,
  -2.03858670e-02f, -1.47306891e-02f, -3.53388637e-02f, 2.16553882e-02f, -2.77337211e-04f, 1.29837587e-01f, -5.78724258e-02f, 5.20471595e-02f, 8.84960592e-02f, 7.99051151e-02f,
  6.94649667e-02f, -4.59111072e-02f, 6.13698810e-02f, 1.71639826e-02f, -2.43123062e-02f, 1.06486201e-01f, 1.06882781e-01f, 1.26573831e-01f, 1.78106711e-03f, 9.37093198e-02f,
  3.11693642e-02f, 6.98764846e-02f, -3.33768614e-02f, 1.03478751e-03f, 9.56314132e-02f, 8.20450634e-02f, 7.30408076e-03f, 6.50259629e-02f, -2.38278750e-02f, 3.32735889e-02f,
  -9.46875989e-01f, 1.60097778e-01f, 4.33849961e-01f, -3.03343505e-01f, -1.28798038e-02f, 3.58702481e-01f, 2.68191367e-01f, -4.17398214e-02f, -2.46439233e-01f, 1.09387107e-01f,
  1.12708680e-01f, -1.95389435e-01f, 2.59377867e-01f, 1.72502413e-01f, 1.21113829e-01f, 2.43724540e-01f, 1.18145356e-02f, -1.06736116e-01f, -7.83741251e-02f, -2.52258688e-01f,
  -7.45818615e-02f, 5.02351485e-03f, 2.77670860e-01f, -1.73868760e-02f, 3.35655548e-02f, -2.48478889e-01f, -3.35621610e-02f, 2.18657121e-01f, 5.97626679e-02f, 1.36727944e-01f,
  -2.81638831e-01f, -4.01635945e-01f, -2.03584000e-01f, -5.00825271e-02f, -6.47310987e-02f, -8.29278380e-02f, 9.51651577e-03f, 7.40060732e-02f, -8.35844055e-02f, -9.00966898e-02f,
  -1.54671520e-02f, 9.93057638e-02f, -1.03531301e-01f, 1.96935907e-02f, -1.42637685e-01f, -2.14041509e-02f, 1.32926434e-01f, 7.40665123e-02f, 2.19419431e-02f, 1.18139207e-01f,
  1.52608573e-01f, 5.58917336e-02f, 7.00816661e-02f, 3.01635973e-02f, 8.70611519e-02f, -3.90039310e-02f, 1.02064632e-01f, 3.49590406e-02f, -5.80281578e-02f, -1.01990588e-01f,
  2.33078189e-02f, 5.53264134e-02f, -6.88106229e-04f, -6.73931390e-02f, 2.05381997e-02f, 3.47896926e-02f, 2.85446551e-02f, -2.65901489e-03f, 1.63231399e-02f, -1.23281414e-02f,
  -2.37826519e-02f, -2.11348990e-03f, -1.68032810e-01f, -4.50010747e-02f, -2.74979658e-02f, -5.93242003e-03f, 5.34061268e-02f, -1.02992684e-01f, 7.85913393e-02f, -2.74150334e-02f,
  -6.91321939e-02f, -1.82695705e-02f, 3.94951552e-02f, 1.36139216e-02f, 1.25876805e-02f, 4.77383919e-02f, 2.23330911e-02f, 4.64647124e-03f, -6.25792816e-02f, 3.33154276e-02f,
  -4.95913714e-01f, -4.35929239e-01f, -6.78201839e-02f, -1.10093571e-01f, -6.69187307e-02f, -2.69478839e-02f, -6.09931313e-02f, -5.28536923e-02f, -9.94539484e-02f, -8.87373909e-02f,
  -3.35067771e-02f, 1.33596724e-02f, -8.51677433e-02f, -6.62481189e-02f, 9.51439738e-02f, 2.46847700e-02f, -9.15475935e-02f, -8.91571715e-02f, -5.99048696e-02f, -4.58728857e-02f,
  -6.56324923e-02f, -7.85372555e-02f, 1.52425840e-01f, -3.42089646e-02f, -1.18999323e-03f, -4.37276587e-02f, -2.12954342e-01f, 3.21562514e-02f, -5.98300919e-02f, 1.18900388e-01f,
  -1.03826240e-01f, -2.59522527e-01f, 3.47049683e-01f, 4.85735685e-01f, -1.97340518e-01f, -4.04859513e-01f, -1.94438919e-01f, -3.45455766e-01f, 5.11452667e-02f, -3.71770740e-01f,
  -3.77471209e-01f, 2.66081423e-01f, -5.23332059e-01f, 3.32756937e-01f, 4.86296386e-01f, -7.58630931e-02f, 1.37263656e-01f, 3.41190882e-02f, 1.12329558e-01f, -1.05264438e-02f,
  2.08791524e-01f, 1.21338882e-01f, 3.30677509e-01f, 2.06602097e-01f, 9.87384096e-02f, 3.79561782e-01f, 5.72037458e-01f, 2.03279465e-01f, 5.57686985e-01f, 1.55695960e-01f,
  -1.85840547e-01f, -4.95918058e-02f, -8.05139318e-02f, -5.33406585e-02f, -8.75354633e-02f, -1.02141365e-01f, 5.82317933e-02f, 5.38917072e-03f, -3.78991431e-03f, -6.27596630e-03f,
  -8.44457671e-02f, 7.76818171e-02f, 1.81849808e-01f, 7.26212114e-02f, -7.42212161e-02f, 1.70001358e-01f, 5.21709174e-02f, -1.53173760e-01f, -9.75784883e-02f, -6.22562617e-02f,
  -1.88042149e-02f, -1.15112074e-01f, -4.30394895e-02f, 7.25501701e-02f, 9.80541259e-02f, -3.93937230e-02f, 1.69467747e-01f, 1.00017428e-01f, 9.63250250e-02f, 1.82902455e-01f,
  -7.40477368e-02f, 8.85548964e-02f, 1.87333450e-02f, 8.65237564e-02f, 1.12431385e-02f, 1.41759925e-02f, 3.66312712e-02f, 6.72844052e-03f, -5.01177534e-02f, -7.17369542e-02f,
  6.90060556e-02f, -1.20464731e-02f, -2.52729487e-02f, 3.16930190e-02f, 8.20930302e-03f, -2.58044302e-02f, -2.63662860e-02f, -2.03626081e-02f, -7.83722699e-02f, 5.05602583e-02f,
  -1.91480145e-02f, -1.18076494e-02f, 8.89119804e-02f, -5.87375537e-02f, -1.06470034e-01f, -3.59022953e-02f, 5.17615862e-02f, -3.42948958e-02f, -2.77158357e-02f, -3.96641269e-02f,
  -6.60050586e-02f, 3.51960570e-01f, -6.22693188e-02f, -1.63408980e-01f, 6.55452013e-02f, -2.58586016e-02f, 8.65693912e-02f, 4.65133181e-03f, 6.80748150e-02f, 6.05883019e-04f,
  -1.82035446e-01f, 2.03403048e-02f, -2.76356377e-02f, 2.92316061e-02f, 1.37569187e-02f, 2.20961981e-02f, 2.26480945e-04f, 4.25518192e-02f, 5.61114550e-02f, 5.86041100e-02f,
  -4.95205745e-02f, -1.37118548e-01f, 3.24091874e-02f, 4.04977724e-02f, -8.50609019e-02f, -6.58403859e-02f, -4.95536579e-03f, -6.88458458e-02f, 1.16748452e-01f, 7.39779398e-02f,
  -1.93472385e-01f, -5.36675453e-01f, -1.00090377e-01f, 2.50058532e-01f, -1.12646393e-01f, 8.96338522e-02f, 4.76806998e-01f, -2.94771284e-01f, -1.42518654e-01f, 5.26350457e-03f,
  2.81878144e-01f, -1.09050073e-01f, 5.23878373e-02f, 3.19460303e-01f, 2.65872538e-01f, 1.77811190e-01f, 2.54418254e-01f, 2.00158224e-01f, -1.49472862e-01f, -8.88380185e-02f,
  -1.59558132e-02f, 1.31350055e-01f, 2.29763135e-01f, -3.54548484e-01f, -3.63690332e-02f, -2.55653441e-01f, 5.46010174e-02f, -1.37927577e-01f, 9.26011801e-02f, 1.23194143e-01f,
  -4.78876680e-02f, -1.59336478e-01f, 8.73743519e-02f, -1.27585217e-01f, 1.39061064e-02f, 6.51581064e-02f, 3.80507894e-02f, 1.53581366e-01f, 4.19672839e-02f, -7.80324743e-04f,
  -6.71788752e-02f, -8.56935456e-02f, -6.61638901e-02f, 1.13933682e-02f, -8.38019699e-02f, -1.27939209e-01f, -9.38665271e-02f, 9.84051600e-02f, -3.30956429e-02f, 3.14932242e-02f,
  -4.30360623e-02f, 1.87900607e-02f, 7.84438401e-02f, 5.62839471e-02f, -1.19032068e-02f, -2.30772384e-02f, 7.69910887e-02f, 9.06852167e-03f, -7.91066438e-02f, -4.45061363e-02f,
  -5.06314598e-02f, -3.65051180e-02f, -8.82743299e-02f, -4.74397689e-02f, -2.09017680e-03f, 1.13326363e-01f, 1.58189218e-02f, 5.84499575e-02f, -3.38612916e-03f, 4.07171138e-02f,
  4.88286875e-02f, -8.95211846e-03f, -4.90620434e-02f, 3.07922438e-02f, 5.85514195e-02f, 2.52114832e-02f, 2.18151044e-02f, -8.24529454e-02f, -1.51827922e-02f, 4.03680913e-02f,
  3.40501182e-02f, 4.31784615e-03f, 4.70315164e-04f, 1.72605156e-03f, -2.87521072e-02f, 3.98063427e-03f, -3.64105776e-02f, 1.27218487e-02f, 2.86696069e-02f, 1.37918284e-02f,
  -2.95488238e-01f, -4.23166513e-01f, -2.33100858e-02f, -1.51358861e-02f, 4.92003262e-02f, -9.06218886e-02f, -6.12205677e-02f, -8.63219276e-02f, -1.32885054e-01f, -6.11481955e-03f,
  -5.16662672e-02f, 7.09051192e-02f, -1.17483325e-01f, 1.68048069e-02f, -4.67542186e-02f, -4.92709652e-02f, 5.99706806e-02f, 1.79339275e-02f, 4.92954999e-02f, -8.05129781e-02f,
  5.93112549e-03f, -7.26437420e-02f, 6.84576258e-02f, -9.67488363e-02f, 3.12603973e-02f, 7.75273666e-02f, -1.11895777e-01f, -4.16331030e-02f, -4.59036864e-02f, 1.82449743e-02f,
  2.41811275e-01f, -4.35836256e-01f, -3.40564072e-01f, -1.04805730e-01f, 2.31198668e-01f, 2.44020328e-01f, 1.10134818e-01f, -2.13264003e-01f, -4.10390526e-01f, -2.34782606e-01f,
  -5.76608721e-03f, 2.08127007e-01f, -2.32001603e-01f, 1.17377639e-01f, 6.10004067e-01f, -7.04734102e-02f, -1.06418496e-02f, 2.08473176e-01f, -1.62755162e-01f, -2.10107580e-01f,
  -1.03694871e-01f, 2.54671425e-01f, -7.97970667e-02f, -2.12943163e-02f, 1.37169123e-01f, -7.78135359e-02f, 2.58672684e-01f, 4.05302942e-02f, 2.24616259e-01f, 3.49851489e-01f,
  3.16085033e-02f, -1.47746488e-01f, -1.03910923e-01f, 5.17246686e-02f, 4.17888490e-03f, 5.82676195e-02f, 2.14149788e-01f, 2.29134962e-01f, 3.82639132e-02f, -4.60262597e-02f,
  1.95546269e-01f, 9.10478383e-02f, 2.28409134e-02f, 1.04537196e-01f, -2.39093765e-03f, -1.25426203e-01f, -1.05624236e-01f, -1.13969967e-01f, -1.24585845e-01f, -1.23123396e-02f,
  -1.98990569e-01f, -1.27505198e-01f, -1.86691862e-02f, 2.46762056e-02f, -9.76732150e-02f, -7.85252303e-02f, -4.49970067e-02f, 1.61954984e-02f, 3.59082520e-02f, -1.20532215e-01f,
  2.46965010e-02f, 1.05352372e-01f, -4.54342030e-02f, -1.35882022e-02f, 2.85281596e-04f, 5.46046644e-02f, 1.28306495e-02f, 3.97766270e-02f, 2.16899402e-02f, -4.62674908e-02f,
  -4.91783991e-02f, -1.93742160e-02f, -2.99514569e-02f, 4.41099331e-02f, 4.70169485e-02f, -5.84183522e-02f, 6.08275272e-02f, 8.72272104e-02f, -1.62242204e-01f, 2.82823366e-05f,
  5.33908308e-02f, 2.31629871e-02f, 4.06387867e-03f, 5.26379934e-03f, -1.11589450e-02f, 2.02816762e-02f, -1.17357550e-02f, -7.15032443e-02f, -4.47039008e-02f, 1.03507310e-01f,
  -4.40391302e-02f, -2.65395641e-01f, -1.76173657e-01f, 4.20346595e-02f, 2.83270404e-02f, 7.19022974e-02f, 7.52338469e-02f, -4.38918769e-02f, 5.19999675e-02f, -2.87679043e-02f,
  4.73187752e-02f, 5.47307916e-02f, 5.18978499e-02f, 7.26802424e-02f, 1.37487501e-01f, -2.21681967e-01f, 4.05780524e-02f, 9.84149706e-03f, 2.12252568e-02f, -3.16143110e-02f,
  2.13947818e-02f, 3.71266641e-02f, 1.55869827e-01f, -5.13132475e-02f, -1.79583337e-02f, 7.47310445e-02f, 2.25642566e-02f, 2.61895992e-02f, 6.81542158e-02f, 3.57526317e-02f,
  -6.90683648e-02f, -1.98347554e-01f, 3.43395263e-01f, -2.43710384e-01f, 1.44885600e-01f, 1.90844119e-01f, 2.11868465e-01f, -1.93648040e-01f, -2.99861133e-01f, -3.07504296e-01f,
  -1.52445972e-01f, 1.73101559e-01f, 3.65810513e-01f, -3.55136335e-01f, 5.73220432e-01f, 2.29676202e-01f, -2.69234449e-01f, -1.74384519e-01f, -4.18532602e-02f, -1.39967844e-01f,
  -7.14644864e-02f, -2.74667889e-01f, 3.24723452e-01f, -3.23115200e-01f, -9.24806744e-02f, -1.89136192e-01f, -6.95260763e-02f, 2.80761987e-01f, -2.99718916e-01f, 9.68237743e-02f,
  -1.42546877e-01f, -2.38255560e-01f, 2.22952347e-02f, -3.85073349e-02f, -5.01061194e-02f, 5.54520115e-02f, 8.11334923e-02f, 2.00779334e-01f, 5.84992813e-03f, 4.11678292e-02f,
  -3.50156426e-03f, 3.99465626e-03f, -1.60946563e-01f, 2.48808898e-02f, -9.95965227e-02f, -6.12301491e-02f, 5.13526909e-02f, -7.27691278e-02f, 6.01125695e-02f, 9.55440328e-02f,
  8.54031444e-02f, 2.70561744e-02f, -1.73333455e-02f, -5.11763282e-02f, 1.05846994e-01f, -1.85285196e-01f, 4.96698208e-02f, 1.95191011e-01f, -5.90373389e-02f, -3.89100239e-02f,
  1.24220261e-02f, 4.09200266e-02f, 2.81065982e-02f, -5.13536222e-02f, 2.24836986e-03f, -1.16443790e-01f, -4.74342257e-02f, 1.56151997e-02f, -1.02037387e-02f, 2.17630807e-02f,
  -2.23409180e-02f, -2.26552263e-02f, -4.00585718e-02f, -9.51799080e-02f, -1.09566167e-01f, -1.06924355e-01f, 8.88141990e-02f, -4.56766300e-02f, -4.69164066e-02f, -4.24350835e-02f,
  2.65484657e-02f, 2.60724891e-02f, 8.43048543e-02f, 4.62757275e-02f, -3.65354382e-02f, 8.17158520e-02f, -9.75238904e-02f, 6.50621206e-02f, -3.18208337e-02f, 1.72786430e-01f,
  -2.37348855e-01f, -3.34622920e-01f, -1.14478264e-02f, -1.09562807e-01f, 5.79953601e-04f, -3.37844416e-02f, 2.92361225e-03f, -1.01333857e-01f, -4.26382013e-02f, -3.16175935e-03f,
  -1.36411726e-01f, 5.21395244e-02f, -3.30928154e-02f, -3.34672779e-02f, -3.01023037e-03f, -5.88283837e-02f, 2.44153682e-02f, -3.99689972e-02f, 2.55243145e-02f, -1.07259102e-01f,
  8.08485691e-03f, -2.59193536e-02f, 4.37765606e-02f, -1.21332057e-01f, -2.76587177e-02f, 1.68130186e-03f, -3.29097509e-02f, -3.98609415e-02f, 9.80943814e-02f, 2.25890353e-02f,
  1.88027129e-01f, 3.33701849e-01f, 2.10687041e-01f, -3.00135553e-01f, -2.16853827e-01f, -2.26542473e-01f, -3.33481789e-01f, 7.54708797e-02f, 1.15610085e-01f, 2.67665744e-01f,
  -3.00986201e-01f, 3.16662371e-01f, -3.27359140e-02f, -1.14492804e-01f, -3.26878726e-01f, -1.58334389e-01f, -4.02251840e-01f, -2.53818840e-01f, -6.10323809e-02f, -3.08739513e-01f,
  -2.05849931e-01f, -5.05641222e-01f, -2.90820062e-01f, -2.53412336e-01f, -1.03443265e-01f, 1.58346519e-01f, -2.28930190e-01f, -3.51702645e-02f, -4.84089851e-02f, -4.30766344e-02f,
  6.55531324e-03f, 1.82875350e-01f, 1.79902762e-01f, 1.26457825e-01f, 2.83814239e-04f, 6.50478750e-02f, -5.85949887e-03f, -5.95784411e-02f, -4.50442024e-02f, 5.06217182e-02f,
  3.96237150e-02f, 2.20714882e-02f, -2.83127371e-03f, -4.46811654e-02f, 5.37938178e-02f, 1.37333617e-01f, -1.93469580e-02f, 4.24095877e-02f, 8.55362937e-02f, 4.00032103e-03f,
  -6.09806441e-02f, 1.39811859e-01f, -3.63517776e-02f, -4.97580580e-02f, -2.27746498e-02f, 2.17395779e-02f, 4.63155704e-03f, 2.48055384e-02f, 1.56077716e-04f, 3.07841785e-02f,
  -6.58496690e-04f, -7.16180503e-02f, -3.55285704e-02f, 6.39018267e-02f, -6.17376342e-02f, 1.27045931e-02f, -4.60855737e-02f, 3.93037461e-02f, -1.56929623e-02f, 9.69263818e-03f,
  2.51397816e-03f, 7.48476759e-02f, -6.91697299e-02f, -7.86815733e-02f, -9.14297625e-02f, 7.52661973e-02f, -3.20913233e-02f, 1.60380062e-02f, -1.28127158e-01f, 4.81222160e-02f,
  -7.09519684e-02f, -1.18183784e-01f, -7.67286569e-02f, -8.51281956e-02f, -3.97255942e-02f, -8.62951204e-03f, 6.24021376e-03f, 1.55979082e-01f, 1.28243631e-02f, -1.58012420e-01f,
  -7.96275064e-02f, 1.97094213e-02f, 6.24859706e-04f, 4.49104309e-02f, 1.05996057e-02f, 6.58213794e-02f, 1.36708247e-03f, 6.41312525e-02f, -5.86729087e-02f, -6.97077364e-02f,
  1.13828508e-02f, -1.40027972e-02f, -2.34031864e-02f, -2.06098463e-02f, -6.15756400e-02f, -3.65079790e-02f, -1.17480397e-01f, -1.92624014e-02f, -9.37048122e-02f, 5.00742272e-02f,
  2.58141570e-02f, -3.26005705e-02f, -1.96159687e-02f, -9.40847024e-02f, -5.83105274e-02f, -2.26615630e-02f, 1.12518795e-01f, 1.03097767e-01f, -1.49398208e-01f, -6.37592822e-02f,
  -5.55863678e-02f, -2.85668612e-01f, -3.56302321e-01f, -2.40691558e-01f, 1.23706892e-01f, 2.52518147e-01f, -1.96358398e-01f, -5.12867644e-02f, -3.37759078e-01f, 2.07198307e-01f,
  1.79586664e-01f, -4.84283447e-01f, -1.70162052e-01f, -1.56443194e-01f, -1.68901294e-01f, -2.16083884e-01f, 1.50384024e-01f, 4.86089215e-02f, -1.76834673e-01f, -8.07560533e-02f,
  -8.02025571e-02f, 2.40485191e-01f, -1.59948230e-01f, 1.88751668e-01f, 3.20367073e-03f, -6.64365292e-02f, 3.34813535e-01f, -1.72893688e-01f, 2.30697393e-01f, 1.16979398e-01f,
  1.93052273e-02f, -1.48929045e-01f, -7.57422596e-02f, 4.89644669e-02f, 1.85982317e-01f, 1.81159824e-01f, 6.40302002e-02f, -1.01740636e-01f, -1.14791416e-01f, -3.91154066e-02f,
  -3.76156829e-02f, -1.69832155e-01f, -4.78823707e-02f, -3.36876847e-02f, 6.20615706e-02f, -8.00504908e-02f, -8.95473287e-02f, 6.56038001e-02f, -2.03034624e-01f, -1.55639499e-01f,
  -1.62372753e-01f, -3.60348285e-03f, 7.39385560e-02f, 9.15287137e-02f, -8.85073319e-02f, -1.52567044e-01f, 2.24093348e-02f, -1.00115143e-01f, 1.03891715e-01f, -4.36365306e-02f,
  7.33622015e-02f, 1.28670394e-01f, 7.96132982e-02f, 3.44688855e-02f, 2.23779678e-02f, 7.18617886e-02f, 2.95139253e-02f, -1.16439094e-03f, -8.90189335e-02f, 3.84901837e-02f,
  -5.90848317e-03f, -1.60969481e-01f, -4.89278957e-02f, 7.62947053e-02f, 1.01580903e-01f, -9.28614289e-03f, -1.39199886e-02f, 1.20396027e-02f, 5.36932435e-04f, -1.48275848e-02f,
  -7.27222709e-04f, 1.74548328e-02f, 1.85742211e-02f, 3.34969088e-02f, 2.82464875e-03f, -6.48095906e-02f, 1.36763155e-01f, -6.73821494e-02f, 4.59283404e-02f, 1.06760576e-01f,
  1.64275959e-01f, 7.49977306e-02f, -6.36495203e-02f, -1.50263039e-02f, -6.72541857e-02f, 1.33273453e-01f, 4.03759927e-02f, -3.20229866e-02f, 7.82416537e-02f, 1.75466063e-04f,
  4.52938341e-02f, 2.94798836e-02f, 2.30003610e-01f, 2.11598706e-02f, 8.62640142e-02f, 1.17276281e-01f, 3.35996747e-02f, 3.90480692e-03f, 9.60369781e-02f, 1.11223003e-02f,
  1.01891764e-01f, -1.53071259e-03f, -2.82084998e-02f, 2.64873244e-02f, 9.09394249e-02f, 2.09664870e-02f, 3.63467261e-02f, 6.18700637e-03f, 4.08457257e-02f, -6.52752519e-02f,
  -4.39779401e-01f, 3.03547561e-01f, 3.48692685e-01f, -1.20103233e-01f, 5.38856387e-01f, 3.05112898e-01f, 8.20227116e-02f, 3.99210364e-01f, 4.38662380e-01f, -1.11565299e-01f,
  -5.40503003e-02f, -1.35144353e-01f, 5.65762147e-02f, 5.93290851e-03f, -3.11073989e-01f, -5.33689857e-02f, -1.36790544e-01f, -1.79102913e-01f, 3.10458392e-01f, -1.83094777e-02f,
  -1.89013977e-03f, -1.53408855e-01f, -5.25300093e-02f, 1.17436484e-01f, 7.77509660e-02f, -2.71200705e-02f, -3.52815598e-01f, 2.32171208e-01f, -1.95111424e-01f, 7.14659225e-03f,
  -2.24774510e-01f, 5.64245470e-02f, -1.82596385e-01f, -1.11201487e-01f, -7.33460933e-02f, -8.27554166e-02f, -1.87860712e-01f, -1.91179607e-02f, -3.81930657e-02f, 1.25605147e-02f,
  -7.34479576e-02f, -1.73037313e-02f, 5.53804524e-02f, 1.77338980e-02f, 8.61315206e-02f, 3.18760946e-02f, 1.54174179e-01f, 1.27203420e-01f, 1.45993322e-01f, 1.09724201e-01f,
  1.54668570e-01f, 1.11915037e-01f, 1.05962548e-02f, -5.75877391e-02f, 5.07137971e-03f, 1.19876064e-01f, 1.21297743e-02f, -9.64024588e-02f, -6.35701641e-02f, -7.39770057e-03f,
  4.70449217e-02f, -3.63173196e-03f, 2.11986769e-02f, -3.42247188e-02f, 3.69680002e-02f, 5.64087257e-02f, -1.25939189e-03f, -7.17239827e-02f, -4.35403846e-02f, -3.32561657e-02f,
  -1.10771349e-02f, -8.91359001e-02f, 1.56974092e-01f, 4.88141924e-02f, 9.07836203e-03f, -7.12558161e-03f, -1.02057837e-01f, 3.47655937e-02f, -1.38870012e-02f, -5.44057935e-02f,
  4.22846116e-02f, -1.01218112e-02f, 2.60329004e-02f, -2.06203535e-02f, -8.92135948e-02f, 9.93253663e-02f, 6.15737028e-02f, 1.23088457e-01f, 3.10828816e-02f, 2.47853529e-03f,
  -4.76589471e-01f, -3.46841186e-01f, -2.17244044e-01f, -1.23246253e-01f, -8.22835788e-02f, -6.48441762e-02f, -1.06326386e-01f, -9.92875267e-03f, -8.48473683e-02f, 1.63799580e-02f,
  -1.95745472e-03f, -5.23749255e-02f, -1.08554333e-01f, -4.80414070e-02f, -1.30809158e-01f, 1.36330370e-02f, -6.99552223e-02f, -6.60142079e-02f, -2.28858277e-01f, -1.00739226e-01f,
  -9.37262103e-02f, -7.94594362e-02f, -4.45121340e-02f, -1.38629563e-02f, -5.57049140e-02f, -1.15225405e-01f, -6.92854226e-02f, -4.69530821e-02f, 1.07570263e-02f, 4.94759576e-03f,
  3.95254970e-01f, -1.93285525e-01f, 1.87395856e-01f, 1.81218594e-01f, 1.70228839e-01f, -1.51113644e-01f, -1.38317958e-01f, 2.36398071e-01f, -6.49488270e-02f, -4.41434681e-01f,
  7.01135844e-02f, -4.28745061e-01f, 8.75114724e-02f, 1.38311118e-01f, 2.23647818e-01f, 2.03286082e-01f, 2.24840268e-01f, -1.58165008e-01f, 3.59538823e-01f, 3.88351977e-01f,
  3.03430974e-01f, 2.09999353e-01f, 3.91482383e-01f, 1.93469912e-01f, 3.42026234e-01f, 1.06250592e-01f, 9.15150270e-02f, 3.12244669e-02f, -1.26390859e-01f, -2.37274483e-01f,
  1.33360073e-01f, 2.52567977e-01f, 2.13703990e-01f, -1.33174717e-01f, 2.60912865e-01f, -1.07701525e-01f, -9.40286219e-02f, -1.21284373e-01f, 5.43989837e-02f, -1.80206243e-02f,
  -1.46972612e-01f, -2.88855769e-02f, -1.81204658e-02f, -4.09469381e-02f, 3.56748365e-02f, 1.35089997e-02f, 1.32896557e-01f, 1.32570758e-01f, -7.28083178e-02f, 1.03260741e-01f,
  1.09068669e-01f, -1.01193056e-01f, -1.64511632e-02f, -3.36365104e-02f, 4.82418500e-02f, -4.53778505e-02f, -1.41311511e-01f, -1.17596783e-01f, -9.07451063e-02f, -6.49592951e-02f,
  2.49715801e-02f, 1.10690212e-02f, 3.51617113e-03f, 7.75208771e-02f, -1.28128184e-02f, 1.05909906e-01f, -7.74797201e-02f, 1.29894987e-02f, 7.93589801e-02f, -5.69009595e-03f,
  -4.83667143e-02f, 1.00427762e-01f, 1.51607106e-02f, -6.93645999e-02f, -5.88231115e-03f, 4.49549686e-03f, -5.30919656e-02f, -6.51202276e-02f, 1.40834702e-02f, 7.79378116e-02f,
  -7.64822587e-03f, -7.96167925e-02f, 7.62381107e-02f, -9.82687995e-03f, -1.46935791e-01f, -2.57656928e-02f, 4.49416712e-02f, 2.19842084e-02f, 1.19467124e-01f, -4.32330556e-02f,
  2.99746008e-03f, 4.51714024e-02f, 1.17321208e-01f, -1.74735308e-01f, 5.65188937e-02f, 1.32774964e-01f, -3.51106515e-03f, 2.90886685e-02f, -3.79667170e-02f, 9.90328789e-02f,
  -7.17889965e-02f, -3.61195318e-02f, -2.86641698e-02f, 8.51526782e-02f, -5.36717437e-02f, 4.08418886e-02f, -1.67975292e-01f, -1.82951137e-01f, -6.00197576e-02f, -1.79584660e-02f,
  -4.37421724e-02f, 1.87578779e-02f, -5.55316247e-02f, 8.16334262e-02f, -8.01680759e-02f, -9.37967077e-02f, -7.68539682e-02f, -6.64318576e-02f, 1.33078154e-02f, -6.60179257e-02f,
  -5.05336344e-01f, 2.70454943e-01f, -1.66509032e-01f, 3.76832306e-01f, -2.22677737e-01f, -6.45417646e-02f, 2.55876362e-01f, 1.50344595e-01f, 1.94162473e-01f, 4.16783214e-01f,
  4.37018305e-01f, 6.29674792e-02f, 2.80986071e-01f, 5.02935171e-01f, -5.12995645e-02f, 2.85525024e-01f, 1.48925498e-01f, 1.97286576e-01f, 8.79367515e-02f, -1.59252927e-01f,
  -9.50137526e-02f, 2.62072086e-01f, 1.07084319e-01f, 1.33421281e-02f, -5.40411621e-02f, 3.61944996e-02f, 1.36222601e-01f, 3.76473255e-02f, 2.10951790e-01f, 1.56548083e-01f,
  5.69969378e-02f, 2.77638346e-01f, -1.31341696e-01f, -6.87704533e-02f, -9.27789956e-02f, -1.79014102e-01f, -9.75895599e-02f, -1.77982189e-02f, 5.08256257e-02f, 3.82522270e-02f,
  -6.99890330e-02f, 1.95172373e-02f, 1.34997532e-01f, -1.55681735e-02f, -5.52248247e-02f, 6.90620542e-02f, 4.78429422e-02f, -4.33160588e-02f, 1.67487524e-02f, 4.98946086e-02f,
  -9.59104486e-03f, -7.16585517e-02f, -1.36896642e-02f, 1.36984095e-01f, 3.31043266e-02f, 4.19117510e-02f, -3.66819128e-02f, -6.90032169e-02f, 5.04130237e-02f, 7.70508349e-02f,
  5.95917776e-02f, -3.19320187e-02f, -5.20497635e-02f, -2.42393855e-02f, 7.27299973e-02f, 3.61921825e-02f, 2.38084681e-02f, 1.10979751e-02f, 3.30843739e-02f, 6.58759102e-02f,
  -5.25901467e-02f, -4.71570641e-02f, 3.27536575e-02f, -1.97361037e-02f, 8.04193914e-02f, -5.40780872e-02f, -1.40482157e-01f, 7.22772479e-02f, -1.30075231e-01f, 4.21440192e-02f,
  1.81309894e-01f, 3.56882629e-05f, 1.09348044e-01f, -8.27797055e-02f, 5.17142341e-02f, 9.40389261e-02f, 6.73996806e-02f, 5.73125668e-03f, 1.25069216e-01f, -6.19505309e-02f,
  1.88240975e-01f, 4.24722761e-01f, 7.70560130e-02f, -2.14859704e-03f, 6.26658052e-02f, -5.06333783e-02f, 2.08485629e-02f, -8.63189921e-02f, 1.96311668e-01f, 6.09066291e-03f,
  -4.98466529e-02f, -6.54021800e-02f, -8.20799470e-02f, -3.84201892e-02f, -4.39404175e-02f, 1.14482842e-01f, 8.43293890e-02f, 9.87916589e-02f, 6.47551715e-02f, 3.50818634e-02f,
  1.08889841e-01f, 5.50489873e-02f, -8.93686805e-03f, 4.81140167e-02f, -5.11658788e-02f, 1.60462603e-01f, 3.33045013e-02f, -5.57928905e-03f, 3.19835842e-02f, 4.60178852e-02f,
  1.10004179e-01f, -3.90421510e-01f, -3.66561711e-01f, -2.94894964e-01f, 1.38102323e-01f, -5.18285215e-01f, -1.44913480e-01f, -2.92022943e-01f, -1.51916131e-01f, -1.55438066e-01f,
  -7.86696300e-02f, 2.46620864e-01f, 3.54889661e-01f, -4.35198277e-01f, -1.56177059e-01f, 9.88358110e-02f, -5.28057218e-01f, -3.00895303e-01f, 4.67218421e-02f, -1.48975760e-01f,
  -1.91504061e-01f, -1.41930670e-01f, -1.69012100e-01f, -1.33866534e-01f, -1.49851114e-01f, -3.99325788e-02f, 1.68258712e-01f, 3.17785382e-01f, -3.82764161e-01f, 1.25867441e-01f,
  -1.48268014e-01f, 1.73000351e-01f, -1.10534141e-02f, -4.12681662e-02f, -1.57431915e-01f, 6.93601593e-02f, 6.58660308e-02f, 1.49686158e-01f, 8.14642310e-02f, -7.78874680e-02f,
  1.06490001e-01f, 8.29438940e-02f, -1.14576958e-01f, 1.86585113e-01f, 4.87598181e-02f, -4.38985452e-02f, -6.59701228e-02f, -1.07843071e-01f, -5.39191291e-02f, 2.22488474e-02f,
  -3.78254987e-02f, -1.33081019e-01f, -6.89045414e-02f, -3.97798270e-02f, 7.12387785e-02f, -9.85985436e-03f, -8.47343057e-02f, 7.98454508e-02f, -6.18690513e-02f, -9.60239992e-02f,
  6.91119488e-03f, 7.54802972e-02f, 1.68172177e-02f, -5.41727468e-02f, 5.36217242e-02f, 5.20813428e-02f, 5.00880107e-02f, -6.95645204e-03f, 5.29286675e-02f, 2.11012233e-02f,
  -1.29313041e-02f, 2.31329296e-02f, 6.44265860e-02f, -8.35035145e-02f, 1.15248132e-02f, 6.25208020e-02f, 7.14388564e-02f, 4.31687981e-02f, -1.15501739e-01f, -7.93422535e-02f,
  8.70258883e-02f, -6.37298301e-02f, 3.29359286e-02f, 4.21058200e-02f, -7.18300343e-02f, -1.19895618e-02f, 3.73411365e-03f, -3.17559168e-02f, -6.37114421e-02f, 1.09170496e-01f,
  -1.31281048e-01f, -7.89531544e-02f, -4.68619056e-02f, 4.75533940e-02f, 5.98894544e-02f, -7.01983869e-02f, -3.10702883e-02f, -1.78779289e-01f, -8.31682906e-02f, -5.42893857e-02f,
  -1.41785905e-01f, 2.29780674e-02f, -8.36406425e-02f, 1.03811659e-02f, -6.33475259e-02f, -1.33034930e-01f, 1.03238977e-01f, -3.95462289e-02f, -6.42637238e-02f, -5.69619313e-02f,
  -1.07447421e-02f, 1.32620305e-01f, 6.22507930e-02f, -1.76270064e-02f, -4.11435477e-02f, 5.34499846e-02f, 7.45502114e-02f, 2.03091316e-02f, 1.49851501e-01f, -5.96342832e-02f,
  -2.03142203e-02f, 7.38236913e-03f, -3.78762573e-01f, -2.73221076e-01f, 1.59071386e-01f, -3.06041092e-02f, -5.30727766e-02f, -5.37721999e-02f, -1.53575301e-01f, 2.32321128e-01f,
  2.16328390e-02f, -5.53153493e-02f, -2.53749266e-02f, -2.21179187e-01f, -5.46534121e-01f, -3.41486096e-01f, -2.83533514e-01f, -1.26429737e-01f, -9.40725356e-02f, 1.38948664e-01f,
  -1.61006927e-01f, 1.52802750e-01f, -3.85950118e-01f, 2.94429660e-01f, 4.50892374e-02f, 1.92705318e-01f, 1.33047745e-01f, 1.65347308e-01f, 4.20223437e-02f, 2.79790107e-02f,
  -1.46838337e-01f, -7.80396089e-02f, -2.75816265e-02f, 1.16133466e-02f, -2.70916149e-02f, 6.47690073e-02f, 1.18463218e-01f, -1.19892240e-01f, -7.79595375e-02f, -6.29177168e-02f,
  8.39693174e-02f, 4.59078960e-02f, 5.60303144e-02f, 2.85072788e-03f, 5.59788197e-02f, 7.17637613e-02f, -7.71638677e-02f, -7.38249645e-02f, -2.54662875e-02f, -1.14669345e-01f,
  -1.21204875e-01f, -8.62106308e-02f, 5.30957356e-02f, -1.13953035e-02f, 6.38856515e-02f, -1.73121691e-02f, -2.59910431e-02f, -4.25602272e-02f, 5.20479754e-02f, -5.51482625e-02f,
  2.35910099e-02f, 1.32046103e-01f, 4.98186331e-03f, -5.74527010e-02f, 3.26245688e-02f, 6.57935021e-03f, -3.28131877e-02f, -8.57685506e-03f, 2.18635593e-02f, 1.03371605e-01f,
  5.72759546e-02f, 2.99919546e-02f, 3.27664092e-02f, -4.19674292e-02f, -2.22771373e-02f, -2.65003946e-02f, 1.69099141e-02f, 1.41147286e-01f, 1.87185798e-02f, -1.92880005e-01f,
  5.28751612e-02f, 3.69714871e-02f, -2.66265459e-02f, 3.51251960e-02f, -7.76850507e-02f, 4.70656119e-02f, 1.08108513e-01f, -6.75324500e-02f, -9.44999829e-02f, -4.70527783e-02f,
  3.36687779e-03f, 2.15892300e-01f, -1.48333646e-02f, 4.85337488e-02f, 7.87448883e-03f, -3.98711767e-03f, -3.27302814e-02f, -6.59476668e-02f, -7.76596367e-02f, 9.62670818e-02f,
  7.12471753e-02f, 6.53769597e-02f, 1.77896142e-01f, 2.67613716e-02f, 4.95020859e-03f, -5.71466349e-02f, 1.34165511e-01f, 1.01483934e-01f, 5.49487211e-02f, 6.24614470e-02f,
  4.56541851e-02f, 1.51072413e-01f, -2.29762141e-02f, 6.34799004e-02f, 8.83679837e-02f, 4.58531193e-02f, 1.13545537e-01f, -4.85891700e-02f, -3.29349632e-03f, -1.40194474e-02f,
  4.18077737e-01f, -2.43527517e-01f, 1.12905644e-01f, 3.53922307e-01f, 5.34886606e-02f, -2.97185600e-01f, -3.20201486e-01f, 5.83243370e-02f, 5.75988770e-01f, -3.97552848e-01f,
  -1.63552925e-01f, 1.08383790e-01f, -1.32409215e-01f, -1.58344984e-01f, 2.34224811e-01f, 1.87352106e-01f, -4.29529808e-02f, -4.23421338e-03f, 3.08020294e-01f, -8.21160078e-02f,
  1.31105155e-01f, -3.41446102e-01f, -1.14258833e-01f, -4.71114457e-01f, -2.23804742e-01f, 6.34688232e-03f, -1.49510220e-01f, -1.86117500e-01f, -2.95176744e-01f, -4.02477533e-02f,
  1.24625340e-01f, 1.03448540e-01f, -1.68205798e-01f, 5.31191425e-03f, 3.25845964e-02f, -1.03564337e-01f, -4.22721282e-02f, -1.13276854e-01f, 1.55980453e-01f, 7.42408857e-02f,
  -4.75407019e-03f, 2.13309377e-02f, -2.72544846e-02f, -8.26902129e-03f, 8.07224512e-02f, 1.13230869e-01f, 1.68762892e-01f, 5.67010976e-02f, -3.98322530e-02f, 3.18753980e-02f,
  5.30317146e-03f, 1.13655448e-01f, 1.01651527e-01f, 5.20959869e-02f, 3.60713229e-02f, 2.28212271e-02f, 2.56667715e-02f, -2.41224486e-02f, -4.64375578e-02f, 1.20337881e-01f,
  -1.82116732e-01f, 9.82807670e-03f, -9.91190374e-02f, 8.56484324e-02f, 2.66720308e-03f, 1.68719962e-02f, 1.88552979e-02f, 5.40363090e-03f, 9.03615057e-02f, 3.28189954e-02f,
  2.76084221e-03f, 6.22268394e-02f, 1.18165746e-01f, 6.54289052e-02f, -4.52228859e-02f, 1.24463752e-01f, -6.70419857e-02f, 9.42823514e-02f, 1.99618433e-02f, 5.39773256e-02f,
  -6.04093410e-02f, -5.08999676e-02f, 2.75855362e-02f, 3.54790315e-02f, -9.41837430e-02f, 4.51410376e-02f, -7.67067149e-02f, 5.45357466e-02f, 7.33970627e-02f, -1.15485571e-01f,
  -1.29310921e-01f, -3.79967749e-01f, -4.87426482e-02f, 1.05004171e-02f, 3.35424906e-03f, -6.39834860e-03f, 1.76800247e-02f, 8.45346674e-02f, -3.48320268e-02f, -4.59698215e-02f,
  -2.09545568e-02f, 4.37304154e-02f, 3.28251049e-02f, 8.43965486e-02f, -9.43139195e-02f, -4.66399565e-02f, -7.50595238e-04f, 2.66441964e-02f, -1.50116786e-01f, 2.82218065e-02f,
  -8.25688094e-02f, -1.44711956e-02f, 6.43443167e-02f, 1.51024051e-02f, 5.49799837e-02f, -8.22258927e-03f, -1.35210771e-02f, 4.47377600e-02f, 1.61587173e-04f, 2.66109016e-02f,
  3.07792246e-01f, -2.63440996e-01f, 1.54022142e-01f, 6.36334047e-02f, 3.53363067e-01f, 4.60530490e-01f, 4.86027539e-01f, 1.74452871e-01f, 6.15429878e-01f, -3.42636853e-01f,
  -2.48126626e-01f, -1.66547358e-01f, 8.41688737e-03f, -2.55298376e-01f, 6.05577588e-01f, 1.76611573e-01f, 1.15908496e-01f, -1.30219879e-02f, 1.32383138e-01f, -9.70387310e-02f,
  1.30520519e-02f, -2.37389460e-01f, -1.91795647e-01f, -3.23639631e-01f, -2.48913094e-01f, -2.34331518e-01f, -4.26981091e-01f, 1.39692545e-01f, -4.21963662e-01f, 1.88516542e-01f,
  -4.49927174e-04f, -1.34662921e-02f, -9.29725617e-02f, -5.30546717e-02f, 4.04988118e-02f, 6.95259646e-02f, 3.17344479e-02f, 1.24836594e-01f, 1.45884708e-01f, 1.38620625e-03f,
  -4.46515046e-02f, -5.27307801e-02f, -7.29032084e-02f, 5.85913733e-02f, 6.49410114e-02f, -1.70158416e-01f, -1.26785010e-01f, -1.23782314e-01f, -6.97118938e-02f, -4.06208076e-02f,
  -1.16093956e-01f, -6.98249340e-02f, -7.91436806e-02f, -6.67797402e-02f, -7.32420832e-02f, -7.31895417e-02f, -3.45645915e-03f, -3.06348540e-02f, -5.63682392e-02f, 8.45485479e-02f,
  2.07345020e-02f, 1.91143602e-01f, -1.55314878e-02f, -7.41083622e-02f, 5.92995360e-02f, -1.07821180e-02f, -2.07824223e-02f, -7.19039217e-02f, 4.73359525e-02f, -1.13509245e-01f,
  -1.37145752e-02f, -2.96800733e-02f, 3.03204805e-02f, -1.04120029e-02f, -1.93801057e-02f, 4.17270027e-02f, 1.12021528e-03f, 1.15702478e-02f, 7.57416058e-03f, -1.68353301e-02f,
  8.09605494e-02f, 6.30340874e-02f, -6.66321740e-02f, -4.84582148e-02f, 4.54350375e-02f, -3.72507796e-02f, -4.57957387e-02f, -1.73599329e-02f, -3.94694656e-02f, 3.46940011e-02f,
  1.45967871e-01f, 1.41327351e-01f, -5.68352938e-02f, -2.00620696e-01f, -5.34693897e-03f, 4.11726860e-03f, 1.00241646e-01f, -3.95948291e-02f, 7.47279823e-02f, 5.18226102e-02f,
  -7.48145133e-02f, -5.99014834e-02f, 1.95083655e-02f, -4.56326827e-02f, -1.08432338e-01f, 1.07514216e-02f, -2.58776881e-02f, 2.19204929e-03f, 1.57042593e-01f, -6.40569031e-02f,
  -1.46979406e-01f, -2.90794410e-02f, -3.40049677e-02f, -4.42765877e-02f, -1.42768383e-01f, -3.85894813e-02f, 6.04771674e-02f, -5.92711754e-02f, 2.03980878e-02f, 7.05972463e-02f,
  -5.11728406e-01f, 3.39301437e-01f, -2.62719661e-01f, -1.40875429e-01f, -2.17448771e-01f, -3.74879986e-01f, -2.42429703e-01f, -7.14643225e-02f, 2.32899785e-01f, 2.79922962e-01f,
  1.09387912e-01f, 1.93501428e-01f, 3.17246407e-01f, -1.76251438e-02f, -3.50795656e-01f, 2.72758871e-01f, -3.18940908e-01f, -1.12847835e-02f, 2.47812252e-02f, -8.44896063e-02f,
  -5.67805097e-02f, 3.71144004e-02f, -2.00389132e-01f, 1.45043820e-01f, -3.39998871e-01f, -1.75473362e-01f, -1.90467328e-01f, -5.78272752e-02f, -2.53342479e-01f, -1.42178088e-01f,
  -3.60168159e-01f, -1.04937717e-01f, -1.83371171e-01f, -1.86705023e-01f, -1.60183191e-01f, -8.17734823e-02f, -1.76843643e-01f, -1.56877618e-02f, -9.18979943e-03f, -2.78557930e-02f,
  2.21565925e-02f, 3.23025174e-02f, 5.56106083e-02f, 1.58292890e-01f, -8.88233408e-02f, -6.22957386e-02f, -9.46687981e-02f, -2.05933720e-01f, -5.76166920e-02f, -1.28461912e-01f,
  2.51887795e-02f, -7.24292547e-02f, -1.53612405e-01f, -3.19369026e-02f, -2.23747581e-01f, -9.94416475e-02f, -7.09385872e-02f, -1.09294258e-01f, -1.55047074e-01f, -1.42445073e-01f,
  1.75382718e-02f, -2.61544599e-03f, -3.06105781e-02f, 8.68210346e-02f, 1.56902391e-02f, 5.60605936e-02f, 1.77820288e-02f, 4.53232042e-02f, -6.90723304e-03f, -5.15644141e-02f,
  -2.48830300e-02f, -6.92428499e-02f, -2.56124213e-02f, -5.72043993e-02f, 2.32400792e-03f, -8.87196139e-03f, -4.75520864e-02f, -2.22556908e-02f, -4.32164036e-03f, -5.34162708e-02f,
  -2.11583823e-02f, -1.28033785e-02f, 6.27619848e-02f, -4.82031889e-02f, -6.22786544e-02f, -4.44878191e-02f, -6.95027236e-04f, -1.06400158e-03f, -4.51185666e-02f, -1.15167029e-01f,
  -4.60556120e-01f, -3.31749260e-01f, -1.19131453e-01f, -3.67211998e-02f, -3.99318151e-02f, -4.15377766e-02f, 3.27713788e-02f, -4.23891656e-02f, -2.08677799e-01f, 2.60952767e-02f,
  -1.05456766e-02f, 5.29391319e-03f, -6.31226599e-02f, 2.55595464e-02f, 3.79927494e-02f, 7.15055037e-03f, -3.12203765e-02f, 3.75806279e-02f, -1.55038327e-01f, -1.27529755e-01f,
  4.72275726e-02f, 1.11689284e-01f, -2.52471454e-02f, -7.61093721e-02f, -8.85210037e-02f, -1.31164089e-01f, 6.03505820e-02f, -6.20425381e-02f, -1.56734273e-01f, 7.81359598e-02f,
  2.03546047e-01f, -1.00372797e-02f, -2.77339548e-01f, -1.79682478e-01f, -2.89329998e-02f, -1.57006964e-01f, -6.07371747e-01f, -7.20558455e-03f, -2.98182011e-01f, -1.65054053e-01f,
  -3.79918441e-02f, -2.42990702e-02f, -3.05491507e-01f, 3.78441781e-01f, 3.60731572e-01f, 1.78078155e-03f, 3.72868419e-01f, 2.49648005e-01f, 2.32627302e-01f, 2.36024693e-01f,
  2.96467185e-01f, 4.44046587e-01f, 3.42371374e-01f, 4.61317480e-01f, 2.94721633e-01f, 1.69454053e-01f, 1.91117331e-01f, -5.80098145e-02f, 2.32478306e-01f, 2.50822067e-01f,
  3.43616456e-02f, 5.30709885e-03f, -9.35178101e-02f, -6.41400665e-02f, 4.94947210e-02f, -9.48561952e-02f, 1.29032768e-02f, -5.08360518e-03f, -9.03296545e-02f, -2.86403671e-02f,
  -3.93842123e-02f, 1.35676578e-01f, 8.07173476e-02f, -2.73562036e-02f, -7.09531009e-02f, -4.52862047e-02f, 6.34092763e-02f, -2.51005334e-03f, -6.50302991e-02f, 7.22919703e-02f,
  -1.13385469e-01f, 3.89526077e-02f, -4.08275111e-04f, 1.36026032e-02f, -1.13761336e-01f, -8.87923837e-02f, -6.81232885e-02f, -8.67293328e-02f, 1.17508464e-01f, -4.00037728e-02f,
  6.54368401e-02f, 5.67034539e-03f, 2.68603545e-02f, -6.97897077e-02f, -5.48707470e-02f, -4.94880900e-02f, 9.04624909e-03f, 1.52839185e-03f, -9.20245703e-03f, -4.46621887e-02f,
  -3.86198722e-02f, 2.70289779e-02f, -4.69652750e-02f, -9.06197429e-02f, 7.15759024e-02f, 8.00578967e-02f, 1.26954736e-02f, 2.38543134e-02f, -2.66568456e-02f, -4.58959676e-03f,
  -2.87307743e-02f, 6.42214566e-02f, -7.07905218e-02f, 9.39378887e-02f, -6.45897177e-04f, -1.76216096e-01f, 4.60330695e-02f, -6.88413829e-02f, 3.12577337e-02f, 1.03146680e-01f,
  -1.16335656e-02f, 8.45717341e-02f, -1.34667203e-01f, -3.54473889e-02f, -2.10667215e-02f, 3.38753574e-02f, -1.43354088e-02f, 1.31005615e-01f, 2.18909164e-03f, -4.09235843e-02f,
  2.89636385e-02f, -8.43317956e-02f, 2.81635150e-02f, -2.84826513e-02f, 5.75525351e-02f, -1.20814897e-01f, -4.74541746e-02f, -1.26470819e-01f, -6.04309700e-02f, 1.00448735e-01f,
  8.67578480e-03f, 2.49201544e-02f, 4.71948087e-02f, -5.98327145e-02f, 2.67136320e-02f, -3.63131054e-02f, 1.29799489e-02f, 4.41578254e-02f, 9.93917510e-02f, -1.65943559e-02f,
  3.59347820e-01f, 2.15100288e-01f, 4.67535794e-01f, 4.44323212e-01f, -2.06093058e-01f, -1.57640904e-01f, 1.45714551e-01f, -5.02763167e-02f, 3.02561224e-01f, 9.98971760e-02f,
  -1.24772958e-01f, 3.54022145e-01f, -3.62538546e-01f, 3.34486663e-01f, -3.99951339e-01f, -2.20933706e-01f, 1.50710210e-01f, 1.80416524e-01f, -1.53879821e-01f, 3.70984375e-02f,
  -5.80367893e-02f, -3.90335053e-01f, 9.42907557e-02f, -3.21250916e-01f, 2.39592820e-01f, 2.12911025e-01f, -3.65877062e-01f, -1.61510766e-01f, 1.96730584e-01f, -1.04341239e-01f,
  -1.02154445e-02f, 7.80915841e-02f, 1.85083687e-01f, 3.93438227e-02f, 5.40780509e-03f, 5.99960126e-02f, 1.04451865e-01f, -1.20062204e-02f, -3.58850360e-02f, 5.14417961e-02f,
  5.46004772e-02f, -6.44770339e-02f, 4.00687475e-03f, -5.29207699e-02f, 7.99568966e-02f, 9.04578641e-02f, 3.89420502e-02f, 1.03092507e-01f, 1.13790967e-01f, 6.44925386e-02f,
  1.67925969e-01f, 1.11581571e-01f, 1.18744165e-01f, 1.85419768e-02f, 2.88479924e-02f, -2.11644862e-02f, 5.11684678e-02f, 4.68698032e-02f, 9.33470801e-02f, 3.77612449e-02f,
  4.34631901e-03f, -6.98076114e-02f, -2.42507178e-02f, 8.09969194e-03f, -1.63575877e-02f, 6.82573617e-02f, 6.58596531e-02f, -6.61348477e-02f, 4.47045267e-03f, -5.29919937e-02f,
  -8.24078918e-02f, 8.03160071e-02f, -1.49651105e-02f, 2.67256200e-02f, 3.85086313e-02f, 1.13886543e-01f, 6.67210668e-02f, -6.62792334e-03f, 7.87818357e-02f, 1.29551264e-02f,
  -6.14994504e-02f, -5.48099950e-02f, 1.03168655e-02f, 5.18820435e-02f, 3.11300289e-02f, -5.71748503e-02f, 1.01996632e-02f, 1.70528367e-01f, -3.75290848e-02f, -1.75124437e-01f,
  -4.69983339e-01f, -4.98361588e-01f, -2.26328708e-02f, -6.12973496e-02f, -3.96769075e-03f, -3.47591154e-02f, -2.42795032e-02f, 5.46411946e-02f, -2.04729602e-01f, -3.23263928e-02f,
  -1.51735703e-02f, 7.79016986e-02f, -4.11716253e-02f, 3.06427330e-02f, -1.04135744e-01f, -2.73871552e-02f, -3.68303210e-02f, -1.16022944e-01f, -2.14069754e-01f, -3.29708792e-02f,
  -5.82890585e-03f, -2.31651478e-02f, 7.18675740e-03f, 3.27718779e-02f, 3.99435572e-02f, -8.31644535e-02f, -3.18964981e-02f, 7.24501833e-02f, -9.68125984e-02f, 1.38668120e-02f,
  6.75985515e-01f, -3.70647252e-01f, 3.33885640e-01f, 4.76251841e-01f, 1.96278691e-01f, -1.98200364e-02f, 4.76640880e-01f, -1.83051050e-01f, 1.42006263e-01f, -4.86054450e-01f,
  -1.87833071e-01f, 3.42586249e-01f, -2.30689555e-01f, -3.55740450e-02f, 1.84424557e-02f, -3.89011323e-01f, -1.50293820e-02f, 7.65687376e-02f, -3.03671900e-02f, 5.58699705e-02f,
  1.07738741e-01f, -2.60440171e-01f, 1.37360871e-01f, -4.30793583e-01f, 2.82123983e-01f, 1.92414567e-01f, -2.44231910e-01f, -4.83660176e-02f, -1.14432611e-02f, 5.11392914e-02f,
  -2.32935045e-02f, 6.33217841e-02f, 2.28887856e-01f, -1.08136147e-01f, 1.97568955e-03f, 3.28443386e-02f, 1.18243381e-01f, 3.71372774e-02f, 1.54367164e-01f, 1.32861566e-02f,
  6.71889186e-02f, -5.79170212e-02f, 1.82929970e-02f, -2.18757130e-02f, 9.04758647e-02f, 8.16601366e-02f, 6.37526214e-02f, 8.64178613e-02f, 6.93196803e-02f, 1.28566891e-01f,
  1.46551803e-01f, 1.10780716e-01f, 8.35295767e-02f, -4.24813814e-02f, 1.82948224e-02f, 5.42356595e-02f, 8.16909783e-03f, 1.07099660e-01f, 4.34361026e-02f, 6.68857396e-02f,
  -9.56209153e-02f, 5.46705909e-03f, 3.12821828e-02f, 7.23116249e-02f, -2.19960827e-02f, 9.97184813e-02f, -7.13519892e-03f, -3.47067490e-02f, 3.22511914e-04f, -2.27821451e-02f,
  -1.05383955e-02f, 6.87567517e-02f, -9.23956931e-02f, 1.14417626e-02f, 1.82853974e-02f, 1.12552948e-01f, 7.04785958e-02f, -3.06717884e-02f, 2.46064495e-02f, 8.28811973e-02f,
  -3.36971460e-03f, -2.78148204e-02f, -3.14528160e-02f, 5.21087982e-02f, -7.88506418e-02f, 1.07241503e-03f, -9.56126451e-02f, 9.32076760e-03f, 1.29368836e-02f, -1.30013498e-02f,
  -5.00266910e-01f, -6.26444101e-01f, -6.19709343e-02f, -4.49005030e-02f, -1.08999319e-01f, -9.62045714e-02f, -1.04471631e-01f, -2.72381194e-02f, -8.03412870e-02f, -6.95419535e-02f,
  -5.20660840e-02f, 3.72879431e-02f, -5.38456813e-02f, -1.58730336e-02f, -9.33470502e-02f, -1.09117486e-01f, 6.29197136e-02f, -4.28821221e-02f, 2.25159060e-02f, -1.23546943e-01f,
  3.43048833e-02f, -4.72263340e-03f, -1.85792986e-02f, 6.82991138e-03f, -4.83882204e-02f, 9.44171846e-03f, -1.07726073e-02f, -1.27283903e-02f, -4.47653718e-02f, -7.16768503e-02f,
  1.76488295e-01f, 4.21961397e-01f, 3.96748096e-01f, 3.50566357e-01f, -3.08898717e-01f, -1.92917809e-01f, 1.03182450e-01f, 1.25789627e-01f, 4.01199430e-01f, -1.07967541e-01f,
  -3.45442712e-01f, 3.77469987e-01f, -2.26050746e-02f, -6.16403110e-02f, 8.84648114e-02f, -1.38894786e-04f, 2.49145865e-01f, 1.26029268e-01f, 1.93517163e-01f, 2.33499914e-01f,
  1.71596304e-01f, -3.12485367e-01f, 3.97545323e-02f, -2.75097638e-01f, -9.35946330e-02f, 3.42775226e-01f, -2.98906565e-01f, 6.96687074e-03f, -1.30248711e-01f, 2.77257841e-02f,
  -9.79392007e-02f, 1.34436905e-01f, 8.14738944e-02f, 1.70151442e-01f, 5.13399616e-02f, -6.12079948e-02f, 5.10732383e-02f, -4.22517359e-02f, 1.37106597e-01f, 5.33617288e-02f,
  1.21488012e-01f, -5.12434691e-02f, 1.66821349e-02f, -7.60014057e-02f, 6.91704005e-02f, -9.26412176e-03f, 3.98675203e-02f, 4.16707285e-02f, 8.07738453e-02f, -4.91540730e-02f,
  6.15852736e-02f, -7.04641221e-03f, 1.07261553e-01f, 1.67041376e-01f, 1.74956873e-01f, 9.19350386e-02f, 2.17508539e-04f, 5.54095469e-02f, 1.30194267e-05f, 6.73553869e-02f,
  -1.75342672e-02f, -2.01370958e-02f, -5.58220483e-02f, -1.78702489e-01f, -2.85289958e-02f, 4.27905545e-02f, 4.35667206e-03f, -1.60360605e-01f, 1.14516966e-01f, -7.58347511e-02f,
  3.19384746e-02f, 9.88656580e-02f, 7.82519858e-03f, -6.92641661e-02f, -5.73766939e-02f, 2.55809091e-02f, -1.62182059e-02f, 9.63792950e-02f, 1.69056967e-01f, -5.59182167e-02f,
  -2.69327890e-02f, 1.05946017e-02f, -8.60615224e-02f, -1.30745173e-01f, -8.24054256e-02f, 4.46560699e-03f, 1.72997210e-02f, 1.60872284e-02f, -9.36655477e-02f, 8.94256979e-02f,
  1.01804100e-01f, 4.26507056e-01f, 6.90897778e-02f, 4.17647883e-02f, 4.73844968e-02f, -6.12685718e-02f, 4.94009107e-02f, 8.57421681e-02f, 2.33940914e-01f, 9.88031458e-03f,
  4.79197651e-02f, 4.94134203e-02f, -9.05303843e-03f, -1.22200765e-01f, 7.45468959e-02f, -7.01768473e-02f, 8.48525092e-02f, 1.62294865e-01f, 1.38446093e-01f, 6.81669340e-02f,
  -3.92390676e-02f, -9.86505533e-04f, 1.03057258e-01f, 2.34875455e-02f, 3.20687853e-02f, 2.89036669e-02f, -5.75550571e-02f, 1.09007813e-01f, -8.27692635e-03f, 7.21633211e-02f,
  -3.58566493e-01f, -7.78777301e-02f, 2.65917212e-01f, -4.68735665e-01f, 1.84685141e-01f, 9.55009367e-03f, -1.88861176e-01f, -1.33346878e-02f, -9.24374163e-03f, -3.06290567e-01f,
  -3.68110612e-02f, -1.19180031e-01f, 2.40203321e-01f, -3.29089999e-01f, 4.46133375e-01f, 3.48142236e-01f, -2.46655092e-01f, -2.32394546e-01f, 4.77114692e-02f, -2.23557919e-01f,
  -2.14402657e-02f, -2.82390743e-01f, 1.68899924e-01f, -2.63033714e-02f, -2.42301181e-01f, -1.64025575e-01f, -1.93921685e-01f, 1.76237494e-01f, -4.20468241e-01f, 8.11037868e-02f,
  1.50907740e-01f, 8.90615582e-02f, 9.19871926e-02f, 8.01795870e-02f, -8.21739063e-02f, -3.81252244e-02f, -4.31455299e-02f, 1.23862550e-01f, 1.06850117e-01f, -9.46509689e-02f,
  -1.49793372e-01f, 9.25825387e-02f, -1.40025735e-01f, 8.56516138e-02f, -5.13449237e-02f, -9.25153866e-03f, 2.13612858e-02f, -4.55049984e-02f, 1.07617574e-02f, -3.73182185e-02f,
  1.01768911e-01f, 7.17608631e-03f, -9.81922355e-03f, -1.05556240e-02f, 1.10507287e-01f, 1.84530690e-02f, -3.70223541e-03f, -1.29161347e-02f, 2.68038027e-02f, -4.22087722e-02f,
  -4.39431779e-02f, -7.64595866e-02f, 4.48561348e-02f, 1.51606668e-02f, 6.40352145e-02f, 9.00045689e-03f, -7.67769758e-03f, -1.40700657e-02f, -4.85100970e-02f, 5.17221808e-04f,
  1.16024479e-01f, -1.35632539e-02f, 4.51368652e-02f, -5.51313497e-02f, -2.04991788e-01f, -6.02927394e-02f, 6.41678423e-02f, 2.66511235e-02f, -8.76633637e-03f, 3.84922437e-02f,
  1.72467269e-02f, 3.62411067e-02f, 4.79384363e-02f, 8.07811506e-03f, 4.40668203e-02f, -9.37313249e-04f, -8.44506323e-02f, 5.29825781e-03f, 1.49195930e-02f, 1.84931736e-02f,
  1.00825377e-01f, -1.95753947e-01f, 1.80691168e-01f, 1.03525534e-01f, 3.02170254e-02f, -2.59794462e-02f, 4.06073406e-02f, -1.04755402e-01f, -7.87852183e-02f, -3.47958505e-02f,
  -2.66136944e-01f, -7.49008358e-02f, -6.81492239e-02f, 2.08024662e-02f, 5.03534041e-02f, -4.54297625e-02f, -1.63793966e-01f, -8.25654790e-02f, -2.51218975e-02f, 2.10953448e-02f,
  8.85305740e-03f, 4.29099053e-03f, 1.02034964e-01f, -4.60779183e-02f, -1.21845260e-01f, -5.00667728e-02f, -6.28386578e-03f, 1.01646028e-01f, -9.18284655e-02f, -2.74818670e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.68033016e-01f, 4.70320553e-01f, 3.60331059e-01f, 3.52533430e-01f, 2.69777387e-01f, 1.96168453e-01f, 4.45107251e-01f, 3.52236897e-01f, 3.54833454e-01f, 4.50034916e-01f,
  2.48606503e-01f, 3.96336079e-01f, 4.46127653e-01f, 2.90220231e-01f, 3.62283587e-01f, 3.74998122e-01f, 5.59978902e-01f, 3.22389573e-01f, 3.37645054e-01f, 3.99549186e-01f,
  3.87125254e-01f, 2.45649382e-01f, 2.67396241e-01f, 2.70590276e-01f, 3.97310197e-01f, 4.13745314e-01f, 3.73858035e-01f, 3.95836353e-01f, 3.72730702e-01f, 3.82634014e-01f,
  5.10585725e-01f, 3.36054415e-01f, 4.51434374e-01f, 6.06389701e-01f, 2.72931188e-01f, 3.66069466e-01f, 5.53319275e-01f, 5.42923689e-01f, 5.14833927e-01f, 4.90478098e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.25700879e-01f, -1.22294806e-01f, -5.41092575e-01f, 6.37512803e-02f, -2.80942116e-02f, -2.48527732e-02f, -7.13222176e-02f, -6.68498203e-02f, -1.46989301e-01f, -1.67011157e-01f,
  -8.92520621e-02f, -1.70748785e-01f, 4.04090703e-01f, -2.44117454e-01f, -1.03586026e-01f, 1.24327004e-01f, -3.37749749e-01f, -1.62080869e-01f, -2.05182701e-01f, -2.90855527e-01f,
  2.94259399e-01f, 2.89633691e-01f, 3.22432250e-01f, -1.79575264e-01f, -3.52868408e-01f, -4.58532125e-01f, -1.65767983e-01f, 9.51671973e-02f, -5.28312981e-01f, -2.23894984e-01f,
  3.66763264e-01f, -1.11665532e-01f, -1.99636847e-01f, -2.59471685e-01f, 2.42266491e-01f, -2.14840814e-01f, 4.65216249e-01f, 5.06838143e-01f, 4.26860988e-01f, 5.65791070e-01f,
  4.37681615e-01f, -2.99317300e-01f, -4.88096356e-01f, -1.59014463e-01f, 4.55058426e-01f, -1.70643121e-01f, 5.91232121e-01f, -3.97796184e-01f, -3.71091098e-01f, -4.95563954e-01f,
  1.88859388e-01f, -2.98946470e-01f, -1.06343448e-01f, 5.54391265e-01f, -3.21329117e-01f, -2.89209843e-01f, -3.94171357e-01f, -7.39457905e-01f, 1.98597416e-01f, -3.04149508e-01f,
  1.98427379e-01f, -1.89430937e-01f, -4.48323786e-01f, -3.97706628e-01f, 8.90059322e-02f, 1.78691044e-01f, 3.85877118e-02f, -1.04949191e-01f, 8.78482312e-02f, -1.73067704e-01f,
  2.86189597e-02f, -1.46078423e-01f, -1.78039726e-02f, 1.68644875e-01f, -1.46579698e-01f, 2.81529844e-01f, -4.99346286e-01f, -1.79404512e-01f, -5.22273421e-01f, -3.71933937e-01f,
  6.03548408e-01f, 5.33371866e-01f, -1.53251946e-01f, -1.26254454e-01f, -4.82222065e-02f, 1.32317260e-01f, -2.38327727e-01f, -3.64229351e-01f, 5.34262598e-01f, -1.82229653e-01f,
  2.16917902e-01f, -1.17269821e-01f, 5.76367199e-01f, -5.41574895e-01f, 7.44666532e-02f, 2.45772809e-01f, -4.79186565e-01f, -4.78968799e-01f, -5.74362636e-01f, -5.72044671e-01f,
  1.90704390e-01f, -1.20882072e-01f, 1.77932516e-01f, 9.31907631e-03f, 4.99751747e-01f, 4.48319644e-01f, 4.35320854e-01f, 4.51408654e-01f, -3.49736989e-01f, -8.40594172e-01f,
  -3.45840491e-02f, 2.78907031e-01f, -3.55709076e-01f, -1.01541311e-01f, 2.88653523e-01f, -3.47987980e-01f, 1.15071364e-01f, 2.60264605e-01f, 5.08247502e-02f, 1.28020257e-01f,
  -6.57497883e-01f, -4.25356962e-02f, -5.60108721e-01f, 3.93084586e-01f, -5.86733997e-01f, -5.22612929e-01f, -7.24503517e-01f, -5.58500767e-01f, -1.03419021e-01f, -1.10881403e-01f,
  3.92657183e-02f, -7.38330036e-02f, -2.26629823e-01f, 8.22236240e-02f, -2.63633907e-01f, -5.71752600e-02f, -2.74051219e-01f, -6.25929609e-02f, -2.21557766e-01f, -2.87534893e-01f,
  1.71826258e-02f, 1.52328074e-01f, 1.93931252e-01f, -7.49272993e-03f, 2.08100602e-01f, -1.06020376e-01f, -1.56909600e-01f, -4.52178344e-02f, 3.54552716e-01f, -1.86689660e-01f,
  -1.71775371e-01f, 1.54665589e-01f, -4.53948557e-01f, -1.73339367e-01f, 1.89245448e-01f, -1.74601495e-01f, 4.43712354e-01f, 5.79362154e-01f, 4.40788269e-01f, -6.28361940e-01f,
  -1.92690387e-01f, 5.04275970e-02f, -1.46261990e-01f, -1.97658271e-01f, 2.25162089e-01f, -1.53637603e-01f, -3.98752153e-01f, -4.47617441e-01f, -5.04638016e-01f, 1.39870614e-01f,
  4.13978934e-01f, 2.10877731e-01f, -7.59096071e-02f, 5.03084600e-01f, 3.32928687e-01f, 5.57943165e-01f, -4.58617300e-01f, -2.44920507e-01f, 1.84023917e-01f, -4.14764285e-01f,
  -2.08908290e-01f, -2.52430379e-01f, -5.49591899e-01f, 1.42356068e-01f, -1.03522629e-01f, -3.08151871e-01f, -1.76464647e-01f, 4.22315478e-01f, -5.30632846e-02f, 3.60946311e-03f,
  -3.09948683e-01f, -4.60549518e-02f, -4.04840559e-02f, -5.62494755e-01f, -8.53496492e-02f, -3.89758527e-01f, 3.20502043e-01f, -1.33021474e-01f, 3.24899107e-02f, -2.51648664e-01f,
  -7.99676403e-02f, -2.66144127e-01f, -2.89323717e-01f, -1.00799859e-01f, 2.52109349e-01f, -3.11856091e-01f, -5.89508653e-01f, 2.01236263e-01f, -1.36070848e-01f, 4.02523398e-01f,
  -1.81994867e-03f, -3.59666735e-01f, 2.66784728e-01f, 4.33578581e-01f, 1.39478967e-01f, 1.02752201e-01f, -1.92832023e-01f, 3.12314898e-01f, -5.18256426e-01f, -6.37532413e-01f,
  -2.08151460e-01f, 2.77028847e-02f, 3.19032341e-01f, -8.13980401e-03f, -7.36680701e-02f, 4.77188170e-01f, 4.17297840e-01f, 4.22435313e-01f, -5.08196652e-01f, -2.19772950e-01f,
  -4.18974608e-01f, 3.70646752e-02f, -5.67216635e-01f, -3.03904027e-01f, -8.23594704e-02f, 1.78516015e-01f, 1.14002610e-02f, -2.74217516e-01f, -3.17704439e-01f, -3.38726521e-01f,
  -2.30932072e-01f, 2.65596062e-01f, -3.51323634e-01f, 2.69600570e-01f, -2.89014071e-01f, 3.80908966e-01f, 4.94257361e-01f, 2.53548384e-01f, -5.38169146e-01f, -5.56326210e-01f,
  6.00912690e-01f, -3.60510141e-01f, -3.66210818e-01f, -3.64567399e-01f, -1.42802656e-01f, 1.97757497e-01f, -1.02976024e-01f, 3.25891078e-01f, 3.06807011e-01f, 5.22670329e-01f,
  -1.12133361e-01f, 4.16449755e-02f, 8.17622989e-02f, 2.48851597e-01f, 5.57602048e-02f, 3.99723798e-01f, 2.32079804e-01f, -2.58638300e-02f, 4.35330331e-01f, 1.54583097e-01f,
  1.05448134e-01f, 3.04289937e-01f, -3.28736305e-01f, -4.41672981e-01f, 3.04154754e-01f, 5.73622406e-01f, 3.73923004e-01f, -4.79062498e-02f, 3.13442200e-01f, -1.71510741e-01f,
  -2.12325543e-01f, 7.37017035e-01f, -2.84877568e-01f, -4.60936837e-02f, -3.84763062e-01f, 2.52700876e-02f, -4.08084616e-02f, -2.94478595e-01f, -2.01979727e-01f, -5.99749565e-01f,
  -1.88493028e-01f, -2.64433593e-01f, 3.23056310e-01f, -6.27167225e-01f, -2.27323681e-01f, -1.26461342e-01f, 1.95320338e-01f, -1.37816221e-01f, -4.06904012e-01f, -1.65041625e-01f,
  7.43002951e-01f, -2.01954305e-01f, -4.18208957e-01f, -3.78138244e-01f, 3.49013448e-01f, 3.13896775e-01f, -5.49545046e-03f, 5.71862698e-01f, 5.25020361e-01f, -1.66985363e-01f,
  -5.19913852e-01f, -6.21915817e-01f, -2.51812816e-01f, -3.58273741e-03f, -5.31730391e-02f, 4.49396580e-01f, -1.24988310e-01f, -5.37177980e-01f, -8.93674716e-02f, 5.79245925e-01f,
  2.34190211e-01f, 1.71923712e-01f, 4.10623640e-01f, 3.98914039e-01f, 1.69418201e-01f, 3.54577377e-02f, 2.61370689e-01f, 3.35820764e-01f, 6.99217170e-02f, 4.71064646e-04f,
  3.62076104e-01f, -1.54200986e-01f, -3.48411113e-01f, 5.37264585e-01f, 7.89253190e-02f, -4.60052699e-01f, 3.60782258e-02f, -4.66655731e-01f, -3.73813927e-01f, -4.39522326e-01f,
  3.36509943e-02f, 3.91798675e-01f, 4.07470902e-03f, -5.14357150e-01f, 5.21548331e-01f, -3.85554940e-01f, -2.82034259e-02f, 2.72508264e-01f, -4.84513015e-01f, 1.12298556e-01f,
  -6.78239107e-01f, 3.39353710e-01f, -4.73863751e-01f, -3.23421061e-01f, 5.09915531e-01f, 2.10275259e-02f, -5.15690565e-01f, 3.70353997e-01f, 5.37838280e-01f, -5.76079905e-01f,
  3.25285763e-01f, -3.68514180e-01f, -1.06314942e-01f, -3.93825680e-01f, -4.67462450e-01f, 4.88776803e-01f, -3.46176594e-01f, -2.86284328e-01f, -2.10439190e-01f, -3.07964176e-01f,
  -5.52464724e-01f, 2.54752077e-02f, -5.52365541e-01f, 6.67390898e-02f, -4.25715834e-01f, 1.13105789e-01f, -1.47700071e-01f, 5.89371979e-01f, 1.64587528e-01f, -5.27462423e-01f,
  -1.59755915e-01f, -4.15388346e-01f, 5.93422532e-01f, -1.69145867e-01f, 4.03318703e-02f, -2.11886942e-01f, 4.06439975e-02f, -1.27819717e-01f, 8.62439647e-02f, 3.06854360e-02f,
  -8.56199861e-02f, -1.54967487e-01f, 3.05927079e-02f, -7.03254640e-02f, 8.99461936e-03f, 1.34940267e-01f, -2.74675667e-01f, 2.45430730e-02f, 1.87796131e-01f, -1.25551775e-01f,
  -4.87856805e-01f, 1.45792797e-01f, -4.02966231e-01f, 1.08286150e-01f, 1.14977151e-01f, -2.13932678e-01f, -4.69719768e-01f, 4.24962848e-01f, -7.98181891e-02f, -3.78700912e-01f,
  5.30759692e-01f, -5.52777469e-01f, 4.99125198e-02f, 7.95632426e-04f, -4.77090925e-01f, -4.74729776e-01f, -1.46677554e-01f, 5.61969817e-01f, -5.31811655e-01f, -5.50149322e-01f,
  -6.44518673e-01f, 2.45773926e-01f, 4.95647043e-02f, -1.80345014e-01f, -4.45817709e-01f, 2.55195022e-01f, 6.26197577e-01f, -4.25647974e-01f, -5.60239553e-01f, -2.83434778e-01f,
  7.21487626e-02f, -5.47536671e-01f, -2.78867811e-01f, -4.35510635e-01f, -6.00346699e-02f, 3.17294002e-01f, 5.63372374e-01f, -8.21968555e-01f, -3.65006417e-01f, -2.01361030e-01f,
  6.62979424e-01f, 4.32450026e-01f, -3.36315185e-01f, -4.39935863e-01f, 3.32352608e-01f, 5.22150695e-01f, 5.39800115e-02f, -5.83663173e-02f, -1.36204302e-01f, -1.13935895e-01f,
  -2.93479383e-01f, 1.08520791e-01f, -1.37013376e-01f, 4.63951416e-02f, -2.17315376e-01f, -1.79069668e-01f, -4.33743745e-03f, -3.10160611e-02f, -1.85224935e-01f, -8.32214430e-02f,
  5.74271660e-03f, -2.87198186e-01f, 2.72768676e-01f, -5.04286475e-02f, 6.85989037e-02f, -8.32059532e-02f, 2.20204443e-01f, 1.25361964e-01f, -1.43204942e-01f, 2.24106997e-01f,
  -3.66962522e-01f, 1.08621433e-01f, -2.87308693e-01f, -1.54315025e-01f, -1.26593456e-01f, 5.00710666e-01f, -2.53234029e-01f, -2.96865683e-02f, -2.48530135e-01f, 8.96511320e-03f,
  -1.80366173e-01f, -3.33990872e-01f, 4.19004023e-01f, 1.31264836e-01f, -3.16863000e-01f, 3.21931913e-02f, -3.52037668e-01f, -3.82228673e-01f, -3.86053115e-01f, -2.41506681e-01f,
  -2.29387492e-01f, -1.86182648e-01f, -3.05208236e-01f, 2.34871775e-01f, -2.93790609e-01f, 8.14616010e-02f, 2.16785982e-01f, 3.01719815e-01f, 7.23622218e-02f, -3.64994586e-01f,
  -2.20477700e-01f, -1.66409612e-01f, 5.09857655e-01f, -1.71064034e-01f, 5.25625765e-01f, 1.48841411e-01f, 3.67300957e-01f, 2.43742153e-01f, -3.11671853e-01f, -3.20740700e-01f,
  -5.17640263e-03f, 3.75798106e-01f, -2.34856665e-01f, -2.22703721e-02f, -1.13669276e-01f, -5.28374352e-02f, -2.88920879e-01f, -3.24586749e-01f, 7.50782788e-02f, -2.33031362e-01f,
  1.51276186e-01f, -1.17086418e-01f, 1.12269334e-01f, -2.14131325e-01f, -3.95432413e-02f, -4.73912507e-02f, -1.88969478e-01f, 3.67743403e-01f, 2.30383098e-01f, 2.45735079e-01f,
  3.25907826e-01f, -2.81862915e-01f, -2.85938799e-01f, -9.61056873e-02f, -2.23214421e-02f, 4.15655702e-01f, -2.06704929e-01f, -2.59369105e-01f, 1.84492588e-01f, 5.46610095e-02f,
  -1.44913182e-01f, 1.89251825e-01f, -3.01964581e-01f, 3.54348451e-01f, 5.28448403e-01f, 1.06974393e-01f, -1.02753609e-01f, -1.88575745e-01f, -1.33766145e-01f, -2.35558853e-01f,
  -3.48916138e-03f, 8.09213594e-02f, -4.26290154e-01f, 2.53142297e-01f, -1.41956553e-01f, -4.03247476e-01f, -1.70337021e-01f, 6.21079981e-01f, -1.94316730e-01f, -3.59900415e-01f,
  -8.59936327e-02f, -2.63455510e-01f, -2.36623183e-01f, -3.13483089e-01f, 4.46255416e-01f, 3.14151108e-01f, -3.09884340e-01f, -1.81446522e-01f, -2.56424919e-02f, -3.89578223e-01f,
  -1.68978006e-01f, 3.87394965e-01f, -1.44621104e-01f, -3.98012578e-01f, 4.09220308e-01f, -1.40144259e-01f, 1.95347100e-01f, 8.17874819e-02f, -2.24371076e-01f, -2.99933314e-01f,
  -1.22161798e-01f, -3.86935472e-02f, 1.46907613e-01f, 1.33667842e-01f, 7.94702321e-02f, -3.03033173e-01f, -1.06022127e-01f, 1.81821346e-01f, 4.61700588e-01f, 2.50867307e-01f,
  3.84904832e-01f, -3.51658911e-01f, -2.90427089e-01f, -3.79348695e-01f, 4.48584765e-01f, -9.78110805e-02f, -4.64731634e-01f, -4.02998120e-01f, 3.30255002e-01f, 1.68364525e-01f,
  -6.19249761e-01f, -5.81722498e-01f, -4.28836972e-01f, -5.36532030e-02f, 1.62056521e-01f, -4.66881692e-01f, -4.05287743e-01f, 4.93483245e-02f, -2.31636792e-01f, -5.21150410e-01f,
  -3.87441670e-03f, -1.19166933e-01f, 4.01071399e-01f, 1.86144531e-01f, -5.15306532e-01f, -4.39787209e-02f, -1.41988292e-01f, -8.78172591e-02f, -2.48506978e-01f, 3.40259910e-01f,
  2.71898955e-01f, 1.12559078e-02f, 4.95822489e-01f, 5.26632607e-01f, 7.35708237e-01f, -5.18296123e-01f, -4.15482849e-01f, -3.73335272e-01f, -1.80628777e-01f, -9.49591845e-02f,
  4.38949287e-01f, -1.73212364e-01f, -8.30297843e-02f, 4.51355249e-01f, -5.13760507e-01f, -4.02045935e-01f, -1.40468910e-01f, 4.69804972e-01f, -2.03163587e-02f, 4.15672302e-01f,
  2.70180792e-01f, 2.94380695e-01f, 2.85670787e-01f, 1.51707992e-01f, -5.72573282e-02f, 2.69081056e-01f, -1.15377188e-01f, 1.45266756e-01f, 5.59137762e-03f, 8.50831866e-02f,
  9.68894735e-02f, 2.16737121e-01f, -2.90614963e-01f, -3.32509398e-01f, 3.51257950e-01f, 3.01382065e-01f, 3.26039821e-01f, 8.67730603e-02f, 2.89846629e-01f, 1.47839963e-01f,
  -3.91846001e-01f, -1.59329250e-01f, 2.57287294e-01f, 2.07941726e-01f, -3.21129501e-01f, 1.28777400e-01f, 3.86717916e-01f, 5.06395459e-01f, -1.62985682e-01f, 1.30736023e-01f,
  2.62804776e-01f, -4.46599692e-01f, 4.96249706e-01f, 4.07312393e-01f, -4.46659476e-01f, 2.56079048e-01f, 1.33747250e-01f, -3.40953618e-01f, -1.00730307e-01f, 5.47340989e-01f,
  -2.26492301e-01f, 1.20852320e-02f, -4.26168263e-01f, 4.76974517e-01f, -4.20243591e-01f, -4.61667925e-01f, -1.10284910e-01f, -5.11580221e-02f, -3.42973381e-01f, -6.46665618e-02f,
  6.38765693e-01f, -5.44030905e-01f, -3.66715550e-01f, -5.21040559e-01f, 8.96812752e-02f, 5.92582464e-01f, -2.76233882e-01f, -8.20503086e-02f, -5.13936460e-01f, -4.23131764e-01f,
  -5.60942352e-01f, -4.12461847e-01f, -2.87762970e-01f, -5.07999778e-01f, -6.42287582e-02f, -2.55384091e-02f, 1.92823678e-01f, 8.90718326e-02f, 2.08900928e-01f, 1.03432313e-01f,
  5.26637062e-02f, -1.09725945e-01f, -5.07037006e-02f, 1.75393239e-01f, 4.23106551e-03f, 2.27740362e-01f, -2.55902320e-01f, 3.48080993e-01f, -1.25509113e-01f, 4.03558105e-01f,
  1.08601153e-01f, 2.17274845e-01f, -1.32678270e-01f, 3.87993336e-01f, -2.40338370e-01f, -8.15303065e-04f, 2.65278161e-01f, 6.28747698e-03f, 3.26611578e-01f, 3.76843475e-03f,
  -3.87445599e-01f, -1.18673339e-01f, -3.32420738e-03f, -3.70348155e-01f, -7.90001824e-03f, -8.47782269e-02f, 3.03050756e-01f, -3.07239234e-01f, -3.87459695e-01f, 4.91786718e-01f,
  -2.41163373e-01f, -3.65908325e-01f, -4.30046201e-01f, 1.89090129e-02f, -1.36127248e-02f, -2.77880520e-01f, -3.86139423e-01f, -3.36654931e-01f, -2.98094094e-01f, -1.35518059e-01f,
  -2.22608924e-01f, -2.83787876e-01f, -1.23020314e-01f, 5.25769711e-01f, -3.44032824e-01f, 5.03815934e-02f, -3.23399276e-01f, -3.56697023e-01f, -2.72870332e-01f, -8.65601078e-02f,
  2.21069545e-01f, -5.29061675e-01f, -1.34678960e-01f, -9.81156528e-02f, 8.53702784e-01f, 6.17779434e-01f, 5.01030803e-01f, -4.50351804e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.33321614e-03f, -9.24142674e-02f, -5.54782636e-02f, -7.11041391e-02f, 9.10342708e-02f, 1.35257274e-01f, -2.52970047e-02f, -1.64858758e-01f, -5.97121520e-03f, -8.47821012e-02f,
  7.25801885e-02f, 2.23405566e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    