/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.98953271e-01f, -2.33907819e-01f, -1.66682094e-01f, 6.74317405e-03f, -8.11007246e-02f, -1.29962355e-01f, -1.48077626e-02f, 1.38266042e-01f, -4.79098149e-02f, -6.68421090e-02f,
  -9.59196985e-02f, 1.34811491e-01f, 2.63751019e-02f, 1.42393261e-02f, 1.65491045e-01f, -2.07115531e-01f, -1.86534539e-01f, 1.32162720e-01f, 3.73251379e-01f, 4.06918675e-01f,
  1.72436655e-01f, 2.22558379e-01f, 3.86030406e-01f, 6.64905310e-02f, -7.93158039e-02f, 3.69565189e-02f, -2.29183316e-01f, -1.28060952e-01f, -9.11664814e-02f, -1.34721100e-01f,
  3.37034613e-02f, -9.41315368e-02f, 1.56809583e-01f, 1.31061494e-01f, -6.54672012e-02f, 7.37612844e-02f, 9.38152745e-02f, -3.73524129e-02f, 9.44164544e-02f, 4.47305590e-02f,
  3.64907011e-02f, 1.11620009e-01f, 3.90504487e-02f, -2.88752206e-02f, 4.67696264e-02f, 1.34745225e-01f, 1.84054505e-02f, 8.99203047e-02f, 2.01313682e-02f, 4.34279181e-02f,
  -7.02688843e-02f, 2.26002671e-02f, -1.02105644e-02f, 8.90616104e-02f, 8.41241181e-02f, -1.58034377e-02f, -3.51178274e-02f, 5.08946069e-02f, 2.07079090e-02f, 1.04231201e-01f,
  1.57598063e-01f, -3.00488360e-02f, -9.69610214e-02f, -1.25665694e-01f, 5.78000909e-03f, -1.79584295e-01f, -1.16856039e-01f, -9.03341174e-02f, -2.92606708e-02f, -1.32597918e-02f,
  -1.07117683e-01f, -1.72276482e-01f, -1.62285920e-02f, -5.51184192e-02f, -1.28867328e-01f, -8.57234970e-02f, -1.02172464e-01f, -4.82618697e-02f, -1.52029321e-01f, -1.36098519e-01f,
  -6.39431626e-02f, -1.35271296e-01f, -1.07583493e-01f, -2.27007288e-02f, -9.73877087e-02f, -1.11475989e-01f, -1.06137566e-01f, -8.98448676e-02f, -2.76580695e-02f, -6.84637204e-02f,
  -5.02684445e-04f, -4.33528796e-02f, 1.04889106e-02f, 7.98110515e-02f, -8.25854857e-03f, 1.48966666e-02f, 8.80808532e-02f, 7.09202662e-02f, -1.45521224e-01f, 1.56072497e-01f,
  7.95630962e-02f, 1.66838661e-01f, 3.64590473e-02f, 2.02529043e-01f, 1.76691264e-01f, 6.33550882e-02f, 8.23580921e-02f, 9.65427011e-02f, 3.80108245e-02f, 7.19897598e-02f,
  1.14969291e-01f, 1.82517007e-01f, 2.24258050e-01f, 6.71004578e-02f, 1.13889672e-01f, 8.66046250e-02f, 1.41095996e-01f, 1.24900021e-01f, 1.12340458e-01f, 3.10281038e-01f,
  2.64533550e-01f, -2.20127851e-01f, 7.33181238e-02f, 1.91584542e-01f, 2.24243440e-02f, -2.16499910e-01f, -4.14508462e-01f, -2.27047861e-01f, -6.88121319e-02f, -1.40393376e-01f,
  -1.14629917e-01f, -1.17479980e-01f, -1.21107608e-01f, -1.33156940e-01f, -2.10120767e-01f, -2.09759697e-01f, 1.87530398e-01f, 1.72365144e-01f, -9.89645198e-02f, -9.19637233e-02f,
  1.06744915e-01f, 2.17891112e-01f, 1.47626370e-01f, 7.38410652e-02f, 2.42103249e-01f, 1.40270039e-01f, 9.13850963e-02f, 1.85800865e-02f, 1.69861745e-02f, 2.89557815e-01f,
  -3.55699688e-01f, -1.36381060e-01f, 1.07503291e-02f, -6.94217682e-02f, -1.55411651e-02f, -8.16812739e-02f, -3.46951857e-02f, -4.88174334e-02f, -1.29807070e-02f, -2.07242686e-02f,
  4.19474877e-02f, -4.44746390e-02f, 9.80621390e-03f, 2.56160982e-02f, 4.23060916e-02f, -3.09552290e-02f, 2.48314757e-02f, 4.29204060e-03f, -1.13094218e-01f, -1.33984447e-01f,
  -5.88462548e-03f, -2.24602371e-02f, -7.36549422e-02f, -1.71007171e-01f, -9.02917236e-02f, 1.01374341e-02f, -6.17919341e-02f, -7.92988762e-02f, -1.72102258e-01f, -1.10635169e-01f,
  -5.02618775e-02f, 4.59296070e-02f, 3.01968101e-02f, -3.45217511e-02f, 1.05918117e-01f, 3.11181787e-02f, 1.70170262e-01f, 4.04482819e-02f, 1.74100965e-01f, 1.93754658e-02f,
  4.70804647e-02f, 6.12094663e-02f, 1.44050658e-01f, -2.72564869e-02f, 8.90994444e-02f, 9.68361050e-02f, 6.22544736e-02f, -1.35096526e-02f, 6.38515949e-02f, 1.05002716e-01f,
  1.02281801e-01f, 8.44681635e-02f, 3.27638946e-02f, -2.58838311e-02f, 5.33670932e-02f, 1.66218486e-02f, 7.34213293e-02f, 7.71061033e-02f, 8.26673061e-02f, 1.09068640e-01f,
  -1.37619376e-01f, -1.40355945e-01f, -1.10587753e-01f, -9.37203094e-02f, -2.49201898e-02f, -6.87270761e-02f, -1.41650647e-01f, -2.37388145e-02f, -1.74284671e-02f, -4.91101071e-02f,
  -1.45574033e-01f, -8.61906633e-02f, -9.34621841e-02f, 4.49525146e-03f, 3.92828025e-02f, -4.05238084e-02f, -4.77169380e-02f, -6.65750131e-02f, -1.15001172e-01f, -4.80375774e-02f,
  -7.54807442e-02f, -1.45301625e-01f, -1.62668005e-01f, -1.52254850e-01f, -6.40756339e-02f, -1.34999976e-02f, -3.26409712e-02f, -1.72916636e-01f, -9.70836356e-02f, -1.71166748e-01f,
  -4.80914205e-01f, 6.53687716e-01f, 2.16503158e-01f, 9.82750878e-02f, 1.74830750e-01f, 1.66209996e-01f, 3.87586057e-01f, 1.50352374e-01f, -4.45430614e-02f, 2.36279264e-01f,
  1.38547674e-01f, -1.81302190e-01f, -1.99507743e-01f, -9.88212898e-02f, -8.30316991e-02f, 1.46063253e-01f, 1.14505388e-01f, -2.87099510e-01f, -3.75857413e-01f, -7.80565888e-02f,
  -2.23211385e-02f, -2.17267964e-02f, -1.72509953e-01f, -8.71240944e-02f, 1.15167767e-01f, -5.97783923e-02f, 1.81552783e-01f, 1.55596942e-01f, 2.08025917e-01f, 2.72243563e-02f,
  8.48784372e-02f, 3.38519543e-01f, -9.24332663e-02f, -1.95469186e-02f, 1.17043622e-01f, 9.31613240e-03f, 8.86063576e-02f, 1.18509382e-02f, 8.57890025e-03f, 1.14742495e-01f,
  3.18473615e-02f, -3.30127776e-02f, 7.20765963e-02f, -2.09583100e-02f, 3.79604250e-02f, 2.81205513e-02f, 1.04106627e-01f, 4.92843427e-02f, 1.16735145e-01f, 1.95263043e-01f,
  9.52524692e-02f, 7.80384094e-02f, -1.10957175e-02f, 2.29310155e-01f, 8.89315307e-02f, -5.12859784e-02f, 1.77316710e-01f, 7.97879845e-02f, -3.34854089e-02f, 1.16325781e-01f,
  2.46467534e-02f, 4.68440652e-02f, -1.18545331e-02f, -3.11763547e-02f, -7.00001195e-02f, -7.62074739e-02f, 4.76119071e-02f, -4.21394147e-02f, -1.44792721e-01f, -6.34854063e-02f,
  -7.06707239e-02f, -1.14181876e-01f, 2.16972753e-02f, -1.07232943e-01f, -1.27461448e-03f, -7.98970386e-02f, 3.72331007e-03f, 3.21654566e-02f, -3.19058895e-02f, -3.77509743e-02f,
  -7.39803538e-02f, -2.25226805e-02f, -5.55818416e-02f, 1.02874248e-04f, -5.65791763e-02f, -2.44368496e-03f, -1.56489164e-01f, -4.92481068e-02f, -7.69548789e-02f, -4.65668514e-02f,
  -3.73251103e-02f, -9.45361108e-02f, -4.15740944e-02f, 1.68521125e-02f, 1.26588298e-02f, 5.19637764e-02f, 1.05686903e-01f, 1.13757335e-01f, 1.59588642e-02f, 2.19616294e-02f,
  3.90403122e-02f, 4.48750518e-02f, 7.78977424e-02f, 3.41919549e-02f, -5.63288555e-02f, -8.37468207e-02f, -3.09645124e-02f, -5.82826175e-02f, -5.01811802e-02f, 1.26896665e-01f,
  3.73702459e-02f, -7.18331560e-02f, -1.15952715e-01f, -8.89027119e-03f, -2.87237316e-02f, -1.39717624e-01f, 1.56119922e-02f, -1.06203042e-01f, -1.39100045e-01f, 5.99994808e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.16765940e-01f, 5.33143342e-01f, -1.23906386e+00f, 1.71143651e-01f, -6.22711182e-01f, -6.95969045e-01f, -4.50270176e-01f, 8.21711272e-02f, 1.66244134e-01f, -1.98797360e-02f,
  -5.62976040e-02f, 1.47303864e-01f, -1.03070885e-02f, -3.56137037e-01f, -6.20261610e-01f, -6.35512888e-01f, -7.90212750e-01f, -9.07047629e-01f, -8.83861601e-01f, -5.53884447e-01f,
  -2.12462068e-01f, 1.21082179e-01f, -6.74648434e-02f, -1.84558243e-01f, 1.35585353e-01f, 1.05900794e-01f, -3.05890024e-01f, -2.27909610e-01f, -3.67392778e-01f, -8.94941762e-02f,
  -2.36335307e-01f, -7.84045383e-02f, -2.55304158e-01f, 7.16327354e-02f, -5.20889089e-02f, -9.10863504e-02f, -1.43362358e-01f, -9.48874876e-02f, 1.08772263e-01f, -6.79131076e-02f,
  -1.24080792e-01f, -2.87950277e-01f, -1.15994275e-01f, -8.34682882e-02f, -8.55348483e-02f, -6.01342320e-02f, -2.68177271e-01f, -5.35119414e-01f, -2.23315924e-01f, -3.43787283e-01f,
  -3.60554695e-01f, -5.66438079e-01f, -5.54324925e-01f, -2.87487417e-01f, -4.71440107e-01f, -5.23029447e-01f, -1.56947836e-01f, -4.00889009e-01f, -4.02000964e-01f, 6.18322670e-01f,
  3.68116461e-02f, -7.17487857e-02f, -5.65696955e-02f, 2.49552503e-01f, 1.79457337e-01f, 3.23054828e-02f, 1.93803348e-02f, 4.82484289e-02f, -5.51258214e-02f, 7.01998472e-02f,
  4.17322069e-02f, -6.00663461e-02f, 1.45280063e-01f, 2.67100483e-02f, -1.82266802e-01f, -2.73961902e-01f, -1.99073888e-02f, -1.62214618e-02f, 3.24575752e-02f, 5.40068075e-02f,
  8.27939063e-02f, -1.14502579e-01f, -6.35051727e-02f, 7.18173906e-02f, -2.47101307e-01f, -1.75406635e-01f, 2.00957470e-02f, 1.04333676e-01f, 7.64292330e-02f, 1.30674634e-02f,
  7.57252932e-01f, -2.62282640e-01f, 3.07613432e-01f, 1.30923456e-02f, -2.23142385e-01f, -1.45421192e-01f, 2.34972671e-01f, 3.92544083e-02f, 9.46275145e-02f, -1.29937842e-01f,
  -2.24206656e-01f, -2.57529076e-02f, 1.38327957e-03f, 9.53051895e-02f, -1.18911013e-01f, 4.25407365e-02f, 9.81925875e-02f, -1.46149844e-01f, -2.64280792e-02f, 6.20918311e-02f,
  2.29887083e-01f, -2.16172077e-03f, 1.87142357e-01f, 2.34992608e-01f, -6.81369901e-02f, 5.24474718e-02f, 3.92189741e-01f, 2.51662806e-02f, -2.71412522e-01f, 8.32288504e-01f,
  -6.35900348e-02f, -2.63257891e-01f, -7.61822164e-02f, 3.14100236e-01f, 1.81925986e-02f, -6.47463739e-01f, -8.02830040e-01f, -3.66658837e-01f, -1.45373866e-01f, -3.49623173e-01f,
  -3.72660637e-01f, -2.34006625e-02f, 3.85801382e-02f, 1.27397060e-01f, -2.21561957e-02f, 3.99927758e-02f, 5.01011908e-01f, 6.48268878e-01f, 3.80051464e-01f, 2.20297456e-01f,
  4.55084234e-01f, 5.78766525e-01f, 7.37753570e-01f, 5.30605555e-01f, 4.77871567e-01f, 4.17060941e-01f, 1.47150680e-01f, 2.64148831e-01f, 1.20440327e-01f, 5.91939092e-01f,
  -3.89877975e-01f, -6.46755874e-01f, -7.06352964e-02f, 2.96326369e-01f, -2.91509796e-02f, 9.08943862e-02f, 2.35099867e-02f, 3.97295356e-01f, 6.81611970e-02f, 2.65825540e-01f,
  1.61665007e-01f, -8.19180440e-03f, 1.34983674e-01f, 1.87507898e-01f, 4.40773368e-02f, -3.99421811e-01f, 2.65699059e-01f, 4.79000919e-02f, -1.46542668e-01f, -2.46255964e-01f,
  2.86985785e-01f, 2.17683598e-01f, -4.26935971e-01f, -3.48414093e-01f, -3.81565422e-01f, 3.31298381e-01f, -3.98885727e-01f, -2.70384669e-01f, -3.46228361e-01f, 2.66606323e-02f,
  -2.10061058e-01f, -1.12456873e-01f, -1.34314075e-01f, 7.04347938e-02f, 1.56716891e-02f, 3.02479751e-02f, -7.84553736e-02f, -1.51908100e-01f, -4.80926633e-02f, 8.65940899e-02f,
  1.14035130e-01f, -1.04288556e-01f, -5.55135347e-02f, 1.52267268e-04f, 1.16205037e-01f, -8.25135335e-02f, -3.12673040e-02f, 3.69065814e-02f, 1.42346457e-01f, 9.66247823e-03f,
  -1.05253123e-01f, -2.01433361e-01f, 1.68683559e-01f, 5.28692966e-03f, 6.02285974e-02f, 6.98872050e-03f, 1.79406196e-01f, 7.06302375e-02f, 3.99100929e-02f, 1.01496622e-01f,
  9.49186310e-02f, 7.71707972e-04f, -2.50046194e-01f, -9.08864662e-02f, -2.63835698e-01f, -9.19504166e-02f, -4.10136431e-02f, -1.87158465e-01f, -3.12353760e-01f, 9.77811515e-02f,
  -2.22126972e-02f, -7.54135251e-02f, 4.96533886e-02f, 7.02265501e-02f, 6.79667620e-03f, -3.11954111e-01f, -1.18843664e-03f, -1.60381600e-01f, -1.30445063e-01f, -2.62712836e-01f,
  6.76705092e-02f, -2.34043926e-01f, -3.05648953e-01f, -5.23524106e-01f, -3.89242202e-01f, -6.86853519e-03f, -2.15577140e-01f, -4.12772477e-01f, -5.38842559e-01f, -2.41463080e-01f,
  -1.57410115e-01f, -8.16707134e-01f, -4.77873892e-01f, -6.74599767e-01f, -3.92491639e-01f, -1.55117139e-01f, -8.88011992e-01f, -3.87292087e-01f, -1.00756541e-01f, -9.43352640e-01f,
  -3.79950523e-01f, 5.08131087e-01f, 1.36758536e-01f, 1.99196175e-01f, 1.93914791e-04f, -9.94326591e-01f, -6.74148858e-01f, 6.51031733e-02f, 6.02400541e-01f, 1.16971694e-01f,
  -2.42803663e-01f, -3.25631827e-01f, 3.09696626e-02f, -1.85928404e-01f, -6.25886202e-01f, -1.86353669e-01f, -5.92628896e-01f, -4.25369859e-01f, -1.87248796e-01f, -7.09102631e-01f,
  -4.67672437e-01f, 8.14429391e-03f, 4.18507993e-01f, 2.78394341e-01f, -4.73784029e-01f, 3.31973046e-01f, -1.42762780e-01f, 8.19096044e-02f, 2.27419183e-01f, -1.50075316e-01f,
  1.92594886e-01f, 1.58328995e-01f, 2.28905484e-01f, 1.08900532e-01f, -3.24139684e-01f, 1.87179685e-01f, -1.20752029e-01f, 2.36880928e-01f, 8.62447172e-03f, -1.57607988e-01f,
  -1.19255006e-01f, 1.06948562e-01f, 1.34596080e-01f, 4.99267802e-02f, 2.76996225e-01f, 2.21470997e-01f, -1.37455747e-01f, 4.68482882e-01f, 2.76076823e-01f, -6.78906798e-01f,
  -1.19274922e-01f, -8.21705014e-02f, -9.04341345e-04f, 9.81419906e-02f, 1.39515370e-01f, 1.07701048e-02f, -3.42117846e-02f, -8.40036422e-02f, 1.30384773e-01f, 2.81827524e-02f,
  -5.28786443e-02f, -1.55469012e-02f, 1.00405782e-01f, -1.51743516e-01f, -1.73747670e-02f, -1.09657668e-01f, -1.49158716e-01f, -1.88728064e-01f, -2.69785058e-02f, 7.62051716e-02f,
  2.12324813e-01f, 3.82384509e-02f, -5.86527027e-02f, 2.28403285e-02f, -1.78656690e-02f, -1.13250844e-01f, 5.36723584e-02f, 1.21360302e-01f, -1.97228119e-01f, 1.07489750e-01f,
  -4.35186565e-01f, 5.13532519e-01f, -4.93518680e-01f, 1.98195830e-01f, -2.88301110e-01f, -3.86111462e-03f, -1.01718288e-02f, 1.55038014e-02f, 9.12591442e-02f, -2.57060289e-01f,
  7.92628005e-02f, -1.55956432e-01f, -1.41477451e-01f, 8.67680684e-02f, 7.46135116e-02f, 1.48135498e-01f, -1.55432135e-01f, -2.11569756e-01f, 8.04767311e-02f, 1.10059325e-02f,
  -1.06456943e-01f, -1.14790648e-01f, -1.40394047e-01f, -9.63633582e-02f, 1.25251144e-01f, 1.70079604e-01f, -3.04055601e-01f, -1.87658235e-01f, -1.39073525e-02f, -9.15434420e-01f,
  -3.64109367e-01f, -4.42540824e-01f, 6.53085053e-01f, -2.43416190e-01f, -2.40072101e-01f, -3.63144189e-01f, -7.03054130e-01f, -5.40235341e-01f, -3.06569010e-01f, -1.06952034e-01f,
  3.75847608e-01f, 8.68188024e-01f, 1.02032554e+00f, 6.19948983e-01f, 3.71100962e-01f, -1.02127098e-01f, 2.04237625e-02f, 4.93923277e-01f, 3.33164811e-01f, -3.22883457e-01f,
  -3.47407788e-01f, -3.97156149e-01f, -1.93102837e-01f, -1.70307815e-01f, -2.23579764e-01f, 3.33354712e-01f, 8.75521749e-02f, -3.95587645e-02f, -1.13671489e-01f, 6.91245943e-02f,
  4.14533257e-01f, -5.34240544e-01f, 2.09744558e-01f, -5.74398339e-02f, 3.60324718e-02f, -2.04064757e-01f, -3.35181952e-02f, 2.86361203e-02f, -9.34941322e-02f, -6.53491467e-02f,
  3.20415385e-02f, -9.89764035e-02f, -3.06673609e-02f, -1.26928523e-01f, -2.98260599e-01f, -1.14446834e-01f, -1.47800624e-01f, -5.48583455e-02f, -5.79233281e-03f, -5.86968437e-02f,
  -1.28759950e-01f, -1.53688818e-01f, 2.62254089e-01f, 4.85047735e-02f, -1.70723662e-01f, 3.10151339e-01f, 4.34216149e-02f, -3.34949512e-03f, 8.37303046e-03f, -2.73093671e-01f,
  6.09629788e-02f, 1.18596397e-01f, -3.09138820e-02f, 5.80588691e-02f, 1.32686287e-01f, 1.20981090e-01f, -5.56423701e-02f, 5.82328513e-02f, 3.67664918e-02f, -3.08102183e-02f,
  8.32154602e-03f, -1.22540267e-02f, -2.77836621e-02f, -2.13615298e-01f, -1.07197720e-03f, -5.41721992e-02f, 4.32599382e-03f, -4.11600657e-02f, 3.99152488e-02f, -3.82835642e-02f,
  1.66624337e-01f, 1.23219565e-01f, 4.40247506e-02f, 6.37092292e-02f, -6.81380462e-03f, -2.77208947e-02f, -1.66874126e-01f, -1.02486074e-01f, 8.12513307e-02f, -2.71611482e-01f,
  6.46632463e-02f, 1.45257175e-01f, 2.27804020e-01f, 4.27839234e-02f, -2.22741246e-01f, -9.86899994e-03f, -2.07352787e-02f, -1.22729234e-01f, 1.44747645e-01f, 7.68181589e-03f,
  -5.66288419e-02f, 7.83016086e-02f, -7.62836561e-02f, -4.47452292e-02f, -1.34371975e-02f, -8.60693455e-02f, -8.13787431e-02f, 2.05854192e-01f, -1.29647478e-01f, -2.01172858e-01f,
  -1.94846570e-01f, -1.78910881e-01f, 3.37808967e-01f, 1.83211967e-01f, -1.64980218e-01f, 1.43079311e-01f, 1.26044989e-01f, 3.90178487e-02f, 1.97951943e-01f, -1.18589386e-01f,
  9.79892313e-01f, -6.18508160e-01f, -5.83951473e-01f, 5.13209820e-01f, 3.45207661e-01f, 2.71117002e-01f, 3.83375362e-02f, 3.26364130e-01f, 2.89548159e-01f, -1.68212175e-01f,
  -2.55277932e-01f, -3.05773973e-01f, -4.57336009e-01f, -4.37016129e-01f, -3.36226135e-01f, -3.02980185e-01f, -1.69260636e-01f, -1.84093252e-01f, 1.16361588e-01f, 2.71254957e-01f,
  6.71186969e-02f, 3.01131517e-01f, 2.45837301e-01f, 2.90892855e-03f, -1.39545843e-01f, -1.15395278e-01f, -1.55330867e-01f, -1.02858983e-01f, -3.79487902e-01f, -6.27262950e-01f,
  -6.06919706e-01f, -5.82838431e-02f, 9.48891938e-02f, -1.30334169e-01f, -1.48164168e-01f, 1.54300377e-01f, -1.03080552e-02f, 1.10635489e-01f, 1.81652099e-01f, 2.28156835e-01f,
  -2.31906492e-02f, -3.68909985e-02f, -1.72067359e-01f, -1.02592357e-01f, 1.45024359e-01f, 7.52265900e-02f, 7.85487592e-02f, 1.19623199e-01f, -1.60018057e-01f, -1.09274007e-01f,
  -3.26644570e-01f, 2.62847124e-03f, 1.16224632e-01f, 1.59151256e-01f, -6.55359477e-02f, 3.00020818e-02f, -7.60485157e-02f, 3.22411433e-02f, -4.35287170e-02f, 2.33061135e-01f,
  -3.50420594e-01f, -3.93476747e-02f, -1.53715506e-01f, 6.94588646e-02f, 2.11624295e-01f, 1.02502897e-01f, 5.44923730e-03f, 8.20929483e-02f, -2.62558199e-02f, 9.18683782e-02f,
  1.47566022e-02f, -1.45164907e-01f, -1.00747868e-02f, 8.64183679e-02f, -2.61719525e-01f, -1.17736466e-01f, -6.02130368e-02f, -4.63818461e-02f, -8.48764405e-02f, 1.61901992e-02f,
  -2.24771723e-01f, -5.37802912e-02f, -6.71190768e-02f, -1.37334302e-01f, -1.64281040e-01f, -8.48769471e-02f, -1.09397493e-01f, -2.10504815e-01f, -1.80251542e-02f, 1.27284437e-01f,
  -1.56071141e-01f, -2.38745004e-01f, 1.56276170e-02f, -1.70017928e-01f, 8.24170038e-02f, -6.19903393e-02f, -2.33089760e-01f, -1.26649633e-01f, -3.41789261e-03f, -1.50536910e-01f,
  -8.51705894e-02f, -1.20369410e-02f, -1.76861480e-01f, -2.67238319e-02f, 3.46608043e-01f, 1.86480328e-01f, 1.12929359e-01f, 2.78850086e-02f, -1.22122668e-01f, 1.77621618e-02f,
  -1.66737035e-01f, 1.83075279e-01f, 3.05390596e-01f, 8.50795209e-02f, 1.53234214e-01f, 5.68570755e-02f, -8.56327266e-03f, 2.00343698e-01f, 2.03524023e-01f, 5.54786146e-01f,
  -2.28087708e-01f, -1.22304164e-01f, 3.86261642e-01f, 5.83780944e-01f, 5.13080657e-01f, 4.17121619e-01f, 5.36171496e-01f, 4.24029738e-01f, 3.47878367e-01f, 3.25737417e-01f,
  -6.88386783e-02f, 5.76068908e-02f, 1.67387411e-01f, 1.31270543e-01f, 1.51849642e-01f, 4.89264369e-01f, 6.00096822e-01f, 3.60372931e-01f, 3.49941671e-01f, 3.05527776e-01f,
  2.57498235e-01f, 1.41748577e-01f, -6.61509112e-02f, 2.53457934e-01f, 1.29650623e-01f, 2.28263095e-01f, 1.44482434e-01f, 1.30150825e-01f, 2.83537060e-02f, 4.18232560e-01f,
  -1.56329229e-01f, -2.71999806e-01f, 8.80496278e-02f, -2.02936172e-01f, -3.40508223e-01f, -2.05084816e-01f, -5.00288643e-02f, 4.66431901e-02f, 5.24476310e-03f, 6.96574673e-02f,
  -5.84686026e-02f, -1.59529820e-01f, -9.34329405e-02f, -1.21461023e-02f, -5.41842729e-02f, -8.29467848e-02f, -1.26902521e-01f, 1.10280089e-01f, 1.91932127e-01f, -1.40459701e-01f,
  2.80966684e-02f, 3.22834738e-02f, 1.03688687e-01f, 5.42724580e-02f, -8.23025778e-02f, -1.08707182e-01f, -2.34026656e-01f, -1.79937780e-01f, -9.26175117e-02f, -3.30234431e-02f,
  3.55146915e-01f, 1.03843123e-01f, -3.77050638e-02f, 1.29257768e-01f, -4.94015142e-02f, 2.63468735e-02f, 1.67858109e-01f, 2.32237101e-01f, 7.01631233e-02f, -4.11702581e-02f,
  6.26050085e-02f, 4.75285649e-02f, 1.29436031e-01f, 1.09752752e-01f, -8.47526491e-02f, 1.26704067e-01f, 2.82908175e-02f, -4.60188165e-02f, -2.11681753e-01f, -1.01480559e-01f,
  -1.05412774e-01f, 7.54646212e-02f, -2.36142769e-01f, -2.66796630e-02f, -8.89182538e-02f, 1.05560057e-01f, 5.40593415e-02f, -1.65373702e-02f, -1.05747893e-01f, -7.09905401e-02f,
  2.44561195e-01f, -2.04893380e-01f, 3.06264926e-02f, 2.33363077e-01f, 7.86813814e-03f, -2.30231345e-01f, -5.02624251e-02f, -8.04088935e-02f, -1.29267752e-01f, 1.11634126e-02f,
  -1.05257504e-01f, -1.22942157e-01f, -1.32468298e-01f, -7.23650074e-03f, 2.38206629e-02f, 7.29734078e-02f, -1.48385569e-01f, 3.16894978e-01f, 1.68933302e-01f, 9.80606005e-02f,
  -5.69434203e-02f, 2.14903355e-01f, 2.26727381e-01f, 2.30169386e-01f, -1.08035810e-01f, 1.33360744e-01f, -1.15955293e-01f, -1.05872765e-01f, 2.53222473e-02f, 6.72809482e-02f,
  -2.83406824e-01f, 3.58291492e-02f, -5.94121099e-01f, 4.10684794e-02f, -6.35352358e-02f, -1.97641015e-01f, -1.11591101e-01f, 1.50172263e-01f, 5.07437229e-01f, 2.80842543e-01f,
  -9.84644070e-02f, -3.74226958e-01f, -5.87175786e-01f, -4.09081429e-01f, -5.38781404e-01f, -3.28112096e-01f, -4.07289207e-01f, -7.98412740e-01f, -6.06617868e-01f, -1.87751785e-01f,
  -1.57789469e-01f, -3.69330764e-01f, -4.06947017e-01f, -3.54840785e-01f, 6.50437409e-03f, -5.85557997e-01f, -2.83058912e-01f, -4.35694158e-01f, -4.98503387e-01f, -4.20804143e-01f,
  -3.63007128e-01f, -3.20713431e-01f, -1.37385860e-01f, -1.81434557e-01f, 2.43023649e-01f, 1.36866003e-01f, 2.00472362e-02f, -3.46177727e-01f, -1.94022104e-01f, 1.20692931e-01f,
  -2.43238285e-01f, 2.56380826e-01f, 3.45869921e-04f, -3.66702676e-02f, -2.32809901e-01f, -1.80285439e-01f, 1.69272661e-01f, -2.01308995e-01f, 2.09817570e-02f, 2.12026000e-01f,
  1.06407538e-01f, -4.84713703e-01f, -5.82508624e-01f, -1.62304446e-01f, 5.91421388e-02f, -5.13869584e-01f, -6.87887445e-02f, -2.30045334e-01f, -4.57295835e-01f, -1.56996801e-01f,
  3.54086578e-01f, 2.14348286e-02f, 1.13017261e-01f, 1.49982676e-01f, 1.42816141e-01f, -1.34726269e-02f, -7.88809657e-02f, 2.93572377e-02f, 1.11360304e-01f, 3.52013321e-03f,
  1.48242805e-02f, 1.56683162e-01f, -1.33619579e-02f, -1.75460309e-01f, -3.26467335e-01f, 3.45244184e-02f, -1.71821550e-01f, -1.06106989e-01f, -2.27636576e-01f, -1.44090816e-01f,
  -1.79752782e-01f, -6.16469085e-02f, -6.46620095e-02f, -1.31154999e-01f, -1.41593799e-01f, -1.09271714e-02f, 1.18928149e-01f, -4.24415171e-02f, 9.18927342e-02f, 3.10201440e-02f,
  -1.26804888e-01f, -2.86354870e-01f, -2.59007215e-01f, -1.24012306e-01f, 9.07772258e-02f, 1.10528171e-01f, -8.23097974e-02f, 1.88989386e-01f, -6.23626709e-02f, 2.92353362e-01f,
  -1.53875634e-01f, 2.34032243e-01f, -1.74454585e-01f, 1.10697925e-01f, -1.34234160e-01f, -1.41650047e-02f, 3.28727633e-01f, -2.75789440e-01f, -2.41598338e-01f, 3.19609553e-01f,
  3.23130548e-01f, -4.72648263e-01f, -5.78704298e-01f, -2.79576093e-01f, -1.74707398e-01f, -6.58721089e-01f, -3.64906341e-01f, -3.32079679e-01f, -6.04525447e-01f, -2.29335725e-02f,
  1.13920009e+00f, 1.54430628e-01f, -2.11976208e-02f, -2.98645329e-02f, -3.84921551e-01f, -2.11829513e-01f, -2.37930492e-01f, -1.29282540e-02f, 6.23356439e-02f, 6.21422827e-02f,
  9.91393253e-02f, 2.74255246e-01f, 2.06620038e-01f, 2.77528703e-01f, 2.29864150e-01f, -5.67923188e-02f, -1.88770309e-01f, 2.26385787e-01f, 1.09625667e-01f, 1.58947296e-02f,
  -1.97081640e-02f, 3.77676263e-02f, 2.97745466e-01f, 6.60194457e-02f, -1.83058098e-01f, -3.41566689e-02f, -1.90121993e-01f, -2.31022298e-01f, -2.96527147e-01f, -2.26129174e-01f,
  2.23269500e-02f, 3.01489443e-01f, 2.43102968e-01f, 2.93315768e-01f, 1.37745798e-01f, 2.89704174e-01f, 1.73655376e-01f, 8.82613733e-02f, -5.28646708e-02f, -1.16433322e-01f,
  5.36438543e-03f, -1.71731296e-03f, -1.20909489e-03f, -8.22326913e-02f, -8.28953609e-02f, 5.48880547e-02f, 1.49655759e-01f, 1.20516911e-01f, 6.49297163e-02f, 2.35756934e-02f,
  5.04562743e-02f, -1.97617531e-01f, -1.26263991e-01f, 3.96312661e-02f, 2.25668535e-01f, 2.68374141e-02f, 2.81603001e-02f, 1.73988014e-01f, 4.36675027e-02f, 6.47681653e-02f,
  -4.73765060e-02f, 3.28120023e-01f, 1.74777344e-01f, -2.93550007e-02f, 7.37414882e-03f, -1.39482617e-01f, -2.16542795e-01f, -2.19918236e-01f, -2.89605930e-03f, -5.32803126e-02f,
  -2.17160910e-01f, -6.68175370e-02f, -3.55085498e-03f, -1.93533972e-01f, 9.94739681e-02f, -2.21651681e-02f, -8.32126886e-02f, 7.05455244e-02f, -1.15280552e-02f, 8.92433804e-03f,
  -1.27926573e-01f, -1.36537209e-01f, -1.72762737e-01f, -3.37314196e-02f, -1.88625932e-01f, -3.98398004e-02f, -7.78614432e-02f, 5.58500364e-02f, -1.13738090e-01f, -9.47110876e-02f,
  -1.83481798e-01f, 1.70392871e-01f, 1.31147057e-01f, 2.08428577e-01f, -8.25621262e-02f, 9.79987606e-02f, 9.81088579e-02f, -6.32746741e-02f, -2.78245747e-01f, -6.42777905e-02f,
  -5.87609299e-02f, 1.01046108e-01f, 1.30580604e-01f, 5.49350083e-02f, -1.18000112e-01f, 1.90364919e-03f, 1.17441580e-01f, 5.67441210e-02f, -5.57253659e-02f, 7.24450266e-03f,
  9.54601467e-02f, -8.28644186e-02f, -1.80480760e-02f, -9.54617783e-02f, 6.53399751e-02f, 6.76810369e-02f, -3.84259671e-02f, -1.53063200e-02f, -7.78085068e-02f, -3.36067937e-02f,
  5.10221064e-01f, 5.26332617e-01f, 2.01739103e-01f, 9.17231441e-02f, 2.48016670e-01f, 1.41589940e-01f, 1.86115101e-01f, -1.77042902e-01f, -2.64584303e-01f, 4.13131490e-02f,
  1.19264930e-01f, -2.52371699e-01f, -1.39157146e-01f, -3.08377534e-01f, -2.04037324e-01f, -8.82926509e-02f, -1.77672822e-02f, -1.43183157e-01f, -2.11545214e-01f, -2.62401223e-01f,
  -6.21465482e-02f, 1.00862004e-01f, 8.21703002e-02f, -9.98291373e-02f, 1.36288151e-01f, -1.17832616e-01f, 4.09605987e-02f, 3.01406920e-01f, 3.06991130e-01f, 3.59290212e-01f,
  1.72867700e-01f, 5.40837348e-01f, -4.41989869e-01f, -1.02255762e-01f, 1.41198948e-01f, -8.51419047e-02f, -8.57260078e-02f, -1.00172617e-01f, -1.04687832e-01f, -1.43565416e-01f,
  1.44307792e-01f, 1.25945956e-01f, 1.88533664e-01f, -7.07029030e-02f, -2.39795391e-02f, -1.60835057e-01f, -1.13494821e-01f, -1.65926039e-01f, -2.45545313e-01f, 5.12848943e-02f,
  1.32047027e-01f, 3.42765927e-01f, 1.86559841e-01f, -2.99134821e-01f, -3.58598739e-01f, -1.86821535e-01f, 6.83894753e-02f, 1.50114279e-02f, -2.02696934e-01f, -1.65945098e-01f,
  -4.49616104e-01f, -2.20471665e-01f, -2.77249608e-02f, -1.46472722e-01f, -2.15101287e-01f, -1.52105287e-01f, -1.28617927e-01f, -8.76233801e-02f, -1.77723303e-01f, 6.25189766e-02f,
  -8.83340314e-02f, -8.56890231e-02f, -1.68764561e-01f, -8.82664099e-02f, -1.71745986e-01f, 3.14636193e-02f, -7.27983341e-02f, -2.51861751e-01f, -1.20569043e-01f, -4.80537899e-02f,
  -5.55104837e-02f, -1.06746135e-02f, 1.05129451e-01f, -7.23960623e-02f, -9.53468010e-02f, -2.58256137e-01f, -3.16319168e-01f, -1.49141058e-01f, -1.44368410e-01f, 1.15029784e-02f,
  -2.75943756e-01f, 2.16843605e-01f, -5.71556240e-02f, 2.16051012e-01f, 2.79774249e-01f, 1.22070558e-01f, 1.87811568e-01f, 1.92663953e-01f, 2.28435919e-01f, -3.27743627e-02f,
  9.25709009e-02f, -1.45800784e-02f, 1.17191665e-01f, 3.50875594e-03f, 9.13304240e-02f, -9.74902883e-02f, 1.23001799e-01f, 8.98532476e-03f, 1.99844167e-02f, 3.21257636e-02f,
  -3.66100259e-02f, -1.15685433e-01f, -3.36662143e-01f, -2.41808087e-01f, -2.37107873e-01f, -3.58828604e-01f, -1.99098185e-01f, -1.99669257e-01f, -2.00670674e-01f, -4.59699720e-01f,
  -1.21966295e-01f, -3.90832692e-01f, 3.50672193e-02f, 4.32957888e-01f, 2.27998674e-01f, 1.52966455e-01f, 2.88194329e-01f, 2.42474496e-01f, 2.96805412e-01f, 5.03366366e-02f,
  -1.02788307e-01f, 4.24174443e-02f, 1.37688458e-01f, 2.21832082e-01f, 2.58800566e-01f, 2.19426483e-01f, 4.02481019e-01f, 3.68649840e-01f, 3.33122194e-01f, 1.28192425e-01f,
  9.44539532e-02f, 5.03973253e-02f, -1.76168323e-01f, 1.57225087e-01f, 1.82508662e-01f, 1.81570902e-01f, 2.32851710e-02f, -1.80205464e-01f, -1.72739223e-01f, 1.64011627e-01f,
  -4.60085392e-01f, -3.12766016e-01f, 1.45507112e-01f, -8.34446475e-02f, -1.38443619e-01f, -1.08199529e-01f, 1.59181170e-02f, -2.21114114e-01f, -1.00228712e-01f, -4.68729846e-02f,
  -7.62546510e-02f, -2.17411637e-01f, 1.44165456e-02f, -2.18371794e-01f, -1.26757339e-01f, -2.35044733e-02f, -7.64945149e-02f, 2.13301405e-02f, 6.01346679e-02f, -1.52676478e-01f,
  -7.13176429e-02f, -2.39003539e-01f, -8.20596740e-02f, 1.36769684e-02f, 1.00739971e-01f, -4.58034454e-03f, -1.02757998e-01f, -1.04566179e-01f, -2.11600568e-02f, -1.46354064e-01f,
  1.17872462e-01f, -4.14020643e-02f, 1.09796248e-01f, 8.85432884e-02f, 3.30060534e-02f, 9.44465697e-02f, 1.40423968e-01f, 6.33190349e-02f, 1.72028944e-01f, 5.46745546e-02f,
  1.93240106e-01f, 1.60561711e-01f, 1.92054659e-01f, 4.32877690e-02f, 1.11522749e-01f, 5.07154018e-02f, -5.95997795e-02f, -2.21921638e-01f, 4.89021651e-02f, -4.01341468e-02f,
  9.21769142e-02f, 1.21299028e-01f, 8.35533217e-02f, 1.22641928e-01f, -3.22758630e-02f, 1.13614000e-01f, 1.39637843e-01f, -8.13303068e-02f, 9.49586704e-02f, -7.73304999e-02f,
  -3.14132601e-01f, -8.00866261e-02f, 2.44013667e-01f, -1.38935456e-02f, -1.27164796e-01f, -1.26273364e-01f, 8.31605773e-03f, -1.34616151e-01f, -1.59161851e-01f, 4.16023061e-02f,
  -1.97187975e-01f, 5.89981638e-02f, -4.66971546e-02f, 6.38825912e-03f, 2.80815735e-02f, -1.67337600e-02f, -4.35462147e-02f, 2.32763365e-02f, -3.66351046e-02f, -1.00822464e-01f,
  -7.31754750e-02f, 8.19106176e-02f, 1.26338638e-02f, 7.54196942e-02f, -1.93230081e-02f, 1.35657594e-01f, -2.64705122e-02f, -8.46944675e-02f, -5.99963926e-02f, 1.07368067e-01f,
  -5.90095580e-01f, 7.10128546e-01f, 5.65443158e-01f, -4.53184128e-01f, -8.78529102e-02f, 3.55506957e-01f, 8.09719265e-01f, 1.65354639e-01f, -5.03371477e-01f, 5.87627999e-02f,
  9.65311565e-03f, -4.29492831e-01f, -7.91485384e-02f, 1.04811311e-01f, 5.67825317e-01f, 5.22798300e-01f, 4.81945574e-01f, 3.06809187e-01f, -1.60597190e-01f, -1.49884939e-01f,
  -1.47015154e-01f, -1.03677563e-01f, -5.11924997e-02f, -4.39380705e-02f, -3.64504486e-01f, -3.38312209e-01f, 2.53391623e-01f, -6.23947196e-02f, 2.52527684e-01f, 5.03055155e-02f,
  -4.40594137e-01f, 3.65140773e-02f, -2.73134053e-01f, -3.18543345e-01f, -3.07674315e-02f, 2.24574897e-02f, -6.20596223e-02f, -4.76473980e-02f, 9.61057376e-03f, 4.14079055e-02f,
  -3.95397805e-02f, 1.05514387e-02f, 7.44961621e-03f, 4.23206538e-02f, -1.14348695e-01f, -4.78901006e-02f, 1.92630157e-01f, 2.50420958e-01f, 2.38164663e-02f, 8.22173804e-02f,
  1.29194990e-01f, -2.80941725e-01f, -2.18501687e-01f, 2.61151791e-01f, 1.95396721e-01f, -2.39496544e-01f, 6.73884079e-02f, -1.81935325e-01f, 1.45217136e-01f, -2.37438321e-01f,
  -1.19229078e-01f, 1.45898819e-01f, 9.98576358e-02f, 1.07581526e-01f, 1.33254707e-01f, -2.99935825e-02f, 1.03449456e-01f, 2.22274855e-01f, -5.41647011e-03f, -3.83509463e-03f,
  4.51323837e-02f, -1.54012278e-01f, -1.99456081e-01f, -1.14513427e-01f, -1.73712522e-01f, -7.57249910e-03f, 3.63426507e-02f, 1.05163731e-01f, 2.40930840e-02f, 6.43244535e-02f,
  -1.86952680e-01f, 5.32045998e-02f, -3.44876736e-01f, 5.26553355e-02f, -3.74279283e-02f, -7.53477775e-03f, -1.86836004e-01f, -1.97397858e-01f, -2.19789505e-01f, -3.05781718e-02f,
  -5.57915986e-01f, 4.87526327e-01f, -5.11919081e-01f, 2.05374226e-01f, -2.17797211e-03f, 8.58006924e-02f, 2.53411122e-02f, -2.23224759e-02f, -9.63560566e-02f, -2.08233371e-01f,
  -1.74084995e-02f, -5.65126650e-02f, -1.25296386e-02f, 1.33965120e-01f, -2.08624929e-01f, -5.43643832e-02f, 3.91339920e-02f, -7.20789060e-02f, 1.21702015e-01f, -2.55723707e-02f,
  8.06889534e-02f, -1.07332006e-01f, -6.65033996e-01f, -1.59631014e-01f, -3.77273142e-01f, -6.76886678e-01f, -2.38263980e-01f, -4.24086332e-01f, -5.43395914e-02f, -1.92943528e-01f,
  7.08522052e-02f, -7.74119794e-01f, 1.38327420e-01f, -1.38356820e-01f, -3.55545998e-01f, -4.30010080e-01f, -8.69239807e-01f, -2.69303471e-01f, -5.34546860e-02f, -6.57224894e-01f,
  -2.98797041e-01f, 5.78158498e-01f, 6.73110127e-01f, 6.09941542e-01f, 3.72398347e-01f, -8.29211950e-01f, -7.03293025e-01f, 5.02421856e-01f, 6.75940990e-01f, -2.32415468e-01f,
  -5.29239595e-01f, -8.05290639e-02f, 1.73435077e-01f, 1.69064313e-01f, -4.36370224e-01f, -8.35295115e-03f, -2.27306783e-01f, -2.25955829e-01f, -4.79394734e-01f, -5.05256653e-01f,
  3.34064484e-01f, -2.21734390e-01f, 2.34005168e-01f, -5.82585819e-02f, -9.26411152e-02f, -6.33820053e-03f, -3.15171108e-02f, -6.04146905e-02f, -1.17484078e-01f, -4.16916162e-02f,
  -4.74194363e-02f, 6.79897442e-02f, 2.00308830e-01f, -1.71056073e-02f, -8.09215382e-02f, -5.75686805e-02f, -1.20230801e-01f, 7.10347295e-02f, 3.91998887e-03f, -1.35836557e-01f,
  -2.04730317e-01f, -1.27609134e-01f, 1.16690516e-01f, -1.19364969e-01f, -4.24619857e-03f, 3.23850900e-01f, -6.87816143e-02f, -2.47208491e-01f, 1.22782916e-01f, -4.59865212e-01f,
  -9.96993557e-02f, 3.20759080e-02f, -1.35769859e-01f, -4.28125933e-02f, -1.38818204e-01f, -1.90424118e-02f, 4.24795076e-02f, -6.83919415e-02f, 5.08475490e-02f, 6.34704083e-02f,
  2.57898662e-02f, -6.69088680e-03f, 5.39680533e-02f, -8.99900720e-02f, -5.89338737e-03f, 8.21214821e-03f, 4.31320118e-03f, 2.42497511e-02f, -6.77224398e-02f, -1.37983233e-01f,
  1.15768779e-02f, -2.16678634e-01f, 7.42162913e-02f, 5.93592003e-02f, -1.34071246e-01f, 2.09511951e-01f, -1.22900447e-02f, 1.31574258e-01f, 5.81312887e-02f, -2.06762642e-01f,
  4.01440501e-01f, 3.70235085e-01f, -6.77046850e-02f, 6.54610693e-02f, -1.78778663e-01f, -5.36449663e-02f, -1.20648511e-01f, 1.71558131e-02f, -5.14416173e-02f, -3.90829109e-02f,
  -8.78307670e-02f, 1.65635735e-01f, 7.97031894e-02f, -1.87871754e-02f, -1.23883672e-01f, -1.32392451e-01f, -1.57644629e-01f, 6.39773905e-02f, -1.25783071e-01f, -1.63531333e-01f,
  -2.36528188e-01f, -1.21817313e-01f, 1.19717225e-01f, -6.17867860e-04f, -1.82746530e-01f, 2.25640759e-01f, 6.09606467e-02f, -1.39767662e-01f, 2.54361808e-01f, -2.90601224e-01f,
  1.06287777e+00f, 3.86685371e-01f, 1.87165305e-01f, 3.28532130e-01f, -1.89269498e-01f, -1.55887455e-01f, -7.88128749e-02f, 1.31620154e-01f, 1.10141180e-01f, 4.87252265e-01f,
  1.86980009e-01f, 2.81007111e-01f, 1.82948545e-01f, 2.68910229e-01f, 3.59482974e-01f, 1.84509188e-01f, 1.76566228e-01f, 4.46615070e-01f, 2.37101197e-01f, 4.26366806e-01f,
  3.10723513e-01f, 2.99859792e-01f, 2.95148045e-01f, 2.15123668e-01f, 3.16975027e-01f, 1.33632421e-01f, 8.55521336e-02f, 2.43909210e-01f, 2.95625180e-01f, 3.64240795e-01f,
  7.47325182e-01f, 4.69866544e-01f, -3.70296121e-01f, -1.61473796e-01f, -1.52548864e-01f, 4.51081805e-02f, -7.61836395e-02f, -1.83991104e-01f, -6.30624369e-02f, 4.47390229e-02f,
  -1.36736795e-01f, 7.28808567e-02f, 3.94948013e-02f, -9.18081328e-02f, -5.93377240e-02f, -9.83473957e-02f, 8.31011459e-02f, 2.06988111e-01f, -1.58806339e-01f, 1.51603580e-01f,
  4.18149717e-02f, 1.13615446e-01f, -2.25919396e-01f, -4.18059200e-01f, -2.89274286e-02f, -1.46233574e-01f, -1.34534150e-01f, 7.30725890e-03f, -3.07757139e-01f, 3.50757509e-01f,
  5.60104027e-02f, 1.55701354e-01f, 2.25520164e-01f, 2.85296500e-01f, 5.17605484e-01f, 5.38367964e-02f, 1.56985205e-02f, 1.02617569e-01f, 1.87775671e-01f, 2.35939641e-02f,
  1.51917851e-02f, 1.37548938e-01f, 3.81767265e-02f, 1.11053199e-01f, 1.57014608e-01f, -1.51008961e-03f, -9.48844478e-02f, -6.88762665e-02f, -1.90748516e-02f, -9.52618942e-02f,
  1.78095907e-01f, -6.50540292e-02f, -1.23205528e-01f, -7.11211711e-02f, -2.82725215e-01f, -5.28361797e-02f, 5.10575920e-02f, -4.10081521e-02f, -4.16607633e-02f, 8.13307241e-02f,
  -6.28598750e-01f, -3.60062778e-01f, 3.02099913e-01f, 4.41185907e-02f, -3.10028121e-02f, -9.86072719e-02f, 1.26511648e-01f, -9.37701613e-02f, -2.64853202e-02f, 9.43353698e-02f,
  -9.52822249e-03f, 1.09184571e-01f, -5.78398742e-02f, -2.96193194e-02f, -7.52751380e-02f, -1.73881158e-01f, -2.58793179e-02f, -6.69298619e-02f, -2.66706437e-01f, -1.69192582e-01f,
  -2.55111694e-01f, -2.25010470e-01f, -1.87352657e-01f, -3.49802345e-01f, -1.43331677e-01f, -3.26992512e-01f, -1.77858368e-01f, -2.08562464e-01f, -2.85690188e-01f, -3.16733718e-01f,
  -1.04806356e-01f, 2.31844246e-01f, 1.90626904e-01f, 3.42345476e-01f, 4.94390011e-01f, 4.56351519e-01f, 5.54311395e-01f, 2.39168361e-01f, 2.66834795e-02f, 1.09854296e-01f,
  3.75004560e-01f, 4.44407240e-02f, 1.11375093e-01f, 6.09619282e-02f, 1.53255910e-01f, 2.38394886e-01f, 1.26495659e-01f, -1.55735806e-01f, -1.24501608e-01f, 7.50370100e-02f,
  1.61494851e-01f, 9.10729766e-02f, -8.52819011e-02f, -3.21379863e-02f, 3.01898760e-03f, -5.36783189e-02f, 2.76784807e-01f, 2.15729862e-01f, 8.38198587e-02f, -2.95100302e-01f,
  -7.80413821e-02f, 2.32886612e-01f, -1.05873838e-01f, 4.25816812e-02f, 1.25279769e-01f, -2.02292934e-01f, 8.02177116e-02f, -1.58272639e-01f, -1.17620684e-01f, -1.61901265e-01f,
  1.33719325e-01f, 3.90622988e-02f, 1.74578160e-01f, 3.76389436e-02f, 8.07674378e-02f, -5.98418787e-02f, -6.21150471e-02f, -1.20235421e-01f, 1.31585792e-01f, 3.02411616e-02f,
  7.04363361e-02f, 1.67657539e-01f, 1.50415227e-01f, 7.33808577e-02f, 2.40602896e-01f, 7.83290938e-02f, 1.08799718e-01f, 4.26248275e-02f, 1.32961541e-01f, -2.00221941e-01f,
  8.51323456e-02f, -7.46890679e-02f, 1.90231293e-01f, 1.88013408e-02f, 8.40737149e-02f, -5.90886772e-02f, 1.57075953e-02f, 1.03040300e-01f, 2.07438782e-01f, 8.12897757e-02f,
  -3.49804536e-02f, 1.42879948e-01f, 4.39766273e-02f, 1.19158223e-01f, 1.97933130e-02f, 8.35273415e-02f, -1.10419570e-02f, 1.14761636e-01f, 1.58912212e-01f, 3.84387895e-02f,
  1.44906834e-01f, -1.20199546e-02f, -1.27721325e-01f, -4.36176686e-03f, 1.25077867e-03f, 2.41144355e-02f, 6.92564202e-03f, 6.78657740e-02f, 1.13185920e-01f, -1.33218011e-02f,
  1.86884895e-01f, 6.46971524e-01f, -2.84251571e-01f, -1.29020289e-01f, 1.79039799e-02f, -2.03034639e-01f, 1.90957636e-02f, -2.37444714e-01f, -1.11550301e-01f, -1.93444714e-01f,
  1.95889007e-02f, -2.52681226e-01f, 3.84005792e-02f, -1.11474283e-02f, -3.47725712e-02f, -7.36744255e-02f, -2.73358338e-02f, 2.01654714e-02f, -5.12176333e-03f, -8.51357728e-02f,
  1.07659390e-02f, -1.54579571e-02f, -1.17486799e-02f, -4.34825197e-02f, 9.04193893e-02f, -4.75948006e-02f, -1.30708501e-01f, -3.62926237e-02f, 6.28165901e-02f, -2.46174380e-01f,
  -9.54947114e-01f, -8.18729997e-01f, -3.73563528e-01f, -3.65252942e-02f, 5.49699247e-01f, -1.87183067e-01f, -6.08981967e-01f, -4.02103245e-01f, -8.98099244e-02f, -4.25468177e-01f,
  4.07330185e-01f, 5.48328221e-01f, -2.27969959e-02f, 1.56282231e-01f, -2.41025791e-01f, -7.00863838e-01f, -2.69930273e-01f, 1.55471906e-01f, 5.14820158e-01f, 5.19120216e-01f,
  3.53896379e-01f, 1.93411380e-01f, 1.58520088e-01f, 7.52516985e-02f, 4.44950499e-02f, 1.15895547e-01f, -2.73979127e-01f, 1.55262560e-01f, -1.51708871e-01f, -2.07193419e-01f,
  -2.01029047e-01f, -4.74293888e-01f, 2.00415120e-01f, 4.48280185e-01f, 6.07271850e-01f, -4.65066671e-01f, -2.22792655e-01f, -6.86347187e-02f, 4.30450179e-02f, -3.46018165e-01f,
  1.86876759e-01f, 3.17997159e-03f, 4.61153060e-01f, -6.17279820e-02f, -5.67109659e-02f, -2.73059845e-01f, -1.04709439e-01f, -2.07002297e-01f, -3.48090351e-01f, 1.73445717e-02f,
  3.42879176e-01f, 4.76864845e-01f, -1.10660665e-01f, -3.02381486e-01f, -4.74033445e-01f, 8.59370679e-02f, -1.19953476e-01f, -1.67593196e-01f, -5.81935048e-01f, -5.77332318e-01f,
  3.00342619e-01f, 1.47034585e-01f, 5.14629558e-02f, -4.10165340e-02f, 4.44422476e-02f, 2.23877802e-02f, -9.77958143e-02f, 2.92087346e-02f, 1.66486621e-01f, -1.29488528e-01f,
  1.60235211e-01f, 4.13699746e-02f, 1.56990752e-01f, -7.98110068e-02f, 8.55266154e-02f, 9.37544089e-03f, -3.66946869e-02f, -1.10198796e-01f, 1.36783674e-01f, -1.69249192e-01f,
  7.86224157e-02f, 1.51172513e-02f, 5.15992977e-02f, 1.08924836e-01f, -1.43313617e-01f, 1.53516587e-02f, -2.44396389e-01f, -7.75778517e-02f, -1.36232330e-02f, -1.18723504e-01f,
  -2.54836857e-01f, 8.14263746e-02f, -3.07289928e-01f, 9.47972760e-02f, 1.01671629e-02f, 1.30195707e-01f, 9.31580141e-02f, 5.05722091e-02f, -7.27394521e-02f, -8.09684992e-02f,
  -1.48707004e-02f, -1.54926524e-01f, -1.41013935e-01f, 7.31305629e-02f, 8.23081881e-02f, -1.06238805e-01f, -2.19348162e-01f, 1.60766929e-01f, -1.49966374e-01f, 9.23899859e-02f,
  -2.33125344e-01f, -2.00978845e-01f, -5.08423984e-01f, -3.99359614e-01f, -2.77744412e-01f, -1.18524492e-01f, -3.05251300e-01f, -2.03614876e-01f, -5.41706204e-01f, -7.94051588e-01f,
  -1.01041079e+00f, 4.68148738e-02f, 4.98410285e-01f, -2.50715226e-01f, -3.79425257e-01f, -2.72820324e-01f, -1.23443544e-01f, -2.51190752e-01f, 8.97972845e-03f, 1.41414389e-01f,
  9.74458903e-02f, -1.36687696e-01f, 2.81590372e-02f, 7.53689208e-04f, -2.99326301e-01f, 2.02038541e-01f, 1.68758612e-02f, -2.06176400e-01f, -5.88668883e-01f, -6.18140996e-01f,
  -5.42111158e-01f, -5.93441069e-01f, -5.34598351e-01f, -2.50362128e-01f, -6.99150786e-02f, -1.56770051e-01f, 2.05847800e-01f, -1.44992784e-01f, -3.05649102e-01f, 1.05175087e-02f,
  4.42022145e-01f, -5.25616348e-01f, -1.39944613e-01f, -2.22230569e-01f, -8.23905505e-03f, 6.58880621e-02f, -1.22285616e-02f, 2.32713833e-01f, 6.14870973e-02f, 1.32718518e-01f,
  -3.81910279e-02f, -2.32804753e-02f, 4.49728444e-02f, 1.16853379e-02f, 6.88604638e-03f, 3.21598239e-02f, 3.62362638e-02f, -3.00854933e-03f, 1.42951077e-02f, 7.98999295e-02f,
  -1.64054465e-02f, -8.01800862e-02f, 1.66643098e-01f, -7.28020892e-02f, -2.96543390e-02f, -2.28530049e-01f, -6.36354908e-02f, -1.58575803e-01f, 4.43243794e-02f, 1.26118779e-01f,
  8.72131065e-02f, 3.10997486e-01f, -1.42904028e-01f, -7.59374127e-02f, 1.32383496e-01f, 1.77632779e-01f, 9.00786519e-02f, 4.20951061e-02f, -1.27046611e-02f, 1.53723650e-03f,
  -3.58371325e-02f, 1.43778294e-01f, 1.06609156e-02f, 8.01379755e-02f, 2.04639714e-02f, -1.06601112e-01f, -1.62145764e-01f, -8.72638635e-03f, 8.45949873e-02f, 8.49025324e-03f,
  -6.54838383e-02f, -3.88142131e-02f, 1.13552801e-01f, 5.09994589e-02f, -1.50542617e-01f, 1.85495138e-03f, -1.62503183e-01f, -9.91447195e-02f, -1.01269908e-01f, -1.48039222e-01f,
  -4.44701426e-02f, -2.94845194e-01f, 1.40990973e-01f, -9.25584957e-02f, 4.28980775e-03f, 8.21378157e-02f, -1.17368802e-01f, 7.07187597e-03f, -6.34723157e-02f, 1.27462018e-02f,
  5.23706572e-03f, 1.50764391e-01f, 1.15370832e-01f, 2.37559319e-01f, 1.61211923e-01f, 8.70624483e-02f, -3.31486091e-02f, -2.01010592e-02f, 3.25716063e-02f, 1.27481043e-01f,
  1.39178455e-01f, 1.44401878e-01f, 1.64560899e-01f, 2.48990133e-01f, -1.13144834e-02f, -1.40303925e-01f, 1.10457748e-01f, 7.99796581e-02f, 6.16563410e-02f, 2.51403421e-01f,
  -1.16910887e+00f, -1.91732049e-01f, 3.73939604e-01f, -6.91471875e-01f, 2.50255316e-02f, 4.57590073e-01f, 8.00912678e-01f, 4.42066826e-02f, -4.15484875e-01f, 6.60833344e-02f,
  -1.88619763e-01f, -4.75499988e-01f, -4.04989779e-01f, -1.65679753e-01f, 2.90470198e-02f, 5.30842900e-01f, 3.19353163e-01f, 8.04576278e-02f, 2.40639046e-01f, 3.76711547e-01f,
  1.03904016e-01f, -2.01992765e-01f, -4.70198870e-01f, -3.02237779e-01f, -2.32806131e-01f, -1.58587873e-01f, -9.27081406e-02f, -2.61920184e-01f, -4.90856618e-02f, -2.54228652e-01f,
  6.88731134e-01f, -4.32006687e-01f, 6.52515367e-02f, -4.53421503e-01f, -1.34212017e-01f, -1.51407376e-01f, -6.12451993e-02f, -2.26593226e-01f, -1.36405632e-01f, -1.46850765e-01f,
  -3.73486012e-01f, -1.91212654e-01f, -2.22556725e-01f, -5.12035750e-02f, -4.57801148e-02f, -1.04687385e-01f, -2.45250732e-01f, -2.02898622e-01f, -1.55704021e-01f, 5.19847311e-02f,
  8.06270912e-02f, -4.60436894e-03f, 4.82035466e-02f, 1.66641250e-01f, -1.99032396e-01f, -2.09202822e-02f, 4.16620560e-02f, -1.13835648e-01f, -7.14005008e-02f, 3.02536525e-02f,
  1.54482618e-01f, 4.42513227e-02f, -1.38020188e-01f, 1.18593171e-01f, -8.57042335e-03f, 4.90302257e-02f, -5.42276762e-02f, -1.58325434e-02f, 1.12203166e-01f, 6.85537308e-02f,
  -1.78321768e-02f, 1.32667810e-01f, 1.95021126e-02f, -1.64999720e-02f, -9.47957709e-02f, -1.20161138e-01f, -1.14938868e-02f, -4.58126888e-02f, -2.26244759e-02f, -2.22640157e-01f,
  -8.31244811e-02f, -9.53747183e-02f, -1.07820250e-01f, 8.15366656e-02f, 1.23181827e-01f, -2.27643773e-01f, -4.92569953e-02f, -6.81106821e-02f, -9.73824710e-02f, 1.79271642e-02f,
  3.00612658e-01f, -2.05837741e-01f, 9.14360881e-02f, -2.91263998e-01f, -6.80426657e-02f, -1.44081460e-02f, -1.23891570e-01f, -1.21906102e-01f, -1.90848842e-01f, -1.03330947e-02f,
  -1.09965332e-01f, -1.49664328e-01f, -1.26433391e-02f, 9.37628299e-02f, 1.74062923e-01f, 1.58810809e-01f, -1.02162614e-01f, 3.50415483e-02f, -4.34104241e-02f, 1.25480309e-01f,
  -1.71625540e-02f, 1.88428193e-01f, 2.74796993e-01f, 2.78577417e-01f, 1.28828451e-01f, 2.26287976e-01f, 3.76067758e-01f, 2.67877966e-01f, 2.52696842e-01f, 4.85474676e-01f,
  1.09536386e+00f, 3.40671018e-02f, 2.00899288e-01f, 2.63989538e-01f, 9.04630274e-02f, -9.40158665e-02f, -3.23750600e-02f, 2.61259004e-02f, 1.04684092e-01f, 2.84325957e-01f,
  1.99125946e-01f, 1.04201697e-01f, 1.20568514e-01f, -2.43129414e-02f, 8.89612883e-02f, -1.31526724e-01f, -3.60582918e-02f, 2.36773387e-01f, 2.40831733e-01f, 1.53656557e-01f,
  -2.58833021e-02f, 5.37025332e-02f, 3.84143561e-01f, 4.18443345e-02f, -6.45534135e-03f, 4.16510440e-02f, 4.99601215e-02f, 6.24246821e-02f, -4.10567895e-02f, -3.55511159e-02f,
  3.00265756e-02f, 5.20152926e-01f, -1.18370995e-01f, -1.26989573e-01f, 3.18526477e-02f, 6.34354204e-02f, 5.36886975e-02f, 1.56447396e-01f, -3.19951028e-02f, -1.38332054e-01f,
  -2.02471018e-02f, 1.23712420e-01f, 7.84211047e-03f, 5.15239500e-02f, 1.19260050e-01f, 1.38751730e-01f, 2.09140986e-01f, 1.85269862e-01f, -9.13249105e-02f, -3.19817476e-02f,
  -5.50634600e-02f, 2.30301976e-01f, 7.75126517e-02f, -1.03700250e-01f, 3.93710732e-02f, 1.25472546e-01f, -1.84420999e-02f, 9.06148925e-02f, 1.03896007e-01f, 1.32077977e-01f,
  2.91925162e-01f, 4.03309017e-01f, 2.18675435e-01f, 1.46290347e-01f, -3.91717348e-03f, 1.48031265e-01f, 1.37192518e-01f, -7.58522227e-02f, 2.27660000e-01f, 1.90845221e-01f,
  -6.31479770e-02f, 6.86589107e-02f, 2.83855230e-01f, 1.68386787e-01f, 1.74066111e-01f, 5.09515941e-01f, 3.16542953e-01f, 2.19967335e-01f, 1.87612548e-01f, 7.78980777e-02f,
  6.57675192e-02f, 8.94388333e-02f, 3.63558173e-01f, 7.80144474e-03f, 1.31295830e-01f, 3.43904495e-01f, 2.59506881e-01f, 3.58942859e-02f, 2.69679278e-01f, 1.93579659e-01f,
  -3.39513689e-01f, 8.61468166e-02f, -8.94036740e-02f, -5.60131706e-02f, 4.26518098e-02f, 1.32093346e-03f, 1.51319560e-02f, -1.16379522e-01f, -1.75359115e-01f, -2.14302704e-01f,
  -9.55830663e-02f, 2.08151825e-02f, 1.29845338e-02f, 2.94187553e-02f, 1.05820306e-01f, -7.23047629e-02f, -1.76596232e-02f, -2.53441893e-02f, -1.12787083e-01f, -6.68248832e-02f,
  -1.29421458e-01f, -8.86404607e-03f, -6.46299962e-03f, -2.61552662e-01f, -6.73224181e-02f, 9.10778642e-02f, -1.50464639e-01f, -1.78648949e-01f, -1.00658827e-01f, 9.24544130e-03f,
  -6.70157552e-01f, 7.65129209e-01f, 5.99400997e-01f, -6.23744011e-01f, 4.53000039e-01f, 8.27898562e-01f, 8.57697964e-01f, 4.69881237e-01f, -1.98191136e-01f, 2.35850930e-01f,
  5.26174963e-01f, -3.21458548e-01f, -4.30344820e-01f, -3.97889435e-01f, -2.86217272e-01f, 3.10927313e-02f, -4.74839389e-01f, -6.43988967e-01f, -1.85300827e-01f, 3.33968699e-01f,
  -1.39903545e-01f, -4.47491437e-01f, -4.59832460e-01f, -4.75704342e-01f, -2.76525259e-01f, -4.70055014e-01f, -9.24993306e-02f, -7.47460052e-02f, 2.45357543e-01f, -6.90152943e-01f,
  -4.56570297e-01f, 3.94457310e-01f, -1.58783361e-01f, -2.47091249e-01f, 9.82544571e-02f, -2.62671202e-01f, -1.04297079e-01f, -1.16537586e-01f, -1.20646007e-01f, 1.26520311e-02f,
  3.40823978e-02f, 4.99423780e-02f, 6.07164390e-02f, -2.42427081e-01f, 1.18074305e-02f, -5.08174077e-02f, 6.47258200e-03f, -1.66931778e-01f, -3.22668761e-01f, 3.13471377e-01f,
  1.65148955e-02f, 9.14911553e-02f, 2.04862878e-01f, 2.45128736e-01f, 2.27692604e-01f, -1.70322269e-01f, 5.06419003e-01f, 3.85492742e-02f, 9.64267924e-02f, -4.49760497e-01f,
  -2.45856449e-01f, -6.11168407e-02f, 3.35887112e-02f, 1.24246217e-01f, -1.73998296e-01f, -4.38515581e-02f, -1.71024397e-01f, -2.01920971e-01f, -5.17684147e-02f, -1.13877647e-01f,
  1.46404743e-01f, 2.32464090e-01f, 1.47053022e-02f, 8.53888094e-02f, -2.31260851e-01f, -3.27841975e-02f, 3.15497890e-02f, 5.06625418e-03f, 4.65110391e-02f, 2.61893850e-02f,
  -6.90600425e-02f, 6.14299253e-02f, 2.03903273e-01f, -2.04568863e-01f, 3.14898312e-01f, 1.18170738e-01f, 2.86445878e-02f, 1.95231423e-01f, 6.81367144e-02f, 1.96794167e-01f,
  -6.78880334e-01f, 5.60560562e-02f, -5.39856195e-01f, -1.20611385e-01f, -1.62947983e-01f, -9.47261527e-02f, 5.28901070e-03f, 7.32281730e-02f, 9.50970426e-02f, -1.12432577e-01f,
  5.48870206e-01f, -8.48342776e-02f, 1.08289406e-01f, -5.01101576e-02f, -3.36955518e-01f, 5.04024513e-02f, -1.39284953e-01f, -2.52565861e-01f, -1.17845908e-01f, 8.86141881e-02f,
  -1.68992594e-01f, -2.29257762e-01f, -4.51395601e-01f, -3.44899982e-01f, -1.65854972e-02f, -3.46492738e-01f, -3.31869572e-01f, -3.23858291e-01f, -6.41048923e-02f, -7.05376387e-01f,
  3.70726615e-01f, 3.15024137e-01f, 5.01226820e-02f, 3.02422673e-01f, 4.20797557e-01f, 2.43824676e-01f, 3.37194242e-02f, -1.77656904e-01f, -6.94980146e-03f, 3.14284831e-01f,
  4.65537459e-01f, 4.37771410e-01f, 3.00357968e-01f, 1.21711612e-01f, -2.38222987e-04f, -3.12604755e-01f, -3.73450994e-01f, -2.00433955e-01f, 5.21728620e-02f, 2.71253526e-01f,
  2.82062143e-01f, 2.06999660e-01f, 1.01910450e-01f, -2.24144563e-01f, 9.16656107e-02f, 3.36767375e-01f, 9.82694924e-02f, 6.06443956e-02f, 1.45515427e-01f, -1.33857712e-01f,
  3.72542113e-01f, 7.90976584e-02f, 5.54672675e-03f, -1.37873413e-02f, 1.02557270e-02f, -1.32623941e-01f, -3.14060524e-02f, -1.57182530e-01f, -1.28546342e-01f, -1.47422150e-01f,
  6.84596738e-03f, -2.92164348e-02f, -4.56181914e-02f, -1.06744118e-01f, -1.15639463e-01f, -8.12353119e-02f, -4.04435396e-01f, -3.31285655e-01f, -1.68882415e-01f, -1.11926600e-01f,
  1.35890678e-01f, 5.54099008e-02f, -5.57867549e-02f, -1.58385620e-01f, -1.26312776e-02f, 7.49139339e-02f, -8.01739767e-02f, -1.14254348e-01f, -1.77616090e-01f, -8.09536278e-02f,
  -2.60388274e-02f, 3.42028290e-02f, 3.87660302e-02f, -1.32453710e-01f, 2.78661326e-02f, -1.77524257e-02f, -9.43693221e-02f, 6.64921552e-02f, -1.16807550e-01f, -1.23347469e-01f,
  -9.71790478e-02f, 4.47746404e-02f, -1.21098854e-01f, 3.46121043e-02f, 1.86151013e-01f, -7.38607720e-02f, -2.67286301e-02f, -7.75615647e-02f, 3.45438756e-02f, -8.66424888e-02f,
  -4.42629345e-02f, -2.70309776e-01f, -4.14032936e-02f, -1.95624471e-01f, -1.30508378e-01f, 2.72173565e-02f, -1.28957480e-02f, 1.85194403e-01f, 1.62726730e-01f, -3.10783777e-02f,
  -1.30771296e-02f, 1.40922561e-01f, 5.44258170e-02f, -3.95420432e-01f, -6.64730594e-02f, 3.02926470e-02f, 1.48527816e-01f, -1.33811012e-01f, 6.08351082e-03f, 2.13198108e-03f,
  1.50536925e-01f, -1.04965344e-02f, 2.70727947e-02f, -1.17485873e-01f, -1.03793018e-01f, -1.46338539e-02f, 3.95786539e-02f, -1.12754926e-01f, -9.58544463e-02f, -6.53425902e-02f,
  -3.59073281e-02f, -1.51612401e-01f, 5.26353717e-02f, -6.52633756e-02f, -1.71262138e-02f, 2.14046493e-01f, -2.75075752e-02f, 4.31801714e-02f, 1.19835455e-02f, 5.74137047e-02f,
  1.93367332e-01f, 2.14316845e-01f, 9.74586368e-01f, -3.25483173e-01f, -2.35390052e-01f, -2.98675209e-01f, -1.47665277e-01f, -2.75666118e-01f, -4.45115775e-01f, 1.71617106e-01f,
  -6.08433448e-02f, -7.79902756e-01f, -3.26588750e-01f, -4.09766585e-01f, -2.48072669e-02f, 2.77911574e-01f, 4.65715289e-01f, 3.74173790e-01f, -3.53681892e-01f, -6.26487076e-01f,
  -6.59245491e-01f, -5.61938509e-02f, 2.88704962e-01f, 1.90538839e-01f, -4.45122868e-02f, -2.23029822e-01f, 6.62658811e-01f, 2.23840684e-01f, 3.74625415e-01f, 3.90918761e-01f,
  3.89999092e-01f, 4.80120450e-01f, -6.39116094e-02f, -1.82919234e-01f, 1.25047162e-01f, -4.42039371e-02f, 3.64770591e-02f, 2.57491976e-01f, -1.22851163e-01f, 2.92854726e-01f,
  -2.10645154e-01f, -1.33060634e-01f, -2.65432656e-01f, -1.59206018e-01f, -1.34765804e-01f, -2.22260252e-01f, 2.77742118e-01f, 2.49827683e-01f, 1.18031196e-01f, 8.98366794e-02f,
  -6.64081991e-01f, -1.11579746e-01f, 3.26784551e-01f, 1.00543033e-02f, 9.32299569e-02f, -1.63859293e-01f, 1.21470772e-01f, -1.88787356e-02f, 2.51632810e-01f, 1.22555614e-01f,
  -1.25164175e-02f, 6.01167530e-02f, 3.83079820e-03f, 1.36670098e-01f, -1.23509072e-01f, 3.82080562e-02f, -5.52582182e-03f, -1.22584209e-01f, 8.04491416e-02f, 1.66830301e-01f,
  -2.77345274e-02f, 1.01818204e-01f, 7.78813213e-02f, 1.98441356e-01f, -2.06018705e-03f, 5.27432114e-02f, 2.80685956e-03f, 1.55645043e-01f, 9.56584588e-02f, 8.85245502e-02f,
  -1.79560214e-01f, 1.33532420e-01f, -4.66188490e-02f, -5.65220490e-02f, 2.20318303e-01f, 9.59027857e-02f, -2.19020210e-02f, -3.59376296e-02f, 1.55454641e-02f, 2.12858722e-01f,
  -5.51164865e-01f, 4.56633598e-01f, -2.85722483e-02f, -1.88965071e-02f, 1.10443026e-01f, -5.49317151e-02f, 4.75627743e-02f, -1.85905859e-01f, -4.38598217e-03f, -4.29240316e-02f,
  -5.68181314e-02f, -1.48370072e-01f, 1.82254553e-01f, -4.26692553e-02f, -3.97708774e-01f, -2.52195328e-01f, -2.49610707e-01f, -3.84624690e-01f, -1.68189943e-01f, -8.34545493e-02f,
  -8.25874954e-02f, -3.94083619e-01f, -5.85115135e-01f, -3.96786064e-01f, -3.33683729e-01f, -5.33004045e-01f, -1.44285649e-01f, -2.87091076e-01f, -2.61081934e-01f, -4.71248448e-01f,
  5.65875590e-01f, 2.78550684e-01f, 2.87088335e-01f, 4.84582365e-01f, -2.07629241e-02f, -5.56457758e-01f, -7.07210720e-01f, -1.58029795e-01f, 3.79639119e-01f, 1.95604920e-01f,
  -1.46481946e-01f, -1.47118583e-01f, 1.99629083e-01f, -2.94956118e-01f, -6.34505153e-01f, 2.41602864e-02f, 2.25946337e-01f, -2.34747142e-01f, -7.27795184e-01f, -8.19291055e-01f,
  -3.29495609e-01f, -6.54930770e-02f, -2.22305343e-01f, -4.71849606e-04f, 6.36200845e-01f, 1.91648915e-01f, 5.29451489e-01f, 3.42095435e-01f, 9.76482928e-02f, 7.64653325e-01f,
  2.47336313e-01f, 3.92204344e-01f, -6.74274862e-01f, -4.96891737e-02f, 8.59042071e-03f, 6.60275295e-02f, -2.05760300e-01f, 3.06320637e-01f, -1.68841556e-02f, -3.00761592e-02f,
  -1.07998192e-01f, -2.05094755e-01f, -4.60025221e-02f, -1.02900833e-01f, -2.01944038e-01f, -1.93728432e-01f, 1.48670347e-02f, -1.43539116e-01f, 4.24782336e-02f, -5.73963951e-03f,
  -1.70580268e-01f, -2.43704696e-03f, -7.83464983e-02f, -1.53823629e-01f, 1.67431608e-01f, 5.72861768e-02f, 2.81858575e-02f, 1.57791525e-01f, -3.00178211e-03f, 6.03975892e-01f,
  2.00044606e-02f, -2.33862158e-02f, 1.17580734e-01f, 1.78667501e-01f, -2.44038507e-01f, 3.51507962e-02f, 1.82484850e-01f, -1.31152257e-01f, -6.18256330e-02f, -4.04305160e-02f,
  -5.16391844e-02f, -8.79441798e-02f, 1.86034907e-02f, 5.41554801e-02f, 6.47939295e-02f, 4.42977920e-02f, -7.98818767e-02f, -1.50949612e-01f, -1.17908113e-01f, -3.07884794e-02f,
  8.98520369e-03f, 2.80016996e-02f, 8.13620016e-02f, -1.73193868e-02f, 1.37120306e-01f, 2.46122014e-02f, 5.17177284e-02f, -6.36227131e-02f, -2.34991382e-03f, 1.87005438e-02f,
  -8.17392990e-02f, -6.98791564e-01f, 1.42509729e-01f, -1.75182238e-01f, 1.72392249e-01f, 1.42934978e-01f, 1.00893065e-01f, -1.13687783e-01f, 2.17533290e-01f, -1.11333266e-01f,
  -2.44203955e-01f, -8.39103609e-02f, 1.46321416e-01f, -1.28505930e-01f, -3.68273616e-01f, -7.15552866e-02f, -3.71789634e-01f, -1.19152777e-01f, -2.10663170e-01f, 2.51937896e-01f,
  2.52311919e-02f, -6.53631389e-01f, -3.18563104e-01f, -1.92080170e-01f, 2.48458255e-02f, -3.81955296e-01f, -8.04288909e-02f, -1.97235733e-01f, -4.96653020e-01f, -2.13975266e-01f,
  -1.00098503e+00f, 3.25819761e-01f, -5.42922497e-01f, 2.19300762e-01f, 5.14888763e-01f, -7.47737885e-02f, -4.24831867e-01f, -4.22049731e-01f, 3.32872212e-01f, 2.65048832e-01f,
  2.17098132e-01f, 3.38103980e-01f, 1.98498785e-01f, -8.53709579e-02f, -5.35518229e-01f, 6.63155243e-02f, 2.71785170e-01f, -5.39199233e-01f, -8.15796614e-01f, -4.37712669e-01f,
  5.00112057e-01f, 1.99872609e-02f, -5.09472847e-01f, -1.92406699e-01f, 5.18496513e-01f, 4.80800450e-01f, 2.26301521e-01f, 2.43338108e-01f, 3.09318930e-01f, 5.73719561e-01f,
  -2.70448208e-01f, -3.46021473e-01f, -2.56187946e-01f, 2.97517061e-01f, 1.17549092e-01f, -3.19237411e-01f, -8.49712193e-02f, -1.80900574e-01f, 1.42416298e-01f, -9.84244198e-02f,
  2.66878247e-01f, 5.99286966e-02f, 2.67970324e-01f, 1.40305042e-01f, 1.67780798e-02f, -3.14154416e-01f, -3.44192564e-01f, -6.61629796e-01f, -5.72076261e-01f, -4.47524101e-01f,
  6.58216536e-01f, 2.08828390e-01f, -5.03016651e-01f, -1.86556384e-01f, -3.51566613e-01f, -7.27401748e-02f, -4.27085757e-01f, -2.95444548e-01f, -6.28159165e-01f, -3.65441799e-01f,
  -6.73801303e-02f, 2.36372203e-02f, 1.67837683e-02f, 3.34313586e-02f, 4.31313962e-02f, 1.06661081e-01f, 2.59332031e-01f, 1.01947658e-01f, 1.08836129e-01f, -9.18309689e-02f,
  -5.56127913e-03f, -1.34679005e-01f, -2.08762899e-01f, -7.74807036e-02f, 1.87765896e-01f, -8.38267431e-02f, 7.63463378e-02f, -4.11404930e-02f, -5.14156222e-02f, -3.14097665e-02f,
  -6.58598244e-02f, -1.73384115e-01f, 1.57289669e-01f, -1.97550431e-01f, 1.61344156e-01f, -3.95187512e-02f, 8.67396370e-02f, 1.01867728e-01f, -2.24036738e-01f, 1.54223949e-01f,
  3.28252375e-01f, 1.07720926e-01f, 1.67590454e-01f, -2.19106644e-01f, 1.31519586e-01f, -6.30701780e-02f, 2.29871497e-01f, 1.88914929e-02f, 2.63218224e-01f, -8.87228772e-02f,
  -1.26084477e-01f, -2.15581223e-01f, 2.58449882e-01f, -1.24284439e-01f, -2.50184566e-01f, 9.45404638e-03f, 3.16229224e-01f, 1.74494740e-02f, -7.01627508e-02f, 1.30522072e-01f,
  3.79348189e-01f, -2.84125268e-01f, -2.62209624e-01f, -1.30485073e-01f, 1.26058802e-01f, -2.54425034e-02f, -1.77046105e-01f, -2.37985119e-01f, -4.19844985e-01f, -3.03173363e-01f,
  -4.34188247e-01f, -9.24002647e-01f, 3.46532106e-01f, -6.12313032e-01f, 1.49214491e-01f, 4.49190766e-01f, 1.86745971e-01f, -5.20818233e-02f, -4.37307842e-02f, -3.22744697e-01f,
  -3.59272569e-01f, -2.29687601e-01f, -1.96347505e-01f, -6.27658740e-02f, 5.20570911e-02f, 1.85655117e-01f, 3.89492720e-01f, 3.84768575e-01f, 6.60990238e-01f, 3.79954010e-01f,
  -1.34147182e-01f, -2.45367885e-01f, -2.52538025e-01f, -2.64088899e-01f, -6.81579053e-01f, -8.07376055e-04f, -2.61541128e-01f, -2.44606391e-01f, 8.82775113e-02f, -3.57744694e-01f,
  -4.18508127e-02f, -2.98634261e-01f, 2.80632228e-01f, -5.05453758e-02f, -1.60488844e-01f, 1.49989827e-02f, 1.62085146e-02f, -1.02296308e-01f, -1.52454823e-01f, -9.05311927e-02f,
  -1.33732319e-01f, -6.25420213e-02f, -1.17983870e-01f, -2.19443709e-01f, -1.99053943e-01f, 6.30924013e-03f, -1.05369411e-01f, -1.58836499e-01f, -1.03323326e-01f, -5.74331405e-03f,
  -3.35082680e-01f, 1.40956193e-01f, 3.75924930e-02f, -4.01819199e-02f, -1.07673995e-01f, 2.68494159e-01f, -1.85857505e-01f, -5.81246801e-03f, 2.51618356e-01f, -3.63056540e-01f,
  1.37166202e-01f, -1.82717800e-01f, 7.23063871e-02f, 3.35368812e-02f, -4.48908284e-02f, 7.92045370e-02f, 8.36141407e-03f, -1.11333765e-01f, 1.13999266e-02f, -4.89137918e-02f,
  -1.45333037e-01f, 8.13992471e-02f, -2.35539861e-02f, -6.75411224e-02f, -8.39414168e-03f, -1.05755486e-01f, -5.36047481e-02f, -1.57894522e-01f, -3.44713568e-03f, -4.36428050e-03f,
  -2.17984561e-02f, -9.09684878e-03f, -4.92290631e-02f, -7.11488202e-02f, 5.15444502e-02f, -8.08007866e-02f, -1.41544774e-01f, 1.58263948e-02f, -1.61543727e-01f, -3.17665637e-02f,
  -5.70321143e-01f, 7.66122818e-01f, -3.98577042e-02f, 2.50770375e-02f, 2.73430590e-02f, -1.59392394e-02f, 4.83332425e-02f, 6.52240738e-02f, 6.94786087e-02f, 4.60093506e-02f,
  9.52067077e-02f, 3.07975952e-02f, -4.51726839e-02f, -6.53774813e-02f, 2.27242097e-01f, 2.44463459e-01f, -2.41299979e-02f, -7.31395930e-02f, 8.03737193e-02f, -1.70440242e-01f,
  -1.13992855e-01f, 1.89816982e-01f, 1.35181040e-01f, 1.03939787e-01f, 5.50291128e-02f, 4.13671911e-01f, 2.21240833e-01f, 1.53756544e-01f, 3.69726986e-01f, -7.97397792e-02f,
  6.31169856e-01f, -3.69272381e-02f, -5.05330801e-01f, 4.39517498e-01f, 1.95495814e-01f, 1.26539931e-01f, 5.10950327e-01f, 3.68247122e-01f, 4.05603498e-01f, 2.05723718e-01f,
  -1.60283759e-01f, -1.29021883e-01f, 9.14050415e-02f, -1.16599604e-01f, 5.25364354e-02f, 2.02401221e-01f, 2.54945368e-01f, -4.74423058e-02f, -1.85511529e-01f, -2.02336520e-01f,
  2.09375381e-01f, 3.45775694e-01f, -2.77597904e-02f, 5.02051972e-02f, -2.14128450e-01f, -1.23446798e-02f, -1.87603838e-03f, -2.34903738e-01f, -2.59690225e-01f, -3.02382618e-01f,
  -6.53591633e-01f, -3.13227326e-01f, 2.15713196e-02f, 3.73763070e-02f, -1.26087427e-01f, 2.39715204e-02f, 2.18262076e-02f, -1.87418267e-01f, 3.12998295e-02f, 3.62334065e-02f,
  -1.21374443e-01f, -1.43644676e-01f, -1.61711872e-02f, -1.24411710e-01f, -2.40555871e-02f, -1.67088777e-01f, -1.49821848e-01f, -1.81707650e-01f, -2.19827920e-01f, -2.30456293e-01f,
  -1.54514313e-01f, -2.52653360e-01f, -7.17476755e-02f, -9.28971320e-02f, -2.41514072e-01f, -1.06888888e-02f, -2.86299556e-01f, -3.77651364e-01f, -1.70687065e-01f, -9.55384076e-02f,
  4.72460501e-02f, -2.46142615e-02f, -1.09611645e-01f, -1.82509294e-03f, -4.15727943e-02f, 2.15913355e-03f, -1.62894260e-02f, -7.80639872e-02f, 2.55149067e-03f, -4.38246913e-02f,
  6.48178207e-03f, 1.58587322e-02f, -7.16425553e-02f, 1.29508391e-01f, 6.01214431e-02f, -2.74847690e-02f, -2.72684880e-02f, -2.55855508e-02f, -1.62419453e-01f, 2.19133660e-01f,
  -3.56262848e-02f, 2.25996738e-03f, -8.55542198e-02f, -9.04358625e-02f, -6.65376037e-02f, -2.77134534e-02f, 2.77983081e-02f, -5.20696072e-03f, 6.82724863e-02f, 1.93594113e-01f,
  4.16013032e-01f, 1.88919261e-01f, -1.39014181e-02f, -6.37226477e-02f, -1.61324754e-01f, -1.18365340e-01f, 2.63482407e-02f, -7.31058866e-02f, 4.54740562e-02f, 5.57248443e-02f,
  -1.44824639e-01f, -5.84748499e-02f, 1.74921956e-02f, -2.42488924e-02f, 1.42174587e-01f, -1.61728337e-02f, 4.62654307e-02f, 9.81617868e-02f, -7.00589493e-02f, -1.15826711e-01f,
  5.05150063e-03f, 2.01215386e-01f, 3.21080297e-01f, 1.49754420e-01f, -4.79635634e-02f, 3.58554125e-01f, 4.49932041e-03f, -5.70095219e-02f, 1.61798775e-01f, 5.74935436e-01f,
  5.10108292e-01f, 3.46623957e-02f, -1.27860880e+00f, -5.49944878e-01f, -9.85554338e-01f, -6.17258668e-01f, 2.56472558e-01f, 4.75228548e-01f, 4.20244001e-02f, -1.95112508e-02f,
  1.49750218e-01f, 8.15327764e-02f, -1.69226572e-01f, 5.71835339e-02f, 4.37058389e-01f, -6.42707571e-02f, -3.60082865e-01f, -3.98147434e-01f, -1.96354747e-01f, 2.38347948e-01f,
  3.31762105e-01f, -8.48023966e-02f, 4.69366238e-02f, -7.82609954e-02f, -4.41263318e-01f, -3.28257591e-01f, -5.75523436e-01f, -4.56877500e-01f, -1.71714112e-01f, -7.64208078e-01f,
  -7.64464617e-01f, -3.50465268e-01f, 6.17197566e-02f, 1.19919047e-01f, -2.03139246e-01f, 1.68958321e-01f, -3.10532842e-02f, -9.71593261e-02f, 2.43703187e-01f, -1.86419249e-01f,
  -2.98378915e-01f, 1.10371917e-01f, -3.18933651e-02f, -1.63095176e-01f, -3.44979346e-01f, -3.83167639e-02f, -1.27235293e-01f, -7.59394392e-02f, -3.64904478e-03f, -1.24382228e-01f,
  1.82037383e-01f, 9.12384223e-03f, -1.65914044e-01f, -1.05869863e-02f, 2.32501365e-02f, -2.11341187e-01f, -2.09472850e-01f, -1.75072271e-02f, -2.28951514e-01f, 2.23213509e-02f,
  1.93873018e-01f, -1.58610847e-02f, 9.59336013e-02f, 9.40521583e-02f, 2.84659296e-01f, 9.67048034e-02f, 1.57311559e-02f, 1.22899219e-01f, 5.36557063e-02f, 5.91978058e-02f,
  -1.28543988e-01f, 6.45141825e-02f, 5.40402569e-02f, 1.70437813e-01f, -4.03643511e-02f, -9.57411677e-02f, 8.82483572e-02f, 1.59990296e-01f, 1.03692776e-02f, 3.28328237e-02f,
  4.14674953e-02f, 8.60370621e-02f, -1.49958834e-01f, 1.83508679e-01f, 1.60875261e-01f, -5.20712249e-02f, -1.35867923e-01f, 1.24243692e-01f, -1.24988481e-01f, -1.06924683e-01f,
  9.72975194e-02f, 6.72769099e-02f, 4.59407791e-02f, 7.01773241e-02f, -4.94766831e-02f, -1.08652353e-01f, -1.00556761e-01f, 2.22084746e-01f, -5.88936806e-02f, -9.08671096e-02f,
  -1.11985646e-01f, -6.39303634e-03f, -7.95410872e-02f, 1.25708831e-02f, -9.06272233e-02f, -1.32969067e-01f, 2.25724623e-01f, -1.97366271e-02f, 1.07625671e-01f, -1.16151519e-01f,
  3.15710604e-01f, 5.56434393e-01f, 3.42553645e-01f, 1.40212163e-01f, 1.65567070e-01f, 1.97785825e-01f, 1.44893844e-02f, 5.49452975e-02f, 1.79309621e-01f, 4.65116680e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.93466413e-01f, 9.60273802e-01f, 2.34587759e-01f, 8.49924803e-01f, 9.13524628e-01f, 1.21166259e-01f, 4.62716848e-01f, 5.76084614e-01f, 7.57440448e-01f, 3.93968880e-01f,
  8.07440519e-01f, 5.35910547e-01f, 4.86189097e-01f, 4.98530924e-01f, 1.87305048e-01f, 7.17675149e-01f, 1.11921513e+00f, 7.61878431e-01f, 6.94767296e-01f, 5.54011583e-01f,
  1.07952428e+00f, 5.27770877e-01f, 4.71167445e-01f, 7.75494218e-01f, 9.45461929e-01f, 5.41741967e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.15316622e-01f, -5.78325316e-02f, -2.28318006e-01f, 5.64841509e-01f, -7.29559958e-02f, -3.17232996e-01f, 1.66605711e-01f, 7.19859749e-02f, 6.62598133e-01f, -1.11408496e+00f,
  1.15270808e-01f, -9.88866866e-01f, 4.42525864e-01f, 3.78970742e-01f, -1.21624970e+00f, 2.04036504e-01f, -8.49719346e-01f, 2.70349771e-01f, -3.79023194e-01f, -3.04425985e-01f,
  8.61180127e-01f, -8.07372272e-01f, -5.08607090e-01f, -9.16267693e-01f, 3.18902612e-01f, -1.94506541e-01f, -1.27401948e+00f, -1.06266832e+00f, -4.16752726e-01f, -2.18870163e-01f,
  -1.03994060e+00f, 2.08546475e-01f, 1.74974859e-01f, 4.65169884e-02f, -4.72269386e-01f, 3.66359860e-01f, -1.21867381e-01f, 3.43244337e-02f, 7.87178613e-03f, -5.94882250e-01f,
  8.58231366e-01f, 6.47744358e-01f, 1.87219977e-01f, -1.17032811e-01f, -6.60475492e-01f, 1.78156525e-01f, -3.55565786e-01f, 2.89391667e-01f, -8.59368503e-01f, 8.78036618e-01f,
  3.98909092e-01f, 3.85202207e-02f, -4.09341067e-01f, -5.31144261e-01f, -1.00786066e+00f, 1.83656096e-01f, -1.36141050e+00f, 4.65474069e-01f, -1.11916840e+00f, -4.47922766e-01f,
  -1.18521690e+00f, -5.18661439e-02f, 1.49909139e-01f, 3.52001339e-01f, 1.52992561e-01f, 1.61442369e-01f, 1.28946871e-01f, 1.11613847e-01f, 4.63095844e-01f, -3.45570713e-01f,
  -9.67019320e-01f, 7.48776138e-01f, 2.89904147e-01f, 5.81829548e-01f, -2.93258160e-01f, -8.55242312e-01f, -2.91507721e-01f, 2.99939901e-01f, -4.75195080e-01f, 1.49996340e-01f,
  5.04557073e-01f, 5.97398460e-01f, -8.71463835e-01f, 2.00472325e-01f, 6.68701291e-01f, -1.93402082e-01f, -7.00415969e-01f, 5.46332300e-02f, -5.35043895e-01f, -8.35668504e-01f,
  5.55063367e-01f, -3.40790182e-01f, -5.43539822e-01f, 3.57979566e-01f, -5.73192596e-01f, -1.06293583e+00f, -2.12024063e-01f, -2.17314169e-01f, -1.12548573e-02f, -3.66957009e-01f,
  -2.32109234e-01f, 3.43335032e-01f, -7.79648840e-01f, -7.41931498e-01f, -2.16550939e-02f, -8.03421259e-01f, -9.60724354e-01f, -5.13253629e-01f, 2.69089907e-01f, -7.90273547e-01f,
  -5.83232760e-01f, -5.33336937e-01f, 9.38853085e-01f, -8.16644132e-01f, -5.05521417e-01f, -3.41130704e-01f, -9.28154364e-02f, 2.66102672e-01f, 7.35046923e-01f, -7.70199299e-01f,
  6.48149610e-01f, -7.13518202e-01f, 5.98659515e-01f, -1.09535825e+00f, 1.43135145e-01f, 9.26466048e-01f, -6.77531958e-01f, 3.91152918e-01f, -1.08525664e-01f, 1.08127020e-01f,
  9.80509073e-02f, -6.85345590e-01f, -1.90824136e-01f, 1.69445500e-01f, 1.90514490e-01f, -1.40659666e+00f, -3.15788984e-01f, 2.71522343e-01f, -2.88327903e-01f, 2.25195587e-01f,
  2.92623013e-01f, 4.03718650e-02f, -2.56245621e-02f, -2.92917609e-01f, -8.57634604e-01f, 2.40834933e-02f, -6.45457566e-01f, 4.69261147e-02f, -8.29549506e-02f, 9.14928913e-01f,
  -1.04312396e+00f, -2.51270235e-02f, 1.50669053e-01f, -5.07143319e-01f, 5.77319145e-01f, 1.10294461e+00f, 5.04712105e-01f, -7.59088993e-01f, -7.37472832e-01f, -5.77536523e-01f,
  1.33378893e-01f, 1.65964469e-01f, 3.00223231e-01f, 3.41080040e-01f, 9.00642797e-02f, -2.44497120e-01f, 9.57499623e-01f, 3.28329891e-01f, -1.07497799e+00f, -1.04775226e+00f,
  4.78996158e-01f, 2.00239997e-02f, 3.61158431e-01f, 7.58335069e-02f, -6.77506208e-01f, -1.93318024e-01f, -3.92172962e-01f, -5.50408065e-01f, -1.35428712e-01f, -4.70053285e-01f,
  -1.16484785e+00f, 9.90698561e-02f, -2.12395012e-01f, -4.91306037e-02f, -1.09043717e+00f, 2.20900044e-01f, -7.16800928e-01f, -3.13999742e-01f, 4.47894007e-01f, -1.08394301e+00f,
  7.67712295e-01f, 8.31716120e-01f, 1.22331686e-01f, -4.57117744e-02f, 2.70340383e-01f, 4.85120595e-01f, 6.16931655e-02f, 2.21440613e-01f, -9.27239418e-01f, 5.29524267e-01f,
  -6.25962198e-01f, -7.48377979e-01f, -5.64747036e-01f, -1.15177326e-01f, -6.70735955e-01f, 2.62718797e-01f, 2.78702796e-01f, -1.59812793e-01f, 1.21126428e-01f, -3.80364031e-01f,
  6.76354527e-01f, -9.41985846e-01f, -1.41058242e+00f, -5.10959566e-01f, -2.35811666e-01f, 8.89068544e-02f, -8.45539451e-01f, -6.32806301e-01f, 8.10884476e-01f, 6.41576469e-01f,
  -1.18352842e+00f, -8.82247329e-01f, -9.10555780e-01f, -2.07780644e-01f, -2.36810893e-01f, -2.36639261e-01f, -4.75991189e-01f, -4.87422436e-01f, 1.27580320e-03f, 3.15046489e-01f,
  -6.34426177e-01f, 3.74139845e-02f, -3.75239789e-01f, -3.76022220e-01f, -9.93199885e-01f, 4.26253796e-01f, -2.11105436e-01f, -1.52070776e-01f, -4.00096387e-01f, 3.34898055e-01f,
  7.36168802e-01f, -7.75516033e-02f, -4.80561286e-01f, 2.88935244e-01f, -4.40577455e-02f, -2.70071447e-01f, 2.49424204e-01f, -8.14470530e-01f, 9.93765369e-02f, -5.16346335e-01f,
  -8.33169222e-01f, 2.21071050e-01f, 8.62033784e-01f, -1.20470330e-01f, 2.34504223e-01f, -6.35155499e-01f, 1.92777410e-01f, 2.63689101e-01f, 1.32402599e-01f, 4.08020794e-01f,
  2.62427449e-01f, -2.87022054e-01f, -9.71699774e-01f, 1.45543084e-01f, -6.68772399e-01f, -3.81418914e-01f, 9.16102529e-01f, 3.12953621e-01f, -4.90360618e-01f, -9.00385261e-01f,
  -1.79132104e-01f, 4.51279610e-01f, -4.76126164e-01f, -3.01225066e-01f, -5.65063119e-01f, -1.55959919e-01f, -6.98624194e-01f, -1.80170342e-01f, 2.74792910e-01f, 1.84821218e-01f,
  -2.68503428e-01f, -4.53462303e-01f, 2.69236237e-01f, -5.24636745e-01f, -6.57894552e-01f, 7.41677105e-01f, 6.74770594e-01f, -4.12446171e-01f, -2.98077464e-01f, -4.17182952e-01f,
  1.12158753e-01f, -2.61410654e-01f, 2.98524976e-01f, -1.71150237e-01f, 3.26603442e-01f, 3.34726870e-01f, -3.53287786e-01f, 2.67236680e-01f, -1.63177878e-01f, -6.63186133e-01f,
  1.07761256e-01f, -9.56526622e-02f, 3.84345323e-01f, -4.38962728e-01f, -9.69685972e-01f, -1.24891567e+00f, 5.01210913e-02f, -1.81295708e-01f, 8.18029702e-01f, -6.37984514e-01f,
  -7.25148439e-01f, 4.34634745e-01f, -7.89912403e-01f, 6.49614275e-01f, -4.70197678e-01f, 4.84590530e-01f, 8.62732828e-01f, -1.18443653e-01f, -1.34063852e+00f, -5.29362679e-01f,
  1.72164917e-01f, -4.85664271e-02f, 2.77032703e-01f, -1.24032386e-01f, -3.70900244e-01f, -1.45521671e-01f, 3.15533429e-01f, -6.13173425e-01f, -1.13652623e+00f, 9.48205650e-01f,
  -8.30025673e-01f, -4.75306869e-01f, -6.45528555e-01f, -4.07139748e-01f, -3.05959731e-01f, -2.40458459e-01f, -2.75832981e-01f, 5.12498915e-01f, -1.03436634e-01f, -6.56610370e-01f,
  -6.25768423e-01f, 5.63085079e-01f, 1.07047176e+00f, -5.57473421e-01f, -4.16058093e-01f, 4.07708973e-01f, -7.95321941e-01f, -5.76180518e-01f, -2.37608850e-01f, -2.82658875e-01f,
  -7.53006876e-01f, -2.54733682e-01f, 1.03148915e-01f, 4.49740350e-01f, -6.58589005e-01f, -6.98364973e-02f, -1.46210104e-01f, 4.13957506e-01f, -4.19104069e-01f, -7.70500839e-01f,
  -5.95342398e-01f, -7.17120349e-01f, -2.87056342e-02f, -4.35514241e-01f, -6.48315012e-01f, -6.24002516e-01f, 6.22969151e-01f, -6.24968946e-01f, 8.30945671e-01f, 3.42732854e-02f,
  -3.19135785e-02f, 6.85295880e-01f, -2.03501552e-01f, -1.72412544e-01f, -2.29107305e-01f, 2.18911335e-01f, 1.09762740e+00f, 8.00539330e-02f, 5.16341329e-01f, -1.96814358e-01f,
  -7.76525855e-01f, -7.96489656e-01f, -1.27136916e-01f, -6.38452649e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.22635901e-01f, -1.72649354e-01f, 2.24418610e-01f, -8.41354281e-02f, -4.48426083e-02f, 1.71038508e-01f, -2.00649530e-01f, -2.74821043e-01f, 2.57317461e-02f, 2.88264360e-02f,
  9.40608308e-02f, -9.42272246e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    