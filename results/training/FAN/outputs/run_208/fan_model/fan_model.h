/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52860314e-01f, -4.40801382e-01f, -6.16390957e-03f, -2.80685544e-01f, -2.05144323e-02f, -3.18016022e-01f, -9.06261951e-02f, -1.11440383e-01f, -3.66902709e-01f, -1.78687304e-01f,
  1.89469138e-03f, -7.37089887e-02f, -6.61285818e-02f, -3.73918951e-01f, -6.29099160e-02f, -1.77548528e-01f, -3.00558925e-01f, -8.38390067e-02f, -3.60645019e-02f, -1.15646571e-01f,
  -7.99058303e-02f, -2.21662089e-01f, 1.02705546e-01f, -5.11502884e-02f, -8.72656256e-02f, 1.41996637e-01f, 1.50579825e-01f, 1.84336111e-01f, 1.21794648e-01f, 8.46633539e-02f,
  1.33326072e-02f, -1.42980754e-01f, -5.74911647e-02f, 4.82122898e-02f, -1.66817103e-02f, 6.74862266e-02f, 7.77392462e-02f, 7.06295446e-02f, -6.70646026e-04f, -1.06892856e-02f,
  2.71377563e-02f, -1.05879847e-02f, -5.81761412e-02f, -5.48188500e-02f, -5.70334420e-02f, 4.91129607e-03f, 7.45844655e-03f, -2.00814642e-02f, -3.53377685e-02f, -1.18834516e-02f,
  7.80952862e-03f, 9.54854265e-02f, -5.70593439e-02f, 6.44068345e-02f, 4.56097238e-02f, -7.99596012e-02f, -3.75445150e-02f, 1.26007184e-01f, -5.14016524e-02f, -2.70258635e-02f,
  -6.49320986e-03f, -5.53802289e-02f, -3.47668640e-02f, 4.82432730e-02f, -4.01034020e-02f, 5.65780699e-02f, -6.08931258e-02f, 7.55486935e-02f, 5.79091795e-02f, -4.64562811e-02f,
  3.08890063e-02f, -1.84631048e-04f, -2.95607205e-02f, -5.53574599e-02f, -1.26032690e-02f, 1.14998417e-02f, -7.95674976e-03f, 5.51547259e-02f, 4.25510760e-03f, -1.94368083e-02f,
  -3.26687060e-02f, -6.87462837e-02f, 3.91210467e-02f, 4.89973798e-02f, -4.69388664e-02f, 4.09516767e-02f, -8.43461603e-03f, 2.17145942e-02f, 6.51286021e-02f, 4.33537178e-02f,
  -1.36636779e-01f, -2.15026140e-01f, -4.68471795e-02f, 3.90285477e-02f, -2.37160173e-04f, -6.72542602e-02f, -1.05522551e-01f, -8.01783130e-02f, -2.18838807e-02f, -2.15851385e-02f,
  5.02585396e-02f, -1.49370462e-03f, 8.91759060e-03f, 8.52589682e-02f, 3.99689674e-02f, -8.37348849e-02f, 2.44348068e-02f, 6.84270635e-02f, -2.03233063e-02f, 3.26031446e-02f,
  -2.04289444e-02f, 2.54300088e-02f, -4.82903980e-03f, -4.91397977e-02f, -1.00099621e-02f, 1.05578206e-01f, -4.32453901e-02f, 2.52190828e-02f, 3.89240831e-02f, -6.20166473e-02f,
  -6.19416475e-01f, -1.62528172e-01f, -1.70465489e-03f, -4.45042789e-01f, -1.70612156e-01f, -4.68963347e-02f, 1.48426160e-01f, -2.75545597e-01f, -1.45002902e-01f, 1.01721222e-02f,
  6.17364421e-02f, -6.07768372e-02f, 2.20664620e-01f, -5.23554534e-02f, 2.46243905e-02f, 2.12367103e-01f, -1.51929229e-01f, -8.38945732e-02f, 1.04759090e-01f, -2.22058013e-01f,
  -1.42958552e-01f, -3.95838022e-02f, 7.59501532e-02f, -8.30903724e-02f, -1.21422105e-01f, -1.15420602e-01f, 1.26499802e-01f, 1.15882464e-01f, -1.00320883e-01f, 4.49699871e-02f,
  9.83053595e-02f, -5.63107096e-02f, 5.65661415e-02f, 2.04163603e-03f, -1.19864345e-01f, -8.60376190e-03f, 1.56452302e-02f, 1.61364391e-01f, 5.12673184e-02f, 1.97719950e-02f,
  2.17514429e-02f, -6.55244514e-02f, -3.36668380e-02f, 3.11571676e-02f, -5.72071448e-02f, 3.72880511e-02f, 2.07872484e-02f, 3.31925377e-02f, -1.45455664e-02f, 3.57611105e-02f,
  3.57191078e-02f, -1.59543194e-02f, -2.41458975e-02f, -9.96194482e-02f, -1.12063775e-04f, -1.74356941e-02f, 2.04440299e-02f, 1.26842028e-02f, -1.09579228e-01f, -7.21403509e-02f,
  -4.59869057e-02f, 3.46398354e-02f, 8.57061520e-02f, -6.57587405e-03f, -5.38804848e-03f, 1.94355450e-03f, -2.20721569e-02f, 6.09075055e-02f, -2.49536503e-02f, -3.87842096e-02f,
  -5.38563766e-02f, -7.32661560e-02f, -5.92660112e-03f, 6.46139309e-02f, -1.71191897e-02f, 5.51848905e-03f, 4.52824309e-02f, -4.96040359e-02f, -9.63280648e-02f, -2.81411894e-02f,
  1.06430333e-02f, 1.18370466e-02f, 2.71516442e-02f, 1.61683548e-03f, 1.95199717e-02f, 7.87097868e-03f, 4.99565303e-02f, 2.73440336e-03f, 5.88512681e-02f, 3.32417600e-02f,
  -3.58307004e-01f, -4.52390492e-01f, -2.20932867e-02f, -3.01680136e-02f, 4.72976193e-02f, 6.34086579e-02f, 5.36439791e-02f, -3.28013040e-02f, 5.51626459e-02f, -1.26782451e-02f,
  -9.09123290e-03f, 3.89216538e-03f, -7.25963861e-02f, -2.50967350e-02f, 9.47995018e-03f, -2.66596973e-02f, -2.00067852e-02f, -3.45101617e-02f, -4.54190969e-02f, -5.07743023e-02f,
  -3.59997936e-02f, 4.00376022e-02f, 2.64288187e-02f, -9.81597044e-03f, -4.79837507e-02f, 3.92895900e-02f, -1.21200599e-01f, -2.26343889e-02f, 4.45516035e-02f, -4.58566879e-04f,
  2.05429286e-01f, 2.03809753e-01f, 2.23132581e-01f, 2.81134695e-01f, -3.19187902e-02f, 6.46342337e-01f, 4.09367263e-01f, 6.14756346e-02f, 9.91168767e-02f, 3.58832185e-03f,
  3.82508226e-02f, 2.55108029e-01f, -9.61525887e-02f, 3.09390277e-01f, 2.65700459e-01f, 1.56383291e-01f, 1.68154538e-01f, 1.07892692e-01f, -3.52544934e-02f, -4.92534190e-02f,
  7.57343918e-02f, 4.25368696e-02f, 2.21650988e-01f, -9.47133601e-02f, 1.72187299e-01f, -1.77437682e-02f, -3.36868972e-01f, 2.98513565e-02f, -1.13871656e-02f, 9.69492570e-02f,
  -3.63600850e-02f, 7.28430040e-03f, 8.37059245e-02f, 5.50843216e-02f, 3.92895527e-02f, -6.52712630e-03f, 8.38097092e-03f, -2.37709265e-02f, -3.88326608e-02f, 7.13796169e-02f,
  -5.94768487e-03f, -2.93364115e-02f, 9.89722833e-02f, 3.13480534e-02f, 6.97686896e-03f, 1.87298972e-02f, 5.71153648e-02f, 5.65136001e-02f, 7.13966936e-02f, 1.21063709e-01f,
  1.00088224e-01f, 1.06300548e-01f, 3.32480557e-02f, 3.69626172e-02f, 4.41564694e-02f, 3.44529748e-02f, 4.15716320e-02f, 2.76375934e-02f, -9.45506990e-03f, 4.46650535e-02f,
  2.40638871e-02f, -4.86555286e-02f, 7.17902044e-03f, -3.33165936e-03f, 3.56089547e-02f, -7.22061023e-02f, 5.94969690e-02f, -9.35180485e-03f, 9.19374079e-03f, -3.01991012e-02f,
  5.50500536e-03f, 3.41483839e-02f, -9.04414896e-03f, 5.01756854e-02f, -2.07558414e-03f, 1.98747348e-02f, -6.53287442e-03f, -3.90005074e-02f, 5.37739769e-02f, 4.06999812e-02f,
  -1.04978355e-02f, -5.35104461e-02f, -4.28770995e-03f, -3.06738205e-02f, 7.89234880e-03f, -1.15216365e-02f, 2.11623274e-02f, 7.63280177e-03f, -2.71401973e-03f, 7.96022732e-03f,
  -2.08399817e-01f, -2.44682744e-01f, 2.34911740e-02f, -1.38055319e-02f, -7.57912397e-02f, 6.15501851e-02f, 8.41820911e-02f, 2.70511452e-02f, -6.02542348e-02f, -4.57602143e-02f,
  -2.20363704e-03f, -3.57398274e-03f, -1.10064231e-01f, 3.53249572e-02f, -3.74931991e-02f, -7.50368182e-03f, -5.20920642e-02f, -3.56676877e-02f, 1.61589961e-02f, -8.79229158e-02f,
  -9.49350148e-02f, -6.54527768e-02f, 9.28808702e-04f, 1.00325895e-02f, -3.25879566e-02f, -1.79030374e-02f, 1.73667017e-02f, 2.33171228e-03f, -2.10894719e-02f, -9.85009683e-05f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.37991940e-02f, -6.58700913e-02f, 2.83432603e-01f, 1.42291322e-01f, 1.58192709e-01f, 5.73534220e-02f, 6.50286078e-02f, 3.86074781e-01f, 6.21653736e-01f, -3.26746032e-02f,
  -1.99000180e-01f, -5.36734723e-02f, -1.61158040e-01f, -1.20348215e-01f, 1.53311633e-03f, 2.95421928e-02f, 1.44412620e-02f, -3.86996865e-02f, 2.53621787e-01f, 3.67568769e-02f,
  3.17151397e-02f, -1.55033946e-01f, -2.50673503e-01f, -1.83450133e-01f, -1.71762064e-01f, 7.78109208e-02f, -2.02610016e-01f, -6.07225038e-02f, -2.16950923e-01f, -1.12018257e-01f,
  -9.63936672e-02f, 9.41088274e-02f, -1.82143629e-01f, 2.24827579e-03f, -1.47866178e-02f, -1.00797169e-01f, -1.20398998e-01f, -2.65550148e-02f, 2.12947819e-02f, 8.22781846e-02f,
  -4.01803516e-02f, -5.21067344e-02f, -3.53806503e-02f, 8.50932524e-02f, 7.43674338e-02f, 8.83083493e-02f, 2.23269649e-02f, -1.67455748e-02f, -6.08643293e-02f, 6.67927861e-02f,
  -2.52864547e-02f, -1.03369309e-03f, 9.30089206e-02f, 5.34709990e-02f, 4.03514132e-03f, -2.55397037e-02f, 6.30179271e-02f, -4.83912183e-03f, -4.67527136e-02f, 3.70980836e-02f,
  4.78266254e-02f, 5.36198206e-02f, -2.06777453e-02f, -8.00843313e-02f, -1.02454044e-01f, -1.24792824e-03f, -7.97641277e-02f, 1.47235058e-02f, -2.20157322e-03f, -8.13819282e-03f,
  5.87593997e-03f, -5.72341233e-02f, 4.09588963e-02f, 1.66351181e-02f, -1.08309789e-02f, -2.09328737e-02f, -8.06628689e-02f, 6.67622909e-02f, -4.34992509e-03f, 2.36225314e-02f,
  -2.30701268e-02f, -2.82648709e-02f, -2.88311243e-02f, -5.73708601e-02f, -6.46218881e-02f, -2.75251158e-02f, 2.21717041e-02f, 1.02998726e-01f, -1.41565949e-02f, -2.65705977e-02f,
  -7.08449408e-02f, -7.32598305e-02f, -8.13263878e-02f, -1.20199263e-01f, -1.17844371e-02f, -2.11388487e-02f, 2.34470051e-03f, -1.35978162e-02f, 1.30484581e-01f, -4.32406329e-02f,
  5.28223515e-02f, 1.35728838e-02f, -7.24590719e-02f, -3.20697278e-02f, -5.86482137e-02f, 3.27360583e-03f, -4.29505892e-02f, 4.74854074e-02f, -4.63784393e-03f, 6.52163615e-03f,
  -1.05220400e-01f, 4.34311926e-02f, 8.51458982e-02f, -6.89070374e-02f, 6.60289526e-02f, -2.04699691e-02f, -2.17465889e-02f, -5.27126342e-02f, 6.22649584e-03f, -1.55472625e-02f,
  -1.47070289e-01f, -3.11737478e-01f, -2.91885734e-01f, -4.03847247e-01f, 1.09073043e-01f, -2.16478884e-01f, -4.02354538e-01f, -1.73752636e-01f, -8.55138302e-02f, -6.22733831e-02f,
  -1.73969626e-01f, -4.29830924e-02f, 1.38239831e-01f, -5.09759605e-01f, 7.95586258e-02f, 5.01760207e-02f, -5.01518190e-01f, -1.71008259e-01f, 2.62204800e-02f, -2.91494399e-01f,
  -1.12044133e-01f, -2.89570391e-01f, -2.53410488e-01f, -8.36048499e-02f, -3.17299217e-01f, -1.28039077e-01f, 2.06333026e-01f, -3.16109695e-02f, -2.21442729e-01f, -4.29150835e-02f,
  -1.53664216e-01f, -1.63957193e-01f, -5.85189462e-02f, -4.48116427e-03f, -8.80448893e-02f, -1.36263052e-03f, -1.16771050e-01f, 2.22418606e-02f, -2.30466817e-02f, -2.99081462e-03f,
  3.14648934e-02f, 5.39460815e-02f, -1.62833482e-01f, 3.08363996e-02f, -1.51331266e-02f, -8.23542103e-02f, -7.12454319e-02f, -3.72798927e-02f, 2.43260944e-03f, -5.55391498e-02f,
  -1.12697750e-01f, -5.99217182e-03f, -3.86299118e-02f, -2.33563352e-02f, -3.87344547e-02f, 1.12443324e-02f, 3.43446136e-02f, 4.53168936e-02f, 1.09261880e-02f, 3.55623034e-03f,
  -8.13472196e-02f, 3.89882885e-02f, -2.50331927e-02f, -2.94657201e-02f, -7.80603811e-02f, -1.57573633e-02f, -2.68327631e-02f, -6.06187657e-02f, -6.88715465e-03f, 1.00326344e-01f,
  -6.36095554e-02f, -5.96876489e-03f, 7.63550475e-02f, -1.69418268e-02f, -5.60676530e-02f, -2.22132616e-02f, -1.40138008e-02f, 1.91497561e-02f, -2.09400114e-02f, 4.94602919e-02f,
  -3.77209410e-02f, -1.25425104e-02f, 2.96552796e-02f, 4.19822112e-02f, 1.97160663e-03f, 3.99968922e-02f, -7.65058324e-02f, 6.64299875e-02f, -5.52658029e-02f, -2.84980033e-02f,
  -3.60711813e-02f, 5.76270111e-02f, -6.00382425e-02f, -1.93857718e-02f, 6.93917796e-02f, -5.39560802e-02f, -5.65254036e-03f, -1.37108132e-01f, -7.89441764e-02f, -2.59734523e-02f,
  -4.12424766e-02f, -2.00766027e-02f, 1.03992829e-02f, -3.29246074e-02f, -4.77471985e-02f, 4.88751046e-02f, 4.21149135e-02f, 3.16038169e-02f, 7.33527243e-02f, 5.22745214e-02f,
  7.52473064e-03f, -1.69947837e-02f, 3.09352148e-02f, 3.77045050e-02f, -5.40488996e-02f, -1.11404262e-01f, 6.11212254e-02f, -7.54976273e-02f, 3.00044175e-02f, 7.52368802e-03f,
  -8.88654515e-02f, 2.93593407e-01f, -1.29732373e-03f, 1.40891418e-01f, -1.97115779e-01f, 8.78492221e-02f, 2.38083318e-01f, -1.18862070e-01f, 1.04160279e-01f, 2.42378309e-01f,
  5.27142994e-02f, 7.82278255e-02f, -1.49169853e-02f, 2.26155058e-01f, -1.23654827e-01f, 1.77916452e-01f, 1.49903372e-01f, 2.00626045e-01f, -5.43424562e-02f, -8.82832780e-02f,
  1.49524026e-02f, -6.88930182e-03f, -2.96489801e-02f, -1.30383566e-01f, -9.96446908e-02f, -8.18247423e-02f, -1.88761607e-01f, -2.36577988e-01f, -8.86457320e-03f, -8.94612968e-02f,
  1.41090482e-01f, 1.12634292e-02f, -1.88212097e-02f, 8.48274454e-02f, 1.69520248e-02f, -5.74775636e-02f, 3.58377979e-03f, 9.93570779e-03f, -2.85233911e-02f, 7.15416437e-03f,
  5.33137731e-02f, -6.90030977e-02f, 2.87022684e-02f, -4.23254147e-02f, 6.96885511e-02f, 6.45954907e-03f, -6.19927282e-03f, -4.44119610e-02f, 2.88852230e-02f, -8.54080692e-02f,
  -3.18010747e-02f, 4.56930213e-02f, 1.58556439e-02f, -1.01379827e-02f, -3.91613580e-02f, 4.74104397e-02f, 1.11001795e-02f, -4.33000028e-02f, -4.12070937e-02f, 6.48205802e-02f,
  -9.01876912e-02f, 3.76717821e-02f, -9.90986731e-03f, 1.49504393e-02f, 2.15607733e-02f, 1.61468573e-02f, 5.65777416e-04f, 8.89545530e-02f, 1.65752154e-02f, 2.41146740e-02f,
  2.32594255e-02f, -1.19141191e-02f, 3.08788661e-03f, 2.42159870e-02f, -1.94635428e-02f, 7.74663314e-02f, -4.53696912e-03f, -7.57446215e-02f, 3.88834961e-02f, -2.99702100e-02f,
  4.63674217e-02f, -1.22690415e-02f, -6.79619983e-02f, 3.34189944e-02f, 2.36815065e-02f, -3.78043540e-02f, -4.75114994e-02f, -3.42999748e-03f, -3.63369868e-03f, 1.76695157e-02f,
  1.23019256e-01f, 2.38904804e-02f, -5.21488162e-03f, -4.88580465e-02f, -1.18190618e-02f, 6.03192262e-02f, 4.96952832e-02f, 3.25559750e-02f, -1.07022133e-02f, -2.22886037e-02f,
  5.58509026e-03f, 1.09128982e-01f, 8.36916119e-02f, -3.96861956e-02f, -5.76274320e-02f, -1.60997489e-03f, 1.64210871e-02f, 1.14925206e-02f, -1.93888266e-02f, -9.62171238e-03f,
  -6.47225901e-02f, 3.12894508e-02f, -1.04091014e-03f, 7.76959807e-02f, -2.01513618e-02f, 2.97001917e-02f, 8.43016431e-03f, -7.03355148e-02f, -4.14223820e-02f, 3.20149809e-02f,
  1.61231849e-02f, -1.39443040e-01f, 1.68229088e-01f, 4.60292816e-01f, -2.57108416e-02f, -3.49291146e-01f, -2.92805076e-01f, 7.11410046e-02f, -3.65628488e-02f, -3.29449058e-01f,
  6.31101578e-02f, -1.49673158e-02f, -2.08649635e-01f, 4.00824785e-01f, 4.68075693e-01f, -9.07794088e-02f, 1.17905401e-01f, -1.65928621e-02f, 8.04923922e-02f, 1.59434915e-01f,
  3.73478681e-01f, 3.42822731e-01f, 4.11931604e-01f, 2.53978759e-01f, 2.00489946e-02f, 2.95709252e-01f, 3.28733623e-01f, 1.60663277e-02f, 2.41007939e-01f, 2.08046705e-01f,
  -1.49471402e-01f, 9.18405578e-02f, -2.94270217e-02f, -2.17079427e-02f, -2.66780034e-02f, -1.16241828e-01f, -8.50760341e-02f, 3.73718590e-02f, 1.17411464e-01f, 4.06426825e-02f,
  -1.50232390e-01f, 8.16148371e-02f, 1.28828451e-01f, 4.90199104e-02f, -8.37089196e-02f, 8.45275298e-02f, -2.08621342e-02f, -6.06378801e-02f, 2.70027411e-03f, 1.82886310e-02f,
  8.66000727e-03f, -9.35869738e-02f, -2.20733043e-02f, 2.24158950e-02f, 1.29780114e-01f, 4.52939160e-02f, 1.53868767e-02f, 6.39322388e-05f, -1.52021460e-02f, 7.96118528e-02f,
  -2.71719396e-02f, -5.66969663e-02f, -6.05287179e-02f, 5.78714646e-02f, 4.33190875e-02f, 3.84703316e-02f, -5.51689323e-03f, 4.61534038e-02f, -3.48436348e-02f, 6.06380999e-02f,
  -3.99369039e-02f, 3.99565883e-02f, 5.67100033e-05f, -3.73526439e-02f, 4.55752714e-04f, -4.94106486e-02f, 1.45954415e-02f, 5.64137995e-02f, 6.42308407e-03f, 7.49221742e-02f,
  -4.58022393e-02f, 3.29487808e-02f, 4.41048369e-02f, -1.83416922e-02f, -7.10877869e-03f, -3.71107571e-02f, 7.17644319e-02f, -1.37120616e-02f, -1.08257132e-02f, -2.27122363e-02f,
  -6.62826598e-02f, 1.88406676e-01f, -1.81285664e-02f, -4.13071886e-02f, 3.95063572e-02f, -1.63015013e-03f, -2.85360799e-03f, 1.32721998e-02f, 6.10803701e-02f, -9.56742018e-02f,
  3.20605515e-03f, -1.85694657e-02f, -1.26882225e-01f, 3.77535820e-02f, 5.35123684e-02f, -3.66191678e-02f, 7.36560300e-02f, -1.37810092e-02f, 7.19797164e-02f, 1.24883763e-01f,
  2.32781582e-02f, -2.87766941e-02f, 7.88545012e-02f, -1.60468500e-02f, 5.54695614e-02f, -7.91936293e-02f, 2.44116616e-02f, -4.90633920e-02f, -3.41670960e-03f, -1.53358532e-02f,
  4.41962123e-01f, -7.71910846e-01f, 1.00442313e-01f, 3.67310911e-01f, 6.80496097e-01f, 2.68240422e-01f, 4.63553935e-01f, -2.49142721e-01f, 1.08000405e-01f, -7.64297187e-01f,
  -6.29191548e-02f, -2.62514383e-01f, -3.14333707e-01f, -1.18290879e-01f, 5.22734642e-01f, -2.81024247e-01f, 3.75767462e-02f, -1.09389104e-01f, -5.64232236e-03f, -4.96564507e-02f,
  2.45182693e-01f, 4.98979725e-02f, 4.89396751e-02f, -2.30894342e-01f, 1.12572663e-01f, -5.36655486e-02f, -3.14384513e-02f, -4.13819849e-02f, -9.11639780e-02f, 2.69999895e-02f,
  2.21754149e-01f, -5.28198965e-02f, 6.71308041e-02f, -9.49522257e-02f, -9.14808735e-02f, 5.13768941e-02f, 1.82338543e-02f, 7.65577480e-02f, 1.76061600e-01f, -4.07419428e-02f,
  -5.98504208e-02f, -6.34663552e-02f, 5.12526706e-02f, 1.91542115e-02f, 6.67855367e-02f, -1.52939651e-02f, 4.43019643e-02f, 4.71968912e-02f, -6.26771376e-02f, 5.26975375e-03f,
  -5.22152819e-02f, -5.23896776e-02f, 8.47420096e-02f, -1.48895234e-01f, -3.61037627e-02f, 7.78521672e-02f, 6.02169335e-02f, -6.83211461e-02f, -3.59340645e-02f, -1.80541314e-02f,
  -1.55256078e-01f, 4.92228903e-02f, -4.43651117e-02f, -2.89277509e-02f, 2.09849775e-02f, 8.40721801e-02f, 1.09461181e-01f, -4.92500477e-02f, 3.25932987e-02f, 3.98446135e-02f,
  4.73041311e-02f, 4.17615436e-02f, 2.27611717e-02f, 6.00311458e-02f, 5.39193265e-02f, -2.11065896e-02f, 2.61851493e-02f, -9.46059152e-02f, -1.87531970e-02f, 4.20116447e-03f,
  -3.64203416e-02f, 5.41612506e-02f, -5.50618879e-02f, 1.84931420e-02f, 1.37518728e-02f, 5.00745848e-02f, -8.35825801e-02f, -6.44548908e-02f, 9.81507823e-03f, 6.27798140e-02f,
  -1.78882390e-01f, -6.38867557e-01f, -2.30152458e-02f, -4.01039608e-02f, -6.54169098e-02f, -4.84203324e-02f, 5.72890937e-02f, -8.48176405e-02f, -1.10898472e-01f, -3.21720317e-02f,
  -4.06039096e-02f, 9.37852785e-02f, -2.34263018e-02f, -1.52025921e-02f, 2.22611930e-02f, -3.07153426e-02f, -7.98586234e-02f, -3.73019464e-02f, 7.40092061e-03f, -1.49125919e-01f,
  -4.69650179e-02f, 1.32687129e-02f, 2.40630247e-02f, 7.76808709e-02f, -6.40091747e-02f, -5.86108714e-02f, -1.81395095e-02f, -6.31560087e-02f, -1.16219297e-01f, -7.44503587e-02f,
  -1.18463658e-01f, 3.43877494e-01f, 2.16573849e-01f, 2.83643693e-01f, 5.95851913e-02f, -3.28721941e-01f, -3.37436408e-01f, 1.78344801e-01f, -2.11775988e-01f, 1.06564425e-01f,
  -1.32761911e-01f, 2.36770660e-01f, -3.03688139e-01f, -8.24483037e-02f, -7.36397922e-01f, -6.42658532e-01f, -1.48330286e-01f, -5.39965071e-02f, -1.09746695e-01f, 1.86326876e-01f,
  -1.52486682e-01f, -1.46831229e-01f, -5.81701361e-02f, 1.08416654e-01f, 2.19525233e-01f, 5.39135814e-01f, 2.70208210e-01f, 1.45564005e-01f, 4.15593237e-01f, -7.74458051e-02f,
  -3.01158637e-01f, -1.47668064e-01f, 1.86693937e-01f, 5.06015122e-02f, 6.81204349e-02f, 1.09298371e-01f, 7.94000402e-02f, -5.27805910e-02f, 3.22548412e-02f, 4.58692526e-03f,
  3.06290798e-02f, -1.67525318e-02f, -1.97006785e-03f, -3.74927819e-02f, 4.63688746e-02f, 1.12661444e-01f, 3.53140123e-02f, 6.48611635e-02f, 5.32649681e-02f, 1.90243721e-02f,
  3.78492251e-02f, 5.14238700e-02f, 1.76380724e-01f, -2.36600842e-02f, 1.87418591e-02f, -1.74687076e-02f, 3.36938277e-02f, 3.18701230e-02f, -8.27357697e-04f, -3.43835242e-02f,
  -4.67448905e-02f, 2.48506628e-02f, -3.79182845e-02f, -4.28050011e-02f, -1.06003666e-02f, -7.67980143e-03f, 4.84473596e-04f, -1.34780882e-02f, 2.70980038e-02f, 1.52915688e-02f,
  4.12039310e-02f, 5.69830053e-02f, -1.80384237e-02f, 1.21261992e-01f, 2.36598719e-02f, 1.70303434e-02f, 3.83141376e-02f, -1.50294919e-02f, -2.50219256e-02f, -1.72758084e-02f,
  -1.33490935e-02f, -2.65518073e-02f, 1.51104797e-02f, -4.95979562e-02f, -9.95417610e-02f, 1.68117043e-02f, 1.80787295e-02f, 6.90052807e-02f, 1.26881907e-02f, 5.82719781e-02f,
  3.02772969e-02f, 1.80077463e-01f, 4.31486405e-02f, -1.17698498e-01f, -4.21727151e-02f, -5.72079234e-02f, -1.02176167e-01f, 4.95227836e-02f, 9.28833410e-02f, -4.16824892e-02f,
  1.34812966e-01f, 7.83794597e-02f, 1.40518323e-02f, -4.15113457e-02f, 1.15375342e-02f, -5.71271852e-02f, 9.64433234e-03f, 7.86382034e-02f, 1.09112859e-01f, 6.29052743e-02f,
  8.38386714e-02f, 3.08555253e-02f, 2.78416183e-03f, -3.26039456e-02f, -1.24450019e-02f, 7.55589157e-02f, -6.66825054e-03f, 1.64349563e-02f, 3.32726240e-02f, 2.79701948e-02f,
  3.54482830e-01f, -6.77908659e-02f, -6.26374066e-01f, -9.47099552e-03f, 1.46874100e-01f, 2.23933280e-01f, 5.25418073e-02f, 4.08130214e-02f, -2.92867064e-01f, 3.33256274e-01f,
  4.97124553e-01f, -3.34438562e-01f, -8.83121863e-02f, 5.58146954e-01f, 4.29975381e-03f, -6.59790263e-02f, 4.32682663e-01f, 2.85829127e-01f, -2.03069776e-01f, 3.31128761e-02f,
  1.66760348e-02f, 6.00278020e-01f, -8.31739530e-02f, 1.63395509e-01f, 2.45436162e-01f, -1.81443661e-01f, 3.17987949e-01f, -2.17956454e-01f, 3.09175134e-01f, 6.77445233e-02f,
  5.10018039e-03f, 1.37868347e-02f, -5.05157746e-02f, -1.15387015e-01f, 6.62498036e-03f, 1.61974281e-01f, 5.48311416e-03f, -3.51581611e-02f, -5.14220521e-02f, -3.30941714e-02f,
  8.58761091e-03f, 7.65682943e-03f, -3.41969617e-02f, -2.90615652e-02f, -1.14599457e-02f, -1.41207753e-02f, -1.02996968e-01f, -3.08292024e-02f, -1.00167386e-01f, 7.08584499e-04f,
  -1.98799670e-01f, 6.63245246e-02f, 1.07532796e-02f, -4.63175625e-02f, -1.24815270e-01f, 1.69548355e-02f, -1.35793630e-02f, -8.48236233e-02f, -1.13313105e-02f, -1.57638211e-02f,
  4.34249043e-02f, 1.82057321e-02f, 1.91245135e-02f, 3.67635414e-02f, 1.24840895e-02f, 7.56350756e-02f, -3.18014761e-03f, 3.37510221e-02f, -5.86385988e-02f, 1.04755282e-01f,
  3.01046087e-03f, 1.84144452e-02f, 3.64153944e-02f, 8.46336856e-02f, 1.27599146e-02f, 2.91550793e-02f, -7.48157175e-03f, 2.23333556e-02f, -1.06728613e-01f, 1.36845885e-02f,
  -2.27031894e-02f, -1.84983406e-02f, 8.29949509e-03f, 1.62734129e-02f, -1.94324236e-02f, -4.67728190e-02f, 9.29961950e-02f, -2.32169405e-02f, -4.48071174e-02f, -1.20631382e-02f,
  2.35142489e-03f, -5.55668250e-02f, -1.78765818e-01f, -7.43897036e-02f, -7.34459683e-02f, 8.65504667e-02f, -5.97736761e-02f, -3.38430479e-02f, -4.74097505e-02f, 2.41621863e-02f,
  6.37832358e-02f, -2.15881225e-02f, -2.19528750e-02f, 1.63055528e-02f, -3.96432728e-02f, 8.80123153e-02f, 7.79823363e-02f, 1.76180005e-02f, 9.16620865e-02f, -1.11563848e-02f,
  2.95614861e-02f, 2.57594325e-02f, -7.10068876e-03f, -5.05563803e-02f, 1.44160613e-01f, 9.50136222e-03f, -3.21894474e-02f, -8.33313465e-02f, -5.29349875e-03f, -4.80389148e-02f,
  -5.12996875e-02f, 1.55373812e-01f, 1.60717338e-01f, 6.67522699e-02f, 2.62559593e-01f, -1.80861235e-01f, -1.32467926e-01f, 3.01328480e-01f, 1.95006371e-01f, -1.05199693e-02f,
  -2.23087519e-02f, -1.36373132e-01f, -1.16414968e-02f, -1.15159251e-01f, -5.90423644e-01f, -2.39662677e-01f, -3.07303488e-01f, -2.72941113e-01f, 7.46279722e-03f, -5.23568653e-02f,
  -1.07239656e-01f, -6.29758686e-02f, -1.05221167e-01f, 2.79860198e-01f, 2.73421139e-01f, 1.91251710e-01f, -2.34756753e-01f, 1.64572582e-01f, -5.23014516e-02f, 2.46117394e-02f,
  -9.24701244e-02f, 9.11744535e-02f, 1.09422147e-01f, 1.57940552e-01f, -3.23450305e-02f, -7.28347432e-03f, -1.03020608e-01f, -6.09123632e-02f, 5.64988069e-02f, 6.59680143e-02f,
  -4.39232364e-02f, 7.30078965e-02f, 4.69967090e-02f, -1.14326400e-03f, 1.90247923e-01f, 8.86910856e-02f, 1.14327751e-01f, 6.82326406e-02f, 9.32648480e-02f, -3.45870294e-02f,
  1.32165879e-01f, 6.59291446e-02f, -7.30745122e-02f, -6.16082959e-02f, -2.51374077e-02f, 1.21199645e-01f, -5.67177199e-02f, -1.13466926e-01f, -1.08521357e-02f, 5.70458621e-02f,
  -2.21318584e-02f, -8.71118233e-02f, -3.71788815e-02f, 7.25649819e-02f, 4.65340540e-02f, 1.86582953e-02f, 1.60641167e-02f, -7.99070150e-02f, 3.36423591e-02f, -4.38225269e-02f,
  -4.90499102e-02f, 7.32402205e-02f, 8.40934813e-02f, -2.32858770e-02f, -5.77988755e-03f, 5.66388033e-02f, -1.26507863e-01f, -1.18878102e-02f, -1.01180803e-02f, 4.52484526e-02f,
  5.64131662e-02f, -6.45714030e-02f, 7.02016503e-02f, -1.08320061e-02f, 6.91569373e-02f, 2.60873064e-02f, 3.60490475e-03f, 6.52669743e-02f, 1.40582435e-02f, -1.09667324e-01f,
  -4.16374087e-01f, -2.00978920e-01f, -2.75118090e-02f, 8.54621679e-02f, -1.14000686e-01f, -2.34752968e-02f, -8.86443630e-02f, 8.60093459e-02f, -1.25669926e-01f, -3.44503741e-03f,
  1.22580389e-02f, 1.42917475e-02f, -6.55462891e-02f, 1.17476910e-01f, -1.28078103e-01f, -7.35849440e-02f, -7.41131157e-02f, -6.41180128e-02f, -2.29435973e-02f, 2.64699161e-02f,
  9.76774259e-04f, 1.45074092e-02f, -6.35062307e-02f, 3.83199193e-02f, -3.39117396e-04f, -6.11775406e-02f, -8.73927623e-02f, 5.42647252e-03f, -6.35068500e-05f, -1.66971743e-01f,
  -1.70107648e-01f, -1.07248552e-01f, 8.49502906e-02f, -1.83340892e-01f, 6.56964183e-02f, -3.89888771e-02f, 1.38083128e-02f, 1.05013847e-01f, -9.28924456e-02f, 2.75969710e-02f,
  1.66344404e-01f, -3.60236764e-02f, 1.32992875e-03f, 8.15892220e-02f, -6.72552958e-02f, 4.79812687e-03f, -6.35355562e-02f, -1.17661292e-02f, -4.67065518e-04f, -1.06362596e-01f,
  -8.17683414e-02f, 1.85759999e-02f, 7.57306069e-02f, 8.01335052e-02f, 1.13964520e-01f, 1.55600822e-02f, -4.33890074e-02f, -6.84643490e-03f, 3.64347063e-02f, 1.52137533e-01f,
  -8.05847272e-02f, -1.04250327e-01f, -5.24032265e-02f, -4.50444520e-02f, 7.81023279e-02f, -3.00465524e-02f, -9.84096453e-02f, -5.62500693e-02f, -5.85171282e-02f, -7.02492744e-02f,
  5.18819503e-02f, 8.92054513e-02f, 7.24032568e-03f, 5.61060570e-02f, -5.37736788e-02f, -2.01570950e-02f, -5.53270057e-02f, -5.85363656e-02f, 6.56486601e-02f, 5.63466065e-02f,
  2.57423166e-02f, -1.43384766e-02f, -5.60406782e-02f, 7.07191899e-02f, 9.04748812e-02f, -5.61112761e-02f, 3.42597812e-02f, 9.95017514e-02f, -7.23073818e-03f, -1.79843605e-02f,
  1.01682343e-01f, -5.87273091e-02f, -2.51729507e-02f, 2.25423481e-02f, -2.28833240e-02f, -2.31670421e-02f, -8.97001103e-02f, -1.31255006e-02f, -1.00201689e-01f, 4.19488400e-02f,
  6.96471706e-02f, -1.01033293e-01f, 2.25564884e-03f, 6.87255040e-02f, -9.33736265e-02f, -1.68176610e-02f, 1.33555457e-02f, -1.92416962e-02f, 9.20452625e-02f, 6.54899105e-02f,
  1.50867607e-02f, -5.84712364e-02f, -1.65764485e-02f, 2.97991782e-02f, 4.58369218e-03f, -7.04539046e-02f, -3.27755846e-02f, 4.15247977e-02f, -8.95698741e-02f, 2.24720687e-03f,
  -1.27678260e-01f, -1.61447778e-01f, -9.19146612e-02f, -3.24346349e-02f, 6.74186349e-02f, -3.65020265e-03f, 1.85183992e-04f, -8.18844140e-03f, -1.00803211e-01f, -3.09166536e-02f,
  -3.75786945e-02f, 6.95384741e-02f, 1.45891272e-02f, -2.54748203e-02f, -3.63620482e-02f, -2.07374338e-02f, 3.80065739e-02f, -7.73892552e-02f, -8.10032561e-02f, 8.62557790e-04f,
  2.22330559e-02f, -3.54182906e-02f, 1.19010702e-01f, -5.48342802e-02f, 7.47831399e-03f, 2.87179425e-02f, 3.27180400e-02f, 7.98196346e-03f, 3.91250327e-02f, 5.48228249e-02f,
  -7.44625032e-01f, 6.28606021e-01f, 1.75432295e-01f, -5.09916730e-02f, -1.92437440e-01f, 2.41445918e-02f, -9.26924720e-02f, 1.21905301e-02f, -3.68458964e-02f, 2.55380958e-01f,
  -4.17121537e-02f, 4.47115973e-02f, 3.83770131e-02f, 2.64102608e-01f, -4.86484200e-01f, 2.38180265e-01f, 1.42227873e-01f, 1.39358178e-01f, 9.24737304e-02f, -1.20790824e-01f,
  -5.20420484e-02f, 3.32426727e-02f, 2.10211262e-01f, 1.90869927e-01f, -5.79824448e-02f, 8.25282000e-03f, -2.63544112e-01f, 3.29416916e-02f, 4.59689423e-02f, -1.27107397e-01f,
  -1.56386808e-01f, 2.22382639e-02f, -5.32441325e-02f, -4.06211950e-02f, -8.75844657e-02f, -3.80714200e-02f, -3.94632556e-02f, -1.28884003e-01f, -5.49189784e-02f, 1.14774350e-02f,
  -1.48949465e-02f, -1.69748571e-02f, 6.00619465e-02f, -1.30990855e-02f, -9.65533927e-02f, 7.63688758e-02f, 1.15307979e-02f, 9.19486359e-02f, 3.02473623e-02f, 1.13865100e-01f,
  1.07640356e-01f, 7.58195370e-02f, 4.50502634e-02f, 5.32612465e-02f, -2.67643593e-02f, 2.36664508e-02f, 7.53945038e-02f, -1.11105114e-01f, 2.31850352e-02f, -5.47137074e-02f,
  -9.78310499e-03f, -5.03329337e-02f, -5.09085692e-03f, -4.31123637e-02f, 6.50133789e-02f, -1.48161100e-02f, 5.35428226e-02f, -3.92637029e-02f, 2.50850543e-02f, 5.19859716e-02f,
  -3.55233327e-02f, 4.92628105e-03f, 1.03037329e-02f, 1.28579848e-02f, -4.03916016e-02f, 3.61493118e-02f, 1.47698652e-02f, -1.13959089e-02f, 6.33339733e-02f, -8.21954012e-03f,
  4.26827278e-03f, -6.38984218e-02f, 2.28746850e-02f, 3.38824000e-03f, -4.55109663e-02f, 2.77913213e-02f, -1.19569618e-02f, 8.75324681e-02f, -5.91342859e-02f, -1.25442576e-02f,
  -3.80148590e-01f, -1.97950542e-01f, -2.98175309e-02f, -9.09125134e-02f, -2.00467464e-02f, -7.50578195e-02f, -3.17708813e-02f, -9.68568847e-02f, -4.47673574e-02f, -1.46745011e-01f,
  -1.35206267e-01f, -4.04029526e-02f, -1.67213172e-01f, -4.71057147e-02f, 3.36899944e-02f, -6.33836836e-02f, 1.39700659e-02f, -2.48146933e-02f, -1.14142478e-01f, -9.16742235e-02f,
  -5.37490174e-02f, -6.86420575e-02f, -2.02892125e-02f, 5.46873696e-02f, -8.93099885e-03f, -8.58960822e-02f, -6.88319355e-02f, 8.88654292e-02f, -1.06233381e-01f, 6.51115775e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.76726097e-01f, 4.51466501e-01f, 7.39733651e-02f, 3.40560228e-02f, 5.18576086e-01f, 6.94433272e-01f, 3.79748106e-01f, 5.34562528e-01f, 1.28536671e-01f, 4.68725830e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.68859458e-01f, -1.78431086e-02f, 2.51005620e-01f, 2.65217245e-01f, 7.33571529e-01f, 5.07163405e-01f, -6.93559796e-02f, -2.98941433e-01f, -9.01214257e-02f, -2.92434305e-01f,
  3.00621629e-01f, -8.70322138e-02f, -2.34194428e-01f, 3.89346689e-01f, 2.86431015e-01f, 3.60239625e-01f, -3.77535708e-02f, 2.40935266e-01f, -3.75592440e-01f, 2.03180626e-01f,
  8.69895890e-02f, -6.26319289e-01f, 3.18193063e-02f, 4.14786756e-01f, -2.36275628e-01f, -6.91325441e-02f, -2.94302464e-01f, 2.36553803e-01f, -3.62124860e-01f, -2.24428698e-01f,
  -7.46438652e-02f, -1.42230973e-01f, -2.77836863e-02f, 2.88627684e-01f, -1.29461095e-01f, 3.53338003e-01f, 6.13119900e-02f, -4.10172390e-03f, -9.87241268e-02f, 4.42825556e-01f,
  4.08946872e-02f, -1.46643937e-01f, -2.40216240e-01f, 4.12707120e-01f, -2.08929870e-02f, -4.82649267e-01f, -5.91896847e-02f, -2.50971735e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.60154009e-01f, -3.62302437e-02f, -3.22805196e-01f, 4.32800174e-01f, 1.03012097e+00f, -7.33424485e-01f, 3.07848155e-01f, 1.05361974e+00f, -1.42736718e-01f, -1.45818368e-01f,
  2.30071396e-01f, 1.13068730e-01f, -1.73564464e-01f, 8.03459764e-01f, 3.68112952e-01f, 6.86693966e-01f, 1.17560230e-01f, 2.97273815e-01f, -3.03777188e-01f, 4.70589101e-01f,
  -7.84939408e-01f, -1.24568082e-02f, -2.71240890e-01f, -1.39323413e-01f, -2.87497818e-01f, 3.72022599e-01f, 9.81413782e-01f, 4.29251492e-01f, 9.80640709e-01f, -7.56412968e-02f,
  1.34535119e-01f, -6.67815328e-01f, -2.12309748e-01f, -5.00498675e-02f, 2.21877452e-02f, -1.46125361e-01f, 5.43937236e-02f, -1.08414084e-01f, -5.52524216e-02f, -7.05331517e-03f,
  -4.32555936e-02f, 6.55091405e-02f, -4.74120080e-02f, -1.35416865e-01f, 1.38945386e-01f, 1.40158370e-01f, 7.98875690e-02f, -2.23449051e-01f, -2.05825716e-01f, 3.03532302e-01f,
  -7.61013776e-02f, 1.19175710e-01f, 2.10483298e-02f, 6.51481142e-03f, -2.31609493e-01f, 3.18703949e-01f, -1.09504677e-01f, -2.22782746e-01f, 1.59794658e-01f, 1.52829096e-01f,
  7.91926324e-01f, -1.94386229e-01f, -1.54169247e-01f, -3.65434796e-01f, -3.21062207e-01f, 3.29902470e-01f, -2.95336545e-01f, -1.66913018e-01f, -4.22233269e-02f, 3.01223189e-01f,
  6.21880472e-01f, 3.67221951e-01f, -1.20756164e-01f, 3.05595517e-01f, 8.93374205e-01f, -1.44835427e-01f, 2.65154932e-02f, 8.10505301e-02f, -1.64746959e-02f, -4.66768444e-01f,
  3.17938864e-01f, 2.78785169e-01f, 4.70114350e-01f, 3.55363637e-01f, 4.91615176e-01f, 7.09355831e-01f, 5.71069196e-02f, 1.91074938e-01f, -1.65660933e-01f, 2.86458164e-01f,
  1.26130390e+00f, 3.08437590e-02f, -3.94353092e-01f, -1.86358511e-01f, 2.15412050e-01f, -8.25881660e-02f, -2.29295522e-01f, 7.18618274e-01f, -1.96022063e-01f, -1.24216303e-01f,
  -1.02001548e+00f, -5.97861521e-02f, 3.88860375e-01f, 1.54197849e-02f, 1.79250702e-01f, -6.60406888e-01f, 2.53627509e-01f, 8.00095737e-01f, 3.40181729e-03f, 6.34904623e-01f,
  2.18374170e-02f, -9.25129105e-04f, 4.50023979e-01f, 3.63036022e-02f, -1.09165885e-01f, 4.52540845e-01f, -6.29422486e-01f, -6.02804959e-01f, -8.17096084e-02f, -1.80445567e-01f,
  -1.56817913e-01f, 1.04948807e+00f, -2.31157005e-01f, 1.39149892e+00f, 1.35980055e-01f, 6.26190245e-01f, -1.16544150e-01f, 2.91029274e-01f, 7.77698904e-02f, 3.06783706e-01f,
  6.30207121e-01f, -6.23500705e-01f, -5.01775503e-01f, 8.55115235e-01f, 7.16140449e-01f, -2.61116862e-01f, 2.93142974e-01f, 2.70402133e-01f, 3.35841060e-01f, 1.84463024e-01f,
  -4.23532426e-01f, 1.66036844e-01f, -2.20109209e-01f, 4.93925899e-01f, -1.07119285e-01f, 1.63062841e-01f, 4.37516235e-02f, -6.67738438e-01f, -3.12398314e-01f, 6.39796257e-01f,
  6.76458627e-02f, 2.03324363e-01f, 5.85040510e-01f, -9.72575173e-02f, -4.17640954e-01f, 1.43389583e-01f, 8.49837840e-01f, -3.08480084e-01f, -1.24911271e-01f, 7.29783177e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  6.35249436e-01f, 2.63788551e-01f, -1.69560835e-01f, 5.20536542e-01f, 3.66383255e-01f, 2.86425859e-01f, 3.95458907e-01f, 2.88722008e-01f, 7.28418708e-01f, 4.77552503e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.92059472e-01f, -3.26439798e-01f, 4.43955630e-01f, 9.96774077e-01f, -5.23479342e-01f, -5.27842343e-01f, -7.73502421e-03f, -4.64823633e-01f, -2.25409925e-01f, -5.05256094e-02f,
  -5.64553022e-01f, -4.39812034e-01f, -5.70904016e-01f, -3.77600998e-01f, 1.62975401e-01f, 1.21333516e+00f, -2.19605342e-02f, -2.54931003e-01f, 1.41677260e-01f, -9.64246929e-01f,
  -3.71123701e-01f, -6.29530549e-02f, -5.24764419e-01f, 7.62745500e-01f, 2.17798334e-02f, 7.31400251e-01f, 4.41859514e-02f, -4.92721438e-01f, 2.32067540e-01f, -3.18923175e-01f,
  -2.37180069e-01f, 6.45455658e-01f, 3.64792049e-01f, -7.53097773e-01f, -2.01812491e-01f, 2.20282692e-02f, -8.23393986e-02f, -9.54001695e-02f, -7.17891395e-01f, 9.71592367e-01f,
  -5.52475154e-02f, 1.31846756e-01f, -1.29935062e-02f, 4.34429199e-01f, -2.85569072e-01f, 4.62014526e-01f, -1.51203617e-01f, -4.48207140e-01f, -1.93800837e-01f, 1.97424158e-01f,
  3.29067290e-01f, 6.55731738e-01f, 5.88489830e-01f, -2.73788422e-01f, 1.04939163e+00f, -7.26885915e-01f, -1.61757663e-01f, -1.67564332e-01f, -3.87737632e-01f, -5.03464639e-01f,
  -1.23316348e-02f, 6.10474944e-01f, -7.90607214e-01f, -1.96567088e-01f, -6.63150966e-01f, 3.59727681e-01f, 3.24179918e-01f, 5.90109944e-01f, -6.58071339e-01f, -4.32500154e-01f,
  9.57124472e-01f, -7.80953169e-01f, 2.01030493e-01f, -2.87977189e-01f, -3.96191120e-01f, 5.21890581e-01f, -2.62228072e-01f, -3.71187538e-01f, 4.62739915e-01f, -1.59166962e-01f,
  6.19583130e-01f, 5.77669621e-01f, 3.92469943e-01f, -2.77711600e-01f, -5.65877676e-01f, -8.10146928e-02f, -9.11254942e-01f, -6.35402560e-01f, -1.11940533e-01f, -7.43685439e-02f,
  3.30010146e-01f, 9.23520178e-02f, 4.09929067e-01f, -4.93654966e-01f, 1.13855743e+00f, 4.84063506e-01f, -7.20566139e-02f, -3.89028847e-01f, -8.45724344e-01f, 3.69058996e-01f,
  -2.23179888e-02f, -2.22215235e-01f, -3.83621842e-01f, 3.18250895e-01f, 1.24599397e-01f, -3.19809973e-01f, 7.00129330e-01f, 2.64497638e-01f, 6.63267434e-01f, -5.11801660e-01f,
  5.04257262e-01f, -5.54155529e-01f, -1.71156530e-03f, -3.31660002e-01f, -5.08634686e-01f, -9.40234363e-01f, 7.28309512e-01f, 6.04051650e-01f, 1.06432509e+00f, -5.25140584e-01f,
  -1.09576203e-01f, 2.08021149e-01f, 2.85272777e-01f, 8.83486196e-02f, -4.65829700e-01f, -3.18064272e-01f, -5.42818367e-01f, 4.69737947e-02f, -5.44481337e-01f, 1.93630829e-01f,
  -1.38886377e-01f, -7.67774343e-01f, 8.97679292e-03f, 5.59477806e-02f, -5.64387321e-01f, 1.74312606e-01f, -5.76463789e-02f, -2.48480305e-01f, -3.40359598e-01f, -3.58580112e-01f,
  -5.95493197e-01f, 1.34540200e+00f, 4.12128195e-02f, 7.99240842e-02f, -4.41643327e-01f, 4.23392534e-01f, 2.00818628e-01f, 5.55900276e-01f, -3.58865559e-01f, 1.76604822e-01f,
  8.93187150e-02f, 1.83383718e-01f, 1.52132168e-01f, 1.45885602e-01f, 3.45081419e-01f, 1.24230170e+00f, -6.84300244e-01f, -8.42534125e-01f, -3.40059996e-01f, -5.29194474e-01f,
  4.57615733e-01f, -1.18854813e-01f, -4.64831382e-01f, -6.15117431e-01f, 8.38040233e-01f, 4.87067610e-01f, 2.55265623e-01f, 3.46190125e-01f, -1.21447168e-01f, 5.08782625e-01f,
  -3.37790728e-01f, -5.37564099e-01f, 8.09403718e-01f, 5.16483665e-01f, -7.40425766e-01f, -2.37165436e-01f, 5.40035404e-02f, 3.09290230e-01f, 2.12568849e-01f, 5.37887037e-01f,
  -2.09661275e-01f, 3.07592601e-01f, -4.08113837e-01f, -3.05837035e-01f, 2.14782089e-01f, -3.36159885e-01f, -6.24241829e-01f, -2.27248222e-01f, 8.81278753e-01f, 7.04558671e-01f,
  4.42470491e-01f, 1.90679789e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.29593897e-01f, 1.67145371e-01f, -5.71682394e-01f, -1.86176941e-01f, 5.86398244e-01f, 3.23295981e-01f, -1.65237680e-01f, -5.13046011e-02f, -3.19152296e-01f, 1.26361579e-01f,
  -2.48426303e-01f, -2.26809680e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    