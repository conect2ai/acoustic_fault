/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.74278581e-01f, 1.98957548e-02f, -1.23828776e-01f, -8.09359774e-02f, 1.05174392e-01f, 2.89863665e-02f, -2.16238737e-01f, -7.52114272e-03f, 5.97966388e-02f, -9.12851319e-02f,
  -7.07536042e-02f, 8.88761133e-03f, -8.21685232e-03f, 1.93775576e-02f, -1.83292508e-01f, -9.85009521e-02f, -8.77534598e-02f, -5.11727817e-02f, -1.46161795e-01f, 4.04897742e-02f,
  7.45366365e-02f, -2.53032856e-02f, -1.92973465e-01f, 5.69528267e-02f, 1.41068667e-01f, 3.80722545e-02f, 4.53450345e-02f, 2.03520823e-02f, 8.81658792e-02f, 1.84360176e-01f,
  -1.70285836e-01f, -1.72683254e-01f, -8.58217850e-02f, -4.77661416e-02f, 5.35965897e-04f, -7.40240812e-02f, -9.20296982e-02f, 6.78999498e-02f, 5.42889237e-02f, 6.44046739e-02f,
  -1.05602285e-02f, -3.97712849e-02f, -3.18520423e-03f, 9.62178037e-02f, -4.22384366e-02f, -3.82236321e-03f, 7.11134523e-02f, -4.15435323e-04f, 1.19392911e-03f, -5.74745014e-02f,
  4.06288095e-02f, 1.23746701e-01f, 1.98401585e-02f, 1.29196197e-01f, -1.30137742e-01f, 3.62360515e-02f, 3.47090885e-02f, 1.05997026e-02f, 1.67320538e-02f, -2.42707767e-02f,
  3.84767577e-02f, -1.77220330e-02f, -9.13605036e-04f, -5.14170304e-02f, -3.87786031e-02f, 5.94592374e-03f, 2.53954846e-02f, -8.05306062e-03f, -3.85360308e-02f, -4.45011593e-02f,
  1.12813428e-01f, 5.92691042e-02f, -3.79756875e-02f, -6.95613027e-02f, 2.10229401e-02f, 3.86079289e-02f, -4.85337339e-02f, -2.57199854e-02f, 3.03337667e-02f, -4.75222692e-02f,
  2.16649678e-02f, 4.87590283e-02f, -9.30765457e-03f, 1.36587033e-02f, 2.15329006e-02f, 4.33120951e-02f, -1.92504842e-02f, 1.71861518e-02f, -1.06139846e-01f, -3.87919135e-03f,
  -1.17127873e-01f, 8.48351941e-02f, -6.44664988e-02f, -1.28060520e-01f, 6.49884939e-02f, 1.83063261e-02f, -4.64115432e-03f, 5.71063384e-02f, -1.98153071e-02f, -4.63073365e-02f,
  -9.96628180e-02f, -4.37864251e-02f, -8.96106809e-02f, 6.97033331e-02f, -9.21980105e-03f, -2.87117939e-02f, -1.94995366e-02f, -2.16356888e-02f, -2.34252028e-03f, -1.24559030e-02f,
  -1.07096620e-01f, -6.70312941e-02f, -1.11618847e-01f, -3.02663669e-02f, -1.23939142e-01f, -4.22674529e-02f, -1.62598997e-01f, -9.06270444e-02f, -1.97643697e-01f, -2.20160007e-01f,
  2.86535788e-02f, 1.22115389e-01f, 3.20153236e-01f, 6.54516220e-02f, 2.73595512e-01f, 7.22988024e-02f, 2.14788929e-01f, -2.53734708e-01f, -1.93589643e-01f, 8.22859928e-02f,
  3.19079719e-02f, -1.42958179e-01f, -2.46530175e-01f, -1.08330615e-01f, -2.58555766e-02f, 1.97476983e-01f, 2.99692065e-01f, 8.70744288e-02f, -2.54847825e-01f, -5.01236394e-02f,
  -9.19364020e-02f, -7.83274323e-02f, -1.19162396e-01f, -2.54088163e-01f, 7.97189027e-02f, -1.69854403e-01f, 1.12441301e-01f, 6.27431273e-02f, 1.09841533e-01f, 4.47610348e-01f,
  1.81711972e-01f, 3.43438506e-01f, -8.21916480e-03f, 4.65846024e-02f, 1.33122280e-01f, -2.87552364e-02f, 3.28431539e-02f, 9.55308229e-02f, -1.26447733e-02f, -2.62037218e-02f,
  2.52887718e-02f, -5.51775917e-02f, 4.17929590e-02f, -8.67409483e-02f, 4.80236560e-02f, -3.33576873e-02f, -2.61286106e-02f, 5.66677563e-02f, 1.16958104e-01f, 1.61648020e-01f,
  1.15094557e-01f, 2.64996141e-01f, 2.40788072e-01f, -1.26616834e-02f, 4.49020937e-02f, 7.80050233e-02f, 1.04575843e-01f, 6.49376661e-02f, 6.84163496e-02f, -4.14025970e-02f,
  -7.25380108e-02f, 1.84879396e-02f, 7.37005025e-02f, 2.56609134e-02f, -8.65190998e-02f, -1.28063876e-02f, 7.30818957e-02f, -3.08444891e-02f, -1.26127936e-02f, -7.08535761e-02f,
  -1.94373969e-02f, -5.54242684e-03f, -2.79912073e-02f, 3.47081423e-02f, -6.36881590e-02f, 6.79877400e-02f, 1.17482180e-02f, -5.56608252e-02f, 3.51739973e-02f, -4.31305170e-02f,
  -5.49552515e-02f, 5.96310869e-02f, 1.95330172e-03f, -1.00469276e-01f, 5.21930791e-02f, 2.75463555e-02f, -9.71222017e-03f, -1.26528516e-02f, -3.88255790e-02f, 1.01124555e-01f,
  -3.32078993e-01f, 1.52717784e-01f, -1.81556717e-02f, -3.06578185e-02f, 3.34012061e-02f, -4.91809174e-02f, 4.72675450e-02f, -4.08172384e-02f, 4.56385463e-02f, -3.26875895e-02f,
  8.26937482e-02f, -7.88493231e-02f, -5.65050580e-02f, 4.10936922e-02f, -7.22105280e-02f, -2.58010589e-02f, -8.38254765e-02f, -4.82823923e-02f, -4.41355184e-02f, -7.25116208e-02f,
  -1.48424923e-01f, -1.72699273e-01f, -1.05285808e-01f, -4.86547649e-02f, 1.18681267e-02f, -6.68220744e-02f, -8.30481127e-02f, -1.11044355e-01f, -3.01939715e-02f, -3.13463002e-01f,
  -8.13576937e-01f, 3.21036093e-02f, 9.59843099e-02f, -1.74858734e-01f, 1.01200655e-01f, 1.98551454e-02f, -8.36305544e-02f, -1.58445731e-01f, -1.40686557e-01f, -1.64344758e-01f,
  1.68283537e-01f, 3.71634930e-01f, 2.83853531e-01f, 3.13711882e-01f, -3.03391609e-02f, -5.99056557e-02f, -1.43986996e-02f, -1.12963080e-01f, -3.51337008e-02f, -5.40085621e-02f,
  1.65256441e-01f, -9.52363983e-02f, -2.27790222e-01f, -2.47041006e-02f, -9.74783748e-02f, 1.06216922e-01f, 1.30145736e-02f, -1.29822925e-01f, 7.30389059e-02f, 4.69242688e-03f,
  7.49812722e-02f, -1.11897953e-01f, 1.94199517e-01f, 6.47385716e-02f, 4.82144430e-02f, -6.62921444e-02f, -4.42290381e-02f, -1.09071499e-02f, 4.42168042e-02f, -1.22060575e-01f,
  4.32009660e-02f, -2.37567234e-03f, 9.01916027e-02f, 8.64306986e-02f, -7.66284689e-02f, 1.72085389e-02f, -7.41907805e-02f, -1.21724203e-01f, -4.38543037e-02f, 4.08013575e-02f,
  2.13118583e-01f, 4.10770774e-02f, -1.14707902e-01f, 7.06684068e-02f, 1.33311134e-02f, 1.22621872e-01f, 4.58405651e-02f, -3.75182517e-02f, -9.32277516e-02f, -1.34773538e-01f,
  -3.54240201e-02f, -6.94633201e-02f, 5.03370315e-02f, -4.57889847e-02f, -1.47711504e-02f, -1.89900082e-02f, 1.67834722e-02f, -5.58484159e-03f, 7.88023248e-02f, -7.92894140e-02f,
  1.13520794e-01f, -6.89484775e-02f, 3.43493707e-02f, -6.61928132e-02f, 3.78429107e-02f, -1.61220375e-02f, 6.75800294e-02f, -4.99720220e-04f, -6.97177881e-03f, -2.47636475e-02f,
  3.52564715e-02f, 1.36427889e-02f, -3.10293529e-02f, 3.73095423e-02f, 3.36855650e-02f, 5.68165705e-02f, 5.03752045e-02f, 5.46252839e-02f, 5.23630045e-02f, -3.63093428e-02f,
  1.05438884e-02f, 3.34391803e-01f, 2.62589008e-02f, 2.07097940e-02f, -4.53621931e-02f, 2.53465567e-02f, 1.42086983e-01f, -3.68685201e-02f, 2.16204710e-02f, -1.41115766e-02f,
  3.23121175e-02f, -6.01038523e-02f, 7.30257630e-02f, 1.17357550e-02f, 6.46265820e-02f, 1.19311465e-02f, -6.04840554e-02f, 2.03324780e-02f, 3.11211869e-02f, -1.26722202e-01f,
  -7.24597499e-02f, -1.42288953e-01f, -3.47854309e-02f, 7.06261303e-03f, -6.27219724e-03f, -4.44931053e-02f, 4.37302999e-02f, -3.93184572e-02f, -5.79455160e-02f, -1.28997758e-01f,
  -1.12256758e-01f, 7.81571344e-02f, -3.17104235e-02f, -8.19466636e-02f, 1.42270131e-02f, -1.61743164e-02f, 1.20271541e-01f, -6.88869432e-02f, -1.16554908e-01f, 1.36955343e-02f,
  -8.81158412e-02f, -1.41104102e-01f, -5.33529446e-02f, 7.39590032e-03f, -7.25980557e-04f, -1.19806174e-02f, -4.49174605e-02f, -1.22603811e-01f, -6.41745627e-02f, 6.34032413e-02f,
  -4.41458896e-02f, -1.43438205e-01f, -1.81844488e-01f, -3.62078249e-02f, -2.89623113e-03f, 1.67231099e-03f, -9.69525054e-02f, -1.95558872e-02f, 4.85606380e-02f, 7.91180059e-02f,
  8.97174515e-03f, 6.60327896e-02f, 5.52650839e-02f, -1.03033762e-02f, -4.19685431e-02f, -1.05054956e-02f, 2.15400532e-02f, -1.18843820e-02f, -4.56255563e-02f, -8.18154812e-02f,
  -1.02389626e-01f, -6.42332435e-02f, -8.34701136e-02f, 4.64917161e-03f, -7.07730651e-02f, -6.66581318e-02f, -5.75957038e-02f, -1.20754195e-02f, -4.70822938e-02f, -3.02810296e-02f,
  1.68596487e-02f, 8.68042186e-02f, 3.00682988e-03f, 6.85591325e-02f, 3.22995782e-02f, -2.10358221e-02f, 1.21133119e-01f, 6.71624094e-02f, 8.51750001e-02f, 8.45135525e-02f,
  1.11602478e-01f, 6.39433041e-02f, -4.23999280e-02f, 1.92844141e-02f, 1.11165106e-01f, -1.72994100e-02f, 3.53663377e-02f, 1.50491176e-02f, -4.05688211e-02f, 4.12616041e-03f,
  -4.78234235e-03f, 5.81544712e-02f, 1.87462580e-03f, -8.92677158e-03f, 4.03149985e-02f, -3.36717255e-02f, 1.04008727e-01f, -3.09632737e-02f, 3.54643613e-02f, -1.50540099e-02f,
  2.13393755e-02f, 8.56495127e-02f, -3.57878208e-02f, 4.90725636e-02f, 2.55105570e-02f, -4.07726057e-02f, -3.92794684e-02f, -1.72526818e-02f, -9.42968577e-02f, -1.96502194e-01f,
  -1.73506930e-01f, -2.91684326e-02f, -2.19940059e-02f, -3.90317850e-02f, 4.32603247e-02f, -1.26487715e-02f, -1.70819405e-02f, -3.63261113e-03f, -9.13369060e-02f, -5.43931276e-02f,
  -3.44037282e-04f, 3.49590592e-02f, -6.13960624e-03f, 6.07115850e-02f, 3.95267382e-02f, -8.90025496e-03f, 5.22407666e-02f, 2.50111464e-02f, -5.12263849e-02f, 5.55203743e-02f,
  2.47365423e-02f, 5.05017713e-02f, -6.55304315e-03f, 5.38428798e-02f, 1.12685375e-01f, 1.05818789e-02f, 5.76202683e-02f, 4.55048196e-02f, -1.03589818e-02f, -9.67528846e-04f,
  2.86737263e-01f, 3.96202616e-02f, 3.18507552e-02f, 1.81662098e-01f, -1.34256616e-01f, -1.27539977e-01f, -1.48741424e-01f, -1.27409220e-01f, 3.66354287e-02f, -5.76924607e-02f,
  -1.97943188e-02f, 4.94123064e-02f, -1.41816549e-02f, -2.80306935e-02f, 6.82855844e-02f, -4.11437042e-02f, 1.57102898e-01f, 1.52645901e-01f, 2.05394700e-02f, -7.41939992e-02f,
  4.05062549e-02f, 2.20293075e-01f, 1.92887202e-01f, 4.51002736e-03f, 3.78658772e-02f, -7.30894953e-02f, 7.47202262e-02f, 1.12654284e-01f, 1.17278762e-01f, 1.80836022e-01f,
  9.10980776e-02f, 3.62929776e-02f, -7.06477016e-02f, -5.30192479e-02f, -2.39553060e-02f, 2.22023600e-03f, -9.50868204e-02f, 7.85921440e-02f, 3.39696882e-03f, 4.36339714e-02f,
  6.13610968e-02f, -1.11843217e-02f, -4.96616848e-02f, 3.27079296e-02f, 3.37852836e-02f, -6.07622899e-02f, 7.25511685e-02f, 4.81060259e-02f, -2.26712297e-03f, -1.33380949e-01f,
  4.06763889e-02f, 5.27269915e-02f, -7.72126094e-02f, -1.53277442e-01f, 2.71797460e-02f, 4.06866297e-02f, -1.33519061e-02f, -3.48095261e-02f, -6.60293028e-02f, 5.62071912e-02f,
  -9.29770432e-03f, 9.54599306e-02f, 1.15663275e-01f, 9.41844471e-03f, -5.13498858e-03f, -2.74405046e-03f, 4.86355945e-02f, -1.09431688e-02f, 5.67552373e-02f, 5.49587719e-02f,
  -1.50797516e-02f, -6.37149662e-02f, -6.51796237e-02f, -2.13131476e-02f, -4.40775556e-03f, 7.96298161e-02f, 3.38956378e-02f, 6.50014170e-03f, 1.50857344e-02f, 3.40596214e-02f,
  8.21800716e-03f, -9.75565836e-02f, 7.52602890e-03f, -9.10581835e-03f, -2.81831492e-02f, 3.62165016e-03f, -1.06789311e-02f, -1.61978751e-02f, 4.80523668e-02f, 3.91707197e-02f,
  1.03550944e-02f, -8.75086710e-02f, 9.51020345e-02f, -1.72742140e-02f, -9.00651608e-03f, 1.36760836e-02f, -2.39991974e-02f, 3.72990966e-02f, 4.83618267e-02f, -7.60584846e-02f,
  -4.32742685e-02f, 8.93975347e-02f, 2.98687275e-02f, 5.72688179e-03f, -5.92044145e-02f, -2.82892603e-02f, -4.26856726e-02f, 1.62130445e-02f, -9.41370428e-02f, -8.77017304e-02f,
  -3.05184852e-02f, -7.99903199e-02f, -2.52823085e-02f, -2.39167605e-02f, -1.31478503e-01f, -3.30058299e-03f, -7.53231794e-02f, 8.17357935e-03f, -5.87144345e-02f, -5.71675301e-02f,
  3.41505796e-01f, 2.14850008e-01f, -1.99625328e-01f, 4.47152823e-01f, 6.70342967e-02f, -7.56472796e-02f, 7.26338699e-02f, -1.08770296e-01f, 3.50356326e-02f, 3.87403183e-02f,
  3.06132715e-02f, 1.74850896e-02f, -2.27229837e-02f, -7.68425986e-02f, -2.27309883e-01f, 1.07477985e-01f, 1.50596380e-01f, -6.27669245e-02f, -3.32666993e-01f, -2.28767991e-01f,
  2.24794537e-01f, 2.80630767e-01f, -1.29808597e-02f, -7.89622962e-02f, 2.35036969e-01f, -1.25969291e-01f, 9.89381075e-02f, 1.40185103e-01f, -7.25954324e-02f, 4.35103357e-01f,
  1.47546437e-02f, 3.27748880e-02f, -9.18146819e-02f, 8.10216516e-02f, -6.15589647e-03f, -1.01685584e-01f, -6.43971786e-02f, -8.12607184e-02f, -5.03148213e-02f, -3.15962881e-02f,
  -2.96776202e-02f, 2.73282304e-02f, 3.92468832e-02f, 1.83656439e-03f, 8.07515606e-02f, 2.62975320e-02f, -3.29634361e-02f, -1.01698339e-01f, -5.88588342e-02f, -2.93108616e-02f,
  1.57372907e-01f, 1.74100161e-01f, 3.42803672e-02f, -9.62153599e-02f, -1.62034944e-01f, -5.67419492e-02f, -3.97517495e-02f, 9.53601021e-03f, -1.59061655e-01f, 1.70150205e-01f,
  4.92973030e-02f, 1.57592050e-03f, -2.78515052e-02f, 1.10969897e-02f, 7.49669969e-02f, 2.62868293e-02f, -3.33118960e-02f, 1.07674778e-01f, -7.47393146e-02f, 8.62762183e-02f,
  -9.74316075e-02f, 3.22867706e-02f, -1.35752261e-02f, -5.89930750e-02f, 5.32245683e-03f, 9.56084430e-02f, -5.91663085e-02f, 2.72144750e-02f, -3.16189565e-02f, 1.26677286e-02f,
  -3.32320179e-03f, 2.41459738e-02f, 6.27935678e-02f, -3.27139497e-02f, -1.70848072e-02f, -1.10976491e-02f, -3.49277444e-03f, -9.22957659e-02f, -2.38710511e-02f, 1.97955756e-03f,
  8.82974789e-02f, -2.73944765e-01f, 1.12743177e-01f, -3.10304258e-02f, 6.93892315e-03f, 1.46075094e-04f, 7.28505105e-02f, -1.72201172e-02f, 3.87589112e-02f, 2.43770760e-02f,
  -2.66663209e-02f, -5.15131019e-02f, 1.90257262e-02f, -7.67690018e-02f, -1.01479962e-01f, -1.24647841e-01f, 7.42273703e-02f, 2.59711165e-02f, 2.12964453e-02f, 3.16673443e-02f,
  3.64346802e-02f, 6.81972578e-02f, 1.05485311e-02f, 7.29319677e-02f, 9.36218202e-02f, 4.93812896e-02f, -4.98491377e-02f, -4.36198339e-02f, -2.08244741e-01f, 1.37975246e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.95864870e-03f, -2.58692116e-01f, 2.78955758e-01f, -9.55230668e-02f, 1.46749020e-01f, 3.04562122e-01f, 2.36345470e-01f, 8.86386186e-02f, 6.82782680e-02f, 1.76486233e-03f,
  -1.26973897e-01f, -1.63621694e-01f, -1.92394510e-01f, -9.09505710e-02f, -8.67938548e-02f, 8.08225200e-02f, 7.67207239e-03f, 6.26074448e-02f, 1.62665293e-01f, 1.40943274e-01f,
  -2.59920955e-02f, 1.00339390e-01f, -8.96502137e-02f, 1.47181265e-02f, -4.15927246e-02f, 6.96902946e-02f, 1.05188541e-01f, -3.16045806e-02f, 1.20062651e-02f, 2.19787825e-02f,
  2.14242950e-01f, -7.24574253e-02f, 1.28769577e-01f, -1.69233799e-01f, -3.63605134e-02f, 2.75983848e-02f, -2.01163609e-02f, -7.66758099e-02f, -1.27412871e-01f, -6.78456202e-02f,
  -1.18064798e-01f, 1.53172128e-02f, -5.56908175e-02f, 3.31757851e-02f, 1.05262280e-01f, 1.36054516e-01f, -1.74308136e-01f, -7.75781870e-02f, -5.90039715e-02f, -3.47161703e-02f,
  -1.27076209e-01f, -1.04826456e-03f, 2.74703931e-02f, -1.01280846e-01f, -1.26962764e-02f, 1.48289539e-02f, 1.67266559e-02f, -1.01742417e-01f, 2.20220648e-02f, -4.89413179e-02f,
  9.03242454e-02f, -1.92520730e-02f, -2.98660938e-02f, -1.09089114e-01f, -1.54079804e-02f, -5.10920919e-02f, 6.77792057e-02f, 5.79075925e-02f, 7.29366764e-02f, 1.12098046e-02f,
  6.00734726e-04f, 2.09138729e-02f, -5.43151167e-04f, 5.00049926e-02f, -3.07292826e-02f, 8.61880705e-02f, -1.78101771e-02f, -6.06895499e-02f, 6.37236750e-03f, 3.37219536e-02f,
  -4.96278033e-02f, 1.68045554e-02f, 3.45239192e-02f, -1.80257373e-02f, -8.56637582e-02f, -4.88490053e-03f, -6.69980794e-02f, 4.95920628e-02f, 6.01659603e-02f, -2.43567526e-02f,
  7.91567713e-02f, -9.69988257e-02f, 7.87678361e-03f, -4.32883240e-02f, 7.99470544e-02f, -3.88127640e-02f, -5.79887368e-02f, 5.53888967e-03f, 2.67118681e-02f, 9.17142704e-02f,
  1.10811368e-01f, 9.88014564e-02f, 4.59085368e-02f, 4.23373096e-02f, 1.41651347e-01f, 1.99973378e-02f, -1.42622635e-01f, -8.43289867e-02f, 3.74616943e-02f, 6.26661852e-02f,
  -1.10252790e-01f, 1.59025624e-01f, 1.36304274e-01f, 8.61130431e-02f, 9.38784927e-02f, 2.67308205e-01f, 9.76520479e-02f, 1.19519748e-01f, 1.11402541e-01f, 1.40702218e-01f,
  2.39655256e-01f, 2.04657599e-01f, 5.24078682e-02f, 9.82721746e-02f, 2.26554081e-01f, 2.90980160e-01f, 3.65854383e-01f, 2.99208969e-01f, 7.04080537e-02f, 1.60683870e-01f,
  1.90559238e-01f, 5.11638671e-02f, 2.13874672e-02f, 8.48193318e-02f, 8.60794857e-02f, 8.36857967e-03f, 7.46539235e-02f, -1.42256007e-01f, -9.20088887e-02f, 4.63094525e-02f,
  2.94303019e-02f, 6.57140091e-02f, 1.20855510e-01f, -9.37850177e-02f, 3.38678733e-02f, 5.81192039e-03f, 5.53223537e-03f, -9.24851396e-04f, -3.79173011e-02f, -2.00659409e-01f,
  -1.55644745e-01f, 2.23209277e-01f, -1.28178895e-01f, -2.10950561e-02f, -4.57072305e-03f, -5.01353443e-02f, -7.88008347e-02f, -7.31256008e-02f, -3.18170749e-02f, -6.27722684e-03f,
  -3.98216099e-02f, -2.38662399e-02f, -5.77667449e-03f, -1.07132740e-01f, -2.65110680e-03f, -5.37376888e-02f, 1.38061028e-02f, -9.70236212e-02f, 8.62661470e-03f, 5.80179989e-02f,
  3.82708646e-02f, 1.49908632e-01f, 1.51738524e-01f, 6.17931783e-02f, 7.43644387e-02f, -1.26025639e-02f, 2.23807264e-02f, -4.09553712e-03f, -6.22055680e-02f, -1.19173452e-01f,
  4.88809012e-02f, 6.19193241e-02f, -5.40009923e-02f, 4.04361486e-02f, -2.05676444e-02f, 2.55288347e-03f, -8.18448365e-02f, -4.28453200e-02f, 4.11037430e-02f, 1.56174740e-02f,
  4.28966545e-02f, 5.34918606e-02f, -4.69433181e-02f, -3.68439257e-02f, -5.52956574e-02f, 5.83746582e-02f, -3.38404365e-02f, -5.96693568e-02f, 7.12661967e-02f, 5.13452701e-02f,
  -3.57689783e-02f, 1.72178540e-02f, -1.09617859e-02f, -4.21759225e-02f, -1.50037324e-02f, -2.42814664e-02f, -1.68276578e-02f, -3.49515229e-02f, 4.99921516e-02f, -1.57352667e-02f,
  -6.70263991e-02f, 9.83781815e-02f, -5.27774654e-02f, -1.03604190e-01f, 1.95801295e-02f, 4.00060005e-02f, 2.47780560e-03f, -2.61277147e-02f, -5.52237630e-02f, -1.30406534e-02f,
  1.05069384e-01f, -2.18698103e-02f, 8.34222734e-02f, -4.70709205e-02f, -6.93688989e-02f, -1.43394060e-02f, 5.17864153e-02f, 2.43073869e-02f, 6.36134446e-02f, -1.00278534e-01f,
  -6.24278747e-02f, 8.06234311e-03f, 8.69954526e-02f, 2.11071745e-02f, 9.12061408e-02f, -1.40882656e-01f, -7.23337336e-03f, -9.87024531e-02f, 4.68605906e-02f, -6.87418804e-02f,
  -1.15194269e-01f, -6.29367307e-02f, -4.63055708e-02f, -2.42424216e-02f, 1.13771399e-02f, 3.46660838e-02f, 3.99123989e-02f, -6.69703707e-02f, -2.91289226e-03f, -3.54361728e-05f,
  4.43791971e-02f, 3.74098495e-02f, 1.87502921e-01f, 9.41330940e-02f, 6.78073391e-02f, -3.31266038e-02f, -1.16222531e-01f, -2.90720141e-03f, 1.78877786e-01f, -3.24041992e-02f,
  -7.41748586e-02f, -6.72755251e-03f, -2.82998458e-02f, -4.66245934e-02f, 7.20797386e-03f, 5.79614788e-02f, 6.08790517e-02f, -8.92079473e-02f, 7.55246654e-02f, -9.80142355e-02f,
  1.99480012e-01f, -1.61018178e-01f, -6.10547028e-02f, -1.65752042e-02f, 7.09306598e-02f, 5.34413308e-02f, -1.23095242e-02f, -6.28983416e-03f, -4.25610840e-02f, -2.23307349e-02f,
  -8.43750909e-02f, -6.23222254e-02f, 1.59240197e-02f, -7.00369403e-02f, -3.87144499e-02f, -5.43092191e-02f, -5.94467763e-03f, 4.35682833e-02f, 7.01405928e-02f, 7.77876526e-02f,
  7.09426552e-02f, 5.57338595e-02f, 1.10083722e-01f, -2.92567722e-02f, -2.08596494e-02f, 8.82948413e-02f, 3.43179703e-02f, 6.08125851e-02f, 3.56300548e-02f, -1.47596616e-02f,
  -1.62156597e-02f, 1.05234042e-01f, 2.60115974e-02f, 3.44769955e-02f, -5.00280038e-02f, -6.08630218e-02f, 5.09688146e-02f, 7.74706528e-03f, 1.31124782e-03f, 3.18930782e-02f,
  5.15385307e-02f, 4.11580615e-02f, 2.47027837e-02f, 1.65553612e-03f, 3.18233743e-02f, -6.56182542e-02f, -7.42367804e-02f, 4.55271006e-02f, 4.18755747e-02f, -6.38251454e-02f,
  7.44554475e-02f, -2.22819429e-02f, -3.53030562e-02f, -5.40474765e-02f, -6.33036569e-02f, 2.61526015e-02f, -5.90092242e-02f, -4.63516451e-02f, -7.45597333e-02f, -2.26750318e-02f,
  1.30372956e-01f, 4.72866297e-02f, 5.07457592e-02f, -1.00581190e-02f, -5.07036969e-02f, -1.34843737e-01f, 1.33376652e-02f, 1.12306289e-02f, -2.20877845e-02f, -6.68334365e-02f,
  5.24997674e-02f, -4.58027609e-02f, 2.13608481e-02f, 1.42379804e-02f, 9.33441445e-02f, -5.19706979e-02f, 2.30777208e-02f, 1.89833343e-02f, 4.37780004e-03f, 1.67731829e-02f,
  -1.35732621e-01f, 2.60539558e-02f, 3.97493728e-02f, 9.76289362e-02f, 7.07233399e-02f, 1.18172377e-01f, 1.23531871e-01f, -1.87805314e-02f, 1.00504003e-01f, 7.59698525e-02f,
  -1.52971476e-01f, -1.17986225e-01f, -5.71377799e-02f, 6.24794178e-02f, -2.66251415e-02f, -1.16688401e-01f, -3.18994194e-01f, -4.90266047e-02f, 5.89933991e-02f, -2.33959347e-01f,
  -6.48003146e-02f, 1.52970761e-01f, 2.11033062e-03f, 2.90905200e-02f, -1.29601225e-01f, -2.46415272e-01f, -2.74278879e-01f, -2.74431761e-02f, 2.90860026e-03f, 3.98351103e-02f,
  2.07012706e-02f, -1.02671035e-01f, -2.06847750e-02f, 1.50642633e-01f, -1.15660913e-01f, -3.58033623e-03f, -2.76945252e-02f, 6.68240488e-02f, -2.01531872e-02f, -4.80872840e-02f,
  -1.07112579e-01f, 8.39690343e-02f, 1.19636893e-01f, -4.42042872e-02f, -3.77022326e-02f, 3.43870781e-02f, 4.17232327e-02f, 1.77236565e-03f, -2.88214404e-02f, -2.31407955e-02f,
  8.93510226e-03f, 5.78309782e-02f, 5.84282093e-02f, -4.65709455e-02f, -5.52983470e-02f, -5.89761622e-02f, 2.31229924e-02f, 9.08407122e-02f, 8.57070182e-03f, 6.96327984e-02f,
  5.26459403e-02f, 7.30360895e-02f, 1.62757471e-01f, 7.88786411e-02f, 1.27426833e-01f, 1.58076063e-02f, 9.89791825e-02f, 4.61352803e-02f, 2.00614378e-01f, -2.08134893e-02f,
  -2.71880366e-02f, -1.34513732e-02f, 8.54686573e-02f, 7.83621073e-02f, -7.60880709e-02f, 4.33002673e-02f, 4.29578647e-02f, 6.52570352e-02f, -2.03142334e-02f, 6.02425188e-02f,
  -3.93700562e-02f, -8.39460269e-02f, 3.59931737e-02f, -2.01313407e-03f, 7.07423501e-03f, -2.78074369e-02f, -5.20414822e-02f, 2.25978233e-02f, -9.64910068e-05f, 1.21177863e-02f,
  -7.02808946e-02f, 7.80907422e-02f, -2.46706810e-02f, -9.74714532e-02f, -5.69773503e-02f, 3.15792114e-03f, -5.85800670e-02f, 4.45060432e-02f, 1.88497435e-02f, -2.73638926e-02f,
  -2.75690481e-03f, 4.77147959e-02f, -1.99250072e-01f, -6.75608963e-02f, -7.66644254e-02f, -4.97811427e-03f, 1.01125576e-02f, -3.04309987e-02f, 3.33208889e-02f, -6.46457300e-02f,
  8.36878568e-02f, -4.12416607e-02f, -5.01554720e-02f, 9.62518808e-03f, 1.10207952e-03f, 5.55200502e-04f, -6.22137412e-02f, 3.67545616e-03f, 8.41085017e-02f, -4.79154885e-02f,
  1.10144047e-02f, 5.78331575e-02f, -1.55412192e-02f, 6.43454120e-03f, 1.22351356e-01f, 6.28047884e-02f, -7.52272606e-02f, 1.25253107e-02f, -6.86487257e-02f, -8.25603306e-02f,
  1.20662943e-01f, -4.38758165e-01f, 7.77965635e-02f, -7.16182739e-02f, -1.30976439e-01f, 6.23183995e-02f, -5.61361425e-02f, -1.59339115e-01f, -5.27087115e-02f, -1.44648105e-01f,
  -2.08829507e-01f, 3.17820273e-02f, 1.39761299e-01f, -2.83908825e-02f, 8.51224288e-02f, 3.03364336e-03f, -2.48055458e-02f, 3.00163507e-01f, 3.13516200e-01f, 8.80358182e-03f,
  -3.40246633e-02f, -6.42830273e-03f, 6.93887472e-02f, 7.88281560e-02f, -2.04587415e-01f, 2.75462624e-02f, -3.37223671e-02f, -4.00160737e-02f, -1.82898819e-01f, -8.91512409e-02f,
  9.17197019e-02f, -2.46047840e-01f, 1.71649009e-01f, -1.03533529e-01f, -1.05851581e-02f, -1.11269645e-01f, -4.27091867e-02f, -5.75199574e-02f, -2.43457481e-02f, -6.20921049e-03f,
  -8.44652504e-02f, -2.99826879e-02f, -3.68324071e-02f, -8.91427770e-02f, -7.21593201e-02f, -3.21943648e-02f, -8.90628919e-02f, -3.27539295e-02f, 4.19991240e-02f, -2.03491300e-01f,
  -1.75116643e-01f, -6.40302300e-02f, 1.73086450e-01f, -6.96969181e-02f, -5.92950657e-02f, -3.44022401e-02f, -7.16692209e-02f, -1.21164709e-01f, -3.52215804e-02f, -6.58157021e-02f,
  -7.23780915e-02f, 5.29066585e-02f, 5.56148365e-02f, -6.98592290e-02f, 6.55561090e-02f, -9.58081800e-03f, 1.77752320e-02f, 1.23634189e-02f, -2.10168120e-02f, -5.26506938e-02f,
  1.34916056e-03f, -3.46140340e-02f, -6.56047389e-02f, -1.40767554e-02f, -3.05306278e-02f, -7.19776750e-02f, 1.08491302e-01f, -4.87839505e-02f, 1.62349660e-02f, 5.47212139e-02f,
  1.09739995e-05f, -6.63869753e-02f, 7.50517473e-02f, 3.94052230e-02f, -1.11859530e-01f, 3.92620973e-02f, 6.56382143e-02f, -5.00130914e-02f, -1.99646987e-02f, -6.62820637e-02f,
  1.63034275e-01f, 6.72235414e-02f, 8.83878395e-02f, -3.80677317e-04f, 3.88996340e-02f, -1.07524917e-02f, 2.98531502e-02f, -8.83749276e-02f, 5.93399815e-03f, 6.97361305e-02f,
  -8.95211250e-02f, 4.06206809e-02f, -3.58504243e-02f, -7.19147399e-02f, 9.54094008e-02f, -4.92368080e-02f, -8.96386504e-02f, 5.68047091e-02f, -4.34106886e-02f, -8.99335444e-02f,
  -1.08017266e-01f, 1.16384894e-01f, 2.51106203e-01f, 1.85989395e-01f, -3.94141786e-02f, 3.10656250e-01f, 1.23720929e-01f, 5.40919788e-02f, 1.65569067e-01f, 7.64226764e-02f,
  -4.16145213e-02f, 9.15579218e-03f, -2.97197122e-02f, 1.08751930e-01f, 1.82169661e-01f, 2.01828554e-01f, 1.49916351e-01f, 8.82562324e-02f, 1.53807417e-01f, 4.47659343e-02f,
  1.60950646e-01f, 5.77002168e-02f, 1.87866226e-01f, 1.72852367e-01f, 8.26251507e-02f, 3.34824175e-02f, 1.21294238e-01f, 7.61175230e-02f, 6.22803234e-02f, 3.63631472e-02f,
  1.06915914e-01f, -3.89024690e-02f, -1.16811357e-01f, -2.70528607e-02f, 1.12286299e-01f, 1.00657269e-01f, -8.93566236e-02f, 1.06168156e-02f, 4.69748713e-02f, -1.64785068e-02f,
  -1.68346584e-01f, -1.78186357e-01f, -2.56222840e-02f, -3.53105590e-02f, -5.91917895e-02f, 7.78026460e-03f, -6.42607659e-02f, -7.38205165e-02f, -8.92854761e-03f, -1.05512850e-01f,
  -2.50172354e-02f, 2.44724266e-02f, -8.10010284e-02f, -1.30938604e-01f, -1.97119415e-02f, -8.16669035e-06f, -6.92781955e-02f, -3.31550017e-02f, 4.91399355e-02f, -2.26216707e-02f,
  9.08503830e-02f, -1.31682515e-01f, -2.22573634e-02f, -7.68482760e-02f, -6.97779236e-03f, -5.07736541e-02f, -8.71109143e-02f, -6.63299188e-02f, -6.44698367e-02f, -1.80464014e-01f,
  6.86043799e-02f, -3.86514291e-02f, 3.50539163e-02f, -3.86443995e-02f, 1.39655285e-02f, 9.39613134e-02f, 1.71188246e-02f, 1.12865204e-02f, 1.51107293e-02f, -1.00477338e-01f,
  -1.52492328e-02f, 1.29619651e-02f, 4.60690446e-02f, 7.29696453e-02f, 8.65318328e-02f, 2.59507764e-02f, -4.89236973e-02f, 6.78176209e-02f, -6.37884736e-02f, -1.15201145e-01f,
  -6.66816533e-02f, 5.69094380e-04f, -8.95214528e-02f, -2.04376914e-02f, -1.17191328e-02f, -1.21422643e-02f, -1.03711367e-01f, 6.23224489e-02f, 3.55194323e-02f, -1.02475509e-01f,
  -1.84457507e-02f, 7.50008151e-02f, -2.32339613e-02f, 9.23307091e-02f, -1.05835706e-01f, -1.53776035e-02f, 1.29981443e-01f, -8.76474082e-02f, 6.91194087e-02f, 8.88566077e-02f,
  4.57096845e-02f, -4.71012574e-03f, 2.08296422e-02f, 2.68446021e-02f, -2.70847175e-02f, -4.89421412e-02f, 9.00304094e-02f, 1.02897026e-01f, 2.45189201e-02f, -2.59844642e-02f,
  7.73851573e-02f, -1.80543121e-02f, -8.78368318e-02f, 3.63963731e-02f, 1.75223798e-02f, 5.08450493e-02f, -7.84324780e-02f, -1.03196934e-01f, -5.59744574e-02f, -1.39125511e-01f,
  -2.38181785e-01f, 9.26155075e-02f, 2.31900681e-02f, -1.32309571e-01f, -7.68241659e-03f, 8.63144621e-02f, 1.75716802e-02f, 2.77928449e-02f, -4.10692804e-02f, 6.88138530e-02f,
  1.70418844e-01f, 1.94219589e-01f, 1.55666277e-01f, 2.44484127e-01f, 2.93752197e-02f, -2.67518517e-02f, -2.01736372e-02f, -5.36929928e-02f, 1.70157909e-01f, 1.90358087e-01f,
  -2.53799725e-02f, -1.10185750e-01f, -1.95984408e-01f, -1.07965581e-01f, -3.74393240e-02f, 1.27178878e-01f, -1.01399899e-01f, 4.27793264e-02f, -3.16447788e-03f, -8.23949650e-02f,
  4.22331542e-01f, -6.76016808e-02f, 8.37466493e-02f, -1.90755874e-02f, -8.61442089e-02f, -1.82201080e-02f, 2.03894097e-02f, -7.89404362e-02f, -9.49214101e-02f, -8.69269520e-02f,
  -4.05251980e-02f, -2.71515194e-02f, -3.27410288e-02f, 3.32440902e-03f, -3.41981538e-02f, -5.62082678e-02f, -2.71082427e-02f, -1.14604202e-03f, 9.35189202e-02f, 8.58761445e-02f,
  7.34334737e-02f, 6.53613806e-02f, 7.56027177e-02f, 6.85444772e-02f, 9.57124978e-02f, 2.22756322e-02f, 7.73396268e-02f, 2.79494133e-02f, 6.38192594e-02f, -6.87353909e-02f,
  5.90808988e-02f, -6.06297292e-02f, -2.27758544e-03f, 6.08181320e-02f, 8.52290690e-02f, 4.49933894e-02f, -8.56278837e-03f, 2.88219415e-02f, 3.61441001e-02f, -7.22040907e-02f,
  -3.24310735e-02f, 8.17625225e-02f, -3.48019600e-02f, 1.50820226e-04f, 5.99829219e-02f, 1.78855453e-02f, -2.82944851e-02f, 9.45072994e-02f, 5.63430078e-02f, -4.56822403e-02f,
  -4.37083542e-02f, -8.95738080e-02f, 7.90161919e-03f, -6.84044287e-02f, -6.06244542e-02f, 9.47895870e-02f, -8.61324817e-02f, -6.12677354e-03f, -3.47519480e-02f, -1.05583422e-01f,
  2.00549126e-01f, 3.23798181e-03f, -1.44139556e-02f, -4.73102480e-02f, -8.12315345e-02f, -2.62637734e-02f, -3.51719074e-02f, -6.16853638e-03f, -1.18473321e-01f, -1.69143651e-03f,
  5.73726632e-02f, 3.94261070e-02f, -1.75899658e-02f, -1.08808123e-01f, 4.65621846e-03f, -2.76006367e-02f, -6.69947863e-02f, -4.75065298e-02f, -7.05654025e-02f, -3.06423958e-02f,
  -2.01534177e-03f, 1.79281589e-02f, 7.08315521e-02f, 1.75411150e-01f, 4.49668691e-02f, 1.36802390e-01f, 1.95871428e-01f, 5.39751425e-02f, 7.73130963e-03f, 1.07992388e-01f,
  -2.39765257e-01f, -1.00163318e-01f, -2.50846803e-01f, -2.16074169e-01f, 2.68318262e-02f, -5.29474504e-02f, -1.28503591e-02f, 3.41065340e-02f, 2.73206588e-02f, -3.22984695e-01f,
  -8.15421343e-03f, 4.74898592e-02f, -6.76545948e-02f, -3.58886085e-02f, 6.02282444e-03f, -3.36372942e-01f, -3.41304094e-01f, -2.21912622e-01f, 1.99010909e-01f, 2.63011128e-01f,
  -1.19661156e-03f, -1.06780082e-01f, -4.52518426e-02f, 1.89492390e-01f, -6.75771907e-02f, 1.15890630e-01f, -1.87402532e-01f, -5.48415333e-02f, 1.07115299e-01f, -2.65590519e-01f,
  -1.80182785e-01f, 1.35922551e-01f, 1.39677241e-01f, 8.16307310e-03f, -1.26555905e-01f, -1.35826036e-01f, -4.63089347e-02f, 8.69805459e-03f, -8.15100893e-02f, -9.68097225e-02f,
  -3.85361984e-02f, 8.15141499e-02f, 1.75918341e-02f, 3.77482884e-02f, 4.78345715e-03f, -1.98601875e-02f, -1.34194925e-01f, -5.42210005e-02f, -5.69232553e-03f, 5.53998575e-02f,
  7.19716921e-02f, 1.02303274e-01f, 7.48307332e-02f, 1.23513989e-01f, 5.80622964e-02f, -4.50029559e-02f, 8.40946063e-02f, 2.11655527e-01f, 2.18751281e-01f, 1.29555300e-01f,
  -4.32884246e-02f, 5.33870943e-02f, 1.62662920e-02f, 6.21884838e-02f, -4.62931767e-02f, 1.98133234e-02f, -8.14774409e-02f, -3.82359512e-02f, 1.27286986e-01f, -4.31303121e-02f,
  -6.25889897e-02f, -4.05197404e-02f, -8.54186341e-03f, -5.73715866e-02f, -5.68787986e-03f, 3.10756769e-02f, 2.99435069e-05f, -2.50415634e-02f, 2.61407979e-02f, -2.90772915e-02f,
  2.74910629e-02f, -8.67744035e-04f, -5.76366074e-02f, 9.52222496e-02f, -2.07703095e-02f, -6.34190589e-02f, 7.52611309e-02f, 3.39506418e-02f, 5.95333651e-02f, 3.87400687e-02f,
  -5.99708930e-02f, -5.99154904e-02f, -1.24186479e-01f, 1.23192877e-01f, 4.03153338e-02f, -3.22302468e-02f, -3.95310670e-03f, -3.56169343e-02f, -3.91483977e-02f, 2.71538575e-03f,
  1.32127240e-01f, 1.12795243e-02f, -6.98303729e-02f, -7.82965496e-02f, 2.18895245e-02f, 3.71738672e-02f, -1.60771292e-02f, 4.78718095e-02f, -7.05472240e-03f, 8.60312581e-02f,
  -1.35250226e-01f, 8.09049979e-02f, 5.86183593e-02f, -6.08606040e-02f, 2.36362126e-02f, -1.90999303e-02f, -3.42129096e-02f, 6.81931973e-02f, 7.72230476e-02f, -6.70410693e-02f,
  4.00996655e-02f, -4.73998766e-03f, 8.92709792e-02f, 1.03089176e-01f, -1.60786986e-01f, -1.26769081e-01f, -1.36168495e-01f, -9.35212076e-02f, 8.87235161e-03f, 2.81969775e-02f,
  -6.72360137e-02f, -3.54368612e-02f, 1.31627798e-01f, -2.24632230e-02f, 6.09326996e-02f, 8.96599814e-02f, 1.89818740e-01f, 1.19742356e-01f, 1.43889815e-01f, -4.07918543e-02f,
  7.81711265e-02f, -7.56157003e-03f, 8.80957991e-02f, 1.01988509e-01f, 1.24396361e-01f, 4.71224934e-02f, -3.46211679e-02f, 1.21394694e-01f, -8.38570297e-02f, 1.33607015e-01f,
  -2.84024924e-02f, 4.49215099e-02f, -4.39157942e-03f, -3.34609710e-02f, -5.71610928e-02f, 8.07578936e-02f, 1.51909729e-02f, -2.34159306e-02f, 7.97736458e-03f, 8.67546499e-02f,
  -1.17804922e-01f, 4.19678800e-02f, 4.52957451e-02f, 4.56513204e-02f, -2.20435811e-03f, 4.33825841e-03f, 3.40834968e-02f, 1.06427439e-01f, -3.73594910e-02f, -3.98725122e-02f,
  2.87189439e-04f, 1.29478592e-02f, -2.23875921e-02f, 1.19172689e-02f, 3.04986890e-02f, -8.08661133e-02f, -1.62984822e-02f, 7.10824430e-02f, -4.00933065e-02f, -5.84417991e-02f,
  5.78129180e-02f, 4.33980376e-02f, -4.16270941e-02f, 6.03181459e-02f, 8.48661289e-02f, 1.15835608e-03f, 8.65793303e-02f, -3.12885754e-02f, 7.50610977e-02f, -4.27183360e-02f,
  3.99954505e-02f, 2.87353899e-02f, 5.90534955e-02f, -2.18211170e-02f, 6.81087673e-02f, -6.49931654e-02f, -3.02256923e-03f, 5.44406809e-02f, -5.98553382e-02f, 6.63338974e-02f,
  5.86297400e-02f, 1.07078589e-02f, -7.36372964e-03f, 2.33762376e-02f, 4.81187878e-03f, 7.70017039e-03f, -6.64573610e-02f, 3.61234173e-02f, 4.82081734e-02f, 9.26697161e-03f,
  7.58733824e-02f, -6.20138384e-02f, 3.52220866e-03f, -1.01851730e-03f, -2.82219537e-02f, -3.36151123e-02f, 6.10577036e-03f, 1.37645528e-02f, -5.33192195e-02f, 2.08093002e-02f,
  -1.57350898e-02f, -3.81394364e-02f, -1.06477089e-01f, 6.80842474e-02f, -3.72559167e-02f, -1.13966577e-01f, -5.14570288e-02f, 8.38668793e-02f, 3.21187451e-02f, -1.06757060e-01f,
  -2.83487141e-03f, -1.10428974e-01f, -9.07830223e-02f, -1.05275817e-01f, -1.17517665e-01f, -3.65664996e-02f, -3.16790268e-02f, -1.45033941e-01f, -3.70602347e-02f, 4.82417364e-03f,
  1.61470212e-02f, -1.83017403e-01f, 9.81869549e-02f, 2.43450835e-01f, 2.08631828e-01f, 2.04537362e-01f, 1.94609225e-01f, 2.20667452e-01f, 2.20784605e-01f, 1.45901861e-02f,
  -2.36914437e-02f, 5.92551418e-02f, 1.15214266e-01f, 2.33922005e-01f, 1.22306220e-01f, 2.10292861e-01f, 2.26009563e-01f, 1.31133854e-01f, 1.53832838e-01f, 1.25163689e-01f,
  1.51010230e-01f, 3.08424607e-02f, -1.36812091e-01f, -2.85003912e-02f, 7.82546252e-02f, 6.99314475e-02f, -3.17583755e-02f, -1.69606790e-01f, -8.25437456e-02f, 1.05512828e-01f,
  -1.31793976e-01f, -1.50290430e-01f, 2.01994196e-01f, -1.67943351e-02f, -1.65289432e-01f, -9.36412737e-02f, 6.37580408e-03f, -2.01688826e-01f, -5.55772260e-02f, -1.17768712e-01f,
  -5.10707498e-02f, -1.04891978e-01f, 9.67758298e-02f, -1.10378325e-01f, -4.57911901e-02f, -5.32577448e-02f, -7.51704201e-02f, 8.61212760e-02f, -4.21685306e-03f, -2.57514417e-02f,
  9.36280489e-02f, 5.74770244e-03f, -6.56914413e-02f, -3.08137533e-04f, 1.11366041e-01f, -2.26846915e-02f, 7.78066134e-03f, -5.85355647e-02f, 2.49873358e-03f, -9.99743640e-02f,
  9.30581763e-02f, -4.09168787e-02f, 8.03366229e-02f, 1.11929044e-01f, 6.73773512e-02f, -6.52433699e-03f, 4.10356820e-02f, 2.75336206e-02f, 7.01240124e-03f, 1.23425713e-02f,
  8.51332098e-02f, 1.39792096e-02f, 1.25728846e-01f, 1.27757914e-04f, 8.20861012e-02f, -1.32934391e-01f, 5.57302944e-02f, -5.30225113e-02f, 5.64447232e-02f, -5.95711395e-02f,
  6.31823316e-02f, 1.70956776e-02f, 2.35913992e-02f, -3.00500970e-02f, -1.71629973e-02f, 1.47261798e-01f, 5.30769024e-03f, -3.28516997e-02f, -8.07434693e-02f, -7.46191815e-02f,
  -1.03554592e-01f, 1.19978398e-01f, 1.64568469e-01f, -1.58985052e-02f, -2.17960887e-02f, -4.19051982e-02f, -6.39215796e-05f, -6.40100315e-02f, -7.83803463e-02f, -5.29346429e-02f,
  -4.43295762e-02f, -1.99687090e-02f, -1.24340141e-02f, -5.12099601e-02f, -2.76438911e-02f, 1.86413061e-02f, -8.49533081e-02f, 1.59601033e-01f, 6.05900958e-02f, -3.39388512e-02f,
  1.04665823e-01f, 6.29166514e-02f, 1.38580725e-02f, 1.15881793e-01f, 8.15462545e-02f, 8.98616016e-02f, -7.05788285e-02f, -5.94322607e-02f, -8.36108904e-03f, 1.72374456e-03f,
  -2.45470613e-01f, 3.28195805e-04f, -1.75259069e-01f, 1.87887419e-02f, 1.91070467e-01f, 4.49093096e-02f, -2.75507458e-02f, -6.95422664e-02f, 6.49757832e-02f, -3.68400514e-02f,
  9.35335308e-02f, 2.92740529e-03f, 1.44159719e-02f, 4.28921618e-02f, -7.75645152e-02f, 9.67512056e-02f, 1.11024514e-01f, 5.82983196e-02f, -3.40840258e-02f, 5.56781627e-02f,
  9.08739418e-02f, 1.49354909e-03f, -4.99019772e-02f, 6.06737770e-02f, 1.36153951e-01f, 9.12498534e-02f, -4.45030741e-02f, -2.55012941e-02f, -2.98228431e-02f, 2.65165865e-01f,
  -1.73704222e-01f, -1.57029688e-01f, 7.63774803e-03f, 1.66440066e-02f, -1.79582164e-02f, -1.10359974e-01f, 2.11825985e-02f, -8.77961144e-03f, -5.34408204e-02f, -9.75875258e-02f,
  5.30361794e-02f, 7.37101138e-02f, -5.12395836e-02f, 3.03513948e-02f, 3.59069649e-03f, -1.00246854e-02f, -6.12415783e-02f, -1.75234318e-01f, -1.30436957e-01f, -1.38598561e-01f,
  6.44644052e-02f, -3.32954228e-02f, -1.13702655e-01f, -1.27225682e-01f, -1.26719289e-03f, -8.47179964e-02f, -1.12819793e-02f, -9.36045423e-02f, -1.27703145e-01f, -1.09229229e-01f,
  -3.23350867e-03f, 1.08055472e-01f, -3.71479951e-02f, 4.55067381e-02f, 2.39441842e-02f, -1.18101644e-03f, 6.01606146e-02f, 4.80406918e-03f, -2.61842012e-02f, 5.22567220e-02f,
  -1.64751541e-02f, -2.76096817e-02f, -3.44171152e-02f, 1.51135109e-03f, -5.19710742e-02f, -7.89923593e-02f, 4.38743196e-02f, 5.09683751e-02f, -3.91383376e-03f, 2.23907996e-02f,
  5.16070612e-02f, -5.50556332e-02f, 2.76176352e-02f, -1.05429493e-01f, -9.51378122e-02f, 2.09617950e-02f, -8.41668807e-03f, 1.10305101e-02f, -7.98609555e-02f, 5.90766966e-03f,
  -6.77899271e-02f, 3.49364206e-02f, -1.02908462e-01f, -2.23662518e-02f, -3.45342457e-02f, 3.94425802e-02f, -6.06451668e-02f, -5.67936040e-02f, 4.96937670e-02f, 2.26258561e-02f,
  -3.88225866e-03f, 2.83670928e-02f, 7.37460628e-02f, 1.08404430e-02f, -1.26314029e-01f, -1.22052722e-01f, 4.08243313e-02f, 1.13629922e-02f, -1.61088377e-01f, -1.54450545e-02f,
  1.81306433e-03f, -1.85648412e-01f, -1.73684016e-01f, -1.14080541e-01f, -1.00136697e-01f, -1.13667749e-01f, -8.39915201e-02f, -7.29456842e-02f, -1.91782638e-01f, -2.10262910e-01f,
  2.76269615e-01f, 1.81800738e-01f, -1.04505941e-01f, 4.42800447e-02f, -6.45488650e-02f, -1.43100753e-01f, -8.59775394e-02f, -8.26949254e-02f, -4.27165069e-02f, 5.69308624e-02f,
  4.98892888e-02f, -1.64436847e-01f, -1.11644052e-01f, -1.85346261e-01f, -1.76282629e-01f, -8.09101909e-02f, -1.95537120e-01f, -2.15607375e-01f, -4.06731188e-01f, -2.23585859e-01f,
  -1.18935697e-01f, -3.03054582e-02f, -8.53762850e-02f, -8.61048102e-02f, 3.54593173e-02f, -4.14414480e-02f, -4.62402105e-02f, 5.73724024e-02f, -1.37796342e-01f, -3.87749355e-03f,
  2.67240051e-02f, 1.20209299e-01f, -1.74340859e-01f, -4.62839231e-02f, -7.05412552e-02f, -2.35761106e-02f, 2.11563352e-02f, 4.84910831e-02f, -1.04603339e-02f, -6.70691729e-02f,
  -9.09858420e-02f, 5.29886736e-03f, 1.06782634e-02f, -8.15421641e-02f, -1.79026332e-02f, -5.22251427e-02f, -9.32267755e-02f, -8.72827321e-02f, -1.23033389e-01f, -1.11070707e-01f,
  -5.92050254e-02f, 2.89784651e-02f, 3.10607515e-02f, -9.29745659e-02f, 2.88794618e-02f, -1.66160792e-01f, 8.93105865e-02f, 9.59014222e-02f, -7.63337687e-02f, 1.64641112e-01f,
  -7.33199716e-02f, -1.74333714e-02f, 3.00737889e-03f, 1.09477572e-01f, 4.21775924e-03f, 8.86488589e-04f, -5.74169196e-02f, 2.62314025e-02f, 3.71421501e-02f, -4.63975482e-02f,
  -1.36916135e-02f, -8.73255804e-02f, 1.73145905e-02f, -1.34209963e-02f, -4.09278786e-03f, 2.57858373e-02f, -3.81813161e-02f, 6.74746111e-02f, -3.73058766e-02f, 4.22796793e-02f,
  -9.88718048e-02f, -4.74209785e-02f, 4.08972353e-02f, 2.18629502e-02f, -3.91397849e-02f, 9.45986733e-02f, -3.55004109e-02f, 5.25686948e-04f, -1.05994165e-01f, -7.34373033e-02f,
  1.82268128e-01f, -1.13866493e-01f, -8.34272709e-03f, 1.14948917e-02f, -7.48618171e-02f, 5.42388670e-02f, 4.62412983e-02f, 1.54485945e-02f, 5.03555872e-03f, -1.05989151e-01f,
  -6.81042904e-04f, 1.43288914e-02f, -4.00038585e-02f, -1.27946094e-01f, -3.96274738e-02f, -2.14891639e-02f, 4.30728495e-02f, -2.08177567e-02f, -1.43395871e-01f, 9.65997428e-02f,
  -2.40802690e-02f, -1.05474897e-01f, -7.52771273e-02f, -7.42864311e-02f, 2.31412239e-02f, -1.06587663e-01f, -1.01141721e-01f, -9.76573080e-02f, -1.67794779e-01f, -6.65171966e-02f,
  4.25426722e-01f, -2.58672595e-01f, -1.76756829e-01f, 2.54859209e-01f, -1.05326466e-01f, -2.85779923e-01f, -4.15627182e-01f, -4.30322103e-02f, 9.10361111e-02f, -1.46684974e-01f,
  -5.61234318e-02f, 1.92150027e-01f, 1.67520687e-01f, 3.90761793e-02f, -1.04456171e-01f, -3.29999685e-01f, -2.96214312e-01f, -1.10256739e-01f, -6.82585463e-02f, -2.55768806e-01f,
  -2.16604307e-01f, -1.08968005e-01f, -8.71751737e-03f, -3.54984067e-02f, -1.24163434e-01f, -4.09911796e-02f, -1.70289770e-01f, -1.77574217e-01f, -2.11345285e-01f, -1.43182263e-01f,
  -3.12974930e-01f, 1.92397878e-01f, 6.88111484e-02f, 5.26663922e-02f, -6.05477858e-03f, 1.31235331e-01f, -1.05879977e-02f, 1.42600223e-01f, 1.11094281e-01f, -1.19277984e-01f,
  2.67200228e-02f, 2.51629148e-02f, 8.67112726e-02f, 2.86150025e-03f, 5.57099693e-02f, -3.29618640e-02f, -2.74362024e-02f, -7.47900456e-02f, -1.98652819e-02f, -1.42907605e-01f,
  -1.09616749e-01f, -1.86234131e-01f, 3.66544500e-02f, -8.94730389e-02f, 9.26013365e-02f, 1.08299382e-01f, -4.03347239e-02f, 1.97788849e-02f, -3.60821150e-02f, -4.28106189e-02f,
  -4.68513109e-02f, 1.38343144e-02f, -8.38447884e-02f, 2.58304235e-02f, 1.13446470e-02f, 1.52249559e-05f, 3.41102923e-03f, -3.39864451e-03f, -8.54355749e-03f, -5.05265258e-02f,
  1.12466536e-01f, 2.04981435e-02f, -2.77856309e-02f, -1.03259552e-02f, -1.16229884e-01f, 1.93715431e-02f, 9.24126711e-03f, -2.11202670e-02f, -6.92042569e-03f, -1.00751612e-02f,
  -4.83060675e-03f, 6.81947246e-02f, -4.64008423e-03f, -3.13526988e-02f, -3.73892039e-02f, 4.34456915e-02f, -3.84631306e-02f, 3.97851458e-03f, 6.07155152e-02f, 2.39622910e-02f,
  2.09105074e-01f, 4.63915765e-02f, 6.79963455e-02f, 1.47455469e-01f, -1.95170709e-04f, 1.56177264e-02f, 1.31151741e-02f, 5.34709953e-02f, 1.09669566e-01f, -5.45525216e-02f,
  8.99444858e-04f, 2.08547935e-02f, -2.65416200e-03f, -2.61964295e-02f, -1.89648066e-02f, -1.14353277e-01f, -2.09636092e-02f, -1.44056687e-02f, -5.83396442e-02f, -5.11230305e-02f,
  -7.10712895e-02f, 3.91559973e-02f, 1.43015102e-01f, 7.72693306e-02f, 1.17859039e-02f, 1.55075788e-01f, 2.12035235e-03f, -3.66983451e-02f, 1.17061839e-01f, -1.68996863e-02f,
  1.32735983e-01f, 2.16648638e-01f, 1.45749092e-01f, 2.35900301e-02f, 1.16459697e-01f, 1.43398464e-01f, 3.30139428e-01f, 5.84262684e-02f, -6.89705163e-02f, 8.06520432e-02f,
  6.91956282e-02f, -6.34697527e-02f, -1.32247597e-01f, -7.73875182e-03f, -1.50237447e-02f, 1.72693819e-01f, 9.21428278e-02f, -4.73888628e-02f, -9.01583210e-02f, 9.64546651e-02f,
  -1.13329226e-02f, 8.63554627e-02f, 7.10154101e-02f, -7.59183317e-02f, 1.04305692e-01f, -4.73381057e-02f, -4.07227911e-02f, 4.41653691e-02f, 4.84802499e-02f, -9.84696373e-02f,
  9.75285545e-02f, 2.15087116e-01f, -1.85643658e-01f, -1.80330470e-01f, 6.26388146e-03f, 2.88704559e-02f, -2.96355747e-02f, 1.62663311e-02f, -1.64884608e-02f, -7.29070827e-02f,
  7.17482939e-02f, 5.67668024e-03f, 1.49880335e-01f, 3.46774608e-02f, 6.02198858e-03f, -2.63085198e-02f, -3.63077484e-02f, -5.79027273e-02f, -6.74471585e-03f, 8.25539902e-02f,
  -7.47380629e-02f, -1.52349686e-02f, 4.48051989e-02f, -6.84407679e-03f, 5.93952388e-02f, -7.40364194e-02f, 1.26502886e-01f, 4.14725766e-02f, -6.69321194e-02f, -7.29350373e-02f,
  2.59501534e-03f, -3.97493467e-02f, -1.48553038e-02f, -5.20696677e-02f, 1.44119132e-02f, 9.00037289e-02f, 1.06882222e-01f, 1.07265621e-01f, 1.85775887e-02f, 4.18976834e-03f,
  3.86481285e-02f, 5.18442802e-02f, 2.25066766e-02f, 5.10008482e-04f, -8.00770223e-02f, -1.15899472e-02f, 1.30615875e-01f, 1.23044319e-01f, -3.19120325e-02f, -2.32597701e-02f,
  1.22001737e-01f, 7.50789419e-02f, 3.86023670e-02f, 3.10573392e-02f, -5.80239072e-02f, -1.48275411e-02f, 9.49173272e-02f, -3.57449427e-02f, 3.34583521e-02f, 2.79615149e-02f,
  -5.69488201e-03f, 7.36553818e-02f, -1.22164838e-01f, -3.90731283e-02f, 4.94610853e-02f, -1.06784582e-01f, 5.17766029e-02f, -1.39051545e-02f, 3.03436443e-02f, 1.15607828e-02f,
  2.71195602e-02f, -4.02048603e-02f, -1.78951025e-02f, 8.85718688e-02f, 1.81323849e-02f, -5.07310070e-02f, 5.72913401e-02f, -9.78249535e-02f, -9.00786892e-02f, -7.30816275e-02f,
  -1.53753217e-02f, -8.19514245e-02f, -1.40202940e-02f, -3.58426869e-02f, -6.00102358e-02f, -1.09797642e-01f, 9.20197219e-02f, 6.60399674e-03f, 5.22016175e-02f, 3.96605693e-02f,
  1.63072616e-01f, -4.10793861e-03f, 5.04042134e-02f, 1.38687223e-01f, 1.49361655e-01f, 1.83505177e-01f, 8.45191330e-02f, 3.33383568e-02f, 1.10578932e-01f, -3.14559264e-04f,
  -6.30851388e-02f, -1.00284949e-01f, -1.76349312e-01f, -1.21647999e-01f, -1.27310697e-02f, -4.50894162e-02f, 1.95084177e-02f, -1.00024693e-01f, -9.06784683e-02f, 7.97096193e-02f,
  -3.25934514e-02f, 8.79659429e-02f, -3.64179574e-02f, -3.37665752e-02f, -1.67818163e-02f, -1.59576274e-02f, -3.81158590e-02f, 4.04051319e-03f, -7.84208477e-02f, -1.23517156e-01f,
  -1.58870637e-01f, 7.71002397e-02f, -8.92843083e-02f, -1.19969122e-01f, -1.62891056e-02f, -6.75912341e-03f, 1.50755020e-02f, 6.04544953e-02f, 3.95423248e-02f, 3.23741138e-02f,
  -1.14585824e-01f, -1.00911833e-01f, -6.94623291e-02f, 1.09559566e-01f, 1.05123244e-01f, 5.81517536e-03f, 9.90339667e-02f, -4.30940604e-03f, 7.20212050e-03f, -7.39154443e-02f,
  -6.47968203e-02f, 4.32060100e-02f, 1.60533264e-01f, -3.36563475e-02f, 3.52923200e-02f, -1.05752870e-01f, 3.89845446e-02f, 4.59372401e-02f, 9.22115520e-02f, 9.01844501e-02f,
  4.05139029e-02f, -7.40913898e-02f, 1.02736354e-02f, 9.56705436e-02f, 5.45383431e-02f, 1.86577775e-02f, 6.19131289e-02f, -3.01559828e-02f, -3.40821734e-03f, 8.24230462e-02f,
  7.07908571e-02f, -6.78089112e-02f, -5.94517849e-02f, 6.38682321e-02f, -6.40810505e-02f, -7.07084686e-02f, 8.62093344e-02f, -2.25142557e-02f, -7.63336271e-02f, -4.18856181e-03f,
  3.73108871e-02f, -1.78186561e-03f, 9.49511304e-02f, 1.67107247e-02f, -3.38754468e-02f, 5.95037378e-02f, 4.00127433e-02f, -2.22566184e-02f, -1.87719036e-02f, -7.22076744e-02f,
  -6.48219660e-02f, -5.90435453e-02f, -1.34238362e-01f, -1.77043781e-01f, 6.59414679e-02f, 6.27644593e-03f, -7.76744112e-02f, 6.58027595e-03f, -3.13650779e-02f, 3.38047557e-02f,
  4.75690663e-02f, -7.37242177e-02f, -7.43537850e-04f, 8.01152363e-02f, -1.05745718e-02f, -1.00705810e-02f, 3.27297300e-03f, -1.39140068e-02f, 4.94824499e-02f, -3.93488482e-02f,
  7.27543905e-02f, 1.30726084e-01f, 1.37535781e-01f, 2.95976195e-02f, 9.20007750e-02f, -4.38007116e-02f, 1.23962596e-01f, 5.73335923e-02f, 6.82698935e-02f, 1.06750332e-01f,
  4.97237593e-01f, -5.37039004e-02f, 1.94405138e-01f, -4.43270206e-02f, -1.15996316e-01f, -5.01195677e-02f, -1.53153256e-01f, -4.90967706e-02f, 6.42090812e-02f, -6.02980740e-02f,
  -8.66181478e-02f, -1.20540140e-02f, -2.12033764e-02f, 1.17917076e-01f, 1.23979039e-01f, 8.60307068e-02f, 7.91514292e-02f, 2.04964682e-01f, 2.35303402e-01f, 6.08348846e-02f,
  -7.01166093e-02f, 1.18508130e-01f, 1.49677724e-01f, 5.77650182e-02f, 6.81028962e-02f, -1.09607965e-01f, -4.55163084e-02f, -1.65908281e-02f, 1.28285086e-03f, 1.16490968e-01f,
  1.37224840e-03f, 1.48623914e-01f, 4.39470336e-02f, -6.21449314e-02f, -7.30195493e-02f, 9.56141055e-02f, 1.14436217e-01f, 1.11636549e-01f, 2.04275101e-02f, -4.51962315e-02f,
  -3.28679569e-02f, 2.28147320e-02f, 9.07003693e-03f, 5.27805313e-02f, 1.26639260e-02f, -1.12252170e-02f, 1.31465226e-01f, 1.09293401e-01f, 1.44333959e-01f, 4.25770581e-02f,
  -1.16888106e-01f, -6.37498572e-02f, -5.84222302e-02f, 3.09108179e-02f, 7.13665783e-02f, 2.02836860e-02f, -3.56878750e-02f, 6.77446947e-02f, 1.29198462e-01f, 1.10473566e-01f,
  4.15419601e-02f, 1.95262376e-02f, -6.79139718e-02f, -3.49508151e-02f, -1.93249471e-02f, -9.12938341e-02f, -6.28359020e-02f, 1.29561173e-02f, -5.97115643e-02f, 6.45371377e-02f,
  -2.00309977e-02f, 3.85036431e-02f, -3.13249603e-02f, 2.72628721e-02f, -6.32709041e-02f, 8.27949643e-02f, -2.30530687e-02f, -3.76688130e-03f, -1.25939036e-02f, -2.12798771e-02f,
  -2.28364114e-03f, 6.71472102e-02f, -7.38989338e-02f, 1.46961585e-02f, -8.52042902e-03f, 1.24807805e-02f, 3.72056849e-02f, -8.86071250e-02f, 1.16795930e-03f, -9.28393006e-02f,
  -1.77577451e-01f, 3.20728756e-02f, 8.66916254e-02f, 2.49701627e-02f, -8.10283571e-02f, 5.86325787e-02f, -8.03720653e-02f, -9.76232067e-02f, 6.71112863e-03f, 6.11959808e-02f,
  1.71619430e-02f, 8.02032724e-02f, 4.28588921e-03f, -4.54624854e-02f, -2.55760420e-02f, 5.31650558e-02f, -8.76128078e-02f, 4.94152904e-02f, 8.41210261e-02f, -2.97139566e-02f,
  -6.48297444e-02f, 2.27429848e-02f, 5.74043244e-02f, 6.85190223e-03f, 2.66117416e-02f, 2.95452420e-02f, -3.47561501e-02f, 4.39934712e-03f, -8.00175518e-02f, 5.37222400e-02f,
  2.75938306e-02f, 4.27633431e-03f, 1.27554923e-01f, 1.04496568e-01f, 2.58860295e-04f, 1.23706631e-01f, 1.09886140e-01f, 1.00758679e-01f, -4.66166325e-02f, -4.47031148e-02f,
  1.18750565e-01f, 4.21350412e-02f, 6.24820590e-02f, -5.36279567e-02f, 3.50406654e-02f, -7.84091502e-02f, -2.07052436e-02f, 1.49114802e-03f, -8.67704395e-03f, 1.58733949e-01f,
  9.63143632e-02f, -5.66126816e-02f, 9.88789424e-02f, 7.39097148e-02f, -5.99775501e-02f, 3.78750488e-02f, 8.29651207e-02f, 1.19302683e-02f, 1.36657730e-02f, -5.77838309e-02f,
  -2.26968154e-02f, 3.10421772e-02f, -7.17874244e-02f, -6.63715079e-02f, -5.15402667e-02f, 2.59895213e-02f, 7.01668710e-02f, -3.44635434e-02f, -7.66170695e-02f, -6.62550405e-02f,
  -8.85962099e-02f, 5.81718795e-02f, 6.79565743e-02f, -6.79982007e-02f, 9.51624960e-02f, -5.08583635e-02f, 1.01941200e-02f, -4.49305363e-02f, 3.58785456e-03f, 1.31955706e-02f,
  -3.45154442e-02f, 3.89151946e-02f, 1.86912064e-02f, 4.28042822e-02f, 9.52184126e-02f, -2.16694828e-02f, 7.72050023e-02f, -6.65844381e-02f, -1.24527831e-02f, -4.39218171e-02f,
  -1.87453777e-02f, -6.15712069e-02f, 9.60394815e-02f, -1.45096530e-03f, 1.11844866e-02f, -5.78545555e-02f, -1.51305017e-03f, -6.46099523e-02f, 5.87706417e-02f, -8.58633593e-03f,
  9.63933095e-02f, 8.78143087e-02f, -3.92845050e-02f, 4.18922976e-02f, 9.24984291e-02f, -7.01235682e-02f, -2.55605625e-03f, 4.05865051e-02f, -5.41781001e-02f, -8.55237804e-03f,
  4.95956168e-02f, -5.18182404e-02f, -3.01525346e-03f, 3.06921322e-02f, 7.91710317e-02f, 5.70350960e-02f, -4.36023325e-02f, 9.17293206e-02f, -1.96311045e-02f, 5.74916825e-02f,
  -5.84253967e-02f, -1.05358429e-01f, -3.82715948e-02f, 6.33899048e-02f, -9.87297148e-02f, -9.26517174e-02f, 1.01054842e-02f, -8.16917047e-02f, 1.24870306e-02f, -1.56901721e-02f,
  -9.19743776e-02f, 8.15106854e-02f, -4.63238023e-02f, -1.07754050e-02f, 3.55061106e-02f, 1.49015766e-02f, -9.73461121e-02f, -4.12628949e-02f, -5.09349518e-02f, 5.61916316e-03f,
  -9.72889364e-02f, -3.75385024e-02f, 2.86554452e-02f, 1.05674081e-01f, 3.88306961e-03f, 2.47421674e-03f, -5.08400127e-02f, 2.85683796e-02f, 1.11281179e-01f, -1.46454591e-02f,
  -3.50314319e-01f, -2.43628807e-02f, -8.34285766e-02f, -1.72908321e-01f, 5.94812706e-02f, 2.88794845e-01f, 1.78250864e-01f, 1.85264692e-01f, -2.14703437e-02f, -2.56648492e-02f,
  1.81572624e-02f, 5.71889952e-02f, -1.62217960e-01f, -4.35561948e-02f, 4.73659486e-02f, -1.33442238e-01f, -1.13075629e-01f, -2.24592630e-02f, 5.25773615e-02f, 1.65928945e-01f,
  1.25715777e-01f, -1.49252161e-01f, -1.11450538e-01f, -7.75497183e-02f, -1.59937367e-01f, -1.59808561e-01f, -3.10008794e-01f, -1.13712080e-01f, -5.20295575e-02f, -2.63385206e-01f,
  -9.56467837e-02f, 8.00752565e-02f, 5.29913558e-03f, -8.66698399e-02f, -1.44365402e-02f, 2.34298687e-02f, -4.87025408e-03f, -6.80332854e-02f, 2.49824952e-03f, 1.10506071e-02f,
  -2.97079515e-02f, 8.72447863e-02f, -9.33204666e-02f, -5.13556413e-04f, 3.29591297e-02f, 2.57965568e-02f, 3.39591354e-02f, -9.51412395e-02f, -6.45637289e-02f, -2.13867016e-02f,
  3.51630673e-02f, -2.02532150e-02f, -8.81955102e-02f, -6.52264804e-02f, 7.37082660e-02f, -7.89174438e-03f, 5.40716015e-03f, -1.52008727e-01f, -1.12260189e-02f, -2.08822832e-01f,
  -6.21311851e-02f, 4.01980616e-02f, -1.64551046e-02f, -3.08863120e-03f, 3.36737446e-02f, -1.17613906e-02f, 5.11384197e-02f, 6.87668547e-02f, -8.59886315e-03f, -3.75507772e-02f,
  5.44637702e-02f, 2.73528211e-02f, 4.30308655e-02f, -9.60890483e-03f, -6.13846704e-02f, -2.90138423e-02f, 1.00609615e-01f, -9.52745900e-02f, -3.34939025e-02f, 3.94862369e-02f,
  -4.65551130e-02f, 3.98317445e-03f, -8.44804011e-03f, 4.57383245e-02f, -8.31431746e-02f, -2.27746814e-02f, 2.24250928e-02f, 2.95287021e-03f, -4.11384255e-02f, 4.29202132e-02f,
  -1.05220683e-01f, 2.13914718e-02f, -6.27496392e-02f, 3.12177651e-02f, 2.08740197e-02f, -2.98231393e-02f, -8.72174948e-02f, 4.51796651e-02f, 5.85818850e-02f, 6.35488778e-02f,
  1.63023565e-02f, -8.28934684e-02f, -1.42282128e-01f, 5.36789522e-02f, 1.01588229e-02f, -2.26189569e-02f, -6.61146864e-02f, -1.04596451e-01f, 2.09798757e-02f, -1.82146847e-03f,
  -1.31695673e-01f, -4.14191037e-02f, -4.33871858e-02f, -1.08398132e-01f, -5.02031706e-02f, -3.74196395e-02f, -6.11979216e-02f, -1.61543667e-01f, -1.76839158e-01f, -3.50472569e-01f,
  3.17762010e-02f, 1.18303195e-01f, -3.85883264e-02f, 6.18544966e-02f, 2.87363417e-02f, -1.59305140e-01f, 2.90941540e-02f, 1.70665681e-02f, 1.94475781e-02f, 4.74113375e-02f,
  -5.66719063e-02f, 6.95429891e-02f, 6.56456277e-02f, 2.27298796e-01f, 1.61038086e-01f, 2.13954732e-01f, 1.33404627e-01f, 2.07255080e-01f, 2.36856304e-02f, 6.55673146e-02f,
  1.73719749e-01f, -4.91126068e-03f, 6.61332980e-02f, 1.49844140e-01f, 8.21175873e-02f, 9.08383727e-02f, -3.87830697e-02f, 1.12871982e-01f, 9.82552990e-02f, 2.50340432e-01f,
  4.29188414e-03f, -9.43269730e-02f, -3.08080167e-02f, -8.25498104e-02f, -7.42989331e-02f, 1.04347043e-01f, -6.61636144e-02f, -4.16952465e-03f, 7.29192719e-02f, -3.02622118e-03f,
  2.82462388e-02f, -3.67376618e-02f, 5.78290559e-02f, 7.44612813e-02f, -8.90285224e-02f, -2.08014324e-02f, 1.18160605e-01f, 7.44925216e-02f, -3.40090171e-02f, -2.42572241e-02f,
  1.99821331e-02f, -1.36600837e-01f, -1.72460247e-02f, -9.51129422e-02f, -5.19753508e-02f, 3.35263950e-03f, -3.23033221e-02f, 5.47604822e-02f, -5.44573292e-02f, 2.93736979e-02f,
  9.47649032e-02f, -4.21944521e-02f, 1.11471131e-01f, -2.93994118e-02f, 4.53640595e-02f, -5.81189245e-02f, -5.04161306e-02f, 5.01041189e-02f, 6.64964840e-02f, -3.55256125e-02f,
  3.64852995e-02f, 1.45863299e-03f, 1.56727284e-02f, -5.39810769e-02f, -2.73757353e-02f, 1.63193960e-02f, 4.18200828e-02f, 3.56381088e-02f, -3.20873111e-02f, 1.36611396e-02f,
  -3.88907567e-02f, -6.10553622e-02f, 2.36461498e-02f, 1.09424792e-01f, -2.33188178e-02f, 4.82861400e-02f, 7.95008391e-02f, 1.50272436e-02f, 4.68350761e-02f, -6.20082244e-02f,
  -1.25687063e-01f, -2.28021562e-01f, -8.47361311e-02f, 1.73976287e-01f, -4.41721268e-02f, -5.18107321e-03f, 3.05427443e-02f, -1.96886044e-02f, -7.04148225e-03f, -1.02996426e-02f,
  -8.79733562e-02f, -1.75842997e-02f, -1.23371938e-02f, -5.12094833e-02f, 3.02426936e-03f, 4.84557115e-02f, -4.59450446e-02f, 5.25047220e-02f, -1.82108060e-02f, 1.61155555e-02f,
  -3.91169377e-02f, -1.15776338e-01f, -1.49249911e-01f, -1.36399418e-01f, -7.90325999e-02f, -3.45038436e-02f, -6.96040988e-02f, -3.50236669e-02f, -1.71499088e-01f, -2.44165018e-01f,
  -2.09430516e-01f, 9.32437852e-02f, -1.06486797e-01f, -3.69718485e-02f, -1.99466795e-02f, -1.45187452e-02f, -1.22572109e-03f, 5.20398766e-02f, -1.82662830e-02f, 8.83237645e-02f,
  9.04793218e-02f, -6.37086555e-02f, -1.69807255e-01f, 1.08396197e-02f, -6.27064407e-02f, -2.50194203e-02f, -6.81602061e-02f, -1.22197956e-01f, -6.61281645e-02f, 6.51213229e-02f,
  -5.47209084e-02f, -6.19694181e-02f, -3.37907933e-02f, 3.69291827e-02f, -3.28752212e-03f, -1.68443881e-02f, 1.03218919e-02f, 2.18879376e-02f, 9.74843800e-02f, -7.79434890e-02f,
  3.52803245e-02f, -4.85556535e-02f, -6.67783394e-02f, -5.65098822e-02f, -4.00352553e-02f, 4.50639665e-04f, -7.09142834e-02f, -7.71589503e-02f, 6.44489825e-02f, 3.34022753e-02f,
  1.37851074e-01f, 3.07281353e-02f, 8.31238553e-03f, 6.68893829e-02f, 2.22048759e-02f, 5.95991574e-02f, 5.87186590e-03f, -7.97868595e-02f, 1.05506547e-01f, 9.59755704e-02f,
  6.92279413e-02f, 1.42107725e-01f, -2.13709474e-02f, 6.42224699e-02f, 7.18084499e-02f, -1.91543531e-02f, 5.04797511e-02f, 6.12783879e-02f, 1.02730557e-01f, 6.42058477e-02f,
  -5.86176999e-02f, -7.74132237e-02f, 6.59425706e-02f, -3.36759686e-02f, -9.76048484e-02f, -5.25808856e-02f, -1.08805805e-01f, -8.43520984e-02f, -3.08079012e-02f, 6.14154562e-02f,
  -4.69269939e-02f, 5.52219488e-02f, -1.01208836e-01f, 4.20537181e-02f, -8.83849114e-02f, 7.50177503e-02f, -1.63590326e-03f, -6.64272830e-02f, 8.00180957e-02f, 9.15888771e-02f,
  -3.40802111e-02f, -1.40167195e-02f, -8.64844471e-02f, 2.04913188e-02f, 3.11733317e-02f, 6.03392087e-02f, -4.38461825e-03f, 6.75745085e-02f, 1.40138818e-02f, 7.17348829e-02f,
  -1.37727018e-02f, 3.18581238e-03f, -8.24958235e-02f, 1.00034706e-01f, 3.21455859e-02f, 1.05489843e-01f, 1.06213819e-02f, -1.10904844e-02f, 1.31411418e-01f, 1.58406654e-03f,
  4.67683189e-02f, 4.90108272e-03f, 8.18954781e-04f, -3.87994908e-02f, -1.10743538e-01f, 4.99023981e-02f, 1.26846775e-01f, -8.82195681e-02f, 2.73521915e-02f, 1.23774342e-01f,
  5.34701906e-02f, 2.08856985e-02f, 1.15576759e-02f, 8.19797292e-02f, 8.02423730e-02f, -1.31229199e-02f, 5.53988889e-02f, -3.69878188e-02f, -3.60475518e-02f, 6.97567686e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -3.59175174e-04f, 1.22331440e-01f, 4.61313501e-02f, 7.73485228e-02f, 2.71982074e-01f, 7.90423378e-02f, 7.73703083e-02f, 2.21447468e-01f, 1.36308493e-02f, 1.55934840e-01f,
  2.48982772e-01f, 2.89676249e-01f, 1.73121974e-01f, 2.16556624e-01f, 2.40201708e-02f, 1.71426266e-01f, 3.05292923e-02f, 7.91727751e-02f, 5.15974872e-02f, 1.96341774e-03f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.67590603e-01f, 7.77522698e-02f, -2.72023678e-01f, 2.18388379e-01f, 9.39434916e-02f, 3.14386159e-01f, -2.54011661e-01f, 3.39869529e-01f, -3.95269468e-02f, -8.55937079e-02f,
  2.38983221e-02f, 2.85545498e-01f, 2.42963299e-01f, -1.39193386e-01f, 8.33889022e-02f, -9.65175778e-02f, 3.20519209e-01f, -1.63145363e-01f, 6.17564358e-02f, -1.92986205e-01f,
  1.28268793e-01f, 9.21978354e-02f, -5.30502126e-02f, 1.30165303e-02f, -1.60857514e-01f, 2.44587183e-01f, 1.15347477e-02f, 3.17243397e-01f, -2.01812126e-02f, -1.68612316e-01f,
  -1.22185200e-01f, -1.05924845e-01f, -1.35234132e-01f, -9.75193977e-02f, -2.16132745e-01f, -3.70042510e-02f, -1.37144476e-01f, 2.00953320e-01f, 3.08878049e-02f, -1.17488064e-01f,
  -1.87635213e-01f, -1.36539608e-01f, 1.29383311e-01f, 8.26287735e-03f, -1.35094598e-01f, -1.51836872e-01f, 1.10928327e-01f, -2.08075225e-01f, -2.05997974e-02f, -1.10795274e-01f,
  -7.94915482e-02f, -1.34431586e-01f, 1.44185349e-01f, -2.00996429e-01f, -1.03652537e-01f, 2.02968553e-01f, 1.07662879e-01f, 1.26048326e-01f, 1.35328814e-01f, -4.20113979e-03f,
  1.69289913e-02f, -3.21780264e-01f, 8.09387118e-02f, 1.11309350e-01f, -1.15914859e-01f, -1.39512479e-01f, 1.05074473e-01f, -2.73837447e-01f, -2.59930873e-03f, -2.35242024e-01f,
  2.51968205e-01f, -2.01716155e-01f, 3.40201885e-01f, 1.06759802e-01f, -2.10257582e-02f, -6.66835811e-03f, -7.96121284e-02f, -5.34220077e-02f, -2.90536918e-02f, 4.16818336e-02f,
  -3.39943558e-01f, 1.86961412e-01f, 5.05753160e-02f, 2.94907242e-01f, -2.44191527e-01f, -1.37357175e-01f, 2.01398864e-01f, 8.80076066e-02f, -1.54218495e-01f, -2.42520683e-02f,
  -1.53685749e-01f, -3.65208715e-01f, 1.22576058e-01f, 3.85974020e-01f, -5.03470786e-02f, 2.17477351e-01f, 9.68453437e-02f, -6.27949387e-02f, 1.84964761e-02f, 1.84460059e-01f,
  -3.56722921e-02f, -2.36223593e-01f, 4.50518608e-01f, -8.08729306e-02f, 5.45286596e-01f, -1.10710569e-01f, -9.60501134e-02f, -2.41829418e-02f, -1.19909286e-01f, -2.31445953e-01f,
  2.51054466e-01f, 8.72700475e-03f, 5.76622747e-02f, 5.97381294e-02f, 3.98457408e-01f, 2.44134590e-01f, -8.34506154e-02f, -1.61585044e-02f, 1.09290041e-01f, -3.01910192e-01f,
  -3.98169309e-01f, 6.88044354e-02f, -2.20075339e-01f, -2.17671350e-01f, -3.99034768e-02f, 1.80445209e-01f, 1.46704018e-01f, 6.93313926e-02f, 1.78304389e-01f, 4.01191592e-01f,
  -1.17816262e-01f, 3.51117820e-01f, -8.05586278e-02f, 1.65376276e-01f, 1.16848066e-01f, 4.43518102e-01f, 1.84661523e-01f, 7.58183226e-02f, -2.99941320e-02f, 1.76892057e-01f,
  7.78161734e-02f, -3.19591343e-01f, 1.49684295e-01f, -2.33610496e-01f, 2.25986272e-01f, 4.23518429e-03f, -2.20641978e-02f, -2.14217111e-01f, -8.68725851e-02f, 1.05011009e-01f,
  5.62014543e-02f, -7.65005052e-02f, -8.70613530e-02f, 4.80667539e-02f, -2.83876985e-01f, 2.37515807e-01f, 1.50300479e-02f, -1.00548148e-01f, 1.89547285e-01f, -1.69530466e-01f,
  4.07508835e-02f, 4.26207721e-01f, 3.20561305e-02f, 5.45489304e-02f, -4.11483385e-02f, -1.75302729e-01f, 3.47412199e-01f, 3.81605923e-01f, 1.80599287e-01f, 2.73967944e-02f,
  2.35335052e-01f, -7.11220130e-02f, -4.13094044e-01f, -3.74874413e-01f, -1.66175410e-01f, 2.41304543e-02f, -1.26483496e-02f, -1.55721709e-01f, -2.92448491e-01f, -2.36600250e-01f,
  3.61219287e-01f, 1.00018121e-01f, 1.55164063e-01f, -1.30679831e-01f, -1.40478626e-01f, -2.30164483e-01f, -3.10025811e-01f, 2.53688872e-01f, -1.61865577e-01f, -1.02608897e-01f,
  3.09306026e-01f, -1.37081325e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -6.33035004e-02f, 3.39047521e-01f, -5.34475036e-02f, 3.43963772e-01f, -1.60922483e-03f, 3.11011285e-01f, -1.78571586e-02f, 1.08476207e-01f, -5.12845576e-01f, -1.26238480e-01f,
  2.16433525e-01f, -1.53587341e-01f, 1.76577702e-01f, -1.23067610e-01f, -1.04722694e-01f, -2.36270115e-01f, 4.31570113e-01f, 2.86227334e-02f, -2.71221787e-01f, -2.22007241e-02f,
  4.79341149e-02f, 3.07146013e-01f, -9.96060967e-02f, -1.27699047e-01f, -1.28576219e-01f, -1.65159386e-02f, 9.03442055e-02f, 2.31184438e-01f, 1.71421930e-01f, -2.58813173e-01f,
  1.45341665e-01f, -2.19279364e-01f, 1.14266500e-01f, -7.71514848e-02f, 1.90822110e-02f, 4.63839173e-02f, -3.70540917e-02f, -9.54044610e-02f, 9.62811038e-02f, -5.46527728e-02f,
  2.62046576e-01f, 2.73025818e-02f, 1.01720998e-02f, -2.13981524e-01f, 2.01989874e-01f, -1.69593826e-01f, 1.18640348e-01f, -7.31470883e-02f, 2.98009127e-01f, -3.75767089e-02f,
  6.52647461e-04f, 4.79298644e-02f, 1.05929784e-01f, 1.31787255e-01f, -8.83908421e-02f, -4.46176855e-03f, -1.69611424e-01f, -1.08219244e-01f, 8.34575966e-02f, -2.17060581e-01f,
  1.17028013e-01f, -3.06898430e-02f, -1.40906677e-01f, 9.55493897e-02f, 1.26947105e-01f, -5.73429875e-02f, 8.79788399e-02f, 8.84129032e-02f, -7.99879655e-02f, -1.33584337e-02f,
  4.10778783e-02f, -7.28197396e-02f, 1.35548133e-02f, 3.35095525e-02f, -1.16417162e-01f, -1.60208732e-01f, 2.04859041e-02f, 1.21357545e-01f, -5.31895719e-02f, 2.19856985e-02f,
  1.66687295e-01f, -6.55492023e-02f, -7.00808037e-03f, 1.70342356e-01f, 3.06633301e-02f, -1.73034772e-01f, -5.87500855e-02f, -6.68521971e-03f, -1.52838096e-01f, 1.18480630e-01f,
  4.60171960e-02f, 1.55792665e-02f, 1.22214340e-01f, 1.37291461e-01f, -6.08663410e-02f, -5.47257364e-02f, 6.39490932e-02f, 3.02631259e-01f, 3.14999640e-01f, 2.64926136e-01f,
  2.61755753e-02f, -1.59205198e-01f, 3.95092398e-01f, 2.99377143e-01f, 2.12607309e-01f, 6.09613471e-02f, -5.64517453e-03f, 8.13826770e-02f, -8.20406526e-02f, -1.37944102e-01f,
  -6.38945773e-02f, -5.63776828e-02f, -2.29341641e-01f, 3.69960023e-03f, 1.79669745e-02f, 1.09457262e-01f, 1.84490591e-01f, 5.12089320e-02f, 2.10422918e-01f, 1.24388658e-01f,
  -5.81253618e-02f, -1.11797661e-01f, 4.34614532e-02f, 5.21268509e-02f, -7.69828483e-02f, 2.18989909e-01f, 1.67580396e-01f, 1.26186654e-01f, -5.38003482e-02f, -1.54294506e-01f,
  -9.32023153e-02f, 1.39514625e-01f, -9.98126492e-02f, 1.41339526e-01f, -1.80413336e-01f, -1.08198106e-01f, -2.92166173e-01f, -7.71487737e-03f, 2.46255379e-03f, 8.84696618e-02f,
  4.37602736e-02f, 1.66936964e-01f, -1.47415757e-01f, -1.82017714e-01f, 2.17344120e-01f, -6.26115501e-02f, -9.61902589e-02f, 4.04284149e-02f, 2.09884476e-02f, -3.32587659e-02f,
  -8.60900655e-02f, -2.33608447e-02f, -1.46564111e-01f, -1.26219735e-01f, -2.97207460e-02f, 9.70591828e-02f, 1.45482108e-01f, 1.21980108e-01f, 5.62006906e-02f, -1.05537973e-01f,
  -4.22887644e-03f, -1.36771351e-01f, -1.14872925e-01f, 8.30426887e-02f, 9.16151181e-02f, -7.86449574e-03f, 1.28028214e-01f, 9.12269875e-02f, -1.20865628e-01f, 1.38233647e-01f,
  -7.46701509e-02f, 1.90319583e-01f, -1.14718251e-01f, 2.13918492e-01f, -1.48746312e-01f, -8.88785794e-02f, -1.72666714e-01f, -1.00580066e-01f, -6.52429461e-02f, 5.63464388e-02f,
  5.60621321e-02f, -1.14911743e-01f, 1.29218578e-01f, 1.50197327e-01f, 1.19059347e-01f, 2.54541218e-01f, -5.83993532e-02f, -1.41820371e-01f, 3.65980789e-02f, 4.89774272e-02f,
  -3.92485857e-02f, 1.74126141e-02f, 1.67224519e-02f, -3.90632339e-02f, 7.80633017e-02f, 5.51791349e-03f, -8.68600532e-02f, -2.27666702e-02f, -1.31327589e-03f, 1.72386747e-02f,
  -2.05533996e-01f, -1.24125928e-01f, -2.12135073e-02f, 2.05131382e-01f, 6.83062747e-02f, -4.42908183e-02f, -1.02910688e-02f, -1.62931666e-01f, -9.39114466e-02f, -4.15245257e-02f,
  -6.72454908e-02f, 8.26609358e-02f, -5.73726967e-02f, -2.46651843e-01f, 1.78185061e-01f, 5.68211963e-03f, -1.77157186e-02f, 4.45731021e-02f, 9.97299328e-02f, 1.96900442e-01f,
  -1.67241946e-01f, -4.14773114e-02f, -2.27700006e-02f, 1.90856680e-01f, 1.43008027e-02f, 3.87104958e-01f, 5.02392113e-01f, 3.80730271e-01f, 1.55626088e-01f, 2.71134138e-01f,
  5.18631577e-01f, -1.02104001e-01f, 3.28451470e-02f, -1.13296755e-01f, 1.82139799e-01f, -1.02067210e-01f, -3.55085403e-01f, -9.57719013e-02f, -1.92012250e-01f, 3.25367957e-01f,
  -1.20517947e-01f, -4.67865653e-02f, -3.23978931e-01f, 3.17782253e-01f, 4.86630946e-02f, -5.79384714e-02f, 3.36439371e-01f, 4.83921647e-01f, 4.56570774e-01f, -1.09951280e-01f,
  1.05191767e-02f, -2.81693488e-01f, -1.20363891e-01f, 1.48557857e-01f, -6.87423497e-02f, 1.46869600e-01f, -7.86263719e-02f, -2.15490475e-01f, 5.10214210e-01f, 3.70234400e-01f,
  5.21833539e-01f, 1.82257459e-01f, -1.35059543e-02f, -5.52396655e-01f, 1.03127167e-01f, -3.13588828e-01f, -1.63729891e-01f, -4.35908347e-01f, -4.55558419e-01f, 1.37530863e-01f,
  9.77261364e-02f, 3.91152233e-01f, 1.24811932e-01f, 3.30477804e-01f, 2.59252876e-01f, 3.93261611e-01f, -8.84098336e-02f, 3.09900701e-01f, -9.86915752e-02f, -1.11914739e-01f,
  4.56790358e-01f, -1.20821238e-01f, -9.78521481e-02f, 1.74092695e-01f, 1.13727532e-01f, 1.67683229e-01f, 1.49136245e-01f, -1.49034604e-01f, -2.31117040e-01f, 8.58518258e-02f,
  -8.63064006e-02f, 7.50652552e-02f, 6.26441017e-02f, -5.45720235e-02f, 1.81594610e-01f, 1.38261065e-01f, 2.48553634e-01f, -8.27335864e-02f, -1.82278901e-01f, 2.34723408e-02f,
  -3.10563352e-02f, 2.64241874e-01f, 1.56643316e-01f, -1.04127653e-01f, -1.32803872e-01f, 4.32952315e-01f, 2.39636824e-01f, 1.21011175e-01f, 1.15875050e-01f, 5.48039556e-01f,
  2.08112672e-01f, -2.38790095e-01f, 3.04833706e-02f, -2.69359350e-02f, -9.36066881e-02f, -1.48484617e-01f, -6.04431564e-03f, -9.69596952e-02f, 1.52534217e-01f, 1.13694288e-01f,
  3.39033037e-01f, 3.39211710e-02f, 3.09088498e-01f, 3.60778987e-01f, 5.62133253e-01f, 5.38507342e-01f, -4.97327715e-01f, -4.33762193e-01f, 8.24436720e-04f, -2.14478701e-01f,
  1.24635428e-01f, -4.70555872e-01f, 1.51075730e-02f, -4.12784889e-02f, 1.63355738e-01f, 9.36657712e-02f, 4.89047110e-01f, 1.21078663e-01f, -1.43073842e-01f, -3.54278623e-03f,
  1.45954579e-01f, 2.80372500e-01f, 1.30419713e-02f, -6.68278113e-02f, 6.54354155e-01f, 1.27030864e-01f, 4.07734094e-03f, 1.88584000e-01f, 1.97035566e-01f, -2.29460567e-01f,
  -1.25345558e-01f, -2.89741188e-01f, 1.70543324e-02f, -1.04988128e-01f, -1.10564820e-01f, 7.04018772e-02f, 2.89894193e-01f, 3.70277524e-01f, -4.08746600e-01f, -4.34609056e-02f,
  -4.33244884e-01f, -6.01916537e-02f, -1.50382012e-01f, 2.11401224e-01f, 1.14369109e-01f, 1.91325009e-01f, 4.50951494e-02f, -1.58816040e-01f, 8.54194239e-02f, -1.37768865e-01f,
  -4.59452495e-02f, -5.33912554e-02f, -1.83967710e-01f, 1.09476700e-01f, -1.63765207e-01f, 2.04478011e-01f, -1.90157369e-02f, 3.50243330e-01f, 4.06252295e-01f, -2.01059263e-02f,
  1.02276891e-01f, 1.67340096e-02f, -7.99192786e-02f, -1.52447954e-01f, 2.43131056e-01f, 4.11701202e-01f, 1.73190251e-01f, 4.41290349e-01f, 2.84770519e-01f, 3.33822936e-01f,
  -1.99515134e-01f, -2.52082676e-01f, -2.09984690e-01f, -1.03359960e-03f, -1.04548354e-02f, -1.09424047e-01f, 3.10281217e-01f, -1.75069615e-01f, 5.37952920e-03f, 1.14659861e-01f,
  4.49107498e-01f, 3.83609869e-02f, 1.49784371e-01f, -2.40769744e-01f, 4.07214314e-02f, -1.71175718e-01f, 3.97071354e-02f, -2.31182441e-01f, 3.39067459e-01f, -1.97479710e-01f,
  -1.89569175e-01f, 3.80342640e-02f, -1.28364757e-01f, -2.67979652e-01f, 2.35911831e-02f, -1.35850459e-01f, 1.71350330e-01f, -2.59198487e-01f, 1.19230486e-01f, 2.32694268e-01f,
  2.20004603e-01f, -4.62455821e-04f, -1.86815917e-01f, -2.14735031e-01f, 3.63095284e-01f, 1.89245686e-01f, -2.94112414e-01f, -2.72025853e-01f, 1.72910932e-02f, 1.91827230e-02f,
  9.80837867e-02f, 6.67877570e-02f, 1.67734444e-01f, -1.26948670e-01f, 2.88729161e-01f, 3.30835640e-01f, -5.19038690e-03f, -2.77060002e-01f, -3.14422660e-02f, 3.85842994e-02f,
  -2.53599212e-02f, -9.59667340e-02f, 5.48594855e-02f, -2.44543999e-01f, 9.52671617e-02f, 9.79992151e-02f, -1.65277287e-01f, 8.07819515e-02f, 1.42177954e-01f, 1.62102476e-01f,
  7.42083266e-02f, -6.42491598e-03f, -4.51423936e-02f, 2.58709211e-02f, 1.83344305e-01f, -2.50534505e-01f, 2.83782240e-02f, -9.81097743e-02f, 2.36624312e-02f, -1.89776808e-01f,
  -9.38452333e-02f, -5.01572751e-02f, 1.54438391e-02f, 8.11963156e-02f, -1.35298431e-01f, 1.00794077e-01f, 5.06080873e-03f, 2.35630170e-01f, -1.50606319e-01f, 4.42620255e-02f,
  5.03865331e-02f, 2.05632336e-02f, 2.22816795e-01f, 1.83283295e-02f, 8.51036161e-02f, -1.24939747e-01f, -9.76512791e-04f, 1.63781360e-01f, -7.15521649e-02f, -8.99975151e-02f,
  -9.33277160e-02f, -1.40553430e-01f, -8.03667381e-02f, 7.84164593e-02f, -1.04114071e-01f, -8.06590542e-02f, 1.11288473e-01f, -1.13371633e-01f, 2.47972026e-01f, -4.98127490e-02f,
  -2.17562735e-01f, -1.71679690e-01f, -7.78849795e-02f, -3.10405698e-02f, -1.37912020e-01f, -1.25308841e-01f, 1.54980451e-01f, -9.76914167e-02f, 1.90362081e-01f, 2.01026559e-01f,
  7.69624040e-02f, 2.65165325e-02f, 3.05624548e-02f, -1.18448108e-01f, 1.73565827e-03f, 1.43463537e-01f, 5.33541292e-02f, -4.63937111e-02f, 9.84191075e-02f, 3.80007029e-02f,
  1.51944026e-01f, -2.62038000e-02f, 2.87070513e-01f, -2.31654093e-01f, -2.11278781e-01f, 3.64362538e-01f, 1.56137362e-01f, 2.40614280e-01f, -1.63918942e-01f, 4.10495073e-01f,
  -3.98010276e-02f, 1.04063973e-01f, 1.32611334e-01f, 1.49768218e-01f, -1.78625256e-01f, 8.98354575e-02f, 8.28455463e-02f, -1.87499076e-01f, 1.21290004e-02f, 1.85275331e-01f,
  -1.58492804e-01f, -4.34756204e-02f, 1.68722421e-01f, 3.11863590e-02f, 1.09731309e-01f, 2.33084038e-01f, -2.33290166e-01f, 3.26831371e-01f, -1.68112069e-01f, 5.91811948e-02f,
  1.52998298e-01f, -2.01734930e-01f, 3.87376249e-01f, 7.77687132e-02f, -1.05090111e-01f, -2.75102615e-01f, 7.51546100e-02f, -7.26422146e-02f, 1.40774339e-01f, 5.73766120e-02f,
  1.20903611e-01f, 2.27567405e-01f, -1.20611496e-01f, 2.06547856e-01f, -1.75891584e-03f, 7.73813203e-02f, 2.92656384e-02f, 9.62268859e-02f, -1.38702005e-01f, -1.68716624e-01f,
  -8.21559429e-02f, 4.41259844e-03f, 1.83599126e-02f, 3.87560576e-02f, 1.51083693e-01f, -2.03230917e-01f, -1.76207304e-01f, -3.02656647e-02f, -1.27300378e-02f, 1.84844837e-01f,
  9.50385779e-02f, -8.03780183e-02f, -3.10091749e-02f, 4.49887589e-02f, -7.57271573e-02f, -1.48028433e-01f, -9.18757096e-02f, -2.67222337e-02f, 2.10557416e-01f, 1.26284704e-01f,
  3.11392576e-01f, -1.47120580e-01f, 1.03698574e-01f, -3.04897167e-02f, 2.53260612e-01f, 1.45520017e-01f, -7.96499029e-02f, -1.34410724e-01f, -6.31940663e-02f, 2.36019239e-01f,
  -1.77221850e-01f, 8.30873623e-02f, -3.86461318e-02f, 2.96520501e-01f, -1.14898004e-01f, 4.51812238e-01f, -9.27887186e-02f, 3.88686895e-01f, 3.69233847e-01f, -2.16590345e-01f,
  2.95536250e-01f, 1.10204801e-01f, -2.23878566e-02f, -2.17488930e-01f, -5.26673235e-02f, 4.33131635e-01f, -9.05832648e-03f, 6.80151656e-02f, 3.30646992e-01f, -3.67217571e-01f,
  1.21909663e-01f, 4.69649076e-01f, 2.46146321e-01f, 2.71785766e-01f, -5.16421124e-02f, 4.42448199e-01f, -4.94700372e-01f, 1.27683096e-02f, 2.35989764e-01f, 5.43074846e-01f,
  -1.27670541e-01f, 3.48598152e-01f, -1.56918034e-01f, -1.70753419e-01f, -1.73776016e-01f, 1.39883101e-01f, -2.57530734e-02f, -1.79357037e-01f, 4.67747301e-02f, -1.34113595e-01f,
  2.78422803e-01f, 4.99226421e-01f, 2.05999479e-01f, 2.66834736e-01f, -1.88319087e-02f, 7.48257264e-02f, 9.16780997e-03f, -2.67833918e-01f, 3.57930422e-01f, 7.54057020e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.44425148e-01f, 7.13317692e-02f, -2.44534444e-02f, 3.06736678e-01f, 2.09061623e-01f, -3.82327810e-02f, 1.16357446e-01f, 3.32537860e-01f, 2.94094533e-01f, 1.79332361e-01f,
  3.09773505e-01f, 3.15244108e-01f, 3.79377097e-01f, -1.01266745e-02f, 1.23475716e-01f, -4.65522110e-02f, 1.11860760e-01f, 1.62802845e-01f, 1.37889236e-01f, 4.74019498e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -3.46049815e-01f, -1.59973070e-01f, -1.08099028e-01f, -1.30397364e-01f, -3.69616598e-01f, -3.70040864e-01f, -2.86689937e-01f, 3.77215222e-02f, 1.71522766e-01f, 2.89786100e-01f,
  -1.45594239e-01f, 2.47797966e-01f, 7.64743774e-04f, -4.44655828e-02f, -1.45957544e-01f, -2.89277304e-02f, 1.11105785e-01f, 1.94437653e-01f, -6.92676529e-02f, 7.32669905e-02f,
  2.57595450e-01f, 1.00627638e-01f, -3.90033334e-01f, -2.90541202e-01f, -2.98393995e-01f, 7.11471662e-02f, 6.69899806e-02f, 1.48513451e-01f, 5.73295690e-02f, 8.39587599e-02f,
  3.11179966e-01f, -1.08105347e-01f, 1.78567976e-01f, 6.25775158e-02f, 1.99890181e-01f, -4.29568589e-02f, -2.34411843e-02f, 1.15161411e-01f, -8.04144740e-02f, -1.67863920e-01f,
  2.60565840e-02f, 2.15487882e-01f, -2.93261081e-01f, -5.15244365e-01f, -3.88546824e-01f, -2.52583995e-02f, 1.21010877e-01f, 1.59739237e-02f, -4.60215360e-02f, 1.07754469e-01f,
  -2.16769859e-01f, 1.47597268e-01f, 2.52941668e-01f, -8.96890014e-02f, 1.63844600e-01f, 8.52602348e-02f, -1.11506596e-01f, 1.01156346e-01f, 1.27875149e-01f, 1.26647636e-01f,
  6.59944937e-02f, 1.84959397e-01f, 6.99693263e-02f, 1.01379864e-02f, 1.55996218e-01f, -5.34779392e-03f, -1.42642036e-01f, -3.07838060e-02f, 1.30574778e-01f, 5.29553331e-02f,
  -1.29288197e-01f, 5.75102679e-02f, -1.54066086e-01f, -5.83064258e-01f, -5.12201302e-02f, 7.72974491e-02f, 2.43641540e-01f, -9.46522579e-02f, -1.33678392e-01f, -1.76240295e-01f,
  1.23730540e-01f, -1.72220424e-01f, -9.99122933e-02f, 5.19995913e-02f, -1.00975789e-01f, 5.06353714e-02f, 4.39500511e-01f, -9.87560749e-02f, 2.46624514e-01f, -3.02794278e-01f,
  -4.77916636e-02f, -2.18349755e-01f, -2.67372638e-01f, -1.44524246e-01f, -1.33831933e-01f, -1.62999615e-01f, 4.07766588e-02f, 1.74337924e-02f, -8.09379742e-02f, -1.34207960e-02f,
  1.10452197e-01f, 3.24365534e-02f, 2.46560741e-02f, -7.85405040e-02f, 1.51925728e-01f, 1.82015106e-01f, -1.46685004e-01f, -2.25968242e-01f, -1.94334760e-01f, -2.53416132e-02f,
  8.08000788e-02f, -1.22050308e-01f, 6.15858994e-02f, -1.42144397e-01f, 8.44288245e-02f, 9.62770637e-03f, 4.42166507e-01f, 1.77531347e-01f, 2.34802514e-01f, -1.37925074e-01f,
  -1.61898464e-01f, 2.20576391e-01f, 9.73122194e-02f, 1.67418733e-01f, -3.11412573e-01f, -2.05190778e-01f, 1.02962114e-01f, -2.67984897e-01f, 1.87687412e-01f, 1.37756214e-01f,
  3.54301393e-01f, -1.09244898e-01f, 2.28017837e-01f, 2.03841045e-01f, -1.57384485e-01f, 2.09386617e-01f, 1.74688399e-02f, -2.65477657e-01f, -4.23815638e-01f, -3.77264172e-01f,
  -9.90883410e-02f, 9.06685069e-02f, -1.69205010e-01f, -2.09157661e-01f, -1.27754807e-01f, 7.47655937e-03f, 2.06494853e-02f, 2.41415575e-01f, 5.17170839e-02f, -1.42167673e-01f,
  3.16726148e-01f, 1.99378014e-01f, 3.01084459e-01f, -9.12988260e-02f, 2.96203252e-02f, 2.03115102e-02f, -2.99042195e-01f, -2.32941151e-01f, -3.52940150e-02f, -1.66364595e-01f,
  -9.44777131e-02f, 1.88774019e-01f, -7.77243674e-02f, 1.23915151e-01f, -1.99250728e-02f, -2.24525586e-01f, 3.04824620e-01f, 7.05595240e-02f, -1.27715722e-01f, 1.18580349e-01f,
  1.63622171e-01f, 3.38241488e-01f, 7.77447075e-02f, 8.72272328e-02f, -1.42865047e-01f, 1.97809070e-01f, -1.45724073e-01f, 1.40021726e-01f, 2.34907836e-01f, -1.51196301e-01f,
  -5.13881207e-01f, -3.02024662e-01f, -1.35601610e-01f, -9.49924067e-02f, 5.05296662e-02f, 1.16881855e-01f, -2.28078082e-01f, 1.24191515e-01f, 2.66022295e-01f, 2.36719903e-02f,
  -2.71442503e-01f, 3.43733996e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.17499046e-01f, 6.33707345e-02f, -2.02433541e-01f, 1.46077543e-01f, -2.96598911e-01f, -2.11527824e-01f, 9.18995366e-02f, -7.66140819e-02f, -9.98079497e-03f, -9.83109325e-02f,
  -2.14002490e-01f, -1.43556088e-01f, 6.88405558e-02f, 9.71715003e-02f, -1.43804356e-01f, 5.85234836e-02f, -1.00176416e-01f, 1.19131364e-01f, 1.65110156e-01f, 1.82715833e-01f,
  3.45395744e-01f, -6.85430039e-03f, 1.10650964e-01f, -1.07617952e-01f, -1.75417945e-01f, 1.37557074e-01f, -1.86037403e-02f, -7.45412409e-02f, 5.08267097e-02f, 1.21602513e-01f,
  1.59653172e-01f, -1.46485895e-01f, 2.65266627e-01f, 3.75778466e-01f, -6.53371513e-02f, 4.00258034e-01f, -2.15919584e-01f, 1.08017497e-01f, 2.78555155e-01f, -8.87538493e-02f,
  -5.30878901e-01f, -2.18568351e-02f, 5.14077544e-01f, 6.48444533e-01f, 3.15993428e-01f, -2.25452781e-01f, -2.32060894e-01f, 2.18553290e-01f, 1.32066175e-01f, -1.38556167e-01f,
  -2.80420352e-02f, -2.84083206e-02f, 7.15911835e-02f, 7.09114075e-02f, 1.45100519e-01f, -2.09817097e-01f, 2.27534801e-01f, -3.36221337e-01f, -1.30179763e-01f, -1.23119392e-01f,
  3.96902680e-01f, -2.27426253e-02f, -2.20286891e-01f, 5.50650001e-01f, 2.86776602e-01f, 2.39853784e-01f, 2.87750810e-01f, 2.36207753e-01f, -1.54277727e-01f, 2.00289786e-01f,
  -4.33906354e-02f, -7.98680261e-03f, -1.07651740e-01f, 8.68866965e-02f, -4.77597177e-01f, -1.20670900e-01f, -2.60117143e-01f, -2.49236450e-02f, 7.12452158e-02f, 2.34166682e-02f,
  -2.17194140e-01f, -1.77106664e-01f, 2.59811692e-02f, 2.95790166e-01f, 8.65717888e-01f, 1.63772598e-01f, 4.80349332e-01f, -1.63744926e-01f, 2.18038127e-01f, 1.96907714e-01f,
  1.84597448e-01f, 8.42204988e-02f, -1.66840907e-02f, -2.06910387e-01f, 4.12634276e-02f, 8.86360928e-02f, 2.20292598e-01f, 1.05314754e-01f, -2.50695258e-01f, 1.58533320e-01f,
  1.39557673e-02f, 2.60579407e-01f, -4.11837220e-01f, -9.12221819e-02f, 3.48088145e-01f, -2.64853746e-01f, -3.36706430e-01f, -4.49503809e-01f, -3.99988145e-03f, 1.54841682e-02f,
  6.98742643e-02f, 1.23998165e-01f, 2.54228581e-02f, 9.53657329e-02f, 1.28007978e-01f, 7.19505966e-01f, 4.00393069e-01f, -1.04114130e-01f, -1.35806659e-02f, -5.32044191e-03f,
  -2.38416299e-01f, 1.37084708e-01f, 3.84358674e-01f, -1.29159465e-01f, -8.52228701e-02f, 2.30909493e-02f, 4.06853169e-01f, -3.68086658e-02f, -6.98081255e-02f, 1.34603128e-01f,
  2.58460313e-01f, 3.72914486e-02f, -3.60500067e-02f, -1.27707601e-01f, 2.04376340e-01f, -1.85758770e-01f, -9.28646252e-02f, 2.27700964e-01f, 1.10481046e-01f, 2.94102401e-01f,
  6.43841699e-02f, -5.49747273e-02f, 1.12149762e-02f, 1.89098209e-01f, -1.22725673e-01f, -1.42117515e-01f, 1.39546007e-01f, 9.29405913e-02f, -1.54830450e-02f, -6.66265786e-02f,
  -1.28067434e-01f, -1.50729358e-01f, -1.14187345e-01f, -7.24977180e-02f, 1.87530685e-02f, -1.22889936e-01f, 3.17480534e-01f, -3.79981063e-02f, 1.00432940e-01f, 2.39258766e-01f,
  -1.53518721e-01f, -7.18503445e-02f, -6.66246936e-02f, -1.65718794e-01f, 1.47582904e-01f, -8.54077414e-02f, 1.81219094e-02f, -4.88639139e-02f, -9.80229955e-03f, -5.79722598e-02f,
  -2.35942454e-04f, -1.33706838e-01f, 3.17400582e-02f, -1.73400328e-01f, -1.38437465e-01f, 1.01011634e-01f, -2.56383885e-02f, 1.67382717e-01f, 1.19733050e-01f, -1.02540925e-01f,
  -3.26666757e-02f, 1.29693136e-01f, 9.81479958e-02f, -2.60866191e-02f, 2.70578451e-02f, -1.01272926e-01f, -3.62724205e-03f, -9.02041048e-02f, -1.44429088e-01f, -1.57749340e-01f,
  -2.37345286e-02f, 1.53826594e-01f, -2.38301694e-01f, 1.56902283e-01f, -2.10349277e-01f, -4.10947204e-02f, -1.16554558e-01f, -9.59282741e-02f, -8.74876231e-02f, -2.00631917e-01f,
  -6.09666854e-03f, -1.08776882e-01f, 2.22374827e-01f, 2.52858311e-01f, 3.45119923e-01f, 1.95714787e-01f, 5.16648367e-02f, 1.89505398e-01f, -8.51210132e-02f, -2.30700970e-01f,
  1.06842749e-01f, 1.04935840e-01f, -7.36756399e-02f, 2.24429563e-01f, 2.17825249e-01f, 1.36258438e-01f, 3.21344823e-01f, -2.02113032e-01f, -8.40787441e-02f, 1.04110412e-01f,
  1.76051363e-01f, -4.23445739e-02f, 1.17887117e-01f, -1.78681221e-03f, 1.69790149e-01f, 8.97975191e-02f, -5.38115911e-02f, 2.50633359e-01f, 1.45540595e-01f, 9.36977267e-02f,
  -1.54989079e-01f, -1.14222832e-01f, 1.02742031e-01f, 2.99283713e-01f, -8.97378325e-02f, 1.78633243e-01f, -8.95616859e-02f, -3.17279156e-03f, 2.64551919e-02f, 3.05256307e-01f,
  -2.06009448e-02f, 8.53462443e-02f, -6.92368150e-02f, 6.02158666e-01f, 2.91836113e-01f, 4.77618635e-01f, -4.71990630e-02f, -3.57973464e-02f, -2.07709894e-01f, -1.70585021e-01f,
  2.25308940e-01f, 1.55991495e-01f, -1.26903325e-01f, -1.54509023e-01f, 4.26018685e-01f, 8.80854055e-02f, 1.50449440e-01f, 1.34914234e-01f, 3.66053909e-01f, 4.24882509e-02f,
  -9.59936082e-02f, -1.11216649e-01f, 1.41914845e-01f, -1.26787007e-01f, -2.07801104e-01f, 2.16277242e-01f, 9.88727659e-02f, -2.20025599e-01f, -2.14296803e-01f, 1.62179217e-01f,
  -1.65212348e-01f, -7.96793436e-04f, -1.43658474e-01f, 1.00976445e-01f, -1.65900409e-01f, -1.28034696e-01f, 4.66873534e-02f, 4.35744196e-01f, 2.79579639e-01f, -1.29758522e-01f,
  1.75144970e-01f, -1.52260974e-01f, 1.56595167e-02f, 1.20857470e-01f, 2.13135868e-01f, -4.24363837e-02f, 3.51081163e-01f, 3.02220345e-01f, 6.23895302e-02f, -6.20838888e-02f,
  7.38639832e-02f, 1.05141319e-01f, 9.63519067e-02f, 1.96420681e-03f, -3.60669161e-04f, 8.13264251e-02f, -1.61263421e-02f, -1.41410694e-01f, 6.44901842e-02f, -1.98541895e-01f,
  -3.02165616e-02f, -1.13400429e-01f, 1.34586796e-01f, 1.20804318e-04f, -1.60833195e-01f, 1.87656358e-02f, 1.79640621e-01f, 6.47638440e-02f, 1.95650592e-01f, -5.35707548e-02f,
  -6.16554245e-02f, 2.15813220e-01f, -9.81866047e-02f, -5.94387129e-02f, -1.48425736e-02f, 3.50663289e-02f, 3.97483855e-02f, 1.72099859e-01f, -1.49734661e-01f, 3.18134785e-01f,
  -6.62787929e-02f, -5.42283542e-02f, 2.87678670e-02f, -1.07065544e-01f, 3.26896191e-01f, 1.63879186e-01f, -6.63139969e-02f, 6.08205236e-03f, -2.25631118e-01f, 2.21801922e-01f,
  8.77840668e-02f, -1.99879408e-01f, 2.96776950e-01f, 1.77946746e-01f, -6.33059144e-02f, -1.63611606e-01f, 3.95836383e-02f, 5.77623025e-02f, -7.25497305e-02f, -3.50804240e-01f,
  3.14681113e-01f, -1.52133659e-01f, 7.08317161e-01f, -9.16300416e-02f, 5.43289781e-01f, 1.77316695e-01f, 2.23850943e-02f, 1.28728554e-01f, 1.30096912e-01f, -9.24432129e-02f,
  -6.69206306e-02f, -2.92788774e-01f, 9.23975259e-02f, 7.97208324e-02f, 2.18294971e-02f, 3.63214165e-02f, -4.83302101e-02f, -1.17292225e-01f, 1.92655027e-01f, 2.25358605e-02f,
  8.54999721e-02f, -5.29329218e-02f, -1.26424348e-02f, 5.06780632e-02f, -1.01945423e-01f, -1.69637412e-01f, -1.08115055e-01f, -9.54357311e-02f, -1.33298025e-01f, 8.34975764e-02f,
  -1.00016795e-01f, -5.68332486e-02f, -6.67238235e-02f, 5.65908700e-02f, -1.03258744e-01f, -3.95415239e-02f, -1.29699945e-01f, 8.55775774e-02f, -9.38707665e-02f, 1.41194522e-01f,
  -7.73496926e-02f, 1.49074629e-01f, 3.26592028e-02f, 2.62299806e-01f, 9.99102816e-02f, 2.74239063e-01f, 2.43864775e-01f, 3.47657129e-02f, 3.39195311e-01f, 1.95419297e-01f,
  2.77027130e-01f, 2.33263206e-02f, -4.41915654e-02f, -2.41912156e-01f, 2.02228323e-01f, -1.88960031e-01f, -2.15136245e-01f, -6.67679757e-02f, 1.70472905e-01f, -1.28414437e-01f,
  1.92586347e-01f, 1.91913798e-01f, 2.11765602e-01f, -1.42306760e-01f, -3.14350307e-01f, -1.79922655e-01f, 1.46949038e-01f, 2.44649708e-01f, -2.32686847e-02f, 1.34684607e-01f,
  -1.35751575e-01f, -2.17427701e-01f, 2.56849140e-01f, 7.20063318e-03f, -2.86887474e-02f, 6.46904647e-01f, 4.95600760e-01f, 1.58065185e-01f, 4.30572391e-01f, 3.74804229e-01f,
  4.78223205e-01f, 3.20139863e-02f, -5.45784980e-02f, 2.56152183e-01f, -9.84734446e-02f, -5.87721169e-01f, -4.29202206e-02f, -2.04803422e-01f, 2.41136160e-02f, -2.98861206e-01f,
  -1.22667558e-01f, 1.27345622e-02f, 1.30274057e-01f, -1.24193475e-01f, 1.91808969e-01f, 5.15285909e-01f, 1.10969029e-01f, -1.56401291e-01f, 3.64652693e-01f, 9.96463075e-02f,
  1.20914213e-01f, -3.13614070e-01f, -3.38098332e-02f, -2.17820108e-01f, -1.60032362e-01f, 1.05792740e-02f, -3.41741085e-01f, 4.17816132e-01f, -5.22880331e-02f, -1.43911779e-01f,
  -3.80148202e-01f, 1.25648361e-02f, -5.75688370e-02f, -7.82882981e-03f, 1.73439384e-01f, -2.68805385e-01f, -2.91438639e-01f, -8.92874524e-02f, 2.38577351e-01f, -8.63521621e-02f,
  2.39010707e-01f, -1.57149136e-01f, -1.36499226e-01f, -3.60478833e-02f, -1.05602719e-01f, -2.17415154e-01f, -1.25018761e-01f, -2.47185990e-01f, 4.22905982e-01f, 3.23025495e-01f,
  2.62092501e-01f, 2.71386411e-02f, 4.27633431e-03f, 2.41565648e-02f, 1.34855747e-01f, 4.32480080e-03f, -3.25683653e-02f, -2.10674211e-01f, 4.35761303e-01f, 7.03649595e-02f,
  5.36292940e-02f, 2.40094751e-01f, 2.79090792e-01f, 1.60633042e-01f, 5.59733286e-02f, -1.07863091e-01f, 9.51421214e-04f, -2.34525092e-02f, -2.72591740e-01f, 2.26880640e-01f,
  1.60822004e-01f, -3.24494578e-02f, 2.57472098e-01f, 1.67529941e-01f, 1.44023404e-01f, -1.69976711e-01f, 1.32537514e-01f, -1.49560913e-01f, -2.32784008e-03f, -7.51838014e-02f,
  4.62075621e-01f, -1.99388430e-01f, 6.83911622e-01f, 3.61296311e-02f, 5.47010303e-01f, 2.87727833e-01f, 3.01316865e-02f, 1.45784631e-01f, -8.38792995e-02f, 7.20859766e-02f,
  2.27651335e-02f, -2.60545254e-01f, 8.99735019e-02f, 1.50143653e-01f, 1.90651819e-01f, 4.65678647e-02f, 2.44158953e-02f, 2.36558929e-01f, 3.15516489e-03f, -5.40250540e-02f,
  -7.26585984e-02f, -5.53969219e-02f, 9.83898118e-02f, -4.43682283e-01f, -2.05498338e-01f, -1.60408780e-01f, 9.95939076e-02f, -8.69874656e-02f, 1.08338259e-01f, 2.27877066e-01f,
  -1.66336551e-01f, 2.06705090e-02f, -2.04214212e-02f, 2.67023265e-01f, -5.13265394e-02f, 1.53798342e-01f, 3.21997851e-02f, -4.41268198e-02f, 6.00437261e-02f, -4.09833193e-02f,
  2.99335748e-01f, 1.59629490e-02f, 1.76555485e-01f, 4.14878815e-01f, 4.42472368e-01f, 3.44723016e-01f, 3.69561166e-01f, 2.73658693e-01f, 8.83813500e-02f, 1.87443927e-01f,
  9.01008174e-02f, -2.13315636e-01f, 3.03832293e-02f, 2.52754152e-01f, 4.53521669e-01f, 7.06194103e-01f, -6.68236911e-02f, -8.14504251e-02f, -1.21845387e-01f, 4.76626307e-01f,
  -2.59994715e-01f, 1.35169908e-01f, 9.34027433e-02f, 4.99944538e-01f, -2.75257498e-01f, -2.67928466e-02f, -1.51217431e-01f, -3.12319160e-01f, 2.17801228e-01f, -2.72209793e-01f,
  1.23850077e-01f, -1.83718175e-01f, 6.66844472e-02f, -4.47677746e-02f, 1.80904016e-01f, 2.41289899e-01f, -9.07296035e-03f, 1.18648171e-01f, -6.41775653e-02f, -1.68271869e-01f,
  -1.94378048e-02f, 6.63680062e-02f, 1.44272208e-01f, -2.35828152e-03f, -1.85381636e-01f, 1.24384873e-01f, 1.59327090e-01f, -1.60318315e-01f, -9.27679613e-02f, -3.35357413e-02f,
  1.26428127e-01f, -8.32525790e-02f, -8.90112966e-02f, -9.61018652e-02f, 9.16025937e-02f, 8.46029893e-02f, -1.53558820e-01f, 8.41718633e-03f, -1.31713033e-01f, -9.52966809e-02f,
  -1.15182206e-01f, -2.62753051e-02f, -1.62569452e-02f, 1.55723065e-01f, -4.49323095e-02f, 1.75005287e-01f, -1.67995114e-02f, -7.99117982e-02f, -4.07911614e-02f, 2.64969051e-01f,
  -3.10048282e-01f, 1.61746845e-01f, 2.97747463e-01f, 1.42870784e-01f, 2.52332717e-01f, 2.42208809e-01f, -5.40831149e-01f, -8.02375615e-01f, -1.03601232e-01f, -5.97138882e-01f,
  4.90674019e-01f, -1.91346288e-01f, -3.56039554e-02f, -3.87074351e-01f, 3.47276866e-01f, 1.63101122e-01f, 1.36110652e-02f, -3.66617084e-01f, -1.75757661e-01f, -2.38606051e-01f,
  4.37408090e-01f, 6.98455632e-01f, 2.37566173e-01f, -2.07261458e-01f, -1.90747231e-01f, 6.27417117e-02f, 2.88565814e-01f, 1.58552274e-01f, 1.34041123e-02f, 6.51380718e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  4.95033823e-02f, 5.18825166e-02f, -5.92314079e-02f, 1.08132154e-01f, 2.37432137e-01f, -1.43224031e-01f, 4.69298512e-02f, 2.73516685e-01f, -8.67432565e-04f, -7.70650133e-02f,
  2.19527200e-01f, -1.22074820e-01f, 1.79216005e-02f, -6.40514633e-03f, 5.35097420e-02f, 2.28834990e-03f, -5.34874294e-03f, 3.24198157e-01f, 2.10935399e-02f, 2.57378101e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.88183063e-01f, -1.51336536e-01f, -1.59001410e-01f, -4.25916344e-01f, -8.62596259e-02f, 1.49094045e-01f, 6.28275394e-01f, -3.09043437e-01f, -1.45937711e-01f, -2.26983994e-01f,
  2.62046844e-01f, 2.26228267e-01f, 5.34638047e-01f, -2.47875080e-01f, 5.14589012e-01f, 6.55617416e-01f, -3.01450100e-02f, 4.49423008e-02f, -4.40991893e-02f, 1.57054484e-01f,
  -2.38897473e-01f, -5.11002988e-02f, -1.79481000e-01f, -1.30709931e-01f, -1.55067854e-02f, -4.04596746e-01f, 3.69087346e-02f, 3.44390906e-02f, -1.32269591e-01f, -3.96390945e-01f,
  -1.88368946e-01f, -3.80960792e-01f, -1.67980924e-01f, 1.23468406e-01f, -2.91761935e-01f, -2.83687592e-01f, 1.28179133e-01f, -5.34873664e-01f, -2.56070774e-02f, -1.07348017e-01f,
  1.26505628e-01f, 1.82380050e-01f, -6.12996757e-01f, 1.70081735e-01f, 8.11978802e-02f, 1.88359350e-01f, 3.73595417e-01f, 1.59039330e-02f, -2.78431624e-01f, -8.68947804e-02f,
  -6.54079095e-02f, -1.31511986e-01f, 1.26969323e-01f, -4.66539562e-02f, 3.64115596e-01f, 1.82300776e-01f, -3.60560864e-01f, 1.42834574e-01f, 6.29805624e-01f, 1.19705454e-01f,
  9.07000229e-02f, -5.44602394e-01f, 9.16950498e-03f, 1.30446613e-01f, 1.13231733e-01f, 4.53067720e-01f, 1.08037829e-01f, 6.24229550e-01f, 4.84644592e-01f, 5.42426765e-01f,
  -3.08058977e-01f, 1.81911826e-01f, 2.40082711e-01f, -4.79352660e-02f, 4.48106170e-01f, -3.37489508e-02f, -1.32727712e-01f, 3.28971326e-01f, 1.76931649e-01f, -3.18854719e-01f,
  1.07027099e-01f, 4.89507951e-02f, 1.44063637e-01f, 2.23661870e-01f, -2.26537332e-01f, -1.82264760e-01f, 1.07605360e-01f, -1.84072524e-01f, -4.04839903e-01f, 2.67087638e-01f,
  -2.26049840e-01f, 4.97831672e-01f, -4.46190655e-01f, 5.60406089e-01f, 4.09396887e-02f, -6.46829665e-01f, 5.45004308e-01f, -2.28668621e-04f, -8.07590559e-02f, -1.66037798e-01f,
  5.74381411e-01f, -2.24379733e-01f, 4.88593727e-01f, 4.67418671e-01f, -7.19479263e-01f, 5.82115710e-01f, 3.61199379e-01f, -7.13747263e-01f, -8.74217972e-02f, -4.97720778e-01f,
  -9.52948406e-02f, 6.69943333e-01f, -2.64501665e-02f, -1.71522647e-01f, -1.34125277e-01f, 5.47976494e-01f, -2.64149785e-01f, -1.36507422e-01f, -1.95314497e-01f, 4.71726656e-02f,
  -3.59867305e-01f, -5.09498835e-01f, -1.01854026e-01f, -4.86550063e-01f, -1.51817843e-01f, 3.32856029e-01f, -4.70149107e-02f, -4.40681070e-01f, 4.95242298e-01f, -8.81549418e-02f,
  2.32730538e-01f, -4.16960754e-02f, -6.94888294e-01f, -3.77042383e-01f, -4.19974953e-01f, 3.56153369e-01f, 1.43037632e-01f, 4.27449167e-01f, 4.99087036e-01f, -1.90924928e-01f,
  -2.82298904e-02f, -3.79367709e-01f, 2.99725771e-01f, 3.60436141e-01f, -1.99895903e-01f, -6.94378018e-02f, -1.56334445e-01f, 2.54732937e-01f, -2.04113528e-01f, 9.28280056e-02f,
  -3.43811572e-01f, 1.74073249e-01f, -2.40524814e-01f, 5.77723742e-01f, -2.91573584e-01f, -2.90949047e-01f, 1.48811936e-01f, 3.80494714e-01f, -6.54447526e-02f, -3.60072404e-01f,
  -2.61568367e-01f, 1.91072866e-01f, -9.31603014e-02f, 3.75105262e-01f, -6.11238241e-01f, 7.04732016e-02f, -2.62435347e-01f, 2.37804189e-01f, 5.89345753e-01f, 4.28753078e-01f,
  -1.40751243e-01f, -6.72628880e-01f, -1.96107954e-01f, -2.83774853e-01f, 1.36330485e-01f, 2.58131742e-01f, -2.69629896e-01f, 1.03942402e-01f, -3.52454364e-01f, -1.47001058e-01f,
  9.16783363e-02f, 1.06110804e-01f, 7.48996511e-02f, -1.55196622e-01f, 1.32203013e-01f, 7.89568424e-01f, -2.73037016e-01f, -5.40204495e-02f, 9.12960172e-02f, -3.17956448e-01f,
  7.45206699e-02f, 5.48157036e-01f, 1.61110833e-01f, -2.12555021e-01f, -7.20290327e-03f, -1.86013222e-01f, 1.25539958e-01f, -6.46989048e-01f, -2.46211514e-01f, -5.10920346e-01f,
  8.03432092e-02f, -2.87648410e-01f, -6.71907663e-01f, 2.12325409e-01f, 1.26659544e-02f, 9.12068725e-01f, -5.34845471e-01f, -3.34329933e-01f, 2.12752879e-01f, -7.17743486e-02f,
  2.22073451e-01f, -4.40681666e-01f, -2.46617019e-01f, -5.54672554e-02f, -2.76917815e-01f, 9.61789042e-02f, 2.54956156e-01f, -2.43072465e-01f, -8.07331055e-02f, -3.24451447e-01f,
  -2.39262059e-01f, 6.30712286e-02f, -8.19293186e-02f, 5.59091985e-01f, -2.15744833e-03f, 7.13515207e-02f, -1.77645460e-01f, 6.31675571e-02f, -8.35088342e-02f, 1.84224159e-01f,
  7.67736793e-01f, 1.25453234e-01f, -4.78477746e-01f, -2.46962860e-01f, -7.10738838e-01f, 1.59312069e-01f, 3.46676037e-02f, 1.58360511e-01f, -8.35013315e-02f, -8.57759863e-02f,
  2.49916866e-01f, 1.40642244e-02f, 8.56007487e-02f, 4.88467872e-01f, 6.31982446e-01f, -4.71770763e-03f, 4.92058741e-03f, 5.83102880e-03f, -2.18544513e-01f, -4.59973097e-01f,
  3.46932799e-01f, -2.31341943e-01f, 1.62596509e-01f, 2.23265141e-01f, 2.07657591e-01f, -6.33826554e-01f, -3.42236876e-01f, 1.43472299e-01f, -5.09575903e-01f, 2.97609776e-01f,
  -2.82062531e-01f, 4.35897142e-01f, -3.46916169e-02f, -4.39829499e-01f, 5.09976566e-01f, -1.32595211e-01f, 4.01015580e-01f, 3.80340852e-02f, -1.79031581e-01f, 1.57510415e-02f,
  -7.68546581e-01f, -2.01423034e-01f, -2.47956336e-01f, 2.48916559e-02f, 3.98362637e-01f, -2.33736888e-01f, -1.38991654e-01f, -2.23969370e-01f, 3.94476533e-01f, -1.72840476e-01f,
  -3.01349591e-02f, -2.78152496e-01f, 3.31680477e-01f, 1.93741083e-01f, -1.18083231e-01f, -1.05688728e-01f, 1.63663536e-01f, 8.51451457e-01f, 2.39697751e-02f, 2.72512794e-01f,
  4.00382616e-02f, 1.62191018e-01f, 4.43560749e-01f, -4.39944826e-02f, -1.86359510e-01f, -1.13200225e-01f, -2.69219041e-01f, -7.47835577e-01f, -6.59175441e-02f, 7.70781875e-01f,
  -1.34709358e-01f, 7.54601002e-01f, -2.40121916e-01f, -4.30594832e-01f, 3.41978103e-01f, 1.10229570e-02f, -9.25376788e-02f, -4.07848544e-02f, 1.91718504e-01f, 1.40231522e-02f,
  -3.40238094e-01f, 9.33188796e-02f, 1.77758023e-01f, 1.59187615e-01f, -2.53101021e-01f, -2.70940185e-01f, 5.55335078e-03f, 8.33694458e-01f, 4.93044332e-02f, -4.78245378e-01f,
  -1.89914405e-01f, -5.81684485e-02f, 4.74352956e-01f, -3.15779358e-01f, -3.57684463e-01f, -1.92623064e-02f, -3.28059942e-01f, 2.42962211e-01f, -1.19649939e-01f, 2.78055876e-01f,
  3.87173504e-01f, -4.46654290e-01f, -2.15713456e-02f, -2.82987893e-01f, 3.24209362e-01f, -5.55763781e-01f, -9.79470313e-02f, -1.95434153e-01f, -2.83828169e-01f, -4.71276432e-01f,
  2.50071406e-01f, -6.14695027e-02f, 7.20089793e-01f, -1.65232763e-01f, -3.03120688e-02f, -4.69853491e-01f, -1.07971042e-01f, 7.19688594e-01f, -5.58545440e-02f, -2.93306649e-01f,
  -2.27468554e-04f, -4.96386617e-01f, -3.69673371e-01f, -4.16286029e-02f, -4.25454564e-02f, -6.28031045e-02f, 3.08773160e-01f, 1.20386168e-01f, -1.59491390e-01f, 3.48949909e-01f,
  -1.84740767e-01f, -4.69950497e-01f, -8.42578262e-02f, 4.46521372e-01f, 7.79498965e-02f, -1.63433254e-01f, -3.10975611e-01f, -9.44979191e-02f, 1.84192471e-02f, 8.47042874e-02f,
  -2.65005261e-01f, -1.49645686e-01f, 3.86986956e-02f, 2.33362302e-01f, -2.48570651e-01f, 6.11625798e-02f, 7.25000918e-01f, 1.05918989e-01f, -1.47089943e-01f, -2.85667211e-01f,
  4.63851392e-01f, -3.11185718e-01f, 2.05240875e-01f, 7.49371231e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.76495397e-01f, -1.06190898e-01f, 1.03014529e-01f, 4.00067419e-01f, 1.06607042e-01f, -1.02657706e-01f, 2.46127490e-02f, -1.43320069e-01f, -1.87471926e-01f, 1.80959240e-01f,
  -1.88147966e-02f, -2.76928455e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    