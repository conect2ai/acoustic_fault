/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.38783261e-01f, -4.24779430e-02f, 3.22022028e-02f, -1.36204898e-01f, -1.97118074e-01f, 4.47745293e-01f, 4.16579783e-01f, -1.49644852e-01f, -3.10277820e-01f, 1.52287155e-01f,
  5.45873828e-02f, -1.19153604e-01f, 2.38624841e-01f, -5.86099736e-02f, 5.20302653e-01f, 3.87217134e-01f, 7.52891675e-02f, -4.03144993e-02f, -1.70259714e-01f, -3.99545766e-02f,
  3.10109369e-02f, -1.70916364e-01f, 2.73073167e-01f, -2.09524170e-01f, -4.67527881e-02f, -1.89856902e-01f, 8.26342553e-02f, -6.78481236e-02f, 1.75665924e-03f, -5.88529781e-02f,
  2.09484369e-01f, -1.46103889e-01f, -5.04922271e-02f, -7.51161277e-02f, -2.78822891e-02f, 1.31875709e-01f, 9.27475169e-02f, 1.16832413e-01f, -6.89530233e-03f, -1.45252366e-02f,
  4.16196138e-02f, -1.82505175e-02f, -5.21647669e-02f, -1.24010123e-01f, -2.01829877e-02f, -2.90789679e-02f, -7.01747388e-02f, 2.66867038e-02f, -6.65994212e-02f, 4.16838489e-02f,
  -5.64006669e-03f, -8.83015618e-03f, -1.55827375e-02f, -4.69937548e-02f, -2.34757047e-02f, -4.31928337e-02f, 3.93844917e-02f, -2.23780181e-02f, 8.56506377e-02f, -1.05060734e-01f,
  -3.75543982e-02f, -3.53897288e-02f, 1.70508102e-02f, 3.53531949e-02f, 2.11476628e-02f, -3.55213098e-02f, -3.44647802e-02f, 3.24147493e-02f, -8.20620432e-02f, 8.94078836e-02f,
  -5.48062101e-02f, 1.37582431e-02f, -5.35663813e-02f, 2.55358126e-02f, -1.32423919e-02f, -2.87269633e-02f, 1.85088739e-02f, -2.48406697e-02f, -3.11960629e-03f, 2.18019504e-02f,
  -5.24666905e-02f, 8.26859996e-02f, 2.01474391e-02f, 1.70056820e-01f, 9.72469226e-02f, -3.56784686e-02f, -3.57882380e-02f, 1.25706317e-02f, 5.83599620e-02f, 5.65480441e-02f,
  -7.60683604e-03f, -2.21244127e-01f, -1.86889712e-02f, 2.68630707e-03f, 9.44994297e-03f, -2.91195195e-02f, -1.82484332e-02f, -6.88054711e-02f, -1.95262376e-02f, -7.72351166e-04f,
  -1.62589494e-02f, 8.45719967e-03f, 2.52052266e-02f, 7.22952187e-02f, 5.57506317e-03f, 6.32966459e-02f, 7.30876848e-02f, -1.14614993e-01f, 1.62733365e-02f, -1.02398112e-01f,
  6.96368665e-02f, 3.59307900e-02f, 4.14682273e-03f, 2.56869886e-02f, 9.95494500e-02f, -6.59214891e-03f, -8.74168053e-02f, -9.02224332e-03f, -3.54461721e-03f, -2.63200551e-02f,
  -5.24349153e-01f, -3.29414725e-01f, 1.06952041e-01f, -5.92898250e-01f, 2.90047750e-03f, 2.14809105e-01f, 1.04786918e-01f, -2.49605000e-01f, -2.71774203e-01f, -1.66040182e-01f,
  -2.91607231e-01f, 1.31812811e-01f, 9.88208652e-02f, -4.47806418e-01f, 2.21449763e-01f, 7.46473521e-02f, -4.60195571e-01f, -7.93805569e-02f, -6.89101219e-02f, -1.37201965e-01f,
  -1.38491631e-01f, -3.75259310e-01f, -5.17784618e-02f, -1.63172856e-01f, -1.83878735e-01f, -5.44865169e-02f, 1.38068303e-01f, 2.24469617e-01f, -6.30498752e-02f, 9.81660485e-02f,
  -2.20087662e-01f, -2.80077964e-01f, 4.09008376e-02f, -4.96158889e-03f, -1.17442980e-01f, 5.49138263e-02f, 1.24049634e-01f, 1.50336608e-01f, 1.51487766e-02f, -2.20706016e-02f,
  1.60006322e-02f, -5.82846366e-02f, -9.34986323e-02f, 8.45830664e-02f, -4.47809920e-02f, -6.96709752e-02f, -1.06862105e-01f, -1.57297533e-02f, -7.24141747e-02f, -3.49552222e-02f,
  -4.04304117e-02f, -4.36426513e-02f, -1.02992639e-01f, 2.65260488e-02f, -1.64408144e-02f, -9.38768685e-02f, 3.15968655e-02f, 5.02617732e-02f, 5.89182153e-02f, -8.79809409e-02f,
  3.03641576e-02f, 3.89178693e-02f, -5.27540334e-02f, -8.97032171e-02f, -4.88105901e-02f, -2.76767015e-02f, 1.82974823e-02f, -1.96839124e-02f, 5.91232069e-02f, -2.48885397e-02f,
  -6.85831159e-02f, -5.31163141e-02f, -1.12234294e-01f, -7.62240738e-02f, 1.50925235e-03f, -1.23171948e-01f, 2.74578459e-03f, -2.69409195e-02f, -1.60940662e-02f, -4.08939607e-02f,
  1.00960657e-01f, 1.57105587e-02f, -7.02302977e-02f, 7.77271241e-02f, -2.58589559e-03f, -7.65300617e-02f, -1.24287326e-02f, -6.24014735e-02f, 4.56406958e-02f, 1.10367298e-01f,
  1.39599785e-01f, 9.25803483e-02f, 9.51087177e-02f, -9.16893361e-04f, 9.37613994e-02f, -2.98388433e-02f, 2.27352735e-02f, -9.03122276e-02f, 1.08746439e-01f, -3.27542908e-02f,
  -6.68484420e-02f, 1.91233587e-02f, 5.63636273e-02f, -1.27431452e-01f, 3.15136127e-02f, 2.19459478e-02f, 3.64168361e-02f, 4.21588905e-02f, 7.88606405e-02f, 4.76850346e-02f,
  1.27570471e-02f, 8.57924446e-02f, 5.93312643e-02f, -1.36868134e-01f, 4.57706675e-02f, 2.65645497e-02f, -1.93767566e-02f, -7.22216908e-03f, -2.88064033e-02f, 7.18340501e-02f,
  3.75400066e-01f, -5.81412673e-01f, -2.02567965e-01f, 3.00045013e-01f, -8.20848048e-02f, -4.64803666e-01f, -1.48265034e-01f, 3.23590636e-02f, 1.33302420e-01f, -1.59967110e-01f,
  4.72271331e-02f, -8.50851163e-02f, -1.08421400e-01f, -1.59223661e-01f, 1.25578970e-01f, -1.51161849e-01f, -7.19569176e-02f, -1.03133626e-01f, 5.20332418e-02f, -5.12999371e-02f,
  1.82242412e-02f, 9.19756219e-02f, -1.24535576e-01f, -2.79225316e-02f, -1.74285367e-01f, 1.60494357e-01f, 2.91261822e-01f, 7.80809447e-02f, -1.35707995e-02f, -3.81440930e-02f,
  -2.30471734e-02f, 1.58748358e-01f, -9.10734758e-02f, -4.73834760e-02f, -1.85063649e-02f, 1.13186590e-01f, 4.43628989e-02f, -7.60779390e-03f, 6.10787794e-02f, 1.83445364e-02f,
  -3.88586000e-02f, 1.28803896e-02f, 2.87361182e-02f, 1.22671779e-02f, -2.88163479e-02f, -6.28523231e-02f, -7.73121044e-02f, -1.09660611e-01f, -9.48218629e-02f, -8.30819383e-02f,
  -9.86141041e-02f, 1.75601291e-03f, -1.10860514e-02f, 9.81197581e-02f, 5.92597649e-02f, -1.15920059e-01f, -2.96565495e-03f, 2.00932054e-03f, -9.72083118e-03f, 7.30036572e-02f,
  -2.26219790e-03f, 1.04169231e-02f, -7.55695999e-02f, 3.03752553e-02f, -7.76616484e-02f, 1.06484458e-01f, -1.89556293e-02f, 2.17796788e-02f, 9.14006680e-03f, 2.76041962e-03f,
  4.15826030e-02f, -5.45222312e-02f, 4.21551242e-02f, 1.16575090e-02f, 1.65252723e-02f, 4.02440652e-02f, -8.34636297e-03f, -1.41369617e-02f, 2.06563808e-03f, -1.91173274e-02f,
  -1.47422485e-04f, -1.53002413e-02f, -3.36765461e-02f, -2.76069250e-02f, -7.73876607e-02f, 5.95354587e-02f, 4.34435755e-02f, 4.26315852e-02f, 3.28057334e-02f, 3.45381126e-02f,
  -2.56900638e-02f, 4.05670136e-01f, 4.35587615e-02f, 9.46378149e-03f, 4.10061665e-02f, -1.77468672e-01f, -4.00574785e-03f, 1.12308515e-02f, -1.22650163e-02f, 3.56576331e-02f,
  -3.33810225e-03f, 3.37475985e-02f, -9.77157895e-03f, -4.01501507e-02f, 7.90203884e-02f, 4.28450517e-02f, 2.23297738e-02f, 1.08009372e-02f, 1.32767051e-01f, 5.27818948e-02f,
  9.76857319e-02f, -6.99077249e-02f, 5.61866984e-02f, 3.36298868e-02f, -8.45518187e-02f, 6.00585900e-02f, -1.65486913e-02f, -2.02397313e-02f, 5.25842272e-02f, 4.40244228e-02f,
  8.57881978e-02f, -9.05269906e-02f, -3.11396033e-01f, -2.50512868e-01f, -5.51522784e-02f, 4.41605508e-01f, 4.19181526e-01f, -2.03799412e-01f, -4.57792312e-01f, 3.56162131e-01f,
  -2.46318169e-02f, 8.83178636e-02f, -4.29082429e-03f, 8.34880918e-02f, -8.53028148e-02f, -8.55277702e-02f, 1.43208280e-01f, 1.38139084e-01f, -2.38373399e-01f, 6.68440610e-02f,
  -1.84761524e-01f, 2.12103665e-01f, -5.76629825e-02f, -6.94409609e-02f, 5.66142909e-02f, -1.95292965e-01f, 1.12818688e-01f, -4.89003547e-02f, 3.16362798e-01f, 7.66283497e-02f,
  3.34359445e-02f, -1.74652144e-01f, -6.48310184e-02f, -6.39276356e-02f, 8.80290568e-03f, 7.10185617e-02f, 1.70208305e-01f, 1.03772536e-01f, -1.12601735e-01f, 3.74245981e-04f,
  4.46099043e-02f, 5.39659858e-02f, -7.72200748e-02f, -1.51926558e-02f, 3.14994082e-02f, -4.92465161e-02f, -4.39409912e-02f, 5.10510057e-02f, -9.11404341e-02f, -1.09184729e-02f,
  -1.23088606e-01f, -5.25315478e-02f, 1.38994688e-02f, 7.48383701e-02f, -1.16834253e-01f, -7.29529038e-02f, 5.78442169e-03f, 1.11130103e-01f, 2.56374981e-02f, -1.17753306e-02f,
  9.35700983e-02f, -4.11683731e-02f, 1.43095069e-02f, -2.01528519e-02f, -3.50060277e-02f, -1.08956201e-02f, -4.00297716e-03f, 8.83490220e-02f, -5.21313921e-02f, 5.72674423e-02f,
  1.46545833e-02f, -2.85377838e-02f, -7.43024498e-02f, -1.80003587e-02f, -2.79619638e-02f, 3.42601240e-02f, 4.28362899e-02f, 6.19262084e-02f, -5.53534040e-03f, -2.37463824e-02f,
  -2.97820009e-02f, 4.79453877e-02f, -1.49262063e-02f, -1.37447631e-02f, -2.67748572e-02f, -9.01262090e-02f, -5.46699576e-02f, 1.10887559e-02f, -1.27414390e-01f, 2.22298559e-02f,
  1.22402929e-01f, 1.45570040e-01f, -2.83087436e-02f, -2.63458248e-02f, 2.05515251e-02f, -4.26947661e-02f, -1.30342171e-01f, 3.36464047e-02f, 4.63637570e-03f, 2.03951802e-02f,
  3.86359505e-02f, -4.41775881e-02f, 1.60675883e-01f, 2.53183711e-02f, -3.61704640e-02f, -2.85734106e-02f, 7.22609535e-02f, -2.89411303e-02f, 6.87808096e-02f, 1.10799382e-02f,
  1.35290280e-01f, 4.12713960e-02f, -2.05445439e-02f, 5.37598729e-02f, 2.40841508e-02f, 7.78112262e-02f, -3.74744236e-02f, -8.32869485e-02f, 2.39569489e-02f, -4.18048538e-02f,
  4.20195013e-01f, -5.30377805e-01f, 1.31248072e-01f, 5.19361272e-02f, 1.31979674e-01f, 2.01060519e-01f, 2.44014025e-01f, -3.48645821e-02f, 7.26194009e-02f, -1.95818365e-01f,
  2.01738864e-01f, -2.02819273e-01f, 1.39008582e-01f, 1.06019937e-02f, 4.10794109e-01f, 9.87643600e-02f, 1.25942558e-01f, -1.13698505e-01f, 1.46487467e-02f, -1.33726984e-01f,
  1.18277997e-01f, 1.01792574e-01f, 3.02359939e-01f, -1.23054884e-01f, -4.17507254e-02f, -4.76283729e-02f, -1.86753228e-01f, -4.23606262e-02f, -7.64992982e-02f, 7.86478221e-02f,
  2.52408534e-01f, -1.39071375e-01f, 1.21925510e-02f, 3.74658667e-02f, 3.44149955e-03f, 3.61361131e-02f, -1.63318627e-02f, 3.58898528e-02f, 5.41639291e-02f, -3.34370844e-02f,
  -1.51373614e-02f, -4.79052290e-02f, 8.74735042e-03f, -3.21743563e-02f, -5.31282350e-02f, 1.80955008e-02f, 4.17639352e-02f, -1.88993569e-02f, -7.47388750e-02f, 4.89755254e-03f,
  1.70122180e-02f, 3.46099772e-02f, -1.43956710e-02f, -4.34631184e-02f, 1.04201213e-02f, -1.82482470e-02f, 1.04861043e-03f, -3.44979763e-02f, -3.14682722e-02f, -7.96732605e-02f,
  -1.57314017e-02f, -4.86345869e-03f, 5.22928126e-03f, 5.38993627e-02f, 3.00905015e-03f, 7.67395645e-02f, -4.04425077e-02f, 1.16079720e-03f, -3.03551070e-02f, 4.80706152e-03f,
  2.12611863e-03f, 5.19069657e-03f, -5.75444549e-02f, 9.12610218e-02f, 1.22106187e-02f, -1.75541686e-03f, -3.83358449e-02f, -5.92643879e-02f, -3.00001502e-02f, 4.96171564e-02f,
  1.97892897e-02f, -3.93590853e-02f, -2.43902020e-02f, -1.43143842e-02f, -4.58829366e-02f, 4.53694388e-02f, -5.65136410e-02f, 4.09685262e-03f, 7.84515310e-03f, 9.12817046e-02f,
  -1.58209234e-01f, -3.98059785e-01f, -7.34871998e-03f, -8.46133083e-02f, -8.41466710e-02f, -1.33968458e-01f, 4.55787890e-02f, -7.35822171e-02f, -1.31477294e-02f, -4.81986487e-03f,
  -7.43050948e-02f, 4.40640338e-02f, 2.83690989e-02f, -1.78049281e-02f, 8.43927171e-03f, -1.75161660e-02f, -1.65691655e-02f, -1.66522525e-02f, 2.34079063e-02f, -5.85899837e-02f,
  -3.20668183e-02f, -6.54340610e-02f, 3.81980240e-02f, 3.86331491e-02f, -4.11641560e-02f, 1.63324911e-03f, -7.88295120e-02f, 7.93461967e-03f, -1.10859387e-02f, -7.92909786e-03f,
  -3.38938653e-01f, -1.81863457e-01f, -3.55565459e-01f, 6.24505840e-02f, -2.04045717e-02f, 5.16643584e-01f, 4.31687176e-01f, -9.25843231e-03f, 1.11597084e-01f, 3.53541315e-01f,
  2.31285691e-01f, 6.72935769e-02f, 2.53623337e-01f, 1.79845080e-01f, 1.85473487e-01f, 2.07076252e-01f, 1.39402688e-01f, 1.30349979e-01f, -1.02116652e-01f, -6.22466132e-02f,
  -1.03285305e-01f, 3.36679071e-01f, 1.30315065e-01f, 8.91155973e-02f, -3.08211297e-02f, -1.26503572e-01f, 3.28518189e-02f, 5.34489425e-03f, -5.88073879e-02f, 1.56509876e-01f,
  7.55358785e-02f, -1.01242565e-01f, -9.22245383e-02f, 4.74966168e-02f, 1.67318657e-02f, 7.13222101e-02f, -4.95964177e-02f, 7.25760236e-02f, -3.00906692e-02f, 2.62572267e-03f,
  -1.90191548e-02f, -1.03576519e-01f, 4.41154614e-02f, 9.88413841e-02f, -2.21592467e-02f, -1.63619161e-01f, -1.36614814e-01f, 1.27636762e-02f, -2.35652160e-02f, 3.56307328e-02f,
  7.01431856e-02f, -6.94986284e-02f, -6.89916462e-02f, 7.92086571e-02f, 1.95744932e-02f, -3.20401378e-02f, -4.57860790e-02f, 4.79790755e-03f, 2.23020799e-02f, -5.28485887e-02f,
  3.81342024e-02f, -8.53475854e-02f, 5.46711236e-02f, -6.42856136e-02f, 2.08556950e-02f, -1.43141309e-02f, 6.01475574e-02f, -2.13171504e-02f, 1.05390176e-02f, -4.85517504e-03f,
  5.15452176e-02f, -1.00794099e-01f, 1.79840438e-02f, -1.25544043e-02f, 3.54282297e-02f, -7.86778405e-02f, -6.74251094e-02f, 1.95692666e-02f, -6.60480261e-02f, -7.67957047e-02f,
  3.90562825e-02f, -9.45011526e-03f, 5.02046235e-02f, -1.18757738e-02f, 9.05159190e-02f, 9.24492553e-02f, 3.32129113e-02f, -4.62186709e-02f, 6.86571375e-02f, 6.20028526e-02f,
  1.30233034e-01f, 9.08520445e-02f, 1.06059887e-01f, 5.77095337e-02f, 3.85518745e-02f, -7.93120861e-02f, 4.89946529e-02f, -2.63157431e-02f, 7.00383857e-02f, -8.94438650e-04f,
  -8.50915611e-02f, 2.77566314e-02f, -4.44363840e-02f, -2.29275804e-02f, -3.63242365e-02f, 7.72608370e-02f, 1.78234037e-02f, 3.76112610e-02f, 9.87688825e-03f, -1.14608966e-01f,
  -1.19721770e-01f, -7.48684513e-04f, 5.63448742e-02f, 2.52759121e-02f, 1.06816487e-02f, 6.36626733e-03f, -1.26812223e-03f, -3.62578407e-02f, -6.29748031e-02f, 2.18242630e-02f,
  -1.76868215e-02f, -2.85952701e-03f, 3.92448425e-01f, 1.33159742e-01f, 5.73723800e-02f, 3.67412120e-01f, 3.11949044e-01f, -2.07381155e-02f, 4.92279202e-01f, -8.98020789e-02f,
  3.86002399e-02f, -1.50200829e-01f, 9.63342283e-03f, -7.56836385e-02f, 2.84028292e-01f, 4.27025080e-01f, 1.37713417e-01f, 1.71338618e-01f, 1.76048540e-02f, -2.26645902e-01f,
  8.64323154e-02f, -1.06637314e-01f, 6.42093569e-02f, -1.60635844e-01f, -1.53556922e-02f, -1.91246226e-01f, -2.75991052e-01f, 5.36706001e-02f, -1.40138477e-01f, 7.83772394e-02f,
  -5.62601686e-02f, -1.03745006e-01f, -1.26232907e-01f, 6.58882111e-02f, -1.49161920e-01f, 6.43732324e-02f, -1.09602753e-02f, 1.17763542e-01f, -5.22908159e-02f, 2.51481365e-02f,
  4.17524613e-02f, -5.58678713e-03f, -1.01373099e-01f, 9.51531380e-02f, 1.26527578e-01f, 1.51007390e-02f, 1.12104997e-01f, 1.23718865e-02f, -1.12100653e-01f, 1.23209640e-01f,
  4.22751531e-02f, -5.67181185e-02f, 1.26894983e-02f, 6.45748600e-02f, -2.42817216e-02f, 2.49162242e-02f, -5.37188202e-02f, 1.99091453e-02f, -2.20164587e-03f, -1.09319631e-02f,
  -1.60753578e-02f, -1.96472239e-02f, -1.82406884e-03f, 6.81696981e-02f, 1.46948416e-02f, -5.31072021e-02f, 6.81581721e-02f, -7.48566315e-02f, 4.31485921e-02f, 2.53338926e-02f,
  3.71264890e-02f, 6.34869188e-02f, -4.10638824e-02f, 2.16182582e-02f, -1.93357747e-02f, 3.72738391e-02f, 4.34301980e-02f, -2.95717213e-02f, -1.11877546e-02f, 6.83584586e-02f,
  5.87592460e-02f, -3.13645825e-02f, -1.16037548e-01f, 1.95730589e-02f, 6.17735554e-03f, -4.06686366e-02f, -3.69925350e-02f, 4.61332984e-02f, -1.81154590e-02f, 3.87470610e-02f,
  1.67717952e-02f, -1.31334633e-01f, -1.15323827e-01f, -2.95801889e-02f, 7.88355097e-02f, 1.54287312e-02f, 1.01826780e-01f, -2.53874548e-02f, -1.29804313e-02f, -1.53585151e-02f,
  -9.69807804e-02f, 3.82443098e-03f, -1.02560900e-01f, -2.95774397e-02f, -2.53444929e-02f, 5.82111031e-02f, -6.30358979e-02f, 1.99528001e-02f, -2.05883104e-02f, -9.46246311e-02f,
  -5.70667982e-02f, -2.81123836e-02f, 1.09013811e-01f, -1.59693044e-02f, -9.21433866e-02f, -2.69384310e-02f, -4.88686860e-02f, -6.84351996e-02f, 7.78662413e-02f, 6.56969994e-02f,
  7.32775629e-01f, 6.40141368e-01f, 3.25386316e-01f, 4.67064857e-01f, -1.75052524e-01f, 1.02564134e-01f, 1.99779961e-02f, 2.03283519e-01f, 3.94141853e-01f, 2.26653810e-03f,
  -1.46046132e-01f, 1.68203622e-01f, -6.90258071e-02f, 1.13931201e-01f, -2.33569473e-01f, -1.29694983e-01f, 3.11235994e-01f, 5.48532680e-02f, -6.32001646e-03f, 2.70512700e-01f,
  5.56301884e-02f, -3.26901615e-01f, 7.36800907e-03f, -1.36620253e-01f, 1.70484453e-01f, 2.34973654e-01f, -1.58411607e-01f, -1.44975647e-01f, -8.80578309e-02f, -1.28726617e-01f,
  -1.58124983e-01f, -2.03810278e-02f, 6.59870803e-02f, 1.75837986e-02f, 1.20707020e-01f, 4.12381850e-02f, -3.67201641e-02f, -1.13073282e-01f, -9.42747146e-02f, 2.38634963e-02f,
  3.43799517e-02f, -6.14420995e-02f, 1.35938767e-02f, -4.63090055e-02f, 2.11192872e-02f, 7.33668357e-02f, -3.24808061e-02f, 1.07621640e-01f, 1.72067340e-02f, -5.81442229e-02f,
  3.60241160e-02f, -5.50329452e-03f, 7.23633543e-02f, 7.94628076e-03f, 5.06666638e-02f, 3.84817980e-02f, -7.99245201e-03f, -1.68998335e-02f, 5.36310747e-02f, -5.99787012e-03f,
  6.54569343e-02f, -3.47391665e-02f, 7.41491653e-03f, -1.04634641e-02f, -1.18035944e-02f, -4.41580638e-02f, 1.35092037e-02f, -1.52145594e-01f, 6.60036951e-02f, -7.50627816e-02f,
  -6.40594354e-03f, 1.07542984e-02f, -4.31369897e-03f, 2.74040643e-02f, -1.67605262e-02f, 2.66982801e-02f, -8.93241540e-02f, -5.74753582e-02f, 9.47740898e-02f, -8.07131529e-02f,
  -2.74736527e-02f, -1.08178398e-02f, -1.34511339e-02f, -3.50029469e-02f, -7.88762346e-02f, -4.82808985e-02f, 4.28074487e-02f, 4.91522327e-02f, 2.84750778e-02f, -4.51232493e-02f,
  4.66190390e-02f, 2.18285501e-01f, -1.60842370e-02f, -1.17952593e-01f, -1.02885455e-01f, 6.11357689e-02f, 3.21785398e-02f, 6.15806766e-02f, 1.03022531e-01f, -4.03904244e-02f,
  5.34437746e-02f, 1.86052676e-02f, 6.47700951e-02f, -3.25075872e-02f, -4.69539426e-02f, 4.74675968e-02f, -1.61501430e-02f, -5.46665303e-03f, 5.52618317e-03f, 5.36452271e-02f,
  6.36867732e-02f, -2.62824073e-02f, -5.57085350e-02f, 1.92369800e-02f, 3.77765228e-03f, -3.88560779e-02f, 3.03912070e-02f, 1.73383225e-02f, -7.06007928e-02f, -2.02655494e-02f,
  8.00682008e-01f, -5.28948665e-01f, -5.46659112e-01f, 4.50135507e-02f, 4.38852221e-01f, -7.27581307e-02f, -1.94564953e-01f, 9.68651772e-02f, 3.00831228e-01f, -1.90312997e-01f,
  -1.60542373e-02f, -5.50569631e-02f, -3.18896890e-01f, -4.46422510e-02f, -2.10813098e-02f, -1.63006678e-01f, -1.25555307e-01f, -1.71343293e-02f, 3.72852497e-02f, 1.64918024e-02f,
  5.79699874e-02f, 1.05336949e-01f, -3.01696181e-01f, 1.20121511e-02f, 1.23062534e-02f, -1.74401253e-02f, -1.36189699e-01f, -1.19143486e-01f, -9.02551878e-03f, 7.94634521e-02f,
  9.77468714e-02f, 7.59306625e-02f, -8.88704956e-02f, -9.95643884e-02f, -8.70229769e-03f, -5.27485944e-02f, -8.62511806e-03f, -1.79978330e-02f, 4.81166504e-02f, -2.53880359e-02f,
  -4.66319313e-03f, 6.60276785e-02f, 9.58866403e-02f, -4.55545522e-02f, 4.77538444e-02f, 1.06010456e-02f, 1.17232770e-01f, 4.97523986e-04f, 2.53271945e-02f, 2.12656911e-02f,
  -7.90962726e-02f, -7.05999881e-03f, -5.20478599e-02f, -7.27179348e-02f, -2.52616853e-02f, -3.31391990e-02f, -3.31126451e-02f, -5.83411343e-02f, 9.70125869e-02f, 6.89576939e-02f,
  3.97515148e-02f, 2.35325173e-02f, -1.29703898e-02f, 1.42507926e-02f, 7.72752985e-02f, 4.19769585e-02f, -2.94133611e-02f, 5.17306253e-02f, 8.74323770e-03f, -2.02520359e-02f,
  1.17964759e-01f, -3.31652700e-03f, 9.19138268e-02f, -6.77176714e-02f, 5.13528287e-02f, 3.19049768e-02f, -8.64024833e-02f, -2.24609170e-02f, 2.50899140e-02f, 4.95961718e-02f,
  3.82643589e-03f, -4.46751248e-03f, 3.29523198e-02f, -8.74831993e-03f, 1.48670934e-02f, -5.13746366e-02f, -4.65560220e-02f, -1.03143074e-01f, -6.23033158e-02f, -8.84106830e-02f,
  -9.18209851e-02f, -1.63164899e-01f, 1.18442833e-01f, 6.10781610e-02f, -2.93094516e-02f, 3.06029618e-02f, 5.71754649e-02f, 8.83482993e-02f, -9.85737815e-02f, 5.30353524e-02f,
  -4.99989018e-02f, -3.89862433e-02f, -3.11334375e-02f, 4.16307934e-02f, -6.60793632e-02f, -5.14220595e-02f, 1.40531939e-02f, 3.25006731e-02f, 7.93218333e-03f, -2.47438680e-02f,
  -1.88092254e-02f, 7.63753951e-02f, 3.44866104e-02f, 1.32049307e-01f, 7.43161663e-02f, 1.81396678e-02f, 1.13144562e-01f, 4.02126014e-02f, -5.28551899e-02f, -4.40221503e-02f,
  -1.75348178e-01f, 5.37794709e-01f, -2.10284218e-01f, 1.26688212e-01f, -7.95782134e-02f, 7.96669662e-01f, -3.24699096e-02f, 1.00758404e-01f, 7.63806049e-04f, 3.35957438e-01f,
  -5.31074032e-02f, -1.35844409e-01f, -4.03114222e-02f, 4.01815593e-01f, 1.75503671e-01f, 2.58453965e-01f, 2.53653318e-01f, 1.20915413e-01f, -2.11345851e-02f, 7.62632489e-02f,
  9.87352803e-03f, 4.51744765e-01f, -3.04397251e-02f, 1.94510892e-01f, -4.15420979e-02f, -7.82847553e-02f, -1.36653364e-01f, -1.86574742e-01f, 3.54122110e-02f, 7.91146532e-02f,
  -2.56932545e-02f, -1.07449695e-01f, -8.55583921e-02f, -4.27406281e-02f, 7.51030147e-02f, -6.04554527e-02f, -7.90894218e-03f, -1.43860728e-01f, -4.06594127e-02f, -3.74386311e-02f,
  -7.70369992e-02f, 6.06284626e-02f, 2.58135367e-02f, 1.69873629e-02f, -1.14288752e-03f, -5.60960546e-02f, -1.61300916e-02f, 5.23541309e-02f, 6.76371902e-02f, -3.79050784e-02f,
  -3.64609621e-02f, -1.60661358e-02f, -2.92945355e-02f, -1.78147890e-02f, -5.17159030e-02f, 2.81801205e-02f, 5.38339131e-02f, -8.82770196e-02f, 1.27567556e-02f, 1.43286169e-01f,
  3.14256214e-02f, 3.68356891e-02f, -5.52178286e-02f, -7.71970749e-02f, 7.76244327e-02f, -6.75031543e-02f, 4.08316106e-02f, -5.37768155e-02f, -1.02019347e-02f, 3.04560289e-02f,
  3.85460071e-02f, -7.87787735e-02f, 4.90605496e-02f, 6.33490738e-03f, 4.36760187e-02f, 2.50129476e-02f, -4.98703085e-02f, 2.20764168e-02f, -3.59935425e-02f, 2.55124383e-02f,
  -5.54929264e-02f, 4.10558023e-02f, 3.72352800e-03f, -4.02834229e-02f, 4.60740589e-02f, -8.91123787e-02f, 7.22557753e-02f, 3.01072598e-02f, -4.19017673e-02f, -1.36122089e-02f,
  2.50141174e-01f, 3.18960994e-01f, 2.46868283e-02f, 3.19760628e-02f, 3.27061452e-02f, 1.54340575e-02f, 2.55407430e-02f, 7.53869340e-02f, -1.83271011e-03f, 8.28124769e-03f,
  3.29161324e-02f, 4.54414578e-04f, 1.44193945e-02f, -9.09896754e-03f, 3.09854317e-02f, 3.19051072e-02f, -3.11083049e-02f, -2.94945054e-02f, -3.97845171e-03f, 2.59400737e-02f,
  -5.89596629e-02f, -4.16871831e-02f, -2.88472269e-02f, 3.82757746e-02f, -2.50851773e-02f, -3.39756906e-02f, -1.41117983e-02f, 4.58779978e-03f, 2.91649736e-02f, -4.42927107e-02f,
  -3.94211620e-01f, -1.59701303e-01f, 3.34036410e-01f, -3.60629931e-02f, -2.20123664e-01f, -1.94881618e-01f, -3.60374987e-01f, -1.73422635e-01f, -2.83571631e-01f, -1.99424222e-01f,
  -3.14457417e-01f, 2.76979476e-01f, -1.85693935e-01f, 1.16013817e-01f, 1.42409399e-01f, -1.69349462e-02f, -4.66144085e-02f, 6.96371049e-02f, -1.31347209e-01f, -5.47772534e-02f,
  6.72490746e-02f, -1.86130270e-01f, 2.41890207e-01f, -5.87685332e-02f, 1.06293701e-01f, 1.64879069e-01f, 2.12701216e-01f, 1.37257144e-01f, 2.71239638e-01f, 8.10647458e-02f,
  -2.18041725e-02f, -2.54200637e-01f, 5.35513507e-03f, 1.80138871e-01f, -1.32516906e-01f, 2.26785932e-02f, 1.48173258e-01f, -1.06285494e-02f, 1.02265574e-01f, 1.25460830e-02f,
  -2.19549425e-02f, 1.37632722e-02f, 3.68338302e-02f, 3.53313982e-02f, -7.28046000e-02f, 8.38921294e-02f, 3.56573835e-02f, -9.95280221e-02f, 3.97258531e-03f, 1.93571076e-02f,
  -3.03478707e-02f, 1.84709523e-02f, 2.53954548e-02f, 1.85707863e-02f, 3.08129564e-02f, -7.83988237e-02f, 4.23528813e-02f, 8.51207525e-02f, 4.78843749e-02f, -8.60486552e-02f,
  -1.54140696e-01f, -3.00687551e-02f, 1.11402191e-01f, -3.39510068e-02f, -2.44679619e-02f, -2.73138806e-02f, -3.94132920e-02f, 2.40518562e-02f, 3.27930339e-02f, -1.12168558e-01f,
  -7.22396299e-02f, 4.63978536e-02f, -2.05904841e-02f, -5.76342382e-02f, -1.84444357e-02f, -1.49705619e-01f, -2.68840715e-02f, -7.54686911e-03f, -1.98013764e-02f, 3.92927341e-02f,
  -2.50609498e-02f, 2.26743259e-02f, 4.91424538e-02f, -7.04419985e-03f, -5.44207133e-02f, 3.22152264e-02f, -4.32259999e-02f, -4.95509431e-03f, 2.17164564e-03f, -1.75100248e-02f,
  -3.91765237e-02f, -2.70285085e-03f, -1.13956323e-02f, -9.42436159e-02f, 3.98057327e-02f, -1.51027488e-02f, 2.21528411e-02f, 4.43334728e-02f, 9.67812724e-03f, -6.58777952e-02f,
  4.76806983e-02f, 2.47492660e-02f, -4.06249873e-02f, -1.72092617e-02f, 1.02776013e-01f, -6.35393932e-02f, 8.36945511e-03f, 6.13562241e-02f, 7.34732524e-02f, -8.05738382e-03f,
  6.76257834e-02f, -3.09213847e-02f, -2.84761726e-03f, 3.36303897e-02f, -4.03528512e-02f, -6.46656752e-02f, 4.93234210e-02f, 9.39427037e-03f, 1.57856997e-02f, 4.24150825e-02f,
  1.17749631e-01f, -3.88920158e-01f, 3.86645794e-01f, 1.63945958e-01f, -1.50531456e-01f, 2.36927480e-01f, 2.13977024e-01f, -5.56510091e-02f, 2.43731495e-02f, -3.38532746e-01f,
  -1.09777436e-01f, -1.33946240e-01f, -7.83821419e-02f, -2.85717342e-02f, 4.00463313e-01f, 2.00287737e-02f, 2.74332017e-01f, -4.78420369e-02f, 2.28370298e-02f, -9.58628878e-02f,
  5.30350581e-02f, -5.37165329e-02f, 2.92235047e-01f, -7.20299035e-02f, -2.16604415e-02f, 4.81938906e-02f, 1.21717982e-01f, 6.09771758e-02f, -5.08261798e-03f, 1.47106759e-02f,
  6.35335371e-02f, -1.20785795e-01f, -4.03313339e-02f, -6.18247949e-02f, 6.12767190e-02f, -4.50461928e-04f, -9.66211222e-03f, -2.00571585e-02f, 6.02290221e-02f, -1.76181886e-02f,
  -6.91420063e-02f, 2.82238182e-02f, -2.24650130e-02f, 4.31241188e-03f, -9.14950967e-02f, 1.18781731e-03f, 1.96927674e-02f, 1.17925361e-01f, 2.30517355e-03f, 7.07461089e-02f,
  3.93558778e-02f, 3.41186672e-02f, 5.66868819e-02f, -5.06444834e-02f, 1.15564898e-01f, 6.94879293e-02f, 1.19483985e-01f, 8.64992589e-02f, 4.10589054e-02f, -1.31844711e-02f,
  8.57857466e-02f, 1.26751708e-02f, 2.08687107e-03f, -5.35608120e-02f, -2.29719956e-03f, 4.28205496e-03f, -3.22740413e-02f, -6.10312037e-02f, -1.67084616e-02f, -4.97593135e-02f,
  7.77930673e-03f, -7.57040530e-02f, 1.08316692e-03f, -3.15812379e-02f, -2.72886436e-02f, 4.00254577e-02f, -1.08257737e-02f, -8.60323608e-02f, 2.35775188e-02f, 5.11555187e-03f,
  -2.91596148e-02f, 5.45947477e-02f, -6.55967891e-02f, 2.02603843e-02f, 3.74081172e-02f, 2.88823023e-02f, -3.51571329e-02f, 1.01576010e-02f, 1.64381471e-02f, 4.78857495e-02f,
  -2.58485377e-01f, -9.61041152e-02f, -4.10182290e-02f, -8.30384046e-02f, -2.23141182e-02f, -1.72641466e-03f, 8.93250257e-02f, 2.56189276e-02f, -3.99542414e-02f, -4.70639765e-03f,
  -5.73387556e-03f, 1.51994433e-02f, 3.85862812e-02f, -4.00091410e-02f, 7.65812099e-02f, -3.16260979e-02f, 1.80503540e-02f, -6.86956793e-02f, 1.40639571e-02f, -6.52907044e-02f,
  -4.38915789e-02f, -6.92619523e-03f, 5.84976785e-02f, 3.43839526e-02f, -4.28386666e-02f, -5.24793677e-02f, -3.34574692e-02f, 1.99440978e-02f, -6.81444257e-02f, 3.34565118e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.30605197e+00f, 7.41599143e-01f, 3.75655502e-01f, -8.55158091e-01f, -1.06222875e-01f, 9.88151506e-02f, -4.18458104e-01f, 4.00258899e-01f, -4.77884591e-01f, 3.80756021e-01f,
  7.41699263e-02f, -6.93784952e-01f, 6.13443971e-01f, -2.27938652e-01f, -6.27660811e-01f, 2.51578595e-02f, -2.73415238e-01f, -3.56993675e-01f, -1.92408681e-01f, 1.11304566e-01f,
  -1.67090014e-01f, -2.19701692e-01f, 4.78704274e-01f, 5.39209843e-01f, 9.38884355e-03f, 1.34935006e-01f, 3.70774031e-01f, 4.10550386e-01f, 3.05654138e-01f, -1.17879011e-01f,
  5.90695813e-03f, 6.89629987e-02f, 1.19604543e-01f, -4.05959859e-02f, 2.11542368e-01f, 9.58796814e-02f, -6.25930205e-02f, -2.08058745e-01f, -2.24239498e-01f, 1.37735726e-02f,
  -1.30656049e-01f, 6.42557144e-02f, -2.23423168e-01f, -2.84343176e-02f, -2.30239015e-02f, -5.81707656e-02f, 1.37765780e-01f, 1.36440054e-01f, 8.70591179e-02f, 1.36887014e-01f,
  1.26337975e-01f, 7.73420334e-02f, -5.76126873e-02f, 2.72869896e-02f, 5.24464995e-02f, -1.04261776e-02f, -9.83224437e-02f, 5.49925193e-02f, 2.25393940e-03f, -2.19068170e-01f,
  -8.77334103e-02f, -9.29142907e-02f, 1.56041542e-02f, 6.79780096e-02f, -7.15200529e-02f, 1.08202405e-01f, -1.00643829e-01f, -7.62029551e-03f, -7.01209158e-02f, 4.63879807e-03f,
  -5.77860605e-03f, -1.82697996e-01f, -3.13811824e-02f, -8.92914310e-02f, -5.89246601e-02f, -1.17997595e-04f, -4.90526743e-02f, -9.10685980e-04f, -4.97664213e-02f, 1.20982088e-01f,
  -9.85544696e-02f, -1.24264292e-01f, -1.93503555e-02f, 6.08113259e-02f, -2.61605643e-02f, -6.55069053e-02f, 9.35435295e-03f, 2.35551577e-02f, 3.13918367e-02f, 3.42137590e-02f,
  2.75970519e-01f, 3.27311218e-01f, 1.37915075e-01f, -8.56442899e-02f, -1.46906935e-02f, 2.22223476e-02f, -5.78457639e-02f, 4.05887552e-02f, -3.40018645e-02f, -9.05890837e-02f,
  -7.80430958e-02f, -5.89878336e-02f, 1.62062934e-03f, -1.31872579e-01f, -7.33098686e-02f, 9.17321369e-02f, 2.81316265e-02f, -2.14095026e-01f, 6.90802783e-02f, 1.60322562e-01f,
  8.06811973e-02f, -1.34758562e-01f, -1.86441392e-01f, 8.15257728e-02f, -8.24000463e-02f, -7.47008994e-03f, 3.74981873e-02f, -1.98461991e-02f, 1.06760785e-01f, 1.19618122e-02f,
  7.33524978e-01f, 4.54565138e-01f, 5.92452705e-01f, 4.99229804e-02f, -3.46076310e-01f, -2.97901601e-01f, -1.59570724e-01f, -2.71879315e-01f, 2.19004452e-01f, -2.01103240e-01f,
  -4.44402486e-01f, 8.59342635e-01f, -4.46184836e-02f, -2.27340341e-01f, -2.10310459e-01f, -1.77530900e-01f, -4.89643902e-01f, -1.03142478e-01f, 3.40044498e-02f, -2.38003522e-01f,
  -2.16162786e-01f, -7.68450856e-01f, 2.20422493e-03f, -7.01737881e-01f, -9.20515857e-04f, 2.19355658e-01f, -6.02876425e-01f, -2.61238545e-01f, -1.05514660e-01f, -1.39784336e-01f,
  7.87165388e-02f, -6.79183081e-02f, 2.39731938e-01f, 7.98565522e-03f, -8.27231258e-02f, 1.11743674e-01f, 1.23377532e-01f, -7.44834393e-02f, 7.27035925e-02f, 8.20222944e-02f,
  2.30586633e-01f, 3.89689542e-02f, -1.27338275e-01f, 7.74436584e-03f, 1.06824443e-01f, 5.33976629e-02f, 1.39174372e-01f, 2.22249582e-01f, 1.69347778e-01f, 2.70490617e-01f,
  2.68194765e-01f, 2.46952429e-01f, 1.40046075e-01f, 2.69181002e-02f, 2.76738666e-02f, 1.89130213e-02f, 3.30681205e-02f, 1.46692380e-01f, 1.52320504e-01f, 1.73002362e-01f,
  -1.06909178e-01f, -5.21219298e-02f, -1.65977210e-01f, 1.11790039e-01f, -1.09472714e-01f, -4.51155603e-02f, -6.34383932e-02f, -2.21123565e-02f, 1.41814336e-01f, -1.11083500e-01f,
  -2.78989244e-02f, 2.06862539e-01f, -1.10443838e-01f, -9.58742723e-02f, 1.96624198e-03f, 1.10460468e-01f, 5.38145937e-02f, -9.67283025e-02f, -2.49266159e-02f, 2.04141662e-01f,
  -1.45031214e-01f, -1.45353273e-01f, 2.09185015e-02f, -6.17324747e-02f, -1.05308972e-01f, 4.37882654e-02f, 9.90623794e-03f, 2.83151239e-01f, -3.93369719e-02f, -9.81708616e-02f,
  -2.20377102e-01f, -8.68030787e-01f, -3.45381089e-02f, -8.47461913e-03f, 2.38248240e-02f, -3.59364301e-02f, -9.91242304e-02f, 1.36131607e-02f, -3.23260963e-01f, -2.34313458e-01f,
  -1.75871119e-01f, 5.11822216e-02f, 7.50452653e-02f, 7.86710158e-02f, -1.19510859e-01f, -1.63945168e-01f, -2.44100764e-01f, -8.77556950e-02f, -1.15667604e-01f, 1.66863780e-02f,
  -5.51234744e-02f, -8.04171711e-02f, 1.86745182e-01f, 2.47406512e-02f, -7.27432221e-02f, -1.62467256e-01f, 3.44681181e-02f, 1.64119393e-01f, -2.13823646e-01f, -7.74547132e-03f,
  -1.42350054e+00f, 6.27811790e-01f, -3.39064926e-01f, -5.41443110e-01f, -6.16671555e-02f, -2.40536749e-01f, -1.11846462e-01f, 2.68674344e-01f, 1.12955593e-01f, 6.58582687e-01f,
  1.61752164e-01f, 3.55589800e-02f, 6.20305240e-01f, 6.03609644e-02f, -6.34252250e-01f, 4.57426667e-01f, -5.16027749e-01f, -2.16947243e-01f, 2.94233680e-01f, -2.28043050e-01f,
  -3.03149372e-01f, 1.78378284e-01f, -2.80077308e-01f, 5.61052322e-01f, -6.11857235e-01f, -2.20988542e-01f, -3.82774591e-01f, 1.45566434e-01f, -5.12277842e-01f, -3.12224515e-02f,
  -6.54527247e-01f, 4.05473709e-02f, -3.29992145e-01f, -1.57380745e-01f, -3.10346007e-01f, -8.88637602e-02f, -2.84072280e-01f, 1.39380306e-01f, 6.54968545e-02f, 4.70417598e-03f,
  -9.95453671e-02f, 1.13541141e-01f, 7.97784925e-02f, 1.16860494e-01f, -7.27267712e-02f, -5.90265058e-02f, -1.03175379e-01f, -2.26997212e-01f, 1.10636652e-01f, -8.58644769e-02f,
  2.10838877e-02f, 3.09836864e-02f, -2.19645157e-01f, 1.08987363e-02f, -2.33478367e-01f, -5.97059680e-03f, 4.68122363e-02f, -1.05596244e-01f, -3.24477911e-01f, -7.59112984e-02f,
  2.01239645e-01f, 8.41610357e-02f, -7.33827055e-02f, 4.46486957e-02f, -4.43814369e-03f, -9.80675519e-02f, -1.98507961e-02f, -3.00291590e-02f, -1.84969325e-02f, -1.56806946e-01f,
  -1.57877013e-01f, -8.30799062e-03f, -6.40856624e-02f, -1.09970190e-01f, -1.66620277e-02f, -5.93207069e-02f, -4.91895936e-02f, -8.34824145e-02f, -3.45750749e-02f, -1.08832933e-01f,
  4.40247403e-03f, 6.26929328e-02f, 1.41894922e-01f, -1.83799818e-01f, 2.19840184e-02f, 1.49049470e-02f, 7.93181136e-02f, 2.31717341e-03f, -8.13593343e-02f, -1.53403252e-01f,
  -9.67036903e-01f, -3.22590768e-01f, 3.97938229e-02f, -2.17855006e-04f, -1.23310529e-01f, -1.83065161e-02f, 8.80384967e-02f, -8.66760164e-02f, -8.34852681e-02f, 5.49063683e-02f,
  -1.44762859e-01f, -8.33765492e-02f, -2.77761251e-01f, -4.06184755e-02f, -6.54621422e-02f, -1.13033421e-01f, -1.73082322e-01f, 5.57663478e-02f, -2.59589285e-01f, -8.94783661e-02f,
  -6.51684925e-02f, 1.92652866e-01f, 2.10749254e-01f, -3.75025198e-02f, -5.33081777e-02f, -1.46794409e-01f, -1.18975341e-01f, 3.89089324e-02f, -1.62427694e-01f, 9.87682566e-02f,
  3.17153126e-01f, -5.23115098e-01f, -7.85364568e-01f, -4.12196964e-01f, 7.22917914e-01f, 7.54588544e-01f, -1.52929664e-01f, 2.82888860e-01f, -7.06294537e-01f, 8.50590467e-02f,
  2.46837601e-01f, -7.03107357e-01f, -8.30897510e-01f, -4.18022349e-02f, 5.85646108e-02f, -8.86990845e-01f, 4.17358965e-01f, 7.32175931e-02f, -2.20848873e-01f, 4.24776226e-01f,
  1.17456071e-01f, 8.06301415e-01f, -2.23103181e-01f, 6.49114072e-01f, 4.26719069e-01f, 2.24951394e-02f, 6.05821073e-01f, -1.73492059e-01f, 4.60753500e-01f, -1.23244338e-02f,
  -9.98019502e-02f, -1.71964660e-01f, 2.45143101e-03f, -2.25977987e-01f, 2.80445665e-01f, 2.06973970e-01f, 4.83533479e-02f, -1.77495092e-01f, -1.30463958e-01f, -1.84643522e-01f,
  -1.19061612e-01f, -7.96578676e-02f, 2.83801742e-02f, -9.42487791e-02f, 1.66168854e-01f, -2.42122691e-02f, -9.95264798e-02f, -1.05045706e-01f, -2.84109950e-01f, -6.75210506e-02f,
  -1.51412874e-01f, -1.23105966e-01f, 9.69008356e-02f, -9.48293060e-02f, -1.55325100e-01f, -1.24786487e-02f, 2.56534796e-02f, -1.36374738e-02f, -2.27850862e-02f, 2.27156177e-01f,
  2.39716947e-01f, 4.57478352e-02f, 3.44041288e-02f, -1.01340242e-01f, 8.39624438e-04f, -2.18343288e-02f, -7.83477947e-02f, 5.55979647e-02f, -4.67485264e-02f, 1.42272543e-02f,
  4.23528776e-02f, 1.63476903e-03f, -9.64639410e-02f, 1.73646823e-01f, 1.89587727e-01f, -9.07480717e-02f, 8.33342224e-02f, 1.44776227e-02f, 1.18499205e-01f, 2.93234978e-02f,
  -2.08468616e-01f, 1.17710106e-01f, -2.21438408e-02f, -4.14054058e-02f, -8.07545036e-02f, -2.49199774e-02f, 1.30560741e-01f, 8.97361618e-03f, 2.68013496e-02f, 3.72985005e-02f,
  5.46157323e-02f, 2.95321465e-01f, -1.87534675e-01f, -2.40286589e-02f, -1.81425765e-01f, 3.03047508e-01f, -1.31258845e-01f, 1.01958960e-01f, 6.70722872e-02f, 6.80062473e-02f,
  3.35335732e-01f, 1.41778573e-01f, 9.60023776e-02f, 4.47710007e-02f, -7.00649247e-02f, 2.97113389e-01f, 2.24335101e-02f, 7.09351897e-02f, 2.45645389e-01f, 1.52035952e-01f,
  2.21499205e-01f, 2.43728474e-01f, 5.25944903e-02f, 2.30719283e-01f, 1.38078541e-01f, 3.90145592e-02f, 1.85280457e-01f, -6.32361025e-02f, 3.36881727e-02f, -1.53356835e-01f,
  2.20040232e-01f, -2.95063168e-01f, -6.75293982e-01f, 4.99635220e-01f, -1.06191508e-01f, -3.53763342e-01f, -4.96506035e-01f, 1.97821245e-01f, -6.55521750e-01f, 6.88345209e-02f,
  6.47405446e-01f, 1.18857380e-02f, -7.98004046e-02f, 1.05450988e+00f, 6.44927502e-01f, 1.33910596e-01f, 7.05449820e-01f, 4.23130363e-01f, -1.10468909e-01f, 1.36825606e-01f,
  3.95135701e-01f, 6.89927816e-01f, 6.55928969e-01f, 4.78408545e-01f, 4.54012245e-01f, 2.15735465e-01f, 5.86454391e-01f, -1.91017330e-01f, 6.05653346e-01f, 2.46080324e-01f,
  3.57175842e-02f, -3.31268236e-02f, 1.29469140e-02f, -9.98010188e-02f, -6.22590333e-02f, 2.26228107e-02f, -8.27376097e-02f, 1.55212402e-01f, -7.05900267e-02f, -9.39076319e-02f,
  -9.98644456e-02f, 1.77533045e-01f, 6.70874864e-02f, -6.54959157e-02f, -8.97780880e-02f, -1.99629635e-01f, -2.55964279e-01f, 6.18767506e-03f, -2.38009810e-01f, 4.21956405e-02f,
  -2.35797182e-01f, 8.93080309e-02f, 6.33879974e-02f, 1.31468937e-01f, -1.02858983e-01f, -1.18338771e-01f, -1.46358997e-01f, -1.86156929e-01f, -1.13999017e-01f, -2.02489663e-02f,
  8.64014924e-02f, -4.97163134e-03f, -1.19736694e-01f, 1.06897093e-01f, -1.68573856e-01f, 1.81982554e-02f, 1.23214751e-01f, 3.24738696e-02f, 8.21123179e-03f, 2.53977515e-02f,
  8.03751051e-02f, -5.59678674e-03f, 3.23981396e-03f, -9.72297192e-02f, 3.56402360e-02f, 2.82839686e-02f, 4.16472033e-02f, 6.18734881e-02f, -1.79266363e-01f, 9.22422335e-02f,
  1.68144166e-01f, -6.53141513e-02f, -9.46695283e-02f, -2.67262831e-02f, -3.47073041e-02f, -2.79356930e-02f, 1.60415128e-01f, 1.34629253e-02f, 2.96692587e-02f, 5.67734092e-02f,
  7.94302393e-03f, 3.78690548e-02f, -9.04229528e-04f, -1.42815813e-01f, 6.85228093e-04f, -1.30875716e-02f, 1.14062913e-01f, 1.63565744e-02f, 5.44338338e-02f, -1.14275649e-01f,
  7.78936073e-02f, -2.88868751e-02f, -9.18994248e-02f, -6.58126734e-03f, 6.89045042e-02f, -6.10521547e-02f, -9.89056472e-03f, -1.02536760e-01f, 8.76701400e-02f, 1.56034052e-01f,
  9.01450813e-02f, -2.17536777e-01f, 5.92170991e-02f, -2.52409190e-01f, 7.94575885e-02f, 9.68336463e-02f, -1.08928226e-01f, -2.30492502e-02f, 2.16228902e-01f, 9.20312628e-02f,
  5.94647288e-01f, -4.58977558e-02f, -2.56200016e-01f, -7.49823093e-01f, -2.70646393e-01f, 2.60202318e-01f, -1.43080980e-01f, -1.97193876e-01f, -1.75324351e-01f, -2.88375348e-01f,
  -4.48274314e-01f, 1.50795236e-01f, 6.28836036e-01f, -6.36605442e-01f, 1.02222776e+00f, 8.51175606e-01f, -3.74727339e-01f, -3.20182949e-01f, 3.84822041e-02f, -1.10806748e-01f,
  -6.45669624e-02f, -2.53548414e-01f, -2.23302677e-01f, -4.05322671e-01f, -5.47219276e-01f, -6.18994951e-01f, -7.32672587e-02f, -1.14701144e-01f, -8.43210757e-01f, 2.17837412e-02f,
  -2.22839639e-01f, -5.04475506e-03f, -1.37751222e-01f, 5.38038127e-02f, 5.16107120e-02f, -1.57780815e-02f, -1.31864712e-01f, 1.86414614e-01f, -3.99480313e-02f, 4.10848483e-02f,
  2.76081651e-01f, 2.14606628e-01f, -1.31682456e-01f, 1.58930168e-01f, -1.43073156e-01f, -2.79100478e-01f, -1.16597600e-01f, -1.79757074e-01f, -7.54179284e-02f, 1.83224618e-01f,
  6.11061370e-03f, -3.36327823e-03f, -1.66294083e-01f, -8.98727849e-02f, -1.42725527e-01f, -1.73169807e-01f, 1.09364644e-01f, 1.28162414e-01f, -1.08876869e-01f, 1.31307855e-01f,
  2.00901166e-01f, 2.71912158e-01f, 9.73286107e-02f, -6.53618574e-02f, 4.69220169e-02f, -2.22060621e-01f, 1.10031061e-01f, 2.59822439e-02f, 8.51943344e-03f, 4.08902392e-02f,
  -2.36845821e-01f, -6.31698519e-02f, 1.67471562e-02f, 6.12472035e-02f, -4.51126173e-02f, 1.85531229e-01f, 6.18761145e-02f, 5.48412837e-02f, -7.78928995e-02f, -2.83694663e-03f,
  -1.52480543e-01f, -5.52715734e-03f, -2.62924563e-02f, -2.45136678e-01f, -1.20580181e-01f, 5.38045727e-02f, -9.75062624e-02f, 9.83027462e-03f, -7.93115497e-02f, 1.76473156e-01f,
  6.42785579e-02f, 2.85994202e-01f, -1.28347933e-01f, -4.14583571e-02f, -9.85504016e-02f, 8.20529088e-02f, 7.17800260e-02f, -1.21215656e-01f, 2.04846292e-05f, 1.45482123e-01f,
  -7.23887384e-02f, -3.48902196e-02f, -2.82914042e-02f, -7.28277713e-02f, 1.43861145e-01f, -2.37646908e-01f, -2.59125978e-02f, -1.66007492e-03f, 6.19508103e-02f, 1.20384678e-01f,
  -4.04803827e-03f, 1.31035194e-01f, 9.31248665e-02f, -1.56031057e-01f, -6.68639466e-02f, 1.71397917e-03f, 2.36637935e-01f, -9.90155116e-02f, 8.27140734e-02f, -8.15968588e-02f,
  -1.05908918e+00f, -3.28601241e-01f, -8.23306024e-01f, -1.97332114e-01f, -6.20743275e-01f, -5.26605248e-01f, -1.51601955e-01f, -4.60040867e-01f, -3.53382051e-01f, 6.27797604e-01f,
  1.70595095e-01f, -5.53076208e-01f, 3.96404654e-01f, -1.36371940e-01f, -9.40352976e-01f, 2.95388609e-01f, 6.55414909e-02f, 1.70544714e-01f, -3.83498341e-01f, -2.34055191e-01f,
  -4.18676823e-01f, -1.47333354e-01f, -1.72178894e-01f, -7.92511255e-02f, -3.74737173e-01f, -1.39604881e-01f, 7.36816049e-01f, -1.40120372e-01f, -7.51801208e-02f, -2.99831510e-01f,
  -4.48165447e-01f, -3.62074345e-01f, 5.39906621e-02f, -6.24273829e-02f, -7.59564042e-02f, 1.38148800e-01f, 8.73051435e-02f, -4.61150035e-02f, -4.92529981e-02f, -2.13842675e-01f,
  1.33808419e-01f, -1.52724251e-01f, -2.12721735e-01f, -1.30233448e-02f, -8.30948651e-02f, -1.22272812e-01f, -2.32270852e-01f, -6.11897632e-02f, -1.56356454e-01f, -1.81449369e-01f,
  -2.58153319e-01f, -5.31595275e-02f, 1.32370815e-01f, 6.53359219e-02f, -1.28689826e-01f, -1.48112088e-01f, 1.58856526e-01f, -3.89045308e-04f, -1.13456517e-01f, -1.86173514e-01f,
  -5.24462461e-02f, 8.01116973e-02f, -1.56096537e-02f, -9.84445214e-02f, -1.92933723e-01f, 1.53715527e-02f, 6.28004372e-02f, 4.20596637e-02f, 2.86834724e-02f, -8.00704286e-02f,
  -1.27651736e-01f, -2.10703462e-02f, -5.51433153e-02f, 9.58604440e-02f, -2.08865851e-02f, 1.24395542e-01f, 6.10981844e-02f, -9.94321033e-02f, -5.57103753e-02f, -1.76662803e-02f,
  -4.25450962e-05f, -3.10032852e-02f, -7.44292885e-02f, 1.61057726e-01f, -5.46836667e-02f, -8.26331750e-02f, 9.26171765e-02f, -6.35977983e-02f, 2.03453079e-01f, -8.87600891e-03f,
  -4.68896702e-03f, -9.74966288e-02f, -8.15546811e-02f, -8.16070959e-02f, 1.12152249e-01f, -2.33412627e-02f, -3.73602882e-02f, -1.02273472e-01f, -1.78462192e-01f, -7.42590129e-02f,
  5.97248301e-02f, 2.91694343e-01f, -1.29235219e-02f, -7.78284715e-03f, -9.31584509e-04f, 2.12973151e-02f, 1.50697783e-01f, 1.31641090e-01f, 9.54448357e-02f, 3.30338962e-02f,
  1.89793557e-01f, 6.09012991e-02f, -9.11053866e-02f, 7.14278296e-02f, 2.18416408e-01f, 1.43749624e-01f, 2.15457324e-02f, -8.65022242e-02f, 1.70841832e-02f, -1.32840583e-02f,
  1.51663767e-02f, 1.25489509e+00f, 1.30348161e-01f, 9.69619930e-01f, -6.71334267e-01f, 2.33534664e-01f, 5.65549791e-01f, 1.03086077e-01f, 5.44075727e-01f, 7.01825857e-01f,
  -5.63144274e-02f, 5.44480622e-01f, 2.49647632e-01f, 6.32808864e-01f, -4.06140447e-01f, 5.01007855e-01f, 9.19533730e-01f, 5.21893322e-01f, -6.69473037e-02f, 5.90035915e-01f,
  1.83347747e-01f, 3.24181825e-01f, 1.28343463e-01f, -7.15547577e-02f, -2.09150948e-02f, 8.40841606e-02f, -1.29521400e-01f, -3.85357171e-01f, 2.31149971e-01f, -2.64353871e-01f,
  -8.22292864e-02f, 1.71019018e-01f, -2.92952289e-03f, 2.64657363e-02f, 1.17469467e-01f, -7.62604848e-02f, 3.99857806e-03f, -1.90579504e-01f, -1.76689923e-01f, 7.89389610e-02f,
  2.77512651e-02f, -1.04171835e-01f, 1.18969165e-01f, -1.69925839e-01f, -4.76938039e-02f, -8.39885399e-02f, -3.05832755e-02f, -4.66310494e-02f, 1.24519179e-02f, -7.50807449e-02f,
  7.49122060e-04f, -5.03985286e-02f, 1.11774704e-03f, 1.15143582e-01f, -6.56723604e-02f, 4.18631099e-02f, 1.77683532e-01f, 2.65244171e-02f, 2.35702693e-02f, 4.76975478e-02f,
  1.55250980e-02f, 8.46002325e-02f, 8.59713927e-02f, -1.40227675e-01f, 1.80549230e-02f, -1.81464687e-01f, 2.24360805e-02f, -9.65403393e-02f, -5.12545332e-02f, 3.24270092e-02f,
  -2.64853220e-02f, -1.34945670e-02f, -7.49229938e-02f, 9.28445086e-02f, 1.15659624e-01f, 1.19677611e-01f, -4.50906828e-02f, -2.38502752e-02f, 6.09754585e-02f, -1.98844932e-02f,
  2.36945748e-02f, -5.38609065e-02f, 4.78362963e-02f, -4.75268662e-02f, 3.27150002e-02f, -1.95564590e-02f, 6.54491633e-02f, -2.38026194e-02f, -9.70568508e-03f, -8.19327161e-02f,
  3.95628482e-01f, 9.17020321e-01f, 1.93981409e-01f, -8.18505138e-02f, 1.11409716e-01f, 1.92141160e-02f, 4.56630290e-02f, 7.61218816e-02f, 2.39369601e-01f, -4.46332106e-03f,
  1.57170594e-02f, 1.33136988e-01f, 6.85601234e-02f, -1.19856067e-01f, 2.06547845e-02f, 1.27271220e-01f, 2.64464110e-01f, 7.67462328e-02f, 2.32185155e-01f, 3.95656861e-02f,
  3.81094851e-02f, 1.82245746e-01f, -1.58545226e-02f, 5.25865480e-02f, 1.41053632e-01f, -1.62218288e-02f, 2.30434947e-02f, -1.27782822e-01f, -1.17777847e-01f, 1.18707933e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.31155944e+00f, 9.89854932e-01f, 4.69389230e-01f, 7.07942843e-01f, 5.17156780e-01f, 8.30019772e-01f, 5.15665174e-01f, 9.13140416e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -8.44928682e-01f, -1.90741390e-01f, -7.22655654e-01f, -2.59866267e-01f, -1.59598157e-01f, -6.30472124e-01f, 4.00960334e-02f, -2.59984970e-01f, -9.42079246e-01f, -4.26759034e-01f,
  -3.08732778e-01f, -2.47727428e-02f, 5.57455838e-01f, -4.98525530e-01f, -1.00439206e-01f, 7.69693434e-01f, 1.11147031e-01f, 1.77024454e-01f, 5.78404605e-01f, -3.99007052e-01f,
  -3.47891122e-01f, 4.04759437e-01f, -5.02169013e-01f, 5.52664977e-03f, -7.88278040e-03f, -9.30288553e-01f, 3.44294727e-01f, -8.57133806e-01f, 6.93935081e-02f, -9.47897136e-01f,
  9.91462290e-01f, 6.10481620e-01f, 3.92838955e-01f, -5.83806157e-01f, 5.10026693e-01f, -9.69063997e-01f, 1.95225969e-01f, -1.10167873e+00f, 1.19579233e-01f, 5.07523417e-01f,
  3.36445928e-01f, -1.10973656e+00f, -5.17664440e-02f, 4.90426868e-01f, 7.58722782e-01f, -6.49402678e-01f, -1.06479084e+00f, 8.26360762e-01f, -2.37572983e-01f, 2.96790123e-01f,
  -1.03025148e-02f, -2.27790713e-01f, 3.97811413e-01f, 1.55816332e-01f, -1.35903037e+00f, -1.20765996e+00f, -7.14319229e-01f, -3.83535832e-01f, -1.06329429e+00f, 6.29831016e-01f,
  4.54811037e-01f, 1.72070771e-01f, -7.88396955e-01f, 2.26311252e-01f, 2.64701433e-02f, 2.63646096e-01f, -2.05610842e-02f, 2.90860951e-01f, 4.75967526e-02f, 1.17335878e-01f,
  4.90171671e-01f, -1.50737122e-01f, -7.04784334e-01f, 2.38811761e-01f, -2.75043696e-01f, -6.30450368e-01f, -2.43611053e-01f, -3.16244960e-01f, 5.74799836e-01f, 7.52207458e-01f,
  4.23842818e-01f, -6.06154576e-02f, -6.93025231e-01f, -8.22108209e-01f, 7.81473994e-01f, 2.33987212e-01f, 1.01028442e+00f, 6.07281446e-01f, -1.00563800e+00f, -7.17989802e-01f,
  -4.60860997e-01f, 7.56025970e-01f, 7.53841043e-01f, -9.68997240e-01f, -7.68954933e-01f, -1.29946935e+00f, -7.02243030e-01f, -3.38855409e-03f, -2.57806908e-02f, -8.63927305e-02f,
  -6.84547067e-01f, 7.67806172e-02f, 3.61559391e-01f, 8.83251987e-03f, 2.33456925e-01f, 1.88808933e-01f, -1.96310073e-01f, -1.30880201e+00f, -1.07783699e+00f, -1.68076515e-01f,
  -1.67025536e-01f, -5.88422537e-01f, -4.96426880e-01f, -2.65833437e-01f, -1.23020267e+00f, -6.15973771e-01f, -4.01491858e-02f, -6.76084936e-01f, -3.52821738e-01f, -4.95296240e-01f,
  6.40812814e-01f, -4.65512455e-01f, 1.04407549e+00f, -1.29142058e+00f, -9.57652450e-01f, -5.76948583e-01f, 1.50413215e-01f, -6.64054394e-01f, 3.05511951e-01f, -2.57403031e-02f,
  -9.26781297e-01f, 3.07912648e-01f, 9.65683818e-01f, 2.93833435e-01f, 8.48677903e-02f, 2.43677303e-01f, -4.00090992e-01f, 4.39732134e-01f, 2.96802461e-01f, 8.45648408e-01f,
  1.01663923e+00f, 6.90654933e-01f, -8.63373935e-01f, -5.46545744e-01f, 4.41128910e-01f, 1.28112854e-02f, 1.04798222e+00f, -1.14782907e-01f, -9.10960972e-01f, 1.11325479e+00f,
  3.56248468e-01f, 6.00192130e-01f, 8.62494886e-01f, 4.21417281e-02f, 5.14565527e-01f, -9.77514312e-02f, -3.19662482e-01f, -1.67838503e-02f, -8.47220004e-01f, -1.17526448e+00f,
  3.50260228e-01f, 7.91640282e-01f, 2.99683809e-01f, 5.70664167e-01f, 7.62356102e-01f, 1.09995380e-01f, -7.34909952e-01f, -3.76108699e-02f, 8.21661651e-01f, -4.62679446e-01f,
  1.02420613e-01f, 6.85877144e-01f, -3.60505164e-01f, 4.55132008e-01f, -1.43554360e-01f, -1.43371731e-01f, -4.12273586e-01f, 1.10231972e+00f, 5.41537464e-01f, 9.36093271e-01f,
  -2.33209744e-01f, 1.17801523e+00f, 5.19877188e-02f, 2.91339189e-01f, -1.39870858e+00f, -3.13710481e-01f, 3.17812972e-02f, -8.63912880e-01f, -1.19960904e+00f, 5.45780063e-01f,
  -4.64152753e-01f, 1.08411026e+00f, 7.71085680e-01f, 4.64979559e-01f, 4.69996959e-01f, 3.40877399e-02f, -7.07218170e-01f, 6.65947378e-01f, -8.89720917e-02f, 3.95520806e-01f,
  -8.37651134e-01f, 8.60909641e-01f, 4.86169249e-01f, -2.22540811e-01f, -3.16478878e-01f, -1.44661939e+00f, 5.23600221e-01f, -1.28951776e+00f, 1.29425287e+00f, -3.28520954e-01f,
  6.32716179e-01f, 1.41019237e+00f, 1.29784763e+00f, -7.41641879e-01f, -1.26433325e+00f, 1.03602278e+00f, -6.91036284e-01f, 3.48137528e-01f, -5.90949655e-01f, 4.38799351e-01f,
  -8.24483633e-01f, -2.25601494e-01f, -6.14289641e-01f, -4.03980851e-01f, -4.25384901e-02f, -3.94844145e-01f, -6.48402393e-01f, -4.28066701e-01f, 4.59643662e-01f, -1.83863729e-01f,
  -1.46326870e-02f, -4.46504891e-01f, -6.42921031e-02f, -4.43814784e-01f, -7.14582384e-01f, -1.14524744e-01f, -6.01758897e-01f, 1.33238524e-01f, 6.01547837e-01f, -2.68597007e-01f,
  -9.45008360e-03f, -2.72122294e-01f, -4.86951172e-01f, -5.20380497e-01f, 5.26052237e-01f, -2.12713927e-01f, -2.87077688e-02f, -4.60481197e-01f, -5.75255632e-01f, 3.80738318e-01f,
  4.16889740e-03f, -6.10001922e-01f, -1.69297129e-01f, 7.60766923e-01f, 5.33593595e-01f, -8.37871730e-01f, -3.06465104e-02f, -3.15329403e-01f, -8.15290451e-01f, -1.38509452e-01f,
  -2.65197784e-01f, -6.67801127e-02f, -5.18398464e-01f, -2.65634567e-01f, 8.65175724e-02f, 1.24483883e-01f, -5.64792752e-01f, 9.38359872e-02f, -8.24081779e-01f, -4.09437865e-01f,
  7.53786445e-01f, -9.38084483e-01f, -7.55233288e-01f, -8.36764395e-01f, -6.51462018e-01f, 8.15607786e-01f, -9.75294709e-01f, -2.38950595e-01f, 1.04189813e+00f, 1.31541431e-01f,
  1.72544152e-01f, -7.05974281e-01f, -4.64837253e-01f, -1.17134295e-01f, 7.10397005e-01f, -2.66167611e-01f, -6.47118390e-01f, 3.71920615e-01f, -7.49892414e-01f, -1.55684710e-01f,
  8.23386192e-01f, 8.01964164e-01f, -9.33951497e-01f, 5.94178557e-01f, -1.75032511e-01f, 5.25559604e-01f, 7.70051301e-01f, 9.56923291e-02f, 4.95249510e-01f, -6.01162136e-01f,
  1.01586390e+00f, 1.45177388e+00f, -2.75660872e-01f, 7.91394293e-01f, 7.72961438e-01f, 8.66584897e-01f, 8.05759013e-01f, -1.04262245e+00f, -7.71178126e-01f, -1.09372139e+00f,
  7.95965075e-01f, 6.89356267e-01f, -1.02782547e+00f, 3.08781654e-01f, -9.61302757e-01f, -5.62271237e-01f, -2.88840421e-02f, 5.62254131e-01f, -9.70731080e-02f, -8.94002974e-01f,
  2.74249047e-01f, -2.73198951e-02f, 3.67615193e-01f, -1.74278561e-02f, -1.97780654e-01f, 8.15368369e-02f, -6.34867668e-01f, 2.05386847e-01f, 2.13135928e-02f, 3.13349105e-02f,
  9.99170989e-02f, 2.41082743e-01f, -4.65490818e-01f, 8.04576755e-01f, 6.65252566e-01f, 8.28671038e-01f, -7.11145461e-01f, -4.99426305e-01f, -3.32849324e-01f, 5.72392568e-02f,
  4.98197705e-01f, -3.86984229e-01f, 2.84525380e-02f, -8.18662286e-01f, 5.15268683e-01f, -6.37234151e-01f, -6.13228679e-01f, 8.30749273e-01f, -9.48824525e-01f, -5.60842097e-01f,
  7.84242332e-01f, -4.89009827e-01f, -8.71408135e-02f, 1.36748075e-01f, 9.61615816e-02f, 2.77316511e-01f, 5.93033712e-03f, -5.12116492e-01f, 4.40954983e-01f, -7.17921972e-01f,
  1.80245787e-01f, 1.85215086e-01f, 1.09012928e-02f, 3.06700975e-01f, -4.39101994e-01f, -2.64346689e-01f, -6.99131906e-01f, 2.14907140e-01f, -7.49596596e-01f, -6.30027711e-01f,
  -6.37862384e-01f, 3.24129879e-01f, -1.31938860e-01f, -5.97854793e-01f, 5.20695031e-01f, -7.24251330e-01f, -1.59895554e-01f, 1.21424878e+00f, -5.66030324e-01f, -6.82270050e-01f,
  -7.23971009e-01f, -1.04587460e+00f, -3.37022036e-01f, 4.17041689e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.95486113e-01f, -4.72317599e-02f, -1.12932369e-01f, -9.76074934e-02f, 6.78205267e-02f, 7.44031221e-02f, 5.21832168e-01f, -4.53060091e-01f, -3.51762623e-01f, 4.34427440e-01f,
  -7.20349327e-02f, 3.97449695e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    