/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.77323717e-01f, 5.55201545e-02f, 2.20047489e-01f, 1.61033332e-01f, 6.91258162e-02f, -2.90859584e-02f, -1.46913216e-01f, 1.53133180e-02f, 1.15418941e-01f, -5.32859517e-03f,
  -3.88688780e-02f, -1.87897563e-01f, -2.19385758e-01f, -1.31504729e-01f, -1.35686785e-01f, -2.07399148e-02f, 1.56211173e-02f, -5.96132465e-02f, -2.09458962e-01f, -2.55061448e-01f,
  -1.21753469e-01f, -2.45377012e-02f, 7.24895671e-02f, 4.50633466e-02f, 1.83245987e-02f, -1.16526626e-01f, 1.12925634e-01f, 1.09054781e-01f, -6.33530989e-02f, -2.20277682e-01f,
  -2.06573606e-01f, 3.40748250e-01f, -1.19279981e-01f, -7.47779608e-02f, 3.81895788e-02f, 3.03157493e-02f, -6.21172972e-02f, 1.27454236e-01f, 6.07294254e-02f, 9.43835974e-02f,
  -3.36359022e-03f, 3.43356095e-02f, 1.82163883e-02f, 1.20155215e-02f, 6.26096576e-02f, 5.13197146e-02f, 7.94026181e-02f, 1.45739064e-01f, 4.09244746e-02f, 6.61897659e-02f,
  -1.27859026e-01f, 4.37933905e-03f, 1.47592083e-01f, 8.92651603e-02f, 1.54705316e-01f, -4.84470315e-02f, 3.80715169e-02f, 4.38206317e-03f, 1.16110258e-01f, 5.56401424e-02f,
  -1.37641162e-01f, 4.37826850e-03f, -2.43145190e-02f, -4.45907749e-03f, -2.52267215e-02f, 4.78374511e-02f, 7.69587280e-03f, -2.85068490e-02f, -2.84014866e-02f, 1.74627379e-02f,
  8.93959682e-03f, -8.70963279e-03f, -4.30723950e-02f, 7.05906600e-02f, -3.32361013e-02f, 1.54492464e-02f, 2.11652704e-02f, -8.71797428e-02f, 1.00179352e-01f, 5.96892647e-02f,
  3.58131491e-02f, 4.09328677e-02f, 8.14097673e-02f, -3.70940380e-02f, 2.41144225e-02f, -1.35105578e-02f, 2.22252663e-02f, 9.25463799e-04f, -2.32457910e-02f, 6.15698576e-04f,
  -6.07989393e-02f, 6.80420026e-02f, -1.78318501e-01f, 2.51818565e-03f, 9.02259815e-03f, 3.55460532e-02f, -5.52225970e-02f, 1.70472302e-02f, 1.06560122e-02f, -1.06554106e-01f,
  1.25620766e-02f, -1.96006838e-02f, 2.49673743e-02f, -3.01424880e-03f, -4.55319025e-02f, -6.00580722e-02f, -1.12108346e-02f, -8.68886784e-02f, 5.10409214e-02f, 7.53832161e-02f,
  1.27345948e-02f, -4.74353544e-02f, -1.80467486e-01f, -8.07346329e-02f, -5.12230843e-02f, -1.03916250e-01f, -1.36028036e-01f, -1.73243642e-01f, -1.85407192e-01f, -2.04455093e-01f,
  -6.71682283e-02f, 1.30959958e-01f, 2.56564617e-01f, -2.96345968e-02f, -7.94020966e-02f, 2.43990004e-01f, 5.33913553e-01f, 1.98953286e-01f, -1.49329141e-01f, 9.38981473e-02f,
  -2.30240479e-01f, -3.32313538e-01f, -2.36643657e-01f, -9.76806805e-02f, 2.58610338e-01f, 3.90512675e-01f, 3.22101593e-01f, 2.72920281e-01f, 8.63914266e-02f, 1.64780483e-01f,
  -1.59227122e-02f, 9.97242332e-02f, 8.57026502e-02f, -4.54271976e-05f, -1.29158556e-01f, -1.93361208e-01f, 4.44735624e-02f, -1.14514247e-01f, -1.85361877e-02f, -1.72760174e-01f,
  -3.02742541e-01f, -2.21028290e-06f, 5.77179715e-02f, -9.48531106e-02f, -7.43499249e-02f, -5.17166592e-02f, 3.59128155e-02f, -2.05004551e-02f, -9.38938558e-02f, -1.42809271e-03f,
  -8.19999948e-02f, -4.37444709e-02f, 4.17778781e-03f, -6.52008355e-02f, 5.99409267e-02f, 1.28037222e-02f, 4.08297479e-02f, 1.00671068e-01f, 3.60447131e-02f, 1.61927510e-02f,
  -1.29346505e-01f, -1.11849895e-02f, -5.51468693e-02f, 9.96263102e-02f, 1.49446845e-01f, 3.87625000e-03f, -1.22829741e-02f, -4.47109342e-02f, 4.43232879e-02f, 9.37332958e-03f,
  2.63356734e-02f, -3.55221331e-02f, -1.18135596e-02f, -1.49469106e-02f, -4.05516885e-02f, 8.44146777e-03f, -8.47694091e-03f, 3.94069962e-03f, 8.68879724e-03f, 5.02826311e-02f,
  3.41623165e-02f, 8.03102367e-03f, 8.91045332e-02f, 2.85231061e-02f, -2.47354656e-02f, 3.64135318e-02f, 2.81101037e-02f, 5.85495532e-02f, -1.58496369e-02f, 7.76261231e-03f,
  1.27070248e-02f, -2.59530917e-02f, -1.17258413e-03f, -1.44889271e-02f, 2.69971229e-02f, 6.28645048e-02f, -6.05632663e-02f, -1.82133242e-02f, -9.12956595e-02f, 3.23492475e-02f,
  -1.95500001e-01f, 2.07882464e-01f, -1.35795385e-01f, 4.25728858e-02f, -5.45753241e-02f, 7.37978518e-03f, -1.05721913e-01f, 3.85270603e-02f, -1.19983852e-01f, -8.06795247e-03f,
  -1.97960753e-02f, 3.98805588e-02f, -8.83489847e-03f, 9.72259045e-03f, 4.12674733e-02f, 6.20604446e-03f, 2.98642404e-02f, -6.77637681e-02f, 6.56334311e-02f, -3.59598286e-02f,
  5.67279868e-02f, 5.63267283e-02f, -1.60562210e-02f, -4.48720008e-02f, -8.09293240e-02f, 1.25237170e-03f, 1.84291434e-02f, -9.43240747e-02f, 2.00761706e-01f, 7.97411725e-02f,
  -3.77650470e-01f, 2.41569221e-01f, -2.26170957e-01f, -5.56298019e-03f, -1.43800557e-01f, -1.65760294e-01f, -1.93425074e-01f, -8.01164135e-02f, 6.39713258e-02f, 1.39329117e-02f,
  1.20935040e-02f, 1.20602548e-02f, -4.83907796e-02f, -7.22380951e-02f, -1.25232786e-01f, -7.61181191e-02f, -1.35943055e-01f, -2.40417540e-01f, -2.64635921e-01f, -4.08491530e-02f,
  2.74256375e-02f, 6.79910034e-02f, -1.38281390e-01f, -1.64086409e-02f, 2.27629751e-01f, 7.02620894e-02f, 1.44587755e-01f, 2.08129101e-02f, 1.96055442e-01f, 3.75770301e-01f,
  1.32136077e-01f, 1.20198794e-01f, -1.98639914e-01f, -2.01108716e-02f, -2.93717217e-02f, 1.74909662e-02f, -2.88923364e-02f, -2.90373601e-02f, -6.45545200e-02f, -7.43482411e-02f,
  -1.06664263e-01f, -3.95766944e-02f, -7.56357759e-02f, 5.15876785e-02f, 1.28444051e-02f, -2.38200258e-02f, -7.89753273e-02f, 2.27535460e-02f, -8.52928311e-02f, 9.40841213e-02f,
  1.24567084e-01f, -5.34632429e-02f, -2.02418432e-01f, -1.16618410e-01f, -1.08738080e-01f, -1.37206122e-01f, 6.66687712e-02f, 7.84245282e-02f, -5.63685372e-02f, 1.64202541e-01f,
  4.62922789e-02f, -5.96106537e-02f, 4.68289815e-02f, 3.98642793e-02f, -1.79170594e-02f, -4.50983644e-02f, -9.23054758e-03f, 2.39950456e-02f, 2.72516720e-02f, -6.96023926e-02f,
  -3.70164402e-02f, 7.02440068e-02f, -3.03321914e-03f, -4.36611436e-02f, 8.82926658e-02f, -3.41998087e-03f, -4.09084605e-04f, 1.37042210e-01f, 3.44124623e-02f, 3.76218148e-02f,
  -2.59371009e-02f, -4.10093218e-02f, -5.58964722e-03f, 3.99113223e-02f, 2.77461018e-02f, 4.86000441e-03f, -1.45788286e-02f, -3.02917790e-02f, -1.38259877e-03f, -4.24528010e-02f,
  4.05405760e-02f, -2.49795243e-01f, 1.33246019e-01f, -2.57074796e-02f, -6.08886145e-02f, 3.86018269e-02f, 9.87334326e-02f, -2.52707414e-02f, 8.35520104e-02f, 2.32159230e-03f,
  -8.63635726e-03f, -5.99140897e-02f, -7.82534014e-03f, -1.08498950e-02f, -5.38610034e-02f, -1.99874248e-02f, -5.73474765e-02f, -7.77398869e-02f, 3.57408612e-03f, 9.65342373e-02f,
  -2.40920521e-02f, -2.03349441e-01f, -1.40550137e-01f, -8.86621624e-02f, -2.85995044e-02f, -2.05864727e-01f, -2.60240193e-02f, 7.98566490e-02f, -1.45667821e-01f, -5.02851270e-02f,
  -3.39032547e-03f, -3.67553622e-01f, -2.86222935e-01f, 7.36807510e-02f, 4.36192483e-01f, 2.73944646e-01f, 1.40650868e-01f, 1.88440159e-02f, -8.23818743e-02f, -6.65476471e-02f,
  8.39589834e-02f, 9.32677984e-02f, -6.57990351e-02f, -1.23116970e-01f, -1.05777360e-01f, -3.06873918e-01f, -3.11931729e-01f, -1.10209651e-01f, 2.51718223e-01f, 4.04548734e-01f,
  2.70392090e-01f, 2.49410167e-01f, 1.46599978e-01f, -6.73319548e-02f, -5.71019799e-02f, 1.14766926e-01f, -2.21373260e-01f, 4.89477329e-02f, -7.31531018e-03f, -3.74640971e-01f,
  -1.51710451e-01f, -3.16229641e-01f, 2.26115704e-01f, 1.26191169e-01f, 2.97917854e-02f, -1.09708987e-01f, 3.13068293e-02f, -1.56490684e-01f, 8.67083017e-03f, -1.19397379e-01f,
  1.56309400e-02f, -3.69155314e-03f, -3.38771865e-02f, 1.91943087e-02f, -1.45244726e-03f, 8.91254283e-03f, -1.71676695e-01f, -2.11705238e-01f, -1.41757458e-01f, -5.76711968e-02f,
  1.14791997e-01f, 6.18305504e-02f, -4.97613810e-02f, 1.98324472e-02f, -1.53343394e-01f, 1.46389946e-01f, -6.75971881e-02f, -1.06758073e-01f, -8.52435976e-02f, -1.53313130e-01f,
  6.99372366e-02f, -2.37203408e-02f, -8.50215461e-03f, 1.96939912e-02f, -8.62225983e-03f, 1.74103267e-02f, -2.25820094e-02f, 6.03080466e-02f, 4.75615524e-02f, -1.70748346e-02f,
  8.66198540e-03f, 1.56473871e-02f, -2.94057708e-02f, -6.45022886e-03f, -1.80147626e-02f, -6.05746619e-02f, 6.47886619e-02f, -2.11495440e-02f, 1.42337810e-02f, -4.63822782e-02f,
  4.38987240e-02f, 2.64263507e-02f, 3.68804447e-02f, -8.61663669e-02f, -3.26687917e-02f, -7.92521611e-02f, 3.16755436e-02f, 2.96582356e-02f, -4.62348294e-03f, 1.16540259e-02f,
  8.88947770e-02f, 1.87825605e-01f, -1.91342711e-01f, -1.22621201e-01f, -1.50691289e-02f, -3.47256288e-02f, 1.49694802e-02f, 1.25233177e-02f, -7.10607553e-03f, -1.79635093e-03f,
  6.91342726e-02f, -9.98809002e-03f, -3.04523073e-02f, -1.84376817e-02f, 1.38913959e-01f, 1.21677816e-02f, 3.32231037e-02f, -2.57360116e-02f, 2.47206399e-03f, -3.61653008e-02f,
  -4.11815234e-02f, 1.54144242e-01f, 1.30450636e-01f, 1.07505042e-02f, 7.20764920e-02f, 2.16954470e-01f, 1.16073653e-01f, 6.01993911e-02f, 6.72424659e-02f, 1.11120403e-01f,
  -6.00755632e-01f, 2.33855680e-01f, 3.42632622e-01f, -2.76719868e-01f, 1.83942065e-01f, 3.76493424e-01f, 4.76477653e-01f, 1.30375251e-01f, -1.18638508e-01f, 1.56334117e-01f,
  -1.38058707e-01f, -3.98076057e-01f, -3.34341019e-01f, -2.05894634e-01f, 4.76368703e-03f, 2.88899899e-01f, 2.73586839e-01f, -3.00866384e-02f, -2.31675059e-01f, -3.98521079e-03f,
  -2.52022371e-02f, -1.28898159e-01f, -2.73460060e-01f, -5.52287176e-02f, 9.00274962e-02f, -1.35709926e-01f, 2.16458514e-01f, -5.77921011e-02f, 8.57919678e-02f, 1.01354524e-01f,
  -3.35545242e-02f, -1.95126124e-02f, -6.14196472e-02f, -1.02550820e-01f, -2.93141454e-02f, -2.08874438e-02f, -4.94839214e-02f, 7.04173790e-03f, 2.38857269e-02f, 4.28421199e-02f,
  -1.13239959e-01f, -7.13063916e-03f, -1.27582446e-01f, 4.89763357e-02f, 1.36205722e-02f, 3.17493491e-02f, 7.29348361e-02f, -7.83338025e-02f, -1.99805554e-02f, 1.02868386e-01f,
  7.82955959e-02f, 3.50608528e-02f, 3.33102755e-02f, 1.09063342e-01f, 4.67046024e-03f, -6.54857308e-02f, 1.28470048e-01f, 3.88136990e-02f, 8.62435922e-02f, -7.12356195e-02f,
  8.45392933e-04f, -5.34201749e-02f, 8.70893300e-02f, -5.04250079e-03f, 2.08781082e-02f, 6.23206189e-03f, 2.66683809e-02f, 2.41037346e-02f, -1.45438628e-03f, -7.30772736e-03f,
  2.44643055e-02f, 3.20934542e-02f, 1.86615693e-03f, -3.99823338e-02f, -6.93932921e-02f, 7.78951123e-02f, -3.12184598e-02f, -2.86263749e-02f, 1.02516990e-02f, 3.05312015e-02f,
  -8.78480170e-03f, 4.19954807e-02f, -2.57808045e-02f, 1.70922466e-03f, 4.45726141e-02f, -7.15710397e-04f, -2.09465120e-02f, 7.02911466e-02f, -3.76501717e-02f, -1.11815566e-02f,
  -2.83151150e-01f, 8.32093507e-02f, -1.17062010e-01f, -1.23735450e-01f, 5.48964068e-02f, -3.49759385e-02f, -6.30258247e-02f, -4.61825393e-02f, -7.31659234e-02f, -2.47642752e-02f,
  9.75493528e-03f, -1.05202951e-01f, 5.36316894e-02f, 2.63472907e-02f, -5.94896413e-02f, -1.10614356e-02f, 2.77473014e-02f, -8.66509974e-02f, 5.09237591e-03f, -1.99923050e-02f,
  7.57033378e-02f, 4.08463888e-02f, -8.42062086e-02f, -4.38318588e-02f, -4.62921113e-02f, -8.89666080e-02f, -2.36843433e-02f, 8.17834958e-03f, -6.03706837e-02f, -9.70964804e-02f,
  8.13036598e-03f, 2.67688513e-01f, 5.60777247e-01f, 1.84289753e-01f, 2.17443258e-01f, 1.15289740e-01f, 1.99386239e-01f, -8.33053440e-02f, -2.64480077e-02f, 2.17731014e-01f,
  9.63304341e-02f, -2.25695625e-01f, -1.40645683e-01f, -1.58912644e-01f, -1.55758664e-01f, 2.01013193e-01f, 2.45879486e-01f, 1.47008985e-01f, -2.27563858e-01f, -1.49644822e-01f,
  -8.16711858e-02f, 5.34732528e-02f, -1.66503176e-01f, -1.05846904e-01f, 1.52249768e-01f, 3.87608376e-03f, 1.85942158e-01f, -1.32659897e-02f, 7.17823431e-02f, 3.69307429e-01f,
  3.06240678e-01f, 1.54034078e-01f, -1.12490535e-01f, -2.72141453e-02f, 5.91936857e-02f, -1.01399377e-01f, -6.03802130e-03f, -3.13389413e-02f, -7.57246166e-02f, 2.64103040e-02f,
  7.94863328e-02f, -2.24552415e-02f, 6.04362637e-02f, -8.58885273e-02f, 4.71535623e-02f, -4.11627628e-02f, -4.87109609e-02f, -6.53247535e-02f, -5.52099477e-03f, 6.54788092e-02f,
  8.11288729e-02f, 1.64664984e-01f, 1.58294559e-01f, -2.93173697e-02f, -2.73600705e-02f, 6.85053915e-02f, -2.76279519e-03f, -2.87148226e-02f, -7.96124339e-02f, 1.40654817e-02f,
  -1.35970330e-02f, 2.15813331e-02f, 2.93908790e-02f, -1.93155110e-02f, -4.04380858e-02f, 1.31527893e-02f, 6.71294630e-02f, -1.21201538e-02f, -6.73842942e-03f, 6.75909687e-04f,
  -2.06892826e-02f, 4.98498902e-02f, -3.02293189e-02f, 2.81493850e-02f, 4.49601747e-02f, 3.98697630e-02f, -1.25423037e-02f, 2.06130240e-02f, -3.78152914e-02f, -2.29649595e-03f,
  -3.64765152e-02f, -4.51958328e-02f, 3.16554420e-02f, -1.49647286e-02f, -1.15213078e-02f, 3.22298408e-02f, 8.46457947e-03f, -4.47437242e-02f, -5.85809350e-02f, 6.12179637e-02f,
  -2.22846344e-01f, -4.50435989e-02f, 1.33875072e-01f, -1.18979178e-01f, 8.12194645e-02f, -3.57105024e-02f, 7.88604394e-02f, -5.94246853e-03f, 3.56733389e-02f, 2.63287080e-03f,
  -8.11417028e-02f, -7.05604348e-03f, 4.97057214e-02f, 4.65899892e-02f, -1.45901293e-02f, 1.76825151e-02f, 1.57578674e-03f, 6.53108433e-02f, -4.95162830e-02f, 1.17990198e-02f,
  -8.72665718e-02f, -9.56071317e-02f, -9.09970477e-02f, 6.15448412e-03f, -1.28984600e-01f, -6.66479021e-02f, 1.00385271e-01f, -4.85985093e-02f, -3.28823254e-02f, -1.40063660e-02f,
  1.53030366e-01f, -9.47258726e-04f, 2.75784843e-02f, 3.35687934e-03f, 1.88783899e-01f, 1.92374930e-01f, 3.14778239e-02f, 9.96708591e-03f, -3.85768339e-02f, 7.23007247e-02f,
  2.26460055e-01f, -3.14033888e-02f, -1.00133866e-01f, -4.41390611e-02f, -1.00106582e-01f, -2.67078608e-01f, -2.19217077e-01f, -2.12975338e-01f, -1.00003481e-01f, 5.78103494e-03f,
  -1.12606911e-02f, 1.75238156e-03f, -1.00105919e-01f, -1.31858036e-01f, -6.86898157e-02f, -1.66481733e-01f, -7.31094405e-02f, 1.36313409e-01f, 9.60216075e-02f, -2.58059472e-01f,
  2.32859720e-02f, 4.23208088e-01f, 4.83137071e-02f, 8.71196538e-02f, 9.11692530e-02f, -6.29890338e-02f, 2.22497750e-02f, 6.66628731e-03f, 2.70779077e-02f, -5.41193075e-02f,
  6.28454387e-02f, 7.26767331e-02f, 3.61976388e-04f, -3.57227655e-05f, 5.99775128e-02f, 5.97582944e-02f, 1.22608982e-01f, -5.75335473e-02f, -4.77930484e-03f, 9.91353169e-02f,
  3.02431565e-02f, 9.90870148e-02f, 1.63431704e-01f, -1.38349719e-02f, 5.16749360e-02f, 1.20050646e-01f, 1.88926265e-01f, 1.56837955e-01f, 1.68600291e-01f, -1.12232221e-02f,
  -7.53288195e-02f, 2.02979241e-03f, 9.01119560e-02f, -1.34912012e-02f, -3.57359345e-03f, -1.18662640e-02f, -3.33081633e-02f, -3.66219021e-02f, -2.55178325e-02f, -3.99730913e-02f,
  6.20579682e-02f, -3.64988372e-02f, 6.20498881e-02f, -1.51216865e-01f, -6.13092910e-03f, -2.66957376e-03f, -1.51799424e-02f, -5.73856384e-02f, -8.40407144e-03f, 7.43631274e-02f,
  5.53782051e-03f, 6.90615177e-03f, 4.30658050e-02f, -1.35997133e-02f, 4.79417071e-02f, 1.42667554e-02f, -1.46318441e-02f, 2.34125927e-02f, 3.40605341e-02f, -9.42060165e-03f,
  -2.56640017e-01f, 2.04254299e-01f, -1.69446021e-01f, -4.78220060e-02f, -2.12679468e-02f, -1.22533282e-02f, -1.77667160e-02f, 5.60525209e-02f, 1.03816334e-02f, 4.58430592e-03f,
  1.53388724e-01f, -4.18706909e-02f, -5.32935485e-02f, -4.89873961e-02f, -4.18274589e-02f, 6.80383220e-02f, -3.81861217e-02f, -8.83756578e-02f, -1.51958419e-02f, 6.98710829e-02f,
  -1.04173332e-01f, -1.08065486e-01f, -1.11766003e-01f, -1.57498166e-01f, -1.01955915e-02f, -2.38998875e-01f, -1.19006053e-01f, -4.67230454e-02f, -4.84377965e-02f, -4.09802288e-01f,
  -1.49911329e-01f, -3.15087914e-01f, 6.24837317e-02f, -7.50672072e-02f, -1.60897002e-01f, -2.34936237e-01f, -3.64790171e-01f, -1.19466841e-01f, -6.32079840e-02f, -2.23941877e-01f,
  -1.65147603e-01f, 1.50645256e-01f, 1.02300510e-01f, 7.01079071e-02f, 4.16168012e-02f, -5.80192618e-02f, 9.89721566e-02f, 3.19114149e-01f, 1.80921301e-01f, 7.31591927e-03f,
  8.16636011e-02f, 7.00401142e-02f, 1.80278957e-01f, 1.89364702e-01f, 5.16598113e-02f, 5.90285612e-03f, 4.25445177e-02f, 9.50050130e-02f, 9.24168248e-03f, 3.12028021e-01f,
  -1.36695966e-01f, -1.63507238e-01f, 1.02874286e-01f, 5.83268292e-02f, 4.64696698e-02f, 1.50065590e-02f, -5.17818518e-02f, 1.06684655e-01f, -1.25216106e-02f, 1.94454903e-03f,
  -3.68418284e-02f, 6.49060076e-03f, 5.74375130e-02f, 9.64182690e-02f, -1.97337065e-02f, -5.83219416e-02f, 6.30997345e-02f, 7.46050701e-02f, 2.06626989e-02f, -9.91529450e-02f,
  8.16658512e-02f, -2.50719395e-02f, -3.07896733e-02f, -9.36136991e-02f, 3.92503850e-03f, 6.41371533e-02f, -5.44832647e-02f, 7.28145707e-03f, -9.62768681e-03f, -8.66928026e-02f,
  2.51456089e-02f, 7.09332235e-04f, 3.27867363e-03f, 1.53493031e-03f, -4.12520692e-02f, 4.94300015e-02f, 5.91162927e-02f, -1.58513486e-02f, 6.63215518e-02f, -1.95394196e-02f,
  2.31853835e-02f, 2.11289688e-03f, -2.18587201e-02f, 1.81682296e-02f, -6.43648067e-03f, -3.55542498e-03f, 6.83088740e-03f, -4.90767248e-02f, 3.25017050e-03f, 1.37140350e-02f,
  1.54266590e-02f, 4.07142416e-02f, -6.91194227e-03f, 8.90947878e-02f, 1.94764882e-02f, -7.18537299e-03f, -1.67627204e-02f, -1.37681514e-02f, -7.08046034e-02f, -9.04694349e-02f,
  -1.93644822e-01f, 1.72770843e-01f, -5.28608784e-02f, 4.94395234e-02f, -5.43350466e-02f, -4.36505601e-02f, -3.04771159e-02f, 1.77026913e-02f, -4.16203029e-02f, -6.57581612e-02f,
  -4.86350022e-02f, -1.88933425e-02f, -5.67205884e-02f, 6.25858875e-03f, -1.24529339e-02f, -9.64239165e-02f, -9.42639075e-03f, 1.38982367e-02f, 4.90170456e-02f, -6.15072884e-02f,
  7.16619473e-03f, -7.31856599e-02f, -1.53573677e-01f, -1.26324296e-01f, -8.43363479e-02f, -1.15405478e-01f, -1.44563049e-01f, -1.37345880e-01f, -2.28642464e-01f, -3.68913531e-01f,
  -1.19048573e-01f, 3.23734358e-02f, 3.29769284e-01f, 8.87650065e-03f, 3.79720181e-01f, 3.73633504e-01f, 3.22924554e-01f, -7.11794496e-02f, -1.73029769e-02f, 2.64325559e-01f,
  9.05881897e-02f, -1.21916495e-01f, -1.97648287e-01f, -2.66017705e-01f, -2.20655009e-01f, 1.67481273e-01f, 3.11195135e-01f, -1.21819898e-01f, -1.46751970e-01f, -3.55242789e-02f,
  1.31991990e-02f, -4.45245765e-02f, -2.91618019e-01f, -1.99618310e-01f, 2.50956684e-01f, 1.08706057e-01f, 1.12274669e-01f, 1.84697229e-02f, 1.68777078e-01f, 3.37184757e-01f,
  3.15769464e-01f, -6.51670471e-02f, -6.21337369e-02f, -1.04363017e-01f, 6.05070964e-02f, -5.72101437e-02f, 3.13206688e-02f, -5.67165464e-02f, -2.68476959e-02f, 2.83316709e-03f,
  5.69671765e-02f, -1.01687588e-01f, -5.92949651e-02f, 1.65351052e-02f, -1.23940762e-02f, 4.34837639e-02f, -1.80105045e-02f, -8.91051739e-02f, -3.23371701e-02f, 7.55800977e-02f,
  1.06948368e-01f, 1.05770163e-01f, 9.79581550e-02f, 1.53702935e-02f, -4.96564172e-02f, -5.30860648e-02f, 6.79817274e-02f, 5.96826486e-02f, 6.27419874e-02f, 1.18109778e-01f,
  9.65120737e-03f, 5.88928722e-02f, -1.11851292e-02f, -5.13458438e-02f, 2.74177510e-02f, -2.88894260e-03f, -2.33314969e-02f, 8.06667507e-02f, -1.67904329e-02f, 7.15891737e-03f,
  -4.04167548e-02f, 3.47747095e-02f, -2.92311572e-02f, 2.70574316e-02f, 2.62734629e-02f, 6.33730292e-02f, -2.05826238e-02f, 2.39937007e-03f, -5.55308769e-03f, -3.65465730e-02f,
  1.24091143e-02f, 1.58586893e-02f, -1.33019956e-02f, -3.78591963e-03f, -1.98946707e-02f, 2.25501787e-02f, -2.03852691e-02f, -8.37070644e-02f, -4.34507132e-02f, -2.50754971e-02f,
  -9.95575860e-02f, -1.81760848e-01f, 1.22622058e-01f, -4.43702117e-02f, 5.24475016e-02f, -2.13231072e-02f, 9.80084389e-03f, -1.57954488e-02f, -4.18668613e-02f, 1.41819250e-02f,
  -6.41175061e-02f, -6.42587319e-02f, 9.92533937e-03f, -5.90385571e-02f, 4.65988442e-02f, -4.88812141e-02f, 6.31107166e-02f, 6.19430393e-02f, -6.50631590e-03f, 4.17297855e-02f,
  -7.39459693e-02f, 1.28263146e-01f, 1.02471247e-01f, -4.30657668e-03f, 3.20457555e-02f, -1.96465403e-02f, 1.36224121e-01f, 1.11670956e-01f, -4.83026616e-02f, 1.58481315e-01f,
  -3.25127572e-01f, -5.56608677e-01f, 3.18421841e-01f, -1.59724414e-01f, -1.92527026e-01f, -1.40491173e-01f, -4.08604920e-01f, -2.29866445e-01f, -8.81042853e-02f, -1.31275311e-01f,
  -7.18385577e-02f, 2.96034604e-01f, 2.17252195e-01f, 2.95480281e-01f, 1.24050401e-01f, -2.20224053e-01f, -7.92145059e-02f, 3.96605194e-01f, 4.61321414e-01f, 2.70502120e-02f,
  -1.87228143e-01f, -1.46550000e-01f, 3.58965360e-02f, 3.96303125e-02f, -4.97935079e-02f, 1.85831591e-01f, -4.90094163e-02f, 2.12840573e-03f, -2.27688048e-02f, -1.96285062e-02f,
  3.52025032e-01f, -3.36973280e-01f, 2.45186046e-01f, -4.77285162e-02f, 3.91200632e-02f, 5.56531698e-02f, 1.93769503e-02f, 8.37014019e-02f, -1.87374763e-02f, -1.53038511e-02f,
  -5.61784096e-02f, -5.47744520e-02f, -4.97816019e-02f, 6.80649057e-02f, -1.36775658e-01f, 1.73203666e-02f, -3.86769734e-02f, 7.36087710e-02f, 3.45945396e-02f, 4.21974882e-02f,
  -1.08477689e-01f, -7.09347576e-02f, 3.49910334e-02f, -2.59385891e-02f, -2.19234955e-02f, 1.41548380e-01f, 3.43333930e-02f, 3.54874879e-02f, 6.48724809e-02f, -4.70330045e-02f,
  -1.21820951e-02f, 2.33895238e-03f, 2.11409777e-02f, -3.27273421e-02f, 2.24879570e-02f, 5.80525352e-03f, 1.38542510e-03f, -1.41413580e-03f, 6.76700175e-02f, -4.12103161e-02f,
  8.29979684e-03f, -1.24869877e-02f, 1.32049145e-02f, -5.30196428e-02f, 3.52880619e-02f, 2.00676713e-02f, -1.03428122e-02f, 1.26790563e-02f, 5.47800362e-02f, 3.49108092e-02f,
  -2.95964889e-02f, 7.24969804e-02f, -2.19323169e-02f, 1.53665403e-02f, -3.17271948e-02f, 6.99258759e-04f, -1.67480651e-02f, 3.27932015e-02f, -3.01905740e-02f, -6.47497252e-02f,
  4.64855097e-02f, 2.92180330e-01f, -3.09634451e-02f, 3.00314352e-02f, -3.92780378e-02f, -2.24507656e-02f, 1.42278289e-02f, -1.81756485e-02f, -5.48885204e-02f, -3.31448652e-02f,
  -4.57328418e-03f, -2.69193971e-03f, 3.42772454e-02f, -1.39022423e-02f, 7.23211542e-02f, -3.31765153e-02f, -1.03632070e-01f, 6.54905587e-02f, -2.65010726e-02f, -7.22099692e-02f,
  -5.72986118e-02f, -3.83339301e-02f, 8.43507871e-02f, 1.37564823e-01f, -6.08459227e-02f, 4.87738085e-04f, 1.17398970e-01f, 3.93337719e-02f, 5.79160191e-02f, -1.60796091e-01f,
  -4.58842158e-01f, 2.56988287e-01f, -1.72324836e-01f, -1.93465710e-01f, 1.40184149e-01f, -3.46540026e-02f, 8.71567801e-02f, -9.68284905e-02f, -5.37995771e-02f, 9.50975046e-02f,
  2.10861832e-01f, 2.00777009e-01f, 4.54152077e-02f, -7.37935491e-03f, -8.61570463e-02f, -6.31241202e-02f, -3.12616155e-02f, -2.74821401e-01f, -1.95508510e-01f, 6.79330081e-02f,
  2.30515242e-01f, -2.42913328e-02f, -6.74063787e-02f, -6.58824295e-02f, 3.65196466e-02f, 1.42649263e-02f, -1.65900774e-02f, 2.94829998e-02f, 1.21922411e-01f, 1.21798366e-01f,
  -2.64540967e-02f, -7.89555386e-02f, -2.22576395e-01f, 9.43340436e-02f, 1.12859823e-01f, -8.87769461e-02f, -3.18637490e-02f, 5.15447324e-03f, 9.53139365e-02f, -1.14042439e-01f,
  6.69978410e-02f, 8.67708251e-02f, 1.13679327e-01f, 6.10353649e-02f, -4.88224588e-02f, -7.36956224e-02f, -4.84425053e-02f, -1.57573223e-01f, -1.02744125e-01f, -2.73373239e-02f,
  2.36756623e-01f, 2.23622233e-01f, -1.17317326e-01f, -2.79870629e-02f, -7.08738938e-02f, 1.57848895e-02f, -3.95906717e-02f, -6.66178241e-02f, -1.91222399e-01f, -1.14101954e-01f,
  -6.78630220e-03f, -6.11492805e-02f, -6.37049600e-03f, 1.21504907e-02f, -5.27720302e-02f, 1.67990383e-02f, -2.49877702e-02f, 1.59533042e-02f, 2.77421791e-02f, -3.68423574e-02f,
  3.35306264e-02f, -6.12273254e-02f, -1.89513899e-03f, -5.72926477e-02f, 3.03180832e-02f, -2.08070911e-02f, 5.99001860e-03f, 2.69515216e-02f, 6.76263049e-02f, -3.02609373e-02f,
  1.19177373e-02f, 6.82333671e-03f, -1.61253531e-02f, 7.03096092e-02f, 4.88363802e-02f, -9.51427370e-02f, -3.37223336e-02f, 3.32521498e-02f, -5.11510000e-02f, -3.75182629e-02f,
  -7.31098205e-02f, 1.65658697e-01f, -1.37616217e-01f, -1.17720664e-01f, -3.87886353e-02f, 7.18678311e-02f, 4.59933281e-02f, 2.52531394e-02f, -2.40811948e-02f, -7.56091475e-02f,
  4.66707274e-02f, -1.12058885e-01f, 1.26921451e-02f, 4.14387845e-02f, -5.08242883e-02f, -5.82728013e-02f, 1.56599239e-01f, 7.17167603e-03f, -2.61616912e-02f, 3.49523202e-02f,
  7.18956590e-02f, -9.12696570e-02f, -1.45455897e-01f, -1.05135515e-01f, -4.03597765e-02f, -1.65304318e-01f, -1.44553902e-02f, -1.30169138e-01f, -2.53770292e-01f, -2.56598294e-01f,
  6.22081101e-01f, 2.24966526e-01f, -1.90495774e-01f, -5.34522533e-02f, -2.91754156e-01f, -3.07306834e-02f, 2.80441046e-01f, 3.14019978e-01f, -5.22942059e-02f, 5.07919006e-02f,
  -1.23189822e-01f, -1.56435326e-01f, -1.90696076e-01f, -5.31080440e-02f, 1.88709423e-01f, -2.56255065e-04f, -1.74685374e-01f, -9.31046903e-02f, 1.32526075e-02f, 1.60983518e-01f,
  -1.62816837e-01f, 1.69233143e-01f, 1.80219725e-01f, 1.52176172e-01f, -1.50228769e-01f, -1.50171027e-01f, -1.07612751e-01f, -1.03557318e-01f, -1.14618786e-01f, -3.55517060e-01f,
  -9.34553146e-02f, 1.41795903e-01f, -9.07101035e-02f, -1.00975350e-01f, -8.45182762e-02f, 1.43327728e-01f, 1.16225988e-01f, 1.10310391e-01f, 2.98059974e-02f, 8.72535855e-02f,
  -1.41855299e-01f, -9.85283330e-02f, -3.33058462e-02f, -6.03948859e-03f, 4.03200388e-02f, 6.01957403e-02f, 1.34889603e-01f, 7.90669546e-02f, -5.02370298e-02f, 4.02185023e-02f,
  -1.90013230e-01f, -1.30764797e-01f, -8.53929482e-03f, 1.99207235e-02f, -5.42700887e-02f, -1.64943948e-01f, 3.67326066e-02f, 7.76210502e-02f, -7.91608095e-02f, 2.41139024e-01f,
  2.30598468e-02f, -2.93148793e-02f, -2.23490708e-02f, -1.77507736e-02f, 4.11171727e-02f, 1.32744564e-02f, -4.51233648e-02f, 1.67235527e-02f, 6.43778965e-02f, 2.42257137e-02f,
  1.18100159e-02f, -5.08242957e-02f, 2.50966568e-02f, 3.21004093e-02f, -1.66420806e-02f, -5.72077818e-02f, -3.24657816e-03f, 2.44290326e-02f, -1.25863450e-02f, 1.65107585e-02f,
  -3.34999077e-02f, 4.94993618e-03f, -2.92058941e-02f, 1.75987631e-02f, -6.03548549e-02f, -1.38548259e-02f, -3.24336663e-02f, 2.50039753e-02f, -6.39195461e-03f, -4.48656715e-02f,
  1.97404072e-01f, -2.05898851e-01f, 5.18985465e-02f, 9.93346348e-02f, -1.07336909e-01f, -4.54112105e-02f, -1.00999430e-01f, -5.56679145e-02f, -9.93884057e-02f, 2.68876310e-02f,
  -1.15558424e-03f, 9.12036598e-02f, 4.18907739e-02f, -6.48899600e-02f, 5.20603843e-02f, -8.06981977e-03f, 4.57604490e-02f, -9.92973745e-02f, -2.90537719e-02f, -7.55047202e-02f,
  3.43367346e-02f, 8.50691646e-02f, 1.10640317e-01f, -6.83916174e-03f, -4.48537283e-02f, -1.67445272e-01f, 8.10778216e-02f, 5.95358666e-03f, -4.51630317e-02f, 4.72017616e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.91521442e-01f, -6.72839060e-02f, 1.76429212e-01f, -6.17882013e-02f, -4.52073999e-02f, 3.15081254e-02f, 3.49857770e-02f, -8.95096064e-02f, -2.95447987e-02f, -1.15847895e-02f,
  -1.05794389e-02f, -2.04633269e-03f, -6.56859251e-03f, -1.29760772e-01f, -1.94110885e-01f, 7.96888396e-02f, -1.09709941e-01f, -1.22273363e-01f, -1.89710394e-01f, -1.21567681e-01f,
  -1.85235977e-01f, -3.11506927e-01f, -2.93948352e-01f, -1.95027769e-01f, -6.15183488e-02f, -1.13718897e-01f, -5.27406558e-02f, -1.09017886e-01f, -1.84129059e-01f, -1.39380783e-01f,
  3.86051893e-01f, -6.39688000e-02f, 4.94303256e-02f, -1.95933953e-01f, 7.13795200e-02f, -6.46915287e-02f, -6.06533103e-02f, 6.28054664e-02f, -2.62115523e-02f, 4.79683317e-02f,
  6.95167333e-02f, -1.94490105e-02f, -1.00528762e-01f, -3.50395031e-02f, -8.47486109e-02f, -6.01972267e-02f, -1.34047478e-01f, -6.55684844e-02f, -4.66722436e-02f, 7.91412685e-03f,
  -6.77340925e-02f, -1.82877436e-01f, -1.41464725e-01f, -1.06866844e-03f, 6.55723736e-02f, -1.34915531e-01f, 9.57738087e-02f, 4.54640649e-02f, -6.67120516e-02f, -9.78063494e-02f,
  -1.52853457e-02f, 2.86513139e-02f, -7.41835460e-02f, -4.00910191e-02f, -5.23549169e-02f, 6.46368340e-02f, 2.50288360e-02f, -3.08036362e-03f, 4.69554169e-03f, -6.46782145e-02f,
  4.40835720e-03f, 3.74761373e-02f, 8.81496519e-02f, 4.02039662e-03f, -6.32954836e-02f, 1.76422652e-02f, -9.74405631e-02f, -6.01738095e-02f, 1.77250318e-02f, -4.19350080e-02f,
  -5.73233292e-02f, 2.45926417e-02f, 2.12554727e-02f, 2.32969951e-02f, -7.49651045e-02f, -8.94524977e-02f, 1.82921831e-02f, -2.96957530e-02f, 9.92115289e-02f, 4.84088883e-02f,
  1.71993315e-01f, -3.16799618e-02f, -4.00742553e-02f, -1.56880423e-01f, -2.81655192e-02f, 8.26235265e-02f, 8.17933977e-02f, 7.45887682e-02f, -1.28552588e-02f, 4.57737744e-02f,
  -7.16227964e-02f, -1.95053797e-02f, 9.98196602e-02f, -2.20133346e-02f, -1.36446124e-02f, -2.76411772e-02f, -5.71862534e-02f, -1.28858820e-01f, 3.40138562e-02f, 1.27480254e-01f,
  -5.87163046e-02f, -1.84223384e-01f, -1.95979670e-01f, 2.18401588e-02f, 7.26336986e-02f, -9.87375304e-02f, -4.04884145e-02f, -6.85931668e-02f, -2.17888970e-02f, -1.71202555e-01f,
  -1.12909384e-01f, -1.22516207e-01f, -7.01844469e-02f, -2.60158449e-01f, -2.57936250e-02f, 1.13452913e-03f, -1.45489844e-02f, -1.72218397e-01f, -1.48441106e-01f, -1.17082767e-01f,
  5.49022108e-02f, 1.01117358e-01f, 6.22026585e-02f, 5.97964153e-02f, -4.03416902e-02f, -1.78427160e-01f, -1.00009531e-01f, -1.79556897e-03f, -1.83387473e-02f, 2.90530324e-02f,
  -1.89273283e-02f, -2.15295702e-02f, 1.02585023e-02f, -7.39452913e-02f, -4.39793281e-02f, -1.00683114e-02f, -1.94409281e-01f, 2.15116143e-02f, 5.26704825e-02f, 3.90940048e-02f,
  2.53151238e-01f, 1.02008164e-01f, -5.50061315e-02f, 1.07061870e-01f, -4.42697741e-02f, -6.31168559e-02f, 3.17544788e-02f, -1.22809447e-01f, -3.68498452e-02f, -5.94516695e-02f,
  6.98028207e-02f, 8.57743695e-02f, -4.27118391e-02f, 5.70651749e-03f, 5.02205417e-02f, 3.37418281e-02f, -1.17320791e-01f, -1.10992245e-01f, 8.29995424e-03f, 1.34390980e-01f,
  1.10393196e-01f, 2.90839896e-02f, 6.99885190e-02f, -4.91144508e-02f, -9.64556858e-02f, 9.40978676e-02f, -6.33861078e-03f, 6.51689321e-02f, -6.35351762e-02f, -5.72372787e-02f,
  -5.62896356e-02f, 4.09530848e-03f, 6.78428859e-02f, -1.59886535e-02f, 1.79282017e-02f, 6.79073408e-02f, -4.09271196e-02f, 8.72914270e-02f, -1.84922926e-02f, 4.34444323e-02f,
  -1.85746942e-02f, 2.14424655e-02f, 2.03078985e-02f, -9.78335142e-02f, 2.08863541e-02f, 2.31625102e-02f, 4.46129106e-02f, -6.28759116e-02f, -8.77472386e-02f, 8.25752765e-02f,
  -2.17135195e-02f, 2.28167977e-02f, -9.55528468e-02f, -7.15699717e-02f, -3.74672189e-02f, 1.12827700e-02f, 5.96941970e-02f, 1.25332773e-01f, 6.38563186e-02f, 1.72362030e-02f,
  -2.88188737e-02f, -8.91847238e-02f, 3.45478840e-02f, 3.66093442e-02f, 1.19991051e-02f, -8.40118155e-02f, -6.16458096e-02f, 1.89748071e-02f, 2.20463108e-02f, 4.46543582e-02f,
  1.13305589e-02f, -6.17457666e-02f, -5.90185635e-02f, -3.22063826e-02f, 7.71989375e-02f, 1.79395769e-02f, -7.62891546e-02f, 1.91706605e-02f, 8.19236934e-02f, 1.20740142e-02f,
  -1.85047388e-02f, 6.74127340e-02f, 1.83339231e-02f, -1.56643242e-02f, -7.74388835e-02f, 4.00912948e-02f, -4.01999839e-02f, -1.19718239e-02f, 3.43343243e-02f, -1.04891248e-01f,
  7.37239361e-01f, 6.66992664e-02f, -1.27425432e-01f, 7.25958869e-02f, -2.76768617e-02f, 4.79787216e-02f, -3.33074224e-03f, 8.78891647e-02f, 1.16010673e-01f, 1.28465414e-03f,
  2.95518011e-01f, 3.60194564e-01f, 2.30548277e-01f, 1.10780738e-01f, 1.61976963e-01f, -1.31566152e-01f, -1.80587798e-01f, -4.69662920e-02f, 3.83152850e-02f, -1.46706149e-01f,
  -1.01762846e-01f, -1.66868746e-01f, 2.64091548e-02f, -7.45910825e-03f, -1.64387584e-01f, -1.01780377e-01f, -4.13251929e-02f, -1.89806998e-01f, -1.65921286e-01f, -2.60810316e-01f,
  -2.44895399e-01f, 2.73803145e-01f, 3.97914983e-02f, -4.90114540e-02f, -5.61703183e-02f, -4.64850366e-02f, 4.89038490e-02f, -2.91155279e-03f, 2.48538218e-02f, -1.10917002e-01f,
  3.34639568e-03f, -7.68038770e-03f, -2.65629869e-03f, -1.13345273e-01f, -2.03238782e-02f, 4.72702160e-02f, -6.74963593e-02f, -5.91870816e-03f, 7.09950551e-02f, -1.12614207e-01f,
  -9.80365351e-02f, 6.39657378e-02f, 1.72074482e-01f, 7.40536973e-02f, 4.76530418e-02f, 1.08695932e-01f, 9.43671614e-02f, 8.34049582e-02f, 1.06547542e-01f, -2.47296635e-02f,
  -1.72726940e-02f, -7.60133145e-03f, 4.88332585e-02f, 5.12592234e-02f, 3.60660292e-02f, 3.73772010e-02f, -2.77009271e-02f, 1.35054635e-02f, 4.43267003e-02f, 5.33115305e-03f,
  -8.77364874e-02f, 6.83005229e-02f, 5.62813804e-02f, -2.54256204e-02f, -5.90479225e-02f, 3.39793824e-02f, -7.04084486e-02f, 4.68456448e-04f, 6.15587793e-02f, -2.49076448e-02f,
  7.18119293e-02f, 2.96711735e-02f, -5.48264757e-02f, -3.95505354e-02f, -6.89385012e-02f, -2.96626166e-02f, -8.11936483e-02f, 3.82723212e-02f, 2.60038897e-02f, 9.24727172e-02f,
  -1.10033497e-01f, 2.79465705e-01f, -4.78836857e-02f, 2.94820517e-02f, -2.25513838e-02f, -2.67182514e-02f, -8.77123252e-02f, -5.30580319e-02f, 1.31203318e-02f, -1.42268166e-01f,
  -6.56663179e-02f, -1.03311194e-02f, 4.11971956e-02f, -5.01695275e-02f, -2.87985373e-02f, -4.37001847e-02f, 1.47052379e-02f, 5.96038587e-02f, -1.54654039e-02f, -1.95833683e-01f,
  -1.71955571e-01f, -2.33646613e-02f, 9.82174352e-02f, 8.12149420e-02f, 2.43450515e-02f, 2.17638195e-01f, -3.05584520e-02f, -1.24483280e-01f, 1.50118083e-01f, -7.24890037e-03f,
  -1.45945430e-01f, 1.25061601e-01f, 8.96702632e-02f, -3.19642335e-01f, -6.73161745e-02f, 9.89371538e-02f, 1.74012184e-01f, -9.23331007e-02f, -8.34470466e-02f, 1.82708278e-02f,
  1.24693789e-01f, -1.36304319e-01f, -4.41115350e-02f, 1.18229436e-02f, -3.65426242e-02f, 1.42027587e-01f, -5.06033096e-03f, -1.48555458e-01f, -1.88859999e-01f, -5.66755794e-02f,
  -7.92854652e-02f, -2.72211790e-01f, -2.13649988e-01f, -1.70493156e-01f, -2.27152646e-01f, -5.90490438e-02f, -9.47060660e-02f, -5.60810976e-02f, -2.02810168e-02f, 1.80051860e-03f,
  5.94344102e-02f, 1.63129345e-01f, -9.26504359e-02f, -1.38342669e-02f, 3.99692431e-02f, -5.44793382e-02f, 7.26923868e-02f, -1.16647005e-01f, 2.82942411e-03f, -3.06103714e-02f,
  3.27498429e-02f, -1.13593489e-02f, -1.32267311e-01f, -1.26025379e-01f, -8.38836432e-02f, -1.02534316e-01f, -1.94820631e-02f, -1.39479533e-01f, 4.00745049e-02f, 1.69865377e-02f,
  2.55146734e-02f, 1.00212835e-01f, 9.20252353e-02f, 3.51539887e-02f, 8.95823240e-02f, 1.32869989e-01f, 1.26241818e-01f, 4.24177684e-02f, 1.63712040e-01f, -1.12201944e-02f,
  7.30386153e-02f, -2.27486622e-02f, 9.54969674e-02f, -2.53925435e-02f, -6.32727966e-02f, 1.76944654e-03f, -5.47106788e-02f, -2.14472562e-02f, 4.06632945e-02f, -1.01738229e-01f,
  -1.27240419e-02f, 5.89524657e-02f, 2.44645718e-02f, -1.00323424e-01f, -5.56557886e-02f, -6.45973757e-02f, 1.11198403e-01f, -9.81259998e-03f, -3.23140807e-02f, -3.43286544e-02f,
  -8.41499027e-03f, 4.74823788e-02f, 3.25279646e-02f, -4.23114635e-02f, 1.99269891e-01f, -1.09680346e-04f, -4.80535720e-03f, -2.48961151e-02f, -4.41762879e-02f, 4.05323170e-02f,
  -2.95809895e-01f, 2.77487695e-01f, 1.45342182e-02f, -6.22810647e-02f, -5.23285493e-02f, 3.58468927e-02f, 5.38759725e-03f, -4.21635844e-02f, 2.75983810e-02f, -8.45511258e-02f,
  1.35545343e-01f, -3.36834453e-02f, 2.16739066e-02f, -8.82818773e-02f, -6.52467459e-02f, -1.55632822e-02f, -1.02760367e-01f, -3.46983708e-02f, 5.18821515e-02f, 5.11257499e-02f,
  7.47311860e-04f, 4.36682254e-02f, 2.26410963e-02f, -1.65138673e-02f, 1.08945034e-01f, 4.85239271e-03f, -5.11148386e-03f, 8.79425369e-03f, 8.49708617e-02f, -6.56773429e-03f,
  8.27452362e-01f, 2.47526839e-01f, 4.21898752e-01f, 1.79736003e-01f, -2.79806405e-01f, -3.18415523e-01f, -2.14922756e-01f, -3.41129184e-01f, -2.16845080e-01f, -7.56565831e-04f,
  1.40358567e-01f, -8.30025598e-02f, -2.25763191e-02f, -1.06224753e-02f, 1.35259209e-02f, -9.11404788e-02f, 1.56601761e-02f, 3.02800685e-01f, 2.31450781e-01f, 1.26619324e-01f,
  -5.64410351e-02f, 1.90339252e-01f, 3.98360372e-01f, 2.06493542e-01f, 5.30217949e-04f, -8.93609971e-02f, -2.27015768e-03f, 1.73063487e-01f, 1.57743126e-01f, 2.83991218e-01f,
  3.49383622e-01f, 5.19747913e-01f, -2.76169956e-01f, 5.99596789e-03f, 6.94363043e-02f, 5.75384237e-02f, 2.12891120e-02f, 9.40268263e-02f, -3.74606736e-02f, -5.38526811e-02f,
  6.04953524e-03f, 5.05267680e-02f, -6.75584599e-02f, -9.11375433e-02f, 3.25907804e-02f, -6.46919683e-02f, 4.47735451e-02f, 8.60399008e-02f, -7.14313611e-02f, -2.13219747e-02f,
  2.78687570e-03f, 7.42560625e-02f, 7.57653266e-02f, -1.61533728e-01f, -4.14136285e-03f, 5.00010103e-02f, -1.06014730e-02f, -4.37738467e-03f, -7.21145272e-02f, -5.99569036e-03f,
  -4.20465507e-02f, 1.05460137e-01f, -1.77780241e-02f, -9.38624889e-03f, -1.71930622e-02f, -9.37330946e-02f, -6.68786168e-02f, -3.23426947e-02f, 2.34437883e-02f, -2.21771989e-02f,
  -6.52731135e-02f, 8.15858915e-02f, -6.50109276e-02f, -1.94953419e-02f, -5.88029213e-02f, 8.34527612e-03f, -4.21705171e-02f, 1.40978191e-02f, -1.81269906e-02f, -3.73688787e-02f,
  1.02911107e-01f, -2.33011022e-02f, -3.81399668e-03f, -6.40499685e-03f, -4.14731875e-02f, 4.61357348e-02f, 3.53549197e-02f, -5.02052121e-02f, -6.98790029e-02f, 6.59615099e-02f,
  -3.48994851e-01f, -8.89991969e-02f, -2.63852328e-02f, 9.56073925e-02f, 1.16682686e-01f, 1.20742269e-01f, 2.05072612e-02f, 1.08881526e-01f, 1.24000177e-01f, 3.73210497e-02f,
  1.35148317e-01f, 9.17433277e-02f, 8.15227032e-02f, 3.49080861e-02f, -8.66052061e-02f, -1.26020133e-01f, -4.41244710e-03f, -3.07304356e-02f, -3.82469334e-02f, 5.63757084e-02f,
  -1.45284176e-01f, -1.90709531e-01f, -1.56392753e-01f, -2.65636325e-01f, -1.07936524e-01f, -1.21484205e-01f, -1.88273787e-01f, -1.70852438e-01f, -1.73653066e-01f, -3.11081380e-01f,
  3.43664676e-01f, 2.85240740e-01f, -1.35438949e-01f, 2.89862603e-01f, 9.17379558e-02f, -2.34202281e-01f, -3.15471441e-01f, -2.36154988e-01f, 8.21903944e-02f, 1.26426220e-01f,
  1.98629037e-01f, 8.67757797e-02f, -1.05205983e-01f, -2.97164381e-01f, -5.44928908e-01f, -3.49007040e-01f, -2.37656683e-01f, -4.70696479e-01f, -5.28014660e-01f, -2.90986240e-01f,
  -8.42173398e-02f, 4.33521345e-02f, -2.73808856e-02f, -8.85240212e-02f, 3.79029751e-01f, 1.58816770e-01f, 2.20222965e-01f, 1.98129788e-01f, -6.90773726e-02f, 2.07428470e-01f,
  6.60736039e-02f, 1.17127381e-01f, -2.29201391e-01f, 1.12841427e-01f, 1.37861565e-01f, -9.68807936e-02f, -3.30904722e-02f, 2.51693595e-02f, 4.57246155e-02f, 6.82200417e-02f,
  6.64947554e-02f, -6.00733683e-02f, 5.09272702e-02f, -8.33208263e-02f, 5.71724260e-03f, -1.00689456e-01f, -1.19404055e-01f, -2.37005949e-01f, -1.58146843e-01f, -1.27808144e-02f,
  -6.94867596e-02f, 1.67033561e-02f, -5.69768134e-04f, -1.34295121e-01f, -1.07865803e-01f, -5.04423603e-02f, 7.38320872e-02f, -5.08845113e-02f, -1.86781526e-01f, 2.23708928e-01f,
  -2.78095342e-02f, 2.88759416e-04f, -3.35258506e-02f, 2.57306658e-02f, -1.98856200e-04f, 5.71734123e-02f, 3.02113430e-03f, -2.36671176e-02f, -1.47350635e-02f, 7.38483891e-02f,
  -1.54028572e-02f, 2.03476772e-02f, 6.19653687e-02f, 1.24519113e-02f, 1.93623044e-02f, -1.47675518e-02f, -3.83523367e-02f, -2.14575231e-02f, -1.11704543e-01f, 5.22680730e-02f,
  -6.04130365e-02f, -3.09990942e-02f, 1.21346287e-01f, -3.76735325e-03f, -6.42477348e-02f, 3.86660397e-02f, -5.11993617e-02f, 5.17947134e-03f, -4.76177372e-02f, 1.02824129e-01f,
  3.22022587e-01f, -3.62948358e-01f, 6.40533492e-02f, -5.21614440e-02f, 1.15400761e-01f, -5.98208921e-04f, 1.33220345e-01f, -1.11173525e-01f, 7.74545893e-02f, -4.22223806e-02f,
  -2.62967478e-02f, -4.82007042e-02f, 1.04352370e-01f, -5.87882772e-02f, -9.20295566e-02f, -1.17392898e-01f, 1.83488317e-02f, 1.71205262e-03f, -1.08631998e-01f, 2.80674193e-02f,
  1.14153832e-01f, -4.52756137e-02f, -9.79000181e-02f, -3.98843177e-02f, -5.41772880e-02f, -2.20175330e-02f, -3.91815640e-02f, -1.31443590e-02f, -2.32977942e-01f, 2.46229067e-01f,
  -2.90342480e-01f, -2.34249368e-01f, -2.71991044e-01f, -2.63806015e-01f, -1.07441761e-01f, 2.40694433e-02f, -9.67156887e-02f, 6.78898841e-02f, 3.37193348e-02f, -2.02873051e-01f,
  4.97851856e-02f, -1.68276086e-01f, -2.68078089e-01f, -1.87420979e-01f, -2.09061339e-01f, -2.76371896e-01f, -2.97025234e-01f, -2.53507316e-01f, -1.06080793e-01f, 3.47618721e-02f,
  3.73309813e-02f, -1.69310257e-01f, -1.84870690e-01f, -1.75601140e-01f, -5.26348092e-02f, -1.84947953e-01f, -2.54104525e-01f, -1.60428554e-01f, -4.67981920e-02f, -3.11838627e-01f,
  -3.29912871e-01f, 7.82831293e-03f, 3.36269625e-02f, -2.04859022e-02f, 3.50650810e-02f, 4.06782068e-02f, 3.84329483e-02f, 9.56466887e-03f, -1.35439551e-02f, -2.75166780e-02f,
  -3.28784920e-02f, -1.22311227e-02f, 9.47315525e-03f, 4.22361270e-02f, 4.47820686e-03f, -3.59980538e-02f, -3.95223312e-02f, -1.85675666e-01f, -1.01895720e-01f, -1.95736680e-02f,
  1.03763483e-01f, -1.12844899e-01f, -2.00945869e-01f, -4.51924317e-02f, -1.26909371e-02f, -1.81654707e-01f, -1.43151790e-01f, -9.02674124e-02f, -8.83058980e-02f, -2.57319361e-01f,
  4.02310118e-02f, 1.52587034e-02f, -2.43065692e-02f, 4.16083485e-02f, 2.74001006e-02f, -4.20498475e-02f, -2.44230777e-03f, -2.54876800e-02f, 5.05868010e-02f, -2.18079649e-02f,
  -9.85212252e-03f, 4.84525375e-02f, -7.47300824e-03f, -1.75664648e-02f, -5.95937930e-02f, -2.65033636e-02f, -6.22320287e-02f, -2.48065311e-02f, -6.51967898e-02f, 3.57913622e-03f,
  -5.48637211e-02f, -3.76064144e-02f, -8.40744749e-02f, 2.86626117e-03f, 4.08479907e-02f, -4.89739189e-03f, 7.05606565e-02f, 6.75722063e-02f, -4.43812571e-02f, 3.85347791e-02f,
  -3.34509552e-01f, 7.36178309e-02f, -1.12382494e-01f, -1.12220934e-02f, 2.23651771e-02f, 4.64370772e-02f, -8.23727101e-02f, -6.10813685e-02f, 2.02009082e-02f, 2.03133840e-02f,
  4.98866700e-02f, -5.91368936e-02f, -4.90886271e-02f, 7.42480531e-02f, 5.19048087e-02f, -4.88433428e-02f, -1.46897230e-02f, -1.98958069e-01f, -4.16341759e-02f, 8.05959553e-02f,
  -1.21312067e-01f, -3.10532242e-01f, -3.18865061e-01f, -1.39103398e-01f, -1.63778886e-01f, -2.34786525e-01f, -2.30801478e-01f, -1.70091137e-01f, -3.00600678e-01f, -3.37378621e-01f,
  -1.32091880e-01f, 1.30642727e-01f, -8.78578052e-02f, 2.37039283e-01f, 1.83163702e-01f, 1.71165004e-01f, 2.05991343e-01f, 2.40718544e-01f, 2.65106887e-01f, 2.21831426e-01f,
  1.67010218e-01f, 1.71531856e-01f, 2.76927590e-01f, 2.10438937e-01f, 1.75995752e-01f, 2.88028836e-01f, 1.93037003e-01f, 1.12117536e-01f, 4.11975272e-02f, 3.24630924e-02f,
  1.44029170e-01f, 6.02331646e-02f, -1.00019798e-01f, 1.16811104e-01f, 2.59856611e-01f, 1.80155978e-01f, 1.21408239e-01f, 3.07577513e-02f, 8.58038142e-02f, 2.56906509e-01f,
  -3.38713899e-02f, 8.70540272e-03f, 1.03720479e-01f, 6.05413392e-02f, -1.87492874e-02f, -1.57295257e-01f, 1.95008758e-02f, -1.48105025e-01f, -3.69472168e-02f, 6.05270080e-03f,
  -6.05008975e-02f, -1.78960785e-02f, 9.59516391e-02f, -5.59162684e-02f, -1.21388264e-01f, -6.08226880e-02f, 5.92922652e-03f, -7.14019537e-02f, 4.29318426e-03f, -6.06039120e-03f,
  1.46393076e-01f, -1.21121980e-01f, -9.38528106e-02f, 3.66534702e-02f, 3.21416259e-02f, 3.99897248e-02f, -9.04056951e-02f, -4.96659204e-02f, -2.09000763e-02f, -5.92306443e-03f,
  -2.39126361e-03f, 9.40619931e-02f, -7.03161806e-02f, 7.00839236e-02f, -4.77914838e-03f, -1.24997562e-02f, -2.13890541e-02f, 2.40893718e-02f, 6.87907487e-02f, -6.06342703e-02f,
  -3.06537412e-02f, 4.22832333e-02f, -1.26016084e-02f, 4.62312959e-02f, -9.19624977e-03f, -2.62009725e-02f, -7.48286955e-03f, -5.03458381e-02f, -6.59742281e-02f, -1.71144847e-02f,
  1.37490220e-02f, 6.04056520e-03f, -6.83442280e-02f, 4.29306366e-02f, 4.09732014e-02f, 4.46944404e-03f, -2.86127236e-02f, -7.16456845e-02f, -4.56807539e-02f, -1.44066304e-01f,
  -1.51151586e-02f, -1.49490729e-01f, 9.78679508e-02f, 6.00061007e-02f, 5.49886981e-03f, -7.29332492e-02f, 3.21257673e-02f, -8.58333614e-03f, -1.26180882e-02f, 5.27504943e-02f,
  -7.07694739e-02f, -5.58352880e-02f, -5.81433959e-02f, -1.01685911e-01f, -7.37883747e-02f, -9.08197016e-02f, -3.79259922e-02f, -4.26962525e-02f, 2.66798888e-03f, 6.57196110e-03f,
  -4.39152010e-02f, -1.30689442e-01f, -2.09301740e-01f, -8.15190822e-02f, 8.96141306e-03f, -2.95394799e-03f, -1.99569538e-01f, -5.66961728e-02f, -2.40423426e-01f, -1.36194080e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.39133945e-01f, 9.63580459e-02f, 3.86993200e-01f, 1.70841724e-01f, 5.49209654e-01f, 4.22195524e-01f, 2.73255318e-01f, 5.23837581e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.87787046e-03f, -1.55917391e-01f, -1.09021775e-01f, -3.84877205e-01f, 7.03433082e-02f, -1.21181703e+00f, -3.70558858e-01f, -6.72202110e-02f, -7.05286980e-01f, 3.92263830e-02f,
  8.73422399e-02f, -4.93973531e-02f, 1.33663043e-01f, -2.66407549e-01f, 2.10883930e-01f, 8.29448462e-01f, -3.42758715e-01f, -1.51391476e-01f, 4.45238680e-01f, 1.72098994e-01f,
  1.34528369e-01f, 1.58152372e-01f, 1.86405107e-01f, 3.32950622e-01f, 1.46847367e-01f, 2.28562549e-01f, 2.21456781e-01f, -1.50126979e-01f, -1.88114047e-01f, -2.21752942e-01f,
  1.01016641e+00f, -8.02795514e-02f, 6.05316795e-02f, -5.19071817e-02f, -1.65464878e-02f, 1.85308546e-01f, -5.18528402e-01f, -7.12575912e-01f, 1.26740903e-01f, 5.80816925e-01f,
  -2.76963651e-01f, 1.45284981e-01f, 4.20967713e-02f, 1.79155231e-01f, -2.73981363e-01f, -2.78356850e-01f, -7.60946393e-01f, 4.06197190e-01f, -7.89199293e-01f, -5.43369710e-01f,
  -1.44655541e-01f, -8.67676958e-02f, -5.71833432e-01f, 4.79178756e-01f, -6.88265979e-01f, 1.78184107e-01f, -2.90561318e-01f, 1.59899950e-01f, 1.00745583e+00f, 3.06324303e-01f,
  5.21866158e-02f, -4.06163573e-01f, -5.61213680e-02f, 4.67989266e-01f, 1.67533293e-01f, 4.52763200e-01f, 5.46125293e-01f, 2.58590609e-01f, 2.15283915e-01f, 4.17054415e-01f,
  2.85993725e-01f, -8.28368902e-01f, -6.84098899e-02f, -3.80157828e-01f, 3.85490596e-01f, 2.41139308e-01f, 3.74537051e-01f, 2.34908164e-01f, -1.01365298e-01f, -9.50422436e-02f,
  -1.91798523e-01f, -4.78702277e-01f, -3.26666608e-02f, 8.93871665e-01f, -8.49137902e-01f, 8.50013614e-01f, 1.25904188e-01f, -5.20979226e-01f, -5.96183389e-02f, -1.40664846e-01f,
  -5.63892573e-02f, -2.62744606e-01f, 3.46560299e-01f, -5.55030763e-01f, 1.68538522e-02f, -4.16913509e-01f, 2.02145308e-01f, 4.98560458e-01f, -8.44117478e-02f, -2.79804152e-02f,
  -7.97096550e-01f, 3.49641114e-01f, -1.35660321e-01f, 1.37107790e-01f, 2.21056238e-01f, 3.84994835e-01f, -3.55237216e-01f, 1.56293586e-01f, 6.23525567e-02f, 4.39576179e-01f,
  1.89164415e-01f, -1.03710771e-01f, 9.25702691e-01f, -2.55804718e-01f, 1.67124659e-01f, -5.45330830e-02f, -3.79105918e-02f, -9.68820527e-02f, 3.49017739e-01f, -2.93438792e-01f,
  4.63310599e-01f, 1.15276389e-01f, -1.88962102e-01f, 7.10995138e-01f, -4.38546419e-01f, -7.01412261e-01f, 5.92512310e-01f, -2.30736747e-01f, -4.65621203e-01f, -6.28223360e-01f,
  -6.41339481e-01f, -4.98713851e-01f, 4.48310226e-01f, 5.31559467e-01f, 7.44081587e-02f, 1.10927105e-01f, 5.12051489e-03f, -1.25930890e-01f, -1.07192732e-01f, 7.55923986e-02f,
  4.70834821e-01f, -4.31619614e-01f, 1.48221463e-01f, -6.75429225e-01f, 2.55817026e-01f, -2.88573176e-01f, 5.07699370e-01f, 4.60139103e-02f, -1.49487033e-01f, 4.89284173e-02f,
  -2.60906499e-02f, -3.47823411e-01f, 6.31829381e-01f, -1.67864114e-01f, 1.96547374e-01f, 6.27387762e-02f, -4.32611912e-01f, 9.37432647e-01f, 2.90694684e-01f, 9.41511914e-02f,
  2.87276864e-01f, 4.61266130e-01f, 4.77892339e-01f, 9.92502496e-02f, 2.61332929e-01f, 5.83407693e-02f, 2.30934680e-01f, 2.87351638e-01f, 5.59043109e-01f, 4.63648945e-01f,
  4.82143790e-01f, -6.51169896e-01f, -4.95056473e-02f, 3.08203325e-02f, 1.40168786e-01f, 1.72513202e-01f, -5.56804061e-01f, -5.25200725e-01f, -5.26026011e-01f, -6.83124959e-01f,
  -5.58536351e-01f, -9.39105809e-01f, -1.70226097e-01f, 7.21695065e-01f, -1.05078734e-01f, -3.21659267e-01f, 1.32638678e-01f, -1.70930311e-01f, -5.19994140e-01f, 5.85352838e-01f,
  7.31354132e-02f, 9.65168551e-02f, -1.13220261e-02f, 2.33372331e-01f, 1.81315187e-02f, -8.87400091e-01f, 7.46069998e-02f, 1.33032110e-02f, 2.08001524e-01f, -1.10979453e-01f,
  1.21882953e-01f, 4.23801363e-01f, 8.27740356e-02f, 3.13083231e-01f, 3.94006044e-01f, 2.47834489e-01f, 3.82994622e-01f, -8.95312965e-01f, 6.98216930e-02f, 5.85681975e-01f,
  -1.51725754e-01f, 6.52739704e-01f, -1.72365353e-01f, -4.39862549e-01f, -2.88053155e-01f, 4.75627273e-01f, -2.50748634e-01f, -6.82183951e-02f, -2.55260408e-01f, -2.54110992e-01f,
  1.01069844e+00f, -2.00858340e-01f, -7.35571623e-01f, -9.58380029e-02f, 5.42917580e-04f, -3.58103335e-01f, 2.90520817e-01f, 1.20381564e-01f, -3.57263327e-01f, -3.66141237e-02f,
  -1.44246861e-01f, -5.10741211e-02f, 7.21916184e-02f, -3.90230626e-01f, -2.44084597e-01f, -5.77458501e-01f, -2.82629848e-01f, 5.81547260e-01f, 1.26519337e-01f, -5.36632799e-02f,
  6.09437943e-01f, 3.98056060e-01f, -4.60444748e-01f, 5.37692547e-01f, 4.10788924e-01f, -2.90801048e-01f, 4.68152672e-01f, -4.68409568e-01f, 5.08674644e-02f, -2.24733070e-01f,
  -2.24754423e-01f, -1.86287865e-01f, -6.96983695e-01f, -1.17189012e-01f, -1.53001975e-02f, 8.17557275e-01f, 2.51117945e-01f, 6.49689138e-02f, -4.17005748e-01f, -2.66733617e-01f,
  4.40812021e-01f, 5.40498674e-01f, 2.07182020e-01f, -2.10759211e-02f, -4.92363721e-01f, 4.40837711e-01f, -5.91725647e-01f, 3.89507562e-01f, -2.04305053e-01f, 7.72821128e-01f,
  -6.90941632e-01f, 6.19635820e-01f, 4.00716603e-01f, 5.10954499e-01f, -4.14985538e-01f, -3.08506310e-01f, 9.50992525e-01f, -1.75199464e-01f, -6.55684888e-01f, 4.11282092e-01f,
  -4.14907277e-01f, -1.55403093e-01f, 5.61487786e-02f, -8.04458112e-02f, -2.80703276e-01f, -2.90880859e-01f, -2.68586725e-01f, -1.69162080e-01f, -4.28839177e-02f, -2.50740498e-01f,
  -1.28864035e-01f, 3.50658625e-01f, 1.38651937e-01f, -3.19107696e-02f, 1.56461790e-01f, -2.30205134e-01f, 2.67067343e-01f, 3.49063218e-01f, -3.71676803e-01f, -2.05739513e-01f,
  -6.80628270e-02f, -8.77477527e-01f, 5.39853394e-01f, 7.86437616e-02f, -4.34668362e-01f, 5.25119543e-01f, 2.08468676e-01f, 4.78279650e-01f, 1.41751543e-01f, -9.43840519e-02f,
  7.63392806e-01f, -7.67662227e-01f, -3.38544548e-01f, 2.31207654e-01f, -2.73304552e-01f, -1.07058994e-01f, 6.62816644e-01f, 7.07254350e-01f, -4.86612283e-02f, 5.17074130e-02f,
  -8.18346560e-01f, -1.00407287e-01f, 3.94703150e-01f, 3.88680726e-01f, 2.58773416e-01f, 2.38209516e-01f, -1.26094714e-01f, -9.13986340e-02f, 3.94339055e-01f, -7.11891413e-01f,
  3.10831755e-01f, 1.22059889e-01f, -8.53820562e-01f, -5.98643720e-01f, 3.34839553e-01f, 2.71339715e-01f, -2.47917309e-01f, -1.85637906e-01f, -6.44910872e-01f, -6.05332851e-01f,
  5.66507816e-01f, 7.34232664e-01f, -3.15958023e-01f, 1.53671160e-01f, 5.31720400e-01f, 2.37120003e-01f, -4.28383410e-01f, 1.77801456e-02f, -2.62710959e-01f, 2.14278221e-01f,
  -4.77486700e-01f, -2.89717615e-01f, -3.24789792e-01f, -2.27065518e-01f, 1.91213042e-01f, 3.38302493e-01f, -5.33931181e-02f, -4.47542518e-01f, -4.05246109e-01f, 3.47078681e-01f,
  -4.38045412e-02f, -5.31598330e-01f, 3.08206290e-01f, 9.35462415e-02f, 6.18078709e-01f, 4.97286052e-01f, -5.10734499e-01f, -1.28307035e-02f, 6.27295196e-01f, 5.28243661e-01f,
  8.73818278e-01f, -5.93288124e-01f, 4.05322611e-01f, -5.30911207e-01f, 2.22835854e-01f, 3.34821939e-01f, -2.14977503e-01f, -7.17857853e-02f, 3.99045080e-01f, 2.57722050e-01f,
  6.96842790e-01f, 1.32574379e-01f, -1.45979613e-01f, 3.86799104e-03f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.50436625e-01f, 1.05523601e-01f, 1.50514662e-01f, -3.28859948e-02f, 5.35987169e-02f, 3.13577145e-01f, -1.48656070e-01f, -1.97307002e-02f, 4.26327556e-01f, -3.26240696e-02f,
  2.96180874e-01f, 2.12177541e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    