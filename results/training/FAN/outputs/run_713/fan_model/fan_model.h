/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.89087792e-02f, -1.66219831e-01f, -4.12896276e-02f, 5.23652369e-03f, 1.57175250e-02f, -2.24583745e-02f, 1.12797953e-01f, 6.68034181e-02f, 9.97634605e-02f, 4.79286313e-02f,
  8.88755396e-02f, 6.08131513e-02f, 9.37505513e-02f, -9.35384929e-02f, -9.17229354e-02f, -7.78508484e-02f, -1.47334322e-01f, -1.46790385e-01f, -6.26947060e-02f, 9.82905179e-02f,
  4.39909920e-02f, -6.19532689e-02f, -1.41587947e-02f, -4.24170345e-02f, 6.95742294e-02f, 1.01034030e-01f, 4.80037853e-02f, 9.97457430e-02f, 1.13643734e-02f, -6.36471137e-02f,
  1.18718266e-01f, 3.95399556e-02f, -8.04263800e-02f, -1.30776182e-01f, -1.43519089e-01f, -1.97952520e-02f, -1.26417398e-01f, -7.91923255e-02f, -1.91873252e-01f, -2.98458524e-02f,
  -7.46509060e-02f, -1.42263591e-01f, -1.07788756e-01f, -3.78123112e-02f, -5.91298118e-02f, -3.96804810e-02f, -1.21479593e-01f, -7.77391419e-02f, -3.07842121e-02f, -1.01003967e-01f,
  -2.39286974e-01f, -2.22251087e-01f, -6.59430996e-02f, -4.63091731e-02f, -1.92834273e-01f, -1.08353458e-01f, -3.53224054e-02f, -7.86240324e-02f, -3.46725807e-02f, -5.33973128e-02f,
  -2.54218169e-02f, 1.86274596e-03f, 1.19596653e-01f, 1.16423085e-01f, 8.69960804e-03f, 1.11898988e-01f, -4.96266373e-02f, -8.52677878e-03f, 7.49652013e-02f, 8.32722485e-02f,
  3.31358872e-02f, 1.27632514e-01f, 4.54684906e-02f, 1.40390649e-01f, -2.18488220e-02f, -5.77100031e-02f, 6.60633221e-02f, 8.61122087e-02f, 4.54445966e-02f, 9.43968296e-02f,
  1.83643952e-01f, 7.94409513e-02f, 1.38873324e-01f, 6.47446662e-02f, 1.20886089e-02f, 2.50752605e-02f, 7.32871071e-02f, 9.65594947e-02f, 7.44041428e-02f, 2.93561462e-02f,
  1.89686760e-01f, -2.47036085e-01f, 2.60487441e-02f, -5.79514541e-02f, -2.37125680e-02f, -5.51823005e-02f, -9.35491771e-02f, -1.17925741e-01f, -1.07035473e-01f, -4.53543030e-02f,
  -4.43473384e-02f, -1.13885462e-01f, -1.81450278e-01f, -5.69094829e-02f, -6.43333644e-02f, 3.46782021e-02f, -4.56605516e-02f, -1.27977043e-01f, -6.86625540e-02f, -7.49541670e-02f,
  -4.88995090e-02f, 8.35850369e-03f, 2.07766760e-02f, 2.08175704e-02f, -4.09432501e-03f, -1.15293257e-01f, 1.03931101e-02f, 5.66486754e-02f, -7.82016572e-03f, 1.84994508e-02f,
  -2.50385076e-01f, -5.83647154e-02f, 2.94099133e-02f, 5.96789159e-02f, -3.59816104e-02f, -1.73723906e-01f, -1.38880089e-01f, -5.83531559e-02f, 4.80866544e-02f, -9.41829756e-02f,
  -6.56774573e-05f, 7.11949915e-02f, 5.23191206e-02f, 1.38002411e-01f, -9.30606723e-02f, -8.53998363e-02f, 2.21744940e-01f, 1.60533264e-01f, -1.35967180e-01f, -5.02152182e-03f,
  2.30691694e-02f, 6.74105883e-02f, -4.10857759e-02f, -5.35060987e-02f, 9.64179561e-02f, 5.23106717e-02f, 5.57626039e-02f, 1.05339192e-01f, 1.75735191e-01f, 3.66304368e-01f,
  -2.10969411e-02f, -2.59473920e-02f, 3.83901671e-02f, 2.85837729e-03f, 1.19047292e-01f, -1.13820218e-01f, -6.39823377e-02f, 6.75146515e-03f, 7.40252482e-03f, -9.47207138e-02f,
  7.43297711e-02f, 8.99041146e-02f, 1.14331150e-03f, 7.73453489e-02f, -3.62990983e-02f, -2.84735276e-03f, 1.04620098e-03f, -2.93442849e-02f, 6.02818169e-02f, -3.97580937e-02f,
  1.24957174e-01f, -2.62739118e-02f, -6.11069463e-02f, 2.26960909e-02f, 8.90098438e-02f, 9.17889830e-03f, -1.15964502e-01f, 8.53080526e-02f, -3.41711305e-02f, -5.85128888e-02f,
  3.21829654e-02f, 2.55518351e-02f, -1.18077286e-02f, 3.65095586e-02f, 9.11164656e-02f, 8.69295225e-02f, 9.48753059e-02f, 2.15441994e-02f, 2.38079838e-02f, 1.02106936e-01f,
  1.22525066e-01f, 7.61814564e-02f, 1.25409901e-01f, -1.74525343e-02f, -1.75499190e-02f, -1.04479849e-01f, -3.72824669e-02f, 5.56614585e-02f, 4.14766669e-02f, 3.94397341e-02f,
  8.23045522e-02f, 1.52837917e-01f, 1.41276373e-02f, 2.82064974e-02f, 2.40679812e-02f, 1.00217327e-01f, 1.80191491e-02f, -8.66470560e-02f, -1.44714549e-01f, -4.09723818e-02f,
  -3.70629936e-01f, -4.46506627e-02f, 2.68517975e-02f, -7.72582516e-02f, 8.20268616e-02f, 2.89927740e-02f, -7.89012313e-02f, -3.51459570e-02f, -1.07294649e-01f, 1.11441053e-02f,
  -1.87602043e-01f, -9.18785036e-02f, -4.68465649e-02f, -1.79536548e-02f, -1.34535190e-02f, -1.40432283e-01f, 1.23295095e-02f, -9.87954140e-02f, -4.93279062e-02f, -5.38244238e-03f,
  -1.07603250e-02f, -9.48267896e-03f, -1.72321379e-01f, -1.09298348e-01f, -1.40261678e-02f, -8.72704759e-02f, -5.12999706e-02f, -1.07129723e-01f, -1.48785859e-01f, -2.55969673e-01f,
  -2.80586451e-01f, 6.97909994e-03f, 1.03636915e-02f, -1.57791942e-01f, -1.64836287e-01f, -2.17608437e-01f, -3.71809572e-01f, -8.82853195e-02f, 1.07521061e-02f, -1.18641026e-01f,
  7.30886310e-02f, 2.48361334e-01f, 1.38576716e-01f, 1.60461456e-01f, 2.71167904e-02f, -2.20094904e-01f, -8.85198191e-02f, -2.79035848e-02f, 1.75012201e-02f, -2.72678621e-02f,
  1.56485587e-01f, 9.73850675e-03f, -5.16647771e-02f, 5.49266674e-02f, -7.62052238e-02f, 1.46694750e-01f, -1.68437641e-02f, -8.65190774e-02f, -4.40992862e-02f, 8.47961009e-02f,
  2.02315778e-01f, -1.17645279e-01f, 1.22706657e-02f, -4.63391691e-02f, -3.40894833e-02f, 3.98935638e-02f, -3.37258391e-02f, 4.36702780e-02f, -9.66154039e-03f, 3.07404660e-02f,
  -1.77110564e-02f, -3.64008956e-02f, 3.76721174e-02f, 1.27362266e-01f, -1.02998145e-01f, -7.65100643e-02f, -3.66452187e-02f, 5.17619401e-02f, -1.10531226e-02f, -3.37700848e-03f,
  1.82207227e-02f, 1.75942667e-03f, -1.05272926e-01f, -7.65240192e-03f, -1.17556423e-01f, -4.21785451e-02f, 2.24073809e-02f, -2.31000055e-02f, -8.05186704e-02f, 3.35657820e-02f,
  -8.82818270e-03f, 4.29275408e-02f, -3.33174190e-04f, -3.32486928e-02f, 1.01996519e-01f, -2.68223509e-02f, 2.77957832e-03f, -6.75048167e-03f, 9.12885834e-03f, 1.29459411e-01f,
  1.05037533e-01f, -2.30938438e-02f, -4.17322991e-03f, -3.69001902e-03f, -1.08494544e-02f, 9.47712883e-02f, 6.42142445e-02f, 9.41520929e-02f, 6.65065870e-02f, -5.38978279e-02f,
  3.37835625e-02f, -8.25470313e-03f, -1.90335512e-02f, 6.51162639e-02f, -4.12833802e-02f, 8.52570385e-02f, 3.70185897e-02f, 6.12097643e-02f, 8.16044137e-02f, 8.80040601e-02f,
  5.77858910e-02f, -3.24417688e-02f, 9.92133915e-02f, -1.40275136e-02f, -7.49156345e-03f, -8.95611420e-02f, -4.52522635e-02f, 2.16355212e-02f, -4.52616997e-02f, 6.51204027e-04f,
  -4.12131019e-04f, 2.37547234e-02f, -3.10735237e-02f, 8.87429118e-02f, -5.54872118e-02f, -8.85476619e-02f, -2.49617659e-02f, -4.75765653e-02f, -7.92225674e-02f, 5.84017374e-02f,
  3.35787088e-02f, -1.52689919e-01f, -1.03930876e-01f, -9.26580932e-03f, 1.37416795e-02f, -1.99502334e-02f, -2.18443442e-02f, -8.58205482e-02f, -1.98638793e-02f, -9.72232670e-02f,
  -3.56240451e-01f, -1.79514706e-01f, 6.94451854e-02f, -2.84941137e-01f, -2.44565323e-01f, -5.95652312e-02f, -2.50225008e-01f, -1.59123644e-01f, -1.85137376e-01f, -1.40270665e-01f,
  5.62112220e-03f, 1.36267155e-01f, -2.50462419e-03f, 6.51882291e-02f, 1.02251239e-01f, -3.14021200e-01f, -1.86002016e-01f, 1.55569734e-02f, 2.10693002e-01f, 7.38606751e-02f,
  -2.11590622e-03f, -6.99982569e-02f, 1.08966753e-01f, -6.52606506e-03f, -2.68680274e-01f, -1.04498295e-02f, -1.11935511e-01f, -8.84620920e-02f, 2.52908096e-02f, -3.66938502e-01f,
  2.45934367e-01f, -1.36485666e-01f, 8.88643414e-02f, -8.08742940e-02f, 2.66210157e-02f, -4.71583121e-02f, -8.25622380e-02f, -1.09996691e-01f, -4.62094396e-02f, -6.13935031e-02f,
  -6.85043260e-02f, 5.63070625e-02f, -3.32875475e-02f, -2.25475952e-02f, -1.24745861e-01f, -7.56045282e-02f, -5.38467132e-02f, 4.80490550e-03f, 6.32839184e-03f, 2.87215300e-02f,
  -8.35421309e-02f, 7.18369801e-03f, -4.52850498e-02f, -2.46277191e-02f, 6.45045340e-02f, 3.93015295e-02f, -5.42413257e-02f, 1.53603740e-02f, -2.31022015e-03f, -1.78269103e-01f,
  -3.35632227e-02f, -1.25842104e-02f, -5.52460691e-03f, 3.45493145e-02f, 2.42430959e-02f, 3.31208520e-02f, 6.38592392e-05f, 1.28997043e-02f, 1.13752775e-01f, -6.60956977e-03f,
  1.94597226e-02f, 1.18222557e-01f, 2.26140216e-01f, 7.99022689e-02f, 5.62742166e-02f, 8.24777596e-03f, 8.03366378e-02f, -1.83297452e-02f, 1.61980987e-01f, 4.02578041e-02f,
  -6.22253749e-04f, 9.30910856e-02f, 1.26188010e-01f, 5.98101579e-02f, 7.98305199e-02f, 1.97262000e-02f, -8.15260457e-04f, 6.93431497e-02f, 4.68830876e-02f, 1.73796862e-02f,
  -4.90007252e-02f, 3.53386819e-01f, -6.34215251e-02f, -1.12023251e-02f, 1.18171275e-02f, -3.58279981e-02f, -3.13543752e-02f, 1.48763657e-02f, -3.56973372e-02f, -7.27843493e-02f,
  -1.19684292e-02f, -5.34490012e-02f, -1.25321420e-02f, -2.83770412e-02f, -7.10192788e-03f, 1.44557366e-02f, -5.09117544e-02f, -9.26405489e-02f, 4.83832806e-02f, -6.72012195e-02f,
  -1.32793993e-01f, -3.30401771e-02f, -1.49186635e-02f, 1.29536409e-02f, -1.12127371e-01f, -1.14445321e-01f, -8.60102549e-02f, -1.26071334e-01f, 1.75883919e-02f, -2.01693654e-01f,
  5.34646027e-02f, -3.41780603e-01f, -2.38695815e-01f, -8.97076502e-02f, -2.16693655e-01f, 3.32661085e-02f, -1.44094914e-01f, 1.06699891e-01f, 3.31714144e-03f, -1.12618908e-01f,
  -1.79595396e-01f, 3.13992165e-02f, -1.03215493e-01f, 5.21053858e-02f, 2.08258823e-01f, -1.87081471e-01f, -1.69463515e-01f, 1.43937275e-01f, 3.30170572e-01f, 6.86676279e-02f,
  -6.11534156e-02f, 1.24338463e-01f, 8.07746723e-02f, 1.55672550e-01f, -1.29781902e-01f, 7.96714574e-02f, -1.87942863e-01f, -7.90706128e-02f, 5.38457111e-02f, -3.80702108e-01f,
  -2.15496853e-01f, -2.21038684e-01f, 1.28033877e-04f, 7.40025192e-02f, -1.21733464e-01f, 1.12333104e-01f, 2.18092147e-02f, -6.27829954e-02f, -1.83738917e-01f, -1.16714768e-01f,
  -1.53236508e-01f, -6.25887290e-02f, -1.73049539e-01f, 5.46582043e-02f, -1.48186877e-01f, -2.43154471e-03f, 3.84457596e-02f, -4.58012894e-03f, 6.20523840e-02f, -4.34452575e-03f,
  -2.94359084e-02f, -9.07499045e-02f, 2.59409882e-02f, 2.87030600e-02f, 7.11384937e-02f, -4.31140466e-03f, 9.84313991e-03f, -2.33001658e-03f, 7.63753653e-02f, 4.54156622e-02f,
  7.02209994e-02f, -4.50671986e-02f, 4.21984158e-02f, 2.20466889e-02f, 8.49002078e-02f, -1.05023663e-03f, -1.32981911e-01f, -5.66195473e-02f, 7.05668926e-02f, -8.80675986e-02f,
  3.86352129e-02f, -6.23065345e-02f, -4.31982167e-02f, -1.02626141e-02f, 7.33148605e-02f, -4.71804291e-02f, -4.02431097e-03f, -8.60921070e-02f, 1.45443091e-02f, 8.84718634e-03f,
  -4.86165807e-02f, -8.28582700e-03f, -7.21019804e-02f, 9.21632946e-02f, 1.24873649e-02f, 1.20594837e-02f, -7.28893206e-02f, 1.27459213e-01f, 2.63952333e-02f, 1.50812734e-02f,
  1.29085496e-01f, -6.16229773e-02f, -1.02283329e-01f, 4.51200418e-02f, 6.30648956e-02f, 1.94223095e-02f, -1.43616423e-01f, 1.42421275e-01f, -1.41178161e-01f, -2.87838001e-02f,
  -8.79534706e-02f, -4.57317457e-02f, -1.09279118e-01f, -8.34438056e-02f, 3.73325055e-03f, 4.57287878e-02f, 6.54216185e-02f, -2.34306417e-02f, 6.89566582e-02f, -5.36747873e-02f,
  8.05920437e-02f, 1.35345399e-01f, 1.44550651e-01f, -1.69995036e-02f, 1.70871764e-02f, 1.15165807e-01f, 7.22468249e-04f, 9.76307690e-02f, 2.35481396e-01f, 1.34916618e-01f,
  -1.83676437e-01f, -3.10656846e-01f, -4.07644480e-01f, -1.54987082e-01f, 3.45776863e-02f, 1.96670666e-01f, 1.97159827e-01f, 1.44523203e-01f, 1.64725989e-01f, 3.89338657e-03f,
  -6.78812503e-04f, 1.50660619e-01f, 1.70604095e-01f, 1.29630148e-01f, 1.36118770e-01f, -1.69483162e-02f, -2.28182241e-01f, -2.78543625e-02f, 2.72933543e-01f, 2.41671085e-01f,
  1.91964924e-01f, -5.42888790e-02f, -1.41440228e-01f, 3.03217042e-02f, -1.20524995e-01f, 1.92154646e-01f, -1.83513045e-01f, -1.98475912e-01f, -1.18064553e-01f, -2.65452653e-01f,
  -1.62421659e-01f, -2.36592889e-01f, 1.79644614e-01f, 5.23137301e-02f, -2.13589609e-01f, 4.53989208e-02f, 6.99963570e-02f, -2.97604967e-02f, -8.66132677e-02f, -9.00214016e-02f,
  -8.88027698e-02f, 4.41247784e-02f, 3.23596783e-02f, -4.66837846e-02f, -5.40463068e-02f, -4.31854650e-02f, -1.55297667e-01f, -1.65264547e-01f, -7.70848468e-02f, -5.24276271e-02f,
  2.51722876e-02f, -1.26658052e-01f, -1.03475846e-01f, 5.31463027e-02f, -1.58571322e-02f, 8.55138153e-02f, -1.23148695e-01f, -7.65398443e-02f, -1.23217426e-01f, -8.13677981e-02f,
  1.01758234e-01f, -1.07786290e-01f, -1.16972826e-01f, -7.64349848e-02f, 4.42199456e-03f, -8.89985859e-02f, -7.70706534e-02f, -7.89859444e-02f, 8.92061666e-02f, 6.01162165e-02f,
  3.76016907e-02f, -8.80145468e-03f, -2.60146186e-02f, 6.31961226e-02f, 6.32012822e-03f, 1.87650714e-02f, 2.30512004e-02f, 1.22661367e-01f, -3.99465337e-02f, 1.13616668e-01f,
  3.24591510e-02f, 6.09468669e-02f, -8.61296952e-02f, -8.87349714e-03f, 4.22262959e-03f, -2.82946136e-02f, -2.99766194e-02f, 1.22149654e-01f, 9.28132385e-02f, 5.21413721e-02f,
  2.15683386e-01f, -7.00053349e-02f, 6.27131462e-02f, 9.45224240e-02f, -5.14437892e-02f, -2.73512807e-02f, 1.20448649e-01f, -9.31075215e-03f, 2.94400845e-02f, 1.34770155e-01f,
  9.91771072e-02f, 5.23180887e-02f, -6.21001376e-03f, 4.38404083e-02f, 8.14446285e-02f, 1.64266974e-01f, -2.73314137e-02f, 7.38953203e-02f, -9.24547110e-03f, -9.00425985e-02f,
  -1.59118753e-02f, 7.69918337e-02f, 2.26952121e-01f, 6.61945716e-02f, 5.29818870e-02f, 1.82448640e-01f, 2.07265794e-01f, 9.32404697e-02f, 9.48636606e-02f, 1.96872711e-01f,
  -4.58416939e-01f, 6.81168139e-02f, -3.36504471e-03f, -5.59842307e-03f, 1.18807703e-01f, -7.97306746e-02f, 1.44626617e-01f, -5.69564886e-02f, -1.99748397e-01f, 1.52377844e-01f,
  -3.35493460e-02f, -1.23344824e-01f, -1.46335438e-01f, -8.37720856e-02f, -2.35540256e-01f, 1.61232352e-01f, 1.86091378e-01f, -5.29802628e-02f, -2.28786841e-01f, -4.80316579e-02f,
  1.27019763e-01f, -9.83193070e-02f, -9.86518711e-02f, -1.67736903e-01f, 1.97899878e-01f, 3.68897170e-02f, 8.07697400e-02f, -2.74422839e-02f, 2.84667057e-03f, 3.49981546e-01f,
  3.19115631e-02f, 6.65745959e-02f, -2.22493913e-02f, 7.50591140e-03f, 1.88198909e-02f, 1.10859588e-01f, 3.60104628e-02f, -7.03368511e-04f, 2.68798824e-02f, 4.22243699e-02f,
  6.97166547e-02f, 1.05779264e-02f, -7.34847561e-02f, 1.20991968e-01f, -9.24414117e-03f, 4.30420153e-02f, -4.31216601e-03f, -9.28578600e-02f, -2.44454928e-02f, 8.13251138e-02f,
  1.08745106e-01f, 5.24246544e-02f, -3.85122420e-03f, 9.95142758e-02f, -3.52687649e-02f, -3.38846184e-02f, 2.94731427e-02f, 1.04316212e-02f, -8.09304342e-02f, 3.93695720e-02f,
  1.37605250e-01f, 4.00305353e-02f, -3.21821608e-02f, 2.18707472e-02f, 1.21077953e-03f, -7.46239126e-02f, 6.13176413e-02f, -8.15044791e-02f, 7.91853443e-02f, -2.31563747e-02f,
  -7.00827986e-02f, 9.59667191e-02f, -7.56223500e-03f, -2.15662131e-03f, 4.59959619e-02f, 3.16583440e-02f, -5.22770770e-02f, -4.07996448e-03f, 4.77003530e-02f, -1.45179918e-02f,
  3.44347507e-02f, 7.18391612e-02f, 2.91980729e-02f, 1.30828291e-01f, -6.40696585e-02f, 6.89483583e-02f, 3.96283045e-02f, 1.14503764e-01f, -3.24123213e-03f, 6.03573099e-02f,
  -5.97915873e-02f, -2.27878522e-02f, 1.20212175e-02f, 6.77524135e-02f, 2.29449905e-02f, -4.26259972e-02f, 3.88315395e-02f, -6.02609385e-03f, -4.41300385e-02f, 9.59988609e-02f,
  6.41092435e-02f, -1.45275459e-01f, -4.62785969e-03f, 1.57713629e-02f, -1.03512788e-02f, 4.39963974e-02f, 7.45704100e-02f, -8.96456302e-04f, 7.76222274e-02f, 7.32958922e-03f,
  1.11339621e-01f, 6.22977354e-02f, 1.43258795e-02f, 2.82113794e-02f, 1.52131915e-01f, -5.46224788e-02f, -7.98747540e-02f, -4.18200381e-02f, -1.01637192e-01f, -2.75916457e-02f,
  2.43805036e-01f, -3.58310565e-02f, -3.55703741e-01f, 1.05974458e-01f, -3.81949216e-01f, -3.41546446e-01f, -4.53495800e-01f, 4.10599634e-02f, 1.23369224e-01f, -1.80328146e-01f,
  -3.14197429e-02f, 3.23181301e-01f, 5.04354946e-02f, 1.41348511e-01f, 7.19246715e-02f, -3.06969613e-01f, -1.85095534e-01f, -1.00885816e-01f, 6.60514608e-02f, 5.98568134e-02f,
  -4.40986902e-02f, 1.31934032e-01f, 3.04531872e-01f, 1.20004781e-01f, 5.46243191e-02f, 5.76341487e-02f, -1.77674875e-01f, -6.17504530e-02f, -1.14067048e-01f, 4.09133397e-02f,
  -1.60955399e-01f, 1.65901244e-01f, 1.73931077e-01f, 1.36949047e-01f, -1.03233866e-01f, 2.63133440e-02f, -4.03009877e-02f, 1.22071072e-01f, 5.00847474e-02f, 1.04613211e-02f,
  1.24998271e-01f, 1.26782224e-01f, 1.30027741e-01f, 1.06603287e-01f, 1.00132093e-01f, 1.34412393e-01f, 1.59838527e-01f, 1.65199220e-01f, 8.05250555e-02f, 6.78439662e-02f,
  1.14870565e-02f, 6.81105256e-02f, 1.39335347e-02f, -1.29447486e-02f, 5.07140309e-02f, 1.87201977e-01f, 4.88565154e-02f, 6.64683655e-02f, 6.11450709e-02f, 5.09729348e-02f,
  -4.65832315e-02f, -9.92944986e-02f, -7.48075172e-02f, -5.99839054e-02f, -4.32362258e-02f, -1.40567452e-01f, 5.58829531e-02f, 6.53631333e-03f, -7.21312128e-03f, 3.61893210e-03f,
  3.64968181e-02f, -1.13473080e-01f, -7.68233091e-02f, -8.18751827e-02f, -3.65898572e-02f, -7.60507956e-02f, -1.78375226e-02f, -2.66772527e-02f, 1.30422816e-01f, 2.79365946e-02f,
  -5.72352146e-04f, 7.81212598e-02f, -6.28859773e-02f, 7.16089457e-02f, -4.28935140e-02f, -1.88020431e-02f, 1.12812826e-02f, -1.90689508e-02f, 8.84682313e-02f, -1.42132059e-01f,
  2.37037502e-02f, -4.76160273e-02f, 2.06139088e-01f, 1.71711117e-01f, -2.20582578e-02f, 1.28618836e-01f, -1.26968417e-02f, 5.91471307e-02f, 1.42421171e-01f, 1.41200554e-02f,
  4.68503125e-02f, 6.74440265e-02f, 9.18414071e-02f, 4.49268557e-02f, 3.49621214e-02f, 1.93645343e-01f, -5.22368029e-02f, -3.39955799e-02f, 1.54035121e-01f, 7.08486065e-02f,
  8.12705830e-02f, 4.99088056e-02f, 3.86740379e-02f, 2.68188724e-03f, 2.02835444e-02f, 1.02996029e-01f, -8.11100826e-02f, 5.65840453e-02f, -5.18837869e-02f, -1.96180418e-02f,
  -3.27746533e-02f, 1.10771365e-01f, 1.14311606e-01f, -1.17694072e-01f, 1.05971813e-01f, 2.09652320e-01f, 5.71336985e-01f, 1.13956653e-01f, -1.05684720e-01f, 4.67597023e-02f,
  -9.50671211e-02f, -3.13717186e-01f, -1.92244470e-01f, -2.13647455e-01f, -6.78780600e-02f, 2.15349749e-01f, 2.50928193e-01f, -6.57445984e-03f, -1.19920231e-01f, -3.26797366e-02f,
  -5.54789566e-02f, -6.73836246e-02f, -9.19049382e-02f, -1.97669212e-02f, -1.68300383e-02f, -2.12050006e-01f, -1.09975208e-02f, -2.60200296e-02f, 1.42603219e-02f, 4.29271720e-02f,
  -4.15214561e-02f, -4.39516045e-02f, -1.36359647e-01f, -1.56669199e-01f, -1.10475846e-01f, 6.42478764e-02f, -8.48841518e-02f, 1.55818593e-02f, -1.45846428e-02f, 1.91200338e-02f,
  -2.39810795e-02f, -5.46012558e-02f, -1.71201855e-01f, -1.17962196e-01f, -1.09598776e-02f, -3.35706547e-02f, -4.32626978e-02f, 1.21544413e-02f, 3.87780834e-03f, 3.72287855e-02f,
  3.54064554e-02f, 1.15739657e-02f, 1.25007406e-01f, -3.16669345e-02f, 6.21748939e-02f, -2.60275546e-02f, -9.56344604e-02f, -6.87156841e-02f, -1.76638976e-01f, -5.24598435e-02f,
  -1.34674087e-01f, 3.12780999e-02f, -8.35177004e-02f, -2.66595837e-02f, 5.08199148e-02f, 1.00039374e-02f, -3.89107913e-02f, -1.22444639e-02f, 3.28022498e-03f, -4.37916629e-03f,
  4.04293314e-02f, -1.00177892e-01f, -1.55126126e-02f, 1.97945395e-03f, -4.20863554e-02f, 8.58970284e-02f, 1.10510744e-01f, -3.18308771e-02f, -1.02786710e-02f, 7.09159076e-02f,
  -3.19331922e-02f, 2.33484861e-02f, 2.20863894e-03f, 2.76794918e-02f, 8.17731470e-02f, 2.43361760e-02f, -2.19153203e-02f, 4.89681447e-03f, -3.88652384e-02f, 3.56625281e-02f,
  -1.90695867e-01f, -1.71979338e-01f, -7.39818290e-02f, -2.70941928e-02f, 3.08325887e-02f, 6.73690736e-02f, -1.51150497e-02f, -2.56463923e-02f, -7.46618807e-02f, 3.36992964e-02f,
  4.46020579e-03f, -2.36969925e-02f, -8.24799687e-02f, -4.24772874e-02f, -3.34498137e-02f, -1.97247099e-02f, 1.11526102e-02f, 3.02825980e-02f, -9.96804908e-02f, 8.51702839e-02f,
  6.90060630e-02f, 8.40442479e-02f, -7.38604739e-02f, 2.09440924e-02f, -4.96381670e-02f, -1.82575732e-02f, -3.64791527e-02f, -8.48661456e-03f, 1.45042650e-02f, 3.49143818e-02f,
  -3.21618080e-01f, -2.55156815e-01f, -1.20527372e-01f, -1.67985424e-01f, -6.92816675e-02f, -1.38556451e-01f, -2.26716861e-01f, -1.23920143e-01f, -2.50625666e-02f, -1.06068186e-01f,
  -5.52278049e-02f, -6.26525655e-02f, 2.30179206e-02f, 9.47177187e-02f, -8.11714679e-02f, -6.24011271e-02f, 1.14605516e-01f, 1.03274420e-01f, 5.66556118e-02f, -1.46150845e-03f,
  1.28930807e-01f, -1.16347089e-01f, -1.08652800e-01f, 2.53489930e-02f, -3.23702954e-02f, -7.74682611e-02f, -1.03599437e-01f, -1.50546163e-01f, -1.08549565e-01f, 9.24251229e-02f,
  -2.57630944e-02f, -1.09038785e-01f, 9.30231214e-02f, 7.78900310e-02f, 8.58129002e-03f, -4.85635586e-02f, 1.33555755e-02f, 2.59604901e-02f, 5.72848842e-02f, -1.30149677e-01f,
  -2.19202824e-02f, -2.37643090e-03f, 5.96599467e-02f, 1.04192376e-01f, 9.29992199e-02f, 1.68182217e-02f, 5.37926517e-03f, 1.17887579e-01f, -3.20916623e-02f, 1.55246854e-02f,
  1.00047782e-01f, 1.23280575e-02f, -7.42228031e-02f, 2.72395257e-02f, 3.20468135e-02f, 9.58417878e-02f, 8.98747984e-03f, -3.30822766e-02f, 3.45945209e-02f, -1.24618635e-02f,
  1.68681383e-01f, 6.24270663e-02f, 3.50292749e-03f, -5.22696748e-02f, -8.15873146e-02f, -5.06335720e-02f, -2.88498178e-02f, -3.00242957e-02f, 1.04252212e-01f, -6.07934408e-02f,
  -6.39492050e-02f, -6.02405332e-02f, -4.88893641e-03f, -1.27187014e-01f, 4.94082831e-03f, -7.61720091e-02f, 8.01798329e-03f, 1.22495079e-02f, 2.76477896e-02f, -4.98910546e-02f,
  -1.06768832e-02f, 4.10711244e-02f, -1.17517915e-02f, 1.05310157e-01f, -1.21107846e-02f, -6.83929473e-02f, -5.29182367e-02f, -2.12568883e-02f, -1.03301862e-02f, 1.63980629e-02f,
  -2.85558730e-01f, 2.70147026e-02f, -1.32089749e-01f, 5.54542989e-02f, 7.84299374e-02f, 6.78849667e-02f, -1.65040359e-01f, -4.27712016e-02f, -6.30792379e-02f, -8.47879425e-02f,
  -5.59068620e-02f, -5.35039417e-02f, -4.52268310e-02f, 8.00274685e-02f, -2.27443576e-02f, -4.69707772e-02f, -1.78787280e-02f, 4.01250646e-02f, -1.15701335e-03f, -5.51419752e-03f,
  -7.80086219e-02f, -6.44874899e-03f, -1.41113892e-01f, -6.61495030e-02f, -1.41891658e-01f, -1.21551566e-01f, -7.91552290e-02f, -1.65943697e-01f, -9.90783870e-02f, -3.04151446e-01f,
  6.01750553e-01f, 2.68879682e-01f, -9.23212245e-02f, 8.98370668e-02f, -1.35337621e-01f, -7.09680319e-02f, 1.48811728e-01f, 4.65453938e-02f, -5.14595099e-02f, 1.18878394e-01f,
  -3.31644677e-02f, -1.59708396e-01f, 5.15614217e-03f, -1.30135089e-01f, 4.17070463e-02f, -4.87798005e-02f, -1.37989417e-01f, -1.10650636e-01f, -7.11903796e-02f, -6.39404058e-02f,
  -9.30980667e-02f, 8.00782163e-03f, 1.97794452e-01f, 3.83437797e-02f, 5.82498731e-03f, -9.92890820e-02f, 6.65076450e-02f, 7.59308264e-02f, -1.22946970e-01f, 1.19285369e-02f,
  -1.19006485e-01f, 2.23248988e-01f, -1.62189767e-01f, -4.84654084e-02f, -1.31292924e-01f, 1.18036354e-02f, -1.83575340e-02f, -1.44574419e-03f, 4.33214270e-02f, 3.73990498e-02f,
  -8.20530728e-02f, -3.10756620e-02f, -1.05592841e-02f, -6.80701062e-02f, 7.89270699e-02f, 2.00095382e-02f, 5.66363558e-02f, 6.33660853e-02f, -1.52883856e-02f, 3.09153534e-02f,
  -1.32772416e-01f, -1.32534593e-01f, 2.54008062e-02f, 4.44605425e-02f, 8.24633427e-03f, 2.88681332e-02f, -1.09182924e-01f, -1.15661070e-01f, -3.85458842e-02f, -1.47138257e-02f,
  5.29813617e-02f, 4.93152030e-02f, 7.45720938e-02f, 1.14363335e-01f, 8.11928604e-03f, 8.72293413e-02f, 5.09260297e-02f, -4.48557548e-02f, 2.73063537e-02f, 3.35285030e-02f,
  1.80584062e-02f, -9.81373619e-03f, 2.72693206e-02f, 5.46005666e-02f, -5.53124547e-02f, 8.93098395e-03f, -5.28104678e-02f, 7.92726409e-03f, 9.01567563e-02f, 5.25195636e-02f,
  1.16177447e-01f, -7.58371269e-03f, 9.26282257e-02f, -2.93930639e-02f, 7.18251094e-02f, 5.40832058e-02f, 1.47715479e-01f, 2.41146181e-02f, 8.38496387e-02f, 1.72043424e-02f,
  1.13773055e-01f, -1.05194777e-01f, 1.89472288e-02f, 6.73044007e-03f, -6.27649762e-03f, -4.60768119e-02f, 1.92950740e-02f, 6.88008144e-02f, -2.21273731e-02f, 6.59779757e-02f,
  6.07572719e-02f, 1.25741720e-01f, 2.50025908e-03f, -2.80689206e-02f, -5.75544015e-02f, 1.99775305e-02f, 1.07308984e-01f, -1.41628208e-02f, 6.85413461e-03f, 8.01447481e-02f,
  1.43440599e-02f, -3.29144523e-02f, 5.09661324e-02f, 1.55936606e-04f, 5.02196774e-02f, 8.53748471e-02f, 4.20929752e-02f, -5.06983744e-03f, -6.70902058e-02f, 5.31420186e-02f,
  2.75274098e-01f, 7.74640739e-02f, 7.35538527e-02f, 4.88832623e-01f, 2.79106408e-01f, -7.52177611e-02f, -7.31210262e-02f, -9.91592631e-02f, -2.04644725e-03f, 1.38766021e-01f,
  1.67580009e-01f, 2.75794148e-01f, 1.64734274e-01f, -3.43276821e-02f, -7.27257133e-02f, -6.46661520e-02f, 6.66279346e-02f, 1.26211941e-01f, -3.75207104e-02f, 4.08146009e-02f,
  1.59079775e-01f, 2.11858124e-01f, 1.39213294e-01f, -8.32310505e-03f, 2.51620650e-01f, 4.18544300e-02f, 7.14550391e-02f, 1.64397016e-01f, -5.47016449e-02f, 2.84533978e-01f,
  1.92782246e-02f, -8.37171376e-02f, 5.73578151e-03f, -1.06447050e-02f, 5.42598292e-02f, -3.59616540e-02f, -9.39722266e-03f, -1.17682509e-01f, -3.49534303e-02f, -1.92266013e-02f,
  -1.69761460e-02f, -3.97657529e-02f, 6.20601773e-02f, 1.01141026e-03f, 2.67931689e-02f, -2.95813177e-02f, -6.45896643e-02f, -1.05566032e-01f, -2.50564516e-03f, -4.73662689e-02f,
  3.70229930e-02f, 1.12733260e-01f, -6.95035458e-02f, -7.39072636e-02f, -1.11890450e-01f, 2.54792627e-02f, -1.08345538e-01f, -1.37715444e-01f, -1.22664914e-01f, -5.46737909e-02f,
  -6.68544844e-02f, -6.79734349e-02f, -1.11589275e-01f, -5.46458215e-02f, -8.45723525e-02f, -1.58327386e-01f, -4.25211340e-02f, -6.71343226e-03f, -1.63136348e-02f, -5.87993152e-02f,
  -1.04933523e-01f, 1.73813961e-02f, 9.21223313e-02f, -4.01295833e-02f, 7.37225190e-02f, 4.95035760e-02f, 1.83429658e-01f, 6.56582192e-02f, 6.14477471e-02f, -5.18758073e-02f,
  3.87908518e-02f, -3.60172018e-02f, 6.43753335e-02f, -7.93861747e-02f, 8.16982910e-02f, 8.69039968e-02f, -2.92494260e-02f, -6.51400089e-02f, 7.53167504e-03f, -8.82634148e-02f,
  2.16184497e-01f, -8.60105380e-02f, 1.08601421e-01f, 6.64133951e-03f, 6.45375475e-02f, 8.78613722e-03f, 4.34518456e-02f, -4.39420454e-02f, 7.75272101e-02f, 1.14948235e-01f,
  -1.00736776e-02f, -1.72193982e-02f, 8.07306394e-02f, 5.08893467e-03f, -2.76972745e-02f, -6.19485881e-03f, 1.05897993e-01f, 7.67409205e-02f, 2.56971642e-02f, 3.55751663e-02f,
  3.63285169e-02f, -5.22068031e-02f, -3.17786410e-02f, 3.57825905e-02f, -1.52863301e-02f, 6.03050254e-02f, 5.04154079e-02f, -2.95651928e-02f, 7.67879561e-03f, -8.61199722e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.26252055e-01f, -1.50917292e-01f, 1.90536812e-01f, 2.03250438e-01f, 8.27323273e-02f, 2.78508682e-02f, -2.33415291e-01f, -2.43991870e-03f, 2.16436163e-02f, -2.31670141e-01f,
  -1.16767980e-01f, 1.79131702e-01f, 6.57594576e-02f, 8.11068192e-02f, 9.62356776e-02f, -1.22339316e-01f, -1.04303390e-01f, 2.28492200e-01f, 3.95078093e-01f, 1.42568707e-01f,
  -2.22168937e-01f, -1.47583514e-01f, 1.37522653e-01f, 3.63627225e-02f, -3.86559278e-01f, -1.20696258e-02f, -3.30066562e-01f, -1.73700020e-01f, -1.11216336e-01f, -4.23566610e-01f,
  1.16565667e-01f, 3.75312343e-02f, 1.05467260e-01f, 8.03122595e-02f, -9.61273462e-02f, 8.85060653e-02f, 1.78080276e-02f, -2.76835673e-02f, -6.50501670e-03f, -1.74176574e-01f,
  -4.27110903e-02f, -1.80611797e-02f, 7.10286871e-02f, -1.58113554e-01f, -4.24206406e-02f, 9.17934347e-03f, -1.55663639e-01f, 4.75484207e-02f, 5.75623438e-02f, -8.70460719e-02f,
  -6.51498735e-02f, 1.13714598e-02f, 6.50404915e-02f, -5.82119003e-02f, 3.05543933e-02f, 2.17385381e-01f, -1.04606897e-01f, -3.87346521e-02f, 8.13090650e-04f, -3.54997814e-01f,
  -5.33946306e-02f, -9.57181770e-03f, 6.19998276e-02f, -2.02863552e-02f, -4.78217080e-02f, -2.14688969e-03f, -3.68378474e-03f, 1.78480137e-03f, -6.09466061e-02f, -7.06127062e-02f,
  6.36392310e-02f, 4.73592095e-02f, 3.56850736e-02f, 2.26693265e-02f, -8.96798354e-03f, 5.37670292e-02f, 3.58022936e-03f, -7.31413215e-02f, -8.27974901e-02f, -3.37062664e-02f,
  1.47177011e-01f, -2.45427638e-02f, -2.58757677e-02f, 5.91987744e-02f, 1.31868443e-03f, 3.92491668e-02f, 8.12257975e-02f, 1.21012900e-03f, 1.42753078e-02f, -2.78811138e-02f,
  2.08600517e-02f, 2.38830045e-01f, -1.08985454e-01f, 6.33033738e-02f, 1.44897653e-02f, 1.05203707e-02f, 5.94700463e-02f, 1.00591988e-03f, 7.82795548e-02f, -2.14689765e-02f,
  4.55935858e-02f, 1.22548789e-01f, 8.04354027e-02f, -1.70383081e-01f, -2.32924186e-02f, -6.69430068e-04f, -1.35438427e-01f, 1.99708730e-01f, 8.63038823e-02f, -1.72154885e-02f,
  -9.57885757e-02f, -1.37733025e-02f, 9.51925665e-02f, 1.14163354e-01f, -1.20666005e-01f, 2.93237954e-01f, -3.70205217e-03f, -3.83049250e-02f, 1.86196938e-01f, -1.99553281e-01f,
  4.52230781e-01f, -2.66084462e-01f, -3.51252407e-01f, 4.61615101e-02f, -2.06828237e-01f, 5.84367961e-02f, -7.79162720e-02f, 1.62905246e-01f, 2.46668831e-01f, -1.48854464e-01f,
  1.31682470e-01f, 4.08624917e-01f, 3.37038100e-01f, 1.92990631e-01f, 1.31700084e-01f, -2.73140669e-01f, -3.79299432e-01f, 6.28882572e-02f, 3.39175284e-01f, 1.09152235e-01f,
  1.02667930e-02f, 3.60221602e-02f, 6.54840693e-02f, 3.70925367e-02f, -1.14651263e-01f, -5.14948228e-03f, -2.51748145e-01f, -5.29993363e-02f, -1.64076537e-01f, -4.88344997e-01f,
  -8.43355507e-02f, -4.24504355e-02f, 1.59959480e-01f, 2.03930307e-02f, -5.91987148e-02f, 5.81033789e-02f, 1.23248033e-01f, -7.72698149e-02f, 1.04130944e-02f, -4.84970883e-02f,
  -1.02118682e-02f, -1.42847225e-01f, -5.61555438e-02f, 6.46494403e-02f, -3.26373312e-03f, 3.00506670e-02f, 6.34396374e-02f, 1.26887366e-01f, 5.52748591e-02f, -3.76556031e-02f,
  -4.56868596e-02f, -1.63541753e-02f, 6.45875782e-02f, 1.19742222e-01f, 1.64577827e-01f, 1.25765979e-01f, 8.62811208e-02f, -2.34223846e-02f, 1.89286187e-01f, 1.36517823e-01f,
  3.83027121e-02f, 1.25424191e-01f, 8.51249695e-02f, 5.39430715e-02f, 1.44466519e-01f, 6.18651658e-02f, 4.24698070e-02f, -1.84593780e-04f, 5.60718402e-02f, -9.42328274e-02f,
  4.92042862e-02f, -1.53319221e-02f, 8.56205076e-02f, 6.20989166e-02f, -1.42065778e-01f, -2.36519650e-02f, -4.51519378e-02f, 1.33732855e-02f, -4.22456861e-02f, -3.84576060e-02f,
  -6.86734095e-02f, -8.28020573e-02f, -1.50201842e-01f, -8.40444863e-02f, -8.36496055e-03f, 3.51602137e-02f, -5.06283343e-02f, -2.54301932e-02f, 1.49565805e-02f, -5.98409260e-03f,
  -4.18747254e-02f, 6.54577464e-02f, -1.04113430e-01f, 5.29397726e-02f, -1.71500057e-01f, -2.94553526e-02f, -6.80504292e-02f, -7.35028759e-02f, -1.69541150e-01f, -8.94985422e-02f,
  -1.25814334e-01f, -6.66059777e-02f, -7.81512409e-02f, -1.65556252e-01f, 8.87228549e-03f, -7.70584792e-02f, -7.41805211e-02f, 5.52348793e-02f, -1.29298434e-01f, -9.61678550e-02f,
  -5.07608391e-02f, 8.27549323e-02f, 6.64747134e-02f, 1.34982765e-01f, 1.17237881e-01f, 5.23355789e-02f, 8.27479735e-02f, -6.27477989e-02f, 7.65744522e-02f, 6.40409663e-02f,
  -2.69302633e-02f, -2.07286458e-02f, 7.22607672e-02f, 2.53846347e-01f, 5.23262322e-02f, -3.44809562e-01f, -3.99472237e-01f, -3.17056239e-01f, 6.13404177e-02f, 4.80277725e-02f,
  4.40647709e-04f, 1.44439816e-01f, -1.94337480e-02f, -6.27231970e-02f, -2.62692571e-01f, -1.07921891e-01f, 1.94968894e-01f, 5.56001216e-02f, -2.54963249e-01f, -2.76846495e-02f,
  1.62305951e-01f, 1.12968214e-01f, 6.41936511e-02f, 4.48837988e-02f, 1.70048356e-01f, 1.12563014e-01f, 1.58815265e-01f, 1.58334836e-01f, 3.58065367e-02f, 6.02882028e-01f,
  1.74612507e-01f, -3.49728460e-03f, -4.51466478e-02f, 4.14982922e-02f, 2.02277541e-01f, 8.33241493e-02f, 1.51840582e-01f, 9.46087092e-02f, -9.31660011e-02f, -5.16698062e-02f,
  1.54048502e-01f, -1.57067813e-02f, -6.19959421e-02f, 3.81361954e-02f, -3.20722014e-02f, 4.43351306e-02f, 1.42750016e-03f, -4.54125069e-02f, -1.42600566e-01f, -2.88369469e-02f,
  -1.15684075e-02f, 5.75020202e-02f, -1.18875675e-01f, -2.19089031e-01f, -1.47777542e-01f, -1.52998015e-01f, -3.01560536e-02f, -9.09675285e-02f, -4.16225158e-02f, 2.17920914e-01f,
  2.30110046e-02f, 1.03052445e-02f, 1.15598507e-01f, 1.12659417e-01f, 8.49303976e-02f, 4.63204682e-02f, 1.12663195e-01f, 1.15559129e-02f, 1.53089957e-02f, 8.84800851e-02f,
  -8.53437707e-02f, 5.21313511e-02f, 1.67198956e-01f, -2.12482158e-02f, -1.19146854e-02f, 3.94634902e-02f, 1.30974710e-01f, -8.07538554e-02f, -6.97107464e-02f, 9.74823236e-02f,
  2.78800987e-02f, 3.79045233e-02f, -1.53418323e-02f, -5.24557419e-02f, -9.73814502e-02f, 5.79935908e-02f, 1.06750138e-01f, -2.85438970e-02f, -2.98646744e-02f, 5.51045127e-02f,
  2.39342675e-02f, -2.30322435e-01f, 1.26120195e-01f, 8.74522477e-02f, 8.20863321e-02f, 2.63264906e-02f, 1.14154719e-01f, 5.50992601e-03f, -3.94815840e-02f, -1.15230709e-01f,
  -1.37059689e-01f, 2.05109324e-02f, -7.73987323e-02f, -2.49459837e-02f, 5.33405170e-02f, 2.62870174e-02f, 1.99843735e-01f, 1.08521231e-01f, -1.77967232e-02f, 3.94336954e-02f,
  -9.11090672e-02f, -2.79407859e-01f, -3.00527155e-01f, -2.07627654e-01f, 1.45613477e-01f, -1.20787472e-01f, -4.49817032e-02f, -1.42173603e-01f, -1.52067468e-01f, -2.36373290e-01f,
  -3.76180619e-01f, -2.93518692e-01f, 2.29358986e-01f, 1.66889697e-01f, 3.86837870e-01f, 3.35530341e-01f, 2.50204057e-01f, 9.36561450e-03f, -5.71002811e-02f, 3.34405452e-02f,
  -8.12717453e-02f, -8.11885744e-02f, -1.76509812e-01f, -1.15307271e-01f, -6.68758973e-02f, 2.45859161e-01f, 2.51221448e-01f, 1.97108090e-01f, 2.82415092e-01f, 1.86751232e-01f,
  1.11780576e-01f, 1.57286853e-01f, -4.38788794e-02f, -3.33733261e-02f, 8.86908993e-02f, 1.96760684e-01f, 5.15187159e-02f, -3.09984200e-02f, 5.13708517e-02f, -1.10137817e-02f,
  1.25253588e-01f, -1.77446887e-01f, 9.18162689e-02f, -9.75062177e-02f, -1.45179614e-01f, -7.89086670e-02f, -1.12646908e-01f, -1.42163828e-01f, -2.10943781e-02f, 1.84643678e-02f,
  1.88063513e-02f, -1.76442489e-01f, -2.09049508e-02f, -1.22519165e-01f, 7.81985000e-02f, -1.41661819e-02f, -2.20882982e-01f, -7.32301921e-02f, -7.84043521e-02f, -1.22360736e-02f,
  -4.50725928e-02f, -3.95359322e-02f, 8.71711671e-02f, 1.19279288e-01f, -8.57387036e-02f, 1.12110628e-02f, -1.08637586e-01f, -2.61906143e-02f, -5.05137704e-02f, -1.10426480e-02f,
  7.85988569e-02f, -7.74718374e-02f, -1.31101474e-01f, -8.45038053e-03f, -1.24863625e-01f, -2.40825694e-02f, 1.91617967e-03f, 3.70201878e-02f, -2.03525578e-03f, -2.81137973e-02f,
  4.10229117e-02f, 4.18674238e-02f, 7.37265944e-02f, -7.05973059e-02f, -4.17800620e-02f, -1.23625025e-01f, 1.37061492e-01f, 2.63920873e-02f, -1.15709476e-01f, -1.00759730e-01f,
  -9.93847009e-03f, -3.32562365e-02f, -4.42419499e-02f, -4.63191569e-02f, -1.62760168e-01f, -7.92559236e-03f, 4.60753515e-02f, -4.96981107e-02f, -2.14310959e-02f, -4.12330404e-02f,
  3.32438022e-01f, -1.18393742e-01f, -8.80367607e-02f, -1.17446475e-01f, 5.02484180e-02f, -1.29938811e-01f, -2.23908853e-02f, 2.15136837e-02f, 1.42061822e-02f, 1.74904644e-01f,
  -4.12928313e-02f, 3.71175185e-02f, -2.65628919e-02f, 9.72267892e-03f, 4.26582284e-02f, 1.00515805e-01f, -9.21981484e-02f, 1.23202078e-01f, -3.51415090e-02f, 6.99042603e-02f,
  -7.60482450e-04f, 1.90231234e-01f, 2.25386173e-01f, 1.95808411e-01f, 2.31505066e-01f, 2.08387390e-01f, 8.49357322e-02f, 1.30529121e-01f, 5.06652370e-02f, 1.17212124e-01f,
  -2.17871487e-01f, 8.70209634e-02f, -3.95309366e-02f, 6.38271645e-02f, 1.83604628e-01f, 9.71272886e-02f, 8.01860727e-03f, -6.31063953e-02f, 8.68986920e-02f, 1.93561137e-01f,
  2.41046131e-01f, 1.56371370e-01f, 1.73290476e-01f, 7.31143951e-02f, -1.55321255e-01f, -2.03237608e-02f, 9.26478803e-02f, -8.87781456e-02f, -2.24868238e-01f, -9.99704525e-02f,
  2.19051421e-01f, -1.70119375e-01f, -3.30725938e-01f, -5.16125970e-02f, -2.36756671e-02f, 8.67751315e-02f, -1.86830871e-02f, -8.89928043e-02f, 1.29167110e-01f, 2.14711770e-01f,
  4.76472043e-02f, 5.30250696e-03f, 1.39641508e-01f, 8.93703252e-02f, 1.45652682e-01f, -2.06571907e-01f, -2.96002198e-02f, -1.89435184e-01f, 2.65704235e-03f, -5.82242608e-02f,
  -4.80573392e-03f, 2.05947179e-02f, 1.47311419e-01f, -5.37896827e-02f, -2.13742390e-01f, -1.50489330e-01f, -2.10000083e-01f, -1.66486919e-01f, -1.58756703e-01f, -1.04762413e-01f,
  2.34475762e-01f, -1.42908683e-02f, -2.19859108e-01f, -6.37762845e-02f, 3.16741727e-02f, -2.52937544e-02f, -1.42611608e-01f, -1.24109067e-01f, -2.32007474e-01f, -1.90445155e-01f,
  -1.57693520e-01f, -3.88209075e-02f, 1.13547325e-01f, 6.12977310e-04f, 1.08701319e-01f, 1.97113112e-01f, 6.65003359e-02f, 8.53558164e-03f, 8.13834220e-02f, -4.40570749e-02f,
  7.93255121e-02f, -2.37529743e-02f, -1.22779861e-01f, -3.51090054e-03f, -7.61031061e-02f, 1.98221020e-02f, 1.96360853e-02f, 9.68459249e-02f, -1.36087090e-01f, -7.66652599e-02f,
  -7.66832847e-03f, -9.60392877e-02f, 4.67991270e-02f, -2.71042846e-02f, 3.68098430e-02f, -5.94575703e-03f, -1.43333515e-02f, -6.50413856e-02f, -4.55314703e-02f, 4.60076518e-02f,
  -1.95960566e-01f, 1.62208378e-01f, 7.39772990e-02f, 1.26990095e-01f, -2.25948859e-02f, 7.12019876e-02f, 8.17361698e-02f, -3.37267518e-02f, -3.61126661e-02f, -4.91706282e-02f,
  -1.29248723e-02f, -3.40887345e-02f, 6.48105964e-02f, 5.32324500e-02f, -5.07243238e-02f, -3.83087024e-02f, -3.40321250e-02f, -2.34457082e-03f, -7.96481594e-02f, -9.89853665e-02f,
  -2.29048915e-02f, -1.26361534e-01f, -1.26112014e-01f, 7.10325548e-03f, -3.47984694e-02f, 6.88480958e-02f, -3.38498540e-02f, -1.55850947e-01f, -1.13370754e-01f, -2.88652569e-01f,
  -4.81699228e-01f, -1.52556285e-01f, 2.93136667e-02f, -2.74510205e-01f, 1.01626141e-03f, 8.25717971e-02f, 1.12543963e-01f, -3.45221870e-02f, -3.19147021e-01f, -1.33646965e-01f,
  -7.90008605e-02f, -1.86710060e-01f, -3.87001820e-02f, 1.24864839e-01f, 2.22215101e-01f, 1.27956331e-01f, 2.12626025e-01f, 2.23546878e-01f, 2.29281560e-01f, 1.91400245e-01f,
  7.86816180e-02f, -6.64083213e-02f, 1.77371260e-02f, 4.08542044e-02f, -2.34418288e-01f, -1.19126529e-01f, -6.74427152e-02f, -9.44927782e-02f, 1.38768619e-02f, -2.14773901e-02f,
  -1.51196137e-01f, -4.22589034e-01f, 1.13261797e-01f, 3.37506831e-02f, -5.79013638e-02f, -7.77996033e-02f, 9.70818624e-02f, -7.37793148e-02f, 2.25268640e-02f, -1.78967312e-01f,
  -1.55420482e-01f, -1.14954943e-02f, -1.17301643e-01f, -2.32052971e-02f, -1.39364928e-01f, -3.19538079e-02f, 2.70937663e-02f, 2.40606926e-02f, 1.13510515e-03f, -1.04915090e-01f,
  1.10409670e-01f, -1.65773518e-02f, -6.94470331e-02f, 5.11765741e-02f, -1.13801435e-02f, 1.14828654e-01f, -5.20956935e-03f, 3.43388282e-02f, 3.41465175e-02f, -2.65592426e-01f,
  3.02430266e-03f, -4.91099991e-02f, 3.16008739e-02f, -3.88438962e-02f, -2.20828112e-02f, 4.77743372e-02f, 7.53327534e-02f, 7.38902614e-02f, 1.19281873e-01f, 3.38618234e-02f,
  1.31394580e-01f, -2.04737820e-02f, -2.42966861e-02f, 8.98229033e-02f, 9.18712616e-02f, -1.93957493e-01f, 1.37263149e-01f, 4.95567061e-02f, -5.72687685e-02f, 7.25310966e-02f,
  1.85222737e-02f, -1.64353430e-01f, -6.98664784e-02f, 8.72874185e-02f, 7.61879310e-02f, 1.41478717e-01f, 6.52335491e-03f, -3.20639536e-02f, -7.05532432e-02f, 4.11527744e-03f,
  -2.53530413e-01f, 4.25236851e-01f, -3.24027836e-01f, -6.24757521e-02f, -1.46536008e-02f, 8.53374228e-02f, -1.11239016e-01f, 3.21515203e-02f, -1.15447037e-01f, -1.50443822e-01f,
  1.42973848e-03f, -5.91908880e-02f, -1.73079684e-01f, 5.01574799e-02f, 1.12659894e-01f, -1.03008993e-01f, 6.78856745e-02f, -4.35404889e-02f, -6.62568840e-04f, -1.65566251e-01f,
  1.57074422e-01f, 3.94049585e-02f, -1.11515164e-01f, -6.45336360e-02f, -1.05620220e-01f, -1.17897987e-01f, -5.45432083e-02f, -4.93174680e-02f, 2.72194315e-02f, -2.14798525e-01f,
  -4.26127434e-01f, 6.17871843e-02f, 2.64268219e-01f, -3.68129201e-02f, 1.17496014e-01f, -2.25932114e-02f, -3.34287077e-01f, -2.02275366e-01f, -2.85071731e-02f, -3.84483747e-02f,
  -5.59072010e-03f, -1.21090636e-02f, 5.98404594e-02f, 6.58837333e-02f, -2.93248951e-01f, -3.20093066e-01f, -1.45047292e-01f, -2.38643616e-01f, -1.72689244e-01f, -1.75940722e-01f,
  -2.32316941e-01f, -3.55171829e-01f, -3.13870490e-01f, -9.27426741e-02f, 8.99277627e-02f, 1.43827721e-01f, -2.02942248e-02f, -1.25893578e-02f, 4.01467532e-02f, 7.65045080e-03f,
  1.51324362e-01f, 1.83502167e-01f, 1.86764449e-01f, 8.36158618e-02f, 5.23288995e-02f, 4.43287157e-02f, 5.73764853e-02f, 1.51558056e-01f, 5.82170533e-03f, 5.06010801e-02f,
  -9.29901972e-02f, 7.65847042e-02f, -1.14501193e-01f, -3.09992041e-02f, -1.07071444e-01f, -5.55641428e-02f, 6.54933527e-02f, 3.44665200e-02f, -1.37709752e-02f, 1.17571205e-01f,
  8.60617589e-03f, 1.83883042e-03f, 1.50946245e-01f, 2.91024208e-01f, 1.61708549e-01f, 1.83190748e-01f, 2.43970633e-01f, 1.99105203e-01f, 3.37228090e-01f, 2.07014680e-01f,
  -1.68818027e-01f, 1.33722335e-01f, 1.97328150e-01f, 2.08515450e-02f, -1.21319234e-01f, -8.94799754e-02f, 6.39255866e-02f, -1.81491479e-01f, -1.18230030e-01f, -4.08459688e-03f,
  3.19103152e-02f, -9.15944204e-03f, -6.61916211e-02f, -5.56998774e-02f, 1.58243537e-01f, 1.30199557e-02f, 3.82892974e-02f, -1.33374985e-02f, 1.58681050e-01f, 8.65596309e-02f,
  7.39608407e-02f, -6.50250763e-02f, -1.26347095e-01f, -4.03063111e-02f, 1.24554075e-01f, 1.62052289e-01f, 3.02463137e-02f, 4.92993407e-02f, -5.54515943e-02f, -5.09448070e-03f,
  -7.40811303e-02f, 3.47763568e-01f, -6.24003373e-02f, -1.67238653e-01f, 1.41332997e-02f, 7.25511238e-02f, 2.15827361e-01f, 8.93189665e-03f, -7.18978122e-02f, 4.72503901e-02f,
  -5.32465130e-02f, -1.23864688e-01f, -9.27422121e-02f, 4.68595214e-02f, -1.35142952e-01f, -4.11188863e-02f, -9.34586152e-02f, -1.91049129e-01f, 1.17886454e-01f, 6.32646531e-02f,
  4.88966852e-02f, -1.56642675e-01f, -2.13308558e-02f, -4.65858914e-03f, -8.76614153e-02f, -1.62502080e-01f, 6.64584860e-02f, 5.30340858e-02f, 1.59661192e-02f, -1.60460442e-01f,
  9.82722789e-02f, 2.77415931e-01f, 1.65892348e-01f, 3.29747275e-02f, -2.11332083e-01f, 7.20188320e-02f, 4.13948506e-01f, 2.21896097e-01f, -6.88631013e-02f, 7.49014467e-02f,
  -1.25246823e-01f, -1.87284201e-01f, -7.20501542e-02f, 7.45847151e-02f, 1.94373071e-01f, 2.73887187e-01f, 1.03932276e-01f, 1.08264342e-01f, 1.26322269e-01f, -1.45245381e-02f,
  -8.83757398e-02f, -1.69289485e-02f, 2.21115556e-02f, -4.81433980e-02f, 1.63951188e-01f, -4.99579646e-02f, -3.70183364e-02f, 6.22355081e-02f, -2.26833057e-02f, 6.01437502e-02f,
  -9.70613658e-02f, 1.87943906e-01f, -1.58281401e-01f, -2.79440165e-01f, -2.28631169e-01f, -6.77474141e-02f, -1.32166460e-01f, -1.53379878e-02f, 2.35852376e-02f, 4.26364457e-03f,
  1.92021709e-02f, -1.93419419e-02f, 1.70714572e-01f, 5.77688254e-02f, -4.65259627e-02f, -2.30638590e-02f, 8.19297731e-02f, 2.43131220e-01f, 4.16944697e-02f, 6.43955320e-02f,
  -1.79355815e-02f, -2.18072250e-01f, -5.19957058e-02f, 1.47711024e-01f, 1.15927570e-01f, -5.32011390e-02f, -7.05393478e-02f, 1.40678793e-01f, 1.53528317e-03f, 1.99339002e-01f,
  7.80770183e-02f, 5.47278412e-02f, 7.97596481e-03f, 2.02106848e-01f, 4.99625765e-02f, -1.00998916e-01f, 9.53602567e-02f, -1.70960091e-04f, 3.04577053e-02f, 4.64239605e-02f,
  6.50077239e-02f, 5.35645768e-06f, 2.84047816e-02f, 6.09185211e-02f, -6.15851358e-02f, -4.74389866e-02f, 8.45082551e-02f, 3.37487869e-02f, -4.92805988e-02f, 3.66094634e-02f,
  8.08157176e-02f, -5.06586395e-02f, -1.97866783e-01f, 3.54688503e-02f, 1.45031819e-02f, -1.46682346e-02f, -3.06580365e-02f, -3.06759402e-02f, -2.40817368e-02f, -3.54148671e-02f,
  -2.24518582e-01f, -2.43970543e-01f, -1.49268106e-01f, -6.97080046e-02f, -1.90033227e-01f, -2.33005047e-01f, -1.46412954e-01f, -1.19827278e-01f, -6.65937364e-02f, -1.24580927e-01f,
  -5.72387539e-02f, 5.92281520e-02f, 1.02766249e-02f, 1.71215448e-04f, -1.49603739e-01f, -6.10092236e-03f, -9.25718471e-02f, -1.36165740e-03f, -1.85933951e-02f, -4.56180833e-02f,
  -5.38045391e-02f, -1.08710453e-01f, -1.04427390e-01f, 4.66198623e-02f, -1.37528718e-01f, -2.12798655e-01f, -2.14971527e-01f, -4.72522853e-03f, -1.62793789e-02f, -8.05029050e-02f,
  -4.49090928e-01f, -2.21303448e-01f, -1.22513495e-01f, 4.90734838e-02f, 1.75180897e-01f, 2.61096299e-01f, 1.91193506e-01f, -1.57705173e-02f, 8.26585069e-02f, -4.17003334e-02f,
  8.58841538e-02f, 1.47192940e-01f, 1.43181354e-01f, 9.34470445e-02f, 1.89496368e-01f, 1.14165373e-01f, 2.44362518e-01f, -4.17027920e-02f, 6.19955249e-02f, 1.20424712e-02f,
  1.45946920e-01f, -9.07276943e-02f, -1.27110556e-01f, 3.13221291e-02f, 5.63399913e-03f, 1.11274950e-01f, 1.22947441e-02f, 3.32849026e-02f, 4.26601730e-02f, 2.16979623e-01f,
  4.77622710e-02f, -1.36940449e-01f, 1.30659088e-01f, -1.34952292e-02f, -2.34784316e-02f, -1.96228310e-01f, -9.92103741e-02f, -1.60864443e-01f, -6.43292964e-02f, -9.35378745e-02f,
  -7.69216567e-03f, -1.14968389e-01f, -3.36743109e-02f, -1.79991171e-01f, -1.28508672e-01f, -1.18587382e-01f, -1.02108218e-01f, 2.79431883e-02f, 1.65897295e-01f, 1.51827842e-01f,
  1.48488075e-01f, 6.43302575e-02f, 6.00301996e-02f, 1.27845451e-01f, 9.42458734e-02f, 7.48914927e-02f, -7.70483315e-02f, 2.74481568e-02f, 1.18349470e-01f, -4.73551042e-02f,
  1.59792393e-01f, -1.09519437e-01f, 7.71611137e-03f, 3.78428120e-03f, 5.74887842e-02f, 6.38938369e-03f, 9.92880464e-02f, 1.05847027e-02f, 8.89968574e-02f, -1.24221630e-01f,
  1.02021940e-01f, 1.54568046e-01f, 8.30522776e-02f, 3.72838452e-02f, 8.35560709e-02f, 1.71441399e-02f, 8.98677036e-02f, 9.69041288e-02f, -4.56991866e-02f, 2.74270140e-02f,
  -3.30843665e-02f, 4.81719375e-02f, -2.00772122e-01f, 4.01854366e-02f, 3.06555312e-02f, -5.50434552e-03f, 5.77305444e-02f, -2.36307960e-02f, -7.69512355e-02f, -2.28603533e-03f,
  7.56094828e-02f, 2.46397674e-01f, -4.61607706e-04f, 7.90057778e-02f, -7.30821341e-02f, -1.05379812e-01f, 7.17547759e-02f, 2.15372201e-02f, 3.72441742e-03f, 8.89985077e-03f,
  1.03838360e-02f, -1.34121478e-01f, -6.92960098e-02f, -1.33411601e-01f, -1.60694525e-01f, -1.22534707e-01f, -7.73398429e-02f, -7.76140811e-03f, 9.00218338e-02f, 8.99772942e-02f,
  1.20194014e-02f, 1.92109272e-01f, 1.19649060e-01f, 1.43736318e-01f, 7.52108991e-02f, 1.08267337e-01f, -1.12281568e-01f, -4.85226177e-02f, -1.98097005e-02f, -6.99889138e-02f,
  7.40981698e-01f, -3.43936145e-01f, -2.68779099e-01f, 1.45189855e-02f, 5.07100150e-02f, 6.49254024e-02f, 5.85520938e-02f, 1.80285484e-01f, 1.48233533e-01f, -9.39330906e-02f,
  -2.17983704e-02f, 1.89854130e-01f, -4.74733263e-02f, -3.81644554e-02f, 1.10948786e-01f, -1.54984057e-01f, -2.50277668e-01f, -1.02131397e-01f, 2.85425514e-01f, 2.22209454e-01f,
  -1.90992549e-01f, -7.44708478e-02f, 9.98192951e-02f, -5.65707125e-02f, -3.96332294e-01f, -8.97357613e-02f, -3.10109466e-01f, -1.40777677e-01f, -5.56381010e-02f, -5.90187252e-01f,
  -3.97302091e-01f, 1.66397125e-01f, 2.15275567e-02f, 9.02390406e-02f, 1.34913009e-02f, 1.13615163e-01f, 1.28046870e-01f, 7.73041770e-02f, 4.23662551e-02f, -9.08956900e-02f,
  -6.92139417e-02f, -9.26055461e-02f, 8.76014158e-02f, 9.66560245e-02f, -9.08841267e-02f, 8.81534219e-02f, 2.43116152e-02f, 1.15415417e-01f, 2.98810787e-02f, -1.07089289e-01f,
  -5.01948446e-02f, 2.31676251e-01f, 1.93428159e-01f, 8.66565853e-02f, 4.35863249e-02f, 1.77405760e-01f, -3.15753967e-02f, 3.07881329e-02f, 1.42901301e-01f, -8.32620934e-02f,
  -6.03340901e-02f, -1.34462584e-02f, 5.06583564e-02f, 6.16020896e-02f, 5.95585071e-02f, 3.96792367e-02f, 2.87564490e-02f, -4.35369611e-02f, 5.97858354e-02f, -1.82697520e-01f,
  -2.28167474e-02f, -8.40605497e-02f, 1.51046410e-01f, -1.79550480e-02f, -7.30120316e-02f, -1.36974631e-02f, 5.59936324e-03f, -4.24599983e-02f, -4.15674746e-02f, 1.37784202e-02f,
  5.96646070e-02f, -3.44556049e-02f, -1.09732144e-01f, 2.14612149e-02f, -2.03871243e-02f, -1.39946919e-02f, -1.08286865e-01f, 1.09598599e-01f, -9.70835239e-03f, 3.71169783e-02f,
  7.88707845e-03f, 1.13426246e-01f, -1.16902716e-01f, -8.95866484e-04f, -2.57179327e-02f, -1.41465217e-01f, -4.86225337e-02f, -1.32617742e-01f, -4.58116308e-02f, -3.13455611e-02f,
  3.80968116e-02f, -3.27393115e-02f, -5.15043177e-02f, -8.52117036e-03f, -2.74746655e-03f, 5.37100658e-02f, 4.41676341e-02f, 1.17023759e-01f, 2.57787369e-02f, -2.27832317e-01f,
  -8.28860477e-02f, 1.01470046e-01f, 2.02039823e-01f, 1.35706857e-01f, -4.49247211e-02f, 8.37799311e-02f, -6.30379561e-03f, -6.13599345e-02f, 7.40029812e-02f, 8.08197483e-02f,
  5.34676909e-01f, -1.99713811e-01f, 3.25589687e-01f, 3.43253225e-01f, 1.47120342e-01f, 2.94264674e-01f, 2.45743617e-01f, 1.62648574e-01f, -4.85068783e-02f, 1.07650518e-01f,
  5.78271784e-02f, -6.59923181e-02f, -1.49688482e-01f, -9.74750891e-02f, -1.44112669e-02f, -6.07659556e-02f, -5.95401935e-02f, 5.99592440e-02f, 3.03673208e-01f, 2.08505586e-01f,
  -4.80860323e-02f, 6.10023253e-02f, 7.76593760e-02f, -2.53798682e-02f, -1.48086753e-02f, 4.84289080e-02f, -3.58295254e-02f, -2.07016822e-02f, -5.96178025e-02f, -1.68514743e-01f,
  -1.49525657e-01f, 2.03872338e-01f, 1.33671701e-01f, -8.24613571e-02f, -3.52300443e-02f, -9.37782675e-02f, -2.57893670e-02f, -5.54438643e-02f, -1.00026369e-01f, -1.65506169e-01f,
  -2.10324764e-01f, -1.17724970e-01f, -3.71123967e-03f, 6.05211556e-02f, 7.90405348e-02f, 1.35718033e-01f, 2.09058970e-02f, -1.29709125e-01f, -5.73444031e-02f, -1.20416805e-01f,
  -2.38239877e-02f, 1.40806079e-01f, 1.24582775e-01f, 4.90353145e-02f, 1.31270647e-01f, 9.65491459e-02f, 1.91486068e-03f, 3.68716344e-02f, 1.51190415e-01f, -2.30957959e-02f,
  -7.34109804e-03f, 8.80715176e-02f, 6.42059073e-02f, 5.57580311e-03f, -1.09889712e-02f, -3.39930393e-02f, -4.55542579e-02f, -5.69796376e-02f, 1.37960091e-01f, -4.80794534e-03f,
  1.07555397e-01f, 2.16810759e-02f, -8.27390999e-02f, 7.01545030e-02f, -2.32052598e-02f, -1.65415625e-03f, -8.88406038e-02f, -1.14101388e-01f, 2.69990955e-02f, -1.16354953e-02f,
  7.44290054e-02f, -3.78177166e-02f, 8.48890170e-02f, 6.75794110e-02f, 8.73919576e-02f, 2.96693426e-02f, -8.05567298e-03f, -5.80492765e-02f, 5.25924750e-02f, 9.44546461e-02f,
  -5.38059413e-01f, 1.79684028e-01f, 4.15834710e-02f, -1.02440476e-01f, 8.01569447e-02f, -4.33962345e-02f, 3.52507345e-02f, -1.65734619e-01f, -2.90004253e-01f, -2.01976568e-01f,
  2.39916388e-02f, -5.52400900e-03f, 2.30814125e-02f, 1.42725945e-01f, -5.30221453e-03f, -3.36335674e-02f, -6.79766163e-02f, -4.55960743e-02f, -1.14262260e-01f, -1.70207918e-01f,
  3.62525657e-02f, 3.40566076e-02f, 9.13443491e-02f, 2.74436325e-02f, -6.71052411e-02f, 1.63991705e-01f, 5.56681491e-02f, 9.32753980e-02f, 3.09050968e-03f, 3.81892100e-02f,
  -3.84484351e-01f, 3.08602088e-04f, 1.13269500e-02f, 5.85717745e-02f, -1.16947062e-01f, -1.96809739e-01f, -2.61601627e-01f, -2.17388764e-01f, -9.46072042e-02f, -7.56865442e-02f,
  8.53364449e-03f, 3.59711908e-02f, -7.62619972e-02f, -6.33202568e-02f, -3.48147660e-01f, -2.20962226e-01f, -1.89623952e-01f, -3.14405441e-01f, -2.54578859e-01f, -1.60768583e-01f,
  -1.60463810e-01f, -1.57309562e-01f, -1.16427153e-01f, -1.20517120e-01f, 9.22073498e-02f, -1.42017100e-02f, 6.02305233e-02f, -3.23816054e-02f, 2.01425329e-02f, 9.08142999e-02f,
  5.14943860e-02f, -2.55686510e-02f, -3.65283713e-02f, 1.16962120e-02f, 1.42534956e-01f, 6.67425543e-02f, -8.47252756e-02f, 3.69825140e-02f, 8.32938030e-02f, 1.51666909e-01f,
  -1.17493887e-02f, 6.38737828e-02f, -1.87111534e-02f, -6.70628473e-02f, 7.91209191e-02f, 6.97497651e-02f, 1.44883081e-01f, -5.17209470e-02f, -1.70485545e-02f, 4.60819788e-02f,
  1.20700665e-01f, 5.07548936e-02f, 4.16430198e-02f, 8.91999453e-02f, -2.37377919e-02f, 1.11799203e-01f, 1.57868147e-01f, 5.60587309e-02f, 9.86545384e-02f, 7.85046890e-02f,
  -9.73887071e-02f, -1.48236454e-01f, -1.05961502e-01f, -7.53158778e-02f, -4.33744639e-02f, 1.97770223e-02f, -6.01003058e-02f, -1.04297042e-01f, -2.35447541e-01f, -9.15116966e-02f,
  -5.55043761e-03f, -8.19506794e-02f, 2.51916349e-02f, -5.87761588e-02f, 5.68060279e-02f, -7.45408684e-02f, -7.48268738e-02f, 1.28336353e-02f, 2.12173924e-01f, -5.43815009e-02f,
  -7.03948960e-02f, 1.31076261e-01f, 1.46872997e-02f, -7.42044821e-02f, 7.13173300e-03f, -7.43425712e-02f, 7.64674917e-02f, -7.50234500e-02f, -2.56038941e-02f, -8.12525228e-02f,
  -2.28027347e-02f, -2.33971566e-01f, -1.07655972e-01f, -7.43165091e-02f, 4.71898504e-02f, 1.77846417e-01f, 8.20302889e-02f, -6.91319481e-02f, 8.00852031e-02f, 2.05316916e-02f,
  2.55866405e-02f, 9.39538609e-03f, 2.23506726e-02f, 4.65594493e-02f, 5.68595529e-02f, 8.35426152e-02f, 1.66479751e-01f, 7.78112411e-02f, 5.65627627e-02f, 2.11715028e-01f,
  9.94881764e-02f, -9.16690305e-02f, 9.35567729e-03f, 9.53076780e-02f, 5.53848818e-02f, -9.77787599e-02f, 8.28882381e-02f, -6.21453393e-03f, -1.48845196e-01f, 2.30129641e-02f,
  2.08565235e-01f, -6.39564633e-01f, 2.58840799e-01f, 2.97754437e-01f, 3.14511597e-01f, 3.30426037e-01f, 9.18608904e-02f, 1.85164157e-02f, 6.40190840e-02f, -6.70014471e-02f,
  -1.17919326e-01f, 1.62868276e-02f, -6.45690039e-02f, -4.98758070e-02f, 1.57016348e-02f, 1.10941224e-01f, 1.79376211e-02f, 1.86230808e-01f, 3.38198960e-01f, 3.28654766e-01f,
  -8.96672979e-02f, 4.45649065e-02f, -4.81013581e-02f, 5.52646928e-02f, -1.69659749e-01f, 1.75076455e-01f, -5.58055528e-02f, -1.24915794e-01f, -2.00295582e-01f, -3.56779903e-01f,
  1.49762496e-01f, -1.76095009e-01f, 2.78706133e-01f, -8.52464586e-02f, 2.88556982e-02f, -3.40225026e-02f, 4.74479571e-02f, -3.61075476e-02f, -5.70331998e-02f, -7.27296621e-02f,
  -1.27004281e-01f, -2.08399892e-02f, 8.35798532e-02f, -8.05380046e-02f, -9.76330116e-02f, 1.46285053e-02f, -1.15926892e-01f, -1.91418156e-01f, -2.07612723e-01f, -1.18363835e-01f,
  -7.11539239e-02f, -6.83879182e-02f, -1.36324123e-01f, -1.20987799e-02f, -2.38578897e-02f, 1.02438785e-01f, -1.35709792e-01f, -5.82134500e-02f, -7.01115429e-02f, -1.24014415e-01f,
  5.33485562e-02f, -7.23646209e-02f, -1.67333521e-02f, -6.33774251e-02f, 8.89383703e-02f, -3.49798910e-02f, 5.26081659e-02f, -2.59359963e-02f, -4.92851585e-02f, -1.51373949e-02f,
  1.20797560e-01f, -8.15916434e-02f, -8.94269943e-02f, -3.11980397e-02f, -1.43569797e-01f, 2.04912573e-02f, -4.60830107e-02f, -6.53098430e-03f, -3.99017558e-02f, 8.30701515e-02f,
  -2.83724722e-02f, -2.83820257e-02f, -3.55740217e-03f, -3.72868031e-02f, -1.92200094e-02f, 7.07319304e-02f, 3.97720560e-02f, 6.62121223e-03f, 1.00571441e-03f, -1.39905075e-02f,
  -2.12456822e-01f, 5.07525122e-03f, 5.53652048e-02f, -1.84790418e-01f, -8.38917494e-02f, -5.05063795e-02f, 7.43465265e-03f, -6.21319339e-02f, 9.42584798e-02f, 8.69755894e-02f,
  -1.22977652e-01f, 8.73552337e-02f, -1.18766367e-01f, -5.33283427e-02f, 9.61555913e-02f, 1.83806624e-02f, -2.32268214e-01f, 2.69431043e-02f, -3.42110731e-02f, 2.63364948e-02f,
  -7.66558349e-02f, 1.09962432e-03f, 1.94523931e-01f, 2.61789020e-02f, -2.12134942e-02f, 2.41726682e-01f, 1.18870601e-01f, 2.52404008e-02f, 1.45896912e-01f, 1.28012851e-01f,
  -5.16557634e-01f, 1.80299759e-01f, -1.05457023e-01f, -2.66288340e-01f, 3.33919853e-01f, 2.68693566e-01f, 4.10055190e-01f, 5.86220659e-02f, -1.15346886e-01f, 2.25151122e-01f,
  1.93474174e-01f, 1.10363273e-03f, 8.09547976e-02f, 1.12101875e-01f, -7.94219077e-02f, 2.61356533e-01f, 1.63760811e-01f, -8.93870220e-02f, -1.72288001e-01f, -8.05851743e-02f,
  6.82483315e-02f, -1.58351451e-01f, -3.36840302e-01f, -1.06697947e-01f, 1.72069129e-02f, -1.13126524e-01f, 7.02897366e-03f, -1.14892200e-01f, 7.85121396e-02f, 5.18795103e-02f,
  -1.14675596e-01f, -5.51101454e-02f, 1.73911583e-02f, -3.12918723e-02f, -1.30557433e-01f, -1.66028902e-01f, -7.87010789e-02f, -1.05120942e-01f, -6.50105104e-02f, 1.57464221e-02f,
  -2.53340602e-03f, -5.87375723e-02f, -8.57943073e-02f, 7.27344751e-02f, -8.69294554e-02f, -4.13495116e-02f, -3.84054554e-04f, -1.33006826e-01f, -9.14134607e-02f, 7.14391321e-02f,
  2.60501981e-01f, 2.47642577e-01f, 6.11593090e-02f, 1.63262844e-01f, 8.15327540e-02f, -8.81307721e-02f, 3.53952013e-02f, -3.91192734e-02f, -8.48541707e-02f, -1.95875660e-01f,
  -7.54704757e-04f, 6.11675717e-02f, 6.75257891e-02f, 2.97277397e-03f, 4.49322686e-02f, -6.95525333e-02f, 1.06280543e-01f, 1.30507588e-01f, -7.92362839e-02f, -8.20871741e-02f,
  1.37545571e-01f, 1.35891454e-03f, -3.56168188e-02f, -4.82605062e-02f, 1.24251842e-01f, 4.94115874e-02f, 7.66599625e-02f, 1.32309962e-02f, 7.35396668e-02f, -6.21844977e-02f,
  1.78539027e-02f, -2.52920035e-02f, 4.36472446e-02f, -3.58644389e-02f, 2.73320023e-02f, -3.61174233e-02f, -2.93152984e-02f, 2.23358814e-02f, 8.02756995e-02f, -6.04303135e-03f,
  -2.03046113e-01f, 7.25422278e-02f, -1.80278078e-01f, 1.22311480e-01f, 9.34577733e-02f, -1.53706400e-02f, 2.69759968e-02f, 8.59063864e-02f, 2.28067320e-02f, 8.72624200e-03f,
  1.26508586e-02f, -1.68887287e-01f, 2.55202726e-02f, -3.69175896e-03f, -1.13471057e-02f, 5.55480318e-03f, 1.76990956e-01f, 3.28862406e-02f, 1.47717565e-01f, -4.71357293e-02f,
  5.44783361e-02f, 1.35572866e-01f, -5.37400022e-02f, -1.24629317e-02f, -1.14873439e-01f, -1.57005116e-01f, -5.77053092e-02f, -1.76868454e-01f, -1.63859263e-01f, -2.64872193e-01f,
  3.01480800e-01f, -5.61459780e-01f, 8.78411308e-02f, 2.06461132e-01f, 2.20874265e-01f, 2.28217751e-01f, 5.09588383e-02f, 2.62763780e-02f, -9.35051590e-03f, -1.13585353e-01f,
  -1.96552381e-01f, -1.18793644e-01f, -2.05654860e-01f, -1.30962104e-01f, -6.00329079e-02f, 1.10580072e-01f, 1.03585094e-01f, 2.85362929e-01f, 4.29677635e-01f, 2.26807564e-01f,
  -7.96170831e-02f, 1.10621691e-01f, 2.72719655e-02f, 9.33293998e-02f, -1.39862195e-01f, 6.14343695e-02f, 4.66791214e-03f, 1.73906027e-03f, -1.27388582e-01f, -3.23811471e-01f,
  -8.52252394e-02f, -1.65319502e-01f, 1.02973342e-01f, -9.44096893e-02f, -8.78646523e-02f, -5.34291156e-02f, 6.79858327e-02f, 4.56447154e-02f, 9.52312648e-02f, 6.03240542e-02f,
  -8.18787590e-02f, -1.01209521e-01f, -8.68391916e-02f, -1.37026817e-01f, 3.93538317e-03f, 3.55985649e-02f, -4.31255512e-02f, -3.34675387e-02f, -2.03935355e-01f, -1.48602962e-01f,
  -1.30092904e-01f, -4.30868044e-02f, -7.51115605e-02f, -5.19645289e-02f, 7.77209178e-02f, -1.91176664e-02f, -7.05734864e-02f, 4.49830405e-02f, -6.97812513e-02f, 2.27862205e-02f,
  1.47649765e-01f, 9.69373155e-04f, -1.30016983e-01f, 4.32475545e-02f, -2.89891008e-02f, -5.19970916e-02f, 7.31918439e-02f, -2.42165029e-02f, 2.39695385e-02f, -1.04054764e-01f,
  3.40626054e-02f, 1.05944173e-02f, 1.29492236e-02f, -2.42521535e-04f, -1.75518900e-01f, -3.39733250e-02f, -2.80049108e-02f, -1.03044227e-01f, -4.57227677e-02f, -1.21059202e-01f,
  -6.09151945e-02f, -2.52155238e-03f, -9.17534754e-02f, -1.43224001e-01f, -1.35016739e-01f, 7.76334293e-03f, -1.01795398e-01f, -1.12053536e-01f, 4.69100252e-02f, 1.02081150e-01f,
  -2.35233575e-01f, 4.66327220e-02f, 4.34363401e-03f, -1.35204002e-01f, 2.76862681e-02f, -1.14085220e-01f, -1.40610501e-01f, -5.22291809e-02f, -2.27740463e-02f, 1.01728737e-01f,
  8.05263817e-02f, -3.69570367e-02f, -2.75981184e-02f, -9.11178365e-02f, 7.27803186e-02f, 1.36818692e-01f, -1.97512880e-01f, -3.03201228e-02f, -9.93448868e-02f, -1.54216141e-01f,
  -1.70020878e-01f, 1.03159383e-01f, 5.09749278e-02f, 1.32005401e-02f, 1.07043006e-01f, 1.38919890e-01f, 1.03710629e-02f, 1.28414035e-01f, 1.86601162e-01f, 1.44770771e-01f,
  -3.09368074e-01f, 7.73901865e-02f, 3.51482048e-03f, 1.45060673e-01f, 2.22965568e-01f, -7.64646456e-02f, -3.21131915e-01f, -9.69312061e-03f, 1.52343303e-01f, 9.32358503e-02f,
  9.66375023e-02f, 9.76449996e-02f, -2.35858262e-02f, -1.98885556e-02f, -4.00395542e-01f, -4.32293504e-01f, -2.09087431e-01f, -3.77766222e-01f, -3.32424849e-01f, -4.48824503e-02f,
  -4.24526818e-02f, -1.21536411e-01f, -2.16246188e-01f, 4.98131104e-02f, 1.38535440e-01f, 2.25925762e-02f, -8.44938457e-02f, -1.05907492e-01f, -9.42829624e-02f, 9.16039664e-03f,
  -1.58646598e-01f, -1.77099984e-02f, 4.60163765e-02f, 8.91945213e-02f, 4.90512960e-02f, -1.60747375e-02f, -1.34270251e-01f, -1.02504879e-01f, 7.35563487e-02f, -8.68639164e-03f,
  8.07907134e-02f, 4.35015336e-02f, -1.96153633e-02f, 4.05399241e-02f, 6.71872450e-03f, -3.76704484e-02f, 3.31164673e-02f, 4.06126603e-02f, 4.83683869e-02f, 6.85116649e-02f,
  1.60628498e-01f, 1.36485659e-02f, 2.12106369e-02f, 9.56132337e-02f, 6.06768057e-02f, 3.56013700e-02f, 8.32902417e-02f, 1.88463062e-01f, 1.32266760e-01f, -1.73633024e-02f,
  4.63377945e-02f, 4.04368602e-02f, 1.94253970e-03f, -2.57481169e-02f, 2.91740354e-02f, 4.04181443e-02f, 3.59783508e-02f, -3.46797295e-02f, -1.18811525e-01f, 3.41573805e-02f,
  -3.06537300e-02f, 8.49295291e-04f, -1.23922855e-01f, -1.38586745e-01f, -1.48699079e-02f, 5.60441799e-02f, 5.24922162e-02f, -6.32687137e-02f, 3.63409594e-02f, 7.59207010e-02f,
  6.79949149e-02f, 1.44771695e-01f, -9.41825192e-03f, -3.67293470e-02f, 3.67496535e-02f, 7.81710446e-02f, 1.09771751e-01f, 3.73302959e-02f, 7.28931976e-03f, 9.09637585e-02f,
  -1.59851417e-01f, -1.73218951e-01f, -5.24011441e-02f, 1.04674518e-01f, -5.36475852e-02f, 6.15903921e-02f, 2.92725433e-02f, -1.51346419e-02f, 5.21272235e-02f, 3.65725942e-02f,
  -1.21722044e-02f, -9.92363170e-02f, -1.64569039e-02f, 1.31809145e-01f, 6.33586850e-03f, 5.13246693e-02f, -6.98322104e-03f, 3.95029597e-02f, -1.34824840e-02f, 2.80782014e-01f,
  1.09039642e-01f, -3.78218628e-02f, -1.01174645e-01f, 1.07543588e-01f, 5.18845953e-02f, -1.46583110e-01f, -1.17331512e-01f, 1.02712736e-01f, -1.93734378e-01f, -2.51235217e-01f,
  -1.60930157e-01f, -1.95785701e-01f, -3.04467157e-02f, 1.40028119e-01f, 7.29871318e-02f, -5.05189337e-02f, -1.80249050e-01f, 1.24987833e-01f, 2.57734746e-01f, -1.72199085e-01f,
  4.80734892e-02f, 2.15670422e-01f, 2.72812620e-02f, 2.26493906e-02f, -3.18321556e-01f, -3.73714179e-01f, -3.00554037e-01f, -1.34282663e-01f, 2.01467559e-01f, 2.44981915e-01f,
  1.47026196e-01f, 4.33825217e-02f, 1.23722322e-01f, 9.60878581e-02f, -9.96316746e-02f, 5.63877895e-02f, -2.38878727e-01f, -1.13147601e-01f, -1.33028328e-01f, -3.48758399e-01f,
  -8.49687383e-02f, -7.65149519e-02f, -4.32422720e-02f, -9.50412378e-02f, 4.89169918e-02f, 4.05838825e-02f, -1.76051274e-01f, -6.92192316e-02f, 1.06243268e-01f, -2.64473930e-02f,
  4.05143611e-02f, 9.74335819e-02f, -1.19230054e-01f, 1.36859313e-01f, 1.08737595e-01f, 1.21256419e-01f, 1.64130554e-01f, -7.03925490e-02f, -1.84348419e-01f, 7.55956694e-02f,
  -3.10761873e-02f, 2.89810123e-03f, -1.09348945e-01f, -1.40903041e-01f, -8.67170617e-02f, 6.05080836e-02f, -2.04931162e-02f, -7.37839937e-02f, -2.44115949e-01f, -2.85353154e-01f,
  5.41666113e-02f, -8.91904999e-03f, -1.59326731e-03f, -1.54881272e-02f, 1.09895617e-01f, 6.19144589e-02f, -1.55433208e-01f, 4.13548239e-02f, -3.37476209e-02f, 6.69833319e-03f,
  -3.37926708e-02f, 9.96441022e-02f, 3.55597325e-02f, -8.77350569e-02f, -5.43655716e-02f, 2.01568753e-02f, -3.95006575e-02f, -9.17661786e-02f, -9.40818787e-02f, 2.45942082e-02f,
  1.02724843e-01f, -2.68931687e-02f, 9.74788964e-02f, -1.22461449e-02f, 1.06252087e-02f, 4.59112078e-02f, 9.11848620e-03f, 1.02698147e-01f, 1.41804054e-01f, 3.11924866e-03f,
  8.72824714e-03f, -1.56549677e-01f, 5.91887757e-02f, -3.57238203e-02f, -2.83210278e-02f, 1.48138916e-02f, -2.00989157e-01f, 4.68955711e-02f, 6.79543912e-02f, -8.83005094e-03f,
  2.24276744e-02f, -1.54101640e-01f, -1.96874082e-01f, -5.60156964e-02f, 1.32394224e-01f, -4.84327646e-03f, -1.52257398e-01f, 4.89500277e-02f, -1.72307286e-02f, 8.50258917e-02f,
  -9.12362561e-02f, -6.35381835e-03f, -1.93904638e-01f, -2.08332047e-01f, -1.49660274e-01f, -1.55719385e-01f, -1.39372617e-01f, -1.25562802e-01f, -2.79408336e-01f, -2.26735026e-01f,
  3.54933619e-01f, 2.52408624e-01f, 3.65433991e-01f, 4.38087014e-03f, -1.50581047e-01f, -2.21480504e-02f, 1.38753995e-01f, 8.76220223e-03f, -1.83452845e-01f, 2.44675428e-02f,
  5.76714519e-03f, -1.62114382e-01f, -2.71619838e-02f, -9.71943960e-02f, 1.08949013e-01f, 4.43257578e-02f, 1.03099234e-01f, 2.47527987e-01f, 1.51184589e-01f, 1.07686050e-01f,
  2.89862273e-05f, 2.69491971e-01f, 3.98418128e-01f, 3.41421217e-02f, -7.78613985e-02f, -1.57242239e-01f, 9.24702510e-02f, 1.33970857e-01f, 8.86011682e-03f, -3.56944129e-02f,
  2.03699306e-01f, 4.41659868e-01f, -1.57711789e-01f, -2.22996160e-01f, 4.86999936e-02f, 1.25811785e-01f, 3.61937694e-02f, 1.60269722e-01f, -5.51796630e-02f, 9.19787679e-03f,
  -3.97643186e-02f, 7.52606466e-02f, -3.45576704e-02f, 1.31121323e-01f, 9.89630297e-02f, -1.95360947e-02f, 1.23703890e-01f, 3.09859306e-01f, 6.18332326e-02f, 1.14914849e-01f,
  -3.97525579e-02f, 6.87192827e-02f, 7.44746476e-02f, 1.93436313e-02f, 1.02939285e-01f, -3.95296281e-03f, 9.05504227e-02f, 5.15572578e-02f, 8.29273611e-02f, 3.34498398e-02f,
  -1.46042496e-01f, 1.51441721e-02f, -2.05352176e-02f, 7.03597590e-02f, 1.03913717e-01f, -1.36865348e-01f, -4.66959625e-02f, -6.06402406e-04f, -1.21774795e-02f, 8.95610526e-02f,
  -1.33500904e-01f, 9.28363297e-03f, 1.40398160e-01f, 6.22345805e-02f, -1.15453720e-01f, 1.31435379e-01f, 4.66695242e-02f, 2.50987411e-02f, 6.92844838e-02f, 4.13210206e-02f,
  2.23731063e-02f, 2.96249203e-02f, 2.90457648e-03f, 1.84215070e-03f, 1.24227829e-01f, 1.01685962e-02f, 1.71043366e-01f, 1.92456901e-01f, 4.87846024e-02f, -3.61555978e-03f,
  -6.18711971e-02f, 1.44649446e-01f, -3.02761704e-01f, -1.19957469e-01f, 1.82045680e-02f, -1.72872826e-01f, -1.89939961e-01f, -3.84700596e-02f, -1.99462429e-01f, -6.16854541e-02f,
  -5.38005382e-02f, 2.73412354e-02f, 7.82821029e-02f, 2.28572376e-02f, -1.28272325e-01f, -3.33685577e-02f, -1.15041733e-01f, -1.54684886e-01f, -5.91923781e-02f, -1.47262260e-01f,
  -1.64624259e-01f, -1.54687092e-01f, -1.90842897e-01f, -1.98094651e-01f, -1.86112061e-01f, -3.77636552e-01f, -1.40076548e-01f, -1.18915215e-01f, -1.09417528e-01f, -7.42843747e-02f,
  7.18194067e-01f, 5.18886328e-01f, 1.67091891e-01f, -1.93176065e-02f, -1.41158447e-01f, -1.01266719e-01f, -3.14517021e-02f, 2.33209729e-02f, 5.19946553e-02f, 5.54039478e-02f,
  -2.10225973e-02f, 9.75368079e-03f, -6.99475314e-03f, -2.15115957e-02f, -2.00630948e-02f, 5.18487766e-02f, 4.84696869e-03f, 5.57243973e-02f, -7.64461011e-02f, -4.09308076e-02f,
  -7.95385838e-02f, 1.16027087e-01f, 1.86075896e-01f, 3.07463333e-02f, 8.72552097e-02f, -5.72458953e-02f, -4.97279465e-02f, -5.17027825e-02f, -6.07637241e-02f, 1.23748682e-01f,
  -9.54023302e-02f, 9.51608866e-02f, -1.74166843e-01f, 1.29676104e-01f, 3.48791704e-02f, 2.42527902e-01f, 7.08270073e-02f, 9.22292098e-02f, 7.97571912e-02f, -5.19758612e-02f,
  -2.28808206e-02f, 4.69079427e-02f, 4.66086753e-02f, 1.03606265e-02f, -4.29824814e-02f, 1.05023392e-01f, 1.60428565e-02f, 3.51005867e-02f, -4.22628485e-02f, 5.34013025e-02f,
  3.85829620e-02f, -4.07163575e-02f, -1.66756734e-02f, -1.34087071e-01f, -7.59736001e-02f, -8.24002549e-02f, 4.87569161e-02f, 1.22427372e-02f, -8.28480273e-02f, 1.75026566e-01f,
  1.22274011e-01f, 4.17939797e-02f, -1.06833130e-01f, -5.53172752e-02f, -7.61656687e-02f, -3.22171040e-02f, -4.60331365e-02f, -7.56422952e-02f, -7.48389289e-02f, 1.37977138e-01f,
  -9.66915116e-02f, -1.99653115e-02f, -6.83622137e-02f, -4.36176881e-02f, 2.36936491e-02f, 6.76546618e-02f, 3.69110107e-02f, -3.34419459e-02f, -1.35877296e-01f, -2.64005008e-04f,
  -1.00009091e-01f, -5.20103537e-02f, 7.00480565e-02f, 4.72090170e-02f, -3.99144366e-02f, 4.58772779e-02f, -8.42593536e-02f, -2.19254550e-02f, 5.05693182e-02f, 1.08014464e-01f,
  -5.25092721e-01f, -7.02907264e-01f, -4.52339388e-02f, 7.74808973e-02f, 2.16505285e-02f, 1.05833530e-01f, -1.32360488e-01f, 6.12174347e-02f, 6.51069656e-02f, -3.70117538e-02f,
  7.01455474e-02f, 4.11194973e-02f, -3.22369933e-02f, -7.83437565e-02f, -1.57826836e-03f, -6.72021061e-02f, 5.15113818e-03f, 7.16063529e-02f, 1.22434534e-02f, 5.28837927e-02f,
  9.22403708e-02f, 6.69366941e-02f, 2.48739868e-03f, -7.71679580e-02f, -8.39645565e-02f, 5.23655443e-03f, -5.51584885e-02f, -6.09299541e-02f, -5.57614341e-02f, 2.59163547e-02f,
  5.24892658e-02f, -1.68536156e-01f, -2.44517088e-01f, -7.05491230e-02f, -2.02182710e-01f, -1.37832001e-01f, -5.09922624e-01f, -7.11269397e-03f, 1.30136907e-01f, -3.20577383e-01f,
  -2.94947904e-02f, 2.60944307e-01f, -6.11439608e-02f, 4.28333543e-02f, 3.59439966e-03f, -4.02713180e-01f, -3.03228170e-01f, 4.20760997e-02f, 1.47918850e-01f, 1.16197690e-01f,
  3.06389481e-03f, 7.78992027e-02f, 2.81132460e-01f, 1.15027025e-01f, -1.64347515e-01f, 1.04324326e-01f, -1.71459541e-01f, -2.51491442e-02f, -6.16667094e-03f, -3.44270796e-01f,
  -4.56774980e-01f, -4.95523624e-02f, -1.18209422e-01f, 1.54315472e-01f, -2.59390801e-01f, -7.39648342e-02f, -1.30591229e-01f, 2.49609072e-03f, 8.08928385e-02f, -1.33746997e-01f,
  1.52334645e-01f, 1.33155584e-01f, 2.03895316e-01f, 8.01649019e-02f, -3.95634621e-02f, 8.84107966e-03f, -1.04143182e-02f, 2.23205220e-02f, 6.83117509e-02f, -1.42117411e-01f,
  -4.86237295e-02f, 4.88486923e-02f, -4.96347658e-02f, -1.37288794e-01f, -1.47398695e-01f, -3.08811143e-02f, -3.17267850e-02f, -4.77188602e-02f, -8.02640989e-02f, -1.32424459e-01f,
  -7.23164678e-02f, -8.37967023e-02f, 6.16487823e-02f, -6.44994015e-03f, 1.93850952e-03f, 9.79854073e-03f, 4.23576646e-02f, -7.99261481e-02f, 1.49503248e-02f, 6.71305060e-02f,
  -3.38399201e-03f, -6.72926381e-02f, -6.83318153e-02f, -8.82604346e-03f, 2.12285854e-02f, 2.37429604e-01f, -9.76070203e-03f, -3.38758677e-02f, 6.70266449e-02f, -1.58060603e-02f,
  1.68840983e-03f, 8.50517973e-02f, 3.85846011e-02f, 5.32312393e-02f, -5.48630692e-02f, 3.18952464e-02f, 1.89058017e-02f, 1.89971626e-02f, 6.92116749e-03f, 4.02860716e-02f,
  6.49469942e-02f, 3.31066214e-02f, -3.91496159e-02f, -5.48103312e-03f, 2.00369693e-02f, 4.86879004e-03f, 1.22013204e-02f, -3.06127761e-02f, 1.21936627e-01f, -1.79581884e-02f,
  7.23791048e-02f, 2.37977467e-02f, 4.99266870e-02f, -2.73541640e-02f, -1.10361367e-01f, -4.00274545e-02f, -2.07804330e-02f, 1.27644256e-01f, 1.25186414e-01f, -8.76348093e-02f,
  -5.77439293e-02f, 8.41592439e-03f, -1.46578311e-03f, -1.27146244e-01f, 6.12325892e-02f, 1.48057109e-02f, 5.20867445e-02f, -5.39049879e-02f, 3.15697305e-02f, -8.78570974e-02f,
  -5.88530749e-02f, -1.13807581e-01f, -1.65095851e-02f, 5.64809665e-02f, 1.47622287e-01f, -5.40439896e-02f, -1.67129830e-01f, 9.24886912e-02f, 1.08875297e-01f, -1.34700909e-01f,
  3.76185179e-02f, 1.77077144e-01f, -6.94200769e-02f, -7.87045956e-02f, -2.09483713e-01f, -3.93889010e-01f, -2.68174648e-01f, -1.62833333e-02f, 5.25292419e-02f, 1.14683295e-02f,
  1.13269687e-01f, -1.85843650e-02f, -6.92918152e-02f, -2.38076989e-02f, -7.19564185e-02f, 1.20817959e-01f, -3.06571126e-02f, -8.57073069e-02f, -1.96032673e-02f, -1.19205013e-01f,
  -2.68024653e-01f, 8.22848305e-02f, -2.72737518e-02f, 7.86038935e-02f, 2.66044270e-02f, 1.51355982e-01f, 1.27314582e-01f, -2.18599988e-03f, 1.00422710e-01f, -6.59221634e-02f,
  -1.09617628e-01f, -1.18621672e-02f, -2.73085777e-02f, -1.08378597e-01f, -1.05970189e-01f, -2.92931572e-02f, -5.09485230e-02f, -1.24448873e-01f, -6.82519451e-02f, -1.15856871e-01f,
  -8.89116004e-02f, 9.06964839e-02f, -1.17620595e-01f, -6.94759190e-02f, -1.61380917e-01f, 6.40309304e-02f, 1.18814060e-03f, -9.07644723e-03f, -1.48538619e-01f, -1.60470009e-01f,
  -5.41301034e-02f, -4.98350970e-02f, -6.32786527e-02f, -1.13279290e-01f, -8.85398015e-02f, -8.35681632e-02f, -7.92376921e-02f, -2.88557783e-02f, -2.84755155e-02f, -3.42175066e-02f,
  -3.21259424e-02f, 5.45790140e-03f, 1.94006599e-02f, -1.75266966e-01f, 2.36566411e-03f, -6.73501343e-02f, -1.09531336e-01f, -1.51151896e-01f, -6.76741451e-02f, -3.37436646e-02f,
  -1.27260655e-01f, -3.40675451e-02f, -7.58281723e-02f, -1.01975121e-01f, -5.28106056e-02f, -1.63386643e-01f, -2.72561740e-02f, -4.49458435e-02f, -4.04805318e-02f, -1.13605283e-01f,
  -7.05460683e-02f, 1.27445593e-01f, -1.37656644e-01f, -1.03506804e-01f, 3.20092365e-02f, -1.17527470e-02f, 2.35251226e-02f, -6.00473881e-02f, 1.22598320e-01f, -4.00477126e-02f,
  -1.27346635e-01f, -6.09542727e-02f, -3.74436304e-02f, -3.92055698e-02f, -3.90890166e-02f, -2.67466158e-01f, -1.67032897e-01f, 3.46220145e-03f, -4.67732362e-02f, 4.42185514e-02f,
  -8.84770155e-02f, -1.79089069e-01f, -2.99191698e-02f, -8.93232226e-02f, -1.75970629e-01f, 2.04387773e-03f, -7.21668974e-02f, -1.30096883e-01f, -1.46914124e-01f, -2.34965399e-01f,
  6.16252460e-02f, 1.85317062e-02f, -2.25691628e-02f, 1.91435784e-01f, 7.08971769e-02f, -1.79601774e-01f, -3.52257401e-01f, -2.69885659e-01f, 2.83664931e-02f, 2.79953331e-02f,
  -6.32174686e-02f, 1.33668438e-01f, 5.66541217e-02f, -3.01139485e-02f, -2.18210563e-01f, -5.98782450e-02f, 1.51097462e-01f, -4.17122208e-02f, -3.80989790e-01f, -2.74525702e-01f,
  1.59323737e-01f, 1.39102429e-01f, -1.42186448e-01f, -4.27100435e-02f, 2.15368181e-01f, 2.54957769e-02f, 1.09031521e-01f, 2.22147956e-01f, 1.47705108e-01f, 5.38023174e-01f,
  1.76622406e-01f, 1.48932770e-01f, -4.21218015e-02f, 3.22124958e-02f, 4.12674882e-02f, -2.19732493e-01f, -4.60303761e-02f, -9.76989344e-02f, -6.19754493e-02f, -7.42579922e-02f,
  1.75937653e-01f, -1.32308632e-01f, 1.06416583e-01f, -3.81575786e-02f, -1.44644737e-01f, -3.40694368e-01f, -1.67932019e-01f, -1.90601408e-01f, -1.85906798e-01f, -9.01947021e-02f,
  1.01048119e-01f, 1.64489653e-02f, 6.13698661e-02f, -1.89956009e-01f, -2.28809491e-02f, -4.56294976e-02f, -8.33624825e-02f, 7.15031773e-02f, -2.16455862e-01f, 1.29241079e-01f,
  2.04580929e-02f, 3.08707617e-02f, -7.13601708e-02f, 7.86264837e-02f, 6.00837357e-02f, 3.81322466e-02f, 1.25474095e-01f, 7.96651840e-03f, -9.04640835e-03f, -4.23406400e-02f,
  -1.38362065e-01f, -5.80638833e-02f, -3.83168943e-02f, 5.49966060e-02f, 9.81919318e-02f, 1.18232250e-01f, -2.31828503e-02f, -1.31574050e-01f, -8.54449570e-02f, -4.06532399e-02f,
  -1.52380392e-01f, -7.95803266e-04f, 9.49147791e-02f, -1.34246662e-01f, -3.86466384e-02f, -4.83189747e-02f, -1.06128559e-01f, -1.10237963e-01f, 9.08882618e-02f, 4.71425690e-02f,
  -1.65921059e-02f, -2.34015211e-02f, 3.59479785e-02f, -1.22602500e-01f, 1.31954607e-02f, 6.05254527e-03f, -6.50567040e-02f, -1.76870093e-01f, -4.97000851e-02f, -1.53774276e-01f,
  -1.35253379e-02f, -1.44140959e-01f, 1.05023839e-01f, -8.56800601e-02f, -1.03370972e-01f, -7.32452124e-02f, -5.06626479e-02f, -1.13537095e-01f, -1.55851170e-01f, -7.02271610e-02f,
  -1.20358385e-01f, -1.42585099e-01f, -1.72127351e-01f, -7.70670921e-02f, 5.83927743e-02f, -2.43908614e-02f, -8.77613574e-02f, 2.02569049e-02f, -2.59204894e-01f, 1.50983995e-02f,
  1.67439617e-02f, 1.18167093e-02f, -1.31811027e-03f, 3.02328300e-02f, 2.27227673e-01f, 3.76186907e-01f, 4.55987871e-01f, 1.87071264e-01f, 2.00061742e-02f, 9.80149880e-02f,
  1.90386221e-01f, 2.60562859e-02f, -3.31167020e-02f, -1.17744140e-01f, 3.16466689e-02f, 1.23869538e-01f, 1.28388077e-01f, -5.24321161e-02f, -1.57415524e-01f, 2.84897368e-02f,
  3.27416696e-02f, -6.72696978e-02f, -1.87479571e-01f, -1.13673218e-01f, -1.19378485e-01f, -1.19309485e-01f, 1.44184651e-02f, 4.45411503e-02f, 2.41223294e-02f, -2.74775088e-01f,
  -1.98119789e-01f, 2.12046176e-01f, -7.12805316e-02f, 4.71959934e-02f, 6.75352737e-02f, -1.19999886e-01f, 1.47524193e-01f, -3.04440279e-02f, -4.02538106e-02f, -7.52174184e-02f,
  -5.73134199e-02f, 7.41552329e-03f, 5.42061552e-02f, -5.19867316e-02f, 6.49534091e-02f, 6.07502162e-02f, -8.02715421e-02f, -1.72278397e-02f, 9.34443623e-02f, 4.41761799e-02f,
  8.47521946e-02f, 1.30495459e-01f, 4.73694839e-02f, 1.34369090e-01f, 8.13102641e-04f, 4.70853560e-02f, 5.90289347e-02f, -2.99572223e-03f, 7.50268102e-02f, -1.97510809e-01f,
  1.32707357e-01f, -1.23198271e-01f, -2.29751761e-03f, -1.45296883e-02f, 2.53451914e-02f, -1.46131963e-01f, -1.11159822e-02f, 1.18462048e-01f, -8.40620622e-02f, -9.50144902e-02f,
  1.01271749e-01f, -2.11256891e-02f, -3.32745723e-02f, 8.25352129e-03f, -4.67427541e-03f, 6.89254627e-02f, -2.94821337e-02f, 1.07341297e-01f, 6.51824474e-03f, 9.29789692e-02f,
  1.76871225e-01f, 5.75360581e-02f, -4.34528803e-03f, 7.99080208e-02f, 4.10949774e-02f, 1.14818765e-02f, 6.85100257e-02f, 2.12378085e-01f, 2.05302611e-03f, 1.34392455e-01f,
  -2.93478519e-01f, 3.17654729e-01f, -1.68402091e-01f, 4.26684879e-02f, 6.57613799e-02f, -7.35318884e-02f, 1.89309865e-01f, 4.65897508e-02f, -1.79339200e-01f, 1.03944270e-02f,
  1.03598855e-01f, -1.01485237e-01f, 1.09740794e-02f, 2.82163564e-02f, -2.94818990e-02f, -5.59637621e-02f, -5.88465035e-02f, -5.46516443e-04f, 2.18591597e-02f, -1.95700616e-01f,
  -1.54457437e-02f, -5.48456721e-02f, -1.05970562e-01f, -9.72240642e-02f, -1.39107350e-02f, -1.34236678e-01f, -2.44358536e-02f, 3.78380902e-02f, -7.83246011e-03f, -5.37897013e-02f,
  -3.13403219e-01f, -1.85652956e-01f, -2.32042909e-01f, -2.38555789e-01f, -3.78491253e-01f, -2.30291262e-01f, -5.40206544e-02f, -1.90407038e-01f, -1.39801919e-01f, -2.18630373e-01f,
  -5.47319576e-02f, 2.78825045e-01f, 2.54837066e-01f, 6.23292699e-02f, 6.77341595e-02f, -1.10592119e-01f, -2.03839421e-01f, -5.16308332e-03f, 1.03135630e-01f, 9.09557194e-02f,
  -2.17935648e-02f, 1.19981505e-01f, 6.99624494e-02f, -2.20974907e-02f, 9.02333036e-02f, 1.64615780e-01f, -1.63677573e-01f, -1.40850976e-01f, -8.86812210e-02f, -2.66892850e-01f,
  3.71317476e-01f, -2.11715549e-01f, -1.06386617e-02f, -1.50272131e-01f, -2.76705772e-02f, -1.46366403e-01f, 1.30139470e-01f, -8.04181173e-02f, -1.33361533e-01f, -1.89597264e-01f,
  -2.47531742e-01f, -5.40717393e-02f, 5.05044013e-02f, 2.00296585e-02f, 1.29900947e-01f, -1.79704465e-02f, 7.76709476e-03f, 8.44327733e-02f, 1.84717197e-02f, 1.87316000e-01f,
  -1.05043165e-02f, -9.80520323e-02f, -1.48786535e-03f, 3.99425812e-02f, -1.49548529e-02f, 2.02838778e-02f, 8.75067711e-02f, -3.71244550e-02f, -1.01348497e-02f, -1.36074461e-02f,
  -4.32426520e-02f, 1.22507647e-01f, 4.46270332e-02f, 2.08310746e-02f, 7.05677420e-02f, 1.95672866e-02f, 9.40443296e-03f, 2.91941632e-02f, 7.44178519e-02f, 1.00499794e-01f,
  -9.94271636e-02f, -1.19968608e-01f, -1.06464503e-02f, -1.27140537e-01f, -4.44320813e-02f, 1.54777803e-02f, -4.25311215e-02f, -3.41556445e-02f, -1.40759557e-01f, -4.42006476e-02f,
  -1.39960125e-01f, -3.82486247e-02f, -8.58066827e-02f, 7.15283379e-02f, -8.42927992e-02f, -4.75664251e-02f, 1.95789356e-02f, 6.34656325e-02f, 1.14535494e-03f, -2.19862714e-01f,
  3.58175367e-01f, -3.53396595e-01f, 1.49708912e-01f, -1.92807838e-02f, 3.60102057e-02f, -1.25526488e-01f, -2.71723829e-02f, -9.29932445e-02f, -1.76047478e-02f, -1.63643703e-01f,
  -7.23936707e-02f, 3.23118316e-03f, -5.26092527e-03f, -8.55980590e-02f, -1.67626459e-02f, -3.07603218e-02f, -1.50380866e-03f, 3.71772535e-02f, -5.86016215e-02f, -3.67358257e-03f,
  -1.16865762e-01f, -4.06725891e-02f, 1.12076961e-01f, 3.29307932e-03f, 2.21453025e-03f, 4.65746187e-02f, 2.17970073e-01f, 5.27083734e-03f, 2.90167332e-02f, 2.12846994e-01f,
  -6.50681794e-01f, 2.35397220e-02f, -1.61203027e-01f, -3.75442356e-01f, 2.13001281e-01f, 2.23761410e-01f, 2.70420343e-01f, 3.85097638e-02f, -5.86793125e-02f, -7.77698029e-03f,
  3.03342845e-02f, -3.66331823e-02f, -1.16323844e-01f, 1.67654291e-01f, 1.31699726e-01f, 1.97933286e-01f, 1.80951491e-01f, 3.99923921e-02f, 9.31920111e-02f, 1.81953877e-01f,
  1.76593155e-01f, -2.25650847e-01f, -2.77296007e-01f, -2.98379268e-02f, -1.27413437e-01f, -3.16397808e-02f, -1.01673432e-01f, -1.36648640e-01f, 2.85978597e-02f, 8.57117251e-02f,
  -2.18729809e-01f, -2.18816489e-01f, 1.05523847e-01f, -6.75869659e-02f, -6.45350218e-02f, -2.05513120e-01f, 1.42710388e-01f, -1.79021314e-01f, -7.81083992e-03f, -8.24738443e-02f,
  -1.39405176e-01f, -1.63266249e-02f, -1.20194117e-02f, 1.53557315e-01f, -5.54822981e-02f, -6.09600954e-02f, -2.78510507e-02f, -9.59037095e-02f, -9.43270251e-02f, -7.90804029e-02f,
  1.32362887e-01f, 9.10352468e-02f, -1.63779289e-01f, 5.06951064e-02f, -1.09873042e-01f, -5.83486855e-02f, 3.39257009e-02f, 1.07267395e-01f, 8.00855458e-02f, -8.29463229e-02f,
  2.64064246e-03f, -6.11814186e-02f, 5.02863852e-03f, 6.42034635e-02f, -6.91420734e-02f, -3.00446711e-02f, 7.45988637e-02f, -1.05847558e-02f, 6.46582991e-02f, -1.00219958e-01f,
  -1.99302603e-02f, -2.45668553e-02f, -2.42310166e-02f, 4.84015197e-02f, 6.64314926e-02f, -3.25068906e-02f, 1.15291215e-01f, 4.32494320e-02f, -6.85326532e-02f, 3.23832855e-02f,
  4.63964678e-02f, -7.54856765e-02f, -9.96510014e-02f, -3.29774432e-02f, 8.66220426e-03f, 1.17145739e-02f, -3.96174677e-02f, 1.65338963e-02f, -1.17419891e-01f, -4.70674820e-02f,
  -2.17456192e-01f, 1.18450902e-01f, -1.18730970e-01f, 8.08124896e-03f, -9.06593651e-02f, 1.86668970e-02f, -1.41569346e-01f, 3.34780328e-02f, -2.02321768e-01f, -5.44748083e-02f,
  2.54505277e-02f, -1.50182337e-01f, -7.63984993e-02f, 6.73823878e-02f, 8.15638229e-02f, -2.47701816e-02f, 1.50192738e-01f, -3.82979065e-02f, 2.99986396e-02f, -3.22853066e-02f,
  3.82216983e-02f, -2.73893215e-02f, -1.72275662e-01f, 3.03396601e-02f, -6.28318638e-02f, -1.26902714e-01f, 3.03313956e-02f, 2.60441899e-02f, -6.49740621e-02f, -8.32255110e-02f,
  2.43536741e-01f, 1.55558571e-01f, -1.63747922e-01f, 1.01830222e-01f, -1.66940287e-01f, -1.56427652e-01f, -2.47456416e-01f, 7.90483877e-03f, 1.50110245e-01f, -6.05421560e-03f,
  -4.42890972e-02f, -4.47284989e-02f, 3.31793800e-02f, -9.09590274e-02f, -3.75106893e-02f, -4.86607738e-02f, -2.91381836e-01f, -1.92209736e-01f, -2.19208688e-01f, -1.26983672e-01f,
  -2.11934030e-01f, 5.21057518e-03f, -1.89035274e-02f, -3.56948450e-02f, 1.47729650e-01f, 1.49370402e-01f, 4.43267673e-02f, 3.20040472e-02f, -1.81768358e-01f, 4.58288677e-02f,
  8.43583047e-03f, 3.71869677e-03f, -6.76455945e-02f, -6.00113496e-02f, 3.75375093e-05f, -7.77439177e-02f, -1.23819277e-01f, 3.78709100e-02f, -7.82472268e-02f, -4.07506712e-02f,
  -1.04591198e-01f, -1.43848255e-01f, -1.24962434e-01f, -1.23953395e-01f, -1.03070311e-01f, -2.15833291e-01f, -1.25163734e-01f, -6.31331205e-02f, -5.75323217e-02f, -2.85261050e-02f,
  -1.55823752e-01f, -1.81729659e-01f, -1.41841009e-01f, -5.74024394e-02f, -4.65531573e-02f, -1.25348061e-01f, 8.21282789e-02f, -1.16286546e-01f, -1.12907417e-01f, 3.23451996e-01f,
  9.03136879e-02f, -5.36575764e-02f, -6.68710098e-02f, 9.55486149e-02f, 3.09680384e-02f, 6.34838641e-02f, -2.94048106e-03f, 1.33654684e-01f, 1.48321539e-02f, 1.18227094e-01f,
  -7.03883357e-03f, -5.00564538e-02f, -4.22845334e-02f, 1.85436718e-02f, 4.88073267e-02f, -1.41457776e-02f, 4.37209606e-02f, 1.09735236e-01f, 2.25129109e-02f, -2.11374629e-02f,
  -2.13614665e-02f, 7.21310079e-02f, 1.21249363e-01f, 1.65800944e-01f, -7.15444461e-02f, -5.54700941e-02f, -1.03865288e-01f, 3.08620073e-02f, 1.36958227e-01f, -1.57049209e-01f,
  3.28192025e-01f, -3.96291494e-01f, 2.05588073e-01f, 2.36657299e-02f, 1.21313334e-02f, -1.05485633e-01f, 2.31676474e-02f, -4.21045162e-02f, 4.58739065e-02f, -1.57355126e-02f,
  -2.00222656e-01f, 6.88475892e-02f, 1.13663329e-02f, -3.86777632e-02f, -4.52648774e-02f, -1.42565250e-01f, -9.97722745e-02f, -7.11449794e-03f, -5.37434295e-02f, 1.58117667e-01f,
  5.21477275e-02f, 9.28298235e-02f, 9.19563472e-02f, 1.16230629e-01f, 1.91282749e-01f, 1.35313541e-01f, 5.93358353e-02f, 1.12683579e-01f, -8.02466646e-02f, 2.77953833e-01f,
  3.37310731e-01f, -8.90008882e-02f, 2.39397869e-01f, 2.16340154e-01f, 3.53657305e-02f, -1.25362501e-01f, -3.31547707e-01f, -1.78155854e-01f, 1.47746339e-01f, -7.11069256e-02f,
  -4.93957363e-02f, 2.73403168e-01f, 2.15875775e-01f, 3.01089793e-01f, 1.19935639e-01f, 2.13699811e-03f, 1.89828098e-01f, 2.47553885e-01f, 1.87515199e-01f, 5.36081791e-02f,
  1.13362983e-01f, 1.19333573e-01f, 2.65875459e-01f, 1.52880207e-01f, 1.92885876e-01f, 1.85357362e-01f, -1.72080733e-02f, 5.26058488e-02f, 5.06741405e-02f, 4.46547419e-01f,
  3.18752974e-01f, 5.89737631e-02f, 9.66726691e-02f, 1.34162769e-01f, 3.92044522e-02f, 5.53876087e-02f, 2.09834408e-02f, -8.16603079e-02f, -1.15874093e-02f, 1.00638969e-02f,
  3.62204462e-02f, 2.71748267e-02f, -3.75644825e-02f, -5.54973260e-03f, -6.55736178e-02f, 4.46407066e-05f, -6.60396786e-03f, 9.01938006e-02f, 1.27651483e-01f, -1.99152473e-02f,
  -1.68890897e-02f, -1.24365933e-01f, -2.63730064e-02f, -1.55825466e-01f, -3.14624645e-02f, 1.54084638e-01f, 8.92606005e-03f, 4.71795909e-02f, -5.21513931e-02f, -2.77477968e-02f,
  5.25653921e-02f, 3.44316736e-02f, 1.82658643e-01f, -1.37309089e-01f, 2.41217855e-02f, 2.37013064e-02f, 1.50397029e-02f, -7.38148168e-02f, 5.82917705e-02f, -3.89482267e-02f,
  -7.92863145e-02f, -4.48516980e-02f, -9.65687186e-02f, -6.23940751e-02f, 6.92195073e-02f, 1.71479378e-02f, 6.04525357e-02f, 1.94559786e-02f, 7.64670223e-02f, -3.35197933e-02f,
  5.93416020e-02f, 5.39682172e-02f, 2.81016789e-02f, -1.12889288e-02f, -1.28703505e-01f, -6.86150417e-02f, -7.38060623e-02f, -1.95486657e-03f, 7.46184066e-02f, 7.35067353e-02f,
  -5.85342161e-02f, 5.56308068e-02f, 9.55952927e-02f, 2.04675645e-01f, 3.24455574e-02f, 4.62624952e-02f, 4.10016142e-02f, 1.26698315e-01f, 1.05970658e-01f, -9.85394344e-02f,
  -3.97046618e-02f, 3.59346457e-02f, -5.60652129e-02f, -7.38123134e-02f, -9.34068784e-02f, -7.53054842e-02f, -1.06144115e-01f, -4.89417883e-03f, 8.34738389e-02f, 4.74855714e-02f,
  -1.20171316e-01f, -2.66310960e-01f, -5.02092429e-02f, -1.65068343e-01f, -9.91945937e-02f, -6.08863309e-02f, -1.74263030e-01f, -1.69968724e-01f, -1.96058586e-01f, -3.20962399e-01f,
  -3.55013683e-02f, -1.12088390e-01f, -1.74204662e-01f, -1.24325618e-01f, -7.70138577e-02f, -7.14120343e-02f, -2.33756393e-01f, 7.22858086e-02f, 8.97071287e-02f, -3.10800940e-01f,
  -4.61806469e-02f, 1.70877308e-01f, -1.21939249e-01f, 4.60178638e-03f, 1.00408785e-01f, -3.23701531e-01f, -1.89015567e-01f, 8.64726603e-02f, 2.66795814e-01f, 2.04870760e-01f,
  7.37868308e-04f, 2.98257675e-02f, 9.78894159e-02f, 1.91572592e-01f, -1.34509519e-01f, -1.71751641e-02f, -3.06337327e-01f, -1.48229226e-01f, -1.04033969e-01f, -3.67519140e-01f,
  -3.51276726e-01f, 2.43217330e-02f, 8.08181986e-02f, 5.90103120e-02f, -1.92030311e-01f, 5.76897487e-02f, 3.19546717e-03f, -1.27541432e-02f, -3.36777791e-02f, 2.78732274e-02f,
  -2.99002547e-02f, 1.55782953e-01f, 8.92929062e-02f, -1.73302945e-02f, 6.56200498e-02f, 2.52604317e-02f, -2.55536046e-02f, 7.26732090e-02f, -1.71116833e-02f, 1.86254159e-02f,
  -4.68263105e-02f, -4.24799994e-02f, -7.21724331e-02f, -6.60786852e-02f, -9.77922752e-02f, -6.56798035e-02f, -1.22372480e-03f, 1.06130049e-01f, -7.86860287e-03f, -3.14990699e-01f,
  -4.39977683e-02f, -6.50266632e-02f, -1.93016957e-02f, -5.42836301e-02f, 2.84481999e-02f, -5.03707156e-02f, -1.85021590e-02f, -3.63900028e-02f, -8.36975053e-02f, -3.19928527e-02f,
  3.93904336e-02f, -1.00652250e-02f, 5.67254238e-02f, -1.13838606e-01f, 1.74074583e-02f, 4.82549481e-02f, -1.15943812e-01f, -9.10362303e-02f, -2.00074837e-02f, 2.89911628e-02f,
  3.52486707e-02f, 2.73473524e-02f, 2.28208359e-02f, -3.64898611e-03f, -1.00888275e-01f, -6.08230680e-02f, -2.33215876e-02f, 3.02412268e-02f, 8.08897428e-03f, 3.81361209e-02f,
  -1.65470853e-01f, 7.26961493e-02f, -3.44007611e-02f, 7.62862563e-02f, 4.53918315e-02f, 8.40526447e-03f, -8.96359161e-02f, 7.37145990e-02f, -2.56896932e-02f, 4.44741324e-02f,
  1.37107104e-01f, 2.62046419e-03f, -6.58970624e-02f, 7.86130279e-02f, 3.50594148e-02f, 1.43918479e-02f, -1.92749593e-02f, -5.84434047e-02f, 1.02852739e-01f, -3.17474129e-04f,
  -1.29988402e-01f, -2.86512505e-02f, 7.66456723e-02f, -1.40851200e-01f, -7.15698972e-02f, 3.00488342e-02f, -6.85928464e-02f, 9.85048618e-03f, -5.90403862e-02f, -3.09666783e-01f,
  2.06508875e-01f, 2.87944734e-01f, 7.70543590e-02f, -9.03227106e-02f, -1.28249323e-03f, -3.94755788e-02f, 7.78427944e-02f, 8.13104287e-02f, -1.40891984e-01f, -1.36013459e-02f,
  -1.48713782e-01f, -1.93389326e-01f, -1.67106777e-01f, -1.45668343e-01f, 1.38893798e-01f, 6.45012185e-02f, 1.99962392e-01f, 8.31958279e-02f, -1.30109668e-01f, 8.39285180e-03f,
  -5.35635166e-02f, 1.88004971e-01f, 2.14843407e-01f, -3.08871139e-02f, 1.52333409e-01f, -1.64272308e-01f, 6.04081973e-02f, 9.21686366e-02f, -1.65958982e-02f, 3.05076063e-01f,
  3.81619446e-02f, 2.47786522e-01f, 5.34393406e-03f, -3.88161838e-02f, -5.47341369e-02f, -1.35733618e-03f, -4.65133674e-02f, 8.46232567e-03f, -1.91406906e-01f, -5.63997291e-02f,
  1.68368837e-03f, -4.31905413e-04f, 1.17532067e-01f, -1.12532794e-01f, -3.25793289e-02f, -9.72246975e-02f, -1.21035784e-01f, 1.24466702e-01f, -1.66224137e-01f, -1.27027944e-01f,
  -5.61903194e-02f, -4.82990444e-02f, 3.49015417e-03f, -1.91654444e-01f, -1.14837557e-01f, -2.51412839e-01f, -6.99032694e-02f, -1.52894445e-02f, -1.68179885e-01f, 1.32669797e-02f,
  -2.15700716e-01f, -1.22458423e-02f, -1.76401675e-01f, -1.89765647e-01f, -1.79611906e-01f, -2.21028309e-02f, -1.67104930e-01f, -8.23547617e-02f, -8.91824216e-02f, -2.96835937e-02f,
  -8.78058001e-02f, -2.44233042e-01f, -2.19402671e-01f, -8.82343277e-02f, -1.28133491e-01f, -1.77597329e-01f, -9.27141234e-02f, -1.21595614e-01f, -3.45012136e-02f, 6.11687033e-03f,
  7.82383606e-03f, -9.55210906e-03f, -3.60703561e-03f, 1.93597283e-02f, -9.71530154e-02f, -5.89541793e-02f, -3.25419642e-02f, -6.92572966e-02f, -5.81683479e-02f, -3.50490026e-02f,
  -6.47705197e-02f, -1.51979566e-01f, 7.47134909e-02f, 2.28197619e-01f, 5.08549549e-02f, -6.50198832e-02f, -4.70258668e-02f, -2.81728450e-02f, -7.93996081e-02f, 1.08648233e-01f,
  2.08875045e-01f, 1.20167304e-02f, 3.73104811e-02f, 5.52015826e-02f, 5.94883040e-02f, 3.46134268e-02f, -3.40354778e-02f, 7.99658075e-02f, 6.60048053e-02f, -4.55100089e-02f,
  4.91172113e-02f, 6.96230505e-04f, -1.83161840e-01f, -2.11592503e-02f, 4.22667116e-02f, -1.93911165e-01f, -9.12076607e-02f, -8.97265002e-02f, -6.51903749e-02f, -1.02887981e-01f,
  1.57012224e-01f, 2.66174704e-01f, 1.73694924e-01f, 1.90511331e-01f, 3.25955182e-01f, 3.87779832e-01f, 6.65393949e-01f, 2.89202809e-01f, -1.07571445e-01f, 3.51876207e-02f,
  1.08515456e-01f, -2.86314964e-01f, -2.75977969e-01f, -1.93386093e-01f, 7.14916736e-03f, 6.40519187e-02f, 1.42054275e-01f, -1.29643023e-01f, -1.44563526e-01f, 6.58431426e-02f,
  -1.49028972e-01f, -4.81196381e-02f, -2.00127009e-02f, -1.24558613e-01f, 1.09540736e-02f, -1.00923471e-01f, -6.10494502e-02f, 1.41103104e-01f, -1.32731199e-02f, -2.04343960e-01f,
  -3.69362861e-01f, 2.99803317e-01f, -1.89232662e-01f, -1.16542242e-01f, 1.20589927e-01f, -1.88027881e-02f, -1.67922333e-01f, -8.57224315e-02f, 3.01015507e-02f, 6.88562021e-02f,
  3.86639424e-02f, -5.27123958e-02f, 5.35021834e-02f, 3.38261686e-02f, 1.36811271e-01f, 1.73677877e-02f, 2.55764108e-02f, -5.80034554e-02f, -4.73180637e-02f, -4.56686579e-02f,
  -5.30556291e-02f, 1.40509576e-01f, 2.08988801e-01f, 1.82052538e-01f, 8.98246169e-02f, -9.64748338e-02f, 6.46501854e-02f, 7.77949840e-02f, 7.15285167e-02f, -1.72579199e-01f,
  -2.04767678e-02f, 7.92805664e-03f, -7.00048879e-02f, 6.92668334e-02f, -2.38081794e-02f, -5.85352518e-02f, -3.19179669e-02f, -3.76219936e-02f, 3.99433449e-02f, 8.88550431e-02f,
  -1.84010109e-03f, -6.42935708e-02f, -2.15437673e-02f, -8.98184255e-02f, -1.32693186e-01f, 6.34931549e-02f, 1.14277564e-01f, 3.94478962e-02f, 3.75496037e-03f, -6.00986443e-02f,
  -1.07060391e-02f, 5.26381657e-02f, -3.42967920e-02f, -1.22631304e-01f, -4.35026921e-02f, -2.54908372e-02f, -7.79925212e-02f, -2.52893269e-02f, -3.90274525e-02f, -2.47050449e-02f,
  -2.72880644e-01f, -7.69640133e-03f, -2.77297616e-01f, -1.69580787e-01f, 1.16349630e-01f, 2.47551966e-02f, -7.14908540e-02f, -4.86593805e-02f, 5.76819628e-02f, -1.11014232e-01f,
  7.79454932e-02f, -1.95428431e-02f, 4.89444137e-02f, 1.89708307e-01f, -8.13790038e-03f, 3.14318500e-02f, -2.14295954e-01f, -7.20061585e-02f, -1.03223234e-01f, -1.59961656e-01f,
  -1.05973035e-01f, 4.02072519e-02f, -1.57227051e-02f, -9.52210128e-02f, -9.11191031e-02f, -1.08019426e-01f, -5.67505043e-03f, -2.85851490e-02f, -2.64187553e-03f, -1.15468996e-02f,
  3.94464314e-01f, -8.24827775e-02f, 3.51347417e-01f, 1.53128922e-01f, 1.64871439e-01f, 2.29660884e-01f, 3.70563269e-01f, 5.15328161e-03f, -1.12582490e-01f, -2.06602681e-02f,
  -3.80501933e-02f, -2.05394864e-01f, -1.23185292e-01f, -1.18567511e-01f, 1.10902414e-01f, 1.53827563e-01f, 4.51438800e-02f, 1.46696374e-01f, 1.66474491e-01f, 1.19925842e-01f,
  -1.69069722e-01f, -2.60185753e-03f, 5.88907115e-02f, 1.00136645e-01f, -4.43529934e-02f, -7.27232639e-03f, 1.33851431e-02f, 1.89041570e-01f, -2.13181637e-02f, -1.42744035e-01f,
  -3.81851271e-02f, 3.12288135e-01f, 6.76082354e-03f, -1.72212377e-01f, 1.93013754e-02f, -7.28205442e-02f, -1.27002135e-01f, 7.40782404e-03f, -7.62951076e-02f, -1.27598643e-01f,
  -3.19550782e-02f, -9.34408829e-02f, 1.05959617e-01f, -2.82715745e-02f, 3.71641405e-02f, 5.98326437e-02f, -1.28397876e-02f, 1.63965508e-01f, 7.89653733e-02f, 8.37607533e-02f,
  1.21870615e-01f, 1.85027778e-01f, 1.25134438e-01f, 1.22896262e-01f, 9.17155221e-02f, 1.47864684e-01f, 1.15511887e-01f, 6.32235631e-02f, 1.80021003e-01f, -5.36271594e-02f,
  -1.51552379e-01f, -1.31731585e-01f, 1.20216288e-01f, 3.42518874e-02f, 1.25272900e-01f, 7.27554187e-02f, -2.78020538e-02f, 4.58054766e-02f, 1.84629172e-01f, 3.81535627e-02f,
  1.95000786e-02f, 7.71723688e-02f, -2.28221379e-02f, 6.61719739e-02f, 3.28570120e-02f, 1.10435024e-01f, -9.44005849e-04f, 1.10269278e-01f, -2.59576626e-02f, -2.68767141e-02f,
  1.02969766e-01f, 1.55340433e-02f, -7.64250662e-03f, 9.65862274e-02f, 9.83828679e-02f, -2.66922358e-03f, -3.27369273e-02f, -2.35036593e-02f, -4.30822223e-02f, 1.80698615e-02f,
  -4.04764950e-01f, 1.56565905e-01f, -1.58636421e-01f, -8.63704681e-02f, -3.31002101e-02f, -1.42928258e-01f, -9.04373452e-02f, -5.74113391e-02f, -3.75298224e-02f, -5.23821451e-02f,
  -7.15874806e-02f, 4.58161347e-03f, 5.71004897e-02f, -1.91230532e-02f, 1.29717477e-02f, -1.91676263e-02f, -2.15592608e-01f, 3.40360217e-02f, -1.78458259e-01f, -2.70700395e-01f,
  -6.18568733e-02f, -6.40257522e-02f, 3.78020070e-02f, 6.30554631e-02f, 2.78111268e-02f, -4.63033691e-02f, -9.98188704e-02f, 1.67386774e-02f, 1.08464636e-01f, -1.43161491e-01f,
  -2.03828499e-01f, -1.68985367e-01f, 8.21121186e-02f, 2.12319747e-01f, 3.24921936e-01f, 2.95316577e-01f, 3.07963818e-01f, 1.66602686e-01f, 5.98612241e-02f, 8.52498263e-02f,
  -5.10732830e-02f, 1.04096914e-02f, -3.34555618e-02f, -6.39286451e-03f, -5.24548404e-02f, 7.79291764e-02f, 1.11776933e-01f, 1.95587929e-02f, 9.65064168e-02f, 8.78745411e-03f,
  -5.89103214e-02f, -4.31748591e-02f, -1.94519818e-01f, -1.41263530e-01f, 6.67447150e-02f, 3.24777067e-02f, -8.87985155e-02f, -2.72011198e-02f, -5.43191805e-02f, 1.71537232e-02f,
  -1.84355378e-01f, -3.81964482e-02f, 1.29413307e-01f, -1.36960968e-01f, -1.67544067e-01f, -8.07019845e-02f, -1.79302003e-02f, 3.13836597e-02f, -5.00863232e-02f, 3.02257240e-02f,
  -5.90550303e-02f, -1.22016706e-01f, -1.88253243e-02f, 3.67757678e-02f, -3.35701965e-02f, 3.46831083e-02f, -2.12692618e-02f, -3.76588292e-02f, 8.34204257e-02f, -6.76978901e-02f,
  9.18431580e-02f, 1.33364692e-01f, 4.50509898e-02f, 1.03916578e-01f, 1.05293959e-01f, 6.43273145e-02f, -5.16230874e-02f, 9.48111713e-03f, -6.00626953e-02f, -1.38000846e-01f,
  1.33101836e-01f, 7.79144559e-03f, 5.57283871e-02f, -4.76911440e-02f, 4.50284742e-02f, 7.04944804e-02f, -6.16422854e-03f, -1.15581408e-01f, 2.18869708e-02f, -2.79341964e-03f,
  6.99934363e-02f, 1.18816346e-01f, -8.22342336e-02f, -9.69869737e-03f, 4.54100594e-02f, -1.09680099e-02f, 1.26816303e-01f, -1.00780927e-01f, -1.98657855e-01f, -1.05552524e-01f,
  -5.31483926e-02f, -4.05163169e-02f, -1.68414518e-01f, 1.46954190e-02f, -3.33270729e-02f, 6.06449582e-02f, 6.90188408e-02f, 5.91875017e-02f, -4.14818749e-02f, 7.77245462e-02f,
  6.72480819e-05f, 6.66172579e-02f, -9.27488133e-02f, -7.50597492e-02f, -2.28062913e-01f, -1.66943282e-01f, 6.85391873e-02f, -5.21533974e-02f, -4.88052182e-02f, -7.06298575e-02f,
  -5.19516245e-02f, -1.01487495e-01f, -1.38439864e-01f, -1.70504093e-01f, -2.53300443e-02f, -1.40862670e-02f, -4.17407714e-02f, 3.51810269e-02f, -3.61580658e-03f, -1.11592159e-01f,
  6.98818415e-02f, 1.45707682e-01f, 8.83964226e-02f, 2.90584266e-02f, -1.34688448e-02f, 5.65922931e-02f, -1.18973935e-02f, -2.84611732e-02f, -6.65906146e-02f, -7.72227943e-02f,
  -5.13895042e-02f, -1.15315244e-01f, 1.36846185e-01f, 2.62758106e-01f, 2.09611803e-01f, 2.66329974e-01f, 2.10920244e-01f, 1.00139342e-01f, -2.71588601e-02f, -5.29497452e-02f,
  -1.02622963e-01f, -6.30441234e-02f, 2.57466137e-02f, 5.59629314e-02f, 1.10080712e-01f, 1.81636885e-01f, 1.46164879e-01f, 2.35963427e-02f, -1.89736895e-02f, 3.46354060e-02f,
  -2.80864146e-02f, -1.18139170e-01f, -4.76159789e-02f, -5.01527488e-02f, 8.85369703e-02f, 6.21910915e-02f, 1.02266833e-01f, -1.08312359e-02f, 1.86256822e-02f, 1.92092746e-01f,
  1.54827535e-01f, 6.71857744e-02f, 2.02841330e-02f, 6.63063303e-02f, -1.82815753e-02f, -9.42972004e-02f, 6.97069690e-02f, 1.57347787e-02f, 1.66734941e-02f, 1.51073132e-02f,
  7.12019876e-02f, -7.03348890e-02f, -7.02437460e-02f, -4.56272103e-02f, -4.19603288e-02f, 3.25501263e-02f, -1.21830925e-02f, 1.32991105e-01f, 1.46279082e-01f, 4.53251153e-02f,
  -1.02247419e-02f, 3.14597189e-02f, 1.51585624e-01f, 9.85082686e-02f, 1.40035033e-01f, 1.08791433e-01f, 1.10630721e-01f, 1.29865050e-01f, 1.36630759e-01f, -3.63125540e-02f,
  2.00769797e-01f, 3.42594162e-02f, 6.29080907e-02f, 6.34611025e-02f, -2.77225170e-02f, -5.84760448e-04f, 6.37767604e-03f, -8.83731470e-02f, 4.93452176e-02f, -7.18518123e-02f,
  -3.64219137e-02f, 1.46324754e-01f, 1.70409068e-01f, 3.02790385e-02f, 3.99336442e-02f, -1.84700992e-02f, 7.63364434e-02f, -4.82055992e-02f, -1.96807571e-02f, -5.31078652e-02f,
  -1.17534749e-01f, -9.14075375e-02f, -8.21376517e-02f, -2.40444690e-02f, 7.65466318e-02f, -3.03647500e-02f, -2.58403458e-02f, -2.92697717e-02f, -5.80922440e-02f, -2.86932494e-02f,
  2.75455981e-01f, 7.84794241e-02f, 2.27930304e-02f, 3.88460755e-02f, -7.86509216e-02f, -1.14119671e-01f, 1.63787439e-01f, -5.38266962e-03f, -5.55857196e-02f, 1.67630628e-01f,
  2.26875916e-02f, 2.02497132e-02f, 1.44638764e-02f, -1.65601537e-01f, -3.03880014e-02f, 1.86365731e-02f, -8.30757692e-02f, 1.88695267e-01f, 8.32062308e-03f, -1.35930162e-03f,
  1.12451361e-02f, 1.64088309e-01f, 7.31481537e-02f, 4.45671342e-02f, -1.16300220e-02f, 1.51291475e-01f, 3.50511074e-02f, 7.84013644e-02f, -6.32703751e-02f, -1.00897446e-01f,
  -6.20689452e-01f, -7.30223507e-02f, -1.95811465e-01f, -3.67173254e-01f, 8.43252148e-03f, 1.61652401e-01f, 9.36616734e-02f, 1.22394487e-01f, -2.10865229e-01f, -1.27016321e-01f,
  -2.61356160e-02f, -4.10910398e-02f, -2.92417139e-01f, -1.05696432e-01f, -1.59022063e-01f, -2.16423586e-01f, -1.75579324e-01f, -5.62102571e-02f, 1.11187331e-01f, 2.30733156e-01f,
  1.22450091e-01f, -8.62987489e-02f, -6.91130012e-02f, -1.39475409e-02f, -6.15366036e-03f, -4.86518592e-02f, -1.58579037e-01f, -1.30877525e-01f, 1.46652743e-01f, -1.56527713e-01f,
  -1.65157408e-01f, 3.72564867e-02f, 7.78681040e-02f, -1.17558338e-01f, -2.41901278e-01f, -7.10351691e-02f, -5.88664599e-02f, -1.56718150e-01f, 3.78224142e-02f, -1.97445601e-03f,
  -1.28436536e-02f, 1.98140621e-01f, -6.35707453e-02f, 3.63012962e-02f, -1.21166043e-01f, 8.71847346e-02f, -5.11549339e-02f, -6.38557673e-02f, 4.10139412e-02f, 6.14572428e-02f,
  1.39536589e-01f, 2.52867825e-02f, 2.28630714e-02f, 6.36229366e-02f, 5.67040332e-02f, -7.82541484e-02f, 1.12096533e-01f, 2.15135977e-01f, 2.18212888e-01f, -3.07589024e-02f,
  1.08843364e-01f, -1.03736095e-01f, 5.27861528e-02f, -7.55117238e-02f, 3.50218825e-02f, 2.10737344e-03f, -1.60963818e-01f, -4.78200093e-02f, 9.13376212e-02f, -1.53983384e-01f,
  -9.40758083e-03f, -2.79955566e-02f, 2.30810642e-02f, -1.22305620e-02f, -1.47562185e-02f, 1.00803547e-01f, -5.20029366e-02f, -8.63210559e-02f, -8.65725521e-03f, -4.71748151e-02f,
  -5.23700640e-02f, -1.66978110e-02f, -1.45433873e-01f, 1.11588351e-01f, 8.76381844e-02f, -1.13675147e-02f, 9.11560804e-02f, 6.76723421e-02f, -8.56016949e-02f, -6.52929943e-04f,
  -3.00422937e-01f, 3.86973284e-02f, -3.59922588e-01f, 1.05209686e-01f, -5.13405018e-02f, 1.08991705e-01f, -1.37429878e-01f, -6.50280043e-02f, -1.46513626e-01f, 4.41380218e-02f,
  7.66922012e-02f, -6.37105554e-02f, -1.76273212e-01f, 8.26930851e-02f, 3.38235795e-02f, 3.14619802e-02f, -3.77387591e-02f, -9.02938023e-02f, 6.84276223e-02f, 3.88248041e-02f,
  1.59573510e-01f, 4.37393747e-02f, -1.32658333e-01f, -1.05102919e-02f, 7.81627521e-02f, -5.65413125e-02f, -1.13621550e-02f, 8.16403702e-02f, 1.62689853e-02f, -1.19507566e-01f,
  6.12200379e-01f, 1.18945442e-01f, -1.24779693e-03f, 2.62439698e-01f, -2.59749562e-01f, -2.95922428e-01f, -2.44836602e-02f, -8.49630460e-02f, -1.47607401e-01f, 1.04828782e-01f,
  -1.48696974e-01f, -3.84403259e-01f, -1.02752365e-01f, -1.51967391e-01f, -4.53648269e-02f, 1.30545959e-01f, 2.11180132e-02f, 7.50348121e-02f, -3.42233241e-01f, -2.35696852e-01f,
  -1.65632740e-01f, 4.62025255e-02f, 9.66972709e-02f, -3.42275091e-02f, 3.90417986e-02f, -1.18906222e-01f, 1.75336644e-01f, -7.06425235e-02f, -1.31613836e-01f, 2.98269372e-03f,
  3.67064886e-02f, 1.91607580e-01f, -2.39693865e-01f, -1.55289695e-01f, -2.08694473e-01f, 1.84356764e-01f, -8.24064314e-02f, -2.41009910e-02f, -1.49727330e-01f, -7.00899884e-02f,
  -3.08702886e-01f, -1.04969472e-01f, -1.77989811e-01f, -2.33210757e-01f, -5.70326820e-02f, -1.64271668e-01f, 6.43950477e-02f, 1.13591217e-01f, 5.75494207e-02f, 5.48569733e-05f,
  -1.68669343e-01f, -1.62871689e-01f, -5.53996563e-02f, 1.17349820e-02f, 2.22005062e-02f, -6.68390766e-02f, -8.78983960e-02f, -3.75127159e-02f, -7.16660544e-02f, 1.38482437e-01f,
  -3.17959264e-02f, -1.42272403e-02f, 7.63751660e-03f, 1.35589421e-01f, 1.14167541e-01f, -8.26493129e-02f, -9.49707925e-02f, -1.21707588e-01f, -8.29596221e-02f, 4.41945903e-02f,
  -2.45211944e-02f, 6.82844967e-02f, -1.19319387e-01f, 4.57935892e-02f, 2.04038862e-02f, -1.11411110e-01f, -9.85590816e-02f, 1.68360889e-01f, 6.05173782e-02f, 2.08971612e-02f,
  -4.71279509e-02f, -1.96616892e-02f, 5.67344464e-02f, -2.78186649e-02f, 1.48467012e-02f, -1.98513847e-02f, 2.70070843e-02f, -1.55441269e-01f, -3.88358198e-02f, 2.02617962e-02f,
  4.49946932e-02f, -1.71431527e-01f, 7.99559057e-02f, -5.13869524e-02f, -2.10660651e-01f, 3.25447954e-02f, 1.20327510e-02f, -1.01552017e-01f, -9.44416448e-02f, -3.27091366e-02f,
  -2.42709443e-01f, 5.36049530e-02f, 5.71513399e-02f, -1.86132509e-02f, 8.68721493e-03f, -2.89886091e-02f, 2.03606989e-02f, 1.49817215e-02f, -1.34799778e-01f, 1.41871303e-01f,
  1.86569005e-01f, 8.17830116e-02f, -1.59703493e-02f, 4.77334158e-03f, -1.41189210e-02f, -4.62630205e-02f, -1.27173245e-01f, -1.86876386e-01f, -1.41051769e-01f, 2.29512289e-01f,
  1.63101956e-01f, 1.19078703e-01f, 2.42632151e-01f, 2.88939357e-01f, 2.62937576e-01f, 8.47971365e-02f, 1.67309314e-01f, 2.12449133e-01f, 6.22748174e-02f, 5.55859320e-02f,
  1.00848153e-01f, 1.73238456e-01f, 2.52360582e-01f, 2.21757740e-01f, 1.60915241e-01f, 1.97191730e-01f, 2.71069854e-01f, 1.24959491e-01f, 1.41231775e-01f, 9.82632264e-02f,
  1.99313760e-01f, 8.26586783e-02f, 8.32925588e-02f, 2.75554582e-02f, 2.46550038e-01f, 1.31482154e-01f, 7.15585202e-02f, 1.26367092e-01f, 1.46804914e-01f, 2.57472813e-01f,
  -2.09899452e-02f, 1.26215920e-01f, 5.02928235e-02f, -2.96236668e-02f, -7.19499663e-02f, -2.11697549e-01f, -1.22276127e-01f, -7.24290386e-02f, -8.60149488e-02f, -1.59979045e-01f,
  -1.07010990e-01f, 3.31038721e-02f, 1.16921321e-01f, -1.07654385e-01f, -1.87735170e-01f, -1.33509800e-01f, -1.57084435e-01f, 4.30564536e-03f, 9.43173915e-02f, -6.63833097e-02f,
  1.15358941e-01f, 9.29050446e-02f, 4.65629436e-02f, -7.59240687e-02f, 4.27746624e-02f, 1.51210085e-01f, 1.58637632e-02f, 5.17126694e-02f, -6.60769269e-02f, -6.42173514e-02f,
  1.12792812e-01f, 1.30667314e-01f, 1.22401156e-01f, -1.23259723e-01f, -4.56471648e-03f, -2.64412373e-01f, -1.40549794e-01f, -1.41788200e-01f, -9.99537706e-02f, -9.75894332e-02f,
  -9.31200236e-02f, 2.81764995e-02f, -8.66525546e-02f, -8.03781524e-02f, 1.32303745e-01f, 6.72733337e-02f, -6.05180822e-02f, -1.35061353e-01f, 1.83919654e-03f, -2.71600042e-03f,
  -5.05711362e-02f, -1.82106756e-02f, -4.42174152e-02f, -2.95952801e-02f, -2.04795562e-02f, 4.29496057e-02f, -7.75093958e-02f, -9.09441710e-02f, -1.32314919e-03f, -2.94739753e-02f,
  1.16445839e-01f, 1.90984517e-01f, 8.34564120e-02f, 1.41473070e-01f, -1.63660217e-02f, -1.28601696e-02f, 3.20308656e-02f, 1.08704984e-01f, -1.19612338e-02f, -1.43938407e-01f,
  -3.57066095e-02f, 6.87523633e-02f, -4.10452262e-02f, -9.11287144e-02f, -1.72887623e-01f, -1.87491745e-01f, -5.80798648e-02f, 2.09711660e-02f, 2.11816989e-02f, -1.46307215e-01f,
  -2.61233114e-02f, -1.34729594e-01f, 1.69567838e-02f, 3.41044068e-02f, -1.19008936e-01f, -2.01093610e-02f, -1.70943663e-01f, -9.97559875e-02f, -5.99019341e-02f, -1.89937815e-01f,
  -2.93263555e-01f, 3.16227078e-01f, -5.66344969e-02f, -1.73414752e-01f, 1.32307976e-01f, 1.68308973e-01f, 2.57342398e-01f, 8.97350255e-03f, -3.57867964e-02f, 1.55057073e-01f,
  6.17304966e-02f, -8.05623233e-02f, 1.04839712e-01f, 6.94482028e-02f, -2.48907417e-01f, 1.28206030e-01f, 2.19699025e-01f, -2.56823033e-01f, -4.03895915e-01f, -1.07473910e-01f,
  -2.59705018e-02f, -1.95605502e-01f, -3.52473050e-01f, -2.85179049e-01f, 1.78776905e-01f, -3.84062305e-02f, 7.98741579e-02f, -1.01823509e-01f, 2.78084315e-02f, 3.40720206e-01f,
  5.01234224e-03f, 2.20976304e-02f, 1.75886676e-02f, -1.78500548e-01f, 1.22676924e-01f, -1.80036753e-01f, 6.41068518e-02f, -3.84460986e-02f, -3.84019837e-02f, 3.40949856e-02f,
  -1.14875368e-03f, 1.33521229e-01f, 6.57503679e-02f, -8.24430119e-03f, -1.79630786e-01f, -1.09513253e-01f, -7.38031194e-02f, -1.14024319e-01f, -1.60853297e-01f, -8.26511830e-02f,
  6.81690872e-02f, -1.70045663e-02f, 2.26902720e-02f, -6.54289946e-02f, 5.61489984e-02f, -1.30959719e-01f, 1.42554427e-02f, -9.12981182e-02f, -1.56880945e-01f, 1.12327905e-02f,
  5.86856008e-02f, -2.43928935e-02f, 9.53637436e-02f, 7.03751389e-03f, -8.90529826e-02f, 2.63591241e-02f, -3.46864685e-02f, 4.05841619e-02f, 4.19980995e-02f, -7.93675631e-02f,
  -8.95318985e-02f, -3.77951004e-02f, 3.62114934e-03f, 1.07367836e-01f, -1.10572599e-01f, -2.22575967e-03f, -3.17879021e-02f, 3.35591622e-02f, -3.47535349e-02f, 3.95592861e-02f,
  2.31880043e-02f, -1.53412055e-02f, -3.11861541e-02f, -1.02487147e-01f, 1.98903307e-03f, -1.55225210e-03f, 5.35807535e-02f, -1.22194849e-01f, -3.29673290e-02f, 8.30494612e-02f,
  -2.11840808e-01f, 1.59010347e-02f, -7.52221942e-02f, -1.03066843e-02f, 6.10542996e-03f, 2.67358758e-02f, 6.05834089e-02f, -1.37790978e-01f, 7.07170507e-03f, -3.13155875e-02f,
  -2.51647457e-02f, 4.96399812e-02f, -1.74435601e-02f, 8.44229832e-02f, -7.84694627e-02f, 1.14692815e-01f, 9.65703502e-02f, -5.18666115e-04f, -1.10748392e-02f, -1.52800098e-01f,
  -1.19462699e-01f, 1.69646293e-02f, 3.67664825e-03f, 4.40791808e-02f, 1.42207928e-02f, -6.48621330e-03f, -1.26147851e-01f, -1.08172923e-01f, -1.32500604e-01f, -2.39736959e-02f,
  -1.61853358e-01f, 1.96995288e-01f, -1.42150134e-01f, 1.15485094e-01f, 2.21506476e-01f, 7.17855478e-03f, 7.64054246e-03f, -1.15134746e-01f, -8.08667578e-03f, -4.34590392e-02f,
  2.00374052e-02f, 7.63960630e-02f, 1.08096696e-01f, 2.23042928e-02f, -1.33404985e-01f, 2.52871681e-02f, 2.35818967e-01f, 1.87461838e-01f, -1.08448766e-01f, 8.16290230e-02f,
  1.73018202e-01f, 9.90131348e-02f, -6.61180168e-02f, 4.70818914e-02f, 3.03077936e-01f, 1.68604836e-01f, 8.88143927e-02f, 7.97419697e-02f, 1.48667783e-01f, 5.50732374e-01f,
  -1.99147269e-01f, -1.48074090e-01f, -1.73468262e-01f, 7.85485581e-02f, 8.68842453e-02f, 4.97025922e-02f, 2.22132266e-01f, -1.42644510e-01f, 1.50830783e-02f, -1.65213197e-02f,
  9.26235467e-02f, -1.89353805e-02f, 3.52298468e-02f, -2.70879827e-03f, -4.41657007e-02f, -1.55623499e-02f, 1.80443786e-02f, 1.24649107e-02f, -8.34673941e-02f, -1.34752542e-01f,
  9.90150496e-02f, 5.24861552e-02f, -5.39113302e-03f, -1.17263906e-01f, -9.10453275e-02f, 4.63418476e-02f, -1.17614172e-01f, 3.33595499e-02f, -1.80647105e-01f, 2.25772746e-02f,
  -4.97458987e-02f, 8.73436555e-02f, 7.59534314e-02f, 6.49454817e-02f, 1.50040746e-01f, -2.68024392e-02f, 3.95314768e-02f, 1.13278262e-01f, -1.71765387e-02f, 6.58360496e-02f,
  -6.50738180e-02f, -2.73892712e-02f, 2.99787312e-03f, -1.56163990e-01f, -5.27402237e-02f, 2.79575437e-02f, 1.14907242e-01f, 1.11979067e-01f, -1.10175297e-01f, -6.65630773e-02f,
  7.60750249e-02f, 7.11975321e-02f, -5.27077615e-02f, 9.88981053e-02f, -4.24210951e-02f, 1.40748844e-02f, -1.21142007e-02f, -5.13384007e-02f, -5.74054942e-02f, 1.36884108e-01f,
  -7.36066848e-02f, -2.78199136e-01f, -2.86599994e-02f, 9.22791511e-02f, -3.60435061e-02f, 4.17147614e-02f, 1.47776827e-02f, -1.06151208e-01f, 6.77616969e-02f, -8.39780793e-02f,
  -4.30553705e-02f, -1.04158655e-01f, -1.53605074e-01f, 9.79368314e-02f, 3.53212445e-03f, 2.83959713e-02f, 1.11804686e-01f, 8.25463012e-02f, -9.95231569e-02f, -5.92896454e-02f,
  3.09479181e-02f, -1.78183258e-01f, -3.39660682e-02f, 4.30873735e-03f, 1.38937712e-01f, -3.43193822e-02f, -1.42077446e-01f, -3.60832848e-02f, -2.48093158e-01f, -2.00758800e-01f,
  4.99260098e-01f, 1.99430123e-01f, 1.83189556e-01f, 1.74097531e-02f, -1.11024104e-01f, 6.90863729e-02f, 8.62101167e-02f, -3.95176113e-02f, -1.78402767e-01f, 2.06456855e-02f,
  1.21586673e-01f, -6.94426754e-03f, 5.33803478e-02f, 3.13570090e-02f, 7.05337524e-02f, -1.49703529e-02f, -1.63703710e-01f, 7.06638470e-02f, 1.79204345e-02f, -5.07725589e-02f,
  -1.31255209e-01f, -2.03852415e-01f, -5.12289225e-05f, -5.24869822e-02f, -8.53670537e-02f, -1.36938706e-01f, 1.68145858e-02f, -5.06437160e-02f, -9.07425210e-02f, -1.67228207e-01f,
  4.05429453e-01f, 1.63332388e-01f, -9.30011272e-03f, -8.69978443e-02f, 7.23422095e-02f, 7.42437094e-02f, 9.92069915e-02f, 9.32876468e-02f, 4.19450551e-02f, -7.21413866e-02f,
  -7.75484927e-03f, 1.69210713e-02f, 4.70742993e-02f, 2.62708627e-02f, 7.38489479e-02f, -4.09966940e-03f, -1.14154771e-01f, -1.22392409e-01f, -8.64250138e-02f, 1.03868559e-01f,
  -5.89828454e-02f, -8.88140351e-02f, 2.67666373e-02f, -1.01899445e-01f, -3.10095493e-02f, 2.71699578e-03f, 6.48347586e-02f, -1.34190321e-01f, -1.00263664e-02f, -8.06866810e-02f,
  3.67868952e-02f, 2.64779516e-02f, -6.68359501e-03f, -4.38829102e-02f, 4.87539060e-02f, 5.77065758e-02f, 5.15749939e-02f, -3.06565110e-02f, 3.63473482e-02f, -8.05881154e-03f,
  -1.33835331e-01f, -2.22082678e-02f, 1.06470026e-01f, 3.44335511e-02f, 1.42042875e-01f, -2.34892182e-02f, -1.63137857e-02f, 6.25637323e-02f, 2.20004991e-02f, -3.06014474e-02f,
  2.64048222e-02f, 2.75719538e-02f, 1.03582628e-01f, -9.36049893e-02f, 9.39492807e-02f, -5.40165640e-02f, 5.03885839e-03f, 7.80442730e-02f, 3.41014122e-04f, -1.45788282e-01f,
  -1.40337974e-01f, 2.16341272e-01f, -4.88022268e-02f, -6.24107495e-02f, 1.48093998e-01f, 1.03033885e-01f, 2.09311172e-01f, 1.56565636e-01f, 1.43830746e-01f, 1.00539409e-01f,
  9.87190008e-02f, 1.89486727e-01f, 3.08545167e-03f, -7.30168745e-02f, -9.42216739e-02f, 7.77168348e-02f, 1.10643327e-01f, 6.19653463e-02f, -7.26280957e-02f, 3.10816765e-02f,
  4.56411988e-02f, 4.99821715e-02f, -3.20833512e-02f, 1.67587716e-02f, -7.25608021e-02f, -6.21461309e-02f, 9.23242718e-02f, 4.73875813e-02f, 1.35297075e-01f, -1.85321923e-02f,
  -6.45239115e-01f, -2.89701670e-02f, -3.49267162e-02f, -4.63669121e-01f, -1.87936768e-01f, -3.13932933e-02f, -6.01152405e-02f, 1.50278350e-02f, -1.48927614e-01f, -1.54804185e-01f,
  8.64527225e-02f, 4.11280952e-02f, -1.85852617e-01f, 3.13555710e-02f, -9.39808935e-02f, -2.49199972e-01f, -3.08744609e-01f, -1.06418803e-01f, 1.48647755e-01f, 2.80672520e-01f,
  -8.17108899e-03f, -1.77620113e-01f, -1.44475460e-01f, 4.83854301e-02f, -5.91379292e-02f, -4.66251113e-02f, -2.32776642e-01f, -4.99010980e-02f, 6.37444332e-02f, -3.51499975e-01f,
  1.90040227e-02f, -3.29301991e-02f, -1.18416056e-01f, -1.43310934e-01f, -1.55337006e-01f, 2.16021296e-02f, 3.53160724e-02f, -4.88432199e-02f, 6.24456666e-02f, -8.00276995e-02f,
  -1.05486393e-01f, 5.69444299e-02f, -9.37203392e-02f, 1.01413783e-02f, 7.72515452e-03f, 3.00966073e-02f, 6.06577396e-02f, 3.19960602e-02f, -7.06243142e-02f, 1.08657464e-01f,
  5.45221381e-02f, -3.53011526e-02f, 5.26342168e-02f, 5.07234335e-02f, 1.48107067e-01f, -7.41989762e-02f, 5.62880747e-02f, 1.49006128e-01f, 2.08836615e-01f, 2.99602328e-03f,
  1.08065270e-02f, 8.46702978e-02f, 4.40124534e-02f, -1.47329485e-02f, 5.79138054e-03f, -1.60190389e-02f, -1.10496335e-01f, 3.79623636e-03f, 6.24854155e-02f, -1.05460972e-01f,
  -4.02957499e-02f, -4.61819544e-02f, -2.77083591e-02f, -1.00112058e-01f, 3.58215198e-02f, 5.72246350e-02f, -1.60948783e-01f, -3.63679752e-02f, 3.95044014e-02f, -7.61945993e-02f,
  -2.18818560e-02f, 1.47628831e-02f, -1.13577716e-01f, 2.87923329e-02f, -1.34226009e-02f, -6.16754778e-02f, -2.80801579e-02f, 2.69118343e-02f, 6.73967972e-03f, 5.15565537e-02f,
  -5.38084842e-02f, -6.40470311e-02f, -1.28058106e-01f, 1.75283030e-01f, -3.30081843e-02f, -9.30318236e-03f, -5.15137911e-02f, 5.60783297e-02f, -1.26205593e-01f, -4.32448611e-02f,
  7.47163743e-02f, 7.21852109e-02f, -2.46591959e-03f, 6.47978708e-02f, -8.44382122e-02f, -7.08953291e-02f, 4.98943543e-03f, -2.03008130e-01f, -3.31746265e-02f, 4.08253074e-02f,
  4.27397676e-02f, -5.48245050e-02f, -9.61992070e-02f, 7.29917455e-03f, 5.24064898e-02f, -1.33175194e-01f, 1.78920120e-01f, 5.13983928e-02f, 1.22813635e-01f, -1.42754748e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  8.42904970e-02f, 6.53413385e-02f, 1.29804015e-01f, 5.53249903e-02f, 1.52069330e-01f, 2.40339026e-01f, 4.19120602e-02f, 1.75973997e-02f, 9.45691541e-02f, 1.27062738e-01f,
  1.11226477e-01f, -4.32676151e-02f, 1.18073434e-01f, 1.68311968e-01f, 1.74500003e-01f, 1.21040821e-01f, 7.11371079e-02f, 1.15704916e-01f, 6.03001788e-02f, 8.84286910e-02f,
  1.44791063e-02f, 6.68081343e-02f, 1.66241731e-02f, -4.17595394e-02f, 7.89603665e-02f, 1.16983242e-01f, 4.22346666e-02f, -3.48991379e-02f, 1.32698908e-01f, 6.05658107e-02f,
  1.72191501e-01f, -9.53012779e-02f, -1.82367206e-01f, -6.41282424e-02f, 2.64537245e-01f, 2.33107843e-02f, 9.16365534e-02f, -1.07620820e-01f, -7.73168802e-02f, 6.34908900e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.16347929e-02f, 9.76876728e-03f, -1.05766684e-01f, -2.58928627e-01f, -1.32868558e-01f, 7.01876953e-02f, -9.12710372e-03f, -9.35945511e-02f, 2.35398393e-02f, -1.39261514e-01f,
  -1.71138402e-02f, -2.35651240e-01f, 3.63144442e-03f, -6.19243979e-02f, -1.20242208e-01f, 8.02833773e-03f, 2.44838316e-02f, 1.10769331e-01f, 6.15883581e-02f, -2.74459682e-02f,
  1.89684048e-01f, 1.28165362e-02f, -8.00145268e-02f, -1.57038663e-02f, -5.41166842e-01f, -2.13802502e-01f, 4.78198454e-02f, 9.69073921e-02f, 3.14072967e-02f, 1.37101576e-01f,
  5.12253307e-02f, -1.31807467e-02f, 1.61403984e-01f, -1.02941088e-01f, -3.06820720e-01f, 8.26486275e-02f, -1.26458064e-01f, 2.43457183e-01f, 7.18908571e-03f, -1.61209241e-01f,
  -3.36626694e-02f, -9.50682387e-02f, -1.74585968e-01f, -1.04772747e-01f, -1.03045993e-01f, 1.52405381e-01f, 1.82707176e-01f, 1.36499712e-02f, 3.67359251e-01f, -1.12059034e-01f,
  -2.01189741e-01f, 1.01103541e-02f, -2.57930392e-03f, -2.02849321e-02f, -2.22298384e-01f, 1.49192542e-01f, 7.15594515e-02f, 2.18197525e-01f, -2.88259119e-01f, -2.53654867e-02f,
  2.19098985e-01f, 2.22643912e-01f, -1.10059768e-01f, 1.27423584e-01f, 5.93630373e-02f, -1.49323076e-01f, 1.76561698e-01f, 1.18048126e-02f, 5.09871468e-02f, -1.72381565e-01f,
  -1.46359131e-02f, 3.24055701e-02f, 2.00533643e-02f, 7.80423954e-02f, -9.24658477e-02f, 9.02754441e-02f, -6.19919263e-02f, 1.05606101e-01f, 7.76601508e-02f, 1.12168603e-01f,
  -5.31490520e-03f, -1.55781761e-01f, -5.49751781e-02f, 5.50376736e-02f, 7.68771768e-02f, 1.56778902e-01f, -2.37061650e-01f, -4.42830399e-02f, -1.61071464e-01f, -3.39822914e-03f,
  2.66907483e-01f, -8.39218944e-02f, -1.90462634e-01f, 2.36614913e-01f, 1.24825627e-01f, 1.44058257e-01f, 7.53576532e-02f, -6.17134459e-02f, -1.55487791e-01f, 1.01998225e-01f,
  -2.30932608e-01f, -1.82408124e-01f, -1.78797334e-01f, 1.25101849e-01f, 2.07648829e-01f, 1.06063403e-01f, 9.17174146e-02f, 2.67645698e-02f, 1.34168893e-01f, 1.72846273e-01f,
  -2.82341003e-01f, -1.24546893e-01f, 8.87225196e-02f, 5.23119941e-02f, 1.17600515e-01f, 2.90349633e-01f, -2.67522093e-02f, -3.16293716e-01f, -4.42981860e-03f, -6.34264499e-02f,
  1.07773036e-01f, 1.56324565e-01f, -1.83238997e-03f, 2.96172816e-02f, 7.73612736e-03f, 8.31917822e-02f, -1.33073241e-01f, -5.71616441e-02f, -4.40516658e-02f, -1.36024207e-01f,
  1.24159500e-01f, 5.18224761e-02f, 2.25867797e-02f, 5.44510819e-02f, 1.78267416e-02f, 9.38645080e-02f, 5.00963256e-02f, 3.07601430e-02f, 8.94271880e-02f, -3.06661613e-02f,
  9.35400575e-02f, 5.67836538e-02f, 3.81794274e-02f, -2.25199819e-01f, -1.11675136e-01f, 1.33519039e-01f, 1.69530973e-01f, 4.40640226e-02f, -7.67216235e-02f, -3.59780365e-03f,
  1.93935838e-02f, -6.56531285e-03f, -2.41293833e-01f, -1.07161261e-01f, 3.71638805e-01f, -1.83869466e-01f, 5.50719015e-02f, -2.23387644e-01f, 6.21471331e-02f, 1.64454088e-01f,
  8.39764178e-02f, -3.81641537e-01f, -1.92904085e-01f, 1.45907536e-01f, -1.66770101e-01f, 1.34128794e-01f, -2.04136148e-01f, 3.63718867e-02f, -1.60255115e-02f, -3.48450132e-02f,
  8.27943906e-02f, -1.45695627e-01f, -3.98440063e-02f, 2.87482142e-01f, -2.30110601e-01f, -1.14486683e-02f, 2.55174376e-02f, 1.66512206e-01f, 3.77087891e-02f, -1.22826137e-01f,
  5.11981882e-02f, -3.07931215e-01f, -1.89780295e-01f, -1.44455999e-01f, -9.62628201e-02f, -2.31438458e-01f, -1.20195143e-01f, -1.87756196e-01f, 6.69677854e-02f, 2.89096475e-01f,
  2.43542064e-02f, -1.56931862e-01f, -8.55495185e-02f, -9.30268764e-02f, 7.07611665e-02f, -3.94855589e-02f, -7.99600780e-02f, 2.40449235e-02f, -1.58656657e-01f, 1.09377913e-02f,
  9.94732138e-03f, 1.63917821e-02f, -1.08902745e-01f, 1.09144330e-01f, -1.07177354e-01f, 1.27308071e-01f, 8.20852667e-02f, -1.21779637e-02f, 6.89095408e-02f, -1.25136495e-01f,
  1.12922862e-01f, 1.18578849e-02f, -7.96496421e-02f, 1.04866445e-01f, -2.16510192e-01f, -3.77084054e-02f, -1.26409203e-01f, -1.00543000e-01f, 1.95199892e-01f, 1.18370662e-02f,
  7.88313709e-03f, 3.88886243e-01f, -3.15524936e-02f, -5.60919866e-02f, 9.14794058e-02f, -2.46695373e-02f, 1.19170211e-01f, 5.71313454e-03f, 1.33523634e-02f, 9.11023989e-02f,
  6.41262308e-02f, 7.06723630e-02f, 2.65469790e-01f, -2.99591459e-02f, -3.90429012e-02f, 8.73205811e-02f, -3.30809429e-02f, -2.04710085e-02f, 1.70551203e-02f, -1.98210046e-01f,
  3.50283861e-01f, -1.48412824e-01f, -3.45907398e-02f, 1.56303421e-01f, 1.41225532e-01f, -2.58471053e-02f, 3.54874954e-02f, 7.77180493e-02f, -1.44570798e-01f, 2.52091169e-01f,
  -7.40244836e-02f, -2.07568891e-02f, 6.27178103e-02f, 1.01938143e-01f, -1.15978949e-01f, 1.76513977e-02f, 6.91929758e-02f, 3.43118869e-02f, -7.89767727e-02f, -3.23643498e-02f,
  6.20373078e-02f, -2.04162300e-01f, 3.49626131e-02f, -2.68115513e-02f, -2.80096699e-02f, 5.09393821e-03f, 4.07364629e-02f, -1.70068994e-01f, 6.14984557e-02f, 1.58782993e-02f,
  2.42939308e-01f, 2.09170163e-01f, 2.88051486e-01f, 2.76985437e-01f, -1.22008756e-01f, 3.38874310e-02f, -9.02010202e-02f, 2.24147420e-02f, 4.53567877e-02f, 2.90300790e-02f,
  4.40224409e-01f, 2.55658031e-01f, -2.09720016e-01f, -1.52510494e-01f, 3.90908681e-02f, -6.31241500e-02f, -1.44796865e-02f, -1.16656393e-01f, 9.08014923e-02f, 2.23225042e-01f,
  1.29778743e-01f, -2.13972628e-02f, 2.73830235e-01f, -2.39137337e-01f, 1.12544447e-01f, -1.40459672e-01f, 2.17641726e-01f, -1.71390936e-01f, -9.30178836e-02f, 8.94343704e-02f,
  9.45774093e-02f, -1.09723717e-01f, -2.57191323e-02f, -7.69629562e-03f, 3.55956815e-02f, -1.55941948e-01f, -2.06471737e-02f, 1.43740982e-01f, -1.46786064e-01f, -5.23070283e-02f,
  -1.15190469e-01f, -8.27962533e-02f, -9.11107957e-02f, 1.00026421e-01f, -5.95866740e-02f, 4.04427722e-02f, -3.13309133e-01f, -2.36969978e-01f, 8.47038254e-02f, -3.90228443e-02f,
  4.03157994e-02f, 1.21047795e-01f, -2.91661434e-02f, 6.04236126e-02f, -2.01212186e-02f, 6.25781342e-02f, -5.52928932e-02f, -1.09310402e-02f, 1.38399109e-01f, 8.26665163e-02f,
  9.46932063e-02f, -8.29252973e-02f, 4.26669158e-02f, 8.95374417e-02f, -5.35919331e-03f, 4.51322608e-02f, 1.48816183e-01f, -1.39552817e-01f, -1.16416842e-01f, 6.65258467e-02f,
  2.01517150e-01f, 1.91730894e-02f, 9.49993730e-03f, -6.24092370e-02f, -6.15904070e-02f, 1.69021487e-02f, -6.90130750e-03f, -1.11709490e-01f, -3.32379699e-01f, -6.93473518e-02f,
  8.20983797e-02f, 2.34819978e-01f, -1.03382275e-01f, 9.03418809e-02f, 9.84297767e-02f, -6.60015285e-05f, 3.03379376e-03f, -3.91081214e-01f, 1.33661106e-01f, -2.91363090e-01f,
  -3.63662332e-01f, 1.19659424e-01f, 5.24895340e-02f, 8.12785253e-02f, -2.04092100e-01f, -7.09751695e-02f, 2.55907606e-02f, 1.44606471e-01f, -2.17456356e-01f, 1.11043088e-01f,
  -1.41462414e-02f, -1.45004317e-01f, 1.30278319e-01f, 1.63527474e-01f, 1.95189714e-02f, -7.64646381e-02f, -1.14308439e-01f, -2.16418296e-01f, 1.44609630e-01f, -2.12362092e-02f,
  -2.77317822e-01f, -2.70408317e-02f, -5.84347211e-02f, -1.66749388e-01f, -1.55470327e-01f, -7.81648904e-02f, -4.88180332e-02f, -5.22042923e-02f, 2.33099349e-02f, -3.90062518e-02f,
  -4.37631905e-02f, -4.17916067e-02f, 5.60972542e-02f, -1.73454568e-01f, -7.07133627e-03f, 6.08328357e-03f, 3.83518450e-02f, -2.50012968e-02f, -5.36557334e-03f, 7.49421716e-02f,
  -2.59700686e-01f, -2.21468210e-01f, 9.13805366e-02f, 6.18583001e-02f, 2.25322042e-02f, -9.11824964e-03f, -8.30796640e-03f, 9.08977613e-02f, -2.63091445e-01f, -2.85190493e-01f,
  8.59076530e-03f, -9.59081277e-02f, 1.47521719e-01f, -1.83274597e-01f, 1.09940648e-01f, 6.86256960e-03f, -2.16100067e-02f, -1.35927945e-01f, -1.28954470e-01f, 1.02375103e-02f,
  -3.43906850e-01f, 1.64472654e-01f, -1.56127140e-01f, -1.43214520e-02f, -2.41518002e-02f, 2.46179938e-01f, 1.17259242e-01f, -8.83151814e-02f, 9.98481084e-03f, 1.37802452e-01f,
  -1.34274811e-02f, -1.22378714e-01f, 8.10424760e-02f, -1.81052350e-02f, 8.29074532e-02f, -2.15285614e-01f, 1.58673882e-01f, 1.77157119e-01f, 5.05422577e-02f, -7.92370439e-02f,
  -4.73653292e-03f, -2.38721073e-01f, 1.96950063e-01f, -8.82554427e-02f, 3.02418560e-01f, 1.84912279e-01f, 6.21010847e-02f, -1.41733319e-01f, -2.92304792e-02f, 9.48868096e-02f,
  1.65591031e-01f, 5.86078800e-02f, 1.31339550e-01f, 2.08399758e-01f, 1.32551402e-01f, 4.16831017e-01f, 1.25349313e-01f, 1.73938125e-01f, 2.87391189e-02f, 3.42387594e-02f,
  -2.25756671e-02f, 3.33135910e-02f, -3.58653329e-02f, -2.13022634e-01f, -1.94572046e-01f, -1.15741432e-01f, 1.07347943e-01f, 1.76881514e-02f, 1.94392934e-01f, 1.09461375e-01f,
  -2.48914864e-02f, -7.12777581e-03f, -1.78638726e-01f, -1.19356640e-01f, 3.35602574e-02f, 1.65522575e-01f, 1.56649292e-01f, 7.35104382e-02f, 3.29664610e-02f, 4.01230641e-02f,
  8.92425701e-02f, -2.16369167e-01f, 2.55101979e-01f, 1.51635662e-01f, -8.46256223e-03f, 1.60654649e-01f, 3.13062333e-02f, 2.36428138e-02f, -1.95348993e-01f, -1.04288749e-01f,
  1.37634441e-01f, -2.26184204e-01f, 1.68259591e-02f, 5.63214123e-02f, 5.23131639e-02f, 2.82616932e-02f, 1.72353506e-01f, -6.81316704e-02f, 2.60786768e-02f, -2.42080465e-01f,
  -9.78684053e-02f, -3.96885090e-02f, 1.76276892e-01f, 1.90376580e-01f, 7.35249445e-02f, -4.43983376e-02f, 1.23587079e-01f, 4.62747365e-02f, 2.81894445e-01f, 3.07409652e-02f,
  5.93881682e-02f, -5.63563593e-02f, -9.92798954e-02f, 5.04350327e-02f, 3.48399729e-02f, 1.29779503e-02f, -3.77445482e-02f, -3.22649255e-02f, -2.30738856e-02f, -1.84931576e-01f,
  -6.71478957e-02f, -1.94005538e-02f, -8.43460262e-02f, -1.29133552e-01f, -7.56847858e-02f, -3.29457186e-02f, 1.55529231e-01f, 1.84879348e-01f, 1.70290425e-01f, 4.33349162e-02f,
  -9.33667719e-02f, 1.18358836e-01f, -1.45141095e-01f, 5.70353791e-02f, -4.32846881e-02f, -2.59957105e-01f, 5.67753911e-02f, 4.14177701e-02f, -1.71905473e-01f, -2.39137366e-01f,
  -1.81163698e-01f, 1.37358725e-01f, 2.96762008e-02f, -4.09640111e-02f, -2.81528048e-02f, -6.86582997e-02f, -1.38173684e-01f, -7.13810548e-02f, -1.39107823e-01f, 6.24514418e-03f,
  7.18169361e-02f, 1.58759430e-01f, -5.21164946e-02f, 1.22520007e-01f, -1.50928691e-01f, 2.35214561e-01f, -7.28790164e-02f, -1.66290313e-01f, -5.73997758e-02f, 2.14599129e-02f,
  6.21698005e-03f, -4.30797040e-02f, -1.40261352e-01f, 2.53209382e-01f, 3.43454778e-02f, -2.94306446e-02f, -2.32019704e-02f, -9.68998447e-02f, -2.56416768e-01f, 2.44370297e-01f,
  -3.71704698e-02f, -8.54837820e-02f, -1.48046374e-01f, -7.94269145e-02f, -1.40329614e-01f, 2.29108781e-01f, -1.51186138e-01f, -8.83086398e-03f, 3.53754759e-02f, -4.26335745e-02f,
  -1.70234460e-02f, -2.21070945e-01f, 2.07165390e-01f, 1.65135294e-01f, 1.16510026e-01f, 9.96413454e-03f, 6.74485788e-02f, 1.75826077e-03f, -8.42453092e-02f, -5.17448857e-02f,
  -1.09238952e-01f, 3.48407365e-02f, -2.82116029e-02f, 1.52531624e-01f, 1.18949026e-01f, -1.72124773e-01f, -2.33440489e-01f, 7.90760946e-03f, -1.97284445e-01f, 2.64613274e-02f,
  -1.00911483e-01f, -8.43698531e-02f, 6.10977635e-02f, 2.67441049e-02f, -4.13628258e-02f, 1.63620442e-01f, 1.38527632e-01f, -1.01022944e-01f, -5.72369732e-02f, -1.35274231e-01f,
  -1.14874385e-01f, 1.32296294e-01f, 1.56360358e-01f, -3.18920761e-02f, 1.25696674e-01f, -4.79218587e-02f, 2.65155107e-01f, -2.81458199e-02f, -6.23852499e-02f, -1.86507814e-02f,
  2.18134791e-01f, -6.64637461e-02f, -6.92168111e-03f, 7.02569410e-02f, 9.88193825e-02f, 3.69365863e-03f, -5.77217676e-02f, -2.38822196e-02f, -2.15269495e-02f, 6.46816641e-02f,
  7.64905065e-02f, 4.86842059e-02f, -1.20863475e-01f, -4.51538786e-02f, -2.16519371e-01f, 2.30282154e-02f, -5.02510630e-02f, 3.63515951e-02f, -3.78883965e-02f, 1.94850639e-01f,
  -7.79517516e-02f, -3.54018323e-02f, 6.54230043e-02f, 3.88390347e-02f, 2.17421688e-02f, 4.31024730e-02f, -4.86454740e-02f, 1.15086019e-01f, 3.41023542e-02f, -4.68111932e-02f,
  1.07189976e-01f, -1.43582165e-01f, 1.95057560e-02f, -2.27955878e-02f, -1.44733191e-01f, -5.24469139e-03f, -1.22466289e-01f, 6.42007515e-02f, -4.86709736e-02f, -4.02821228e-02f,
  -2.61858944e-02f, 2.99188867e-02f, -9.40844566e-02f, 1.17094435e-01f, 5.09019569e-03f, -1.69570446e-01f, -1.94795113e-02f, 1.20698452e-01f, 2.35067949e-01f, 1.59328327e-01f,
  4.35033999e-02f, -1.85605466e-01f, 3.60174552e-02f, -2.17668235e-01f, 1.35060251e-01f, -7.45882988e-02f, 2.58951694e-01f, 2.80126575e-02f, 3.03177312e-02f, -1.13051400e-01f,
  -1.20404176e-01f, 2.73881346e-01f, 1.05562225e-01f, -2.74408937e-01f, -7.42397271e-03f, -1.67269818e-02f, 2.25114629e-01f, -2.48362303e-01f, -7.92466924e-02f, -2.07269534e-01f,
  1.63068876e-01f, -2.79925782e-02f, 1.50223300e-01f, -1.80333480e-02f, 5.44153340e-02f, 1.63191378e-01f, -4.64341454e-02f, -7.72579238e-02f, 1.13639005e-01f, 1.18633538e-01f,
  7.75517523e-02f, 1.33820891e-01f, 6.30044937e-03f, -1.36338264e-01f, -8.09390545e-02f, -1.99836995e-02f, 4.95989472e-02f, 4.31992114e-02f, 1.11006953e-01f, -2.73282509e-02f,
  1.04921848e-01f, -2.45359968e-02f, 3.33449878e-02f, -1.52500952e-02f, -3.36552784e-02f, 4.69297618e-02f, 2.71820296e-02f, 9.64756906e-02f, 1.25810176e-01f, 1.78160802e-01f,
  -2.71616746e-02f, 6.50219023e-02f, -3.88917439e-02f, -7.06343958e-03f, -3.02894861e-01f, -1.65084433e-02f, -1.88175678e-01f, 1.42183885e-01f, 8.11537057e-02f, 1.33504257e-01f,
  1.99150294e-01f, -4.93909717e-02f, 1.27400294e-01f, -8.71955156e-02f, 1.62681937e-01f, -1.17803425e-01f, 4.85409750e-03f, -8.58653337e-02f, -1.42856752e-02f, 1.71355810e-02f,
  1.80935282e-02f, 9.31471065e-02f, -1.49032444e-01f, 9.87247005e-02f, 2.72085935e-01f, -2.30471373e-01f, -9.82948691e-02f, 2.49199018e-01f, 1.52832836e-01f, 1.16673149e-01f,
  1.39418999e-02f, 1.73446655e-01f, 2.62005609e-02f, 1.16230875e-01f, 1.92742780e-01f, 1.29559353e-01f, -9.43790674e-02f, -2.39176616e-01f, -1.57476142e-01f, -8.54857638e-02f,
  -9.76285711e-02f, 5.02036214e-02f, -2.67746806e-01f, -3.77357705e-03f, 3.08576860e-02f, 4.52649370e-02f, 3.91478427e-02f, 8.63032788e-03f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.17792837e-01f, -6.09012805e-02f, -5.89874573e-02f, -7.27265002e-03f, -7.48161450e-02f, -4.47680205e-02f, -8.24533682e-03f, 2.17120182e-02f, -2.69298963e-02f, 6.85330704e-02f,
  7.07627758e-02f, 8.42976496e-02f, -3.98913166e-03f, -4.13634907e-03f, 1.08132608e-01f, 1.79992318e-01f, 6.22692555e-02f, -1.10982601e-02f, -4.56203595e-02f, -1.13829851e-01f,
  2.20062181e-01f, -3.68298404e-02f, 3.07357103e-01f, 1.38364226e-01f, -6.40284270e-02f, -6.36193231e-02f, -7.02216774e-02f, -1.74770385e-01f, -3.94784473e-02f, -2.46526837e-01f,
  -4.13600728e-02f, 2.84140348e-01f, -2.83387542e-01f, 2.94199702e-03f, 1.64328832e-02f, -1.71529636e-01f, -1.66289419e-01f, -1.12341948e-01f, -2.04867274e-01f, -6.01894744e-02f,
  -2.23066688e-01f, 1.71488300e-01f, 2.47253627e-01f, -3.42038780e-01f, -2.05208346e-01f, -1.42050609e-01f, 1.28585976e-02f, -8.07209164e-02f, -2.09483683e-01f, -1.19275600e-01f,
  6.15715496e-02f, -4.82644215e-02f, 1.77809760e-01f, 2.23782554e-01f, 1.49494931e-01f, -5.99169619e-02f, 1.18501903e-02f, -8.64662044e-03f, 4.72896695e-02f, 5.37805595e-02f,
  7.09114550e-03f, 8.36007968e-02f, 1.20789200e-01f, -2.47236058e-01f, 2.92887948e-02f, 1.22018293e-01f, 4.10807505e-02f, 1.40115827e-01f, 1.92897141e-01f, 1.44084841e-01f,
  1.21133052e-01f, 1.67581722e-01f, 6.98907226e-02f, 1.59567073e-01f, 1.60934955e-01f, -3.36943865e-02f, -1.80783674e-01f, 2.68803090e-01f, 2.04196125e-01f, 1.02536857e-01f,
  -4.03126962e-02f, -2.26599783e-01f, -4.92753685e-02f, 1.81271628e-01f, -9.52483937e-02f, 3.19957048e-01f, -4.16666977e-02f, 3.29764895e-02f, -1.07485875e-01f, -8.19922760e-02f,
  1.12852238e-01f, -3.12203974e-01f, 4.10466194e-02f, 4.09805357e-01f, 1.99436799e-01f, 8.44852850e-02f, -1.20765857e-01f, -2.80756980e-01f, -1.10091731e-01f, -8.04798827e-02f,
  -6.77709207e-02f, -7.07506090e-02f, 1.49163594e-02f, -1.10889167e-01f, -1.64412245e-01f, 1.87280521e-01f, 1.26553670e-01f, 1.11906361e-02f, 1.66276041e-02f, 1.16676442e-01f,
  -2.29838401e-01f, -2.23034069e-01f, 1.64173633e-01f, -2.09127426e-01f, 2.81623811e-01f, 6.54554740e-02f, -2.48120893e-02f, -4.90663320e-01f, -3.43402326e-02f, 4.26659733e-02f,
  7.76519328e-02f, -1.29977998e-03f, -4.88924701e-03f, -1.04912058e-01f, -1.46924093e-01f, -1.92892514e-02f, -7.69665837e-02f, -2.33660191e-02f, -9.17327330e-02f, -6.73061833e-02f,
  -5.67063540e-02f, -1.97605833e-01f, -1.21452704e-01f, 4.56856638e-02f, -1.07117675e-01f, -1.30937815e-01f, -3.75715382e-02f, -4.82351631e-02f, -1.28561303e-01f, -1.99968159e-01f,
  -5.80007210e-02f, 6.02975897e-02f, -1.05584241e-01f, -9.30606499e-02f, 1.46029770e-01f, 3.75515431e-01f, 3.02553624e-02f, -1.79874286e-01f, 9.02527012e-03f, 8.20888653e-02f,
  -4.70349900e-02f, 6.79353625e-02f, -1.62141681e-01f, -9.35775861e-02f, -1.31566629e-01f, -1.08039670e-01f, 2.12200791e-01f, 2.05169261e-01f, -7.14790598e-02f, 3.27622928e-02f,
  8.78362209e-02f, 1.13136575e-01f, 5.94276339e-02f, -6.77155182e-02f, -2.77761854e-02f, 1.68002918e-01f, -8.82055238e-02f, 1.17566854e-01f, 1.64656103e-01f, -3.36824059e-01f,
  -1.70862600e-01f, -3.84707078e-02f, 6.27937615e-02f, -2.36010030e-01f, 7.17937201e-02f, -1.18576370e-01f, 3.53535146e-01f, -7.94791058e-02f, 1.82643496e-02f, 1.04430839e-01f,
  -5.11347800e-02f, -1.15116753e-01f, 4.05834131e-02f, -3.27651314e-02f, -1.00019380e-01f, 2.51101404e-01f, -1.28070250e-01f, 3.15139741e-02f, 1.31325617e-01f, 1.51041985e-01f,
  -6.43436909e-02f, 2.05542788e-01f, -7.65115842e-02f, -1.12605020e-02f, 6.43871352e-02f, -1.58923212e-02f, 1.32673293e-01f, -1.47675037e-01f, 7.92174414e-02f, 1.41751915e-01f,
  2.16772154e-01f, 8.13748389e-02f, 5.02690561e-02f, 3.34935099e-01f, 1.72457546e-01f, -6.32309318e-02f, 1.08404733e-01f, 8.30624476e-02f, 1.72313936e-02f, 2.75568634e-01f,
  5.53892665e-02f, -4.79163677e-02f, 1.75391156e-02f, -2.04859987e-01f, -8.43596905e-02f, -1.06243670e-01f, -2.26365551e-01f, 1.69835985e-01f, 1.41251609e-01f, 1.45137385e-01f,
  1.08966036e-02f, -3.90519440e-01f, -3.18101142e-03f, -5.41451983e-02f, -1.35566846e-01f, -1.88675597e-02f, -2.18426123e-01f, 1.03866361e-01f, 2.24873684e-02f, -1.69684604e-01f,
  -1.43878639e-01f, 1.34154722e-01f, 2.63320386e-01f, -3.71990740e-01f, 2.08130971e-01f, 1.87486783e-01f, 4.70723622e-02f, 2.55348794e-02f, -1.08243138e-01f, 4.41236019e-01f,
  -2.07714751e-01f, 3.80294114e-01f, -3.43677908e-01f, 3.84369567e-02f, -1.96178585e-01f, 1.03681430e-01f, -9.50173736e-02f, -1.20882437e-01f, -4.32461649e-02f, -8.74078199e-02f,
  -1.01146966e-01f, -1.70846820e-01f, -2.54164226e-02f, -6.08170144e-02f, -8.40001181e-02f, 8.65049437e-02f, -3.45671177e-02f, 8.40037763e-02f, 1.86840780e-02f, -2.38346290e-02f,
  1.20486794e-02f, 1.68763354e-01f, 1.36433259e-01f, -1.93996243e-02f, 8.97837207e-02f, -9.53774061e-03f, 1.31688556e-02f, -7.76679516e-02f, 1.02505423e-01f, -4.32784259e-02f,
  -1.84481964e-02f, 1.36395961e-01f, -1.49171741e-03f, -8.92144516e-02f, 8.58072042e-02f, -2.07829550e-01f, 2.22932458e-01f, 1.47618279e-02f, 4.69607599e-02f, 7.99371973e-02f,
  2.15470210e-01f, 2.12939188e-01f, 1.59799799e-01f, 5.51917851e-02f, -1.15792595e-01f, -1.41832516e-01f, 8.70350003e-02f, 9.49927140e-03f, -3.31834471e-03f, 5.45367748e-02f,
  -1.17789447e-01f, 2.82402158e-01f, 1.67092949e-01f, -9.32996497e-02f, 1.05545208e-01f, -2.91911781e-01f, -2.46558860e-01f, -1.36703655e-01f, 2.88257509e-01f, -1.90777600e-01f,
  -1.11265860e-01f, -5.23816235e-02f, -1.93087548e-01f, 2.59751435e-02f, 1.73150152e-02f, 8.04701671e-02f, 1.35732412e-01f, -1.04833156e-01f, 4.49443422e-02f, -1.81618392e-01f,
  -3.41599062e-02f, 6.12651259e-02f, 2.78027922e-01f, -3.06591243e-01f, -5.94396181e-02f, -1.45472825e-01f, -1.12326249e-01f, 6.41400069e-02f, 2.34610647e-01f, -2.19132945e-01f,
  -4.85788696e-02f, 1.30936578e-01f, -2.50531267e-02f, 1.83942884e-01f, 1.74918562e-01f, -7.61319399e-02f, -8.36298615e-03f, 4.00863662e-02f, 4.05983031e-02f, 1.56879380e-01f,
  1.64730996e-01f, -4.73711751e-02f, 5.85587360e-02f, 4.76149805e-02f, -1.81729682e-02f, -3.03052552e-03f, -2.29476523e-02f, -9.99598578e-02f, -3.99364717e-02f, -1.30102530e-01f,
  -1.00901037e-01f, -7.45888501e-02f, 6.32930361e-03f, -6.20336793e-02f, 3.78859276e-03f, -6.21845610e-02f, 4.64577693e-03f, -2.23910511e-01f, 2.00866371e-01f, -8.21756199e-02f,
  2.22855821e-01f, -7.21868351e-02f, -6.77656941e-03f, -2.71810591e-01f, -2.97081470e-01f, 1.44744098e-01f, 1.05241381e-01f, 2.07774565e-01f, -3.12128723e-01f, 1.00347325e-01f,
  8.67185146e-02f, -5.82816079e-02f, -1.09941460e-01f, -8.18089545e-02f, 5.85720651e-02f, 2.30188653e-01f, -1.19889803e-01f, 4.21261601e-02f, 8.19822848e-02f, 1.65975124e-01f,
  -1.41601279e-01f, -4.62759249e-02f, -1.04977109e-01f, 6.37724772e-02f, -2.69784898e-01f, -4.25684564e-02f, -7.77221695e-02f, 1.80321664e-01f, -1.20770328e-01f, -1.53191641e-01f,
  1.63724691e-01f, -3.68123092e-02f, -7.04108626e-02f, 1.89958796e-01f, 1.09032564e-01f, 2.33680278e-01f, 5.20042777e-02f, 1.55446321e-01f, 2.99204607e-02f, 4.86627929e-02f,
  1.52934611e-01f, 1.28742352e-01f, 2.13693064e-02f, 2.55734712e-01f, 6.39329553e-02f, -4.85701375e-02f, 2.37998530e-01f, -1.28117770e-01f, 4.68801260e-02f, 4.67917603e-03f,
  5.39510064e-02f, 2.11667359e-01f, 1.04731493e-01f, -1.57400772e-01f, 8.64367113e-02f, -1.58273175e-01f, -1.12583898e-01f, -1.36166558e-01f, 1.22573026e-01f, -7.53998086e-02f,
  -7.68902898e-02f, 2.50949502e-01f, -9.77385789e-02f, -1.10288598e-01f, -8.18654448e-02f, -6.52198493e-02f, 5.88898584e-02f, -1.41669869e-01f, 9.55326483e-02f, -1.33870989e-01f,
  2.95045882e-01f, -4.48352844e-01f, 2.01087177e-01f, -2.07339272e-01f, -1.47698507e-01f, -2.02406034e-01f, -2.82835782e-01f, -1.83391303e-01f, -2.58492857e-01f, -6.61900714e-02f,
  -2.00839326e-01f, 2.95073777e-01f, -3.91835645e-02f, 3.80933343e-04f, -1.44256040e-01f, -3.88929009e-01f, -1.53763518e-01f, -3.66008468e-02f, 1.62204588e-03f, 6.16357028e-02f,
  1.07638761e-01f, -1.25378385e-01f, -2.97610462e-01f, -5.45698218e-02f, -2.56558359e-01f, -1.28050810e-02f, -8.64025280e-02f, 1.43927127e-01f, 4.11137715e-02f, 1.07127838e-01f,
  -1.13351634e-02f, 1.28932819e-01f, 1.79816395e-01f, 6.52145669e-02f, 1.58858955e-01f, 2.14777336e-01f, 1.56267464e-01f, 1.98453009e-01f, 9.57738049e-03f, 2.04517171e-01f,
  8.06506574e-02f, 1.09002739e-01f, -1.74268261e-01f, -5.24326712e-02f, -1.21434473e-01f, -6.11312203e-02f, -1.59514830e-01f, -7.93436617e-02f, 2.11414602e-02f, 1.33618176e-01f,
  1.05184473e-01f, 2.10281201e-02f, -1.03115119e-01f, 1.37985095e-01f, -2.91727856e-02f, -1.24391630e-01f, 2.09669128e-01f, 4.38864790e-02f, 1.99138403e-01f, -1.03677064e-01f,
  -2.17793822e-01f, 6.42110929e-02f, -2.98281372e-01f, 9.55433622e-02f, -9.25679207e-02f, 2.12740064e-01f, -1.17418364e-01f, 1.27325431e-01f, 2.58334070e-01f, -1.31982461e-01f,
  -8.60483795e-02f, 2.84572214e-01f, 1.86788127e-01f, 2.02715725e-01f, 9.63424295e-02f, -1.72195897e-01f, -9.24168900e-02f, 1.38461396e-01f, -2.16711774e-01f, 1.79363981e-01f,
  -4.27735448e-02f, 6.84599504e-02f, -3.71421784e-01f, -1.89691350e-01f, -2.72864494e-02f, -9.30671170e-02f, 2.02631965e-01f, -3.30220282e-01f, 1.39090598e-01f, -1.03451766e-01f,
  -1.89760268e-01f, -1.27744824e-01f, 3.35637219e-02f, 2.37501524e-02f, 6.11913279e-02f, -4.04766165e-02f, 1.54222203e-02f, 9.96915698e-02f, 7.31582893e-03f, -2.51182467e-02f,
  1.43436804e-01f, 1.22305520e-01f, 7.96577483e-02f, -2.16400966e-01f, -1.42103598e-01f, 6.00466318e-02f, 1.06131189e-01f, -2.25112773e-02f, -2.14874763e-02f, 3.18948418e-01f,
  8.67749602e-02f, -5.77079542e-02f, 9.08442140e-02f, -4.48988825e-02f, -1.23449445e-01f, 1.99493188e-02f, -2.06957430e-01f, -1.09413303e-01f, 3.00648133e-03f, 1.27521783e-01f,
  2.75262624e-01f, 1.71635702e-01f, -1.80985779e-02f, -3.65517028e-02f, 2.26429015e-01f, -4.79543433e-02f, -2.29838848e-01f, -6.16627932e-02f, -2.95477863e-02f, 2.28302404e-01f,
  -2.75071949e-01f, -5.35831898e-02f, 7.96974227e-02f, -2.62565911e-01f, -1.92493781e-01f, -8.95730872e-03f, -6.59126649e-03f, 6.56347647e-02f, 1.06346533e-01f, -8.94055143e-02f,
  4.26342934e-01f, -1.83304518e-01f, 7.60873035e-02f, -4.21975106e-02f, -1.20842956e-01f, -1.54071808e-01f, -5.76542243e-02f, 1.81354731e-01f, 1.18944526e-01f, 1.72745794e-01f,
  -3.59993637e-01f, 6.31468892e-02f, 1.12731025e-01f, 1.09715857e-01f, -6.92596287e-02f, 5.16407080e-02f, 1.31726667e-01f, 5.96084967e-02f, 1.00353412e-01f, 1.94927201e-01f,
  7.89054856e-02f, 1.72162876e-01f, 3.13551389e-02f, -1.23734921e-01f, 9.13964286e-02f, -6.55451864e-02f, 9.24941003e-02f, 3.61263156e-02f, 1.51878357e-01f, -7.83853829e-02f,
  -6.43472821e-02f, -1.83239385e-01f, 4.16008323e-01f, 4.83476013e-01f, -1.38716877e-01f, 1.43417761e-01f, -2.30445340e-01f, -1.95462093e-01f, 3.41377944e-01f, -7.85420649e-03f,
  9.03763026e-02f, 3.11811626e-01f, 8.15432519e-02f, 7.60945352e-03f, 7.26131499e-02f, -1.38107225e-01f, -2.81482309e-01f, -6.99069165e-03f, -8.34206641e-02f, 2.93921232e-01f,
  3.03787868e-02f, -1.51312426e-01f, 1.88551143e-01f, -5.19522615e-02f, 1.17914394e-01f, -3.86368930e-02f, 2.11443473e-03f, 5.81613667e-02f, -1.24778040e-01f, 2.85653114e-01f,
  1.68991178e-01f, -1.79607496e-01f, 1.53183326e-01f, -1.88211538e-02f, -1.04551010e-01f, 2.45560169e-01f, -1.37610584e-01f, 8.33373219e-02f, -1.16412960e-01f, -3.26823667e-02f,
  -2.22274780e-01f, 1.21489145e-01f, -1.55443847e-01f, -5.12729175e-02f, 2.06696764e-01f, 8.12188685e-02f, -1.54845864e-01f, -1.62767872e-01f, -1.00600585e-01f, -5.32614365e-02f,
  3.74975614e-02f, 4.18693805e-03f, -3.56983840e-02f, 1.29072249e-01f, 4.58049029e-02f, -1.74379200e-02f, 8.70024934e-02f, 8.37840736e-02f, 6.71766251e-02f, -7.82917365e-02f,
  1.27191409e-01f, 1.35178626e-01f, 5.59696220e-02f, -4.24241945e-02f, -6.33972213e-02f, -4.98403832e-02f, -4.89823297e-02f, -1.65575196e-03f, -2.67240796e-02f, -1.07626803e-01f,
  5.93895763e-02f, 2.14328617e-02f, -3.84209305e-02f, 1.44828968e-02f, 1.84094787e-01f, 1.97423100e-01f, -1.22334383e-01f, 1.66073497e-02f, -4.48390609e-03f, -2.74118304e-01f,
  -2.05062911e-01f, -8.49768799e-03f, -1.06600761e-01f, 7.17374757e-02f, 6.49741814e-02f, -7.11793005e-02f, 1.67240411e-01f, -2.00809941e-01f, 1.70094073e-01f, -1.21153571e-01f,
  -1.25186011e-01f, -1.15927518e-03f, 3.01521242e-01f, -3.25369626e-01f, -2.11757198e-01f, -2.82027334e-01f, 3.02085727e-02f, 9.78973731e-02f, -3.33138883e-01f, 1.12050265e-01f,
  -7.52980262e-02f, -3.54162008e-01f, 1.11210674e-01f, 1.10204257e-01f, 2.37758067e-02f, 1.36255145e-01f, 5.83485775e-02f, -1.12739265e-01f, 1.53714001e-01f, 1.06553964e-01f,
  6.25533238e-02f, -1.39418587e-01f, -6.49972484e-02f, 4.95895371e-02f, 5.54073825e-02f, 1.28922194e-01f, 7.08656460e-02f, 2.49656998e-02f, 1.58070982e-01f, 2.65284747e-01f,
  1.83485061e-01f, 7.96568766e-02f, 1.00280754e-01f, 1.10371701e-01f, 1.06359823e-02f, 1.36412188e-01f, -2.42175609e-01f, 4.07276601e-02f, -3.91906910e-02f, 1.37336150e-01f,
  -2.46509507e-01f, -4.11834657e-01f, -6.09616451e-02f, -8.38020351e-03f, -6.59593269e-02f, 2.20821992e-01f, -1.24129646e-01f, 1.73126191e-01f, 1.16602518e-01f, -2.57117033e-01f,
  8.36711898e-02f, -2.55154688e-02f, 2.93116886e-02f, 3.03751886e-01f, 1.91437826e-01f, 1.03576332e-01f, 8.77591521e-02f, -3.12369466e-01f, -1.89926609e-01f, -6.34324923e-02f,
  -1.26186579e-01f, 1.11607946e-01f, -2.73334891e-01f, 7.70426914e-02f, -1.44116372e-01f, 1.22295186e-01f, -6.98064396e-04f, -2.79899146e-02f, -5.24560325e-02f, 1.25556409e-01f,
  -9.25694965e-03f, -2.48739615e-01f, 2.33896479e-01f, -2.71798521e-01f, 1.67271838e-01f, -1.26487255e-01f, 2.09192380e-01f, 9.74668097e-03f, 9.37254280e-02f, 8.71204212e-02f,
  1.70138225e-01f, 1.61545202e-01f, 9.39021353e-03f, 2.15506002e-01f, 8.00715759e-02f, 5.24789803e-02f, 7.29751736e-02f, -1.76914539e-02f, -1.27634421e-01f, -2.49768458e-02f,
  8.36282000e-02f, -1.28390372e-01f, -2.04099379e-02f, 1.78691298e-02f, 7.37864897e-02f, -3.46279442e-02f, 6.60414472e-02f, -1.85654033e-02f, 5.62421829e-02f, 3.28067355e-02f,
  1.12834327e-01f, -9.75435823e-02f, 1.77493259e-01f, -1.33014858e-01f, 3.75565072e-03f, 3.04562181e-01f, 5.43410704e-02f, -1.13359623e-01f, -4.64047827e-02f, -1.39260098e-01f,
  -2.16334954e-01f, 1.04650572e-01f, -5.74788377e-02f, 2.65174180e-01f, -1.79916378e-02f, 2.14743502e-02f, 9.46225747e-02f, -1.00501709e-01f, 8.63099545e-02f, 1.75045237e-01f,
  6.15954250e-02f, -1.75740477e-02f, -2.61771023e-01f, -6.56098723e-02f, -9.53924209e-02f, 3.15186322e-01f, -2.52744824e-01f, 7.10842460e-02f, 1.69396311e-01f, -1.81157187e-01f,
  -1.92625105e-01f, -1.17790900e-01f, 1.79028716e-02f, -8.56278315e-02f, 2.17635389e-02f, 1.71283826e-01f, 3.32873225e-01f, 1.09432578e-01f, -1.30319893e-01f, -4.19422425e-03f,
  -1.45574942e-01f, -5.57053387e-02f, -2.56122947e-01f, -1.71320345e-02f, 1.21481851e-01f, 1.56063050e-01f, -4.43685383e-01f, 1.35438755e-01f, 2.11788699e-01f, 2.85589516e-01f,
  -4.30687778e-02f, 2.67907679e-01f, -1.00133352e-01f, -1.84990272e-01f, -6.11248910e-02f, -4.15520966e-02f, 3.05558252e-03f, -1.15245186e-01f, -1.78504199e-01f, 7.53010213e-02f,
  -6.62159994e-02f, 9.47219878e-02f, 8.09904635e-02f, 1.59051165e-01f, 9.03073475e-02f, -1.37093039e-02f, -1.19522303e-01f, -1.77647859e-01f, -1.04470313e-01f, 2.04384118e-01f,
  3.05635426e-02f, -2.05387846e-01f, 1.24618568e-01f, 1.55768529e-01f, 3.24156135e-02f, 2.21703753e-01f, 2.93548942e-01f, 1.07382193e-01f, -4.07713689e-02f, 1.38787776e-01f,
  1.49027750e-01f, -3.29919495e-02f, -1.03368416e-01f, 1.60830710e-02f, 1.76837206e-01f, 8.38699862e-02f, 4.78171557e-02f, -2.80051440e-01f, 2.24372953e-01f, -1.34897605e-01f,
  1.47392064e-01f, -8.68392959e-02f, -7.68333897e-02f, -9.84450281e-02f, 9.85199437e-02f, -9.81931388e-02f, 3.62580232e-02f, -2.07622290e-01f, -8.20893347e-02f, 3.21386233e-02f,
  2.71474328e-02f, -2.35098153e-01f, -5.54492325e-02f, -8.61804411e-02f, -1.54632613e-01f, 6.03819303e-02f, -7.84144178e-02f, 1.95700303e-01f, 1.47155911e-01f, 1.76675785e-02f,
  -1.10554211e-01f, 1.50143117e-01f, -3.19717592e-03f, 1.02210194e-01f, -6.86238334e-02f, -1.78161547e-01f, 1.52306691e-01f, 1.05096325e-01f, 9.72456113e-02f, -9.90849361e-02f,
  1.35585889e-02f, 1.61417574e-01f, -2.09447667e-02f, 4.51679043e-02f, 1.83226183e-01f, 9.68861431e-02f, 1.92753211e-01f, -1.05185449e-01f, -9.58271697e-02f, -8.56743678e-02f,
  1.51332058e-02f, 1.36436239e-01f, -1.96835352e-03f, 1.87923029e-01f, 1.45177450e-02f, -1.36260867e-01f, 2.81951666e-01f, -7.74311796e-02f, -1.36829510e-01f, 5.52524030e-02f,
  1.54802084e-01f, -6.83955103e-03f, -2.50518620e-01f, 1.84195526e-02f, 2.18706384e-01f, 3.02818775e-01f, 1.46390110e-01f, 1.26555637e-01f, 1.15883388e-01f, -1.84227014e-03f,
  4.98796552e-02f, -4.58664559e-02f, 2.28042640e-02f, 2.70336151e-01f, 6.62086904e-02f, -1.39738768e-01f, -1.47676989e-01f, -2.14404598e-01f, -1.85595170e-01f, -1.31038040e-01f,
  7.03934655e-02f, -2.35420227e-01f, 6.05181511e-03f, -1.21436812e-01f, 2.48026609e-01f, -1.37861878e-01f, 4.18853126e-02f, 6.58014640e-02f, -7.08188415e-02f, 9.24651697e-02f,
  3.00952941e-02f, 1.12410579e-02f, 1.85064133e-02f, 2.74910331e-01f, -3.14953297e-01f, 1.81269690e-01f, 2.87798997e-02f, 1.42322987e-01f, -1.36452243e-01f, 2.47943729e-01f,
  1.74251094e-01f, -1.09790042e-02f, 8.48601609e-02f, 2.78299600e-01f, 5.25682084e-02f, -9.63109285e-02f, -1.08820172e-02f, 4.04439643e-02f, 5.93900494e-03f, 8.32790509e-03f,
  -8.03077072e-02f, 1.24487698e-01f, 8.06238055e-02f, -1.52678326e-01f, -1.28466070e-01f, -1.90270945e-01f, -1.30150365e-02f, 1.51351526e-01f, -4.00487781e-02f, -3.72767709e-02f,
  1.85754508e-01f, 7.31445337e-03f, 2.80206889e-01f, -8.13169107e-02f, -4.76671197e-03f, 5.35240024e-02f, -2.96809580e-02f, -1.06502384e-01f, -1.53547391e-01f, -2.08833709e-01f,
  -1.61226913e-01f, 1.77565981e-02f, -3.39650246e-03f, 1.39357120e-01f, 3.07199478e-01f, -4.03202176e-01f, -1.15585851e-03f, -1.28918111e-01f, 9.20929164e-02f, -2.23077223e-01f,
  -2.55283386e-01f, 2.74553657e-01f, 1.82562858e-01f, -7.00254664e-02f, -7.10724965e-02f, -2.49856189e-01f, 2.97147095e-01f, 6.12894334e-02f, -2.61707246e-01f, 7.66523927e-02f,
  8.51727948e-02f, -3.97017337e-02f, 3.62600461e-02f, 3.58155847e-01f, 1.99236676e-01f, 9.87965688e-02f, 7.09640905e-02f, 4.77471128e-02f, 1.96908474e-01f, 9.61181615e-03f,
  1.11865386e-01f, -1.00478597e-01f, -1.41717970e-01f, -2.38049746e-01f, 2.24886894e-01f, 2.39040330e-02f, 1.31732494e-01f, 1.79237068e-01f, -2.49017472e-03f, 4.06745635e-02f,
  1.83093384e-01f, 3.76507826e-03f, 1.22662321e-01f, 1.39972776e-01f, 2.16597438e-01f, 6.70360699e-02f, -1.90381147e-02f, 3.84209529e-02f, -1.92803770e-01f, -2.66316682e-01f,
  -1.28011316e-01f, -8.95552933e-02f, -1.13801854e-02f, 8.39556605e-02f, 6.98298588e-02f, -1.41952291e-01f, 3.85803789e-01f, -2.47424003e-02f, -3.15099746e-01f, -2.43622214e-01f,
  1.16476156e-01f, -4.18058150e-02f, -3.15768458e-02f, -1.87080130e-01f, -1.92801893e-01f, 1.83304965e-01f, -1.25986442e-01f, -4.37009148e-02f, -1.60340980e-01f, 1.47412926e-01f,
  -4.28042442e-01f, -1.49200298e-02f, -1.75660372e-01f, 1.94654018e-01f, -1.59549087e-01f, 2.35238865e-01f, 1.21685170e-01f, 4.64865454e-02f, -1.67954266e-02f, 2.35402897e-01f,
  -8.37026760e-02f, -1.33745730e-01f, -3.59310240e-01f, 1.17113374e-01f, -6.37590066e-02f, -4.35734019e-02f, 1.84980333e-01f, 1.02422886e-01f, 1.62014887e-01f, -1.38868108e-01f,
  -4.42237668e-02f, -1.54949442e-01f, 3.90194714e-01f, -1.52949933e-02f, 1.45206437e-01f, 8.94847512e-02f, 7.26183802e-02f, -1.13669887e-01f, 1.40350088e-01f, 1.34876028e-01f,
  9.22729820e-02f, -9.76790413e-02f, 9.62647889e-03f, 3.06210015e-02f, 1.87516287e-01f, 9.38207284e-03f, 1.19697846e-01f, 1.51900411e-01f, 9.90609974e-02f, 1.69101655e-02f,
  1.22309074e-01f, -8.18880424e-02f, 1.82759479e-01f, 1.83385778e-02f, 1.73668891e-01f, 9.36404690e-02f, 4.73979451e-02f, -1.79888576e-01f, 1.44345775e-01f, -1.06507264e-01f,
  -2.69779861e-01f, 2.27735415e-02f, -7.49406666e-02f, -4.25767936e-02f, 4.68365960e-02f, 3.10110539e-01f, -2.48125479e-01f, 3.35566700e-02f, -2.92592674e-01f, 2.36888006e-02f,
  7.87395835e-02f, -2.11513281e-01f, -1.77004766e-02f, 1.29491657e-01f, 2.98157692e-01f, -3.21286857e-01f, 3.90473515e-01f, -4.57281955e-02f, -1.09464690e-01f, -2.05075756e-01f,
  -1.54287055e-01f, -2.90595651e-01f, -1.14682265e-01f, -1.54968351e-01f, -1.25280485e-01f, 3.94933701e-01f, 1.68359071e-01f, -3.66286114e-02f, -1.72180206e-01f, -2.26908684e-01f,
  1.05746970e-01f, -1.88425966e-02f, 8.48447755e-02f, 8.36456474e-03f, 3.03943716e-02f, 1.23722255e-01f, -7.27986515e-01f, -2.46401608e-01f, -2.09307700e-01f, 1.55519862e-02f,
  1.01520479e-01f, 2.73075581e-01f, 1.23193420e-01f, 7.21497461e-02f, 7.42622092e-03f, 3.44657823e-02f, 1.78895965e-01f, 1.49166226e-01f, 1.59832895e-01f, 2.14098394e-01f,
  -5.93868643e-02f, 1.16174929e-01f, 5.07707149e-02f, -7.57688060e-02f, -1.37745738e-01f, 1.90108776e-01f, -4.75719124e-02f, 9.26042274e-02f, -1.83314815e-01f, -2.03253776e-01f,
  -7.97818322e-03f, -8.60515088e-02f, -1.53703302e-01f, 1.49945617e-01f, -2.75778770e-01f, 3.74640860e-02f, -1.61678359e-01f, -3.79568040e-01f, 2.86324441e-01f, 7.91106746e-02f,
  1.54832006e-02f, 1.08793311e-01f, 2.14041978e-01f, -1.16512366e-01f, -2.50092536e-01f, -4.08450335e-01f, -1.28529683e-01f, 1.67576745e-01f, -4.92548235e-02f, -4.13669385e-02f,
  -1.13139069e-02f, -5.01030609e-02f, 1.01978183e-01f, 8.02107528e-02f, 1.87958539e-01f, 3.63230035e-02f, 1.13528714e-01f, 1.52529687e-01f, -2.02874303e-01f, -1.63345486e-01f,
  3.68131772e-02f, -1.00454018e-01f, 1.23372778e-01f, -4.13286053e-02f, 1.90199930e-02f, -4.20804113e-01f, -6.48280531e-02f, -2.46235237e-01f, -4.76355106e-02f, -1.09557800e-01f,
  -3.96672031e-03f, -3.89636867e-02f, -6.26170933e-02f, 2.00582847e-01f, 3.71527411e-02f, 1.09764203e-01f, 2.11519331e-01f, -3.89212631e-02f, 1.54430762e-01f, -6.19683089e-03f,
  1.16350807e-01f, 3.17933112e-01f, 3.30347046e-02f, 2.39057049e-01f, -5.60536496e-02f, 3.67022157e-02f, 9.92221013e-02f, 2.51659956e-02f, -6.99156523e-02f, 2.84094900e-01f,
  2.15387702e-01f, -8.01009536e-02f, -1.06007144e-01f, -4.93481129e-01f, 9.32191778e-03f, 2.18999445e-01f, -8.42476338e-02f, 2.43827596e-01f, -1.54416859e-01f, 7.01843053e-02f,
  -2.48470128e-01f, -1.90414846e-01f, 3.86661947e-01f, -2.49993712e-01f, -6.30929787e-03f, -9.24317911e-03f, 1.33699253e-01f, -3.94388661e-02f, -2.12794930e-01f, -3.46997321e-01f,
  5.68921454e-02f, 5.05247749e-02f, -9.07320529e-02f, -2.67894119e-01f, 1.08696915e-01f, 8.63366872e-02f, 7.47042336e-03f, 1.29966989e-01f, 1.15676112e-01f, 4.37067775e-03f,
  1.55689018e-02f, 2.66612500e-01f, -2.54843891e-01f, -2.55602688e-01f, -2.03741770e-02f, -1.13828201e-02f, 2.20560715e-01f, 3.99642531e-03f, 2.42236238e-02f, -4.36840326e-01f,
  -5.05044498e-02f, -2.47968167e-01f, -2.04501659e-01f, -1.58660859e-01f, 3.68895531e-02f, 8.30137134e-02f, -1.07108302e-01f, 1.08826064e-01f, -3.37358952e-01f, -1.19129755e-01f,
  8.85214433e-02f, -5.92121109e-02f, 1.45411685e-01f, 7.39237070e-02f, -6.13990426e-02f, -4.49592061e-02f, -1.27454653e-01f, 6.74858615e-02f, -1.15827754e-01f, 8.44349563e-02f,
  -1.66841790e-01f, -8.64148811e-02f, 1.04841776e-01f, -3.24563533e-02f, 5.46505302e-02f, 2.66930796e-02f, -1.01367474e-01f, -4.24031615e-02f, 2.06632651e-02f, -6.15952946e-02f,
  2.62510646e-02f, 1.52889651e-03f, -1.27972692e-01f, -1.29418567e-01f, -1.34494960e-01f, -1.78173631e-02f, 1.35597080e-01f, 2.78095026e-02f, -6.03214726e-02f, -1.63312390e-01f,
  2.77010322e-01f, 1.23921864e-01f, -1.04304694e-01f, 1.31062269e-01f, -9.19063687e-02f, 2.10035026e-01f, -1.45558402e-01f, 2.30589345e-01f, -6.93206042e-02f, 1.66976213e-01f,
  2.01900333e-01f, -1.18708536e-01f, -1.43797219e-01f, 7.49403611e-02f, -3.78031693e-02f, 4.09518592e-02f, -3.49236280e-02f, -3.73140648e-02f, 1.18175164e-01f, 5.18132634e-02f,
  -1.77393675e-01f, 2.61886328e-01f, -1.21949024e-01f, 2.67249271e-02f, -1.50830448e-01f, 1.06854513e-02f, 5.88108003e-02f, 3.56491894e-01f, -1.54934242e-01f, -3.20608854e-01f,
  1.38949066e-01f, 1.80111993e-02f, 4.31315899e-02f, 2.39586323e-01f, 1.24021083e-01f, 1.95355922e-01f, 2.40167513e-01f, 2.68810671e-02f, 1.74425796e-01f, 5.40422946e-02f,
  1.14732116e-01f, 6.47241483e-03f, 5.94298840e-02f, 1.23718502e-02f, 7.36779347e-02f, -8.06825906e-02f, 8.42227340e-02f, -1.80653706e-01f, -6.80176392e-02f, -1.10932834e-01f,
  9.08147246e-02f, 3.18379730e-01f, -1.23452842e-01f, 1.62776392e-02f, -1.34721160e-01f, -2.60821600e-02f, 1.54682428e-01f, -2.17019729e-02f, 1.40511587e-01f, 2.25148827e-01f,
  -2.16964126e-01f, -2.61115432e-01f, 1.97872475e-01f, -5.83290122e-02f, 2.76447743e-01f, 1.12863384e-01f, -1.26613691e-01f, 2.21800074e-01f, 6.55896077e-03f, 1.48952872e-01f,
  -1.15653910e-01f, 1.95280820e-01f, -8.53931829e-02f, 2.00113982e-01f, 7.13521540e-02f, -1.92785189e-01f, -5.99930063e-02f, 2.89784908e-01f, 1.97203577e-01f, -1.52478188e-01f,
  4.72409837e-02f, -3.00708830e-01f, 1.04527958e-01f, 1.03443846e-01f, -1.06825307e-01f, 2.35115096e-01f, -1.57848522e-01f, 5.35278320e-02f, -1.30151838e-01f, 5.56418002e-02f,
  6.01321496e-02f, 1.20876461e-01f, 1.34793386e-01f, -1.02873512e-01f, -3.48978676e-03f, -2.07308963e-01f, -3.67989540e-02f, 1.47974566e-01f, 8.39489996e-02f, 1.77590236e-01f,
  8.52398761e-03f, 1.24346882e-01f, -7.80283511e-02f, -5.50275622e-03f, 3.73503380e-02f, -7.63991699e-02f, -3.47105451e-02f, 3.48209329e-02f, 1.19916886e-01f, 1.56173095e-01f,
  4.14073728e-02f, -1.16158910e-01f, -3.20037276e-01f, -1.95694372e-01f, 6.87739179e-02f, -3.77863436e-03f, -8.86672214e-02f, -1.70817837e-01f, 2.84429163e-01f, -4.29185703e-02f,
  1.80090711e-01f, -1.90797806e-01f, 2.38527939e-01f, -1.32557556e-01f, -1.21912368e-01f, -9.19002108e-03f, -5.40968105e-02f, 5.76843414e-03f, -1.76187932e-01f, -3.42592299e-02f,
  -1.72439646e-02f, 1.62177309e-01f, 1.03502914e-01f, -2.28119045e-01f, 8.92473459e-02f, -8.83633420e-02f, 2.10166529e-01f, -3.19552533e-02f, -4.37556719e-03f, 1.93491817e-01f,
  -1.58975422e-01f, 1.35579675e-01f, 1.32978633e-01f, -6.85340986e-02f, 1.55281529e-01f, 6.70076394e-03f, -1.82079840e-02f, -9.92225632e-02f, -2.15521485e-01f, 2.20943406e-01f,
  4.43174504e-02f, 2.24307135e-01f, 2.63377547e-01f, -1.08740769e-01f, 6.71918318e-02f, 6.36135638e-02f, 3.13623697e-02f, -2.32786089e-01f, 2.33265851e-02f, -1.05703712e-01f,
  -7.01664165e-02f, 5.22649288e-02f, -5.99168986e-02f, 1.13099493e-01f, 2.51607560e-02f, 1.28085703e-01f, 9.20588672e-02f, -5.63862547e-03f, 3.35475206e-02f, 1.15576901e-01f,
  -4.71728519e-02f, 9.43617988e-03f, -7.86992982e-02f, -1.05570786e-01f, 5.20749614e-02f, 2.84431409e-02f, -1.83255851e-01f, 4.29880880e-02f, -4.33697939e-01f, -1.67946696e-01f,
  9.79903713e-02f, 4.72093336e-02f, -5.43805659e-02f, 6.27025217e-02f, 9.98609290e-02f, -9.30811837e-02f, -7.78048206e-03f, -2.95981914e-01f, 2.37526327e-01f, -1.26138225e-01f,
  3.08088750e-01f, -2.38265514e-01f, 3.13454390e-01f, -1.49286240e-01f, 4.61627208e-02f, -3.27173382e-01f, -7.80947506e-02f, 1.99179724e-01f, 3.07409726e-02f, 1.73143223e-01f,
  -1.34535104e-01f, 1.93506047e-01f, 1.83660343e-01f, -2.27221549e-01f, -1.37944028e-01f, -2.01902241e-02f, 2.10996523e-01f, 2.88950861e-01f, -9.39441472e-02f, -3.30799818e-01f,
  -1.05938114e-01f, 6.76705688e-02f, -1.80529170e-02f, 7.39531266e-03f, -1.31437242e-01f, 8.56637061e-02f, -2.15576336e-01f, 4.43278402e-02f, 7.11723929e-03f, 1.57021493e-01f,
  -4.04478274e-02f, -2.57443249e-01f, 3.43807280e-01f, 1.38731450e-01f, -2.17562895e-02f, 2.33519793e-01f, 3.90162244e-02f, 2.06111908e-01f, 2.88582146e-01f, 1.70097902e-01f,
  2.01554969e-01f, 1.97533425e-02f, 5.95143214e-02f, 1.72996581e-01f, -3.23607624e-02f, 1.49867103e-01f, 2.30602361e-02f, 1.70445055e-01f, -1.94150999e-01f, -1.59352254e-02f,
  2.34415159e-01f, 3.86119574e-01f, 1.98826432e-01f, -3.86926532e-02f, -2.60351181e-01f, 1.56888619e-01f, -2.37676382e-01f, 3.28695565e-01f, 1.09351352e-01f, -2.65589148e-01f,
  3.66487652e-01f, 2.25304410e-01f, -4.25448745e-01f, -3.01237375e-01f, -8.97101462e-02f, 3.27853471e-01f, 9.46952403e-02f, 3.79529372e-02f, 3.95859592e-02f, 8.22408795e-02f,
  2.12029919e-01f, -2.01324463e-01f, -9.26261470e-02f, -4.89747673e-02f, -4.84759994e-02f, -1.08204238e-01f, -5.35688102e-02f, 1.50462940e-01f, -8.69158730e-02f, 2.64379978e-01f,
  1.78214163e-01f, -5.10978281e-01f, 8.31827447e-02f, -1.98552012e-01f, 1.15217350e-01f, -1.31228298e-01f, 1.09154217e-01f, 4.12749320e-01f, -8.85087550e-02f, -6.87273890e-02f,
  2.23477438e-01f, 3.67967822e-02f, -1.55460104e-01f, 2.34546568e-02f, 2.10369498e-01f, 1.33479804e-01f, -1.72173902e-01f, -1.11208491e-01f, 6.09488338e-02f, 5.27764224e-02f,
  -2.64507327e-02f, -2.61708945e-02f, 8.85546505e-02f, 2.95840234e-01f, 2.77893305e-01f, 7.20655397e-02f, 2.29591042e-01f, 2.45321184e-01f, 1.11455716e-01f, -5.80288246e-02f,
  2.15291828e-01f, 8.91382843e-02f, 3.36078852e-01f, -1.46456182e-01f, 1.40048429e-01f, -3.05446833e-01f, 6.48981407e-02f, 9.41346660e-02f, -6.10211864e-02f, 1.89919919e-01f,
  4.09071445e-02f, -2.51178145e-01f, 8.33622292e-02f, -1.24594783e-02f, -3.73310447e-01f, -4.69069593e-02f, 1.52055606e-01f, 8.68107900e-02f, 4.94686253e-02f, -1.25934318e-01f,
  -1.79999396e-01f, 6.90377876e-02f, -2.04837561e-01f, -1.83514282e-01f, -2.02143848e-01f, 9.38228890e-02f, -2.24850357e-01f, -2.28149056e-01f, -3.48390862e-02f, 1.05978012e-01f,
  1.75783172e-01f, 2.37573609e-01f, 2.72115856e-01f, 1.21481575e-01f, -6.26466945e-02f, 2.14230642e-01f, 4.57288735e-02f, 5.85673861e-02f, -3.13437968e-01f, 2.42380157e-01f,
  -1.08596653e-01f, -1.05506763e-01f, 4.16675471e-02f, -3.64346430e-02f, -2.74509668e-01f, -9.00708660e-02f, -2.72601210e-02f, -2.41522610e-01f, 4.30333704e-01f, 4.56331158e-03f,
  -8.74245837e-02f, -3.00698020e-02f, -2.28241265e-01f, 1.92104355e-02f, 1.36568174e-01f, 3.36606726e-02f, -2.07281224e-02f, 1.02130122e-01f, 1.04662128e-01f, 5.05012944e-02f,
  8.50250050e-02f, 1.60789005e-02f, 6.55660406e-02f, 5.74353822e-02f, 3.30259427e-02f, 4.92346995e-02f, 9.42414030e-02f, -2.25035056e-01f, -1.56150162e-01f, -1.97499692e-01f,
  3.24766189e-02f, 5.38689904e-02f, -1.02484666e-01f, -1.01412602e-01f, 2.84729958e-01f, -2.76015438e-02f, 2.04712555e-01f, -3.89867686e-02f, 9.16319191e-02f, -3.53392512e-01f,
  -5.56269176e-02f, -4.44560254e-04f, -5.73142432e-02f, -4.36963886e-02f, -1.59197733e-01f, 7.84798115e-02f, 6.90194443e-02f, -1.01297177e-01f, 7.55807161e-02f, -1.61331862e-01f,
  1.80901632e-01f, -6.74221590e-02f, 2.05468923e-01f, -8.46649334e-02f, -1.50206247e-02f, 1.01367608e-01f, -1.54093076e-02f, -1.64075226e-01f, -1.37327209e-01f, -1.26803935e-01f,
  -5.99054545e-02f, 9.94002074e-03f, -6.64100647e-02f, 2.07620203e-01f, -1.97531551e-01f, -2.30762750e-01f, -4.74387966e-02f, 1.03992052e-01f, 2.56202012e-01f, 1.24532059e-01f,
  1.75223798e-02f, -1.65175796e-02f, 2.24006489e-01f, -2.22126290e-01f, -1.56686883e-02f, -4.57091853e-02f, 1.36876613e-01f, 6.36455044e-02f, -4.23074327e-02f, 9.87590849e-02f,
  1.19795755e-01f, 1.93562657e-01f, 4.55058776e-02f, 7.03530610e-02f, 4.90924269e-02f, -1.64261945e-02f, 2.42094807e-02f, 1.88482314e-01f, 4.23253775e-02f, 1.22324318e-01f,
  -2.26128544e-03f, 1.45824835e-01f, 7.58831054e-02f, 2.01361716e-01f, -9.11599845e-02f, -2.49249727e-01f, 2.45509688e-02f, 1.81056820e-02f, 1.19102430e-02f, 1.04796320e-01f,
  -1.43845484e-01f, -2.83927649e-01f, 1.05858237e-01f, 7.65409507e-03f, 4.26608734e-02f, 1.42114177e-01f, 1.01054147e-01f, 2.06564277e-01f, 1.45200446e-01f, -1.22882321e-01f,
  1.20029584e-01f, -2.15185583e-01f, -3.01988631e-01f, -2.05044486e-02f, -6.50408268e-02f, 2.05843374e-01f, 4.48743161e-03f, -6.06600288e-03f, -1.46638658e-02f, -5.37611321e-02f,
  -2.13661566e-01f, 4.86496948e-02f, 8.59813914e-02f, -1.15031712e-01f, -8.10861439e-02f, -1.38923619e-02f, 2.98636347e-01f, -1.75495461e-01f, 1.16770431e-01f, -1.05051056e-03f,
  -3.04330230e-01f, -1.97133005e-01f, -1.43362671e-01f, -3.99761535e-02f, 1.03788018e-01f, 3.36773574e-01f, -3.09902411e-02f, 2.64657997e-02f, 1.19050324e-01f, -2.18549445e-01f,
  -1.21622540e-01f, 1.39821768e-01f, -2.58682482e-03f, 6.37550056e-02f, 1.52190417e-01f, 2.14380980e-01f, -1.07880898e-01f, -1.14318557e-01f, 1.24832526e-01f, 4.85852733e-03f,
  -4.04139794e-02f, 2.31771283e-02f, 2.93939374e-02f, -9.20769665e-03f, 1.16726898e-01f, -6.20175749e-02f, -6.25519529e-02f, -1.04075015e-01f, 1.39689237e-01f, 2.46654868e-01f,
  -7.89553672e-02f, -1.17386959e-01f, 5.07087307e-03f, -1.00043193e-01f, -5.08813523e-02f, -1.59406230e-01f, -2.04971507e-01f, 1.83025882e-01f, 4.60414886e-02f, -2.27183644e-02f,
  -7.35340938e-02f, 1.73200339e-01f, -4.84744422e-02f, -5.76966302e-03f, -9.90851149e-02f, 2.16987789e-01f, -6.99578151e-02f, 1.45886436e-01f, 5.36918081e-02f, -5.36873005e-02f,
  1.89771220e-01f, -2.90097129e-02f, -2.08737910e-01f, 2.71923870e-01f, 8.05597156e-02f, 1.27797768e-01f, -1.40476197e-01f, -1.60559997e-01f, 9.52360481e-02f, 1.26659781e-01f,
  7.22038597e-02f, 6.46229535e-02f, -1.23986401e-01f, -1.00330627e-02f, 1.48894221e-01f, 1.75006866e-01f, -1.59066394e-01f, 7.05119520e-02f, -1.43543497e-01f, -2.31160164e-01f,
  3.15838188e-01f, -6.42637983e-02f, -1.09270297e-01f, -1.81198403e-01f, -1.36308044e-01f, 2.05772761e-02f, 6.61296323e-02f, -4.59521823e-02f, 1.91969834e-02f, 2.52392083e-01f,
  1.30647451e-01f, 6.38638437e-02f, -1.29272863e-01f, 1.27160504e-01f, 1.70332119e-02f, 1.18786842e-01f, -4.25931104e-02f, 1.51437074e-01f, -4.03720625e-02f, 2.00290307e-01f,
  3.08113359e-02f, -1.09674007e-01f, -1.62279263e-01f, -2.20363081e-01f, -3.19189765e-02f, 1.05638124e-01f, -1.94966704e-01f, 7.82204866e-02f, 1.46949634e-01f, 1.06556989e-01f,
  2.45071389e-02f, -5.02049588e-02f, 1.99442461e-01f, 7.81535916e-03f, 6.76749051e-02f, -6.08842261e-02f, -1.52009785e-01f, 1.13662489e-01f, 2.95926947e-02f, -1.58869289e-02f,
  -1.87564090e-01f, -2.76272092e-02f, 4.00109515e-02f, -1.11732641e-02f, 3.43574001e-03f, 4.32046130e-02f, 1.40518695e-01f, -6.54071048e-02f, 1.37029678e-01f, -9.22665745e-02f,
  -8.88842158e-03f, 1.35869861e-01f, -4.80336063e-02f, -1.14485703e-01f, -5.79279363e-02f, -1.14850327e-01f, 2.14134187e-01f, -2.02635899e-02f, -3.46026458e-02f, -2.53252517e-02f,
  -1.98666230e-01f, 8.66663530e-02f, -3.58146131e-02f, -6.24732152e-02f, -6.62724301e-02f, 2.48679772e-01f, 6.78287446e-02f, 1.14865869e-01f, -2.84433495e-02f, -1.31590500e-01f,
  -6.11050241e-03f, 1.34872392e-01f, 2.30250686e-01f, -1.59954593e-01f, -1.55669689e-01f, 1.36429578e-01f, -3.21782753e-02f, 1.21927842e-01f, 2.82201827e-01f, 5.75836003e-02f,
  1.24738596e-01f, -1.65163036e-02f, -1.81568533e-01f, -1.68001711e-01f, -9.87647101e-02f, 4.23666947e-02f, 8.52144063e-02f, 1.82001531e-01f, 1.29693756e-02f, -1.33274928e-01f,
  4.15903956e-01f, -3.97252515e-02f, -1.18463151e-01f, -1.06884144e-01f, 3.94677259e-02f, -7.01077282e-02f, -2.73627937e-01f, -1.23374397e-02f, 9.98400673e-02f, 2.53410190e-01f,
  1.17127605e-01f, 3.33558358e-02f, 1.84962880e-02f, -1.65736064e-01f, 6.32715449e-02f, -1.61543101e-01f, -8.52982998e-02f, 2.92416513e-01f, -6.48101121e-02f, -1.96975291e-01f,
  -1.95642516e-01f, -5.75944483e-02f, -1.09954603e-01f, -1.52051881e-01f, -9.13583487e-02f, -2.37314507e-01f, -3.93686969e-05f, -1.12326957e-01f, 2.45839462e-01f, -7.00934231e-02f,
  -7.91856572e-02f, 4.75034155e-02f, 1.11731730e-01f, 3.04236710e-01f, 8.81429985e-02f, 1.02782853e-01f, -1.06851891e-01f, 2.25114226e-01f, -3.46697830e-02f, 1.93794772e-01f,
  2.44981408e-01f, 1.42246589e-01f, -6.80484399e-02f, -1.35292243e-02f, 8.45401436e-02f, 5.67891262e-02f, 1.30208194e-01f, 5.20681776e-02f, 6.09447286e-02f, 1.04829324e-02f,
  1.25934184e-01f, 9.59069058e-02f, -1.19979037e-02f, 8.33852515e-02f, 1.21126376e-01f, 2.13590279e-01f, 8.48732516e-02f, -2.13627711e-01f, -3.54174338e-02f, -1.87432125e-01f,
  1.35302380e-01f, -4.85604804e-04f, -4.31231372e-02f, 8.47521126e-02f, 1.31542340e-01f, -1.93104669e-01f, 3.81146669e-01f, 3.90872583e-02f, -2.88031161e-01f, 1.16412006e-02f,
  4.35604155e-02f, 6.17782325e-02f, -2.80381680e-01f, -2.14466453e-01f, -5.76651573e-01f, 2.06914395e-01f, -1.68924257e-01f, 1.48485243e-01f, 9.73356329e-03f, -1.49678767e-01f,
  -8.02665483e-03f, -1.68308303e-01f, 2.23244742e-01f, -1.36117920e-01f, -2.07441092e-01f, 3.05873930e-01f, 1.29456669e-01f, -1.62700400e-01f, -2.15603977e-01f, -1.54525191e-01f,
  1.75595339e-02f, -8.94380175e-03f, -1.00966282e-01f, 3.25290322e-01f, 2.18791217e-02f, -1.37727167e-02f, 2.41798803e-01f, 1.23734921e-01f, -7.93760940e-02f, 6.96109384e-02f,
  -1.10945262e-01f, 5.67936786e-02f, 3.90046716e-01f, 8.83315429e-02f, 1.39729846e-02f, -1.04598805e-01f, -8.47769231e-02f, -8.08352157e-02f, 1.71353012e-01f, -5.56265488e-02f,
  1.21961378e-01f, 1.20191358e-01f, 2.04897568e-01f, 7.97880962e-02f, 2.29700049e-03f, 1.48913175e-01f, 7.53510892e-02f, 1.85888112e-01f, 1.00244515e-01f, 1.91120058e-01f,
  -8.20121840e-02f, 1.18926048e-01f, -1.07067265e-01f, 6.24422580e-02f, -3.65949869e-01f, -2.63805509e-01f, 1.07642703e-01f, -7.10628703e-02f, 7.90286660e-02f, -1.30958393e-01f,
  1.54243872e-01f, -1.36557028e-01f, -1.17139310e-01f, -3.47359329e-01f, 1.95626039e-02f, -1.75904468e-01f, 2.22057924e-01f, -1.58713117e-01f, 1.72936484e-01f, -7.13496953e-02f,
  5.02937473e-02f, -2.11380526e-01f, -4.32187952e-02f, -1.64428540e-02f, -4.95416448e-02f, 2.71008730e-01f, -2.34214902e-01f, -2.74384506e-02f, -4.67745177e-02f, 8.17545280e-02f,
  1.20795570e-01f, 2.46435851e-02f, 1.39500484e-01f, 3.85743320e-01f, 1.06835574e-01f, -1.57400563e-01f, -1.56203359e-01f, 4.72585708e-02f, -1.62926152e-01f, 9.58924647e-03f,
  9.76298824e-02f, 2.87916899e-01f, -9.67609212e-02f, -1.46402314e-01f, -1.61278740e-01f, 8.80359784e-02f, -9.35760420e-03f, 9.63856801e-02f, 1.02629088e-01f, 1.33040011e-01f,
  -6.33404702e-02f, -8.08962286e-02f, -8.74936767e-03f, 1.62993044e-01f, 5.67386206e-03f, 5.22373617e-02f, 2.11732555e-02f, 1.91614762e-01f, 3.11869532e-02f, -9.19599086e-02f,
  -9.18936655e-02f, 9.71525982e-02f, 1.11005493e-01f, -1.42585635e-02f, -7.95922279e-02f, -1.77936256e-03f, -3.84704843e-02f, -1.54964507e-01f, 4.36160207e-01f, 1.82742909e-01f,
  1.64830163e-01f, 6.99947327e-02f, 2.08552808e-01f, 1.44539122e-02f, 1.98051497e-01f, -1.00964114e-01f, 2.26345882e-02f, 1.60312876e-01f, -2.40067746e-02f, 7.13498294e-02f,
  -1.66950189e-02f, -1.27480522e-01f, -1.09206261e-02f, -1.11443184e-01f, -1.60012141e-01f, 2.49567881e-01f, 6.58888444e-02f, -3.09956279e-02f, 3.05191316e-02f, -2.23014191e-01f,
  1.58944756e-01f, -5.22394218e-02f, 1.72225256e-02f, -7.39969686e-02f, -3.70876580e-01f, 3.24766278e-01f, 1.99999753e-02f, -1.16341375e-01f, -1.16529845e-01f, 1.66518584e-01f,
  2.73989178e-02f, 2.22771969e-02f, -1.70128152e-01f, 7.74256140e-02f, -2.95589507e-01f, -8.55009109e-02f, 1.15667777e-02f, -2.18805578e-02f, -4.53855433e-02f, -4.63902317e-02f,
  6.96875900e-02f, -1.22699551e-01f, -1.81155369e-01f, -2.71467846e-02f, -1.18906610e-01f, 1.31846607e-01f, 2.94564478e-02f, 5.33271395e-02f, 1.67929545e-01f, -5.92935346e-02f,
  -3.41070928e-02f, 1.81088507e-01f, -8.05247501e-02f, -2.17365660e-02f, 2.23077297e-01f, 1.25091508e-01f, 9.83383656e-02f, 1.56122103e-01f, -3.16094980e-02f, -6.59720153e-02f,
  5.51015995e-02f, -2.60952741e-01f, -3.52038965e-02f, 1.86399102e-01f, 2.31015645e-02f, 1.21417850e-01f, 1.49420202e-01f, -5.85918687e-02f, 1.56573892e-01f, 3.25419009e-01f,
  -1.37690037e-01f, -8.24786723e-02f, 1.85681537e-01f, -1.93015113e-01f, 1.90276295e-01f, -5.24594449e-02f, -3.32548141e-01f, 2.29675859e-01f, 8.44532531e-03f, -4.55868766e-02f,
  3.00589483e-02f, -1.11899167e-01f, -6.98598847e-02f, 2.64761299e-01f, -2.38271683e-01f, -1.30013853e-01f, -1.75875530e-01f, 2.81188507e-02f, 1.00143582e-01f, -1.69639334e-01f,
  -9.69650298e-02f, 1.09103136e-01f, -2.86928564e-02f, -4.69922367e-03f, 1.60685226e-01f, 1.49079323e-01f, 1.26291931e-01f, -2.21963346e-01f, 1.51751101e-01f, 1.35509759e-01f,
  -2.04141680e-02f, -4.54839803e-02f, -2.46926993e-02f, -2.08865944e-02f, 3.49720903e-02f, 6.20042868e-02f, 1.65395603e-01f, 2.70602882e-01f, -3.31579261e-02f, -3.34784359e-01f,
  -5.42159788e-02f, -4.31830920e-02f, -6.15351368e-03f, 1.20490221e-02f, 6.13389164e-02f, -8.17733482e-02f, -1.18027896e-01f, -9.06329304e-02f, -1.09203719e-01f, -9.33191851e-02f,
  -7.40299746e-02f, -7.21132755e-02f, 1.12266615e-01f, -6.55358583e-02f, -2.94060297e-02f, -7.81499594e-02f, 1.49944112e-01f, 1.04935057e-01f, -2.35130936e-01f, 1.48279414e-01f,
  -2.64533699e-01f, 7.66051486e-02f, 1.00571495e-02f, 6.09770864e-02f, 2.07204685e-01f, 3.01050514e-01f, -1.20133407e-01f, 1.50549151e-02f, 1.51490405e-01f, -1.84661731e-01f,
  1.25250578e-01f, 1.20727152e-01f, 4.83682938e-02f, 3.12689692e-01f, 9.70068946e-02f, -9.78595205e-03f, 1.12152770e-01f, -4.14938256e-02f, -7.49672530e-03f, -2.63463892e-02f,
  2.02325165e-01f, 2.49352138e-02f, 1.37220502e-01f, 3.61934006e-01f, 1.61119431e-01f, -2.50908196e-01f, -3.96121629e-02f, -1.72403306e-02f, 2.57668942e-02f, -5.67850694e-02f,
  -4.25273590e-02f, 3.33387315e-01f, -1.45280048e-01f, -5.52329533e-02f, 1.26916282e-02f, 4.95608412e-02f, 1.14072315e-01f, 2.76257377e-02f, -1.70661226e-01f, 9.45044085e-02f,
  -1.61981910e-01f, -4.75131761e-04f, 3.26071493e-02f, -1.41006082e-01f, 3.59774078e-03f, 9.43662897e-02f, -2.00311039e-02f, 1.32090628e-01f, 2.05584019e-01f, 3.15756090e-02f,
  2.61620432e-03f, 2.45646462e-01f, 9.93891954e-02f, 1.83589727e-01f, -1.30348634e-02f, 7.29619712e-02f, -5.11628017e-02f, -3.38045955e-02f, 1.63722441e-01f, 3.42979014e-01f,
  3.04983497e-01f, 1.77053422e-01f, -2.50191122e-01f, 1.06222935e-04f, -3.13541174e-01f, 3.39889564e-02f, -2.49110624e-01f, -3.72781418e-02f, 3.04783493e-01f, 2.64329761e-01f,
  -1.79098591e-01f, -1.82544917e-01f, -1.21176288e-01f, 2.47244045e-01f, -2.44168546e-02f, -6.09986782e-02f, 6.21851161e-02f, 2.23003365e-02f, 1.33240968e-01f, -1.52385622e-01f,
  9.91867930e-02f, -8.85898247e-02f, -1.24549232e-02f, -2.25693643e-01f, 1.47436827e-01f, 7.48815313e-02f, -1.10972516e-01f, 2.34088495e-01f, 1.40009746e-02f, -3.35695654e-01f,
  2.52496614e-03f, 5.50196543e-02f, 1.29965944e-02f, -1.35623142e-01f, 3.07559669e-01f, 2.13693231e-01f, -1.25641420e-01f, -2.14994937e-01f, 8.25032145e-02f, -3.26832160e-02f,
  -4.02343348e-02f, 1.10580467e-01f, -2.09763318e-01f, 6.58887848e-02f, -2.93380648e-01f, -8.59557614e-02f, -1.46887422e-01f, 6.35251105e-02f, -7.68327489e-02f, 1.69787765e-01f,
  2.03714762e-02f, 2.45731816e-01f, 1.00069091e-01f, 2.00665280e-01f, 2.03308597e-01f, 2.80623376e-01f, 1.40186399e-01f, 1.07876137e-01f, 9.40979347e-02f, 1.28908277e-01f,
  -5.04877307e-02f, 2.92772744e-02f, 7.65545219e-02f, 4.62530255e-02f, -1.74365684e-01f, -1.81116968e-01f, -4.69285138e-02f, 9.96303558e-02f, -6.48119673e-02f, -1.07066825e-01f,
  -2.11413518e-01f, -3.40251848e-02f, -3.15174431e-01f, -7.33164251e-02f, 2.29628831e-01f, 6.78819865e-02f, 1.95495829e-01f, -1.92426533e-01f, 2.47940585e-01f, -3.35890591e-01f,
  1.01854309e-01f, -4.56812590e-01f, -5.24401031e-02f, 8.26786533e-02f, -9.97593403e-02f, 1.52004436e-01f, -8.49989336e-03f, 6.39032125e-02f, -3.35522927e-02f, -1.59989938e-01f,
  -1.10882021e-01f, -1.17264196e-01f, 1.94579601e-01f, 3.53507578e-01f, -1.49207085e-01f, 4.88515869e-02f, -1.34205028e-01f, 1.66712150e-01f, 4.18258384e-02f, -6.38199151e-02f,
  -6.45207241e-02f, -1.86838031e-01f, -3.16208124e-01f, -1.54612988e-01f, -2.46854082e-01f, -7.59918019e-02f, -1.20262071e-01f, -1.61583483e-01f, 2.69256383e-02f, 6.28203228e-02f,
  -1.58410892e-01f, 1.46112591e-02f, 5.96928857e-02f, 7.31896958e-04f, 1.34331873e-02f, -1.27769411e-01f, 8.85239244e-02f, -1.04945786e-01f, -1.49519920e-01f, -2.40486301e-02f,
  6.25282452e-02f, -1.28202662e-02f, -1.33585587e-01f, -1.26399249e-01f, 9.99046303e-03f, 7.64673427e-02f, 5.64323775e-02f, 1.13697574e-01f, 4.94530164e-02f, 2.45847434e-01f,
  -1.68765560e-02f, 4.12526503e-02f, 2.02742266e-03f, -5.19999787e-02f, -3.55069824e-02f, 6.53692484e-02f, 2.42513455e-02f, 9.68351141e-02f, -5.43553233e-02f, 1.02852933e-01f,
  1.94363520e-01f, 8.80113468e-02f, -2.80689038e-02f, -5.03280712e-03f, 1.08891562e-01f, -8.03406611e-02f, 4.61868979e-02f, -4.32837903e-02f, -8.63929093e-02f, 2.59302735e-01f,
  -7.27382973e-02f, 1.40063150e-03f, 1.46703720e-01f, -1.15881674e-01f, -9.06364843e-02f, 6.59379596e-03f, 6.59039468e-02f, 4.53756228e-02f, -1.51106074e-01f, -1.21639520e-01f,
  2.03633457e-01f, -2.06745770e-02f, 4.31615859e-02f, 1.72212515e-02f, -2.18951464e-01f, -1.02953710e-01f, 1.52128683e-02f, 2.52799317e-02f, 1.51027236e-02f, 1.54808462e-01f,
  -3.05671185e-01f, 1.59196511e-01f, 1.64620772e-01f, 9.55236107e-02f, -1.91488400e-01f, 1.43285662e-01f, 1.32581607e-01f, 4.78682779e-02f, 5.24126925e-02f, 6.16309009e-02f,
  1.48184881e-01f, 1.37065262e-01f, 2.18312323e-01f, 6.53391406e-02f, 1.71549872e-01f, 2.05639422e-01f, 1.96649909e-01f, 2.31546745e-01f, 3.52622289e-03f, 2.13951971e-02f,
  8.34354386e-02f, 2.57783622e-01f, 2.54485995e-01f, 1.82800770e-01f, -2.02828869e-01f, 8.12115893e-02f, -1.47695178e-02f, 9.71516520e-02f, -1.09802738e-01f, -9.26487073e-02f,
  1.52529269e-01f, 2.26555496e-01f, -2.00443313e-01f, -1.25945300e-01f, -4.68564369e-02f, 1.70284182e-01f, -4.76411618e-02f, 6.27964213e-02f, -8.36349428e-02f, 1.23553416e-02f,
  -3.03128242e-01f, -9.64155141e-03f, -1.06478326e-01f, -3.48468423e-02f, -1.35195196e-01f, 6.51456341e-02f, 2.70215571e-01f, -7.61319697e-02f, -1.65944874e-01f, 7.87769035e-02f,
  1.15462812e-02f, -1.20619178e-01f, 4.04255744e-03f, 3.48248988e-01f, 4.13677096e-03f, 2.27193803e-01f, -1.85409665e-01f, 2.04396158e-01f, -1.56387538e-01f, -7.90171698e-02f,
  -1.08575910e-01f, -2.31830198e-02f, -2.13260993e-01f, -7.37741299e-04f, -4.43660244e-02f, 1.37248486e-01f, -8.28760639e-02f, -2.29125082e-01f, 5.13192229e-02f, 3.15756761e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  3.93877551e-02f, 1.01296805e-01f, 3.80723625e-02f, 2.65822560e-02f, -2.57602841e-01f, 6.48356527e-02f, 1.89567849e-01f, 7.09135011e-02f, 5.35574704e-02f, 2.32787803e-01f,
  7.62382150e-03f, 1.23525046e-01f, 1.05778806e-01f, -3.36647630e-02f, -1.91962067e-02f, 9.38562676e-02f, 2.95902640e-01f, 6.25937581e-02f, 7.03706816e-02f, 1.64789155e-01f,
  -3.93247828e-02f, -3.07565816e-02f, -7.01397518e-03f, 7.26918578e-02f, 3.62457111e-02f, 1.01020513e-02f, 1.49038404e-01f, 8.97356421e-02f, 9.16409865e-03f, -4.75309715e-02f,
  4.14485149e-02f, -9.11223516e-03f, 8.01152736e-02f, -6.98237494e-02f, 1.16230294e-01f, -1.84844241e-01f, 3.62800099e-02f, 1.66078910e-01f, 1.45529695e-02f, 6.59205988e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.31192082e-01f, -3.42081413e-02f, 1.78850234e-01f, -2.28075497e-02f, -1.57776132e-01f, -2.02627197e-01f, -7.91212469e-02f, -1.25491396e-01f, -1.06699377e-01f, -2.26812497e-01f,
  -3.26853897e-03f, 1.00348471e-02f, 1.35266736e-01f, 1.65144771e-01f, 1.67478263e-01f, 1.19635217e-01f, -1.28152341e-01f, 3.16755846e-02f, 2.07858399e-01f, 3.62558030e-02f,
  4.04963866e-02f, -2.02105921e-02f, -8.20979923e-02f, 8.55231136e-02f, 5.90446331e-02f, 1.01026066e-01f, 2.11315289e-01f, -1.04141305e-03f, 2.33839646e-01f, 2.11078953e-02f,
  -6.62649795e-02f, -2.30998714e-02f, 1.30645603e-01f, -1.11511663e-01f, 3.91849689e-02f, -1.26113221e-01f, 3.25369507e-01f, -8.11580271e-02f, -2.68693026e-02f, -1.29289672e-01f,
  -1.00804623e-02f, 1.38892561e-01f, 2.54222378e-02f, 2.32712790e-01f, 1.18813433e-01f, 1.63790137e-01f, -1.11320265e-01f, 9.40507129e-02f, -2.39591494e-01f, 1.99339092e-01f,
  -8.79482478e-02f, 3.62474434e-02f, -7.67580867e-02f, 1.24330789e-01f, -5.72449975e-02f, 2.99766641e-02f, -1.50635019e-02f, 1.30912244e-01f, 1.93041623e-01f, 1.27630159e-01f,
  -2.03265473e-01f, 4.22886461e-02f, -3.13519239e-02f, -8.29394981e-02f, -1.86639223e-02f, 2.47844949e-01f, 3.56383547e-02f, -3.75282280e-02f, 4.20207158e-02f, 1.35719776e-01f,
  6.96191192e-02f, -1.30934224e-01f, -2.15072230e-01f, 6.43211007e-02f, -3.22981998e-02f, 1.89853325e-01f, 6.89929724e-02f, 7.41541982e-02f, 8.36384073e-02f, -7.56349862e-02f,
  5.53047620e-02f, -2.92389899e-01f, -6.42493591e-02f, -4.73273844e-02f, 1.89333737e-01f, 8.04337338e-02f, -3.71865690e-01f, 2.78313719e-02f, 8.70027244e-02f, -1.04576841e-01f,
  1.99454069e-01f, 1.30895197e-01f, -1.50088862e-01f, 1.02516770e-01f, 5.84590714e-03f, 3.16695124e-02f, 1.61815584e-01f, -1.08271673e-01f, -1.54635638e-01f, -2.59082150e-02f,
  2.13276997e-01f, -8.07032660e-02f, 7.66001493e-02f, -7.63124973e-02f, 5.67503506e-03f, 3.34214605e-02f, 3.67665365e-02f, -1.46508694e-01f, 7.50389323e-02f, 1.02632515e-01f,
  -1.94848888e-02f, -6.68515190e-02f, -7.89126903e-02f, 1.40886545e-01f, 3.97801995e-02f, -1.15591042e-01f, 1.31645218e-01f, -1.07510388e-01f, 1.19732425e-01f, -1.01708703e-01f,
  -5.46085387e-02f, -5.32450043e-02f, 1.09070092e-01f, -1.26377970e-01f, 2.18874402e-02f, 2.19482109e-02f, 2.10502207e-01f, 2.82464661e-02f, -5.59259988e-02f, 8.08102787e-02f,
  -1.61256701e-01f, 6.11722171e-02f, -2.39290744e-01f, 2.09955931e-01f, -1.53219551e-01f, -1.10570945e-01f, -1.27831325e-01f, -5.09535559e-02f, 4.39007487e-03f, -2.60376871e-01f,
  3.71883541e-01f, -1.30783647e-01f, -1.28602862e-01f, -1.22534027e-02f, -1.09926134e-01f, 1.95776910e-01f, -1.95323065e-01f, 5.19087864e-03f, -1.19972944e-01f, 2.38144293e-01f,
  2.07026973e-02f, 1.22629618e-02f, -8.67301747e-02f, -2.78212339e-01f, -1.82566512e-03f, -1.26625625e-02f, 1.77843601e-01f, -1.06566019e-01f, 2.00108320e-01f, -1.39464900e-01f,
  4.67432737e-02f, -2.23033354e-01f, 4.60192487e-02f, -4.20175046e-02f, -7.05986694e-02f, 2.05669608e-02f, 8.26916844e-02f, -2.63926536e-01f, -5.62288053e-02f, 4.82935905e-01f,
  -1.85628328e-02f, -3.77362877e-01f, -5.61303273e-02f, -2.17471898e-01f, 8.09681565e-02f, -2.13630255e-02f, 4.31748778e-02f, -9.06018615e-02f, 6.57028407e-02f, -2.73218863e-02f,
  6.51210919e-02f, -8.22775811e-02f, 1.27351910e-01f, -8.25078338e-02f, 7.37090483e-02f, 3.84062231e-02f, -1.17787652e-01f, 8.20035636e-02f, 6.32407144e-02f, -1.25193402e-01f,
  3.94273214e-02f, -1.06522273e-02f, 2.12475002e-01f, -5.95429391e-02f, 1.08081520e-01f, 2.12265357e-01f, 1.10836074e-01f, 4.09880988e-02f, 2.25466684e-01f, 1.87667072e-01f,
  1.73042849e-01f, 7.48421475e-02f, -6.82133213e-02f, -5.81410415e-02f, -2.27505401e-01f, 1.75803557e-01f, 3.15371424e-01f, -2.20599219e-01f, -5.82702309e-02f, -1.91397414e-01f,
  1.07354000e-01f, 4.57446650e-03f, -1.93206444e-01f, 2.36900792e-01f, -2.00485587e-01f, -1.14692293e-01f, -3.37468204e-03f, 3.61647084e-02f, -2.04797626e-01f, 1.81859210e-02f,
  -5.81148639e-02f, 2.68212911e-02f, 1.22551307e-01f, 1.42398968e-01f, -1.28577009e-01f, -4.82567325e-02f, -4.59622964e-02f, -9.81424078e-02f, -2.37914726e-01f, -6.65697753e-02f,
  -1.71885699e-01f, 1.55454636e-01f, 1.73535272e-01f, -2.99577922e-01f, 7.03054443e-02f, 2.12841228e-01f, 1.78032089e-02f, -5.91413602e-02f, -1.76977023e-01f, -4.02369536e-02f,
  -1.40608042e-01f, 2.62742788e-01f, 3.61600593e-02f, 2.14303508e-02f, 1.02192663e-01f, 1.24363549e-01f, -8.57012067e-03f, 1.37411773e-01f, -3.76984477e-02f, -1.69063419e-01f,
  2.14520767e-02f, 5.52010676e-03f, 9.36777890e-02f, 3.27949636e-02f, -4.96626161e-02f, -1.51093090e-02f, -5.00500537e-02f, 1.23302765e-01f, 2.47952223e-01f, 3.93608548e-02f,
  3.63676660e-02f, 2.33531907e-01f, 1.16852157e-01f, -1.61005631e-01f, -7.26189057e-04f, -2.62148045e-02f, -3.09907068e-02f, 7.13664591e-02f, 6.73388168e-02f, 4.65450101e-02f,
  -1.41356692e-01f, -1.24745183e-01f, -5.80436923e-02f, 1.25380233e-01f, 2.51992997e-02f, 3.01906079e-01f, -1.90469861e-01f, 2.40443889e-02f, 2.66128480e-01f, -5.10492921e-02f,
  -1.37530461e-01f, 1.97754189e-01f, -3.17786671e-02f, -1.14937536e-01f, -1.11523107e-01f, 1.36773974e-01f, 1.67423133e-02f, -9.71334279e-02f, -5.25963120e-02f, -1.59091622e-01f,
  -4.02477719e-02f, 2.59124905e-01f, -3.15815993e-02f, 6.98328167e-02f, 1.51598334e-01f, -1.26449108e-01f, 5.36153391e-02f, 4.45120633e-02f, 1.97839350e-01f, 2.48385414e-01f,
  9.17726662e-03f, -8.89228731e-02f, 2.87794769e-02f, 1.39170792e-02f, -1.46763707e-02f, -1.24537580e-01f, 1.72553957e-01f, 1.34071738e-01f, 2.17962321e-02f, 9.07688960e-02f,
  1.28078640e-01f, 3.32148038e-02f, -6.54006824e-02f, 1.35580609e-02f, 1.75509751e-02f, 3.56602259e-02f, -6.92722201e-02f, -5.76740429e-02f, 3.04172151e-02f, -1.68902814e-01f,
  7.01991692e-02f, 1.72399297e-01f, -7.37726837e-02f, -1.02560394e-01f, 2.77002752e-02f, -9.78442132e-02f, 7.94173032e-02f, -2.25430429e-01f, -5.97807653e-02f, -8.98596048e-02f,
  5.41448556e-02f, 5.01051135e-02f, -4.89480468e-03f, -8.94444361e-02f, -8.83515030e-02f, -1.47106618e-01f, 1.35662239e-02f, -4.51303184e-01f, -5.35107553e-02f, -1.65596679e-01f,
  1.12825349e-01f, 4.93911840e-02f, -2.22318918e-01f, -1.19520918e-01f, 5.82950190e-02f, -1.41131803e-01f, 8.90854001e-02f, 1.48724690e-01f, -1.53415889e-01f, 1.29934385e-01f,
  6.12404384e-02f, 1.15377508e-01f, -4.28558094e-03f, -7.83889070e-02f, -1.12345569e-01f, -1.10659026e-01f, 8.82467777e-02f, 3.78752127e-02f, 6.56700581e-02f, -2.35538837e-02f,
  -1.49320485e-02f, -1.19158953e-01f, 4.62679341e-02f, -2.01438993e-01f, -1.61627890e-03f, 1.16708651e-01f, -3.49027780e-03f, 5.03025800e-02f, -2.49909647e-02f, -2.66385544e-02f,
  -8.52965098e-03f, -3.31203900e-02f, 7.98937771e-03f, -9.30671766e-02f, -1.31265977e-02f, -7.04734325e-02f, 1.71999320e-01f, -1.15930393e-01f, -1.30897745e-01f, -1.82834417e-01f,
  1.00889862e-01f, -1.24218941e-01f, 6.97710067e-02f, 4.81773503e-02f, -1.41807139e-01f, 1.96415752e-01f, 8.60055089e-02f, 1.10333592e-01f, 1.42726660e-01f, -1.26536950e-01f,
  1.26282170e-01f, -1.39413267e-01f, -1.02711976e-01f, 1.47325993e-01f, 6.30719913e-03f, 2.32146189e-01f, 3.78003791e-02f, 1.65837467e-01f, 1.51585922e-01f, -1.47084117e-01f,
  -1.68749273e-01f, -1.69012502e-01f, 2.57983387e-01f, 2.18602046e-02f, 9.24408529e-03f, -1.52452409e-01f, 1.38853461e-01f, -1.01017088e-01f, -1.24740154e-02f, -5.46269491e-02f,
  1.78834796e-03f, -1.24355808e-01f, -1.34571880e-01f, -9.68605801e-02f, -1.80391133e-01f, 7.53316954e-02f, 1.99500039e-01f, -2.41183847e-01f, -2.23354891e-01f, 2.01146249e-02f,
  1.13433115e-01f, -1.35802805e-01f, -3.57239973e-03f, 2.59580333e-02f, 1.49986997e-01f, -2.29594395e-01f, -2.96179689e-02f, -5.36738448e-02f, 9.81371030e-02f, 7.35551044e-02f,
  -4.84296493e-02f, 1.59734443e-01f, 5.11281677e-02f, 1.80769637e-02f, -1.58248320e-01f, -9.51894447e-02f, 3.50754447e-02f, -8.46588016e-02f, 1.11599162e-01f, 9.05737504e-02f,
  1.18471935e-01f, -1.66165069e-01f, 1.39295384e-01f, 3.29833739e-02f, -2.95099407e-01f, -2.16352120e-02f, 5.11719845e-02f, -1.11277930e-01f, 3.59579287e-02f, 2.89519548e-01f,
  5.22607064e-04f, 1.47576302e-01f, 9.77110937e-02f, 1.10451639e-01f, 1.77156568e-01f, -9.51865595e-03f, 1.57249391e-01f, 1.04631938e-01f, 3.61759849e-02f, 1.25417178e-02f,
  -1.92146841e-02f, 3.42675969e-02f, 2.62703657e-01f, -8.13510120e-02f, -1.17221564e-01f, -2.57852852e-01f, 2.61145085e-01f, 3.43528301e-01f, -3.83231044e-02f, -4.35310565e-02f,
  -9.05947462e-02f, -8.10964629e-02f, 2.48245358e-01f, -2.17762172e-01f, -1.50230661e-01f, 1.39802560e-01f, 4.38027345e-02f, 1.00868672e-01f, -2.14410558e-01f, -5.82232252e-02f,
  -1.66281149e-01f, -2.05117151e-01f, 4.13596677e-03f, 6.77675903e-02f, 4.62239049e-02f, -2.00608999e-01f, -4.07485664e-02f, -8.87453556e-03f, 4.21811283e-01f, -8.59539881e-02f,
  8.66776425e-03f, -4.89925221e-03f, 1.06125705e-01f, 1.13899343e-01f, -1.46684676e-01f, 2.76555747e-01f, -6.21526875e-02f, 2.43056580e-01f, 6.54954314e-02f, -8.76828358e-02f,
  -9.37781483e-03f, -7.43762478e-02f, 2.13407949e-01f, 1.63690299e-01f, 2.71129757e-01f, -3.08770072e-02f, 8.08935016e-02f, -1.40837312e-01f, -3.18329483e-01f, 8.19641873e-02f,
  -1.63969565e-02f, 4.08870317e-02f, -2.70177722e-01f, 1.54793069e-01f, -4.46859114e-02f, -1.34593636e-01f, -1.45718321e-01f, -2.83885039e-02f, 4.02021110e-02f, -3.36402893e-01f,
  -1.61564082e-01f, -4.98035923e-02f, -1.51094183e-01f, -1.26415910e-02f, 3.44241649e-01f, -1.66101396e-01f, -1.39697969e-01f, 2.44730543e-02f, -4.06966126e-03f, -5.06168082e-02f,
  6.28414974e-02f, -1.63828328e-01f, 1.35529384e-01f, 6.96326569e-02f, 1.71984911e-01f, 1.10593833e-01f, -1.59368396e-01f, -7.57768378e-02f, 7.81804174e-02f, -2.38679156e-01f,
  -1.23166023e-02f, 8.27645063e-02f, -5.03878891e-02f, -2.88592489e-03f, 2.32921213e-01f, -2.03229785e-01f, -2.09235474e-01f, 4.61925380e-02f, -5.27326390e-02f, 3.72002162e-02f,
  9.25554335e-02f, -1.04453020e-01f, -1.26877978e-01f, 1.13396578e-01f, -5.73311523e-02f, -2.12260559e-01f, 2.56963000e-02f, -7.54477158e-02f, -1.72496270e-02f, 7.13987276e-03f,
  3.35731963e-03f, -3.08570445e-01f, -2.50240299e-03f, 9.86591056e-02f, 1.57226264e-01f, -9.92874503e-02f, 1.35256946e-01f, 8.58141631e-02f, 7.99878016e-02f, -1.59831107e-01f,
  -3.08862701e-02f, -8.01891834e-02f, -1.12625901e-02f, -3.11336983e-02f, -2.09480450e-02f, 7.24980012e-02f, -1.43111736e-01f, -4.85696271e-02f, -2.49296814e-01f, -8.69602263e-02f,
  -5.65036498e-02f, -1.10506989e-01f, -9.97243077e-02f, 1.93947285e-01f, -1.74359024e-01f, -1.61410570e-02f, 1.24638677e-01f, 5.74788591e-03f, -7.07913637e-02f, -1.36881173e-01f,
  1.81167454e-01f, 2.01433115e-02f, 1.65683590e-02f, -6.47494867e-02f, 5.85589968e-02f, 3.56322117e-02f, -2.80508399e-01f, -2.49555856e-01f, 2.24843770e-01f, 9.82746333e-02f,
  2.48754576e-01f, -2.90424265e-02f, 8.18571374e-02f, 4.17410918e-02f, 1.82856306e-01f, -1.42558590e-01f, 2.16202408e-01f, -2.25526199e-01f, 1.32776543e-01f, -1.12253696e-01f,
  1.84921324e-01f, 1.16609789e-01f, -7.39624128e-02f, 1.46266207e-01f, 1.83232669e-02f, 6.40293397e-03f, 1.34729277e-02f, 2.07983434e-01f, 1.64473087e-01f, -4.32133749e-02f,
  -1.89732891e-02f, -1.11960307e-01f, -2.14130580e-01f, 5.27020060e-02f, -2.15914279e-01f, 6.24612607e-02f, -4.94130924e-02f, -8.41735080e-02f, -4.27587554e-02f, 3.10589969e-01f,
  1.19247302e-01f, 3.19619328e-01f, -1.69627145e-01f, -1.44851983e-01f, 9.16064382e-02f, 1.54634476e-01f, -4.42355275e-02f, -1.49269909e-01f, 4.10895795e-02f, -1.77904770e-01f,
  -1.72561815e-03f, 1.38259277e-01f, -2.41318289e-02f, -1.02965876e-01f, -9.22641531e-02f, 1.16094708e-01f, -1.10821366e-01f, 1.71646267e-01f, 1.02376111e-01f, 2.02388112e-02f,
  8.47465768e-02f, -1.07186712e-01f, 8.22014436e-02f, -6.75662458e-02f, -2.51984864e-01f, 2.29639411e-01f, 1.65699452e-01f, 2.44911551e-01f, -2.40486011e-01f, 2.16727167e-01f,
  8.49280655e-02f, 3.77538800e-01f, -1.38699878e-02f, 4.95765684e-03f, -7.58183450e-02f, 5.11128195e-02f, -3.61530855e-02f, -3.66403349e-02f, -1.55997157e-01f, 8.65360349e-03f,
  1.29223421e-01f, 4.42600660e-02f, -1.26990467e-01f, 1.00527974e-02f, 5.32637611e-02f, -1.41711235e-02f, 7.32721165e-02f, 1.53734977e-03f, 1.45314634e-01f, 1.62526965e-01f,
  -1.76574767e-01f, -1.06353965e-02f, -8.38144124e-02f, -9.86676961e-02f, -3.31624374e-02f, -1.96656473e-02f, 2.61263847e-01f, -1.44786119e-01f, 1.71750307e-01f, -1.48342907e-01f,
  1.40013266e-02f, 1.95316851e-01f, -1.30529314e-01f, -1.24003485e-01f, 2.65411218e-03f, -8.52280110e-02f, 4.67984974e-02f, 8.79126340e-02f, -4.63589504e-02f, 4.02653813e-02f,
  1.02557592e-01f, 1.70087181e-02f, -9.53920931e-02f, 1.87087759e-01f, 1.54196322e-01f, -6.08790703e-02f, 4.07667942e-02f, -9.40838233e-02f, -6.55164793e-02f, -6.73669903e-03f,
  -4.22606915e-02f, -8.29898790e-02f, -7.70637617e-02f, -2.24645641e-02f, -1.17956974e-01f, 9.10015255e-02f, 1.33135349e-01f, -1.01149030e-01f, -3.52463543e-01f, 5.00795655e-02f,
  1.07849322e-01f, -7.58740585e-03f, -3.21091473e-01f, -1.32031828e-01f, 1.01358071e-01f, 7.87627473e-02f, 7.99938962e-02f, -6.84860125e-02f, -2.84772273e-02f, -1.82078317e-01f,
  -1.29529178e-01f, 9.54892784e-02f, 5.05599827e-02f, -1.12995356e-01f, 1.44286975e-01f, -1.09387428e-01f, -6.04918264e-02f, 1.69393405e-01f, 5.96986003e-02f, -1.31099001e-01f,
  1.75586995e-02f, 7.33873248e-02f, 2.79505160e-02f, -1.94757268e-01f, -2.09741190e-01f, 2.96418399e-01f, -7.32958317e-02f, -7.54225776e-02f, 4.80928048e-02f, -6.56429157e-02f,
  1.16577543e-01f, 6.09825179e-02f, 3.84058058e-02f, -2.00997308e-01f, 1.43672809e-01f, -6.73626643e-03f, -1.38532836e-02f, 7.78152421e-02f, -3.16187702e-02f, -2.37930253e-01f,
  -2.12971628e-01f, 1.84293330e-01f, -2.22612187e-01f, 2.52891518e-03f, 8.73528421e-02f, -4.37766165e-02f, 2.66807303e-02f, 1.78825390e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  3.29187512e-01f, -1.45704821e-01f, -1.30531797e-02f, 3.00414830e-01f, 7.01023042e-02f, -1.74521003e-02f, -1.85396764e-02f, 7.74311693e-03f, 1.32370383e-01f, 1.30709097e-01f,
  -1.35839984e-01f, -1.16037130e-01f, 4.01481465e-02f, -1.56320576e-02f, 2.39465296e-01f, 6.97519630e-02f, 1.52835742e-01f, -3.12055945e-01f, -2.90217977e-02f, -1.15613386e-01f,
  1.64811164e-01f, -1.31196275e-01f, -2.07727954e-01f, -2.60442644e-01f, -1.57667637e-01f, -1.61434650e-01f, 8.37913156e-02f, 2.26353064e-01f, 6.20118435e-03f, -9.42726061e-03f,
  -3.07463467e-01f, 2.17748404e-01f, -1.81090891e-01f, 2.05870420e-01f, -4.64514550e-03f, -3.01581502e-01f, 2.54415870e-02f, 6.75761625e-02f, -2.44759023e-01f, 1.50655493e-01f,
  -2.39230366e-03f, -3.81664693e-01f, -1.25117928e-01f, 1.45269945e-01f, 1.61799654e-01f, 1.81694731e-01f, 1.36030570e-01f, 1.14278570e-01f, 7.68231079e-02f, 1.55181453e-01f,
  1.63142402e-02f, 1.16419084e-01f, 3.46968435e-02f, -5.32873012e-02f, -1.50805250e-01f, 5.97784333e-02f, 2.45225534e-01f, 1.66218236e-01f, 4.52418849e-02f, 5.82782030e-02f,
  -2.31647164e-01f, -2.09102575e-02f, 8.95252004e-02f, 2.42342614e-03f, 8.66947025e-02f, 1.46118309e-02f, 9.18592289e-02f, 1.80133417e-01f, -1.32525831e-01f, 2.54643671e-02f,
  -1.67621046e-01f, -2.01025128e-01f, 2.91982573e-02f, 2.02973455e-01f, 3.82362753e-02f, -1.55766875e-01f, 2.60986108e-02f, -1.48488551e-01f, -2.05685228e-01f, -6.82790354e-02f,
  -1.97881356e-01f, 3.51893604e-01f, 1.13863364e-01f, 3.86220515e-02f, -1.94034800e-01f, -1.92983329e-01f, 7.71873966e-02f, -3.95462185e-01f, 1.46227658e-01f, 6.71621785e-02f,
  -7.97610804e-02f, -9.50955749e-02f, -1.58625897e-02f, -4.30133611e-01f, 1.92876175e-01f, -5.07456183e-01f, -1.40623331e-01f, 1.34256408e-02f, 1.27619222e-01f, 9.12993960e-03f,
  -2.13867545e-01f, -1.27284795e-01f, -1.74249280e-02f, 1.42570436e-01f, 2.14229569e-01f, 1.18212417e-01f, -1.65149048e-01f, -3.41484360e-02f, -2.97360301e-01f, -3.24416906e-01f,
  2.01362297e-01f, -4.23952252e-01f, -7.00241374e-03f, 8.81984979e-02f, 2.57105947e-01f, -2.00972989e-01f, 1.40591756e-01f, 2.02112459e-02f, 1.99469030e-02f, 3.03313673e-01f,
  -7.67966732e-02f, 3.31291109e-02f, 6.96979612e-02f, -2.11901143e-01f, -2.85984874e-01f, -4.29468304e-01f, -2.09606901e-01f, -2.06245452e-01f, 1.20444428e-02f, 7.72790238e-02f,
  2.10696504e-01f, 2.77821012e-02f, 1.60361394e-01f, -7.61146145e-03f, 1.85048148e-01f, 2.67788589e-01f, 1.13713712e-01f, 1.26218900e-01f, -6.95710331e-02f, 1.70081720e-01f,
  -3.57101381e-01f, 1.73148587e-01f, 3.11312024e-02f, -1.93472102e-01f, -8.26949347e-03f, 9.13870111e-02f, 2.05560654e-01f, 9.10235718e-02f, 9.92142409e-02f, -1.21681400e-01f,
  3.74555409e-01f, 1.24889851e-01f, 1.44826323e-01f, 3.30742776e-01f, -9.88388807e-03f, -9.24759880e-02f, -2.00462639e-01f, -1.21992975e-01f, -2.59422570e-01f, 6.46365806e-02f,
  -1.64817169e-01f, -1.79842524e-02f, 1.32580668e-01f, 1.80445001e-01f, -2.23466218e-01f, -6.65609986e-02f, -2.25129165e-02f, 1.08608834e-01f, 5.14166392e-02f, -3.92868876e-01f,
  1.32290736e-01f, 2.72829682e-01f, -3.54037941e-01f, -4.46454808e-02f, -9.03666764e-02f, -4.11791652e-01f, 3.19845259e-01f, 1.21861264e-01f, 1.68778040e-02f, -8.73661190e-02f,
  -3.25384103e-02f, 1.34123236e-01f, -6.22638799e-02f, 1.18171535e-01f, 4.32922393e-02f, -3.40536311e-02f, 1.45113140e-01f, -1.60912741e-02f, 2.32192487e-01f, 7.86095411e-02f,
  9.83356126e-03f, 5.92047051e-02f, -2.74063740e-02f, 1.76067173e-03f, 4.78004888e-02f, -1.50670633e-01f, 1.09007776e-01f, 8.12578127e-02f, 2.57185567e-02f, 1.83921322e-01f,
  -3.68941762e-02f, 1.52277991e-01f, 1.03556350e-01f, 1.58358827e-01f, 7.17356950e-02f, 1.56534731e-01f, -1.49648279e-01f, 3.59378606e-01f, -1.21530397e-02f, -1.38253912e-01f,
  5.20072952e-02f, 2.49371491e-02f, 1.53088182e-01f, -3.54127958e-02f, 2.34803155e-01f, -1.93500035e-02f, 4.32289541e-02f, 1.81024387e-01f, 1.73756778e-02f, -3.07808757e-01f,
  -2.08927840e-02f, 1.50633663e-01f, -3.41399387e-02f, -1.39858639e-02f, 1.52490005e-01f, -1.69588238e-01f, -1.54574275e-01f, 1.79271549e-01f, 1.08206607e-02f, 1.32991210e-01f,
  2.04266638e-01f, -2.23811567e-01f, -2.09061027e-01f, -4.20107126e-01f, 1.58728465e-01f, 1.48568317e-01f, -2.15701368e-02f, 1.38534218e-01f, -2.06201032e-01f, 1.09959193e-01f,
  1.09100290e-01f, -1.05909228e-01f, -1.35961115e-01f, 2.52399176e-01f, -2.98775107e-01f, 1.68545783e-01f, 4.33250032e-02f, -8.35786834e-02f, -3.95079777e-02f, -1.42784044e-01f,
  2.27886792e-02f, 1.32204801e-01f, -3.50282155e-02f, 8.66693929e-02f, 5.03257103e-02f, -9.55329835e-03f, -7.76378363e-02f, 1.49145991e-01f, -4.46207896e-02f, 1.23833165e-01f,
  -2.56010983e-02f, 1.71218678e-01f, 1.77721664e-01f, -2.44154245e-01f, -3.83249581e-01f, 1.81652471e-01f, -9.30690859e-03f, -1.66267738e-01f, 2.30109587e-01f, 1.50828809e-01f,
  2.71295100e-01f, 1.13234751e-01f, -2.52229333e-01f, 2.05525197e-02f, 2.54167616e-01f, 4.43201736e-02f, -2.96113163e-01f, -2.23082438e-01f, -2.43857149e-02f, -1.00410834e-04f,
  -9.44857299e-02f, -7.53821805e-03f, 1.89173684e-01f, 5.38274739e-03f, -2.76987672e-01f, 2.18973741e-01f, -1.28004715e-01f, -5.04943393e-02f, 2.84727402e-02f, -9.66213644e-02f,
  -9.07557905e-02f, 1.43391058e-01f, 2.56472677e-01f, -1.45073697e-01f, 3.18348147e-02f, -7.06611052e-02f, 2.00954571e-01f, 3.35986279e-02f, -8.83458331e-02f, 7.54974596e-03f,
  8.41500759e-02f, -1.38781011e-01f, -1.54100984e-01f, 1.15293153e-01f, -3.34316641e-01f, -7.26867169e-02f, 4.45236824e-02f, 8.47271457e-02f, -7.36561120e-02f, -1.05248354e-02f,
  8.35637450e-02f, 6.94874898e-02f, 1.73555359e-01f, 8.60244874e-03f, 2.46916398e-01f, -1.94392741e-01f, -3.57067734e-01f, 2.63635606e-01f, 1.11066028e-01f, -2.51212001e-01f,
  1.12319268e-01f, 2.04351395e-02f, -1.87864065e-01f, 3.09599876e-01f, -3.51678096e-02f, -2.79380884e-02f, 1.74586385e-01f, -7.09966496e-02f, 2.75447201e-02f, -6.89550936e-02f,
  1.26188800e-01f, 1.48659162e-02f, 1.90434456e-01f, 7.98711702e-02f, 1.62193239e-01f, 1.18841030e-01f, -2.50079960e-01f, -4.14260179e-01f, 2.04853430e-01f, 1.12404995e-01f,
  1.34434789e-01f, 1.42450452e-01f, -2.83620153e-02f, 1.04986399e-01f, -1.28236949e-01f, -9.46837962e-02f, 1.15623079e-01f, -2.28438862e-02f, -2.56462812e-01f, 2.39025638e-01f,
  -3.16228628e-01f, 1.87524766e-01f, -1.31450728e-01f, -9.33999866e-02f, -2.64916331e-01f, -4.69211787e-02f, 4.07639220e-02f, -1.90269932e-01f, -1.83189902e-02f, -2.57593334e-01f,
  1.66979685e-01f, -1.71936676e-01f, 5.16703837e-02f, 1.27815634e-01f, 3.94157646e-03f, 1.15797251e-01f, 1.12166464e-01f, 3.72018397e-01f, -1.45268694e-01f, -6.98112708e-05f,
  -6.46430925e-02f, 1.24812357e-01f, -9.51720029e-02f, 1.26438901e-01f, -1.94356009e-01f, -3.48430246e-01f, 2.44222343e-01f, -8.05680230e-02f, -1.38261452e-01f, -1.73619077e-01f,
  -2.65924215e-01f, 2.09437668e-01f, 1.84999898e-01f, 7.92714581e-02f, 1.60502717e-01f, -1.31615326e-02f, -1.99642897e-01f, 1.76190063e-01f, 1.10824786e-01f, -7.84342065e-02f,
  1.39638752e-01f, 2.65013456e-01f, 1.05746180e-01f, 9.27337930e-02f, 1.53265774e-01f, 9.08603296e-02f, -2.82134205e-01f, 1.93028778e-01f, 2.48496369e-01f, -6.52827024e-02f,
  -3.31976940e-03f, -2.90784597e-01f, 1.53480843e-01f, 8.78966693e-03f, -6.26833439e-02f, -2.09279746e-01f, -9.51996744e-02f, -5.22154532e-02f, -7.45853707e-02f, 3.46014611e-02f,
  -2.51777828e-01f, 2.27328494e-01f, 1.73464835e-01f, 1.50327548e-01f, -1.73431888e-01f, 1.48038760e-01f, -6.05205111e-02f, 1.77661657e-01f, 1.17139004e-01f, -1.12857401e-01f,
  -1.94656119e-01f, -8.01795274e-02f, -1.69767946e-01f, 6.36199415e-02f, 1.96242616e-01f, -1.64571211e-01f, 2.28100136e-01f, 1.03464082e-01f, 8.37536901e-02f, 9.00388956e-02f,
  -7.83426315e-02f, 2.74556696e-01f, -1.98049143e-01f, 1.26047581e-01f, -1.10989302e-01f, -1.90005839e-01f, -8.83746520e-02f, 1.55469775e-01f, -2.46693015e-01f, 1.18631184e-01f,
  1.45712107e-01f, -1.18524551e-01f, 1.52066620e-02f, 1.60521045e-01f, -3.04962099e-01f, 2.66431510e-01f, -9.74841788e-02f, -3.08895949e-02f, -1.40723497e-01f, 2.73540448e-02f,
  4.74973544e-02f, 7.12492317e-02f, -4.10746448e-02f, -5.73458523e-02f, 1.82645142e-01f, -7.41574541e-02f, -6.19725287e-02f, -1.19445585e-01f, -1.56435102e-01f, 3.03307176e-01f,
  -3.13544005e-01f, -1.69232190e-01f, -6.37735724e-02f, -7.97005221e-02f, 2.21482202e-01f, -3.10498595e-01f, -1.15524530e-01f, 1.35192797e-01f, 1.99085046e-02f, -2.58174509e-01f,
  3.13425399e-02f, 4.81089205e-02f, 1.58554941e-01f, 1.39316961e-01f, 8.48273411e-02f, -6.69737011e-02f, -1.27049480e-02f, 1.26037464e-01f, -9.94888693e-02f, -2.30930641e-01f,
  -1.29121557e-01f, 3.77111398e-02f, 5.62442131e-02f, -2.39665713e-02f, -5.52998893e-02f, -9.18059573e-02f, -7.13079050e-02f, 1.43732168e-02f, -9.92565900e-02f, -2.54555881e-01f,
  -1.93958089e-01f, 6.95159733e-02f, 9.04365331e-02f, 7.64306337e-02f, -1.41631544e-01f, 4.20531780e-02f, 1.92007989e-01f, 3.23291011e-02f, -2.84858234e-02f, -2.83920527e-01f,
  -9.55268145e-02f, 3.42189893e-02f, -3.92353237e-02f, 3.86802256e-02f, -7.20311254e-02f, -1.98376611e-01f, 4.33387607e-03f, 8.86269510e-02f, 3.10966998e-01f, -2.08350524e-01f,
  1.10203521e-02f, -2.14420676e-01f, 1.54938670e-02f, -1.34437099e-01f, -6.90734908e-02f, -1.79625750e-01f, -7.00798631e-02f, -1.82436839e-01f, -7.77679160e-02f, -1.52827039e-01f,
  -8.95751044e-02f, -3.17550711e-02f, 9.43103954e-02f, 4.80189808e-02f, -3.42045039e-01f, -6.41089901e-02f, -1.80348158e-01f, -1.43153578e-01f, 2.69616246e-01f, -9.99608263e-02f,
  -5.86541630e-02f, -3.72709364e-01f, 1.98565334e-01f, -5.78599274e-02f, 1.78295188e-02f, 2.41296738e-01f, 1.11922413e-01f, 2.61998829e-02f, 3.23526897e-02f, 8.35134238e-02f,
  4.84543741e-02f, 2.24289671e-02f, -2.13108778e-01f, 1.56319991e-01f, -2.26690054e-01f, 5.14246896e-02f, 1.43864080e-01f, -8.15029666e-02f, -2.90520098e-02f, 7.18522072e-02f,
  3.91701944e-02f, 1.86799586e-01f, -8.49348828e-02f, -2.19196454e-02f, 1.60590594e-03f, 3.42962332e-02f, 2.96021998e-01f, 2.41499573e-01f, -1.75810844e-01f, 8.13632756e-02f,
  2.78052151e-01f, -1.90761656e-01f, -2.89794564e-01f, -6.74811825e-02f, 1.30506963e-01f, 1.01433925e-01f, 4.18614522e-02f, -1.03641830e-01f, -1.55609310e-01f, 8.86811763e-02f,
  1.10198269e-02f, 2.29431376e-01f, 2.93316036e-01f, -1.53609350e-01f, -7.34999776e-02f, -3.77034629e-03f, 3.29871684e-01f, 7.57156163e-02f, -9.50408652e-02f, 1.31062433e-01f,
  2.52164841e-01f, 2.22120196e-01f, 1.84292555e-01f, 2.67160147e-01f, 3.15135837e-01f, 1.44148827e-01f, 4.52392220e-01f, 9.36723500e-02f, 4.65787984e-02f, 1.46637470e-01f,
  -5.66971526e-02f, 3.77729535e-01f, -7.20180795e-02f, -3.66104126e-01f, -3.22049856e-02f, 1.07621983e-01f, -5.06798662e-02f, 1.52453005e-01f, 2.10672051e-01f, 2.80189663e-01f,
  -2.04535753e-01f, 6.07378818e-02f, -5.40707074e-02f, -5.45522906e-02f, -2.41919994e-01f, 9.32714418e-02f, 4.92063761e-02f, 1.78131610e-01f, 8.21186453e-02f, -1.69247538e-01f,
  -3.40253711e-01f, 1.84865698e-01f, -7.68969879e-02f, -1.20497592e-01f, 1.21487878e-01f, -2.59368718e-01f, -1.21889502e-01f, 1.79740623e-01f, 1.79167077e-01f, 2.74731219e-01f,
  6.20563813e-02f, 1.36547685e-01f, 1.34216519e-02f, 1.04689866e-01f, -6.59418330e-02f, 2.91150925e-03f, -1.60588026e-01f, 9.77105275e-02f, -1.00526676e-01f, 1.62136093e-01f,
  1.02228438e-02f, -2.77065486e-01f, 2.06776723e-01f, -9.26278830e-02f, -1.41934156e-01f, -6.88891485e-02f, -1.33991474e-02f, 3.51739883e-01f, 1.16188847e-01f, 1.61856353e-01f,
  1.05408862e-01f, -1.03324473e-01f, -1.52860165e-01f, -3.02707497e-02f, -3.27213109e-01f, -1.31998053e-02f, -4.93192255e-01f, -2.62248844e-01f, -3.33900660e-01f, 3.75473499e-02f,
  -3.21247190e-01f, -3.86389233e-02f, -5.04843220e-02f, -1.05268925e-01f, -1.17467977e-01f, 1.74506947e-01f, 1.22076899e-01f, 1.62312225e-01f, -5.76643087e-02f, -4.77865070e-01f,
  1.80654317e-01f, -2.97201741e-02f, -4.11856622e-02f, -5.14308922e-03f, -7.52243400e-02f, -8.29374269e-02f, 7.31993616e-02f, -5.04267588e-03f, -3.42236981e-02f, 2.91077662e-02f,
  1.11401305e-01f, 3.11502013e-02f, 6.19244911e-02f, 1.43867970e-01f, -6.76695555e-02f, -4.10194069e-01f, 2.09768340e-02f, -2.68548429e-01f, -1.21587902e-01f, -3.61817773e-03f,
  -7.93936402e-02f, -4.11464758e-02f, -2.44601425e-02f, 9.36649856e-04f, 1.89576805e-01f, 1.55385926e-01f, 2.61914045e-01f, 2.55898051e-02f, 8.18282962e-02f, -2.64771998e-01f,
  6.59878850e-02f, 4.88373674e-02f, 4.16736258e-03f, -2.06420556e-01f, -2.33812630e-01f, -5.51907569e-02f, -2.07652271e-01f, 2.35534787e-01f, -2.10278809e-01f, 2.78732955e-01f,
  1.92050129e-01f, -6.08348362e-02f, 1.49022967e-01f, 1.93547547e-01f, 3.69310051e-01f, -8.99708048e-02f, 1.78278551e-01f, -5.09597473e-02f, 1.85614452e-01f, -8.66725072e-02f,
  1.89371631e-01f, 1.40632242e-01f, 2.77294874e-01f, 9.20509100e-02f, 8.32195356e-02f, 2.01304138e-01f, -2.67342657e-01f, 4.14348394e-02f, 2.64821518e-02f, 1.59163505e-01f,
  3.08446735e-01f, -1.56127021e-01f, -2.02496648e-01f, -1.86925054e-01f, -4.84094210e-02f, 3.41841541e-02f, -1.58011019e-01f, -3.68508808e-02f, -7.20734969e-02f, 1.90003276e-01f,
  -1.16807520e-01f, 1.92837194e-01f, -2.47528419e-01f, 6.74884543e-02f, -7.63080940e-02f, 6.36669621e-02f, 8.02410766e-02f, 1.99455768e-01f, -7.51702040e-02f, -1.39501646e-01f,
  -7.97422081e-02f, -1.83744863e-01f, -5.82577065e-02f, -2.32412703e-02f, 1.60571799e-01f, -1.68063059e-01f, 2.87280157e-02f, 2.52354085e-01f, -6.69575036e-02f, 2.12745354e-01f,
  7.96641335e-02f, -7.61419162e-02f, 1.17927499e-01f, 3.30348194e-01f, 9.76413116e-03f, 5.29732592e-02f, 2.03039020e-01f, 5.96545637e-02f, 2.21603140e-02f, 1.36250272e-01f,
  -3.07590868e-02f, -2.46119201e-02f, -4.20691520e-02f, -1.47000864e-01f, 3.48972559e-01f, 7.32673854e-02f, 6.37678206e-02f, 3.27593952e-01f, 1.10899091e-01f, 1.05381059e-02f,
  -8.73640832e-03f, 1.06399961e-01f, -1.25232264e-01f, 7.84309283e-02f, -1.47997305e-01f, -1.47314787e-01f, 7.36194327e-02f, 1.01254970e-01f, 1.47736505e-01f, -2.46644408e-01f,
  -1.63777113e-01f, -4.28684115e-01f, -3.33979934e-01f, -3.25996168e-02f, 1.05868861e-01f, -1.36148229e-01f, -7.16510266e-02f, 1.29682392e-01f, -2.01079249e-01f, 1.44625887e-01f,
  1.57009646e-01f, -1.59552440e-01f, 1.35064080e-01f, -3.49978566e-01f, -3.01506761e-02f, -9.53424126e-02f, -1.57654077e-01f, -1.79113477e-01f, -1.77759826e-02f, -1.76392511e-01f,
  -1.47191435e-01f, -2.68632993e-02f, 1.18743926e-01f, 1.33851737e-01f, -1.22541018e-01f, 1.85651913e-01f, 2.15757594e-01f, 2.31034800e-01f, -1.06504157e-01f, -3.34191583e-02f,
  -4.80034709e-01f, -6.14729345e-01f, -1.09320045e-01f, -2.15521857e-01f, 3.45595717e-01f, -2.85934657e-02f, 1.56953931e-01f, -2.87442535e-01f, 1.22485965e-01f, -1.61453784e-01f,
  1.24362623e-02f, 1.00986324e-01f, 1.31654039e-01f, -2.15186086e-02f, 6.21539317e-02f, 1.20709881e-01f, 1.42424434e-01f, 5.68437316e-02f, -1.66095778e-01f, -7.62829632e-02f,
  1.18531197e-01f, -2.35179335e-01f, 4.21821438e-02f, 1.66577414e-01f, 1.68703064e-01f, 2.19679788e-01f, -3.54098864e-02f, -6.77122101e-02f, 1.17428884e-01f, -1.21755064e-01f,
  -4.11694385e-02f, 2.41591200e-01f, -1.41385505e-02f, -2.12119017e-02f, -1.99672699e-01f, -3.22193921e-01f, -1.76461518e-01f, -5.09581029e-01f, -4.97632995e-02f, 8.99548382e-02f,
  6.70393696e-03f, 1.28829792e-01f, -1.11145869e-01f, -3.04517239e-01f, -2.84137558e-02f, -1.37742817e-01f, 2.88006887e-02f, -8.58866274e-02f, -8.45084563e-02f, -6.03731349e-03f,
  -2.84081638e-01f, -1.42542258e-01f, 9.29851755e-02f, -8.59035004e-04f, -1.65455848e-01f, 1.34060398e-01f, 1.35189503e-01f, -5.26365042e-02f, -1.88356355e-01f, 1.03495710e-01f,
  7.63993636e-02f, 2.71315038e-01f, 2.31673926e-01f, -7.65773952e-02f, -1.49946466e-01f, -1.38363004e-01f, 3.65829170e-02f, 1.66451588e-01f, 1.61757648e-01f, -3.55346084e-01f,
  1.54231653e-01f, -1.28361695e-02f, 8.69657770e-02f, -2.38980368e-01f, 6.07238971e-02f, 2.72536110e-02f, 2.34946102e-01f, 1.92936912e-01f, 3.36244777e-02f, 1.75110444e-01f,
  1.40407875e-01f, 9.35559124e-02f, -2.26053484e-02f, -2.18099222e-01f, 1.31287649e-02f, -1.62720680e-01f, -9.06215608e-02f, 3.74558903e-02f, -1.72586590e-01f, 1.92309618e-02f,
  5.55294193e-02f, -4.03871723e-02f, -1.63808078e-01f, 1.42609894e-01f, 2.73846447e-01f, 1.65479496e-01f, 3.52407508e-02f, -7.32660070e-02f, -4.08382912e-04f, 6.79660514e-02f,
  1.99111309e-02f, -7.75921717e-02f, -2.79850364e-01f, 1.80008754e-01f, 1.90655127e-01f, 1.83151904e-02f, -2.26315692e-01f, -3.00718158e-01f, -6.64896071e-02f, -2.25282431e-01f,
  1.66523889e-01f, -1.99946880e-01f, -1.88065708e-01f, 2.93324459e-02f, 3.02026812e-02f, -1.37754992e-01f, -3.35410386e-02f, 5.84515072e-02f, 8.41570795e-02f, 1.05555348e-01f,
  5.38598048e-03f, 2.10643023e-01f, -4.84218150e-02f, -7.64094889e-02f, -8.18233714e-02f, 5.14056124e-02f, 2.93049634e-01f, -1.19844824e-01f, -1.16436400e-01f, 6.75856173e-02f,
  -3.75705987e-01f, -1.21645935e-01f, 1.81508273e-01f, -1.35063425e-01f, -9.81189236e-02f, 7.32746348e-02f, 6.28615469e-02f, -2.54322082e-01f, -1.92604274e-01f, 1.84471175e-01f,
  2.65588332e-02f, 1.58523366e-01f, 1.79761767e-01f, -1.24040686e-01f, -7.69541934e-02f, -1.36932568e-03f, -4.44155335e-01f, 1.59688294e-02f, -1.39890909e-01f, -2.41644364e-02f,
  3.21387827e-01f, -7.39837587e-02f, 2.19557390e-01f, 2.79736787e-01f, 2.40106761e-01f, 2.00814217e-01f, 2.70185457e-03f, 1.14525013e-01f, 2.95580309e-02f, 2.83095360e-01f,
  3.92491519e-02f, -1.26455277e-01f, -1.53215185e-01f, -5.27027510e-02f, -3.53627130e-02f, 5.29911183e-02f, -8.96886811e-02f, 2.41061449e-01f, -2.03650087e-01f, 2.68211603e-01f,
  -2.58848876e-01f, -3.97844650e-02f, -9.08163860e-02f, -1.82978734e-01f, 4.92599644e-02f, -1.82457596e-01f, -1.90776691e-01f, 2.29840666e-01f, -1.38750404e-01f, -4.66803275e-02f,
  1.29754379e-01f, -9.58780646e-02f, -1.24317192e-01f, 2.02683181e-01f, -1.83774251e-02f, -1.62766874e-01f, 8.17702040e-02f, 1.56617220e-02f, 2.54689809e-02f, 1.60014257e-01f,
  1.78639337e-01f, 1.13588452e-01f, -1.45302087e-01f, -5.81889115e-02f, -2.25674082e-02f, -1.37360729e-02f, 2.16277257e-01f, -2.99235553e-01f, -2.77017802e-01f, 3.20362926e-01f,
  2.82905757e-01f, -1.57474741e-01f, 1.47057101e-01f, 2.67455578e-02f, 9.22235772e-02f, 1.95592389e-01f, -7.25144148e-02f, 1.08966313e-01f, -1.52941830e-02f, -2.83438206e-01f,
  -2.21319988e-01f, -1.36432990e-01f, -1.72607407e-01f, -1.12978771e-01f, 2.10013598e-01f, -3.38603859e-03f, -6.95709065e-02f, 2.96988059e-02f, 9.03533846e-02f, 1.38612509e-01f,
  2.81824972e-02f, 3.86301488e-01f, 1.99230433e-01f, 2.03977585e-01f, -1.26496240e-01f, -4.94731329e-02f, -1.89725026e-01f, 1.29246742e-01f, -6.49364740e-02f, 1.43093348e-01f,
  -1.48347691e-01f, 3.08456093e-01f, 2.80245356e-02f, 2.08916456e-01f, -8.09528828e-02f, -1.53583027e-02f, -3.39223035e-02f, -3.41030270e-01f, -1.34927966e-02f, 1.08503930e-01f,
  -1.04993157e-01f, 3.08757573e-02f, -1.69006661e-02f, -1.44768983e-01f, -2.55416054e-02f, 1.30888134e-01f, -3.03095311e-01f, 1.97020501e-01f, -3.37025337e-02f, 4.50482965e-02f,
  -2.32767880e-01f, -1.69644445e-01f, -1.66134074e-01f, 7.03510968e-03f, 6.75685033e-02f, -2.70770192e-01f, 1.74177453e-01f, 1.00476496e-01f, -1.92223623e-01f, -3.91840488e-02f,
  1.45831287e-01f, -5.25920630e-01f, 1.29710674e-01f, 8.26712698e-02f, 1.41606443e-02f, 1.26411453e-01f, 3.09860766e-01f, -8.49029887e-03f, -3.53006721e-02f, 2.19747081e-01f,
  -9.07004327e-02f, 1.90397233e-01f, 3.90814468e-02f, 1.48432981e-02f, -1.42712211e-02f, 1.77586321e-02f, -1.82674184e-01f, -5.71078733e-02f, -6.53257072e-02f, 3.74133401e-02f,
  1.11187086e-01f, 8.83545727e-02f, 2.91920118e-02f, -1.64720509e-02f, -1.08523950e-01f, -1.42375991e-01f, -2.46133745e-01f, 4.44924645e-02f, 6.13371991e-02f, 1.97396889e-01f,
  4.92685996e-02f, -4.08845469e-02f, -2.32711956e-02f, 1.50976315e-01f, 3.74698371e-01f, -1.27783149e-01f, -3.54271621e-01f, -2.69365996e-01f, 2.59331167e-01f, 1.37564659e-01f,
  2.78618857e-02f, 2.26912070e-02f, 1.09416202e-01f, 2.06974730e-01f, 1.62967190e-01f, -5.33558317e-02f, -4.29057032e-02f, -6.60894290e-02f, 3.11833946e-03f, -4.56011370e-02f,
  -1.49472698e-03f, 8.42622593e-02f, -7.11179376e-02f, -1.43842429e-01f, 1.24271296e-01f, 9.32907164e-02f, 8.83397758e-02f, 1.28664702e-01f, -2.93649614e-01f, -3.18917185e-02f,
  -1.49519965e-01f, 1.47835493e-01f, -6.39663264e-02f, 1.61185339e-01f, 7.95230344e-02f, -8.71793404e-02f, 1.44234583e-01f, -1.68316148e-03f, -6.90875649e-02f, 2.56025195e-02f,
  -1.03633210e-01f, 5.01165651e-02f, 8.04602578e-02f, 9.81763452e-02f, -5.95749076e-03f, -1.58193279e-02f, -4.20081466e-02f, 8.27273577e-02f, 2.47446746e-01f, 9.04590040e-02f,
  8.54346063e-03f, 2.49309942e-01f, 2.02364907e-01f, 4.10832698e-03f, 2.14671567e-01f, 2.54248530e-01f, 2.03854576e-01f, 3.15289617e-01f, 6.76927418e-02f, 9.32430029e-02f,
  1.50352031e-01f, 1.70953214e-01f, 6.06542602e-02f, -1.07677892e-01f, 3.39507163e-02f, -4.05676782e-01f, -6.99741468e-02f, -4.33230884e-02f, -2.68144965e-01f, -5.39091490e-02f,
  -1.80276990e-01f, 2.25111723e-01f, -1.89954817e-01f, 3.64779413e-01f, -2.53029823e-01f, 2.09559146e-02f, 5.50961941e-02f, -2.38422886e-01f, -2.64191717e-01f, 2.70496696e-01f,
  -1.79980576e-01f, 1.39976263e-01f, 2.89475739e-01f, -2.01646000e-01f, -6.86471630e-03f, 1.15302779e-01f, 3.21049169e-02f, -8.42704251e-03f, 8.41923133e-02f, 8.06861743e-02f,
  6.38435706e-02f, 1.32674858e-01f, -1.06039800e-01f, 3.79662037e-01f, -1.40814945e-01f, -4.69714969e-01f, -2.87529349e-01f, -3.97772312e-01f, 1.07960410e-01f, -1.15320817e-01f,
  -3.63170683e-01f, 5.84319122e-02f, 2.07100794e-01f, -8.25991556e-02f, 1.02069475e-01f, -1.83725253e-01f, 1.30237773e-01f, 2.29500890e-01f, 1.22452624e-01f, 1.78200215e-01f,
  2.57221907e-02f, -3.02387297e-01f, -4.06113565e-02f, 2.10803568e-01f, -1.15789585e-01f, 9.53873321e-02f, 3.12553853e-01f, 2.17115179e-01f, 5.57721369e-02f, -3.83321084e-02f,
  1.49761826e-01f, 1.53219312e-01f, 2.51512110e-01f, 3.02478522e-01f, 2.06325918e-01f, 7.60642365e-02f, -1.05424292e-01f, 2.79533058e-01f, -2.71118790e-01f, -3.34701203e-02f,
  1.40588775e-01f, -2.92543888e-01f, 2.79283756e-03f, -1.49111375e-01f, -2.19490290e-01f, 9.93151963e-02f, -1.38662130e-01f, 7.29857311e-02f, -2.39183262e-01f, 1.12463087e-02f,
  -1.14445560e-01f, -1.07514799e-01f, -1.13310061e-01f, 2.67641753e-01f, -1.65958405e-01f, 1.12314053e-01f, 1.00205831e-01f, 1.58451453e-01f, -1.85280472e-01f, 4.88628596e-02f,
  2.26538807e-01f, -2.30876341e-01f, 1.49222106e-01f, 9.66685787e-02f, 3.47411539e-03f, -1.40826497e-02f, -4.07982580e-02f, 1.89552158e-01f, -1.70968845e-01f, -2.02640936e-01f,
  -9.24519897e-02f, -5.90422340e-02f, -1.41074091e-01f, 2.12870017e-02f, -1.68446809e-01f, 3.40253472e-01f, -1.19067123e-02f, -1.40550375e-01f, -3.83742526e-02f, 1.16983324e-01f,
  -6.79562613e-02f, 2.41942182e-01f, -6.11332199e-03f, 3.02184280e-03f, 9.49201435e-02f, 2.03752164e-02f, -2.06350200e-02f, 2.29893148e-01f, -7.87480995e-02f, 9.39609334e-02f,
  -1.17164150e-01f, 3.25582445e-01f, 2.53665864e-01f, 2.51299858e-01f, 1.89147830e-01f, -5.92624815e-03f, 4.11288217e-02f, 1.05875008e-01f, -1.40495207e-02f, 3.99055071e-02f,
  -1.76621541e-01f, 1.85470432e-01f, -3.46585095e-01f, -3.77308249e-01f, -2.68183053e-01f, -5.60452104e-01f, 1.76501021e-01f, -9.51554533e-03f, -2.11052895e-01f, 8.69050995e-03f,
  1.87594339e-01f, -1.67764992e-01f, 6.23028576e-02f, 4.81618643e-02f, 1.54431552e-01f, 8.21921825e-02f, -2.04929188e-01f, -1.65347785e-01f, -1.77492201e-01f, -1.20534383e-01f,
  -2.01967712e-02f, 4.93207201e-02f, -2.23066464e-01f, 2.37886161e-01f, -1.88307744e-02f, 5.09257950e-02f, -2.55237669e-01f, 1.81524515e-01f, 1.29147872e-01f, 2.52321959e-01f,
  1.72079504e-01f, -5.51191330e-01f, -2.33594134e-01f, -1.40709624e-01f, -1.59551039e-01f, 1.00953177e-01f, -7.14603439e-02f, -4.65338439e-01f, 3.48099798e-01f, 1.02380686e-01f,
  -9.40836892e-02f, -9.75012854e-02f, 2.06751853e-01f, 2.90452931e-02f, 2.02133134e-01f, 2.62684196e-01f, -7.21558630e-02f, 3.50082628e-02f, 1.31906541e-02f, 1.13950625e-01f,
  1.99086979e-01f, -1.37208819e-01f, -7.80510753e-02f, 9.41892639e-02f, 3.41980249e-01f, 1.20067164e-01f, 1.66661710e-01f, 2.73855954e-01f, 3.20320189e-01f, 2.51923263e-01f,
  2.41504118e-01f, 2.80834585e-01f, 2.02908441e-01f, 1.88241586e-01f, -1.12352893e-01f, 2.10333943e-01f, -1.42608240e-01f, -2.50239313e-01f, -2.02639084e-02f, -3.26201648e-01f,
  -1.30966203e-02f, -4.99200895e-02f, -1.93219095e-01f, 9.19435471e-02f, -2.42417261e-01f, 1.73250616e-01f, -4.35348541e-01f, -3.97813134e-02f, -1.43547310e-02f, -2.31790692e-01f,
  -2.47178361e-01f, 2.60818988e-01f, -1.69637218e-01f, 3.01081706e-02f, 2.19462618e-01f, 1.11191437e-01f, -6.41693324e-02f, 1.61922276e-01f, 2.72234023e-01f, -2.30445549e-01f,
  1.57213598e-01f, 4.15518358e-02f, -1.72251388e-02f, 8.37546289e-02f, 1.70109998e-02f, -2.40920344e-03f, -1.98937416e-01f, -2.58006930e-01f, 3.95801775e-02f, 4.60022017e-02f,
  4.41159718e-02f, -9.43828002e-02f, -6.32775947e-02f, 2.69137353e-01f, -4.16769832e-02f, -6.06883168e-02f, 9.88719538e-02f, -3.87089849e-02f, 6.45496771e-02f, 8.18818733e-02f,
  1.55717239e-01f, -5.18940985e-02f, 9.38740969e-02f, -1.40712736e-02f, -1.33837432e-01f, 1.98308706e-01f, -1.01227790e-01f, 1.76410362e-01f, -2.22003981e-01f, 2.10415483e-01f,
  1.33147255e-01f, 1.04878940e-01f, -1.24261841e-01f, 1.44652650e-01f, -1.80435047e-01f, -3.05867374e-01f, -1.61489293e-01f, -2.06765309e-02f, -2.22908184e-01f, 2.66365223e-02f,
  1.71967193e-01f, 5.82496542e-03f, 4.51449789e-02f, -1.06199384e-01f, 2.06638604e-01f, -4.65915129e-02f, -2.43783996e-01f, -2.17216060e-01f, 2.47325048e-01f, 8.33742768e-02f,
  -1.03451103e-01f, 9.12516266e-02f, 6.13503717e-02f, -8.96046162e-02f, 1.33666053e-01f, 2.16220334e-01f, -5.18808626e-02f, -7.52904341e-02f, 3.78715575e-01f, -1.25791818e-01f,
  1.66037485e-01f, 2.09742617e-02f, 3.96909118e-02f, -6.67211860e-02f, 2.09823057e-01f, 2.52201874e-02f, 1.60886779e-01f, 1.43872276e-02f, -1.73748940e-01f, 9.16399658e-02f,
  -1.01061158e-01f, -5.03970385e-02f, 7.79365450e-02f, 7.10765794e-02f, -1.25068292e-01f, -1.55229077e-01f, 7.87063017e-02f, -1.63899720e-01f, -7.83588365e-02f, 1.36111885e-01f,
  -3.23763251e-01f, -6.22612536e-02f, 7.91622624e-02f, -7.23287463e-02f, -8.59586373e-02f, 3.17934267e-02f, 2.38377288e-01f, -4.06780653e-02f, 3.48702967e-01f, -5.67317046e-02f,
  1.90755576e-01f, 2.51633171e-02f, 9.00999159e-02f, 4.23315167e-02f, -8.24737474e-02f, 1.93073586e-01f, 1.35668695e-01f, 7.72890970e-02f, 9.02258083e-02f, 9.90761369e-02f,
  4.40374821e-01f, 6.06595762e-02f, 4.45025951e-01f, 1.05993278e-01f, 2.41183892e-01f, 2.69449204e-01f, -1.07869431e-01f, 1.90329954e-01f, -5.35683855e-02f, -3.75480950e-01f,
  1.40224313e-02f, 2.67158449e-01f, 1.84389919e-01f, 2.89699852e-01f, 6.71562776e-02f, 5.10983765e-02f, -1.74828306e-01f, 1.27756462e-01f, -3.30887437e-02f, 5.94232306e-02f,
  -1.64073020e-01f, 1.69718698e-01f, 1.21468110e-02f, 1.20012932e-01f, -1.18184261e-01f, -1.67317018e-01f, -1.46559641e-01f, 4.22046222e-02f, 1.12767473e-01f, -3.10339123e-01f,
  3.62253934e-02f, -1.25736684e-01f, 7.65163004e-02f, 1.77507192e-01f, 2.06550539e-01f, 8.75970647e-02f, 5.37950136e-02f, -3.90925370e-02f, 1.06086746e-01f, 1.80779248e-01f,
  1.52202412e-01f, -1.55984852e-02f, -3.23093794e-02f, 2.85897732e-01f, -3.33539620e-02f, -3.38999624e-03f, 8.09014365e-02f, -2.41143212e-01f, 1.09161668e-01f, -2.40750819e-01f,
  -2.58654624e-01f, -2.28093907e-01f, 1.97849065e-01f, 9.61076543e-02f, 3.85297574e-02f, -3.17516364e-03f, -1.54558674e-01f, -1.53554142e-01f, 1.55431807e-01f, -5.38788326e-02f,
  -7.34820440e-02f, 8.69660005e-02f, -1.04148582e-01f, 1.89927801e-01f, 1.99807845e-02f, -1.52400993e-02f, -9.42143723e-02f, -6.51126876e-02f, 1.44575741e-02f, -1.38659224e-01f,
  -5.82511462e-02f, -2.36044660e-01f, 8.60574320e-02f, 3.17872554e-01f, -2.62109905e-01f, 9.05153826e-02f, -1.32261947e-01f, 6.06985278e-02f, -2.20567659e-01f, -1.10552885e-01f,
  -8.02650396e-03f, -1.12441823e-01f, -1.93287283e-02f, 6.68149590e-02f, 1.45099998e-01f, 3.79904844e-02f, 1.16471007e-01f, 1.04866341e-01f, 9.27772094e-03f, 1.88173160e-01f,
  2.12228239e-01f, -4.00979929e-02f, 5.66969812e-02f, 2.41890177e-01f, 6.20271936e-02f, 9.64076221e-02f, -1.48622647e-01f, -8.13000277e-02f, -2.05252185e-01f, -1.84403062e-01f,
  -5.66022694e-02f, 1.79905057e-01f, -1.02924414e-01f, -1.66778237e-01f, -5.71860559e-02f, 5.05514480e-02f, -7.26157799e-02f, -2.18873054e-01f, 1.41287625e-01f, 3.79230566e-02f,
  9.86899361e-02f, 6.57876506e-02f, -1.55030936e-01f, 6.32193312e-02f, -1.84473470e-02f, 2.33389080e-01f, 1.97418988e-01f, 5.96148148e-02f, 1.05674274e-01f, -8.65444690e-02f,
  -2.39444599e-01f, 1.21601053e-01f, 7.23418444e-02f, -7.37047270e-02f, 2.21596789e-02f, 6.27932511e-03f, -9.97737795e-02f, -7.94247314e-02f, 7.27850273e-02f, 1.34484053e-01f,
  -8.42992812e-02f, 2.61058927e-01f, 3.99309099e-01f, 4.67727834e-04f, -1.25725895e-01f, 1.63309917e-01f, 1.54044092e-01f, 2.69220769e-01f, -3.24711539e-02f, 2.48106085e-02f,
  1.39194235e-01f, 1.39013901e-01f, -6.36457372e-03f, 9.13106650e-02f, -8.44426162e-04f, -1.38622941e-02f, 1.60773218e-01f, -2.92562217e-01f, -2.33675122e-01f, -1.84413716e-02f,
  -1.20749056e-01f, -5.94841056e-02f, 1.85511798e-01f, 1.55167699e-01f, -1.39001161e-01f, -9.19904858e-02f, 5.47999777e-02f, -1.03031732e-01f, 2.51573473e-01f, -1.39836773e-01f,
  -1.63056806e-01f, -1.00367449e-01f, 1.01599917e-02f, -8.44787583e-02f, 1.14316411e-01f, 1.48312658e-01f, 2.90406961e-02f, 1.28182257e-02f, 2.19651565e-01f, -1.11487001e-01f,
  5.09155244e-02f, 1.95756555e-01f, 9.05571580e-02f, -3.58616076e-02f, 1.94343463e-01f, -1.01768859e-01f, 1.32608473e-01f, -4.00574058e-02f, -9.22537744e-02f, -1.42408162e-01f,
  -4.97600883e-02f, -9.90216807e-02f, 9.16335285e-02f, 4.06563021e-02f, 2.92533427e-01f, -5.25559187e-02f, 8.82164016e-02f, 8.80536735e-02f, 1.69726219e-02f, 1.05049655e-01f,
  -9.48077347e-03f, 1.84641704e-02f, 6.32367656e-02f, 2.25499511e-01f, 1.40728101e-01f, 5.92671745e-02f, 2.42909864e-01f, -1.86284259e-01f, -1.41243026e-01f, 1.76067036e-02f,
  1.46929160e-01f, 2.42810413e-01f, -2.64546037e-01f, 1.81474790e-01f, 7.90609885e-03f, 1.00791469e-01f, -2.33970642e-01f, -3.80209416e-01f, -8.27493742e-02f, -3.97012336e-03f,
  -1.93321910e-02f, 1.65792957e-01f, -9.93575007e-02f, 1.39112353e-01f, 3.45962018e-01f, 7.24857077e-02f, 2.65804157e-02f, 1.59947976e-01f, -8.71228948e-02f, -1.15425311e-01f,
  -1.99538167e-03f, -1.53113464e-02f, 7.80517012e-02f, 2.03749970e-01f, -1.43053472e-01f, 3.06733735e-02f, -8.56908932e-02f, -8.93180668e-02f, 2.58733183e-01f, 1.68726161e-01f,
  8.53667781e-02f, 4.34533544e-02f, -6.04377426e-02f, -8.37831274e-02f, 2.99354076e-01f, 7.09561333e-02f, 1.86936617e-01f, -1.33895963e-01f, 6.18876368e-02f, 1.53667927e-01f,
  -1.29971951e-01f, 1.68096751e-01f, 5.53796031e-02f, 5.68378307e-02f, -7.14410990e-02f, 9.26605761e-02f, 5.97302243e-03f, 5.04710898e-02f, 3.10533959e-02f, -1.59068286e-01f,
  -1.91405974e-02f, 1.73842967e-01f, -3.72935930e-04f, 7.00451657e-02f, -1.21973962e-01f, -9.24211815e-02f, -8.72835740e-02f, -7.52231702e-02f, -2.37777874e-01f, -1.08240820e-01f,
  -4.33030203e-02f, -1.31536697e-04f, -7.09300786e-02f, 1.78728476e-01f, 5.86134791e-02f, -5.85516989e-02f, -1.10235110e-01f, -2.41613343e-01f, 4.25112247e-02f, 1.53777137e-01f,
  -1.05506971e-01f, -1.42623454e-01f, -8.44851136e-03f, -1.37830585e-01f, 2.30170429e-01f, 1.55856103e-01f, 8.40720837e-04f, 1.22609347e-01f, 1.39193073e-01f, 1.91191241e-01f,
  1.44626573e-01f, 2.28678122e-01f, -1.53984278e-02f, -9.67542753e-02f, 2.37634599e-01f, 1.76271826e-01f, -4.09196131e-02f, 7.05556199e-02f, -2.33608201e-01f, -1.27031267e-01f,
  -1.58221751e-01f, 5.60558550e-02f, 1.82276651e-01f, 2.30102956e-01f, 5.75094298e-02f, 6.04204368e-04f, 2.31180508e-02f, -5.21063097e-02f, 7.64642470e-03f, 1.59235492e-01f,
  -1.26645759e-01f, 3.68498750e-02f, -1.73518971e-01f, 4.92397696e-02f, 2.80438643e-02f, 6.00061156e-02f, 1.58506691e-01f, 1.44118443e-01f, 4.47729137e-03f, -5.18583357e-02f,
  6.84361160e-02f, 1.68628544e-01f, -2.06123427e-01f, 5.77240922e-02f, -1.55348346e-01f, 8.21311846e-02f, 1.14038456e-02f, 1.35261223e-01f, 1.06600583e-01f, -2.07100824e-01f,
  -2.86540717e-01f, -1.56306565e-01f, -5.75783923e-02f, 1.25116929e-01f, 1.10767514e-01f, -4.41922769e-02f, 5.21030463e-02f, -2.78563082e-01f, 8.24999809e-02f, -2.53096223e-01f,
  2.34197117e-02f, 7.27749914e-02f, -1.54710516e-01f, -2.87403494e-01f, -3.64456177e-02f, -6.72560632e-02f, 1.68220013e-01f, -6.68646619e-02f, -3.69969346e-02f, -3.41918141e-01f,
  4.94647846e-02f, -2.57875472e-01f, -3.90700921e-02f, -3.21770817e-01f, 1.62089571e-01f, -1.83879018e-01f, 3.96771803e-02f, 2.64039904e-01f, 3.21513236e-01f, 1.34964243e-01f,
  1.03732571e-01f, 5.76787964e-02f, 1.37013480e-01f, -2.00226203e-01f, -1.39245391e-01f, -8.72017965e-02f, -4.22209293e-01f, -2.84249604e-01f, -1.18123084e-01f, -1.87962830e-01f,
  -1.13521315e-01f, -2.25257203e-01f, -7.12942034e-02f, -5.37810437e-02f, -4.32443798e-01f, 2.40991309e-01f, 1.00382149e-01f, -1.91668898e-01f, -1.02205165e-02f, -1.27288863e-01f,
  2.49916986e-01f, -2.61300541e-02f, -3.64067964e-02f, -8.82812664e-02f, 1.55001745e-01f, -4.29256976e-01f, 2.42993191e-01f, 2.25671637e-03f, 1.93081886e-01f, 8.10721293e-02f,
  2.69696414e-01f, 9.71233845e-02f, 2.43187815e-01f, 2.39491805e-01f, 3.27448130e-01f, 1.55877611e-02f, -1.55636007e-02f, 2.70237088e-01f, -5.08091301e-02f, -1.30905420e-01f,
  4.77814227e-02f, 2.46306006e-02f, 3.50885093e-01f, -1.22792944e-01f, -2.75022238e-01f, 7.18782544e-02f, 1.16279721e-01f, 8.87852982e-02f, -1.36889532e-01f, 2.42316261e-01f,
  -6.82666525e-02f, -2.60730833e-02f, -5.25890524e-03f, 3.64901125e-02f, -2.65940964e-01f, 2.32242599e-01f, -3.47631909e-02f, 1.22529708e-01f, 5.22104055e-02f, 2.14174941e-01f,
  1.09993830e-01f, 3.96744832e-02f, -1.84998825e-01f, -2.54821740e-02f, 1.50214881e-01f, 6.19189925e-02f, -1.88725572e-02f, -1.48274660e-01f, 1.44590423e-01f, 4.15607058e-02f,
  -1.47894695e-01f, 8.89671445e-02f, -5.88390231e-02f, -3.06087285e-02f, 1.40150517e-01f, 2.42987815e-02f, -9.23607871e-02f, 4.70741689e-02f, 2.09021136e-01f, -4.55089584e-02f,
  1.36927232e-01f, -1.00827385e-02f, 9.39361472e-03f, -6.33781031e-02f, 8.48211795e-02f, 5.88169694e-02f, 2.13264540e-01f, 1.96027115e-01f, 3.88836190e-02f, 3.55733097e-01f,
  -1.13023363e-01f, 2.01484319e-02f, -1.11786395e-01f, -1.05295107e-01f, -2.48059556e-01f, 1.78536564e-01f, -2.33759880e-01f, -2.64432300e-02f, -2.86622643e-01f, -2.57695038e-02f,
  -2.45181859e-01f, -9.36476439e-02f, 6.67557642e-02f, -1.17393946e-02f, -1.59433000e-02f, 4.52767387e-02f, 6.02870323e-02f, -4.07510474e-02f, -6.85486943e-02f, -1.87455729e-01f,
  -7.80869424e-02f, 2.76825517e-01f, -1.33857653e-01f, -6.23901375e-02f, 8.19950774e-02f, -1.34836912e-01f, 1.31407022e-01f, 1.37792379e-01f, -1.37421861e-01f, 6.88181594e-02f,
  3.22112530e-01f, 6.55068606e-02f, 8.56107622e-02f, 1.22987792e-01f, 2.06210259e-02f, 4.44980338e-02f, 2.00312436e-01f, -1.85317416e-02f, 6.75497809e-03f, -5.34268767e-02f,
  -9.16748717e-02f, 6.79965839e-02f, -2.05461845e-01f, -2.06956163e-01f, -1.28062114e-01f, -7.86414221e-02f, 2.71507744e-02f, -8.94298851e-02f, 5.23168780e-02f, -1.69078365e-01f,
  -6.36989400e-02f, 4.87575568e-02f, -2.01550111e-01f, 7.37275258e-02f, -1.47927403e-01f, -7.95319304e-02f, 4.63602729e-02f, 4.25593294e-02f, 7.94636086e-02f, 4.57942821e-02f,
  1.23011060e-01f, -5.47079295e-02f, 1.60895169e-01f, 1.60856187e-01f, 1.64156377e-01f, 6.15980923e-02f, 1.84348032e-01f, 1.48695618e-01f, 2.01331735e-01f, 1.73616335e-01f,
  3.31663452e-02f, 1.41324461e-01f, 1.67928591e-01f, 5.71804270e-02f, -1.38391271e-01f, 8.45834613e-02f, -3.46677333e-01f, -2.93782558e-02f, -2.06374750e-01f, -2.56372839e-01f,
  8.60766917e-02f, 1.69576611e-02f, -5.26314117e-02f, 1.10680565e-01f, 3.18853185e-02f, -3.02708983e-01f, 1.12187162e-01f, -1.09406531e-01f, 1.53252274e-01f, -6.95365071e-02f,
  -9.77176875e-02f, -1.08086139e-01f, -1.32672533e-01f, -1.55169636e-01f, -2.88859338e-01f, 6.13964908e-02f, -2.01421618e-01f, 2.37650305e-01f, -9.31087881e-03f, 1.15604781e-01f,
  -2.48579770e-01f, 5.05353548e-02f, 6.07910976e-02f, 2.29626417e-01f, 2.57525831e-01f, -3.87114465e-01f, -1.77362487e-01f, -9.69533622e-02f, -1.85308427e-01f, 1.95837021e-01f,
  2.38295600e-01f, -3.05571526e-01f, 3.27762723e-01f, 1.05038039e-01f, 3.92774045e-02f, 1.78735033e-02f, 1.83794871e-01f, -2.51930393e-02f, 1.76327825e-01f, 1.84434369e-01f,
  4.05559726e-02f, 1.86073691e-01f, -9.31172371e-02f, -3.33751403e-02f, 5.41843846e-02f, -1.77168265e-01f, -1.26040623e-01f, -7.23101422e-02f, -8.85870028e-03f, 5.37851639e-03f,
  2.48351663e-01f, 7.00434968e-02f, -1.35555387e-01f, 5.06649055e-02f, -2.02336773e-01f, -5.47321662e-02f, 1.30580619e-01f, 2.90437881e-02f, 4.65122387e-02f, -2.69682586e-01f,
  2.63783354e-02f, -2.10037485e-01f, -1.12004355e-01f, -8.90655294e-02f, 2.22453121e-02f, 6.31154701e-02f, -3.33467163e-02f, -1.12413645e-01f, -1.66734010e-01f, -1.86011493e-01f,
  1.15662284e-01f, -2.35061079e-01f, 5.34744523e-02f, -1.80750638e-01f, 6.46669120e-02f, -1.09792113e-01f, 7.93931410e-02f, -2.97268927e-01f, 1.07665583e-01f, -3.89282197e-01f,
  2.95100749e-01f, 9.66852382e-02f, 2.70779788e-01f, 6.70059696e-02f, 8.74557197e-02f, 1.48160458e-01f, 2.00467825e-01f, 5.07279783e-02f, 1.02360966e-03f, -7.65242800e-03f,
  -3.76214594e-01f, -4.20661509e-01f, -2.79399693e-01f, -3.46335649e-01f, 2.38565877e-01f, -1.84719026e-01f, -2.18859747e-01f, -1.55304432e-01f, 1.22060947e-01f, 1.35564566e-01f,
  -1.67649522e-01f, 2.32378632e-01f, 1.20902076e-01f, -1.30555749e-01f, 2.27688432e-01f, -1.03532635e-01f, 4.66453694e-02f, 1.93483084e-01f, -2.53444701e-01f, -1.27959207e-01f,
  1.11273132e-01f, -2.66733348e-01f, -1.47775844e-01f, 3.88034470e-02f, 5.99620910e-03f, 3.31773125e-02f, 7.60112628e-02f, 2.13876106e-02f, 1.98999450e-01f, 1.92430750e-01f,
  -2.27457941e-01f, -5.96650168e-02f, 2.82864749e-01f, 7.92742427e-03f, 4.71535102e-02f, 2.81603098e-01f, 1.32735431e-01f, 2.59101450e-01f, -2.60392398e-01f, 1.79350376e-01f,
  1.02351978e-01f, 1.03552870e-01f, -4.06409539e-02f, -1.07341282e-01f, 1.72842845e-01f, 5.06794713e-02f, 2.57309470e-02f, 1.59855008e-01f, 4.51438725e-02f, -1.70754656e-01f,
  -3.51348877e-01f, 5.84921502e-02f, -2.37390563e-01f, 6.31342083e-03f, 4.49979827e-02f, -3.26352455e-02f, -1.46521151e-01f, 1.38231009e-01f, 3.87612507e-02f, -4.02873335e-03f,
  1.85586110e-01f, -1.30254507e-01f, 2.03750748e-02f, -1.18152685e-01f, 1.43360466e-01f, 1.69259280e-01f, -6.27052188e-02f, -1.07468069e-01f, -2.11866617e-01f, -1.07288003e-01f,
  -4.22131009e-02f, 4.41285037e-03f, -1.65551946e-01f, 5.01580164e-02f, -2.09207032e-02f, 2.34085768e-02f, 4.65733781e-02f, 2.10348498e-02f, 1.59053445e-01f, -2.28245109e-02f,
  5.09554036e-02f, -2.65163749e-01f, 2.55751591e-02f, 1.59961715e-01f, 7.72424042e-02f, -8.44336152e-02f, -1.94509216e-02f, 4.00005355e-02f, 4.57848683e-02f, -7.81866815e-03f,
  -7.33291060e-02f, 1.69610545e-01f, 7.88965374e-02f, -1.34093881e-01f, -1.33003578e-01f, 8.59640837e-02f, 1.04007550e-01f, 3.75273138e-01f, 1.85474083e-01f, 4.67727631e-02f,
  -1.24485776e-01f, 1.03365235e-01f, 1.46386623e-01f, -1.08328737e-01f, -2.05737472e-01f, -8.31553489e-02f, 2.48678923e-01f, 1.82400018e-01f, -1.58692822e-02f, 1.10761538e-01f,
  -1.64707780e-01f, 1.21715054e-01f, 1.89182684e-01f, -1.86241984e-01f, -2.11100608e-01f, 1.05652072e-01f, 9.06171724e-02f, -3.17236483e-02f, 2.13635579e-01f, 9.79317129e-02f,
  -8.69236141e-02f, 5.80976605e-02f, -1.00094210e-02f, 1.27608195e-01f, 2.13978887e-01f, -9.31284130e-02f, 1.54196694e-02f, -1.87640995e-01f, 1.12245262e-01f, -3.22072580e-02f,
  2.15911940e-02f, 9.18561742e-02f, 5.68951704e-02f, 1.92151487e-01f, 1.16870858e-01f, -2.21164525e-01f, -9.06513929e-02f, 3.29771250e-01f, -2.17382461e-02f, 7.54062161e-02f,
  9.16149989e-02f, -2.23800853e-01f, 9.42205787e-02f, 9.59708765e-02f, 1.17292210e-01f, 2.59135887e-02f, 2.47464329e-01f, 1.38819262e-01f, 8.22014585e-02f, 2.07231089e-01f,
  -2.18032277e-03f, -2.70748790e-02f, -1.08707219e-01f, 2.24113554e-01f, -8.03743824e-02f, 7.89948255e-02f, 5.32600619e-02f, 4.91320305e-02f, 8.45331773e-02f, 8.71964693e-02f,
  -1.80518612e-01f, -1.50579005e-01f, -2.06089228e-01f, 3.90988708e-01f, 2.23984480e-01f, -2.63096690e-02f, -3.71746778e-01f, 1.86001629e-01f, 2.16444790e-01f, -2.04614438e-02f,
  -2.56760865e-01f, -2.27546975e-01f, 1.68794245e-01f, -5.68504781e-02f, 1.42002419e-01f, 2.84621865e-01f, 4.12687361e-02f, -7.83358812e-02f, -3.01433774e-03f, -1.42308816e-01f,
  -3.08919013e-01f, -1.47990212e-01f, 4.95463796e-02f, -3.12419832e-01f, -2.65635159e-02f, 1.69687912e-01f, -2.82070637e-02f, -1.90313995e-01f, -4.06271853e-02f, 3.79719250e-02f,
  1.48896798e-01f, -1.60896003e-01f, 1.26255274e-01f, 2.53361076e-01f, -3.50325406e-01f, -4.29406822e-01f, -1.47463188e-01f, -3.46560389e-01f, -7.58770853e-02f, 2.05088720e-01f,
  7.60452822e-02f, 4.59264852e-02f, -1.22436412e-01f, 4.00045030e-02f, 7.93348774e-02f, 1.65679306e-01f, 1.80796489e-01f, -2.53682643e-01f, 2.49198258e-01f, -1.97229773e-01f,
  -1.59117952e-02f, -8.77155587e-02f, -1.09647855e-01f, -1.82748154e-01f, 2.14127719e-01f, -1.88708026e-02f, 1.30339712e-01f, 5.00913747e-02f, 2.29234412e-01f, 6.82412237e-02f,
  1.76308215e-01f, 1.73688829e-01f, 3.09782147e-01f, 5.94142079e-02f, 5.83018102e-02f, 1.63683519e-01f, 7.81001449e-02f, -4.69044670e-02f, -5.63359670e-02f, 2.00425893e-01f,
  1.30258843e-01f, -2.28725821e-01f, -2.10207328e-01f, 6.75373524e-03f, 1.76720172e-01f, 2.17767715e-01f, -1.21937796e-01f, 1.50018707e-01f, -7.26620108e-02f, 8.44866484e-02f,
  9.49525908e-02f, 1.12129457e-01f, -2.16802657e-01f, 2.05005348e-01f, 1.32553115e-01f, 1.31462425e-01f, -1.70159385e-01f, 1.52216494e-01f, -8.08823332e-02f, 5.22841737e-02f,
  9.98855084e-02f, -1.95434317e-01f, -1.38802707e-01f, -2.05546468e-01f, 8.46146047e-03f, 3.65568674e-03f, 9.68934596e-02f, 8.73515084e-02f, -1.46034791e-03f, -1.26823103e-02f,
  8.34518299e-02f, 1.73337683e-01f, 1.92814156e-01f, 1.08695835e-01f, 7.25425035e-02f, 1.63819551e-01f, 9.90374684e-02f, -3.01793516e-02f, 2.08801627e-02f, -1.99558377e-01f,
  1.49476215e-01f, -2.21781470e-02f, -5.82550913e-02f, -2.09548250e-01f, 2.43686423e-01f, 5.22137433e-02f, -7.43313208e-02f, 2.73894042e-01f, -2.64276832e-01f, 1.45202190e-01f,
  6.40271306e-02f, -1.49540752e-01f, 6.67667612e-02f, -9.70862713e-03f, 1.30951181e-01f, -2.35158607e-01f, -4.52191308e-02f, 1.53419711e-02f, 2.26254955e-01f, 2.43224695e-01f,
  4.84679401e-01f, 6.99974000e-02f, -7.76137412e-02f, 2.30774701e-01f, -5.38872778e-02f, -6.77466169e-02f, 1.53195336e-01f, 1.28780678e-01f, 2.24790256e-02f, -1.08187124e-01f,
  1.29377201e-01f, 3.92450839e-02f, -1.52580559e-01f, -2.76558124e-03f, 2.50972271e-01f, -2.96367288e-01f, -2.17380524e-01f, -5.68541139e-03f, 7.39464685e-02f, 4.73706536e-02f,
  3.09550107e-01f, -2.32066512e-01f, -2.61487961e-01f, 4.78786901e-02f, 1.36754483e-01f, -3.76664586e-02f, 2.56493956e-01f, -1.50588825e-01f, 3.34169641e-02f, 6.37885630e-02f,
  -3.10769472e-02f, -6.85279164e-03f, 5.23750670e-02f, 1.44838080e-01f, -5.34618273e-02f, 1.36649370e-01f, 9.43576619e-02f, -1.76198006e-01f, -4.12521474e-02f, 1.85045406e-01f,
  -1.67774763e-02f, -7.68879950e-02f, 2.52582967e-01f, -8.74972045e-02f, -1.31796589e-02f, -1.74932033e-01f, 8.53765234e-02f, -1.60188302e-02f, -3.36307064e-02f, 5.09875007e-02f,
  7.74424348e-04f, -5.60348332e-02f, 1.14839152e-01f, -5.64338602e-02f, -1.84882566e-01f, 1.93269506e-01f, -8.81995261e-02f, -2.42227033e-01f, -1.98579252e-01f, -8.54603201e-02f,
  -1.02014817e-01f, -2.83808578e-02f, -4.63214666e-02f, 6.10861927e-02f, 9.10349190e-02f, -1.08248875e-01f, -4.44630021e-03f, 4.45555598e-01f, -2.46955566e-02f, -2.80011922e-01f,
  1.42877027e-01f, -1.64240777e-01f, 1.67525291e-01f, 5.21390736e-02f, 8.26350227e-02f, 2.71940939e-02f, 1.20402155e-02f, 1.65540967e-02f, 2.22675413e-01f, 6.93885833e-02f,
  -6.06485493e-02f, 2.24699378e-01f, -1.65089950e-01f, 9.90780145e-02f, -2.87293326e-02f, -1.11437790e-01f, -2.64193475e-01f, -1.95050817e-02f, 3.45569812e-02f, -3.03820491e-01f,
  1.49054214e-01f, -5.31149209e-02f, 9.51852649e-02f, -1.25881493e-01f, -6.74693361e-02f, -5.58163151e-02f, 1.80974111e-01f, 1.26572400e-01f, 6.91723526e-02f, 2.16137126e-01f,
  1.64138861e-02f, -3.99193279e-02f, -1.54517749e-02f, -2.44158618e-02f, -2.38182068e-01f, -2.57763360e-02f, 1.13155924e-01f, -1.37437418e-01f, 1.34304985e-01f, 4.29823473e-02f,
  -6.64974824e-02f, 3.35915238e-02f, -1.09443560e-01f, 1.32310688e-01f, 2.71495432e-02f, -6.66600913e-02f, 2.08485380e-01f, -1.37263164e-01f, 1.96882412e-01f, 2.29468733e-01f,
  1.35148689e-01f, 7.96441138e-02f, 1.38483644e-01f, 2.47143090e-01f, 2.54103690e-01f, 2.56791443e-01f, 1.48662925e-01f, 7.79180303e-02f, -4.45663363e-01f, 2.92310059e-01f,
  3.35147321e-01f, 5.92666529e-02f, -4.72328477e-02f, -5.90552054e-02f, 1.96452215e-01f, 1.12789199e-01f, -7.94478655e-02f, -1.10216103e-01f, 1.36704326e-01f, 2.55600680e-02f,
  1.03645325e-01f, 5.38169742e-02f, -3.47506255e-01f, 7.03324843e-03f, -9.02472362e-02f, -2.00962136e-03f, -3.04261178e-01f, 7.58386925e-02f, -1.88471407e-01f, 1.19480811e-01f,
  6.87657064e-03f, 7.57471174e-02f, -2.58463293e-01f, -1.74291402e-01f, -2.51182169e-01f, 6.62402855e-03f, 2.43084654e-01f, -3.84895653e-01f, 3.27783883e-01f, 2.34955952e-01f,
  -1.28018230e-01f, -4.91217263e-02f, 4.53621708e-02f, 1.37440875e-01f, 7.81902671e-02f, 2.49361724e-01f, -6.52794316e-02f, 9.34113190e-02f, 1.82854023e-03f, 8.60150233e-02f,
  -2.04085603e-01f, 2.71374851e-01f, 1.33345112e-01f, -1.12376519e-01f, 1.35425687e-01f, -7.66943470e-02f, -1.11153275e-01f, 1.75440326e-01f, -1.04990333e-01f, 1.01091854e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -4.10632305e-02f, 1.46705836e-01f, 1.06073007e-01f, 9.65488702e-02f, 3.88070494e-02f, -5.91648417e-03f, 4.39325534e-02f, -8.96981135e-02f, 7.48120015e-03f, 4.98194306e-04f,
  -1.32253870e-01f, 4.87169996e-02f, 5.81166856e-02f, 1.68163404e-01f, 4.89651673e-02f, 1.45375216e-02f, 1.78237259e-02f, 3.88234630e-02f, 8.13334137e-02f, 5.52311987e-02f,
  1.76498920e-01f, 1.54323168e-02f, -6.17235824e-02f, 1.52467579e-01f, -9.40011218e-02f, -1.88287478e-02f, 1.40823185e-01f, -1.88559949e-01f, 2.03535795e-01f, 1.23379178e-01f,
  -1.25543028e-01f, 8.72752741e-02f, 7.93235451e-02f, 7.45077506e-02f, 6.96120486e-02f, 1.21395588e-01f, 9.93012935e-02f, -6.68214634e-02f, -2.06739064e-02f, 2.22199801e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.09629603e-02f, 1.34092897e-01f, -1.16267242e-02f, -2.48547848e-02f, 9.34378989e-03f, 1.16667904e-01f, 1.01692550e-01f, 7.01007608e-04f, -4.28294390e-03f, 1.44933751e-02f,
  -1.39599070e-01f, -5.71147650e-02f, -8.31765831e-02f, -6.55973405e-02f, -2.27117864e-03f, -7.16799498e-03f, 7.54126012e-02f, 6.22915253e-02f, 1.31969333e-01f, 9.40881744e-02f,
  -3.57744955e-02f, -7.08273128e-02f, 6.28978759e-02f, 6.50862083e-02f, -5.29085435e-02f, -1.33690894e-01f, -2.91569419e-02f, 2.31045876e-02f, 3.44180726e-02f, 7.73112476e-02f,
  1.36669442e-01f, -3.35802324e-02f, -3.82975303e-03f, 1.90265387e-01f, -4.04301845e-02f, 8.71207491e-02f, -2.73473173e-01f, -1.02106400e-01f, -1.90037012e-01f, 2.58215237e-02f,
  -6.34998083e-03f, -3.47262761e-03f, 7.10647553e-02f, 2.17744689e-02f, -2.11117402e-01f, -1.60835460e-02f, -7.99046755e-02f, 2.54884005e-01f, -6.16664477e-02f, 9.83206630e-02f,
  -8.47625509e-02f, -5.15840352e-02f, -1.60175979e-01f, 4.70615290e-02f, 2.58034132e-02f, -1.78702325e-01f, -2.44677007e-01f, 9.28913206e-02f, 8.00424442e-03f, -1.40438732e-02f,
  1.41557120e-02f, 6.73969239e-02f, 2.30162844e-01f, 1.83636509e-02f, -1.00183979e-01f, -2.55197823e-01f, -8.67695063e-02f, 8.62724930e-02f, -2.54712522e-01f, -2.00801671e-01f,
  -1.91998675e-01f, 1.37126207e-01f, -1.24620892e-01f, -1.35656089e-01f, 1.10077821e-01f, -2.53325105e-02f, 6.08211905e-02f, -4.47917655e-02f, 1.61893383e-01f, 2.91229784e-01f,
  -2.07854718e-01f, 5.11254407e-02f, -2.28155702e-01f, -1.02482229e-01f, -1.53817043e-01f, -2.03325242e-01f, 2.60730773e-01f, -1.14617877e-01f, 1.31915003e-01f, 2.21124068e-02f,
  -2.00746343e-01f, 1.66533962e-02f, -7.53687844e-02f, 1.14523150e-01f, 1.21214781e-02f, -1.75582141e-01f, 5.30295894e-02f, -2.96744294e-02f, 2.73015589e-01f, 7.41701648e-02f,
  5.97192124e-02f, -8.35208744e-02f, -5.95528930e-02f, -1.30222872e-01f, 4.59268456e-03f, -8.24380443e-02f, 3.18808667e-02f, -1.00877605e-01f, -1.40137738e-02f, 7.51307905e-02f,
  -1.27660692e-01f, 1.64064854e-01f, -9.63086784e-02f, 4.66173701e-02f, 1.75625190e-01f, -4.64443229e-02f, -8.35029185e-02f, 9.56759602e-03f, -1.02667227e-01f, -6.67232201e-02f,
  -1.97960287e-02f, -9.51951668e-02f, 1.94663301e-01f, -5.75036593e-02f, 6.93947375e-02f, -5.29851951e-02f, 1.54709056e-01f, -6.55915886e-02f, -1.16531283e-01f, 1.45655558e-01f,
  8.88460781e-03f, -1.33839354e-01f, 8.09649453e-02f, 2.39709690e-01f, 3.57912540e-01f, -1.24686193e-02f, -1.53990136e-02f, -5.56622706e-02f, 6.64584488e-02f, 1.14589008e-02f,
  2.66051263e-01f, 2.53012720e-02f, -2.58096177e-02f, 2.56895304e-01f, 4.54959227e-03f, 2.52870657e-02f, 7.22154528e-02f, 2.35977262e-01f, -1.18385024e-01f, 4.55668755e-02f,
  -2.11354613e-01f, -2.91876465e-01f, -5.85326515e-02f, 5.80688752e-03f, 4.70058881e-02f, -1.85356855e-01f, -8.95589441e-02f, -1.67276841e-02f, -3.29670422e-02f, -3.71602960e-02f,
  -1.61889464e-01f, 1.80885997e-02f, -1.03228591e-01f, 1.94788873e-01f, -1.73549905e-01f, 1.86139643e-02f, -7.29065910e-02f, -8.57132599e-02f, 1.55702550e-02f, 1.26356371e-02f,
  -9.48747527e-03f, 1.83906659e-01f, 4.68975753e-02f, -1.83372311e-02f, 5.28630912e-02f, 1.45138174e-01f, -1.85719520e-01f, -1.61049426e-01f, 1.07725784e-01f, -7.21943378e-02f,
  -2.79545784e-02f, -5.38302697e-02f, -4.29620259e-02f, -7.29041323e-02f, -2.69189745e-01f, 7.85026550e-02f, -5.53818643e-02f, 8.92274380e-02f, -5.37010953e-02f, -9.57101882e-02f,
  -1.07832640e-01f, 2.69636661e-01f, -4.39977050e-02f, 6.32624887e-03f, 2.84646273e-01f, 1.57132044e-01f, -1.21553401e-02f, 2.28269696e-01f, 1.56399131e-01f, 4.63176034e-02f,
  8.09694827e-02f, -1.74354985e-01f, -1.05662107e-01f, -4.10309844e-02f, 1.97807074e-01f, -3.25727582e-01f, 8.33158661e-03f, -2.02361003e-01f, 8.90149400e-02f, -1.13134801e-01f,
  3.77692915e-02f, -1.16168074e-01f, 1.37755483e-01f, 6.27183840e-02f, -1.74038455e-01f, -6.30098507e-02f, -3.91479135e-02f, -8.12658519e-02f, 4.78277318e-02f, -4.67430502e-02f,
  8.57415125e-02f, -1.15212463e-01f, -7.17964098e-02f, 1.48941562e-01f, -4.45830338e-02f, -1.42175853e-01f, 7.13942349e-02f, -9.33561847e-02f, -1.50750533e-01f, 1.82515964e-01f,
  -2.32591033e-02f, -1.97383091e-01f, -1.07588001e-01f, -1.35731384e-01f, -1.68302566e-01f, -2.44352490e-01f, 1.84042335e-01f, -2.01953724e-01f, 6.61756247e-02f, -1.92771759e-02f,
  -1.58036843e-01f, -4.52906489e-02f, -8.34837109e-02f, -1.13630563e-01f, 1.22846462e-01f, -1.49262687e-02f, -1.72038481e-01f, -3.40066776e-02f, -4.03777771e-02f, 3.34468298e-02f,
  -5.02115749e-02f, 8.51844549e-02f, -1.79547146e-02f, 3.79735604e-02f, 1.13098815e-01f, -2.74118096e-01f, -1.55303076e-01f, 1.70007080e-01f, 2.21268639e-01f, 4.90949815e-03f,
  3.19312662e-01f, -6.77213445e-02f, 1.58856541e-01f, -8.68291855e-02f, -8.25645460e-04f, -2.62370288e-01f, -8.79686624e-02f, -9.50459838e-02f, 1.20512545e-01f, -2.01418504e-01f,
  -5.82485050e-02f, -1.84514597e-01f, 8.75735097e-03f, -1.77534014e-01f, 6.66058585e-02f, 2.36688048e-01f, 1.19793192e-01f, 3.57544161e-02f, -2.37687767e-01f, -9.64395776e-02f,
  4.48049456e-02f, 2.20029160e-01f, 1.07452691e-01f, -1.09985150e-01f, -4.87781465e-02f, 1.63636114e-02f, -2.09477276e-01f, -7.34706447e-02f, -5.81072867e-02f, -1.10255808e-01f,
  -1.22521296e-01f, -2.73838453e-02f, -1.16880879e-01f, 6.68757409e-02f, 2.52717733e-02f, 1.92405179e-01f, 1.49853840e-01f, -7.89339542e-02f, -1.61549598e-01f, -8.54008123e-02f,
  1.67602092e-01f, -4.90477160e-02f, -1.57904446e-01f, -6.20415471e-02f, -2.47889850e-02f, -6.86341822e-02f, -5.41490167e-02f, -7.91119263e-02f, -1.79732844e-01f, -2.57138964e-02f,
  -2.22425088e-01f, 1.04139656e-01f, -5.02431393e-02f, 1.05083413e-01f, -9.49881822e-02f, 1.43129483e-01f, -8.19791928e-02f, 1.00426875e-01f, -9.47821513e-02f, 3.34135741e-02f,
  6.35449588e-02f, -1.33979335e-01f, 5.06642908e-02f, 4.74232659e-02f, -5.65107688e-02f, -6.08269423e-02f, -6.99405894e-02f, 2.42168102e-02f, 5.53008616e-02f, 2.82789357e-02f,
  1.44810662e-01f, -2.27306094e-02f, -2.42669895e-01f, 5.18706255e-02f, 4.59584855e-02f, 2.77536750e-01f, -2.26603411e-02f, 9.07999724e-02f, -2.79235523e-02f, 5.35843484e-02f,
  -1.41087472e-01f, 1.11333638e-01f, 6.32079318e-03f, -6.03491114e-03f, -1.01613760e-01f, -3.41196954e-02f, 1.27188310e-01f, -3.34481932e-02f, -6.60952702e-02f, -1.83584064e-01f,
  -6.45985454e-02f, -8.91069248e-02f, -1.08314883e-02f, -1.63814634e-01f, -9.23510790e-02f, -6.47478998e-02f, 2.42188036e-01f, 1.95753783e-01f, -2.70580109e-02f, 3.76397371e-02f,
  2.25072786e-01f, 4.96817864e-02f, 1.28610998e-01f, 5.97323850e-03f, -4.03842144e-03f, 1.02411747e-01f, 4.04510833e-02f, -1.05099447e-01f, 2.10124776e-01f, -8.80020112e-02f,
  4.86033857e-02f, 1.48630619e-01f, 4.97452803e-02f, -6.25237226e-02f, 1.22079335e-01f, 2.07324028e-01f, 8.62710550e-02f, -7.35012516e-02f, -9.27821547e-02f, -7.38715157e-02f,
  -1.37427732e-01f, -1.42159209e-01f, -2.34291986e-01f, 6.60217926e-02f, -4.72393110e-02f, 2.56919814e-03f, 5.36841108e-03f, -9.30017456e-02f, -7.45940208e-02f, -1.98380873e-01f,
  -2.68083721e-01f, -4.37705517e-02f, -1.74062207e-01f, 1.73783734e-01f, -2.24724308e-01f, 6.64762184e-02f, -1.46357313e-01f, 1.53388098e-01f, -1.75358608e-01f, -2.05731198e-01f,
  -9.10559110e-03f, 1.19932964e-01f, -1.22686680e-02f, -2.26951033e-01f, -1.72543779e-01f, -1.66179016e-01f, 2.50796735e-01f, 1.40706211e-01f, -1.05668217e-01f, -1.81865528e-01f,
  -1.08202696e-01f, 1.02607235e-01f, -9.96173248e-02f, 1.84301540e-01f, -7.56569486e-03f, -1.13340504e-02f, 1.21111572e-01f, 1.71867758e-01f, -2.56042462e-02f, 6.53180256e-02f,
  -9.09864828e-02f, -1.19682871e-01f, 1.05386347e-01f, -1.94789723e-01f, -1.66192129e-01f, 1.41058162e-01f, -5.89719974e-02f, -1.53341433e-02f, -1.50862232e-01f, -6.49027303e-02f,
  -7.92398378e-02f, 1.07475378e-01f, 1.11746788e-01f, 1.21253051e-01f, -1.36727169e-01f, -7.32906163e-02f, 1.49945607e-02f, 5.58684431e-02f, -3.42715979e-02f, -1.40642822e-01f,
  8.89699385e-02f, -7.55321458e-02f, 6.65087849e-02f, -1.61515042e-01f, 7.69434422e-02f, 9.85390767e-02f, 6.79445341e-02f, -6.06605820e-02f, 1.56495109e-01f, 2.34960276e-03f,
  -1.74505800e-01f, 3.99519056e-02f, -6.42685145e-02f, -1.41160026e-01f, 6.30980358e-02f, -3.60022597e-02f, -1.38430551e-01f, -2.31778160e-01f, 1.52836919e-01f, 6.68047890e-02f,
  3.03965807e-01f, -2.69612283e-01f, -9.53875408e-02f, 1.06153950e-01f, -5.67445345e-02f, -1.75139204e-01f, 1.02989510e-01f, 2.47302607e-01f, 4.40063253e-02f, -3.47987935e-02f,
  1.90909989e-02f, -3.05926800e-01f, 1.65692359e-01f, 1.17450826e-01f, 1.41865343e-01f, 2.29733763e-03f, -2.10981071e-01f, -1.48585036e-01f, -8.61040726e-02f, 1.75598025e-01f,
  8.09581131e-02f, 7.66526312e-02f, 1.33930087e-01f, 1.00280374e-01f, 4.36803699e-02f, 1.66421920e-01f, -5.88865541e-02f, 2.68820301e-02f, 1.00485310e-01f, 9.24620256e-02f,
  -2.10499633e-02f, 1.83448531e-02f, 8.61872435e-02f, -1.56513378e-02f, -3.13314097e-03f, -2.76916977e-02f, -8.10212567e-02f, 2.78606676e-02f, -4.06350191e-05f, 3.42004001e-02f,
  -1.50149018e-01f, -4.19968478e-02f, -8.97986889e-02f, 1.60862878e-01f, -1.18148156e-01f, 5.80108687e-02f, 7.11228848e-02f, 1.37153074e-01f, 6.94722086e-02f, -4.99235168e-02f,
  1.23825319e-01f, 9.75067317e-02f, -9.65580344e-02f, -1.91317111e-01f, -3.77200656e-02f, -1.78293158e-05f, 6.54965788e-02f, -1.19566314e-01f, -5.20701148e-02f, 1.90035328e-02f,
  -1.39014861e-02f, -1.99942291e-01f, 2.19989434e-01f, -1.06436357e-01f, -7.74602070e-02f, -1.77523181e-01f, 3.37669998e-02f, -1.86891127e-02f, 1.39398947e-01f, 5.22641605e-03f,
  -4.52707782e-02f, -1.11954361e-01f, -3.60309146e-02f, -2.64620572e-01f, -2.18621455e-02f, -1.01590775e-01f, -1.19458199e-01f, 2.72716433e-01f, -8.53722095e-02f, 1.13565288e-01f,
  7.84936547e-02f, -1.20529912e-01f, -1.53916106e-01f, -7.46796429e-02f, 9.87085328e-03f, -1.38195634e-01f, 2.41101142e-02f, 3.05073485e-02f, 8.37822109e-02f, 1.17699400e-01f,
  1.39851108e-01f, -4.72878180e-02f, 1.41655400e-01f, -1.24884564e-02f, -1.30594485e-02f, -2.23157287e-01f, 1.82647541e-01f, -1.39447734e-01f, -2.83142179e-02f, -1.33495227e-01f,
  -2.61526089e-03f, -4.75378819e-02f, -1.32995453e-02f, 1.12686656e-01f, 4.52420041e-02f, 1.46309165e-02f, -2.53022052e-02f, 1.22742526e-01f, 1.44535825e-01f, 3.73048671e-02f,
  4.65403218e-03f, 9.27545279e-02f, -2.72887461e-02f, -3.86350453e-02f, -1.10673197e-01f, -1.09029494e-01f, 2.42228806e-01f, -1.05187543e-01f, 3.64595354e-02f, 6.23514429e-02f,
  -7.73854479e-02f, 9.46789831e-02f, -5.35475090e-02f, 1.18710212e-01f, 4.81720231e-02f, 1.60565943e-01f, 1.52772665e-02f, -1.35244057e-01f, 8.60784128e-02f, 1.49492085e-01f,
  -1.39948815e-01f, 1.94407389e-01f, -3.07560060e-02f, 1.56906217e-01f, 5.27054593e-02f, -7.87445754e-02f, -3.51253226e-02f, 1.34371668e-01f, -1.07591458e-01f, -1.24882132e-01f,
  2.70280596e-02f, 5.11190062e-03f, -2.54426092e-01f, -1.87086627e-01f, -6.90733269e-03f, 4.03658599e-02f, 2.13292129e-02f, 3.73330526e-02f, 1.69169009e-02f, 5.83045594e-02f,
  -4.95156571e-02f, 5.39764501e-02f, -2.69237265e-04f, 8.94901827e-02f, 3.22861746e-02f, 1.42300189e-01f, -5.99114550e-03f, -7.26397336e-02f, 1.58829987e-01f, 1.87328935e-01f,
  -8.38212743e-02f, 3.08735520e-02f, -1.44476250e-01f, 1.78334877e-01f, -1.91602126e-01f, -1.26797095e-01f, -1.59364626e-01f, -2.41476335e-02f, -1.41238719e-01f, 2.27960981e-02f,
  -2.83400547e-02f, 7.51658231e-02f, -1.40944555e-01f, -1.45203799e-01f, -7.95715377e-02f, 3.72082315e-04f, 7.09733218e-02f, -3.26609798e-02f, 9.90467444e-02f, 7.66913518e-02f,
  2.27040246e-01f, 7.98295289e-02f, 8.16354007e-02f, 1.47335023e-01f, -7.39173815e-02f, -4.11385223e-02f, 5.24873808e-02f, 2.50621259e-01f, 1.01638976e-02f, -2.67845532e-03f,
  -2.76399925e-02f, 4.30923253e-02f, -2.16541439e-01f, 4.97963913e-02f, -4.97490317e-02f, 1.22105405e-02f, -1.00023448e-01f, -7.86064938e-02f, -1.93826288e-01f, 2.03763414e-02f,
  -1.29212052e-01f, -2.43688487e-02f, 5.26081063e-02f, -3.86126935e-02f, 3.41114998e-02f, -2.12825865e-01f, 1.36326179e-01f, -8.07656348e-03f, -3.29071015e-01f, -8.71257335e-02f,
  6.70371158e-03f, -1.58806425e-03f, 2.27609098e-01f, -1.40262216e-01f, 1.55544132e-01f, 1.26934409e-01f, -7.84368813e-02f, -7.75054768e-02f, -2.44666785e-01f, -1.03399426e-01f,
  8.95597413e-02f, 5.22105210e-02f, 3.36082391e-02f, 5.90364970e-02f, 1.54036462e-01f, -1.26707610e-02f, 1.60318628e-01f, -1.64140657e-01f, 1.00248419e-01f, 1.22321911e-01f,
  -7.72720054e-02f, 1.31376803e-01f, 5.61664626e-02f, 1.34977207e-01f, 4.85606194e-02f, -4.91091534e-02f, -4.00901511e-02f, -1.04489684e-01f, -1.15183275e-02f, 4.33727205e-02f,
  2.46281475e-02f, -1.35378152e-01f, 5.60610779e-02f, -1.40167661e-02f, -2.93559879e-02f, -3.35570984e-02f, 1.03974923e-01f, 8.37196112e-02f, -5.95242120e-02f, -8.01308006e-02f,
  8.99905786e-02f, -1.73396379e-01f, -4.44140397e-02f, -1.64080948e-01f, -9.97919887e-02f, -1.15864024e-01f, 1.08623557e-01f, -2.17375606e-01f, 7.54586384e-02f, -2.76294380e-01f,
  1.34770066e-01f, -1.23427160e-01f, 9.71704647e-02f, 4.32667248e-02f, 2.42772654e-01f, -3.18298899e-02f, -3.20722237e-02f, 2.86161974e-02f, -4.44968715e-02f, 2.23213673e-01f,
  -3.33744548e-02f, -1.63110852e-01f, 1.20006271e-01f, 1.04310021e-01f, -8.27856362e-02f, -2.58212928e-02f, -1.25314847e-01f, -1.20971121e-01f, 8.03787857e-02f, -9.40145999e-02f,
  -2.37864070e-02f, 1.36315390e-01f, -5.64920716e-02f, 1.11977339e-01f, -2.21811216e-02f, 8.87814257e-03f, -1.35516115e-02f, -1.00196265e-01f, -8.35089013e-02f, -6.76498981e-03f,
  4.21925895e-02f, -1.41125605e-01f, -4.17116508e-02f, 3.51447985e-02f, 6.00169646e-03f, -9.29668918e-02f, -1.30083874e-01f, -1.10742398e-01f, 2.61049308e-02f, -6.08477928e-02f,
  4.48975712e-03f, 1.17264772e-02f, -7.09464401e-02f, 1.58658713e-01f, -2.73680557e-02f, 1.42469391e-01f, -5.47921881e-02f, -1.30480543e-01f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.47690941e-02f, 2.65577823e-01f, -8.91403258e-02f, 1.94968179e-01f, 5.58346361e-02f, 1.34657562e-01f, 5.69417402e-02f, -1.15251832e-01f, -5.65119041e-03f, 2.45173827e-01f,
  -2.12038029e-02f, -8.81951302e-02f, 2.06093922e-01f, -7.29007693e-03f, 1.81415692e-01f, 1.07783657e-02f, -5.21492623e-02f, -3.44065093e-02f, 3.33676815e-01f, 1.59849867e-01f,
  2.42350269e-02f, 3.00423920e-01f, -3.10302764e-01f, -7.07021281e-02f, 2.93134507e-02f, -3.64179462e-02f, 2.77951639e-02f, -1.02364412e-02f, 2.17787206e-01f, 6.44256920e-02f,
  1.67198569e-01f, -9.21730921e-02f, -2.22007036e-01f, -8.31337180e-03f, -4.76731220e-03f, -3.97346877e-02f, -2.75018550e-02f, 5.84773757e-02f, 2.48989463e-01f, 1.29783913e-01f,
  9.38826725e-02f, -2.12971494e-01f, 3.26672941e-03f, 2.48693619e-02f, 7.70358965e-02f, 9.29223150e-02f, -1.49046689e-01f, -1.21809654e-01f, -9.50220376e-02f, -3.12689602e-01f,
  -1.20658010e-01f, -2.38373205e-01f, -2.73535047e-02f, -2.00463310e-01f, -2.85072047e-02f, 4.96025756e-02f, -8.41339007e-02f, 1.25839770e-01f, -2.25137264e-01f, 9.04024616e-02f,
  -1.51227012e-01f, -1.65354952e-01f, -1.93210304e-01f, 2.03663737e-01f, 6.65553436e-02f, 1.89877123e-01f, 2.19623476e-01f, 6.75221980e-02f, 1.58758447e-01f, 1.18944414e-01f,
  1.88248858e-01f, 7.97886699e-02f, 1.40346736e-01f, -3.63139026e-02f, 5.01116961e-02f, 1.05331063e-01f, -1.35110587e-01f, -4.22650874e-01f, 3.11595201e-02f, -1.32137001e-01f,
  1.85492739e-01f, -2.28636563e-01f, 1.26422971e-01f, 1.84661090e-01f, 1.87045649e-01f, 8.61840844e-02f, 8.90680328e-02f, -2.09494278e-01f, -2.91985929e-01f, -4.84930016e-02f,
  2.15059057e-01f, 2.10535467e-01f, 4.12292778e-02f, 1.19809143e-01f, 1.19182639e-01f, 1.22531652e-01f, -3.31150964e-02f, 1.98618755e-01f, -3.19349676e-01f, 2.14971974e-02f,
  1.14235105e-02f, -5.67600615e-02f, 1.40787676e-01f, -8.58829767e-02f, 1.81993112e-01f, 3.76065820e-02f, -1.81418076e-01f, -2.11571559e-01f, -6.86851367e-02f, -3.01168084e-01f,
  3.29209305e-02f, 5.05824620e-03f, -4.66546342e-02f, -1.46281142e-02f, -1.34795755e-01f, -1.29710063e-01f, 1.98973775e-01f, 9.12414417e-02f, 1.60422772e-01f, 1.27620056e-01f,
  5.39408810e-02f, 9.57276896e-02f, 1.04749888e-01f, 3.27593625e-01f, 1.68162137e-02f, 2.22398579e-01f, -7.50690252e-02f, 2.71718919e-01f, -5.42851985e-02f, 1.63876894e-03f,
  1.58357173e-01f, 7.69388899e-02f, -2.72196867e-02f, -1.17000028e-01f, -6.77715093e-02f, -9.10973921e-02f, -1.73557289e-02f, -9.50382650e-02f, 1.29484355e-01f, -1.27420515e-01f,
  -8.59550834e-02f, -1.80578813e-01f, 1.96298048e-01f, 4.40258794e-02f, 1.12664796e-01f, 2.27999184e-02f, -3.78159024e-02f, 8.17997381e-02f, -3.78702804e-02f, 1.44902170e-01f,
  9.06567648e-02f, -8.56638849e-02f, -2.48686656e-01f, 3.04247826e-01f, -2.89655253e-02f, -6.46682307e-02f, -2.93073244e-02f, -1.67397618e-01f, -1.39427617e-01f, -9.25512016e-02f,
  -4.71306592e-02f, -3.72252703e-01f, -5.73321991e-02f, -8.49083886e-02f, 2.28942662e-01f, 2.54059732e-01f, 2.03677475e-01f, 1.32690832e-01f, 1.11196853e-01f, -2.47563660e-01f,
  1.97207481e-01f, -9.64232758e-02f, 6.16985671e-02f, -2.42245235e-02f, -1.60109788e-01f, -2.29262739e-01f, -1.33646429e-01f, -5.12907431e-02f, -5.69528639e-02f, -2.32422113e-01f,
  1.14697687e-01f, -2.97405601e-01f, -9.83736217e-02f, 2.25483105e-01f, 1.80365220e-01f, -1.19247675e-01f, -1.83164254e-01f, 1.37458920e-01f, -1.54840201e-01f, -6.35753646e-02f,
  -2.02318102e-01f, 1.23667464e-01f, -7.67664239e-02f, -1.13767020e-01f, 8.14176165e-03f, 9.51584876e-02f, 7.27379844e-02f, 1.53375790e-02f, 1.12777241e-01f, -1.52637824e-01f,
  -6.93191141e-02f, -5.36636226e-02f, 1.62570868e-02f, 1.92036122e-01f, -1.10249519e-01f, 3.09878890e-03f, -1.65073603e-01f, 1.18659005e-01f, -4.44468260e-02f, -1.20920375e-01f,
  1.87403411e-01f, 1.46042332e-01f, 7.67050609e-02f, -1.55231372e-01f, -3.46059948e-02f, -4.07133341e-01f, 7.05601275e-02f, 2.39380792e-01f, 1.61781013e-01f, 1.65107071e-01f,
  1.40110955e-01f, 4.45448142e-03f, 6.16418347e-02f, -2.89623607e-02f, -1.45406395e-01f, 1.49094071e-02f, -2.81679541e-01f, 1.24339484e-01f, -2.93252934e-02f, -5.20035811e-02f,
  1.41991600e-01f, 5.13739251e-02f, 1.01118043e-01f, -1.84845001e-01f, -1.49414688e-01f, -1.80893898e-01f, 6.84448257e-02f, -1.32030209e-05f, -2.06427559e-01f, 2.53478348e-01f,
  -5.38307391e-02f, 4.70981151e-02f, 5.07208556e-02f, -1.73264638e-01f, 3.93541940e-02f, 6.88269138e-02f, -1.03819996e-01f, 1.84140846e-01f, -8.45748633e-02f, 2.01142535e-01f,
  -3.07985283e-02f, 4.07485776e-02f, 1.68180019e-01f, 1.72908425e-01f, 5.66569604e-02f, 1.37607783e-01f, -1.52208861e-02f, 1.58433095e-02f, 5.56846242e-03f, -1.58898398e-01f,
  1.19493365e-01f, 1.56094760e-01f, 2.33298063e-01f, 2.84229636e-01f, -1.63746718e-02f, 3.88979405e-01f, 2.59555608e-01f, 1.28495052e-01f, -1.20939277e-01f, 2.47177929e-01f,
  -7.74466768e-02f, -4.21508811e-02f, 5.38206436e-02f, -9.25854892e-02f, 7.47601390e-02f, 2.77729005e-01f, 2.67656505e-01f, -1.93314239e-01f, 1.45811915e-01f, -1.82615861e-01f,
  -2.72771686e-01f, -2.84836411e-01f, 1.92645505e-01f, 1.28858790e-01f, -1.80758581e-01f, -1.82604909e-01f, -2.05044448e-01f, -9.41164792e-02f, -2.96387702e-01f, 8.20303485e-02f,
  -3.34138095e-01f, 1.60583079e-01f, -2.73584157e-01f, -5.75705543e-02f, -7.45563135e-02f, 1.97434083e-01f, 5.07157110e-02f, 4.72795665e-02f, 2.02834666e-01f, 1.62375942e-01f,
  7.13472888e-02f, 1.96402937e-01f, -2.41856053e-02f, 1.60147890e-01f, -1.78899571e-01f, 6.25577122e-02f, 5.27951047e-02f, -9.11727324e-02f, -2.89525241e-01f, 2.05560476e-01f,
  -1.11146271e-01f, 1.62680909e-01f, -3.67715955e-01f, 2.14544788e-01f, 1.67515829e-01f, -7.10887164e-02f, 1.42003924e-01f, 2.09338486e-01f, -1.50632828e-01f, 7.68587440e-02f,
  3.35824750e-02f, 1.26765668e-01f, -5.20411804e-02f, -6.96278140e-02f, 1.07127890e-01f, -7.64747933e-02f, 1.93031028e-01f, 4.18365411e-02f, -1.58439413e-01f, -1.22178979e-02f,
  1.05291970e-01f, 1.72212735e-01f, 5.30201644e-02f, 5.43634184e-02f, -2.00282961e-01f, 1.66432202e-01f, 3.51276658e-02f, -1.23251587e-01f, 6.32087141e-02f, 9.08447132e-02f,
  6.07533455e-02f, 7.27339983e-02f, -1.95554167e-01f, -2.74745107e-01f, 2.12785244e-01f, 2.87008524e-01f, 5.23534082e-02f, -2.17312381e-01f, 1.30628780e-01f, -2.55317062e-01f,
  -1.33209810e-01f, 4.89451960e-02f, -1.27115861e-01f, -1.40919402e-01f, -1.24987409e-01f, -9.36495960e-02f, 4.26250808e-02f, 2.34153748e-01f, 7.56724998e-02f, 3.60236317e-01f,
  3.07301015e-01f, -3.58691402e-02f, 1.32278338e-01f, 1.53181344e-01f, 1.99902862e-01f, 2.25019976e-01f, -2.49174848e-01f, -9.16982591e-02f, 1.03107229e-01f, -1.47449136e-01f,
  6.87582195e-02f, -4.51689847e-02f, -1.78875893e-01f, -6.13494478e-02f, -1.44083276e-01f, 7.33680651e-02f, -7.77923167e-02f, 4.29477543e-02f, -1.49616510e-01f, 6.66626468e-02f,
  -1.83024183e-01f, 4.57965173e-02f, -1.24776877e-01f, -2.27825716e-03f, 3.12187612e-01f, -7.94859510e-03f, -3.85795794e-02f, -4.17137034e-02f, -5.41883148e-03f, 1.36362821e-01f,
  1.34848148e-01f, 1.66402653e-01f, 9.68545154e-02f, -2.27399841e-02f, 1.43820152e-01f, 1.80054337e-01f, -1.36546612e-01f, 1.55393273e-01f, -2.13085011e-01f, 8.81268308e-02f,
  -1.16942145e-01f, 7.21781328e-02f, -2.70138383e-01f, -8.76809582e-02f, -2.15371922e-01f, -1.25156522e-01f, -1.56380683e-02f, 3.57856750e-02f, 2.86841422e-01f, -1.31615013e-01f,
  -7.58190081e-02f, 2.02230401e-02f, -2.10595950e-01f, 1.56737044e-01f, 1.50988176e-01f, 1.20111197e-01f, 2.11076438e-01f, -7.41552338e-02f, 6.55929074e-02f, 2.66089350e-01f,
  -6.64000064e-02f, -2.93240193e-02f, -2.38948613e-01f, -5.60635738e-02f, -1.24988973e-01f, 2.06906825e-01f, -3.74745689e-02f, 1.64998814e-01f, 2.26714894e-01f, 9.40960720e-02f,
  1.44478574e-01f, 2.38042921e-01f, 1.99452430e-01f, 1.42798230e-01f, 1.89833313e-01f, 2.00269774e-01f, -1.03123173e-01f, 2.67692387e-01f, -7.31080696e-02f, 1.52964145e-01f,
  2.23260988e-02f, -1.16069146e-01f, 1.12297542e-01f, -2.01060459e-01f, 1.47034973e-01f, 8.89175758e-02f, 2.19645590e-01f, -1.15404420e-01f, -3.67424004e-02f, -2.43964300e-01f,
  7.07036555e-02f, 1.43682331e-01f, -3.38096976e-01f, -9.03601870e-02f, -1.93401694e-01f, 6.04945282e-03f, -1.68242201e-01f, 7.20905736e-02f, 1.57640465e-02f, -1.36915287e-02f,
  8.51923153e-02f, 9.84157100e-02f, -4.06694505e-03f, -9.02708843e-02f, 8.59227702e-02f, 2.11017907e-01f, -4.49945107e-02f, -1.46950700e-03f, 1.16350882e-01f, -1.54287592e-01f,
  1.20118178e-01f, 1.06595578e-02f, 1.90499619e-01f, -1.50149807e-01f, -1.49310648e-01f, -5.51137095e-03f, 1.26635611e-01f, 2.22598374e-01f, -4.30935621e-02f, 1.52100638e-01f,
  1.00682594e-01f, 3.57570425e-02f, 2.96205699e-01f, 1.23590171e-01f, 1.09715397e-02f, -2.87042558e-01f, -1.65072918e-01f, -5.56304194e-02f, -3.83840561e-01f, 1.58057243e-01f,
  2.54156351e-01f, -4.04381640e-02f, -2.03577518e-01f, 3.51627767e-02f, 2.64849681e-02f, 1.11535981e-01f, -2.07832530e-02f, 4.44377102e-02f, 1.55768767e-01f, 2.09118024e-01f,
  1.62360206e-01f, 4.56453376e-02f, 1.53824329e-01f, -2.09535122e-01f, -4.95113134e-02f, 1.37464534e-02f, 1.13512106e-01f, -7.50986561e-02f, 2.08648115e-01f, 7.81195238e-02f,
  1.61459476e-01f, -1.49318218e-01f, -1.01270474e-01f, 1.59425512e-01f, -2.71767348e-01f, -7.14703649e-02f, -1.71935126e-01f, -1.22973286e-02f, 2.24433586e-01f, 1.16327815e-01f,
  -1.68892369e-01f, -1.76531360e-01f, -8.06146115e-02f, 1.80921853e-01f, 6.82563424e-01f, -4.44200672e-02f, -1.51783019e-01f, 4.97903749e-02f, 7.60965943e-02f, -1.30673379e-01f,
  2.95773596e-01f, 2.70754337e-01f, 1.06481582e-01f, -5.93100935e-02f, -1.49872378e-01f, -7.45282397e-02f, 3.10543984e-01f, 5.77547960e-02f, 2.03788653e-01f, 2.44832069e-01f,
  9.04514566e-02f, 2.35892326e-01f, 1.45019799e-01f, 7.19422102e-02f, -7.94639215e-02f, 1.44429073e-01f, 7.66390413e-02f, 3.20318907e-01f, -4.37779933e-01f, 2.14747842e-02f,
  -6.63897023e-02f, 2.40896493e-01f, 1.33066759e-01f, 1.46840438e-01f, -8.54685083e-02f, 1.30198538e-01f, -1.05182879e-01f, 5.14332689e-02f, -2.20142275e-01f, 1.45313472e-01f,
  -2.69224674e-01f, 9.06503350e-02f, -3.42227519e-02f, 1.19964622e-01f, -1.44556090e-01f, 1.01499528e-01f, -1.33508697e-01f, 1.47518022e-02f, -3.20753247e-01f, 1.89453568e-02f,
  6.74052164e-02f, 5.04868440e-02f, 2.16699734e-01f, -5.29242307e-02f, 8.12390447e-02f, 2.30896086e-01f, 3.37276049e-02f, 1.86839670e-01f, -1.19719528e-01f, -7.81500414e-02f,
  2.34810933e-01f, 1.67433739e-01f, 1.34030223e-01f, 2.05917016e-01f, -9.86059457e-02f, 1.55868903e-01f, 2.71481991e-01f, 1.43278152e-01f, 1.15971170e-01f, 2.32216448e-01f,
  -6.02265075e-02f, 2.46170565e-01f, 4.13093297e-03f, -2.95253266e-02f, 7.10249469e-02f, 2.87457645e-01f, 5.94006553e-02f, -9.66677815e-02f, -1.77611589e-01f, -1.47011101e-01f,
  9.07145217e-02f, -1.18650988e-01f, 3.64434123e-02f, 1.25928983e-01f, -3.40189785e-03f, 1.90867990e-01f, 2.86792144e-02f, -1.10989548e-01f, -1.44767359e-01f, 3.33220750e-01f,
  -2.72427678e-01f, 2.64062524e-01f, -2.27975979e-01f, 7.22972304e-02f, -1.14694744e-01f, 2.88315922e-01f, 1.52360752e-01f, -7.75353704e-03f, 4.79290895e-02f, 1.96330354e-01f,
  1.96933169e-02f, 1.90130100e-01f, -2.58693129e-01f, 3.33632708e-01f, -6.49996102e-02f, 5.71801886e-02f, 1.29478619e-01f, -1.59076393e-01f, -3.17271620e-01f, 1.65240511e-01f,
  -1.27300084e-01f, -4.74466644e-02f, -3.59421253e-01f, 1.19499378e-01f, 9.40653533e-02f, -5.82970604e-02f, 2.05562994e-01f, 1.75203949e-01f, 8.46610963e-02f, 3.44323993e-01f,
  1.25113338e-01f, 2.54108727e-01f, 3.60710412e-01f, 3.68174702e-01f, 1.12119447e-02f, 2.40226328e-01f, 1.30322382e-01f, 1.55894598e-02f, 2.76351780e-01f, 2.51676708e-01f,
  3.25336605e-01f, -1.58644676e-01f, -2.31789678e-01f, 7.64929205e-02f, -1.59090310e-02f, 2.13608027e-01f, -1.27906978e-01f, -1.39023349e-01f, -3.65179718e-01f, -3.13063711e-01f,
  -1.26256421e-01f, 5.34524918e-02f, -5.93993552e-02f, -8.88443813e-02f, -1.59935310e-01f, 7.15605691e-02f, 9.01136696e-02f, -1.42815322e-01f, -1.30771339e-01f, -2.80198902e-01f,
  -1.40938580e-01f, -1.01786487e-01f, -2.14992315e-02f, -9.15919617e-02f, 1.07771501e-01f, 1.61027849e-01f, 2.41014332e-01f, 8.72744173e-02f, 1.68960057e-02f, 7.51094222e-02f,
  5.39811738e-02f, 7.76341185e-02f, 1.48431614e-01f, 7.77390078e-02f, 2.75119007e-01f, 3.42001528e-01f, 6.01613782e-02f, -2.14922801e-01f, -1.91731080e-02f, -1.32917181e-01f,
  -2.41280627e-02f, -8.76777768e-02f, 2.36635748e-02f, 2.42998764e-01f, -2.72405092e-02f, 1.90795749e-01f, 2.03830609e-03f, -1.48529202e-01f, 1.21461011e-01f, -2.32351527e-01f,
  8.68999213e-02f, -3.10844500e-02f, -1.92840636e-01f, 2.77907145e-03f, 2.47309744e-01f, 4.87213247e-02f, 2.41166949e-02f, 3.75440419e-02f, 2.68380418e-02f, 1.83424816e-01f,
  2.72562094e-02f, -1.02907099e-01f, 4.63918671e-02f, -4.11102593e-01f, -1.90545544e-01f, 1.79310784e-01f, 5.44072948e-02f, -1.66043460e-01f, -8.54241401e-02f, -1.06999695e-01f,
  -1.45068377e-01f, -2.69873720e-02f, -3.54412436e-01f, -3.49465199e-02f, -4.97828647e-02f, -2.03886256e-02f, 1.75013229e-01f, 6.63307682e-02f, 1.58641815e-01f, 2.07596287e-01f,
  2.55708724e-01f, -8.25040638e-02f, -8.97114649e-02f, -8.84615928e-02f, 1.07139044e-01f, 1.00678749e-01f, 3.04788738e-01f, -2.85642922e-01f, 3.32157522e-01f, 1.87522382e-01f,
  -1.67781308e-01f, 1.36786267e-01f, -2.00235173e-02f, -1.81393400e-01f, 7.03246519e-02f, 2.29801517e-02f, -2.58651257e-01f, -3.39995660e-02f, 3.18732023e-01f, -3.41596454e-02f,
  1.40486434e-01f, -3.74521643e-01f, -2.22594440e-02f, 1.20683022e-01f, 2.03693539e-01f, -4.30344269e-02f, 1.35986194e-01f, 2.34957645e-03f, 7.19975904e-02f, 4.71147038e-02f,
  -1.83384553e-01f, -1.35626018e-01f, 1.42213972e-02f, 1.66173443e-01f, 1.05369441e-01f, -1.89214244e-01f, -1.31560236e-01f, 2.11314354e-02f, -8.82899165e-02f, 1.15340941e-01f,
  8.10662881e-02f, 1.10630006e-01f, 9.88447815e-02f, -1.32721039e-02f, 2.07129735e-02f, 3.22249681e-02f, 8.63361955e-02f, -1.34867549e-01f, -1.56886876e-01f, -4.92879003e-02f,
  1.97782725e-01f, -2.20804751e-01f, 2.01235175e-01f, -5.87260351e-02f, 1.33016944e-01f, -1.85104564e-01f, -1.13736629e-01f, 1.51823252e-01f, 5.72143570e-02f, 1.22161187e-01f,
  -1.24467030e-01f, -2.26258263e-02f, -1.61261663e-01f, -3.38645652e-02f, 2.16203690e-01f, 1.19985521e-01f, 1.99341223e-01f, 4.50356789e-02f, 1.62942007e-01f, -8.62444863e-02f,
  -2.64218431e-02f, 1.57587573e-01f, -1.62873715e-01f, 3.39353271e-02f, -5.58381043e-02f, -1.35312602e-01f, 1.99655473e-01f, 9.05090347e-02f, -6.25231639e-02f, -2.18269661e-01f,
  -1.75517783e-01f, 4.93360013e-02f, -2.21772492e-01f, -1.04631498e-01f, -2.02814505e-01f, -8.08531493e-02f, -9.24800411e-02f, -2.31424719e-01f, -1.99874625e-01f, -2.50903964e-01f,
  7.43659660e-02f, -3.32902260e-02f, -1.38521627e-01f, 8.16126540e-02f, -1.43784270e-01f, 2.39050448e-01f, 7.23187253e-02f, 1.71608120e-01f, -1.99213296e-01f, -1.10518888e-01f,
  -1.09554552e-01f, 1.70607910e-01f, 1.38028473e-01f, -1.30796626e-01f, 1.38218090e-01f, 9.88395587e-02f, 3.56000252e-02f, 5.62182181e-02f, -1.18144237e-01f, -6.10527098e-02f,
  8.98386240e-02f, 9.96566787e-02f, 8.00178349e-02f, 1.14235394e-01f, 2.86723197e-01f, 3.48896116e-01f, 5.83434217e-02f, 2.20771328e-01f, -6.86205998e-02f, 1.80910632e-01f,
  1.16837375e-01f, -4.59562987e-02f, -1.85959101e-01f, -3.36421505e-02f, 1.39727771e-01f, -3.77438106e-02f, 7.25381775e-03f, -2.36945659e-01f, -2.61054397e-01f, -1.53567463e-01f,
  -1.97215155e-02f, 2.43794084e-01f, 6.51318207e-02f, -2.12679818e-01f, -2.99497724e-01f, 1.74682170e-01f, -8.54218751e-02f, -1.93054900e-02f, -1.96301490e-01f, -3.59198600e-01f,
  -3.15886557e-01f, -5.43753132e-02f, -5.54843605e-01f, -4.36479077e-02f, 3.01167428e-01f, 7.38322213e-02f, -1.78920701e-01f, 2.32152998e-01f, 8.66556540e-02f, 2.75562853e-01f,
  -1.84514984e-01f, 5.93284667e-02f, 1.58521235e-01f, 1.11197926e-01f, -1.02872208e-01f, 1.82087645e-01f, 3.08463201e-02f, -2.83603281e-01f, -2.67143488e-01f, -2.11735010e-01f,
  1.13145173e-01f, -5.40092945e-01f, 2.46169358e-01f, -4.32792716e-02f, 1.12668738e-01f, 1.03827596e-01f, -2.81894833e-01f, 1.15077801e-01f, 4.69472706e-02f, 8.78903642e-02f,
  7.95605481e-02f, -1.70230210e-01f, -1.00532323e-01f, 1.33501545e-01f, -1.17010407e-01f, -6.28629252e-02f, -8.70630220e-02f, 6.05951808e-02f, -3.66154537e-02f, 1.13919154e-01f,
  9.21991467e-02f, 6.17501773e-02f, 3.76339294e-02f, -9.54977944e-02f, 8.64742026e-02f, -5.44885593e-03f, 3.30792591e-02f, 1.41657060e-02f, 3.82302776e-02f, -6.88448874e-03f,
  -9.21766981e-02f, 1.82925999e-01f, -1.70877397e-01f, -1.27713367e-01f, 1.64109841e-02f, -1.07383028e-01f, -8.40274245e-02f, -1.40263572e-01f, -6.73545748e-02f, -1.90681368e-01f,
  6.99789450e-02f, -8.59240741e-02f, 7.03832582e-02f, -8.69484432e-03f, 5.46872281e-02f, 3.04635584e-01f, 1.55181929e-01f, -4.99490052e-02f, 1.65035293e-01f, -4.75548767e-02f,
  -9.02018622e-02f, 4.76332605e-02f, -2.86245812e-02f, -2.08108023e-01f, -2.51716748e-02f, -4.73749377e-02f, 7.29323477e-02f, -1.62517339e-01f, -1.50731832e-01f, -1.61346734e-01f,
  -4.74525765e-02f, 1.52154773e-01f, 7.33473971e-02f, -1.12568159e-02f, -1.43088445e-01f, 1.23351112e-01f, -2.90328443e-01f, -3.69578302e-02f, -1.24465466e-01f, -4.25036438e-02f,
  -2.80485183e-01f, -8.64602905e-03f, 1.86628371e-01f, -2.39826381e-01f, -1.10898279e-02f, 8.11554044e-02f, -7.28012100e-02f, 1.68227658e-01f, -1.52390167e-01f, 6.82153776e-02f,
  3.60168107e-02f, -3.27047892e-02f, -4.08916362e-02f, -3.27132158e-02f, -1.24736309e-01f, -4.24854904e-01f, 2.78854758e-01f, -1.79959506e-01f, 1.34736374e-01f, 8.62139687e-02f,
  4.33255464e-01f, -1.15669472e-02f, 1.44260302e-01f, 1.34648889e-01f, -2.37474531e-01f, 2.69513875e-01f, -1.73008397e-01f, 6.12312146e-02f, 1.35948896e-01f, 2.72269156e-02f,
  -2.03047946e-01f, -3.02905858e-01f, -2.48106778e-01f, 3.97435352e-02f, -1.22364163e-01f, -2.11316958e-01f, -1.84456166e-02f, -4.24279422e-02f, -1.11926861e-01f, 2.55721509e-01f,
  -3.47891413e-02f, -2.10064426e-02f, 4.46735740e-01f, -6.68855831e-02f, -1.16646603e-01f, -1.86886657e-02f, 1.93476319e-01f, -3.09126079e-02f, 9.85197127e-02f, 2.21411705e-01f,
  2.34836459e-01f, 1.14136964e-01f, -9.52811092e-02f, -6.97631687e-02f, 1.53138330e-02f, -8.84084329e-02f, 1.23773731e-01f, 1.42353311e-01f, 1.71444312e-01f, 5.86322956e-02f,
  -5.10993674e-02f, 2.96379179e-01f, 1.45544738e-01f, -1.98669493e-01f, -2.33732969e-01f, -1.72441199e-01f, -1.39246238e-02f, 1.44600809e-01f, -2.57787909e-02f, -2.38219544e-01f,
  -3.72143835e-02f, 5.97568266e-02f, -1.43647492e-01f, -4.73002605e-02f, -1.42623007e-01f, 7.94303864e-02f, -7.04598650e-02f, -1.44725308e-01f, 1.78842947e-01f, -5.79952961e-03f,
  3.24586034e-02f, -9.42714512e-02f, -1.20712188e-03f, 1.21569909e-01f, -5.50849512e-02f, -4.49436083e-02f, 5.59204891e-02f, -6.70484221e-03f, -1.91193491e-01f, 3.04495603e-01f,
  9.68979206e-03f, -3.08087058e-02f, 6.30103331e-03f, -2.44044065e-01f, -1.46808013e-01f, -2.50332579e-02f, -1.97132632e-01f, -3.89199764e-01f, 7.09000528e-02f, -1.75172597e-01f,
  -5.33012152e-02f, 1.77760765e-01f, 2.14328766e-01f, 1.65921077e-01f, 2.42375895e-01f, -1.88980415e-01f, 7.48852342e-02f, -5.57430387e-02f, 5.79437986e-02f, -1.14411391e-01f,
  -2.37180796e-02f, -1.79605290e-01f, 3.35465483e-02f, -4.98280153e-02f, 1.32514670e-01f, -1.00107655e-01f, -1.34404570e-01f, -2.23669842e-01f, 3.61722670e-02f, 5.13857082e-02f,
  5.20220175e-02f, 2.20869686e-02f, -2.69338578e-01f, 1.81659251e-01f, -3.74055117e-01f, -1.31705776e-01f, -2.71198511e-01f, 8.14771205e-02f, 1.24544352e-01f, 1.41401008e-01f,
  1.85387000e-01f, 1.67265251e-01f, 1.45597115e-01f, 2.34379604e-01f, -5.15500046e-02f, -1.13841213e-01f, 2.73165524e-01f, -6.13560453e-02f, 1.20486073e-01f, -1.71383843e-03f,
  -7.72152767e-02f, -3.58565867e-01f, 1.66788340e-01f, -2.61091083e-01f, 2.02196807e-01f, -3.03260773e-01f, -1.83168113e-01f, -8.63483697e-02f, 8.13630670e-02f, 1.92278195e-02f,
  9.39407106e-03f, 1.21745937e-01f, -1.32355452e-01f, -2.18492746e-02f, 1.76513180e-01f, 1.08642884e-01f, 5.00107035e-02f, -2.95379966e-01f, -3.18836093e-01f, 8.22166577e-02f,
  1.47971541e-01f, -2.72579104e-01f, 9.19769034e-02f, -1.36786073e-01f, 1.43137917e-01f, 9.05457661e-02f, 3.04095950e-02f, -2.29241624e-01f, -9.24413092e-03f, 1.12373106e-01f,
  -1.26480713e-01f, -1.05873361e-01f, 2.78674722e-01f, -2.04581171e-01f, 1.47165105e-01f, -2.49279439e-01f, 6.00144826e-02f, 2.32708585e-02f, -1.08060732e-01f, 3.80201899e-02f,
  3.49269569e-01f, -6.08280413e-02f, 8.08123574e-02f, 1.64278120e-01f, 1.58714086e-01f, 4.42831032e-02f, 4.71536964e-02f, 1.32359356e-01f, 5.54189533e-02f, 6.57840371e-02f,
  -2.86844730e-01f, 1.22462831e-01f, 7.89920166e-02f, 4.27905954e-02f, -7.29573071e-02f, -5.40634729e-02f, -1.08774543e-01f, -1.29504174e-01f, -1.41130194e-01f, -2.33339518e-02f,
  -1.99945178e-03f, 9.42987278e-02f, -1.49744675e-01f, -2.18534842e-01f, -8.27778280e-02f, -1.51354700e-01f, -1.45181119e-01f, -3.67707647e-02f, 9.34701934e-02f, -1.77104115e-01f,
  1.74767122e-01f, 1.85762867e-02f, 4.38227132e-02f, -5.57952598e-02f, -8.77627954e-02f, -8.61443765e-03f, -1.46754049e-02f, -2.78617859e-01f, 5.47217801e-02f, 1.17107242e-01f,
  1.83267370e-02f, 5.88985160e-02f, -4.12344225e-02f, -2.74618834e-01f, 3.25441957e-02f, 3.70138228e-01f, -4.96008620e-02f, 2.49534652e-01f, -1.94510475e-01f, -1.81574270e-01f,
  -4.63014320e-02f, -1.59911543e-01f, 8.69719777e-03f, 2.01193780e-01f, -3.48795503e-02f, -1.38997748e-01f, -2.33845428e-01f, -7.49792382e-02f, 8.65796357e-02f, 2.81709343e-01f,
  -2.59556711e-01f, -2.28620432e-02f, -2.12962963e-02f, -1.04292862e-01f, -1.32147133e-01f, 1.21050268e-01f, -2.74141668e-03f, -1.18948994e-02f, -2.64863789e-01f, 2.29010150e-01f,
  1.67918488e-01f, 1.50219589e-01f, 2.27625459e-01f, 1.26899600e-01f, -3.86393592e-02f, 8.81414339e-02f, 2.55996644e-01f, 1.27369776e-01f, 2.04380229e-01f, 2.03846022e-01f,
  -6.30879169e-03f, 2.79568106e-01f, 2.83509672e-01f, 2.97087040e-02f, 3.54838446e-02f, 1.06451645e-01f, 1.71471745e-01f, -1.28236800e-01f, -2.09176585e-01f, 2.11381376e-01f,
  -1.33887142e-01f, 1.47880331e-01f, -5.01105823e-02f, -5.94046265e-02f, -8.47897604e-02f, 8.01079124e-02f, -1.87339336e-01f, 1.94712698e-01f, -1.97003316e-02f, -9.25905555e-02f,
  1.03271462e-01f, 1.31253600e-01f, 9.69133377e-02f, -2.16647178e-01f, 8.40638280e-02f, -2.68855840e-01f, -5.76598123e-02f, 6.60312697e-02f, -7.96950459e-02f, -9.36570689e-02f,
  -4.76235636e-02f, -1.01194577e-02f, 1.18553229e-01f, 2.37190709e-01f, 9.96392146e-02f, 1.63494349e-01f, -9.34059024e-02f, -7.65439793e-02f, 2.37987444e-01f, 3.56444389e-01f,
  2.82405168e-01f, 3.53713095e-01f, 1.14728592e-01f, -3.40028644e-01f, 1.08803384e-01f, -3.74075547e-02f, 9.06817839e-02f, -2.44395081e-02f, 1.98271237e-02f, 1.32556245e-01f,
  6.46397397e-02f, 1.47080034e-01f, 1.70905724e-01f, -1.98511034e-01f, -9.26058143e-02f, -1.68944642e-01f, -2.82637309e-02f, -7.43169785e-02f, -2.61010766e-01f, -8.77408683e-02f,
  2.93084055e-01f, 9.25900936e-02f, 2.35188007e-02f, 2.37158075e-01f, 2.43596695e-02f, 2.34478757e-01f, 7.32079148e-03f, -6.17467165e-02f, 1.46619841e-01f, 7.74508193e-02f,
  9.77729410e-02f, -1.11748964e-01f, 2.05250680e-01f, -8.78191069e-02f, -2.11042985e-02f, 1.83275238e-01f, 1.68102562e-01f, 7.18029514e-02f, 2.09008515e-01f, 2.00563502e-02f,
  -1.68038800e-01f, 3.80148977e-01f, -7.67003596e-02f, -9.87550840e-02f, -2.98650246e-02f, -4.69864160e-02f, 1.19086228e-01f, -1.25969693e-01f, 9.38982144e-02f, 1.86726451e-02f,
  7.08690062e-02f, 4.78838757e-02f, 4.85437214e-02f, -1.40424464e-02f, -1.78180709e-01f, -2.41681978e-01f, 1.97197095e-01f, 2.25057304e-01f, 4.97520678e-02f, 4.10004333e-02f,
  -1.54970795e-01f, 4.64929733e-03f, 7.96532780e-02f, 3.48390453e-02f, 1.91829830e-01f, -1.48018328e-02f, -1.68118719e-02f, -1.89976692e-02f, -4.63223271e-02f, -1.48815751e-01f,
  -1.77912980e-01f, -1.57656923e-01f, -3.94066460e-02f, 6.56574294e-02f, -4.72323149e-02f, 1.22533984e-01f, 8.26379955e-02f, 7.24273771e-02f, 3.57258730e-02f, 1.77546158e-01f,
  -2.27842227e-01f, 2.21608058e-02f, -1.50088429e-01f, 6.52144253e-02f, 1.03986226e-01f, 7.04215094e-02f, 3.25636774e-01f, 2.24880688e-02f, 1.84016734e-01f, 4.97996926e-01f,
  2.41356134e-01f, -8.06613639e-02f, 1.30130863e-02f, -2.30845079e-01f, 4.14518505e-01f, -1.15060002e-01f, -9.79617611e-02f, 1.64423108e-01f, -1.97531492e-01f, -3.00039593e-02f,
  -6.38823658e-02f, -1.25440910e-01f, 4.70070429e-02f, -1.78795919e-01f, 2.81921513e-02f, 2.01656178e-01f, -8.65877941e-02f, -1.98344931e-01f, -9.73001942e-02f, 1.56392157e-02f,
  -3.78011577e-02f, -1.54757416e-02f, 2.88395286e-01f, 1.22246116e-01f, -1.51044011e-01f, 2.03556687e-01f, -2.35609915e-02f, -1.58308387e-01f, -8.77347738e-02f, -1.10736467e-01f,
  3.49731259e-02f, 2.91281134e-01f, -5.11916541e-02f, -5.68326376e-02f, -1.36327341e-01f, 1.48905843e-01f, -7.39789084e-02f, -1.22194234e-02f, 3.03460389e-01f, 1.31411016e-01f,
  1.95489049e-01f, -3.40797037e-01f, -3.84166762e-02f, 2.04917386e-01f, 7.28357956e-02f, -7.15137944e-02f, 2.18718424e-01f, 1.63942888e-01f, -6.23800382e-02f, 1.81104124e-01f,
  1.06791347e-01f, 6.91368952e-02f, 2.44248793e-01f, 3.41448262e-02f, -1.19020000e-01f, 1.83301955e-01f, -9.89035964e-02f, -1.83828220e-01f, -2.50474691e-01f, 1.69935137e-01f,
  -2.43214503e-01f, -1.05947860e-01f, 1.17706046e-01f, 7.75788352e-02f, 4.97402921e-02f, -1.50119439e-01f, 1.01357378e-01f, -5.85651696e-02f, -3.15939039e-02f, 7.95164034e-02f,
  3.52451354e-01f, 1.90312639e-01f, 2.38782227e-01f, -3.39228548e-02f, -6.73770010e-02f, -1.75170481e-01f, 1.06449753e-01f, 9.64415222e-02f, -3.27792130e-02f, 1.12279706e-01f,
  -2.36913070e-01f, 8.32484737e-02f, 1.07160598e-01f, 8.98675621e-03f, 5.65209566e-03f, 2.07905903e-01f, 3.37826997e-01f, 2.56665647e-01f, 1.49473414e-01f, -9.70344394e-02f,
  -1.02443054e-01f, 2.22790033e-01f, -3.66040081e-01f, -5.77879176e-02f, -1.52131140e-01f, -8.33734572e-02f, 2.19015941e-01f, -3.82492915e-02f, -2.59951979e-01f, -5.21864705e-02f,
  -2.14588687e-01f, -5.78233413e-02f, -2.94008255e-01f, 7.23713115e-02f, -2.63492823e-01f, 1.09901436e-01f, -1.10520482e-01f, -3.42303142e-02f, -1.34860203e-01f, 3.34845893e-02f,
  2.22881719e-01f, 2.63756905e-02f, -2.10124820e-01f, -1.54352069e-01f, 3.91340144e-02f, 2.37977773e-01f, 1.17036544e-01f, 1.83693394e-01f, 1.01397917e-01f, 1.52877897e-01f,
  -5.80325946e-02f, 1.99589878e-01f, 2.02531032e-02f, -2.75994446e-02f, 6.17961064e-02f, 2.34219342e-01f, 1.69149488e-01f, 1.94520205e-01f, -1.32079333e-01f, -4.50557470e-02f,
  1.43042237e-01f, 1.27409443e-01f, 9.41410810e-02f, 3.09080124e-01f, 2.78794393e-02f, 2.97938168e-01f, 3.59720200e-01f, 3.03257048e-01f, -7.34796673e-02f, 1.08357131e-01f,
  -3.20406884e-01f, -2.63783872e-01f, -2.74358302e-01f, -1.84468143e-02f, 7.00726062e-02f, 1.39069453e-01f, -3.31011303e-02f, -1.11613862e-01f, -9.67037752e-02f, 1.24080233e-01f,
  -8.66386965e-02f, 7.71914423e-02f, 1.46015599e-01f, 7.69806001e-03f, -1.86187532e-02f, 4.34209667e-02f, -2.03894824e-01f, 4.22875956e-02f, -1.38497632e-02f, -3.28182206e-02f,
  -1.60474740e-02f, -1.42562985e-01f, -1.56088203e-01f, -1.26745909e-01f, 7.14973956e-02f, 1.71437606e-01f, -1.05515040e-01f, 2.58967906e-01f, 2.24865805e-02f, 1.17822431e-01f,
  1.23434886e-01f, -8.55525956e-02f, 2.26919120e-03f, -9.13671553e-02f, 2.20703110e-01f, 1.72649343e-02f, -9.28271562e-03f, -2.10047036e-01f, 1.33304462e-01f, -1.18597195e-01f,
  -8.77229571e-02f, -3.48161787e-01f, 1.78299069e-01f, -1.35959879e-01f, -7.15543553e-02f, 5.17071299e-02f, 2.07050741e-01f, 4.12485525e-02f, -1.35114610e-01f, -9.54089612e-02f,
  4.53801174e-03f, 9.49362069e-02f, 1.88290387e-01f, 6.70249807e-03f, 9.97087955e-02f, -8.74700770e-02f, 1.57864064e-01f, 6.47209063e-02f, -3.10585350e-01f, -6.79899659e-03f,
  -2.31373772e-01f, 2.31699347e-01f, -3.22395831e-01f, 3.44851031e-03f, -1.58388525e-01f, 6.73740059e-02f, -8.02768618e-02f, -2.29540855e-01f, -4.25953902e-02f, -1.89308599e-01f,
  2.24161088e-01f, 3.59020606e-02f, 1.14932038e-01f, 3.50294411e-02f, -2.35972703e-01f, -8.16337541e-02f, 1.16883494e-01f, 1.12822294e-01f, 7.31846988e-02f, -4.74791192e-02f,
  -1.34061933e-01f, 2.19309375e-01f, -1.61687508e-02f, 1.30405337e-01f, -1.68095138e-02f, 2.89375763e-02f, 2.81628013e-01f, 1.63681597e-01f, -1.76070720e-01f, -1.24505594e-01f,
  2.74276286e-01f, -2.21605208e-02f, -9.80606079e-02f, 4.40221839e-02f, 2.06057038e-02f, 1.53416276e-01f, 9.73085538e-02f, 2.31312197e-02f, -2.30745599e-01f, -8.41646455e-03f,
  -5.00746667e-02f, 2.62896210e-01f, -4.38526422e-02f, -2.14238446e-02f, 5.56046106e-02f, -1.74926862e-01f, -1.66569022e-03f, 1.14755481e-01f, -4.84220348e-02f, 7.50928372e-02f,
  1.73630536e-01f, 7.52124190e-02f, -3.19588333e-02f, 1.81398883e-01f, 3.60377654e-02f, 3.09032530e-01f, -1.95441283e-02f, 2.94861436e-01f, 1.38672784e-01f, 9.38914940e-02f,
  -1.24233011e-02f, 1.52190000e-01f, -5.02755865e-02f, 1.51842922e-01f, 1.63463101e-01f, 6.05227984e-03f, -6.23684973e-02f, -8.02150816e-02f, -2.73401946e-01f, -3.51804376e-01f,
  -1.03212297e-01f, 1.41366944e-02f, -7.37788603e-02f, 3.44603390e-01f, -6.23899549e-02f, -1.33852735e-01f, -2.24730417e-01f, -3.57071966e-01f, -1.28120571e-01f, -2.01927900e-01f,
  -1.38020143e-01f, -8.53349715e-02f, -1.45869687e-01f, -1.37688637e-01f, 1.54122159e-01f, 3.70528772e-02f, 9.89554003e-02f, -1.88058913e-02f, -1.60303116e-01f, 1.93207696e-01f,
  9.19108912e-02f, 1.52228281e-01f, 2.80571878e-01f, 2.00089708e-01f, 2.61553496e-01f, 3.00736099e-01f, 6.18432760e-02f, -2.39059865e-01f, 2.43320882e-01f, -5.98928258e-02f,
  1.80508614e-01f, 5.75336777e-02f, -3.68989110e-02f, 8.75462964e-02f, -1.08226389e-01f, 5.80178387e-02f, -1.42128050e-01f, -2.00081676e-01f, 3.97906937e-02f, -3.84619713e-01f,
  1.36573330e-01f, -1.55539215e-01f, -2.45762110e-01f, -1.38759553e-01f, 1.05049752e-01f, 8.70168488e-03f, -7.39157274e-02f, -4.18885425e-02f, 7.01409578e-02f, -1.26853272e-01f,
  -5.33870310e-02f, 1.53311133e-01f, -1.45124480e-01f, 9.03369673e-03f, 4.01378758e-02f, 1.43469214e-01f, 2.39096805e-01f, 1.84746429e-01f, 1.17752822e-02f, 1.63657650e-01f,
  -1.02648854e-01f, 2.04413623e-01f, -2.72207528e-01f, -1.05520897e-01f, -9.61543098e-02f, 2.46720221e-02f, 2.59511173e-02f, 1.85377181e-01f, 2.63376594e-01f, -4.47360203e-02f,
  -2.86874294e-01f, -2.40030333e-01f, -2.27761179e-01f, 2.36057535e-01f, 1.40886799e-01f, -1.10672593e-01f, 1.00312065e-02f, 2.95317192e-02f, -4.04665526e-03f, 3.97216156e-02f,
  1.33063525e-01f, 1.15844451e-01f, -1.78822987e-02f, 7.56723285e-02f, -4.30124998e-02f, -7.51185566e-02f, 2.27002829e-01f, 1.75797567e-01f, 9.64700878e-02f, 2.74346411e-01f,
  -1.32367983e-01f, -3.83219533e-02f, 2.19766542e-01f, -4.18556035e-02f, 1.70806617e-01f, 1.65806785e-01f, -1.98826253e-01f, 2.37555489e-01f, -4.98096980e-02f, 5.11569455e-02f,
  1.17722265e-01f, -2.12369725e-01f, -4.88293283e-02f, -5.79738140e-01f, 1.81042731e-01f, -7.44976997e-02f, 3.16029005e-02f, 4.06020433e-02f, 6.51309714e-02f, 2.01907847e-02f,
  -1.65806681e-01f, -7.36073554e-02f, -1.41269654e-01f, 1.23262651e-01f, -1.76575184e-02f, 1.18158117e-01f, -1.51111066e-01f, -2.64414012e-01f, -5.73177226e-02f, 4.21865173e-02f,
  -5.99119766e-03f, 5.96720651e-02f, -4.92937900e-02f, -1.24910828e-02f, -7.28263566e-03f, -1.82177305e-01f, -2.28039213e-02f, 4.94578034e-02f, 1.11825988e-01f, 3.09832722e-01f,
  -2.03118533e-01f, -6.04181588e-02f, -2.98650444e-01f, 1.64762333e-01f, 9.39456001e-02f, 2.10421085e-02f, 3.17005277e-01f, -2.02575088e-01f, -7.17477277e-02f, 6.01007864e-02f,
  -2.34493494e-01f, -1.83100834e-01f, 1.71022082e-03f, -1.13683663e-01f, -2.43034676e-01f, -1.15576766e-01f, 1.17907211e-01f, -4.03468609e-02f, 8.36320594e-02f, -8.73162076e-02f,
  -1.38185203e-01f, -1.73354208e-01f, -1.45991519e-01f, -2.31153876e-01f, 1.67681500e-01f, -3.75626653e-01f, -1.47377431e-01f, -6.35513514e-02f, -2.20404267e-01f, -4.84345742e-02f,
  2.68848658e-01f, -2.14555889e-01f, 1.07525498e-01f, -6.30465522e-02f, 1.33724557e-02f, 2.73691267e-01f, 3.91600989e-02f, 2.32286513e-01f, -2.74684697e-01f, 8.14557970e-02f,
  4.68897820e-02f, 1.04641661e-01f, 7.64439702e-02f, 2.16471821e-01f, -2.77673267e-02f, 1.05625868e-01f, 5.22660185e-03f, 1.19342104e-01f, 1.26585349e-01f, 4.30511348e-02f,
  2.51498878e-01f, 1.78907797e-01f, -8.33041593e-02f, -5.83898276e-02f, 2.16928452e-01f, 1.02551803e-01f, 2.04347428e-02f, 2.35926807e-01f, 6.73821941e-02f, -2.10233092e-01f,
  1.85834661e-01f, 2.62679398e-01f, -1.55830279e-01f, 2.67045200e-01f, -2.71315396e-01f, 3.07884463e-03f, -5.14044892e-03f, -1.22222699e-01f, -1.81483086e-02f, -1.14387296e-01f,
  1.37999937e-01f, 1.84422076e-01f, 2.71359980e-01f, -1.24519557e-01f, -2.03552052e-01f, 2.64275044e-01f, -1.12299494e-01f, 6.64803162e-02f, 1.74426027e-02f, -2.08533481e-02f,
  1.35288432e-01f, 1.26313716e-01f, 6.43404499e-02f, -1.75955921e-01f, 9.19178054e-02f, 1.77818671e-01f, -6.94830790e-02f, 2.34731048e-01f, -2.33125493e-01f, 9.65220928e-02f,
  -3.18020821e-01f, -1.90808386e-01f, -1.56745419e-01f, -6.47833049e-02f, 6.61081746e-02f, -4.75590080e-02f, -1.46646768e-01f, 1.79837137e-01f, 4.01703082e-03f, 1.48523688e-01f,
  -4.12740894e-02f, 4.71649542e-02f, 7.65411602e-03f, -1.01862952e-01f, -8.57654586e-03f, 1.50899202e-01f, -1.22054741e-01f, 1.03271641e-01f, -6.86669424e-02f, -1.75611317e-01f,
  1.85683846e-01f, 1.88995019e-01f, 8.83784145e-02f, -1.71907201e-01f, -5.43917082e-02f, 7.51769245e-02f, 8.21132883e-02f, 5.68951927e-02f, 1.52893305e-01f, 2.54746135e-02f,
  1.89454164e-02f, -3.25344503e-01f, 1.84981003e-01f, -1.37647763e-01f, 3.00711185e-01f, 9.40378085e-02f, 4.17637795e-01f, 1.77187808e-02f, -1.08567484e-01f, 5.71139567e-02f,
  3.86021137e-02f, -2.63315529e-01f, 6.23214990e-02f, 1.60475582e-01f, 2.46421799e-01f, -3.11680185e-03f, 1.89023186e-02f, -1.12282686e-01f, -6.08385392e-02f, 4.26142327e-02f,
  -2.56113678e-01f, -1.19147494e-01f, -2.17766725e-02f, -2.52062559e-01f, -1.29170403e-01f, -9.88938212e-02f, -2.15828598e-01f, -5.97882047e-02f, -1.24680474e-01f, -7.49261528e-02f,
  -3.33228409e-01f, -2.52395898e-01f, 1.02012008e-01f, 1.17120691e-01f, -8.37274864e-02f, 1.76729664e-01f, -5.47948964e-02f, -1.11344911e-01f, 4.77863923e-02f, -7.21412525e-02f,
  4.98074219e-02f, -1.80244863e-01f, 6.95543587e-02f, 2.09037811e-01f, 2.03757137e-01f, -6.98249787e-03f, 9.42273811e-03f, 2.59497911e-01f, 4.38181981e-02f, 4.67428714e-02f,
  -2.07750052e-02f, 1.19326487e-01f, -7.89841190e-02f, 1.34719923e-01f, -1.95105448e-02f, 2.32466273e-02f, -1.09595336e-01f, -1.97286382e-01f, 1.23786712e-02f, 3.33644971e-02f,
  -2.35073596e-01f, -1.66576698e-01f, 2.03219488e-01f, -2.96198547e-01f, 3.74795824e-01f, -1.47906570e-02f, 1.51139215e-01f, -2.53956109e-01f, 1.16769344e-01f, 1.70335159e-01f,
  -3.78295183e-02f, 2.31287315e-01f, 1.10924892e-01f, 1.86068371e-01f, -7.38329962e-02f, 1.90387785e-01f, -2.08377503e-02f, -1.73889816e-01f, 1.38018981e-01f, 1.62876606e-01f,
  1.21394053e-01f, -4.34608087e-02f, -3.06342691e-01f, -7.57214576e-02f, 1.04986317e-01f, -1.39558434e-01f, 1.06433161e-01f, -8.15710984e-04f, 1.51537033e-02f, 1.98198095e-01f,
  1.43859759e-01f, -1.78705826e-01f, 1.12780958e-01f, 1.35169581e-01f, -6.97669163e-02f, -1.09550394e-02f, -8.68307650e-02f, 4.55452092e-02f, -1.78850248e-01f, -2.85351783e-01f,
  1.29713625e-01f, -2.47438669e-01f, -2.52386220e-02f, -2.66146213e-01f, -8.25036690e-02f, 8.94643366e-02f, 6.50768727e-02f, 9.50571001e-02f, -1.88388333e-01f, 2.23915532e-01f,
  -1.61667839e-02f, -1.97670400e-01f, -9.49586555e-02f, 8.01681429e-02f, 1.73480913e-01f, 2.54931420e-01f, -1.45775542e-01f, -1.21839300e-01f, 7.71353319e-02f, 8.73782486e-02f,
  8.53809267e-02f, 3.10438335e-01f, 1.39233619e-01f, 1.42383724e-01f, -8.12017024e-02f, 6.65344414e-04f, -4.15935814e-01f, 7.20248595e-02f, -3.64508688e-01f, 2.25197360e-01f,
  -2.18871936e-01f, -8.30067545e-02f, 1.77059472e-02f, 1.80968821e-01f, -1.92565501e-01f, -1.56441838e-01f, -1.58092469e-01f, -2.06990361e-01f, -2.66012866e-02f, 1.47451892e-01f,
  3.02790344e-01f, 5.05862981e-02f, -2.40204379e-01f, -1.71878055e-01f, 4.43946034e-01f, 7.18249604e-02f, 2.32520893e-01f, 1.47054911e-01f, 2.91181896e-02f, 1.87290266e-01f,
  -2.31158271e-01f, 6.94680288e-02f, 9.84632894e-02f, 1.20834745e-01f, 1.44634813e-01f, 1.67830549e-02f, -2.73783833e-01f, 1.37614116e-01f, 2.41086707e-01f, 9.91722941e-02f,
  -3.12604606e-01f, -3.36050019e-02f, 1.23487838e-01f, -1.29566312e-01f, -6.80754930e-02f, -7.19828382e-02f, -6.84121251e-02f, 5.37470207e-02f, -1.31873235e-01f, 2.52651393e-01f,
  6.07155226e-02f, 9.80153382e-02f, -4.25723381e-02f, 1.93888828e-01f, 1.02220029e-01f, -1.86882406e-01f, -1.25661105e-01f, 3.90134364e-01f, -6.10785708e-02f, 1.44255593e-01f,
  1.40746713e-01f, -3.30341943e-02f, 1.77352086e-01f, 1.15429759e-01f, -1.15620121e-01f, 3.21606267e-03f, 1.11126743e-01f, -1.09137846e-02f, -7.37756789e-02f, -3.13549563e-02f,
  -3.54003787e-01f, -2.33661085e-01f, -1.76371396e-01f, -2.69709140e-01f, -1.62778441e-02f, -7.05208555e-02f, -1.15040854e-01f, 2.85790171e-02f, 1.22098558e-01f, -2.85082072e-01f,
  8.87253135e-02f, -9.11735222e-02f, -1.65425777e-01f, -2.79806614e-01f, 1.12781145e-01f, 3.10134798e-01f, 1.75318494e-01f, 8.49766359e-02f, 9.99727026e-02f, -2.05879077e-01f,
  4.11238298e-02f, 2.20836505e-01f, -2.20949143e-01f, -3.09872068e-03f, -1.75106972e-02f, -3.51882815e-01f, -1.73566386e-01f, -2.50381261e-01f, -2.18096673e-02f, 2.77679320e-02f,
  -2.90977895e-01f, -1.61960885e-01f, -1.42486393e-01f, -1.31848738e-01f, -1.63883865e-01f, 2.74873525e-01f, -2.01230764e-01f, 2.58108735e-01f, -2.96800882e-02f, -2.06878781e-02f,
  -1.94976076e-01f, 1.61071792e-01f, -1.73460066e-01f, 9.36640948e-02f, -2.47365534e-01f, 3.74281965e-02f, 1.37057737e-01f, -6.15114756e-02f, 1.81438133e-01f, 1.53359532e-01f,
  2.36222632e-02f, 2.67210137e-02f, 7.91976228e-03f, 4.89297733e-02f, 2.89495915e-01f, 1.31614819e-01f, -1.62407644e-02f, 2.02169016e-01f, 1.73889980e-01f, -1.48829192e-01f,
  5.88684902e-02f, -3.94303292e-01f, -1.17316946e-01f, -2.21220136e-01f, -3.28178555e-02f, -2.69997776e-01f, -8.63214657e-02f, -3.42708379e-01f, 1.32578880e-01f, -2.23803461e-01f,
  -7.93901365e-03f, -2.94965565e-01f, 2.11750194e-01f, 1.91413090e-01f, -1.01440445e-01f, 1.40459523e-01f, -1.08226864e-02f, 2.97103766e-02f, -4.26365994e-02f, 7.34245107e-02f,
  5.39496765e-02f, 2.67664455e-02f, -1.37333721e-01f, -1.07604988e-01f, 5.63790090e-02f, -8.88372213e-03f, 4.50809151e-01f, -3.36275026e-02f, 9.78903621e-02f, 1.25502169e-01f,
  -1.70183599e-01f, -6.05539158e-02f, -1.02859057e-01f, 2.04957321e-01f, 2.90058311e-02f, -3.32574360e-02f, 5.55690117e-02f, -8.00309107e-02f, 1.77147835e-01f, -2.88576961e-01f,
  -1.46101909e-02f, 8.67833868e-02f, 7.22838938e-02f, 1.76127702e-01f, 1.68978333e-01f, -4.07674834e-02f, 1.39106363e-01f, -5.03832940e-03f, 1.07296035e-01f, -1.36504285e-02f,
  2.03718215e-01f, 1.08597875e-01f, -1.10229522e-01f, 9.26853046e-02f, 1.90915853e-01f, -3.49632233e-01f, 1.12115614e-01f, 9.31099150e-03f, -2.85692930e-01f, -2.60267351e-02f,
  -9.08180475e-02f, -1.08823888e-01f, 2.24486254e-02f, -1.88426644e-01f, -2.96276566e-02f, -4.17775542e-01f, -1.21040411e-01f, 2.42215302e-02f, 2.05329880e-01f, 3.30406800e-02f,
  2.39491761e-01f, 2.11414441e-01f, 3.42280697e-03f, 1.59479141e-01f, -1.91313792e-02f, -1.66559458e-01f, -1.52138263e-01f, 2.58683980e-01f, -1.40306890e-01f, 1.74910381e-01f,
  3.18975121e-01f, -5.53859286e-02f, 5.51382117e-02f, -1.81141272e-02f, 1.11314505e-01f, 7.56199807e-02f, 2.75530457e-01f, 1.02846161e-01f, -1.61275137e-02f, -9.95344147e-02f,
  1.17953345e-01f, 1.83743343e-01f, -1.88846439e-02f, 6.40255138e-02f, 1.27782479e-01f, -1.64089710e-01f, -1.84284344e-01f, 1.07285582e-01f, -1.91582575e-01f, 1.02838157e-02f,
  4.26392779e-02f, -1.36127453e-02f, 1.85273319e-01f, -1.61725625e-01f, 2.14665890e-01f, -1.22500934e-01f, -6.36610016e-02f, 1.66297242e-01f, 2.86125124e-01f, -2.64846198e-02f,
  1.80273786e-01f, 5.06815724e-02f, 2.90044397e-01f, 4.13169786e-02f, 6.58934042e-02f, 9.03287996e-03f, 1.14695460e-01f, -3.64775844e-02f, -1.59245096e-02f, 2.00602248e-01f,
  -2.55791217e-01f, -1.61285803e-01f, 1.24920934e-01f, -4.63756099e-02f, 1.05994135e-01f, 1.95692435e-01f, -1.36941904e-02f, 1.13159395e-03f, 3.17303166e-02f, -1.19463995e-01f,
  -1.31826028e-01f, -8.11315551e-02f, 2.26341695e-01f, -2.70886302e-01f, 1.49908110e-01f, -6.33599341e-01f, 2.67797738e-01f, -1.13699213e-01f, 1.65597454e-01f, 6.03359416e-02f,
  1.59703940e-01f, 1.57709662e-02f, 7.52433091e-02f, 2.80659318e-01f, -1.69350684e-01f, 2.60656595e-01f, -7.20329359e-02f, -7.86341131e-02f, 3.38516265e-01f, 1.95033461e-01f,
  -1.04791954e-01f, -2.90018022e-01f, -2.54310817e-01f, 9.57718939e-02f, -1.74782276e-01f, -1.18765868e-01f, 9.84656289e-02f, 1.13724895e-01f, 2.86389347e-02f, 2.00881302e-01f,
  5.05434759e-02f, 3.47497463e-02f, 3.05321693e-01f, -1.22454502e-01f, -7.62500316e-02f, 5.37847057e-02f, 9.58229322e-03f, 1.47828966e-01f, -1.96154580e-01f, 1.89372167e-01f,
  1.08046181e-01f, -1.51774334e-02f, -1.35474011e-01f, -1.46114230e-01f, -4.03249115e-02f, -3.26025486e-02f, 3.95908393e-02f, 1.85766011e-01f, 1.06558658e-01f, 1.73062414e-01f,
  -1.23231605e-01f, 2.14790419e-01f, 1.27366278e-02f, -1.94170207e-01f, 2.21661925e-02f, -1.66300889e-02f, 1.18456580e-01f, 1.10195994e-01f, 2.50162750e-01f, 1.72042966e-01f,
  1.68398321e-01f, -1.01849996e-01f, 2.77850553e-02f, 1.62215039e-01f, 1.80592716e-01f, -8.53293017e-02f, -1.00420974e-01f, 2.58871943e-01f, 1.90385088e-01f, 2.33415648e-01f,
  -2.77574137e-02f, -6.31938353e-02f, 6.27139956e-02f, 7.08089173e-02f, -1.10304989e-01f, 6.34038821e-02f, -3.78056377e-01f, -5.87842576e-02f, 1.76424742e-01f, 3.53920572e-02f,
  -1.24332711e-01f, -1.14602774e-01f, 8.50297231e-03f, 1.79148361e-01f, 8.17258582e-02f, -2.50340663e-02f, -9.31484923e-02f, 1.64934933e-01f, -3.68330747e-01f, 8.53198320e-02f,
  1.34068236e-01f, 2.42740735e-01f, 8.96841064e-02f, 1.18019141e-01f, -7.82583207e-02f, -8.45564976e-02f, 2.07742214e-01f, 2.84191608e-01f, 3.46778631e-02f, 3.47873062e-01f,
  -2.63317134e-02f, -3.19621824e-02f, 1.14990979e-01f, -2.75946856e-01f, 1.70717254e-01f, -5.10789193e-02f, -1.13036029e-01f, 1.11595698e-01f, 9.45596397e-02f, 1.83380246e-01f,
  2.99095958e-01f, -1.71801131e-02f, -3.44010838e-03f, -3.09922367e-01f, -8.96091163e-02f, -6.82940781e-02f, -3.83335613e-02f, -5.50880507e-02f, -4.79925275e-02f, -1.42074406e-01f,
  1.66438252e-01f, 9.67018157e-02f, 4.96070534e-02f, 4.45586964e-02f, -2.72330403e-01f, 3.15425575e-01f, -5.23206852e-02f, 1.69191301e-01f, -1.25584513e-01f, -1.11907832e-01f,
  1.91766232e-01f, -1.39801681e-01f, 9.73527580e-02f, -4.37843353e-01f, 1.53212070e-01f, -1.07692242e-01f, -6.85971379e-02f, 3.82695422e-02f, 5.89815378e-02f, 2.95081385e-03f,
  3.23872656e-01f, 4.73110110e-01f, -1.30352542e-01f, 2.28048593e-01f, -4.18551415e-01f, -1.47713140e-01f, -2.53082309e-02f, 7.08113834e-02f, -3.38985801e-01f, -2.28221864e-01f,
  -6.65627792e-02f, 9.85203758e-02f, 1.14483736e-01f, 8.84535611e-02f, 2.45713182e-02f, -4.52729389e-02f, -1.94414899e-01f, 3.29467744e-01f, 6.21131621e-02f, 1.68511614e-01f,
  4.43301588e-01f, 1.76444247e-01f, -7.27443919e-02f, 1.46399168e-02f, 2.19907224e-01f, 1.71904832e-01f, -1.28675073e-01f, 1.05080046e-02f, 1.61912560e-01f, -4.75128032e-02f,
  -6.92738742e-02f, 6.87217936e-02f, 1.87238604e-01f, -2.47186020e-01f, -4.13509049e-02f, 6.32075518e-02f, 8.80215466e-02f, -1.75971150e-01f, 1.59089297e-01f, 2.01062560e-01f,
  -3.82530913e-02f, -4.27451938e-01f, 2.32027359e-02f, -3.05991709e-01f, 6.09506294e-02f, -5.35696410e-02f, -2.70363122e-01f, -1.72332525e-01f, -3.26662771e-02f, 8.57748911e-02f,
  -2.90266186e-01f, -5.39089181e-02f, 8.87940601e-02f, -1.32955313e-01f, 3.81015301e-01f, 2.59967651e-02f, -8.90255719e-02f, -1.69683680e-01f, 1.45297423e-01f, 1.61899686e-01f,
  3.16807479e-01f, -1.98403411e-02f, 2.38465935e-01f, -8.18639472e-02f, 1.27645820e-01f, 1.09566048e-01f, 1.60077915e-01f, 5.20333499e-02f, -1.48577347e-01f, 2.45146140e-01f,
  1.82287395e-01f, 1.55904248e-01f, 8.57076515e-03f, -4.05738279e-02f, -4.29760441e-02f, 6.94034770e-02f, 1.45316601e-01f, 1.92550030e-02f, -7.68327415e-02f, -1.07097149e-01f,
  1.15253247e-01f, 2.06794485e-01f, -3.51053298e-01f, 1.28883496e-01f, -5.32569829e-03f, -7.67411143e-02f, -2.26458445e-01f, -2.11335719e-01f, 1.83589011e-01f, 2.10992441e-01f,
  -1.10597983e-01f, 2.38713756e-01f, 9.44569483e-02f, 2.39378124e-01f, 1.96116745e-01f, 1.13679960e-01f, 2.38624290e-01f, 3.32461558e-02f, -2.53340118e-02f, -1.70262046e-02f,
  2.14375958e-01f, -4.87545319e-02f, 3.24131660e-02f, 1.57623231e-01f, 2.77173966e-01f, -2.61848211e-01f, 7.45903999e-02f, 7.26053119e-02f, 4.65200916e-02f, 9.05979145e-03f,
  -2.57228757e-03f, 1.92337614e-02f, 2.02459753e-01f, 5.15273632e-03f, 2.92427212e-01f, -1.79199785e-01f, -1.26752689e-01f, -1.09983243e-01f, -2.37747990e-02f, -2.56042570e-01f,
  -2.14051083e-01f, -3.57288033e-01f, -1.54884934e-01f, -1.13125414e-01f, -2.10005596e-01f, -1.18887663e-01f, 1.12070665e-01f, -2.25550458e-01f, 1.17089957e-01f, 3.15372087e-02f,
  1.53045431e-02f, -1.21250600e-01f, 1.79021522e-01f, 1.79702371e-01f, -8.05201903e-02f, 2.79602781e-02f, 7.66662359e-02f, 1.45257697e-01f, 2.80794799e-01f, 1.24825671e-01f,
  2.68378735e-01f, 1.36136040e-01f, 1.16866559e-01f, 7.88597092e-02f, -1.45972654e-01f, -3.36877614e-01f, -3.42906788e-02f, 6.49579987e-02f, -3.08217168e-01f, -1.44488662e-01f,
  1.23324536e-01f, -1.04231991e-01f, 6.28376082e-02f, -1.36673646e-02f, -6.29782602e-02f, 7.80541450e-02f, 1.45076618e-01f, 1.02837458e-01f, -1.72589138e-01f, 1.68814823e-01f,
  -4.09821570e-02f, 1.12025842e-01f, -2.24476412e-01f, -8.49981457e-02f, 2.57520556e-01f, -1.57671779e-01f, 1.09541185e-01f, 2.13637754e-01f, 1.24524541e-01f, 5.64644076e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  9.19688195e-02f, 1.05727844e-01f, 3.67078036e-02f, 1.84847638e-01f, 1.74513519e-01f, 1.02772184e-01f, -2.83958409e-02f, -8.00499022e-02f, 1.29724443e-01f, 1.53107315e-01f,
  -4.67400514e-02f, 7.30362460e-02f, -3.79499197e-02f, 2.34126188e-02f, 2.02256888e-02f, -2.31564958e-02f, 1.00645602e-01f, -1.11537725e-02f, 3.62692252e-02f, 1.66517213e-01f,
  -3.03345080e-02f, 1.21367201e-01f, 5.13019003e-02f, -7.87538961e-02f, 1.65435925e-01f, 1.20396882e-01f, 4.43680733e-02f, 1.09787025e-01f, 9.84114478e-04f, -4.86933105e-02f,
  2.77675386e-03f, 2.33159110e-01f, -2.59039849e-02f, 4.68761474e-02f, -5.95767424e-02f, 1.21869713e-01f, 2.23039836e-01f, 1.23321220e-01f, -4.57552820e-02f, -8.02018717e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.06867906e-02f, -1.56859234e-01f, -1.89488975e-03f, -1.96377426e-01f, -2.00918555e-01f, -1.84717420e-02f, -1.25156343e-01f, -2.12268487e-01f, 1.40051857e-01f, -2.01368220e-02f,
  -1.95270494e-01f, -1.64133430e-01f, 2.24911571e-01f, 3.90504347e-03f, 1.30234167e-01f, 6.71359599e-02f, 3.92214116e-03f, -2.15308547e-01f, 1.51088148e-01f, 9.33288485e-02f,
  -1.42410398e-01f, 2.03033224e-01f, 9.35410857e-02f, 1.09627068e-01f, 6.52374849e-02f, -4.62044030e-01f, 2.86511242e-01f, -2.39418074e-01f, -1.36543676e-01f, -9.58910659e-02f,
  1.35206103e-01f, 2.09813088e-01f, 8.19995925e-02f, -9.02762115e-02f, -2.22779978e-02f, 5.63249364e-02f, -3.74307521e-02f, 6.49748594e-02f, -1.36248469e-02f, -1.62710413e-01f,
  1.03495166e-01f, -4.26065207e-01f, 8.47423226e-02f, -1.93578884e-01f, 1.02130398e-01f, -2.59329766e-01f, -2.23307177e-01f, -1.72220111e-01f, 8.94233733e-02f, -2.38286052e-02f,
  1.46829084e-01f, 7.80815482e-02f, -2.45105997e-01f, -1.54908434e-01f, 5.08444756e-02f, -8.72408822e-02f, -6.19004332e-02f, 1.36480629e-01f, 1.43384531e-01f, -2.48340055e-01f,
  -2.73537785e-01f, 1.93839043e-01f, 2.06141174e-01f, 1.42344818e-01f, -8.81869495e-02f, -3.48107964e-02f, -1.80397540e-01f, 2.60294706e-01f, 2.76535377e-02f, -6.11384436e-02f,
  3.06764305e-01f, 1.53134435e-01f, 1.11098111e-01f, 8.42521861e-02f, -1.25816166e-01f, 1.18748881e-01f, -2.90189743e-01f, 1.04440399e-01f, -2.02028438e-01f, -2.41990149e-01f,
  -3.41631651e-01f, 2.15090424e-01f, -1.74235895e-01f, 8.51848349e-02f, 2.05682307e-01f, -2.55042821e-01f, 1.80289105e-01f, -9.78323147e-02f, -1.71946958e-01f, 8.40986371e-02f,
  -8.66177380e-02f, -1.94893032e-01f, -9.51980352e-02f, -1.76485389e-01f, 9.65402722e-02f, -9.38391611e-02f, -4.03978795e-01f, -3.46837699e-01f, 1.75676852e-01f, 2.63791859e-01f,
  -6.67334720e-02f, -7.05198646e-02f, -2.00004578e-01f, -2.54176855e-01f, -1.10773981e-01f, 2.19706312e-01f, -3.92691791e-01f, 6.85300007e-02f, 8.11964497e-02f, 2.33971447e-01f,
  -2.29802221e-01f, 4.47474606e-02f, 1.68119714e-01f, 1.00779116e-01f, 8.44529942e-02f, -1.01571053e-01f, -1.75494835e-01f, -1.24837354e-01f, -2.15413377e-01f, -1.98142063e-02f,
  -3.99696499e-01f, 1.28752768e-01f, 1.44541249e-01f, -2.60183901e-01f, -4.24702242e-02f, -1.27409220e-01f, -2.73696750e-01f, 1.30406484e-01f, -2.73678023e-02f, 2.81869382e-01f,
  6.51105940e-02f, 8.90397578e-02f, 1.10996731e-01f, 1.90656722e-01f, 3.01955819e-01f, 2.53975205e-02f, 1.44825876e-01f, 2.41513625e-01f, 8.65268558e-02f, -5.97657040e-02f,
  2.85647035e-01f, -6.95019662e-02f, -1.81083426e-01f, -6.93196505e-02f, -1.18623488e-02f, -2.25638196e-01f, 7.85581619e-02f, 2.77862754e-02f, 8.36865902e-02f, -1.54273361e-01f,
  3.31622064e-01f, -3.20981033e-02f, -2.55340785e-01f, 2.31147066e-01f, -8.98429528e-02f, 1.57683030e-01f, 1.78882033e-01f, -2.74711818e-01f, 4.41625044e-02f, -1.34712934e-01f,
  -3.02896718e-03f, 1.15313724e-01f, 4.72592041e-02f, 7.97491521e-02f, 6.48151115e-02f, -3.74800116e-01f, -1.19019710e-01f, -1.23688214e-01f, 4.14744541e-02f, 4.53687832e-02f,
  2.70450294e-01f, -2.57069021e-01f, -3.90247643e-01f, -4.94703084e-01f, -1.48875132e-01f, -1.60484046e-01f, 2.00044602e-01f, -1.32305324e-01f, -2.26446614e-01f, -2.90967554e-01f,
  -1.47890031e-01f, -4.26232480e-02f, -2.82531828e-01f, 2.12956727e-01f, 3.12579840e-01f, 2.07892153e-02f, -2.19448060e-01f, -3.29793632e-01f, -3.90593976e-01f, -9.58901495e-02f,
  -2.86756277e-01f, 1.81534678e-01f, -1.27034513e-02f, -1.52859047e-01f, -6.22388497e-02f, 1.38022438e-01f, -6.39781076e-03f, -1.50231704e-01f, -1.52068302e-01f, 5.76558597e-02f,
  -7.42896572e-02f, -1.13807388e-01f, 6.67483509e-02f, 1.04907513e-01f, -3.00958008e-02f, 2.43500456e-01f, -3.07379186e-01f, 6.53960370e-03f, -1.27846524e-01f, -7.71804973e-02f,
  2.77297925e-02f, 3.11809089e-02f, -2.04659104e-01f, -1.87412784e-01f, -9.24552605e-02f, 8.76576155e-02f, -1.47790490e-02f, -1.82265528e-02f, -4.46370244e-02f, 1.06765844e-01f,
  1.07436202e-01f, 6.21205047e-02f, 4.32051867e-02f, 4.68441844e-02f, 3.46837342e-02f, 8.87125134e-02f, -1.85038775e-01f, -4.13560659e-01f, -3.00784677e-01f, -1.20184850e-02f,
  -3.99810448e-03f, 1.56381607e-01f, -4.53071147e-02f, -3.59674662e-01f, 1.03171840e-01f, -1.81213453e-01f, -6.68774918e-02f, -6.36555701e-02f, 5.78465797e-02f, -2.17476159e-01f,
  3.15278806e-02f, -1.07665822e-01f, -1.11961864e-01f, -4.62544292e-01f, -4.15599167e-01f, 2.29224086e-01f, 8.65284577e-02f, -5.62487066e-01f, 1.45522624e-01f, -6.50680736e-02f,
  -2.24494547e-01f, 1.80441201e-01f, -2.58114338e-01f, 1.82954580e-01f, 1.69610143e-01f, 1.25238210e-01f, -2.19713509e-01f, 9.06092767e-03f, 1.46893889e-01f, -9.69899297e-02f,
  -1.11740626e-01f, -2.07569718e-01f, -2.25216433e-01f, -3.79253644e-03f, -2.96910197e-01f, -2.29787558e-01f, 1.52483732e-01f, -1.85977053e-02f, -7.89435878e-02f, -7.71119371e-02f,
  3.38357270e-01f, -6.38158321e-02f, -1.92697477e-02f, 8.28749090e-02f, 1.95539221e-01f, -4.40956987e-02f, -2.08622473e-03f, 2.33139440e-01f, -2.07722262e-01f, -7.09976852e-02f,
  -1.37229696e-01f, -1.12764969e-01f, -2.58303192e-02f, 9.87273380e-02f, -1.27176136e-01f, -9.40505862e-02f, 9.77870226e-02f, 6.89635724e-02f, 9.90398377e-02f, 1.57515690e-01f,
  -1.65833518e-01f, -2.44453847e-01f, -1.91488311e-01f, 2.12573498e-01f, -7.90080428e-02f, -2.18993247e-01f, -2.23698206e-02f, 1.49393395e-01f, 6.73133656e-02f, -2.21296445e-01f,
  -2.12124929e-01f, -2.25608364e-01f, 1.70855507e-01f, 2.00427428e-01f, 7.33035132e-02f, -3.44283342e-01f, 1.05380021e-01f, -4.93852645e-02f, 6.11985140e-02f, -1.62479538e-03f,
  -1.27287641e-01f, -1.74766362e-01f, 1.59011558e-02f, -1.82570994e-01f, 2.06613734e-01f, -1.75500810e-01f, 4.33446802e-02f, -1.56590044e-01f, 2.49345489e-02f, -3.32706496e-02f,
  3.84565860e-01f, -3.91479433e-02f, -6.47869855e-02f, -4.04923074e-02f, 5.91775589e-02f, 2.99763471e-01f, -2.91343302e-01f, -1.62023216e-01f, 2.89438590e-02f, 1.98254406e-01f,
  1.84517637e-01f, 1.12007141e-01f, -7.88391754e-02f, -1.55318797e-01f, 1.60551876e-01f, -5.54408617e-02f, -1.51364312e-01f, 1.88505024e-01f, 8.56842920e-02f, -1.77078575e-01f,
  -1.42318547e-01f, 5.41867055e-02f, 2.82929778e-01f, -2.26910785e-01f, 2.70482637e-02f, -1.84657604e-01f, -1.50848821e-01f, -4.41504903e-02f, 1.99158013e-01f, 2.47492462e-01f,
  6.17695414e-02f, -2.75265694e-01f, 3.93122509e-02f, 1.00949302e-01f, 1.55660719e-01f, -2.55937427e-02f, -1.02307208e-01f, -1.50262192e-01f, 1.21791735e-02f, -2.65340239e-01f,
  -2.14665439e-02f, -2.95370251e-01f, -1.32095799e-01f, 1.85625225e-01f, 1.67224072e-02f, 5.76923117e-02f, -6.51706755e-02f, -1.20109534e-02f, 2.18795583e-01f, 7.19144046e-02f,
  1.90345168e-01f, -8.79704058e-02f, 4.44349693e-03f, -8.82151201e-02f, -2.41159797e-01f, 2.24807471e-01f, -3.46519470e-01f, -3.39966297e-01f, 7.29951859e-02f, -3.35289448e-01f,
  1.62499174e-01f, -5.06360590e-01f, -2.58586586e-01f, -1.23547465e-01f, 1.76763296e-01f, 1.02944024e-01f, -1.56857058e-01f, 7.77667612e-02f, -2.48110980e-01f, 2.31218413e-01f,
  -2.12911144e-01f, -1.15660295e-01f, 9.32238325e-02f, 4.87511344e-02f, 1.26257166e-01f, -1.71272248e-01f, -3.43219131e-01f, -3.93887162e-02f, 2.65359908e-01f, -2.97713745e-02f,
  4.10564356e-02f, 2.66792357e-01f, -3.62970009e-02f, -1.21719778e-01f, 2.54601598e-01f, -1.70518160e-02f, -1.29943132e-01f, 2.24441551e-02f, 1.44555226e-01f, 1.08172320e-01f,
  9.89337638e-02f, 1.29059657e-01f, -3.07600200e-01f, 5.23118488e-03f, -3.67789030e-01f, -7.16051236e-02f, 1.10834457e-01f, -1.83598340e-01f, -4.38854754e-01f, 2.01723158e-01f,
  1.29949495e-01f, -7.86013305e-02f, 1.34565476e-02f, -3.28140646e-01f, 2.30631456e-01f, 6.61726594e-02f, -1.64930314e-01f, -1.49645731e-01f, 5.70155717e-02f, -2.42175341e-01f,
  -2.07551438e-02f, 1.26945853e-01f, -5.30471839e-02f, -8.79057273e-02f, -7.93903694e-02f, 1.87215954e-01f, 1.05145648e-01f, -2.50819504e-01f, 1.54623002e-01f, 1.93375513e-01f,
  -2.95847952e-01f, -3.11103910e-01f, 8.44331160e-02f, 7.77143463e-02f, -3.02973300e-01f, -3.54203803e-04f, -2.02130646e-01f, -3.14522624e-01f, 1.20401643e-01f, -4.12607864e-02f,
  -1.94811955e-01f, -1.21853285e-01f, 1.50403291e-01f, -3.85312773e-02f, 9.73528549e-02f, 1.25889197e-01f, -7.76473060e-02f, -1.09188147e-01f, -2.35739686e-02f, -2.08947491e-02f,
  -2.14294776e-01f, -1.44408077e-01f, -2.38837555e-01f, 2.39143059e-01f, 1.44812500e-03f, -1.56212986e-01f, 3.90943810e-02f, -3.60988855e-01f, 7.57578090e-02f, -1.76377118e-01f,
  -1.11804985e-01f, 2.10815310e-01f, -1.55821532e-01f, 1.22697659e-01f, -7.23039135e-02f, 8.70398581e-02f, -5.89015484e-01f, -7.72239491e-02f, -8.56924206e-02f, 6.59272298e-02f,
  -2.98865169e-01f, -3.25592607e-01f, -1.86112821e-01f, -9.64819789e-02f, 7.06687197e-02f, -4.67722923e-01f, -6.72080368e-02f, 2.15118960e-01f, 2.89938394e-02f, 1.34921238e-01f,
  -1.19728623e-02f, -3.42839933e-03f, -1.15972608e-01f, 2.15978831e-01f, 8.46766084e-02f, -1.16170235e-01f, -1.28059939e-01f, -1.88456297e-01f, -1.72475874e-02f, 2.47810513e-01f,
  -8.71302113e-02f, 1.49662375e-01f, -1.82439759e-01f, -3.13518435e-01f, 1.16080288e-02f, 2.55304277e-01f, 1.41031682e-01f, 1.71292439e-01f, -9.97749250e-03f, -8.91011022e-03f,
  1.16714865e-01f, -1.19914047e-01f, 1.22245699e-01f, 2.24032491e-01f, -7.19003677e-02f, -1.62011594e-01f, 1.29543573e-01f, -5.56798875e-02f, -1.22918963e-01f, 2.41266370e-01f,
  9.16683599e-02f, 1.77616194e-01f, 2.19019845e-01f, -6.35535792e-02f, -1.57233581e-01f, -1.68597892e-01f, -2.02921227e-01f, -7.50449151e-02f, 1.22934811e-01f, -2.32813172e-02f,
  3.93693410e-02f, 1.94471534e-02f, 4.82252650e-02f, -1.39363736e-01f, -4.11102086e-01f, 4.72515404e-01f, -2.14514345e-01f, -2.28201300e-01f, 9.91281644e-02f, -3.85109037e-01f,
  -1.67818040e-01f, 1.45106256e-01f, -2.79426485e-01f, -1.45444617e-01f, -9.91878957e-02f, -3.59613776e-01f, 5.46311587e-02f, -1.73074678e-01f, 1.08746037e-01f, -3.24024707e-01f,
  1.88577250e-01f, 3.05273026e-01f, 1.70316309e-01f, -1.53628916e-01f, 1.33336810e-02f, 4.68215533e-02f, 4.38218340e-02f, 1.38856750e-02f, -2.69681484e-01f, -1.99957803e-01f,
  -6.45970032e-02f, 1.71618402e-01f, 1.40415683e-01f, -2.57239372e-01f, -2.04485044e-01f, -2.12952614e-01f, 2.03625217e-01f, -3.40708971e-01f, -1.53940529e-01f, 1.53328910e-01f,
  -1.37330532e-01f, 3.18016350e-01f, 4.63060886e-02f, 3.49671900e-01f, -1.45931644e-02f, -1.91019356e-01f, -6.36100844e-02f, -1.78126395e-01f, 1.32856458e-01f, 4.40764725e-02f,
  1.97687566e-01f, -1.32085860e-01f, 1.21696353e-01f, -9.88186970e-02f, -1.59742460e-02f, 1.37731835e-01f, -1.16584517e-01f, 1.97081313e-01f, 2.14976206e-01f, -2.33120590e-01f,
  1.11054763e-01f, 1.92779243e-01f, 1.78074822e-01f, -1.77728847e-01f, -1.81714192e-01f, 1.71572283e-01f, -2.33359963e-01f, 3.25880349e-02f, -2.28360191e-01f, -5.25942184e-02f,
  2.55561262e-01f, 1.80088118e-01f, -3.84937972e-01f, 3.33063453e-02f, -2.10612193e-01f, -2.56381691e-01f, -3.94262403e-01f, -4.29478198e-01f, 1.38233989e-01f, 2.24997215e-02f,
  -6.75683543e-02f, -2.63391972e-01f, 2.31376454e-01f, -2.37612993e-01f, -1.91726074e-01f, -2.02024207e-01f, -1.69624835e-01f, -1.15006007e-01f, 2.04166204e-01f, -2.11600214e-01f,
  4.66882512e-02f, -7.83592612e-02f, 1.88168302e-01f, -2.22654969e-01f, -3.42457712e-01f, 1.22432290e-02f, -2.77288318e-01f, -9.94955096e-03f, 2.64046103e-01f, 1.46225587e-01f,
  1.32833868e-01f, -1.01502147e-02f, -3.10615152e-02f, -7.33362138e-02f, 4.81561683e-02f, 1.01228185e-01f, -8.96487162e-02f, -1.46946102e-01f, -1.22593440e-01f, 9.87390522e-03f,
  4.85902280e-02f, 7.29982927e-02f, 1.07649162e-01f, -1.71184272e-01f, -2.54188091e-01f, 9.22401547e-02f, 1.51870906e-01f, 1.15821190e-01f, -2.20721409e-01f, -4.42995206e-02f,
  -1.21152565e-01f, -9.12549198e-02f, 2.12208718e-01f, 2.90731132e-01f, 1.66912213e-01f, 3.92760262e-02f, 6.13825731e-02f, 1.62750393e-01f, -1.39146492e-01f, -2.70046860e-01f,
  -2.30898380e-01f, 3.55481446e-01f, 1.05682299e-01f, -1.05332255e-01f, -1.44047245e-01f, -1.82528496e-01f, -3.64464402e-01f, -3.73732984e-01f, 2.44352147e-01f, -1.66078940e-01f,
  2.50910744e-02f, 1.14147790e-01f, -2.65122563e-01f, 3.74903455e-02f, 1.66424051e-01f, -4.95104969e-01f, -9.05430317e-02f, 2.38674775e-01f, -1.25041887e-01f, 6.97482675e-02f,
  -2.99383581e-01f, -3.81235600e-01f, 1.74806046e-04f, 1.15548015e-01f, -1.74676627e-01f, -2.38033369e-01f, -1.67191863e-01f, 2.89804965e-01f, -2.84819871e-01f, 1.92478731e-01f,
  1.40536010e-01f, 1.13797761e-01f, 4.50500622e-02f, -9.65956300e-02f, -1.09852187e-01f, -3.36306244e-01f, -5.94115146e-02f, -2.98292875e-01f, -6.09193146e-01f, -1.51800690e-02f,
  1.14745550e-01f, 4.14760500e-01f, -1.12410940e-01f, -3.05882841e-01f, -2.82804854e-02f, -2.32441351e-01f, 2.57729918e-01f, -5.44216447e-02f, 1.15272611e-01f, -1.25525400e-01f,
  1.48754176e-02f, -6.99308142e-02f, -9.05629247e-02f, -1.92857515e-02f, -1.09062679e-02f, -8.16030242e-03f, 1.00520752e-01f, 6.73791617e-02f, -2.18906403e-01f, 1.30091785e-02f,
  1.55409858e-01f, -1.93502486e-01f, 5.08665033e-02f, 1.64288938e-01f, 1.45176023e-01f, 1.17430888e-01f, -1.62234277e-01f, 4.89107259e-02f, 1.11108996e-01f, 3.22263241e-02f,
  2.42119610e-01f, 3.52633893e-02f, -1.32711530e-01f, 6.80482388e-02f, -3.78358185e-01f, -9.03696641e-02f, -4.87374604e-01f, -3.44145805e-01f, 1.59762487e-01f, -1.26787215e-01f,
  -1.91199649e-02f, 5.53636178e-02f, 6.15445450e-02f, -1.73333302e-01f, 1.38885915e-01f, 1.33033395e-01f, -2.78539717e-01f, 1.91717803e-01f, 1.84219033e-01f, 1.04345500e-01f,
  -3.72187674e-01f, -4.64258432e-01f, 6.74430802e-02f, -3.58641267e-01f, -4.19953912e-01f, -1.38347521e-01f, 1.13441333e-01f, -7.47793391e-02f, 6.84000850e-02f, 6.58290908e-02f,
  -1.79929833e-03f, -4.69972789e-02f, -1.46195248e-01f, 2.79070344e-02f, 1.35916829e-01f, -4.09775496e-01f, -1.27511531e-01f, -2.04710677e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.16385502e-02f, -5.30173071e-02f, 2.10319236e-01f, 2.36882586e-02f, 2.21276060e-02f, -5.93723671e-04f, 5.24435490e-02f, 1.02518804e-01f, -2.99759209e-02f, -5.92428818e-03f,
  -1.29628152e-01f, -1.94476284e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    