/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.30452049e-02f, 1.19150035e-01f, 7.46284286e-03f, -1.49145722e-01f, -1.47314444e-01f, -1.56936571e-01f, 7.74599239e-02f, 3.09482254e-02f, -5.53933643e-02f, -7.27606490e-02f,
  -4.10144180e-02f, -1.59996927e-01f, -7.53212944e-02f, 1.10636046e-02f, 4.38232832e-02f, -5.45858964e-02f, 1.95725821e-04f, 4.11968771e-03f, -1.51251256e-01f, -1.44539908e-01f,
  1.20856939e-02f, 6.02919161e-02f, 3.44342776e-02f, -8.73472095e-02f, -6.23709485e-02f, -1.15955129e-01f, -1.96163468e-02f, -3.57284490e-03f, 6.14147224e-02f, 1.01437829e-02f,
  -2.01082200e-01f, 1.48588881e-01f, -2.10924465e-02f, -5.38030863e-02f, -1.09762825e-01f, -6.25413954e-02f, -8.07657838e-02f, -3.52188349e-02f, -2.64666080e-02f, -1.14755608e-01f,
  -5.77305257e-03f, -8.54831263e-02f, -6.08371384e-02f, -2.50242576e-02f, -6.43081032e-03f, -9.25675556e-02f, 7.30201975e-02f, -7.44733075e-03f, 4.99199107e-02f, -1.03075160e-02f,
  9.84437987e-02f, 4.64427918e-02f, -1.36122704e-01f, 3.85044143e-02f, 1.13190487e-02f, -8.79577920e-02f, -6.18212484e-02f, 5.22532640e-03f, -1.04173891e-01f, -3.54014188e-02f,
  7.07354769e-02f, -2.20227130e-02f, 7.12700114e-02f, 6.30920306e-02f, -5.07898070e-03f, -5.80222346e-02f, 7.05545768e-02f, -6.02537282e-02f, 8.03559572e-02f, 1.01635084e-02f,
  4.18092981e-02f, 5.54291252e-03f, 5.91219291e-02f, 4.44250554e-02f, 9.50448588e-03f, -2.58044209e-02f, 3.20003703e-02f, 4.37416770e-02f, 2.11517494e-02f, 6.60085827e-02f,
  -2.92684380e-02f, 1.46764740e-02f, 2.45973058e-02f, 9.98272002e-02f, 4.98181172e-02f, 5.34495153e-03f, -1.47412093e-02f, -2.48625921e-03f, 1.55300251e-04f, 9.58972648e-02f,
  -1.34962127e-01f, -2.36920007e-02f, -1.84761941e-01f, -1.26034647e-01f, -1.96630314e-01f, -5.65690324e-02f, -4.38324884e-02f, -5.61044924e-02f, -2.08567232e-02f, 5.00113331e-03f,
  -1.36651233e-01f, -1.44580036e-01f, -1.28055692e-01f, -4.25272398e-02f, -6.74667060e-02f, -1.28134876e-01f, -6.61941022e-02f, -8.08963850e-02f, -8.10493901e-02f, -7.88910612e-02f,
  -1.29252017e-01f, -7.74030685e-02f, -1.62493736e-01f, -1.01616591e-01f, -1.08174525e-01f, -2.25440666e-01f, -8.60891342e-02f, -1.06846102e-01f, -2.18809977e-01f, -2.51656562e-01f,
  1.23585053e-01f, -1.25735670e-01f, -2.48676494e-01f, -3.33894759e-01f, -2.56760150e-01f, -2.23232821e-01f, -1.49256900e-01f, 2.52809953e-02f, 1.93120837e-02f, -1.84495792e-01f,
  -1.71007365e-01f, -1.86210111e-01f, -6.01227432e-02f, -1.92498773e-01f, -9.90847126e-03f, -1.53087258e-01f, -1.09500580e-01f, -1.46500364e-01f, -2.05839545e-01f, -2.36618683e-01f,
  -2.82694966e-01f, -1.79671541e-01f, -1.15262546e-01f, -7.64621124e-02f, -2.06094086e-01f, -2.12690815e-01f, -2.46915326e-01f, -1.24642581e-01f, -2.73194671e-01f, -1.72107518e-01f,
  -3.39317769e-01f, -4.35707672e-03f, -7.18992800e-02f, 3.98015454e-02f, -1.08512446e-01f, -9.19801742e-02f, -2.12004185e-02f, -3.24029066e-02f, -5.78305088e-02f, -1.44769102e-01f,
  -1.46437064e-01f, -1.19570561e-01f, -1.64709195e-01f, -1.15700662e-01f, -6.31396621e-02f, -2.01768726e-01f, -5.63334813e-03f, -7.57204928e-03f, -1.00867257e-01f, -1.67203099e-02f,
  -1.68284714e-01f, -1.35538325e-01f, -1.04067542e-01f, -9.38131139e-02f, -9.10097510e-02f, 1.38545949e-02f, 3.05067059e-02f, -2.52649584e-03f, -6.83936924e-02f, -3.31727043e-02f,
  9.61668491e-02f, 1.15003893e-02f, -8.83184560e-03f, 9.18991342e-02f, 1.40096871e-02f, -1.84818059e-02f, 2.34245956e-02f, -2.93410420e-02f, 4.11814973e-02f, 8.53210688e-02f,
  7.67467767e-02f, 9.59026292e-02f, 4.68702568e-03f, 1.88873019e-02f, -3.02652624e-02f, 5.30917123e-02f, 5.17467968e-02f, 2.99530197e-02f, 5.61305359e-02f, 1.00779627e-02f,
  1.02183549e-02f, 8.35270062e-03f, -3.38712111e-02f, 4.36281860e-02f, 8.91264528e-02f, -1.43038621e-02f, -3.42496037e-02f, 2.06764862e-02f, -2.69692186e-02f, 4.39738855e-02f,
  -1.96703464e-01f, 1.73103750e-01f, -2.57554222e-02f, -7.04208240e-02f, -9.35488865e-02f, 4.05454636e-02f, -7.44699687e-02f, -5.91431409e-02f, -1.49204880e-01f, -7.21088722e-02f,
  -9.86894146e-02f, -5.35683185e-02f, -1.32481884e-02f, -6.59761503e-02f, -1.18440077e-01f, -2.18423307e-02f, -7.65029117e-02f, -1.70854181e-01f, 2.88750492e-02f, -4.31634998e-03f,
  7.77963325e-02f, -6.56192750e-02f, -8.33905675e-03f, 3.92544940e-02f, -6.59941733e-02f, -6.81311712e-02f, -2.00254731e-02f, 3.21188308e-02f, -1.77085754e-02f, -2.16669738e-02f,
  -3.82873058e-01f, 1.82068408e-01f, 4.57131350e-03f, 8.74697044e-03f, 1.11587837e-01f, 2.86341190e-01f, 4.21198219e-01f, 1.35653853e-01f, 3.39307971e-02f, 7.96385407e-02f,
  -1.00649737e-01f, -2.35899508e-01f, -5.82456738e-02f, -1.69713467e-01f, -1.11474469e-01f, 2.40225956e-01f, 2.96480328e-01f, -5.58261983e-02f, -1.70627058e-01f, -1.01985872e-01f,
  -5.75788610e-04f, 3.14422250e-02f, -2.22036690e-01f, -4.00039591e-02f, 7.04239905e-02f, 2.17354996e-03f, 2.13153645e-01f, 1.17626198e-01f, -2.73469649e-02f, 9.84787643e-02f,
  -1.28531139e-02f, -7.88657144e-02f, -3.53756920e-02f, -6.85224682e-02f, -8.80309939e-02f, -6.13887087e-02f, -7.63991028e-02f, -1.15955420e-01f, -7.24519044e-02f, 6.58798292e-02f,
  -5.85833043e-02f, -6.25951290e-02f, -5.11644036e-02f, -4.55683619e-02f, -3.91770080e-02f, 5.19569963e-02f, 8.80557112e-03f, -7.32839108e-02f, 5.42577915e-02f, -6.30698577e-02f,
  -1.50220720e-02f, 2.08873264e-02f, 2.73637474e-03f, -4.71697077e-02f, -6.79459870e-02f, -1.14088677e-01f, -7.22356513e-02f, -7.87553489e-02f, -8.51572305e-02f, 2.35788692e-02f,
  -6.66292831e-02f, 1.22901809e-03f, -4.35863482e-03f, 4.11364287e-02f, 3.68187800e-02f, 7.73569569e-03f, 3.04489918e-02f, 8.89853835e-02f, 1.61878532e-03f, 9.25495476e-02f,
  -1.26145093e-03f, -2.10750792e-02f, -8.00729264e-03f, 9.82182324e-02f, 6.99459668e-03f, 7.28405640e-02f, 3.24107148e-02f, 3.48124504e-02f, 3.96305658e-02f, 2.14053132e-02f,
  1.04247453e-02f, -5.61285578e-02f, 5.07631386e-03f, -1.17702708e-02f, 3.24183963e-02f, -4.00226973e-02f, 1.09387264e-01f, -8.12496245e-02f, 4.91364636e-02f, 2.84584463e-02f,
  9.84890759e-02f, -1.63272321e-01f, 1.28634870e-01f, -2.23427285e-02f, 4.84309196e-02f, -3.17694619e-02f, -5.53202629e-02f, -1.56741478e-02f, -5.70535995e-02f, -3.80271710e-02f,
  -1.11952052e-01f, -1.25715017e-01f, 1.29342424e-02f, -4.92061339e-02f, 2.29761358e-02f, -3.32865044e-02f, 3.17614190e-02f, 4.80153672e-02f, -4.75473441e-02f, 3.71912122e-02f,
  -1.22180000e-01f, 1.09212719e-01f, 1.51830725e-02f, 8.47728103e-02f, -8.34926367e-02f, -2.12790109e-02f, -2.54742578e-02f, 1.55956456e-02f, 7.13314340e-02f, 1.33734286e-01f,
  1.54397835e-03f, -7.45460913e-02f, -3.04161310e-01f, -1.09872311e-01f, -1.37202337e-01f, -2.57597864e-01f, -4.23914194e-01f, -2.40844414e-01f, 5.84155545e-02f, -1.23531014e-01f,
  1.14583924e-01f, 2.54621774e-01f, 9.98675078e-02f, 1.74937844e-01f, -4.67991680e-02f, -2.76654273e-01f, -2.02372029e-01f, -8.00511315e-02f, -8.95065516e-02f, -1.19863742e-03f,
  4.79569510e-02f, -9.30654183e-02f, -7.94204604e-03f, 3.36419977e-02f, -2.72935275e-02f, 2.08433508e-03f, -1.09402455e-01f, -5.34252822e-02f, 8.59385580e-02f, -1.28170460e-01f,
  1.39773369e-01f, -1.57714218e-01f, -3.11157890e-02f, 5.70275523e-02f, 3.16509977e-04f, 4.98387255e-02f, 5.45499439e-04f, 5.36979847e-02f, -2.24614590e-02f, -2.20173281e-02f,
  -3.82524319e-02f, 7.46566132e-02f, -2.47124340e-02f, -4.99954931e-02f, -5.07532544e-02f, -1.87392626e-02f, -3.92383747e-02f, -5.93847744e-02f, -7.36168027e-02f, -3.46218422e-02f,
  3.11124045e-03f, -1.40595004e-01f, -5.80877811e-02f, -1.86835989e-01f, -1.45956293e-01f, 4.83303331e-02f, -3.95557620e-02f, -1.04806088e-01f, -1.35625720e-01f, -1.38450786e-01f,
  -1.03384987e-01f, -8.00634027e-02f, 4.10556756e-02f, -5.95840290e-02f, -3.70179527e-02f, 4.90353182e-02f, -9.54294875e-02f, -8.88598934e-02f, -6.76270854e-03f, 2.10419670e-02f,
  -4.83479723e-02f, -3.42686623e-02f, -9.19099972e-02f, -6.87168911e-02f, 8.70553311e-03f, -5.45541421e-02f, -4.73312251e-02f, -3.39579880e-02f, -5.96453957e-02f, -1.26824738e-03f,
  -6.26395121e-02f, -3.09652928e-02f, -4.78787683e-02f, -6.24379367e-02f, -8.72572586e-02f, -8.97273943e-02f, 7.60249188e-03f, -9.12824180e-03f, -4.62036878e-02f, 1.00212879e-02f,
  1.86301783e-01f, -1.21465087e-01f, 1.56290103e-02f, 2.01896727e-02f, -6.36513159e-02f, 7.29995780e-03f, -1.35448193e-02f, -7.57896667e-03f, 5.87681588e-03f, 2.07936354e-02f,
  -1.34320751e-01f, -6.82767779e-02f, -8.10589045e-02f, -3.12433094e-02f, -1.60504669e-01f, -5.77920228e-02f, 7.82928020e-02f, -3.55282389e-02f, -1.14298157e-01f, 3.67731936e-02f,
  -8.48816633e-02f, -1.40753701e-01f, -1.23607986e-01f, -8.16492066e-02f, -8.03750828e-02f, -7.03340620e-02f, -3.93753946e-02f, -5.68942539e-02f, -2.92048324e-02f, -2.76180003e-02f,
  4.38467383e-01f, -1.61973149e-01f, -2.37910524e-01f, 1.40060186e-01f, -6.78724721e-02f, -2.12137878e-01f, -2.76507556e-01f, -1.03539519e-01f, 7.04555809e-02f, -1.63230076e-02f,
  1.36449531e-01f, 2.06870168e-01f, 6.88810349e-02f, 9.92328972e-02f, 1.30977288e-01f, -6.93598092e-02f, -2.00943723e-01f, 6.59612864e-02f, 1.22527733e-01f, 1.54009759e-01f,
  -4.00864668e-02f, 2.87636910e-02f, 8.54916796e-02f, -6.06619380e-02f, 1.17694996e-02f, 1.46856800e-01f, -1.66763753e-01f, -1.35034770e-01f, 3.51352990e-02f, -1.01530790e-01f,
  3.50243300e-01f, 6.72366098e-02f, 6.03516176e-02f, -1.96468295e-03f, 1.01635598e-01f, 7.10874274e-02f, 8.04364607e-02f, -7.77674243e-02f, 4.21196632e-02f, 1.34788351e-02f,
  7.08976984e-02f, 3.65376361e-02f, 9.53777432e-02f, -1.92797519e-02f, -2.53849979e-02f, 1.51825976e-02f, 8.46206490e-03f, -7.41980374e-02f, 6.44813851e-02f, 2.55605821e-02f,
  5.30054048e-02f, 5.62232286e-02f, -4.55618910e-02f, -2.38730665e-02f, -7.89116845e-02f, 5.40023334e-02f, 1.35611207e-03f, 4.85245027e-02f, -3.70533578e-02f, 1.48820058e-01f,
  4.10583876e-02f, -6.56250268e-02f, 1.31941093e-02f, -1.09638140e-01f, -7.58535936e-02f, -1.94330532e-02f, 3.26020159e-02f, -5.18068410e-02f, -3.08777634e-02f, -3.34777869e-02f,
  -5.16542681e-02f, -5.22513092e-02f, -3.57332714e-02f, -9.31487232e-02f, -5.57345711e-02f, -4.15848158e-02f, -3.00609469e-02f, -8.90698507e-02f, 8.98781791e-03f, -2.93337181e-02f,
  -4.29783277e-02f, -4.61584777e-02f, -2.05780473e-02f, 6.05464652e-02f, -8.93829912e-02f, -6.51211813e-02f, -4.28260490e-02f, -4.20744605e-02f, -4.57749590e-02f, -5.65232113e-02f,
  1.94121316e-01f, -1.44733623e-01f, 1.69797599e-01f, 6.08023442e-02f, -2.17461269e-02f, -5.18569238e-02f, 1.04289159e-01f, -1.45117939e-02f, 4.92553562e-02f, 8.64348747e-03f,
  -3.08540417e-03f, -2.64284294e-02f, 2.40746718e-02f, 8.00046846e-02f, 7.00846463e-02f, 5.88638298e-02f, -4.13599052e-02f, 9.42956433e-02f, -2.07418818e-02f, 2.82779727e-02f,
  -3.41799669e-02f, 1.26315346e-02f, 6.39251694e-02f, 4.97638211e-02f, 2.46270485e-02f, 1.79726467e-01f, 7.11894259e-02f, 1.87490007e-03f, 8.01344514e-02f, 9.19922218e-02f,
  3.52140933e-01f, -2.29163527e-01f, -5.80061562e-02f, -1.98317736e-01f, -2.41860047e-01f, -1.66457072e-01f, 6.81011565e-03f, -1.28002599e-01f, -1.01326771e-01f, 4.35884073e-02f,
  -1.93187684e-01f, 8.25805403e-03f, 5.48927039e-02f, 9.74003971e-02f, 1.19689219e-01f, 1.12461597e-01f, 9.11107287e-03f, 1.64265245e-01f, 9.33290049e-02f, 1.46376556e-02f,
  -5.87490527e-03f, -3.90496626e-02f, 1.69368267e-01f, 1.42522305e-01f, 7.76700750e-02f, 1.61597848e-01f, -1.02133684e-01f, -6.29442260e-02f, 6.74313167e-03f, 2.52325445e-01f,
  1.91015586e-01f, -8.43257532e-02f, 1.27307232e-02f, 1.07547536e-01f, -7.22476020e-02f, 4.86943573e-02f, 9.04842988e-02f, 1.60590913e-02f, -9.35173482e-02f, 7.70733878e-02f,
  -8.46792236e-02f, 2.06252430e-02f, -6.48009107e-02f, 4.40340340e-02f, -5.81938513e-02f, -4.69839722e-02f, -3.94422449e-02f, -1.21316668e-02f, -3.87199633e-02f, 3.74221019e-02f,
  -8.49800110e-02f, 5.05346665e-03f, -9.08488780e-03f, -7.16565028e-02f, 3.80582474e-02f, -8.48776624e-02f, 6.70724586e-02f, 1.42717689e-01f, 1.00842111e-01f, 2.35808685e-01f,
  1.26937404e-01f, 3.30608425e-04f, -1.21061817e-01f, 2.95951422e-02f, -2.11829413e-02f, -2.61320639e-02f, -3.99828441e-02f, -5.81874885e-02f, 3.13071609e-02f, -5.04255146e-02f,
  -3.77559811e-02f, -3.03218272e-02f, -2.05347594e-02f, 8.89370143e-02f, -4.57414426e-02f, -4.89177331e-02f, 3.31030190e-02f, 3.93452272e-02f, 5.60811050e-02f, 5.66434897e-02f,
  -3.87591198e-02f, -8.40872899e-03f, -2.56707962e-03f, 1.22186907e-01f, 2.85302158e-02f, -1.98692009e-02f, -4.08743471e-02f, -2.15142425e-02f, 1.80024758e-03f, -2.26928666e-02f,
  -8.57356191e-02f, -8.64361823e-02f, 2.52801865e-01f, 2.36733388e-02f, 1.41859129e-02f, -8.62057600e-03f, 5.97797446e-02f, -8.08814391e-02f, -4.41939272e-02f, 3.34400982e-02f,
  -6.29371703e-02f, 1.04850903e-02f, -3.53383422e-02f, 6.05284832e-02f, -4.02402468e-02f, 7.54573941e-02f, -5.51009364e-02f, 4.12582941e-02f, -7.01239780e-02f, -9.13862363e-02f,
  -1.75780747e-02f, -9.08467453e-03f, 1.59315199e-01f, 9.23214480e-02f, 3.83933559e-02f, 9.10189748e-02f, 1.15297422e-01f, 2.32704710e-02f, 1.71136066e-01f, 1.24406092e-01f,
  9.13041830e-02f, 3.14061791e-02f, 1.04265930e-02f, 7.42871836e-02f, -1.57895647e-02f, -9.14912391e-03f, 4.68822792e-02f, 1.08590439e-01f, -7.83297140e-03f, -3.88257112e-03f,
  -4.02783491e-02f, -1.79489981e-02f, -5.87852821e-02f, 6.23271391e-02f, 2.14436371e-02f, -6.30239248e-02f, 1.11377999e-01f, -2.08122451e-02f, 8.91143382e-02f, 1.09393299e-02f,
  5.45609295e-02f, 1.30665421e-01f, -3.07202116e-02f, 1.01807721e-01f, 1.63655933e-02f, -2.43095141e-02f, -1.00557312e-01f, 8.97092745e-02f, -1.14319734e-01f, 2.81458423e-02f,
  -1.43633053e-01f, 6.50815293e-02f, -2.23586056e-02f, 1.82990823e-03f, -3.39725614e-02f, -6.72843978e-02f, -7.39689916e-02f, -4.73801829e-02f, 7.16010183e-02f, 5.85014839e-03f,
  3.09842266e-02f, -3.39347683e-02f, 6.34387415e-03f, -5.17088473e-02f, 1.67755466e-02f, -5.85742062e-03f, 1.24258853e-01f, -1.49272345e-02f, 2.84738336e-02f, 8.01676065e-02f,
  9.12756026e-02f, 2.66102757e-02f, 6.37915060e-02f, -2.07302179e-02f, -3.69117260e-02f, -4.16922793e-02f, 2.10120920e-02f, -4.82807048e-02f, -4.78786640e-02f, -1.76414922e-01f,
  -1.32766277e-01f, 9.47945714e-02f, 1.59287646e-01f, 8.74221623e-02f, -5.56703238e-03f, 1.08104184e-01f, -9.31196194e-03f, 9.84724462e-02f, 1.34385094e-01f, 9.54978839e-02f,
  1.39813930e-01f, 2.15815883e-02f, 1.03258826e-01f, 9.45636109e-02f, -1.86625086e-02f, 6.09261356e-02f, 8.91693011e-02f, 1.17914572e-01f, -1.35159874e-02f, 7.90990368e-02f,
  9.92084946e-03f, 1.09238587e-02f, 7.29634762e-02f, 1.50522217e-01f, 7.92292804e-02f, 4.14715558e-02f, 1.37540385e-01f, 4.93176840e-02f, 1.55915413e-03f, 9.00055282e-03f,
  -1.98077768e-01f, 1.94743350e-01f, 1.44513343e-02f, -2.13465607e-03f, -9.59805250e-02f, -1.03166409e-01f, -1.95015352e-02f, -1.84865203e-02f, 1.61233060e-02f, -6.98453337e-02f,
  -6.59160241e-02f, -3.69673669e-02f, 6.01322502e-02f, 7.90067837e-02f, -4.13380042e-02f, 5.08150458e-02f, -8.42170715e-02f, -2.25787535e-02f, -3.26598529e-03f, 4.81136031e-02f,
  3.72806266e-02f, -9.61675271e-02f, -9.54619348e-02f, -9.42623168e-02f, 2.66925078e-02f, -1.08612381e-01f, -1.81062564e-01f, -1.43859357e-01f, -9.81423333e-02f, -1.38993561e-01f,
  -2.31442273e-01f, 3.07121307e-01f, 1.50180280e-01f, 2.57301331e-02f, 2.26054594e-01f, 5.90009503e-02f, 2.46849567e-01f, -1.34382313e-02f, -1.44551635e-01f, 1.83384076e-01f,
  9.32376310e-02f, -7.12999925e-02f, -7.25721493e-02f, -3.32559049e-02f, -1.62504613e-01f, 2.66910136e-01f, 9.98160541e-02f, -8.41004476e-02f, -2.77776301e-01f, -1.95652708e-01f,
  1.67610236e-02f, -4.70392779e-02f, -1.96054533e-01f, -1.49037182e-01f, 4.39986512e-02f, -4.04330790e-02f, 2.33785212e-01f, -3.41237523e-02f, 1.62611887e-01f, 2.75374800e-01f,
  1.84407070e-01f, 1.86841860e-01f, 8.75021424e-03f, 5.09470813e-02f, 5.01555465e-02f, 7.10158795e-02f, -2.14524493e-02f, 9.37348977e-02f, 3.03153917e-02f, -2.87314178e-03f,
  1.15516581e-01f, -3.99537273e-02f, 3.77858952e-02f, -3.63655016e-02f, 5.33509143e-02f, 8.50977153e-02f, -4.20607403e-02f, -1.88205875e-02f, -4.99064010e-03f, 1.54927939e-01f,
  9.91118848e-02f, 1.64566845e-01f, 8.09111670e-02f, 9.53012407e-02f, -3.90947200e-02f, 2.02584732e-02f, 4.91024740e-02f, 1.08954802e-01f, 3.07476316e-02f, 1.22985870e-01f,
  2.69126147e-02f, 5.09662516e-02f, 2.25879624e-02f, 2.36012023e-02f, -2.99536828e-02f, 6.40644804e-02f, -7.65333930e-03f, -4.00655270e-02f, 2.85839979e-02f, -1.22773862e-02f,
  -1.99923534e-02f, 4.72921468e-02f, -4.24152380e-03f, 6.75871298e-02f, -8.94815754e-03f, 2.55301651e-02f, -4.22147103e-02f, 1.62610915e-02f, 2.45350003e-02f, 8.58088955e-03f,
  -6.11036494e-02f, 4.99597266e-02f, -1.97489802e-02f, -4.91673574e-02f, -4.37617376e-02f, -3.02834250e-02f, -6.94351364e-03f, -5.73637197e-03f, -2.48378702e-02f, 9.60261037e-04f,
  -1.58069387e-01f, 5.36695793e-02f, 5.89427091e-02f, -1.52611556e-02f, 8.54197517e-02f, -1.59761019e-03f, 1.19173862e-01f, -1.25163672e-02f, -3.33454534e-02f, 3.85618582e-02f,
  -4.24078219e-02f, 1.74867827e-03f, 1.35203496e-01f, 5.62672839e-02f, -9.98740345e-02f, -3.68771963e-02f, 8.38261843e-02f, -4.73276041e-02f, -4.16195355e-02f, 3.42058316e-02f,
  7.37952888e-02f, -3.78129333e-02f, -4.93616657e-03f, 1.03654508e-02f, 9.50323492e-02f, -3.10238525e-02f, 9.50781330e-02f, -8.33626986e-02f, -5.81875928e-02f, 7.69461840e-02f,
  -1.21663518e-01f, 2.41051763e-01f, 2.17480540e-01f, -2.96733249e-02f, 1.65146351e-01f, 2.46189639e-01f, 3.56209576e-01f, 1.72396287e-01f, 8.95640627e-02f, 2.18769357e-01f,
  1.58476502e-01f, 8.82775262e-02f, 1.19389921e-01f, 1.05004117e-01f, 1.87804848e-01f, 1.33130580e-01f, -7.37849921e-02f, -7.90257528e-02f, -2.21978649e-02f, -3.11438087e-02f,
  -1.35909721e-01f, -2.24887133e-01f, -2.34535411e-01f, -4.44266833e-02f, -2.97073424e-01f, -2.35269815e-01f, -5.65156080e-02f, -2.51092970e-01f, -8.49593505e-02f, -4.08372492e-01f,
  -9.89286602e-02f, 1.45269865e-02f, 1.94076255e-01f, -2.59556007e-02f, 7.36542568e-02f, 4.15034667e-02f, 1.34089008e-01f, 4.56432700e-02f, 1.19055152e-01f, 3.19550000e-02f,
  6.13808744e-02f, 7.68455938e-02f, 3.63854691e-02f, -3.75366062e-02f, 1.37331141e-02f, 1.04933783e-01f, 3.23201679e-02f, 7.07355812e-02f, 3.94208059e-02f, 3.85805741e-02f,
  1.34309903e-01f, -8.88764635e-02f, -3.72012705e-02f, 7.64758214e-02f, 1.32597670e-01f, 4.67091165e-02f, -7.08794966e-02f, -8.70735645e-02f, -5.59278950e-02f, -1.19498961e-01f,
  7.29756355e-02f, -3.27807330e-02f, 1.83268301e-02f, -2.43106745e-02f, 1.34101985e-02f, -7.18893763e-03f, 3.97832319e-02f, -8.96183997e-02f, -4.91874963e-02f, -3.90551388e-02f,
  3.79273407e-02f, 5.44616953e-02f, -8.99792910e-02f, 4.29630019e-02f, -2.21025087e-02f, -4.53811027e-02f, 1.11800907e-02f, -7.89454430e-02f, -5.11027575e-02f, -3.62625048e-02f,
  -3.46431434e-02f, -1.13046326e-01f, -4.30227257e-02f, -1.01716436e-01f, -7.23688528e-02f, -8.94206464e-02f, -8.28896984e-02f, -4.24518809e-02f, 3.08813788e-02f, -1.06519796e-01f,
  -5.77234365e-02f, 2.88429499e-01f, -2.61112675e-02f, -8.35158974e-02f, 8.92601907e-02f, -4.26434763e-02f, 8.56283009e-02f, 8.47739279e-02f, 6.66399822e-02f, 2.07477901e-02f,
  1.80757046e-01f, 4.27478142e-02f, 1.71408907e-01f, 1.40454546e-02f, 1.13005102e-01f, 1.54514611e-01f, 1.37559488e-01f, 2.20429935e-02f, 1.27739578e-01f, -4.79598111e-03f,
  3.61001603e-02f, 4.96394001e-02f, 3.37297805e-02f, 1.16589226e-01f, 9.54471901e-02f, 2.18167938e-02f, -5.20063341e-02f, 4.80041280e-02f, 9.88247842e-02f, 2.99481638e-02f,
  3.98589224e-01f, 2.12052017e-02f, 2.62389891e-02f, 1.17703997e-01f, -1.06958978e-01f, -2.17036009e-01f, -1.02036141e-01f, -2.10369825e-01f, 6.56510517e-02f, 1.79337040e-01f,
  6.50516944e-03f, -1.16820633e-03f, 6.92787543e-02f, -5.73993362e-02f, -1.62455171e-01f, -5.75616397e-02f, -7.14760646e-02f, -5.96890934e-02f, -1.60194144e-01f, -2.09819302e-02f,
  -1.66073367e-01f, 2.47522946e-02f, -3.30926441e-02f, -5.66404983e-02f, 4.00285721e-02f, 5.70044853e-02f, 7.27047073e-03f, -1.13130054e-02f, -1.34257093e-01f, 4.02008966e-02f,
  2.51592427e-01f, 7.90798143e-02f, -2.77811233e-02f, -8.07483401e-03f, 2.77946750e-03f, 2.36146133e-02f, 5.78600205e-02f, 5.82066514e-02f, 1.36999199e-02f, -1.95153579e-02f,
  3.77312377e-02f, 2.40106024e-02f, -1.81633942e-02f, 6.19665161e-03f, -5.02526015e-02f, -3.83979757e-03f, -2.04370935e-02f, -9.89770666e-02f, -7.90697783e-02f, 5.80003783e-02f,
  -6.56597912e-02f, -7.57281333e-02f, 4.77538817e-03f, -1.29401520e-01f, -3.80099341e-02f, -1.09546408e-01f, 5.12259314e-03f, -1.92349486e-03f, -8.66319388e-02f, 1.03195429e-01f,
  -3.78365815e-02f, 2.90138256e-02f, 1.11624515e-02f, 7.65900761e-02f, 3.12500522e-02f, 3.88839580e-02f, 4.54461165e-02f, 4.94239256e-02f, -7.34020174e-02f, 1.00477323e-01f,
  -4.31348644e-02f, 2.67439764e-02f, 2.64645722e-02f, 4.94306022e-03f, 3.65151167e-02f, 1.20088141e-02f, -3.05593219e-02f, 9.71795768e-02f, -1.28468480e-02f, -2.34481506e-02f,
  -1.97609402e-02f, -4.32794821e-03f, 3.33759002e-02f, -4.91489619e-02f, -7.68801197e-02f, 3.63012031e-02f, 6.52251765e-02f, 2.30783261e-02f, 2.67421678e-02f, -1.29601927e-02f,
  2.74329901e-01f, -8.84305537e-02f, 2.90960930e-02f, -4.59483229e-02f, -3.07854302e-02f, -3.25814933e-02f, 2.73518451e-02f, 4.14158627e-02f, 7.38900229e-02f, 4.28263098e-02f,
  8.77658837e-03f, -1.17804771e-02f, 3.44504714e-02f, -8.69485289e-02f, 8.24096240e-03f, -5.77872507e-02f, -8.70031863e-02f, 3.54689322e-02f, -3.67830042e-03f, 2.92632561e-02f,
  -1.45938486e-01f, 4.54643629e-02f, 1.19510546e-01f, -2.37731375e-02f, -6.42948831e-03f, -9.29263420e-03f, 2.31065564e-02f, 4.76521924e-02f, 2.27568801e-02f, 2.07764521e-01f,
  3.98715526e-01f, 1.31172519e-02f, -1.31012112e-01f, -1.36453763e-01f, -3.01519632e-01f, -1.26846433e-01f, 3.86914387e-02f, 3.33227776e-02f, -1.90922897e-02f, -1.45357773e-01f,
  -1.50195271e-01f, -3.12382787e-01f, -2.14791894e-01f, -2.07502648e-01f, -5.52356765e-02f, -1.26503125e-01f, -1.98158711e-01f, -3.58956046e-02f, -5.06558977e-02f, -1.46657735e-01f,
  -1.76222950e-01f, -1.85939595e-02f, 2.17000917e-01f, 5.23732277e-03f, -9.42258611e-02f, -1.67647585e-01f, -1.32920310e-01f, -1.17272943e-01f, -7.83014223e-02f, -1.06886096e-01f,
  -1.67971209e-01f, 1.02435671e-01f, -1.33996904e-01f, -7.23657534e-02f, -1.25831276e-01f, -3.74535210e-02f, -1.80499420e-01f, -1.19898558e-01f, -2.13713855e-01f, -1.74271792e-01f,
  -2.54116446e-01f, -2.47202888e-01f, -2.26341039e-01f, -9.57075208e-02f, -6.10188134e-02f, -9.14178863e-02f, -5.97812906e-02f, -6.63029179e-02f, -4.53743339e-02f, -1.03080526e-01f,
  -2.15280294e-01f, -1.90284848e-01f, 3.23117338e-02f, -1.34663582e-01f, -9.76984128e-02f, -1.28196329e-01f, -9.67942402e-02f, -9.43743810e-02f, -6.06282428e-02f, -4.56714891e-02f,
  7.53704971e-03f, 5.05926758e-02f, 5.17582372e-02f, 1.67892531e-01f, 7.11023575e-04f, 3.88688333e-02f, -2.06198078e-02f, -4.25723717e-02f, 4.14344948e-03f, 1.14605457e-01f,
  8.75618234e-02f, 6.32882044e-02f, -2.29916051e-02f, 5.92209399e-02f, -2.87845135e-02f, 3.50478888e-02f, 1.63243227e-02f, 1.46478921e-01f, 7.07669929e-02f, 1.40385851e-01f,
  9.16257352e-02f, 7.53709003e-02f, 1.33286089e-01f, 5.32671511e-02f, 1.48362875e-01f, 7.52936974e-02f, 1.29136100e-01f, 2.69265976e-02f, 4.76719104e-02f, 1.22033454e-01f,
  -1.95831303e-02f, -1.35622203e-01f, -1.67478770e-01f, -1.72786370e-01f, -1.96923733e-01f, -1.46594703e-01f, -1.80460006e-01f, -1.12571806e-01f, -2.06152424e-01f, -5.37173077e-02f,
  -2.00972319e-01f, -1.31800562e-01f, -1.92053273e-01f, -1.84191167e-01f, -1.84468806e-01f, -1.80499628e-01f, -2.05677688e-01f, -1.63649976e-01f, -2.15399966e-01f, -1.16428353e-01f,
  -1.38843000e-01f, -1.33086577e-01f, 1.87438782e-02f, -5.79307228e-02f, -1.84570178e-01f, -7.47778416e-02f, -2.31510580e-01f, -1.11934789e-01f, -6.95964172e-02f, -9.73819196e-03f,
  -1.43701583e-01f, 2.60186404e-01f, -6.53979927e-02f, -1.66910363e-03f, 2.43668601e-01f, 1.15331739e-01f, 2.95506984e-01f, 2.72000134e-01f, 3.82429808e-02f, 7.53771961e-02f,
  2.19018832e-01f, -6.07181564e-02f, -1.15435258e-01f, -2.46482305e-02f, 3.13987620e-02f, 3.06580565e-03f, -1.89709559e-01f, -2.47121409e-01f, -8.73088017e-02f, -2.10104696e-02f,
  3.70127521e-02f, -4.35686223e-02f, -7.15420544e-02f, 4.71503772e-02f, -7.95348287e-02f, -1.51486471e-01f, 1.80710461e-02f, -5.61869778e-02f, 7.27016628e-02f, -1.48218110e-01f,
  -2.13307649e-01f, 1.36572942e-01f, 7.50141870e-03f, 1.58098534e-01f, 8.46957117e-02f, 4.64906171e-02f, 1.07911766e-01f, 1.48825916e-02f, 1.48830757e-01f, 1.04345500e-01f,
  1.48160174e-01f, 1.51224405e-01f, -5.66456616e-02f, 1.03057809e-01f, 5.75473793e-02f, 1.07877575e-01f, -5.83265070e-03f, 9.01217945e-03f, 8.91156569e-02f, 1.22008212e-01f,
  1.37179315e-01f, 1.46389768e-01f, 1.14558809e-01f, 1.55006960e-01f, 1.24507159e-01f, -1.55588228e-03f, 1.23640507e-01f, 6.52907491e-02f, 1.20359264e-01f, 1.40409306e-01f,
  -1.20418794e-01f, 5.44616114e-03f, -1.66952666e-02f, 2.07977388e-02f, 1.07972778e-01f, 3.60960923e-02f, 4.04970068e-03f, 1.08613204e-02f, -1.55810909e-02f, -8.68256390e-03f,
  8.00998043e-03f, -3.74942943e-02f, -4.24707346e-02f, -7.03219473e-02f, -1.06433608e-01f, -1.29646342e-03f, -4.76315767e-02f, 6.59087347e-03f, -7.44439363e-02f, 1.49998991e-02f,
  1.70767251e-02f, -5.29467836e-02f, -1.74447317e-02f, -3.86571325e-02f, -8.61984640e-02f, -1.50532737e-01f, -9.68247950e-02f, -1.36876097e-02f, 2.55047474e-02f, -9.99355763e-02f,
  -5.52931353e-02f, 8.36709738e-02f, -2.96621509e-02f, -2.15057265e-02f, 7.17306789e-03f, 4.70175706e-02f, 3.69194746e-02f, 3.81439854e-03f, 1.11987665e-01f, 8.44350681e-02f,
  1.19770393e-01f, -7.17790499e-02f, -2.85606328e-02f, 4.74789627e-02f, -3.69407050e-02f, 1.17660694e-01f, 1.35006860e-01f, 3.88580486e-02f, 1.23417482e-01f, 1.51215598e-01f,
  1.06314175e-01f, 6.72477558e-02f, 6.61529824e-02f, 2.93546207e-02f, 9.40036699e-02f, 1.55171407e-02f, -4.72769327e-02f, 3.59847620e-02f, 9.74762589e-02f, 4.06978577e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.08235091e-01f, 4.81220424e-01f, -1.42746523e-01f, 3.69493663e-02f, 2.39673108e-01f, 1.16469108e-01f, 2.61208117e-01f, 5.44286054e-03f, -8.10496658e-02f, 1.31924495e-01f,
  9.10155922e-02f, 6.93471506e-02f, 3.92519794e-02f, 4.49306369e-02f, -1.37676015e-01f, 1.37835547e-01f, 1.03508681e-01f, -6.37070136e-03f, -1.97296754e-01f, 5.35171703e-02f,
  1.46343529e-01f, -1.64975990e-02f, -1.64410666e-01f, -1.52739227e-01f, 1.22656964e-01f, -8.59239548e-02f, 6.10858537e-02f, 1.50811121e-01f, 1.26775295e-01f, 2.28709400e-01f,
  -1.59458399e-01f, 7.43728131e-02f, -1.64550841e-01f, 2.23578885e-01f, 2.08831136e-03f, -1.01682775e-01f, -9.12192091e-03f, -1.70043752e-01f, -9.62370187e-02f, 5.87107129e-02f,
  1.40035212e-01f, 1.09686948e-01f, 5.20766601e-02f, -1.09219439e-01f, -2.06349105e-01f, -7.15151131e-02f, -2.12446675e-01f, -2.26299003e-01f, -2.71913499e-01f, -1.93533689e-01f,
  3.57497275e-01f, 2.62761950e-01f, -1.35733172e-01f, 2.84326412e-02f, -8.49017724e-02f, -1.02777608e-01f, -1.92160085e-01f, -5.09445108e-02f, -1.44290790e-01f, -1.05961911e-01f,
  9.06382576e-02f, 1.77071691e-02f, 7.11493790e-02f, 1.23844743e-02f, 1.25068560e-01f, 9.88207832e-02f, 3.04366332e-02f, 1.28160074e-01f, 2.47915257e-02f, -2.13371776e-02f,
  6.37760684e-02f, -2.01639742e-01f, -1.06977172e-01f, -9.23529193e-02f, -1.04303449e-01f, 6.65437654e-02f, 1.53510999e-02f, -4.40837927e-02f, -9.12813619e-02f, -1.00376345e-02f,
  -3.23090516e-02f, 2.71690525e-02f, -1.15671307e-01f, -1.18045025e-01f, 4.43578660e-02f, -2.54397001e-02f, 7.10892305e-02f, -4.53214115e-03f, -1.66303664e-02f, 2.32789647e-02f,
  -3.24516386e-01f, -1.12630993e-01f, -8.59143212e-02f, 1.46369025e-01f, 9.95336473e-02f, -4.42135409e-02f, -1.06170617e-01f, 5.33882203e-03f, -1.12396013e-02f, 3.98655646e-02f,
  -4.15820330e-02f, -1.28199339e-01f, 2.27239402e-03f, -3.02078784e-01f, -1.06288821e-01f, 3.47440578e-02f, 3.73883545e-02f, -1.38237894e-01f, -6.40765950e-02f, -7.53136501e-02f,
  2.28353031e-02f, -6.23428188e-02f, -1.37909576e-01f, -9.28237066e-02f, -1.24624759e-01f, -4.02988531e-02f, -6.87332526e-02f, -2.09661230e-01f, -1.40389860e-01f, -1.26520857e-01f,
  4.02254909e-01f, -1.13916002e-01f, 2.20122248e-01f, 4.85216975e-02f, 2.79308632e-02f, -6.20504320e-02f, -7.96781108e-02f, 1.79032292e-02f, 3.40639949e-02f, 1.25036925e-01f,
  5.36950231e-02f, 1.93786070e-01f, 1.66189253e-01f, 2.06150442e-01f, 1.93576217e-01f, 4.39807773e-02f, 8.49441737e-02f, 2.41503462e-01f, 2.63962358e-01f, 2.00250953e-01f,
  8.70164856e-02f, 2.80370116e-02f, 1.41042143e-01f, 1.53779224e-01f, 3.77063006e-02f, 7.81333521e-02f, 8.48470479e-02f, 7.61433244e-02f, -5.21651432e-02f, 1.66333057e-02f,
  1.71124309e-01f, -2.49092449e-02f, 1.01508694e-02f, 2.23033614e-02f, -1.04172461e-01f, 9.24263820e-02f, 2.66011879e-02f, 3.57899815e-02f, -7.11261630e-02f, -1.35961697e-01f,
  1.43013066e-02f, 9.15656164e-02f, 1.33702779e-04f, 3.45693417e-02f, -3.79631817e-02f, -1.71105773e-03f, 3.81450425e-03f, 5.92792640e-03f, -1.03961937e-01f, 8.23657960e-02f,
  -3.82655002e-02f, -8.09351820e-03f, 7.57770799e-03f, -8.84461924e-02f, -2.35578679e-02f, -6.54797703e-02f, -4.06070799e-02f, 7.43736997e-02f, 5.03799431e-02f, 1.07698955e-01f,
  3.48977856e-02f, 1.47009447e-01f, 2.38511160e-01f, 1.85616553e-01f, 2.30084717e-01f, 1.22801699e-01f, -5.91925811e-03f, 5.82376905e-02f, 1.67734116e-01f, 2.01185688e-01f,
  1.22871168e-01f, 1.89130306e-01f, 5.83738349e-02f, 6.87726513e-02f, 4.62724566e-02f, 3.46501656e-02f, 7.42297545e-02f, 3.96867506e-02f, -4.55994159e-02f, 4.64672148e-02f,
  1.09482691e-01f, 1.59063399e-01f, 1.70154244e-01f, 1.03143305e-01f, 4.03883979e-02f, 1.07773803e-02f, 1.54744148e-01f, 6.36753514e-02f, 1.12972423e-01f, 7.63427392e-02f,
  -2.97626346e-01f, -6.08850345e-02f, 2.23613918e-01f, 8.78833756e-02f, -8.50627273e-02f, -1.50709063e-01f, 4.51868773e-02f, -2.03017220e-02f, -1.86447188e-01f, -1.52603731e-01f,
  -1.09062932e-01f, -2.30153534e-03f, -1.74796011e-03f, -5.05861156e-02f, 1.34060085e-01f, -7.94190988e-02f, -1.25622228e-01f, -1.09316535e-01f, -1.14823677e-01f, -1.26504064e-01f,
  -3.80939874e-03f, -1.12304762e-02f, -5.18783741e-03f, -6.40338287e-03f, -1.87246297e-02f, 8.04321393e-02f, 1.46068707e-02f, 2.80435588e-02f, -6.56602308e-02f, 1.20688766e-01f,
  -2.92879462e-01f, -2.01339766e-01f, 1.00418694e-01f, 4.08856608e-02f, 2.55352348e-01f, -9.72858965e-02f, -4.33504492e-01f, -4.19927657e-01f, -2.09568199e-02f, 4.32705879e-02f,
  1.62716120e-01f, 2.46153012e-01f, 1.01022586e-01f, -4.76819985e-02f, -3.44084054e-01f, -2.37759173e-01f, 3.53729390e-02f, -7.14720935e-02f, -1.75787270e-01f, 1.36786513e-02f,
  6.31927773e-02f, 8.61867666e-02f, -1.09843602e-02f, 5.86605519e-02f, 1.08589292e-01f, 1.75697103e-01f, 2.02741578e-01f, 2.18706831e-01f, 8.15759823e-02f, 2.04833634e-02f,
  1.91676065e-01f, 5.40532023e-02f, -5.06485552e-02f, 1.14499882e-01f, 2.55275249e-01f, -2.03985095e-01f, -9.81997475e-02f, 5.32554276e-02f, -3.35025601e-02f, -1.75735215e-03f,
  2.64125437e-01f, 5.13373241e-02f, 1.59891590e-01f, 2.85382085e-02f, 5.16100936e-02f, -1.12695515e-01f, 9.29356180e-03f, -1.70797572e-01f, -3.47942561e-01f, -2.88704664e-01f,
  -4.41917218e-03f, 1.19676657e-01f, -1.48503080e-01f, -2.54360050e-01f, -3.06874603e-01f, -1.21205926e-01f, -1.37133732e-01f, -2.07320094e-01f, -2.22358838e-01f, -3.36474925e-01f,
  -7.97307864e-02f, -1.94944758e-02f, -5.23564480e-02f, -6.98541990e-03f, -6.63671494e-02f, 1.63430542e-01f, 1.21559538e-01f, 2.57571395e-02f, 7.48365000e-02f, -7.93937743e-02f,
  2.68556774e-02f, -8.46560523e-02f, -5.18886410e-02f, -6.66104909e-03f, 1.26325056e-01f, -6.46698996e-02f, -6.15488701e-02f, -1.08466841e-01f, -3.06631289e-02f, 3.44377197e-02f,
  3.03531494e-02f, 8.13988671e-02f, 2.27456152e-01f, -8.96848664e-02f, 1.95073839e-02f, -2.03869790e-02f, 9.13275480e-02f, -1.35049149e-01f, -1.12205349e-01f, -2.76151970e-02f,
  -8.92812237e-02f, 2.45584875e-01f, -4.51207198e-02f, -6.34853914e-02f, 3.87891196e-02f, 3.26312669e-02f, 4.20497619e-02f, 1.21893279e-01f, 4.85643633e-02f, -9.93853807e-02f,
  -1.35388330e-03f, -9.22705159e-02f, 1.17892839e-01f, -3.48878801e-02f, -2.40556411e-02f, -4.98837866e-02f, -2.25397740e-02f, 9.91079658e-02f, -1.14295453e-01f, -5.42706344e-03f,
  -2.12901458e-01f, -2.05297634e-01f, -1.64062470e-01f, -1.18725903e-01f, -1.29411086e-01f, -6.74521327e-02f, -1.86802119e-01f, -1.39679685e-01f, -2.54323453e-01f, -5.33685923e-01f,
  -5.70443809e-01f, -2.25431144e-01f, -1.79625571e-01f, 8.16809088e-02f, 9.39876363e-02f, 6.97731748e-02f, 1.67692438e-01f, 1.17039703e-01f, 1.34183168e-01f, 5.03207557e-02f,
  -1.22734318e-02f, 1.90857008e-01f, 1.82591453e-01f, 8.08770955e-02f, 9.21218768e-02f, 2.66335666e-01f, 2.54142582e-01f, -4.99030091e-02f, -8.65653902e-03f, 5.58312982e-02f,
  1.38647094e-01f, -3.91209796e-02f, -9.39244404e-02f, 1.30086198e-01f, 8.65197107e-02f, 2.02076197e-01f, 1.53526008e-01f, 2.31454261e-02f, 1.40857741e-01f, 1.90421179e-01f,
  2.28486713e-02f, -3.98734123e-01f, 3.41029800e-02f, -9.06981900e-02f, -1.30313098e-01f, -1.77607983e-01f, -4.84078079e-02f, -1.17580108e-01f, -5.62076829e-02f, 1.55744562e-02f,
  3.65332291e-02f, -1.42601073e-01f, 6.79981634e-02f, -8.37715790e-02f, -3.30121741e-02f, -8.19840953e-02f, -6.66651055e-02f, -1.36021227e-01f, 6.30012006e-02f, -4.85260598e-02f,
  1.03640914e-01f, -1.21275142e-01f, -7.78826848e-02f, 1.79600418e-01f, 9.71178934e-02f, -4.16535325e-02f, -1.43912539e-01f, -1.02528997e-01f, -8.29402134e-02f, -1.25236705e-01f,
  -9.89640877e-03f, 2.60623544e-02f, -8.51279572e-02f, -6.22208044e-02f, 2.85586193e-02f, 4.13644612e-02f, 1.11745093e-02f, 7.74561018e-02f, 1.26168251e-01f, 1.24667034e-01f,
  5.75620718e-02f, 4.02059667e-02f, 6.81124702e-02f, 6.03372455e-02f, 1.05719917e-01f, -3.17532718e-02f, -1.94281470e-02f, 4.94401120e-02f, -4.80616130e-02f, -2.26044450e-02f,
  -3.86394486e-02f, 4.79209721e-02f, -7.31669441e-02f, 1.16657250e-01f, 2.86952872e-02f, 9.06609278e-03f, 8.97604078e-02f, -4.13703434e-02f, -2.43012886e-02f, -5.38763031e-03f,
  3.60211939e-01f, -5.89442812e-02f, 4.71429229e-02f, 1.12494521e-01f, 2.38407310e-02f, -2.40880717e-02f, -2.48880740e-02f, -1.36195971e-02f, -4.38032486e-02f, 1.06855281e-01f,
  -1.23817258e-01f, 1.48187671e-02f, -2.76416074e-02f, -4.74319980e-02f, 8.39518160e-02f, 9.52425599e-02f, -9.91667248e-03f, 4.96139713e-02f, -4.69196914e-03f, 9.98239741e-02f,
  1.11153442e-02f, 3.37097608e-02f, 6.38718382e-02f, 2.47159854e-01f, 4.07304354e-02f, 3.77591290e-02f, 1.32486880e-01f, 1.30784623e-02f, 1.06109135e-01f, -2.05835216e-02f,
  -1.64706290e-01f, -1.00867011e-01f, 1.14391744e-01f, 2.45497674e-01f, 1.39242768e-01f, 4.67538163e-02f, -6.36660978e-02f, -1.15268588e-01f, 2.99089961e-02f, -3.40216532e-02f,
  -1.17156589e-02f, 2.58394033e-01f, 3.43104303e-01f, 3.30930263e-01f, 1.41878352e-01f, 1.10073179e-01f, 2.34171346e-01f, 1.80948094e-01f, 1.71290651e-01f, -6.28404319e-04f,
  2.07865819e-01f, 1.83101390e-02f, 6.18012901e-03f, 1.19509436e-01f, 1.51183277e-01f, 2.61938930e-01f, -3.07535287e-02f, 3.75832282e-02f, 7.82316830e-03f, 2.48486236e-01f,
  -2.88351513e-02f, -3.71246755e-01f, 2.63844728e-01f, 8.77236724e-02f, 9.16264057e-02f, -3.19758989e-02f, -1.07974887e-01f, -7.49865025e-02f, 3.20855305e-02f, -5.40852770e-02f,
  4.35150899e-02f, -6.68374524e-02f, 1.58196360e-01f, -7.28347525e-02f, -1.54421672e-01f, -9.26864520e-02f, -1.30605131e-01f, -1.16628252e-01f, -2.29398850e-02f, -1.38743773e-01f,
  2.72313207e-01f, -5.19979224e-02f, -8.49335417e-02f, -5.12795523e-02f, -1.69399695e-03f, 1.64339766e-01f, -1.83395743e-01f, -8.61830488e-02f, -1.62732154e-01f, -1.92196012e-01f,
  1.60169415e-02f, 1.61545295e-02f, 4.42556217e-02f, -4.41828966e-02f, 1.16045542e-01f, 2.21904200e-02f, 2.09965985e-02f, -4.38554166e-03f, 7.03863651e-02f, -3.29472795e-02f,
  1.41298547e-01f, 1.19163595e-01f, 6.15374558e-02f, 5.17735668e-02f, 1.21475540e-01f, -1.79509129e-02f, -3.22876424e-02f, -4.59321626e-02f, 3.93885188e-02f, -9.16026384e-02f,
  2.40694135e-02f, 9.76812914e-02f, 9.08889249e-02f, 1.45987675e-01f, -2.68731639e-02f, 1.28886893e-01f, 8.14488530e-02f, 1.55893350e-02f, -4.98398989e-02f, -4.55845371e-02f,
  -3.39092702e-01f, 5.85079640e-02f, -4.18549031e-02f, 6.59824535e-03f, 9.77477357e-02f, -4.84207906e-02f, -8.19691718e-02f, -9.95488241e-02f, -7.46725202e-02f, 3.30195093e-04f,
  -1.74690053e-01f, -1.38734812e-02f, -1.91812392e-03f, -6.41692132e-02f, 7.89791048e-02f, -1.72673821e-01f, -9.57178250e-02f, 5.23811914e-02f, -2.19634902e-02f, -9.09577757e-02f,
  -4.54905890e-02f, -1.08844958e-01f, -1.81731954e-02f, -9.22494233e-02f, -4.42339592e-02f, 2.10267678e-02f, -9.41419005e-02f, -1.71047762e-01f, -1.97507679e-01f, -3.46884668e-01f,
  3.46280962e-01f, -6.20975375e-01f, 2.44375661e-01f, 2.00162128e-01f, 1.00024886e-01f, 2.17706025e-01f, -1.99391365e-01f, -6.77678138e-02f, -2.27037426e-02f, -3.12297136e-01f,
  -4.01678741e-01f, -1.93941861e-01f, -2.19060138e-01f, -1.72015861e-01f, 1.37006622e-02f, -1.62907079e-01f, 5.14970347e-02f, 3.57985348e-01f, 4.79863495e-01f, 4.09237593e-02f,
  -2.97121704e-01f, 3.21134590e-02f, 2.66141593e-01f, 1.08150870e-01f, -2.76463479e-01f, 7.87496660e-03f, -1.44434750e-01f, 2.56864913e-02f, -2.71671057e-01f, -4.09473985e-01f,
  -3.03257797e-02f, -9.56440717e-02f, 1.60187650e-02f, -1.21873043e-01f, -1.34466141e-01f, -6.83652535e-02f, 3.96154374e-02f, -8.28917231e-03f, -8.98893178e-02f, 3.66713777e-02f,
  -7.06255734e-02f, -4.52880450e-02f, 3.85710709e-02f, -1.44957900e-01f, 6.64596409e-02f, 6.08470179e-02f, -5.76600954e-02f, -4.87019718e-02f, -6.41127452e-02f, -1.60915226e-01f,
  -2.21193194e-01f, -8.00327435e-02f, 1.00893982e-01f, 7.34231398e-02f, -1.03490598e-01f, 1.36630982e-01f, -8.80778953e-02f, -4.00083400e-02f, 6.99553192e-02f, -1.23878732e-01f,
  4.24794108e-02f, 1.70574728e-02f, -6.33066148e-02f, -6.40553012e-02f, -6.24636337e-02f, 6.90119639e-02f, 9.97501016e-02f, -2.42814943e-02f, 9.58887301e-03f, -9.07610953e-02f,
  3.51109654e-02f, 1.11041330e-02f, 9.39702168e-02f, -3.59421335e-02f, -8.05495828e-02f, 7.62874484e-02f, 1.04817554e-01f, -1.12040900e-01f, 5.53197265e-02f, -5.24767898e-02f,
  -4.49976251e-02f, 8.14681202e-02f, -9.53599345e-03f, 4.46491502e-02f, -8.43038112e-02f, 5.81932664e-02f, 4.11761217e-02f, -6.61836490e-02f, 3.51812057e-02f, -3.87484767e-02f,
  -8.99071768e-02f, 2.54061013e-01f, -9.61812511e-02f, -9.35212225e-02f, 1.16387330e-01f, -9.16139260e-02f, -9.71949920e-02f, -3.56473476e-02f, 8.63904320e-03f, 8.52998495e-02f,
  1.55906333e-02f, -2.69895121e-02f, -9.77040306e-02f, -3.06069106e-02f, 6.80478066e-02f, -9.35260393e-03f, -8.30093473e-02f, -7.72478059e-02f, -7.15347975e-02f, -5.48966005e-02f,
  2.55500861e-02f, 1.13346912e-01f, 1.17750369e-01f, 2.25365311e-02f, -3.58360000e-02f, 1.18461341e-01f, -2.48100217e-02f, 8.41015726e-02f, 7.76594132e-02f, 8.24343693e-03f,
  -2.88019329e-01f, -2.44748533e-01f, -1.88882411e-01f, -4.13811326e-01f, -2.31716543e-01f, -2.78631896e-02f, -1.95083827e-01f, -1.13487817e-01f, -2.91256160e-01f, -2.04350352e-01f,
  -3.10148355e-02f, 1.57106072e-01f, 1.29584476e-01f, 7.14729503e-02f, 9.19473469e-02f, -2.27438360e-01f, -3.40556622e-01f, -1.59138754e-01f, 3.04692477e-01f, 1.89582705e-01f,
  -1.66363895e-01f, -6.74822181e-02f, 6.55751899e-02f, 1.31176949e-01f, -1.22687235e-01f, 1.41961634e-01f, -4.87815775e-02f, -8.97362381e-02f, 3.04995198e-02f, -2.03676015e-01f,
  8.52679312e-02f, -1.52370259e-01f, 1.53035838e-02f, -1.10936567e-01f, 2.78577060e-02f, -2.98675112e-02f, 1.67353563e-02f, 2.53800657e-02f, 9.15107056e-02f, -6.89132512e-02f,
  -5.28053008e-02f, -4.11490852e-04f, -3.76798026e-02f, 1.99988112e-02f, 2.06812993e-02f, -4.39069420e-02f, -8.89234692e-02f, -5.25344312e-02f, -3.24920528e-02f, 1.58970896e-02f,
  -2.89056916e-02f, -1.64031550e-01f, 3.06577999e-02f, 1.15652815e-01f, 8.25098827e-02f, -8.52570385e-02f, -6.12159725e-03f, 8.12219232e-02f, 1.37397572e-01f, -1.51408374e-01f,
  -1.28841937e-01f, 1.41160679e-03f, -2.37304494e-02f, -3.04634441e-02f, -4.31952961e-02f, 7.86200836e-02f, 1.60282515e-02f, 7.19167888e-02f, 1.13059089e-01f, 3.40165123e-02f,
  -2.10974813e-02f, -3.56399151e-03f, 9.02698189e-02f, 1.15647957e-01f, 2.25499012e-02f, -8.77930149e-02f, 4.14992012e-02f, 4.47593406e-02f, -2.76398845e-02f, -9.70514938e-02f,
  -3.77380960e-02f, 4.67072874e-02f, -6.08590953e-02f, 6.04493879e-02f, -9.76211280e-02f, -4.22112048e-02f, -6.43531308e-02f, -2.92021059e-03f, -6.46474818e-03f, -7.37884790e-02f,
  1.72269240e-01f, 2.00785766e-03f, -7.78187662e-02f, 7.56361708e-02f, -4.61972579e-02f, -3.05615626e-02f, -1.81536879e-02f, -7.21134767e-02f, 2.25409158e-02f, 1.51316123e-03f,
  -3.12388665e-03f, -1.23591283e-02f, -6.44541830e-02f, -7.16986135e-02f, -9.33961719e-02f, 1.31374439e-02f, -1.83395952e-01f, -7.09582418e-02f, 8.34419206e-02f, -3.31828929e-02f,
  -2.16039419e-01f, -9.38722864e-02f, 4.15513888e-02f, 7.69252703e-02f, 4.92655970e-02f, 3.79531682e-02f, 1.51610270e-01f, -2.04066746e-03f, 1.85857281e-01f, -5.45775034e-02f,
  5.30122280e-01f, -2.24332169e-01f, 6.77888617e-02f, 6.32241294e-02f, -1.49009936e-02f, 4.72198538e-02f, -1.34964734e-01f, 2.69996794e-03f, 2.35153362e-02f, 3.48702073e-02f,
  2.08216719e-02f, 2.31254950e-01f, 1.15601324e-01f, 1.32351652e-01f, -3.73279750e-02f, -6.43023150e-03f, -1.06624905e-02f, 1.75141525e-02f, 2.13727698e-01f, 4.08106782e-02f,
  -8.34466890e-02f, -1.30934596e-01f, -3.15244980e-02f, 7.78758749e-02f, -1.48024723e-01f, 6.02533109e-02f, -9.07421559e-02f, -9.80531946e-02f, -5.53647988e-02f, -1.86560184e-01f,
  5.32982163e-02f, 2.55536884e-01f, 1.96108878e-01f, 8.13859254e-02f, 4.65025045e-02f, -2.11620908e-02f, 6.92308247e-02f, -5.39996997e-02f, -7.55090564e-02f, -1.26586348e-01f,
  1.77179519e-02f, 1.49516938e-02f, -7.38546029e-02f, 1.50339929e-02f, -1.01563230e-01f, -1.86209213e-02f, 6.13807254e-02f, 7.11441338e-02f, -1.05144940e-01f, -1.46235933e-03f,
  1.37220882e-02f, -2.54430827e-02f, 8.39069113e-02f, 4.18670438e-02f, 1.04942396e-01f, 1.31140560e-01f, 8.45560804e-03f, 6.78286701e-02f, 4.41040061e-02f, 1.12907127e-01f,
  1.21735573e-01f, 4.99773584e-02f, 1.68824285e-01f, 1.04788095e-01f, 3.50772925e-02f, 4.68591377e-02f, -7.24810883e-02f, 5.99526949e-02f, 3.23467329e-02f, -7.50934705e-02f,
  -7.09508434e-02f, 1.08320467e-01f, 1.86773032e-01f, -4.82777581e-02f, 1.56513378e-01f, 5.10298908e-02f, 3.16179381e-03f, -9.31025818e-02f, 5.70835918e-02f, 4.45622168e-02f,
  -6.98158890e-02f, -2.51150038e-02f, -1.33842379e-01f, -3.75872813e-02f, -1.05312213e-01f, 6.75911605e-02f, 1.59512274e-02f, -3.85452993e-03f, -7.10791424e-02f, -7.29435459e-02f,
  -2.02289015e-01f, 3.69165391e-01f, 8.50061104e-02f, 1.33785293e-01f, 3.17744426e-02f, -8.54167417e-02f, 1.23804592e-01f, -9.27218050e-02f, -1.96794823e-01f, -1.36872694e-01f,
  -1.11936048e-01f, 5.47511950e-02f, 7.44732702e-03f, -8.35028589e-02f, -4.78191562e-02f, -1.30262658e-01f, 3.76625396e-02f, 1.07845142e-01f, 5.31468960e-03f, -1.54816747e-01f,
  -5.20303063e-02f, 5.09866178e-02f, 1.25830352e-01f, 7.31272921e-02f, 3.01424470e-02f, -2.55347136e-02f, -5.00556231e-02f, -9.13010091e-02f, -1.29442355e-02f, -4.54764552e-02f,
  -2.87613153e-01f, -2.36737520e-01f, -4.31303829e-02f, -4.76515830e-01f, -1.99365616e-01f, 5.35649806e-02f, -1.81571573e-01f, -3.79369073e-02f, -1.47325188e-01f, -3.63087773e-01f,
  -1.78634822e-01f, 5.60347773e-02f, -3.30652967e-02f, 2.10397229e-01f, 1.99393600e-01f, -2.31259882e-01f, -1.29878387e-01f, 3.07353679e-02f, 3.84821802e-01f, 1.73772737e-01f,
  -1.19860373e-01f, -1.72602326e-01f, -3.49315666e-02f, 3.58159281e-02f, -4.80732352e-01f, -1.03913918e-01f, -2.24996328e-01f, -1.98641643e-01f, -4.35419045e-02f, -3.87283236e-01f,
  -2.22951934e-01f, -5.75548634e-02f, 1.87504679e-01f, 1.77282654e-02f, -1.03504874e-01f, -1.68491453e-02f, -2.47568432e-02f, -1.11561663e-01f, -4.80293520e-02f, 7.91862905e-02f,
  -8.46505314e-02f, 5.10492511e-02f, -5.33988178e-02f, -2.87224464e-02f, -3.44728455e-02f, 2.69644503e-02f, 3.87760880e-03f, 7.70402774e-02f, 1.25808120e-02f, 7.08266869e-02f,
  -1.61875442e-01f, 3.38030457e-02f, 6.15153164e-02f, 6.66608661e-02f, 1.27002269e-01f, 1.19422719e-01f, 9.86752734e-02f, 1.61470138e-02f, 1.64348558e-01f, -4.19987559e-01f,
  -7.56007507e-02f, -5.01293465e-02f, 1.20465299e-02f, -1.15087479e-01f, 1.39643240e-03f, -1.38058215e-01f, 8.49570427e-03f, 5.02191717e-03f, -1.17391152e-02f, -2.41024178e-02f,
  5.36538884e-02f, 1.42416470e-02f, -7.19981566e-02f, -9.20648202e-02f, 2.17219274e-02f, -9.47549865e-02f, -9.35946256e-02f, -9.40937549e-02f, 3.69433686e-02f, 1.85026880e-02f,
  -3.65679618e-03f, -3.83986868e-02f, -2.07569227e-01f, 2.10563280e-02f, 9.02812034e-02f, 3.29580680e-02f, -3.81814651e-02f, 1.51178032e-01f, -8.40665847e-02f, 7.74441138e-02f,
  -1.54217258e-01f, 2.98983008e-01f, -1.66799486e-01f, -3.24041136e-02f, -1.09673545e-01f, 5.14451154e-02f, -9.46018770e-02f, 7.74106085e-02f, 5.39401062e-02f, -9.80715156e-02f,
  7.49447048e-02f, -1.14195935e-01f, -7.83957839e-02f, -2.81170234e-02f, 1.58346090e-02f, -1.72226913e-02f, -9.07611921e-02f, -4.03048843e-02f, 7.86744580e-02f, 1.87520939e-03f,
  -8.95527601e-02f, 2.80832611e-02f, -2.37834305e-02f, -8.86527300e-02f, -8.95219520e-02f, 1.59590729e-02f, -3.75819430e-02f, -7.19480813e-02f, 7.51629174e-02f, -2.70469934e-01f,
  1.47752047e-01f, 1.23550005e-01f, 1.24065407e-01f, 1.34500682e-01f, 2.55974650e-01f, 3.93237114e-01f, 4.68104362e-01f, 3.17466497e-01f, 2.02109262e-01f, 1.18036687e-01f,
  -3.35409790e-02f, -3.19051057e-01f, -1.40801892e-01f, -2.68776715e-01f, -6.74278662e-02f, 9.21228677e-02f, 4.22981791e-02f, 3.49827409e-02f, 1.23938240e-01f, 4.85992506e-02f,
  -1.27774224e-01f, 1.27598897e-01f, 3.29513140e-02f, -1.29661053e-01f, -7.87557065e-02f, -6.90644309e-02f, 1.62779316e-01f, 7.48940334e-02f, -4.75048386e-02f, -2.88847864e-01f,
  -2.32120231e-01f, -7.71205500e-02f, -9.58528817e-02f, -1.47084415e-01f, 3.38691399e-02f, -4.91259433e-02f, 5.93842231e-02f, -1.29528837e-02f, 1.42661616e-01f, 1.72395688e-02f,
  -3.69287729e-02f, -3.10867373e-02f, 1.24112807e-01f, 8.14542733e-03f, 1.28957227e-01f, 5.22885025e-02f, 6.17308579e-02f, 1.84631244e-05f, 2.84406263e-02f, -1.70396026e-02f,
  -7.81333596e-02f, 2.06112117e-01f, 3.40658635e-01f, 9.70426798e-02f, 4.71845735e-03f, -1.14762201e-03f, 4.63592149e-02f, 1.60598475e-02f, -5.08635566e-02f, 4.67312383e-03f,
  7.41072744e-02f, -2.50004288e-02f, -5.12286462e-02f, 4.08669896e-02f, -5.73579594e-02f, -1.72316432e-02f, 1.21315122e-02f, 3.21541051e-03f, 5.99459894e-02f, 4.39470559e-02f,
  6.76239189e-03f, -5.51321879e-02f, -3.57830785e-02f, -9.42204669e-02f, -1.76878393e-01f, 1.04953222e-01f, -5.14401197e-02f, -1.03895739e-01f, -7.80320838e-02f, 6.10558577e-02f,
  2.10609362e-02f, 9.69603658e-03f, -8.93798023e-02f, 2.76661422e-02f, -6.63843453e-02f, 3.20011824e-02f, -5.87409809e-02f, -6.70175208e-03f, -2.06943545e-02f, 2.59799361e-02f,
  1.14201149e-02f, -7.72390366e-02f, -2.08373562e-01f, -5.82238175e-02f, 1.26579795e-02f, -6.91029429e-02f, -2.07617149e-01f, -1.67534664e-01f, 2.18076594e-02f, -4.49806079e-02f,
  -4.47055921e-02f, -8.56082067e-02f, -2.15575583e-02f, 1.29290426e-03f, 1.83099046e-01f, -1.18059879e-02f, -1.09252833e-01f, 3.54043953e-02f, -7.47617409e-02f, -7.28780553e-02f,
  -1.41039521e-01f, 3.82483639e-02f, 2.30897263e-01f, -4.00709473e-02f, -8.66550282e-02f, -9.04461741e-02f, 6.90975040e-02f, 7.46110901e-02f, 1.59333795e-02f, 7.86873326e-02f,
  -4.57912028e-01f, -1.92560360e-01f, -7.72058293e-02f, -3.68172556e-01f, 9.23203304e-02f, 3.94719876e-02f, 9.19736400e-02f, -6.48786053e-02f, -1.88704759e-01f, -1.07314959e-01f,
  -1.21125087e-01f, -1.35840714e-01f, -3.73688079e-02f, 2.25492820e-01f, 1.96580380e-01f, 2.19008222e-01f, 2.49445260e-01f, 2.94868886e-01f, 2.14742228e-01f, 1.01693623e-01f,
  -3.18055786e-03f, -8.88641626e-02f, -3.33523341e-02f, -1.67677980e-02f, -1.33603230e-01f, -8.37749839e-02f, 6.66746050e-02f, 7.46460557e-02f, 1.27229750e-01f, 6.00720346e-02f,
  -1.31776258e-01f, -3.12287718e-01f, 1.47854716e-01f, 9.00545269e-02f, 2.53760405e-02f, -5.79966046e-03f, -4.99838814e-02f, 2.55275592e-02f, -3.54469977e-02f, -1.43548357e-03f,
  -1.24169178e-01f, -3.22337672e-02f, -4.26967740e-02f, -8.85176286e-02f, -1.59078285e-01f, -2.57196814e-01f, 6.69282116e-03f, 1.32680699e-01f, -4.43178937e-02f, -1.78973116e-02f,
  2.20349923e-01f, 6.71372637e-02f, 1.10022649e-02f, 5.42753898e-02f, -7.44942725e-02f, 3.25549543e-02f, -6.93132281e-02f, 1.33490441e-02f, 7.13416701e-03f, -1.67249322e-01f,
  1.22376807e-01f, 2.58729998e-02f, 6.36926070e-02f, 3.14721875e-02f, -1.78706665e-02f, 1.88964345e-02f, 1.11548640e-01f, 1.05752446e-01f, 5.13735078e-02f, -5.26695177e-02f,
  -5.81550002e-02f, -1.20300740e-01f, 3.25947143e-02f, -8.67059007e-02f, 2.18877252e-02f, 1.34200286e-02f, 6.07162826e-02f, 1.21602163e-01f, 5.93295461e-03f, 4.45048064e-02f,
  -1.32166520e-02f, -9.77224263e-05f, -1.43837547e-02f, -5.49845807e-02f, 5.49555868e-02f, 4.22990024e-02f, 5.11733182e-02f, -6.49247095e-02f, -1.73884630e-01f, -4.91572358e-02f,
  -3.84347856e-01f, 2.62044340e-01f, -8.03064033e-02f, -8.84978697e-02f, 1.48897816e-04f, 1.06103532e-02f, -8.84047374e-02f, 1.01051264e-01f, -1.50330260e-01f, -1.58232115e-02f,
  -3.19679826e-02f, -8.55936483e-02f, -1.83385685e-01f, 6.69414476e-02f, -1.12247482e-01f, -1.46233946e-01f, -5.07637896e-02f, -3.77813801e-02f, 4.00750339e-02f, -8.35943446e-02f,
  8.48440267e-03f, 7.88682420e-03f, -2.08057389e-01f, -1.71263278e-01f, -1.29470259e-01f, -8.41562450e-03f, -1.37008041e-01f, -1.44430280e-01f, -1.32741258e-01f, -2.83381671e-01f,
  -3.57201040e-01f, -1.15304574e-01f, 5.13026156e-02f, -7.29585215e-02f, 1.00262597e-01f, 1.30429082e-02f, -2.31530294e-01f, -2.56262064e-01f, -6.67559728e-02f, -6.77781478e-02f,
  3.01872753e-02f, -4.74069118e-02f, -1.05203010e-01f, -6.69341385e-02f, -1.91419929e-01f, -1.36897385e-01f, 2.58440129e-03f, -1.03532009e-01f, -1.76054165e-01f, -1.42592996e-01f,
  6.58549890e-02f, -7.60451332e-02f, -2.16251984e-01f, -1.18984962e-02f, 3.90690519e-03f, 9.25272703e-03f, 9.51424614e-02f, 6.24654721e-03f, 1.27528265e-01f, 1.21497393e-01f,
  1.32712409e-01f, 1.33088296e-02f, 1.93213180e-01f, 1.00193871e-02f, 2.34034091e-01f, 3.14529799e-02f, 4.72338125e-02f, 1.65241629e-01f, 1.10326000e-01f, -4.26058508e-02f,
  -3.88978235e-02f, 6.56878576e-02f, 4.44663828e-03f, 2.61937901e-02f, -2.68101264e-02f, -7.63696656e-02f, -1.08518451e-01f, -6.30199239e-02f, -5.20243347e-02f, -7.68095925e-02f,
  -6.42034039e-02f, 4.24073711e-02f, -2.28383094e-01f, -3.05453800e-02f, -1.40324846e-01f, 1.25403866e-01f, -5.07892901e-03f, -3.01214494e-02f, 1.29070249e-03f, -9.28416178e-02f,
  2.60718446e-02f, 1.24909254e-02f, 9.99161974e-02f, 6.65667877e-02f, -9.03094113e-02f, 1.22892231e-01f, 4.87806648e-02f, -2.41290145e-02f, 9.73514281e-03f, -9.41099674e-02f,
  -1.04717486e-01f, 2.70955954e-02f, -5.20575270e-02f, 4.12429348e-02f, 3.32101285e-02f, 6.81572482e-02f, 8.18755552e-02f, 4.85627539e-03f, 9.64488648e-03f, 1.01779830e-02f,
  9.62732080e-03f, 2.29130294e-02f, -2.54616924e-02f, 3.04868841e-03f, 1.69106781e-01f, 1.31266692e-03f, 4.17059138e-02f, 9.85196978e-03f, -1.04257934e-01f, 6.18681908e-02f,
  -3.18166018e-01f, 2.12371409e-01f, 7.38772377e-02f, 3.56691591e-02f, 2.15803343e-03f, -3.45114842e-02f, 1.28976330e-01f, 1.22974157e-01f, 1.04309097e-01f, -2.23628096e-02f,
  -7.10605606e-02f, 6.31422549e-02f, -8.80609546e-03f, 4.83101010e-02f, -7.09944442e-02f, -2.16406025e-02f, -4.45559286e-02f, 2.95496620e-02f, -1.11855157e-01f, 1.61860753e-02f,
  -2.45236695e-01f, -1.22137643e-01f, -3.06117773e-01f, -1.45633891e-01f, -1.19767621e-01f, -1.29309639e-01f, -5.15005477e-02f, 5.35950111e-03f, -2.31859043e-01f, -3.21578771e-01f,
  -1.10952467e-01f, 8.92252624e-02f, -1.32760271e-01f, 1.50216356e-01f, 2.73387522e-01f, 2.52995163e-01f, 3.31641465e-01f, 1.33186951e-01f, 4.97562848e-02f, 2.76035480e-02f,
  -1.52120903e-01f, -1.36359915e-01f, -4.75216210e-02f, -3.38503830e-02f, -1.44828796e-01f, 2.16010109e-01f, 1.31732166e-01f, -5.43223880e-02f, -6.23257160e-02f, -8.23236071e-03f,
  6.37374744e-02f, 1.38062090e-01f, -1.91226929e-01f, -3.32952328e-02f, 1.09120123e-01f, 6.35611787e-02f, 1.17031641e-01f, 3.44209820e-02f, 7.87106007e-02f, 1.80515617e-01f,
  -1.82786986e-01f, -1.88320994e-01f, -5.11354059e-02f, -4.96141464e-02f, -5.82534522e-02f, -1.57041132e-01f, -1.74422383e-01f, -1.53940484e-01f, -1.12045616e-01f, -8.14576522e-02f,
  9.85731557e-02f, 3.61033455e-02f, 2.06310228e-02f, 1.22142948e-01f, 6.73618866e-03f, -6.53229728e-02f, -4.34761234e-02f, 9.50606447e-03f, 2.97831441e-03f, -6.85159117e-02f,
  1.86867237e-01f, 1.03982583e-01f, 3.67691889e-02f, 1.28446110e-02f, -1.17540359e-01f, 4.15801033e-02f, -7.76072731e-03f, -4.70904671e-02f, -9.80577692e-02f, -3.92125696e-02f,
  -2.05859765e-01f, -6.61294209e-03f, -1.06642827e-01f, -1.41885355e-01f, -4.62285848e-03f, 8.16122442e-02f, -3.91573319e-03f, 1.80899873e-02f, -3.77259701e-02f, -3.08599696e-03f,
  -4.75628600e-02f, -1.12824619e-01f, -1.40460566e-01f, -5.80981560e-02f, -2.54041970e-01f, 8.38966109e-03f, -1.13735497e-01f, -5.91799952e-02f, -1.85555547e-01f, -1.40225947e-01f,
  -2.43469495e-02f, -6.11847565e-02f, -8.96650404e-02f, -5.89841492e-02f, -9.43441987e-02f, -2.05889434e-01f, -1.79063395e-01f, -4.59210984e-02f, -8.52696076e-02f, -4.03736979e-02f,
  -6.51347414e-02f, -2.89061844e-01f, 5.74263893e-02f, -1.13119110e-01f, -5.86985461e-02f, -2.00519964e-01f, -2.09734678e-01f, -2.22247943e-01f, 7.50352442e-02f, -7.02715963e-02f,
  -4.52385545e-02f, -2.41059437e-01f, -5.75586297e-02f, -4.75462200e-03f, 6.22730665e-02f, -1.24534927e-01f, -8.64642635e-02f, 1.71131194e-01f, -9.70429555e-02f, -5.58986105e-02f,
  -5.90364560e-02f, 9.05167498e-03f, 7.54639357e-02f, -5.22410171e-03f, -7.99593404e-02f, -6.42102361e-02f, -4.09798063e-02f, -1.94118153e-02f, -5.48278950e-02f, 3.59218642e-02f,
  3.97477336e-02f, -8.13122373e-03f, 3.20697635e-01f, 3.19752425e-01f, 2.23713651e-01f, 2.68814385e-01f, 3.21221888e-01f, 1.21714078e-01f, 3.78461592e-02f, 1.04014717e-01f,
  2.49166608e-01f, 2.68191725e-01f, 2.17826366e-01f, 1.87196791e-01f, 1.66164547e-01f, 1.26265332e-01f, 1.66923523e-01f, 9.53864083e-02f, 4.14033756e-02f, 1.50817439e-01f,
  8.93343538e-02f, -1.59389321e-02f, -1.23348497e-01f, -4.68474142e-02f, 2.63650110e-03f, 4.85731550e-02f, 3.61904800e-02f, 2.35449299e-02f, 8.05739388e-02f, -4.90135280e-03f,
  -6.80108070e-02f, 6.90906821e-03f, 8.80114511e-02f, -1.06772184e-01f, -6.05316684e-02f, -1.92484394e-01f, -2.71401741e-02f, -1.45689383e-01f, -1.72232360e-01f, -8.45080167e-02f,
  -8.38751569e-02f, -9.78103280e-02f, 6.17695004e-02f, -1.55606538e-01f, -4.78830598e-02f, -1.94308579e-01f, -1.70942888e-01f, 5.68028279e-02f, 5.53156883e-02f, 5.90767786e-02f,
  1.03098951e-01f, 1.79648235e-01f, 1.90139920e-01f, 1.97200820e-01f, 1.11755192e-01f, 1.26342297e-01f, 5.03097884e-02f, -5.63028604e-02f, -1.32638561e-02f, -8.63076597e-02f,
  1.62036806e-01f, 9.63991359e-02f, 1.66859731e-01f, 4.80459034e-02f, 1.00987218e-01f, 2.82828864e-02f, -1.57605913e-02f, 8.68471637e-02f, 4.74744476e-02f, -6.37280121e-02f,
  -5.48831411e-02f, 2.00567648e-01f, 8.08784366e-03f, 1.19000956e-01f, 2.67151296e-02f, 1.09010100e-01f, -7.30384421e-03f, -6.93201972e-03f, -4.77860905e-02f, -2.26505436e-02f,
  1.59471612e-02f, 1.57736037e-02f, -2.50830561e-01f, -1.26536235e-01f, -5.03162965e-02f, 1.90854445e-02f, -1.08912282e-01f, -4.82899733e-02f, -9.25697908e-02f, -1.29076496e-01f,
  -9.13893282e-02f, 2.64337838e-01f, -3.45361046e-02f, -5.35527468e-02f, -1.11895800e-01f, -2.35059425e-01f, 8.91839489e-02f, -1.54127460e-02f, -1.56877041e-01f, -1.34965219e-02f,
  -4.79565300e-02f, 1.57355648e-02f, -4.39038947e-02f, -7.24254549e-02f, -1.31316587e-01f, -9.61743966e-02f, -4.09991592e-02f, 1.10273540e-01f, -3.95077020e-02f, 2.03618817e-02f,
  -5.92960157e-02f, 9.19042435e-03f, 1.12023272e-01f, 1.49105474e-01f, 2.23122630e-02f, 1.90080721e-02f, 2.90490650e-02f, -1.37752309e-01f, -3.79553623e-02f, -3.33401561e-02f,
  -2.70551592e-01f, 2.56888382e-02f, 6.54789433e-02f, -2.73283303e-01f, -1.05875626e-01f, 4.90259267e-02f, 1.50426939e-01f, 4.62852456e-02f, 8.61744583e-03f, 1.38680384e-01f,
  1.46994025e-01f, -1.95965782e-01f, 2.15427522e-02f, -4.03043851e-02f, -1.28262624e-01f, 1.18085772e-01f, -1.42114386e-01f, -2.51876265e-01f, -2.99898386e-01f, -9.88642499e-02f,
  -9.66309607e-02f, -1.77660882e-01f, -3.04982483e-01f, -2.09909365e-01f, -5.58244884e-02f, -2.13826016e-01f, -1.51671460e-02f, -9.43522379e-02f, 5.25965020e-02f, -1.97414681e-02f,
  1.25888124e-01f, 1.49472177e-01f, 1.02271892e-01f, -2.23269269e-01f, 1.31775364e-01f, -6.29812032e-02f, 1.23449303e-01f, 1.81900904e-01f, 3.62119302e-02f, 1.29987989e-02f,
  -1.35685295e-01f, 1.70391083e-01f, -2.99729649e-02f, -1.68203473e-01f, -2.03203186e-02f, 3.58923525e-02f, -1.82038043e-02f, -7.48267844e-02f, 6.84741586e-02f, 9.29230526e-02f,
  -1.15433492e-01f, -1.37678906e-01f, -9.57662836e-02f, 2.64433734e-02f, 6.83472827e-02f, 4.48412709e-02f, -1.64122358e-02f, 6.20212853e-02f, 5.65274879e-02f, 2.11982764e-02f,
  3.76444496e-02f, 1.18586265e-01f, -3.51962522e-02f, 1.09588793e-02f, -7.28310719e-02f, -2.47792210e-02f, 1.24081355e-02f, 6.49299696e-02f, 1.40091926e-01f, 7.83225801e-03f,
  6.25286158e-03f, 1.26592904e-01f, 1.17638648e-01f, 3.25524509e-02f, 8.65057856e-02f, -1.45157650e-01f, 4.52434942e-02f, 1.12603895e-01f, 2.31914185e-02f, -6.71749189e-02f,
  -9.15027037e-02f, 1.06236234e-01f, -3.76793034e-02f, -9.06025395e-02f, 1.46709725e-01f, 1.48387611e-01f, 1.83572426e-01f, 1.25152811e-01f, -9.42968726e-02f, 4.41468395e-02f,
  -1.92020565e-01f, 4.03362419e-03f, 8.42172205e-02f, -6.27845933e-04f, 2.40881853e-02f, 1.73867848e-02f, -7.51277898e-03f, 9.50436592e-02f, -9.15150717e-02f, -1.35610119e-01f,
  5.55467373e-03f, -1.18084503e-02f, 1.52371442e-02f, -6.06917068e-02f, 6.19571358e-02f, -1.11041911e-01f, 3.31859599e-04f, -1.24679461e-01f, 2.39042267e-02f, 5.89341484e-02f,
  -3.55419591e-02f, 5.64256078e-03f, -2.23071948e-01f, -5.13372645e-02f, 7.51265138e-02f, -1.18631788e-01f, 6.19317740e-02f, 1.52565151e-01f, 3.85995805e-02f, 1.42458498e-01f,
  -1.04656696e-01f, 1.12225570e-01f, -1.49568900e-01f, 3.09999883e-01f, 4.64664735e-02f, 9.58960578e-02f, -6.54825419e-02f, 1.66754395e-01f, 1.16886631e-01f, 7.42275789e-02f,
  2.93947279e-01f, 2.87626594e-01f, 3.11747670e-01f, 1.78375989e-01f, 1.00475699e-01f, 3.78950797e-02f, 1.39729036e-02f, -4.44821976e-02f, 8.77110511e-02f, 5.46294414e-02f,
  1.90612391e-01f, 8.52204263e-02f, 1.80723183e-02f, 7.13815317e-02f, 1.52055770e-01f, 1.19389184e-01f, 4.90047820e-02f, -5.10100909e-02f, 1.11412421e-01f, 1.90393060e-01f,
  4.29326631e-02f, 2.15229820e-02f, 1.11620709e-01f, 1.45832613e-01f, -1.49668194e-02f, 2.46739350e-02f, -3.46629620e-02f, -4.92657684e-02f, 1.09214894e-01f, -6.26725517e-03f,
  9.52202156e-02f, -1.58027727e-02f, -5.11022620e-02f, -5.51105365e-02f, 1.13946460e-02f, -6.25114469e-03f, -1.97482277e-02f, 7.65195340e-02f, 1.90192953e-01f, 5.66909425e-02f,
  3.20045203e-02f, 6.65758774e-02f, 6.88178688e-02f, 2.11058860e-03f, -1.76748019e-02f, 1.39589056e-01f, 5.59725910e-02f, 5.16011752e-02f, 1.33973971e-01f, -1.12907864e-01f,
  7.50885233e-02f, 1.12403870e-01f, -1.20638125e-02f, -5.60874008e-02f, -4.56458703e-02f, -6.33175746e-02f, -5.21239405e-03f, -1.34384349e-01f, -6.64251894e-02f, -2.43051589e-01f,
  4.70769294e-02f, 4.16825572e-03f, 3.55441235e-02f, 1.50309810e-02f, -9.03141510e-04f, 2.87012663e-03f, 1.67894997e-02f, 1.73852500e-02f, 3.91892679e-02f, -1.36767281e-02f,
  -1.05467610e-01f, -3.46397571e-02f, -6.34422898e-02f, -8.94125402e-02f, 5.95191605e-02f, 2.54859533e-02f, 5.42626567e-02f, 8.26127678e-02f, 4.41936925e-02f, -3.76475304e-02f,
  7.44784847e-02f, 8.88182595e-02f, 9.56535339e-02f, 5.26563078e-02f, -1.08539261e-01f, -3.52594443e-02f, 4.93240617e-02f, 2.74569658e-03f, 1.19183131e-01f, 7.09212618e-03f,
  1.40077490e-02f, -1.04967289e-01f, -9.10880268e-02f, -1.58698514e-01f, -1.10642105e-01f, -9.47222561e-02f, -4.81732488e-02f, 8.19616765e-02f, 9.75296274e-02f, 1.00425608e-01f,
  6.66179210e-02f, -6.44608885e-02f, 1.50485551e-02f, -5.40988147e-02f, -5.86778037e-02f, 8.01803246e-02f, -4.10553738e-02f, -7.16279522e-02f, 2.78743021e-02f, -6.03565276e-02f,
  2.84141392e-01f, -1.10130534e-01f, -2.40913376e-01f, -2.23724283e-02f, -3.19178514e-02f, -7.66111910e-02f, -2.69403398e-01f, -1.35831729e-01f, -9.05754790e-02f, -1.59258530e-01f,
  1.82298735e-01f, 3.43141675e-01f, 1.63734734e-01f, 1.45906657e-01f, 1.31864294e-01f, -2.64770210e-01f, -3.24182421e-01f, -5.09141870e-02f, 1.36850610e-01f, 4.49144840e-02f,
  1.15907732e-02f, 2.57191472e-02f, 5.03323786e-02f, 8.49855840e-02f, -2.01677561e-01f, 6.41729906e-02f, -2.35408098e-01f, -4.29127775e-02f, -1.52347252e-01f, -2.22867593e-01f,
  -6.02576658e-02f, 2.31630914e-02f, 4.99696136e-02f, 2.51141712e-02f, 9.38334968e-04f, -1.64187271e-02f, -2.61206273e-02f, -5.62593527e-03f, 5.34717366e-02f, -1.91879511e-01f,
  2.63803615e-03f, -2.29951907e-02f, -2.33996846e-02f, -7.52874911e-02f, -3.06614973e-02f, 2.99725309e-02f, -1.57181293e-01f, -6.04792945e-02f, -1.06999904e-01f, -7.71081373e-02f,
  -4.62580882e-02f, 7.86735341e-02f, -4.08822149e-02f, -1.66433200e-01f, -1.14420854e-01f, 5.94396666e-02f, -1.86199754e-01f, -1.28191635e-02f, -1.93925634e-01f, -1.62876859e-01f,
  7.70784020e-02f, 8.79166350e-02f, 3.86201479e-02f, 3.95849496e-02f, 1.48613662e-01f, 1.63414299e-01f, -5.78376241e-02f, -1.21969441e-02f, 7.44491667e-02f, 9.91376210e-03f,
  7.41064623e-02f, -7.40717426e-02f, -9.98574123e-03f, -4.28873487e-02f, 7.31424093e-02f, 1.01609282e-01f, 1.61084697e-01f, 4.57564853e-02f, 1.40835688e-01f, 8.84141847e-02f,
  1.81540385e-01f, 6.39529154e-02f, 1.19928695e-01f, 7.87514299e-02f, 8.52213949e-02f, 7.47888684e-02f, 5.04441261e-02f, 9.70318727e-03f, 3.17654163e-02f, 6.09987192e-02f,
  5.90877868e-02f, 2.79802494e-02f, 5.58098443e-02f, 1.12924658e-01f, 1.46338657e-01f, 6.99727833e-02f, 5.58272563e-02f, 1.44860158e-02f, 1.09645821e-01f, -2.89220549e-02f,
  1.84924304e-02f, -3.81712266e-03f, -7.76868537e-02f, -4.68557999e-02f, -6.87975511e-02f, 1.02845309e-02f, 5.54566942e-02f, 7.66323432e-02f, 2.30348483e-02f, 1.79995969e-02f,
  8.96518081e-02f, 6.29444271e-02f, 2.36884192e-01f, 1.65587161e-02f, -4.21255901e-02f, 1.50865868e-01f, 1.22963879e-02f, -8.81856829e-02f, 4.08273488e-02f, -1.78357646e-01f,
  5.67009807e-01f, 3.13764840e-01f, 2.56923854e-01f, 2.46546209e-01f, 1.11878462e-01f, 1.55345887e-01f, 2.09114701e-01f, 2.45587915e-01f, 1.05033301e-01f, 1.63045913e-01f,
  9.56975818e-02f, 4.79549654e-02f, 8.30384195e-02f, 3.07262894e-02f, 2.09279552e-01f, 9.41896066e-02f, 1.37283176e-01f, 1.51140705e-01f, 8.60698819e-02f, 1.47496909e-01f,
  5.33922128e-02f, 1.32415265e-01f, 1.74750581e-01f, 1.41231909e-01f, 1.32738382e-01f, 5.95076904e-02f, -1.47308800e-02f, 6.20259456e-02f, 1.31633893e-01f, 1.97889015e-01f,
  -2.20958248e-01f, 9.91399288e-02f, -3.24057564e-02f, -7.08256662e-02f, -3.34902965e-02f, -3.40850018e-02f, -3.98938870e-03f, 4.93838228e-02f, 2.07410064e-02f, -2.46431213e-03f,
  4.96294089e-02f, -8.11519325e-02f, -1.39483094e-01f, -1.78122625e-01f, -6.98614269e-02f, -1.09976180e-01f, -2.34853961e-02f, 4.56289798e-02f, -2.27080137e-02f, -3.95591184e-02f,
  -1.93264498e-03f, -1.22286513e-01f, -4.14882973e-02f, -9.01814550e-02f, 7.40310848e-02f, -1.10287957e-01f, 4.99839522e-02f, 4.44767587e-02f, -1.13776892e-01f, 2.89695803e-02f,
  -4.86886166e-02f, 6.58171698e-02f, -1.36728033e-01f, -1.92659184e-01f, -1.23624869e-01f, -1.67984545e-01f, -8.85567442e-02f, -5.58920763e-02f, -1.73627085e-03f, -9.63095948e-03f,
  -1.09493650e-01f, -1.13283992e-01f, -6.40303120e-02f, -7.68826604e-02f, 6.68157963e-03f, -5.64881153e-02f, -1.68550685e-02f, -2.55150963e-02f, -8.82196203e-02f, -1.81587022e-02f,
  -2.50951778e-02f, 4.74530160e-02f, 3.35563943e-02f, -5.62696755e-02f, -1.08519502e-01f, -1.32887572e-01f, -3.00385850e-03f, -1.34011030e-01f, -2.66130399e-02f, 1.30960539e-01f,
  -2.39395499e-01f, -1.16100781e-01f, -1.95993064e-03f, 2.28113249e-01f, 1.01101972e-01f, 6.96861893e-02f, 7.34993070e-02f, -3.77053320e-02f, -9.64555517e-02f, -7.85037354e-02f,
  -6.85817823e-02f, -7.22925961e-02f, -7.55393505e-03f, 1.18969856e-02f, -1.62030742e-01f, -1.07490622e-01f, -1.05267487e-01f, 8.49185511e-02f, 4.67593223e-02f, -6.19615726e-02f,
  -7.56517872e-02f, -4.62908037e-02f, -1.00607134e-01f, -7.01565519e-02f, 3.00587025e-02f, -1.11684151e-01f, -1.18738838e-01f, 7.81651400e-03f, 2.14934186e-03f, -1.40502886e-03f,
  -3.35699052e-01f, -1.30375251e-02f, -1.44284785e-01f, -3.54413353e-02f, -8.98186956e-03f, 7.26361424e-02f, -1.10612907e-01f, 1.23033375e-01f, -4.19012718e-02f, -4.47762944e-02f,
  2.57614199e-02f, -5.76326922e-02f, -2.16663316e-01f, -1.25594065e-01f, -2.38935292e-01f, -2.89645851e-01f, -2.66522467e-01f, -2.24693358e-01f, -2.13666067e-01f, 9.09672584e-03f,
  -8.57476741e-02f, -2.75596410e-01f, -2.15358406e-01f, -9.73629132e-02f, -9.51818191e-03f, -1.65462658e-01f, -1.26734450e-01f, -1.14504270e-01f, -8.89490452e-03f, -1.81701139e-01f,
  -1.09305777e-01f, 1.31080672e-01f, 1.79287922e-02f, 5.26174493e-02f, 6.62077442e-02f, 2.12013684e-02f, 5.37795201e-02f, 2.93249432e-02f, 1.31566182e-01f, 5.91438897e-02f,
  1.17776155e-01f, -4.28547636e-02f, 4.12383825e-02f, 1.75924361e-01f, 1.60900876e-01f, 1.26510724e-01f, 1.87848791e-01f, 8.13585371e-02f, -3.07052862e-03f, 6.03354052e-02f,
  6.13263547e-02f, 1.60316437e-01f, 2.23873213e-01f, 1.65379286e-01f, 7.89885297e-02f, 8.54247734e-02f, 2.19170034e-01f, 1.68221399e-01f, 1.46339089e-01f, 1.03193566e-01f,
  -1.15668997e-01f, -1.15233399e-01f, 1.31999254e-01f, 8.78717527e-02f, 9.32567120e-02f, 5.19975014e-02f, 1.67269651e-02f, -3.17768157e-02f, -1.16299823e-01f, -7.89354667e-02f,
  1.44026190e-01f, -6.07606620e-02f, 8.03411007e-03f, 4.60361354e-02f, -7.33061358e-02f, -5.11489902e-03f, -4.46998589e-02f, 4.38959673e-02f, 1.02365106e-01f, 8.97877961e-02f,
  2.30257749e-03f, 8.56349468e-02f, -4.64324653e-02f, 7.46381953e-02f, 7.70329088e-02f, 1.78379595e-01f, 1.56818673e-01f, 1.52645856e-01f, 6.18671020e-03f, -6.57519177e-02f,
  -9.86862648e-03f, -8.32944587e-02f, -1.27786681e-01f, -1.08905636e-01f, -1.08312117e-02f, 7.08745047e-02f, -1.17969431e-01f, -3.39503922e-02f, 3.10978759e-02f, 7.27859139e-02f,
  1.54439464e-01f, -1.05067700e-01f, -7.38626197e-02f, 3.50834094e-02f, 4.36919667e-02f, -2.66167969e-02f, 7.31030181e-02f, -1.01631694e-01f, 7.01484382e-02f, 1.90697029e-01f,
  9.81918722e-02f, -1.21161770e-02f, -1.12517895e-02f, -2.16134544e-02f, -1.00896552e-01f, -1.10429652e-01f, 4.18658927e-02f, 8.28262568e-02f, 7.78236985e-02f, 2.43651625e-02f,
  3.24496359e-01f, -6.53641403e-01f, 2.21618712e-01f, 1.26362279e-01f, 2.44033616e-03f, 1.03818968e-01f, 1.80283189e-02f, 1.33502766e-01f, 1.44231692e-01f, -9.73752216e-02f,
  -1.61631256e-01f, -1.05133923e-02f, -4.62485813e-02f, -6.49793372e-02f, 1.91909317e-02f, -9.56336930e-02f, 8.32568258e-02f, 3.21698129e-01f, 4.33282077e-01f, 7.56969005e-02f,
  -4.38958146e-02f, -1.66216314e-01f, 1.05136223e-01f, 9.02312919e-02f, -8.54523256e-02f, 1.24564268e-01f, -1.10353529e-01f, -1.58722475e-01f, -2.42464945e-01f, -2.96972275e-01f,
  -2.56392539e-01f, -3.16284567e-01f, 1.62578449e-01f, 2.17233840e-02f, -1.75922178e-02f, 4.85329442e-02f, -5.31307682e-02f, -1.78690571e-02f, -2.08962336e-02f, -7.39232153e-02f,
  -6.08856324e-04f, 2.84275394e-02f, 4.73263972e-02f, -1.21043682e-01f, -1.02940120e-01f, -1.08513176e-01f, -1.19312741e-01f, -5.19586243e-02f, -2.78964583e-02f, -8.62896666e-02f,
  -9.16660056e-02f, -1.50036678e-01f, -8.13440140e-03f, -7.36150965e-02f, -3.84826176e-02f, 4.83230539e-02f, -8.96099806e-02f, -1.34222135e-01f, -1.45001352e-01f, -2.89065331e-01f,
  4.86385599e-02f, -8.64379480e-03f, 5.03984988e-02f, 4.63237613e-02f, 4.45125103e-02f, 1.31491095e-01f, 1.79441534e-02f, 1.32908493e-01f, -7.98518360e-02f, -1.07326441e-01f,
  -3.16233411e-02f, 1.27352461e-01f, -7.56775960e-03f, -2.79155653e-02f, -2.65412256e-02f, 1.77124590e-02f, -5.84995300e-02f, -1.58012405e-01f, 5.05706891e-02f, -7.55273318e-03f,
  -7.05170557e-02f, 7.24378079e-02f, 1.85499378e-02f, 9.80632678e-02f, -9.30147059e-03f, 5.14796562e-02f, -3.20687741e-02f, -1.25090599e-01f, -5.71472608e-02f, 4.14438099e-02f,
  -5.83702773e-02f, 9.65153053e-02f, 7.14184195e-02f, -1.43416002e-02f, 5.62003665e-02f, -6.14889972e-02f, -5.34396470e-02f, -7.37653822e-02f, -1.19021060e-02f, 7.63539076e-02f,
  5.46796422e-04f, 6.76013529e-02f, -2.23638453e-02f, -4.31440994e-02f, -1.76007841e-02f, 3.29135843e-02f, -1.62247241e-01f, 9.50819254e-02f, 6.96601793e-02f, -6.77652210e-02f,
  2.49429736e-02f, 1.47847719e-02f, -2.63613500e-02f, 7.28948638e-02f, -8.89042486e-03f, 1.77511245e-01f, 1.37052581e-01f, 5.58789968e-02f, 1.20808534e-01f, 2.99261361e-02f,
  4.36415255e-01f, 1.59900144e-01f, 1.52660847e-01f, 7.01501593e-02f, -1.23747326e-01f, -1.03935590e-02f, 2.67223418e-02f, 5.32629043e-02f, 6.32999986e-02f, 8.82590935e-03f,
  2.58119050e-02f, 6.18099794e-02f, -4.32463661e-02f, 4.64843698e-02f, 7.30829760e-02f, 1.35878548e-01f, 5.77014871e-02f, 1.12746805e-01f, 7.27734566e-02f, 2.12112024e-01f,
  1.74346402e-01f, 1.32537276e-01f, 1.90115869e-01f, 5.00321239e-02f, 2.42652029e-01f, 8.01499635e-02f, 3.85765247e-02f, 1.93468124e-01f, 1.63750827e-01f, 3.16005439e-01f,
  3.01332609e-03f, 1.51152581e-01f, -1.68992072e-01f, -2.17295587e-02f, 1.05116747e-01f, 3.44911218e-02f, 9.73233804e-02f, 1.42686591e-02f, 9.37845837e-03f, -2.38514822e-02f,
  1.71872489e-02f, 6.79661334e-02f, 9.62457806e-02f, 3.16142663e-02f, 1.05450992e-02f, 6.10450516e-03f, 1.04377158e-01f, 1.31136477e-01f, -3.14795375e-02f, 6.55231923e-02f,
  -3.24368551e-02f, 2.27983226e-03f, -1.80824418e-02f, -1.74807847e-01f, 7.46899471e-02f, -1.15513392e-01f, -1.07433021e-01f, 1.25716686e-01f, -1.04130246e-01f, 1.27884775e-01f,
  1.06492892e-01f, 2.29919955e-01f, 2.30204329e-01f, 2.11548388e-01f, 1.73134372e-01f, 1.59538224e-01f, -1.19823767e-02f, -6.21452853e-02f, 7.11402223e-02f, 6.86036497e-02f,
  2.88824532e-02f, -1.78045854e-02f, -1.25347357e-02f, 4.15088795e-02f, -3.58658731e-02f, 6.04975149e-02f, 2.46366598e-02f, -3.19828764e-02f, -5.49598262e-02f, 9.07212645e-02f,
  7.56844878e-02f, -8.20856094e-02f, -2.04460360e-02f, -4.04705778e-02f, -7.12571889e-02f, -1.67421401e-02f, 2.74152998e-02f, 7.08648516e-03f, 5.23793027e-02f, 9.57791284e-02f,
  -4.55575377e-01f, -3.85759771e-01f, 8.86054710e-02f, 7.53445551e-02f, 3.86759788e-02f, -1.11818217e-01f, -6.87187985e-02f, -9.48428363e-02f, -9.05892402e-02f, -1.42583391e-02f,
  5.07431105e-02f, 2.12127646e-03f, 5.28822057e-02f, -6.55643791e-02f, -8.38109702e-02f, -1.21548034e-01f, 5.36738634e-02f, 9.11852811e-03f, -2.25654230e-01f, -1.00407019e-01f,
  -5.94555549e-02f, -2.17960685e-01f, -1.93293810e-01f, -1.23204187e-01f, 3.95202683e-03f, -2.64373600e-01f, -1.99974760e-01f, -3.71686816e-02f, -1.70723781e-01f, -1.60398766e-01f,
  -4.16370869e-01f, -1.26052916e-01f, -1.85286090e-01f, -6.14853859e-01f, -2.49619409e-01f, -2.09863633e-02f, 1.90067381e-01f, -9.47630182e-02f, -3.65886837e-01f, -2.43338808e-01f,
  8.42329785e-02f, 1.30731419e-01f, 1.97250699e-03f, 1.08628869e-01f, 7.87001252e-02f, -1.42526209e-01f, -2.64257610e-01f, -1.02546498e-01f, 1.27248749e-01f, 2.69015431e-01f,
  5.81450760e-02f, -1.55830443e-01f, -2.13359535e-01f, -1.29980758e-01f, -1.91002563e-01f, 9.36371908e-02f, -1.45806238e-01f, -1.75914958e-01f, 1.05685733e-01f, -9.89480168e-02f,
  2.11443126e-01f, -1.07277641e-02f, 9.71167311e-02f, -8.86878073e-02f, -9.84760448e-02f, -7.83058703e-02f, -4.03777100e-02f, -5.71783958e-03f, -1.00682072e-01f, -2.79240757e-02f,
  -1.32943377e-01f, 6.74544871e-02f, 1.90597773e-02f, -3.28000821e-02f, -6.80003464e-02f, 3.81289199e-02f, 1.01801325e-02f, 3.35597284e-02f, -9.53307897e-02f, 9.63954255e-02f,
  2.51059104e-02f, -3.32491994e-02f, 3.11004817e-02f, 8.66886750e-02f, -2.81039365e-02f, 1.32180592e-02f, 1.50664061e-01f, 7.22358301e-02f, 3.32467332e-02f, 6.67394176e-02f,
  -2.38689668e-02f, 1.19185470e-01f, 4.64724656e-03f, 8.10801089e-02f, 3.54109108e-02f, 1.69541594e-02f, -4.57162932e-02f, -2.91148685e-02f, 5.11497222e-02f, -2.61629000e-03f,
  -5.51440520e-03f, -9.57596377e-02f, -1.01632774e-01f, 2.87349158e-05f, 1.71812717e-02f, -1.66323893e-02f, -7.10788369e-02f, 9.60686058e-02f, -1.62817031e-01f, -7.13129342e-02f,
  -2.06423923e-02f, 4.03404497e-02f, -2.56721731e-02f, 7.22469389e-02f, 4.56439145e-02f, -1.17000252e-01f, -5.27620241e-02f, 4.76956815e-02f, 4.99199554e-02f, -8.41373727e-02f,
  -8.28440115e-02f, -2.23500747e-02f, -6.84498921e-02f, 1.09804133e-02f, -7.63491318e-02f, -1.11890480e-01f, -1.01712637e-01f, -9.75285843e-02f, -1.46752164e-01f, -8.43926743e-02f,
  -3.80385965e-02f, 1.86172370e-02f, -1.83541905e-02f, 8.18090662e-02f, 7.08689243e-02f, 1.45704418e-01f, -7.72283375e-02f, -2.93255318e-02f, 1.12723492e-01f, -2.21240777e-03f,
  -8.21559578e-02f, -3.04765496e-02f, 7.24396780e-02f, 1.88332811e-01f, 7.72938058e-02f, 5.23179770e-02f, 1.08989000e-01f, 8.72016475e-02f, 1.75830975e-01f, 8.02497491e-02f,
  5.44874966e-01f, -2.06177801e-01f, -4.39122260e-01f, 1.34777680e-01f, -4.24674116e-02f, 5.92947006e-02f, -7.12415278e-02f, 3.54212597e-02f, 1.42470837e-01f, -9.58656967e-02f,
  -6.65283278e-02f, 1.56687617e-01f, 1.25284538e-01f, -1.31800979e-01f, 4.51414548e-02f, -1.63290098e-01f, -2.28077590e-01f, -4.28334996e-02f, 7.16249496e-02f, 4.96982783e-02f,
  -3.45962942e-02f, -8.40923116e-02f, 1.06415036e-03f, -9.89600783e-04f, -1.85135245e-01f, 2.85137240e-02f, -3.08837354e-01f, -1.79488301e-01f, -2.42699727e-01f, -3.33232611e-01f,
  -4.67831284e-01f, -3.95313166e-02f, 5.38962111e-02f, 1.34417659e-03f, -1.63201932e-02f, 4.15297709e-02f, 1.03705205e-01f, 9.69323441e-02f, 1.30962133e-01f, 2.28730813e-02f,
  9.98608768e-03f, -2.85803024e-02f, 1.25327006e-01f, 6.30473793e-02f, 1.13292985e-01f, -8.00944641e-02f, -4.29848172e-02f, 1.69541836e-02f, -3.49097066e-02f, -9.25792903e-02f,
  2.95028202e-02f, 1.62721008e-01f, 1.06963485e-01f, 1.73905760e-01f, 1.87961496e-02f, 1.59610936e-05f, -9.43535939e-03f, 1.01447990e-02f, -1.49646541e-02f, 1.63732320e-02f,
  -1.85548693e-01f, 1.99234262e-01f, -1.51402252e-02f, 1.52838394e-01f, 1.04250364e-01f, 2.07050532e-01f, 1.11062512e-01f, 1.83636874e-01f, 1.69507787e-01f, -3.33911218e-02f,
  -1.32256830e-02f, 5.78634143e-02f, 2.01113354e-02f, -2.24981029e-02f, -1.46763638e-01f, 3.57743651e-02f, -1.81981288e-02f, -8.67360551e-03f, 8.00641533e-03f, -1.57745145e-02f,
  -4.75983992e-02f, -2.35781223e-02f, -1.67242691e-01f, -1.54917970e-01f, -1.73525646e-01f, -7.31702223e-02f, -5.66588566e-02f, 5.38520236e-03f, -5.90743944e-02f, 2.98641883e-02f,
  4.47257683e-02f, -1.03762813e-01f, -4.70573790e-02f, -8.67336020e-02f, 8.55309665e-02f, -7.53239542e-03f, -7.99536109e-02f, -1.10354096e-01f, 6.85385391e-02f, -4.48299535e-02f,
  -1.30032212e-01f, -2.94482578e-02f, -8.84060264e-02f, 1.32208750e-01f, 2.84915771e-02f, 5.58903441e-02f, 3.33463736e-02f, 1.63844481e-01f, -1.10047229e-01f, -1.06991492e-01f,
  -1.06914572e-01f, 1.84425637e-01f, 1.38623133e-01f, 3.90388258e-02f, 9.52091292e-02f, 1.08668439e-01f, 6.32475913e-02f, 2.79843900e-02f, 2.12654024e-02f, 1.71060622e-01f,
  1.10187061e-01f, -2.28957281e-01f, -2.42770344e-01f, 1.36675343e-01f, -1.59996808e-01f, -2.22020254e-01f, -1.64494976e-01f, 1.89139634e-01f, 1.66910157e-01f, -2.43637666e-01f,
  -1.26627326e-01f, 8.67498443e-02f, 3.72313112e-02f, -6.61693066e-02f, -4.76150364e-02f, -2.14182660e-01f, -2.23080888e-01f, -1.71607211e-01f, 1.39425009e-01f, 1.51898205e-01f,
  1.05850413e-01f, 1.75748020e-01f, 1.90358788e-01f, 5.14117144e-02f, -1.23929851e-01f, 5.42848483e-02f, -2.34751284e-01f, -6.99974410e-03f, -1.40563175e-01f, -3.66365790e-01f,
  -3.95758599e-01f, -2.85163224e-02f, 5.01647107e-02f, 2.70138104e-02f, -5.56580536e-02f, 7.70277977e-02f, 1.30898051e-03f, 1.05315568e-02f, 1.52200475e-01f, -2.23194696e-02f,
  7.44649097e-02f, 1.48368627e-01f, 2.16974914e-02f, 1.14787944e-01f, 8.84663463e-02f, 1.63337544e-01f, 4.48123701e-02f, -1.78973913e-01f, -1.78076863e-01f, -2.17078000e-01f,
  -2.08093114e-02f, -1.20128863e-01f, -7.95064494e-02f, -2.14906916e-01f, -6.21491298e-03f, 7.12044723e-03f, -1.33301750e-01f, -1.79134365e-02f, -1.77123278e-01f, -1.29420385e-01f,
  -2.32670456e-01f, -1.60703272e-01f, -6.20877519e-02f, 3.28949988e-02f, 9.73401591e-02f, 1.99565962e-02f, -5.72685748e-02f, -5.71011603e-02f, -2.19546948e-02f, 8.51742402e-02f,
  2.94433925e-02f, 4.27099131e-02f, 1.06197698e-02f, -1.27994731e-01f, -8.54905918e-02f, -7.09588900e-02f, -8.03718790e-02f, -1.28917009e-01f, -3.14902849e-02f, -7.50238076e-02f,
  -5.25992103e-02f, -3.09911259e-02f, -4.62829247e-02f, 3.86609584e-02f, -3.88267487e-02f, -2.71701925e-02f, -1.57933220e-01f, -1.60940345e-02f, 1.58909678e-01f, 1.78567525e-02f,
  2.11700097e-01f, -1.53157070e-01f, -1.09979540e-01f, 2.37635151e-02f, 8.77477578e-04f, 1.69170164e-02f, -1.74901128e-01f, -6.76187128e-02f, 2.83173546e-02f, -5.00163920e-02f,
  -4.39224429e-02f, 1.16967205e-02f, 2.11595297e-02f, 7.42546096e-02f, -2.22989894e-03f, 1.98719539e-02f, -3.82288508e-02f, -9.48686749e-02f, -9.65837836e-02f, -1.91936418e-02f,
  -2.93007270e-02f, -5.74944168e-02f, -2.22641006e-02f, -7.35806152e-02f, -8.13021660e-02f, 1.53781613e-02f, -1.28004566e-01f, 3.63787357e-03f, -8.60993862e-02f, -2.31039971e-02f,
  6.80417240e-01f, -1.84592664e-01f, 4.00232971e-01f, -8.74705166e-02f, -3.26054484e-01f, -1.91783696e-01f, -2.27786347e-01f, -9.64003354e-02f, -7.97944665e-02f, -2.39461005e-01f,
  -2.77450234e-01f, -2.75551230e-01f, -1.12269409e-01f, -7.29021430e-03f, 2.17794016e-01f, 1.16574913e-01f, 4.81447205e-02f, 4.12234366e-01f, 3.63799930e-01f, -1.46422246e-02f,
  -1.82648510e-01f, 1.29617944e-01f, 3.54502350e-01f, 1.03042506e-01f, -1.14827268e-01f, -9.74965841e-03f, 9.67960618e-03f, -9.24437270e-02f, -1.29249126e-01f, -2.89587416e-02f,
  -9.76377726e-02f, 1.64735362e-01f, 9.38686952e-02f, 1.03724832e-02f, -7.52257556e-02f, 7.01000169e-02f, 1.22403614e-02f, 8.39670375e-02f, -5.04514873e-02f, -9.60805640e-02f,
  -5.87192364e-02f, 4.80397865e-02f, -2.87842210e-02f, 2.25371346e-02f, -7.72411050e-03f, 1.75058674e-02f, 2.70867180e-02f, -8.19335971e-03f, -1.73348375e-03f, -5.53731993e-02f,
  -1.81769788e-01f, -6.49481863e-02f, -5.50806299e-02f, -6.90725967e-02f, 1.30988538e-01f, 4.17713150e-02f, -1.51799954e-02f, 8.35834369e-02f, 1.02704957e-01f, 5.22971619e-03f,
  -7.73473158e-02f, -6.76573217e-02f, -9.42908674e-02f, -3.69300842e-02f, 8.66905898e-02f, 4.06017452e-02f, 8.80792961e-02f, -2.07853820e-02f, 9.27659199e-02f, 4.67795208e-02f,
  -5.96621372e-02f, 3.02233994e-02f, -7.24031702e-02f, 8.05158243e-02f, -3.74216326e-02f, -3.37960795e-02f, -2.85408786e-03f, -1.90847199e-02f, -9.12068188e-02f, -1.24719247e-01f,
  -5.62144853e-02f, -2.59908848e-02f, 4.38008718e-02f, -6.22600988e-02f, -9.94480550e-02f, 1.04034906e-02f, -3.18107978e-02f, -1.25387296e-01f, 4.16896269e-02f, -5.82441278e-02f,
  -4.38566983e-01f, 4.43009920e-02f, 3.29666696e-02f, -6.11089356e-02f, 8.80994797e-02f, 6.39011934e-02f, -1.43897802e-01f, -5.04102521e-02f, -3.84294391e-02f, -3.46218683e-02f,
  1.16470300e-01f, 1.19665384e-01f, -7.25761103e-03f, -9.71121415e-02f, 5.91735430e-02f, 1.40601337e-01f, -8.02550185e-03f, -6.80261627e-02f, -7.44589940e-02f, -8.29081312e-02f,
  -1.29797369e-01f, -2.59304382e-02f, 5.15434742e-02f, -5.53639093e-03f, 1.21520936e-01f, 1.02445848e-01f, 1.91169064e-02f, 7.24603906e-02f, 1.51652485e-01f, 1.18098900e-01f,
  -1.43421432e-02f, 3.72810103e-02f, -1.99329983e-02f, -3.91119570e-02f, -1.99623898e-01f, -2.39610955e-01f, -1.26776947e-02f, -3.90350074e-01f, -2.69697100e-01f, 5.01952842e-02f,
  -4.30591144e-02f, -3.65748070e-02f, 8.61588046e-02f, -2.32539885e-02f, -9.28999633e-02f, 1.17765382e-01f, 8.05029720e-02f, -4.96311765e-03f, -2.01633766e-01f, -1.22747026e-01f,
  -7.77348354e-02f, 4.84871119e-02f, -3.52882110e-02f, -4.49455343e-02f, 1.15335144e-01f, 4.85432893e-03f, 9.68675315e-02f, -6.11981153e-02f, 3.35979313e-02f, 2.90561885e-01f,
  3.58142912e-01f, -8.47741216e-02f, -1.00930400e-01f, -9.05619189e-02f, -1.51798591e-01f, 5.16899340e-02f, -6.78025931e-02f, -8.91474783e-02f, -1.26228690e-01f, 3.28886285e-02f,
  -2.86754291e-03f, -4.86658551e-02f, -1.19519286e-01f, 1.88489020e-01f, -8.22378322e-02f, 5.40135950e-02f, -5.75230923e-03f, -1.34557083e-01f, -1.54480785e-01f, 1.50003523e-01f,
  3.25323604e-02f, -1.22637656e-02f, 8.41209888e-02f, -5.88098951e-02f, -1.09384485e-01f, -8.75867829e-02f, 7.41384691e-04f, -1.94556221e-01f, -2.32388005e-01f, 1.28017932e-01f,
  -7.90625438e-02f, 1.05599247e-01f, -4.12385724e-02f, 5.90772964e-02f, -8.00638124e-02f, -5.57342544e-02f, 6.55005798e-02f, 3.04755685e-03f, 5.64856268e-02f, -1.25144692e-02f,
  -6.27801288e-03f, 9.19015557e-02f, -5.87774366e-02f, -9.64014605e-02f, 8.18673968e-02f, -1.23661801e-01f, -7.02090040e-02f, -3.91859449e-02f, -1.19137585e-01f, -7.01253349e-03f,
  -2.40316112e-02f, -4.80870306e-02f, 2.35537831e-02f, -6.59132749e-02f, 7.78547600e-02f, 4.43360396e-02f, 8.70805793e-03f, 4.34077950e-03f, -7.29199778e-03f, -4.48352052e-03f,
  1.94744140e-01f, -1.92447260e-01f, 1.98426872e-01f, -1.17052086e-01f, -1.29997343e-01f, -5.56228422e-02f, 4.51623313e-02f, -8.09660330e-02f, 5.80911990e-03f, 2.59026922e-02f,
  2.55676452e-02f, -7.03346776e-03f, 1.73247755e-01f, 9.78024304e-02f, 8.74890909e-02f, 8.20586905e-02f, 4.12499942e-02f, -4.71323095e-02f, -6.35530502e-02f, -1.32905304e-01f,
  5.58238812e-02f, -6.21240772e-02f, 1.07866950e-01f, -5.74212857e-02f, -1.03520371e-01f, 3.07379495e-02f, 2.93186963e-01f, 1.00887835e-01f, -1.11269444e-01f, 2.55699843e-01f,
  5.57779729e-01f, 1.23869143e-01f, 2.88719237e-01f, 6.28995597e-02f, -5.37602268e-02f, -2.08254129e-01f, -1.31085068e-01f, -2.08884656e-01f, -2.10514411e-01f, -1.49015128e-03f,
  3.34970164e-03f, -1.62651777e-01f, 7.83489365e-03f, -6.48118649e-03f, 1.11569889e-01f, 6.23822911e-03f, 1.17462903e-01f, 1.90026700e-01f, 9.49816853e-02f, 4.24803421e-02f,
  3.87445022e-03f, 2.23372608e-01f, 2.68536180e-01f, 5.25082573e-02f, 8.60476494e-02f, -1.00308128e-01f, 9.30181742e-02f, 2.52062887e-01f, 9.08013582e-02f, 2.61943161e-01f,
  2.17273071e-01f, 3.77797425e-01f, -2.34743521e-01f, -4.41991352e-02f, 2.62206763e-01f, 8.21982175e-02f, 4.71577197e-02f, 1.52417615e-01f, -5.07475883e-02f, 2.54139770e-02f,
  6.13682382e-02f, 1.90845579e-01f, 1.35445923e-01f, 8.30686316e-02f, 5.13392612e-02f, 8.27388186e-03f, 1.57392591e-01f, 1.60326734e-01f, 2.58544125e-02f, 8.78551695e-03f,
  1.42511325e-02f, 3.03943083e-02f, 9.42136534e-03f, -1.12933427e-01f, 1.60651598e-02f, 1.06017431e-02f, 1.32671997e-01f, 9.86680314e-02f, 3.87600847e-02f, 4.23199832e-02f,
  -2.26366699e-01f, -8.65524188e-02f, 6.64251894e-02f, -6.85427710e-02f, -2.21421290e-02f, 2.57200580e-02f, 3.08302622e-02f, -8.71631876e-02f, 2.35602986e-02f, 1.16655871e-01f,
  -1.03154881e-02f, 7.48556526e-03f, -3.18477117e-02f, -6.70895725e-02f, 1.70789119e-02f, 1.27467319e-01f, 1.40631050e-01f, 5.33064827e-02f, 9.33874100e-02f, -3.26210894e-02f,
  -1.20128710e-02f, 2.00175066e-02f, 9.88771096e-02f, 1.04757041e-01f, 6.59520924e-02f, 6.88533410e-02f, -2.78351782e-03f, 6.73975125e-02f, 8.50324407e-02f, -4.80537526e-02f,
  -1.32047489e-01f, 4.80622463e-02f, -7.18061104e-02f, -4.88147847e-02f, 9.00776237e-02f, 5.28486818e-02f, -8.16783495e-03f, -9.81142968e-02f, -5.74426204e-02f, -1.36541098e-01f,
  -1.97752137e-02f, 1.37674898e-01f, 1.12487204e-01f, 9.37371328e-02f, -9.12209749e-02f, -8.24380144e-02f, -1.00894995e-01f, -5.14084063e-02f, 1.92614389e-04f, -9.56938788e-02f,
  -1.17202103e-01f, -3.21526587e-01f, -2.94239700e-01f, -3.10758144e-01f, -1.87807098e-01f, -2.86260247e-01f, -1.47267759e-01f, -1.00008771e-01f, -1.59477845e-01f, -1.72045827e-01f,
  1.55526876e-01f, -2.30856314e-01f, -2.90099889e-01f, -1.29733473e-01f, -3.26985627e-01f, -1.60095975e-01f, -2.56382912e-01f, 3.83493751e-02f, -1.34410650e-01f, -3.03172588e-01f,
  -1.16761915e-01f, 2.48835161e-01f, 1.13385275e-01f, 6.40977696e-02f, 1.90496668e-01f, -3.32442105e-01f, -3.21319371e-01f, -8.54591951e-02f, 2.12131098e-01f, -6.07602112e-02f,
  -8.51057842e-02f, -1.38204277e-01f, 4.97030541e-02f, -7.50714764e-02f, -2.06680283e-01f, -5.67152128e-02f, -3.75721723e-01f, -1.01374492e-01f, -1.55879289e-01f, -3.29550326e-01f,
  -2.30231993e-02f, 4.59914245e-02f, -3.79445329e-02f, 5.24962768e-02f, -2.38584265e-01f, -6.88685551e-02f, -4.00670432e-02f, -2.46458307e-01f, 9.76153091e-02f, -5.56906983e-02f,
  -7.64399022e-02f, -4.62374389e-02f, 6.05001152e-02f, -1.91449411e-02f, -8.05942565e-02f, 3.05700507e-02f, 8.60846695e-03f, -3.14995162e-02f, -7.05133304e-02f, -1.03098415e-01f,
  -7.99849704e-02f, 8.31871033e-02f, 7.67099613e-04f, -3.42314802e-02f, -9.34687853e-02f, 5.80592826e-02f, -1.49938822e-01f, -7.79876709e-02f, -9.45779681e-03f, -2.83224732e-01f,
  -1.24359235e-01f, -1.18438818e-01f, -3.73385586e-02f, -7.55622387e-02f, 6.68098778e-03f, -3.01243570e-02f, 2.47919653e-02f, 1.31766684e-02f, 8.20671991e-02f, 1.42627075e-01f,
  -4.65177968e-02f, -1.02097943e-01f, -1.27700716e-01f, -3.29397395e-02f, -3.09087113e-02f, 9.82727259e-02f, -9.35871303e-02f, 1.31716365e-02f, -3.38898525e-02f, -3.28095406e-02f,
  -1.25691807e-02f, 7.91006461e-02f, 9.91116278e-03f, 1.07873797e-01f, 3.48975509e-02f, 7.62239471e-02f, 5.54202646e-02f, 1.50282159e-02f, 2.15404318e-03f, -5.74220382e-02f,
  9.37130824e-02f, 8.03063661e-02f, -4.40657213e-02f, 8.26922432e-02f, -6.65208623e-02f, -6.01427332e-02f, -5.39518707e-02f, -5.71053512e-02f, 4.29189540e-02f, -4.26900573e-02f,
  1.13561727e-01f, 1.04953900e-01f, 6.76629767e-02f, -4.67220321e-03f, -1.54734438e-03f, 2.44320487e-03f, -2.50213351e-02f, 4.55829464e-02f, -9.43577066e-02f, -5.92790507e-02f,
  -1.18758298e-01f, 9.38016847e-02f, 1.24674149e-01f, 9.18643400e-02f, -4.09012511e-02f, 1.06572956e-01f, 1.82510521e-02f, -1.06314512e-03f, 2.21140221e-01f, 3.40416329e-03f,
  -3.51987004e-01f, 7.58170858e-02f, 4.85267825e-02f, -2.40747795e-01f, 1.69758454e-01f, 1.80653095e-01f, 2.35725790e-01f, 1.10792011e-01f, -5.25066890e-02f, 1.65100433e-02f,
  -1.23249270e-01f, -2.06393033e-01f, 5.94222434e-02f, 3.90323699e-02f, 6.05400689e-02f, 2.77014583e-01f, 2.61243850e-01f, 2.24783093e-01f, -6.61142096e-02f, -3.42840254e-02f,
  3.57553437e-02f, -4.85413633e-02f, -1.13547258e-01f, 2.72819381e-02f, -3.52117717e-02f, -3.39167416e-02f, -8.61745421e-03f, -1.12094738e-01f, 1.46134064e-01f, 1.81237340e-01f,
  -2.99775273e-01f, -3.01149935e-01f, 8.27597752e-02f, -1.63708001e-01f, -9.37577337e-02f, -1.93248279e-02f, 1.36340871e-01f, 1.00970887e-01f, -5.22820391e-02f, -5.74369095e-02f,
  -9.67389569e-02f, 7.55591840e-02f, 1.81504432e-02f, 2.05995385e-02f, -3.67147662e-02f, -1.26901180e-01f, 3.55708711e-02f, 3.37574035e-02f, -9.64056402e-02f, -5.12619950e-02f,
  2.66710937e-01f, -2.15330143e-02f, -1.77561745e-01f, 2.02606525e-02f, 3.83515023e-02f, -1.54378727e-01f, -1.03693895e-01f, -1.67317361e-01f, -1.47085607e-01f, -1.08913086e-01f,
  2.81616841e-02f, 1.11164533e-01f, 2.27870848e-02f, 4.14664000e-02f, -1.52967535e-02f, 7.38281608e-02f, -2.67011598e-02f, 2.29775701e-02f, 1.18586190e-01f, -7.84051865e-02f,
  -9.29007605e-02f, -2.80374028e-02f, -1.02925664e-02f, -3.46100852e-02f, -1.76743381e-02f, 7.43871182e-02f, 6.66760467e-03f, -2.00640112e-02f, 7.16917589e-03f, -6.80278055e-04f,
  2.03161631e-02f, -6.88955262e-02f, -2.01570973e-01f, 2.80045308e-02f, 1.04684569e-01f, -6.60100579e-03f, -7.08751157e-02f, -7.18684343e-04f, -9.60611925e-02f, -1.21564828e-01f,
  -3.85859251e-01f, -2.91944165e-02f, -9.70268250e-02f, 9.45359543e-02f, -3.11053023e-02f, -9.46153253e-02f, -5.88949658e-02f, 3.81572582e-02f, -1.12491019e-01f, -9.09732655e-02f,
  -7.20641911e-02f, -7.72441924e-02f, -1.02245070e-01f, 1.61198646e-01f, -3.21934558e-02f, -3.63383777e-02f, 7.02861324e-02f, 1.12241015e-01f, -7.37808272e-03f, -1.57173470e-01f,
  1.67270243e-01f, -1.47070691e-01f, -1.07466333e-01f, 3.13026048e-02f, -1.14270866e-01f, -2.63294160e-01f, -1.11435279e-01f, -2.06304371e-01f, -1.35037810e-01f, -2.23929390e-01f,
  -5.84547371e-02f, -5.87381003e-03f, 2.39302173e-01f, -8.62917751e-02f, 2.74522454e-01f, 3.49602908e-01f, 4.61194098e-01f, 2.02458873e-01f, -8.62550810e-02f, 1.06073536e-01f,
  -9.39016715e-02f, -3.17734331e-01f, -2.41696551e-01f, -1.93723246e-01f, -1.09109813e-02f, 2.63308614e-01f, 1.33845299e-01f, 1.09861866e-01f, 1.88411832e-01f, 6.21564984e-02f,
  -1.87726453e-01f, -6.09094128e-02f, -6.37471974e-02f, -2.14328039e-02f, -1.52331993e-01f, -1.70022294e-01f, 1.37769952e-01f, 8.63280445e-02f, 1.42345652e-01f, -1.44905418e-01f,
  3.09119403e-01f, 2.53452748e-01f, -7.37608969e-02f, -1.76502913e-01f, -8.58413652e-02f, -7.81829655e-02f, 3.08665372e-02f, 5.82562387e-02f, -3.12521122e-02f, -1.53060639e-02f,
  -2.37909704e-02f, 5.74639812e-03f, 4.89001945e-02f, 1.26515059e-02f, 1.19858511e-01f, 4.73120585e-02f, -2.12373957e-02f, -5.81938662e-02f, -6.19213656e-02f, -9.02102366e-02f,
  -2.05505878e-01f, 8.07841122e-02f, 2.40309611e-01f, 8.36378261e-02f, -4.48753014e-02f, -1.04643911e-01f, 2.44292337e-02f, 1.06298532e-02f, 7.35518932e-02f, -1.50372952e-01f,
  -7.02504888e-02f, -3.68394703e-02f, -4.22153994e-03f, -3.68129387e-02f, 1.50322719e-02f, -1.26163056e-02f, 4.13768254e-02f, 1.54397599e-02f, 3.96144539e-02f, 4.95584384e-02f,
  1.59906805e-01f, 1.26635641e-01f, 1.53321490e-01f, 4.68717776e-02f, -2.98124496e-02f, 8.75764266e-02f, 4.47075032e-02f, -7.92583171e-03f, 4.85264435e-02f, 6.14580736e-02f,
  4.84553352e-03f, 1.11496307e-01f, 1.05566457e-01f, 9.27138403e-02f, 3.49711217e-02f, -2.08313726e-02f, 3.54991779e-02f, 3.45588923e-02f, 7.19485758e-03f, 4.16765660e-02f,
  1.00270338e-01f, 1.22909516e-01f, -1.46740273e-01f, 2.40968037e-02f, -3.63029377e-03f, -5.46516776e-02f, 1.22236758e-02f, 9.36186686e-03f, 6.62141070e-02f, -3.81604880e-02f,
  1.16549969e-01f, -6.56186566e-02f, 1.42297104e-01f, -1.18098024e-03f, 3.58187035e-02f, 4.84287031e-02f, -1.94137305e-01f, -1.91665702e-02f, -1.16425253e-01f, -2.17895657e-02f,
  -9.09682363e-02f, -4.79970500e-02f, 8.44717026e-02f, 1.04883477e-01f, -6.06017634e-02f, 7.36219808e-02f, 1.64996937e-01f, 1.22164950e-01f, 3.03540248e-02f, 1.09165916e-02f,
  3.15812409e-01f, 1.93712056e-01f, -1.22284956e-01f, 2.04149947e-01f, -1.10937178e-01f, -3.71508300e-01f, -3.73065770e-01f, -3.01302940e-01f, 2.44860034e-02f, 1.18257597e-01f,
  -8.63884091e-02f, -1.15612052e-01f, -1.14099577e-01f, -2.58262455e-01f, -4.00798023e-01f, -8.13461989e-02f, 1.18052484e-02f, -1.93159759e-01f, -4.53443646e-01f, -2.69669741e-01f,
  -9.17445198e-02f, -6.11149939e-03f, 1.24434896e-01f, -4.23967540e-02f, 1.48563266e-01f, 6.87671378e-02f, 1.95172966e-01f, 5.97474948e-02f, 1.01249509e-01f, 3.44995648e-01f,
  1.77969586e-03f, 4.11624424e-02f, -2.16639534e-01f, 4.97204326e-02f, 5.05166501e-03f, 3.43075432e-02f, -1.36279908e-03f, -4.94998246e-02f, -2.07953691e-01f, -1.10582367e-01f,
  -7.18560144e-02f, 1.52303148e-02f, -6.54585510e-02f, -5.42914569e-02f, -1.24748662e-01f, -9.47291404e-02f, -1.87057920e-03f, -5.18203042e-02f, -2.70114571e-01f, -1.91707134e-01f,
  4.31361981e-02f, -1.83136147e-02f, -1.74190849e-01f, -1.07618146e-01f, -1.40711546e-01f, 1.13303363e-02f, -6.55370653e-02f, 3.12051885e-02f, -2.39743665e-01f, 2.21518159e-01f,
  2.57718749e-03f, -1.13024220e-01f, -3.21720429e-02f, -4.27462608e-02f, -2.05674898e-02f, 4.01491448e-02f, -7.71390740e-03f, 8.72614235e-02f, -4.95486110e-02f, 6.73592836e-02f,
  -5.29053994e-02f, 1.19599132e-02f, 1.93530936e-02f, 9.69964415e-02f, -5.20445965e-02f, 1.28320763e-02f, 5.94946854e-02f, -8.68727732e-03f, -8.71876702e-02f, -8.80362242e-02f,
  -1.63831506e-02f, 2.64329072e-02f, 7.97912404e-02f, -8.43843669e-02f, 2.03566272e-02f, 6.01092391e-02f, -1.82808936e-03f, -1.34880394e-01f, -3.58459689e-02f, -5.85872494e-03f,
  2.96944976e-02f, -2.93894917e-01f, 1.35361105e-01f, -1.16427615e-01f, -9.74400640e-02f, -1.10847235e-01f, 1.33720227e-02f, 1.07528389e-01f, 1.06772378e-01f, 6.61286351e-04f,
  -9.59658325e-02f, 4.27876934e-02f, -3.61189060e-03f, -6.99834600e-02f, 3.39119043e-03f, 9.43828747e-03f, -1.39583396e-02f, -3.71652767e-02f, -1.62883356e-01f, -3.36064026e-02f,
  1.99955955e-01f, -8.42837393e-02f, 2.53720898e-02f, 7.82749057e-02f, -8.75563174e-02f, -6.04432300e-02f, 3.92431989e-02f, 2.59467475e-02f, -7.69192204e-02f, 2.95552105e-01f,
  4.32392508e-01f, 4.04132381e-02f, -3.25927228e-01f, 3.24856579e-01f, -2.89689749e-01f, -3.34208220e-01f, -9.87554938e-02f, -3.47060561e-02f, 2.35881418e-01f, 6.40404003e-04f,
  -3.15249592e-01f, -1.35026962e-01f, -4.31233086e-03f, -1.66375041e-01f, -3.80629487e-02f, -2.74940915e-02f, 1.06577277e-01f, -1.17398351e-01f, -2.00069800e-01f, -2.44612023e-01f,
  -3.76309752e-02f, 1.78138763e-01f, 7.60444114e-03f, -8.40838030e-02f, -2.79381089e-02f, -5.98047264e-02f, -1.72592402e-02f, -7.39289001e-02f, -1.14084788e-01f, 4.67819721e-02f,
  -1.50321439e-01f, -2.26483434e-01f, -1.53444670e-02f, 1.37087461e-02f, -3.25577473e-03f, 1.41910911e-01f, -7.64226541e-02f, -3.12391464e-02f, -1.02321384e-02f, -4.04073782e-02f,
  -4.11670879e-02f, -2.90847838e-01f, 2.43121330e-02f, -2.08727747e-01f, -1.21857323e-01f, -6.39752671e-02f, 7.08072912e-03f, 3.65084037e-02f, 1.31702110e-01f, -1.96231276e-01f,
  -1.24602519e-01f, -2.16713026e-01f, -1.63167298e-01f, -1.16198793e-01f, -1.75189927e-01f, -2.39934977e-02f, -1.48747906e-01f, -2.08615720e-01f, -2.59158462e-01f, 2.17793688e-01f,
  -6.34328946e-02f, -1.25214774e-02f, -4.64492897e-03f, -4.17924151e-02f, 1.08066835e-01f, 6.04771636e-02f, 4.52341139e-02f, 3.59165594e-02f, -3.07944007e-02f, 3.35592292e-02f,
  6.22087047e-02f, 2.51518264e-02f, -3.34507003e-02f, 7.46094361e-02f, 8.59861374e-02f, 1.83947701e-02f, -2.62558274e-02f, 8.05872120e-03f, 5.32524511e-02f, 8.66100937e-02f,
  -7.32738227e-02f, -8.57498869e-03f, 9.69142392e-02f, -8.20398517e-03f, -3.76523100e-02f, 2.60552857e-02f, -5.80898449e-02f, -9.41989049e-02f, 8.92776847e-02f, -1.09870853e-02f,
  3.62800360e-01f, -1.82890177e-01f, 3.34509104e-01f, 8.86343047e-02f, 7.70068318e-02f, 3.49292457e-02f, 6.59399629e-02f, 1.36045769e-01f, 1.16775028e-01f, -1.62593666e-02f,
  -1.20108694e-01f, 2.85151508e-02f, 1.60790160e-02f, -1.49199953e-02f, -5.91949038e-02f, -1.27141535e-01f, -1.08201709e-02f, 5.19367568e-02f, 9.48879197e-02f, -1.31307635e-02f,
  2.57868320e-01f, 2.01580107e-01f, 2.95257121e-01f, 1.73640773e-02f, 8.51762965e-02f, 1.33885533e-01f, 8.04141238e-02f, 6.54952675e-02f, 2.00251881e-02f, 4.89950210e-01f,
  -3.32491159e-01f, 1.70937300e-01f, 8.40575621e-02f, -1.89963400e-01f, 1.73373194e-03f, 7.65874013e-02f, -3.16368714e-02f, -2.05971882e-01f, -7.37410113e-02f, 2.70170122e-01f,
  1.30361170e-01f, -4.35737222e-02f, 4.85186018e-02f, -4.40790690e-02f, -2.63658583e-01f, 1.12848170e-01f, -2.80936845e-02f, -1.83668524e-01f, -3.30721766e-01f, -1.52063578e-01f,
  -5.96044436e-02f, -1.89738587e-01f, -1.69130608e-01f, -1.27360746e-01f, 9.56367254e-02f, 1.29495561e-01f, 1.94124907e-01f, -3.90633531e-02f, 1.06100835e-01f, 1.14834517e-01f,
  2.52802849e-01f, 4.22030613e-02f, 4.48127426e-02f, -2.24166065e-01f, 7.45309517e-02f, 2.58781444e-02f, -1.12152882e-02f, 1.78779531e-02f, -8.34710225e-02f, 1.88857783e-02f,
  -1.30258337e-01f, 1.13684982e-01f, -1.05996005e-01f, -1.07777864e-02f, -1.64684802e-01f, -1.29205603e-02f, -1.83734939e-01f, -1.93024054e-01f, -2.30408847e-01f, -1.32975623e-01f,
  -2.39194706e-01f, -9.22251865e-02f, -1.17391065e-01f, -7.90252537e-02f, 3.76307927e-02f, -8.67978334e-02f, 1.58596262e-02f, 9.56860196e-04f, 1.92074217e-02f, 1.39667809e-01f,
  7.63880312e-02f, -8.16535391e-03f, -6.67512566e-02f, -3.37584340e-03f, -1.43793402e-02f, 3.16323973e-02f, 3.47689800e-02f, 7.68597703e-03f, 3.45593169e-02f, -9.30685177e-03f,
  -2.31222510e-02f, 1.64790154e-01f, 4.58978303e-03f, -1.93125997e-02f, -2.12465376e-02f, 2.03996133e-02f, -5.86405247e-02f, -1.88617073e-02f, -3.98105271e-02f, 5.48308864e-02f,
  8.39783810e-03f, 1.93541627e-02f, -2.38195248e-03f, -1.47282004e-01f, 9.05799642e-02f, 3.33044529e-02f, 3.95182818e-02f, -5.96427210e-02f, -2.19110250e-02f, 7.72682354e-02f,
  -1.30351800e-02f, 1.35922730e-01f, 5.17970249e-02f, -1.54271632e-01f, 8.94364193e-02f, 4.55766469e-02f, 4.92546521e-02f, -1.16229422e-01f, 6.45273030e-02f, -1.39665857e-01f,
  -5.95690347e-02f, -3.49809751e-02f, 8.30557644e-02f, -1.09073177e-01f, -1.21916100e-01f, 2.78332215e-02f, -6.12907819e-02f, -7.69400150e-02f, -1.05671927e-01f, -2.00174332e-01f,
  -2.17822567e-01f, -1.59233272e-01f, -1.51242211e-01f, 1.01402134e-01f, 1.55673139e-02f, 2.25565694e-02f, 1.06031939e-01f, 2.39187106e-01f, 1.01999398e-02f, 1.45134181e-01f,
  -8.48491490e-01f, -6.80466741e-02f, 1.42678946e-01f, -2.56518781e-01f, 7.48367235e-02f, -3.94616602e-03f, 1.63063586e-01f, -1.09160900e-01f, -1.87519435e-02f, 1.38246164e-01f,
  4.02160846e-02f, -1.06919035e-01f, -4.68376130e-02f, 1.47560770e-02f, -9.40728188e-02f, 2.45672494e-01f, 1.74155846e-01f, -1.65760607e-01f, -1.92222074e-01f, -7.24045709e-02f,
  5.60000837e-02f, -2.09998295e-01f, -3.04923356e-01f, -2.76083529e-01f, 9.14340094e-02f, -7.60726705e-02f, 7.19477832e-02f, 2.08036676e-02f, -1.61623340e-02f, 8.96439105e-02f,
  2.04456568e-01f, -1.12088911e-01f, 7.75772184e-02f, -1.41367599e-01f, -6.62005991e-02f, -1.52840391e-01f, -1.70152709e-01f, -1.83535054e-01f, -1.69310331e-01f, -1.29696891e-01f,
  -9.89319980e-02f, -1.78142250e-01f, -7.30857179e-02f, -1.01325653e-01f, -1.01984583e-01f, -1.74865007e-01f, -9.03460607e-02f, -7.01675043e-02f, 3.65098612e-03f, 6.55469075e-02f,
  1.74959505e-03f, -1.97233874e-02f, -2.27053370e-02f, -2.45334092e-03f, -1.22402564e-01f, -6.67579398e-02f, -2.16946099e-02f, -1.23776615e-01f, -9.01106670e-02f, 2.65585519e-02f,
  -3.39014232e-02f, -1.46239311e-01f, -5.92250004e-02f, -8.50667059e-02f, 1.56478900e-02f, 6.86465278e-02f, 4.36738208e-02f, -1.95720289e-02f, -8.65580142e-02f, 4.27380130e-02f,
  6.46404875e-03f, -1.51866963e-02f, -5.64560443e-02f, -7.83147514e-02f, -4.92508896e-02f, -1.03816420e-01f, -4.29317616e-02f, 5.22502251e-02f, -7.56745785e-02f, -1.62375003e-01f,
  -9.17527154e-02f, -1.40622064e-01f, -3.52962650e-02f, 7.42181316e-02f, -5.51669635e-02f, -8.85065421e-02f, 4.45582643e-02f, -4.69738320e-02f, -8.72090608e-02f, -2.38813944e-02f,
  1.51144877e-01f, -2.72399466e-02f, 1.45196453e-01f, 3.94184003e-03f, 6.01715816e-04f, -2.37511508e-02f, -1.26183122e-01f, 1.82489883e-02f, 2.26871129e-02f, 1.07732229e-01f,
  -4.28338535e-02f, -1.72424823e-01f, -1.48831615e-02f, 8.87174979e-02f, -6.88817278e-02f, 2.28654966e-02f, 1.53231725e-01f, 9.60507989e-02f, 1.14237234e-01f, 1.38901711e-01f,
  6.84633255e-02f, 1.59926891e-01f, 7.61631727e-02f, 1.60102576e-01f, 2.10998934e-02f, 1.54125303e-01f, 2.50483245e-01f, 1.15434445e-01f, 2.28833243e-01f, 1.75129846e-01f,
  -1.88210290e-02f, 2.00576335e-02f, -1.66374341e-01f, 2.07332477e-01f, -3.03118397e-02f, -3.42600852e-01f, -2.89467931e-01f, -9.80963558e-02f, 1.85211360e-01f, -1.68733656e-01f,
  -1.78739727e-01f, -1.52786270e-01f, -1.89039130e-02f, -2.11121023e-01f, -2.76452363e-01f, -2.92672575e-01f, -2.26186916e-01f, -3.98581356e-01f, -3.86628777e-01f, -2.06062183e-01f,
  -2.16287613e-01f, -7.31906444e-02f, -2.13409722e-01f, -1.29164383e-01f, 1.49165139e-01f, -9.06415954e-02f, 5.08390553e-02f, 4.48463764e-03f, -2.55197078e-01f, -6.17981830e-04f,
  -4.17094558e-01f, -7.37924352e-02f, -9.08800811e-02f, -3.28864753e-02f, 3.85417603e-02f, 3.73592302e-02f, -1.11344241e-01f, 8.71232152e-03f, 8.54418576e-02f, 1.40035739e-02f,
  5.40425330e-02f, 4.03222218e-02f, -6.14402331e-02f, 8.58509075e-03f, 1.25310142e-02f, -1.95767641e-01f, -4.44587599e-03f, -1.78929955e-01f, -8.59946832e-02f, 1.22506544e-01f,
  1.14379264e-01f, -1.09235525e-01f, -4.92675565e-02f, -7.13457763e-02f, 8.35703388e-02f, 1.31613357e-04f, -2.25348435e-02f, 8.73988941e-02f, 2.60454454e-02f, -3.93045396e-02f,
  9.16781351e-02f, -6.13491237e-03f, -8.34660903e-02f, -1.80862918e-02f, 3.49884368e-02f, 4.39732894e-02f, -2.71092709e-02f, -2.59489771e-02f, 1.80280991e-02f, 6.49404451e-02f,
  6.29211068e-02f, 4.08582622e-03f, -1.16557829e-01f, -9.69507024e-02f, -7.86493942e-02f, -3.94569188e-02f, -1.39742896e-01f, -9.13933665e-03f, -1.61508620e-01f, -9.60743949e-02f,
  -2.07072705e-01f, 7.71282017e-02f, 8.29237103e-02f, 5.99134527e-02f, -3.94684412e-02f, -3.31290811e-02f, 1.38566038e-02f, -1.70162082e-01f, 4.29977961e-02f, -1.17016509e-01f,
  -1.23579996e-02f, -2.86493003e-01f, -7.46767595e-02f, -7.17508346e-02f, 9.14549530e-02f, 1.78983390e-01f, 3.24790105e-02f, -6.57640696e-02f, 1.23407692e-02f, -8.47576186e-02f,
  -4.81708497e-02f, -2.75243279e-02f, -6.57401979e-03f, 3.85622345e-02f, -9.48683247e-02f, -6.34588003e-02f, 1.03879049e-02f, -7.71469949e-03f, -1.24411285e-01f, 2.59181321e-01f,
  1.35822967e-01f, -9.07562897e-02f, -9.81007144e-02f, -5.39714098e-02f, -3.95966806e-02f, -2.49212444e-01f, -3.39439064e-02f, -7.97499046e-02f, -1.41673200e-02f, -1.11074992e-01f,
  2.88336903e-01f, -2.17400596e-01f, -3.35946530e-01f, 2.47960702e-01f, -1.49568766e-01f, 1.75629705e-02f, -1.24809921e-01f, 2.24258095e-01f, 2.46567905e-01f, -8.74020606e-02f,
  -1.91334710e-02f, 3.52850616e-01f, 2.68122762e-01f, 8.04524943e-02f, 8.17362815e-02f, -1.56041831e-01f, -1.40184253e-01f, -9.24235657e-02f, 2.43834600e-01f, 2.65334517e-01f,
  1.82898313e-01f, 1.31985307e-01f, 1.59353718e-01f, 1.93102539e-01f, -1.79070830e-01f, 7.56826997e-02f, -1.38432771e-01f, -1.38162449e-01f, -1.49183691e-01f, -3.00653309e-01f,
  -3.95498604e-01f, -9.29577127e-02f, 1.02852508e-01f, 1.63489938e-01f, -1.19461268e-01f, 1.82087775e-02f, 6.61710650e-02f, -7.48501122e-02f, 3.09438482e-02f, -2.66465731e-02f,
  1.64536852e-02f, 3.44379358e-02f, 1.23918846e-01f, 5.88420816e-02f, -1.05921499e-01f, 5.51716983e-02f, -2.24141981e-02f, -4.37316261e-02f, -1.19305663e-01f, 1.94517486e-02f,
  -5.71226478e-02f, -3.56877223e-02f, -1.79847181e-01f, -6.51926026e-02f, -1.85959518e-01f, -5.94913289e-02f, -2.48330176e-01f, -2.36909747e-01f, -7.69713819e-02f, -2.54315734e-01f,
  5.53099774e-02f, 3.58235240e-02f, -4.09779884e-02f, -1.24789886e-01f, 7.78684393e-02f, -2.80506965e-02f, -1.07816234e-01f, -3.19925509e-02f, 6.78728372e-02f, -5.86524643e-02f,
  5.17633967e-02f, -3.40000205e-02f, 4.86572124e-02f, 8.85252878e-02f, 3.82905863e-02f, -8.78814887e-03f, 5.18768318e-02f, -7.25092180e-03f, -3.69327590e-02f, -4.94277030e-02f,
  -1.05832271e-01f, -2.24737935e-02f, -9.28612649e-02f, -2.14977264e-02f, -1.54316118e-02f, -3.53473648e-02f, 5.57197258e-02f, 1.38493210e-01f, 1.89174518e-01f, 1.15747014e-02f,
  3.12535584e-01f, 4.86738980e-02f, 2.51746364e-02f, -7.41636157e-02f, -8.55634063e-02f, 8.79575685e-02f, 1.44825475e-02f, -4.32901122e-02f, -1.26892745e-01f, -9.60452929e-02f,
  -6.57191724e-02f, 1.80848502e-02f, 5.79575375e-02f, -5.11914082e-02f, -4.19827029e-02f, 6.15616292e-02f, 2.63276659e-02f, -5.58582507e-02f, 3.81854251e-02f, -1.62532240e-01f,
  -5.80705963e-02f, 1.29995570e-02f, 9.08647999e-02f, -1.59055293e-01f, -7.06399307e-02f, 9.78169264e-04f, -1.86954141e-01f, -5.54037094e-03f, 9.74690616e-02f, -4.01288345e-02f,
  -2.61711448e-01f, -8.71613249e-02f, -2.52129972e-01f, -1.21348254e-01f, -7.37537742e-02f, -8.11270699e-02f, -3.11305702e-01f, -1.18959527e-02f, 1.83862984e-01f, -1.63975924e-01f,
  3.56503278e-02f, 1.80732593e-01f, -4.53687496e-02f, 8.76847580e-02f, -3.08587074e-01f, -4.03291732e-01f, -3.55253458e-01f, -1.92468137e-01f, 1.10450322e-02f, 1.07845254e-01f,
  1.49563015e-01f, -1.87969971e-02f, -3.64118144e-02f, 3.39630730e-02f, 8.39081686e-03f, 2.09900245e-01f, -2.20342167e-03f, 1.15743339e-01f, 2.17027832e-02f, -8.99966899e-03f,
  -3.12276930e-02f, 1.10436138e-02f, 1.96554493e-02f, -8.24110135e-02f, 2.72802357e-02f, -2.08643191e-02f, -9.33362842e-02f, -1.53557792e-01f, -4.61985497e-03f, -8.76970291e-02f,
  3.93619575e-02f, 6.60676211e-02f, -1.14507921e-01f, 6.89784437e-02f, -3.23988348e-02f, -8.83832294e-03f, -1.78039744e-02f, -5.19319959e-02f, -1.78401336e-01f, 1.00689024e-01f,
  1.38689056e-01f, 1.40077397e-01f, -3.14681195e-02f, -4.29639518e-02f, 3.32651683e-03f, -8.70028324e-03f, 1.48831561e-01f, 1.64015755e-01f, 1.71779424e-01f, 9.42806229e-02f,
  8.07592645e-02f, 6.65694475e-02f, 3.42405774e-02f, -2.33859327e-02f, -5.74473813e-02f, 1.06910624e-01f, 7.07049817e-02f, 1.08097102e-02f, -2.06664652e-02f, 4.35024453e-03f,
  1.19049825e-01f, 1.19812436e-01f, 1.86826941e-02f, -9.93367061e-02f, -3.80386524e-02f, 3.80410850e-02f, -1.88318305e-02f, -4.59226184e-02f, -2.32936796e-02f, -2.72461791e-02f,
  -6.49471581e-02f, 6.79301396e-02f, 7.32575879e-02f, 1.30217835e-01f, -1.52351663e-01f, 2.92111728e-02f, -4.25960049e-02f, 3.04886661e-02f, 8.06603134e-02f, -1.07131712e-01f,
  5.02771586e-02f, -7.10178465e-02f, -4.41173874e-02f, 1.59920193e-02f, -6.16299175e-02f, 1.09573156e-01f, 2.21909082e-04f, -1.69541702e-01f, -5.14380671e-02f, -1.10171162e-01f,
  1.08907908e-01f, 8.29986930e-02f, -2.99040880e-03f, 1.40527949e-01f, -4.30370308e-03f, 8.63880850e-03f, -1.13534480e-01f, -1.22094154e-01f, -1.45552577e-02f, -7.31504485e-02f,
  -7.45829791e-02f, -8.88001323e-02f, -1.41782939e-01f, -9.09043103e-02f, 8.63977149e-02f, 1.94800850e-02f, -3.27446274e-02f, 8.79822001e-02f, -1.14840083e-01f, -1.77257806e-01f,
  -2.08041705e-02f, -8.87014419e-02f, 4.34963554e-02f, 2.22869813e-01f, 3.97738330e-02f, -3.13584626e-01f, -3.82199049e-01f, -9.79658142e-02f, 1.17136084e-01f, -1.67380318e-01f,
  -5.82336411e-02f, -1.06273092e-01f, -1.28609285e-01f, -1.19717553e-01f, -3.87078583e-01f, -2.89395541e-01f, -2.56081492e-01f, -2.22226113e-01f, -1.97202772e-01f, -2.80481577e-01f,
  -1.31912515e-01f, -2.98925433e-02f, -1.48196251e-03f, 4.32810858e-02f, 2.08951056e-01f, 5.75823039e-02f, 2.48070344e-01f, 4.33665961e-02f, 5.96961789e-02f, 2.15207532e-01f,
  -1.46383941e-01f, 8.15066248e-02f, 5.69419600e-02f, -1.84526205e-01f, 5.66965900e-02f, -7.06367716e-02f, -1.24071859e-01f, 1.60957985e-02f, 6.73372820e-02f, -1.06909566e-01f,
  9.66256261e-02f, -1.81105047e-01f, -4.52362522e-02f, 9.28392857e-02f, -1.07031092e-01f, -2.96605229e-01f, -1.22630998e-01f, -9.43634957e-02f, -2.10468054e-01f, -1.48512974e-01f,
  -1.10250048e-01f, -1.11631401e-01f, -1.67671651e-01f, -8.35328996e-02f, -5.82865663e-02f, 1.53894220e-02f, 1.16247334e-01f, 8.18427186e-03f, 7.68176094e-02f, 1.48870170e-01f,
  -3.57967764e-02f, 9.00949836e-02f, 1.12337448e-01f, 1.60747752e-01f, -2.55972557e-02f, -4.79766354e-03f, 6.98356107e-02f, 1.39900461e-01f, -6.59722984e-02f, -1.34132402e-02f,
  4.37813997e-03f, -7.37614483e-02f, -1.17751107e-01f, -4.88088652e-02f, -4.75540198e-02f, -1.60940625e-02f, 3.94794792e-02f, 3.05818394e-02f, -4.76198569e-02f, -3.94835584e-02f,
  -1.18721411e-01f, -4.64279018e-02f, 1.65715124e-02f, 4.46387120e-02f, -9.28527117e-02f, -1.92849025e-01f, -5.84278367e-02f, -4.27874476e-02f, 3.65059450e-02f, -5.78632727e-02f,
  1.61945298e-01f, -8.23841691e-02f, 7.33787834e-04f, -1.83041599e-02f, 1.17226399e-01f, 2.87911552e-03f, -1.08175121e-01f, 4.35175560e-02f, 5.70836589e-02f, -2.73566460e-04f,
  -2.51161098e-01f, -5.78522086e-02f, 7.33571053e-02f, 9.89648774e-02f, -1.14461884e-01f, -1.11968135e-02f, -3.73908095e-02f, 1.24851968e-02f, -3.31684910e-02f, -1.00685455e-01f,
  -1.16621487e-01f, -1.94552064e-01f, -1.00355193e-01f, -2.57121362e-02f, -1.14724025e-01f, -2.04628974e-01f, 4.89233471e-02f, 3.58687378e-02f, -1.03077359e-01f, -1.64474100e-02f,
  -3.19215089e-01f, 4.04331088e-01f, 2.18415067e-01f, -2.01874450e-01f, 2.49676913e-01f, 2.99265176e-01f, 4.80276138e-01f, 8.15255102e-03f, -1.95185125e-01f, 2.36415848e-01f,
  2.02403814e-01f, -1.35975331e-01f, -5.26383184e-02f, -1.10322230e-01f, 1.80376489e-02f, 1.64807618e-01f, 1.66975036e-02f, -1.31874457e-01f, -3.66075367e-01f, -1.58130988e-01f,
  -1.86425149e-01f, -1.04241744e-01f, -1.24551460e-01f, -7.06104562e-02f, -1.17212072e-01f, -1.79517388e-01f, 5.35091907e-02f, 7.16519803e-02f, 1.02634050e-01f, -1.36780903e-01f,
  1.02677211e-01f, 2.53898561e-01f, -3.05611461e-01f, 1.68197639e-02f, 9.90222767e-03f, -1.24166599e-02f, -2.64027547e-02f, -5.25241531e-02f, 1.08886644e-01f, -2.15875413e-02f,
  9.18709934e-02f, 6.44046515e-02f, 1.73619792e-01f, 7.21671358e-02f, 6.21761680e-02f, -6.62771193e-03f, 1.50600644e-02f, -6.72391430e-02f, -8.41242149e-02f, 3.30567770e-02f,
  -1.39012942e-02f, 2.33459510e-02f, 5.91063574e-02f, 1.96567201e-03f, 4.58187200e-02f, -8.96155238e-02f, -4.59311344e-02f, -1.21565796e-01f, 3.18356976e-02f, -9.83319432e-02f,
  -8.66507515e-02f, 7.67466053e-02f, 3.35397385e-02f, -9.57864244e-03f, -2.58205757e-02f, -6.27458468e-02f, -3.44843753e-02f, 3.30702774e-02f, -1.84537880e-02f, -4.73587215e-02f,
  8.40862244e-02f, 3.42744291e-02f, 5.41535579e-02f, 5.46405278e-02f, 5.24213091e-02f, -1.31049855e-02f, 2.06302609e-02f, -2.33536530e-02f, 5.20795062e-02f, 2.73281280e-02f,
  2.80947890e-02f, -6.34054616e-02f, 7.66517669e-02f, 9.16482508e-02f, 1.35129109e-01f, 4.16843183e-02f, 1.18508404e-02f, 7.66897900e-03f, 4.97100614e-02f, 2.03521311e-01f,
  -2.25144103e-01f, 1.37330309e-01f, -1.89273104e-01f, -2.67443676e-02f, 5.08593544e-02f, 1.24782942e-01f, 1.01884052e-01f, 1.23122051e-01f, 1.82106793e-01f, 1.41018510e-01f,
  2.11587682e-01f, 9.23564732e-02f, 1.87015340e-01f, 6.22835197e-02f, -9.23667625e-02f, 7.85088465e-02f, 1.71903092e-02f, -3.45628411e-02f, -5.29272631e-02f, 7.66860470e-02f,
  5.45797311e-02f, -8.22991431e-02f, -2.34129205e-01f, -4.21654098e-02f, -2.04328960e-03f, -1.42374232e-01f, -1.06265850e-01f, -2.70794574e-02f, 3.33725661e-02f, -3.50095145e-02f,
  1.05334759e-01f, -7.32252449e-02f, 1.15586430e-01f, 2.62588054e-01f, 1.93008095e-01f, 3.35125506e-01f, 2.69354761e-01f, 2.57600158e-01f, 1.97248816e-01f, 1.43190593e-01f,
  6.50775582e-02f, 7.53063485e-02f, 8.47102478e-02f, -2.14131158e-02f, 3.14789042e-02f, 3.62756513e-02f, 1.40341207e-01f, 9.04730931e-02f, 1.02419958e-01f, 1.32975608e-01f,
  1.00451834e-01f, 2.80052628e-02f, 3.54891941e-02f, 1.13252416e-01f, -5.82321249e-02f, 1.56544417e-01f, 1.62517622e-01f, -2.66085640e-02f, 1.34499013e-01f, -5.72737306e-02f,
  -2.15226293e-01f, 9.37520862e-02f, -1.55253811e-02f, -3.84500884e-02f, -1.22662276e-01f, -1.12998068e-01f, -5.01615256e-02f, -5.92730977e-02f, 1.25651285e-02f, 4.05459143e-02f,
  -9.24019068e-02f, -2.00832188e-02f, -6.15761541e-02f, -2.24856194e-02f, -5.43148257e-02f, -2.09690630e-02f, -4.18453999e-02f, 7.22900778e-02f, 7.75372386e-02f, -2.94451360e-02f,
  -7.35774338e-02f, 7.99347907e-02f, 9.16624367e-02f, 7.79769272e-02f, -9.48421843e-03f, 7.94395953e-02f, 5.97612523e-02f, -6.81187734e-02f, 2.30897646e-02f, 3.74724753e-02f,
  -8.83892644e-03f, 1.31079298e-03f, -2.64691804e-02f, -1.34188461e-03f, 2.41894964e-02f, 5.20723425e-02f, -4.80995029e-02f, -3.59124318e-02f, 9.96523649e-02f, -5.75447083e-02f,
  3.91929634e-02f, 8.92649740e-02f, 2.67191371e-03f, 3.85042280e-02f, 8.86058994e-03f, 2.10386515e-02f, 1.32578509e-02f, -1.02907062e-01f, 5.08722439e-02f, 3.09812725e-02f,
  1.94712773e-01f, 9.84691158e-02f, -1.97938178e-03f, 1.03655001e-02f, 3.30254361e-02f, 6.96548149e-02f, 2.86959372e-02f, 7.16575831e-02f, 9.95551571e-02f, 6.63695997e-03f,
  -1.92709893e-01f, 1.85261548e-01f, 7.69326240e-02f, -9.17839259e-03f, -1.51663944e-01f, -1.32771984e-01f, -1.82066355e-02f, -2.37580147e-02f, -1.40432209e-01f, -3.97421829e-02f,
  -4.84411009e-02f, 3.95084657e-02f, -1.03174686e-01f, 2.43913103e-02f, 2.77785864e-02f, 1.64329689e-02f, -1.29240066e-01f, 1.01160496e-01f, 3.09903529e-02f, -3.58144119e-02f,
  -4.75199558e-02f, 7.21300989e-02f, 1.28146820e-02f, 1.97684057e-02f, 5.33315763e-02f, 1.66400764e-02f, -9.47748274e-02f, 4.10583504e-02f, 1.06879152e-01f, -9.61945206e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.54521757e-01f, 4.53359671e-02f, 1.17856272e-01f, 1.56255469e-01f, 1.30991518e-01f, 4.43000406e-01f, 1.70292825e-01f, 2.85117067e-02f, 2.56722122e-01f, 1.61889538e-01f,
  1.48623824e-01f, 4.43826579e-02f, 2.91728735e-01f, 8.13398361e-02f, 2.21868698e-02f, -1.87393680e-01f, 1.49254844e-01f, 4.09713089e-02f, -5.84624819e-02f, 3.34136873e-01f,
  8.13563541e-02f, 1.95949435e-01f, 1.15813121e-01f, 1.60255264e-02f, 2.55807519e-01f, 2.20980570e-01f, 4.36710238e-01f, -2.18454842e-02f, 2.73018360e-01f, 2.34024316e-01f,
  1.78182527e-01f, 1.08899519e-01f, 1.04732746e-02f, 3.25403780e-01f, 4.63713780e-02f, 1.66571856e-01f, 9.84519795e-02f, 1.43115306e-02f, 2.08003178e-01f, 2.27782652e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.24490706e-02f, 2.81878542e-02f, 4.43260930e-02f, -2.99075283e-02f, -1.59372855e-02f, 7.49837980e-02f, -5.99306114e-02f, 8.75105187e-02f, -1.16390325e-01f, -1.42161369e-01f,
  1.47020593e-01f, -1.45034343e-02f, -4.90696132e-02f, -1.24785602e-01f, -2.76488252e-02f, 1.82447210e-02f, -4.68743630e-02f, 1.21733218e-01f, -6.27940223e-02f, 9.43206027e-02f,
  -4.01493847e-01f, -3.67036946e-02f, -1.92080989e-01f, -7.41416141e-02f, 1.18952572e-01f, 1.28600486e-02f, -6.06825016e-02f, -1.89030655e-02f, 6.64492771e-02f, -1.10452779e-01f,
  -1.02795452e-01f, -6.66047260e-02f, 8.11571032e-02f, -2.05301344e-02f, 2.78720826e-01f, 9.73734558e-02f, 1.13573357e-01f, -1.84664682e-01f, 2.00579353e-02f, 1.04768877e-03f,
  -5.41076101e-02f, -8.54971856e-02f, 3.87643091e-02f, -1.01465791e-01f, 2.35697314e-01f, 9.11475271e-02f, -1.08091570e-01f, -2.62453198e-01f, 5.25032636e-03f, 1.13901861e-01f,
  2.67195761e-01f, -9.69284996e-02f, 2.52730340e-01f, 2.32450888e-01f, -1.92681655e-01f, -2.67049044e-01f, 1.45382611e-02f, 2.21101373e-01f, -9.18737501e-02f, -3.11151713e-01f,
  -2.98245642e-02f, -1.85097203e-01f, 1.15407750e-01f, -4.11210656e-02f, 2.91416440e-02f, 9.02534425e-02f, -9.92888361e-02f, 6.10385202e-02f, -4.36471961e-02f, -2.18274519e-02f,
  -9.70611721e-02f, 3.04333288e-02f, -4.16037776e-02f, -1.60667896e-01f, -7.86328763e-02f, 7.67756952e-03f, 1.06045946e-01f, 1.37120143e-01f, 1.05696209e-01f, 1.42483249e-01f,
  1.03205875e-01f, -1.82747290e-01f, 5.85771576e-02f, 9.72891375e-02f, -4.67918217e-02f, -5.12445718e-02f, -6.09333664e-02f, 1.24419527e-02f, 1.57951459e-01f, -6.02093413e-02f,
  1.31904125e-01f, 6.99171796e-02f, -4.07133363e-02f, -3.39926541e-01f, 9.47834998e-02f, -8.78886506e-02f, -9.67938453e-03f, -8.99786204e-02f, 1.64851874e-01f, 6.43345937e-02f,
  -3.04892194e-02f, -3.13888267e-02f, 1.53147290e-02f, -1.03724085e-01f, 7.37547353e-02f, -2.68991571e-02f, -1.30890275e-03f, -2.38994807e-01f, 1.66758060e-01f, 1.12247594e-01f,
  -1.04266375e-01f, -2.92940103e-02f, 1.56841089e-03f, -3.03415442e-03f, 6.61011562e-02f, -7.08658099e-02f, 6.79414794e-02f, -1.01581030e-01f, -1.05440080e-01f, -3.01551670e-01f,
  7.86142275e-02f, 3.77383232e-01f, 2.98757441e-02f, -1.62113950e-01f, 5.80730550e-02f, -1.52427912e-01f, -1.00928813e-01f, -7.55468011e-02f, -4.35836203e-02f, -3.95251364e-02f,
  1.22913402e-02f, -1.00806326e-01f, -7.35976547e-02f, -4.38720919e-02f, -1.38956457e-01f, -1.11870006e-01f, 8.31918046e-02f, -9.79766250e-02f, 2.51246262e-02f, -6.20915890e-02f,
  -1.34305775e-01f, -1.65068030e-01f, -9.33702216e-02f, -1.26726450e-02f, 1.15615107e-01f, 7.87217543e-02f, -3.51566561e-02f, -1.49769455e-01f, 5.26361614e-02f, -1.69199944e-01f,
  -4.30028662e-02f, -2.40432397e-01f, -3.83728117e-01f, 1.06867813e-01f, 1.28100580e-02f, 7.35187978e-02f, 5.25507964e-02f, 4.53334838e-01f, 1.97369784e-01f, 1.20318569e-01f,
  1.19433343e-01f, -1.23057939e-01f, -8.50550383e-02f, -1.05481111e-01f, -5.49376346e-02f, -9.45881009e-03f, -1.01532288e-01f, -5.88491000e-02f, -2.09562387e-02f, -1.16338022e-01f,
  1.62903685e-02f, 4.87486869e-01f, 2.61588562e-02f, 3.05724852e-02f, 5.66683896e-03f, 1.30522624e-01f, 2.71964580e-01f, -2.07383499e-01f, 3.63440402e-02f, 9.68648493e-02f,
  -1.79666907e-01f, -1.74687430e-03f, -3.08976144e-01f, -7.08807707e-02f, -2.88339525e-01f, -2.41791010e-01f, 4.36425693e-02f, 8.86543319e-02f, -3.39456238e-02f, 3.55818085e-02f,
  -3.09624434e-01f, 1.27329886e-01f, 1.04773909e-01f, 6.90308586e-02f, 1.04679480e-01f, 2.05344900e-01f, 1.07635438e-01f, 6.43721502e-03f, 2.14678869e-01f, 6.27052039e-02f,
  1.77561808e-02f, -5.87879643e-02f, -7.96108786e-03f, -2.45804228e-02f, 3.64323668e-02f, 6.83865324e-02f, 1.68844104e-01f, -1.61253065e-02f, -5.59018925e-02f, -5.19441180e-02f,
  5.22164686e-04f, 2.00365737e-01f, -2.35726852e-02f, 9.25210342e-02f, 7.74849877e-02f, 1.55239359e-01f, 2.54560113e-01f, 1.45418849e-02f, 1.97058305e-01f, 1.57436486e-02f,
  -1.04957908e-01f, -1.71841174e-01f, -1.81177929e-01f, 2.77422834e-02f, -1.66652694e-01f, -3.39239351e-02f, -6.22720271e-03f, 6.10441901e-02f, 9.59575027e-02f, -1.28022000e-01f,
  4.30896133e-02f, -1.38436988e-01f, -6.97976127e-02f, -1.43397704e-01f, 1.12709858e-01f, -7.12541118e-02f, 6.36530519e-02f, -6.64504468e-02f, -8.21638573e-03f, -5.83957247e-02f,
  -1.73609704e-01f, 1.22787409e-01f, 7.45049119e-02f, -2.25100964e-01f, -3.82209830e-02f, 3.40934806e-02f, 1.80769950e-01f, 1.85549572e-01f, 2.69534767e-01f, 2.85369068e-01f,
  1.29047617e-01f, -2.11856052e-01f, -9.52318385e-02f, 1.00032412e-01f, 2.16490731e-01f, -1.64551120e-02f, 1.12548955e-01f, -1.31099477e-01f, -1.84196644e-02f, 3.52350362e-02f,
  -2.64019538e-02f, -2.67695874e-01f, 5.00205792e-02f, -6.42075613e-02f, 1.22421935e-01f, 4.74545290e-04f, -3.57437134e-02f, 5.04479967e-02f, 1.14721805e-01f, -1.43980198e-02f,
  -4.48188297e-02f, 3.10844868e-01f, -5.02084643e-02f, -2.72722811e-01f, 3.15308981e-02f, -3.23334821e-02f, 9.19461176e-02f, -9.29485261e-02f, -9.49152634e-02f, 2.48549110e-03f,
  9.74697843e-02f, -5.51555529e-02f, 2.84066141e-01f, 1.85412750e-01f, 2.70385176e-01f, -8.55899304e-02f, 2.17480808e-02f, 9.99858007e-02f, 1.31996289e-01f, -2.47458637e-01f,
  1.07870467e-01f, 2.48774849e-02f, -1.70047775e-01f, 1.22709729e-01f, -1.38934642e-01f, 1.76434249e-01f, 1.72379598e-01f, -9.54609457e-03f, -1.99908130e-02f, 8.63908678e-02f,
  -2.36699358e-01f, -2.07785405e-02f, -4.66365777e-02f, -2.22199094e-02f, -1.55340463e-01f, -8.87130052e-02f, -3.72152179e-01f, 1.67644486e-01f, 1.89701825e-01f, -3.09004724e-01f,
  2.64766924e-02f, -2.42728129e-01f, 3.33910957e-02f, -7.12843910e-02f, 1.23091079e-01f, 1.17832348e-01f, 2.16958478e-01f, 1.95962131e-01f, -2.69879494e-03f, -1.20603897e-01f,
  -7.68032148e-02f, -1.01069979e-01f, 4.00419794e-02f, -2.47494616e-02f, -6.37279823e-02f, -8.54193494e-02f, 1.02224343e-01f, -7.10606277e-02f, 1.39654636e-01f, -8.42770860e-02f,
  6.63147867e-02f, -6.24871477e-02f, 4.63461503e-02f, 4.44828756e-02f, -1.92813516e-01f, 8.93753693e-02f, 1.31247252e-01f, -1.73626333e-01f, 9.61739663e-03f, -1.01785868e-01f,
  1.07469670e-01f, -3.18229198e-02f, 5.77929392e-02f, -2.33957842e-02f, 4.59833592e-02f, -4.70415615e-02f, -2.02584527e-02f, -1.05941162e-01f, -2.84931641e-02f, -3.07251774e-02f,
  -5.72670437e-02f, 5.13670817e-02f, 1.30975619e-01f, 7.25022238e-03f, -2.47844681e-01f, -1.37536660e-01f, -2.07578138e-01f, 1.37271047e-01f, -8.64505321e-02f, 5.86286113e-02f,
  1.47389457e-01f, 9.41900685e-02f, 7.43749961e-02f, -2.54433993e-02f, -1.10722825e-01f, -1.45981282e-01f, 5.10591716e-02f, 1.70604452e-01f, -5.29670045e-02f, -1.99815542e-01f,
  -1.35806218e-01f, 2.16614440e-01f, -1.75957888e-01f, -6.28103539e-02f, 1.25312537e-01f, 1.64617836e-01f, -2.41540432e-01f, -4.49231923e-01f, 9.46931392e-02f, 2.15746194e-01f,
  -4.26369496e-02f, -5.49387597e-02f, 6.28878549e-02f, 7.98453167e-02f, 1.40086904e-01f, 1.31542206e-01f, 2.11521134e-01f, 9.98759195e-02f, 1.33917913e-01f, 1.28991872e-01f,
  3.55293788e-02f, 9.03876945e-02f, 3.78777713e-01f, 1.06084317e-01f, 5.46555482e-02f, 2.25542456e-01f, -9.06088874e-02f, 1.26554728e-01f, 3.66362035e-02f, -7.98313394e-02f,
  -3.33428644e-02f, 5.86783253e-02f, -9.10131484e-02f, 6.32370710e-02f, 3.40556324e-01f, 3.32540795e-02f, 1.55624866e-01f, -6.09976314e-02f, -1.80795230e-03f, 2.27814540e-01f,
  -4.07407545e-02f, 9.37547311e-02f, -2.05761399e-02f, 1.57507747e-01f, 1.92674354e-01f, -3.73556577e-02f, 2.17886552e-01f, -5.62145077e-02f, -6.95157200e-02f, 2.83539910e-02f,
  -1.33389845e-01f, -7.85186291e-02f, 6.53252006e-03f, -8.22555050e-02f, 1.06970258e-01f, -7.77729228e-02f, -1.24405622e-01f, 3.59248936e-01f, -7.50544742e-02f, 1.89846799e-01f,
  -6.94952607e-02f, -2.31935799e-01f, 1.26954868e-01f, 2.14016795e-01f, -2.53674954e-01f, 8.86800513e-02f, -1.88138291e-01f, 1.19476475e-01f, -4.35318053e-02f, 1.28035486e-01f,
  5.60279116e-02f, 1.05877884e-01f, -2.90715452e-02f, 4.74194363e-02f, -7.08473027e-02f, 4.94782403e-02f, 4.58096676e-02f, 1.07011311e-02f, -4.54884581e-02f, -1.54579291e-02f,
  -2.20065475e-01f, -9.03092034e-04f, -1.66540876e-01f, 8.15355554e-02f, -1.00243583e-01f, -1.31010786e-01f, 5.81869446e-02f, 4.43187356e-02f, -4.02568169e-02f, 3.19373198e-02f,
  -1.66067183e-01f, -1.00887902e-01f, -7.46782646e-02f, -7.00124772e-03f, 1.30339056e-01f, 2.46893186e-02f, -1.42330432e-03f, -1.27791941e-01f, 1.05122909e-01f, -2.30664685e-02f,
  -6.06548451e-02f, 2.09048409e-02f, -3.22947241e-02f, 5.51130921e-02f, -2.11778045e-01f, 1.07850105e-01f, 5.41336648e-02f, 1.62488237e-01f, 9.68761519e-02f, -1.91580802e-02f,
  1.69943199e-01f, 2.74051279e-02f, -2.80076303e-02f, -2.05943435e-01f, 5.35852425e-02f, 1.34252638e-01f, -5.17996401e-03f, -1.74622491e-01f, 1.45565167e-01f, 4.16362099e-02f,
  -1.07633568e-01f, 1.98733628e-01f, -1.85556814e-01f, 2.18843341e-01f, -7.60292984e-04f, -1.52242975e-02f, -1.41671181e-01f, -5.02398387e-02f, -1.86005220e-01f, 1.21653415e-01f,
  -1.86384812e-01f, 5.41146770e-02f, -1.88378468e-01f, -2.24273875e-02f, -5.47067448e-02f, -2.38883510e-01f, -8.42007250e-02f, 7.39715844e-02f, 5.88124692e-02f, -1.99987456e-01f,
  -2.13743486e-02f, 1.21933229e-01f, 5.84366694e-02f, 5.52589931e-02f, 1.37550920e-01f, -1.51374876e-01f, 1.22417152e-01f, -1.23683006e-01f, 9.62768048e-02f, 3.15921679e-02f,
  1.98415279e-01f, 1.44538313e-01f, -8.28482434e-02f, 1.28481284e-01f, -6.77527711e-02f, 1.73739880e-01f, 3.28969844e-02f, 1.94753617e-01f, -1.52774602e-01f, -8.75126123e-02f,
  -1.37709482e-02f, -8.97016525e-02f, 8.26413110e-02f, -1.89196505e-02f, -5.21912389e-02f, -8.14089328e-02f, -1.62488773e-01f, -1.95335940e-01f, 1.32742882e-01f, 9.03469250e-02f,
  -9.95491222e-02f, 2.16085583e-01f, 7.23345801e-02f, -3.34763117e-02f, -9.53686833e-02f, 1.34608969e-01f, -1.46396458e-01f, -2.48531364e-02f, -1.08752906e-01f, -2.47690640e-02f,
  -2.22118888e-02f, 1.08881861e-01f, 7.76371136e-02f, 1.81731991e-02f, 3.79695706e-02f, 1.63524806e-01f, -1.81351751e-01f, -1.72862813e-01f, 7.53603354e-02f, 1.27593279e-01f,
  -1.91487476e-01f, -1.86755553e-01f, -1.65640593e-01f, 3.26815657e-02f, -7.85015970e-02f, -1.29735842e-01f, 8.25585276e-02f, 3.89889359e-01f, -5.48382029e-02f, -2.47197643e-01f,
  3.49412067e-03f, 4.36884344e-01f, 1.21155702e-01f, 1.92488015e-01f, -1.45461923e-02f, 1.04691334e-01f, -1.26581490e-01f, -5.06012440e-02f, 1.05269656e-01f, -1.21603133e-02f,
  4.24436852e-02f, 3.63970511e-02f, -5.01504168e-02f, 9.38085914e-02f, -6.19766600e-02f, 2.21439060e-02f, 1.42604792e-02f, -1.10248430e-02f, 1.90241802e-02f, -1.07750773e-01f,
  4.40436900e-02f, -2.30317071e-01f, -1.71387032e-01f, 1.11323081e-01f, -1.25580117e-01f, -2.97186561e-02f, -9.85604078e-02f, 2.76789628e-02f, -3.53165157e-02f, -1.77342206e-01f,
  -2.84715388e-02f, -9.01522562e-02f, -1.53181717e-01f, -1.25979125e-01f, -1.81780994e-01f, 2.00752914e-01f, 1.60021801e-02f, 1.00155219e-01f, 2.84702837e-01f, 6.74890801e-02f,
  2.36992121e-01f, 5.00715747e-02f, -5.37074655e-02f, 6.38507679e-02f, 1.51482046e-01f, -1.36716347e-02f, -2.15086609e-01f, 6.42406382e-03f, -1.80482827e-02f, 9.28477868e-02f,
  3.51907276e-02f, -6.97677881e-02f, -1.31411612e-01f, -1.11646727e-01f, 2.51250118e-01f, -8.06290656e-02f, 9.87928659e-02f, 5.66654317e-02f, 1.88828573e-01f, 1.44708827e-01f,
  -1.60643518e-01f, -2.48512685e-01f, -5.21217771e-02f, 1.41859084e-01f, -7.94517249e-02f, -4.07775074e-01f, -8.10202733e-02f, -1.53700978e-01f, -8.46833363e-02f, 2.98043322e-02f,
  2.90795714e-02f, 1.63231008e-02f, 1.58520803e-01f, -1.72587316e-02f, 8.52135271e-02f, 5.67585938e-02f, -1.53794214e-01f, -8.67982954e-02f, 5.77862598e-02f, 1.52025670e-01f,
  3.74698862e-02f, -9.67759639e-02f, -1.80372462e-01f, 3.85433156e-03f, -9.38869342e-02f, 5.35138622e-02f, 8.11220407e-02f, 1.20268635e-01f, -1.04344897e-01f, -6.04273789e-02f,
  2.20944569e-01f, 1.16458111e-01f, 8.33135396e-02f, 1.66028634e-01f, -7.86970090e-03f, 1.92286894e-02f, -4.62797098e-02f, -1.08745620e-02f, -2.59676799e-02f, 3.92387137e-02f,
  1.28786024e-02f, -3.41429301e-02f, 2.92089302e-02f, 7.10232705e-02f, -2.12613359e-01f, -6.91449791e-02f, -1.94108707e-03f, 1.81933373e-01f, 2.63662599e-02f, 6.32754192e-02f,
  1.42738476e-01f, -8.78901109e-02f, 4.24446501e-02f, 1.07815623e-01f, 3.81731167e-02f, 1.44136310e-01f, 1.65012702e-01f, 2.43618727e-01f, -1.66667521e-01f, -6.25224486e-02f,
  -9.17042494e-02f, 1.91466793e-01f, -3.62233251e-01f, 5.80453724e-02f, -1.17349729e-01f, -1.47400899e-02f, -5.94453141e-02f, -8.52153599e-02f, 8.20557252e-02f, 1.92647710e-01f,
  4.01080437e-02f, -8.82034376e-02f, -1.89714313e-01f, 1.39723301e-01f, 1.15800239e-02f, 1.38667390e-01f, 6.59300238e-02f, -7.97573291e-03f, 9.77060758e-03f, 3.29621546e-02f,
  2.80296784e-02f, 1.50641818e-02f, -4.00817813e-03f, -3.92682329e-02f, 1.58719718e-02f, -9.88468379e-02f, -2.64602862e-02f, 2.13950932e-01f, 1.17946714e-01f, 1.24992959e-01f,
  1.84880234e-02f, -3.21374238e-02f, 2.35888269e-02f, 1.48250097e-02f, -2.73033772e-02f, 1.23396683e-02f, -9.77278687e-03f, 1.32005200e-01f, -5.01419753e-02f, 1.64218694e-01f,
  1.42089948e-01f, 2.08088100e-01f, 6.60061240e-02f, -3.19971114e-01f, 1.41272889e-02f, -6.17393628e-02f, -2.30490118e-01f, -1.48862034e-01f, -1.35823190e-01f, 9.95997041e-02f,
  -2.49422789e-02f, -1.51472509e-01f, 1.77264974e-01f, -5.12925051e-02f, 1.67155545e-03f, -1.12644367e-01f, 2.04492852e-01f, 5.58386259e-02f, 1.75094128e-01f, 5.05784936e-02f,
  3.61471996e-02f, 9.02943239e-02f, -2.23144308e-01f, 1.00494638e-01f, -1.54249087e-01f, 1.64090395e-02f, -1.40409410e-01f, -1.69445187e-01f, 1.57782316e-01f, 2.86352456e-01f,
  1.49346311e-02f, 1.34976864e-01f, 2.39805713e-01f, 3.56428593e-01f, 8.71108994e-02f, 1.26064971e-01f, 7.54635558e-02f, 9.84357297e-03f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.85946508e-03f, -1.85163412e-02f, 1.60884365e-01f, -5.96193969e-02f, 1.44062946e-02f, 3.75443487e-03f, -4.08054516e-02f, 2.20924765e-01f, 2.40074262e-01f, 2.16016069e-01f,
  -5.04925326e-02f, 1.06562160e-01f, -2.36626118e-01f, -5.49404323e-02f, -1.66248560e-01f, -7.64186904e-02f, 1.09909318e-01f, 2.87193984e-01f, 4.39794082e-03f, -1.34406574e-02f,
  4.23751846e-02f, 2.90272325e-01f, 3.39526795e-02f, -1.62128046e-01f, -1.07114889e-01f, 2.42024168e-01f, 6.71676621e-02f, -6.31039515e-02f, 3.00642271e-02f, 2.42124051e-01f,
  1.40191004e-01f, 6.55960441e-02f, 3.71713042e-02f, -1.17199663e-02f, -1.47237688e-01f, -1.22783370e-01f, 5.94667979e-02f, 6.96139932e-02f, 2.03394275e-02f, -1.64838001e-01f,
  -7.06111640e-02f, 6.08092844e-02f, -1.38506293e-01f, 2.65081018e-01f, 2.33786598e-01f, 8.87916237e-03f, 2.09151477e-01f, -7.52151385e-03f, 2.37505898e-01f, 1.99028358e-01f,
  1.81417093e-01f, 9.28286165e-02f, -2.81637460e-01f, 1.67724892e-01f, 1.32415429e-01f, 2.70398080e-01f, 1.49232708e-02f, -1.40295729e-01f, 8.05123672e-02f, -7.10999891e-02f,
  1.00517295e-01f, 1.37984738e-01f, -2.41167117e-02f, 1.58096060e-01f, 8.64742026e-02f, 2.62125224e-01f, 1.14707202e-01f, -7.22241402e-03f, 1.35554761e-01f, 1.76327407e-01f,
  2.98598856e-02f, -6.13467162e-03f, -1.64283931e-01f, 6.49598464e-02f, 2.02988103e-01f, -3.45248193e-03f, 2.53881752e-01f, 1.52530715e-01f, -1.64756596e-01f, -1.42127112e-01f,
  -3.92172128e-01f, -3.59764546e-01f, -1.25731081e-02f, -5.30093610e-02f, -6.29607704e-04f, -4.40685809e-01f, -8.96448418e-02f, 4.38782685e-02f, -1.10708289e-01f, 9.26514342e-02f,
  1.79026291e-01f, -5.37628643e-02f, 2.08099008e-01f, 1.43169001e-01f, 9.52849314e-02f, -2.14504033e-01f, 3.66507322e-01f, -9.75232795e-02f, 5.08182347e-01f, 3.00658256e-01f,
  -1.23752773e-01f, 8.94550756e-02f, 2.40318447e-01f, -1.55028597e-01f, -3.74773778e-02f, -9.55119431e-02f, 1.12341546e-01f, 1.66350275e-01f, -1.77186757e-01f, 8.77077505e-02f,
  -3.54445457e-01f, 3.30893099e-02f, -6.95464686e-02f, -2.53770351e-01f, 2.77814325e-02f, -2.05492619e-02f, 1.69748411e-01f, 3.02946679e-02f, -8.23127478e-02f, -2.60170519e-01f,
  1.67175397e-01f, -1.97627712e-02f, 1.89228728e-01f, 3.86662669e-02f, 9.96359885e-02f, 1.28917754e-01f, 1.35581762e-01f, 5.89361973e-02f, 2.61092544e-01f, -1.07391048e-02f,
  1.10635579e-01f, 2.14505374e-01f, 1.18739098e-01f, 1.83030650e-01f, 1.27976313e-01f, 2.67646402e-01f, 1.17311925e-01f, 2.50700146e-01f, 1.94798052e-01f, 1.00176185e-01f,
  -9.47182477e-02f, 3.14784288e-01f, -1.45523295e-01f, 2.81517297e-01f, 2.03936379e-02f, -2.34996051e-01f, -1.22256152e-01f, -2.26520792e-01f, 1.55112326e-01f, 8.48531649e-02f,
  -7.37754777e-02f, -4.10453789e-03f, -5.54894619e-02f, 8.41173679e-02f, 1.71507493e-01f, 4.53004092e-02f, 2.87597686e-01f, 7.96418861e-02f, 9.37348083e-02f, -1.00291213e-02f,
  1.77464634e-01f, -1.03937173e-02f, 1.03519969e-01f, 2.16296211e-01f, -1.28709292e-02f, -2.54900213e-02f, 1.24753080e-02f, -1.70298174e-01f, 2.54056543e-01f, -1.65374056e-01f,
  2.95485277e-02f, 6.94329068e-02f, -2.13621780e-01f, 1.85613349e-01f, 1.03946745e-01f, 2.97790647e-01f, -1.64080113e-01f, -3.78490761e-02f, -1.01977237e-01f, 2.42751956e-01f,
  -1.07114367e-01f, -2.31654555e-01f, 5.77638410e-02f, 3.16639006e-01f, 6.61696717e-02f, -1.56148642e-01f, 2.51612812e-01f, 5.47168672e-01f, 3.18695247e-01f, 2.87867159e-01f,
  -1.01415686e-01f, 3.50862816e-02f, 1.20999351e-01f, -1.40159458e-01f, 3.38044725e-02f, -5.38377501e-02f, 1.84126109e-01f, -3.18521746e-02f, -2.18544248e-02f, 1.88858453e-02f,
  1.92613587e-01f, 2.40397304e-01f, -4.36780825e-02f, 1.50013611e-01f, -5.65298460e-02f, 1.84175700e-01f, 2.57448286e-01f, -1.67260468e-01f, -1.79302379e-01f, -1.42455116e-01f,
  -1.62661001e-01f, 8.19813758e-02f, 3.79538313e-02f, 1.81332543e-01f, 1.19754933e-01f, 1.16421524e-02f, 2.23360375e-01f, -1.13988675e-01f, 5.76773696e-02f, 1.14222638e-01f,
  -1.85539693e-01f, -4.36805598e-02f, 5.89366965e-02f, -8.45642835e-02f, -1.20558567e-01f, 2.46518582e-01f, -1.23327099e-01f, 1.29429977e-02f, 2.09798649e-01f, -7.08021149e-02f,
  4.76720184e-02f, -2.91620120e-02f, -1.10327691e-01f, -2.04079170e-02f, 1.76606819e-01f, -6.81524798e-02f, -1.85039535e-01f, 8.08691978e-02f, -5.80606796e-02f, -2.68469821e-03f,
  -2.21282244e-01f, -7.59869367e-02f, 9.38133150e-02f, -1.47132888e-01f, 7.60465488e-02f, 2.06417546e-01f, 2.07521141e-01f, 1.31716207e-01f, 7.61836916e-02f, 9.68231782e-02f,
  2.00277507e-01f, 1.33185610e-01f, 6.69722855e-02f, 1.96257323e-01f, 3.87237787e-01f, 1.10263675e-01f, 1.46586612e-01f, -7.36329379e-03f, 2.16057837e-01f, 9.91284754e-03f,
  9.65224430e-02f, 2.55372822e-01f, 8.20007026e-02f, 5.93142724e-03f, 2.20074266e-01f, 1.13166958e-01f, 2.11289838e-01f, 2.48948991e-01f, 1.30808592e-01f, 2.29759626e-02f,
  -4.12212461e-02f, -1.47369519e-01f, -3.24276447e-01f, -1.67637765e-01f, 3.33794244e-02f, 2.40122899e-01f, 3.23531800e-03f, -1.16452582e-01f, -1.61207281e-02f, 1.19655713e-01f,
  7.57845268e-02f, -1.00682095e-01f, 3.06752950e-01f, -1.77727208e-01f, 2.58911196e-02f, 3.02134097e-01f, -3.85763682e-02f, -6.01872317e-02f, 6.32419139e-02f, 1.46482989e-01f,
  2.00436294e-01f, 1.86447218e-01f, 1.90042332e-01f, 2.97490824e-02f, 5.30614294e-02f, -1.90600052e-01f, 7.08552301e-02f, 1.78756956e-02f, 1.85291786e-02f, 1.21873897e-02f,
  5.52352220e-02f, -2.34420568e-01f, -1.84727997e-01f, -1.31297663e-01f, 1.20506950e-01f, 1.46317631e-01f, 2.31907547e-01f, -9.77266356e-02f, 2.64637858e-01f, 3.70286733e-01f,
  -8.93370360e-02f, -1.50995508e-01f, 1.76245272e-02f, -5.69818281e-02f, 1.71580657e-01f, -2.21832693e-01f, -1.27322108e-01f, -1.10148154e-02f, 3.74501467e-01f, 6.45190850e-02f,
  7.85601065e-02f, -4.47686426e-02f, 2.02247590e-01f, 2.30576470e-01f, 2.87210852e-01f, 1.01220548e-01f, 3.15229185e-02f, -3.63249378e-03f, -7.34698623e-02f, 1.50795788e-01f,
  2.33854085e-01f, 9.24694389e-02f, -8.26561153e-02f, 2.97968715e-01f, 1.89127475e-01f, 1.01195753e-01f, 2.58507822e-02f, -6.22249544e-02f, -2.93968730e-02f, -4.72061802e-03f,
  -3.43243629e-02f, 4.60620970e-02f, -7.87417293e-02f, -4.06303443e-02f, 2.18527541e-01f, -9.38384756e-02f, 2.69280285e-01f, -3.27813625e-03f, -3.62829305e-02f, -3.18636447e-01f,
  3.63520384e-02f, -2.02269956e-01f, -2.32269481e-01f, 6.41944781e-02f, -1.21355675e-01f, 1.06060542e-01f, 1.52851105e-01f, 6.94397558e-03f, 2.79127210e-01f, 4.96379426e-03f,
  3.78473885e-02f, -9.60632190e-02f, 5.47905639e-02f, -2.02544108e-01f, -5.58234639e-02f, 4.60099764e-02f, 2.14967988e-02f, 1.39287114e-01f, -4.44348723e-01f, 2.21716315e-01f,
  -1.40320003e-01f, -1.25977665e-01f, -1.69764742e-01f, -1.86890408e-01f, 3.19219530e-01f, 2.77265996e-01f, 3.71367007e-01f, 5.09593971e-02f, 3.17230344e-01f, 1.64569229e-01f,
  1.32737115e-01f, 5.55235445e-02f, 1.49400994e-01f, -1.22832447e-01f, -2.96138115e-02f, 2.16870904e-01f, 1.63701922e-01f, 1.95164233e-01f, 3.12859774e-01f, 8.09823275e-02f,
  2.07797941e-02f, 2.12045997e-01f, -1.87775299e-01f, 1.19449787e-01f, 2.18285605e-01f, 6.37805015e-02f, -1.90476358e-01f, -3.43279503e-02f, 3.59147787e-01f, 2.60344110e-02f,
  -1.65586188e-01f, 8.86430293e-02f, -2.51902699e-01f, 1.75353900e-01f, -9.37267691e-02f, -5.55533394e-02f, 4.73052189e-02f, 1.88621894e-01f, 1.32801816e-01f, -1.85883604e-02f,
  -5.44832647e-03f, 3.86636227e-01f, -1.29424259e-01f, -1.40208855e-01f, 1.76561639e-01f, -9.28443223e-02f, 3.74199450e-02f, -2.87940335e-02f, 1.13060713e-01f, 1.93347111e-02f,
  1.32190973e-01f, -1.63232926e-02f, 2.27459893e-01f, -5.17641008e-02f, 1.37350876e-02f, -2.10661784e-01f, -1.31297097e-01f, 8.40200484e-03f, -3.05164978e-02f, 2.61267513e-01f,
  -1.03523910e-01f, -2.29804188e-01f, -1.87782302e-01f, 1.30229652e-01f, -3.14155132e-01f, -1.05050758e-01f, 2.63491631e-01f, 2.29123816e-01f, -2.23238096e-01f, 1.52051404e-01f,
  2.66990781e-01f, 4.33379233e-01f, -6.58342093e-02f, -9.04915705e-02f, -5.13902307e-03f, -1.77045971e-01f, 3.31814498e-01f, 3.89888175e-02f, 8.04486498e-03f, 9.30398554e-02f,
  1.28556946e-02f, 2.52633495e-03f, 9.58925709e-02f, 5.19560538e-02f, -1.11579701e-01f, 5.02953865e-02f, 1.04333386e-01f, 1.22498587e-01f, 1.44236967e-01f, -3.58571820e-02f,
  1.60833851e-01f, -1.16332404e-01f, -1.99470613e-02f, -1.34686723e-01f, -2.23694786e-01f, -2.56124258e-01f, 1.65192839e-02f, 1.26622766e-01f, 1.04738280e-01f, 1.28141478e-01f,
  1.08700790e-01f, 7.00734407e-02f, 7.89045095e-02f, 1.62085623e-01f, 2.97690295e-02f, 1.13340408e-01f, -5.27475141e-02f, 2.15827361e-01f, -1.65925965e-01f, 1.35971401e-02f,
  -3.20122130e-02f, 2.28456706e-01f, -6.74740672e-02f, -1.46712735e-01f, 1.37297451e-01f, 1.58703104e-01f, -5.08621009e-03f, -1.71522468e-01f, -1.67976141e-01f, 1.25735119e-01f,
  8.85018334e-02f, 1.80702522e-01f, 1.35391027e-01f, -2.71032453e-01f, 8.25838372e-02f, -3.16144191e-02f, -1.19994968e-01f, -1.80127949e-01f, 8.09438899e-02f, -1.07678697e-01f,
  5.69333918e-02f, 2.13203445e-01f, -1.77435428e-01f, -8.06183144e-02f, -1.16554044e-01f, 5.77448076e-03f, -1.03124484e-01f, 1.68589074e-02f, -9.13762003e-02f, 5.06940000e-02f,
  2.89433300e-01f, 1.43972874e-01f, -3.06532402e-02f, -2.34148055e-01f, -2.98153497e-02f, 5.17665036e-02f, -9.27065909e-02f, -1.97165951e-01f, -1.21210031e-02f, 3.34830284e-02f,
  9.94269103e-02f, -1.65389359e-01f, -7.29744276e-03f, 1.50257805e-02f, 1.59233101e-02f, 1.51065253e-02f, 3.60176340e-02f, -2.39761636e-01f, -1.79278225e-01f, -1.59405276e-01f,
  5.36331348e-02f, -5.95095716e-02f, 6.63684215e-03f, -9.62829366e-02f, -9.97384340e-02f, 1.42705262e-01f, -1.59519091e-01f, 1.68002680e-01f, -1.32851496e-01f, 1.56508937e-01f,
  -2.71491498e-01f, 1.90418184e-01f, 7.54856393e-02f, -1.17239572e-01f, 1.66805424e-02f, -1.38731986e-01f, 2.25239605e-01f, 8.31850320e-02f, -8.40147734e-02f, -2.26484120e-01f,
  2.53066212e-01f, 1.34924129e-01f, 1.27268657e-01f, 1.18269593e-01f, -9.00784358e-02f, 9.52685475e-02f, -1.12195779e-02f, 1.24338530e-01f, -1.25438333e-01f, 9.98096988e-02f,
  2.12775338e-02f, -2.79742956e-01f, -1.65312830e-02f, -2.02072844e-01f, 5.84737957e-02f, 1.73972636e-01f, -1.72423050e-01f, 2.19969335e-03f, 1.93519276e-02f, 1.42234325e-01f,
  -1.52299270e-01f, -1.19413175e-01f, -2.78083496e-02f, -1.37692407e-01f, 1.55894488e-01f, -7.86495805e-02f, -1.91725194e-02f, -1.07998617e-01f, -1.41716719e-01f, -9.52253118e-03f,
  -5.62612414e-02f, -1.11723533e-02f, 4.93754372e-02f, -1.46878064e-01f, 1.50670528e-01f, -8.69823396e-02f, -2.85046808e-02f, -4.38848995e-02f, -5.81825897e-03f, 3.19910869e-02f,
  -3.48896235e-02f, 6.47587776e-02f, 1.70786679e-02f, -8.79247710e-02f, -6.40248582e-02f, -2.05837116e-01f, -6.68398365e-02f, -1.24858066e-01f, 1.18829094e-01f, 8.77170861e-02f,
  -1.57361418e-01f, 7.08557814e-02f, 7.00042918e-02f, -5.22607267e-02f, 1.56022757e-01f, 1.01648480e-01f, -2.91166399e-02f, 1.78482741e-01f, 2.34687120e-01f, 3.47534344e-02f,
  1.83051169e-01f, 8.11079666e-02f, -3.82428557e-01f, -1.16012627e-02f, -1.64510876e-01f, -7.85969757e-03f, 6.50979131e-02f, -1.69338539e-01f, 8.23368281e-02f, 1.15224630e-01f,
  -1.48126319e-01f, 1.73347518e-01f, 1.47002175e-01f, 1.65241912e-01f, 2.71365553e-01f, -5.96015379e-02f, 1.67009175e-01f, 2.52199918e-02f, -6.65003099e-05f, 7.86317065e-02f,
  -2.05650151e-01f, -7.79583231e-02f, -1.78253621e-01f, -1.72580287e-01f, -5.80130480e-02f, 1.08771317e-01f, 9.38050151e-02f, 1.27636129e-02f, -2.96924353e-01f, -1.12429887e-01f,
  1.40389249e-01f, 1.33286729e-01f, 2.37762734e-01f, -1.07440673e-01f, 1.94094833e-02f, 8.83785859e-02f, 7.74351284e-02f, 3.61310854e-03f, 1.49506345e-01f, 1.96521148e-01f,
  1.06035613e-01f, 2.48947144e-01f, -3.63725028e-03f, 1.81305468e-01f, 9.99011695e-02f, -2.39110589e-01f, -1.36779428e-01f, -2.03118715e-02f, 1.67636514e-01f, 1.34259731e-01f,
  -9.46715996e-02f, 1.81508303e-01f, 8.47653449e-02f, 6.34923875e-02f, 1.55886158e-01f, -1.80732071e-01f, 7.34853595e-02f, -2.45332465e-01f, -3.13619584e-01f, -7.66988322e-02f,
  -5.22388406e-02f, -8.16027671e-02f, -2.63123363e-01f, 2.23881602e-01f, -2.28327885e-01f, 1.71458229e-01f, 1.88966736e-01f, -6.78364187e-02f, 3.91138978e-02f, -1.79070741e-01f,
  3.56405601e-02f, 1.37882277e-01f, 6.18708245e-02f, -1.07929371e-01f, -1.21083148e-02f, -1.88437551e-02f, 3.03647239e-02f, 8.36657882e-02f, 1.23184649e-02f, 2.10049003e-01f,
  1.71911577e-03f, -1.98233962e-01f, 1.14989832e-01f, 1.81616366e-01f, 2.11215645e-01f, 2.58679003e-01f, 1.35523692e-01f, 9.42309722e-02f, 1.58831790e-01f, -1.64263353e-01f,
  -1.20438278e-01f, 1.35517314e-01f, 2.39630193e-01f, 1.81995668e-02f, -1.39190197e-01f, -1.03073809e-02f, 1.84283536e-02f, -4.19132486e-02f, -6.08069338e-02f, 1.17620386e-01f,
  -3.35020050e-02f, -5.60724586e-02f, 3.92424464e-01f, -4.25199941e-02f, 9.16671846e-03f, 2.64494866e-03f, 3.58377434e-02f, -1.11797944e-01f, 1.06632188e-01f, -2.69838959e-01f,
  -1.84882522e-01f, -2.03422084e-01f, 1.52485609e-01f, 2.25203037e-01f, 1.52186111e-01f, -8.88918992e-03f, 1.20052025e-01f, 1.18678734e-01f, 3.02510083e-01f, -2.26207469e-02f,
  -2.78749522e-02f, 2.00906500e-01f, -3.10925040e-02f, 1.33310139e-01f, -2.36166492e-01f, 2.12725606e-02f, -2.64896870e-01f, 2.43059009e-01f, -9.07208174e-02f, -1.48713544e-01f,
  2.06650928e-01f, 3.48984718e-01f, 6.09688647e-02f, -9.14707314e-03f, -1.53991714e-01f, 9.18746963e-02f, -1.26543403e-01f, -1.05956100e-01f, -2.70340014e-02f, -2.26445764e-01f,
  -6.39958978e-02f, -2.56544143e-01f, -1.75392285e-01f, -4.64964658e-02f, 9.54162702e-02f, 7.88584128e-02f, 4.33655316e-03f, 1.49602965e-01f, -1.48890585e-01f, -2.14340270e-01f,
  3.51830311e-02f, -4.91205752e-02f, 1.07136771e-01f, -1.63475320e-01f, -3.50032747e-01f, -1.31915450e-01f, 2.19464675e-01f, 1.87438056e-01f, -6.92633465e-02f, 1.89008787e-01f,
  3.55477147e-02f, 4.62178923e-02f, 7.48910904e-02f, 7.18273446e-02f, 1.59716886e-02f, 7.20139369e-02f, 1.71325654e-01f, -4.78708223e-02f, -3.78634036e-02f, 1.62548628e-02f,
  1.12900279e-01f, 2.07592919e-01f, -9.32774022e-02f, 1.45490803e-02f, 6.48526028e-02f, -1.63425773e-01f, -3.96124311e-02f, 1.22590885e-01f, 1.57251909e-01f, -5.05424701e-02f,
  -1.54968947e-02f, 1.72646284e-01f, -2.86033582e-02f, -4.69818041e-02f, 7.20255747e-02f, 8.28478783e-02f, 1.61067307e-01f, -1.08153857e-01f, 3.32753927e-01f, 1.61354914e-01f,
  3.44383121e-01f, 1.93040501e-02f, 4.38613892e-02f, 1.41361743e-01f, -1.73733890e-01f, 1.34045884e-01f, 8.64261836e-02f, 1.85558610e-02f, 1.27020970e-01f, -9.92437825e-02f,
  2.03017309e-01f, -1.97240487e-01f, -3.52446400e-02f, 1.91928923e-01f, 1.22086421e-01f, 1.60747930e-01f, -1.07638896e-01f, -1.15903684e-04f, 4.97893021e-02f, 2.66369767e-02f,
  -6.83509335e-02f, -1.87183656e-02f, -5.90724237e-02f, -1.35701627e-01f, 1.03490077e-01f, -5.58913797e-02f, 1.26707822e-01f, 1.44746140e-01f, 2.80699372e-01f, 2.07100257e-01f,
  -2.28259653e-01f, 1.21680580e-01f, 8.46791342e-02f, -8.62094387e-02f, -1.78721517e-01f, -8.21414664e-02f, -1.15264885e-01f, 1.05320066e-01f, -4.69772145e-02f, 1.35059521e-01f,
  1.77085251e-01f, -1.56802207e-01f, -1.29201645e-02f, 1.11053094e-01f, -1.03824608e-01f, 2.12323785e-01f, 1.04641646e-01f, 1.90631613e-01f, 2.24683255e-01f, -1.68374091e-01f,
  3.66392266e-03f, 1.95430830e-01f, -1.16402209e-01f, 1.30758062e-01f, -4.82199043e-01f, -1.79275051e-01f, 1.85179338e-01f, 1.29264370e-01f, 3.80101144e-01f, 1.22499011e-01f,
  1.07473932e-01f, -4.67907876e-01f, 1.54310405e-01f, -5.72036020e-03f, -2.42462322e-01f, -2.39773333e-01f, -3.79646085e-02f, 1.35920972e-01f, 2.09010407e-01f, -4.28539701e-02f,
  5.36767170e-02f, -3.86482254e-02f, 1.61753207e-01f, -1.02534279e-01f, -1.15646549e-01f, -6.91317320e-02f, 1.40455604e-01f, -2.24992353e-03f, -7.66545013e-02f, 1.74547806e-02f,
  -4.21549380e-01f, 4.17562991e-01f, 7.35286176e-02f, -8.94436985e-02f, 6.40297309e-02f, 6.73968997e-03f, 1.27409026e-01f, -9.50591639e-02f, 2.60823339e-01f, 3.20748329e-01f,
  3.90706444e-03f, -1.21637702e-01f, 1.90496117e-01f, 2.27522366e-02f, -9.08268988e-02f, -5.40753733e-03f, 8.76817927e-02f, 1.59218177e-01f, -5.16840070e-02f, 1.24964505e-01f,
  -3.75432558e-02f, 1.11392356e-01f, -3.85366306e-02f, 1.96639523e-01f, -1.02841437e-01f, 7.52647817e-02f, 8.85337815e-02f, -1.38893902e-01f, 1.14178225e-01f, -6.37622178e-02f,
  -1.67114452e-01f, 9.12620872e-02f, 1.69780225e-01f, 1.08233042e-01f, 2.09597405e-02f, -1.27132326e-01f, -1.83439672e-01f, 9.09627825e-02f, -1.17058896e-01f, -1.91001728e-01f,
  9.13564954e-03f, 1.44035161e-01f, -1.30810827e-01f, -4.44804877e-02f, 2.43023574e-01f, -2.28456065e-01f, -2.43933633e-01f, 2.19791114e-01f, -1.76013619e-01f, -1.50813922e-01f,
  -1.45903140e-01f, 1.28281629e-03f, -1.65120229e-01f, 1.42559052e-01f, -5.73642254e-01f, 1.27825394e-01f, 4.31147180e-02f, 1.91158921e-01f, -1.07530601e-01f, 1.61910564e-01f,
  2.82166809e-01f, -3.26662511e-01f, -6.89598918e-02f, 3.70697118e-02f, 7.74104893e-02f, 3.89976978e-01f, -1.10578937e-02f, -1.45964593e-01f, -1.05547011e-02f, -2.38738552e-01f,
  3.28931898e-01f, -4.81597744e-02f, -7.04743639e-02f, -2.14603141e-01f, 1.14423551e-01f, -1.52063981e-01f, 6.58501312e-02f, 1.37938187e-01f, -3.24504882e-01f, -2.68845018e-02f,
  1.79222330e-01f, -9.73173156e-02f, 3.96545343e-02f, -4.33901809e-02f, 1.11452684e-01f, 6.10142387e-02f, 8.83502141e-02f, 1.66768096e-02f, 2.32085153e-01f, -6.36452064e-02f,
  1.18254744e-01f, 6.15330786e-02f, 3.02216616e-02f, 1.01940730e-03f, 1.59570307e-01f, -9.97273624e-02f, 6.75282767e-03f, -3.27683568e-01f, 2.22917367e-02f, 1.01179592e-02f,
  -3.92700285e-02f, -9.37609524e-02f, 3.08742560e-02f, 4.84638661e-03f, 2.84053534e-01f, -1.56220585e-01f, 3.00357252e-01f, 2.40215436e-01f, 1.93361342e-01f, -4.01200801e-01f,
  -3.25669885e-01f, 1.15289539e-02f, -4.31048036e-01f, 1.67193655e-02f, 2.79861093e-01f, 2.21666351e-01f, 1.47800550e-01f, 5.88535517e-02f, -3.41493845e-01f, 1.29450947e-01f,
  5.97419515e-02f, -2.91306823e-02f, -1.18770503e-01f, 6.32778257e-02f, -1.56989947e-01f, -4.07631427e-01f, -2.69976079e-01f, 2.81303018e-01f, -3.36897880e-01f, 1.83055568e-02f,
  -2.17759222e-01f, -2.57846922e-01f, 2.52689004e-01f, -1.74075648e-01f, 1.49449006e-01f, 6.51223585e-02f, -1.67030290e-01f, 1.36559352e-01f, -1.83767498e-01f, 1.42408550e-01f,
  1.05641350e-01f, 4.56389412e-02f, -3.35245430e-02f, 3.17300446e-02f, -1.47294283e-01f, 7.15831593e-02f, 1.05674118e-01f, 1.14065990e-01f, 1.99432418e-01f, 2.18526684e-02f,
  2.32800141e-01f, 1.57082275e-01f, 2.47257784e-01f, 2.57613331e-01f, 7.26184249e-02f, 1.30000472e-01f, 6.42560422e-02f, -1.72654465e-01f, 9.49659646e-02f, 1.09805483e-02f,
  7.85607323e-02f, 5.97290955e-02f, 3.81897315e-02f, -4.98244315e-02f, -3.76489460e-01f, -5.36278822e-02f, 2.97839497e-03f, -2.92884320e-01f, -4.04523648e-02f, 1.75217316e-01f,
  7.52027854e-02f, -1.13823280e-01f, 2.58175582e-02f, 4.07682270e-01f, -1.78016737e-01f, -2.99849920e-02f, -1.09126508e-01f, 7.25393072e-02f, 2.23261610e-01f, 2.54190378e-02f,
  8.65634903e-02f, -1.93803445e-01f, -3.59838545e-01f, -1.95099741e-01f, -9.64484811e-02f, 6.17924519e-02f, -1.94749638e-01f, 4.66574252e-01f, 2.18432352e-01f, -2.77839899e-01f,
  3.33839431e-02f, -6.39295802e-02f, 4.15176868e-01f, 1.14772066e-01f, 7.22740740e-02f, -2.19957456e-01f, 1.18730821e-01f, 1.66919529e-01f, 1.64951220e-01f, 1.94500223e-01f,
  -2.49339074e-01f, 2.09683031e-01f, -3.68948206e-02f, -1.57600448e-01f, -9.86603573e-02f, 3.72493118e-02f, -4.21702921e-01f, -1.87832415e-01f, 3.91121432e-02f, 6.17389902e-02f,
  -6.14939295e-02f, -8.23774114e-02f, 5.49050421e-02f, 7.75855035e-02f, 8.08750317e-02f, -1.42593076e-02f, -2.87146538e-01f, -1.90663449e-02f, 1.90193594e-01f, -7.97635168e-02f,
  -1.25532866e-01f, 9.61801633e-02f, 2.92082615e-02f, -1.82974383e-01f, -1.51767164e-01f, 3.60268317e-02f, -1.52547866e-01f, -4.19581169e-03f, -2.00308114e-01f, -1.87944278e-01f,
  7.38380179e-02f, 3.81438658e-02f, -1.01555027e-01f, -2.19085962e-02f, -1.36286572e-01f, -6.37114570e-02f, -1.77270681e-01f, 2.24548310e-01f, 1.77416712e-01f, -2.16515407e-01f,
  3.73015881e-01f, -3.77697945e-02f, 2.19143659e-01f, -8.20609629e-02f, -1.46937743e-01f, -5.29378913e-02f, 9.23882723e-02f, -4.30070832e-02f, 5.73131554e-02f, -9.08813477e-02f,
  1.43656591e-02f, 6.46814853e-02f, 8.58615190e-02f, 2.84770131e-01f, -9.05998349e-02f, 8.79525393e-03f, 2.20083043e-01f, -1.11936405e-01f, -1.46188602e-01f, 1.59614041e-01f,
  8.81058574e-02f, 3.05044025e-01f, -2.95327783e-01f, -1.74542978e-01f, -1.13708735e-01f, 2.66592234e-01f, -1.11424945e-01f, 6.63966388e-02f, 6.49693608e-02f, 1.56909321e-02f,
  2.58226573e-01f, 1.45006195e-01f, -1.30189672e-01f, -5.70897684e-02f, -1.04399174e-01f, -1.12237625e-01f, -2.25054752e-02f, -5.40383942e-02f, 2.01720605e-03f, 9.23874453e-02f,
  3.20528537e-01f, -7.49229416e-02f, 1.89944115e-02f, 8.38514790e-02f, -1.11390941e-01f, -1.42876625e-01f, 1.42025083e-01f, -1.20872788e-01f, -2.56011128e-01f, 2.78190933e-02f,
  -9.92558897e-02f, -4.56855185e-02f, 9.85600203e-02f, -8.90218467e-02f, -3.96039635e-02f, -1.56584680e-01f, 7.42427036e-02f, -6.08714744e-02f, -1.25919640e-01f, 3.15418929e-01f,
  2.37970456e-01f, 4.45208997e-01f, 1.99253604e-01f, 1.15351297e-01f, 2.37120956e-01f, 1.69254512e-01f, 2.79096544e-01f, -5.39105758e-02f, 1.36675984e-01f, 2.48389259e-01f,
  -1.14874065e-01f, -3.79706584e-02f, 1.56586528e-01f, -1.88745752e-01f, 6.67000636e-02f, 3.72997344e-01f, -1.40169561e-01f, 1.36472285e-01f, 1.38786077e-01f, 6.30504712e-02f,
  1.15852341e-01f, -3.84636253e-01f, 7.75078014e-02f, 9.18212831e-02f, 1.04429580e-01f, 2.26166382e-01f, -2.20126241e-01f, -2.17144519e-01f, -2.72175550e-01f, 9.10547227e-02f,
  7.41471276e-02f, -1.24026962e-01f, 7.91454911e-02f, -1.54316157e-01f, 1.09529145e-01f, 1.61568865e-01f, 1.42751113e-01f, 5.17536625e-02f, 1.76030368e-01f, 2.72300690e-01f,
  7.20943436e-02f, 2.30286121e-01f, 2.67414361e-01f, 1.68946654e-01f, -1.08230472e-01f, -2.22801361e-02f, 7.97408819e-02f, 9.45444219e-03f, 6.29845858e-02f, 2.40131561e-02f,
  -1.13021716e-01f, 1.90612614e-01f, 2.88938731e-01f, 3.07730466e-01f, 2.35504862e-02f, -1.48610443e-01f, -1.21829979e-01f, 1.62632078e-01f, -6.66430816e-02f, 9.41411480e-02f,
  1.54921725e-01f, 9.48215052e-02f, 5.57453446e-02f, 4.76112142e-02f, 2.29884416e-01f, -2.18600601e-01f, -2.50068977e-02f, 1.12699801e-02f, 1.46155179e-01f, -3.49772990e-01f,
  5.47983795e-02f, -3.85770411e-03f, 9.93489176e-02f, -2.71063626e-01f, 1.46351755e-02f, -1.57857519e-02f, 2.65376657e-01f, -6.08129576e-02f, 1.24796383e-01f, 2.21813563e-02f,
  1.72611535e-01f, 2.48170227e-01f, 1.77016139e-01f, 2.05706075e-01f, -1.06713824e-01f, 3.22569311e-01f, 7.76819363e-02f, 1.84855968e-01f, -3.02050095e-02f, -1.17981158e-01f,
  2.18167037e-01f, 1.75024435e-01f, 1.78612228e-02f, -6.41251504e-02f, -2.39814594e-01f, 3.81925821e-01f, 7.79894739e-02f, -1.14734963e-01f, -2.14929916e-02f, -1.97759271e-01f,
  1.31768182e-01f, 9.27635059e-02f, 1.17295898e-01f, 1.76532656e-01f, 1.36449412e-01f, 9.20538083e-02f, 1.12920269e-01f, -9.20191482e-02f, 1.74554158e-02f, 3.11216027e-01f,
  1.02636375e-01f, 1.10978886e-01f, -1.62852667e-02f, -1.23258717e-01f, 1.83824018e-01f, -2.75246620e-01f, -2.85858531e-02f, 1.01851076e-01f, -3.39150317e-02f, 5.17754741e-02f,
  -2.09308878e-01f, 1.54728919e-01f, 1.37539312e-01f, -3.00566480e-02f, 5.69769181e-03f, -2.34217886e-02f, -1.87738523e-01f, -1.10794015e-01f, -1.90296471e-01f, 2.56250709e-01f,
  -1.34897783e-01f, -2.31039882e-01f, -3.27610552e-01f, 3.43355149e-01f, -3.40793729e-01f, -1.94835678e-01f, 2.80340791e-01f, -2.53938019e-01f, 3.19389477e-02f, -2.20216617e-01f,
  9.45254415e-03f, 2.08463997e-01f, -8.55974853e-02f, 3.16533089e-01f, 1.76300347e-01f, -2.69149691e-02f, 2.70963639e-01f, -1.19762458e-01f, 1.26136005e-01f, 9.16226655e-02f,
  1.68556333e-01f, 7.35116377e-02f, 5.99398278e-02f, 9.77729112e-02f, 2.06942424e-01f, 3.77511442e-01f, -1.43863097e-01f, 2.92104147e-02f, 1.38428444e-02f, 3.37775171e-01f,
  -2.33058095e-01f, -1.69290453e-01f, 9.39423218e-02f, 1.17639010e-03f, -3.08197051e-01f, -8.06249827e-02f, 2.23438498e-02f, -1.05696522e-01f, 9.19467583e-02f, 9.44861472e-02f,
  -2.37050891e-01f, 2.90918022e-01f, 3.17328662e-01f, 6.85600564e-02f, -1.78047102e-02f, 3.50663275e-01f, -2.73350090e-01f, -2.43022725e-01f, 3.71759206e-01f, 1.89940870e-01f,
  1.12559140e-01f, 9.14050788e-02f, -1.33708930e-02f, 5.42570278e-02f, 7.69248903e-02f, 2.14528486e-01f, -2.48109996e-01f, -6.85983673e-02f, 1.53710246e-01f, -7.47952387e-02f,
  -9.64148641e-02f, 2.84854710e-01f, 2.16659337e-01f, 8.78999382e-02f, 2.88708150e-01f, 2.75238492e-02f, 6.32088585e-03f, 4.34470847e-02f, -2.17563391e-01f, -1.12232426e-02f,
  2.04023346e-01f, 1.05965324e-02f, 3.53398435e-02f, -5.75779006e-02f, 8.98693576e-02f, -5.27714938e-02f, -3.80112052e-01f, 2.85800457e-01f, -9.14298296e-02f, 2.06241578e-01f,
  1.00855082e-01f, -8.61723945e-02f, -2.08875209e-01f, 3.55448931e-01f, -4.08547878e-01f, 1.78354129e-01f, 3.16758186e-01f, 7.91749805e-02f, -3.45071763e-01f, 6.10088743e-02f,
  1.95856571e-01f, 1.41499981e-01f, -2.57082671e-01f, -4.04031761e-02f, -9.23753530e-02f, -2.49505863e-01f, -1.51598349e-01f, -9.20394287e-02f, 2.39352494e-01f, 5.73875755e-02f,
  3.76476981e-02f, 1.81641981e-01f, 8.66080001e-02f, -2.25869101e-02f, -2.96808258e-02f, 8.76407623e-02f, 1.55961901e-01f, 1.67401195e-01f, 2.79210359e-01f, 9.21432897e-02f,
  1.49107084e-01f, 1.56115234e-01f, -1.73560143e-01f, -9.28186253e-02f, 1.04807958e-01f, -4.53179032e-02f, -1.46368310e-01f, -1.15965590e-01f, -6.02182224e-02f, -2.15287209e-01f,
  3.82805355e-02f, 1.12727858e-01f, 1.90867573e-01f, -1.32129148e-01f, 2.24334911e-01f, -2.56176949e-01f, 2.29993090e-01f, -9.67707187e-02f, -7.45350868e-02f, -5.75423501e-02f,
  2.67593294e-01f, -5.54743819e-02f, 4.17209715e-01f, 1.24667428e-01f, 9.37988609e-03f, -2.60553509e-01f, 1.56906411e-01f, 1.04143366e-01f, 2.38914177e-01f, -1.07331993e-02f,
  1.17637902e-01f, -9.17666182e-02f, -5.98253645e-02f, 2.60281134e-02f, -2.42477074e-01f, 2.51545489e-01f, 1.63062602e-01f, -8.34818231e-04f, 3.71452659e-01f, 7.58469552e-02f,
  1.97058141e-01f, 1.11819208e-01f, 1.40002206e-01f, -2.29995131e-01f, -7.70404786e-02f, -4.48617451e-02f, -7.28752166e-02f, 2.95842856e-01f, 1.07120506e-01f, 1.95582688e-01f,
  1.83631182e-01f, -1.19065627e-01f, 7.23401308e-02f, 5.08186892e-02f, 9.66187492e-02f, 1.08488247e-01f, -6.83277324e-02f, 3.84358689e-02f, 1.60464093e-01f, 1.42744966e-02f,
  -7.01109767e-02f, -7.71429064e-03f, -1.97122544e-01f, 4.93187234e-02f, 4.50337231e-02f, 4.27600928e-02f, -1.77248627e-01f, 9.28638056e-02f, 1.56634167e-01f, 1.61125749e-01f,
  1.86164066e-01f, -7.49230236e-02f, -1.74405396e-01f, 6.52486309e-02f, 6.93220869e-02f, -3.91840711e-02f, 1.17587835e-01f, 3.14885899e-02f, -2.61587024e-01f, -6.44641817e-02f,
  1.44724324e-01f, -1.00987852e-01f, -2.05082521e-01f, -1.82808451e-02f, -2.62423366e-01f, -7.67173618e-03f, -1.72307998e-01f, -9.69079584e-02f, 7.13138059e-02f, -6.86842203e-02f,
  -1.45455822e-01f, -4.83961254e-02f, 1.60922989e-01f, 2.33860627e-01f, -1.67404935e-01f, -1.39544383e-02f, 3.04878622e-01f, 2.47572605e-02f, -1.03211170e-02f, 1.30978748e-01f,
  1.46712556e-01f, 2.05662116e-01f, 2.70575285e-01f, 1.95563376e-01f, -2.05026660e-02f, -4.34589051e-02f, 2.83109903e-01f, 3.58298689e-01f, -1.40407994e-01f, -9.65379924e-02f,
  1.53363701e-02f, 1.30020648e-01f, -1.80891410e-01f, 1.26620429e-02f, -9.95332934e-03f, -5.53191975e-02f, 1.67712376e-01f, -1.17880546e-01f, 1.75182968e-01f, -4.32869755e-02f,
  1.59455925e-01f, 1.01321787e-01f, 1.89334273e-01f, 3.27367783e-02f, 1.67788804e-01f, 1.54906839e-01f, 7.26884976e-03f, 1.16782255e-01f, -5.33141717e-02f, 3.11116427e-01f,
  3.77349816e-02f, -1.02755465e-01f, 1.81024354e-02f, 4.42438684e-02f, 1.38759300e-01f, -1.94728389e-01f, 9.56586376e-02f, -1.26234973e-02f, 1.29096225e-01f, 7.72974044e-02f,
  -5.05659282e-02f, 1.98890567e-02f, -9.27911922e-02f, 7.93400183e-02f, -3.07271760e-02f, 2.21609876e-01f, 1.40443295e-01f, -1.52114168e-01f, -5.40516675e-02f, 2.79138595e-01f,
  -2.07557246e-01f, 7.90487882e-03f, 1.95014626e-01f, 4.87909801e-02f, 6.65820763e-02f, -3.37555483e-02f, 4.83989902e-02f, 3.48689146e-02f, 1.82946131e-01f, 1.13577165e-01f,
  4.60927300e-02f, -2.92127766e-02f, 4.49138701e-01f, 2.82441825e-01f, 2.46723428e-01f, 1.01080403e-01f, -3.93567264e-01f, 1.64590642e-01f, 5.55573665e-02f, -1.64963260e-01f,
  2.06562459e-01f, 5.02026379e-01f, 1.07161202e-01f, 4.76123095e-02f, 1.55105844e-01f, 5.87136269e-01f, -4.54535410e-02f, 1.82206824e-01f, 1.27837723e-02f, -3.64341773e-02f,
  4.08916511e-02f, 1.89246088e-01f, 1.03843190e-01f, -9.97381881e-02f, 8.63981098e-02f, -4.49812263e-02f, -1.57156527e-01f, -1.00860372e-01f, 2.17225373e-01f, 2.25103885e-01f,
  6.83829337e-02f, -3.54661443e-03f, -1.22519527e-02f, -2.72453241e-02f, -3.83140415e-01f, 1.83354337e-02f, 3.45687032e-01f, -9.96360183e-02f, -9.17213969e-03f, 1.07902452e-01f,
  7.34125152e-02f, 2.88297564e-01f, 4.38107885e-02f, -7.11515024e-02f, 2.27977172e-01f, 8.46022740e-02f, 3.53093505e-01f, -2.84323722e-01f, 1.39427325e-02f, -3.00510138e-01f,
  -8.26820210e-02f, 1.14578277e-01f, -9.30516422e-02f, 1.51971042e-01f, -2.57190466e-01f, 1.21436015e-01f, 1.26810029e-01f, 1.85518086e-01f, -9.49385166e-02f, -7.41227344e-02f,
  5.89410216e-02f, 2.32667908e-01f, -2.24928573e-01f, -1.87290981e-01f, 1.69482425e-01f, -2.61489242e-01f, 2.78150346e-02f, -5.48986718e-02f, -1.51241273e-01f, 1.67262197e-01f,
  2.50422060e-01f, 8.86622593e-02f, -1.90676719e-01f, 2.36750133e-02f, 2.70055950e-01f, -1.47337601e-01f, 1.77776694e-01f, -3.31905991e-01f, 2.98887163e-01f, -2.27842256e-01f,
  1.38250560e-01f, 1.34794340e-01f, 1.53260231e-01f, -1.15618226e-04f, -5.64836860e-02f, -5.14612487e-03f, 3.93425561e-02f, 1.14532739e-01f, 1.53383210e-01f, 1.69447437e-01f,
  2.10904196e-01f, 1.91269860e-01f, -3.40847857e-02f, -5.09928353e-03f, 4.06694300e-02f, 8.90192315e-02f, 1.50442719e-01f, -2.11442895e-02f, 3.66541259e-02f, -1.01592839e-01f,
  -2.50266850e-01f, 1.09862564e-02f, 3.04345917e-02f, 2.83523709e-01f, -7.77633712e-02f, -1.02228798e-01f, -1.98999837e-01f, -7.94673637e-02f, 2.30755135e-01f, 1.87264040e-01f,
  2.03114986e-01f, 8.73077437e-02f, 1.29752666e-01f, -8.72196034e-02f, -1.74162120e-01f, -1.41970888e-01f, 8.28302577e-02f, -3.13107431e-01f, 3.07062000e-01f, 1.49017826e-01f,
  1.65272757e-01f, -1.64186731e-01f, 1.05172858e-01f, -9.24924538e-02f, -4.31920663e-02f, -1.05274782e-01f, -1.45260675e-03f, -9.45291296e-02f, 2.29892001e-01f, 1.26098748e-03f,
  -3.24137449e-01f, -1.20732538e-01f, -1.45055056e-01f, 1.71707898e-01f, 2.65182227e-01f, -7.42835030e-02f, 1.84914887e-01f, -1.94325238e-01f, 2.46792898e-01f, -2.10790094e-02f,
  2.10572928e-01f, 2.44848490e-01f, -4.52606604e-02f, -2.00327516e-01f, -6.99879453e-02f, 6.39332905e-02f, 8.48738998e-02f, -1.29463851e-01f, -5.27592078e-02f, -1.15486868e-01f,
  1.78570420e-01f, -1.88411295e-01f, 6.11301176e-02f, 1.04601420e-02f, -2.45777071e-01f, 3.79856192e-02f, 2.50591934e-01f, 9.38784331e-02f, 2.05513850e-01f, 1.86221704e-01f,
  -2.77247876e-01f, -2.56139517e-01f, 8.04805942e-03f, 1.79362923e-01f, 1.43713087e-01f, 1.48745865e-01f, -4.10206206e-02f, 2.84527093e-01f, 2.23521113e-01f, 1.43915102e-01f,
  -6.92184567e-02f, 3.41257919e-03f, -2.19938322e-03f, 1.69026285e-01f, -1.14582121e-01f, 1.05166093e-01f, -8.82380754e-02f, 2.13469654e-01f, 2.42230564e-01f, 1.19358025e-01f,
  1.69387758e-01f, 2.29662850e-01f, -2.90845692e-01f, -8.07922259e-02f, 1.41111091e-01f, 7.66174868e-02f, 2.02054664e-01f, -1.67800859e-01f, 1.61897421e-01f, 7.49223083e-02f,
  -2.13671446e-01f, -2.91115027e-02f, 4.13863361e-02f, 1.54979020e-01f, 2.88761351e-02f, -2.25659236e-01f, 5.81681691e-02f, 2.48413831e-01f, 9.00288522e-02f, 2.21537903e-01f,
  -1.09907933e-01f, 2.24958986e-01f, -2.75255591e-01f, -9.96690691e-02f, 2.54485458e-02f, 8.12799409e-02f, -1.44779474e-01f, -2.66409844e-01f, -1.53764769e-01f, -2.07333237e-01f,
  2.00796455e-01f, 6.52512237e-02f, -5.17537147e-02f, -1.25530034e-01f, 3.10461223e-01f, 6.07308000e-02f, 2.96022832e-01f, 8.38340148e-02f, -3.63719370e-03f, 2.25007489e-01f,
  2.72706777e-01f, 2.39358634e-01f, -9.34569985e-02f, 1.20421052e-01f, -2.17655689e-01f, -2.04994157e-01f, 1.40379459e-01f, 1.09514780e-01f, 2.94477254e-01f, 9.84797329e-02f,
  -9.89367887e-02f, 3.05913836e-02f, -2.43885461e-02f, 2.06830695e-01f, -2.01495248e-03f, -3.44917253e-02f, 4.67265509e-02f, 1.22790731e-01f, 7.11695617e-03f, -1.10115431e-01f,
  -1.35989830e-01f, -3.55330333e-02f, -1.80507097e-02f, -6.60836101e-02f, -2.09885255e-01f, 2.50450224e-01f, -3.50452363e-01f, -9.25506055e-02f, 5.11733703e-02f, -7.76301846e-02f,
  -1.47551354e-02f, -1.90769255e-01f, 7.95106143e-02f, 9.76403877e-02f, -1.92072898e-01f, 4.08947356e-02f, 1.82623699e-01f, -4.11367603e-02f, 2.97042932e-02f, -1.31920213e-02f,
  7.35294223e-02f, 2.82165825e-01f, 1.22111715e-01f, -2.58441418e-02f, -1.30516484e-01f, 3.14829290e-01f, 4.61272635e-02f, 2.61956394e-01f, 1.61743224e-01f, 7.98266456e-02f,
  5.05671427e-02f, -6.79089427e-02f, 6.10771552e-02f, 1.55756876e-01f, 1.48257643e-01f, -7.21847713e-02f, -1.06725194e-01f, 7.95207769e-02f, 1.67225435e-01f, 1.30075082e-01f,
  -2.94517502e-02f, 2.21600123e-02f, 1.36677429e-01f, 1.29493579e-01f, 3.42021063e-02f, -8.19474831e-02f, 1.06864795e-01f, 1.58685103e-01f, 2.51686960e-01f, -1.20134145e-01f,
  2.02029854e-01f, -3.84112000e-02f, -1.92892894e-01f, -1.60289090e-02f, -3.87663767e-02f, 3.26885402e-01f, -8.40910152e-02f, -1.12246439e-01f, -7.60981366e-02f, -2.04860978e-02f,
  4.17955399e-01f, -1.31183311e-01f, 9.95851904e-02f, 5.10211326e-02f, 1.29810810e-01f, -2.57826686e-01f, 1.53973669e-01f, -5.80222458e-02f, -1.87763944e-02f, -6.79822871e-03f,
  8.85184556e-02f, 2.33005002e-01f, 3.50562595e-02f, 6.87522814e-02f, 2.55556971e-01f, -1.22130461e-01f, -6.58746287e-02f, 4.01137024e-02f, 1.25698507e-01f, -2.78790563e-01f,
  -9.66285472e-04f, 1.85920149e-01f, -2.12854728e-01f, -7.67447129e-02f, -1.68261826e-01f, -3.96993235e-02f, -7.28101507e-02f, 9.13347155e-02f, 1.87430471e-01f, 2.89601535e-01f,
  -7.84704462e-02f, -1.53350368e-01f, 3.02335978e-01f, 1.29867375e-01f, 2.25646973e-01f, -2.07512036e-01f, 2.10673302e-01f, 7.86340460e-02f, 2.55223751e-01f, -1.57282531e-01f,
  1.22037597e-01f, -1.37800509e-02f, -9.29228514e-02f, 2.18171794e-02f, -6.21418357e-02f, 1.19650394e-01f, 1.24081738e-01f, -5.65020815e-02f, -5.23634851e-02f, -5.11686802e-02f,
  1.12959318e-01f, 1.52983665e-02f, 1.70891527e-02f, -4.92639132e-02f, -1.39028832e-01f, 2.42192484e-02f, 1.82141632e-01f, -1.61784589e-01f, 1.79367897e-03f, -1.66993424e-01f,
  1.08559765e-02f, -2.43225977e-01f, -2.90094972e-01f, -2.46181358e-02f, 4.83873338e-02f, -3.00121345e-02f, 3.14531714e-01f, 1.12083945e-02f, 8.10718760e-02f, 8.71867463e-02f,
  1.05411932e-01f, -3.32259871e-02f, 2.14793518e-01f, -2.07654506e-01f, 3.37018430e-01f, 1.04207367e-01f, -6.75157905e-02f, -1.50701895e-01f, 2.28285678e-02f, -9.13386466e-04f,
  2.99522299e-02f, -1.64300963e-01f, 3.13553393e-01f, 1.81720629e-01f, -1.67110655e-02f, 4.18207459e-02f, 3.35154720e-02f, 3.28741580e-01f, -3.52668278e-02f, -1.28642872e-01f,
  7.66806751e-02f, 1.06519036e-01f, 1.97784588e-01f, -8.98186415e-02f, 7.23090321e-02f, -2.76672244e-01f, 1.00497030e-01f, -1.92110702e-01f, 2.10766494e-01f, 2.12925732e-01f,
  2.27004051e-01f, 2.60927349e-01f, -1.02046639e-01f, -2.22360030e-01f, 1.00022770e-01f, 1.20005518e-01f, 1.70088485e-01f, 8.44810158e-02f, 1.59098640e-01f, -2.03375518e-02f,
  8.17157999e-02f, 1.47069320e-01f, 1.95796594e-01f, -5.96512742e-02f, 9.43764523e-02f, -1.32925138e-02f, 1.64087221e-01f, -7.42489123e-04f, -1.14369281e-01f, 1.17786802e-01f,
  -3.78217502e-03f, -3.10429018e-02f, 7.00225830e-02f, -2.17300225e-02f, 1.04661308e-01f, 1.36361316e-01f, -6.27988279e-02f, 2.32205214e-03f, 4.45669703e-02f, -4.61112186e-02f,
  3.33071440e-01f, -6.16607629e-02f, -4.70508225e-02f, -1.69818059e-01f, 8.85175094e-02f, 3.67666106e-03f, 4.99402173e-02f, 1.03795432e-01f, -1.97326727e-02f, 1.90050006e-01f,
  -5.39434664e-02f, -1.64998487e-01f, 1.62313312e-01f, 3.69319059e-02f, 1.09188542e-01f, -2.75222927e-01f, 3.72743249e-01f, -1.89119540e-02f, -3.46237570e-02f, 9.61926058e-02f,
  1.01177290e-01f, 1.75658286e-01f, -1.29526839e-01f, 6.65997267e-02f, -7.12948143e-02f, -9.68493521e-02f, -2.85002235e-02f, -9.70836505e-02f, 1.81610629e-01f, 9.25523713e-02f,
  2.07174912e-01f, 1.22852391e-02f, 2.76270598e-01f, 2.90949911e-01f, 3.59613538e-01f, 2.28626445e-01f, -9.46022850e-03f, -3.18878561e-01f, -4.27369662e-02f, 4.01020283e-03f,
  1.85644820e-01f, 6.16117083e-02f, 4.93391370e-03f, 8.79180133e-02f, 4.72503603e-02f, 2.29034647e-02f, 2.32356600e-02f, -3.07842176e-02f, 1.64226845e-01f, -3.12603191e-02f,
  2.13437155e-02f, 8.84474665e-02f, 4.24362004e-01f, -7.97794536e-02f, -2.34420583e-01f, -8.34193304e-02f, -1.14957832e-01f, 3.04431260e-01f, -5.39301820e-02f, -1.70686558e-01f,
  -1.43683136e-01f, 8.10313895e-02f, 2.80279934e-01f, -1.14258885e-01f, -8.34790096e-02f, 2.68299505e-02f, 1.42772019e-01f, -1.60463482e-01f, 1.34722143e-01f, -5.96189313e-02f,
  8.69363770e-02f, -2.45425552e-02f, 1.63628921e-01f, 9.64989662e-02f, 7.83540159e-02f, 3.58165205e-02f, 5.91246709e-02f, -2.28295237e-01f, -5.81034198e-02f, 2.91214027e-02f,
  2.90172151e-03f, -1.24510415e-01f, -5.37011139e-02f, 3.45556706e-01f, -1.79333314e-01f, -8.46591741e-02f, -2.69380540e-01f, 4.01425958e-02f, -1.85307845e-01f, 8.49230215e-02f,
  3.06094021e-01f, 1.09435774e-01f, -2.77844369e-01f, -3.08812618e-01f, 2.04949215e-01f, 3.53693515e-01f, -1.75258428e-01f, -6.50194362e-02f, 2.06388701e-02f, 2.33146772e-02f,
  2.08312020e-01f, 1.91164706e-02f, 2.31083229e-01f, 2.04642341e-01f, 6.01929277e-02f, 2.33211368e-01f, 1.04674324e-01f, 1.10825934e-01f, 2.53647029e-01f, 1.02822311e-01f,
  -4.27305885e-02f, 8.45413357e-02f, 1.44487962e-01f, 1.26743189e-03f, 2.20399648e-01f, -4.82901670e-02f, -2.06191584e-01f, -6.15206100e-02f, -2.91700274e-01f, 6.44257739e-02f,
  -8.42585564e-02f, 1.95362851e-01f, -2.02884749e-01f, -1.84098914e-01f, -6.39269501e-02f, -1.79863542e-01f, 1.22149728e-01f, 1.08262822e-01f, 1.05428323e-01f, -2.34224759e-02f,
  1.17434494e-01f, -3.90782468e-02f, -4.92918864e-02f, -2.19847009e-01f, 1.24814548e-01f, -1.76702201e-01f, 3.63469481e-01f, 8.94844905e-02f, 2.04803813e-02f, -1.94647446e-01f,
  1.18062822e-02f, -2.62367338e-01f, -2.73256656e-02f, -5.15505224e-02f, -6.61311522e-02f, -4.44894843e-02f, 1.89401314e-01f, 9.68239382e-02f, -3.20344448e-01f, -3.13845687e-02f,
  9.65568349e-02f, 2.20981538e-01f, 3.01895797e-01f, -6.58538342e-02f, 2.62701124e-01f, -2.64260061e-02f, 1.66159019e-01f, -1.57228872e-01f, 2.56714374e-01f, 1.67379156e-01f,
  -8.94992054e-02f, -2.04267070e-01f, 2.25917809e-03f, 2.86243036e-02f, 2.03689799e-01f, -4.32612188e-02f, 7.67920017e-02f, -5.55511490e-02f, 4.13383469e-02f, 1.29920512e-01f,
  1.63988501e-01f, -4.35467772e-02f, 1.67234182e-01f, 1.56271860e-01f, 1.17549434e-01f, 1.30299911e-01f, 3.19189690e-02f, -1.04206443e-01f, 2.08237283e-02f, -1.32077495e-02f,
  -1.09245069e-01f, 1.20794058e-01f, 1.35320976e-01f, 1.14996187e-01f, 2.16636121e-01f, 1.09032750e-01f, 2.82585733e-02f, 1.59915850e-01f, 4.65788953e-02f, -9.38638821e-02f,
  1.61721289e-01f, 1.72560737e-01f, -7.76881874e-02f, -9.13679004e-02f, 9.50823352e-02f, -2.50593454e-01f, 9.47562158e-02f, 1.43593952e-01f, -3.95308845e-02f, -2.78173327e-01f,
  -8.25406015e-02f, -1.20155282e-01f, 8.65583271e-02f, 9.97163281e-02f, -1.66936480e-02f, 8.78041610e-02f, 1.84461012e-01f, 2.61095524e-01f, -2.29910716e-01f, -4.91130613e-02f,
  3.56051505e-01f, 4.50387187e-02f, 4.03777771e-02f, 3.17231342e-02f, 1.34511143e-01f, 2.17617154e-01f, 1.81797355e-01f, 2.61186928e-01f, -9.40853432e-02f, -1.84084803e-01f,
  2.93401033e-01f, 1.67212605e-01f, -2.46486105e-02f, 1.22184761e-01f, -1.32080153e-01f, -1.03890352e-01f, -3.67535837e-02f, -7.32202902e-02f, 1.11642770e-01f, 1.88917350e-02f,
  1.33311329e-02f, 3.58298197e-02f, 4.22783829e-02f, -1.02370372e-02f, 1.48463964e-01f, 1.17034085e-01f, -8.27867687e-02f, 1.60621598e-01f, 1.56241804e-01f, 2.05597747e-02f,
  1.69287413e-01f, 2.00939864e-01f, -5.96797913e-02f, -9.22154188e-02f, 1.67256102e-01f, 3.34931538e-02f, 2.93328892e-02f, 1.72672123e-01f, -2.43650116e-02f, -2.56501704e-01f,
  9.02420282e-02f, 9.99741554e-02f, 6.26048371e-02f, -1.94999754e-01f, -5.16375490e-02f, 2.85489112e-01f, -2.61452924e-02f, 1.92145884e-01f, 9.35758930e-03f, 4.01794225e-01f,
  3.06776643e-01f, -1.58035532e-01f, 1.74653485e-01f, 8.08624849e-02f, -1.12413086e-01f, -1.65567756e-01f, 4.11392972e-02f, 9.90467295e-02f, -1.08782746e-01f, -1.65595517e-01f,
  2.11070180e-01f, -1.52980745e-01f, -1.29572868e-01f, 2.02722535e-01f, -8.53276104e-02f, 2.47242212e-01f, 1.17238812e-01f, 1.25758246e-01f, 2.20843703e-01f, 2.38015085e-01f,
  -2.21305281e-01f, 2.74325132e-01f, 1.97204113e-01f, 2.26888433e-01f, -3.03331375e-01f, 1.05360866e-01f, -1.53558940e-01f, 3.60056162e-02f, -1.67450249e-01f, 3.06842864e-01f,
  1.11318026e-02f, -1.92945912e-01f, 5.71475625e-02f, 7.95931295e-02f, 1.78425625e-01f, -3.55671123e-02f, -5.65603096e-03f, 3.49797942e-02f, -7.93152601e-02f, -4.87237833e-02f,
  4.01812419e-02f, -1.27435267e-01f, 8.80258903e-02f, -1.00078054e-01f, -5.54275000e-03f, 1.49411008e-01f, 3.67285162e-02f, -1.02268890e-01f, 2.37877443e-01f, -2.02864751e-01f,
  -2.70099729e-01f, -2.73421258e-01f, 1.10740855e-01f, 9.30437818e-02f, -9.94156897e-02f, -1.91745028e-01f, 6.10102713e-02f, 1.74800038e-01f, 1.96493715e-01f, -4.10474688e-01f,
  5.21517508e-02f, 2.45733663e-01f, 1.57460064e-01f, -3.80438864e-01f, -2.32903492e-02f, -8.28312263e-02f, -4.10341732e-02f, -2.62457039e-02f, 2.40649536e-01f, 7.31602684e-02f,
  3.43590267e-02f, 2.10784748e-01f, 1.65245369e-01f, 8.31317827e-02f, 2.39577834e-02f, -7.70989954e-02f, -7.51858130e-02f, 1.87441204e-02f, 1.44650147e-03f, 1.00287132e-01f,
  -2.10380808e-01f, 5.67014925e-02f, -4.03985143e-01f, -2.23916024e-01f, -2.21003935e-01f, 5.29148951e-02f, 2.88662851e-01f, 7.18108788e-02f, -2.32634872e-01f, 2.06176843e-02f,
  3.76978740e-02f, 3.23476136e-01f, -1.67514756e-01f, 9.58741754e-02f, -2.32141446e-02f, -8.72962400e-02f, 2.23785806e-02f, 2.42455788e-02f, 9.79036912e-02f, 1.07234657e-01f,
  3.40515375e-01f, 1.46306260e-02f, 2.00639695e-01f, 1.48325637e-01f, 1.95152551e-01f, 1.58523023e-01f, 9.80902091e-02f, 3.26174557e-01f, 1.63531438e-01f, 1.44121826e-01f,
  1.72476783e-01f, 3.28343362e-01f, -7.15385824e-02f, -1.87652498e-01f, -2.61883199e-01f, -2.88040459e-01f, -1.00276265e-02f, 2.31460392e-01f, 3.81611520e-04f, 2.51255166e-02f,
  1.02926241e-02f, 1.63249224e-01f, 1.56541616e-01f, 1.54084070e-02f, 2.88756073e-01f, -2.25601926e-01f, -2.00921759e-01f, 1.80142909e-01f, -1.38523161e-01f, -2.71275733e-02f,
  -2.05384791e-02f, 2.65170634e-01f, 1.93900064e-01f, 1.50434852e-01f, -2.58483496e-02f, 5.66295423e-02f, 6.70733154e-02f, -1.79627880e-01f, -9.10516307e-02f, -9.75310281e-02f,
  -4.19164039e-02f, 4.63565439e-02f, 3.83508243e-02f, 4.67297575e-03f, -2.50974834e-01f, -1.32129073e-01f, -5.98365851e-02f, 1.41991794e-01f, 2.12388113e-01f, -9.71773937e-02f,
  -4.94469814e-02f, 2.92865366e-01f, 9.92727280e-02f, -3.11057009e-02f, 1.47509173e-01f, -4.31259200e-02f, 3.82818542e-02f, -1.33573219e-01f, -1.03875332e-01f, 2.00468272e-01f,
  3.07324946e-01f, -8.18731040e-02f, 1.09016495e-02f, -8.05382058e-02f, 1.43784493e-01f, 3.32983911e-01f, 2.11756513e-01f, 2.27575541e-01f, 2.93854088e-01f, 2.61994600e-01f,
  1.19236842e-01f, 1.49695262e-01f, 1.71090335e-01f, 3.39742843e-03f, 3.79324742e-02f, -1.47073761e-01f, -6.38411790e-02f, 2.39455830e-02f, 2.52221912e-01f, 4.47912484e-01f,
  -1.74390189e-02f, -2.10936353e-01f, -9.18912292e-02f, 4.41624284e-01f, 2.16800660e-01f, -1.52666643e-01f, -1.48345634e-01f, 1.51387841e-01f, -2.10321561e-01f, -1.37882352e-01f,
  1.68247491e-01f, 2.65584052e-01f, 6.31270139e-03f, 5.80907054e-02f, -9.36249346e-02f, -2.35983595e-01f, 3.00722551e-02f, -3.56798768e-01f, -6.63626241e-03f, -2.24930882e-01f,
  -6.98692128e-02f, -1.51357621e-01f, 6.50708750e-02f, 3.99450138e-02f, -1.59799770e-01f, 2.91015089e-01f, 1.52321383e-01f, -5.60431778e-02f, 9.48945284e-02f, 4.38194387e-02f,
  2.78211057e-01f, 3.41569066e-01f, 2.68309742e-01f, 2.82667220e-01f, -4.22080542e-04f, -3.35571915e-02f, 1.00376420e-01f, 3.31774563e-01f, -1.40130818e-01f, -1.13712803e-01f,
  -1.31506532e-01f, 1.57858264e-02f, -2.42414758e-01f, -4.84709255e-03f, -2.10546970e-01f, -5.22864386e-02f, 1.57681987e-01f, 1.21132523e-01f, 1.89803749e-01f, 1.96905002e-01f,
  9.27203596e-02f, -5.80642000e-03f, 4.34619971e-02f, 6.87967017e-02f, 1.98249936e-01f, 1.82811767e-01f, 3.30956094e-02f, 1.31255900e-02f, -1.80389553e-01f, 1.15509726e-01f,
  -1.99829906e-01f, 2.67449766e-01f, 1.51898637e-01f, -2.35616326e-01f, -1.23738497e-01f, -1.76769525e-01f, -1.12066399e-02f, -1.16287909e-01f, -1.63883552e-01f, -2.14879327e-02f,
  9.23093110e-02f, 3.52923386e-02f, 2.16119722e-01f, 2.36055553e-02f, 2.55741566e-01f, -1.04375467e-01f, 2.06435725e-01f, -1.58197358e-01f, 3.17904443e-01f, -1.46181926e-01f,
  2.57203311e-01f, 2.26206899e-01f, 7.04649165e-02f, 1.09071217e-01f, 1.75412551e-01f, -1.28143147e-01f, 2.25552887e-01f, -3.51832919e-02f, -2.91822944e-03f, 1.16127685e-01f,
  -1.70388281e-01f, 2.79891819e-01f, -6.85855448e-02f, 1.73275381e-01f, -1.71598241e-01f, -1.25091106e-01f, -3.97724286e-02f, 2.37986445e-01f, 6.10737242e-02f, 1.17246415e-02f,
  -7.30399713e-02f, -3.30106795e-01f, -7.33271465e-02f, 2.11320654e-01f, 6.61060736e-02f, 3.21928084e-01f, 3.48497927e-01f, 2.11065248e-01f, 7.83998519e-02f, -1.13885283e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.00068995e-01f, 1.82633728e-01f, 1.15952797e-01f, 5.36619499e-02f, 8.40246454e-02f, 1.89610839e-01f, 1.27545998e-01f, 1.01528361e-01f, 2.04103500e-01f, -4.41716127e-02f,
  5.42234369e-02f, 9.27344561e-02f, 1.01728730e-01f, 1.49689957e-01f, 1.09385267e-01f, -8.66557956e-02f, 9.42704380e-02f, -2.39563276e-04f, -5.61293699e-02f, 2.30997130e-01f,
  2.38774732e-01f, 1.60634488e-01f, 1.93393245e-01f, 2.66599804e-01f, -5.93863688e-02f, -7.47388788e-03f, 1.14105500e-01f, 1.14557184e-01f, 1.30889103e-01f, 2.03175306e-01f,
  -4.70096245e-02f, 2.14663610e-01f, 1.33785903e-01f, 8.84750038e-02f, 2.50138432e-01f, 9.75413099e-02f, 1.43341571e-01f, 1.99961200e-01f, 9.82593447e-02f, -6.93392754e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.48057237e-01f, 2.81161442e-02f, -3.62821370e-02f, 1.27299711e-01f, 4.25855778e-02f, 8.39580148e-02f, -1.83444157e-01f, -1.66119188e-01f, -1.39995903e-01f, -1.60539538e-01f,
  2.03011911e-02f, 1.72677472e-01f, 7.54448846e-02f, 1.39556706e-01f, 7.07796291e-02f, -1.45782560e-01f, 6.23550899e-02f, -3.19049984e-01f, 2.36089841e-01f, 2.66533524e-01f,
  -2.14813221e-02f, 1.23773227e-02f, 7.37777725e-02f, -8.26017633e-02f, 9.30701271e-02f, -8.17041844e-02f, 1.41870365e-01f, -2.48328954e-01f, 8.40849504e-02f, 6.18341984e-03f,
  -5.87784275e-02f, -1.59309998e-01f, 2.58336365e-02f, 1.66925445e-01f, -2.15040430e-01f, -1.33187294e-01f, -6.60833791e-02f, 2.01437697e-01f, 4.06433865e-02f, 1.01227947e-01f,
  -3.26934154e-03f, 1.59201294e-01f, 9.51199327e-03f, 1.44904539e-01f, -6.34461117e-04f, 3.27615738e-02f, 3.71379144e-02f, -1.25951037e-01f, 1.60791352e-01f, -1.43918768e-01f,
  2.84441039e-02f, -1.45582743e-02f, 1.33265957e-01f, -4.12832424e-02f, 1.70294046e-01f, 1.02111995e-01f, -8.94481316e-03f, 4.99692969e-02f, -3.78409885e-02f, 2.18525693e-01f,
  -8.36223587e-02f, -1.11309931e-01f, -6.00092374e-02f, 8.70223865e-02f, -3.51037048e-02f, -2.20975801e-02f, -4.52629626e-02f, 7.52368718e-02f, 5.56071848e-02f, 5.42610399e-02f,
  -1.04478858e-01f, 3.59301828e-02f, -2.94182245e-02f, 4.43105027e-02f, 7.12270290e-02f, 1.82586871e-02f, 2.88008928e-01f, -4.16869589e-04f, -2.69053355e-02f, 3.42754930e-01f,
  -1.59384161e-01f, -3.51298928e-01f, -5.94002269e-02f, -1.57572746e-01f, -2.02779278e-01f, 1.35928661e-01f, 1.11329220e-01f, -2.40995497e-01f, 4.71858457e-02f, 3.74618322e-02f,
  -1.38137087e-01f, 3.20178568e-02f, 2.37419810e-02f, 2.13690381e-02f, 2.08999231e-01f, -9.10317004e-02f, 5.01936525e-02f, -1.19087115e-01f, 1.34503424e-01f, 2.04630811e-02f,
  1.95112228e-02f, -3.71801172e-04f, -1.54750526e-01f, -1.41387388e-01f, 1.90969527e-01f, 8.94413218e-02f, -7.24482834e-02f, -6.39933869e-02f, 3.24990541e-01f, 1.29922271e-01f,
  1.24717906e-01f, 9.51881334e-02f, -3.47934105e-02f, -1.95304185e-01f, 9.45334360e-02f, 8.82185325e-02f, -8.22017714e-02f, -3.40876356e-02f, 1.55670252e-02f, -1.57038391e-01f,
  1.76618308e-01f, 2.49277934e-01f, 1.93032399e-02f, -5.78952394e-02f, 3.10765766e-02f, 4.65978310e-02f, 2.58549955e-02f, -1.24310374e-01f, 2.12096162e-02f, -3.98075916e-02f,
  -1.41660094e-01f, 1.45795266e-03f, 1.58976734e-01f, -4.87819351e-02f, -5.65665141e-02f, -9.74517595e-03f, 1.55055687e-01f, 6.72135949e-02f, -4.36038226e-02f, 3.56172072e-03f,
  2.68608779e-01f, 4.36055698e-02f, 2.91245636e-02f, -1.96799651e-01f, 2.04857998e-02f, -1.80483371e-01f, 1.03105448e-01f, 1.54272810e-01f, -2.83613265e-01f, 2.62161076e-01f,
  3.16539481e-02f, -4.01136838e-02f, 1.69877231e-01f, 8.63336399e-02f, -8.37585777e-02f, -2.66121417e-01f, -3.24682221e-02f, -6.10069484e-02f, 1.12620242e-01f, 2.29764171e-02f,
  1.49005586e-02f, -1.32149249e-01f, 1.66145831e-01f, 3.70720960e-02f, -6.78274557e-02f, -3.63309607e-02f, 7.44126216e-02f, -2.09587663e-01f, 4.10798080e-02f, 3.59724492e-01f,
  -1.55461475e-01f, 9.37377065e-02f, 1.08143285e-01f, 1.85844861e-02f, 1.22893445e-01f, 8.41713995e-02f, -1.13764711e-01f, 2.65086859e-01f, -1.35139123e-01f, 3.15690607e-01f,
  2.05088615e-01f, 2.69932263e-02f, 8.82715173e-03f, -8.36994424e-02f, 9.17783082e-02f, -4.61995136e-03f, 1.42263964e-01f, -2.00133976e-02f, -1.41673192e-01f, -2.96037365e-02f,
  1.77822039e-01f, -5.98558709e-02f, -2.04236299e-01f, -1.31313697e-01f, -9.84407663e-02f, -1.73608467e-01f, 1.24109060e-01f, -1.30041733e-01f, -1.05738141e-01f, 6.09662086e-02f,
  2.86768973e-02f, -1.17227733e-02f, -2.85530426e-02f, 4.92677130e-02f, -4.68195789e-02f, 1.01262666e-01f, 1.69842422e-01f, -2.76767343e-01f, 3.30831930e-02f, 2.63973355e-01f,
  1.72447991e-02f, 2.81810880e-01f, 5.65600134e-02f, -2.34849304e-02f, 8.46169814e-02f, 7.45520890e-02f, 3.12620178e-02f, -2.10454669e-02f, 5.93395829e-02f, -9.87706035e-02f,
  -1.68023348e-01f, 1.15527846e-01f, -2.73218937e-02f, 3.72070931e-02f, -2.27660745e-01f, 1.61505207e-01f, -7.97930136e-02f, -4.26632762e-02f, 6.87040985e-02f, 1.07515708e-01f,
  -7.43826181e-02f, 4.37222719e-02f, -1.46827459e-01f, -1.61908567e-01f, 1.03932396e-01f, 3.90903167e-02f, -6.57250136e-02f, -1.73856113e-02f, -6.19821884e-02f, -1.09384008e-01f,
  -3.99248600e-02f, -6.50831982e-02f, 6.95344731e-02f, 8.24851170e-02f, -1.67933866e-01f, -4.63979207e-02f, 1.69106618e-01f, 1.79537773e-01f, 1.31215662e-01f, -1.15231842e-01f,
  -1.64043650e-01f, -2.45836433e-02f, -8.34246129e-02f, -1.39642740e-02f, 1.05323065e-02f, 1.77455917e-01f, -1.95355505e-01f, 4.03179415e-02f, 2.91794743e-02f, -2.35050499e-01f,
  1.50024043e-02f, -1.37015328e-01f, -1.23980612e-01f, 1.24994203e-01f, 7.94098228e-02f, 8.08320567e-02f, -3.32617372e-01f, 1.83895491e-02f, 1.68149829e-01f, 1.70809507e-01f,
  2.52308518e-01f, -3.65966678e-01f, -1.03393821e-02f, 3.48501690e-02f, -4.02967585e-03f, 2.74111211e-01f, -1.41208172e-01f, -7.18932003e-02f, 1.35334092e-04f, 6.97229570e-03f,
  -8.99839476e-02f, -4.28226851e-02f, 1.03019364e-03f, -1.54955432e-01f, -4.48056608e-02f, -4.95585091e-02f, -1.05732113e-01f, 8.06604549e-02f, -1.63152248e-01f, 1.61045089e-01f,
  -1.59154415e-01f, 9.60441828e-02f, 1.91544905e-01f, 3.44382506e-03f, 1.77461915e-02f, 1.99103341e-01f, -3.52629554e-03f, -9.91585478e-03f, 7.21312761e-02f, 1.00430638e-01f,
  -2.44946972e-01f, 1.89142916e-02f, 4.63668108e-02f, -4.86757569e-02f, -6.14778437e-02f, 5.69282211e-02f, -1.62097126e-01f, -6.50622249e-02f, -1.36822119e-01f, 9.38578160e-04f,
  2.59427000e-02f, 6.64254129e-02f, 4.84880842e-02f, 5.30448556e-02f, -4.17622961e-02f, 1.34019747e-01f, 1.74802870e-01f, -3.73681903e-01f, 7.86545128e-02f, 1.14458226e-01f,
  -2.24282593e-01f, -3.80109437e-02f, 8.32110550e-03f, -1.82162583e-01f, 2.51779743e-02f, -1.61869358e-02f, 1.33922920e-01f, -8.09249058e-02f, -3.70736867e-02f, 2.26399273e-01f,
  -1.96171775e-02f, 6.26307577e-02f, -3.34395058e-02f, 8.09678286e-02f, -1.83835670e-01f, -4.83872332e-02f, 1.44489855e-01f, -9.93804410e-02f, -9.79985744e-02f, -1.34300962e-01f,
  -3.36276591e-01f, 7.41001889e-02f, -1.16663851e-01f, 2.94278264e-01f, 9.28400382e-02f, -6.08559921e-02f, 4.84817661e-02f, -2.23425373e-01f, -7.10409805e-02f, 6.79637566e-02f,
  8.42632949e-02f, -1.20493725e-01f, 1.95484206e-01f, -7.74265304e-02f, -7.40052387e-02f, -4.33503017e-02f, -4.78687473e-02f, 2.36767977e-02f, 2.36403540e-01f, -1.23148121e-01f,
  -1.55987769e-01f, 4.20449644e-01f, -6.64403588e-02f, 2.48727053e-02f, -2.03905910e-01f, -1.40310556e-01f, -4.53355648e-02f, -1.73686780e-02f, -1.23327404e-01f, 3.67534831e-02f,
  1.03975587e-01f, 1.54906884e-01f, 9.30003449e-02f, 1.05080657e-01f, -3.40316705e-02f, 3.19850966e-02f, 1.90308779e-01f, -8.89440924e-02f, 8.30279738e-02f, -1.76162645e-01f,
  2.91569736e-02f, -1.64491177e-01f, -1.78433228e-02f, 1.42844900e-01f, -1.26642674e-01f, 3.35952193e-01f, 2.14845818e-02f, 2.02183649e-01f, 1.75525248e-02f, 1.76710963e-01f,
  -9.09309983e-02f, 3.37948911e-02f, -9.54760239e-02f, 4.34088707e-02f, 8.84201229e-02f, 1.32024456e-02f, 5.87045997e-02f, 1.33770496e-01f, -3.57545644e-01f, 4.46172148e-01f,
  2.05290895e-02f, -2.17475370e-01f, -2.92146429e-02f, -1.71494782e-01f, -3.47770095e-01f, -2.11921856e-01f, -1.57667056e-01f, 3.34328353e-01f, -2.15909198e-01f, -2.58310791e-02f,
  7.89298117e-02f, -5.91233484e-02f, 1.51273748e-02f, 1.62174910e-01f, 2.58233219e-01f, -1.45382091e-01f, 3.42811383e-02f, -2.14480162e-01f, 7.22294003e-02f, 6.68466464e-02f,
  3.29988524e-02f, 1.14901215e-01f, 9.30496380e-02f, -2.74453424e-02f, 3.43512632e-02f, 1.26539931e-01f, -9.16017219e-02f, 1.68955363e-02f, -9.06582326e-02f, 2.34776251e-02f,
  -1.77984573e-02f, -3.69086415e-02f, -3.96713279e-02f, -2.85658818e-02f, 1.87525675e-01f, -9.36517119e-02f, -1.14798360e-01f, 3.85662541e-02f, 4.47769240e-02f, 5.09085581e-02f,
  -2.32656952e-02f, 3.61595713e-02f, 1.84265878e-02f, -2.21025735e-01f, 1.49175748e-01f, -1.24930024e-01f, -1.17816038e-01f, -3.67706306e-02f, -1.00108497e-01f, -2.31941324e-02f,
  1.85322642e-01f, 4.69506532e-02f, 8.76544341e-02f, -7.05977380e-02f, 7.17023239e-02f, 1.03955038e-01f, 4.31693043e-04f, -1.68762505e-02f, -2.01925915e-02f, -1.68587118e-01f,
  -3.89657468e-01f, 2.17292421e-02f, 4.38049696e-02f, -3.81314754e-02f, -1.06296595e-02f, 3.30179542e-01f, -6.59241825e-02f, -1.29198045e-01f, 1.43692896e-01f, -7.15891868e-02f,
  1.10975109e-01f, 1.73238277e-01f, -6.38318202e-03f, 3.34736891e-02f, 1.07908383e-01f, -1.83927909e-01f, -1.58853635e-01f, 2.20186204e-01f, 1.81035429e-01f, -2.78307889e-02f,
  -6.22236095e-02f, -7.09392875e-02f, 8.96859448e-03f, -8.05148408e-02f, 1.65517539e-01f, -8.54411572e-02f, 8.41692537e-02f, 8.01980942e-02f, -2.54717618e-01f, -1.09780394e-01f,
  -1.66828409e-01f, 1.44442409e-01f, -5.93782254e-02f, 1.55683845e-01f, -1.91763625e-01f, 4.93486151e-02f, 1.14380531e-01f, 6.17442876e-02f, -3.52609307e-01f, -9.71202999e-02f,
  -1.02604300e-01f, 6.88814446e-02f, -2.21485030e-02f, 4.07040343e-02f, -1.20956793e-01f, -8.54222775e-02f, 3.99141647e-02f, -2.55066995e-03f, 1.20406471e-01f, -3.24939424e-03f,
  4.63697277e-02f, 2.47541796e-02f, 2.80842511e-03f, 1.97701395e-01f, -2.05255654e-02f, -1.31003037e-01f, -4.45621274e-02f, -9.95554030e-02f, -1.30257428e-01f, -1.61914587e-01f,
  -2.15776578e-01f, 1.87324136e-02f, -2.39484742e-01f, 1.00647941e-01f, -1.54215634e-01f, -2.99571324e-02f, -7.30287731e-02f, -5.61736971e-02f, -2.25308180e-01f, 3.18554103e-01f,
  2.82974038e-02f, 6.93074837e-02f, -1.54118434e-01f, 1.50147840e-01f, -1.16692506e-01f, -1.86688244e-01f, 2.86453422e-02f, -1.19775951e-01f, 4.32450585e-02f, -8.87717083e-02f,
  9.08455104e-02f, -1.34178907e-01f, -1.97802007e-01f, -3.32857929e-02f, 1.07361982e-03f, 1.79746479e-01f, -3.44386771e-02f, 2.77451307e-01f, 2.71461345e-02f, -1.07716814e-01f,
  1.49909109e-01f, 1.30648121e-01f, -1.32577464e-01f, -1.67031854e-01f, -6.03850074e-02f, -8.55835900e-02f, 7.47874007e-02f, 3.62478755e-02f, -9.84519869e-02f, 1.80765718e-01f,
  1.12168290e-01f, 1.92190886e-01f, -9.91333872e-02f, 1.09752111e-01f, -6.53720053e-04f, -1.37359321e-01f, 3.08610182e-02f, -1.31398931e-01f, -1.18202530e-01f, -7.01106340e-02f,
  7.08371997e-02f, 3.91635858e-02f, 6.82137683e-02f, -3.57772335e-02f, -1.02495421e-02f, -2.18919721e-02f, -4.98226583e-02f, 4.93578836e-02f, -5.73249497e-02f, -7.21820816e-02f,
  -1.93993673e-02f, -1.46749526e-01f, -7.77814165e-02f, 2.13422239e-01f, -3.77589650e-02f, 7.38991797e-02f, -1.58435106e-01f, -4.46112789e-02f, 1.65141329e-01f, 2.03946799e-01f,
  1.13686047e-01f, 1.88166066e-03f, 1.65765360e-01f, -1.89305365e-01f, 6.60622939e-02f, 1.46065876e-01f, -2.13806316e-01f, -4.31718528e-02f, -1.34482786e-01f, 1.23715177e-01f,
  -1.38446197e-01f, 1.09257556e-01f, 5.76647185e-02f, 1.59576833e-01f, -5.70935272e-02f, -3.31418477e-02f, 1.30207658e-01f, -1.05434723e-01f, -3.58187966e-02f, 1.48451596e-01f,
  -1.47942513e-01f, -3.44958808e-03f, 9.85028595e-02f, -1.36571631e-01f, 9.08430368e-02f, -1.20989650e-01f, -3.71086970e-02f, 2.11458467e-02f, 8.43726844e-02f, 8.46149251e-02f,
  -2.41786227e-01f, -2.91708112e-01f, 3.11066005e-02f, -5.55690378e-03f, -1.40115460e-02f, -1.84297398e-01f, -1.04954630e-01f, -2.05678746e-01f, -1.65059865e-01f, 1.40010387e-01f,
  3.14809158e-02f, 2.11565699e-02f, 1.32112533e-01f, -7.31192306e-02f, -9.18549150e-02f, 3.91319394e-02f, -1.15105338e-01f, -7.68152103e-02f, -6.01389213e-03f, 1.58580080e-01f,
  2.31549770e-01f, -1.15185566e-02f, 2.05843393e-02f, 2.22622961e-01f, -4.42165844e-02f, -1.71331298e-02f, -7.17440061e-03f, -1.44552812e-01f, 9.24044698e-02f, -1.88257113e-01f,
  2.40500584e-01f, -1.14436038e-01f, 1.73372880e-01f, 2.45978191e-01f, -1.51944399e-01f, 3.96572649e-01f, -9.47371647e-02f, -2.08798289e-01f, 1.10967390e-01f, -2.01169536e-01f,
  6.28919005e-02f, 4.28535752e-02f, 1.26709074e-01f, 1.03240028e-01f, 8.30441713e-02f, -1.71288848e-02f, -9.92296636e-03f, 1.72271654e-01f, 5.47318198e-02f, 2.40471199e-01f,
  1.23851791e-01f, 3.58992890e-02f, 6.11043572e-02f, -2.08357543e-01f, 1.50681466e-01f, 3.09309978e-02f, -1.28496423e-01f, -6.56181946e-02f, -1.45709172e-01f, -1.42981231e-01f,
  1.78214218e-02f, -6.65099621e-02f, -7.81482365e-03f, -9.03987959e-02f, 1.53094888e-01f, 3.82736214e-02f, -8.89092311e-02f, -1.13872491e-01f, 1.78105887e-02f, 1.10451980e-02f,
  -1.76304892e-01f, 1.86172590e-01f, 8.15621614e-02f, 1.32388668e-02f, -7.36615509e-02f, -3.36202327e-03f, 1.38797566e-01f, -1.06585242e-01f, -1.11898750e-01f, -1.41099989e-01f,
  -2.55295902e-01f, 2.07537413e-01f, -1.19749688e-01f, 3.33157815e-02f, -1.39903471e-01f, -5.29955812e-02f, -1.85599908e-01f, -7.87814334e-02f, 8.40032846e-02f, -6.06732145e-02f,
  -1.35835007e-01f, -4.00287546e-02f, -3.28202173e-02f, -2.75836214e-02f, -4.83637713e-02f, 1.47737846e-01f, 1.05246305e-01f, 2.44517177e-01f, 1.11570403e-01f, 9.60918702e-03f,
  4.28664722e-02f, -9.50588286e-02f, 6.50242046e-02f, 1.90433577e-01f, -1.76236093e-01f, 2.37701926e-03f, 2.53970921e-03f, 3.04079205e-01f, -1.50423303e-01f, -1.18440790e-02f,
  1.01276979e-01f, -1.13710061e-01f, -8.01301077e-02f, -1.37563888e-02f, -3.55903096e-02f, -5.70523143e-02f, -1.88942730e-01f, 1.21202782e-01f, -1.85183331e-01f, -2.73502860e-02f,
  1.23257644e-01f, -8.24810117e-02f, -1.07159354e-01f, 1.11617893e-01f, -1.00488251e-03f, 2.04852700e-01f, 1.54381782e-01f, 1.54945031e-01f, 1.31697273e-02f, -1.09756634e-01f,
  1.31547675e-02f, -1.20198959e-02f, 1.54403597e-01f, -1.71066090e-01f, 6.89014345e-02f, -6.61090463e-02f, -8.56822655e-02f, 6.52402490e-02f, -3.79895680e-02f, 1.38111487e-01f,
  9.39820930e-02f, -5.70395887e-02f, -2.01404184e-01f, 2.04508066e-01f, -1.30665451e-01f, -2.19513141e-02f, -4.28595506e-02f, 7.19799399e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.60958573e-01f, 2.06370741e-01f, 1.97412640e-01f, -2.77380962e-02f, 1.70293957e-01f, 3.03128690e-01f, 2.65174620e-02f, -8.71691331e-02f, 2.05695599e-01f, 1.77694842e-01f,
  3.38870585e-01f, 1.54554442e-01f, 3.49833518e-01f, 2.10985482e-01f, -3.88456166e-01f, 1.63025856e-01f, 3.86156961e-02f, -3.28459948e-01f, 3.41863297e-02f, -1.65381834e-01f,
  -3.24574143e-01f, 4.15858060e-01f, -2.63110083e-02f, 1.17236473e-01f, -4.19130996e-02f, 1.78186744e-01f, -1.56135023e-01f, -8.60863086e-03f, 2.31119335e-01f, -9.85033810e-02f,
  1.99601084e-01f, -9.09134522e-02f, 1.14678934e-01f, -1.70265809e-01f, 2.23441467e-01f, -1.25801891e-01f, -3.74456844e-03f, 1.85292900e-01f, -5.28105982e-02f, -7.99284205e-02f,
  9.16719288e-02f, 2.31396586e-01f, -1.26158774e-01f, 2.02277601e-01f, -6.75387755e-02f, -2.13989243e-01f, 2.24698812e-01f, 1.41143918e-01f, -2.46122405e-01f, 1.34905905e-01f,
  3.02964777e-01f, 2.03178838e-01f, 5.97085878e-02f, 1.68102920e-01f, -9.48174596e-02f, 1.74659327e-01f, 2.95221567e-01f, 3.65963221e-01f, 6.62459284e-02f, -8.99394304e-02f,
  -3.98907401e-02f, 3.42175275e-01f, 1.57636642e-01f, 1.30929679e-01f, 5.16089350e-02f, 2.49897599e-01f, 1.81954324e-01f, -1.15194069e-02f, 1.48209125e-01f, 2.94829667e-01f,
  1.66500390e-01f, 1.81020483e-01f, 1.11717716e-01f, -7.10401498e-03f, 2.24687263e-01f, -1.74827382e-01f, 1.78437680e-01f, 1.78393394e-01f, -1.87205285e-01f, 3.58816326e-01f,
  -4.19245288e-02f, -2.08677307e-01f, 1.29728109e-01f, -1.53518662e-01f, -1.80308431e-01f, -3.23110849e-01f, 1.61974698e-01f, 3.01643252e-01f, 3.20431148e-03f, 2.18008071e-01f,
  2.22577110e-01f, 3.04986894e-01f, 5.74361905e-02f, 3.16561311e-01f, 2.01833710e-01f, -8.46107379e-02f, -2.85755061e-02f, -9.68771353e-02f, 3.51341993e-01f, -1.36274537e-02f,
  1.43900454e-01f, 4.18376416e-01f, -1.23660237e-01f, -8.41898173e-02f, -1.04360498e-01f, 3.25115621e-02f, -1.86132133e-01f, 9.12138522e-02f, -1.70035467e-01f, 1.07781157e-01f,
  5.70125878e-02f, -1.01604238e-01f, -5.51652126e-02f, 2.15936720e-01f, -1.08018324e-01f, 1.64714918e-01f, 3.18310447e-02f, 2.91626811e-01f, 1.74348727e-01f, 3.97419602e-01f,
  1.71968371e-01f, 8.36704001e-02f, -9.53752920e-02f, 3.82326320e-02f, -9.09130350e-02f, 3.19896698e-01f, -3.00969690e-01f, 2.91040450e-01f, -1.78504526e-03f, 2.22497899e-03f,
  7.25333765e-02f, 8.80240500e-02f, 5.66129088e-02f, -4.70351204e-02f, 1.21273480e-01f, 2.34815523e-01f, 8.56007561e-02f, -1.08437635e-01f, -1.23003744e-01f, 3.38176861e-02f,
  1.09569721e-01f, -2.57966399e-01f, -5.11865579e-02f, 4.47004549e-02f, -1.34528652e-01f, -4.41100784e-02f, 2.77964920e-01f, 5.93436435e-02f, -1.40595958e-01f, 4.40428019e-01f,
  -1.64470021e-02f, -8.89373124e-02f, 1.53741211e-01f, -2.64017414e-02f, -2.03372031e-01f, 1.39139399e-01f, 1.06829852e-01f, -2.74083465e-01f, 8.51711929e-02f, 2.84849435e-01f,
  3.36947143e-02f, -7.28635490e-02f, 1.38297543e-01f, 1.28915548e-01f, 7.30204880e-02f, -2.98507631e-01f, 2.24361911e-01f, 2.97838282e-02f, 1.05209410e-01f, 1.18192255e-01f,
  2.05743685e-01f, -3.67897868e-01f, 1.37265446e-02f, 2.00628921e-01f, -1.17121302e-01f, 1.61757041e-02f, -1.28371745e-01f, 3.41992706e-01f, -1.30003989e-02f, 2.11616755e-01f,
  1.21368162e-01f, 5.62360585e-02f, -2.31132299e-01f, -2.48638019e-01f, 2.97966331e-01f, -5.05763218e-02f, 1.86165944e-01f, -1.47791822e-02f, 4.28356603e-02f, 9.81634632e-02f,
  -1.12945847e-01f, 5.31021319e-02f, 4.32288945e-02f, -8.74518007e-02f, 4.60404940e-02f, 4.35458049e-02f, 1.08254202e-01f, -4.04312313e-02f, -9.26241353e-02f, 8.65704268e-02f,
  1.25003681e-01f, 7.32771680e-02f, -5.73519059e-02f, 1.11894064e-01f, 7.01627135e-02f, 1.25979036e-01f, 2.85952926e-01f, -4.37105983e-01f, 3.32926065e-02f, -1.84136629e-01f,
  3.16909969e-01f, 2.44675070e-01f, 1.52345151e-01f, 2.83282846e-01f, -2.15258542e-02f, -1.90669838e-02f, 8.77159014e-02f, 2.69807339e-01f, 2.54271835e-01f, -4.83047329e-02f,
  -8.67961347e-02f, -4.42182757e-02f, 2.68253028e-01f, -1.08396798e-01f, -9.61540118e-02f, 7.93558657e-02f, -3.10950071e-01f, -1.00434266e-01f, 1.21002808e-01f, 1.62771881e-01f,
  -1.75030276e-01f, 3.74816544e-02f, 2.00012892e-01f, 2.96469569e-01f, 2.76861250e-01f, 1.84573755e-01f, -1.32167816e-01f, 4.96370256e-01f, 7.03249201e-02f, -1.39720395e-01f,
  2.96013355e-01f, -2.47335359e-01f, -6.38682349e-03f, 2.56281376e-01f, -1.55806243e-01f, 2.49063492e-01f, 2.87492335e-01f, 6.12937361e-02f, 3.92164052e-01f, 7.10472390e-02f,
  -6.00928068e-02f, 4.28006172e-01f, 1.40213013e-01f, -1.51279420e-01f, -4.36492264e-02f, 4.25369352e-01f, 2.30810829e-02f, 1.64171252e-02f, 1.06433921e-01f, 6.36789352e-02f,
  2.71835536e-01f, 1.49512544e-01f, -1.47563582e-02f, 1.13472119e-01f, 1.10157795e-01f, 2.61857621e-02f, -4.42276821e-02f, -3.63637507e-02f, 4.28734757e-02f, -3.53585817e-02f,
  3.81718613e-02f, -1.37924343e-01f, 1.13623813e-01f, 8.49612802e-02f, 2.00186282e-01f, 1.12339452e-01f, 7.72928223e-02f, -2.48447627e-01f, 9.68454033e-02f, 3.39168519e-01f,
  4.56022285e-02f, 1.30326062e-01f, 3.85158926e-01f, -1.41174302e-01f, -5.56487925e-02f, 1.31321594e-01f, -9.99365598e-02f, -1.52562931e-01f, -1.13143876e-01f, 2.73075420e-02f,
  -1.56072363e-01f, -1.26418501e-01f, 1.97784051e-01f, 2.97607362e-01f, 1.04423255e-01f, -1.01618096e-03f, -1.84023336e-01f, -1.17404170e-01f, 1.49568487e-02f, 2.46701375e-01f,
  -1.56067967e-01f, 5.36011718e-02f, 2.44844720e-01f, -1.16102166e-01f, 3.03682983e-01f, 1.70064718e-02f, -9.61753167e-03f, 1.42214596e-02f, -6.07101806e-02f, 4.92773876e-02f,
  1.53456807e-01f, 3.37976992e-01f, -2.24675778e-02f, -3.54789547e-03f, -6.55333921e-02f, 1.96718827e-01f, 5.30000962e-02f, -1.70313537e-01f, 1.23256005e-01f, 2.44466677e-01f,
  5.81099428e-02f, -1.38905779e-01f, -9.16560590e-02f, -8.83722454e-02f, -1.53088253e-02f, -1.07405938e-01f, -5.02025560e-02f, 6.92106858e-02f, 1.12171806e-01f, 6.16656393e-02f,
  1.88099183e-02f, 2.34280691e-01f, -2.22995430e-02f, -1.32482916e-01f, 3.34096283e-01f, -6.87788606e-01f, -2.55026251e-01f, 2.59229243e-01f, 2.94216350e-02f, 4.87341315e-01f,
  3.74645554e-02f, -3.87008674e-03f, 1.76470220e-01f, -8.44943970e-02f, 2.49311239e-01f, -4.42482196e-02f, 1.56959355e-01f, -1.58129603e-01f, -4.50029410e-02f, -1.90090194e-01f,
  -9.78310034e-02f, 1.32103056e-01f, -6.50362894e-02f, 2.07346186e-01f, -1.62796482e-01f, 7.29886442e-02f, 1.30382255e-01f, -2.06938460e-02f, -5.66492751e-02f, -1.20361455e-01f,
  2.61479944e-01f, 1.02539465e-01f, 2.76369363e-01f, 6.45710155e-02f, -9.01992619e-03f, 1.60807893e-01f, -1.03391297e-01f, 6.63222596e-02f, 1.63272217e-01f, 8.03202242e-02f,
  -2.67854929e-01f, 2.73666233e-01f, 5.69551177e-02f, 8.12699180e-03f, 9.63533372e-02f, 1.26870662e-01f, -9.37772021e-02f, -1.98627338e-01f, 1.85269732e-02f, 3.68915141e-01f,
  1.98560636e-02f, -2.17199028e-01f, 8.31025690e-02f, 1.15570635e-01f, -1.10181756e-01f, -1.66893303e-02f, 1.00790272e-02f, -4.33399752e-02f, 3.94399673e-01f, 4.41615395e-02f,
  -2.37218440e-01f, 5.33009917e-02f, -1.49810821e-01f, 1.52141839e-01f, 3.97515893e-02f, -8.48692581e-02f, -2.19090104e-01f, -2.17976108e-01f, 9.14069638e-02f, 1.70664504e-01f,
  -8.20005983e-02f, 2.27342341e-02f, -1.65647268e-02f, 2.17654467e-01f, 3.66841048e-01f, -1.73331931e-01f, 1.29609436e-01f, 8.87366831e-02f, 3.06619287e-01f, -9.86900404e-02f,
  1.56442061e-01f, -2.49371491e-02f, -2.01090962e-01f, 6.97903335e-02f, 3.11334748e-02f, 1.57893270e-01f, 1.52583718e-01f, -1.68820992e-01f, 8.60231891e-02f, -1.78486947e-02f,
  1.03400862e-02f, 1.96536571e-01f, 1.09802105e-01f, -5.98700009e-02f, 4.47044708e-02f, -2.16778785e-01f, -1.15237802e-01f, 2.80959010e-01f, 9.50030908e-02f, 1.84155211e-01f,
  5.00867330e-03f, 2.47725233e-01f, 1.75878972e-01f, 9.10088979e-03f, 1.06998183e-01f, 2.33799025e-01f, 3.03648502e-01f, -1.11409411e-01f, -1.35717556e-01f, 8.89018476e-02f,
  -1.26708940e-01f, 2.83979867e-02f, 2.11936355e-01f, 2.33691737e-01f, -2.02463284e-01f, -1.77964568e-01f, 2.31588885e-01f, 7.54965395e-02f, 5.45933880e-02f, 7.67037123e-02f,
  9.13075209e-02f, 6.50449097e-02f, 1.49673577e-02f, 2.89959903e-03f, 1.79687962e-01f, 1.38053715e-01f, 2.44387798e-02f, 1.41901612e-01f, 2.13437602e-01f, 3.34020913e-01f,
  1.35815009e-01f, 1.28883854e-01f, -2.70509303e-01f, 9.66617092e-02f, 2.03749500e-02f, -4.10862975e-02f, -2.13222936e-01f, -1.40705913e-01f, -3.58581781e-01f, -1.24288477e-01f,
  -1.11611955e-01f, 2.54037231e-01f, -1.39858574e-01f, -5.80822080e-02f, -6.60053939e-02f, -2.21536919e-01f, 1.75099745e-01f, -7.97303095e-02f, 1.54780066e-02f, -1.23815171e-01f,
  1.52941383e-02f, -1.33113936e-01f, -1.64951622e-01f, -1.55348867e-01f, -2.00840905e-01f, 2.47546196e-01f, 3.27804297e-01f, 1.88906625e-01f, 5.43592237e-02f, 1.84009179e-01f,
  -9.46291015e-02f, 2.70720690e-01f, 9.97165516e-02f, -1.49304584e-01f, 1.24007277e-01f, 1.57100856e-01f, -3.25911134e-01f, 1.59163810e-02f, 3.52410555e-01f, 6.17371723e-02f,
  -4.02312987e-02f, 2.36344174e-01f, 5.11281528e-02f, 3.06983218e-02f, 1.19549230e-01f, 2.17352599e-01f, 1.67112097e-01f, -2.61543930e-01f, 3.26647848e-01f, 6.63508028e-02f,
  2.19085574e-01f, 4.13967669e-02f, 1.26267523e-01f, 2.86663115e-01f, 2.64295816e-01f, 1.10551812e-01f, -3.79093997e-02f, 1.55475616e-01f, 2.18023553e-01f, -1.71292379e-01f,
  4.52786274e-02f, 1.96041554e-01f, 8.94231275e-02f, 2.19758764e-01f, -5.47590293e-02f, -1.07768968e-01f, -6.14371486e-02f, -1.03719369e-01f, 2.19353735e-02f, 6.86620697e-02f,
  -1.83557242e-01f, -2.87596226e-01f, 1.18138894e-01f, 6.67842478e-02f, -5.59540130e-02f, -1.95203289e-01f, 1.39791101e-01f, -2.66403835e-02f, -6.40427843e-02f, 7.98441395e-02f,
  5.00858165e-02f, -1.27935424e-01f, -4.05555338e-01f, -8.04111362e-02f, 2.45652888e-02f, 5.56777306e-02f, 1.52164280e-01f, 1.16553716e-01f, 7.33764470e-02f, 1.87059179e-01f,
  2.54174173e-01f, 4.01247852e-02f, 5.39302602e-02f, -3.41461301e-01f, -1.68850213e-01f, 1.67578042e-01f, 1.76370695e-01f, -1.28423005e-01f, 2.78968990e-01f, 9.68078675e-04f,
  -2.12810591e-01f, -3.71718071e-02f, 2.79347330e-01f, -1.28044635e-01f, 1.06410608e-01f, 1.23302013e-01f, -1.82130989e-02f, -6.61651790e-02f, -2.58927226e-01f, 3.05382103e-01f,
  2.08458886e-01f, -6.33345395e-02f, -1.74286976e-01f, 2.74067879e-01f, 1.20538771e-01f, 4.57868278e-02f, -1.96708634e-01f, -1.78426683e-01f, -1.69964090e-01f, -1.17441967e-01f,
  1.04993425e-01f, -4.23989221e-02f, 1.53366965e-03f, 5.59240626e-03f, 1.89987496e-01f, -3.73632573e-02f, -2.71124572e-01f, 1.20066106e-01f, -2.15652108e-01f, -2.31723890e-01f,
  2.53442585e-01f, -4.05035257e-01f, 1.56895727e-01f, 5.15250206e-01f, -1.16758220e-01f, 2.81076372e-01f, 2.58483261e-01f, -2.15912923e-01f, 2.22261518e-01f, 2.08005860e-01f,
  1.68898031e-01f, 5.04210666e-02f, 2.01226041e-01f, -3.18097800e-01f, -1.15527801e-01f, 1.41218128e-02f, -2.90030062e-01f, -4.18558307e-02f, -1.32393271e-01f, 1.13479085e-01f,
  -1.72208965e-01f, 1.08464472e-01f, 1.05107822e-01f, 1.47779688e-01f, 2.16635317e-01f, 4.16272357e-02f, -1.12636536e-01f, -4.57264967e-02f, -1.51707348e-03f, 1.92875624e-01f,
  -8.45835358e-02f, -1.21695958e-01f, -5.09644300e-02f, 1.56956628e-01f, -2.59316768e-02f, 2.79530972e-01f, 7.24050924e-02f, -7.86604173e-03f, 1.57143638e-01f, 1.63147673e-02f,
  2.70911276e-01f, 2.17867807e-01f, -2.34667629e-01f, -1.01204347e-02f, 1.48646623e-01f, 6.64778799e-02f, -1.62905931e-01f, -1.29081979e-01f, -2.55647488e-02f, 1.12914868e-01f,
  -5.62126152e-02f, 3.27847183e-01f, 1.59632489e-01f, 2.20201015e-01f, 1.61061525e-01f, 2.77823899e-02f, 2.13910967e-01f, 1.00677937e-01f, 9.83498544e-02f, 7.55752623e-02f,
  9.83681902e-02f, -4.97362316e-02f, 1.13774300e-01f, 2.04784155e-01f, -1.60975844e-01f, 3.69457453e-01f, 3.93996805e-01f, -2.02247962e-01f, 7.13730901e-02f, -2.16710418e-01f,
  -1.66956216e-01f, -1.30378217e-01f, -9.33324732e-03f, 1.74657568e-01f, -6.95519671e-02f, 3.40351641e-01f, 1.70134977e-01f, 2.60004044e-01f, 1.97352394e-01f, 1.89881191e-01f,
  -1.83809809e-02f, 5.22021949e-02f, 6.60802275e-02f, 5.18310666e-02f, -1.16978198e-01f, 7.86746293e-02f, 1.12586178e-01f, 3.33523124e-01f, -5.75337857e-02f, 2.54099607e-01f,
  -6.69459552e-02f, 2.95280721e-02f, 1.63559064e-01f, 1.43633306e-01f, -2.79355407e-01f, -5.35509028e-02f, 1.88145950e-01f, -1.01208411e-01f, -2.30269264e-02f, 6.42686188e-02f,
  1.22507900e-01f, -2.96983689e-01f, -2.17844978e-01f, 4.50131334e-02f, 3.43147606e-01f, 2.25888863e-01f, -8.04567561e-02f, 1.33370578e-01f, -1.05913721e-01f, -3.12849641e-01f,
  2.43645042e-01f, 5.25109805e-02f, -2.24413171e-01f, 2.80674130e-01f, 9.70083326e-02f, 9.07536298e-02f, 2.11200640e-01f, 7.91294798e-02f, 6.22907504e-02f, 3.25628430e-01f,
  1.48571208e-01f, 5.89077733e-03f, 1.18975766e-01f, 2.53694922e-01f, 3.56888443e-01f, 1.05908222e-01f, 1.52951494e-01f, 9.08810496e-02f, -3.37911129e-01f, 9.96190161e-02f,
  -1.80099607e-01f, -3.16933066e-01f, -3.28996964e-02f, -2.61136115e-01f, -2.06940979e-01f, -6.62697107e-02f, -6.83441833e-02f, 1.58034325e-01f, -3.73652093e-02f, -6.98673353e-02f,
  -1.11458302e-01f, 2.10354432e-01f, 2.51929909e-01f, 1.26559585e-01f, 1.12996206e-01f, -4.18639667e-02f, 2.14124307e-01f, 5.09197637e-02f, 1.72234863e-01f, -1.20778151e-01f,
  -1.84396073e-01f, -2.89974809e-02f, -7.05499202e-02f, 4.72904034e-02f, -1.46126607e-02f, 2.16932297e-01f, -2.57733583e-01f, 2.75598139e-01f, 3.93490970e-01f, -2.79786527e-01f,
  1.85415313e-01f, 1.28737882e-01f, 3.11673526e-03f, 6.96199834e-02f, 1.57423571e-01f, 2.26400122e-02f, 1.07572190e-01f, 4.40287776e-02f, 3.05493968e-03f, -5.16135711e-03f,
  -2.47667357e-03f, 2.04266757e-01f, 1.50073275e-01f, -1.36453256e-01f, 4.33621667e-02f, 1.50080696e-01f, 2.90898323e-01f, -2.15807408e-02f, 1.38813525e-01f, -2.50806868e-01f,
  -3.40369083e-02f, -5.32920659e-02f, 3.61542135e-01f, 6.47022873e-02f, -1.37070939e-01f, -4.38173451e-02f, 3.06799799e-01f, -4.41720709e-02f, 2.11230889e-01f, 1.64793372e-01f,
  -5.11123911e-02f, -4.22587305e-01f, 2.94570416e-01f, -3.57968390e-01f, 7.42959965e-04f, 1.83441248e-02f, 1.60993755e-01f, 4.07687992e-01f, 1.73114985e-01f, 1.77500904e-01f,
  4.12683450e-02f, -3.59150887e-01f, 2.96424776e-01f, 5.67921847e-02f, 1.41016483e-01f, -2.05975667e-01f, 2.88203806e-01f, -3.84856015e-01f, -1.59483135e-01f, 5.93035892e-02f,
  -6.04745075e-02f, 1.21565543e-01f, -2.64609814e-01f, 9.88847166e-02f, -3.89762223e-02f, -1.97661445e-01f, -1.28574550e-01f, -2.70258635e-01f, 3.26207072e-01f, -7.08727771e-03f,
  2.29141727e-01f, 6.78569451e-02f, -6.76952899e-02f, 3.06152076e-01f, 9.45766121e-02f, 6.05706545e-03f, -1.17415860e-01f, 6.04271404e-02f, -9.48703066e-02f, 3.43641579e-01f,
  4.81086895e-02f, -8.13665539e-02f, -1.45368755e-01f, -5.00537604e-02f, -6.65628687e-02f, 1.30488962e-01f, 1.23630494e-01f, 1.18334182e-01f, -1.61543503e-01f, 1.40915811e-01f,
  2.96556383e-01f, 1.91076414e-03f, 1.03013173e-01f, 6.59545064e-02f, 1.10217407e-01f, 9.35698021e-03f, 7.29761347e-02f, 8.65432546e-02f, -2.55934913e-02f, -9.20494795e-02f,
  5.13253640e-03f, -7.57249221e-02f, 4.52504009e-02f, 2.32089415e-01f, 1.26378762e-03f, -2.33183429e-01f, 1.65173367e-01f, -5.56935221e-02f, -3.05574626e-01f, 3.33093889e-02f,
  -2.13918522e-01f, 3.99822257e-02f, 2.61213273e-01f, 4.01842855e-02f, 2.34116465e-01f, 6.64080679e-02f, 3.31689239e-01f, -3.35405260e-01f, 4.13610041e-02f, -1.66495785e-01f,
  2.53522377e-02f, -7.38626719e-02f, 1.82999205e-02f, 5.77850081e-02f, 3.23497951e-02f, 1.09462999e-01f, 1.10836267e-01f, 1.42137622e-02f, -1.51536152e-01f, -7.72265643e-02f,
  2.17100903e-01f, -1.67792872e-01f, 7.93015957e-02f, 8.93466622e-02f, -1.48043171e-01f, 2.12954000e-01f, 3.28125119e-01f, -5.30382209e-02f, 1.09428838e-01f, 2.40074947e-01f,
  2.07351699e-01f, -3.91455367e-02f, -6.52821958e-02f, 1.19762681e-01f, 3.13759893e-01f, -1.50845349e-01f, -2.03218758e-01f, -9.62646231e-02f, -1.96550101e-01f, 9.19644237e-02f,
  2.70466089e-01f, 4.80390787e-02f, -1.33041903e-01f, 1.35057986e-01f, 4.42599565e-01f, -8.74117687e-02f, 1.58911899e-01f, 1.21697918e-01f, -2.12081239e-01f, 1.78588629e-01f,
  -2.10626990e-01f, -1.74645036e-01f, 7.34376684e-02f, 1.40763804e-01f, 4.99350913e-02f, -1.85217872e-01f, 9.16729271e-02f, 1.53058633e-01f, 1.65839449e-01f, 1.28213927e-01f,
  1.91963553e-01f, -8.53637457e-02f, -9.81850177e-02f, -4.81162608e-01f, 8.54405239e-02f, 2.86193669e-01f, -3.05363864e-01f, 1.83391362e-01f, -2.06020594e-01f, -1.32856071e-01f,
  8.70084092e-02f, 5.95851950e-02f, -8.63419622e-02f, 1.24757245e-01f, -3.18910144e-02f, 4.52019498e-02f, 4.94002819e-01f, 3.87183912e-02f, 1.66680422e-02f, -1.97818592e-01f,
  1.09404147e-01f, 1.30042493e-01f, -9.93918478e-02f, 2.89510876e-01f, -2.59161711e-01f, 3.58479246e-02f, 2.19715104e-01f, 2.28076413e-01f, 1.38727784e-01f, -2.10663870e-01f,
  2.42490366e-01f, 4.53433424e-01f, -1.71449795e-01f, -6.43746182e-02f, 8.64788815e-02f, -3.53367656e-01f, 2.19466120e-01f, 1.78731784e-01f, 1.80047125e-01f, 1.27181053e-01f,
  -1.28656313e-01f, -2.37590462e-01f, 3.86133313e-01f, 1.23568632e-01f, -1.90762848e-01f, 1.21890888e-01f, 1.26052782e-01f, -1.19163901e-01f, -4.22541536e-02f, 7.07739815e-02f,
  -5.95565848e-02f, 1.18530445e-01f, 1.76602006e-01f, 1.06781937e-01f, 1.50730491e-01f, 2.42734045e-01f, -2.61859387e-01f, 4.78745289e-02f, -6.16721250e-02f, -7.58222118e-02f,
  2.03488879e-02f, -5.35064153e-02f, -2.62644231e-01f, -9.03159976e-02f, 5.89115433e-02f, 2.77005166e-01f, -1.74363509e-01f, 2.79445916e-01f, 5.62246842e-03f, 7.62454700e-03f,
  2.73524642e-01f, -3.35836530e-01f, 1.80680364e-01f, 2.08425269e-01f, 7.25535750e-02f, -8.91352668e-02f, 2.33820885e-01f, 1.95576429e-01f, 8.76364186e-02f, 2.46136397e-01f,
  2.44318873e-01f, 8.90686065e-02f, -2.20981836e-01f, -2.20059171e-01f, 1.59571245e-01f, 1.35391966e-01f, -9.89743918e-02f, 1.89700305e-01f, -2.27018222e-01f, 1.61365554e-01f,
  -1.18772341e-02f, -4.53770161e-01f, -1.24786627e-02f, 5.98962344e-02f, 3.53135049e-01f, 3.08082223e-01f, -1.37581140e-01f, 1.19499564e-01f, 2.97149956e-01f, -1.20293908e-01f,
  -4.13595885e-02f, 4.49004732e-02f, 3.03169250e-01f, -6.67159930e-02f, -1.25885546e-01f, -3.78754884e-02f, -5.40275360e-03f, -1.09066293e-01f, -4.94103692e-02f, 2.64594883e-01f,
  7.21153840e-02f, -1.13914432e-02f, 7.49309734e-02f, -6.00401163e-02f, 9.10273567e-02f, 1.05292782e-01f, 4.30001430e-02f, -6.49216538e-03f, 1.03119187e-01f, -1.79340970e-02f,
  -9.34978649e-02f, 2.56952822e-01f, 1.03416130e-01f, 2.32822582e-01f, 6.19743243e-02f, -2.73851335e-01f, -9.27928835e-02f, 7.99008980e-02f, -1.08358018e-01f, 1.58668742e-01f,
  1.59042061e-03f, 3.46614122e-02f, 2.59459317e-01f, -1.43050089e-01f, 1.03857830e-01f, -2.49109864e-02f, 1.00598738e-01f, 1.01117663e-01f, 7.03670382e-02f, 2.74325579e-01f,
  2.03258350e-01f, 1.19055621e-01f, -1.20946787e-01f, 3.15076590e-01f, 2.52465338e-01f, -1.80642724e-01f, -2.36882851e-01f, -3.51906754e-02f, 2.39547253e-01f, -2.71058291e-01f,
  1.87809855e-01f, 1.29617140e-01f, -3.08190614e-01f, -5.16810119e-01f, -4.12873864e-01f, -6.41952008e-02f, -1.45653933e-01f, 9.50345695e-02f, -7.87378326e-02f, 9.33886990e-02f,
  -1.17950320e-01f, -3.88642758e-01f, 2.51289785e-01f, -2.67524868e-01f, 3.38245109e-02f, 9.13158432e-02f, 1.51465848e-01f, 2.51812369e-01f, 2.22982913e-01f, 2.22105414e-01f,
  2.01185763e-01f, -1.33186849e-02f, -1.74174234e-01f, -4.66617309e-02f, -1.63826644e-01f, -3.31655554e-02f, -3.06816667e-01f, 2.16976460e-02f, -9.68637466e-02f, 3.84014882e-02f,
  5.32771200e-02f, 9.79575738e-02f, -4.63866703e-02f, -8.93307328e-02f, -6.63682222e-02f, 1.60559565e-01f, -5.00314161e-02f, 9.68687683e-02f, -3.16317707e-01f, -1.00751361e-03f,
  -1.45031616e-01f, -1.94648027e-01f, 1.25796571e-01f, -2.08360121e-01f, 3.49700190e-02f, 3.70908231e-01f, -3.30517553e-02f, 2.94556975e-01f, 2.42350250e-01f, -2.31665462e-01f,
  1.72231212e-01f, 1.91943765e-01f, 1.91292584e-01f, -9.57538858e-02f, 4.13631201e-02f, -4.57542911e-02f, -2.52486944e-01f, 1.18502550e-01f, -4.72380035e-02f, 1.02056034e-01f,
  -3.88242910e-03f, 1.87077090e-01f, -1.83345303e-01f, -4.17600311e-02f, 1.96459502e-01f, 1.36932591e-02f, 9.89393145e-02f, 2.11435914e-01f, -2.26585120e-01f, -4.33140807e-02f,
  -1.70262992e-01f, 2.32363090e-01f, 2.00748727e-01f, 1.33747265e-01f, 1.34613872e-01f, 1.33794069e-01f, 1.69787779e-01f, -1.08562067e-01f, -3.74909729e-01f, 3.26288044e-02f,
  -4.06890474e-02f, -1.37878731e-01f, -6.63138181e-02f, 7.19681531e-02f, 9.72563624e-02f, -1.46173716e-01f, 2.07033139e-02f, 1.69310451e-01f, 5.79845756e-02f, -3.00807923e-01f,
  1.22726947e-01f, 1.73574597e-01f, -7.57837817e-02f, -7.78133646e-02f, -1.53628632e-01f, -1.77721694e-01f, -1.22150227e-01f, -1.43745527e-01f, -1.56687856e-01f, -2.10500717e-01f,
  -2.76305377e-01f, -1.34181112e-01f, -1.08307868e-01f, -2.10483611e-01f, -7.38520697e-02f, 1.19091898e-01f, -1.76143810e-01f, 4.39799368e-01f, 4.71424013e-02f, 2.66130012e-03f,
  -7.21588060e-02f, 1.12174772e-01f, 7.76918530e-02f, -1.84441656e-02f, -7.86542371e-02f, 1.55200856e-02f, -1.06064893e-01f, -1.94472522e-01f, 6.07351847e-02f, 4.24050763e-02f,
  -1.72994822e-01f, 1.83843449e-02f, 1.09297559e-01f, 8.46005231e-02f, 1.04316592e-01f, 1.29330844e-01f, -6.99170381e-02f, 1.97122127e-01f, 1.78413868e-01f, 4.65403050e-02f,
  1.42505527e-01f, 3.66082378e-02f, -2.25677952e-01f, 1.83903486e-01f, 1.95497215e-01f, -1.84698492e-01f, -1.03521474e-01f, 7.07135275e-02f, 5.71240336e-02f, -5.35250194e-02f,
  1.73774287e-01f, -6.12183250e-02f, 8.19702968e-02f, -1.05119891e-01f, -1.64057314e-01f, -5.11733862e-03f, -2.53434390e-01f, -4.36857551e-01f, -1.26101509e-01f, -6.10332005e-02f,
  1.41694248e-01f, 2.88727810e-03f, 3.71330753e-02f, -1.21573389e-01f, -2.90598214e-01f, 7.69793093e-02f, 2.14337051e-01f, 1.84476506e-02f, -8.92849267e-02f, 3.68731618e-02f,
  -4.49214177e-03f, 2.38340832e-02f, 1.73608735e-01f, -7.37425238e-02f, 5.72795570e-02f, 1.69246178e-02f, 5.75060770e-03f, 3.59029770e-01f, 1.16252206e-01f, -1.70865521e-01f,
  2.66733557e-01f, -5.69444954e-01f, -5.59006669e-02f, -6.84785843e-02f, 1.31333172e-02f, 2.23426953e-01f, 1.77651972e-01f, 5.02804101e-01f, -7.62080550e-02f, -5.00574410e-01f,
  -9.38189030e-03f, 3.46855134e-01f, -1.00679301e-01f, -1.35130314e-02f, 3.14305902e-01f, -3.31405282e-01f, 1.73506677e-01f, 4.99287322e-02f, -1.60245240e-01f, 1.30094007e-01f,
  -1.79854468e-01f, -7.51449466e-02f, 2.78451703e-02f, -1.32206976e-01f, -1.38823420e-01f, -1.54896587e-01f, 3.13377798e-01f, 2.22398743e-01f, 1.94728196e-01f, -6.44441172e-02f,
  2.22025827e-01f, 1.07260495e-01f, 2.14746743e-01f, -3.19582447e-02f, -8.13913569e-02f, -1.77868590e-01f, 1.45159960e-01f, 3.04086017e-03f, -6.69554174e-02f, 3.41881812e-02f,
  4.16261964e-02f, -5.76446913e-02f, 1.42301187e-01f, 1.58644289e-01f, -8.37138966e-02f, 3.11218232e-01f, 5.19746840e-02f, 9.56116915e-02f, 2.81261653e-01f, 5.49545772e-02f,
  1.21468149e-01f, 1.34673893e-01f, 8.61387774e-02f, 1.88314229e-01f, 6.61334097e-02f, 2.53963232e-01f, -4.88048568e-02f, 2.99969632e-02f, 1.79416180e-01f, -3.32057923e-02f,
  6.88088387e-02f, 2.73840129e-02f, 9.72562097e-03f, -2.10331395e-01f, 1.68654159e-01f, 2.38593951e-01f, -2.71204531e-01f, 4.27687950e-02f, 3.72738451e-01f, -7.49089643e-02f,
  1.31395698e-01f, 1.19568609e-01f, -9.69377160e-02f, -2.58597672e-01f, 2.08513454e-01f, 2.86450982e-01f, 1.24532230e-01f, 1.96206480e-01f, 3.45021009e-01f, -6.69659227e-02f,
  -3.54481488e-02f, 2.40146995e-01f, 8.49667192e-02f, -6.87174723e-02f, 1.93818301e-01f, -5.68394251e-02f, 6.82800710e-02f, -2.29540870e-01f, -2.04750896e-02f, -3.05205077e-01f,
  2.68747956e-01f, 3.61548886e-02f, 4.76634838e-02f, -1.27071902e-01f, 2.28490397e-01f, -1.92067340e-01f, 1.25743132e-02f, -6.87659085e-02f, 1.09728873e-01f, -8.06986690e-02f,
  5.45013919e-02f, -7.14273006e-02f, -1.04076685e-02f, 8.29847157e-02f, -3.77890803e-02f, 1.13332510e-01f, -1.58448800e-01f, 2.23256871e-02f, -1.05200499e-01f, 1.23191684e-01f,
  -2.54542947e-01f, 1.84840724e-01f, 7.06085116e-02f, 1.61198247e-02f, 2.17387736e-01f, 5.90442270e-02f, 1.89527795e-01f, -4.72576469e-02f, 5.95144182e-03f, 2.48316050e-01f,
  7.82660767e-02f, -4.55829762e-02f, 9.01794061e-02f, 1.76979959e-01f, 2.64289230e-01f, 5.75431883e-02f, -1.68059558e-01f, -4.43908364e-01f, -2.49946952e-01f, 1.59129664e-01f,
  -3.76350582e-02f, 2.88318813e-01f, -2.39711925e-01f, -9.93661433e-02f, 1.25446305e-01f, -3.41985226e-02f, 7.02877119e-02f, -7.92376325e-02f, 1.25796080e-01f, -7.23833963e-02f,
  1.96883529e-02f, 8.26494396e-02f, 2.59157002e-01f, -1.19887225e-01f, -1.67588130e-01f, 6.48936583e-03f, -2.99402699e-03f, -3.65794040e-02f, 3.36365014e-01f, 2.19443932e-01f,
  -1.97102845e-01f, -1.14982715e-02f, 6.10506535e-02f, 3.17912370e-01f, 2.39305988e-01f, -2.99774587e-01f, 8.58564973e-02f, -8.05774257e-02f, 3.62049103e-01f, -1.27583191e-01f,
  1.78666711e-01f, 3.25536698e-01f, 2.02773809e-01f, 4.44210917e-02f, 3.86795141e-02f, -5.92868663e-02f, 1.46934509e-01f, 7.18184337e-02f, -2.30107866e-02f, -4.47346084e-02f,
  -5.60543835e-02f, -1.16190396e-03f, 1.56493664e-01f, -7.23822089e-03f, 1.55284122e-01f, 2.03907520e-01f, 2.25513309e-01f, -1.27841800e-01f, 6.35638013e-02f, -2.31701881e-01f,
  -1.34355322e-01f, -1.72687485e-03f, 3.35368551e-02f, 6.22927807e-02f, -5.67490235e-02f, 1.60634145e-01f, 7.17481598e-02f, 1.73958942e-01f, -1.46061286e-01f, 1.61543891e-01f,
  1.40090078e-01f, -1.12851307e-01f, -2.20377386e-01f, -2.77823567e-01f, 7.58259818e-02f, 6.50792345e-02f, -5.86816519e-02f, 1.13324426e-01f, -2.28650555e-01f, -5.63303567e-02f,
  2.38737926e-01f, 1.17883794e-01f, -1.99023843e-01f, -1.72486946e-01f, 7.69593492e-02f, 3.03009916e-02f, 1.30230159e-01f, 1.17555276e-01f, 2.89782077e-01f, 1.43694729e-01f,
  -2.09775791e-02f, -1.70216918e-01f, 5.86462505e-02f, 1.19989932e-01f, -1.44024119e-01f, 2.22103707e-02f, -1.95678622e-01f, 2.44805768e-01f, -1.46474808e-01f, 2.15453237e-01f,
  1.32121965e-01f, 1.29369438e-01f, 2.48580664e-01f, 3.88071865e-01f, 1.06354179e-02f, -1.29028913e-02f, 9.38399881e-03f, -3.22975926e-02f, 1.94453076e-03f, 3.05910885e-01f,
  9.28177387e-02f, 1.21848024e-01f, -1.29937455e-01f, -8.93499330e-02f, 3.23448211e-01f, -9.98427421e-02f, 6.74808323e-02f, 3.05442661e-01f, 4.96285111e-01f, 5.65082282e-02f,
  3.23623121e-02f, 1.28218263e-01f, -4.79278117e-02f, 1.71482116e-01f, 2.11615503e-01f, 1.66215152e-01f, 3.04937344e-02f, 1.69851199e-01f, 2.05479339e-02f, 1.03974469e-01f,
  4.95476909e-02f, 7.02845380e-02f, 1.50448486e-01f, -5.84622063e-02f, 2.68307269e-01f, 1.37201115e-01f, -9.07418430e-02f, 2.96132594e-01f, 3.54065895e-01f, -3.20999235e-01f,
  1.77796796e-01f, -1.83531493e-01f, -6.14302978e-02f, -1.39583990e-01f, -2.37983726e-02f, 2.97516346e-01f, -1.22052282e-01f, 2.32004061e-01f, 1.53502539e-01f, 2.13440973e-03f,
  -5.73098287e-02f, 1.75828502e-01f, 2.99414188e-01f, -1.12682216e-01f, 9.92406979e-02f, 1.19422361e-01f, 2.67267544e-02f, -1.27357483e-01f, 4.12820727e-02f, 1.52971163e-01f,
  3.18171561e-01f, 8.35009590e-02f, 1.11859791e-01f, 1.08092591e-01f, -1.61738411e-01f, 2.95226812e-01f, 2.32101902e-02f, -1.76898092e-01f, 1.91123709e-01f, 1.12894259e-01f,
  1.75691634e-01f, -9.28749591e-02f, 9.83541980e-02f, -2.89819360e-01f, -1.68223992e-01f, 2.06552207e-01f, 9.21934471e-02f, 2.04341799e-01f, 8.73001739e-02f, 2.70897478e-01f,
  -6.82365596e-02f, 8.89735073e-02f, 8.00163001e-02f, -1.09542549e-01f, -2.14964338e-02f, 2.64173478e-01f, 9.39768329e-02f, 1.71793014e-01f, 7.11235628e-02f, 2.75659949e-01f,
  5.02055548e-02f, 1.05585232e-01f, 3.40516120e-02f, 2.22398564e-01f, -2.51917988e-02f, -9.89298597e-02f, 6.85173497e-02f, -3.35671693e-01f, -5.32414243e-02f, 1.27794042e-01f,
  9.90399718e-02f, 2.51713842e-01f, -1.43886609e-02f, 2.19601262e-02f, 3.04816335e-01f, -1.47318244e-01f, 8.89305323e-02f, -6.67862147e-02f, 1.36369482e-01f, 1.10642850e-01f,
  -6.00347817e-02f, 2.43594095e-01f, 2.14680448e-01f, 3.34460616e-01f, 1.78217605e-01f, 7.04994947e-02f, -1.20500855e-01f, 2.15231150e-01f, -2.28142932e-01f, -1.74911432e-02f,
  2.90107816e-01f, 5.25512621e-02f, -3.44196446e-02f, -3.64445671e-02f, -1.65933236e-01f, -1.34305013e-02f, -9.23056751e-02f, -3.94292027e-02f, 1.21521307e-02f, -2.92993151e-02f,
  4.12186235e-02f, -3.60475004e-01f, 2.32623726e-01f, -3.37266959e-02f, 2.14564264e-01f, 7.80864209e-02f, -8.65091980e-02f, -2.91027963e-01f, -1.00074045e-01f, -1.54585727e-02f,
  2.10972235e-01f, 2.38810733e-01f, 3.67926136e-02f, -5.92683591e-02f, -5.12233637e-02f, -5.83154522e-02f, 1.74892351e-01f, 2.16895312e-01f, -8.47423375e-02f, 2.21849635e-01f,
  -4.89694215e-02f, 6.80509210e-02f, 2.21711516e-01f, -2.36822918e-01f, -1.74753606e-01f, 1.62423119e-01f, -4.91470471e-02f, 5.65511622e-02f, 1.39502287e-01f, 2.31448580e-02f,
  1.61023840e-01f, -3.84951502e-01f, -3.24958959e-03f, 1.63370650e-02f, -2.09970459e-01f, 4.21824723e-01f, 2.11809650e-02f, -2.25434024e-02f, -1.75588936e-01f, -2.81676620e-01f,
  -1.28407165e-01f, 1.10549219e-01f, 1.08323731e-01f, 4.59395982e-02f, 6.29513040e-02f, -8.42383578e-02f, 1.00685634e-01f, 2.23158859e-02f, 1.12016752e-01f, 2.10383609e-01f,
  -2.17633650e-01f, 6.33405074e-02f, -8.96655023e-02f, 8.74229148e-03f, 1.59677058e-01f, 1.42705113e-01f, -7.43663311e-02f, 2.60781914e-01f, -4.58233356e-02f, -6.54482692e-02f,
  -3.25511955e-02f, -2.57877588e-01f, -7.36649707e-02f, -2.10724138e-02f, -1.20137952e-01f, -1.90792426e-01f, -2.71751126e-03f, -4.19063270e-02f, -7.77943730e-02f, 2.56260425e-01f,
  1.90453842e-01f, -6.50794059e-02f, 2.71315426e-01f, 1.96285471e-01f, 3.15347849e-03f, -3.13909650e-02f, -5.35978414e-02f, 6.74574450e-02f, -8.27331915e-02f, -3.49840671e-01f,
  -1.21625461e-01f, 2.45227739e-01f, -2.70732611e-01f, -1.49996663e-02f, 2.11240016e-02f, -1.99660853e-01f, 7.49359429e-02f, -1.08697139e-01f, 2.11665854e-01f, -3.55283916e-02f,
  -1.31879345e-01f, -1.54705094e-02f, -3.14374745e-01f, -1.19883746e-01f, -1.28956869e-01f, 2.04752505e-01f, -7.16433898e-02f, -3.17908764e-01f, 9.67438892e-02f, -2.29526535e-02f,
  -1.29986376e-01f, 1.32946149e-01f, 1.21265929e-02f, 1.41254410e-01f, 2.49409631e-01f, -1.48624554e-01f, 2.26687536e-01f, -3.43216211e-02f, 2.36365691e-01f, -1.25917271e-01f,
  2.20200986e-01f, 9.56971645e-02f, -1.98269039e-01f, -2.98786480e-02f, 5.25488779e-02f, 5.81486598e-02f, 1.23160027e-01f, 8.12128037e-02f, 2.05911994e-01f, -1.05456859e-02f,
  1.03548504e-02f, -2.96988666e-01f, -5.95679171e-02f, 5.50891720e-02f, 1.42501429e-01f, -1.57423973e-01f, -3.63209541e-03f, -8.74822866e-03f, 4.69150424e-01f, -9.13195610e-02f,
  -2.55137235e-02f, 1.92715466e-01f, 2.89250910e-01f, -9.68700498e-02f, -2.44563088e-01f, 6.99448884e-02f, 1.57242462e-01f, -2.80166149e-01f, -9.74560305e-02f, -2.16634981e-02f,
  -2.64902413e-01f, -2.30442196e-01f, -5.83258606e-02f, 5.21235764e-02f, 6.82498440e-02f, -1.98616281e-01f, 2.89892316e-01f, -1.01057872e-01f, -4.81589995e-02f, 1.33609939e-02f,
  1.25993967e-01f, -1.30918071e-01f, 2.00033247e-01f, 2.57966015e-02f, 4.03071903e-02f, 1.48175567e-01f, 5.90363108e-02f, 3.26518230e-02f, -2.34674647e-01f, 2.08818074e-02f,
  -1.53711632e-01f, -1.49437711e-01f, 1.94451049e-01f, -4.34209645e-01f, 1.06586888e-02f, 4.36810583e-01f, 1.13739617e-01f, 2.63861060e-01f, 2.70196825e-01f, -3.19537073e-01f,
  2.66880095e-01f, 1.85226679e-01f, 5.51457517e-02f, 7.50441179e-02f, 2.22666442e-01f, -2.74725646e-01f, -7.51766609e-03f, 8.68269950e-02f, -2.63705701e-01f, 3.77998687e-02f,
  -2.34238073e-01f, 1.60991788e-01f, -1.54404193e-01f, 1.19315051e-01f, -2.81110983e-02f, -1.03864662e-01f, 2.60159280e-02f, -6.38207868e-02f, 1.13808056e-02f, -3.94545533e-02f,
  7.30830655e-02f, 2.43038073e-01f, -4.86422330e-02f, -2.59861022e-01f, 1.77859053e-01f, 1.68856621e-01f, 2.65685409e-01f, 3.15910690e-02f, -1.93702370e-01f, -9.89724696e-02f,
  -8.27893913e-02f, -1.05874240e-01f, 3.24072421e-01f, 1.85552329e-01f, -1.67360425e-01f, -1.04796834e-01f, 1.47014573e-01f, -1.10499291e-02f, -9.73557234e-02f, -2.36230120e-01f,
  1.09828137e-01f, 1.63543165e-01f, 2.17255414e-01f, 1.74466282e-01f, -1.02712261e-02f, 1.83121741e-01f, 1.27130538e-01f, 2.85615057e-01f, 4.13061529e-02f, 7.61895478e-02f,
  3.22740823e-01f, 7.64996707e-02f, 1.31953463e-01f, -8.24230760e-02f, 4.14765656e-01f, 2.97425576e-02f, -9.48971808e-02f, 9.66334566e-02f, -6.34059235e-02f, -7.45527074e-02f,
  2.68603325e-01f, 1.63648501e-01f, -1.01219593e-02f, 1.30008087e-01f, 1.12284236e-01f, 9.32861045e-02f, -1.85901716e-01f, 3.02285671e-01f, 2.02838168e-01f, 2.30035126e-01f,
  3.14975560e-01f, 9.54227224e-02f, 5.26349135e-02f, -3.22681107e-02f, -1.26538366e-01f, 1.20325744e-01f, 1.13359258e-01f, -3.31140161e-02f, 2.17418581e-01f, -1.51781693e-01f,
  -2.43993863e-01f, -3.10291708e-01f, -9.11520645e-02f, 2.28357181e-01f, -1.62401453e-01f, -1.30899027e-01f, -1.47466421e-01f, -5.89112580e-01f, 2.81632274e-01f, -1.09908141e-01f,
  4.46279570e-02f, -6.01806585e-03f, 4.93138358e-02f, 1.80785488e-02f, -6.16745912e-02f, 1.06515370e-01f, 2.56346613e-01f, 1.11207910e-01f, 2.14097068e-01f, 2.34476656e-01f,
  -2.23578021e-01f, -9.94122103e-02f, -1.46921292e-01f, 3.72133940e-01f, -1.54281154e-01f, 1.37494355e-01f, -1.19814344e-01f, -1.33685067e-01f, -1.20235961e-02f, -1.44196808e-01f,
  1.18547909e-01f, -3.44429582e-01f, -3.34116332e-02f, 1.59156948e-01f, -5.11016473e-02f, 2.29072243e-01f, -2.10600212e-01f, 2.17757657e-01f, -1.14651330e-01f, 1.49970755e-01f,
  9.95271057e-02f, -4.05680090e-01f, 2.05381438e-01f, -8.09050202e-02f, -4.31258939e-02f, 2.94407099e-01f, 1.01233004e-02f, 2.53368855e-01f, -1.07719116e-02f, 7.27972463e-02f,
  -1.61612604e-03f, -2.33725056e-01f, -5.45102172e-02f, -2.38777220e-01f, 3.57246175e-02f, -1.46027440e-02f, 2.98251212e-01f, 1.01702496e-01f, -1.81323305e-01f, -6.99063614e-02f,
  -3.39748919e-01f, 2.44473010e-01f, 1.12953871e-01f, 2.46693730e-01f, 3.06548551e-02f, 1.20349288e-01f, 4.05561179e-02f, 4.78266552e-02f, 1.81511670e-01f, 2.13524029e-02f,
  -7.85173774e-02f, 5.96278191e-01f, -2.62948781e-01f, 2.94830687e-02f, -6.15856089e-02f, 5.39484993e-02f, 2.72967041e-01f, 2.66037434e-01f, 6.88036904e-02f, 5.23269698e-02f,
  -1.60210177e-01f, -1.83687955e-01f, 2.69716859e-01f, -3.44686881e-02f, 2.02857420e-01f, 2.91511923e-01f, 1.51765913e-01f, -3.72602105e-01f, 1.96573943e-01f, 2.64048260e-02f,
  1.63419843e-01f, 1.44031659e-01f, 2.13788643e-01f, 6.03738725e-02f, -1.31686945e-02f, 1.23354115e-01f, 1.78209633e-01f, -8.09578821e-02f, -2.21123453e-02f, 7.46847689e-02f,
  3.22580218e-01f, -5.74200191e-02f, -3.91451627e-01f, -1.05142541e-01f, -2.40657225e-01f, 4.46599722e-01f, -1.63751572e-01f, 1.71585381e-01f, -3.55745628e-02f, -2.66311526e-01f,
  2.93975532e-01f, -1.74774244e-01f, 2.38201469e-01f, 1.99088112e-01f, 3.15906197e-01f, -2.32883230e-01f, -1.67790931e-02f, -9.04063955e-02f, 2.97428276e-02f, 2.66232789e-01f,
  -3.17049712e-01f, 1.11130871e-01f, 2.09467798e-01f, -8.80971700e-02f, 2.08057493e-01f, 7.91387632e-02f, -2.02873107e-02f, 5.53130247e-02f, 2.55962640e-01f, 1.14644073e-01f,
  -7.49707520e-02f, -2.65834719e-01f, -2.21854478e-01f, 1.91700578e-01f, 4.04106140e-01f, -2.56784022e-01f, 2.72319093e-02f, 1.69917285e-01f, 1.94994345e-01f, 1.81039006e-01f,
  5.91466948e-02f, -6.78336471e-02f, 2.25322708e-01f, 1.11590371e-01f, -7.08061308e-02f, 1.27682149e-01f, -2.85980284e-01f, 7.80396014e-02f, 2.65970498e-01f, -6.59750104e-02f,
  -1.41092613e-01f, 1.53003126e-01f, 2.08916470e-01f, -1.56756043e-01f, 9.71993208e-02f, 1.95266062e-03f, 9.03768539e-02f, -8.85411575e-02f, 1.43202934e-02f, -1.36520103e-01f,
  -3.73038799e-02f, 2.27090403e-01f, -2.79380847e-02f, 4.99780923e-02f, -1.36131223e-03f, 2.08817884e-01f, 1.11367553e-02f, 2.49638017e-02f, -2.58318841e-01f, -2.23650157e-01f,
  2.90732514e-02f, 1.72320172e-01f, -1.63119927e-01f, 4.97077554e-02f, 1.59101132e-02f, -2.55205370e-02f, 1.16340965e-01f, -2.44680151e-01f, -3.03554330e-02f, -1.32163346e-01f,
  -1.37742370e-01f, 2.27063727e-02f, 1.33053169e-01f, -1.78835675e-01f, 9.47265476e-02f, 1.87614948e-01f, -2.59455115e-01f, -1.09326623e-01f, 1.75817143e-02f, 2.67046720e-01f,
  2.95184255e-02f, 1.81129381e-01f, -6.91152215e-02f, 1.03398301e-01f, -1.93447784e-01f, -1.81243658e-01f, 6.48839772e-02f, -1.71534538e-01f, 5.73836230e-02f, 5.22568464e-01f,
  -1.21771775e-01f, 7.64335245e-02f, -6.23797029e-02f, 2.58967429e-01f, -7.52494708e-02f, 2.85835028e-01f, 1.89845264e-01f, 2.06715807e-01f, -2.28391796e-01f, -5.04880548e-02f,
  2.25319386e-01f, 3.52932550e-02f, 9.82185230e-02f, 1.44861937e-01f, 2.90920228e-01f, -8.94171894e-02f, -1.99285865e-01f, 1.61083415e-01f, 2.57715166e-01f, 1.87764075e-02f,
  1.15008026e-01f, 4.08327803e-02f, -1.71737850e-01f, -8.42242613e-02f, 2.12467685e-01f, -6.97947294e-02f, -1.76099807e-01f, 1.72343954e-01f, 1.11279935e-01f, 3.85792762e-01f,
  -2.56255031e-01f, 9.70827937e-02f, -3.50106835e-01f, -2.46403322e-01f, 2.11178347e-01f, 1.29783321e-02f, -4.32283729e-01f, -3.46483797e-01f, 2.45002331e-04f, 1.99216127e-01f,
  9.97409970e-02f, -9.05012190e-02f, -3.03616021e-02f, -2.66875148e-01f, -2.29207188e-01f, -1.40103415e-01f, -7.17761964e-02f, -4.82094288e-03f, 2.36601569e-02f, 6.76388517e-02f,
  2.81349152e-01f, -5.25928997e-02f, -1.04253069e-01f, 1.64755583e-02f, -1.29610047e-01f, 3.73006284e-01f, 1.35826081e-01f, 1.98102430e-01f, 2.46002167e-01f, -3.72316569e-01f,
  6.21843338e-02f, 2.95079529e-01f, 1.18953109e-01f, 1.89100116e-01f, 1.33683637e-01f, 2.83510983e-01f, 4.41463590e-02f, 3.32171023e-02f, 3.07212144e-01f, -2.03463361e-01f,
  8.99461284e-02f, 1.54508561e-01f, 9.61303618e-03f, -2.12801859e-01f, -8.65023285e-02f, 2.63937294e-01f, 1.19200461e-01f, -4.69661281e-02f, 2.54263431e-01f, -5.11648767e-02f,
  2.05423281e-01f, -3.34091097e-01f, 2.15789795e-01f, 4.89344373e-02f, 3.54561657e-01f, 2.43960395e-01f, 4.81127910e-02f, 3.13457102e-01f, -1.51379257e-01f, 1.25768438e-01f,
  7.58363828e-02f, -7.71285817e-02f, 2.90386885e-01f, -2.58547843e-01f, -1.79976925e-01f, -7.67562240e-02f, -3.53882074e-01f, 3.20678622e-01f, -2.11490020e-01f, 1.38688302e-02f,
  8.14180076e-02f, -3.28505039e-01f, 1.04781641e-02f, -3.57990086e-01f, 2.09617823e-01f, 6.45992383e-02f, 2.74002235e-02f, -7.35475048e-02f, -5.99269420e-02f, 3.55930001e-01f,
  1.29166007e-01f, 1.57667890e-01f, 1.79450557e-01f, 6.60044998e-02f, -2.45812178e-01f, -3.37751508e-01f, 4.54026937e-01f, -2.53285002e-02f, 8.19782726e-03f, 6.85098544e-02f,
  -4.02473032e-01f, -1.57339081e-01f, -4.35256287e-02f, -1.89755738e-01f, -2.81306446e-01f, 8.40312988e-02f, 2.74672747e-01f, 1.17997967e-01f, -1.28582552e-01f, 5.22462167e-02f,
  7.87149966e-02f, 1.26760989e-01f, 8.92432258e-02f, 1.10847175e-01f, 2.31600091e-01f, 1.82397053e-01f, -1.62731528e-01f, 1.54778898e-01f, 7.29323328e-02f, -5.88506795e-02f,
  -4.20008115e-02f, -2.50308551e-02f, -8.67191926e-02f, 2.52321213e-01f, -4.50616740e-02f, 4.14018184e-02f, 4.20325659e-02f, 1.92941561e-01f, -1.67670415e-03f, -2.55259238e-02f,
  -7.27213174e-02f, 1.28926756e-02f, -6.72623664e-02f, 2.36417856e-02f, 2.99443305e-01f, 1.13707781e-01f, -7.34290853e-02f, -3.13371956e-01f, -1.06574789e-01f, 1.59961313e-01f,
  -7.82754570e-02f, 2.56627709e-01f, 2.00999692e-01f, 2.48601660e-02f, 2.14513749e-01f, -1.92236468e-01f, 1.48202360e-01f, 5.27741350e-02f, 3.93491536e-02f, -1.16148919e-01f,
  1.32949606e-01f, 1.08608454e-01f, 1.45184919e-01f, 1.66309953e-01f, 5.77043369e-02f, 6.74322546e-02f, -1.87677890e-01f, 2.32839093e-01f, -3.17496806e-01f, -8.55169594e-02f,
  1.50972635e-01f, 3.08889568e-01f, 1.71731412e-01f, 2.72973254e-02f, 7.46062957e-03f, 1.14903010e-01f, -2.19067797e-01f, -2.50501186e-01f, 2.46775568e-01f, -2.93618470e-01f,
  -1.47580519e-01f, 1.57271530e-02f, -5.80926649e-02f, 6.73094252e-03f, 3.78231592e-02f, 1.58424258e-01f, 7.71420524e-02f, 9.73796099e-02f, -2.92146299e-02f, 1.73333973e-01f,
  5.61823249e-02f, 2.99773570e-02f, 6.12441748e-02f, -2.03444306e-02f, -1.96592323e-02f, -1.39727369e-01f, 1.68954417e-01f, 1.82587698e-01f, -3.88252527e-01f, 2.07498595e-01f,
  2.15026904e-02f, 3.56876738e-02f, 1.79740116e-01f, 1.36835268e-02f, 3.30447823e-01f, 1.45387709e-01f, -3.76259163e-02f, 2.72470355e-01f, 5.23949713e-02f, 2.53947288e-01f,
  4.04241800e-01f, -7.15404674e-02f, 3.36809218e-01f, 1.26053765e-01f, -4.04827505e-01f, 2.81860322e-01f, 2.44965255e-02f, -3.03145111e-01f, 1.21658042e-01f, -1.43494949e-01f,
  -1.01092830e-01f, -8.81535709e-02f, 6.08725101e-02f, 4.24142659e-01f, -1.01773068e-01f, -6.69272691e-02f, 8.05392414e-02f, 1.32570609e-01f, 1.41881913e-01f, 2.15568468e-01f,
  4.44171935e-01f, -3.78615945e-03f, 5.32564241e-03f, -3.20330560e-01f, 2.08432406e-01f, -2.60794491e-01f, -4.85509373e-02f, 2.45047212e-01f, -6.26445264e-02f, 2.55525596e-02f,
  1.57517865e-01f, -1.69355899e-01f, -3.00976664e-01f, 2.93360531e-01f, 6.57767951e-02f, 2.00206473e-01f, -4.19299752e-02f, 4.27739136e-02f, -9.38218534e-02f, -9.19034928e-02f,
  3.62551898e-01f, -4.67553847e-02f, 1.81555539e-01f, 9.32985991e-02f, -1.27761260e-01f, 7.58850388e-03f, 2.76737005e-01f, 1.56449899e-01f, 7.50190988e-02f, 8.71704519e-02f,
  1.37990460e-01f, 2.83080071e-01f, 3.77455801e-02f, 3.62053663e-02f, -1.06189921e-02f, 3.30704264e-02f, -2.37576943e-03f, 1.32537857e-02f, 1.45508498e-01f, 2.19129622e-01f,
  -8.97245929e-02f, 2.60539018e-02f, 2.36506134e-01f, 1.48356184e-01f, 2.12670974e-02f, -1.72079161e-01f, -3.82226110e-02f, -8.31278488e-02f, -3.20551962e-01f, 3.83122176e-01f,
  2.87627816e-01f, -5.79367839e-02f, -5.08205667e-02f, -9.52162221e-02f, 5.86651228e-02f, -2.61624396e-01f, 2.28565440e-01f, 3.26274395e-01f, 3.56663354e-02f, -5.63190952e-02f,
  1.36141434e-01f, 1.97686955e-01f, 3.88046391e-02f, 1.53660089e-01f, 1.72877967e-01f, 1.15231983e-01f, -1.87685460e-01f, -1.36184797e-01f, 1.91445604e-01f, 2.57250696e-01f,
  1.51924655e-01f, 3.14640164e-01f, 2.37151906e-02f, 1.43277228e-01f, -8.51522312e-02f, -6.93208575e-02f, -9.61994231e-02f, -7.56872632e-03f, -9.80729237e-02f, 1.94436461e-01f,
  -1.28749060e-02f, 2.04358082e-02f, 1.45560861e-01f, 2.24706873e-01f, -5.54902405e-02f, 7.84247667e-02f, -6.37748241e-02f, 4.72766683e-02f, 1.39424205e-01f, 4.43411060e-02f,
  1.56488091e-01f, -1.10678658e-01f, 1.25767529e-01f, -2.22809091e-01f, 4.14849609e-01f, 2.81339921e-02f, -2.74030596e-01f, 1.73248529e-01f, 1.46179259e-01f, 2.39919230e-01f,
  3.90428491e-02f, 2.47417673e-01f, -2.09747553e-01f, 1.46260932e-01f, 4.11356539e-02f, 4.80599925e-02f, -2.87800692e-02f, -7.48474076e-02f, 1.52904868e-01f, -1.15300208e-01f,
  -1.86707899e-02f, -1.07552595e-01f, -1.49381056e-01f, 3.21381748e-01f, -4.87108618e-01f, -2.10019678e-01f, -5.78791555e-03f, -1.14841729e-01f, -3.28363478e-01f, 2.95335919e-01f,
  -2.00829625e-01f, -1.99163646e-01f, 2.07904633e-02f, 8.12122133e-03f, -1.70503199e-01f, 4.62411225e-01f, 1.88564569e-01f, -2.37944704e-02f, 2.46603832e-01f, 2.50336677e-01f,
  -9.13888291e-02f, -1.42278746e-01f, 3.09733003e-01f, 1.88814238e-01f, -2.19987690e-01f, -3.05195093e-01f, -2.07267702e-01f, -5.66168651e-02f, 2.73077071e-01f, 1.09916842e-02f,
  -1.80939790e-02f, -1.65993363e-01f, 5.17827749e-01f, -1.38074541e-02f, -1.50988996e-01f, 5.24359904e-02f, 1.91065922e-01f, 7.36348564e-03f, -2.27506086e-02f, 8.21879730e-02f,
  1.75439268e-01f, 1.89025998e-01f, -2.38199100e-01f, -1.37863755e-01f, 6.88387901e-02f, 1.24860056e-01f, -6.38688356e-02f, 2.55359650e-01f, -7.35616609e-02f, 7.98341483e-02f,
  1.12778552e-01f, -3.92182022e-01f, 2.39559039e-01f, 1.55640036e-01f, 2.23702997e-01f, 1.13450393e-01f, 1.79372907e-01f, 6.87121227e-02f, 1.82663456e-01f, -1.34647563e-01f,
  1.19594045e-01f, 5.14981151e-02f, 2.19537809e-01f, 2.21169829e-01f, -4.70282584e-02f, -2.04832882e-01f, 1.97739840e-01f, -4.73398298e-01f, -1.42245173e-01f, 2.12516472e-01f,
  -1.58609152e-01f, -8.54685977e-02f, -6.56116114e-04f, 3.64195377e-01f, 4.30122837e-02f, -2.12566584e-01f, 3.09787750e-01f, -1.61692411e-01f, 1.33446753e-01f, -2.32582435e-01f,
  8.43452737e-02f, -1.91009790e-01f, -1.27317935e-01f, 2.91535854e-02f, 2.22076382e-02f, 2.10584819e-01f, 1.66969582e-01f, -7.53403008e-02f, -1.81150287e-02f, 1.37625560e-01f,
  9.47437733e-02f, -3.01378012e-01f, 3.20785165e-01f, -2.81105228e-02f, -4.15870249e-02f, 2.57852614e-01f, 2.54618973e-01f, 1.62139639e-01f, 1.59999833e-01f, 1.48801491e-01f,
  6.32237345e-02f, 1.37805849e-01f, 2.72834096e-02f, 4.07722563e-01f, 2.75276363e-01f, -8.43884796e-02f, -7.02265799e-02f, -2.66468115e-02f, -1.95957556e-01f, 1.14218041e-01f,
  7.57946223e-02f, 2.43631557e-01f, -2.58000493e-01f, 4.38852981e-02f, 2.73806483e-01f, 1.29952461e-01f, 6.64709136e-02f, 2.14581400e-01f, -1.04310282e-01f, 1.08929977e-01f,
  -8.19593519e-02f, 8.76600221e-02f, 2.07392812e-01f, 2.05965698e-01f, 9.41564441e-02f, 2.68650115e-01f, 1.51158825e-01f, 1.55590013e-01f, 2.62858480e-01f, 2.44885221e-01f,
  -9.78759155e-02f, -9.37341452e-02f, 1.94916166e-02f, -1.19806424e-01f, 9.67574492e-02f, -8.39451626e-02f, -4.80731018e-02f, 1.71500310e-01f, -1.18871048e-01f, 4.07748558e-02f,
  -1.55419722e-01f, 2.00588152e-01f, -1.45480642e-03f, 7.80845899e-03f, 1.91220999e-01f, 3.42235416e-02f, 1.40180528e-01f, -1.96659073e-01f, 1.65984221e-02f, 2.97405454e-03f,
  1.36504369e-02f, -3.76029164e-02f, 5.22706918e-02f, 2.12586671e-03f, 9.27854031e-02f, 4.26329207e-03f, 1.32604748e-01f, 1.84849754e-01f, -6.06898516e-02f, 2.46287465e-01f,
  -6.53369352e-02f, -2.34572843e-01f, 2.37003967e-01f, -1.51297655e-02f, -3.01942676e-01f, 1.10032506e-01f, 1.87929928e-01f, -4.53818291e-02f, -7.55431652e-02f, 2.73389012e-01f,
  1.34513527e-01f, 6.32029865e-03f, 2.21423194e-01f, 3.42613369e-01f, -3.79166119e-02f, -3.39989848e-02f, 1.47532597e-01f, 2.58955121e-01f, 1.15930755e-02f, 1.60922110e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  8.73070061e-02f, 2.48888601e-02f, -3.95250991e-02f, 1.19912416e-01f, 2.54943222e-02f, 9.27622244e-02f, 1.80697039e-01f, -2.52347756e-02f, 1.92810714e-01f, 5.24356812e-02f,
  -7.44643211e-02f, 3.89613621e-02f, -4.83257920e-02f, 1.48772895e-01f, 8.80933106e-02f, -6.04732744e-02f, 1.15917936e-01f, 4.83820140e-02f, 2.00356282e-02f, 1.44656524e-01f,
  3.85023914e-02f, 1.73979133e-01f, -8.23854506e-02f, 5.33128902e-03f, 4.61014099e-02f, 1.35415256e-01f, -2.11064629e-02f, -9.32341721e-03f, 4.30492237e-02f, -5.50873354e-02f,
  8.73942077e-02f, 1.99447237e-02f, 1.44319773e-01f, -1.63547043e-02f, -7.39543512e-02f, 1.97686930e-03f, 8.93127918e-02f, -8.02772120e-02f, 1.06484786e-01f, 8.03758800e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.47338584e-01f, -2.88399547e-01f, -1.61650166e-01f, -1.66891918e-01f, -1.63350090e-01f, 4.61640581e-03f, -5.58280945e-02f, -1.96937084e-01f, 4.25837785e-02f, -4.15625572e-01f,
  8.46195780e-03f, -3.30714494e-01f, -4.91893254e-02f, -1.86749652e-01f, -3.90999485e-03f, -1.83440074e-01f, 1.50474280e-01f, 3.62097323e-02f, -9.30077508e-02f, -2.00284198e-02f,
  -1.89724371e-01f, 4.91346717e-02f, -1.94534764e-01f, -8.12541842e-02f, -3.80319774e-01f, 8.28426257e-02f, -4.82838511e-01f, 1.57239586e-01f, 1.49047345e-01f, 1.68752238e-01f,
  -7.44993761e-02f, -3.65042120e-01f, -2.56775141e-01f, 5.49788475e-02f, 9.38237906e-02f, -2.31427372e-01f, -2.74478078e-01f, -4.06930298e-01f, -1.91299275e-01f, -1.20463051e-01f,
  3.59518267e-02f, 1.49637908e-01f, -1.71833396e-01f, -5.02134711e-02f, 2.40168832e-02f, -3.25622499e-01f, -1.30403519e-01f, 1.56599939e-01f, 2.23899946e-01f, -3.73602569e-01f,
  -1.15057267e-02f, 2.16727927e-01f, 1.18899979e-01f, -3.38730693e-01f, -3.31657112e-01f, -2.30653748e-01f, -3.24153006e-01f, -2.75413215e-01f, 1.11449240e-02f, -4.08358395e-01f,
  -3.42584103e-02f, -1.65089965e-01f, -8.25084522e-02f, 1.05427422e-01f, -9.10278335e-02f, -1.94274746e-02f, -1.12113059e-01f, 9.59972758e-03f, 5.12873344e-02f, 1.93038404e-01f,
  -2.34568760e-01f, 1.07487783e-01f, 1.08041257e-01f, 7.14495555e-02f, -1.86415672e-01f, -2.04519227e-01f, -1.63433790e-01f, -4.04969871e-01f, -3.26111391e-02f, 2.99089760e-01f,
  3.80509049e-01f, -1.43292740e-01f, -2.32936163e-02f, 3.53508770e-01f, 3.01040500e-01f, -4.80370261e-02f, -2.74423510e-01f, 5.37717603e-02f, -3.75703156e-01f, -3.63041550e-01f,
  1.50924876e-01f, 1.19648695e-01f, 1.17673516e-01f, 2.75816739e-01f, 1.31207883e-01f, -7.29216114e-02f, -8.86686742e-02f, 2.58319646e-01f, -2.96485066e-01f, -3.03837270e-01f,
  1.97928414e-01f, 1.09723046e-01f, -2.42497221e-01f, 9.66934673e-03f, -2.13786364e-01f, 1.25423476e-01f, -7.02716187e-02f, 4.14198525e-02f, -3.60056106e-03f, 5.04784808e-02f,
  7.54888505e-02f, -2.08440349e-01f, -2.03902870e-01f, -9.52082202e-02f, 1.68147385e-01f, 2.05289721e-01f, -1.80844724e-01f, 1.22588702e-01f, 2.77395248e-02f, 4.99801748e-02f,
  -2.48433016e-02f, -3.55615646e-01f, -4.18952480e-02f, -5.79891145e-01f, -8.01714323e-03f, -2.39057779e-01f, 7.19634220e-02f, -3.43247473e-01f, -1.14468500e-01f, 8.22466016e-02f,
  4.19383310e-02f, 1.67940006e-01f, 1.38986737e-01f, -8.42309594e-02f, 1.02433632e-03f, -2.12323025e-01f, 1.81597650e-01f, 1.19605631e-01f, -8.09281617e-02f, 1.20489985e-01f,
  1.15129024e-01f, 1.26641780e-01f, 8.98669064e-02f, -7.43297786e-02f, 2.31861249e-01f, -4.33954865e-01f, -8.08809996e-02f, -2.71371305e-01f, -2.17811003e-01f, 3.27207625e-01f,
  -2.48475194e-01f, 3.26749742e-01f, 1.29507095e-01f, -7.30580613e-02f, -4.54514652e-01f, 9.21975374e-02f, 2.20383108e-02f, 6.94925487e-02f, -3.09575684e-02f, -7.05319494e-02f,
  1.26210019e-01f, -3.90252359e-02f, 6.91728666e-02f, 8.91814977e-02f, 3.37890536e-01f, 7.45893782e-03f, -2.04322591e-01f, -3.39510322e-01f, -5.00286162e-01f, -1.72308609e-01f,
  -3.74859422e-02f, 3.32710952e-01f, 2.71438211e-01f, 2.58332081e-02f, -4.68021989e-01f, 8.43888372e-02f, 3.89353111e-02f, -3.57300937e-01f, -2.74043512e-02f, 6.32931963e-02f,
  1.63531572e-01f, -2.97759593e-01f, -2.87381947e-01f, -2.22449213e-01f, -1.91073969e-01f, -4.04734790e-01f, -1.25056654e-01f, -5.82306162e-02f, -1.76016599e-01f, -3.20753038e-01f,
  9.91279334e-02f, 1.55881196e-01f, 1.19471941e-02f, -2.41301477e-01f, 1.55394346e-01f, 4.86979745e-02f, -2.89214551e-02f, -1.30980030e-01f, -1.23607382e-01f, -1.53072951e-02f,
  -5.99881150e-02f, -4.54963207e-01f, 3.57657559e-02f, -2.79475659e-01f, 2.08338439e-01f, 1.36516988e-01f, 1.53803557e-01f, 2.78790414e-01f, -2.00465638e-02f, 2.55623341e-01f,
  9.79577899e-02f, -1.87425852e-01f, 1.39804289e-01f, 1.04219511e-01f, 1.84694797e-01f, 1.22773223e-01f, 2.37011552e-01f, 8.62827152e-02f, 1.08502418e-01f, 8.86807963e-02f,
  -3.13180424e-02f, -1.78459078e-01f, -5.08317411e-01f, 5.83022088e-02f, -3.47736806e-01f, -4.52889979e-01f, 7.35495016e-02f, 8.62248465e-02f, -1.45479321e-01f, -1.57877550e-01f,
  7.54483864e-02f, -4.44140702e-01f, 3.65534611e-02f, -2.94472724e-01f, -1.58256799e-01f, 3.95674445e-02f, 6.12574518e-02f, -3.31213623e-01f, 1.28267974e-01f, 2.00386345e-01f,
  -6.13731891e-02f, -1.18828371e-01f, -7.88564757e-02f, -1.47794291e-01f, 2.28772774e-01f, -1.23499066e-01f, -7.48682499e-01f, -1.48917049e-01f, -6.21383965e-01f, -1.52572384e-02f,
  -6.13043196e-02f, 8.19811746e-02f, 3.17508392e-02f, -1.52889624e-01f, -5.19466162e-01f, 2.47460008e-01f, 3.71259488e-02f, 1.89735964e-01f, 1.31220281e-01f, 3.31339836e-02f,
  -1.05497874e-01f, 2.51798362e-01f, 4.64067236e-02f, 1.86293259e-01f, -2.96007127e-01f, 3.48019898e-01f, 6.71705324e-03f, 1.56231135e-01f, -1.74212590e-01f, -1.87238991e-01f,
  -1.81886077e-01f, 7.60419620e-03f, -1.77052647e-01f, 3.39898951e-02f, 2.76433408e-01f, 1.64500162e-01f, -1.65788576e-01f, 3.08912098e-01f, 2.80861050e-01f, 2.02487066e-01f,
  -1.20024554e-01f, 1.09362960e-01f, 1.39071763e-01f, -1.72442552e-02f, 2.68067084e-02f, -2.34992191e-01f, -1.54101262e-02f, -2.83172995e-01f, -3.73610370e-02f, -8.94739553e-02f,
  1.62762433e-01f, -1.06798112e-01f, -1.88079372e-01f, -3.55286330e-01f, -2.65211046e-01f, -4.36829850e-02f, 1.90746009e-01f, -2.55128771e-01f, 2.25945279e-01f, -3.52071404e-01f,
  1.76781863e-01f, -4.01931591e-02f, -2.89088517e-01f, 7.07742423e-02f, 6.54081926e-02f, 1.66141897e-01f, -3.86945486e-01f, -6.68321997e-02f, 7.37578422e-02f, -6.10774234e-02f,
  8.27417597e-02f, -6.40682280e-02f, -1.90679252e-01f, 2.31336877e-01f, 2.49690890e-01f, -6.09979369e-02f, 1.72701418e-01f, -7.34569654e-02f, -2.95514256e-01f, -5.68030253e-02f,
  1.57437369e-03f, 1.89447343e-01f, 2.64202178e-01f, 1.74891964e-01f, 5.29332161e-02f, -1.03976578e-01f, 2.65330344e-01f, -1.09041072e-01f, 1.20260350e-01f, 1.19190672e-02f,
  1.70111880e-01f, 2.30213836e-01f, 2.49265015e-01f, 1.07002653e-01f, -6.09872453e-02f, -1.21948242e-01f, -9.51706469e-02f, -1.19817846e-01f, -1.42040893e-01f, 5.39447740e-02f,
  -1.73912197e-02f, -1.62839934e-01f, -4.37675416e-02f, 1.63585559e-01f, -4.05647188e-01f, -5.56857623e-02f, -2.62852401e-01f, -6.05213530e-02f, 4.12421115e-02f, -5.45765795e-02f,
  1.52022362e-01f, -1.58114061e-01f, -2.00819567e-01f, -1.59644961e-01f, -1.54513091e-01f, 8.96262079e-02f, -1.84582189e-01f, 7.58766383e-02f, -1.60687536e-01f, 2.89707303e-01f,
  -2.79628243e-02f, 1.14270590e-01f, 1.27209321e-01f, -3.10727000e-01f, 1.41654223e-01f, 1.28396645e-01f, 1.24066770e-01f, 5.97590581e-02f, 8.83094892e-02f, -4.38200772e-01f,
  2.91853964e-01f, 8.49527419e-02f, -1.95377454e-01f, -3.03759098e-01f, 2.17229649e-01f, -1.35900661e-01f, -4.33893725e-02f, 2.91118145e-01f, -2.27526203e-01f, 7.15048835e-02f,
  5.24118841e-02f, 5.70449233e-02f, -1.41318202e-01f, -3.56254965e-01f, 2.84411579e-01f, -1.14898644e-01f, -8.55965838e-02f, -7.64474720e-02f, 6.02028519e-02f, 1.06142581e-01f,
  1.83170393e-01f, -8.65478143e-02f, -6.43616468e-02f, 3.56037989e-02f, 8.78063366e-02f, -3.21679175e-01f, -3.34948361e-01f, -1.11984678e-01f, -1.25158861e-01f, 4.30451371e-02f,
  -1.46410272e-01f, 2.23873481e-01f, 5.31813018e-02f, 4.91841398e-02f, 4.52453345e-01f, -7.73290917e-02f, -3.48716140e-01f, -1.93667933e-01f, 9.41745415e-02f, -4.05746251e-01f,
  -1.14548735e-01f, -5.22295535e-01f, -5.05602837e-01f, -2.54019052e-01f, 3.23938057e-02f, 1.65197849e-01f, 3.03991050e-01f, -1.01101242e-01f, -3.62621099e-01f, 2.07169637e-01f,
  -9.78114381e-02f, 2.99717754e-01f, -1.56652078e-01f, -2.94344604e-01f, -2.56742150e-01f, 4.38671634e-02f, 3.72115262e-02f, 1.54441923e-01f, -2.45442316e-02f, 9.35722962e-02f,
  -2.72940636e-01f, -1.68001391e-02f, -5.41257799e-01f, -1.52185842e-01f, -1.08428650e-01f, -2.28999287e-01f, -4.70715255e-01f, -5.58836572e-02f, 2.35952035e-01f, -1.19899049e-01f,
  2.64950335e-01f, -6.02842085e-02f, -5.33453703e-01f, -4.50736322e-02f, -3.62230122e-01f, 9.26742479e-02f, 1.68509737e-01f, 1.33317709e-01f, -3.19904387e-02f, -9.16084126e-02f,
  7.15734288e-02f, 3.08793001e-02f, -2.19953895e-01f, 1.41491562e-01f, -6.23732619e-02f, -1.21953644e-01f, 1.18751697e-01f, 1.82239592e-01f, -1.92256883e-01f, 1.99166611e-01f,
  -3.19038153e-01f, 6.76606521e-02f, -3.74940664e-01f, -1.51616842e-01f, 5.50939813e-02f, -2.23332867e-01f, 1.60953626e-01f, 9.64980349e-02f, 1.14412513e-03f, -1.73170324e-02f,
  -2.20682770e-01f, -2.01283813e-01f, -1.45049915e-01f, -3.23859677e-02f, 2.66677830e-02f, 3.44850905e-02f, -2.62830168e-01f, -3.81488614e-02f, -4.18030739e-01f, 1.06014274e-01f,
  1.09868497e-02f, -1.47040740e-01f, 1.76000029e-01f, -7.96148852e-02f, -1.71026543e-01f, -3.45516354e-01f, 2.62445867e-01f, 7.70393535e-02f, -5.10061800e-01f, -1.66924566e-01f,
  -7.16639087e-02f, 1.09058529e-01f, -4.71180826e-01f, 9.43453163e-02f, 2.28722796e-01f, -4.14449982e-02f, -9.54977572e-02f, -3.78976502e-02f, -7.12441877e-02f, -2.26380348e-01f,
  -3.39961469e-01f, 2.17709467e-01f, -1.91294298e-01f, 2.02195466e-01f, 1.67588338e-01f, -1.10827990e-01f, 1.16317675e-01f, 7.60951415e-02f, 1.57344714e-01f, -1.01807080e-01f,
  -3.57451320e-01f, 7.40612485e-03f, -1.99570283e-02f, -1.92496985e-01f, -4.67668734e-02f, -7.15957657e-02f, 7.68357515e-02f, -2.31767297e-01f, -5.03388792e-02f, -1.16359517e-01f,
  2.39491686e-01f, -1.68092132e-01f, -1.02069834e-02f, 1.79179698e-01f, 3.84411871e-01f, 3.82862717e-01f, 2.52531677e-01f, -1.62598148e-01f, -3.58120859e-01f, -6.02908544e-02f,
  1.56791180e-01f, -4.47402239e-01f, -1.50526315e-01f, -1.05015514e-02f, 4.02776808e-01f, 3.51954103e-02f, -1.97241127e-01f, -7.18802288e-02f, 1.61977395e-01f, 6.23815656e-02f,
  -4.59208339e-01f, 2.04302713e-01f, 3.93771147e-03f, -2.72554964e-01f, -1.94061279e-01f, -3.07938516e-01f, 1.33507920e-03f, -9.20910537e-02f, 1.29439920e-01f, 1.11471295e-01f,
  4.30841774e-01f, 1.05344884e-01f, -3.24174196e-01f, -3.23702604e-01f, -1.18309690e-03f, 3.09862792e-01f, 2.21488222e-01f, 2.54404712e-02f, 2.64008213e-02f, -3.13810796e-01f,
  -2.13414773e-01f, -7.42777944e-01f, 1.53637856e-01f, -3.77120525e-01f, -2.94729650e-01f, 9.08095911e-02f, -1.28920883e-01f, -4.30198088e-02f, -7.03174025e-02f, -3.98684852e-02f,
  -1.12660348e-01f, -2.82291770e-01f, -2.91877002e-01f, 2.50707418e-01f, 1.00664213e-01f, -2.30452061e-01f, 4.95012142e-02f, 2.81702131e-01f, -9.52551365e-02f, -6.77488446e-02f,
  2.33687852e-02f, -5.83006330e-02f, -1.30139500e-01f, 2.85627097e-02f, 3.33815813e-01f, 6.56019896e-02f, 3.06376755e-01f, 2.74612367e-01f, 3.92038137e-01f, 3.29892546e-01f,
  2.67974049e-01f, -4.95483458e-01f, -7.26946145e-02f, 3.59382272e-01f, 2.09074751e-01f, -2.36543328e-01f, -3.99969816e-01f, -2.16939077e-01f, 1.54876858e-01f, -1.92837417e-01f,
  2.22740844e-01f, 1.47916868e-01f, -2.31308490e-01f, -2.81083077e-01f, -2.92523559e-02f, -1.69022948e-01f, -1.55461300e-02f, 2.31660753e-01f, 6.77007884e-02f, 1.28099188e-01f,
  2.14915842e-01f, 2.36194462e-01f, -2.61059225e-01f, -4.82362881e-02f, -2.14454934e-01f, -2.02841222e-01f, -4.99792457e-01f, -4.45554823e-01f, -7.24332452e-01f, -1.83056086e-01f,
  -1.59960195e-01f, 2.79557630e-02f, -4.81974930e-02f, 1.05914824e-01f, -2.00459316e-01f, 1.89364344e-01f, -1.81630611e-01f, -5.51233403e-02f, -9.85565707e-02f, -1.42892540e-01f,
  5.03971986e-02f, -1.39718130e-01f, 3.06762476e-02f, -8.14420506e-02f, -2.69042969e-01f, 1.30998075e-01f, 1.20669752e-01f, -4.78032470e-01f, 5.30440435e-02f, 9.34126228e-02f,
  -2.45170727e-01f, -1.31728530e-01f, -3.49100024e-01f, 7.55543336e-02f, 1.95035692e-02f, 1.12945540e-02f, -2.26215497e-02f, -1.14347478e-02f, -1.61427945e-01f, 2.60678560e-01f,
  -7.73984268e-02f, -3.94195579e-02f, 1.99866593e-01f, 1.67224467e-01f, 7.16924146e-02f, 8.94172266e-02f, -5.71628809e-02f, 2.58403629e-01f, -2.06394996e-02f, 2.72439510e-01f,
  -8.81073326e-02f, 5.93817793e-02f, 2.33298168e-01f, 3.77502330e-02f, 5.99860810e-02f, 1.72905356e-01f, -2.78273553e-01f, 1.57321393e-01f, 1.05144709e-01f, 1.18861690e-01f,
  2.10700393e-01f, -1.96676254e-01f, -2.63219297e-01f, -5.12658894e-01f, -3.20661753e-01f, 4.95847687e-03f, 6.31781702e-04f, 9.19158943e-03f, 2.44142115e-01f, 1.22181870e-01f,
  1.88367143e-01f, 7.31011927e-02f, -3.85096371e-01f, -2.63293624e-01f, -3.36532623e-01f, -3.85456204e-01f, 1.82399362e-01f, -4.82552052e-02f, -5.22250175e-01f, -1.99410632e-01f,
  -3.36340070e-01f, -3.67488176e-01f, -3.11253488e-01f, 3.00188184e-01f, -4.07337546e-01f, 1.94196865e-01f, -3.32736135e-01f, 2.16847792e-01f, -3.52245003e-01f, 2.35801801e-01f,
  -2.66060978e-02f, -1.93297029e-01f, 3.63974236e-02f, -8.24913904e-02f, -2.64131784e-01f, -1.23438284e-01f, -3.19337517e-01f, -1.33826062e-01f, 4.65498902e-02f, -7.18307868e-02f,
  1.50503933e-01f, -7.97951370e-02f, -1.18939184e-01f, -2.70178467e-01f, -1.14228792e-01f, -2.65653729e-01f, -2.66912103e-01f, 1.37261093e-01f, 5.80037907e-02f, 9.39602926e-02f,
  1.20039746e-01f, -3.01277608e-01f, -9.73248631e-02f, -1.18314780e-01f, 1.07231326e-01f, 1.86322276e-02f, 3.03588688e-01f, -1.42064571e-01f, 1.35972649e-01f, 1.77655667e-01f,
  1.49636567e-01f, -4.29261595e-01f, -4.02992457e-01f, -2.47264765e-02f, -2.31927052e-01f, -1.63478196e-01f, 1.26541955e-02f, -1.41208231e-01f, -1.54184178e-01f, 1.40798569e-01f,
  -3.66207436e-02f, -4.87425476e-02f, -1.39115244e-01f, -3.76472734e-02f, -2.73385048e-01f, -3.11928540e-01f, -7.81455696e-01f, -3.73754427e-02f, 1.55935854e-01f, 1.69955179e-01f,
  1.18533537e-01f, -4.65889633e-01f, 5.69311343e-02f, 6.30236939e-02f, -1.74388811e-01f, -2.14888245e-01f, 2.11850777e-01f, -2.87924826e-01f, -1.36947948e-02f, 2.02326968e-01f,
  -1.89871937e-01f, 2.75026917e-01f, 1.56843647e-01f, -1.98799744e-01f, 5.44728376e-02f, 2.22882003e-01f, 4.13006954e-02f, 3.90372574e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.10893361e-01f, 2.22631749e-02f, 1.30266368e-01f, -1.01609290e-01f, 1.26686126e-01f, 2.42416896e-02f, 1.55763879e-01f, -1.02790654e-01f, -1.20929711e-01f, -3.67695764e-02f,
  2.37898119e-02f, -7.31281191e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    