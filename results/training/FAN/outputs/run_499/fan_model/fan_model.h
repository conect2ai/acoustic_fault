/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.31682533e-01f, 1.82477921e-01f, 1.84481785e-01f, 3.57063591e-01f, 6.50491491e-02f, 5.77439182e-02f, 2.54276693e-01f, -8.32338259e-02f, 1.01548560e-01f, -7.21634328e-02f,
  -3.16213332e-02f, 1.73713803e-01f, -2.32236266e-01f, 1.33882850e-01f, 2.10843801e-01f, -2.67537922e-01f, 2.92036951e-01f, 4.99988720e-02f, -1.05159000e-01f, 2.03866094e-01f,
  4.21813391e-02f, 1.07641377e-01f, -6.98404089e-02f, -1.44060537e-01f, 3.24633896e-01f, 9.22428817e-02f, 2.00507194e-01f, 3.50507423e-02f, 2.83013821e-01f, 4.51382063e-02f,
  -4.65314984e-02f, -3.65006067e-02f, -1.88018885e-02f, -2.70445831e-02f, 4.75240499e-02f, -6.99539762e-03f, 5.56261241e-02f, -5.57670742e-02f, -7.78835639e-02f, -4.63372283e-02f,
  5.68422452e-02f, 2.45173974e-03f, 1.13457059e-02f, -1.10955112e-01f, 9.54624638e-02f, 7.28104040e-02f, -3.16734030e-03f, 8.88198912e-02f, 4.43748944e-02f, 2.73327176e-02f,
  5.21028377e-02f, -4.23174277e-02f, 8.91122147e-02f, 2.60177869e-02f, 4.57539298e-02f, 5.55304363e-02f, 1.05912223e-01f, 2.99316924e-02f, 6.85531944e-02f, 1.04691811e-01f,
  -6.17609434e-02f, 1.21282146e-03f, -2.10507214e-02f, -4.14623022e-02f, 3.50420848e-02f, -2.88575590e-02f, -3.07865310e-02f, -3.47326472e-02f, 4.88390513e-02f, -2.32131463e-02f,
  -2.41297372e-02f, -2.07994157e-03f, -2.28145719e-03f, 3.55529748e-02f, 3.05849500e-02f, 1.02387862e-02f, -8.22577998e-03f, -2.38662828e-02f, 5.41139245e-02f, -2.05859765e-02f,
  -1.37105230e-02f, 3.69702317e-02f, -4.91282716e-02f, 5.96075598e-03f, -4.02724706e-02f, -1.51517354e-02f, 3.36642638e-02f, -3.14742047e-03f, -4.62822057e-03f, 3.40691432e-02f,
  4.67300303e-02f, 2.72845775e-01f, -7.85795320e-03f, -1.09631047e-02f, 7.73222127e-04f, 3.03620845e-02f, -9.46891867e-03f, -8.78712907e-03f, 1.98732600e-01f, 1.41481021e-02f,
  2.74056736e-02f, -4.02948931e-02f, 5.75029589e-02f, 1.70684569e-02f, -3.12577561e-02f, 7.45185614e-02f, 5.94461635e-02f, 8.11904371e-02f, 9.75102857e-02f, 2.41713896e-02f,
  3.71463113e-02f, -8.26746318e-03f, -1.08358771e-01f, 3.99768688e-02f, -3.07122003e-02f, -1.21872248e-02f, 2.08326578e-02f, -9.84931737e-03f, 1.47106387e-02f, -1.81849208e-02f,
  -3.91387433e-01f, 1.17739640e-01f, -2.53430068e-01f, -2.67113633e-02f, -1.33008182e-01f, 3.31658304e-01f, 1.97305754e-01f, -3.17989923e-02f, 3.18882138e-01f, 3.78603518e-01f,
  1.26571357e-01f, 1.26855955e-01f, 4.77540307e-02f, 1.93664223e-01f, -4.33884449e-02f, 1.39885470e-01f, 1.43188694e-02f, 1.74065940e-02f, -8.91811922e-02f, -2.36572266e-01f,
  -1.88942805e-01f, -9.03066620e-03f, -2.22208634e-01f, -5.84391542e-02f, 6.86178263e-03f, -1.94416508e-01f, -7.60313049e-02f, -5.71274273e-02f, 2.37589665e-02f, 8.48836452e-02f,
  -4.97012436e-02f, -2.79754796e-03f, -5.76388873e-02f, -9.83949099e-03f, -1.01476885e-01f, -2.75889281e-02f, -6.62983283e-02f, 3.45364772e-03f, -5.37257753e-02f, -7.17842281e-02f,
  1.40225533e-02f, -5.89731261e-02f, 1.25675406e-02f, 1.31671026e-01f, 5.16088083e-02f, 2.68880781e-02f, -4.81072515e-02f, 4.86753806e-02f, -9.53515023e-02f, -5.40276393e-02f,
  2.86982358e-02f, -8.17845687e-02f, 7.08828866e-02f, 4.47077453e-02f, -2.49308851e-02f, -1.19587928e-02f, -3.81319877e-03f, -1.47185419e-02f, 3.16822641e-02f, -5.93399666e-02f,
  5.99853508e-02f, -2.19507106e-02f, -6.40873015e-02f, -1.73816923e-02f, 3.26842740e-02f, -5.00697047e-02f, 9.40749198e-02f, -1.08032301e-01f, -5.01994975e-02f, 3.55644263e-02f,
  -9.33405105e-03f, 2.55775452e-02f, 3.11535988e-02f, 6.13964610e-02f, -2.24407706e-02f, 7.63650015e-02f, -3.95946652e-02f, -4.51111086e-02f, -2.41379123e-02f, 3.83863188e-02f,
  9.87338349e-02f, -2.60442821e-03f, 1.88108198e-02f, 3.31522226e-02f, 2.12893132e-02f, 1.19343502e-02f, 1.37502318e-02f, 8.82697552e-02f, -2.45410204e-02f, -4.72205095e-02f,
  5.70785142e-02f, 5.53778792e-03f, -2.40908284e-03f, 1.87522862e-02f, 5.88453934e-02f, 5.64692263e-03f, 3.83409187e-02f, 3.71309593e-02f, 9.61994007e-03f, -6.14788942e-02f,
  -6.87313527e-02f, -2.26143897e-02f, 1.03397695e-02f, -1.22741573e-02f, 8.79535452e-03f, 2.64534354e-03f, -4.09463607e-02f, 1.87683068e-02f, 2.62332186e-02f, -4.44702804e-02f,
  -2.52588131e-02f, -9.38492119e-02f, 1.79492608e-02f, -7.58458078e-02f, 4.55678590e-02f, 8.14643502e-02f, 2.23541120e-03f, 3.11008398e-03f, 3.34392465e-03f, 6.55592009e-02f,
  3.26503366e-01f, -5.12252897e-02f, 7.54790381e-02f, -2.25326009e-02f, -1.05513632e-01f, -2.47325331e-01f, -6.21710233e-02f, -1.94804549e-01f, -1.54034853e-01f, -1.82919875e-01f,
  -1.23551011e-01f, 1.57407120e-01f, 8.43038708e-02f, -1.63619772e-01f, 1.06266484e-01f, -4.20874506e-02f, -1.57638267e-01f, 5.52681163e-02f, 1.80165172e-02f, 3.56809050e-02f,
  -4.34738919e-02f, -2.12794900e-01f, -1.40710011e-01f, -5.95334917e-02f, -1.34336622e-02f, 3.28264758e-02f, -9.28855594e-03f, 1.28203049e-01f, -8.20579156e-02f, 7.85947964e-02f,
  -9.05807130e-03f, 1.49223611e-01f, -2.85620186e-02f, -1.49919838e-02f, -4.76276316e-03f, 2.80385278e-02f, 1.11614153e-01f, 5.42050488e-02f, 6.25053495e-02f, -3.00379656e-02f,
  -1.25512350e-02f, 4.24579903e-02f, -6.61926940e-02f, -2.65513938e-02f, 1.64546501e-02f, 4.46457006e-02f, -5.85074238e-02f, -7.26006329e-02f, -5.88372797e-02f, -2.20814999e-02f,
  -7.65542760e-02f, 2.57366784e-02f, -3.87917757e-02f, 6.00923813e-05f, 1.08837355e-02f, -2.75485367e-02f, -1.22243725e-02f, 5.35714440e-02f, -2.79953089e-02f, -1.07748918e-01f,
  -1.62964705e-02f, 9.02569015e-03f, -1.03216516e-02f, -8.99452996e-03f, 6.05948409e-03f, 1.47340866e-02f, -4.48604785e-02f, 3.79806980e-02f, -5.21658175e-03f, 9.49214585e-03f,
  -7.20224380e-02f, 5.40230423e-02f, -1.17340144e-02f, -1.23680597e-02f, 3.21737083e-04f, -3.86927873e-02f, 6.35874420e-02f, 2.46342272e-02f, -5.23871183e-02f, -4.73894775e-02f,
  2.34803651e-02f, -2.55673751e-02f, -4.24125753e-02f, 1.97982471e-02f, -5.78183830e-02f, 1.67376979e-03f, -6.39435053e-02f, -5.56070209e-02f, -3.29541899e-02f, 7.49223754e-02f,
  1.74630791e-01f, 1.68683857e-01f, -2.74741389e-02f, -3.64088938e-02f, -5.89744141e-03f, 5.03797363e-03f, 4.56423163e-02f, -4.79300544e-02f, 7.25346208e-02f, -7.34049603e-02f,
  -2.54568420e-02f, 5.16798124e-02f, 3.53999548e-02f, 2.22494025e-02f, 2.63689086e-02f, -5.66902347e-02f, 1.45397549e-02f, 1.74041726e-02f, -8.11670907e-03f, 2.89125908e-02f,
  8.71371850e-02f, 1.04925312e-01f, 2.59984713e-02f, 4.72915173e-02f, -2.43749022e-02f, -1.38685713e-02f, 9.88608412e-03f, -3.59894596e-02f, 6.92122281e-02f, 1.25643769e-02f,
  8.34081173e-02f, 1.80475622e-01f, 1.67983443e-01f, 4.47900116e-01f, -8.87815133e-02f, -2.21893832e-01f, -9.52312052e-02f, 2.06408709e-01f, 2.25114569e-01f, 7.39806741e-02f,
  -9.04457346e-02f, 1.57887384e-01f, 3.72066982e-02f, 1.92871332e-01f, -2.73235559e-01f, -1.64077312e-01f, 4.34937179e-02f, 6.04627877e-02f, 9.90853310e-02f, 2.19525084e-01f,
  1.44701749e-02f, 1.86088961e-02f, -9.77376625e-02f, 5.01202121e-02f, 5.87293878e-02f, 1.42529503e-01f, -4.53676432e-02f, 4.07032557e-02f, 1.42250415e-02f, -1.40805900e-01f,
  -9.26845968e-02f, 5.48549220e-02f, 7.92124569e-02f, -3.90636697e-02f, -4.45794016e-02f, -3.25556323e-02f, -5.94258308e-03f, -2.27059126e-02f, 4.07898016e-02f, 1.33306878e-02f,
  3.56741697e-02f, -2.52411216e-02f, 1.45156279e-01f, 1.53243113e-02f, 1.16881551e-02f, -4.07528989e-02f, 3.34507376e-02f, -9.75306481e-02f, 4.63180915e-02f, 1.72155872e-02f,
  2.72451318e-04f, -7.21850544e-02f, 1.21372733e-02f, -2.76633315e-02f, 2.13137567e-02f, 6.75154030e-02f, -4.34038676e-02f, -6.09618127e-02f, -2.62517165e-02f, 3.85266952e-02f,
  -9.27564204e-02f, 4.05290686e-02f, 5.95041476e-02f, 1.71710756e-02f, 1.91646535e-02f, -3.12686374e-04f, 2.33918391e-02f, -3.28599289e-02f, 6.78525865e-02f, -6.69371113e-02f,
  -6.92033116e-03f, 5.37970476e-02f, 1.01061270e-01f, 2.33852933e-03f, -9.39838123e-03f, 2.45396588e-02f, -3.71667631e-02f, -2.24223267e-02f, 7.98888654e-02f, -3.86066325e-02f,
  -7.40359956e-03f, 4.66988282e-03f, -2.72459332e-02f, -3.02567426e-02f, -6.62072971e-02f, 4.84671444e-02f, -7.61612877e-03f, -4.91466075e-02f, 6.99029712e-04f, -1.00906957e-02f,
  -6.74575120e-02f, 1.38626218e-01f, 2.24253796e-02f, 2.25598291e-02f, 3.09722647e-02f, -3.01669221e-02f, 3.50749190e-03f, 9.66788549e-03f, -9.45624411e-02f, 5.92908077e-02f,
  -7.12116957e-02f, 6.98456988e-02f, -7.56451488e-02f, 1.06806988e-02f, 1.22668743e-02f, -6.70554638e-02f, -1.96836405e-02f, 5.19148074e-02f, 3.47257107e-02f, 4.69591841e-03f,
  2.17508487e-02f, -3.29152457e-02f, 1.86364073e-02f, 3.62016074e-02f, 3.82937840e-03f, -9.49234888e-02f, 2.78894845e-02f, 1.21738404e-01f, -9.19195488e-02f, 1.78990979e-02f,
  -2.27313843e-02f, 5.94903119e-02f, -2.62435943e-01f, -7.61306137e-02f, 5.81352599e-02f, -2.89887816e-01f, -1.93104327e-01f, -3.33950557e-02f, -1.51635483e-01f, 6.74477518e-02f,
  7.21509904e-02f, -6.88948929e-02f, -2.31407024e-02f, -1.59909159e-01f, -1.92539543e-01f, -2.79103339e-01f, -1.93074331e-01f, -6.38100728e-02f, -5.50641492e-02f, 3.38970125e-02f,
  -6.78793415e-02f, 7.12799579e-02f, -5.42570204e-02f, 1.48550734e-01f, 6.74022138e-02f, 1.49558097e-01f, 1.51275039e-01f, 2.45305836e-01f, 8.06101412e-02f, 1.62314534e-01f,
  -4.34123017e-02f, 1.06521703e-01f, -3.15473042e-02f, -5.92472479e-02f, 1.57229579e-03f, 1.01882823e-01f, 1.18394243e-02f, 4.59900824e-03f, 6.04630224e-02f, 2.05531009e-02f,
  -6.07671216e-02f, -3.51968817e-02f, -3.65247279e-02f, -5.32225594e-02f, -4.21353281e-02f, -4.31217328e-02f, -2.05506105e-02f, -1.02271661e-02f, -9.60214511e-02f, -9.24203917e-02f,
  -3.25765572e-02f, -1.26412570e-01f, -4.68500294e-02f, -3.95316035e-02f, 2.14811321e-03f, -7.31968284e-02f, 1.58588719e-02f, -3.71391736e-02f, -2.57634353e-02f, 1.06347620e-03f,
  -9.43085030e-02f, 1.24824770e-01f, -4.95615043e-03f, 6.88552335e-02f, -3.70983444e-02f, 3.83161455e-02f, -3.36112641e-02f, 7.08210468e-03f, 4.26583737e-02f, -3.68327722e-02f,
  -1.13990922e-02f, 2.06529908e-02f, 2.80200364e-03f, -8.45631659e-02f, 7.64534250e-02f, 1.56752020e-02f, -6.04922660e-02f, -5.16068116e-02f, 1.14493417e-02f, -6.20043278e-02f,
  4.34744433e-02f, -2.16018260e-02f, 1.01924784e-01f, -7.86873791e-03f, 8.13992992e-02f, 8.24741945e-02f, 9.79392007e-02f, -1.18359409e-01f, 4.69464902e-03f, -5.88762853e-03f,
  8.49569216e-02f, 2.43378416e-01f, 3.39316316e-02f, 1.15753254e-02f, 8.41935501e-02f, 7.72069246e-02f, 2.51390189e-02f, -7.96008185e-02f, 4.27940376e-02f, 1.03674149e-02f,
  -2.57782340e-02f, 4.20252346e-02f, 4.52672057e-02f, 5.06158825e-03f, 3.09077390e-02f, 6.98427856e-02f, 6.55795783e-02f, 6.43882900e-02f, 1.39693379e-01f, 6.82730675e-02f,
  6.67039081e-02f, -1.47761069e-02f, 4.75430414e-02f, 1.04115255e-01f, 5.47551475e-02f, 7.40673915e-02f, 8.82669315e-02f, -9.43851024e-02f, 4.13714861e-03f, -5.25198653e-02f,
  3.62865925e-01f, 6.48244470e-02f, 1.03963748e-01f, 9.58846211e-02f, 4.62701507e-02f, -1.89456925e-01f, -6.86411560e-02f, 6.92259800e-03f, 2.99924463e-01f, -1.28253058e-01f,
  -1.00873120e-01f, 3.35463792e-01f, -2.91585140e-02f, -2.02532083e-01f, -8.75158459e-02f, -6.15692437e-02f, -6.29295260e-02f, -1.75910406e-02f, 1.72354936e-04f, 4.17006575e-02f,
  3.76335457e-02f, -1.19127885e-01f, -2.44704455e-01f, -1.91925183e-01f, -1.95423998e-02f, 8.01040381e-02f, -1.32033363e-01f, -8.32275450e-02f, -2.18257874e-01f, -5.51458523e-02f,
  -6.30162582e-02f, 1.57702178e-01f, -2.07317322e-02f, 4.47182655e-02f, -1.25516523e-02f, -6.92119077e-02f, -4.09743227e-02f, -3.52904238e-02f, -4.59859557e-02f, -6.04885397e-03f,
  5.94465435e-02f, 5.41880615e-02f, -4.21692990e-03f, 7.19685748e-04f, 3.54676954e-02f, 2.13332772e-02f, -2.63184011e-02f, -2.48358538e-03f, 6.11441247e-02f, -1.98730286e-02f,
  -2.17220094e-02f, 3.41986343e-02f, -1.34855034e-02f, -6.97762668e-02f, 2.88137421e-02f, 1.16070427e-01f, 5.64218778e-03f, -7.62304710e-03f, -3.20333391e-02f, -3.37310806e-02f,
  -1.89544242e-02f, -8.98409337e-02f, -1.53309321e-02f, -4.24102582e-02f, -3.04057486e-02f, -3.81052196e-02f, -3.14269252e-02f, -3.86603661e-02f, 5.12339957e-02f, 2.30958834e-02f,
  -2.93015130e-02f, 2.87096370e-02f, -3.40106040e-02f, -2.83877309e-02f, 5.21680526e-03f, 2.84678303e-02f, -2.61067320e-02f, -4.27414887e-02f, -3.13783772e-02f, -2.18422804e-03f,
  8.08958430e-03f, -6.84526786e-02f, 6.24805130e-02f, -6.91894628e-03f, 2.44958289e-02f, 5.40815704e-02f, 2.86231544e-02f, 4.65532839e-02f, -8.86095967e-03f, 5.49113378e-03f,
  -8.81603435e-02f, 7.27434456e-02f, 1.77374501e-02f, -5.93481623e-02f, -2.74674315e-02f, -1.01167616e-02f, -3.20841447e-02f, 1.88187957e-02f, 4.46886308e-02f, -4.25669104e-02f,
  -1.95284411e-02f, -3.63822803e-02f, -5.74700497e-02f, -6.64112996e-03f, -1.71064343e-02f, 1.97603218e-02f, -2.78671626e-02f, -5.63838379e-03f, -2.85692867e-02f, -6.30198792e-02f,
  -4.98861372e-02f, -3.70498113e-02f, 2.68138219e-02f, -1.68007053e-02f, 6.48874342e-02f, -3.12511884e-02f, 7.88000375e-02f, 5.84126934e-02f, -3.73657122e-02f, -1.44350389e-02f,
  4.59988743e-01f, 1.16147511e-01f, 1.55202895e-01f, 2.39531443e-01f, 1.67329442e-02f, -7.28339851e-02f, -6.49451185e-03f, 6.85290769e-02f, 1.70661420e-01f, -1.38196304e-01f,
  1.53630525e-02f, 1.37652621e-01f, 1.64659396e-01f, -8.90366733e-02f, 3.54664236e-01f, 6.29052073e-02f, 1.68003351e-03f, 8.96820892e-03f, 4.60737245e-03f, 9.44898501e-02f,
  8.96528587e-02f, 1.55836314e-01f, 5.79242297e-02f, -5.24832271e-02f, -6.23980239e-02f, -6.77113459e-02f, -2.69284304e-02f, 5.10074049e-02f, -1.74025729e-01f, -1.40743013e-02f,
  2.43069790e-02f, 9.76107121e-02f, -3.40233743e-02f, -6.63720891e-02f, -5.41757792e-02f, -3.16002406e-02f, -4.65574078e-02f, -3.45896594e-02f, -5.74230812e-02f, 2.02946905e-02f,
  7.40768947e-03f, 4.60690483e-02f, -3.02010309e-02f, 7.89756775e-02f, 2.40962990e-02f, -5.29841781e-02f, -1.32638097e-01f, -2.16789301e-02f, 2.66125728e-03f, -6.75725564e-02f,
  6.27057552e-02f, -3.29404809e-02f, -3.43063064e-02f, -5.85550889e-02f, 9.32562165e-03f, 7.06773438e-03f, -7.07926676e-02f, -3.24716568e-02f, -8.52073077e-03f, 8.33869912e-03f,
  -1.20334616e-02f, 4.24670838e-02f, -5.99181205e-02f, 5.26438141e-03f, 5.25495820e-02f, 2.38561048e-03f, -3.40411700e-02f, -2.38686148e-02f, 1.45745771e-02f, 3.27378102e-02f,
  8.89077410e-02f, 3.57632004e-02f, 2.13569663e-02f, 4.33366001e-02f, 1.32786762e-02f, 3.28269824e-02f, 4.94583212e-02f, 3.58513743e-02f, 2.71591693e-02f, -6.01117732e-03f,
  5.10782897e-02f, 3.76808904e-02f, 5.04827723e-02f, -8.47732797e-02f, -1.86089333e-02f, 6.69517517e-02f, 5.93192596e-03f, -3.32362019e-02f, 4.60592583e-02f, 6.46161512e-02f,
  2.38494083e-01f, 2.53009230e-01f, 1.41673358e-02f, -7.66047183e-03f, -1.13417534e-02f, -1.17578700e-01f, -5.11680311e-03f, -3.50903496e-02f, 8.26395825e-02f, -2.43014432e-02f,
  -7.70955235e-02f, -1.50297314e-01f, 3.07625625e-02f, -1.37959970e-02f, 1.36681413e-02f, 6.00310043e-02f, 7.30550289e-02f, 2.94495188e-02f, 3.66893224e-02f, 3.82912997e-03f,
  5.67944348e-03f, 1.37967467e-02f, -8.00057203e-02f, -3.80232073e-02f, -3.01282108e-02f, -1.98304113e-02f, 7.45050833e-02f, -4.90408391e-03f, -4.63693030e-02f, -5.22388564e-03f,
  -5.83836257e-01f, 4.53330167e-02f, -1.95635229e-01f, -2.35316798e-01f, -1.17702698e-02f, -2.60673016e-01f, -1.93909392e-01f, 1.38110384e-01f, -2.48289391e-01f, 9.73836631e-02f,
  1.51569083e-01f, -1.22714467e-01f, 2.01307029e-01f, -1.35476038e-01f, -1.22120105e-01f, 5.35225645e-02f, -2.41672188e-01f, -1.84647471e-01f, -2.05898546e-02f, 1.27857909e-01f,
  2.42974386e-02f, 7.76371434e-02f, -3.16936523e-02f, 1.87913358e-01f, -2.51173645e-01f, 2.27822294e-03f, 1.55099809e-01f, 4.44934517e-03f, -1.23793654e-01f, -5.69696091e-02f,
  -7.98204541e-02f, 2.79553328e-02f, -2.59133745e-02f, 5.08220382e-02f, 4.17610630e-02f, 7.41344616e-02f, -7.27340430e-02f, -7.88457617e-02f, -3.84695944e-03f, -8.99827946e-03f,
  -2.36880984e-02f, 3.43304761e-02f, 8.42962787e-02f, 6.71427231e-03f, -7.53996223e-02f, 5.24792634e-02f, 3.22096772e-03f, -9.32868347e-02f, -4.39310111e-02f, 5.04350895e-03f,
  1.27974814e-02f, -3.00085843e-02f, -6.27111122e-02f, -1.76083315e-02f, -4.46311384e-02f, -4.30999063e-02f, -3.45976651e-02f, -7.46631995e-02f, -7.60964453e-02f, -1.26891255e-01f,
  2.75919177e-02f, 1.40359970e-02f, -3.71139944e-02f, 2.22681127e-02f, 6.21944899e-03f, 2.89252792e-02f, 2.68497057e-02f, 5.65379374e-02f, -8.89542997e-02f, -4.94183265e-02f,
  -3.55522111e-02f, -5.83843403e-02f, 5.70061505e-02f, -2.27301344e-02f, 5.33983065e-03f, -1.00000268e-02f, 7.34308595e-03f, 3.28694172e-02f, -2.33864877e-02f, -1.53965820e-02f,
  2.26926226e-02f, -1.10356426e-02f, -4.11993917e-03f, -6.88499771e-03f, 1.66332424e-02f, -7.07316818e-03f, 3.03506628e-02f, -3.66376080e-02f, 8.21605697e-02f, -2.90766470e-02f,
  -1.73910260e-02f, 1.20411389e-01f, 4.83417325e-02f, 2.13511828e-02f, 2.52903476e-02f, 7.03023467e-03f, -3.52904908e-02f, -4.21609133e-02f, 9.13547818e-03f, 2.55724415e-02f,
  5.53322025e-02f, 4.44127619e-03f, -1.87809505e-02f, -3.53958495e-02f, -9.76515841e-03f, -2.45973002e-03f, 6.40445203e-02f, 5.99683709e-02f, 3.27804238e-02f, 1.11161724e-01f,
  -2.08719708e-02f, 1.90962069e-02f, -1.18564349e-03f, 4.00128588e-02f, -7.90212303e-03f, -1.98103189e-02f, -8.44009444e-02f, -3.98767702e-02f, 2.98324600e-02f, -8.23800638e-03f,
  -3.69121790e-01f, -1.45684212e-01f, -1.22150354e-01f, -7.79618472e-02f, -1.42945841e-01f, 1.26467773e-03f, 3.75779033e-01f, -2.98857540e-01f, 2.12817430e-01f, 9.39721763e-02f,
  6.30611973e-03f, 1.69437379e-01f, 2.68468410e-01f, -8.45058113e-02f, 2.44889408e-01f, 2.55863070e-01f, -1.01569824e-01f, 2.27474105e-02f, -1.50272222e-02f, -1.42544106e-01f,
  -8.48774090e-02f, -1.09592862e-01f, -2.44396715e-03f, -1.82020441e-01f, -2.00287968e-01f, -1.84383526e-01f, -6.72045648e-02f, 8.82547572e-02f, -1.79993927e-01f, 5.90870865e-02f,
  -9.41656455e-02f, 8.72309087e-04f, -1.70700788e-03f, 3.85453738e-02f, -7.04057291e-02f, -1.82350967e-02f, 1.57696921e-02f, 6.85802847e-02f, -8.64659622e-03f, 3.58025841e-02f,
  -9.77005437e-03f, 9.10182390e-03f, 4.62561799e-03f, 3.67036536e-02f, -7.50824809e-02f, 1.47963660e-02f, 5.68795600e-04f, -1.07993726e-02f, 1.10655492e-02f, -5.82712777e-02f,
  4.63962369e-02f, -6.09078370e-02f, -4.69715223e-02f, 3.18475999e-02f, -4.30652639e-03f, -2.02798322e-02f, 5.17873690e-02f, 5.45774065e-02f, -7.93872252e-02f, 8.17096457e-02f,
  5.03736101e-02f, 4.24806029e-03f, -3.20779160e-02f, -6.17472529e-02f, 4.86806892e-02f, -6.94833696e-02f, 4.03728634e-02f, 5.43532846e-03f, 1.13714039e-02f, -5.76037681e-03f,
  -3.59010808e-02f, -2.11232435e-02f, -7.06841098e-03f, -1.50622744e-02f, 1.17447628e-02f, -1.99614372e-02f, 4.04601777e-03f, 2.87309140e-02f, -2.86684725e-02f, -6.29108325e-02f,
  1.65748820e-02f, 2.32001804e-02f, 7.41474777e-02f, 3.89350206e-02f, -3.12346709e-03f, 1.01350680e-01f, -3.60179096e-02f, 2.11689826e-02f, -1.57698970e-02f, -1.18550425e-02f,
  2.56543830e-02f, 6.72896653e-02f, 3.90956514e-02f, 8.09125751e-02f, 1.04475103e-01f, 3.12441103e-02f, 7.66370744e-02f, -1.43254384e-01f, 8.55100434e-03f, -2.84406869e-03f,
  -4.36753687e-03f, 1.58960279e-02f, -1.31370023e-01f, 6.96866494e-03f, 6.04158603e-02f, 1.39518604e-02f, 6.32556602e-02f, 3.13685127e-02f, 4.86532487e-02f, -6.84305355e-02f,
  -5.75017892e-02f, -1.78621542e-06f, -2.47061662e-02f, 3.50733078e-03f, -5.25437854e-02f, 3.90801504e-02f, -5.32875955e-03f, -2.43273117e-02f, 4.66119591e-03f, 5.39133046e-03f,
  -1.97268844e-01f, 1.82839543e-01f, 1.28888279e-01f, -4.66597155e-02f, -2.02195570e-02f, -1.78710029e-01f, -1.91332117e-01f, 1.81505933e-01f, 2.55798161e-01f, -2.18798622e-01f,
  -8.51308331e-02f, -1.65101171e-01f, 7.84122348e-02f, -2.13319868e-01f, -1.86088622e-01f, 8.41100737e-02f, -1.13415368e-01f, -3.77892964e-02f, 2.46471301e-01f, -1.41319916e-01f,
  3.59368473e-02f, -1.43219739e-01f, -4.32650037e-02f, 7.60460719e-02f, -9.60024521e-02f, 1.03446990e-01f, -3.12001109e-01f, 1.43642342e-02f, -3.07165533e-01f, -2.26347726e-02f,
  -1.23278257e-02f, 8.18566158e-02f, 4.36976254e-02f, 1.26373962e-01f, -6.27327412e-02f, -6.50582686e-02f, -1.35442719e-01f, -2.70564817e-02f, 1.86301190e-02f, -2.24415155e-04f,
  -2.86725089e-02f, -1.02851473e-01f, -7.68022565e-03f, -1.83048937e-02f, 3.82290073e-02f, -1.76877547e-02f, 2.57399734e-02f, 3.80725227e-02f, 4.44091633e-02f, -3.80981974e-02f,
  6.87511116e-02f, -1.28393928e-02f, -2.96769477e-02f, -1.60367936e-02f, 3.78364548e-02f, 9.57708526e-03f, 4.73840088e-02f, -7.00794831e-02f, -2.80802865e-02f, 7.42956921e-02f,
  -4.32658456e-02f, 4.84785885e-02f, -6.33879229e-02f, 4.16875668e-02f, -5.11975139e-02f, -9.83161945e-03f, 5.87718189e-02f, -8.52159932e-02f, -2.12436058e-02f, -1.76276863e-02f,
  -1.61852241e-02f, 4.61741351e-03f, 1.32972291e-02f, 8.61448608e-03f, -5.36710098e-02f, 2.54973862e-02f, -1.29948094e-01f, 1.17849978e-02f, -1.40217422e-02f, 4.37773280e-02f,
  -4.15316708e-02f, 1.07448595e-02f, 7.44875818e-02f, -2.89094765e-02f, 2.30020322e-02f, -3.42152566e-02f, -1.58988852e-02f, -4.61383956e-03f, -2.15111282e-02f, -1.00625139e-02f,
  4.14272100e-02f, 5.05957082e-02f, 4.89672720e-02f, -4.62217331e-02f, 8.24293718e-02f, 3.84517834e-02f, 8.90949070e-02f, -6.54752403e-02f, -1.17611466e-02f, -3.22911218e-02f,
  -3.03360615e-02f, -7.29960669e-03f, 5.93228149e-04f, 1.65438168e-02f, -3.56170125e-02f, 4.61156145e-02f, -3.08759481e-05f, 1.04507376e-02f, 4.69170650e-03f, 3.66822705e-02f,
  -6.71848878e-02f, -3.63235176e-02f, -3.95004964e-03f, -8.68928134e-02f, -5.65466192e-03f, -6.12464957e-02f, -3.98711227e-02f, 5.26985377e-02f, 6.15137443e-02f, -2.53620744e-02f,
  -7.72147179e-02f, -9.66409519e-02f, -8.97594616e-02f, -1.68139666e-01f, 6.23409338e-02f, -1.38380438e-01f, -2.09840238e-01f, -5.55154309e-02f, 2.75591135e-01f, -1.65487021e-01f,
  -1.53276578e-01f, -1.02281515e-02f, -2.26660267e-01f, -3.01310003e-01f, -1.79772228e-01f, -1.02952167e-01f, -2.28406295e-01f, -9.06234160e-02f, 1.58708885e-01f, -4.55293208e-02f,
  -6.86459094e-02f, -2.33692929e-01f, -2.25408539e-01f, 2.34036576e-02f, -1.86903894e-01f, 9.23188478e-02f, -1.57725915e-01f, 3.34860347e-02f, -1.25378326e-01f, -2.17797291e-02f,
  -1.75004341e-02f, 8.28351527e-02f, 1.30676860e-02f, 4.21366282e-02f, 2.16776002e-02f, -4.86448817e-02f, -6.50227889e-02f, -4.72054742e-02f, 4.47404683e-02f, 3.11868861e-02f,
  -4.38448451e-02f, 8.82368013e-02f, 2.20780578e-02f, 9.15320497e-03f, 9.73722413e-02f, 4.33992557e-02f, 7.30574578e-02f, 1.32713874e-03f, -1.00564100e-02f, 6.96162600e-03f,
  4.24800068e-02f, 2.48785038e-02f, -7.84982815e-02f, 4.49131243e-03f, 1.10227428e-02f, -4.60398532e-02f, 4.76015024e-02f, -2.72410829e-02f, 8.15368593e-02f, 1.76471919e-02f,
  5.84723763e-02f, 3.72263044e-02f, 6.37088297e-03f, -1.55114131e-02f, 4.61592823e-02f, 4.51735407e-02f, -4.81371246e-02f, -3.11455615e-02f, 4.99509238e-02f, -3.59892547e-02f,
  6.28512129e-02f, 3.73132639e-02f, 1.17924053e-03f, -3.86685543e-02f, -2.93349382e-02f, -3.86510268e-02f, 7.68567959e-04f, 1.43510010e-02f, -1.45776372e-03f, 1.71235967e-02f,
  -6.04872871e-03f, 3.14810723e-02f, -4.51864637e-02f, -1.95246264e-02f, -6.04516640e-03f, 3.09891556e-03f, -3.46703641e-02f, -2.61607711e-05f, -4.17466238e-02f, -2.90530343e-02f,
  -4.47009429e-02f, -1.61556438e-01f, -2.32317927e-03f, 2.37500481e-02f, 4.30412637e-03f, 6.80043548e-03f, -4.94031920e-05f, 5.19902892e-02f, -6.87137432e-03f, -8.83761346e-02f,
  -4.35065338e-03f, 9.46359243e-03f, -4.37318906e-02f, 4.58603771e-03f, 6.52539060e-02f, -1.16849102e-01f, -7.81708956e-02f, 8.58360603e-02f, -2.22377013e-02f, -4.62293811e-02f,
  -4.54089716e-02f, 2.68275626e-02f, 1.39477020e-02f, 5.08723073e-02f, 2.30005961e-02f, -1.12915980e-02f, 5.21133356e-02f, 8.65967795e-02f, -7.31169730e-02f, 2.84096692e-02f,
  1.50772035e-01f, 1.81068450e-01f, -2.24984527e-01f, 3.10302198e-01f, -4.45309281e-02f, -6.09044321e-02f, 1.25866517e-01f, -2.39372011e-02f, 1.82784915e-01f, 1.72418967e-01f,
  7.39392117e-02f, -1.74107715e-01f, 5.67180142e-02f, 2.60719806e-01f, -1.72929004e-01f, 1.78484231e-01f, 5.90571016e-02f, 9.84932259e-02f, -1.59138758e-02f, 9.17324945e-02f,
  2.73049064e-02f, 2.39738807e-01f, -4.66048121e-02f, -7.45430887e-02f, -1.35348607e-02f, -7.84599334e-02f, -3.72917801e-02f, -1.53883979e-01f, 1.53285041e-02f, -1.03213228e-01f,
  2.94812229e-02f, 8.93908218e-02f, 6.29151464e-02f, 3.29339430e-02f, 4.35020775e-02f, -6.12822771e-02f, -9.16618761e-03f, -1.64668784e-02f, -3.93753909e-02f, 1.31968511e-02f,
  2.12036986e-02f, 1.48702515e-02f, -5.48350513e-02f, -4.22147252e-02f, 7.16128796e-02f, -8.54539052e-02f, -4.82502803e-02f, -8.59206915e-02f, 5.13279550e-02f, -5.39482981e-02f,
  6.78322604e-03f, -8.50526541e-02f, -1.01115005e-02f, -5.81838042e-02f, -3.18251066e-02f, 5.62443994e-02f, -6.49765283e-02f, -1.13947190e-01f, -3.06556784e-02f, 3.45003717e-02f,
  -7.61355609e-02f, -1.30311977e-02f, -3.00772581e-02f, 2.77514234e-02f, 3.08156069e-02f, 3.44353616e-02f, -3.03832851e-02f, 3.30231488e-02f, -5.05984612e-02f, 4.20030951e-02f,
  6.76327124e-02f, 3.46107297e-02f, -5.15275672e-02f, -4.93378192e-02f, -7.74820568e-03f, 1.08747847e-01f, -9.26061906e-03f, 4.18459810e-02f, -2.30119135e-02f, -1.24106696e-03f,
  3.63942757e-02f, 1.46175185e-02f, 7.13976845e-02f, -1.70989409e-02f, 3.23306210e-02f, -3.04305218e-02f, 1.23519897e-02f, -5.11539467e-02f, 4.08609658e-02f, -4.03716639e-02f,
  2.12669790e-01f, 9.62386951e-02f, 9.22192335e-02f, 1.98260471e-02f, 5.05184755e-02f, 4.17020582e-02f, -4.04100493e-02f, 1.48059148e-02f, -2.98787914e-02f, -3.78116481e-02f,
  -3.32194418e-02f, 2.80148163e-02f, -6.97929934e-02f, 8.09228793e-02f, 4.05039303e-02f, -2.25354196e-03f, 1.06238388e-01f, 9.43213776e-02f, 7.74241835e-02f, -7.89274499e-02f,
  9.12739150e-03f, -3.02693825e-02f, 2.17414107e-02f, 1.15285590e-02f, -2.38071363e-02f, 1.77368103e-03f, -1.16274301e-02f, -3.70505825e-02f, -2.21445337e-02f, -7.54431039e-02f,
  -2.51486036e-03f, 1.08892675e-02f, -3.06579202e-01f, -3.84538144e-01f, 1.74104214e-01f, 4.21102285e-01f, 1.47863969e-01f, 1.05692245e-01f, -2.67882019e-01f, 1.04714416e-01f,
  1.23657003e-01f, -2.28540540e-01f, 1.79252967e-01f, 1.13894837e-02f, -1.56033233e-01f, 9.66276303e-02f, 1.24750413e-01f, -3.77423712e-04f, 3.54946889e-02f, 5.79454862e-02f,
  -8.30563828e-02f, 1.13216668e-01f, -1.44908195e-02f, 8.43925104e-02f, 1.10557325e-01f, -2.37089187e-01f, 1.04233501e-02f, -5.84060997e-02f, -3.97000089e-02f, 5.73951378e-02f,
  -7.51514267e-03f, -5.82608618e-02f, -1.93057396e-02f, -8.06585792e-03f, 4.82990332e-02f, 2.54549198e-02f, -1.29068773e-02f, -9.13013741e-02f, -1.23295516e-01f, -1.30905639e-02f,
  -1.34428507e-02f, -5.19038141e-02f, -4.57765646e-02f, -1.20893307e-01f, 2.20936630e-02f, -1.37423322e-01f, 6.69690669e-02f, 1.54754281e-01f, -8.13546255e-02f, 1.19813733e-01f,
  4.88217063e-02f, -1.80238914e-02f, 7.01721236e-02f, -5.21229021e-02f, -1.46752279e-02f, -3.89645882e-02f, -3.27490941e-02f, 4.24626134e-02f, 7.25325719e-02f, -5.99892288e-02f,
  6.25992492e-02f, -5.73718958e-02f, -1.62167300e-03f, -6.08651005e-02f, 3.83748710e-02f, 3.63299996e-02f, -6.63130805e-02f, 7.94033855e-02f, -4.84004207e-02f, 9.97425765e-02f,
  -3.47494483e-02f, -5.77638783e-02f, -3.03871818e-02f, -3.90487537e-02f, 4.98380512e-03f, -3.80034733e-04f, -8.43884051e-02f, -9.19639319e-02f, -4.53222804e-02f, -9.67018008e-02f,
  -9.72885787e-02f, -1.18375346e-02f, 2.22391114e-02f, 5.17542586e-02f, -1.64819025e-02f, -7.86476061e-02f, -5.25320321e-02f, 5.87400720e-02f, 2.91273289e-04f, 6.34185895e-02f,
  1.63391113e-01f, 5.04642539e-02f, 7.06402585e-02f, -2.12301277e-02f, -6.21166416e-02f, 9.94785130e-02f, -7.42919296e-02f, 2.69390177e-02f, -1.33934738e-02f, 3.55288237e-02f,
  2.93247625e-02f, 1.30147049e-02f, 3.05063166e-02f, 1.71353109e-02f, -8.31021965e-02f, 2.54447460e-02f, -3.72295193e-02f, -6.76922947e-02f, -6.76843300e-02f, 8.30958858e-02f,
  1.07714951e-01f, 4.24314104e-03f, -8.96168314e-03f, 5.59639093e-03f, 4.72499989e-02f, 3.56171429e-02f, -7.00892298e-04f, -6.04597963e-02f, 4.72895838e-02f, 3.57265398e-02f,
  -2.97024906e-01f, 2.72458196e-01f, -5.11468053e-02f, -2.48520337e-02f, -1.75871223e-01f, -2.48538554e-02f, -6.53991997e-02f, -1.09700374e-01f, -6.51034042e-02f, 4.17068750e-01f,
  4.71431874e-02f, 8.59415978e-02f, 1.25274375e-01f, -5.46953008e-02f, -2.79865205e-01f, 1.01513103e-01f, 2.02955841e-03f, 9.39466730e-02f, -1.34824127e-01f, -7.56382123e-02f,
  -1.18459553e-01f, -1.78366214e-01f, -1.19078875e-01f, -8.82043391e-02f, -3.17548253e-02f, -1.24813581e-03f, 2.23739102e-01f, 5.50948596e-03f, 4.71125953e-02f, -1.94097966e-01f,
  -9.11043063e-02f, -1.09533012e-01f, -8.06998182e-03f, 2.08008904e-02f, -3.05687152e-02f, 9.38917845e-02f, 5.32395020e-02f, 2.44982317e-02f, -1.91093922e-01f, -2.34223297e-03f,
  1.16963893e-01f, -2.52496228e-02f, 1.38481082e-02f, -4.64550033e-02f, -4.13048863e-02f, -8.04272965e-02f, -7.11338744e-02f, 1.69368032e-02f, -3.73037606e-02f, 7.03248521e-03f,
  -4.31768037e-02f, 4.31931205e-02f, -2.68782191e-02f, 1.00267775e-01f, -3.72804739e-02f, 1.92317870e-02f, 1.19545929e-01f, 1.58637129e-02f, 3.73134762e-02f, 4.95269634e-02f,
  1.29840262e-02f, 2.48406790e-02f, -4.07529287e-02f, -9.86877233e-02f, -5.16934060e-02f, -1.37682892e-02f, -1.50176203e-02f, 4.63809789e-04f, -4.44438681e-02f, 7.29324445e-02f,
  3.13061811e-02f, -6.16363622e-02f, -4.41665798e-02f, -2.22444721e-02f, -1.03114201e-02f, 1.05205607e-02f, -4.23736945e-02f, 1.57584064e-02f, 3.61582562e-02f, 3.66233103e-02f,
  1.47150224e-02f, -2.82031074e-02f, -7.29114860e-02f, 5.92383519e-02f, -1.07401200e-02f, 1.80655550e-02f, 2.21793018e-02f, 3.02789807e-02f, -8.34792480e-02f, 3.13302092e-02f,
  2.03463465e-01f, 3.19649369e-01f, 1.32846693e-02f, -7.85428956e-02f, 2.41205283e-02f, 1.74434688e-02f, 8.59565753e-03f, -8.82732775e-03f, 8.88557658e-02f, -4.58164290e-02f,
  6.80223182e-02f, 1.24430628e-02f, 1.90955505e-01f, -1.25608429e-01f, -6.71632662e-02f, 1.22961784e-02f, 9.32460949e-02f, 7.74771944e-02f, 7.58059248e-02f, 4.26189639e-02f,
  9.50793028e-02f, 1.16854288e-01f, -7.93533679e-03f, -4.57720691e-03f, 1.37689263e-01f, 1.04015663e-01f, -1.92461628e-02f, 2.81926652e-04f, -1.22446287e-02f, 3.30553129e-02f,
  -1.81597695e-01f, 2.73913026e-01f, 1.83159634e-01f, -1.46948546e-01f, -1.24617644e-01f, -1.01526581e-01f, -1.75394773e-01f, 1.28447711e-01f, -7.46565685e-02f, 1.40396720e-02f,
  -2.77537525e-01f, 2.54724622e-01f, 2.99636945e-02f, -1.80607870e-01f, -1.73237592e-01f, 4.28622682e-03f, -2.39026044e-02f, -5.49490638e-02f, 1.21948332e-01f, -5.92699051e-02f,
  -5.91813810e-02f, -2.46986106e-01f, 5.88948503e-02f, 2.33861193e-01f, -1.47875473e-01f, 2.38055915e-01f, -6.33671954e-02f, 1.28347680e-01f, 5.89557029e-02f, 3.10427733e-02f,
  -7.85688087e-02f, -6.60013361e-03f, 3.14597897e-02f, 5.15139103e-02f, -6.45414786e-03f, -7.83755332e-02f, -3.63541730e-02f, 8.12850669e-02f, -4.20888737e-02f, 4.59357463e-02f,
  2.96746921e-02f, 1.80615690e-02f, -1.04678255e-02f, 3.04038562e-02f, -2.54029669e-02f, -1.86358783e-02f, -3.16111632e-02f, 1.88079160e-02f, 1.07693963e-01f, -1.85332366e-03f,
  -4.01927531e-02f, -5.91922291e-02f, -7.33412430e-02f, 6.88042343e-02f, 6.32101819e-02f, -6.50694408e-03f, 1.95279671e-03f, 1.56511217e-01f, 1.08063873e-02f, 7.49763027e-02f,
  8.54539219e-04f, 3.94559354e-02f, -7.54247513e-03f, 3.09459027e-02f, -6.30216524e-02f, -6.74316064e-02f, -4.71594036e-02f, -3.73435579e-02f, 3.40005895e-03f, -4.59889770e-02f,
  -2.93268822e-02f, -3.77886333e-02f, -6.79073557e-02f, -4.30397838e-02f, -4.14330624e-02f, -2.14402527e-02f, -4.49249614e-03f, -3.39420624e-02f, 3.35131735e-02f, -2.15608478e-02f,
  2.29264498e-02f, -4.32790816e-02f, 1.41064757e-02f, -3.03128753e-02f, 4.30654623e-02f, -3.39336470e-02f, -3.96695919e-02f, 1.06266476e-02f, 2.76702754e-02f, -3.87547649e-02f,
  4.73955758e-02f, 2.36958146e-01f, 7.73186535e-02f, 3.23219523e-02f, 5.03895171e-02f, 3.57495509e-02f, -1.75110400e-02f, 1.87850986e-02f, 4.29912060e-02f, -4.77703696e-04f,
  3.78815923e-03f, -4.72885091e-03f, 1.01847332e-02f, 1.76120698e-02f, -1.69282090e-02f, -1.23835009e-04f, -1.02961473e-02f, 4.58562523e-02f, 2.39827577e-02f, 3.11323386e-02f,
  -2.17032637e-02f, -4.79383543e-02f, 1.32614709e-02f, 2.81960070e-02f, 2.45268028e-02f, -2.70681810e-02f, 5.68117984e-02f, -1.21733407e-02f, -4.49611843e-02f, 1.89296510e-02f,
  3.58524993e-02f, 3.82426172e-01f, -2.75799632e-01f, 5.24165705e-02f, 1.06757551e-01f, -2.36200884e-01f, -1.65491328e-01f, 9.22792405e-02f, -8.83753784e-03f, 2.91031420e-01f,
  3.73367872e-03f, 1.23706281e-01f, -1.20229661e-01f, 2.00534180e-01f, -2.93209821e-01f, -1.39805973e-01f, 1.32910043e-01f, 1.23286754e-01f, 2.95825452e-02f, 1.72661662e-01f,
  -6.78515509e-02f, 1.84255451e-01f, -1.31941423e-01f, 7.38709867e-02f, -4.58436497e-02f, -6.91025555e-02f, 1.82401285e-01f, -6.17452003e-02f, 6.37336969e-02f, -1.28375348e-02f,
  -3.38063054e-02f, 1.57973975e-01f, -4.41343077e-02f, -1.91397425e-02f, -5.00653684e-02f, -3.59169617e-02f, -2.63001453e-02f, -6.12692796e-02f, -1.20858029e-01f, -3.00232172e-02f,
  -5.74375764e-02f, -4.35456447e-02f, 1.25270998e-02f, -3.69497538e-02f, -1.62764527e-02f, 7.75621366e-03f, -6.75178319e-02f, 2.42251419e-02f, -4.71858680e-02f, -7.89180472e-02f,
  -9.83168557e-02f, -6.48261905e-02f, -4.50506480e-03f, -7.29389638e-02f, -1.34457156e-01f, -6.90122992e-02f, -8.08936078e-03f, -7.65227899e-02f, -5.70754241e-03f, -1.95920758e-04f,
  1.74234028e-03f, 3.23051587e-02f, 3.68516296e-02f, 7.25123286e-02f, 5.75887337e-02f, -2.80873049e-02f, 7.04761073e-02f, 6.02661856e-02f, 3.78924934e-03f, 5.78021631e-02f,
  3.04798111e-02f, 3.36822751e-03f, 4.61518541e-02f, -4.38055769e-02f, 1.40360733e-02f, 4.47989367e-02f, -6.06167391e-02f, 9.88092199e-02f, 2.80508753e-02f, -5.17394282e-02f,
  2.84342598e-02f, -2.04846635e-02f, 4.22112793e-02f, 4.44819629e-02f, 1.10083465e-02f, -2.34422497e-02f, -3.98838855e-02f, 4.04121652e-02f, -2.19269060e-02f, -1.74942845e-03f,
  2.45851159e-01f, 2.90333837e-01f, 4.96826880e-02f, 1.67386641e-03f, 3.81447040e-02f, 1.94201916e-02f, -4.55568172e-02f, -7.34781474e-02f, 2.32429840e-02f, -2.10428946e-02f,
  -1.91957839e-02f, 4.49468642e-02f, -6.05891272e-02f, 2.38394886e-02f, -6.13056496e-02f, 3.40344897e-03f, 2.32644118e-02f, 4.86786338e-03f, -5.67183131e-04f, 1.01367779e-01f,
  7.76719600e-02f, 3.73119712e-02f, -6.91763610e-02f, -4.33147773e-02f, 3.90678681e-02f, 7.09551498e-02f, 6.01492375e-02f, -1.67117435e-02f, -2.39461847e-02f, -3.25854570e-02f,
  -1.65556177e-01f, 3.71544957e-01f, 2.97987193e-01f, -3.16514038e-02f, -2.05924541e-01f, -1.81245342e-01f, -4.04350907e-02f, 2.05601901e-02f, 1.63427964e-01f, 8.18341449e-02f,
  -1.00546204e-01f, 1.66404858e-01f, 1.44028649e-01f, 1.73001792e-02f, -8.13841447e-02f, 2.94099629e-01f, -1.87286928e-01f, -2.45272256e-02f, 6.88642561e-02f, -4.69962731e-02f,
  -2.16676109e-02f, -2.16251925e-01f, 2.30404794e-01f, -3.30433585e-02f, -3.23084518e-02f, 1.69275805e-01f, -1.85016036e-01f, -3.42983454e-02f, -1.39306977e-01f, -2.92849746e-02f,
  4.00767550e-02f, 1.10280573e-01f, 1.37948021e-01f, 5.01589142e-02f, -4.86616455e-02f, -1.00847490e-01f, -2.02900115e-02f, 6.60869898e-03f, -1.39056463e-02f, 3.90971676e-02f,
  9.42584220e-03f, 6.74700039e-03f, 2.85463240e-02f, -5.76832844e-03f, -9.37601775e-02f, -2.41462346e-02f, 1.34078348e-02f, 5.23000360e-02f, 9.04873759e-02f, 4.65149619e-02f,
  8.42953026e-02f, 3.20549645e-02f, -7.97045305e-02f, 8.44676495e-02f, 3.73726375e-02f, 2.68491022e-02f, 1.07710890e-03f, 4.19178419e-02f, -4.08847481e-02f, -2.54738778e-02f,
  -6.50285110e-02f, 5.56955719e-03f, -4.11388511e-03f, 2.20459644e-02f, 1.79158449e-02f, 5.25894500e-02f, -5.64578399e-02f, -3.21493368e-03f, -4.54100333e-02f, 8.84828046e-02f,
  -9.27779078e-03f, 8.16197193e-04f, -2.23904643e-02f, -3.73162776e-02f, -5.56321479e-02f, 1.55862523e-02f, -1.96797084e-02f, -2.41897255e-02f, -3.05471383e-03f, -3.64465490e-02f,
  2.82560252e-02f, -2.67880186e-02f, 1.43882101e-02f, -2.24896893e-02f, -1.97423901e-02f, -2.39590090e-02f, -2.41929889e-02f, 6.36398122e-02f, -1.62540954e-02f, -1.08108662e-01f,
  -7.19420090e-02f, 6.00339554e-04f, 7.85622466e-03f, -7.11216126e-03f, 5.24918586e-02f, 3.81611055e-03f, -3.67916748e-03f, -1.33120352e-02f, -1.21520581e-02f, -9.95674636e-03f,
  -6.27928227e-02f, -1.01831900e-02f, -7.08875731e-02f, -2.88053378e-02f, 7.24073127e-02f, 3.68862897e-02f, -4.80969399e-02f, 2.12888438e-02f, -1.35760620e-01f, -7.84316659e-02f,
  -8.48374665e-02f, -2.73198597e-02f, -2.41699014e-02f, -4.89379205e-02f, -1.53434753e-01f, -2.99213212e-02f, -1.02343746e-01f, 8.98501277e-02f, -7.24132210e-02f, 4.51883748e-02f,
  3.81871253e-01f, -9.94387120e-02f, 3.06299061e-01f, 9.52688530e-02f, -6.37927949e-02f, -2.26613700e-01f, -2.22431183e-01f, -1.37823775e-01f, -2.06496343e-02f, -3.88382733e-01f,
  -2.49171749e-01f, 1.77529886e-01f, -1.10335611e-01f, -2.20534533e-01f, 1.79096788e-01f, -9.55006331e-02f, 1.90639608e-02f, 6.24582618e-02f, 6.32086471e-02f, -6.11312613e-02f,
  1.17195770e-01f, -2.81496853e-01f, 2.14210048e-01f, -1.81015238e-01f, -2.45738253e-02f, 1.52394190e-01f, 5.54059446e-02f, 7.55488947e-02f, -4.79423301e-03f, 4.29355204e-02f,
  -7.59058744e-02f, -2.16132700e-02f, 1.18544862e-01f, 1.00586109e-01f, 4.04881388e-02f, 1.61671769e-02f, 9.51360259e-03f, 8.07655156e-02f, -1.06633678e-02f, -6.04831427e-02f,
  7.11847842e-02f, -8.45973101e-03f, -3.98806930e-02f, -7.05846027e-02f, -1.84269771e-02f, 7.71358386e-02f, 4.82605435e-02f, 2.22403966e-02f, -3.28207053e-02f, 1.94521118e-02f,
  2.14418452e-02f, -3.52877863e-02f, -3.14374156e-02f, 5.58280479e-03f, 8.70542452e-02f, -7.24338517e-02f, -1.84181035e-02f, -2.27426197e-02f, -3.46555896e-02f, -6.11340180e-02f,
  -3.70928906e-02f, 6.06431346e-03f, -1.45078804e-02f, -2.30053496e-02f, 9.45579261e-02f, -8.70110095e-02f, -3.95722985e-02f, 2.17952970e-02f, 9.38032269e-02f, -6.03243113e-02f,
  2.52687261e-02f, 5.84013872e-02f, -7.41395801e-02f, -4.39043529e-02f, -7.44162779e-03f, 2.18669157e-02f, 5.16186431e-02f, 3.13500799e-02f, 4.24704403e-02f, 2.96497159e-02f,
  -2.39463709e-02f, 5.74972928e-02f, -4.21462171e-02f, 5.61954156e-02f, -8.67967159e-02f, 3.77144031e-02f, -5.12475297e-02f, 3.07293218e-02f, -1.53996227e-02f, 9.40166265e-02f,
  -1.69925839e-01f, -1.02059536e-01f, -5.46493717e-02f, 3.13647762e-02f, 5.34823388e-02f, -7.62852654e-02f, 1.48312291e-02f, -3.05922329e-02f, -2.99016386e-02f, 6.99284283e-05f,
  -2.93911994e-02f, -5.47615625e-02f, -5.68916202e-02f, 4.05696640e-03f, 7.77806714e-02f, -1.09723493e-01f, 3.42873745e-02f, 3.20819914e-02f, 4.94525544e-02f, -8.50422531e-02f,
  -4.39045206e-02f, -1.48811750e-02f, 4.65167239e-02f, -4.60998937e-02f, -4.76867110e-02f, -1.81420539e-02f, -1.12374321e-01f, 4.03399616e-02f, 4.85029742e-02f, -5.03033586e-02f,
  2.42191702e-01f, -1.27432808e-01f, 3.77538577e-02f, 3.92406672e-01f, -9.90127847e-02f, 2.68071536e-02f, 1.62678212e-01f, 8.06603860e-03f, 1.40652150e-01f, -1.31193474e-01f,
  9.36987400e-02f, -1.61965918e-02f, 2.05381718e-02f, 1.98958486e-01f, 4.12716061e-01f, 1.99639991e-01f, 2.79122531e-01f, 4.80490795e-04f, 8.68631601e-02f, 1.05080605e-01f,
  1.57053158e-01f, 1.63541153e-01f, 1.47118613e-01f, -1.57450348e-01f, -1.02941900e-01f, -2.17203572e-02f, 1.22738458e-01f, -1.14551589e-01f, -8.16852078e-02f, -2.28458364e-02f,
  -1.27854109e-01f, 4.84884046e-02f, -3.73986885e-02f, -2.67871339e-02f, 7.68503472e-02f, -1.15126729e-01f, -6.61473945e-02f, 3.41521837e-02f, -1.60095468e-02f, -2.16616187e-02f,
  -1.86792705e-02f, 1.46209970e-02f, 1.05620891e-01f, 4.20187190e-02f, -4.73451205e-02f, 2.21586367e-03f, -2.82307547e-02f, -7.83410072e-02f, 5.64920669e-03f, 6.97442144e-02f,
  -1.51580255e-02f, -2.29333062e-03f, 7.45073939e-03f, 5.86740039e-02f, 4.08179015e-02f, 3.58448811e-02f, 2.35013943e-02f, 3.49121541e-02f, 1.93646532e-02f, 6.63542151e-02f,
  2.48741489e-02f, -4.62223450e-03f, 1.82338117e-03f, -4.23408262e-02f, 1.55673530e-02f, -3.62029858e-02f, -1.82385091e-02f, -1.98142994e-02f, 2.90397764e-03f, 1.31573258e-02f,
  3.85223441e-02f, 2.43142643e-03f, 1.27131213e-02f, -4.07395437e-02f, 2.95069944e-02f, 7.70257926e-03f, -7.69442245e-02f, -2.76313722e-02f, 4.20519151e-02f, 2.09847931e-02f,
  -4.61719185e-02f, 1.59510914e-02f, -4.27162051e-02f, -2.84175947e-02f, -4.35307920e-02f, 3.39865126e-02f, 2.72715073e-02f, -8.88004750e-02f, 2.01871525e-02f, 8.91757160e-02f,
  7.74702281e-02f, 2.01686919e-01f, -7.82097876e-03f, -4.37505841e-02f, 1.05763851e-02f, 2.62905564e-02f, 7.50272870e-02f, 1.31580960e-02f, -8.18780903e-03f, 3.03452350e-02f,
  2.84132995e-02f, 2.74977810e-03f, -6.54217675e-02f, -5.68670109e-02f, 8.36267881e-03f, -3.24221328e-02f, -2.08937656e-02f, 4.28748690e-02f, 1.03748910e-01f, 1.96403079e-02f,
  -3.36558372e-02f, -2.51195394e-02f, 8.02227929e-02f, -5.10064662e-02f, -3.58071625e-02f, 2.77142711e-02f, -1.91579722e-02f, -5.53406328e-02f, 2.02538148e-02f, -3.66915204e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.29502338e-01f, -8.82240236e-02f, -1.41996637e-01f, -2.16556609e-01f, 1.99492633e-01f, 1.77889138e-01f, 4.26680408e-03f, 1.09307230e-01f, -4.01660651e-02f, 1.12371042e-01f,
  6.10746965e-02f, -4.10369813e-01f, 2.41374485e-02f, -4.30896133e-01f, -4.30105686e-01f, -3.10592979e-01f, -3.03191334e-01f, -2.24244192e-01f, -2.09582493e-01f, -4.93944846e-02f,
  -1.81769520e-01f, -1.35693386e-01f, -1.49427846e-01f, 7.30052590e-02f, 2.86677200e-02f, 6.99751228e-02f, 3.12588215e-01f, 1.65123135e-01f, -7.39215314e-03f, -1.39632553e-01f,
  3.38711478e-02f, 1.60089985e-01f, 1.06619976e-01f, 3.19285765e-02f, 1.51745796e-01f, 1.37603611e-01f, 2.62444261e-02f, -7.21942559e-02f, 2.80048084e-02f, -3.24160606e-02f,
  -2.38054544e-02f, -5.02731577e-02f, -1.60662144e-01f, -1.25529557e-01f, 9.56415683e-02f, -1.34635037e-02f, -1.15250930e-01f, -3.12759168e-02f, 2.43978854e-02f, -1.87205970e-01f,
  -4.77117337e-02f, -1.11949079e-01f, 2.10128375e-03f, -1.40106261e-01f, -9.18839276e-02f, 6.39479384e-02f, -8.17363411e-02f, 3.76017066e-04f, 2.13263538e-02f, -1.06178343e-01f,
  -5.90381399e-02f, -2.47745570e-02f, 6.14932105e-02f, -3.61097194e-02f, -6.05419744e-03f, 4.33702767e-02f, -3.51257324e-02f, -4.39695008e-02f, 2.62655434e-03f, 9.12600085e-02f,
  2.52516959e-02f, -6.21584542e-02f, -1.41292131e-02f, 1.99357998e-02f, -1.11471206e-01f, -6.35211319e-02f, -5.17795272e-02f, -7.36045986e-02f, -5.95166534e-02f, 1.74169652e-02f,
  5.80331683e-02f, -5.44533581e-02f, -5.66311628e-02f, 5.73511496e-02f, 9.58972201e-02f, 2.59629674e-02f, 2.08321270e-02f, -6.24842010e-02f, 7.45867565e-02f, 4.96307872e-02f,
  1.86636180e-01f, 1.86954975e-01f, 1.05488136e-01f, 3.16463523e-02f, 5.45153022e-02f, 7.77563900e-02f, -2.21796595e-02f, -6.76114112e-02f, 5.39114326e-02f, 2.59515867e-02f,
  9.54474285e-02f, 4.10475433e-02f, 1.29816398e-01f, -5.28421849e-02f, 4.83497903e-02f, 9.43275094e-02f, 6.66453987e-02f, 9.39804874e-03f, 1.82551160e-01f, 9.10787955e-02f,
  5.81947416e-02f, 5.39113209e-02f, -6.40323162e-02f, 2.30778661e-02f, 1.15945581e-02f, 1.96575150e-02f, 1.05747797e-01f, 4.28573526e-02f, -1.04832910e-02f, 1.12367226e-02f,
  -2.00311035e-01f, 4.31194067e-01f, 2.00483263e-01f, -1.71196431e-01f, 1.10856317e-01f, 6.13887142e-03f, -1.61929086e-01f, 2.26733666e-02f, -5.03601395e-02f, 1.96226135e-01f,
  -8.67906511e-02f, 2.82035202e-01f, -3.54173295e-02f, -7.44076595e-02f, -4.13009405e-01f, -3.08303207e-01f, -2.00113967e-01f, -1.19953349e-01f, -1.69519544e-01f, 7.37557635e-02f,
  -2.71911144e-01f, -2.90209174e-01f, -1.87847897e-01f, 7.05721378e-02f, 1.30637631e-01f, 1.35189787e-01f, -1.99994802e-01f, 1.13460943e-02f, 1.30390599e-01f, -8.88142213e-02f,
  -6.87638763e-03f, -5.52435741e-02f, 7.47963786e-02f, 1.54261384e-02f, -4.41992879e-02f, 4.07088622e-02f, 5.96457049e-02f, -2.47888248e-02f, -1.69686023e-02f, 9.83662624e-03f,
  9.40137953e-02f, -1.21865841e-03f, 4.75137047e-02f, -6.34005293e-02f, 8.15647170e-02f, 6.36969507e-02f, 1.65784180e-01f, 8.88610408e-02f, 1.14891790e-01f, 8.17460269e-02f,
  8.66234824e-02f, 1.36407480e-01f, 5.55144809e-02f, 1.65869631e-02f, -3.52628641e-02f, -1.10447118e-02f, -4.95822430e-02f, 1.35439523e-02f, -1.30331115e-04f, 3.97943407e-02f,
  4.82942536e-02f, -3.06427963e-02f, -9.29932967e-02f, 6.56716675e-02f, -1.04412824e-01f, -2.77441610e-02f, -3.14876251e-02f, -7.94509053e-02f, 1.31686917e-02f, 1.39377192e-02f,
  -6.01277500e-02f, 1.28838152e-01f, -5.59938401e-02f, 6.21939562e-02f, -1.41550796e-02f, 7.02482685e-02f, 7.49002770e-02f, -3.12756635e-02f, 2.09009685e-02f, 2.17151158e-02f,
  -3.73768210e-02f, 2.84774061e-02f, -5.12142479e-02f, 4.42011170e-02f, -7.60611221e-02f, -5.38795553e-02f, 1.62916686e-02f, 1.61027797e-02f, -9.86844301e-03f, -1.37024432e-01f,
  -1.99685022e-01f, -1.68795213e-01f, 5.19278198e-02f, -7.39306631e-03f, 3.87962572e-02f, 4.49140444e-02f, 8.77043977e-03f, 2.10948680e-02f, -7.97759518e-02f, -2.26500705e-02f,
  -3.45071480e-02f, -3.62195484e-02f, 1.28679620e-02f, -1.51787940e-02f, -1.06947802e-01f, -4.44612913e-02f, -7.97544718e-02f, 3.97153897e-03f, -1.60672069e-02f, -7.56904557e-02f,
  6.95563704e-02f, -4.79374714e-02f, -4.26174328e-02f, 1.69252534e-03f, -3.61777539e-03f, -2.16906099e-03f, 1.36496201e-02f, -4.91386047e-04f, -6.41657487e-02f, 8.93023890e-03f,
  -3.11809242e-01f, -4.52409387e-01f, 5.46366461e-02f, -7.67332409e-03f, 4.00654301e-02f, 1.66745201e-01f, 8.81243646e-02f, -2.72080570e-01f, -3.09778869e-01f, -2.10206389e-01f,
  8.51475969e-02f, 4.35398780e-02f, 1.34542631e-02f, 2.76479542e-01f, 4.11616743e-01f, 3.98607068e-02f, 2.24084556e-01f, 2.67785788e-01f, -1.70172025e-02f, -1.04353301e-01f,
  4.50071655e-02f, 2.07899153e-01f, 2.98091441e-01f, 5.50579466e-03f, 7.58808758e-03f, -1.24333434e-01f, 1.25616103e-01f, 1.68467641e-01f, 1.04129754e-01f, 2.93473661e-01f,
  -2.46910170e-01f, -2.77628630e-01f, 8.49481113e-03f, -7.60023743e-02f, -1.87286958e-01f, -5.32130562e-02f, 1.03776857e-01f, 2.31126219e-01f, 7.33202174e-02f, 4.51349281e-02f,
  1.81117337e-02f, 3.26541588e-02f, 5.98806702e-02f, 3.11460346e-02f, -9.50038359e-02f, -1.23191379e-01f, -6.14056289e-02f, 1.06789852e-02f, -1.05316460e-01f, -6.24187514e-02f,
  -5.16492352e-02f, -3.75695266e-02f, -4.38890643e-02f, -4.97436943e-03f, 4.72854115e-02f, 3.38825658e-02f, 4.75851782e-02f, -4.72420565e-04f, -1.09288029e-01f, -9.46250483e-02f,
  8.53070840e-02f, 7.86758512e-02f, -1.02751702e-01f, -5.36893047e-02f, 3.98423113e-02f, -5.31893186e-02f, 2.53580585e-02f, 1.85843304e-01f, 4.35214117e-02f, 2.46781800e-02f,
  2.53502466e-02f, 3.91863473e-02f, -9.02931318e-02f, -4.28687818e-02f, -2.95067374e-02f, -3.44184414e-02f, 9.50823203e-02f, -9.41828638e-03f, -4.22514156e-02f, -3.42533691e-03f,
  1.05786301e-01f, -7.68200960e-03f, 2.77157594e-02f, 4.18969691e-02f, 4.86951582e-02f, -4.17379886e-02f, -6.81285039e-02f, -3.51869017e-02f, -5.60955331e-02f, 1.10524237e-01f,
  -5.78239322e-01f, -3.76655668e-01f, -4.21065651e-03f, -2.70220684e-03f, 8.93849656e-02f, -3.64338607e-02f, -5.25318645e-03f, -6.87921941e-02f, -4.24930900e-02f, -1.18030533e-01f,
  -9.58163738e-02f, 1.02292471e-01f, -1.78684831e-01f, 1.93997826e-02f, 7.00699389e-02f, -9.04148966e-02f, 2.32705921e-02f, -5.24606109e-02f, 8.13755766e-02f, -7.36173242e-02f,
  -1.91022214e-02f, -1.31759092e-01f, 1.37209907e-01f, -3.12376805e-02f, 1.17255305e-03f, 4.62629087e-02f, -3.57393622e-02f, -3.10835341e-04f, 8.38898197e-02f, -3.21831293e-02f,
  2.45875537e-01f, -2.87626892e-01f, 2.30934307e-01f, 3.94208372e-01f, 2.12477192e-01f, -2.59873241e-01f, 1.25802875e-01f, 1.93657771e-01f, 1.64511323e-01f, -5.38647652e-01f,
  -3.24630365e-02f, -1.70354247e-01f, 3.12534161e-02f, -1.12572692e-01f, 3.16987038e-01f, 5.35991602e-02f, 1.88771859e-01f, -1.46960095e-01f, 3.14166397e-01f, 1.89094290e-01f,
  3.89165759e-01f, 9.63364393e-02f, 4.32838351e-01f, 1.72072072e-02f, 2.10667267e-01f, 8.99776071e-02f, 2.31097609e-01f, 1.44201666e-01f, -1.23087123e-01f, -1.35489136e-01f,
  -1.47395894e-01f, 1.83734015e-01f, 7.51853511e-02f, -2.10321724e-01f, 1.68154426e-02f, -9.58612561e-02f, -5.89340404e-02f, -1.04564607e-01f, 1.37622297e-01f, 3.91950086e-02f,
  -1.75583288e-01f, -1.95831582e-02f, -3.81552018e-02f, 8.45364202e-03f, 6.36337176e-02f, 5.53489216e-02f, 5.08363992e-02f, 7.20493123e-02f, 9.87147447e-03f, -2.64558233e-02f,
  1.01889290e-01f, -1.27006754e-01f, 1.22425601e-01f, -1.61039725e-01f, 1.59786433e-01f, 1.86663345e-02f, -4.29755077e-02f, -3.41934785e-02f, -4.92499620e-02f, 4.87877391e-02f,
  1.52269989e-01f, 4.80195247e-02f, -1.29141659e-01f, 2.00309195e-02f, -4.43721861e-02f, 4.63105440e-02f, 6.67034686e-02f, -2.94122566e-02f, -9.14987735e-03f, 5.77138290e-02f,
  2.67959479e-02f, 1.09698080e-01f, 1.53368628e-02f, -9.60675851e-02f, 4.67961989e-02f, -2.01306287e-02f, -2.14336277e-03f, -9.22541246e-02f, 3.43287401e-02f, 9.32560340e-02f,
  1.37986660e-01f, -6.20982572e-02f, 5.50282672e-02f, 9.62785818e-03f, -7.22385943e-02f, 4.30641025e-02f, -1.91986486e-02f, -4.47320044e-02f, 4.23466004e-02f, 5.23877218e-02f,
  -3.81349295e-01f, -7.49963615e-03f, 2.68869270e-02f, -8.96161944e-02f, -1.82021156e-01f, -3.07612289e-02f, 5.11978306e-02f, 2.38820799e-02f, 3.16972323e-02f, 2.86621116e-02f,
  -3.93825434e-02f, -2.94692232e-03f, -2.58091111e-02f, -2.42138319e-02f, -8.25900808e-02f, 3.07749864e-02f, -6.03705885e-05f, -1.43839762e-01f, -3.19175385e-02f, 1.05428010e-01f,
  -2.29909923e-02f, -8.39475170e-02f, -5.02527133e-02f, 1.86958343e-01f, -2.43701544e-02f, 3.14554642e-03f, -8.33186954e-02f, -6.79261237e-02f, 5.10752946e-02f, -2.73318496e-03f,
  -3.39486077e-02f, 2.17895120e-01f, 1.85984850e-01f, 7.96335116e-02f, 1.67249113e-01f, 3.41580629e-01f, 3.90933007e-01f, 3.10482264e-01f, 4.45741594e-01f, -1.11199263e-02f,
  -2.34188125e-01f, 1.89248994e-01f, -1.29872918e-01f, -7.65849650e-02f, -6.50842711e-02f, -5.26478700e-02f, 1.79832980e-01f, -3.37863751e-02f, 2.86929339e-01f, 1.92481969e-02f,
  -3.24628390e-02f, -2.18510196e-01f, -1.63708627e-01f, -3.14084664e-02f, -2.55210735e-02f, 3.95327657e-02f, -3.84074926e-01f, 1.33672848e-01f, -1.32701814e-01f, 1.17290229e-01f,
  1.05079301e-01f, 8.22564587e-02f, -2.46252306e-02f, 1.02882423e-01f, -5.08966818e-02f, 1.22870751e-01f, -2.73258947e-02f, 8.33355263e-03f, 9.65349153e-02f, 8.83273855e-02f,
  -1.31081313e-01f, 3.13406922e-02f, 2.04121962e-01f, -6.06244728e-02f, 9.67447981e-02f, 1.14292182e-01f, 3.09788920e-02f, -2.55467091e-02f, 5.99972121e-02f, -5.88323958e-02f,
  -1.13226876e-01f, -1.33992946e-02f, -7.05674738e-02f, -3.05218529e-02f, 1.37542596e-03f, 1.83201849e-01f, 1.11683317e-01f, -6.14770092e-02f, -8.38383939e-03f, 1.73212454e-01f,
  -1.36955520e-02f, 4.88068014e-02f, -2.73395590e-02f, -1.12862036e-01f, -4.22427021e-02f, -2.15430651e-02f, -1.80681311e-02f, 2.66825333e-02f, 9.76162329e-02f, -1.31353840e-01f,
  -5.93133084e-02f, 4.45868298e-02f, -8.53484198e-02f, -7.13146711e-03f, 5.15063889e-02f, 3.43741570e-03f, -1.19174104e-02f, -1.07124694e-01f, 4.26062644e-02f, -1.24534413e-01f,
  3.90681066e-02f, 1.16989613e-02f, 1.51358983e-02f, 1.69218108e-02f, 5.33079505e-02f, 8.45169276e-03f, -2.76358034e-02f, 1.02040283e-01f, -1.11561500e-01f, -1.25489533e-01f,
  6.06737994e-02f, 1.40439346e-01f, -5.71913123e-02f, -1.76210608e-02f, -5.55130839e-02f, 5.77760972e-02f, 4.59493697e-02f, 8.11361521e-02f, 1.35612890e-01f, 6.96344972e-02f,
  3.20137627e-02f, 5.69918714e-02f, 4.05328684e-02f, -8.54243934e-02f, -1.62904579e-02f, 8.03660601e-02f, 1.38163045e-02f, -2.96019614e-02f, 1.68905836e-02f, 2.48528644e-02f,
  -2.00011998e-01f, 1.10459402e-01f, 3.64586711e-03f, -2.21118666e-02f, 4.29735286e-03f, -1.62578687e-01f, 5.20012677e-02f, -2.50532385e-02f, -7.75309056e-02f, 1.27548948e-01f,
  4.54077750e-01f, -2.31017753e-01f, -1.23953506e-01f, 2.77187139e-01f, 1.78705260e-01f, 3.20484564e-02f, 2.29849620e-03f, 1.37215182e-01f, 4.79162127e-01f, 3.09927333e-02f,
  -3.14289108e-02f, -1.23298183e-01f, -3.40052009e-01f, 8.03657398e-02f, 5.09042945e-03f, -1.28996521e-01f, 1.88053340e-01f, 1.14552811e-01f, 7.36041516e-02f, 9.67367515e-02f,
  3.00245851e-01f, 3.87578830e-02f, -1.80698216e-01f, -7.73382634e-02f, -8.05283152e-03f, -7.33322185e-03f, -2.22398460e-01f, -2.17439115e-01f, -1.41962439e-01f, -1.75962716e-01f,
  3.43105458e-02f, 5.09232245e-02f, -5.35755195e-02f, -2.97195837e-02f, -4.96752821e-02f, 2.40757521e-02f, -1.20951056e-01f, -1.85411960e-01f, 3.93774398e-02f, -8.26656967e-02f,
  -6.06495552e-02f, 9.78891551e-03f, 3.23044993e-02f, -1.79921258e-02f, 1.36339679e-01f, -5.39772073e-03f, 2.08022594e-02f, 7.38160610e-02f, -7.24442974e-02f, 1.02145262e-02f,
  7.58305341e-02f, -6.58327267e-02f, 4.16482165e-02f, -4.21236157e-02f, -1.24384828e-01f, -3.49398777e-02f, -2.34939307e-02f, -1.81895390e-01f, -4.23015431e-02f, 3.30733284e-02f,
  -3.36795188e-02f, 6.46018758e-02f, -6.26209304e-02f, 2.25897897e-02f, -4.90836315e-02f, -4.93779127e-03f, 7.95752034e-02f, -3.20016444e-02f, -8.18404276e-03f, 7.03843031e-03f,
  1.02921501e-01f, -4.88330945e-02f, 8.29032287e-02f, 6.01124838e-02f, 5.37999161e-02f, 1.23482905e-01f, -1.11470997e-01f, -5.51653765e-02f, 6.19057007e-02f, 7.16434047e-02f,
  -3.67140919e-02f, 1.04906000e-01f, -7.75532573e-02f, -8.97767916e-02f, 5.08745909e-02f, -2.76742633e-02f, -7.05647096e-02f, -7.85084218e-02f, 5.24801947e-02f, -5.62926531e-02f,
  -7.70286471e-02f, -1.37700781e-01f, 1.15108229e-02f, 2.07974222e-02f, -4.16097119e-02f, 1.52599020e-02f, 3.07527874e-02f, 8.52548331e-02f, 1.34541402e-02f, 9.26388651e-02f,
  -6.16254620e-02f, 4.92998883e-02f, 8.16403553e-02f, 1.18668210e-02f, 2.22604331e-02f, -6.60206750e-02f, -1.65418144e-02f, 2.24884581e-02f, 2.93303523e-02f, -4.53907214e-02f,
  3.69389430e-02f, 4.57555205e-02f, 4.19315323e-02f, 5.15545681e-02f, -6.36965334e-02f, -2.04303092e-03f, 6.03791662e-02f, -7.18558878e-02f, -7.15907216e-02f, -8.81104637e-03f,
  4.73695785e-01f, -1.77464530e-01f, 3.39690447e-01f, 2.16665983e-01f, 2.49373809e-01f, 1.56946242e-01f, 3.68628830e-01f, 1.21499933e-01f, 2.31124118e-01f, -2.15151832e-01f,
  -4.85852920e-02f, 9.90275294e-03f, 2.47288533e-02f, -2.08614141e-01f, 2.12364256e-01f, -1.12143755e-01f, -2.05908358e-01f, -1.27684712e-01f, 2.83183362e-02f, -1.22511119e-01f,
  6.52254149e-02f, -2.63149887e-01f, 1.20735049e-01f, -4.56871450e-01f, 3.35806683e-02f, -1.14913369e-02f, -3.08229566e-01f, 7.93432146e-02f, -3.12077880e-01f, 2.29181293e-02f,
  -7.52838999e-02f, 4.15992104e-02f, -9.07976553e-02f, -1.15959316e-01f, 2.56694425e-02f, 7.68447742e-02f, 4.47913818e-03f, 2.85611618e-02f, 1.17082067e-01f, 4.70844544e-02f,
  3.28033976e-02f, -1.65734161e-02f, -1.40601233e-01f, 2.80304477e-02f, 4.70231138e-02f, 5.37072122e-02f, 9.71278250e-02f, 1.39226792e-02f, -6.43501654e-02f, 1.24882415e-01f,
  1.60567775e-01f, 2.70999484e-02f, 6.43124580e-02f, -1.51326016e-01f, -3.73508520e-02f, -4.09501456e-02f, 5.43181337e-02f, 4.26041298e-02f, 9.29715708e-02f, 7.32645839e-02f,
  -1.41636208e-01f, -1.17710643e-01f, 5.75049743e-02f, 1.18725024e-01f, 1.02028020e-01f, 2.89326347e-03f, -2.84653157e-02f, 1.43582569e-02f, -5.96799813e-02f, 5.76823726e-02f,
  -2.07342251e-04f, -3.15192714e-02f, 4.65487465e-02f, 4.70126234e-02f, -8.65302086e-02f, 4.45063040e-02f, -5.59780486e-02f, -7.22447634e-02f, -2.02378072e-03f, -8.50927755e-02f,
  -2.79081799e-02f, -7.02990964e-02f, -1.27098744e-03f, 1.18178055e-01f, 1.09353349e-01f, 9.00046825e-02f, -4.74140160e-02f, 1.28268182e-01f, -6.39494788e-03f, -1.38605058e-01f,
  -2.83027053e-01f, -5.08439064e-01f, -9.53918248e-02f, -8.80046114e-02f, -9.09804553e-02f, -7.72772357e-02f, -1.88077763e-01f, -7.89162442e-02f, -8.50415826e-02f, 1.93265285e-02f,
  -5.03484951e-03f, 2.23179907e-03f, -4.63850051e-03f, 1.00690901e-01f, -1.88083559e-01f, -2.43177079e-02f, -1.46525413e-01f, -1.44675985e-01f, -1.29711553e-01f, -6.03552051e-02f,
  -1.11814246e-01f, -3.79770845e-02f, 1.92285441e-02f, -7.31275231e-02f, -5.56659885e-02f, -1.93218142e-02f, 4.98277601e-04f, -6.67164624e-02f, -1.30765056e-02f, -4.59410772e-02f,
  -5.86442649e-01f, 1.17046639e-01f, -4.75589149e-02f, 3.84896547e-01f, -4.30162013e-01f, -3.52126241e-01f, 1.34742409e-01f, -8.22541341e-02f, 1.17739066e-02f, 3.57013345e-01f,
  2.42637739e-01f, -3.45646054e-01f, 3.20647210e-01f, 4.18794721e-01f, -2.75358379e-01f, 4.25875127e-01f, 3.66387814e-01f, 1.73496634e-01f, 1.57069117e-02f, -6.46455437e-02f,
  7.46075958e-02f, 2.75490016e-01f, 2.51480609e-01f, -1.54416263e-02f, -5.96655272e-02f, -6.71022162e-02f, 2.10208952e-01f, -5.62701523e-02f, 1.98618785e-01f, -2.58405507e-01f,
  -1.68875575e-01f, -5.69399782e-02f, -2.81674005e-02f, -1.00343674e-01f, -1.26123086e-01f, -5.51211759e-02f, -6.54927641e-02f, -1.31577760e-01f, 8.18033051e-03f, -5.86245470e-02f,
  -1.65919796e-01f, -9.10582021e-02f, -3.00750770e-02f, 1.08677391e-02f, -1.48723468e-01f, 1.40314670e-02f, -3.32879983e-02f, 4.94813696e-02f, 1.27765043e-02f, -2.04707179e-02f,
  2.93003265e-02f, 9.26022530e-02f, 4.15300392e-02f, 1.12658903e-01f, -3.82661819e-02f, -4.68533486e-02f, 1.06679924e-01f, -3.35229151e-02f, -9.48650613e-02f, -2.23463550e-02f,
  -1.77937090e-01f, -5.90670593e-02f, -4.65891249e-02f, 2.87144165e-02f, -2.69699264e-02f, 2.79303249e-02f, 3.90695743e-02f, 4.33881991e-02f, -3.38821672e-02f, 5.81302755e-02f,
  -3.29172052e-02f, 1.50783909e-02f, -5.42152785e-02f, 4.20937464e-02f, 3.69987935e-02f, -4.51808907e-02f, 3.85087705e-03f, -7.38419890e-02f, -1.23812156e-02f, 4.84037027e-02f,
  2.10521277e-02f, -1.54511616e-01f, -2.75483690e-02f, 4.47376817e-02f, 5.20143583e-02f, 4.40131016e-02f, 4.44314629e-02f, -1.00045158e-02f, 1.79005685e-04f, -9.18111652e-02f,
  -3.30090195e-01f, -8.49686563e-02f, 5.08227618e-04f, -1.88833416e-01f, -1.93318911e-02f, -4.67411056e-03f, 1.51912041e-04f, -6.55730143e-02f, -1.70841757e-02f, -8.40930939e-02f,
  -9.46445242e-02f, 7.20909834e-02f, -3.09410300e-02f, -8.82964134e-02f, 2.49149520e-02f, 3.91421504e-02f, 1.28646810e-02f, 9.32368729e-03f, -7.48627633e-02f, -6.65194988e-02f,
  -4.83376458e-02f, -5.66197969e-02f, -3.44743766e-02f, 3.61844636e-02f, 1.13704093e-01f, -2.28809491e-02f, -7.37063438e-02f, -5.60436770e-02f, -3.08947396e-02f, 4.56321724e-02f,
  3.35925996e-01f, -3.77470165e-01f, 6.22268058e-02f, 2.30959624e-01f, 1.81453511e-01f, -8.60547274e-02f, -8.77099410e-02f, 3.56622562e-02f, 2.05308154e-01f, -2.13776737e-01f,
  -1.61962975e-02f, 8.24218383e-04f, -4.15916145e-01f, 1.43986568e-01f, -1.47028551e-01f, -3.15078497e-01f, 8.50306973e-02f, -2.26866771e-02f, 9.98303443e-02f, 6.66735321e-03f,
  1.30832821e-01f, -1.40877739e-01f, 4.09424827e-02f, -4.77378070e-02f, 9.23974067e-02f, 1.46711007e-01f, -1.73394322e-01f, -1.31424576e-01f, 9.63501558e-02f, -8.43004361e-02f,
  5.43396734e-03f, 1.25683114e-01f, 9.74089876e-02f, 2.93775275e-02f, 7.80666098e-02f, 7.49507500e-03f, -2.66517345e-02f, 4.43512164e-02f, 7.19939545e-02f, 2.37184428e-02f,
  -2.75829565e-02f, 1.03795916e-01f, 9.18769613e-02f, -1.27097473e-01f, 7.77858123e-02f, 1.00456581e-01f, 1.07213125e-01f, 1.24324299e-01f, 7.50258416e-02f, 3.96581180e-02f,
  7.16734007e-02f, 1.08152330e-01f, 1.64556637e-01f, 5.04357144e-02f, 4.74612899e-02f, 8.78647417e-02f, 5.90897612e-02f, 6.79233996e-03f, -3.31711508e-02f, 9.19499174e-02f,
  -5.36573641e-02f, -1.82840582e-02f, -3.05839982e-02f, 8.72363970e-02f, 5.98593019e-02f, 4.83099185e-02f, 1.96336340e-02f, 4.12971936e-02f, -1.00834752e-02f, 2.17826590e-02f,
  5.09729907e-02f, -7.47566298e-02f, -5.02631254e-03f, 9.66428518e-02f, -7.65052624e-03f, 9.02580172e-02f, 2.85294652e-02f, -4.19269595e-03f, 3.37993987e-02f, 1.03297248e-01f,
  6.22028206e-03f, 3.09980772e-02f, -9.31120664e-02f, 7.53702521e-02f, 2.49344800e-02f, -7.71625638e-02f, 9.94420648e-02f, -4.04425748e-02f, 5.17914854e-02f, 1.15417840e-03f,
  -2.16025561e-01f, -4.39335883e-01f, 4.79706004e-03f, 2.72465893e-03f, -1.69793695e-01f, 1.18752914e-02f, -4.20351475e-02f, 6.13368377e-02f, -9.23848227e-02f, -3.73571999e-02f,
  2.41330899e-02f, 8.20886940e-02f, -5.31674847e-02f, 8.11675191e-02f, -1.14985064e-01f, -7.22242519e-02f, -5.95372990e-02f, -7.70964399e-02f, -1.12191364e-01f, 7.93461055e-02f,
  6.48501888e-03f, -4.17919904e-02f, -1.79820266e-02f, 3.82730141e-02f, 6.08847961e-02f, -9.05482545e-02f, 2.72177067e-02f, -4.67160065e-03f, 1.16341803e-02f, -6.18945695e-02f,
  3.56935740e-01f, 2.99309671e-01f, 2.97077835e-01f, 4.90368366e-01f, -1.92816466e-01f, -2.95647025e-01f, -5.49664311e-02f, 1.43754467e-01f, 4.34534065e-02f, -2.35044137e-02f,
  -7.42397681e-02f, 2.35038996e-01f, -1.75602660e-01f, 3.29616964e-01f, -3.00022304e-01f, -1.16492376e-01f, 1.98841035e-01f, 7.93507993e-02f, -1.02661833e-01f, 1.98562145e-01f,
  7.65528828e-02f, -2.88161673e-02f, 1.22851156e-01f, -1.98302612e-01f, 1.81723922e-01f, 1.60420164e-01f, -1.10972300e-01f, -1.68172404e-01f, 2.22303033e-01f, -1.53506905e-01f,
  7.95403570e-02f, 1.41032979e-01f, 1.87626645e-01f, 4.17174324e-02f, 9.09421891e-02f, -5.93709499e-02f, 4.58461121e-02f, -1.11026809e-01f, -8.68415460e-02f, 8.41975212e-02f,
  1.32925183e-01f, -8.45333412e-02f, -8.72995518e-03f, 4.32739668e-02f, 8.61715823e-02f, 6.89825416e-02f, 1.38025060e-01f, 1.00553282e-01f, 5.76827563e-02f, 1.78153247e-01f,
  1.72629029e-01f, 1.36185989e-01f, 7.32763186e-02f, 7.99684376e-02f, -6.90809544e-03f, 2.71423664e-02f, -1.13066509e-02f, 7.41664097e-02f, 2.88789463e-03f, 2.22285166e-02f,
  8.47203732e-02f, -8.38357061e-02f, -1.76252164e-02f, 3.92788611e-02f, 8.05367678e-02f, 1.64078604e-02f, 5.86941652e-02f, -1.63240522e-01f, 4.80535366e-02f, -5.24005666e-03f,
  -1.24821045e-01f, 1.93278462e-01f, 6.72706077e-03f, -5.53704128e-02f, 4.93624024e-02f, 7.98880085e-02f, -1.30309880e-01f, 4.56652530e-02f, 6.71160370e-02f, 5.54651245e-02f,
  -1.70290433e-02f, -6.48701116e-02f, 1.93884317e-02f, -8.72408506e-03f, -1.11865647e-01f, -3.79854813e-03f, 5.50834239e-02f, 1.61571041e-01f, -9.80334580e-02f, -1.09351024e-01f,
  -3.10458504e-02f, -7.44909560e-03f, 4.74235304e-02f, 1.81469899e-02f, 2.77677197e-02f, -4.39364314e-02f, -1.22636016e-02f, 1.25870168e-01f, -9.65295732e-02f, -1.11528516e-01f,
  -7.96258077e-03f, -4.15319465e-02f, -1.30348559e-02f, -2.43675709e-02f, -3.94278727e-02f, -5.24622798e-02f, -6.69239205e-04f, -5.32609560e-02f, -1.78138781e-02f, 1.76491588e-02f,
  1.14039637e-01f, -4.98134866e-02f, 3.27529223e-03f, -1.14358803e-02f, 4.75398637e-02f, -1.25293201e-02f, -2.07113139e-02f, 5.75703494e-02f, 6.90589845e-02f, -7.69157289e-03f,
  2.26912588e-01f, 3.43496464e-02f, -2.70682156e-01f, -3.56360264e-02f, -3.38959962e-01f, -2.91447997e-01f, -3.57410699e-01f, -9.53269452e-02f, 8.92567337e-02f, 4.01577875e-02f,
  -1.30033970e-01f, 1.49381995e-01f, 2.35208914e-01f, -1.92665890e-01f, 1.77927107e-01f, 3.84921521e-01f, -2.73261547e-01f, -1.84585452e-01f, -1.47480164e-02f, -3.04885190e-02f,
  1.68576032e-01f, -9.19860136e-03f, 1.61987748e-02f, -2.17402428e-02f, -2.53749907e-01f, 1.25010954e-02f, 1.80883735e-01f, -1.76556870e-01f, -1.32337093e-01f, -9.48221013e-02f,
  -8.92283693e-02f, 1.66794285e-01f, -1.70984879e-01f, 2.41218209e-02f, -5.15413471e-02f, -1.03554912e-01f, -1.57576978e-01f, -2.00760271e-02f, 5.87741146e-04f, -2.68432740e-02f,
  1.32789046e-01f, 5.50826602e-02f, -3.06113958e-02f, 6.97907656e-02f, -8.84493813e-02f, -2.98411287e-02f, 1.67600304e-01f, -1.13617867e-01f, -1.48882493e-02f, -2.20515914e-02f,
  -3.24196666e-02f, -1.58959299e-01f, -4.55610529e-02f, 9.17697921e-02f, 4.00111526e-02f, -3.38502042e-02f, 6.11202382e-02f, -2.31246371e-02f, 2.26434954e-02f, 8.53887498e-02f,
  1.00412011e-01f, 2.97589526e-02f, -2.37998907e-02f, 1.44253217e-03f, -3.17647345e-02f, -5.89937270e-02f, -6.19910564e-03f, -1.83284990e-02f, 1.12915173e-01f, 4.89049405e-02f,
  -1.15503028e-01f, 5.40348478e-02f, -4.34012748e-02f, 8.95948261e-02f, 6.08616397e-02f, 4.26874533e-02f, 5.72858825e-02f, 3.50584909e-02f, -3.95868830e-02f, 6.98847771e-02f,
  9.85872000e-02f, 1.08534813e-01f, -1.86099727e-02f, 6.60483465e-02f, -2.95548700e-02f, 8.62915814e-02f, -8.39832705e-03f, 3.31463143e-02f, -5.19139096e-02f, 1.66259464e-02f,
  -3.84601429e-02f, 3.19595695e-01f, -3.85834798e-02f, 2.63641942e-02f, -4.14864793e-02f, -2.93324515e-02f, -2.76151802e-02f, -1.00611664e-01f, 9.22880396e-02f, -9.97177046e-03f,
  -4.19795327e-02f, 2.70990860e-02f, -1.04380488e-01f, -5.84800765e-02f, 2.70984285e-02f, 4.53733318e-02f, 4.21543308e-02f, 7.84126520e-02f, 1.39656454e-01f, 1.02786846e-01f,
  4.10586633e-02f, 8.97932649e-02f, 8.35637972e-02f, -3.27731334e-02f, 4.64316867e-02f, -4.49596643e-02f, -2.21053255e-03f, 2.81094089e-02f, 7.31273517e-02f, -3.95649439e-03f,
  -6.93631291e-01f, 5.33923507e-01f, 2.27178380e-01f, -1.75689399e-01f, 2.28830576e-01f, -1.44744143e-01f, -2.21727535e-01f, 2.54432023e-01f, -2.36390918e-01f, 5.44710495e-02f,
  4.86381073e-03f, -2.39516288e-01f, 1.74525961e-01f, 8.91391635e-02f, -2.05865741e-01f, 1.70866445e-01f, 2.64379010e-02f, -1.74614757e-01f, 1.56922117e-01f, 4.69832346e-02f,
  6.88054487e-02f, 1.12054758e-01f, 2.01984033e-01f, 3.52621019e-01f, -5.71980514e-02f, 3.94968763e-02f, -1.10581769e-02f, 2.93387830e-01f, -1.10957203e-02f, 1.13284066e-01f,
  -3.63566935e-01f, -8.52329209e-02f, -3.29526454e-01f, -2.12136731e-01f, -1.49890780e-01f, -7.29075000e-02f, -1.29222661e-01f, -2.57731825e-02f, -4.71992306e-02f, -1.92817803e-02f,
  -1.78053036e-01f, -9.84105747e-03f, -3.54150496e-02f, 9.45553780e-02f, -1.41138444e-02f, -6.43267632e-02f, -7.01088691e-03f, 4.76670377e-02f, 5.40229678e-02f, -7.92836323e-02f,
  1.15572065e-01f, 1.49506722e-02f, -5.14373295e-02f, -3.17711681e-02f, 6.90333247e-02f, 2.59041321e-02f, 7.63266832e-02f, -5.54018058e-02f, -2.53556874e-02f, -5.62708862e-02f,
  3.11944429e-02f, -6.22864021e-03f, 1.05781794e-01f, -7.00805411e-02f, 5.79726882e-02f, 5.65297119e-02f, -3.70753780e-02f, 1.07987430e-02f, 7.39026964e-02f, 3.70387314e-03f,
  -4.37851399e-02f, -4.34753709e-02f, 3.56945060e-02f, -4.28211614e-02f, 7.32340440e-02f, 3.00970059e-02f, -3.92746292e-02f, 7.23874150e-03f, 5.33255376e-02f, -6.50177300e-02f,
  -3.67915146e-02f, -1.01884669e-02f, 5.44437170e-02f, -7.55143017e-02f, 5.49165681e-02f, 4.81926510e-03f, -2.17238963e-02f, 8.91578421e-02f, -7.73798600e-02f, 1.86139550e-02f,
  -4.62490439e-01f, -1.38675913e-01f, -4.64901067e-02f, -1.33182645e-01f, -5.71473800e-02f, -6.85997605e-02f, 2.67060008e-02f, -2.67204326e-02f, -2.76281126e-02f, -4.91707437e-02f,
  -1.82539783e-02f, -5.62152080e-02f, -9.26609486e-02f, -4.24721465e-02f, 4.07081172e-02f, 3.08652259e-02f, 1.00205909e-03f, -4.69818152e-02f, -9.22051072e-02f, 1.82053801e-02f,
  -5.56355517e-04f, 3.99851277e-02f, 4.79186103e-02f, 6.54014200e-02f, -9.57292393e-02f, -1.09016858e-01f, 5.25009446e-03f, 6.68860879e-03f, -2.13443879e-02f, 2.23660264e-02f,
  3.33240598e-01f, -3.90921354e-01f, -4.08690542e-01f, -3.38168681e-01f, -3.44140572e-03f, -2.86373764e-01f, -3.76623094e-01f, -2.76978910e-01f, -2.16410413e-01f, -1.49347827e-01f,
  -1.33667752e-01f, -6.13443926e-02f, 1.95293531e-01f, -4.38854665e-01f, -6.96812421e-02f, 9.32884961e-03f, -3.75882387e-01f, -1.79982662e-01f, -1.18105533e-02f, -1.57959834e-01f,
  -9.96326283e-02f, -2.49201044e-01f, -3.02235961e-01f, -1.85923666e-01f, -1.37339503e-01f, -8.50269757e-03f, 3.77829701e-01f, 1.14377886e-01f, -9.81970653e-02f, -8.46581459e-02f,
  -1.09117895e-01f, -4.52272296e-02f, -1.52679086e-01f, -3.46380509e-02f, 3.48726125e-03f, 6.91457540e-02f, 9.30285230e-02f, 8.22508521e-03f, -1.44003211e-02f, -9.57166031e-02f,
  1.10365778e-01f, -4.80755866e-02f, -2.06854101e-02f, 1.68876529e-01f, 7.16525838e-02f, -1.11955240e-01f, -7.14264214e-02f, 1.38239725e-03f, -1.18329719e-01f, 9.46763009e-02f,
  -1.14476442e-01f, -2.29708888e-02f, 3.43255065e-02f, 1.18174590e-02f, 5.91481030e-02f, -1.41251206e-01f, 5.02333753e-02f, 8.13617036e-02f, 6.68748394e-02f, 3.23873833e-02f,
  1.02160610e-01f, 1.43282250e-01f, 6.30671531e-02f, -6.50682598e-02f, -6.77379370e-02f, 1.88241247e-02f, -3.30729336e-02f, 2.41691656e-02f, 2.30006687e-02f, -5.27348071e-02f,
  -7.91418403e-02f, -3.37852649e-02f, -6.75664619e-02f, -4.49320003e-02f, 8.46438259e-02f, 2.82702781e-02f, 1.16385132e-01f, -1.34694790e-02f, -9.71708894e-02f, -9.98260379e-02f,
  -9.25101712e-02f, 1.60459131e-02f, -9.34851691e-02f, 1.06110938e-01f, -6.11748248e-02f, -1.96856465e-02f, -3.47355641e-02f, 1.97351966e-02f, 2.40123458e-02f, 1.69384219e-02f,
  -5.57606854e-03f, -1.85893271e-02f, -1.12628914e-01f, -3.53619643e-02f, 3.11590489e-02f, 2.27686707e-02f, -4.88720573e-02f, -9.33633596e-02f, -9.61933881e-02f, 9.41365864e-03f,
  4.17507961e-02f, 5.06290197e-02f, 1.30263582e-01f, -9.52167735e-02f, -1.12470329e-01f, -1.24164894e-01f, 8.39584991e-02f, -2.92377062e-02f, -2.51844581e-02f, 7.17181340e-02f,
  -3.66843157e-02f, 1.54023040e-02f, -2.02894025e-02f, -1.09926518e-02f, 4.88139391e-02f, 1.25896618e-01f, -1.13120209e-02f, 3.55310552e-03f, 5.57730570e-02f, -1.08821966e-01f,
  -2.45848611e-01f, -2.50725806e-01f, 2.14869022e-01f, -3.01878542e-01f, 2.56322436e-02f, 1.07295230e-01f, 1.96739212e-01f, -2.13411033e-01f, -3.12706023e-01f, -1.75428927e-01f,
  -8.07018727e-02f, -9.32156399e-04f, 1.76821366e-01f, -2.69811153e-01f, 3.53132874e-01f, 4.11198810e-02f, -2.67446101e-01f, -7.76701272e-02f, 5.78795606e-03f, -1.59649089e-01f,
  -2.82936823e-02f, -2.79871851e-01f, 1.67380497e-01f, -2.79821038e-01f, -2.85219550e-01f, -1.41884014e-01f, -2.48435214e-02f, 1.43382624e-01f, -1.88210085e-01f, 5.13163544e-02f,
  -5.14058247e-02f, -3.27728063e-01f, -1.63010791e-01f, -3.12405992e-02f, -1.26125962e-01f, 3.75540853e-02f, 9.57583189e-02f, 1.69638187e-01f, -3.42986621e-02f, -6.91314712e-02f,
  -3.84976086e-03f, -7.03303814e-02f, -5.31987362e-02f, 7.01611415e-02f, -8.81634355e-02f, -3.92373689e-02f, -7.41390288e-02f, -3.05973701e-02f, -5.32118371e-04f, 1.07340157e-01f,
  1.01615228e-01f, -8.70760307e-02f, -3.53079475e-02f, -4.51709330e-02f, -2.26431526e-02f, -1.48389731e-02f, -7.25514218e-02f, 7.66463652e-02f, -5.75685538e-02f, -8.39676708e-02f,
  1.75267961e-02f, 7.82232806e-02f, 2.38487311e-02f, 3.34746800e-02f, -5.65662496e-02f, -2.21655741e-02f, 3.32238264e-02f, 5.86101972e-02f, 4.01457474e-02f, 1.34164607e-03f,
  -1.62139460e-02f, -1.17323823e-01f, -5.63880168e-02f, -5.20762280e-02f, -3.83522967e-03f, 2.30828300e-02f, 9.91332084e-02f, -5.17479777e-02f, 6.04343228e-02f, 5.78299314e-02f,
  6.50556907e-02f, 4.20631617e-02f, 6.23328164e-02f, -7.17983767e-02f, 4.38287333e-02f, 1.61489651e-01f, 7.65517578e-02f, -1.60196796e-02f, -2.53704656e-02f, 3.31392251e-02f,
  -3.85193564e-02f, -2.57399619e-01f, -2.03822181e-02f, -1.61785558e-01f, -3.77282761e-02f, -7.09341764e-02f, -1.42188668e-01f, -5.07293344e-02f, 1.34057635e-02f, -7.05231726e-02f,
  -3.40475142e-02f, -7.48533010e-02f, -3.09897191e-03f, 1.83178261e-02f, 1.44347623e-01f, 6.02781819e-03f, -4.20356616e-02f, -5.73205575e-02f, 1.15605502e-03f, 4.87832092e-02f,
  6.10197224e-02f, -2.88645681e-02f, 1.27286330e-01f, -4.80724499e-02f, -7.80701591e-03f, 7.93552899e-04f, -4.53287885e-02f, 8.74993727e-02f, -1.07502647e-01f, 6.13900907e-02f,
  2.94858903e-01f, -1.50020301e-01f, -7.71094114e-02f, -9.80582759e-02f, -2.58592039e-01f, 7.73358122e-02f, 3.08596373e-01f, -1.26382113e-01f, -6.90680370e-02f, -7.47997090e-02f,
  -8.24044421e-02f, 5.23445606e-02f, 3.25133085e-01f, -1.90981656e-01f, 2.85329431e-01f, 2.70342618e-01f, -1.61778722e-02f, -7.50774667e-02f, -6.10903390e-02f, 8.59004110e-02f,
  3.20787169e-02f, 7.76816101e-04f, 1.23265676e-01f, -2.56279796e-01f, -2.00259775e-01f, -1.59564048e-01f, -2.29718834e-01f, -4.52026650e-02f, -3.65180284e-01f, -1.05839565e-01f,
  1.00432627e-01f, -5.06986342e-02f, 4.64681797e-02f, 1.60647064e-01f, 9.19554289e-03f, -5.96768893e-02f, -5.32553755e-02f, 1.07297756e-01f, 8.78977776e-02f, 4.19715568e-02f,
  -5.16728545e-03f, -1.93441752e-02f, -4.00839336e-02f, 7.41706043e-02f, -6.96271807e-02f, -6.30503744e-02f, -8.17788392e-02f, 5.23262434e-02f, 6.11734726e-02f, -7.82719776e-02f,
  1.38348743e-01f, 6.18368611e-02f, -2.75862142e-02f, -1.95844360e-02f, 4.16609384e-02f, 4.70916405e-02f, 8.54091048e-02f, -9.94354114e-02f, -8.66730325e-03f, -4.86833341e-02f,
  -6.68022856e-02f, 7.54534006e-02f, 1.27915964e-01f, -3.77823114e-02f, 4.95278165e-02f, -2.49139443e-02f, 1.15976185e-02f, -9.42645147e-02f, -3.14608291e-02f, -3.00772358e-02f,
  -3.30221304e-03f, -9.29135382e-02f, -4.90459129e-02f, 9.16444063e-02f, -7.59311318e-02f, -7.38032684e-02f, 2.60237809e-02f, -1.58153266e-01f, 5.29460870e-02f, 4.37062085e-02f,
  4.74998169e-02f, 9.08285677e-02f, -9.14344415e-02f, -7.52857476e-02f, -3.72405117e-03f, -1.79914143e-02f, -5.64976521e-02f, -1.53900400e-01f, 4.87500317e-02f, 1.93302169e-01f,
  1.22688673e-01f, -6.12076782e-02f, 7.94066489e-02f, 3.11757345e-03f, -3.86346504e-02f, 5.60085624e-02f, 3.82583193e-03f, -4.29748558e-02f, -4.88802716e-02f, 6.60926700e-02f,
  -1.05575129e-01f, 7.87057206e-02f, 6.21465854e-02f, -5.52288182e-02f, -5.43094426e-02f, 2.50710268e-02f, -3.35706361e-02f, 5.27188648e-04f, -9.82433558e-03f, -9.94631052e-02f,
  1.31602541e-01f, 1.20391764e-01f, 1.04420841e-01f, -3.05563640e-02f, -2.28616208e-01f, -2.31626015e-02f, 1.90597065e-02f, 4.15693223e-02f, -8.34557936e-02f, -3.44650410e-02f,
  1.55984566e-01f, -4.06438440e-01f, -2.70937771e-01f, 1.44093752e-01f, 2.72650868e-01f, 1.02688469e-01f, -5.69961779e-02f, 2.53676116e-01f, -1.54734865e-01f, -2.24523365e-01f,
  1.11187920e-02f, -3.13670814e-01f, -3.88842970e-01f, -1.90501273e-01f, -2.30437275e-02f, -3.84487092e-01f, 7.27923438e-02f, 5.22828661e-03f, -1.45648271e-01f, 1.58642620e-01f,
  6.76842481e-02f, 2.05187887e-01f, 9.97751392e-03f, 2.99998015e-01f, 1.74994498e-01f, 3.40707868e-01f, 3.51564169e-01f, 4.44620252e-02f, 3.33873779e-01f, 4.20459472e-02f,
  -3.74759175e-02f, -1.38403714e-01f, -3.46983634e-02f, -4.68266234e-02f, 1.65890083e-01f, 1.60891697e-01f, 9.43787247e-02f, 2.05356162e-02f, -1.05112232e-02f, -3.41533720e-02f,
  4.05449467e-03f, 1.94300879e-02f, 7.09697157e-02f, 9.85187367e-02f, -3.10428049e-02f, 3.02115269e-02f, -9.76923779e-02f, -3.57501139e-03f, -5.20417430e-02f, -2.55674005e-01f,
  -2.40753412e-01f, 1.11473873e-02f, -1.54525053e-03f, 5.85093047e-04f, -1.02225713e-01f, -7.47257471e-02f, 2.28127148e-02f, -1.17124030e-02f, -4.37089726e-02f, 8.61963555e-02f,
  8.85477960e-02f, 3.26272771e-02f, -1.27680734e-01f, -7.29491860e-02f, -4.27798107e-02f, 3.07490695e-02f, -4.93072085e-02f, -6.85045496e-02f, -3.58758718e-02f, -6.72444142e-03f,
  5.16076796e-02f, 2.49770097e-02f, 3.23498771e-02f, -3.52305286e-02f, 2.50153840e-02f, -3.54563966e-02f, 1.05035983e-01f, -1.33255532e-03f, 7.98472166e-02f, -6.95298538e-02f,
  -4.89632897e-02f, -1.90544676e-03f, 7.76527748e-02f, 6.60512224e-02f, -9.30048600e-02f, 5.25211319e-02f, -4.79161181e-03f, -1.69535168e-02f, -7.39123970e-02f, 5.55803813e-02f,
  -2.23399308e-02f, 7.15492070e-02f, -7.60544464e-02f, 2.85527222e-02f, -7.59330839e-02f, 5.31670004e-02f, -1.69457555e-01f, -4.20820080e-02f, 5.27409501e-02f, 2.50577759e-02f,
  2.05082789e-01f, 9.07876268e-02f, 3.32096405e-02f, 8.16204324e-02f, 9.88683403e-02f, 8.32212418e-02f, 1.49742304e-03f, 6.75735548e-02f, 1.17880657e-01f, 5.09652914e-03f,
  5.80174737e-02f, 3.17702293e-02f, 3.85309495e-02f, -1.87771283e-02f, 5.51471002e-02f, 1.11969583e-01f, 6.90035447e-02f, 1.01132296e-01f, -2.58840006e-02f, -6.85319602e-02f,
  1.65299580e-01f, 2.21002162e-01f, -2.29205817e-01f, 4.23111878e-02f, 4.94549349e-02f, 3.69828463e-01f, 2.29609817e-01f, 1.49316698e-01f, 1.61287576e-01f, 1.18154362e-01f,
  -4.78646122e-02f, 2.79654507e-02f, 7.96030611e-02f, -1.06311314e-01f, 1.57981277e-01f, 1.83768049e-01f, 1.25662491e-01f, 2.39858165e-01f, 1.79047823e-01f, 9.74876657e-02f,
  -1.60565134e-02f, 7.59072378e-02f, -2.55335629e-01f, 4.45300713e-02f, -6.73150644e-03f, -1.91487640e-01f, -3.25476795e-01f, -1.44187316e-01f, -1.59296468e-01f, 6.56341240e-02f,
  3.96822281e-02f, 1.39298499e-01f, -7.79995620e-02f, -1.06734678e-01f, 1.15816742e-01f, 1.13303348e-01f, -6.20654225e-02f, 6.61482150e-03f, -1.92437135e-02f, 1.53583229e-01f,
  1.02841325e-01f, -2.00268216e-02f, 1.34001806e-01f, -1.01289168e-01f, -3.08724158e-02f, -1.01539589e-01f, -3.83794643e-02f, -5.14362268e-02f, -5.44818901e-02f, -1.84257533e-02f,
  -1.14575610e-01f, 4.65712510e-04f, -1.08524233e-01f, 4.09985967e-02f, -1.41885743e-01f, -3.68181914e-02f, -2.94389892e-02f, -1.18014857e-01f, -1.96791422e-02f, 7.85483792e-02f,
  7.61267096e-02f, 8.32561031e-02f, -2.95405444e-02f, -1.43085867e-01f, 7.91249797e-02f, 4.74048033e-02f, -1.36644736e-01f, 2.38999887e-03f, -3.43709327e-02f, 8.55512097e-02f,
  -3.59159149e-02f, -1.05866112e-01f, 6.48289174e-02f, -5.52788302e-02f, 3.50304469e-02f, 3.59352008e-02f, 1.49973361e-02f, 5.40970936e-02f, -6.58733817e-03f, -7.00159296e-02f,
  4.22799699e-02f, -7.68734962e-02f, -2.08034553e-02f, -9.72003639e-02f, 5.49262799e-02f, -5.72338328e-03f, -2.40980368e-02f, -5.96230365e-02f, -6.02700226e-02f, -4.58999611e-02f,
  2.31660426e-01f, 3.79782528e-01f, 3.05012818e-02f, 3.48199010e-02f, 8.82435888e-02f, 6.53622299e-02f, 1.93524770e-02f, 1.44923642e-01f, 6.42361939e-02f, 3.37325409e-02f,
  1.07398611e-02f, -1.76099930e-02f, 8.10366273e-02f, -1.17772855e-01f, -5.80446236e-03f, 2.48690378e-02f, -2.24544406e-02f, -3.65943015e-02f, -8.06206279e-03f, -2.48573069e-03f,
  -1.90733820e-01f, 9.43508968e-02f, 2.77926698e-02f, 9.37180519e-02f, 3.80341448e-02f, -1.03258137e-02f, 7.29916990e-02f, -1.18482329e-01f, 3.54213119e-02f, -3.90697904e-02f,
  3.20887007e-02f, 2.83443660e-01f, 2.01240078e-01f, 1.53546095e-01f, -3.55978906e-02f, -2.96735823e-01f, -1.55571997e-01f, 5.81581593e-02f, -1.78783178e-01f, 7.07796812e-02f,
  -2.07653835e-01f, 1.66710973e-01f, -1.97787344e-01f, -1.31715760e-01f, -4.01566327e-01f, -3.55919421e-01f, -1.35511577e-01f, -9.79844555e-02f, -1.85894921e-01f, 1.96222022e-01f,
  5.43960258e-02f, -1.76672414e-01f, 1.08669810e-01f, 1.08921655e-01f, 1.73713997e-01f, 2.53681213e-01f, 2.04824403e-01f, 8.65714997e-02f, 2.41285414e-01f, -1.90948397e-02f,
  -1.25375435e-01f, -7.46253273e-03f, 3.73412482e-02f, 3.70372720e-02f, 7.83788785e-02f, 9.33384970e-02f, 1.38619542e-01f, -6.32691160e-02f, -2.71006916e-02f, 4.42228317e-02f,
  -2.38157958e-02f, -6.31153435e-02f, 5.60911447e-02f, -8.68516639e-02f, 4.03484628e-02f, -7.45693734e-03f, -5.23091201e-03f, 6.23815916e-02f, 1.84854791e-02f, 2.95785181e-02f,
  7.58483335e-02f, 6.25040336e-03f, -2.94665247e-02f, 1.11073583e-01f, 8.70084837e-02f, 7.16050938e-02f, 1.94962472e-02f, 1.80527300e-01f, 8.30381643e-04f, 5.30866385e-02f,
  -2.09113471e-02f, -7.53958151e-02f, -1.90665219e-02f, -1.29918128e-01f, -9.88054201e-02f, -3.14956084e-02f, -2.72171237e-02f, 5.39989257e-03f, -2.47761402e-02f, -2.82679666e-02f,
  -2.28640288e-02f, 6.82278490e-03f, -1.21884741e-01f, 6.57964647e-02f, 6.07799292e-02f, 2.07201801e-02f, 1.97748770e-03f, 5.41347414e-02f, 4.49327193e-02f, -1.97898299e-02f,
  -1.23304303e-03f, -1.51740937e-02f, 9.50862169e-02f, -3.88056822e-02f, -1.12629905e-01f, 2.19824314e-02f, -1.19616771e-02f, 3.73969860e-02f, 5.65525740e-02f, -6.40879348e-02f,
  2.41854712e-02f, 2.27843493e-01f, 9.83439386e-02f, -6.81435168e-02f, 3.35163027e-02f, -3.14268209e-02f, -1.46568075e-01f, 6.17352016e-02f, -7.09965898e-05f, -1.11365728e-01f,
  1.47035971e-01f, 9.09945741e-02f, -5.36713861e-02f, 2.56472938e-02f, 6.27924427e-02f, 1.12172971e-02f, 1.76225584e-02f, 5.03123105e-02f, 1.22993022e-01f, 1.39010772e-01f,
  1.02445602e-01f, -3.38530429e-02f, 3.68439779e-02f, -7.12946206e-02f, -1.21131334e-02f, 3.55627644e-03f, -2.83302134e-03f, 5.51159531e-02f, 3.30910534e-02f, 2.79345307e-02f,
  1.28266528e-01f, -1.76718310e-02f, -1.75217211e-01f, 1.12268046e-01f, -2.84235124e-02f, -2.82186344e-02f, -1.67315200e-01f, 1.61353275e-01f, -1.16257437e-01f, -3.22615169e-02f,
  1.95693672e-01f, 3.65272276e-02f, -2.06536010e-01f, 3.95252138e-01f, 3.38965029e-01f, -1.28597543e-01f, 2.38120362e-01f, 1.68073654e-01f, -4.47661690e-02f, 1.17544517e-01f,
  9.29456651e-02f, 3.41331989e-01f, 1.55090466e-01f, 2.76532739e-01f, 1.03234380e-01f, 3.14762741e-02f, 1.40412256e-01f, -1.28137633e-01f, 2.63895750e-01f, 1.34025067e-01f,
  7.43850097e-02f, 1.23493358e-01f, -1.13032043e-01f, -7.85095319e-02f, -2.71302853e-02f, 4.22799699e-02f, -9.44157317e-02f, 6.60107359e-02f, -4.74997871e-02f, 6.63574934e-02f,
  -1.41336679e-01f, 2.90368535e-02f, 1.08854361e-01f, -2.32532304e-02f, 7.90177360e-02f, -4.48883325e-02f, -1.82604082e-02f, -1.59476966e-01f, -2.66362112e-02f, -6.66413456e-02f,
  -1.33588552e-01f, -9.06754658e-03f, -3.73770259e-02f, 4.03862670e-02f, 9.58240554e-02f, -9.05074179e-03f, -9.70393866e-02f, -5.62936179e-02f, 3.68322432e-02f, 1.54591709e-01f,
  4.26730700e-03f, -5.61450943e-02f, 4.96335253e-02f, 4.71549518e-02f, 1.83603819e-02f, 6.49826080e-02f, 3.46208215e-02f, 4.06957045e-02f, -7.47538060e-02f, 1.29497334e-01f,
  2.84799282e-02f, -2.79872976e-02f, 3.73472571e-02f, -2.74805585e-03f, 9.34145898e-02f, -4.50451523e-02f, -2.68707052e-02f, 2.81024445e-03f, -6.93086758e-02f, -2.35842504e-02f,
  -9.20132995e-02f, -1.47828786e-02f, -1.73890702e-02f, 4.20738161e-02f, 3.46274860e-02f, 3.30597982e-02f, 1.02659449e-01f, 3.56960110e-03f, -8.16082582e-02f, -1.00663885e-01f,
  1.82041049e-01f, 2.20399737e-01f, -9.94224101e-02f, 7.27336779e-02f, 2.71507557e-02f, 6.01463318e-02f, 6.15859441e-02f, 1.46907926e-01f, 5.93078956e-02f, 8.80999565e-02f,
  2.82505434e-02f, -8.65462720e-02f, 8.99856240e-02f, -2.10004337e-02f, 4.95463610e-02f, 1.17493741e-01f, -8.45504254e-02f, 8.89148621e-04f, -3.93249393e-02f, 6.99987262e-02f,
  2.75672674e-02f, -4.54238895e-03f, 1.45188263e-02f, -9.05232579e-02f, 8.59417617e-02f, -2.00658087e-02f, -1.19921364e-01f, 4.09638882e-02f, 5.17058047e-03f, 3.28272171e-02f,
  2.83094198e-01f, 1.90779403e-01f, -2.77383067e-03f, 1.23361848e-01f, -1.99870560e-02f, -1.77175164e-01f, -1.16534606e-01f, 2.99660325e-01f, -6.62374124e-02f, -2.44860966e-02f,
  1.52940199e-01f, 9.44467261e-02f, -9.37993303e-02f, 2.65009314e-01f, 2.05411136e-01f, -1.04188874e-01f, 1.75308093e-01f, 4.79968414e-02f, 5.11949733e-02f, 2.25342900e-01f,
  1.17927872e-01f, 1.67774335e-01f, 2.79735059e-01f, 1.90146402e-01f, 2.58311242e-01f, 1.70284063e-01f, 2.29281917e-01f, 4.97341044e-02f, 1.24355324e-01f, 8.50966722e-02f,
  -7.38715455e-02f, 1.19308166e-01f, 2.83925366e-02f, -8.22927356e-02f, 8.00555125e-02f, 7.77189014e-03f, -1.02591977e-01f, -5.91122825e-03f, -1.48914307e-01f, 7.75056984e-03f,
  -9.31231398e-03f, 1.42933965e-01f, -5.24533167e-02f, 9.60824639e-03f, -2.38722451e-02f, -2.11640224e-02f, -3.72059783e-03f, 7.16551542e-02f, -3.40550393e-02f, 2.82962248e-02f,
  6.79552928e-02f, 8.48570745e-03f, 9.21742916e-02f, -4.21771780e-03f, 1.25356941e-02f, 4.76166047e-02f, -6.51601329e-02f, 2.99417805e-02f, 1.26110688e-01f, 5.82973212e-02f,
  1.06311314e-01f, 4.89638336e-02f, 4.89661098e-03f, -6.42689317e-02f, 4.38443311e-02f, -9.58208740e-02f, -3.70148011e-02f, -8.03636312e-02f, 2.82822402e-05f, -4.68564034e-02f,
  6.04638364e-03f, -4.08411250e-02f, -2.63079274e-02f, -4.00761329e-02f, 8.96108747e-02f, 5.14169112e-02f, -1.25725061e-01f, -3.88159119e-02f, -4.05805223e-02f, -5.39284162e-02f,
  3.80162820e-02f, 9.71965939e-02f, 1.53077804e-02f, -9.20184713e-04f, 3.13641168e-02f, 3.43761332e-02f, 6.43599108e-02f, 2.60238107e-02f, -1.16098439e-02f, 5.60125858e-02f,
  6.86211362e-02f, 2.77501315e-01f, 9.02192667e-02f, -6.42652661e-02f, -1.36737540e-01f, -6.21639229e-02f, 6.87598959e-02f, 1.03580028e-01f, 5.73548637e-02f, -3.84186246e-02f,
  1.02447741e-01f, -8.34472999e-02f, -3.40260342e-02f, -1.97599679e-02f, -1.13604106e-02f, 1.50086388e-01f, 2.10657585e-02f, 4.38591987e-02f, 1.21322103e-01f, 1.76201928e-02f,
  6.94530308e-02f, -1.79161713e-01f, 2.88148019e-02f, -9.45366621e-02f, -2.23273728e-02f, -4.92625497e-02f, 8.45821276e-02f, -3.63212377e-02f, 4.87538837e-02f, 3.13642137e-02f,
  1.27720609e-01f, -2.10404947e-01f, 3.20851475e-01f, -1.22345306e-01f, 3.21528345e-01f, 2.84603238e-01f, 3.60032022e-01f, -2.20526099e-01f, -1.87391028e-01f, -3.36325765e-01f,
  2.01560389e-02f, 3.80719267e-02f, 1.61006957e-01f, -1.36013418e-01f, 4.02504861e-01f, 8.98528472e-02f, -9.59868804e-02f, -7.28115216e-02f, 1.09940208e-01f, -2.26689018e-02f,
  3.48891690e-02f, -1.47666216e-01f, 3.11076015e-01f, -1.82967857e-01f, 1.37870550e-01f, -1.61801100e-01f, -9.17558447e-02f, 3.33820850e-01f, -1.61467075e-01f, 4.26528081e-02f,
  1.07934438e-01f, -3.22030075e-02f, 8.35351050e-02f, 7.12110251e-02f, 1.63848713e-01f, 5.51430769e-02f, 3.95304896e-02f, 2.23907188e-01f, -1.19958567e-02f, 2.67861914e-02f,
  7.90386423e-02f, -1.05216671e-02f, -1.61324322e-01f, 4.60319296e-02f, -3.65868881e-02f, -1.34471282e-01f, 1.03264391e-01f, 9.23021361e-02f, -5.59647381e-03f, 8.76753926e-02f,
  9.01873708e-02f, 4.66332622e-02f, -1.55588537e-02f, -9.22177061e-02f, 2.61179116e-02f, -1.44453049e-01f, 5.17816506e-02f, 1.04171187e-01f, -4.69005518e-02f, -8.08205456e-04f,
  -3.11596822e-02f, 1.24050332e-02f, 6.28345907e-02f, -3.37887891e-02f, 5.91919161e-02f, -1.62307024e-01f, 3.47382650e-02f, -4.00408320e-02f, -4.66391891e-02f, 5.43563301e-03f,
  -6.12323135e-02f, -2.38431860e-02f, 2.36447118e-02f, -1.12431258e-01f, -5.43840379e-02f, -7.06534907e-02f, 4.79841083e-02f, -3.81197706e-02f, -8.66211653e-02f, 1.42147345e-03f,
  -5.94631210e-02f, -9.23670307e-02f, 9.90512688e-03f, -5.36196008e-02f, 6.18348233e-02f, 1.19343452e-01f, -1.80519611e-01f, 7.37971347e-03f, -2.90287547e-02f, 1.03505507e-01f,
  6.00373410e-02f, -2.66262591e-01f, 3.57986279e-02f, -6.20050170e-02f, 8.53180047e-03f, 2.33654622e-02f, 1.15661107e-01f, -7.06318691e-02f, -2.71998812e-02f, -5.89778982e-02f,
  -1.47364974e-01f, 5.95627315e-02f, -7.22879395e-02f, -3.79299447e-02f, 4.43467423e-02f, -1.35728136e-01f, 8.30521584e-02f, 3.56721357e-02f, 1.28660440e-01f, -6.94471076e-02f,
  -3.38175222e-02f, -5.49122058e-02f, -7.14910924e-02f, -2.30261207e-01f, -1.42837733e-01f, 3.82673182e-02f, -2.75596287e-02f, -1.20118186e-02f, -3.34534906e-02f, -5.04299589e-02f,
  1.68965980e-02f, 1.47007471e-02f, 3.16333622e-01f, 2.22275019e-01f, 1.51299998e-01f, 2.66397387e-01f, 3.51741344e-01f, 3.33329111e-01f, 4.54768747e-01f, -1.32354900e-01f,
  5.53867817e-02f, -2.33826026e-01f, 9.23054293e-02f, 4.00847271e-02f, 1.82569876e-01f, 9.36208814e-02f, 2.69594342e-01f, 4.54329513e-02f, 6.12053974e-03f, -1.36066511e-01f,
  2.03913879e-02f, -2.36670718e-01f, -8.97936523e-02f, -1.94784388e-01f, -1.15026332e-01f, -1.96981996e-01f, -2.14657843e-01f, -7.32201803e-03f, -2.71691054e-01f, 1.90642551e-02f,
  -1.29727140e-01f, -1.15951419e-01f, -2.44447082e-01f, -8.12308565e-02f, 1.30680185e-02f, -9.54511017e-02f, 6.94062337e-02f, -6.83038831e-02f, 1.58416387e-02f, 7.26477057e-03f,
  -1.58455104e-01f, -5.85182533e-02f, 3.21193486e-02f, -9.04633775e-02f, 6.78897128e-02f, -8.07345361e-02f, 6.74972460e-02f, 5.35202660e-02f, -2.07773894e-02f, 1.00359954e-01f,
  -1.91187728e-02f, 3.74256372e-02f, 9.12628546e-02f, 1.11716032e-01f, 9.81320292e-02f, 8.66242424e-02f, -2.45063528e-02f, 9.42598879e-02f, -1.44598857e-02f, 7.93941095e-02f,
  9.25846025e-02f, 1.37827992e-01f, -5.05500436e-02f, -1.42508924e-01f, -1.03862219e-01f, -7.44208619e-02f, -9.99020711e-02f, -5.42856120e-02f, 3.70103940e-02f, -1.34068979e-02f,
  1.62171740e-02f, -8.05964228e-03f, 1.81776196e-01f, 1.02429716e-02f, 1.03351129e-02f, -2.44749840e-02f, 3.80702689e-02f, 4.58285995e-02f, 1.10335559e-01f, -1.12165399e-01f,
  3.48480493e-02f, 2.27541383e-02f, -6.17029844e-03f, 3.14925909e-02f, -1.38001854e-03f, -7.78246596e-02f, -1.06214546e-01f, 6.52393624e-02f, 4.13457230e-02f, 8.58414546e-03f,
  -1.21999465e-01f, -6.76693097e-02f, -1.70109961e-02f, -1.18042650e-02f, -6.94579724e-03f, -9.71235558e-02f, 9.60682184e-02f, -7.14219874e-03f, -9.60946754e-02f, 1.25947418e-02f,
  4.76867072e-02f, -6.90844432e-02f, -1.46447465e-01f, 1.69834290e-02f, -2.04028338e-02f, 8.94076249e-04f, -7.18169957e-02f, -3.03568263e-02f, -6.08070530e-02f, -7.22090006e-02f,
  -7.19731152e-02f, -1.12299189e-01f, 7.75839537e-02f, 6.99919602e-03f, 5.90118952e-02f, -6.89312443e-02f, 7.17745572e-02f, 1.00560330e-01f, 6.30879513e-05f, -7.03838915e-02f,
  -2.30333686e-01f, 3.10942501e-01f, 1.96669042e-01f, -2.88559079e-01f, 1.11918487e-01f, -9.75349732e-03f, -1.97280526e-01f, 1.86820060e-01f, -1.78613231e-01f, -4.69595157e-02f,
  -1.26018628e-01f, 3.05146635e-01f, 2.33385642e-03f, -3.04214433e-02f, -1.74033895e-01f, -1.20932087e-01f, -3.02593976e-01f, -1.05211079e-01f, -4.32402529e-02f, -6.59184232e-02f,
  -2.49627251e-02f, -3.67463797e-01f, 4.37406525e-02f, -3.65231000e-02f, -4.61797118e-02f, 1.61358193e-02f, -2.48068392e-01f, 2.28076711e-01f, -2.24221237e-02f, 7.99386874e-02f,
  -1.47167981e-01f, -6.32827953e-02f, -3.82701829e-02f, 1.06764019e-01f, -1.14412986e-01f, 3.96266393e-02f, -2.09049624e-03f, 3.65139470e-02f, -3.31690721e-03f, 4.35911343e-02f,
  -1.13091851e-02f, 1.25071198e-01f, 6.68162033e-02f, 6.74421564e-02f, -1.80195831e-02f, 1.40475810e-01f, 6.77819252e-02f, -8.68376996e-03f, -1.25244902e-02f, 2.20685765e-01f,
  1.20568320e-01f, 1.21038303e-01f, 7.97101855e-03f, -2.70326752e-02f, 9.68782306e-02f, -8.63838568e-02f, 2.91012246e-02f, 1.31704003e-01f, 7.11919069e-02f, -1.68209560e-02f,
  -9.68634337e-02f, -1.38301834e-01f, 2.20236219e-02f, -2.05522403e-02f, -6.52206540e-02f, 7.02370405e-02f, 5.90486042e-02f, 3.77372727e-02f, 2.67686229e-02f, -1.04095032e-02f,
  -7.20573887e-02f, 1.20342962e-01f, -8.16570595e-02f, -7.44026601e-02f, -1.03420831e-01f, -4.50361930e-02f, -2.51842160e-02f, 5.84518611e-02f, -5.22323735e-02f, -5.11574857e-02f,
  -6.08762577e-02f, 2.05456037e-02f, 1.20079204e-01f, -2.47882716e-02f, 8.19352493e-02f, -3.48249897e-02f, 1.54701814e-01f, 6.29257709e-02f, 5.40761463e-02f, -1.01834571e-03f,
  -4.37513739e-01f, -3.72184128e-01f, -1.08553745e-01f, 5.15311696e-02f, -7.75273740e-02f, 2.32574586e-02f, -4.83152717e-02f, -3.00283935e-02f, -1.30777687e-01f, 7.03817187e-03f,
  -2.74658808e-03f, -1.12480305e-01f, -4.08992283e-02f, -7.90258422e-02f, -3.54287066e-02f, -9.09807310e-02f, -1.22556940e-01f, -8.17642510e-02f, -3.86546887e-02f, 9.57391188e-02f,
  -5.66098280e-02f, -2.93858424e-02f, -2.27735750e-02f, -3.81060615e-02f, -1.10540889e-01f, -1.58175342e-02f, 3.38289551e-02f, -6.67782202e-02f, 7.01600388e-02f, 1.94601435e-02f,
  -4.98857617e-01f, 1.25550196e-01f, -2.28562027e-01f, -2.29436100e-01f, 2.21589103e-01f, -3.77729028e-01f, -3.03761214e-01f, -4.90967333e-02f, -7.98240677e-02f, 6.26792908e-02f,
  8.33478943e-02f, -4.61200178e-02f, 2.86274284e-01f, -2.14109361e-01f, -2.32973859e-01f, 8.07146952e-02f, -4.45308924e-01f, -1.24920644e-01f, 1.91889077e-01f, -1.53046146e-01f,
  4.52998243e-02f, -6.19548224e-02f, -2.62104988e-01f, 2.25266203e-01f, -1.97878897e-01f, -2.41828766e-02f, -1.19179301e-02f, 1.74144745e-01f, -1.99892730e-01f, 4.65190597e-02f,
  -3.58796835e-01f, -1.28887028e-01f, -1.36216477e-01f, -1.47951782e-01f, -1.81156978e-01f, -9.27127525e-02f, -1.12662882e-01f, 6.23499230e-02f, 2.21818946e-02f, 7.12286010e-02f,
  9.30018947e-02f, 3.71681154e-02f, -6.17375560e-02f, 1.66454554e-01f, 2.11405233e-02f, 2.22004689e-02f, -8.67953449e-02f, -1.88583031e-01f, 2.00473666e-02f, -6.82303905e-02f,
  -5.05163409e-02f, -1.04953654e-01f, -1.50993153e-01f, -1.26180395e-01f, -1.12328351e-01f, -4.59642801e-03f, -1.91997349e-01f, -1.31775230e-01f, -1.37716502e-01f, -1.01569444e-01f,
  7.67637193e-02f, 5.83989471e-02f, -2.39551794e-02f, -1.92431491e-02f, 1.12143010e-01f, -5.67400455e-02f, -1.71732325e-02f, -4.30442840e-02f, -3.12619731e-02f, -7.47542456e-02f,
  -1.16563156e-01f, -8.33664089e-02f, 3.75749804e-02f, -4.01018783e-02f, 2.83879833e-03f, 1.15920696e-02f, 1.19039025e-02f, 9.97674745e-03f, 3.48765031e-02f, -9.28241983e-02f,
  1.32013364e-02f, 1.05089005e-02f, 2.03309152e-02f, 2.77285371e-03f, -3.00459489e-02f, 4.28118147e-02f, -5.29533587e-02f, -3.14878486e-02f, 5.45089245e-02f, -5.48785999e-02f,
  -3.79666328e-01f, -4.16657150e-01f, 3.28507461e-02f, -5.55214696e-02f, 1.99809745e-02f, -7.73992091e-02f, -3.52131017e-02f, 2.19833814e-02f, -3.48592438e-02f, 1.74954459e-02f,
  -5.97862946e-03f, -2.55082548e-02f, -1.52100235e-01f, 3.99733707e-02f, -3.20783406e-02f, -3.95975113e-02f, -1.50310490e-02f, -3.38242427e-02f, -9.32501480e-02f, 3.44042256e-02f,
  -5.27742468e-02f, -3.25032845e-02f, 9.00224447e-02f, -2.17731297e-02f, -1.00231886e-01f, -7.11394250e-02f, 1.85550342e-03f, -2.66350321e-02f, -5.59701025e-02f, -1.95281841e-02f,
  -4.22590613e-01f, 7.03712553e-03f, -4.19498160e-02f, -2.25556329e-01f, 2.13932946e-01f, -3.07049662e-01f, -5.04002422e-02f, 1.65623948e-01f, 1.14383556e-01f, 2.44013354e-01f,
  8.32287148e-02f, -2.38484191e-03f, 1.72126293e-01f, -1.64208502e-01f, -5.03893614e-01f, -2.93864787e-01f, -3.34019065e-01f, -2.50347555e-01f, -1.38427392e-01f, 5.48901036e-03f,
  -2.14175165e-01f, -5.92097454e-02f, -3.58356833e-01f, 7.14265555e-02f, -1.26475450e-02f, 1.51921466e-01f, -4.12377231e-02f, 2.75048256e-01f, -1.42330125e-01f, -9.45345685e-02f,
  -7.42363408e-02f, 2.59699911e-01f, 1.09995082e-01f, 1.00062625e-03f, -5.88815426e-03f, 6.87195035e-03f, 3.93774398e-02f, 6.79755285e-02f, 1.26736045e-01f, -9.40651447e-02f,
  -6.77622110e-03f, -1.84954610e-02f, -3.36552337e-02f, 2.62379777e-02f, 1.17368221e-01f, 9.54039842e-02f, 9.03190393e-03f, -8.77061784e-02f, 1.26714436e-02f, -8.27643275e-02f,
  -3.29327472e-02f, -7.17358887e-02f, 1.48059707e-02f, -2.02619517e-03f, 3.32278907e-02f, 1.19654626e-01f, -1.12572141e-01f, 7.79063478e-02f, -6.56475080e-03f, -8.28495249e-02f,
  -5.81934117e-03f, -7.66225916e-04f, -2.67608222e-02f, 7.65691474e-02f, -5.80585329e-03f, 6.07462972e-02f, -9.06155352e-03f, 1.02114365e-01f, -1.05824372e-04f, 5.30263297e-02f,
  3.55742546e-03f, 8.24943557e-02f, 1.04971424e-01f, 7.54882162e-03f, -6.17426932e-02f, -3.98024693e-02f, -5.96285500e-02f, 2.39420533e-02f, -2.04066426e-01f, -2.03360002e-02f,
  9.98128429e-02f, -1.03451535e-01f, -3.66030331e-03f, 2.54725292e-02f, -7.19213486e-02f, 1.20480895e-01f, 1.43674135e-01f, -9.39427242e-02f, -4.37610410e-02f, 6.58907443e-02f,
  -9.42869857e-03f, 1.28191069e-01f, 8.24007466e-02f, 1.22742020e-01f, -4.94862907e-02f, -8.89921784e-02f, -5.09281307e-02f, -5.23057841e-02f, -4.03482541e-02f, -4.23347279e-02f,
  9.95310321e-02f, -4.45945896e-02f, -7.60567188e-02f, 1.78981900e-01f, -9.94841084e-02f, -1.33419141e-01f, -2.43656593e-03f, 6.28921166e-02f, -1.49821222e-01f, 2.94506159e-02f,
  1.09517574e-01f, 1.17354915e-01f, -1.07779332e-01f, -2.35874616e-02f, -2.72086076e-02f, 8.54116306e-02f, -6.36612177e-02f, 7.31325522e-02f, -2.73976661e-02f, -1.45592669e-04f,
  1.10198580e-01f, -2.84809887e-01f, -3.85680884e-01f, -1.27648652e-01f, 2.63668209e-01f, 4.54486907e-01f, -6.63256571e-02f, 3.39108646e-01f, -1.07691415e-01f, -1.47950470e-01f,
  1.15440682e-01f, 4.18454856e-02f, -4.19574648e-01f, 3.37884337e-01f, 4.18974847e-01f, -1.83700293e-01f, 2.04442531e-01f, 6.47264048e-02f, 3.29198651e-02f, 1.37683181e-02f,
  4.38853540e-02f, 3.63754928e-01f, -1.19378813e-01f, 2.66001344e-01f, 1.38613552e-01f, -1.79921433e-01f, -5.81051521e-02f, -1.57428294e-01f, 2.41909370e-01f, 3.09042990e-01f,
  1.12311460e-01f, -1.27090544e-01f, -2.46967335e-04f, -1.55615592e-02f, -6.32641688e-02f, -8.22491050e-02f, -1.41361624e-01f, 2.43380275e-02f, 1.26249656e-01f, 6.62213890e-04f,
  -1.40283242e-01f, 1.28902197e-01f, 6.27573058e-02f, -2.02886444e-02f, 9.01336744e-02f, 9.33379978e-02f, 1.24887824e-01f, 7.40374019e-03f, 4.13021557e-02f, 1.22535944e-01f,
  2.09080055e-02f, 3.50059755e-03f, -1.57020390e-01f, 4.97751273e-02f, -4.23381105e-02f, 7.07413852e-02f, -2.59028915e-02f, 7.36363651e-03f, 1.49110705e-02f, 2.60391720e-02f,
  7.46037206e-03f, -1.83402851e-01f, -2.89093051e-02f, 7.84376040e-02f, -7.71128759e-02f, 5.31283878e-02f, 3.47857513e-02f, -5.33378609e-02f, -1.47643387e-01f, 1.85389966e-02f,
  -2.11297348e-02f, 4.13312353e-02f, -1.16001945e-02f, -2.18461119e-02f, -1.21125660e-03f, -2.38819197e-02f, -9.88391936e-02f, 3.45033333e-02f, 5.87350177e-03f, 4.87144291e-02f,
  1.22095076e-02f, 3.45403478e-02f, -4.05733585e-02f, -1.21689267e-01f, 8.67298096e-02f, -5.03184721e-02f, 1.17929699e-02f, -2.22583860e-02f, -1.37198001e-01f, -1.12043202e-01f,
  7.55436420e-02f, -1.44565433e-01f, -8.82133618e-02f, 6.52391911e-02f, -1.32899985e-01f, -8.96893814e-03f, 1.50505537e-02f, 8.51028934e-02f, -2.27060611e-03f, -1.62429027e-02f,
  1.81290098e-02f, -1.55217454e-01f, -5.60206585e-02f, 1.31134584e-03f, -3.84218153e-03f, -6.71213940e-02f, -9.44940373e-02f, -6.03726739e-03f, 7.14541897e-02f, 1.42516166e-01f,
  -8.25339481e-02f, -4.09116112e-02f, -8.08453262e-02f, 1.19274467e-01f, 7.30865672e-02f, -1.04977801e-01f, 9.58520770e-02f, -1.21708877e-01f, 2.62485277e-02f, 4.47678529e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.39068076e-01f, 3.18499237e-01f, 2.00766638e-01f, 3.46466184e-01f, 2.34378934e-01f, 2.26729065e-01f, 3.43906254e-01f, 2.16222435e-01f, 1.89888880e-01f, 1.94542050e-01f,
  2.19918102e-01f, 3.55478704e-01f, 3.83070081e-01f, 2.34133661e-01f, 1.82032868e-01f, 3.41136515e-01f, 2.16445088e-01f, 1.30779132e-01f, 1.35299787e-01f, 5.83876297e-02f,
  1.37200326e-01f, 2.93176264e-01f, 3.30886334e-01f, 1.82331041e-01f, 1.49323136e-01f, 2.16577351e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.03739567e-01f, 4.76872474e-02f, 8.45317394e-02f, 1.32716540e-02f, 1.60655707e-01f, 3.81066054e-02f, -2.86917482e-02f, 1.07990824e-01f, -8.63102674e-02f, 5.82904331e-02f,
  2.04646289e-01f, 4.32122126e-02f, 4.30558361e-02f, -1.02039091e-01f, 1.20096847e-01f, 1.03414785e-02f, -7.70061389e-02f, 1.14563167e-01f, -4.29394245e-02f, -1.50525197e-01f,
  -2.74909418e-02f, -4.93853614e-02f, -3.17207421e-03f, -1.94746748e-01f, 5.17300367e-02f, -4.02814634e-02f, -2.84204066e-01f, 1.15633244e-02f, 1.00076139e-01f, 1.16786519e-02f,
  -2.51822442e-01f, -2.11859986e-01f, -1.55154765e-01f, 1.62221551e-01f, -2.27293745e-01f, 2.15485886e-01f, 3.59914690e-01f, -2.50414908e-01f, -2.05021769e-01f, 2.07181841e-01f,
  1.55063212e-01f, -1.02788843e-01f, 9.28633288e-02f, -2.01676205e-01f, 4.07057889e-02f, -3.56853083e-02f, -2.91441828e-02f, -1.23280661e-05f, -6.00900613e-02f, -1.42642772e-02f,
  -2.64570355e-01f, 1.63739339e-01f, 1.59190655e-01f, -6.89669251e-02f, -1.48762882e-01f, 3.96106839e-02f, 1.05238184e-01f, -1.79331377e-01f, 2.34133527e-01f, -8.46683905e-02f,
  2.36260608e-01f, -5.28088361e-02f, -1.16034843e-01f, 8.68399628e-04f, 8.03965516e-03f, 9.49414968e-02f, 2.38058008e-02f, 8.15159641e-03f, 1.26127347e-01f, -1.02192923e-01f,
  -1.67885229e-01f, -5.17100841e-03f, 1.10726394e-01f, -1.21156417e-01f, 1.14753388e-01f, 1.01655878e-01f, -8.92089158e-02f, -9.30983201e-03f, -5.55079356e-02f, 7.78367296e-02f,
  -4.66883108e-02f, 2.04420492e-01f, 3.29073444e-02f, -1.73279837e-01f, 6.18115738e-02f, -5.28706424e-02f, 1.19043782e-01f, -1.60250396e-01f, 2.71307915e-01f, 5.25934249e-02f,
  -4.71973233e-03f, 1.80792287e-01f, 2.29400262e-01f, 1.72158241e-01f, 6.68837652e-02f, -3.24165463e-01f, -4.20349799e-02f, 6.35633916e-02f, -2.49579981e-01f, 2.07596570e-01f,
  4.87334430e-02f, 7.59733990e-02f, 4.93275700e-04f, -6.76441118e-02f, -1.65301815e-01f, 8.85692239e-02f, 2.61326343e-01f, 1.63898736e-01f, 2.13644773e-01f, 5.38001675e-03f,
  7.38990009e-02f, 1.00837156e-01f, 1.48643315e-01f, 1.95434779e-01f, -2.47479856e-01f, -1.84948713e-01f, 1.23802021e-01f, -2.54971087e-01f, 3.64856049e-02f, -1.77869290e-01f,
  -4.26767282e-02f, -2.08905101e-01f, 8.66071358e-02f, 1.67576522e-01f, 4.07298766e-02f, 1.20345794e-01f, 3.86584885e-02f, -1.94782764e-01f, -7.59126991e-02f, -2.56639272e-01f,
  -4.30504270e-02f, 7.81064900e-03f, 3.09478194e-02f, 1.03895754e-01f, -9.73701626e-02f, -8.03399133e-04f, -1.86371580e-01f, 9.12588835e-02f, -1.60247952e-01f, 7.59214312e-02f,
  9.65253785e-02f, 3.06485116e-01f, 7.51645491e-02f, 3.39469430e-03f, 1.56406283e-01f, -1.94805726e-01f, -1.52060390e-01f, 5.52297160e-02f, 1.57808244e-01f, -1.88117772e-01f,
  3.17868888e-01f, 5.06343096e-02f, 4.21329141e-02f, 1.60195634e-01f, -1.79334179e-01f, -3.72597203e-02f, -1.24689884e-01f, -2.87900418e-01f, 2.86917806e-01f, -1.20628498e-01f,
  1.22879148e-01f, -1.04221120e-01f, 1.47186443e-01f, 8.50231126e-02f, -1.33068755e-01f, 1.98767290e-01f, -1.75818682e-01f, 8.45572054e-02f, -1.28189519e-01f, -1.87257066e-01f,
  2.33650148e-01f, -1.97227970e-01f, -1.44844443e-01f, 1.31713048e-01f, -2.41078973e-01f, 3.55034888e-01f, 3.89351062e-02f, 1.62418991e-01f, -2.01100588e-01f, -9.53582823e-02f,
  3.77285480e-02f, -2.62828767e-01f, 1.97796538e-01f, 1.24963343e-01f, 7.44026229e-02f, 2.25328013e-01f, -3.55097018e-02f, -9.54661295e-02f, 2.74306219e-02f, -5.91657264e-03f,
  1.94216222e-01f, -8.03063139e-02f, 5.13407290e-02f, -2.02689052e-01f, -1.38902724e-01f, -3.65633145e-02f, 9.74674076e-02f, -5.91784492e-02f, -8.86808038e-02f, 7.81268161e-03f,
  1.75636802e-02f, -4.10441170e-03f, -3.74745764e-02f, -1.84016058e-03f, -1.01661555e-01f, -3.50221395e-02f, -1.53083175e-01f, -3.36315148e-02f, -6.21396005e-02f, -6.47240877e-02f,
  -3.75068448e-02f, 1.86015770e-01f, -1.80893570e-01f, -2.13053390e-01f, 8.95900577e-02f, -1.41980767e-01f, -1.36803046e-01f, -1.35098234e-01f, -1.25265568e-01f, -1.78071752e-01f,
  -3.51152010e-02f, -2.08671004e-01f, 5.86658865e-02f, 1.70760423e-01f, -1.21991239e-01f, -2.16408297e-01f, -7.03390464e-02f, 1.41965345e-01f, 9.06222314e-02f, 1.16843082e-01f,
  -1.07233338e-01f, 9.58878398e-02f, 1.46565244e-01f, 2.66153604e-01f, -1.48234352e-01f, -2.72962321e-02f, 2.04234496e-01f, 2.77387410e-01f, 1.62849322e-01f, 2.04712391e-01f,
  -2.10260615e-01f, 9.18075889e-02f, -2.45052353e-01f, -1.54070809e-01f, 7.09146410e-02f, -2.79498380e-02f, -9.36430171e-02f, -1.09532431e-01f, 1.44645706e-01f, 8.32997486e-02f,
  1.88376352e-01f, 4.38342132e-02f, 1.19214088e-01f, -7.67855048e-02f, -4.68875431e-02f, 1.19288221e-01f, -1.72574054e-02f, -3.82345468e-02f, -7.76026472e-02f, -3.54771838e-02f,
  -1.73738152e-01f, -5.19065559e-02f, -4.15178612e-02f, -4.02649529e-02f, -4.11628634e-02f, -2.34715883e-02f, -1.80008397e-01f, -4.16294858e-02f, -1.53290406e-01f, 1.33985907e-01f,
  -1.63866043e-01f, -7.25206286e-02f, 1.92093365e-02f, -7.51501173e-02f, -1.66197121e-01f, -7.73778707e-02f, -7.95230642e-03f, -2.52926499e-01f, 1.56978190e-01f, 5.68830185e-02f,
  -7.93510899e-02f, -1.48409665e-01f, 2.55354673e-01f, -9.36189443e-02f, 1.63852721e-02f, -1.23820156e-01f, 1.77729428e-01f, 2.25744799e-01f, 5.53708114e-02f, -1.90850437e-01f,
  1.97610185e-01f, -2.26741415e-02f, -3.02477330e-01f, -7.77972117e-02f, 2.04349577e-01f, 6.20199405e-02f, -6.94757104e-02f, 6.18140735e-02f, -1.11064762e-01f, -2.19776690e-01f,
  -1.53258950e-01f, 1.86575755e-01f, -1.29242584e-01f, 1.13961816e-01f, -8.52990989e-03f, 1.16564818e-01f, -2.96320841e-02f, -1.26218900e-01f, -4.43979725e-02f, -4.26731221e-02f,
  -8.27328563e-02f, 8.62951651e-02f, 4.26970869e-02f, 1.72437623e-01f, -6.44356683e-02f, -1.73628867e-01f, -4.58844192e-02f, 1.46275356e-01f, 1.60251707e-01f, 1.56374462e-03f,
  -9.93560925e-02f, -8.70635211e-02f, 1.63139716e-01f, -1.14763744e-01f, -1.68045372e-01f, 2.05107853e-01f, -1.22608386e-01f, 9.10490677e-02f, 8.42132121e-02f, -1.46071181e-01f,
  3.00968029e-02f, -4.08597030e-02f, 3.58666666e-02f, 1.85994729e-01f, 4.49929275e-02f, -1.79456979e-01f, -5.99758350e-04f, 6.09866753e-02f, 3.44626978e-02f, 2.30990291e-01f,
  -2.37345949e-01f, 1.05712511e-01f, 1.29262982e-02f, 2.46099412e-01f, -7.78016448e-02f, 1.75122306e-01f, 1.51385397e-01f, -1.97279632e-01f, -8.05975199e-02f, 4.05217074e-02f,
  -5.31996414e-02f, 2.84264863e-01f, -1.03429317e-01f, 9.39143077e-02f, 1.39130990e-03f, -2.29951650e-01f, -1.12635776e-01f, 9.65457782e-02f, 1.49160415e-01f, -1.59719646e-01f,
  8.14968906e-03f, 1.46777272e-01f, -3.66564915e-02f, -9.90639180e-02f, -2.10261539e-01f, -1.97517961e-01f, -3.00877273e-01f, -1.20378010e-01f, 6.96932077e-02f, 9.20618139e-03f,
  -8.64255652e-02f, 5.49066775e-02f, 1.53717920e-01f, 7.39634186e-02f, 2.36049965e-01f, -2.55870782e-02f, 1.99288368e-01f, 1.08676605e-01f, 2.64481097e-01f, -2.10519046e-01f,
  -8.27760547e-02f, -1.30688712e-01f, 2.21130744e-01f, 2.87974775e-01f, 1.19512469e-01f, 3.71153094e-02f, -1.06599912e-01f, -4.29212786e-02f, -4.95145582e-02f, -1.10166885e-01f,
  2.32747101e-04f, -2.40154956e-02f, 1.17324747e-01f, 1.13651358e-01f, 1.02357291e-01f, 1.08163759e-01f, 7.96261877e-02f, -1.22185871e-01f, 4.19949368e-02f, 1.62867486e-01f,
  4.40630354e-02f, 1.21691795e-02f, 2.09337518e-01f, -6.95637167e-02f, 1.04541093e-01f, -8.30877349e-02f, -3.03629860e-02f, -2.29105040e-01f, 8.05089995e-02f, -1.85323596e-01f,
  -1.63709074e-01f, 1.09769687e-01f, 8.22654888e-02f, 1.65747032e-01f, 4.12946865e-02f, -1.10541284e-01f, 6.78709745e-02f, 4.99913990e-02f, -2.80187339e-01f, 2.58072644e-01f,
  -8.83906707e-02f, -1.49250388e-01f, -3.33801471e-02f, 9.73693728e-02f, -1.56990349e-01f, 3.83084044e-02f, 1.47538170e-01f, 2.28723675e-01f, 1.46984026e-01f, 2.96776891e-01f,
  2.26935863e-01f, 1.83841482e-01f, -1.71037838e-01f, -5.48447929e-02f, -2.55757183e-01f, -1.50971219e-01f, 1.94234043e-01f, -2.25187212e-01f, -7.11367885e-03f, -1.91871971e-02f,
  -6.42756671e-02f, -1.59173459e-01f, -8.27138349e-02f, 7.69266635e-02f, -1.16191402e-01f, -2.25852549e-01f, -2.09975719e-01f, -3.42948407e-01f, -2.28427559e-01f, 1.39264822e-01f,
  3.94390933e-02f, 6.90487167e-03f, 3.78643535e-02f, 8.30610320e-02f, 5.36012650e-02f, -1.42170534e-01f, 4.06566747e-02f, -7.51417875e-02f, 1.21890448e-01f, -3.48149277e-02f,
  -7.06344247e-02f, 1.52066365e-01f, 1.56107424e-02f, 2.19014004e-01f, 1.35299653e-01f, 1.89085439e-01f, -4.92562018e-02f, -2.08839774e-01f, 1.39784977e-01f, 1.25727415e-01f,
  2.34976992e-01f, -1.66871026e-01f, 1.81456715e-01f, 9.64674428e-02f, 4.57219929e-02f, -5.64322881e-02f, 1.94036588e-01f, 2.24715039e-01f, -9.49930102e-02f, -1.52325854e-01f,
  1.13415845e-01f, 3.67617011e-01f, 1.51866935e-02f, 1.88853562e-01f, 1.21386692e-01f, -1.88728124e-01f, -6.69537261e-02f, 1.04252554e-01f, -1.60506025e-01f, -3.29375342e-02f,
  1.82511777e-01f, -2.33011786e-02f, -1.06809177e-01f, -1.78376690e-01f, 8.33758712e-03f, 3.95753458e-02f, 1.24593660e-01f, 1.42008275e-01f, -1.22314334e-01f, -5.08129969e-02f,
  3.36003723e-03f, -2.36425132e-01f, 1.92262933e-01f, -1.41572580e-01f, -2.06325412e-01f, -6.97247908e-02f, -1.16058707e-01f, -7.68508762e-02f, 3.61097492e-02f, 1.99946076e-01f,
  1.07572190e-01f, -1.03663309e-02f, -1.11406207e-01f, 3.13532241e-02f, -1.41407222e-01f, -1.09905161e-01f, -8.18823129e-02f, -1.16690546e-01f, -1.20781466e-01f, -1.11010812e-01f,
  -1.56173036e-01f, 3.19524370e-02f, -1.84074789e-01f, 4.39884746e-03f, 6.22793622e-02f, -1.21713012e-01f, -1.14368282e-01f, -9.64043438e-02f, -8.14667121e-02f, -2.30920184e-02f,
  -1.65841654e-01f, 3.66789326e-02f, -1.92352280e-01f, 2.38502756e-01f, 2.29024187e-01f, 1.31401047e-01f, 1.43677160e-01f, 6.08109497e-02f, 1.50469646e-01f, -1.31962568e-01f,
  2.20729530e-01f, 2.25284487e-01f, 3.00170202e-03f, -2.60557324e-01f, 2.17880663e-02f, 1.27648115e-01f, 1.74329579e-02f, 1.56120792e-01f, 2.71676362e-01f, -1.34341985e-01f,
  -5.24521023e-02f, 7.37444907e-02f, -2.33429462e-01f, 1.11232512e-01f, -8.02069083e-02f, 1.45272359e-01f, 7.79475048e-02f, 1.34417508e-02f, 1.64404780e-01f, 1.21290840e-01f,
  1.34211197e-01f, 1.19989477e-01f, 1.66595101e-01f, -7.58058429e-02f, -4.25785817e-02f, -1.93203390e-01f, -4.42293659e-02f, 2.13595420e-01f, 1.61721464e-02f, 4.96074930e-02f,
  -2.00217620e-01f, -1.40246600e-01f, 6.68677762e-02f, 1.00719146e-01f, 1.60049973e-03f, -2.18862310e-01f, 1.49755776e-01f, 1.22585483e-01f, -4.60837036e-02f, -9.02237073e-02f,
  7.25225806e-02f, -1.07996516e-01f, 7.50240311e-02f, -1.15423970e-01f, 1.22847438e-01f, -8.44852254e-02f, 1.95816457e-02f, -7.64277428e-02f, 1.19009718e-01f, -1.71972692e-01f,
  -2.18944803e-01f, 8.26336537e-03f, -8.19318667e-02f, 1.87071875e-01f, 3.72879207e-02f, 1.41850598e-02f, -2.36341089e-01f, -1.10562027e-01f, -8.84165019e-02f, -1.02387816e-01f,
  -1.46748377e-02f, -1.73398480e-01f, -2.77156621e-01f, -1.63546413e-01f, 1.00669540e-01f, 1.03139617e-01f, -2.51538120e-02f, -1.38462752e-01f, -3.33787352e-01f, 1.31594148e-02f,
  -1.90050542e-01f, 1.04649603e-01f, 2.74658650e-01f, -2.49587089e-01f, -1.08134583e-01f, 3.02428395e-01f, 4.15545888e-02f, 1.31355166e-01f, 1.71287600e-02f, 7.36164823e-02f,
  3.89109030e-02f, -8.62165391e-02f, 3.54532450e-01f, 1.46299377e-02f, -2.55120307e-01f, 1.79137900e-01f, -2.82593757e-01f, -1.18573055e-01f, -8.70454460e-02f, 4.89680320e-02f,
  -1.89082444e-01f, -1.89309165e-01f, -1.49855271e-01f, -3.70199010e-02f, 8.31905678e-02f, -1.97034273e-02f, 1.57612935e-01f, 2.21328259e-01f, 1.28686160e-01f, 1.65808454e-01f,
  5.32921739e-02f, 1.84881270e-01f, 1.95796192e-01f, 1.54020600e-02f, -1.07954092e-01f, 1.67500600e-01f, -6.57543764e-02f, -1.37351826e-01f, -3.48919630e-02f, -1.34106517e-01f,
  1.13517262e-01f, 4.46752757e-02f, 7.90358037e-02f, -1.81622207e-02f, -1.10788532e-01f, 1.95205957e-01f, -7.16440156e-02f, 1.68824151e-01f, -1.72225147e-01f, 2.33610660e-01f,
  -1.85788572e-01f, 7.76998401e-02f, 1.60434797e-01f, 2.41676122e-01f, 2.32297406e-01f, 2.39609033e-01f, -7.27889761e-02f, -7.11434931e-02f, -8.43736380e-02f, 5.40043414e-02f,
  3.36051807e-02f, 1.08910605e-01f, -1.02500834e-01f, 8.91602412e-02f, 1.37241289e-01f, -3.12945187e-01f, 3.93938599e-03f, 2.35582218e-02f, 9.78313982e-02f, 7.52720386e-02f,
  -1.28032520e-01f, 6.14572577e-02f, 4.21177596e-02f, 2.11452276e-01f, -7.33971521e-02f, -8.07676241e-02f, 1.72666028e-01f, 1.25802889e-01f, -1.74456388e-01f, -1.29992634e-01f,
  -1.17078796e-02f, -7.55937621e-02f, -1.73927218e-01f, 3.25494051e-01f, 2.55626962e-02f, 1.63257569e-01f, 1.48247570e-01f, 1.47753805e-01f, -5.63207008e-02f, -8.51441175e-02f,
  -1.90903455e-01f, -6.90134689e-02f, 8.79223496e-02f, 1.96953788e-01f, -1.16656415e-01f, -6.84745014e-02f, 9.09943953e-02f, -7.22954571e-02f, 1.98052339e-02f, 1.25596702e-01f,
  -3.08456197e-02f, -2.45681509e-01f, 3.39111947e-02f, -2.06774268e-02f, 1.96269937e-02f, -1.27165895e-02f, -4.46636230e-02f, 1.82423249e-01f, -1.63938120e-01f, 4.09628684e-03f,
  2.33676583e-01f, -1.38414845e-01f, -1.33203015e-01f, 6.03319034e-02f, 1.84380069e-01f, -8.67011398e-02f, 1.71896249e-01f, 1.03084825e-01f, 1.58148333e-01f, 1.95058569e-01f,
  -8.47445354e-02f, -3.56192049e-03f, -4.31895815e-03f, -6.98515922e-02f, 3.13806891e-01f, -1.78252965e-01f, 2.65159062e-03f, -1.11387126e-01f, 1.98918894e-01f, 2.04398543e-01f,
  -9.44915414e-02f, 1.38022825e-01f, -1.31466240e-01f, 1.48982462e-02f, -2.48777270e-01f, 4.51746248e-02f, 2.28605449e-01f, 2.03265905e-01f, -2.69108769e-02f, 2.24837750e-01f,
  1.07586682e-02f, 3.75132620e-01f, 1.94631442e-01f, 1.27669066e-01f, -4.90771420e-02f, -2.89243668e-01f, -1.05698630e-02f, -1.63588479e-01f, 1.78791389e-01f, -7.17253238e-02f,
  1.58318669e-01f, 1.67431667e-01f, -4.83793877e-02f, 2.43198108e-02f, 4.79219807e-03f, 1.90136150e-01f, 8.36187527e-02f, -1.33040860e-01f, -2.39657499e-02f, -2.48957593e-02f,
  7.60700554e-02f, 1.38832167e-01f, -5.02632894e-02f, 9.85115580e-03f, 9.81196612e-02f, 1.49636688e-02f, 1.04733454e-02f, 9.09322798e-02f, -9.59206894e-02f, 9.30792689e-02f,
  9.67556536e-02f, -9.09280777e-02f, -6.04368299e-02f, -9.90207940e-02f, 1.02782309e-01f, -5.64704724e-02f, -1.15457684e-01f, 1.47618696e-01f, 7.36586284e-03f, 1.09127961e-01f,
  2.11832404e-01f, -1.34204887e-02f, 3.62334102e-02f, 2.40677476e-01f, -1.40064910e-01f, 1.50633544e-01f, -2.24675640e-01f, -1.63090020e-01f, 2.08860993e-01f, -5.28897829e-02f,
  7.68510997e-02f, -1.99280679e-01f, 6.10811375e-02f, -4.39596958e-02f, 1.48739666e-01f, 2.75495201e-01f, -1.77990377e-01f, -1.92448318e-01f, 1.40404068e-02f, 5.45127578e-02f,
  3.89847159e-02f, 6.65493980e-02f, 2.11546466e-01f, -2.85465010e-02f, 1.02295995e-01f, -7.92581588e-03f, 1.55376002e-01f, -1.52605876e-01f, 7.52411112e-02f, 5.19114360e-02f,
  -3.49305314e-03f, 1.94625825e-01f, 1.14539713e-01f, 5.30645326e-02f, 6.90909475e-02f, 1.78586736e-01f, 8.43565017e-02f, 2.44140476e-01f, -1.91518486e-01f, -1.31918073e-01f,
  -2.14004546e-01f, -8.20772946e-02f, -8.08977112e-02f, -9.40535218e-02f, 9.17635020e-03f, 1.31926611e-01f, -7.35054240e-02f, 8.49447623e-02f, 1.34644106e-01f, 8.73235241e-02f,
  -7.18268305e-02f, -4.13498655e-02f, 4.28923890e-02f, 1.55904703e-02f, -1.47476494e-01f, 1.09141342e-01f, 8.94828234e-03f, 2.41895653e-02f, 7.91390762e-02f, -6.12121411e-02f,
  7.89497942e-02f, -1.26772583e-01f, 7.01443925e-02f, -2.83913612e-01f, 1.24795586e-01f, -1.45165846e-01f, -7.02132881e-02f, 2.06205994e-01f, -4.94283959e-02f, 1.20911315e-01f,
  2.32125923e-01f, -3.38058136e-02f, 2.34095573e-01f, 3.19815725e-01f, -1.06897324e-01f, 1.90441422e-02f, -2.01444551e-01f, 3.97624262e-02f, -2.85012454e-01f, 1.96558803e-01f,
  -7.44111910e-02f, -2.46783346e-01f, -3.09855372e-01f, 1.90435890e-02f, 2.16330335e-01f, -9.13039967e-02f, 5.06413244e-02f, -1.68684602e-01f, -1.73246354e-01f, 5.14779501e-02f,
  1.09313957e-01f, 1.41614586e-01f, -2.30790764e-01f, -2.63383657e-01f, 1.30335763e-01f, -8.29157326e-03f, 1.31478220e-01f, -2.79731661e-01f, -7.97192529e-02f, 1.32538855e-01f,
  1.11097336e-01f, 1.93295419e-01f, -4.79332311e-03f, -1.52109480e-02f, -1.34806603e-01f, 3.35703716e-02f, -1.70335978e-01f, -5.14315953e-03f, 7.06543401e-02f, -9.64024104e-03f,
  3.98387685e-02f, -5.39579429e-02f, -9.43289548e-02f, 7.14816377e-02f, 8.96786228e-02f, -5.33981472e-02f, -1.02497898e-01f, 9.40723866e-02f, -4.33552340e-02f, 3.44282016e-02f,
  1.68758538e-02f, -2.58567274e-01f, 4.71329801e-02f, 2.30050813e-02f, -2.09090021e-03f, -1.68394238e-01f, -7.43056759e-02f, 6.47191182e-02f, -7.30354786e-02f, 1.83779955e-01f,
  1.15364641e-01f, 5.35024814e-02f, 1.52248129e-01f, 1.93294495e-01f, 6.15052171e-02f, 4.84195426e-02f, -1.58726946e-01f, -2.13423178e-01f, -9.10717025e-02f, 1.15767121e-01f,
  -1.82839260e-02f, 1.48339778e-01f, 6.77837357e-02f, -4.06417660e-02f, 1.11667939e-01f, -5.68269789e-02f, 1.63531080e-01f, 2.57927150e-01f, -1.14899047e-01f, -2.45177686e-01f,
  -1.94155127e-02f, -8.39683786e-02f, -3.41567785e-01f, -1.78644180e-01f, 5.09083755e-02f, 1.57107204e-01f, 1.58596516e-01f, 2.38827124e-01f, -3.24222781e-02f, -2.32962132e-01f,
  -8.66440311e-02f, -1.59782395e-01f, -3.66375670e-02f, 2.41396561e-01f, 1.67366937e-01f, -2.14826778e-01f, 1.63040102e-01f, 2.16053784e-01f, 2.03405365e-01f, -2.41049990e-01f,
  -1.87370673e-01f, 8.87743533e-02f, 9.31418836e-02f, -2.29170129e-01f, 1.10414311e-01f, 9.00523551e-03f, -5.95709682e-02f, 2.20371736e-03f, 1.29864350e-01f, -6.98241442e-02f,
  6.90309256e-02f, 1.58577248e-01f, 3.98806259e-02f, 5.03837131e-02f, 1.48494944e-01f, -6.98601753e-02f, 1.49176260e-02f, 1.56515405e-01f, -1.81612536e-01f, -2.63721436e-01f,
  -3.14423628e-02f, 2.28441879e-01f, 2.57831533e-03f, 2.09854439e-01f, 1.31323934e-01f, -5.24623170e-02f, 7.71735907e-02f, 7.73091167e-02f, 1.71273679e-01f, -5.61014935e-03f,
  -2.16561750e-01f, -1.79850265e-01f, 1.01747431e-01f, 2.78582454e-01f, 4.32802364e-02f, 1.23312548e-01f, 2.24462703e-01f, -3.30272764e-02f, 5.60602248e-02f, 1.54797494e-01f,
  9.39919520e-03f, 7.69639611e-02f, -1.18437693e-01f, -2.15312824e-01f, 5.52385161e-03f, -1.26135379e-01f, -1.09569587e-01f, 3.21593918e-02f, 1.52780861e-01f, 6.36530221e-02f,
  -1.51066771e-02f, 5.69282956e-02f, -1.23238422e-01f, -1.02020733e-01f, -5.90778887e-02f, 9.36012194e-02f, 1.53298602e-02f, -2.10896111e-03f, 1.04746908e-01f, -1.47736505e-01f,
  1.83025107e-01f, 2.56222188e-01f, 2.66709864e-01f, -1.02616511e-01f, -1.45395681e-01f, -4.42408361e-02f, 4.30772640e-02f, 3.78804170e-02f, 1.80621650e-02f, 1.39594451e-01f,
  -7.64982328e-02f, -1.03736855e-01f, 7.84623921e-02f, 2.36678664e-02f, -3.88399325e-03f, -2.60992777e-02f, 1.58837009e-02f, 1.95477471e-01f, -3.50845866e-02f, 1.69180587e-01f,
  1.39263064e-01f, 3.88243571e-02f, 5.52104972e-02f, -3.80992405e-02f, 2.27112055e-01f, 2.17484578e-01f, 1.03491582e-01f, -5.67878671e-02f, 1.85880721e-01f, 2.40350038e-01f,
  -1.42678589e-01f, 5.53799719e-02f, 2.95720771e-02f, -6.12500422e-02f, 7.72313625e-02f, -1.76148564e-01f, 2.06464186e-01f, 2.19508588e-01f, 1.57113418e-01f, 1.42315373e-01f,
  -9.39863622e-02f, -1.93291362e-02f, -7.87289590e-02f, 9.73548666e-02f, -2.02078909e-01f, -2.93968737e-01f, 1.84494779e-01f, -1.20104633e-01f, -1.56524442e-02f, -1.86737657e-01f,
  -1.21939205e-01f, 1.26719669e-01f, 1.67010412e-01f, 5.48835518e-03f, -1.68213192e-02f, -6.99225590e-02f, -5.91536313e-02f, -1.84095278e-01f, 1.37601689e-01f, 8.60223398e-02f,
  -1.45385191e-02f, 1.97434187e-01f, -1.73890635e-01f, -6.52623698e-02f, 7.72770569e-02f, 1.66338235e-01f, 1.69024438e-01f, -7.63771534e-02f, -1.32342473e-01f, 1.05113052e-02f,
  -5.56295365e-02f, 6.81032166e-02f, -8.69593173e-02f, 8.14457685e-02f, -1.30574852e-01f, -2.51291811e-01f, -7.07533211e-02f, 1.18014067e-02f, -1.51643798e-01f, 9.11653340e-02f,
  -1.10582458e-02f, -3.91626032e-03f, -3.14354710e-02f, 4.12644558e-02f, 2.29116410e-01f, -9.69855413e-02f, -1.28356323e-01f, 1.60651207e-01f, 2.91277021e-01f, -1.26584217e-01f,
  2.14464962e-01f, 1.18181013e-01f, 1.93529949e-02f, 1.92858905e-01f, 5.44647463e-02f, 1.25624269e-01f, 1.41850993e-01f, -4.07072864e-02f, 2.47918993e-01f, -5.10187782e-02f,
  3.93633358e-02f, -1.24562040e-01f, 1.19035626e-02f, 2.18355849e-01f, -1.71986774e-01f, 2.45913208e-01f, 4.99676578e-02f, -1.52855769e-01f, -2.58685946e-01f, 1.89919561e-01f,
  1.72087237e-01f, 1.02837220e-01f, -7.74295814e-03f, 1.61811769e-01f, -4.85523604e-02f, 5.94855919e-02f, 1.87921166e-01f, 3.44561897e-02f, -5.88426329e-02f, -2.44273543e-01f,
  -6.87090773e-03f, -1.98768899e-01f, 5.58883175e-02f, -1.46942168e-01f, 2.38482840e-02f, 5.06416596e-02f, -2.96398881e-04f, 4.96154800e-02f, -1.39132753e-01f, 2.32986778e-01f,
  7.48443604e-02f, -1.57447338e-01f, 1.00855492e-01f, 9.91353467e-02f, 5.10809645e-02f, -1.23470671e-01f, -9.60469022e-02f, -4.00597528e-02f, -9.23501998e-02f, 9.00191218e-02f,
  1.07851639e-01f, -4.56034727e-02f, 1.19254403e-01f, 9.82891247e-02f, 1.08241193e-01f, -9.29668024e-02f, 2.88660219e-03f, 1.18016079e-01f, -1.03546660e-02f, 7.09368140e-02f,
  -4.14066836e-02f, -7.08736554e-02f, -1.53722465e-01f, 4.27596606e-02f, 1.18161283e-01f, -5.15468754e-02f, 1.90711170e-01f, 1.71028420e-01f, -1.04587197e-01f, -1.49203241e-01f,
  2.42345065e-01f, 1.41979232e-01f, -3.05033922e-01f, -2.89722592e-01f, -1.68630809e-01f, 1.41586885e-01f, -2.97168911e-01f, 1.97731137e-01f, 2.68029571e-01f, 3.54385190e-02f,
  -7.81420320e-02f, -5.83579540e-02f, 6.09687269e-02f, 1.95475683e-01f, -2.41375994e-02f, -8.18015018e-04f, 2.63383001e-01f, -1.31194089e-02f, 1.69147030e-01f, 2.98868734e-02f,
  -6.48733601e-02f, -2.50086188e-02f, -2.41759688e-01f, -9.17647183e-02f, 1.76208634e-02f, 1.90842241e-01f, -1.56202570e-01f, 7.24815950e-02f, -1.02093659e-01f, -5.14100902e-02f,
  2.97601204e-02f, 6.36721104e-02f, 2.85625327e-02f, -2.14656949e-01f, -1.53669298e-01f, -1.16137415e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.56772714e-02f, -1.84379280e-01f, 7.70973694e-03f, 1.63122818e-01f, 7.74053857e-02f, -1.24509074e-02f, 2.38828748e-01f, 3.39690387e-01f, 1.28233984e-01f, 2.03722641e-01f,
  3.19520950e-01f, 2.04071522e-01f, 9.32100117e-02f, 3.10525388e-01f, 3.62863243e-01f, 2.92291224e-01f, 2.98648357e-01f, 1.44750580e-01f, 9.50491354e-02f, -3.22857052e-01f,
  3.68551999e-01f, -5.07794380e-01f, -3.38085704e-02f, -2.23006800e-01f, -3.91464829e-01f, -4.27283287e-01f, 4.70321894e-01f, 3.89459491e-01f, 1.08318724e-01f, -3.41683298e-01f,
  2.77845889e-01f, 2.06272259e-01f, 3.90611857e-01f, 2.03739405e-01f, 8.62523764e-02f, 2.99570650e-01f, -4.97619152e-01f, -2.52686609e-02f, 4.03189093e-01f, 2.26428226e-01f,
  2.31553957e-01f, -8.70399550e-02f, 3.81030083e-01f, -1.06236361e-01f, -2.88722992e-01f, 4.71051365e-01f, -2.35398918e-01f, -1.14113152e-01f, -3.75392325e-02f, 5.57809711e-01f,
  -4.40629691e-01f, -2.58630048e-02f, 5.71457017e-03f, -1.95818380e-01f, 1.17071256e-01f, -3.00121099e-01f, 1.48976281e-01f, -9.03574899e-02f, -5.81749044e-02f, 1.75118178e-01f,
  2.20673367e-01f, 3.16567957e-01f, 3.40446264e-01f, 2.33608127e-01f, 1.17432974e-01f, -1.84470832e-01f, 1.74155280e-01f, 1.25978202e-01f, 7.66394287e-02f, 1.73779935e-01f,
  6.00936376e-02f, 3.64348888e-01f, -3.26648820e-03f, 1.45993188e-01f, -6.02221191e-02f, 1.84544608e-01f, 6.73132315e-02f, 1.96017936e-01f, 2.14929789e-01f, -9.05538723e-03f,
  1.57679990e-01f, -1.96528450e-01f, 2.40005571e-02f, 1.75639138e-01f, -9.97055992e-02f, -2.02647671e-01f, -2.08302904e-02f, 4.26533669e-02f, -3.07085633e-01f, 1.62955039e-04f,
  2.15240315e-01f, -3.74395609e-01f, -3.62531394e-01f, -3.59092981e-01f, 1.48731753e-01f, 3.94756317e-01f, 1.13615908e-01f, 1.98816024e-02f, 4.04767454e-01f, -2.95772314e-01f,
  -2.14565367e-01f, -1.87634826e-01f, 4.69877906e-02f, 4.14542347e-01f, 2.26165459e-01f, -1.42639190e-01f, -1.20955855e-01f, -8.75300318e-02f, -1.13236114e-01f, 5.28191447e-01f,
  5.17523400e-02f, 4.02106762e-01f, 6.17078356e-02f, 1.67927876e-01f, 4.51689884e-02f, 2.56653242e-02f, -7.94515386e-02f, 2.33964249e-01f, 1.24774106e-01f, 3.27216476e-01f,
  4.02366400e-01f, 4.68512863e-01f, -9.39976573e-02f, -1.56092048e-01f, 2.16076151e-01f, -1.88375950e-01f, 1.05856322e-01f, 2.99709737e-01f, 2.57412702e-01f, 3.74620594e-03f,
  6.19435385e-02f, 8.41619223e-02f, 1.37986034e-01f, 2.69856900e-01f, 8.56152847e-02f, 3.27725887e-01f, 1.05493478e-01f, 1.97772175e-01f, 1.01564966e-01f, 1.32551745e-01f,
  8.25988129e-02f, 1.55118406e-01f, 1.08076721e-01f, -6.13604113e-02f, 3.29324245e-01f, -4.65760194e-02f, 2.20983833e-01f, -1.27106950e-01f, 3.01317215e-01f, -3.12946260e-01f,
  -3.93175036e-01f, -5.07830679e-01f, -7.79058337e-02f, 1.66606426e-01f, -9.67544988e-02f, 2.32688755e-01f, -7.49155879e-02f, -2.52747267e-01f, -4.62586954e-02f, 3.15318793e-01f,
  -7.12230802e-02f, -2.09540874e-01f, -3.22009593e-01f, 8.20778161e-02f, -3.72059375e-01f, 9.37037840e-02f, -3.48253138e-02f, -1.13134913e-01f, -6.78377226e-02f, 3.18672270e-01f,
  3.20942134e-01f, -7.40247220e-02f, 3.82410496e-01f, 2.10458934e-01f, -3.39621631e-03f, -8.77950341e-02f, 6.17517792e-02f, 1.26595214e-01f, -2.85773277e-02f, 3.60419333e-01f,
  4.85900223e-01f, -8.28761831e-02f, 2.91440874e-01f, -3.24691594e-01f, -4.37705852e-02f, 1.02902696e-01f, 5.10641932e-01f, 4.36761171e-01f, -4.90632840e-02f, -2.26892307e-01f,
  -2.10487694e-01f, -1.62852645e-01f, 2.20435509e-03f, 5.79413660e-02f, -8.81473795e-02f, 2.81801999e-01f, 1.96597233e-01f, -5.62576279e-02f, 1.58601955e-01f, 1.60978749e-01f,
  2.86396444e-01f, 1.34041965e-01f, -8.04046169e-02f, 1.95259467e-01f, 1.51250521e-02f, 1.84629768e-01f, 2.50412971e-01f, 4.71008569e-02f, 2.59184241e-02f, -1.25672119e-02f,
  1.38268024e-01f, -3.08543384e-01f, 2.15913415e-01f, -6.41529039e-02f, -3.40846866e-01f, 1.84423272e-02f, -2.17710972e-01f, -4.85160679e-01f, 5.39236605e-01f, -1.44748867e-01f,
  1.68118298e-01f, -4.53301780e-02f, 1.69641674e-02f, 4.73108828e-01f, 8.36686566e-02f, 1.32219955e-01f, 7.59396031e-02f, 2.16753706e-01f, -2.70785570e-01f, -3.38793159e-01f,
  3.71155262e-01f, 2.56263971e-01f, -1.44574031e-01f, -2.00366333e-01f, -1.36138089e-02f, -1.26867816e-01f, -1.52354509e-01f, 4.13999796e-01f, -6.35327864e-03f, 1.18988119e-02f,
  2.46613607e-01f, 3.75954956e-01f, 4.53186482e-01f, 2.46879056e-01f, -2.54788511e-02f, -8.55491683e-02f, 1.68349802e-01f, -7.74020329e-02f, 1.18942127e-01f, -8.26055706e-02f,
  -7.29117766e-02f, -3.63897644e-02f, 3.16912770e-01f, 4.73642677e-01f, 3.90277505e-01f, 1.09212749e-01f, -8.92809033e-03f, 1.64743494e-02f, -2.81030908e-02f, 2.59357691e-01f,
  1.30837694e-01f, 3.10455382e-01f, 2.26819143e-01f, 1.42122045e-01f, -1.61808319e-02f, 1.95767313e-01f, -9.96203274e-02f, 2.65887141e-01f, 9.02526751e-02f, 3.64327013e-01f,
  2.55973876e-01f, 1.11083016e-01f, 3.12818974e-01f, -6.39917850e-02f, 1.64542273e-01f, 1.06839404e-01f, 2.89350122e-01f, 2.48659849e-01f, -1.63312182e-01f, -7.54322261e-02f,
  1.18641220e-01f, 3.81495863e-01f, -3.01326672e-03f, 3.21521789e-01f, -1.13856174e-01f, -2.46619865e-01f, 2.80970603e-01f, 2.85782397e-01f, 3.70018929e-01f, -2.21685380e-01f,
  2.78387576e-01f, -6.54513463e-02f, -3.64157259e-01f, 1.72145724e-01f, -1.75875902e-01f, -3.53368133e-01f, -4.88184206e-02f, -1.82306409e-01f, 1.70552075e-01f, 1.69576004e-01f,
  5.95625155e-02f, 9.77089033e-02f, -4.91637081e-01f, 7.89219439e-02f, 4.21985716e-01f, -3.43294561e-01f, 3.88415873e-01f, 2.53052950e-01f, 2.49921858e-01f, -7.23192096e-02f,
  3.19928586e-01f, -1.48630038e-01f, 1.90311238e-01f, 2.08700925e-01f, -6.11492991e-03f, 3.21754277e-01f, -1.50749505e-01f, 1.51898324e-01f, -9.79083925e-02f, -5.56765161e-02f,
  -2.56135240e-02f, -1.25071853e-01f, 1.14385046e-01f, 8.86499323e-03f, 2.30941828e-02f, 5.39600775e-02f, 7.24771023e-02f, 2.09076419e-01f, 8.13767090e-02f, 6.89055920e-02f,
  1.20577328e-01f, 1.93888545e-01f, 2.43006855e-01f, -1.11485578e-01f, 1.05673656e-01f, 9.84985977e-02f, -1.08828612e-01f, 1.81433260e-02f, 1.08000293e-01f, -9.50323716e-02f,
  -2.82911748e-01f, -1.33557349e-01f, 1.55857382e-02f, 2.70357937e-01f, -4.28650320e-01f, -2.43666455e-01f, 1.10969365e-01f, -3.14601451e-01f, -2.12275490e-01f, -1.56734020e-01f,
  3.90730016e-02f, 1.62129775e-01f, 1.38305604e-01f, -5.70709631e-02f, 9.39020216e-02f, -1.45723701e-01f, -2.05387250e-01f, -1.22555897e-01f, 4.71588552e-01f, 3.05342942e-01f,
  3.90729755e-01f, 9.67932791e-02f, -3.42816859e-01f, 7.15788305e-02f, -3.26990008e-01f, 4.99895960e-01f, 3.02007616e-01f, 5.63805662e-02f, -1.33157894e-01f, 4.35236812e-01f,
  4.80311513e-02f, -1.03952214e-01f, -1.13178700e-01f, 3.22615892e-01f, -3.63636576e-02f, 3.92827719e-01f, 4.02264178e-01f, 1.57933936e-01f, -2.33584717e-01f, -1.58858672e-01f,
  -4.84731644e-02f, 7.63654485e-02f, 1.95292979e-01f, 2.70258337e-01f, -2.48917997e-01f, 9.81300771e-02f, 2.89060175e-01f, -1.08747266e-01f, -6.37393519e-02f, 1.62326857e-01f,
  -1.75374951e-02f, 2.24017575e-02f, 2.18150035e-01f, 2.07277928e-02f, 2.61886925e-01f, 5.71804643e-02f, 1.78766891e-01f, -7.86005929e-02f, 3.20956931e-02f, 3.11636925e-01f,
  1.76698551e-01f, 4.23087925e-01f, -8.97454545e-02f, 6.89973459e-02f, -2.40977958e-01f, 1.59848034e-02f, 4.41013128e-01f, 6.53587729e-02f, 2.34419778e-01f, 3.77906375e-02f,
  2.25347102e-01f, -3.75372350e-01f, 3.27678978e-01f, 2.80504405e-01f, -2.01487541e-01f, -3.70241702e-01f, -2.59187937e-01f, 3.85189742e-01f, 1.66706387e-02f, -2.20060516e-02f,
  1.20132960e-01f, 3.51067111e-02f, 4.31309611e-01f, 1.19370021e-01f, -7.15218633e-02f, 5.37363350e-01f, 1.95276424e-01f, 3.46500456e-01f, 4.05409001e-02f, 6.93127513e-02f,
  3.61105442e-01f, 3.80161941e-01f, 6.86571747e-02f, 3.37192148e-01f, -2.09537625e-01f, -2.48717591e-01f, -1.67007595e-01f, 2.35411227e-01f, -3.60973738e-02f, 4.19501841e-01f,
  7.33381435e-02f, 2.46625751e-01f, -1.92376971e-01f, 6.20950982e-02f, 2.35920444e-01f, 3.38917315e-01f, 3.08356881e-01f, 1.08442977e-01f, -2.47772560e-01f, 1.74254179e-01f,
  6.02802485e-02f, 8.08783472e-02f, 3.59094828e-01f, 1.38806060e-01f, 2.58082509e-01f, 9.85391960e-02f, 1.81265786e-01f, -1.09357581e-01f, -4.26041782e-02f, 2.46719316e-01f,
  -3.59199084e-02f, 4.71386194e-01f, 2.70021707e-01f, -5.04875369e-02f, 5.08819558e-02f, -6.19962327e-02f, 2.16088057e-01f, -1.12883046e-01f, 1.90613821e-01f, 3.15265834e-01f,
  -1.92409396e-01f, 9.25549120e-02f, 9.72124487e-02f, 3.81987244e-01f, 1.40173109e-02f, 2.22515270e-01f, -4.43242118e-02f, -6.37790328e-03f, -1.30688742e-01f, -1.46897389e-02f,
  1.31362066e-01f, 1.04301600e-02f, 2.52110064e-01f, 4.70825806e-02f, 1.34150460e-01f, 1.10925384e-01f, -1.13677822e-01f, 3.90597247e-02f, 1.21331692e-01f, -1.12859406e-01f,
  1.79920167e-01f, -1.45795286e-01f, 1.29795969e-01f, -2.70209849e-01f, -4.57557589e-01f, -1.71636760e-01f, 4.20068353e-01f, 1.94125667e-01f, 5.72683513e-01f, 4.35622036e-01f,
  7.38194287e-02f, -1.79631248e-01f, 1.42721146e-01f, -3.08427438e-02f, 4.25285026e-02f, 3.59945089e-01f, 2.67936081e-01f, -7.80907869e-02f, 3.28539044e-01f, 4.15389985e-01f,
  4.41174269e-01f, 1.96428835e-01f, -3.85876708e-02f, 9.58650932e-02f, 1.58723891e-01f, 1.55695558e-01f, 1.91856325e-01f, 2.72715867e-01f, 2.09026873e-01f, -8.01112279e-02f,
  -2.61189714e-02f, -9.99457948e-03f, 1.75007284e-01f, 1.37251616e-01f, 2.27372363e-01f, 4.13133539e-02f, 1.62866220e-01f, 3.32595259e-01f, 6.31498694e-02f, 2.15534881e-01f,
  1.95008591e-01f, 4.14074063e-02f, 3.76819611e-01f, -3.50327045e-01f, -1.88106652e-02f, 2.31197923e-02f, -1.21605486e-01f, 8.51801969e-03f, -2.05426782e-01f, 2.23057628e-01f,
  4.61633950e-02f, 7.45891966e-03f, 3.29687208e-01f, 2.04458117e-01f, -1.01809345e-01f, -1.98474288e-01f, 2.76034623e-01f, -1.88244984e-01f, -3.15956950e-01f, 1.83333844e-01f,
  -6.74245283e-02f, 6.03606924e-03f, 1.76772058e-01f, -4.11854714e-01f, 3.44687104e-01f, 1.70456618e-01f, -3.72875869e-01f, 7.52728432e-02f, -1.01735920e-01f, -1.36003286e-01f,
  1.24293469e-01f, 1.56196142e-02f, -9.71275289e-03f, -7.19817132e-02f, 2.98734475e-02f, 3.13421898e-02f, 2.21658364e-01f, -2.10422292e-01f, 3.98825586e-01f, 2.43876893e-02f,
  -1.99296743e-01f, -5.40098660e-02f, -1.15485862e-01f, 1.24414153e-01f, 2.15473145e-01f, 4.83907193e-01f, -2.00340569e-01f, 2.87262946e-01f, 2.06531927e-01f, 1.33907840e-01f,
  1.38141215e-01f, 1.02043465e-01f, 1.89594358e-01f, -1.85976416e-01f, 8.36721957e-02f, 7.34211951e-02f, -5.10330573e-02f, 1.66299775e-01f, 1.53490022e-01f, 1.35122940e-01f,
  -8.98239538e-02f, 2.50552654e-01f, 2.32599929e-01f, 1.74342275e-01f, 1.74753577e-01f, 1.71993226e-01f, 3.39394420e-01f, 1.83043778e-02f, 2.66997337e-01f, 6.21997193e-02f,
  4.01651502e-01f, 3.71867716e-01f, -2.09854320e-01f, 7.42675364e-03f, 3.03073734e-01f, 3.35940778e-01f, 2.34413326e-01f, 7.29834959e-02f, 4.71997522e-02f, 7.66444057e-02f,
  1.13658793e-01f, 1.26972666e-03f, -2.57698804e-01f, 1.96205396e-02f, 1.25907302e-01f, 1.78336233e-01f, -3.18768203e-01f, -1.87590301e-01f, 4.32975918e-01f, 4.26896781e-01f,
  1.98897198e-01f, -1.83230937e-01f, 2.05384150e-01f, 2.00352207e-01f, 1.80680975e-01f, -2.80068330e-02f, 1.02149136e-01f, -4.39034142e-02f, 3.25262062e-02f, -1.51857048e-01f,
  3.29066664e-01f, -1.94929466e-01f, -5.04409783e-02f, 7.39109218e-02f, -1.07888021e-01f, 1.03256442e-01f, 1.74219966e-01f, 3.87365907e-01f, 3.64510417e-01f, 1.56422108e-01f,
  9.40669179e-02f, 1.65081635e-01f, 7.59983156e-03f, 2.03082874e-01f, -3.65528986e-02f, 2.41103768e-01f, 1.08365260e-01f, -4.18483317e-02f, 1.94725230e-01f, -4.85144509e-03f,
  1.60126835e-01f, 1.91572141e-02f, 1.51401684e-01f, 1.88580036e-01f, -5.11147864e-02f, 2.09023073e-01f, -5.23697026e-02f, 2.07131337e-02f, 1.18515044e-01f, 1.97183624e-01f,
  1.76162228e-01f, -3.52749467e-01f, -8.57962519e-02f, 3.99339199e-01f, -3.36019874e-01f, -3.09507906e-01f, 7.65418187e-02f, -2.97481149e-01f, -4.02732968e-01f, -6.89607337e-02f,
  3.54216039e-01f, 3.42484951e-01f, 1.84824571e-01f, -4.16670144e-01f, 3.15412730e-01f, -4.31475639e-01f, -3.95297021e-01f, -2.50980169e-01f, 4.17348802e-01f, 1.97710112e-01f,
  2.25678578e-01f, -4.51615274e-01f, -7.04965889e-02f, 3.38735253e-01f, -4.59640473e-01f, -1.01542715e-02f, 1.32981375e-01f, -1.64197102e-01f, -9.85267460e-02f, -8.18146393e-02f,
  3.45620841e-01f, 6.09733388e-02f, -4.81472574e-02f, 3.84703398e-01f, 9.06104073e-02f, 7.26452470e-02f, 1.74777254e-01f, -9.84124392e-02f, -1.26185656e-01f, -1.42649963e-01f,
  -1.63361534e-01f, 5.56146875e-02f, 3.09023291e-01f, 3.67596686e-01f, -3.49060856e-02f, 1.67815283e-01f, 5.84630147e-02f, -4.13241684e-02f, 3.55312265e-02f, 1.59375459e-01f,
  1.29598632e-01f, 1.24405198e-01f, 1.71032727e-01f, 2.61076331e-01f, 3.61325108e-02f, 2.43322894e-01f, 2.09219396e-01f, 1.42248660e-01f, 2.00335979e-01f, 1.96279243e-01f,
  1.95923403e-01f, 5.09813465e-02f, 2.95224646e-03f, 4.60537881e-01f, -1.05208322e-01f, 3.99457663e-01f, 4.37051505e-01f, -1.06972858e-01f, 4.33312029e-01f, 3.95284683e-01f,
  -3.04181993e-01f, 7.01451823e-02f, 6.42142072e-02f, -4.75435369e-02f, 3.65574867e-01f, -2.95631379e-01f, 7.45197088e-02f, 1.63020968e-01f, 7.56088495e-02f, 1.17114924e-01f,
  3.44438493e-01f, 4.36357468e-01f, -3.10630411e-01f, -4.17123623e-02f, -2.98211098e-01f, 3.66005033e-01f, 2.54112214e-01f, 4.28056449e-01f, 3.17547679e-01f, -1.66876093e-02f,
  1.23648278e-01f, 4.67060596e-01f, 3.74234408e-01f, -2.54044563e-01f, 2.32426122e-01f, -8.20444152e-02f, 2.96892762e-01f, -6.92921355e-02f, 1.65216833e-01f, 2.72720695e-01f,
  1.39640093e-01f, 3.24603498e-01f, -5.54249026e-02f, 2.80165315e-01f, -1.13910716e-02f, -4.26252894e-02f, -1.72765762e-01f, -9.93586928e-02f, 1.17777465e-02f, -4.70471103e-03f,
  8.82152617e-02f, 2.33178452e-01f, -5.72959483e-02f, 1.53105825e-01f, -1.42996401e-01f, -1.83781415e-01f, 1.45293832e-01f, 2.49284148e-01f, 8.69549960e-02f, 2.67684698e-01f,
  1.59847900e-01f, 1.74543291e-01f, 1.23572655e-01f, 9.51586738e-02f, 3.26370597e-01f, 2.20557511e-01f, -8.74231905e-02f, -8.73242915e-02f, 3.38514358e-01f, 6.61727712e-02f,
  4.17474687e-01f, 6.70713857e-02f, 5.50857410e-02f, -8.07234049e-02f, 2.59642899e-01f, 4.62763637e-01f, 2.07304701e-01f, 8.84885862e-02f, 2.47454599e-01f, -2.29788572e-01f,
  5.39448857e-01f, 1.89404801e-01f, 5.11045232e-02f, 2.35746786e-01f, -3.12885314e-01f, 5.15238829e-02f, 2.34291688e-01f, 3.52999508e-01f, 1.46256955e-02f, -1.29556552e-01f,
  1.71109706e-01f, 1.80328831e-01f, 4.83550392e-02f, 4.92105335e-01f, -3.59491929e-02f, 2.51705199e-01f, 5.74820768e-03f, 1.04831502e-01f, -1.50923654e-01f, -2.29243916e-02f,
  1.39573082e-01f, -2.52007127e-01f, 1.07545108e-01f, 1.62706092e-01f, -4.07219268e-02f, -1.55401081e-01f, -9.50678661e-02f, 2.11050242e-01f, 5.73655441e-02f, 3.66759270e-01f,
  3.92442256e-01f, -4.19356018e-01f, 1.03983685e-01f, 1.23673361e-02f, 7.09340796e-02f, -1.27262339e-01f, 6.27002269e-02f, 8.44181553e-02f, 2.13845307e-03f, 3.87263559e-02f,
  -5.52896746e-02f, 4.14144322e-02f, -3.66487913e-02f, -2.25648172e-02f, -2.69133821e-02f, -6.50579557e-02f, -1.17355175e-01f, 1.51244365e-02f, -1.28701717e-01f, -1.22859672e-01f,
  -8.28195661e-02f, 1.82022795e-03f, -1.14546552e-01f, 5.45413308e-02f, 3.32782716e-02f, 3.40141207e-02f, -5.93641214e-02f, -1.18374377e-01f, 6.90242127e-02f, -1.17761701e-01f,
  5.16407378e-02f, -9.92343873e-02f, -1.07509241e-01f, 2.97154859e-02f, 5.39572164e-02f, 6.93024043e-03f, -9.86600369e-02f, -6.42813891e-02f, 2.38430183e-02f, 1.17107496e-01f,
  -6.79578036e-02f, -9.37366262e-02f, -9.29958820e-02f, -1.08932741e-01f, -8.44590962e-02f, -1.13407589e-01f, 6.76572546e-02f, -5.31445146e-02f, -9.68808234e-02f, 3.83656435e-02f,
  -8.60698670e-02f, -1.37632713e-02f, 4.70920242e-02f, -6.98829815e-02f, -2.32543051e-02f, -5.12502110e-03f, -8.73573720e-02f, -9.90557820e-02f, -8.66779909e-02f, 3.23292017e-02f,
  -5.48706166e-02f, 4.52183038e-02f, -3.34589779e-02f, -7.24865124e-02f, 2.31179763e-02f, -1.19974665e-01f, 2.95705050e-01f, 3.15219820e-01f, 1.26560301e-01f, 2.34259307e-01f,
  1.57273740e-01f, 2.71517634e-01f, 3.30216289e-01f, 6.39630333e-02f, 1.82470664e-01f, 4.70006950e-02f, 2.93263346e-01f, 1.51940197e-01f, 2.31475085e-01f, 1.27581239e-01f,
  4.76276763e-02f, 2.89946556e-01f, -8.31153244e-02f, 1.18200600e-01f, 1.68756112e-01f, 3.26327324e-01f, -1.26632854e-01f, -3.21674734e-01f, -1.43280178e-01f, -7.67557546e-02f,
  1.31973565e-01f, 6.02477528e-02f, -3.74141634e-01f, -4.37643081e-01f, -2.71878362e-01f, 3.71510275e-02f, 6.35951385e-02f, 1.54420376e-01f, -2.97415048e-01f, -1.65700719e-01f,
  6.22892454e-02f, -3.62436861e-01f, 6.63656183e-03f, -9.00089964e-02f, -1.15289643e-01f, 3.05602372e-01f, 1.46228611e-01f, 1.56261194e-02f, 3.91438931e-01f, 4.59053963e-01f,
  3.37086409e-01f, -2.60839581e-01f, 3.20008844e-01f, 4.11717653e-01f, -2.14525238e-01f, -1.20886818e-01f, 1.87627435e-01f, -1.64525643e-01f, 1.75673596e-03f, 3.90797257e-01f,
  1.92338124e-01f, 1.31993160e-01f, 2.53097326e-01f, 2.56002277e-01f, 1.24745183e-01f, 1.84266642e-01f, 8.36850330e-02f, -3.13369602e-01f, -1.56273335e-01f, 5.54626644e-01f,
  -1.75995335e-01f, 3.09746355e-01f, 2.62309074e-01f, 7.27632493e-02f, 1.62720993e-01f, 1.98366985e-01f, 9.67835933e-02f, -8.87891352e-02f, 3.39275897e-01f, 1.80317741e-02f,
  2.49068722e-01f, 8.25677216e-02f, 1.49122268e-01f, 9.60395709e-02f, 1.98184833e-01f, 2.71756858e-01f, 2.54496992e-01f, 4.42345172e-01f, 4.52971049e-02f, -2.76648521e-01f,
  1.25559479e-01f, -1.72363192e-01f, 1.69015780e-01f, -1.18021972e-01f, 1.72410399e-01f, -8.42570812e-02f, 1.88942119e-01f, -1.01416290e-01f, 5.28618276e-01f, 3.61828744e-01f,
  -1.05975315e-01f, -8.35144967e-02f, -1.31498545e-01f, 5.18724799e-01f, -2.08873302e-01f, 3.79168272e-01f, -2.22503722e-01f, -2.45947525e-01f, 2.88507342e-01f, 3.02016526e-01f,
  -3.50861311e-01f, 5.41965701e-02f, 5.75429022e-01f, 1.02887310e-01f, -2.55740676e-02f, -1.16521120e-01f, 1.64225534e-01f, 1.22132212e-01f, -1.18321702e-02f, 4.26688135e-01f,
  -3.10724735e-01f, -9.38731059e-02f, -7.92878196e-02f, -1.06165364e-01f, 3.42949897e-01f, -7.78722912e-02f, -1.78835675e-01f, -1.38649791e-01f, 1.63992979e-02f, 2.70245701e-01f,
  3.04309368e-01f, 1.43771529e-01f, 4.30225879e-01f, -1.43136131e-02f, 8.64629000e-02f, 2.10098907e-01f, 2.30936810e-01f, 6.80643842e-02f, -7.04810619e-02f, 2.75875498e-02f,
  1.91224441e-01f, 4.70233299e-02f, 1.94314018e-01f, 2.86148608e-01f, 4.49622460e-02f, 1.82146132e-01f, 1.66079208e-01f, 8.67305025e-02f, -6.77182376e-02f, -4.33928221e-02f,
  6.93811625e-02f, 2.59644873e-02f, -1.69108778e-01f, -6.18541352e-02f, -3.97899896e-01f, 3.45997721e-01f, 2.86587089e-01f, 2.53641039e-01f, 3.52882832e-01f, -7.18843415e-02f,
  1.96074396e-01f, -2.60275155e-01f, 2.06033602e-01f, 2.17769593e-01f, -1.64789140e-01f, -1.95673779e-01f, 1.54321983e-01f, 1.65424854e-01f, 1.22017913e-01f, 1.93480760e-01f,
  2.19062865e-01f, -2.37852216e-01f, 4.65375811e-01f, 3.63060266e-01f, -3.72790456e-01f, 2.14577824e-01f, 1.77110136e-02f, 2.58476622e-02f, 3.76573980e-01f, 1.70182064e-01f,
  3.11837286e-01f, 4.13274735e-01f, -1.25997169e-02f, 1.72768697e-01f, 2.73708731e-01f, 1.12699261e-02f, -2.80357897e-01f, 4.28600013e-02f, -3.87335680e-02f, 4.12181258e-01f,
  -6.15132339e-02f, 2.53812641e-01f, -6.24364391e-02f, -1.39488295e-01f, 2.13486329e-01f, 3.48512471e-01f, 4.39217061e-01f, -2.64951378e-01f, 1.55851975e-01f, -7.51315579e-02f,
  -6.52945638e-02f, 1.50658175e-01f, 9.25687402e-02f, 9.16668177e-02f, -2.38915086e-02f, 8.29093009e-02f, 1.44763142e-01f, 2.50868887e-01f, 9.68552679e-02f, 2.47642055e-01f,
  2.17210203e-01f, -2.00125352e-02f, 1.55373201e-01f, -3.95970345e-02f, 2.18333662e-01f, 7.30910338e-03f, 2.51142178e-02f, -3.28957945e-01f, 7.90525749e-02f, 1.32982090e-01f,
  -3.29308778e-01f, -1.45330071e-01f, -2.96215445e-01f, -3.84496897e-01f, 2.40919143e-01f, 3.84654790e-01f, -2.15356290e-01f, -1.48442701e-01f, -1.33468702e-01f, 7.44663691e-03f,
  3.64949524e-01f, -1.18432954e-01f, -1.63771838e-01f, -1.45443857e-01f, -1.72925621e-01f, -1.93690225e-01f, 3.81944358e-01f, 1.09469391e-01f, 3.67206156e-01f, -1.50204136e-03f,
  -3.85506868e-01f, -2.77467310e-01f, 2.62455761e-01f, 3.62424254e-01f, -2.44688783e-02f, -3.11934471e-01f, 5.35882004e-02f, 8.16566423e-02f, 3.15214247e-01f, 4.13536251e-01f,
  2.78455503e-02f, 1.47503957e-01f, -2.42699578e-01f, 2.28384957e-02f, -2.31118172e-01f, -2.50835150e-01f, 2.11971775e-01f, 2.52105854e-02f, 9.60532799e-02f, 1.94812957e-02f,
  3.76891382e-02f, -1.65033653e-01f, -2.10540324e-01f, -1.00193277e-01f, -2.63827909e-02f, -4.49948525e-03f, 2.97627807e-01f, -7.55096823e-02f, 1.57889515e-01f, 4.33926672e-01f,
  2.43628416e-02f, -8.30316171e-02f, 8.99903383e-03f, 2.67467737e-01f, 1.11668706e-01f, 3.02587688e-01f, 2.87199557e-01f, 1.23753540e-01f, -9.33138188e-03f, 1.00041097e-02f,
  4.00883794e-01f, -4.38541204e-01f, 2.25325152e-01f, 1.69844866e-01f, -2.45450780e-01f, -4.49584961e-01f, -2.00198013e-02f, -1.62249133e-01f, 1.55917883e-01f, 3.79818469e-01f,
  3.37274045e-01f, 1.13574252e-01f, -4.27703679e-01f, -3.49802703e-01f, 1.32903725e-01f, 4.68759209e-01f, -2.23585784e-01f, 7.00100780e-01f, 2.03444228e-01f, -1.16343834e-01f,
  -1.63869604e-01f, 2.35283449e-01f, 2.06379339e-01f, 1.06556043e-01f, 2.20837176e-01f, -3.19653660e-01f, 1.29098937e-01f, 1.56794995e-01f, -1.24526285e-01f, 1.54984847e-01f,
  2.72904068e-01f, 4.42626506e-01f, 1.41120881e-01f, 4.59170431e-01f, 2.06472903e-01f, -5.79277098e-01f, 1.14048824e-01f, 1.01208892e-02f, 4.94023934e-02f, 8.33114758e-02f,
  2.27791861e-01f, 2.86072224e-01f, 4.52611297e-01f, 3.33964139e-01f, 5.64805642e-02f, -8.02352652e-02f, -2.42634770e-02f, -2.60810435e-01f, 1.33475915e-01f, 1.93045288e-01f,
  -1.59559306e-02f, 4.82490286e-02f, 9.25514176e-02f, 1.49346039e-01f, 1.13359444e-01f, 5.16487658e-02f, 2.71442626e-02f, 4.07768786e-02f, 8.80069137e-02f, 4.26555227e-04f,
  7.98026286e-03f, 1.53548539e-01f, 2.24760637e-01f, 1.03602119e-01f, 1.03918061e-01f, 3.13723803e-01f, 1.26577273e-01f, -2.19862252e-01f, 3.07100505e-01f, -1.47112701e-02f,
  -1.41885594e-01f, 4.17739958e-01f, 3.53591107e-02f, -7.27218762e-02f, -2.06250414e-01f, -2.29118824e-01f, 4.52021241e-01f, 5.77834211e-02f, -1.16585307e-01f, -1.82964265e-01f,
  2.80260473e-01f, -2.22180799e-01f, -1.67849526e-01f, 4.17873770e-01f, -2.05553826e-02f, -2.24662080e-01f, 1.33248091e-01f, 2.80915737e-01f, 2.65026629e-01f, 4.19092298e-01f,
  -2.72091907e-02f, 4.03983295e-01f, 1.91612348e-01f, 1.48450211e-01f, 3.24134380e-01f, 1.52264148e-01f, -1.05233043e-01f, -3.07671487e-01f, 1.38977438e-01f, 4.49953914e-01f,
  2.76325375e-01f, 6.22766986e-02f, 5.18240631e-01f, 4.23035711e-01f, -2.36687541e-01f, 3.62102300e-01f, -4.74163473e-01f, -1.71013549e-01f, -2.51184702e-01f, 2.64087737e-01f,
  3.99897456e-01f, 4.65197444e-01f, 3.41451854e-01f, 2.32431576e-01f, 2.16343388e-01f, 9.81676206e-02f, 1.08426012e-01f, 1.24387302e-01f, 1.60053432e-01f, 1.46176159e-01f,
  4.56847638e-01f, 2.80349940e-01f, 2.12936506e-01f, -2.79892702e-02f, 1.00188896e-01f, 2.43351310e-01f, -3.71605158e-02f, 3.98647934e-01f, 2.31155768e-01f, 2.02532839e-02f,
  -2.18652546e-01f, -6.23888932e-02f, 1.26482975e-02f, -4.78990197e-01f, 3.55648279e-01f, -2.87239581e-01f, -4.78078663e-01f, -3.05162728e-01f, 1.21067606e-01f, 2.49592140e-01f,
  -1.92981288e-01f, -2.27410227e-01f, -9.91367027e-02f, 2.40105465e-01f, -3.88273597e-01f, -6.82259724e-02f, 5.45807660e-01f, -4.07054454e-01f, 1.48180813e-01f, 4.41730440e-01f,
  1.74359232e-01f, 9.97655690e-02f, 3.53061408e-01f, 4.57227141e-01f, 5.33297896e-01f, -1.84704840e-01f, 5.32597303e-01f, 2.80449957e-01f, -4.14109558e-01f, -2.24184260e-01f,
  -1.49245232e-01f, -3.87956798e-02f, 2.05590148e-02f, 1.93159088e-01f, -5.50009310e-02f, 2.57012337e-01f, -1.90347448e-01f, -1.86577722e-01f, 2.52576649e-01f, 3.20628554e-01f,
  2.84146994e-01f, -3.56838197e-01f, -9.45264399e-02f, 2.50718087e-01f, -6.61020353e-02f, 1.95655331e-01f, 1.43592238e-01f, -4.87789959e-02f, 1.04006277e-02f, -3.01824100e-02f,
  -2.93577723e-02f, 5.41299395e-02f, 2.26905823e-01f, 1.87866420e-01f, 1.58934236e-01f, 2.86368988e-02f, 3.04496258e-01f, 7.37863779e-02f, 1.31667815e-02f, 9.59873796e-02f,
  -1.39123276e-01f, 1.69498876e-01f, -1.37961298e-01f, -3.83712798e-02f, -3.58040154e-01f, -2.49198340e-02f, 3.14299077e-01f, 3.19366962e-01f, 1.53587461e-01f, -2.86237895e-01f,
  2.51038998e-01f, -3.57563108e-01f, 2.14019239e-01f, 2.71994025e-01f, -3.39504272e-01f, -3.29182297e-01f, -1.65599853e-01f, 3.98375452e-01f, -7.80810639e-02f, 9.11843553e-02f,
  3.07712793e-01f, -3.02972943e-01f, 3.78555328e-01f, 4.02571559e-01f, 1.71004727e-01f, 4.93049055e-01f, 7.13845566e-02f, 5.71093187e-02f, 4.86657806e-02f, 7.71199614e-02f,
  3.11978340e-01f, 3.30831766e-01f, -3.71477678e-02f, 4.31544989e-01f, 6.76108077e-02f, -1.51765391e-01f, -2.10679352e-01f, 3.87171388e-01f, -1.56658739e-01f, 3.47787887e-01f,
  2.10752666e-01f, 2.00812384e-01f, -1.67686194e-01f, -1.81928188e-01f, 2.78105974e-01f, 3.19725573e-01f, 5.07795811e-01f, 2.41438910e-01f, 7.14283958e-02f, 1.17231183e-01f,
  1.68657489e-02f, -8.02851841e-03f, 1.12148181e-01f, 2.73420811e-01f, 5.84734045e-02f, 2.10545883e-01f, 1.16967961e-01f, 8.38818867e-03f, 9.93717909e-02f, 1.86414093e-01f,
  -5.28202159e-04f, 5.11141159e-02f, 1.04918770e-01f, -3.53357918e-03f, 1.77421257e-01f, 1.13844261e-01f, 2.28982463e-01f, -2.63787955e-01f, -6.01490475e-02f, -1.13671221e-01f,
  -2.33111873e-01f, -2.60797232e-01f, -1.96640734e-02f, 6.63579032e-02f, -6.73360899e-02f, 2.88494855e-01f, 2.47172937e-01f, 1.59836002e-02f, -3.94942701e-01f, 5.47126457e-02f,
  -3.59210402e-01f, 2.30250973e-02f, -3.98116082e-01f, 2.67502189e-01f, 1.15731992e-01f, -6.87166303e-02f, 6.20905869e-02f, -4.17115958e-03f, 2.80154198e-01f, 2.79826224e-01f,
  1.91272989e-01f, -1.67055801e-01f, 4.12522763e-01f, -1.88469142e-02f, 5.29267546e-03f, -3.17819804e-01f, -2.01740950e-01f, 4.15290803e-01f, -6.11273386e-02f, 3.24854881e-01f,
  1.48867667e-01f, -7.29007795e-02f, -1.13446996e-01f, -2.78508991e-01f, -2.08876237e-01f, -1.64955333e-01f, 5.12186766e-01f, 1.70243189e-01f, 2.99414217e-01f, 8.48716572e-02f,
  -5.31684549e-04f, -3.53515632e-02f, 4.32011306e-01f, 9.03248116e-02f, 1.73094556e-01f, 9.77959707e-02f, -2.53116548e-01f, 1.97987422e-01f, 1.28459558e-01f, 7.75387362e-02f,
  4.40223634e-01f, 2.33624697e-01f, 1.52441725e-01f, 9.42677539e-03f, -9.70000476e-02f, -2.20099732e-01f, -4.33629528e-02f, -3.60434391e-02f, 1.46242842e-01f, 2.69400805e-01f,
  2.03877494e-01f, -1.70645058e-01f, -3.03593218e-01f, -2.48055264e-01f, -2.41852611e-01f, -1.78127378e-01f, -1.62110567e-01f, -1.77779362e-01f, 3.43674928e-01f, -3.68382186e-01f,
  3.18085581e-01f, 3.56197178e-01f, -8.96876901e-02f, 4.38270181e-01f, -1.32772148e-01f, 1.02102727e-01f, -4.31677729e-01f, -3.47608685e-01f, -2.00286299e-01f, -2.71278560e-01f,
  5.29977918e-01f, -3.19921039e-02f, -3.85367930e-01f, 5.11685193e-01f, -3.56871821e-02f, 2.32912213e-01f, 3.18821281e-01f, -2.88907462e-03f, 3.26066613e-01f, -4.71224159e-01f,
  -2.93547302e-01f, 1.48337483e-01f, 4.24990728e-02f, -7.42904544e-02f, 3.75276618e-02f, 3.96037996e-01f, -4.28802632e-02f, -8.67996514e-02f, -2.38684520e-01f, -7.63609484e-02f,
  1.18790045e-01f, 3.81305873e-01f, -2.65710384e-01f, -2.90620178e-01f, 5.88666797e-02f, -2.82140613e-01f, 1.20736018e-01f, 1.40475243e-01f, 2.23162755e-01f, 1.82647407e-01f,
  -7.18437284e-02f, 2.20525041e-02f, 4.21424434e-02f, 1.33428663e-01f, 5.73895685e-02f, 2.02412486e-01f, 3.62460464e-01f, 1.10492140e-01f, 2.37714991e-01f, -1.20087177e-01f,
  1.96705908e-01f, 5.60309403e-02f, 1.19494647e-01f, 2.27938026e-01f, 8.10102373e-02f, -1.96272507e-01f, -3.48202847e-02f, -2.00218961e-01f, -2.46629462e-01f, -3.68529141e-01f,
  -6.83475137e-02f, 2.13100649e-02f, -7.96134472e-02f, 3.97324979e-01f, 1.27362251e-01f, -6.28874525e-02f, -2.32304156e-01f, -2.15957537e-01f, -1.34973943e-01f, -1.53498843e-01f,
  -4.76642430e-01f, 1.03839159e-01f, 1.05159923e-01f, 2.05785230e-01f, 1.21200293e-01f, -2.09007785e-01f, 4.62652296e-01f, 4.71353680e-01f, 6.88679591e-02f, 7.90998489e-02f,
  3.16446424e-01f, 2.78039813e-01f, 2.14703768e-01f, -3.60775501e-01f, -1.45563915e-01f, 3.45890582e-01f, -3.91227812e-01f, 3.15601200e-01f, 3.19650948e-01f, 6.50638044e-02f,
  5.46677336e-02f, -2.42972270e-01f, -5.57495467e-02f, -2.35845283e-01f, 4.93623376e-01f, 3.13344389e-01f, -2.20105369e-02f, 1.10943075e-02f, -3.21537480e-02f, -4.22419123e-02f,
  3.91909778e-01f, 3.89585286e-01f, 5.88204041e-02f, 2.44654700e-01f, 3.13601717e-02f, 3.57462496e-01f, 3.71417701e-01f, 1.28950804e-01f, 1.82327479e-01f, 1.13975540e-01f,
  2.03077406e-01f, 1.97892532e-01f, 1.23749599e-01f, -3.74268889e-02f, 5.93804978e-02f, 7.13083297e-02f, 1.75622687e-01f, 7.03342408e-02f, 1.76477805e-01f, 2.62802184e-01f,
  -3.62633258e-01f, 2.18124181e-01f, -4.10350949e-01f, -7.61252716e-02f, 3.90306935e-02f, 2.18929783e-01f, -4.09961641e-01f, -4.96383235e-02f, -3.53574902e-01f, 6.53556436e-02f,
  -2.94261426e-01f, 9.97798666e-02f, -4.48422730e-01f, -2.95296818e-01f, -2.89628267e-01f, -3.38515908e-01f, 1.59474835e-01f, 1.66285783e-01f, 5.86719811e-02f, -1.02828927e-01f,
  3.96375030e-01f, 4.00451422e-01f, 1.61325127e-01f, 2.84259796e-01f, 4.89228785e-01f, -3.18448395e-01f, 3.70845109e-01f, -4.33895081e-01f, 1.55379653e-01f, -2.54930526e-01f,
  4.88782197e-01f, 3.92503858e-01f, 3.56417358e-01f, 6.30639374e-01f, 3.03738043e-02f, -1.06149547e-01f, 1.14434503e-01f, 8.69037360e-02f, 4.60405052e-01f, 3.07549179e-01f,
  5.98453246e-02f, 7.81615674e-02f, -5.01015000e-02f, 5.43818772e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.16147751e-01f, 7.00799301e-02f, 1.98617727e-01f, 7.67334998e-02f, 2.68434346e-01f, 1.76417947e-01f, 1.17771693e-01f, 1.71389967e-01f, 7.30663165e-02f, 1.85976416e-01f,
  6.62356839e-02f, 1.89509660e-01f, 1.74980849e-01f, -1.05622388e-01f, 2.68688440e-01f, 4.55948599e-02f, 1.43617630e-01f, 6.87409043e-02f, 3.16317737e-01f, 2.14933813e-01f,
  1.43159762e-01f, 7.54663274e-02f, 6.17326200e-02f, 4.99887764e-02f, 4.98407297e-02f, 1.56604454e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.18216127e-01f, 1.42894343e-01f, -9.18097515e-03f, -3.04901563e-02f, 7.00380206e-02f, -1.00647017e-01f, -1.56616885e-02f, -3.32436636e-02f, -1.00006603e-01f, 5.16450256e-02f,
  -1.31585047e-01f, -1.61020141e-02f, 2.09501103e-01f, 1.46963805e-01f, 1.81543022e-01f, -5.53408787e-02f, 4.78307344e-02f, 8.98097306e-02f, -2.04155907e-01f, -6.66408613e-02f,
  -3.08347475e-02f, 2.92688489e-01f, 2.34406471e-01f, 4.51089829e-01f, -4.56732303e-01f, 3.79213989e-01f, -2.79204935e-01f, -1.73982903e-01f, -1.35385066e-01f, -4.01575178e-01f,
  1.01127900e-01f, -1.66251212e-02f, 7.40485340e-02f, -2.10398033e-01f, -3.21115881e-01f, -2.13340104e-01f, 2.82898784e-01f, -2.29903281e-01f, 4.82659310e-01f, 1.71942487e-01f,
  1.83434978e-01f, 2.31855124e-01f, 6.01195283e-02f, 1.90014526e-01f, -4.67281967e-01f, -4.93895888e-01f, 3.30508947e-02f, -4.45050955e-01f, 7.83925653e-02f, -4.12423849e-01f,
  3.76399845e-01f, 1.19768260e-02f, -3.61617386e-01f, -3.81580919e-01f, -3.40547681e-01f, 3.47859055e-01f, -8.05880651e-02f, 1.06887802e-01f, -3.88240397e-01f, -3.69143158e-01f,
  -1.71082497e-01f, -4.75708358e-02f, 1.37934312e-01f, -5.24139762e-01f, -5.01792990e-02f, 6.18349761e-02f, 9.18728784e-02f, -7.61328079e-03f, 8.74298960e-02f, -1.29332200e-01f,
  -4.38749120e-02f, -5.09025641e-02f, -1.62624598e-01f, 9.49942917e-02f, 1.73252821e-01f, 6.39131740e-02f, 3.79461236e-02f, 1.58346832e-01f, 4.94303413e-06f, -1.78030968e-01f,
  1.30073339e-01f, 1.86688796e-01f, -2.76169568e-01f, -2.98510075e-01f, -4.58054006e-01f, 2.76018947e-01f, 2.01144934e-01f, 2.74438620e-01f, 4.50998664e-01f, -4.63708192e-01f,
  -3.16593379e-01f, 2.95909159e-02f, -2.31162801e-01f, 4.09028023e-01f, 2.73166150e-01f, 2.10506782e-01f, 3.19469839e-01f, -1.38647944e-01f, -2.48462453e-01f, -7.12354630e-02f,
  2.44294945e-02f, -2.98861384e-01f, -1.44717749e-02f, 3.24895203e-01f, 1.35755166e-01f, 4.08340134e-02f, 2.67579317e-01f, -4.50427420e-02f, -4.36951607e-01f, 1.53365359e-01f,
  2.58348644e-01f, 8.75721872e-02f, 4.07827646e-01f, -2.34479718e-02f, -5.14317274e-01f, 3.48515809e-02f, 2.72994608e-01f, -5.32425404e-01f, -4.63285267e-01f, -3.53603423e-01f,
  -8.37867916e-01f, 2.50766128e-01f, -4.99256730e-01f, -4.35145736e-01f, -4.73968357e-01f, -2.20707566e-01f, -3.69490713e-01f, 9.97625664e-02f, 1.69347599e-01f, -8.56685191e-02f,
  -9.68441553e-03f, -9.05148610e-02f, -4.23933193e-02f, -2.41156332e-02f, -5.73536418e-02f, -1.83906779e-01f, -1.03751764e-01f, -1.47382379e-01f, -7.92624354e-02f, 8.61595124e-02f,
  2.65607685e-02f, -1.05343960e-01f, -1.11135952e-01f, 8.87044519e-02f, -2.21944496e-01f, -2.19972908e-01f, -3.37471291e-02f, 2.56960064e-01f, -1.80078328e-01f, -3.86891961e-01f,
  2.16165900e-01f, -1.89869791e-01f, 9.98340622e-02f, -2.82061607e-01f, -1.84482381e-01f, -2.14888662e-01f, 3.82294655e-01f, 8.14897791e-02f, -3.63675058e-01f, 1.15751252e-02f,
  -4.16674256e-01f, -2.11894616e-01f, -3.38984817e-01f, -2.32516915e-01f, -2.34345898e-01f, 2.96443135e-01f, -2.13978574e-01f, 3.52704674e-02f, -3.96673560e-01f, -5.45846224e-01f,
  -4.95534629e-01f, 3.14831316e-01f, 1.54151082e-01f, -5.63335598e-01f, 2.37002671e-01f, -3.33240867e-01f, 2.08364084e-01f, -2.81311750e-01f, -3.26506019e-01f, -5.50487675e-02f,
  1.86764389e-01f, -4.42200750e-01f, -5.04835069e-01f, -8.51273164e-02f, -6.71510756e-01f, 2.01782703e-01f, 2.44206548e-01f, 3.00500214e-01f, -2.69429773e-01f, -3.70523781e-01f,
  9.89300534e-02f, 1.61115751e-01f, 8.23500231e-02f, 4.68959399e-02f, 3.22336815e-02f, -7.64341652e-02f, -2.15305269e-01f, 1.10903129e-01f, 1.25688575e-02f, -3.30991358e-01f,
  1.19111545e-01f, -8.19293410e-02f, 1.50124505e-01f, -2.40364671e-01f, -1.67105108e-01f, 1.01778671e-01f, -3.86364251e-01f, -2.40763620e-01f, -3.37802231e-01f, -1.21664867e-01f,
  -1.63812265e-01f, 8.12707189e-03f, 1.44209996e-01f, 3.10282290e-01f, -2.30454594e-01f, 3.47072661e-01f, 3.08377519e-02f, -4.21286494e-01f, 2.02970147e-01f, 2.88355052e-01f,
  1.46849856e-01f, -2.58051287e-02f, 3.28518420e-01f, -2.21726686e-01f, -2.37366155e-01f, 1.77952096e-01f, -1.55323505e-01f, 1.65909767e-01f, 5.11811912e-01f, -2.03895494e-01f,
  1.72283292e-01f, -1.71278909e-01f, -4.51166242e-01f, 1.55214816e-01f, -2.31890664e-01f, -1.60402972e-02f, 1.48121074e-01f, 1.91094249e-01f, 9.63022113e-02f, 2.80797124e-01f,
  -7.19215116e-03f, -3.06642354e-01f, 2.96871275e-01f, 1.94932166e-02f, -5.60414016e-01f, 2.84801871e-01f, 1.48584887e-01f, -8.29334706e-02f, -1.11776568e-01f, -3.28633130e-01f,
  -4.18725550e-01f, 2.26031214e-01f, 2.11280727e-04f, -2.86144942e-01f, -1.41256839e-01f, -7.77145803e-01f, -1.35562658e-01f, -1.45690702e-02f, 6.89281300e-02f, -2.41078599e-03f,
  1.67863384e-01f, -1.63828522e-01f, 1.52619243e-01f, 1.28020748e-01f, 7.68374503e-02f, -3.00623197e-02f, -4.68517020e-02f, 1.73746899e-01f, 1.47357568e-01f, 1.19664170e-01f,
  2.21178518e-03f, 5.48418574e-02f, 1.88136641e-02f, -3.17528695e-02f, 2.93767512e-01f, 2.44305566e-01f, 1.11832961e-01f, -3.03781092e-01f, 5.54423546e-03f, -1.41597465e-01f,
  1.95113830e-02f, 7.95678720e-02f, 3.21566850e-01f, -2.41845757e-01f, 3.71229500e-01f, -3.13924670e-01f, -2.62893498e-01f, -4.70920712e-01f, 3.76642793e-01f, 2.87309378e-01f,
  4.28510249e-01f, -7.77763501e-02f, -1.80224374e-01f, 2.15391278e-01f, 2.36950889e-01f, -1.48190975e-01f, 1.95600390e-01f, 2.33533561e-01f, -3.37086111e-01f, -1.29735038e-01f,
  5.18373959e-02f, -8.05854723e-02f, -1.26684263e-01f, -1.35061473e-01f, -4.81649756e-01f, -5.17852724e-01f, -1.75877169e-01f, -7.13207349e-02f, -1.91925362e-01f, 3.11524928e-01f,
  -1.85945958e-01f, 3.00057977e-02f, 3.15843493e-01f, -4.10884738e-01f, 5.76865263e-02f, 4.76255417e-02f, 3.16704780e-01f, 2.89662093e-01f, 2.01588929e-01f, -2.25662217e-01f,
  2.23750859e-01f, -5.44528179e-02f, 4.18407284e-02f, 2.94707268e-01f, -8.22280496e-02f, 2.73390859e-01f, 2.14199368e-02f, 2.15553477e-01f, 2.65561161e-03f, 1.28544077e-01f,
  1.47586569e-01f, -1.39207095e-01f, 2.76174136e-02f, -5.63933477e-02f, 8.17892402e-02f, 1.92635000e-01f, -5.92214800e-02f, -1.11046754e-01f, 2.69270569e-01f, 6.06671236e-02f,
  4.01610374e-01f, 4.18922693e-01f, -3.11823994e-01f, -3.40625405e-01f, 5.27463108e-02f, 2.50436813e-01f, 5.33871055e-01f, -2.18753844e-01f, -2.42752180e-01f, 3.68946344e-02f,
  1.31406561e-01f, 2.47671202e-01f, 3.00361395e-01f, -3.27749819e-01f, -1.62133455e-01f, 5.06663978e-01f, 2.38908038e-01f, -3.67246494e-02f, 7.49352276e-02f, -3.66528004e-01f,
  1.40942723e-01f, -3.45185548e-01f, 2.93034941e-01f, -4.72119927e-01f, -1.51308291e-02f, 3.47708613e-02f, 2.61424303e-01f, 3.18785459e-01f, -2.52408564e-01f, 2.88878530e-01f,
  2.78151363e-01f, -7.28654787e-02f, -9.64520723e-02f, 2.69663244e-01f, -4.28610504e-01f, -2.86520809e-01f, -6.28555343e-02f, 1.92489594e-01f, -1.42900134e-02f, -4.30419236e-01f,
  -1.44989625e-01f, -3.02701563e-01f, 8.58545750e-02f, -1.91565186e-01f, 1.31691247e-01f, -2.04615697e-01f, 2.63966788e-02f, -1.35466188e-01f, 1.77335292e-02f, -5.41872270e-02f,
  -7.55793005e-02f, 1.79927856e-01f, 1.93790644e-01f, -1.02676637e-01f, 6.94291387e-03f, 6.26113936e-02f, -1.00339040e-01f, 1.69509858e-01f, -1.23613052e-01f, -9.14682448e-02f,
  -3.67547311e-02f, 1.57832950e-01f, -2.50166863e-01f, -2.83056833e-02f, 2.25100711e-01f, -3.86390626e-01f, 1.38778776e-01f, 8.81384651e-04f, -3.09704483e-01f, 3.44167173e-01f,
  -1.67159453e-01f, -1.10562526e-01f, 2.26187751e-01f, 1.40878871e-01f, 2.29921922e-01f, -3.93794663e-02f, 2.94738740e-01f, -2.36846328e-01f, -3.26465547e-01f, -4.30072963e-01f,
  1.32496625e-01f, 1.36978790e-01f, -5.83907306e-01f, -5.68424344e-01f, 1.27197787e-01f, -3.46470296e-01f, -2.81583875e-01f, -2.63295829e-01f, 1.96395755e-01f, -7.16826499e-01f,
  -1.80459023e-01f, 1.81705847e-01f, -1.79804787e-01f, 1.77683800e-01f, -5.93415424e-02f, 1.09736063e-01f, 8.80855247e-02f, 2.80897040e-02f, -4.09835717e-03f, -3.17563832e-01f,
  -7.21428454e-01f, 1.53095782e-01f, 2.77584136e-01f, -1.39330300e-02f, 3.64290550e-02f, 4.34879959e-01f, 1.79826796e-01f, 1.45378008e-01f, 1.15313299e-01f, -4.09955112e-03f,
  -6.88669607e-02f, -2.65667766e-01f, -5.07188737e-02f, 1.10164873e-01f, 7.92717263e-02f, -3.87503468e-02f, -1.62015393e-01f, -4.07497361e-02f, 4.45348211e-03f, 4.17972691e-02f,
  3.45993638e-02f, 5.94326369e-02f, -2.06058323e-01f, -1.04349747e-01f, 2.92718504e-02f, 6.92265332e-02f, 9.97595415e-02f, -1.06049694e-01f, 8.37725997e-02f, -2.72845984e-01f,
  -1.53806239e-01f, -1.64257288e-01f, -2.49957591e-01f, -2.61944622e-01f, 1.75571501e-01f, 3.43058527e-01f, -2.12681308e-01f, -2.13865414e-01f, 5.37715387e-03f, 5.40759452e-02f,
  -1.98358700e-01f, 2.21334279e-01f, 2.66872525e-01f, 2.48052984e-01f, 7.29074404e-02f, -1.03031121e-01f, -7.14683771e-01f, -4.07437742e-01f, -6.78461269e-02f, 2.58817613e-01f,
  2.71914810e-01f, -3.40673804e-01f, -1.23464815e-01f, 4.32356685e-01f, -1.69022173e-01f, 2.06580907e-01f, -3.31537366e-01f, 2.21968561e-01f, -2.18109414e-02f, -5.02726473e-02f,
  -3.78897607e-01f, -2.19549999e-01f, 7.40498453e-02f, 1.22313812e-01f, 4.25859004e-01f, -2.22666979e-01f, -4.05069441e-01f, -7.95876458e-02f, -1.12231039e-01f, -3.89452666e-01f,
  -2.16812372e-01f, 1.22246422e-01f, 9.13278759e-02f, -1.25780553e-01f, -1.95629939e-01f, -3.13589685e-02f, -1.08113717e-02f, -1.00279786e-01f, -6.77409247e-02f, 1.91177074e-02f,
  6.29683509e-02f, 8.55396166e-02f, -1.05459630e-01f, -1.34475425e-01f, -2.23199219e-01f, 1.38791159e-01f, 7.91291595e-02f, 1.07568018e-01f, 1.49802109e-02f, -9.43047926e-02f,
  7.61425570e-02f, -1.41076446e-01f, -1.51682928e-01f, 2.24889025e-01f, 2.68368423e-01f, 3.13931525e-01f, 2.91078269e-01f, -2.97227085e-01f, -2.73893416e-01f, 2.64495760e-01f,
  -2.51200557e-01f, 2.06362784e-01f, 1.80824548e-01f, 1.85128972e-01f, -2.68000185e-01f, 1.58465832e-01f, 2.59873033e-01f, 1.32708792e-02f, 6.56778961e-02f, 1.39885247e-01f,
  -2.45654628e-01f, 3.34914804e-01f, -2.30314434e-01f, -3.30804616e-01f, -1.19220845e-01f, 2.14658991e-01f, 3.75476837e-01f, -6.93793222e-02f, -2.93193042e-01f, -3.37352842e-01f,
  -3.97146732e-01f, 3.51810813e-01f, -9.40793380e-02f, -9.48879421e-02f, -1.19084850e-01f, -3.94138366e-01f, 2.24938616e-01f, -3.04261416e-01f, -1.82614010e-02f, 3.49099815e-01f,
  -5.56512773e-01f, 3.49127501e-01f, -2.14536175e-01f, -3.29786330e-01f, -2.47846231e-01f, -2.65677452e-01f, -2.38405123e-01f, 4.51997519e-02f, 7.29923025e-02f, 6.90212250e-02f,
  -3.24085295e-01f, -9.43253748e-04f, 1.93991423e-01f, -1.46062896e-01f, -1.47851720e-01f, 1.90184310e-01f, 1.26132086e-01f, -3.37413838e-03f, -2.14669302e-01f, 4.72376347e-02f,
  -3.56031694e-02f, 1.65591091e-01f, 9.68568586e-03f, 3.52861695e-02f, 9.90090445e-02f, 8.86420608e-02f, -1.90476850e-02f, -2.02093735e-01f, 2.62624204e-01f, -1.68623820e-01f,
  1.47098660e-01f, -3.08085456e-02f, -4.05219346e-01f, -1.67425022e-01f, 2.46566966e-01f, -2.39187405e-01f, -4.14436072e-01f, 2.96179831e-01f, -8.68455917e-02f, 3.89636248e-01f,
  1.51813626e-01f, -1.86573744e-01f, -3.00737798e-01f, 2.40074128e-01f, -5.93303978e-01f, -3.44641417e-01f, 3.33407432e-01f, -5.06779552e-01f, 5.29008955e-02f, -4.49965209e-01f,
  -5.20410419e-01f, 2.54695922e-01f, -2.18102634e-01f, -3.61506224e-01f, -2.63195366e-01f, -7.18941763e-02f, -1.69116169e-01f, -2.50151437e-02f, -8.23846012e-02f, -5.72378337e-01f,
  -3.21484059e-01f, 3.43246549e-01f, 5.13040163e-02f, -3.82129937e-01f, 1.06034555e-01f, -4.30165976e-01f, 3.62701684e-01f, -5.31206504e-02f, 3.16002607e-01f, 3.88980150e-01f,
  -9.51454490e-02f, -2.00883329e-01f, -2.30809432e-02f, -2.21776307e-01f, 9.03006047e-02f, 7.06154704e-02f, -1.03839161e-03f, 1.47550002e-01f, 1.53367102e-01f, 1.25225917e-01f,
  -2.04133675e-01f, 1.26214564e-01f, 8.87066200e-02f, -1.79227859e-01f, 1.55269191e-01f, 3.95688377e-02f, 1.51879147e-01f, -2.25685653e-03f, -2.70391833e-02f, -2.93875217e-01f,
  -3.15708637e-01f, -5.01062691e-01f, -3.61889482e-01f, 3.03964138e-01f, 3.21323663e-01f, -2.00816512e-01f, -5.89419231e-02f, -1.04817145e-01f, -2.73747504e-01f, 2.69746721e-01f,
  -4.75687087e-01f, -2.87489206e-01f, -2.04759926e-01f, 2.47974470e-02f, 2.61145741e-01f, 4.08255383e-02f, -2.76453495e-01f, -2.50544697e-01f, -5.88165596e-02f, 1.49329424e-01f,
  -3.24526012e-01f, 1.31535709e-01f, -1.35944426e-01f, 1.86818868e-01f, 5.70481308e-02f, -1.65807515e-01f, -1.34826064e-01f, -1.05321974e-01f, 3.95277172e-01f, -3.52403462e-01f,
  -1.66939609e-02f, 1.71341095e-02f, -1.15911677e-01f, -4.33435030e-02f, 2.18877062e-01f, 2.85637379e-01f, -7.27503836e-01f, -3.63608062e-01f, 6.70505166e-02f, 1.89358577e-01f,
  -3.74064296e-01f, 4.27060038e-01f, -3.35617185e-01f, -1.28549114e-01f, -2.30839595e-01f, 7.00116232e-02f, 1.28572389e-01f, 1.51109979e-01f, 1.43451586e-01f, -3.01855393e-02f,
  -5.74892499e-02f, -5.64912036e-02f, -2.03289483e-02f, -9.24533512e-03f, 7.64519721e-02f, 8.95365849e-02f, 2.10248888e-01f, -9.27515849e-02f, -9.78650060e-03f, -1.10666908e-01f,
  -8.50653201e-02f, -9.67278332e-02f, -1.16298916e-02f, 3.37155432e-01f, 1.33987904e-01f, 2.84854352e-01f, 1.84538648e-01f, -8.50049108e-02f, -3.80379289e-01f, 3.18741351e-01f,
  1.90069720e-01f, 2.22929791e-01f, 3.17893475e-01f, 2.28944883e-01f, 1.81825086e-01f, -2.25384623e-01f, -2.43745446e-01f, -2.42135674e-01f, 2.64508039e-01f, 2.11882621e-01f,
  -2.74129629e-01f, 1.48991898e-01f, -4.44023758e-01f, 1.65149570e-01f, -3.07047844e-01f, -1.12596698e-01f, -3.89933556e-01f, -7.61848986e-02f, 7.85375237e-02f, -2.21144214e-01f,
  -2.69100070e-01f, 1.46181583e-01f, -2.10272118e-01f, 2.17187718e-01f, 8.74742419e-02f, -1.12797968e-01f, 2.42695644e-01f, 9.94898826e-02f, 3.08726728e-01f, -2.70159423e-01f,
  5.20566255e-02f, -4.68964547e-01f, 4.96839315e-01f, 2.15595216e-01f, -1.82989731e-01f, -5.41935384e-01f, -3.69059712e-01f, -3.40129524e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.91731001e-02f, 9.34804156e-02f, 1.34832561e-01f, 6.68304339e-02f, -9.35628787e-02f, 1.29916176e-01f, -1.06945157e-01f, -1.08001895e-01f, 1.00451320e-01f, -3.49770300e-02f,
  -2.55758967e-03f, 9.22708027e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    