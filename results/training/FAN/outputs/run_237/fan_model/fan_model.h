/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.49308658e-01f, 2.12524608e-01f, 7.38010108e-02f, -2.21387878e-01f, -1.79169074e-01f, -8.80894363e-02f, 5.05660400e-02f, -8.53670985e-02f, -1.52510196e-01f, 8.46727043e-02f,
  -7.88999256e-03f, -9.07398090e-02f, 2.23512575e-01f, -1.84535429e-01f, -1.73353523e-01f, 5.24962917e-02f, -2.07897961e-01f, -8.45910087e-02f, -6.03194758e-02f, -3.05294283e-02f,
  -1.18518442e-01f, -1.83886826e-01f, -9.22454242e-03f, 1.80901363e-02f, -4.19553667e-02f, 5.16343489e-02f, -4.03627716e-02f, 1.32388726e-01f, -2.21719127e-02f, -3.27517539e-02f,
  -1.03314623e-01f, -7.36111179e-02f, 5.60373552e-02f, 1.24564059e-02f, -7.59611791e-03f, 2.91041508e-02f, 4.99009266e-02f, 2.92926077e-02f, -2.61325464e-02f, -1.32017108e-02f,
  3.50368172e-02f, -7.80624710e-03f, -2.70738732e-02f, -1.81967132e-02f, -2.58980673e-02f, -3.85721065e-02f, -8.21894780e-03f, 3.51640931e-03f, -5.15252817e-03f, -1.20467525e-02f,
  3.42092253e-02f, -3.16335373e-02f, -2.05637980e-02f, 3.02410079e-03f, -1.98138058e-02f, -1.86775085e-02f, 5.13737136e-03f, 2.54757348e-02f, -4.84190062e-02f, -5.07024042e-02f,
  1.48474798e-02f, 1.93592533e-02f, 2.54088044e-02f, -2.74268864e-03f, 1.28338002e-02f, 1.50298001e-02f, -1.26822349e-02f, 1.13130370e-02f, 7.25730415e-03f, -1.72781630e-03f,
  -1.07657574e-02f, -1.58620812e-02f, -4.26863767e-02f, -1.20456079e-02f, -7.80020701e-03f, 7.91938510e-03f, 1.32190092e-02f, 2.68089343e-02f, -7.35737104e-03f, -2.24857014e-02f,
  2.39770003e-02f, -2.43461188e-02f, 1.44479573e-02f, 1.84868500e-02f, -4.33602417e-03f, -2.21094098e-02f, -2.83121038e-02f, 1.78994853e-02f, 3.06383148e-02f, 7.59092718e-03f,
  5.39252497e-02f, 1.88694388e-01f, -1.20924627e-02f, -8.88053980e-03f, -5.42882131e-04f, -3.17355357e-02f, -5.90315685e-02f, -1.02578001e-02f, 3.19013521e-02f, 3.98908444e-02f,
  -4.94379625e-02f, 7.02011818e-03f, -5.56078367e-03f, -1.49622967e-03f, -1.07596684e-02f, 2.10602302e-03f, 9.67471302e-03f, -1.56212291e-02f, 1.36217813e-03f, -1.23721743e-02f,
  -1.49642536e-03f, -2.39286222e-03f, 4.13452927e-03f, -1.53022055e-02f, -1.52541744e-02f, 1.65726542e-02f, -1.35393655e-02f, -2.70649772e-02f, 3.15937400e-02f, 1.03855943e-02f,
  3.23727727e-01f, 3.83008718e-01f, 1.84142247e-01f, 2.41910964e-01f, -6.61674589e-02f, 5.93624227e-02f, 9.32213366e-02f, 2.04450771e-01f, 3.47099006e-02f, 7.62742609e-02f,
  1.12225162e-02f, 1.12110212e-01f, -1.08480277e-02f, 2.11518690e-01f, -1.46559015e-01f, -1.16418160e-01f, 4.42365035e-02f, 1.30846098e-01f, 3.59973758e-02f, 1.19580597e-01f,
  1.39902011e-02f, 3.81036438e-02f, -1.66677926e-02f, 1.14380822e-01f, 1.22646756e-01f, 1.56545103e-01f, -8.19016770e-02f, 2.05378942e-02f, 6.31423667e-02f, 3.81728336e-02f,
  5.06247692e-02f, 3.20549197e-02f, 8.04938152e-02f, 4.15548123e-02f, 4.16595414e-02f, -7.95510337e-02f, 3.27617279e-03f, -7.72500932e-02f, 8.38538981e-04f, -1.65628083e-02f,
  -4.05986458e-02f, 8.01157672e-03f, 3.35793123e-02f, 2.24807039e-02f, 4.89074597e-03f, 3.18324417e-02f, 1.68553777e-02f, 5.88671640e-02f, -1.78009477e-02f, -2.42628600e-03f,
  -2.00893753e-03f, -4.21250425e-03f, -1.58528332e-02f, -1.64726079e-02f, 6.07180782e-03f, 6.71368018e-02f, -4.60712276e-02f, -8.87853559e-03f, 2.92017851e-02f, -1.94335333e-03f,
  -6.04704805e-02f, -5.97747080e-02f, -2.92766816e-03f, -9.10223811e-04f, 3.42230499e-02f, -8.66452605e-03f, 5.09927668e-05f, -1.69133383e-03f, 2.13853549e-02f, -1.54015273e-02f,
  5.20437621e-02f, 1.89258959e-02f, 1.21400729e-02f, 1.31162312e-02f, -2.02383231e-02f, -2.44257227e-03f, -1.64622962e-02f, 5.62038831e-02f, 5.63452765e-03f, 3.75461951e-02f,
  3.07414122e-03f, -7.37205660e-03f, -5.49991196e-03f, -3.96947935e-02f, 5.87647595e-03f, -2.50849910e-02f, 7.64484257e-02f, -1.58315932e-03f, 1.37882298e-02f, -4.70616370e-02f,
  1.68352887e-01f, 2.04010382e-01f, 1.73014347e-02f, 2.21919268e-02f, -1.14824867e-03f, 4.61801738e-02f, -7.40631297e-02f, 5.32672778e-02f, -1.62245706e-02f, -1.44373244e-02f,
  2.29927003e-02f, 1.03426091e-02f, 1.29554896e-02f, -5.39058670e-02f, -9.29722376e-03f, -3.88497747e-02f, -3.86895426e-02f, -2.57157218e-02f, 5.28845862e-02f, 5.10443226e-02f,
  2.48934906e-02f, -4.10773158e-02f, 1.32443849e-02f, 7.57533964e-03f, -4.91506793e-02f, -2.43809689e-02f, 1.82202067e-02f, 2.45206989e-02f, -3.88437286e-02f, -3.20483595e-02f,
  -7.36560583e-01f, 1.32806361e-01f, -2.05662325e-01f, -2.20499799e-01f, -8.06041434e-02f, 8.34019035e-02f, -1.96029499e-01f, 1.03334263e-01f, -3.18024784e-01f, 1.20905742e-01f,
  1.60881072e-01f, -4.13610458e-01f, 3.36611569e-02f, 5.31327948e-02f, -1.81268573e-01f, -1.89171955e-02f, 3.59987170e-02f, -9.68547389e-02f, -4.69657220e-02f, 5.15850000e-02f,
  -1.11651219e-01f, 1.61249921e-01f, -2.10429411e-02f, 3.37431192e-01f, -2.16953028e-02f, -1.96058955e-03f, -3.00419889e-02f, 6.24231528e-03f, 1.59493625e-01f, 3.00457571e-02f,
  1.52806893e-01f, 1.31358251e-01f, -4.43769097e-02f, 4.91106957e-02f, -1.93685852e-02f, -3.76868732e-02f, -3.13914083e-02f, -1.21700764e-02f, -2.06969082e-02f, -2.49342825e-02f,
  -5.29435128e-02f, -2.91631948e-02f, -2.34814826e-03f, 1.35559300e-02f, -5.68645298e-02f, -5.71206585e-02f, 1.99142452e-02f, 5.09980097e-02f, -1.58529878e-02f, 2.26518083e-02f,
  -2.54518748e-03f, -2.37920089e-03f, -7.28173554e-02f, 5.26796319e-02f, -4.47247811e-02f, 4.16339487e-02f, -3.13096084e-02f, -5.44153042e-02f, -3.90149392e-02f, -2.31676083e-02f,
  2.75440197e-02f, 3.21534202e-02f, 1.27646243e-02f, 5.59617877e-02f, -1.62080873e-03f, 5.48643172e-02f, -2.74773892e-02f, 7.32839899e-03f, -2.34826449e-02f, -1.42642837e-02f,
  1.51264081e-02f, -2.44588703e-02f, -2.12996956e-02f, 3.59155349e-02f, 1.00603011e-02f, 4.65020016e-02f, 5.93602052e-03f, 4.51850183e-02f, -6.70401286e-03f, 3.72105837e-02f,
  8.00117292e-03f, -7.84111395e-03f, 1.26048271e-03f, 4.13203500e-02f, 3.08478903e-02f, -3.60036194e-02f, 1.06623005e-02f, -1.03515368e-02f, -1.81570183e-02f, -1.01013090e-02f,
  3.73527929e-02f, 1.01311952e-02f, 2.58897562e-02f, -4.05738465e-02f, 8.60741176e-03f, 4.51052152e-02f, -6.48565739e-02f, -9.38553084e-03f, -5.57435816e-03f, 4.06395830e-02f,
  1.40108331e-03f, -1.66935772e-02f, -6.44151494e-03f, -4.36139712e-03f, 6.92596892e-03f, 6.14004694e-02f, -2.72336751e-02f, -9.03914403e-03f, -9.61433258e-03f, 1.73164066e-02f,
  -1.96840968e-02f, -4.30054851e-02f, 2.97596771e-02f, 2.18856819e-02f, 2.41451506e-02f, -3.12905163e-02f, -1.25950109e-02f, 6.19985163e-03f, 1.99618135e-02f, 1.93947926e-02f,
  2.59049922e-01f, 1.08809099e-01f, -2.01936066e-01f, 2.17029862e-02f, -8.77621397e-02f, 3.30863655e-01f, 6.72788993e-02f, -5.75924218e-02f, -6.03112392e-02f, 1.84460148e-01f,
  9.64742973e-02f, -1.47890262e-02f, -3.70613709e-02f, 1.56206056e-01f, -4.06632237e-02f, 7.87624270e-02f, 1.75916180e-01f, 1.24188691e-01f, -4.87859435e-02f, 1.02900555e-02f,
  -9.07119215e-02f, 1.60728201e-01f, -1.09238654e-01f, 5.14096878e-02f, 3.06826159e-02f, -9.66371894e-02f, -3.12938308e-03f, -1.12706602e-01f, 3.06170601e-02f, -3.48804668e-02f,
  -6.17795773e-02f, -5.22248037e-02f, -3.87333073e-02f, 2.15924531e-02f, 3.19625810e-02f, -8.63543618e-03f, 2.16058418e-02f, 8.35174881e-03f, -8.51838961e-02f, -1.87681075e-02f,
  -2.19150223e-02f, -5.80881573e-02f, -3.49046588e-02f, -3.73415351e-02f, 2.08549723e-02f, 9.86440759e-03f, -3.09499800e-02f, 3.21363844e-02f, -4.18613590e-02f, -8.57475102e-02f,
  -3.87575962e-02f, -2.05996856e-02f, 3.71071547e-02f, 3.98053601e-02f, -9.36683714e-02f, 3.18173482e-03f, 1.57378009e-03f, -2.94650719e-02f, -3.93011840e-03f, 5.40841222e-02f,
  8.86243731e-02f, -4.45005633e-02f, 1.13115730e-02f, -5.15357766e-04f, 4.31319326e-02f, 5.65308742e-02f, -2.87724379e-03f, 2.36376766e-02f, -2.70500220e-02f, 5.23474142e-02f,
  -1.78380520e-03f, 8.73679164e-05f, -4.46162224e-02f, -1.62092298e-02f, 2.10112017e-02f, -9.30914190e-03f, -6.23191334e-03f, 1.64117832e-02f, 4.19534370e-03f, 3.67716420e-03f,
  -4.02799994e-03f, -2.31555142e-02f, 2.87135374e-02f, -2.74896175e-02f, -1.35984076e-02f, -2.65315995e-02f, -2.44905464e-02f, -4.89704311e-02f, -3.14869806e-02f, 1.30080357e-02f,
  2.43198335e-01f, 1.39741629e-01f, 5.88632515e-03f, -5.21187671e-02f, -1.58754606e-02f, 6.57952353e-02f, -1.80351117e-03f, -2.03110538e-02f, 5.00270315e-02f, 2.07791105e-02f,
  1.07110422e-02f, 3.12157739e-02f, 5.97684197e-02f, -7.87844975e-03f, -9.30132624e-03f, -4.50118305e-03f, 2.66065076e-02f, 1.40141544e-03f, 7.11965039e-02f, 1.28852334e-02f,
  1.88151728e-02f, 4.98144664e-02f, 2.20299745e-03f, -2.03975569e-02f, 5.16426973e-02f, 1.79230142e-02f, 3.51584866e-03f, -9.08780785e-04f, -3.60782002e-03f, -7.16694370e-02f,
  2.14802355e-01f, 1.70238331e-01f, 3.10192108e-01f, 2.10882381e-01f, 4.99926992e-02f, 8.78293291e-02f, 2.62733966e-01f, 6.21335134e-02f, 2.36349359e-01f, -7.44610652e-02f,
  -7.24988282e-02f, 6.38021156e-02f, 1.56332463e-01f, -4.55198810e-02f, 1.28872931e-01f, 1.50099516e-01f, -3.33055221e-02f, 1.24378381e-02f, 7.57824779e-02f, 1.67865790e-02f,
  9.15696658e-03f, -1.45932257e-01f, 9.43010598e-02f, -1.05405897e-01f, 4.49168310e-02f, 3.78505923e-02f, -1.51715711e-01f, 3.63494083e-02f, -1.14241503e-01f, -1.83676686e-02f,
  -1.13057435e-01f, -4.23320234e-02f, 8.46185982e-02f, -4.21488890e-03f, 3.38417366e-02f, 1.47800297e-02f, -1.62839796e-02f, -3.88154648e-02f, -2.46594986e-03f, -5.49354218e-03f,
  2.56454926e-02f, 3.30652446e-02f, -2.95055062e-02f, 4.55218814e-02f, -3.20228934e-02f, 1.80117544e-02f, -1.21352775e-02f, 3.31916893e-03f, 2.51175426e-02f, -1.89690746e-03f,
  3.86791043e-02f, 6.50600856e-03f, -1.10286841e-04f, 1.21254930e-02f, 1.69566218e-02f, -3.22295842e-03f, 2.42233407e-02f, 2.91757146e-03f, -2.71667000e-02f, 2.03971919e-02f,
  -3.85035910e-02f, -3.59167717e-03f, 1.86929444e-03f, -2.30442756e-03f, 3.86479013e-02f, -3.21560726e-02f, 3.35237458e-02f, -1.46680260e-02f, 7.55392686e-02f, 7.67590990e-03f,
  3.17044146e-02f, -2.90538976e-03f, 1.81484893e-02f, 1.27955005e-02f, -2.74657756e-02f, 1.22282067e-02f, -1.29469493e-02f, -5.24639478e-03f, 3.58341113e-02f, -1.15480907e-02f,
  5.06378748e-02f, -6.11639069e-03f, 3.52259018e-02f, -3.41170803e-02f, -7.05905305e-03f, 3.14772166e-02f, 8.39675125e-03f, 3.61404307e-02f, 6.41605705e-02f, -1.48896854e-02f,
  2.18596756e-02f, 6.30834699e-02f, 6.07398618e-03f, 1.53343817e-02f, -2.82672029e-02f, -5.77189177e-02f, -2.85935290e-02f, 3.02793514e-02f, 9.34683066e-03f, 3.77621688e-02f,
  -4.88559417e-02f, -8.23995192e-03f, -1.19692879e-02f, -4.71845679e-02f, -3.43228132e-02f, -1.63408145e-02f, -7.14564603e-03f, 1.05934972e-02f, -3.31293494e-02f, -7.38802692e-03f,
  -4.27463697e-03f, -2.98460610e-02f, -1.76292215e-03f, -1.79426651e-02f, -3.42051946e-02f, -1.46039790e-02f, -2.91146450e-02f, 5.18188477e-02f, -1.78877003e-02f, -1.48686925e-02f,
  -1.26911119e-01f, -2.39597872e-01f, -2.78188828e-02f, 1.35509530e-02f, 3.79501969e-01f, -6.08040504e-02f, -1.73111066e-01f, 1.60455763e-01f, 2.79049963e-01f, -1.72423273e-01f,
  8.40220880e-03f, -1.21012114e-01f, -2.11425021e-01f, -1.84826508e-01f, -3.25989276e-02f, -1.74568817e-01f, -4.89182472e-02f, -2.88332365e-02f, 1.74487159e-02f, -9.02714115e-03f,
  2.64577121e-02f, 7.61473202e-04f, -1.85318664e-01f, 1.48611274e-02f, 2.21481435e-02f, 8.93309638e-02f, 9.67094079e-02f, -3.85145880e-02f, 1.25440797e-02f, -9.94311180e-03f,
  -2.48995051e-03f, -5.51587567e-02f, -2.16538273e-02f, -7.88854957e-02f, 1.45618264e-02f, -1.18574873e-03f, -4.11467515e-02f, -1.26348644e-01f, -2.44858153e-02f, 4.84420639e-03f,
  -5.62773421e-02f, 5.90475500e-02f, 8.56056437e-03f, -8.31860863e-03f, 1.76799239e-03f, 4.57683913e-02f, 2.16834489e-02f, -3.57276089e-02f, -1.62168182e-02f, -5.59266657e-02f,
  -2.28724275e-02f, 7.76771605e-02f, 5.63474856e-02f, 8.19730340e-05f, 4.80374806e-02f, -1.90291610e-02f, -4.51554507e-02f, -1.32586062e-03f, 5.02659567e-02f, 8.05534646e-02f,
  -3.94906756e-03f, -4.72660437e-02f, -2.36260258e-02f, -1.79792121e-02f, -7.73339532e-03f, -9.03304387e-03f, 1.88379139e-02f, -7.59552175e-04f, -1.48595832e-02f, 4.45862710e-02f,
  4.70963754e-02f, 1.19977025e-02f, -1.63967069e-02f, -2.74138320e-02f, -2.56613325e-02f, 1.33164227e-02f, -4.91793863e-02f, 3.09751593e-02f, -3.37407701e-02f, -1.85977388e-03f,
  -1.65350677e-03f, -6.26609847e-03f, 1.50676798e-02f, -3.39607298e-02f, 5.66231459e-03f, 2.76653823e-02f, 3.52914333e-02f, 1.96494870e-02f, 3.47165577e-02f, -1.83176957e-02f,
  9.75232869e-02f, 9.85135958e-02f, 1.49599537e-02f, 2.22187769e-02f, -2.32340358e-02f, -2.14436166e-02f, -1.92889702e-02f, 6.20729588e-02f, 2.23075934e-02f, 5.41913137e-03f,
  9.82270297e-03f, -1.37241036e-02f, -1.09814387e-02f, 4.59365640e-03f, -7.59138074e-03f, -1.20411441e-02f, -1.95114352e-02f, 8.43961313e-02f, 3.99701446e-02f, 2.86621694e-02f,
  2.16358937e-02f, -2.54473966e-02f, -6.55661225e-02f, 1.94209274e-02f, -6.36765314e-03f, -1.85128599e-02f, 3.54851559e-02f, 5.13572656e-02f, -3.79459597e-02f, -4.27967943e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.12734595e-01f, 2.46748567e-01f, -1.21981762e-01f, -8.12708773e-03f, 9.55313668e-02f, 1.00289717e-01f, 7.34262243e-02f, 1.28372952e-01f, 2.51438826e-01f, 1.72079593e-01f,
  3.40299197e-02f, 9.56047252e-02f, -1.31955296e-01f, 1.05842054e-01f, 7.13026449e-02f, 4.00413722e-02f, 4.45758924e-02f, 3.38928401e-02f, 1.11172535e-01f, 1.58379395e-02f,
  -5.19125871e-02f, 1.01375012e-02f, -1.54211670e-01f, -1.94089726e-01f, -1.58817485e-01f, -1.32018223e-01f, -6.09140284e-02f, -1.05522908e-01f, 1.72634628e-02f, 1.70704499e-01f,
  -6.24996312e-02f, -6.42699599e-02f, -5.30351475e-02f, 2.94097997e-02f, -4.26659621e-02f, -3.41203362e-02f, -4.96334396e-03f, -8.75056442e-03f, 5.11803776e-02f, 7.10325465e-02f,
  7.53281787e-02f, 2.34873835e-02f, 4.80165668e-02f, -6.91914856e-02f, 4.16802727e-02f, -5.34525216e-02f, -8.61729309e-03f, -3.08221430e-02f, -8.66388436e-03f, 6.64691254e-02f,
  1.84015837e-02f, 1.16146151e-02f, -5.01653962e-02f, -4.47649397e-02f, 3.25749591e-02f, 3.66769657e-02f, 3.80344987e-02f, 6.52066320e-02f, 7.00042099e-02f, 3.37202698e-02f,
  2.74093915e-02f, 1.25597686e-01f, -4.69123162e-02f, -6.63692430e-02f, -5.73167317e-02f, -8.41600671e-02f, 1.04557108e-02f, -4.06034440e-02f, -1.22817280e-02f, -4.34568748e-02f,
  -6.12114817e-02f, 5.12088463e-02f, 8.18157271e-02f, 3.05805653e-02f, 9.09063816e-02f, 2.59623714e-02f, 9.12054777e-02f, -6.95183277e-02f, -9.40761119e-02f, 1.16224331e-03f,
  -2.46164668e-02f, 1.52556058e-02f, -6.88399151e-02f, 1.07612805e-02f, 4.94660661e-02f, -1.42785851e-02f, -1.68370940e-02f, -6.12944458e-03f, -7.92066827e-02f, 4.22638579e-04f,
  2.78420866e-01f, 2.95286655e-01f, 2.44360394e-03f, -5.91967395e-03f, 5.97825088e-02f, -6.08721860e-02f, 8.95712525e-02f, -1.07809687e-02f, -5.19112265e-03f, -2.83456985e-02f,
  -4.67296988e-02f, -5.02501689e-02f, -2.80497354e-02f, 7.00383931e-02f, 3.94505858e-02f, 1.17223859e-01f, 2.33026724e-02f, 2.42614355e-02f, -2.69189849e-03f, 1.98006928e-02f,
  -7.64741078e-02f, 3.79578881e-02f, -4.83058840e-02f, -2.45516896e-02f, -2.19558477e-02f, -8.82165208e-02f, 3.29105854e-02f, -3.74116562e-02f, 1.14377551e-02f, 5.91098145e-02f,
  6.09585270e-02f, 2.51837790e-01f, -1.38146013e-01f, -9.11936015e-02f, -1.59087740e-02f, -3.31182271e-01f, -2.91663140e-01f, 1.77263503e-03f, 1.98622301e-01f, 1.47421286e-01f,
  -2.02529043e-01f, 2.58229911e-01f, -7.88147748e-02f, -9.11057219e-02f, -2.83538908e-01f, -9.11925659e-02f, -3.24158192e-01f, -2.73566712e-02f, -5.01899682e-02f, -2.12317228e-01f,
  -1.51506782e-01f, -2.73767024e-01f, -2.46704921e-01f, -8.44417289e-02f, -1.50733471e-01f, 1.25349658e-02f, -3.83027159e-02f, -1.16086401e-01f, -2.25159489e-02f, 5.88950180e-02f,
  5.69848493e-02f, 1.25212565e-01f, 1.10002324e-01f, -2.20837514e-03f, -1.38902739e-01f, -7.16914684e-02f, -4.32536080e-02f, 1.52472248e-02f, -2.76797097e-02f, 3.55653511e-03f,
  1.76725127e-02f, 1.37586091e-02f, -1.50765307e-04f, -1.08744549e-02f, -1.46232769e-02f, 2.94257253e-02f, -2.27657352e-02f, -1.23806652e-02f, 8.32756143e-03f, 1.06611643e-02f,
  -5.26178740e-02f, 2.31536049e-02f, -6.36462420e-02f, 2.44275411e-03f, 2.01214608e-02f, 1.44507751e-04f, -3.34990397e-02f, 2.46182061e-03f, 1.37613015e-02f, -4.81375270e-02f,
  5.38246259e-02f, -6.68906048e-03f, -3.58921960e-02f, -1.56899896e-02f, -1.97946429e-02f, 1.53133105e-02f, -4.96533327e-02f, 2.25977134e-02f, -3.82331287e-04f, 8.49866774e-03f,
  -3.14953215e-02f, 5.03329597e-02f, 2.39116065e-02f, -8.99042860e-02f, -3.24361213e-02f, 1.80884935e-02f, -7.16608204e-03f, 3.58755887e-02f, -8.54843259e-02f, 2.03365795e-02f,
  -5.15524182e-04f, -1.03646338e-01f, 3.45306359e-02f, -9.17012170e-02f, -9.81024373e-03f, -7.69605907e-03f, 4.25114715e-03f, 2.07965281e-02f, -1.14291711e-02f, -5.46539277e-02f,
  -1.19748905e-01f, -1.85427368e-01f, 2.94323899e-02f, 6.72970042e-02f, 1.09376550e-01f, 2.87761795e-03f, 1.89979337e-02f, 2.49999966e-02f, -4.50407825e-02f, -4.47475649e-02f,
  -6.72981963e-02f, 5.81961125e-03f, -3.81945185e-02f, 4.01991382e-02f, -2.07925737e-02f, 8.86573922e-03f, -4.81937602e-02f, -2.01102868e-02f, -1.57679971e-02f, -3.54775861e-02f,
  -2.63301004e-02f, -1.09389555e-02f, -1.33436117e-02f, -3.92698422e-02f, -3.58986370e-02f, 1.72666088e-02f, 5.37755750e-02f, 1.97015889e-02f, -3.62624228e-02f, -1.23391114e-02f,
  1.20151795e-01f, 3.11524510e-01f, 2.22253114e-01f, 1.17649607e-01f, -2.13837713e-01f, -2.21345767e-01f, -1.51883721e-01f, 5.06249480e-02f, -7.81920776e-02f, 6.89307079e-02f,
  1.03890926e-01f, 1.02340907e-01f, -2.37407498e-02f, 1.96724497e-02f, -1.91003412e-01f, -1.93245839e-02f, -1.13397531e-01f, 1.17829470e-02f, 2.44687423e-02f, 1.67822406e-01f,
  -4.17071879e-02f, 1.26729524e-02f, 5.69424480e-02f, 4.74614836e-02f, 1.22382388e-01f, 2.02236161e-01f, 2.35743970e-02f, 9.74947587e-02f, 5.90276234e-02f, 4.21412475e-02f,
  -1.19245395e-01f, 6.04901649e-02f, -4.73771393e-02f, 1.20020090e-02f, 1.97080877e-02f, -2.79791187e-02f, 1.72210466e-02f, 3.68838459e-02f, 1.73023120e-02f, -2.96598207e-02f,
  -4.95088995e-02f, -4.90748743e-03f, 1.50702268e-01f, -5.85918911e-02f, -2.26586908e-02f, 6.38924763e-02f, -1.22125344e-02f, 3.52455415e-02f, 1.05943203e-01f, 1.95035171e-02f,
  1.52438015e-01f, 6.62308335e-02f, -9.01793018e-02f, 4.04709429e-02f, 1.09262150e-02f, 2.26459429e-02f, -1.10705337e-02f, 2.95592993e-02f, 2.23661009e-02f, -2.48948988e-02f,
  6.05245940e-02f, -2.87941955e-02f, -1.20516345e-02f, 3.71647030e-02f, -1.50726857e-02f, -8.34557042e-02f, -2.06182115e-02f, 7.02927411e-02f, 7.56936381e-03f, -6.44305814e-03f,
  -4.28538285e-02f, 4.10084166e-02f, -8.55812430e-02f, 2.08284222e-02f, -7.75562646e-03f, 3.81205156e-02f, 5.92776425e-02f, -6.26671687e-02f, -6.93336129e-02f, 5.24140298e-02f,
  4.15797113e-03f, -4.95909676e-02f, -8.50143749e-03f, -2.30265055e-02f, 2.20529828e-02f, 7.09906593e-03f, 1.22657744e-02f, 5.53248683e-05f, -2.88686696e-02f, -9.00602341e-03f,
  -1.26745582e-01f, 1.35619998e-01f, -3.40874232e-02f, -6.99356571e-02f, -4.30391617e-02f, 6.80375621e-02f, -1.83052812e-02f, -3.17424648e-02f, 3.11960857e-02f, -3.80989276e-02f,
  -6.34152517e-02f, -4.35149521e-02f, -1.03041530e-01f, -8.40443149e-02f, 2.96752509e-02f, -4.23190221e-02f, 4.14200835e-02f, 5.17233387e-02f, 4.01327051e-02f, 9.55393687e-02f,
  6.57467842e-02f, -3.12308203e-02f, -2.14999728e-02f, -7.37841614e-03f, 6.26528040e-02f, -9.50116813e-02f, 5.69116101e-02f, -3.92088480e-02f, 7.14553241e-03f, -2.75185667e-02f,
  4.05471921e-01f, 2.45998353e-01f, 2.61289626e-02f, 2.18185112e-01f, -7.27286749e-03f, -1.86362922e-01f, -1.30749077e-01f, 1.33354142e-01f, -7.69883916e-02f, -4.39873151e-02f,
  6.01926669e-02f, -9.18085575e-02f, -3.48695591e-02f, 1.61582693e-01f, 2.83300340e-01f, -1.53131813e-01f, 1.88918754e-01f, -7.83371702e-02f, -3.12361941e-02f, 1.38792709e-01f,
  1.29346520e-01f, 2.86892831e-01f, 2.53744811e-01f, 1.87331796e-01f, 8.79564136e-02f, 1.01807877e-01f, 1.89481199e-01f, -1.06098522e-02f, 2.29435697e-01f, -2.09114123e-02f,
  -7.45259225e-02f, 7.50257671e-02f, 5.07679395e-02f, -7.72597268e-02f, 5.85727282e-02f, 4.53097420e-03f, -9.83760357e-02f, 3.08393072e-02f, -2.27256324e-02f, -3.66891809e-02f,
  1.05844773e-02f, 6.93982318e-02f, 1.16831297e-02f, 2.23529860e-02f, 1.47708189e-02f, -1.65915638e-02f, 3.57463546e-02f, -9.75373313e-02f, -3.68709825e-02f, 6.68622777e-02f,
  -3.04399990e-03f, -6.54157326e-02f, -1.80370640e-02f, -4.68292274e-02f, 5.09047136e-02f, 1.20993005e-03f, -5.40714851e-03f, -2.57360041e-02f, -8.04233328e-02f, 2.12847162e-02f,
  5.44196926e-02f, -2.27516070e-02f, 5.04228286e-03f, 1.33890500e-02f, 1.10960290e-01f, 8.60960111e-02f, -5.02239428e-02f, -5.13020419e-02f, -6.11288399e-02f, 7.37280445e-03f,
  2.49957889e-02f, -9.28572472e-03f, -1.35074882e-02f, 8.20009096e-04f, 6.95074573e-02f, -3.59479524e-03f, 6.13264274e-03f, -3.37265842e-02f, -1.16897458e-02f, -1.78216733e-02f,
  -8.61638859e-02f, 7.53826201e-02f, 2.70238658e-03f, 2.98566446e-02f, -7.46454624e-03f, -3.13404538e-02f, -3.78123932e-02f, -1.89032629e-02f, -4.68357317e-02f, 5.86005710e-02f,
  -4.41301763e-02f, 1.70982614e-01f, 5.10675013e-02f, -3.05732023e-02f, 4.65752147e-02f, 6.69023648e-05f, 5.07060438e-02f, 1.91497579e-02f, 5.19871265e-02f, 4.16617505e-02f,
  -7.42128445e-03f, -3.57577316e-02f, 8.53097625e-03f, 2.52747424e-02f, 1.05303060e-02f, 1.15988404e-02f, -5.76128513e-02f, 3.80536094e-02f, 3.76833677e-02f, 1.68624911e-02f,
  4.42405278e-03f, 5.10385307e-03f, 4.80535366e-02f, 2.15211753e-02f, -1.22864405e-02f, 1.21684524e-03f, 7.61120487e-03f, -6.84000254e-02f, 5.10119349e-02f, -1.60004813e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -5.68900891e-02f, 2.62883753e-02f, 1.57279819e-02f, 6.39313981e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -4.81188744e-01f, 1.91094548e-01f, 2.78951049e-01f, -1.23393172e-02f, -1.20839499e-01f, 1.76368833e-01f, -2.64212281e-01f, 3.10254544e-01f, 2.17333540e-01f, -2.26620197e-01f,
  -2.72302777e-01f, 2.95591146e-01f, -3.73706698e-01f, -1.79329365e-01f, 6.01244532e-02f, 2.82520175e-01f, 7.28863239e-01f, -8.53584036e-02f, -1.43729851e-01f, -2.04737246e-01f,
  4.70050693e-01f, 1.93288755e-02f, 2.09052395e-02f, 4.49381143e-01f, -3.33718807e-01f, 3.56532007e-01f, 6.11225307e-01f, -4.49673533e-01f, 6.80261403e-02f, -1.02168679e-01f,
  3.35868865e-01f, 4.45490986e-01f, -2.02142835e-01f, 6.27140343e-01f, 2.91211903e-01f, -5.21554768e-01f, -3.65109593e-01f, -2.18987346e-01f, 1.00981414e-01f, 1.00839324e-01f,
  4.56726670e-01f, 4.00285214e-01f, -4.94346827e-01f, 1.05381846e-01f, 1.87369764e-01f, -2.29884580e-01f, -1.38567388e-01f, -1.21653192e-01f, -2.67701000e-01f, 2.55232304e-01f,
  9.02647153e-02f, 1.02556214e-01f, 2.43791908e-01f, 1.38791472e-01f, -4.14581776e-01f, 2.16442108e-01f, -3.75497997e-01f, -2.27392055e-02f, 3.89093161e-01f, 2.43663698e-01f,
  -6.55783294e-03f, -5.46815172e-02f, 3.91501397e-01f, 3.25251192e-01f, -1.18687712e-01f, 1.15719382e-02f, 2.20228076e-01f, -3.80417138e-01f, -2.16752812e-01f, -1.17226101e-01f,
  -5.50033033e-01f, 1.93244368e-01f, -2.30513364e-01f, 3.97219568e-01f, 3.25851709e-01f, 2.60323077e-01f, 5.08498967e-01f, -3.56413066e-01f, -8.51272866e-02f, 5.42487800e-01f,
  1.34747429e-02f, 1.42764851e-01f, -1.93645224e-01f, 1.29935324e-01f, 1.03511006e-01f, 1.85575768e-01f, -2.77304769e-01f, 1.01307124e-01f, 3.73918526e-02f, -8.74888971e-02f,
  -8.61070007e-02f, 1.47451060e-02f, 1.26071870e-01f, 1.37961835e-01f, -1.32468287e-02f, 2.92391121e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.39687046e-03f, -4.57087934e-01f, -7.55949095e-02f, 3.81032765e-01f, 3.04302573e-01f, 2.45471686e-01f, 2.93403119e-03f, 3.41543823e-01f, -3.17370087e-01f, -7.39876851e-02f,
  -1.96437135e-01f, -3.78720127e-02f, -2.35861227e-01f, 3.17407608e-01f, 1.67168275e-01f, -4.10173945e-02f, 3.97899151e-01f, 3.87031376e-01f, -9.83984992e-02f, 3.34706783e-01f,
  2.34972745e-01f, -1.90019712e-01f, -1.96697358e-02f, -1.72694758e-01f, -2.40026921e-01f, -9.64502916e-02f, 3.96635115e-01f, 1.32396668e-02f, 1.22039348e-01f, -3.47043723e-01f,
  -2.03152075e-01f, -1.41709596e-01f, -9.71112624e-02f, -2.11354807e-01f, -3.51825319e-02f, 3.75841022e-01f, 2.29681060e-01f, 5.13518333e-01f, 1.95209414e-01f, 1.61559597e-01f,
  1.22229652e-02f, -4.62905884e-01f, -2.22632974e-01f, 7.15006143e-02f, -2.69013315e-01f, 3.46650124e-01f, 2.49659717e-01f, 2.63463557e-01f, 2.47970913e-02f, 1.36426553e-01f,
  -1.20316893e-01f, 3.56682204e-02f, 9.33468267e-02f, -2.10913152e-01f, -4.75007948e-03f, -9.72330719e-02f, -6.23892508e-02f, 1.00398578e-01f, -1.34554863e-01f, -8.65558088e-02f,
  -1.63362026e-01f, -6.47194637e-03f, 2.12177649e-01f, 1.70485184e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.03530185e-02f, 2.72004634e-01f, 2.97685474e-01f, 2.64293730e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.59412324e-01f, 2.57722527e-01f, 1.93083942e-01f, -1.24983154e-01f, 2.35872462e-01f, 2.52329648e-01f, 3.20390552e-01f, -9.72276777e-02f, 6.41779304e-01f, 1.54161543e-01f,
  4.92230147e-01f, 1.66750774e-01f, -3.59580517e-01f, 2.56520003e-01f, -3.34424049e-01f, 2.36479416e-02f, 4.96716090e-02f, 1.71700448e-01f, 3.47963780e-01f, -3.09688658e-01f,
  -1.32132381e-01f, 1.93646938e-01f, 2.38599867e-01f, -1.25594243e-01f, 5.16979158e-01f, 4.95322764e-01f, 6.75126851e-01f, 4.97464761e-02f, -3.96050274e-01f, -6.45648539e-02f,
  1.63099572e-01f, 2.70142615e-01f, 4.59399540e-03f, -8.86820704e-02f, -3.60994637e-02f, 1.14897616e-01f, -2.76019257e-02f, -1.29560471e-01f, -6.11911654e-01f, 3.23660016e-01f,
  -4.95446712e-01f, -1.43944383e-01f, -1.27175555e-01f, -3.25583190e-01f, -8.92492384e-02f, 7.61179104e-02f, -4.28658500e-02f, -3.91440615e-02f, -2.54641175e-01f, -1.86505750e-01f,
  8.36613625e-02f, -3.60149354e-01f, -2.21710011e-01f, 1.11062534e-01f, 2.52862930e-01f, 4.59541306e-02f, -3.71099383e-01f, 5.15272796e-01f, 3.25819790e-01f, 3.28771412e-01f,
  -2.47516930e-02f, 1.55613068e-02f, -1.50812429e-03f, 9.76744369e-02f, 1.61705151e-01f, 4.55184907e-01f, -2.10928485e-01f, 1.20410755e-01f, -1.82532012e-01f, -4.05677371e-02f,
  -4.32120040e-02f, -1.07040524e-01f, 1.66183114e-01f, -5.21643877e-01f, -4.83980626e-01f, -3.79108995e-01f, -2.18003303e-01f, 7.74269849e-02f, -1.29982188e-01f, 2.30496064e-01f,
  -7.87501782e-02f, 1.83107957e-01f, -2.96348155e-01f, -5.33644438e-01f, 4.09933954e-01f, -1.22375049e-01f, 3.34972382e-01f, -5.70806623e-01f, -7.78770983e-01f, 1.93141848e-01f,
  -2.90237099e-01f, 6.35828078e-02f, 4.61297631e-01f, 6.50644973e-02f, 5.19862413e-01f, -2.94116605e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.14713036e-01f, 3.65240946e-02f, 3.00192177e-01f, 4.22999889e-01f, 2.43926272e-01f, 6.02503121e-01f, -7.56809413e-01f, 7.38825023e-01f, -3.07107031e-01f, 1.84265032e-01f,
  1.89418152e-01f, -2.95430552e-02f, -2.25667551e-01f, 7.31527984e-01f, -5.05922496e-01f, 1.23557314e-01f, 2.63632536e-01f, 7.60395885e-01f, 2.99316168e-01f, 4.48438495e-01f,
  2.74575502e-01f, 3.54441583e-01f, 1.49876878e-01f, -3.35399956e-01f, 4.73907590e-02f, -6.67507350e-02f, -4.98748630e-01f, 2.07953379e-01f, 1.85199112e-01f, -1.91441819e-01f,
  3.49673301e-01f, -5.66169061e-02f, -1.27787396e-01f, 6.68219477e-02f, -1.97279632e-01f, 2.08338574e-01f, 9.06614289e-02f, -1.40712857e-01f, -8.43522102e-02f, 7.07169548e-02f,
  1.08765781e-01f, -2.02543527e-01f, -4.03645039e-02f, -6.93550706e-02f, -3.89283225e-02f, 6.66611716e-02f, -2.45159671e-01f, -1.52419865e-01f, 1.97871730e-01f, -2.58321971e-01f,
  -5.28437495e-02f, -7.17413351e-02f, 1.36882260e-01f, 1.74003199e-01f, -2.10923422e-02f, 2.35357061e-01f, -8.96169901e-01f, 2.07698375e-01f, -2.16446579e-01f, -8.05611536e-02f,
  5.54106057e-01f, 2.87801683e-01f, 2.60406911e-01f, 7.76788890e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  4.82980788e-01f, -2.41748057e-02f, -1.72706217e-01f, 1.13739252e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.35006839e-01f, -1.82210058e-01f, 9.76593345e-02f, 2.07053944e-01f, -3.73797446e-01f, -2.03302786e-01f, 4.22859430e-01f, 4.80345547e-01f, -2.37885952e-01f, 2.37299815e-01f,
  -3.92563462e-01f, -7.38967359e-01f, 1.43811285e-01f, -4.90063488e-01f, 1.47659220e-02f, -9.07238275e-02f, -1.03678338e-01f, -2.02199563e-01f, 8.92725289e-02f, 2.69430071e-01f,
  1.42039701e-01f, -2.86705345e-02f, 2.56873727e-01f, 6.07583106e-01f, -5.84452808e-01f, 1.92498177e-01f, 3.25254142e-01f, 3.91498715e-01f, -5.14075696e-01f, 4.31818247e-01f,
  -2.62311399e-01f, -4.12967861e-01f, 1.90173522e-01f, -5.36762662e-02f, -1.99726615e-02f, -3.78581621e-02f, 2.22378969e-01f, 1.42823800e-01f, 7.11793244e-01f, 4.85325366e-01f,
  -2.86712378e-01f, -3.11296225e-01f, 3.02040815e-01f, -5.14320731e-01f, 8.06404799e-02f, 4.47310746e-01f, -1.24031402e-01f, -5.88792026e-01f, -4.70014036e-01f, -1.66492090e-01f,
  -8.29470232e-02f, -1.14154562e-01f, -3.29605234e-03f, -3.17493856e-01f, -5.82858264e-01f, -7.53742754e-01f, 7.11323619e-01f, -2.37387076e-01f, 1.59326300e-01f, 2.98306495e-01f,
  2.89122254e-01f, -1.09509297e-01f, -1.38567999e-01f, 3.62407148e-01f, 2.13365033e-01f, -1.18769385e-01f, 1.54244840e-01f, 2.01501936e-01f, 2.44597822e-01f, 5.11095583e-01f,
  7.81029761e-01f, 8.41896057e-01f, -5.07610857e-01f, -1.04195820e-02f, -2.77345270e-01f, -3.49833161e-01f, 6.37089908e-02f, 2.20539287e-01f, -1.11084014e-01f, -4.66336757e-01f,
  -3.44813854e-01f, -2.26827964e-01f, -2.15269789e-01f, -1.16603389e-01f, -2.60006636e-01f, 1.01180822e-01f, -5.30521534e-02f, -2.99307287e-01f, -3.65059108e-01f, -2.55205005e-01f,
  1.10059924e-01f, 7.16704786e-01f, -5.30916393e-01f, 5.26697397e-01f, 1.93284601e-01f, 1.68869257e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.72344381e-01f, -4.22204733e-02f, 2.69305587e-01f, 2.32634783e-01f, -1.28314078e-01f, 4.97903347e-01f, 1.99237745e-02f, 2.54085839e-01f, 2.13845950e-02f, 7.87411571e-01f,
  -6.67391062e-01f, 8.33539546e-01f, 5.16646266e-01f, -4.72284704e-01f, -6.67000413e-02f, 5.99911034e-01f, -1.09765776e-01f, -1.83504283e-01f, 1.68185890e-01f, 4.53019828e-01f,
  -4.15036529e-02f, 4.36434597e-01f, 7.60851383e-01f, 6.01331353e-01f, -2.79382974e-01f, 4.86259133e-01f, -2.92467088e-01f, 1.22420363e-01f, 3.17190081e-01f, -1.73555776e-01f,
  -9.86319184e-02f, -1.45769402e-01f, -4.59654117e-03f, -2.71198004e-01f, 3.48066866e-01f, -1.76072121e-03f, 6.64646849e-02f, 9.91053060e-02f, 7.15574026e-01f, 3.67543578e-01f,
  1.85220271e-01f, 7.40877092e-02f, -1.27058372e-01f, -9.18320656e-01f, 4.30586696e-01f, -3.37672234e-01f, 1.00692920e-01f, -3.51036519e-01f, 7.68235683e-01f, 2.61862308e-01f,
  9.75039005e-02f, 2.11011931e-01f, 2.10009381e-01f, 4.02345747e-01f, 1.68024838e-01f, -4.34692912e-02f, 3.69627982e-01f, -4.60765600e-01f, 2.78117418e-01f, -7.67844975e-01f,
  1.16643822e+00f, -5.91326728e-02f, -5.06533794e-02f, -1.78711414e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  4.28333104e-01f, 2.26615489e-01f, 4.10525829e-01f, 3.88721704e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  7.48290300e-01f, -1.59696728e-01f, -1.64800510e-01f, 2.05064178e-01f, 4.47509944e-01f, -7.19486713e-01f, 1.57734782e-01f, -8.90752614e-01f, 5.77850044e-01f, 8.59946609e-02f,
  2.76217192e-01f, -6.85773313e-01f, -1.05975318e+00f, -4.21285123e-01f, 4.27372277e-01f, 7.81987965e-01f, -3.28328788e-01f, 6.59918010e-01f, -3.61185879e-01f, -4.50483292e-01f,
  -8.15461814e-01f, -6.73282802e-01f, 1.06705141e+00f, 3.33211601e-01f, 5.86791337e-01f, -6.17919445e-01f, 3.68386745e-01f, -8.31238270e-01f, -3.89921129e-01f, 4.59031671e-01f,
  8.63161922e-01f, -4.15274166e-02f, 7.02962637e-01f, -6.14739239e-01f, 1.00457735e-01f, -5.54041862e-01f, -7.61960864e-01f, 5.58323979e-01f, -5.75474603e-03f, 8.50619614e-01f,
  6.40715718e-01f, -6.59737885e-01f, 5.32605350e-01f, 3.11303973e-01f, 3.33588719e-01f, 6.84053540e-01f, 6.16451837e-02f, -8.33126366e-01f, -1.03960025e+00f, 1.55800745e-01f,
  8.55681717e-01f, 8.09978187e-01f, 1.06467521e+00f, 1.60528943e-02f, -2.44495109e-01f, 1.15983486e+00f, 1.17244758e-01f, 1.80234298e-01f, -5.34125268e-02f, 1.13065553e+00f,
  -2.33791500e-01f, -4.61446166e-01f, 1.00355614e-02f, -4.64152902e-01f, -3.44965070e-01f, 5.34634113e-01f, 7.35474110e-01f, 3.23474646e-01f, 6.76136017e-01f, 8.21424365e-01f,
  -7.64982164e-01f, -9.08836186e-01f, 2.99675584e-01f, 7.80603170e-01f, 3.70716825e-02f, -3.01789194e-01f, -3.34958553e-01f, -5.19204661e-02f, -5.73067129e-01f, 6.62616372e-01f,
  -2.11195648e-01f, -6.75127268e-01f, 1.21851154e-01f, 1.71872392e-01f, 7.21701160e-02f, -8.73991013e-01f, 1.19304669e+00f, -3.94395947e-01f, -9.30535868e-02f, 2.20793456e-01f,
  5.35704374e-01f, 1.91715106e-01f, 5.80387153e-02f, 1.94548160e-01f, 5.72868228e-01f, 3.04596454e-01f, 6.84119344e-01f, 7.33997524e-01f, 5.90888321e-01f, 1.82708278e-01f,
  5.31085730e-02f, 5.78831472e-02f, 2.38369912e-01f, -1.88797295e-01f, 7.09972084e-02f, -1.81296885e-01f, 6.77622318e-01f, -1.06028521e+00f, 6.06192291e-01f, 6.01797402e-01f,
  -1.73028111e-01f, -1.60062030e-01f, -1.07730067e+00f, 7.16800869e-01f, 1.56973824e-01f, -1.17987835e+00f, -6.17211044e-01f, -5.30704677e-01f, 3.53343897e-02f, 3.74978691e-01f,
  -5.47492266e-01f, 6.68516874e-01f, -1.10983407e+00f, 5.55645347e-01f, -3.33539635e-01f, 6.34425655e-02f, -1.39113292e-01f, -5.35821795e-01f, 6.39327228e-01f, 5.27356267e-01f,
  -2.60194719e-01f, 6.53274894e-01f, 7.20249414e-01f, 8.75844836e-01f, 5.49603343e-01f, -3.40732336e-01f, -9.78223562e-01f, -4.39790905e-01f, -7.04978347e-01f, -4.25185770e-01f,
  5.83850682e-01f, -1.26729056e-01f, -3.89916569e-01f, -8.50135922e-01f, 2.92009801e-01f, -6.35988772e-01f, 1.25271514e-01f, -4.26102549e-01f, 3.98191541e-01f, -9.97372903e-03f,
  -3.19496840e-01f, 4.02248465e-02f, -9.13844168e-01f, 6.67060673e-01f, -7.44969666e-01f, -6.70037866e-01f, 3.16371560e-01f, -9.13718715e-02f, -3.86124730e-01f, 4.37753737e-01f,
  -2.34884262e-01f, -4.23978502e-03f, -5.77213407e-01f, 1.30307421e-01f, -1.80894598e-01f, 4.32322770e-01f, -9.23190236e-01f, 8.13512743e-01f, 8.10967624e-01f, -9.77412879e-01f,
  8.14226925e-01f, 6.70044184e-01f, -6.10158145e-01f, -1.18801504e-01f, -3.96893561e-01f, 2.93560565e-01f, 1.46849886e-01f, -6.63615227e-01f, -8.53443265e-01f, -8.31038535e-01f,
  -8.70591938e-01f, 7.78698027e-01f, -8.02764177e-01f, -6.16786718e-01f, -3.02057981e-01f, 3.95877212e-01f, -7.56675482e-01f, 1.26336113e-01f, 5.69692135e-01f, -5.66065788e-01f,
  -2.72766918e-01f, -4.77784663e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.11961412e-01f, -4.86933626e-02f, -1.84275120e-01f, 1.92894965e-01f, -2.03831065e-02f, -2.69215643e-01f, -2.84385592e-01f, 3.47097278e-01f, 2.05124140e-01f, -2.53698260e-01f,
  2.92921275e-01f, 2.71516919e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    