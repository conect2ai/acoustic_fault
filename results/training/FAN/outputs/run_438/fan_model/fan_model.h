/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.84559000e-01f, -5.93641281e-01f, 2.32086569e-01f, 5.98523468e-02f, 2.31540501e-01f, -6.31472051e-01f, -3.57896209e-01f, 6.50206879e-02f, 5.51730059e-02f, -4.03361201e-01f,
  6.53383434e-02f, 2.31155995e-02f, -2.07591027e-01f, -2.62364626e-01f, 8.65594819e-02f, -2.32436553e-01f, -2.36058101e-01f, -1.74260587e-01f, -1.47432894e-01f, -7.55043402e-02f,
  1.06271736e-01f, -2.03146517e-01f, 1.93868190e-01f, -1.84989035e-01f, 2.12221425e-02f, -6.25933036e-02f, 1.88283041e-01f, -1.20883184e-02f, 4.80861478e-02f, -2.69467849e-02f,
  -3.03234365e-02f, -2.70479731e-03f, 1.58278465e-01f, 5.40689826e-02f, -3.76194976e-02f, -1.04837846e-02f, 2.64987014e-02f, 4.28964794e-02f, 1.02110088e-01f, -6.43182173e-02f,
  -6.64821714e-02f, -4.96516898e-02f, -7.88102672e-02f, -9.28081851e-03f, 6.27898052e-02f, 6.64833486e-02f, 3.47427055e-02f, 3.68065722e-02f, -3.70207168e-02f, 4.84631062e-02f,
  -1.08046196e-02f, 3.52565460e-02f, 1.36901811e-01f, -5.40328100e-02f, 5.98386489e-02f, -1.37733633e-03f, -3.94676402e-02f, 5.67448474e-02f, 3.82512100e-02f, -6.75795078e-02f,
  1.73902921e-02f, -9.34977457e-02f, -3.81677113e-02f, 1.37614146e-01f, -2.16362160e-02f, 1.19188383e-01f, -2.21447609e-02f, 4.47855443e-02f, 1.57882050e-02f, 4.66368981e-02f,
  1.84945147e-02f, 8.97137672e-02f, 1.03970496e-02f, 6.10786751e-02f, -4.31179516e-02f, -4.87461723e-02f, -1.74450204e-02f, -4.29227250e-03f, 4.17169034e-02f, 6.73762932e-02f,
  -2.33988613e-02f, -5.11806197e-02f, -2.40867529e-02f, -6.56733336e-03f, -6.92578256e-02f, 6.95510209e-02f, -2.40703466e-05f, 2.85413861e-02f, 6.48773788e-03f, -2.72483733e-02f,
  -1.97928607e-01f, -3.64343733e-01f, -4.09728624e-02f, -5.06164832e-03f, -7.44758546e-02f, 1.10236347e-01f, -2.07911134e-02f, -4.44106087e-02f, -9.89567339e-02f, -1.35907084e-02f,
  5.26177278e-03f, 1.62406955e-02f, 4.58999649e-02f, 6.61099553e-02f, 4.61509563e-02f, -7.02623203e-02f, -1.28857911e-01f, -4.10778001e-02f, 5.56881949e-02f, -2.59229951e-02f,
  3.20982561e-02f, -1.66793093e-02f, 7.53340079e-03f, -5.80393150e-02f, 6.22415505e-02f, -6.14664145e-02f, 2.75883079e-02f, 3.50447744e-02f, -1.09320246e-02f, 1.44908847e-02f,
  -3.04041237e-01f, -3.59998822e-01f, 1.47790864e-01f, -5.65328002e-01f, 2.89700702e-02f, -4.60635483e-01f, -9.34957191e-02f, -3.01751643e-01f, -2.07114965e-01f, -8.62152800e-02f,
  -2.11064219e-01f, 1.75111920e-01f, 1.43248290e-01f, -4.33728576e-01f, -3.34031731e-01f, -2.04453226e-02f, -4.41212416e-01f, -9.91785005e-02f, 1.53988808e-01f, -1.47062525e-01f,
  -6.66905195e-02f, -3.03451002e-01f, -1.60348803e-01f, -5.90962134e-02f, -2.22310901e-01f, 1.29957467e-01f, -3.62482667e-02f, 2.16276184e-01f, -1.31029651e-01f, 1.56013966e-02f,
  -3.29176448e-02f, -1.49414480e-01f, 2.07006447e-02f, -9.52373967e-02f, -1.40128165e-01f, 8.53900686e-02f, 2.08471809e-02f, 1.51793852e-01f, 4.62021604e-02f, -4.90922965e-02f,
  6.55009896e-02f, 2.18733829e-02f, 7.98965916e-02f, 7.71384239e-02f, -1.64529786e-01f, -5.06264344e-02f, -9.20783430e-02f, -6.13670461e-02f, 2.76109241e-02f, -1.32417232e-01f,
  -3.27404477e-02f, -6.16761632e-02f, -1.53209284e-01f, -1.74533706e-02f, 2.77028512e-02f, 6.22964604e-03f, 2.30916925e-02f, 9.95858312e-02f, -5.07330373e-02f, -4.04345356e-02f,
  -6.48499578e-02f, -6.09885827e-02f, -1.77840889e-02f, -2.95943767e-02f, -5.14692217e-02f, 5.55957109e-02f, -2.94895079e-02f, 4.95315082e-02f, 2.62866784e-02f, -6.65682256e-02f,
  1.20785683e-02f, 2.15184242e-02f, -5.24105467e-02f, -3.20870318e-02f, -7.87463188e-02f, -2.78732367e-02f, 4.46681213e-03f, 4.88794185e-02f, -7.82654211e-02f, 2.71747131e-02f,
  3.23285460e-02f, -1.51974680e-02f, -2.33004279e-02f, -5.27677350e-02f, -2.21938286e-02f, 2.13629287e-02f, 2.23435722e-02f, -5.29759005e-02f, -2.66089719e-02f, -4.10339460e-02f,
  -8.49774256e-02f, -1.78347915e-01f, -8.22014175e-03f, 8.08627978e-02f, 7.99966380e-02f, -6.36721551e-02f, -6.67055696e-03f, -7.54182637e-02f, 1.12513795e-01f, -7.73818865e-02f,
  -3.16089094e-02f, -9.31130350e-02f, 3.35227661e-02f, -3.63190696e-02f, 4.98619005e-02f, -1.61789134e-02f, 8.22269917e-02f, 1.44186288e-01f, -4.27446030e-02f, 4.11833189e-02f,
  2.64273845e-02f, 9.06968862e-02f, 7.33063221e-02f, -6.82651401e-02f, 6.72298251e-04f, 3.19286771e-02f, -7.86988586e-02f, -8.79560336e-02f, 7.38346502e-02f, 1.28897987e-02f,
  -4.50794280e-01f, -4.08159792e-02f, 8.24266076e-02f, -1.65906280e-01f, 2.83286363e-01f, 3.29321504e-01f, 2.03510784e-02f, 2.46054068e-01f, -2.14988753e-01f, -9.14556440e-03f,
  -2.39822000e-01f, -2.41134912e-01f, -5.50635979e-02f, -2.16326281e-01f, -5.02857625e-01f, -2.21145689e-01f, -2.86831468e-01f, -2.66533196e-01f, -1.62773341e-01f, -8.21756050e-02f,
  -1.11039706e-01f, 5.92285544e-02f, 5.57507612e-02f, 3.30497265e-01f, 4.04113531e-01f, 9.09337848e-02f, 9.71058607e-02f, 1.50852099e-01f, 1.78120002e-01f, -1.29505470e-02f,
  8.45986232e-02f, -7.45343715e-02f, -7.18709081e-02f, 7.18513206e-02f, -5.32739311e-02f, 4.61528786e-02f, -1.27809227e-01f, 7.28008673e-02f, 5.11192381e-02f, 5.28513379e-02f,
  6.73508970e-03f, 9.12765488e-02f, -5.62821999e-02f, 6.96599036e-02f, 1.24356048e-02f, 1.04212791e-01f, 1.15371771e-01f, 2.42884294e-03f, 1.67773888e-01f, 3.42602804e-02f,
  4.43572886e-02f, 2.05587763e-02f, -6.46852851e-02f, -5.00259139e-02f, 3.50173041e-02f, -8.78938586e-02f, 1.73386067e-01f, -2.18734238e-02f, -9.49586928e-03f, -7.21132057e-03f,
  -6.97411150e-02f, -5.85632101e-02f, -1.92518272e-02f, 3.90713476e-02f, 1.89556740e-04f, 2.18869676e-03f, -2.27692593e-02f, 6.73019439e-02f, 8.61732662e-03f, -2.05068141e-02f,
  1.23912811e-01f, -7.04790801e-02f, 8.12337473e-02f, 9.88269597e-02f, -5.24910502e-02f, 3.52054611e-02f, 4.75481674e-02f, 7.34864399e-02f, -2.29236414e-03f, 1.52365249e-02f,
  1.92708541e-02f, -4.56888191e-02f, -5.66063076e-02f, 1.01406120e-01f, -5.67842014e-02f, -6.70019398e-03f, 5.49395531e-02f, 1.42737404e-01f, -7.22638145e-02f, 7.59517476e-02f,
  -2.05533668e-01f, -1.15890011e-01f, -4.93441634e-02f, 1.30022615e-01f, -1.99344452e-03f, 1.55351553e-02f, -1.30805941e-02f, -3.36098261e-02f, 8.43742713e-02f, -1.13423718e-02f,
  4.06244621e-02f, 1.83995645e-02f, -1.57555733e-02f, -4.31790054e-02f, -1.68738700e-02f, -7.08156750e-02f, -1.02811597e-01f, -6.99066091e-03f, -7.94966370e-02f, -1.37539338e-02f,
  5.58554269e-02f, 1.63517874e-02f, 7.76098371e-02f, 1.13687217e-01f, 2.63562426e-02f, 2.50744727e-02f, -4.62035686e-02f, 7.43450895e-02f, 1.76314592e-01f, 1.08271884e-02f,
  -5.07929564e-01f, 9.39367712e-02f, -1.25915170e-01f, 1.60338566e-01f, -2.17666194e-01f, -4.47795331e-01f, 8.15557782e-03f, 6.52836345e-04f, -8.62665772e-02f, 3.81189078e-01f,
  -5.17828949e-02f, -4.08331305e-01f, 2.86397040e-01f, -1.31235451e-01f, -5.39778888e-01f, 1.13622770e-01f, -2.01589808e-01f, -9.15465206e-02f, -4.52731475e-02f, -1.52404621e-01f,
  -1.73383847e-01f, 4.11601663e-02f, -3.11491219e-03f, 1.50920090e-03f, 3.56872529e-02f, 1.54741704e-01f, 3.44143420e-01f, 1.52377844e-01f, 7.17690364e-02f, -1.78120151e-01f,
  -1.64489403e-01f, 1.87107380e-02f, 8.36975873e-02f, -9.65492278e-02f, -1.43035978e-01f, 3.90486494e-02f, -8.18005949e-03f, 1.11579664e-01f, -1.08614445e-01f, -1.17983028e-01f,
  -2.75634248e-02f, -1.69145897e-01f, -7.61445835e-02f, 2.32378356e-02f, -1.07282057e-01f, -1.40587538e-01f, -1.83261055e-02f, -2.38638055e-02f, -6.90739155e-02f, -2.56737377e-02f,
  -7.57410079e-02f, -3.65379415e-02f, -9.21995863e-02f, -5.32274395e-02f, 2.30748625e-03f, -3.84207964e-02f, 7.07769394e-02f, -2.46169488e-03f, -7.09327906e-02f, -7.73881152e-02f,
  -2.40906626e-02f, 2.20795311e-02f, -4.71622236e-02f, 1.85892489e-02f, -1.34212812e-02f, 9.81560051e-02f, -8.03659856e-02f, -2.20361650e-02f, 5.35998121e-02f, -6.44433349e-02f,
  2.41715275e-02f, -2.80219014e-03f, 2.45541167e-02f, 5.33463024e-02f, 1.63807906e-02f, 3.16590653e-03f, 1.39282700e-02f, -6.15849532e-02f, -5.25535494e-02f, 5.95689379e-02f,
  3.46822627e-02f, -3.65883447e-02f, 6.68523684e-02f, -9.27891210e-03f, -8.80403146e-02f, 4.61677983e-02f, -3.14164050e-02f, 2.09359694e-02f, 8.14973041e-02f, -5.84032387e-02f,
  -9.35254544e-02f, 8.24150816e-02f, -6.44206852e-02f, 2.91106794e-02f, 9.33412462e-02f, 7.58391097e-02f, 7.21464306e-02f, 3.05673033e-02f, -6.50078952e-02f, 1.08737117e-02f,
  5.75535521e-02f, 1.08764835e-01f, 3.32419984e-02f, -8.51566494e-02f, -1.64335733e-03f, 6.33456111e-02f, 7.08543286e-02f, 3.97931039e-02f, -4.29578945e-02f, -5.18212579e-02f,
  6.77029788e-02f, -4.42138910e-02f, -9.73519590e-03f, 1.53114786e-03f, 2.23779865e-03f, 1.13360211e-02f, -8.54952037e-02f, 1.13407999e-01f, 7.67524838e-02f, 4.18974385e-02f,
  6.05484664e-01f, -5.99244833e-01f, -5.95287204e-01f, -1.60857961e-02f, 6.11209035e-01f, -6.76285475e-02f, -1.90431431e-01f, 2.91081332e-02f, 5.85615076e-02f, -3.61675262e-01f,
  -4.94951904e-02f, -9.78930220e-02f, -1.88338026e-01f, -9.45661440e-02f, 3.79195392e-01f, -3.64130616e-01f, -4.03725132e-02f, -1.31751791e-01f, 3.11302952e-03f, -4.50514331e-02f,
  1.12650111e-01f, 2.88888574e-01f, -2.02743366e-01f, 1.22056101e-02f, 1.51844397e-01f, -2.13410258e-01f, 1.22045837e-01f, -2.24272981e-01f, 8.18644613e-02f, 1.06771998e-01f,
  8.19629617e-03f, -4.92650159e-02f, 4.22384664e-02f, -6.16450571e-02f, 1.98571384e-02f, 6.83366433e-02f, 3.72615792e-02f, 1.84612479e-02f, -2.22734064e-02f, -7.15387613e-02f,
  -6.35621622e-02f, 9.56625268e-02f, 6.27386644e-02f, -5.07586785e-02f, 1.46986231e-01f, 1.20217642e-02f, 2.68353857e-02f, 8.07816610e-02f, 4.93954830e-02f, 7.61518478e-02f,
  -6.04005307e-02f, -3.16469260e-02f, 2.69544497e-02f, -6.02240004e-02f, 6.78165257e-02f, 2.46490054e-02f, -2.87314914e-02f, 6.74135517e-03f, -9.22476314e-03f, 4.28759865e-02f,
  9.32918563e-02f, -1.02140009e-02f, -8.86531100e-02f, -3.43578421e-02f, 5.63412793e-02f, 4.46335785e-02f, 1.10330721e-02f, 2.26694643e-02f, -1.55232832e-01f, 6.12953790e-02f,
  8.67875759e-03f, 6.29167259e-02f, 4.12449613e-02f, 6.26154095e-02f, 3.10328305e-02f, 7.61381611e-02f, -5.42006865e-02f, 2.24991166e-03f, -2.00842209e-02f, 6.36237711e-02f,
  -1.01924478e-03f, 9.21888649e-03f, -1.17224842e-01f, 6.98446296e-03f, -3.34525704e-02f, 5.02980649e-02f, 1.08558342e-01f, 2.20299903e-02f, -7.17966631e-02f, 1.89881418e-02f,
  -1.37333438e-01f, -3.40733826e-01f, -9.18780267e-02f, 8.59080255e-02f, -1.55610353e-01f, -6.17645308e-02f, 2.24240199e-02f, 3.29484493e-02f, -6.41762987e-02f, 1.66662633e-02f,
  1.38581693e-01f, -2.08944976e-02f, -1.11366481e-01f, 6.41578734e-02f, -8.60869884e-02f, -1.63928401e-02f, -4.76890840e-02f, -7.71887451e-02f, 6.61177635e-02f, 3.41383927e-02f,
  5.40781729e-02f, 1.32899573e-02f, -9.25223753e-02f, 1.18693382e-01f, 8.95521566e-02f, -6.82218298e-02f, 1.91625450e-02f, -2.37182546e-02f, 2.87592895e-02f, -6.60592690e-02f,
  1.91367082e-02f, 5.81592441e-01f, -1.28219992e-01f, 3.34460407e-01f, 1.13141108e-02f, 5.27174056e-01f, -2.25849047e-01f, 3.10782522e-01f, -5.05817235e-02f, 1.33170173e-01f,
  6.37429655e-02f, 1.14972569e-01f, -7.88952932e-02f, 4.60884333e-01f, 1.23837873e-01f, 1.47833452e-01f, 4.14686143e-01f, 3.61544043e-02f, 1.06432196e-03f, 2.21466869e-01f,
  -9.46854334e-03f, 2.20591336e-01f, 9.26793143e-02f, 1.86837748e-01f, -1.30340597e-02f, 4.65993397e-03f, -8.38867277e-02f, -1.68600246e-01f, 4.13832158e-01f, -5.50281741e-02f,
  -9.15077329e-02f, -3.71319577e-02f, -1.80406515e-02f, -1.57077521e-01f, 2.87382323e-02f, -1.44039854e-01f, -1.23322941e-01f, -1.79320589e-01f, 1.23265356e-01f, 8.46012458e-02f,
  -1.28481820e-01f, 2.67353822e-02f, 1.06049031e-02f, -6.01548143e-02f, -5.62523678e-02f, -4.50335667e-02f, 7.96342418e-02f, 5.47312051e-02f, 1.30359262e-01f, -4.40596454e-02f,
  -3.09405979e-02f, 8.25713351e-02f, -1.21639661e-01f, 4.25232910e-02f, 6.24795957e-03f, -4.49149013e-02f, -9.83254835e-02f, -1.44031212e-01f, 8.85246992e-02f, 9.08318460e-02f,
  -7.98507780e-02f, -9.30595174e-02f, -1.59201473e-02f, -4.10866626e-02f, -5.02526946e-02f, -1.44857302e-01f, -8.67397338e-03f, -1.22008651e-01f, -1.66975651e-02f, 3.20534548e-03f,
  1.95390329e-01f, 1.34359989e-02f, -1.72301102e-02f, -3.86436768e-02f, 3.34332660e-02f, -2.17908379e-02f, -1.12082191e-01f, -4.65242798e-03f, 5.29407412e-02f, 3.34156468e-03f,
  -1.11295357e-01f, 4.12833728e-02f, -4.82890904e-02f, -3.25049646e-02f, -1.31712988e-01f, -1.40005350e-02f, 3.17330100e-02f, 4.49368432e-02f, -5.58310896e-02f, 1.82428677e-02f,
  1.45301074e-01f, 2.24186882e-01f, -6.62417486e-02f, 1.37361884e-01f, -3.01020145e-02f, 1.02225654e-01f, -4.33203876e-02f, 1.07165381e-01f, 9.18737650e-02f, 4.60444205e-02f,
  -1.40306512e-02f, -3.37790176e-02f, 1.64373126e-02f, 7.10796118e-02f, 2.85274815e-02f, -4.45227586e-02f, -6.78509325e-02f, -1.80406105e-02f, -3.74954343e-02f, 1.66654550e-02f,
  3.77103835e-02f, -1.14707612e-01f, -2.44817920e-02f, 8.55174009e-03f, -2.74421070e-02f, 8.36037621e-02f, -6.35816753e-02f, -4.42773439e-02f, 1.15769813e-02f, 4.20104824e-02f,
  -2.23921567e-01f, -5.64896286e-01f, 1.82009220e-01f, -2.49544665e-01f, 5.20168170e-02f, -1.74265981e-01f, 4.96220440e-02f, -3.00530255e-01f, -1.09092202e-02f, -4.08346206e-01f,
  6.04379922e-02f, -2.53927171e-01f, 9.76689756e-02f, -2.33779132e-01f, 4.30791855e-01f, 1.93253636e-01f, -1.87491447e-01f, -2.22341210e-01f, 1.42221600e-01f, -1.30413651e-01f,
  2.27243006e-01f, -1.62655160e-01f, 2.62954891e-01f, -9.04338434e-02f, -8.05373117e-02f, 1.84220858e-02f, 8.63142610e-02f, 8.99353176e-02f, -1.75500199e-01f, 2.38039698e-02f,
  -6.80583417e-02f, -1.64284363e-01f, 7.45957624e-03f, -1.71975754e-02f, 3.10558826e-04f, 1.05366491e-01f, 4.38609533e-02f, 6.76720142e-02f, 8.38406608e-02f, 4.31292057e-02f,
  3.78310941e-02f, 1.84909638e-03f, -2.33415235e-02f, -1.69281866e-02f, -1.20782420e-01f, -1.10252440e-01f, -3.12108509e-02f, 5.51422127e-04f, -4.26532552e-02f, 1.91828728e-01f,
  1.27602711e-01f, 2.30727084e-02f, 5.97944073e-02f, 1.00437161e-02f, 7.58184791e-02f, 2.35711262e-02f, 6.92166761e-02f, 1.65802278e-02f, -3.65868509e-02f, -1.12441517e-01f,
  -2.01893281e-02f, 7.20568281e-03f, -2.91441660e-02f, -2.48408895e-02f, -8.76501901e-04f, 3.28914076e-02f, -1.22067183e-02f, -4.76096056e-06f, -4.65025306e-02f, -1.38552845e-01f,
  -1.30823851e-02f, -9.92836133e-02f, -2.00644508e-02f, -5.38277663e-02f, -6.16770051e-03f, -5.93708223e-03f, 2.05599107e-02f, -4.07752581e-02f, 1.85546800e-02f, 2.57452913e-02f,
  -2.29824446e-02f, 5.39472140e-02f, -8.55225995e-02f, -7.82110635e-03f, 5.90540506e-02f, 1.97426919e-02f, -5.34912720e-02f, -1.11379698e-01f, 6.50521889e-02f, 4.55319658e-02f,
  -3.40590239e-01f, -4.22418207e-01f, 1.14019930e-01f, -8.97854865e-02f, -1.30496651e-01f, -1.28667681e-02f, 2.93473080e-02f, -6.64224923e-02f, -5.17613962e-02f, -3.11559662e-02f,
  -3.15545872e-02f, -5.35432203e-03f, 9.55650583e-03f, -9.49978307e-02f, 4.16997746e-02f, 1.42840380e-02f, 6.69536889e-02f, -3.95971239e-02f, -4.91765365e-02f, -1.55663535e-01f,
  -1.57280207e-01f, 4.70108464e-02f, 1.04988754e-01f, -9.99779813e-03f, -5.85782863e-02f, -3.31800841e-02f, -9.43029001e-02f, -2.71529565e-03f, -1.37584321e-02f, -3.43759321e-02f,
  5.75670481e-01f, -1.83205351e-01f, 2.34765172e-01f, 5.05497932e-01f, 2.11234033e-01f, -2.05689669e-01f, 3.09275419e-01f, -8.80320221e-02f, 2.41384253e-01f, -3.34064066e-01f,
  -1.32921055e-01f, 1.38777226e-01f, -1.57043740e-01f, 8.32620040e-02f, 7.63727903e-01f, -1.72047451e-01f, 1.85768187e-01f, 5.43711102e-03f, 1.12885507e-02f, 1.44527704e-01f,
  8.61348510e-02f, 1.79951951e-01f, 2.12419361e-01f, -9.70035866e-02f, 2.19269320e-01f, 8.84534512e-03f, 1.41005769e-01f, 3.31373550e-02f, -1.25427663e-01f, 1.23761304e-01f,
  -1.67440519e-01f, 8.03019404e-02f, -2.71325535e-03f, 5.73699130e-03f, -7.12210014e-02f, -1.17357925e-01f, -5.26811108e-02f, 1.18692871e-02f, -1.68194417e-02f, -1.26778930e-01f,
  -1.73990317e-02f, 9.83545184e-02f, 2.33009961e-02f, 4.72098514e-02f, 1.01067275e-01f, 5.18380255e-02f, 6.98953867e-02f, -6.88823089e-02f, 3.64590064e-02f, -3.54703404e-02f,
  2.93223951e-02f, 3.36214118e-02f, 1.24886498e-01f, 5.06341504e-03f, 1.04207702e-01f, 4.34094407e-02f, -7.04611167e-02f, 1.04155295e-01f, 8.05244129e-03f, 6.29756302e-02f,
  -9.29647684e-03f, -6.96464702e-02f, -5.07938787e-02f, -1.51539939e-02f, 1.80140957e-02f, 4.16043401e-02f, -5.33132851e-02f, 1.07878009e-02f, 8.87155160e-02f, -4.24023196e-02f,
  2.42765043e-02f, -3.13941948e-02f, 4.80930656e-02f, 1.35323387e-02f, -6.67769834e-02f, -4.14843075e-02f, 2.94995047e-02f, -1.23725802e-01f, 2.69178189e-02f, 3.10306903e-02f,
  -2.94304360e-02f, 5.98586760e-02f, -8.24895352e-02f, -1.51099004e-02f, -9.04579163e-02f, 7.26494715e-02f, 6.63880585e-03f, -6.15020283e-02f, 1.74244773e-02f, 1.06974781e-01f,
  1.75484315e-01f, 2.19513088e-01f, -8.93539339e-02f, 1.23198457e-01f, -5.28401993e-02f, 5.32028191e-02f, 1.01091683e-01f, 3.10944952e-02f, 9.47684571e-02f, 3.68417948e-02f,
  5.79415224e-02f, -5.80065958e-02f, -3.62274349e-02f, -1.48691880e-02f, -6.69611916e-02f, -5.22180162e-02f, -5.25794439e-02f, -4.93622990e-03f, 1.48279727e-01f, -6.69748113e-02f,
  -3.16792540e-02f, -5.11823222e-02f, -6.43894449e-02f, -9.39887017e-02f, -3.35697047e-02f, 1.30428091e-01f, 1.71212628e-02f, 5.21738688e-03f, 4.57347836e-03f, -6.65995702e-02f,
  7.15257153e-02f, -2.97703981e-01f, 3.68437558e-01f, 2.03785345e-01f, -3.11897602e-02f, -6.41577411e-03f, 1.98620290e-01f, -6.99043870e-02f, -3.02660137e-01f, -2.65913397e-01f,
  -9.06511098e-02f, 2.05180302e-01f, -1.62237361e-01f, -2.42960468e-01f, 2.92824022e-02f, -2.62369573e-01f, -1.40567437e-01f, -8.32527801e-02f, -1.43771008e-01f, 4.66564409e-02f,
  3.65063250e-02f, -3.26035500e-01f, 3.84499192e-01f, -1.57607570e-01f, 3.58333662e-02f, 2.53212571e-01f, -3.45753506e-02f, 8.12631324e-02f, 1.42143115e-01f, -8.17827284e-02f,
  -9.72995386e-02f, 4.31816168e-02f, 1.19631559e-01f, -1.84236616e-02f, 2.05701701e-02f, 2.41705850e-02f, 1.07485078e-01f, 8.81161913e-03f, 1.68471962e-01f, -1.96257178e-02f,
  -4.31876443e-02f, -1.77926365e-02f, -1.51226046e-02f, -7.07846656e-02f, 5.30056655e-02f, 4.54163440e-02f, 8.85901153e-02f, 1.84544064e-02f, -9.75601599e-02f, 9.72192809e-02f,
  1.30715787e-01f, 1.24946639e-01f, 5.54022118e-02f, -5.71934581e-02f, 9.61889327e-02f, -1.84738990e-02f, 4.03030068e-02f, 1.50509983e-01f, -6.03587404e-02f, -7.45799392e-02f,
  1.43304393e-01f, 1.15492931e-02f, 8.71030167e-02f, -2.31292155e-02f, -7.31992945e-02f, 4.37671132e-02f, 2.30877809e-02f, -5.80560938e-02f, -1.95146464e-02f, -2.41950750e-02f,
  1.26035437e-01f, -8.60469230e-03f, -1.28891012e-02f, 5.44028357e-02f, 1.18444756e-01f, 1.31516885e-02f, 6.16814792e-02f, -4.52478342e-02f, 7.02448785e-02f, 1.15395270e-01f,
  -1.76896453e-01f, -4.68450896e-02f, 1.90679599e-02f, -1.13699831e-01f, -3.39705311e-02f, 6.99277818e-02f, -9.55949649e-02f, 2.22688783e-02f, -2.11178493e-02f, -4.92685288e-02f,
  -3.56475383e-01f, -4.04060364e-01f, -8.02032948e-02f, 2.77133100e-02f, -3.86065580e-02f, -6.47798777e-02f, -9.61932093e-02f, -3.29792090e-02f, -1.10065900e-01f, -1.32630244e-01f,
  -2.35634148e-02f, 2.19294298e-02f, 8.87655616e-02f, 1.05103046e-01f, 8.55714306e-02f, 1.64846424e-02f, -1.07302691e-03f, -9.42343101e-02f, -8.78549144e-02f, 3.24030966e-02f,
  -1.38337296e-02f, 3.26512866e-02f, 6.08541109e-02f, 2.82429419e-02f, 4.63318154e-02f, 7.14549720e-02f, -2.96949446e-02f, 7.54364431e-02f, -7.25430474e-02f, -3.31046581e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.50878209e-01f, 1.13456500e+00f, 3.80023360e-01f, -5.53397954e-01f, -1.17069200e-01f, -5.10582030e-01f, -6.12783432e-01f, 6.69471025e-02f, -7.99445510e-02f, 3.90544012e-02f,
  -4.17642236e-01f, 5.31523526e-01f, 8.17837268e-02f, -2.73088783e-01f, -6.40275776e-01f, 5.17190481e-03f, -6.88563764e-01f, -2.56264031e-01f, 1.52788535e-01f, -2.97442257e-01f,
  -2.44851246e-01f, -7.00978458e-01f, -1.29533559e-01f, -2.88543198e-03f, -1.80368528e-01f, 1.42903954e-01f, -3.89315575e-01f, 2.82340795e-01f, -2.24049702e-01f, 1.19731627e-01f,
  -6.24355953e-03f, -5.72575629e-02f, 2.76314139e-01f, -8.47370327e-02f, -3.75577062e-01f, -8.84140283e-02f, -3.50698382e-02f, 8.12494829e-02f, -1.48424193e-01f, 5.24323694e-02f,
  9.72374976e-02f, 1.55737698e-01f, -7.37845153e-02f, 8.28758031e-02f, 6.72528371e-02f, 2.24156320e-01f, 1.81182384e-01f, 1.60510346e-01f, 1.22549370e-01f, 2.72572368e-01f,
  3.24819624e-01f, 1.89069048e-01f, 5.97814331e-03f, -8.82744864e-02f, -1.36541175e-02f, 9.63443518e-02f, -2.13263199e-01f, 6.51635006e-02f, 6.56768084e-02f, -5.96157052e-02f,
  -1.85366705e-01f, -2.24499926e-01f, -1.23711213e-01f, 3.99315879e-02f, -1.69775710e-01f, 6.45263568e-02f, -4.52972911e-02f, -7.97684714e-02f, -3.15380469e-03f, -1.32111296e-01f,
  -8.14446881e-02f, 1.27163514e-01f, -6.84577823e-02f, -2.00402856e-01f, -1.98405266e-01f, -1.25843240e-02f, -7.09032826e-03f, 4.39265780e-02f, -7.95346722e-02f, -3.93863842e-02f,
  7.10474476e-02f, -1.08708426e-01f, 6.25500977e-02f, -8.97604823e-02f, 2.62605138e-02f, 3.93227078e-02f, 4.73825298e-02f, 1.76891521e-01f, 2.14633867e-02f, -2.08477527e-01f,
  -8.04848969e-01f, -8.28194797e-01f, -2.29653597e-01f, 7.84190446e-02f, 3.53445648e-03f, -3.20007354e-02f, -5.11635169e-02f, 1.57519266e-01f, -2.58458704e-01f, -2.27149978e-01f,
  -1.18596822e-01f, -1.80282220e-01f, -9.83861536e-02f, 3.79227065e-02f, -2.95595881e-02f, -1.65446490e-01f, -2.86825448e-01f, -7.73127601e-02f, -2.73203433e-01f, 2.87542585e-02f,
  -5.89612015e-02f, -1.63588710e-02f, -6.30677119e-02f, -9.68273878e-02f, -1.11489706e-01f, -2.00493187e-01f, -2.52788495e-02f, 1.41509816e-01f, -1.46023259e-01f, -2.40540667e-03f,
  3.58703941e-01f, 5.33612490e-01f, 3.39590788e-01f, 5.27608395e-01f, -7.51736045e-01f, -6.16491079e-01f, -3.94627303e-01f, -2.45430440e-01f, 5.97272575e-01f, 2.33871683e-01f,
  -6.27030313e-01f, 8.90095472e-01f, -1.19934857e-01f, -4.09709513e-01f, -1.34273157e-01f, -6.60673156e-02f, 1.44451812e-01f, 6.25760183e-02f, 5.44779338e-02f, 2.73957431e-01f,
  1.96737573e-01f, -4.06988114e-01f, -1.22818798e-01f, -3.43199283e-01f, -7.68408477e-02f, 3.88102472e-01f, 6.38197437e-02f, -3.20173174e-01f, 1.12091443e-02f, -3.10373366e-01f,
  -2.44851053e-01f, 2.04824179e-01f, 2.99355946e-02f, 9.86815840e-02f, 1.42759830e-01f, -2.28476506e-02f, 4.82925512e-02f, -1.25304565e-01f, -1.36552706e-01f, 3.87476347e-02f,
  3.15237522e-01f, 1.18811168e-01f, 1.57326683e-01f, -1.41667619e-01f, -4.87582088e-02f, -8.57308879e-02f, 1.87571138e-01f, 6.50276095e-02f, 9.15333852e-02f, -7.07001314e-02f,
  1.61093980e-01f, 1.48986861e-01f, 2.16405932e-02f, 2.33851552e-01f, 1.34319603e-01f, 6.45636693e-02f, 3.27668265e-02f, 7.52670094e-02f, 1.44822985e-01f, 3.65711451e-01f,
  1.11601353e-01f, 1.77178979e-02f, -1.66453466e-01f, 1.78120453e-02f, -8.56241584e-02f, -1.59780979e-01f, 1.68234438e-01f, -5.98566569e-02f, 8.72598775e-03f, -6.51319027e-02f,
  -8.40062499e-02f, -5.38707972e-02f, -9.23984870e-02f, 3.45283486e-02f, 9.06902645e-03f, 1.84211925e-01f, -8.33494961e-03f, -1.52023181e-01f, 2.81973351e-02f, 2.24335194e-01f,
  -1.27574220e-01f, -9.57293510e-02f, 1.52461991e-01f, -9.31305662e-02f, -2.82152295e-01f, 1.09760119e-02f, 1.26322880e-01f, 9.73933116e-02f, -1.24968819e-01f, -6.38351291e-02f,
  3.59199382e-02f, 6.33322239e-01f, 2.43834928e-01f, -3.13947648e-02f, 9.04365405e-02f, 5.90893216e-02f, 7.65363686e-03f, 1.65116161e-01f, 3.09068203e-01f, -9.37055796e-02f,
  2.66718026e-02f, 1.08827524e-01f, -2.01088004e-02f, -1.91522509e-01f, -3.72939892e-02f, 1.05023682e-01f, 1.63018182e-01f, 2.98610389e-01f, 1.88398227e-01f, 9.17133391e-02f,
  9.03877243e-02f, -3.27272452e-02f, 2.61958688e-01f, 7.74939135e-02f, 4.40804064e-02f, 1.25851676e-01f, -4.01832629e-03f, 1.37546957e-01f, 1.05871238e-01f, 9.96662006e-02f,
  5.57252288e-01f, -6.46219313e-01f, -4.29631919e-01f, -1.90220356e-01f, -4.14365947e-01f, -3.03237051e-01f, 2.12859452e-01f, -6.91552043e-01f, -7.14441463e-02f, -4.37567860e-01f,
  -2.99544871e-01f, 2.76499748e-01f, 7.22763479e-01f, -5.45109093e-01f, 9.05143678e-01f, 6.63534284e-01f, -4.25378710e-01f, 1.54151889e-02f, -1.76747471e-01f, -1.82822704e-01f,
  -9.14203301e-02f, -1.21883735e-01f, 4.22781073e-02f, -6.48913682e-01f, -2.99186260e-01f, -4.89999533e-01f, 9.61547941e-02f, -3.34490761e-02f, -6.64493680e-01f, 5.12113273e-02f,
  -8.84046704e-02f, 2.93599665e-02f, -1.13059379e-01f, 4.52697612e-02f, -1.44768402e-01f, 1.30482297e-02f, 8.40097442e-02f, 3.77686411e-01f, 1.77685827e-01f, 4.73206379e-02f,
  2.04544768e-01f, 1.72803000e-01f, -2.50280946e-01f, 2.14752853e-01f, -1.23415560e-01f, -4.16752696e-01f, -4.52565625e-02f, -2.46530101e-01f, -1.19766658e-02f, 1.37525573e-01f,
  4.17538360e-03f, -1.57492131e-01f, -1.89489871e-01f, -6.93867579e-02f, 6.89632595e-02f, -4.97493632e-02f, 1.95408523e-01f, 2.07204461e-01f, -8.99234712e-02f, 7.57134147e-03f,
  -3.45476787e-04f, 1.85166880e-01f, 8.14681575e-02f, -9.87811759e-02f, -8.13927948e-02f, -1.66930974e-01f, 2.29547303e-02f, 5.99689297e-02f, -1.54449530e-02f, 1.14735756e-02f,
  -1.01018146e-01f, -5.42056412e-02f, -2.15544198e-02f, 1.26305774e-01f, 1.74543932e-01f, 2.80285235e-02f, 1.23351403e-01f, 3.41353156e-02f, -1.56624869e-01f, -2.35851169e-01f,
  2.85650026e-02f, -3.84626687e-02f, -1.87271945e-02f, -3.31072621e-02f, -8.53167325e-02f, 7.46598989e-02f, -1.35133415e-01f, 4.66080233e-02f, -7.31712729e-02f, 1.75603181e-01f,
  -1.21802583e-01f, -2.12964192e-01f, -1.59421161e-01f, -9.42283347e-02f, -8.15009326e-02f, -1.33810699e-01f, -6.20953627e-02f, -1.43635496e-01f, -1.92599311e-01f, -2.07684841e-02f,
  -2.59272605e-01f, 8.56566951e-02f, -1.63892210e-01f, -4.47470918e-02f, 3.04594040e-02f, -2.28454560e-01f, 8.94962996e-02f, -1.69011340e-01f, -5.00540473e-02f, -1.62123948e-01f,
  -4.04555462e-02f, 9.83188897e-02f, 2.93100893e-01f, -2.91070086e-03f, -1.46523356e-01f, 2.08313182e-01f, -3.79144726e-03f, 5.23458011e-02f, 1.28400207e-01f, -1.07829444e-01f,
  -6.29399180e-01f, 2.77453840e-01f, 4.01334018e-01f, -1.03241587e+00f, 3.63125384e-01f, 3.57868969e-01f, -8.18663895e-01f, 1.85371980e-01f, -2.53062874e-01f, -3.79066885e-01f,
  -3.52526128e-01f, -3.37235570e-01f, 2.67460823e-01f, -5.34091592e-01f, 5.34945071e-01f, 4.84062105e-01f, -4.48625296e-01f, -5.13852119e-01f, 2.33198598e-01f, -4.80508685e-01f,
  1.75318904e-02f, -4.17644620e-01f, 1.34828344e-01f, 3.34311366e-01f, -2.47506812e-01f, -8.79239663e-02f, -1.73275009e-01f, 1.85625941e-01f, -2.34088004e-01f, 2.30885476e-01f,
  -3.53908055e-02f, -3.16163927e-01f, 5.98834036e-03f, 1.68722317e-01f, 4.30939067e-03f, -8.79013853e-04f, -1.89310476e-01f, 5.90318441e-02f, -9.83626246e-02f, -1.89255979e-02f,
  -6.30392432e-02f, 2.34584630e-01f, -6.69547766e-02f, 1.19124323e-01f, -5.22117279e-02f, 1.12557717e-01f, 2.22400278e-01f, 3.56127024e-02f, 1.13143876e-01f, 1.28706709e-01f,
  7.11079985e-02f, 1.51859835e-01f, -1.96928717e-02f, 1.08991787e-02f, 4.03417312e-02f, -4.50282451e-03f, -9.62226558e-03f, -4.87788729e-02f, 2.66306605e-02f, 2.77715158e-02f,
  -8.89209099e-04f, 1.35776728e-01f, 1.69431474e-02f, 2.76850853e-02f, -9.58783403e-02f, 1.09355198e-02f, -3.83325247e-03f, -7.77245611e-02f, -4.65968847e-02f, -4.96483408e-02f,
  -6.91414252e-02f, -1.76645041e-01f, 1.72246546e-02f, -5.71160056e-02f, -8.23795274e-02f, -1.80677846e-01f, 4.74032294e-03f, 1.70146693e-02f, 3.62301543e-02f, 5.22636101e-02f,
  -3.17690857e-02f, 7.88419321e-03f, -7.24360943e-02f, 4.71791588e-02f, -8.79276544e-03f, 9.87249464e-02f, -1.89044494e-02f, 5.77797890e-02f, 5.56132868e-02f, 2.47561140e-03f,
  -1.73141897e-01f, -6.17096961e-01f, -4.92257364e-02f, -5.10115735e-02f, 9.43216309e-03f, 2.65660696e-02f, 4.53174114e-02f, -3.10985819e-02f, -4.55047004e-02f, -4.63462733e-02f,
  -4.52121440e-03f, -9.58873704e-02f, -4.98420969e-02f, 9.02799144e-03f, 7.56401941e-03f, -3.20135094e-02f, -1.25886187e-01f, -1.74628019e-01f, -1.37965754e-01f, 6.23971149e-02f,
  -1.20090626e-01f, -1.46533281e-01f, 1.13429353e-02f, -2.32400727e-02f, -5.72722629e-02f, -5.26269674e-02f, -7.89014623e-02f, 6.97303712e-02f, 5.43595571e-03f, 9.42604151e-03f,
  2.39255294e-01f, -2.59579271e-01f, -3.51014197e-01f, 1.90490335e-02f, 2.14225814e-01f, -4.51252550e-01f, -8.12624037e-01f, 2.89808869e-01f, -4.32646364e-01f, -2.44926602e-01f,
  3.51530790e-01f, -4.53952044e-01f, -4.43266094e-01f, 4.24027406e-02f, 1.24399491e-01f, -7.65494287e-01f, 4.14489478e-01f, -5.18067591e-02f, -1.89331234e-01f, 5.72602332e-01f,
  5.56284785e-01f, 6.56047165e-01f, 2.82929987e-01f, 6.96936965e-01f, 2.42739573e-01f, 5.83659351e-01f, 6.84344351e-01f, 2.72241924e-02f, 7.22949505e-01f, 6.10108487e-02f,
  -1.28314331e-01f, -1.35268435e-01f, -1.77896529e-01f, -3.50054115e-01f, 1.43476099e-01f, 2.22093402e-03f, -4.66815988e-03f, -1.75925761e-01f, -1.37366414e-01f, -1.30169109e-01f,
  -6.84860125e-02f, 2.72351772e-01f, 3.18908729e-02f, 7.27588013e-02f, -2.06249803e-02f, -1.37982816e-01f, -4.70314845e-02f, -5.27985431e-02f, -2.78825313e-01f, 1.18917748e-01f,
  -6.49445802e-02f, -1.80313930e-01f, 1.30977184e-01f, -6.48046061e-02f, 2.66950801e-02f, 3.47135633e-01f, -3.64738517e-02f, -1.73484609e-01f, 6.87773665e-03f, 2.18053088e-01f,
  1.87779009e-01f, 6.55346289e-02f, 6.79496154e-02f, -5.38072623e-02f, -1.19896103e-02f, 4.83954586e-02f, 9.74690728e-03f, 9.93289724e-02f, 5.78932762e-02f, -5.24740517e-02f,
  1.74372178e-02f, -6.46311417e-02f, -9.36661139e-02f, -7.39677902e-03f, 1.13057075e-02f, -6.63383231e-02f, -1.06568851e-01f, -1.22022964e-02f, 2.81362906e-02f, -2.00012714e-01f,
  -2.97065973e-01f, 1.05994880e-01f, -2.58450121e-01f, -7.52510801e-02f, -2.03805864e-01f, -1.08380400e-01f, 1.70078143e-01f, -1.32727355e-01f, 8.78184661e-02f, -5.00017144e-02f,
  4.37140316e-02f, 4.09682065e-01f, -4.86486144e-02f, -5.98878376e-02f, 4.28913236e-02f, -1.01204872e-01f, -2.71076500e-01f, -9.50847566e-02f, 9.78371128e-02f, -8.65843371e-02f,
  2.84811050e-01f, 6.18503690e-02f, 1.01265125e-01f, 9.31700170e-02f, 8.22246820e-02f, 1.20285541e-01f, 2.55674094e-01f, -2.68917368e-03f, 7.25980252e-02f, 1.60666883e-01f,
  2.38196418e-01f, -6.21072315e-02f, 2.20198892e-02f, 1.08878858e-01f, 1.85586467e-01f, 5.17118908e-02f, 8.52947384e-02f, 1.01399295e-01f, 9.48861092e-02f, -1.24968099e-03f,
  3.28220665e-01f, -1.83664396e-01f, 4.44514528e-02f, 7.50119150e-01f, 7.80850947e-01f, -5.18020630e-01f, -4.35209014e-02f, 2.94026196e-01f, 9.57048476e-01f, -2.94434011e-01f,
  1.03863575e-01f, -2.22626776e-01f, -3.30300510e-01f, 3.36716563e-01f, -8.11906278e-01f, -4.45178479e-01f, -1.41959324e-01f, -1.24526106e-01f, 3.34929526e-01f, 9.96934846e-02f,
  1.61806479e-01f, 2.67625898e-01f, -3.16611707e-01f, 4.02798027e-01f, 2.45013639e-01f, 2.09892496e-01f, -5.85080326e-01f, 1.28608778e-01f, -1.75078630e-01f, 1.80988964e-02f,
  -1.28937483e-01f, 4.73642498e-01f, 1.40722051e-01f, -6.46058694e-02f, -1.06788717e-01f, -1.56647772e-01f, -3.70322496e-01f, 1.17771169e-02f, 1.57092005e-01f, 7.23888651e-02f,
  -1.09934621e-01f, 8.11057240e-02f, 1.34560242e-01f, 1.54543310e-01f, 2.16358736e-01f, 1.50241300e-01f, 2.12208137e-01f, -2.05303840e-02f, 1.30001470e-01f, -1.78256445e-02f,
  1.25139996e-01f, -1.05960198e-01f, -1.38411829e-02f, -1.85370505e-01f, 2.52533145e-02f, 3.14309567e-01f, -1.42118976e-01f, -2.82825559e-01f, -1.94865972e-01f, 1.73961207e-01f,
  2.97666073e-01f, -8.16739649e-02f, -1.12420935e-02f, 4.27355282e-02f, 1.16678827e-01f, 1.72051862e-01f, 7.44955987e-02f, -1.48665786e-01f, 2.48641195e-03f, -9.95833874e-02f,
  5.89516386e-02f, 9.88321826e-02f, 2.62850940e-01f, 3.80725786e-02f, 7.82562513e-03f, 1.79937750e-01f, -1.32319704e-01f, -1.00079477e-02f, -7.61831105e-02f, 9.31496918e-02f,
  8.08416754e-02f, -1.50892600e-01f, -7.76436329e-02f, -8.59361514e-02f, 9.34748258e-03f, 5.93580566e-02f, -4.23695426e-03f, 4.90444452e-02f, 1.08720705e-01f, -1.02047399e-01f,
  -1.29241681e+00f, -6.68856025e-01f, -1.28270209e-01f, 1.09722868e-01f, -2.12975200e-02f, -1.41822807e-02f, -2.42287833e-02f, 1.05855927e-01f, -2.14927122e-01f, 6.05988987e-02f,
  -1.15543209e-01f, 5.02121672e-02f, -2.65803516e-01f, 1.35327186e-02f, -2.06989646e-01f, -1.61912069e-01f, -1.21365495e-01f, -1.85554147e-01f, -3.17949176e-01f, -1.80086881e-01f,
  -7.28178546e-02f, 4.52717133e-02f, -1.16334155e-01f, 5.53976037e-02f, -1.44975886e-01f, -3.66135053e-02f, -8.98500308e-02f, 4.07881923e-02f, -1.68407690e-02f, -1.49541840e-01f,
  2.99760461e-01f, 9.89621356e-02f, -3.73988330e-01f, 8.57977476e-03f, -3.06188478e-03f, 2.21499149e-02f, -2.79479265e-01f, 1.86695442e-01f, -5.16419172e-01f, 2.45199010e-01f,
  4.44545805e-01f, -2.30051324e-01f, -7.67341480e-02f, 8.09360862e-01f, 3.43258828e-01f, 1.75899342e-01f, 6.37464046e-01f, 5.00979066e-01f, 2.19553277e-01f, 6.13891900e-01f,
  3.83917093e-01f, 9.42565441e-01f, 3.10117245e-01f, 7.34978199e-01f, 5.21634042e-01f, -1.63444169e-02f, 4.46514726e-01f, -2.27745429e-01f, 5.54743826e-01f, 9.40123200e-02f,
  1.47415310e-01f, 1.51830092e-02f, 3.74218784e-02f, -7.38015622e-02f, 2.16954187e-01f, 8.53037238e-02f, 4.56347913e-02f, -8.53724480e-02f, -2.04448611e-01f, -4.80259173e-02f,
  -1.78374365e-01f, 9.95321870e-02f, 1.08967483e-01f, -8.68327841e-02f, -9.28433388e-02f, -1.25702426e-01f, 3.89257446e-03f, -9.17275921e-02f, -2.07138076e-01f, 4.10542823e-02f,
  -8.64347070e-02f, -5.53069115e-02f, -1.06507741e-01f, 1.67570096e-02f, -1.67627990e-01f, -1.00997947e-01f, -1.34128585e-01f, 2.77342126e-02f, -2.08517183e-02f, -4.58344370e-02f,
  1.54850468e-01f, -1.05600968e-01f, 1.11851938e-01f, 2.51520146e-03f, 1.14262290e-01f, 2.74257045e-02f, 3.08962669e-02f, 2.76518259e-02f, -8.58731046e-02f, 1.57559410e-01f,
  1.56993847e-02f, -8.46748576e-02f, 1.43126830e-01f, -1.29802614e-01f, 1.22644857e-01f, 2.06780955e-02f, 9.20687057e-03f, 8.90311673e-02f, -1.30510673e-01f, 1.12431861e-01f,
  1.91791132e-02f, -4.02273200e-02f, 7.73751736e-02f, 9.74323377e-02f, -1.79262385e-02f, -1.08474880e-01f, 8.87518227e-02f, 9.60545167e-02f, -3.78323793e-02f, 3.03895604e-02f,
  2.49206871e-01f, 2.88143605e-01f, -1.30916387e-01f, -1.05718479e-01f, -1.04611702e-01f, 1.15544394e-01f, 7.56395310e-02f, 1.15715921e-01f, 4.56228107e-03f, 7.88992122e-02f,
  9.70967785e-02f, -3.90969962e-02f, 4.33338583e-02f, -8.84868205e-02f, -9.32891741e-02f, 1.82499960e-01f, 1.00217555e-02f, -2.01011211e-01f, -1.25223026e-01f, 1.80227026e-01f,
  -3.64690982e-02f, 7.46675208e-02f, -2.47214399e-02f, -2.20092442e-02f, 2.44990606e-02f, -1.02032848e-01f, -4.57061045e-02f, -2.70474758e-02f, 1.09618418e-01f, -2.81358268e-02f,
  2.51105964e-01f, -6.23032870e-03f, 3.85749131e-01f, 5.10072112e-01f, -3.13592076e-01f, -1.54410303e-01f, -7.33135790e-02f, -4.18616652e-01f, -2.77287215e-01f, -3.41682807e-02f,
  -5.88711321e-01f, 8.43455493e-01f, -7.88846910e-01f, 4.39530373e-01f, -2.25217357e-01f, -4.89849746e-01f, 1.50961474e-01f, 4.19506162e-01f, -1.31251127e-01f, -2.69846231e-01f,
  -1.62366390e-01f, -4.62581486e-01f, -1.80890989e-02f, -2.09561959e-01f, 2.77745038e-01f, 4.22685444e-01f, -2.36252367e-01f, 7.78603926e-02f, 8.93957376e-01f, 3.19290906e-01f,
  3.94372344e-02f, -1.22591816e-01f, 1.69667259e-01f, 1.68536082e-01f, -1.20026700e-01f, -3.82806249e-02f, 3.46575677e-01f, 8.61185789e-02f, 2.55954593e-01f, 4.14052233e-02f,
  1.86088830e-01f, 1.72745749e-01f, 1.70708448e-01f, 6.40788600e-02f, 1.11721508e-01f, 5.35914302e-02f, 1.76527843e-01f, -7.51947984e-02f, 9.92791206e-02f, 1.41089410e-01f,
  4.90497332e-03f, 5.78572741e-03f, 4.52411361e-02f, 2.47629136e-01f, -1.22133076e-01f, -1.39413271e-02f, 1.55224860e-01f, 2.04672754e-01f, 1.60937294e-01f, 8.93010013e-03f,
  7.44894668e-02f, -1.21138141e-01f, 1.00632291e-03f, 6.07486963e-02f, -8.37532207e-02f, 1.26773873e-02f, -1.01996049e-01f, -1.98575370e-02f, 1.17744163e-01f, -1.01766616e-01f,
  -1.05113566e-01f, -1.52513850e-02f, -2.50783712e-02f, -2.24816855e-02f, -1.42283484e-01f, 1.30646080e-02f, 9.42987017e-03f, 2.79354870e-01f, 1.05198100e-02f, -1.40814576e-03f,
  -1.13951964e-02f, 1.16156694e-02f, -1.39757141e-01f, 1.26731187e-01f, -5.13466522e-02f, -1.90513139e-03f, -9.81701612e-02f, 1.08552299e-01f, -8.73889551e-02f, -6.42115176e-02f,
  -5.49014986e-01f, -6.09751225e-01f, -1.71621501e-01f, 8.52918252e-02f, 7.96823204e-02f, 6.71683177e-02f, -1.74481168e-01f, 1.05975918e-01f, -5.79297356e-02f, -1.19806558e-01f,
  2.47065555e-02f, 1.61946744e-01f, 8.87594372e-03f, 8.52968320e-02f, 5.48781343e-02f, -8.30389857e-02f, -7.53389001e-02f, -5.65499254e-02f, -6.67621568e-02f, 1.41797028e-02f,
  -1.58393662e-02f, 3.74838971e-02f, 1.37393558e-02f, -4.35436256e-02f, 2.13363528e-01f, -1.07595377e-01f, 7.91441500e-02f, -1.53746677e-03f, 1.32688865e-01f, 9.99473333e-02f,
  2.35970199e-01f, -7.41979718e-01f, -8.71027946e-01f, -1.58907190e-01f, 7.19202995e-01f, 8.20761800e-01f, -5.25470823e-02f, 1.04882576e-01f, -7.22391665e-01f, 9.78917163e-03f,
  1.96844146e-01f, -4.05132025e-01f, -5.95484376e-01f, -1.28789201e-01f, 5.51693738e-02f, -6.36866689e-01f, 1.91135749e-01f, 6.64632469e-02f, -3.48684877e-01f, 8.90607089e-02f,
  -7.48997852e-02f, 3.37023467e-01f, -7.86920309e-01f, 4.00880665e-01f, 5.07580101e-01f, 1.25097126e-01f, 6.00238264e-01f, 1.16754510e-01f, 4.58922416e-01f, 1.81375206e-01f,
  -8.14588740e-03f, -3.08188587e-01f, -1.21543355e-01f, -1.98813826e-01f, 6.22308031e-02f, 3.14192116e-01f, 1.58075646e-01f, 2.08281666e-01f, -1.12037808e-01f, -1.20710202e-01f,
  2.02063799e-01f, 1.49127450e-02f, 2.10058130e-02f, -1.81767523e-01f, 5.12108952e-02f, 6.40961975e-02f, -1.26820356e-01f, -9.22284499e-02f, -1.66705161e-01f, -2.10990191e-01f,
  -2.29966953e-01f, 4.58842218e-02f, 1.19120747e-01f, 9.97190550e-03f, -1.98883012e-01f, -3.13175544e-02f, 1.03655092e-01f, 7.27834702e-02f, 1.55519471e-01f, 9.74865071e-03f,
  1.83728129e-01f, 1.49778202e-01f, 5.85897639e-03f, -7.67988041e-02f, -1.22896940e-01f, 8.69372189e-02f, 2.71620322e-02f, 2.40851417e-02f, -1.59777611e-01f, -2.05174908e-02f,
  8.98209810e-02f, 3.31304334e-02f, -4.36344296e-02f, 8.17597210e-02f, -2.73075365e-02f, -1.05991788e-01f, 2.09958747e-01f, 6.76102191e-02f, -5.41727096e-02f, 1.22552710e-02f,
  -3.17633301e-02f, 2.49618646e-02f, 2.36693881e-02f, 1.37295038e-01f, -4.95272875e-02f, -1.45497292e-01f, 5.22456653e-02f, -4.42043506e-02f, -1.53517693e-01f, 1.31401777e-01f,
  1.88181621e-05f, -4.94311936e-02f, -1.42052040e-01f, -1.39134256e-02f, -9.89303216e-02f, 2.98549205e-01f, -5.38327023e-02f, 9.08376947e-02f, 2.25664619e-02f, 1.53945880e-02f,
  2.65653163e-01f, 1.57778040e-01f, 3.09533894e-01f, -6.34638891e-02f, -6.44090623e-02f, 1.08153239e-01f, 6.42422736e-02f, 2.17709944e-01f, 2.96115816e-01f, 4.47399020e-02f,
  1.39733270e-01f, 1.77755162e-01f, -3.44065651e-02f, 8.20587724e-02f, 7.80594498e-02f, 1.00260235e-01f, 1.09560378e-01f, -5.79678006e-02f, 1.53082013e-01f, -1.15976624e-01f,
  3.44510585e-01f, -1.04508616e-01f, 5.85678279e-01f, 4.47086275e-01f, 4.49555159e-01f, 6.87587380e-01f, 5.60611129e-01f, 6.61327660e-01f, 1.13478577e+00f, -4.96545434e-01f,
  -4.61925238e-01f, -5.33686757e-01f, -1.66670829e-01f, -1.88936859e-01f, 5.58345973e-01f, 3.61532152e-01f, 4.79066133e-01f, 1.12813793e-01f, 3.83666575e-01f, -1.81042820e-01f,
  1.92986414e-01f, -6.19451940e-01f, -6.67872608e-01f, -6.97252691e-01f, -4.47906315e-01f, -2.64688462e-01f, -8.95360887e-01f, -6.32894561e-02f, -6.82611585e-01f, -4.58325818e-02f,
  -6.72814101e-02f, -9.78419110e-02f, -3.65043759e-01f, 1.35636600e-02f, 3.61079834e-02f, 6.55236766e-02f, -1.31966308e-01f, -1.08656123e-01f, 1.10052079e-01f, 1.08750593e-02f,
  -1.37699261e-01f, -1.85178250e-01f, -1.51953576e-02f, -1.71539500e-01f, 2.10840136e-01f, -7.78860748e-02f, 1.12082228e-01f, 1.54822394e-02f, -1.74104631e-01f, 5.77886626e-02f,
  6.35696724e-02f, 7.52005279e-02f, 9.95322540e-02f, 1.16972893e-01f, 8.97306576e-03f, -4.26910492e-03f, 1.53914481e-01f, -1.01921394e-01f, 6.44316375e-02f, 8.91570970e-02f,
  -3.84295695e-02f, 3.57171118e-01f, -5.15868254e-02f, -6.70843497e-02f, -1.18035963e-02f, 7.41612315e-02f, -6.33209869e-02f, -9.66146365e-02f, 1.12317681e-01f, -1.75390720e-01f,
  8.71919543e-02f, -1.17863350e-01f, 2.13557556e-01f, 8.10070634e-02f, -7.63100535e-02f, 8.67359042e-02f, -5.68538867e-02f, -1.09246280e-02f, 9.69793200e-02f, -1.05769977e-01f,
  5.69186918e-02f, 5.13387918e-02f, -9.30245072e-02f, 5.89068159e-02f, 1.18567973e-01f, 3.80011159e-03f, -1.05217829e-01f, 1.04429983e-01f, 2.11299192e-02f, -1.42889008e-01f,
  2.34739497e-01f, -1.18717849e-01f, -1.71083584e-01f, -1.42246664e-01f, -7.48028979e-02f, -7.63578340e-02f, 2.70021349e-01f, 8.35114811e-03f, 1.50508776e-01f, -1.63194686e-02f,
  6.55531585e-02f, -1.44650443e-02f, 6.68578874e-03f, 8.15912858e-02f, -7.00672641e-02f, 4.29469254e-03f, -8.72150660e-02f, -4.77513224e-02f, -5.18211089e-02f, -1.82197735e-01f,
  -2.17118219e-01f, 1.09346518e-02f, 5.60350604e-02f, -1.32022306e-01f, -1.87588364e-01f, -1.53365821e-01f, 3.86869237e-02f, 1.34944156e-01f, -5.30127361e-02f, -1.44775081e-02f,
  -7.61847258e-01f, -6.44060075e-01f, -3.23354214e-01f, 5.89127123e-01f, -4.78825510e-01f, -2.49902368e-01f, 2.72489488e-01f, -4.71383125e-01f, -2.09895238e-01f, 2.42147774e-01f,
  4.33777422e-01f, -2.92884231e-01f, -4.87011112e-02f, 7.96498716e-01f, 2.86019862e-01f, 3.91820937e-01f, 5.11569500e-01f, 3.42319369e-01f, -1.53971344e-01f, -5.13890624e-01f,
  4.39855531e-02f, 2.74587750e-01f, 4.23324436e-01f, -3.39325428e-01f, -3.38651150e-01f, -2.87353486e-01f, 3.65718693e-01f, -3.61435741e-01f, 4.04009998e-01f, 2.35314324e-01f,
  -1.88962534e-01f, -3.80803406e-01f, -3.48702148e-02f, -4.05514836e-02f, -1.10517994e-01f, -6.19668663e-02f, 5.34047261e-02f, 8.46366659e-02f, -5.23267174e-03f, -1.31089568e-01f,
  -5.87348603e-02f, -6.79088682e-02f, 2.71368548e-02f, 9.76382568e-02f, -2.01910809e-01f, -6.99710175e-02f, -6.71976013e-03f, 1.87956870e-01f, -2.23008901e-01f, -5.63514791e-02f,
  -5.50309680e-02f, 1.18786134e-02f, 9.39938948e-02f, 1.63597986e-01f, -2.01112498e-02f, 8.33057836e-02f, 5.79074845e-02f, -6.79930374e-02f, -1.48988649e-01f, 3.01955268e-02f,
  5.78622408e-02f, 1.33343413e-02f, -3.15783322e-02f, 1.10194497e-01f, -6.59405580e-03f, 1.10608526e-01f, 2.05938622e-01f, 1.15648903e-01f, -8.65469947e-02f, -8.02360568e-03f,
  -1.86205152e-02f, 1.59585543e-04f, -1.18471775e-02f, 8.25680718e-02f, 6.04148917e-02f, 1.08524412e-01f, -9.99776050e-02f, -6.16984926e-02f, 1.12010896e-01f, 1.30652830e-01f,
  5.59099279e-02f, -8.08249861e-02f, -7.02325329e-02f, -1.44943269e-02f, -8.06226954e-03f, -6.80313557e-02f, 9.14464071e-02f, -5.68048172e-02f, 1.92919716e-01f, -8.80640596e-02f,
  -8.56909037e-01f, -7.09615052e-01f, -1.02824844e-01f, 1.37262931e-02f, 9.28152278e-02f, -4.53962050e-02f, -8.20298567e-02f, -1.72877818e-01f, -2.36560509e-01f, -1.88227743e-01f,
  -7.52919540e-02f, 1.77676216e-01f, -1.91738650e-01f, 5.68624847e-02f, 3.19311507e-02f, -8.64279419e-02f, 1.06660254e-01f, 6.11320361e-02f, 1.00359239e-01f, -1.19250685e-01f,
  6.91660419e-02f, 1.09966081e-02f, 9.75357518e-02f, -3.00406162e-02f, 1.26895592e-01f, 7.99112767e-02f, -1.24342360e-01f, -5.51175103e-02f, -4.06268314e-02f, 1.06811062e-01f,
  1.33052945e-01f, -3.05177450e-01f, 8.41480792e-01f, 5.10497868e-01f, 9.98473018e-02f, -4.89635587e-01f, 4.12723601e-01f, 1.22112542e-01f, -3.08869839e-01f, -8.52012336e-01f,
  -7.86338991e-04f, 5.70365265e-02f, 5.18608153e-01f, -1.79691106e-01f, 7.09691823e-01f, -1.06678352e-01f, 8.47356468e-02f, 8.25988036e-03f, 1.60017148e-01f, 5.05464494e-01f,
  4.41827446e-01f, -2.65206575e-01f, 8.33849609e-01f, -5.14855683e-02f, 3.78564566e-01f, 1.83652386e-01f, 2.65958816e-01f, 4.47963685e-01f, -9.53824818e-02f, -1.28614038e-01f,
  -2.61710912e-01f, -5.27376346e-02f, 2.03276709e-01f, -1.33893162e-01f, 2.26126403e-01f, -5.27970307e-02f, 1.67898834e-01f, 1.70747891e-01f, 1.46129429e-01f, -1.92467831e-02f,
  6.31166399e-02f, 9.47582163e-03f, -2.90682446e-02f, 8.57254490e-02f, -1.78941175e-01f, 5.20201214e-03f, 1.10953473e-01f, 1.16943188e-01f, -1.81067418e-02f, 1.47771746e-01f,
  3.17976534e-01f, -1.52732795e-02f, 1.18705019e-01f, -7.67195895e-02f, 2.35566795e-01f, -3.20614241e-02f, -5.13487086e-02f, 1.88379928e-01f, -7.71160647e-02f, 2.13809274e-02f,
  -2.35078409e-01f, 4.38329093e-02f, 4.55506258e-02f, 3.72515135e-02f, -3.38125713e-02f, -6.99150637e-02f, 1.63647421e-02f, 1.36354137e-02f, 1.04034193e-01f, -4.22172658e-02f,
  8.47765878e-02f, 1.10263005e-01f, -9.87257510e-02f, -8.05712584e-03f, -1.02710187e-01f, -2.89420635e-01f, 2.28965253e-01f, -1.66013315e-02f, 1.08274490e-01f, 1.32717714e-02f,
  4.85798232e-02f, -7.93991312e-02f, 1.50881603e-01f, 5.27525768e-02f, -2.83690751e-01f, 1.25808597e-01f, 2.04256969e-03f, -7.58318184e-03f, 1.33507892e-01f, 2.14026481e-01f,
  -1.21473514e-01f, 1.13755740e-01f, 1.63980909e-02f, -1.86752319e-01f, -2.04982474e-01f, -1.74397063e-02f, -1.08987808e-01f, -3.65035944e-02f, 2.38542221e-02f, 9.43116006e-03f,
  4.86265533e-02f, 1.74660429e-01f, -2.16101944e-01f, -6.68742284e-02f, -2.05523502e-02f, 6.02659509e-02f, 3.69934812e-02f, -1.28561884e-01f, 4.89825048e-02f, 3.21037546e-02f,
  4.85239737e-02f, 8.62392969e-03f, -4.74540815e-02f, 1.95402764e-02f, -1.73840344e-01f, -1.06415255e-02f, -6.64667040e-02f, 3.66448276e-02f, -5.47749782e-03f, 5.58197610e-02f,
  -1.24866855e+00f, 2.36814037e-01f, 3.81857418e-02f, -3.39223117e-01f, 7.50077143e-02f, 9.82060850e-01f, 8.79791617e-01f, -1.76894873e-01f, -5.82110167e-01f, 3.60650271e-01f,
  2.88825065e-01f, -1.87198848e-01f, 5.17100990e-01f, 3.98338437e-01f, 7.72023737e-01f, 5.48640728e-01f, 4.05953407e-01f, 2.02382758e-01f, -2.10109770e-01f, -3.04064542e-01f,
  -1.84641838e-01f, 5.13269544e-01f, 4.25124973e-01f, -1.30960867e-01f, -3.12311668e-02f, -6.47508204e-01f, -1.69776008e-02f, 2.34852985e-01f, 1.76444888e-01f, 3.88706863e-01f,
  -3.84072989e-01f, -7.59394467e-01f, -1.11899421e-01f, -1.62683183e-03f, -5.78146055e-02f, -5.12619503e-02f, 6.02694750e-02f, 1.19626395e-01f, -6.38397485e-02f, -7.64068449e-03f,
  2.60586478e-02f, -1.01628281e-01f, -8.60120282e-02f, 4.17830609e-02f, -1.72628403e-01f, -1.41823322e-01f, 5.35813607e-02f, 2.98970509e-02f, -9.25540850e-02f, 8.92487615e-02f,
  1.37281761e-01f, 7.58436546e-02f, -7.65514672e-02f, 3.00513040e-02f, 1.33958697e-01f, -4.07012366e-02f, 2.95022260e-02f, 1.77503273e-01f, 1.07786089e-01f, -1.84957571e-02f,
  1.51274905e-01f, 4.00974564e-02f, 1.00080885e-01f, 5.88061512e-02f, 2.93299858e-03f, 4.77628736e-03f, 4.26247641e-02f, 2.03830143e-03f, -4.84741852e-02f, 1.43582955e-01f,
  -1.89587697e-01f, 2.18690336e-02f, -1.19731553e-01f, 4.41903286e-02f, -7.66222551e-02f, -1.67356580e-01f, 6.91606104e-02f, -1.74471930e-01f, -9.93365422e-02f, 5.11215441e-03f,
  -5.18193617e-02f, -1.00638032e-01f, 1.40568167e-01f, 1.07654063e-02f, -1.28721725e-02f, 3.48843448e-02f, -1.40292510e-01f, -1.42503195e-02f, 9.65136476e-03f, 1.06273860e-01f,
  -2.65950590e-01f, -4.38297838e-01f, -6.55058622e-02f, -9.13285464e-03f, 1.90908182e-02f, 9.80982631e-02f, -1.06118649e-01f, -4.36966345e-02f, 1.29237920e-01f, -3.59379896e-03f,
  -2.01008357e-02f, -1.51230916e-01f, -1.21626087e-01f, -1.29069060e-01f, 1.02722347e-01f, 1.45177782e-01f, 2.64847539e-02f, -1.38703912e-01f, 1.51743039e-01f, -4.18687239e-02f,
  -4.21673059e-02f, -6.30100444e-02f, 2.95135435e-02f, -1.55395374e-01f, -3.33015583e-02f, 4.84763719e-02f, -2.36797690e-01f, -8.32279921e-02f, 1.18763983e-01f, 7.66461417e-02f,
  -1.02696180e+00f, 3.01222771e-01f, -9.58679974e-01f, -3.97218555e-01f, 1.27202481e-01f, -1.99226454e-01f, 1.96696803e-01f, 1.45742744e-01f, -3.85793075e-02f, 8.70069861e-01f,
  5.58518708e-01f, -2.43419990e-01f, 7.68949449e-01f, -1.47904739e-01f, -1.09484088e+00f, 2.86734719e-02f, -3.53859961e-01f, -8.16992018e-03f, -2.48411223e-01f, 1.75507829e-01f,
  -3.64750981e-01f, 4.48193699e-01f, -5.57776213e-01f, 6.13966882e-01f, -1.11011781e-01f, -2.41376311e-02f, 3.62935066e-01f, 3.53372514e-01f, -2.86678731e-01f, -3.84753793e-01f,
  -5.03078215e-02f, 1.24805503e-01f, -2.20581070e-01f, -1.51046336e-01f, -8.64832625e-02f, 8.73183832e-02f, 7.27031454e-02f, -1.22276403e-01f, -8.06183666e-02f, -2.20591146e-02f,
  1.41415089e-01f, 1.74645260e-01f, -7.03718588e-02f, 1.31169856e-01f, -2.25164518e-02f, -1.00605614e-01f, -2.50499755e-01f, -1.64541155e-01f, 7.96759799e-02f, -2.13792324e-01f,
  -1.78383306e-01f, -1.06062301e-01f, -3.02742776e-02f, -1.73627213e-02f, -2.56325305e-01f, 7.83096068e-03f, -4.43725474e-02f, -1.43829778e-01f, 5.89228868e-02f, -2.17249826e-01f,
  -4.03013639e-02f, -6.63147941e-02f, 1.30450323e-01f, 4.81557986e-03f, -5.35690412e-02f, 6.08463511e-02f, 7.61177614e-02f, -1.54592069e-02f, -7.43575627e-03f, 1.42632321e-01f,
  1.40785351e-02f, -6.52086735e-02f, 1.82705626e-01f, -9.59875807e-02f, -7.86522180e-02f, -9.02927071e-02f, -5.44052534e-02f, 2.08221525e-01f, 8.61311797e-03f, -2.32170269e-01f,
  2.07968876e-01f, -1.15646571e-01f, -6.79319445e-03f, 9.78768542e-02f, 3.30780819e-02f, 1.66762547e-04f, 8.69055763e-02f, -8.77527818e-02f, -1.18168041e-01f, 1.06381848e-01f,
  1.51105553e-01f, 3.29032749e-01f, 6.47628754e-02f, 1.64555073e-01f, 1.26995817e-01f, -5.47207557e-02f, 1.91928614e-02f, -1.69361621e-01f, 3.89590524e-02f, 3.19936238e-02f,
  1.04865827e-01f, 1.41230971e-01f, 6.08949326e-02f, 1.94118377e-02f, 6.16439506e-02f, -7.64564946e-02f, 2.39608601e-01f, -1.47865996e-01f, 1.04588747e-01f, -6.42626584e-02f,
  1.15846666e-02f, 2.33229682e-01f, 2.84838639e-02f, 2.15316385e-01f, 2.04620421e-01f, 5.49241826e-02f, -3.28413560e-03f, 6.80447072e-02f, 1.86672322e-02f, 4.24903631e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.72124898e-01f, 9.27695453e-01f, 6.28360331e-01f, 4.70654964e-01f, 8.84217083e-01f, 6.79703534e-01f, 6.09661281e-01f, 5.38769603e-01f, 9.42255080e-01f, 8.30240965e-01f,
  2.23798677e-01f, 9.90514815e-01f, 8.93573880e-01f, 6.48655653e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.16185617e-01f, -2.31653787e-02f, -3.63789052e-02f, 3.52951773e-02f, -5.36613524e-01f, 9.36042219e-02f, 3.43027323e-01f, -4.75961596e-01f, -2.49441876e-03f, -2.81961352e-01f,
  -6.10942304e-01f, -4.37564790e-01f, 8.53335202e-01f, -7.20005035e-01f, -1.95883941e-02f, 2.16217741e-01f, -8.57985556e-01f, -3.99717033e-01f, -5.79642117e-01f, -7.14971006e-01f,
  -2.93343246e-01f, -1.00273311e+00f, -8.03331375e-01f, -5.67875504e-01f, 2.80900896e-01f, -2.30736777e-01f, -1.03295970e+00f, -5.67252159e-01f, 9.79205310e-01f, -5.80854416e-01f,
  7.69225359e-01f, 5.63486576e-01f, -3.87958944e-01f, -8.44104588e-01f, 8.49453434e-02f, 1.55550197e-01f, 6.89372480e-01f, -6.91814005e-01f, -5.04885256e-01f, 6.85983777e-01f,
  -7.19604015e-01f, -8.94246221e-01f, -2.95639724e-01f, -3.46184760e-01f, -1.13290501e+00f, 1.11419582e+00f, 1.43607587e-01f, -7.78127551e-01f, 9.93112624e-01f, -7.32439518e-01f,
  -3.87143135e-01f, -7.08418787e-01f, 1.66904747e-01f, -6.32536888e-01f, 3.77132803e-01f, -9.73068416e-01f, 6.90882504e-01f, -1.09120417e+00f, 6.96756721e-01f, -3.65386069e-01f,
  -1.66735873e-01f, -1.36114049e+00f, 4.93046314e-01f, -3.47151279e-01f, 1.47674400e-02f, -1.52981594e-01f, -5.06191850e-01f, -5.94058931e-01f, -7.18579650e-01f, 3.09065189e-02f,
  -2.17468783e-01f, -2.87652194e-01f, -9.42241400e-02f, 8.18687379e-01f, -4.61105019e-01f, 2.88265169e-01f, 1.01298299e-02f, 2.70902157e-01f, 4.41317737e-01f, 6.07672453e-01f,
  3.43659759e-01f, 6.30696476e-01f, -4.73221332e-01f, -1.10090137e+00f, -6.72188938e-01f, -5.11256039e-01f, 5.68915188e-01f, 1.25161689e-02f, 2.22670704e-01f, 6.99300766e-01f,
  6.74738526e-01f, -8.92202377e-01f, 6.37926340e-01f, -5.06203532e-01f, -2.27235913e-01f, -1.18535507e+00f, -1.74464971e-01f, -6.40085459e-01f, -1.96737237e-02f, -6.87176526e-01f,
  -1.13535911e-01f, -3.11037064e-01f, -7.83894733e-02f, -2.14314803e-01f, -3.37464642e-03f, 3.18975784e-02f, 1.65834919e-01f, 3.66024494e-01f, 4.95821327e-01f, -5.18635869e-01f,
  -5.70858657e-01f, 2.60036647e-01f, 1.54555276e-01f, -6.23002648e-01f, 7.13728666e-01f, -1.28200755e-01f, -4.34089929e-01f, 1.05213434e-01f, -2.94177383e-01f, 7.92365432e-01f,
  -8.47824395e-01f, -6.02613688e-01f, -9.74555194e-01f, -1.20012665e+00f, -4.60824579e-01f, -9.33609486e-01f, -3.13295960e-01f, 8.79279137e-01f, 1.84425294e-01f, 7.07287908e-01f,
  2.60494560e-01f, 3.97580594e-01f, -1.26298532e-01f, 2.15892613e-01f, -2.05062493e-03f, 4.94787335e-01f, 5.51550865e-01f, -6.03626132e-01f, 7.27024078e-01f, 1.07016301e+00f,
  -1.94420725e-01f, -7.27494478e-01f, 3.07638735e-01f, 7.23135173e-01f, -9.11848009e-01f, 4.34975058e-01f, 4.50906277e-01f, -7.12729633e-01f, -4.73981231e-01f, 1.00701606e+00f,
  -3.00404847e-01f, -4.49675024e-01f, 4.67433333e-01f, -7.94349432e-01f, -6.19781137e-01f, 6.04541115e-02f, -6.98379934e-01f, 3.16370428e-01f, 6.22210622e-01f, -6.51674747e-01f,
  -4.25622672e-01f, 3.92339438e-01f, 8.01184028e-02f, 5.65244794e-01f, 3.50419819e-01f, 3.62673908e-01f, 6.50039494e-01f, 3.54444206e-01f, -1.32989079e-01f, -9.40923512e-01f,
  -7.28702247e-01f, -1.17217290e+00f, -9.98657048e-01f, -1.07007492e+00f, 1.05156517e+00f, -9.78229403e-01f, 2.80548483e-01f, -8.02895129e-01f, -1.20946693e+00f, 7.87089944e-01f,
  1.05804116e-01f, -3.94710362e-01f, -5.38825333e-01f, -3.11659485e-01f, -5.98514020e-01f, -1.02622993e-02f, -7.72132397e-01f, 9.34103370e-01f, -5.82689643e-01f, -6.47507608e-01f,
  -1.19700789e-01f, 8.55131000e-02f, 2.19735906e-01f, 3.03881895e-02f, -3.93483043e-01f, 1.47542998e-01f, -5.56363583e-01f, 6.26408875e-01f, 4.56116080e-01f, -2.67890036e-01f,
  3.81639332e-01f, 9.03000176e-01f, -8.88445258e-01f, 5.56518734e-01f, 5.79736866e-02f, 9.15364683e-01f, -3.32477778e-01f, 1.01856339e+00f, 6.95916116e-01f, 3.71949047e-01f,
  -9.31633353e-01f, -1.21330597e-01f, -1.82609305e-01f, -5.21574140e-01f, -3.33001502e-02f, 8.95266950e-01f, -5.93646705e-01f, -4.66017604e-01f, -2.11362451e-01f, 8.61839116e-01f,
  -1.97582662e-01f, 3.43624622e-01f, -1.23233306e+00f, -6.47732854e-01f, -4.58012432e-01f, -5.38040221e-01f, -2.87243664e-01f, -1.43758103e-01f, -7.82579407e-02f, -6.16311014e-01f,
  -6.61085308e-01f, -2.94465184e-01f, 1.08101971e-01f, 4.62722123e-01f, 1.34721681e-01f, -4.39810067e-01f, 2.34579936e-01f, 6.50733709e-01f, -3.11721653e-01f, 4.03849274e-01f,
  -1.01113811e-01f, -2.55268514e-01f, 4.48760182e-01f, 4.22218829e-01f, 7.79726744e-01f, 5.77431977e-01f, -4.83594425e-02f, -7.90789068e-01f, -4.95286584e-01f, -4.39239815e-02f,
  -7.19808400e-01f, 1.22490592e-01f, -2.85344690e-01f, -9.41253126e-01f, -8.88628006e-01f, -5.69983780e-01f, -1.79179967e-03f, 3.23640241e-04f, 3.67902189e-01f, 1.92938581e-01f,
  -2.48601437e-01f, -3.59438032e-01f, -1.80370063e-01f, -5.47729313e-01f, -3.88773754e-02f, 4.92034376e-01f, -1.89314827e-01f, -3.52043927e-01f, 7.53632307e-01f, -3.25179964e-01f,
  4.81804430e-01f, -3.40981692e-01f, 3.49009514e-01f, 2.71304394e-03f, -5.54492652e-01f, 5.20325005e-01f, -7.85430610e-01f, -4.15312618e-01f, 7.25382864e-01f, -4.77598280e-01f,
  4.40650314e-01f, -5.46819568e-01f, -6.30660892e-01f, -5.85875213e-01f, -4.01467651e-01f, 8.80216241e-01f, -8.61921608e-01f, -7.04446673e-01f, 2.62188613e-01f, 2.08655864e-01f,
  4.15464729e-01f, 3.71460617e-02f, 2.02991828e-01f, -1.27372071e-01f, -5.77018976e-01f, 8.34326670e-02f, -3.81474674e-01f, 5.26587546e-01f, 7.66177475e-01f, -1.77623421e-01f,
  -5.40946960e-01f, 4.19164687e-01f, -8.38812053e-01f, 4.20098364e-01f, 7.68943906e-01f, 5.56756556e-01f, -6.68554604e-01f, -1.21857703e+00f, 9.50391054e-01f, -2.69424617e-01f,
  -1.16033280e+00f, -8.39153111e-01f, -1.18575990e+00f, 2.07626820e-01f, 1.63130969e-01f, -2.80168653e-02f, 9.84253138e-02f, 7.86765218e-01f, 5.96383929e-01f, -7.94993520e-01f,
  4.56134975e-01f, 2.66215295e-01f, -1.32738292e-01f, -1.35133669e-01f, 4.80482936e-01f, 2.69976377e-01f, 2.33960614e-01f, -4.74787131e-02f, 3.95456344e-01f, -1.65303349e-01f,
  8.60971868e-01f, 6.28384292e-01f, 7.23236799e-01f, 1.21672861e-01f, -7.40607321e-01f, -2.86898762e-01f, -1.02928102e+00f, 3.69646996e-01f, -7.00962067e-01f, -1.43615335e-01f,
  -6.91809595e-01f, -4.83045101e-01f, 5.93617618e-01f, -1.06392634e+00f, -4.61634219e-01f, -4.63824868e-01f, 1.02649307e+00f, -3.00181150e-01f, -7.62931526e-01f, -2.41402656e-01f,
  -6.43166304e-01f, 6.05793715e-01f, 3.30210805e-01f, 3.15050513e-01f, 2.27111161e-01f, 2.45883569e-01f, 1.95205435e-01f, 3.40369642e-01f, -1.01835601e-01f, 3.56531560e-01f,
  -3.43206614e-01f, 4.73185033e-01f, 2.93570280e-01f, 5.96227264e-03f, -8.14481899e-02f, -4.30973709e-01f, 1.52952701e-01f, -6.36533320e-01f, -5.18845558e-01f, 6.78056657e-01f,
  8.00231814e-01f, 7.68427968e-01f, -1.10207307e+00f, -8.33041668e-01f, -4.98007357e-01f, 2.48129293e-01f, -4.87755269e-01f, 9.46057737e-01f, -4.26623225e-01f, -3.35037798e-01f,
  -7.82254636e-01f, -7.18984678e-02f, -7.90206075e-01f, -7.96179771e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.08329290e-01f, 9.48841423e-02f, -3.01964507e-02f, 1.20128356e-01f, -1.17035201e-02f, 2.73444027e-01f, 5.93843199e-02f, -3.75202119e-01f, -2.23081037e-01f, 8.00522268e-02f,
  7.66497925e-02f, -5.54301627e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    