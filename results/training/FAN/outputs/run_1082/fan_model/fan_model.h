/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.39582002e-01f, 2.14235246e-01f, 1.75032705e-01f, -1.19631000e-01f, 1.09411322e-01f, 1.38706163e-01f, 1.20109320e-01f, 3.92334759e-02f, -4.70917448e-02f, 9.29628089e-02f,
  4.37742174e-02f, -5.95778078e-02f, -1.41205445e-01f, 6.33276347e-03f, -9.29897055e-02f, 2.79915094e-01f, 1.33320093e-01f, -4.29379568e-03f, -2.55410284e-01f, -7.81479776e-02f,
  -2.82913242e-02f, -1.44903734e-01f, -2.06227094e-01f, -1.13016754e-01f, 1.84022099e-01f, 1.01677820e-01f, 2.10479975e-01f, 1.02437079e-01f, 1.23689689e-01f, 2.47858047e-01f,
  1.09849401e-01f, 1.08447306e-01f, 7.32077882e-02f, 9.52674747e-02f, 6.07763045e-02f, 1.03861459e-01f, 1.04468167e-01f, 8.26441720e-02f, 2.33901013e-02f, 7.42132664e-02f,
  7.90784806e-02f, -1.94830615e-02f, 1.82709977e-01f, 8.27804357e-02f, 3.21112052e-02f, 1.30267054e-01f, 5.25322631e-02f, 9.21453610e-02f, 6.59273788e-02f, 1.53729528e-01f,
  1.33228526e-01f, 1.22417696e-01f, 1.01531662e-01f, 1.18312515e-01f, 9.40450430e-02f, 5.51194772e-02f, 1.69484690e-01f, 9.12818909e-02f, 5.64881451e-02f, 3.22012067e-01f,
  4.47017513e-02f, -6.61871731e-02f, -6.40421137e-02f, -1.56845570e-01f, -6.01278543e-02f, 3.93096842e-02f, 3.71131189e-02f, -1.90994814e-02f, -6.97086304e-02f, -4.37386855e-02f,
  -4.30391990e-02f, -7.09990337e-02f, -8.08295012e-02f, -1.69052966e-02f, 6.60740063e-02f, 3.20754610e-02f, -4.54621613e-02f, 6.27363697e-02f, -4.67068739e-02f, -6.32971898e-02f,
  5.68307713e-02f, -1.97730102e-02f, -3.63079719e-02f, 2.38601752e-02f, 2.25499477e-02f, -6.87633604e-02f, 1.86139848e-02f, 7.41377613e-03f, -1.15786523e-01f, -8.40647072e-02f,
  -3.68351899e-02f, -1.19156137e-01f, 2.27426395e-01f, 1.19962208e-01f, 7.17688426e-02f, -5.00726141e-03f, 7.95486197e-02f, 5.35498448e-02f, 5.55283837e-02f, 8.47889110e-02f,
  4.35652062e-02f, -8.85669142e-03f, 3.42989303e-02f, 5.66525236e-02f, 8.49446878e-02f, 1.05102167e-01f, 2.85019726e-02f, 4.53912318e-02f, 4.78396229e-02f, 2.25325227e-02f,
  -1.63007379e-02f, 9.70518962e-02f, 1.18757021e-02f, 1.16479285e-01f, 1.38147920e-01f, 1.25143155e-01f, 1.21026404e-01f, 1.67747691e-01f, 9.62222368e-03f, 1.77419767e-01f,
  4.81133834e-02f, 3.37059468e-01f, 9.97937471e-02f, -2.72304285e-02f, 3.46610099e-02f, 9.65921879e-02f, 2.86971778e-01f, -1.01561621e-02f, -9.59774554e-02f, 1.37084618e-01f,
  1.30849272e-01f, -1.74808383e-01f, -2.63744026e-01f, -2.26044685e-01f, -1.04198061e-01f, 6.42425567e-02f, 1.33323735e-02f, -3.02371144e-01f, -3.61968040e-01f, -7.66368210e-02f,
  -8.50621052e-03f, -1.12728573e-01f, -2.22467080e-01f, -8.38748515e-02f, 1.36200443e-01f, -1.39132351e-01f, 1.44344226e-01f, 2.87281275e-02f, 9.25995111e-02f, 1.69304594e-01f,
  1.20987765e-01f, 1.43561885e-02f, -1.11554049e-01f, 1.49025200e-02f, 1.95663162e-02f, -4.46464755e-02f, 2.10051257e-02f, 2.88348105e-02f, 4.40687127e-02f, 2.42577158e-02f,
  -5.43063618e-02f, -1.67244137e-03f, -1.00001551e-01f, -6.37198240e-02f, -3.14813592e-02f, -4.07763869e-02f, -5.60371503e-02f, -9.36540961e-02f, 4.56872545e-02f, 1.04352124e-01f,
  -6.43331483e-02f, 9.17816162e-02f, 1.59719706e-01f, -3.21516357e-02f, -4.10116129e-02f, -7.05076531e-02f, 1.36829183e-01f, -2.46045329e-02f, 2.45084846e-03f, 2.15136439e-01f,
  4.17351797e-02f, 4.75103315e-03f, 4.60058711e-02f, 5.18729612e-02f, -3.36979069e-02f, 2.64692735e-02f, -1.12307899e-01f, 4.44886014e-02f, 2.75256042e-03f, 4.07030284e-02f,
  -3.87937166e-02f, 7.20449015e-02f, -2.85783075e-02f, 6.49799872e-03f, -9.37465206e-02f, 2.68970691e-02f, -5.04978485e-02f, 5.38123325e-02f, -6.99573532e-02f, -1.47239910e-02f,
  -1.17345937e-02f, -1.77486967e-02f, -9.66592431e-02f, -5.21532074e-02f, -5.02991006e-02f, -5.70929572e-02f, 1.24741886e-02f, 1.46335531e-02f, 7.88761228e-02f, -7.79059716e-03f,
  7.46642128e-02f, -4.58303392e-02f, -1.08093228e-02f, -5.92811918e-03f, 2.19267625e-02f, 3.34303826e-02f, -5.21905757e-02f, -1.33739703e-03f, -5.02750371e-03f, 1.49731766e-02f,
  7.16106147e-02f, -1.02006815e-01f, 6.23693429e-02f, -8.18310678e-03f, -1.90089885e-02f, -6.25387505e-02f, 1.05428755e-01f, -1.00947283e-02f, 1.69095490e-02f, 1.93017926e-02f,
  9.37470943e-02f, 5.29574715e-02f, 9.33855549e-02f, 3.52423489e-02f, 4.59763110e-02f, -4.45336811e-02f, 7.03375181e-03f, 1.03531279e-01f, -4.64681489e-03f, 3.34902197e-01f,
  3.84480447e-01f, 1.92379519e-01f, 5.46004251e-02f, 1.37700155e-01f, -9.46053956e-03f, -7.41451383e-02f, 1.69501677e-01f, 4.97718807e-03f, -2.59621372e-03f, 1.59869924e-01f,
  2.41446346e-02f, -1.82665020e-01f, -2.09069937e-01f, -1.04544483e-01f, -2.38860026e-02f, 1.71087578e-01f, 1.56994268e-01f, -1.06198221e-01f, -9.34469476e-02f, -7.49894138e-03f,
  6.66167438e-02f, 1.61289573e-01f, 7.51002058e-02f, 7.65333846e-02f, 2.51683574e-02f, -1.35290414e-01f, 1.04531236e-01f, 1.38090655e-01f, 4.16683108e-02f, 2.10233182e-01f,
  3.99669446e-02f, 2.14932516e-01f, -1.18338801e-02f, 1.01632699e-02f, 4.55578044e-03f, -1.59112585e-03f, 2.47850120e-02f, 3.04471496e-02f, -1.33644538e-02f, 1.48939401e-01f,
  3.15751843e-02f, 8.72323960e-02f, -5.10214381e-02f, 6.55190498e-02f, 4.10207361e-02f, 9.03035700e-03f, 1.37063980e-01f, 6.40103668e-02f, 6.98002055e-03f, 1.25577720e-02f,
  7.26882070e-02f, 1.12064168e-01f, 9.89646241e-02f, 7.88034275e-02f, 5.85560054e-02f, 7.48973861e-02f, 6.18205704e-02f, 7.68660381e-02f, 1.34508545e-02f, 1.75928503e-01f,
  -4.12239991e-02f, 1.21513503e-02f, -1.27545923e-01f, 8.41093659e-02f, -9.96981934e-02f, -1.11909792e-01f, -6.54128417e-02f, -9.30037647e-02f, -8.94606560e-02f, 1.52393361e-03f,
  -1.23108566e-01f, 5.42623783e-03f, -4.34252359e-02f, -2.37619150e-02f, -7.15855956e-02f, 1.50676044e-02f, -2.89013740e-02f, 3.49522335e-03f, 7.21370801e-02f, 1.54019594e-02f,
  -7.10399002e-02f, -6.28872123e-03f, -2.59180199e-02f, 1.85069367e-02f, -5.58890253e-02f, -8.65666047e-02f, 2.08790414e-02f, -1.17845364e-01f, 1.49344280e-02f, 6.55878559e-02f,
  -1.60725741e-03f, -1.02081560e-01f, 1.90497041e-02f, -2.09577847e-02f, -1.96596663e-02f, 2.48021092e-02f, 3.32467631e-02f, 8.56615379e-02f, 6.11096844e-02f, 1.83896814e-02f,
  3.51800285e-02f, 5.38570061e-02f, 7.20564835e-03f, 4.51928005e-03f, 5.00329165e-03f, 5.01927435e-02f, -1.02961445e-02f, -6.31666183e-03f, 2.34014615e-02f, 8.90011415e-02f,
  1.02303073e-01f, 3.77808884e-02f, 2.59326939e-02f, -3.66384685e-02f, 5.01137674e-02f, -1.42256217e-02f, -8.36331397e-02f, -8.21671262e-03f, -2.78598238e-02f, 8.04139003e-02f,
  4.93380517e-01f, -8.59672129e-02f, 9.38317850e-02f, 1.48374215e-01f, -9.57210436e-02f, -2.14918062e-01f, -1.80179670e-01f, 2.74223220e-02f, 1.62968189e-01f, 4.95657232e-03f,
  3.77146783e-03f, -3.01942714e-02f, -2.48376746e-02f, 3.33826840e-02f, -6.04457036e-02f, -4.14485820e-02f, 2.96249669e-02f, 5.07871853e-03f, 1.12528965e-01f, -4.40424047e-02f,
  -5.76241761e-02f, -5.87649047e-02f, 7.74682313e-02f, -5.64361364e-02f, 9.58856195e-03f, 5.50435819e-02f, 5.96879199e-02f, 4.21401486e-02f, -1.04104932e-02f, 2.40536290e-03f,
  2.90826380e-01f, 3.36370058e-02f, -1.04654901e-01f, -6.69024363e-02f, 1.88125353e-02f, 7.29719400e-02f, 1.95863210e-02f, 4.28022966e-02f, -3.68757569e-03f, 6.84672967e-03f,
  -2.25428189e-03f, 3.38385217e-02f, -3.41852903e-02f, 2.02340744e-02f, 8.15640688e-02f, 3.38788629e-02f, 7.29656871e-03f, 3.41575593e-02f, -4.88580354e-02f, -3.52191627e-02f,
  -1.66151002e-01f, -6.98138997e-02f, -4.40885834e-02f, -3.66607420e-02f, 2.43872940e-03f, 5.95374126e-03f, 8.77372362e-03f, -5.08765178e-03f, 2.83690449e-02f, 3.52537557e-02f,
  -7.03500770e-03f, -2.48744991e-02f, -4.93403934e-02f, 2.06640046e-02f, 2.03302782e-03f, 8.23215544e-02f, -2.66409246e-03f, 2.25735251e-02f, 1.95258390e-02f, 1.15003474e-02f,
  5.73156364e-02f, 2.60646101e-02f, 1.60193425e-02f, 2.58051194e-02f, 9.13254991e-02f, 5.54379262e-03f, -1.87293743e-03f, -1.71616357e-02f, 9.94260386e-02f, 2.86285970e-02f,
  -4.73753400e-02f, -2.87122130e-02f, 4.70046625e-02f, 2.83614057e-03f, -4.18497669e-03f, 4.35851887e-02f, 2.69259252e-02f, -2.82878578e-02f, -2.08515171e-02f, -5.08764610e-02f,
  2.51021445e-01f, -1.49529487e-01f, 1.40342295e-01f, -2.70189401e-02f, -1.33576235e-02f, -4.81789224e-02f, 2.88268477e-02f, 1.29522700e-02f, 7.20765814e-02f, -6.71045156e-03f,
  1.43982330e-02f, -2.53205076e-02f, 8.07828009e-02f, -9.79822800e-02f, -4.57970332e-03f, 6.14837976e-03f, 5.33587346e-03f, 2.40387153e-02f, 5.40137403e-02f, 6.99753538e-02f,
  -5.49103059e-02f, 2.85789464e-02f, 1.42595008e-01f, 2.58220807e-02f, 6.26513734e-02f, 1.02813147e-01f, 2.47607455e-02f, 7.36409575e-02f, 2.36048661e-02f, 2.37982243e-01f,
  -1.97461378e-02f, -1.88093349e-01f, -1.94523931e-01f, -9.30610895e-02f, -5.12531176e-02f, -4.59857695e-02f, -1.19411401e-01f, -6.12855190e-03f, -4.77992408e-02f, -1.86035454e-01f,
  6.24751225e-02f, 1.99641198e-01f, 1.16315156e-01f, 1.27849072e-01f, 5.34791090e-02f, -2.67567396e-01f, -1.86934695e-01f, 1.05036706e-01f, 2.28476942e-01f, 1.58050701e-01f,
  6.59593521e-03f, -9.46713910e-02f, 5.54076917e-02f, 4.06061858e-02f, -2.17856497e-01f, -2.45329700e-02f, -1.32203847e-01f, -1.71349704e-01f, -3.74724232e-02f, -3.84647280e-01f,
  -7.44974092e-02f, -4.96867858e-02f, 3.48867774e-02f, 8.50648433e-02f, -7.95970708e-02f, 8.09461698e-02f, -2.17046365e-02f, -3.77112851e-02f, -5.00450283e-02f, -1.08284771e-01f,
  -8.66227075e-02f, 3.61825377e-02f, -1.24946594e-01f, 2.22086650e-03f, -5.01653664e-02f, -8.90555754e-02f, -3.26630250e-02f, -2.70467009e-02f, -4.88102809e-02f, -9.11640599e-02f,
  3.04671028e-03f, -2.60281619e-02f, -1.10655107e-01f, -8.87303799e-02f, 4.42592092e-02f, -8.15594643e-02f, -9.50780511e-02f, -1.06158920e-01f, -5.06844483e-02f, -6.73059225e-02f,
  3.94354165e-02f, -2.07027630e-03f, 1.07680924e-01f, -8.89913067e-02f, 2.29924303e-02f, -3.06744985e-02f, -5.81811890e-02f, -6.47277236e-02f, 2.00073626e-02f, 2.35390267e-04f,
  -2.01870240e-02f, 9.08804238e-02f, 1.49170347e-02f, 6.92319358e-03f, 1.78934156e-03f, 3.10625299e-03f, 4.04424369e-02f, 3.96648422e-02f, 5.63526005e-02f, -4.98899259e-02f,
  -5.23522422e-02f, -2.73327716e-02f, -5.02719060e-02f, -2.58202385e-03f, -7.71338493e-02f, 9.56451371e-02f, 8.29070732e-02f, 7.18212780e-03f, 4.38025333e-02f, 8.62188488e-02f,
  1.57834440e-01f, 1.47216424e-01f, -7.01056048e-02f, 4.61979024e-02f, 2.57884129e-03f, 4.67064120e-02f, -3.02758999e-02f, 4.03939039e-02f, -1.98926628e-02f, 6.57487363e-02f,
  4.77949679e-02f, 3.52784954e-02f, 3.08181792e-02f, -1.37212295e-02f, 1.79049242e-02f, -5.33487722e-02f, 3.74383852e-02f, 1.36858560e-02f, 2.78100986e-02f, 5.16478345e-02f,
  -4.64208238e-02f, 6.14953525e-02f, -1.56331919e-02f, 2.88630147e-02f, -3.84363271e-02f, 4.06074990e-03f, 1.45009756e-02f, 4.51991484e-02f, 1.53658083e-02f, -7.41271749e-02f,
  3.53683621e-01f, -1.34917647e-01f, 2.20847115e-01f, -7.97222257e-02f, -6.16193488e-02f, 2.15487644e-01f, 2.44705617e-01f, 1.82813648e-02f, -1.63895369e-01f, -6.34338930e-02f,
  -8.55888277e-02f, -1.43646151e-01f, -7.95891583e-02f, 7.43882582e-02f, 1.80692822e-01f, 5.72932921e-02f, 1.95501577e-02f, 2.84002632e-01f, 3.24529022e-01f, 1.87611014e-01f,
  -2.23302603e-01f, -1.36109933e-01f, 9.62263346e-03f, -9.00319740e-02f, -1.58321783e-01f, -1.14936605e-01f, -4.85799611e-02f, -7.52070993e-02f, 5.26528135e-02f, -1.71350930e-02f,
  3.12314868e-01f, 1.90578371e-01f, -8.65108296e-02f, -2.59509552e-02f, -9.09591559e-03f, 1.79975182e-02f, -3.90307605e-02f, 3.34128030e-02f, -2.45311297e-02f, -2.33472269e-02f,
  -3.99745442e-02f, 7.30305314e-02f, 8.43190104e-02f, -6.75907508e-02f, 1.15428522e-01f, 9.55230296e-02f, -3.10852053e-03f, 9.75932553e-02f, 2.02669233e-01f, 1.00415312e-01f,
  -9.62225199e-02f, 3.70951220e-02f, 1.91210970e-01f, 1.33505970e-01f, 9.73347425e-02f, 1.23360388e-01f, 3.78646851e-02f, 1.90850168e-01f, 1.66760370e-01f, -6.87824637e-02f,
  -8.84563699e-02f, 3.99276800e-02f, 9.10682604e-03f, 1.67592987e-02f, -9.54315588e-02f, 7.41294846e-02f, -1.21860271e-02f, 2.18808688e-02f, 3.28059830e-02f, -1.00840218e-01f,
  -5.87879382e-02f, 5.29049449e-02f, -3.43882591e-02f, -5.05755544e-02f, -3.82712148e-02f, 5.31435087e-02f, -5.80040598e-03f, -3.20550310e-03f, 1.06438091e-02f, 2.96694320e-02f,
  -2.07127482e-02f, -2.39522047e-02f, 3.85892950e-03f, 4.96359766e-02f, -5.79429120e-02f, 5.69387265e-02f, 1.69196241e-02f, -4.23133150e-02f, -1.34678632e-01f, -3.48452367e-02f,
  -2.36020267e-01f, 9.99121070e-02f, -1.54329287e-02f, 3.48455645e-02f, 1.18692517e-01f, 2.84734648e-02f, 5.73998876e-02f, 7.53809884e-02f, 2.51206495e-02f, 3.04203909e-02f,
  1.66332603e-01f, 1.05042659e-01f, -3.51339467e-02f, 1.36047425e-02f, -6.72795400e-02f, 3.48551199e-02f, -4.35433276e-02f, 4.95241396e-03f, 1.42343016e-02f, 4.38368767e-02f,
  -1.01490580e-01f, 1.52254505e-02f, 1.37070313e-01f, 1.08027704e-01f, 4.54768650e-02f, 3.30314338e-02f, 4.64681871e-02f, 7.39178434e-02f, 1.76469833e-01f, -1.07185371e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.67183936e-01f, -1.32674217e-01f, 2.42355634e-02f, -5.12715518e-01f, -1.51343733e-01f, -8.27876776e-02f, -1.77993611e-01f, -4.82684784e-02f, -1.55744672e-01f, -3.38065863e-01f,
  -9.62560549e-02f, 1.32114487e-02f, 8.35618004e-02f, 1.12581164e-01f, -1.35635599e-01f, -1.65440887e-01f, -2.71211952e-01f, -1.06447347e-01f, 1.72021821e-01f, 1.48963155e-02f,
  -4.57576700e-02f, -2.20515788e-01f, -9.70400870e-02f, 4.66787480e-02f, -1.11971069e-02f, 7.95200542e-02f, 9.75184664e-02f, -7.72387311e-02f, 9.68556255e-02f, -1.03383653e-01f,
  4.58315127e-02f, 5.65945916e-02f, 9.91648734e-02f, -1.44795626e-01f, -2.64604054e-02f, -1.75255835e-02f, -1.17249124e-01f, 1.56245567e-03f, 4.53936420e-02f, 6.88976794e-02f,
  -9.06921644e-03f, -2.04058979e-02f, -2.03826632e-02f, -7.05573857e-02f, -1.04058728e-01f, -1.01224162e-01f, -8.61880034e-02f, 3.87775190e-02f, 1.90753669e-01f, 5.06600216e-02f,
  -6.84963539e-02f, 4.68706675e-02f, 1.49459764e-01f, 1.17510773e-01f, 1.88650563e-01f, -1.50041291e-02f, 2.45670676e-01f, 1.89969003e-01f, 2.14738637e-01f, 4.97529022e-02f,
  -1.80835798e-02f, 4.09055352e-02f, 1.43606635e-02f, 3.17207463e-02f, 6.99829832e-02f, -7.55725056e-02f, -9.79026407e-03f, 6.10594675e-02f, 8.42981488e-02f, -4.48105410e-02f,
  -6.14394061e-03f, 2.61331201e-02f, 7.33829811e-02f, -1.16916031e-01f, 4.71658856e-02f, -8.52182135e-02f, -8.67884681e-02f, -8.81266035e-03f, 1.04375139e-01f, -2.41950043e-02f,
  -7.88583141e-03f, 9.03132334e-02f, -1.72756501e-02f, 8.94336104e-02f, -8.34026784e-02f, -7.37658963e-02f, -4.66709584e-02f, 4.38643806e-02f, -6.96599782e-02f, -3.74708474e-02f,
  -1.19357534e-01f, 1.30825654e-01f, -1.73767686e-01f, 1.26213906e-02f, -1.59036264e-01f, 1.17771618e-01f, -8.59489962e-02f, -4.98940498e-02f, -7.77643919e-02f, -3.93604785e-02f,
  -5.66461906e-02f, -2.37933360e-02f, -7.02160671e-02f, -4.14990783e-02f, -1.79398470e-02f, -9.94172692e-02f, -1.85734943e-01f, -8.50631371e-02f, 6.97724298e-02f, 1.84606779e-02f,
  2.54657064e-02f, 1.46511169e-02f, -4.51209024e-02f, 1.83205027e-02f, 1.41953379e-01f, 1.07698357e-02f, -2.77205370e-02f, 6.77698702e-02f, -4.94483337e-02f, -4.22122255e-02f,
  3.47392738e-01f, 2.34484613e-01f, 3.24476093e-01f, 7.25626647e-02f, 1.35106146e-01f, 3.05795223e-01f, 2.22702920e-01f, 1.97079092e-01f, -3.25562246e-02f, -1.11130299e-02f,
  1.88968778e-01f, -1.14791967e-01f, -8.40613793e-04f, -9.56929028e-02f, 3.37792560e-02f, -1.05907805e-01f, -1.50707111e-01f, 3.20731774e-02f, 9.45722163e-02f, 3.84701081e-02f,
  -6.47888333e-02f, -1.02774777e-01f, 5.83622754e-02f, -5.23917116e-02f, -2.27974236e-01f, -2.46967122e-01f, -5.00263609e-02f, 6.01831935e-02f, 5.85090220e-02f, -3.80287200e-01f,
  5.65520711e-02f, 2.28527308e-01f, -1.44281328e-01f, -2.11810872e-01f, 7.93825835e-02f, -1.83480978e-01f, 2.23193225e-03f, -4.38224673e-02f, -1.21725969e-01f, -2.48484574e-02f,
  5.62570617e-03f, 1.83655005e-02f, 1.06640302e-01f, -5.49121723e-02f, -5.33911493e-03f, -5.04004722e-03f, -9.40833837e-02f, 6.56749159e-02f, 7.41752535e-02f, 4.61170860e-02f,
  -4.49127816e-02f, 1.84372410e-01f, 1.53826162e-01f, 1.37140471e-02f, 1.35778800e-01f, 3.93539369e-02f, 3.43884379e-02f, -7.11064562e-02f, 1.65217981e-01f, -9.94751751e-02f,
  -3.01666446e-02f, 6.45645931e-02f, 7.71885738e-02f, -5.34588322e-02f, -3.24494280e-02f, -2.37365905e-02f, -1.17258638e-01f, -1.01897188e-01f, -6.01173453e-02f, 9.50073972e-02f,
  1.38709590e-01f, 1.14608429e-01f, 1.39019325e-01f, 9.80193019e-02f, -2.16066409e-02f, -9.57580935e-03f, 1.02405347e-01f, -5.18568419e-02f, 1.16132915e-01f, 8.68773758e-02f,
  2.33938824e-02f, 1.18956998e-01f, 6.57856986e-02f, 5.71520589e-02f, 5.24267741e-03f, 9.56148058e-02f, -3.22005451e-02f, 8.45054537e-02f, 1.34437522e-02f, 1.09286427e-01f,
  -2.49292165e-01f, 2.26768792e-01f, -1.66063517e-01f, -1.69075727e-01f, -6.69722334e-02f, -8.43203887e-02f, -1.03177324e-01f, -5.72764166e-02f, -1.82378516e-01f, -1.00370899e-01f,
  2.44097766e-02f, -4.24953327e-02f, 6.45080954e-02f, 5.60805835e-02f, -3.84480543e-02f, -8.51416737e-02f, -8.37939307e-02f, -5.40792756e-02f, 1.61870394e-03f, -1.23801485e-01f,
  -1.09899797e-01f, 1.34968638e-01f, 1.50292799e-01f, -1.46981170e-02f, 6.28553778e-02f, 9.00918897e-03f, -8.00104588e-02f, -4.39622886e-02f, 5.40963449e-02f, -7.97027349e-02f,
  -2.17229590e-01f, -2.74101198e-01f, -7.70563930e-02f, 3.86100113e-02f, 7.63003379e-02f, -4.59901430e-02f, -1.65251777e-01f, 1.25989467e-02f, 2.06781074e-01f, -2.06573844e-01f,
  1.03073277e-01f, 4.76479642e-02f, -1.99602529e-01f, -1.87566131e-01f, -2.44133085e-01f, -4.23970968e-01f, -3.83654207e-01f, -2.48876989e-01f, -6.27402067e-02f, 1.90684125e-01f,
  -6.04883826e-04f, 4.07037996e-02f, 1.94331780e-02f, -5.54927997e-02f, 7.52674565e-02f, 3.37388590e-02f, -6.21685460e-02f, -7.57680088e-02f, -1.37470275e-01f, -1.37845695e-01f,
  -2.82951802e-01f, 9.15372670e-02f, 3.22187282e-02f, -1.06678456e-01f, 4.89337072e-02f, 2.31235716e-02f, -2.31711008e-02f, -2.09431536e-03f, -2.40658084e-03f, -1.30707473e-01f,
  1.74071044e-01f, 4.00282629e-02f, -6.01560809e-02f, -3.63686606e-02f, 3.29098776e-02f, 5.90926595e-02f, 9.77533460e-02f, -1.01223677e-01f, -5.67381866e-02f, 1.93210214e-01f,
  -7.04553947e-02f, 1.14308253e-01f, -5.57759702e-02f, 3.30905505e-02f, 1.60253286e-01f, -5.62642328e-02f, 1.87023625e-01f, 2.33104602e-01f, -2.10797135e-02f, -1.76421449e-01f,
  -1.30760698e-02f, 6.09184708e-03f, 9.96203497e-02f, 1.84956845e-02f, -2.97400001e-02f, 2.34056637e-03f, -6.93959892e-02f, -1.73173457e-01f, 1.08186327e-01f, 7.16401264e-05f,
  -3.63399647e-02f, -1.57854389e-02f, -9.54672135e-03f, -6.48588538e-02f, 4.25561983e-03f, -5.25068194e-02f, -5.83918542e-02f, -5.76038770e-02f, 1.92551967e-02f, 3.14855129e-02f,
  2.83932649e-02f, 3.91690135e-02f, 6.51768893e-02f, -4.51979712e-02f, 4.38276641e-02f, -1.10581778e-01f, 5.83517365e-02f, -3.47739719e-02f, 2.92183049e-02f, 5.94217107e-02f,
  -8.67326781e-02f, -1.13005139e-01f, -1.31729037e-01f, -5.80187775e-02f, -5.50056109e-03f, 1.53484926e-01f, 5.61139695e-02f, 3.96336727e-02f, -6.15959149e-03f, -3.40182558e-02f,
  1.04550645e-01f, -3.27723026e-02f, -1.43726781e-01f, 8.52523372e-02f, 1.39121069e-02f, 1.00718863e-01f, -1.42910734e-01f, -7.68305659e-02f, 1.72805693e-03f, 8.20356086e-02f,
  -3.18288542e-02f, -5.31203765e-03f, -6.26536459e-02f, -2.49942839e-01f, 9.51426383e-03f, -2.28895515e-01f, -1.86991990e-01f, -8.04766566e-02f, -2.18237907e-01f, -4.00382847e-01f,
  -4.28896010e-01f, -2.54908323e-01f, 3.87940407e-01f, -1.56410336e-01f, -1.07738264e-01f, -2.55071402e-01f, -4.27119613e-01f, -3.84848714e-01f, -2.39004567e-01f, -1.61056712e-01f,
  -2.65820414e-01f, -2.26775736e-01f, 1.42196007e-03f, 9.91704911e-02f, 4.34520617e-02f, 1.57679528e-01f, 3.11296165e-01f, 2.83483863e-01f, 5.13013862e-02f, -2.05562770e-01f,
  -1.01706713e-01f, 7.12577328e-02f, 5.90186529e-02f, 6.53512478e-02f, -2.62464471e-02f, 1.13556336e-03f, 2.83947587e-01f, 1.62263215e-01f, 4.59289998e-02f, 2.65579641e-01f,
  1.03379734e-01f, -5.80165610e-02f, 1.51552185e-01f, -2.46466380e-02f, 4.48551774e-03f, -5.19052707e-02f, -4.35342789e-02f, 1.54371500e-01f, -7.92026594e-02f, 5.29068373e-02f,
  -3.75055708e-02f, -1.21842995e-01f, -4.11539804e-03f, 4.27111462e-02f, -1.39243692e-01f, -2.20333368e-01f, 1.83566988e-01f, 2.00833201e-01f, 1.71425536e-01f, -1.67686090e-01f,
  -1.76400412e-02f, -1.96847782e-01f, 5.72398677e-02f, 3.46545316e-02f, 1.28489537e-02f, 4.86780703e-02f, 1.19519429e-02f, 2.13629194e-02f, 1.58264451e-02f, -2.21527159e-01f,
  -8.48658681e-02f, -2.60192063e-02f, 5.95600903e-02f, 6.20797910e-02f, -6.98259100e-02f, 7.27279186e-02f, 1.20067336e-01f, 6.88326657e-02f, 1.13894016e-01f, -1.56624645e-01f,
  -4.59433487e-03f, 2.32780445e-02f, 5.54818660e-02f, -2.48302147e-02f, -9.03622061e-03f, 1.97498612e-02f, -1.49536263e-02f, 7.76147172e-02f, 1.49200305e-01f, 9.25660729e-02f,
  -6.72585238e-03f, -4.23794426e-02f, 8.43070373e-02f, -1.65184180e-03f, -6.58847466e-02f, 1.01681672e-01f, -4.69141230e-02f, -1.38014361e-01f, -7.62251168e-02f, 3.99198048e-02f,
  -2.28239998e-01f, 3.36443484e-01f, -1.31577626e-01f, -8.33615512e-02f, -4.84196395e-02f, 1.18907422e-01f, -6.24403656e-02f, 1.91064730e-01f, 3.33346333e-03f, -1.08778723e-01f,
  -2.15618342e-01f, -2.19826493e-02f, 1.05616748e-02f, 9.58708376e-02f, -8.74343887e-02f, -8.93344209e-02f, -1.44025579e-01f, -8.51734504e-02f, 4.39407676e-02f, -2.73216277e-01f,
  -4.84192483e-02f, -2.01847941e-01f, -1.34406626e-01f, -2.16841817e-01f, -2.41614401e-01f, -2.07608745e-01f, 6.73726723e-02f, -1.92496359e-01f, -1.09230459e-01f, -3.84321302e-01f,
  9.30834264e-02f, -2.46575445e-01f, -2.27359846e-01f, -2.13500366e-01f, -1.87388331e-01f, -2.21513659e-01f, -2.72294343e-01f, 5.53344339e-02f, -5.29083163e-02f, -4.66388255e-01f,
  -1.94876716e-01f, 6.42926246e-02f, -1.35354593e-01f, -1.44806765e-02f, 8.87503847e-02f, -4.11197037e-01f, -2.35794947e-01f, -1.25562483e-02f, 1.28402948e-01f, 3.65459621e-02f,
  -9.86291692e-02f, 3.61399688e-02f, 1.50138304e-01f, 1.13433763e-01f, -2.23542050e-01f, -2.95857862e-02f, -2.77449667e-01f, -1.33048519e-02f, -2.04845294e-01f, -3.80136549e-01f,
  -3.20441246e-01f, 1.89474002e-02f, 8.71497989e-02f, 2.32154205e-01f, -1.24325328e-01f, -2.36174706e-02f, -9.59358886e-02f, -4.84770956e-03f, 4.32330333e-02f, -3.63402255e-02f,
  -1.07174143e-01f, 1.18042059e-01f, 1.05270900e-01f, -4.77671772e-02f, -9.05441418e-02f, 8.68168697e-02f, 1.01743877e-01f, 1.57485515e-01f, -5.39086806e-03f, 2.54664645e-02f,
  -1.03979520e-01f, 2.40953006e-02f, -7.84471724e-03f, 1.17709376e-02f, 8.97199810e-02f, 4.08147983e-02f, 4.98108892e-03f, 4.11904082e-02f, 2.40003169e-01f, -1.11845620e-01f,
  -4.26116847e-02f, -1.95243195e-01f, -3.00368425e-02f, -2.79857963e-02f, 3.60977696e-03f, 3.91676128e-02f, 1.81181915e-02f, -6.26641214e-02f, 1.54884651e-01f, 1.05041429e-01f,
  -1.25677860e-03f, 3.88090983e-02f, -3.58327776e-02f, 1.27293831e-02f, -1.13367066e-01f, 1.25614449e-01f, -2.66013630e-02f, -9.17149261e-02f, -3.55537198e-02f, -3.50282975e-02f,
  -1.44222407e-02f, -8.17006305e-02f, 1.57761201e-02f, 1.81630496e-02f, 1.26291523e-02f, 7.54690915e-03f, -1.60936685e-03f, 1.58038437e-02f, -1.13934102e-02f, -2.21295655e-03f,
  -1.36735484e-01f, 2.12797388e-01f, -2.78268427e-01f, 7.76207373e-02f, 2.81189401e-02f, -3.68792713e-02f, -1.94040895e-01f, 2.57047988e-03f, -7.80489966e-02f, -6.01345338e-02f,
  4.08777334e-02f, -8.70279782e-03f, -8.82980600e-02f, -5.86694852e-02f, 1.95768941e-03f, 2.94953678e-02f, -2.98911929e-02f, 2.49612555e-02f, 6.53631464e-02f, 9.63647738e-02f,
  -1.39545854e-02f, -4.36606491e-03f, 1.10442787e-02f, 3.26838344e-02f, -2.05014646e-02f, 1.06687248e-01f, -6.28657341e-02f, 1.13512866e-01f, 1.58563852e-01f, -2.10395828e-01f,
  4.79831219e-01f, 2.62381732e-01f, 2.44135797e-01f, -2.43515074e-02f, -9.75685641e-02f, -2.49986886e-03f, 1.04911260e-01f, -1.66976117e-02f, 3.64384986e-02f, -2.27225926e-02f,
  -1.97481737e-01f, -3.71548593e-01f, -2.75609910e-01f, -1.89316124e-01f, 8.10954124e-02f, 1.70129031e-01f, 9.09191445e-02f, 8.16463381e-02f, -9.72561389e-02f, 7.38702565e-02f,
  -1.17337480e-01f, 1.27570868e-01f, 2.71581054e-01f, 9.97460634e-02f, 1.00816347e-01f, -2.01195449e-01f, -4.13712673e-02f, 1.39532909e-01f, -8.89072418e-02f, 9.21037719e-02f,
  -7.40412399e-02f, 4.71068919e-02f, -2.79977292e-01f, -9.71748158e-02f, 9.00257088e-04f, -2.89145038e-02f, 5.28175831e-02f, 4.31911312e-02f, -9.22633782e-02f, -4.33464497e-02f,
  -2.38456577e-02f, -5.19974679e-02f, -1.55654401e-01f, -1.44932613e-01f, 6.47392182e-04f, 8.42524413e-03f, 6.00924753e-02f, 4.54881229e-02f, 2.79621072e-02f, -4.88011912e-02f,
  -1.96571425e-01f, -3.85800027e-03f, 4.86056739e-03f, -1.41085684e-02f, -1.81443263e-02f, -1.30079851e-01f, 5.37261181e-02f, 9.39339250e-02f, -3.73662673e-02f, 3.90568823e-02f,
  -9.87067968e-02f, -2.02736910e-02f, -5.79763576e-02f, -8.27420801e-02f, -3.94496620e-02f, -1.55099079e-01f, -7.97922760e-02f, 3.57640013e-02f, -4.10220921e-02f, 9.44465697e-02f,
  -1.00594237e-01f, -1.06406901e-02f, -3.95292528e-02f, 7.02797696e-02f, -1.05587393e-01f, 9.66245607e-02f, 3.72174717e-02f, 4.38858708e-03f, -6.33971989e-02f, -7.55067542e-02f,
  1.97666083e-02f, -1.26601085e-02f, 2.71822270e-02f, -1.31244361e-02f, 1.74982231e-02f, 3.34759131e-02f, -6.27154335e-02f, -6.26915321e-02f, 1.05465420e-01f, 2.10467651e-02f,
  -2.21508443e-01f, -4.06220257e-01f, -7.54090846e-02f, 1.87995397e-02f, 1.01652786e-01f, 2.00627390e-02f, -1.33212522e-01f, -2.20368020e-02f, -1.31557258e-02f, 6.41240999e-02f,
  -3.86315174e-02f, -8.33704323e-02f, -1.00494370e-01f, 2.62827501e-02f, 2.05687638e-02f, -3.92931812e-02f, 2.77743191e-02f, 4.38966677e-02f, -1.08623570e-02f, 6.67842180e-02f,
  3.09305154e-02f, 4.52916734e-02f, -2.86980011e-02f, -1.31744564e-01f, -7.06244111e-02f, -1.73858121e-01f, -1.03772089e-01f, 1.15356833e-01f, 1.29561052e-01f, 1.13358416e-01f,
  2.56089896e-01f, 8.94435495e-02f, 2.28179768e-01f, -2.10200623e-02f, 2.58836329e-01f, 3.60271364e-01f, 4.78440285e-01f, 2.55869389e-01f, -6.56036064e-02f, 1.19638115e-01f,
  -8.52536317e-03f, -2.65384912e-01f, -1.72694460e-01f, -1.40295178e-01f, 1.19010262e-01f, -1.23180132e-02f, 5.23094535e-02f, 9.52128395e-02f, 1.17168911e-01f, 1.04043953e-01f,
  -1.95915639e-01f, 1.03381630e-02f, 7.03512430e-02f, -1.38490200e-01f, -1.42896160e-01f, -2.32332855e-01f, 6.27032202e-03f, 6.48641214e-02f, 3.79532226e-03f, -1.96017012e-01f,
  6.71434999e-02f, 1.81506604e-01f, -1.45340145e-01f, -1.71535820e-01f, 2.58213859e-02f, -5.62385209e-02f, -1.75737776e-02f, -5.27477860e-02f, -9.07182246e-02f, -3.80351245e-02f,
  -5.53019419e-02f, -4.05710340e-02f, 1.00021407e-01f, -3.54511589e-02f, 1.21611506e-01f, -5.90725765e-02f, 1.57202780e-03f, 3.24221365e-02f, 1.01257414e-01f, -1.59209203e-02f,
  -1.24582410e-01f, 1.53526887e-01f, 2.39099294e-01f, 4.79617380e-02f, 1.41491160e-01f, -1.61536261e-02f, -1.89325474e-02f, 4.78214212e-02f, -9.22677200e-03f, -3.93673740e-02f,
  -2.68786792e-02f, 1.40351113e-02f, 6.01479504e-03f, 1.03360951e-01f, 6.36725724e-02f, 9.55459103e-02f, -5.26280440e-02f, -8.98367912e-02f, -5.76928072e-02f, -1.67131629e-02f,
  1.28817167e-02f, 1.18906111e-01f, 1.46298930e-01f, 9.01925843e-03f, -4.18613441e-02f, 8.48881453e-02f, 5.94620593e-03f, -1.23190761e-01f, 6.02064803e-02f, 2.60286778e-03f,
  8.78062621e-02f, 1.43140614e-01f, 6.51706904e-02f, 1.46255106e-01f, 6.68428913e-02f, 6.78104386e-02f, 1.72762983e-02f, -3.70496362e-02f, 8.07384774e-02f, 9.11556631e-02f,
  -1.74788892e-01f, 1.55689642e-01f, -1.79564625e-01f, -1.92106944e-02f, 1.67564433e-02f, -8.60894844e-02f, -9.51830819e-02f, -6.43759668e-02f, -1.23164095e-01f, -3.76733323e-03f,
  -1.02922104e-01f, 1.11553684e-01f, 9.46579576e-02f, 1.38533726e-01f, 1.36477768e-01f, -1.46109149e-01f, -8.86150301e-02f, 4.68146689e-02f, 3.93559709e-02f, -9.48697999e-02f,
  -4.24679220e-02f, 1.30051095e-02f, 1.36601567e-01f, -4.52209413e-02f, -5.56414127e-02f, -5.78527413e-02f, 6.15260042e-02f, -1.79143939e-02f, 1.01616487e-01f, -7.38125443e-02f,
  -5.39840639e-01f, -2.22488027e-02f, -1.61963105e-02f, 1.72523677e-01f, 2.90469110e-01f, 3.69163364e-01f, 2.65055209e-01f, 2.19758496e-01f, 2.80483574e-01f, 1.01077013e-01f,
  -1.00392506e-01f, 5.63522540e-02f, 5.69735542e-02f, -3.25623825e-02f, 6.23613186e-02f, 3.36111963e-01f, 3.37170213e-01f, 8.19457173e-02f, 4.51732986e-02f, 1.67741016e-01f,
  1.63026720e-01f, -4.45276760e-02f, -1.66958049e-01f, 1.01876184e-01f, 6.97928742e-02f, 6.24964610e-02f, 1.43218637e-01f, 1.19543165e-01f, 1.41807973e-01f, 1.86107442e-01f,
  -1.65216520e-01f, -2.32320651e-01f, 9.95218456e-02f, -4.01708633e-02f, -2.28120044e-01f, -1.20710090e-01f, -1.08434595e-01f, -1.15337461e-01f, -6.25049025e-02f, 7.98059404e-02f,
  -9.52647924e-02f, -1.20909838e-02f, 1.93222500e-02f, -1.46460637e-01f, -8.76767859e-02f, -1.29514784e-01f, -2.22038940e-01f, -2.29621958e-02f, 4.77268323e-02f, 1.18519599e-02f,
  1.29152881e-02f, 6.01669885e-02f, 7.25612640e-02f, 9.80689153e-02f, 1.43663645e-01f, -5.44027835e-02f, -3.27991508e-02f, 1.62989683e-02f, -4.34471034e-02f, -2.22084299e-02f,
  1.79532036e-01f, 3.47345993e-02f, -3.49200666e-02f, 1.22982949e-01f, -6.57159984e-02f, 1.00432217e-01f, 3.49915065e-02f, 6.66629449e-02f, 1.92894503e-01f, -1.67094141e-01f,
  -9.76519473e-03f, 2.00834841e-01f, 8.73262733e-02f, 3.68278883e-02f, -7.62050301e-02f, 6.16802573e-02f, 7.29855299e-02f, -2.64263134e-02f, -2.87121125e-02f, 6.45353459e-04f,
  6.57775924e-02f, 8.17828551e-02f, -9.35947001e-02f, 3.20545360e-02f, -4.96313088e-02f, 5.61284497e-02f, 1.55748436e-02f, -1.19433433e-01f, -3.76678295e-02f, 8.41426179e-02f,
  2.91079164e-01f, 6.45519719e-02f, 1.80131346e-02f, -2.01480743e-02f, -6.74856380e-02f, -2.17649475e-01f, -5.95545359e-02f, -2.03394555e-02f, 8.51404071e-02f, 7.21003711e-02f,
  -9.88814235e-02f, -5.34486473e-02f, 7.62656424e-03f, -4.88697086e-03f, -9.68351029e-03f, -4.76838276e-02f, -6.40830472e-02f, 1.21174984e-01f, 1.53857976e-01f, -7.11357147e-02f,
  1.05331399e-01f, 1.24859370e-01f, 5.18603623e-02f, 1.90920174e-01f, 1.44836739e-01f, 1.52211607e-01f, -1.16537958e-01f, 5.40054068e-02f, 5.62001429e-02f, 8.98489058e-02f,
  -4.98844624e-01f, -6.28426224e-02f, -3.77114445e-01f, 2.63216048e-02f, 1.58301234e-01f, 1.64624900e-01f, 3.08438271e-01f, 2.04698652e-01f, 9.29970816e-02f, -3.52354534e-03f,
  2.60495655e-02f, -9.26940050e-03f, 6.50485158e-02f, 1.39703780e-01f, 2.07652431e-02f, -3.04311831e-02f, 4.20685001e-02f, -2.36709043e-02f, 4.85145636e-02f, 1.70087814e-01f,
  2.06901252e-01f, 4.75617461e-02f, -1.61317289e-01f, -5.94624728e-02f, 1.66416559e-02f, 1.17836483e-02f, -1.89182520e-01f, -8.10419694e-02f, -6.11077547e-02f, -3.03317197e-02f,
  -4.70784634e-01f, -3.66861820e-01f, 1.43446565e-01f, 1.06215924e-02f, -1.98609665e-01f, -5.98903932e-02f, 4.71963286e-02f, -1.20906010e-01f, -4.05008569e-02f, 1.54623613e-02f,
  -5.14569618e-02f, -3.82988006e-02f, 2.35829800e-02f, 3.13935019e-02f, -2.03862088e-03f, 3.08456887e-02f, -2.35734750e-02f, -1.53712407e-02f, -1.33805811e-01f, -1.58919796e-01f,
  1.37338340e-01f, -2.26131659e-02f, -3.12685102e-01f, 7.40277693e-02f, -1.00590505e-01f, 6.56865016e-02f, -1.02402560e-01f, -1.12603813e-01f, -1.39586553e-01f, -3.16728294e-01f,
  1.12760440e-01f, 9.73290935e-06f, 2.67660078e-02f, -5.54335341e-02f, 1.02064408e-01f, -3.24016879e-03f, 2.80175619e-02f, 4.37178882e-03f, 2.26057209e-02f, -9.76290256e-02f,
  -9.92423818e-02f, -8.26751813e-02f, -1.06852926e-01f, -8.42177495e-02f, 8.16502497e-02f, -1.49543285e-02f, -2.37845108e-02f, -9.83253717e-02f, -5.88924177e-02f, -4.52590249e-02f,
  -8.43068659e-02f, -1.14348479e-01f, -3.38625871e-02f, -1.74182653e-02f, -6.73019513e-02f, -5.07745259e-02f, 9.40253362e-02f, 1.60039179e-02f, 4.13128035e-03f, -2.13748217e-02f,
  -1.35463759e-01f, 3.93166021e-02f, -1.10700823e-01f, 9.73021612e-02f, -1.59679845e-01f, 8.18284303e-02f, 8.10448527e-02f, -4.37360331e-02f, -8.66553858e-02f, 5.97101934e-02f,
  -4.07810099e-02f, -9.70578864e-02f, -2.54892129e-02f, 2.71281749e-02f, 1.22771218e-01f, 1.48888752e-02f, 6.56963661e-02f, 9.97781083e-02f, -1.79177802e-02f, -1.30378515e-01f,
  1.12926729e-01f, 6.72911927e-02f, -1.13045976e-01f, 3.23658697e-02f, 3.23818661e-02f, -1.13664322e-01f, -8.02715309e-04f, -1.11968555e-02f, -1.39155507e-01f, -2.17046455e-01f,
  -2.94971824e-01f, -1.67321607e-01f, 1.55868933e-01f, 2.15876717e-02f, -1.49424657e-01f, -3.22850049e-02f, -1.61736354e-01f, -2.30488196e-01f, -1.72020197e-02f, 3.59736905e-02f,
  -7.91928917e-02f, 1.33625492e-01f, 1.85767487e-01f, 1.10438541e-01f, 5.90573512e-02f, 1.06173098e-01f, 4.66914326e-02f, 1.99557006e-01f, 2.64868945e-01f, 3.51962186e-02f,
  5.25844395e-02f, 4.11758274e-02f, 6.61732554e-02f, 2.65502632e-02f, -9.43221375e-02f, 1.17351174e-01f, 1.00776620e-01f, -1.16970628e-01f, -3.01679000e-02f, 5.55942208e-02f,
  5.15293121e-01f, -4.15644526e-01f, 1.62020400e-02f, -2.85771310e-01f, -6.37529343e-02f, -6.84696212e-02f, 3.34934816e-02f, -8.04773495e-02f, -2.20735952e-01f, -1.08407438e-02f,
  -1.17251135e-01f, -8.89126137e-02f, 1.12140775e-02f, 3.37086655e-02f, -7.07871392e-02f, -1.91961471e-02f, -7.70851523e-02f, 2.50809215e-04f, 6.53757527e-02f, -8.93759658e-04f,
  -1.29964396e-01f, -9.63501558e-02f, -3.44313718e-02f, -1.33434497e-02f, -1.01939604e-01f, 9.51632559e-02f, -6.03725985e-02f, -1.04230806e-01f, -8.50272179e-02f, 4.14841101e-02f,
  -6.79097027e-02f, 7.38011897e-02f, 3.67065184e-02f, 2.26419815e-03f, 8.27832446e-02f, 5.13237640e-02f, 1.11392193e-01f, 3.17849852e-02f, 1.44991418e-02f, -2.70522311e-02f,
  -2.27132123e-02f, 7.63735846e-02f, 1.11061759e-01f, -1.18730858e-01f, -2.77488772e-02f, -1.95931464e-01f, -4.73424755e-02f, -9.11219325e-03f, -4.82452624e-02f, -1.37282521e-01f,
  1.34062422e-02f, -1.74762625e-02f, -3.75935808e-02f, -6.33626357e-02f, -1.41632602e-01f, 3.00688278e-02f, 6.18729740e-03f, -3.83113325e-02f, 2.52065938e-02f, -7.64920563e-02f,
  3.20628852e-01f, 5.19516725e-05f, 2.86214679e-01f, 1.75969731e-02f, -1.00591958e-01f, -1.40648454e-01f, -3.32287140e-02f, -5.27080288e-03f, -4.43345606e-02f, -2.46755369e-02f,
  -1.97337285e-01f, 4.07844409e-02f, 3.97678167e-02f, 7.25181773e-02f, 7.73262605e-02f, 2.40394212e-02f, -2.89573278e-02f, 9.64438543e-02f, -3.77169400e-02f, -5.00278026e-02f,
  -6.06025755e-02f, -3.69213172e-03f, 2.09430024e-01f, 1.97116196e-01f, -3.67804058e-02f, 1.11278288e-01f, 2.47956008e-01f, 9.35720876e-02f, 2.57512748e-01f, 2.61392772e-01f,
  9.30645391e-02f, 3.35710198e-01f, 3.33881229e-01f, -3.33918929e-02f, -1.19472928e-01f, 1.84527948e-01f, 2.64581263e-01f, 1.43689558e-01f, 2.95763500e-02f, -5.01151867e-02f,
  1.07672187e-02f, -9.67441779e-03f, 7.65041187e-02f, 2.10156932e-01f, 2.77724415e-01f, 2.15587348e-01f, 1.43030718e-01f, 1.27919391e-01f, 1.16873994e-01f, 2.33737491e-02f,
  3.69024612e-02f, -1.02732696e-01f, -1.27206564e-01f, 1.39426645e-02f, -1.43945590e-01f, -8.46687146e-03f, -2.06172634e-02f, 2.61474364e-02f, 1.38895223e-02f, 3.32459086e-03f,
  4.62801084e-02f, 1.43213317e-01f, -1.00303791e-01f, -2.23075569e-01f, -7.03532025e-02f, -7.11713061e-02f, 6.73734844e-02f, -1.09192953e-01f, -6.39789104e-02f, -3.48356850e-02f,
  -3.17915045e-02f, 1.43973706e-02f, -2.15777270e-02f, -7.78619125e-02f, -9.41300914e-02f, -8.22443739e-02f, -3.78991403e-02f, 1.52170300e-01f, 2.20184445e-01f, 1.41795695e-01f,
  2.80922744e-02f, -8.89385045e-02f, -3.87647524e-02f, -1.97665263e-02f, 4.82359156e-02f, -7.87919685e-02f, 3.17757577e-02f, 3.80295739e-02f, 3.10649667e-02f, 1.57329421e-02f,
  5.89841120e-02f, 5.56201972e-02f, 8.02094042e-02f, 4.26756404e-02f, 4.87266369e-02f, -1.39114223e-02f, 1.32135302e-01f, -5.34470472e-03f, -5.60111366e-02f, -1.46183640e-01f,
  6.89231083e-02f, 1.31989997e-02f, 1.09696746e-01f, 8.83047804e-02f, 4.71715964e-02f, 2.33252540e-01f, 1.00799993e-01f, -7.26240948e-02f, 9.91152693e-03f, -6.65303469e-02f,
  -2.12643445e-02f, 4.01143543e-02f, -1.83235243e-01f, 3.03035341e-02f, -2.63960194e-02f, 7.03537557e-03f, -4.21554893e-02f, -1.20154664e-01f, -2.10668504e-01f, -1.07758380e-01f,
  -2.86344457e-02f, 1.08570464e-01f, 5.04871905e-02f, 8.57796445e-02f, -2.05682218e-01f, -1.15862526e-01f, 3.19865681e-02f, 5.47773689e-02f, 4.58870009e-02f, -1.55090401e-02f,
  4.31947038e-02f, 1.70559943e-01f, -7.49586076e-02f, -4.35865717e-03f, -1.60319164e-01f, -1.65422723e-01f, -6.99430588e-04f, 9.24067050e-02f, -4.83888527e-03f, 4.96855490e-02f,
  4.21518125e-02f, -1.83403157e-02f, 2.52145920e-02f, 7.81163871e-02f, -7.74786174e-02f, -8.55821893e-02f, -1.63601801e-01f, -1.67465195e-01f, -2.40741540e-02f, -2.08660498e-01f,
  -2.44507566e-01f, 2.37853065e-01f, -1.65248543e-01f, -2.36674756e-01f, -2.55417079e-01f, -1.89445913e-01f, 1.53350588e-02f, 1.15930364e-02f, 3.50884045e-03f, 9.98061970e-02f,
  3.37397419e-02f, -8.99172276e-02f, 1.10697253e-02f, 7.62673616e-02f, 1.24524273e-01f, 1.72125250e-01f, 2.05470696e-02f, -1.98964447e-01f, -3.02947700e-01f, -2.57440001e-01f,
  -1.48207648e-02f, 1.53899953e-01f, 6.54800609e-02f, 7.57630216e-03f, -4.71958183e-02f, 6.64502978e-02f, 1.95954293e-01f, -4.50373627e-03f, 5.30043133e-02f, -4.80283350e-02f,
  -1.15554959e-01f, -3.04727107e-01f, -2.60533988e-01f, 6.39044039e-04f, -6.37103096e-02f, 1.50430510e-02f, -8.73302519e-02f, -4.76768427e-02f, -1.33445293e-01f, 4.79692109e-02f,
  -2.53662556e-01f, -1.40765876e-01f, -3.10160071e-01f, -9.13683847e-02f, -8.38798732e-02f, -6.83196038e-02f, -4.33672108e-02f, -2.17658281e-02f, -2.12101471e-02f, -8.08343887e-02f,
  -1.81859300e-01f, -1.38647303e-01f, -4.07598242e-02f, 9.38605219e-02f, -1.03664108e-01f, -1.59334674e-01f, -4.15988453e-02f, -1.20922580e-01f, 1.66657671e-01f, 2.08802998e-01f,
  2.07209960e-03f, 3.36119346e-02f, -1.80825181e-02f, 1.64022483e-02f, -5.15999421e-02f, -8.07948187e-02f, -8.14474151e-02f, 2.27361619e-02f, 3.54686305e-02f, -5.97932190e-03f,
  -5.77808507e-02f, 2.15340145e-02f, 1.09245844e-01f, -1.01951450e-01f, -6.36035651e-02f, -8.62760171e-02f, -8.67864788e-02f, 9.68403444e-02f, -5.62875234e-02f, 4.23523672e-02f,
  -6.00764304e-02f, -1.84378424e-03f, 3.03786859e-04f, 6.65905699e-02f, 6.61132634e-02f, -7.22461790e-02f, 2.68550795e-02f, 5.77047691e-02f, -9.96882543e-02f, -9.16568264e-02f,
  3.47519487e-01f, 5.75770512e-02f, 5.36367111e-02f, 4.03303504e-02f, 4.07233946e-02f, 8.29160586e-03f, 6.19628206e-02f, 2.00801194e-02f, -1.89976454e-01f, 1.05673056e-02f,
  -1.84774339e-01f, -9.42699313e-02f, -1.32780492e-01f, -2.31112186e-02f, -1.93210952e-02f, -2.97838859e-02f, 5.08010276e-02f, -1.04073565e-02f, 8.97788629e-02f, 2.15300871e-03f,
  1.43749729e-01f, 1.68493927e-01f, 1.91120178e-01f, 1.86420530e-01f, 4.00461107e-02f, -1.68792736e-02f, 6.71052337e-02f, 9.43900645e-02f, 1.42170846e-01f, 3.63086998e-01f,
  8.34912956e-02f, -1.20480269e-01f, -3.37063462e-01f, 1.67900380e-02f, 1.28423333e-01f, 3.47578526e-02f, -9.79920179e-02f, 1.07596107e-01f, 2.25688040e-01f, -1.12108521e-01f,
  8.05740282e-02f, 1.79277062e-01f, -1.72770771e-04f, -1.04451329e-01f, -2.39935771e-01f, -3.78963917e-01f, -3.15547705e-01f, -2.41647139e-01f, 1.67875901e-01f, 2.65890658e-01f,
  4.56611663e-02f, 6.69943467e-02f, 7.98346661e-03f, -3.82712819e-02f, 3.70312040e-03f, -9.07227099e-02f, -7.74160549e-02f, -8.79421160e-02f, -1.97156131e-01f, -3.21155548e-01f,
  -2.25275591e-01f, 6.68329373e-02f, 2.85629835e-02f, 1.15897126e-01f, -7.15633705e-02f, 2.09092703e-02f, 9.32819173e-02f, 1.96104851e-02f, 1.55306235e-01f, -3.86739522e-02f,
  8.63000751e-02f, 7.19720051e-02f, -2.84915734e-02f, 1.41440213e-01f, 8.32142308e-02f, 1.97823234e-02f, 9.32704136e-02f, -8.60186368e-02f, -8.84430185e-02f, 9.91313756e-02f,
  -7.90473223e-02f, -9.36074704e-02f, -1.24346063e-01f, -2.87699178e-02f, 1.79361384e-02f, -1.22463003e-01f, -2.67548990e-02f, 1.32681578e-01f, -2.17832312e-01f, -1.10975228e-01f,
  -3.80602255e-02f, 7.62223378e-02f, -6.18192255e-02f, -2.45547835e-02f, 7.21835196e-02f, -1.40718305e-02f, -3.26513225e-04f, -5.62523082e-02f, 4.65468839e-02f, -4.64844778e-02f,
  7.43088126e-03f, 1.14501792e-03f, -5.08591570e-02f, -9.06451121e-02f, -1.45767452e-02f, -1.78287700e-02f, -7.84763023e-02f, -1.19423389e-01f, -1.04938097e-01f, -2.58518774e-02f,
  5.94819896e-02f, -4.51467782e-02f, -4.20217700e-02f, 8.34115893e-02f, -5.51662371e-02f, -7.06883743e-02f, 3.83130386e-02f, 7.50235915e-02f, -5.33644073e-02f, 6.10653535e-02f,
  -1.49270175e-02f, -7.32735395e-02f, -7.41639137e-02f, -4.96110991e-02f, -3.37323584e-02f, 6.29674643e-02f, -9.31113586e-02f, 2.66949204e-03f, 1.12518914e-01f, 8.85197893e-03f,
  1.45899087e-01f, -3.84813249e-02f, -3.60023864e-02f, 3.57662626e-02f, 8.48702118e-02f, -2.17629913e-02f, -1.00176424e-01f, -3.55145037e-02f, -4.02452573e-02f, 1.03311889e-01f,
  -9.45469588e-02f, -1.47817731e-01f, -1.83094680e-01f, -2.30918095e-01f, 5.99264428e-02f, -9.81600806e-02f, -9.90981907e-02f, -3.72065185e-03f, -2.42800131e-01f, -2.33408272e-01f,
  2.12332740e-01f, -8.22491869e-02f, 7.68423900e-02f, 2.32380405e-01f, 1.62752643e-01f, 5.74024320e-02f, 5.82898818e-02f, 9.17299166e-02f, 2.24120557e-01f, 7.88792148e-02f,
  1.23086341e-01f, 2.04069242e-01f, 2.37827018e-01f, 7.01056272e-02f, 1.16611551e-02f, 1.35880616e-02f, -3.84129621e-02f, 9.95914787e-02f, 2.08667114e-01f, 1.89802960e-01f,
  4.96897288e-02f, 8.74723569e-02f, 5.72838485e-02f, 8.36510956e-02f, 3.78339961e-02f, 6.08123131e-02f, -3.70910093e-02f, -1.65610760e-02f, 1.86256282e-02f, -1.12142958e-01f,
  -1.85752705e-01f, 3.16091664e-02f, 1.69855222e-01f, -3.42743918e-02f, -8.99751708e-02f, 4.40952256e-02f, 4.62848172e-02f, -4.64050798e-03f, 1.50184045e-02f, -2.96593625e-02f,
  -9.95482579e-02f, -1.46035761e-01f, -2.07485072e-02f, -6.18671738e-02f, -6.78079203e-02f, 5.13029471e-02f, -1.18107207e-01f, 6.40889779e-02f, 1.10218681e-01f, -4.55714427e-02f,
  -1.99903306e-02f, -2.78882030e-03f, 5.13614761e-03f, -4.31738682e-02f, -8.57408941e-02f, 2.67739519e-02f, 3.97111177e-02f, -9.09615308e-02f, 6.43805191e-02f, 6.16675653e-02f,
  1.80444896e-01f, 8.86509717e-02f, -8.29488114e-02f, 4.93710563e-02f, 2.46878937e-02f, -1.04140349e-01f, -1.31941428e-02f, -5.66680469e-02f, -8.01821053e-02f, -1.24372067e-02f,
  4.40412574e-02f, 3.91572341e-02f, 8.05469453e-02f, 1.26450196e-01f, 5.72590763e-03f, -1.57731604e-02f, -6.11258000e-02f, -6.16915077e-02f, 4.84144837e-02f, -6.05946332e-02f,
  -5.26478551e-02f, 3.32047966e-05f, -7.93297067e-02f, -1.05774976e-01f, 3.01204696e-02f, 5.72120510e-02f, 9.28632319e-02f, -5.98057127e-03f, 4.28200997e-02f, -3.17104831e-02f,
  -2.14638952e-02f, 1.83693409e-01f, -1.89573113e-02f, -1.66974598e-04f, -1.91668168e-01f, -1.57219693e-01f, 9.45341736e-02f, -2.94725914e-02f, -9.86954644e-02f, 2.93841641e-02f,
  5.43373339e-02f, -7.27849752e-02f, 2.35443339e-02f, -1.39997870e-01f, -3.94822061e-02f, -8.44718888e-02f, -1.89985961e-01f, 1.35991490e-02f, 4.92697358e-02f, -1.60651594e-01f,
  -5.58573455e-02f, 1.10616982e-01f, 6.09544106e-02f, 8.96631926e-02f, -2.44113151e-02f, 1.42568767e-01f, -2.71006431e-02f, -1.01634935e-01f, 2.09576227e-02f, 8.69693831e-02f,
  6.02234244e-01f, -2.42741957e-01f, 1.15150161e-01f, 1.63339432e-02f, -1.44534439e-01f, -1.23377390e-01f, -1.94191143e-01f, -5.90328239e-02f, -7.35649467e-02f, -5.67409070e-03f,
  1.12266839e-01f, 1.66246071e-01f, 5.00486307e-02f, 1.78481832e-01f, 1.55150205e-01f, -1.31797284e-01f, -1.21639140e-01f, 2.50398070e-01f, 2.65639573e-01f, -1.18707791e-02f,
  -2.08746150e-01f, -1.35004401e-01f, 1.03607617e-01f, 4.83987592e-02f, -1.24589801e-01f, 1.25510529e-01f, -1.87158570e-01f, -4.85778265e-02f, -1.19799875e-01f, 5.13239158e-03f,
  1.60674468e-01f, 6.53572008e-02f, 1.32007763e-01f, -5.47997952e-02f, -1.01793744e-01f, 4.54850867e-02f, -6.84381425e-02f, -1.50009036e-01f, -1.47091225e-01f, -1.17978521e-01f,
  -1.21612817e-01f, 4.06751260e-02f, -1.25587553e-01f, -6.34618253e-02f, -1.87774450e-01f, 4.76323627e-02f, -1.01703599e-01f, 3.18890624e-02f, -1.08372517e-01f, 9.80505068e-03f,
  -5.82778603e-02f, -8.94646570e-02f, -6.51078299e-02f, -3.50832753e-02f, 7.86262378e-02f, 2.59766933e-02f, 3.02937198e-02f, -2.09303908e-02f, -2.05523279e-02f, 3.65682617e-02f,
  -3.23519558e-02f, -1.43050477e-01f, -1.08093895e-01f, 1.23726659e-01f, 1.18004985e-01f, -3.78614897e-03f, 1.14957998e-02f, 7.18600377e-02f, 1.04191341e-01f, 3.01763639e-02f,
  -1.75473154e-01f, 1.66867048e-01f, 5.81088401e-02f, -3.80272642e-02f, 1.01224333e-02f, -1.48074567e-01f, -7.22916471e-03f, -8.24060813e-02f, -4.91274670e-02f, -4.98915985e-02f,
  6.98855892e-02f, -8.66379067e-02f, -1.80415720e-01f, -1.72387406e-01f, -1.47870347e-01f, -1.07554711e-01f, -2.62510385e-02f, -4.27637761e-03f, -1.75136887e-02f, -1.95575848e-01f,
  -2.45430186e-01f, 2.11382926e-01f, 2.00029567e-01f, 9.57688838e-02f, -1.00868136e-01f, 2.97056232e-02f, 1.63511157e-01f, 1.04495823e-01f, 4.28309813e-02f, 9.70137715e-02f,
  6.98900491e-04f, 1.19641133e-01f, -2.10611764e-02f, -1.19304292e-01f, 6.54400364e-02f, 5.90824075e-02f, -7.49271065e-02f, 9.29205958e-03f, 4.69493717e-02f, -1.37345895e-01f,
  -2.07680196e-01f, 5.34374639e-02f, 1.34538054e-01f, 3.96412984e-03f, -4.60098535e-02f, 1.93905398e-01f, -4.08122689e-02f, 1.66873895e-02f, 1.78177450e-02f, -5.62654771e-02f,
  3.90405804e-01f, -4.21432674e-01f, -2.97520787e-01f, 2.25413926e-02f, -1.09002560e-01f, -1.63398743e-01f, -2.91478783e-01f, -8.52335319e-02f, 8.83178189e-02f, -2.87786365e-01f,
  -9.70374122e-02f, 3.57662797e-01f, 1.99225113e-01f, 1.36485860e-01f, 4.11196202e-02f, -3.58344287e-01f, -3.63923848e-01f, -6.02576397e-02f, 2.57596105e-01f, 1.42299101e-01f,
  -6.81811897e-03f, 7.84138143e-02f, 1.07531808e-01f, 7.49875829e-02f, -1.52638003e-01f, -6.01849109e-02f, -2.50177979e-01f, -1.62461221e-01f, -1.51139364e-01f, -2.45595008e-01f,
  -1.45146418e-02f, 2.67028511e-02f, 7.83484709e-03f, 1.74523264e-01f, -4.48847488e-02f, 9.73096192e-02f, -4.29664329e-02f, -1.64872959e-01f, 1.99826788e-02f, -1.01081759e-01f,
  1.91347729e-02f, 3.32073569e-02f, 1.44784972e-01f, 6.25162572e-02f, -1.62589148e-01f, 4.31257784e-02f, -1.30076379e-01f, -1.15899995e-01f, -1.30011529e-01f, -1.72427520e-01f,
  -1.32311314e-01f, 3.77904586e-02f, 1.10695638e-01f, -1.66634262e-01f, -1.14858799e-01f, 1.03353031e-01f, -2.50963598e-01f, -8.13244656e-03f, -1.13246351e-01f, -2.11632907e-01f,
  -3.88025455e-02f, 5.18348329e-02f, 1.10863363e-02f, -4.37215976e-02f, 3.82889714e-03f, -1.05072707e-01f, 1.89707633e-02f, -7.06013665e-02f, -3.25290821e-02f, -1.63722187e-02f,
  2.63769813e-02f, -1.04390159e-01f, 4.65279743e-02f, 1.00372229e-02f, -3.74390557e-02f, -2.26490311e-02f, 6.55464977e-02f, -3.14088203e-02f, -8.00179243e-02f, -4.71839271e-02f,
  2.33639660e-03f, 2.82068681e-02f, -4.53999601e-02f, 1.08210377e-01f, -4.80215102e-02f, 1.88048615e-03f, -5.31371757e-02f, 4.59585860e-02f, 5.99552207e-02f, -4.94549498e-02f,
  1.75973505e-01f, 1.01930901e-01f, -4.14960533e-02f, 1.35905594e-02f, 6.53975904e-02f, 5.36553338e-02f, 2.09288467e-02f, 3.73656452e-02f, 3.48228291e-02f, -3.74592580e-02f,
  4.60096821e-02f, -2.71889009e-02f, 5.23949377e-02f, -3.14489156e-02f, -3.05075217e-02f, -1.92553329e-03f, -1.45350441e-01f, -7.93210417e-03f, -3.57656702e-02f, -1.79025888e-01f,
  -1.73197195e-01f, 8.21426660e-02f, 1.67925879e-01f, -5.09849042e-02f, 1.52529860e-02f, 2.27835268e-01f, -1.37812153e-01f, 9.31590497e-02f, 1.69198170e-01f, -1.97947502e-01f,
  4.28429395e-01f, -2.45204300e-01f, -4.76944387e-01f, 1.16421826e-01f, -2.09915191e-01f, -1.84586480e-01f, -2.47430399e-01f, -1.07000330e-02f, 1.83225930e-01f, -1.83422610e-01f,
  1.80174168e-02f, 2.71789521e-01f, -1.86940352e-03f, -8.79598260e-02f, 4.88513783e-02f, -3.09552193e-01f, -2.17465565e-01f, -7.63420090e-02f, 1.50973186e-01f, 1.16724439e-01f,
  6.93522999e-03f, -1.47588050e-03f, 2.28857711e-01f, -2.10655853e-02f, -7.68377706e-02f, 8.50616139e-04f, -2.58925766e-01f, -1.54967755e-01f, -2.00433820e-01f, -2.26334989e-01f,
  -3.05639893e-01f, -1.92657605e-01f, -3.38269509e-02f, 6.70956075e-02f, -9.44048315e-02f, 1.05463043e-01f, 1.07957609e-01f, 7.12624043e-02f, 7.37088546e-02f, -8.13511759e-02f,
  -4.41291593e-02f, 1.00255258e-01f, 1.65808573e-02f, 3.31659243e-02f, -1.30991125e-02f, 6.10654540e-02f, 1.41233800e-03f, 2.51678545e-02f, 1.46957757e-02f, -1.61262490e-02f,
  -3.06485593e-02f, -3.29786949e-02f, -7.20083341e-02f, -1.50748551e-01f, 4.00221981e-02f, -8.36521238e-02f, -1.56845257e-01f, -1.08576156e-01f, -1.96846258e-02f, -1.33800223e-01f,
  6.42976083e-04f, 1.29499137e-01f, 9.74660590e-02f, 1.73491567e-01f, 1.76060319e-01f, 1.40752330e-01f, 3.63718010e-02f, 3.32500450e-02f, 1.01659656e-01f, 9.38857272e-02f,
  6.49794703e-04f, -5.01096360e-02f, -3.17000188e-02f, -6.65648431e-02f, 2.82445196e-02f, 1.06289396e-02f, -3.91580760e-02f, 5.61824292e-02f, 1.77689493e-02f, 1.93618387e-02f,
  1.00172207e-01f, 1.40499957e-02f, 2.38045361e-02f, 1.55824674e-02f, -1.20823272e-01f, -7.18064234e-02f, -7.70925283e-02f, -3.30244489e-02f, 8.73374492e-02f, -1.15417771e-01f,
  3.02496642e-01f, -8.39181170e-02f, -1.43429050e-02f, 2.07079016e-03f, 1.21556818e-02f, 2.62098722e-02f, 4.47533466e-02f, 2.51563452e-02f, 1.00323044e-01f, 8.52202717e-03f,
  3.58108282e-02f, 6.50953921e-03f, 4.05003652e-02f, 1.29017187e-02f, 7.46843368e-02f, 4.25213128e-02f, -2.27995664e-02f, -6.87209815e-02f, 6.76769242e-02f, -1.93156861e-02f,
  -1.36426231e-03f, 1.43816128e-01f, 6.73973262e-02f, -1.95331918e-03f, 1.13352291e-01f, 1.30962608e-02f, -3.67403440e-02f, -8.77213255e-02f, 3.85751352e-02f, 9.23920348e-02f,
  -3.55424464e-01f, 2.69128561e-01f, 2.22246125e-01f, -1.50680169e-01f, 1.37805015e-01f, -1.03931777e-01f, -1.38127888e-02f, -2.88051456e-01f, -1.28007531e-01f, 5.51418513e-02f,
  1.17667794e-01f, -7.41892606e-02f, 5.34078367e-02f, 5.18652014e-02f, -1.74030453e-01f, 1.38463259e-01f, 1.60457686e-01f, 4.76064347e-02f, -2.86846757e-01f, -1.46710783e-01f,
  8.35071057e-02f, -1.25080105e-02f, -8.62282440e-02f, -1.51490882e-01f, 1.39717147e-01f, 2.72621699e-02f, 1.82483464e-01f, 7.78029636e-02f, 2.09464327e-01f, 1.89359143e-01f,
  2.41477042e-01f, 5.60981296e-02f, -1.33007377e-01f, -2.02033017e-02f, 8.71155933e-02f, -5.14717139e-02f, -3.58358733e-02f, 7.36329108e-02f, 7.06136748e-02f, 2.59084813e-02f,
  2.94271469e-01f, 1.00788429e-01f, 1.11758329e-01f, 7.27206320e-02f, -7.39609897e-02f, -2.04377934e-01f, -1.00258403e-01f, -1.24366798e-01f, -4.95899245e-02f, -6.57799765e-02f,
  1.53094083e-01f, 2.60320425e-01f, -9.71284136e-02f, -5.87884299e-02f, -2.06067845e-01f, -9.37805697e-02f, -1.29677430e-01f, -1.09582826e-01f, -4.17335816e-02f, -1.55750066e-01f,
  -9.15665105e-02f, 5.83255216e-02f, 5.88726141e-02f, -7.86990300e-03f, -4.17514844e-03f, 2.03350008e-01f, 9.23958644e-02f, 1.00946017e-01f, -3.26629015e-05f, 4.73944470e-02f,
  5.74301835e-03f, 2.91344542e-02f, -1.76990801e-03f, -5.82901521e-05f, 3.66702080e-02f, -5.05401045e-02f, -7.19897524e-02f, -1.65787444e-01f, -4.16812524e-02f, 5.05041368e-02f,
  8.39084387e-02f, -4.49649990e-02f, 2.33866237e-02f, -2.79063731e-02f, -4.85349298e-02f, -7.43965283e-02f, -5.20097911e-02f, -1.25720039e-01f, -7.98727125e-02f, 1.30161896e-01f,
  -6.77207559e-02f, 2.06402019e-01f, 1.42451366e-02f, 8.13307893e-03f, 8.42318237e-02f, -8.89274627e-02f, -2.47419737e-02f, -3.70526430e-03f, 3.95134091e-02f, 6.02962188e-02f,
  -1.01002350e-01f, -5.78429289e-02f, 9.54089910e-02f, -4.05912176e-02f, -7.78132230e-02f, -9.02102143e-02f, -5.61821051e-02f, 5.97237702e-03f, -9.94640142e-02f, -1.32710919e-01f,
  -1.88591942e-01f, -1.78559646e-01f, -2.30475783e-01f, -1.04061961e-01f, -9.59317908e-02f, -2.35883623e-01f, -7.04767480e-02f, -2.97382772e-02f, -2.64546666e-02f, -3.19275469e-01f,
  1.57736406e-01f, 3.27511311e-01f, 1.22913323e-01f, 9.34484154e-02f, 8.54279995e-02f, -1.72913969e-01f, -2.61291236e-01f, -2.75556684e-01f, -1.56765863e-01f, 7.03013241e-02f,
  -7.03521743e-02f, -8.47325101e-02f, 1.71804782e-02f, -6.56401441e-02f, -5.32441922e-02f, 8.55904371e-02f, 3.00348029e-02f, 4.99140956e-02f, -1.60810277e-01f, -8.84098634e-02f,
  1.96523592e-02f, 1.39245838e-01f, 3.51807661e-02f, 1.52416155e-02f, 2.58530408e-01f, -1.35224909e-02f, 1.31938964e-01f, 1.61602065e-01f, 1.75101504e-01f, 3.92505765e-01f,
  3.01134884e-01f, 1.61987185e-01f, -5.87022156e-02f, 2.94243935e-02f, 4.30678017e-02f, -2.06018938e-03f, 1.28026232e-02f, 6.89585730e-02f, -1.62463084e-01f, -1.80312246e-01f,
  1.26866624e-01f, 2.02471600e-03f, 1.22239456e-01f, 2.94343662e-02f, -4.28250208e-02f, -3.78457457e-02f, 9.28202178e-03f, -8.37985724e-02f, -1.52471932e-02f, -2.12685410e-02f,
  8.08131844e-02f, -2.48156451e-02f, -1.79117501e-01f, -2.34092861e-01f, -1.36081249e-01f, -1.79917231e-01f, -6.86252862e-02f, -1.53897867e-01f, -9.82880816e-02f, -1.02563508e-01f,
  -1.45051062e-01f, -1.02651335e-01f, 1.12565443e-01f, -1.06005706e-01f, -1.25050113e-01f, -9.87661332e-02f, -4.21463810e-02f, -4.48753871e-02f, -1.31654486e-01f, -4.52135429e-02f,
  -3.50762270e-02f, -4.75192852e-02f, -1.06885388e-01f, 8.63476470e-02f, 3.56399901e-02f, 1.21672049e-01f, -7.58958310e-02f, -4.42071781e-02f, -1.79367419e-02f, -8.26963633e-02f,
  -4.07169908e-02f, -3.31135653e-02f, 4.10198011e-02f, -1.22381048e-02f, 2.24402966e-03f, -1.35936573e-01f, -1.36977313e-02f, -1.22125588e-01f, 5.70806935e-02f, 6.77581951e-02f,
  -1.74440637e-01f, -1.26590714e-01f, 1.04807213e-01f, 1.67537570e-01f, 1.01710297e-01f, 1.96098894e-01f, 2.35778674e-01f, 3.97350527e-02f, 3.94182876e-02f, 4.06071655e-02f,
  8.73371363e-02f, 1.41304895e-01f, 5.44913597e-02f, 1.35293156e-02f, -9.43758413e-02f, 5.41150244e-03f, 3.89449717e-03f, 1.09735750e-01f, -2.11809594e-02f, 4.98084128e-02f,
  6.35700068e-03f, -1.75263092e-01f, -1.48863807e-01f, -1.23322137e-01f, 3.19950841e-02f, 1.30064005e-03f, -2.23348252e-02f, 1.13184126e-02f, -1.75413582e-02f, -1.97518721e-01f,
  3.49853814e-01f, 2.75637835e-01f, -1.02791078e-01f, 1.97206452e-01f, 2.11027175e-01f, -1.54419020e-01f, -2.46200964e-01f, -3.07110935e-01f, -6.71511963e-02f, 2.14942113e-01f,
  1.62674293e-01f, -1.13226466e-01f, -1.75713494e-01f, -4.15460944e-01f, -5.25169194e-01f, -2.37749279e-01f, -2.38818064e-01f, -4.59301263e-01f, -6.42821729e-01f, -3.37545604e-01f,
  -7.12991431e-02f, 1.85008720e-02f, -8.40881988e-02f, -1.12187698e-01f, 1.25734508e-01f, -4.17233631e-02f, 2.29141321e-02f, 3.14019658e-02f, -1.70267355e-02f, 2.22452432e-01f,
  -1.20093711e-01f, 1.77319944e-01f, -3.03219914e-01f, 1.58948526e-02f, 2.05418453e-01f, -1.18062692e-02f, -8.65389854e-02f, -1.18144900e-01f, -8.16313699e-02f, -8.47260877e-02f,
  2.37779900e-01f, -1.42189890e-01f, -4.79837023e-02f, -1.70036018e-01f, -1.16057150e-01f, -1.70921803e-01f, -9.92394537e-02f, -2.47055247e-01f, -2.94771194e-01f, 4.80081420e-03f,
  6.78351820e-02f, 2.16492847e-01f, -7.22748190e-02f, -2.37931311e-01f, -2.25091785e-01f, -8.24157372e-02f, -2.11767629e-02f, -1.50893033e-01f, -4.41374481e-01f, 8.10416341e-02f,
  4.92963083e-02f, -7.19750347e-03f, 9.99005139e-02f, 6.36312552e-03f, 9.12957415e-02f, 1.58314854e-01f, -8.53292197e-02f, 6.83106929e-02f, -1.54283896e-01f, -7.74300843e-02f,
  -1.03965811e-01f, 5.07241599e-02f, -6.06243908e-02f, -3.51337530e-02f, -2.12230794e-02f, -7.43879676e-02f, -7.31756091e-02f, 4.96830121e-02f, 7.12127388e-02f, -1.31346453e-02f,
  -2.68900953e-02f, 5.67471026e-04f, 1.16443180e-01f, -8.66776034e-02f, -4.13368409e-03f, 2.78140288e-02f, -1.73917592e-01f, -2.28218846e-02f, -4.24771607e-02f, 1.21510951e-02f,
  -3.43615673e-02f, -1.50394171e-01f, 2.31966034e-01f, -2.22321212e-01f, -6.57533556e-02f, -5.94599824e-03f, 8.65195692e-02f, -8.43509436e-02f, -6.92463946e-03f, -8.51621106e-02f,
  -8.86326358e-02f, -1.19979762e-01f, 1.54395372e-01f, -1.41241075e-03f, 7.96410721e-03f, -7.06734229e-03f, 1.80430606e-01f, -2.77130790e-02f, -3.14417407e-02f, 7.29656965e-02f,
  5.43467551e-02f, -5.13277017e-04f, 8.33581388e-03f, -7.56372586e-02f, -8.56664905e-04f, -4.77505215e-02f, -1.71562657e-01f, -1.05582111e-01f, -2.82217473e-01f, 9.90023557e-03f,
  -6.12263799e-01f, 9.02242064e-02f, 2.63438553e-01f, -3.88949782e-01f, 8.41625780e-02f, 1.86172113e-01f, 3.52551311e-01f, 1.64437592e-01f, -2.52488971e-01f, 1.53957769e-01f,
  1.52016103e-01f, -2.41414115e-01f, -6.56810403e-02f, 8.45080689e-02f, -1.22012524e-02f, 3.35133702e-01f, 8.87535065e-02f, -1.52331159e-01f, -1.44019157e-01f, -1.33782476e-01f,
  -3.02590020e-02f, -2.91105658e-01f, -3.63179386e-01f, -2.38309592e-01f, -1.32517740e-01f, -2.01222077e-01f, -6.76322207e-02f, -1.26626343e-01f, 1.45758137e-01f, -1.73829608e-02f,
  5.74433468e-02f, -3.64025570e-02f, 1.54474881e-02f, -2.19296828e-01f, -9.28140581e-02f, -1.01488635e-01f, -4.18211222e-02f, -7.71673396e-02f, -7.02331513e-02f, -1.76702086e-02f,
  -1.04245648e-01f, 9.99559369e-03f, -1.12903923e-01f, -1.17514566e-01f, -1.26598358e-01f, -1.48943782e-01f, -9.46399271e-02f, -1.00760214e-01f, 5.49404416e-03f, 1.45317510e-01f,
  4.79566231e-02f, -7.50481859e-02f, -1.83504317e-02f, 1.10584311e-01f, 8.00139233e-02f, -6.56028651e-03f, 6.39206618e-02f, -7.16585889e-02f, 4.37709875e-02f, -1.27697319e-01f,
  -2.24122591e-03f, 1.26876011e-01f, 7.06783682e-02f, 6.92964531e-03f, -7.71614462e-02f, -5.26033789e-02f, -1.26055777e-01f, -2.26387903e-02f, -1.86916832e-02f, -1.30016401e-01f,
  6.64932877e-02f, 5.64937145e-02f, -8.50788131e-02f, -1.49965391e-01f, 2.46707741e-02f, -9.91720632e-02f, -8.48530903e-02f, 4.15338092e-02f, 8.99150297e-02f, -2.39895824e-02f,
  -1.43998206e-01f, 8.06218460e-02f, -3.64262573e-02f, 1.06358910e-02f, -7.52958702e-03f, -9.37370658e-02f, 3.56684513e-02f, 4.46860231e-02f, -2.56582890e-02f, 1.26145780e-02f,
  -2.04687953e-01f, 7.18556717e-02f, 5.04297465e-02f, 5.59775345e-02f, -3.37382592e-02f, 3.13141048e-02f, 3.41537520e-02f, 6.77772760e-02f, -4.22990955e-02f, -3.76776159e-02f,
  -5.68587817e-02f, -4.56670001e-02f, 3.42089906e-02f, -4.28366736e-02f, -5.37542962e-02f, 2.48117629e-03f, 5.02833202e-02f, 7.40819005e-03f, 1.32158011e-01f, 3.25970054e-02f,
  5.40733375e-02f, 3.78416441e-02f, 4.17407602e-02f, 6.47113367e-04f, 2.07374319e-02f, -1.08019568e-01f, 1.24827467e-01f, 6.75814822e-02f, 4.12659086e-02f, 7.08541572e-02f,
  4.64386344e-01f, -9.74179357e-02f, 3.04420292e-01f, 2.59783678e-02f, 5.81006594e-02f, 1.22544028e-01f, 1.68830350e-01f, 1.12919673e-01f, -7.50741828e-03f, -1.01120524e-01f,
  -5.30659221e-02f, -2.04285666e-01f, -2.09000289e-01f, -1.89211443e-01f, 9.64435041e-02f, 3.46629992e-02f, -5.74497432e-02f, 2.25782916e-01f, 2.40824267e-01f, 1.20310284e-01f,
  -1.43953323e-01f, -4.91138957e-02f, 1.22036263e-01f, -1.53761795e-02f, -1.02853857e-01f, -1.45568894e-02f, -3.58907394e-02f, -5.96717410e-02f, -1.64175659e-01f, -1.81464136e-01f,
  1.90709904e-02f, -1.18509764e-02f, 3.94526012e-02f, -9.28777531e-02f, -1.43411336e-02f, 6.21486790e-02f, 8.02615136e-02f, -9.51979123e-03f, -4.98567848e-03f, -5.55693805e-02f,
  -3.04771494e-03f, -2.45629326e-02f, -4.81019393e-02f, 4.78020422e-02f, 1.42623624e-02f, 9.28725153e-02f, 5.55896871e-02f, -3.81889679e-02f, -1.10723130e-01f, -1.42124653e-01f,
  -1.82479665e-01f, 1.23248510e-01f, 1.53390259e-01f, -1.35594150e-02f, -2.43478995e-02f, -4.29883897e-02f, -1.40097560e-02f, -4.47068103e-02f, -4.85409005e-03f, 6.24945797e-02f,
  -9.81416628e-02f, 1.31548032e-01f, -1.57672539e-02f, -2.37711538e-02f, 1.09685838e-01f, 1.54637441e-01f, 1.51893005e-01f, 3.75596508e-02f, 1.21702589e-01f, 1.40567571e-02f,
  -1.22245610e-01f, -1.38863176e-01f, -1.38251064e-02f, -6.01543696e-04f, 2.42461078e-02f, 9.23283696e-02f, 6.47631213e-02f, -9.06997994e-02f, -2.27559824e-02f, -1.68197379e-01f,
  -1.58610001e-01f, 2.63441325e-04f, 2.11872738e-02f, -1.68618053e-01f, -9.13622826e-02f, -1.90081149e-02f, 1.87075790e-02f, -1.67259932e-01f, 4.19446034e-03f, 3.92981954e-02f,
  -3.60512882e-01f, -5.63236699e-02f, -1.16140209e-01f, -4.82448637e-02f, 6.55570626e-02f, -4.67755310e-02f, -7.17777237e-02f, -8.41944590e-02f, 4.68308441e-02f, 9.46372375e-02f,
  -3.59132178e-02f, 8.95479098e-02f, -7.92451724e-02f, -7.36097097e-02f, 1.86174631e-01f, 3.00851725e-02f, -9.82773155e-02f, 4.78687882e-02f, -9.77589637e-02f, -1.88382491e-01f,
  -5.83468378e-02f, 1.69824541e-01f, 1.22112289e-01f, 1.39657989e-01f, 1.60349891e-01f, 2.07560256e-01f, 1.63547888e-01f, 4.36471291e-02f, 1.79769024e-01f, 1.44001469e-01f,
  -3.39194924e-01f, -1.37889251e-01f, 1.36088327e-01f, -2.18481431e-03f, 5.12185283e-02f, -1.08453907e-01f, -1.98062107e-01f, -1.45081148e-01f, -2.27476563e-03f, -6.31465763e-02f,
  -2.62362659e-02f, 5.49583733e-02f, 1.19279794e-01f, -2.46792585e-02f, -4.54013757e-02f, 3.58806886e-02f, 2.62955159e-01f, 1.90250784e-01f, -2.06910446e-02f, 3.54667543e-03f,
  8.83214995e-02f, 3.21870409e-02f, -3.40657830e-02f, 6.41938522e-02f, 1.18428752e-01f, -2.62909830e-02f, 2.90695159e-03f, -1.24449385e-02f, -1.42389648e-02f, 2.36439690e-01f,
  -1.50774688e-01f, -2.66062677e-01f, 8.94620270e-02f, 7.21695051e-02f, -2.42865253e-02f, -1.86638057e-01f, -1.51534528e-01f, -1.17236286e-01f, -4.50720489e-02f, 1.21107150e-04f,
  1.38335958e-01f, -5.06964810e-02f, -4.71198699e-03f, 1.21909812e-01f, 4.17432189e-02f, 1.37003303e-01f, 1.07034259e-01f, 1.91754254e-03f, -2.07823627e-02f, -5.52284978e-02f,
  3.55348438e-02f, 4.99106981e-02f, -1.40692398e-01f, 1.82459336e-02f, -2.08110604e-02f, 9.74346548e-02f, -9.98039097e-02f, -5.09241596e-02f, -3.95166390e-02f, -2.54051119e-01f,
  -3.35385464e-03f, 6.06442839e-02f, 1.56284407e-01f, -3.11255325e-02f, 7.05039203e-02f, 9.28273126e-02f, 1.97076485e-01f, 5.48793338e-02f, 5.55976331e-02f, -1.92020033e-02f,
  -3.63771655e-02f, 1.87778231e-02f, -1.09664738e-01f, 6.24571880e-03f, 3.28577384e-02f, 2.15050150e-02f, 1.81972422e-02f, 1.41349152e-01f, 1.36540249e-01f, -7.54977018e-02f,
  8.63264799e-02f, 8.90569687e-02f, 8.67731273e-02f, 5.12214489e-02f, -3.96634191e-02f, 1.85966507e-01f, 8.54848549e-02f, 5.48299961e-02f, -2.84799491e-03f, -9.07116532e-02f,
  -1.37282103e-01f, 1.07043110e-01f, 4.70830090e-02f, 1.39514133e-01f, 2.76237018e-02f, 7.90061429e-02f, -8.02421197e-02f, 8.77293348e-02f, 8.47300142e-02f, -3.00104823e-03f,
  -1.12164348e-01f, -2.21147299e-01f, -9.87679809e-02f, -1.94966178e-02f, -8.68526101e-02f, 2.18746569e-02f, 1.87016696e-01f, 1.81558505e-01f, 8.50344170e-03f, -2.03018412e-02f,
  8.61668959e-03f, -2.04253137e-01f, -1.67238533e-01f, -1.17980205e-01f, -1.17657766e-01f, 3.13616842e-02f, -1.77667663e-01f, -2.39011467e-01f, -1.07107557e-01f, -4.76457179e-01f,
  6.12019181e-01f, -1.82279795e-02f, 5.08380160e-02f, 1.82574391e-02f, -1.95467353e-01f, -4.21767421e-02f, -1.46020487e-01f, 7.50732645e-02f, 1.43108726e-01f, -3.06076631e-02f,
  1.47532485e-02f, 2.02189013e-01f, 1.36568591e-01f, 8.47693980e-02f, 1.05307989e-01f, 1.09977283e-01f, 1.00317486e-01f, 2.70632416e-01f, 2.77603328e-01f, 1.17069058e-01f,
  4.27648239e-02f, 8.54032114e-02f, 1.53442800e-01f, 1.51919663e-01f, -3.85132432e-02f, 1.10697791e-01f, -2.99746450e-03f, 5.47822751e-02f, -9.11601260e-02f, 8.71278048e-02f,
  -3.19769494e-02f, 2.26816610e-01f, 1.42127797e-01f, 6.72347844e-02f, -1.22821391e-01f, 4.88122664e-02f, -9.08478126e-02f, -1.34593705e-02f, -1.46709671e-02f, -1.60339296e-01f,
  -1.09569557e-01f, -6.21609576e-02f, -4.98505421e-02f, -2.25232337e-02f, -5.92784584e-02f, -5.71842045e-02f, 1.06699141e-02f, 1.32933408e-01f, 1.10175498e-01f, -4.44906242e-02f,
  -3.87773439e-02f, -7.91822299e-02f, -1.17216080e-01f, -4.39242125e-02f, 1.43826932e-01f, 4.11692634e-02f, -1.02719655e-02f, 1.13420196e-01f, 1.75577998e-02f, 1.62056327e-01f,
  1.53322875e-01f, 2.10941210e-02f, 1.21738747e-01f, 6.64691031e-02f, 1.45476401e-01f, 1.29432544e-01f, 4.71339561e-03f, -7.30985478e-02f, 4.00659926e-02f, -3.55120972e-02f,
  -5.71473166e-02f, 8.90381634e-02f, -5.25722541e-02f, 7.77147412e-02f, 3.60906124e-02f, 1.13652004e-02f, -1.70422554e-01f, 1.09457625e-02f, -6.18720166e-02f, -4.93707843e-02f,
  6.10200092e-02f, 2.61850506e-02f, -2.75391024e-02f, -3.25305983e-02f, 2.94904578e-02f, 7.36830011e-02f, 4.22143005e-03f, 4.80598286e-02f, 6.08273735e-03f, -1.30083701e-02f,
  -6.00273967e-01f, 4.98205461e-02f, 1.57103434e-01f, 1.30162418e-01f, -4.68352064e-03f, -1.05116844e-01f, -2.19165850e-02f, -9.87368226e-02f, -2.72547603e-01f, -1.08819656e-01f,
  -7.85139725e-02f, -1.51731810e-02f, 1.45160966e-02f, 7.26055726e-02f, -4.35081273e-02f, -1.40219614e-01f, -5.90597875e-02f, -4.80627492e-02f, 8.00166279e-02f, -1.58138141e-01f,
  4.36674356e-02f, -1.58848375e-01f, -5.76888286e-02f, -1.08169224e-02f, -2.58388966e-02f, -1.84032507e-02f, -9.32986066e-02f, -1.49045289e-02f, 6.73915818e-02f, -6.25172704e-02f,
  -3.04567873e-01f, 1.99107558e-01f, 1.45309698e-03f, -1.57732107e-02f, 1.59665629e-01f, 9.49550197e-02f, 2.02752605e-01f, 1.25723958e-01f, -1.68324746e-02f, 8.09499770e-02f,
  2.24846918e-02f, -9.68350768e-02f, 4.06982005e-02f, 1.67703211e-01f, 1.99403107e-01f, 1.88104451e-01f, 1.17340013e-01f, 4.45582122e-02f, 1.13439374e-01f, 9.45707858e-02f,
  5.63744120e-02f, 4.60587330e-02f, -6.38664141e-02f, -2.75761336e-02f, 7.75706694e-02f, -4.12043184e-02f, 6.79957420e-02f, 1.25344172e-01f, 6.03477247e-02f, 1.99910313e-01f,
  7.95392394e-02f, 8.65320712e-02f, -8.26903954e-02f, 4.08997871e-02f, 1.03080608e-02f, -1.63816869e-01f, -7.69989341e-02f, -1.06766135e-01f, 6.03397340e-02f, -1.91256553e-02f,
  8.74038637e-02f, 8.89464170e-02f, 2.18353588e-02f, -3.79815586e-02f, -2.19818819e-02f, 4.55854759e-02f, -5.31773828e-02f, 1.66170284e-01f, 8.44111890e-02f, -7.22939754e-03f,
  7.93395713e-02f, 4.12487127e-02f, -3.00424024e-02f, 3.54692489e-02f, 2.23067310e-02f, 8.28271210e-02f, 7.78521746e-02f, -2.62407251e-02f, -7.04683438e-02f, -9.78480279e-02f,
  5.72437271e-02f, 2.38606352e-02f, 7.06630200e-02f, 1.58007760e-02f, -6.14718068e-03f, -4.92977314e-02f, -1.98127721e-02f, 9.02561769e-02f, -2.30091065e-02f, -1.48078531e-01f,
  -1.57481790e-01f, -6.52484670e-02f, -4.81519587e-02f, -3.84745859e-02f, -3.20845582e-02f, 1.98973026e-02f, 6.39513731e-02f, -1.99805535e-02f, -1.51089266e-01f, -8.01665783e-02f,
  -8.14319924e-02f, -2.32236423e-02f, -2.07169410e-02f, 6.59827515e-02f, -3.11430879e-02f, 1.53243099e-03f, -1.54893413e-01f, -1.67785615e-01f, -1.60082489e-01f, -2.00060606e-01f,
  6.38338327e-02f, 2.46121734e-03f, -7.25749731e-02f, 7.29733109e-02f, 3.05831917e-02f, -9.33730453e-02f, -8.34220797e-02f, -5.68064228e-02f, 7.96334296e-02f, -5.06978594e-02f,
  -7.09145665e-02f, -4.38069403e-02f, 7.23911375e-02f, 4.87536117e-02f, -2.21757926e-02f, -4.72757667e-02f, 8.79835188e-02f, 1.02973305e-01f, -2.90936627e-03f, -1.18083600e-02f,
  -2.90848669e-02f, -1.67502314e-01f, -1.33065492e-01f, -7.93845206e-02f, -1.10948794e-01f, -9.72701758e-02f, 2.27176794e-03f, -1.14201397e-01f, -2.24513859e-01f, -2.37191603e-01f,
  -3.59688878e-01f, -5.74291386e-02f, 1.48892701e-01f, -8.57079029e-02f, 1.40854698e-02f, 7.70967379e-02f, 3.91430147e-02f, -1.19930692e-01f, -6.82879016e-02f, 1.10786013e-01f,
  5.36726452e-02f, -9.60919857e-02f, 9.18432921e-02f, -6.65269718e-02f, -2.38267973e-01f, 1.00883611e-01f, 1.98896118e-02f, -4.62964773e-02f, -2.16992050e-01f, -1.89746946e-01f,
  -7.34224617e-02f, -2.36034721e-01f, -1.53702810e-01f, -4.15273197e-02f, -3.10658738e-02f, -4.28236350e-02f, 1.73236623e-01f, -4.40771366e-03f, -7.84180034e-03f, -3.07590030e-02f,
  -1.25838369e-01f, -7.96679333e-02f, 1.40781686e-01f, -1.16937503e-01f, 5.67393452e-02f, 6.62371963e-02f, 5.20391092e-02f, -3.06402985e-03f, 7.18607679e-02f, 3.97682041e-02f,
  3.91978212e-03f, 1.92187756e-01f, -5.86239472e-02f, -2.58452930e-02f, -2.25469396e-02f, -2.95298826e-02f, -2.41485075e-03f, -2.25187726e-02f, 2.59710960e-02f, -3.56429480e-02f,
  3.99251170e-02f, -3.55499983e-02f, -1.03307240e-01f, 2.09878292e-02f, -9.49819759e-02f, 8.32130313e-02f, -1.39372358e-02f, -4.84616570e-02f, -6.47854134e-02f, -1.62226677e-01f,
  1.06469385e-01f, 5.76805696e-03f, 5.60048409e-02f, 1.76375210e-02f, -4.64976206e-02f, 7.46707767e-02f, -2.39416282e-03f, 7.39553347e-02f, 9.96022075e-02f, -1.08243018e-01f,
  -1.61035117e-02f, 7.52571970e-02f, 1.44510761e-01f, 9.96339843e-02f, -2.72834171e-02f, 2.16131043e-02f, -4.47393619e-02f, 2.54597440e-02f, 2.97310483e-03f, 9.02424678e-02f,
  8.17809254e-03f, 1.54227652e-02f, 1.10244587e-01f, 4.13755625e-02f, 3.02829575e-02f, 1.44541422e-02f, -2.90377382e-02f, -3.28710116e-02f, -2.60506254e-02f, -9.03219283e-02f,
  -1.28343701e-01f, 8.65183473e-02f, 2.77418755e-02f, -1.03036031e-01f, -2.98810694e-02f, 5.92011325e-02f, 4.86349240e-02f, -2.73136813e-02f, 1.46570295e-01f, -1.42015055e-01f,
  -3.43602560e-02f, 1.79024577e-01f, 3.04492731e-02f, 8.80321935e-02f, -5.84033914e-02f, -7.09172338e-02f, -3.89255513e-03f, -7.19261095e-02f, 1.58058666e-02f, 4.38110642e-02f,
  -4.92311865e-02f, -8.29679891e-02f, -2.25308388e-01f, -1.43701255e-01f, 3.16326916e-02f, -1.50538415e-01f, -2.69445032e-02f, -3.14296633e-02f, -2.03610376e-01f, -2.88466334e-01f,
  3.94742727e-01f, -3.08214486e-01f, 6.46124110e-02f, 1.56058893e-01f, 1.13044502e-02f, 5.32377250e-02f, 1.12252600e-01f, 8.16413462e-02f, 6.82166964e-02f, -2.70422548e-02f,
  -1.95339158e-01f, -3.48499902e-02f, -3.44580486e-02f, -6.53282646e-03f, -4.05474508e-04f, 7.93698728e-02f, 1.47388086e-01f, 2.12225005e-01f, 1.10089429e-01f, 1.11012310e-01f,
  -4.77283299e-02f, 1.33505747e-01f, 3.83905917e-02f, 1.03062559e-02f, -1.20511055e-01f, -5.69179617e-02f, 4.55941334e-02f, -1.50322840e-01f, -6.45295903e-02f, -9.18028355e-02f,
  -3.54872048e-01f, -1.06404804e-01f, 1.19051628e-01f, -6.30504265e-02f, -3.46013866e-02f, 6.84599131e-02f, 8.88479352e-02f, 4.18730415e-02f, -9.10825729e-02f, 5.04734069e-02f,
  -1.35699689e-01f, -1.50704518e-01f, 2.85502691e-02f, -2.18068212e-02f, 8.02932680e-02f, -4.73561324e-02f, -4.02056277e-02f, 1.13636710e-01f, 4.88699228e-03f, -7.89188370e-02f,
  -1.24470130e-01f, 1.64561886e-02f, 2.08791578e-03f, -3.44874971e-02f, 5.55710196e-02f, -7.76499510e-02f, -1.11931041e-02f, -2.41019893e-02f, 4.61944863e-02f, 1.52975246e-01f,
  1.23495273e-01f, -4.60458845e-02f, -9.35721397e-03f, 1.43485665e-01f, 7.79897422e-02f, -9.44271982e-02f, -7.05882162e-02f, -1.16910972e-01f, 1.04427591e-01f, 9.35235843e-02f,
  -1.77896349e-03f, -6.20765835e-02f, -5.25091924e-02f, 7.46597946e-02f, -3.68804187e-02f, -9.01022106e-02f, -2.66442075e-02f, 1.29195042e-02f, -5.71659580e-02f, 1.52235292e-03f,
  9.19148698e-02f, -6.26035780e-02f, -3.22746001e-02f, -1.18702702e-01f, -5.69724776e-02f, -1.36984782e-02f, 7.92177096e-02f, -3.33756171e-02f, -7.76812285e-02f, -1.49907582e-02f,
  -1.92362100e-01f, -4.82590348e-02f, 6.27758503e-02f, -1.01171106e-01f, -1.12979256e-01f, 1.92773454e-02f, 4.15997021e-02f, -8.03382844e-02f, -1.35777146e-01f, -7.23198950e-02f,
  -1.33816019e-01f, 7.64110088e-02f, -8.19135532e-02f, 4.97988472e-03f, 8.72812793e-02f, 1.27028644e-01f, -6.03711903e-02f, 9.56210941e-02f, -1.19004667e-01f, -1.35460898e-01f,
  -7.84121975e-02f, 8.77167135e-02f, 1.02584913e-01f, 1.40269861e-01f, 9.78010520e-02f, 7.91889876e-02f, -7.86244497e-03f, 1.10499291e-02f, 6.93999277e-03f, 3.04561615e-01f,
  3.87747139e-02f, -2.11758465e-01f, -3.91819537e-01f, -3.05322051e-01f, -3.61472577e-01f, -6.72650039e-02f, -1.85164094e-01f, -6.68752380e-03f, -1.56025738e-01f, -2.03161731e-01f,
  -8.50606859e-02f, 1.64050832e-01f, 4.58450876e-02f, 1.66005418e-01f, 2.09142432e-01f, -1.64446205e-01f, -3.85078013e-01f, -1.07160814e-01f, 9.91437361e-02f, 1.14844732e-01f,
  -2.19898168e-02f, -8.45408887e-02f, 6.11855723e-02f, -1.11581385e-02f, -3.14887941e-01f, -9.74059105e-02f, -3.75444442e-01f, -2.26607561e-01f, -1.88326165e-01f, -3.45334589e-01f,
  -1.36593431e-01f, -4.75881808e-02f, 1.21107571e-01f, 1.23471335e-01f, -2.25630358e-01f, -1.63473003e-02f, 1.31668821e-01f, -1.28618658e-01f, 4.58484516e-02f, -2.67035346e-02f,
  -8.28155503e-02f, 2.48629097e-02f, 5.88240661e-02f, -1.50443735e-02f, -7.99240172e-02f, 9.37583856e-03f, -9.35228840e-02f, -6.71028346e-02f, -9.15217921e-02f, 5.97591661e-02f,
  9.13836360e-02f, -1.02671854e-01f, 9.88792628e-02f, 2.13812036e-03f, -3.64809185e-02f, -5.65385558e-02f, -9.02907252e-02f, -1.07431728e-02f, 2.63150353e-02f, -1.94521874e-01f,
  4.29190099e-02f, -7.40964636e-02f, 4.76568975e-02f, 8.26657712e-02f, -5.60818017e-02f, 2.51398850e-02f, 1.03640586e-01f, 1.78475678e-02f, 1.48395181e-01f, 4.38891388e-02f,
  -2.91137248e-02f, -8.27158317e-02f, 6.37754053e-02f, -8.48293453e-02f, -5.18969931e-02f, -7.19259679e-02f, -4.74243760e-02f, 6.40062168e-02f, -9.23636407e-02f, -6.45680651e-02f,
  -7.52822012e-02f, -8.38388577e-02f, -6.35833293e-02f, 4.59262542e-02f, -1.16469748e-01f, 3.54001746e-02f, 7.77529031e-02f, 6.37160763e-02f, -4.68749404e-02f, -5.09208404e-02f,
  1.02035269e-01f, 1.07447304e-01f, -9.29758176e-02f, 1.70265496e-01f, -1.14782089e-02f, -4.56906036e-02f, -8.84196609e-02f, 2.70618033e-02f, -5.48133850e-02f, 8.68934393e-02f,
  1.52943572e-02f, 6.47906065e-02f, -4.93461937e-02f, 8.45657513e-02f, -1.03455037e-01f, 8.47205967e-02f, 9.53973532e-02f, 5.52962273e-02f, 4.39970233e-02f, -7.69907758e-02f,
  -6.84051514e-02f, 2.16921121e-02f, 1.97848365e-01f, 7.61327520e-02f, 8.04487802e-03f, 6.20426983e-02f, 7.40993768e-02f, 3.83639708e-02f, 2.64659345e-01f, 4.99887355e-02f,
  2.07035571e-01f, 1.92783564e-01f, 2.29306489e-01f, 2.93476582e-02f, -2.23184481e-01f, -3.12645286e-01f, -1.81923747e-01f, -1.17067248e-01f, -4.50705662e-02f, -3.01596001e-02f,
  1.40324347e-02f, -4.94325347e-02f, 2.38189311e-03f, -3.65247242e-02f, 4.67725396e-02f, 6.88690543e-02f, 1.42210469e-01f, 1.33222803e-01f, 2.92521045e-02f, -3.86550799e-02f,
  -6.51758164e-02f, -1.88714098e-02f, 3.10297068e-02f, 4.31252159e-02f, 8.20797309e-02f, -1.37222242e-02f, -1.79450568e-02f, 5.57207055e-02f, 4.82533798e-02f, 2.85485685e-01f,
  2.15224922e-01f, 2.75976330e-01f, -1.11808181e-01f, -1.49518386e-01f, 5.24668619e-02f, 1.48896407e-02f, 1.86551772e-02f, 1.25800401e-01f, 1.16312765e-02f, 7.01805353e-02f,
  -2.63586566e-02f, 1.26074091e-01f, -7.08261097e-04f, -1.15397610e-02f, -1.05496002e-02f, -5.54875098e-02f, 6.01953194e-02f, 1.72352284e-01f, 1.82225071e-02f, 2.12426364e-01f,
  -5.30144610e-02f, -7.17172921e-02f, -7.62488768e-02f, -1.02064393e-01f, 8.89252946e-02f, -6.55482560e-02f, -5.32548651e-02f, 5.50877750e-02f, -1.21824965e-01f, 6.17063716e-02f,
  -7.73254186e-02f, -5.00854366e-02f, 7.31585696e-02f, 1.20823689e-01f, 1.26652747e-01f, -5.85423857e-02f, 1.72446370e-01f, -1.37477415e-02f, 2.21677870e-03f, 7.78333545e-02f,
  1.81793235e-02f, 1.12671956e-01f, 3.54301967e-02f, 1.22770451e-01f, -2.58960146e-02f, 3.05521879e-02f, 6.90088198e-02f, 4.72677611e-02f, 2.10362226e-02f, 1.09275237e-01f,
  6.35701343e-02f, 9.73296836e-02f, 7.90565833e-03f, -1.76534671e-02f, 1.32252201e-01f, 1.18400805e-01f, 1.97627887e-01f, -4.84322570e-02f, -8.74065310e-02f, -7.07496190e-03f,
  -1.51705444e-01f, -2.58519709e-01f, 5.13982354e-03f, 1.19096234e-01f, -6.66751061e-03f, 4.19702344e-02f, -2.10338794e-02f, -6.55380860e-02f, -5.41979671e-02f, 4.72806804e-02f,
  -1.28742233e-01f, 1.16894044e-01f, -9.84636843e-02f, -5.60059361e-02f, -7.85220787e-02f, 3.54292504e-02f, -3.87654752e-02f, -2.84717418e-02f, -4.74596098e-02f, 5.26641794e-02f,
  -8.49689096e-02f, -2.01315835e-01f, -2.25656986e-01f, -7.37588629e-02f, -1.55743986e-01f, -3.34569067e-01f, -3.12786430e-01f, -3.04943413e-01f, -3.11979055e-01f, -3.93413574e-01f,
  -7.72975624e-01f, -2.37652749e-01f, 8.44914019e-02f, -4.30289239e-01f, -1.69140711e-01f, -5.87447360e-02f, -1.68801323e-01f, -2.03030363e-01f, -3.02979976e-01f, -1.82403624e-01f,
  5.51944263e-02f, -9.92467068e-03f, 3.78345251e-02f, 1.38708912e-02f, -1.94853678e-01f, -2.21924201e-01f, -3.00443828e-01f, -1.54996127e-01f, -4.48856615e-02f, 1.06589206e-01f,
  -5.51677532e-02f, -3.34742814e-01f, -3.93507481e-01f, -1.28034770e-01f, -6.81903809e-02f, -5.39526250e-03f, -1.02737933e-01f, -3.57016772e-02f, -8.55726451e-02f, -1.49226978e-01f,
  3.31061453e-01f, -5.25262356e-02f, -6.61191996e-03f, -3.74402404e-02f, 3.75674926e-02f, -9.07897279e-02f, 3.28136384e-02f, -1.15422241e-01f, -5.12816347e-02f, 1.53844476e-01f,
  9.72064361e-02f, 7.22040758e-02f, 2.51846667e-03f, 4.61744852e-02f, 1.17796309e-01f, 1.28642574e-01f, 3.35915349e-02f, 7.98297748e-02f, -3.55922617e-02f, 1.46458685e-01f,
  1.76523551e-01f, 1.11207612e-01f, 2.45187193e-01f, 1.26002133e-01f, 1.21435806e-01f, 6.83949441e-02f, 2.13866532e-01f, 1.97550148e-01f, 5.80767542e-02f, 1.15428552e-01f,
  -1.22132972e-01f, -1.40575124e-02f, 7.02357069e-02f, 1.13447467e-02f, 8.01675990e-02f, 6.71730489e-02f, 8.96965936e-02f, 1.35859251e-01f, -7.20814839e-02f, 4.92155030e-02f,
  7.90922493e-02f, 3.33313830e-04f, -2.95687281e-02f, -5.86865060e-02f, -3.41056138e-02f, 3.18504944e-02f, 1.31272208e-02f, -6.06863853e-03f, 1.39711276e-01f, -7.02718869e-02f,
  -3.22980992e-02f, 1.29862890e-01f, -1.18789889e-01f, 1.35769367e-01f, 4.47411016e-02f, 3.63501087e-02f, -5.66429133e-03f, 1.32989297e-02f, 7.27467355e-04f, 3.48349172e-03f,
  1.15623884e-01f, -9.50445756e-02f, -1.04192451e-01f, 3.09122130e-02f, -1.27629694e-02f, -3.16114016e-02f, -6.99004382e-02f, -1.05191872e-01f, -4.25741263e-02f, 4.92154211e-02f,
  2.36313809e-02f, -1.91705907e-03f, -2.91516054e-02f, 7.75984451e-02f, 1.05645955e-01f, 1.43782288e-01f, 1.18728857e-02f, 1.55222295e-02f, -1.49843069e-02f, 1.33725435e-01f,
  -4.46111038e-02f, 2.73162555e-02f, 1.40318617e-01f, 1.08123258e-01f, 7.78926611e-02f, 1.70147821e-01f, 1.75173014e-01f, 2.65665445e-02f, 1.17451161e-01f, 1.35303915e-01f,
  -6.24785483e-01f, 9.91090685e-02f, 2.55081654e-01f, -3.28002453e-01f, -6.93927854e-02f, 1.95253808e-02f, 1.77241534e-01f, -2.04961434e-01f, -2.25121558e-01f, 1.19254529e-01f,
  1.31036788e-01f, -6.99539334e-02f, -5.04085980e-03f, -6.25476390e-02f, -1.20814502e-01f, 1.63172171e-01f, -2.39950791e-02f, -2.26810902e-01f, -3.25295955e-01f, -3.12090337e-01f,
  -1.66165844e-01f, -2.87624449e-01f, -3.54013503e-01f, -2.24628642e-01f, 3.25526409e-02f, -9.71239731e-02f, -7.47382408e-03f, -1.62536532e-01f, -8.32065418e-02f, 9.35052112e-02f,
  3.10614645e-01f, -1.99381113e-01f, -5.88305332e-02f, -2.04880729e-01f, 9.12489370e-02f, -6.64626807e-02f, 3.87801006e-02f, 3.43830995e-02f, 9.01114009e-03f, 6.21259096e-04f,
  -1.28384367e-01f, -8.23710337e-02f, 5.11508668e-03f, 7.05294386e-02f, 1.09896669e-02f, 4.20949655e-03f, 2.79470738e-02f, 1.37739563e-02f, 3.66652273e-02f, 1.64914295e-01f,
  1.18756793e-01f, -7.44513199e-02f, -1.47358952e-02f, 2.96986867e-02f, 7.03211455e-03f, -2.16853456e-03f, -1.72096696e-02f, -1.07983790e-01f, -7.28931427e-02f, 2.58277915e-03f,
  -3.84608172e-02f, 7.86436424e-02f, 2.56047938e-02f, -1.04489833e-01f, 9.71041918e-02f, 4.45091575e-02f, 2.26582065e-02f, 1.23616345e-01f, -1.57484308e-01f, 8.03358760e-03f,
  1.44776672e-01f, 1.11035250e-01f, -1.71959009e-02f, -1.18168006e-02f, -1.67361908e-02f, -2.10528057e-02f, -4.44054380e-02f, 2.77993120e-02f, 5.81731796e-02f, 2.81995032e-02f,
  -1.17503703e-01f, -3.87071483e-02f, 9.33364481e-02f, -6.16677739e-02f, 2.11806949e-02f, 5.75184040e-02f, -7.91459605e-02f, -2.32760571e-02f, -1.63783934e-02f, -4.58938219e-02f,
  1.92094489e-03f, -1.13276452e-01f, 1.16795272e-01f, -4.56758104e-02f, 3.71600576e-02f, 9.30514708e-02f, 7.43685812e-02f, 6.00319356e-02f, 3.68969291e-02f, 4.32931408e-02f,
  -4.79634404e-02f, 7.05047026e-02f, 1.12493329e-01f, 1.49566323e-01f, -2.60408446e-02f, 1.07229343e-02f, 1.17014900e-01f, -6.42061159e-02f, 1.13425655e-02f, 1.94890663e-01f,
  6.21711425e-02f, -5.01858667e-02f, 2.02233568e-02f, 1.11128792e-01f, -2.71564964e-02f, -9.40999836e-02f, 3.98472324e-02f, 7.68306032e-02f, 1.04095004e-01f, 1.75840646e-01f,
  5.23679852e-01f, -1.11634843e-01f, -2.31580138e-01f, 2.07753032e-01f, -3.31415057e-01f, -2.75209934e-01f, -2.83125520e-01f, 4.25769873e-02f, 1.55332506e-01f, -2.41686236e-02f,
  -2.37453833e-01f, -1.40338019e-01f, -3.80828455e-02f, 7.71324092e-04f, -3.90812531e-02f, -9.19951200e-02f, 2.14711539e-02f, 6.96925148e-02f, -1.21519744e-01f, -2.65065789e-01f,
  -9.24087986e-02f, 4.59306352e-02f, 1.58585921e-01f, -6.63308352e-02f, -1.13104336e-01f, -8.11123177e-02f, -3.91799621e-02f, -3.77709195e-02f, -2.93999165e-01f, -1.69166163e-01f,
  -7.14144930e-02f, -1.72623321e-02f, -2.04370871e-01f, -1.43759578e-01f, -1.12501591e-01f, 2.11074669e-02f, -1.12610042e-01f, -3.38544026e-02f, -1.61736868e-02f, -2.32476145e-02f,
  -9.04211104e-02f, -2.41538480e-01f, -7.69531205e-02f, -1.51828066e-01f, 1.06241964e-02f, -1.08000459e-02f, -6.08176272e-03f, 4.36875261e-02f, 4.16075177e-02f, 2.85021719e-02f,
  -6.06121495e-02f, -3.39419246e-02f, 8.75388756e-02f, -9.62846279e-02f, 7.06878081e-02f, 6.29040003e-02f, -1.30167767e-01f, -1.19870983e-01f, -1.68768466e-01f, 7.38297477e-02f,
  4.96782735e-02f, -1.13405555e-01f, -1.48003355e-01f, 1.48362726e-01f, 3.91156860e-02f, 1.13742910e-02f, 4.55445573e-02f, 5.38787842e-02f, -2.25695334e-02f, 1.55137748e-01f,
  -6.77414015e-02f, 7.21531454e-03f, -6.62044287e-02f, 4.15994599e-02f, 5.02885245e-02f, -9.53363776e-02f, -3.88505720e-02f, 1.76499151e-02f, -2.67313346e-02f, 9.23044607e-02f,
  4.11691219e-02f, -6.68918528e-03f, 4.05094260e-03f, 1.14836998e-01f, 8.50435533e-03f, 7.39449188e-02f, 7.61802727e-03f, -1.27941564e-01f, 2.37497836e-02f, 1.31329559e-02f,
  2.80208558e-01f, -2.64275581e-01f, 2.27371201e-01f, 2.45115552e-02f, 1.52668715e-01f, 8.19198973e-03f, -8.70649144e-02f, -4.86789271e-02f, 2.19674110e-02f, -2.48262752e-02f,
  -1.64530531e-01f, 3.82398404e-02f, 5.19210193e-03f, -3.04912310e-02f, -1.72742516e-01f, -1.51752397e-01f, -9.62769017e-02f, 5.83802834e-02f, -6.48057461e-02f, -1.17361816e-02f,
  1.36695519e-01f, -1.18736934e-03f, 2.43025228e-01f, 1.78827137e-01f, 2.09563542e-02f, 1.33403793e-01f, 3.80119565e-03f, -9.17802453e-02f, 1.02323368e-02f, 3.15593839e-01f,
  -8.49412680e-02f, 4.94608330e-03f, -3.95678073e-01f, -1.69762179e-01f, -4.57138211e-01f, -2.47960642e-01f, -1.99457526e-01f, 9.12186503e-02f, 4.80003506e-02f, -5.84343709e-02f,
  1.20046316e-02f, -3.30317989e-02f, 1.01937745e-02f, 1.68907389e-01f, 2.67282397e-01f, -2.24016588e-02f, -5.80136925e-02f, -7.87789896e-02f, 2.68978886e-02f, 3.58384289e-02f,
  -9.91986878e-03f, 1.15478151e-01f, 1.62121743e-01f, 4.16961871e-02f, -1.67723984e-01f, -1.07180804e-01f, -2.35660642e-01f, -2.05881104e-01f, -2.06608638e-01f, -3.81683409e-01f,
  -2.40728796e-01f, -3.95808339e-01f, -5.79992197e-02f, -4.44737002e-02f, -1.84306368e-01f, -1.59825996e-01f, -2.93840077e-02f, 1.53542636e-02f, 9.39926505e-03f, -4.42799032e-02f,
  -2.72969723e-01f, 2.48383153e-02f, -1.42341852e-01f, -1.78470775e-01f, -6.60775006e-02f, -8.72144550e-02f, 1.30074903e-01f, 2.69434154e-02f, 1.29709281e-02f, 2.55331323e-02f,
  6.89659193e-02f, -2.41317049e-01f, -1.58613056e-01f, 2.06122221e-03f, -3.34390625e-02f, -4.91596833e-02f, -8.84765536e-02f, 1.19306650e-02f, 2.82835029e-03f, 7.35186264e-02f,
  -2.76548378e-02f, -2.63482835e-02f, 1.41592054e-02f, -5.71888173e-03f, 5.30862883e-02f, 6.64557070e-02f, -5.68721443e-02f, -3.98899727e-02f, 8.27595126e-03f, 1.94123089e-01f,
  2.82035861e-02f, 9.02488679e-02f, 1.00404032e-01f, -1.55716076e-01f, -1.60922445e-02f, 8.78434107e-02f, 8.90666917e-02f, 1.43966854e-01f, 2.02391185e-02f, -6.24165274e-02f,
  -2.96725370e-02f, 1.58335473e-02f, -3.68626751e-02f, 5.39228544e-02f, -6.25984743e-02f, 5.62701840e-03f, -7.18523562e-02f, 1.39330149e-01f, -3.08897393e-03f, 5.15210517e-02f,
  -1.78040937e-02f, 1.25866443e-01f, -1.63160022e-02f, -8.44358187e-03f, -7.88067952e-02f, -7.05530569e-02f, -5.31951562e-02f, 6.98781237e-02f, -7.73598487e-03f, -1.21786170e-01f,
  9.13398638e-02f, 9.92337987e-02f, 1.88708697e-02f, -4.20696773e-02f, -2.75378465e-04f, -8.63585100e-02f, 1.61138430e-01f, 5.06177545e-02f, -1.60404090e-02f, 2.25115269e-01f,
  3.23001206e-01f, 2.05716506e-01f, 1.27048776e-01f, 9.50336829e-02f, -5.39818257e-02f, 3.79689671e-02f, 1.48077309e-01f, 9.05006081e-02f, 1.53031483e-01f, 3.83657783e-01f,
  4.13159072e-01f, -9.93941799e-02f, 1.74752995e-01f, 6.56736419e-02f, -2.49065414e-01f, -1.13444738e-01f, -1.21238485e-01f, 4.35844250e-02f, -2.17817742e-02f, 4.79954891e-02f,
  1.55729488e-01f, 2.44174853e-01f, 2.28704691e-01f, 1.47071689e-01f, 2.19450012e-01f, -2.68989597e-02f, -1.43397808e-01f, 1.92245752e-01f, 1.65309221e-01f, -9.16521400e-02f,
  -1.80757597e-01f, -9.23300460e-02f, -8.95749405e-03f, 8.95289704e-02f, -2.31937334e-01f, 1.33982867e-01f, -3.37345898e-02f, -1.34586856e-01f, -5.02548255e-02f, -6.18254468e-02f,
  -6.97136521e-02f, 1.09897673e-01f, 7.03612939e-02f, 3.44787426e-02f, -4.09355089e-02f, 7.04909191e-02f, 2.11410802e-02f, -7.83199072e-02f, -1.22735672e-01f, 4.52671266e-05f,
  5.97710125e-02f, 2.41535418e-02f, -9.06914845e-02f, -1.09673060e-01f, -1.61510095e-01f, -1.26577332e-03f, 2.03218078e-03f, 1.50817618e-01f, 1.84104323e-01f, -1.13698896e-02f,
  -6.98918477e-02f, -6.38981014e-02f, 1.09085247e-01f, -1.78994872e-02f, 1.12641133e-01f, 7.82465339e-02f, 4.54909801e-02f, 1.17815219e-01f, 1.83590159e-01f, 1.39602929e-01f,
  1.96941569e-01f, 9.49189365e-02f, 1.03476599e-01f, 1.19160451e-01f, -8.60977843e-02f, 1.31543614e-02f, -9.95565057e-02f, -1.44563345e-02f, 1.02692544e-01f, -5.78426309e-02f,
  -4.65676971e-02f, -4.65871207e-03f, 9.91647467e-02f, -8.73114541e-02f, -1.52735338e-02f, 4.42548580e-02f, 6.31260946e-02f, 1.98961776e-02f, 7.53101110e-02f, 7.51074702e-02f,
  -1.63782723e-02f, 3.04453797e-03f, -7.97825381e-02f, -9.55597013e-02f, -1.66840218e-02f, 8.91007781e-02f, 1.09446876e-01f, -7.78485462e-02f, -1.44655883e-01f, -1.08183637e-01f,
  -1.48955464e-01f, 2.75481433e-01f, 7.04467436e-03f, 9.45753083e-02f, -2.76934467e-02f, 4.95311208e-02f, 2.03789026e-01f, -1.38502613e-01f, -3.43501642e-02f, -2.63182372e-02f,
  -4.32790853e-02f, 3.65986228e-02f, 1.35501981e-01f, -1.41135782e-01f, -5.24718910e-02f, -3.37627605e-02f, 1.08105049e-01f, 7.38080069e-02f, 7.44917765e-02f, -2.72151781e-03f,
  1.27327386e-02f, -8.80602980e-04f, 7.35065117e-02f, 8.08731988e-02f, -1.36280600e-02f, 1.88237369e-01f, -7.18231201e-02f, -8.20251927e-02f, 9.79875550e-02f, -4.38134447e-02f,
  4.59591359e-01f, -1.12967215e-01f, 3.22588205e-01f, 2.55123079e-01f, 1.55496895e-01f, 1.49589941e-01f, 4.06742133e-02f, 4.57008742e-02f, 5.15856892e-02f, 3.97327840e-02f,
  1.52668282e-01f, 1.60059154e-01f, 2.90033687e-02f, 1.34051293e-01f, -2.32422315e-02f, -3.94603461e-02f, -2.42220331e-02f, 1.30699664e-01f, 2.79383421e-01f, 1.56368136e-01f,
  -9.11839753e-02f, -5.12548611e-02f, 7.44441897e-02f, -8.24249983e-02f, -5.77538572e-02f, 3.80098261e-02f, -9.00601819e-02f, -7.18710423e-02f, -3.93875390e-02f, -6.74534962e-02f,
  1.27454713e-01f, -8.13350268e-03f, 1.14736915e-01f, 1.52535168e-02f, -7.95033500e-02f, -1.29543096e-01f, 3.50258574e-02f, -4.33402508e-02f, -5.17964996e-02f, -1.49251208e-01f,
  -1.22065172e-01f, -3.00630294e-02f, -4.14326265e-02f, -1.02484688e-01f, -1.01853505e-01f, 5.98447677e-03f, -9.54537690e-02f, 3.51594687e-02f, 7.32677206e-02f, -8.15333650e-02f,
  -1.25036687e-01f, 5.28899431e-02f, -1.18309679e-02f, 6.50093481e-02f, -4.26382432e-03f, 1.39591739e-01f, 7.62437806e-02f, 5.82136922e-02f, 1.00391492e-01f, 6.59352820e-03f,
  1.18859701e-01f, 1.89137414e-01f, 1.40834227e-01f, -7.51766264e-02f, -1.83338821e-02f, 1.80797018e-02f, 3.21328193e-02f, -4.64062281e-02f, -2.23297309e-02f, -6.61881343e-02f,
  5.77379651e-02f, 7.77987167e-02f, 1.81395821e-02f, -1.94155518e-02f, 3.71269621e-02f, 3.76034086e-03f, 7.60966027e-03f, 8.79940614e-02f, 8.81596878e-02f, -3.57351382e-03f,
  -3.77455652e-02f, -1.15378946e-02f, 1.26231477e-01f, 2.73768902e-02f, -4.24241424e-02f, 3.65934633e-02f, 2.37309672e-02f, 3.92844714e-02f, 6.09662496e-02f, -4.56013680e-02f,
  -3.93571854e-01f, 2.09004626e-01f, -8.06533918e-03f, -1.70022383e-01f, 3.33334878e-02f, 2.57261805e-02f, 1.36465326e-01f, -7.01536834e-02f, -1.50658429e-01f, -1.06338166e-01f,
  9.24119540e-03f, 4.27225307e-02f, -5.00937179e-02f, -1.05706669e-01f, 1.31676784e-02f, 2.05402486e-02f, -4.50736769e-02f, 5.49181849e-02f, -8.54574367e-02f, -1.21869706e-02f,
  -1.09390467e-01f, -1.18534807e-02f, 1.50147766e-01f, 9.80893746e-02f, -8.62650946e-02f, 1.46704257e-01f, -4.54269946e-02f, 4.18738164e-02f, 9.46308672e-02f, 2.47305855e-02f,
  2.04717308e-01f, 5.67742251e-02f, 2.00348437e-01f, 3.08026075e-01f, -1.65547580e-01f, -4.00483757e-01f, -5.25962293e-01f, -1.88857302e-01f, 9.81287956e-02f, -1.60775423e-01f,
  -1.59990311e-01f, 8.18744116e-03f, 5.87188117e-02f, -1.72691531e-02f, -2.72791266e-01f, -2.05191702e-01f, -4.34932634e-02f, -1.28138110e-01f, -2.88685888e-01f, -3.54011744e-01f,
  -2.76803553e-01f, 2.55817566e-02f, 2.24400088e-02f, 4.61996533e-02f, 2.29873642e-01f, 1.01030342e-01f, 9.97984782e-02f, -1.25101553e-02f, -9.43164527e-02f, 1.97686031e-01f,
  -9.84453112e-02f, 1.40732273e-01f, -2.31281579e-01f, -5.71555421e-02f, 9.85009223e-02f, 3.52655239e-02f, -7.38069862e-02f, 4.76636998e-02f, 6.41653463e-02f, -7.04923421e-02f,
  -3.79507951e-02f, -9.24215764e-02f, 6.00064266e-03f, 3.08420472e-02f, -5.72632030e-02f, -6.12521954e-02f, 1.03115914e-02f, 5.06514572e-02f, 3.41966860e-02f, 6.43385388e-03f,
  -1.12607062e-01f, -9.64326710e-02f, -6.90282062e-02f, 2.39443369e-02f, -3.03232707e-02f, -3.66254672e-02f, -4.71948162e-02f, 1.29532605e-01f, 4.86503504e-02f, 1.83653742e-01f,
  -3.05991560e-01f, 4.18439284e-02f, -1.69595748e-01f, -6.18337877e-02f, -1.62261918e-01f, -9.11922902e-02f, -9.26138535e-02f, -3.24419364e-02f, -1.05340734e-01f, -5.53023815e-02f,
  -5.88860288e-02f, -4.78535593e-02f, -3.64492126e-02f, 3.07124406e-02f, 4.33464274e-02f, -2.82362793e-02f, -4.40173559e-02f, -1.21415257e-01f, -3.32700573e-02f, -5.35921492e-02f,
  -6.39934316e-02f, -3.70111428e-02f, -2.75992285e-02f, -8.69662222e-03f, -9.22760293e-02f, 3.23285647e-02f, 2.15390176e-02f, -9.09212530e-02f, 4.69639227e-02f, -8.72567594e-02f,
  2.82861143e-01f, -3.41526777e-01f, 8.13482627e-02f, -3.52091715e-02f, -4.64604422e-02f, 4.21925448e-02f, 4.85635214e-02f, -1.20245658e-01f, 5.42149618e-02f, -1.46623015e-01f,
  -1.47007871e-02f, -2.95151584e-02f, 2.00690165e-01f, 1.87150881e-01f, -1.79437146e-01f, -6.83708563e-02f, -1.75093208e-02f, 7.75961485e-03f, 7.84169789e-03f, 1.19100057e-01f,
  7.39723369e-02f, -2.00619653e-01f, -1.25540882e-01f, 9.22975466e-02f, 8.14536586e-02f, -4.54816893e-02f, 6.20090850e-02f, 1.41176075e-01f, -1.21975943e-01f, -5.72748221e-02f,
  3.33476841e-01f, -2.13774040e-01f, 1.72629595e-01f, 1.61322430e-01f, 1.85971722e-01f, 1.69829369e-01f, 3.16880405e-01f, 9.93820503e-02f, 1.55878635e-02f, -8.12981129e-02f,
  -3.46532255e-01f, -4.42745745e-01f, -3.06610882e-01f, -3.70786428e-01f, -1.45970181e-01f, 2.12650135e-01f, 2.58569121e-01f, 1.51561886e-01f, 1.10884525e-01f, 1.45441189e-01f,
  4.68679965e-02f, 1.58142328e-01f, 5.26094660e-02f, 8.69867355e-02f, -7.76601024e-03f, -9.22652856e-02f, 7.72821903e-02f, -3.76434326e-02f, -4.23400998e-02f, 6.05151579e-02f,
  -5.85731491e-02f, -1.45040438e-01f, 7.35265668e-03f, -3.40793245e-02f, -1.31117597e-01f, -5.52336909e-02f, -1.28488407e-01f, -5.66418804e-02f, 2.38084663e-02f, -1.81358904e-02f,
  -6.82301000e-02f, -4.43377942e-02f, -8.14108774e-02f, -5.46606369e-02f, 1.15085587e-01f, -8.26265067e-02f, -4.29979935e-02f, 5.68352118e-02f, -6.33780658e-02f, -1.13057047e-01f,
  -1.81272641e-01f, -1.48353521e-02f, 9.95074138e-02f, -6.04575239e-02f, -5.58300130e-02f, -1.78295244e-02f, -1.17672302e-01f, 9.71774235e-02f, -8.56431797e-02f, 1.16749465e-01f,
  -6.57725632e-02f, -6.05930835e-02f, -1.75607242e-02f, -4.61518466e-02f, 4.16609757e-02f, -3.62333329e-03f, 1.16621405e-01f, 2.40494907e-02f, 4.27470170e-02f, -6.03386723e-02f,
  2.71834545e-02f, -1.32325187e-01f, -8.31039920e-02f, 3.29832151e-03f, -1.00140460e-01f, -8.75835307e-03f, -8.88561364e-03f, -9.15201828e-02f, -1.24791041e-01f, -9.16918740e-02f,
  -1.31998792e-01f, 4.95382622e-02f, -7.82420335e-04f, -4.80650784e-03f, -1.45964578e-01f, 3.98578681e-02f, -1.02978438e-01f, -1.32974222e-01f, 2.17088144e-02f, -5.95624745e-03f,
  -1.77962214e-01f, -2.29260981e-01f, 7.64390687e-03f, -3.59789319e-02f, 5.01706898e-02f, -2.68265754e-02f, -1.21953212e-01f, -6.46529421e-02f, -1.11186290e-02f, 3.36368829e-02f,
  -6.47589788e-02f, 1.96464192e-02f, -1.09030530e-01f, -8.79255533e-02f, 1.47362456e-01f, 5.02641015e-02f, -9.02686939e-02f, 6.41420037e-02f, -3.19689587e-02f, 7.54815191e-02f,
  4.87800762e-02f, 1.57382548e-01f, 5.86217195e-02f, 9.79242474e-02f, -9.51105915e-03f, 1.45131409e-01f, 3.37717980e-02f, 9.22986642e-02f, 1.19059905e-01f, 2.71004856e-01f,
  -4.32560712e-01f, -1.72798440e-01f, -1.23410419e-01f, 1.25191510e-01f, 1.00198045e-01f, 7.09223896e-02f, 1.45889342e-01f, 9.68877524e-02f, 1.40950516e-01f, 7.63967484e-02f,
  1.30908675e-02f, 1.03732474e-01f, 5.57725020e-02f, 1.48258358e-01f, 1.56893715e-01f, 1.44507930e-01f, 6.31973743e-02f, -5.97310904e-03f, -7.32925087e-02f, 8.70007575e-02f,
  3.77981476e-02f, -3.30202058e-02f, -1.67552769e-01f, 6.89078048e-02f, 2.21993886e-02f, 8.90528038e-02f, 9.31929573e-02f, -2.20605657e-02f, 7.17022419e-02f, -3.93170416e-02f,
  -1.30872190e-01f, -8.01592842e-02f, 1.09954692e-01f, 1.55530363e-01f, -7.64884800e-02f, -7.18536079e-02f, 1.09641925e-02f, -1.28358006e-01f, 1.71529762e-02f, 1.69707052e-02f,
  1.08558029e-01f, -1.67407393e-02f, 5.43345213e-02f, -1.09898403e-01f, -3.20201255e-02f, -6.14080392e-02f, -5.49836904e-02f, 8.26839581e-02f, 1.48626998e-01f, 4.15843772e-03f,
  1.55574724e-01f, 1.04024306e-01f, 7.33924955e-02f, 1.22276649e-01f, 2.17809796e-01f, 9.81100574e-02f, 3.99608575e-02f, 4.49802987e-02f, 1.70699969e-01f, 4.57951538e-02f,
  2.46679053e-01f, 5.28066605e-02f, 7.64139295e-02f, -6.20777011e-02f, -1.63332596e-02f, -6.31961972e-02f, 6.43057153e-02f, 4.22732569e-02f, 4.29883525e-02f, -1.39800578e-01f,
  6.32814765e-02f, 9.49856862e-02f, 2.19478700e-02f, 1.60489045e-02f, 1.11000486e-01f, -4.10238504e-02f, 4.51315343e-02f, 5.81556894e-02f, 7.09607601e-02f, -1.06667243e-02f,
  -1.93701927e-02f, 1.05946414e-01f, -1.04211584e-01f, 4.79596965e-02f, 1.11066945e-01f, 1.61091357e-01f, 7.42544681e-02f, -3.62930857e-02f, -2.49164272e-02f, -6.58264086e-02f,
  5.40790558e-02f, 1.67353034e-01f, -9.00077745e-02f, -5.66406809e-02f, -6.28637150e-02f, -8.72198418e-02f, -8.38425979e-02f, -9.14656743e-03f, -6.06651753e-02f, 1.59266859e-01f,
  -2.23547444e-02f, -1.16250269e-01f, 3.17287445e-02f, -6.56421334e-02f, -3.33303362e-02f, -1.13458550e-02f, 5.30298874e-02f, 6.13231808e-02f, 2.12198198e-01f, 9.33164954e-02f,
  1.28929377e-01f, 8.31859857e-02f, 4.66253720e-02f, 1.23419262e-01f, 7.50032067e-02f, 3.64614986e-02f, -4.43263836e-02f, -9.27354246e-02f, -4.39133607e-02f, -1.76279888e-01f,
  3.52234155e-01f, -5.17401397e-01f, 2.52223480e-02f, 1.44604385e-01f, 2.59658724e-01f, 2.73268968e-01f, 3.27240340e-02f, 1.21891513e-01f, 6.76482245e-02f, -1.27401620e-01f,
  -2.53470898e-01f, -2.68779695e-02f, -9.73685235e-02f, -7.41172433e-02f, -2.64460333e-02f, 9.76292789e-02f, 2.91755080e-01f, 2.69960374e-01f, 3.87971193e-01f, 1.24446750e-01f,
  -9.18270946e-02f, -3.69842499e-02f, -3.29784229e-02f, 2.94871684e-02f, -1.89624637e-01f, 3.83749530e-02f, -1.44812241e-01f, -1.18666187e-01f, -1.04810528e-01f, -1.48180807e-02f,
  -8.89152288e-02f, -2.74569362e-01f, 1.59142569e-01f, -1.98103115e-01f, -9.18240547e-02f, -1.96870067e-03f, -7.64525682e-02f, -4.29628454e-02f, -1.57668561e-01f, 1.31311174e-03f,
  -1.85412709e-02f, -6.02844991e-02f, 2.07547247e-02f, -1.29756272e-01f, -3.26403491e-02f, -5.75253665e-02f, -7.91276991e-02f, -8.18816721e-02f, -6.26788847e-03f, -4.20520417e-02f,
  -1.72055930e-01f, 3.10623180e-02f, -1.58937536e-02f, -1.13910092e-02f, -1.41374245e-01f, 1.34858593e-01f, -1.05253890e-01f, -5.68205193e-02f, -9.74302143e-02f, -1.56301148e-02f,
  9.32239592e-02f, 1.13290392e-01f, 1.02291249e-01f, -5.32660335e-02f, 2.16828417e-02f, 1.28256619e-01f, 5.56572974e-02f, 1.02468748e-02f, 3.33788246e-02f, 5.02847433e-02f,
  5.96922636e-02f, 1.32605704e-02f, -8.74897745e-03f, -2.06078291e-02f, 1.63774546e-02f, 1.00640602e-01f, 1.29740864e-01f, -9.29236487e-02f, 1.83608513e-02f, 9.80065167e-02f,
  1.86361130e-02f, -2.15707738e-02f, 5.44511527e-02f, 6.01692386e-02f, 1.02417292e-02f, -2.90502440e-02f, 1.11689698e-03f, -1.00529278e-02f, -3.55564244e-02f, 7.62307569e-02f,
  -1.88944146e-01f, -7.39442110e-02f, 1.54124618e-01f, -2.04593651e-02f, -4.48179692e-02f, -1.90640375e-01f, -6.17388934e-02f, -1.56167001e-01f, -7.53864348e-02f, -1.19563334e-01f,
  -2.00896606e-01f, -3.37605551e-02f, -1.45810068e-01f, -1.52486237e-02f, 1.01189144e-01f, 1.26975045e-01f, -8.49706307e-02f, 1.67933673e-01f, 8.33906755e-02f, -3.73719372e-02f,
  -4.89926748e-02f, 1.44055679e-01f, 1.51672229e-01f, 1.61207661e-01f, 8.26038048e-03f, 1.56997189e-01f, 1.32372513e-01f, 1.94054633e-01f, 2.00029910e-01f, 2.05574900e-01f,
  -4.91405368e-01f, 2.11720746e-02f, -2.02351138e-01f, 1.25403732e-01f, 2.67096579e-01f, 1.26085535e-01f, 2.46579155e-01f, 1.00148330e-02f, 2.67086010e-02f, 8.46505258e-03f,
  -1.05648823e-01f, 2.65353709e-03f, 5.76518923e-02f, 4.34695072e-02f, 6.83132187e-02f, 1.17498852e-01f, 2.36409947e-01f, -6.38319328e-02f, 7.83009902e-02f, 9.10814703e-02f,
  8.34114328e-02f, -1.55363074e-02f, -1.50098771e-01f, 9.31773633e-02f, -1.80318262e-02f, 9.57882628e-02f, -1.26456597e-03f, -3.46767381e-02f, 1.75936997e-01f, 1.15306474e-01f,
  -2.33809441e-01f, -3.15900236e-01f, 3.21748629e-02f, 2.02043764e-02f, -1.33083597e-01f, -1.76902160e-01f, -1.08996846e-01f, -2.08719060e-01f, -4.27856147e-02f, -9.21393633e-02f,
  -1.09104738e-01f, -1.55342549e-01f, 1.80857167e-01f, 1.98857747e-02f, -1.41263217e-01f, -3.18963267e-02f, -7.69334882e-02f, -2.44556516e-01f, -2.50633150e-01f, -1.56544447e-01f,
  1.33708209e-01f, -7.61358514e-02f, -2.16207996e-01f, 5.99877760e-02f, -1.53484479e-01f, 1.56411082e-02f, 1.60739720e-02f, -1.04083747e-01f, -2.12310463e-01f, -2.87930667e-01f,
  -9.56876855e-03f, 1.22270480e-01f, 4.74551097e-02f, 9.11398903e-02f, -8.84028599e-02f, 5.64037897e-02f, 1.43205673e-01f, 2.04928234e-01f, 5.00952899e-02f, -1.38872072e-01f,
  1.24090381e-01f, -1.05402827e-01f, 2.67381556e-02f, 1.11353910e-02f, 4.50350251e-03f, 2.86655892e-02f, 3.28698494e-02f, 5.37040532e-02f, -8.89316201e-02f, -9.67609584e-02f,
  4.76183090e-03f, -1.34032778e-02f, 7.87345544e-02f, -2.16826852e-02f, 1.49065197e-01f, -1.82735678e-02f, 1.69944271e-01f, 1.07652798e-01f, -4.07460555e-02f, -7.72927999e-02f,
  -1.31075546e-01f, 6.51699007e-02f, -1.10020973e-02f, 1.54231137e-04f, -3.03921439e-02f, -2.62902882e-02f, -6.29013171e-03f, -1.34114459e-01f, 1.37588590e-01f, -8.27887729e-02f,
  -4.30191904e-02f, -3.96146663e-02f, 3.42899673e-02f, 1.23254038e-01f, 2.63889842e-02f, 1.27745852e-01f, 7.56563842e-02f, 2.21252739e-01f, 5.71721755e-02f, -1.16561629e-01f,
  2.52001733e-02f, 5.72289005e-02f, -1.73429772e-01f, -3.61993909e-02f, -3.28495987e-02f, 1.16241463e-01f, -6.38553780e-03f, -4.44969907e-02f, 2.50488538e-02f, -8.28036144e-02f,
  3.33838999e-01f, 2.76328713e-01f, 2.24667415e-01f, 1.15402311e-01f, -1.99030995e-01f, -1.56172469e-01f, 2.29689968e-03f, 1.03311524e-01f, -7.34753208e-03f, 1.08660735e-01f,
  8.12193453e-02f, 7.61267766e-02f, 2.77638771e-02f, 2.21498888e-02f, 1.31786272e-01f, 1.71875004e-02f, -9.54988077e-02f, 6.96520656e-02f, 7.11979568e-02f, -5.68412505e-02f,
  -2.02319510e-02f, -1.09776773e-01f, 8.63388181e-02f, 6.47611991e-02f, -4.26422581e-02f, -7.53015652e-02f, -2.33837664e-02f, 5.84065216e-03f, -1.51245177e-01f, 9.59352702e-02f,
  2.23657906e-01f, 9.57927927e-02f, 7.52691850e-02f, -1.10579254e-02f, 9.01186094e-02f, 5.56114949e-02f, 1.08950958e-01f, 1.35155290e-01f, -9.41883847e-02f, 5.91363758e-02f,
  -6.66881353e-02f, 5.38320951e-02f, 3.71839968e-03f, 3.66776995e-02f, 5.56726865e-02f, -3.94876041e-02f, 1.88455377e-02f, 1.40166789e-01f, 1.10637426e-01f, 5.29254265e-02f,
  6.31195083e-02f, -2.48455768e-03f, 2.88817305e-02f, -9.74673256e-02f, -5.17908782e-02f, -1.59639969e-01f, 4.46122251e-02f, -6.88337954e-03f, -3.54920141e-03f, 1.10865355e-01f,
  3.06473598e-02f, 9.34009179e-02f, 1.42371133e-01f, -3.56352404e-02f, -4.66982611e-02f, -1.31862029e-01f, -2.78447066e-02f, -7.37997144e-02f, -1.44718915e-01f, -1.19512059e-01f,
  -2.85812262e-02f, 8.03878754e-02f, 7.21210148e-03f, 2.12221220e-03f, 2.26248186e-02f, 7.88679793e-02f, -6.37318119e-02f, 1.96949482e-01f, -6.25619218e-02f, 4.59458539e-03f,
  -2.03584488e-02f, 4.51593995e-02f, 3.07640973e-02f, 5.72686316e-03f, 1.16183333e-01f, 1.28117114e-01f, 3.04159541e-02f, -9.73975938e-03f, -1.05707325e-01f, -5.06360866e-02f,
  2.19988629e-01f, -1.11774422e-01f, 4.29479629e-02f, 8.15206096e-02f, 3.08601614e-02f, 1.36037409e-01f, 1.71956923e-02f, 4.83897850e-02f, 3.16008776e-02f, -7.59956986e-03f,
  1.15311079e-01f, 7.60037825e-02f, 7.62261674e-02f, -3.13647725e-02f, -6.07699864e-02f, -8.16182122e-02f, 1.09072283e-01f, 1.81540012e-01f, 8.44443962e-02f, 1.33844510e-01f,
  5.35746552e-02f, 7.68526942e-02f, 7.82251507e-02f, -8.88961926e-02f, -4.13901769e-02f, -1.34105995e-01f, -5.78119457e-02f, -3.91499931e-03f, 7.99428970e-02f, -4.28255275e-02f,
  4.13043618e-01f, -7.30616450e-02f, 6.68956991e-03f, 7.46707171e-02f, 7.43047372e-02f, -1.40542760e-01f, -1.22043438e-01f, -7.80070722e-02f, 4.79381252e-03f, 1.78184599e-01f,
  1.30102724e-01f, 1.51325196e-01f, 4.59748805e-02f, 3.63198258e-02f, 7.89338201e-02f, 2.32272651e-02f, -5.80889508e-02f, -1.29991630e-02f, -3.19077447e-03f, 9.73041877e-02f,
  -1.30926799e-02f, 1.02728605e-01f, 1.69377208e-01f, 1.33719593e-02f, 6.07386939e-02f, 9.32625830e-02f, 8.38270783e-02f, 1.36560753e-01f, 5.93987480e-02f, -8.03198293e-02f,
  2.47779265e-01f, 3.56345862e-01f, 2.12688763e-02f, 1.42793609e-02f, 1.78174272e-01f, 5.17930537e-02f, 5.31650931e-02f, 2.72531100e-02f, 9.72013697e-02f, 4.70358506e-02f,
  -4.24683839e-02f, -1.91623974e-03f, 8.48070085e-02f, 1.15276590e-01f, 3.55942324e-02f, 1.55564159e-01f, 8.50815251e-02f, -9.11032930e-02f, -2.22755261e-02f, -1.06143905e-02f,
  1.10899694e-02f, 1.53117970e-01f, 1.17468156e-01f, -7.84538165e-02f, 2.22656634e-02f, -3.45373899e-02f, -3.13602574e-02f, 2.24575978e-02f, -6.02600910e-03f, 9.31864753e-02f,
  1.78823456e-01f, 3.56166095e-01f, 2.81986952e-01f, 1.82719037e-01f, 2.06397966e-01f, 1.55074298e-01f, 4.89332341e-02f, 2.41077431e-02f, 1.94207087e-01f, 2.41808951e-01f,
  -7.95882568e-02f, 1.91933408e-01f, 1.41565278e-01f, 1.13513827e-01f, 2.20755890e-01f, 6.05752394e-02f, 2.18307167e-01f, 9.26546752e-02f, 1.69051990e-01f, 1.40168428e-01f,
  7.12183118e-03f, 3.21526751e-02f, 1.41097829e-01f, -7.02601746e-02f, 4.46277000e-02f, 2.17802510e-01f, 1.08822346e-01f, 2.37776086e-01f, 6.30617440e-02f, 1.21026024e-01f,
  -2.91799933e-01f, 5.81648946e-02f, 4.87491973e-02f, -1.08794622e-01f, 1.43941358e-01f, 8.49780068e-02f, -7.40054473e-02f, -5.90995178e-02f, 4.09746990e-02f, -1.12755649e-01f,
  -9.98502523e-02f, 8.69278535e-02f, -1.51119269e-02f, -1.42077059e-01f, 8.95916969e-02f, -2.06397679e-02f, -5.63694956e-03f, -1.20010480e-01f, -1.64842322e-01f, 3.18437219e-02f,
  -8.50882605e-02f, 3.00345961e-02f, -1.03432268e-01f, -1.00950092e-01f, -1.38257816e-01f, 2.03043334e-02f, 2.78861970e-02f, -4.23802659e-02f, -5.47919795e-02f, 1.28064528e-01f,
  8.03018063e-02f, 4.32799101e-01f, 1.26525417e-01f, -6.82507083e-02f, 2.48676389e-01f, 2.59558737e-01f, 3.87640744e-01f, -4.11512814e-02f, -2.13017598e-01f, 4.90747485e-03f,
  5.72508574e-02f, -1.03072666e-01f, -6.80914223e-02f, -1.02261037e-01f, -7.30137452e-02f, -8.46409053e-03f, -3.88599634e-02f, -1.86355397e-01f, -2.41416082e-01f, -8.55872855e-02f,
  -1.07495807e-01f, -3.41677442e-02f, -1.36366487e-01f, -2.16556072e-01f, 4.26780526e-03f, -1.27007917e-01f, 1.22486860e-01f, 5.01762889e-02f, 1.59126177e-01f, -1.12959065e-01f,
  -8.56067613e-03f, 2.87017822e-01f, -2.02295959e-01f, -2.02868477e-01f, 7.02333869e-04f, -1.99439973e-02f, 5.95570318e-02f, 1.13568958e-02f, 4.90669049e-02f, -4.36201878e-02f,
  4.80856746e-02f, 1.13345124e-01f, 1.81758344e-01f, 1.06933482e-01f, 2.74367183e-02f, -4.64313924e-02f, -2.94013564e-02f, -4.90946248e-02f, 2.40474641e-02f, 8.78716353e-03f,
  5.55637479e-02f, 1.58125922e-01f, 8.92456621e-02f, 1.46986647e-02f, -1.40920924e-02f, -7.55130723e-02f, 2.80286446e-02f, 1.89677104e-02f, 2.53776331e-02f, -1.41171098e-01f,
  -1.14515789e-01f, 5.89762330e-02f, 2.38380749e-02f, 4.70653884e-02f, 6.88776467e-03f, 2.67546009e-02f, -4.14403602e-02f, 8.06483552e-02f, 3.50089855e-02f, 1.13998257e-01f,
  3.91070992e-02f, 8.85634720e-02f, 3.67166707e-03f, 1.54061958e-01f, 3.83970477e-02f, 4.55793515e-02f, 8.61323476e-02f, 8.22387189e-02f, 1.03386573e-01f, -3.34385559e-02f,
  -1.76994503e-02f, -4.22536582e-02f, 6.82116374e-02f, -6.37339205e-02f, 1.64629206e-01f, 3.10689639e-02f, 2.15319972e-02f, 9.13078636e-02f, 4.29516472e-02f, 1.89159997e-02f,
  -1.21312335e-01f, 2.43642122e-01f, -1.61551073e-01f, -3.64246257e-02f, 1.90416202e-01f, 3.87147255e-02f, 4.96573485e-02f, 5.78923970e-02f, 1.56411111e-01f, -8.82062986e-02f,
  1.54731115e-02f, -1.41282454e-02f, 1.33212909e-01f, 1.07165270e-01f, 6.13528164e-03f, 2.59607472e-02f, 3.15260291e-02f, -1.17761508e-01f, -1.59241050e-01f, -1.38480574e-01f,
  -6.91956282e-02f, -7.32038543e-02f, -1.72213331e-01f, -1.75182194e-01f, -5.42445928e-02f, -2.02461407e-01f, -5.32974768e-03f, -8.78834724e-03f, 1.56280827e-02f, -2.00146273e-01f,
  -3.36944431e-01f, 1.41731473e-02f, 1.42104685e-01f, -3.28573734e-01f, 4.94774207e-02f, 4.47349297e-03f, -1.70146361e-01f, -1.37812749e-01f, -1.69383034e-01f, -2.07784146e-01f,
  -8.60410742e-03f, 5.06502949e-02f, -4.26406935e-02f, -1.64773300e-01f, -2.47248232e-01f, -3.36597681e-01f, -2.32970595e-01f, -2.14102194e-01f, -2.84923576e-02f, 3.61930728e-02f,
  -1.25607505e-01f, -2.32755691e-01f, -2.04970270e-01f, -3.32508236e-02f, -2.86930725e-02f, 3.44912969e-02f, 6.01000823e-02f, 1.31803416e-02f, -3.06199980e-03f, -5.91393560e-02f,
  -1.15400523e-01f, 1.04278035e-01f, 2.72704154e-01f, -5.32846302e-02f, 5.86848035e-02f, 6.48158342e-02f, -4.69827764e-02f, -4.47494909e-02f, -8.75005382e-04f, -1.56831264e-01f,
  4.26421687e-02f, 7.40550458e-02f, -1.45136744e-01f, 6.12471253e-03f, -2.23041132e-01f, -1.00300536e-01f, -1.79767326e-01f, -6.58573583e-02f, 4.21730056e-02f, -2.92168520e-02f,
  -6.16914406e-02f, -6.11737976e-03f, -5.02370074e-02f, 8.87120422e-03f, 7.44348988e-02f, 3.89967510e-03f, 1.06240496e-01f, 1.29711166e-01f, 1.29755884e-01f, -1.44074261e-01f,
  -4.96251620e-02f, 6.57709166e-02f, 6.46740645e-02f, -3.77722643e-02f, -1.43675402e-01f, 1.44977914e-03f, -1.52280167e-01f, -1.58990666e-01f, 5.56582250e-02f, -1.43843353e-01f,
  2.94553936e-02f, -1.58354137e-02f, -3.76296155e-02f, -1.17667198e-01f, -5.12430407e-02f, -4.36454788e-02f, -1.05421804e-01f, -1.21193074e-01f, -9.35731679e-02f, -5.67509159e-02f,
  -9.73993391e-02f, 9.19341817e-02f, -6.14838935e-02f, -1.94955394e-02f, 7.55983870e-03f, -1.73778012e-02f, -1.62653450e-03f, 8.12191740e-02f, -4.51019295e-02f, 1.92178804e-02f,
  -2.37910122e-01f, 2.14546263e-01f, -1.92952201e-01f, -5.07324003e-02f, -8.37376043e-02f, 7.42793679e-02f, 2.69099902e-02f, -2.09949370e-02f, 8.13207403e-03f, -2.50112526e-02f,
  1.68915256e-03f, -2.03963101e-01f, -1.35132959e-02f, 1.08667105e-01f, -1.43407062e-01f, -7.68283829e-02f, -1.18006967e-01f, -3.62421460e-02f, 4.52434793e-02f, 4.89894710e-02f,
  -1.77612938e-02f, -1.44428611e-02f, -2.29316056e-01f, -1.73177794e-01f, -6.27837405e-02f, -1.52970180e-01f, 2.35997532e-02f, 1.42354801e-01f, -1.21765044e-02f, -2.44035110e-01f,
  -2.78995901e-01f, 6.55482709e-02f, -1.23710960e-01f, 1.33348092e-01f, 1.57298997e-01f, -8.63662884e-02f, -9.68956947e-02f, -1.59382939e-01f, 7.72258220e-03f, -5.01608886e-02f,
  4.14853692e-02f, 1.77645922e-01f, 1.12582698e-01f, 9.69393253e-02f, -1.31526783e-01f, -6.20993972e-02f, 8.23436752e-02f, 9.02104080e-02f, -1.66714460e-01f, 7.03528076e-02f,
  2.15138808e-01f, 1.46355182e-01f, -1.90335177e-02f, -4.68232743e-02f, 1.77208915e-01f, 1.40331596e-01f, 1.58576801e-01f, 1.78033739e-01f, 2.66793370e-01f, 3.11284751e-01f,
  2.89567634e-02f, -2.78636754e-01f, -5.91107272e-02f, 2.20110595e-01f, 5.73726594e-02f, -1.02492146e-01f, -1.67341605e-01f, -1.57086939e-01f, 1.03493266e-01f, -1.16442375e-01f,
  1.14244290e-01f, -9.65750143e-02f, 7.12025315e-02f, 1.12686336e-01f, -1.87639520e-01f, -2.09627673e-01f, -2.39971042e-01f, -1.76338658e-01f, -2.06566796e-01f, -1.60309806e-01f,
  2.93975294e-01f, 2.73215920e-01f, -8.91588405e-02f, -1.03933290e-01f, -3.52945417e-01f, 8.23325366e-02f, -5.54631650e-02f, -1.76101953e-01f, -3.17280531e-01f, -2.61215746e-01f,
  -6.19547777e-02f, -7.45150670e-02f, -2.45528370e-02f, -3.61993462e-02f, -9.54196528e-02f, 8.88165757e-02f, 2.20833551e-02f, 9.56669748e-02f, 9.68902484e-02f, -1.88106939e-01f,
  9.48398281e-03f, -9.34772491e-02f, 6.76544290e-03f, -1.97283402e-01f, 7.66669437e-02f, 1.30562082e-01f, -6.63967878e-02f, -2.50199083e-02f, 1.87419895e-02f, -9.15985480e-02f,
  1.46292383e-02f, -7.69380033e-02f, 1.61152538e-02f, -4.25600186e-02f, 2.61275358e-02f, -5.81997633e-03f, -9.93593410e-02f, 4.63783555e-02f, -6.67308867e-02f, 6.72064945e-02f,
  -1.16947368e-01f, 9.03099775e-04f, 1.55608460e-01f, 7.48473331e-02f, 2.34962367e-02f, 4.45943177e-02f, 1.25954777e-01f, 7.05123320e-02f, -7.70522701e-03f, -1.08305410e-01f,
  -1.28110930e-01f, -1.65139288e-01f, 8.26939195e-02f, -9.33624581e-02f, -7.73861855e-02f, -8.67655575e-02f, 9.58858132e-02f, 1.31043375e-01f, -6.01143576e-03f, -1.43209726e-01f,
  5.87689951e-02f, -5.53516373e-02f, -8.40860829e-02f, -1.45718426e-01f, -1.32366613e-01f, 3.25063453e-03f, -1.76428817e-02f, -5.89953586e-02f, -2.45853633e-01f, -3.37482482e-01f,
  -3.83744061e-01f, 2.62794077e-01f, 2.42848232e-01f, -3.05288106e-01f, 1.17742032e-01f, 2.01382071e-01f, 3.98553610e-01f, 4.36101444e-02f, -1.78814948e-01f, -4.85531874e-02f,
  -2.16796678e-02f, -1.94516167e-01f, -1.75396115e-01f, 7.16954172e-02f, 3.39766452e-03f, 1.63411260e-01f, 1.63520724e-01f, 1.26594976e-01f, 8.23391601e-02f, -3.35616320e-02f,
  8.75670314e-02f, -1.09676212e-01f, -7.74238631e-02f, -1.22163638e-01f, -4.05968018e-02f, -1.04403317e-01f, -5.92154078e-02f, -7.83210807e-03f, 1.98757380e-01f, -4.28744182e-02f,
  -1.08282834e-01f, 1.00434780e-01f, -1.58617690e-01f, -2.52005979e-02f, 6.32326072e-03f, -1.69755459e-01f, -8.76154229e-02f, -1.96170777e-01f, 8.43062028e-02f, 1.08382866e-01f,
  1.63372438e-02f, 6.11495674e-02f, -4.06268239e-02f, -3.17996219e-02f, 5.39367273e-03f, 5.50885983e-02f, -3.09542678e-02f, 7.87750110e-02f, -5.72985224e-03f, 1.44289492e-03f,
  4.25602384e-02f, 8.73765349e-02f, 1.67764291e-01f, 5.28438427e-02f, 1.12761788e-01f, 1.34374956e-02f, 8.44388455e-02f, 1.09872445e-02f, 7.66811660e-03f, -1.19537652e-01f,
  1.63298622e-02f, 2.90139783e-02f, 1.05822936e-01f, 8.94099995e-02f, -1.22066550e-02f, -2.22734008e-02f, -4.79798578e-02f, -8.31741560e-03f, 1.31506801e-01f, -1.12564005e-01f,
  6.59751892e-03f, -3.73037644e-02f, -7.78753608e-02f, -9.15213153e-02f, -1.42737105e-01f, -6.95436960e-03f, 4.59590107e-02f, 8.69810805e-02f, -5.90001047e-02f, 1.89524464e-04f,
  7.75323957e-02f, -5.33683002e-02f, -3.81175391e-02f, -8.09016302e-02f, 1.05404466e-01f, -5.41584827e-02f, -1.00319371e-01f, -2.02507637e-02f, -4.51868214e-02f, 2.65919860e-03f,
  -3.02279681e-01f, 2.80627936e-01f, -2.42761821e-01f, 3.34033888e-04f, -5.48299588e-02f, -2.31398754e-02f, -6.29243851e-02f, -6.24684431e-02f, -6.67384416e-02f, 3.22733708e-02f,
  2.88163461e-02f, -1.16904549e-01f, -7.04804286e-02f, -1.91127837e-01f, -2.39408746e-01f, -1.78456709e-01f, -1.58250928e-02f, -9.43036526e-02f, -3.80184501e-02f, -4.61707860e-02f,
  -1.49714142e-01f, -5.04084630e-03f, -2.41941199e-01f, -1.17120512e-01f, -1.05937384e-01f, -1.63816273e-01f, -5.98668084e-02f, -1.35557830e-01f, 1.40345739e-02f, -2.42327243e-01f,
  -2.72437662e-01f, 2.08104059e-01f, 1.00280873e-01f, -1.27238631e-01f, 6.58258572e-02f, 9.13011655e-02f, 1.83589980e-02f, 7.67461257e-04f, 3.50734107e-02f, 2.77012497e-01f,
  7.43441433e-02f, -1.13027968e-01f, -3.00925262e-02f, -1.52026847e-01f, -1.95981801e-01f, -1.22535311e-01f, -7.37277120e-02f, -2.83890277e-01f, -3.70515972e-01f, -2.95948654e-01f,
  1.24996074e-03f, -2.49047950e-01f, -2.01338798e-01f, -4.05476652e-02f, 1.43189520e-01f, -8.37456062e-02f, 1.13361828e-01f, -6.99243098e-02f, 1.67380705e-01f, 1.76907077e-01f,
  -7.00810105e-02f, -1.83081813e-02f, -3.89454365e-02f, -8.91995952e-02f, 1.05800405e-01f, 3.29677835e-02f, 1.04136346e-02f, 9.84023362e-02f, 6.98808506e-02f, -3.58103327e-02f,
  -3.53433751e-02f, 1.19603872e-01f, -1.49786621e-01f, 4.88537587e-02f, -1.53307244e-01f, -7.93816522e-02f, -1.88766032e-01f, -2.10679352e-01f, -1.15873247e-01f, -1.23591982e-01f,
  -5.56718782e-02f, -8.43341947e-02f, -1.35693192e-01f, -2.94892080e-02f, -5.40569164e-02f, -7.39161000e-02f, 7.34839588e-02f, 1.00750476e-01f, 1.19103543e-01f, 1.07215308e-01f,
  7.69634023e-02f, -6.62818272e-03f, 1.32690474e-01f, 1.77802723e-02f, 3.06222145e-03f, 1.08120531e-01f, -1.48168271e-02f, 1.81685865e-01f, 1.56752747e-02f, -6.11157045e-02f,
  1.81290768e-02f, 2.18015313e-02f, 1.37386486e-01f, -1.69849664e-03f, 2.48570014e-02f, 6.08188547e-02f, 4.59010191e-02f, 5.84051386e-02f, 2.98132971e-02f, -1.14319490e-04f,
  3.65972035e-02f, 5.67593724e-02f, -3.74234244e-02f, 1.60992276e-02f, 1.68320656e-01f, 1.07011311e-01f, 7.84319788e-02f, 6.43483624e-02f, -2.73382254e-02f, -9.70134363e-02f,
  -1.57890350e-01f, 9.69528928e-02f, 4.95639704e-02f, 5.85168637e-02f, -1.99259557e-02f, 5.52843548e-02f, 9.76200104e-02f, 2.84332503e-02f, 1.41930953e-01f, -6.85741827e-02f,
  -1.54279023e-02f, 9.23093483e-02f, 1.52685901e-03f, -6.64454326e-02f, -1.51585534e-01f, 5.82109094e-02f, -3.75616997e-02f, 1.02813458e-02f, -1.03551351e-01f, 1.32563133e-02f,
  -1.75770104e-01f, -1.11879826e-01f, -2.09181204e-01f, -4.52842526e-02f, 4.41227555e-02f, 4.45295088e-02f, -1.50713474e-02f, 7.90506676e-02f, 8.34394619e-03f, 2.03958736e-03f,
  6.74661994e-01f, 4.04401898e-01f, -5.91549538e-02f, 1.36381119e-01f, 1.88255664e-02f, 2.71086067e-01f, 3.94326419e-01f, 2.11825684e-01f, 1.23448715e-01f, 1.78332642e-01f,
  1.58832088e-01f, 2.61778999e-02f, -5.29405922e-02f, -1.40323704e-02f, 1.38007700e-01f, 7.29124025e-02f, -1.07497275e-01f, -1.21963032e-01f, 5.92065938e-02f, 3.86714861e-02f,
  3.29763852e-02f, 5.93472980e-02f, 1.69055551e-01f, 8.66051987e-02f, -7.30115399e-02f, -1.11329213e-01f, -3.46352756e-02f, 3.07243820e-02f, -8.40355307e-02f, -2.02875257e-01f,
  -5.62399924e-01f, 1.61765844e-01f, 2.82310508e-02f, -7.35833272e-02f, -7.83076733e-02f, 5.38501255e-02f, 3.39143686e-02f, 6.39587343e-02f, -1.16117811e-02f, -6.26789331e-02f,
  -6.65003359e-02f, -2.21245121e-02f, -4.34292667e-02f, 3.87547584e-03f, -5.29754907e-02f, -3.95416841e-02f, 7.98144266e-02f, 1.17898867e-01f, 2.97902152e-02f, -1.39167503e-01f,
  -1.15390986e-01f, 8.08588415e-02f, 6.95445761e-02f, 1.80687550e-02f, 9.37417671e-02f, -7.58747905e-02f, 5.67668378e-02f, -2.04245485e-02f, 1.46873400e-01f, 1.13070399e-01f,
  -9.48969573e-02f, 7.81060681e-02f, -8.32255557e-02f, -3.72810140e-02f, 1.01307675e-01f, 4.62809764e-02f, -7.92647079e-02f, 4.57388163e-02f, 9.25391391e-02f, 7.28335008e-02f,
  2.57662451e-03f, -8.69369581e-02f, -8.75576660e-02f, -1.01731218e-01f, -1.70717523e-01f, -1.15708604e-01f, -2.59535350e-02f, -1.27935141e-01f, 3.61902616e-03f, 7.14418339e-03f,
  3.06518562e-02f, -1.35561183e-01f, -1.35683939e-01f, -2.27293015e-01f, -1.19111888e-01f, -1.09345421e-01f, -6.09044619e-02f, -1.23011902e-01f, -3.86236683e-02f, 5.16213514e-02f,
  -4.04971153e-01f, -1.39849573e-01f, -1.54832900e-01f, 2.45677237e-03f, -5.17901545e-03f, 6.79214597e-02f, -1.15616173e-01f, -1.72465295e-01f, -4.28264402e-02f, -1.31844535e-01f,
  1.76257975e-02f, -1.03547364e-01f, -1.52084708e-01f, 2.20125392e-02f, 4.54806946e-02f, 4.79052402e-02f, 2.85697244e-02f, -4.59562577e-02f, -7.40768090e-02f, -9.59275961e-02f,
  -1.26860470e-01f, 4.54920940e-02f, -1.69067029e-02f, 1.03809796e-01f, -4.70305458e-02f, -6.08645678e-02f, -8.85334015e-02f, -3.22926082e-02f, 7.49990195e-02f, 2.49734297e-01f,
  5.38542330e-01f, -7.31155137e-03f, 2.55617499e-01f, 5.07457927e-02f, -3.68538469e-01f, -3.32496881e-01f, -2.55816996e-01f, -1.22711845e-01f, -1.03025734e-01f, -1.40395239e-01f,
  -2.16711193e-01f, -2.41372678e-02f, -1.29731242e-02f, 1.00432560e-01f, 2.57381797e-01f, -5.52897202e-03f, 1.66620687e-01f, 3.35387647e-01f, 2.72175938e-01f, -1.02979906e-01f,
  -5.81348389e-02f, 1.78095475e-01f, 3.67759496e-01f, 2.02322796e-01f, -3.56681272e-02f, -4.02069725e-02f, 4.08085808e-02f, 5.56183457e-02f, -8.14816132e-02f, 2.20303133e-01f,
  -3.03270221e-02f, 5.72738089e-02f, 1.28235556e-02f, 5.27703464e-02f, 9.63875875e-02f, 1.42465562e-01f, -4.27912958e-02f, 1.24907874e-01f, -1.21286251e-01f, -5.14549762e-02f,
  -7.11518750e-02f, -3.05407811e-02f, 8.48544836e-02f, 1.70026603e-03f, 9.12043080e-02f, 1.07305318e-01f, 7.86454454e-02f, 1.12864189e-01f, 1.72940746e-01f, -2.87724081e-02f,
  -4.90713343e-02f, -1.65293217e-01f, -7.50648454e-02f, -1.35957688e-01f, 8.84251967e-02f, 4.04507779e-02f, -4.60394882e-02f, 5.73905036e-02f, 6.03795424e-03f, 6.56466782e-02f,
  -1.74926743e-01f, 6.68654742e-04f, -5.27043045e-02f, -3.04587130e-02f, -8.76120701e-02f, -1.44809231e-01f, -2.10961830e-02f, -1.26718268e-01f, 1.12396143e-01f, 1.51312009e-01f,
  -8.28251417e-04f, -4.93098609e-02f, -1.95187386e-04f, -9.69338492e-02f, 1.72733963e-02f, -8.19524974e-02f, 4.23045121e-02f, 3.03110946e-02f, 8.76457617e-02f, -1.93799601e-03f,
  3.67182381e-02f, 2.27222182e-02f, 2.58793980e-02f, 5.64793013e-02f, -4.80828155e-03f, 4.27173264e-02f, -5.67345209e-02f, -1.54800098e-02f, -4.60669249e-02f, -6.11729957e-02f,
  -2.57375032e-01f, 1.34360105e-01f, 5.92402332e-02f, 1.18351586e-01f, -4.32434417e-02f, 3.47331055e-02f, -5.43251634e-03f, -6.91013224e-03f, -5.52318692e-02f, -1.50489822e-01f,
  -3.97019181e-03f, 1.10928476e-01f, 4.98222373e-02f, 9.92007181e-02f, -3.78046110e-02f, -4.03983518e-02f, 1.96433533e-02f, 4.04058769e-02f, -5.12647182e-02f, -4.92032915e-02f,
  5.55646718e-02f, -2.09409371e-01f, -2.44824588e-01f, -2.14501783e-01f, -1.12754256e-01f, -1.52626604e-01f, -1.53586954e-01f, -2.60773525e-02f, -7.19832703e-02f, -8.47678483e-02f,
  -2.12455422e-01f, -8.78850296e-02f, -2.22694963e-01f, 2.74066953e-03f, 1.65362269e-01f, 9.01185125e-02f, 7.35636130e-02f, -9.03964564e-02f, -1.37545511e-01f, -1.05508007e-01f,
  -4.08512987e-02f, 3.26016694e-02f, -4.14573252e-02f, 1.29844937e-02f, 7.74336085e-02f, 1.11310422e-01f, 1.16883941e-01f, 7.19453767e-02f, 1.92114450e-02f, 4.89884615e-02f,
  1.42391801e-01f, 7.25630522e-02f, 1.64247919e-02f, 5.87568525e-03f, -3.36153470e-02f, 4.85460162e-02f, -1.00737780e-01f, 3.15207653e-02f, 1.50922820e-01f, 1.69476286e-01f,
  -3.02599937e-01f, -1.00052707e-01f, 4.76257950e-02f, 7.63035640e-02f, -4.66617458e-02f, -2.92047951e-02f, -9.37708840e-03f, -1.45777157e-02f, 5.95191829e-02f, 5.06162085e-03f,
  1.37917921e-01f, 1.22327551e-01f, 6.24123774e-02f, -1.67470295e-02f, 1.15466535e-01f, 3.07010747e-02f, -6.24209344e-02f, -9.10155028e-02f, -1.93063349e-01f, -4.86682244e-02f,
  1.30070478e-01f, 9.77885202e-02f, 8.24312419e-02f, -1.06598720e-01f, -1.37649328e-01f, -1.96854919e-02f, 3.31977718e-02f, 5.08719869e-02f, -1.91722870e-01f, -7.15026706e-02f,
  1.09939247e-01f, 1.80732712e-01f, -5.27418219e-02f, -6.60573645e-03f, 1.30502373e-01f, -1.34270471e-02f, 1.34644890e-02f, 2.78980225e-01f, 2.04739571e-01f, -1.88863471e-01f,
  4.23102975e-02f, -7.40611479e-02f, -5.23239523e-02f, -7.58086592e-02f, 7.04327449e-02f, -7.96843991e-02f, 6.47782981e-02f, 2.91582309e-02f, -6.53623194e-02f, -1.66811496e-01f,
  1.13970235e-01f, -7.43506849e-02f, -1.38413653e-01f, 2.80768313e-02f, -1.89545676e-01f, -1.21097043e-01f, 2.44103372e-02f, -9.21602175e-02f, -1.27073482e-01f, -1.70448780e-01f,
  -2.84819275e-01f, -1.43715426e-01f, -1.05623841e-01f, 7.20473826e-02f, 1.01237893e-02f, -4.49544825e-02f, -1.40096352e-01f, -4.09623794e-02f, -2.68078092e-02f, -6.51532784e-02f,
  9.64469761e-02f, -7.03261718e-02f, -1.26969784e-01f, 7.94792697e-02f, -5.19302040e-02f, 4.88443812e-03f, 1.38003424e-01f, 5.48916459e-02f, 2.73292381e-02f, -3.71279977e-02f,
  -3.24073210e-02f, -1.57336846e-01f, -3.19695543e-03f, -2.20908061e-01f, -1.31703213e-01f, -1.55854374e-01f, -1.63960025e-01f, -8.90679434e-02f, -2.81044364e-01f, -3.46630305e-01f,
  3.10157061e-01f, -4.25462946e-02f, 1.93232536e-01f, 2.69243926e-01f, 1.12186573e-01f, -9.52427238e-02f, -1.35771513e-01f, -3.83922830e-02f, 6.76151440e-02f, 6.52482137e-02f,
  7.94893876e-02f, 1.88164085e-01f, 6.89048842e-02f, 6.20005988e-02f, 6.65033460e-02f, -3.25710932e-03f, 2.56270673e-02f, 2.40374431e-01f, 1.27516791e-01f, 1.13256276e-01f,
  5.57446666e-03f, -3.60387377e-02f, 6.71606660e-02f, -1.76182576e-02f, 1.27010331e-01f, 1.82773933e-01f, 1.01049721e-01f, 2.02750742e-01f, 8.72842744e-02f, 1.72305718e-01f,
  2.65871972e-01f, 1.36975944e-01f, -4.22024168e-03f, -5.26858168e-03f, 1.34283851e-03f, -4.59259599e-02f, -9.45029780e-02f, 4.65267542e-04f, -1.19631872e-01f, -5.03689349e-02f,
  7.67013580e-02f, 6.35046288e-02f, 6.78869635e-02f, -5.93886748e-02f, 8.77181347e-03f, -1.20377973e-01f, -7.99561068e-02f, 1.80897024e-02f, -7.20938519e-02f, -6.82519749e-02f,
  2.30675060e-02f, -7.35288626e-03f, -2.95168888e-02f, -1.23008102e-01f, -5.15600629e-02f, 4.01716568e-02f, -5.83842620e-02f, 2.26631816e-02f, -4.90765832e-02f, 8.28831568e-02f,
  4.74033542e-02f, -8.86416957e-02f, -7.32087418e-02f, 6.39742613e-02f, 1.84764490e-01f, 3.18724290e-02f, 4.53780480e-02f, 8.48372653e-02f, 6.51302785e-02f, -5.74641451e-02f,
  -1.27586164e-02f, 1.03867322e-01f, 5.13589662e-03f, -5.49284592e-02f, 5.38129956e-02f, -6.92918450e-02f, 1.13437861e-01f, 4.07629274e-02f, 4.10822444e-02f, -7.38546848e-02f,
  -4.57379073e-02f, 2.64262594e-02f, 9.03083384e-02f, 9.38028004e-03f, -4.54789251e-02f, 1.54680595e-01f, 1.14562951e-01f, -5.85483247e-03f, 3.42492647e-02f, -8.40000585e-02f,
  -2.98596025e-01f, -1.40258983e-01f, 2.04646617e-01f, 7.03125820e-02f, 1.06104709e-01f, 8.33248720e-03f, 8.63882080e-02f, -4.32787612e-02f, -5.04803173e-02f, -6.03513606e-02f,
  2.11258419e-02f, 9.81522277e-02f, -8.59416947e-02f, -7.13922456e-02f, 3.06355432e-02f, -9.52060744e-02f, 5.66986501e-02f, -3.28799747e-02f, -1.30513415e-01f, -9.72667187e-02f,
  -6.22533336e-02f, -1.66331276e-01f, -8.59541446e-02f, -1.27984002e-01f, 1.35876499e-02f, -6.32935762e-02f, -4.62668343e-03f, -5.55190782e-04f, -9.54965353e-02f, -1.80057496e-01f,
  4.54033196e-01f, 2.03513190e-01f, 1.65679887e-01f, -6.62743812e-03f, -2.39246726e-01f, -1.62398145e-01f, -7.52881840e-02f, -1.11057639e-01f, -1.71499386e-01f, 1.30111828e-01f,
  -2.01339237e-02f, -2.39338979e-01f, -1.68524727e-01f, -1.93450704e-01f, -1.69774026e-01f, 1.40512452e-01f, 5.28163873e-02f, 4.67994101e-02f, -1.61830857e-01f, -1.37506098e-01f,
  -1.74451441e-01f, -5.53471409e-03f, 1.38897091e-01f, -7.98253566e-02f, 1.62826985e-01f, -1.11171447e-01f, 1.26808837e-01f, 1.84244439e-01f, 1.01694241e-01f, 3.18972737e-01f,
  2.83443898e-01f, 2.40210757e-01f, -2.06198573e-01f, -1.43712983e-01f, -3.82773206e-02f, 4.25856747e-02f, -4.64089066e-02f, 1.58704638e-01f, 2.67790612e-02f, 9.74603649e-03f,
  -3.44791561e-02f, -1.67880263e-02f, 4.63723391e-02f, -6.86886609e-02f, 6.27528429e-02f, -4.98912148e-02f, -4.72020581e-02f, 9.28283185e-02f, -1.25031844e-01f, 1.52061328e-01f,
  -2.10092574e-01f, -3.07777785e-02f, -2.20377166e-02f, -8.86649415e-02f, 3.67512703e-02f, -1.76068917e-01f, 3.41194607e-02f, 1.39080122e-01f, 2.93054525e-02f, 2.45366737e-01f,
  -9.23355445e-02f, 2.76818704e-02f, -3.07583772e-02f, 9.45465863e-02f, 3.58655527e-02f, -6.86441138e-02f, 6.40278384e-02f, 4.09814082e-02f, -7.07573369e-02f, 8.00686628e-02f,
  6.63484260e-02f, -3.18544209e-02f, 4.86024097e-03f, 7.95161724e-02f, -5.21318056e-02f, 6.47988096e-02f, 3.28682773e-02f, -8.58551785e-02f, 5.57875969e-02f, -5.83550986e-03f,
  -1.03283659e-01f, 4.93142903e-02f, -4.92562987e-02f, 4.90942784e-02f, 1.94169804e-02f, 4.30114456e-02f, -3.83839160e-02f, -4.65206094e-02f, -7.93741457e-03f, 5.26495613e-02f,
  -1.59820005e-01f, -2.28966266e-01f, -2.15381142e-02f, -7.22791404e-02f, 2.42428519e-02f, -1.36749253e-01f, 3.70934494e-02f, -1.36002794e-01f, -2.09614635e-02f, 1.10938355e-01f,
  1.56268589e-02f, -1.02238776e-02f, 6.58156499e-02f, -4.56684045e-02f, -2.06137538e-01f, -1.52790055e-01f, -2.12922007e-01f, -2.34721377e-01f, -2.28913099e-01f, -1.00989304e-01f,
  -2.12918013e-01f, -2.62240887e-01f, -2.24092305e-01f, -1.31279126e-01f, -8.24581385e-02f, -3.29610705e-01f, -2.61446714e-01f, -1.26375392e-01f, -1.65751964e-01f, -2.82963514e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  7.12992176e-02f, 3.17545235e-02f, 2.76411157e-02f, 2.43593961e-01f, 3.75434384e-02f, 2.78300971e-01f, 1.76521420e-01f, 2.37783238e-01f, 8.07104632e-02f, 3.78380269e-01f,
  4.82876785e-02f, 2.13206351e-01f, -4.46713157e-02f, -2.42032297e-02f, 2.07787856e-01f, 9.74835455e-02f, 1.22050710e-01f, 2.58717656e-01f, 1.79488108e-01f, 2.68875718e-01f,
  7.84501731e-02f, 6.76218793e-02f, 1.37370497e-01f, 1.37123048e-01f, 1.21612675e-01f, -9.93381487e-04f, 9.18357894e-02f, 1.56856313e-01f, 1.47649914e-01f, 1.97689515e-03f,
  2.23142520e-01f, 1.94862708e-01f, 1.62361294e-01f, -1.46921411e-01f, 1.99700192e-01f, 1.06361181e-01f, 1.67823508e-01f, -1.08505867e-01f, 1.87301859e-01f, 4.14365306e-02f,
  -2.98274785e-01f, 2.50058681e-01f, 1.56761691e-01f, 2.11924598e-01f, 5.12528680e-02f, 3.20906937e-01f, 7.53485039e-02f, 1.06732160e-01f, 2.09200725e-01f, 1.56295657e-01f,
  2.53387988e-01f, 1.08879313e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.18268793e-02f, -1.04403738e-02f, -2.77710985e-02f, 4.91286963e-02f, 2.46671483e-01f, -2.21564397e-02f, -9.15810466e-02f, 2.77945995e-01f, 7.92635158e-02f, 1.72921494e-01f,
  1.08039983e-01f, -4.39098835e-01f, 1.02608064e-02f, -2.33569387e-02f, -4.74600904e-02f, -9.57282707e-02f, -1.95869431e-01f, -3.26119103e-02f, -8.36004615e-02f, 7.48880953e-03f,
  -6.64802864e-02f, 4.41254415e-02f, -7.77040347e-02f, 1.80990472e-01f, 6.62729591e-02f, 5.30032767e-03f, -1.42010748e-01f, -2.92207032e-01f, -8.24308842e-02f, 1.46750823e-01f,
  -6.25017658e-02f, 2.73369938e-01f, -1.27271758e-02f, -6.87006116e-02f, -1.52367532e-01f, -3.79223898e-02f, -1.02752611e-01f, 1.17192991e-01f, 4.27689636e-03f, -1.69176996e-01f,
  -1.51955649e-01f, 5.37812747e-02f, 7.31645077e-02f, -3.07208654e-02f, -1.05489723e-01f, -1.50667354e-01f, -2.19695032e-01f, 1.48630574e-01f, 8.59543681e-02f, -5.72701022e-02f,
  4.07154225e-02f, 3.46640125e-02f, 7.36935511e-02f, 8.79042745e-02f, 2.06824094e-01f, -7.29301870e-02f, 8.69128406e-02f, -1.36652097e-01f, 1.61512539e-01f, 1.11125894e-01f,
  -2.03519583e-01f, -2.28928968e-01f, -1.19144417e-01f, -4.47552465e-03f, 3.29583623e-02f, -5.66535890e-02f, -1.67563800e-02f, 2.40563415e-03f, 1.69516250e-01f, 1.09816998e-01f,
  -5.38350306e-02f, 2.14854509e-01f, 1.05816163e-01f, 6.87254742e-02f, -8.42090249e-02f, -1.63105428e-01f, 4.87314016e-02f, 4.01290208e-02f, -5.08042127e-02f, 1.75587758e-01f,
  -1.05537325e-01f, 1.07695058e-01f, 1.06493011e-01f, -1.13814019e-01f, -1.30842119e-01f, -7.95546919e-02f, -7.91393220e-02f, 1.85301676e-01f, 5.81583604e-02f, 4.95812222e-02f,
  -9.00396556e-02f, -3.51532221e-01f, -7.02347374e-03f, 6.27137721e-02f, -7.35791549e-02f, 9.55439880e-02f, 5.48354983e-02f, -2.03615770e-01f, -9.11815688e-02f, 2.13278517e-01f,
  -1.36804776e-02f, 9.63357612e-02f, 3.43886353e-02f, -2.00546026e-01f, 1.82657689e-01f, -4.86049242e-03f, 2.24507704e-01f, -6.39026761e-02f, 5.04691042e-02f, -1.38766244e-01f,
  -2.81936023e-02f, 1.65307134e-01f, -8.11043978e-02f, -1.45069346e-01f, -1.03671506e-01f, -1.38998866e-01f, -5.56188487e-02f, 1.12221114e-01f, -7.32874051e-02f, -2.83363555e-02f,
  -1.91940621e-01f, 1.58383951e-01f, 1.24603622e-01f, 1.78873330e-01f, 1.49049282e-01f, -3.74562033e-02f, -1.39221966e-01f, 1.59982800e-01f, -1.52471205e-02f, -5.98770157e-02f,
  -1.19142920e-01f, -6.34403378e-02f, -8.47688541e-02f, 1.15184657e-01f, 6.68540299e-02f, -9.14005861e-02f, -9.28173885e-02f, -1.46437168e-01f, 6.17701709e-02f, 7.80378506e-02f,
  2.07522020e-01f, 1.15776777e-01f, -3.27638090e-02f, -1.91222101e-01f, -6.93809167e-02f, -2.12893069e-01f, 5.28437793e-02f, -9.82831120e-02f, 1.95528343e-01f, -1.04377098e-01f,
  1.22644156e-01f, 6.93478286e-02f, 1.13290891e-01f, -5.72609901e-02f, 7.03774542e-02f, 1.54237047e-01f, 3.52318361e-02f, 7.09732175e-02f, -6.22285195e-02f, -1.63721636e-01f,
  6.77260533e-02f, -1.20135397e-02f, 7.33272135e-02f, 1.34505555e-01f, 1.13724321e-01f, 5.54168178e-03f, -2.18733829e-02f, 2.30853945e-01f, 6.04860447e-02f, 3.20138663e-01f,
  -9.70580727e-02f, -1.59376368e-01f, 5.76583482e-02f, 6.88387007e-02f, 1.24897391e-01f, -1.52720809e-01f, -2.82241613e-01f, 6.04342744e-02f, -1.40055120e-01f, 1.39624968e-01f,
  8.31761211e-02f, -7.15942159e-02f, -2.62040310e-02f, 1.51335672e-01f, 1.80850878e-01f, 2.01563373e-01f, 2.77606081e-02f, -9.64427441e-02f, -1.67032883e-01f, 2.32591033e-01f,
  1.73956856e-01f, -2.17541948e-01f, -1.98102742e-02f, 3.36660109e-02f, -1.61008798e-02f, -6.55832291e-02f, 7.16080517e-02f, 1.05637938e-01f, -2.48287782e-01f, 7.68172182e-03f,
  1.01447821e-01f, 6.03059679e-02f, -2.23267805e-02f, 1.55021995e-01f, -1.52199149e-01f, -2.10198965e-02f, -1.59184039e-01f, 2.15961754e-01f, -4.04200330e-03f, 1.47150919e-01f,
  1.02445930e-01f, -1.25569403e-02f, 6.56776577e-02f, -2.58209999e-04f, 1.98918313e-01f, 5.70907220e-02f, -2.00537518e-01f, -5.77691756e-02f, -6.77723289e-02f, -8.26336071e-02f,
  -2.85961088e-02f, 9.41307992e-02f, -1.02176018e-01f, -8.03807527e-02f, -1.19976483e-01f, 1.13997363e-01f, 8.82737190e-02f, 5.77500276e-02f, 4.84297462e-02f, 4.12271209e-02f,
  1.06815577e-01f, -8.33893493e-02f, 3.29985805e-02f, -2.07978994e-01f, -1.33641381e-02f, 8.25779960e-02f, 1.24988131e-01f, 6.26030043e-02f, -8.46044067e-03f, 1.12655133e-01f,
  1.48984626e-01f, 4.35829535e-02f, 5.56605197e-02f, 4.33553420e-02f, 1.01910099e-01f, -4.26915586e-02f, -8.45297650e-02f, -1.83945537e-01f, -9.81711820e-02f, 1.75392643e-01f,
  -1.30141424e-02f, 1.48486570e-01f, 1.85715407e-01f, -1.26175731e-01f, 3.61756012e-02f, 6.01056702e-02f, -2.42016949e-02f, 9.39229727e-02f, 1.14063412e-01f, -7.97915310e-02f,
  -9.41619873e-02f, -1.14092551e-01f, 1.92479908e-01f, 3.09305787e-01f, 1.41455919e-01f, 6.58962578e-02f, -1.33635446e-01f, 2.93788351e-02f, -1.31204292e-01f, -1.69103935e-01f,
  -1.03356913e-01f, -4.88619693e-02f, -3.34514529e-01f, 7.54828304e-02f, -9.65088308e-02f, -3.82277556e-02f, -6.24249503e-02f, 6.17049783e-02f, -1.32268175e-01f, 1.03632715e-02f,
  -1.36189044e-01f, -1.45625025e-01f, -1.21053517e-01f, -1.33326456e-01f, -1.24462940e-01f, 1.63630173e-01f, 3.34264249e-01f, 2.93781817e-01f, 1.48811966e-01f, 8.46776366e-02f,
  4.31780703e-02f, 6.57609180e-02f, -2.57483609e-02f, 8.98172185e-02f, 7.66513422e-02f, -2.83040792e-01f, 1.61179423e-01f, 2.20649652e-02f, 7.75078237e-02f, -7.65364319e-02f,
  -7.41861463e-02f, -1.80945680e-01f, -1.17687069e-01f, -2.37908680e-02f, 1.64274335e-01f, -9.98937432e-03f, 1.96738362e-01f, 6.03459030e-02f, -6.18263744e-02f, 5.56920692e-02f,
  1.26491442e-01f, -8.70035067e-02f, 1.72687590e-01f, 7.24032000e-02f, 2.04451174e-01f, -3.82485129e-02f, -1.57866590e-02f, 1.27547726e-01f, -1.03104979e-01f, 2.79539764e-01f,
  -9.03676450e-02f, -6.58750609e-02f, -1.19461775e-01f, -8.19156915e-02f, -6.48309663e-02f, 1.74020216e-01f, 1.04675293e-01f, -1.33492306e-01f, 1.40450140e-02f, -5.88344485e-02f,
  -9.23928246e-03f, -1.60758108e-01f, 2.27126494e-01f, -2.58997846e-02f, 1.48673132e-02f, 6.31096913e-03f, 4.01132507e-03f, -2.62833208e-01f, -6.70820102e-02f, -2.47909799e-01f,
  -6.29026368e-02f, 6.64086491e-02f, -2.78059188e-02f, -1.02593638e-01f, -4.14850265e-02f, -4.59687561e-02f, -8.42726454e-02f, 1.82847455e-01f, 1.17943347e-01f, -5.03693596e-02f,
  -5.26111759e-02f, -1.92842498e-01f, 3.12449355e-02f, -1.21934243e-01f, -2.80165914e-02f, -7.35314041e-02f, 6.66573495e-02f, 9.88113135e-03f, -1.82289761e-02f, 7.03987330e-02f,
  -5.61741972e-03f, 1.23601906e-01f, 1.13787819e-02f, -5.14173135e-02f, 5.93866743e-02f, -1.06014736e-01f, -2.56481748e-02f, 9.46865380e-02f, -1.52872056e-01f, -1.65421784e-01f,
  6.70524910e-02f, 2.62657069e-02f, -1.44543946e-01f, -9.79867354e-02f, -4.28966060e-02f, 1.64753258e-01f, 1.63231388e-01f, 1.28632948e-01f, -2.70348024e-02f, -6.56766444e-02f,
  1.43728787e-02f, 1.27198532e-01f, 1.09893598e-01f, -1.00554384e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.32615834e-01f, 1.61258802e-01f, 4.09122882e-03f, 1.31277397e-01f, -2.06001326e-02f, 1.48439497e-01f, 2.75065571e-01f, 2.92346627e-01f, 3.36120427e-01f, -4.58711945e-02f,
  -2.57859081e-01f, 2.18739867e-01f, -1.60474464e-01f, -1.92414075e-02f, -8.96773767e-03f, 6.84914887e-02f, -2.35638916e-02f, 3.33374649e-01f, 2.74703801e-01f, 3.97016481e-02f,
  -9.29895118e-02f, 1.54573610e-02f, -8.23888481e-02f, -1.03160165e-01f, -2.05170646e-01f, -1.55195847e-01f, 2.88850125e-02f, -2.44589925e-01f, 1.36321364e-02f, 7.67973363e-02f,
  -7.89579824e-02f, -5.71784005e-02f, 8.26377049e-02f, 1.60074025e-01f, 3.39247845e-02f, 5.26538827e-02f, 1.01777978e-01f, -1.02299206e-01f, -1.48050347e-02f, -3.57535094e-01f,
  1.95019543e-01f, -1.83747336e-02f, -7.12127164e-02f, 2.38352865e-02f, -3.15984756e-01f, -2.61841893e-01f, 1.86040811e-02f, 5.93132339e-02f, 2.05241784e-01f, -2.15853706e-01f,
  3.28177422e-01f, -1.91444624e-02f, -8.60680416e-02f, 2.41593961e-02f, 5.46240956e-02f, -1.81568787e-01f, 3.94249596e-02f, 1.45533420e-02f, -2.37121373e-01f, 5.97843109e-03f,
  1.26966879e-01f, 2.13284656e-01f, 1.21297762e-01f, 2.02448621e-01f, 7.44757801e-02f, 2.00092774e-02f, -1.13233112e-01f, -4.64587323e-02f, -1.50828719e-01f, 1.25357598e-01f,
  7.68115595e-02f, -2.45035619e-01f, 6.67333929e-03f, -2.16904819e-01f, 4.55761421e-03f, -2.33600084e-02f, -1.00873159e-02f, -1.47749543e-01f, 7.00743273e-02f, 1.62469640e-01f,
  8.34469721e-02f, -2.23677948e-01f, -9.63132530e-02f, 3.48510742e-01f, 2.93074131e-01f, 3.14812586e-02f, 1.67931750e-01f, -5.25846668e-02f, 1.31038398e-01f, 3.14484797e-02f,
  -6.95580244e-02f, 2.91464012e-02f, -2.06411883e-01f, 1.69450387e-01f, -1.18964411e-01f, -4.89598103e-02f, 3.12751472e-01f, -1.91610590e-01f, 2.35538617e-01f, -9.88286808e-02f,
  3.63572948e-02f, 5.84524944e-02f, -2.55135051e-03f, 3.45777534e-02f, -2.10192576e-02f, -6.06997907e-02f, 1.68651447e-01f, -2.06661597e-01f, 7.15859085e-02f, -4.45704497e-02f,
  -1.08672537e-01f, -2.68780828e-01f, -1.43284276e-01f, 2.89837122e-01f, 7.79021829e-02f, 1.29710242e-01f, 4.36843187e-03f, -5.70349917e-02f, -1.58052444e-02f, 1.96374178e-01f,
  5.83033264e-02f, 1.74198240e-01f, 8.56031924e-02f, -2.10082963e-01f, -1.81349754e-01f, 2.92689770e-01f, -1.02440841e-01f, -1.55988082e-01f, 7.96317831e-02f, -5.76034980e-03f,
  1.14217073e-01f, 2.02415287e-02f, 1.55992701e-03f, 1.30060196e-01f, 6.28635511e-02f, -3.42304856e-02f, -1.02063611e-01f, 2.07749978e-01f, 7.55046308e-02f, 1.15461476e-01f,
  1.93451151e-01f, -5.42952158e-02f, -1.03065595e-01f, 2.20975518e-01f, 1.71376005e-01f, -7.45483208e-03f, -4.54161391e-02f, 2.94515640e-01f, 4.92916591e-02f, 2.47350708e-01f,
  2.31962264e-01f, -1.68281212e-01f, -3.08295876e-01f, 3.32483649e-02f, 2.50934541e-01f, 2.48271659e-01f, 6.26043826e-02f, -7.63884261e-02f, 8.44296813e-02f, -5.12193024e-01f,
  -1.59514248e-01f, -9.67164859e-02f, 1.31331056e-01f, 2.84372568e-01f, -3.76278884e-03f, -1.09848224e-01f, 2.49306988e-02f, 2.05897868e-01f, 2.66260654e-01f, -1.60652786e-01f,
  -3.51517528e-01f, 2.07523510e-01f, -3.83478254e-02f, 1.61610365e-01f, 9.17557701e-02f, 1.91906214e-01f, -4.33999719e-03f, -6.02871459e-03f, 9.72696170e-02f, 2.77223848e-02f,
  3.43789235e-02f, 2.08877306e-02f, -1.64855927e-01f, -5.65468185e-02f, 3.63414101e-02f, 7.75097087e-02f, -3.60727608e-01f, 7.57272393e-02f, 2.56880939e-01f, -6.66760281e-02f,
  1.64992198e-01f, 9.54271853e-02f, 1.25217825e-01f, 3.07337224e-01f, 8.80452171e-02f, 8.81454423e-02f, 1.69581845e-01f, 3.10569406e-01f, 2.23615929e-01f, 1.28639832e-01f,
  -3.57387394e-01f, 1.17336065e-01f, 1.84725359e-01f, 2.11805776e-01f, 2.78832942e-01f, -1.17168076e-01f, -2.23324180e-01f, 1.60860136e-01f, -9.25167575e-02f, -2.66683161e-01f,
  8.16605017e-02f, 1.20133080e-01f, 2.95225214e-02f, 4.51532334e-01f, 2.83340923e-02f, 2.99499761e-02f, -1.97491691e-01f, -4.04222980e-02f, 2.28548363e-01f, 2.31785402e-02f,
  -2.23348603e-01f, 1.59155816e-01f, -6.75334111e-02f, -2.28690639e-01f, 4.09770310e-01f, 3.10775876e-01f, -1.36579290e-01f, -2.09290385e-01f, 2.14441549e-02f, 8.94629732e-02f,
  1.39573008e-01f, 1.26123980e-01f, -4.18724492e-02f, 9.92364436e-02f, 3.33695590e-01f, -5.46429493e-02f, 5.98355643e-02f, -2.91544914e-01f, 1.81211725e-01f, -1.47786036e-01f,
  1.35545760e-01f, -2.82401621e-01f, 4.44320083e-01f, 7.76278898e-02f, -2.41761327e-01f, 1.19283013e-01f, -1.36747733e-01f, 4.79621105e-02f, -1.58417732e-01f, 5.83224185e-02f,
  5.83020970e-02f, -1.62057921e-01f, -2.07120731e-01f, -1.26592115e-01f, -1.91787988e-01f, -2.26449817e-01f, 1.92773089e-01f, 6.90097213e-02f, -1.00540943e-01f, -1.56362668e-01f,
  -2.19523787e-01f, -2.72128671e-01f, 2.91213036e-01f, 1.07007533e-01f, -1.56546593e-01f, -1.85374945e-01f, -2.09598273e-01f, -2.22325593e-01f, -2.64294207e-01f, -2.30031371e-01f,
  -2.47132078e-01f, 9.89803076e-02f, -2.71113038e-01f, 1.16514854e-01f, -6.63706735e-02f, 2.40733162e-01f, 2.44239166e-01f, 1.56384967e-02f, 9.44470316e-02f, -2.16838151e-01f,
  -6.52419105e-02f, -1.94017813e-01f, -2.60345072e-01f, -1.80196300e-01f, -2.24442154e-01f, 2.01598629e-01f, -1.29608018e-02f, 7.20737725e-02f, 5.78121655e-02f, -1.23833142e-01f,
  4.08659689e-02f, -1.05208293e-01f, 1.50959134e-01f, 1.37287810e-01f, -5.05131856e-02f, -1.76350147e-01f, 1.38332725e-01f, -5.31861894e-02f, -6.40982836e-02f, 3.17430571e-02f,
  -3.24733138e-01f, -4.46862690e-02f, -5.39808050e-02f, 1.32417217e-01f, 5.98235019e-02f, 1.71698049e-01f, -5.18067703e-02f, 2.49128312e-01f, -8.28627497e-02f, -8.42540860e-02f,
  1.12942196e-02f, -1.59609497e-01f, 1.68681294e-01f, 1.97789688e-02f, 2.26606075e-02f, -1.87779531e-01f, -2.52847582e-01f, 1.17748067e-01f, 9.33712423e-02f, 2.98057459e-02f,
  4.81342413e-02f, -7.03432644e-03f, 2.52356470e-01f, 3.18370283e-01f, 2.52149403e-01f, 2.59772509e-01f, -1.90556556e-01f, -1.61468834e-01f, 7.06819072e-02f, 2.51932830e-01f,
  -2.45419773e-03f, -2.94522047e-01f, 1.06613524e-01f, -2.85724133e-01f, -4.78329603e-03f, 1.48593351e-01f, -5.85391521e-02f, 1.77261680e-02f, -2.70908982e-01f, -2.76010007e-01f,
  -1.23059593e-01f, 1.33383885e-01f, -7.19309151e-02f, -1.14964414e-02f, 1.91897959e-01f, 7.29032233e-02f, -4.90775406e-02f, 3.93798240e-02f, 1.81117579e-01f, 5.81526868e-02f,
  1.80509523e-01f, 1.16056807e-01f, -3.33278537e-01f, -2.68782347e-01f, 7.08537549e-02f, 2.56689668e-01f, 9.11451727e-02f, 1.65453292e-02f, -4.73556593e-02f, -3.93669084e-02f,
  1.92617968e-01f, -2.30738714e-01f, -7.20107481e-02f, 1.76752090e-01f, -2.05990765e-02f, -4.27769348e-02f, 1.88098643e-02f, 2.27482542e-01f, -2.94128299e-01f, -6.25093579e-02f,
  -2.15370610e-01f, -1.06083311e-01f, 4.66899946e-02f, 2.50160933e-01f, -2.72475258e-02f, 2.02477770e-03f, 3.21760774e-02f, -2.22402662e-01f, 6.95781037e-02f, -2.54770994e-01f,
  1.84242949e-01f, 1.28464147e-01f, 1.71505764e-01f, 2.38992721e-01f, 1.42701939e-01f, -5.30084483e-02f, -7.49809295e-02f, -8.73533487e-02f, 1.53122455e-01f, -9.83508900e-02f,
  -1.92457929e-01f, 1.15070932e-01f, -3.96524705e-02f, -2.38573834e-01f, 1.04650453e-01f, 7.18980804e-02f, -9.79886726e-02f, 1.22141168e-01f, -2.15501189e-02f, -1.91930503e-01f,
  -1.51910633e-01f, 6.26434758e-02f, 1.76449403e-01f, 1.72960058e-01f, 1.06034949e-01f, 1.63895376e-02f, -1.96813159e-02f, 1.79904923e-01f, -1.03234999e-01f, 2.29395926e-01f,
  -1.05141364e-01f, -2.06279278e-01f, -1.24573112e-01f, 1.51605800e-01f, -5.75777423e-03f, 1.38556108e-01f, 8.37002918e-02f, 5.78855025e-03f, -1.62001953e-01f, -2.21384466e-01f,
  2.26248994e-01f, 5.19949384e-02f, -1.46051809e-01f, 8.75222906e-02f, 2.41912790e-02f, -5.19320741e-02f, -1.33577071e-03f, -1.36872172e-01f, 3.80588733e-02f, 7.52083212e-02f,
  -1.21083453e-01f, -1.35375902e-01f, -2.21275151e-01f, 3.19347461e-03f, -1.34411484e-01f, -2.12531611e-01f, 9.82305780e-02f, 1.75667062e-01f, 1.57623768e-01f, -8.15479457e-02f,
  -2.24667657e-02f, 1.53710917e-01f, 6.89777732e-02f, 1.09106287e-01f, -2.97028720e-01f, 6.25104383e-02f, -9.72271785e-02f, 1.38350323e-01f, 2.48777419e-01f, 2.09959954e-01f,
  1.14472814e-01f, 7.79090673e-02f, 2.05789834e-01f, 1.91380918e-01f, -2.74167284e-02f, -5.01384102e-02f, 2.23263592e-01f, -4.55567427e-02f, -6.19980730e-02f, 1.87285617e-01f,
  -1.35388911e-01f, -7.64864832e-02f, 1.49479270e-01f, 4.11420405e-01f, 5.37902862e-02f, 1.81660622e-01f, -1.71943661e-02f, -1.39525915e-02f, -3.31752062e-01f, 4.80054505e-02f,
  -3.96171473e-02f, -7.44134858e-02f, -1.62617579e-01f, -7.34191760e-02f, -1.34151857e-02f, 4.96034883e-03f, -1.36981547e-01f, 2.11238846e-01f, 1.40138611e-01f, 8.02287757e-02f,
  -2.36767113e-01f, 1.31797567e-01f, 6.55937344e-02f, -1.12645395e-01f, -3.68717909e-02f, 4.67729010e-02f, -1.12285174e-01f, -1.47594705e-01f, 1.09358110e-01f, -1.26771674e-01f,
  -2.37690464e-01f, 1.88801363e-01f, -2.30383314e-02f, -2.09165774e-02f, 4.22025187e-04f, 9.84517857e-02f, 1.68327451e-01f, -1.95153300e-02f, 1.69030190e-01f, -1.59590706e-01f,
  1.34209454e-01f, -1.15744635e-01f, 1.36009464e-02f, -9.56701040e-02f, 2.11624783e-02f, 9.62942317e-02f, -2.03850478e-01f, 9.68471691e-02f, 1.60665587e-01f, -1.37624494e-03f,
  -5.18654995e-02f, 2.33076170e-01f, 1.33441821e-01f, 1.69273511e-01f, -2.94657461e-02f, 3.82501408e-02f, 1.34156138e-01f, 1.97888300e-01f, -1.48836762e-01f, 1.35220110e-01f,
  2.63227493e-01f, 3.51451035e-03f, -9.34989527e-02f, 2.12034091e-01f, -1.18185900e-01f, 2.19765395e-01f, 1.17152348e-01f, 6.23481348e-02f, -1.41217828e-01f, 1.88994154e-01f,
  2.17142731e-01f, 1.38795944e-02f, -2.99380600e-01f, -2.06989899e-01f, 1.33103598e-02f, -2.75037915e-01f, 6.03660531e-02f, -1.93654671e-01f, -5.10884672e-02f, -1.07313171e-01f,
  -1.74261391e-01f, 1.66723654e-01f, 4.96598370e-02f, 2.69534022e-01f, -1.25742778e-01f, -1.88048095e-01f, -2.20918618e-02f, 2.87523400e-03f, 1.10544190e-01f, 2.60189082e-02f,
  -1.94424167e-01f, -1.77313939e-01f, 2.69933492e-01f, -2.20642071e-02f, 6.36095777e-02f, -8.20393637e-02f, -5.71218580e-02f, -7.98962340e-02f, 1.05470277e-01f, 1.48465022e-01f,
  -2.33760774e-02f, -7.18083233e-02f, -2.93083251e-01f, -2.28725195e-01f, -2.19110195e-02f, 2.36955419e-01f, 2.43895501e-01f, 4.15214226e-02f, -8.64597782e-02f, 6.86563030e-02f,
  -1.99479349e-02f, 2.08554827e-02f, 9.81169492e-02f, 1.26396835e-01f, -8.38250481e-03f, 3.05492401e-01f, 2.11304992e-01f, -1.14129528e-01f, 2.67751604e-01f, 2.52021432e-01f,
  6.11586757e-02f, 2.91331172e-01f, -1.42521277e-01f, 3.21125947e-02f, 1.48685873e-01f, 1.94061548e-01f, -1.24002829e-01f, 2.27819793e-02f, -1.84909984e-01f, 7.34590963e-02f,
  9.78056788e-02f, -1.20094597e-01f, 1.99395940e-01f, 2.18379758e-02f, 1.66122913e-01f, -1.44420862e-01f, -2.87064075e-01f, -9.78931636e-02f, -2.86507607e-03f, -2.02143610e-01f,
  6.16234206e-02f, 1.22742690e-01f, 9.49754119e-02f, 2.65107989e-01f, 6.44531325e-02f, -1.22746848e-01f, 8.93202573e-02f, 1.79320991e-01f, -4.19041485e-01f, -2.77327206e-02f,
  9.22324955e-02f, 3.49755973e-01f, -2.34209467e-02f, -1.32646918e-01f, 2.03807745e-02f, 1.52822882e-01f, 1.96216062e-01f, -1.37235731e-01f, -1.98879838e-01f, 1.49659872e-01f,
  1.47970229e-01f, 5.29637337e-02f, 1.97410673e-01f, 3.24750006e-01f, -1.67521730e-01f, -1.51472747e-01f, 1.28659800e-01f, -1.60393715e-01f, -5.15437946e-02f, 1.91234723e-01f,
  1.54632434e-01f, -7.69027025e-02f, -2.14365926e-02f, 1.58292742e-03f, -4.50913087e-02f, 2.03863978e-01f, 2.23877653e-01f, -9.01560485e-02f, 2.07555279e-01f, 2.32286736e-01f,
  1.89657941e-01f, -7.29591325e-02f, 1.70058250e-01f, -2.39333045e-02f, 6.59441128e-02f, 2.52713293e-01f, 3.47568877e-02f, -3.21775436e-01f, -4.13749516e-02f, -3.73304129e-01f,
  1.69052687e-02f, -1.75520927e-01f, 2.30634794e-01f, -2.09694058e-01f, 7.78155699e-02f, 2.43109182e-01f, 8.81069899e-02f, -1.75923407e-01f, -1.18881002e-01f, 2.52274889e-02f,
  2.48243704e-01f, -2.14124069e-01f, -8.32706168e-02f, -4.71890941e-02f, 1.33113533e-01f, -2.21576095e-01f, -9.31261480e-02f, -6.74084499e-02f, -2.10421253e-02f, 1.93680152e-01f,
  1.49610370e-01f, -2.36871727e-02f, 2.38823332e-02f, -1.77848235e-01f, 1.94863006e-02f, 7.80947283e-02f, 9.67764780e-02f, 1.85730845e-01f, -2.73323674e-02f, -6.75838813e-02f,
  3.88926603e-02f, 5.94307110e-03f, 1.05908848e-01f, -3.89403820e-01f, 1.27892748e-01f, -1.72973290e-01f, -7.12344423e-02f, -1.32353455e-01f, -4.89526577e-02f, 1.84543252e-01f,
  -9.68695283e-02f, 5.55114485e-02f, -3.48364770e-01f, -3.19107808e-02f, 1.07501939e-01f, 5.52831180e-02f, 2.32251421e-01f, 5.86087396e-03f, 3.42352539e-02f, -1.62322119e-01f,
  7.30980039e-02f, 2.83014089e-01f, 9.04072225e-02f, -8.94686729e-02f, 7.89583698e-02f, 2.11247817e-01f, 1.19231299e-01f, 2.18117073e-01f, 6.22252487e-02f, 9.87583175e-02f,
  2.95028329e-01f, -2.41418425e-02f, 1.65802494e-01f, 8.91582891e-02f, -1.27358600e-01f, 1.30771985e-02f, -1.13097489e-01f, -1.18662134e-01f, -4.09149900e-02f, 1.61736220e-01f,
  -2.89994389e-01f, 1.31308720e-01f, -6.70079216e-02f, 1.27241269e-01f, 8.49776994e-03f, 1.18920244e-01f, 1.23659365e-01f, -3.14560831e-01f, -3.21419239e-01f, -1.60662696e-01f,
  -1.69311240e-02f, -1.98870897e-01f, -2.62768954e-01f, 7.28318766e-02f, 1.95236102e-01f, -3.60887527e-01f, -7.32603669e-02f, -6.74313083e-02f, 4.40775789e-02f, 1.05091333e-01f,
  2.05123216e-01f, 1.30638152e-01f, -1.71139296e-02f, -1.12995610e-01f, 1.58398241e-01f, -2.23735064e-01f, -1.84744447e-01f, 9.46220884e-04f, -3.05988044e-01f, 4.59148735e-02f,
  -7.46518979e-03f, 1.71927691e-01f, 4.67672385e-02f, -7.60178864e-02f, -1.99380174e-01f, 8.43287334e-02f, -3.86895835e-02f, -1.07645705e-01f, -2.20921963e-01f, -1.99755788e-01f,
  3.22274119e-02f, 1.23596810e-01f, -2.53965497e-01f, 4.49556969e-02f, 2.08796993e-01f, -2.20257752e-02f, 1.39726147e-01f, 2.59092003e-01f, 8.14045221e-02f, 1.75095573e-02f,
  5.86810112e-02f, 1.58768788e-01f, -1.01171724e-01f, 5.69881722e-02f, -1.10396929e-02f, -1.57185152e-01f, 1.78797424e-01f, -3.23164761e-02f, 8.51843785e-03f, -2.34412760e-01f,
  4.87001799e-02f, -1.99488148e-01f, 2.31155246e-01f, -1.06106408e-01f, 4.24410328e-02f, -2.57745117e-01f, -2.02005506e-01f, 3.15743238e-01f, 2.70872623e-01f, -1.30463719e-01f,
  8.38808864e-02f, -4.58954163e-02f, 1.75200224e-01f, 1.30231857e-01f, -1.70510262e-01f, 1.29700944e-01f, 7.51013085e-02f, 6.80695474e-02f, -8.88006836e-02f, 2.91113436e-01f,
  1.97690234e-01f, -2.33811229e-01f, 1.35898814e-01f, -1.05892690e-02f, 1.59413308e-01f, 4.31036316e-02f, -1.56478733e-01f, 1.25502586e-01f, -1.29355207e-01f, 6.62376285e-02f,
  2.32657894e-01f, -2.54453778e-01f, 7.00248331e-02f, -3.78169316e-05f, -1.21657163e-01f, 1.50583312e-01f, -1.47783518e-01f, 5.65849319e-02f, 9.45252776e-02f, 1.91870272e-01f,
  -1.18260896e-02f, -2.66427249e-01f, -1.19881585e-01f, 1.75303757e-01f, 1.88677579e-01f, 8.60225335e-02f, 2.83160567e-01f, -4.15306091e-02f, -2.95418829e-01f, 2.67142177e-01f,
  4.87427041e-02f, 1.30961403e-01f, 7.90443346e-02f, 3.17735188e-02f, 2.13176459e-01f, -1.38120502e-01f, 2.53737811e-02f, 1.01341251e-02f, 1.24084882e-01f, -1.59231573e-01f,
  6.31499896e-03f, 1.33829594e-01f, -4.89330515e-02f, 4.31696959e-02f, -1.48190260e-01f, -1.07037745e-01f, -1.52887538e-01f, 1.28568083e-01f, -2.36564368e-01f, 1.04515821e-01f,
  9.31435525e-02f, 3.40432167e-01f, 3.03987652e-01f, 3.06283653e-01f, -1.65565297e-01f, -9.53988582e-02f, -2.40726501e-01f, -4.94106300e-03f, 2.02718265e-02f, -1.90078378e-01f,
  -8.31055641e-02f, -3.12818983e-03f, -9.51892585e-02f, -3.13135177e-01f, -3.45665216e-02f, 6.44770563e-02f, 1.48498863e-01f, -2.72207242e-02f, -3.25430371e-02f, 1.21587351e-01f,
  9.83619243e-02f, -4.88625169e-01f, 2.04675132e-03f, 1.34293027e-02f, -2.33161494e-01f, 3.87067907e-02f, -5.17375410e-01f, -6.51836768e-02f, 3.27026471e-02f, -1.99089006e-01f,
  5.15136361e-01f, 5.42070456e-02f, 3.32334310e-01f, 3.35779995e-01f, -3.43492478e-02f, -1.00734323e-01f, -1.00594424e-01f, -1.63727045e-01f, 1.25474378e-01f, -8.85032713e-02f,
  1.01342529e-01f, -1.90531939e-01f, -2.15130240e-01f, 8.60538408e-02f, -8.08961019e-02f, -1.89928874e-01f, 1.88192919e-01f, 8.04398060e-02f, 2.37948909e-01f, 3.54906410e-01f,
  3.86204541e-01f, 1.33518845e-01f, -1.88484788e-01f, 3.12920421e-01f, -1.19735695e-01f, 1.60340264e-01f, -7.60744885e-02f, -5.64923525e-01f, -8.19748491e-02f, -2.73600429e-01f,
  4.75133955e-02f, 6.49333671e-02f, -2.52260864e-01f, -1.39266243e-02f, -2.04718933e-01f, -3.46634015e-02f, -7.27444068e-02f, 1.16020560e-01f, -2.29344189e-01f, 3.36224645e-01f,
  3.28500718e-02f, 1.59685910e-02f, -1.39160946e-01f, -1.43539622e-01f, 1.80111844e-02f, 3.31970930e-01f, -7.15694427e-02f, 2.00911298e-01f, 1.57315120e-01f, 3.91372629e-02f,
  2.01973561e-02f, -1.80008158e-01f, 1.17071524e-01f, -3.84695921e-03f, 2.98118535e-02f, -1.47523126e-03f, 6.88626152e-03f, 2.94670537e-02f, 1.68075338e-01f, 5.18223904e-02f,
  2.10900545e-01f, -1.65007353e-01f, -5.33741266e-02f, 6.00330308e-02f, 7.00898319e-02f, 2.69685276e-02f, 7.01247202e-03f, 1.56572059e-01f, -2.83268392e-02f, 1.17354125e-01f,
  1.08792335e-01f, -1.43907145e-01f, 1.21544570e-01f, -5.65256514e-02f, 6.30945489e-02f, 3.11626703e-01f, -2.52330959e-01f, -8.33031312e-02f, -7.15825558e-02f, -9.34494510e-02f,
  1.79806918e-01f, 2.43018061e-01f, 1.70999452e-01f, 1.31046232e-02f, 1.09916613e-01f, 9.21615064e-02f, 8.82710367e-02f, 1.54177472e-01f, 2.76825577e-01f, -2.02170089e-01f,
  -5.77831641e-02f, -1.01336129e-01f, -9.44355726e-02f, -1.23854384e-01f, -5.42203896e-02f, -1.53266504e-01f, -8.17363486e-02f, 1.03500471e-01f, 9.32836719e-03f, 7.70950690e-02f,
  2.29975522e-01f, -9.06283632e-02f, -9.69334096e-02f, 5.04063293e-02f, -2.11433709e-01f, -2.07402378e-01f, -1.08135350e-01f, -2.83841103e-01f, 1.02740988e-01f, 1.69090584e-01f,
  5.30121196e-03f, 3.60038787e-01f, 9.01036784e-02f, 1.43585861e-01f, 1.76912528e-02f, -2.99286216e-01f, 5.92616238e-02f, -1.70497466e-02f, 5.15439957e-02f, -4.22755554e-02f,
  -1.93189710e-01f, 2.30797213e-02f, 5.94194010e-02f, 1.15793362e-01f, 9.46445242e-02f, -8.71821269e-02f, -2.03663945e-01f, -1.22755207e-01f, 2.74001569e-01f, 1.03149280e-01f,
  8.09360817e-02f, 1.13056138e-01f, -7.50848278e-02f, 1.16751797e-01f, 2.24172205e-01f, -3.41987669e-01f, 7.48607144e-02f, -8.43703821e-02f, -4.08308357e-02f, 7.84484595e-02f,
  -1.27254752e-03f, 1.94090933e-01f, 2.68405559e-03f, -8.38066936e-02f, 2.84441292e-01f, 2.92636484e-01f, 1.23698428e-01f, -1.51061818e-01f, -3.18923546e-03f, 1.66541710e-01f,
  2.66179770e-01f, -1.54857635e-01f, 1.07861809e-01f, 3.84790525e-02f, -1.65711612e-01f, -3.17424536e-01f, -2.98680753e-01f, -3.71872902e-01f, -8.88137445e-02f, -1.16802387e-01f,
  -4.13175076e-01f, -6.41252249e-02f, -1.67898789e-01f, 4.85737622e-02f, 3.35762836e-02f, 5.18752262e-02f, -1.39707267e-01f, -4.16856349e-01f, 5.45073226e-02f, -1.33018624e-02f,
  1.97205961e-01f, 1.53783634e-01f, -5.46666905e-02f, 1.59333065e-01f, 2.82673091e-01f, 3.12998205e-01f, -3.16461921e-01f, -2.86539644e-01f, 2.26447985e-01f, 2.47524932e-01f,
  4.32672873e-02f, -2.27212310e-01f, -2.45358571e-02f, -8.60143304e-02f, 2.53484935e-01f, -1.09517895e-01f, -6.93534017e-02f, -1.90409541e-01f, -5.47995269e-01f, -3.03590000e-02f,
  7.19647706e-02f, 3.79745737e-02f, -4.76559773e-02f, -8.29391778e-02f, 1.02779731e-01f, 1.44559518e-01f, -6.78068772e-02f, 7.15234950e-02f, -4.80238423e-02f, -2.53548115e-01f,
  3.03303212e-01f, -1.40261844e-01f, 1.43380925e-01f, -2.54187554e-01f, 9.31661204e-02f, 1.54352352e-01f, 3.22512388e-01f, 1.55456915e-01f, 7.15376958e-02f, 1.66799828e-01f,
  -1.71178356e-02f, 1.54495880e-01f, 2.20973790e-01f, -1.45454807e-02f, 2.14917548e-02f, 6.85680434e-02f, 2.95426309e-01f, 1.86331213e-01f, -2.21383855e-01f, 4.06232439e-02f,
  -1.90431967e-01f, -8.89422074e-02f, 1.67156324e-01f, -1.43390670e-01f, -1.34510428e-01f, 2.68759787e-01f, 1.03262767e-01f, -1.29556388e-01f, -3.56223911e-01f, 1.62206020e-03f,
  -7.14552328e-02f, -4.57396582e-02f, 5.30920969e-03f, -1.49463743e-01f, 3.05777323e-02f, -3.45112905e-02f, -5.12129217e-02f, 1.92181870e-01f, 1.95714042e-01f, 3.90386373e-01f,
  -1.00753367e-01f, 1.63124278e-01f, -3.54820793e-03f, -6.78656772e-02f, 8.60697478e-02f, 2.42040865e-02f, 2.33929344e-02f, -7.24261627e-02f, 3.08615148e-01f, -2.01861963e-01f,
  -1.17277466e-01f, 1.43869206e-01f, -1.20801330e-01f, -2.15920918e-02f, -1.27920955e-01f, 1.65776506e-01f, 1.78946584e-01f, -2.26028383e-01f, 2.17734188e-01f, -1.72593698e-01f,
  9.10595134e-02f, 1.49277836e-01f, -1.00449152e-01f, -5.76490872e-02f, -8.67640078e-02f, -1.06353186e-01f, 5.76324575e-02f, -5.22458814e-02f, 4.38317023e-02f, 6.79471195e-02f,
  1.94866225e-01f, 2.25296512e-01f, -1.76037505e-01f, 9.78956893e-02f, 8.21281597e-02f, 2.36291498e-01f, -7.13929012e-02f, 8.95592477e-03f, -1.31672233e-01f, 4.09099683e-02f,
  -8.94458368e-02f, 2.94124298e-02f, 9.82091203e-02f, 8.80865082e-02f, -6.42960966e-02f, 9.83699337e-02f, 1.29946336e-01f, -3.20401937e-01f, 2.97779262e-01f, 3.73838320e-02f,
  -3.74727547e-02f, -5.79497851e-02f, 6.10556453e-02f, -1.09273426e-01f, 5.77229448e-02f, 1.03670090e-01f, 1.76268235e-01f, 1.27273306e-01f, 1.25433803e-01f, 3.43878210e-01f,
  3.25309247e-01f, -3.54088426e-01f, -1.46711156e-01f, 8.26487616e-02f, -2.01229751e-01f, 1.84462070e-01f, -1.76419675e-01f, 2.38444865e-01f, 8.13011155e-02f, -1.50404707e-01f,
  1.32376447e-01f, 1.40392438e-01f, -1.33509219e-01f, 6.43438324e-02f, -1.85467243e-01f, 1.02912433e-01f, 1.11095898e-01f, 1.49162129e-01f, 2.50870675e-01f, 2.46994011e-02f,
  -1.02179140e-01f, 9.32052135e-02f, -6.76937997e-02f, -5.41084670e-02f, 4.81283031e-02f, -1.21874949e-02f, 1.94726083e-02f, -1.22342142e-03f, -1.39173046e-01f, 6.01998111e-03f,
  -1.55564561e-01f, 3.35328102e-01f, 6.99307129e-05f, -1.00146700e-02f, 1.36180505e-01f, -8.60110745e-02f, -7.54906908e-02f, 9.10326466e-02f, 4.20177206e-02f, 1.84678063e-01f,
  1.60978436e-01f, 1.08863257e-01f, -1.98124349e-01f, -3.95258069e-02f, 3.03426466e-04f, 3.57340612e-02f, 8.99634212e-02f, -4.22531873e-01f, -5.94116822e-02f, -1.78539321e-01f,
  1.11222342e-01f, -1.29985452e-01f, 1.81196198e-01f, 1.17435798e-01f, -1.65927678e-01f, -9.55352858e-02f, 9.80347842e-02f, -2.04638898e-01f, -1.67959809e-01f, 1.36506828e-02f,
  2.17901245e-01f, -1.63964242e-01f, -8.99186954e-02f, 5.69068976e-02f, 4.61493909e-01f, -2.07159854e-03f, -1.01976521e-01f, 3.21243882e-01f, -3.63511667e-02f, -1.70748442e-01f,
  -1.36635944e-01f, -2.37867102e-01f, 2.06089560e-02f, 1.55058742e-01f, -3.39655131e-02f, 1.26376301e-01f, -1.22058168e-01f, -2.47614622e-01f, -5.38812540e-02f, 2.81164229e-01f,
  2.32613251e-01f, -7.82089755e-02f, -2.48443723e-01f, 2.05467910e-01f, -3.08892713e-03f, -3.24125662e-02f, -3.46571915e-02f, -8.77111405e-02f, -5.18269688e-02f, 1.53582513e-01f,
  7.66115189e-02f, -1.07090781e-02f, 1.91295847e-01f, -4.16574597e-01f, 1.99685633e-01f, 5.29682152e-02f, 7.04356208e-02f, -8.28909650e-02f, -7.08270818e-02f, 7.84231499e-02f,
  -2.60903966e-02f, 2.44641796e-01f, 1.04971141e-01f, 5.11241257e-02f, 8.85778815e-02f, 2.19282761e-01f, -4.04416732e-02f, 1.00874677e-01f, 2.13942491e-02f, 2.74887443e-01f,
  1.78958163e-01f, -1.89323470e-01f, -6.20192476e-02f, 5.42192906e-03f, 3.37587297e-02f, -3.03835183e-01f, 2.41596594e-01f, -1.63179159e-01f, 9.61239710e-02f, 1.11687832e-01f,
  1.10119276e-01f, -2.44771075e-02f, -7.16422796e-02f, 1.39129788e-01f, 2.17889920e-01f, 2.09671669e-02f, -2.82982923e-02f, 2.64412045e-01f, 3.99944782e-01f, -3.01783174e-01f,
  -2.65660375e-01f, -8.30335543e-02f, -1.92997903e-01f, -1.06891647e-01f, -2.40167186e-01f, 2.15695769e-01f, -1.47067815e-01f, -3.04220282e-02f, 7.20805451e-02f, 2.60192871e-01f,
  -2.47506395e-01f, -1.60066038e-01f, -1.88549444e-01f, 2.89068401e-01f, 2.49801069e-01f, -6.71359450e-02f, 8.36667940e-02f, -2.51381146e-03f, -8.50999579e-02f, -8.59672725e-02f,
  2.43613839e-01f, 8.15339908e-02f, -7.91613311e-02f, 8.06183293e-02f, -2.28194997e-01f, -3.23830098e-02f, -3.77476998e-02f, -4.11462367e-01f, -1.29954293e-01f, 1.26363903e-01f,
  -8.91537368e-02f, -4.95351478e-02f, 7.54588097e-02f, -3.37320179e-01f, 4.38729161e-03f, -8.69798213e-02f, 1.29938528e-01f, -2.34903581e-02f, 2.17789367e-01f, 1.47928700e-01f,
  1.06775858e-01f, 9.15867910e-02f, 4.28498723e-03f, 2.78485212e-02f, 2.28074521e-01f, -1.44146860e-01f, 3.01356912e-01f, -1.24476157e-01f, 2.06515074e-01f, 1.00661509e-01f,
  -4.66982797e-02f, -1.10529941e-02f, -9.56706852e-02f, 5.30269481e-02f, 3.99216171e-03f, -2.48423606e-01f, -1.42436132e-01f, -3.31014022e-02f, 5.91091476e-02f, -8.61273333e-03f,
  -5.56310341e-02f, -7.14438781e-02f, -1.09848313e-01f, 1.54096812e-01f, 1.74246430e-01f, 6.29837140e-02f, 2.94206321e-01f, -1.41805962e-01f, 4.87445593e-02f, -1.00781523e-01f,
  -1.34517163e-01f, 9.70596075e-02f, -2.85027415e-01f, 4.91738617e-02f, 9.76087933e-04f, 2.52269834e-01f, 2.41884664e-01f, -2.08415523e-01f, -6.37427121e-02f, -8.25818032e-02f,
  -1.14359625e-01f, 2.02346042e-01f, -3.51091661e-02f, 9.86120105e-02f, -2.31801897e-01f, -1.77993178e-01f, -1.28277674e-01f, -5.60664311e-02f, 1.04007900e-01f, 2.36187100e-01f,
  5.10547049e-02f, -7.55350739e-02f, 1.93574727e-01f, -1.87242404e-01f, -3.19255710e-01f, -1.33297622e-01f, -5.29535003e-02f, 2.43820518e-01f, 3.33098769e-01f, 1.85370013e-01f,
  2.99416989e-01f, 2.57882267e-01f, 4.83680785e-01f, 5.98180629e-02f, 1.72635857e-02f, 5.46886742e-01f, 6.08417206e-02f, 3.49115487e-03f, -9.44698080e-02f, -2.86393464e-01f,
  -9.75523219e-02f, -8.09870884e-02f, -1.21914797e-01f, 1.42660990e-01f, -2.01504514e-01f, 4.45112854e-01f, 1.55495793e-01f, 2.31166966e-02f, -3.50829624e-02f, 1.75095424e-01f,
  -1.25444084e-01f, 2.65224993e-01f, -2.09513262e-01f, 9.46274251e-02f, -1.30800247e-01f, -2.91143775e-01f, -1.38843998e-01f, 2.09902629e-01f, 8.65561813e-02f, 2.02523068e-01f,
  1.32310197e-01f, -1.02112956e-01f, 6.44680560e-02f, -8.08295757e-02f, -1.75720200e-01f, 5.49306795e-02f, 2.27659672e-01f, 4.27764729e-02f, 1.00590579e-01f, -1.72284376e-02f,
  1.99595138e-01f, 1.83956459e-01f, 1.37818739e-01f, -2.88959354e-01f, -1.08619230e-02f, -5.90886697e-02f, 3.40293258e-01f, -2.92602777e-01f, 1.34055525e-01f, -1.04294874e-01f,
  -1.52283907e-01f, 1.28923982e-01f, 8.23605284e-02f, 4.28394787e-02f, -3.83281037e-02f, 1.37559503e-01f, 5.97920828e-02f, 4.27940339e-02f, -1.04233935e-01f, -1.69855699e-01f,
  -2.34746039e-02f, 2.14287713e-01f, 2.45987084e-02f, -1.00616202e-01f, 3.95974377e-03f, -2.47777137e-03f, -1.52081430e-01f, 1.81154937e-01f, 2.01270372e-01f, -1.94738850e-01f,
  -1.36352807e-01f, -2.85254687e-01f, 2.85127386e-02f, 2.40894884e-01f, 1.33734420e-01f, 1.07852414e-01f, 1.78305522e-01f, 3.21771562e-01f, 3.14518809e-01f, -1.59712940e-01f,
  2.97928844e-02f, 9.92262959e-02f, 3.80620778e-01f, 1.36652542e-02f, -7.31374100e-02f, -4.84230043e-03f, -8.37002939e-04f, 4.27022949e-03f, 2.49758288e-02f, 9.26424861e-02f,
  4.84261401e-02f, 1.43988226e-02f, -2.49731213e-01f, -1.57301232e-01f, 2.08905622e-01f, 5.78480810e-02f, 1.13738500e-01f, -1.91031322e-02f, 6.79540187e-02f, 1.24797821e-01f,
  1.06016710e-01f, 1.55955166e-01f, 6.41642734e-02f, 1.17194243e-01f, -1.19724438e-01f, -1.81979612e-01f, 6.11664355e-02f, -3.95660177e-02f, 4.27780300e-02f, -2.40598500e-01f,
  -3.94756310e-02f, 1.04631722e-01f, -2.75667813e-02f, 7.74069279e-02f, 6.87031001e-02f, -3.19127023e-01f, 2.76880469e-02f, 3.84590868e-03f, 1.76743805e-01f, 1.64556056e-02f,
  9.13724452e-02f, -3.18951845e-01f, -1.30487448e-02f, 1.35197490e-01f, 8.16594586e-02f, -2.92331457e-01f, 2.44022846e-01f, 1.42381996e-01f, 9.66464579e-02f, 1.17123425e-01f,
  6.86433241e-02f, 9.42921788e-02f, -7.79859945e-02f, -6.37265667e-02f, 2.99133390e-01f, 7.93824792e-02f, 4.88134548e-02f, 1.59193333e-02f, -1.59767821e-01f, -2.29307160e-01f,
  -1.24623835e-01f, 1.51442796e-01f, 2.64275551e-01f, 3.18107545e-01f, -9.10588428e-02f, -1.32212108e-02f, -1.15955286e-01f, 9.40003060e-03f, 6.30098954e-02f, 1.34445205e-01f,
  -2.05416717e-02f, -7.99672736e-04f, -6.44335449e-02f, -1.70290843e-01f, 8.09458718e-02f, 2.53465641e-02f, 3.94451991e-02f, -1.01160869e-01f, -1.83924496e-01f, -1.17902406e-01f,
  1.75044075e-01f, 2.82471478e-02f, -1.88518632e-02f, 1.05108634e-01f, -9.09602083e-03f, -4.24656086e-02f, 6.78979605e-02f, -3.00399065e-01f, -1.38029069e-01f, 2.50700712e-01f,
  2.59972274e-01f, -7.37947449e-02f, -1.19873323e-01f, 2.48919025e-01f, 9.40473080e-02f, -2.38411427e-01f, 1.78944357e-02f, 4.22672890e-02f, 7.82729220e-03f, -7.38133639e-02f,
  -2.02135250e-01f, -2.41057768e-01f, 4.92374301e-02f, -7.26997256e-02f, -1.66460127e-01f, 6.06853217e-02f, 2.86399156e-01f, 8.64132270e-02f, 5.64463846e-02f, 2.80656386e-02f,
  2.89503515e-01f, -1.08274939e-02f, 1.15133986e-01f, 2.28936955e-01f, 3.72851580e-01f, 1.16233855e-01f, -2.44718716e-01f, -2.08229259e-01f, -5.09332418e-02f, -1.98918089e-01f,
  1.60312951e-01f, -2.40162492e-01f, -3.48653831e-02f, -1.26983076e-01f, -4.21027727e-02f, 2.45824143e-01f, -1.06805459e-01f, -1.15685597e-01f, -2.18411297e-01f, -2.38483977e-02f,
  -1.90951414e-02f, 9.85403359e-02f, -3.14168274e-01f, -3.88229429e-03f, -1.47073269e-01f, 3.87739949e-02f, -1.97721496e-01f, -1.13427706e-01f, -8.24695006e-02f, 2.76489526e-01f,
  7.24914372e-02f, 1.52049735e-01f, -5.51964343e-02f, -2.25446269e-01f, 2.58126408e-01f, -1.44983083e-01f, -4.39828448e-02f, 1.54620618e-01f, -3.51067126e-01f, -9.11042988e-02f,
  -8.49949047e-02f, -9.10565555e-02f, 1.16321914e-01f, -1.17957920e-01f, -1.82263069e-02f, -6.84171692e-02f, 9.30390358e-02f, 1.64639115e-01f, -7.57145286e-02f, 4.22534645e-02f,
  -2.29493394e-01f, 1.52662229e-02f, -2.89454997e-01f, 1.36909455e-01f, 1.12354591e-01f, 1.53117999e-01f, 2.70408422e-01f, 7.41937831e-02f, 8.57335553e-02f, -2.89009988e-01f,
  1.33727595e-01f, 2.12735366e-02f, -3.66041623e-02f, -3.66463922e-02f, 4.60279733e-02f, 1.42306238e-01f, 3.65127355e-01f, 1.06047846e-01f, 1.34974167e-01f, 1.14350803e-01f,
  -1.11517489e-01f, 1.10420227e-01f, -2.28296742e-02f, 1.76342979e-01f, -2.25867759e-02f, 2.72415310e-01f, -1.90462261e-01f, 1.73916966e-01f, -4.59259376e-02f, -3.51805419e-01f,
  1.64077669e-01f, -7.32167810e-02f, 2.21089751e-01f, 1.48302466e-01f, -2.72729248e-01f, -1.94053855e-02f, 1.10841086e-02f, -1.29084140e-01f, -1.71061739e-01f, 1.05419710e-01f,
  1.88518569e-01f, 2.04877198e-01f, 1.46201074e-01f, -2.30135769e-01f, 2.39264965e-02f, -1.79485992e-01f, -2.03791440e-01f, 1.63045615e-01f, -1.85613975e-01f, 9.94424447e-02f,
  -7.75067732e-02f, -2.17143059e-01f, 2.13794429e-02f, 6.22637309e-02f, -2.51693577e-01f, 2.17487849e-03f, -2.84452796e-01f, 3.08228889e-03f, -5.92026375e-02f, -9.90873799e-02f,
  2.03669950e-01f, 6.10560663e-02f, 2.30392769e-01f, -2.14299168e-02f, 3.05470735e-01f, -8.08966011e-02f, -7.08999485e-02f, 2.94392854e-01f, 1.70285419e-01f, 1.13917589e-01f,
  -4.89454493e-02f, -1.41567528e-01f, -2.36653969e-01f, 1.31616250e-01f, -1.01246662e-01f, -5.47192395e-02f, 9.11127105e-02f, -1.09189391e-01f, -8.01602229e-02f, 1.49420127e-01f,
  -3.26184966e-02f, 1.35657176e-01f, -1.49403438e-02f, 1.49656937e-01f, 1.32576227e-01f, -1.01081327e-01f, -9.65482891e-02f, 2.68473327e-01f, 4.93526459e-02f, -2.23296493e-01f,
  1.76464140e-01f, -1.34729221e-01f, 1.73001558e-01f, -4.67865281e-02f, 7.16216713e-02f, -1.68290496e-01f, -1.22883603e-01f, -2.60801017e-01f, 1.58770550e-02f, 2.74303287e-01f,
  -8.34649801e-02f, 1.76427186e-01f, 1.01397932e-01f, -1.47551134e-01f, -8.66939873e-02f, 1.01794459e-01f, 3.38027537e-01f, 1.61358267e-02f, -3.18360239e-01f, 1.19623087e-01f,
  -2.04367504e-01f, 1.64952390e-02f, -6.90431744e-02f, -4.18232679e-02f, -8.20952952e-02f, 4.73360233e-02f, -1.43587515e-02f, 3.40482891e-02f, -5.56818061e-02f, 3.40075642e-01f,
  1.57383122e-02f, 1.28250554e-01f, 4.40858193e-02f, 6.79647923e-02f, 4.08151299e-02f, 1.68673992e-01f, -2.10625410e-01f, -6.74302652e-02f, 5.16192019e-02f, 5.14021330e-02f,
  1.07794374e-01f, -7.12984651e-02f, -1.84344500e-01f, 6.64202049e-02f, -1.34355664e-01f, -2.25911841e-01f, 4.09224397e-03f, -2.69019753e-02f, 6.76539764e-02f, -1.04316033e-03f,
  2.94058565e-02f, 4.31588069e-02f, 2.32146218e-01f, 3.88679281e-02f, 2.08583698e-01f, 1.68029055e-01f, 2.04249069e-01f, 1.39879301e-01f, 9.49799418e-02f, 1.49979725e-01f,
  -1.05106600e-01f, -1.81610912e-01f, 2.67526507e-02f, -1.70922220e-01f, 1.11072831e-01f, 9.79037136e-02f, -2.98317634e-02f, -3.88180800e-02f, -1.37686297e-01f, -1.04179196e-01f,
  1.22807063e-01f, -4.08218764e-02f, -9.65425149e-02f, 1.30453318e-01f, -1.02031469e-01f, 8.33220556e-02f, 5.28043807e-02f, -4.31081792e-03f, -1.10922083e-01f, -9.75648910e-02f,
  -2.58136749e-01f, 3.55886549e-01f, 1.41368195e-01f, 2.48959303e-01f, 3.71455550e-01f, -1.98153749e-01f, 1.50836647e-01f, -3.32100540e-01f, 7.25839064e-02f, 1.54662237e-01f,
  -4.48727995e-01f, 4.12153490e-02f, 4.76532765e-02f, 3.06038409e-01f, 2.41917238e-01f, -2.71108955e-01f, -1.54100005e-02f, -1.72805369e-01f, -3.66755351e-02f, 4.04031053e-02f,
  -2.14511082e-01f, 8.76338482e-02f, -4.40315902e-01f, 1.86444521e-01f, -2.07958892e-01f, 2.23660454e-01f, 2.28280663e-01f, 7.70131648e-02f, 2.53468126e-01f, 2.43464440e-01f,
  6.01187348e-02f, 2.91564483e-02f, -3.47321242e-01f, 1.03839748e-01f, 4.93391491e-02f, 8.62350836e-02f, 1.34464666e-01f, -1.80472389e-01f, 1.30700797e-01f, 4.29603178e-03f,
  -1.25144020e-01f, -5.11457361e-02f, 1.16492629e-01f, -9.57086086e-02f, -5.84989078e-02f, -1.97414637e-01f, 1.80657487e-02f, 4.29200083e-02f, 2.29274020e-01f, 1.60112321e-01f,
  1.92805216e-01f, 6.68698996e-02f, 1.89808920e-01f, -1.55371487e-01f, 1.36634391e-02f, 1.71663940e-01f, 3.89936686e-01f, -1.46089956e-01f, -9.21922736e-04f, 9.51523483e-02f,
  1.79541439e-01f, 9.54226851e-02f, -2.13962227e-01f, -3.37732062e-02f, 3.12702991e-02f, 5.88954985e-02f, 1.02108140e-02f, 7.16929138e-02f, 4.05869894e-02f, -6.10979907e-02f,
  1.59154058e-01f, -4.87481654e-02f, 4.56822924e-02f, 1.18592270e-01f, -8.88852552e-02f, 2.78708115e-02f, 3.78400050e-02f, -1.09317183e-01f, -1.34392381e-01f, -1.23974927e-01f,
  -1.70897022e-02f, -1.62719846e-01f, -5.51689193e-02f, -1.39626250e-01f, 4.55778651e-02f, 1.47131577e-01f, -3.31954435e-02f, 1.43072233e-01f, -7.54436478e-02f, -9.15125906e-02f,
  -7.50862807e-02f, 2.21709177e-01f, 4.88481075e-02f, 3.99514228e-01f, 1.44221932e-01f, -5.02180159e-02f, -8.10242221e-02f, 2.37933081e-02f, -3.16851102e-02f, -1.33598760e-01f,
  1.18935511e-01f, 2.01081886e-04f, 1.28013179e-01f, 1.08389646e-01f, 2.23537937e-01f, 1.52153522e-01f, -6.50874106e-03f, 1.84039827e-02f, 7.11054280e-02f, 5.77378869e-02f,
  -7.83273876e-02f, -3.72182965e-01f, -1.30498916e-01f, -3.14663351e-01f, 1.53697297e-01f, 2.47442484e-01f, -7.11751133e-02f, 1.11940227e-01f, -3.35251093e-01f, -3.20238769e-01f,
  -2.47563258e-01f, 9.99567658e-03f, -2.47056261e-01f, -1.01656429e-01f, 2.91584469e-02f, -1.47045061e-01f, 4.23751809e-02f, 3.70324031e-02f, -1.51473843e-02f, 6.94836378e-02f,
  1.85672298e-01f, 1.68319717e-01f, -2.88893413e-02f, -1.44193903e-01f, 2.50342548e-01f, -1.22866228e-01f, -8.92535150e-02f, 6.23353571e-03f, -8.12657028e-02f, -2.26837635e-01f,
  2.72302300e-01f, 4.71302681e-02f, 1.80054948e-01f, 7.53569379e-02f, -9.13130268e-02f, 6.59008976e-03f, -1.09102555e-01f, 3.25519830e-01f, -1.39074298e-02f, 2.80864518e-02f,
  -2.48603448e-01f, -1.77894816e-01f, 2.28425741e-01f, 2.70013601e-01f, -1.09065315e-02f, 1.40277058e-01f, 1.81531206e-01f, -2.62508482e-01f, -2.19507851e-02f, -3.35841626e-01f,
  2.33038440e-01f, 1.02431521e-01f, 1.11330047e-01f, 3.03224266e-01f, 3.98470275e-02f, 2.33730301e-01f, 2.55436987e-01f, 2.53773630e-01f, 9.46277604e-02f, 4.36410457e-01f,
  5.52268513e-03f, -3.28718960e-01f, -3.15033585e-01f, -2.61312164e-02f, 1.71384618e-01f, -5.11287376e-02f, 1.67368397e-01f, -7.24292323e-02f, -6.23286478e-02f, 5.00152707e-01f,
  8.04396868e-02f, -1.66798532e-01f, 2.05910951e-02f, -1.58582851e-01f, 1.22296102e-01f, 1.58160657e-01f, 1.19180635e-01f, 1.67075887e-01f, -1.61541086e-02f, -1.28356457e-01f,
  8.79087225e-02f, 1.03479207e-01f, 1.47504890e-02f, 1.00258127e-01f, -1.54593781e-01f, -2.04508230e-01f, 1.99809715e-01f, 9.69576708e-04f, 2.39832655e-01f, -6.15653209e-02f,
  2.29971465e-02f, 4.62821834e-02f, -6.82746153e-03f, 1.13501482e-01f, -8.78321454e-02f, 4.01917070e-01f, 6.14241511e-02f, -4.59042937e-02f, 9.82821137e-02f, 1.47239432e-01f,
  2.80298106e-02f, -1.21997245e-01f, -3.30150366e-01f, 8.78700390e-02f, -1.51322631e-03f, 1.23793080e-01f, -1.03610354e-02f, -9.12976488e-02f, -1.53184399e-01f, 6.40719533e-02f,
  -2.30869893e-02f, 2.43649334e-01f, 7.62689114e-02f, -2.54174441e-01f, 1.08920835e-01f, -9.03910846e-02f, -4.64504547e-02f, -7.54165575e-02f, 1.29787937e-01f, -3.01955771e-02f,
  8.19832012e-02f, -2.35206429e-02f, 1.86632329e-03f, -1.44705012e-01f, 6.81634843e-02f, 6.29288554e-02f, -1.10412039e-01f, 1.66392520e-01f, -7.58388713e-02f, -1.48579866e-01f,
  -1.26346335e-01f, -8.06787238e-02f, 1.44682586e-01f, 5.96757978e-03f, -1.75591707e-01f, -3.43647331e-01f, -4.92751151e-02f, 2.80045331e-01f, 6.56254068e-02f, 2.97752559e-01f,
  5.30137941e-02f, -5.66916704e-01f, -4.53554280e-02f, 3.53550725e-02f, -5.07992022e-02f, 2.42750362e-01f, -2.14762837e-01f, 7.28840753e-02f, 6.65352494e-02f, 4.11560357e-01f,
  -1.85773522e-01f, -1.64532974e-01f, 1.96134388e-01f, 2.74928361e-01f, 8.04794878e-02f, 1.22278348e-01f, -4.40781489e-02f, -1.83901384e-01f, 4.90460137e-04f, -1.51130885e-01f,
  -9.35800076e-02f, -3.85392196e-02f, -4.86035854e-01f, 1.49071380e-01f, 1.25861079e-01f, 1.35354474e-01f, -2.40433782e-01f, 1.99433163e-01f, -5.81963882e-02f, 1.06511585e-01f,
  -4.90070432e-02f, 3.20203118e-02f, 4.32201624e-02f, -1.31669566e-01f, 3.31122637e-01f, -7.97170997e-02f, 3.57206501e-02f, -3.67139429e-02f, -1.56233415e-01f, 1.58813134e-01f,
  5.16756140e-02f, -1.70949161e-01f, 7.90938661e-02f, -5.43367974e-02f, 1.19820870e-01f, 3.62302773e-02f, 1.40549883e-01f, 2.62584358e-01f, -3.03506404e-01f, -3.57509822e-01f,
  4.04245928e-02f, -5.71854189e-02f, 1.84848923e-02f, 6.02178633e-01f, 2.24219888e-01f, -2.00238312e-03f, -7.81486779e-02f, 4.29614663e-01f, 2.99100071e-01f, 1.89722583e-01f,
  5.75481988e-02f, -1.36245310e-01f, -2.65605628e-01f, -7.24860653e-02f, 2.42905512e-01f, 1.84016362e-01f, -2.25148305e-01f, -2.48402506e-02f, 1.14852548e-01f, 9.52204131e-03f,
  -2.23199159e-01f, -4.16180603e-02f, -1.49276450e-01f, -2.13828906e-01f, 1.33722216e-01f, 9.09239724e-02f, 9.22802091e-02f, 2.33056858e-01f, 7.35376626e-02f, -2.45120823e-02f,
  4.70528901e-02f, 1.39648721e-01f, 2.02343151e-01f, -1.83040440e-01f, -6.08610958e-02f, -1.04152210e-01f, 5.85985892e-02f, 1.07249826e-01f, 2.68566119e-03f, -1.10176302e-01f,
  -1.17808327e-01f, -1.56225003e-02f, -2.65446417e-02f, -1.66513801e-01f, -1.10194996e-01f, 4.12708707e-02f, -7.34717771e-02f, 1.86470836e-01f, -2.27279022e-01f, 3.29487622e-01f,
  -8.86661187e-02f, -4.49666791e-02f, 2.43385434e-01f, -4.34286008e-03f, 9.31400508e-02f, 1.68538183e-01f, 5.17181866e-02f, -1.14616752e-02f, 1.81776751e-02f, 4.37714793e-02f,
  9.09670591e-02f, 1.46292374e-01f, 8.93018022e-02f, 2.79038280e-01f, 2.86824465e-01f, -1.37490807e-02f, -1.45037487e-01f, 5.13622046e-01f, -2.00685814e-01f, 3.15226436e-01f,
  -3.61026287e-01f, -3.97391655e-02f, -4.14993763e-01f, 3.21254641e-01f, 3.71633291e-01f, -2.85759196e-02f, -4.03217196e-01f, 4.26059812e-02f, 3.14464197e-02f, -2.58627504e-01f,
  -4.24876332e-01f, 3.50492932e-02f, -2.75281793e-03f, -1.56563431e-01f, -3.12557966e-01f, -4.42388095e-02f, 3.96500304e-02f, -2.90299684e-01f, -1.20487168e-01f, 1.58284590e-01f,
  -6.27973229e-02f, 1.71508551e-01f, 1.13575689e-01f, -2.98134178e-01f, 4.65707593e-02f, -3.09836417e-01f, 1.33110881e-01f, -1.50009245e-01f, -9.03710052e-02f, -1.17105566e-01f,
  -2.74131387e-01f, 4.42694165e-02f, 1.16726428e-01f, -1.00150846e-01f, 1.61560744e-01f, -1.06871501e-01f, 2.52365559e-01f, -2.17456371e-01f, -1.89535633e-01f, -2.88327001e-02f,
  1.44496739e-01f, -2.52078623e-01f, -1.81973949e-01f, 9.63318571e-02f, -3.45772684e-01f, 4.03142497e-02f, 2.64838159e-01f, 5.47063351e-02f, -1.42376469e-02f, 3.16699445e-01f,
  3.59280258e-02f, 1.64881155e-01f, -1.08148381e-01f, -3.47256176e-02f, -1.09598033e-01f, 1.16139995e-02f, 1.48368701e-01f, 2.86879927e-01f, -1.83792673e-02f, -3.33212078e-01f,
  -1.34682367e-02f, 2.53609508e-01f, 7.56964460e-02f, 2.82105565e-01f, -9.79142040e-02f, 1.83912460e-02f, -8.88284147e-02f, 1.62150219e-01f, 2.47448102e-01f, 1.05194166e-01f,
  1.37129381e-01f, -3.49538743e-01f, 2.47813299e-01f, 7.48326108e-02f, -1.71692833e-01f, -1.95900276e-01f, -5.38031533e-02f, -2.95432657e-01f, -3.56210440e-01f, 2.51847506e-01f,
  2.01523304e-02f, -3.82121988e-02f, 3.47579658e-01f, 3.40842977e-02f, -1.58185601e-01f, -3.22228856e-02f, 1.39233768e-01f, 5.32799587e-03f, -7.59937987e-02f, 1.58995226e-01f,
  -9.24923047e-02f, 8.00489932e-02f, 2.84294873e-01f, -3.09691370e-01f, 1.72027275e-01f, -1.93909809e-01f, 2.20687855e-02f, -4.54666346e-01f, 5.04363514e-03f, -1.67919341e-02f,
  -2.56194651e-01f, 2.04548612e-01f, -2.65794575e-01f, -1.11247331e-01f, 4.01669532e-01f, 5.87059632e-02f, -1.32064559e-02f, 5.03303111e-01f, 1.60708964e-01f, 1.54080048e-01f,
  -2.48841301e-01f, -6.36494998e-03f, -2.03961637e-02f, -1.15642818e-02f, 8.22374150e-02f, -4.56199124e-02f, 1.60097435e-01f, 1.44226074e-01f, 4.42983806e-02f, 1.40150636e-01f,
  3.64760123e-02f, -2.48319775e-01f, -1.34274855e-01f, -1.40660107e-01f, -4.46274057e-02f, -1.21871345e-01f, 2.06665248e-01f, 4.37189713e-02f, 1.35354027e-01f, 2.05561355e-01f,
  1.57791406e-01f, 5.28973788e-02f, -2.31622398e-01f, -1.72216982e-01f, 7.55224898e-02f, -2.71770447e-01f, -1.76144928e-01f, 5.34287654e-02f, 1.79309711e-01f, -1.22472428e-01f,
  -2.87903517e-01f, -5.28763719e-02f, -1.48142412e-01f, 1.76690713e-01f, 3.90974656e-02f, 8.48361701e-02f, -5.94981462e-02f, -1.77956134e-01f, 3.75962071e-02f, -1.07593626e-01f,
  -8.39496776e-02f, 3.74705456e-02f, -9.15643722e-02f, -3.34173702e-02f, 5.62653728e-02f, 1.48557693e-01f, -8.34238380e-02f, -3.75643790e-01f, 6.54873624e-02f, -1.20192409e-01f,
  -8.46210420e-02f, 2.05792144e-01f, -1.24068126e-01f, 1.37310699e-01f, -1.36805683e-01f, -9.69606042e-02f, -2.47310385e-01f, 4.98194918e-02f, 1.51699662e-01f, 1.38268441e-01f,
  9.76212844e-02f, 2.00439841e-02f, 2.03214645e-01f, -1.70215026e-01f, 5.42394258e-02f, -1.02591641e-01f, -2.64576580e-02f, 8.55936110e-02f, 1.88483760e-01f, 1.62488610e-01f,
  3.22409987e-01f, 1.21505342e-01f, 7.66136944e-02f, 2.39901453e-01f, -3.75086665e-02f, 1.73790812e-01f, 9.02392790e-02f, 1.17662042e-01f, 2.32283082e-02f, -1.64956093e-01f,
  -3.29654485e-01f, 4.48262021e-02f, -2.63174236e-01f, -5.11088133e-01f, -8.39509815e-02f, 1.93228334e-01f, 4.64706682e-02f, 1.90352499e-01f, 1.49737567e-01f, 6.17667995e-02f,
  -9.40543190e-02f, 3.24623466e-01f, -7.63051659e-02f, 6.49232939e-02f, -1.73289716e-01f, -6.22440279e-02f, 3.67335349e-01f, -1.39248028e-01f, -1.13376744e-01f, 4.12853844e-02f,
  -1.26313955e-01f, 2.14086235e-01f, -2.27110833e-01f, -2.73186378e-02f, 1.28001377e-01f, -2.40836188e-01f, 1.72709569e-01f, 2.20482707e-01f, -2.98012167e-01f, -7.92801157e-02f,
  2.54849911e-01f, 2.67164856e-01f, 2.59120673e-01f, -1.63686439e-01f, -4.38267714e-04f, -1.04526639e-01f, 3.24643999e-01f, -1.80761114e-01f, 1.10772796e-01f, 1.44547909e-01f,
  -1.06211193e-01f, 4.85138521e-02f, 5.76782487e-02f, -2.41343617e-01f, 1.30680785e-01f, 8.93910527e-02f, -1.53397575e-01f, 2.97101796e-01f, -1.57282516e-01f, -3.21020819e-02f,
  -2.20035166e-02f, -2.66010791e-01f, 8.18243474e-02f, 1.35489300e-01f, -9.31106359e-02f, 4.83848974e-02f, -4.43643741e-02f, 7.33140931e-02f, -1.25993982e-01f, -8.61758664e-02f,
  9.12412405e-02f, -1.58302322e-01f, 1.74444810e-01f, -2.49988269e-02f, 8.00007060e-02f, -1.43270776e-01f, 2.03574598e-01f, 3.24448361e-03f, 9.95764360e-02f, 2.76411682e-01f,
  -6.76133856e-02f, -6.91801608e-02f, 2.62360930e-01f, -8.40606168e-02f, -1.30736098e-01f, -2.53182836e-04f, 2.87997723e-01f, -6.21239096e-02f, -3.56909484e-01f, -7.75281265e-02f,
  2.76781321e-01f, -2.49439701e-01f, -2.54728556e-01f, 4.92907455e-03f, -1.64895970e-02f, 4.98227105e-02f, 7.69203529e-02f, -2.18807295e-01f, -2.22893450e-02f, 6.31746352e-02f,
  -3.92754655e-03f, 1.36194587e-01f, -1.62895873e-01f, 3.42481397e-02f, 8.68711993e-02f, -8.70181173e-02f, 4.40649055e-02f, 6.75544664e-02f, -1.67827340e-04f, -2.51633674e-01f,
  1.30552441e-01f, 1.79565027e-01f, -1.20701194e-01f, 1.46210909e-01f, 1.14564084e-01f, -3.25288683e-01f, -1.51234508e-01f, 8.42376724e-02f, -9.49382260e-02f, 8.93441960e-02f,
  1.24184899e-01f, 1.72781751e-01f, -2.62916297e-01f, 2.01284010e-02f, 9.53378454e-02f, -2.28879660e-01f, 1.27774000e-01f, 1.65828362e-01f, 6.24848418e-02f, 1.82178289e-01f,
  2.06712499e-01f, 2.34873578e-01f, 1.64785147e-01f, -1.44205645e-01f, -1.14117414e-01f, 2.90278703e-01f, 8.66331682e-02f, -2.26061672e-01f, 9.91258994e-02f, -5.48311509e-02f,
  -4.63931859e-02f, 9.68986973e-02f, -2.75577992e-01f, -4.00254935e-01f, -2.21287310e-01f, -1.56172901e-01f, -1.99892581e-01f, 4.74322319e-01f, -1.87888056e-01f, -3.73697802e-02f,
  -4.46303971e-02f, -6.16444461e-02f, 1.15454651e-01f, 1.54472485e-01f, -1.29857987e-01f, 2.65334308e-01f, 1.99760512e-01f, -3.47458906e-02f, -2.34053470e-02f, -2.24606857e-01f,
  -2.56952662e-02f, -1.05408095e-01f, 1.29629731e-01f, -8.97541642e-03f, -3.68815124e-01f, -3.75932232e-02f, 9.42298323e-02f, 2.25524202e-01f, 1.92957655e-01f, -1.64879993e-01f,
  -2.72142272e-02f, -7.87312016e-02f, 8.39921013e-02f, 1.03208899e-01f, -4.30483103e-01f, -1.88216954e-01f, 8.58748052e-03f, 9.35247391e-02f, 1.03247631e-02f, 7.29433671e-02f,
  -1.49454221e-01f, 7.39314854e-02f, 1.56219870e-01f, -1.04208812e-01f, -6.79986328e-02f, -4.08780813e-01f, -2.62645055e-02f, -2.88169570e-02f, 2.19306469e-01f, -1.30671337e-01f,
  2.18911946e-01f, 1.66223645e-01f, 1.43413529e-01f, 4.32992242e-02f, 2.15702862e-01f, 1.06829681e-01f, -9.40406770e-02f, 1.05659768e-03f, 1.08854793e-01f, -1.74889639e-01f,
  -6.31177202e-02f, 2.18883067e-01f, 6.60432056e-02f, -1.20196259e-02f, -2.54153013e-02f, 3.18645209e-01f, -3.71114165e-02f, 1.49842113e-01f, 1.71689719e-01f, 6.18855134e-02f,
  -4.29511890e-02f, -2.24008754e-01f, 1.69934332e-02f, 1.60640493e-01f, -1.26852272e-02f, -5.70218265e-02f, -1.81463882e-01f, -1.89668566e-01f, -3.63388062e-01f, 2.12603986e-01f,
  5.69117106e-02f, 5.32486886e-02f, 3.36578041e-01f, -7.26439282e-02f, 7.81997293e-02f, 2.12874953e-02f, 2.20463559e-01f, 1.93614826e-01f, -6.88134134e-02f, -6.07042611e-02f,
  1.03859911e-02f, 3.47198024e-02f, 2.59838611e-01f, -2.13214874e-01f, -1.32256091e-01f, -9.44403652e-03f, -3.05275284e-02f, 1.75087228e-01f, -3.04207709e-02f, 1.54263750e-01f,
  -5.14049865e-02f, -2.93028206e-02f, -5.41466363e-02f, 6.30180538e-02f, 2.19244584e-01f, 2.42576107e-01f, -1.28376544e-01f, 2.58330137e-01f, 1.62878275e-01f, -1.13070915e-02f,
  -3.26406285e-02f, -2.58948468e-02f, 2.64692772e-02f, 1.26054898e-01f, 1.69221237e-01f, 1.27091438e-01f, 3.10268234e-02f, 8.85972381e-02f, 3.96054894e-01f, 2.08838098e-02f,
  -1.51713893e-01f, 1.48092896e-01f, 5.70038185e-02f, -1.26397461e-01f, -9.39151432e-05f, 7.62475207e-02f, 8.89600813e-02f, 2.86030114e-01f, 9.05262604e-02f, -1.16779558e-01f,
  -1.42774284e-01f, 2.37025470e-01f, 1.80924907e-01f, -1.47650018e-01f, -2.56008893e-01f, -4.30830359e-01f, 1.11852132e-03f, -1.29191920e-01f, 5.84960394e-02f, -1.97110340e-01f,
  -3.64117995e-02f, -2.62289315e-01f, -1.80008426e-01f, 1.29994646e-01f, 1.42776102e-01f, 1.34317964e-01f, 1.35236546e-01f, -5.74355945e-02f, -9.81097817e-02f, -3.90255935e-02f,
  1.34141698e-01f, 4.64437939e-02f, -3.65177631e-01f, -1.55143574e-01f, -2.40835529e-02f, -1.07280791e-01f, 2.40698084e-01f, 1.16156191e-02f, -2.53529772e-02f, -1.37582853e-01f,
  -4.21470627e-02f, -4.47416818e-03f, -2.15490729e-01f, -5.24476655e-02f, -3.16491187e-01f, -2.15138286e-01f, 1.43091409e-02f, 4.89634387e-02f, 4.88443971e-01f, 1.93727911e-01f,
  2.98580173e-02f, 1.55440807e-01f, 1.87224314e-01f, 2.19670027e-01f, -1.52225811e-02f, 3.76091339e-02f, -3.91781554e-02f, 2.21776038e-01f, 4.52920943e-02f, -4.78176065e-02f,
  9.63564292e-02f, 4.50878264e-03f, 1.66585118e-01f, 1.36373043e-01f, 1.69741362e-02f, -3.21477741e-01f, -1.22032985e-01f, -2.32303455e-01f, 8.65630656e-02f, -1.44772142e-01f,
  2.39470124e-01f, -1.20162450e-01f, 2.48154089e-01f, 3.45285177e-01f, 1.25228375e-01f, -1.36696860e-01f, 4.83618714e-02f, 1.76373228e-01f, 2.72173464e-01f, -1.51936769e-01f,
  -1.78760424e-01f, 7.68709788e-03f, 1.50516063e-01f, -1.43449187e-01f, -2.59548753e-01f, 5.93264252e-02f, -3.15937493e-03f, 1.92788884e-01f, 1.04070053e-01f, 8.92305449e-02f,
  4.98228855e-02f, -2.06023991e-01f, 1.77737325e-01f, 3.70791703e-02f, 1.46058798e-01f, 1.82985857e-01f, -1.12756900e-01f, -5.85582294e-02f, 1.95035920e-03f, -4.89423648e-02f,
  -6.57954141e-02f, -2.54888296e-01f, -7.19539747e-02f, -1.78420231e-01f, -1.71345755e-01f, 6.73156381e-02f, -2.97535378e-02f, 9.21585560e-02f, 4.85351458e-02f, 2.46438965e-01f,
  -3.01838487e-01f, -1.52143985e-01f, 1.08153753e-01f, 2.22440451e-01f, 1.95443481e-01f, 1.35110483e-01f, 1.05231024e-01f, -2.32975110e-01f, 2.03886241e-01f, 2.16919094e-01f,
  2.77471170e-02f, -1.74706876e-01f, 1.41954899e-01f, 4.47694510e-02f, -6.96261451e-02f, 4.80187200e-02f, 2.40221843e-02f, -7.95930400e-02f, 1.34196624e-01f, 2.09686890e-01f,
  1.93791032e-01f, -1.27918437e-01f, -2.95725197e-01f, 2.30858684e-01f, -1.93385154e-01f, 2.33702987e-01f, 2.96274796e-02f, -1.71061948e-01f, -2.35279232e-01f, 1.86255231e-01f,
  1.23493373e-01f, -9.57918912e-02f, -3.76142412e-02f, -2.64049917e-01f, 1.17896505e-01f, -3.28053683e-01f, -8.08142200e-02f, -2.01058030e-01f, 8.09782892e-02f, -4.73799892e-02f,
  -2.47044533e-01f, 2.40505099e-01f, 2.25019664e-01f, 2.58314312e-01f, -7.25227967e-02f, -1.76142648e-01f, -1.53299384e-02f, -9.21065509e-02f, 1.99782610e-01f, -2.29787990e-01f,
  -8.09170678e-02f, -3.04723442e-01f, 1.28796190e-01f, -8.82269144e-02f, -1.34103045e-01f, -1.33751512e-01f, -4.57670748e-01f, -9.32332054e-02f, -1.36396229e-01f, -8.29189420e-02f,
  -8.13669711e-02f, -1.57268137e-01f, -2.86591053e-01f, -2.31838413e-02f, 7.65998736e-02f, 4.82793748e-02f, 2.90116668e-01f, -2.38727480e-01f, 1.41938135e-01f, 2.02328905e-01f,
  -1.31186455e-01f, 2.16271490e-01f, 9.00212675e-02f, 2.23475263e-01f, 1.76527381e-01f, 3.08861047e-01f, -6.41636923e-02f, -6.67821094e-02f, -6.46253601e-02f, 1.82623178e-01f,
  -2.70197004e-01f, 8.44020993e-02f, 7.40794316e-02f, -1.52069092e-01f, 3.39428522e-02f, 1.35213822e-01f, 1.28938213e-01f, -1.36406973e-01f, 2.18381718e-01f, 4.46487181e-02f,
  8.41173083e-02f, -2.99045324e-01f, 3.33137304e-01f, -6.87510753e-03f, -1.97767228e-01f, -2.82735258e-01f, 1.58107996e-01f, -2.67921299e-01f, -2.35580593e-01f, -6.24498576e-02f,
  2.35760152e-01f, -2.34655030e-02f, 5.21762371e-02f, 2.53033578e-01f, 2.06932947e-01f, -1.29038617e-01f, -1.58636540e-01f, 2.05478638e-01f, -1.23759411e-01f, -1.13995507e-01f,
  4.39398848e-02f, 2.17283070e-02f, -1.76191315e-01f, 7.89292678e-02f, -1.26634568e-01f, 1.23154528e-01f, 5.78574315e-02f, 3.78472246e-02f, -1.22212358e-01f, 1.17908031e-01f,
  4.38721143e-02f, -1.84759742e-03f, -1.66897789e-01f, 2.07904845e-01f, -1.26487151e-01f, -8.09828844e-03f, -9.88249257e-02f, -1.38603613e-01f, -1.65269405e-01f, 8.41933787e-02f,
  -7.46755749e-02f, 2.08401695e-01f, -1.73989996e-01f, -1.95096880e-01f, -2.30339728e-03f, -8.95989165e-02f, -1.24429636e-01f, 1.23995259e-01f, -2.00819448e-01f, 4.08336520e-02f,
  3.26085418e-01f, 1.92713112e-01f, 2.79116809e-01f, 2.01520979e-01f, 3.01123261e-01f, 6.61178157e-02f, -1.53415412e-01f, 7.37720728e-02f, -6.41681850e-02f, -1.42326236e-01f,
  1.84416011e-01f, -5.86089194e-01f, -5.85071854e-02f, -2.11690754e-01f, -1.19474828e-01f, 7.36068562e-02f, 8.72315280e-03f, 1.74068119e-02f, -1.05923772e-01f, 2.61794478e-01f,
  3.56898397e-01f, 1.68054163e-01f, -1.04159549e-01f, 1.55171335e-01f, -8.10375139e-02f, 1.14961177e-01f, -2.25208074e-01f, -8.94914269e-02f, -3.24825197e-02f, 1.83692724e-01f,
  6.72495589e-02f, 1.06811836e-01f, 1.62443146e-01f, -2.34908774e-01f, 1.90053076e-01f, -1.21327356e-01f, 1.47134185e-01f, 8.56551901e-02f, 3.23862992e-02f, 7.85884447e-03f,
  -2.45195940e-01f, -1.36320561e-01f, 5.32560013e-02f, -1.08103231e-02f, 2.33556584e-01f, -1.93586618e-01f, -7.03423992e-02f, -2.13423744e-01f, 7.01127900e-03f, 6.70153201e-02f,
  -3.21268104e-02f, 3.41717660e-01f, 3.20667471e-03f, -2.35648993e-02f, 1.64843559e-01f, -1.08077645e-01f, 2.40507394e-01f, 1.41811803e-01f, -2.14879285e-03f, -1.48104166e-03f,
  -4.03136909e-02f, 1.73456535e-01f, 6.77669570e-02f, -2.27991492e-01f, 1.26443297e-01f, 5.23021743e-02f, 9.35228541e-02f, 1.67188764e-01f, 3.67922485e-01f, 2.78556377e-01f,
  4.24383916e-02f, -8.06753933e-02f, -4.19334844e-02f, 1.75951913e-01f, 2.14476749e-01f, -1.88687548e-01f, 1.23268574e-01f, 7.46134203e-03f, 1.57806858e-01f, 1.99586645e-01f,
  -5.09924032e-02f, 2.86773425e-02f, -2.69928157e-01f, -2.16588423e-01f, -1.10549323e-01f, -8.37837756e-02f, -2.99703419e-01f, 8.99462402e-02f, 6.10738397e-02f, -2.47952947e-03f,
  -2.17242032e-01f, -9.30106267e-02f, -1.70311645e-01f, 2.84092855e-02f, -4.78479378e-02f, -3.26691046e-02f, 1.13985665e-01f, -2.77076028e-02f, 2.01797783e-01f, 1.58501621e-02f,
  8.21443796e-02f, 9.28203762e-02f, -3.61514054e-02f, -2.47812681e-02f, 1.50745332e-01f, 2.12810844e-01f, 2.10411683e-01f, -6.07877895e-02f, 1.03592582e-01f, 7.57903978e-02f,
  2.86596343e-02f, 2.48987660e-01f, -7.95370489e-02f, 8.68542120e-02f, -1.76434800e-01f, -1.38402939e-01f, -3.30120176e-02f, 2.30132163e-01f, -1.16770774e-01f, -7.00139329e-02f,
  1.14016809e-01f, -1.75677866e-01f, 6.29241914e-02f, -1.76597476e-01f, 4.54093292e-02f, -7.14081619e-03f, 2.85341144e-02f, 2.17707619e-01f, 2.22948976e-02f, 2.25478023e-01f,
  2.32377812e-01f, 1.79715246e-01f, 8.25148001e-02f, 1.03446811e-01f, 8.86343345e-02f, 2.01845374e-02f, -1.36686683e-01f, 1.18403487e-01f, 4.34349813e-02f, 5.99278323e-02f,
  3.44370343e-02f, 7.28521645e-02f, -2.67524153e-01f, -3.66159856e-01f, 1.81695935e-03f, -5.12913615e-02f, -8.60003289e-04f, 1.86105967e-01f, -1.05144054e-01f, 1.96893886e-01f,
  -9.05855820e-02f, 1.09472916e-01f, -2.88261026e-01f, -1.14324717e-02f, 1.32436708e-01f, 1.79649428e-01f, 2.17452988e-01f, -2.84855098e-01f, -1.31922260e-01f, -2.36254141e-01f,
  1.14686042e-02f, 2.00763002e-01f, -1.36229843e-01f, 8.21194872e-02f, 3.37920412e-02f, -1.16527759e-01f, 1.39561966e-01f, 1.97930828e-01f, -2.32046634e-01f, -5.70866056e-02f,
  -4.36013229e-02f, 2.36511514e-01f, -7.64986128e-03f, -3.71659873e-03f, 2.07135946e-01f, 5.78707755e-02f, 7.91187659e-02f, -1.41999703e-02f, 7.99040645e-02f, 5.11217751e-02f,
  2.24488527e-02f, 2.98337955e-02f, 9.63239819e-02f, 2.25445032e-02f, 6.78926185e-02f, -1.35516718e-01f, -1.93308905e-01f, 1.37484491e-01f, 6.05972074e-02f, -1.57102868e-01f,
  8.84333625e-02f, -3.65366101e-01f, 1.22733980e-01f, 9.92510989e-02f, 3.26636225e-01f, 1.64171800e-01f, 2.40107551e-01f, 2.34769464e-01f, -2.01113760e-01f, 3.17566305e-01f,
  -2.42750227e-01f, 2.92797387e-01f, -3.86736318e-02f, -3.40372294e-01f, 2.47948617e-02f, -2.83968627e-01f, -3.28614205e-01f, -2.68306613e-01f, -1.47533610e-01f, -1.46257967e-01f,
  -1.35970995e-01f, 2.41658203e-02f, -4.94480170e-02f, 3.22834164e-01f, 1.34634659e-01f, 3.60617548e-01f, -1.86237946e-01f, 1.60680190e-01f, -6.31717741e-02f, -1.06198438e-01f,
  2.93597370e-01f, -2.93330438e-02f, -2.69183684e-02f, -9.07845795e-02f, 7.32470304e-02f, -2.76402056e-01f, -1.46368831e-01f, 6.18223622e-02f, 1.21757127e-01f, 5.10049313e-02f,
  9.20120850e-02f, 1.61313981e-01f, -3.11611056e-01f, -9.12304819e-02f, 2.76618451e-01f, 3.06085885e-01f, 1.01776086e-01f, -3.37791920e-01f, -1.09230466e-01f, 5.51161170e-02f,
  -2.90684044e-01f, -1.49582192e-01f, -2.38099158e-01f, 5.87598830e-02f, 3.39578465e-02f, 1.08230352e-01f, 5.26465401e-02f, -2.41320014e-01f, 2.07626037e-02f, -2.72881478e-01f,
  2.93694232e-02f, 2.01578364e-01f, 1.73002370e-02f, -2.00767606e-01f, -1.25110652e-02f, -1.20485157e-01f, 2.30521187e-01f, 1.89923450e-01f, 2.93693036e-01f, 2.19103336e-01f,
  3.28409910e-01f, 2.43524984e-01f, -1.20386228e-01f, -3.24258864e-01f, -2.22267479e-01f, 2.20541179e-01f, 9.04409587e-02f, -2.76388414e-03f, 1.24599516e-01f, -3.25928658e-01f,
  -1.54735029e-01f, 4.72452551e-01f, -1.44441336e-01f, 4.72838001e-04f, -2.80717641e-01f, -2.13741615e-01f, -2.74454683e-01f, 5.13556480e-01f, -1.75708488e-01f, 6.71290234e-02f,
  -1.78403661e-01f, -6.78186193e-02f, 1.34059429e-01f, 1.59357004e-02f, 2.09954325e-02f, 1.35023013e-01f, 2.38904446e-01f, 2.41496563e-02f, -8.54420513e-02f, 4.16647606e-02f,
  2.58318096e-01f, 1.21383160e-01f, 1.38896722e-02f, -4.62111980e-02f, 2.80721765e-02f, -1.23307958e-01f, 1.54723629e-01f, 3.99883650e-02f, 2.48906776e-01f, 1.50893748e-01f,
  -6.38544038e-02f, 2.82062292e-02f, 1.23902209e-01f, 2.36363679e-01f, -1.04402386e-01f, -1.90642148e-01f, -2.29164567e-02f, 8.55329167e-03f, -6.99416250e-02f, 1.65686637e-01f,
  -2.55681928e-02f, 3.05719450e-02f, 1.87880695e-01f, 4.55695093e-02f, 9.32944864e-02f, -2.56191730e-01f, 2.49856830e-01f, 9.46243107e-03f, 1.50415108e-01f, 3.14663313e-02f,
  2.51239330e-01f, 2.82165796e-01f, 2.83061683e-01f, 1.01427585e-02f, 9.65116769e-02f, 2.83256501e-01f, -1.13659203e-01f, -1.37372449e-01f, -2.63484567e-01f, 2.60320395e-01f,
  2.47502580e-01f, -5.79324439e-02f, -2.78523676e-02f, 1.61316976e-01f, -8.71032253e-02f, 3.94968763e-02f, 1.32720798e-01f, -3.13628882e-01f, -3.84097211e-02f, -1.03760466e-01f,
  5.45795001e-02f, 7.57293403e-02f, -1.68364327e-02f, 2.95075197e-02f, -3.93298417e-02f, 9.07600597e-02f, 1.64245024e-01f, 4.36757565e-01f, 3.18786263e-01f, -1.51382968e-01f,
  -3.91242020e-02f, -2.01419830e-01f, -3.45817208e-01f, -1.13173686e-01f, -4.19661701e-02f, 1.14877492e-01f, 2.46049371e-02f, -1.29810736e-01f, -3.35652418e-02f, 2.38861814e-01f,
  -1.17525220e-01f, -1.97709724e-01f, -2.04871371e-01f, 5.45432419e-02f, 2.37901285e-01f, -3.20768021e-02f, 1.53457254e-01f, 6.79262280e-02f, 5.67851104e-02f, 4.18482088e-02f,
  3.06572318e-01f, 5.26882559e-02f, -8.75675082e-02f, 1.39668033e-01f, -2.25443110e-01f, 1.32318586e-01f, 1.90583721e-01f, -2.78098267e-02f, -1.98953375e-01f, -5.98308183e-02f,
  2.13088378e-01f, 1.48386091e-01f, 1.34901181e-01f, -3.08925003e-01f, 9.37192813e-02f, -9.58466306e-02f, -1.16157465e-01f, -6.62838519e-02f, 1.00060981e-02f, -3.44917811e-02f,
  7.97242373e-02f, -6.11541308e-02f, 1.39812484e-01f, 1.85300246e-01f, -1.76018804e-01f, 7.45902807e-02f, -2.69943684e-01f, -2.79069155e-01f, -4.10332084e-01f, 2.91922450e-01f,
  -1.13696925e-01f, 2.31728852e-01f, -1.26866832e-01f, -1.35683417e-01f, -3.80143106e-01f, -1.53245181e-02f, 1.83055133e-01f, -1.26435891e-01f, -1.70988932e-01f, -6.00718558e-02f,
  4.15962748e-02f, -1.67755544e-01f, -3.00003946e-01f, 3.84057574e-02f, 3.00073892e-01f, -4.49109137e-01f, -2.14446858e-01f, 4.95057506e-03f, -4.51475158e-02f, 4.73987758e-02f,
  8.26854855e-02f, -7.37171322e-02f, -1.49437293e-01f, 1.24517148e-02f, 2.20258042e-01f, -1.32918254e-01f, -2.33371362e-01f, 5.31862192e-02f, -2.38236040e-01f, 1.42104998e-01f,
  -8.08419064e-02f, 1.19136930e-01f, -1.63812310e-01f, 3.82880569e-02f, -1.22452475e-01f, -1.51536897e-01f, 1.49685085e-01f, -3.00520053e-03f, -3.26900929e-01f, -4.03936833e-01f,
  -8.65844339e-02f, -1.70826226e-01f, -2.42210865e-01f, -1.45289183e-01f, 1.87757328e-01f, 9.73782465e-02f, 1.33997276e-01f, 3.25507432e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.13084623e-01f, 2.23990604e-02f, -2.22402625e-02f, 1.79073095e-01f, -1.07308850e-01f, 1.38229936e-01f, -4.34107743e-02f, 2.11526558e-01f, 9.75749642e-02f, 3.42989683e-01f,
  2.31746659e-01f, 5.25073782e-02f, 2.74400651e-01f, 6.20742678e-04f, 1.12155177e-01f, 2.55317926e-01f, 1.89580787e-02f, 1.83187887e-01f, 4.58197482e-02f, 7.48651847e-02f,
  1.23390958e-01f, 7.52183720e-02f, 1.32594362e-01f, 4.15636450e-02f, 1.76925689e-01f, 1.07865721e-01f, 1.52540192e-01f, 1.27165273e-01f, 8.77592620e-03f, -3.71897817e-02f,
  1.90098941e-01f, 1.02168538e-01f, 1.72608331e-01f, 7.48815686e-02f, 1.13350563e-01f, -4.66469824e-02f, 1.62649587e-01f, 3.46548587e-01f, -1.98825181e-01f, 1.09370016e-01f,
  1.31910920e-01f, 1.90553397e-01f, 1.01546355e-01f, 2.30647206e-01f, 1.37502536e-01f, 3.16846877e-01f, 1.08236894e-01f, 7.55218342e-02f, 1.72888875e-01f, 2.94354707e-01f,
  2.92740077e-01f, -4.33486179e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.23172179e-01f, 1.52793631e-01f, -9.41143464e-03f, 9.46281329e-02f, -7.14544803e-02f, 2.29633730e-02f, -1.34626210e-01f, -2.34691456e-01f, 1.16094751e-02f, -3.69629189e-02f,
  2.05919278e-04f, 4.42593917e-02f, 9.82522890e-02f, 1.30174950e-01f, -8.08151066e-02f, 7.97607526e-02f, -7.18022957e-02f, -8.76725465e-02f, -5.05273938e-02f, 4.43915688e-02f,
  -6.63640648e-02f, -9.68004465e-02f, 1.23524994e-01f, -1.09619603e-01f, 1.20615065e-01f, -1.02417827e-01f, 9.76236314e-02f, 1.55985638e-01f, 2.00588271e-01f, -2.46825106e-02f,
  -5.58611266e-02f, -9.17901695e-02f, 1.91015959e-01f, 1.18665650e-01f, -4.32323441e-02f, 3.21676880e-02f, -8.58274773e-02f, 7.29720816e-02f, 5.83216585e-02f, -2.11948566e-02f,
  3.44991311e-02f, -9.37869325e-02f, -1.55588314e-01f, -2.91038640e-02f, -2.40549892e-02f, -1.36569619e-01f, -3.03021725e-02f, -9.98066855e-04f, 2.13128794e-03f, 2.44177163e-01f,
  -1.05009072e-01f, 5.22317067e-02f, -1.07483245e-01f, -1.06277257e-01f, 1.97313786e-01f, -2.82354886e-04f, 2.82695554e-02f, 1.19702816e-01f, -3.43695022e-02f, -3.78818847e-02f,
  3.22587341e-02f, -1.25296727e-01f, 1.41436726e-01f, -6.96611628e-02f, 5.68697751e-02f, 1.04998685e-01f, -1.43771619e-01f, 8.90914723e-02f, 9.12167206e-02f, 1.05194047e-01f,
  2.64608294e-01f, -3.37822502e-03f, -9.52925682e-02f, 1.16732411e-01f, 9.91100520e-02f, -2.45276973e-01f, 7.38918409e-02f, -3.59559990e-03f, -5.18960617e-02f, -5.46809472e-02f,
  1.38814012e-02f, 8.08307081e-02f, -9.17025208e-02f, -2.71403551e-01f, -1.65077746e-01f, 7.43169412e-02f, 9.42170396e-02f, -8.71057063e-02f, 1.60386473e-01f, 1.23435840e-01f,
  1.57479271e-01f, -5.83723150e-02f, -1.95885450e-02f, 1.22981228e-01f, -1.80690259e-01f, -5.73452376e-02f, 6.91769347e-02f, 1.93153210e-02f, 2.37808973e-01f, -1.49636701e-01f,
  -8.01353157e-02f, 1.46882841e-02f, -2.45861150e-02f, 4.01374809e-02f, 3.47680449e-02f, 3.99856046e-02f, 5.62448278e-02f, 4.31643985e-02f, 2.77388003e-02f, -4.78582345e-02f,
  -2.22673733e-02f, -8.89119431e-02f, 9.75839421e-02f, 7.02940077e-02f, -1.84216231e-01f, 5.59391417e-02f, -1.20718647e-02f, 1.09381296e-01f, 3.31748426e-02f, -7.24503323e-02f,
  -4.86413687e-02f, -3.43592539e-02f, 7.49352276e-02f, -1.89927474e-01f, 3.56008150e-02f, -1.07984722e-01f, -9.24104378e-02f, -1.56208560e-01f, -5.35967015e-02f, 4.11400432e-03f,
  -7.67706409e-02f, -2.57733893e-02f, 9.18182358e-03f, 1.38068050e-01f, 1.02998003e-01f, -5.36204353e-02f, 2.51039833e-01f, 1.89099405e-02f, -2.25871935e-01f, 1.61674455e-01f,
  -1.58451781e-01f, 7.77650550e-02f, -2.17673838e-01f, 5.74590899e-02f, -2.79241912e-02f, -1.47029400e-01f, 2.33396254e-02f, -1.56309009e-01f, -3.69176045e-02f, -2.12013692e-01f,
  4.13759723e-02f, -1.18063129e-01f, -1.43827602e-01f, -2.16358662e-01f, -7.37076700e-02f, 3.62691581e-02f, -2.87498310e-02f, -1.75462916e-01f, -2.01628581e-01f, -1.25593439e-01f,
  -1.95013866e-01f, 1.14389174e-01f, -7.95187652e-02f, 1.03653982e-01f, -1.80549964e-01f, 1.26029298e-01f, -1.45785406e-01f, -3.73353139e-02f, 1.82649329e-01f, -7.31134117e-02f,
  9.95097309e-02f, 1.80526197e-01f, 3.41355707e-03f, -1.80040061e-01f, -2.11968526e-01f, 1.38445660e-01f, -1.94974765e-02f, -1.89338848e-01f, 2.77168048e-03f, 1.82526901e-01f,
  1.10970072e-01f, 1.01655506e-01f, 1.70130551e-01f, -1.79360107e-01f, 7.65348896e-02f, 7.13004470e-02f, 6.92739561e-02f, -1.72878698e-01f, -3.42346877e-02f, 1.27781145e-02f,
  1.84702184e-02f, 7.94456825e-02f, -4.71664518e-02f, -2.97424495e-02f, 5.24119139e-02f, 5.28985932e-02f, 6.21303059e-02f, -4.98693623e-02f, 8.30327161e-03f, 1.05061278e-01f,
  8.38135779e-02f, -2.50001960e-02f, 1.36677101e-01f, -1.61647364e-01f, 1.15595959e-01f, 1.45709530e-01f, -1.75073855e-02f, -2.23664477e-01f, 2.66776979e-02f, -1.59466982e-01f,
  4.67846803e-02f, -1.33481920e-01f, 1.14459889e-02f, -9.28626209e-02f, 7.33912066e-02f, -1.68863889e-02f, 1.70680672e-01f, 8.84123519e-02f, -1.05925605e-01f, 4.99482825e-02f,
  1.92069009e-01f, 4.92661968e-02f, -1.04914702e-01f, 1.21987812e-01f, 2.58268835e-03f, 8.85278210e-02f, 5.90358041e-02f, 1.98322803e-01f, 1.43104509e-01f, -6.87104762e-02f,
  -2.25856379e-01f, -1.89204037e-01f, -9.13312063e-02f, 6.21928200e-02f, 7.71797970e-02f, 3.89263742e-02f, 1.73111886e-01f, -1.35155246e-01f, -8.67933631e-02f, -2.87281275e-02f,
  -3.89488563e-02f, -1.87510163e-01f, 8.84579644e-02f, 2.62441467e-02f, 1.07449323e-01f, 6.65658638e-02f, 1.36536390e-01f, -5.94106875e-03f, 7.79635236e-02f, -3.40447873e-02f,
  -2.24375855e-02f, -1.81288064e-01f, -1.37244716e-01f, -3.46536636e-02f, -2.49860033e-01f, 6.28937036e-02f, 2.64535546e-02f, 2.25126613e-02f, 3.67771000e-01f, 1.90745994e-01f,
  1.88897513e-02f, 1.80035949e-01f, -2.03889180e-02f, -7.36684427e-02f, -5.08293211e-02f, -1.17211901e-01f, -2.98910346e-02f, 1.46314546e-01f, -1.69374600e-01f, -5.54809235e-02f,
  -4.56164405e-02f, -4.33607966e-01f, -1.72209322e-01f, 1.33606300e-01f, 4.46087457e-02f, 8.49824250e-02f, 6.26203120e-02f, 1.98983192e-01f, 3.90456952e-02f, 9.38338339e-02f,
  -1.33748442e-01f, -1.58571064e-01f, -1.03993610e-01f, 8.17046314e-02f, 3.51068713e-02f, 4.24789339e-02f, 1.85800835e-01f, -4.62306961e-02f, 2.31698975e-02f, 1.17048092e-01f,
  -1.39097124e-01f, -1.85744502e-02f, 3.69393155e-02f, -4.50057648e-02f, 7.24858195e-02f, 1.75810993e-01f, -9.06421244e-02f, -1.15210228e-01f, 6.09703064e-02f, 1.04379110e-01f,
  6.36648834e-02f, 3.95602845e-02f, 1.31778359e-01f, -1.31058455e-01f, 1.04244530e-01f, -1.78289011e-01f, -3.68591510e-02f, 1.50143266e-01f, -6.78278133e-02f, 6.21342584e-02f,
  4.97492887e-02f, -6.65697306e-02f, 1.64831057e-01f, -6.84786662e-02f, 1.55244455e-01f, 6.17427006e-02f, -1.55391127e-01f, -4.19709310e-02f, 1.67974919e-01f, -3.01365759e-02f,
  7.17722997e-02f, 6.75286865e-04f, -1.39426231e-01f, 1.97869092e-02f, -3.78956981e-02f, -5.37389554e-02f, -2.20700264e-01f, -2.11194605e-02f, 1.95544466e-01f, 1.42261818e-01f,
  -2.27826163e-01f, 2.49975231e-02f, -2.23310124e-02f, 1.19913667e-01f, 1.95780784e-01f, 1.99500665e-01f, -1.21993676e-01f, -4.68948260e-02f, 2.00281784e-01f, -1.03181683e-01f,
  -4.47100550e-02f, -2.15810724e-02f, -1.55583862e-02f, -1.00871824e-01f, 2.24106871e-02f, -1.58617139e-01f, -9.38782915e-02f, -4.57232594e-02f, 1.31078690e-01f, -1.33016348e-01f,
  -7.94040563e-04f, -4.31468301e-02f, -8.28143731e-02f, -1.94288552e-01f, -1.09495811e-01f, 1.73506781e-01f, 4.53336686e-02f, -2.34592214e-01f, -4.94866595e-02f, -1.46985084e-01f,
  -9.54123139e-02f, -7.83872455e-02f, -1.99718997e-01f, -3.83675098e-02f, 1.71498910e-01f, 3.55983153e-02f, 2.16175038e-02f, 9.32854787e-02f, -4.69407700e-02f, -1.15661740e-01f,
  -4.83916141e-02f, -1.77886590e-01f, -1.53562352e-01f, -3.25984843e-02f, -7.46809021e-02f, 1.17828503e-01f, 6.38416260e-02f, -8.71759057e-02f, -1.20692842e-01f, 4.56695408e-02f,
  1.14120610e-01f, -2.09572807e-01f, 3.34624201e-03f, 1.20136105e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -7.83047527e-02f, -2.43202314e-01f, 1.53893948e-01f, 3.54352742e-02f, -2.13305414e-01f, 6.05863193e-03f, -1.45261019e-01f, -2.67936319e-01f, 8.75699297e-02f, -2.27714819e-03f,
  -6.84587751e-03f, 3.11502665e-01f, -2.79886723e-01f, 2.05391631e-01f, 8.37181360e-02f, -2.67177612e-01f, -1.63487390e-01f, -1.40462071e-02f, -4.30832841e-02f, -1.03745423e-01f,
  -1.39675349e-01f, 1.90138549e-01f, 5.01027443e-02f, -2.77858712e-02f, 1.75800636e-01f, 4.35453132e-02f, 9.98244882e-02f, -1.13897890e-01f, -1.72825798e-01f, -2.76076347e-01f,
  2.35120907e-01f, 2.58571714e-01f, 2.08460197e-01f, 1.32820055e-01f, -2.89372176e-01f, 2.06489742e-01f, -8.74106735e-02f, 3.21558653e-03f, 1.83173567e-01f, 1.36381462e-01f,
  -3.76499034e-02f, 2.01985314e-01f, 2.58666463e-02f, 3.02749276e-01f, 7.84162059e-02f, 1.31754711e-01f, 1.03604205e-01f, -3.05990994e-01f, 2.82207757e-01f, 7.22313579e-03f,
  1.51788294e-01f, -1.35487062e-03f, 1.06966645e-01f, -2.07798388e-02f, 2.27328360e-01f, -9.90649313e-02f, 2.67199636e-01f, -6.99783713e-02f, 1.04541130e-01f, 1.46820351e-01f,
  8.56745290e-04f, -1.03186108e-01f, 6.58121184e-02f, -5.17324451e-03f, 5.81639297e-02f, 3.34876147e-03f, -1.39149548e-02f, 1.44357597e-02f, -3.78688537e-02f, -1.63938075e-01f,
  -7.78461918e-02f, -2.33065382e-01f, 1.84188545e-01f, 9.67881158e-02f, 9.82606709e-02f, 1.34143919e-01f, 1.73608318e-01f, 3.43492389e-01f, 3.19437906e-02f, 3.26271832e-01f,
  9.17134061e-02f, -4.36298490e-01f, -1.68529451e-02f, -5.23321070e-02f, 5.20922467e-02f, -2.43769631e-01f, 1.81132704e-01f, 1.53206110e-01f, 2.30376899e-01f, 4.60303240e-02f,
  -4.29949537e-02f, 1.18813641e-01f, -1.64624229e-02f, -1.54580355e-01f, -2.41066933e-01f, -1.03612185e-01f, -1.19457297e-01f, 1.01550348e-01f, 5.13286106e-02f, 2.86199659e-01f,
  -1.54958693e-02f, -1.34642184e-01f, 1.91073325e-02f, -1.04222097e-01f, 2.37565368e-01f, 1.60680786e-01f, -2.83117712e-01f, -1.74082350e-02f, 3.30765471e-02f, 1.62646353e-01f,
  7.45720416e-02f, 4.91858333e-01f, 1.13253206e-01f, 1.62940398e-01f, 3.59970261e-03f, -3.59882027e-01f, 2.27488965e-01f, 7.15025663e-02f, 3.88127491e-02f, 9.21436250e-02f,
  -9.63219330e-02f, 1.06528834e-01f, -1.93568543e-02f, -5.46304099e-02f, 6.46716449e-03f, -3.65720510e-01f, -8.42335299e-02f, -1.77737057e-01f, 1.17463514e-01f, -2.43567843e-02f,
  7.94808473e-03f, 9.25263241e-02f, -8.01408216e-02f, -4.81119826e-02f, -1.73284709e-02f, -3.64467114e-01f, -1.63815662e-01f, 4.95014489e-02f, -1.98364649e-02f, -1.79833397e-01f,
  -1.22155406e-01f, 1.74756020e-01f, 3.35474908e-01f, 6.58545345e-02f, -9.57850926e-03f, -4.96387519e-02f, 7.05672577e-02f, -7.87899422e-04f, -1.28391623e-01f, 1.35124221e-01f,
  -6.10716455e-02f, -8.54197741e-02f, -7.26861209e-02f, 4.78418529e-01f, -2.62980815e-03f, 3.82675156e-02f, 1.65530115e-01f, -2.18199998e-01f, 2.50652492e-01f, 5.99099286e-02f,
  1.56352162e-01f, -9.17769149e-02f, 3.44234332e-02f, 4.87279296e-02f, 2.46585421e-02f, -1.29919946e-01f, 1.99323475e-01f, 3.37116886e-03f, -1.94876507e-01f, -5.73201627e-02f,
  -3.07260007e-01f, -1.34821489e-01f, 2.98531830e-01f, -5.01657091e-02f, 7.44986385e-02f, -2.94486582e-01f, 6.38067769e-03f, 2.34634757e-01f, -5.60505614e-02f, -4.35100421e-02f,
  1.39279375e-02f, -3.57339442e-01f, 7.66645893e-02f, -3.02077923e-02f, 3.94929759e-02f, 1.28961634e-02f, -6.66994378e-02f, 2.83585370e-01f, 1.67234749e-01f, -1.14664678e-02f,
  8.68335273e-03f, -1.23424232e-01f, -3.01655643e-02f, 1.00469992e-01f, 7.49700740e-02f, 1.02027088e-01f, -3.81939918e-01f, -1.05115294e-01f, -3.07376862e-01f, -4.65973675e-01f,
  8.58012810e-02f, 8.42920691e-02f, 9.50393304e-02f, 1.00569263e-01f, -9.94364843e-02f, -7.01353475e-02f, 1.21908836e-01f, -2.17936542e-02f, 1.01582848e-01f, 1.89355567e-01f,
  -2.37644270e-01f, 8.85216072e-02f, 3.21891308e-02f, 2.12840915e-01f, 2.35123768e-01f, 2.05958173e-01f, 1.88055634e-01f, -9.20075849e-02f, -2.42207393e-01f, -1.68490812e-01f,
  3.41434181e-01f, -6.58990815e-02f, 1.20401710e-01f, 1.06625624e-01f, 1.64019346e-01f, 6.82268441e-02f, -3.59898299e-01f, -2.43770517e-02f, -2.75085159e-02f, -1.71689153e-01f,
  -3.18143182e-02f, 6.78326190e-02f, -1.49481222e-01f, -7.42523894e-02f, 1.89371817e-02f, -1.65881030e-02f, 7.28408992e-02f, 3.46319750e-02f, -6.28078133e-02f, -1.07286483e-01f,
  4.44197021e-02f, 3.79474461e-02f, -1.55410409e-01f, 5.36139719e-02f, 8.00552890e-02f, -1.06304519e-01f, 1.09825479e-02f, 8.01184624e-02f, 2.15785980e-01f, -5.29661812e-02f,
  1.53333340e-02f, -3.75319906e-02f, -1.56857803e-01f, 1.14858098e-01f, 2.52102792e-01f, 2.14988232e-01f, -2.61003937e-04f, -9.72302631e-02f, -4.40075435e-02f, -4.09410782e-02f,
  2.72485793e-01f, 1.42091811e-01f, 3.52132201e-01f, 2.01586843e-01f, 1.85484365e-01f, -3.25675905e-02f, 7.20059052e-02f, 1.33850202e-01f, -8.44059289e-02f, 2.01675802e-01f,
  -4.01777849e-02f, 3.36622357e-01f, -4.76824492e-03f, -2.44194940e-02f, 1.30232841e-01f, -1.47049755e-01f, -3.23790871e-02f, -2.31237635e-01f, -4.75073084e-02f, -6.92309514e-02f,
  2.08675504e-01f, 3.21704405e-03f, 2.30827108e-01f, 1.13745973e-01f, -2.98210144e-01f, -1.41375288e-01f, -1.29698738e-01f, 4.29233313e-02f, -1.71968475e-01f, 2.21075714e-01f,
  2.73401558e-01f, -1.30554840e-01f, -1.77399486e-01f, 8.90439153e-02f, 9.89923775e-02f, 5.98062016e-02f, 2.10401729e-01f, 3.26505937e-02f, -3.09206862e-02f, 1.11880198e-01f,
  1.29755035e-01f, -9.03608575e-02f, -7.67530203e-02f, 5.84929697e-02f, 1.40357837e-01f, 3.76307108e-02f, -2.37337187e-01f, 1.21317640e-01f, 3.80471975e-01f, 1.97318673e-01f,
  1.12271897e-01f, -3.08725446e-01f, -2.99232714e-02f, 4.09475453e-02f, 1.20565422e-01f, 6.19791262e-02f, 7.23075941e-02f, 1.42852351e-01f, -1.63056538e-01f, -3.14074829e-02f,
  7.63067380e-02f, 1.24392740e-01f, 1.60257444e-02f, 1.64296031e-02f, 5.47583662e-02f, 2.30079845e-01f, 1.21543609e-01f, 8.84047970e-02f, 2.62875974e-01f, -1.12779543e-01f,
  -4.59383637e-01f, 8.07576478e-02f, -2.74258763e-01f, 7.15759769e-02f, -1.65223897e-01f, 1.96805418e-01f, -1.83643058e-01f, 5.61715551e-02f, -9.56323445e-02f, -1.85069904e-01f,
  -1.30741671e-01f, -2.64256708e-02f, -1.21770293e-01f, -1.13201462e-01f, 6.12686872e-02f, -5.15986621e-01f, 2.77780265e-01f, 8.20860267e-02f, -2.40842178e-02f, -3.68619651e-01f,
  1.05396621e-02f, 5.99922240e-02f, 1.06477909e-01f, 1.59101840e-02f, 1.55848414e-01f, -1.26562372e-01f, -9.38597694e-02f, 8.71072486e-02f, 7.00775208e-03f, 8.40493515e-02f,
  2.09563419e-01f, -3.62046883e-02f, -5.30061908e-02f, 7.53137693e-02f, -1.20057143e-01f, -6.51178183e-03f, -3.57834429e-01f, 1.96583837e-01f, -1.00596949e-01f, 3.69645238e-01f,
  -1.22487657e-01f, 2.03797907e-01f, -4.16336693e-02f, -6.08407483e-02f, -1.57863840e-01f, -2.91002989e-01f, -2.69343406e-02f, 1.32539481e-01f, 1.37972385e-01f, 5.53692318e-03f,
  4.64517236e-01f, -3.63817364e-02f, 7.59041235e-02f, -3.67452532e-01f, 2.86155820e-01f, 1.23429582e-01f, -1.62824988e-02f, 4.48298864e-02f, 3.41934860e-01f, 5.90070821e-02f,
  4.34463099e-03f, 4.62955534e-01f, -6.75441027e-02f, 9.39904898e-02f, -1.17155656e-01f, -3.27902496e-01f, 2.08111569e-01f, -2.81158596e-01f, -1.89395636e-01f, -1.94148257e-01f,
  -1.21891111e-01f, 1.25657275e-01f, 1.32530391e-01f, 1.71932533e-01f, 1.65747210e-01f, 7.80632123e-02f, -5.32593317e-02f, -8.69734362e-02f, -1.36668831e-01f, -2.72558630e-01f,
  1.34562999e-01f, 2.35852286e-01f, -1.95482254e-01f, 1.68470711e-01f, 1.92543417e-02f, 2.41216585e-01f, 4.12616022e-02f, -1.32657383e-02f, 3.24739993e-01f, 2.24778283e-04f,
  1.45937368e-01f, -1.73341796e-01f, -2.35834755e-02f, 1.19790643e-01f, -2.53229532e-02f, -1.75759107e-01f, 1.57976791e-01f, -1.33544058e-01f, -1.09119430e-01f, -1.30674198e-01f,
  9.52132121e-02f, -1.89037576e-01f, -1.94419593e-01f, 2.61262923e-01f, 2.51465738e-01f, -3.76964390e-01f, -8.48966092e-02f, 1.49778938e-02f, -1.65043518e-01f, 2.12487075e-02f,
  -1.45329803e-01f, -1.37166427e-02f, 1.11203104e-01f, -4.00779173e-02f, 5.36302514e-02f, -1.42049685e-01f, 9.18906853e-02f, 1.06812976e-01f, 3.09848376e-02f, -6.54404312e-02f,
  -7.67762810e-02f, 5.21105109e-03f, 1.50515705e-01f, 1.95402175e-01f, 7.84013644e-02f, 2.84357727e-01f, -2.70030528e-01f, 1.37892947e-01f, -2.29066253e-01f, 2.44998112e-02f,
  8.86688828e-02f, -4.53725755e-02f, 7.66633451e-02f, -5.80876395e-02f, 1.48106083e-01f, -6.56050304e-03f, 6.74291626e-02f, 2.19593152e-01f, -6.55614659e-02f, -8.38804841e-02f,
  1.15713865e-01f, 1.68311149e-01f, 1.16350122e-01f, -6.15205355e-02f, 6.76268637e-02f, 7.18059316e-02f, 5.18158637e-02f, 8.63828957e-02f, -1.17358178e-01f, 5.92098571e-02f,
  4.24388312e-02f, -1.20526165e-01f, 2.90726304e-01f, -1.64894480e-02f, 1.28924474e-01f, 1.46304742e-01f, -1.82319164e-01f, -1.45244986e-01f, -2.38918230e-01f, -1.42939731e-01f,
  2.19030365e-01f, -4.31504957e-02f, 1.46235541e-01f, -2.85471380e-02f, 4.03565839e-02f, -2.67419189e-01f, -5.86890206e-02f, -1.03917375e-01f, 1.30416259e-01f, -1.79050773e-01f,
  7.11041912e-02f, -1.81186140e-01f, 8.51641744e-02f, -1.39912799e-01f, 3.16156191e-03f, -3.95840146e-02f, 8.61547142e-02f, -2.34181061e-02f, 2.69625247e-01f, 2.43722215e-01f,
  -7.34786317e-02f, 2.91635901e-01f, 5.18009849e-02f, -3.45201977e-02f, 2.19174977e-02f, -2.68655289e-02f, -3.14196199e-02f, -2.86767632e-02f, -1.74261183e-01f, 1.17399104e-01f,
  -3.19390029e-01f, 9.07364041e-02f, 1.53166294e-01f, -1.85950637e-01f, 2.91207552e-01f, 2.54322112e-01f, 1.58131480e-01f, 2.01985389e-01f, -9.15369242e-02f, -1.05945028e-01f,
  1.44383326e-01f, 1.36607841e-01f, 1.37845427e-01f, 9.23219547e-02f, 1.62250791e-02f, 1.29254326e-01f, -3.59096825e-02f, 1.00293532e-02f, -1.38136357e-01f, 1.02594949e-01f,
  -5.07229976e-02f, 8.17965418e-02f, 5.31461500e-02f, -4.16575700e-01f, -3.67950387e-02f, -1.94769546e-01f, 1.72460273e-01f, -4.91823703e-02f, 6.83861822e-02f, -2.52585709e-01f,
  1.70279443e-01f, -2.45204553e-01f, 1.14812823e-02f, -7.71249756e-02f, -3.29520851e-02f, -4.51296717e-02f, 2.70859282e-02f, -6.33070990e-02f, 1.75521642e-01f, 1.68808684e-01f,
  -2.67931104e-01f, 6.83219805e-02f, -2.07394883e-01f, -2.42876247e-01f, 2.68261619e-02f, 1.91536933e-01f, -4.18218374e-02f, 1.10566996e-01f, -3.39951605e-01f, -5.19186035e-02f,
  -1.33480772e-01f, -5.58439083e-02f, -2.94008404e-01f, -2.97272593e-01f, -8.05341378e-02f, -4.85513778e-03f, -6.32219911e-02f, 1.11561073e-02f, -1.11370115e-02f, -4.50052693e-02f,
  1.23562172e-01f, 4.15522978e-02f, -1.55729443e-01f, 1.76447466e-01f, 7.56720034e-03f, 2.33251508e-02f, -1.42267093e-01f, 6.26894981e-02f, -8.44919831e-02f, 1.64128035e-01f,
  -8.95806924e-02f, 2.42630504e-02f, -3.04276705e-01f, 2.45465904e-01f, -2.32193872e-01f, 1.96077347e-01f, 1.35477170e-01f, 1.17918670e-01f, 3.76201242e-01f, -6.72949478e-02f,
  1.22325808e-01f, -1.17208093e-01f, 1.02448069e-01f, -2.25259408e-01f, 1.10380836e-01f, 3.56501937e-02f, -2.39883333e-01f, -2.29700059e-02f, -1.76205501e-01f, 1.81344837e-01f,
  8.85885060e-02f, 1.72733277e-01f, 4.68397737e-02f, 3.12108159e-01f, -1.86586037e-01f, 8.04632306e-02f, 2.45432723e-02f, 9.63965580e-02f, 2.85897404e-01f, 1.92372426e-01f,
  -1.74357027e-01f, 2.80604213e-01f, 1.07156450e-03f, -1.93762839e-01f, 3.09721559e-01f, -3.40104818e-01f, -1.94727834e-02f, 1.90351978e-01f, 1.93991169e-01f, 3.06278970e-02f,
  2.47143805e-01f, -1.58376977e-01f, 7.42631208e-04f, 1.46966636e-01f, 2.87524611e-01f, -2.40283459e-01f, -2.21830979e-01f, 3.68507296e-01f, 3.95746268e-02f, 1.09012708e-01f,
  1.39781281e-01f, 1.12043433e-01f, -4.97245565e-02f, -1.54933184e-01f, 6.11837097e-02f, -2.03396305e-02f, -1.36847466e-01f, 1.01821870e-01f, 1.41784728e-01f, -9.44250152e-02f,
  1.52391821e-01f, 8.18253830e-02f, 1.61291406e-01f, 9.58857760e-02f, -1.11090161e-01f, -3.74903262e-01f, -2.31089052e-02f, 1.98663846e-01f, -2.04483286e-01f, 1.74376622e-01f,
  3.22950035e-01f, 1.17126897e-01f, 3.23555246e-02f, -4.33767661e-02f, 2.25723863e-01f, 1.57164391e-02f, -3.78347770e-03f, 1.48725599e-01f, 1.36908844e-01f, 2.90667862e-01f,
  -1.19473070e-01f, 1.36676639e-01f, -1.46663919e-01f, 2.36442715e-01f, -1.01212859e-01f, 3.39985192e-02f, -8.59838426e-02f, 4.97789681e-02f, -9.61322710e-02f, -8.09743349e-03f,
  1.62263185e-01f, 2.50983238e-01f, 2.71777719e-01f, 3.78010087e-02f, 9.90950316e-03f, -1.47691891e-01f, 1.13421567e-01f, -1.68643922e-01f, 2.05581844e-01f, -2.97431082e-01f,
  -3.19721960e-02f, 1.37590080e-01f, 1.73976585e-01f, 1.86507285e-01f, 2.20570490e-01f, 7.59732574e-02f, 1.13320239e-01f, -2.10380912e-01f, 2.09787250e-01f, -2.40355462e-01f,
  -3.02081257e-01f, 3.47913355e-02f, -8.04937854e-02f, -1.36322165e-02f, 1.52661204e-01f, 1.16049096e-01f, -3.10139190e-02f, 1.93389237e-01f, -4.95441519e-02f, -1.38321351e-02f,
  -5.04086167e-03f, -1.71053559e-01f, -2.35544164e-02f, 4.23580781e-02f, 2.72192508e-01f, -1.22573160e-01f, 2.39438027e-01f, 9.20707360e-02f, -4.27811742e-02f, 3.00071031e-01f,
  3.86029124e-01f, -6.76412955e-02f, -2.21271310e-02f, 1.05179064e-01f, 1.10797949e-01f, 1.04978576e-01f, 1.44364133e-01f, 1.03641942e-01f, -4.16006111e-02f, 2.08061650e-01f,
  -3.01607996e-02f, 2.62995541e-01f, 2.37010017e-01f, 3.11437219e-01f, -2.25095525e-01f, -9.29517299e-02f, -1.69552922e-01f, -1.71848342e-01f, -1.01745492e-02f, 4.07202244e-02f,
  8.34574625e-02f, -1.79910415e-03f, 6.48149624e-02f, -1.86068013e-01f, 1.49618700e-01f, -2.08560467e-01f, 1.47621185e-01f, -8.88409764e-02f, 1.34767488e-01f, -2.49762937e-01f,
  -1.05334625e-01f, 9.86708179e-02f, -9.29287970e-02f, -1.65143475e-01f, -1.83089092e-01f, 3.03142041e-01f, 6.37977347e-02f, -7.20121413e-02f, -2.82972138e-02f, 3.23727965e-01f,
  -1.12745255e-01f, 9.23847407e-02f, -2.16706153e-02f, 4.48473319e-02f, 3.42905298e-02f, 3.62985954e-02f, -1.59795493e-01f, 2.27734163e-01f, 1.27812460e-01f, 1.08034894e-01f,
  -1.10572666e-01f, 2.63831317e-01f, 1.26332730e-01f, 2.96709985e-02f, -2.08726525e-01f, -2.29755640e-01f, -1.18326910e-01f, -3.06078512e-02f, 2.78930783e-01f, -5.97770624e-02f,
  1.44620791e-01f, -3.15647088e-02f, 6.55381009e-02f, 3.76307726e-01f, 1.24106660e-01f, 2.79210180e-01f, -8.50510672e-02f, 1.52032822e-01f, 8.25331022e-04f, 1.58292517e-01f,
  5.82291223e-02f, 6.10262379e-02f, 1.74098904e-03f, -5.16305380e-02f, 5.78023829e-02f, 6.84097782e-02f, 3.27433646e-01f, 3.19385737e-01f, -1.03203304e-01f, 6.73829541e-02f,
  -2.32821442e-02f, -1.44809917e-01f, -3.95602994e-02f, -8.64987001e-02f, 1.25367194e-01f, 2.19805036e-02f, 1.91840470e-01f, -4.79571074e-02f, 1.90488640e-02f, -2.58792788e-01f,
  2.13576108e-01f, 4.42215167e-02f, 1.60842672e-01f, -1.52204866e-02f, 1.49797201e-02f, -4.88186657e-01f, -6.24783821e-02f, 2.05676444e-02f, -3.26715767e-01f, 3.02598625e-01f,
  6.63787648e-02f, -1.65265873e-02f, -1.25701755e-01f, 1.64580971e-01f, -6.87774271e-02f, 1.39097422e-01f, 9.00524855e-02f, 8.30675438e-02f, -2.69688535e-02f, 3.48155081e-01f,
  2.68894970e-01f, 2.41796687e-01f, -5.80866300e-02f, -2.02130735e-01f, 1.58766687e-01f, 1.15935527e-01f, 3.75508778e-02f, -1.80174988e-02f, -2.94367611e-01f, -1.16580084e-01f,
  -3.21178734e-01f, 2.90921986e-01f, 3.20211472e-03f, 2.79889166e-01f, 1.60045475e-01f, 8.36732090e-02f, -6.64849579e-02f, 4.68547409e-03f, -5.00296578e-02f, 1.04961701e-01f,
  -5.41857816e-02f, 2.11783245e-01f, 1.67937785e-01f, 6.03466853e-02f, 5.88857792e-02f, -2.73512043e-02f, -2.07920402e-01f, -3.17826271e-01f, -2.77035445e-01f, 1.43663034e-01f,
  -5.29568642e-02f, 5.49621554e-03f, -5.31451358e-03f, -1.72590345e-01f, -3.30457576e-02f, -2.77073711e-01f, 4.11549732e-02f, 2.06416205e-01f, 1.87436551e-01f, 2.54441142e-01f,
  1.11875333e-01f, 5.30018099e-02f, -2.47636169e-01f, -1.52998447e-01f, 9.23526213e-02f, 3.15255761e-01f, 2.58522332e-02f, 8.67323875e-02f, -7.49818608e-02f, -3.33517902e-02f,
  -5.58848605e-02f, -1.48452193e-01f, -6.18107058e-02f, -3.10525987e-02f, 4.95595895e-02f, -5.08104600e-02f, 1.78466648e-01f, 1.13332696e-01f, -1.75637856e-01f, 1.68376282e-01f,
  1.53878376e-01f, -4.53466736e-02f, -2.19351221e-02f, 3.31703067e-01f, 1.42760158e-01f, 1.50372043e-01f, 1.12196274e-01f, 8.52692872e-02f, 5.71092814e-02f, 1.11319050e-01f,
  -1.68951117e-02f, -2.08970308e-01f, -2.06772804e-01f, 1.01027504e-01f, -7.85467848e-02f, 2.27846485e-02f, 2.72090554e-01f, 1.64777562e-02f, 1.90163344e-01f, 1.05998650e-01f,
  -1.42368615e-01f, 3.56957376e-01f, 6.65489063e-02f, -3.77273589e-01f, -7.65228793e-02f, 2.38209859e-01f, 1.19571872e-01f, -1.46699354e-01f, 1.67555258e-01f, -8.20316225e-02f,
  7.60415196e-02f, -1.18717924e-02f, 3.91110815e-02f, 1.91476032e-01f, 5.30034564e-02f, 5.77990562e-02f, -8.42813700e-02f, 1.73173510e-02f, -4.88340594e-02f, 3.63074802e-02f,
  2.04490647e-01f, 8.94232020e-02f, 1.57359410e-02f, 1.22844614e-01f, 9.59676877e-03f, -2.94697523e-01f, 1.85185969e-01f, -1.29516348e-02f, -7.07822219e-02f, 1.05521150e-01f,
  5.35794650e-04f, 6.00470379e-02f, 2.93208961e-03f, 5.26201606e-01f, -1.57189816e-01f, 1.67840615e-01f, -1.51643366e-01f, 7.37397969e-02f, 1.13753445e-01f, 1.88642070e-01f,
  -2.24808771e-02f, 2.37457708e-01f, -2.28324294e-01f, -2.11303192e-03f, -8.27453434e-02f, 9.64052007e-02f, -1.19269453e-01f, -1.41996771e-01f, 1.07206218e-01f, -3.58104855e-01f,
  7.94136077e-02f, 3.31133343e-02f, -7.09349886e-02f, -1.87393770e-01f, 9.66249108e-02f, 7.58939460e-02f, 3.52087393e-02f, 2.20490634e-01f, -7.01932609e-02f, 7.64730647e-02f,
  -5.71697429e-02f, -1.24780826e-01f, 1.89032674e-01f, -1.78184688e-01f, 1.35489494e-01f, -1.20514587e-01f, -1.14937142e-01f, 1.32915646e-01f, 4.69300859e-02f, 1.33151963e-01f,
  2.13746935e-01f, 1.46447062e-01f, -5.57874329e-02f, 1.09777942e-01f, -2.32057303e-01f, -4.80838716e-01f, -4.06385869e-01f, -4.81771752e-02f, 1.19104043e-01f, 1.80881038e-01f,
  -1.94557622e-01f, -2.69179195e-01f, -2.30636626e-01f, -2.09989846e-01f, 1.37747258e-01f, -1.83540553e-01f, -4.48786169e-02f, -1.27656654e-01f, -8.84497166e-02f, -1.11118980e-01f,
  -7.61508048e-02f, -2.14593202e-01f, 1.91716015e-01f, -3.70420992e-01f, -1.03682466e-01f, 1.98739290e-01f, 1.20841131e-01f, 1.35538116e-01f, -1.22542776e-01f, -8.44811276e-02f,
  8.94980431e-02f, -1.07426509e-01f, -3.55242863e-02f, 1.67368993e-01f, -3.24226946e-01f, 1.21033475e-01f, -3.60980816e-03f, -2.26762816e-01f, 1.65352318e-02f, -1.70797899e-01f,
  -8.80525634e-02f, 3.28887976e-03f, -2.53857344e-01f, 3.06065977e-01f, -8.68136510e-02f, 1.58944935e-01f, 1.32203624e-01f, 1.93841010e-02f, -1.67261347e-01f, -2.22786833e-02f,
  -1.65904894e-01f, -8.08774829e-02f, 1.60910904e-01f, 2.48464998e-02f, -1.51459545e-01f, 8.47265869e-02f, 8.49930272e-02f, 9.42198634e-02f, 2.70326119e-02f, 4.59783226e-01f,
  -3.90028119e-01f, -3.11579078e-01f, 4.45534885e-02f, 4.92199548e-02f, 2.12288857e-01f, -6.74820784e-03f, -7.39306360e-02f, -1.24391811e-02f, -1.85135335e-01f, -1.12180322e-01f,
  7.98761323e-02f, 7.68210515e-02f, -2.36763880e-01f, -1.29552186e-01f, -8.21909532e-02f, -1.22024864e-01f, 7.14474469e-02f, 1.67744577e-01f, 1.09552391e-01f, 1.67150483e-01f,
  -1.77307442e-01f, -1.69335082e-01f, 2.37209812e-01f, -1.33343982e-02f, 2.47276783e-01f, -1.46950737e-01f, -1.87697604e-01f, 2.50572205e-01f, -9.38991271e-03f, 2.73272961e-01f,
  2.00888500e-01f, 4.26789403e-01f, 5.50641306e-02f, 1.31722465e-01f, -9.55146644e-03f, 1.11038134e-01f, 2.77734160e-01f, 2.09644079e-01f, -1.01420209e-01f, -1.63169559e-02f,
  -1.55599177e-01f, -4.25448790e-02f, 1.21471807e-01f, 7.79678151e-02f, 2.04655766e-01f, -6.25680164e-02f, 1.02833427e-01f, -2.52192169e-01f, 6.50702417e-02f, 1.11138768e-01f,
  5.38834482e-02f, 1.87107250e-01f, 3.47221971e-01f, 1.21891394e-01f, 7.91544542e-02f, 5.41314006e-01f, -1.62639230e-01f, 1.00535348e-01f, -2.48765662e-01f, -2.97924042e-01f,
  -4.93700965e-04f, -2.94267267e-01f, -6.82179909e-03f, -3.70477080e-01f, -3.04039359e-01f, 9.59786698e-02f, 4.05713357e-02f, 1.04308128e-01f, 2.51482695e-01f, 1.48452476e-01f,
  -3.51915881e-02f, 6.77887723e-02f, 3.13473791e-02f, -3.45255464e-01f, 3.48126106e-02f, 8.26034620e-02f, -2.51332164e-01f, 1.02141961e-01f, 2.46264249e-01f, -1.79607943e-02f,
  3.68716307e-02f, -1.04743086e-01f, 1.50233313e-01f, -6.85926303e-02f, 1.85189828e-01f, -1.40901536e-01f, -7.27154464e-02f, -2.98491213e-02f, 1.38347775e-01f, -3.50290537e-02f,
  -6.03516027e-02f, 6.99350536e-02f, -2.42959484e-01f, -8.50796774e-02f, -2.18775775e-02f, 1.78263560e-01f, -3.99898216e-02f, 6.73570707e-02f, 1.10890046e-01f, -2.68523812e-01f,
  -1.89599432e-02f, 2.33884200e-01f, -7.32196271e-02f, 1.44911066e-01f, -1.30935133e-01f, 1.41351447e-01f, 9.16993469e-02f, 8.72804374e-02f, 2.14073822e-01f, -2.09046558e-01f,
  -7.07023218e-02f, 1.26663940e-02f, -3.94760892e-02f, -1.37587786e-01f, 7.15117529e-02f, -2.23194808e-01f, 2.20362488e-02f, 1.72830701e-01f, 2.45978907e-01f, 5.92076145e-02f,
  2.52467096e-01f, -5.82894124e-02f, -7.19859004e-02f, 2.65609503e-01f, -1.28549308e-01f, 7.28027150e-02f, -2.20036447e-01f, -1.87064558e-01f, -8.37896317e-02f, -4.98848073e-02f,
  -1.73544437e-01f, -2.14638665e-01f, 1.18175454e-01f, -6.67244643e-02f, 1.96056113e-01f, -1.94714203e-01f, 3.04331273e-01f, -1.56176761e-01f, 9.16924607e-03f, -1.06503829e-01f,
  -2.38068476e-01f, -1.23778425e-01f, -1.62811223e-02f, 1.98791102e-01f, -1.75428260e-02f, 3.59830409e-01f, -1.29983112e-01f, 1.88257843e-01f, -3.71395290e-01f, 2.60871858e-03f,
  -1.60689294e-01f, 1.33859769e-01f, 3.04686278e-01f, 2.68495262e-01f, 1.45114571e-01f, 1.23242773e-01f, -3.01280349e-01f, 8.30687210e-02f, 9.41493139e-02f, -4.87583242e-02f,
  1.19144246e-01f, -2.17858598e-01f, 2.24102706e-01f, -4.53756452e-02f, 2.04390347e-01f, 3.45959723e-01f, 2.21504629e-01f, -1.84459403e-01f, 2.85612911e-01f, -1.25944123e-01f,
  1.75517336e-01f, -2.81610876e-01f, -2.31606215e-01f, -1.34842575e-01f, -2.09407389e-01f, -5.56041151e-02f, -1.25094607e-01f, -1.24580571e-02f, 1.58861697e-01f, 1.41346604e-01f,
  9.57968086e-02f, -1.14070736e-02f, -2.20918849e-01f, 7.14769736e-02f, -1.46132722e-01f, 1.40720502e-01f, 2.74607483e-02f, 2.01654240e-01f, -7.97807872e-02f, 8.98129866e-02f,
  -9.10916030e-02f, 3.50813895e-01f, -2.07795098e-01f, 1.34593099e-01f, -4.22987901e-02f, -3.46074700e-02f, -1.66826248e-01f, -1.02243744e-01f, 1.45903036e-01f, -1.49603799e-01f,
  1.17823416e-02f, -1.50981218e-01f, 7.54224062e-02f, -1.50091335e-01f, -6.81340545e-02f, -1.76718131e-01f, 6.24189936e-02f, 4.25195061e-02f, 2.72873882e-02f, 2.34303743e-01f,
  -6.26861602e-02f, 1.06300250e-01f, -1.52514607e-01f, 1.79968446e-01f, -9.52996165e-02f, 2.96435624e-01f, 9.15131941e-02f, 2.31134832e-01f, 2.57652551e-01f, 4.02773023e-01f,
  -2.63120443e-01f, 2.54742742e-01f, -1.78014655e-02f, -7.53128156e-02f, 1.79784596e-01f, -2.15401322e-01f, 9.72472206e-02f, 2.26054609e-01f, 1.64212823e-01f, 2.38898415e-02f,
  1.60801873e-01f, -1.08689047e-01f, -9.36645642e-02f, -3.15312296e-02f, 2.08957076e-01f, 5.76087125e-02f, 9.65126008e-02f, 4.11698312e-01f, 2.07294717e-01f, -2.26268750e-02f,
  8.23382139e-02f, 1.79817842e-04f, 1.92718118e-01f, 1.00450562e-02f, 4.21929993e-02f, -1.94729269e-01f, -7.91400671e-02f, -1.22221150e-01f, -1.65585101e-01f, 1.77526414e-01f,
  2.21351489e-01f, -1.94281161e-01f, 1.76252365e-01f, 1.62454825e-02f, 2.15896834e-02f, 2.26392075e-01f, 2.20282525e-02f, 8.53166799e-04f, 3.93379442e-02f, 2.05648288e-01f,
  2.42487699e-01f, 7.42271319e-02f, -2.41803378e-01f, 8.49679112e-02f, -1.79624453e-01f, 2.46756356e-02f, -9.50532034e-02f, 8.54073986e-02f, 2.42189452e-01f, 8.97633731e-02f,
  -1.48392469e-01f, -3.44461173e-01f, 1.09631427e-01f, -1.97188556e-01f, 6.38678223e-02f, -1.81035370e-01f, 5.50527349e-02f, -2.93309748e-01f, 3.68618406e-03f, -1.46688744e-01f,
  -2.79838182e-02f, -4.13154602e-01f, 7.64253214e-02f, -2.41446614e-01f, 4.23958823e-02f, 1.03361070e-01f, 1.28891468e-01f, -3.79628807e-01f, -3.16138297e-01f, 1.70309953e-02f,
  -2.70922393e-01f, -2.38125265e-01f, 1.43646777e-01f, -2.03785181e-01f, -3.33023071e-01f, 7.09041953e-02f, -2.71017849e-01f, -1.14511386e-01f, 9.72972065e-03f, 6.09600469e-02f,
  -2.39629239e-01f, -8.00526366e-02f, 1.97160468e-02f, 5.47798499e-02f, -4.93164621e-02f, 1.63918525e-01f, -2.39009447e-02f, -1.28384501e-01f, -2.62711555e-01f, 5.56513853e-02f,
  -7.56281987e-02f, -2.31670048e-02f, 4.82635558e-01f, 8.32737312e-02f, -1.20027810e-01f, -1.36040384e-02f, -5.41989021e-02f, 7.12556988e-02f, 1.46085713e-02f, -1.24887284e-02f,
  2.05975682e-01f, 2.36119572e-02f, -1.77082956e-01f, -1.74036831e-01f, -4.99344170e-02f, 1.33679446e-03f, 3.99266519e-02f, 2.63284028e-01f, 8.88404176e-02f, -1.70396134e-01f,
  9.43735018e-02f, -4.22571786e-02f, 3.81501108e-01f, -1.90640464e-01f, 1.09951593e-01f, 1.69197857e-01f, 3.11171353e-01f, 5.99936619e-02f, -2.25649297e-01f, 4.88113239e-02f,
  9.92685258e-02f, -1.07007578e-01f, -2.48704348e-02f, 2.08160177e-01f, -8.25530067e-02f, 1.81999639e-01f, -7.81420060e-03f, 2.22323060e-01f, -7.04348553e-03f, -1.39366165e-01f,
  -1.35700973e-02f, -1.31973937e-01f, -7.90873356e-03f, 3.06144059e-01f, 1.88929718e-02f, 2.27785215e-01f, -3.32352698e-01f, -9.59850773e-02f, -6.18207231e-02f, 1.13227762e-01f,
  1.75860032e-01f, -7.51225501e-02f, -5.47342636e-02f, -2.12151613e-02f, 6.41303733e-02f, -1.85374960e-01f, 2.87577659e-01f, -1.10568693e-02f, 1.55446559e-01f, 5.82825094e-02f,
  -4.46109809e-02f, 7.43158013e-02f, -7.25530833e-02f, -1.30037352e-01f, -3.02167326e-01f, -2.64787972e-01f, 5.12874842e-01f, -2.11663377e-02f, 1.04895979e-01f, 1.77682951e-01f,
  2.19274312e-01f, 2.21435070e-01f, -1.50639430e-01f, -1.09621041e-01f, 4.11025435e-01f, -6.52162209e-02f, -9.97987986e-02f, -3.91556770e-02f, -8.46106559e-02f, -7.06255659e-02f,
  1.82455927e-01f, 1.52196243e-01f, 2.72908837e-01f, 2.17072610e-02f, -1.18822036e-02f, 9.67535377e-02f, 2.60687530e-01f, -8.74240324e-02f, -6.85591474e-02f, 1.85633093e-01f,
  6.84336200e-02f, -4.73434068e-02f, -1.98460907e-01f, -8.77352338e-03f, -3.83612178e-02f, 1.21192932e-01f, -1.56832173e-01f, 8.24871659e-02f, 7.88744837e-02f, 1.26040787e-01f,
  -7.76645020e-02f, 9.58235562e-02f, 1.40194431e-01f, -6.74772486e-02f, 4.92406376e-02f, 2.59578228e-01f, -4.69997749e-02f, 2.30302345e-02f, 5.14789522e-02f, -3.28127444e-02f,
  1.13054268e-01f, 1.15344869e-02f, 1.91045582e-01f, 2.02118099e-01f, 1.52531341e-01f, 2.71844208e-01f, 8.19341615e-02f, -2.69754529e-01f, -1.14715025e-01f, -1.87218398e-01f,
  -4.28815261e-02f, -5.78137934e-02f, 1.51911318e-01f, 2.48464212e-01f, -6.33402839e-02f, -5.05569689e-02f, 2.94433273e-02f, 1.58577487e-01f, 1.71690822e-01f, 3.54116827e-01f,
  3.69929254e-01f, -2.17127353e-01f, -7.79724270e-02f, 5.75702339e-02f, -1.89926952e-01f, -1.13675073e-01f, -2.54284054e-01f, 1.85818970e-01f, -2.25306407e-01f, 6.25428706e-02f,
  1.92747325e-01f, -4.30112099e-03f, -7.37264529e-02f, -2.45490689e-02f, 4.58014756e-02f, -9.51007828e-02f, -6.62681907e-02f, -1.89293966e-01f, 2.26600692e-01f, 1.39642403e-01f,
  2.30019782e-02f, -2.37944022e-01f, -1.59942489e-02f, 5.37957475e-02f, 3.54098789e-02f, 1.49077743e-01f, 1.52874663e-01f, -5.72218969e-02f, -6.70889542e-02f, -1.73900843e-01f,
  -2.59339865e-02f, 1.13747865e-01f, 1.66136742e-01f, -5.36687374e-02f, 1.90955680e-02f, 2.23310992e-01f, -2.40213528e-01f, -3.92010957e-01f, -3.05783242e-01f, -9.47032273e-02f,
  1.37951463e-01f, 1.81752026e-01f, 1.80325463e-01f, 2.40099192e-01f, -3.30778509e-01f, -1.73085958e-01f, -1.24092340e-01f, -5.36430143e-02f, 7.57452995e-02f, 3.28809649e-01f,
  8.05235654e-03f, 2.15414708e-04f, 3.57578516e-01f, 7.02449828e-02f, 7.30856806e-02f, -1.26407176e-01f, 2.65518665e-01f, 1.92231163e-01f, 9.04656127e-02f, 3.33606750e-01f,
  3.24604064e-01f, 1.66175798e-01f, 4.21158433e-01f, -1.45620704e-02f, -1.90005019e-01f, -3.22383404e-01f, 5.18413298e-02f, -2.24655122e-02f, -2.00084507e-01f, -1.68679565e-01f,
  -3.27341676e-01f, 3.41340527e-02f, -2.48431057e-01f, 6.57548532e-02f, 1.39322132e-01f, -1.18947932e-02f, 9.49968621e-02f, 6.09663140e-04f, -8.34973827e-02f, -1.91039935e-01f,
  -2.96776984e-02f, -3.69593412e-01f, 1.67552114e-01f, 8.93678516e-02f, 1.45262003e-01f, 9.85108316e-02f, -2.90347964e-01f, 7.07949251e-02f, -9.49522778e-02f, 6.59629703e-02f,
  1.27792731e-01f, -4.40913677e-01f, -7.93438330e-02f, 2.88789690e-01f, -1.18231531e-02f, 3.38015482e-02f, 2.46881038e-01f, -2.73399567e-03f, 2.79488564e-01f, 6.72211573e-02f,
  4.10292856e-02f, -1.54114038e-01f, -3.28693718e-01f, -2.70809025e-01f, -3.79481539e-02f, 1.06700718e-01f, -1.13327965e-01f, 3.70058984e-01f, -5.00594750e-02f, 1.94492877e-01f,
  -1.15523703e-01f, 2.50339061e-02f, -3.63148525e-02f, 9.07080472e-02f, 1.71614230e-01f, 3.66998240e-02f, 2.32762098e-01f, 2.36153305e-01f, -5.89202046e-02f, -2.94549555e-01f,
  1.32031918e-01f, 2.16540366e-01f, -1.12030640e-01f, 2.47024357e-01f, 2.78588802e-01f, 1.37868062e-01f, 8.12569186e-02f, 7.36693889e-02f, 1.77451372e-01f, -1.45136476e-01f,
  1.74540162e-01f, -3.32385022e-03f, -9.78364348e-02f, -3.03286742e-02f, -1.92100912e-01f, 3.55771482e-01f, -2.07199290e-01f, 1.48536205e-01f, 1.17637269e-01f, -2.24408619e-02f,
  1.88716665e-01f, 8.25610906e-02f, 1.17449760e-01f, -1.13460228e-01f, 1.08456254e-01f, -4.02531058e-01f, 2.14910075e-01f, -6.34069368e-02f, 8.20697397e-02f, 2.03499317e-01f,
  -2.94045597e-01f, -1.17206201e-01f, -2.52562553e-01f, 1.90013424e-01f, 2.81172037e-01f, -2.00882688e-01f, -1.42964438e-01f, 6.82517365e-02f, -1.55435279e-01f, 7.35639483e-02f,
  3.25323313e-01f, -1.39689490e-01f, 6.42241612e-02f, -2.33935956e-02f, 1.29005507e-01f, -9.40534100e-02f, -4.32886556e-02f, -1.51867317e-02f, 7.62188854e-03f, 1.51734814e-01f,
  -1.26819685e-01f, 3.29017162e-01f, -6.80682342e-03f, 3.33567798e-01f, 1.04849590e-02f, 4.88868989e-02f, 6.40035346e-02f, 7.97238722e-02f, 1.85892005e-02f, -7.52180070e-02f,
  1.35588706e-01f, 1.72343269e-01f, -1.02729052e-02f, -8.67809877e-02f, 8.79792124e-03f, -8.80201533e-02f, 1.59937039e-01f, 1.82701096e-01f, 4.43732664e-02f, 2.73457319e-01f,
  -4.07062829e-01f, -1.91296011e-01f, -7.17649683e-02f, 2.58203149e-01f, -4.85580236e-01f, 1.75085619e-01f, -2.90116042e-01f, -8.58902261e-02f, 8.81592333e-02f, 2.61268854e-01f,
  -2.17519447e-01f, -1.26776919e-01f, -1.52053371e-01f, 8.74471292e-02f, -7.39498362e-02f, -2.22160183e-02f, 1.27486348e-01f, 5.15525742e-03f, -1.03253186e-01f, -3.18455875e-01f,
  1.50694385e-01f, -1.98500425e-01f, -1.16755255e-01f, -4.22960222e-01f, -2.87953615e-02f, 1.15088597e-02f, 8.35167319e-02f, -5.91079816e-02f, 1.37284771e-01f, 6.82098567e-02f,
  1.73881233e-01f, 2.01620564e-01f, -2.36317758e-02f, -1.14310652e-01f, -9.88313258e-02f, -9.54208076e-02f, -1.68443739e-01f, 3.48967463e-01f, 1.66972294e-01f, 2.15549752e-01f,
  1.83582455e-02f, 2.93814652e-02f, 5.31919189e-02f, 9.58226547e-02f, -1.34829223e-01f, 6.22014366e-02f, 2.47941896e-01f, 1.34882005e-02f, 6.88772947e-02f, -2.50691593e-01f,
  -1.36653602e-01f, 1.26625538e-01f, -6.52486309e-02f, 1.43221751e-01f, 3.03119957e-01f, 3.91042411e-01f, 3.31880331e-01f, -1.40469149e-01f, -1.24810766e-02f, -7.15480596e-02f,
  1.02127530e-01f, 1.28022313e-01f, -2.54061580e-01f, 1.93259627e-01f, -3.65625769e-01f, -3.19102019e-01f, -2.63781715e-02f, 3.75912666e-01f, -2.95596682e-02f, 2.21273541e-01f,
  -1.62708431e-01f, -1.36267925e-02f, 1.91371977e-01f, -2.41099030e-01f, 3.57546732e-02f, 1.27435371e-01f, -2.42520824e-01f, -5.69294346e-03f, 6.15458041e-02f, 2.67487407e-01f,
  7.47938231e-02f, 1.97966784e-01f, 9.10820290e-02f, -1.24695942e-01f, -1.35738432e-01f, -2.67493933e-01f, 2.19128400e-01f, 1.04514368e-01f, 1.16857402e-01f, 6.95039853e-02f,
  1.36978095e-02f, 3.53471264e-02f, -2.47055367e-01f, 2.09199488e-02f, 4.66424460e-03f, -6.82923151e-03f, 4.17439677e-02f, 2.07771584e-01f, -2.08214805e-01f, -5.05495705e-02f,
  1.56707346e-01f, 2.26835310e-01f, 1.38811126e-01f, 2.16208234e-01f, 1.23118341e-01f, -1.95725441e-01f, 1.34750485e-01f, -1.71540871e-01f, -3.77135947e-02f, 5.69069237e-02f,
  2.51421761e-02f, 1.62571613e-02f, 2.08167493e-01f, 1.07311808e-01f, 9.42083448e-02f, 6.52495101e-02f, -2.30836514e-02f, 8.67438409e-03f, -7.45038018e-02f, 1.36697486e-01f,
  2.97412425e-01f, 1.91397607e-01f, 1.21364921e-01f, 1.70064658e-01f, 7.27890506e-02f, 2.32254729e-01f, -2.00596943e-01f, 4.92857471e-02f, -1.32947847e-01f, -2.02808768e-01f,
  1.77017093e-01f, 2.35998362e-01f, -1.41330153e-01f, -3.58973294e-02f, -7.59204328e-02f, 3.26944478e-02f, -2.76082493e-02f, -1.96841687e-01f, 3.15755397e-01f, 1.47342579e-02f,
  -2.13412717e-01f, 8.05227458e-03f, -2.29107380e-01f, 1.67003367e-02f, 1.31265372e-01f, 7.72415698e-02f, 1.32381290e-01f, 2.89923966e-01f, 1.47637445e-02f, 2.44659051e-01f,
  3.14150542e-01f, -2.13812426e-01f, 1.97076231e-01f, 1.24009542e-01f, 3.43039900e-01f, -7.33991116e-02f, -2.90919036e-01f, 2.43872851e-01f, 1.25408918e-01f, -4.32690568e-02f,
  -1.25511050e-01f, 1.45276502e-01f, -1.24476351e-01f, 8.48734751e-02f, -9.53692421e-02f, 1.32218510e-01f, -8.18531886e-02f, -1.53446361e-01f, -1.33887395e-01f, 3.46849822e-02f,
  2.22659558e-02f, 2.48728946e-01f, 1.40563771e-01f, -6.55307844e-02f, -1.57930151e-01f, -1.97592929e-01f, 1.75848141e-01f, 1.39403328e-01f, 1.45561874e-01f, 2.44150862e-01f,
  1.51059581e-02f, 1.34313107e-01f, 6.77931458e-02f, -1.28830180e-01f, 3.00104141e-01f, -5.24958782e-02f, 1.15437090e-01f, 3.73539291e-02f, 3.51226926e-02f, -9.58570745e-03f,
  -2.18634114e-01f, -1.03122383e-01f, -3.34597141e-01f, -5.35435855e-01f, 1.99196488e-01f, 1.04689591e-01f, 3.78911458e-02f, -3.65651958e-02f, 4.62253839e-02f, -1.69649109e-01f,
  1.17550592e-03f, 4.09145445e-01f, -1.42973721e-01f, -1.11985110e-01f, 5.25616594e-02f, 1.08351313e-01f, 2.96784252e-01f, 2.25761712e-01f, -1.03646159e-01f, 2.39581801e-02f,
  -2.68128753e-01f, -1.21860959e-01f, -3.54010090e-02f, -1.19414851e-01f, 1.97482660e-01f, 6.20004013e-02f, -6.64843200e-03f, -1.62588000e-01f, 1.52078986e-01f, 3.69902737e-02f,
  -6.24826066e-02f, -2.23941073e-01f, -1.50238425e-01f, -3.18375200e-01f, 2.43729249e-01f, 8.90555978e-02f, 2.40796879e-01f, -3.39119554e-01f, -2.35088766e-01f, 2.23795429e-01f,
  1.93361714e-01f, 7.71475285e-02f, 5.83509952e-02f, 1.91051230e-01f, -8.70074928e-02f, 1.13821469e-01f, -4.39025998e-01f, 3.15103322e-01f, 1.14504874e-01f, -7.86408857e-02f,
  -3.33862692e-01f, 1.21876702e-01f, -1.23167108e-03f, 2.46761623e-03f, 3.22346874e-02f, 1.79151013e-01f, 1.89758301e-01f, 1.38892725e-01f, 1.09229520e-01f, -5.83772324e-02f,
  1.35954425e-01f, 2.64599264e-01f, 2.06075579e-01f, 1.31433249e-01f, 1.02134109e-01f, 1.82791486e-01f, 5.27546965e-02f, 1.62144050e-01f, -5.03992029e-02f, 4.74438034e-02f,
  -3.10330689e-02f, 2.72025019e-02f, 4.09260429e-02f, 2.33646855e-01f, -1.55611381e-01f, 1.43970430e-01f, 2.67385453e-01f, 6.00436553e-02f, -2.07249701e-01f, 2.05912933e-01f,
  -4.94828559e-02f, 2.47749481e-02f, 3.59705508e-01f, 6.44650459e-02f, 1.43461414e-02f, -8.01727474e-02f, 2.40165234e-01f, 2.82439142e-01f, -7.57095367e-02f, -2.69661129e-01f,
  -2.08249196e-01f, 2.38825083e-02f, -2.59980392e-02f, -2.55578421e-02f, 3.44491780e-01f, 1.27439842e-01f, 9.22225341e-02f, 4.23684001e-01f, -2.79355288e-01f, -1.18422419e-01f,
  2.43777961e-01f, 1.97146624e-01f, -7.07950220e-02f, 2.22051173e-01f, 1.25961572e-01f, 2.33138143e-03f, -2.49106303e-01f, 2.44863257e-01f, 8.21242407e-02f, -4.27724142e-03f,
  -1.62811548e-01f, 2.30183497e-01f, 1.60750940e-01f, -2.48789620e-02f, 2.55739391e-01f, -6.41430095e-02f, -5.45859821e-02f, 4.58943248e-01f, -2.44958103e-02f, -1.13171540e-01f,
  1.32347479e-01f, 2.65135825e-01f, 5.33699244e-02f, -3.22742313e-01f, 1.80849314e-01f, -6.38396516e-02f, -2.23607309e-02f, -5.24528921e-02f, 4.37252559e-02f, 1.53939836e-02f,
  -1.66384934e-03f, -7.55866058e-03f, 3.05929035e-01f, -2.85628401e-02f, -1.08050769e-02f, 4.84487973e-03f, -8.36091563e-02f, 2.84066260e-01f, 6.76186010e-02f, 3.53065699e-01f,
  2.84305155e-01f, -1.72331333e-01f, 3.17546725e-02f, -1.28514156e-01f, -3.30794722e-01f, -3.34060252e-01f, 1.42101645e-01f, 1.49882376e-01f, 2.78316617e-01f, -9.50069923e-04f,
  1.03858396e-01f, 1.79852292e-01f, 3.01331747e-02f, -1.23295933e-01f, -1.17933765e-01f, 3.07087172e-02f, 2.27351770e-01f, 8.92719254e-02f, 9.46606472e-02f, -2.13066563e-02f,
  -6.70330599e-02f, -1.46041811e-01f, -2.49155104e-01f, -9.52484608e-02f, 1.54257402e-01f, 1.26812547e-01f, -3.51852745e-01f, 1.94154121e-02f, 1.65710840e-02f, -2.16138959e-01f,
  -2.17990562e-01f, 4.46337223e-01f, 3.70982699e-02f, 2.52416044e-01f, 1.40387908e-01f, -1.71466470e-02f, 1.04728043e-01f, -2.37036094e-01f, 2.39489526e-02f, 8.39939490e-02f,
  -2.86096390e-02f, 3.01016420e-01f, 9.84456837e-02f, -7.91185200e-02f, 2.37518325e-01f, -3.05686831e-01f, -1.02823757e-01f, -2.71936446e-01f, 2.18798146e-01f, 6.17931113e-02f,
  7.24149123e-02f, -5.90896606e-03f, 2.41190210e-01f, -5.70857264e-02f, 4.68356192e-01f, 2.70432770e-01f, -9.68870074e-02f, -1.71595827e-01f, 1.81626022e-01f, -3.03244263e-01f,
  2.15041012e-01f, -2.04145506e-01f, -4.56934758e-02f, 9.56444889e-02f, -1.10883854e-01f, 1.10170268e-01f, -3.05723280e-01f, 6.47542775e-02f, -4.18794714e-02f, 2.88628116e-02f,
  -3.83459367e-02f, 1.60850912e-01f, 4.14122902e-02f, 3.19310397e-01f, 1.75287679e-01f, 8.77191573e-02f, 2.12563768e-01f, 3.01421940e-01f, -2.60505050e-01f, 7.72334784e-02f,
  9.32656601e-02f, -1.50786042e-02f, 2.72613406e-01f, -2.30981454e-01f, 1.19011313e-01f, -8.32157303e-03f, -2.03625076e-02f, 2.01264381e-01f, -3.20439264e-02f, -1.68094933e-01f,
  3.65220219e-01f, -1.15939021e-01f, -2.05759183e-01f, -2.02414840e-01f, 2.22260132e-01f, -4.36743736e-01f, -1.60829145e-02f, -9.57752764e-03f, -4.94422950e-02f, 2.72752643e-01f,
  3.25702466e-02f, -8.64152536e-02f, -3.90392020e-02f, -1.81108281e-01f, -6.48794025e-02f, -5.27926534e-02f, 1.63906410e-01f, 7.41194114e-02f, 1.24080710e-01f, 3.38299692e-01f,
  -5.12095280e-02f, 1.00278117e-01f, 2.32959837e-01f, 1.34506896e-01f, 1.12693898e-01f, 2.08239436e-01f, 2.94774592e-01f, -6.21985272e-02f, 1.15307152e-01f, 8.66696239e-02f,
  -3.24640155e-01f, 1.27613798e-01f, 1.66082159e-01f, -1.24360651e-01f, 1.28991395e-01f, -1.95705637e-01f, -2.83835679e-01f, -1.33044109e-01f, -8.85130391e-02f, -4.74088714e-02f,
  -1.37478068e-01f, 1.02240711e-01f, 1.07857496e-01f, 5.94298616e-02f, -6.84088990e-02f, 3.32546048e-02f, -5.85843101e-02f, -7.70866405e-03f, 2.08077565e-01f, 3.81630570e-01f,
  4.78556454e-02f, 1.86093450e-01f, 1.53958122e-03f, 1.04431443e-01f, 1.08569432e-02f, -4.39788774e-02f, 2.26567656e-01f, -1.38314709e-01f, 1.73068255e-01f, 2.56036550e-01f,
  -2.67770402e-02f, 1.06809482e-01f, -9.28089097e-02f, -2.09489256e-01f, 2.53799766e-01f, -1.84307322e-01f, -9.22635943e-02f, -9.64305475e-02f, 1.81473698e-02f, -1.33467495e-01f,
  -1.61148719e-02f, 2.51254112e-01f, -3.30893360e-02f, 8.92548114e-02f, 4.76750135e-02f, 7.02564418e-02f, 5.62536046e-02f, 9.99459624e-02f, -1.62301466e-01f, 1.02657080e-01f,
  5.22864982e-02f, -1.20137762e-02f, -5.59581853e-02f, 7.10534230e-02f, 7.37655349e-03f, -3.52369398e-01f, 2.53045201e-01f, 3.48643035e-01f, -8.93060118e-03f, 2.70314485e-01f,
  3.80047232e-01f, 3.05024594e-01f, 1.11997284e-01f, -6.34243665e-03f, -3.70774478e-01f, 1.15889490e-01f, -3.72154027e-01f, -2.10616589e-01f, -6.59534782e-02f, -2.27727309e-01f,
  -1.77933872e-01f, -4.63824272e-01f, -2.98281074e-01f, 3.25113147e-01f, -7.76554644e-02f, 4.66145836e-02f, 1.35488197e-01f, 2.49893278e-01f, 1.09079920e-01f, 5.76847903e-02f,
  -5.66955730e-02f, -4.17595446e-01f, 9.83557478e-02f, 1.34302646e-01f, 4.76255864e-02f, -3.17927040e-02f, 8.00387859e-02f, 7.26910681e-02f, 3.90057787e-02f, -7.38745779e-02f,
  6.91945329e-02f, -9.46759582e-02f, 1.19392970e-03f, 9.88334790e-02f, 1.07624263e-01f, 4.72395718e-02f, -3.09068263e-02f, -1.10393152e-01f, 2.82980502e-01f, -5.75967729e-02f,
  1.47372290e-01f, 3.63680199e-02f, 6.03112243e-02f, -2.88435906e-01f, -2.79170722e-02f, 1.63488746e-01f, -8.81341994e-02f, 2.38471515e-02f, -1.39240576e-02f, 2.23030418e-01f,
  8.07955340e-02f, 1.48956567e-01f, -1.55574828e-02f, 2.48403326e-01f, -3.07697020e-02f, 1.86530482e-02f, 9.37714428e-02f, 3.10654100e-02f, 9.13497526e-03f, -2.12513402e-01f,
  1.98281258e-01f, 2.28105336e-01f, 1.94438264e-01f, -2.00277511e-02f, 1.72100946e-01f, -2.27479622e-01f, 9.58044827e-03f, 2.32941899e-02f, -9.37179774e-02f, 1.03600800e-01f,
  1.12008542e-01f, -2.33324394e-01f, 1.68275014e-01f, -1.50451988e-01f, -2.34297782e-01f, -1.44332778e-02f, -2.85087489e-02f, -3.88552755e-01f, -2.49807686e-02f, 9.23132151e-02f,
  -2.43351329e-02f, 1.29358560e-01f, -1.41934097e-01f, 3.10760587e-02f, 5.77150797e-03f, 2.79830217e-01f, 1.13051191e-01f, 2.17587367e-01f, -1.96523761e-05f, 2.99505919e-01f,
  -1.02493770e-01f, 8.00813660e-02f, 1.55769974e-01f, -1.57734543e-01f, 2.78293639e-01f, -9.95964855e-02f, 1.50826201e-01f, 1.19713575e-01f, 2.73013022e-02f, -1.38931870e-01f,
  4.91264975e-03f, 1.37235792e-02f, -3.21335763e-01f, -2.05030024e-01f, -1.20299980e-02f, -4.34514275e-03f, 2.47743856e-02f, 2.05529913e-01f, -1.34410083e-01f, 3.76839280e-01f,
  -1.31834909e-01f, -2.40557387e-01f, 7.25606754e-02f, 1.66370243e-01f, -4.79912832e-02f, 3.05895150e-01f, -1.00181401e-01f, 1.48925155e-01f, -2.68521100e-01f, -3.49794440e-02f,
  -3.75121124e-02f, -1.88897178e-01f, 6.65173084e-02f, -3.45077991e-01f, 1.40761184e-02f, 6.43099379e-03f, -4.16200161e-02f, 1.31743833e-01f, 1.96827903e-01f, 2.30044916e-01f,
  -7.75237530e-02f, 1.77765682e-01f, -4.00055557e-01f, 2.61019379e-01f, -4.31934930e-02f, -1.61768720e-02f, -1.68583393e-02f, -3.42500135e-02f, -4.48389072e-03f, -8.35804921e-03f,
  -1.45922583e-02f, 3.22903574e-01f, -5.14723882e-02f, 2.02858061e-01f, 2.20852181e-01f, -1.69889033e-02f, 1.88582867e-01f, 1.17523991e-01f, -8.13222155e-02f, -1.38224602e-01f,
  6.66969456e-03f, 6.09906353e-02f, 1.70863524e-01f, 2.79907342e-02f, -2.34613463e-01f, 4.14924845e-02f, -1.86214790e-01f, -9.04985741e-02f, 9.61446688e-02f, -1.18791930e-01f,
  2.65629172e-01f, 1.98604599e-01f, -1.69182479e-01f, -7.35630095e-02f, 9.54936519e-02f, -1.77535504e-01f, 2.06950560e-01f, 1.35973513e-01f, 7.25685656e-02f, 3.82103622e-02f,
  -1.21229954e-01f, -3.19643170e-01f, 4.17028442e-02f, 3.89877916e-03f, -1.66596979e-01f, 1.98324725e-01f, 1.61890283e-01f, 8.47780332e-02f, 1.16393156e-01f, 7.42541179e-02f,
  -4.11644839e-02f, -4.45304997e-02f, 2.29441524e-01f, -1.86227605e-01f, -5.24189286e-02f, 3.12004030e-01f, 4.02096240e-03f, 2.23308414e-01f, 3.37261893e-02f, -2.38213339e-03f,
  2.21243322e-01f, 3.22170369e-02f, -5.11581264e-02f, -2.27840878e-02f, -1.70231476e-01f, -4.13728565e-01f, -1.17755219e-01f, 1.74374823e-02f, 1.79821402e-01f, -4.93953340e-02f,
  2.52201289e-01f, -1.80574954e-01f, 1.72626927e-01f, 4.80709106e-01f, -1.88241914e-01f, 7.52166510e-02f, -2.18501613e-01f, 9.49012563e-02f, -6.34914935e-02f, -1.00086164e-03f,
  -2.50791788e-01f, 8.25838000e-02f, -1.02597170e-01f, 9.95465815e-02f, 3.53243631e-05f, -6.86058402e-02f, 2.23689407e-01f, 1.90015584e-01f, -5.84684014e-02f, 2.95196697e-02f,
  2.28338212e-01f, -1.58567086e-01f, 1.76491484e-01f, -1.65479288e-01f, 2.36804876e-02f, -3.36372405e-01f, 9.67359915e-02f, 1.00575522e-01f, -2.88396448e-01f, -3.93904328e-01f,
  -6.35480732e-02f, 4.94345501e-02f, -1.26934931e-01f, 7.06773028e-02f, 4.93120588e-02f, -3.41054350e-01f, -2.39538759e-01f, 3.47093865e-02f, -2.94537961e-01f, 1.03198014e-01f,
  -1.51555076e-01f, -3.63899797e-01f, -4.16016579e-01f, -1.35721117e-01f, -1.55748939e-02f, -1.03899412e-01f, 6.56325072e-02f, 7.53306672e-02f, 5.81218302e-02f, 4.14981872e-01f,
  2.99362212e-01f, -3.09069362e-02f, 8.47610086e-02f, 4.79740277e-02f, 5.67337759e-02f, 2.82114595e-02f, 1.51477039e-01f, 2.62031078e-01f, -2.69738793e-01f, -7.95194954e-02f,
  -3.98364335e-01f, 2.86130339e-01f, -4.37612474e-01f, -1.63540289e-01f, -2.46527232e-02f, -3.13470751e-01f, 1.33421138e-01f, -1.58969849e-01f, -3.00932974e-01f, 7.49181360e-02f,
  -1.86300948e-02f, 1.06123872e-01f, 1.25776783e-01f, 2.33979493e-01f, -2.52976537e-01f, 1.95880100e-01f, -2.89804280e-01f, -3.87424976e-02f, 7.17217773e-02f, 4.01381552e-02f,
  -1.27310753e-01f, 3.16204950e-02f, 2.61831164e-01f, 3.47015969e-02f, 1.81466684e-01f, -1.20822988e-01f, -4.68072109e-02f, -1.30728453e-01f, 1.87113866e-01f, -1.59830064e-01f,
  4.50686254e-02f, 2.24251556e-03f, -3.46523046e-01f, -1.94829717e-01f, -1.85389817e-02f, 1.55988201e-01f, -1.22779526e-01f, 1.09500960e-01f, 2.64103740e-01f, -1.43947259e-01f,
  -1.36359617e-01f, 4.13849115e-01f, 1.12673407e-02f, -1.56338751e-01f, 1.08479790e-01f, -6.88411221e-02f, -1.81540936e-01f, 4.24654363e-03f, 3.88795100e-02f, 4.87618595e-02f,
  1.26935810e-01f, 4.52560894e-02f, 2.42630914e-01f, -1.75220128e-02f, 5.59386909e-02f, 1.26088178e-02f, 1.28910407e-01f, 1.73430786e-01f, 1.47849634e-01f, 1.01817258e-01f,
  1.01813175e-01f, 7.09120780e-02f, -1.50943220e-01f, -2.94353634e-01f, -1.70851991e-01f, 1.72876120e-01f, -1.42512664e-01f, -5.92966266e-02f, -4.05391343e-02f, -2.78072774e-01f,
  -3.11474707e-02f, 2.05654308e-01f, -1.83660939e-01f, -6.98750094e-02f, -5.07275984e-02f, 1.11193806e-01f, -8.04768279e-02f, 1.17234975e-01f, -2.45568469e-01f, -9.83808842e-03f,
  5.81428558e-02f, 1.47323608e-01f, 2.14623272e-01f, 2.47907296e-01f, -2.70088222e-02f, -1.02103293e-01f, 1.12605266e-01f, 3.77940573e-02f, 2.09332019e-01f, -3.94132473e-02f,
  -6.80954009e-03f, -1.87787518e-01f, 1.34366497e-01f, -5.92639074e-02f, 2.30181128e-01f, 1.04302287e-01f, -1.89892858e-01f, -1.73715830e-01f, -1.61512420e-01f, -1.08157203e-03f,
  4.12362851e-02f, -1.43660620e-01f, 1.24388739e-01f, -3.47214729e-01f, -3.16946954e-02f, 2.37666130e-01f, -9.17894542e-02f, -4.24491502e-02f, -8.01058412e-02f, -3.78686279e-01f,
  -2.01198965e-01f, -7.56928250e-02f, 2.03971878e-01f, -8.65656883e-03f, 9.60909761e-03f, 1.30475983e-01f, 7.66370445e-02f, -8.77383202e-02f, 2.56208956e-01f, -2.63069272e-01f,
  1.82409391e-01f, 2.00398881e-02f, -3.50598730e-02f, 2.18263596e-01f, 8.60865116e-02f, 3.15863341e-02f, -4.58932705e-02f, -4.46005650e-02f, 4.23370339e-02f, -1.49999484e-02f,
  3.09867054e-01f, -5.51541634e-02f, 1.83708742e-01f, 3.40919286e-01f, 3.52468416e-02f, -1.20435413e-02f, -1.06123285e-02f, -2.61178892e-02f, 2.79016048e-01f, -2.20755059e-02f,
  1.89079776e-01f, -2.50115748e-02f, 1.03794259e-03f, -1.27612054e-01f, 2.09268123e-01f, -1.04380380e-02f, 2.50585899e-02f, 1.24983497e-01f, 1.56345397e-01f, 3.04868631e-02f,
  2.41830628e-02f, 4.16602306e-02f, -2.34116286e-01f, 1.05127059e-01f, 2.45878711e-01f, 1.20348791e-02f, -1.45433694e-01f, 7.85315856e-02f, 1.50836840e-01f, -2.11512059e-01f,
  3.49493682e-01f, -4.33590525e-04f, -6.11347370e-02f, 4.99944463e-02f, 4.69479173e-01f, -1.16739027e-01f, -6.45070430e-03f, 4.48582619e-01f, 8.84007756e-03f, -1.38057426e-01f,
  4.59080823e-02f, 5.83299622e-02f, 2.21559659e-01f, 2.52609491e-01f, 8.82037058e-02f, 1.33655563e-01f, 4.43205349e-02f, 2.18127623e-01f, -2.66340841e-02f, -1.42728426e-02f,
  -2.16096193e-01f, -2.16405205e-02f, -2.13381559e-01f, -1.64315119e-01f, 2.30836764e-01f, 1.54075131e-01f, 3.97302471e-02f, 2.28481367e-01f, 3.34384114e-01f, 1.07453547e-01f,
  3.81622940e-01f, 2.66298145e-01f, -1.68223366e-01f, -7.10315164e-03f, -2.66336918e-01f, 8.75023939e-03f, -1.40664861e-01f, -4.25932929e-02f, -2.85193115e-01f, -9.94372070e-02f,
  -2.55057961e-01f, 2.21282780e-01f, -8.67384970e-02f, -5.08070737e-02f, -1.00920081e-01f, -5.26307300e-02f, 1.01538777e-01f, -4.11975943e-02f, 1.24342360e-01f, -4.35313076e-01f,
  3.25335145e-01f, 4.15243814e-03f, -1.78522110e-01f, -1.44855464e-02f, -1.04399145e-01f, 2.53202766e-01f, 1.89283922e-01f, 2.33489335e-01f, 3.35763305e-01f, -4.43828851e-01f,
  1.46408200e-01f, 1.74482673e-01f, -2.39473119e-01f, 6.24258369e-02f, 1.11567438e-01f, -5.49509563e-02f, 4.36393581e-02f, 1.09839126e-01f, -1.74664572e-01f, 4.86378856e-02f,
  -3.75573397e-01f, -2.50994802e-01f, 2.05400512e-01f, 1.52833506e-01f, -3.75046283e-02f, 1.35483474e-01f, -1.41057456e-02f, 1.06504560e-01f, 1.43719852e-01f, -2.58447319e-01f,
  5.69444187e-02f, 1.59393832e-01f, 2.62527376e-01f, -2.30375957e-02f, 2.64251322e-01f, 1.95150837e-01f, -3.50314640e-02f, -3.16462547e-01f, 2.10562989e-01f, 1.46561265e-01f,
  2.19003558e-01f, 1.17768295e-01f, -1.06952153e-01f, 1.64850622e-01f, -7.20649287e-02f, -4.06312436e-01f, 3.25631052e-02f, -6.22436926e-02f, -6.31318614e-02f, -4.68500070e-02f,
  -9.77982730e-02f, -1.35861993e-01f, 8.16786438e-02f, 3.86881866e-02f, 2.83727162e-02f, 2.55773067e-01f, -1.18047997e-01f, -2.03450531e-01f, -1.64564729e-01f, 2.07889885e-01f,
  -7.65625760e-03f, 3.30744497e-02f, 8.24068040e-02f, 2.33979508e-01f, 1.35144100e-01f, 2.56432388e-02f, 3.05550456e-01f, -1.87720165e-01f, 2.16348320e-01f, 2.12531358e-01f,
  2.52280653e-01f, -8.06705877e-02f, -7.83117935e-02f, -8.28207061e-02f, -1.73947159e-02f, -3.28543335e-02f, 1.15241721e-01f, 1.83156446e-01f, -9.53063965e-02f, -1.14551790e-01f,
  1.00083269e-01f, 2.28277370e-01f, 8.40051696e-02f, -1.21897571e-01f, -5.76298963e-03f, -4.27230060e-01f, -6.51352778e-02f, 2.22245187e-01f, -5.53501595e-04f, 2.30121121e-01f,
  -1.35025591e-01f, -1.69937298e-01f, 7.10489154e-02f, -6.60357848e-02f, 1.57376707e-01f, 1.76279217e-01f, -7.48435408e-02f, 1.51456922e-01f, 2.13388816e-01f, 3.00397694e-01f,
  2.29074240e-01f, -9.84425843e-02f, 4.90620025e-02f, -1.86668653e-02f, 4.62486297e-02f, -1.21479563e-01f, 3.64502594e-02f, -3.86820026e-02f, 1.35005284e-02f, -1.42392088e-02f,
  -1.65813327e-01f, 1.80256113e-01f, 8.32277462e-02f, -1.12059496e-01f, 8.36132392e-02f, -8.43646973e-02f, -7.66874384e-03f, 1.70504078e-01f, 8.91471878e-02f, -1.24430202e-01f,
  -1.52021125e-01f, 2.85410970e-01f, 1.56484127e-01f, -4.89847809e-02f, -9.92471576e-02f, 2.39268206e-02f, -2.51831710e-01f, 5.18916510e-02f, 2.56147925e-02f, 1.85617536e-01f,
  -1.98176643e-03f, 2.31638804e-01f, -1.66574419e-01f, -3.79449129e-01f, -5.70046231e-02f, -1.00915015e-01f, 2.35724539e-01f, -1.22051321e-01f, 1.20157383e-01f, -3.21405739e-01f,
  6.01787083e-02f, -8.10001567e-02f, -2.06635073e-01f, -6.45452067e-02f, -1.59785002e-02f, -2.20423892e-01f, -4.33809273e-02f, 3.57917733e-02f, 2.50672638e-01f, 2.57851899e-01f,
  -2.88755894e-01f, 1.62950009e-02f, -6.25061393e-02f, -4.36806411e-01f, -3.14181186e-02f, 7.78744742e-02f, -1.38965875e-01f, 1.35807410e-01f, -3.18252623e-01f, -6.04693592e-02f,
  -1.26624569e-01f, -4.39223945e-02f, -9.90342945e-02f, 8.02387949e-03f, -4.46679033e-02f, 7.20839873e-02f, 2.02675089e-02f, 2.33594012e-02f, -7.25335814e-03f, 4.03413028e-02f,
  6.95523620e-02f, 1.91540062e-01f, 2.89649367e-02f, -1.96651947e-02f, -5.69767728e-02f, 1.81520551e-01f, 2.19164580e-01f, -2.19108611e-01f, 1.85505077e-01f, 3.52213264e-01f,
  1.61771223e-01f, -1.04306929e-01f, 6.56827539e-02f, -7.00969920e-02f, 1.42157242e-01f, 1.47393569e-01f, 1.21725298e-01f, 1.65645808e-01f, -7.66759589e-02f, 1.57535657e-01f,
  1.98373258e-01f, 6.61622658e-02f, -2.00110190e-02f, -2.37005632e-02f, 1.77931339e-02f, 2.25690559e-01f, 4.77960818e-02f, -1.80704594e-01f, -2.86497533e-01f, -9.20101628e-02f,
  1.68501496e-01f, 7.14239255e-02f, -4.39932086e-02f, -1.84963673e-01f, -1.83621004e-01f, -1.17881261e-01f, 4.00335081e-02f, -2.82055795e-01f, 1.34188831e-01f, -2.07505822e-01f,
  2.31920540e-01f, 9.94350389e-03f, -1.33494079e-01f, -5.47013730e-02f, -4.79847379e-02f, -1.57912210e-01f, -4.21529301e-02f, -1.22072317e-01f, 1.12295553e-01f, 1.86065882e-01f,
  1.26486504e-02f, 1.75313100e-01f, 9.81645659e-02f, -9.69482213e-02f, -1.21246129e-01f, 3.32895853e-02f, -3.41073312e-02f, -9.27727446e-02f, -2.34556332e-01f, 2.74060398e-01f,
  5.22098616e-02f, -8.55369419e-02f, 1.13354124e-01f, -9.35927406e-02f, -1.20609000e-01f, -6.15126751e-02f, -7.42513314e-02f, -2.89992243e-01f, -4.17636000e-02f, 1.87681884e-01f,
  -9.55305547e-02f, -7.03744292e-02f, 3.32263857e-02f, -1.92971542e-01f, 1.30433276e-01f, -2.43976206e-01f, 7.18204901e-02f, 6.33700639e-02f, 1.58366654e-02f, 9.25108418e-02f,
  1.61798358e-01f, 6.88160881e-02f, -1.43791474e-02f, 2.09195554e-01f, -1.42947808e-01f, -2.40246147e-01f, -3.52778398e-02f, -5.27912006e-02f, 1.25721067e-01f, 1.40503850e-02f,
  1.11890741e-01f, -2.08396092e-01f, -8.90366435e-02f, -2.46779263e-01f, -4.01190035e-02f, -1.69528529e-01f, 1.15896195e-01f, -3.87204140e-01f, -1.47241354e-01f, -1.53928429e-01f,
  1.17796594e-02f, -3.23085308e-01f, -6.59318492e-02f, -2.17141867e-01f, -8.77573714e-02f, 8.03041682e-02f, 2.27148339e-01f, 1.13065422e-01f, -3.07251304e-01f, -4.61270437e-02f,
  -1.87736779e-01f, -2.52190799e-01f, 2.07847610e-01f, 2.41736770e-01f, -5.85535401e-03f, 2.21038342e-01f, -3.37599546e-01f, -7.60475621e-02f, -2.24262848e-01f, -9.85075682e-02f,
  -5.70835695e-02f, -1.35259196e-01f, -1.55263513e-01f, 1.67189121e-01f, 1.14760794e-01f, 6.28211200e-02f, 1.06210569e-02f, 2.47693822e-01f, 2.86472142e-01f, -5.03260046e-02f,
  -3.96163017e-02f, -1.70910716e-01f, -3.09260547e-01f, 2.85906821e-01f, -1.95695534e-01f, -1.33291751e-01f, 1.94217563e-01f, 1.45480424e-01f, 2.91433558e-02f, -1.98482528e-01f,
  1.12855367e-01f, -1.50776789e-01f, -1.00973688e-01f, 2.05195665e-01f, -1.18666090e-01f, 4.17676866e-02f, 1.65933788e-01f, 3.67796384e-02f, 9.77143943e-02f, 3.27262312e-01f,
  2.26386860e-02f, 2.16688499e-01f, -9.69353914e-02f, -9.67875421e-02f, -8.94167200e-02f, -2.65431050e-02f, 1.16415001e-01f, -1.12734430e-01f, -7.96423061e-04f, 1.84768617e-01f,
  1.10913850e-01f, 3.46660279e-02f, 5.28295934e-02f, 1.07718304e-01f, -1.83425158e-01f, 1.09607890e-01f, -8.96875188e-03f, 5.96228167e-02f, 4.72904854e-02f, 6.37796149e-02f,
  -3.02080847e-02f, 2.33069565e-02f, 1.29002351e-02f, 1.64088041e-01f, -8.17836449e-03f, -2.90873438e-01f, -8.45268816e-02f, -1.56470791e-01f, 2.46339887e-01f, -1.08793341e-01f,
  -2.15848222e-01f, 2.66301841e-01f, 5.07998355e-02f, -3.67344804e-02f, 1.12816922e-01f, 2.78976429e-02f, 1.77421525e-01f, -1.52377754e-01f, 3.68281230e-02f, -7.01550990e-02f,
  1.09060183e-02f, -1.59903556e-01f, 2.90729880e-01f, 1.86546668e-01f, -5.77495284e-02f, 1.48404688e-01f, -2.28960931e-01f, 1.81779750e-02f, 4.86962795e-02f, 1.36358934e-02f,
  1.66286126e-01f, -9.43370089e-02f, 1.56179368e-01f, 3.00417423e-01f, -8.44763815e-02f, 3.33923548e-01f, -2.27678671e-01f, 1.74285278e-01f, -5.64071722e-02f, 5.49590290e-02f,
  -8.10072646e-02f, 4.98779640e-02f, 1.53131653e-02f, 5.03083915e-02f, -7.22860694e-02f, -1.32605657e-02f, 8.43690410e-02f, 2.77773678e-01f, -2.65636206e-01f, -4.23116237e-02f,
  -7.28681451e-03f, -3.34658846e-02f, 1.70994669e-01f, -2.78883018e-02f, 1.49528772e-01f, -8.40661451e-02f, -9.03350562e-02f, 1.58691779e-01f, -1.52587071e-01f, -1.49057761e-01f,
  2.04609916e-01f, 3.01340576e-02f, -1.09014504e-01f, 8.90049860e-02f, -6.24996424e-02f, -3.58377218e-01f, -1.41665325e-01f, -7.71386325e-02f, -1.82945549e-01f, 3.48768741e-01f,
  -4.45695072e-02f, -1.52185842e-01f, 4.91803251e-02f, -3.97394225e-02f, -6.65230751e-02f, -4.51034717e-02f, 1.61856458e-01f, 1.47375524e-01f, 1.88663006e-01f, 3.09050202e-01f,
  7.71620572e-02f, 2.23513260e-01f, 3.78797233e-01f, 2.36168697e-01f, 5.48326261e-02f, 9.10639912e-02f, 2.07813203e-01f, -7.11354911e-02f, 2.41191730e-01f, 4.05758709e-01f,
  -2.41772518e-01f, -2.52451003e-01f, 5.68147898e-02f, -2.42681265e-01f, 8.67623687e-02f, -3.64357419e-02f, -9.86180678e-02f, -1.81540623e-01f, -2.97568738e-01f, 4.10217009e-02f,
  1.18576623e-01f, 7.53208622e-02f, 1.68286089e-03f, 6.72259852e-02f, -3.15542109e-02f, -2.80717641e-01f, 8.04296508e-02f, 1.87059447e-01f, 2.14892313e-01f, 2.59101659e-01f,
  4.40510511e-02f, 1.91995457e-01f, 1.07346270e-02f, 1.51430354e-01f, -2.22143680e-02f, 8.59824270e-02f, 2.29809180e-01f, -1.95827827e-01f, -3.68189998e-02f, 1.58157915e-01f,
  1.82374373e-01f, -9.38310921e-02f, -2.47208420e-02f, -8.11824277e-02f, 1.37811884e-01f, -1.23289421e-01f, -9.53413099e-02f, -2.58339524e-01f, -6.59297556e-02f, -3.95607620e-01f,
  -7.60370642e-02f, 2.28868410e-01f, 1.82835296e-01f, -1.58501983e-01f, -1.67304594e-02f, 1.27132252e-01f, -1.15729891e-01f, -2.91436464e-01f, -3.47081795e-02f, 2.75578976e-01f,
  -4.01996262e-02f, 9.58838835e-02f, 8.50084051e-02f, -2.23612227e-02f, -7.03293607e-02f, -2.15339079e-01f, -7.64795914e-02f, 4.82431389e-02f, 1.03548504e-01f, -1.93668619e-01f,
  8.08423683e-02f, -6.99500144e-02f, -2.85440851e-02f, 2.70741880e-01f, -4.18254100e-02f, 2.61296034e-01f, -2.35717408e-02f, 2.30577029e-02f, 1.45639449e-01f, -8.55761915e-02f,
  -8.24119058e-03f, -5.96903823e-02f, -8.13850760e-02f, -1.46991193e-01f, 4.29107435e-02f, 1.26402885e-01f, 6.88883886e-02f, -6.31101355e-02f, 6.43396899e-02f, -8.89591035e-03f,
  1.17447980e-01f, -2.06285506e-01f, 5.88735603e-02f, -8.26882850e-03f, -1.15886992e-02f, 9.84144062e-02f, -1.85379893e-01f, 8.49095359e-02f, -2.17834488e-01f, 2.42649227e-01f,
  8.53572339e-02f, 4.74121124e-02f, 2.30585765e-02f, 1.68994013e-02f, -1.84022799e-01f, -8.34069625e-02f, 7.56162629e-02f, 4.04996090e-02f, 2.62068510e-02f, 2.20739052e-01f,
  -2.72565454e-01f, 2.14929178e-01f, 1.57478526e-01f, 4.94573236e-01f, 1.71246473e-02f, -1.90349612e-02f, 3.75219900e-03f, -2.48484194e-01f, 1.40328273e-01f, 3.52075189e-01f,
  8.15831590e-03f, 1.66944742e-01f, 6.64327815e-02f, 1.29752923e-02f, -1.70192178e-02f, -5.99984527e-02f, 1.27257928e-01f, -1.16876356e-01f, -3.55730563e-01f, -4.53449860e-02f,
  1.06472030e-01f, 2.52962053e-01f, 4.85623591e-02f, 5.89822493e-02f, -5.08471467e-02f, 7.61017203e-03f, 5.82769960e-02f, 9.99424513e-03f, 2.62186170e-01f, -1.73655316e-01f,
  -6.14493452e-02f, -1.52989579e-02f, -4.03270759e-02f, -1.01683311e-01f, -7.54587203e-02f, -3.75624716e-01f, 1.78354383e-02f, 1.62887350e-01f, 3.45468111e-02f, -1.11527741e-02f,
  2.80823886e-01f, 2.87577659e-01f, -1.01759195e-01f, 1.88106131e-02f, 1.15273304e-01f, -1.18153222e-01f, 1.63320720e-01f, -7.67159089e-03f, 1.99774399e-01f, 1.10031702e-01f,
  2.64316350e-01f, 2.46935487e-01f, 3.12408090e-01f, 5.31769432e-02f, -1.88735530e-01f, -6.07703365e-02f, -5.78667037e-02f, -1.48933917e-01f, 9.31321159e-02f, 1.67712480e-01f,
  7.66779482e-02f, -5.85413389e-02f, -4.14882191e-02f, -2.74526030e-02f, 8.28825682e-02f, 1.21890870e-03f, 1.97432950e-01f, -3.30760390e-01f, 1.45710520e-02f, 2.61016637e-01f,
  2.41546184e-01f, 1.45477736e-02f, 3.69182527e-02f, -2.63511203e-04f, -1.46172151e-01f, 1.99702755e-01f, 2.98982173e-01f, -1.08486954e-02f, 9.14056450e-02f, -5.45088984e-02f,
  1.48927391e-01f, -1.49223492e-01f, 2.63342738e-01f, 4.43299301e-02f, 1.14630260e-01f, 1.78895354e-01f, 5.61568104e-02f, -3.80335636e-02f, 1.68816805e-01f, -2.15115678e-02f,
  -8.92677456e-02f, 2.68282652e-01f, -1.78108275e-01f, 2.86818177e-01f, 1.97690412e-01f, -2.17206538e-01f, 3.18282306e-01f, -1.57071680e-01f, -7.70681947e-02f, 6.39960691e-02f,
  8.60446543e-02f, -1.65554360e-01f, -1.71833023e-01f, 2.06477761e-01f, 5.56116831e-03f, 4.57395203e-02f, -2.08463579e-01f, 1.33904934e-01f, -1.61445379e-01f, -1.02371320e-01f,
  5.09131476e-02f, 5.29798046e-02f, -1.04442529e-01f, 3.08338881e-01f, 8.05832446e-02f, -1.44113719e-01f, 1.70236956e-02f, -1.59105405e-01f, 3.57257366e-01f, -7.86347762e-02f,
  1.06116936e-01f, -1.70328438e-01f, 5.55309579e-02f, -1.27151862e-01f, -1.20613657e-01f, -4.81250770e-02f, -5.99878989e-02f, -1.95224747e-01f, -2.92087525e-01f, 2.10318089e-01f,
  2.22705469e-01f, 2.06977382e-01f, -3.38578850e-01f, 1.55256391e-01f, -6.01370558e-02f, -3.34183276e-01f, 7.68453851e-02f, 1.01545677e-01f, -3.27353239e-01f, 2.84671754e-01f,
  -1.49150386e-01f, 3.83507460e-02f, -8.26125965e-02f, 6.19628020e-02f, 1.83952540e-01f, -1.37077183e-01f, -2.04060301e-01f, 8.97199959e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.91294193e-01f, -7.05280295e-03f, 2.18294069e-01f, 3.52657773e-02f, 1.19751683e-02f, -5.23960544e-03f, 9.70477462e-02f, 1.04606882e-01f, 1.39353564e-02f, 7.28356019e-02f,
  1.98472351e-01f, 8.41786414e-02f, 2.43640482e-01f, 1.49292499e-01f, 1.05908334e-01f, -4.48186360e-02f, 1.82602540e-01f, 8.75822380e-02f, -1.24342181e-02f, 9.54992399e-02f,
  2.22972296e-02f, -1.50646092e-02f, 1.68553248e-01f, -5.77754192e-02f, 5.54593047e-03f, 7.05323517e-02f, 6.64563179e-02f, 2.48130202e-01f, 9.62189883e-02f, 9.35491920e-02f,
  1.68952551e-02f, 2.40362082e-02f, 1.93880677e-01f, 2.42907777e-01f, 3.17687958e-01f, 1.80546805e-01f, 2.03441843e-01f, 2.26347204e-02f, 1.16828620e-01f, 2.04655915e-01f,
  -1.35699678e-02f, 8.06996450e-02f, 2.24597067e-01f, 2.44513229e-02f, 1.19905248e-01f, 1.77279800e-01f, 2.05239683e-01f, 1.26772463e-01f, 8.25977623e-02f, 7.07696825e-02f,
  1.79855302e-01f, 5.40020084e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.31647864e-01f, -4.11233641e-02f, 1.46145537e-01f, -2.40194034e-02f, -2.76057243e-01f, 1.36339311e-02f, 1.91489130e-01f, 2.09754348e-01f, 1.86158583e-01f, -4.03925329e-02f,
  -2.16073155e-01f, -2.80997843e-01f, 2.51135826e-01f, -5.59307523e-02f, -1.02673359e-01f, 1.27571881e-01f, -7.36847147e-02f, 7.67710954e-02f, -1.68930758e-02f, -1.13329768e-01f,
  6.67378232e-02f, 7.31969327e-02f, 1.30282804e-01f, 1.82111815e-01f, -3.02900672e-01f, 7.87835866e-02f, -8.18985403e-02f, 2.94549149e-02f, -5.43195307e-02f, -1.73590723e-02f,
  1.81295931e-01f, 6.81826100e-02f, -2.96914652e-02f, 2.84462601e-01f, 2.02940926e-01f, 1.26266778e-01f, -3.47961783e-01f, -2.19792977e-01f, -2.00393468e-01f, 6.84869587e-02f,
  1.81295231e-01f, -1.79008290e-01f, -2.28173118e-02f, 1.21419176e-01f, -5.25618568e-02f, -3.16709816e-01f, -2.02034071e-01f, 1.78128704e-01f, -2.02487990e-01f, -2.21897840e-01f,
  -1.48270532e-01f, -5.79387732e-02f, -3.74831885e-01f, 2.37599853e-02f, 2.32890118e-02f, 3.38755369e-01f, -4.26033169e-01f, -3.84291485e-02f, -9.86133665e-02f, -1.59821033e-01f,
  -1.96702033e-01f, 3.77524039e-03f, 2.25561574e-01f, 7.37862512e-02f, 7.99193159e-02f, -1.48142502e-01f, -4.39066440e-02f, -1.07893139e-01f, -2.60853648e-01f, -3.72229330e-02f,
  3.64043489e-02f, -3.58551174e-01f, -2.85055935e-01f, -6.55847639e-02f, 2.76768237e-01f, 2.47107401e-01f, 1.59902871e-01f, -6.69783205e-02f, 1.95712209e-01f, 2.26473272e-01f,
  -2.18650967e-01f, 4.85356860e-02f, -3.23451191e-01f, -1.55778274e-01f, -3.16891037e-02f, -4.22964036e-01f, -3.43163192e-01f, -1.14199102e-01f, 7.15164095e-02f, 4.37538698e-02f,
  -3.13355118e-01f, -5.27745374e-02f, 8.05553421e-02f, -2.57337838e-01f, -2.99673766e-01f, -2.13181265e-02f, 7.61103258e-02f, 9.52626243e-02f, -3.99361670e-01f, -2.38338336e-01f,
  -1.88529834e-01f, -5.11186063e-01f, 2.38363087e-01f, 2.33033046e-01f, 9.90427285e-02f, 1.55428812e-01f, -5.90425789e-01f, -2.80937940e-01f, -1.68022141e-01f, -2.58017629e-01f,
  2.38303710e-02f, -1.55102104e-01f, -3.03373545e-01f, 2.24250421e-01f, 2.51825631e-01f, 1.78698301e-01f, -1.45928308e-01f, -8.26380327e-02f, 2.24254280e-01f, -1.31956488e-01f,
  -6.24641851e-02f, 1.16527610e-01f, 2.99822558e-02f, -5.09843454e-02f, -1.21699043e-01f, -1.00626476e-01f, 1.22789249e-01f, -3.06870848e-01f, 7.72949755e-02f, -5.12823872e-02f,
  2.40974069e-01f, 9.28037688e-02f, -1.35465235e-01f, 5.79885282e-02f, -2.68390357e-01f, -4.30795074e-01f, 5.73111288e-02f, -1.86757948e-02f, 1.92082971e-01f, -1.08295061e-01f,
  3.91592532e-02f, -3.34038407e-01f, -2.35359102e-01f, -4.25611436e-02f, -3.66896927e-01f, -2.61536866e-01f, 2.57196445e-02f, 2.34487444e-01f, -1.79879412e-01f, 2.11734340e-01f,
  -4.67746146e-02f, -2.21923754e-01f, 3.21878940e-02f, 3.50553274e-01f, 2.35008560e-02f, -1.21513493e-01f, -1.68587953e-01f, 8.36787075e-02f, -2.35374913e-01f, 2.42924988e-01f,
  -2.66204953e-01f, -2.68469512e-01f, -1.08918630e-01f, -3.93909961e-01f, -1.38830468e-01f, -1.87119991e-01f, 4.66112077e-01f, 1.46567509e-01f, -1.10537961e-01f, -3.97603571e-01f,
  3.20510209e-01f, -3.66745383e-01f, -1.43910751e-01f, 5.23968562e-02f, 9.59719568e-02f, -1.60686597e-01f, 2.56471664e-01f, -8.55490640e-02f, 1.61948085e-01f, -1.81039348e-01f,
  -3.47253889e-01f, -2.77876798e-02f, -6.88381270e-02f, 2.44209282e-02f, -2.09687531e-01f, -3.97197425e-01f, 2.50995100e-01f, 8.43849778e-02f, -1.99909091e-01f, 6.03705533e-02f,
  -4.12353277e-01f, -1.16816774e-01f, -1.78513110e-01f, 1.01874389e-01f, -6.19469658e-02f, -2.36180797e-02f, 1.07218876e-01f, 6.11444190e-02f, 3.49678844e-01f, 1.87787339e-01f,
  -5.66377677e-02f, 2.12955460e-01f, -3.42998862e-01f, 1.15148813e-01f, -1.68144666e-02f, 3.53627741e-01f, -3.02066207e-01f, -1.37834296e-01f, 1.50623560e-01f, 1.37167767e-01f,
  -2.49799177e-01f, -7.31108710e-02f, -1.65463671e-01f, 9.89126563e-02f, -6.75137788e-02f, -3.39730054e-01f, -3.96306276e-01f, -3.97768579e-02f, 1.30648941e-01f, -3.23667191e-02f,
  3.00892830e-01f, -1.99448586e-01f, 9.13388357e-02f, 8.04691985e-02f, -4.56192493e-02f, -1.06130339e-01f, 1.33292183e-01f, 2.77465545e-02f, -1.22179985e-01f, 1.17422946e-01f,
  1.00505985e-01f, -1.78430498e-01f, -1.64051339e-01f, -1.55404121e-01f, 9.35402140e-02f, 2.48973429e-01f, -3.13778877e-01f, -1.40989736e-01f, -3.65590632e-01f, -1.22147957e-02f,
  -6.03943914e-02f, -7.32220709e-02f, -1.23830989e-01f, -1.49305508e-01f, 1.09778173e-01f, 4.86459993e-02f, -4.47129071e-01f, -9.96284932e-02f, -2.88070500e-01f, -1.33472178e-02f,
  -1.35547921e-01f, -4.55811918e-01f, -4.45957221e-02f, 2.37325102e-01f, -2.17166081e-01f, -1.21574350e-01f, 2.00029165e-02f, -1.93454817e-01f, -3.71406198e-01f, 8.80034990e-04f,
  5.30338511e-02f, -1.11424059e-01f, -2.18298003e-01f, 2.01472372e-01f, 3.93832266e-01f, 3.34446937e-01f, 2.51761049e-01f, -1.78092405e-01f, 1.64952323e-01f, -2.11434916e-01f,
  1.76248863e-01f, -9.72925425e-02f, 1.97603822e-01f, 5.29057980e-02f, -4.90433648e-02f, 4.03232127e-02f, 1.86354682e-01f, 1.28161713e-01f, 1.55675635e-01f, -4.01437700e-01f,
  -1.13983862e-01f, -4.87138778e-01f, -3.21421504e-01f, -2.85769880e-01f, -1.13351457e-01f, 1.27205297e-01f, 1.74530700e-01f, 6.45032898e-02f, -2.40793929e-01f, -1.00647606e-01f,
  -4.93410267e-02f, 1.47823812e-02f, 1.98281258e-01f, 1.75460160e-01f, -1.75703719e-01f, -5.07146902e-02f, -1.71887666e-01f, -3.09126437e-01f, 3.51253971e-02f, -5.10766543e-02f,
  1.75521687e-01f, -6.92928657e-02f, -4.65997495e-02f, -1.82208061e-01f, 6.07190356e-02f, -2.98494428e-01f, -2.25549296e-01f, -2.72221684e-01f, 6.87280297e-02f, 1.92721561e-01f,
  -5.86060956e-02f, -1.62771821e-01f, 1.03291616e-01f, -9.66305807e-02f, -2.24705860e-01f, -2.44001076e-02f, 1.10346258e-01f, 6.42552897e-02f, 5.48696592e-02f, -1.78548858e-01f,
  3.88305187e-02f, 4.53315191e-02f, -1.81163345e-02f, 1.31007567e-01f, 6.33226708e-02f, 9.95148495e-02f, 3.47515382e-02f, 2.58255720e-01f, -1.72953129e-01f, -1.66346267e-01f,
  1.61051765e-01f, 2.16104444e-02f, -3.96565571e-02f, -2.72645772e-01f, 1.19662486e-01f, -2.17716783e-01f, -1.15780838e-01f, 2.02439249e-01f, 2.65597612e-01f, 1.69640049e-01f,
  -2.40164816e-01f, -2.20637739e-01f, -4.26029831e-01f, -2.75650293e-01f, -7.40101933e-02f, -3.16722721e-01f, -2.10593760e-01f, -1.04209639e-01f, -8.05615187e-02f, 3.08816642e-01f,
  -2.30314299e-01f, -1.34995565e-01f, -1.15608573e-01f, 3.58659923e-02f, -6.04189709e-02f, 1.65749773e-01f, 1.67827159e-01f, -4.40665036e-02f, 5.63380569e-02f, -1.91194251e-01f,
  1.37108669e-01f, -2.73690134e-01f, 5.58480285e-02f, 1.04306884e-01f, 1.36323601e-01f, 1.70949131e-01f, 2.06539840e-01f, 1.40285552e-01f, 9.10106464e-05f, -1.40370473e-01f,
  2.52869070e-01f, 1.11645594e-01f, -3.71871203e-01f, 2.44296476e-01f, 1.65475875e-01f, -2.64059752e-01f, -2.24078923e-01f, -1.69524491e-01f, 9.55138430e-02f, -8.91123563e-02f,
  3.33781809e-01f, -4.17177379e-01f, 1.43849432e-01f, 8.55217651e-02f, -3.13777506e-01f, -9.99436975e-02f, 1.66972708e-02f, 8.31817761e-02f, -4.39258106e-02f, -2.41957992e-01f,
  -1.15467377e-01f, 1.12042993e-01f, -3.17690134e-01f, 5.35415709e-02f, 8.20990205e-02f, 1.86890483e-01f, -1.97973043e-01f, -1.89189821e-01f, -2.04579249e-01f, 9.49315056e-02f,
  -1.22221269e-01f, 8.36564302e-02f, 1.20695770e-01f, 2.03950390e-01f, 1.01771757e-01f, 2.51870286e-02f, 5.08650169e-02f, 9.36932862e-02f, 6.09607436e-02f, 8.83099139e-02f,
  -1.81411672e-02f, 3.46957415e-01f, -2.98625559e-01f, 6.80720359e-02f, -1.13818273e-01f, -3.21814060e-01f, 1.28849372e-01f, -8.31346959e-02f, -1.88513830e-01f, -8.49743634e-02f,
  -3.92587453e-01f, -9.15845931e-02f, -3.73335063e-01f, 9.15147737e-02f, -3.68982226e-01f, -1.44536132e-02f, -3.46196711e-01f, -1.52800065e-02f, 1.29398480e-01f, 6.90028667e-02f,
  -5.82383908e-02f, -2.35656857e-01f, 1.66918069e-01f, 1.72834426e-01f, 1.87275931e-01f, -2.41405725e-01f, -2.25268006e-01f, -3.99236590e-01f, -3.36343765e-01f, 1.52796298e-01f,
  1.78043172e-01f, 1.98332459e-01f, -2.33150914e-01f, 1.78270608e-01f, -2.76211739e-01f, 1.29521772e-01f, 2.09274073e-03f, 1.25383571e-01f, -6.68934584e-02f, 3.93060744e-02f,
  6.09249361e-02f, -2.47404262e-01f, 8.63131657e-02f, -2.06081450e-01f, 1.49451017e-01f, -2.85946459e-01f, -3.24270390e-02f, 1.50921986e-01f, -2.60775805e-01f, 4.17357646e-02f,
  7.72931501e-02f, 2.69928992e-01f, 7.42320344e-02f, 3.68611217e-02f, -7.88238738e-03f, -2.58856386e-01f, -1.24929368e-01f, 1.09013639e-01f, 5.16895242e-02f, -2.20221847e-01f,
  2.63353400e-02f, 1.77631259e-01f, -9.46621448e-02f, 1.30341761e-02f, 1.35061398e-01f, -2.95226634e-01f, -3.43420684e-01f, -1.64995283e-01f, -5.64083606e-02f, -4.68339741e-01f,
  -1.83463993e-03f, -1.84551999e-02f, 3.36214334e-01f, -3.12365979e-01f, -1.28729314e-01f, -1.60273880e-01f, -8.33539739e-02f, 2.56385625e-04f, 1.37232557e-01f, -2.07913086e-01f,
  1.85601339e-01f, 3.89639735e-01f, -3.03766996e-01f, 3.51289399e-02f, -1.15591317e-01f, 3.45828868e-02f, -2.55618664e-03f, -3.03085119e-01f, -3.01574767e-01f, -1.44240782e-01f,
  8.02140608e-02f, -3.11959654e-01f, -7.33208731e-02f, 1.03075974e-01f, 9.39050391e-02f, 1.20343350e-01f, 1.11500315e-01f, -2.11535931e-01f, -1.64021164e-01f, 1.09478645e-01f,
  -2.91522235e-01f, -1.13478370e-01f, 4.28342493e-03f, 8.15650076e-02f, -7.01799691e-02f, -8.24112818e-02f, -3.29567976e-02f, 2.06105232e-01f, 1.64863646e-01f, 9.34107453e-02f,
  -9.84438732e-02f, -9.73102152e-02f, -3.25493008e-01f, -3.56671572e-01f, -1.84150919e-01f, 1.83236569e-01f, 1.03495888e-01f, -1.78900123e-01f, 8.53778720e-02f, -3.80322874e-01f,
  4.32499647e-02f, -2.04377308e-01f, 2.28162244e-01f, -1.25693470e-01f, -1.38331607e-01f, 1.27047464e-01f, 1.52466401e-01f, -1.27090707e-01f, 2.29246810e-01f, -2.03074083e-01f,
  1.44045770e-01f, -3.70513529e-01f, -1.15112759e-01f, -1.33431032e-01f, 2.36150652e-01f, -2.58292139e-01f, -1.65750101e-01f, -2.59197593e-01f, -1.61178976e-01f, -3.19766462e-01f,
  -2.06121370e-01f, -3.18768114e-01f, -2.51993626e-01f, 1.30975887e-01f, -1.01094671e-01f, -6.76617622e-02f, 2.97581971e-01f, 2.22699523e-01f, -1.48152694e-01f, 3.03563595e-01f,
  -2.73508012e-01f, 3.65770906e-01f, -1.18305936e-01f, 1.85920343e-01f, 6.46211654e-02f, -3.81872863e-01f, -7.12843463e-02f, 2.13682696e-01f, -4.39559594e-02f, -2.72575438e-01f,
  1.28274381e-01f, 7.75346085e-02f, 2.34480157e-01f, -3.10071260e-01f, -1.18628837e-01f, 1.45675316e-01f, 2.39760906e-01f, 1.75952867e-01f, 1.06623910e-01f, -4.72468324e-02f,
  5.12302443e-02f, 6.40835837e-02f, -2.51671940e-01f, -1.00309476e-01f, 3.57861489e-01f, 1.57515630e-01f, 1.40067071e-01f, 8.24107379e-02f, -5.15942216e-01f, -9.07410905e-02f,
  -1.57050982e-01f, 1.45435512e-01f, -5.24198294e-01f, -3.10490370e-01f, 4.58565801e-02f, -2.23484007e-03f, -2.73022532e-01f, 1.22708775e-01f, 1.65608987e-01f, 2.38171488e-01f,
  2.30649337e-01f, 4.53401916e-02f, 8.56851116e-02f, -6.83720937e-05f, -2.68629581e-01f, -1.31868348e-01f, -3.09697926e-01f, -1.37377292e-01f, -2.64339875e-02f, 7.18547553e-02f,
  1.42069653e-01f, -1.07605800e-01f, 3.03454190e-01f, 2.60649383e-01f, -3.57740402e-01f, 1.05480708e-01f, -9.96540040e-02f, -5.67875849e-03f, 7.42321312e-02f, -3.72590095e-01f,
  6.93964586e-02f, 1.61746457e-01f, 4.72714938e-02f, -3.02366644e-01f, 1.84189081e-01f, -1.13766506e-01f, -3.84187073e-01f, -2.53719538e-01f, 1.27083212e-01f, -1.79191396e-01f,
  1.06916159e-01f, -2.26629183e-01f, 7.68419206e-02f, -6.90288693e-02f, -1.55182570e-01f, 4.37273011e-02f, 1.06386960e-01f, -1.29543558e-01f, 3.24183144e-02f, -4.71766621e-01f,
  -8.99460539e-02f, 7.69487843e-02f, 9.98466983e-02f, -2.52469033e-01f, -1.17089011e-01f, 1.19724877e-01f, 1.80782363e-01f, 8.74285623e-02f, 1.71354100e-01f, -1.99077830e-01f,
  -2.10848510e-01f, -2.91758887e-02f, -4.06355530e-01f, -1.26457185e-01f, -1.10987484e-01f, -3.10347229e-01f, 1.55278459e-01f, 2.41498858e-01f, -2.96118259e-01f, -1.23297185e-01f,
  -2.10123926e-01f, -5.63969389e-02f, -4.30135727e-01f, 1.23451099e-01f, 3.54697406e-02f, 6.90128580e-02f, 1.73817612e-02f, -3.47888060e-02f, 2.99230337e-01f, -2.54072726e-01f,
  -4.09395933e-01f, 7.90638030e-02f, -3.09116095e-01f, 1.33318910e-02f, -3.61765504e-01f, 2.54303187e-01f, 1.90625653e-01f, 2.31719568e-01f, 2.32242957e-01f, -4.01204497e-01f,
  -3.70456696e-01f, 3.25400621e-01f, 1.66197672e-01f, 2.60813147e-01f, 1.38423175e-01f, -4.17470276e-01f, -4.27742958e-01f, -2.43479311e-01f, -7.43624866e-02f, 1.79828122e-01f,
  -1.79676503e-01f, -1.22074038e-01f, -2.89399207e-01f, 1.64295118e-02f, 3.61877382e-02f, 4.22938354e-02f, -2.28457972e-01f, -3.41507047e-02f, -4.69245762e-01f, 1.51211441e-01f,
  -3.37442160e-01f, -1.53138176e-01f, -4.14536178e-01f, -1.04677148e-01f, 4.98356260e-02f, -9.17392969e-02f, -8.81721359e-03f, -2.11651951e-01f, 1.18609844e-02f, -1.74282603e-02f,
  -6.41149282e-02f, -1.15146473e-01f, -2.27776747e-02f, -2.05302283e-01f, -1.70795158e-01f, 1.75097972e-01f, -2.23652989e-01f, 8.71863589e-02f, -2.07803696e-01f, -2.26438671e-01f,
  -1.01683937e-01f, 6.02010526e-02f, 1.69148639e-01f, -3.12178403e-01f, 2.21861631e-01f, -2.78734475e-01f, 3.81563231e-02f, 4.61557209e-02f, -6.05941564e-02f, 5.84368296e-02f,
  2.74526983e-01f, 1.50358856e-01f, 2.54239827e-01f, 3.21768850e-01f, -1.36679485e-01f, -2.56507993e-01f, -2.11098022e-03f, -5.64283133e-03f, 4.64664213e-02f, 1.11446390e-03f,
  1.18435919e-02f, 1.02562509e-01f, -8.99130180e-02f, -1.22248694e-01f, -2.47484550e-01f, 1.39856026e-01f, -7.20301494e-02f, -8.11389387e-02f, -3.96934658e-01f, 1.60572186e-01f,
  1.34621441e-01f, 2.91290253e-01f, -8.13212320e-02f, -4.36654925e-01f, 1.64756849e-01f, -1.30352110e-01f, 1.38695031e-01f, -2.53081977e-01f, -3.19545209e-01f, 1.66716561e-01f,
  2.10579932e-02f, 1.47001252e-01f, -9.69139114e-02f, -3.69727433e-01f, -7.69885927e-02f, 1.92819878e-01f, 1.25841305e-01f, 3.13466907e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.95309292e-02f, -5.35884090e-02f, 1.66274607e-01f, -1.32896760e-02f, 1.57022655e-01f, 7.53214136e-02f, 4.71371338e-02f, 3.58506292e-02f, -1.30732253e-01f, -6.33512288e-02f,
  -9.98884365e-02f, 4.68825735e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    