/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.09069097e-01f, 7.34532356e-01f, -3.78712147e-01f, 1.10547384e-02f, 9.39110443e-02f, 6.25370294e-02f, 3.36737752e-01f, 2.39183262e-01f, 1.66178625e-02f, 2.12071970e-01f,
  2.70762235e-01f, -1.34816915e-01f, -1.85164034e-01f, -2.30856851e-01f, -2.01219723e-01f, -1.09284103e-01f, -3.15611482e-01f, -5.92560351e-01f, -5.08930266e-01f, -1.37055637e-02f,
  4.16803267e-03f, -2.29794588e-02f, -2.66318442e-03f, -1.16993949e-01f, -4.49974388e-02f, -2.67599434e-01f, 4.04657163e-02f, -3.71745676e-02f, -3.21435146e-02f, -2.97060728e-01f,
  -2.99961656e-01f, 4.51339036e-01f, -2.03287765e-01f, 9.25768092e-02f, 1.58478189e-02f, -3.36899646e-02f, 5.97734004e-02f, -6.22316413e-02f, 7.76705742e-02f, -2.02428196e-02f,
  9.91519354e-03f, 1.08508825e-01f, -3.92410271e-02f, 1.25557240e-02f, 2.93751732e-02f, 1.01727642e-01f, 1.56622663e-01f, -1.01296343e-01f, -3.82119197e-07f, 1.22645497e-01f,
  6.25642464e-02f, 1.41331023e-02f, -5.83213978e-02f, 7.84712844e-03f, 1.58045851e-02f, -1.68415546e-01f, 7.37420656e-03f, -5.28509878e-02f, -1.36605650e-01f, -1.04996497e-02f,
  -2.10324168e-01f, -6.47810623e-02f, 6.41204743e-03f, 1.50021417e-02f, 4.71302047e-02f, 9.44609009e-03f, -6.85783848e-02f, 1.37333516e-02f, -4.63980157e-03f, 1.85081251e-02f,
  2.47340053e-02f, 7.75013771e-03f, -1.48626873e-02f, 3.35798077e-02f, -7.02354014e-02f, -2.68472126e-03f, -8.31528381e-02f, -3.88227962e-02f, -1.17646232e-02f, 6.26378208e-02f,
  -7.08843023e-02f, -1.36637241e-01f, 7.73330629e-02f, -4.86643240e-03f, -2.61648353e-02f, -1.47457317e-01f, -4.82521169e-02f, 5.10051176e-02f, 4.28723805e-02f, 1.30518596e-03f,
  1.34961814e-01f, 2.22490095e-02f, 5.82555076e-03f, -2.09204759e-02f, 4.61104922e-02f, 2.60639787e-02f, -1.51269473e-02f, -1.67616941e-02f, 4.57865112e-02f, 3.82298678e-02f,
  1.38208782e-02f, 4.92142551e-02f, 1.29526615e-01f, -1.77871790e-02f, 3.31816752e-03f, 3.84297483e-02f, 8.41810480e-02f, -1.52450278e-01f, -4.06021811e-02f, 3.27535607e-02f,
  4.99026552e-02f, -1.52262211e-01f, -1.33819640e-01f, -5.83696216e-02f, -5.86310998e-02f, -1.28556371e-01f, -1.23391397e-01f, -1.01439513e-01f, -1.33672148e-01f, 3.09830271e-02f,
  5.70689082e-01f, -6.52324408e-02f, 1.43716142e-01f, 1.06933482e-01f, 3.23374331e-01f, 3.86650324e-01f, 3.60634834e-01f, 6.93793073e-02f, -1.80188641e-02f, -5.20860963e-03f,
  6.74110791e-03f, -3.19650531e-01f, -3.80677730e-01f, -3.40543628e-01f, -1.32554412e-01f, -6.70221969e-02f, -2.15042252e-02f, -2.49400120e-02f, 1.42420352e-01f, 2.37976432e-01f,
  8.50814767e-03f, 1.12454265e-01f, 9.70012695e-02f, 8.46022516e-02f, -2.69765072e-02f, -1.85423046e-01f, -6.93404600e-02f, 9.19737853e-03f, -6.49294257e-02f, -1.85712919e-01f,
  3.95116173e-02f, 4.43681419e-01f, 1.58576846e-01f, 1.30734414e-01f, 1.65792838e-01f, 1.40784448e-02f, 1.47746548e-01f, 8.05289596e-02f, 7.65111670e-02f, -1.90151157e-04f,
  1.07981116e-01f, 1.19121067e-01f, 1.07348837e-01f, 6.42530248e-02f, 1.20016433e-01f, 1.37245595e-01f, 3.44577469e-02f, 8.61814767e-02f, 1.62256919e-02f, 8.58387947e-02f,
  -2.70046256e-02f, 2.18438789e-01f, 1.45309433e-01f, 5.63781969e-02f, 6.27955794e-02f, 1.29215166e-01f, 7.35053122e-02f, 1.02925882e-01f, 2.08053172e-01f, 6.27618209e-02f,
  3.07228267e-02f, -1.05787978e-01f, -8.45575556e-02f, -1.28420845e-01f, -1.35765791e-01f, -1.68822318e-01f, -3.19361053e-02f, -1.35957778e-01f, -1.01272941e-01f, -1.30764529e-01f,
  -1.55928954e-01f, -5.95805533e-02f, -7.70808011e-02f, -1.01613039e-02f, -1.78717464e-01f, -1.95784587e-02f, 7.73034850e-03f, -2.83337384e-01f, -1.56301513e-01f, -6.87504560e-02f,
  -1.20892100e-01f, -7.45021924e-02f, -1.31006300e-01f, -7.72619918e-02f, -8.72551501e-02f, -1.03101991e-01f, -9.92435887e-02f, -8.31568763e-02f, -9.74663496e-02f, 3.97050902e-02f,
  -1.20948769e-01f, 1.66121542e-01f, -1.79289542e-02f, 5.58648221e-02f, 1.44669265e-01f, -3.20535563e-02f, 3.51201706e-02f, 8.41346309e-02f, 6.74009770e-02f, 1.72077075e-01f,
  1.42260268e-01f, 5.78757897e-02f, 2.05069575e-02f, 5.83542064e-02f, 1.53880328e-01f, 1.47528742e-02f, 1.71107389e-02f, -4.27727289e-02f, 9.59269479e-02f, 7.24888891e-02f,
  -1.38010040e-01f, 2.88692862e-02f, 4.40442525e-02f, -2.23800391e-02f, 6.48174360e-02f, -6.07963477e-04f, -3.23531739e-02f, 4.53975461e-02f, 3.56475189e-02f, 4.82828170e-02f,
  4.74574268e-01f, -1.17533945e-01f, -6.24171421e-02f, 3.34857017e-01f, -2.74411887e-01f, -2.83708006e-01f, -3.06055516e-01f, -1.42575040e-01f, 6.27359003e-02f, -1.03395566e-01f,
  -2.04499692e-01f, -8.94544050e-02f, 1.07752845e-01f, 4.76981625e-02f, 1.74097151e-01f, 1.81205481e-01f, 3.46747041e-01f, 2.96334922e-01f, -3.88136762e-03f, -2.68801033e-01f,
  -9.27485973e-02f, 1.72766998e-01f, 2.39834800e-01f, 1.95839360e-01f, 2.62220018e-03f, -1.42198317e-02f, -1.89548340e-02f, 1.62284113e-02f, -5.29723652e-02f, 3.54757369e-01f,
  -2.74301559e-01f, 1.43866763e-01f, -9.28894058e-02f, -1.30609944e-02f, -1.19272225e-01f, 4.97452877e-02f, -5.68369217e-02f, 1.33117110e-01f, 2.48407908e-02f, 4.01391909e-02f,
  2.04275399e-02f, -2.02615149e-02f, 1.29751548e-01f, -2.48508481e-03f, 5.75751998e-02f, -4.62565646e-02f, 7.92169422e-02f, 1.53943166e-01f, 1.10623121e-01f, -5.56804799e-02f,
  3.41306664e-02f, 8.88272226e-02f, 4.38885354e-02f, -9.39850211e-02f, -3.81081104e-02f, 1.05272584e-01f, -6.96207061e-02f, -6.08539656e-02f, -4.98285666e-02f, -3.62342745e-02f,
  -3.43480445e-02f, -3.02487481e-02f, 2.98260562e-02f, -2.28225701e-02f, 7.45588765e-02f, 8.29490484e-04f, 3.97512913e-02f, 3.27750333e-02f, 4.30213986e-03f, 3.77132408e-02f,
  4.52430509e-02f, -1.38907386e-02f, 7.45327696e-02f, 6.71767741e-02f, -3.45358104e-02f, 1.17872572e-02f, -2.45004222e-02f, -3.62087153e-02f, 3.98045480e-02f, 5.55438995e-02f,
  5.41214868e-02f, -7.42956027e-02f, 1.26744350e-02f, 8.42058808e-02f, 8.84968881e-03f, 3.97301391e-02f, -3.77503447e-02f, 2.74534617e-02f, -1.15926936e-02f, -1.01201169e-01f,
  -1.67119429e-01f, -5.66827171e-02f, 1.48562044e-01f, 7.81544223e-02f, -8.44722986e-03f, -1.13715805e-01f, -3.29752937e-02f, 2.11851262e-02f, -9.54120047e-03f, -1.29512832e-01f,
  -1.47488773e-01f, -2.86733638e-02f, -1.38889579e-02f, -5.29490449e-02f, -2.69709043e-02f, -5.73170744e-02f, -2.66139978e-03f, 4.94759306e-02f, -1.00712396e-01f, -8.65437835e-02f,
  -9.47720781e-02f, -7.75787905e-02f, -9.90203768e-02f, -1.14572711e-01f, -1.04024410e-01f, -1.47865072e-01f, -2.35956043e-01f, -1.61888614e-01f, -1.11688353e-01f, -1.87037438e-01f,
  5.81534445e-01f, -2.35092267e-01f, -4.87431765e-01f, 2.78345853e-01f, 1.48705812e-03f, 8.89716446e-02f, -1.01281293e-01f, 1.76133484e-01f, 3.96331012e-01f, -6.65682787e-03f,
  1.12197839e-01f, 3.57382655e-01f, 6.05604649e-02f, 1.41933449e-02f, 2.75639035e-02f, -2.66007662e-01f, -3.32053095e-01f, -2.45891139e-01f, 9.91249532e-02f, 1.77836820e-01f,
  7.82607943e-02f, -1.13627072e-02f, 5.86925000e-02f, 1.48747116e-01f, 7.32154548e-02f, 1.49856821e-01f, -1.75555393e-01f, -4.87034842e-02f, -1.25015870e-01f, -3.08567613e-01f,
  -3.18845719e-01f, 1.24363497e-01f, 6.91167777e-03f, 6.24299496e-02f, -1.09483540e-01f, -7.37701124e-03f, -1.33221038e-02f, 5.27197197e-02f, 7.30433464e-02f, 4.88975272e-02f,
  8.97634868e-03f, 9.46570537e-04f, -3.30649340e-03f, -4.31830436e-02f, 4.69352044e-02f, 2.84672547e-02f, -2.11599395e-02f, 3.51372510e-02f, -2.83769723e-02f, 3.13831866e-02f,
  -1.11635253e-01f, -3.15352194e-02f, 3.12717445e-02f, 3.23324166e-02f, -7.84441363e-03f, -4.41311374e-02f, -1.12255894e-01f, -7.78786512e-03f, -2.49255989e-02f, 1.44595101e-01f,
  -7.83803090e-02f, -5.15479185e-02f, 3.43654864e-02f, 1.23514107e-03f, 5.11429878e-03f, 6.83648977e-03f, -4.27009426e-02f, -5.85267246e-02f, -3.24708549e-03f, -4.86730831e-03f,
  1.60976201e-02f, -5.51213659e-02f, 2.87226494e-02f, 3.54411416e-02f, 2.32708864e-02f, -1.92052741e-02f, -5.80484746e-03f, -3.78596894e-02f, -4.93672565e-02f, -2.51107533e-02f,
  -3.60599831e-02f, -6.70424253e-02f, -2.93903816e-02f, -8.33111722e-03f, -4.70600612e-02f, -6.56224266e-02f, -2.94333771e-02f, -1.50840748e-02f, 4.88143340e-02f, 3.70449424e-02f,
  4.43868697e-01f, -1.50887072e-01f, -9.13270935e-03f, 3.70281073e-03f, -2.64945030e-02f, 1.53390979e-02f, -8.60741269e-03f, -1.43981501e-02f, -6.64771274e-02f, -2.20891014e-02f,
  -2.94386651e-02f, 4.84258309e-02f, -8.79700333e-02f, 7.37807155e-02f, 2.68834960e-02f, 3.76657359e-02f, 4.47988324e-02f, 2.13733409e-02f, 7.84925520e-02f, -7.24726990e-02f,
  -1.78886519e-03f, 1.81185067e-01f, 1.70373306e-01f, 9.79968235e-02f, 5.55424765e-02f, 5.32267280e-02f, -7.75962546e-02f, 9.27194729e-02f, -1.32918110e-04f, 5.42605445e-02f,
  7.22772554e-02f, -7.38181919e-02f, -4.82542038e-01f, 5.24475500e-02f, -2.61463016e-01f, -3.31443965e-01f, -2.52549917e-01f, -1.83883328e-02f, 9.36983302e-02f, -2.12063655e-01f,
  -1.64048120e-01f, -2.61777788e-02f, 3.90171409e-02f, -2.40899473e-02f, -2.20311373e-01f, -2.61482209e-01f, -2.46641710e-01f, -2.71699607e-01f, -2.75709152e-01f, -1.23666286e-01f,
  -1.52106419e-01f, -8.51348117e-02f, 2.07455382e-02f, -1.79552846e-02f, 5.13533689e-03f, 3.76360081e-02f, -7.59308934e-02f, -7.70070823e-03f, -9.59514380e-02f, 3.69816497e-02f,
  -4.90821034e-01f, 5.84054664e-02f, -6.87167794e-02f, 8.16138368e-03f, -1.83530953e-02f, 4.84695435e-02f, -1.42069592e-03f, 3.35671008e-02f, 1.04601204e-01f, -5.14122657e-02f,
  -6.80285618e-02f, 6.68826774e-02f, 1.27131641e-01f, 5.41435666e-02f, -6.03945809e-04f, 5.40272705e-02f, 1.11823976e-01f, -1.40050109e-02f, 1.14090613e-03f, 3.98798957e-02f,
  5.72270975e-02f, -5.20265251e-02f, -6.21812493e-02f, -5.65671921e-03f, 9.80080366e-02f, 6.05778247e-02f, -1.07068429e-02f, 2.19996762e-03f, 1.71846580e-02f, 1.33427903e-01f,
  -2.00724706e-01f, -1.23215459e-01f, -8.49984065e-02f, 4.52656597e-02f, 1.15855522e-02f, 3.72376963e-02f, 4.51656431e-02f, -7.56874233e-02f, 1.82850962e-03f, 5.07211722e-02f,
  -4.68149632e-02f, -4.49342988e-02f, 3.23047154e-02f, 6.89235181e-02f, -1.53235067e-02f, 5.06583340e-02f, -3.11726108e-02f, -4.42892499e-02f, 5.83762638e-02f, 1.71346236e-02f,
  -8.76841974e-03f, 8.07093382e-02f, 2.54873559e-02f, 1.32086850e-03f, -6.07688092e-02f, -5.91330789e-02f, -2.94255326e-04f, 5.41145355e-02f, 6.22126320e-03f, 3.23267989e-02f,
  1.91948727e-01f, -9.41071939e-03f, 3.70972194e-02f, 1.95148084e-02f, -5.80902621e-02f, 1.36162981e-01f, 7.42787123e-02f, 1.46654144e-01f, 7.57994354e-02f, 2.18544211e-02f,
  2.11439990e-02f, 3.14178760e-04f, -1.78712849e-02f, 3.41257229e-02f, -1.34063540e-02f, 2.38070898e-02f, 6.67264238e-02f, -3.09212711e-02f, 1.02916425e-02f, 4.58154678e-02f,
  6.73415065e-02f, 2.65461393e-03f, 2.72036139e-02f, 6.09471537e-02f, 1.00464197e-02f, -4.88288291e-02f, -1.66901369e-02f, -5.71701955e-03f, -3.26711941e-03f, -3.63240056e-02f,
  6.44335210e-01f, -5.75914145e-01f, -2.77286530e-01f, 2.52933413e-01f, -9.57653741e-04f, -8.55724066e-02f, -3.44319314e-01f, 8.14077258e-02f, 1.94529414e-01f, -1.54037565e-01f,
  -5.11261560e-02f, 2.00444832e-01f, 1.60078898e-01f, 2.98504345e-02f, -5.72264865e-02f, -2.61556745e-01f, -3.53898257e-01f, -4.78619933e-02f, 4.17307287e-01f, 2.15704486e-01f,
  -2.80715432e-02f, 1.06484883e-01f, 1.90331563e-01f, 5.90930618e-02f, -1.55029595e-01f, 8.54617655e-02f, -2.84663737e-01f, -4.22264123e-03f, -3.13726306e-01f, -5.05896270e-01f,
  -9.15422067e-02f, -9.05503705e-03f, 3.34349535e-02f, -1.93254382e-04f, -6.07481487e-02f, 6.99073374e-02f, 6.52766451e-02f, 7.06349239e-02f, -1.55191182e-03f, 5.20419776e-02f,
  -7.26338848e-02f, -3.88613045e-02f, 7.41825476e-02f, -3.04585453e-02f, 4.95475158e-02f, 2.44068895e-02f, -2.82871220e-02f, -6.74936399e-02f, -3.26681696e-02f, -1.31536961e-01f,
  -1.86072633e-01f, -1.50923915e-02f, 6.90314407e-03f, 3.38222645e-02f, -2.79997233e-02f, -4.63026576e-02f, -1.06476754e-01f, 1.48338303e-02f, -8.20338279e-02f, -6.00352921e-02f,
  1.15452468e-01f, 5.56612872e-02f, -4.60811853e-02f, 3.83316949e-02f, 1.04477704e-01f, 5.57710603e-02f, 5.63128367e-02f, -8.11602920e-03f, 3.68549377e-02f, 7.72507340e-02f,
  -4.61713336e-02f, -4.72539030e-02f, 2.66439677e-03f, -5.38355485e-02f, -4.22353446e-02f, -3.13579440e-02f, -4.15993109e-02f, 3.26504260e-02f, 9.88559891e-03f, 4.41201329e-02f,
  4.03591245e-02f, -1.93409100e-02f, 4.34472933e-02f, -2.70160176e-02f, -5.49728163e-02f, -2.69273873e-02f, 8.16218257e-02f, 5.55137685e-03f, 7.79155418e-02f, -1.08527504e-01f,
  2.00117245e-01f, -1.14094526e-01f, 2.76764832e-03f, 1.05104044e-01f, -5.56616075e-02f, -8.45820829e-02f, -7.90583342e-02f, -2.83396877e-02f, -6.87361956e-02f, 4.53344360e-02f,
  4.05224115e-02f, 6.35565594e-02f, -6.86673447e-02f, -9.23426524e-02f, 1.29376471e-01f, 1.11739844e-01f, -6.16337452e-03f, 1.32614793e-02f, -3.28812674e-02f, -6.43816357e-03f,
  -1.21264823e-01f, 6.19769171e-02f, 1.38573185e-01f, 7.40946159e-02f, 9.84043032e-02f, 2.01763570e-01f, -2.24399921e-02f, 1.00121289e-01f, 1.04570128e-01f, 1.08172573e-01f,
  -4.18479919e-01f, -1.49081573e-01f, 2.81006753e-01f, -3.38820875e-01f, -5.95416501e-02f, 2.99204618e-01f, 1.94127619e-01f, -3.55684496e-02f, -1.68071836e-01f, -1.16543546e-01f,
  2.40232602e-01f, 2.09042296e-01f, 3.11669260e-01f, 2.72545516e-01f, 2.12471500e-01f, -3.39281932e-02f, -7.52509981e-02f, 1.76954549e-02f, 1.26267299e-01f, -1.11110307e-01f,
  -2.41526946e-01f, -2.84447253e-01f, -3.22051555e-01f, -7.85186663e-02f, -4.49672550e-01f, -2.01571256e-01f, -1.72718942e-01f, -2.87325054e-01f, -9.42833871e-02f, -5.51972389e-01f,
  1.78398341e-02f, 7.89180119e-03f, 1.81317136e-01f, -7.31210336e-02f, 2.31267326e-02f, -1.88746229e-02f, -4.76259328e-02f, -8.94775763e-02f, -6.76730135e-03f, -1.44094303e-02f,
  -3.58558930e-02f, 7.03787012e-03f, 6.78079426e-02f, -8.15819204e-02f, -1.12301353e-02f, 6.04871754e-03f, -1.77692808e-02f, -2.82965824e-02f, 2.88028102e-02f, 3.14548276e-02f,
  -6.78374767e-02f, -6.18868507e-02f, 3.32280509e-02f, 8.27756673e-02f, 5.92264906e-02f, 1.32321911e-02f, 3.39616388e-02f, -7.74535760e-02f, 8.90961811e-02f, -3.24938238e-01f,
  1.25649087e-02f, 5.81441782e-02f, 8.69388655e-02f, -9.88889262e-02f, 2.77478248e-03f, 2.92126872e-02f, -2.69974191e-02f, 3.61306742e-02f, -7.12125450e-02f, -4.83275689e-02f,
  -1.61044858e-02f, -1.84949413e-02f, -1.34185236e-02f, -1.63459197e-01f, -3.83895040e-02f, -1.77838933e-02f, -3.97488810e-02f, -1.29327341e-03f, 3.59981880e-02f, 2.15771645e-02f,
  1.93489678e-02f, -4.09679674e-03f, -2.25380436e-02f, -5.67153580e-02f, 1.05297901e-02f, 9.74169821e-02f, -7.40446895e-02f, -2.78963079e-03f, 6.70311898e-02f, -4.48570848e-02f,
  -1.79455519e-01f, 4.13351983e-01f, -1.40207246e-01f, 1.27992854e-02f, -3.53634655e-02f, 1.55146783e-02f, 9.07339752e-02f, 5.49094155e-02f, 6.82998896e-02f, 3.33717763e-02f,
  1.40913114e-01f, 7.32894018e-02f, 6.72408193e-02f, 5.35950204e-03f, 2.56826710e-02f, 6.79937229e-02f, 2.21806094e-02f, 3.40111740e-02f, -1.14173554e-02f, -2.60075722e-02f,
  -4.09449227e-02f, -1.05255015e-01f, 1.40509084e-02f, -2.75457301e-03f, -7.84761310e-02f, 1.69727821e-02f, -1.24031343e-02f, -5.68883754e-02f, 2.69556250e-02f, -3.92472059e-01f,
  -7.35655487e-01f, 2.78074890e-01f, 3.78319353e-01f, -1.50787324e-01f, 3.01187605e-01f, 3.65188390e-01f, 5.65014064e-01f, 1.62377626e-01f, 5.42751793e-03f, 2.03674823e-01f,
  2.10859999e-02f, -1.04402974e-01f, 1.02788042e-02f, -1.60426851e-02f, -1.12209870e-02f, 4.71794963e-01f, 3.50745857e-01f, 1.15958594e-01f, -3.28611881e-02f, 1.19762145e-01f,
  2.22701564e-01f, 6.62220269e-02f, -1.41187832e-01f, -3.81758511e-02f, 1.56733677e-01f, 1.39868930e-01f, 2.27944568e-01f, 4.09356644e-03f, 1.23595618e-01f, 2.09657103e-01f,
  5.52348010e-02f, -2.23706365e-01f, 1.09522298e-01f, -3.80215570e-02f, 1.26332089e-01f, 5.45477867e-02f, 1.95187643e-01f, 4.11643125e-02f, 2.21691150e-02f, 1.01934843e-01f,
  7.89333284e-02f, 8.30664933e-02f, 5.35707250e-02f, 1.09590814e-01f, 9.28187817e-02f, 7.55570978e-02f, 4.54807580e-02f, -3.38706635e-02f, 7.57264346e-02f, 3.81042212e-02f,
  8.54611024e-02f, 1.44779533e-01f, 1.25736237e-01f, 1.23670973e-01f, 2.45404150e-02f, 6.99407607e-02f, 1.17951460e-01f, -5.83795272e-02f, 2.53753345e-02f, 1.36862233e-01f,
  -1.09282784e-01f, -6.04722910e-02f, -5.31645343e-02f, -9.74477530e-02f, -9.08133537e-02f, -5.06572016e-02f, -2.31704637e-02f, -3.63400429e-02f, -5.59538752e-02f, 2.59601511e-03f,
  9.60294809e-03f, -1.49808094e-01f, 6.30240561e-03f, -8.97925273e-02f, 4.33276873e-03f, 1.50129078e-02f, -5.75774387e-02f, -1.32421255e-01f, -9.24500749e-02f, -1.16489328e-01f,
  -1.15248241e-01f, -1.03243813e-01f, -6.46224304e-04f, -1.38982479e-02f, -6.03895746e-02f, -1.94773488e-02f, -1.20902948e-01f, -6.12417683e-02f, -3.41079012e-02f, -8.38025361e-02f,
  1.67844534e-01f, -9.84279513e-02f, 7.48606250e-02f, 4.32576761e-02f, 1.35162354e-01f, 5.92651777e-02f, 2.75779217e-02f, 1.10439695e-01f, 1.10184602e-01f, -1.77394543e-02f,
  2.19186605e-03f, 5.12382537e-02f, 1.21690273e-01f, 1.35034010e-01f, 7.98660591e-02f, 9.68864262e-02f, 1.97003454e-01f, 7.07712397e-02f, 1.14434607e-01f, 6.88807070e-02f,
  8.75818133e-02f, 1.86341316e-01f, 2.18742266e-01f, 2.04911783e-01f, 1.53582897e-02f, 4.50566746e-02f, 2.59962499e-01f, 2.05378950e-01f, 1.60872236e-01f, 3.30974251e-01f,
  -2.92123586e-01f, -5.12620091e-01f, -6.95647523e-02f, -1.97524235e-01f, -1.24499157e-01f, -2.49888584e-01f, -5.31078577e-01f, -2.69185930e-01f, -3.91112786e-04f, -1.63307309e-01f,
  1.11316405e-02f, 1.23387583e-01f, 9.46514979e-02f, 1.63427934e-01f, 2.85612177e-02f, -1.55819759e-01f, 9.30807069e-02f, 1.50663257e-01f, 1.35505572e-01f, -5.14077349e-03f,
  -7.23994076e-02f, -1.87566146e-01f, 1.02286883e-01f, 8.12474117e-02f, 9.00627300e-02f, 8.14108029e-02f, 1.79697480e-02f, 3.13028954e-02f, 8.49240795e-02f, 4.12418783e-01f,
  5.11462949e-02f, -1.29178256e-01f, -6.12693764e-02f, 4.06817254e-03f, -5.41958213e-03f, 2.53309812e-02f, -2.36925874e-02f, 3.05207521e-02f, -1.84120294e-02f, -3.29869278e-02f,
  -1.91964873e-03f, 2.67715920e-02f, -4.13369723e-02f, 5.91754057e-02f, -1.12712406e-01f, -5.62209263e-02f, 1.59575883e-02f, 7.71646202e-02f, -3.86416540e-02f, 6.01493120e-02f,
  3.67905758e-02f, 5.15027121e-02f, -7.06068501e-02f, -3.26378904e-02f, -3.62894647e-02f, 7.95397460e-02f, -1.21244103e-01f, 1.12064980e-01f, -4.90787104e-02f, -7.10866526e-02f,
  3.10959667e-02f, 1.00317888e-01f, 1.12552255e-01f, 2.29706001e-02f, -3.88912414e-03f, 1.00733586e-01f, -9.31597222e-03f, 1.78726651e-02f, 6.44348189e-02f, 3.70858759e-02f,
  4.65556532e-02f, 9.20787733e-03f, 2.88093109e-02f, 1.98037941e-02f, 1.41169727e-01f, 1.82975624e-02f, 6.79002106e-02f, -1.70039255e-02f, 1.05786197e-01f, 1.40752569e-02f,
  -5.29830083e-02f, 6.10453598e-02f, -2.58108713e-02f, 4.78840843e-02f, 8.32867473e-02f, 1.27527351e-02f, 8.02470595e-02f, 5.83048239e-02f, -1.30195543e-02f, -1.16442405e-02f,
  -2.77491122e-01f, -1.19840100e-01f, 5.60087711e-02f, 9.40514077e-03f, -6.07122807e-03f, 1.52081428e-02f, -7.22525045e-02f, 3.04691643e-02f, -8.51738155e-02f, -7.06020072e-02f,
  -7.85041228e-02f, -6.12767786e-02f, -1.33824646e-01f, -3.15479077e-02f, -1.19027697e-01f, -7.11075915e-03f, -1.11823775e-01f, -6.87741814e-03f, 1.49068626e-04f, -3.63157354e-02f,
  -1.31019816e-01f, -7.54260570e-02f, -1.90966949e-01f, -2.67026424e-01f, -6.65619224e-02f, -1.60670072e-01f, -2.41721407e-01f, -1.04992419e-01f, -1.35301262e-01f, -3.92553002e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.07315488e-02f, -1.18213654e-01f, -1.48166478e+00f, 6.17322385e-01f, 4.54268605e-01f, -5.00175059e-01f, -8.71291757e-01f, -5.11071086e-01f, 2.27245554e-01f, 2.22797366e-03f,
  5.52333057e-01f, 9.68641937e-01f, 3.79065573e-01f, 1.82647273e-01f, -3.12497646e-01f, -7.20162511e-01f, -6.62974954e-01f, -6.62967980e-01f, -1.48662761e-01f, 5.97546518e-01f,
  7.79403031e-01f, 4.98026967e-01f, 8.70766640e-02f, -2.96819836e-01f, 3.56772035e-01f, 4.88201529e-01f, -2.75600970e-01f, 2.34841198e-01f, 2.20399797e-02f, -4.44339067e-02f,
  -5.83855622e-03f, -2.31449828e-01f, -4.78521809e-02f, 3.61270934e-01f, 1.34078383e-01f, -2.55014360e-01f, -8.02033842e-02f, -1.60847992e-01f, -8.73636454e-02f, -3.18131894e-01f,
  2.81864077e-01f, -2.11271197e-02f, 1.84069157e-01f, 1.53963551e-01f, 2.86223143e-02f, -1.83486357e-01f, -3.54290724e-01f, -5.29941976e-01f, -4.32032496e-01f, -1.77275985e-01f,
  6.12858534e-01f, 2.73987293e-01f, -6.05727196e-01f, -4.86643851e-01f, -2.22068772e-01f, 2.78194517e-01f, -3.42934370e-01f, -2.88574975e-02f, -6.03535652e-01f, -1.73549786e-01f,
  2.12463588e-01f, 2.04456896e-02f, 9.48100537e-03f, -5.59361093e-02f, 1.11770794e-01f, -1.60573181e-02f, -4.81572561e-02f, 1.06888972e-01f, 1.26172230e-02f, -7.25054666e-02f,
  -3.14710028e-02f, -3.60236205e-02f, -6.72901422e-02f, 6.99196532e-02f, 6.20175600e-02f, -1.13430634e-01f, -9.46666375e-02f, -6.73769787e-02f, -1.31288812e-01f, -2.71512233e-02f,
  1.56286165e-01f, -2.08664060e-01f, -5.64697646e-02f, -2.60096580e-01f, -4.00492772e-02f, -2.54087243e-02f, 1.28390163e-01f, 9.56167430e-02f, 2.82331526e-01f, -2.85253227e-02f,
  6.42999530e-01f, -2.68554688e-01f, 2.59559095e-01f, -1.09325476e-01f, 1.01326324e-01f, 1.36800945e-01f, -9.98156704e-03f, -1.10897385e-01f, 3.43803763e-02f, -1.08553484e-01f,
  4.37463671e-02f, -1.51033416e-01f, -4.49204370e-02f, -1.83386147e-01f, 3.17783579e-02f, 8.05521160e-02f, 4.09059554e-01f, 2.08050776e-02f, -2.20419541e-02f, -4.50122058e-02f,
  -1.76241547e-01f, -1.93726718e-02f, 2.79612780e-01f, -2.55218297e-01f, 1.92747071e-01f, 2.36705020e-01f, -9.09205377e-02f, 9.60373133e-02f, -3.24321359e-01f, 1.53903529e-01f,
  7.94524372e-01f, 1.21419676e-01f, -2.22937733e-01f, 3.36102784e-01f, 2.61359632e-01f, 4.67441767e-01f, 5.29449046e-01f, 5.13867021e-01f, 4.74594921e-01f, 3.07134330e-01f,
  3.09467524e-01f, 3.54947627e-01f, 3.68887722e-01f, 2.89818466e-01f, 2.12664694e-01f, 1.41131833e-01f, 2.65629310e-02f, -5.99508248e-02f, -3.59275565e-02f, -2.04502158e-02f,
  -1.03413537e-02f, -1.72318682e-01f, -2.40385070e-01f, -9.71394181e-02f, -1.61943108e-01f, -3.69620211e-02f, 1.38213607e-02f, -1.76288083e-01f, -2.73849100e-01f, -4.14804429e-01f,
  -8.89554620e-01f, -7.01185912e-02f, -5.20996414e-02f, 2.52853669e-02f, -1.06560953e-01f, 7.34279118e-03f, 4.31067087e-02f, -1.02867350e-01f, -7.83938840e-02f, -2.07848057e-01f,
  -7.55479857e-02f, 8.37812349e-02f, -4.19839956e-02f, 1.52585469e-03f, -2.11562559e-01f, -6.29645064e-02f, -1.78920552e-02f, 6.30422533e-02f, -6.42808601e-02f, 3.76283079e-02f,
  -2.79049948e-03f, -1.70442611e-02f, -5.70335649e-02f, -2.58773919e-02f, 1.72390535e-01f, 1.47462130e-01f, -1.19393095e-01f, 4.84237884e-04f, 9.10048932e-02f, 8.06035697e-02f,
  1.58768088e-01f, -9.29440483e-02f, -7.93957263e-02f, 1.15187101e-01f, 9.03410465e-02f, -1.97377518e-01f, -2.61889547e-01f, -7.61164501e-02f, 2.16765270e-01f, 4.47414070e-02f,
  -1.69151336e-01f, 6.51570484e-02f, 6.19110651e-02f, -1.38109863e-01f, -1.70788124e-01f, -4.65552695e-02f, -2.04132885e-01f, -1.57511562e-01f, -8.73896331e-02f, -1.37757324e-02f,
  -9.83296484e-02f, -2.87894607e-02f, -2.64296174e-01f, -1.99205965e-01f, -8.97776559e-02f, -8.58769491e-02f, 4.66925763e-02f, 8.63008052e-02f, 1.73135027e-01f, 3.96837527e-03f,
  -4.76800799e-01f, 1.77402750e-01f, -8.55644271e-02f, 1.57418877e-01f, -1.69532129e-03f, -9.91323292e-02f, 3.66670638e-02f, -2.16038421e-01f, -2.51105547e-01f, -1.73274606e-01f,
  -1.25301272e-01f, -1.78604037e-01f, -9.87178907e-02f, -1.52582154e-02f, 1.72993466e-02f, -1.10794418e-02f, -3.28494646e-02f, 5.83192706e-02f, -8.19747150e-02f, -4.86429520e-02f,
  -3.38521264e-02f, 1.82662413e-01f, -1.88803133e-02f, 7.99728706e-02f, 1.05356745e-01f, 9.39319655e-02f, -1.24469370e-01f, -1.20926075e-01f, 9.40382257e-02f, 9.82825607e-02f,
  5.57262719e-01f, -6.31936491e-02f, -5.39848328e-01f, 1.21580753e-02f, -3.71956140e-01f, -3.06069374e-01f, -1.50732502e-01f, 9.28471237e-02f, -8.79181772e-02f, -3.46455812e-01f,
  -1.09231949e-01f, 1.56883717e-01f, -1.04097212e-02f, -3.11278850e-02f, -8.56008604e-02f, -4.92037505e-01f, -7.73377478e-01f, -1.49657711e-01f, 3.06330532e-01f, 3.61382395e-01f,
  1.04819961e-01f, 1.91806018e-01f, 2.29884759e-01f, 3.98468152e-02f, -6.78031743e-02f, 1.33610755e-01f, -3.32856983e-01f, -2.17296526e-01f, -3.16317230e-01f, -5.00046968e-01f,
  3.76062512e-01f, 1.05878957e-01f, 2.36263752e-01f, 1.33414045e-01f, 1.27176136e-01f, 2.67402455e-02f, 2.05771059e-01f, 4.58023064e-02f, 4.17003483e-02f, 5.84556684e-02f,
  1.24070579e-02f, -1.34579793e-01f, 1.73604507e-02f, 3.47647853e-02f, 1.91490874e-01f, 1.34028360e-01f, 1.87451705e-01f, 1.88525971e-02f, -1.56014979e-01f, -8.19088072e-02f,
  -1.09733053e-01f, -1.37034923e-01f, 3.36894207e-02f, 1.09418325e-01f, -4.01975168e-03f, -3.33805336e-03f, 9.75985602e-02f, 9.81057882e-02f, -4.44198139e-02f, 2.24566609e-01f,
  -1.61295533e-01f, 9.31869373e-02f, 1.32841766e-01f, 4.34564389e-02f, 5.34667587e-03f, 1.67295471e-01f, 1.67461403e-03f, -7.48167699e-03f, -7.34947389e-03f, 1.92242280e-01f,
  1.90243460e-02f, -1.79402336e-01f, -1.96379870e-02f, 4.95488197e-03f, 1.47936642e-01f, -5.27264625e-02f, 1.46803632e-02f, 2.39950642e-01f, 5.81130711e-03f, -1.34200543e-01f,
  -1.26077473e-01f, 4.85193683e-03f, -5.89437261e-02f, 1.30820982e-02f, -1.41112044e-01f, -7.77831897e-02f, -1.21920839e-01f, -1.00819618e-01f, -8.51212293e-02f, -2.34879583e-01f,
  3.57189387e-01f, -3.68106574e-01f, 7.52297491e-02f, -1.34535804e-01f, -1.85123324e-01f, -4.53237556e-02f, 4.45872955e-02f, -9.83294919e-02f, -1.28885046e-01f, 4.09183018e-02f,
  3.19012217e-02f, 8.31546932e-02f, 1.12784788e-01f, 1.13159560e-01f, 7.90889785e-02f, 1.45525381e-01f, 7.40224570e-02f, -3.61929163e-02f, -2.03074455e-01f, -8.49982724e-02f,
  -7.65356198e-02f, -7.53733516e-02f, 9.30838883e-02f, 1.67507693e-01f, 5.67179844e-02f, -1.07182004e-01f, 2.19053507e-01f, 1.83731541e-01f, -3.18950787e-02f, 1.18163921e-01f,
  6.43593818e-02f, 9.11866367e-01f, -3.59825231e-02f, 2.03276500e-01f, 3.66844684e-01f, 2.94093430e-01f, 5.28500259e-01f, 1.05989136e-01f, -1.03378646e-01f, 4.08871435e-02f,
  3.34814452e-02f, -1.61557868e-01f, -7.30433911e-02f, -7.81363547e-02f, -2.42459085e-02f, 3.36624235e-01f, 3.18435311e-01f, 7.23134428e-02f, -3.24931860e-01f, 5.07856421e-02f,
  2.96492994e-01f, 1.90823525e-01f, -1.56273305e-01f, -4.18522116e-03f, 3.47949833e-01f, -1.42939359e-01f, -1.88256111e-02f, 3.53988767e-01f, 3.14235628e-01f, 5.49121380e-01f,
  -1.25109538e-01f, 3.46766770e-01f, -8.79998446e-01f, -9.76536423e-02f, 1.41471643e-02f, -1.03257507e-01f, 1.44936573e-02f, -3.33156377e-01f, 2.75680795e-02f, -2.59041905e-01f,
  2.25206524e-01f, 2.24581614e-01f, 2.78854996e-01f, 2.23626807e-01f, 5.73976003e-02f, -8.37341547e-02f, 1.46402672e-01f, -5.35746217e-02f, -2.60182738e-01f, -1.60327852e-01f,
  4.68440861e-01f, 2.79169798e-01f, -2.81037800e-02f, -1.99511364e-01f, -1.38089299e-01f, -5.16268432e-01f, -1.08401649e-01f, -2.98786405e-02f, -4.21475023e-01f, -1.05215617e-01f,
  -3.71993072e-02f, 1.37169063e-01f, 1.48530081e-01f, 1.12537980e-01f, 2.08694085e-01f, 7.52831846e-02f, -2.73603145e-02f, 1.00966178e-01f, 1.90491721e-01f, 2.84135610e-01f,
  -7.40333349e-02f, -3.72116148e-01f, -2.57411718e-01f, -3.02097321e-01f, -2.77350068e-01f, 7.61985183e-02f, 1.33847862e-01f, -5.73214050e-03f, 2.15681028e-02f, -1.46471381e-01f,
  -1.93495117e-02f, -7.52992406e-02f, -1.62614927e-01f, 5.00152223e-02f, -3.30855221e-01f, -2.26113826e-01f, -2.23033234e-01f, -1.39317602e-01f, -4.91768830e-02f, 6.65608644e-02f,
  -6.07443035e-01f, -4.63032126e-01f, -4.40110028e-01f, 2.81186134e-01f, 9.05351862e-02f, -9.04512107e-02f, 1.09734051e-01f, -7.73513839e-02f, 2.54917711e-01f, -2.91848123e-01f,
  1.12662073e-02f, -1.62636161e-01f, 8.23396724e-03f, -5.67280389e-02f, -4.37105268e-01f, -3.47680986e-01f, 1.44597560e-01f, 1.23884387e-01f, -1.42475203e-01f, -1.49335146e-01f,
  1.71603814e-01f, -3.68738413e-01f, -7.30402946e-01f, -4.98337477e-01f, -3.23690087e-01f, -1.03583419e+00f, -3.53819221e-01f, -4.49346274e-01f, -5.93038082e-01f, -4.68937188e-01f,
  -1.38772398e-01f, 1.15700233e+00f, -7.69056082e-01f, 1.53123215e-02f, -7.11958349e-01f, -7.20712125e-01f, 4.16198730e-01f, 2.15442151e-01f, 8.64651054e-02f, 7.92493343e-01f,
  3.17340851e-01f, -7.68286765e-01f, -4.71806467e-01f, -5.34015119e-01f, -3.84527147e-01f, 4.51269358e-01f, 9.37365294e-02f, -1.12311077e+00f, -1.51272655e+00f, -9.22047794e-01f,
  -4.22057837e-01f, -3.19041312e-01f, -3.59181404e-01f, -3.80067408e-01f, 1.88720793e-01f, -4.38835919e-01f, 2.98264146e-01f, -2.52532244e-01f, -9.87388846e-03f, -3.32788229e-02f,
  -7.73203075e-02f, -2.35614911e-01f, -5.46543360e-01f, -1.97638124e-02f, 6.07763231e-03f, -9.27545503e-03f, -1.31277531e-01f, -2.25208655e-01f, -2.59798095e-02f, 1.62969202e-01f,
  -2.97095686e-01f, -1.61291644e-01f, -3.89418542e-01f, -2.30841368e-01f, -9.40154940e-02f, -1.98921755e-01f, -5.18543795e-02f, -3.19265664e-01f, -2.07691520e-01f, 1.70440748e-01f,
  -6.69141635e-02f, -5.88651061e-01f, -3.56885165e-01f, 1.81179926e-01f, -3.79105151e-01f, -5.52429199e-01f, 1.00434996e-01f, -3.29596400e-01f, -3.58822763e-01f, 6.86505616e-01f,
  2.99648851e-01f, 5.49674854e-02f, -6.04736507e-02f, -5.37334941e-03f, 3.03185165e-01f, 6.80503855e-03f, 8.55179578e-02f, 3.68699133e-02f, 2.79509462e-02f, -1.71796139e-02f,
  5.72324544e-02f, 1.47482738e-01f, -1.64416030e-01f, -7.68376142e-02f, -1.08947769e-01f, 5.78924874e-03f, 1.15573816e-01f, 3.65976334e-01f, -5.91648221e-02f, 8.62263814e-02f,
  -1.79159954e-01f, 2.53091957e-02f, -2.57381145e-02f, 1.45835713e-01f, 3.86922471e-02f, -3.74669745e-03f, -1.03810214e-01f, 3.26390639e-02f, -9.12607759e-02f, -1.81941292e-03f,
  4.90050793e-01f, -2.36345902e-01f, 1.74896285e-01f, 4.31080163e-03f, -1.67091116e-01f, -4.04827707e-02f, 7.12240264e-02f, 2.78350681e-01f, -3.81502584e-02f, -1.71869218e-01f,
  -3.08562100e-01f, 5.65608032e-02f, 1.06957130e-01f, 2.83536851e-01f, -2.48606250e-01f, -2.06075594e-01f, 3.10793728e-01f, -1.32203132e-01f, -1.62649974e-01f, 1.69294581e-01f,
  3.71694922e-01f, 8.04767665e-03f, 3.38558503e-03f, 2.45689571e-01f, -1.96515396e-01f, -3.74807686e-01f, 1.50212631e-01f, 5.13905436e-02f, -3.59313190e-01f, 1.01658213e+00f,
  -8.74365807e-01f, -1.63587555e-01f, 2.67339163e-02f, 3.35132688e-01f, 3.91875476e-01f, 3.82790923e-01f, 3.78503203e-01f, 1.31084636e-01f, 2.03751847e-01f, 7.13416189e-02f,
  -1.28124282e-02f, 3.59131545e-01f, 4.69523370e-01f, 2.76102990e-01f, 2.69913822e-01f, 4.68966454e-01f, 4.11789089e-01f, -4.83671622e-03f, -4.42206003e-02f, 3.71180698e-02f,
  2.05655023e-01f, -3.78315523e-02f, -6.21769011e-01f, -8.17084778e-03f, 7.45249093e-02f, 4.45817798e-01f, 7.64576793e-02f, -1.59571275e-01f, -8.28756467e-02f, 1.55255467e-01f,
  1.13382131e-01f, -5.93809187e-01f, 3.08442444e-01f, -4.47931215e-02f, -2.66660839e-01f, -2.76036680e-01f, 6.48336709e-02f, -1.94839150e-01f, -1.45084739e-01f, 9.19972286e-02f,
  -7.75412545e-02f, -1.44944146e-01f, 1.88136455e-02f, -1.39871731e-01f, -1.43662229e-01f, -1.65839776e-01f, -3.35974604e-01f, -8.32759440e-02f, 1.65316269e-01f, -4.62442823e-02f,
  2.59211138e-02f, -2.51503110e-01f, -9.15655680e-03f, 3.00717652e-01f, -2.51929462e-03f, 9.31197479e-02f, -1.10164583e-01f, -1.34107634e-01f, -3.72091085e-02f, -3.10971756e-02f,
  1.55033544e-01f, 1.74115211e-01f, 1.57888204e-01f, 5.96599840e-02f, 3.74896973e-02f, -5.51796295e-02f, 1.55950680e-01f, 1.63751006e-01f, 1.17982835e-01f, -2.76442021e-02f,
  1.35659501e-01f, 2.51924753e-01f, 1.08095966e-01f, 8.43994990e-02f, 2.72709727e-01f, 6.64284080e-03f, -9.61983576e-02f, 7.61317611e-02f, -1.50135368e-01f, -5.10520721e-03f,
  -3.72294970e-02f, -5.06756231e-02f, -2.88988233e-01f, -1.06950384e-02f, -1.01897873e-01f, 2.29420679e-04f, 9.85618308e-02f, 3.30774598e-02f, -1.34720966e-01f, -1.15319595e-01f,
  6.39803231e-01f, 4.57215048e-02f, 2.47343779e-01f, 5.29674850e-02f, -1.72059461e-01f, -3.90462250e-01f, 2.06064269e-01f, -1.40988275e-01f, -4.30739038e-02f, 1.12306595e-01f,
  -1.22936964e-01f, -2.24218979e-01f, -2.78437920e-02f, 4.03439580e-03f, 1.03652356e-02f, 7.28303893e-03f, -1.92293629e-01f, 1.36658207e-01f, 1.54433725e-02f, -1.92563441e-02f,
  -8.12997296e-02f, 1.03223018e-01f, 2.97095865e-01f, 2.61102915e-01f, 6.91141337e-02f, 2.12056547e-01f, 1.90065965e-01f, 1.20216142e-02f, 9.04535800e-02f, 1.69185460e-01f,
  -1.23979485e+00f, -8.12618434e-01f, -7.94239044e-02f, -1.51789224e+00f, -6.48598373e-01f, 1.98771402e-01f, 3.72140795e-01f, -3.59288305e-01f, -7.54853904e-01f, -4.20764051e-02f,
  1.03538558e-01f, 2.13109419e-01f, 1.67165130e-01f, 2.48044059e-01f, 3.52301121e-01f, 1.41641051e-01f, -3.51249844e-01f, 2.65407306e-03f, 4.69084144e-01f, 2.14359969e-01f,
  4.15036231e-02f, -7.06869841e-01f, -7.78991640e-01f, -5.71055233e-01f, -6.95981443e-01f, 5.49622625e-02f, -4.28284585e-01f, -6.51443124e-01f, -7.98420608e-02f, -6.47292972e-01f,
  8.95063281e-01f, -3.53064954e-01f, 1.11624561e-01f, -2.63232917e-01f, -3.15384269e-01f, -1.35776311e-01f, -5.89041710e-02f, -3.43970507e-01f, -4.86853272e-02f, -1.45333335e-01f,
  -2.38822073e-01f, -9.54408646e-02f, -9.08800885e-02f, -1.45850740e-02f, -3.47619168e-02f, -4.03660238e-02f, -1.94741830e-01f, -2.73641020e-01f, -2.62012750e-01f, -1.38961812e-02f,
  -8.18348229e-02f, 5.21563739e-02f, 1.55447617e-01f, 1.76800758e-01f, -1.01770647e-01f, 1.87769279e-01f, 9.59150866e-02f, -1.18540423e-02f, 1.37330338e-01f, 6.66843727e-02f,
  -1.46613866e-01f, 1.06231950e-01f, -3.79781909e-02f, -5.50539531e-02f, 3.51557024e-02f, 1.48596957e-01f, 6.57273307e-02f, 8.61139297e-02f, -1.54427849e-02f, -2.71601398e-02f,
  -1.19028976e-02f, -3.14751752e-02f, 1.97118428e-02f, -2.96026357e-02f, -6.06954247e-02f, -1.50574774e-01f, 2.00396076e-01f, -3.85385379e-02f, -1.51053488e-01f, -3.76383178e-02f,
  -1.01286694e-01f, -1.11652449e-01f, -2.07185924e-01f, -1.39749825e-01f, -4.58175354e-02f, -1.49500623e-01f, -2.43984126e-02f, -8.23903307e-02f, -8.84762257e-02f, -1.00693032e-01f,
  3.43105704e-01f, 7.00860471e-02f, 1.56176656e-01f, -1.08704127e-01f, -1.61413386e-01f, -2.51512706e-01f, -1.78176209e-01f, -1.61649764e-01f, -7.77434856e-02f, -3.07610491e-03f,
  -7.68668577e-02f, 1.23810641e-01f, 7.26439208e-02f, -6.74589574e-02f, 1.07200742e-02f, 9.51214805e-02f, -1.16726406e-01f, 3.36481594e-02f, -7.45035708e-02f, -2.20033988e-01f,
  -1.77050486e-01f, 1.82746485e-01f, 4.26396996e-01f, 3.40661019e-01f, 8.87400657e-02f, 4.00820494e-01f, 3.33082706e-01f, 2.52934635e-01f, 3.97233754e-01f, 3.01177144e-01f,
  1.40943539e+00f, -2.25412607e-01f, 2.58458227e-01f, 1.71053573e-01f, -6.68850005e-01f, -4.28707808e-01f, -4.83684838e-01f, 5.79185113e-02f, 1.18742131e-01f, 8.07098448e-02f,
  -1.81126505e-01f, 1.59193903e-01f, 2.72692472e-01f, 1.62635416e-01f, 3.96579504e-01f, 2.07772255e-02f, 4.06874567e-02f, 6.25739098e-01f, 5.56930602e-01f, 9.59999114e-02f,
  -1.47578865e-01f, 2.00975925e-01f, 5.08421957e-01f, 2.50046700e-01f, -1.30267665e-01f, 1.45908799e-02f, 5.69299459e-02f, -9.80932564e-02f, -2.02693611e-01f, 8.40186551e-02f,
  3.13844025e-01f, 2.62359709e-01f, 1.36533231e-01f, -1.11952305e-01f, -1.94884509e-01f, 1.32897377e-01f, 5.83388358e-02f, -4.36259806e-02f, -2.12201729e-01f, 6.45514354e-02f,
  -1.83819115e-01f, -7.44537935e-02f, -1.15680061e-01f, -1.09092630e-01f, -5.61806932e-02f, -7.96472505e-02f, 4.86210734e-02f, 2.76775271e-01f, 1.58661276e-01f, -5.99913225e-02f,
  -3.05602312e-01f, -2.47558638e-01f, -9.82071683e-02f, -1.99331701e-01f, -2.25284472e-02f, 5.59633970e-02f, -1.41409427e-01f, -9.66642145e-03f, 5.58269732e-02f, 1.59136370e-01f,
  1.91133380e-01f, 1.13389678e-01f, 1.61694929e-01f, -9.14838389e-02f, 1.59612015e-01f, 2.67812200e-02f, 1.46995308e-02f, 6.40006503e-04f, 1.52891457e-01f, -4.81263585e-02f,
  -3.90925221e-02f, 1.43690974e-01f, -3.51194367e-02f, -1.03355244e-01f, -8.21513236e-02f, -1.29413933e-01f, -1.77962944e-01f, -1.62956685e-01f, -2.22204983e-01f, 1.02668442e-03f,
  1.01094566e-01f, 6.30218089e-02f, -4.78652455e-02f, 8.02830011e-02f, -9.10769254e-02f, -3.38300243e-02f, 1.97592601e-01f, -1.79765690e-02f, -8.19999874e-02f, -1.62285175e-02f,
  -5.21072328e-01f, 7.48601034e-02f, 3.70289892e-01f, 2.14270592e-01f, -1.20629795e-01f, -3.01622227e-02f, 1.15230657e-01f, -5.74787557e-02f, -3.29553336e-01f, -8.28575864e-02f,
  -2.45196611e-01f, 9.37077999e-02f, -6.99145645e-02f, 4.30357940e-02f, 8.70499015e-02f, 1.95380766e-02f, -1.72368199e-01f, 3.98768671e-02f, -4.81579378e-02f, -1.74242213e-01f,
  -2.02914983e-01f, -4.32011560e-02f, 5.35632484e-02f, -1.18042745e-01f, -1.49181396e-01f, 3.46181281e-02f, -9.18311775e-02f, 6.56133443e-02f, 1.32881522e-01f, 1.13898493e-01f,
  -1.72079965e-01f, -6.35888398e-01f, -3.74155551e-01f, -1.01887532e-01f, 5.42241991e-01f, 6.47953689e-01f, 7.06341445e-01f, 3.17461222e-01f, 1.52970999e-01f, -1.29304975e-02f,
  -5.65775156e-01f, -5.87096512e-01f, -7.66773105e-01f, -3.25229794e-01f, -6.50384948e-02f, 2.61590034e-01f, 1.47389606e-01f, -2.26225093e-01f, 4.56704646e-01f, 8.36832762e-01f,
  4.80849355e-01f, 2.13087916e-01f, -1.65915206e-01f, 5.86349554e-02f, -2.93899514e-02f, -3.63316610e-02f, -3.89001966e-01f, -2.59636283e-01f, 2.11027768e-02f, -4.50812727e-01f,
  -7.70327508e-01f, -4.52336490e-01f, 3.05635124e-01f, -5.17531782e-02f, -2.17167705e-01f, 2.45177243e-02f, 1.03835024e-01f, -1.61426514e-01f, -3.46078724e-02f, 1.26692176e-01f,
  -1.22021101e-01f, 1.38790254e-02f, -2.20529079e-01f, 1.49037698e-02f, 7.43697658e-02f, 1.01898558e-01f, -1.87608957e-01f, -1.85257956e-01f, -2.35768974e-01f, -1.06406890e-01f,
  -1.63967371e-01f, 9.67948698e-04f, -7.90252164e-02f, 9.01715606e-02f, -1.07578076e-01f, 5.43896900e-03f, -8.96382555e-02f, 2.86869556e-02f, -1.98168252e-02f, -8.03483650e-02f,
  8.65827873e-02f, -1.02450378e-01f, 2.44454052e-02f, 5.70900477e-02f, 3.12930234e-02f, 2.80177016e-02f, 3.67039889e-02f, -3.51787396e-02f, 2.74093635e-02f, -8.05502459e-02f,
  -2.79710498e-02f, -2.08628297e-01f, -8.00746977e-02f, -5.18887192e-02f, -2.09698573e-01f, -1.79362625e-01f, 1.07113510e-01f, -1.17463522e-01f, -1.21540122e-01f, -9.74745397e-03f,
  -5.39757684e-02f, 4.22788933e-02f, -1.63528204e-01f, -1.51198640e-01f, -7.69879520e-02f, -1.47438079e-01f, 5.64218778e-03f, -1.26398951e-01f, -6.41834587e-02f, 1.25482917e-01f,
  8.68972018e-02f, -1.14638716e-01f, -2.36052349e-02f, -1.57724530e-01f, 3.93282175e-02f, -1.38260126e-01f, -3.99940401e-01f, -8.62668678e-02f, -2.07192287e-01f, -1.95768569e-02f,
  4.47637774e-03f, -1.59823596e-01f, -2.91168571e-01f, -1.94591954e-02f, 2.96409339e-01f, 8.49470645e-02f, -1.58936217e-01f, -3.16880569e-02f, -2.32370570e-02f, 6.71894550e-02f,
  -2.54862458e-02f, 2.86763966e-01f, 1.50063530e-01f, -6.31311908e-02f, 1.04637451e-01f, 2.05805808e-01f, 1.70040429e-02f, 1.53529331e-01f, 2.54203588e-01f, 4.29938763e-01f,
  1.00857937e+00f, 2.85575390e-01f, 4.36715454e-01f, 2.45071083e-01f, 1.20635547e-01f, -4.75536168e-01f, -4.17213887e-01f, -4.02281821e-01f, 5.92886657e-02f, 2.37170771e-01f,
  1.11835778e-01f, -2.24147022e-01f, 5.23527823e-02f, -5.31477451e-01f, -5.24825811e-01f, -1.61813229e-01f, -1.29294515e-01f, -4.07731920e-01f, -7.06311524e-01f, -6.69045329e-01f,
  -4.54944909e-01f, 6.54123724e-02f, 4.20029573e-02f, -1.83607146e-01f, 5.74807048e-01f, -6.48124292e-02f, 6.80203736e-01f, 6.10073447e-01f, 5.05683012e-02f, 5.89939713e-01f,
  8.02896559e-01f, 6.98352218e-01f, -4.90024090e-01f, -5.93569577e-02f, 2.41249770e-01f, -5.20224944e-02f, -6.12386037e-03f, 1.68861941e-01f, 1.04321027e-02f, 1.39481783e-01f,
  2.32419908e-01f, 7.19460994e-02f, 2.38866825e-02f, -5.69199175e-02f, 6.09460324e-02f, -1.92085251e-01f, -5.29472902e-02f, -2.41493940e-01f, -2.00811937e-01f, 6.90326989e-02f,
  -3.86501580e-01f, 2.28991583e-01f, 4.13201451e-01f, -1.73416182e-01f, -8.69001970e-02f, -1.87223479e-01f, 2.66404301e-01f, 1.37808725e-01f, 6.17160387e-02f, 5.30994833e-01f,
  -2.29350448e-01f, 1.09556742e-01f, 5.21433428e-02f, 9.19350013e-02f, -9.21472758e-02f, 4.83001806e-02f, 5.62291369e-02f, -1.58375166e-02f, -1.96896076e-01f, 4.22668364e-03f,
  -2.79741198e-01f, -1.23090893e-01f, -4.24002297e-02f, -7.83554316e-02f, -1.68995634e-01f, 7.99731612e-02f, -1.02231316e-01f, -1.52081281e-01f, -2.69473600e-03f, 4.64241467e-02f,
  -1.52009390e-02f, -7.67573938e-02f, 1.59809127e-01f, -1.58378050e-01f, -6.77499175e-02f, -6.62546381e-02f, -1.48086160e-01f, -1.24343969e-01f, -2.55403146e-02f, 2.36427471e-01f,
  1.10713780e-01f, -7.30078220e-01f, 3.34731549e-01f, -1.68872759e-01f, 1.79524422e-01f, 5.99320270e-02f, 3.34291756e-02f, -3.51853430e-01f, 2.52573699e-01f, 1.34775024e-02f,
  -6.34187087e-02f, -1.48461582e-02f, 1.91257909e-01f, -2.54290342e-01f, -2.97620118e-01f, -1.23866737e-01f, -1.30781427e-01f, -1.42478332e-01f, -2.68056244e-01f, 1.91734359e-01f,
  -1.55677170e-01f, -3.85054827e-01f, -4.34307039e-01f, -3.40717822e-01f, 4.76508141e-02f, -3.40210706e-01f, -1.32013723e-01f, -2.48825386e-01f, -3.62145185e-01f, -4.10075605e-01f,
  1.09668243e+00f, -2.25007713e-01f, 6.30719066e-01f, 1.66355431e-01f, 4.45660979e-01f, 5.60378015e-01f, 4.79539126e-01f, 7.69545883e-02f, -2.10747644e-02f, 3.63039263e-02f,
  1.68801203e-01f, -1.16160668e-01f, -1.74457967e-01f, -1.62156492e-01f, -1.03448115e-01f, -1.36651009e-01f, -2.28683472e-01f, 1.11461274e-01f, 2.84033746e-01f, 2.18669519e-01f,
  -2.87211180e-01f, -6.64207935e-02f, 2.39927515e-01f, -6.79067522e-02f, -2.17978328e-01f, -1.90894857e-01f, -8.61727372e-02f, 8.90946481e-03f, -3.26123871e-02f, -3.99294525e-01f,
  8.91926363e-02f, 2.69683272e-01f, -1.00983366e-01f, -1.98310494e-01f, 3.89420241e-02f, -1.49333745e-01f, 8.43585096e-03f, -9.07371938e-02f, -1.26722977e-01f, -1.88285112e-01f,
  -3.88761014e-02f, -3.09465900e-02f, 4.16670628e-02f, -7.83114731e-02f, 1.60146266e-01f, 7.32835084e-02f, -6.04459420e-02f, -1.52110448e-02f, -1.34709209e-01f, -5.01192696e-02f,
  -1.86028183e-01f, 4.12203558e-02f, 2.64861375e-01f, 1.17983125e-01f, -2.75860708e-02f, -6.99292263e-03f, 1.34995356e-02f, -1.48807183e-01f, 5.72063848e-02f, -1.21701390e-01f,
  1.18944593e-01f, 1.93360761e-01f, 1.35890603e-01f, -4.15813886e-02f, 4.71204072e-02f, 4.67748903e-02f, -2.55712122e-02f, 1.87682882e-02f, 1.80578187e-01f, 1.49543345e-01f,
  -5.26238419e-02f, 1.30647883e-01f, 1.37315020e-01f, 9.23336670e-02f, -1.17704915e-02f, 2.20310926e-01f, 6.26157820e-02f, 8.42690840e-03f, 1.40118957e-01f, 4.12896648e-02f,
  4.48707268e-02f, -9.50634778e-02f, 6.03385754e-02f, -1.30515844e-01f, -1.08953603e-01f, 2.70646978e-02f, 4.04928289e-02f, -4.07041274e-02f, 8.51038024e-02f, 1.47561688e-04f,
  -4.60958123e-01f, 4.79554504e-01f, -5.47177605e-02f, -1.05105199e-01f, 2.78023276e-02f, -2.19407678e-02f, 9.35758874e-02f, -1.50223345e-01f, -2.01030999e-01f, -2.89147943e-01f,
  -4.24761996e-02f, -2.27381773e-02f, 1.06091864e-01f, 5.83333895e-02f, 1.88758418e-01f, 1.80164874e-02f, 1.27849830e-02f, 1.14330016e-02f, -2.66754806e-01f, -1.68998882e-01f,
  -1.86217085e-01f, 1.63613752e-01f, 2.68306315e-01f, 5.69560267e-02f, 3.12306881e-02f, 1.63725287e-01f, 6.87803403e-02f, 6.22605309e-02f, 2.08935603e-01f, 7.53858909e-02f,
  -1.32353246e+00f, -1.16822338e+00f, 5.27587831e-01f, -3.07193417e-02f, 5.12435019e-01f, -2.52601564e-01f, -1.19003987e+00f, -7.31099546e-01f, 2.43254200e-01f, -6.41793609e-01f,
  -6.93647191e-02f, 5.44118106e-01f, 2.09263742e-01f, -1.90376759e-01f, -9.49991405e-01f, -8.17460656e-01f, -1.18972912e-01f, 1.88542940e-02f, 2.05408856e-02f, -3.03710431e-01f,
  -1.06514767e-01f, -3.17223324e-03f, 2.22039893e-02f, 1.33726567e-01f, 2.18866631e-01f, 2.02550247e-01f, 5.79583406e-01f, 2.41008461e-01f, -1.27411351e-01f, 1.81824848e-01f,
  -1.40610665e-01f, -6.26966953e-01f, 5.00286162e-01f, 1.87996849e-01f, 6.41806781e-01f, -4.55182701e-01f, -2.09490657e-01f, 1.73063830e-01f, 2.40128692e-02f, -9.83127877e-02f,
  3.37338895e-01f, -6.35213256e-02f, 1.32854253e-01f, 7.30913430e-02f, -2.29173154e-01f, -5.07685065e-01f, 5.40972166e-02f, -2.46126026e-01f, 2.97499890e-03f, -3.17185313e-01f,
  1.12684540e-01f, -4.01729858e-03f, -4.42960918e-01f, -1.81339964e-01f, -4.13934320e-01f, 5.81311882e-01f, -2.11234033e-01f, -1.54509187e-01f, -1.92059010e-01f, -3.64543110e-01f,
  1.97503075e-01f, 3.56224850e-02f, -1.10415921e-01f, 3.26474681e-02f, -1.62066400e-01f, 1.58432558e-01f, 1.75119221e-01f, -1.73441961e-01f, 1.53225645e-01f, -1.80548668e-01f,
  1.45064741e-01f, -2.92342789e-02f, 4.77592833e-03f, -2.51573324e-01f, 2.18873441e-01f, -1.52850598e-01f, -1.41050786e-01f, -9.84584466e-02f, -1.63267534e-02f, -6.28051013e-02f,
  4.05813903e-02f, -9.60644856e-02f, 3.08590263e-01f, -6.41948506e-02f, -2.51459062e-01f, 5.81462942e-02f, 8.60325694e-02f, -1.08270772e-01f, 5.55370264e-02f, 1.01443127e-01f,
  -1.47061333e-01f, 4.66533691e-01f, -4.45433378e-01f, -1.72106400e-01f, -4.22901474e-02f, 8.43487009e-02f, 2.13173151e-01f, -6.10085241e-02f, -1.99526083e-02f, -1.29434213e-01f,
  -2.93317139e-01f, -2.16585919e-01f, -2.19407186e-01f, 2.89324403e-01f, 2.09550955e-03f, -1.04898132e-01f, -3.27473670e-01f, 3.86285805e-03f, -1.63077772e-01f, 1.19938098e-01f,
  -7.74762332e-02f, -7.04326451e-01f, -8.39395106e-01f, -5.57028890e-01f, -4.11637306e-01f, -2.30973348e-01f, -2.50919938e-01f, -3.23604673e-01f, -6.09283388e-01f, -1.09987652e+00f,
  -1.07467151e+00f, 9.91979837e-02f, 2.11351156e-01f, -7.24059463e-01f, 2.98606306e-01f, 7.31817842e-01f, 6.65239334e-01f, 4.60322648e-01f, -7.74904415e-02f, -1.14147522e-01f,
  4.18599427e-01f, -3.32568914e-01f, -5.88167489e-01f, -2.68638939e-01f, -2.17910677e-01f, -2.02409253e-01f, -4.45999831e-01f, -7.51576841e-01f, -2.08443761e-01f, 3.93092424e-01f,
  -1.35016561e-01f, -4.70911860e-01f, -5.52259445e-01f, -1.70436263e-01f, -3.51408422e-01f, -6.21039391e-01f, -3.71289194e-01f, -3.72063190e-01f, 4.58239391e-02f, -8.75634909e-01f,
  -1.47579744e-01f, 6.41619086e-01f, 5.47902212e-02f, -2.44976819e-01f, 7.83805922e-02f, -3.52979898e-01f, -2.84304228e-02f, -9.04192626e-02f, -1.13458969e-01f, -7.08784759e-02f,
  1.42728791e-01f, 2.57666528e-01f, -1.18943140e-01f, 5.90283647e-02f, 3.42621580e-02f, 1.38635501e-01f, 2.30782419e-01f, 2.37477228e-01f, 1.51402563e-01f, 5.41461647e-01f,
  2.69063443e-01f, 5.47811165e-02f, 1.60408452e-01f, 3.76800030e-01f, 7.63616681e-01f, -4.70078699e-02f, 3.47516119e-01f, 4.48416740e-01f, 2.17778310e-01f, -4.28809762e-01f,
  3.44464816e-02f, -1.79497480e-01f, 3.58554751e-01f, 7.04448717e-03f, -1.17551379e-01f, 3.86600941e-03f, -2.29395226e-01f, -2.68098898e-02f, 2.19898038e-02f, -1.65617853e-01f,
  1.45029813e-01f, 2.63665766e-01f, 1.24057278e-01f, -2.96267290e-02f, -1.91091970e-01f, -2.34684329e-02f, -3.67735103e-02f, 1.09781973e-01f, -8.46310779e-02f, -2.08073497e-01f,
  -9.15324166e-02f, 1.21627212e-01f, 6.44052774e-02f, 1.27536759e-01f, 1.79064706e-01f, -7.11562037e-02f, 2.32185066e-01f, 3.32351297e-01f, 6.28227517e-02f, 2.20247522e-01f,
  -6.56860352e-01f, 2.63769567e-01f, -5.00742912e-01f, -6.33581728e-02f, -1.18663721e-01f, 5.46233356e-03f, -2.14673251e-01f, 1.88689828e-01f, -1.05869614e-01f, 1.03291385e-01f,
  5.11451542e-01f, -1.18351839e-01f, -2.11907938e-01f, 5.14293239e-02f, -1.36886999e-01f, -5.45486808e-02f, 2.00311206e-02f, -2.98343211e-01f, 2.15018168e-01f, 1.36719033e-01f,
  -1.39580503e-01f, -3.01013976e-01f, -6.12724125e-01f, -3.62783879e-01f, -4.03264984e-02f, -6.12053871e-01f, -5.33551335e-01f, -3.31965029e-01f, -4.93838578e-01f, -1.11188710e+00f,
  9.09674764e-01f, -1.04346919e+00f, -9.57003355e-01f, -4.19982463e-01f, -6.48779631e-01f, -4.74074632e-01f, -9.55973864e-01f, 1.26452133e-01f, 9.69325900e-02f, -9.58643198e-01f,
  -2.12306604e-01f, 7.43489563e-01f, 2.17221543e-01f, 3.91323686e-01f, 6.70236111e-01f, -1.01179194e+00f, -7.48275161e-01f, 3.14582974e-01f, 8.61948550e-01f, 2.08245888e-01f,
  -1.85927570e-01f, 1.06530011e-01f, 6.92151368e-01f, 3.46588433e-01f, -1.10948145e+00f, -1.19234234e-01f, -9.50307727e-01f, -4.90346581e-01f, -5.77248991e-01f, -1.17022371e+00f,
  -6.51593149e-01f, -3.10016692e-01f, 5.01704924e-02f, 6.40779018e-01f, -1.38382301e-01f, 5.06272763e-02f, -9.71688554e-02f, -2.82913059e-01f, 2.11076990e-01f, -3.30440909e-01f,
  -3.29190530e-02f, 2.74330527e-01f, 9.67507735e-02f, -7.58699030e-02f, 1.73357669e-02f, 5.96545711e-02f, 5.39030246e-02f, 1.16920263e-01f, 5.35376221e-02f, -3.89140189e-01f,
  -2.34892085e-01f, -1.48254767e-01f, -1.18061006e-01f, -1.92022249e-01f, 1.03516392e-02f, 3.45594883e-01f, -2.85695642e-01f, 1.17489398e-01f, 3.26675743e-01f, -8.31639290e-01f,
  -9.56098661e-02f, -1.29458189e-01f, -6.02504611e-02f, 3.10616381e-02f, 8.01471621e-02f, -1.44291654e-01f, -1.01716466e-01f, -4.05117637e-03f, -2.70272102e-02f, -9.59783420e-02f,
  1.52584696e-02f, 5.35832532e-02f, 2.33535424e-01f, -2.29346454e-01f, -7.94705525e-02f, 5.65448664e-02f, 8.60713795e-02f, -1.06024504e-01f, 5.85939793e-04f, 7.06346259e-02f,
  1.81334734e-01f, -1.07650526e-01f, -6.49400009e-03f, 9.84925106e-02f, -1.85641453e-01f, 5.32509647e-02f, -1.25050679e-01f, 1.27786368e-01f, 5.71551286e-02f, -1.20961912e-01f,
  -4.23868410e-02f, 6.82131529e-01f, -5.76260984e-01f, 1.59307092e-01f, -2.11169273e-01f, -2.35882878e-01f, -2.72036821e-01f, -4.26440276e-02f, 5.10885380e-02f, 1.06767818e-01f,
  8.58675747e-04f, 3.47924769e-01f, -2.39871025e-01f, 3.31693678e-03f, -8.09900612e-02f, -1.08353324e-01f, 4.54693213e-02f, -1.18457749e-01f, 9.50381011e-02f, -1.87293127e-01f,
  7.64826778e-03f, 1.09045126e-01f, 9.95429084e-02f, -1.02154063e-02f, -6.13593683e-02f, 3.34651381e-01f, -5.42435706e-01f, -4.84837055e-01f, 3.46802413e-01f, -5.30258596e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.79797256e-01f, 5.16676307e-01f, 2.07473454e-03f, 8.47709000e-01f, 9.53095257e-01f, 6.39623582e-01f, 9.46686447e-01f, 1.06902015e+00f, 1.33074510e+00f, 8.97872269e-01f,
  7.86151052e-01f, 5.69690943e-01f, 4.21843946e-01f, 5.90989232e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -2.00051442e-01f, 2.38962960e-03f, -4.36101258e-01f, -4.56439704e-01f, -2.59810299e-01f, -4.89584386e-01f, -2.09293574e-01f, -1.24152735e-01f, -1.46853730e-01f, 4.93981577e-02f,
  2.70960450e-01f, 5.18036895e-02f, 3.41526687e-01f, -5.82380034e-02f, 4.60154682e-01f, 2.90925056e-01f, -4.06056017e-01f, 2.95740459e-02f, 5.06455004e-01f, -2.68936604e-01f,
  3.09788167e-01f, -1.03909302e+00f, -2.68510640e-01f, -1.02511895e+00f, -3.52376580e-01f, -5.21921635e-01f, 1.23209119e-01f, -1.32596767e+00f, -6.35015607e-01f, 1.08584628e-01f,
  4.52413142e-01f, 7.46587873e-01f, 3.41709733e-01f, -8.89962763e-02f, 1.26111761e-01f, -1.28185377e-01f, -3.59327912e-01f, -4.89962637e-01f, 2.03521997e-01f, -1.71777800e-01f,
  4.75050956e-02f, -1.43575266e-01f, 1.05427273e-01f, -1.67238370e-01f, 1.93309590e-01f, -7.47097423e-03f, 3.19525450e-01f, 6.61478579e-01f, -5.27720392e-01f, -7.08102509e-02f,
  -2.53457855e-02f, 2.56707102e-01f, 1.96010899e-02f, -5.19405782e-01f, -9.72881913e-01f, 2.00964250e-02f, 2.31738165e-01f, 1.05085921e+00f, -8.90784681e-01f, -6.11351550e-01f,
  3.18671048e-01f, -1.42412341e+00f, -1.38502598e+00f, 1.32772887e+00f, -3.88782442e-01f, -1.54178655e-02f, -2.96499152e-02f, 1.32025152e-01f, 2.22700581e-01f, -2.67045572e-02f,
  2.27760106e-01f, 3.68639588e-01f, -7.79915601e-02f, -4.62366551e-01f, -4.72264774e-02f, 3.23591918e-01f, -3.03794831e-01f, -1.69301793e-01f, -1.71037018e-01f, 4.06221211e-01f,
  -4.36875522e-01f, 4.38759863e-01f, -1.12222564e+00f, -1.65852696e-01f, 1.57291189e-01f, -4.46926475e-01f, -1.19641674e+00f, -6.53360486e-01f, -6.61736429e-01f, 4.80348974e-01f,
  -3.77587438e-01f, -7.70422518e-01f, -1.99154001e-02f, 1.30675316e+00f, -9.70486641e-01f, 7.53742695e-01f, 5.53640164e-02f, 1.97666287e-01f, -5.59822500e-01f, 3.54130358e-01f,
  4.55667198e-01f, -7.76546076e-02f, -1.06932008e+00f, 1.78235218e-01f, 2.32833892e-01f, 6.51827812e-01f, -1.53454944e-01f, -7.70515576e-02f, -4.60105538e-01f, -2.09834799e-01f,
  -1.67797554e+00f, -7.94466913e-01f, 6.42911077e-01f, 6.07335448e-01f, -1.60583627e+00f, -2.89474994e-01f, -1.69544709e+00f, -3.88781399e-01f, 2.41409779e-01f, -2.05050081e-01f,
  6.66814268e-01f, -6.85549974e-01f, 5.24415731e-01f, -1.11436164e+00f, -5.79044521e-01f, 9.30630565e-02f, 5.94826818e-01f, -6.61660314e-01f, -2.82014906e-01f, -1.93533599e-01f,
  7.57419705e-01f, 7.12240860e-02f, -4.48069990e-01f, 4.81352359e-01f, 2.79381782e-01f, 8.91879667e-03f, -7.06603527e-02f, -3.68935794e-01f, -3.27292800e-01f, -3.74293655e-01f,
  3.63263041e-01f, 2.62570947e-01f, 2.23389775e-01f, 1.02053738e+00f, -2.59006083e-01f, 2.45315433e-01f, -4.51514900e-01f, 2.64457375e-01f, -1.65295973e-01f, -7.31221497e-01f,
  4.12936032e-01f, 1.06288299e-01f, -2.15183645e-01f, -6.75063074e-01f, -1.50942409e+00f, 7.81284690e-01f, -2.64280200e-01f, 6.07034385e-01f, 1.49217129e-01f, -5.84182680e-01f,
  2.51423866e-01f, 2.20369920e-01f, 5.84495962e-01f, -3.82924587e-01f, -1.94826424e-01f, 1.46673232e-01f, 2.27117747e-01f, 3.31164151e-01f, 5.65585792e-02f, 1.03675973e+00f,
  -7.37097040e-02f, -1.09416954e-01f, 4.97668892e-01f, 3.35436165e-01f, 8.47703516e-01f, -4.84533668e-01f, -2.69617796e-01f, -4.24549997e-01f, 7.87991822e-01f, 1.47296891e-01f,
  -6.93009272e-02f, -5.02438366e-01f, 1.20063937e+00f, -2.04821914e-01f, -4.49078053e-01f, -1.67515755e-01f, 3.85392159e-01f, -6.92245245e-01f, -4.46681798e-01f, -9.51627195e-01f,
  -9.10720527e-01f, -1.66776031e-01f, 4.84863490e-01f, 4.46535587e-01f, -9.50869977e-01f, 6.91263676e-02f, 3.02823693e-01f, 2.32502386e-01f, -4.15436715e-01f, -7.78390691e-02f,
  1.20262101e-01f, -2.95779228e-01f, 8.85421187e-02f, 4.41630602e-01f, -2.03247815e-01f, -3.30342114e-01f, -3.08224000e-02f, -3.31075966e-01f, -4.06628340e-01f, 5.65318048e-01f,
  -1.52513754e+00f, 5.72766513e-02f, -6.95926324e-02f, 3.49687904e-01f, -8.66064429e-01f, -8.35601628e-01f, -6.76219821e-01f, 1.14195192e+00f, -1.34982705e+00f, 9.09213901e-01f,
  -8.49123120e-01f, -1.07472146e+00f, -8.77526522e-01f, -5.67531586e-01f, 1.74091130e-01f, -1.36214662e-02f, 1.15846425e-01f, -1.27734527e-01f, -2.19988823e-01f, -6.71500206e-01f,
  1.32096604e-01f, -3.50062340e-01f, 4.30190504e-01f, 4.30999659e-02f, -1.49021924e-01f, 4.39028919e-01f, -7.21498430e-02f, -2.28564531e-01f, -3.06131035e-01f, 3.06174695e-01f,
  3.75048876e-01f, -1.33214250e-01f, -2.13642880e-01f, -6.73020482e-02f, -7.25418627e-01f, 5.88478327e-01f, -2.49265194e-01f, 6.64066076e-01f, -6.23509467e-01f, -8.42443347e-01f,
  1.10529006e-01f, -9.14739609e-01f, -9.54935193e-01f, 9.64616388e-02f, -5.50462957e-03f, -8.28834176e-01f, -2.46977240e-01f, -2.13849112e-01f, -1.32448897e-01f, 2.26937488e-01f,
  2.74073839e-01f, -1.83990866e-01f, 4.14770573e-01f, -7.03035519e-02f, 1.37902528e-01f, -5.73698401e-01f, 7.19270051e-01f, -6.01204634e-01f, 1.43911064e-01f, -3.82705957e-01f,
  7.31840909e-01f, -4.94794011e-01f, 4.02283221e-01f, -4.38720137e-01f, -8.84941638e-01f, -5.10243177e-01f, -3.45054954e-01f, -3.58494252e-01f, -1.00554442e+00f, 8.83880332e-02f,
  1.50350586e-01f, 5.28098792e-02f, 1.14944828e+00f, -7.67769337e-01f, 5.76075971e-01f, -2.77028263e-01f, -7.72777438e-01f, -2.77548760e-01f, 1.95713323e-02f, -4.84928451e-02f,
  3.58491391e-01f, 8.15151408e-02f, -1.35198116e-01f, 3.83755505e-01f, -5.45360506e-01f, -1.95559427e-01f, -4.23895299e-01f, -3.58957052e-01f, -2.08289564e-01f, 3.65863919e-01f,
  -1.88552588e-01f, 5.16657174e-01f, -3.15224618e-01f, -8.92130435e-01f, -3.21302921e-01f, 7.88013577e-01f, 1.15543771e+00f, -6.02539599e-01f, -2.64163036e-02f, 2.36810401e-01f,
  -5.82646310e-01f, -5.01300454e-01f, -9.60137010e-01f, -4.53329355e-01f, -1.58679903e+00f, 3.55073243e-01f, 1.41494721e-01f, 6.14065289e-01f, -7.58377254e-01f, -8.15274239e-01f,
  7.67634660e-02f, -3.74872923e-01f, -9.30332839e-01f, 2.94714808e-01f, 3.93714577e-01f, 2.07356662e-02f, 3.78168613e-01f, -2.84445405e-01f, 1.53294981e-01f, -7.34390974e-01f,
  -3.95911276e-01f, -2.26918086e-01f, -1.17140979e-01f, -4.77241397e-01f, -1.20292276e-01f, 5.12354314e-01f, 5.53353369e-01f, -3.23855281e-01f, 3.03349167e-01f, -1.06434214e+00f,
  -2.37166882e-01f, -5.20936012e-01f, 1.22420721e-01f, 2.88073361e-01f, 1.13034272e+00f, -7.13269949e-01f, -5.04475415e-01f, -5.03405988e-01f, -6.88314855e-01f, -4.55217630e-01f,
  -8.52166295e-01f, -1.12645936e+00f, -3.18757951e-01f, -5.65243840e-01f, 6.26225173e-01f, -4.32281606e-02f, -1.87662646e-01f, -1.64972290e-01f, 5.19228637e-01f, 2.25261390e-01f,
  -8.26338364e-04f, 9.31876123e-01f, 5.11486292e-01f, -1.41384259e-01f, -1.34609401e-01f, -2.56152540e-01f, -5.10990083e-01f, 4.74125028e-01f, -1.59066215e-01f, -8.41539264e-01f,
  -7.76346147e-01f, 6.05305620e-02f, -6.65994048e-01f, 6.07010543e-01f, -7.00709581e-01f, -1.03821385e+00f, -1.36841178e-01f, -6.09756112e-01f, -4.85123336e-01f, 8.77209306e-01f,
  9.37158525e-01f, -1.25807858e+00f, 4.39885974e-01f, -7.94907749e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.11163926e-01f, -2.40074903e-01f, 3.60542387e-01f, -1.36117578e-01f, 1.19657792e-01f, 8.99125040e-02f, 5.01631200e-01f, -6.01721592e-02f, -3.85790408e-01f, 3.20712090e-01f,
  -4.10339117e-01f, -5.25479242e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    