/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.37158015e-01f, -4.14958239e-01f, -1.25019357e-01f, -2.41066039e-01f, -1.51774213e-01f, -1.51038155e-01f, -4.08369511e-01f, -2.11297765e-01f, -7.99131393e-02f, -3.17047596e-01f,
  -7.06961751e-02f, 1.50966749e-01f, 1.65132269e-01f, 2.26863891e-01f, 1.05133038e-02f, -3.72181505e-01f, -2.21046939e-01f, 4.24151607e-02f, 2.28430927e-01f, -2.94650514e-02f,
  -5.00486186e-03f, -6.11388125e-02f, 1.27668247e-01f, 2.89274212e-02f, -2.45091319e-01f, -2.10874490e-02f, -2.02786967e-01f, -1.85912043e-01f, -7.18503818e-02f, -1.22407407e-01f,
  -2.40831301e-02f, -2.10809872e-01f, 5.70669398e-02f, -3.30495015e-02f, -9.97400954e-02f, -1.35290116e-01f, -1.09627970e-01f, -1.12119749e-01f, -4.79588918e-02f, -1.36429608e-01f,
  -1.15134388e-01f, -9.33441892e-02f, -9.19656530e-02f, -1.33068830e-01f, -1.24351308e-01f, -1.56025440e-01f, -1.63835153e-01f, -6.01367466e-02f, -1.48840263e-01f, -9.41904858e-02f,
  -1.40243456e-01f, -1.68880403e-01f, -1.71058014e-01f, -1.95120394e-01f, -2.28613526e-01f, -7.96678383e-03f, -2.42047578e-01f, -2.26655036e-01f, -1.53942451e-01f, -2.19891503e-01f,
  5.86450435e-02f, 1.15516499e-01f, 8.81404728e-02f, 5.12476675e-02f, 9.07682106e-02f, 1.39677882e-01f, 5.00138327e-02f, 1.78315133e-01f, 8.45918655e-02f, 3.67507301e-02f,
  7.10543320e-02f, 5.91602474e-02f, 1.04844719e-01f, 2.76555661e-02f, 7.52174109e-02f, 1.15246177e-02f, 1.30339444e-01f, -3.54566425e-02f, 1.17882878e-01f, 2.29799412e-02f,
  8.47844705e-02f, 1.16922706e-01f, 6.83467835e-02f, 1.40294671e-01f, 3.27172838e-02f, 8.73346850e-02f, 4.82248887e-02f, 1.25327885e-01f, 1.12043833e-02f, 9.51871127e-02f,
  -2.19302833e-01f, -1.77229568e-02f, -1.78760573e-01f, -4.45197001e-02f, -1.62482813e-01f, -2.73768418e-02f, -1.55939028e-01f, -3.79677191e-02f, -4.75180373e-02f, -1.79401264e-01f,
  -1.33830830e-01f, -1.62907362e-01f, -2.42877692e-01f, -7.48613402e-02f, -1.08619392e-01f, -7.74938986e-02f, -1.39270186e-01f, -3.59103419e-02f, -8.85412320e-02f, -1.10933550e-01f,
  -1.68241605e-01f, -9.73673612e-02f, -1.15120210e-01f, -9.39580277e-02f, -1.49191514e-01f, -3.27886529e-02f, -1.35987252e-01f, -1.19755216e-01f, -2.17634901e-01f, -2.59389907e-01f,
  -5.33685207e-01f, 4.06699181e-02f, -3.07386041e-01f, -5.82234971e-02f, 7.70934299e-02f, -1.11183338e-01f, -1.90460160e-01f, -1.75117061e-01f, -3.47330309e-02f, -4.57702689e-02f,
  4.70504314e-02f, 7.26499036e-02f, -3.73215717e-03f, 5.90542965e-02f, -1.95636034e-01f, -6.75068423e-02f, 2.21384596e-02f, -6.85732141e-02f, -1.55178279e-01f, -1.27609536e-01f,
  2.31630266e-01f, 3.84930931e-02f, -2.95587122e-01f, 4.19654474e-02f, 2.33982250e-01f, 2.17512876e-01f, 8.10941309e-02f, -3.84697430e-02f, -1.26435487e-02f, 2.35797107e-01f,
  -6.21773042e-02f, -3.58373463e-01f, -5.16108088e-02f, 2.35281810e-02f, 1.73517112e-02f, -1.67142749e-01f, -1.82769131e-02f, -1.11169249e-01f, 2.02539936e-02f, -6.59004971e-02f,
  8.00796896e-02f, -6.74286857e-02f, -6.91398531e-02f, 8.90939012e-02f, -2.65081655e-02f, -1.17104016e-01f, -9.56910029e-02f, -1.49570584e-01f, -7.70671219e-02f, -1.05853967e-01f,
  4.08630371e-02f, -1.03624910e-01f, -2.16989860e-01f, -6.40970021e-02f, -1.79292649e-01f, -7.91357979e-02f, -9.59139839e-02f, -1.22331508e-01f, -1.49902821e-01f, -7.44561628e-02f,
  -7.78072476e-02f, 5.23937531e-02f, 9.77346301e-02f, 1.88814234e-02f, 1.32772177e-01f, 3.60002555e-02f, 8.62993747e-02f, 1.08563848e-01f, 6.49869889e-02f, 9.45357457e-02f,
  9.62341279e-02f, 2.38659605e-02f, 6.62761852e-02f, 4.47820388e-02f, 1.20751232e-01f, 1.69952009e-02f, 1.18340604e-01f, 8.12037587e-02f, 5.56597523e-02f, 3.38630155e-02f,
  -3.02972533e-02f, 5.47578968e-02f, 6.44080043e-02f, 9.05477256e-02f, -1.95075534e-02f, 8.98619741e-02f, 4.80712578e-02f, 1.32791802e-01f, 2.39096489e-02f, 3.50770243e-02f,
  1.52950794e-01f, -1.26505047e-01f, 4.90706526e-02f, -7.80984461e-02f, -5.28660305e-02f, 1.93755571e-02f, 5.37241772e-02f, -8.22052732e-03f, 5.44395857e-02f, 4.06249333e-03f,
  -9.93705094e-02f, -1.10841043e-01f, -3.53669487e-02f, -2.05625948e-02f, -7.27373809e-02f, -5.65794520e-02f, 9.91877094e-02f, 1.25663523e-02f, -1.09000709e-02f, 2.71469150e-02f,
  -1.19034778e-02f, -8.06220397e-02f, -3.81219052e-02f, 4.56502214e-02f, -1.00369163e-01f, -5.22892103e-02f, -1.85104534e-02f, 2.16246434e-02f, -8.11831728e-02f, -1.84928738e-02f,
  -1.95019931e-01f, 3.15920450e-02f, -5.02787456e-02f, -5.86328320e-02f, 2.42652237e-01f, 2.78696001e-01f, 1.89768776e-01f, 1.41323552e-01f, -3.59221138e-02f, -3.59532051e-02f,
  4.58730944e-03f, 1.32963851e-01f, 1.02254249e-01f, 1.06780909e-01f, 8.09424073e-02f, 6.03419766e-02f, 8.67834464e-02f, 6.40565455e-02f, 1.35054767e-01f, 2.45147303e-01f,
  2.17569530e-01f, 2.11039602e-04f, -1.34883761e-01f, -1.80543736e-02f, 1.03857275e-03f, 4.90925461e-02f, 2.38253139e-02f, -1.10686347e-01f, 7.51005635e-02f, -1.36151448e-01f,
  -5.88677116e-02f, -1.15377001e-01f, 1.26221508e-01f, 1.56335887e-02f, -2.73733232e-02f, 6.37444928e-02f, 1.17601696e-02f, -2.20004674e-02f, 1.14025064e-02f, 5.95069909e-03f,
  4.20014448e-02f, -5.08381017e-02f, 9.37071815e-02f, 7.96106458e-02f, -4.41847071e-02f, 3.89122814e-02f, -6.20702505e-02f, -6.98000863e-02f, 4.20835428e-02f, -8.23681653e-02f,
  9.07390267e-02f, 9.52124149e-02f, 8.35927650e-02f, 2.86352187e-02f, -2.74320599e-02f, 5.09093143e-02f, 4.90165688e-02f, -1.03025530e-02f, 1.17857242e-02f, -1.62026167e-01f,
  -5.74306399e-02f, -8.17836374e-02f, 2.27296129e-02f, -2.25165263e-02f, -3.39846760e-02f, 1.92901455e-02f, -6.17768541e-02f, -9.18595567e-02f, -7.04633668e-02f, 8.86668265e-03f,
  -9.94418561e-02f, -7.01392442e-02f, -3.18746790e-02f, -8.69016722e-02f, -6.44651949e-02f, -5.54962419e-02f, 3.95535268e-02f, -6.72561079e-02f, -6.50179759e-02f, -8.01986679e-02f,
  -2.82219425e-02f, -4.12786603e-02f, -9.98492241e-02f, -3.79138179e-02f, -7.20447302e-03f, -1.26756415e-01f, 3.66750769e-02f, -9.51539651e-02f, 6.85381936e-03f, -3.55678387e-02f,
  1.07040226e-01f, 1.39182180e-01f, 4.19503972e-02f, 7.55138174e-02f, 8.02206323e-02f, -1.07860100e-02f, 8.07341263e-02f, -3.03984508e-02f, 9.57473889e-02f, 8.31879396e-03f,
  6.09042356e-03f, 8.06608647e-02f, 5.28302751e-02f, 6.46714345e-02f, 6.83441460e-02f, 8.79274532e-02f, 7.48189688e-02f, 1.02803759e-01f, 1.37301758e-01f, 3.40382867e-02f,
  3.07266153e-02f, 1.62978351e-01f, 6.93605915e-02f, 1.65558025e-01f, 1.09180957e-01f, 1.56228989e-01f, 9.95154530e-02f, 1.39902234e-01f, 1.75910622e-01f, 9.75376219e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.04030430e-01f, -2.08295539e-01f, 8.33993927e-02f, 2.18938544e-01f, 1.07291482e-01f, 6.87280148e-02f, 5.37095070e-02f, 5.56213222e-03f, -3.34590040e-02f, 1.00712590e-01f,
  2.65914738e-01f, 2.37051308e-01f, 2.45802492e-01f, 1.60179600e-01f, 8.18055961e-03f, -4.99073938e-02f, -2.21457675e-01f, 1.91613175e-02f, 9.82662663e-02f, 6.14928640e-02f,
  -9.63282287e-02f, -1.63234487e-01f, -1.66102633e-01f, -1.24264941e-01f, -1.04932614e-01f, 5.51194474e-02f, -2.16249168e-01f, -2.28167683e-01f, -1.53156698e-01f, -2.19564766e-01f,
  4.39252406e-01f, 7.69293755e-02f, -7.73687586e-02f, -2.05869421e-01f, -6.69550374e-02f, 1.66565608e-02f, 8.31235275e-02f, -1.90899715e-01f, -6.60884529e-02f, -1.70857966e-01f,
  -9.59249213e-02f, -1.13658756e-01f, -4.80269454e-02f, -1.60466507e-01f, -1.39721915e-01f, -5.57117835e-02f, -1.10704437e-01f, -1.05451070e-01f, -3.38707305e-02f, -1.05672732e-01f,
  -1.55630469e-01f, 2.56011821e-02f, -4.09795530e-02f, 1.33753307e-02f, 9.03903320e-02f, 9.63898227e-02f, -1.30276792e-02f, -2.59018559e-02f, -3.41282487e-02f, -8.73590335e-02f,
  -1.27293497e-01f, 1.41684189e-02f, 9.61616337e-02f, 1.80336371e-01f, 2.09758431e-01f, 1.25992283e-01f, 3.19409072e-02f, 6.98358491e-02f, 4.71018255e-03f, -3.14520448e-02f,
  -1.23251930e-01f, 2.17534706e-01f, 9.70352218e-02f, 1.46791711e-01f, 9.93496552e-02f, -6.53091520e-02f, -1.93095338e-02f, -9.43797752e-02f, -2.74570640e-02f, 9.74716097e-02f,
  9.62924287e-02f, -1.22979507e-01f, -1.77994072e-01f, -1.05587997e-01f, -1.17717728e-01f, -2.60513593e-02f, -9.59510654e-02f, 3.18614468e-02f, 4.89960574e-02f, -9.56956148e-02f,
  -1.04908482e-03f, 1.07332662e-01f, 1.74723774e-01f, 4.22009500e-03f, -7.81710818e-02f, -6.53526261e-02f, 1.91915900e-01f, -8.65132660e-02f, -4.36855443e-02f, 6.00364134e-02f,
  -4.52845730e-02f, 7.16836527e-02f, -5.89776747e-02f, -1.36283636e-01f, 6.78261966e-02f, 1.02640934e-01f, 2.63411999e-02f, 9.48697478e-02f, -7.49969110e-02f, -1.49598017e-01f,
  -2.43226975e-01f, 1.11678869e-01f, 3.41105163e-01f, 1.93008676e-01f, 7.90644437e-03f, 1.18952133e-01f, 7.23435581e-02f, 1.06978029e-01f, 9.72676128e-02f, 8.74740630e-02f,
  3.99288654e-01f, -3.32413971e-01f, -6.05103672e-01f, -7.96013847e-02f, -4.90776449e-01f, -2.73455113e-01f, -3.15810412e-01f, -1.36979885e-04f, -1.22299446e-02f, -3.95418018e-01f,
  -2.95688421e-01f, 1.38484910e-01f, -9.34385508e-02f, -1.14774808e-01f, 3.22828978e-01f, -3.81006867e-01f, -4.49417531e-01f, -1.16915248e-01f, 4.89201322e-02f, -8.86864439e-02f,
  -1.08347565e-01f, 8.14967826e-02f, 1.49457544e-01f, -1.96490102e-02f, -3.74970675e-01f, -2.21642613e-01f, -5.05445480e-01f, -3.12330037e-01f, -3.64907146e-01f, -5.71015060e-01f,
  -3.03011209e-01f, -4.86979932e-02f, -1.03672296e-01f, -3.17519344e-02f, -1.59016609e-01f, 1.09283045e-01f, -6.16050735e-02f, -6.98589683e-02f, 1.22969106e-01f, -9.96715873e-02f,
  -1.89786315e-01f, 1.09460931e-02f, 2.91523904e-01f, 8.86620358e-02f, 5.52695580e-02f, 1.06224557e-02f, -8.02274868e-02f, -1.51847959e-01f, -1.23353586e-01f, 3.83914215e-03f,
  -1.90319568e-02f, -1.51274428e-01f, -9.75552190e-04f, -1.22471035e-01f, 3.25704250e-03f, -1.26511112e-01f, -2.24440843e-01f, -1.76348463e-01f, -3.27462927e-02f, -4.80278432e-02f,
  1.30004287e-02f, -1.07707053e-01f, 4.06245841e-03f, 2.75000315e-02f, 1.94797352e-01f, -1.82022490e-02f, -6.92169294e-02f, 5.90183362e-02f, 4.08127531e-02f, 3.26868631e-02f,
  -2.34258939e-02f, -7.65859783e-02f, -6.31019771e-02f, 9.73184779e-03f, -1.43017128e-01f, -2.00776523e-03f, 1.03047900e-01f, 2.76538040e-02f, 9.43024382e-02f, 9.82964486e-02f,
  2.53119022e-02f, -1.43985003e-01f, 4.46698554e-02f, 1.91690791e-02f, -1.08441785e-01f, 7.32918978e-02f, 3.22125778e-02f, 7.06636999e-03f, 6.26344010e-02f, -3.39072384e-02f,
  3.00251931e-01f, 4.00014259e-02f, -3.55279110e-02f, 6.50534928e-02f, 2.60467976e-02f, -8.64868686e-02f, -1.65262595e-02f, 2.20405161e-02f, -8.91847536e-03f, -4.27046232e-03f,
  -1.21730819e-01f, -2.56803799e-02f, 1.49490714e-01f, -2.87246183e-02f, -5.76140881e-02f, 6.12319820e-02f, 5.29480949e-02f, -5.03715202e-02f, 1.69536173e-02f, -1.01032341e-02f,
  4.98527251e-02f, 2.60952055e-01f, 1.82689607e-01f, 3.56842484e-03f, -8.42583030e-02f, 1.06710754e-01f, -8.04838687e-02f, -7.96663538e-02f, 1.66232839e-01f, 1.92465693e-01f,
  9.78665352e-01f, -3.86956096e-01f, 5.12571782e-02f, 2.86648273e-01f, 1.76140472e-01f, 2.63756067e-01f, 2.61413485e-01f, 1.46353945e-01f, 2.33070910e-01f, 6.10126294e-02f,
  7.10621029e-02f, 7.20008537e-02f, 1.27285093e-01f, 1.35315685e-02f, -5.57726361e-02f, -1.28371283e-01f, -4.43085395e-02f, 6.61638528e-02f, 2.80514657e-01f, 1.29201069e-01f,
  -5.83666526e-02f, -1.66284144e-01f, -1.49838431e-02f, -5.01148440e-02f, -3.46802056e-01f, -8.03757086e-02f, -2.19479516e-01f, -2.19524309e-01f, -2.86732227e-01f, -4.10860360e-01f,
  -5.11923850e-01f, -7.36789256e-02f, 1.16974413e-01f, -1.18239589e-01f, -1.61409304e-01f, 5.93123175e-02f, 1.21774390e-01f, 9.01171006e-03f, 3.84995453e-02f, -5.85111491e-02f,
  -6.07720464e-02f, -9.53296721e-02f, -4.39681672e-02f, -5.93685405e-03f, -2.34845448e-02f, 1.92185361e-02f, -1.64361168e-02f, 1.51030645e-01f, -7.05453902e-02f, -1.21607937e-01f,
  -7.36885145e-02f, 9.81798619e-02f, 1.22461759e-01f, 3.78170125e-02f, 1.41768781e-02f, 1.71811998e-01f, -1.46675035e-02f, 8.02521184e-02f, 1.27318352e-02f, 1.06826484e-01f,
  1.05854675e-01f, 9.29996744e-02f, 4.79504652e-03f, 1.79594327e-02f, 5.68320043e-02f, 7.41076097e-02f, 1.85724363e-01f, 5.28429970e-02f, 6.24665879e-02f, 1.02998298e-02f,
  8.28088894e-02f, -1.65508896e-01f, -1.81286111e-02f, 6.48096949e-02f, -1.64299920e-01f, -1.09513830e-02f, 1.41665535e-02f, -6.28055111e-02f, -2.42159545e-01f, -2.82624140e-02f,
  1.73729360e-02f, 8.88911411e-02f, -1.30371019e-01f, -1.50308251e-01f, -6.29197359e-02f, -3.66766788e-02f, 4.80552875e-02f, -5.81605099e-02f, -6.06739186e-02f, 8.24503675e-02f,
  -4.03583765e-01f, -1.00590222e-01f, 5.97377233e-02f, -7.50391372e-03f, 6.58941343e-02f, -7.15666264e-02f, -6.83148429e-02f, -1.07412979e-01f, -1.04066364e-01f, -1.14455670e-01f,
  -7.30376542e-02f, 7.09452927e-02f, -1.20923944e-01f, -7.55547956e-02f, 9.45134237e-02f, 2.16590092e-02f, 6.05838448e-02f, 1.42627209e-01f, -2.28543077e-02f, -1.23511985e-01f,
  -1.01266786e-01f, 2.01169327e-01f, 2.14548528e-01f, 2.46702030e-01f, 9.68659446e-02f, 1.89565882e-01f, 1.30286247e-01f, -1.53591661e-02f, 1.13755338e-01f, 2.34189615e-01f,
  -6.01604044e-01f, -5.85275829e-01f, 1.14562385e-01f, -3.93572032e-01f, -4.15097833e-01f, -2.25515902e-01f, -6.82014823e-01f, -2.91802049e-01f, -2.37913176e-01f, -6.35677874e-01f,
  -2.94435680e-01f, 5.07635958e-02f, 1.90044194e-02f, 1.51156396e-01f, 2.47407958e-01f, -3.88230741e-01f, -1.99543223e-01f, 3.64975423e-01f, 7.27398753e-01f, 1.14214160e-01f,
  -1.09430969e-01f, 1.17253233e-02f, 4.86700803e-01f, 1.47368580e-01f, -5.08888245e-01f, 7.00088292e-02f, -2.15077639e-01f, -6.93233013e-02f, -9.95497927e-02f, -5.21294415e-01f,
  -3.41907591e-02f, -3.33767831e-01f, 2.97468841e-01f, -7.67353177e-02f, -1.43150136e-01f, 1.34289972e-02f, -1.83252484e-01f, 1.90983027e-01f, 1.45412043e-01f, -2.81179138e-02f,
  -9.67597738e-02f, -8.65079015e-02f, -1.27953708e-01f, -2.51057576e-02f, -1.12591885e-01f, -1.27427697e-01f, -6.20998023e-03f, 2.22574711e-01f, 1.90373689e-01f, -2.02481687e-01f,
  -2.63558507e-01f, -2.21385837e-01f, 9.31663439e-02f, 1.87113374e-01f, 1.20421499e-01f, 1.65124625e-01f, 9.23140198e-02f, 7.96609521e-02f, 2.02477232e-01f, -4.28169906e-01f,
  -1.23336196e-01f, -2.40576323e-02f, -6.06315769e-02f, -5.05350865e-02f, -1.08909972e-01f, 5.95059209e-02f, -3.77852954e-02f, -1.31214902e-01f, -2.54853349e-03f, -3.86355408e-02f,
  1.26595244e-01f, 1.32750589e-02f, 8.01357627e-02f, -8.13235641e-02f, -2.42710263e-02f, -1.03196323e-01f, -2.00769473e-02f, 9.61908028e-02f, -9.27305743e-02f, -2.29072859e-04f,
  1.25194386e-01f, 3.22614089e-02f, 7.95584321e-02f, 5.77111840e-02f, -1.30841043e-02f, 3.93298008e-02f, 9.56909731e-04f, 1.56230750e-02f, -6.80342540e-02f, -5.14747910e-02f,
  7.43853897e-02f, 3.70072246e-01f, -2.38071725e-01f, -7.24179521e-02f, -3.04294407e-01f, 1.77197380e-03f, -1.32375970e-01f, 8.05959031e-02f, 3.98462154e-02f, -1.48487343e-02f,
  -1.44739866e-01f, -1.85095891e-01f, -2.89365321e-01f, -3.95434760e-02f, -7.99898654e-02f, -1.02812283e-01f, -3.80139738e-01f, -1.90637380e-01f, -1.47048582e-03f, -1.84886679e-01f,
  -1.71724722e-01f, -1.75643533e-01f, -8.88589993e-02f, -1.78699180e-01f, -2.74898082e-01f, -6.89117387e-02f, -4.04672101e-02f, -2.24370658e-01f, 5.36480136e-02f, -3.24725747e-01f,
  4.98157948e-01f, 2.15872407e-01f, 3.30611020e-01f, 1.54513031e-01f, -1.77240968e-01f, -1.66108578e-01f, -1.98887363e-01f, -7.61053115e-02f, 1.77991286e-01f, 4.12999168e-02f,
  1.31866381e-01f, 2.58528084e-01f, 3.63816530e-01f, 2.68049568e-01f, 2.75746465e-01f, 4.41683941e-02f, 1.07692502e-01f, 4.51488465e-01f, 2.72860318e-01f, 5.08034565e-02f,
  3.15579399e-02f, 8.41588527e-02f, 2.47514024e-01f, 2.29052663e-01f, 9.54774916e-02f, 1.69168770e-01f, 2.42977887e-01f, 3.05193737e-02f, 6.28976598e-02f, 2.94340193e-01f,
  3.11014235e-01f, 2.49081954e-01f, 8.98868293e-02f, 5.37685342e-02f, 1.81405291e-01f, 1.28692761e-01f, 1.46597857e-02f, -4.92766239e-02f, -1.37717888e-01f, -1.45102695e-01f,
  4.22156341e-02f, 6.91253021e-02f, -1.10498779e-01f, -1.33899450e-01f, -3.05899698e-02f, 9.57764499e-03f, 1.26521200e-01f, 1.23712160e-01f, 1.09866671e-01f, -1.00507466e-02f,
  2.36382348e-05f, -5.15076295e-02f, -9.21366587e-02f, -3.63585614e-02f, -3.01529747e-02f, -2.46507116e-02f, -6.53766915e-02f, 4.18310761e-02f, 5.84897771e-02f, 7.71908313e-02f,
  -2.65684575e-02f, 2.24610604e-02f, 7.26787597e-02f, 8.40033069e-02f, -4.99395607e-03f, -8.86666030e-02f, -2.00141147e-01f, -1.52192116e-01f, -4.13717441e-02f, -1.13038301e-01f,
  -2.88935881e-02f, 3.33014391e-02f, -6.79202657e-03f, 9.58140567e-02f, 8.97122622e-02f, -2.24946663e-02f, -1.81769520e-01f, -3.01340818e-02f, 8.52234811e-02f, 8.87998864e-02f,
  1.15608759e-02f, -1.40044719e-01f, -1.11181527e-01f, -7.13877976e-02f, 1.27029577e-02f, -5.98096009e-03f, -7.02004656e-02f, -5.26738865e-03f, -7.23843947e-02f, -9.89995822e-02f,
  8.84604603e-02f, 2.14460835e-01f, 1.61976457e-01f, 1.22836672e-01f, -2.23099031e-02f, 1.81457642e-02f, 8.33846182e-02f, 5.55627868e-02f, -2.62840390e-02f, -1.32257402e-01f,
  -1.07628234e-01f, 2.34289169e-02f, -1.09174410e-02f, 1.25512626e-04f, -7.48071820e-02f, -3.71541791e-02f, 7.32878596e-02f, 9.34959948e-02f, 6.63313493e-02f, 1.23848677e-01f,
  -3.30878943e-02f, -1.04083516e-01f, -4.30283099e-02f, -1.81320116e-01f, -1.96691394e-01f, -1.34311169e-01f, -1.83187962e-01f, -1.53005496e-01f, -6.23677298e-02f, -2.11493284e-01f,
  -6.13075912e-01f, -1.84177384e-01f, 2.25337185e-02f, -6.72119200e-01f, -4.20267701e-01f, 6.64748847e-02f, 2.87573814e-01f, -2.30729848e-01f, -4.03581202e-01f, 3.21091451e-02f,
  -1.36217579e-01f, -3.21820021e-01f, -1.58382639e-01f, -9.53804851e-02f, -3.65221314e-02f, 3.75706553e-01f, 1.69626981e-01f, -1.91514954e-01f, -1.17841236e-01f, -4.01259810e-02f,
  -2.27811426e-01f, -4.52543706e-01f, -4.86047983e-01f, -4.61731076e-01f, -2.48596117e-01f, -2.58945376e-01f, -2.40831599e-01f, -4.01959777e-01f, -2.21722096e-01f, -2.37158775e-01f,
  4.93661284e-01f, -5.60656250e-01f, -1.52670503e-01f, -3.17357332e-01f, -2.15211287e-01f, -1.33974448e-01f, -6.68669790e-02f, -1.14532515e-01f, -1.44319430e-01f, -1.20573737e-01f,
  -3.57867718e-01f, -4.78947908e-02f, -2.24124655e-01f, -8.82627293e-02f, -7.38905743e-02f, -1.17392815e-03f, -3.58175784e-02f, -1.29907578e-01f, -6.70100749e-02f, 8.44531655e-02f,
  1.27707701e-03f, -5.14980555e-02f, -1.83664989e-02f, 2.85326503e-02f, -1.67260304e-01f, 5.42667806e-02f, 3.40347737e-03f, -7.65892640e-02f, -6.74466267e-02f, 1.53345063e-01f,
  -1.60146296e-01f, 9.97247174e-02f, 2.11531315e-02f, -6.58032522e-02f, 1.45634811e-04f, -4.28218804e-02f, 7.35570118e-02f, 1.27918288e-01f, 4.76361960e-02f, -9.36909392e-03f,
  -5.21416292e-02f, -2.12544762e-02f, -3.65257123e-03f, -3.50282863e-02f, -8.00045282e-02f, -3.96683393e-03f, -1.01017887e-02f, 8.12067613e-02f, -5.48706651e-02f, -1.33676067e-01f,
  -1.85026854e-01f, -1.05567209e-01f, -4.21829931e-02f, -1.61071774e-02f, -1.12165503e-01f, -1.21476464e-01f, -3.61774154e-02f, 1.55592067e-02f, 4.69324067e-02f, 2.64085755e-02f,
  2.63161689e-01f, -1.80611655e-01f, 1.82417572e-01f, -1.72087491e-01f, -6.03338368e-02f, -8.94603282e-02f, -7.75788203e-02f, -7.87408277e-02f, -9.36515182e-02f, 4.12572697e-02f,
  -1.22065634e-01f, -2.71886092e-04f, -5.28605990e-02f, 7.56008625e-02f, 5.06669022e-02f, 1.05526194e-01f, 9.58454013e-02f, 8.11413974e-02f, 1.04759596e-02f, 1.61953762e-01f,
  3.82693708e-02f, 1.18519574e-01f, 3.28004032e-01f, 1.71786040e-01f, 7.30414242e-02f, 9.07778069e-02f, 1.59097359e-01f, 1.37867540e-01f, 2.37303555e-01f, 4.29396778e-01f,
  -4.53881383e-01f, -2.96661466e-01f, -1.17837623e-01f, 5.75844385e-02f, 2.20700577e-01f, -2.23568846e-02f, -1.87548876e-01f, -3.03882062e-01f, -3.02909855e-02f, -3.83226611e-02f,
  8.55233073e-02f, 2.89007336e-01f, 1.27553552e-01f, 1.79989636e-01f, -1.87987462e-01f, 1.45280227e-01f, 3.16825122e-01f, 2.09907934e-01f, 4.41414453e-02f, 4.61060368e-03f,
  2.78004348e-01f, 6.94374144e-02f, -1.92944661e-01f, 1.05982393e-01f, 2.57192582e-01f, 1.80636227e-01f, 7.27209896e-02f, 2.29386780e-02f, 1.75349817e-01f, 4.27818656e-01f,
  -3.87602597e-02f, -3.58801007e-01f, 1.67680040e-01f, 2.22046286e-01f, 1.21424228e-01f, -2.27034181e-01f, -2.35222653e-01f, -1.50282905e-01f, 6.93720728e-02f, -9.82073247e-02f,
  3.74751240e-02f, -3.17341089e-02f, 9.19326097e-02f, -1.48160324e-01f, -2.82841533e-01f, -2.69061536e-01f, -1.91650748e-01f, -1.72198355e-01f, -2.88967729e-01f, -3.05344641e-01f,
  3.90691966e-01f, 2.67144650e-01f, -2.19849318e-01f, -1.21413864e-01f, -3.09787899e-01f, 5.11546582e-02f, -2.45688021e-01f, -1.65726736e-01f, -4.54840660e-01f, -4.10178721e-01f,
  2.95774266e-02f, -3.23172212e-02f, -1.55342773e-01f, 8.88376776e-03f, 8.30794424e-02f, 1.33001849e-01f, 1.77753121e-01f, 2.21860886e-01f, 7.98930824e-02f, -2.35358238e-01f,
  5.46914525e-02f, -1.79778058e-02f, 5.50408140e-02f, -7.53179640e-02f, 3.19626294e-02f, -2.94123925e-02f, 4.67955098e-02f, 2.17850525e-02f, -3.62089314e-02f, -7.65923485e-02f,
  1.48940668e-01f, -1.97339314e-03f, 7.78152002e-03f, 4.75841165e-02f, -4.59577665e-02f, 1.04796305e-01f, -8.42962414e-02f, -5.83785065e-02f, -1.06584124e-01f, -8.45720470e-02f,
  -1.41449884e-01f, 5.90877384e-02f, 1.01417322e-02f, -4.17194664e-02f, 1.33489624e-01f, 6.28408566e-02f, 9.74183381e-02f, -5.61322980e-02f, 9.36916769e-02f, -1.65853947e-01f,
  -1.48627266e-01f, -1.57530576e-01f, 3.55414636e-02f, -6.62311986e-02f, -2.38235351e-02f, -4.45744991e-02f, 3.47389765e-02f, 1.29244387e-01f, -1.39328286e-01f, -1.93640664e-01f,
  9.54419598e-02f, -2.99725775e-02f, -1.28073260e-01f, -1.31439790e-01f, -1.87947869e-01f, -1.18911587e-01f, -1.42407203e-02f, -1.25870585e-01f, -3.15306932e-01f, -4.17953879e-01f,
  4.96381134e-01f, -9.14663076e-02f, -7.89075971e-01f, 2.12005094e-01f, -4.61637586e-01f, -3.64717335e-01f, 3.10620610e-02f, 3.08220774e-01f, 3.90274823e-01f, 1.55654475e-01f,
  -1.59030169e-01f, -6.65587857e-02f, -1.61440820e-01f, -2.28377238e-01f, -7.81193748e-02f, -2.24916860e-01f, -2.59904444e-01f, -4.41482425e-01f, -4.27474499e-01f, -8.19975957e-02f,
  -6.05210997e-02f, 8.23774114e-02f, 2.94370279e-02f, 4.19403985e-02f, -4.17131968e-02f, -5.58770448e-02f, -2.66493529e-01f, -2.19395131e-01f, -2.08720535e-01f, -2.91926473e-01f,
  -5.83898246e-01f, -2.88765073e-01f, -7.08289966e-02f, 3.67962383e-02f, -5.60620688e-02f, 2.00953931e-01f, 1.76079907e-02f, 1.21405691e-01f, 2.34504595e-01f, -4.26218733e-02f,
  -2.98909619e-02f, -3.28623727e-02f, -4.59253695e-03f, -1.01755224e-01f, -9.29889083e-02f, -1.02050401e-01f, 4.65471521e-02f, -6.03867881e-02f, -4.25391831e-02f, -5.24920113e-02f,
  -1.32454872e-01f, -1.87526852e-01f, -2.73037434e-01f, -2.36776948e-01f, -1.25341669e-01f, -2.75145143e-01f, -3.68728578e-01f, -3.05801719e-01f, -2.16634527e-01f, 4.96093743e-02f,
  8.78486186e-02f, 7.39561319e-02f, 1.03755459e-01f, 1.20421156e-01f, 2.43834123e-01f, 1.69067189e-01f, 8.88567641e-02f, 1.80936363e-02f, 4.18620296e-02f, 1.45733967e-01f,
  -2.30977200e-02f, 9.03313905e-02f, 8.56335834e-02f, 6.53982386e-02f, -2.36975346e-02f, -8.34031031e-02f, 1.10364504e-01f, 5.61073050e-02f, 6.29195049e-02f, 1.23555124e-01f,
  -1.40218120e-02f, -9.64034945e-02f, 4.04209830e-02f, 4.79191095e-02f, -1.58029854e-01f, -1.24338746e-01f, -1.08430326e-01f, 1.11882858e-01f, -6.72838315e-02f, -1.07704684e-01f,
  4.13871497e-01f, -2.43203446e-01f, 5.56812696e-02f, -4.40333709e-02f, 3.01199239e-02f, -1.06557198e-02f, -3.22205015e-03f, 1.73916176e-01f, 9.68205854e-02f, 6.28098696e-02f,
  -4.09375578e-02f, 8.04356188e-02f, -2.30960026e-02f, -5.37812598e-02f, -1.15119375e-01f, -4.07490544e-02f, 5.31916507e-02f, -1.18231200e-01f, 6.38022125e-02f, 7.66070634e-02f,
  1.36809990e-01f, 2.79972613e-01f, 2.19402894e-01f, 8.35514516e-02f, -1.98806878e-02f, 1.24627456e-01f, -5.31025715e-02f, 5.30985780e-02f, 4.25004028e-02f, 5.09140968e-01f,
  4.32315499e-01f, 2.46843830e-01f, 2.90939659e-01f, 2.78918952e-01f, 3.82819027e-01f, 5.03057420e-01f, 5.88606298e-01f, 3.83035362e-01f, 2.12964833e-01f, 2.25221008e-01f,
  1.54571384e-01f, -1.24245621e-01f, -2.26578526e-02f, -1.70052573e-02f, 1.36719629e-01f, 1.99760526e-01f, 1.18324772e-01f, 5.99528328e-02f, 1.71582684e-01f, 2.75910586e-01f,
  5.49428798e-02f, 2.17025965e-01f, 1.68994233e-01f, 1.47906452e-01f, 4.15203869e-02f, -1.49140470e-02f, 1.79014236e-01f, 1.49987563e-01f, -5.21777256e-04f, -5.14920615e-02f,
  -1.59960434e-01f, 2.95133382e-01f, -1.74101919e-01f, -1.64521545e-01f, -7.61801451e-02f, -1.09774500e-01f, -4.44393009e-02f, -1.23447292e-01f, -1.01672441e-01f, -3.26127256e-03f,
  -2.07545161e-02f, 1.78608950e-02f, 1.43159002e-01f, -6.68559130e-03f, 1.16188250e-01f, 6.09552413e-02f, 4.33160216e-02f, 1.01266047e-02f, 2.02857293e-02f, -5.21026216e-02f,
  -1.06569678e-01f, -3.52909639e-02f, 4.99795526e-02f, 8.51931646e-02f, 2.22074683e-03f, -2.32447758e-01f, -5.76685555e-02f, -1.06720664e-01f, -1.28062636e-01f, 5.43627478e-02f,
  2.88472306e-02f, -1.23457089e-01f, 2.72357110e-02f, -4.60122190e-02f, 4.78140749e-02f, 4.89185518e-03f, -4.90330486e-03f, 3.05992384e-02f, 1.23547569e-01f, 2.01140165e-01f,
  1.69248685e-01f, 1.64525166e-01f, 9.22349915e-02f, 2.34823510e-01f, -1.34830931e-02f, 3.33801508e-02f, 5.48590571e-02f, 1.57433674e-02f, 7.98344016e-02f, 1.49892211e-01f,
  2.50134498e-01f, 2.59250905e-02f, 1.05361000e-01f, 1.39854252e-01f, 6.03016652e-02f, -1.11860493e-02f, 9.70610604e-02f, 7.68897310e-02f, 2.16580480e-01f, 1.35900512e-01f,
  -1.28984094e-01f, -2.80324239e-02f, -1.61266088e-01f, -1.75141245e-01f, -8.83472040e-02f, -2.94672996e-02f, -4.46509533e-02f, -2.10170418e-01f, -1.69234186e-01f, -5.27729020e-02f,
  -5.43207563e-02f, -1.97583064e-01f, -2.25555301e-02f, -1.21748690e-02f, 4.19806764e-02f, -1.35404676e-01f, -1.22414626e-01f, -9.58661661e-02f, -2.54767865e-01f, -2.72034377e-01f,
  -5.29066324e-02f, -1.54543459e-01f, -1.22235883e-02f, -2.32531149e-02f, -9.96547267e-02f, -1.71538457e-01f, -6.82090968e-02f, -5.33726625e-02f, -7.12031797e-02f, 4.23465073e-02f,
  -3.87848690e-02f, -4.59997147e-01f, -3.83217126e-01f, -4.62687910e-01f, -4.54076320e-01f, -3.01376164e-01f, -5.93307197e-01f, -3.53353500e-01f, -1.78806782e-01f, -5.39193273e-01f,
  -3.46309185e-01f, 1.56098112e-01f, -8.16629007e-02f, 5.29387221e-03f, -3.48098800e-02f, -5.92374325e-01f, -4.63535875e-01f, 6.21235408e-02f, 2.76625663e-01f, -3.45373787e-02f,
  -1.88404471e-01f, -2.01360673e-01f, 1.16558939e-01f, -2.04193387e-02f, -4.89244968e-01f, -1.43178195e-01f, -4.68271196e-01f, -1.72851324e-01f, -1.80078089e-01f, -5.94268024e-01f,
  -3.13319892e-01f, 3.38669680e-02f, -1.44060710e-02f, 8.19607154e-02f, -2.17527255e-01f, 1.08619854e-02f, -1.17640100e-01f, -7.35721216e-02f, 5.15712835e-02f, -2.24767238e-01f,
  -2.37258244e-02f, 1.14701211e-03f, -5.79861589e-02f, -5.59851341e-02f, -9.80623662e-02f, -9.19670612e-02f, -1.23475447e-01f, -3.87915857e-02f, 9.65316221e-02f, 7.88437650e-02f,
  2.97694393e-02f, 1.67624764e-02f, 1.56154081e-01f, -3.28143593e-03f, 1.35122433e-01f, 1.46534726e-01f, -1.14472490e-02f, 7.22263008e-02f, 2.34039515e-01f, -2.27267534e-01f,
  -7.29630217e-02f, 2.61746123e-02f, 5.80187738e-02f, 2.93430109e-02f, 4.39421088e-02f, 3.12902369e-02f, 1.30070765e-02f, -9.75055397e-02f, 5.34574352e-02f, 2.68408041e-02f,
  -6.07163869e-02f, 1.86901130e-02f, -4.04987969e-02f, 2.66349409e-02f, -6.29963055e-02f, 1.17469259e-01f, -2.83883289e-02f, -6.87841251e-02f, -2.50691269e-02f, 2.38355789e-02f,
  1.27474830e-01f, 4.91420478e-02f, 1.19849667e-01f, -4.07224484e-02f, 4.92624454e-02f, -4.00795676e-02f, -1.45005304e-02f, 4.00669612e-02f, 3.35852765e-02f, 1.47061795e-01f,
  -3.05037290e-01f, 1.13217123e-01f, -3.19657773e-01f, 6.92430465e-03f, -3.04003339e-02f, 1.87272150e-02f, -2.43215524e-02f, -2.82443914e-04f, 3.92877907e-02f, -4.43335101e-02f,
  6.78938776e-02f, -6.32630568e-03f, -8.87141675e-02f, -5.64231463e-02f, -8.30404386e-02f, -4.53202054e-02f, -2.45170444e-02f, 1.57495160e-02f, 2.07989588e-01f, 8.40194523e-02f,
  1.09911196e-01f, 1.16010875e-01f, 5.35706840e-02f, 8.03019628e-02f, 1.33812606e-01f, 6.37043715e-02f, -9.96804163e-02f, 7.61696547e-02f, 1.10075958e-01f, -3.46254230e-01f,
  -5.95950723e-01f, -3.93240094e-01f, -2.69691676e-01f, -4.07506466e-01f, 3.32606845e-02f, -1.15682431e-01f, -2.32090935e-01f, 1.22972339e-01f, 1.09411128e-01f, -2.07756251e-01f,
  -1.11575842e-01f, 1.53647326e-02f, -3.76210660e-01f, -2.87171721e-01f, -4.53910530e-01f, -5.17293096e-01f, -4.28797543e-01f, -2.34428734e-01f, 8.00872371e-02f, 2.85229266e-01f,
  1.84255064e-01f, -1.39964735e-02f, 4.09304872e-02f, 6.56441450e-02f, -6.42643943e-02f, -1.24827683e-01f, -1.26856863e-01f, -2.34264895e-01f, -1.86955750e-01f, -4.44640994e-01f,
  -4.36196059e-01f, -2.00804606e-01f, 2.13212296e-01f, -9.41468999e-02f, 7.70606175e-02f, 5.07509783e-02f, -1.24399653e-02f, -9.41586345e-02f, -4.89034802e-02f, -1.17129460e-02f,
  -1.86229311e-02f, 7.89904296e-02f, 4.14809436e-02f, 1.16918571e-01f, 1.40308902e-01f, -1.24916628e-01f, 1.23162366e-01f, 6.84621092e-03f, -1.43685669e-01f, 1.19656049e-01f,
  -2.86005363e-02f, -2.00952426e-01f, -3.18426728e-01f, -1.96671784e-02f, 8.48113745e-02f, -6.93563521e-02f, 5.94213605e-02f, 3.06955702e-03f, -7.69072399e-02f, -3.88907611e-01f,
  2.00464785e-01f, -2.43408382e-02f, 8.32246058e-03f, 5.61364964e-02f, 4.05087173e-02f, 1.30358607e-01f, 1.62387323e-02f, -1.04626559e-01f, 1.84409916e-01f, 5.23684360e-02f,
  1.25802159e-01f, 1.93915814e-02f, 4.66580316e-02f, 4.39370088e-02f, -8.80003348e-02f, -6.10824600e-02f, -1.13906987e-01f, -1.17218092e-01f, -1.18808910e-01f, -1.81033108e-02f,
  -1.42575979e-01f, -2.49412172e-02f, -1.98957901e-02f, -1.05724849e-01f, -6.89594224e-02f, -1.78284809e-01f, -4.07581553e-02f, -6.96684718e-02f, -5.14639206e-02f, -2.46500522e-02f,
  -3.20881546e-01f, -1.48306578e-01f, -4.70622271e-01f, 5.36133423e-02f, -3.40802572e-03f, -5.70872873e-02f, -1.75833300e-01f, -1.33491725e-01f, -1.69648290e-01f, 1.04922958e-01f,
  1.99157014e-01f, 1.33434609e-01f, -1.02364339e-01f, 1.37659863e-01f, 1.39682263e-01f, 2.57644840e-02f, -1.22138252e-02f, -1.71303913e-01f, -1.37477428e-01f, 1.92837775e-01f,
  2.15503783e-03f, -3.16733271e-01f, -6.29067183e-01f, -2.80217171e-01f, -1.27355590e-01f, -4.03189093e-01f, -2.33540908e-01f, -3.14750969e-01f, -4.42064106e-01f, -6.05924964e-01f,
  -1.71893016e-01f, -2.52919853e-01f, -3.03292245e-01f, -2.83034444e-01f, -2.73350626e-01f, -2.69088507e-01f, -2.24360287e-01f, -1.95905846e-02f, -3.01643670e-01f, -3.23223591e-01f,
  4.30683047e-02f, 3.37653875e-01f, 2.39685178e-01f, 2.65196592e-01f, 2.77900726e-01f, -3.78405154e-01f, -5.38553774e-01f, -1.09511115e-01f, 4.28288013e-01f, 2.99892724e-01f,
  -8.94394424e-03f, -1.55153170e-01f, 7.23451227e-02f, 1.81470454e-01f, -1.46447361e-01f, 2.55213100e-02f, -3.85146171e-01f, -3.19976658e-01f, -2.05268800e-01f, -4.95601505e-01f,
  5.12629747e-01f, -1.52440891e-01f, -7.25642517e-02f, -7.50971809e-02f, -6.80141449e-02f, 6.07983321e-02f, -7.44444365e-03f, -2.31399804e-01f, -1.84054673e-01f, -2.42829338e-01f,
  -1.29024297e-01f, 4.41045128e-02f, -6.83566555e-02f, -2.38595363e-02f, -5.94243295e-02f, 1.22263573e-01f, -1.29665345e-01f, -1.20670274e-01f, -1.78585604e-01f, 7.89820850e-02f,
  1.19063191e-01f, -2.03625605e-01f, -8.67708176e-02f, -8.06970149e-02f, 3.90645023e-03f, -1.11506447e-01f, -3.29713002e-02f, -3.30511779e-02f, -1.04893759e-01f, -1.83752328e-01f,
  6.28845347e-03f, -1.87130366e-02f, -3.28297317e-02f, 3.79837453e-02f, -9.60591659e-02f, -1.05341688e-01f, -5.92135713e-02f, 2.29561497e-02f, -1.05346419e-01f, 9.39346477e-02f,
  3.86843868e-02f, -2.60430276e-02f, -4.67577986e-02f, 1.61011312e-02f, -1.11489326e-01f, -1.82626292e-01f, -6.75040931e-02f, 3.71753909e-02f, -4.40347008e-02f, -1.07438155e-01f,
  -1.48255438e-01f, -1.06287375e-01f, -2.39319708e-02f, 1.06699593e-01f, -4.95348275e-02f, 1.77326165e-02f, -8.55967328e-02f, 8.57171342e-02f, 1.94191396e-01f, -1.22280784e-01f,
  4.84517187e-01f, -4.68337387e-02f, 7.72864819e-02f, 6.75575435e-02f, -1.64710596e-01f, -1.00158423e-01f, -1.29992500e-01f, -1.09642796e-01f, -5.22891432e-02f, 1.92532800e-02f,
  7.64995366e-02f, 1.41978309e-01f, -7.19665438e-02f, 5.86142647e-04f, -5.37676737e-02f, 3.49566266e-02f, 2.29996573e-02f, -1.06070740e-02f, -1.78107798e-01f, -4.31055464e-02f,
  -2.00689152e-01f, -1.37708083e-01f, 2.21264735e-01f, -4.06249836e-02f, -7.61574060e-02f, 7.86097944e-02f, 9.70492661e-02f, 9.65614095e-02f, 2.19499737e-01f, 1.22420818e-01f,
  4.06756774e-02f, -2.33971775e-01f, 8.51811692e-02f, 2.67399192e-01f, 2.30118215e-01f, 1.15445577e-01f, 3.20078246e-02f, 1.01975657e-01f, 2.05389798e-01f, 1.80965841e-01f,
  2.45006844e-01f, 3.39111358e-01f, 3.87017995e-01f, 3.04412246e-01f, 1.83059633e-01f, 1.60971120e-01f, 1.60401776e-01f, 2.07172617e-01f, 1.12265997e-01f, 1.97467729e-01f,
  2.42667407e-01f, 7.34118968e-02f, -7.47822179e-03f, 3.49069349e-02f, 2.42751790e-03f, 2.66026080e-01f, -5.39985346e-03f, 5.63582331e-02f, 2.28181053e-02f, -4.98884358e-02f,
  1.33356318e-01f, -1.63884372e-01f, 1.45200297e-01f, 2.15450469e-02f, -1.51027188e-01f, -1.91821232e-01f, 6.40103519e-02f, -1.88204512e-01f, -7.74649307e-02f, -3.28570344e-02f,
  2.02415008e-02f, -1.14531048e-01f, -3.75665240e-02f, -1.21238257e-03f, -2.32603345e-02f, -6.33378997e-02f, -1.36583373e-01f, -4.39305790e-02f, 7.51609728e-02f, 5.02731018e-02f,
  -4.28711856e-03f, -4.46766801e-02f, 1.22029118e-01f, 3.64074595e-02f, 8.98481011e-02f, 2.28115600e-02f, -4.46578935e-02f, 3.43094356e-02f, 3.29224765e-02f, 6.82516769e-03f,
  3.37851316e-01f, 1.88548431e-01f, 1.67359635e-01f, 8.40519816e-02f, 3.10075767e-02f, -1.12190405e-02f, 2.42331866e-02f, 7.96831921e-02f, 1.41349122e-01f, -4.44679186e-02f,
  5.57686836e-02f, 1.58140004e-01f, -4.09095101e-02f, 1.13410786e-01f, 4.91782874e-02f, 3.18970531e-02f, 2.24757623e-02f, 6.39481992e-02f, 6.67837029e-03f, 5.93929589e-02f,
  8.84188861e-02f, -9.20693949e-02f, -1.23062208e-01f, -7.01546893e-02f, -1.62342582e-02f, 1.96168110e-01f, 9.98999774e-02f, 1.20718494e-01f, 3.62021066e-02f, -1.29449189e-01f,
  3.81390929e-01f, 3.61062139e-01f, 2.03728259e-01f, 4.84396890e-02f, -1.35248184e-01f, -2.32318044e-01f, 1.36211783e-01f, -1.55438870e-01f, -2.27357820e-01f, -6.20896704e-02f,
  -1.30559951e-01f, -1.68708771e-01f, -1.31276533e-01f, -1.62255690e-02f, -3.33240367e-02f, -1.11168511e-01f, -8.12012702e-02f, 4.42355461e-02f, -4.76119407e-02f, -1.50836721e-01f,
  -1.47594616e-01f, 1.08077705e-01f, 2.42876992e-01f, 1.64691910e-01f, 1.05514906e-01f, 1.63654059e-01f, 1.42239124e-01f, 1.45261540e-04f, 8.64099786e-02f, 9.05014277e-02f,
  -6.76876664e-01f, 1.92940041e-01f, -3.61940235e-01f, -8.19969535e-01f, -1.75438896e-01f, 1.95631072e-01f, 6.22221768e-01f, 3.10194314e-01f, -9.19710398e-02f, 2.29364038e-01f,
  -5.66212507e-03f, -4.75684106e-01f, -4.62562054e-01f, -1.79702863e-01f, -1.36224136e-01f, 2.79072195e-01f, -1.66594639e-01f, -3.96503538e-01f, -3.09769988e-01f, 9.91251767e-02f,
  4.41395603e-02f, -3.39079767e-01f, -5.23122966e-01f, -1.83165357e-01f, -2.15062685e-02f, -1.59559608e-01f, -7.37900957e-02f, -2.71694303e-01f, 1.80148065e-01f, -1.04960881e-01f,
  -1.94569245e-01f, -2.00220555e-01f, -8.44958238e-03f, -1.14917971e-01f, -4.23751660e-02f, -7.35602379e-02f, 9.06294659e-02f, -3.64616774e-02f, -1.24171011e-01f, 2.74491478e-02f,
  -2.79657185e-01f, -4.64968421e-02f, -3.12165439e-01f, -3.26768309e-02f, -1.51363671e-01f, -1.87710710e-02f, -8.84880051e-02f, -2.38646969e-01f, -7.12594315e-02f, 1.70565531e-01f,
  1.68850809e-01f, -1.08348012e-01f, -1.08146816e-01f, 3.62637907e-01f, 2.14067642e-02f, -2.76268512e-01f, 1.66787043e-01f, 6.85090572e-02f, 1.24460816e-01f, 2.22390637e-01f,
  2.57382751e-01f, 3.41009488e-03f, -7.17393383e-02f, -3.26078832e-02f, 1.75416991e-01f, -2.65666991e-02f, -7.38512278e-02f, 9.74082574e-02f, 1.42849803e-01f, 2.20621508e-02f,
  1.03108756e-01f, 9.80960727e-02f, -2.45674085e-02f, 2.05222089e-02f, 2.18741950e-02f, -1.45474344e-01f, 6.99869590e-03f, 5.23759536e-02f, 7.67958239e-02f, -4.53090072e-02f,
  -1.33078685e-02f, -3.48266156e-04f, -1.18617073e-01f, -4.59064133e-02f, 1.77110523e-01f, -7.92428758e-03f, 3.94380763e-02f, 1.43351346e-01f, -6.06359951e-02f, -7.50015676e-02f,
  -7.37222955e-02f, -2.89732404e-02f, -1.92033604e-01f, 6.26191646e-02f, -7.52680823e-02f, -3.73405330e-02f, -1.43640578e-01f, 7.76086003e-02f, -1.21286422e-01f, 3.38515565e-02f,
  -1.13555393e-03f, 9.32045430e-02f, -1.97033480e-01f, 1.37339327e-02f, -6.26577809e-02f, -6.16438538e-02f, 1.87727883e-01f, -2.26588368e-01f, -9.02936012e-02f, 9.91825238e-02f,
  1.25623718e-01f, 8.71350765e-02f, -9.28837508e-02f, 8.43410343e-02f, 2.67688390e-02f, -1.21357135e-01f, -1.79204866e-02f, 1.47947833e-01f, 9.39398706e-02f, 1.87470213e-01f,
  3.88082594e-01f, -3.63803387e-01f, 1.77166581e-01f, 1.75000951e-01f, 3.43901306e-01f, 4.52824563e-01f, 4.69043732e-01f, 9.90682989e-02f, 1.64706200e-01f, -2.82830764e-02f,
  -3.29030633e-01f, -6.34973407e-01f, -5.61349750e-01f, -3.99304867e-01f, -2.77508706e-01f, 7.61264116e-02f, 1.79171711e-01f, 1.58814207e-01f, 2.55464345e-01f, 1.68111190e-01f,
  5.50491437e-02f, 2.32418790e-01f, 2.49127239e-01f, -4.10903729e-02f, -3.20665129e-02f, -4.47927378e-02f, 1.56043366e-01f, 1.12170279e-01f, -9.39281434e-02f, -2.96396494e-01f,
  -2.86184847e-01f, 5.72926924e-02f, 8.85541439e-02f, -1.50218397e-01f, -1.11134894e-01f, -1.23405606e-01f, -1.14807896e-01f, -2.55437225e-01f, -1.37638599e-01f, -9.38276798e-02f,
  -1.84902564e-01f, -1.77753016e-01f, -2.22298086e-01f, -1.44210681e-01f, 6.06722496e-02f, 3.60775664e-02f, -1.45248026e-01f, -2.48023152e-01f, -2.21116871e-01f, -1.64650202e-01f,
  -2.79249281e-01f, 4.19871807e-02f, 1.65146366e-01f, 4.91514802e-02f, -1.00239329e-01f, -6.07696064e-02f, -6.07988425e-02f, -8.64042565e-02f, -4.56150398e-02f, -8.56789295e-03f,
  2.55229138e-03f, 3.48819569e-02f, 7.15867132e-02f, 7.24832118e-02f, 1.35462388e-01f, 7.19808713e-02f, -6.85646683e-02f, -1.96991656e-02f, 2.81390790e-02f, 6.08682819e-02f,
  -1.08306766e-01f, 1.24499621e-02f, -3.32238451e-02f, 1.01715274e-01f, -7.36120939e-02f, 5.68069704e-02f, 5.11288792e-02f, -6.58806041e-02f, -1.25153273e-01f, 2.48239815e-01f,
  -3.98585275e-02f, 6.64671557e-03f, 1.75521262e-02f, -1.50239915e-01f, -5.06235659e-02f, -2.28239391e-02f, -3.80586646e-02f, -8.36989805e-02f, -2.24588290e-02f, 4.36712317e-02f,
  -6.06470332e-02f, -2.26654615e-02f, 8.66278857e-02f, -8.90673548e-02f, 3.42911072e-02f, -1.77294165e-01f, -3.09088193e-02f, -4.89322841e-02f, -6.01733811e-02f, -2.87305843e-02f,
  -9.78611484e-02f, -1.71022594e-01f, -1.55001685e-01f, -4.09611613e-02f, 1.75499871e-01f, 6.63887858e-02f, -2.74302159e-02f, 1.05171409e-02f, -9.94162932e-02f, -3.59583385e-02f,
  -6.44586459e-02f, 2.19663978e-01f, 1.17268458e-01f, 8.18036869e-03f, 4.06938232e-02f, 2.84006447e-01f, 6.40862659e-02f, 5.84521256e-02f, 2.02291429e-01f, 4.17284340e-01f,
  -1.11196421e-01f, 2.95415483e-02f, 1.13375209e-01f, 9.17579606e-02f, 1.90044940e-01f, -2.22624063e-01f, -2.66751677e-01f, -3.79119217e-01f, -6.23298548e-02f, 1.75152496e-01f,
  2.17333570e-01f, -1.72256455e-02f, -2.63412409e-02f, -1.89683542e-01f, -6.35098338e-01f, -2.92243510e-01f, -1.37887582e-01f, -4.83251780e-01f, -6.51677907e-01f, -4.52421397e-01f,
  -1.92146510e-01f, -2.32873589e-01f, -2.85772413e-01f, -2.52722085e-01f, 2.58135796e-01f, -7.90039822e-02f, 5.05991355e-02f, 3.96784507e-02f, 1.19810700e-02f, 3.23570758e-01f,
  2.55848765e-01f, 1.34805664e-01f, -1.57768592e-01f, -8.71704146e-02f, 1.54879913e-01f, -2.79769837e-03f, -1.56947821e-01f, -8.86660218e-02f, -1.25986204e-01f, -1.18942801e-02f,
  1.45168260e-01f, -2.04591118e-02f, 1.56390071e-01f, 8.31474662e-02f, -1.43433154e-01f, -1.57024190e-01f, -1.47476688e-01f, -2.72376776e-01f, -1.63390055e-01f, -1.99261010e-02f,
  -2.49378458e-02f, 1.00699209e-01f, -1.79114148e-01f, -1.60637021e-01f, -8.07439089e-02f, -6.33729622e-02f, 5.94066828e-02f, -4.65702787e-02f, -2.65246242e-01f, -6.00689314e-02f,
  5.37216850e-02f, 8.61480739e-03f, 4.55807103e-03f, -7.36148804e-02f, -3.28424573e-02f, 1.82891801e-01f, -8.49273929e-04f, -1.23068932e-02f, -1.49189919e-01f, -1.13970719e-01f,
  -1.77668817e-02f, 1.23018231e-02f, 2.86399294e-02f, 1.30754998e-02f, -2.20965669e-02f, -7.62479082e-02f, -4.64238180e-03f, -1.19468279e-01f, -1.08545512e-01f, -2.19458584e-02f,
  -2.13081334e-02f, 6.32512346e-02f, 1.39703438e-01f, -2.38366183e-02f, 2.81577948e-02f, -3.98127064e-02f, 7.86562935e-02f, -6.77021071e-02f, -1.93860624e-02f, 9.97901857e-02f,
  -3.47684510e-02f, -4.79705818e-02f, 9.71244052e-02f, -1.45249337e-01f, -7.30866715e-02f, 1.02759600e-01f, 1.85150772e-01f, 5.19246347e-02f, 8.37763995e-02f, -8.61843750e-02f,
  -1.71675414e-01f, 4.35524695e-02f, 2.94831544e-01f, -6.25944138e-02f, -1.89402789e-01f, 6.01516180e-02f, -4.26662676e-02f, 8.62211287e-02f, -1.20249964e-01f, 3.71106318e-03f,
  -5.94248623e-02f, -3.35440189e-01f, -1.37555808e-01f, -6.33512214e-02f, -6.05259091e-02f, -1.27396256e-01f, -1.54204756e-01f, -1.59504861e-01f, -3.57626110e-01f, -2.74145931e-01f,
  4.89910543e-01f, 2.18595266e-01f, -6.53355271e-02f, 1.62485838e-01f, -3.41670930e-01f, -4.16783988e-01f, -3.43333513e-01f, -1.90683961e-01f, 3.99702042e-02f, 1.72666103e-01f,
  -1.36123404e-01f, -4.77585196e-02f, 1.49838310e-02f, -3.80524956e-02f, -1.67206407e-01f, 5.08274473e-02f, 8.59723911e-02f, -5.55724241e-02f, -3.52694809e-01f, -2.17223957e-01f,
  3.84110250e-02f, 1.09578677e-01f, 2.79218912e-01f, -4.25839461e-02f, 2.63269722e-01f, 9.89579409e-03f, 2.24915519e-01f, 1.87059969e-01f, 5.66249080e-02f, 4.72241282e-01f,
  2.18847573e-01f, 3.96819450e-02f, 1.22135608e-02f, 1.56367585e-01f, -3.67024331e-03f, 1.61653772e-01f, 7.01866373e-02f, 1.83271796e-01f, -7.79486299e-02f, -6.05518669e-02f,
  2.20887940e-02f, -1.58802420e-01f, -1.58762410e-01f, -1.14124514e-01f, -1.21452928e-01f, -1.85607359e-01f, 4.88344580e-02f, 3.30875777e-02f, -4.56574261e-02f, -4.75344248e-03f,
  -1.77559316e-01f, 2.29312778e-02f, -5.02790399e-02f, -8.55962709e-02f, -2.29594499e-01f, -3.37732673e-01f, -1.47231549e-01f, -1.67329416e-01f, -1.47749215e-01f, 2.73286074e-01f,
  -1.07934020e-01f, -7.82717988e-02f, -1.48880795e-01f, -6.22334927e-02f, -1.23275071e-01f, -1.45823717e-01f, -1.04587063e-01f, -1.31198347e-01f, -2.53986806e-01f, -7.79084638e-02f,
  -1.39680356e-01f, -1.90063994e-02f, -1.10925019e-01f, 3.98130789e-02f, 3.81029546e-02f, -1.28297908e-02f, -1.01866238e-02f, -6.19035549e-02f, -1.30575836e-01f, -9.93923843e-02f,
  -8.92359316e-02f, -5.44808917e-02f, 8.64084810e-02f, -5.47203002e-03f, 2.80118436e-02f, 5.20892302e-03f, 5.05079888e-02f, -7.66749233e-02f, -7.77605921e-02f, 1.79904237e-01f,
  2.25088626e-01f, -2.92714775e-01f, 2.63442397e-01f, 1.49583161e-01f, -3.40575092e-02f, 2.87973210e-02f, 5.72330840e-02f, -1.54655173e-01f, -1.61026016e-01f, -1.21790342e-01f,
  -1.08540608e-02f, -1.79867923e-01f, 1.65237471e-01f, -1.91494711e-02f, -5.39816096e-02f, 7.66697899e-02f, 1.04783736e-02f, -3.85550074e-02f, 1.83304250e-02f, -7.75685459e-02f,
  -2.25455835e-02f, -8.91289860e-02f, -1.62502736e-01f, -3.21978778e-02f, 8.74130949e-02f, -1.08835831e-01f, -1.34308845e-01f, -7.09721074e-02f, -2.38186613e-01f, 3.73534337e-02f,
  6.20626330e-01f, 7.16617778e-02f, 2.26027414e-01f, 1.41487226e-01f, -3.54194194e-01f, -4.45761681e-01f, -4.57362562e-01f, -3.16767156e-01f, -9.72299501e-02f, 1.45174176e-01f,
  7.69894421e-02f, -5.32351760e-03f, -6.08759560e-02f, -4.04327065e-02f, 4.78901528e-02f, 1.63169391e-02f, 1.37639746e-01f, 2.86650300e-01f, 2.21258000e-01f, 1.29734278e-01f,
  7.01258406e-02f, 1.87826797e-01f, 3.44227731e-01f, 1.57713853e-02f, 4.35532779e-02f, -3.69572490e-02f, 7.19603896e-02f, 2.40865842e-01f, 1.64162546e-01f, 3.65556538e-01f,
  5.27803540e-01f, 1.76371768e-01f, -3.17681670e-01f, -4.26553339e-02f, 7.94269443e-02f, 1.00281239e-01f, -2.13529821e-02f, 1.06159106e-01f, -4.90285531e-02f, 8.80575255e-02f,
  -1.57423783e-02f, 1.26680732e-01f, -1.46097168e-01f, 2.59118900e-02f, -4.82611135e-02f, -6.55343682e-02f, -8.70669931e-02f, 6.13920912e-02f, -6.72128052e-02f, 8.85172263e-02f,
  -1.02183580e-01f, -8.10026526e-02f, -1.36203259e-01f, -3.61176282e-01f, -2.58906484e-02f, -4.48965281e-02f, -6.40485138e-02f, 1.63060650e-02f, -7.07035437e-02f, 1.21555835e-01f,
  2.84621954e-01f, 1.56978339e-01f, 7.12116957e-02f, 1.26515761e-01f, 1.94761544e-01f, 1.00144528e-01f, 2.36222208e-01f, 5.68596497e-02f, 1.70886859e-01f, 1.22786991e-01f,
  -4.10679318e-02f, 2.07904562e-01f, 4.13083918e-02f, 3.69751528e-02f, -1.01037063e-01f, 2.29715724e-02f, 1.41668931e-01f, 7.87305534e-02f, 9.08249319e-02f, 3.52435298e-02f,
  -2.00717133e-02f, 9.97522622e-02f, 8.17798078e-02f, 1.17461167e-01f, 2.25017276e-02f, 5.42984977e-02f, 1.40624911e-01f, 5.68463057e-02f, 2.13330537e-01f, 1.08808108e-01f,
  -3.71871710e-01f, -4.45259333e-01f, 8.54075104e-02f, -9.05597731e-02f, 1.20613202e-01f, -7.22267702e-02f, 6.94386810e-02f, -6.09032996e-02f, 6.82578906e-02f, 1.73857957e-01f,
  2.02976656e-03f, 9.84356254e-02f, -1.15707152e-01f, 1.91652235e-02f, 1.13437384e-01f, -9.62024927e-02f, 2.63033938e-02f, -8.17933232e-02f, -1.70483232e-01f, 1.52985472e-02f,
  -1.03368349e-01f, -2.29185626e-01f, -1.67066231e-01f, -4.43933934e-01f, -1.39963582e-01f, -1.67293996e-01f, -1.03090271e-01f, -1.38428301e-01f, -2.04135910e-01f, -2.05467194e-01f,
  -7.63893604e-01f, 4.56918806e-01f, 1.97881535e-01f, -1.55833021e-01f, 3.07155490e-01f, 3.35714340e-01f, 3.58702779e-01f, -4.25686203e-02f, -1.68784037e-01f, 1.48318365e-01f,
  1.80678427e-01f, 3.12313233e-02f, 2.07120087e-02f, -1.14917252e-02f, -1.13775842e-01f, 2.27496877e-01f, 3.20372880e-01f, -5.39072901e-02f, -1.90406412e-01f, -6.17720895e-02f,
  5.81592172e-02f, -1.46740124e-01f, -5.02172709e-01f, -2.04539269e-01f, 1.17957219e-01f, -3.71049717e-02f, 6.57527074e-02f, 2.57806317e-03f, 1.49817988e-01f, 2.93701470e-01f,
  -4.96670812e-01f, -4.18232650e-01f, -5.56063615e-02f, -4.51192185e-02f, -9.02526155e-02f, -2.06554428e-01f, -7.90371299e-02f, -1.92198470e-01f, 2.15908010e-02f, -7.71473870e-02f,
  -7.08251521e-02f, -6.41308203e-02f, 1.64753929e-01f, 4.33308892e-02f, -2.70963699e-01f, -7.70062506e-02f, -7.86883086e-02f, -2.80426800e-01f, -2.89794534e-01f, -8.57564341e-03f,
  5.77880621e-01f, 4.29111831e-02f, -2.57277459e-01f, 1.19038433e-01f, -1.01212382e-01f, -1.13259286e-01f, -2.39711910e-01f, -3.33017439e-01f, -3.31145108e-01f, -4.80670154e-01f,
  1.70828737e-02f, -2.83136815e-02f, 1.08100191e-01f, -2.64668781e-02f, 2.16554087e-02f, 1.48245338e-02f, 1.83767397e-02f, 1.03832193e-01f, 2.40977313e-02f, -7.34659517e-03f,
  8.08847770e-02f, -5.78043610e-02f, -8.49846601e-02f, -3.93253937e-02f, -1.55236032e-02f, 6.13248572e-02f, 6.61061853e-02f, -1.98339522e-02f, -1.78869590e-01f, 5.74457236e-02f,
  1.63219473e-03f, -2.98156291e-02f, -8.41199085e-02f, 8.52205157e-02f, 2.56375432e-01f, -3.71261016e-02f, -5.35538457e-02f, -7.12336972e-02f, -3.82283740e-02f, -1.90724712e-02f,
  -4.99496698e-01f, 2.02214003e-01f, -2.03457683e-01f, 4.80154529e-02f, -1.55085415e-01f, -6.13949224e-02f, 1.57925002e-02f, -1.34150088e-01f, -6.21684417e-02f, -1.38997212e-01f,
  -2.14388352e-02f, -1.38956681e-01f, 3.95974256e-02f, 9.53906029e-02f, -7.29496256e-02f, 4.67319861e-02f, 1.73206761e-01f, 1.05530046e-01f, -8.07521194e-02f, 1.06945606e-02f,
  2.28303879e-01f, -9.17268395e-02f, -3.20802361e-01f, 9.08760205e-02f, -1.17249839e-01f, -2.40484297e-01f, -1.60615221e-01f, -3.62095863e-01f, -3.23041081e-01f, -3.26507270e-01f,
  -6.95403159e-01f, 4.35304567e-02f, 1.57522812e-01f, -9.94265527e-02f, -1.59219176e-01f, -3.29598665e-01f, -2.69513190e-01f, -4.15984452e-01f, -2.02497184e-01f, 1.21608011e-01f,
  8.54056925e-02f, 1.92356035e-01f, 1.64004803e-01f, 5.71643328e-03f, -3.81365508e-01f, -2.11506069e-01f, -3.30750406e-01f, -4.77422297e-01f, -5.37054062e-01f, -4.16639656e-01f,
  -2.72536665e-01f, -2.80210227e-01f, -5.70409656e-01f, -1.83222905e-01f, 3.16155881e-01f, 1.49084374e-01f, 1.61311142e-02f, -2.41638631e-01f, -1.94097772e-01f, 9.84573439e-02f,
  3.37672204e-01f, -1.11535817e-01f, -7.65039623e-02f, -1.69922501e-01f, 1.32979274e-01f, -1.52352825e-02f, 2.48484910e-02f, -1.81913120e-03f, 4.76289168e-02f, 8.87124017e-02f,
  -3.81288826e-02f, 8.19847547e-03f, 2.72844974e-02f, 1.65439844e-01f, -2.54306197e-02f, 5.24826832e-02f, -3.47706899e-02f, 3.42186131e-02f, 6.59974664e-02f, 2.27407739e-01f,
  7.58099258e-02f, -1.95180088e-01f, 4.35201377e-02f, 7.24698463e-03f, -4.39046212e-02f, -3.26386355e-02f, 1.34080842e-01f, -8.63783993e-04f, -1.88845359e-02f, 1.29600525e-01f,
  -1.45835966e-01f, 8.21088776e-02f, 1.06532641e-01f, -7.78132025e-03f, 5.12056053e-02f, 7.24702403e-02f, 7.64164850e-02f, 9.55961272e-02f, -1.58964489e-02f, 1.34314403e-01f,
  1.01060629e-01f, -8.89192671e-02f, -7.62020946e-02f, -6.54762089e-02f, -9.90613028e-02f, 8.15176591e-02f, -4.46313769e-02f, 7.51543324e-03f, 8.81554335e-02f, 4.39655073e-02f,
  -2.91704312e-02f, 8.05626810e-02f, 2.71671638e-02f, -4.12303582e-02f, -1.47228196e-01f, 6.30222335e-02f, -5.98289724e-03f, -1.75681636e-01f, 3.20181176e-02f, -1.00913160e-01f,
  1.31822258e-01f, -5.19971371e-01f, 1.63478255e-01f, 7.89422840e-02f, -2.86357217e-02f, -1.52814686e-02f, 1.13626800e-01f, -2.46005524e-02f, 3.53707895e-02f, -8.48701075e-02f,
  -1.49360433e-01f, -8.16523507e-02f, 1.07169397e-01f, 8.12918246e-02f, -2.17824765e-02f, -9.79493931e-02f, -3.64599265e-02f, 1.38277516e-01f, -1.21257536e-01f, 1.46888629e-01f,
  1.99648235e-02f, 8.72857589e-03f, 4.02841866e-02f, 2.16575414e-01f, 2.42852028e-02f, -2.88145058e-02f, 2.46610895e-01f, 2.63262223e-02f, 4.49182875e-02f, 2.69979890e-02f,
  3.40909272e-01f, 5.49458683e-01f, 3.03805768e-01f, 5.25251552e-02f, 7.97415599e-02f, 6.88948929e-02f, 1.61248818e-01f, -8.79583061e-02f, -3.64902437e-01f, 1.10547245e-01f,
  1.98160764e-02f, -2.69015819e-01f, -1.23578824e-01f, -2.33058691e-01f, -3.63547876e-02f, 1.26080930e-01f, 1.10994115e-01f, 6.53317198e-02f, -3.19729060e-01f, -1.53935865e-01f,
  -1.95243493e-01f, 1.43379048e-01f, 5.13981804e-02f, -1.28099322e-01f, -1.40104713e-02f, -3.19136620e-01f, 1.37117893e-01f, 2.12573990e-01f, 1.37935072e-01f, 2.70295978e-01f,
  2.24701017e-01f, 3.59674811e-01f, -6.27577543e-01f, -2.66824327e-02f, 1.46570250e-01f, -1.36626914e-01f, -6.96543828e-02f, -1.04374319e-01f, 4.41595837e-02f, -4.41079251e-02f,
  1.26902610e-01f, 2.84838621e-02f, 2.40604281e-01f, 5.11061586e-03f, 6.24209680e-02f, -1.93531573e-01f, 9.07053612e-03f, -3.89318615e-02f, 2.99119763e-02f, 4.73020300e-02f,
  6.22297898e-02f, 2.09542960e-01f, 2.80967593e-01f, -9.45045725e-02f, 6.67646900e-02f, -1.70014232e-01f, 1.53859407e-01f, 5.45781739e-02f, -7.70563409e-02f, -1.41188607e-01f,
  -3.69787276e-01f, 3.53725301e-03f, 1.75207525e-01f, 4.48128618e-02f, -1.33845910e-01f, -1.16484918e-01f, -4.06524651e-02f, 1.29785864e-02f, -1.14588104e-02f, 9.68902633e-02f,
  -4.98063415e-02f, -1.58579499e-01f, -2.85865683e-02f, -9.68177989e-02f, -1.56263500e-01f, 1.20845534e-01f, -7.05879033e-02f, -9.67907161e-02f, 6.05761260e-02f, 7.37179536e-03f,
  -7.18437210e-02f, -3.30584422e-02f, 6.75330609e-02f, -1.03539668e-01f, -2.70992398e-01f, -1.69398323e-01f, -2.94697523e-01f, -1.24991916e-01f, -4.19603772e-02f, 1.14239149e-01f,
  -2.58670747e-01f, 5.67316376e-02f, -4.35952336e-01f, -4.50143032e-02f, 2.65971214e-01f, 1.91909954e-01f, -3.38937342e-03f, 9.53634363e-03f, 1.82246044e-01f, -1.14899173e-01f,
  1.26181602e-01f, -1.86983943e-01f, 1.11218713e-01f, -1.40809134e-01f, -2.40300387e-01f, -1.40455663e-01f, -1.56835914e-01f, -5.73943779e-02f, -2.85571486e-01f, -5.34701534e-03f,
  -2.48996522e-02f, -3.27965707e-01f, -3.95955294e-01f, -3.29141796e-01f, -3.98436159e-01f, -6.24076545e-01f, -2.74560869e-01f, -1.40024021e-01f, -1.78807929e-01f, -4.12753880e-01f,
  -1.91729218e-01f, -4.89633650e-01f, -3.87069166e-01f, 4.77679461e-01f, 2.66439110e-01f, -2.69161671e-01f, -5.72283626e-01f, -2.09774926e-01f, 4.90768731e-01f, 8.76018852e-02f,
  2.42504328e-01f, 3.50108415e-01f, 1.40274271e-01f, -4.06429507e-02f, -5.08118749e-01f, -3.99905980e-01f, -1.59484074e-01f, -2.72398800e-01f, -2.40187839e-01f, -8.40211734e-02f,
  2.84173191e-01f, 3.00230354e-01f, 2.23374397e-01f, 9.92944688e-02f, 1.52220562e-01f, 1.40293300e-01f, 1.28977045e-01f, 1.70861661e-01f, -1.16301768e-01f, -6.26203120e-02f,
  -3.04098636e-01f, -2.47274294e-01f, -6.67358935e-02f, 1.90429583e-01f, 7.66503736e-02f, -5.72226681e-02f, -6.63602501e-02f, 7.92810693e-02f, 2.07057327e-01f, 1.03967346e-01f,
  2.53609002e-01f, 8.13807361e-03f, 2.19141543e-01f, 5.29049747e-02f, 1.46486074e-01f, 2.60543246e-02f, 1.26827925e-01f, -2.64164209e-01f, -2.80697674e-01f, -1.06534839e-01f,
  1.53153583e-01f, 3.61996889e-01f, -7.50684440e-02f, -1.64771587e-01f, -3.78007859e-01f, -3.06244418e-02f, -1.97025135e-01f, -1.86511770e-01f, -2.24690273e-01f, -3.09663713e-01f,
  3.20206932e-03f, -9.93569102e-03f, -1.33382156e-01f, -7.68965781e-02f, -3.52121405e-02f, 6.30016327e-02f, -6.85135126e-02f, -5.43842837e-02f, 2.24027578e-02f, 2.14744955e-02f,
  4.47285920e-02f, -4.01194766e-02f, -7.00479224e-02f, -6.34520799e-02f, 1.21163145e-01f, 9.66273900e-03f, -1.25341564e-01f, -1.14215031e-01f, -5.76958135e-02f, 5.23503534e-02f,
  1.06365448e-02f, -1.58898279e-01f, 1.83441415e-01f, -2.14157507e-01f, -1.30452231e-01f, -1.55224204e-01f, 1.04541369e-01f, 3.12708132e-02f, 1.26772985e-01f, 1.49824962e-01f,
  4.49143827e-01f, 8.22338313e-02f, -2.29691058e-01f, -6.27289563e-02f, -4.23667654e-02f, 6.80188313e-02f, -9.79377776e-02f, -6.90968484e-02f, 5.20737879e-02f, -6.90520927e-02f,
  -1.33370273e-02f, -2.33006299e-01f, 2.23704781e-02f, 1.07440623e-02f, -3.71790379e-02f, 1.23187810e-01f, -6.92794798e-03f, -1.77359760e-01f, -6.45613521e-02f, 5.02759628e-02f,
  -7.69311488e-02f, -4.61326092e-02f, -1.88964844e-01f, -2.64348418e-01f, -9.93104000e-03f, -2.20367163e-02f, -1.40347332e-01f, -1.14308730e-01f, -3.74223202e-01f, -2.48580784e-01f,
  6.37361765e-01f, 3.10610980e-01f, -1.22775055e-01f, 3.68340313e-01f, -2.63931692e-01f, -4.90789205e-01f, -3.31123382e-01f, -1.71405658e-01f, 5.71570173e-02f, 1.97396591e-01f,
  -6.55496493e-02f, -3.43512207e-01f, -1.68736726e-01f, -2.00580850e-01f, -2.59467810e-01f, -1.62891656e-01f, 1.64306182e-02f, -2.69856036e-01f, -5.66436589e-01f, -3.87746215e-01f,
  -1.54245436e-01f, 7.50336051e-02f, 1.87358186e-01f, -1.35216057e-01f, 3.18330467e-01f, -2.86185071e-02f, 3.37940186e-01f, 1.99653551e-01f, 8.86562560e-03f, 3.87127101e-01f,
  -6.42117113e-02f, 2.00081706e-01f, -4.36077356e-01f, -5.58940955e-02f, -1.26919419e-01f, -8.36491138e-02f, -2.90114641e-01f, -5.14487252e-02f, -1.84153587e-01f, 5.97544247e-03f,
  -2.37454295e-01f, -5.00630774e-02f, -2.14793578e-01f, 1.04950517e-02f, -4.18797834e-03f, -4.42946628e-02f, 9.82087702e-02f, -1.06352054e-01f, -3.54539342e-02f, 3.19124311e-02f,
  -1.45143047e-01f, -1.53947651e-01f, -8.01979229e-02f, -1.13844484e-01f, -1.03319138e-01f, -2.19793785e-02f, 3.27536799e-02f, 7.10905865e-02f, -7.68879801e-02f, 4.82194394e-01f,
  5.99650815e-02f, -5.20158298e-02f, -6.84745982e-02f, 1.03255071e-01f, 2.68017426e-02f, -5.54516353e-02f, 9.33535248e-02f, 1.56780973e-01f, -1.04817115e-01f, -2.61026202e-03f,
  9.27438065e-02f, -2.24826019e-03f, -3.36358789e-03f, -1.19873527e-02f, -1.02137364e-01f, -9.97328162e-02f, -3.38937491e-02f, 1.73123896e-01f, -1.78280845e-02f, 6.29705563e-02f,
  3.34971026e-03f, -1.25375977e-02f, -7.27308169e-02f, -2.90552434e-02f, -7.95063004e-03f, -1.01881837e-02f, -7.18525127e-02f, 3.09666689e-03f, 1.07286438e-01f, -1.88559992e-03f,
  1.29959464e-01f, -2.73288161e-01f, 8.94653201e-02f, -1.22710630e-01f, -1.10492595e-01f, -6.47147046e-03f, -3.77397649e-02f, -3.25049534e-02f, 5.25025800e-02f, -5.81523292e-02f,
  -2.17224762e-01f, -4.36585136e-02f, 8.18693563e-02f, -7.19898045e-02f, -1.61911353e-01f, -9.94200408e-02f, 2.04500198e-01f, -1.04243137e-01f, -2.22311571e-01f, 7.46508613e-02f,
  2.39332691e-01f, -3.66148241e-02f, 4.16668355e-02f, 1.15427420e-01f, -2.28350274e-02f, -1.00975625e-01f, 4.00186591e-02f, -7.78302178e-02f, -2.12306827e-01f, 3.50730687e-01f,
  -5.12585342e-01f, 1.19250566e-01f, 3.04444909e-01f, -2.11536661e-01f, 7.62306526e-02f, -4.47442010e-02f, -2.58984268e-01f, -4.59078670e-01f, -1.87118873e-01f, 2.01262742e-01f,
  2.64370739e-01f, 9.59309936e-02f, 1.41203955e-01f, -4.19274308e-02f, -3.78108293e-01f, -4.76446971e-02f, -1.34455398e-01f, -3.61449122e-01f, -5.62209070e-01f, -3.29470307e-01f,
  -3.81078124e-02f, -2.35451013e-01f, -3.57922584e-01f, -2.27307200e-01f, 1.34094447e-01f, 4.18689325e-02f, 3.17741424e-01f, -1.77030673e-03f, 2.27295280e-01f, 4.03298616e-01f,
  2.98298031e-01f, 2.87219137e-02f, 6.21147789e-02f, -7.39851326e-04f, 2.06893921e-01f, 3.27236205e-02f, -8.17166194e-02f, 2.55711433e-02f, 5.50872386e-02f, 8.75247568e-02f,
  7.38548711e-02f, 2.46770009e-02f, -2.37965956e-02f, 5.75025119e-02f, -3.64634901e-01f, -1.52139381e-01f, -1.48614049e-01f, -2.47690365e-01f, -4.48216498e-02f, -2.42263824e-02f,
  -6.22705594e-02f, -3.01542226e-02f, -1.03347450e-01f, -3.97838801e-02f, -4.88012470e-02f, 1.02983885e-01f, 7.65032619e-02f, 9.16231610e-03f, -2.92924624e-02f, -3.49939354e-02f,
  -7.31716454e-02f, 9.28616971e-02f, 8.06836486e-02f, 3.55767529e-03f, -8.60865936e-02f, 1.05137452e-01f, 9.91152078e-02f, -5.86720854e-02f, -7.92609230e-02f, -1.55470684e-01f,
  -6.39280602e-02f, 7.00725690e-02f, 5.27698472e-02f, -1.49392709e-02f, 7.53909647e-02f, 5.11561520e-03f, 4.52464335e-02f, 7.82847777e-02f, -1.32294847e-02f, 1.25328958e-01f,
  -3.60557698e-02f, 3.78396772e-02f, 7.14910850e-02f, -6.54850826e-02f, 1.39048949e-01f, 1.00634694e-02f, 5.25102243e-02f, 1.45744696e-01f, -3.29691246e-02f, 1.60654694e-01f,
  -2.00180113e-01f, 2.89486945e-01f, 1.56672463e-01f, -1.32928506e-01f, 3.54542658e-02f, 2.93918580e-01f, 2.17450410e-01f, 1.22621819e-01f, 2.22390682e-01f, -1.10626400e-01f,
  5.29932044e-02f, 7.52526894e-02f, -9.15593840e-03f, -7.81930834e-02f, -1.50713041e-01f, 3.75542864e-02f, -4.90587056e-02f, -6.78108037e-02f, -2.40695700e-02f, -2.83973124e-02f,
  -1.27004564e-01f, -3.47128898e-01f, -2.71298409e-01f, -1.71161667e-01f, -1.19180307e-01f, -9.97877270e-02f, -2.81674881e-02f, -5.57346344e-02f, -1.45065606e-01f, -2.41836861e-01f,
  -1.11123487e-01f, 5.03601074e-01f, 3.68994325e-01f, -2.15573326e-01f, 2.67388433e-01f, 4.34628606e-01f, 5.76524496e-01f, 3.12145352e-01f, -1.45324722e-01f, 1.90805212e-01f,
  2.44371742e-01f, -3.70867014e-01f, -2.52847791e-01f, -2.98615038e-01f, -6.32304698e-02f, 2.48500943e-01f, -7.43846223e-02f, -2.41082042e-01f, -2.48968139e-01f, -2.64365450e-02f,
  -1.97593361e-01f, -1.58993796e-01f, -3.06951344e-01f, -2.41305664e-01f, -2.63312995e-01f, -4.93796170e-01f, -1.21001169e-01f, 2.43594013e-02f, -4.92706103e-03f, -3.80441636e-01f,
  1.43064931e-01f, 3.97869408e-01f, -1.84024721e-01f, -8.14929977e-02f, 1.40429258e-01f, -2.53578578e-03f, -5.12794293e-02f, -5.36721013e-02f, 8.84823948e-02f, 3.21842171e-02f,
  3.92890200e-02f, 7.70410150e-02f, 3.56415547e-02f, 3.11375689e-02f, 2.03837991e-01f, 1.48951095e-02f, 1.23633310e-01f, 8.70215893e-02f, -6.18367485e-05f, 1.87072769e-01f,
  1.02817208e-01f, 2.09745362e-01f, 3.28522027e-01f, 1.46000147e-01f, 1.59489438e-02f, -2.99014524e-03f, 2.20352009e-01f, 6.81807799e-03f, 1.78271636e-01f, -6.94643110e-02f,
  -1.38238981e-01f, -6.48671091e-02f, 1.24938890e-01f, -8.10546055e-03f, 6.75180182e-02f, -2.63742991e-02f, 6.52293616e-04f, -7.65018910e-02f, -3.44475545e-03f, -5.40588312e-02f,
  -9.04982808e-05f, 9.03035402e-02f, -1.07077202e-02f, -6.87322067e-03f, -1.24638468e-01f, 9.54301432e-02f, 2.79527325e-02f, 7.66617730e-02f, 8.90847370e-02f, 1.18861988e-01f,
  7.42714293e-03f, 5.06709963e-02f, 8.72723013e-02f, 1.13230571e-01f, 1.15444958e-01f, 8.23931303e-03f, 6.53242841e-02f, 4.48286422e-02f, 3.46612819e-02f, -6.48234785e-02f,
  -1.12279341e-01f, 2.07784265e-01f, -2.68071890e-01f, -1.58695102e-01f, 7.64811113e-02f, 2.92127412e-02f, -2.82673072e-02f, -1.28614455e-02f, 1.06568523e-01f, 1.55288711e-01f,
  1.23307943e-01f, -3.44957337e-02f, 4.19205837e-02f, 3.27351242e-02f, -1.20953165e-01f, -1.93180628e-02f, 5.97667582e-02f, -1.55650735e-01f, 2.55787615e-02f, 1.51363790e-01f,
  3.76346037e-02f, 1.61344670e-02f, -1.87461793e-01f, -1.29810587e-01f, -1.88316643e-01f, -2.66540319e-01f, -1.45739660e-01f, 5.24227843e-02f, -7.52606615e-02f, -3.20785165e-01f,
  -9.16772544e-01f, -4.00265425e-01f, 3.57743651e-01f, 9.16634500e-02f, 3.98973584e-01f, 2.69365817e-01f, 4.03468519e-01f, 5.84028810e-02f, -5.47228493e-02f, 7.48452395e-02f,
  -2.65836537e-01f, -2.53127426e-01f, -1.78077862e-01f, -2.39905953e-01f, -1.59593552e-01f, 4.11753267e-01f, 4.04440492e-01f, 4.23806347e-02f, 7.96222836e-02f, 2.04684377e-01f,
  8.80071893e-02f, -1.73067097e-02f, -2.82726139e-01f, -1.43146455e-01f, 1.68384999e-01f, 1.10974990e-01f, 1.43078506e-01f, -6.14400720e-03f, 4.96387519e-02f, 3.13871682e-01f,
  4.41798627e-01f, -3.42020214e-01f, -1.37392413e-02f, -2.24810794e-01f, -7.93026909e-02f, -1.47824526e-01f, -5.66524416e-02f, 3.39414664e-02f, -1.51383420e-02f, 1.42331019e-01f,
  2.44408976e-02f, -9.82897356e-02f, -7.45350644e-02f, 6.36005029e-02f, 1.56597853e-01f, -4.94462289e-02f, 4.12919885e-03f, 3.96417342e-02f, 6.16945624e-02f, 2.00693142e-02f,
  -5.57153486e-02f, 1.75817385e-02f, 9.98857543e-02f, 8.72973055e-02f, -1.88953027e-01f, 1.69634968e-02f, -7.62341097e-02f, -9.76911485e-02f, -1.43332019e-01f, 2.42777704e-03f,
  -3.40633281e-02f, -3.77963409e-02f, -1.04907997e-01f, -4.63400893e-02f, -1.53773859e-01f, 1.00666076e-01f, 1.63483918e-01f, -1.44203277e-02f, -1.47140726e-01f, -4.92273271e-02f,
  1.59792289e-01f, 4.38261218e-02f, 3.36635336e-02f, -4.06549796e-02f, -7.41370022e-02f, 2.40295772e-02f, -4.44424003e-02f, -1.16304964e-01f, -3.59819494e-02f, -6.58035129e-02f,
  -1.03263497e-01f, 6.24195673e-02f, 1.07108399e-01f, 1.24106957e-02f, 2.39711106e-02f, -5.37564643e-02f, 5.15296794e-02f, -1.16275884e-02f, -5.22226579e-02f, 1.35373980e-01f,
  2.47284248e-01f, -2.47169450e-01f, 1.93221159e-02f, -1.02483146e-02f, 5.81562854e-02f, -1.48730546e-01f, -1.27159029e-01f, 1.14123784e-01f, 1.69908375e-01f, 1.09931678e-01f,
  -2.16788016e-02f, -8.36566165e-02f, -3.22984979e-02f, -8.15088525e-02f, 1.18314818e-01f, 3.98562802e-03f, -1.76363602e-01f, 8.14937577e-02f, 1.43217826e-02f, 6.64421692e-02f,
  -8.18058923e-02f, 8.72262195e-03f, 1.72364756e-01f, 1.27840817e-01f, -3.34276855e-02f, 1.43145010e-01f, 1.15683027e-01f, 1.91060811e-01f, 1.26040623e-01f, 1.16988197e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.56501210e-01f, 1.88641325e-01f, 1.45694375e-01f, 7.07702577e-01f, 2.69522935e-01f, 6.33360088e-01f, 4.60896879e-01f, 5.16820133e-01f, 4.72295225e-01f, 2.64056563e-01f,
  2.18361408e-01f, 3.76574278e-01f, 5.07875264e-01f, 5.47508657e-01f, 4.10786808e-01f, 7.19658062e-02f, 5.28608263e-01f, 6.03750646e-01f, 2.64687657e-01f, 2.90423512e-01f,
  5.12913585e-01f, 4.12804157e-01f, 5.44631481e-01f, 9.60407928e-02f, 3.20583701e-01f, 3.93595040e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -5.24395034e-02f, 5.48930354e-02f, -9.66178104e-02f, -1.70501173e-02f, 1.88711151e-01f, -8.66996311e-03f, -8.54581669e-02f, -2.89005637e-01f, -7.27745518e-02f, -1.84488744e-01f,
  -1.72289968e-01f, 1.72259644e-01f, 1.43756390e-01f, -1.57192886e-01f, 2.38483083e-02f, -5.68421558e-02f, 1.19717315e-01f, -3.98406506e-01f, -2.29667649e-01f, 2.21440747e-01f,
  4.29535031e-01f, 3.72642219e-01f, -1.46399796e-01f, -1.86564997e-01f, 1.85071528e-01f, 1.14004001e-01f, -2.03073651e-01f, 1.15633525e-01f, -5.45264175e-03f, 2.74146318e-01f,
  1.31542072e-01f, 3.74338478e-01f, -1.99757263e-01f, 5.10233007e-02f, -2.02020422e-01f, -4.66478541e-02f, -3.89574885e-01f, -1.08506322e-01f, 1.63849801e-01f, 3.35553139e-01f,
  1.41799629e-01f, -1.23048089e-01f, 1.26633704e-01f, 9.39914733e-02f, -1.41854271e-01f, -4.61419113e-02f, 1.34590968e-01f, 8.43667760e-02f, -8.22184160e-02f, -1.40628770e-01f,
  -9.38969478e-02f, -3.84487301e-01f, 1.18419103e-01f, 7.04213455e-02f, 7.25005940e-02f, -2.80258991e-02f, 9.02361497e-02f, -3.26078653e-01f, 1.92484409e-02f, -5.05741596e-01f,
  -7.89243057e-02f, -1.42601013e-01f, -3.23474258e-01f, 2.42144600e-01f, 8.79651904e-02f, -1.18071558e-02f, 2.04762176e-01f, 8.98179635e-02f, -1.80233791e-01f, 2.62857139e-01f,
  4.21702899e-02f, 1.17959537e-01f, 2.38396227e-01f, -9.21641514e-02f, 3.71231278e-03f, 4.90552606e-03f, -6.59403056e-02f, 1.23609215e-01f, 1.07468642e-01f, 2.01788232e-01f,
  -1.35526970e-01f, -1.19142108e-01f, -9.66973603e-02f, -1.96184769e-01f, 3.31392229e-01f, -7.04793483e-02f, -1.95685282e-01f, -2.85530329e-01f, 3.12553585e-01f, -3.01432997e-01f,
  1.98674127e-01f, -1.07754983e-01f, -3.78802381e-02f, 3.17612030e-02f, 5.94553240e-02f, 3.34211409e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  6.98316991e-02f, 2.41294846e-01f, 2.49972403e-01f, 1.45139873e-01f, 1.48345426e-01f, 3.24452259e-02f, 1.55911326e-01f, 5.87860405e-01f, 4.59782243e-01f, 5.90175331e-01f,
  -6.16642535e-02f, 3.10720861e-01f, 1.18066378e-01f, 2.93647051e-01f, 1.15299039e-01f, 3.14930052e-01f, -3.30962352e-02f, 5.93955994e-01f, 2.84354597e-01f, 1.80494860e-01f,
  -3.49434465e-02f, -3.63806695e-01f, -6.79101422e-03f, -1.03173507e-02f, -1.30117759e-01f, -2.77684420e-01f, -3.53490174e-01f, 1.43186465e-01f, -2.14394122e-01f, -2.06025243e-01f,
  -1.45656154e-01f, -4.98484135e-01f, 2.21602514e-01f, -1.05102293e-01f, 2.54135668e-01f, -3.08236569e-01f, -3.24675553e-02f, 6.51767105e-02f, 7.86870904e-03f, -3.38276237e-01f,
  7.03049526e-02f, -4.20030206e-01f, -3.05655062e-01f, 1.79115921e-01f, 1.86826363e-01f, -3.35273206e-01f, 2.58572936e-01f, -1.24128520e-01f, -2.25833014e-01f, -4.50338364e-01f,
  -1.34413708e-02f, -1.34425893e-01f, 7.29073226e-01f, -4.66436334e-02f, 1.12711124e-01f, 2.35912681e-01f, 2.81563461e-01f, -3.10401887e-01f, 4.24096882e-01f, -4.83742595e-01f,
  7.74934813e-02f, -1.02187738e-01f, 4.48621809e-01f, 4.57749069e-01f, -1.30257636e-01f, -8.41263495e-03f, 2.14481324e-01f, 7.43672103e-02f, 1.51259691e-01f, 1.21011011e-01f,
  3.82325649e-01f, 4.62142169e-01f, 1.29785761e-01f, 4.15899873e-01f, 2.81166732e-02f, 2.16135561e-01f, 1.99277550e-01f, 2.79266238e-01f, 4.68349596e-03f, 3.14627588e-01f,
  -1.21208318e-01f, 7.10677922e-01f, 2.31855050e-01f, -2.08911985e-01f, -3.80809546e-01f, -2.47579351e-01f, -8.34192410e-02f, -1.54290861e-03f, -2.93054134e-01f, 7.85098821e-02f,
  -3.94663393e-01f, -1.67433377e-02f, -3.47911447e-01f, -3.42989624e-01f, -5.13590276e-01f, -3.94246995e-01f, 3.32220763e-01f, 1.93436474e-01f, 2.63093621e-01f, 1.63051505e-02f,
  2.19626620e-01f, 2.95466930e-01f, -3.83274615e-01f, -2.30332643e-01f, -3.66773814e-01f, 3.67477626e-01f, 1.65045056e-02f, 3.90307486e-01f, 6.87383771e-01f, -2.42289752e-01f,
  -2.63474792e-01f, 6.05271459e-02f, 1.63619906e-01f, 1.40089720e-01f, 2.09177434e-01f, 3.54114145e-01f, -1.81369603e-01f, -2.86908820e-02f, -1.57799527e-01f, -5.50945755e-03f,
  7.24190176e-01f, 1.07286319e-01f, 3.30397785e-01f, 7.39593953e-02f, -3.13266933e-01f, 2.71899849e-01f, 1.52283832e-01f, 2.83129573e-01f, 3.75528932e-01f, -2.26220161e-01f,
  2.46865869e-01f, -1.53779581e-01f, 3.19973797e-01f, 1.76783338e-01f, -1.20554551e-01f, 2.28379279e-01f, 1.88968614e-01f, -5.33853509e-02f, 8.44852552e-02f, 7.99296349e-02f,
  4.57031354e-02f, 4.86280322e-01f, 1.53703764e-01f, -3.66453916e-01f, 3.88350129e-01f, 4.57631797e-01f, 6.06969893e-02f, 3.52794290e-01f, 3.42979103e-01f, 1.61640644e-02f,
  1.89001277e-01f, -5.30400872e-01f, -2.78908879e-01f, 5.50147891e-01f, -5.66429257e-01f, 6.42676592e-01f, 1.55241966e-01f, -1.36169598e-01f, -3.79905514e-02f, 3.05795670e-01f,
  -9.40050557e-03f, -1.03260949e-01f, 3.94188643e-01f, 4.50105523e-04f, -3.60600471e-01f, 2.80585177e-02f, 3.24054211e-02f, 2.18690187e-01f, -2.60941982e-01f, 7.77051985e-01f,
  -1.98004562e-02f, -9.13893878e-02f, 1.41351774e-01f, -1.09311134e-01f, 2.03907877e-01f, 3.66762787e-01f, 5.27322292e-01f, 3.71773355e-02f, 2.83231318e-01f, 1.84394464e-01f,
  2.87551522e-01f, 2.20875278e-01f, -3.88443232e-01f, -3.83046567e-01f, 6.48025334e-01f, -8.82214606e-02f, 6.51421010e-01f, 4.15948173e-03f, -4.14756507e-01f, 2.41197154e-01f,
  1.03943777e+00f, 6.57383502e-02f, -4.69566928e-03f, -1.00475796e-01f, 1.37671694e-01f, 2.49354526e-01f, -3.82662088e-01f, 1.46335989e-01f, 2.30820715e-01f, 2.87711412e-01f,
  1.87051997e-01f, 5.65714478e-01f, 1.40408427e-01f, 2.93733090e-01f, 5.64957820e-02f, 2.74049431e-01f, 1.10441692e-01f, 5.87016940e-01f, 1.53488755e-01f, 5.19032538e-01f,
  7.09429234e-02f, 1.39404133e-01f, -2.75554597e-01f, 4.31830101e-02f, -3.25823396e-01f, -1.32104963e-01f, 3.33945192e-02f, -1.39139339e-01f, -3.42123896e-01f, 1.79236263e-01f,
  -6.26499593e-01f, 1.18587337e-01f, 3.60884741e-02f, -4.70830232e-01f, 2.60201246e-01f, 1.63508758e-01f, 1.59208924e-01f, 2.38280088e-01f, 3.43913257e-01f, -4.11062129e-02f,
  1.10783979e-01f, -4.62924987e-02f, 1.30743369e-01f, -1.88870490e-01f, -2.80016661e-01f, 2.51092166e-01f, 1.33656800e-01f, 4.11436230e-01f, 1.39831394e-01f, -1.15451120e-01f,
  -3.08112234e-01f, -1.05469629e-01f, 2.67136037e-01f, -3.89317155e-01f, 5.21169662e-01f, 1.68224439e-01f, 8.25724825e-02f, 4.54288237e-02f, -4.17277068e-01f, 5.13318121e-01f,
  -7.39294589e-02f, 3.83144528e-01f, 4.26472962e-01f, 2.39408970e-01f, 1.65278524e-01f, -7.41383806e-02f, -1.55803198e-02f, 1.25038818e-01f, 2.98478603e-01f, -1.43257886e-01f,
  -8.20286497e-02f, -2.06092879e-01f, 2.16475666e-01f, -2.84082144e-01f, 1.12830782e-02f, 7.03989789e-02f, 2.96193182e-01f, -4.81546462e-01f, 3.61369073e-01f, -2.95805037e-01f,
  1.57147795e-01f, -3.20397094e-02f, 5.07593453e-02f, -1.11315496e-01f, -1.79866731e-01f, -4.97569084e-01f, -1.13614187e-01f, 5.27653173e-02f, 3.31422299e-01f, 6.70374453e-01f,
  3.90995182e-02f, -3.16316962e-01f, 6.28940105e-01f, -3.28908078e-02f, 2.28127182e-01f, -1.87036842e-01f, -3.56610538e-03f, -3.05936128e-01f, 1.30183905e-01f, 3.98303688e-01f,
  2.05373839e-01f, 1.87885553e-01f, 2.84265608e-01f, -3.73582363e-01f, 7.21038580e-02f, 3.60164464e-01f, 1.62652537e-01f, 3.47251564e-01f, 4.97078568e-01f, -3.15687478e-01f,
  6.10624254e-01f, 7.06660002e-02f, -1.17348999e-01f, 4.95645434e-01f, 2.69783139e-01f, -7.96618089e-02f, 3.02778602e-01f, -6.36864901e-01f, -3.23597938e-01f, 1.34857476e-01f,
  3.58320177e-01f, 7.14800000e-01f, 5.69287315e-02f, 6.88756183e-02f, -2.02536568e-01f, 5.60989261e-01f, 3.54773641e-01f, 1.34041682e-02f, -4.48772341e-01f, -1.39965475e-01f,
  2.28911594e-01f, 4.81416434e-01f, 3.20772082e-01f, 1.42345294e-01f, 1.18440107e-01f, -2.00954348e-01f, -2.55311817e-01f, -1.64957210e-01f, -9.73136872e-02f, 3.29588145e-01f,
  2.69214332e-01f, 4.05087292e-01f, 3.89879674e-01f, -1.65146321e-01f, -4.02995795e-01f, 2.43640468e-01f, 5.15635729e-01f, -2.72303522e-01f, -1.09407036e-02f, 5.45023203e-01f,
  -2.54808247e-01f, 4.55576211e-01f, 3.29618156e-01f, 4.21421587e-01f, -2.31502309e-01f, 3.77368987e-01f, -2.10296482e-01f, 3.07895720e-01f, 5.14916837e-01f, 5.64340293e-01f,
  1.66493386e-01f, 1.56674743e-01f, 1.11128569e-01f, 7.27354214e-02f, 2.76203543e-01f, -2.44632334e-01f, -1.63186938e-02f, 2.76939124e-01f, -1.86792344e-01f, 2.84779221e-01f,
  -1.02262370e-01f, -3.68085839e-02f, -1.37201518e-01f, 3.45128924e-01f, 1.79396182e-01f, 3.91580045e-01f, 1.62308037e-01f, -2.42370851e-02f, 4.36500996e-01f, 1.67269945e-01f,
  1.19591661e-01f, 4.72037137e-01f, 7.63868988e-01f, -3.42626840e-01f, -9.71652865e-02f, -3.24130595e-01f, 3.08698326e-01f, -4.48953331e-01f, -3.32324058e-02f, 1.81477875e-01f,
  -2.40736708e-01f, -2.39543647e-01f, 2.22663239e-01f, 5.56935072e-02f, 2.12735727e-01f, -5.25755137e-02f, 2.57054955e-01f, -6.43600896e-02f, 2.92922914e-01f, -3.63198929e-02f,
  1.50772659e-02f, 3.95134151e-01f, 3.66944969e-01f, 1.43924197e-02f, 1.42063633e-01f, -5.97816259e-02f, 2.31107190e-01f, 4.92887616e-01f, 2.41711035e-01f, 2.95813441e-01f,
  -3.17548611e-03f, 1.18551813e-02f, 1.72806427e-01f, -3.71432573e-01f, 1.89177528e-01f, -9.60855857e-02f, 3.03504258e-01f, -2.60546625e-01f, 4.48618799e-01f, -1.00766644e-01f,
  -1.75426155e-01f, 4.56803799e-01f, 3.51588726e-01f, -4.27484274e-01f, -1.61882222e-01f, -1.22493273e-02f, 1.71718210e-01f, 1.58744141e-01f, 2.47500181e-01f, 1.50681645e-01f,
  -5.68421092e-04f, 5.38464487e-02f, 1.20543363e-02f, 1.55269235e-01f, 1.46688104e-01f, 1.18943386e-01f, 1.32960454e-01f, 3.75718921e-01f, -4.10584696e-02f, 2.37621695e-01f,
  2.63081998e-01f, -3.52457196e-01f, -2.83478945e-01f, 3.95763628e-02f, -2.91380696e-02f, -1.84254333e-01f, 3.15628409e-01f, 5.99026233e-02f, 6.17173195e-01f, 3.83217365e-01f,
  -3.46726358e-01f, 3.51411313e-01f, -1.43769711e-01f, -1.51520833e-01f, 6.41160190e-01f, 1.72088772e-01f, -5.75786650e-01f, 2.90321946e-01f, 1.05779536e-01f, 4.51769620e-01f,
  2.22412974e-01f, -2.20684722e-01f, -1.12360477e-01f, -4.26150441e-01f, -1.40313983e-01f, 4.82619293e-02f, -2.02567294e-01f, 1.10556679e-02f, 9.84440893e-02f, -3.18347551e-02f,
  8.59616101e-02f, 3.89333546e-01f, -7.14176102e-03f, -1.56812608e-01f, 1.35252759e-01f, -2.88342893e-01f, -5.89630976e-02f, -2.98147261e-01f, -8.26941431e-02f, 3.00366521e-01f,
  5.46007216e-01f, 3.93616796e-01f, -3.72904539e-01f, 3.56268317e-01f, 2.80722409e-01f, 4.85757440e-01f, 7.22116292e-01f, 5.24784029e-02f, -1.61644071e-01f, -8.58020037e-02f,
  1.73174530e-01f, 5.74026369e-02f, -3.78606771e-03f, -6.01744056e-02f, 5.11232853e-01f, 4.53939289e-02f, 1.71299726e-01f, -7.90345669e-02f, -4.66866404e-01f, -4.11501199e-01f,
  -6.55770376e-02f, 4.40368682e-01f, 3.14902514e-01f, 1.41806215e-01f, -1.09324217e-01f, -8.84797871e-02f, -7.57028684e-02f, 1.33209854e-01f, -3.19869407e-02f, 4.81474638e-01f,
  -4.65922654e-01f, 6.13108337e-01f, 2.76013762e-01f, 2.21614376e-01f, 4.34852093e-01f, 6.19818628e-01f, 2.36446872e-01f, 1.37840942e-01f, 2.75226504e-01f, 5.44085741e-01f,
  1.31048307e-01f, 3.69623631e-01f, 3.19361910e-02f, 1.60813794e-01f, 3.17440927e-01f, 6.08884804e-02f, -2.61425853e-01f, 1.08639278e-01f, 3.93795669e-01f, 3.10382932e-01f,
  1.32461905e-01f, 6.40821159e-02f, -1.29264640e-02f, 2.64240205e-01f, 6.17877245e-02f, 8.31857845e-02f, 2.79343873e-01f, 1.13030419e-01f, -6.31321847e-01f, 4.43965197e-01f,
  3.32177579e-01f, -9.46770832e-02f, 5.51033497e-01f, -3.65448773e-01f, -2.02532843e-01f, 3.80085781e-02f, -4.97454256e-02f, -3.51434238e-02f, -3.16206247e-01f, -2.21597359e-01f,
  -2.41860613e-01f, -1.68171272e-01f, -1.33746073e-01f, 4.51048017e-02f, 2.53671944e-01f, -1.25835970e-01f, 1.59453958e-01f, -2.44621560e-01f, 1.18924223e-01f, 1.16006255e-01f,
  4.08654921e-02f, -2.42966175e-01f, -4.32090521e-01f, 3.33511122e-02f, 1.96570665e-01f, 4.43031311e-01f, 3.35146755e-01f, -1.97469100e-01f, 1.13718979e-01f, -2.64191598e-01f,
  -1.56623036e-01f, 3.23515683e-01f, 3.43967021e-01f, 5.01188375e-02f, -4.38557148e-01f, 2.02601463e-01f, 3.92375529e-01f, 4.19865966e-01f, 5.00012875e-01f, 1.70650378e-01f,
  2.27345020e-01f, -3.99162292e-01f, -1.57955617e-01f, 4.55667764e-01f, -3.01176786e-01f, 3.56367558e-01f, 1.72345176e-01f, 4.76333424e-02f, 9.77021828e-02f, -2.74305552e-01f,
  4.60356139e-02f, -4.86440025e-02f, 2.24555746e-01f, 4.19207543e-01f, -1.60551246e-03f, -3.57658118e-01f, 7.25059435e-02f, -5.57652898e-02f, -2.61392355e-01f, 6.58641458e-01f,
  4.48501110e-01f, 4.44296189e-02f, -2.43478477e-01f, 3.36081744e-03f, 1.11166336e-01f, -1.14582926e-01f, -4.64314856e-02f, 2.27478728e-01f, 5.05286813e-01f, 2.13983521e-01f,
  -8.32569674e-02f, -2.37362355e-01f, 4.44749892e-01f, 4.31453407e-01f, 5.79454780e-01f, -2.95042932e-01f, 2.50312351e-02f, -8.27522755e-01f, 1.82742819e-01f, -3.90753970e-02f,
  1.91118643e-01f, -1.50745764e-01f, -5.01069091e-02f, 9.89365354e-02f, 9.88109782e-02f, 2.63774276e-01f, 3.18962276e-01f, -1.05117090e-01f, 3.01505928e-03f, 1.38568074e-01f,
  -9.80338156e-02f, 4.74096626e-01f, 3.62096667e-01f, 1.99372709e-01f, 2.40645900e-01f, 2.03526512e-01f, 1.93329215e-01f, 3.45923573e-01f, 5.79250231e-02f, 3.44120622e-01f,
  -1.13416056e-03f, -5.15553474e-01f, -1.34289607e-01f, 5.80107868e-01f, -3.66112769e-01f, 3.26768577e-01f, 2.59661376e-01f, 1.91579282e-01f, 2.32278556e-01f, 6.73455968e-02f,
  3.14759940e-01f, 2.15823114e-01f, 1.07991531e-01f, -3.22121650e-01f, -3.62352788e-01f, -1.74963772e-02f, -8.74031633e-02f, 1.86867654e-01f, 2.42786035e-01f, -2.51369298e-01f,
  2.16378900e-03f, 1.33311957e-01f, -3.04143369e-01f, 4.51613009e-01f, 2.85070717e-01f, -6.04117811e-01f, -4.60538208e-01f, -2.19066724e-01f, -3.61509621e-01f, 6.65866435e-01f,
  5.79624355e-01f, -5.37159622e-01f, 5.67005336e-01f, 3.30463022e-01f, -1.66520566e-01f, -9.19298232e-02f, 4.41316426e-01f, -9.12091196e-01f, 5.68289042e-01f, -2.67623901e-01f,
  6.75194636e-02f, -3.66293341e-02f, 7.94700086e-02f, -1.68440938e-01f, 7.44669437e-02f, -1.73624873e-01f, -2.96245962e-01f, -2.79178232e-01f, 1.39480233e-01f, -4.40386444e-01f,
  -8.01982805e-02f, -3.37835163e-01f, 1.04424477e-01f, 1.57737970e-01f, -1.44462109e-01f, -5.76971114e-01f, 4.40996826e-01f, -3.52228671e-01f, -1.95517734e-01f, 2.09115043e-01f,
  -2.51044035e-01f, 2.18171597e-01f, -3.82864550e-02f, -1.76591069e-01f, 3.35442752e-01f, 2.67647296e-01f, -3.31854880e-01f, 1.45693272e-01f, 5.86484373e-01f, -8.69998574e-01f,
  5.66688657e-01f, -3.95243205e-02f, 2.63606042e-01f, -2.63314992e-01f, 2.21757784e-01f, 1.21069647e-01f, 1.80560455e-01f, -4.58283350e-02f, 1.80180445e-01f, 1.71085969e-01f,
  2.14598879e-01f, 1.60965443e-01f, 1.74088806e-01f, -1.52926534e-01f, -2.96573967e-01f, 5.79748511e-01f, 2.83189386e-01f, 2.38146991e-01f, 1.78493839e-02f, 8.76466781e-02f,
  -9.16041359e-02f, 9.98082832e-02f, 2.28599727e-01f, 4.07305092e-01f, 7.29895949e-01f, -1.47805944e-01f, -6.73114285e-02f, -1.60769835e-01f, 4.17279691e-01f, 2.60657892e-02f,
  -2.88764775e-01f, -4.47536737e-01f, -4.64148611e-01f, 1.82349473e-01f, -4.97129589e-01f, 6.12376392e-01f, 3.93318087e-01f, 3.01128715e-01f, 1.77206397e-01f, 7.63624534e-02f,
  -1.08595997e-01f, -1.83380529e-01f, -3.01412672e-01f, 1.87146966e-03f, -4.21504855e-01f, 6.35923028e-01f, 7.17190728e-02f, 3.02824199e-01f, 1.32636175e-01f, -3.33988577e-01f,
  -9.84852239e-02f, -5.09810215e-03f, -7.61493444e-02f, -4.79436189e-01f, -4.56830896e-02f, 3.17817032e-01f, 7.20714703e-02f, 2.16633845e-02f, 2.73945391e-01f, 4.21688110e-01f,
  2.38453403e-01f, -3.14150810e-01f, 4.08224225e-01f, -1.05480656e-01f, 4.03822452e-01f, 1.69540614e-01f, 1.54831409e-01f, -3.19431126e-01f, 1.79734588e-01f, 8.51934329e-02f,
  2.96062320e-01f, -3.48152488e-01f, 9.65542197e-02f, -1.47085011e-01f, 7.26619810e-02f, -2.14217737e-01f, -2.23485336e-01f, -3.81808579e-01f, -1.20758019e-01f, 2.96829015e-01f,
  -7.80675486e-02f, 4.09724772e-01f, 9.28924158e-02f, -3.26425344e-01f, -9.33754519e-02f, -4.50873345e-01f, -1.43199712e-01f, 2.86758542e-01f, 6.34631276e-01f, 3.78686100e-01f,
  4.83887732e-01f, 2.86316723e-01f, -8.89892876e-02f, 2.07436338e-01f, 4.56783921e-01f, 2.87116885e-01f, 6.87243581e-01f, 3.51143926e-01f, 2.29667157e-01f, 1.03486374e-01f,
  3.08983177e-01f, -1.23078376e-01f, 1.36155143e-01f, 1.55319765e-01f, 1.94341898e-01f, 4.51657027e-02f, 2.72441089e-01f, -1.09297730e-01f, -6.03117123e-02f, 1.14980139e-01f,
  -2.45217215e-02f, 2.87657320e-01f, 5.68427444e-01f, -2.05800474e-01f, 5.21830879e-02f, -1.38411462e-01f, -4.31355298e-01f, 5.94321966e-01f, 4.45332229e-01f, -3.31960708e-01f,
  -8.95879865e-02f, -4.89452220e-02f, 4.13330458e-02f, -3.07833165e-01f, 3.63643348e-01f, 2.41101190e-01f, 6.03631511e-02f, 2.34853640e-01f, -4.00872052e-01f, 8.33152011e-02f,
  -2.51115054e-01f, 4.53842282e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  6.02427185e-01f, 3.61107975e-01f, 3.90516937e-01f, 4.59998399e-01f, -1.89746201e-01f, 6.11174889e-02f, 8.45798999e-02f, 3.27674657e-01f, 4.35277462e-01f, 4.03488129e-01f,
  4.36114043e-01f, 1.09859169e-01f, 3.85982037e-01f, 2.83353448e-01f, 2.69734025e-01f, 1.41171053e-01f, 1.40393689e-01f, 1.71076760e-01f, 4.27445710e-01f, -5.21443151e-02f,
  9.25417542e-02f, 2.57047087e-01f, 5.33463843e-02f, 2.71443874e-01f, 4.45530593e-01f, -5.36808111e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  3.32701802e-01f, -2.15589195e-01f, -3.82770866e-01f, -2.93428719e-01f, -2.03699782e-01f, -3.11124593e-01f, 2.53574163e-01f, 6.87828213e-02f, 3.52886915e-01f, -2.46305332e-01f,
  4.14447546e-01f, 3.98975402e-01f, 2.89066523e-01f, -4.51240778e-01f, -2.64308006e-02f, -6.79866318e-03f, 5.94683401e-02f, 3.70344579e-01f, -6.76810518e-02f, -6.33887410e-01f,
  -1.07656322e-01f, -3.22073102e-01f, -6.44356549e-01f, -9.52401876e-01f, -3.57826680e-01f, 2.17414975e-01f, 1.54272422e-01f, 2.84590870e-01f, -3.22138429e-01f, -4.80379999e-01f,
  -6.30353510e-01f, -2.83054709e-01f, -5.99085808e-01f, 4.13360208e-01f, 1.53822094e-01f, -2.29181647e-01f, 5.15973032e-01f, 3.33623618e-01f, 4.82187092e-01f, -2.39316493e-01f,
  6.29276872e-01f, -8.50890338e-01f, -2.25054294e-01f, -2.34262258e-01f, 4.93642539e-01f, -2.35737115e-02f, 2.31810078e-01f, 1.51502356e-01f, -4.29826796e-01f, -1.27935886e-01f,
  2.57609040e-01f, -1.60570443e-01f, -3.14311683e-01f, -5.38299918e-01f, 2.88852602e-01f, -1.89153142e-02f, 2.48695567e-01f, 7.86582157e-02f, -1.75055236e-01f, 1.49649546e-01f,
  2.67037880e-02f, -6.12977564e-01f, -9.66653049e-01f, 2.17489395e-02f, 2.99127489e-01f, 1.09308949e-02f, 2.33482331e-01f, -7.93332160e-01f, -2.18509480e-01f, 2.26549342e-01f,
  2.92492479e-01f, -8.26108515e-01f, 1.49546832e-01f, 2.72608906e-01f, -5.23239732e-01f, 2.95452982e-01f, -6.21370412e-02f, -5.01042128e-01f, 2.88032532e-01f, 4.13069189e-01f,
  2.53729850e-01f, -3.63992721e-01f, 6.92098364e-02f, -5.56666814e-02f, 1.14244916e-01f, -6.90010011e-01f, -2.41277620e-01f, -5.54422975e-01f, -6.14553332e-01f, -4.42300707e-01f,
  -1.21881381e-01f, -2.49414995e-01f, -3.93962175e-01f, 6.13993287e-01f, -5.67542493e-01f, -2.09189489e-01f, -1.31953955e-01f, -8.14457312e-02f, 6.35370463e-02f, 2.81273961e-01f,
  -7.86640421e-02f, -3.53181288e-02f, 6.64971247e-02f, -2.92832106e-01f, -3.51963997e-01f, 4.79683191e-01f, -1.62506953e-01f, 2.36874908e-01f, 1.32804379e-01f, -5.08481979e-01f,
  -1.81548014e-01f, -6.23263478e-01f, 2.10308090e-01f, 3.30393910e-01f, -7.93104172e-01f, -6.38877034e-01f, -6.89124703e-01f, 2.58657515e-01f, -1.58114001e-01f, -5.71531914e-02f,
  -7.22974181e-01f, 3.05178799e-02f, -1.26862829e-03f, -4.92022812e-01f, 3.12650889e-01f, 2.39112869e-01f, -6.30756691e-02f, -4.07964528e-01f, -3.54043782e-01f, -3.87493074e-01f,
  -2.16485649e-01f, 1.09054863e+00f, -2.89244562e-01f, -1.78704172e-01f, -1.91336438e-01f, -1.76197320e-01f, -4.35416609e-01f, -1.80763170e-01f, 1.33558482e-01f, 1.58989862e-01f,
  -5.61478734e-02f, 7.40266889e-02f, -3.73553276e-01f, 6.64687976e-02f, 2.73045123e-01f, -3.34910840e-01f, -1.37409344e-01f, -4.50929888e-02f, 2.55889148e-01f, 3.09051037e-01f,
  -1.46959588e-01f, -1.96774572e-01f, -1.95343196e-01f, 2.94031799e-01f, -1.00746639e-01f, 2.66749680e-01f, -5.98237574e-01f, -3.58126760e-02f, 3.31299782e-01f, 1.89673290e-01f,
  5.12746751e-01f, 3.47738415e-01f, 3.31050813e-01f, -7.52275646e-01f, -4.78694975e-01f, 3.73810641e-02f, 1.54573366e-01f, -5.35839796e-01f, -1.66336566e-01f, -5.92041016e-01f,
  4.25768703e-01f, -5.72491348e-01f, -2.73393422e-01f, 2.94467717e-01f, -1.64996594e-01f, -1.53444275e-01f, -1.05951287e-01f, 3.00066173e-01f, 2.91194439e-01f, 2.42460102e-01f,
  2.42655560e-01f, -9.43773165e-02f, -9.52820554e-02f, -4.74264443e-01f, 5.38522661e-01f, 2.22368330e-01f, 4.43745106e-01f, -6.48900330e-01f, -6.08474500e-02f, -2.31028199e-01f,
  3.29424113e-01f, -1.63746133e-01f, -6.25678062e-01f, 2.75551677e-01f, 6.28288239e-02f, -3.14807296e-01f, 2.13608727e-01f, -4.80838627e-01f, -7.44644344e-01f, 2.41048902e-01f,
  -1.53432459e-01f, -7.77427733e-01f, -5.05343042e-02f, -1.01436841e+00f, 1.30502254e-01f, -5.97151637e-01f, 4.04028773e-01f, 2.37373695e-01f, -7.31050372e-02f, -4.56959248e-01f,
  -8.26881975e-02f, 3.44160408e-01f, 3.01802635e-01f, -3.64848405e-01f, -4.25536126e-01f, 1.67311251e-01f, 1.37548804e-01f, -4.01557505e-01f, 5.48505127e-01f, 3.97578150e-01f,
  -4.17983621e-01f, 3.10216218e-01f, 2.72424612e-02f, -5.96201003e-01f, 2.93670923e-01f, 1.51622221e-01f, -3.77152383e-01f, 2.84925431e-01f, 1.12097487e-01f, 3.78295869e-01f,
  -7.44188428e-01f, 3.00546348e-01f, -1.97766796e-01f, 6.08840048e-01f, -1.48108117e-02f, 2.32609496e-01f, -5.14836252e-01f, -4.89442676e-01f, -2.62277760e-02f, 1.19975107e-02f,
  -3.86087328e-01f, 5.85503057e-02f, 1.92192823e-01f, -4.09202963e-01f, -3.38225901e-01f, 1.84663549e-01f, -9.02422667e-02f, 2.59064913e-01f, -7.94073194e-02f, -2.11153507e-01f,
  -6.17771029e-01f, -2.94887334e-01f, 1.50093183e-01f, -1.99333385e-01f, -4.08281744e-01f, 3.98176879e-01f, 6.32199049e-02f, -1.09216660e-01f, -4.88735914e-01f, 7.93942034e-01f,
  4.22129571e-01f, 1.54311314e-01f, -7.13267177e-02f, 5.80538332e-01f, -5.42126894e-01f, -3.16252023e-01f, 1.21644460e-01f, -2.05452040e-01f, -3.18468213e-01f, 2.93994874e-01f,
  -5.03338695e-01f, -2.31255159e-01f, -6.74113572e-01f, 2.70378023e-01f, 8.63064751e-02f, 2.97079295e-01f, -4.24230129e-01f, -5.89122891e-01f, 3.51253688e-01f, -1.14862904e-01f,
  -2.24775881e-01f, 4.07835990e-02f, 2.71528959e-01f, -4.84077245e-01f, 5.57233632e-01f, -2.74268895e-01f, 1.76243439e-01f, 4.97582294e-02f, 5.07638693e-01f, -1.78563803e-01f,
  1.59234315e-01f, -5.87625476e-03f, -7.38844499e-02f, 3.26113924e-02f, -6.77102625e-01f, -1.85051695e-01f, -4.88038272e-01f, 1.00122809e-01f, -4.89891917e-01f, -6.09271944e-01f,
  -8.49307656e-01f, 2.17911720e-01f, 2.24874407e-01f, 4.51129526e-01f, 3.56075555e-01f, -7.62163341e-01f, -1.97013482e-01f, -4.45637517e-02f, 4.14325356e-01f, 4.69629735e-01f,
  -2.47785375e-01f, 1.11722320e-01f, 1.24965914e-01f, -5.20675898e-01f, -9.85895157e-01f, -2.46993124e-01f, -4.40643847e-01f, -9.75078344e-02f, 3.12095582e-01f, 3.53769846e-02f,
  4.00796346e-02f, -7.01012760e-02f, 8.43949318e-02f, -1.66944087e-01f, -2.57793069e-01f, -3.06620300e-01f, 1.05747268e-01f, -5.62099397e-01f, 4.98905689e-01f, 2.78907686e-01f,
  2.20647514e-01f, -5.27447760e-01f, 3.50181200e-02f, 1.01978451e-01f, -2.29280621e-01f, -8.51120710e-01f, -2.56947279e-01f, -2.15679109e-01f, -7.71170318e-01f, 1.60269767e-01f,
  -5.02291203e-01f, 3.96842360e-01f, 2.08326191e-01f, 5.35592914e-01f, -4.71986920e-01f, -4.59565818e-02f, -1.13190509e-01f, 1.74073949e-01f, 1.89385369e-01f, -4.04567271e-01f,
  -2.70321846e-01f, 5.06644607e-01f, 3.46172154e-02f, 1.64618969e-01f, -1.43769339e-01f, 2.34104946e-01f, 3.20468456e-01f, 5.27600586e-01f, -2.93970525e-01f, 5.08404791e-01f,
  -2.49236152e-01f, -2.36924931e-01f, -5.54891288e-01f, 6.10196710e-01f, -4.22426105e-01f, 5.06490357e-02f, 3.11063588e-01f, -6.15273476e-01f, -6.86665237e-01f, 4.20127138e-02f,
  -1.10352263e-01f, -3.46257150e-01f, 1.02064654e-01f, -2.00447738e-01f, -7.43757142e-03f, -1.19369783e-01f, 3.04515660e-01f, -1.75083131e-01f, 4.29875225e-01f, 4.54140961e-01f,
  -5.95789373e-01f, 7.61084855e-02f, 3.40292692e-01f, -2.65494853e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.53977865e-01f, -6.66797236e-02f, 2.30427653e-01f, 1.82831474e-02f, 1.39166966e-01f, 2.11936273e-02f, -2.49220729e-01f, -2.26327017e-01f, -5.88682257e-02f, 7.18132360e-03f,
  -1.80342078e-01f, 2.19948620e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    