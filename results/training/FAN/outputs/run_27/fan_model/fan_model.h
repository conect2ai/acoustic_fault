/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.90928116e-01f, -1.19464271e-01f, 1.83298260e-01f, -2.09808767e-01f, 1.15302600e-01f, 5.78502595e-01f, 3.44429851e-01f, -8.97708237e-02f, 7.33602569e-02f, 2.09156908e-02f,
  6.95485175e-02f, -1.29259244e-01f, 6.50991946e-02f, -9.03777406e-02f, 2.20391899e-01f, 1.02197984e-02f, -1.06587345e-02f, 8.23533013e-02f, -4.39992286e-02f, -4.87953536e-02f,
  -7.68005624e-02f, -1.83909193e-01f, -3.19225080e-02f, 4.74151857e-02f, 7.02599436e-02f, -1.24967061e-01f, -2.06729501e-01f, 7.66853318e-02f, -3.44398469e-02f, -1.23211360e-02f,
  3.51943105e-04f, -9.94108617e-02f, 1.09987445e-02f, -6.18257606e-03f, 9.57523137e-02f, 1.42738789e-01f, 4.91698943e-02f, 3.28112468e-02f, 1.78127475e-02f, 3.20427120e-02f,
  -9.45493206e-02f, -3.51304710e-02f, -3.12589519e-02f, -3.87003063e-03f, 1.33462884e-02f, -9.01097879e-02f, -1.56792048e-02f, 2.69018952e-02f, -1.51559158e-04f, 1.97122376e-02f,
  7.70938210e-03f, 3.40045355e-02f, 2.49426775e-02f, -3.96418609e-02f, -1.30798826e-02f, -2.66048610e-02f, 1.14969620e-02f, 1.93450376e-02f, -4.90626134e-02f, -6.41608164e-02f,
  2.80619115e-02f, -5.00813015e-02f, 4.88605490e-03f, -1.10964039e-02f, 3.61150466e-02f, -1.68260615e-02f, 1.14924274e-02f, -9.97934956e-03f, -2.66089826e-03f, 2.04567071e-02f,
  -1.28673716e-02f, -2.01356243e-02f, -2.51343865e-02f, -2.14669071e-02f, -4.20332663e-02f, -7.61483461e-02f, 7.85027351e-03f, -6.68150634e-02f, 7.30925724e-02f, -1.13645578e-02f,
  -5.06616011e-02f, 6.64495006e-02f, 5.11625968e-03f, 1.31396810e-03f, 7.59312734e-02f, -6.08447613e-03f, -4.82322909e-02f, 2.90991664e-02f, -1.31376209e-02f, 3.00223697e-02f,
  1.66290030e-01f, -2.76767790e-01f, -3.99919637e-02f, 3.24297100e-02f, -5.21792993e-02f, -3.26511338e-02f, -5.43071553e-02f, -1.03644114e-02f, -2.24858560e-02f, 4.10343036e-02f,
  -3.70161422e-02f, 7.51343742e-02f, 2.25763153e-02f, -4.54432005e-03f, 1.59167182e-02f, 1.64579544e-02f, -2.89405584e-02f, -6.62573352e-02f, 2.29161489e-03f, -8.37198719e-02f,
  3.76900509e-02f, -1.95043976e-03f, 5.89553593e-03f, 1.51887350e-02f, 5.74658327e-02f, 1.39530944e-02f, 3.53058726e-02f, 3.41855735e-02f, -6.61109164e-02f, 3.88528518e-02f,
  -3.90262008e-01f, -4.12698835e-02f, -3.80088277e-02f, -6.30091354e-02f, -2.41478175e-01f, -4.69301688e-03f, -6.62847981e-02f, -1.50792047e-01f, 1.18570618e-01f, 1.12847067e-01f,
  -2.42604330e-01f, 1.28963679e-01f, 4.62563224e-02f, -1.71528548e-01f, -2.83654779e-01f, 6.92920806e-03f, -2.29480416e-02f, -3.41159739e-02f, -2.46288367e-02f, -6.36244491e-02f,
  -1.73829436e-01f, -2.09835514e-01f, -1.97742984e-01f, -6.62559122e-02f, -2.13411331e-01f, 7.59181082e-02f, -1.82967372e-02f, -1.56839211e-02f, -7.75088742e-02f, -4.29004012e-03f,
  9.53100389e-04f, -1.41913250e-01f, -7.29284734e-02f, 2.58716419e-02f, -1.94356814e-02f, -2.33653281e-02f, 4.64882888e-02f, 5.67233772e-04f, 7.12229870e-03f, -7.39728063e-02f,
  5.74051216e-02f, -4.85060290e-02f, 8.69630370e-03f, -8.67229402e-02f, 4.89482060e-02f, 6.74471706e-02f, -6.29280955e-02f, -9.03928578e-02f, -3.16147730e-02f, -2.46268921e-02f,
  -7.06211701e-02f, -9.89812613e-02f, 4.47770134e-02f, 1.31207228e-01f, 2.71193609e-02f, 6.09728806e-02f, 1.56736877e-02f, -3.43260020e-02f, 6.28795996e-02f, -3.70059721e-02f,
  1.00301076e-02f, -4.48502526e-02f, -1.14408270e-01f, 1.40719088e-02f, -1.39399111e-01f, -5.16746454e-02f, -1.65685508e-02f, -9.01949853e-02f, -1.48149421e-02f, -2.99543887e-02f,
  -7.74665698e-02f, -7.61281252e-02f, -2.98332307e-03f, -4.05108221e-02f, -2.85613313e-02f, 8.07368606e-02f, 5.95862158e-02f, 4.66251234e-03f, 6.26252294e-02f, -4.95544598e-02f,
  -2.52371393e-02f, -4.49351873e-03f, -7.99936578e-02f, 8.83565918e-02f, 4.49989811e-02f, -3.37619744e-02f, -6.34735078e-02f, -9.54495743e-03f, 4.43225130e-02f, 1.29347909e-02f,
  2.08948806e-01f, 5.42125143e-02f, 5.27209714e-02f, 5.33685796e-02f, 1.12921342e-01f, -1.28386974e-01f, -3.45748477e-02f, 5.33392765e-02f, 4.48884033e-02f, -6.06430545e-02f,
  2.22023502e-02f, 2.50862446e-02f, 1.61465202e-02f, -1.57208405e-02f, 2.60235891e-02f, -8.72829854e-02f, 1.63984671e-02f, 4.91423793e-02f, 7.51696229e-02f, 3.92815880e-02f,
  -2.27603819e-02f, 4.12931405e-02f, -7.80510809e-03f, 1.32257743e-02f, 1.35022933e-02f, 6.45098044e-03f, 8.30488577e-02f, 7.85247758e-02f, -9.88670159e-03f, 3.53787430e-02f,
  7.22488821e-01f, 3.28946680e-01f, 2.08074003e-01f, 2.80042499e-01f, 7.15353563e-02f, 3.47135253e-02f, 7.74580091e-02f, 5.09712361e-02f, 1.56704590e-01f, -8.97609964e-02f,
  -3.81842256e-02f, 1.20180309e-01f, 5.70595339e-02f, 6.45743608e-02f, 2.13533297e-01f, 1.61486082e-02f, 1.18443079e-01f, 4.32510041e-02f, 2.91276351e-02f, 1.34371862e-01f,
  5.52286431e-02f, -1.17972521e-02f, 8.92104954e-02f, -9.73248333e-02f, 4.99364175e-02f, 2.23009381e-02f, -1.05946757e-01f, -5.87206259e-02f, -2.39837989e-02f, -1.06918085e-02f,
  1.25951231e-01f, -1.13970570e-01f, 2.07334608e-02f, 1.38965352e-02f, 4.30694818e-02f, -5.82698546e-03f, -2.88483538e-02f, -5.37978783e-02f, 8.30139890e-02f, 4.79835719e-02f,
  -3.57600152e-02f, 4.88137566e-02f, -1.99072901e-02f, 4.42685699e-03f, -6.03062361e-02f, 2.66625155e-02f, 2.15021390e-02f, 2.75036693e-02f, 6.35516644e-02f, -1.02077045e-01f,
  7.99543038e-02f, -3.82133387e-02f, -3.73182818e-03f, -2.49917316e-03f, 2.31845248e-02f, -4.08244096e-02f, -4.31034938e-02f, -8.19126740e-02f, -3.68534923e-02f, -2.28139646e-02f,
  -6.88147247e-02f, 5.01216650e-02f, -2.25317827e-03f, 8.27651285e-03f, 7.86995366e-02f, -3.61999832e-02f, 2.27290746e-02f, 6.23118207e-02f, 6.62774071e-02f, -2.35028956e-02f,
  3.37085538e-02f, 2.08990332e-02f, -3.64594422e-02f, -2.30319183e-02f, -3.39507312e-03f, -3.08194049e-02f, 1.54374377e-03f, -7.50373974e-02f, -1.03391465e-02f, 4.28759791e-02f,
  -1.11993738e-02f, 2.27158181e-02f, -1.35931736e-02f, -4.82795388e-02f, 2.84029096e-02f, 7.51478001e-05f, -3.00963167e-02f, 1.93936136e-02f, -2.36216858e-02f, 2.01437939e-02f,
  2.36725792e-01f, 1.42268181e-01f, -2.79456954e-02f, 4.91045117e-02f, -1.05269412e-02f, -1.92733796e-03f, 2.45624185e-02f, 5.32130674e-02f, 1.47038391e-02f, 3.91365699e-02f,
  -8.13746452e-02f, -3.12392283e-02f, 4.26615030e-03f, -2.05124673e-02f, -7.34056160e-03f, -6.61571650e-03f, 4.31101536e-03f, 4.47791331e-02f, 6.75768405e-03f, -3.77820851e-03f,
  1.67691857e-02f, 2.88994005e-03f, 9.51405556e-04f, 2.39299070e-02f, -5.14556058e-02f, -2.51184888e-02f, 3.71662043e-02f, 5.89185813e-03f, 1.10936277e-02f, -5.38468622e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.98120630e-01f, -3.81081611e-01f, -9.27632395e-03f, 2.97501951e-01f, 2.99541533e-01f, 9.85711068e-02f, 1.57497093e-01f, 1.42739907e-01f, 2.60518640e-01f, -1.95122644e-01f,
  8.51016566e-02f, -1.55012697e-01f, -1.94134623e-01f, 7.77474865e-02f, 1.96078584e-01f, -2.15471253e-01f, 1.78290203e-01f, 3.55419815e-02f, 1.85590878e-01f, 1.40263483e-01f,
  1.95946351e-01f, 1.36303291e-01f, -7.08476291e-04f, -4.52703573e-02f, 2.56173760e-01f, 8.42971802e-02f, -5.19121364e-02f, -1.06651574e-01f, -4.44624526e-03f, -6.47199973e-02f,
  2.42477283e-01f, -5.59218377e-02f, 9.31901038e-02f, 9.93412882e-02f, 4.36768010e-02f, -1.28691643e-02f, 2.01388076e-02f, -5.89152873e-02f, 1.25591412e-01f, -7.77444663e-03f,
  1.99523903e-02f, 7.85272270e-02f, 2.85511520e-02f, -1.14181198e-01f, 1.04628682e-01f, 1.13454685e-01f, -1.48389675e-02f, 3.19760889e-02f, 7.10076420e-03f, -4.92102504e-02f,
  -7.34542832e-02f, -5.57099655e-02f, 1.11656465e-01f, -1.00909606e-01f, -9.71792117e-02f, 8.34077373e-02f, 6.09501824e-02f, -8.29334930e-02f, 6.46302768e-04f, -8.57902244e-02f,
  -2.00676024e-01f, -5.16154207e-02f, -2.20297631e-02f, 1.83624163e-01f, -9.87272337e-02f, 4.81118299e-02f, 5.17776459e-02f, -1.16067603e-01f, -4.10604663e-02f, 9.92549509e-02f,
  2.86019091e-02f, 8.31876695e-02f, 1.15649045e-01f, 3.90603580e-02f, 9.33022797e-02f, -3.87588032e-02f, 8.63610730e-02f, -9.82165411e-02f, 8.02890435e-02f, 1.81805268e-01f,
  -6.06899485e-02f, -1.37651358e-02f, -8.75957981e-02f, 4.90174480e-02f, 8.34090933e-02f, -1.12324089e-01f, -3.47350053e-02f, -7.72173554e-02f, 7.96987638e-02f, 1.00112870e-01f,
  -1.66186377e-01f, -7.98157930e-01f, -1.27405683e-02f, 3.07266656e-02f, -8.90492126e-02f, 1.57705415e-02f, 5.11437990e-02f, 6.48241714e-02f, -2.64061484e-02f, -1.05033480e-01f,
  3.42698917e-02f, 3.61101143e-02f, -3.47251929e-02f, 2.82410383e-02f, 2.61947792e-03f, -2.76797414e-02f, -1.70170292e-01f, -1.32450044e-01f, -1.07621923e-02f, 1.25933131e-02f,
  -8.27082470e-02f, -1.24095879e-01f, -2.28116103e-02f, 9.79726017e-02f, 1.79558732e-02f, -1.17139429e-01f, 2.89415512e-02f, 4.74282503e-02f, -1.59264699e-01f, -9.76074561e-02f,
  -1.42589912e-01f, 4.31596011e-01f, -4.52000260e-01f, -1.02811800e-02f, -2.23620117e-01f, 7.02021182e-01f, 5.51592112e-01f, -3.96626517e-02f, 2.21480072e-01f, 4.67423737e-01f,
  2.03271776e-01f, 3.13875973e-01f, 1.45003334e-01f, 6.38903379e-01f, 1.12857996e-02f, 5.74668646e-01f, 4.71984744e-01f, 3.69493276e-01f, -1.49841890e-01f, 2.91576460e-02f,
  -2.12313458e-01f, 2.78763562e-01f, -5.60131930e-02f, -9.38178450e-02f, -1.85347665e-02f, -4.65699792e-01f, -2.95063108e-01f, -3.31757575e-01f, -9.87468194e-03f, 2.33837776e-02f,
  1.02017216e-01f, -1.90646779e-02f, -8.03924352e-02f, 7.72058740e-02f, -1.05393946e-01f, -1.38710231e-01f, -3.22196968e-02f, -9.80710834e-02f, -1.55168831e-01f, -2.20739506e-02f,
  -6.30258396e-02f, -9.79658589e-02f, 9.60536078e-02f, -9.80113745e-02f, -1.00672394e-01f, -1.70506865e-01f, -1.53792366e-01f, 3.15308124e-02f, 3.41896974e-02f, 6.59299865e-02f,
  -8.75480026e-02f, -8.87110010e-02f, -3.13591678e-03f, 4.34303246e-02f, -9.64387581e-02f, 9.77794155e-02f, 1.75573453e-01f, -1.39978947e-02f, -3.91679928e-02f, -1.95258553e-03f,
  1.19939586e-02f, -2.12699622e-02f, -2.87407101e-03f, -7.88306668e-02f, -7.04071373e-02f, -7.49941841e-02f, 6.82681128e-02f, -1.26346089e-02f, -8.17344561e-02f, 5.45061678e-02f,
  -1.04329258e-01f, -6.73747212e-02f, 3.87969799e-02f, 1.00513101e-01f, -6.84741214e-02f, -6.50509968e-02f, -8.68224427e-02f, 6.93271533e-02f, 1.48293851e-02f, 1.92652177e-02f,
  6.68736780e-03f, 4.59303297e-02f, -2.08190382e-02f, 3.29762809e-02f, -1.01461755e-02f, -1.37652099e-01f, 9.03286785e-02f, 2.00111978e-02f, 2.11883932e-02f, -6.59912676e-02f,
  2.96070278e-01f, 2.00696781e-01f, 6.24827817e-02f, -1.39234327e-02f, -2.60101575e-02f, -3.46213505e-02f, 5.43874986e-02f, 1.39746487e-01f, 3.76999006e-02f, 1.09275328e-02f,
  1.62594970e-02f, 6.84602708e-02f, 2.18992848e-02f, -1.84000917e-02f, -4.74674217e-02f, 1.39668614e-01f, 5.07628322e-02f, -1.25769928e-01f, 1.63435638e-02f, -8.73067528e-02f,
  1.24713788e-02f, -4.59951572e-02f, 2.18760706e-02f, 5.11754826e-02f, 3.44999135e-02f, -2.24401411e-02f, -5.78726409e-03f, -8.77833590e-02f, -1.14880562e-01f, 9.10312533e-02f,
  1.55176580e-01f, -3.66633683e-01f, 3.51858020e-01f, -3.52220163e-02f, 8.87512565e-02f, -2.19850652e-02f, 1.83025166e-01f, -4.29527640e-01f, -8.06673840e-02f, -4.53631341e-01f,
  -1.83401898e-01f, 1.77583992e-01f, 3.21584940e-01f, -3.79213750e-01f, 6.71082318e-01f, 2.41751805e-01f, -2.97337234e-01f, -1.35326979e-03f, 2.80453302e-02f, -2.69386023e-01f,
  1.11596193e-02f, -5.13084710e-01f, 2.33791903e-01f, -5.76215386e-01f, -4.61400598e-02f, -2.06037551e-01f, -4.92715575e-02f, 1.46852791e-01f, -3.63263100e-01f, 1.64233938e-01f,
  -3.38915050e-01f, -2.50416577e-01f, -8.91763121e-02f, -1.14577554e-01f, -5.58939949e-02f, -8.79121646e-02f, 1.66045092e-02f, 1.41607910e-01f, 4.42149639e-02f, 8.88977125e-02f,
  8.64066407e-02f, 4.93521523e-03f, -1.17326044e-02f, 9.51129049e-02f, -1.01393804e-01f, -2.74784621e-02f, 2.24707182e-02f, -4.45132330e-02f, 3.90854999e-02f, 1.18181810e-01f,
  1.64667532e-01f, 2.45526228e-02f, -6.49680793e-02f, -6.12747222e-02f, 1.00363776e-01f, -1.21611647e-01f, 7.65652210e-02f, 1.45592228e-01f, -2.77480911e-02f, -3.42205949e-02f,
  -1.05746821e-01f, -1.20494448e-01f, 8.36632773e-02f, -1.59969330e-01f, -1.11003876e-01f, 1.68608446e-02f, -4.59992625e-02f, -1.19332159e-02f, -2.64289435e-02f, -1.84350669e-01f,
  -8.49735290e-02f, -2.03809477e-02f, 4.83210664e-03f, 8.79621655e-02f, 2.19600387e-02f, -8.77145752e-02f, 3.75877135e-02f, -2.51846462e-02f, 9.66829956e-02f, -1.99015997e-02f,
  3.74897309e-02f, 6.57885987e-03f, -1.13938493e-03f, 7.24496394e-02f, -7.76539370e-02f, 4.92393859e-02f, -4.34200503e-02f, 1.87015310e-02f, 5.29025942e-02f, 1.32826850e-01f,
  -3.92660558e-01f, -3.97609740e-01f, -1.64426297e-01f, -1.05401896e-01f, -1.28288716e-01f, -1.25009835e-01f, -5.87752871e-02f, -3.44198942e-02f, -2.21659124e-01f, -1.37779623e-01f,
  -1.92201659e-01f, -9.20798331e-02f, 6.68791831e-02f, 2.83689145e-02f, -6.39888197e-02f, -2.57146079e-02f, -4.81751822e-02f, -4.82317507e-02f, -6.72644228e-02f, -8.04498717e-02f,
  -9.16081518e-02f, 5.34190498e-02f, 8.86176825e-02f, 6.21491186e-02f, -1.48417979e-01f, 5.51160716e-04f, 9.22292843e-02f, -4.28928696e-02f, 8.81419405e-02f, 9.67821106e-03f,
  -5.94483435e-01f, 1.88383847e-01f, 5.31426631e-03f, -5.81107199e-01f, 7.15074167e-02f, -2.64034331e-01f, -2.83113271e-01f, 1.42210424e-01f, 2.17891961e-01f, 1.65646896e-01f,
  -5.61338812e-02f, -2.80450098e-02f, 3.56393695e-01f, -1.83727920e-01f, -3.63351256e-02f, 3.45120877e-01f, -1.51433438e-01f, -9.01698992e-02f, 2.38719687e-01f, -1.43481612e-01f,
  -1.43515259e-01f, -1.29601255e-01f, 3.55730876e-02f, 9.70297400e-03f, -3.66753846e-01f, -1.76495448e-01f, -2.00526640e-01f, 3.01711611e-04f, -2.54331321e-01f, 1.05700716e-02f,
  -2.81694978e-01f, -1.01525165e-01f, -1.08780839e-01f, -1.80985853e-02f, -2.57541686e-01f, -4.69714105e-02f, -2.35076055e-01f, -6.29803389e-02f, -6.77037910e-02f, -1.68005768e-02f,
  6.50030747e-02f, -6.17166944e-02f, -7.90437385e-02f, 7.64486045e-02f, -8.09965953e-02f, -2.93063950e-02f, 7.03831911e-02f, -5.19924872e-02f, -4.87855896e-02f, 5.06491922e-02f,
  1.23910993e-01f, -3.92441414e-02f, -1.32273853e-01f, 6.79633021e-02f, 8.87977555e-02f, -5.79102598e-02f, -5.82178235e-02f, 1.52278775e-02f, -6.55920431e-02f, -7.73254037e-02f,
  -2.95276809e-02f, 1.34720162e-01f, -6.11329451e-02f, 9.07142609e-02f, 4.40506525e-02f, 2.05349345e-02f, -1.01707997e-02f, 1.15148975e-02f, 4.88404557e-02f, 8.97192657e-02f,
  -8.95808800e-04f, -2.43561435e-02f, -6.97296932e-02f, -7.26298094e-02f, -6.46686256e-02f, -8.16371366e-02f, -1.11910477e-02f, -5.49080111e-02f, 1.83507148e-02f, -6.43545166e-02f,
  4.50940728e-02f, -1.43334614e-02f, 2.36610889e-01f, -6.03047051e-02f, -9.63202417e-02f, 4.76518869e-02f, -4.93620001e-02f, 3.44916782e-03f, 1.69988666e-02f, -1.81040782e-02f,
  -4.68033224e-01f, -3.33956063e-01f, -2.15588976e-02f, -1.16668187e-01f, -1.02316089e-01f, -1.47360429e-01f, 1.69842876e-02f, 1.55844055e-02f, -1.66241340e-02f, 8.64722878e-02f,
  -8.74271318e-02f, -7.29655102e-02f, -9.32862684e-02f, -4.72187437e-02f, 8.99796411e-02f, -2.20425874e-02f, 3.17266919e-02f, 2.36866856e-03f, -1.27529740e-01f, -1.05738401e-01f,
  -1.09839916e-01f, 1.24268383e-02f, 1.35876417e-01f, -1.07433321e-02f, -8.49038810e-02f, -2.15421785e-02f, -5.60002327e-02f, -4.36659232e-02f, -3.33788209e-02f, 1.16270423e-01f,
  2.49771878e-01f, 4.26980034e-02f, -3.73791426e-01f, -2.49906242e-01f, -4.63208735e-01f, 7.86511377e-02f, -2.75701463e-01f, -3.85573693e-02f, -2.51414776e-01f, 8.19595978e-02f,
  -3.97129297e-01f, 1.19716018e-01f, 1.60076648e-01f, -1.60745939e-03f, 2.74709731e-01f, 5.18572986e-01f, -1.61305785e-01f, -1.82441454e-02f, 1.53952941e-01f, 8.50003213e-03f,
  -5.62093519e-02f, -5.93124293e-02f, 6.66079447e-02f, -3.96372266e-02f, -2.72649109e-01f, 1.17534201e-03f, -2.08133340e-01f, -3.49356502e-01f, -3.81249696e-01f, -3.01723272e-01f,
  1.64154992e-01f, -5.33857383e-02f, -1.13301679e-01f, 7.50177354e-02f, -3.21181081e-02f, -3.43266241e-02f, -1.24327697e-01f, 3.31736146e-03f, -3.10102142e-02f, -1.36671007e-01f,
  4.39678989e-02f, 7.87220299e-02f, -7.69052505e-02f, -2.16803905e-02f, -4.52025868e-02f, -2.36394256e-01f, -6.26252079e-03f, -9.10725817e-02f, 2.05969978e-02f, 5.20317778e-02f,
  -1.69002220e-01f, -1.75716653e-01f, -1.89969733e-01f, 2.50464901e-02f, -1.45454362e-01f, -2.18069151e-01f, -4.96945065e-03f, -1.15979455e-01f, -4.17669304e-02f, -8.26136768e-02f,
  -7.04384595e-02f, 2.58007478e-02f, 1.34879366e-01f, 1.18296891e-02f, 4.04956900e-02f, -1.53769590e-02f, -3.00239660e-02f, -9.85566713e-03f, -8.66467282e-02f, 2.94790301e-03f,
  -6.07176721e-02f, 5.60761616e-03f, 7.34653473e-02f, 8.00923929e-02f, 1.30385801e-01f, 1.24604717e-01f, 2.04963759e-02f, -2.72696894e-02f, -1.96674466e-01f, 1.58416070e-02f,
  2.42346041e-02f, 8.93530995e-02f, -1.19106099e-01f, 3.70250121e-02f, 6.95029125e-02f, 6.82439059e-02f, -5.36780544e-02f, 6.60099015e-02f, 3.64732891e-02f, -5.71551174e-02f,
  1.23976968e-01f, 1.12829611e-01f, -8.14833120e-02f, 6.29462376e-02f, 9.93767977e-02f, 2.01859921e-02f, 5.10378070e-02f, -9.61774290e-02f, -1.86483532e-01f, -1.38087990e-03f,
  -2.43297797e-02f, 2.30484400e-02f, 2.18856130e-02f, -9.57860500e-02f, -5.75246327e-02f, 5.20420447e-02f, 3.31543796e-02f, -3.10233906e-02f, -1.45043120e-01f, -3.27129215e-02f,
  1.55308070e-02f, 1.29843503e-02f, 5.52899726e-02f, -1.40289336e-01f, -2.98173167e-02f, -1.59614936e-01f, 4.41206023e-02f, -2.23415159e-02f, -1.07775785e-01f, -1.82723343e-01f,
  -6.97415888e-01f, 7.08871484e-01f, 1.16778091e-01f, -1.80303738e-01f, 2.92324517e-02f, 1.62808999e-01f, 1.29501792e-02f, 1.97004192e-02f, 6.35035709e-02f, -1.70524031e-01f,
  -2.61435181e-01f, 1.63060814e-01f, 3.58340368e-02f, -1.60958230e-01f, -2.09917843e-01f, 7.36236125e-02f, -3.32564861e-01f, -3.38604122e-01f, 2.04850882e-01f, -1.95993766e-01f,
  -1.83667377e-01f, -3.07788551e-02f, -1.36087209e-01f, 2.76462138e-01f, 4.05309955e-03f, 1.60064958e-02f, -4.36895192e-01f, 1.98259011e-01f, -8.90734270e-02f, 9.03428197e-02f,
  1.57129899e-01f, 5.35376854e-02f, 3.88544574e-02f, 7.57780252e-03f, -1.74470976e-01f, -1.27711698e-01f, -1.25252739e-01f, 7.20938817e-02f, 1.49645815e-02f, -8.62491783e-03f,
  -4.49182913e-02f, 1.81452066e-01f, 2.75454707e-02f, 3.16270776e-02f, -1.01200052e-01f, 1.37465686e-01f, 1.37935966e-01f, 3.22468281e-02f, 4.52572219e-02f, -3.33915502e-02f,
  8.37942287e-02f, 5.67085743e-02f, -1.37552589e-01f, -9.09238979e-02f, 5.24746114e-03f, 1.04840957e-01f, -4.12251800e-02f, -4.36423160e-02f, -2.58549470e-02f, -5.56411482e-02f,
  7.46148452e-02f, -1.70230418e-02f, -6.79997727e-03f, 8.61778036e-02f, 4.43500876e-02f, -7.41047710e-02f, 6.99032992e-02f, -2.59491522e-02f, 7.98494890e-02f, -5.34747131e-02f,
  -6.08108938e-02f, -3.42843309e-02f, 4.26358059e-02f, -1.37191176e-01f, -8.40374902e-02f, 5.38001470e-02f, -8.36753380e-03f, -2.93285791e-02f, -1.05455808e-01f, 9.49616283e-02f,
  1.09489150e-02f, -3.57393995e-02f, -8.67272019e-02f, -2.57688928e-02f, 1.12813704e-01f, -9.05558616e-02f, -2.68955342e-02f, 7.73839951e-02f, 5.33088259e-02f, -4.64078002e-02f,
  -2.67181635e-01f, -2.96417862e-01f, 1.19686298e-01f, 2.15716258e-01f, 1.43317387e-01f, 1.63482949e-02f, 1.41303986e-01f, 1.57087750e-03f, -3.16185765e-02f, -9.48207453e-02f,
  -2.10512772e-01f, -1.07958689e-01f, -1.24668412e-01f, 5.03277592e-02f, 2.51120259e-03f, -1.49495583e-02f, -2.82567769e-01f, -4.37667780e-02f, -1.00163907e-01f, 1.49282180e-02f,
  -5.71327880e-02f, -2.90452801e-02f, 2.42938623e-02f, -9.66381654e-03f, -1.70789808e-01f, -1.16800275e-02f, -1.71271041e-01f, 5.67371547e-02f, -2.49404907e-02f, -2.63177436e-02f,
  4.57250983e-01f, 3.30758393e-01f, 2.59534240e-01f, 2.75128007e-01f, -1.78956345e-01f, -1.62721142e-01f, -1.23258028e-02f, -5.30993193e-02f, 3.38443756e-01f, 1.36478022e-01f,
  -7.15153590e-02f, 5.12792766e-01f, -7.54215494e-02f, 1.85803697e-01f, -4.82423872e-01f, -7.36647546e-02f, -3.59248347e-03f, 1.79547802e-01f, -5.73232658e-02f, 1.21574238e-01f,
  -7.00031640e-03f, -4.70004171e-01f, -1.56165421e-01f, -2.26208657e-01f, 1.36389613e-01f, 8.48244205e-02f, -4.53476906e-01f, -2.19978794e-01f, -4.10648389e-03f, -1.34141847e-01f,
  1.16259061e-01f, 2.02834353e-01f, 2.09174901e-01f, -9.40282084e-03f, -8.34911093e-02f, -4.51400988e-02f, 9.01919324e-03f, -2.30205283e-02f, -2.64837556e-02f, -2.61853747e-02f,
  -2.75231828e-03f, -1.19472191e-01f, 4.40657437e-02f, 4.62697931e-02f, 6.22731522e-02f, 7.71074891e-02f, 1.41053110e-01f, 1.19294003e-01f, 1.59407124e-01f, 1.15174711e-01f,
  1.48714185e-01f, 2.34128404e-02f, 2.36238074e-02f, 2.22027674e-03f, 6.46503046e-02f, 7.84403384e-02f, 5.63974679e-02f, 1.67924426e-02f, 1.11488849e-01f, 6.54533273e-03f,
  -9.05364603e-02f, -3.27910110e-02f, 4.71355468e-02f, -1.62142478e-02f, 8.04783329e-02f, 9.07427594e-02f, -3.91314439e-02f, -3.99300456e-02f, 4.68290644e-03f, -1.67553574e-02f,
  -8.01478624e-02f, 1.23185501e-01f, 8.46910626e-02f, 1.06252402e-01f, -9.49358419e-02f, 4.77486774e-02f, -1.07908938e-02f, 5.95302060e-02f, 7.30966851e-02f, -5.71740344e-02f,
  4.14079055e-02f, -5.16719855e-02f, 5.92083707e-02f, 1.73651427e-02f, -1.27441466e-01f, 1.96499261e-03f, 8.19116160e-02f, 9.17580426e-02f, 6.13985360e-02f, -1.44660175e-01f,
  -3.90261859e-01f, -3.54601830e-01f, -5.02783805e-02f, 1.57159735e-02f, 9.37626977e-03f, -1.11034252e-02f, -3.24479230e-02f, 1.26123816e-01f, -2.56199270e-01f, 1.04201935e-01f,
  9.59520638e-02f, 5.24771400e-02f, -3.11024208e-02f, -1.33208781e-02f, -1.78049102e-01f, -8.40871707e-02f, -6.31335825e-02f, -1.41322881e-01f, -1.38544142e-01f, -4.10730615e-02f,
  7.62138218e-02f, -1.47995015e-03f, -8.86914879e-02f, -4.66605872e-02f, 8.87548625e-02f, -1.35998145e-01f, 5.87179512e-02f, 4.43676300e-02f, -1.00250378e-01f, -2.19686069e-02f,
  -4.02503647e-02f, -4.00238723e-01f, -2.77135998e-01f, 2.30116963e-01f, 4.87687498e-01f, 4.63400483e-01f, -1.45712093e-01f, 3.25866312e-01f, 6.27889633e-02f, -3.69449675e-01f,
  -1.17650032e-01f, -3.01165462e-01f, -5.74454010e-01f, 2.61662573e-01f, 3.69368970e-01f, -3.79823893e-02f, 4.41015452e-01f, 1.54969424e-01f, 1.36184350e-01f, -8.60512480e-02f,
  4.07447852e-02f, 3.66175264e-01f, -4.42591384e-02f, 2.09083200e-01f, -7.68151134e-02f, -3.89650501e-02f, -7.74920285e-02f, -3.47428203e-01f, 1.26061678e-01f, 2.22007349e-01f,
  2.80398671e-02f, -2.62973577e-01f, -2.10425884e-01f, -1.72415465e-01f, -7.76081309e-02f, -1.41847990e-02f, -2.68794268e-01f, 5.14681414e-02f, 5.32757863e-02f, 6.09682081e-03f,
  -1.43170476e-01f, 5.15557304e-02f, 1.68243632e-01f, 2.54822522e-02f, 8.88639968e-03f, 1.15777142e-02f, 4.17828634e-02f, -1.02352705e-02f, -1.00920871e-01f, 3.81149091e-02f,
  -8.88447165e-02f, 9.96784046e-02f, -5.81601225e-02f, 8.94397944e-02f, 3.47552262e-02f, -4.55383882e-02f, 1.56196523e-02f, -7.48490319e-02f, 3.60285528e-02f, 3.62757929e-02f,
  1.41492829e-01f, -1.47191184e-02f, -5.98359145e-02f, -5.58874905e-02f, -3.54213677e-02f, 6.56127483e-02f, 1.79221537e-02f, 4.40154225e-02f, -9.76232216e-02f, -1.65095106e-02f,
  5.17050177e-02f, -6.61195070e-02f, 2.04387512e-02f, -1.08170966e-02f, 1.64233129e-02f, -2.18430837e-03f, -1.92619469e-02f, 6.03079796e-02f, -4.88343351e-02f, 6.63284166e-03f,
  -3.05845477e-02f, 1.15489541e-02f, -5.46168424e-02f, 8.34666491e-02f, -2.82620881e-02f, -4.68604304e-02f, -4.42939103e-02f, -1.08285286e-01f, -3.99447903e-02f, 3.03363614e-02f,
  -4.45600867e-01f, -3.92473668e-01f, -1.10642128e-01f, 2.75156423e-02f, -1.08199127e-01f, -1.19067885e-01f, -2.48537511e-02f, -8.05604905e-02f, -1.04310863e-01f, 6.06129616e-02f,
  -7.61653855e-02f, 1.72777791e-02f, -9.34548117e-03f, 1.67347610e-01f, -2.15598680e-02f, -3.80041189e-02f, -1.25578076e-01f, -1.00734737e-02f, -3.41104716e-02f, -3.74555402e-02f,
  -1.40106231e-02f, -1.80637762e-02f, 6.92847967e-02f, 1.50057487e-02f, 8.31721947e-02f, -1.87975243e-02f, 3.31932940e-02f, 3.42846774e-02f, 1.18273549e-01f, 2.00909358e-02f,
  -1.14791417e+00f, -5.62805720e-02f, 3.37742031e-01f, -3.00832748e-01f, 1.49337783e-01f, 5.87776780e-01f, 4.29987937e-01f, 8.37475806e-02f, -2.64487922e-01f, 2.50467728e-03f,
  1.42338544e-01f, -1.33120582e-01f, 2.38882020e-01f, 3.76496136e-01f, 3.87246281e-01f, 2.26185396e-01f, 3.03339988e-01f, 1.58052996e-01f, -2.02596560e-02f, -1.54761359e-01f,
  1.10010458e-02f, 1.61065646e-02f, 3.31834078e-01f, -1.14952289e-01f, 5.23366220e-03f, -3.15617651e-01f, -1.00792281e-01f, -8.80946033e-03f, 1.58718333e-01f, 9.26820338e-02f,
  6.48860633e-02f, -2.91202039e-01f, 4.24918672e-03f, 5.52219339e-02f, 1.08658664e-01f, 1.61218294e-03f, 8.44313130e-02f, 7.44378492e-02f, -1.55714275e-02f, 3.62924370e-03f,
  -9.92492586e-02f, 8.98628775e-03f, -6.45873621e-02f, -4.23842221e-02f, -2.81053297e-02f, 4.50174697e-03f, 6.16751015e-02f, 2.02513978e-01f, 2.76176929e-02f, 1.07553869e-01f,
  1.32882237e-01f, 4.67832983e-02f, 6.91307858e-02f, 1.70910694e-02f, 2.18994003e-02f, -3.20975929e-02f, -4.15174104e-02f, 8.90917182e-02f, 1.46999117e-02f, 1.10487798e-02f,
  -5.18376417e-02f, 2.28868127e-02f, 3.59909907e-02f, -8.25373009e-02f, 1.08887568e-01f, -6.71786144e-02f, -3.14060040e-02f, -9.06442851e-02f, -2.98900288e-02f, -5.52542210e-02f,
  -1.25868559e-01f, 4.95267734e-02f, -4.54376675e-02f, 2.74337251e-02f, -5.68655059e-02f, -4.74993438e-02f, -5.42973615e-02f, -3.06711216e-02f, -5.62657742e-03f, 6.13476001e-02f,
  -2.15877290e-03f, -8.02604333e-02f, 8.41715932e-02f, -5.73477708e-02f, -1.15791068e-03f, 6.59337044e-02f, 9.48209595e-03f, -3.34671475e-02f, -1.79476272e-02f, 4.93612029e-02f,
  -2.50907570e-01f, -3.57745439e-01f, -4.14100885e-02f, -6.33847788e-02f, 5.16999885e-02f, 1.35852575e-01f, -2.38094069e-02f, 6.79060370e-02f, -4.37990688e-02f, 3.40758753e-03f,
  -4.81385961e-02f, -1.90347955e-02f, -1.17368244e-01f, -1.44763002e-02f, 1.04759283e-01f, 2.13775430e-02f, -1.00967400e-01f, -8.01002234e-02f, -4.18162048e-02f, -5.00825830e-02f,
  -1.09024212e-01f, -7.03465864e-02f, -4.19106707e-02f, 3.72400358e-02f, -3.24003436e-02f, -3.47123668e-02f, -9.55799669e-02f, -1.03543311e-01f, 7.10959211e-02f, 1.14944475e-02f,
  5.04889846e-01f, 1.35002062e-01f, 3.24942142e-01f, 2.88411051e-01f, 1.98889300e-01f, 3.48108411e-01f, 4.87165838e-01f, 2.32350484e-01f, 8.60781968e-01f, -2.75500923e-01f,
  -1.37657762e-01f, 7.62791634e-02f, -1.00955196e-01f, -6.95272610e-02f, 2.35174879e-01f, 1.35202765e-01f, 2.26057619e-01f, 2.53793802e-02f, 3.16741854e-01f, 8.38486105e-03f,
  1.32370636e-01f, -9.94653627e-02f, -2.16654882e-01f, -2.88083941e-01f, -1.84471801e-01f, -2.30825171e-01f, -5.26564121e-01f, 2.71203425e-02f, -2.54709452e-01f, -1.24785714e-02f,
  -7.86993504e-02f, -3.16956174e-03f, -9.85466912e-02f, 5.13863713e-02f, -4.39046845e-02f, -1.59228981e-01f, -4.96293120e-02f, 1.26221096e-02f, 9.83736441e-02f, -7.43226036e-02f,
  3.21892067e-03f, -4.86894846e-02f, 1.46575728e-02f, 3.97236012e-02f, 8.97041038e-02f, -2.89932229e-02f, -4.78220023e-02f, -1.47843584e-02f, -9.70630869e-02f, 1.48654636e-03f,
  4.38714772e-02f, -4.05450352e-02f, 9.76060033e-02f, -1.81526318e-02f, -4.40263131e-04f, 8.16634372e-02f, 6.61912933e-02f, -1.73967835e-02f, -1.66504867e-02f, 7.23062754e-02f,
  -6.90495670e-02f, 8.44993517e-02f, 1.51990643e-02f, 3.26305954e-03f, 2.91374568e-02f, 1.55742913e-02f, -4.46670502e-03f, -1.22726783e-01f, 1.28008291e-01f, -1.07393442e-02f,
  6.49885312e-02f, 6.51891604e-02f, 5.98967485e-02f, 1.88910821e-03f, 3.44719440e-02f, -8.12432822e-03f, -5.07979915e-02f, -2.90939808e-02f, -3.97691093e-02f, -3.53961252e-02f,
  -4.56803776e-02f, 3.70668955e-02f, -4.57412004e-02f, -6.38956577e-02f, -5.71251623e-02f, 5.65374978e-02f, -8.09134319e-02f, -9.16966610e-03f, -3.60262357e-02f, 2.50879433e-02f,
  1.18717745e-01f, 4.51779179e-02f, -1.23528233e-02f, -1.52346836e-02f, 3.53239104e-02f, -4.99647930e-02f, 4.46704142e-02f, -4.59996285e-03f, 1.00296028e-01f, 1.83759797e-02f,
  2.19158288e-02f, -3.48197902e-03f, -1.07370518e-01f, 3.03287227e-02f, 5.81768565e-02f, -2.91057676e-02f, -5.71308285e-02f, 4.97408137e-02f, 2.41233967e-02f, -2.23597996e-02f,
  -1.22804135e-01f, -3.27862031e-03f, 9.92133096e-02f, -7.82416910e-02f, -8.72336105e-02f, -1.40356198e-01f, -1.08887322e-01f, 5.06211556e-02f, -3.23864892e-02f, 9.81208012e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.29718804e-02f, 1.92000315e-01f, 5.75691700e-01f, 3.79089773e-01f, 1.46433473e-01f, 1.79881632e-01f, 1.65386379e-01f, 3.33194941e-01f, 5.38636863e-01f, 4.49682355e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.89389741e-01f, -3.55014443e-01f, -4.65078168e-02f, 4.99227881e-01f, 6.62971199e-01f, -2.14771867e-01f, -3.68406236e-01f, 2.29791135e-01f, -2.36048400e-02f, 3.60392854e-02f,
  4.15509552e-01f, -1.77192077e-01f, -6.43403113e-01f, -2.71874189e-01f, 1.27714500e-01f, 2.34690949e-01f, 8.99710506e-02f, 1.11211032e-01f, 3.46063048e-01f, 2.33632140e-02f,
  6.48304164e-01f, 2.30134413e-01f, -2.79215455e-01f, 1.94707513e-01f, 1.27041370e-01f, 8.14338326e-02f, 2.74990827e-01f, -3.03319067e-01f, -4.10325497e-01f, -2.51895279e-01f,
  -1.11154437e-01f, 5.05834997e-01f, -7.09509194e-01f, -3.11673917e-02f, -1.51230410e-01f, -4.02440101e-01f, -2.87311196e-01f, -4.17554826e-02f, -2.81138271e-01f, -3.76916826e-01f,
  2.96160638e-01f, 2.93951482e-01f, 1.11113951e-01f, 2.99239367e-01f, -2.70149022e-01f, -3.28758448e-01f, 2.04341058e-02f, -3.37613463e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.42400283e-01f, 1.86507612e-01f, 3.77514511e-01f, 2.49192137e-02f, -2.04183966e-01f, -4.08802420e-01f, 8.92779708e-01f, -8.22576404e-01f, -8.45560953e-02f, 2.96201348e-01f,
  -4.11431640e-01f, 6.38755143e-01f, 7.45877445e-01f, 6.38268530e-01f, 8.00288767e-02f, 2.06851706e-01f, 1.05947927e-01f, 3.34728241e-01f, 6.03854179e-01f, 3.80404234e-01f,
  2.09480405e-01f, 7.16821074e-01f, 2.16511130e-01f, 3.99499178e-01f, 3.65950853e-01f, -2.72548735e-01f, -1.46439031e-01f, -3.38914186e-01f, 5.95049441e-01f, 2.78471023e-01f,
  -3.19457233e-01f, 7.82698274e-01f, 4.50644463e-01f, 4.08214509e-01f, 3.07398230e-01f, 4.10119355e-01f, -7.50299990e-01f, -3.18646252e-01f, 5.16052127e-01f, 5.08993149e-01f,
  -6.40162975e-02f, -3.78193855e-02f, 1.29323661e-01f, 1.64544865e-01f, -2.31093213e-01f, 7.45545626e-01f, 7.64890790e-01f, -8.65418762e-02f, 8.73996258e-01f, 3.71478707e-01f,
  4.26292479e-01f, 4.72945869e-01f, -2.76574254e-01f, -2.07704574e-01f, 6.21466637e-01f, 7.74914265e-01f, -4.83085588e-02f, -2.39505708e-01f, 1.33818537e-01f, -9.25713498e-03f,
  -2.52531916e-01f, 4.85765904e-01f, 6.66180074e-01f, 2.27556109e-01f, -2.63465524e-01f, 5.59740424e-01f, -3.37760011e-03f, -3.61651748e-01f, 4.47807789e-01f, -5.10451913e-01f,
  -1.61992371e-01f, -2.42466047e-01f, 5.35496712e-01f, 8.03806186e-01f, 3.54858458e-01f, 8.98321927e-01f, 1.01973951e+00f, 3.74603063e-01f, 3.43049377e-01f, 1.49569184e-01f,
  -3.07521373e-01f, 4.02017921e-01f, 7.21145153e-01f, 4.39541310e-01f, -2.33713150e-01f, 9.00000095e-01f, 3.27748775e-01f, 3.92720282e-01f, 1.05626130e+00f, 1.09189905e-01f,
  -1.91632867e-01f, -1.16207823e-02f, 3.92030776e-01f, 5.12374900e-02f, 2.76589155e-01f, 9.85490024e-01f, 2.83235550e-01f, 1.35598868e-01f, 2.85615891e-01f, 1.17533207e-01f,
  -9.83251870e-01f, 1.07595432e+00f, -6.77706376e-02f, 6.07468188e-01f, -5.82507610e-01f, -5.52029908e-02f, 4.04981673e-01f, -3.05135846e-01f, -3.80127460e-01f, 5.22659719e-01f,
  -3.99578921e-02f, 3.73427629e-01f, 8.88916850e-01f, 5.64412057e-01f, 4.01081026e-01f, -4.41287607e-01f, 4.43103492e-01f, -9.09564018e-01f, -4.10557054e-02f, 9.78407264e-01f,
  -4.19888526e-01f, 8.30424786e-01f, 2.99618959e-01f, 4.13594484e-01f, -1.06142774e-01f, 3.53817731e-01f, 6.72913015e-01f, -2.03479454e-01f, -4.44244176e-01f, 2.46448413e-01f,
  5.27155340e-01f, 1.14862032e-01f, -5.73610961e-01f, 1.02560437e+00f, -2.21276373e-01f, -1.20197311e-01f, 1.01416671e+00f, 3.70523870e-01f, 5.39652228e-01f, 2.88922954e-02f,
  -5.02977252e-01f, 1.29618859e-02f, 3.19707781e-01f, 7.29284108e-01f, -5.01755476e-02f, 4.45721418e-01f, 3.01405251e-01f, 3.28118391e-02f, -6.88169748e-02f, -7.01612830e-01f,
  7.98560455e-02f, 3.69664468e-03f, 5.17295599e-01f, 4.90465373e-01f, 2.62949586e-01f, 5.64637363e-01f, -4.24289316e-01f, -1.13132186e-01f, 8.66051972e-01f, -5.36542654e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  9.93007421e-02f, 5.56552112e-01f, 1.56920612e-01f, 5.97966313e-01f, 1.57123283e-01f, 5.42124569e-01f, 5.87455273e-01f, 5.26465952e-01f, 5.66753030e-01f, 5.80789924e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  9.20310766e-02f, 5.00933409e-01f, 2.87081242e-01f, -5.48324168e-01f, -2.80909985e-02f, 7.90622905e-02f, 2.68682241e-01f, 1.10573769e-01f, -3.82623464e-01f, -8.77423733e-02f,
  -8.63987133e-02f, 1.35216460e-01f, -1.26606300e-01f, -6.67945109e-03f, 2.01328188e-01f, 1.60033014e-02f, 3.38906646e-02f, 2.86794780e-03f, -1.44022375e-01f, 1.34927675e-01f,
  -2.39632621e-01f, 2.62429148e-01f, 6.61155283e-02f, -7.57321045e-02f, -1.35309994e-01f, -2.74218559e-01f, 1.69914037e-01f, -2.33054608e-01f, 4.94691916e-02f, -6.85978159e-02f,
  1.93284303e-01f, 5.00569083e-02f, -9.85468552e-02f, 2.92284697e-01f, 3.05533111e-01f, -7.34731406e-02f, -7.53452480e-02f, 5.22346973e-01f, 1.50415927e-01f, -4.29342240e-01f,
  2.64426947e-01f, 1.14413597e-01f, -7.37156942e-02f, 8.04055184e-02f, -7.24864155e-02f, -1.48721501e-01f, 5.88498451e-02f, 2.46897608e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -6.80443883e-01f, -4.41518575e-01f, -7.62962639e-01f, 2.46218413e-01f, -4.09116060e-01f, -4.84320819e-01f, 5.73871613e-01f, 8.66777956e-01f, 1.14221334e-01f, 4.65238571e-01f,
  -5.45301251e-02f, 1.57867670e-01f, 8.57484579e-01f, 2.50650138e-01f, -2.43518457e-01f, -8.99358690e-01f, -8.36619437e-01f, -1.03496873e+00f, -6.37052000e-01f, 5.01149416e-01f,
  -7.43115395e-02f, -5.49845219e-01f, 2.58481055e-01f, 5.75489104e-01f, 3.29869568e-01f, 4.66661602e-01f, 3.56433332e-01f, 7.72302628e-01f, -3.83764990e-02f, 2.42343485e-01f,
  3.42951983e-01f, -1.10931136e-01f, -7.21565709e-02f, -1.41441107e-01f, -1.62810579e-01f, 1.99454710e-01f, -1.43270358e-01f, 5.75931430e-01f, -8.43120217e-02f, -3.64753366e-01f,
  -5.87224245e-01f, -5.79323292e-01f, 9.64800298e-01f, -5.59371412e-01f, 1.52220100e-01f, 4.98545557e-01f, 6.17323279e-01f, 4.35517162e-01f, 2.21079841e-01f, 1.40234575e-01f,
  1.46172762e-01f, 5.41922033e-01f, 7.93447435e-01f, -6.87961400e-01f, -7.31587827e-01f, 2.60770023e-01f, -4.40863073e-02f, 2.86899537e-01f, 2.52830476e-01f, 1.21548586e-01f,
  -4.28833008e-01f, 9.67247665e-01f, -1.49555698e-01f, 7.78499901e-01f, 3.83794069e-01f, 6.20689809e-01f, 2.55962640e-01f, -1.58614606e-01f, -6.55594841e-02f, -1.52345151e-01f,
  1.12432873e+00f, -4.15878922e-01f, 8.23981166e-01f, 4.09575820e-01f, 4.98490453e-01f, -6.03175044e-01f, -8.97190198e-02f, 8.15711856e-01f, -7.53286064e-01f, 6.52256370e-01f,
  4.87527609e-01f, 4.10986215e-01f, -1.45806700e-01f, -3.36247444e-01f, -7.50670582e-02f, 3.42394829e-01f, -5.43315589e-01f, 5.68941176e-01f, 4.94397402e-01f, 4.10064995e-01f,
  -1.00638866e+00f, 7.55550504e-01f, 1.28945100e+00f, -1.41796172e-01f, 1.13645673e+00f, -1.53551459e-01f, 9.38785732e-01f, 7.78044105e-01f, 1.02037859e+00f, -5.55151105e-01f,
  4.80592221e-01f, -3.95709395e-01f, -1.10373288e-01f, 1.11649953e-01f, 3.41548175e-01f, 6.27079546e-01f, -6.35766149e-01f, 1.01661079e-01f, 6.43493712e-01f, -2.76402067e-02f,
  5.42614162e-01f, 5.38269579e-01f, 1.07221894e-01f, -9.37970161e-01f, -4.58225608e-01f, 6.07599735e-01f, 1.23322435e-01f, -3.64189744e-01f, -7.46899247e-01f, -2.48530954e-01f,
  1.66560903e-01f, 1.80188850e-01f, 4.54227298e-01f, 6.02777638e-02f, 5.08449674e-01f, 6.52395010e-01f, 4.38963801e-01f, 5.34374237e-01f, -7.74924397e-01f, -2.86487371e-01f,
  3.54384243e-01f, -2.43270487e-01f, -2.40232438e-01f, 3.14027727e-01f, 7.88566113e-01f, 1.65799707e-01f, 1.16191268e-01f, -8.21198449e-02f, 1.18233955e+00f, 7.36488104e-01f,
  -5.42595804e-01f, -3.29056978e-01f, 8.46891761e-01f, 7.60263085e-01f, 7.41907179e-01f, 4.45179790e-01f, 4.91007894e-01f, 2.16336206e-01f, 4.24520314e-01f, -7.82077372e-01f,
  -2.75563776e-01f, -4.53016192e-01f, 8.53259683e-01f, 6.01097107e-01f, -4.08865213e-01f, -3.20683926e-01f, 4.72352594e-01f, 7.86170542e-01f, -3.41793716e-01f, 3.19941401e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  6.96222931e-02f, -1.20341867e-01f, 1.10866614e-01f, 4.38996702e-01f, 3.19234967e-01f, 1.13836631e-01f, 3.17792028e-01f, -4.32532012e-01f, 2.19765548e-02f, 7.44040683e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.53744280e-01f, -4.10675645e-01f, -4.87350971e-01f, -3.89995188e-01f, 7.07835674e-01f, 1.83471680e-01f, -4.33536351e-01f, 1.76232830e-02f, -7.56884158e-01f, 7.16644287e-01f,
  1.13437787e-01f, -3.71741891e-01f, -7.94813037e-02f, 2.88782865e-01f, -5.81883132e-01f, 3.16311985e-01f, 2.01336280e-01f, 1.89470887e-01f, 2.01255932e-01f, -8.13751757e-01f,
  5.77089861e-02f, 1.78083494e-01f, 1.92792248e-02f, -3.25443983e-01f, 2.13825390e-01f, -2.95844018e-01f, -1.84757069e-01f, 3.92490566e-01f, 5.21411836e-01f, 1.09067820e-01f,
  -1.03295076e+00f, 6.01407647e-01f, -5.74336983e-02f, -1.52963430e-01f, -2.38163218e-01f, -6.56948328e-01f, -4.08447906e-02f, 3.98081332e-01f, 3.45094889e-01f, 2.89989740e-01f,
  -4.35912728e-01f, -7.58462071e-01f, 4.76427972e-01f, -3.59660447e-01f, -3.17804456e-01f, -2.39541233e-02f, -1.82588220e-01f, 2.23287821e-01f, -2.84244996e-02f, 2.19551489e-01f,
  4.75561572e-03f, -4.62169982e-02f, 5.55310786e-01f, 4.47808713e-01f, -3.51914942e-01f, -1.06561995e+00f, 7.07905471e-01f, 1.42819762e-01f, 7.12997913e-01f, -4.18209970e-01f,
  -8.01566005e-01f, -1.03917688e-01f, 1.28148735e-01f, -3.75131756e-01f, 4.52574432e-01f, -2.26728156e-01f, -3.74448746e-01f, -2.93215781e-01f, -4.70013559e-01f, -3.41199994e-01f,
  -7.40553200e-01f, -2.05657426e-02f, -3.90319794e-01f, -1.24177769e-01f, 2.08277881e-01f, -7.50408947e-01f, 1.14024334e-01f, 2.96531886e-01f, 5.08280635e-01f, 7.61845894e-03f,
  3.35302651e-01f, -7.97587037e-01f, -3.42376113e-01f, -2.32035503e-01f, -6.36672229e-02f, -1.03729689e+00f, 2.78317839e-01f, 4.76803094e-01f, -2.67516255e-01f, 1.07805945e-01f,
  -9.37120914e-01f, 2.59701520e-01f, -1.86881870e-01f, 4.04287577e-01f, -5.03080308e-01f, -2.72643536e-01f, -1.16908755e-02f, -3.79058331e-01f, 3.32425445e-01f, 3.43018860e-01f,
  1.94031522e-01f, 2.84379035e-01f, 4.21320260e-01f, 5.65877855e-01f, -2.94727646e-03f, -1.09959066e+00f, -2.79160023e-01f, 3.75523776e-01f, -1.89725965e-01f, -9.28022444e-01f,
  -6.98839873e-02f, -8.52281332e-01f, 1.03865176e-01f, 2.42019482e-02f, 1.51874587e-01f, -1.44173145e-01f, 5.39853632e-01f, -1.67907834e-01f, -5.15083149e-02f, -1.22179106e-01f,
  7.47953892e-01f, 1.19937986e-01f, -8.84794056e-01f, -2.79865891e-01f, -4.84751374e-01f, 4.91466284e-01f, 3.08572233e-01f, -5.64906836e-01f, 1.74740806e-01f, 6.75922930e-01f,
  3.82563531e-01f, 7.34420002e-01f, -8.62461049e-03f, 6.25523686e-01f, -4.43047374e-01f, -9.99317586e-01f, -2.94252247e-01f, -9.22728956e-01f, -9.31099176e-01f, 1.03539336e+00f,
  7.18164921e-01f, -4.89479423e-01f, -9.07128975e-02f, -4.79827315e-01f, -2.71708995e-01f, -5.12448192e-01f, -3.70131642e-01f, 5.32373786e-04f, -1.72843561e-01f, 2.42196381e-01f,
  -8.65212202e-01f, 3.44034284e-02f, -8.93331289e-01f, -1.12702353e-02f, -5.61745763e-01f, 2.88666904e-01f, 3.40730488e-01f, -1.21499106e-01f, 4.15939271e-01f, -3.24647814e-01f,
  2.75038540e-01f, 4.92618740e-01f, 5.24817646e-01f, 6.23619795e-01f, -6.52966082e-01f, -2.30467111e-01f, -5.47368050e-01f, -9.80625927e-01f, -4.87020195e-01f, 7.98241436e-01f,
  4.91291851e-01f, -9.57559943e-01f, 6.79826736e-01f, -7.11454332e-01f, -7.97326386e-01f, 6.14185095e-01f, -1.65288031e-01f, 4.12917405e-01f, 5.62331118e-02f, 6.48784459e-01f,
  -3.11752528e-01f, -7.19732702e-01f, 4.87877369e-01f, 4.31637555e-01f, -4.27177727e-01f, -3.40341538e-01f, -3.24791223e-02f, -9.51865494e-01f, -6.93620026e-01f, -7.42550910e-01f,
  5.76485515e-01f, -4.24484432e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.94115448e-01f, -2.64090598e-01f, 1.91526972e-02f, 2.73862511e-01f, -1.91270381e-01f, 4.38947827e-02f, -4.30119038e-02f, 8.68144631e-03f, 5.23567915e-01f, -3.62375587e-01f,
  2.76737273e-01f, 3.78397226e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    