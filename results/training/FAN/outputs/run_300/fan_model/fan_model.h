/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.29468784e-01f, 1.83835968e-01f, 1.82666466e-01f, 1.05027564e-01f, -1.92337915e-01f, -1.63104117e-01f, -7.17398748e-02f, 3.63350064e-02f, 3.52299303e-01f, -5.64220585e-02f,
  -2.52517074e-01f, 1.09924659e-01f, -2.27456503e-02f, -5.84852062e-02f, -7.42583126e-02f, 5.21097705e-03f, -9.96138677e-02f, -7.61684775e-02f, 1.43283129e-01f, 3.22719216e-02f,
  2.81508956e-02f, -1.60761029e-01f, -7.88298547e-02f, -3.71191427e-02f, -1.46801695e-01f, 1.84822038e-01f, -1.23306051e-01f, -1.60307239e-03f, -1.00437067e-01f, -1.18528612e-01f,
  -9.99471992e-02f, 6.32087067e-02f, -1.40987895e-03f, 2.32286770e-02f, -7.82143995e-02f, -8.73596147e-02f, -5.62017336e-02f, -3.64206508e-02f, 2.76089143e-02f, 2.81124990e-02f,
  1.05669722e-02f, 1.75581668e-02f, 5.51733524e-02f, -4.34743017e-02f, 1.30532053e-03f, 4.73867841e-02f, 2.53759604e-02f, -2.46818215e-02f, 6.95516244e-02f, -5.66351265e-02f,
  -5.25391735e-02f, -2.27713473e-02f, 2.62637530e-02f, 4.33857329e-02f, 5.13342991e-02f, 1.04918713e-02f, -3.12737393e-04f, -3.93280871e-02f, 8.74684844e-03f, 1.08592965e-01f,
  2.41606706e-03f, -5.78899588e-03f, -2.56800465e-02f, -1.49656106e-02f, -5.77673987e-02f, 2.25721151e-02f, -9.92965885e-03f, -3.13788798e-04f, 2.47297492e-02f, -4.89847474e-02f,
  3.04821897e-02f, 2.73362603e-02f, 4.62530106e-02f, 4.33389992e-02f, -7.96939284e-02f, 4.82865609e-03f, -2.84038391e-02f, 3.36799435e-02f, -7.21744075e-03f, 2.36840677e-02f,
  6.58807252e-03f, 1.06115835e-02f, -2.62208506e-02f, -7.92763829e-02f, -2.60554217e-02f, 2.02906076e-02f, -1.76734123e-02f, 3.25552002e-02f, -4.27451469e-02f, -2.12334692e-02f,
  2.20165532e-02f, 1.48323581e-01f, 7.93680176e-02f, 1.78897195e-02f, -9.03796125e-03f, -4.56303265e-03f, -4.74479888e-03f, -1.26528658e-03f, 4.02851664e-02f, 2.04660967e-02f,
  -9.36780870e-02f, 3.18448618e-02f, -6.48780018e-02f, 2.67615225e-02f, 7.51227885e-02f, 2.33201422e-02f, -3.09273656e-02f, 9.45735443e-03f, -1.10522266e-02f, -1.74161252e-02f,
  5.57657238e-03f, -4.83953431e-02f, 1.46089084e-02f, -2.35939901e-02f, -2.72675641e-02f, -1.21094957e-02f, 2.11884622e-02f, 7.02085793e-02f, -1.10282958e-01f, -2.01110430e-02f,
  1.86079040e-01f, -2.84454703e-01f, 4.70917411e-02f, 4.86757569e-02f, 1.39165312e-01f, 1.03243373e-01f, -1.23565577e-01f, 4.63468172e-02f, -7.56538240e-03f, -2.41907239e-01f,
  2.44931020e-02f, -1.03919003e-02f, -2.17258811e-01f, -1.04495846e-01f, 2.37533495e-01f, -2.26605788e-01f, 1.16500733e-02f, -4.47362028e-02f, -3.20982933e-02f, 7.93194920e-02f,
  3.24407383e-03f, -7.39176869e-02f, 8.54808465e-03f, 5.27750887e-02f, 8.22100937e-02f, 6.43977225e-02f, 2.54299510e-02f, 1.25924768e-02f, 4.57699858e-02f, 3.33439894e-02f,
  1.82117876e-02f, -7.10993707e-02f, 4.88340221e-02f, 4.92572300e-02f, 8.04669708e-02f, 2.89581940e-02f, 5.17890118e-02f, 4.51260507e-02f, 9.22923610e-02f, 2.70525296e-03f,
  -4.39030817e-03f, 1.90474037e-02f, -4.82830638e-03f, 1.12175653e-02f, 4.78585772e-02f, -3.25626992e-02f, 5.92420762e-03f, -5.10891527e-03f, -2.35735737e-02f, -1.83059797e-02f,
  -1.71176065e-02f, 3.95369492e-02f, 5.09195123e-03f, -2.44268980e-02f, 2.27706581e-02f, 2.33996734e-02f, -6.60734251e-04f, -8.94463062e-03f, -1.72288790e-02f, 1.65566523e-02f,
  -6.05798401e-02f, 3.11449077e-02f, -4.26497646e-02f, 2.35310905e-02f, -3.91572267e-02f, 1.37419645e-02f, -4.01281342e-02f, -6.10649884e-02f, 7.16807768e-02f, -2.75927428e-02f,
  8.29570442e-02f, 3.13131511e-02f, -2.64355242e-02f, 1.48884607e-02f, 1.92952361e-02f, -2.92212870e-02f, 1.81749761e-02f, 3.10182534e-02f, 3.70889553e-03f, 4.28816378e-02f,
  -3.49852745e-03f, 3.32837962e-02f, -3.46490145e-02f, -6.48628697e-02f, -2.69258637e-02f, 4.92056608e-02f, -2.76949480e-02f, -1.44091155e-02f, 3.58000696e-02f, 2.59543844e-02f,
  -8.86358991e-02f, -2.28670418e-01f, -5.95254265e-02f, 1.76900495e-02f, -9.10227597e-02f, 1.38804074e-02f, -1.45774428e-02f, 8.98731966e-03f, -2.12894306e-02f, 2.60669887e-02f,
  1.59755908e-02f, 1.02606406e-02f, -4.67235632e-02f, 3.19596007e-02f, 1.35916779e-02f, 1.55029492e-02f, -4.94175889e-02f, 5.45319617e-02f, 5.65774217e-02f, 2.05979664e-02f,
  9.38416415e-05f, -3.53635103e-02f, 2.04580482e-02f, 3.63027602e-02f, -1.34055289e-02f, -1.84272528e-02f, 2.91247237e-02f, 2.24812943e-02f, -5.09032458e-02f, -2.56569292e-02f,
  -2.48210400e-01f, 2.16859058e-01f, 7.31879519e-03f, -1.40297681e-01f, 3.71140614e-02f, 2.00910121e-01f, 1.90547332e-02f, 8.86575580e-02f, 2.89260358e-01f, 1.13955647e-01f,
  -1.50397792e-01f, -5.20309024e-02f, 4.58825417e-02f, -8.76715779e-02f, -1.65916339e-01f, 9.61695686e-02f, 3.68113108e-02f, 7.20245298e-03f, 1.68543711e-01f, -3.69436741e-02f,
  -8.20068121e-02f, -2.30656136e-02f, -1.41840816e-01f, -4.01704386e-02f, -3.93175520e-02f, -1.22223310e-02f, -2.44753748e-01f, -4.84508872e-02f, -3.08938827e-02f, 6.31469786e-02f,
  5.13857603e-02f, 1.29991248e-01f, -1.37016430e-01f, -4.09781523e-02f, 4.73321155e-02f, -4.69546877e-02f, -3.55282687e-02f, -6.58971146e-02f, 3.50575186e-02f, 1.29448418e-02f,
  1.19531332e-02f, -9.97959543e-03f, 3.40141766e-02f, -2.50577871e-02f, 6.37655333e-02f, 7.39254011e-03f, 4.19912906e-03f, 4.94414289e-03f, -3.15598138e-02f, -4.82720956e-02f,
  -6.79036081e-02f, 5.36513180e-02f, -2.60177925e-02f, 2.90524978e-02f, -5.89888357e-02f, 4.13179863e-03f, 8.42559803e-03f, 2.67950222e-02f, 2.85737272e-02f, 1.28133278e-02f,
  -1.09153269e-02f, 5.14683984e-02f, -2.65207551e-02f, -2.23878794e-03f, -1.16381431e-02f, 3.36222947e-02f, -3.53694856e-02f, 8.15446861e-03f, -7.77236512e-03f, -6.88369200e-02f,
  -5.33657409e-02f, -9.46934242e-03f, 1.70660149e-02f, -1.61513072e-02f, 3.24652754e-02f, 4.00263853e-02f, 5.64696500e-03f, 3.88311595e-02f, 8.92892387e-03f, -4.80373576e-02f,
  6.28109574e-02f, 3.53513286e-02f, -2.89378539e-02f, 1.44441391e-03f, 3.55337262e-02f, -5.22675291e-02f, 1.86761003e-02f, 4.49529178e-02f, -6.15524836e-02f, -4.88914512e-02f,
  2.69135106e-02f, 1.84441924e-01f, 3.24791335e-02f, -1.63547620e-02f, 2.62451954e-02f, -3.64512205e-02f, 4.57885005e-02f, 8.32335725e-02f, -2.55404098e-04f, 2.03434080e-02f,
  -2.91598774e-02f, -1.17635010e-02f, 3.03320419e-02f, -5.81452511e-02f, -3.65429223e-02f, 2.38224538e-03f, -5.81713915e-02f, 3.72012183e-02f, -2.94601824e-03f, 2.09042467e-02f,
  -4.99472953e-02f, 2.81438418e-03f, -1.01135857e-02f, -4.46665399e-02f, 2.81562433e-02f, -2.20720414e-02f, 4.38640714e-02f, -5.23866490e-02f, 7.21367523e-02f, 5.19324653e-02f,
  -3.17035317e-01f, -1.50003672e-01f, 4.31504361e-02f, -1.49735123e-01f, -5.57290725e-02f, -5.65189831e-02f, 1.32517278e-01f, -2.07231775e-01f, 4.18598298e-03f, 5.05227188e-04f,
  -1.04131340e-03f, -1.69627234e-01f, 1.44444689e-01f, -5.74408658e-02f, -8.18592757e-02f, 1.90620199e-01f, -1.12924464e-01f, -4.18275855e-02f, -7.72360805e-03f, -1.36509463e-01f,
  -5.35309874e-02f, -6.06284803e-03f, 4.10944335e-02f, 8.35656375e-03f, -9.83481333e-02f, -3.96784917e-02f, 1.20009044e-02f, 5.65578416e-02f, -1.67014003e-01f, -1.85210779e-02f,
  -7.53484741e-02f, -5.66119142e-03f, 1.41130304e-02f, 3.58056575e-02f, -1.61745641e-02f, 3.04765366e-02f, -6.09639436e-02f, 9.80274305e-02f, 7.91875720e-02f, 5.89694688e-03f,
  3.10105216e-02f, 2.27286015e-02f, 4.70744595e-02f, 9.52301249e-02f, -3.98827903e-02f, 6.65270397e-03f, 4.54135314e-02f, -1.67035442e-02f, -3.30300219e-02f, -3.81816030e-02f,
  -6.03182092e-02f, -1.91471875e-02f, 2.55117286e-02f, -1.92805324e-02f, -1.25424741e-02f, -5.06330989e-02f, -2.44463794e-02f, 3.16260457e-02f, -1.05812840e-01f, -3.59438695e-02f,
  -4.09137569e-02f, 5.42242415e-02f, -2.18256898e-02f, -1.20319147e-02f, -5.72543330e-02f, 1.40840895e-02f, -3.31591256e-02f, 8.83259531e-03f, -3.17246504e-02f, -7.47773647e-02f,
  2.14327704e-02f, -4.97796685e-02f, -2.66356505e-02f, 7.07819010e-04f, -9.86087602e-03f, -3.87818925e-02f, 3.46501246e-02f, -1.10315206e-02f, -1.75299658e-03f, 5.53957708e-02f,
  -6.04586967e-04f, -1.36042880e-02f, -1.19815245e-02f, 5.13593704e-02f, -5.78219779e-02f, 1.38938539e-02f, 3.42774205e-02f, 2.52386592e-02f, 5.46168387e-02f, -1.09214671e-02f,
  -3.09314489e-01f, -2.75201827e-01f, -4.91248555e-02f, -3.12165637e-02f, -4.62622531e-02f, -3.05900071e-02f, 3.66598181e-02f, 2.69559957e-02f, -8.92963931e-02f, 1.11360624e-02f,
  2.09791446e-03f, 1.33288242e-02f, -1.16471231e-01f, 3.28368135e-02f, 3.64848003e-02f, -3.94497216e-02f, -5.45015819e-02f, 6.21696375e-03f, -1.44373626e-02f, -3.47844288e-02f,
  -1.88913401e-02f, -3.22158150e-02f, 1.14811659e-02f, -8.16936418e-02f, 5.08692078e-02f, 3.00505739e-02f, -3.35826054e-02f, -4.22255864e-04f, 2.36133416e-03f, 1.64763797e-02f,
  2.65794456e-01f, 1.45001188e-01f, 1.84315145e-02f, 1.25990048e-01f, 1.29680142e-01f, -5.67279942e-02f, -2.72098452e-01f, 2.61869550e-01f, -2.78815646e-02f, -3.34762596e-03f,
  -8.39306861e-02f, -2.92780045e-02f, -2.54626811e-01f, -4.19300497e-02f, -3.23333710e-01f, -2.47818738e-01f, -3.71342041e-02f, 4.60548839e-03f, 4.87357527e-02f, 1.65871963e-01f,
  6.40099794e-02f, 4.95978491e-03f, -1.14091538e-01f, 1.97134390e-01f, 1.74118266e-01f, 1.91311598e-01f, -4.13553044e-02f, -5.47352768e-02f, 1.17543265e-01f, -6.62516281e-02f,
  6.13747574e-02f, 1.93640366e-01f, -2.18036911e-03f, -3.84169333e-02f, -3.10859345e-02f, -1.49891274e-02f, -4.52076010e-02f, -1.28897011e-01f, -1.84241645e-02f, -3.00025493e-02f,
  -2.90783085e-02f, 5.87374642e-02f, 2.76566157e-03f, -2.98056211e-02f, 7.58466274e-02f, -8.80445633e-03f, -3.89961489e-02f, 7.45176617e-03f, 2.17565503e-02f, 9.77469794e-03f,
  -2.88928244e-02f, 1.09027466e-02f, -2.09409511e-03f, 6.73512137e-03f, -3.17151174e-02f, 1.22449761e-02f, -4.51795608e-02f, -1.51745770e-02f, 1.47009874e-02f, 1.42719205e-02f,
  -6.95701689e-02f, 8.88993740e-02f, -9.82897822e-03f, 3.35806236e-02f, -2.23453026e-02f, 6.74262419e-02f, -2.30365600e-02f, -4.96747717e-02f, -3.40748541e-02f, -8.30166042e-03f,
  5.90026043e-02f, 3.36798206e-02f, 1.80067297e-03f, 2.37694029e-02f, 3.60174221e-03f, 7.57996067e-02f, -2.09176484e-02f, 1.08818533e-02f, 1.90303270e-02f, 5.89851514e-02f,
  -2.22918652e-02f, -9.25982464e-03f, -3.03968117e-02f, -6.69764355e-02f, -1.59794297e-02f, -4.79520373e-02f, 7.35107958e-02f, 4.39931117e-02f, 1.69753060e-02f, -5.11595793e-02f,
  1.39756724e-01f, 1.99267715e-02f, -5.56917042e-02f, 5.01066111e-02f, -4.04662229e-02f, 5.14139868e-02f, -3.40379812e-02f, 1.32568078e-02f, 3.14207398e-03f, 1.36163747e-02f,
  3.52321169e-03f, 1.01119550e-02f, 4.82869707e-02f, 1.51336771e-02f, -8.03994536e-02f, -3.02039422e-02f, 8.65348056e-03f, -1.38906464e-02f, -2.68031508e-02f, 4.68113869e-02f,
  8.62364843e-02f, 8.69164243e-02f, -6.09104522e-02f, 1.10825442e-01f, 2.60216296e-02f, 2.08226815e-02f, 7.06180185e-02f, -6.90565305e-03f, -4.51887138e-02f, -5.74711375e-02f,
  -2.23698989e-01f, 1.69768810e-01f, 9.73892733e-02f, 6.29527792e-02f, -6.08796589e-02f, -2.21334457e-01f, -2.24810511e-01f, 9.17830691e-02f, 4.77807112e-02f, 7.99518973e-02f,
  -6.17561005e-02f, -7.12665990e-02f, 2.17609876e-03f, 5.69626391e-02f, -3.47233176e-01f, -2.59741470e-02f, -7.62843937e-02f, 1.55808507e-02f, 3.86853516e-02f, -3.06943487e-02f,
  1.96788125e-02f, -3.84966284e-02f, 4.47474644e-02f, 2.29047552e-01f, 3.50431539e-02f, 7.38729313e-02f, -6.17077947e-02f, -5.03589958e-03f, 4.90174256e-02f, 1.51422406e-02f,
  2.04474516e-02f, 9.09515098e-02f, 7.67290266e-03f, 1.20999098e-01f, -7.84998015e-02f, 5.58689702e-03f, -1.50644286e-02f, -7.23666400e-02f, 7.26879463e-02f, 6.15773313e-02f,
  -3.09142116e-02f, -4.84360522e-03f, 7.43838847e-02f, 4.07010987e-02f, -1.45329414e-02f, 1.03169210e-01f, -1.16644176e-02f, 3.87272350e-02f, 6.03103973e-02f, -4.11416255e-02f,
  3.12904790e-02f, 1.47007853e-02f, -2.17643157e-02f, 6.32868782e-02f, 4.87197526e-02f, -5.36038652e-02f, -8.25045705e-02f, -3.13297147e-03f, -2.57485379e-02f, -6.55198172e-02f,
  1.36718042e-02f, 7.15691084e-03f, -3.75170633e-02f, 2.73750294e-02f, -1.85605511e-02f, 1.16644530e-02f, 7.96381105e-03f, -1.97778475e-02f, -2.20258497e-02f, 1.45899132e-02f,
  -5.33578172e-02f, 2.18943991e-02f, 3.49644832e-02f, -4.67115529e-02f, -3.71381715e-02f, 6.35148436e-02f, -2.28261538e-02f, -3.27796638e-02f, -1.35237630e-02f, 2.67142560e-02f,
  5.90198599e-02f, -3.61440592e-02f, -1.71479061e-02f, 1.81937665e-02f, 3.53050674e-03f, -4.94099595e-02f, 3.30059975e-02f, -1.03710755e-03f, 1.97677724e-02f, -2.13830471e-02f,
  2.25151610e-02f, 5.10803750e-03f, 6.72717392e-02f, 1.89110301e-02f, 2.69995444e-02f, -6.59786016e-02f, 2.88005192e-02f, 8.05103406e-02f, -3.79135879e-03f, 6.16229745e-03f,
  -2.49897949e-02f, -4.42888327e-02f, -2.47187335e-02f, 1.67379156e-02f, 2.83426698e-03f, -7.33327866e-02f, -5.32715023e-02f, -4.84500527e-02f, -3.83450799e-02f, -1.34700257e-02f,
  -2.76228692e-02f, -8.63766223e-02f, -1.54365906e-02f, -6.55078217e-02f, -6.97162673e-02f, 1.75924581e-02f, 1.33593027e-02f, -3.82864699e-02f, -6.20746911e-02f, 2.21839529e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.04171261e-01f, -7.44026676e-02f, -1.20906048e-01f, 4.63483743e-02f, -7.19603105e-03f, 1.62088387e-02f, -4.78655249e-02f, -4.46612537e-02f, -9.15214345e-02f, 5.13355434e-02f,
  1.48969978e-01f, 1.70882400e-02f, -3.63963819e-03f, -1.24838032e-01f, -8.30920041e-02f, -1.17079012e-01f, 3.97984050e-02f, 6.46417141e-02f, -6.79701269e-02f, 1.68842062e-01f,
  1.11114629e-01f, -4.07375395e-02f, 4.14788872e-02f, 5.01687080e-02f, 7.81641006e-02f, 9.97307003e-02f, 2.70483166e-01f, 4.24557850e-02f, 3.98097150e-02f, 5.65912277e-02f,
  -1.18509792e-01f, -2.84479987e-02f, -1.09293565e-01f, -3.70842405e-03f, 4.72572893e-02f, 8.53228495e-02f, 7.01691881e-02f, -1.82816833e-02f, 4.08882610e-02f, -2.15031635e-02f,
  9.60565135e-02f, 1.59578361e-02f, -1.96222570e-02f, 2.05466282e-02f, -6.51780814e-02f, -9.04663466e-03f, -1.00910880e-01f, 2.16459520e-02f, 6.33401126e-02f, -7.50048682e-02f,
  1.75245255e-02f, -8.57445896e-02f, -5.74859604e-02f, -4.01350744e-02f, -4.12560105e-02f, 6.44737482e-02f, -2.73680873e-02f, 1.02174461e-01f, 1.08885195e-03f, -7.78178573e-02f,
  6.18913658e-02f, -4.41360883e-02f, -4.96805832e-03f, -2.23649689e-03f, -5.27109355e-02f, -2.87850462e-02f, 1.34390537e-02f, 1.65000483e-02f, 6.26521632e-02f, -4.48190570e-02f,
  2.16690730e-02f, 8.00627545e-02f, -6.45487309e-02f, 4.43622656e-02f, 2.64601875e-02f, -7.06940293e-02f, -3.69899012e-02f, -2.39186808e-02f, -5.35309613e-02f, 2.11863015e-02f,
  -1.03837810e-01f, 8.28085616e-02f, 6.99426830e-02f, -5.42327762e-02f, -6.76436946e-02f, 4.69328910e-02f, 9.15128738e-02f, 2.32281722e-02f, -4.60970178e-02f, -2.99425609e-03f,
  1.35694280e-01f, 1.50937513e-01f, 1.68733159e-03f, -6.81596100e-02f, -3.31754163e-02f, -4.50016446e-02f, -4.36365344e-02f, -4.65086475e-02f, 8.12267587e-02f, 2.68147420e-02f,
  -1.52166253e-02f, 4.66438383e-02f, -2.12703422e-02f, -2.46448349e-02f, 5.74902818e-02f, 1.37615427e-02f, 2.36889813e-03f, -4.91585582e-02f, 8.65377188e-02f, -3.13680433e-02f,
  8.07470083e-02f, 2.05954369e-02f, 3.33509706e-02f, -4.86806966e-02f, -3.92394625e-02f, 2.04477459e-02f, 1.15396194e-01f, -4.70033512e-02f, -6.58015013e-02f, -4.22374569e-02f,
  3.03954214e-01f, -4.01772372e-02f, -1.81757838e-01f, -6.40610084e-02f, 1.44534141e-01f, 2.32533917e-01f, 1.48259193e-01f, -4.99272766e-03f, -7.00310022e-02f, -3.68162058e-02f,
  1.82829723e-01f, 2.41346918e-02f, -6.15422521e-03f, 1.70289263e-01f, 6.30041957e-02f, 5.57358861e-02f, 1.41020134e-01f, 9.94755700e-02f, -1.13050073e-01f, 1.71937093e-01f,
  6.44037873e-02f, 2.12702677e-01f, -7.80573189e-02f, -9.50590447e-02f, 1.18127778e-01f, -8.62171501e-02f, -1.39006108e-01f, -1.43515095e-01f, -9.51795876e-02f, 3.71872969e-02f,
  7.51473382e-02f, 4.20930535e-02f, 2.40467973e-02f, -7.78567372e-03f, -3.43644470e-02f, 1.02060318e-01f, -9.22909901e-02f, -7.25216269e-02f, 6.82912916e-02f, 4.59569395e-02f,
  5.00044897e-02f, -5.72703891e-02f, 6.39441386e-02f, 2.31298078e-02f, 1.89172160e-02f, -8.08434486e-02f, -3.27131227e-02f, 6.64403895e-03f, -3.23883705e-02f, 2.56828051e-02f,
  -9.42814201e-02f, 4.55303714e-02f, 2.75265779e-02f, -1.29444063e-01f, -7.21399263e-02f, -6.32750243e-02f, -4.69302759e-02f, -2.71287840e-02f, -6.51083738e-02f, 2.79758545e-03f,
  4.28115502e-02f, 5.09030707e-02f, 7.22674578e-02f, -2.96921581e-02f, 1.76399713e-04f, -3.16055603e-02f, 5.70005737e-02f, -2.27936562e-02f, -5.20378388e-02f, -5.60369454e-02f,
  1.14664668e-02f, -7.71806240e-02f, 7.46533507e-03f, 1.25538995e-02f, -3.49981822e-02f, 4.12499867e-02f, 5.85525334e-02f, -1.24152461e-02f, 3.69961001e-02f, 2.45863851e-02f,
  2.92419158e-02f, 7.37875849e-02f, -2.12703962e-02f, -1.64811444e-02f, 3.88510972e-02f, -6.19802065e-02f, -9.08253435e-03f, 1.29504586e-02f, 1.82614140e-02f, -1.69427507e-02f,
  -5.09069674e-02f, 6.29955977e-02f, -2.77274959e-02f, 2.91103739e-02f, -4.93797883e-02f, -1.67438611e-02f, 8.78619775e-03f, 5.72816283e-02f, 4.37039956e-02f, 7.07122758e-02f,
  -2.70435289e-02f, 2.33585052e-02f, 5.11674844e-02f, 3.40923518e-02f, -7.28719011e-02f, 6.88413531e-02f, 2.20641829e-02f, -8.01122338e-02f, -3.25105712e-02f, -3.60718556e-02f,
  3.53936143e-02f, 4.89556566e-02f, -3.90908606e-02f, 3.14528570e-02f, -8.01452473e-02f, 3.94105352e-02f, 2.18854658e-02f, -7.18442723e-02f, -7.43580684e-02f, 1.80999432e-02f,
  4.11239825e-02f, 3.16605493e-02f, -1.90304637e-01f, 1.07245927e-03f, 5.25500514e-02f, 1.49278730e-01f, 2.05601268e-02f, 1.19338982e-01f, -1.17102601e-01f, -8.73508826e-02f,
  1.81276631e-02f, -2.31531691e-02f, -1.74988061e-01f, 1.77257434e-01f, 1.18248336e-01f, -7.73818642e-02f, 1.51121289e-01f, 1.75443608e-02f, -8.28054771e-02f, 1.40246553e-02f,
  1.13128489e-02f, 1.08454704e-01f, 1.12961121e-02f, 1.57645255e-01f, 9.14739519e-02f, -7.14633288e-03f, -2.42011771e-02f, -3.61382514e-02f, 1.14695348e-01f, 2.81518474e-02f,
  2.96220053e-02f, -3.44709493e-02f, -2.41096206e-02f, 5.39429411e-02f, 1.28569575e-02f, 1.60456896e-02f, 6.26431182e-02f, -3.04485746e-02f, -3.83311436e-02f, -1.05404273e-01f,
  -1.01649269e-01f, -4.24954742e-02f, 4.63927537e-03f, 5.45675084e-02f, 5.06716631e-02f, -2.99495105e-02f, -1.94307659e-02f, 6.59015477e-02f, 1.61168240e-02f, 5.05740084e-02f,
  -1.19650282e-01f, -3.78561579e-02f, -1.10901691e-01f, 7.13182166e-02f, 3.59996147e-02f, -5.93799986e-02f, -1.44530544e-02f, -1.17875583e-01f, -3.23260650e-02f, 6.75934628e-02f,
  -5.59250042e-02f, 4.75255810e-02f, -3.58730108e-02f, -4.01309803e-02f, -8.56831297e-03f, -1.82534382e-02f, -5.44579700e-02f, -3.98558453e-02f, 4.95307297e-02f, -9.27496329e-03f,
  2.10281704e-02f, -8.50487724e-02f, -2.71202959e-02f, -6.80048391e-02f, -4.00012136e-02f, -6.93097636e-02f, -5.88901192e-02f, -6.60554320e-02f, -4.80659269e-02f, -1.63307823e-02f,
  -6.60899654e-02f, 3.58352326e-02f, 6.13725185e-02f, 1.81267392e-02f, 2.05948465e-02f, -4.27741557e-02f, 1.07637923e-02f, -1.38858389e-02f, -7.68645629e-02f, 1.79177488e-03f,
  1.92245319e-02f, -4.82177772e-02f, -8.04186836e-02f, 7.57400244e-02f, 2.55547557e-02f, 5.47059160e-03f, -7.36325011e-02f, 6.53747320e-02f, 1.28994612e-02f, -6.17935620e-02f,
  3.83398235e-02f, -5.03552146e-02f, -1.29975136e-02f, 6.94149286e-02f, -1.21365963e-02f, 7.98683614e-02f, -7.13630021e-03f, -8.75565559e-02f, 2.28217747e-02f, -1.71206258e-02f,
  3.01003288e-02f, -7.34808296e-02f, 1.53842978e-02f, -2.69175991e-02f, 7.83477128e-02f, -6.20713755e-02f, 4.99879122e-02f, -2.47958656e-02f, -2.06660442e-02f, 3.83026898e-02f,
  9.75032896e-02f, 1.11886248e-01f, 1.12053007e-01f, -3.95367406e-02f, -1.46604925e-01f, 4.50510792e-02f, -6.67355731e-02f, 7.93053061e-02f, 1.48912385e-01f, 4.03175242e-02f,
  -8.33571181e-02f, 1.85224786e-01f, 8.06152448e-02f, -5.47401011e-02f, 7.52540752e-02f, -4.46107462e-02f, -4.88177948e-02f, 2.17729770e-02f, 6.83359131e-02f, -3.06350441e-04f,
  2.17899401e-02f, -1.91964418e-01f, 2.70563550e-02f, -1.08296864e-01f, -9.93383229e-02f, -2.19210121e-03f, 8.87940696e-04f, -9.95060354e-02f, -7.81732053e-02f, -4.95428704e-02f,
  2.60220692e-02f, -9.77870896e-02f, 1.43038006e-02f, 1.16724022e-01f, 4.13650647e-02f, -5.96032701e-02f, 5.66736097e-03f, 7.03921467e-02f, 2.29059849e-02f, -5.34551926e-02f,
  -3.39190767e-04f, 7.48530254e-02f, 5.41142002e-02f, 4.56116199e-02f, 9.12399590e-02f, -1.96729843e-02f, 2.69435253e-02f, 1.17726289e-02f, 7.89335966e-02f, 8.92214850e-02f,
  1.87079385e-02f, -5.75976297e-02f, -6.52493630e-03f, 1.57199670e-02f, 4.80529591e-02f, -7.56653920e-02f, 5.82694113e-02f, 3.84207852e-02f, 2.17615310e-02f, 2.92593706e-02f,
  7.04489872e-02f, -6.64442107e-02f, -8.85003153e-03f, 6.35448620e-02f, -3.03028580e-02f, -8.00628886e-02f, -7.72261843e-02f, -5.53197600e-02f, -8.54652226e-02f, -1.97933707e-02f,
  -1.87610332e-02f, -2.67029610e-02f, 3.81058529e-02f, -3.72284986e-02f, -2.72305459e-02f, -3.95960063e-02f, -5.67863956e-02f, -9.87979099e-02f, 5.72393127e-02f, -6.91568628e-02f,
  -5.05101793e-02f, -7.89216533e-02f, 8.29908252e-02f, -4.71566105e-03f, -2.41594967e-02f, 7.94027075e-02f, 3.26833837e-02f, -8.61121900e-03f, 4.79606986e-02f, -5.22671267e-02f,
  -1.39007643e-01f, 5.06195147e-03f, -9.09795910e-02f, 1.25494329e-02f, -5.51042221e-02f, -1.67745631e-02f, -5.57027571e-02f, -5.47821298e-02f, -6.58330247e-02f, 2.68143825e-02f,
  -8.36371854e-02f, -1.48588391e-02f, -2.29521259e-03f, -5.12766503e-02f, 2.36050654e-02f, 6.24632314e-02f, -6.04204237e-02f, 2.28688270e-02f, -2.27451138e-02f, -4.95493449e-02f,
  -1.22225927e-02f, 2.00132281e-02f, 1.56654026e-02f, 6.95694685e-02f, -8.76458511e-02f, -6.94278628e-02f, -1.03510236e-02f, -7.58058801e-02f, -2.61399448e-02f, 4.84475866e-02f,
  1.87343583e-01f, 6.24753186e-04f, 1.53216079e-01f, 1.51684299e-01f, -4.32392620e-02f, 1.19511664e-01f, 1.45562768e-01f, 8.72020125e-02f, 1.24152273e-01f, -1.09281845e-01f,
  -9.77216810e-02f, 1.91114008e-01f, -3.50291617e-02f, -3.51414718e-02f, 6.27727583e-02f, 1.86969284e-02f, 6.35254988e-03f, 7.00838631e-04f, 9.09214094e-02f, 6.71208128e-02f,
  5.42391725e-02f, -1.37034833e-01f, 1.36956824e-02f, -5.98815456e-02f, -1.09047648e-02f, 4.42349799e-02f, -2.08324701e-01f, -5.06952964e-02f, -1.57340273e-01f, 2.15705088e-03f,
  4.88956608e-02f, 2.20299009e-02f, -2.94624101e-02f, -1.21650044e-02f, 3.09864487e-02f, 1.13096036e-01f, -6.52825609e-02f, -8.67481679e-02f, -6.83459491e-02f, 3.01788915e-02f,
  2.66919993e-02f, 7.65175819e-02f, 5.84302843e-02f, 6.66070580e-02f, 1.31499432e-02f, 7.82771930e-02f, 7.56742358e-02f, 4.57030050e-02f, 5.52688912e-02f, 1.27878338e-01f,
  1.34010568e-01f, 2.87501402e-02f, -5.45942485e-02f, 1.52395219e-02f, -1.11293336e-02f, 6.75900951e-02f, 4.94864658e-02f, -9.04136971e-02f, -1.59061439e-02f, 1.68359131e-02f,
  3.53566930e-02f, -3.62750851e-02f, -5.81210665e-02f, -1.24954199e-02f, -5.25950082e-02f, -2.41861250e-02f, -6.33726222e-03f, -6.79809228e-02f, 7.71047026e-02f, -4.91495058e-02f,
  -5.53066134e-02f, -3.31256352e-02f, -7.26189390e-02f, -4.66259234e-02f, 6.05164021e-02f, -4.06113714e-02f, 1.43392868e-02f, 6.00695275e-02f, 2.44578887e-02f, 4.97053042e-02f,
  -3.06909438e-02f, 1.78393740e-02f, -6.18634224e-02f, -4.80636545e-02f, 3.83842848e-02f, -2.33811308e-02f, 1.25625849e-01f, 2.15451289e-02f, 6.05462380e-02f, -4.38056849e-02f,
  -3.79883423e-02f, -4.42112684e-02f, -1.02703519e-01f, -6.25440404e-02f, 5.74038960e-02f, 9.49784461e-03f, 3.50270048e-02f, 5.66632636e-02f, 4.11355076e-03f, -3.59548181e-02f,
  4.27401103e-02f, 1.02108136e-01f, 2.50600800e-02f, -2.95133553e-02f, 4.09488343e-02f, -4.99188714e-02f, -5.18816784e-02f, -1.11830473e-01f, -4.64391150e-02f, 1.46482270e-02f,
  3.22209075e-02f, -9.11289081e-02f, -9.46983099e-02f, 4.50510308e-02f, 9.88601074e-02f, 7.13763088e-02f, 1.13874930e-03f, -5.44289127e-02f, 1.87393483e-02f, 5.82351573e-02f,
  -2.37544879e-01f, 5.72133251e-02f, -6.58189207e-02f, 5.29592708e-02f, -1.09982930e-01f, -1.86826676e-01f, 6.94900081e-02f, -1.40489221e-01f, -4.07252088e-02f, 2.76228279e-01f,
  1.55833364e-01f, -6.97141737e-02f, 2.38706604e-01f, 1.49110183e-01f, -1.53574750e-01f, 2.38944918e-01f, 1.05116084e-01f, 3.64081301e-02f, -1.19475245e-01f, -3.37130763e-02f,
  -1.11224346e-01f, 1.67722762e-01f, 6.69892877e-02f, -5.27333049e-03f, -9.50029343e-02f, -7.19631314e-02f, 2.18448527e-02f, 2.39315722e-02f, -1.22352904e-02f, 7.28862477e-04f,
  -1.70901313e-01f, 9.49719828e-03f, 2.55458187e-02f, -6.30014315e-02f, -1.04746170e-01f, -1.03263408e-01f, -5.20255649e-03f, 1.15348091e-02f, 3.86445671e-02f, -2.54655257e-02f,
  -3.61716971e-02f, -7.97758102e-02f, -2.36530304e-02f, -1.90995801e-02f, -7.15371221e-03f, -6.25784099e-02f, -9.25046876e-02f, -9.63029917e-03f, -9.68572591e-03f, -6.50478899e-02f,
  -5.38749024e-02f, -4.25131246e-02f, -3.64892147e-02f, 3.53871076e-03f, -8.24374482e-02f, -5.23343030e-03f, 5.11541851e-02f, -6.91776350e-02f, -6.78148419e-02f, -2.94065499e-03f,
  -3.49144898e-02f, -6.39240891e-02f, 2.15557613e-03f, 3.68127413e-02f, 2.67357100e-02f, 8.23885389e-03f, 7.69989118e-02f, -2.86195520e-02f, 3.91708612e-02f, 7.65043125e-02f,
  -8.13450888e-02f, 4.24286388e-02f, -5.17006218e-02f, -1.46828145e-02f, 6.51888736e-03f, 9.54804048e-02f, -7.30857030e-02f, 6.44664455e-04f, -6.74893185e-02f, -3.04537546e-02f,
  6.44343495e-02f, 6.17080275e-03f, 2.81904880e-02f, -1.30287930e-03f, 1.13007799e-02f, 6.76662475e-02f, -1.88392345e-02f, -7.12373033e-02f, 5.68203703e-02f, -4.37470153e-02f,
  -7.19789118e-02f, -1.28141046e-01f, 1.60083007e-02f, -3.27413008e-02f, 3.77261965e-03f, -3.38428281e-02f, 3.13219987e-02f, -5.26583008e-02f, 4.91533913e-02f, -5.14739193e-03f,
  -9.85483732e-03f, -5.68204597e-02f, -1.69996098e-02f, 3.02866772e-02f, -6.98782951e-02f, 4.99845110e-02f, 7.42503032e-02f, 3.85814346e-02f, -7.68581703e-02f, -7.52048269e-02f,
  3.41597386e-02f, 8.97107422e-02f, 1.84762534e-02f, -4.69078217e-03f, 1.98259391e-02f, -9.56593454e-03f, -2.77558342e-02f, -6.84403405e-02f, -7.90364221e-02f, -3.43110003e-02f,
  -2.09441826e-01f, -1.90439329e-01f, -9.63545442e-02f, 1.86068743e-01f, -5.12938946e-02f, -6.95433281e-03f, 2.86623500e-02f, -4.50359918e-02f, -1.32360458e-01f, 1.26297534e-01f,
  1.17345732e-02f, -8.95953849e-02f, -2.59094626e-01f, 3.38765651e-01f, 1.17029808e-02f, 2.77256723e-02f, 3.18703562e-01f, 7.59715810e-02f, -1.93307027e-02f, -1.45778880e-01f,
  8.56614206e-03f, 3.11312258e-01f, 1.22279018e-01f, 1.44733354e-01f, -1.78906973e-02f, 1.81756932e-02f, 7.09060878e-02f, -7.64229223e-02f, 2.82018751e-01f, 1.66641176e-01f,
  -2.02880688e-02f, -1.30389646e-01f, -1.10936910e-01f, 3.77291441e-03f, -1.23315789e-01f, -1.05792642e-01f, -2.14830860e-02f, -4.29324806e-02f, 3.39459330e-02f, -9.22578350e-02f,
  1.19137270e-02f, 8.05088878e-02f, 1.58349052e-01f, 7.54404441e-02f, 2.69301198e-02f, -4.44378220e-02f, -5.16684614e-02f, 3.89561988e-02f, -5.12750931e-02f, -1.11938067e-01f,
  -8.42508599e-02f, 4.25823033e-02f, -3.91396247e-02f, 1.38564348e-01f, -8.56525078e-03f, 8.21739957e-02f, -2.01164167e-02f, 8.35992210e-03f, -3.74828316e-02f, 6.19134642e-02f,
  -8.16722959e-02f, 4.38323952e-02f, -4.49750461e-02f, 2.94840075e-02f, -7.83141404e-02f, 2.12301929e-02f, 1.88445523e-02f, 7.27185458e-02f, -6.03069142e-02f, -5.83176091e-02f,
  -3.08035128e-02f, 2.68904231e-02f, -2.07891390e-02f, 2.82343924e-02f, 3.03868856e-02f, -1.58872288e-02f, -1.41955661e-02f, -9.81966220e-03f, 6.06357381e-02f, 1.65773612e-02f,
  -7.02372938e-02f, 4.59748320e-02f, -1.33735267e-02f, -4.14569341e-02f, -6.18655346e-02f, -9.55712199e-02f, 1.17124070e-03f, -1.03250921e-01f, -4.52057086e-03f, -1.41549427e-02f,
  -6.70353323e-02f, -3.17016914e-02f, 3.30029204e-02f, -9.64199845e-03f, 3.06843705e-02f, 1.77443586e-02f, 3.48097179e-03f, 5.18793538e-02f, 1.50344090e-03f, -2.02169530e-02f,
  -1.08151473e-01f, 5.92872128e-02f, -2.98664961e-02f, -3.85808796e-02f, 9.14813653e-02f, -9.35922563e-02f, 5.29006869e-02f, -2.74866167e-02f, -2.31740763e-03f, 1.29710622e-02f,
  6.23747706e-02f, -6.22665323e-02f, -2.57003009e-02f, 4.60667163e-03f, 5.11412658e-02f, 4.76348139e-02f, 1.79804694e-02f, -1.09277405e-01f, 3.02790683e-02f, -4.97497469e-02f,
  1.74092930e-02f, 3.67139429e-02f, 8.15277323e-02f, 5.20852543e-02f, -9.54281762e-02f, 5.89264929e-02f, 7.46054994e-03f, -4.52695712e-02f, 6.72753528e-02f, 1.07554812e-02f,
  -3.51634175e-02f, 7.18825636e-03f, 1.16676942e-03f, 9.58800539e-02f, -9.83465761e-02f, 1.14943370e-01f, 7.32260421e-02f, 2.03200802e-02f, -3.28657147e-03f, 2.72072339e-03f,
  7.12731928e-02f, 2.61828862e-02f, -3.19824554e-02f, 6.29727244e-02f, 5.66822989e-03f, -7.62809720e-03f, -4.49617915e-02f, 3.31824981e-02f, -4.50570993e-02f, -1.05249390e-01f,
  -9.65064391e-02f, 2.34512668e-02f, -1.44967055e-02f, -3.56820412e-02f, -1.32842734e-02f, -7.52064660e-02f, 4.39091139e-02f, -1.18970370e-03f, 7.84621835e-02f, -2.56669614e-02f,
  8.62678066e-02f, -3.97954956e-02f, 7.87716359e-02f, -4.39245515e-02f, 2.64247935e-02f, 3.32796499e-02f, -5.12853451e-02f, 8.06652382e-02f, -6.17597513e-02f, 8.19287449e-03f,
  9.42144990e-02f, -6.94980752e-03f, 4.98014651e-02f, 6.14132583e-02f, -2.79678237e-02f, 1.78037249e-02f, 9.23334211e-02f, -1.04553895e-02f, -7.13489130e-02f, -6.16896600e-02f,
  -1.21099586e-02f, -7.96820000e-02f, 1.30250948e-02f, 4.56073396e-02f, -1.95651669e-02f, 8.49499032e-02f, -5.91995288e-03f, 3.14386077e-02f, 7.56172985e-02f, -1.13540655e-02f,
  1.46309636e-03f, -7.08259195e-02f, 6.22775331e-02f, -4.02297564e-02f, 1.33131994e-02f, -3.75064313e-02f, 5.61186001e-02f, 5.98892048e-02f, 2.73720641e-02f, 8.64567682e-02f,
  2.47908942e-02f, 8.97021592e-02f, -2.23976374e-02f, 8.16713721e-02f, 4.43733111e-02f, -5.62215373e-02f, 7.53200129e-02f, 5.85866123e-02f, 8.04973766e-02f, -6.11210503e-02f,
  -6.28210679e-02f, 4.91728596e-02f, 3.16551141e-02f, -9.89038870e-02f, -7.60496929e-02f, -8.46486092e-02f, 5.78634068e-03f, -4.20491472e-02f, 1.63616315e-02f, -8.37510675e-02f,
  5.81123382e-02f, -2.19405405e-02f, -2.85816360e-02f, -1.34453643e-02f, 5.09592369e-02f, 7.67660365e-02f, 4.13033329e-02f, 1.26494430e-02f, 5.95431812e-02f, -6.97520897e-02f,
  -3.09291761e-02f, -4.37911712e-02f, 4.77105565e-02f, 6.25925884e-02f, -1.48435282e-02f, 7.97953680e-02f, -6.02486432e-02f, 2.47597769e-02f, -7.83943012e-02f, -4.71626446e-02f,
  -2.34811023e-01f, 3.89753073e-01f, 3.57220560e-01f, -1.70262158e-01f, 1.24932311e-01f, -8.94881859e-02f, 3.86437364e-02f, 1.51931226e-01f, -9.95749980e-02f, 7.96498805e-02f,
  -9.33326557e-02f, 1.88105807e-01f, 2.12919027e-01f, 6.06908612e-02f, -2.80607522e-01f, -4.68844101e-02f, -1.88250944e-01f, -1.09893806e-01f, 1.23250134e-01f, -1.28674448e-01f,
  -1.24067836e-01f, -2.19130471e-01f, 5.30253071e-03f, 1.14141293e-01f, 5.87959997e-02f, 8.72226208e-02f, -2.75025040e-01f, 2.47899786e-01f, 4.73447219e-02f, 8.35388154e-02f,
  -9.37193260e-02f, -1.04128055e-01f, 3.75135504e-02f, 2.90575586e-02f, -1.23955660e-01f, -2.35737935e-02f, -3.15926485e-02f, 7.79469535e-02f, -8.15102309e-02f, -2.10681502e-02f,
  8.69317576e-02f, 5.59299961e-02f, 6.10021390e-02f, 9.37022120e-02f, 7.09169358e-02f, 1.30020589e-01f, -1.43351397e-02f, 5.69344424e-02f, 3.63733768e-02f, 2.44230982e-02f,
  1.07226752e-01f, 9.44743827e-02f, 5.40134357e-03f, -5.98978885e-02f, -5.10822833e-02f, 5.68433143e-02f, -4.80912924e-02f, 7.22297654e-02f, 4.19903360e-02f, 8.13944563e-02f,
  7.66788200e-02f, -1.22914948e-01f, -6.54171128e-03f, -4.83774347e-03f, 3.36833782e-02f, -3.62442876e-03f, 3.53241861e-02f, 2.74716504e-02f, 2.19231080e-02f, 1.41298641e-02f,
  -1.78081337e-02f, 3.90482247e-02f, -5.28098382e-02f, -7.17064962e-02f, -8.66123140e-02f, -7.49968290e-02f, -9.75065958e-03f, 2.80665793e-02f, -6.16244711e-02f, -2.35243794e-02f,
  -3.27058062e-02f, -6.69396967e-02f, 7.80946016e-02f, -9.92895365e-02f, -1.80308111e-02f, -5.89786805e-02f, -6.99649379e-02f, 3.02887689e-02f, -8.14652070e-02f, -1.16826274e-01f,
  -2.81245381e-01f, -2.56020486e-01f, -5.06753735e-02f, 2.04080269e-02f, -3.22910696e-02f, -5.65786064e-02f, -7.19915405e-02f, -4.36266959e-02f, 1.90887274e-03f, 3.83399203e-02f,
  -1.22986041e-01f, -3.30649875e-02f, -2.94027757e-02f, -1.44133801e-02f, -8.26982036e-02f, -5.00284648e-03f, -6.75504953e-02f, -1.03052199e-01f, -6.03366755e-02f, 3.05919684e-02f,
  3.31816524e-02f, -5.88354580e-02f, 4.54779305e-02f, -7.76368678e-02f, -1.07636131e-01f, -1.58665944e-02f, -4.96546589e-02f, -2.46661119e-02f, -8.33640769e-02f, 8.33528265e-02f,
  -4.86133322e-02f, -2.96355579e-02f, -2.52232760e-01f, -1.88752577e-01f, -3.67141888e-02f, -3.69329244e-01f, -3.46493542e-01f, -4.83179577e-02f, 8.12824592e-02f, 1.30349994e-01f,
  -5.80931157e-02f, 1.58641681e-01f, 4.52474281e-02f, -2.14223236e-01f, -1.68263927e-01f, 1.52584806e-01f, -3.36351961e-01f, -7.82055482e-02f, 3.52236480e-02f, -1.00134581e-01f,
  -3.16651613e-02f, -1.67009503e-01f, -1.22731522e-01f, -5.36559969e-02f, -2.06861988e-01f, -9.62196440e-02f, 9.58595723e-02f, -5.41157536e-02f, -1.83873296e-01f, -2.15751771e-03f,
  -7.89115876e-02f, 1.40001431e-01f, 5.47522046e-02f, 4.23784852e-02f, 5.67207625e-03f, -6.67418912e-02f, -4.36980985e-02f, 7.29616210e-02f, 3.73032270e-03f, 1.00130178e-01f,
  1.42559772e-02f, 7.29667693e-02f, -3.90389003e-02f, 6.28404021e-02f, -2.03662738e-02f, 6.55250549e-02f, 1.61615256e-02f, -9.31717083e-02f, -9.33819730e-03f, 2.39428412e-02f,
  -6.21973388e-02f, -6.04241416e-02f, -9.26383492e-03f, 8.53166915e-03f, -1.37178339e-02f, 1.81948654e-02f, -6.97532147e-02f, -1.87303405e-02f, -7.06022382e-02f, 4.23832089e-02f,
  7.40261748e-02f, 3.94242853e-02f, -4.38320749e-02f, 1.07650757e-02f, -5.72119914e-02f, 3.32511775e-02f, 1.66439041e-02f, -4.25503887e-02f, -4.50636558e-02f, -6.44578338e-02f,
  -6.67927973e-03f, 2.68423967e-02f, 9.48472042e-03f, -8.96008164e-02f, -1.01691954e-01f, 7.04419753e-03f, 3.53164412e-02f, 9.03957263e-02f, -5.67210130e-02f, 1.27202524e-02f,
  3.83753655e-03f, 6.87697250e-03f, -4.14777696e-02f, -2.13509165e-02f, -3.53614916e-03f, 5.46834096e-02f, 3.42011750e-02f, -4.45246771e-02f, -2.54598595e-02f, -1.35858320e-02f,
  -6.13767207e-02f, -2.43664347e-02f, 1.09257661e-01f, 8.96304697e-02f, 7.02196583e-02f, -6.69591427e-02f, -1.09061182e-01f, -3.63277309e-02f, -6.52422532e-02f, 2.30622143e-02f,
  -5.25487810e-02f, 7.78045654e-02f, -7.46170506e-02f, -5.54136075e-02f, -4.76444438e-02f, -6.83107451e-02f, -1.93574671e-02f, -2.14760825e-02f, -5.08590415e-02f, 4.25559506e-02f,
  -8.00866983e-04f, 7.15449601e-02f, -1.12480056e-02f, 5.19749820e-02f, 7.31871426e-02f, 1.04173096e-02f, -2.56761238e-02f, 7.70552009e-02f, -6.86153723e-03f, -5.30480407e-02f,
  -1.24299638e-01f, -5.21281967e-04f, -5.71244210e-02f, 5.76999038e-02f, 9.67401564e-02f, -1.90037981e-01f, -9.24163386e-02f, 1.12437628e-01f, -3.79437804e-02f, 1.52978292e-02f,
  6.34538904e-02f, -1.91593736e-01f, 4.47047316e-02f, -1.29255772e-01f, -5.44042140e-02f, -1.00739576e-01f, -7.93508142e-02f, -1.51851550e-01f, -1.23912439e-01f, 1.06523111e-01f,
  1.74533352e-02f, 9.51296184e-03f, -7.96004757e-03f, 1.40715674e-01f, 5.31480089e-02f, 1.18659452e-01f, 2.19480500e-01f, 5.99778220e-02f, 9.01863798e-02f, -9.68905985e-02f,
  -4.99447286e-02f, -2.90123615e-02f, -8.30647498e-02f, -9.13302824e-02f, -2.04464905e-02f, -2.36180164e-02f, 6.55380860e-02f, -3.31099220e-02f, -3.50300805e-03f, -9.55867022e-02f,
  5.02605364e-03f, 5.20553142e-02f, -4.56068553e-02f, -3.97543944e-02f, 1.93564761e-02f, -5.59113920e-02f, -4.57915477e-02f, 4.66446765e-02f, -3.36681232e-02f, 4.12729243e-03f,
  -5.55057004e-02f, 2.72082649e-02f, 4.78626266e-02f, 3.73016857e-02f, 3.81336547e-02f, -5.45663163e-02f, -4.89173224e-04f, -3.33677046e-03f, 7.86258578e-02f, -4.71536256e-02f,
  6.20486587e-02f, -3.87874246e-02f, -3.10990699e-02f, 4.12384607e-02f, -5.07682078e-02f, 3.13172229e-02f, -2.00981218e-02f, 2.27587167e-02f, -2.20553577e-02f, -5.32646514e-02f,
  -2.37077810e-02f, -1.76958740e-04f, 3.88948359e-02f, -7.03147426e-02f, 5.22078499e-02f, 2.49853954e-02f, 1.93166006e-02f, 7.83172324e-02f, 1.32625084e-03f, -5.81869762e-03f,
  3.78778987e-02f, 5.60806692e-02f, -6.43800721e-02f, -1.01682628e-02f, -1.17383730e-02f, 3.24215204e-03f, -5.11193909e-02f, 4.06263694e-02f, 2.01648884e-02f, 5.89006133e-02f,
  8.89600590e-02f, 2.20305741e-01f, 5.10093495e-02f, 4.17121910e-02f, -1.65737525e-03f, -2.27434654e-02f, -4.34737802e-02f, 3.80347036e-02f, 8.77570137e-02f, 3.64209972e-02f,
  3.84780988e-02f, -5.79071417e-02f, 4.75432649e-02f, 1.99030386e-03f, -1.63756385e-02f, 6.74760565e-02f, 5.75742982e-02f, 5.47156632e-02f, 8.76525417e-02f, 3.42217833e-03f,
  1.23588644e-01f, 3.02787554e-02f, 2.11749803e-02f, 6.73171207e-02f, 7.87156895e-02f, 8.57051183e-03f, -7.82939326e-03f, -3.97116467e-02f, 4.57633324e-02f, -6.31803870e-02f,
  -2.04638124e-01f, 7.07880482e-02f, -2.48558354e-04f, -3.12042031e-02f, 1.23820379e-01f, 2.45829359e-01f, 3.64881903e-02f, 1.00049004e-01f, -9.54765305e-02f, -1.05607519e-02f,
  5.93761317e-02f, -2.81945635e-02f, 4.89195846e-02f, 5.62779196e-02f, 1.25138536e-02f, -5.67472279e-02f, 3.58034521e-02f, 5.46714552e-02f, -1.15583127e-03f, -2.85510905e-02f,
  -7.95606002e-02f, -3.53124924e-02f, -4.36322391e-02f, 3.72158810e-02f, 4.56432551e-02f, -1.00241221e-01f, 6.10261038e-02f, 6.32626787e-02f, 1.57936007e-01f, 1.17131829e-01f,
  -3.46291810e-02f, -5.39589003e-02f, 6.48068264e-02f, 5.87257817e-02f, 8.15732777e-02f, 8.16283599e-02f, 2.96219140e-02f, -2.67452132e-02f, 2.98407953e-02f, 4.54659127e-02f,
  -6.53596222e-02f, 1.20828291e-02f, -5.43088205e-02f, -2.13205479e-02f, 3.71342711e-02f, 5.78566194e-02f, -2.40922198e-02f, 2.28112917e-02f, -7.90541060e-03f, 1.86679717e-02f,
  -2.64897924e-02f, 2.06464007e-02f, 4.84280773e-02f, 6.04100339e-02f, 8.30299184e-02f, 9.03674886e-02f, -5.78595437e-02f, 4.87794243e-02f, 3.83773819e-02f, 8.09773356e-02f,
  6.77983016e-02f, -8.75918791e-02f, -7.15017319e-02f, -8.43495652e-02f, 8.71644691e-02f, 2.58298051e-02f, 1.89418457e-02f, 8.94967616e-02f, -9.33002904e-02f, -4.46971692e-02f,
  5.65154515e-02f, -2.77487449e-02f, -1.06967516e-01f, -2.02602763e-02f, -3.46959382e-02f, -9.09145251e-02f, -1.08677089e-01f, 6.02069721e-02f, -8.65051299e-02f, -8.61177817e-02f,
  -4.95693833e-02f, -5.71212359e-03f, -1.68921407e-02f, -2.91132908e-02f, 1.87279808e-03f, 2.16529872e-02f, 7.14197848e-03f, 2.32027378e-02f, -6.07469715e-02f, -8.07742104e-02f,
  -3.19049805e-02f, -7.21121281e-02f, -9.83362943e-02f, -6.06667288e-02f, -7.78723061e-02f, 6.50032014e-02f, -7.36942887e-02f, 9.68427360e-02f, 2.62054708e-03f, 5.36270589e-02f,
  1.25231653e-01f, 5.48206978e-02f, 7.71829784e-02f, -9.05535445e-02f, 9.12911445e-02f, 3.30214314e-02f, -5.35215661e-02f, -5.03624901e-02f, 2.02160385e-02f, 7.81942308e-02f,
  5.21495901e-02f, 5.65438867e-02f, 1.75600965e-02f, 4.29360978e-02f, 6.86056912e-02f, -1.85579043e-02f, 3.53032947e-02f, 1.49923991e-02f, -3.11806723e-02f, 5.83740100e-02f,
  1.73561618e-01f, -6.44479394e-01f, 8.98783505e-02f, 3.62530053e-01f, 2.49593034e-01f, -4.04030457e-02f, 2.62222677e-01f, -9.94239077e-02f, 1.29670516e-01f, -4.45820481e-01f,
  -6.83624372e-02f, 2.36449670e-03f, -2.27182597e-01f, -3.30005325e-02f, 3.91988456e-01f, -2.01968566e-01f, -4.41033207e-02f, 1.80615000e-02f, 3.17707062e-02f, -4.07151878e-02f,
  1.97512001e-01f, 9.63202491e-02f, 1.33658707e-01f, -1.19960517e-01f, 1.03169903e-01f, 4.30833511e-02f, 8.65179524e-02f, 1.73416864e-02f, -4.27140156e-03f, 7.31425062e-02f,
  -3.57251726e-02f, 2.20433697e-02f, -4.34350930e-02f, -5.74783124e-02f, -3.11670452e-02f, -8.34295228e-02f, -5.71381999e-03f, 1.29108801e-01f, 3.05844843e-02f, 4.97970283e-02f,
  -2.45478153e-02f, 1.72408428e-02f, 5.18464968e-02f, -1.24830632e-02f, 2.45126523e-02f, 7.27661699e-02f, 4.36816737e-02f, -6.71651214e-02f, -1.65971201e-02f, -1.44067900e-02f,
  -6.11525737e-02f, -5.35092056e-02f, 9.63827781e-03f, 9.36823990e-03f, 2.31531858e-02f, -2.85685305e-02f, 4.04328741e-02f, 2.43632612e-03f, 1.27823735e-02f, -1.94481071e-02f,
  5.36608733e-02f, -6.97835982e-02f, 1.26328794e-02f, 4.61506508e-02f, 6.34782389e-02f, 5.19520119e-02f, 2.67087836e-02f, 4.29659486e-02f, -1.60525385e-02f, -5.40971197e-02f,
  -1.68825332e-02f, -5.42857051e-02f, 3.54590677e-02f, -4.84581776e-02f, -2.81756162e-03f, -2.65244413e-02f, 6.88207597e-02f, -6.18193820e-02f, -7.23873302e-02f, -4.14065970e-03f,
  6.02347106e-02f, 4.99806590e-02f, -3.25691402e-02f, 7.57808313e-02f, 4.56431555e-03f, 1.85600333e-02f, -1.95112079e-02f, -5.45044839e-02f, 7.91722722e-03f, -3.79209407e-02f,
  -3.70798081e-01f, -3.13528776e-01f, 8.28718115e-03f, -6.44048750e-02f, -1.14987403e-01f, -1.12830415e-01f, 2.11221986e-02f, -9.21722576e-02f, -8.48149806e-02f, 2.46067774e-02f,
  -1.18184216e-01f, 5.93597889e-02f, -2.39703227e-02f, 2.86668371e-02f, -4.16621752e-02f, -2.32066922e-02f, 2.33458430e-02f, -4.34287451e-02f, -2.91215405e-02f, -7.45001137e-02f,
  -6.47441521e-02f, 3.79533991e-02f, 5.78454882e-02f, 7.40305334e-02f, -5.93905225e-02f, 3.50885391e-02f, -9.54576011e-04f, 3.38895693e-02f, 3.77563760e-03f, -4.27737040e-03f,
  -4.27475795e-02f, -2.77225976e-03f, 5.42093720e-03f, 2.06352010e-01f, -1.39369229e-02f, 2.22717840e-02f, 1.12835407e-01f, 9.60392132e-02f, 2.28548065e-01f, 1.42335311e-01f,
  -4.28859144e-02f, 3.50204110e-02f, 6.33185431e-02f, 3.22938450e-02f, 1.64970666e-01f, 4.98800874e-02f, 1.85390428e-01f, 4.30670939e-02f, 1.33584097e-01f, 9.19140652e-02f,
  -4.63924408e-02f, 4.11699750e-02f, -9.55931619e-02f, 2.19733622e-02f, -1.05667084e-01f, 2.72744112e-02f, 5.44680003e-03f, -7.41295516e-02f, -6.06039166e-02f, -5.19004054e-02f,
  4.69369022e-03f, -1.63510535e-02f, -2.65360088e-03f, 2.60995403e-02f, -1.44454511e-02f, -5.35871536e-02f, 5.35582416e-02f, -1.40171936e-02f, 3.62548046e-02f, 6.38117120e-02f,
  -3.42914015e-02f, -4.38813940e-02f, 4.86561060e-02f, -3.62632833e-02f, -7.97282308e-02f, -6.84012771e-02f, 1.48765147e-02f, -3.03062219e-02f, 6.45974204e-02f, -5.93654178e-02f,
  1.75791010e-02f, 3.58618498e-02f, -5.50091751e-02f, 9.41347796e-03f, -2.74096727e-02f, 1.46082835e-02f, 7.61925755e-03f, -1.46785341e-02f, 5.46299182e-02f, 8.08194056e-02f,
  3.51188071e-02f, 4.51110750e-02f, 3.06957457e-02f, -8.83837342e-02f, -1.61816124e-02f, 2.23147013e-04f, 3.62815373e-02f, -9.78825614e-02f, 8.62245262e-03f, -1.54708643e-02f,
  8.63064528e-02f, 1.94338281e-02f, -1.40372152e-02f, 4.28986214e-02f, 7.11501166e-02f, 2.70858277e-02f, -5.13341315e-02f, -6.59609679e-03f, 1.85633060e-02f, -6.09685257e-02f,
  8.69182870e-03f, -2.50874180e-02f, -2.91366801e-02f, 2.66757258e-03f, 3.17553952e-02f, 6.58464953e-02f, 5.54109886e-02f, 7.67533481e-02f, -3.88967060e-02f, -6.69878125e-02f,
  1.19131960e-01f, 1.42213151e-01f, -5.45735359e-02f, 3.80694233e-02f, -1.67773701e-02f, -2.58855913e-02f, 3.80998477e-02f, 5.44377342e-02f, 6.72103465e-02f, 5.76719269e-02f,
  7.16335773e-02f, -8.35067108e-02f, 8.21577534e-02f, -8.09629560e-02f, 9.80594456e-02f, 1.07276328e-01f, 6.89482968e-03f, -1.22706024e-02f, -1.49853434e-02f, 3.66240554e-02f,
  -1.04072601e-01f, -4.56237532e-02f, 8.85471106e-02f, -4.55143265e-02f, -5.42575307e-02f, -7.83394724e-02f, 1.06126875e-01f, 5.83236665e-03f, 5.20368516e-02f, -3.83765884e-02f,
  8.77384171e-02f, 1.11243993e-01f, 2.67866198e-02f, 2.57994682e-01f, -1.12691388e-01f, -2.72182018e-01f, -2.00599402e-01f, 5.59114553e-02f, -1.20066181e-01f, -9.41466391e-02f,
  1.40322864e-01f, -1.02050111e-01f, -6.68617487e-02f, 1.79805398e-01f, 2.00377539e-01f, 2.23720707e-02f, 1.91493317e-01f, -4.06433791e-02f, 1.59944613e-02f, 1.37615398e-01f,
  1.40221655e-01f, 2.91761011e-01f, 1.36866078e-01f, 1.70409635e-01f, 7.38081187e-02f, 7.99818709e-02f, 2.46727839e-01f, -2.54668184e-02f, 1.12849794e-01f, 1.71512330e-03f,
  -9.31695178e-02f, 1.22461870e-01f, -7.40761533e-02f, -1.12403259e-01f, -2.69134585e-02f, -5.17209359e-02f, 2.46037031e-03f, 3.23225223e-02f, -5.13471924e-02f, 5.20607941e-02f,
  -2.35277768e-02f, 3.47143635e-02f, 1.05284058e-01f, 2.87687927e-02f, -2.55930629e-02f, -2.13823002e-02f, -3.15595195e-02f, -4.95633706e-02f, -8.43411833e-02f, -5.15522622e-02f,
  -2.87116710e-02f, -1.37331700e-02f, 2.64798924e-02f, 4.01353650e-02f, 4.24964502e-02f, 2.20083911e-02f, -7.96776637e-02f, 3.07899192e-02f, 6.29254952e-02f, 6.57215863e-02f,
  4.99399826e-02f, 2.74825022e-02f, -3.43339592e-02f, -4.90726233e-02f, 7.84054399e-02f, -1.03141712e-02f, -2.78231986e-02f, 9.76710990e-02f, -4.16234396e-02f, 5.56192659e-02f,
  -8.18579551e-03f, 1.13331070e-02f, -2.36871783e-02f, -3.40486728e-02f, 4.87106852e-02f, 7.21297553e-03f, -4.38125879e-02f, 8.07432905e-02f, -5.83460294e-02f, -2.58574262e-02f,
  -5.77578023e-02f, 5.91098797e-03f, -5.61436601e-02f, 5.17327376e-02f, 2.08952390e-02f, 1.23132020e-02f, 1.16392493e-01f, 3.26406471e-02f, -4.96318415e-02f, -3.76625992e-02f,
  1.30589172e-01f, 2.36903131e-01f, 3.36444117e-02f, 1.98245998e-02f, -3.15012783e-02f, 3.69589366e-02f, -4.85004373e-02f, 1.02068158e-02f, -7.05894176e-03f, 8.03017616e-02f,
  -4.99520749e-02f, -2.48221643e-02f, -4.60922606e-02f, 3.50605175e-02f, 4.31642123e-02f, 3.08140870e-02f, 1.33281231e-01f, 2.84673763e-03f, 4.96292114e-02f, 7.14086667e-02f,
  9.83094946e-02f, -8.79816711e-02f, 1.83271877e-02f, -7.93395787e-02f, -1.92453805e-02f, 9.89393797e-03f, -1.28283752e-02f, 3.08897514e-02f, 1.15161261e-03f, 2.27677613e-03f,
  -7.61437491e-02f, -1.98697701e-01f, -5.83266877e-02f, 9.43463221e-02f, 9.52022672e-02f, 8.17402452e-02f, -4.08520587e-02f, 2.48218141e-02f, 7.81133100e-02f, -6.89532608e-02f,
  -2.12879907e-02f, -2.80141592e-01f, -5.41214943e-02f, -8.48011672e-02f, -4.27401513e-02f, -1.08001359e-01f, -5.92770725e-02f, -1.56537533e-01f, -2.83954740e-02f, -1.23233452e-01f,
  -4.81459536e-02f, 2.78900489e-02f, -7.12600499e-02f, 1.13871545e-01f, 1.00983888e-01f, 1.50175646e-01f, 5.49440309e-02f, 9.15683433e-02f, 3.29987556e-02f, 5.36849611e-02f,
  -2.98782792e-02f, -8.32320601e-02f, 8.62224326e-02f, -5.84544800e-02f, 4.39482071e-02f, 8.12862962e-02f, -2.84067895e-02f, -2.54232343e-02f, -6.39794320e-02f, 7.08353743e-02f,
  -4.15600911e-02f, 6.48571476e-02f, -3.97052802e-02f, 2.69772038e-02f, 4.16070782e-02f, 8.32954720e-02f, 4.67038676e-02f, -2.85052671e-03f, 5.84706739e-02f, -4.33484465e-03f,
  -2.02039275e-02f, -5.26608378e-02f, 7.97151402e-02f, -8.11936185e-02f, -7.50936568e-04f, 6.33983910e-02f, -6.96080253e-02f, -8.53028670e-02f, -5.36530837e-02f, -5.51181659e-02f,
  5.06558120e-02f, -4.46601994e-02f, 1.49811516e-02f, 8.33916068e-02f, -6.45228848e-02f, 1.11515477e-01f, -1.71821192e-02f, -7.93676525e-02f, 3.16591598e-02f, -5.55361956e-02f,
  -7.33872801e-02f, -5.58998017e-03f, -2.61067245e-02f, -5.91468327e-02f, -6.62885383e-02f, 5.20570874e-02f, -1.04805149e-01f, -4.17231843e-02f, 7.16738924e-02f, 5.10183349e-02f,
  -2.45116185e-02f, -3.34605239e-02f, -5.79649545e-02f, -6.67239055e-02f, -2.93062516e-02f, 5.52608147e-02f, -1.56150181e-02f, -1.56798568e-02f, -3.66159454e-02f, -5.03801368e-03f,
  -1.11399494e-01f, -4.42978442e-02f, -9.80192446e-04f, 3.07246260e-02f, 1.47626025e-03f, -6.51290789e-02f, -1.05411649e-01f, -8.82328823e-02f, -8.84857848e-02f, 7.59244412e-02f,
  6.01457246e-02f, 8.64001662e-02f, 1.07919499e-02f, 3.59359868e-02f, 3.79725061e-02f, -2.89220689e-03f, 2.12611407e-02f, -1.40232081e-02f, 9.02780965e-02f, 3.26147228e-02f,
  7.57576972e-02f, -4.60267030e-02f, 8.42420831e-02f, 9.63549886e-04f, 7.58465901e-02f, -6.70622736e-02f, 6.16831742e-02f, 3.07386238e-02f, 4.24056165e-02f, -2.66725086e-02f,
  -1.30568398e-02f, -6.86801895e-02f, 6.56021982e-02f, 6.85047060e-02f, 7.51615316e-02f, 6.65882528e-02f, -8.01675080e-04f, -2.72951685e-02f, -2.26124916e-02f, 3.11240777e-02f,
  -8.63186568e-02f, 9.22100991e-02f, -9.32929199e-03f, -1.11599475e-01f, 1.14040561e-02f, -2.55184025e-02f, -6.01214804e-02f, 1.20662525e-02f, 2.49192584e-02f, 3.38474922e-02f,
  8.19817409e-02f, -7.51039982e-02f, -8.60781595e-02f, -2.92510330e-03f, 4.37567756e-02f, 8.19998235e-02f, -3.10581401e-02f, 1.29370186e-02f, -2.41789799e-02f, -1.25509556e-02f,
  -7.33864680e-02f, 8.12524781e-02f, 6.35315701e-02f, -2.59133410e-02f, -4.32364456e-02f, 2.51914188e-02f, 7.63835907e-02f, 8.13406408e-02f, -7.19484091e-02f, -8.56869295e-02f,
  2.60706544e-02f, -9.06238109e-02f, 1.99112296e-02f, 3.92616838e-02f, -4.22425345e-02f, 2.85796393e-02f, 3.56057249e-02f, 6.94008321e-02f, 1.56436791e-03f, -8.55447128e-02f,
  -1.27534727e-02f, -1.91111919e-02f, -8.43770057e-02f, -9.07493457e-02f, 7.18700215e-02f, 6.60177171e-02f, -8.30209926e-02f, 8.16125870e-02f, -6.15587868e-02f, 5.15779667e-02f,
  5.23079000e-02f, -1.40866498e-02f, -6.73960671e-02f, 5.41903935e-02f, -6.91869780e-02f, 4.91512865e-02f, 5.08256778e-02f, -8.27899128e-02f, 2.35122591e-02f, 6.53403299e-03f,
  -1.21886600e-02f, 1.98511537e-02f, -5.85905388e-02f, -5.84447803e-03f, -6.87932670e-02f, 3.38266529e-02f, -3.87935620e-03f, 4.22630794e-02f, 6.90481961e-02f, -6.95664659e-02f,
  3.08184940e-02f, 2.23215315e-02f, -1.72980931e-02f, -2.79899668e-02f, -1.30970497e-02f, 3.49631421e-02f, -4.31802310e-02f, 3.13106962e-02f, -6.53556585e-02f, 6.22144789e-02f,
  4.44597304e-02f, -1.37322441e-01f, 6.56845048e-02f, 8.78515169e-02f, -1.95355993e-02f, 7.07123727e-02f, -4.45759073e-02f, -3.59125622e-02f, 5.21266460e-02f, -4.64164503e-02f,
  5.24660349e-02f, 8.56465548e-02f, 4.67107706e-02f, 4.16398197e-02f, 7.16345608e-02f, -1.93262640e-02f, -4.66429144e-02f, 8.20734873e-02f, 3.78383999e-03f, -1.73940491e-02f,
  8.41789879e-04f, -2.17965394e-02f, -7.82153383e-02f, -7.84988776e-02f, 1.31487206e-03f, 2.59131715e-02f, -1.81074031e-02f, 7.28220120e-02f, -5.11546619e-02f, -2.16832776e-02f,
  -1.83453649e-01f, 4.55850512e-02f, -9.58777070e-02f, -2.18922645e-01f, 1.18305892e-01f, 1.66888803e-01f, 5.78426756e-02f, 1.25152990e-01f, -1.95336312e-01f, 5.90351857e-02f,
  -1.16822682e-02f, -9.49269459e-02f, 3.01380977e-02f, -1.48120001e-01f, -2.35099405e-01f, -1.34575173e-01f, -1.37483791e-01f, 2.93311682e-02f, -7.44841471e-02f, -4.53273095e-02f,
  -8.22871402e-02f, -1.05224781e-01f, -4.61725332e-02f, 3.20401900e-02f, -3.57241705e-02f, 9.87534374e-02f, 1.27560515e-02f, 1.23244666e-01f, -4.26744297e-02f, 3.11757401e-02f,
  -5.23829274e-02f, 4.09594886e-02f, -1.40006933e-02f, -2.02160329e-02f, -2.12168018e-03f, 1.07033350e-01f, -3.40371877e-02f, -6.37197569e-02f, -1.50836015e-03f, -4.97367308e-02f,
  -8.08752179e-02f, -8.02561790e-02f, -9.58958045e-02f, 7.07909018e-02f, -1.04486048e-02f, -7.03734383e-02f, -2.06074188e-03f, -5.86599670e-02f, -2.69259047e-02f, -7.90431947e-02f,
  6.87638223e-02f, -7.72538036e-02f, -6.81138113e-02f, 1.90850217e-02f, -3.78138125e-02f, 4.69068717e-03f, 4.75632735e-02f, -7.43007883e-02f, -1.12922918e-02f, -7.26927519e-02f,
  -2.58552879e-02f, -4.23625810e-03f, -4.40482013e-02f, -4.13585380e-02f, -2.47721784e-02f, 4.56497110e-02f, -4.07809624e-03f, -5.74615300e-02f, -3.53144333e-02f, -1.13544920e-02f,
  -7.72449747e-02f, -8.28976035e-02f, -3.73562053e-02f, 4.19279188e-02f, -3.15330736e-02f, 3.12418249e-02f, 6.94655627e-02f, 3.61780636e-02f, 5.60662672e-02f, -8.71123523e-02f,
  1.02657683e-01f, 5.16379364e-02f, -2.23460644e-02f, 5.25375679e-02f, 5.68649694e-02f, -1.92573909e-02f, 8.39312598e-02f, 7.50818849e-02f, 4.25847210e-02f, -5.80376089e-02f,
  1.06978409e-01f, 1.46395817e-01f, 6.52531162e-02f, -4.89651822e-02f, 3.78374904e-02f, 5.86802065e-02f, 2.07494143e-02f, 3.34421843e-02f, 3.07408050e-02f, 8.39255229e-02f,
  9.53609124e-02f, 2.28520557e-02f, 5.32735847e-02f, -9.20904875e-02f, 7.22878575e-02f, 7.59030879e-02f, -1.59768143e-03f, 3.57855856e-02f, 7.21251220e-02f, 8.29028189e-02f,
  1.30573791e-02f, -1.01544280e-02f, -6.31098310e-03f, 7.23168850e-02f, -8.78746137e-02f, 6.48456290e-02f, -5.67162372e-02f, 1.45069072e-02f, -4.94463667e-02f, 7.13439286e-02f,
  2.69035131e-01f, -2.04969525e-01f, -3.27549368e-01f, 2.37199303e-04f, 2.75164872e-01f, 1.87626585e-01f, -9.89579558e-02f, 1.05460212e-01f, -6.35251217e-03f, -8.08170289e-02f,
  4.44004051e-02f, -8.69116485e-02f, -1.85078248e-01f, 2.22019345e-01f, 2.07574636e-01f, -3.76191325e-02f, 2.04144776e-01f, 1.72750670e-02f, 1.43437283e-02f, -4.83881831e-02f,
  1.67611971e-01f, 3.84922415e-01f, -1.05567381e-01f, 8.09190646e-02f, 1.58622205e-01f, -1.40268773e-01f, 8.38642195e-02f, -2.36090288e-01f, 1.68547064e-01f, 6.94845840e-02f,
  9.78728086e-02f, 6.51439652e-02f, 4.57603186e-02f, -7.66398013e-02f, 3.64613310e-02f, 5.36288209e-02f, -9.71179977e-02f, 2.08267588e-02f, 4.85542044e-02f, -1.02849072e-02f,
  -1.03537992e-01f, 4.54199389e-02f, 7.66232386e-02f, 2.99831573e-02f, 6.08455874e-02f, 6.94235265e-02f, 1.12603325e-02f, -2.13144217e-02f, -2.37067621e-02f, -3.83496545e-02f,
  -9.65668708e-02f, -2.39974428e-02f, 4.80802283e-02f, -1.05699580e-02f, -1.02808848e-01f, -2.74699144e-02f, -5.64606898e-02f, -5.65810688e-02f, 1.86668821e-02f, 8.77881050e-02f,
  3.91181000e-02f, -9.18365940e-02f, 6.73889071e-02f, 8.55941791e-03f, 4.04576026e-02f, 6.88112155e-02f, 5.73717393e-02f, 4.99674380e-02f, -4.63630036e-02f, -1.42259980e-02f,
  -2.07215268e-02f, 9.24084634e-02f, 5.49556985e-02f, 2.64993366e-02f, 7.22356588e-02f, 2.20522005e-02f, -1.84829868e-02f, 3.05454899e-02f, -2.32184082e-02f, -2.84670182e-02f,
  -5.01494445e-02f, 9.91484616e-04f, -3.81678753e-02f, 5.05416356e-02f, -4.19815965e-02f, 4.05295156e-02f, -4.49898094e-03f, 3.07479221e-02f, -9.48109478e-03f, -5.05278185e-02f,
  8.04510862e-02f, -1.64801627e-01f, -4.92707714e-02f, 4.24602553e-02f, -7.61400908e-02f, -5.67547453e-04f, 3.63160558e-02f, 2.31565237e-02f, -5.00521995e-02f, 3.78249027e-02f,
  -6.15340332e-03f, -6.87133372e-02f, -3.55525129e-02f, 3.84173580e-02f, 2.82070525e-02f, 2.03088354e-02f, -5.74922636e-02f, 1.51970638e-02f, -6.97854557e-04f, 2.50636507e-02f,
  -7.78783932e-02f, -5.90221696e-02f, 2.65362971e-02f, -7.62626827e-02f, -3.20713632e-02f, -9.04758647e-02f, 6.47380352e-02f, -5.67490384e-02f, -3.21501940e-02f, -5.52212410e-02f,
  7.30665773e-02f, -3.40665095e-02f, 4.86255921e-02f, 5.47328789e-04f, -5.54365106e-02f, -5.89822792e-02f, -7.29404902e-03f, -1.25569478e-01f, -5.00253737e-02f, 4.03082296e-02f,
  -8.64370912e-02f, 1.35926634e-01f, 6.54976293e-02f, -7.64015242e-02f, -1.69687882e-01f, -1.55572310e-01f, -3.44556272e-02f, 5.15867993e-02f, -7.42532834e-02f, -4.02562059e-02f,
  -8.40620100e-02f, -2.12955356e-01f, -7.68679604e-02f, -7.26747364e-02f, -2.63700988e-02f, 3.54311578e-02f, 3.88433337e-02f, -2.75454614e-02f, -2.95005273e-02f, 4.64398926e-03f,
  -1.01951122e-01f, 1.48055758e-02f, -5.33223897e-02f, -5.97461462e-02f, 8.24167021e-03f, 1.19965374e-01f, -2.19516903e-02f, 1.89227867e-03f, 6.24505356e-02f, -4.09968980e-02f,
  8.53173733e-02f, 5.12478240e-02f, 1.57543365e-02f, -5.57524636e-02f, -3.29267122e-02f, 8.51769000e-02f, 3.08681140e-03f, 1.03729613e-01f, 3.62944952e-03f, -1.39799877e-03f,
  3.89302820e-02f, 3.24558504e-02f, 5.71931945e-03f, -2.19541676e-02f, 9.77472439e-02f, 5.35622658e-03f, 4.94248308e-02f, -4.56209704e-02f, 1.07538566e-01f, 2.34897044e-02f,
  -3.42546776e-02f, -2.61778701e-02f, -8.78807902e-02f, 7.40615577e-02f, -5.51305711e-02f, -2.59995200e-02f, 4.93022501e-02f, 4.24377993e-02f, -2.62048338e-02f, -3.73259410e-02f,
  4.80091050e-02f, 3.34390104e-02f, 5.03349118e-02f, -5.30353114e-02f, -8.83579552e-02f, -4.96123992e-02f, -4.90089580e-02f, -3.89508978e-02f, -2.21812930e-02f, -3.57590094e-02f,
  2.59505529e-02f, 4.89721745e-02f, 2.36396529e-02f, -5.53324223e-02f, -8.37902650e-02f, 6.70832098e-02f, -4.55561839e-02f, -1.44260703e-02f, 8.67951885e-02f, 3.87106165e-02f,
  4.14621122e-02f, -8.31304863e-02f, -7.98065513e-02f, 1.97333675e-02f, -6.66365400e-02f, -6.81848964e-04f, 6.89863116e-02f, 3.64503786e-02f, 4.40571159e-02f, -3.82811017e-02f,
  3.39456871e-02f, -4.64538438e-03f, 4.54307348e-02f, -4.23855186e-02f, 1.70566200e-03f, -8.53938460e-02f, -5.79238236e-02f, 1.60819907e-02f, 6.44851327e-02f, 5.35073280e-02f,
  2.09178589e-02f, -1.85616948e-02f, 6.80472851e-02f, 5.05858026e-02f, -7.32170884e-03f, -6.62477836e-02f, 8.23326558e-02f, 6.14061765e-02f, 5.17595224e-02f, -5.49236983e-02f,
  2.07413495e-01f, -9.97685269e-02f, -1.20110616e-01f, -1.46055534e-01f, -1.10619463e-01f, -3.67549397e-02f, 1.42796755e-01f, -2.82243073e-01f, -1.66360095e-01f, -1.16376348e-01f,
  -4.23135646e-02f, 7.26568475e-02f, 2.91534048e-02f, 2.06881494e-04f, 2.99652874e-01f, 1.35165751e-01f, -2.53930967e-02f, 1.41089782e-01f, -2.04631835e-02f, -1.52296826e-01f,
  -3.66136469e-02f, -1.46347759e-02f, 4.69630031e-04f, -2.70509392e-01f, 1.65512841e-02f, -1.95914000e-01f, 2.91560777e-02f, -3.89255509e-02f, -8.46704245e-02f, 1.39053702e-01f,
  6.96177706e-02f, -7.01619759e-02f, -5.01483269e-02f, -1.31447148e-02f, -9.49980284e-04f, -1.66255478e-02f, 4.63894056e-03f, 1.40887573e-01f, 3.19433585e-02f, -4.33556959e-02f,
  7.85782933e-02f, 1.21929245e-02f, -3.40767652e-02f, 2.89077275e-02f, -8.41472596e-02f, -3.90603393e-02f, -1.08173098e-02f, -2.00267844e-02f, -1.52522027e-02f, 3.49558741e-02f,
  -2.96504777e-02f, 3.23763327e-03f, 7.07464758e-03f, -6.16888031e-02f, 4.48873686e-03f, 3.57374027e-02f, -4.59038001e-03f, 3.62199359e-02f, -4.12075454e-03f, -6.56514168e-02f,
  -5.23341447e-02f, -2.09612045e-02f, 1.16432291e-02f, -1.52560333e-02f, 2.69890074e-02f, -5.82704805e-02f, -2.78741959e-03f, -1.14139169e-02f, -4.74117836e-03f, -7.06537589e-02f,
  -4.04008143e-02f, -1.66102853e-02f, -2.84786653e-02f, 3.44470739e-02f, 2.44202055e-02f, 7.10006282e-02f, 3.11476663e-02f, -3.58672813e-02f, -3.94635275e-02f, 1.99452899e-02f,
  1.54947932e-03f, 3.15980911e-02f, -3.49578820e-02f, -5.67440987e-02f, -1.27795795e-02f, 6.09604865e-02f, -2.13904548e-02f, -8.66890624e-02f, 3.60407867e-02f, 1.02020673e-01f,
  4.42662947e-02f, -5.76098226e-02f, -1.24170564e-01f, 8.55499804e-02f, 1.01825714e-01f, 8.45636576e-02f, 7.55576242e-04f, 1.26664285e-02f, -2.89331656e-02f, -5.45450523e-02f,
  9.67330486e-02f, -5.48032392e-03f, -2.20456459e-02f, -1.24315778e-02f, 7.56622897e-03f, 2.42948066e-02f, 9.93061904e-03f, 1.70981809e-02f, -1.43900199e-03f, 6.84771035e-03f,
  4.98658158e-02f, 8.24363455e-02f, -6.74517453e-03f, 3.50848921e-02f, -1.06113683e-02f, 3.36723290e-02f, -3.39863002e-02f, 8.50168895e-03f, 8.99089202e-02f, -2.89474595e-02f,
  -1.44670352e-01f, -5.44255674e-02f, -4.60160002e-02f, -6.01692908e-02f, -2.30781641e-02f, -3.85115072e-02f, -7.18322098e-02f, -8.04628804e-03f, -1.30584585e-02f, 1.18207775e-01f,
  7.44782165e-02f, -1.32205561e-01f, 4.92324084e-02f, -5.79633676e-02f, -1.46761149e-01f, -1.48588836e-01f, -1.74876794e-01f, -2.58025769e-02f, 1.42688788e-02f, 2.21561082e-02f,
  -2.77703721e-03f, -2.43278015e-02f, 3.04656755e-02f, 9.73152518e-02f, -3.41298133e-02f, 1.17603339e-01f, 8.46652016e-02f, 1.36217043e-01f, -7.40318522e-02f, -6.65722787e-02f,
  1.34471795e-02f, 5.92135042e-02f, 9.31620896e-02f, 2.95104235e-02f, 8.98885727e-02f, -5.15116425e-03f, -4.11032401e-02f, -2.56013945e-02f, -1.32490834e-03f, -5.08928262e-02f,
  6.39904588e-02f, 6.64049983e-02f, -1.08923398e-01f, -3.18902880e-02f, -7.64626116e-02f, 4.92533576e-03f, 4.44217473e-02f, 1.96062028e-03f, 1.08939677e-01f, 5.86749278e-02f,
  3.61550152e-02f, -5.93967661e-02f, 2.45377235e-03f, -1.66477170e-02f, 4.53306697e-02f, 7.39714364e-03f, -6.37394935e-02f, 8.55334923e-02f, 6.38980418e-03f, -9.17358547e-02f,
  -7.31461346e-02f, 1.51717095e-02f, 2.06312872e-02f, 6.59484565e-02f, -5.95207922e-02f, -5.38539775e-02f, 2.69344579e-02f, 3.31812203e-02f, 4.77276603e-03f, -7.49262050e-02f,
  5.47931530e-02f, -7.08418936e-02f, 3.95871252e-02f, -1.42984083e-02f, 1.40997507e-02f, 7.13278204e-02f, 6.26390129e-02f, 8.84407684e-02f, -6.36330917e-02f, -7.20230862e-02f,
  9.50608104e-02f, -7.61291608e-02f, 1.61317270e-02f, 7.20859990e-02f, 7.82178864e-02f, 8.08372051e-02f, -7.73101747e-02f, -8.04109424e-02f, 6.80302829e-02f, 2.83801612e-02f,
  2.08819136e-02f, 9.90330726e-02f, 3.82564887e-02f, 9.10760909e-02f, 3.30746807e-02f, 8.91433209e-02f, 8.56054723e-02f, 4.14204895e-02f, -9.73231122e-02f, -5.09286039e-02f,
  -5.79468533e-02f, -5.24974167e-02f, 1.64981140e-03f, -2.61340234e-02f, -6.65623024e-02f, -1.08523211e-02f, 7.73401409e-02f, -2.64872871e-02f, 4.73239576e-04f, 1.54692801e-02f,
  7.70297423e-02f, -1.84942037e-02f, 1.99794713e-02f, 1.99607648e-02f, -4.95482571e-02f, 7.00489804e-02f, 5.47798239e-02f, -4.19973060e-02f, 2.48269383e-02f, -2.28023902e-02f,
  -2.37760872e-01f, -9.78164002e-02f, -1.56717703e-01f, 3.69667262e-02f, 1.41209781e-01f, -1.59576580e-01f, -9.53174010e-02f, 2.65974645e-02f, -2.32469380e-01f, -2.04342064e-02f,
  -4.02459782e-03f, -1.08572990e-01f, 1.01143224e-02f, -1.29345000e-01f, -2.14573026e-01f, -2.94738740e-01f, -3.10646724e-02f, -4.52370010e-02f, -1.14394329e-01f, 1.13391869e-01f,
  5.12809157e-02f, 1.86158448e-01f, 4.89811003e-02f, 2.81891704e-01f, -2.81175859e-02f, 1.40126750e-01f, 3.63034308e-01f, 8.09955001e-02f, 1.99723274e-01f, 1.17233451e-02f,
  -1.51424408e-01f, -1.40080214e-01f, -1.10742636e-03f, -6.67092875e-02f, 1.49889737e-01f, 3.69094685e-02f, 4.51057358e-03f, 1.00940056e-02f, -1.09891236e-01f, -2.29920596e-02f,
  1.29993791e-02f, -1.94306131e-02f, -1.59995202e-02f, -7.74754584e-02f, -3.54606891e-03f, 5.45433611e-02f, -6.14177398e-02f, -1.00639667e-02f, 1.27236908e-02f, -9.89563987e-02f,
  -4.87575345e-02f, 7.06716999e-02f, 1.32637829e-01f, -5.18257283e-02f, -1.98115334e-02f, -1.57501716e-02f, 6.98207691e-02f, -2.87326779e-02f, -7.20573366e-02f, 1.50221586e-02f,
  5.25988676e-02f, 7.72661269e-02f, 6.44087270e-02f, -8.75442475e-02f, -4.77435030e-02f, -3.63113582e-02f, -2.71537304e-02f, -4.58361469e-02f, -3.01760882e-02f, 4.97039594e-02f,
  -3.51055227e-02f, 3.88299264e-02f, -4.85271923e-02f, -2.30730837e-03f, -1.31100658e-02f, 2.57560648e-02f, 1.82326492e-02f, -4.22489718e-02f, -6.81131613e-03f, 5.12519218e-02f,
  -4.68861349e-02f, -2.60041077e-02f, 6.47163158e-03f, 1.28615955e-02f, -5.11901230e-02f, -6.75493777e-02f, 4.93600294e-02f, -8.15365463e-02f, 9.46495011e-02f, 2.04365291e-02f,
  1.62249759e-01f, 2.72092044e-01f, -9.39333229e-04f, -3.78438048e-02f, 4.43186332e-03f, -2.37204861e-02f, -6.57500774e-02f, 3.04586142e-02f, -2.20870320e-02f, -4.73993011e-02f,
  1.73209831e-01f, 9.06924456e-02f, 1.35682538e-01f, 1.78222489e-02f, 4.14658189e-02f, 2.62831245e-03f, 6.51455764e-03f, -1.33695593e-02f, 4.68673855e-02f, 8.68992358e-02f,
  3.02724335e-02f, 3.15375999e-02f, 1.19547481e-02f, 1.68887451e-02f, 5.93188107e-02f, 3.23947743e-02f, 7.74444714e-02f, 3.80577929e-02f, 7.49856606e-02f, 5.09900786e-02f,
  7.47442469e-02f, 1.56184509e-01f, 1.34726986e-01f, 2.29479209e-01f, -1.08372122e-01f, -1.70961529e-01f, -2.18385383e-01f, -4.82858680e-02f, -1.75279565e-02f, 2.05709077e-02f,
  1.62015017e-02f, 1.51633829e-01f, -8.61977041e-02f, -9.28599294e-03f, 3.09845968e-03f, -2.57872064e-02f, 7.39072636e-03f, -5.27685843e-02f, 2.32720841e-02f, 3.63207273e-02f,
  3.86241823e-02f, 7.78382346e-02f, 1.29856035e-01f, 1.01791017e-01f, 2.22474732e-03f, 1.19123138e-01f, 1.19732589e-01f, 3.00660711e-02f, 1.55197844e-01f, 5.44063412e-02f,
  1.66195799e-02f, 1.35585312e-02f, 1.15175374e-01f, 4.31632735e-02f, 1.72700137e-02f, -1.55500341e-02f, 6.88867494e-02f, -8.29841346e-02f, 3.39799933e-02f, -3.21154371e-02f,
  -2.18556169e-03f, 2.45993435e-02f, 1.17495069e-02f, 6.04213625e-02f, -4.48642112e-02f, 3.25787142e-02f, 8.03292766e-02f, -7.59188533e-02f, 1.15124181e-01f, -3.86336260e-02f,
  -1.35486163e-02f, 4.70670126e-02f, 1.58372354e-02f, 1.58286269e-03f, 9.57106203e-02f, -6.85728863e-02f, -8.01701937e-03f, -4.43444960e-02f, -7.47952759e-02f, -5.63584408e-03f,
  1.33756073e-02f, -7.06188604e-02f, 5.39918430e-03f, -9.44310278e-02f, -4.24616188e-02f, 6.28291219e-02f, -2.25068554e-02f, 3.59820388e-03f, 3.92042957e-02f, 4.23546918e-02f,
  1.06851722e-03f, 3.78996469e-02f, 2.17081029e-02f, 2.81817652e-02f, 2.59422772e-02f, -9.22535881e-02f, -3.71486950e-03f, -5.47585785e-02f, 6.59863800e-02f, 4.15622294e-02f,
  1.71125829e-02f, 1.64979920e-02f, -2.95044482e-02f, -6.04759157e-02f, -1.13354355e-01f, 4.71031666e-02f, 5.31035848e-02f, -5.62465899e-02f, -6.29394427e-02f, 1.16811441e-02f,
  -2.57438291e-02f, 2.00887755e-01f, -6.02596998e-02f, 7.73578808e-02f, 3.99196334e-03f, -5.76512292e-02f, -6.83356971e-02f, 6.85670748e-02f, 6.82981536e-02f, -4.15124185e-02f,
  -2.19401903e-02f, -3.40959728e-02f, 6.31765574e-02f, 6.10937588e-02f, -4.11603861e-02f, -7.69661665e-02f, 2.42652837e-02f, 4.20773439e-02f, -4.29672608e-03f, 1.10322163e-01f,
  9.65113565e-02f, -6.84567019e-02f, 3.20641659e-02f, 2.70862095e-02f, -3.37959640e-02f, -3.42152864e-02f, -6.60636872e-02f, 6.96729347e-02f, 3.87274027e-02f, 3.20666400e-03f,
  4.00472492e-01f, 7.94984121e-03f, 1.34337604e-01f, 3.20265114e-01f, 1.41037628e-01f, 1.33840004e-02f, -2.59196367e-02f, 4.07714769e-02f, 3.39740157e-01f, -6.32090867e-03f,
  -9.73328277e-02f, 2.12463409e-01f, -2.16335610e-01f, 1.29539654e-01f, -1.23497263e-01f, -1.65522426e-01f, 1.82592109e-01f, 1.37625545e-01f, -3.07346182e-03f, 1.92469507e-01f,
  1.88465223e-01f, -2.91120410e-02f, -1.70359954e-01f, -1.42446369e-01f, 1.36740535e-01f, 1.06867068e-01f, -1.55045554e-01f, -1.90485567e-01f, -5.62782772e-02f, -1.98703676e-01f,
  2.21687686e-02f, 3.96209545e-02f, 1.14999609e-02f, -4.62917127e-02f, 2.67311651e-02f, -4.67072427e-02f, -2.31111776e-02f, -1.56231359e-01f, 7.07866997e-02f, 6.95583224e-02f,
  -1.36314379e-02f, -5.18143140e-02f, 1.01203457e-01f, -8.66417661e-02f, 1.17405102e-01f, -1.31781762e-02f, 8.88848379e-02f, 7.00934976e-02f, 9.09995809e-02f, 4.83382009e-02f,
  1.03253014e-01f, 3.93490419e-02f, 1.42708093e-01f, -9.80384722e-02f, -3.01021319e-02f, -1.63418818e-02f, 4.74495105e-02f, -5.11118099e-02f, -4.06711884e-02f, -2.39881850e-03f,
  5.83671546e-03f, 3.15035097e-02f, -5.46671934e-02f, 4.18575220e-02f, 4.76154350e-02f, -1.44242207e-02f, 5.48051205e-03f, 7.02317879e-02f, 1.81914084e-02f, 2.18124297e-02f,
  5.07779866e-02f, 7.43009597e-02f, -2.05442403e-02f, -6.27982384e-03f, 1.01353586e-01f, 3.75759527e-02f, -2.06961464e-02f, -3.94806126e-03f, 5.63896336e-02f, -1.46151697e-02f,
  -9.15769413e-02f, -5.98068982e-02f, 3.76880318e-02f, 5.32144029e-03f, 2.66952198e-02f, -1.62294824e-02f, -3.61358398e-03f, 5.78095652e-02f, 5.95435388e-02f, 1.35407900e-03f,
  -5.12054190e-02f, -1.76513474e-02f, 3.51200178e-02f, 5.77903315e-02f, 6.84366301e-02f, 1.45156244e-02f, 3.34582552e-02f, 5.29790819e-02f, -1.18390366e-01f, -8.55886843e-03f,
  4.08704430e-02f, 4.80467528e-02f, -5.41795753e-02f, -6.00363947e-02f, -2.56783832e-02f, 7.08347559e-02f, 1.60476919e-02f, -3.78869250e-02f, -9.92780924e-03f, -7.07258955e-02f,
  9.79919583e-02f, 1.31324502e-02f, 6.31895512e-02f, 1.34106725e-02f, -2.29898188e-02f, -6.10045642e-02f, 1.00789713e-02f, -2.20378097e-02f, 2.70505808e-02f, -2.25300547e-02f,
  -2.33692780e-01f, 1.11486875e-01f, 3.49232065e-03f, -5.23703820e-05f, 8.33582878e-02f, -1.02675125e-01f, -5.17091975e-02f, 4.55733910e-02f, -2.65097176e-03f, 1.68821350e-01f,
  3.63342576e-02f, -1.03553511e-01f, 1.37902811e-01f, 8.21326077e-02f, -3.01340580e-01f, 2.62882304e-03f, -7.94796571e-02f, 2.02807188e-02f, -1.15194142e-01f, -6.01301081e-02f,
  -2.99446210e-02f, 1.13753408e-01f, 8.62634033e-02f, 3.59719582e-02f, 3.02533563e-02f, -2.95897527e-03f, 1.98315550e-02f, -3.44223753e-02f, 1.36478106e-02f, -2.99012940e-02f,
  -3.86263616e-02f, -3.98386866e-02f, 3.09801288e-02f, -8.87538046e-02f, -1.56107498e-03f, -2.02617124e-02f, -1.17606774e-01f, -4.65489030e-02f, -4.08788919e-02f, -8.45826510e-03f,
  -1.40744418e-01f, -7.80899450e-02f, 5.75220399e-02f, -4.71777022e-02f, 6.18716590e-02f, -3.33218947e-02f, -7.11124241e-02f, -6.59894645e-02f, 6.56901449e-02f, 3.13546918e-02f,
  7.63548836e-02f, -1.07024655e-01f, -5.00501879e-02f, -8.33437368e-02f, -4.64795753e-02f, 8.52510333e-02f, -7.21216798e-02f, -5.14499024e-02f, -3.74483019e-02f, -6.89834207e-02f,
  -3.57575417e-02f, 2.11969465e-02f, -3.01339645e-02f, -3.40765901e-02f, 1.17511852e-02f, -1.80475768e-02f, 8.22563022e-02f, -7.83659816e-02f, -5.28271943e-02f, 3.73178683e-02f,
  4.07054089e-02f, 1.34853572e-02f, -1.13865174e-02f, 5.68514280e-02f, 3.70140858e-02f, 2.44946741e-02f, 3.75587679e-02f, 3.00170053e-02f, 4.11983691e-02f, -3.29832956e-02f,
  -6.38875365e-02f, 5.51644666e-03f, 8.07064846e-02f, -4.72212434e-02f, -4.21521738e-02f, -3.04113049e-02f, -9.97461192e-03f, 3.60319838e-02f, 7.80936852e-02f, 1.17467297e-02f,
  -1.10265180e-01f, -1.19675837e-01f, -1.45913418e-02f, -8.52662697e-03f, 1.49053568e-02f, 3.67874019e-02f, -8.87523517e-02f, -1.10197939e-01f, 8.77939817e-03f, -5.51816374e-02f,
  3.46583351e-02f, 5.38713578e-03f, -1.17786773e-01f, 1.73075423e-02f, -8.56076106e-02f, -9.53548849e-02f, 5.46285929e-03f, -9.09718201e-02f, 2.93882955e-02f, -7.21956119e-02f,
  6.43772185e-02f, 9.88183916e-02f, -6.90160394e-02f, 1.66862831e-02f, 5.06197736e-02f, -5.66262007e-02f, -7.29310066e-02f, 1.20312134e-02f, 5.41192964e-02f, -7.30159134e-02f,
  -1.85751572e-01f, 2.00074345e-01f, -7.56982863e-02f, -1.58961073e-01f, -3.08631528e-02f, 1.41535953e-01f, 5.50051704e-02f, 1.59041002e-01f, 1.07433973e-02f, 1.57868624e-01f,
  5.53453453e-02f, 4.68045287e-03f, 4.56020199e-02f, -7.24532083e-02f, -1.08520016e-02f, 1.18141100e-01f, -3.32361162e-02f, 7.71276578e-02f, 3.31278108e-02f, -9.00077894e-02f,
  -7.27747977e-02f, -6.37571663e-02f, -1.23707578e-01f, -9.55296215e-03f, -1.14836745e-01f, -8.42146575e-02f, -4.06996394e-03f, -9.34924558e-02f, 4.34523858e-02f, 6.88739866e-02f,
  1.04109280e-01f, -2.98399292e-02f, 4.56621051e-02f, 2.52435543e-02f, 1.76003370e-02f, 5.34929000e-02f, -7.79739171e-02f, -1.05261058e-01f, -1.30151674e-01f, 2.34574880e-02f,
  -6.93180859e-02f, -7.89686292e-02f, 8.32390264e-02f, -8.30006823e-02f, -8.73051677e-03f, 6.58279210e-02f, 4.69095409e-02f, -3.41639072e-02f, 4.50596213e-02f, -2.55391896e-02f,
  -8.49223286e-02f, -6.42452091e-02f, -3.95605937e-02f, 7.37009794e-02f, -6.34031147e-02f, 6.31302521e-02f, -5.16826287e-02f, -4.34571318e-02f, -4.29177247e-02f, 8.93852040e-02f,
  7.76190683e-02f, -1.53832054e-02f, 7.06424788e-02f, 6.44550025e-02f, 8.55796784e-02f, 4.02846336e-02f, -1.04606301e-01f, 6.13206215e-02f, -3.70280235e-03f, -2.79914569e-02f,
  4.96173128e-02f, 7.92643428e-02f, 6.62645251e-02f, -6.82574585e-02f, -5.43017238e-02f, -4.06019948e-02f, 3.70488800e-02f, 2.72152442e-02f, 3.52337956e-02f, 6.14779815e-02f,
  -6.04032651e-02f, -5.53405620e-02f, 4.43436354e-02f, 2.50076409e-02f, -2.38364767e-02f, -1.45951426e-02f, -3.67999151e-02f, -2.42983550e-02f, 6.96374476e-02f, -7.44085461e-02f,
  6.74735457e-02f, 1.41975626e-01f, 4.35108505e-03f, 3.42467278e-02f, -2.46149767e-02f, 8.32416341e-02f, 2.41796840e-02f, 9.73985158e-03f, -9.36678052e-03f, 5.22025488e-02f,
  6.52547628e-02f, 4.48470712e-02f, -1.06564380e-01f, 2.08040960e-02f, 1.38365179e-02f, 1.28395736e-01f, 3.91007997e-02f, -5.23909330e-02f, -1.07024051e-01f, 8.44500884e-02f,
  -9.57776308e-02f, -4.67497185e-02f, 1.64373759e-02f, 3.93186025e-02f, -7.42734224e-02f, 5.34855155e-03f, -7.02201128e-02f, 6.28883839e-02f, 9.99822393e-02f, 8.76167342e-02f,
  8.07786435e-02f, -8.11366364e-02f, 5.21362619e-03f, -9.24572274e-02f, 4.12364164e-03f, -2.87876353e-02f, -5.54753244e-02f, -1.35635778e-01f, -1.38217896e-01f, 3.12560946e-02f,
  -1.00635998e-01f, 1.18095450e-01f, 5.17179854e-02f, 2.74628922e-02f, 1.02140494e-01f, 1.89508162e-02f, -7.53857568e-02f, 6.72334656e-02f, -1.88101921e-02f, -3.10746916e-02f,
  -1.00188598e-01f, -1.39584631e-01f, 9.29343477e-02f, -4.64165881e-02f, -6.97793067e-02f, 1.24376407e-02f, 1.71375480e-02f, 3.50936092e-02f, -9.43885893e-02f, 3.09783034e-02f,
  2.45383270e-02f, -2.84686591e-02f, 9.05854814e-03f, 7.97422826e-02f, -1.75875146e-02f, 8.39275494e-02f, 5.44468611e-02f, -2.61220410e-02f, 9.83671378e-03f, -7.87613243e-02f,
  4.03205893e-04f, 8.21081549e-02f, -2.04241332e-02f, 1.23690590e-02f, -2.80525885e-03f, -2.82630697e-02f, 1.04152756e-02f, -3.43070067e-02f, -3.94049324e-02f, 1.13903008e-01f,
  6.23827167e-02f, -5.86273521e-03f, 6.69171661e-02f, -7.83337466e-03f, -5.17125428e-02f, -9.60902646e-02f, -3.64583693e-02f, 3.49010713e-02f, 6.45909682e-02f, -7.59205073e-02f,
  6.38052542e-03f, 9.24644843e-02f, -2.17110142e-02f, -1.66152567e-02f, 2.69336570e-02f, -7.75193274e-02f, -6.68009371e-02f, -6.36514202e-02f, -8.55574980e-02f, 7.51489922e-02f,
  -9.12139099e-03f, 2.45150570e-02f, -1.15271546e-02f, -1.06024690e-01f, 6.85694292e-02f, -4.36689034e-02f, 1.12409979e-01f, 8.75689164e-02f, -1.30996602e-02f, -5.48854005e-03f,
  3.90081927e-02f, 6.49065245e-04f, -6.16264939e-02f, -9.32994783e-02f, -6.44154474e-02f, -1.12089617e-02f, -3.70823741e-02f, -6.94970936e-02f, 3.07945888e-02f, -1.17585668e-02f,
  9.35891271e-03f, -2.39698440e-02f, -2.63506006e-02f, 3.58303264e-02f, 3.03536672e-02f, -2.91998181e-02f, 1.43531244e-02f, 9.29978560e-04f, -8.32238048e-02f, -1.74275432e-02f,
  1.56568945e-03f, 4.23098132e-02f, 1.18991220e-02f, 1.01500474e-01f, -6.07401039e-03f, -3.21641862e-02f, 3.22873294e-02f, -6.12169243e-02f, -1.14262421e-02f, 4.90772873e-02f,
  3.73548828e-02f, -3.25630084e-02f, -2.78705284e-02f, 5.02088927e-02f, -2.39919452e-03f, 4.12291251e-02f, 1.90124735e-02f, 1.05840154e-01f, 1.05683389e-03f, 2.51672622e-02f,
  1.88533198e-02f, -1.14880040e-01f, -1.15493141e-01f, 2.26774979e-02f, -1.63680464e-01f, -8.49914029e-02f, -2.31837541e-01f, -2.21560657e-01f, -3.26616168e-02f, -1.56383231e-01f,
  -9.44441259e-02f, 1.77168638e-01f, 4.86120619e-02f, -1.69539943e-01f, 1.74832538e-01f, 1.90118060e-01f, -7.97327608e-02f, -1.04247265e-01f, 5.29120006e-02f, -1.43032312e-01f,
  -5.49442954e-02f, -7.05149844e-02f, -6.99109491e-03f, -7.55584612e-02f, -2.71658063e-01f, -1.31070033e-01f, 4.99187130e-03f, -1.39048815e-01f, -9.65426117e-03f, -1.41059309e-02f,
  -1.29819080e-01f, -1.13044493e-01f, -1.29165217e-01f, -5.62654920e-02f, -1.71966463e-01f, -7.91965947e-02f, -3.96230482e-02f, -1.14627760e-02f, -7.87272975e-02f, 5.83643354e-02f,
  -2.40176786e-02f, -8.18936899e-03f, -3.84761319e-02f, 3.07452045e-02f, -3.33416164e-02f, -5.84228858e-02f, -8.74098465e-02f, -7.87091441e-03f, -7.33197713e-03f, -4.73047905e-02f,
  -2.80867182e-02f, 4.05026153e-02f, 1.58830229e-02f, 8.28611255e-02f, -5.05543640e-03f, 4.32118395e-04f, -4.95730946e-03f, 1.01516061e-01f, 8.00777152e-02f, 4.03815582e-02f,
  3.28375138e-02f, 2.71681463e-03f, -1.97134670e-02f, -6.31228238e-02f, -3.92196402e-02f, -1.00595325e-01f, 4.95771766e-02f, -5.38495518e-02f, 4.51186635e-02f, 3.97427268e-02f,
  1.90627892e-02f, 3.12763266e-02f, -9.19397101e-02f, 8.77535064e-03f, 5.60087040e-02f, 5.36675267e-02f, 3.05629130e-02f, 3.04601863e-02f, -3.39575745e-02f, 4.19379622e-02f,
  4.56193089e-02f, -8.82556438e-02f, -5.92136309e-02f, 2.92567890e-02f, 6.47853091e-02f, -1.66086461e-02f, -5.87056465e-02f, 1.14806285e-02f, 6.78690597e-02f, 3.17576602e-02f,
  -1.48738742e-01f, -5.05610518e-02f, 1.26940049e-02f, -6.44485205e-02f, 4.94203791e-02f, 1.89999938e-02f, 1.19033409e-02f, -7.92518035e-02f, 4.66036052e-02f, -5.00168242e-02f,
  -7.25327954e-02f, -6.96544498e-02f, 2.97639333e-02f, 8.00002739e-02f, 1.22030489e-02f, -5.52306399e-02f, -5.57088926e-02f, -1.72682367e-02f, 4.84230146e-02f, 3.05002350e-02f,
  -5.51714934e-02f, -2.85376310e-02f, 8.52315277e-02f, 4.37756209e-03f, 7.80745149e-02f, -6.03785627e-02f, 7.61758611e-02f, 1.99380033e-02f, -7.69541487e-02f, -7.55044073e-03f,
  -1.38856426e-01f, 2.32698411e-01f, -8.89582038e-02f, 2.61594895e-02f, -1.54113874e-01f, 1.84631139e-01f, 1.25832722e-01f, 6.00285716e-02f, 8.23716894e-02f, 2.15811536e-01f,
  5.68824448e-02f, -2.40805205e-02f, 1.24286488e-01f, 2.50186205e-01f, 3.64856273e-02f, 1.12367339e-01f, 2.51730859e-01f, 1.83030054e-01f, -1.21442817e-01f, 6.68148175e-02f,
  1.06477682e-02f, 1.07102238e-01f, -4.56656236e-03f, -2.76293419e-02f, -8.49551633e-02f, -2.19651848e-01f, -1.05627693e-01f, -1.95354357e-01f, -5.80899091e-03f, -8.30163956e-02f,
  8.54182392e-02f, -6.06697351e-02f, 1.62786972e-02f, 4.45857011e-02f, -1.84129551e-02f, -2.98635028e-02f, -8.31986740e-02f, 2.42675818e-03f, -1.00646719e-01f, 6.31599426e-02f,
  4.20132317e-02f, 4.80380468e-02f, 6.27782196e-02f, 1.25126233e-02f, 3.75605933e-02f, -7.35173449e-02f, -7.49387816e-02f, 4.13255417e-04f, 1.04732141e-02f, 4.12793923e-03f,
  -8.55468214e-03f, -3.86716872e-02f, 5.27280569e-02f, 9.06731468e-03f, -5.67115322e-02f, 4.76698726e-02f, 7.00421259e-02f, -8.81496668e-02f, 2.29883660e-02f, 6.97636157e-02f,
  2.72514187e-02f, 5.87505251e-02f, 4.87990081e-02f, -6.41193986e-02f, -3.59890461e-02f, 2.98536755e-02f, 9.48550031e-02f, -3.96315716e-02f, 2.29144972e-02f, 5.56432605e-02f,
  5.95144071e-02f, -7.03093410e-02f, 1.41828193e-03f, -7.11448351e-03f, -4.57608812e-02f, -7.64404517e-03f, -4.29132916e-02f, 7.79426768e-02f, -2.95236651e-02f, -3.31937224e-02f,
  4.84444983e-02f, -2.78183203e-02f, 7.33357146e-02f, -4.81488518e-02f, -2.33634934e-02f, -7.20350668e-02f, -6.41767085e-02f, -5.87486774e-02f, -7.51842335e-02f, 6.50742799e-02f,
  6.06023334e-02f, 1.55746685e-02f, 6.96005896e-02f, 2.12640082e-03f, -4.50145006e-02f, 2.35530026e-02f, -7.94074237e-02f, -3.89570780e-02f, 4.88277674e-02f, 2.24705115e-02f,
  -2.80177593e-02f, 5.59240170e-02f, -6.19275346e-02f, 5.01919985e-02f, -3.27692367e-02f, 1.11521974e-01f, 1.39692128e-02f, -1.08002797e-02f, 3.67100351e-02f, 4.74418281e-03f,
  -4.44264943e-03f, 1.17822764e-02f, -1.19069079e-02f, 4.94801700e-02f, -3.05764358e-02f, -6.19640797e-02f, 5.01772240e-02f, -7.98408985e-02f, -8.67083073e-02f, 5.82035221e-02f,
  -1.21213324e-01f, 1.66063122e-02f, -3.13668132e-01f, -2.56343484e-01f, 6.20763674e-02f, -3.63637596e-01f, -3.41362923e-01f, -8.28805938e-02f, 6.42606802e-03f, 8.43088180e-02f,
  -3.19899688e-03f, -4.95965555e-02f, 1.42676830e-01f, -3.51964861e-01f, -1.47156879e-01f, 5.20059131e-02f, -4.37811404e-01f, -2.20844373e-01f, 4.05821539e-02f, -2.36122102e-01f,
  -4.83274758e-02f, -2.13434920e-01f, -1.76607862e-01f, 4.96323705e-02f, -2.91202486e-01f, -2.39389017e-03f, 7.52344280e-02f, 1.26582086e-02f, -1.65931761e-01f, -7.05139190e-02f,
  -6.09997548e-02f, 6.03307262e-02f, -4.13989350e-02f, 4.18791100e-02f, -7.59995282e-02f, -7.15344166e-03f, -5.99825568e-02f, -1.57457236e-02f, 2.31400008e-05f, -8.14217702e-02f,
  7.54964128e-02f, -8.26864317e-02f, -5.70969423e-03f, 5.74225932e-02f, 1.07271038e-02f, -8.11983049e-02f, -3.10071539e-02f, -1.48193687e-02f, -6.83651939e-02f, -2.09437814e-02f,
  -5.87403364e-02f, 1.18832858e-02f, -1.79849975e-02f, 2.34830417e-02f, -4.48467024e-02f, -9.60862078e-03f, 3.67854051e-02f, -5.77953979e-02f, -4.77986075e-02f, -4.30233106e-02f,
  7.82020763e-02f, -2.65973900e-02f, 4.51444425e-02f, -6.32048622e-02f, -6.60933033e-02f, 3.93036678e-02f, 4.00500884e-03f, 7.91473165e-02f, 8.86893943e-02f, 6.00994080e-02f,
  -2.41075438e-02f, 5.47265857e-02f, -4.99812886e-02f, 3.29454392e-02f, 1.82278063e-02f, 1.35793658e-02f, -8.13774839e-02f, -3.29420790e-02f, -1.07861750e-01f, -1.01279719e-02f,
  -3.97752672e-02f, 2.57701539e-02f, 1.38921691e-02f, 6.59288093e-02f, -4.21797894e-02f, -4.50323261e-02f, 2.09025238e-02f, -1.89771503e-02f, 2.62680054e-02f, 4.88562451e-04f,
  -4.84848246e-02f, 1.31035388e-01f, -8.52833167e-02f, -1.10056857e-02f, -4.76221479e-02f, 2.82708020e-03f, 3.07342559e-02f, -1.29425824e-02f, 3.62915471e-02f, -1.07778767e-02f,
  -3.72749171e-03f, 2.85140183e-02f, 5.59258983e-02f, 4.94662672e-02f, -3.61246169e-02f, -6.25453948e-04f, 9.45022679e-04f, 6.23436123e-02f, -6.51203422e-03f, -4.53143865e-02f,
  7.27288425e-02f, -2.88138054e-02f, 9.41775069e-02f, -8.21072906e-02f, -3.52525413e-02f, -4.21760790e-02f, 6.19699880e-02f, -2.70435624e-02f, 3.82362194e-02f, 6.98457211e-02f,
  -4.51431088e-02f, 2.67817736e-01f, -7.43695572e-02f, -1.11659532e-02f, 1.01913475e-01f, -2.41392344e-01f, -2.75101978e-03f, 6.58247694e-02f, 8.10127053e-03f, 1.35065123e-01f,
  5.55462241e-02f, 1.46997705e-01f, 2.80335601e-02f, -1.83313601e-02f, -4.71499532e-01f, -1.81636795e-01f, -1.68494195e-01f, -7.05665275e-02f, -1.07171170e-01f, 7.55163133e-02f,
  -2.01871604e-01f, -5.27734309e-02f, -1.64889351e-01f, 1.61239564e-01f, 2.48450432e-02f, 1.72018304e-01f, 1.68284755e-02f, 1.53113618e-01f, 4.41024527e-02f, -5.13423048e-03f,
  -2.40205806e-02f, 7.28205964e-02f, 1.22947618e-01f, 5.29532097e-02f, 2.81702764e-02f, 2.85335053e-02f, 4.33531515e-02f, 2.45522726e-02f, 2.53453068e-02f, -1.85854789e-02f,
  1.16989225e-01f, -3.37705426e-02f, -4.57557663e-03f, -2.85253078e-02f, 6.55736551e-02f, -2.41665877e-02f, -2.63687428e-02f, 1.99564416e-02f, 3.81700471e-02f, 5.31991608e-02f,
  8.79715383e-02f, 7.12281242e-02f, -3.65466774e-02f, -6.07383847e-02f, -2.60596424e-02f, 3.16217430e-02f, 4.11942266e-02f, 3.70241888e-02f, -4.43181880e-02f, -9.32695251e-03f,
  -5.49793318e-02f, -7.33154565e-02f, 1.00193778e-03f, -5.40042296e-02f, 6.31602407e-02f, -3.30655500e-02f, -3.80808599e-02f, 2.78922319e-02f, -5.13146184e-02f, 3.14102992e-02f,
  6.84675798e-02f, -2.66512297e-02f, -7.21526369e-02f, -1.30043821e-02f, 5.58326691e-02f, 6.78022392e-03f, 2.38615386e-02f, 6.57748953e-02f, 3.96881551e-02f, 2.37093922e-02f,
  3.54190655e-02f, -1.81903329e-03f, 7.30233192e-02f, 7.70163760e-02f, -5.92937618e-02f, 5.77299446e-02f, 6.76943688e-03f, 2.77276821e-02f, -2.48656124e-02f, -3.24904807e-02f,
  -7.25718513e-02f, 9.90666747e-02f, 2.61819419e-02f, 2.16362551e-02f, -3.66992429e-02f, -1.04601867e-01f, 1.71280578e-02f, 6.79934695e-02f, -8.78718793e-02f, 4.37651612e-02f,
  -1.49458712e-02f, 6.47447109e-02f, 5.67945838e-03f, 9.96994600e-03f, -3.56793357e-03f, -8.98947269e-02f, -2.61315927e-02f, 8.51020589e-02f, 2.66246088e-02f, -1.10826958e-02f,
  2.23981608e-02f, -4.30605598e-02f, 1.55958701e-02f, 5.13564460e-02f, 4.35873009e-02f, -5.58851287e-02f, 4.22728211e-02f, 1.04537442e-01f, 1.86513234e-02f, -6.74012452e-02f,
  7.02002272e-02f, -1.35099977e-01f, -1.44773185e-01f, 1.41017539e-02f, -7.21656084e-02f, 6.08905628e-02f, -1.37227252e-01f, 1.09505281e-01f, -7.93995708e-02f, 4.38129827e-02f,
  8.42405558e-02f, -1.39976591e-01f, -1.51978269e-01f, 1.73878938e-01f, 8.12716782e-02f, -9.27073357e-04f, 1.17459735e-02f, -1.78431347e-02f, -1.44676473e-02f, 5.88127761e-04f,
  4.84972969e-02f, 1.87772855e-01f, 1.28276825e-01f, 1.10660389e-01f, 5.53475283e-02f, 1.45371348e-01f, 1.11564137e-01f, 3.04791667e-02f, 2.46432826e-01f, 1.30184755e-01f,
  -1.16036981e-02f, -1.95919704e-02f, -6.85185865e-02f, -1.60620734e-02f, -3.46411392e-02f, 6.70677796e-02f, 1.88821889e-02f, -7.51724020e-02f, 5.28248698e-02f, 5.73316514e-02f,
  5.35386503e-02f, 5.41077890e-02f, -1.70412213e-02f, -2.00090874e-02f, 4.56174389e-02f, -7.01743290e-02f, -6.19361289e-02f, 1.68185811e-02f, 5.42228343e-03f, 1.27804317e-02f,
  5.59230968e-02f, 3.43865901e-02f, -1.33878235e-02f, -2.35694852e-02f, 4.40401118e-03f, 5.19962795e-02f, -1.45722097e-02f, 6.20026626e-02f, 4.53729257e-02f, -5.67784235e-02f,
  7.03682154e-02f, 5.84077276e-02f, -6.98564202e-02f, -1.68476701e-02f, 4.21996787e-02f, 4.91000041e-02f, 1.06966421e-01f, -5.88407628e-02f, -6.51904494e-02f, 8.01433399e-02f,
  8.02538916e-02f, -1.85914971e-02f, 1.18186539e-02f, -1.90121529e-03f, 2.94034127e-02f, 7.16828927e-02f, 8.35649669e-02f, -2.20126025e-02f, -7.82391801e-03f, 6.40538037e-02f,
  4.22331169e-02f, 4.19193245e-02f, 9.27616935e-03f, 1.40829146e-01f, 1.14831030e-02f, -6.02881610e-02f, 5.14949821e-02f, -3.66405770e-02f, -6.34201318e-02f, 1.41725503e-02f,
  8.74422491e-02f, 1.10747404e-01f, 5.56115843e-02f, -1.06170505e-01f, -2.33437754e-02f, 7.15141976e-03f, 4.94261272e-02f, 6.21925741e-02f, 6.62544146e-02f, 8.16400908e-03f,
  4.50102687e-02f, 2.85411403e-02f, 3.20756845e-02f, 2.56642923e-02f, 7.75386095e-02f, 3.60935479e-02f, -3.68812904e-02f, 4.62913699e-02f, 8.66778269e-02f, 1.22126758e-01f,
  1.62767246e-02f, -3.71293500e-02f, -6.38394803e-02f, -9.14330781e-02f, -3.04114595e-02f, 8.87648910e-02f, 5.87914810e-02f, -4.40554619e-02f, -1.82825830e-02f, 4.02478613e-02f,
  -2.33846903e-01f, 1.80445284e-01f, -5.43031842e-02f, -2.68052727e-01f, 9.54439342e-02f, -1.57515764e-01f, -1.48566782e-01f, 1.86866056e-02f, -1.00499026e-01f, -1.80428773e-01f,
  -8.91797394e-02f, -1.23976413e-02f, 1.32362083e-01f, -1.94416255e-01f, -7.03587458e-02f, 1.00291699e-01f, -2.22161517e-01f, -1.35343224e-01f, 1.80704981e-01f, 2.42058467e-02f,
  2.59649903e-02f, -1.10802226e-01f, 5.22384495e-02f, 1.61144212e-01f, -8.41594338e-02f, -7.19140694e-02f, -3.38016637e-02f, 2.54331589e-01f, -4.72570881e-02f, 8.80434513e-02f,
  -1.88559160e-01f, -1.57319278e-01f, -1.49360120e-01f, -9.16606486e-02f, -1.57434568e-01f, -1.17991894e-01f, -2.55671833e-02f, -4.00149357e-03f, 1.01751564e-02f, -9.01503116e-03f,
  -2.20713038e-02f, 7.83857256e-02f, -5.24898097e-02f, -3.04550044e-02f, 5.97851574e-02f, -2.12868657e-02f, 1.20754182e-01f, 2.56169885e-02f, -3.07279057e-03f, 5.52448109e-02f,
  -1.23081161e-02f, -5.76935746e-02f, -1.23594142e-01f, 6.44883048e-03f, -3.62949558e-02f, -4.41185646e-02f, -4.88497019e-02f, -5.90540133e-02f, 3.19266170e-02f, -9.43717584e-02f,
  3.31684388e-02f, 3.52497958e-02f, 8.41713622e-02f, 6.11510035e-03f, 3.13642360e-02f, -3.80079076e-03f, 7.10540172e-03f, 5.93907339e-03f, 7.05558360e-02f, -4.08896198e-03f,
  8.34398437e-03f, -8.41072202e-02f, 6.98720515e-02f, 3.85448374e-02f, 6.12230301e-02f, -6.09269403e-02f, 1.43170869e-02f, 5.05947918e-02f, 5.40040657e-02f, -2.48335432e-02f,
  6.32970855e-02f, 3.81011479e-02f, -9.18797124e-03f, 1.20737590e-02f, 3.54351066e-02f, -2.41997391e-02f, 7.54808560e-02f, -3.13705765e-02f, 4.19375934e-02f, 4.76689599e-02f,
  -6.89209178e-02f, -1.43659234e-01f, -6.09244779e-02f, -5.60610071e-02f, 4.33835648e-02f, -1.01244934e-02f, -4.77242144e-03f, -3.65721481e-03f, -8.51091519e-02f, -9.33338627e-02f,
  -1.01583842e-02f, -1.05186023e-01f, -7.33495653e-02f, 2.46691867e-03f, -3.85661684e-02f, -3.63251427e-03f, 3.94196250e-02f, -7.01600388e-02f, -1.08821228e-01f, 7.44534507e-02f,
  4.09718305e-02f, 2.47217584e-02f, -5.32124527e-02f, -2.26601865e-02f, 2.52452027e-02f, -1.14534140e-01f, -5.92458881e-02f, 1.03002274e-02f, 2.85392180e-02f, -4.24273871e-02f,
  -1.48349982e-02f, -3.27141546e-02f, 2.14201093e-01f, -4.66488185e-04f, 8.40742290e-02f, 1.92520350e-01f, 1.63924530e-01f, -3.81982997e-02f, -1.21868672e-02f, -1.43368259e-01f,
  -1.22906089e-01f, -3.98043990e-02f, 2.17945307e-01f, -1.28159478e-01f, 3.02684367e-01f, 1.17993489e-01f, -6.09703362e-02f, 1.04637034e-02f, 8.70538875e-03f, -1.16317414e-01f,
  -2.06581410e-02f, -2.48075321e-01f, -3.27823684e-02f, -2.10151091e-01f, -1.47823289e-01f, -6.41347766e-02f, -1.83719784e-01f, -3.70885246e-03f, -4.42343764e-02f, 2.97863390e-02f,
  -1.19575977e-01f, -3.77450921e-02f, 7.14374930e-02f, -3.55055928e-02f, -1.14813410e-01f, -2.52978653e-02f, -2.84911264e-02f, -3.22844200e-02f, -1.49819050e-02f, -5.35100922e-02f,
  1.92558151e-02f, 1.80087537e-02f, -8.77155364e-02f, -5.91498651e-02f, -8.31817836e-02f, -8.86946768e-02f, -5.12562059e-02f, 6.84794560e-02f, 2.82315128e-02f, 9.97485518e-02f,
  8.39325786e-02f, -8.61269236e-02f, 1.54100172e-02f, -7.36525133e-02f, 4.68212143e-02f, 3.92271169e-02f, 1.57093778e-02f, 2.11724173e-02f, -5.85078076e-02f, -6.58199489e-02f,
  -7.48654306e-02f, -2.41347253e-02f, -4.40816954e-03f, -8.37941468e-02f, -7.21926093e-02f, -2.60470174e-02f, -1.36266956e-02f, -1.18964342e-02f, 2.51216684e-02f, 7.24134892e-02f,
  -5.74963018e-02f, 6.43479601e-02f, -6.33739606e-02f, 5.02311438e-02f, 3.54367867e-02f, -5.63512892e-02f, -6.74266294e-02f, 2.65156589e-02f, -2.74034757e-02f, -5.61417080e-02f,
  -6.87177554e-02f, 6.86853379e-02f, -2.19372511e-02f, 4.31885496e-02f, 3.96991335e-02f, 4.26687710e-02f, 3.63952033e-02f, -2.20872518e-02f, -7.91117102e-02f, 6.72342405e-02f,
  -9.90284681e-02f, -1.39296427e-01f, 1.89806689e-02f, -8.01265240e-03f, -4.76544723e-02f, -7.31809065e-02f, 9.86774359e-03f, -5.82930744e-02f, 8.59000012e-02f, 7.18392804e-02f,
  -9.04704407e-02f, 4.46525514e-02f, -1.02740563e-01f, -4.80694734e-02f, -7.48542473e-02f, -7.59512410e-02f, -6.22378737e-02f, -9.49181691e-02f, -6.28370494e-02f, 2.18491461e-02f,
  -4.45157699e-02f, -2.47800425e-02f, 8.63222554e-02f, 2.91805286e-02f, -1.25921413e-01f, 3.80970277e-02f, 3.84164378e-02f, 2.95675080e-02f, -2.56014504e-02f, -4.98410910e-02f,
  -9.37784207e-04f, 6.56274185e-02f, -7.08462819e-02f, 1.44159803e-02f, 1.02453707e-02f, 6.33826479e-02f, 2.35430263e-02f, -9.02418420e-02f, 1.19845234e-02f, -2.11033281e-02f,
  5.72668724e-02f, 1.85441338e-02f, -9.26680788e-02f, 4.37012278e-02f, 8.24317511e-04f, 1.96972955e-03f, 1.39459157e-02f, 4.07518074e-02f, 7.50350282e-02f, -4.35487442e-02f,
  2.24679150e-02f, -5.73679544e-02f, -5.78334257e-02f, -6.77175969e-02f, 1.12278154e-02f, 2.25523654e-02f, -2.61251293e-02f, 2.22921278e-02f, 6.50957897e-02f, -6.87904581e-02f,
  -1.44406664e-03f, -4.88721635e-05f, -8.57451111e-02f, 7.75021687e-02f, 2.58940123e-02f, -2.80477293e-02f, 4.55708727e-02f, 1.96000002e-02f, -4.94608423e-03f, -5.05015217e-02f,
  -5.35922199e-02f, -3.55479196e-02f, -5.89177199e-02f, -7.51558170e-02f, -1.08081317e-02f, 2.92178076e-02f, 9.81830209e-02f, -2.71584969e-02f, -9.12543833e-02f, 3.25438529e-02f,
  3.22184898e-02f, 1.26293860e-02f, 5.97973876e-02f, 5.53181879e-02f, 2.45360229e-02f, -6.40790984e-02f, -7.71578327e-02f, 1.93994492e-02f, 4.23480645e-02f, -8.93537421e-03f,
  1.05030658e-02f, 9.03272927e-02f, 2.52363309e-02f, -9.63750780e-02f, 5.74352667e-02f, 6.75223619e-02f, 1.10634780e-02f, 2.57590804e-02f, 4.88088354e-02f, -2.38714349e-02f,
  6.11106493e-02f, 9.90103744e-03f, 2.30013020e-02f, -5.91599196e-02f, -1.96365695e-02f, -2.11526942e-03f, -7.83752054e-02f, 7.19130561e-02f, 9.55389142e-02f, -2.46861801e-02f,
  -8.75225812e-02f, -5.26212417e-02f, -4.42990996e-02f, -4.70263064e-02f, -5.13314940e-02f, 6.39779046e-02f, -4.74546850e-02f, -6.10931627e-02f, -1.08926725e-02f, 4.25325632e-02f,
  -2.77974587e-02f, -6.62140548e-02f, 3.58987749e-02f, -3.76554430e-02f, 4.35832925e-02f, -7.92637244e-02f, -6.50892556e-02f, 3.23116817e-02f, -6.57209009e-02f, -6.40226668e-03f,
  8.77196491e-02f, -5.22883497e-02f, 2.12158207e-02f, -1.71881486e-02f, -5.12377508e-02f, -6.53522983e-02f, 6.76196665e-02f, 5.05430857e-03f, 7.70625249e-02f, 6.54840469e-02f,
  1.33206714e-02f, -4.99267578e-02f, 7.77093992e-02f, 7.56265549e-03f, 7.48562291e-02f, -5.51007465e-02f, -2.03157049e-02f, -7.00551495e-02f, 6.62717372e-02f, -9.15809721e-03f,
  2.54180491e-01f, -4.62140813e-02f, 1.59825519e-01f, 2.80403912e-01f, -6.56431168e-02f, -8.87993127e-02f, 6.08684719e-02f, 3.27772647e-02f, -1.81536488e-02f, -1.94319308e-01f,
  4.87776985e-03f, 9.36465859e-02f, -7.50461221e-02f, 6.15438595e-02f, 1.65906355e-01f, 2.25347150e-02f, 5.01027554e-02f, -5.56160808e-02f, 3.12293395e-02f, 1.01313822e-01f,
  2.31603980e-01f, 6.78023025e-02f, 1.72505990e-01f, -2.19051484e-02f, 7.21281469e-02f, 8.98297429e-02f, 1.10376708e-01f, -6.85449839e-02f, 1.29461721e-01f, -8.58183503e-02f,
  2.60360679e-03f, 4.31447439e-02f, -2.70823035e-02f, 5.10122860e-03f, -1.26130870e-02f, -5.14754280e-02f, -8.84730220e-02f, -4.32430878e-02f, 7.68248364e-02f, 8.60664546e-02f,
  -8.18096697e-02f, 1.41385347e-02f, -5.42336516e-02f, -4.45287861e-02f, 3.63457575e-03f, 5.47051877e-02f, 1.93566382e-02f, 4.28708792e-02f, -6.21050484e-02f, 6.13798611e-02f,
  5.34358285e-02f, -8.23408738e-03f, -4.52504121e-02f, -7.29176775e-03f, 1.08209491e-01f, 1.26409400e-02f, -1.48053011e-02f, 6.07014187e-02f, -2.12818030e-02f, 7.75315762e-02f,
  1.20732248e-01f, -9.28188190e-02f, -5.54376692e-02f, -5.97447753e-02f, -4.34225723e-02f, -5.09017110e-02f, -1.84803270e-02f, -5.14214262e-02f, 6.47878787e-03f, -8.08927491e-02f,
  -1.90600622e-02f, 2.52195261e-02f, -3.68066244e-02f, -1.91501179e-03f, 4.02909964e-02f, 4.06056121e-02f, 1.23667428e-02f, 8.08129273e-03f, -3.00116874e-02f, 1.13865193e-02f,
  4.03540619e-02f, -3.40397917e-02f, 2.42583957e-02f, 4.24586283e-03f, 2.20554601e-02f, -7.19936043e-02f, -6.00846820e-02f, -2.74668951e-02f, 5.11497296e-02f, -1.73633303e-02f,
  -4.79759388e-02f, 1.06852353e-01f, -2.24141567e-03f, -6.16317242e-02f, -7.39361197e-02f, -1.78799536e-02f, -7.86386877e-02f, 5.32804197e-03f, 1.11195713e-01f, 3.83183807e-02f,
  4.13375162e-02f, -4.25323732e-02f, -3.86341177e-02f, -4.67342474e-02f, -7.59051070e-02f, 4.85727564e-02f, -1.08035619e-03f, -6.61186781e-03f, -1.76206212e-02f, 6.83987662e-02f,
  -7.63861649e-03f, -8.62048417e-02f, -1.26074580e-02f, -6.14760369e-02f, -1.37430159e-02f, 1.48333414e-02f, -5.28849401e-02f, -9.03595909e-02f, -9.47871339e-03f, 6.10894524e-02f,
  -1.88925564e-01f, -3.44972395e-05f, 1.98561952e-01f, -3.34383279e-01f, 7.21535506e-03f, 1.73299477e-01f, 1.12744473e-01f, -7.07276762e-02f, -2.58181721e-01f, -1.51134714e-01f,
  -1.11234941e-01f, -1.62055373e-01f, 1.07254989e-01f, -3.22073624e-02f, 1.71238780e-01f, 2.67554969e-01f, -7.98914805e-02f, -7.07510784e-02f, 1.47662461e-01f, 1.78527981e-02f,
  1.20652672e-02f, -3.41648534e-02f, 2.23989084e-01f, 5.67213409e-02f, 2.54161321e-02f, -6.52254373e-02f, -1.12161316e-01f, 5.17807007e-02f, -1.46336958e-01f, 4.74157669e-02f,
  1.49986461e-01f, -1.60999879e-01f, 4.06297818e-02f, 3.01991347e-02f, 3.86509337e-02f, -7.96906054e-02f, 1.48306685e-02f, -1.73240760e-03f, -7.98034221e-02f, 5.94197586e-02f,
  -6.13602549e-02f, 1.96713135e-02f, -1.93660446e-02f, 2.47922577e-02f, -8.63571092e-02f, -8.11768100e-02f, 3.14319097e-02f, 1.00267641e-01f, 5.99101819e-02f, 4.85465899e-02f,
  8.65941122e-02f, 5.67475855e-02f, -6.48292620e-03f, -1.13430940e-01f, -6.30589277e-02f, -1.14385784e-01f, 7.02239051e-02f, 2.61370689e-02f, -4.87524383e-02f, 4.61959951e-02f,
  -2.57942788e-02f, -8.44649039e-03f, 1.52133917e-02f, -6.36757612e-02f, -1.83832664e-02f, -2.04377174e-02f, -3.28740589e-02f, 5.85181527e-02f, -5.57568744e-02f, -5.61309047e-03f,
  -3.42538096e-02f, -3.03102250e-04f, -1.71406511e-02f, -1.86733436e-02f, -6.47889450e-03f, 3.61808166e-02f, -3.63361388e-02f, -5.24923392e-02f, -1.14669651e-03f, 5.53507060e-02f,
  -9.47681144e-02f, -2.69072857e-02f, -2.80312132e-02f, -9.27877054e-02f, -1.27535639e-02f, 1.23669617e-02f, -3.95005867e-02f, 9.38493386e-02f, 1.00595593e-01f, -5.96778281e-03f,
  7.69538879e-02f, -2.23017633e-01f, -6.51850086e-03f, -7.26195574e-02f, -1.05190685e-03f, 2.50951555e-02f, -1.51629737e-02f, 5.58348596e-02f, 4.53945063e-02f, 3.06643452e-02f,
  -3.39174345e-02f, -4.31557633e-02f, 7.63448030e-02f, -3.24264951e-02f, 4.12208103e-02f, 8.96337442e-03f, -3.53224389e-02f, -2.51877438e-02f, -2.92747412e-02f, -2.68713795e-02f,
  8.65913089e-03f, 1.15315607e-02f, -6.46849424e-02f, 2.23929808e-02f, -6.25497028e-02f, -1.31441861e-01f, 1.27891870e-02f, 2.34610550e-02f, -3.67523581e-02f, -7.20949993e-02f,
  3.41831326e-01f, 1.71862524e-02f, 4.88923527e-02f, 4.75497842e-02f, -2.49776710e-02f, -1.18346270e-02f, -1.06255613e-01f, 8.12568143e-03f, 4.78746966e-02f, 7.79440030e-02f,
  -1.47869453e-01f, 1.04145892e-01f, -5.93416719e-03f, 7.09122792e-02f, 9.25437286e-02f, 1.50007224e-02f, -1.25532988e-02f, -2.66292635e-02f, -5.23463860e-02f, 9.46801249e-03f,
  6.25499245e-03f, -6.93177283e-02f, -5.60779907e-02f, 3.82965282e-02f, 1.22386530e-01f, 2.12721918e-02f, -3.83857116e-02f, -1.51148081e-01f, -6.18303902e-02f, -8.89435709e-02f,
  1.59127451e-02f, 4.58953455e-02f, 9.75481272e-02f, 3.37969884e-02f, 3.21938694e-02f, -6.99388906e-02f, -9.91824344e-02f, -7.27204382e-02f, 3.32998522e-02f, -3.13594937e-02f,
  9.83222649e-02f, -4.73305210e-02f, 9.67340320e-02f, 7.01552108e-02f, 1.60746463e-02f, 6.71483427e-02f, -6.58074692e-02f, -7.32296705e-02f, 4.75103557e-02f, -8.41979235e-02f,
  2.67119706e-02f, 5.85071556e-02f, 1.06371182e-04f, 4.22024503e-02f, -4.72360365e-02f, -6.88030645e-02f, -5.34696765e-02f, 1.03447296e-01f, 1.03528373e-01f, 8.05650726e-02f,
  1.02919504e-01f, 5.18012531e-02f, -5.03294654e-02f, -6.65346757e-02f, -2.58940533e-02f, -8.74672756e-02f, 5.75621761e-02f, -1.75689720e-02f, 7.73608908e-02f, -7.39196911e-02f,
  3.36988606e-02f, 7.63412789e-02f, -7.04346523e-02f, 1.92464218e-02f, 8.64219517e-02f, 4.40040678e-02f, -5.42434305e-02f, -3.29855196e-02f, 7.18374327e-02f, 5.72231524e-02f,
  2.52202246e-02f, -4.48946543e-02f, 2.59150658e-02f, -4.81129959e-02f, -1.15968920e-01f, -2.04270352e-02f, -3.10450625e-02f, -9.05393343e-03f, -1.09220102e-01f, 4.49311584e-02f,
  5.61679751e-02f, -3.29474695e-02f, 9.88149643e-02f, -7.40233362e-02f, -6.27784580e-02f, 4.85369489e-02f, 2.24901251e-02f, -4.18036804e-02f, -6.05448186e-02f, -5.25235496e-02f,
  9.71533507e-02f, -3.95232551e-02f, 9.27332044e-02f, 8.29965547e-02f, -4.36012372e-02f, 9.08100009e-02f, -1.58749381e-03f, -7.94668496e-02f, 1.03691407e-01f, -2.46076267e-02f,
  -2.26723012e-02f, -3.15313190e-02f, 7.24891871e-02f, 4.96205837e-02f, -4.69429940e-02f, 2.83652805e-02f, -3.01153343e-02f, -5.92556074e-02f, 2.94268839e-02f, -8.25074594e-03f,
  -1.32822365e-01f, 9.03046206e-02f, -1.69299275e-01f, 4.92567476e-03f, -3.06005925e-02f, 2.05089509e-01f, 2.68299848e-01f, 7.53151253e-02f, 1.26081586e-01f, 3.19447488e-01f,
  1.44062683e-01f, 8.08334202e-02f, 7.61303604e-02f, 1.82368159e-01f, 1.27121001e-01f, 5.70671596e-02f, 2.46179536e-01f, 2.21121371e-01f, -7.29405880e-02f, 6.40087426e-02f,
  -9.75205675e-02f, 1.13187864e-01f, -8.00101012e-02f, -1.54088177e-02f, -5.35125099e-02f, -1.01522572e-01f, 4.03194577e-02f, -1.35084540e-01f, 1.00675821e-01f, 6.22564554e-02f,
  -1.08625144e-02f, -7.08493516e-02f, 5.05409949e-03f, -8.48334432e-02f, -4.61088866e-02f, 6.72453409e-03f, 3.30025181e-02f, 7.41718151e-03f, -1.08299024e-01f, 5.06449267e-02f,
  -2.68144230e-03f, -7.40534738e-02f, 5.61546907e-02f, -3.62727270e-02f, 3.61952595e-02f, -8.11216049e-03f, 1.69572304e-03f, -4.18440290e-02f, 4.36906843e-03f, -1.45049868e-02f,
  -1.21019587e-01f, 5.36917858e-02f, -7.36694857e-02f, -1.65356509e-02f, -2.54023988e-02f, 1.69608276e-02f, 8.56796652e-02f, 4.70506027e-03f, -3.76439802e-02f, -6.16761521e-02f,
  1.00782484e-01f, -4.95277643e-02f, 1.76013708e-02f, 5.54686487e-02f, -1.90471597e-02f, -4.59795147e-02f, 8.53439560e-04f, 2.57478859e-02f, 2.71978620e-02f, 5.70425428e-02f,
  -5.40427975e-02f, -6.27922490e-02f, 9.90376156e-03f, 7.11719245e-02f, 2.97512580e-02f, 5.99288605e-02f, -1.08329900e-01f, -1.21133374e-02f, -7.12122992e-02f, -7.10054114e-02f,
  -3.24309580e-02f, 7.89323300e-02f, -4.29366492e-02f, -5.00769950e-02f, -7.21411481e-02f, 3.00072450e-02f, -1.24293976e-02f, 3.36633176e-02f, 3.49283703e-02f, -5.82473166e-02f,
  2.04534903e-01f, 1.82588503e-01f, 9.46688093e-03f, -9.02819112e-02f, 6.34333044e-02f, 7.02436920e-03f, -1.93134304e-02f, -7.18870312e-02f, -1.31693836e-02f, -5.81007078e-02f,
  -2.83987932e-02f, 2.75051836e-02f, 6.83686435e-02f, 5.34959324e-02f, -1.56831983e-02f, -7.62912212e-03f, -1.39495404e-02f, -2.53590364e-02f, 1.39954910e-01f, 1.80676728e-02f,
  4.12459709e-02f, 9.40534323e-02f, 1.98054053e-02f, -2.22779475e-02f, -2.38939580e-02f, 5.79163656e-02f, 5.06419912e-02f, -3.98272723e-02f, -3.84204537e-02f, 4.04261537e-02f,
  1.08893119e-01f, -2.06630267e-02f, 7.13961944e-02f, 2.33417526e-01f, 4.14072499e-02f, -1.06619326e-02f, 1.62746340e-01f, 1.30660877e-01f, 4.49289203e-01f, -2.47885332e-01f,
  -1.32877082e-01f, -3.61955278e-02f, -1.06287897e-01f, -5.83648942e-02f, 2.09907860e-01f, 1.27990440e-01f, 9.42912698e-02f, 6.39081448e-02f, 2.14081928e-01f, -1.85098983e-02f,
  1.20981961e-01f, -1.61476329e-01f, -1.76470086e-01f, -2.58984596e-01f, -2.13074744e-01f, -9.99612734e-02f, -2.91182101e-01f, 4.49993797e-02f, -2.35450953e-01f, 8.17159787e-02f,
  6.32653711e-03f, 2.74017937e-02f, 5.01676276e-03f, -6.38160706e-02f, 1.76078000e-03f, 2.22111773e-02f, 2.95425411e-02f, 2.78398097e-02f, 1.52785927e-01f, 3.72239798e-02f,
  5.82705587e-02f, -2.28616223e-02f, 4.37858701e-02f, 3.37257609e-02f, 4.03984748e-02f, -9.85727385e-02f, -2.30896492e-02f, 4.43048850e-02f, -1.16036758e-02f, -2.54519371e-04f,
  -4.05966584e-03f, -4.82642129e-02f, -7.18653086e-04f, -1.92643180e-02f, 2.03784611e-02f, 6.71105310e-02f, -5.28554134e-02f, -2.35219067e-03f, -2.47199051e-02f, 3.35668810e-02f,
  -1.72201428e-03f, 3.95376459e-02f, -6.02403171e-02f, -1.23732453e-02f, -2.70836633e-02f, -8.36825743e-02f, 1.08361077e-02f, -4.98806387e-02f, 6.06516935e-02f, -4.11139466e-02f,
  3.39239389e-02f, 2.84562968e-02f, 2.84123570e-02f, 1.65890604e-02f, -2.51639560e-02f, 1.87495444e-02f, -3.86321954e-02f, -1.25229713e-02f, -8.78969301e-03f, -1.06117129e-01f,
  -5.69808632e-02f, 9.48436335e-02f, -1.10625431e-01f, -2.61650234e-03f, -7.53642712e-03f, -2.98139919e-02f, -6.24151081e-02f, -5.14642708e-02f, 4.45445292e-02f, -2.76571047e-02f,
  1.13069132e-01f, 1.75290436e-01f, -2.60575581e-03f, -6.71178401e-02f, 1.47604635e-02f, -8.60260725e-02f, 8.53716433e-02f, -3.44742090e-02f, 4.10690345e-02f, -8.68378859e-03f,
  -5.93496114e-02f, -3.04195774e-03f, -4.57745828e-02f, 4.10607010e-02f, 2.87175868e-02f, -4.79819663e-02f, 6.36146739e-02f, -8.54022976e-04f, 5.36197871e-02f, -7.01542944e-02f,
  -2.33605597e-02f, -2.38626357e-03f, -8.54720455e-03f, -5.45618609e-02f, -3.23181972e-02f, -4.18510102e-02f, 5.50090484e-02f, 4.94864397e-02f, -1.04531817e-01f, 1.05763473e-01f,
  1.99108645e-01f, -7.30995163e-02f, 1.15851080e-02f, -4.14902437e-03f, 4.78349924e-02f, 1.22200012e-01f, 1.26955673e-01f, 3.45136272e-03f, 2.32566684e-01f, -8.68303776e-02f,
  3.50011364e-02f, -1.20366074e-01f, -1.04322441e-01f, 3.10801379e-02f, -4.09329943e-02f, -4.94028963e-02f, 1.41760319e-01f, -1.95374861e-02f, 7.84748346e-02f, -4.14376445e-02f,
  7.95570686e-02f, -1.45496679e-02f, -6.69401959e-02f, -1.41843185e-01f, 9.47009474e-02f, -1.96971428e-02f, -7.13837668e-02f, -1.90708768e-02f, -1.08280957e-01f, -8.16802867e-03f,
  6.95299134e-02f, 8.30441564e-02f, -5.50330034e-04f, 1.60204805e-02f, -3.02630328e-02f, 1.28419967e-02f, -5.22729941e-02f, -1.24366820e-01f, -1.18978508e-01f, -5.91124780e-02f,
  6.57358617e-02f, -5.36860228e-02f, 4.85908613e-02f, -2.62863170e-02f, -7.10756034e-02f, -2.52171494e-02f, -2.97034793e-02f, -5.85232303e-02f, -4.09214199e-02f, -5.47137298e-02f,
  -6.91429377e-02f, -1.77946070e-03f, 8.10889974e-02f, -7.65497386e-02f, 1.78625789e-02f, 7.85381645e-02f, -2.77166460e-02f, -5.84036447e-02f, 3.51693071e-02f, 1.52283376e-02f,
  -7.13145286e-02f, -4.21059318e-02f, 5.08943535e-02f, -1.64395049e-02f, -5.24908602e-02f, -2.00957898e-02f, -8.05699602e-02f, 3.71708977e-03f, -5.39890267e-02f, 5.73105030e-02f,
  -3.10789105e-02f, -2.90816557e-02f, -4.41895351e-02f, -5.09551838e-02f, 6.59888089e-02f, -2.48766877e-02f, -4.29100730e-02f, -6.08926676e-02f, 4.92091477e-02f, 4.01206650e-02f,
  7.93147385e-02f, -4.30731289e-02f, 2.57063797e-03f, 1.10408636e-02f, -4.19600718e-02f, -5.18319719e-02f, -6.05781712e-02f, -9.16552618e-02f, 4.90233898e-02f, -2.08276510e-02f,
  2.77055018e-02f, 1.47197902e-01f, -1.01894684e-01f, 2.03320440e-02f, -3.47799286e-02f, 3.54689695e-02f, 6.00267090e-02f, 5.41416779e-02f, 9.32927281e-02f, -1.78526063e-02f,
  -6.49355352e-02f, -7.83202499e-02f, 3.16904411e-02f, 3.31954136e-02f, -8.96513835e-02f, -2.88456995e-02f, -7.99777955e-02f, 5.52755520e-02f, -8.15186128e-02f, -6.26036897e-02f,
  -4.86768037e-02f, 2.35065836e-02f, -1.85118429e-02f, -2.75092460e-02f, -2.91582253e-02f, 2.47771554e-02f, -1.63329765e-03f, -9.46953297e-02f, 2.99648382e-02f, -4.57232411e-04f,
  -9.08725858e-02f, -7.42682889e-02f, -8.16229433e-02f, -1.22786075e-01f, 1.18792892e-01f, -5.93011789e-02f, -2.62435470e-02f, 1.31083792e-02f, 5.29154129e-02f, 9.29074883e-02f,
  7.33046904e-02f, -1.90349147e-01f, 2.62749083e-02f, -1.04072765e-01f, -2.60450274e-01f, -1.15249746e-01f, -5.91126084e-02f, -7.51367211e-02f, -6.98853582e-02f, -1.77776963e-02f,
  -1.00395069e-01f, -3.01114041e-02f, -1.56408623e-01f, 3.00954375e-02f, 8.60575959e-02f, 5.19824438e-02f, 8.73659924e-02f, 1.71146784e-02f, 4.52679098e-02f, -4.69773300e-02f,
  8.37697685e-02f, -6.50705993e-02f, 4.20421064e-02f, 1.06851896e-02f, 4.90762517e-02f, 1.12916626e-01f, -7.72508159e-02f, -7.45607466e-02f, 7.49217346e-02f, 1.54807065e-02f,
  -3.28350998e-02f, -6.62388578e-02f, -4.13757525e-02f, 1.62838269e-02f, 7.17852935e-02f, 6.67395294e-02f, -1.60804740e-03f, 6.70150369e-02f, 1.98085494e-02f, -6.05154671e-02f,
  -8.96682404e-03f, -6.13649338e-02f, 7.82609656e-02f, -3.47398338e-04f, 2.14807503e-02f, -1.01589851e-01f, -9.21836793e-02f, -3.74264047e-02f, -6.32949546e-02f, 1.83089767e-02f,
  -5.22606000e-02f, 9.50931236e-02f, 2.88865585e-02f, 6.82926774e-02f, 5.57978414e-02f, -3.25674042e-02f, 2.66798376e-03f, 2.32799780e-02f, 7.56950257e-03f, -1.47581585e-02f,
  -9.56337340e-03f, -3.01372595e-02f, -2.54712310e-02f, -1.79991443e-02f, -4.61926945e-02f, -6.56070262e-02f, 3.72395031e-02f, -9.32160169e-02f, 5.43752313e-02f, 2.39952374e-02f,
  6.89381883e-02f, -6.21014833e-02f, 7.19857141e-02f, -6.04959987e-02f, -5.28098419e-02f, -1.35566080e-02f, -5.77545501e-02f, -3.67783234e-02f, -1.60118900e-02f, 9.93751287e-02f,
  7.49734640e-02f, -1.07726976e-01f, -1.64088216e-02f, -1.37710394e-02f, 1.30612245e-02f, -6.29101461e-03f, 9.70346574e-03f, 3.04312855e-02f, -7.05233067e-02f, 1.78386308e-02f,
  -3.81694059e-03f, 8.41638297e-02f, 6.91551119e-02f, -1.67326126e-02f, 7.11092306e-03f, 7.02253878e-02f, -3.73863988e-02f, -2.50566006e-02f, 8.30507353e-02f, -3.71083245e-03f,
  -6.61951825e-02f, -2.86262110e-03f, -8.31741933e-03f, -4.57313284e-03f, -7.42592849e-03f, 6.67027310e-02f, 2.02401485e-02f, 2.85258051e-02f, -8.45531672e-02f, 2.56703552e-02f,
  -1.87120333e-01f, -7.14751184e-02f, -8.09601098e-02f, -1.46973908e-01f, -5.44349104e-02f, 6.93078712e-02f, -8.88893381e-02f, 3.51307020e-02f, -1.50330976e-01f, -1.16650097e-01f,
  -4.30236943e-02f, -1.01065457e-01f, 8.01485777e-02f, -9.45390016e-03f, -1.69949383e-02f, 2.69298069e-02f, -6.47286996e-02f, -8.78343135e-02f, 8.22085142e-02f, 1.38481995e-02f,
  6.53888509e-02f, 4.81530875e-02f, 1.36706784e-01f, 5.92462271e-02f, -1.13421075e-01f, 2.28049699e-02f, 6.13458157e-02f, -2.24667322e-02f, 3.37756760e-02f, 1.06929384e-01f,
  -5.04868887e-02f, -1.06848650e-01f, -1.49444073e-01f, -9.89572778e-02f, -9.59649775e-03f, -9.25224796e-02f, 3.23511772e-02f, 3.24601051e-03f, -1.25308903e-02f, -1.76802501e-02f,
  1.55856507e-02f, -6.60072863e-02f, -3.59805822e-02f, -7.88713470e-02f, 4.82960716e-02f, 6.84031397e-02f, 1.44874621e-02f, -7.40807950e-02f, 2.07145996e-02f, 6.47061989e-02f,
  -4.81177270e-02f, 9.01127756e-02f, -2.48391479e-02f, 4.04446423e-02f, -1.10767204e-02f, 6.81543052e-02f, 1.27292778e-02f, 6.19123280e-02f, -7.51999095e-02f, 1.17770908e-02f,
  5.84827065e-02f, 5.32663018e-02f, -4.93661016e-02f, -2.92684678e-02f, -6.99184611e-02f, -9.76966880e-03f, -7.39108175e-02f, -4.85690981e-02f, 1.13023482e-02f, 2.88789999e-02f,
  -3.43931466e-02f, -3.78703475e-02f, 7.02579170e-02f, 2.55648904e-02f, 1.96771566e-02f, 4.04123478e-02f, 7.68288225e-02f, -5.07799461e-02f, -4.79644910e-02f, 8.91661793e-02f,
  7.56378695e-02f, 2.80261431e-02f, -1.79032180e-02f, -6.91234916e-02f, -3.06684338e-02f, -6.41968334e-04f, -9.16247368e-02f, -9.55505148e-02f, -5.97662777e-02f, -1.94320828e-02f,
  -1.49820372e-01f, -1.71319708e-01f, 2.60607935e-02f, -7.75816739e-02f, -5.52847125e-02f, -9.56646353e-02f, 2.30872501e-02f, -7.23176673e-02f, 2.05557849e-02f, -1.10219583e-01f,
  2.73426585e-02f, -2.66105998e-02f, -6.52493387e-02f, 7.99501222e-03f, 6.74060956e-02f, 7.22914562e-02f, -8.97544175e-02f, -1.03801482e-04f, -6.71607628e-02f, -7.60412291e-02f,
  -4.71965633e-02f, -6.97501972e-02f, 5.41178845e-02f, -3.05419434e-02f, 1.07602263e-02f, 3.37868370e-02f, 7.99733587e-03f, -6.09058840e-03f, 5.09758368e-02f, -3.47571098e-03f,
  7.56967515e-02f, 9.60808843e-02f, 9.93365794e-02f, 1.69098638e-02f, -8.51517618e-02f, 1.08391844e-01f, 8.33377615e-02f, 3.79291624e-02f, 4.60957848e-02f, 4.08796147e-02f,
  -6.43320456e-02f, 8.00477266e-02f, 9.35544670e-02f, -3.91583657e-03f, -5.00758961e-02f, 7.95006454e-02f, 5.12199886e-02f, 1.01495884e-01f, 6.14295602e-02f, -7.50514306e-03f,
  -2.06368752e-02f, -1.50682986e-01f, 5.51454648e-02f, -1.31512165e-01f, -1.26873106e-01f, -7.58347139e-02f, -2.04657555e-01f, -4.36820462e-02f, 2.63776202e-02f, -6.15070909e-02f,
  8.60292539e-02f, 3.24071608e-02f, 1.06407031e-01f, 2.37722397e-02f, 5.81525378e-02f, -7.81204030e-02f, -3.61137907e-03f, 8.80382732e-02f, 7.95856789e-02f, 6.49842620e-02f,
  -6.67905509e-02f, 5.74614443e-02f, 7.43811280e-02f, -1.31910304e-02f, -6.34104535e-02f, -6.13373108e-02f, 6.03645891e-02f, 3.17912698e-02f, 9.20028910e-02f, -9.18456614e-02f,
  1.03160575e-01f, 8.01801980e-02f, 3.27378837e-03f, -6.93628937e-03f, -2.92621407e-04f, -1.95548078e-03f, 8.98646712e-02f, 9.67267677e-02f, 9.24372748e-02f, -1.28234942e-02f,
  -6.39599636e-02f, 1.09498642e-01f, 1.49568403e-02f, -1.17799034e-02f, 2.79637128e-02f, -2.96357088e-02f, -7.75102600e-02f, -1.84972771e-02f, 7.21344501e-02f, -2.62189656e-02f,
  4.61384319e-02f, -5.00513501e-02f, 1.71453040e-02f, 4.23691422e-02f, -6.69107288e-02f, -2.35792622e-02f, 2.20339056e-02f, -4.11636345e-02f, 4.04655654e-03f, -5.10694236e-02f,
  4.15476272e-04f, 2.91270278e-02f, -7.90013447e-02f, -7.31457695e-02f, -1.22450280e-03f, -2.46533733e-02f, -5.21713421e-02f, -5.41728549e-02f, 5.18430956e-02f, -1.92181151e-02f,
  1.33440137e-01f, 9.51361582e-02f, 6.32838830e-02f, 1.42705038e-01f, 9.89010036e-02f, -3.64194368e-03f, 2.69773286e-02f, -6.64702430e-02f, 1.14544906e-01f, 9.18239076e-03f,
  -3.59467529e-02f, -2.07726751e-02f, -3.51485014e-02f, -7.50845997e-03f, 6.25788346e-02f, 2.50530876e-02f, -1.35890478e-02f, 7.35880947e-03f, 4.91494946e-02f, -9.52971578e-02f,
  8.11871979e-03f, 1.05386451e-02f, 8.49396214e-02f, -4.08192314e-02f, -6.37324825e-02f, -6.42408207e-02f, -1.17924837e-02f, -3.14442813e-02f, 2.68846806e-02f, 4.23319302e-02f,
  -6.43281117e-02f, 1.17500953e-01f, -1.51527107e-01f, 1.39793247e-01f, -1.85249850e-01f, -1.86578017e-02f, -9.00056586e-03f, 6.54150173e-02f, 6.94578588e-02f, 2.19576150e-01f,
  1.79710299e-01f, 2.23559700e-02f, 4.12173532e-02f, 4.15840387e-01f, 1.68352813e-01f, 8.36075768e-02f, 3.09761375e-01f, 2.48967513e-01f, 5.47191463e-02f, 5.93130775e-02f,
  2.84309592e-02f, 2.11490884e-01f, 1.38450623e-01f, 8.87597799e-02f, -2.42156405e-02f, 1.32170757e-02f, 2.06006709e-02f, -1.75992355e-01f, 2.09447891e-01f, 5.53975701e-02f,
  8.97020549e-02f, -1.84063651e-02f, -7.21048564e-02f, -2.65819635e-02f, -3.44980471e-02f, -9.34417844e-02f, -5.86751364e-02f, -5.91130853e-02f, -5.65774329e-02f, 4.63906582e-03f,
  -8.58201608e-02f, -5.10739572e-02f, 2.23520324e-02f, -4.79461551e-02f, 1.42662795e-02f, -6.76888376e-02f, -5.02728894e-02f, -2.64463462e-02f, -4.88815419e-02f, -7.08763674e-02f,
  -2.03656014e-02f, -5.18990234e-02f, -5.11602545e-03f, -2.51990445e-02f, 4.57069390e-02f, -2.18891408e-02f, 1.99943371e-02f, -4.04365212e-02f, 1.07466197e-02f, 4.20083478e-02f,
  -6.15211017e-02f, 3.62231815e-03f, -6.05780492e-03f, -2.84931418e-02f, -5.19409887e-02f, -2.65017748e-02f, 4.05218918e-03f, 6.87513221e-03f, 2.47990433e-03f, -8.70524812e-03f,
  2.39052381e-02f, -2.36843787e-02f, -4.69283462e-02f, 3.60042341e-02f, -3.46064046e-02f, -3.06232669e-03f, 3.95359732e-02f, 3.04172412e-02f, -2.76014004e-02f, 5.87633327e-02f,
  5.48065603e-02f, -7.17172399e-02f, -2.99208630e-02f, 6.06864430e-02f, 3.30202729e-02f, -3.63190137e-02f, 4.75760959e-02f, -5.70285246e-02f, 4.33652923e-02f, -6.50108680e-02f,
  6.19533323e-02f, 2.34371632e-01f, -3.17602158e-02f, -5.98874092e-02f, -4.74331975e-02f, -7.04540983e-02f, 6.83116615e-02f, 7.32804164e-02f, 1.12760358e-01f, 3.72351669e-02f,
  -6.32576644e-02f, 4.64991219e-02f, -6.56653643e-02f, 9.22323298e-03f, 1.16050197e-02f, 1.20395166e-03f, 3.66435759e-02f, 1.34023987e-02f, 8.75166059e-02f, 8.36809538e-03f,
  5.18336985e-03f, -5.53089231e-02f, -2.31725369e-02f, 2.49224920e-02f, 9.64904353e-02f, 3.58135030e-02f, -3.22830603e-02f, -3.25172511e-03f, 6.49919957e-02f, 1.55294156e-02f,
  1.18599318e-01f, 4.82746027e-03f, -8.48820508e-02f, -9.26618502e-02f, -2.25072987e-02f, 4.10970449e-02f, -6.69917166e-02f, -1.36802465e-01f, -1.23867951e-01f, 3.66531201e-02f,
  -4.21391288e-03f, 6.17072396e-02f, -3.48305181e-02f, 4.63645682e-02f, 4.39838972e-03f, 1.01564489e-02f, 4.16122675e-02f, 7.39849284e-02f, -6.23584446e-03f, 3.10865454e-02f,
  5.46700582e-02f, 8.73833820e-02f, 5.58103435e-02f, -5.09365201e-02f, -4.52966429e-02f, -7.20528364e-02f, 1.23214751e-01f, -3.08594201e-03f, -1.00853026e-01f, 8.74457136e-03f,
  7.92037696e-02f, 2.53949203e-02f, -2.27034297e-02f, -7.68073276e-02f, 8.74869153e-02f, -3.48960236e-02f, 8.24668705e-02f, -1.18831685e-03f, 1.87439695e-02f, 6.87943101e-02f,
  4.31367941e-02f, -2.86270007e-02f, 4.69563249e-03f, -7.76387751e-02f, -9.97885242e-02f, -4.16766526e-03f, -5.72230294e-02f, -4.72142920e-02f, -7.26691186e-02f, -6.06704764e-02f,
  -1.30212205e-02f, -1.53527046e-02f, -1.09253265e-01f, 6.25114962e-02f, 1.11982673e-02f, -8.62619355e-02f, -3.53762507e-02f, -2.57741716e-02f, -5.61040901e-02f, 4.41047437e-02f,
  7.59286210e-02f, 2.70525664e-02f, -5.09204865e-02f, 6.71383888e-02f, -2.27520373e-02f, -4.50076209e-03f, -8.96733403e-02f, -5.04411198e-03f, -4.41329330e-02f, 6.20286465e-02f,
  -3.93041968e-02f, 7.31414631e-02f, 2.78710411e-03f, -6.56058267e-02f, -2.87901070e-02f, 1.34715587e-02f, -2.99932808e-02f, 2.09885072e-02f, 9.35499184e-03f, 1.75262727e-02f,
  -2.50172913e-02f, -4.47489209e-02f, 5.07212849e-03f, -9.01350901e-02f, 2.28890255e-02f, -1.63754765e-02f, 3.57933342e-02f, -1.73675995e-02f, -9.03100222e-02f, -5.01929782e-02f,
  3.07371970e-02f, -3.25661153e-02f, -1.15486160e-01f, 5.18566668e-02f, 8.31146687e-02f, 1.04222529e-01f, 2.32601669e-02f, -5.41651174e-02f, 3.88885513e-02f, 3.14218216e-02f,
  -6.30319044e-02f, 6.12548850e-02f, 3.55500579e-02f, 4.66955267e-02f, 4.37429082e-03f, 5.80650344e-02f, -3.25545780e-02f, -2.82640848e-02f, 1.64902397e-02f, 1.01791732e-02f,
  -3.50984186e-03f, 2.68776417e-02f, 6.53198585e-02f, 4.28108908e-02f, -3.26052718e-02f, 2.24220008e-03f, -3.54181752e-02f, 3.41061293e-03f, 9.27890837e-03f, -9.45621133e-02f,
  -5.32364398e-02f, -6.34047315e-02f, -6.42461553e-02f, -1.72819141e-02f, -1.89107478e-01f, 3.41970772e-02f, 1.04474291e-01f, -1.15441293e-01f, 5.70578352e-02f, 1.13031834e-01f,
  6.73728511e-02f, 3.11089996e-02f, 2.28394553e-01f, 5.30086979e-02f, 5.65406829e-02f, 1.99670389e-01f, 1.12714864e-01f, 6.58104867e-02f, -1.43228561e-01f, -1.44284749e-02f,
  -1.73890404e-02f, -8.55647326e-02f, 1.32931350e-02f, -1.92225501e-01f, -1.08666532e-02f, -6.44422099e-02f, -1.37440532e-01f, -4.60467339e-02f, -1.38711676e-01f, -8.77595842e-02f,
  -1.10274933e-01f, 3.35407034e-02f, -1.06577434e-01f, -3.51541676e-02f, -8.12824890e-02f, -2.87954938e-02f, -1.11190462e-02f, -5.87548725e-02f, 2.60879975e-02f, 2.50006448e-02f,
  8.10581744e-02f, -7.63780996e-02f, -4.67114970e-02f, 1.11457435e-02f, 4.94035482e-02f, -9.93614942e-02f, -5.70161194e-02f, -1.95143968e-02f, -2.44367830e-02f, -4.28124517e-02f,
  3.45980376e-02f, -4.30897400e-02f, 4.06322218e-02f, 3.47877666e-02f, -6.57523572e-02f, -9.96027440e-02f, -5.65354414e-02f, 3.13469768e-02f, -5.65605983e-02f, 1.86148509e-02f,
  6.63043931e-02f, -6.61765933e-02f, 5.72074056e-02f, 5.37054278e-02f, -6.58758804e-02f, 6.08213693e-02f, 6.45058602e-02f, -6.82655200e-02f, -9.74259526e-03f, -6.16707504e-02f,
  -7.41717294e-02f, -7.26879016e-02f, -7.44204968e-02f, -6.62288591e-02f, 2.10873410e-02f, 9.53048468e-02f, -1.89525951e-02f, -7.20284507e-02f, 7.18259215e-02f, -3.34577373e-04f,
  4.91822399e-02f, -7.87546113e-02f, -3.47444415e-02f, -8.24111775e-02f, 7.30062351e-02f, -4.20315862e-02f, 2.39662863e-02f, 1.31023094e-01f, 1.38291074e-02f, -6.79526553e-02f,
  -3.26514505e-02f, -1.10441618e-01f, -8.50431547e-02f, -1.05704412e-01f, -5.25952466e-02f, -4.10403609e-02f, -9.60206613e-02f, 3.85220982e-02f, -2.19553337e-02f, -5.49055776e-03f,
  -3.98837728e-03f, -1.88104715e-02f, -9.98970941e-02f, 4.30417024e-02f, 7.11440071e-02f, -1.79338288e-02f, -3.07530519e-02f, -5.93943261e-02f, -1.97611153e-02f, 1.24102002e-02f,
  3.83118242e-02f, -1.49907675e-02f, 5.99696934e-02f, 1.11095365e-02f, -2.01827846e-03f, 3.51735838e-02f, 5.66744357e-02f, -2.98886169e-02f, 9.97618865e-03f, 4.33672108e-02f,
  2.71272987e-01f, 2.97928810e-01f, 2.37829283e-01f, 3.30529839e-01f, -9.51063409e-02f, -2.61365354e-01f, -1.54882902e-02f, 1.15651404e-02f, 1.95133194e-01f, -1.19047184e-02f,
  -9.36269611e-02f, 2.46020153e-01f, -1.29627939e-02f, 1.55070707e-01f, -1.89779565e-01f, -2.01114073e-01f, 1.05238101e-02f, 2.52311677e-03f, 2.96478085e-02f, 1.64957806e-01f,
  -6.93420395e-02f, -7.33401254e-02f, -7.16302218e-03f, -1.52630940e-01f, 1.30423769e-01f, 2.11476073e-01f, -3.35629620e-02f, -3.88218984e-02f, 1.52873069e-01f, -1.14131846e-01f,
  -1.77832767e-02f, 6.53589964e-02f, 6.48245364e-02f, 8.30183104e-02f, -2.95100529e-02f, 5.92497960e-02f, -7.05180224e-03f, 1.87642518e-02f, -1.17553547e-01f, 7.98505917e-02f,
  -2.08705720e-02f, 2.90848836e-02f, -6.99169934e-02f, 3.87495458e-02f, 7.06872419e-02f, 1.05304413e-01f, 8.91386941e-02f, 7.70454109e-02f, 1.08206972e-01f, 2.24842634e-02f,
  6.63457811e-02f, 3.31081599e-02f, 3.63552198e-02f, 2.52328385e-02f, 9.40314755e-02f, 2.50456738e-03f, -6.53337836e-02f, -2.48404816e-02f, 7.80665278e-02f, 5.23160920e-02f,
  -1.50288552e-05f, -3.69671360e-02f, 6.99396580e-02f, 4.98977341e-02f, -1.14876470e-02f, 7.01878686e-03f, -3.99587229e-02f, -5.56582510e-02f, -7.57618397e-02f, -1.10717580e-01f,
  -1.02895953e-01f, 6.53420314e-02f, -3.71302627e-02f, -5.79934120e-02f, -1.81992967e-02f, 1.14661932e-01f, -5.29312305e-02f, -2.73545031e-02f, -3.20688300e-02f, 1.47306975e-02f,
  2.41150595e-02f, -5.62313870e-02f, -3.69689539e-02f, -3.09048872e-03f, -8.90372470e-02f, 3.87238339e-02f, 1.04184739e-01f, 1.01428583e-01f, -5.12050232e-03f, -1.00461639e-01f,
  -1.64558887e-01f, 6.50597960e-02f, 1.08444942e-02f, 2.85974573e-02f, -3.17589678e-02f, 1.38500948e-02f, 4.29842547e-02f, 3.93032935e-03f, 3.53785530e-02f, -1.12800477e-02f,
  2.23277211e-02f, -6.31055562e-03f, -1.86416265e-02f, 3.80419120e-02f, -1.69352144e-02f, -4.80258279e-02f, 3.20000909e-02f, -6.23830445e-02f, -6.98969364e-02f, 9.14991871e-02f,
  -2.85154488e-02f, -7.72824185e-03f, -8.86110589e-02f, -3.23592797e-02f, -5.60536943e-02f, -4.35597487e-02f, 9.83288959e-02f, 6.20142221e-02f, -3.13040391e-02f, 1.02918372e-02f,
  4.26984718e-03f, 1.15270233e-02f, -1.23607993e-01f, 7.77593330e-02f, -5.42215370e-02f, -7.91985989e-02f, -1.48542985e-01f, 3.52157205e-02f, -6.44600093e-02f, 1.44660315e-02f,
  1.19790263e-01f, 6.10941835e-02f, 5.27761877e-02f, 3.70491832e-03f, -8.03654194e-02f, 2.28585899e-02f, -1.15564689e-01f, 7.19193229e-03f, -1.34789664e-02f, -9.10171941e-02f,
  7.95435812e-03f, 3.06145232e-02f, 3.26789096e-02f, 7.82728866e-02f, 8.01698491e-02f, 5.59129752e-02f, -3.18300421e-03f, -1.40337227e-02f, 9.09669697e-02f, 6.00928925e-02f,
  -9.20294151e-02f, 2.89035402e-02f, -3.03674284e-02f, -3.64376977e-02f, -1.18608223e-02f, 2.63720602e-02f, -6.49099797e-03f, -5.26209585e-02f, 6.37178794e-02f, -8.76314938e-02f,
  3.37695479e-02f, 7.69225582e-02f, 3.56439315e-02f, 6.39112592e-02f, -1.13847673e-01f, 5.27281985e-02f, 9.27403718e-02f, 4.73629832e-02f, -4.64815693e-03f, 1.72113590e-02f,
  7.79088140e-02f, -2.57156156e-02f, 8.57879072e-02f, -5.73402382e-02f, -3.34104970e-02f, 3.92442085e-02f, 1.54328346e-02f, -5.07436693e-02f, 2.10002661e-02f, 6.95031658e-02f,
  8.60745907e-02f, 4.56897775e-03f, 7.50361010e-02f, 2.56501157e-02f, 1.31844034e-04f, -2.14695036e-02f, -1.94552802e-02f, -8.13395232e-02f, -2.14953814e-03f, 1.52618391e-02f,
  -6.14353046e-02f, 6.61776066e-02f, 5.50142862e-02f, -8.96736607e-02f, 6.94112182e-02f, -6.73849210e-02f, -2.93268990e-02f, 4.62318361e-02f, -7.67418146e-02f, -3.47741880e-02f,
  7.12617207e-03f, -6.09766766e-02f, 8.43822509e-02f, -7.16098174e-02f, 7.60031193e-02f, 4.18429598e-02f, -7.59916008e-03f, 2.06252281e-02f, -1.22946622e-02f, 4.21271063e-02f,
  -1.06201634e-01f, 5.97822256e-02f, -6.78870454e-02f, 3.45454738e-02f, -3.73917669e-02f, 4.98658121e-02f, 8.56442004e-02f, -5.72921075e-02f, 1.10244751e-02f, -7.28731677e-02f,
  -5.78243099e-02f, -6.09518997e-02f, -5.83586544e-02f, 5.32992817e-02f, -5.37952483e-02f, -3.34950201e-02f, 6.84985220e-02f, 8.17223564e-02f, -4.13886458e-02f, 5.71114235e-02f,
  2.16827858e-02f, -1.24861337e-02f, -2.76305676e-02f, -5.79325780e-02f, -2.99753137e-02f, 7.88270310e-02f, -2.89216749e-02f, 4.06123325e-02f, -3.30536775e-02f, -2.67192647e-02f,
  2.30753291e-02f, -6.81743845e-02f, 1.93369493e-01f, -2.68495977e-02f, -7.02669248e-02f, 4.70009856e-02f, 2.68857032e-02f, -1.65594533e-01f, 2.69545335e-03f, -7.28859827e-02f,
  -5.49738482e-02f, 1.21778592e-01f, -1.53938318e-02f, -2.64759306e-02f, 5.82974590e-02f, -6.63107187e-02f, 2.62366608e-02f, 1.00143902e-01f, 5.74093126e-02f, 6.58439174e-02f,
  1.98574476e-02f, -9.97921899e-02f, 2.29853783e-02f, -5.18294908e-02f, -2.08747014e-02f, -5.68783507e-02f, 8.14979523e-02f, 6.85817599e-02f, -1.30555648e-02f, 8.47928971e-02f,
  -8.55796114e-02f, -4.31310991e-03f, -1.53784798e-02f, 9.49492082e-02f, -3.92232351e-02f, 7.43727013e-02f, 1.35016024e-01f, 6.69047162e-02f, 5.09047918e-02f, -7.30932504e-02f,
  1.66317075e-02f, -2.85345558e-02f, 2.19127946e-02f, 5.37530854e-02f, -7.19506592e-02f, 2.66890595e-04f, -5.16195968e-02f, -2.45704614e-02f, 2.58845333e-02f, -1.61754359e-02f,
  7.97095243e-03f, 1.72954369e-02f, 6.83538094e-02f, -4.57543172e-02f, 2.27384828e-03f, -7.78056402e-03f, 9.39274728e-02f, 9.27809551e-02f, -6.50597783e-03f, 5.67099489e-02f,
  1.38949649e-02f, 6.86773658e-02f, 2.87252758e-02f, 1.68744009e-02f, -1.59588698e-02f, 6.79490045e-02f, -1.42779816e-02f, -6.22782223e-02f, -3.09451912e-02f, 1.91557873e-02f,
  -1.49737960e-02f, 3.04797702e-02f, 3.86264659e-02f, 2.16133855e-02f, -1.51987635e-02f, 5.77710755e-03f, 8.55487138e-02f, -2.93057598e-02f, -1.18329441e-02f, 1.33420089e-02f,
  6.58827871e-02f, 7.74080574e-04f, -3.90254669e-02f, 7.07062753e-03f, -7.46223470e-03f, -3.61112356e-02f, -4.38950062e-02f, 3.89932394e-02f, -6.61792513e-03f, 5.84155507e-02f,
  -7.98635855e-02f, -7.51007861e-03f, -4.30769147e-03f, 3.87953892e-02f, -5.13015129e-02f, -5.93590364e-02f, -2.92925965e-02f, -6.53084219e-02f, -5.13214879e-02f, -8.05499256e-02f,
  -1.32806255e-02f, 9.16253962e-03f, -5.65640852e-02f, -7.13186488e-02f, 2.19929852e-02f, -6.64788932e-02f, 2.92697386e-03f, -8.55088681e-02f, -6.06647953e-02f, 7.97521695e-02f,
  5.14080152e-02f, 4.43566665e-02f, -9.50845052e-03f, -3.65657210e-02f, 6.40718639e-02f, 5.26855923e-02f, 6.11716062e-02f, -5.15147718e-03f, 6.41448051e-02f, -4.43435051e-02f,
  -3.14052822e-03f, 3.06756422e-03f, 3.88433179e-03f, -4.26375903e-02f, 7.96119124e-02f, -1.18855342e-01f, -1.33226871e-01f, 8.55040848e-02f, 3.91986147e-02f, -5.76173700e-02f,
  -9.16648805e-02f, -9.48277712e-02f, -1.23156063e-01f, 2.37205774e-02f, -6.20931201e-02f, 7.51147643e-02f, 3.89192812e-02f, -2.98568606e-02f, -5.12759350e-02f, 1.61249507e-02f,
  8.46569687e-02f, 7.01661035e-02f, 1.15430564e-01f, 8.95330310e-03f, 3.96165289e-02f, -1.74350683e-02f, 5.63823879e-02f, 8.75549540e-02f, 7.82360416e-03f, 2.18703877e-02f,
  6.29561767e-02f, -7.95643553e-02f, 6.40824214e-02f, -7.97129236e-03f, -1.45930983e-02f, 1.86643135e-02f, 4.77708131e-02f, 5.71924299e-02f, -5.99362440e-02f, 4.09323387e-02f,
  -6.30635321e-02f, -5.83067164e-02f, 9.12737846e-02f, -3.16813681e-03f, 1.30040823e-02f, -5.45050129e-02f, 3.41969058e-02f, -4.19269763e-02f, 4.44469228e-02f, 5.24524637e-02f,
  -1.61958672e-02f, 2.73757912e-02f, 2.72581186e-02f, 9.12426412e-03f, 7.29560331e-02f, -8.50368589e-02f, -8.03229958e-02f, -7.12310672e-02f, 6.90926192e-03f, 1.69415551e-03f,
  1.89876035e-02f, 2.93841064e-02f, 3.82853225e-02f, 3.82887498e-02f, 6.28909394e-02f, -1.26831718e-02f, 4.33481596e-02f, -4.83602434e-02f, 1.27371363e-02f, 7.09626004e-02f,
  -7.42654726e-02f, -3.54363397e-02f, -6.48620129e-02f, 5.22465678e-03f, 6.71561575e-03f, -5.48063517e-02f, 6.26162514e-02f, 8.66652057e-02f, 5.24829440e-02f, -4.36718054e-02f,
  5.46212494e-02f, 3.26828435e-02f, 5.60230054e-02f, 3.82872894e-02f, 4.61744070e-02f, -1.38333933e-02f, 2.20395979e-02f, -3.19213085e-02f, -1.98721979e-02f, 4.62915897e-02f,
  -8.03777501e-02f, 4.99472134e-02f, -4.40369435e-02f, 6.95438981e-02f, 5.09131290e-02f, -1.69313531e-02f, 1.94217395e-02f, -2.26800926e-02f, 6.75047264e-02f, -6.50312677e-02f,
  -8.11504200e-02f, -8.14259574e-02f, 1.21804941e-02f, 8.59225988e-02f, 1.96804255e-02f, -2.11721621e-02f, -1.03761084e-01f, 3.38815227e-02f, -4.02534939e-02f, 8.90337899e-02f,
  -5.21649197e-02f, -5.73093165e-03f, -5.98351844e-02f, -6.82603493e-02f, 7.38480017e-02f, -1.90473869e-02f, 3.36148405e-05f, 4.72623408e-02f, 6.85057119e-02f, -4.56504710e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  -1.05820606e-02f, 1.58214480e-01f, 3.46214026e-02f, 8.69208649e-02f, 2.21260533e-01f, 8.80641490e-02f, 1.89084440e-01f, -4.93903756e-02f, 3.14086646e-01f, 1.23769909e-01f,
  9.58117694e-02f, 6.84814006e-02f, 2.63765246e-01f, 9.21379849e-02f, 1.20112918e-01f, 2.43498664e-02f, -4.57462259e-02f, 1.09139703e-01f, 2.30621323e-01f, -3.17942211e-03f,
  2.87891418e-01f, 2.90448312e-02f, 2.04315811e-01f, 6.70201927e-02f, 1.67396381e-01f, 1.73120618e-01f, 1.90620556e-01f, 5.76929040e-02f, 9.79186818e-02f, 8.70040357e-02f,
  1.73873931e-01f, 1.55135214e-01f, 1.40798897e-01f, 1.27126023e-01f, 1.50004968e-01f, -2.97653712e-02f, 1.96010590e-01f, 2.55238742e-01f, 1.32252127e-01f, 2.52241820e-01f,
  2.70294249e-01f, 1.10383332e-01f, 1.11990869e-01f, 1.80392414e-01f, 3.77343073e-02f, 2.81423509e-01f, -4.74875197e-02f, 1.21521272e-01f, 2.39889354e-01f, 6.90127313e-02f,
  -9.86191779e-02f, -3.79029326e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.53909281e-01f, 4.08073748e-03f, -1.05609760e-01f, 7.28512108e-02f, -9.22288075e-02f, -4.36247960e-02f, -5.86110577e-02f, 3.45325798e-01f, -8.38123113e-02f, 1.87768638e-01f,
  -1.81293681e-01f, 4.83376458e-02f, -1.46118671e-01f, -8.12637433e-02f, 8.62143859e-02f, 1.20366365e-01f, 1.59388468e-01f, -1.55449569e-01f, 4.29210514e-02f, 1.14880577e-01f,
  -1.22217527e-02f, -2.41374835e-01f, -5.73302843e-02f, -1.11577727e-01f, 3.85790855e-01f, -1.20966928e-02f, -2.44790524e-01f, 1.25239104e-01f, -3.01492289e-02f, -9.49423090e-02f,
  -5.44055030e-02f, 7.25186467e-02f, -9.84075740e-02f, -6.26233742e-02f, 2.94792727e-02f, 2.85274833e-02f, 1.98981687e-02f, -3.87648419e-02f, -2.17760503e-01f, 1.79575738e-02f,
  -1.27639964e-01f, -6.89203069e-02f, -2.71221459e-01f, -1.86602086e-01f, 6.26973286e-02f, 4.24839696e-03f, 1.38247907e-01f, 1.39841000e-02f, -8.51765648e-03f, 1.43711701e-01f,
  -1.63863618e-02f, -1.53206408e-01f, 1.88087299e-01f, 6.26925454e-02f, 2.40460560e-02f, 5.46554737e-02f, 1.03808515e-01f, -1.26796544e-01f, -1.40756220e-01f, -2.63098292e-02f,
  -2.11992636e-01f, -1.86516374e-01f, -6.17634729e-02f, 1.03494413e-02f, -2.89348159e-02f, -2.33216900e-02f, -3.11155561e-02f, 3.61189060e-02f, 2.18349278e-01f, 1.07360430e-01f,
  1.00721940e-01f, 2.37981260e-01f, 3.76894958e-02f, -1.82471573e-01f, -9.64155700e-03f, -1.03857227e-01f, -5.25389276e-02f, 1.25969738e-01f, 4.90746796e-02f, 1.35439545e-01f,
  1.24682568e-01f, -2.32495725e-01f, 7.17844293e-02f, -1.34725854e-01f, -1.74427599e-01f, 6.54261261e-02f, 8.44724104e-02f, 9.79352295e-02f, 1.49019107e-01f, -3.05610243e-02f,
  7.75171295e-02f, 1.71707254e-02f, -2.25945357e-02f, -1.13743611e-01f, 2.98297137e-01f, -5.39345406e-02f, 2.22503264e-02f, -1.86565101e-01f, 1.54093876e-01f, 9.87984687e-02f,
  1.16025433e-01f, -1.58701971e-01f, 2.74375957e-02f, -9.77422670e-02f, 2.08166614e-01f, 1.29544800e-02f, 5.86638227e-02f, -2.23406285e-01f, 1.68880671e-01f, 1.82268415e-02f,
  -4.07125428e-02f, 8.61639827e-02f, 4.04077359e-02f, 6.59930930e-02f, 6.14736378e-02f, -3.14893462e-02f, 1.83182523e-01f, 1.26193732e-01f, -1.01798929e-01f, -3.90942134e-02f,
  -3.74992564e-02f, -1.79425720e-02f, 5.85715808e-02f, 6.85503334e-02f, -2.21426666e-01f, -4.28827293e-02f, 4.45175059e-02f, 6.18285649e-02f, -9.57706869e-02f, -1.46749750e-01f,
  -1.06789649e-01f, 1.05630703e-01f, -5.33461745e-04f, 8.18842426e-02f, -1.22499160e-01f, 2.92905837e-01f, -2.64046133e-01f, 1.78981006e-01f, -2.15094000e-01f, -1.35013640e-01f,
  -4.26786281e-02f, -4.85077538e-02f, 1.32072166e-01f, 3.53063233e-02f, 1.35156915e-01f, -2.31488682e-02f, -8.94373879e-02f, -9.03345868e-02f, 1.51918143e-01f, -2.66388953e-01f,
  -9.67070311e-02f, -7.07752705e-02f, 3.90182704e-01f, -1.86140284e-01f, -1.58965230e-01f, 1.66899770e-01f, 3.21109854e-02f, 6.34408817e-02f, 1.34832576e-01f, -8.49821717e-02f,
  3.11820861e-02f, 9.94618535e-02f, -3.81795801e-02f, -2.48976201e-02f, -1.75299048e-01f, -1.02760293e-01f, -1.32277548e-01f, -6.64017871e-02f, 8.20016712e-02f, -1.51869640e-01f,
  -2.41272181e-01f, -1.30080134e-01f, 3.57709490e-02f, -2.18933895e-02f, 1.11167707e-01f, 6.61595166e-02f, -3.58448885e-02f, 2.58512706e-01f, -2.11378001e-02f, -2.55149335e-01f,
  -2.26456616e-02f, -4.76633906e-02f, -9.01915133e-02f, 1.40835568e-01f, 9.33561325e-02f, -2.03202799e-01f, 8.44467357e-02f, -9.37433764e-02f, -1.35276988e-01f, 1.25588961e-02f,
  1.06488332e-01f, 2.03454997e-02f, 2.05225468e-01f, 1.08571894e-01f, 4.85776849e-02f, 1.78826690e-01f, 1.06065683e-01f, 4.30627987e-02f, 1.44443199e-01f, 1.15565665e-01f,
  -3.29608731e-02f, -9.06714797e-02f, 3.69961172e-01f, 1.20688982e-01f, 1.00829355e-01f, 3.81203704e-02f, 5.86746223e-02f, -1.00258440e-01f, 5.09892218e-02f, -1.90063760e-01f,
  -1.32035449e-01f, 4.81685326e-02f, 2.18343124e-01f, -1.84981108e-01f, -5.77037316e-03f, -3.30644101e-02f, -4.44289818e-02f, -5.30410819e-02f, -7.21496269e-02f, 1.55359372e-01f,
  8.46266747e-02f, 1.26549184e-01f, -3.47001590e-02f, -1.04877591e-01f, -6.63003474e-02f, -1.04449026e-01f, 1.79491237e-01f, 1.04936704e-01f, 3.08204144e-01f, 1.07781522e-01f,
  -8.87756646e-02f, -1.29315928e-01f, -1.67669863e-01f, -2.53470913e-02f, -8.32161233e-02f, 1.49379879e-01f, -4.37960681e-03f, 5.45674115e-02f, 2.55860444e-02f, -2.86979172e-02f,
  1.59883156e-01f, -5.19441143e-02f, 1.73605800e-01f, -5.30112721e-02f, 1.22222118e-01f, -1.74743533e-02f, 1.65817454e-01f, -3.52453478e-02f, -8.66158679e-02f, -9.75638032e-02f,
  -1.09865412e-01f, -1.64836228e-01f, 2.17254952e-01f, -4.87694293e-02f, -1.12321250e-01f, -2.63421517e-02f, -3.37608382e-02f, 1.59104094e-01f, 2.17022061e-01f, 3.19880024e-02f,
  7.56350830e-02f, -2.17344295e-02f, 5.30519336e-02f, -9.42553505e-02f, 9.48610157e-02f, 1.69609532e-01f, -1.13672353e-01f, 2.20986128e-01f, -1.75065473e-01f, 2.89216116e-02f,
  -1.75453901e-01f, 1.93159059e-01f, 3.92816439e-02f, 1.58687547e-01f, -1.01965308e-01f, 8.87417980e-03f, 3.26318592e-01f, 2.26455823e-01f, -1.66273385e-01f, -2.38952357e-02f,
  -7.85614252e-02f, -9.31935757e-02f, -2.05698580e-01f, -8.57734606e-02f, 6.29559532e-02f, -7.91914761e-02f, -2.14268103e-01f, 1.51187526e-02f, -8.34936276e-02f, 7.55661055e-02f,
  -2.28481591e-01f, -9.90048796e-02f, 8.15753117e-02f, -2.28290055e-02f, 6.76978528e-02f, -2.55787708e-02f, 1.08737186e-01f, -9.18694288e-02f, 2.35139411e-02f, -2.19005793e-02f,
  -1.89195499e-01f, 2.59194195e-01f, 4.15575840e-02f, 2.87383795e-02f, -6.05154000e-02f, 2.62161493e-01f, -3.69918533e-02f, -9.06155929e-02f, -1.00672588e-01f, -8.77736136e-02f,
  4.66713086e-02f, 1.98210642e-01f, 1.63080916e-01f, -1.94711760e-02f, -7.22364187e-02f, 1.97681814e-01f, 4.13575731e-02f, -2.34142430e-02f, 5.13331592e-02f, 3.52988914e-02f,
  8.31095278e-02f, 2.86008939e-02f, 9.14915428e-02f, -2.53759255e-03f, 1.10692121e-02f, 3.92578356e-02f, -3.85226347e-02f, -1.70509905e-01f, 6.02851845e-02f, 3.10786124e-02f,
  1.92646589e-02f, 1.68943152e-01f, 1.12392791e-01f, -2.31437564e-01f, 1.81761663e-02f, 3.41469236e-02f, -1.07495986e-01f, 1.75794110e-01f, 1.52155966e-01f, 7.90722147e-02f,
  1.08054884e-01f, 6.32061586e-02f, 1.28086716e-01f, -8.68859664e-02f, -2.61896700e-01f, -4.85829227e-02f, 2.21984521e-01f, -7.22609740e-03f, -3.43340039e-02f, 7.62749761e-02f,
  -9.88648981e-02f, -1.81222782e-02f, -2.00271651e-01f, 1.81852430e-01f, 1.96470946e-01f, 1.71245456e-01f, -9.71014276e-02f, 1.67641029e-01f, 1.70935482e-01f, -8.37441832e-02f,
  1.12666026e-01f, 7.07510561e-02f, 2.63266284e-02f, 7.73411915e-02f, 1.23152897e-01f, 1.59284174e-01f, -1.76137492e-01f, 1.13080390e-01f, -6.65653199e-02f, 9.21343639e-02f,
  -1.04494125e-01f, 4.16150317e-02f, -2.51091629e-01f, -1.08323008e-01f, 1.36434540e-01f, 5.42715490e-02f, 1.80806518e-02f, 2.17233390e-01f, -6.72297254e-02f, -5.35860844e-02f,
  5.35153449e-02f, 1.41415060e-01f, -4.78780679e-02f, -2.30182558e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.30937006e-02f, -1.01702280e-01f, -1.43371016e-01f, -5.44081219e-02f, -3.33972797e-02f, -9.17187240e-03f, -5.75774796e-02f, -3.80581729e-02f, 4.69636125e-03f, 1.47510126e-01f,
  5.20403050e-02f, -9.18961391e-02f, 4.35889848e-02f, -9.61687416e-02f, -1.07805774e-01f, 3.79767567e-02f, 2.90537626e-02f, -7.05348626e-02f, 3.62273492e-02f, 1.56995188e-02f,
  5.18491343e-02f, 2.01122150e-01f, -3.26070674e-02f, -9.12059471e-03f, -9.48780105e-02f, -8.38860776e-03f, -7.27366284e-02f, -9.80517492e-02f, 3.36815715e-02f, 5.09268641e-02f,
  -1.15868323e-01f, 1.02234460e-01f, -3.37774120e-02f, 4.36298586e-02f, -9.98860076e-02f, -3.92621420e-02f, 1.59180071e-02f, 3.92187238e-02f, 9.83265489e-02f, 6.79335892e-02f,
  1.73967153e-01f, -1.07211731e-01f, 2.96407700e-01f, 1.37736537e-02f, 8.57357460e-04f, 1.00556411e-01f, 9.02507305e-02f, -1.11389518e-01f, -8.16369653e-02f, -1.18532769e-01f,
  5.19656837e-02f, 9.47386324e-02f, -1.41428420e-02f, -1.19274899e-01f, 9.07476470e-02f, -4.91320863e-02f, 1.16539262e-01f, 7.71642551e-02f, -4.96920384e-02f, 1.27015933e-01f,
  4.14882191e-02f, -8.73496830e-02f, -5.43720052e-02f, 5.44400215e-02f, 1.49625853e-01f, -1.66942421e-02f, -5.73850647e-02f, -8.18487853e-02f, 8.49931389e-02f, -4.90278341e-02f,
  -2.78800894e-02f, -2.07272545e-02f, 5.10732085e-02f, -9.34928432e-02f, 1.10655531e-01f, 1.59972191e-01f, -2.90211216e-02f, -1.07756220e-01f, -3.24696414e-02f, 9.17249098e-02f,
  -7.86221027e-02f, 1.62355322e-02f, 1.48503274e-01f, 2.15913355e-02f, 2.13231802e-01f, -8.71907175e-02f, 1.12260573e-01f, 1.08105719e-01f, -5.91862947e-02f, -1.03108972e-01f,
  4.75136638e-02f, 1.15551107e-01f, 1.17886998e-01f, 1.82777029e-02f, -1.01852931e-01f, -6.56666532e-02f, -1.47733107e-01f, 8.49802792e-02f, 1.08864956e-01f, 6.78274482e-02f,
  3.27681489e-02f, 5.07961772e-02f, 3.75307985e-02f, -3.08208596e-02f, 5.39062135e-02f, -3.88119966e-02f, 7.49209970e-02f, 1.07241601e-01f, -6.96575716e-02f, 1.69828027e-01f,
  -1.25946254e-01f, -8.99313390e-02f, 1.73265293e-01f, 8.17874074e-03f, -8.34175348e-02f, 4.37912494e-02f, -1.60894636e-02f, 6.86406624e-03f, -1.12524301e-01f, 2.94484850e-02f,
  1.55101912e-02f, 2.73157395e-02f, -1.26055181e-01f, -1.16264515e-01f, 5.31764068e-02f, 5.34304008e-02f, 1.02618627e-01f, 1.46463111e-01f, 2.98900139e-02f, 9.66808125e-02f,
  1.20196469e-01f, -1.00743100e-01f, -4.98697422e-02f, 3.91530916e-02f, 1.80977374e-01f, -1.98170021e-02f, 1.13314018e-01f, 1.27814218e-01f, 2.60459278e-02f, -7.98630267e-02f,
  -1.89685095e-02f, -8.31487477e-02f, -1.14359610e-01f, 1.30711585e-01f, 3.80837847e-03f, 2.57937461e-02f, -1.35966599e-01f, 7.91865028e-03f, -1.00708030e-01f, 3.50479871e-01f,
  -9.20583308e-02f, -4.98757549e-02f, 4.89005409e-02f, -4.06412780e-02f, -1.25455707e-01f, 2.28032712e-02f, -8.66447575e-03f, -1.15185216e-01f, 1.03774868e-01f, 1.02414321e-02f,
  8.61819535e-02f, 1.71340518e-02f, -8.53257626e-02f, 1.53450370e-01f, 1.11328609e-01f, -1.06124528e-01f, -1.12545229e-01f, -1.23435147e-02f, 1.02414206e-01f, 5.58151118e-03f,
  3.45479071e-01f, -5.75225987e-03f, 6.35782257e-02f, 8.65340531e-02f, -2.93176230e-02f, 9.37040150e-02f, -7.04338476e-02f, 2.11011060e-02f, 1.55178979e-01f, -8.45571011e-02f,
  1.76438689e-01f, -6.61581084e-02f, 1.12228535e-01f, 1.21551648e-01f, 1.35142580e-01f, -3.12029105e-02f, 5.72530851e-02f, 5.32925082e-03f, 3.23386714e-02f, 8.46163332e-02f,
  -1.02942064e-01f, 2.82194489e-03f, 1.39712051e-01f, -5.10881580e-02f, 2.64488429e-01f, 1.12862960e-01f, 2.36296564e-01f, 1.48570254e-01f, -2.66144294e-02f, 2.70850122e-01f,
  -1.34748667e-01f, -1.05378389e-01f, 2.44737267e-01f, -1.20846801e-01f, -3.43724526e-02f, 1.87095895e-01f, 2.51208395e-01f, 6.50324970e-02f, 1.24142602e-01f, -1.81896001e-01f,
  2.06728160e-01f, 3.77000272e-02f, -4.45323549e-02f, -1.74885139e-01f, -9.71563626e-03f, -3.69204655e-02f, 3.72040600e-01f, 2.21574716e-02f, -9.97495875e-02f, 7.44427815e-02f,
  2.79709082e-02f, -8.78570303e-02f, 4.33092564e-01f, 6.40017316e-02f, -1.99814495e-02f, -6.95853382e-02f, -2.96616405e-02f, -2.07755389e-03f, 3.09821665e-01f, 1.39316782e-01f,
  9.30808298e-03f, -1.83051750e-02f, -1.04935169e-01f, -2.15663668e-02f, -7.65142292e-02f, 1.36633754e-01f, 1.60249099e-01f, -1.58577397e-01f, 5.23189306e-02f, 5.55336140e-02f,
  -7.66792893e-02f, -7.01541752e-02f, 6.49608299e-02f, 1.25624448e-01f, 7.54213408e-02f, 1.40185282e-03f, 7.43916035e-02f, 5.49627692e-02f, -1.52840512e-02f, -5.55210840e-03f,
  2.22350676e-02f, -1.92049779e-02f, 1.63425803e-01f, -3.51278740e-03f, -1.36478454e-01f, -6.96957409e-02f, -5.06020188e-02f, 2.01242939e-01f, 2.57415157e-02f, 3.98986377e-02f,
  -5.83112016e-02f, 9.53377876e-03f, -5.35522960e-02f, -9.81224030e-02f, -1.02853589e-01f, -1.44829050e-01f, 1.26180992e-01f, 1.03677861e-01f, -6.28570765e-02f, -2.17543952e-02f,
  -1.04315445e-01f, 2.79544424e-02f, 1.46153286e-01f, -1.02189794e-01f, -3.52151245e-02f, -8.73698853e-03f, 2.62116969e-01f, 7.70542677e-03f, -1.39424264e-01f, -9.73755568e-02f,
  8.06441437e-03f, -6.89485818e-02f, 1.72119476e-02f, 5.30977063e-02f, -2.32046731e-02f, -1.04657739e-01f, -5.52462414e-02f, 9.87839252e-02f, 9.37592238e-02f, 4.92565706e-02f,
  -1.09854132e-01f, 8.51969421e-02f, 1.96323991e-01f, -8.68019462e-02f, -1.53613021e-03f, 1.72775134e-01f, 7.41711482e-02f, -8.79627764e-02f, -1.11522255e-02f, 1.03990309e-01f,
  6.94274455e-02f, 1.63931004e-03f, 1.83612972e-01f, -3.67905572e-02f, -4.67388891e-02f, 1.02402205e-02f, 8.71897116e-03f, -7.41592571e-02f, 2.54817624e-02f, 7.14617549e-03f,
  -1.34812906e-01f, -1.68112814e-02f, 1.20562062e-01f, -9.55253765e-02f, -3.28765847e-02f, 1.14026226e-01f, 1.94509327e-01f, -4.48299348e-02f, 1.44111231e-01f, 2.08084974e-02f,
  2.64126025e-02f, 1.98233366e-01f, 6.58339337e-02f, 1.35500401e-01f, -2.94927005e-02f, 8.74202326e-02f, 1.88056409e-01f, 4.26605381e-02f, 1.64100558e-01f, -9.40049887e-02f,
  1.25941396e-01f, 6.17177226e-02f, 1.02322914e-01f, -1.55098853e-04f, -3.14476192e-02f, 1.26952559e-01f, 1.58819988e-01f, -1.43076122e-01f, -8.24407712e-02f, -1.28639087e-01f,
  1.65604904e-01f, 4.37184572e-02f, -1.17474526e-01f, 1.91374689e-01f, 3.78731862e-02f, -1.15654714e-01f, -1.58761799e-01f, -8.87352154e-02f, 8.25518966e-02f, 1.33601695e-01f,
  -9.96468887e-02f, 1.67626783e-01f, 1.11142218e-01f, -2.45504770e-02f, 1.62990153e-01f, -6.19792659e-03f, 1.75664499e-01f, 3.73088680e-02f, 1.08489148e-01f, 7.45790079e-02f,
  7.27141947e-02f, -1.25983864e-01f, 1.23188540e-01f, 1.71710655e-01f, -1.00783162e-01f, 9.11833271e-02f, 7.40014911e-02f, -1.84847079e-02f, -1.26950905e-01f, 1.22251712e-01f,
  1.37045786e-01f, -5.40581755e-02f, 1.54240336e-02f, -3.49659659e-02f, -1.51130753e-02f, 1.24404445e-01f, 9.65564176e-02f, 2.60522570e-02f, 2.20971499e-02f, -1.14495404e-01f,
  5.48600592e-02f, 2.86672302e-02f, 5.83056957e-02f, 1.03250049e-01f, 1.57959625e-01f, 1.75409555e-01f, -3.31907533e-02f, 1.70692518e-01f, 5.21510653e-02f, 1.05653927e-01f,
  2.12147593e-01f, -8.79701152e-02f, 7.01836199e-02f, -1.02899432e-01f, 2.00609133e-01f, 1.22680664e-01f, -1.22514248e-01f, 3.67179438e-02f, 8.62232298e-02f, 4.02094461e-02f,
  -2.57770680e-02f, -9.19396803e-02f, -1.73610859e-02f, 4.88247164e-02f, 1.84356585e-01f, 1.26378968e-01f, 8.19825530e-02f, 2.23053880e-02f, -8.93324148e-03f, -6.52701259e-02f,
  -1.31504342e-01f, -2.88615841e-03f, 1.76549610e-02f, 7.95270875e-02f, -6.41052350e-02f, 1.45777717e-01f, -3.29263955e-02f, 1.38805751e-02f, -7.85662830e-02f, 8.64945874e-02f,
  9.96150896e-02f, -4.26964536e-02f, 8.45419914e-02f, -5.54760061e-02f, 6.81377128e-02f, 1.06865153e-01f, -1.87433325e-02f, 9.21234861e-02f, -2.64740419e-02f, 2.29248013e-02f,
  1.21616632e-01f, -2.19869521e-02f, -1.31022945e-01f, -5.86832911e-02f, 6.45819679e-02f, -8.33572820e-02f, -4.55047116e-02f, 1.03016585e-01f, -9.12405699e-02f, 5.43337595e-03f,
  -3.35874073e-02f, -8.37977752e-02f, -1.29027173e-01f, 1.15610443e-01f, 2.24231213e-01f, 5.84769063e-02f, 3.69078368e-02f, -1.44296968e-02f, 1.35595232e-01f, 2.40464076e-01f,
  2.49196067e-01f, 9.79100913e-02f, -1.77270144e-01f, 1.49861008e-01f, -3.27408671e-01f, 1.36910221e-02f, 2.43435823e-03f, 1.94661349e-01f, -1.18278846e-01f, -2.18033537e-01f,
  6.81827143e-02f, 5.08075319e-02f, 7.43457209e-03f, -7.20967501e-02f, 1.66260172e-02f, 2.45074201e-02f, -6.41809627e-02f, 1.03659712e-01f, 8.11310485e-02f, -2.50040814e-02f,
  -7.60984421e-02f, 1.87353939e-01f, 2.51255520e-02f, -6.68819323e-02f, -1.85581911e-02f, -1.18282817e-01f, 6.35631979e-02f, 7.03869313e-02f, -1.05633296e-01f, 1.18595742e-01f,
  1.50354743e-01f, 5.39301485e-02f, -1.16877612e-02f, -5.37705868e-02f, -2.13169128e-01f, -3.82358357e-02f, 4.08846326e-03f, 1.43311366e-01f, 2.18367547e-01f, 5.87485917e-02f,
  1.41140595e-01f, -3.60745341e-02f, 9.68232155e-02f, -4.30686399e-02f, 2.27228373e-01f, 2.40023714e-02f, 3.76055986e-02f, 2.07595497e-01f, -7.53001869e-02f, 1.42030314e-01f,
  -1.13540106e-01f, 2.88384091e-02f, -1.99798532e-02f, 7.92559907e-02f, 1.39545472e-02f, -7.31211454e-02f, 1.68442994e-01f, -4.93567288e-02f, -3.30915884e-03f, -1.02276169e-01f,
  -4.73045073e-02f, -1.48774562e-02f, 1.27841040e-01f, -6.59801718e-03f, -4.43176068e-02f, 1.72123089e-01f, 1.14995576e-01f, 2.51596510e-01f, 8.39178860e-02f, -2.04233527e-01f,
  6.74876571e-02f, 2.01449230e-01f, -3.27699721e-01f, -6.76173717e-02f, -1.22974433e-01f, -1.32240206e-01f, 4.06795144e-02f, 2.90800668e-02f, 1.77561298e-01f, -6.15978725e-02f,
  -5.81489727e-02f, 2.17335019e-02f, -5.23925982e-02f, 8.59624818e-02f, -1.73535511e-01f, 2.82827374e-02f, 7.61309564e-02f, 1.61872745e-01f, -1.52545467e-01f, 1.64451301e-02f,
  5.56997433e-02f, 3.19951866e-03f, -3.78119834e-02f, 5.33140376e-02f, 1.90917775e-01f, 9.03915837e-02f, 1.39835244e-03f, 7.95247927e-02f, -8.77096355e-02f, -5.45122251e-02f,
  -1.18675819e-02f, 1.71937779e-01f, 2.82180399e-01f, 1.68281808e-01f, -4.19797823e-02f, -1.60309449e-01f, 9.41957608e-02f, 6.67592883e-02f, 1.27217859e-01f, 8.86750892e-02f,
  8.68954584e-02f, 2.12579876e-01f, 1.57989785e-01f, 2.24944782e-02f, 2.50781238e-01f, 3.18259485e-02f, -5.05662002e-02f, -6.76856190e-02f, 1.66518062e-01f, 1.39198020e-01f,
  -4.46323454e-02f, 2.53329575e-01f, -1.05854735e-01f, -2.52858885e-02f, -7.86615089e-02f, -1.01071522e-01f, 8.12612548e-02f, 4.74242568e-02f, -3.65454741e-02f, 1.55678570e-01f,
  2.11912796e-01f, 1.02992512e-01f, -7.27917627e-02f, -1.04068868e-01f, 1.94777608e-01f, -2.86103427e-01f, 6.18511997e-02f, -2.03204364e-01f, 4.60408963e-02f, 2.98024446e-01f,
  1.55777290e-01f, -4.66125309e-02f, 1.08208708e-01f, -1.64517276e-02f, -1.06126629e-01f, 3.13019827e-02f, -4.73020636e-02f, 2.90133022e-02f, 3.84003781e-02f, 1.42395183e-01f,
  -1.46155715e-01f, 6.30677491e-02f, -6.97034299e-02f, 2.10541748e-02f, 4.20337822e-03f, 7.73083493e-02f, 5.59337661e-02f, -1.66727453e-02f, 1.44110277e-01f, 6.41659275e-03f,
  -9.59330127e-02f, 5.87071143e-02f, 1.32039562e-01f, -8.90012160e-02f, 1.40392751e-01f, 5.04838079e-02f, -2.75301374e-02f, 1.91872954e-01f, -9.54766646e-02f, 8.82001966e-02f,
  4.17037345e-02f, -6.34170100e-02f, -1.46758899e-01f, 9.88946334e-02f, -1.12555385e-01f, 5.37478365e-02f, 1.27688468e-01f, 2.13206753e-01f, -1.32511575e-02f, 1.62345439e-01f,
  -1.38761550e-01f, -1.73658326e-01f, 1.03138342e-01f, 1.22354366e-01f, 1.84992298e-01f, 3.15635912e-02f, -1.14635929e-01f, 3.51565359e-05f, -9.87602472e-02f, 4.31144461e-02f,
  1.98852807e-01f, 1.41715258e-01f, 2.50291973e-01f, 9.71965492e-02f, 1.58343807e-01f, 2.48477414e-01f, -2.40119666e-01f, -9.80070531e-02f, 1.71270609e-01f, 3.33531313e-02f,
  -2.64621489e-02f, -4.73515689e-02f, 2.35031202e-01f, 2.90812533e-02f, -5.88792898e-02f, -8.86638388e-02f, -2.00030059e-01f, -7.23854676e-02f, -5.84482290e-02f, -1.37129247e-01f,
  8.58458579e-02f, -1.27689674e-01f, 1.24651097e-01f, 1.67390198e-01f, -1.71698481e-01f, 6.74424395e-02f, -1.28945798e-01f, 1.49166018e-01f, 7.36846253e-02f, 3.40986520e-01f,
  -9.87124667e-02f, 1.06912456e-01f, -1.99999705e-01f, 1.98110312e-01f, 3.64212066e-01f, 3.87144974e-03f, -2.14567587e-01f, 7.68742636e-02f, 1.48709938e-01f, 2.28397343e-02f,
  -1.86078072e-01f, -6.78705098e-03f, 1.81562141e-01f, 1.47467136e-01f, 8.14210922e-02f, 1.23982303e-01f, -1.07185967e-01f, 6.03843704e-02f, -1.24475181e-01f, 4.23631333e-02f,
  -9.14263576e-02f, 1.18053831e-01f, -1.25894561e-01f, 7.83348531e-02f, 2.98048794e-01f, 5.56277521e-02f, -8.45464841e-02f, -1.31010994e-01f, 1.46437495e-03f, -8.48326739e-03f,
  -2.41752744e-01f, -2.45363265e-02f, -1.18726522e-01f, -5.79666011e-02f, 6.54956028e-02f, -6.95848912e-02f, -1.14557087e-01f, -7.92487413e-02f, -6.06587864e-02f, -1.08579494e-01f,
  6.94046840e-02f, -4.10623811e-02f, -5.92767075e-03f, -3.07229557e-03f, 1.39669001e-01f, 5.22927493e-02f, 1.94667857e-02f, -9.59892869e-02f, -3.02633140e-02f, -2.44753323e-02f,
  1.03615947e-01f, 4.39648181e-02f, -1.12732612e-01f, -9.75674540e-02f, -3.52880619e-02f, 1.30646572e-01f, 8.10608491e-02f, -1.08454727e-01f, -9.40166786e-02f, 3.33189070e-02f,
  1.12849459e-01f, -7.75117800e-02f, -1.07254691e-01f, -1.50534995e-02f, 4.92441878e-02f, 6.53349236e-02f, 5.72408363e-02f, 6.35729134e-02f, 1.40428513e-01f, 1.19610459e-01f,
  1.25465021e-01f, -6.44285530e-02f, -5.11194021e-02f, -6.35254011e-02f, -8.21686983e-02f, -3.64471925e-04f, 3.32216099e-02f, 1.53725952e-01f, 8.17300379e-02f, 1.32528827e-01f,
  6.80567548e-02f, -1.21490680e-01f, -6.49865437e-03f, -1.56404451e-02f, -4.91376705e-02f, 7.69336745e-02f, -1.80670656e-02f, -4.38081920e-02f, 5.34641743e-02f, 7.65735433e-02f,
  -5.49040735e-02f, 1.29235253e-01f, -3.95971537e-02f, -1.10347413e-01f, 5.44341430e-02f, 2.44108997e-02f, 3.65860313e-02f, -8.61624703e-02f, 1.94515958e-01f, -2.61343997e-02f,
  6.13215417e-02f, 2.05994040e-01f, 1.93294063e-01f, 1.31365806e-01f, -7.50963837e-02f, 1.34332910e-01f, -9.65600982e-02f, 1.21739514e-01f, -1.07268706e-01f, -2.29622394e-01f,
  -4.93360311e-02f, 1.32856920e-01f, -7.98972473e-02f, -5.55001199e-02f, 1.62684008e-01f, -4.74266708e-02f, -1.26362965e-01f, 8.99275169e-02f, -7.84424692e-02f, -1.83786917e-02f,
  -9.32463035e-02f, -9.44992974e-02f, 1.34641558e-01f, -3.74000482e-02f, -1.46861374e-01f, 3.46360058e-02f, 1.23053871e-01f, 7.05654994e-02f, 4.82621416e-02f, -5.83061501e-02f,
  1.54390901e-01f, -1.22024834e-01f, 5.83899952e-02f, -1.34342358e-01f, 1.49641320e-01f, 2.19926331e-02f, -1.06564797e-01f, 7.88511261e-02f, 2.10799817e-02f, -7.83191249e-02f,
  -3.04230843e-02f, -7.11249262e-02f, -4.44131196e-02f, -1.05809547e-01f, 1.23456359e-01f, 2.28538699e-02f, 1.15038864e-01f, -2.00660750e-02f, 1.57979101e-01f, -9.71964523e-02f,
  3.57036404e-02f, 1.86557189e-01f, 1.68662354e-01f, 4.76350673e-02f, 4.21824539e-03f, -1.71692669e-01f, -7.30346143e-02f, 1.48757428e-01f, -1.22796213e-02f, -5.12935296e-02f,
  4.76658344e-02f, -5.07455990e-02f, 2.00274855e-01f, -6.99175596e-02f, 1.96368352e-01f, 2.33714655e-01f, 9.94517505e-02f, 2.45348364e-01f, 1.62078049e-02f, 3.72738689e-01f,
  -2.08386943e-01f, 1.23083135e-02f, 3.23321372e-01f, 9.39286873e-02f, 5.71422577e-02f, -8.01140070e-02f, 4.31841984e-02f, -1.40158519e-01f, 1.63776353e-01f, -1.66765437e-01f,
  2.25705877e-01f, -1.10609032e-01f, -1.72090963e-01f, -2.76885666e-02f, 2.63247341e-01f, 4.74292040e-02f, 2.76600748e-01f, 3.19402595e-03f, 1.80245824e-02f, 2.78177112e-01f,
  6.20192476e-02f, 1.34065658e-01f, 1.33724853e-01f, 8.01594779e-02f, -4.56218831e-02f, 6.93121180e-02f, 4.02869016e-01f, -5.76053262e-02f, 1.99208274e-01f, 5.16149588e-02f,
  -1.41626537e-01f, -1.51182368e-01f, 4.40998822e-02f, -1.36762008e-01f, -6.46433756e-02f, 1.58678114e-01f, 4.74209376e-02f, 6.49722666e-02f, -1.22328505e-01f, 4.06875797e-02f,
  1.28007248e-01f, -1.05625317e-01f, 8.72049481e-03f, -1.90853640e-01f, 1.18800290e-01f, 5.44687845e-02f, 1.90581977e-01f, -5.45572005e-02f, 3.87259908e-02f, -1.67826060e-02f,
  -6.04822971e-02f, -1.25677288e-01f, -3.39638814e-02f, 7.60982260e-02f, -5.70174158e-02f, 1.08869009e-01f, -8.50363672e-02f, 1.11853547e-01f, -1.14399977e-01f, -6.91866949e-02f,
  5.39764129e-02f, 6.45280443e-03f, -2.99358070e-02f, 7.80431926e-02f, -1.07944451e-01f, -1.20207138e-01f, -1.05630718e-01f, -4.95304689e-02f, -6.88244179e-02f, 8.21275115e-02f,
  7.34409168e-02f, -3.03134453e-02f, -3.35587822e-02f, -8.24467018e-02f, 4.54410762e-02f, -2.34650504e-02f, 4.71125729e-02f, -1.16797864e-01f, 1.06817737e-01f, -1.00234799e-01f,
  4.02656347e-02f, 3.99280638e-02f, 8.72551128e-02f, 8.06579068e-02f, 9.89684463e-02f, 4.94606532e-02f, 4.14486937e-02f, -5.79743721e-02f, 4.34266478e-02f, 1.72753409e-02f,
  -3.23849432e-02f, 1.14488669e-01f, 6.06051311e-02f, -1.29370540e-01f, 6.42603785e-02f, -3.41065377e-02f, -2.08609309e-02f, 1.44993272e-02f, -3.29023227e-02f, 4.43162490e-03f,
  8.38305429e-02f, -5.69280572e-02f, 1.41557112e-01f, -9.88546163e-02f, -4.65183072e-02f, 1.44062281e-01f, -9.48477387e-02f, 4.09024209e-02f, 1.32123912e-02f, -6.07883232e-03f,
  1.80176813e-02f, -1.39457621e-02f, -8.67263526e-02f, 3.53212506e-02f, 1.42848253e-01f, -5.04005887e-03f, 8.98919180e-02f, 4.75238711e-02f, -7.87223950e-02f, 1.26230985e-01f,
  1.08387202e-01f, -1.57958046e-02f, 5.55285104e-02f, -5.69870435e-02f, -2.09069736e-02f, 1.50878936e-01f, 1.74478740e-01f, -1.10466346e-01f, 1.28802180e-01f, 2.20407292e-01f,
  -6.49947971e-02f, 6.60693794e-02f, 6.39564842e-02f, 4.69618849e-02f, -1.47181839e-01f, -8.11302364e-02f, -1.02094829e-01f, 1.68934569e-01f, 1.10585846e-01f, 9.59257036e-02f,
  4.79267947e-02f, 1.25178561e-01f, 3.60241309e-02f, -1.10697247e-01f, -1.06827594e-01f, -4.42946367e-02f, -9.46282670e-02f, 1.19533829e-01f, 9.73345861e-02f, 8.65147039e-02f,
  -7.94756413e-02f, -4.06989269e-02f, -6.46487698e-02f, 1.30783111e-01f, 1.45090343e-02f, -5.05278632e-03f, -5.49281351e-02f, 1.38152853e-01f, 1.30983785e-01f, -7.52850845e-02f,
  1.03599124e-01f, 1.61659047e-01f, 9.23718363e-02f, -7.24827275e-02f, -4.69008163e-02f, 6.05508983e-02f, 4.27350663e-02f, -2.63232179e-03f, -1.09027237e-01f, 1.86943963e-01f,
  1.04266265e-02f, 9.16317329e-02f, 1.08249828e-01f, 5.87751567e-02f, 3.88688669e-02f, 1.25630185e-01f, 1.29085645e-01f, 3.47887119e-03f, 7.61316791e-02f, 1.73680276e-01f,
  8.18961486e-02f, 8.20650831e-02f, -9.85881686e-02f, -2.80490611e-02f, 1.22274257e-01f, 9.78923962e-02f, -7.89767131e-02f, 7.68640935e-02f, 2.32473627e-01f, 1.52236670e-01f,
  1.85694858e-01f, 1.89500842e-02f, 2.32794750e-02f, -2.04934105e-01f, 1.86126858e-01f, 5.61519014e-03f, 1.28012031e-01f, 4.53867614e-02f, 1.10182194e-02f, 1.12316549e-01f,
  1.36968821e-01f, -1.46981910e-01f, 1.38883963e-01f, 1.21421367e-01f, 4.92719114e-02f, -8.95659626e-03f, -1.40927276e-02f, -6.77588303e-03f, -1.13087326e-01f, 2.03465208e-01f,
  2.57707775e-01f, -1.93626836e-01f, -1.07313715e-01f, -2.25574560e-02f, 9.12275389e-02f, -7.31492555e-03f, 5.39844334e-02f, 7.64347613e-02f, 1.24108661e-02f, -1.44776364e-03f,
  4.16617282e-02f, -5.08982316e-02f, 1.07422873e-01f, 4.09681946e-02f, -1.22961223e-01f, -2.50285119e-02f, -6.86817616e-03f, -1.11880982e-02f, 2.01613158e-01f, -7.21138269e-02f,
  4.81877215e-02f, -3.13419923e-02f, 1.86859444e-01f, -4.74581420e-02f, 1.84838176e-01f, 1.60293639e-01f, 7.95689374e-02f, -6.20607100e-02f, -9.53282490e-02f, -8.36313814e-02f,
  1.53311536e-01f, 1.55378416e-01f, 3.44329253e-02f, -5.85994124e-02f, 1.07669525e-01f, 5.72218075e-02f, -8.75120424e-03f, 2.93000266e-02f, -6.47663623e-02f, -1.18083417e-01f,
  5.73443770e-02f, 1.07804798e-01f, 1.64700598e-01f, -6.18101023e-02f, 8.39951728e-03f, 1.35412421e-02f, -9.71738547e-02f, 4.52533886e-02f, -1.13555286e-02f, -1.48920035e-02f,
  -6.05740547e-02f, 3.86350639e-02f, 9.62526351e-02f, -9.59771127e-03f, -1.81350056e-02f, 5.55096455e-02f, 1.42477587e-01f, -5.53615913e-02f, 3.87216099e-02f, -1.48382392e-02f,
  -9.99831557e-02f, -4.32492346e-02f, 6.23132586e-02f, -1.17696449e-01f, 7.44967535e-02f, 1.77318528e-01f, -9.01575387e-02f, -5.84841110e-02f, 8.84056464e-02f, 3.18590067e-02f,
  -1.27798304e-01f, -2.48991121e-02f, -7.16809928e-03f, -7.20695630e-02f, -4.71131764e-02f, 1.33149356e-01f, -8.79344810e-03f, 6.82843700e-02f, 2.80810371e-02f, -7.87040368e-02f,
  -1.77596491e-02f, -8.40300471e-02f, -1.06056675e-01f, 2.74764784e-02f, 1.07469141e-01f, -3.50550897e-02f, 2.20067380e-03f, 2.55951658e-03f, 9.49048698e-02f, 6.23283833e-02f,
  5.86148798e-02f, 2.58141384e-02f, 8.99570733e-02f, -2.82887705e-02f, -5.62004447e-02f, -1.34631604e-01f, -1.08245902e-01f, 7.15927854e-02f, 6.63827732e-03f, 1.09062418e-01f,
  -1.28543273e-01f, 1.00352257e-01f, 1.95158944e-02f, 1.52683496e-01f, -3.58043239e-02f, -5.19782938e-02f, 8.08111057e-02f, 6.65761158e-02f, 1.11223407e-01f, -3.10494602e-02f,
  1.37530506e-01f, 5.93824983e-02f, -1.17237037e-02f, 9.89358779e-03f, 3.61903794e-02f, 1.48486376e-01f, 8.75586867e-02f, 8.96819457e-02f, 1.26438960e-01f, -1.18080556e-01f,
  -5.74317612e-02f, -2.42582541e-02f, -1.25975117e-01f, 6.97912350e-02f, 7.81886652e-02f, -7.94221312e-02f, 1.55223295e-01f, 1.14446953e-01f, -1.06083602e-01f, -4.05877829e-02f,
  9.09933820e-03f, 9.17280763e-02f, 1.55457690e-01f, -8.31003040e-02f, 3.50809731e-02f, 5.61518036e-02f, -8.76058489e-02f, -8.99120569e-02f, 1.71609074e-01f, -1.17377847e-01f,
  -9.93153173e-03f, -9.39254537e-02f, 5.66844456e-02f, 1.00674719e-01f, 2.30579898e-02f, 2.42208503e-02f, -6.33624718e-02f, -2.95764506e-02f, -3.71748731e-02f, 4.39909324e-02f,
  2.74718534e-02f, -3.76868956e-02f, 8.39493424e-02f, 3.51288728e-02f, 9.05918032e-02f, 1.94652349e-01f, -5.12066949e-03f, 4.00595292e-02f, 3.03363893e-02f, 6.51907222e-03f,
  -9.00237486e-02f, 1.02694564e-01f, 1.13910966e-01f, -1.15689352e-01f, 4.68604732e-03f, -6.24092259e-02f, -8.59874208e-03f, 6.39112443e-02f, 1.43596858e-01f, 3.59949805e-02f,
  -5.31215779e-02f, 4.39559051e-04f, -2.01394871e-01f, 1.48420213e-02f, -9.46243033e-02f, -5.38840108e-02f, -1.08501390e-01f, -1.21708043e-01f, 4.37446684e-02f, -1.75463315e-02f,
  1.32083371e-01f, 4.74718250e-02f, -7.09026381e-02f, 7.82595351e-02f, 1.72893684e-02f, -1.80597436e-02f, -6.26508221e-02f, -1.72394905e-02f, -5.69709502e-02f, 3.36205065e-02f,
  -1.56039581e-01f, -1.89383440e-02f, -3.88857769e-03f, -1.17645770e-01f, -9.21083987e-02f, 5.79144247e-02f, 1.35574102e-01f, 9.84830186e-02f, 5.78828529e-02f, 1.14049099e-01f,
  1.52143054e-02f, 3.89633290e-02f, -8.16908479e-02f, -5.54731414e-02f, 2.67055444e-02f, -7.77206570e-03f, -8.94622505e-02f, 1.60390567e-02f, -2.09009238e-02f, -3.67453247e-02f,
  2.85814963e-02f, 6.67756498e-02f, 2.83738002e-02f, 9.08827484e-02f, 7.91881755e-02f, -1.56486686e-02f, 1.79325566e-02f, 1.52758554e-01f, 1.76060721e-02f, -5.04379831e-02f,
  -4.33749706e-02f, -4.61940654e-02f, 4.49728854e-02f, -2.21739570e-03f, 1.44665435e-01f, 1.08893961e-01f, -7.59134144e-02f, -1.00781672e-01f, -1.06863610e-01f, -7.87987635e-02f,
  2.04397783e-01f, 1.94480166e-01f, 2.02539489e-01f, -1.71362571e-02f, 1.63817743e-03f, 1.97375908e-01f, -4.01198454e-02f, -9.12771653e-03f, -9.28118918e-03f, -1.01050466e-01f,
  3.40848300e-03f, -8.25748518e-02f, -7.60801435e-02f, 1.31994277e-01f, 5.89814968e-02f, 6.43345937e-02f, 4.23870236e-02f, -9.23522264e-02f, -1.45638630e-01f, -1.90526173e-02f,
  -3.09919585e-02f, -1.39115945e-01f, -9.18625593e-02f, 1.43239170e-01f, 1.92772344e-01f, -1.05222970e-01f, -1.14782780e-01f, 1.02749988e-01f, 9.14129838e-02f, 1.16635360e-01f,
  -6.76570386e-02f, -1.05076686e-01f, 8.36424122e-04f, 8.82631540e-02f, -5.39961495e-02f, -1.02832250e-01f, -6.67577460e-02f, -6.09195307e-02f, 5.19195050e-02f, -4.52087149e-02f,
  -8.45230818e-02f, -7.95800760e-02f, 5.90196699e-02f, -8.30430388e-02f, -5.15752286e-02f, -2.08608247e-02f, 1.44614354e-01f, 7.03952368e-03f, 1.57386601e-01f, 1.77710876e-01f,
  6.91792965e-02f, -6.22339323e-02f, 4.08521555e-02f, -3.78754595e-03f, 4.29718234e-02f, 2.35783439e-02f, 3.11792158e-02f, -1.24834925e-01f, -8.49108100e-02f, 1.38680013e-02f,
  -1.15494862e-01f, -2.86903735e-02f, -2.70803254e-02f, -1.10863648e-01f, 6.48029521e-02f, 7.41189569e-02f, 1.42799526e-01f, 1.10170871e-01f, -2.09938716e-02f, 1.60028353e-01f,
  -3.53909433e-01f, 1.10725448e-01f, -3.69072855e-02f, 1.52942434e-01f, -4.81155589e-02f, 8.26597661e-02f, -3.26767713e-02f, 2.03879505e-01f, 8.12089294e-02f, -6.48659021e-02f,
  -2.10596919e-02f, 7.51547143e-02f, 1.54290915e-01f, 8.47441182e-02f, 8.45100656e-02f, -3.06323133e-02f, -7.65280426e-02f, 1.59265086e-01f, 7.30114281e-02f, -4.86413279e-04f,
  -5.99488653e-02f, 8.49657431e-02f, -9.45520774e-02f, -1.10844322e-01f, 3.36521477e-01f, 7.25624263e-02f, 3.66314277e-02f, 6.19614087e-02f, 4.89948243e-02f, -1.95530981e-01f,
  3.68109457e-02f, 4.86224219e-02f, 5.30037470e-02f, -1.89217310e-02f, -1.26141697e-01f, 2.56931752e-01f, -1.48044363e-01f, -1.52345374e-01f, 1.40999928e-01f, -8.85935426e-02f,
  5.12919053e-02f, -4.06544022e-02f, 5.08296862e-02f, 1.32619858e-01f, -4.52978499e-02f, 6.81138858e-02f, -1.79617584e-01f, 1.08612277e-01f, 7.66518265e-02f, 1.55680805e-01f,
  -9.26335230e-02f, 2.19092831e-01f, 1.45455435e-01f, 1.11089818e-01f, -1.99952900e-01f, 6.80361986e-02f, -1.39278639e-02f, 6.01733066e-02f, 1.71198025e-01f, -4.38626930e-02f,
  2.23154873e-01f, -2.05922741e-02f, 1.67756155e-01f, 1.98371932e-01f, 1.59713328e-02f, -2.51253366e-01f, 2.31725842e-01f, 3.65882516e-01f, -1.71797305e-01f, 3.11656862e-01f,
  -2.66603287e-02f, -1.70463875e-01f, -2.64459159e-02f, 2.48981901e-02f, -3.60424556e-02f, 1.22184783e-01f, 2.19991311e-01f, 7.45460019e-02f, 1.82790458e-01f, 1.51453167e-01f,
  1.37244001e-01f, 1.78852513e-01f, -1.94031507e-01f, 7.32630119e-02f, -4.73462418e-02f, 1.77067921e-01f, -9.84667987e-02f, 2.72689223e-01f, 8.06078166e-02f, -1.08035736e-01f,
  -1.02221809e-01f, 2.08547503e-01f, 2.16015741e-01f, 4.06976277e-03f, -2.47046873e-01f, 1.93805024e-01f, 2.68145412e-01f, -6.73964024e-02f, 1.05155908e-01f, -5.23585640e-02f,
  3.59629363e-01f, 8.62045661e-02f, 1.15632288e-01f, 2.67591208e-01f, 1.02922358e-01f, -1.92651562e-02f, -1.77841887e-01f, 1.99024588e-01f, -1.65202290e-01f, -3.82533148e-02f,
  -1.28074586e-01f, -2.00400148e-02f, 6.50488138e-02f, 9.39593837e-02f, 8.55140239e-02f, -5.15410900e-02f, 3.65908146e-02f, 3.40046897e-03f, -9.33119804e-02f, -2.71848887e-02f,
  -1.42456919e-01f, 1.47315517e-01f, 3.23930643e-02f, 3.16758938e-02f, 1.30485684e-01f, 1.35130718e-01f, -8.13950319e-03f, 2.30778451e-03f, -2.66622990e-01f, 1.79980993e-01f,
  -2.10427120e-01f, -1.74795285e-01f, 1.03912130e-03f, -2.38896310e-02f, -6.87478902e-03f, 1.81803972e-01f, 1.05125561e-01f, -9.53478143e-02f, -7.82569498e-02f, -6.90242499e-02f,
  3.18610579e-01f, -1.26046643e-01f, -1.57458246e-01f, 3.25700529e-02f, -2.59294156e-02f, 1.54405892e-01f, 2.82703251e-01f, -6.22401908e-02f, 2.51227226e-02f, -7.16803148e-02f,
  1.44362360e-01f, -9.81448740e-02f, 3.84138376e-01f, -2.20302213e-02f, 2.70747095e-01f, -1.04846299e-01f, 2.09968053e-02f, -8.90747905e-02f, 4.44258563e-02f, 4.92135733e-02f,
  -1.11652240e-01f, 1.51384398e-01f, 1.27328381e-01f, 4.48451117e-02f, 1.06304042e-01f, -7.55988732e-02f, 2.59824634e-01f, 9.70350280e-02f, 1.05478853e-01f, 2.21118331e-02f,
  1.61935940e-01f, 5.78213334e-02f, 5.75079471e-02f, 1.04098916e-01f, -1.19109139e-01f, -4.19260934e-02f, 2.94842385e-02f, 1.54550925e-01f, -1.20181106e-01f, 1.86477497e-01f,
  1.21979117e-01f, -1.67612717e-01f, -6.96716383e-02f, 5.97204119e-02f, 1.12503711e-02f, -5.14942035e-02f, 7.40198940e-02f, 2.32161116e-02f, 7.51070157e-02f, 7.14892522e-02f,
  -8.98979902e-02f, -1.09370887e-01f, -3.20254490e-02f, 1.94447175e-01f, -2.07953975e-01f, 1.34190708e-01f, -1.90387532e-01f, -1.22944690e-01f, -3.03192995e-03f, 1.00559212e-01f,
  8.03548694e-02f, 1.34880794e-02f, -1.15347937e-01f, 1.40089504e-02f, 6.24297038e-02f, 2.25431938e-02f, 4.51309718e-02f, 1.39713049e-01f, -8.12599733e-02f, -4.68114205e-02f,
  9.22338367e-02f, -6.28452806e-04f, 7.27804154e-02f, 1.37108505e-01f, 7.51670301e-02f, -4.74530309e-02f, 9.17337742e-03f, -4.70566982e-03f, -4.71047573e-02f, 1.72863714e-02f,
  -6.82956651e-02f, -4.15051877e-02f, -1.95562094e-02f, 1.09055847e-01f, -1.21642068e-01f, 1.32889152e-01f, 3.66346464e-02f, 3.34301312e-03f, 6.64187446e-02f, 1.02097653e-01f,
  1.08738787e-01f, 9.33397654e-03f, 7.87570421e-03f, -1.09580308e-01f, -3.19875516e-02f, -4.63490784e-02f, -4.80071977e-02f, 7.51834288e-02f, 2.44198553e-02f, -1.07412286e-01f,
  -1.10142484e-01f, 1.27660245e-01f, 1.85742546e-02f, -9.57446247e-02f, 2.44955402e-02f, -5.18923253e-02f, 8.26176256e-02f, 3.72293927e-02f, 1.54336438e-01f, -4.75469464e-03f,
  -7.71595016e-02f, -8.07404593e-02f, -2.98699542e-05f, -6.28792820e-03f, 1.24829434e-01f, -1.07429609e-01f, 1.39886588e-01f, -1.71472445e-01f, 1.46877646e-01f, 1.79296061e-01f,
  8.52652714e-02f, 1.65703222e-01f, -1.51884213e-01f, -1.23736106e-01f, 2.22310610e-02f, -1.81354377e-02f, 7.58555382e-02f, 1.74942493e-01f, -1.34977967e-01f, -8.94956104e-03f,
  2.58616507e-01f, 2.71506637e-01f, -5.54938056e-02f, -5.11709079e-02f, 4.53884862e-02f, 1.71212945e-02f, 9.74965170e-02f, 3.21250572e-03f, 5.08850478e-02f, -1.10035725e-02f,
  6.13112822e-02f, 5.57049103e-02f, -7.91901276e-02f, 1.05471469e-01f, -7.84418210e-02f, -5.13252132e-02f, -1.43787667e-01f, 1.61913693e-01f, 9.59819853e-02f, -8.87342393e-02f,
  1.22821242e-01f, -3.33763063e-02f, 2.22884670e-01f, 1.63755938e-01f, -1.26176789e-01f, 1.45516917e-01f, -7.14364573e-02f, -7.73916245e-02f, -9.17240679e-02f, 7.61570334e-02f,
  1.12130912e-02f, 2.33145505e-02f, -1.13741560e-02f, -1.32554427e-01f, 9.44327936e-02f, -4.13834602e-02f, -9.83219072e-02f, -2.27054916e-02f, -5.78803457e-02f, -1.27838030e-01f,
  -8.12559575e-02f, 1.06065936e-01f, 5.41215837e-02f, 6.31428063e-02f, 1.56924024e-01f, -9.66780558e-02f, 7.95574188e-02f, -2.79284548e-02f, -1.55746862e-01f, -8.24298710e-02f,
  -1.85373217e-01f, 2.08668970e-02f, -2.76495129e-01f, -3.07365134e-02f, -1.84208199e-01f, 2.72352248e-02f, 1.51965559e-01f, 1.75355300e-01f, 1.48096159e-01f, -2.08464786e-02f,
  3.29190679e-02f, 1.69515237e-01f, 2.77611762e-01f, -6.30127266e-03f, -1.65976379e-02f, -2.19286177e-02f, -6.74002916e-02f, -5.82156405e-02f, 2.68767983e-01f, 5.58800101e-02f,
  3.38975877e-01f, -1.05070129e-01f, -1.15065925e-01f, -9.19782445e-02f, 1.26376599e-01f, -4.38665897e-02f, 1.98803142e-01f, -8.59225839e-02f, 1.26895458e-01f, 2.01154143e-01f,
  -2.70710588e-02f, 1.10105850e-01f, -3.91227230e-02f, 8.48466977e-02f, -1.92961842e-02f, 2.13231176e-01f, -1.49002537e-01f, 1.21779451e-02f, 2.19378307e-01f, -2.01999798e-01f,
  -1.15714520e-02f, -4.26807143e-02f, 2.39731848e-01f, -8.90152454e-02f, 3.83457281e-02f, 1.51149109e-01f, -4.14976999e-02f, -1.70979515e-01f, -5.75657375e-02f, -2.35289186e-02f,
  1.15040742e-01f, 3.79963964e-01f, -4.93709743e-02f, 1.91170007e-01f, -9.97633561e-02f, 1.43185139e-01f, 6.91621080e-02f, 5.92570193e-02f, 6.61322102e-02f, 2.02163309e-01f,
  -3.97285968e-02f, 2.19837978e-01f, 1.71435341e-01f, 2.52285451e-01f, 2.47269616e-01f, 1.17805161e-01f, 1.98673874e-01f, 7.28201643e-02f, 3.82673629e-02f, -4.46267016e-02f,
  -2.55158097e-02f, 1.27214089e-01f, 1.22464791e-01f, -1.15573173e-02f, 1.07103484e-02f, -6.30749464e-02f, -1.00171335e-01f, 8.53181034e-02f, 1.04995511e-01f, -9.48805586e-02f,
  -3.04807127e-02f, -3.30708921e-02f, 2.21372652e-03f, 1.06480204e-01f, -1.24729075e-01f, -7.20294341e-02f, -6.47954084e-03f, 2.96344049e-02f, -2.25962102e-02f, -9.01630595e-02f,
  -7.94632584e-02f, -1.27687931e-01f, -9.81837958e-02f, -1.33542210e-01f, 1.06173106e-01f, -5.37630431e-02f, 3.90846282e-02f, -1.36700734e-01f, 7.25483373e-02f, -7.94596970e-03f,
  -3.60279344e-02f, 2.56040450e-02f, -1.66219566e-02f, 1.81428716e-02f, -3.23348194e-02f, 8.80843028e-02f, 1.05829462e-01f, 1.74186498e-01f, -5.89222610e-02f, 1.43631816e-01f,
  3.07011187e-01f, 9.63929221e-02f, -7.42041916e-02f, -2.43850909e-02f, 2.71200240e-02f, -8.97282287e-02f, -4.08707894e-02f, -7.42376316e-03f, 1.20873109e-01f, -8.87266025e-02f,
  -1.06873713e-01f, 4.81974240e-03f, 6.39371425e-02f, 1.51281431e-01f, 1.16821185e-01f, 2.05121823e-02f, 2.23749220e-01f, 2.09086671e-01f, 2.44156629e-01f, 2.78522950e-02f,
  1.58255190e-01f, 1.65158555e-01f, 8.75566974e-02f, 1.75287068e-01f, -1.55013055e-01f, 1.31498143e-01f, -9.23743472e-02f, 1.17325008e-01f, 1.65863737e-01f, -6.23252057e-02f,
  -1.07008837e-01f, 2.32835934e-02f, 3.31342518e-01f, -4.57036830e-02f, -9.28334817e-02f, 1.22309886e-01f, 1.62492067e-01f, 1.28968745e-01f, 4.45074327e-02f, 7.87815228e-02f,
  -2.66959462e-02f, 5.54078035e-02f, 3.83475833e-02f, -4.87877019e-02f, -1.49751827e-01f, 1.16753560e-02f, -1.77309021e-01f, -4.63730795e-03f, 6.41344041e-02f, 9.48724151e-02f,
  5.03106937e-02f, -1.17974952e-01f, 3.87668051e-02f, -1.19173089e-02f, -5.47426604e-02f, 1.73527092e-01f, -1.14565521e-01f, 1.79045543e-01f, 1.19137011e-01f, 1.20883174e-01f,
  -4.44458984e-02f, 4.89392206e-02f, 7.21580163e-03f, -1.66214421e-01f, 1.78654879e-01f, 1.15098990e-01f, 1.16876243e-02f, 1.57541126e-01f, 1.30401835e-01f, -8.18324760e-02f,
  -5.59147354e-03f, 1.25562519e-01f, 2.75766611e-01f, -8.61819312e-02f, -2.57698279e-02f, 1.68889672e-01f, 3.49443518e-02f, 3.90915796e-02f, 3.46979015e-02f, -4.54706661e-02f,
  4.18783687e-02f, 3.65672112e-02f, 4.73860884e-04f, 2.45882738e-02f, 1.70579776e-01f, -7.22335652e-02f, 1.17049236e-02f, 2.83288602e-02f, -5.91115430e-02f, 2.59688981e-02f,
  5.50557412e-02f, -3.14146921e-04f, 4.89778742e-02f, 1.32056221e-01f, -1.03051662e-01f, -4.23078518e-03f, 1.81178644e-01f, 1.03976563e-01f, -1.56592038e-02f, 1.30724922e-01f,
  -1.18139036e-01f, 8.96264017e-02f, -4.26106080e-02f, 7.58399814e-02f, 6.93503469e-02f, -9.41872895e-02f, -3.48015130e-02f, 1.07562013e-01f, -6.52977899e-02f, -1.88178271e-02f,
  -7.62185305e-02f, 6.97754920e-02f, -1.00642266e-02f, 1.44080102e-01f, 1.33294374e-01f, 1.27393395e-01f, -1.10735834e-01f, -5.69407530e-02f, 1.32925034e-01f, 2.19537348e-01f,
  5.25283553e-02f, -1.68623924e-02f, -1.04600102e-01f, 7.64864609e-02f, -1.26276568e-01f, -6.70014620e-02f, -6.84059411e-02f, 3.18690687e-02f, -3.04399669e-04f, 1.20707296e-01f,
  -7.79191852e-02f, -9.36525017e-02f, 1.04480281e-01f, -3.50204259e-02f, -1.22936435e-01f, -2.35554334e-02f, 8.12106654e-02f, -2.98263133e-02f, 1.30280301e-01f, 1.07125930e-01f,
  1.84974134e-01f, 2.37050071e-01f, 1.92650333e-02f, 1.49193987e-01f, 7.65727833e-02f, 2.26863489e-01f, 1.31163403e-01f, -6.21023029e-02f, 1.89371541e-01f, 5.30237332e-02f,
  -7.91348740e-02f, -2.30366886e-02f, 4.71004322e-02f, -6.32943958e-02f, -1.14921466e-01f, 1.44662365e-01f, 1.88262522e-01f, -7.20282793e-02f, 5.38187362e-02f, 9.69031826e-02f,
  -8.78175646e-02f, -1.26142189e-01f, -8.58133808e-02f, 4.12038341e-02f, 7.78687894e-02f, 2.03540027e-01f, -1.54956371e-01f, -1.74138367e-01f, 5.79649955e-02f, -7.35414699e-02f,
  -2.18502864e-01f, 7.10044652e-02f, -3.08840405e-02f, 4.33519706e-02f, -7.00353384e-02f, 2.50043366e-02f, 2.09601551e-01f, -5.43729775e-02f, 1.57502685e-02f, 7.55391791e-02f,
  1.19023345e-01f, 1.18745372e-01f, -1.92046359e-01f, 1.40161261e-01f, -5.07783480e-02f, -1.49634615e-01f, 1.14631884e-01f, 7.30581880e-02f, 4.88144532e-02f, 1.52210426e-02f,
  1.20166518e-01f, 1.91561073e-01f, 2.49218747e-01f, 1.07401170e-01f, -9.85765234e-02f, -1.33292422e-01f, 2.03287095e-01f, 3.69780287e-02f, -3.14673856e-02f, 1.88570887e-01f,
  1.40578285e-01f, -4.55208495e-02f, 1.50686111e-02f, 1.35857088e-03f, 2.32889622e-01f, 1.04651392e-01f, 1.43541783e-01f, 3.81625853e-02f, 2.02110067e-01f, 1.24133892e-01f,
  -3.37368473e-02f, -1.05034169e-02f, -1.20613789e-02f, -8.44826996e-02f, 2.50253409e-01f, 1.72338001e-02f, 8.83547366e-02f, 6.43890053e-02f, 3.01954914e-02f, -2.78693773e-02f,
  2.46936996e-02f, -1.69292577e-02f, -1.20992169e-01f, 8.82922560e-02f, 2.12144598e-01f, 1.44688517e-01f, 1.46143585e-01f, 5.03804125e-02f, -1.35519609e-01f, 2.27333512e-02f,
  2.44185895e-01f, 2.23305337e-02f, -8.55632406e-03f, 9.07017440e-02f, -3.68682221e-02f, -2.57240515e-02f, -1.99040264e-01f, 1.75804138e-01f, 3.17444295e-01f, 1.66034788e-01f,
  6.69881552e-02f, -3.37663852e-02f, 1.07166357e-01f, -2.19748560e-02f, -2.10360698e-02f, -9.40499231e-02f, 2.35959709e-01f, 1.32970408e-01f, 1.17063880e-01f, 2.34256878e-01f,
  7.02075660e-02f, 2.08459627e-02f, 3.83288823e-02f, -3.13099064e-02f, 6.74981065e-03f, -6.19040430e-02f, -1.41225263e-01f, -2.19726898e-02f, -4.82959487e-02f, 1.23800762e-01f,
  -6.57928512e-02f, -1.00875430e-01f, 6.32881075e-02f, -6.43469840e-02f, 1.72965098e-02f, 1.08494207e-01f, 2.92586512e-03f, -3.09250057e-02f, -6.45496994e-02f, -8.52794349e-02f,
  -1.56094795e-02f, 9.32511501e-03f, 1.04066590e-03f, 6.52638748e-02f, -4.81695421e-02f, -9.66993645e-02f, 1.52931884e-01f, 8.97847861e-03f, -7.13708432e-05f, -6.97203279e-02f,
  -1.12302424e-02f, 8.68935958e-02f, -3.50411385e-02f, -8.95111188e-02f, 3.69786322e-02f, 9.53251794e-02f, -6.89853057e-02f, 6.74762204e-02f, -1.24397129e-01f, 8.21593963e-03f,
  -6.10589907e-02f, 2.24126503e-03f, -5.79083376e-02f, -3.63889821e-02f, -1.25168934e-01f, -4.17641029e-02f, 6.21271320e-03f, -2.44924296e-02f, -7.67696202e-02f, -1.40994219e-02f,
  -7.62980878e-02f, 5.98325729e-02f, -1.07974298e-01f, -8.78605843e-02f, 3.30749825e-02f, 1.59682669e-02f, 7.74833187e-02f, -1.02147505e-01f, 6.61268681e-02f, -2.60412344e-03f,
  -4.10353281e-02f, 3.11153326e-02f, 9.15075541e-02f, -2.05270536e-02f, -8.39559734e-02f, -1.14299268e-01f, 6.89992681e-03f, -8.51302668e-02f, -1.13328673e-01f, 1.32760048e-01f,
  7.86594227e-02f, 1.40314996e-02f, 1.00600943e-01f, -1.96327232e-02f, 3.99648063e-02f, 8.13110694e-02f, -1.01481438e-01f, -9.74440773e-04f, -1.15947872e-01f, 9.27229226e-02f,
  1.24373905e-01f, -7.44401067e-02f, -1.61860865e-02f, 1.32629141e-01f, 8.80546570e-02f, -3.76120396e-02f, -4.13682200e-02f, 9.65357572e-03f, 1.21191360e-01f, -1.76835373e-01f,
  6.74525648e-02f, 1.43228218e-01f, -1.84837505e-02f, 3.09022553e-02f, -5.76752350e-02f, -2.64643412e-02f, -1.14524178e-01f, -1.26636982e-01f, -4.99835089e-02f, 1.91804737e-01f,
  6.05754219e-02f, -4.44993842e-03f, 1.18792549e-01f, 1.50041223e-01f, 1.22813992e-01f, 1.91571191e-02f, -1.12133508e-04f, -7.54793659e-02f, 5.29713091e-03f, 8.79184529e-02f,
  4.82588410e-02f, 1.45015344e-01f, -1.26269981e-01f, -8.11227225e-03f, -8.53243470e-02f, -3.48706692e-02f, 9.50281229e-03f, -4.32799384e-02f, 7.19311088e-02f, 1.20970502e-01f,
  -3.18149198e-03f, 5.36698028e-02f, 9.98787656e-02f, 1.56442881e-01f, 1.94002703e-01f, 1.51112631e-01f, 2.38338392e-02f, -2.28227358e-02f, -9.24833640e-02f, 1.17115401e-01f,
  -7.17593506e-02f, -5.87650463e-02f, -7.08321631e-02f, 2.38256622e-02f, -8.74229446e-02f, 2.42209025e-02f, -1.35473553e-02f, 1.52404740e-01f, 1.18545294e-02f, -6.31736545e-03f,
  7.92022049e-02f, 2.72344183e-02f, -9.57881212e-02f, -6.89441711e-02f, 3.64382192e-02f, -1.26476800e-02f, 1.89438045e-01f, 3.86607125e-02f, -2.86106151e-02f, 1.39520671e-02f,
  7.59258866e-02f, 2.55977511e-02f, 8.99474770e-02f, -1.10037930e-01f, 1.76654294e-01f, 1.45849004e-01f, 3.27951424e-02f, 1.42565295e-02f, -8.43014196e-02f, 4.49515097e-02f,
  9.90285799e-02f, 6.68590143e-02f, -6.46772832e-02f, -5.98126613e-02f, 5.39447106e-02f, -2.91151740e-02f, 3.49849574e-02f, 8.66514295e-02f, -3.38585563e-02f, -9.38757062e-02f,
  -8.16422403e-02f, 5.81609979e-02f, -1.47241233e-02f, 3.48280482e-02f, -3.81291173e-02f, -1.01187013e-01f, -7.63664246e-02f, -1.03956185e-01f, 1.21510457e-02f, -1.24075018e-01f,
  -4.77468818e-02f, 2.86511481e-02f, -3.02200802e-02f, 1.23925254e-01f, 3.36625351e-04f, -1.20908022e-01f, -1.43063068e-01f, -5.22809364e-02f, -7.02767372e-02f, -5.26899286e-02f,
  -5.90398759e-02f, 2.35930528e-03f, -5.22015132e-02f, -6.49666861e-02f, 1.50543330e-02f, -3.43120582e-02f, -7.11197406e-02f, -7.18052313e-02f, 2.00008795e-01f, 1.36320263e-01f,
  -2.96166260e-02f, 6.97115809e-02f, 4.26817946e-02f, 6.54830933e-02f, -4.43977118e-02f, 1.70119747e-03f, 8.91469121e-02f, -1.93048008e-02f, 1.92429759e-02f, -9.01068002e-02f,
  3.86282839e-02f, 4.76352572e-02f, 1.07814357e-01f, 1.10917322e-01f, 1.54786110e-01f, 5.85850105e-02f, 1.18268371e-01f, 5.13172522e-02f, 6.22975864e-02f, 1.13760568e-01f,
  -1.10719353e-01f, -6.68699220e-02f, -2.32690983e-02f, -1.28414065e-01f, -7.95974862e-03f, 1.41598463e-01f, -6.72203004e-02f, 8.10372531e-02f, 2.38145869e-02f, 8.06193277e-02f,
  -2.16293335e-01f, 1.55906662e-01f, 4.79764640e-02f, -3.03947367e-02f, 9.43930447e-02f, -7.15554180e-03f, 1.13635786e-01f, 1.45326421e-01f, -7.25936592e-02f, -7.96757787e-02f,
  1.10362947e-01f, 2.57941317e-02f, 2.72716060e-02f, -5.68584055e-02f, -3.20581272e-02f, 1.09615345e-02f, 1.26044959e-01f, 4.99683395e-02f, 6.33123517e-02f, 1.83903240e-02f,
  3.52826230e-02f, -1.63261071e-02f, 1.69827059e-01f, -1.24198020e-01f, -8.62482786e-02f, -1.28054544e-01f, 5.70846573e-02f, 2.26102583e-02f, 5.37938066e-02f, -9.05524865e-02f,
  -1.12173213e-02f, 5.45003824e-02f, 1.08666547e-01f, -7.91056920e-03f, -2.46439129e-02f, 9.16874409e-02f, 4.18865234e-02f, 1.30453706e-01f, -4.58740368e-02f, 4.46974263e-02f,
  5.00296652e-02f, 1.99586488e-02f, -9.43808258e-02f, 9.39190611e-02f, 2.62302607e-01f, 2.87214667e-01f, 1.45447671e-01f, 1.92596778e-01f, 1.24211729e-01f, 9.82730538e-02f,
  5.37515292e-03f, 4.65635881e-02f, 1.35038085e-02f, 1.25410274e-01f, -3.11134219e-01f, -1.24940261e-01f, -1.44253269e-01f, 1.74944520e-01f, -7.48560429e-02f, 5.23045026e-02f,
  1.30299151e-01f, 9.52590555e-02f, 3.69777810e-03f, -2.44564638e-02f, 2.03997567e-01f, -2.25833520e-01f, 3.64672765e-02f, 1.77939907e-01f, 1.36606377e-02f, -3.22401151e-02f,
  -7.41706714e-02f, -1.27107531e-01f, -1.20773397e-01f, 1.09434733e-02f, 3.87302935e-02f, -1.06458776e-01f, 1.32868811e-01f, -7.77203292e-02f, -1.48536876e-01f, -1.82094499e-01f,
  -1.63409650e-01f, 1.14359841e-01f, 1.70144469e-01f, 1.41171932e-01f, -8.19778964e-02f, 1.60270974e-01f, -1.94746599e-01f, -9.27663743e-02f, 5.51369302e-02f, 3.21735404e-02f,
  2.32094839e-01f, -4.19877768e-02f, 4.20806333e-02f, 2.70127922e-01f, -8.42825919e-02f, 8.40214416e-02f, 5.58836684e-02f, 5.81835955e-02f, -8.57690126e-02f, -2.56554596e-02f,
  1.06429160e-01f, 3.40663157e-02f, -1.88384368e-03f, 1.53957173e-01f, -1.53649300e-01f, -6.55294908e-03f, 2.95834616e-02f, -6.90049231e-02f, -5.21008298e-02f, 1.49772791e-02f,
  1.62280306e-01f, 1.21283673e-01f, 2.96611246e-02f, -6.67167827e-02f, -1.08988166e-01f, -8.03931355e-02f, -7.99108371e-02f, -9.21217501e-02f, -1.18393831e-01f, 6.67566806e-02f,
  -7.07327500e-02f, 3.82046476e-02f, -5.43978289e-02f, -3.90834324e-02f, -2.10029873e-04f, 4.52503189e-02f, 7.18651339e-02f, -4.72800024e-02f, -1.85402259e-02f, 8.45627710e-02f,
  4.05081175e-02f, -2.99309846e-02f, -9.67591256e-02f, 5.48224850e-03f, -4.08892334e-02f, -1.33821405e-02f, 1.09410703e-01f, -7.77415037e-02f, 1.94633752e-01f, -4.14866954e-02f,
  1.68682128e-01f, 1.69653893e-02f, 3.07922605e-02f, -7.94461071e-02f, 1.00427151e-01f, 1.02997072e-01f, -1.75298024e-02f, -1.76688451e-02f, 1.61304753e-02f, -6.04858287e-02f,
  1.63315520e-01f, -9.85244215e-02f, -6.43226653e-02f, 4.08682786e-02f, 2.22264249e-02f, 7.43373185e-02f, -1.17362246e-01f, 1.33416712e-01f, 4.07158099e-02f, 9.51782838e-02f,
  5.06667830e-02f, 1.27783328e-01f, 1.01564653e-01f, -8.24314281e-02f, -3.05225868e-02f, 8.47920775e-02f, 3.26155126e-02f, 5.30616241e-03f, -7.58367106e-02f, 1.23084195e-01f,
  -1.19775727e-01f, 1.16073184e-01f, -8.59400630e-03f, 4.32089828e-02f, -9.62503329e-02f, 1.54177621e-01f, 1.66466441e-02f, -7.24768415e-02f, -1.47417769e-01f, 6.81323856e-02f,
  -5.25019206e-02f, -9.78408158e-02f, -3.27454619e-02f, -2.11183075e-02f, -3.03905290e-02f, -4.34044190e-02f, -6.37603551e-02f, 3.51170602e-04f, -4.03567702e-02f, -5.85263446e-02f,
  1.87751636e-01f, -4.60400656e-02f, 1.25578433e-01f, 1.21946959e-02f, -4.69265655e-02f, 1.21957272e-01f, 2.46033460e-01f, -9.57687795e-02f, -5.41909710e-02f, 4.27017286e-02f,
  -5.52235134e-02f, 1.16964266e-01f, -7.81403258e-02f, 1.18594557e-01f, 2.51779146e-03f, -1.14051841e-01f, 4.16992418e-02f, 1.22010507e-01f, 6.84074685e-02f, -1.22712821e-01f,
  9.36527643e-03f, 1.45558238e-01f, 7.44767440e-03f, -5.66905737e-02f, -8.03589448e-02f, -1.17823156e-02f, 1.53346285e-01f, -2.97260825e-02f, -7.20239058e-03f, 1.26073947e-02f,
  8.27708319e-02f, 1.83841601e-01f, 9.20775756e-02f, 1.84370354e-02f, -9.45296809e-02f, -7.50224814e-02f, -5.69833023e-03f, 1.46405324e-01f, -2.03015283e-02f, 1.93221364e-02f,
  -8.75113383e-02f, -1.20161161e-01f, -1.03318013e-01f, 4.96102273e-02f, 7.06361653e-03f, 6.94449767e-02f, 1.71536967e-01f, 2.10436061e-01f, 1.03132412e-01f, 1.20790780e-01f,
  -4.02117148e-03f, 5.53519055e-02f, -3.00393999e-02f, 8.51587653e-02f, -1.38765112e-01f, 2.11083815e-01f, -2.83215940e-01f, -2.02630609e-02f, 1.49704382e-01f, -1.40787959e-01f,
  -9.97104347e-02f, 8.86611938e-02f, -1.20777503e-01f, -4.25478406e-02f, -8.62260535e-02f, -9.11392197e-02f, 1.37802288e-01f, 2.68078327e-01f, 1.48451686e-01f, 1.36624798e-01f,
  2.33808503e-01f, -1.96076110e-01f, 2.05719136e-02f, 4.83550951e-02f, 1.67279672e-02f, 2.36347243e-02f, -7.10692033e-02f, 1.33328333e-01f, 2.25319758e-01f, -5.78064006e-03f,
  7.72801787e-02f, -1.44286919e-02f, -2.78253049e-01f, -8.68511721e-02f, 2.64474191e-02f, 1.15935467e-01f, 3.05408806e-01f, -2.92633742e-01f, 4.08546418e-01f, 9.76864155e-03f,
  -9.33742002e-02f, 3.51833612e-01f, 2.49505430e-01f, -4.61436622e-02f, -1.01098061e-01f, 2.06845328e-01f, -4.96857725e-02f, -1.19485088e-01f, 1.00199983e-01f, -1.64842859e-01f,
  9.22812149e-02f, 1.27530724e-01f, -1.05209544e-01f, -6.18645847e-02f, -1.29061018e-03f, 4.33805212e-02f, -1.77896172e-01f, 8.89330655e-02f, 7.35288039e-02f, 6.49070516e-02f,
  9.79310051e-02f, -5.50761856e-02f, 8.01714212e-02f, 4.69828546e-02f, -1.11464992e-01f, -5.32000549e-02f, 6.22494332e-02f, -1.24318130e-01f, -7.95328841e-02f, 1.19981855e-01f,
  -4.45118509e-02f, 1.44184291e-01f, -7.73409754e-02f, 8.72970372e-03f, 8.32741801e-03f, 1.15316615e-01f, 8.12837780e-02f, 1.86143816e-01f, 1.77884147e-01f, 7.13684484e-02f,
  -3.94163765e-02f, -1.08229101e-01f, 8.57779458e-02f, 7.22801313e-03f, 2.19120592e-01f, 9.23623666e-02f, 1.29678547e-01f, -1.14227146e-01f, -3.56437601e-02f, 2.36162059e-02f,
  -9.09026861e-02f, -1.19919233e-01f, 1.25858143e-01f, 1.35850171e-02f, 6.05847798e-02f, 1.53013408e-01f, 4.06254828e-02f, 1.28655806e-01f, -8.85784328e-02f, -3.86800617e-02f,
  4.87057678e-02f, 2.97759380e-02f, -9.33354069e-03f, 1.12699926e-01f, -2.57364754e-02f, -1.27918884e-01f, 9.49633196e-02f, 4.82830778e-02f, 1.57131270e-01f, 7.71368816e-02f,
  -3.58914472e-02f, -7.59262443e-02f, -3.83144319e-02f, -9.26100165e-02f, 1.20136030e-01f, -1.42484438e-02f, -5.80719672e-02f, 7.16999620e-02f, 8.79153907e-02f, 9.68420357e-02f,
  2.91372947e-02f, -4.28444594e-02f, 4.85978015e-02f, -1.08008087e-01f, 1.24002270e-01f, 3.89261246e-02f, 1.22663155e-01f, 1.54957220e-01f, 4.13602293e-02f, 2.56808281e-01f,
  1.29873902e-01f, -9.31755975e-02f, 3.25733088e-02f, 2.93103933e-01f, -3.11082363e-01f, -1.42414559e-04f, -4.17793170e-02f, -1.23361818e-01f, 8.67133066e-02f, 1.93955272e-01f,
  1.73302248e-01f, 1.71568498e-01f, 1.77920297e-01f, 7.61316493e-02f, 5.09148277e-02f, 1.48050770e-01f, -1.60558313e-01f, -2.01224089e-02f, 3.43864560e-01f, 4.07901481e-02f,
  -2.99221724e-02f, -7.98264146e-02f, -2.79066451e-02f, -5.70030734e-02f, -6.56044930e-02f, -3.74398828e-02f, 1.78152621e-01f, -6.88182637e-02f, -1.45551845e-01f, -4.88875695e-02f,
  -4.44779359e-02f, 1.08260244e-01f, -8.79350211e-03f, -2.33737230e-02f, 2.07591668e-01f, 8.48156661e-02f, 6.57482222e-02f, 1.06616179e-02f, -6.66046217e-02f, 2.91614514e-02f,
  2.76449800e-01f, 5.81886768e-02f, 2.55317837e-02f, 1.14701316e-01f, -1.12739772e-01f, -3.02000903e-02f, 2.69198596e-01f, 2.24731979e-03f, -9.26819518e-02f, 4.43645455e-02f,
  2.21370578e-01f, 8.93491879e-02f, 1.19265638e-01f, 1.13309652e-01f, -4.35927324e-02f, 3.92499454e-02f, 5.73958606e-02f, 2.96241231e-02f, -2.07729917e-02f, 4.14723977e-02f,
  9.14305374e-02f, -7.10067302e-02f, 1.29261792e-01f, 6.16576076e-02f, -7.07009360e-02f, -1.29762277e-01f, -5.31378016e-02f, 1.69068530e-01f, -1.42747194e-01f, 1.75385773e-01f,
  2.77154893e-02f, -3.87823954e-02f, -8.14062059e-02f, 1.00656494e-01f, -1.15786441e-01f, -5.18515445e-02f, -2.81448122e-02f, -1.08548716e-01f, 2.42644057e-01f, 7.65069649e-02f,
  -4.74852361e-02f, -4.21365574e-02f, 1.55996569e-02f, -9.85403210e-02f, 3.83244008e-02f, -5.02594002e-02f, -6.81687519e-02f, -3.83733921e-02f, 9.63571742e-02f, 7.52981827e-02f,
  -1.38625637e-01f, 1.42410636e-01f, -1.18869960e-01f, 6.20812401e-02f, -1.35843784e-01f, 1.40909955e-01f, -5.87611906e-02f, -5.09707956e-03f, -1.07688829e-01f, -7.23488852e-02f,
  5.11465967e-02f, 4.62245801e-03f, 8.32556114e-02f, 1.68762788e-01f, 1.06322102e-01f, -1.00379802e-01f, -1.19859196e-01f, 1.07628070e-01f, -7.01062530e-02f, -7.49555305e-02f,
  -9.29662660e-02f, -1.66152008e-02f, -7.62967579e-03f, -3.21826823e-02f, -1.54729383e-02f, -4.12749648e-02f, 1.54111069e-02f, -4.25783824e-03f, -9.77540687e-02f, 6.67766035e-02f,
  5.72870411e-02f, 7.94147048e-03f, 8.31238553e-02f, 1.50463820e-01f, 7.76567906e-02f, -1.60876568e-02f, -4.18143831e-02f, 1.35496303e-01f, -8.02376345e-02f, -7.70649761e-02f,
  8.93930569e-02f, 6.88052624e-02f, -2.45525882e-01f, -3.02900542e-02f, 5.18631861e-02f, 1.60568759e-01f, -2.97954790e-02f, -3.48949427e-04f, -9.41312406e-03f, 2.24351853e-01f,
  3.07196062e-02f, -1.09524786e-01f, 1.28814980e-01f, 2.15293303e-01f, 1.46052716e-02f, 1.62378896e-03f, -1.85330793e-01f, 1.02884702e-01f, -7.74256960e-02f, -7.76753295e-03f,
  -9.16182101e-02f, 1.68375105e-01f, 9.36570615e-02f, -4.05076779e-02f, 8.28595012e-02f, -2.84799412e-02f, 5.70347793e-02f, -1.30291879e-01f, 2.23975684e-02f, 1.61476985e-01f,
  1.61548272e-01f, -8.51989314e-02f, -5.08721694e-02f, 1.32080436e-01f, 2.29136750e-01f, 8.83216336e-02f, 1.43936843e-01f, 1.40110448e-01f, -7.44356439e-02f, -6.34732097e-02f,
  -1.31203353e-01f, 8.18512663e-02f, -6.63523898e-02f, 2.69105673e-01f, -1.60843879e-01f, 6.31100163e-02f, 2.23469529e-02f, 1.61257431e-01f, -9.88303423e-02f, 8.04160014e-02f,
  1.15589112e-01f, -1.45115815e-02f, -9.88289416e-02f, 1.50030822e-01f, -2.48245876e-02f, -1.08794682e-01f, 1.62630200e-01f, 2.96467721e-01f, 2.60594577e-01f, 7.78482780e-02f,
  1.56101868e-01f, -1.43983467e-02f, 2.50977367e-01f, 1.27627328e-01f, 2.90498491e-02f, -1.53487921e-01f, 3.99203449e-01f, 1.62686873e-02f, -5.88347856e-03f, 2.77457703e-02f,
  -1.57035440e-01f, 1.44256666e-01f, 2.45493531e-01f, -6.54635802e-02f, -1.43435538e-01f, 7.02078268e-02f, 3.76059771e-01f, 1.78835467e-01f, 6.06496539e-03f, 4.49692570e-02f,
  1.20887219e-03f, -1.24692790e-01f, -2.25042794e-02f, -3.83642092e-02f, 1.03073776e-01f, 2.74271853e-02f, -1.08090982e-01f, 1.57035530e-01f, -1.65861174e-01f, 4.68746722e-02f,
  1.42088383e-01f, 2.04433456e-01f, 4.09986913e-01f, 1.47099197e-01f, -1.24537244e-01f, 6.72282046e-03f, -5.09793237e-02f, -1.50031880e-01f, 5.09357005e-02f, 2.97840118e-01f,
  4.92545031e-02f, 6.22703210e-02f, -5.39344959e-02f, 4.07216959e-02f, 2.41973773e-01f, -8.58930126e-02f, 1.87425703e-01f, -1.12243257e-01f, 4.39496897e-02f, 8.08887556e-02f,
  1.43793419e-01f, -1.07598841e-01f, -2.16472428e-02f, 1.56190740e-02f, 1.25443973e-02f, -1.19757295e-01f, 5.13539493e-01f, 1.24542549e-01f, 1.70767400e-03f, -1.11297257e-01f,
  5.64542525e-02f, -5.16298153e-02f, 5.45077547e-02f, 1.55308142e-01f, 6.70103133e-02f, 2.17622876e-01f, -3.00611973e-01f, -1.09956287e-01f, 2.15381477e-02f, -1.64819025e-02f,
  -1.94909036e-01f, -1.52791172e-01f, 1.05157192e-03f, 1.14584297e-01f, 1.17812678e-01f, -1.19919293e-01f, -2.94367736e-03f, 9.62861478e-02f, 3.79077703e-01f, -7.49160647e-02f,
  -1.11485496e-01f, -9.54893325e-03f, -2.88818683e-02f, 1.59717754e-01f, -4.15297486e-02f, -4.53979708e-02f, 1.69402689e-01f, -8.96271542e-02f, -9.93316546e-02f, -5.86709343e-02f,
  2.28217095e-01f, -9.40330476e-02f, 5.81930615e-02f, -1.37936100e-01f, 1.22641310e-01f, 1.05378844e-01f, -8.32052305e-02f, -2.67420989e-02f, 2.49643940e-02f, -8.86621773e-02f,
  -6.27428368e-02f, 1.07269362e-01f, 8.52326956e-03f, -3.19997631e-02f, 8.46825987e-02f, -1.77433163e-01f, 4.47281674e-02f, 1.32262915e-01f, -1.15799822e-01f, -6.33156449e-02f,
  -1.25275180e-01f, 3.51190269e-01f, -9.55908224e-02f, -3.64018045e-02f, 4.56418321e-02f, 7.68477172e-02f, 9.14911106e-02f, 3.83411050e-01f, -5.28814420e-02f, 3.53039838e-02f,
  -1.15040541e-02f, 1.13714337e-02f, -2.04061493e-02f, 5.84929530e-03f, -8.13971367e-03f, -3.67678218e-02f, -2.90906765e-02f, 9.80477780e-02f, -4.08794172e-02f, 8.48062858e-02f,
  1.42400801e-01f, -1.11109585e-01f, 2.93818470e-02f, 7.63263330e-02f, -1.42957613e-01f, -3.54067944e-02f, 8.46051648e-02f, -1.09079845e-01f, -7.04267099e-02f, -1.13967638e-02f,
  7.95391724e-02f, 8.09202716e-02f, 1.31874949e-01f, -8.86548124e-03f, -2.60071903e-02f, 2.58592386e-02f, -3.42672504e-02f, 5.93779199e-02f, -1.11505181e-01f, 7.45010078e-02f,
  1.06608041e-01f, -1.10649511e-01f, -1.22989096e-01f, -1.25487829e-02f, -1.47240251e-01f, -1.00718424e-01f, 4.12142575e-02f, 3.37862596e-02f, -6.52021021e-02f, -1.02140449e-01f,
  -7.58507773e-02f, -4.39021625e-02f, 4.09897603e-02f, 1.12733260e-01f, 2.32205279e-02f, 1.15603521e-01f, 6.58670515e-02f, -5.68430759e-02f, -3.03737260e-02f, -1.10618837e-01f,
  -8.66645481e-03f, -1.08384661e-01f, 2.92609092e-02f, -7.69723654e-02f, 1.33087054e-01f, 1.52099833e-01f, 1.58917218e-01f, 9.70203876e-02f, -8.84318426e-02f, -6.50426839e-03f,
  -1.11716799e-02f, 5.94473071e-02f, -5.19118682e-02f, 1.27236145e-02f, 1.01505205e-01f, -2.72190552e-02f, -8.04716125e-02f, -1.25817824e-02f, 5.86090535e-02f, 3.37425292e-01f,
  -1.17820241e-01f, 5.42237386e-02f, 2.32694939e-01f, 9.29723978e-02f, 2.35719800e-01f, -7.28129223e-02f, 1.57345030e-02f, -3.36492479e-01f, 9.86985564e-02f, -3.61273028e-02f,
  1.90507144e-01f, 7.33768046e-02f, -1.09843560e-01f, 4.04231958e-02f, 1.68858282e-02f, 6.14570342e-02f, 6.06120303e-02f, 1.20654339e-02f, -1.89723894e-01f, 1.36469668e-02f,
  3.11207145e-01f, -9.14825574e-02f, 1.59647819e-02f, 2.52487600e-01f, 4.46999699e-01f, -9.05439258e-02f, -9.59477499e-02f, 3.29420599e-03f, 1.03117168e-01f, -1.40200227e-01f,
  -1.10594153e-01f, -1.30482027e-02f, 3.20713907e-01f, 2.88259029e-01f, 1.14558175e-01f, -9.13161114e-02f, 2.42946651e-02f, -1.95870809e-02f, -9.19699147e-02f, 1.20493673e-01f,
  1.50322720e-01f, 7.79722705e-02f, 1.70262694e-01f, -2.72765998e-02f, -5.49448878e-02f, -1.11872889e-01f, 3.08191001e-01f, -1.59602135e-01f, 1.87305942e-01f, 1.69771537e-01f,
  3.07597667e-01f, 1.80584803e-01f, -2.94022914e-02f, 4.16166848e-03f, -8.64107758e-02f, 2.76489735e-01f, -1.20656881e-02f, -1.16949521e-01f, 1.28502578e-01f, 8.89934599e-02f,
  -1.17538340e-01f, 1.30169705e-01f, -2.96030454e-02f, 1.21846832e-01f, 1.59644783e-01f, 3.32718226e-03f, 9.80111361e-02f, 1.21097863e-01f, -1.12707756e-01f, -2.08579600e-02f,
  8.34987611e-02f, -6.74864799e-02f, -4.58578318e-02f, 7.90516362e-02f, -8.06998685e-02f, -4.70347330e-03f, 6.73985332e-02f, 8.27405453e-02f, 1.88019723e-02f, 7.12575438e-03f,
  -7.10481778e-02f, 1.07246898e-02f, -4.17733528e-02f, 1.05688885e-01f, 1.20564308e-02f, -6.36483207e-02f, -3.92798856e-02f, -2.51284335e-02f, 1.97054422e-03f, -1.42095620e-02f,
  -1.15171984e-01f, 9.23480019e-02f, 1.03770502e-01f, -7.74742514e-02f, -1.20078497e-01f, 5.59101887e-02f, 8.70936140e-02f, -1.35049045e-01f, 6.60430938e-02f, 1.21223398e-01f,
  3.98385711e-03f, -1.99337173e-02f, -1.62054718e-01f, -2.32897177e-02f, -6.84363255e-03f, -4.16913256e-02f, -4.81127499e-04f, 8.00199211e-02f, -3.70677523e-02f, 2.80624460e-02f,
  -1.37177527e-01f, 1.42938271e-01f, 3.59228402e-02f, 1.24458656e-01f, -1.22785633e-02f, 8.01107213e-02f, 1.44899607e-01f, 1.40862837e-01f, -7.21954405e-02f, 7.06852674e-02f,
  -6.27723709e-02f, -6.95585236e-02f, -5.08620963e-02f, -9.77976099e-02f, 3.67425606e-02f, 7.80184120e-02f, 6.47402629e-02f, -4.74839378e-03f, 1.80199325e-01f, 7.38133397e-03f,
  1.48630410e-01f, -5.33746649e-03f, -6.65344521e-02f, 1.47733852e-01f, -9.98242870e-02f, 6.85070530e-02f, -1.62876874e-01f, -2.84898013e-01f, 1.79816745e-02f, 1.62670135e-01f,
  -1.37456983e-01f, -1.48513177e-02f, 6.46705180e-02f, -1.19712934e-01f, 3.71687040e-02f, -9.23828259e-02f, -4.39599622e-03f, -1.49444357e-01f, 5.64962514e-02f, 4.27809991e-02f,
  5.33709466e-01f, 1.49060845e-01f, -1.23443156e-01f, 7.49721155e-02f, 1.11492202e-01f, 3.44387293e-02f, 4.54348661e-02f, -1.22622028e-02f, 2.24629924e-01f, -1.03522763e-01f,
  -9.83198807e-02f, -5.17091379e-02f, 8.82364511e-02f, -1.07175611e-01f, -6.24581659e-03f, -8.11662301e-02f, 1.21606989e-02f, 3.83222848e-02f, -1.36345819e-01f, -9.12986398e-02f,
  -3.79314157e-03f, -6.02543950e-02f, 2.63768554e-01f, 8.93273056e-02f, 9.82808992e-02f, -1.83520596e-02f, 2.20869333e-02f, 1.90617144e-02f, 3.06546509e-01f, 7.59731680e-02f,
  5.50394654e-02f, -1.37273997e-01f, 8.19517747e-02f, -1.76114246e-01f, -3.63607071e-02f, 2.19476908e-01f, -6.55474290e-02f, -6.59554526e-02f, 1.15977995e-01f, -3.83638777e-02f,
  -7.12343827e-02f, 1.14522815e-01f, -9.28435847e-02f, -6.10918030e-02f, 1.17313035e-01f, 2.59297546e-02f, -3.73362890e-03f, 7.13463947e-02f, 1.27683103e-01f, 1.70237646e-02f,
  2.18935627e-02f, 2.59931497e-02f, -1.35273114e-01f, -3.76704670e-02f, 9.75337699e-02f, 2.03906689e-02f, -6.32388890e-02f, -5.22293225e-02f, -3.39316726e-02f, -6.64790422e-02f,
  2.02861473e-01f, -3.28090377e-02f, 8.65120515e-02f, -6.26393482e-02f, -9.57621783e-02f, 2.82965209e-02f, -1.35199174e-01f, -9.79152247e-02f, -1.49749918e-03f, 2.11446546e-02f,
  1.13288891e-02f, 9.64637622e-02f, 2.47796588e-02f, 1.76338502e-03f, -6.40442073e-02f, 1.21604003e-01f, -1.66914724e-02f, 1.44088650e-02f, 9.89222378e-02f, -8.09252560e-02f,
  4.82583940e-02f, 2.89012846e-02f, -5.80568798e-02f, -4.31006029e-02f, 1.37601141e-02f, 1.48417786e-01f, 1.76589862e-02f, 5.89479916e-02f, -1.22100748e-02f, 1.43934250e-01f,
  -4.47084866e-02f, -1.25454113e-01f, -1.42056821e-02f, -1.12427630e-01f, 4.06879708e-02f, 8.98980424e-02f, 1.46063939e-01f, -6.86284453e-02f, 1.65110119e-02f, 2.59888312e-03f,
  1.51611224e-01f, 1.01827510e-01f, -6.87747896e-02f, -8.04496035e-02f, 5.17902561e-02f, 2.60722935e-01f, -1.47410249e-02f, 5.09695709e-02f, 2.93592662e-01f, 2.55250931e-01f,
  -7.10845664e-02f, -8.72451738e-02f, 2.22847000e-01f, -8.36057067e-02f, -1.44315064e-01f, -1.16425842e-01f, -1.29411817e-01f, 7.84508288e-02f, 1.41802296e-01f, 1.78786144e-01f,
  2.98878755e-02f, -8.12049732e-02f, -7.06022158e-02f, 1.06945917e-01f, 7.08602667e-02f, 3.79633904e-02f, -5.46061359e-02f, 1.96464688e-01f, -1.36908486e-01f, -3.78245488e-02f,
  1.45559683e-01f, -7.20310062e-02f, -3.31367142e-02f, -3.38313244e-02f, 5.64668551e-02f, -2.17456166e-02f, 1.18486479e-01f, -1.11024283e-01f, 1.52357034e-02f, -9.44718495e-02f,
  -8.95802155e-02f, -1.28708631e-01f, 1.88961804e-01f, 8.85267034e-02f, -3.25507484e-02f, 1.89642280e-01f, 1.13107212e-01f, -2.27952331e-01f, -7.80731589e-02f, 1.42799214e-01f,
  2.03191653e-01f, -9.36013684e-02f, -6.86351284e-02f, 1.92429528e-01f, 1.81746781e-02f, 2.05919147e-02f, 6.44372776e-02f, -7.98083749e-03f, -1.49876043e-01f, 5.91571592e-02f,
  -1.27061848e-02f, 1.32706419e-01f, 8.67229924e-02f, -2.05614679e-02f, -8.44893605e-02f, -3.58312577e-02f, -1.23645633e-01f, -6.49962053e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -5.48745617e-02f, 1.19232781e-01f, 5.19928373e-02f, 9.23165530e-02f, -3.23765189e-03f, 2.61395991e-01f, 2.76868567e-02f, 2.19018012e-01f, 2.37724781e-01f, 1.45095885e-01f,
  2.87683964e-01f, 1.50586562e-02f, 1.21404365e-01f, 6.26224205e-02f, -6.44026920e-02f, -2.98699252e-02f, 1.46606341e-01f, -3.04689724e-02f, -2.66534835e-02f, 1.07873164e-01f,
  3.16131897e-02f, 2.20504418e-01f, 2.10641205e-01f, 2.90709827e-02f, -3.36202346e-02f, 8.28025565e-02f, 1.70887619e-01f, 9.35724229e-02f, 4.22856323e-02f, 6.74924254e-02f,
  2.53982753e-01f, 2.55702902e-02f, 9.00014713e-02f, 2.37572677e-02f, 1.86083078e-01f, 1.14532642e-01f, 2.91931003e-01f, 2.62188818e-03f, -3.72005552e-02f, 1.94068030e-01f,
  -8.05406459e-03f, 1.90253586e-01f, 1.70393631e-01f, 8.33362713e-02f, 2.80005962e-01f, 1.03008822e-01f, -4.29864600e-02f, 2.53431976e-01f, 1.32773779e-02f, 1.31189004e-01f,
  1.65259048e-01f, 1.36761889e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  5.97381406e-02f, 1.58811852e-01f, 7.90680572e-02f, -9.43253264e-02f, 1.94347590e-01f, -1.21015631e-01f, -1.51105210e-01f, -3.43649954e-01f, -3.53411525e-01f, -2.51730710e-01f,
  2.05763832e-01f, 3.81540865e-01f, -4.94605042e-02f, -8.32775161e-02f, -1.50570691e-01f, -1.02128856e-01f, -1.33974388e-01f, -3.28801244e-01f, -5.49281277e-02f, 2.39851862e-01f,
  1.88846707e-01f, -2.57574581e-02f, 1.60020202e-01f, -2.65408736e-02f, -1.28543034e-01f, -3.20638537e-01f, -8.08958113e-02f, 2.95165986e-01f, -2.70777524e-01f, -7.74660036e-02f,
  -5.18646725e-02f, 1.35291636e-01f, -1.47481069e-01f, 4.52181906e-01f, 2.96475172e-01f, -7.83646032e-02f, -8.26292858e-02f, -2.99715949e-03f, 3.06667477e-01f, -1.77565292e-01f,
  -1.70372650e-01f, -1.84567156e-03f, 7.69182816e-02f, -2.67491430e-01f, 1.25709236e-01f, 2.05633193e-01f, 5.61395809e-02f, 1.37265190e-01f, 2.49625757e-01f, 1.02177709e-01f,
  -1.17729969e-01f, -2.54717529e-01f, 2.17570513e-01f, 2.72932410e-01f, 4.50889282e-02f, 3.21953595e-01f, -4.79321778e-01f, 4.29090947e-01f, 1.31902546e-01f, -3.65105122e-01f,
  -3.44263166e-02f, -1.29619926e-01f, -1.60006851e-01f, -6.19706362e-02f, -1.95287690e-01f, -9.55577046e-02f, 9.17622000e-02f, 2.83802509e-01f, 1.25017567e-02f, 2.28332475e-01f,
  -4.03409481e-01f, 2.94173032e-01f, -3.31359059e-01f, -7.51431137e-02f, -5.98479927e-01f, -6.22892343e-02f, -5.62667474e-02f, -8.82118791e-02f, -1.31284148e-01f, 2.96668291e-01f,
  2.37034149e-02f, -1.16374798e-01f, -1.60970479e-01f, 1.03687607e-01f, -1.74932942e-01f, 5.39166868e-01f, 5.17327823e-02f, -5.72802946e-02f, 1.35202799e-02f, -3.87797147e-01f,
  1.29404664e-01f, -2.89319515e-01f, 1.80460215e-01f, -4.08278480e-02f, 8.89716297e-02f, 2.53490359e-01f, 1.90498158e-02f, 3.41184855e-01f, -2.75423765e-01f, 4.70185906e-01f,
  -1.40536085e-01f, -3.09034903e-02f, 1.58124998e-01f, -4.18509059e-02f, -2.75474340e-01f, 3.86572406e-02f, -2.00937524e-01f, 8.89127608e-03f, -6.92841783e-02f, -2.20564604e-01f,
  -8.60643983e-02f, -8.01926255e-02f, 1.37923226e-01f, 2.08812654e-01f, -1.09758697e-01f, -2.54750639e-01f, -2.58793920e-01f, -3.99739593e-01f, -9.93130263e-03f, 2.07728818e-01f,
  -2.16555953e-01f, 3.95346493e-01f, -1.96709875e-02f, 2.39538640e-01f, 8.73106197e-02f, -1.27782106e-01f, -1.29017523e-02f, 2.67227441e-01f, 2.65053138e-02f, -4.41562504e-01f,
  -1.17709309e-01f, -1.25845883e-03f, -5.19853532e-01f, 2.94869915e-02f, 3.42012525e-01f, 1.02044031e-01f, 4.99770880e-01f, -2.88059190e-02f, -4.55126613e-01f, -2.42841803e-02f,
  -5.10411011e-03f, 9.33510587e-02f, -1.42445698e-01f, 5.01732528e-01f, -1.31582856e-01f, -6.56183437e-02f, -2.78307963e-02f, -2.12752536e-01f, -1.11915335e-01f, -1.25987008e-01f,
  -1.83767349e-01f, 1.86589453e-02f, -1.41768277e-01f, 4.98591423e-01f, 3.19608413e-02f, -1.13286383e-01f, -4.26683528e-03f, 1.40576050e-01f, -4.65299439e-04f, -4.83666621e-02f,
  -1.37612730e-01f, 2.77716875e-01f, -5.79277985e-02f, 5.84927440e-01f, 1.07577458e-01f, 1.87225752e-02f, 4.13262516e-01f, -1.95590585e-01f, -2.47766405e-01f, -9.57814008e-02f,
  -2.37168849e-01f, -1.30314916e-01f, 6.24032877e-03f, -8.85516778e-02f, -1.60426736e-01f, 6.14598580e-02f, -2.26634473e-01f, -1.99333783e-02f, 2.54582405e-01f, -2.21775509e-02f,
  -8.64694081e-03f, 4.21184637e-02f, -8.15622807e-02f, -2.71133363e-01f, -3.90360951e-01f, 3.31726372e-01f, -1.30063340e-01f, -6.63376302e-02f, -1.80231825e-01f, 8.85950401e-02f,
  9.65354294e-02f, -2.54712433e-01f, -2.92138517e-01f, -2.37242460e-01f, -1.62656263e-01f, 6.80476651e-02f, -3.97052348e-01f, -2.61609197e-01f, -6.85670078e-02f, -4.36469972e-01f,
  -2.53789365e-01f, 1.29917175e-01f, 4.28928912e-01f, 2.57541746e-01f, 8.82436708e-02f, 2.55432457e-01f, 9.16757062e-02f, -2.94995397e-01f, -1.13182396e-01f, 3.75584438e-02f,
  1.09696656e-01f, -2.54114747e-01f, -3.62277806e-01f, -1.40036672e-01f, 2.47721717e-01f, 1.32210851e-01f, -2.21859157e-01f, -1.34204283e-01f, -1.72425658e-02f, 2.50147104e-01f,
  -2.30015516e-01f, 9.72921923e-02f, -4.97865006e-02f, -1.08469591e-01f, -1.92031965e-01f, -2.27629513e-01f, 5.18003464e-01f, -3.10834140e-01f, 4.95483056e-02f, 6.04595840e-01f,
  -1.84638023e-01f, 1.35361785e-02f, 2.06146851e-01f, 2.50413507e-01f, -3.13629419e-01f, 2.79441506e-01f, 3.45530943e-03f, 3.11863065e-01f, 1.05205156e-01f, -1.35501117e-01f,
  -1.36458680e-01f, 9.98461898e-03f, -5.92857925e-03f, 2.23824054e-01f, 2.46436950e-02f, -1.42564267e-01f, 2.73181677e-01f, 2.46659100e-01f, 2.05745518e-01f, -2.51173526e-01f,
  1.71989836e-02f, -5.13119660e-02f, 4.68337275e-02f, -2.63462961e-01f, 1.00375228e-01f, -2.50240862e-01f, 3.51676971e-01f, 2.41392553e-01f, 2.14243278e-01f, 2.44467974e-01f,
  -2.55015939e-01f, 1.81057185e-01f, 2.93384820e-01f, 3.65177505e-02f, 4.56897169e-01f, 1.78325966e-01f, 4.82237279e-01f, 2.12052375e-01f, -1.49853542e-01f, 7.39317909e-02f,
  -1.54391497e-01f, -1.52174562e-01f, 4.34407443e-02f, 2.00160012e-01f, 1.02698132e-01f, 2.37877935e-01f, 1.74863279e-01f, -1.10142447e-01f, 2.68764228e-01f, -2.03839347e-01f,
  -5.60654327e-02f, -5.08510694e-02f, 4.33447473e-02f, 1.47144288e-01f, -1.11511219e-02f, 1.26027074e-02f, -3.90730146e-03f, 5.85724227e-02f, 1.77326679e-01f, 1.52203351e-01f,
  4.75435287e-01f, -1.09960977e-03f, -1.39492348e-01f, 8.80317166e-02f, -4.25092101e-01f, 2.42759824e-01f, 3.92821789e-01f, 3.11248880e-02f, -8.42734873e-02f, 8.32181498e-02f,
  -1.11666746e-01f, -1.98453981e-02f, 9.56637487e-02f, -9.81734991e-02f, 4.55677032e-01f, 1.20124249e-02f, 1.56405285e-01f, 2.26270974e-01f, -1.38677478e-01f, 1.54947743e-01f,
  1.76505789e-01f, 4.32300046e-02f, -2.24053249e-01f, -1.66685000e-01f, 3.13401856e-02f, -3.04133296e-01f, 1.64740235e-01f, -2.50403583e-01f, 2.72535056e-01f, 3.96024853e-01f,
  3.53212953e-01f, 2.24486645e-02f, 8.68088827e-02f, 1.95964962e-01f, 2.64878541e-01f, 4.96014506e-01f, 1.91394589e-04f, 1.83324859e-01f, -5.40352702e-01f, 7.19960928e-02f,
  9.31486487e-02f, -2.93928504e-01f, -1.69101693e-02f, -8.95715207e-02f, 3.63243520e-02f, -1.16142422e-01f, -6.15756623e-02f, 5.72025739e-02f, 1.05636507e-01f, -1.94246173e-01f,
  3.83468568e-01f, 3.51828009e-01f, -1.61277533e-01f, 9.15465429e-02f, -7.40493536e-02f, -1.82182565e-01f, 1.75815914e-02f, 1.47593990e-01f, 2.98174471e-01f, -9.14179906e-02f,
  2.41575107e-01f, -6.89296424e-03f, -3.01306397e-02f, -2.98849136e-01f, -1.93468437e-01f, -2.37554520e-01f, -1.40323102e-01f, -9.57258642e-02f, -2.11845309e-01f, 3.94561410e-01f,
  8.98299664e-02f, 6.04743287e-02f, 6.28061533e-01f, -1.61162853e-01f, 1.57129362e-01f, 2.06361664e-03f, 2.33334169e-01f, 1.19505316e-01f, 2.14870125e-01f, -1.27641305e-01f,
  -3.16431932e-02f, -3.14351976e-01f, -1.48147821e-01f, 2.70895898e-01f, -2.57337064e-01f, -6.43995702e-02f, -1.97251514e-01f, 2.95778140e-02f, 2.68264294e-01f, 3.59163165e-01f,
  -9.15490761e-02f, 1.08866118e-01f, 4.53112572e-02f, 2.31153145e-01f, -1.06792703e-01f, -2.24138364e-01f, 1.93416908e-01f, -2.39479855e-01f, 3.22802186e-01f, -6.77690059e-02f,
  3.94097865e-01f, 1.80317745e-01f, 4.76544768e-01f, 3.36212814e-01f, -6.66176453e-02f, -4.02185500e-01f, 2.58923955e-02f, -4.53130156e-02f, 1.41976625e-01f, 5.98013341e-01f,
  -4.66310531e-02f, -3.62670198e-02f, -1.29231764e-02f, -2.80342966e-01f, 3.14136408e-02f, -5.71573079e-02f, -9.05015171e-02f, 6.09525517e-02f, 4.10062641e-01f, 4.28622633e-01f,
  -8.07864778e-03f, -7.87089318e-02f, -1.37168467e-01f, 1.31648540e-01f, 3.23998004e-01f, -1.61414936e-01f, 1.93481669e-01f, 1.43998668e-01f, -2.49471277e-01f, -3.30971815e-02f,
  -1.63167670e-01f, 2.16210056e-02f, -2.44030505e-01f, 3.00864965e-01f, 3.15098733e-01f, -1.12643227e-01f, 1.02033988e-01f, -2.55061407e-02f, -3.06859072e-02f, 2.03380715e-02f,
  1.36125401e-01f, 2.01813266e-01f, 4.94988002e-02f, 9.38296691e-02f, -1.55902356e-01f, -3.48289996e-01f, 5.69772646e-02f, 8.78673196e-02f, 6.96649251e-04f, -2.91801691e-01f,
  2.23156571e-01f, -3.38817835e-01f, -1.32763788e-01f, -1.00345549e-03f, -2.04168148e-02f, 4.48771894e-01f, -1.33151963e-01f, -1.79190949e-01f, -3.12120855e-01f, -2.76143014e-01f,
  -2.04276085e-01f, -1.42550275e-01f, -2.00810239e-01f, -5.65846153e-02f, -2.47010157e-01f, 1.30667523e-01f, -4.39977609e-02f, -4.98155683e-01f, 1.41671792e-01f, 3.11204698e-02f,
  3.28996599e-01f, -1.66841894e-01f, 5.40295303e-01f, -2.76921451e-01f, 8.27709287e-02f, 1.75710052e-01f, 7.65889809e-02f, 1.74508289e-01f, 3.13751668e-01f, -1.42968968e-01f,
  -1.98688820e-01f, 5.16390651e-02f, -4.23110090e-02f, -1.76724479e-01f, -5.38913347e-03f, 1.86625347e-01f, -1.23126261e-01f, 9.20841694e-02f, 1.29318595e-01f, 9.17592458e-03f,
  -8.92269090e-02f, -2.74699867e-01f, 2.05482766e-01f, 1.03601530e-01f, 2.68031564e-02f, 2.24319339e-01f, -2.36877918e-01f, -1.65025204e-01f, -1.12058051e-01f, -3.56699154e-02f,
  -2.20248967e-01f, 5.67041561e-02f, 8.91932771e-02f, 1.14225022e-01f, -1.17443211e-01f, 2.65086323e-01f, -2.87621200e-01f, 1.61784321e-01f, -1.36738420e-02f, 6.40745521e-01f,
  -1.30574033e-01f, 2.48262838e-01f, -1.82043950e-05f, 1.44513324e-01f, -2.22532913e-01f, -1.94250762e-01f, 4.39492688e-02f, -7.81913102e-02f, -1.29062071e-01f, -7.99316019e-02f,
  4.68834676e-02f, 1.50887549e-01f, -1.89814474e-02f, -1.41680077e-01f, -1.29976332e-01f, -1.38974190e-01f, -2.63937175e-01f, -4.29632038e-01f, -1.20617755e-01f, -6.87942952e-02f,
  -1.26717031e-01f, 1.25015631e-01f, -3.71964633e-01f, 1.48141518e-01f, -1.44217551e-01f, 2.12398335e-01f, -1.28543575e-03f, -1.22364335e-01f, -2.20634596e-04f, -2.13736251e-01f,
  -1.36182010e-01f, -1.84731632e-01f, -1.94285244e-01f, -2.30315223e-01f, -1.62757501e-01f, 2.39593282e-01f, -2.33262628e-01f, 1.78589240e-01f, 1.90573394e-01f, 2.24984940e-02f,
  3.44682723e-01f, -1.60086840e-01f, -9.93707031e-02f, 7.03777093e-03f, 3.59468237e-02f, -2.04342872e-01f, -1.64674550e-01f, -1.04470095e-02f, -1.26502916e-01f, -8.66204128e-02f,
  3.84386301e-01f, -1.12051457e-01f, 5.23370877e-03f, -1.58050150e-01f, -7.93476403e-02f, 3.72707725e-01f, -3.37198637e-02f, -1.25105977e-01f, 3.19687314e-02f, 6.84963390e-02f,
  -2.74928778e-01f, -9.68291685e-02f, 5.20189889e-02f, -7.55166560e-02f, 1.62853822e-01f, -2.68664092e-01f, 2.18362324e-02f, -2.21362725e-01f, 2.83155799e-01f, -2.66200919e-02f,
  -3.12216133e-02f, 8.09864104e-01f, -4.95648384e-02f, -1.57562122e-01f, -9.72127393e-02f, -1.71243280e-01f, -4.10339758e-02f, 1.90329462e-01f, -3.17204982e-01f, 1.35914192e-01f,
  1.92577004e-01f, -7.08888918e-02f, 3.39640379e-01f, -1.06823966e-02f, 7.18495727e-01f, -2.29736418e-01f, 1.07757501e-01f, -5.54325521e-01f, -9.97449756e-02f, -1.18715286e-01f,
  -4.00712155e-02f, -3.57790850e-02f, 1.51416436e-01f, 1.14404587e-02f, -2.24608362e-01f, 4.38606590e-01f, 1.96965933e-01f, -5.81346340e-02f, -6.01820238e-02f, 7.21008852e-02f,
  3.03090066e-01f, -2.21742854e-01f, 1.35136098e-01f, -5.82115017e-02f, -2.50222892e-01f, -6.83701113e-02f, -3.34829614e-02f, 7.02768490e-02f, 2.21434221e-01f, 7.51918554e-03f,
  -4.65514719e-01f, 1.90423146e-01f, 2.39373654e-01f, -8.08706284e-02f, 1.63800880e-01f, -5.18652759e-02f, -1.71263218e-01f, -7.30681568e-02f, 1.16664618e-01f, -2.79138148e-01f,
  -9.48860031e-03f, -1.15435801e-01f, -1.52630778e-02f, -1.08994924e-01f, 4.05076206e-01f, -3.30754854e-02f, 1.60042375e-01f, 5.05837023e-01f, 7.43265599e-02f, 3.29394788e-01f,
  2.92071439e-02f, -5.39473742e-02f, -1.90353066e-01f, -8.18033814e-02f, -2.22335104e-02f, -5.05840182e-01f, -2.27567434e-01f, 5.65466523e-01f, -6.86096549e-02f, -1.00295290e-01f,
  2.11345389e-01f, 1.92005739e-01f, 1.27233148e-01f, -6.86621442e-02f, 3.56893182e-01f, -1.03233054e-01f, -4.06195909e-01f, -1.44349948e-01f, -3.84427488e-01f, 3.07236195e-01f,
  -3.39319795e-01f, 3.00655395e-01f, -1.30155414e-01f, -1.19573008e-02f, -6.79869354e-02f, -2.21446138e-02f, -1.34297267e-01f, 2.17560261e-01f, 3.70799974e-02f, 1.69322759e-01f,
  -2.90981859e-01f, -5.77891478e-03f, 8.81055236e-01f, 4.34411876e-02f, -1.67676166e-03f, 5.38610101e-01f, -1.53122559e-01f, -2.13039387e-02f, -8.88134763e-02f, -1.61271363e-01f,
  -3.99240442e-02f, 8.63479227e-02f, 9.99577567e-02f, -4.78832610e-02f, 2.67098248e-01f, -9.42939520e-02f, -1.65131949e-02f, -1.09765120e-01f, -3.22182149e-01f, -9.51642022e-02f,
  -3.14431369e-01f, -4.37935889e-02f, -1.21293344e-01f, 3.95259291e-01f, 8.03674981e-02f, 1.01032011e-01f, -1.10088162e-01f, 1.31425429e-02f, -1.96399078e-01f, -3.63033526e-02f,
  -7.34786363e-03f, 1.97843179e-01f, -1.23356827e-01f, -4.68565196e-01f, -1.15006559e-01f, 6.80702031e-02f, 1.15372524e-01f, -8.69411156e-02f, 2.25188793e-03f, 1.30528688e-01f,
  1.62522241e-01f, -1.59656942e-01f, -6.98117316e-02f, -1.98320031e-01f, 1.81832954e-01f, -4.11056317e-02f, 5.92246577e-02f, -2.71511823e-01f, 8.76601487e-02f, 1.30049229e-01f,
  -2.98226535e-01f, -2.51139879e-01f, -2.27817386e-01f, 3.02123010e-01f, 4.78449613e-01f, 5.57335578e-02f, -1.07949801e-01f, 1.11232318e-01f, 9.52497870e-02f, 2.17108101e-01f,
  4.14469182e-01f, 4.20071453e-01f, 3.87807369e-01f, 2.74819899e-02f, -1.40797392e-01f, 2.76453085e-02f, -2.76087016e-01f, 1.02195404e-01f, -8.67533758e-02f, -9.88289714e-04f,
  -6.19564280e-02f, -2.93074362e-02f, 1.47884905e-01f, -1.36329100e-01f, 3.71860750e-02f, 3.11874542e-02f, -4.50850837e-02f, -1.97337583e-01f, -3.29125792e-01f, -1.77504674e-01f,
  -6.66824877e-02f, 3.99448834e-02f, -1.44970000e-01f, 5.34939542e-02f, 2.91520894e-01f, 2.22803205e-01f, 2.49215662e-01f, 1.22277968e-01f, -1.38024420e-01f, -7.18316808e-02f,
  -2.01190151e-02f, -1.43616259e-01f, -1.43226802e-01f, -3.79000120e-02f, 8.66733789e-02f, -2.11872637e-01f, -1.20511912e-02f, -9.23749581e-02f, -7.61507973e-02f, -2.12514609e-01f,
  8.83646369e-01f, -2.69969106e-01f, 1.49214305e-02f, -1.89573511e-01f, -1.32393941e-01f, -2.44381264e-01f, 1.66653633e-01f, -2.65978009e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.56676993e-01f, 3.15369666e-02f, -1.32728904e-01f, -7.56693557e-02f, 2.83828713e-02f, 4.72461358e-02f, 8.75466987e-02f, -8.04772750e-02f, -9.92084742e-02f, 4.26057428e-02f,
  1.02072358e-02f, -8.26645046e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    