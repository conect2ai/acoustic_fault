/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.04991673e-02f, 1.37792096e-01f, -5.59686363e-01f, 8.19410384e-02f, 1.30502179e-01f, -1.88381597e-01f, -1.90886512e-01f, 4.18798923e-02f, -2.59985119e-01f, 1.41169190e-01f,
  1.35720208e-01f, -4.42210361e-02f, -8.70743021e-03f, -4.78039831e-02f, 1.27159685e-01f, -1.23808764e-01f, 8.07998795e-03f, -1.74771063e-02f, -1.45060316e-01f, -4.37492654e-02f,
  -5.48368767e-02f, 2.71387100e-01f, -7.58926943e-02f, 5.41262850e-02f, 6.63718209e-02f, 6.52231723e-02f, 3.38927656e-01f, -1.61302313e-01f, 1.41039893e-01f, 1.57469675e-01f,
  -1.10416161e-02f, -4.95869666e-02f, -9.20550749e-02f, -4.79693301e-02f, 7.61640370e-02f, 1.02319069e-01f, 4.62138653e-03f, -1.40329584e-01f, 1.17433136e-02f, -1.57996006e-02f,
  -5.14557073e-03f, -6.17946498e-02f, -1.00898229e-01f, -1.65954884e-02f, -2.98411809e-02f, -5.09238802e-02f, -6.34518191e-02f, 1.02769129e-03f, -1.19388439e-01f, -8.30971748e-02f,
  -1.01087904e-02f, -1.46292476e-02f, -1.43093485e-02f, 9.11951065e-04f, -4.07941155e-02f, -7.97834322e-02f, -9.68803614e-02f, 8.21994767e-02f, 1.27264395e-01f, -1.53033743e-02f,
  -1.19737005e-02f, 6.56599775e-02f, 1.32151609e-02f, -2.79893377e-03f, 5.22575416e-02f, 4.68432643e-02f, -1.57409385e-02f, 9.68223810e-03f, 6.78302571e-02f, 1.38197631e-01f,
  4.23999466e-02f, 1.21608637e-01f, 4.21481133e-02f, 3.87294069e-02f, 3.17674279e-02f, 2.85130716e-03f, -4.34209444e-02f, 4.43893997e-03f, -7.08290376e-03f, -7.14135496e-03f,
  -1.58464927e-02f, 5.24334200e-02f, 7.16929063e-02f, -1.14119295e-02f, 4.04118076e-02f, -1.62723865e-02f, 3.74887697e-02f, -3.24477591e-02f, -2.78143808e-02f, 8.23625247e-04f,
  3.29310596e-01f, 1.42906442e-01f, 3.43406163e-02f, 1.13632716e-02f, -3.75519022e-02f, 1.83106326e-02f, -1.10958159e-01f, 1.23831909e-02f, 6.26265705e-02f, -1.97689310e-02f,
  -3.78686041e-02f, -1.58234164e-02f, 4.14051414e-02f, -1.84301138e-02f, 1.39156478e-02f, 4.84117828e-02f, 1.73031799e-02f, 2.72744410e-02f, 1.55654877e-01f, 6.25598431e-02f,
  1.78428441e-02f, 1.36491619e-02f, -1.00346819e-01f, 2.98212771e-03f, 1.07776873e-01f, 7.54597858e-02f, 8.05564597e-02f, -6.86183870e-02f, -1.16237300e-02f, 3.89433764e-02f,
  2.75950342e-01f, -4.30125669e-02f, -1.97455019e-01f, 3.50088388e-01f, 7.99769685e-02f, -4.46176417e-02f, -1.24669082e-01f, 1.03096075e-01f, 6.11978546e-02f, 2.46319808e-02f,
  2.03586385e-01f, 5.38909510e-02f, -8.97141770e-02f, 4.80408460e-01f, 2.59999573e-01f, 5.37755825e-02f, 3.10693771e-01f, 2.60905743e-01f, -2.14901729e-03f, 1.08642332e-01f,
  1.23406611e-01f, 2.72045016e-01f, 1.24826320e-01f, 7.83940628e-02f, -6.65096268e-02f, -3.88260297e-02f, 1.34545630e-02f, -1.15649566e-01f, 1.60827398e-01f, 1.29049104e-02f,
  8.31349865e-02f, 1.15564160e-01f, 5.11060245e-02f, -5.51309735e-02f, 3.23743150e-02f, -3.16431820e-02f, -8.99034962e-02f, -6.57485612e-03f, -7.97762722e-02f, -5.01706684e-03f,
  -1.06029652e-01f, 4.75863665e-02f, 3.98508273e-02f, -3.16857211e-02f, -4.00995016e-02f, 4.19322401e-02f, -3.20313801e-03f, -3.16034742e-02f, 1.01018995e-02f, 2.46986635e-02f,
  -1.80964842e-02f, 3.85201946e-02f, 9.32383165e-02f, 6.22684024e-02f, 1.11535203e-03f, 1.41305123e-02f, -2.83207241e-02f, -1.97668225e-02f, 3.69363315e-02f, 4.60710078e-02f,
  -1.05302064e-02f, -3.44019383e-02f, 1.48435542e-02f, 3.34203214e-04f, -2.24599224e-02f, 5.72643019e-02f, -4.12912518e-02f, 9.01961550e-02f, -5.31807952e-02f, 3.69418561e-02f,
  3.10390834e-02f, 9.57089011e-03f, 3.86882573e-03f, 5.04307495e-03f, 1.08592939e-02f, -5.19336052e-02f, -7.42591452e-04f, 3.51513103e-02f, 3.29250097e-02f, 6.77949339e-02f,
  3.72874029e-02f, 1.55063923e-02f, -1.00998739e-02f, 3.67054861e-04f, -1.26504079e-02f, 1.76353622e-02f, 5.20789400e-02f, 2.20234301e-02f, -7.54284859e-02f, -6.87324405e-02f,
  2.79919207e-02f, 7.12944269e-02f, -1.67199131e-02f, -3.93396290e-03f, -3.56359892e-02f, -2.93096825e-02f, 6.67075068e-02f, 1.22452378e-02f, -1.06230058e-01f, 3.06006726e-02f,
  -2.63596158e-02f, -4.38761525e-02f, -7.85805434e-02f, 5.34405336e-02f, 6.26985729e-02f, -5.18513285e-02f, -1.27828149e-02f, -9.15327221e-02f, 2.45597158e-02f, 6.64302111e-02f,
  -8.92660022e-03f, -6.04657494e-02f, -6.53577223e-02f, 7.04266969e-03f, 2.94872038e-02f, -2.32874360e-02f, 2.03791633e-03f, -2.42160726e-02f, 2.71493457e-02f, -3.75889242e-02f,
  1.88981935e-01f, -2.69565552e-01f, 4.65567969e-02f, -4.41057473e-01f, 9.67379808e-02f, -1.66154683e-01f, -1.11269116e-01f, -1.28979161e-01f, -3.14936340e-01f, -1.41399214e-02f,
  9.27788988e-02f, 2.78430283e-01f, -5.72125092e-02f, -2.28102461e-01f, -2.23992094e-02f, -2.06707597e-01f, -3.47646356e-01f, 2.97487304e-02f, -1.81630462e-01f, 4.91533428e-02f,
  -9.21763331e-02f, -2.44276807e-01f, -4.90061790e-02f, -3.35848294e-02f, 4.45269383e-02f, 4.29454409e-02f, 5.86449429e-02f, 9.12535340e-02f, 1.21877342e-01f, 2.87163518e-02f,
  -3.23315151e-02f, 2.15922706e-02f, 1.31687045e-01f, -2.27494687e-02f, -2.54329983e-02f, 4.77145314e-02f, 4.70919907e-02f, 5.09044863e-02f, -4.43939527e-04f, 1.37224589e-02f,
  2.25155540e-02f, 7.00043689e-04f, -2.31166519e-02f, 1.44373477e-02f, -7.90943578e-03f, 7.55939707e-02f, -2.39191931e-02f, -5.80746830e-02f, 3.58339623e-02f, -3.06458678e-03f,
  1.03389635e-03f, -6.87529445e-02f, -6.10088967e-02f, -4.21619155e-02f, 3.93961295e-02f, -3.96255478e-02f, -5.79063743e-02f, 1.27540141e-01f, 4.59279539e-03f, -9.67940167e-02f,
  4.92895693e-02f, 1.50459749e-03f, -2.66159941e-02f, 5.22178151e-02f, -1.42582869e-02f, 1.01048946e-02f, 6.40885904e-02f, 2.16541812e-02f, 3.55131328e-02f, -9.26456600e-03f,
  -1.53116640e-02f, -3.00818551e-02f, -4.59704734e-02f, 7.46192411e-02f, -2.52071936e-02f, -1.27350772e-02f, 5.62831350e-02f, 4.91824374e-02f, -5.45046180e-02f, 3.10514383e-02f,
  -3.83295566e-02f, -7.65373409e-02f, 7.18501285e-02f, -9.83678177e-02f, -2.06648968e-02f, 7.25486502e-02f, -6.75582811e-02f, 4.59556021e-02f, 2.12825667e-02f, 1.28433947e-02f,
  -5.34177274e-02f, -1.97242066e-01f, 4.09365818e-03f, 3.42803895e-02f, 3.17234807e-02f, 4.92389724e-02f, -7.57844001e-02f, 4.60322760e-02f, -7.97978491e-02f, -2.68093571e-02f,
  1.19715989e-01f, 7.94502441e-03f, -3.38179320e-02f, 5.47385812e-02f, 2.98311822e-02f, -1.82974208e-02f, -6.65394515e-02f, 2.88656969e-02f, -8.46867114e-02f, 5.66162542e-02f,
  3.92299816e-02f, 1.14738189e-01f, 1.68964695e-02f, 7.03129498e-03f, 2.42166407e-02f, 5.28011769e-02f, 6.91889320e-03f, 4.92357723e-02f, 4.38166708e-02f, -2.01303121e-02f,
  -6.99803591e-01f, -7.01222420e-02f, -2.35919654e-01f, 7.49051198e-02f, -6.09419458e-02f, -1.00103028e-01f, 2.97256317e-02f, -6.90592900e-02f, -3.43833625e-01f, 1.47601306e-01f,
  9.65181142e-02f, -2.32518673e-01f, 1.47550823e-02f, 2.82560289e-02f, -1.76162720e-01f, 1.09908111e-01f, 4.54741456e-02f, -1.22990020e-01f, -6.30253628e-02f, -8.55306257e-03f,
  -4.51572835e-02f, 4.69149090e-02f, -6.28648549e-02f, 1.92335974e-02f, -1.79348171e-01f, -1.28953978e-01f, 1.80203199e-01f, 2.38648318e-02f, 1.46582388e-04f, 7.82027002e-03f,
  -7.52949193e-02f, 5.72673120e-02f, -4.10804041e-02f, -6.77340552e-02f, -5.07085919e-02f, -3.24747339e-02f, -3.80019918e-02f, 7.71421269e-02f, -3.01643070e-02f, 3.81898768e-02f,
  -4.28079851e-02f, -5.98849021e-02f, 1.07872091e-01f, -2.35797614e-02f, -6.35979474e-02f, -5.05119264e-02f, -6.39328882e-02f, -7.13248700e-02f, -5.28816171e-02f, 5.94076402e-02f,
  -1.14771895e-01f, -7.44580925e-02f, 1.14962063e-03f, 4.22096171e-04f, -2.61740293e-02f, 1.67502128e-02f, 4.63655703e-02f, 6.47239313e-02f, -5.83131704e-03f, -2.54683699e-02f,
  -2.55351178e-02f, -9.51010827e-03f, 9.45296139e-04f, -5.78045845e-02f, -1.62325539e-02f, -3.46511863e-02f, -4.97594057e-03f, 5.67655973e-02f, -1.52856588e-01f, -4.85367794e-03f,
  -6.36119163e-04f, -3.89136076e-02f, 5.56288892e-03f, -1.47839949e-01f, 4.59355153e-02f, -1.14608910e-02f, 6.39575627e-03f, 3.82830277e-02f, -7.79077858e-02f, -1.52637316e-02f,
  6.03767931e-02f, -2.81272233e-02f, 7.53549347e-03f, 8.14668685e-02f, 5.91892265e-02f, 1.09583382e-02f, -5.43123744e-02f, -6.77308664e-02f, 9.59329605e-02f, 5.17851226e-02f,
  1.83096662e-01f, 2.11835161e-01f, 5.85056357e-02f, -7.04325587e-02f, 5.57650775e-02f, 2.93714497e-02f, 9.93301719e-03f, -8.01380724e-02f, 2.59302687e-02f, -2.06099823e-02f,
  -3.65369096e-02f, 4.07180637e-02f, -3.50599810e-02f, 2.82784179e-02f, -2.97748726e-02f, 9.61643755e-02f, 7.83375502e-02f, 5.27757965e-02f, -8.24675895e-03f, -1.96203310e-02f,
  2.59341020e-03f, -3.83981578e-02f, -3.42316143e-02f, -3.70977968e-02f, 1.13034453e-02f, 6.07254356e-02f, 6.16157008e-03f, -3.93681936e-02f, 6.15662802e-03f, -4.68128547e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.19100386e-01f, -1.76364645e-01f, 5.18548973e-02f, 3.07742715e-01f, -5.51298521e-02f, -6.06892586e-01f, -7.98333168e-01f, 2.85297614e-02f, -4.13286537e-01f, -3.35625589e-01f,
  2.50271447e-02f, -3.10713321e-01f, -2.67200112e-01f, -9.21035632e-02f, 2.47479200e-01f, -4.18929189e-01f, 9.81412008e-02f, -1.33559778e-01f, -1.27875701e-01f, 2.42232516e-01f,
  2.39807084e-01f, 2.69578159e-01f, 2.47529954e-01f, 3.61537963e-01f, 1.04045672e-02f, 3.44088525e-01f, 6.09895408e-01f, 1.11035399e-01f, 3.70868087e-01f, -1.03151677e-02f,
  -2.08278194e-01f, -3.74019332e-02f, -1.36807570e-02f, -2.59184111e-02f, 6.14613574e-03f, 3.06018349e-03f, -9.59375054e-02f, 5.79735683e-03f, 5.59803322e-02f, 5.66242188e-02f,
  -2.55174376e-02f, 1.11360170e-01f, 7.30103701e-02f, 3.83034125e-02f, -7.43563995e-02f, 1.76131690e-03f, -3.15955766e-02f, -1.82973877e-01f, -7.56464303e-02f, -1.84027560e-03f,
  -1.85741037e-02f, 4.90188040e-02f, 1.13090031e-01f, -3.62397879e-02f, 1.66993756e-02f, -5.06529491e-03f, -3.13378274e-02f, -6.72561899e-02f, -5.03147580e-02f, 4.80411015e-02f,
  7.46356845e-02f, -2.13754773e-02f, -7.01444522e-02f, -3.37664187e-02f, 1.58456806e-02f, 3.29327919e-02f, -1.50680050e-01f, -1.72161255e-02f, 1.25121653e-01f, -1.15066476e-01f,
  -4.17992147e-03f, -6.16790876e-02f, -9.94669460e-03f, 4.35254052e-02f, 1.13434875e-02f, -1.46234380e-02f, 1.92341954e-02f, 9.99742821e-02f, 6.28183084e-03f, -2.66711451e-02f,
  2.26758681e-02f, 8.83996487e-02f, -4.17273715e-02f, -8.03207010e-02f, 6.11977512e-03f, 1.00793652e-01f, -2.83956039e-03f, -2.52268519e-02f, -5.57178035e-02f, 1.49271097e-02f,
  -5.83676323e-02f, 2.52844244e-01f, 4.19195034e-02f, -9.39971954e-03f, 5.59364706e-02f, 5.72731681e-02f, 1.00664258e-01f, 5.01255095e-02f, 1.12013862e-01f, -4.83187512e-02f,
  9.06648040e-02f, 5.38450386e-03f, -1.95371192e-02f, 5.34903109e-02f, 9.83703285e-02f, -4.10348624e-02f, 6.14729002e-02f, 1.31461993e-01f, 1.32996082e-01f, 9.56155583e-02f,
  1.20721839e-01f, -2.43140087e-02f, 5.45962192e-02f, -7.12237656e-02f, -1.71153136e-02f, -1.44109726e-02f, -3.02931424e-02f, 2.33285874e-02f, 1.33622944e-01f, 2.40073516e-03f,
  4.85150218e-01f, 2.69299507e-01f, 5.91263413e-01f, 2.04984859e-01f, -1.08539313e-01f, 2.41840288e-01f, 3.96748275e-01f, -1.66647732e-01f, 2.64278233e-01f, -2.66580045e-01f,
  -3.44939977e-01f, 5.08544981e-01f, 5.96562773e-02f, 1.44301541e-02f, 1.57343090e-01f, 6.68734312e-02f, -4.35449593e-02f, 3.08258757e-02f, 3.99052072e-03f, -1.68311343e-01f,
  -7.78473020e-02f, -3.43992800e-01f, -4.09820825e-02f, -4.79878277e-01f, -9.77260023e-02f, -1.00960709e-01f, -3.35550308e-01f, 1.24706246e-01f, -3.16457659e-01f, 9.39771086e-02f,
  -7.95932859e-02f, -3.58182681e-03f, -3.08657419e-02f, 6.97945654e-02f, 3.13963951e-03f, 3.96283455e-02f, 3.24073657e-02f, 6.36273175e-02f, 7.37138093e-02f, 1.36165813e-01f,
  7.74316639e-02f, -8.47545117e-02f, 1.17813163e-02f, 8.99520442e-02f, -9.53599960e-02f, 6.99504241e-02f, 7.35001564e-02f, -1.76614057e-02f, -2.57224869e-02f, 1.30240887e-01f,
  1.20396338e-01f, -3.50100473e-02f, 1.31472927e-02f, 6.87149093e-02f, 4.93192375e-02f, 2.85779703e-02f, 4.13211025e-02f, 1.16777122e-01f, 6.66834638e-02f, -3.19463462e-02f,
  -1.25059813e-01f, 5.26491087e-03f, 4.46594618e-02f, -1.50428057e-01f, -2.79915649e-02f, -6.53528571e-02f, -7.09388405e-02f, -9.24579613e-03f, 5.30495755e-02f, -3.49120162e-02f,
  -1.04953796e-02f, -4.63298969e-02f, 1.02858372e-01f, -7.10898777e-03f, -7.34650418e-02f, -4.66531999e-02f, 6.21333718e-02f, 5.87837137e-02f, 8.10003653e-03f, -2.70782113e-02f,
  4.68380041e-02f, 5.13990298e-02f, -2.84907725e-02f, -3.05166114e-02f, 5.70328645e-02f, 7.15250522e-02f, -1.38921142e-01f, 5.82488738e-02f, 3.52007374e-02f, -9.96412244e-04f,
  -6.79789931e-02f, 4.17121574e-02f, -8.09879787e-03f, 9.37847327e-03f, 8.67308825e-02f, -6.12243526e-02f, -6.95321802e-03f, -3.07143684e-02f, 4.68091518e-02f, -3.84229422e-02f,
  -1.23328947e-01f, 6.43862858e-02f, 1.76410787e-02f, 1.53799187e-02f, -2.15917453e-02f, -3.56123373e-02f, 5.87735921e-02f, -2.81916000e-02f, -6.52295426e-02f, -1.09826013e-01f,
  -6.27929568e-02f, 3.59062478e-02f, 4.21047024e-02f, -7.17407987e-02f, -8.05635899e-02f, 6.87979208e-03f, 9.16415155e-02f, -3.80917382e-03f, 3.01180705e-02f, 3.76604162e-02f,
  2.02395365e-01f, -3.88730019e-01f, -1.72247604e-01f, -2.31987014e-01f, -3.00113000e-02f, -3.23474735e-01f, -1.96384966e-01f, -5.67567289e-01f, -4.98310924e-02f, -3.92911822e-01f,
  -1.68827668e-01f, 2.52442747e-01f, 3.07934076e-01f, -5.26568115e-01f, 7.22989857e-01f, 3.12544376e-01f, -4.60135281e-01f, -1.60811916e-01f, 9.28433426e-03f, -3.45166177e-01f,
  3.05412952e-02f, -4.78865921e-01f, 8.19789153e-03f, -5.00218332e-01f, -3.41390491e-01f, -2.43194625e-01f, 1.57934636e-01f, 1.16052240e-01f, -2.20752463e-01f, 8.08506906e-02f,
  -5.53934015e-02f, 1.88234448e-02f, -2.36901075e-01f, -9.70988360e-04f, -3.09454370e-02f, -1.38282543e-02f, -9.70249716e-03f, 2.28761584e-01f, -2.55316999e-02f, 9.73581597e-02f,
  4.53954339e-02f, 8.08646381e-02f, -9.25496742e-02f, 8.20962191e-02f, -7.21264854e-02f, -5.86522631e-02f, 4.26396243e-02f, 1.87948290e-02f, -1.18850537e-01f, -2.40826886e-03f,
  5.71628101e-02f, 1.24750286e-01f, -3.61820944e-02f, -6.93213865e-02f, 2.15587616e-02f, -1.29937321e-01f, -1.96050131e-03f, 3.05729769e-02f, -9.25864093e-03f, -3.73886600e-02f,
  -3.20619158e-02f, 1.24337584e-01f, 8.41784328e-02f, -2.54168268e-02f, 6.33198619e-02f, -7.19169676e-02f, 1.34596424e-02f, 4.29109260e-02f, 3.03204055e-03f, -4.04302254e-02f,
  -3.05312276e-02f, -1.07000798e-01f, -1.54226776e-02f, 3.02796364e-02f, -4.09396552e-02f, -2.02349853e-02f, -1.24431343e-03f, 1.10810421e-01f, -9.74878967e-02f, -3.12641039e-02f,
  -2.36937087e-02f, 1.79910585e-02f, -8.90128613e-02f, -1.23471199e-02f, 5.13660759e-02f, 1.29754215e-01f, -2.58475989e-02f, 2.65659355e-02f, 6.72040805e-02f, 7.73730278e-02f,
  -4.01970632e-02f, -1.48239449e-01f, 2.57353764e-02f, -4.28423136e-02f, -1.13290278e-02f, 1.88786108e-02f, 6.61367327e-02f, -1.80851161e-01f, -4.89612333e-02f, -9.49914008e-02f,
  -7.42947310e-02f, 1.80886389e-04f, 2.24788543e-02f, -8.22323263e-02f, 9.19814408e-03f, -1.27608851e-01f, 2.53853574e-02f, 1.46680810e-02f, -1.34646269e-02f, -1.43185228e-01f,
  5.25648985e-03f, -6.24824949e-02f, 3.32918689e-02f, -4.23829481e-02f, -8.04473758e-02f, 1.68643132e-01f, -3.76244821e-02f, -2.24118121e-02f, 3.81050073e-02f, -4.35383096e-02f,
  6.34674609e-01f, -6.62086546e-01f, -2.44253963e-01f, 2.81009942e-01f, 7.63932586e-01f, 3.40368509e-01f, 3.51054490e-01f, 1.28203705e-01f, 1.86332166e-01f, -5.37234962e-01f,
  -7.41601512e-02f, -2.64240444e-01f, -3.20603549e-01f, 1.28347784e-01f, 5.90007961e-01f, -1.49131462e-01f, 1.71248332e-01f, 8.52403194e-02f, 8.01237151e-02f, 9.55882818e-02f,
  2.76968062e-01f, 4.10471410e-01f, 2.25359183e-02f, -1.17362272e-02f, 2.23367333e-01f, -2.28918478e-01f, 4.83271778e-02f, -8.02301988e-02f, -8.11516345e-02f, 1.44953698e-01f,
  1.08711183e-01f, -4.01403829e-02f, 1.04987621e-01f, -1.64108574e-01f, -1.49413920e-03f, 2.59374902e-02f, -6.50748610e-02f, 9.59244091e-03f, 1.64439246e-01f, -5.52738737e-03f,
  -9.84655246e-02f, -5.94648905e-02f, 1.64986521e-01f, 1.00976430e-01f, 5.36039025e-02f, -1.65193193e-02f, 1.48817569e-01f, 7.90655520e-03f, -1.12760626e-01f, 7.48839155e-02f,
  1.58970598e-02f, -3.28568555e-02f, -5.90198748e-02f, -1.35785297e-01f, -8.08150470e-02f, 2.25938745e-02f, -5.15853092e-02f, -7.16900602e-02f, 4.26289402e-02f, 5.26550859e-02f,
  -3.01790307e-03f, 5.99473715e-02f, -2.33619716e-02f, 1.37727037e-01f, -2.45707855e-02f, 2.96054836e-02f, -3.68678644e-02f, 1.08901486e-02f, -1.07440047e-01f, -5.85716181e-02f,
  7.21351206e-02f, -8.42068940e-02f, -4.09758426e-02f, -3.63946706e-02f, -7.76985660e-02f, -9.25418139e-02f, -2.10434496e-02f, -1.31210327e-01f, -8.77785087e-02f, 1.07374780e-01f,
  1.15306750e-01f, 9.50048491e-02f, -8.10841992e-02f, 1.13532044e-01f, 9.53160983e-04f, -4.23027538e-02f, -4.45954874e-02f, -2.19265938e-01f, 1.59562826e-01f, 1.09350219e-01f,
  -5.92064679e-01f, -5.50246358e-01f, -4.35413606e-02f, 1.56263786e-03f, -1.16935819e-01f, 4.36962508e-02f, 1.91826187e-02f, -7.03577772e-02f, -2.02916831e-01f, -3.64813491e-06f,
  2.47390922e-02f, 8.69932100e-02f, -1.22678336e-02f, 2.54309550e-02f, -1.22083314e-01f, -4.20256052e-03f, -1.21337645e-01f, -1.54270992e-01f, 5.65777570e-02f, -1.66728780e-01f,
  -9.55735818e-02f, -6.32214919e-03f, 6.13072589e-02f, 8.81415159e-02f, 6.33174554e-02f, -3.72198410e-02f, 8.37905332e-02f, -5.97548112e-02f, -8.37122425e-02f, -7.71237165e-02f,
  -9.22294021e-01f, 6.83380142e-02f, 3.10746253e-01f, -6.50915325e-01f, -8.66200104e-02f, 3.43871891e-01f, 6.26709759e-02f, -6.48543611e-02f, -3.83888721e-01f, 5.97389638e-02f,
  -7.90805072e-02f, -5.95548935e-02f, 4.47754592e-01f, -3.68880443e-02f, 2.83378035e-01f, 4.37910765e-01f, -1.74574941e-01f, 7.69022554e-02f, -1.03163861e-01f, -3.21851492e-01f,
  -5.26340902e-02f, -2.21769869e-01f, 4.53318357e-01f, -9.27202180e-02f, -2.12869272e-01f, -3.00282270e-01f, -1.30138487e-01f, 8.54448080e-02f, -1.66422054e-02f, 6.90700933e-02f,
  -5.06140471e-01f, -4.98580635e-01f, -1.01761244e-01f, 1.14715947e-02f, -2.83180661e-02f, 6.84044361e-02f, 8.49512685e-03f, 1.11509703e-01f, -5.48819713e-02f, -1.43125821e-02f,
  2.52186805e-02f, -7.26521686e-02f, 3.28950584e-02f, 2.54507624e-02f, -6.67654201e-02f, -1.07547743e-02f, 6.81988746e-02f, 4.02047532e-03f, 2.66962685e-02f, 1.03198446e-01f,
  1.34504691e-01f, 6.91443682e-02f, -1.91465840e-01f, 8.91196951e-02f, 3.89950052e-02f, -8.11170265e-02f, -8.08847696e-03f, 9.68276039e-02f, -4.14078794e-02f, -8.37205127e-02f,
  -1.05117850e-01f, 2.65686773e-02f, -6.33846894e-02f, 9.50293541e-02f, -3.59768942e-02f, -2.75200605e-02f, -4.51025367e-02f, 9.17021465e-03f, -2.11541448e-02f, -5.72070330e-02f,
  -1.38089508e-01f, -1.08524367e-01f, -1.60158589e-01f, -2.64409594e-02f, -6.63813427e-02f, -1.39792487e-01f, 4.86812666e-02f, -1.07112214e-01f, -5.18702976e-02f, 1.92477426e-03f,
  -2.34147925e-02f, 6.92325383e-02f, 5.06515913e-02f, -2.52239313e-02f, -5.43321781e-02f, 5.22224382e-02f, -6.40729293e-02f, 4.05418016e-02f, -1.09468438e-02f, -1.57878138e-02f,
  -4.53179955e-01f, -5.37903190e-01f, -8.70563835e-03f, -6.18933141e-02f, -1.21592227e-02f, 7.22778589e-03f, 4.48179059e-02f, -8.02811161e-02f, -5.55069447e-02f, -5.34700491e-02f,
  -2.73100249e-02f, -2.00840249e-03f, -5.21414094e-02f, -1.80989411e-02f, 3.33343521e-02f, -5.01659773e-02f, -1.07637085e-01f, -1.59435213e-01f, -7.07951561e-02f, -7.67632499e-02f,
  6.21909508e-03f, -1.10839428e-02f, 1.82718232e-01f, -1.04122963e-02f, -4.99423966e-02f, -1.17696643e-01f, -2.13046849e-01f, -7.54324626e-03f, 2.29621362e-02f, 5.10274470e-02f,
  4.17777836e-01f, 3.56271505e-01f, -2.23873749e-01f, 1.10378012e-01f, -2.19955042e-01f, 4.13981497e-01f, 4.01340783e-01f, 7.40970969e-02f, 1.20126687e-01f, 4.76712465e-01f,
  1.56453356e-01f, 7.90281743e-02f, 2.00567022e-01f, 5.15761018e-01f, 5.23016341e-02f, 3.30343008e-01f, 5.98434985e-01f, 3.50852579e-01f, -7.32791126e-02f, 2.41373792e-01f,
  6.31470755e-02f, 5.51587999e-01f, -1.86993942e-01f, 2.71803513e-02f, -6.50117248e-02f, -3.08789313e-01f, -1.11800507e-01f, -2.13648260e-01f, 2.07892451e-02f, -1.50735661e-01f,
  -2.94355284e-02f, -3.84705812e-02f, -1.15052529e-01f, 1.01883173e-01f, -4.87440042e-02f, 4.04467471e-02f, -1.99149046e-02f, -3.08125820e-02f, -1.45653069e-01f, -9.77491438e-02f,
  7.88653791e-02f, -2.62836087e-02f, 1.14231579e-01f, -9.16776888e-04f, 7.40622953e-02f, -4.89278473e-02f, -2.22626980e-02f, -5.72977848e-02f, -1.91959850e-02f, -8.34016204e-02f,
  -1.31303474e-01f, -6.32700175e-02f, 8.65978189e-03f, -2.64855269e-02f, -1.76213831e-01f, 7.35597759e-02f, 5.78603521e-02f, -5.13782874e-02f, -3.26291285e-02f, -6.81347921e-02f,
  1.06088452e-01f, 1.17314169e-02f, 1.19041748e-01f, 7.23733974e-04f, 2.60622557e-02f, -1.23594403e-01f, 1.01870239e-01f, -1.22301884e-01f, -5.96446022e-02f, 1.73629832e-03f,
  1.20397676e-02f, -7.26853982e-02f, -8.15687422e-03f, 1.42767942e-02f, -2.53598578e-02f, 4.82968614e-03f, 2.34014578e-02f, 2.23534070e-02f, 9.47850291e-03f, -3.74478586e-02f,
  7.02987760e-02f, 1.23941168e-01f, -3.69613729e-02f, 2.91497242e-02f, 4.22757454e-02f, 1.53235132e-02f, 1.65439826e-02f, -7.73951113e-02f, -6.94485977e-02f, 1.22726103e-02f,
  1.42285630e-01f, 2.99682647e-01f, -3.46722417e-02f, 7.72775859e-02f, -1.17009975e-01f, 5.81413321e-02f, 8.58362541e-02f, 9.84666646e-02f, 1.53765976e-01f, 5.20124584e-02f,
  1.19387113e-01f, 9.26266387e-02f, 7.64101222e-02f, 1.27310399e-03f, -5.50988466e-02f, 6.10797703e-02f, 3.50590758e-02f, 9.24779326e-02f, 1.36693306e-02f, -1.66846979e-02f,
  2.95652915e-02f, 7.16795102e-02f, 3.58179510e-02f, -4.62069958e-02f, 3.19764093e-02f, -3.31826545e-02f, -1.37399137e-01f, -1.15598790e-01f, -6.74756691e-02f, 1.10208400e-01f,
  -8.89696002e-01f, 1.78532526e-01f, -2.54715651e-01f, -5.34764647e-01f, 1.51141986e-01f, -4.98582214e-01f, -3.94063771e-01f, 1.05033234e-01f, 1.27931997e-01f, 6.23102002e-02f,
  -1.37422100e-01f, -4.30849493e-02f, -1.53129986e-02f, -9.99754742e-02f, -3.56840312e-01f, 1.02387249e-01f, -5.35723686e-01f, -2.42556125e-01f, 1.13030136e-01f, -2.67277032e-01f,
  -1.81906626e-01f, 1.06206544e-01f, -3.16055000e-01f, 2.11283520e-01f, -1.09268531e-01f, -7.50358924e-02f, 6.95333108e-02f, 3.25328410e-01f, -2.60003000e-01f, 1.95296809e-01f,
  -9.83607769e-02f, 1.65861607e-01f, 1.31764323e-01f, 2.88005788e-02f, -2.58138627e-01f, -1.02190129e-01f, -1.32887036e-01f, 2.20951028e-02f, -6.77913874e-02f, -6.57005310e-02f,
  -5.20696491e-02f, 5.94679080e-02f, -8.44675824e-02f, 2.26975307e-01f, -6.20999001e-03f, 9.81347412e-02f, 7.61662275e-02f, 1.01893174e-03f, 3.70803550e-02f, -1.99920665e-02f,
  -5.93078658e-02f, -5.57090938e-02f, -4.50592302e-02f, 5.63539490e-02f, 1.14744253e-01f, 4.01398651e-02f, -1.35253027e-01f, 1.26175582e-02f, -4.55453657e-02f, -4.88392124e-03f,
  1.66103482e-01f, -1.01865597e-01f, 8.05736929e-02f, -4.65819687e-02f, -2.05989461e-02f, 6.23718128e-02f, -6.19458780e-03f, -1.11103378e-01f, 6.77261949e-02f, -6.78192750e-02f,
  -5.17911948e-02f, 3.17308381e-02f, 1.63092390e-01f, -3.58834043e-02f, -1.02796808e-01f, -1.61683820e-02f, -3.50008979e-02f, 4.90610637e-02f, -1.11593455e-01f, -2.84568593e-02f,
  2.84969602e-02f, 4.65788767e-02f, 4.49847691e-02f, -4.00801487e-02f, 3.47800627e-02f, 2.25446001e-03f, 3.54445130e-02f, 6.80240570e-03f, -7.30859786e-02f, -1.52830947e-02f,
  -4.76334661e-01f, -1.52292117e-01f, -9.37992558e-02f, 1.20053999e-01f, -1.55418636e-02f, -6.13418072e-02f, 2.59081982e-02f, 2.97672469e-02f, -2.23272536e-02f, -2.72031277e-02f,
  -8.37667510e-02f, -4.64007109e-02f, -1.13125101e-01f, -7.88796544e-02f, -1.02824852e-01f, 2.54380167e-03f, -4.62844484e-02f, 4.96032499e-02f, -1.73578054e-01f, -8.25458020e-02f,
  -2.93663107e-02f, 2.20055301e-02f, 2.06688941e-02f, 4.37300280e-02f, -3.56334522e-02f, -9.35061052e-02f, 1.45573765e-02f, -9.87769291e-02f, 4.88765575e-02f, 1.97280049e-02f,
  -7.45019734e-01f, 3.58608305e-01f, -5.44043407e-02f, 2.52474338e-01f, -3.80938590e-01f, -4.89179075e-01f, -3.06776147e-02f, -3.69041637e-02f, -8.81621055e-03f, 3.91144753e-01f,
  3.06670964e-02f, 2.42875680e-01f, 2.18369416e-03f, 1.56137422e-01f, -9.21370506e-01f, -8.05223733e-02f, -1.69435412e-01f, 1.21049710e-01f, -1.72625586e-01f, 6.80512041e-02f,
  -1.71219945e-01f, -1.48145974e-01f, -2.04292275e-02f, -3.75453942e-02f, 6.35274574e-02f, 1.70796290e-01f, -1.14923626e-01f, -2.60502491e-02f, 1.74042895e-01f, -2.24132672e-01f,
  8.11960623e-02f, 2.24642843e-01f, 8.01858157e-02f, 6.41145185e-02f, -4.05787416e-02f, 7.39911431e-03f, 6.13833487e-04f, -4.58057076e-02f, 1.07288109e-02f, 2.31788959e-02f,
  2.52907611e-02f, -4.79926206e-02f, -4.33642417e-02f, -8.11202601e-02f, -6.45788061e-03f, -3.63318212e-02f, 6.34804592e-02f, -1.78809818e-02f, 1.36751890e-01f, -3.29117849e-02f,
  1.15118273e-01f, 5.20959729e-04f, 9.01695788e-02f, 8.58500786e-03f, -1.01787545e-01f, 4.89028059e-02f, 4.05311473e-02f, -7.89578632e-02f, 7.03966022e-02f, -1.32726401e-01f,
  -1.28686368e-01f, 3.20263393e-02f, -3.21904104e-03f, 5.77380694e-02f, -3.57546955e-02f, 3.88618000e-02f, -3.84924235e-03f, -3.22998799e-02f, 2.75687082e-03f, -2.88289525e-02f,
  -1.33859634e-03f, 4.14491910e-03f, -3.23552489e-02f, 7.50820339e-02f, -6.59427419e-02f, 9.31980982e-02f, -5.98963089e-02f, -2.83548795e-02f, -3.10793258e-02f, -4.72079478e-02f,
  1.16852447e-01f, -2.81803645e-02f, 4.37276810e-02f, -6.80562556e-02f, -4.78736162e-02f, 1.27919698e-02f, -7.18623865e-03f, -6.23747590e-04f, -3.47392112e-02f, -1.13033421e-01f,
  -3.04780044e-02f, -1.19973719e-01f, 7.77999833e-02f, 5.88755459e-02f, 4.82510589e-03f, -1.13075301e-02f, -3.97660807e-02f, -1.44208958e-02f, 1.24820722e-02f, -6.72945753e-02f,
  1.03850588e-01f, 1.14731364e-01f, -1.91919487e-02f, -3.94461490e-02f, -1.98106561e-02f, -7.88274482e-02f, 3.28138210e-02f, -1.90871432e-02f, -6.29002228e-02f, -4.15066667e-02f,
  4.28654477e-02f, 4.43921201e-02f, -1.87521689e-02f, 4.45227418e-03f, 8.52155499e-03f, 3.18041481e-02f, -9.41204559e-03f, 6.74473122e-02f, -9.87410322e-02f, 3.28618735e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.60321966e-01f, 5.70653975e-01f, -9.44861546e-02f, 3.45037192e-01f, 5.87440670e-01f, 2.79982209e-01f, 3.25071543e-01f, 6.05190039e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  7.59453475e-02f, -3.24068964e-01f, 1.36387438e-01f, 2.17071757e-01f, 2.56749302e-01f, -6.09044358e-02f, -1.26125589e-01f, 7.78044164e-01f, 3.42701703e-01f, -4.09703106e-01f,
  9.11671966e-02f, 6.30287128e-03f, 3.74920309e-01f, -1.65267419e-02f, 3.95642698e-01f, 9.18380991e-02f, 3.62270651e-03f, 2.59158731e-01f, 1.92724645e-01f, 2.61009842e-01f,
  -1.65750369e-01f, -3.23385268e-01f, 1.08326972e-01f, -4.48075771e-01f, -4.40780409e-02f, 4.03367430e-01f, -1.80471644e-01f, 2.38580018e-01f, -1.72422722e-01f, 2.24584356e-01f,
  -5.01621723e-01f, -3.05199772e-01f, -1.08938947e-01f, 4.14297581e-01f, 1.21850342e-01f, 4.99606371e-01f, 3.73905808e-01f, -1.81320280e-01f, 3.59433204e-01f, 1.26974389e-03f,
  -1.85109153e-01f, 1.61596030e-01f, 3.25635612e-01f, -3.53023976e-01f, 1.29786776e-02f, 4.86117691e-01f, -2.60753363e-01f, -2.21184909e-01f, 3.33242416e-01f, 3.83374542e-01f,
  -1.22068182e-01f, -5.57611138e-02f, -3.07057202e-01f, -2.12009504e-01f, 1.22711778e-01f, 2.82579422e-01f, -4.79349643e-01f, -4.88265902e-02f, -1.60300300e-01f, -6.54889718e-02f,
  2.46745557e-01f, -2.46509433e-01f, 9.00148675e-02f, 3.01173300e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.08010966e-01f, 9.16069299e-02f, 8.20606589e-01f, 3.57317775e-01f, -4.12334144e-01f, -5.42195916e-01f, 8.83224189e-01f, -2.23850757e-02f, 1.67008877e-01f, 2.05217391e-01f,
  3.19310218e-01f, 9.29342926e-01f, 1.80282146e-01f, -8.47547948e-01f, 9.30594742e-01f, 5.35248458e-01f, 3.47714782e-01f, 7.77835548e-01f, -2.94944435e-01f, -4.16191779e-02f,
  -5.87327480e-01f, -1.10277921e-01f, -6.46182001e-02f, 4.28496659e-01f, -1.89253613e-01f, 5.68880498e-01f, -6.80257022e-01f, -3.41264099e-01f, 3.59542221e-01f, 1.67824060e-01f,
  4.16446477e-01f, 1.05727553e+00f, 5.79945743e-01f, 8.77156198e-01f, 3.60163540e-01f, 1.94547802e-01f, -9.37702179e-01f, 2.26637766e-01f, -8.58208656e-01f, -6.17248058e-01f,
  9.74757299e-02f, 8.54477346e-01f, -2.82194048e-01f, 7.63143539e-01f, 4.78582025e-01f, 5.19315422e-01f, 4.32809107e-02f, 5.13390958e-01f, 2.73480266e-01f, 5.65200031e-01f,
  9.80765522e-02f, 6.12040758e-01f, 2.07735285e-01f, 3.54577065e-01f, -5.62801898e-01f, 2.85071917e-02f, -5.88311613e-01f, 5.71076989e-01f, 8.74330699e-01f, 2.39067242e-01f,
  4.65785474e-01f, 6.16650164e-01f, -1.50859460e-01f, -2.40196079e-01f, -5.90632975e-01f, -5.32184318e-02f, 4.51680541e-01f, 4.21177447e-01f, 4.32761878e-01f, 2.04624400e-01f,
  5.18761396e-01f, -2.70739585e-01f, -2.37084582e-01f, 2.62174964e-01f, 7.88511395e-01f, 5.68901122e-01f, 2.24219799e-01f, 3.24233860e-01f, 1.44543678e-01f, -5.57938337e-01f,
  8.26132670e-02f, 3.18527579e-01f, 5.49706936e-01f, 7.19158828e-01f, -7.16282189e-01f, -5.80299437e-01f, -2.74011880e-01f, -5.18717706e-01f, -2.48754174e-02f, 3.71482432e-01f,
  5.46621263e-01f, 8.92442644e-01f, 5.89167774e-01f, -6.85564876e-01f, 1.15729056e-01f, -6.46871686e-01f, 2.45411649e-01f, -4.64684635e-01f, 3.28120708e-01f, 6.85775757e-01f,
  6.53075159e-01f, 8.89009833e-02f, -6.80017233e-01f, 9.25133765e-01f, 1.19758892e+00f, -1.85265228e-01f, 4.49069798e-01f, 1.71644375e-01f, 9.67320263e-01f, 3.46931010e-01f,
  7.26250887e-01f, 8.29020068e-02f, -2.59297907e-01f, -2.15047210e-01f, 3.90485346e-01f, 5.47834300e-02f, 2.03697667e-01f, 5.83430946e-01f, -7.03285098e-01f, -8.38535249e-01f,
  5.87201059e-01f, -6.40432909e-02f, -5.35009382e-03f, 6.29210413e-01f, -1.00787401e+00f, 5.55006146e-01f, -3.43735904e-01f, -4.80171889e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  5.19064784e-01f, 6.21856213e-01f, 8.15975845e-01f, 4.79912728e-01f, 1.78573966e-01f, 5.97476184e-01f, 6.76100016e-01f, 5.21021605e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  4.67497706e-01f, 6.87830970e-02f, 6.95225596e-02f, 9.97085497e-02f, -1.78710774e-01f, -1.23443566e-01f, 4.03697699e-01f, 3.47465783e-01f, -1.85885012e-01f, 9.21578333e-02f,
  1.95556864e-01f, 6.84406608e-02f, -4.87158634e-02f, 3.99285764e-01f, -1.51522398e-01f, -4.36873168e-01f, 1.55689165e-01f, 8.82110596e-02f, -2.27738053e-01f, -2.58405115e-02f,
  -2.73940325e-01f, 2.42457479e-01f, 3.58419776e-01f, -2.09789649e-01f, 4.56206650e-02f, -2.04515979e-01f, 3.44754308e-01f, -1.42838091e-01f, -1.28451094e-01f, 1.80401579e-01f,
  -2.73879647e-01f, 4.67938006e-01f, -5.20766079e-01f, 4.08363998e-01f, 4.95662719e-01f, 3.15323710e-01f, 2.50171661e-01f, -2.04121962e-01f, -8.41841251e-02f, -1.87299982e-01f,
  -2.29016364e-01f, 4.55016308e-02f, 2.50217348e-01f, 5.63747101e-02f, -1.53656363e-01f, -2.35553235e-01f, -7.30849802e-02f, 3.09802920e-01f, -6.21948317e-02f, 5.77648394e-02f,
  -5.44077531e-02f, 1.39029026e-02f, -5.26460290e-01f, 5.71789980e-01f, 7.15717256e-01f, 5.71158826e-02f, -8.29162896e-02f, 1.09243587e-01f, 2.44924128e-01f, 5.78280054e-02f,
  2.52104521e-01f, -2.25546941e-01f, -3.74431431e-01f, 2.21787781e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.21813095e-01f, -4.53947753e-01f, -4.61981863e-01f, -9.85619426e-02f, -3.79737206e-02f, 6.34638131e-01f, 4.82843161e-01f, -4.85799074e-01f, 1.97308953e-04f, -7.15124428e-01f,
  5.31181753e-01f, 9.48131144e-01f, 9.77587402e-01f, 9.69162166e-01f, 8.07888508e-01f, 1.03054154e+00f, -7.21386671e-01f, 4.99135144e-02f, 6.13977671e-01f, -5.67194633e-02f,
  6.69205248e-01f, -5.03897548e-01f, -9.38248813e-01f, 4.65504467e-01f, 9.64537740e-01f, 4.55450833e-01f, 2.85204619e-01f, -9.35480714e-01f, -9.00588214e-01f, 5.77375591e-02f,
  9.26797926e-01f, 3.99989843e-01f, 4.88083780e-01f, 1.88839361e-01f, 2.90766418e-01f, 3.65716517e-01f, -1.10455620e+00f, 9.33601379e-01f, -2.93908179e-01f, 5.59624910e-01f,
  5.60587883e-01f, 4.82484043e-01f, 8.97004724e-01f, 3.45863439e-02f, -8.62617269e-02f, 8.71612310e-01f, -4.83510345e-01f, -5.55804931e-03f, 2.02887714e-01f, -1.42920360e-01f,
  7.68337259e-03f, -4.20054138e-01f, -5.61970115e-01f, 9.80261624e-01f, -6.59982383e-01f, -1.64629683e-01f, -2.31760368e-01f, 5.18574595e-01f, 8.20294976e-01f, 1.03201605e-01f,
  -1.80512652e-01f, 5.91505393e-02f, 1.36152491e-01f, 1.23957586e+00f, 2.15558216e-01f, -1.12436071e-01f, 4.70364839e-01f, 4.58623350e-01f, -6.26929641e-01f, 3.74730140e-01f,
  -1.92821890e-01f, 7.59596109e-01f, 7.53029346e-01f, 2.42983758e-01f, 2.32650921e-01f, 9.12663564e-02f, 3.77169043e-01f, 8.37135077e-01f, -3.57453406e-01f, -5.20714104e-01f,
  2.60009289e-01f, 7.91002810e-02f, 2.81606168e-01f, 7.79164433e-01f, 2.22133622e-01f, -2.54702687e-01f, 7.15009034e-01f, 4.60709244e-01f, 4.55080330e-01f, 9.55915451e-01f,
  3.89413208e-01f, 4.30703253e-01f, -1.12289399e-01f, -4.75645900e-01f, 3.51365894e-01f, -9.82955396e-01f, 2.24974100e-02f, 1.19722736e+00f, 5.17421067e-01f, 2.04187140e-01f,
  1.31824648e+00f, -1.13616788e+00f, 6.51247323e-01f, -1.29376188e-01f, 1.46719933e-01f, -2.02497691e-01f, -3.09629709e-01f, 8.88280571e-02f, 5.01380324e-01f, 3.79949391e-01f,
  7.09198654e-01f, -7.97391236e-02f, -1.86188757e-01f, 8.68968248e-01f, 7.44975746e-01f, 3.09735071e-02f, 6.63671315e-01f, -6.61543012e-01f, 4.51648116e-01f, 3.86670232e-01f,
  -1.03940022e+00f, 5.97685933e-01f, 5.81784189e-01f, 5.77600956e-01f, -7.02910841e-01f, -1.67220116e-01f, 7.33248651e-01f, -1.69825032e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.15812473e-01f, 2.31513843e-01f, 8.46073478e-02f, 2.79164314e-01f, 2.70124674e-01f, 4.84642655e-01f, 5.13954580e-01f, 2.38666028e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.35234708e-01f, -6.24485612e-02f, -4.86542225e-01f, 3.48608285e-01f, 4.59345937e-01f, -6.69946611e-01f, 1.81428507e-01f, 4.73053642e-02f, -3.09465319e-01f, -1.88964784e-01f,
  -3.89204621e-01f, -2.64571235e-03f, -6.63379908e-01f, 4.17882800e-01f, -3.48537304e-02f, 8.97191644e-01f, 4.53374147e-01f, 6.58622533e-02f, 1.90629348e-01f, 1.61800340e-01f,
  -6.79112256e-01f, 4.69061941e-01f, 5.11875927e-01f, 5.79950929e-01f, 5.79053581e-01f, -7.70198464e-01f, -9.00419295e-01f, 2.37739086e-01f, -7.39620984e-01f, -5.95769227e-01f,
  4.44841981e-01f, 3.00732732e-01f, -1.12088509e-01f, -6.12403035e-01f, 3.49680275e-01f, -9.96886641e-02f, -5.77963531e-01f, 4.71382514e-02f, 1.53860003e-01f, -8.61423969e-01f,
  3.06727052e-01f, 4.71872926e-01f, 1.14639603e-01f, 5.19974828e-01f, -9.64454889e-01f, -7.87453353e-01f, -2.19266489e-01f, -9.91379678e-01f, 1.33519009e-01f, -5.35959065e-01f,
  -4.39390898e-01f, -1.02997832e-01f, -7.16505051e-01f, -3.45307559e-01f, -6.63118303e-01f, -2.93847978e-01f, -5.00813127e-01f, 6.13020897e-01f, -7.16560408e-02f, -2.55917810e-04f,
  3.87040854e-01f, 3.07609349e-01f, -5.97654879e-01f, -8.07086825e-01f, -2.43489176e-01f, 5.45608938e-01f, 6.88010097e-01f, 1.47263467e-01f, 8.49608839e-01f, -4.88828957e-01f,
  -5.06857216e-01f, -2.76537597e-01f, -2.55780756e-01f, -4.80963849e-02f, 1.72056183e-01f, -3.61678481e-01f, 5.53020239e-01f, -1.27145708e-01f, 5.87328672e-01f, 2.89498866e-01f,
  -1.23749256e-01f, -3.51800770e-02f, 1.42398044e-01f, -1.45507604e-01f, 5.69896102e-01f, 5.02273917e-01f, 3.50968122e-01f, 3.47578228e-01f, 7.38173872e-02f, -1.27215004e+00f,
  2.75321394e-01f, 2.94662833e-01f, -2.12955549e-01f, 3.12140852e-01f, -9.76012528e-01f, 5.09551942e-01f, 4.71121609e-01f, 8.66316780e-02f, 3.92222583e-01f, -1.67435020e-01f,
  6.69046283e-01f, -5.70014939e-02f, 3.71536940e-01f, 3.49523067e-01f, 2.40399480e-01f, -6.62760884e-02f, 3.80908936e-01f, 3.00687879e-01f, 2.85778016e-01f, -1.08064544e+00f,
  -9.79709804e-01f, -8.54424179e-01f, -1.36531204e-01f, -5.25320694e-02f, -5.35842419e-01f, -3.91131878e-01f, 2.80782610e-01f, -6.27056479e-01f, 1.44985365e-02f, -5.89698017e-01f,
  6.27600908e-01f, -2.27968737e-01f, -5.84020674e-01f, -1.26106322e+00f, 2.42140125e-02f, 1.29305318e-01f, 4.44654346e-01f, -7.50594795e-01f, -6.07391953e-01f, 4.36032981e-01f,
  -2.53040791e-01f, -2.73688361e-02f, -3.15674871e-01f, -1.27354056e-01f, 3.36105466e-01f, -1.56832784e-01f, -1.10933021e-01f, 6.11020446e-01f, -1.07479954e+00f, 2.44743936e-03f,
  -7.39328265e-01f, -6.68014765e-01f, 3.61161113e-01f, 6.36913180e-01f, -3.25520545e-01f, -3.40042919e-01f, -5.27356505e-01f, 1.88154742e-01f, -3.96905541e-01f, 7.45073855e-01f,
  -7.85223544e-01f, 3.10980976e-01f, 2.48586014e-01f, -7.69930303e-01f, 3.64670664e-01f, -4.76147711e-01f, 4.65211213e-01f, -1.61374733e-02f, -8.51296708e-02f, -7.63197958e-01f,
  2.95217246e-01f, 2.45992839e-01f, 2.36539960e-01f, -2.32075471e-02f, -5.20832956e-01f, -4.03693646e-01f, 4.27172959e-01f, -2.60369629e-01f, -1.14126241e+00f, 5.72186828e-01f,
  -7.24857271e-01f, -1.44819558e+00f, -2.53862500e-01f, 5.88236928e-01f, 1.03771675e+00f, 2.49667808e-01f, -8.28487650e-02f, 1.25593945e-01f, 3.83803278e-01f, 1.47381852e-05f,
  6.25136197e-01f, 4.72502947e-01f, -1.70149729e-02f, 6.48868859e-01f, -9.33159709e-01f, -2.54386038e-01f, 5.44350684e-01f, 1.16961628e-01f, 6.21565580e-01f, 5.05256891e-01f,
  -1.09266698e+00f, -3.09720606e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.10729569e-01f, -8.28452110e-02f, 1.69308573e-01f, -2.78221488e-01f, 1.36169776e-01f, 2.13838771e-01f, -2.63440400e-01f, -5.94216846e-02f, -1.43299133e-01f, -5.20564169e-02f,
  6.24197647e-02f, -4.40803031e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    