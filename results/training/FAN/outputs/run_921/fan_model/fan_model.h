/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.48240644e-01f, -1.72923312e-01f, -2.21452639e-01f, 9.45133865e-02f, -1.19795270e-01f, -2.41591752e-01f, -1.08471923e-01f, -3.43100727e-02f, 1.79838344e-01f, -3.92280370e-02f,
  -8.90583470e-02f, 4.26793545e-02f, 1.52886301e-01f, 6.70027360e-02f, 9.47095826e-02f, 1.42339421e-02f, -9.04455874e-03f, 8.79763141e-02f, 4.58996110e-02f, 3.63914780e-02f,
  -9.59217735e-03f, 1.46078482e-01f, 2.11118311e-01f, 1.20905645e-01f, 6.32403360e-04f, 3.48914750e-02f, -4.01920713e-02f, 2.54517398e-03f, -1.76340714e-01f, -4.43620048e-02f,
  -2.51163095e-01f, -1.30732611e-01f, 3.61456946e-02f, 7.61158094e-02f, -7.01165870e-02f, 3.04090474e-02f, -2.83843745e-02f, -5.15917921e-03f, 8.92858580e-03f, -2.28742082e-02f,
  -1.64784547e-02f, -3.75496387e-03f, 2.18805168e-02f, -7.81473964e-02f, 6.23589903e-02f, -5.08289486e-02f, -3.39793712e-02f, 9.68597978e-02f, -2.57487297e-02f, -7.72439316e-02f,
  2.12553274e-02f, -1.66569501e-01f, -1.24465652e-01f, -7.66274258e-02f, -1.21449284e-01f, -3.52082029e-02f, -1.17776752e-01f, -3.61646060e-03f, -2.50499286e-02f, 9.35031250e-02f,
  6.31587058e-02f, 1.05204731e-02f, 2.27673501e-02f, 1.13704009e-03f, 5.24861142e-02f, -6.09421618e-02f, -2.70902328e-02f, 4.72567007e-02f, 4.20844890e-02f, -4.31618020e-02f,
  5.43499589e-02f, -5.69802299e-02f, 1.83786191e-02f, 9.25697982e-02f, -2.60643978e-02f, -3.10513359e-02f, -2.84346286e-03f, 8.90175253e-03f, -7.88444579e-02f, 2.10890975e-02f,
  -4.23470400e-02f, -4.75493520e-02f, 1.49262277e-02f, 6.17133006e-02f, -6.98702261e-02f, -2.65365653e-02f, -5.12704551e-02f, -2.39216387e-02f, 4.98181880e-02f, 1.19036473e-02f,
  9.32086334e-02f, -3.28075439e-02f, 5.85431792e-02f, 1.45818099e-01f, 6.61253138e-03f, 2.65503637e-02f, 6.63681254e-02f, 1.98160741e-03f, -8.53099674e-02f, 2.60691736e-02f,
  -9.57545415e-02f, 5.74306771e-02f, 4.24645059e-02f, -3.19476686e-02f, 2.68018874e-03f, 6.09932207e-02f, 2.20467560e-02f, 2.71495041e-02f, 5.90162762e-02f, 2.25425847e-02f,
  -1.98641829e-02f, 6.27719164e-02f, 8.72901306e-02f, 3.68787758e-02f, 1.30370129e-02f, 6.45835772e-02f, -8.83057564e-02f, 3.23670427e-03f, 5.68553731e-02f, 1.13193192e-01f,
  1.15409091e-01f, -7.29252025e-02f, -8.91415752e-04f, 1.01513274e-01f, -8.21720585e-02f, -1.19391255e-01f, -1.77752033e-01f, -5.28848432e-02f, -2.06082346e-04f, -1.01548612e-01f,
  4.56197113e-02f, 7.52222631e-03f, 7.29931891e-02f, -3.65173742e-02f, -5.37407659e-02f, -1.95911437e-01f, -1.57003388e-01f, -1.37139872e-01f, 2.08622892e-03f, -1.23259671e-01f,
  -7.50845000e-02f, 7.93556422e-02f, 1.19675182e-01f, -1.71350874e-02f, -1.46248043e-01f, 3.93770300e-02f, 3.30654047e-02f, 3.67518961e-02f, -5.13443276e-02f, -1.54749230e-01f,
  -4.23291959e-02f, 8.67361389e-03f, 5.05886711e-02f, -5.95789962e-03f, -2.61807232e-03f, 6.59662411e-02f, 8.04431140e-02f, 4.69977334e-02f, 7.75509849e-02f, -5.64009733e-02f,
  -3.10323481e-02f, -2.50772620e-03f, 7.03808442e-02f, 3.02442140e-03f, 2.93937493e-02f, 4.16563414e-02f, 2.90240273e-02f, 2.12738737e-02f, 1.58460438e-02f, -1.13309540e-01f,
  3.62148434e-02f, -8.63606781e-02f, 7.33875707e-02f, 9.79433954e-03f, -6.37309775e-02f, 2.59673391e-02f, 5.62551767e-02f, -1.01546776e-02f, 6.97133839e-02f, 9.77834836e-02f,
  -5.19015339e-05f, 9.71254427e-03f, -1.89954359e-02f, -4.43052463e-02f, 2.38422472e-02f, 9.14515462e-03f, -5.88078499e-02f, -5.63568138e-02f, -1.32179772e-02f, -2.07793992e-02f,
  -2.28621159e-02f, -1.95406005e-03f, 1.33676613e-02f, 2.47051828e-02f, -2.37848666e-02f, 8.61742646e-02f, -2.77025606e-02f, 1.73584335e-02f, 1.81719624e-02f, -2.06678063e-02f,
  -8.77814889e-02f, 7.48606846e-02f, -2.09016912e-02f, 4.79367785e-02f, -3.77235375e-02f, -6.88192770e-02f, -5.56223616e-02f, 4.53468710e-02f, 7.05303578e-03f, -6.04516342e-02f,
  2.78891236e-01f, 1.41746998e-01f, 8.65526218e-03f, 6.14247210e-02f, -2.03805175e-02f, -3.59535888e-02f, 2.07488053e-03f, 5.59780709e-02f, -9.33993608e-03f, 7.00602913e-03f,
  3.76508944e-02f, 9.25138891e-02f, 1.09265298e-01f, -3.23983058e-02f, -4.96222600e-02f, 5.64544983e-02f, 3.61695960e-02f, 3.66366049e-03f, -2.19889060e-02f, 2.91489679e-02f,
  1.80568814e-03f, -3.72991599e-02f, 1.38479611e-02f, 7.40859956e-02f, 1.16388097e-01f, 1.18080033e-02f, 7.59036019e-02f, 9.44062248e-02f, 5.99841848e-02f, 5.80448210e-02f,
  -1.66751854e-02f, 4.90079559e-02f, 3.57446700e-01f, 1.83259726e-01f, 6.48989454e-02f, 1.02551892e-01f, -3.23990136e-02f, 1.48317441e-02f, -1.82029568e-02f, 1.02211192e-01f,
  8.25204179e-02f, -1.81754958e-03f, -3.89167294e-02f, -7.70922527e-02f, -6.40019551e-02f, 1.96827754e-01f, 2.18726277e-01f, 1.75897464e-01f, 2.07819752e-02f, -5.33673400e-03f,
  6.84064906e-03f, 1.38894722e-01f, 8.68508667e-02f, 8.84826109e-02f, -1.48721889e-03f, 9.03360769e-02f, 1.65018067e-01f, 1.39485464e-01f, 9.09137577e-02f, 1.83982581e-01f,
  -4.60897908e-02f, 1.39372841e-01f, -7.78641701e-02f, -1.07249089e-01f, 6.23724423e-02f, -1.77882053e-02f, -2.13107560e-02f, 4.41259481e-02f, -2.62912456e-02f, -1.93662569e-02f,
  9.19548944e-02f, -8.13250318e-02f, -3.52361128e-02f, 5.03694937e-02f, 4.32396010e-02f, -3.54209021e-02f, -4.93115671e-02f, 6.44512055e-03f, -2.19057705e-02f, 7.67858401e-02f,
  4.37410511e-02f, 1.19848028e-01f, 3.10177356e-02f, -6.73098415e-02f, 9.52125937e-02f, 1.29186464e-02f, 4.58901264e-02f, 3.66884395e-02f, 5.33165745e-02f, -5.51671013e-02f,
  6.42424226e-02f, -6.12748191e-02f, -9.46661383e-02f, -5.94109893e-02f, -7.17576668e-02f, -7.03552291e-02f, 3.32433321e-02f, -7.28888204e-03f, -8.25224370e-02f, -2.09484957e-02f,
  -5.72772473e-02f, -4.98511158e-02f, 4.94221970e-02f, 2.71781869e-02f, 3.02491225e-02f, -3.09352819e-02f, -1.99013110e-02f, 5.27358577e-02f, -7.28796646e-02f, -3.10477316e-02f,
  -5.41318022e-02f, -7.73786306e-02f, 4.02921140e-02f, -3.00035812e-02f, 1.03581093e-01f, -1.67168938e-02f, -1.43522369e-02f, 3.71136442e-02f, -4.94293086e-02f, -1.10465121e-02f,
  -2.28671148e-01f, 5.66061325e-02f, -9.64280590e-02f, -6.10528924e-02f, 5.99054918e-02f, 1.12773571e-02f, 2.16361769e-02f, -2.18354166e-02f, -1.17119085e-02f, -4.50972915e-02f,
  -5.61327040e-02f, -2.99389269e-02f, 3.27781253e-02f, -8.81784782e-02f, -3.29378434e-02f, 3.23907956e-02f, -6.84976429e-02f, 3.44185606e-02f, 7.77216405e-02f, 2.84431297e-02f,
  -6.40400052e-02f, -9.16118547e-02f, -1.70360491e-01f, -1.43495262e-01f, 4.24343385e-02f, -4.09928896e-02f, -6.73847571e-02f, -1.29282072e-01f, -1.16068736e-01f, -2.68281281e-01f,
  3.42469424e-01f, 5.07548392e-01f, -2.03593954e-01f, -4.96194372e-03f, -5.67181222e-03f, -4.07977588e-02f, 1.22609742e-01f, 1.53774843e-01f, -8.47762153e-02f, 1.61265492e-01f,
  1.43182859e-01f, -7.62762502e-02f, -1.44801334e-01f, -6.10109493e-02f, -1.01521604e-01f, 6.98450953e-02f, -1.21853285e-01f, -2.22200796e-01f, -2.63898551e-01f, 1.31575884e-02f,
  6.41506016e-02f, -1.85233783e-02f, 7.75558650e-02f, 1.74739528e-02f, 1.96787249e-02f, -1.14849217e-01f, 9.00151879e-02f, 1.18065804e-01f, 1.12191558e-01f, 1.43211842e-01f,
  -2.62230672e-02f, 2.65659600e-01f, -2.15240061e-01f, 6.23798929e-02f, 7.50668161e-03f, 1.02561126e-02f, 4.92480658e-02f, -1.85748003e-02f, -3.85500863e-02f, 8.26040506e-02f,
  2.71005388e-02f, -6.21025302e-02f, 7.12827519e-02f, 4.71973158e-02f, 1.32758096e-01f, 6.34764284e-02f, 1.05986275e-01f, -8.37780535e-02f, -8.89090076e-02f, 1.61415897e-02f,
  1.19427294e-01f, 6.72884211e-02f, 9.90613550e-02f, 2.95419805e-02f, 6.36425391e-02f, -1.65226370e-01f, 1.10425524e-01f, 1.31617650e-01f, 4.43082787e-02f, 1.20148607e-01f,
  5.23075694e-03f, 2.99543235e-02f, 3.84852034e-03f, 1.80854965e-02f, -2.00553350e-02f, 2.46905182e-02f, -9.98979434e-03f, -4.86360583e-03f, -3.79783027e-02f, -3.30515392e-02f,
  -4.82453890e-02f, -4.61983718e-02f, 3.06913685e-02f, 6.77159280e-02f, -2.19825897e-02f, 1.62089653e-02f, 8.34711194e-02f, 2.22833082e-02f, 6.06473722e-02f, -9.34740901e-03f,
  -3.95366810e-02f, -3.14197056e-02f, 7.91448578e-02f, -4.17199917e-02f, -4.41245474e-02f, -1.45809306e-02f, -6.20525964e-02f, -1.03272786e-02f, -4.27610278e-02f, -2.75368579e-02f,
  -2.46250145e-02f, -1.19073100e-01f, -5.81429489e-02f, -4.43513542e-02f, 4.24300991e-02f, -4.37538289e-02f, 1.30034164e-02f, -6.83809146e-02f, -9.75027680e-03f, 9.92813036e-02f,
  -7.29202479e-03f, -1.86717529e-02f, 5.91945574e-02f, -2.23837439e-02f, -1.13691598e-01f, -2.09338255e-02f, 1.15546204e-01f, -7.94153959e-02f, -1.41312378e-02f, 6.11121319e-02f,
  6.88744336e-02f, 5.66704459e-02f, -8.56824815e-02f, -2.14685462e-02f, 8.65462869e-02f, -1.43097907e-01f, -9.32231471e-02f, -8.28614160e-02f, -8.34459886e-02f, -4.73779254e-02f,
  -3.39226812e-01f, -2.17479333e-01f, 2.82309800e-02f, -9.99692753e-02f, 2.93669879e-01f, 3.59785765e-01f, 2.71060228e-01f, 1.27965689e-01f, 5.84008209e-02f, 2.90934108e-02f,
  5.48266098e-02f, 9.91749391e-03f, 3.55862640e-02f, 4.85772314e-03f, -1.12402812e-03f, 4.69875894e-02f, 2.42022853e-02f, -1.34686157e-02f, 8.57004970e-02f, 1.55257136e-01f,
  1.25055481e-02f, -1.69936240e-01f, -2.64286816e-01f, -1.35693148e-01f, -1.33868396e-01f, 7.04606771e-02f, -1.11020617e-01f, -1.46631569e-01f, 7.30677545e-02f, -2.78735667e-01f,
  -2.05934927e-01f, -2.05916420e-01f, 1.02434903e-01f, 2.20114328e-02f, -1.00993447e-01f, -8.39801207e-02f, 1.68442465e-02f, -1.43643349e-01f, 2.58411281e-02f, -9.23038423e-02f,
  -5.04272096e-02f, -5.26537299e-02f, -3.48387584e-02f, -2.90584024e-02f, 1.53274210e-02f, 2.83596832e-02f, -1.49831310e-01f, -6.03443012e-02f, -5.30273765e-02f, -1.06224082e-01f,
  -1.47303252e-03f, -1.50861321e-02f, 7.08833113e-02f, -1.62476301e-02f, 1.13188542e-01f, 2.16157530e-02f, 4.80918996e-02f, -4.49897610e-02f, 3.59049477e-02f, -2.30726153e-01f,
  -2.52438355e-02f, 4.88954633e-02f, 6.16614036e-02f, 2.38467958e-02f, -4.66458368e-05f, 4.15052027e-02f, 2.85020913e-03f, 3.04642469e-02f, 1.95498075e-02f, -3.47614922e-02f,
  5.51811196e-02f, 2.61739884e-02f, 2.49430537e-02f, -4.77979258e-02f, -2.47902367e-02f, 2.29743663e-02f, 3.25705335e-02f, 8.77149403e-03f, -4.75240536e-02f, -7.14998469e-02f,
  -5.97236082e-02f, 8.21807012e-02f, -3.40780430e-02f, -6.37480915e-02f, 6.67070225e-02f, 7.54481589e-04f, -2.12224275e-02f, 1.67670306e-02f, -5.11794388e-02f, -3.59112099e-02f,
  -1.89587280e-01f, 3.09354216e-01f, -5.48747554e-02f, -5.75568620e-03f, 4.29539494e-02f, -3.24929841e-02f, -3.67046297e-02f, -3.63759836e-03f, -1.94531474e-02f, 3.37873437e-02f,
  6.56067505e-02f, -6.44137710e-02f, -1.87951494e-02f, -3.39963995e-02f, -3.67622823e-02f, 2.97599677e-02f, -4.29905066e-03f, 1.24552799e-02f, 5.10257073e-02f, 2.35276725e-02f,
  8.85452703e-02f, 2.75148284e-02f, 1.10301994e-01f, 1.19578473e-01f, 4.39817719e-02f, 1.79285422e-01f, 8.32351968e-02f, 9.28118303e-02f, 1.16782844e-01f, -1.37370944e-01f,
  -8.18017777e-03f, -2.01182842e-01f, -3.26908886e-01f, 5.48603646e-02f, -6.89875260e-02f, -5.23746014e-02f, -1.76815197e-01f, 3.58444639e-02f, 2.45996136e-02f, 2.25238856e-02f,
  -4.21122508e-03f, 2.18941346e-01f, 1.37180373e-01f, 7.52876624e-02f, -3.82343642e-02f, -4.71002795e-02f, 1.98600162e-02f, 3.86203732e-03f, 3.17558907e-02f, 1.32059157e-01f,
  1.85448751e-01f, 1.61040679e-01f, -3.21600586e-02f, 9.76370648e-02f, 1.18383341e-01f, 1.08151935e-01f, -8.22042227e-02f, -8.12802091e-02f, -2.19487795e-03f, 5.79827139e-03f,
  -1.89697355e-01f, -1.40406907e-01f, 9.52142552e-02f, 1.07563265e-01f, -6.71917619e-03f, -5.30692637e-02f, -7.81744942e-02f, -9.39493030e-02f, -2.34316643e-02f, -2.77804155e-02f,
  -3.34646879e-03f, -6.72543198e-02f, 3.73835005e-02f, 6.02606870e-02f, 1.92289837e-02f, 4.16333489e-02f, -5.45118377e-02f, 3.58111821e-02f, 1.84816457e-02f, -1.00750104e-01f,
  3.33799534e-02f, 3.43518816e-02f, -7.47471824e-02f, -9.27451774e-02f, -1.54793551e-02f, -3.82795930e-02f, -9.39742476e-02f, -2.95617077e-02f, -8.94948002e-03f, -1.22648273e-02f,
  -1.51535869e-02f, 3.32973190e-02f, -9.58606601e-02f, -6.12381101e-02f, -8.99350643e-03f, 8.05847347e-02f, -2.94017382e-02f, 1.39889503e-02f, 7.21332431e-02f, 4.24563475e-02f,
  -6.03065044e-02f, -5.92795052e-02f, -2.08744574e-02f, -1.40771521e-02f, 3.83919738e-02f, 2.26564743e-02f, -6.48896173e-02f, -1.11501198e-03f, 1.48819434e-02f, -1.01440412e-03f,
  -3.64695601e-02f, 1.53116742e-02f, -8.45554918e-02f, 4.76885997e-02f, -8.04954916e-02f, -3.55268717e-02f, 4.59223762e-02f, -5.22671603e-02f, -1.63659099e-02f, -1.43051799e-02f,
  2.29381267e-02f, -7.05075413e-02f, 3.07887737e-02f, -2.93482412e-02f, -2.84782797e-02f, -4.77424450e-02f, -4.63386532e-03f, 3.01550739e-02f, -1.25611471e-02f, -4.74518277e-02f,
  -7.69131780e-02f, -7.13582709e-02f, -3.27647179e-02f, -5.80798686e-02f, -3.03392578e-03f, 2.80479491e-02f, 5.99059416e-03f, -5.33442311e-02f, -4.18060087e-02f, 2.63991058e-02f,
  1.64822582e-02f, -2.12595016e-02f, 3.98164690e-02f, -4.91768718e-02f, -3.77887897e-02f, -2.96297688e-02f, -3.11638005e-02f, -5.17657883e-02f, -1.45148411e-01f, -1.32360891e-01f,
  -1.93954960e-01f, -2.88565397e-01f, 1.58249913e-03f, 4.26710583e-02f, 2.89273430e-02f, 8.73318911e-02f, -1.74369618e-01f, -1.09295016e-02f, -8.04337487e-02f, -1.05760038e-01f,
  -2.62906379e-03f, 1.06235325e-01f, 1.34710282e-01f, 3.80941592e-02f, 4.86165360e-02f, -1.66898414e-01f, 1.82348751e-02f, 3.31214145e-02f, 1.44037634e-01f, 1.40494928e-01f,
  1.03348367e-01f, 5.23517430e-02f, -9.06714350e-02f, 1.80462729e-02f, 5.28583974e-02f, 1.29432246e-01f, -1.35012612e-01f, 4.57634665e-02f, 1.28610367e-02f, -4.42565121e-02f,
  1.02149233e-01f, -1.38751656e-01f, 1.03750736e-01f, -1.50430750e-03f, -4.64168787e-02f, -3.14953434e-03f, -5.63267246e-02f, -5.56575097e-02f, -8.01001489e-02f, 5.17733991e-02f,
  -3.21791694e-03f, 1.04409240e-01f, 9.94154289e-02f, 1.04660667e-01f, 2.16198433e-02f, 1.12075489e-02f, -8.53003561e-02f, 2.08677631e-02f, 5.34859262e-02f, -8.16794708e-02f,
  8.94803703e-02f, -8.58830363e-02f, -2.48224325e-02f, -4.07856964e-02f, 2.23572869e-02f, 1.39554024e-01f, -1.15946904e-01f, 4.94204275e-02f, -4.62330431e-02f, -2.21507996e-02f,
  -7.17244744e-02f, -7.44378641e-02f, 9.41474363e-02f, -4.57386002e-02f, 2.31441185e-02f, -5.64309731e-02f, -4.34661210e-02f, 3.51901650e-02f, 4.95051742e-02f, -8.25422332e-02f,
  -1.60392001e-02f, 6.21446595e-02f, 5.20371944e-02f, -3.40454057e-02f, 7.32952869e-03f, 4.15876321e-02f, 8.41611549e-02f, 1.95093267e-02f, -1.13264881e-02f, -4.94679902e-03f,
  7.68439770e-02f, -7.33091822e-03f, 8.71107355e-02f, 1.32095488e-02f, 2.10082624e-02f, -5.06744459e-02f, 4.04631011e-02f, -2.47999448e-02f, -5.95735125e-02f, 1.26950666e-02f,
  1.10073434e-02f, 6.54806048e-02f, 5.82293198e-02f, -2.30452903e-02f, -8.57508928e-02f, 3.85405086e-02f, 6.66684583e-02f, -7.91177910e-04f, 2.74430253e-02f, -2.41517695e-03f,
  3.94447818e-02f, -1.31052844e-02f, 7.36939311e-02f, 1.44233620e-02f, 5.29582053e-02f, 2.74821669e-02f, -2.82416996e-02f, -1.87361352e-02f, 7.62463957e-02f, -7.62659684e-02f,
  -9.02824774e-02f, -9.46989730e-02f, 1.98109215e-03f, -5.04347794e-02f, -1.93495192e-02f, 8.90111774e-02f, 1.68517455e-02f, 8.21962655e-02f, -4.57583517e-02f, -1.92240253e-01f,
  -6.43512383e-02f, -1.92477837e-01f, -3.21356952e-01f, 1.48471650e-02f, -1.32367373e-01f, -3.17979038e-01f, -3.79724354e-01f, 3.84517536e-02f, 1.00649603e-01f, -1.18774520e-02f,
  -9.36296135e-02f, 8.01719129e-02f, 1.22642882e-01f, 1.58332676e-01f, -4.72334735e-02f, -6.91838488e-02f, -4.81026508e-02f, 1.07196830e-01f, -4.05414887e-02f, 1.71172526e-02f,
  1.94196746e-01f, 8.85814354e-02f, 1.90106064e-01f, 1.11524843e-01f, 9.81049985e-02f, 1.86190885e-02f, 1.43323466e-02f, 6.82414100e-02f, -7.81809092e-02f, 6.92693070e-02f,
  -2.60017067e-01f, -1.55377731e-01f, 5.38788252e-02f, 1.72319919e-01f, -4.98387255e-02f, 4.63464670e-02f, -5.88733107e-02f, -3.43773142e-02f, 6.42981082e-02f, -2.05099378e-02f,
  3.59659232e-02f, 8.42733160e-02f, -4.32106331e-02f, 8.56864154e-02f, 2.34299898e-02f, 4.52043638e-02f, 5.94439395e-02f, 9.18003991e-02f, -1.52184106e-02f, -9.56600532e-02f,
  5.49261421e-02f, -1.23874769e-01f, -6.14971481e-02f, -3.73775288e-02f, -7.92558864e-02f, -9.97486568e-05f, -5.32454923e-02f, -7.63249919e-02f, -8.79044533e-02f, 5.93033768e-02f,
  -4.75961482e-03f, -6.32067025e-02f, -2.68780291e-02f, 5.21357507e-02f, 6.49144277e-02f, -2.47094501e-02f, -1.95529331e-02f, -2.80547254e-02f, 2.56648157e-02f, 2.45822780e-02f,
  1.02108316e-02f, 2.62484290e-02f, -5.19589111e-02f, 2.06608400e-02f, 1.11977048e-01f, -6.64597750e-02f, -3.45499329e-02f, 7.78582022e-02f, -6.11832142e-02f, 3.01639009e-02f,
  4.23860811e-02f, -1.98467728e-02f, -3.71098034e-02f, 4.76566590e-02f, -2.87553146e-02f, 6.83621541e-02f, -6.93732724e-02f, 7.96120539e-02f, 3.73312272e-02f, -8.86394233e-02f,
  7.51029998e-02f, -1.00161888e-01f, -9.92311463e-02f, 7.23997802e-02f, -6.05683476e-02f, 2.36667916e-02f, -5.74148148e-02f, 2.03727502e-02f, -7.14054480e-02f, 1.02502611e-02f,
  -3.52799073e-02f, -4.16299663e-02f, -7.81288464e-03f, 4.33880314e-02f, -3.23190354e-02f, -8.25237781e-02f, 1.23442225e-01f, -3.43033820e-02f, -2.71730535e-02f, 2.21143905e-02f,
  9.25414711e-02f, -1.31823525e-01f, -1.64639413e-01f, -5.52348122e-02f, -3.87598784e-03f, -1.05198130e-01f, -1.69514105e-01f, -1.41472429e-01f, -1.64829165e-01f, -1.03093907e-01f,
  -4.63511646e-01f, -1.60926357e-01f, -3.78397048e-01f, -1.90076046e-02f, 1.68095201e-01f, 7.89700970e-02f, -9.19702947e-02f, -5.96079752e-02f, 1.34285942e-01f, 4.10920754e-02f,
  5.24438731e-02f, 2.39331007e-01f, 1.82060078e-01f, 8.20124075e-02f, -1.24573000e-01f, -3.18584889e-02f, -1.25714734e-01f, -2.34173656e-01f, -9.18200091e-02f, 3.50673050e-02f,
  1.45396486e-01f, -1.46423257e-03f, -1.22096382e-01f, -4.99728210e-02f, -7.83523172e-02f, -4.41357493e-03f, -8.27428624e-02f, -1.53708503e-01f, -7.12618604e-02f, -6.59863427e-02f,
  8.53024051e-02f, -2.87407666e-01f, 6.03007991e-03f, 1.47238046e-01f, -6.52847160e-03f, 7.92525025e-05f, 2.23357766e-03f, -8.42377096e-02f, 9.36909318e-02f, -6.92539513e-02f,
  -9.58579499e-03f, 9.45426524e-02f, -3.35019454e-02f, 3.01105324e-02f, -9.86776967e-03f, -3.20072025e-02f, -1.21549726e-01f, -1.53880954e-01f, -1.39677495e-01f, 5.94297163e-02f,
  4.29248884e-02f, 6.07202537e-02f, -1.59126267e-01f, -1.90155730e-02f, -1.21303633e-01f, -3.50912213e-02f, -1.05163015e-01f, -1.75433964e-01f, -2.13572085e-01f, -1.43153965e-01f,
  2.57927738e-02f, 8.00179970e-03f, -2.67094839e-02f, -8.38340521e-02f, 2.48901509e-02f, 2.52161678e-02f, -2.71004438e-02f, 4.26046066e-02f, -8.87812953e-03f, -5.17031625e-02f,
  -3.00740488e-02f, 1.57232489e-02f, 2.33332952e-03f, -1.61925182e-02f, 9.56372451e-03f, -5.81284352e-02f, 2.56701559e-02f, -6.58352003e-02f, 3.69782560e-02f, -4.08607302e-03f,
  2.12103594e-02f, 3.47818271e-03f, -6.00171834e-02f, 3.78295220e-02f, -9.79817286e-02f, -9.79388356e-02f, 4.58013117e-02f, -2.01112852e-02f, 7.82874525e-02f, 2.12173332e-02f,
  2.10510716e-01f, -1.07842907e-01f, 7.11049885e-02f, -5.99904023e-02f, -1.98325701e-02f, 4.04929183e-03f, 1.02121457e-01f, -4.42524701e-02f, -6.37053698e-02f, -5.02040945e-02f,
  -2.08995417e-02f, -9.68068913e-02f, 3.74807939e-02f, 5.03981560e-02f, -2.80364417e-03f, -1.04409864e-03f, 8.68664533e-02f, -4.39741462e-02f, 2.67510526e-02f, 4.97881919e-02f,
  9.55269337e-02f, 1.89168621e-02f, -2.28942912e-02f, 9.18061435e-02f, 3.75338420e-02f, 6.80245385e-02f, 4.74457949e-04f, 3.93409766e-02f, -8.43090117e-02f, -4.98543531e-02f,
  1.43146321e-01f, 2.86056241e-03f, -8.90386850e-02f, 3.00469846e-02f, 1.86604552e-03f, -2.62305476e-02f, -2.56022692e-01f, -4.25871126e-02f, 2.27832887e-02f, -6.60650060e-02f,
  9.73340124e-02f, -5.68054477e-03f, 9.98646021e-04f, -1.49781089e-02f, -1.71082765e-01f, -3.98672409e-02f, -1.78491905e-01f, -8.73467624e-02f, -1.16555028e-01f, -8.88357759e-02f,
  -4.78502773e-02f, 3.05974726e-02f, -8.11739489e-02f, 5.74002191e-02f, 1.45111933e-01f, 1.06027238e-01f, 1.21617932e-02f, 1.19331859e-01f, -3.43782380e-02f, 1.31279677e-01f,
  2.49174424e-02f, 2.64500797e-01f, -8.09953213e-02f, 2.39678808e-02f, 4.70125638e-02f, -2.64181960e-02f, 7.82442465e-03f, 4.93835919e-02f, -8.91895406e-03f, -8.34344998e-02f,
  1.21266320e-02f, -6.36600796e-03f, -1.23891765e-02f, 1.06860198e-01f, -5.49317040e-02f, -3.42763588e-02f, -1.17542133e-01f, -4.84537557e-02f, -5.06553426e-02f, 9.85569209e-02f,
  -2.11451687e-02f, 6.24130946e-03f, 5.64071238e-02f, 1.75330266e-02f, -3.30375917e-02f, -4.77904864e-02f, 7.12253451e-02f, 1.02259323e-01f, -3.26355617e-03f, 1.00282207e-01f,
  -4.41123545e-02f, 4.87773269e-02f, -2.98706051e-02f, -4.52949814e-02f, -6.66071996e-02f, -4.95572500e-02f, 1.95783004e-02f, 3.37898657e-02f, 4.06635143e-02f, -5.24648204e-02f,
  5.83566427e-02f, 6.81750998e-02f, 4.44410145e-02f, -7.31205661e-03f, 2.42387913e-02f, 7.10672662e-02f, 6.74465718e-03f, -5.61682098e-02f, 3.33709866e-02f, 1.39124524e-02f,
  -1.45337777e-02f, -5.07057309e-02f, 2.41874922e-02f, 2.04315893e-02f, 6.02772273e-02f, -2.38343002e-03f, -4.43509296e-02f, -2.08755098e-02f, 1.04638427e-01f, 1.92915890e-02f,
  -6.28080070e-02f, -4.49142680e-02f, 3.59334163e-02f, -4.20835130e-02f, 4.30986509e-02f, 4.11805287e-02f, 2.45436188e-02f, 2.46315077e-02f, 6.24780729e-02f, -7.71144554e-02f,
  -1.73386857e-02f, -5.81289567e-02f, 1.50977559e-02f, -3.73593345e-02f, -9.16194394e-02f, -1.03288457e-01f, -1.55868486e-01f, -1.64870620e-02f, -4.84321006e-02f, -4.55755368e-03f,
  -4.67055589e-02f, -2.20350757e-01f, -1.27772868e-01f, -7.16715753e-02f, 1.45917805e-02f, -1.13474153e-01f, -4.58450541e-02f, 1.31513015e-03f, -1.73087180e-01f, -2.89156854e-01f,
  1.85745507e-02f, 2.07608342e-01f, -1.40636221e-01f, -7.69993523e-03f, -1.85557425e-01f, -1.16680026e-01f, 2.68255435e-02f, -1.93908233e-02f, 6.19883873e-02f, 1.12193227e-01f,
  7.71364644e-02f, 4.09747213e-02f, -2.17620749e-02f, -8.74644220e-02f, 6.33850023e-02f, 3.09394021e-02f, 1.25991441e-02f, -1.37869298e-01f, -1.69442728e-01f, -1.01987951e-01f,
  8.29863921e-03f, -6.33677915e-02f, -2.65469085e-02f, -8.85625780e-02f, 3.48927788e-02f, 1.64598599e-02f, 2.18614992e-02f, -4.84071970e-02f, 6.66828230e-02f, 4.30581486e-03f,
  9.63281095e-02f, 1.20198063e-03f, -1.01343632e-01f, -4.44294885e-02f, 8.71522129e-02f, 8.85843784e-02f, -6.00220263e-02f, 4.92347516e-02f, 8.28876272e-02f, 9.30684060e-02f,
  2.38969866e-02f, 3.41698490e-02f, -1.17026838e-02f, 9.64443758e-02f, 3.20217460e-02f, 1.10904411e-05f, 1.21492989e-01f, -1.40663916e-02f, -3.91954817e-02f, 2.44936887e-02f,
  2.22851709e-02f, -5.15875146e-02f, -5.47901355e-02f, 2.52375137e-02f, 5.09151332e-02f, -1.12323537e-01f, -1.59166642e-02f, -3.06948181e-02f, -4.14669700e-02f, 3.64104323e-02f,
  6.26502708e-02f, -5.73731512e-02f, 2.26890706e-02f, -6.15767799e-02f, 6.50745770e-03f, -6.36718124e-02f, 8.18731636e-03f, 5.28819039e-02f, -4.72688861e-02f, 5.66135608e-02f,
  -1.88248213e-02f, 5.70225492e-02f, 3.54979932e-02f, 1.63354129e-02f, -5.65574691e-02f, -7.62016624e-02f, 4.47042771e-02f, 9.46716890e-02f, -4.29162532e-02f, -1.67218875e-02f,
  -5.48040830e-02f, -2.79603973e-02f, -3.03986706e-02f, -3.05443909e-02f, 2.11739223e-02f, -2.20086128e-02f, 2.44928189e-02f, -3.34274881e-02f, -3.38886939e-02f, 5.20616919e-02f,
  1.45000741e-01f, -3.26991007e-02f, 4.19912152e-02f, -2.82894205e-02f, -6.45444244e-02f, 8.79881233e-02f, -5.72329797e-02f, -3.71973682e-03f, -3.14373896e-02f, -1.42240841e-02f,
  3.74220870e-02f, -5.00884391e-02f, 2.77745426e-02f, 9.83497351e-02f, 4.25757170e-02f, 3.04794926e-02f, 6.81771785e-02f, -1.56697910e-02f, -1.79180354e-02f, 3.26555297e-02f,
  -2.49810237e-02f, -9.16397497e-02f, -1.54198066e-03f, -4.69087623e-03f, -9.99613628e-02f, -8.62623081e-02f, -4.05055992e-02f, 5.83890826e-03f, -1.24016084e-01f, 1.27454147e-01f,
  1.60216123e-01f, -1.95692554e-01f, 1.02282114e-01f, 8.50624442e-02f, 1.63215145e-01f, -8.37760046e-02f, -2.30688453e-01f, -1.15807191e-01f, 1.23759307e-01f, 5.89284115e-02f,
  1.01507589e-01f, 1.61141023e-01f, 1.57075569e-01f, 3.16864289e-02f, -1.02344729e-01f, -1.65991634e-01f, 1.81683227e-02f, -9.47328005e-03f, 1.70725986e-01f, 1.01166353e-01f,
  -4.96351048e-02f, 3.76119837e-02f, 9.77792963e-02f, 1.19688056e-01f, 4.42444198e-02f, 1.19403921e-01f, 1.13842376e-01f, -1.73188224e-02f, -5.22035286e-02f, 9.96188149e-02f,
  1.85563460e-01f, -1.07964814e-01f, 6.07245900e-02f, -7.78940022e-02f, -4.62542893e-03f, -1.10214822e-01f, -4.62455228e-02f, 2.70744693e-03f, -1.07179033e-02f, -4.27062213e-02f,
  7.33003467e-02f, 6.28996417e-02f, 1.35638937e-01f, 6.14389144e-02f, -4.28822078e-02f, 3.45695168e-02f, -9.26193446e-02f, 5.07924929e-02f, 1.85375959e-02f, -5.19576296e-03f,
  5.59491944e-03f, 4.59007593e-03f, 8.23583379e-02f, -2.09938688e-03f, -1.21185899e-01f, 1.10448882e-01f, 3.84927951e-02f, -6.28435984e-02f, -1.85272209e-02f, -4.75648232e-02f,
  -8.32867846e-02f, 8.61456618e-02f, -9.37169977e-03f, 4.89099622e-02f, -1.96304601e-02f, 4.95497845e-02f, 7.86581188e-02f, 5.23542948e-02f, 7.09453672e-02f, -6.95879683e-02f,
  4.01823185e-02f, -7.95619469e-03f, 2.59668939e-02f, 3.87083516e-02f, 7.31234625e-02f, 1.75120886e-02f, -2.37634610e-02f, -7.01639801e-02f, 3.07933614e-02f, 2.28085779e-02f,
  -4.33831662e-02f, 2.45184060e-02f, 1.48325088e-02f, -3.97016816e-02f, -3.72494012e-02f, -5.61146857e-03f, 2.13109273e-02f, -1.51960431e-02f, 9.18608159e-02f, -8.37994460e-03f,
  1.54436201e-01f, -5.62311523e-02f, 1.37442267e-02f, -2.44720150e-02f, 2.57275030e-02f, -9.26796068e-03f, 9.36415885e-03f, -1.08557984e-01f, 3.12007423e-02f, -1.84700564e-02f,
  -4.81191687e-02f, 3.04059796e-02f, 7.63127133e-02f, -6.15022928e-02f, 8.12326446e-02f, 4.22585607e-02f, -1.02945857e-01f, 9.79046971e-02f, -1.16969412e-02f, 6.45731343e-03f,
  -6.39147907e-02f, -7.69406930e-02f, 4.02653627e-02f, -5.95442131e-02f, -5.12641668e-02f, -5.55475568e-03f, 8.59976336e-02f, 3.37789673e-03f, -8.28459784e-02f, -1.26851201e-01f,
  -2.38538176e-01f, -7.61662126e-02f, 8.12755451e-02f, 7.96885267e-02f, -7.36843720e-02f, -1.16695039e-01f, -1.32518917e-01f, -9.77736525e-03f, 1.19482763e-02f, 5.60335331e-02f,
  6.56327531e-02f, 1.27270415e-01f, 2.13351324e-02f, 3.99653018e-02f, -2.89919768e-02f, 3.34339999e-02f, -3.05118058e-02f, -3.39845531e-02f, -3.95240113e-02f, -7.07371309e-02f,
  -1.11729726e-01f, -1.06601775e-01f, -1.44671276e-01f, -9.92479771e-02f, -2.18656454e-02f, -1.17253382e-02f, 2.60081869e-02f, 7.01467022e-02f, -3.08908261e-02f, 1.08509853e-01f,
  4.01898213e-02f, -8.76520574e-02f, 5.15797511e-02f, -3.46820243e-02f, 1.33153230e-01f, -1.60389580e-02f, -1.00747487e-02f, 2.69442778e-02f, -2.12741345e-02f, 1.78938601e-02f,
  -4.82535847e-02f, -5.69797084e-02f, 2.13637296e-02f, -8.88749491e-03f, 4.68133800e-02f, -6.64931163e-02f, -4.51515988e-02f, 6.61047399e-02f, 7.77545720e-02f, -7.79052302e-02f,
  -2.60129687e-04f, -8.85606259e-02f, -8.11771750e-02f, 1.16007701e-02f, -5.58631383e-02f, 2.81566903e-02f, -5.23047186e-02f, 8.79570656e-03f, -1.21400207e-01f, 1.52302217e-02f,
  -8.31376165e-02f, -1.41701102e-02f, -4.51433025e-02f, -5.01562990e-02f, -3.14112790e-02f, 5.98769151e-02f, -4.82449979e-02f, 6.67585433e-02f, 3.76302074e-03f, -9.62145105e-02f,
  2.44936161e-02f, -8.54764953e-02f, -2.81956065e-02f, 1.75744519e-02f, -2.55868230e-02f, -5.80840595e-02f, -2.15747654e-02f, -1.07574742e-02f, -3.57996859e-02f, -1.01469494e-01f,
  -6.80064633e-02f, -1.18021034e-02f, -3.11836936e-02f, 1.72796566e-02f, -7.01853121e-03f, -6.83217570e-02f, -4.14213948e-02f, -6.12784699e-02f, 6.73797280e-02f, -6.00186139e-02f,
  1.97906438e-02f, -8.10581967e-02f, -9.83693749e-02f, 2.18837317e-02f, -7.93121085e-02f, -8.19615461e-03f, 8.90352428e-02f, 2.46522296e-02f, 7.52916036e-04f, -9.23782140e-02f,
  -4.84189130e-02f, 6.17005154e-02f, 2.70966198e-02f, 4.15043458e-02f, -5.94277009e-02f, 9.00176540e-03f, -1.18960947e-01f, 3.21635157e-02f, -9.81385857e-02f, 6.41484112e-02f,
  -1.00109510e-01f, -9.81399640e-02f, -3.71861272e-02f, 5.33860326e-02f, -3.68761010e-02f, -1.07539311e-01f, -1.59881078e-02f, -8.31756890e-02f, -5.79118654e-02f, -1.44763246e-01f,
  -4.06063586e-01f, -9.76713449e-02f, -2.98304837e-02f, -1.51388019e-01f, 4.01524603e-02f, -1.43698245e-01f, -2.32440844e-01f, -2.11097240e-01f, -1.04009986e-01f, -2.64734179e-02f,
  5.17788976e-02f, 1.07727386e-01f, -2.74522826e-02f, 2.55315714e-02f, -7.87091721e-03f, -9.54020582e-03f, -1.01911118e-02f, 4.58217897e-02f, -1.41107380e-01f, 2.52426080e-02f,
  2.36190110e-02f, -1.23906493e-01f, -1.63741499e-01f, 2.21706759e-02f, 6.29715845e-02f, 9.55550149e-02f, 1.17408559e-01f, 7.77900144e-02f, 1.65404007e-01f, 2.10848391e-01f,
  7.23722950e-02f, -3.51080783e-02f, -7.06831515e-02f, 9.75617766e-02f, 5.25602438e-02f, -1.16215192e-03f, -1.30392257e-02f, -3.19839790e-02f, 8.01502094e-02f, 6.54558241e-02f,
  1.12152018e-01f, 6.98465779e-02f, 3.72169316e-02f, 4.96751666e-02f, -4.34279405e-02f, 1.31076239e-02f, 7.38363042e-02f, -8.13021511e-02f, 4.64696623e-02f, 8.66964310e-02f,
  1.94276512e-01f, 2.27749683e-02f, -1.29488438e-01f, 5.13594672e-02f, 2.42013931e-02f, 6.36318028e-02f, 1.02714367e-01f, 9.32466909e-02f, -7.82299340e-02f, -3.10262721e-02f,
  8.68967324e-02f, 7.41778091e-02f, -5.32271527e-02f, 3.31959836e-02f, 5.79468766e-03f, 3.37651819e-02f, 3.16292457e-02f, 4.66503911e-02f, -1.38440402e-02f, -9.44276080e-02f,
  -5.20946365e-03f, -4.99832071e-02f, -6.74329773e-02f, -5.89573532e-02f, 1.80403721e-02f, 8.76448024e-03f, -5.48158400e-02f, 1.47043373e-02f, 3.85342240e-02f, 2.02899277e-02f,
  -3.57207214e-03f, 2.24520788e-02f, -1.86393764e-02f, -3.41962986e-02f, 9.63434130e-02f, -3.45235579e-02f, 4.61655029e-04f, 3.03412490e-02f, 2.15320047e-02f, 3.86419743e-02f,
  -1.74597546e-01f, -6.26282347e-03f, 1.96039286e-02f, -5.24657518e-02f, 7.06841350e-02f, 3.42121050e-02f, 2.36821678e-02f, -2.27936320e-02f, 4.01656292e-02f, -4.37059067e-02f,
  2.92479321e-02f, -6.20219670e-02f, -2.00713016e-02f, 4.97420244e-02f, -2.46314649e-02f, -3.38657349e-02f, -2.77227648e-02f, -8.81450996e-02f, -5.62785827e-02f, 2.02582013e-02f,
  3.99781875e-02f, -1.95817873e-01f, -1.47445321e-01f, -1.14121273e-01f, -5.20592555e-02f, -2.92971786e-02f, -1.51565820e-01f, -1.32569730e-01f, -2.17667818e-01f, -1.72001615e-01f,
  -3.03767115e-01f, 3.54264975e-02f, 1.54310539e-01f, -2.63737198e-02f, 1.91814438e-01f, 1.95008636e-01f, 3.29195142e-01f, 4.48372848e-02f, -1.17203422e-01f, 1.44934967e-01f,
  -6.40202984e-02f, -3.05288732e-02f, -1.08495392e-01f, 5.52884527e-02f, 1.35622332e-02f, 1.59202933e-01f, 2.05362111e-01f, 1.85765281e-01f, 1.74487516e-01f, 5.76702692e-02f,
  1.70055926e-01f, -9.84599441e-03f, -4.32112738e-02f, -4.13932875e-02f, 2.16760281e-02f, -5.90265431e-02f, 8.56224261e-03f, 7.13743195e-02f, 1.30724246e-02f, -1.50735155e-02f,
  1.92344770e-01f, -2.72801846e-01f, 9.16613173e-03f, -2.13175882e-02f, -4.57707793e-02f, 5.24760671e-02f, 1.90233458e-02f, -7.53224343e-02f, 2.21186392e-02f, 9.04879645e-02f,
  5.84072918e-02f, -4.90243994e-02f, -1.01415984e-01f, -1.01752812e-02f, 2.45133042e-02f, -6.31596074e-02f, -5.68698905e-02f, -3.04000527e-02f, -7.29852589e-03f, 6.55602440e-02f,
  -3.57940532e-02f, 9.34890807e-02f, 6.16848618e-02f, -5.50696142e-02f, -1.01683803e-01f, 3.58724222e-02f, 4.08919863e-02f, -6.61834851e-02f, -9.43052694e-02f, -6.96714073e-02f,
  5.02460673e-02f, 2.37861220e-02f, -8.52897391e-02f, 2.58250013e-02f, -1.66431721e-02f, -5.56275547e-02f, 1.63444262e-02f, 7.71472678e-02f, 3.00913323e-02f, -2.43026149e-02f,
  2.48450618e-02f, -1.18336454e-02f, 1.17254369e-02f, -9.05359630e-03f, -6.34622201e-02f, 5.72471432e-02f, 2.87863743e-02f, 5.26112616e-02f, 1.17444359e-02f, 2.66303420e-02f,
  -5.47884591e-02f, -8.26197397e-03f, -2.20459681e-02f, -1.57535188e-02f, -8.02742764e-02f, 2.89074462e-02f, 3.83011103e-02f, -5.18823713e-02f, -4.05565761e-02f, -4.28364100e-03f,
  4.75424230e-02f, -1.27708286e-01f, 2.68682204e-02f, 2.90688928e-02f, 5.69212772e-02f, -9.09347273e-03f, 2.90190205e-02f, -2.66846064e-02f, -5.46334274e-02f, 5.32950833e-02f,
  -4.60284427e-02f, -5.25362864e-02f, -4.70553041e-02f, 5.37897535e-02f, 1.03265099e-01f, 6.87260041e-03f, 1.36762679e-01f, 6.77108839e-02f, -5.22666553e-04f, 1.85941532e-02f,
  5.55081926e-02f, 9.36490446e-02f, 2.04493776e-01f, 1.44118711e-01f, 1.00352801e-01f, 7.91889429e-02f, 6.52827322e-02f, 1.11844972e-01f, 1.40651226e-01f, 1.08598784e-01f,
  -4.46330532e-02f, -3.38593386e-02f, 3.59930456e-01f, -1.00032955e-01f, -1.59030929e-01f, -1.03917131e-02f, -7.28135630e-02f, 7.44037563e-03f, -9.63925719e-02f, -8.03210661e-02f,
  -1.44733921e-01f, -5.50188869e-02f, 1.69795416e-02f, 1.06073149e-01f, 2.21538812e-01f, 1.43424064e-01f, 1.57165036e-01f, 2.59350955e-01f, 1.91958547e-01f, -1.82330385e-01f,
  -1.64401919e-01f, -7.15025887e-02f, 1.01328038e-01f, 1.66643895e-02f, -1.50873885e-01f, -4.51512635e-02f, 4.94583994e-02f, 1.46334842e-02f, -5.45141883e-02f, 5.00970706e-02f,
  9.61867198e-02f, -2.65656654e-02f, 6.32239953e-02f, -4.94616665e-02f, -1.20770141e-01f, 2.74236575e-02f, -5.64973243e-02f, -3.34192403e-02f, -1.67732481e-02f, 6.32300898e-02f,
  -1.36822566e-01f, -8.49319175e-02f, -5.48201092e-02f, -6.26838207e-02f, -4.84674703e-03f, -8.28071460e-02f, 1.30339637e-01f, 1.66407511e-01f, 1.36639729e-01f, 4.47216034e-02f,
  -1.86588705e-01f, -5.00426292e-02f, 9.67270657e-02f, 1.32594705e-02f, -3.96101363e-02f, -1.79349165e-02f, -3.66119593e-02f, 4.92084175e-02f, 2.18772516e-02f, 1.61592066e-01f,
  3.89654785e-02f, 6.48393407e-02f, 2.06640568e-02f, -9.68621485e-03f, -2.51920391e-02f, 9.81516838e-02f, -2.01198291e-02f, 1.81380268e-02f, 2.32017543e-02f, 4.28964384e-02f,
  1.19951488e-02f, 3.26972082e-02f, 6.69928594e-03f, -2.01863442e-02f, 2.06052884e-02f, -3.64309400e-02f, -8.13890621e-02f, 6.86801970e-02f, 2.81605478e-02f, -5.01477718e-02f,
  -1.82239804e-02f, 4.47777249e-02f, -5.81168234e-02f, 2.41066702e-02f, 3.13681886e-02f, -4.22142223e-02f, -6.78658262e-02f, -1.13361649e-01f, 2.61986908e-02f, -7.18278661e-02f,
  1.06577933e-01f, -2.59381589e-02f, 3.39506567e-03f, 5.09760566e-02f, 4.81582545e-02f, 1.33549217e-02f, -9.23689529e-02f, 2.86005978e-02f, -2.61147600e-02f, 2.61233691e-02f,
  -1.71793886e-02f, 5.25112730e-04f, -2.26267092e-02f, 3.20215779e-03f, -3.98214199e-02f, -9.02688354e-02f, 1.39336651e-02f, 4.61729988e-02f, 6.09884411e-02f, -7.11694285e-02f,
  2.50885896e-02f, 5.42770699e-02f, 8.20700750e-02f, 9.83546525e-02f, -2.13517481e-03f, -2.22704373e-02f, 1.20485790e-01f, -2.64817253e-02f, 8.72686207e-02f, 1.00466885e-01f,
  -5.80274582e-01f, -2.59446561e-01f, 1.45610776e-02f, -1.31825447e-01f, 1.52331427e-01f, 1.79152042e-01f, 2.75302202e-01f, 1.94533505e-02f, 2.25044340e-02f, 1.55660966e-02f,
  -2.40645129e-02f, -1.09662302e-01f, -1.21982640e-03f, 9.26543772e-03f, -9.10542682e-02f, 5.04807867e-02f, 7.39286169e-02f, -9.88623723e-02f, 1.17382526e-01f, 1.46667123e-01f,
  1.89064831e-01f, -8.77564996e-02f, -2.21272647e-01f, 3.90979573e-02f, -4.66526635e-02f, 5.91437370e-02f, -7.48396218e-02f, -1.18990272e-01f, -2.60885637e-02f, -1.54417127e-01f,
  6.08354732e-02f, -3.14884275e-01f, 1.67624995e-01f, 8.73418525e-03f, 3.04241255e-02f, 2.99943127e-02f, 3.55919227e-02f, -4.69998159e-02f, -8.74530002e-02f, 1.46932676e-02f,
  -3.17551335e-03f, -7.02589750e-02f, -7.02197179e-02f, 7.26572098e-03f, 1.76411923e-02f, 7.21648857e-02f, -7.41315559e-02f, -1.63674697e-01f, -5.59821650e-02f, -7.44325749e-04f,
  1.14808001e-01f, -7.81817436e-02f, -6.45819530e-02f, 5.84931932e-02f, 3.99746038e-02f, -5.46479188e-02f, 6.10824898e-02f, 8.93893689e-02f, 8.44598114e-02f, -1.05195783e-01f,
  6.48582652e-02f, 7.73362350e-03f, 4.36124653e-02f, 1.73994936e-02f, -4.18663397e-02f, 4.77275252e-02f, -6.43433407e-02f, 5.17668724e-02f, 1.54788764e-02f, 5.44613935e-02f,
  -1.85844488e-03f, -2.27440055e-02f, -1.49348360e-02f, -5.27445115e-02f, 5.53305149e-02f, -2.24820375e-02f, -3.95613983e-02f, 3.32653113e-02f, -3.19550633e-02f, -4.41209413e-02f,
  -9.12343711e-02f, 6.80341497e-02f, 3.03394571e-02f, -3.05995047e-02f, 3.35536227e-02f, 3.45218219e-02f, 1.30120171e-02f, -4.28274423e-02f, -3.23054045e-02f, -6.23090193e-02f,
  -2.14470346e-02f, 5.12973331e-02f, -3.83335389e-02f, -1.89222284e-02f, -3.13910618e-02f, -9.37032700e-02f, -3.76044912e-03f, -1.25298649e-02f, -7.60924295e-02f, 4.49121222e-02f,
  7.27259889e-02f, -5.53912036e-02f, -7.92842731e-02f, 4.45340909e-02f, 7.51826838e-02f, 5.63531257e-02f, -1.23773646e-02f, 6.34071380e-02f, 6.04391731e-02f, 3.20110656e-02f,
  -6.50621802e-02f, 2.56838836e-02f, 6.00824617e-02f, -7.96843413e-03f, 4.82869595e-02f, 5.67340255e-02f, 5.15372865e-02f, 1.94320418e-02f, 1.18631497e-01f, 4.75804098e-02f,
  -1.81077018e-01f, -1.07420888e-02f, 6.54083863e-02f, -3.05719040e-02f, 1.32873878e-01f, 1.81227028e-01f, 1.52380154e-01f, -2.37782784e-02f, -4.77903299e-02f, 2.45547965e-02f,
  -5.89760207e-02f, -8.67994130e-02f, 9.68460813e-02f, 1.28440946e-01f, 7.36035332e-02f, 1.11614630e-01f, 2.11301502e-02f, 1.47215262e-01f, 7.01241866e-02f, 3.55280302e-02f,
  4.13117409e-02f, 1.08808190e-01f, 6.27694204e-02f, 3.92203219e-02f, -1.25318408e-01f, 3.24675441e-02f, 5.09223565e-02f, 1.14185631e-01f, -5.13404682e-02f, -1.14121646e-01f,
  -1.86909422e-01f, 8.02334920e-02f, 4.64863144e-02f, -6.86122850e-03f, -5.04181571e-02f, -9.97888893e-02f, -9.85856801e-02f, -1.89339779e-02f, -6.60617799e-02f, 4.74361889e-02f,
  -7.19619989e-02f, -9.34515242e-03f, -2.69522462e-02f, -6.83469251e-02f, -2.71034390e-02f, 4.00495576e-03f, 1.01884216e-01f, 5.46466634e-02f, 1.55467823e-01f, -3.87222990e-02f,
  -8.39760303e-02f, -5.88631369e-02f, 5.51223867e-02f, 5.52165322e-02f, 1.20748386e-01f, -9.49780270e-03f, -2.27476414e-02f, -8.30457732e-02f, 1.23962581e-01f, -7.03867227e-02f,
  1.12712081e-03f, -2.94321757e-02f, -3.72646414e-02f, -3.05342935e-02f, -6.79877326e-02f, -4.77291755e-02f, 1.93356425e-02f, 3.49251963e-02f, -2.01636218e-02f, 3.43546979e-02f,
  5.84912524e-02f, -7.28869904e-03f, 5.31405509e-02f, -8.92563462e-02f, -2.41540116e-03f, -3.76599915e-02f, 3.28206457e-02f, 3.81342024e-02f, -5.22771142e-02f, 2.57078856e-02f,
  -2.98214909e-02f, 7.00068772e-02f, -5.32871410e-02f, -5.29749803e-02f, -8.14195350e-03f, 5.97311296e-02f, -6.92524249e-03f, 7.22969547e-02f, -1.90852247e-02f, 8.13305527e-02f,
  -1.07023068e-01f, 2.61363357e-01f, -1.18860058e-01f, -5.21291234e-03f, 4.31848988e-02f, -2.96147596e-02f, 4.19407561e-02f, -8.72235931e-03f, -1.28914537e-02f, -7.23166466e-02f,
  2.74647074e-03f, 3.04567795e-02f, -3.89734656e-02f, -2.14394238e-02f, 4.24738601e-02f, -2.65111029e-02f, -2.69439835e-02f, -3.54838744e-02f, 5.28380983e-02f, 2.19911449e-02f,
  -1.09437004e-01f, -8.35253894e-02f, -5.42691611e-02f, -1.08519502e-01f, 3.12198736e-02f, -5.60904741e-02f, -3.89449485e-02f, 1.41696185e-02f, 6.43052086e-02f, -1.63329467e-01f,
  -3.75269175e-01f, 5.38490340e-02f, -2.31449857e-01f, -7.76050091e-02f, -1.16430165e-04f, -1.13522172e-01f, -2.45203897e-02f, -1.04782628e-02f, 1.18747093e-02f, 1.25017032e-01f,
  2.01749697e-01f, 2.01718852e-01f, 9.33212712e-02f, 1.03208110e-01f, -8.74872655e-02f, -1.45935968e-01f, -1.52089760e-01f, -2.30867237e-01f, -2.49983221e-01f, -1.56955287e-01f,
  -7.39493668e-02f, 1.16018467e-02f, -1.32847160e-01f, -1.53333455e-01f, 1.13250449e-01f, -6.43221755e-03f, 7.69057795e-02f, -3.08746137e-02f, 2.67689135e-02f, -7.01296628e-02f,
  -3.89442369e-02f, -1.28393874e-01f, -5.29701002e-02f, 1.69095676e-02f, 7.91827291e-02f, -7.98920840e-02f, 9.64605995e-03f, 3.24979350e-02f, 4.71273772e-02f, -6.15078136e-02f,
  -2.72192303e-02f, 8.72110017e-03f, -5.80688007e-02f, 2.72937696e-02f, -5.06640077e-02f, -8.08078572e-02f, -2.61359289e-02f, -8.48374888e-02f, -6.70446083e-02f, 2.68441886e-02f,
  3.82290632e-02f, -5.80841340e-02f, -1.10199355e-01f, 3.39923576e-02f, -3.14128362e-02f, -3.43895070e-02f, 6.16130643e-02f, 1.72774922e-02f, -7.34674977e-03f, -1.21175149e-03f,
  -1.79505162e-02f, -7.42619974e-04f, 3.38734016e-02f, -3.23086157e-02f, 3.84948477e-02f, 5.87041769e-03f, -3.44046229e-03f, -2.29976233e-02f, -1.48032624e-02f, 5.17065898e-02f,
  2.28869356e-02f, -5.28189838e-02f, 5.58642931e-02f, 1.76241007e-02f, -2.71004457e-02f, -1.83272529e-02f, -2.63917353e-02f, 1.53229861e-02f, 2.92998776e-02f, 6.43415675e-02f,
  -1.64406728e-02f, -2.79163625e-02f, -2.47818734e-02f, 2.18825303e-02f, 6.10376559e-02f, -4.33568656e-02f, -5.77939935e-02f, 1.76693536e-02f, 7.89688453e-02f, -4.73923124e-02f,
  2.69207835e-01f, 9.80923511e-03f, -4.44389023e-02f, -5.25758639e-02f, -3.27247148e-03f, 9.39682499e-02f, 1.09458759e-01f, -6.20367341e-02f, 5.42042516e-02f, 1.39621617e-02f,
  -2.31905766e-02f, 3.24402489e-02f, 8.69584754e-02f, 1.16898259e-02f, -9.66577418e-03f, -3.86683717e-02f, 1.14307307e-01f, -1.09385960e-02f, 2.64490433e-02f, 7.24635199e-02f,
  6.65462837e-02f, 1.26426667e-02f, -5.62271774e-02f, -2.93709012e-03f, 9.78804678e-02f, -8.54493380e-02f, 5.47770038e-02f, -5.40312603e-02f, -2.67081745e-02f, 1.56307653e-01f,
  1.02052480e-01f, -4.58367988e-02f, 4.15888727e-02f, 3.12071480e-02f, 3.63002457e-02f, -1.14658430e-01f, -1.92349583e-01f, -2.78094411e-01f, -1.12963676e-01f, -2.05682055e-03f,
  5.19335829e-02f, 1.51983231e-01f, 2.28856523e-02f, 6.92913607e-02f, -1.38802946e-01f, -2.45734416e-02f, -1.05522364e-01f, 1.81878619e-02f, 4.12578508e-02f, -2.29686536e-02f,
  -4.28780206e-02f, 1.68452114e-01f, 1.77255899e-01f, 1.00464210e-01f, -2.33390294e-02f, 1.09831668e-01f, 9.13775116e-02f, 3.90404128e-02f, 1.16622314e-01f, 1.48221508e-01f,
  1.85138047e-01f, 1.70256365e-02f, -8.52307603e-02f, 6.72458485e-02f, 5.48109412e-02f, -5.70308566e-02f, 6.87666843e-03f, 4.96182702e-02f, 9.44022611e-02f, -5.39269969e-02f,
  1.88784990e-02f, -3.04306690e-02f, 7.86820278e-02f, -2.98922528e-02f, 7.94185996e-02f, 3.82292159e-02f, -6.80355504e-02f, -8.26454163e-02f, -6.70398176e-02f, -1.80836618e-02f,
  1.22595064e-01f, 1.83524549e-01f, -8.75896960e-03f, -5.10612577e-02f, -7.83242285e-02f, 9.82599184e-02f, 5.39770443e-03f, -2.32939590e-02f, -2.29583797e-03f, 1.73136611e-02f,
  -1.20684793e-02f, -2.96966136e-02f, 8.45381021e-02f, 3.41871642e-02f, -8.53254721e-02f, -4.18771282e-02f, -6.02280982e-02f, 1.06160976e-01f, -3.67920287e-02f, 4.19766828e-02f,
  3.68316919e-02f, -3.56387673e-03f, -6.15963712e-02f, 3.62229906e-02f, 1.93441082e-02f, -1.99004207e-02f, -2.05460228e-02f, -1.39275528e-02f, 4.34802985e-03f, -6.79573417e-02f,
  -2.27296371e-02f, -2.73511149e-02f, 5.37235327e-02f, -1.35214534e-02f, -9.19126868e-02f, -4.52254117e-02f, 5.59162050e-02f, -8.00014362e-02f, 7.12241009e-02f, 8.05448368e-03f,
  7.79920444e-02f, 1.80691518e-02f, -2.47777179e-02f, -7.64774829e-02f, 9.53217372e-02f, 3.74616981e-02f, 1.23679660e-01f, -4.13047969e-02f, 7.59599209e-02f, -4.82781045e-02f,
  6.22732639e-02f, 9.52765122e-02f, -2.92152795e-03f, 3.14981975e-02f, -3.38877775e-02f, -8.35732222e-02f, 5.94308646e-03f, 6.67976066e-02f, -1.01016283e-01f, -3.71963531e-02f,
  -1.07064769e-01f, -1.34390732e-03f, -6.67164922e-02f, -1.23712346e-01f, -5.36952987e-02f, -1.31734656e-02f, -6.41230047e-02f, -1.06172964e-01f, -2.24042796e-02f, -1.10885866e-01f,
  3.20546031e-01f, 9.49167535e-02f, 2.87755162e-01f, 1.76684350e-01f, 1.22078680e-01f, 1.92186818e-01f, 1.70977220e-01f, 1.45523027e-01f, 1.41368315e-01f, 1.43922344e-01f,
  -6.29445985e-02f, -1.19095728e-01f, 5.48421480e-02f, -3.12203146e-03f, 3.34762782e-02f, 3.04692179e-01f, 2.72160172e-01f, 1.91893876e-01f, 1.10847652e-01f, 1.85574070e-01f,
  7.89936781e-02f, 1.35718629e-01f, 3.68383080e-02f, 1.31169811e-01f, 1.39756709e-01f, 1.40596315e-01f, 7.36099631e-02f, 1.69665173e-01f, 1.36562422e-01f, 2.26679325e-01f,
  2.36354306e-01f, 1.56925738e-01f, 3.23473439e-02f, -9.49398577e-02f, -4.05276567e-02f, 5.14785610e-02f, 6.76926747e-02f, -4.41025607e-02f, -7.22051486e-02f, -2.60770824e-02f,
  -4.92466092e-02f, -2.27420311e-02f, -6.54614121e-02f, -4.41199765e-02f, 1.10311352e-01f, 1.06661223e-01f, -4.82236631e-02f, 8.53020027e-02f, -5.83286211e-02f, 5.82452267e-02f,
  -9.46395099e-02f, -3.39750685e-02f, 8.27035606e-02f, -7.95662478e-02f, 7.04167858e-02f, -8.75883549e-02f, -6.60435334e-02f, -5.83369881e-02f, 1.60458423e-02f, 1.20037258e-01f,
  5.17416149e-02f, 5.08850664e-02f, 8.00624937e-02f, -3.79677862e-02f, 3.26303355e-02f, -6.34133369e-02f, 1.02004418e-02f, 4.52687182e-02f, -5.56442030e-02f, 3.13522667e-02f,
  -6.69645071e-02f, 6.31854450e-03f, -3.71680669e-02f, 8.36762562e-02f, 5.91221191e-02f, 3.25085968e-02f, -8.13031644e-02f, 5.34801036e-02f, -4.95264828e-02f, -3.01603656e-02f,
  3.04662529e-02f, 1.73376519e-02f, -4.87840399e-02f, 1.05019538e-02f, 9.21011996e-03f, -2.97875553e-02f, 3.52192819e-02f, -7.04009831e-02f, -8.14347491e-02f, -2.36189663e-02f,
  -8.82795155e-02f, -1.04234733e-01f, -3.07189976e-03f, 4.25447896e-02f, 5.42572103e-02f, -5.55785112e-02f, -2.88787913e-02f, -8.93627405e-02f, -7.88124129e-02f, -3.74620706e-02f,
  -3.13150398e-02f, -2.55437233e-02f, 5.34553677e-02f, -2.11488642e-03f, -6.04322441e-02f, 1.26476446e-02f, -5.13385236e-02f, -5.22219501e-02f, -5.15636988e-02f, -6.07185625e-02f,
  -1.52213611e-02f, 5.52844852e-02f, -1.41174465e-01f, 3.06110759e-03f, -2.10112464e-02f, 4.38317433e-02f, 4.22573686e-02f, -5.83091453e-02f, 3.58464830e-02f, -1.89951677e-02f,
  -4.78636682e-01f, -3.19775641e-01f, 1.24180898e-01f, -3.46327037e-01f, -4.26038466e-02f, 1.33086637e-01f, -1.32461831e-01f, 3.98150878e-03f, -1.82462975e-01f, -1.85990363e-01f,
  2.03113649e-02f, 1.26996323e-01f, 7.94990584e-02f, 1.05891582e-02f, 1.05562560e-01f, -1.95284095e-02f, -7.12325722e-02f, 6.73726723e-02f, 1.63371399e-01f, -8.30498431e-03f,
  -1.02680109e-01f, -1.42811984e-01f, -6.18098583e-03f, -1.17671438e-01f, -1.36433035e-01f, -3.93400863e-02f, -7.33115822e-02f, -9.29842070e-02f, 1.00463212e-01f, -2.60461956e-01f,
  1.06733471e-01f, -1.06378607e-01f, 6.65246025e-02f, 5.48559390e-02f, 6.30788580e-02f, 1.42389042e-02f, -4.28582393e-02f, -4.41737548e-02f, -6.09319508e-02f, -9.53480136e-03f,
  -2.89530326e-02f, 7.31832162e-02f, 4.14263643e-02f, -7.45438784e-02f, -1.20484114e-01f, -4.60189171e-02f, -3.60544361e-02f, -3.05010807e-02f, 1.04656041e-01f, 4.88327183e-02f,
  1.35063734e-02f, 5.41793220e-02f, 2.18170676e-02f, 8.43109414e-02f, 7.79391378e-02f, 8.89173448e-02f, 1.00622416e-01f, -6.44844770e-02f, 1.41423792e-01f, -2.29363695e-01f,
  -4.43361811e-02f, 2.11012643e-02f, 4.32923920e-02f, -1.13872468e-01f, 2.63664257e-02f, -3.81530263e-02f, 1.92461945e-02f, -4.10931110e-02f, 2.20722798e-02f, 2.04885215e-03f,
  -2.75153313e-02f, 2.58087758e-02f, -4.98275571e-02f, -7.46131688e-02f, 5.40015250e-02f, 4.87986058e-02f, 1.98200322e-03f, -4.89150919e-02f, 3.23694050e-02f, 3.67775895e-02f,
  2.54316647e-02f, 3.91575806e-02f, -1.76083315e-02f, 2.76255962e-02f, 1.83174610e-02f, -2.19891430e-03f, -5.17413020e-02f, 3.78453732e-02f, 8.01129267e-02f, -6.23774566e-02f,
  -6.27619401e-02f, 3.65244508e-01f, -1.36341289e-01f, -8.73840600e-02f, -1.11261765e-02f, 1.96795519e-02f, 8.00032634e-04f, 4.19630036e-02f, 4.45090346e-02f, -3.92650478e-02f,
  -3.71654378e-03f, -7.41660893e-02f, 2.40682755e-02f, 7.14692706e-03f, 4.63400856e-02f, 9.58858132e-02f, -2.81072110e-02f, -4.87685502e-02f, -2.97217946e-02f, -7.77402967e-02f,
  -8.09637159e-02f, -5.05750440e-03f, -2.57111099e-02f, -3.89211508e-03f, -2.74755172e-02f, 9.50831324e-02f, 2.09970549e-02f, 6.76789284e-02f, 1.27054796e-01f, -1.42411143e-01f,
  -8.35994557e-02f, -4.12093073e-01f, 8.21722597e-02f, -9.00310948e-02f, -1.95111096e-01f, 1.54752086e-03f, -2.32013926e-01f, -1.43878281e-01f, -7.77376220e-02f, -2.66127795e-01f,
  -9.11341533e-02f, 1.15847059e-01f, 1.05206087e-01f, 2.49430358e-01f, 1.75330505e-01f, -3.57108004e-03f, 1.99235920e-02f, 2.39601061e-01f, 3.31272513e-01f, 1.94901437e-01f,
  -8.37451518e-02f, -4.50843796e-02f, 1.10865496e-01f, 4.56028730e-02f, -1.83456704e-01f, 1.51611464e-02f, -8.65834132e-02f, -8.55992436e-02f, -2.14035790e-02f, -2.89875418e-02f,
  1.48278236e-01f, -1.08654328e-01f, 2.06864551e-01f, -4.38084081e-02f, -6.42757192e-02f, 6.39379099e-02f, -3.34832668e-02f, -2.66460944e-02f, 8.66501778e-03f, -6.64570183e-02f,
  2.34017838e-02f, 4.96731400e-02f, 8.67254511e-02f, -5.71370684e-02f, -6.85437694e-02f, 5.81987835e-02f, -3.86858992e-02f, 1.28213465e-01f, 6.67529106e-02f, 2.40386766e-03f,
  -4.42229621e-02f, -9.27372873e-02f, 1.52500840e-02f, 8.62374157e-03f, 1.16727978e-01f, 1.32187724e-01f, -3.03448439e-02f, 8.94628465e-02f, 2.15734579e-02f, -1.55665427e-01f,
  4.41444293e-02f, 3.09204236e-02f, 7.56177157e-02f, 1.87889449e-02f, -3.95967588e-02f, -3.86431534e-03f, 1.61902197e-02f, 3.04738153e-02f, -4.16335184e-03f, 5.99480607e-03f,
  2.40802318e-02f, -2.28137169e-02f, 5.27488366e-02f, -2.21485049e-02f, 1.09091355e-03f, -4.78589125e-02f, 4.88326326e-02f, -1.64875053e-02f, 4.86590266e-02f, -3.43031473e-02f,
  3.54998037e-02f, 3.82426344e-02f, -6.61867708e-02f, 3.88535336e-02f, -2.16811709e-02f, -4.63877209e-02f, -4.06331662e-03f, 4.94955387e-03f, -2.62314454e-02f, -4.66696061e-02f,
  -4.80771102e-02f, 1.46522939e-01f, 1.11355609e-03f, 3.80084962e-02f, -5.90756461e-02f, -4.59653921e-02f, -1.53355720e-02f, -2.91217025e-02f, 5.69919916e-03f, 2.85528954e-02f,
  6.13354370e-02f, -4.35882322e-02f, -1.04850344e-01f, 4.80728596e-02f, 4.45187874e-02f, 5.24813458e-02f, -1.21724106e-01f, -4.80070856e-04f, -2.90640350e-02f, -4.88119274e-02f,
  -1.17716469e-01f, -5.71508631e-02f, 2.68555041e-02f, 6.42378768e-03f, 7.02536181e-02f, 8.09284821e-02f, 2.55823322e-02f, 1.11257741e-02f, 7.39245340e-02f, -1.74917847e-01f,
  4.20517713e-01f, 5.68823442e-02f, -1.19775231e-03f, 3.26310135e-02f, -2.70006601e-02f, -1.27330005e-01f, -1.49636373e-01f, 6.50965422e-02f, 3.85329537e-02f, 4.17439975e-02f,
  2.45355573e-02f, 1.19061016e-01f, 4.57527861e-02f, 3.50484736e-02f, 5.32842875e-02f, 4.74130362e-02f, 5.21088280e-02f, 1.69958025e-01f, -1.48818325e-02f, -8.64201859e-02f,
  1.32103013e-02f, -3.38052399e-02f, 7.79549107e-02f, 7.64786154e-02f, -1.13429159e-01f, 2.60274373e-02f, -5.57798855e-02f, -7.88169503e-02f, -6.85717985e-02f, -2.94488817e-02f,
  1.66130085e-02f, 1.27127573e-01f, -6.51751310e-02f, 6.79463819e-02f, -4.04662453e-02f, 2.56708357e-02f, 4.00082804e-02f, -5.90049364e-02f, -4.05484252e-03f, 8.22763890e-02f,
  2.98772436e-02f, 8.31679031e-02f, -5.75070689e-03f, 2.88006049e-02f, -9.42222252e-02f, 9.62621905e-03f, 1.04530323e-02f, 2.74601765e-02f, -4.50071730e-02f, 2.75601037e-02f,
  -1.71025153e-02f, -1.11209922e-01f, 1.64954066e-02f, 2.66226884e-02f, 2.21483056e-02f, 2.98817474e-02f, -1.21282943e-01f, 8.55867285e-03f, -5.35141230e-02f, -8.06199685e-02f,
  1.90910827e-02f, 1.26976026e-02f, 4.72500622e-02f, -5.46987988e-02f, -4.89320718e-02f, 5.22016473e-02f, -1.76323708e-02f, -5.99118099e-02f, 6.69636056e-02f, -2.12304275e-02f,
  5.89201897e-02f, -1.70275308e-02f, -2.14748364e-02f, -4.04957421e-02f, 2.69303489e-02f, -6.13924153e-02f, 6.65087253e-02f, -3.01937275e-02f, -4.84635569e-02f, 5.72767816e-02f,
  2.28154985e-03f, -4.81582023e-02f, 7.12148333e-03f, -1.31734433e-02f, 6.36104960e-03f, 3.56566124e-02f, 1.65043790e-02f, -7.78822601e-02f, 3.79253514e-02f, -2.74797063e-03f,
  -3.57697010e-02f, -2.54562125e-02f, 9.36635360e-02f, 1.25596849e-02f, -9.88962501e-02f, 3.74927260e-02f, 7.67999068e-02f, 5.33362776e-02f, 5.32698147e-02f, -4.93423417e-02f,
  -1.38368905e-02f, 6.58177733e-02f, -3.06232441e-02f, -8.17156807e-02f, 4.61080484e-02f, 6.48484891e-03f, 1.64419748e-02f, 3.87323126e-02f, -2.65273973e-02f, -7.34625086e-02f,
  -8.45601931e-02f, 8.41351300e-02f, 1.62122190e-01f, 8.37148353e-03f, 2.17928775e-02f, 1.55344918e-01f, -2.37825718e-02f, 3.57511528e-02f, 5.44842705e-02f, 2.24988032e-02f,
  1.82305537e-02f, 8.36532712e-02f, -3.91246304e-02f, 1.26795605e-01f, -1.67943701e-01f, -2.12138444e-01f, -1.74350426e-01f, 5.85156232e-02f, 8.34984258e-02f, -2.78098043e-02f,
  8.78026616e-03f, 1.36565834e-01f, 8.20618346e-02f, 1.45958498e-01f, 4.96961363e-02f, 1.37518167e-01f, 1.00512542e-01f, 8.78937840e-02f, 3.56840044e-02f, -1.57093421e-01f,
  6.02749772e-02f, -5.94809614e-02f, -3.01736370e-02f, 8.76596794e-02f, 3.72751169e-02f, 1.47689447e-01f, -1.42527297e-02f, 7.05544129e-02f, 3.26339975e-02f, 8.98029432e-02f,
  5.70478328e-02f, -6.85894862e-02f, -1.73283294e-02f, -3.52100804e-02f, -1.15340084e-01f, 1.00132592e-01f, -3.50424908e-02f, -4.82339486e-02f, -8.35365653e-02f, -6.80556893e-03f,
  -3.48700806e-02f, 1.71588399e-02f, -3.73313129e-02f, -1.98444743e-02f, 3.21763717e-02f, -7.04079643e-02f, 6.00320958e-02f, -4.07664618e-03f, 1.35997787e-01f, 1.67463515e-02f,
  4.97997552e-03f, -3.09379976e-02f, -4.53036204e-02f, 2.29698978e-02f, 2.35066693e-02f, -1.93553120e-02f, -4.97191772e-02f, 8.78465027e-02f, -1.58299115e-02f, 3.06701977e-02f,
  8.51471424e-02f, -2.03096271e-02f, -1.51742259e-02f, 3.34908962e-02f, 1.70560554e-02f, 6.41040951e-02f, -2.06045844e-02f, -6.90296963e-02f, 1.46134198e-02f, 6.75170720e-02f,
  2.15181448e-02f, -3.02711339e-03f, 3.66159417e-02f, -3.38855386e-03f, -1.84461493e-02f, 8.26491639e-02f, 4.99432720e-02f, 2.68935040e-02f, -4.47001606e-02f, 1.46303196e-02f,
  1.23596173e-02f, 3.17899473e-02f, -5.98856322e-02f, 7.25515708e-02f, 1.11415507e-02f, 9.34177339e-02f, 6.91149905e-02f, -4.92588989e-02f, 5.88298216e-02f, -7.66255260e-02f,
  -8.09517726e-02f, -1.56719059e-01f, 1.22049190e-01f, -9.49742179e-03f, -8.32700059e-02f, -2.19590813e-02f, 6.25728741e-02f, 6.47726581e-02f, 3.12448982e-02f, -3.06755323e-02f,
  -8.25415328e-02f, -6.99397251e-02f, 6.17202185e-02f, -6.60766140e-02f, -2.20074318e-02f, -3.14478837e-02f, 3.92173193e-02f, 7.93446898e-02f, -4.11428735e-02f, -4.02169377e-02f,
  -5.56462556e-02f, -1.34993583e-01f, -6.75083091e-03f, -6.35949373e-02f, -5.08808643e-02f, -1.89206209e-02f, -1.19908646e-01f, -8.62460956e-02f, -6.26104698e-02f, -4.47758660e-02f,
  -1.67924315e-01f, -9.00352597e-02f, -7.42751658e-02f, -1.02704369e-01f, 2.23799683e-02f, -1.42728239e-01f, -2.16173947e-01f, -2.28017062e-01f, -5.83399870e-02f, -1.14951342e-01f,
  1.21972129e-01f, 1.09002814e-01f, 3.92878279e-02f, 1.12015702e-01f, -1.14121147e-01f, -8.97235051e-02f, -6.30516112e-02f, -3.55921090e-02f, 6.13573492e-02f, 4.96108457e-02f,
  1.33859515e-01f, 6.10777996e-02f, 6.82153329e-02f, 6.61291480e-02f, 1.01721562e-01f, 1.02876171e-01f, -4.24837172e-02f, 7.41777197e-02f, 1.00146525e-01f, 1.30318329e-01f,
  5.46827577e-02f, -6.40695691e-02f, -1.40348950e-03f, 9.94308889e-02f, 1.47373319e-01f, -1.00289226e-01f, 5.83639182e-03f, 1.69527177e-02f, 5.42889051e-02f, 2.50378400e-02f,
  1.35341957e-01f, 9.21488777e-02f, 3.14980783e-02f, -1.86960446e-03f, -8.85837898e-02f, -2.76233591e-02f, 2.14178185e-03f, -4.84973975e-02f, 1.02984523e-02f, -4.50351611e-02f,
  1.08477682e-01f, 2.52526645e-02f, -7.48810768e-02f, -1.36162668e-01f, 5.77081032e-02f, 8.88922140e-02f, -5.04372567e-02f, 3.68089527e-02f, -1.08435571e-01f, -9.19466168e-02f,
  2.65503954e-02f, 7.48560131e-02f, 8.45796149e-03f, 4.55585718e-02f, -3.76765430e-02f, -5.22942133e-02f, -1.93364918e-02f, -1.11357272e-02f, -7.33515173e-02f, 3.33565660e-02f,
  1.38346087e-02f, 1.15202041e-02f, -1.67231951e-02f, -1.05739310e-01f, 6.95261136e-02f, 5.96542358e-02f, 7.02955797e-02f, 3.01023945e-02f, -1.02024302e-02f, 2.51732469e-02f,
  -2.05219752e-04f, -5.49382009e-02f, 5.46319298e-02f, 4.29101810e-02f, 2.93651577e-02f, -4.10555117e-02f, 3.77034321e-02f, 4.97058034e-02f, -8.75149295e-02f, -2.60009002e-02f,
  -2.07557883e-02f, 9.12414566e-02f, 2.66265087e-02f, 6.82282597e-02f, -7.07043856e-02f, 4.51012030e-02f, -2.72122808e-02f, 1.65523514e-02f, 8.90849754e-02f, 1.62556078e-02f,
  6.78731827e-03f, -2.44629383e-02f, 1.17571028e-02f, -8.03726315e-02f, -6.83837906e-02f, -6.39706999e-02f, -3.38419676e-02f, -4.18756939e-02f, -1.35019859e-02f, 5.33225127e-02f,
  -1.45372730e-02f, -1.15863971e-01f, -1.55189440e-01f, -1.56199068e-01f, 4.21339497e-02f, 2.95304637e-02f, -1.16278529e-01f, -6.39879610e-03f, -1.93968102e-01f, -2.66183913e-01f,
  2.18099192e-01f, 1.09258287e-01f, -5.01427762e-02f, -3.54261473e-02f, 9.40391608e-03f, -8.94213989e-02f, -1.63654879e-01f, -7.38287903e-03f, -2.68228874e-02f, 4.99144047e-02f,
  4.03792672e-02f, -3.09266541e-02f, 1.49833383e-02f, -1.22319140e-01f, -9.75107178e-02f, -2.12912336e-02f, -1.49500296e-01f, -1.63526654e-01f, -1.65271059e-01f, -7.05504641e-02f,
  -4.40935930e-03f, -1.11989208e-01f, -5.12420461e-02f, 7.05754897e-03f, 2.22516693e-02f, -6.85144588e-02f, 8.64965171e-02f, 6.81986064e-02f, 1.05373099e-01f, 1.27919421e-01f,
  1.27830952e-01f, 2.10008636e-01f, -9.59019363e-02f, -2.22285073e-02f, 1.06902309e-01f, 1.21972952e-02f, -9.02432501e-02f, 5.21234386e-02f, -6.67738030e-03f, 7.15936273e-02f,
  1.02429606e-01f, 2.38653086e-02f, -5.61264157e-02f, -5.91076575e-02f, -1.54081387e-02f, -5.72438426e-02f, 1.44108851e-02f, 2.60396749e-02f, 2.08925139e-02f, 1.31516576e-01f,
  8.17256570e-02f, 1.11234188e-01f, 3.71530210e-03f, 1.58400182e-02f, 9.38966051e-02f, -2.25958452e-02f, 4.24043983e-02f, 8.85770544e-02f, 8.21442455e-02f, -2.85111982e-02f,
  6.70249090e-02f, 3.95033089e-03f, -3.84353250e-02f, 5.68640269e-02f, 3.22480910e-02f, -2.21997686e-02f, -6.17628135e-02f, -5.20296395e-02f, -1.19611789e-02f, 4.70669456e-02f,
  -5.09564281e-02f, 1.73109211e-02f, -4.07846868e-02f, 4.32668552e-02f, 1.06713432e-03f, 5.69352843e-02f, -7.63579533e-02f, -3.18280421e-02f, -6.59042969e-02f, 5.35646603e-02f,
  -1.35585628e-02f, 1.43116182e-02f, 2.25756783e-02f, -6.90480098e-02f, 3.87553610e-02f, 2.24833284e-02f, 3.89960967e-02f, 4.64281859e-03f, 1.55518660e-02f, 7.67898411e-02f,
  -1.71913549e-01f, -4.47337963e-02f, 1.18082315e-02f, -8.38458389e-02f, 6.96456358e-02f, 1.33893471e-02f, 6.85016215e-02f, 2.34886892e-02f, -2.64618378e-02f, -1.75619945e-02f,
  -6.59734234e-02f, -3.82001922e-02f, -6.07967116e-02f, -5.10092564e-02f, -1.26372933e-01f, -3.39580961e-02f, 4.22846787e-02f, -7.18611255e-02f, -2.51990557e-02f, 6.86362833e-02f,
  4.77250926e-02f, -9.29800719e-02f, -6.44290671e-02f, -1.28537491e-01f, -2.62128972e-02f, -5.64930327e-02f, -1.37301579e-01f, -3.74986269e-02f, -8.77706856e-02f, 3.57922888e-03f,
  -1.08945593e-01f, 3.51216167e-01f, 1.37644738e-01f, -1.72759876e-01f, -1.56014189e-01f, -8.37580487e-02f, 3.75712924e-02f, -1.49047479e-01f, -3.48070338e-02f, 8.55812654e-02f,
  1.17211528e-01f, -1.27061154e-03f, 5.61643578e-02f, 5.91993593e-02f, 2.12763324e-02f, 1.12221308e-01f, 4.46541458e-02f, 2.62374599e-02f, -9.85550955e-02f, -9.32413042e-02f,
  -3.88386250e-02f, -1.21645436e-01f, -1.44790411e-01f, -1.45873323e-01f, 6.39339611e-02f, 3.65340970e-02f, 7.57753626e-02f, -7.58001627e-03f, 6.88867271e-02f, 1.59235716e-01f,
  4.62492347e-01f, 1.23116225e-01f, -1.91640466e-01f, -6.46425784e-02f, 1.16613507e-03f, 8.07091966e-02f, 3.18695605e-02f, -5.81029207e-02f, -2.21676137e-02f, 9.46146846e-02f,
  6.01469167e-02f, 7.28801042e-02f, 3.42701115e-02f, -2.68954635e-02f, 2.12354828e-02f, 4.47227694e-02f, 1.40564786e-02f, -4.09406163e-02f, -7.84338340e-02f, 4.49032672e-02f,
  -4.67485636e-02f, 7.41609707e-02f, 3.57384072e-03f, -3.09099387e-02f, -1.84323918e-02f, -5.68285324e-02f, 6.85983747e-02f, 5.70896603e-02f, 5.98747283e-03f, -4.94127115e-03f,
  -7.44684637e-02f, 6.52918871e-03f, 2.47485600e-02f, 5.84730022e-02f, -6.56139180e-02f, -4.16459963e-02f, 4.89143357e-02f, 6.23023324e-02f, 3.08359526e-02f, -2.27685999e-02f,
  3.74955013e-02f, -4.14066948e-02f, -4.80761379e-02f, -4.21804413e-02f, 4.72453237e-02f, 1.46982716e-02f, 2.43468154e-02f, 4.91698906e-02f, 5.25663234e-02f, -6.70439377e-02f,
  3.89137375e-03f, -4.16638143e-02f, 2.78791897e-02f, -3.11307628e-02f, 2.50723679e-02f, 1.29074240e-02f, -3.69123183e-03f, -1.88341625e-02f, 9.24743712e-03f, -3.59319709e-02f,
  3.69034708e-02f, -2.01166540e-01f, 1.18419014e-01f, 1.33855203e-02f, -4.15660162e-03f, 3.91457987e-04f, 6.19179830e-02f, -2.16576755e-02f, -4.99135535e-03f, 3.95787694e-02f,
  8.30377080e-03f, -4.54878323e-02f, 6.88133761e-02f, 2.69344263e-02f, -3.77166532e-02f, -8.48462284e-02f, -6.93888217e-02f, 6.02481514e-02f, 1.25285443e-02f, 8.00399855e-02f,
  -7.05021322e-02f, -4.11549583e-02f, 4.26877514e-02f, -3.54564674e-02f, 5.43307029e-02f, -8.97500888e-02f, 1.06505886e-01f, 4.97678062e-03f, 4.10288908e-02f, -5.38341478e-02f,
  -1.91305250e-01f, 7.54771903e-02f, -5.19155823e-02f, -1.17144771e-01f, 2.03310907e-01f, 3.04300219e-01f, 4.52941775e-01f, 1.54038310e-01f, -8.01906213e-02f, 5.27520441e-02f,
  -4.38846694e-03f, -6.46067187e-02f, -1.39235780e-01f, -9.30791870e-02f, 1.46384329e-01f, 1.68206632e-01f, -2.06522569e-02f, 4.60629053e-02f, 6.00106381e-02f, 2.41004780e-01f,
  8.41314197e-02f, 1.09309971e-01f, 4.44076881e-02f, -9.93630476e-03f, -4.76342738e-02f, -2.92146392e-03f, -1.07073881e-01f, -1.20778657e-01f, 4.39241417e-02f, -4.04552445e-02f,
  -1.67804137e-01f, -2.96846144e-02f, -3.85194793e-02f, -1.11371987e-01f, -1.99443735e-02f, -8.47166851e-02f, 8.35488066e-02f, -7.94502720e-02f, -3.24823856e-02f, -1.49227688e-02f,
  -4.56356108e-02f, 9.95388441e-03f, 1.06475195e-02f, -8.04792494e-02f, 9.83351991e-02f, 8.17028657e-02f, 2.08018348e-02f, 1.29652740e-02f, -5.34010269e-02f, -5.59321186e-03f,
  8.12244937e-02f, 1.35005489e-01f, 3.96204181e-03f, 4.99424757e-03f, -9.62213054e-03f, -7.20350966e-02f, 1.07080869e-01f, 3.76140811e-02f, 1.60368495e-02f, -1.10814810e-01f,
  5.01902029e-02f, -2.29485575e-02f, -3.57446373e-02f, 1.47670899e-02f, 7.30427504e-02f, 3.16661336e-02f, -8.30851495e-02f, 8.18958506e-02f, -2.77540255e-02f, 3.05254404e-02f,
  2.09100619e-02f, -4.05768119e-03f, 2.43167002e-02f, -6.82439432e-02f, 7.57932151e-03f, 4.05203775e-02f, -5.23283258e-02f, -1.19044511e-02f, -9.25318711e-03f, 8.21091235e-03f,
  7.98818003e-03f, 7.69658247e-03f, -8.31195265e-02f, 3.43590602e-02f, 4.10116129e-02f, -1.32375024e-02f, 1.95701327e-02f, -1.30122509e-02f, 1.51087279e-02f, 2.08257455e-02f,
  -1.12968527e-01f, 1.32477313e-01f, -4.74054925e-02f, -4.04343680e-02f, -4.76317108e-02f, 1.90044064e-02f, -1.00979105e-01f, -6.79384619e-02f, -1.71196554e-02f, 1.42237805e-02f,
  8.74665305e-02f, -1.91736035e-02f, 3.36333066e-02f, 6.11383952e-02f, 2.64442712e-02f, -1.59414448e-02f, 8.99243802e-02f, -2.49462314e-02f, 8.09568316e-02f, -2.68059615e-02f,
  9.40181874e-03f, 3.79954502e-02f, 5.68563901e-02f, -9.80992522e-03f, -4.53530587e-02f, -4.19923738e-02f, 5.34760579e-03f, 1.10468268e-02f, -5.93084469e-02f, -2.49767229e-02f,
  1.25962928e-01f, 7.64812753e-02f, 1.52153328e-01f, -8.61088396e-04f, -8.47431868e-02f, -1.74646884e-01f, -3.49854529e-02f, -9.17456746e-02f, -1.50731131e-02f, 4.33908515e-02f,
  1.87263280e-01f, 3.73636931e-02f, 6.30022287e-02f, -4.76580858e-02f, 1.94728114e-02f, -1.12575643e-01f, -1.79765493e-01f, -1.15378276e-01f, -6.09119236e-02f, -1.43075123e-01f,
  -6.09017573e-02f, -9.37509984e-02f, 9.55744609e-02f, -4.60174046e-02f, 8.50736871e-02f, 6.87896507e-03f, 2.99150832e-02f, -4.89688963e-02f, -7.00189620e-02f, -8.06023106e-02f,
  2.42809087e-01f, 2.27292746e-01f, -7.65345097e-02f, -5.58595359e-02f, 8.31688568e-02f, 5.48108891e-02f, 7.53929615e-02f, -8.83393572e-04f, 6.78104609e-02f, 3.67842317e-02f,
  1.00939326e-01f, -2.22484451e-02f, -2.84026694e-02f, 2.81699207e-02f, 8.48782137e-02f, 8.95991474e-02f, -4.59956750e-02f, -3.41174304e-02f, 8.46389383e-02f, 1.89895108e-02f,
  -4.08697762e-02f, -7.31234774e-02f, 1.93708111e-02f, -3.78114358e-02f, 3.09031699e-02f, 4.74529900e-02f, 6.27213940e-02f, -2.34953649e-02f, -3.23793553e-02f, 2.04992276e-02f,
  -8.72472525e-02f, -9.63390863e-04f, -2.03114282e-02f, -4.18738090e-02f, 3.81081812e-02f, -2.06586048e-02f, -5.16393967e-02f, -2.24687792e-02f, 2.99291569e-03f, 4.62971628e-02f,
  7.32392818e-02f, -3.80095467e-02f, -9.80331469e-03f, -7.05595613e-02f, 4.02012691e-02f, -8.22920259e-03f, 4.02883850e-02f, -2.51987558e-02f, -4.23517227e-02f, -3.12438961e-02f,
  6.49971366e-02f, 2.24786699e-02f, 3.81696858e-02f, 3.78182754e-02f, -9.89212990e-02f, 6.13179915e-02f, -3.18253115e-02f, 9.04839262e-02f, 5.21535203e-02f, -2.61870380e-02f,
  1.70466557e-01f, -7.34390877e-03f, -3.95406112e-02f, 6.91648349e-02f, -2.24519465e-02f, -1.37452716e-02f, 2.55117961e-03f, 7.43708238e-02f, 7.75921643e-02f, 1.32745816e-04f,
  1.28514677e-01f, -4.77306806e-02f, 1.19496331e-01f, -6.36114627e-02f, -1.09459206e-01f, -9.75381434e-02f, 2.57406738e-02f, -6.18664883e-02f, -4.37513888e-02f, 3.97899486e-02f,
  -6.47149757e-02f, -1.45245761e-01f, -5.04147969e-02f, 4.86364178e-02f, 2.08523478e-02f, -9.79703814e-02f, 8.25347658e-03f, -3.10202781e-02f, -2.76017413e-02f, -8.48720670e-02f,
  -3.07676867e-02f, 9.63340700e-02f, -1.68006569e-02f, -2.44679496e-01f, -1.56192435e-02f, 1.29950434e-01f, 2.53059357e-01f, 6.75862059e-02f, -1.58556655e-01f, 2.82885768e-02f,
  6.72669485e-02f, -1.15434468e-01f, -5.16663231e-02f, -9.52936709e-03f, -1.08757047e-02f, 3.89949679e-02f, 1.97016355e-02f, 5.15347011e-02f, -3.63862850e-02f, 1.04662506e-02f,
  7.09794089e-02f, -1.61765829e-01f, -3.18525545e-02f, -3.49954283e-03f, -1.56131864e-01f, -1.22163542e-01f, -3.47052538e-03f, 1.65679343e-02f, 1.50440261e-01f, 4.27047573e-02f,
  1.35524794e-01f, 6.21123426e-02f, -1.16407543e-01f, -7.55499164e-03f, -6.56696185e-02f, 4.12179567e-02f, -6.19563535e-02f, -1.08633995e-01f, -4.76862937e-02f, -1.86952145e-03f,
  -2.76239123e-02f, 6.02109805e-02f, 1.90437716e-02f, -2.20635403e-02f, 2.60160044e-02f, -3.82593051e-02f, -2.54429120e-04f, 5.17947450e-02f, 1.39803747e-02f, 9.22253579e-02f,
  8.03064704e-02f, 1.18700378e-01f, 2.73684226e-02f, 9.05579552e-02f, 1.03904478e-01f, -1.02047242e-01f, 4.52091880e-02f, 5.82091287e-02f, 1.28138382e-02f, -2.56978348e-02f,
  4.42295596e-02f, -3.68197262e-03f, 5.75729348e-02f, 4.51879110e-03f, -6.26549497e-02f, -6.21992946e-02f, -8.48677084e-02f, 4.69377041e-02f, -5.74219748e-02f, -7.08788261e-02f,
  6.75730482e-02f, 5.30937053e-02f, 4.11624424e-02f, -1.81723163e-02f, 2.29714606e-02f, 2.44298577e-02f, 8.69378150e-02f, 4.64352667e-02f, -3.54935555e-03f, 6.20957725e-02f,
  -4.92091887e-02f, 4.67687808e-02f, -8.56322199e-02f, -6.79505616e-02f, 7.66636208e-02f, 5.56944981e-02f, -5.52446842e-02f, -2.06614006e-02f, -1.75173488e-02f, 6.26894236e-02f,
  -2.12287858e-01f, 7.36578107e-02f, -4.44468707e-02f, 1.62191000e-02f, 6.56935871e-02f, -1.46719487e-02f, 6.84001446e-02f, 5.70664927e-02f, -7.52404854e-02f, -8.28345586e-03f,
  1.01243183e-01f, 2.52159382e-03f, 5.11151478e-02f, 4.10941020e-02f, -2.67093582e-03f, -6.06634468e-02f, 3.20982304e-03f, -1.02485858e-01f, 5.94405383e-02f, -3.80446799e-02f,
  2.27363557e-02f, 2.54319366e-02f, -8.41340572e-02f, -9.41652060e-02f, -7.71225616e-02f, 4.37201792e-03f, -4.05307189e-02f, -4.20651175e-02f, 1.61674879e-02f, -1.38423026e-01f,
  8.92219413e-03f, 1.97631225e-01f, 4.86334376e-02f, 1.62290875e-02f, 1.71471864e-01f, -1.24578364e-02f, 3.82836834e-02f, -1.54533967e-01f, -8.27743188e-02f, 1.51464328e-01f,
  1.07092686e-01f, 9.08025801e-02f, -6.88379183e-02f, -2.55830437e-02f, -1.27446055e-01f, 1.28806174e-01f, 5.48808649e-02f, -4.76731993e-02f, -9.08400193e-02f, 2.91060321e-02f,
  1.37792066e-01f, -6.40241941e-03f, -8.40296596e-02f, -4.87852916e-02f, 1.59206450e-01f, 1.40055537e-01f, -4.18160185e-02f, 8.07400718e-02f, 8.60333890e-02f, 2.59622574e-01f,
  3.14696074e-01f, -1.31558692e-02f, -7.42797107e-02f, -4.93181646e-02f, 7.17298016e-02f, 4.30085659e-02f, 1.12287529e-01f, -8.51660445e-02f, -8.90410468e-02f, 2.95539703e-02f,
  8.71441588e-02f, -9.53668356e-03f, 7.05653131e-02f, 7.47665241e-02f, -3.90991084e-02f, -5.82604818e-02f, -4.49576117e-02f, -4.76162508e-02f, -1.76170141e-01f, -2.34117005e-02f,
  2.62954757e-02f, 6.55745640e-02f, 7.82825574e-02f, -9.60199684e-02f, -1.75331220e-01f, 9.36618075e-03f, 7.87275657e-02f, -7.81643987e-02f, -3.89200002e-02f, 7.45485909e-03f,
  7.72950053e-03f, 1.30510861e-02f, -4.58420999e-02f, 2.75910203e-03f, 2.76097842e-02f, -1.64486095e-02f, -4.79528122e-02f, 1.29484003e-02f, 5.87220187e-04f, 5.30054495e-02f,
  -7.41264969e-02f, 2.19975505e-02f, 2.53785048e-02f, 4.04995382e-02f, 6.45725876e-02f, -3.79907005e-02f, 1.44399954e-02f, -4.93276231e-02f, -8.21718499e-02f, -2.00994909e-02f,
  6.89589232e-02f, -8.01483691e-02f, -9.07041579e-02f, -5.24373539e-02f, -1.57435499e-02f, 4.49175164e-02f, 3.32350004e-03f, 5.17751388e-02f, 1.42546126e-03f, 7.06327893e-03f,
  1.44683868e-01f, -1.94300711e-01f, 1.26797199e-01f, 3.83212306e-02f, 1.04840815e-01f, -1.91322248e-02f, -7.69457268e-03f, -5.06686978e-02f, 2.47841161e-02f, 2.39909235e-02f,
  3.38744037e-02f, -6.27164869e-03f, 2.53397021e-02f, -1.02063723e-01f, -4.26114508e-04f, 3.46470401e-02f, -5.12158573e-02f, -1.97518803e-02f, -6.68428689e-02f, 2.65891105e-03f,
  -7.46887401e-02f, 3.70032713e-02f, 8.63635689e-02f, 7.30861202e-02f, 5.87591603e-02f, 6.21749796e-02f, 8.45233351e-02f, 1.10466518e-01f, -3.72673348e-02f, 9.06788781e-02f,
  8.17214400e-02f, 9.61639136e-02f, -2.45572522e-01f, 1.21828318e-01f, -2.42448505e-02f, -1.87124550e-01f, -5.64756952e-02f, -1.89277977e-02f, 4.75545973e-02f, 6.14535697e-02f,
  9.05914381e-02f, 1.88596308e-01f, 1.16379149e-01f, 4.80703376e-02f, 8.03671256e-02f, -2.88817007e-02f, -1.35482838e-02f, -1.64028499e-02f, 3.69958095e-02f, 8.78616422e-02f,
  1.32085636e-01f, 1.75535858e-01f, 7.15564638e-02f, 5.65235540e-02f, 1.27665177e-01f, 1.20476529e-01f, -7.35519379e-02f, -3.98923829e-02f, -6.07206523e-02f, 1.08110391e-01f,
  -1.51158169e-01f, -1.44484073e-01f, 6.47321194e-02f, 1.48458838e-01f, -8.31333995e-02f, 3.72197330e-02f, -1.65912621e-02f, -8.88665691e-02f, 1.71240121e-02f, -3.87488641e-02f,
  -4.31078300e-02f, 4.01308201e-02f, -6.67482521e-03f, 7.11869597e-02f, -6.20642714e-02f, -4.29924056e-02f, -6.12593889e-02f, 1.87217910e-02f, -1.05478391e-02f, -3.98142263e-02f,
  1.04443729e-01f, 4.82294057e-03f, -1.57550976e-01f, -2.41885688e-02f, -2.46181414e-02f, -3.29961516e-02f, -2.26742234e-02f, -1.30088270e-01f, -1.08293340e-01f, 8.29339623e-02f,
  4.10963222e-02f, -8.54514241e-02f, -6.35901615e-02f, 5.77190369e-02f, 6.46922663e-02f, 2.08857376e-02f, 5.89636713e-02f, 7.80611709e-02f, 2.92150043e-02f, -2.90607754e-02f,
  5.13968393e-02f, -6.52156323e-02f, 2.54675783e-02f, -4.17535454e-02f, 7.52373338e-02f, -5.41074462e-02f, 4.82080840e-02f, 1.16555899e-01f, -7.48855323e-02f, -5.54274321e-02f,
  -2.79813670e-02f, 9.39520728e-03f, -8.12829100e-03f, -1.73495412e-02f, 2.92344298e-02f, -9.12259296e-02f, 3.76300029e-02f, 2.99667637e-03f, -2.99818963e-02f, -6.21489212e-02f,
  1.62698746e-01f, -9.71851125e-02f, 1.67165279e-01f, 1.12937577e-01f, 1.75319966e-02f, 3.72748859e-02f, -1.75127517e-02f, 1.00526735e-02f, 1.21135926e-02f, 4.19997126e-02f,
  4.50964496e-02f, 4.43632565e-02f, -8.74021575e-02f, 3.19920108e-02f, 3.92880067e-02f, -7.22587034e-02f, 6.23664148e-02f, 3.19895372e-02f, -6.20957017e-02f, -1.06983893e-02f,
  -4.08853553e-02f, 7.71830529e-02f, 1.32170655e-02f, -1.02512531e-01f, -7.84694925e-02f, 2.79464219e-02f, -7.79697299e-03f, 3.43392603e-02f, -6.74530864e-02f, 8.71076807e-02f,
  8.51046387e-03f, -1.96770951e-01f, -8.18471331e-03f, -1.46525949e-01f, -4.68007363e-02f, -1.03962928e-01f, -2.33983621e-01f, 2.73170136e-02f, 8.95451680e-02f, -1.37576595e-01f,
  1.04587795e-02f, -1.54149188e-02f, 7.71691501e-02f, -6.36014640e-02f, -2.32200082e-02f, -1.09117426e-01f, -1.85780868e-01f, -1.52345389e-01f, 8.89356248e-04f, -6.85175241e-04f,
  -1.29065037e-01f, -1.53227255e-01f, -1.71828605e-02f, -6.75003976e-02f, -9.15156007e-02f, 2.62304563e-02f, -6.16788752e-02f, -2.29557231e-02f, -2.20447015e-02f, -1.13711126e-01f,
  1.53318339e-03f, -8.68419837e-03f, 6.25632564e-03f, 6.42773136e-02f, -2.71256380e-02f, -1.05466954e-02f, 6.09869137e-02f, 1.61176622e-02f, 3.18655036e-02f, -5.57451975e-04f,
  4.77625355e-02f, 6.11522384e-02f, -7.97609910e-02f, -2.25293431e-02f, -1.61440368e-03f, -3.04240175e-02f, 5.35510741e-02f, -7.01712072e-02f, 7.58911669e-02f, 2.05570906e-02f,
  -1.15289673e-01f, -4.06403691e-02f, 4.94813956e-02f, 3.79690714e-02f, 3.28942984e-02f, -4.85517196e-02f, 1.92528106e-02f, 8.99621770e-02f, 1.52163759e-01f, 2.38302909e-02f,
  -5.63849993e-02f, 1.04268752e-02f, -4.06411476e-02f, -8.60546075e-04f, 7.71226175e-03f, 6.49463236e-02f, -5.51502546e-03f, -1.22306615e-01f, 4.88239247e-03f, -3.90696200e-03f,
  1.80747751e-02f, -3.26625556e-02f, 2.87046637e-02f, -4.65920791e-02f, -8.66981074e-02f, -2.12424677e-02f, -7.77712390e-02f, -1.95073411e-02f, -2.72176648e-03f, 1.10927932e-02f,
  6.16026223e-02f, 5.67207765e-03f, -5.82794212e-02f, 6.20218553e-02f, 8.31834376e-02f, -2.84527130e-02f, 6.07893169e-02f, 9.11142454e-02f, 3.89979705e-02f, -3.67875793e-03f,
  9.30759460e-02f, -1.36896840e-03f, 1.52440071e-02f, 3.84556912e-02f, 7.57316649e-02f, 8.38383362e-02f, -2.77606919e-02f, -1.95673015e-02f, 4.47638705e-02f, -5.38329855e-02f,
  1.03309348e-01f, -7.29474649e-02f, -1.02214254e-02f, 9.81626734e-02f, 3.74337249e-02f, 5.72204627e-02f, -6.45719618e-02f, -1.13110654e-01f, 4.10391204e-02f, -5.32006733e-02f,
  -1.14592031e-01f, -2.32980400e-02f, -2.01014336e-02f, 3.72249484e-02f, -3.65370810e-02f, 1.06574763e-02f, -7.71721378e-02f, -3.96367870e-02f, 8.55447948e-02f, -1.38052613e-01f,
  -2.68154014e-02f, -9.23646092e-02f, -3.21423978e-01f, 5.20294383e-02f, -3.82670388e-02f, -4.00548019e-02f, -1.27335474e-01f, -4.82857749e-02f, 9.83296856e-02f, -5.69210164e-02f,
  1.63410425e-01f, 1.61829904e-01f, 1.41435236e-01f, 1.71504974e-01f, 8.09227973e-02f, -1.29534617e-01f, -1.28476366e-01f, -1.26568899e-01f, 6.90901801e-02f, -6.16624281e-02f,
  8.61532465e-02f, -1.01625107e-01f, -2.00407784e-02f, -1.00076884e-01f, 1.39389494e-02f, -2.39099860e-02f, -1.47260398e-01f, -1.39590219e-01f, -6.64673299e-02f, -4.80602123e-02f,
  -2.84381509e-01f, -1.33543340e-02f, 3.62594314e-02f, 9.95435789e-02f, 2.59590764e-02f, -6.38960600e-02f, -2.43448261e-02f, -1.61067732e-02f, 9.53823403e-02f, -3.57278958e-02f,
  1.69935077e-02f, 7.67259002e-02f, 1.19076306e-02f, -9.38505027e-03f, -1.87479965e-02f, 4.61297901e-03f, -9.02632773e-02f, -6.50936812e-02f, 1.29012745e-02f, -8.73836577e-02f,
  8.41509849e-02f, 4.41897511e-02f, -9.30589661e-02f, -6.56550899e-02f, -6.55084178e-02f, 2.59383358e-02f, -9.51416269e-02f, -1.41877159e-01f, -1.26613155e-01f, -2.84313858e-01f,
  -1.54460510e-02f, -6.65361807e-03f, 7.98678845e-02f, -5.99768125e-02f, -2.22179503e-03f, -4.31834124e-02f, 4.53217328e-02f, 1.56476814e-02f, 8.62166472e-03f, -5.03434874e-02f,
  -1.35892276e-02f, 1.06046014e-02f, -7.05347257e-03f, -6.66717812e-02f, 2.87479218e-02f, -5.29512055e-02f, 2.09212452e-02f, -1.72613114e-02f, 1.05840797e-02f, 2.65585035e-02f,
  6.92926273e-02f, 2.98437774e-02f, -3.63090485e-02f, 6.59969542e-03f, -3.35558802e-02f, 2.71831583e-02f, 2.94315871e-02f, 3.44698839e-02f, 1.59245506e-02f, -3.36687341e-02f,
  -1.21093635e-02f, 1.82555407e-01f, -3.96213196e-02f, 8.74475576e-03f, 2.28676125e-02f, 7.85218610e-04f, -9.82194394e-03f, -3.13239382e-03f, 8.25480446e-02f, -1.30696282e-01f,
  3.51582356e-02f, -7.74792880e-02f, -2.40869392e-02f, -1.91389080e-02f, 2.53905635e-02f, -6.71597794e-02f, -5.86107187e-02f, 7.40541294e-02f, -2.16477048e-02f, -1.11808568e-01f,
  -4.09031361e-02f, -1.68865416e-02f, -1.12170782e-02f, -5.22823967e-02f, -1.09247923e-01f, 1.07111141e-01f, -1.48720667e-01f, -9.30866525e-02f, -7.16852844e-02f, -2.29845226e-01f,
  -6.03016913e-02f, 1.92072108e-01f, 1.14333384e-01f, -2.14183688e-01f, -1.09630659e-01f, 9.12533700e-02f, 2.26884201e-01f, 1.05143800e-01f, -1.16186261e-01f, -2.95818131e-02f,
  -1.21371672e-01f, -2.80209742e-02f, 2.05966942e-02f, 3.84165309e-02f, 2.31062219e-01f, 3.21829230e-01f, 2.57775843e-01f, 1.13229014e-01f, -2.85190213e-02f, -1.25883315e-02f,
  9.03636683e-03f, 1.96300540e-03f, -5.65180108e-02f, 2.41897814e-02f, -1.51385456e-01f, 1.12651857e-02f, -1.96134876e-02f, -9.70010608e-02f, 1.01221263e-01f, 3.09198033e-02f,
  -1.35905981e-01f, -1.54420555e-01f, 1.60506032e-02f, -3.00962161e-02f, -4.34595197e-02f, -1.47297215e-02f, 6.44273832e-02f, 4.43538576e-02f, -7.67097175e-02f, 7.55101293e-02f,
  -1.63820654e-01f, -4.23048846e-02f, -3.34088989e-02f, -8.13320056e-02f, -1.05953604e-01f, -6.08764887e-02f, 3.36541161e-02f, 1.28210381e-01f, 5.33579737e-02f, 2.08141617e-02f,
  4.10472564e-02f, -5.70429377e-02f, -9.10276175e-02f, 6.67995289e-02f, -7.17047155e-02f, 1.41107710e-02f, -8.40852689e-03f, -8.71073455e-02f, 1.98037308e-02f, 5.25611565e-02f,
  -2.59926915e-02f, -1.98018812e-02f, -1.30039710e-03f, -4.70667612e-03f, 2.69468408e-02f, -4.26786505e-02f, 1.32711343e-02f, -3.73955667e-02f, 7.45964795e-02f, 2.76945904e-02f,
  -4.87845875e-02f, 2.00456008e-02f, -2.33540824e-03f, -6.17253035e-02f, 4.20002639e-02f, 7.31198769e-03f, -2.47410797e-02f, -1.62677709e-02f, 1.24913976e-02f, 2.46546548e-02f,
  3.13491896e-02f, 5.35987020e-02f, -9.94183347e-02f, 3.44205624e-03f, -2.51864586e-02f, 6.02040663e-02f, 2.00201273e-02f, -1.19561246e-02f, -1.25018656e-02f, 1.29523883e-02f,
  -2.36745104e-02f, 1.20148465e-01f, 9.82575417e-02f, -2.81231981e-02f, -9.47550386e-02f, -2.56568231e-02f, -2.91726040e-03f, -5.58766983e-02f, -1.61337072e-03f, 1.01355901e-02f,
  -4.67491522e-03f, -1.04606310e-02f, 8.99954792e-03f, 7.32611716e-02f, 1.77455544e-02f, -5.32140471e-02f, -3.55187356e-02f, -2.80561205e-02f, -9.27994552e-04f, -7.97693133e-02f,
  1.56151783e-02f, 9.91240665e-02f, 1.09480638e-02f, 1.16659157e-01f, -1.49847129e-02f, 9.57667753e-02f, -2.17173409e-04f, -5.92774861e-02f, 9.31978878e-03f, 1.11197367e-01f,
  -4.58346494e-02f, -9.94217992e-02f, -3.94108482e-02f, -5.51461300e-04f, -1.20205760e-01f, 3.24535882e-03f, -1.90171767e-02f, -3.14337499e-02f, 6.54466599e-02f, -1.30311564e-01f,
  -8.40992630e-02f, -1.44760646e-02f, 3.54170203e-02f, -5.58502227e-02f, 2.35706232e-02f, -9.88841280e-02f, -3.80930714e-02f, 3.08686756e-02f, 7.70260319e-02f, -2.00788565e-02f,
  3.57306562e-02f, -5.14488928e-02f, 8.62158984e-02f, -1.99035853e-02f, 6.24621622e-02f, 5.89891337e-02f, 3.90045196e-02f, -5.92197143e-02f, -8.32253769e-02f, 3.15058641e-02f,
  -1.13549739e-01f, -6.25816500e-03f, 4.49980143e-03f, 5.55009861e-03f, -7.49606043e-02f, -3.05071548e-02f, -1.01456396e-01f, 8.75020549e-02f, 2.90827807e-02f, 3.18933465e-02f,
  -2.77351607e-02f, -1.63005944e-02f, -5.61326370e-02f, -5.29229157e-02f, 9.01084617e-02f, 9.74112079e-02f, 1.18831865e-01f, 1.49410799e-01f, 5.41201644e-02f, 7.04313144e-02f,
  -4.67559360e-02f, -1.11370333e-01f, 8.68529733e-03f, -4.46999744e-02f, 1.00972436e-01f, -8.02899301e-02f, 7.59146437e-02f, 1.21740222e-01f, 1.02800429e-01f, -5.89124225e-02f,
  -4.03196476e-02f, -5.10604270e-02f, 8.70807245e-02f, 8.07151720e-02f, -4.87076491e-02f, -1.86801013e-02f, 7.51864016e-02f, 4.00864370e-02f, 1.11943800e-02f, 8.59462935e-03f,
  -4.34022658e-02f, -7.81819820e-02f, -6.38852939e-02f, 3.22325043e-02f, 4.54763882e-02f, -3.85884754e-02f, -6.49560383e-03f, -2.13786704e-03f, -7.05412850e-02f, 1.43711092e-02f,
  3.09325512e-02f, 1.86834633e-02f, -3.95658575e-02f, 8.86786431e-02f, -7.37020522e-02f, 1.29933953e-02f, 3.81107740e-02f, -4.22267616e-02f, -5.53093851e-02f, -5.50693423e-02f,
  4.39536711e-03f, -9.56764370e-02f, -3.26852463e-02f, 8.63995627e-02f, 5.04513457e-02f, 3.65798585e-02f, -2.50411686e-02f, 4.00182270e-02f, -4.56179418e-02f, -5.17170765e-02f,
  -4.54935059e-02f, -2.87529603e-02f, -8.32550824e-02f, -6.49348227e-03f, -3.39447074e-02f, -5.74845187e-02f, -1.47659317e-01f, -3.69146429e-02f, 2.73214709e-02f, 2.71772482e-02f,
  -5.79691902e-02f, -5.98746762e-02f, -1.52260363e-01f, -1.81836020e-02f, 7.74126127e-02f, -1.08356729e-01f, 4.78551500e-02f, 9.84840468e-03f, -3.17883082e-02f, -1.17379531e-01f,
  -3.13729972e-01f, 1.50651941e-02f, -1.72849402e-01f, -1.27014831e-01f, 1.00108748e-02f, 5.19795716e-02f, -6.33167922e-02f, 1.06868155e-01f, 3.33524565e-03f, 5.37143052e-02f,
  -8.91118944e-02f, -8.53149816e-02f, -1.22533835e-01f, -7.57107809e-02f, -1.26091957e-01f, -5.42831570e-02f, -8.79420638e-02f, -2.20789984e-01f, -4.63341065e-02f, 3.02256700e-02f,
  4.81708348e-02f, 7.30744749e-02f, -3.43243107e-02f, 1.40520623e-02f, 3.57449949e-02f, 1.50935457e-03f, 3.16669419e-02f, 2.66369767e-02f, -2.78641582e-02f, -5.02718203e-02f,
  9.43134576e-02f, -1.62843227e-01f, 4.51520160e-02f, -4.82834317e-02f, -3.07280570e-02f, -1.03550643e-01f, -1.01093389e-02f, 1.66075621e-02f, -4.81915399e-02f, -6.97901174e-02f,
  -3.52868773e-02f, -9.79011953e-02f, -8.77624676e-02f, -3.96506824e-02f, 2.34630723e-02f, 4.44655046e-02f, -7.09528476e-02f, -3.57690305e-02f, 2.80175329e-04f, 3.19651663e-02f,
  -1.24948546e-02f, -8.89239162e-02f, -1.56383127e-01f, 7.78886527e-02f, -3.43498550e-02f, -1.25963777e-01f, 3.46366651e-02f, 5.23060076e-02f, 4.80909422e-02f, 1.50690690e-01f,
  1.65044963e-02f, 3.80703993e-02f, 8.42537805e-02f, 2.07445063e-02f, -8.75861105e-03f, -8.21827538e-03f, -1.62146725e-02f, 7.08172843e-02f, 1.01235567e-03f, -3.24999318e-02f,
  -4.00284640e-02f, 4.33247685e-02f, -3.75834517e-02f, -5.13061807e-02f, -7.21267909e-02f, -1.00571495e-02f, 1.77886318e-02f, 7.68017694e-02f, 4.33986187e-02f, -5.88639081e-02f,
  1.78292152e-02f, 9.36224312e-03f, -1.60847921e-02f, -2.92595825e-03f, 1.10978652e-02f, 6.53877929e-02f, 3.98586504e-02f, -1.83471688e-03f, -6.93323687e-02f, 2.83209160e-02f,
  2.02182531e-01f, -1.81540161e-01f, -1.53482119e-02f, -2.94092409e-02f, -7.56385997e-02f, 1.81231871e-02f, -9.05607734e-03f, -4.13522348e-02f, -1.02666385e-01f, -2.96559837e-02f,
  7.85453804e-03f, -7.86510259e-02f, -1.16002336e-01f, 8.08729753e-02f, -9.37983245e-02f, -5.07697184e-03f, 5.26463836e-02f, -9.37132165e-02f, -3.95443514e-02f, 1.12592645e-01f,
  6.94715232e-02f, 5.55330291e-02f, 3.28485817e-02f, 2.95318328e-02f, -3.27864103e-02f, -1.04128405e-01f, 1.00452930e-01f, 3.67982546e-03f, 5.13012242e-03f, 1.27932236e-01f,
  2.67561823e-01f, -1.53472042e-02f, -3.09774429e-01f, 1.07575797e-01f, -4.50831372e-04f, -3.09675988e-02f, 5.10687940e-02f, 4.04041186e-02f, 9.60144922e-02f, 7.96299428e-02f,
  1.46994218e-01f, 1.70248121e-01f, -4.72890632e-03f, -3.55776064e-02f, -4.05963063e-02f, -2.71772057e-01f, -3.07272226e-01f, -2.45226577e-01f, 2.46763080e-02f, 1.42277807e-01f,
  8.05602595e-02f, -3.12995687e-02f, -5.64373396e-02f, 1.77374445e-02f, -3.63997631e-02f, -8.04959014e-02f, -1.73382595e-01f, -3.69536057e-02f, -1.48449257e-01f, -2.40174100e-01f,
  -1.23440184e-01f, 1.17227279e-01f, 8.28526244e-02f, 3.92229669e-02f, -1.39866797e-02f, 3.95294987e-02f, 1.78120974e-02f, -6.59505464e-03f, -4.59537283e-02f, -6.55518547e-02f,
  1.42331766e-02f, 2.47722957e-03f, -2.41981465e-02f, -2.47547626e-02f, -2.72600278e-02f, 7.30296820e-02f, -5.76279238e-02f, -1.57753468e-01f, -8.22519213e-02f, 4.50202152e-02f,
  -5.22450097e-02f, -2.82789581e-02f, 5.15863933e-02f, 3.02201770e-02f, -7.59814680e-02f, 5.60273118e-02f, 7.12215826e-02f, 6.03103172e-03f, -2.31307894e-02f, -6.31982740e-03f,
  -2.68129539e-02f, -4.14572880e-02f, -7.23602390e-03f, 6.21672645e-02f, 1.05471769e-02f, -5.65338582e-02f, -8.32189918e-02f, 5.87324984e-02f, 2.34007072e-02f, 1.66432690e-02f,
  -6.40003532e-02f, 4.24305908e-02f, -2.50761006e-02f, -7.21108392e-02f, 3.37761603e-02f, -5.79287037e-02f, 1.20207192e-02f, -3.48068103e-02f, -6.20328225e-02f, 3.85384448e-02f,
  -2.87225265e-02f, 2.14091688e-02f, 2.79914849e-02f, -3.66394967e-02f, -4.08927761e-02f, -9.78731215e-02f, 2.89963819e-02f, -4.60507423e-02f, -1.46141481e-02f, 6.01866692e-02f,
  2.34686077e-01f, 8.03546309e-02f, 2.98571475e-02f, 4.15285379e-02f, -2.09959736e-03f, -9.99843795e-03f, 6.65103197e-02f, 5.15575409e-02f, 7.95904920e-02f, 7.21970126e-02f,
  5.66320047e-02f, 2.25513335e-03f, 5.27623929e-02f, -5.49593940e-02f, 1.07638434e-01f, 3.70176323e-02f, 1.34133231e-02f, 5.95104434e-02f, -2.89714839e-02f, -3.98173742e-02f,
  7.70865381e-02f, 5.09339124e-02f, 3.61061357e-02f, 1.03532098e-01f, 5.28034270e-02f, 2.13450462e-01f, 3.64751704e-02f, 2.44857203e-02f, 8.78750458e-02f, 1.15543984e-01f,
  -2.85644501e-01f, -1.04472861e-01f, 2.48649064e-02f, -2.66841888e-01f, -2.89123990e-02f, 1.72016785e-01f, 2.48827174e-01f, 2.07595706e-01f, -2.05818322e-02f, -9.72907096e-02f,
  7.39466213e-03f, 7.31588453e-02f, 2.40516551e-02f, 9.89192948e-02f, 1.86370447e-01f, 1.21890552e-01f, -6.46556467e-02f, 2.63420101e-02f, 2.01583639e-01f, 1.70918271e-01f,
  -7.58804902e-02f, -1.26003146e-01f, -2.31692865e-01f, -1.09936431e-01f, -1.82923123e-01f, -1.06627129e-01f, -1.35889128e-01f, -7.16970265e-02f, -1.12005398e-01f, -2.09794760e-01f,
  -4.25647348e-02f, -8.09294879e-02f, 5.93263283e-02f, -4.05722298e-02f, -2.66030915e-02f, -7.90788047e-03f, 4.30873744e-02f, -9.98159647e-02f, 1.20693799e-02f, -1.13195315e-01f,
  -9.84410793e-02f, -1.20093159e-01f, 2.97041778e-02f, 3.70869525e-02f, 3.76467556e-02f, -4.97848354e-02f, -1.25556111e-01f, -7.00442567e-02f, 2.90763658e-02f, -2.69116201e-02f,
  -1.15393646e-01f, -5.27093224e-02f, 5.23496568e-02f, 1.54785350e-01f, -1.25263748e-03f, -7.19796633e-03f, -3.45862769e-02f, 1.07354969e-02f, 1.37213454e-01f, -7.91423917e-02f,
  3.74429971e-02f, -5.29362001e-02f, 6.27022535e-02f, -7.81647861e-02f, 3.02083027e-02f, 1.23760132e-02f, 4.84702066e-02f, 3.25512812e-02f, 9.42494441e-03f, -3.03751100e-02f,
  7.53794834e-02f, 4.13188823e-02f, 7.22279772e-03f, 7.93155506e-02f, -6.35665730e-02f, -8.33703429e-02f, 3.98605242e-02f, 6.80809654e-03f, 5.46037704e-02f, -6.18612505e-02f,
  1.70670729e-02f, -6.46703839e-02f, -6.94406331e-02f, 9.87303928e-02f, -8.13236311e-02f, 7.61721469e-03f, -6.15167990e-02f, 5.83262518e-02f, 3.85787264e-02f, -5.56879342e-02f,
  8.83930251e-02f, 1.29365265e-01f, -4.23014462e-02f, -2.42770854e-02f, -1.16538323e-01f, -3.50099988e-02f, -9.14937556e-02f, -2.09959745e-02f, -1.03344202e-01f, -2.63868365e-02f,
  1.49160316e-02f, 5.59928827e-03f, -1.32807298e-02f, 3.85982655e-02f, -2.99598835e-03f, -3.92421745e-02f, -6.87521771e-02f, 5.50378412e-02f, 5.39772511e-02f, 4.25770655e-02f,
  -4.67786798e-03f, 1.22310214e-01f, 7.57904351e-02f, 1.80531129e-01f, 2.05874927e-02f, 1.31441638e-01f, 6.35437816e-02f, 1.49289379e-02f, 2.39555016e-01f, 1.37411743e-01f,
  4.36583236e-02f, 7.95621946e-02f, 1.67589083e-01f, -6.27627363e-03f, -5.61076216e-02f, 4.88058142e-02f, 7.17689022e-02f, -1.10086106e-01f, -2.27998570e-02f, 2.75006797e-02f,
  2.32010018e-02f, 1.19286366e-01f, -2.44457666e-02f, 9.49768424e-02f, 9.48409364e-02f, 1.81657095e-02f, 2.12879479e-02f, 1.10080570e-01f, 1.06482230e-01f, 1.28478324e-02f,
  3.83845307e-02f, 2.66718138e-02f, 7.21612722e-02f, -5.48501797e-02f, -3.12513746e-02f, 4.14861068e-02f, 3.01279388e-02f, 2.55072601e-02f, 2.92848423e-02f, 5.09499423e-02f,
  1.87171116e-01f, 1.70322910e-01f, -4.11437526e-02f, 9.61303338e-02f, 2.79935598e-02f, -6.61504492e-02f, 9.14702564e-02f, -5.23588732e-02f, 2.47694161e-02f, -5.27006947e-02f,
  -4.74731326e-02f, 9.51244012e-02f, 1.01798952e-01f, 8.34317878e-02f, 1.31553747e-02f, -1.66871622e-02f, -8.73151645e-02f, -7.42201358e-02f, 4.18913476e-02f, -4.89075668e-02f,
  8.28736555e-03f, 1.49325773e-01f, 1.23046115e-01f, -4.24289405e-02f, -5.32193929e-02f, -1.10646216e-02f, -3.20098773e-02f, -3.71161290e-02f, 9.72873822e-05f, -1.72981410e-03f,
  -7.86069687e-03f, 1.63742267e-02f, -4.73777950e-02f, -1.48408897e-02f, 4.26321067e-02f, 6.02339283e-02f, 7.28087500e-02f, -5.54369986e-02f, 7.02246204e-02f, -6.17864504e-02f,
  -8.03769194e-03f, -5.20389490e-02f, 6.64274469e-02f, 2.98784357e-02f, -2.89320592e-02f, -3.40686776e-02f, 5.29526323e-02f, -1.99066307e-02f, -6.41094670e-02f, 2.02619750e-03f,
  -3.69602181e-02f, -2.26120558e-02f, 5.29276347e-03f, 5.47995977e-02f, -1.18586440e-02f, 2.95088656e-04f, -4.81669307e-02f, 3.18489149e-02f, -4.32076212e-03f, -2.06551515e-02f,
  -1.38859376e-01f, 6.25348240e-02f, -1.09716885e-01f, 2.41352711e-02f, -6.55855834e-02f, 8.61825794e-03f, -2.40687877e-02f, -3.58794183e-02f, 1.03639305e-01f, 8.89705308e-03f,
  1.04420535e-01f, 4.85173706e-03f, -1.26675460e-02f, -2.43517067e-02f, 4.50751148e-02f, -1.03593566e-01f, 9.74970311e-03f, 2.41635344e-03f, 4.54567559e-02f, -4.15312238e-02f,
  -7.86422491e-02f, -6.97464496e-02f, 8.43225867e-02f, -3.13858822e-04f, -7.11674765e-02f, 9.78296027e-02f, -5.76576740e-02f, 2.47666035e-02f, -6.94146976e-02f, -1.33019701e-01f,
  -6.12451546e-02f, 3.93142067e-02f, 7.51131028e-02f, 3.41097116e-02f, 1.32518217e-01f, -2.35262141e-02f, -1.78573370e-01f, -7.72276819e-02f, -4.92876209e-02f, -3.11442278e-02f,
  -1.66431982e-02f, -3.21658775e-02f, 5.55148721e-02f, -2.70076897e-02f, -7.80617371e-02f, -1.07260123e-01f, 4.42284271e-02f, -4.85402867e-02f, 2.20024306e-03f, -3.77508998e-02f,
  8.55647400e-02f, -4.78926813e-03f, -4.20560129e-02f, -3.02245300e-02f, 5.71517134e-03f, -2.62924638e-02f, 8.24258551e-02f, 3.53032537e-02f, -1.89647563e-02f, 9.90794078e-02f,
  -1.48273364e-01f, 3.99432704e-02f, 2.01615356e-02f, 9.62050408e-02f, 7.49129243e-03f, 2.24447809e-02f, -9.17188302e-02f, 1.73050594e-02f, 3.23279202e-02f, -5.94365969e-02f,
  2.40405574e-02f, 1.02008618e-01f, 1.02238268e-01f, 1.14611415e-02f, 3.17867771e-02f, -6.71294406e-02f, -4.54423912e-02f, 8.25615525e-02f, 8.07049051e-02f, 9.99156684e-02f,
  8.89414921e-03f, -1.85359493e-02f, -6.43051639e-02f, -7.30256066e-02f, -3.90178114e-02f, 3.52324583e-02f, -9.01825950e-02f, -5.01030087e-02f, -1.38955757e-01f, -1.56407878e-01f,
  1.43381301e-02f, 2.55140625e-02f, -2.88030226e-02f, 6.98790466e-03f, 3.74896191e-02f, -1.63896754e-02f, 8.56894851e-02f, 6.83499649e-02f, 2.47241538e-02f, -3.88675295e-02f,
  8.19176994e-03f, -6.07490391e-02f, -2.49654520e-02f, -3.20169255e-02f, 2.11461354e-02f, -7.10860491e-02f, -2.61801220e-02f, -5.13244458e-02f, -8.17501619e-02f, 4.37350571e-02f,
  5.65477461e-02f, 1.35362484e-02f, -6.18626922e-02f, -2.46151201e-02f, -6.19053431e-02f, 2.53845584e-02f, 1.24162305e-02f, -2.42945980e-02f, -2.79338229e-02f, -9.54732951e-03f,
  -8.97274986e-02f, 1.32662609e-01f, -1.63030207e-01f, -2.70902123e-02f, 2.89709829e-02f, 3.14081050e-02f, 4.67423871e-02f, -2.96656527e-02f, 5.23642264e-02f, 7.15381000e-03f,
  2.63331961e-02f, -4.23981324e-02f, -2.57148277e-02f, -5.48042357e-02f, 4.56625409e-02f, 1.96395628e-02f, 7.99213126e-02f, 2.72679795e-02f, -9.26602110e-02f, -9.21565667e-02f,
  -2.11972874e-02f, -1.29957646e-01f, -2.11855546e-01f, -1.45028949e-01f, 7.01630674e-03f, -1.89417243e-01f, -1.64527848e-01f, -2.15097338e-01f, -2.30941609e-01f, -2.39172429e-01f,
  -4.97547351e-02f, -7.12119834e-03f, 3.94493230e-02f, 1.70979485e-01f, 1.58479109e-01f, 1.52234659e-01f, -3.39646712e-02f, -3.68722640e-02f, 4.99025807e-02f, 9.08139274e-02f,
  -8.76059383e-02f, 3.59913483e-02f, -9.95850656e-03f, -3.47857364e-02f, 8.59644189e-02f, 1.86209872e-01f, 2.34408036e-01f, 2.16759488e-01f, 1.47808895e-01f, -3.60551402e-02f,
  -1.18281040e-02f, 1.25200581e-02f, 1.67313650e-01f, 9.20382366e-02f, -1.04142744e-02f, 1.15238398e-01f, 3.33456546e-02f, -4.35899608e-02f, 7.24692643e-02f, 3.11279818e-02f,
  -2.38286391e-01f, -1.56905919e-01f, 9.43505391e-02f, 7.55730569e-02f, 9.91966203e-02f, 2.98260525e-02f, -5.12979478e-02f, 4.95700091e-02f, -5.03708683e-02f, 1.52404541e-02f,
  -7.67391771e-02f, -7.35058784e-02f, 1.16572902e-03f, -5.25652431e-02f, -4.71872389e-02f, -1.18596107e-01f, 2.49625817e-02f, -1.11166807e-02f, -3.53914744e-04f, -3.80084850e-02f,
  5.37401512e-02f, -5.48792779e-02f, 3.05238366e-02f, 2.43970957e-02f, -1.31104914e-02f, 4.10303324e-02f, -4.11599949e-02f, -7.14213997e-02f, -9.41246226e-02f, -1.37787208e-01f,
  6.60006106e-02f, -4.75418754e-02f, 7.98878148e-02f, -5.19015715e-02f, 1.76548883e-02f, -7.05206022e-02f, 2.43502222e-02f, -2.03794558e-02f, 6.86274320e-02f, -3.64037268e-02f,
  -6.69300258e-02f, 5.96436821e-02f, 3.35556897e-03f, -1.84268802e-02f, 2.24898867e-02f, 7.69178495e-02f, 2.55904496e-02f, -6.77675754e-02f, 2.12910436e-02f, 6.35152981e-02f,
  -7.03925788e-02f, -4.35702652e-02f, -6.01533130e-02f, -2.43443511e-02f, 3.87378670e-02f, 6.15011640e-02f, 1.50583405e-02f, -4.65152487e-02f, 8.37345433e-04f, 6.50969744e-02f,
  -1.50763825e-01f, 2.02141553e-01f, -4.20191363e-02f, -6.55804127e-02f, 1.25642121e-01f, -3.42266401e-03f, -3.18608107e-03f, 5.19852601e-02f, -1.83573384e-02f, -2.32338421e-02f,
  5.29589457e-03f, 1.06445448e-02f, 7.19650313e-02f, 2.97338385e-02f, -4.92497683e-02f, -1.72182489e-02f, 1.10197701e-01f, 1.09682761e-01f, -4.18794602e-02f, 1.93305721e-03f,
  -4.07945029e-02f, 3.66603509e-02f, -8.25240165e-02f, -6.38944237e-03f, -1.67784076e-02f, 1.18710756e-01f, -8.90666917e-02f, 1.84541587e-02f, -2.07729209e-02f, 4.00405712e-02f,
  -2.83658803e-01f, 3.38239111e-02f, -1.31764531e-01f, 1.25193626e-01f, 6.09037913e-02f, -1.50815547e-01f, -1.19739622e-01f, -1.04950234e-01f, 5.07121496e-02f, 3.36957276e-02f,
  -1.04278073e-01f, 7.85588101e-03f, -5.83046116e-03f, -1.06200203e-01f, -1.40950859e-01f, -7.37560689e-02f, 8.41763988e-03f, 2.40164492e-02f, -1.48647148e-02f, 4.48661707e-02f,
  1.71724826e-01f, 1.78653039e-02f, 5.95220774e-02f, 1.45634398e-01f, 1.23133145e-01f, 1.34417742e-01f, 3.20912823e-02f, 1.25546560e-01f, 3.21909487e-02f, 2.19082817e-01f,
  -5.84310759e-03f, -1.57044083e-01f, -5.22406865e-03f, -8.85633193e-03f, 5.32707982e-02f, -5.74964695e-02f, 9.08741076e-03f, -2.90949214e-02f, -6.02210499e-02f, -2.23473758e-02f,
  -1.19773047e-02f, -2.94498745e-02f, -5.20727299e-02f, 8.85914117e-02f, -3.59990634e-02f, 1.09276371e-02f, -3.31698619e-02f, -4.51346338e-02f, -1.10766096e-02f, 8.50685760e-02f,
  4.26391363e-02f, 3.30088325e-02f, -8.18701461e-02f, -4.95116673e-02f, 4.48259199e-03f, -9.54163168e-03f, -3.19927707e-02f, 1.08057998e-01f, -9.46981460e-03f, 1.27692651e-02f,
  -7.13239014e-02f, 3.82051468e-02f, 9.81046632e-02f, 6.31787553e-02f, -5.54072438e-04f, 6.71068281e-02f, 8.36681649e-02f, -1.68729722e-02f, 4.28498089e-02f, 7.27559254e-02f,
  -5.26794186e-03f, -2.26284750e-02f, 3.92271020e-02f, -5.35244606e-02f, 5.19735068e-02f, -3.16516170e-03f, -1.23238284e-02f, -2.82002538e-02f, 2.19001472e-02f, -3.43871489e-02f,
  -6.54899105e-02f, 2.90302150e-02f, -7.01914495e-03f, -1.29608288e-02f, -1.19915782e-02f, 5.51890768e-02f, 1.81295611e-02f, 3.40784108e-03f, -4.77614328e-02f, 5.66481091e-02f,
  2.25844653e-03f, -2.18579337e-01f, -3.16263475e-02f, 3.59799415e-02f, 1.16170645e-02f, -3.89034823e-02f, 3.90361175e-02f, 3.54183925e-04f, 4.81301658e-02f, -4.45500351e-02f,
  7.84968063e-02f, 5.24322502e-03f, -5.36361672e-02f, 7.96134472e-02f, -1.61342137e-02f, 5.86656444e-02f, 2.67770025e-04f, 5.50412200e-02f, -5.76723367e-02f, 8.14826936e-02f,
  4.69046943e-02f, -9.87357050e-02f, -1.00374848e-01f, -1.15963772e-01f, 2.42061336e-02f, -1.72149584e-01f, -7.32978135e-02f, -8.00056010e-02f, -1.03101991e-01f, -1.52064174e-01f,
  4.32445943e-01f, -7.86412582e-02f, 9.21413824e-02f, 9.04353261e-02f, -2.16384545e-01f, -2.20984161e-01f, -1.14818841e-01f, 4.40769887e-04f, 9.73992944e-02f, -6.09736657e-03f,
  -1.89034864e-01f, 3.92924100e-02f, 5.53631736e-03f, -4.63289954e-02f, -1.23005838e-03f, -1.30876422e-01f, 2.54657380e-02f, 2.39020884e-01f, 2.43170008e-01f, 7.64817894e-02f,
  -6.44854233e-02f, 1.03100374e-01f, 2.68434018e-01f, 9.24436450e-02f, -3.70954955e-03f, 2.80726273e-02f, -9.89378691e-02f, 8.97066481e-03f, -8.48104060e-02f, -6.39833882e-02f,
  7.43906945e-02f, 1.06975660e-01f, -3.78241055e-02f, -5.59695251e-02f, -3.87703739e-02f, 6.96876273e-02f, 3.91829237e-02f, 1.28776819e-01f, 6.86098561e-02f, 7.76316896e-02f,
  -9.06154588e-02f, 7.90949315e-02f, -8.05734023e-02f, 2.54101641e-02f, 5.85636161e-02f, -2.79954402e-03f, 4.61723432e-02f, 9.17569101e-02f, 9.17370245e-02f, 5.51302023e-02f,
  -3.49013098e-02f, 4.72213700e-03f, 9.66348723e-02f, -8.24124068e-02f, -5.69946691e-02f, -4.56616841e-02f, 2.85961777e-02f, 1.25887906e-02f, 4.26919125e-02f, 1.42516673e-01f,
  -3.45331468e-02f, 2.32361276e-02f, -7.25557283e-02f, -4.90563037e-03f, -6.65107416e-03f, -4.41074185e-02f, -5.75418882e-02f, 3.86579745e-02f, -3.67221907e-02f, 1.45708732e-02f,
  5.84386699e-02f, -2.23873071e-02f, 2.95566879e-02f, -1.77322812e-02f, 4.44615521e-02f, -6.12750417e-04f, 8.62593763e-03f, -3.10361721e-02f, -2.00624559e-02f, 7.33863711e-02f,
  8.32212567e-02f, -5.18407449e-02f, 6.62514046e-02f, -1.90766957e-02f, 1.49247441e-02f, 4.72891368e-02f, 4.45179604e-02f, -2.67723408e-02f, 3.96753289e-02f, 6.12337552e-02f,
  7.85771906e-02f, -1.58161297e-01f, 1.08347729e-01f, 9.06266719e-02f, -1.63442697e-02f, 2.26082187e-02f, -7.69917667e-02f, 9.58350524e-02f, -1.50530727e-03f, 3.39661874e-02f,
  5.34062013e-02f, -3.17938835e-03f, 6.41944855e-02f, 6.75716922e-02f, 7.74647966e-02f, 5.00288047e-02f, 2.84295361e-02f, 1.83504466e-02f, -1.41613642e-02f, -5.01690395e-02f,
  -4.82127741e-02f, 1.45031616e-01f, 2.02590197e-01f, 8.67273062e-02f, -2.28241514e-02f, -1.19536929e-02f, 1.15905844e-01f, -2.19083987e-02f, 7.69697577e-02f, 1.19010404e-01f,
  -1.68808088e-01f, -8.54409710e-02f, 1.11888267e-01f, -1.78858861e-02f, 9.47375502e-03f, 1.13397064e-02f, 6.23035841e-02f, -6.30891249e-02f, 3.46402898e-02f, 9.58953239e-03f,
  -7.93067887e-02f, -1.82501271e-01f, -4.49842289e-02f, 6.14107810e-02f, 1.61682945e-02f, 1.15338638e-01f, 1.87776834e-01f, 8.56880322e-02f, 7.88730830e-02f, 1.26925215e-01f,
  9.67539847e-02f, 8.19281861e-02f, 6.08197190e-02f, 1.04507849e-01f, 1.26394600e-01f, -4.38740626e-02f, 1.23831995e-01f, -2.16806978e-02f, 2.88786497e-02f, 1.17323577e-01f,
  4.38957363e-02f, -7.29506910e-02f, 1.15452446e-01f, 2.07619984e-02f, 6.82252273e-02f, 1.00152930e-02f, -1.28226057e-02f, -4.77362424e-02f, 9.17319767e-03f, -8.33518729e-02f,
  -7.74128288e-02f, 5.87594248e-02f, -1.24403080e-02f, 9.46934149e-02f, 7.07943365e-02f, 1.93814654e-02f, -4.84953783e-02f, 2.66898982e-02f, -4.58810292e-03f, -9.02004167e-03f,
  2.21252255e-02f, -3.52104381e-02f, 5.38134389e-03f, 2.65133549e-02f, -1.76612064e-02f, -9.05319154e-02f, -4.02014405e-02f, -8.65583271e-02f, -2.75136884e-02f, -1.91086493e-02f,
  3.60023864e-02f, 3.29867937e-02f, -9.41172019e-02f, -9.41090509e-02f, -9.45227593e-02f, 3.93890105e-02f, -6.38612658e-02f, -5.20055033e-02f, 7.45858029e-02f, -4.85086627e-02f,
  6.16699718e-02f, -3.11280917e-02f, 7.54945204e-02f, 3.53098987e-03f, -4.61660847e-02f, -3.31037082e-02f, 7.36334473e-02f, 1.09747089e-02f, 5.30781932e-02f, -1.32990712e-02f,
  4.91236337e-02f, 1.64040030e-04f, -2.98601147e-02f, 4.19999808e-02f, 4.63569835e-02f, 7.24310726e-02f, -8.34026784e-02f, 2.24389732e-02f, -8.19296911e-02f, 2.67628580e-02f,
  -1.70151651e-01f, 4.05058973e-02f, -7.87621737e-02f, 1.40875131e-02f, 8.28047469e-02f, 3.88417416e-03f, 8.72471184e-03f, 7.29498118e-02f, 1.07333437e-02f, -3.29284444e-02f,
  -1.30487196e-02f, 3.55461389e-02f, -2.19474323e-02f, -5.63895628e-02f, 3.00384481e-02f, -5.59171848e-02f, -5.19414879e-02f, 3.59180570e-02f, 3.06273475e-02f, -4.68287617e-02f,
  -1.71315819e-02f, -8.86287242e-02f, -7.17722327e-02f, -1.15422927e-01f, -7.64246332e-03f, 3.58545780e-02f, -1.14222988e-03f, -5.38639389e-02f, 3.88725400e-02f, 8.93108919e-03f,
  5.51411211e-01f, -1.85304761e-01f, -1.66315109e-01f, 2.88342070e-02f, -4.32511829e-02f, -1.31241940e-02f, -2.32835533e-03f, 2.63025016e-02f, 1.04388416e-01f, -2.29535215e-02f,
  -4.40709591e-02f, -3.45660211e-03f, 7.69608244e-02f, -4.50891890e-02f, 1.03092954e-01f, -9.86274406e-02f, -1.37831897e-01f, 4.34968993e-02f, 1.22163989e-01f, 1.73148811e-01f,
  5.89608848e-02f, 5.08254452e-04f, 1.50028229e-01f, 8.76126438e-02f, -1.73147514e-01f, -3.42307589e-03f, -6.67440072e-02f, -1.07371964e-01f, -1.07471280e-01f, -1.36002690e-01f,
  -2.08337381e-02f, -1.99852381e-02f, 3.51994522e-02f, 1.56381205e-02f, -4.53476720e-02f, 8.53327215e-02f, 1.48470094e-03f, 1.07723149e-02f, 3.16945277e-02f, 6.44749263e-03f,
  -3.56887467e-02f, 2.90022809e-02f, -6.56541660e-02f, -1.00495547e-01f, 7.28211030e-02f, 5.81330545e-02f, -1.11771142e-03f, 3.15484181e-02f, -7.44853094e-02f, -3.90959270e-02f,
  -8.01350176e-02f, 4.15436400e-04f, 7.84791335e-02f, -4.61503640e-02f, -8.74808729e-02f, 1.46481231e-01f, -3.77061516e-02f, 4.55469824e-02f, 6.37471899e-02f, 3.64320613e-02f,
  2.25314638e-03f, -8.49376619e-03f, 4.35759574e-02f, 2.50658989e-02f, 2.72763222e-02f, -3.16505060e-02f, 1.58363469e-02f, -7.36740232e-03f, -3.78592610e-02f, -3.82400267e-02f,
  -7.44705126e-02f, -2.06839619e-03f, -3.71283032e-02f, 5.86821325e-02f, -1.58659946e-02f, -5.00852019e-02f, 2.70053130e-02f, -8.44251141e-02f, 5.91658168e-02f, -5.55829071e-02f,
  2.89696977e-02f, 7.60310516e-02f, -5.87812178e-02f, -4.46655555e-03f, -1.06159970e-01f, -4.90199067e-02f, 5.85762262e-02f, 1.47090638e-02f, 1.47089851e-03f, 1.10042296e-01f,
  1.09772265e-01f, 4.39678095e-02f, 2.57588774e-02f, 1.00379430e-01f, 5.26768677e-02f, -7.56387413e-02f, -6.14007674e-02f, -7.34129846e-02f, -6.79682288e-03f, 7.25346506e-02f,
  -2.54377816e-02f, 3.28540243e-03f, -1.77921390e-03f, 2.52739172e-02f, -1.58134494e-02f, 5.06954826e-02f, -2.56232042e-02f, 8.98962542e-02f, 3.77346799e-02f, 1.98250264e-02f,
  -1.04441680e-01f, 1.56675711e-01f, 2.50013143e-01f, -2.45787743e-02f, 4.11548875e-02f, 2.30553940e-01f, 1.35190427e-01f, 7.17931688e-02f, 2.15355545e-01f, 1.45012528e-01f,
  -2.43301354e-02f, -3.60885859e-01f, 8.23986307e-02f, -5.22640534e-02f, -2.23194420e-01f, -2.50875354e-01f, -3.53459358e-01f, -1.39955685e-01f, -7.54190087e-02f, -1.01847641e-01f,
  -1.01939000e-01f, 2.58114755e-01f, 2.29161501e-01f, 2.86719590e-01f, 1.85406893e-01f, -8.37623626e-02f, -1.14407554e-01f, 5.67372777e-02f, 1.38417915e-01f, 4.06621546e-02f,
  -1.58224493e-01f, -9.95859578e-02f, -1.36463623e-02f, 9.15154368e-02f, -7.91673884e-02f, 6.66658655e-02f, -1.34361451e-02f, 2.83838958e-02f, -6.27014264e-02f, -7.99987814e-04f,
  2.51915455e-01f, -7.97013268e-02f, 2.12414846e-01f, 1.88204870e-02f, 7.97269568e-02f, 4.88971211e-02f, 6.95737824e-02f, 1.04814939e-01f, -5.95903844e-02f, 2.67850086e-02f,
  8.34607612e-03f, 1.54645173e-02f, -3.28587852e-02f, 6.17608689e-02f, -7.82216638e-02f, -1.66359078e-02f, 4.61619757e-02f, 8.64440948e-02f, 9.25764740e-02f, -5.60626648e-02f,
  -2.38069873e-02f, -1.86844513e-01f, -1.29353395e-02f, 1.98286306e-02f, 5.62279746e-02f, 1.15738228e-01f, 5.46234958e-02f, 5.39511368e-02f, 1.03488483e-01f, -6.97350055e-02f,
  -3.60780172e-02f, -7.20275892e-03f, -2.68397406e-02f, -1.81392711e-02f, 3.08928285e-02f, -1.56112770e-02f, -4.58541103e-02f, 1.58959180e-02f, -4.69367951e-02f, -8.59634951e-03f,
  8.69377106e-02f, -3.48105244e-02f, 7.78622180e-02f, -3.68201584e-02f, 4.87901606e-02f, 3.40369344e-02f, -4.14475501e-02f, 1.65555486e-03f, 2.38205679e-03f, 4.03421372e-02f,
  4.60506715e-02f, -2.09353119e-02f, 4.33348529e-02f, 2.28193421e-02f, 2.57646460e-02f, -2.93511022e-02f, -4.17608842e-02f, -1.79965105e-02f, -5.06684482e-02f, -1.49442255e-02f,
  1.18562207e-01f, 1.78997412e-01f, 8.34433064e-02f, 1.99842528e-02f, -5.60136326e-02f, 5.17488942e-02f, -5.57507090e-02f, 2.06175353e-02f, -2.93716285e-02f, 1.47044472e-02f,
  2.87853051e-02f, 4.90902923e-02f, 6.80923760e-02f, -6.51129521e-03f, -5.08263148e-02f, -6.54621795e-02f, -8.03516358e-02f, 7.32734799e-02f, -1.35530904e-02f, -2.25583483e-02f,
  -5.30009158e-02f, 2.06932760e-04f, -4.68169451e-02f, 8.15935433e-02f, -1.38039039e-02f, 8.49559084e-02f, 7.22045451e-02f, 8.53195935e-02f, 8.93325433e-02f, -1.60644040e-01f,
  -4.89979982e-01f, 2.76822656e-01f, 2.81530827e-01f, -2.50536092e-02f, 1.95793688e-01f, 2.53156692e-01f, 2.36196890e-01f, 2.62968801e-02f, -5.95196448e-02f, 1.83281898e-01f,
  2.18307272e-01f, -1.73292868e-02f, 3.58412862e-02f, -2.34461632e-02f, -7.76721314e-02f, 2.21336424e-01f, 1.38514251e-01f, -3.16324197e-02f, -1.11201286e-01f, -1.43084764e-01f,
  4.98305857e-02f, -6.08867630e-02f, -2.43144602e-01f, -1.75204858e-01f, 5.55660725e-02f, -4.81486879e-02f, 1.09065667e-01f, 6.39682859e-02f, 1.05186597e-01f, 1.81632638e-01f,
  2.90437073e-01f, 6.29871804e-03f, -8.45161080e-03f, -8.02232232e-03f, 1.19627088e-01f, -1.33788422e-01f, 1.70760378e-02f, -4.82631437e-02f, -3.94464284e-03f, 4.89371978e-02f,
  -1.44833764e-02f, -4.01159637e-02f, -7.59792514e-04f, -3.00900768e-02f, -2.71622632e-02f, -7.92703182e-02f, -4.08436023e-02f, -1.84106514e-01f, 6.20578155e-02f, -1.51451537e-02f,
  6.10090122e-02f, 1.18319966e-01f, 9.00515094e-02f, 6.77347034e-02f, -4.26244782e-03f, -4.63740826e-02f, 3.83472443e-02f, -7.62542635e-02f, -3.14185629e-04f, 1.68293137e-02f,
  2.11129896e-02f, 1.07124858e-01f, -2.15146933e-02f, -4.57496643e-02f, 2.58210115e-02f, 7.42546050e-03f, 6.38995543e-02f, 2.76888721e-02f, 2.25093476e-02f, 2.42529530e-02f,
  -2.36420762e-02f, 8.12389031e-02f, -3.93696614e-02f, 3.38709168e-03f, 1.78759173e-02f, -2.05948520e-02f, -1.26687009e-02f, 6.57302737e-02f, -4.22968343e-02f, -5.34469783e-02f,
  -4.36173119e-02f, -1.65714398e-02f, 2.79291663e-02f, 7.12855980e-02f, 3.82262236e-03f, -3.11258156e-02f, -1.62769016e-02f, 7.51714315e-03f, -1.03426632e-02f, 2.18773149e-02f,
  -7.52958190e-03f, 2.44205780e-02f, 5.52939139e-02f, -1.07766040e-01f, 1.00947693e-02f, -3.91632989e-02f, 1.11018166e-01f, 5.64030595e-02f, 5.11569344e-03f, -4.90984581e-02f,
  4.08617668e-02f, -3.54110822e-02f, 9.31647122e-02f, -1.73660312e-02f, 2.10714974e-02f, 1.92239240e-03f, -2.80160252e-02f, 3.31346728e-02f, -7.25564510e-02f, 1.93859041e-02f,
  4.30140868e-02f, 2.94455420e-02f, -8.67635235e-02f, 4.52474542e-02f, 3.88407670e-02f, -8.61657336e-02f, 1.60573050e-01f, -6.02250695e-02f, 5.45280613e-02f, 1.85290761e-02f,
  5.38454592e-01f, -3.71725917e-01f, -2.43131846e-01f, 1.65768471e-02f, -1.49936765e-01f, -1.33840889e-02f, -2.55528659e-01f, -6.95359719e-04f, 1.22738928e-01f, -9.43533704e-02f,
  -1.16232932e-01f, 7.94115290e-02f, 9.68189389e-02f, 1.32955894e-01f, 5.25674298e-02f, -1.76610798e-01f, -1.31902277e-01f, 1.49449453e-01f, 3.84155691e-01f, 1.70516878e-01f,
  9.48572755e-02f, 9.96083915e-02f, 2.58772403e-01f, 3.28637026e-02f, -1.22117959e-01f, 2.91476622e-02f, -1.61452442e-01f, -1.42969966e-01f, -2.22674280e-01f, -2.85152972e-01f,
  -1.58047333e-01f, -2.88486201e-02f, 8.73103589e-02f, 3.98123376e-02f, -6.13313988e-02f, 1.02826148e-01f, 7.69887492e-02f, 2.22416613e-02f, -6.02174969e-03f, -4.52280566e-02f,
  -9.58065689e-02f, 8.03334117e-02f, -3.21314223e-02f, 4.41242242e-03f, 6.64874837e-02f, -2.31788997e-02f, 2.45833900e-02f, 3.10388617e-02f, 1.03241161e-01f, -6.52289838e-02f,
  -1.84387818e-01f, -3.39182876e-02f, -1.72719974e-02f, -8.92681703e-02f, 1.52977905e-03f, 1.41436055e-01f, -1.10766329e-01f, 3.82097028e-02f, 2.57626437e-02f, -2.13595922e-03f,
  4.43399651e-03f, -2.47165747e-02f, -6.45713732e-02f, -1.11406762e-02f, 3.60775776e-02f, -6.37944862e-02f, -7.18577940e-04f, 3.44149559e-03f, 4.91984151e-02f, 7.95956701e-03f,
  7.90819712e-03f, -3.84250330e-03f, 2.73837354e-02f, 4.66358736e-02f, -6.48042634e-02f, -3.78576573e-03f, 3.48316785e-03f, -1.43906763e-02f, -2.52466947e-02f, -4.46179658e-02f,
  5.02171703e-02f, 1.76531542e-02f, -2.24234294e-02f, -4.87025753e-02f, -2.40035309e-03f, 6.39932975e-03f, 1.56684255e-03f, 3.37934420e-02f, 3.80329113e-03f, 2.66411658e-02f,
  1.96633369e-01f, 4.99296896e-02f, 3.73226553e-02f, 7.31037036e-02f, -4.63770851e-02f, -3.31730694e-02f, -1.67359356e-02f, -6.38661161e-03f, -6.79359064e-02f, 6.43992051e-02f,
  -2.58232020e-02f, 6.15648627e-02f, -4.64509763e-02f, -3.87606844e-02f, 5.39670363e-02f, 1.28371529e-02f, -4.66052778e-02f, 1.66497584e-02f, 6.64166585e-02f, -6.39395937e-02f,
  -7.57579952e-02f, 7.80308768e-02f, 2.16838375e-01f, 1.01885654e-01f, 1.17799990e-01f, 1.71201572e-01f, -1.09365201e-02f, 7.40973279e-02f, 1.69693992e-01f, 9.89200845e-02f,
  6.84528202e-02f, -5.30152433e-02f, 2.23598769e-03f, -7.00172363e-03f, 5.29398164e-03f, -2.26974949e-01f, -3.64671141e-01f, -1.34730980e-01f, 1.89322252e-02f, -3.57971266e-02f,
  1.84971318e-02f, 1.43063053e-01f, 7.06789866e-02f, -5.26736639e-02f, -9.69712958e-02f, -2.06618264e-01f, -1.25758722e-01f, -1.17757246e-01f, -1.64921790e-01f, 1.76302492e-04f,
  -5.31524373e-03f, 9.94391665e-02f, -2.17527095e-02f, 2.19217036e-02f, 1.97620794e-01f, 2.43603941e-02f, 1.68561004e-02f, 1.00752741e-01f, -3.84837091e-02f, 1.08089991e-01f,
  2.87057936e-01f, -9.62382406e-02f, -5.11805974e-02f, -5.68861365e-02f, 1.34506419e-01f, 5.19757112e-03f, 1.75741222e-02f, 5.89104407e-02f, 3.14954016e-03f, -1.86620019e-02f,
  -2.51792241e-02f, 5.00488393e-02f, 8.03790241e-02f, -2.26191431e-02f, 7.59547576e-02f, -5.04472218e-02f, 4.82089780e-02f, -1.18790716e-01f, 1.67373866e-02f, -5.59755340e-02f,
  4.03366014e-02f, -2.31380258e-02f, 4.27168831e-02f, -8.03241879e-02f, -2.49652546e-02f, 7.69037306e-02f, 2.10299771e-02f, 1.37817918e-03f, -1.06449217e-01f, 1.04805678e-02f,
  6.16469458e-02f, 2.73366719e-02f, -8.87088105e-03f, -4.26842272e-02f, -3.68431583e-02f, 6.54515550e-02f, -3.76204066e-02f, -5.07853106e-02f, -1.95898283e-02f, 4.76429313e-02f,
  -4.74531241e-02f, 5.26936864e-03f, 7.10485429e-02f, 3.81450877e-02f, -6.35342207e-03f, -6.65868223e-02f, -1.35250278e-02f, -4.39506136e-02f, 7.51325041e-02f, -2.70302892e-02f,
  2.64710318e-02f, 7.06646889e-02f, 4.78624105e-02f, -3.08359340e-02f, -6.15012310e-02f, -3.34755518e-02f, -5.33353630e-03f, 1.00979796e-02f, 1.66492574e-02f, 5.50689958e-02f,
  8.67248327e-02f, -1.58524901e-01f, 1.33293960e-02f, 7.63161667e-03f, 7.59496763e-02f, 7.55836815e-02f, -1.16888515e-03f, -4.47314344e-02f, 3.53881307e-02f, 5.14787398e-02f,
  2.92439181e-02f, -7.50318989e-02f, 2.17022225e-02f, -1.72725152e-02f, 5.75591810e-02f, -5.87396920e-02f, 4.64185923e-02f, 1.68786291e-02f, 9.15980805e-03f, 7.41645768e-02f,
  -7.84203131e-03f, -9.85370055e-02f, 1.48699246e-02f, -9.77994651e-02f, 1.64727494e-02f, 1.12465117e-02f, 5.05882800e-02f, 8.36158916e-02f, -7.89403617e-02f, -1.02026604e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.11738899e-01f, -1.27773389e-01f, 1.78993478e-01f, 6.03797138e-02f, 4.85812910e-02f, 1.76931009e-01f, 1.15372308e-01f, 1.28060728e-01f, -3.35374214e-02f, 9.27097052e-02f,
  5.80772571e-02f, -8.38177130e-02f, -2.69756746e-02f, 7.10859075e-02f, -7.53093213e-02f, 6.09257445e-02f, -7.20849633e-03f, 8.71875212e-02f, 5.51209971e-02f, -2.74967146e-03f,
  1.38478102e-02f, 7.79939592e-02f, -1.55375164e-03f, -5.67036122e-02f, 1.19312368e-02f, 3.80099341e-02f, 4.60205749e-02f, -8.49368647e-02f, -5.63993677e-02f, -5.64652570e-02f,
  -5.21815158e-02f, 1.14261784e-01f, 7.81934261e-02f, -7.93633685e-02f, 2.61506084e-02f, -1.96200572e-02f, 6.58917129e-02f, -1.09745481e-03f, -3.49128954e-02f, -8.10989887e-02f,
  -7.13465288e-02f, -2.62821354e-02f, -9.98034421e-03f, -1.03058964e-01f, 8.17518234e-02f, 6.49196059e-02f, -7.88426548e-02f, 6.95687160e-02f, -6.49409834e-03f, -1.59997828e-02f,
  -1.87939862e-04f, 5.94618544e-02f, 1.22028910e-01f, -2.18778616e-04f, 2.81644482e-02f, 7.77039081e-02f, 1.20825479e-02f, -5.50060309e-02f, 1.02522552e-01f, 6.98565170e-02f,
  -1.60286129e-02f, 6.62360936e-02f, 9.45218652e-02f, -2.38276869e-02f, -2.65455749e-02f, 8.49666297e-02f, 1.12619651e-02f, 2.42459550e-02f, -3.68476883e-02f, 6.97249696e-02f,
  -3.46058868e-02f, 1.49060702e-02f, -5.48543632e-02f, -5.60517497e-02f, -2.62716617e-02f, 6.08963184e-02f, -5.19017037e-03f, 7.34668002e-02f, -9.46450792e-03f, 2.23003794e-02f,
  2.68872511e-02f, 1.23827897e-01f, 1.82138458e-02f, 4.09938954e-02f, -8.37533828e-03f, 9.70845446e-02f, 9.03109610e-02f, -6.64546806e-03f, 1.25297410e-02f, -3.75949442e-02f,
  -1.06331132e-01f, 2.88573094e-02f, -5.01604229e-02f, 1.57957785e-02f, 1.75091960e-02f, -1.06815599e-01f, 5.74613027e-02f, 1.51668182e-02f, -4.98069637e-02f, 1.08899251e-02f,
  -6.12392426e-02f, 2.61783544e-02f, -5.35766818e-02f, -6.34901747e-02f, 3.11821811e-02f, 2.08119117e-02f, -4.72719111e-02f, 5.82557507e-02f, -1.12325169e-01f, -8.24064687e-02f,
  -2.00950596e-02f, 1.17706805e-01f, 3.01596634e-02f, 9.08612832e-02f, -2.84987409e-02f, -2.36169156e-02f, -1.52349388e-02f, -2.33238861e-02f, 4.79059182e-02f, 2.75301356e-02f,
  1.09599829e-01f, -1.66492149e-01f, 2.66944766e-02f, 4.29685377e-02f, 4.20106947e-02f, -1.87270023e-04f, -7.42352307e-02f, 1.94648914e-02f, 1.78354848e-02f, -6.95842430e-02f,
  -5.17608412e-02f, -3.35181103e-05f, 3.64020839e-02f, -7.79383108e-02f, -3.13160457e-02f, 3.86201404e-02f, -9.81089249e-02f, 1.10277660e-01f, 7.12012798e-02f, 9.51221213e-02f,
  1.80479959e-02f, -5.63631654e-02f, 7.03262910e-02f, -6.38332069e-02f, -4.29486409e-02f, -2.91163661e-02f, -1.06315620e-01f, -8.83321613e-02f, -9.73345637e-02f, -5.26114814e-02f,
  -5.68498969e-02f, -4.36353609e-02f, 9.70202833e-02f, 4.14844602e-02f, 2.99357474e-02f, 5.40503152e-02f, 3.26400697e-02f, -6.41082078e-02f, 6.88228458e-02f, -1.52770542e-02f,
  4.55554537e-02f, -6.03856146e-02f, -8.29656199e-02f, 4.46357727e-02f, 8.54561403e-02f, -1.75948348e-02f, 6.56517744e-02f, 9.97259393e-02f, -3.76714543e-02f, -5.78648746e-02f,
  9.34763066e-03f, 1.49016902e-02f, -2.54416894e-02f, -7.54212886e-02f, 1.88139156e-02f, -7.38409832e-02f, -5.66377379e-02f, 4.93709333e-02f, 9.58587602e-02f, -1.77494008e-02f,
  -5.42228520e-02f, 6.68529794e-02f, -1.82819832e-02f, 9.39291567e-02f, 3.75931971e-02f, -9.35740396e-02f, 4.54018824e-02f, 5.00571132e-02f, -6.62671104e-02f, -2.74971090e-02f,
  -2.63575315e-02f, 4.18150937e-03f, 1.80308595e-02f, 5.55425286e-02f, -9.48020220e-02f, 5.69802634e-02f, 5.40170558e-02f, -2.86835190e-02f, -7.79933110e-02f, -9.01309922e-02f,
  9.80916806e-03f, -2.99499556e-02f, -4.67998199e-02f, -1.28640309e-02f, -1.21798757e-02f, 3.92818153e-02f, -3.34168412e-02f, -1.73234232e-02f, 8.77297595e-02f, -7.23655894e-03f,
  -7.37304464e-02f, -7.76097178e-02f, -1.00727506e-01f, 7.82606602e-02f, -3.36470380e-02f, 4.01158892e-02f, -6.16225302e-02f, 5.32212406e-02f, 5.23731299e-02f, 6.76725134e-02f,
  -7.52897486e-02f, 3.20877954e-02f, -1.10812463e-01f, 4.58770841e-02f, 2.55221617e-03f, -5.55987358e-02f, -7.37210512e-02f, -5.11946343e-02f, -7.67791420e-02f, 4.05578986e-02f,
  -8.68703350e-02f, -7.38877878e-02f, -9.18539613e-02f, -4.70572747e-02f, 7.49262273e-02f, -5.58699435e-03f, -5.72207347e-02f, 7.16388375e-02f, -5.43982945e-02f, -1.08312368e-01f,
  -1.61968112e-01f, 1.36346132e-01f, -6.36912510e-02f, 6.29681796e-02f, 3.51485424e-02f, 6.80202693e-02f, 2.50489693e-02f, 2.68485807e-02f, 5.20096160e-02f, 8.82526711e-02f,
  -6.50005415e-02f, -2.88926121e-02f, -3.62924077e-02f, 1.92736629e-02f, 1.44163547e-02f, -6.64568320e-03f, 4.24938798e-02f, -2.94271614e-02f, -2.82752551e-02f, 6.23006327e-03f,
  4.40043211e-02f, -5.05844653e-02f, -1.03991047e-01f, -1.84128769e-02f, 8.44334140e-02f, 8.24902430e-02f, 8.38712528e-02f, -3.84264775e-02f, 8.58541951e-02f, -3.67184654e-02f,
  -1.23809986e-01f, -1.44311264e-01f, 1.44981686e-02f, 4.67713410e-03f, -6.89959005e-02f, -3.98236252e-02f, 4.86248061e-02f, -8.18814384e-04f, 1.02954850e-01f, 8.56565684e-02f,
  6.56631514e-02f, 7.51065183e-03f, 9.30178761e-02f, 9.44628119e-02f, -5.53798079e-02f, 3.17238681e-02f, -5.33971637e-02f, 6.94322810e-02f, -6.03540801e-03f, -4.09439877e-02f,
  1.16527360e-02f, 2.29308680e-02f, -3.97823099e-03f, -3.63389589e-02f, -6.25886694e-02f, -1.62853599e-02f, 1.30046774e-02f, 9.33838636e-02f, 1.00117341e-01f, -5.75176021e-03f,
  2.70441826e-02f, -2.94954423e-02f, 6.29850384e-03f, -6.85718656e-02f, -6.59394711e-02f, -3.95192020e-03f, -3.95142753e-03f, 3.87905203e-02f, 8.08927044e-02f, 6.14756122e-02f,
  -3.14214570e-03f, 6.05537221e-02f, 4.38683666e-03f, -8.19929019e-02f, 6.30560443e-02f, 4.55939211e-02f, 3.86821851e-02f, 8.29801112e-02f, 2.35148370e-02f, 2.15486865e-02f,
  6.06966913e-02f, 2.18905173e-02f, 4.99535464e-02f, -7.18041556e-04f, 9.39624442e-04f, -4.67367051e-03f, -8.46557543e-02f, -6.09664023e-02f, -6.34898990e-02f, -2.30174325e-02f,
  -2.40337313e-03f, -1.30870610e-01f, 2.03459654e-02f, 8.43459740e-02f, 3.84859294e-02f, 9.80018154e-02f, 6.72501847e-02f, -2.39143483e-02f, 8.63928199e-02f, -1.63401403e-02f,
  -9.45642591e-03f, -2.99504157e-02f, 1.81466236e-03f, 8.86100754e-02f, -2.35088523e-02f, 1.59186721e-02f, 1.09444730e-01f, 4.05009352e-02f, 1.06798701e-01f, 7.09025189e-02f,
  8.88809115e-02f, 1.37044983e-02f, -1.16573758e-02f, 3.64620723e-02f, 9.19284374e-02f, -7.86539167e-02f, 4.56950329e-02f, 7.07538947e-02f, 5.62546514e-02f, 3.30549702e-02f,
  1.21577764e-02f, -9.06518325e-02f, -6.81733638e-02f, -1.16263200e-02f, -7.17778280e-02f, -4.53744084e-02f, -1.02388315e-01f, -4.24860753e-02f, 1.09572886e-02f, -3.90967503e-02f,
  5.29573932e-02f, -7.73730502e-02f, -1.63446106e-02f, -3.21237482e-02f, 2.92947497e-02f, 1.75050162e-02f, 6.52231202e-02f, 3.38028967e-02f, -3.07592060e-02f, 8.28722939e-02f,
  6.45535886e-02f, -3.20479237e-02f, 1.73325334e-02f, -2.31101345e-02f, -5.08200936e-02f, 7.36549795e-02f, 2.93134060e-02f, -4.52464670e-02f, -2.23921333e-03f, 9.77955759e-02f,
  -5.53065762e-02f, -5.99789480e-03f, -5.60570061e-02f, 4.71522175e-02f, -1.26088364e-02f, -3.20773609e-02f, -7.70133510e-02f, 6.54840171e-02f, -3.02741099e-02f, 6.20071255e-02f,
  -8.14372748e-02f, -8.63397419e-02f, 9.80974510e-02f, 6.28664419e-02f, -1.60936732e-02f, -9.78093818e-02f, 3.31044197e-02f, -2.20024828e-02f, -1.51699213e-02f, -9.97938812e-02f,
  -5.89419231e-02f, -3.06430589e-02f, 6.83550388e-02f, -6.04241192e-02f, 1.49632590e-02f, 6.66587651e-02f, 1.18608475e-02f, -6.41528866e-04f, -7.61797652e-02f, 5.52158169e-02f,
  3.99910137e-02f, 4.09018099e-02f, -5.43281324e-02f, -5.02942652e-02f, -9.03609172e-02f, 8.76476690e-02f, 9.10341591e-02f, -7.69528821e-02f, -1.12579446e-02f, 2.07109153e-02f,
  -3.95172872e-02f, -2.50317939e-02f, 1.09790573e-02f, -6.91806972e-02f, -7.26713240e-02f, 1.52033754e-02f, -6.91252500e-02f, 3.51396278e-02f, 4.46667112e-02f, 2.53966060e-02f,
  -5.02908118e-02f, -1.40271904e-02f, -6.58147037e-02f, -3.62076089e-02f, -3.59191261e-02f, -2.66589876e-03f, 5.39844576e-03f, 7.15054870e-02f, 4.27857675e-02f, -3.21275331e-02f,
  7.20794797e-02f, 8.77183005e-02f, 2.56598331e-02f, -6.58929572e-02f, 4.05268334e-02f, -1.24280481e-02f, 3.00792567e-02f, 2.47585438e-02f, -9.90589242e-03f, -8.12982768e-03f,
  7.54879117e-02f, -8.27985853e-02f, -7.18654022e-02f, -3.75832021e-02f, -6.18478507e-02f, 7.71285146e-02f, 4.22455259e-02f, 1.20139616e-02f, 2.80178506e-02f, -7.64937624e-02f,
  2.53033880e-02f, -7.51760304e-02f, 2.40060985e-02f, 6.42583147e-02f, 5.39261997e-02f, -2.11213017e-03f, 1.38225220e-02f, 9.80054513e-02f, 9.52681154e-02f, -9.01630819e-02f,
  8.31132475e-03f, 1.08211473e-01f, 1.28515482e-01f, -4.41371091e-02f, -6.24681786e-02f, 1.01886652e-01f, 1.15560889e-01f, 7.03225955e-02f, 4.10463624e-02f, -1.30059551e-02f,
  1.06386758e-01f, 3.55981104e-02f, 2.73192264e-02f, 4.57115695e-02f, -6.10468946e-02f, -8.81917849e-02f, -8.83661360e-02f, 7.41133392e-02f, 9.11754519e-02f, -7.30591118e-02f,
  -6.91897571e-02f, 7.46955350e-02f, -7.17337653e-02f, 6.58830553e-02f, -6.41860887e-02f, -1.31481975e-01f, 1.03101693e-02f, 8.18728060e-02f, -5.85386045e-02f, -1.61859706e-01f,
  -4.04407792e-02f, 5.41225038e-02f, -8.83561596e-02f, 4.73259464e-02f, 3.21318619e-02f, -3.79531868e-02f, -7.65608028e-02f, -4.33511660e-02f, 7.71072581e-02f, 4.67400476e-02f,
  9.37029719e-02f, 3.89069021e-02f, 4.98007331e-03f, -8.90981988e-04f, -1.87655780e-02f, 6.52275458e-02f, 1.23972036e-01f, 1.01525500e-01f, 6.55630380e-02f, 6.91257068e-04f,
  3.52484669e-04f, 7.22362250e-02f, 1.00316375e-01f, 1.04338489e-01f, 1.29830614e-01f, 5.79796396e-02f, 1.13837034e-01f, -2.88644223e-03f, 6.84973970e-02f, -4.45070816e-03f,
  1.86442174e-02f, -1.62365399e-02f, -6.54627085e-02f, 3.95899154e-02f, 7.50528574e-02f, -4.47292365e-02f, -5.04341386e-02f, -5.94329722e-02f, -1.13918772e-02f, 5.95263671e-04f,
  5.12762787e-03f, 7.16579333e-02f, -3.50354612e-02f, -5.66822179e-02f, -9.28895175e-02f, -5.20015918e-02f, 7.56059214e-02f, 1.14295390e-02f, 8.88604298e-02f, 7.82148466e-02f,
  -5.69785200e-03f, 8.77465531e-02f, 5.76232523e-02f, 3.57749276e-02f, 6.61467612e-02f, -7.51233920e-02f, 4.35729362e-02f, 4.20705564e-02f, 6.30064085e-02f, -5.14964871e-02f,
  2.59731691e-02f, 4.68914472e-02f, -1.43527435e-02f, 1.00672860e-02f, -4.30368297e-02f, 5.14957197e-02f, -5.68905286e-02f, -2.97197029e-02f, 4.07692790e-02f, -8.09949562e-02f,
  7.90437907e-02f, -4.21944559e-02f, -3.40035409e-02f, -2.29557883e-02f, -7.15799183e-02f, -7.47529119e-02f, -2.27866787e-02f, -6.36427552e-02f, -1.57028381e-02f, -7.34877735e-02f,
  -5.45648001e-02f, -6.16121385e-03f, -8.57826844e-02f, -6.61591440e-02f, -4.49816212e-02f, -5.17082699e-02f, -4.98987585e-02f, -8.47961940e-03f, 3.20083685e-02f, -1.25842154e-01f,
  3.33967894e-01f, 1.58612449e-02f, -1.11834966e-01f, 1.33178577e-01f, -2.48417095e-03f, 8.55338126e-02f, -1.62759610e-03f, 5.67122363e-02f, -1.17472140e-02f, -2.74403263e-02f,
  1.55791938e-01f, 4.68198732e-02f, 1.27773717e-01f, -4.21834067e-02f, -1.99651495e-02f, 3.23799392e-03f, -7.50497133e-02f, -5.58239035e-02f, 3.59198963e-03f, 5.51941395e-02f,
  5.34050465e-02f, -4.54758964e-02f, -5.80201745e-02f, 7.04163909e-02f, -1.15185462e-01f, 2.55196597e-02f, -1.72230545e-02f, -3.96089442e-02f, -1.39961928e-01f, -1.93283513e-01f,
  -1.50209993e-01f, 1.73774004e-01f, 6.45778924e-02f, 8.76806378e-02f, -8.40665326e-02f, 8.02183449e-02f, 5.93387336e-02f, 3.22405472e-02f, 6.00527935e-02f, 5.73674478e-02f,
  1.70595909e-03f, 5.27605750e-02f, -4.68404181e-02f, -2.41872165e-02f, 3.68002914e-02f, 1.82554517e-02f, 2.40930617e-02f, 9.26689885e-04f, 2.82531008e-02f, 5.69348186e-02f,
  -8.57138485e-02f, -1.56119168e-02f, 7.24733174e-02f, -5.00108711e-02f, -2.46235020e-02f, -6.09640516e-02f, 2.80799214e-02f, 7.40293935e-02f, 4.99235727e-02f, -6.92087710e-02f,
  3.43114026e-02f, 1.18885357e-02f, -5.80826402e-02f, 5.02266269e-03f, -4.57648858e-02f, 1.15535622e-02f, 9.25514847e-04f, -2.64670271e-02f, 5.73530272e-02f, 6.47509843e-02f,
  2.42141634e-02f, 7.10736215e-02f, -4.09077592e-02f, 3.19773890e-02f, -6.26377240e-02f, -1.46588879e-02f, -6.78217411e-02f, 7.46217743e-02f, -4.67501506e-02f, 3.24280150e-02f,
  2.77315509e-02f, -1.65922102e-02f, -7.58484453e-02f, -1.06197640e-01f, 2.40596011e-02f, -4.23958041e-02f, 5.85870333e-02f, 1.36126289e-02f, 5.63691743e-03f, -6.31751046e-02f,
  -3.84142473e-02f, 2.70095170e-02f, -6.29525557e-02f, 7.13256299e-02f, -4.19556089e-02f, -6.95491508e-02f, 4.01932634e-02f, -1.40011907e-02f, -1.05189696e-01f, 3.22617665e-02f,
  5.72404191e-02f, -5.48839336e-03f, 7.26148263e-02f, -6.01266436e-02f, -2.85635907e-02f, 7.53220683e-03f, -4.43611704e-02f, 8.46238956e-02f, -6.72388449e-02f, 1.92149896e-02f,
  3.42959026e-03f, 1.65916998e-02f, 9.30799246e-02f, 8.28044116e-02f, 3.21091246e-03f, 1.28342554e-01f, -2.76453216e-02f, 5.02307191e-02f, -4.10381481e-02f, -5.55245467e-02f,
  -1.73359007e-01f, 3.29598002e-02f, 8.18256568e-03f, 2.67864335e-02f, 1.17048547e-01f, 3.67916673e-02f, -1.51020223e-02f, 2.83637624e-02f, -7.39778727e-02f, 8.06108117e-02f,
  -2.89372001e-02f, -1.36953732e-02f, 8.21999833e-03f, -4.30603400e-02f, 1.26529345e-02f, 5.16161742e-03f, -3.19488682e-02f, -2.97248345e-02f, -8.92817080e-02f, 5.13559841e-02f,
  1.28776580e-01f, 1.98037475e-02f, 2.57720314e-02f, 5.19846715e-02f, 3.52324955e-02f, 7.93751404e-02f, 5.27328514e-02f, 1.14570498e-01f, 7.33223334e-02f, 1.64589956e-01f,
  6.54392168e-02f, -6.55813217e-02f, -8.00413266e-03f, 2.81947087e-02f, -8.87276456e-02f, -3.59699614e-02f, -5.77383861e-02f, 6.49252813e-03f, -1.18319385e-01f, -6.90250844e-02f,
  9.26829800e-02f, -1.04976706e-01f, -6.49712086e-02f, -7.62691721e-02f, -3.04181483e-02f, 2.17610244e-02f, -2.97719873e-02f, -1.09163165e-01f, -9.73930061e-02f, -1.33082017e-01f,
  -1.93031523e-02f, -5.45397960e-02f, -4.50983383e-02f, -5.91639150e-03f, -5.45536838e-02f, 2.69804779e-03f, -3.48878913e-02f, -1.28717765e-01f, -3.86284515e-02f, 2.70287180e-03f,
  -5.13353013e-02f, -7.27013126e-02f, -1.35844881e-02f, -7.74128512e-02f, -6.23095408e-02f, 6.01442829e-02f, 1.94563195e-02f, 4.44781221e-02f, -6.24405034e-02f, -2.92996708e-02f,
  -1.09946944e-01f, -5.46987616e-02f, -6.00287504e-02f, -2.69176494e-02f, -5.47353597e-03f, -2.96453163e-02f, -3.92371230e-02f, 5.63688874e-02f, -4.79126498e-02f, -4.89455238e-02f,
  -3.05496491e-02f, -1.72169693e-02f, 9.14209262e-02f, 1.56213827e-02f, 7.56050572e-02f, -9.27170087e-03f, 5.05786687e-02f, -1.00656353e-01f, -5.99132814e-02f, 8.22506621e-02f,
  6.41594157e-02f, 2.51768436e-02f, -5.91463745e-02f, 3.48381773e-02f, 9.48960111e-02f, -5.17557301e-02f, -1.85356960e-02f, -1.12680793e-01f, 1.43485051e-02f, -4.63710912e-02f,
  -9.03089494e-02f, 7.30853574e-03f, -1.51680608e-03f, -2.62806788e-02f, -4.75654677e-02f, -1.17560089e-01f, 1.55485002e-02f, 1.36550898e-02f, -4.70977426e-02f, -1.33902103e-01f,
  -3.37551273e-02f, -1.17988005e-01f, -1.44078255e-01f, -5.75991385e-02f, -7.08769774e-03f, -6.36283234e-02f, 5.62416529e-03f, 3.79814766e-02f, -1.05330683e-01f, -7.21312612e-02f,
  -3.14104371e-02f, 1.28311574e-01f, 9.83861387e-02f, 1.42392404e-02f, -3.43243517e-02f, 1.14017323e-01f, 1.32381737e-01f, 2.08264291e-02f, 1.47917690e-02f, 1.24501772e-01f,
  -5.28177544e-02f, -2.24573240e-02f, 1.28362820e-01f, -9.30082705e-03f, 1.44682005e-01f, 5.56290001e-02f, 2.88506225e-02f, 7.12733790e-02f, -2.96496823e-02f, 8.03214125e-03f,
  8.57927799e-02f, 4.21417784e-03f, 9.52618849e-03f, 9.00650397e-03f, 8.99285972e-02f, -4.77791298e-03f, 5.20535111e-02f, 6.85416758e-02f, 1.18544102e-01f, 1.28340334e-01f,
  -1.17310040e-01f, -6.21987358e-02f, -6.37092115e-03f, -6.86157718e-02f, -1.03302434e-01f, 3.61181539e-03f, -7.72125646e-02f, 2.12259218e-03f, 1.65618944e-03f, 8.58806148e-02f,
  3.61065492e-02f, -3.23506743e-02f, 6.72521219e-02f, 4.01442312e-02f, -5.75284883e-02f, -2.77277902e-02f, -5.24816141e-02f, 6.95632622e-02f, -4.00399342e-02f, 5.46776429e-02f,
  -4.61912490e-02f, -5.40319085e-02f, 3.67462225e-02f, -4.52978685e-02f, 1.09014891e-01f, 3.05676460e-02f, 2.09023543e-02f, 4.78406996e-02f, -8.76493305e-02f, -3.70240845e-02f,
  6.99765831e-02f, -3.21758837e-02f, -3.42221707e-02f, 4.19470407e-02f, -7.78522715e-02f, -6.59525394e-02f, 4.99955527e-02f, -5.66919148e-02f, 3.16590406e-02f, -4.04898375e-02f,
  -6.50593713e-02f, -8.20881873e-03f, 1.48062911e-02f, 3.85550484e-02f, 1.19003057e-02f, 6.12432733e-02f, -2.17289068e-02f, -2.72150412e-02f, -4.06555161e-02f, 5.41515909e-02f,
  -6.48603542e-03f, 4.17997465e-02f, 2.88671069e-02f, -1.43825763e-03f, -9.46464986e-02f, -8.09621885e-02f, 4.42913771e-02f, -9.63061675e-02f, 5.70081472e-02f, 2.97826789e-02f,
  1.01323491e-02f, -5.48140891e-02f, 9.08690467e-02f, 1.36471111e-02f, -4.76727821e-02f, 4.04300578e-02f, -1.11141186e-02f, -1.50336400e-02f, -7.02054566e-03f, 7.62799606e-02f,
  -3.45904380e-02f, -4.02870541e-03f, -6.15668669e-02f, 7.61032775e-02f, -3.86143364e-02f, -1.00031175e-01f, 5.46794385e-02f, 5.45041636e-02f, -3.24430317e-02f, 8.05224478e-02f,
  1.21277489e-03f, 2.35362956e-03f, -8.84413868e-02f, -1.04683740e-02f, 3.61555070e-02f, -7.93498158e-02f, -7.29160383e-02f, 1.60402700e-03f, -6.85245544e-02f, 9.32044629e-03f,
  3.67495194e-02f, 2.59476602e-02f, 9.29200798e-02f, 4.59361486e-02f, 6.26675645e-03f, -2.81919204e-02f, -5.95204644e-02f, -2.79176440e-02f, 3.86828855e-02f, -5.11001097e-03f,
  -3.99950370e-02f, 2.35979296e-02f, -1.00590087e-01f, -8.22673514e-02f, -3.76031697e-02f, 3.52749676e-02f, -1.12034410e-01f, -1.09664192e-02f, 8.63891281e-03f, 4.89985570e-02f,
  3.89454030e-02f, 3.94811854e-03f, -4.07003425e-02f, -8.16321000e-02f, 5.24264947e-02f, -1.21414766e-01f, -8.49573985e-02f, 3.30330245e-02f, -5.20318151e-02f, 5.05157858e-02f,
  5.15835099e-02f, 3.50002362e-03f, -3.15902680e-02f, -1.78533662e-02f, -1.92782730e-02f, -2.18125153e-02f, -8.16952437e-02f, 5.39876241e-03f, -7.15733841e-02f, 3.98955531e-02f,
  -4.78257127e-02f, 3.98731492e-02f, 2.72845272e-02f, 6.81037754e-02f, 9.96320322e-02f, 8.35726410e-02f, 8.66692439e-02f, 2.20575952e-03f, 5.00308871e-02f, 9.58158448e-02f,
  6.60717934e-02f, -3.42544913e-02f, 8.38792995e-02f, 4.00302894e-02f, 9.68087539e-02f, -2.75239851e-02f, -2.88962238e-02f, -5.76433055e-02f, -3.89587060e-02f, -3.57961431e-02f,
  4.84902374e-02f, -6.04461357e-02f, 4.64080786e-03f, -3.18938680e-02f, -2.34447680e-02f, -5.03065661e-02f, -8.60873610e-03f, 6.68889135e-02f, 4.59164977e-02f, 3.49480435e-02f,
  1.45796547e-02f, 6.50863275e-02f, -1.84054989e-02f, 6.42896816e-02f, 9.00345668e-02f, -5.09620793e-02f, 8.44267160e-02f, -7.12386370e-02f, 4.12758961e-02f, -1.62124280e-02f,
  -1.62140913e-02f, 5.38175404e-02f, 9.23574120e-02f, -9.78964195e-03f, -6.26911372e-02f, -5.97240664e-02f, 3.21562067e-02f, -5.71530946e-02f, 6.12327941e-02f, 9.37337577e-02f,
  -1.21410914e-01f, 7.61428550e-02f, -4.52495329e-02f, -9.41101313e-02f, 6.11868426e-02f, -4.31019850e-02f, 6.74141049e-02f, 4.72124070e-02f, -6.01636544e-02f, 8.82483050e-02f,
  1.04347140e-01f, 3.05591058e-03f, -5.90379760e-02f, 8.59675705e-02f, -9.44055431e-03f, 6.11982159e-02f, 2.17309576e-02f, -6.49261922e-02f, -2.38166675e-02f, 8.90427455e-03f,
  4.42825779e-02f, -2.60593779e-02f, 4.60237153e-02f, -2.16212031e-03f, 1.84888747e-02f, 1.22790039e-02f, -1.02917112e-01f, -9.28304270e-02f, 5.00352755e-02f, -8.78895074e-02f,
  2.60157317e-01f, 2.80358702e-01f, 1.34154081e-01f, 1.23223819e-01f, 1.28418609e-01f, 2.21360236e-01f, 1.44958183e-01f, 2.22894922e-01f, 5.56425080e-02f, 2.26125598e-01f,
  8.84579644e-02f, 1.02787793e-01f, 6.39081225e-02f, 1.97455928e-01f, 8.42832625e-02f, 1.94451988e-01f, 1.29875347e-01f, 1.07342139e-01f, 6.75994307e-02f, 2.33685263e-02f,
  3.49305496e-02f, 1.21140055e-01f, -1.67110842e-02f, 1.27417058e-01f, 6.59894422e-02f, 9.70253646e-02f, 1.32857980e-02f, 9.61013883e-02f, 5.47558777e-02f, 2.46083979e-02f,
  4.99278270e-02f, 2.05650061e-01f, -7.85760209e-02f, -5.61584905e-02f, -1.19708836e-01f, -4.83334064e-02f, -4.46405411e-02f, 1.34237530e-02f, -4.89565544e-03f, 3.87761258e-02f,
  -1.32156953e-01f, -2.31838487e-02f, 7.56078139e-02f, -9.61953104e-02f, -7.48368958e-03f, 4.29472588e-02f, 1.50745232e-02f, 1.14770137e-01f, 2.82608047e-02f, 6.33808896e-02f,
  -3.20733786e-02f, -4.19151373e-02f, -6.09585494e-02f, -1.37095237e-02f, 3.14367563e-02f, -6.40192404e-02f, 9.08102840e-02f, 2.81700976e-02f, -5.36660552e-02f, 8.83205608e-02f,
  -8.41388032e-02f, 4.55613695e-02f, 2.92406306e-02f, 8.42399895e-03f, 3.28761227e-02f, -1.26024999e-03f, 9.26072430e-03f, -4.19452563e-02f, 3.70261855e-02f, -2.80788951e-02f,
  -8.96167289e-03f, 9.17492434e-03f, 4.99637835e-02f, -1.02091441e-02f, -4.10855487e-02f, 6.60498440e-03f, 3.78098339e-02f, 6.38932139e-02f, -6.00655042e-02f, 4.38145250e-02f,
  3.58372144e-02f, -1.26067186e-02f, -5.17198928e-02f, 2.70131342e-02f, 5.59311211e-02f, -3.12019810e-02f, 1.96766052e-02f, -7.42620975e-02f, -6.92470744e-02f, -4.86715809e-02f,
  -6.36923406e-03f, -2.14928687e-02f, 6.56061545e-02f, -1.49671575e-02f, -2.33987067e-02f, -6.58261180e-02f, 8.67689103e-02f, -1.42938301e-01f, -4.02966850e-02f, 1.27414437e-02f,
  -2.28630286e-02f, 1.08105883e-01f, -4.53797989e-02f, -8.70935693e-02f, -8.05466250e-02f, -3.13691162e-02f, -7.34711997e-03f, 5.39924316e-02f, 6.58214884e-03f, 4.87232767e-03f,
  5.41367419e-02f, -1.06876895e-01f, -5.74901253e-02f, -1.05637074e-01f, 2.48064492e-02f, -1.33731037e-01f, -9.84998420e-02f, -6.02015257e-02f, -1.08953059e-01f, -1.41453758e-01f,
  1.69123281e-02f, -2.49900937e-01f, -4.23888326e-01f, -1.65019944e-01f, -7.37949610e-02f, -4.52116728e-02f, -1.06139600e-01f, 9.43021011e-03f, -7.54618198e-02f, -1.50946721e-01f,
  -1.46895826e-01f, -3.28309983e-02f, -1.84072666e-02f, 8.17040578e-02f, 1.28631964e-01f, -2.34067932e-01f, -2.06368417e-01f, 2.35882308e-02f, 1.22870900e-01f, 1.31838962e-01f,
  6.04842976e-02f, -8.86332616e-02f, 1.71889248e-03f, 4.92123552e-02f, -7.09251612e-02f, -1.65118188e-01f, -3.06179762e-01f, -1.48734570e-01f, -1.24050871e-01f, -1.63803101e-01f,
  -2.60415375e-01f, 7.27364374e-03f, 7.45665506e-02f, 8.02472234e-02f, -4.39316109e-02f, 7.62504414e-02f, -1.00543834e-01f, 4.32687812e-02f, -4.76160645e-02f, -1.07716307e-01f,
  2.80951671e-02f, 7.14508817e-02f, -1.49510521e-02f, -3.24635953e-02f, 6.18967563e-02f, 7.87443593e-02f, -5.25497347e-02f, 1.53353512e-02f, 2.29546819e-02f, 5.56150079e-03f,
  5.32823391e-02f, -4.90665622e-02f, 1.61124207e-02f, 2.16565076e-02f, 2.30843481e-02f, -5.06505668e-02f, -5.94136976e-02f, 8.27502236e-02f, 4.61718701e-02f, -9.88290980e-02f,
  4.22399044e-02f, -1.46386365e-03f, 3.72891426e-02f, -1.67066639e-03f, 3.57831679e-02f, -1.03985362e-01f, 9.38593782e-03f, 6.16543461e-04f, 1.71027482e-02f, 3.83277349e-02f,
  -8.29553306e-02f, -3.57450843e-02f, 2.26123556e-02f, 9.10574663e-03f, 5.25441486e-03f, -1.12048477e-01f, 7.17484131e-02f, 3.13301641e-03f, 5.27896099e-02f, 2.72362530e-02f,
  1.77363474e-02f, -3.94809209e-02f, -6.70013949e-02f, 2.41828170e-02f, 5.46706356e-02f, -3.17473821e-02f, -4.40540798e-02f, 6.39504045e-02f, -3.79560515e-02f, 7.58168176e-02f,
  -1.21634409e-01f, 8.63165930e-02f, -1.16547845e-01f, 1.44852266e-01f, -4.03461605e-03f, -3.64616886e-02f, -5.63200749e-02f, -8.30356926e-02f, -8.08741450e-02f, -5.80130853e-02f,
  1.04137667e-01f, -7.51174521e-03f, -7.53170401e-02f, 2.24930272e-02f, 4.34416858e-03f, 9.74890813e-02f, 6.57589361e-02f, -1.07768893e-01f, 8.18093494e-02f, -3.14305313e-02f,
  -5.21699898e-02f, 1.96508877e-02f, 7.85561558e-03f, 2.84446273e-02f, 9.69392359e-02f, 9.08315703e-02f, -1.97029859e-02f, -7.21485615e-02f, 9.31474045e-02f, -9.08087194e-02f,
  8.15081224e-02f, -2.43342035e-02f, 1.80516154e-01f, -1.96684729e-02f, -1.13184005e-01f, -2.67310739e-01f, -2.99156547e-01f, -1.68180957e-01f, -6.01402409e-02f, 2.61820406e-02f,
  -1.00687578e-01f, 4.75440960e-04f, 1.07237697e-01f, 1.32651478e-01f, 5.48854396e-02f, 2.70211827e-02f, -7.98165519e-03f, 2.41907552e-01f, 1.83097258e-01f, 7.74346739e-02f,
  -1.97768994e-02f, 6.14853092e-02f, 1.76939964e-01f, 1.77150425e-02f, -9.69527941e-03f, 3.88071947e-02f, 6.44791275e-02f, 3.37530188e-02f, 5.54086342e-02f, 1.45279378e-01f,
  9.77698639e-02f, 1.34352753e-02f, 6.59600645e-02f, 1.33668199e-01f, 5.41069126e-03f, 9.06509086e-02f, 8.94964263e-02f, 1.02691285e-01f, -2.09400356e-02f, 9.09964144e-02f,
  -3.19488905e-02f, 2.59829350e-02f, -6.72071800e-02f, 6.73883259e-02f, -8.29913393e-02f, -3.95002328e-02f, 1.19510204e-01f, 1.63422361e-01f, 6.94419816e-02f, -1.84066463e-02f,
  4.07205559e-02f, -6.31185323e-02f, 2.61136591e-02f, -3.86962332e-02f, 3.06657963e-02f, 1.77246518e-02f, -9.35737565e-02f, -3.97375301e-02f, 4.26159054e-02f, -3.67866941e-02f,
  -8.81960895e-03f, -5.78749878e-03f, 4.73045930e-03f, -3.34403887e-02f, -7.03189597e-02f, -5.03626578e-02f, 2.64764074e-02f, -6.54584095e-02f, -1.86644029e-03f, -2.20556762e-02f,
  4.32067886e-02f, 1.07637718e-02f, -6.45561665e-02f, -1.09465243e-02f, -1.05902413e-02f, -3.94576713e-02f, -5.44400439e-02f, 1.31041734e-02f, 1.57976393e-02f, -1.62247103e-02f,
  1.66417435e-02f, 1.13897547e-02f, 4.99497131e-02f, -4.27763052e-02f, 7.50076026e-02f, 5.40980175e-02f, 9.26995575e-02f, -3.59495841e-02f, 3.52619924e-02f, -5.90952225e-02f,
  -1.21885739e-01f, 9.66174230e-02f, -2.75565945e-02f, 1.12721495e-01f, -6.18602782e-02f, 7.67856836e-03f, 6.20507821e-02f, 6.60691932e-02f, 6.08729199e-02f, -4.60401364e-02f,
  -1.00550674e-01f, 6.27474114e-02f, -4.88090701e-02f, -7.41568254e-03f, -7.68900737e-02f, 3.75882760e-02f, -2.20967177e-03f, 8.44563544e-02f, 5.83081879e-02f, -1.88871715e-02f,
  -5.25176413e-02f, -1.22411601e-01f, -1.04320208e-02f, -1.05687037e-01f, 2.39580125e-02f, 3.61850969e-02f, -1.84627920e-02f, 6.17959769e-03f, -5.09550385e-02f, -7.38788322e-02f,
  2.03190725e-02f, -2.41744056e-01f, 8.50090012e-03f, 1.69366710e-02f, 1.38491631e-01f, 6.19184179e-03f, 1.28416136e-01f, 6.39909282e-02f, 1.31669221e-02f, -1.09025635e-01f,
  -9.07177627e-02f, -1.16826901e-02f, -1.47863790e-01f, -1.05568931e-01f, 1.52610075e-02f, -1.96648799e-02f, 1.89143401e-02f, -7.27631748e-02f, 1.06838822e-01f, 5.02975471e-02f,
  4.19034697e-02f, 6.73896447e-02f, 5.82870021e-02f, 3.89469340e-02f, -7.74510726e-02f, -7.26867989e-02f, -7.53134936e-02f, 1.33470669e-02f, -4.06252854e-02f, -7.39959478e-02f,
  8.17817301e-02f, -9.67331678e-02f, 5.49086146e-02f, 4.08501662e-02f, 4.43234593e-02f, -4.91492264e-02f, -1.08242827e-02f, 7.15821534e-02f, -1.00508682e-01f, 2.18973830e-02f,
  -7.51690939e-02f, 7.64302257e-03f, 2.32902747e-02f, 7.83325583e-02f, -2.62884405e-02f, -5.13859838e-02f, -1.65637285e-02f, -4.38450761e-02f, -2.15511993e-02f, -5.83420321e-02f,
  -2.36564083e-03f, 5.92063405e-02f, 4.69667241e-02f, 4.10295976e-03f, -3.58043984e-02f, -4.50122766e-02f, 4.73494679e-02f, 5.30867055e-02f, -6.54888898e-02f, -4.92993258e-02f,
  -2.74658315e-02f, -2.40372382e-02f, 8.38277191e-02f, -7.93529451e-02f, 5.76730072e-02f, 1.78495422e-02f, -7.04888161e-03f, -1.04182782e-02f, 6.11205213e-02f, -1.29466653e-02f,
  -8.35977793e-02f, -5.16192280e-02f, -1.13450643e-03f, -8.45945179e-02f, -7.71423206e-02f, 7.67851919e-02f, 6.66713417e-02f, 3.53195779e-02f, -8.09841156e-02f, -4.03271206e-02f,
  -1.14899566e-02f, 6.05123639e-02f, -3.77218015e-02f, -7.66830370e-02f, -1.13665275e-01f, 6.85674176e-02f, 3.69459689e-02f, -6.57127798e-02f, -1.22294053e-02f, -7.89849386e-02f,
  -1.77526511e-02f, 2.30175853e-02f, 9.02435184e-02f, -8.72840360e-03f, 6.61301464e-02f, -3.34509723e-02f, 2.24088021e-02f, -6.59323297e-03f, -5.82499839e-02f, 1.97870322e-02f,
  -1.98051594e-02f, 6.04894497e-02f, 1.34275863e-02f, -6.02481328e-02f, 2.09694705e-03f, -2.82640830e-02f, -4.29634303e-02f, -2.39964407e-02f, 3.87271494e-02f, -6.41691834e-02f,
  1.96863860e-02f, 1.38116684e-02f, 1.20678499e-01f, -5.64552322e-02f, -9.96901095e-03f, 9.69687030e-02f, 1.07274503e-02f, 1.02431640e-01f, -4.36169244e-02f, 1.31566644e-01f,
  3.16500501e-03f, 4.95931432e-02f, -1.15120709e-01f, -1.98677018e-01f, -9.15296152e-02f, -1.87003158e-03f, 9.86579731e-02f, 8.49002451e-02f, -7.70825818e-02f, 7.48554617e-02f,
  9.84086171e-02f, -1.04725763e-01f, -6.43793866e-03f, -4.36404645e-02f, 4.77242866e-04f, -5.54609746e-02f, -9.31563452e-02f, -1.23258447e-02f, -5.35380803e-02f, 5.82980923e-02f,
  -3.61436196e-02f, -1.23263448e-01f, 8.58250912e-03f, -7.12601095e-02f, -1.40372977e-01f, -1.55439660e-01f, -7.73545876e-02f, -1.28106579e-01f, -3.77998222e-03f, -3.57363150e-02f,
  -4.71823178e-02f, -6.52804272e-03f, -5.89727797e-02f, 7.98705295e-02f, 1.52350860e-02f, -7.62579516e-02f, 7.78280348e-02f, -2.32736692e-02f, 6.14784323e-02f, 1.10051418e-02f,
  -3.85454744e-02f, 4.09988221e-03f, -6.72909915e-02f, -1.83200743e-02f, 2.98846643e-02f, 3.62912640e-02f, -3.86566222e-02f, -9.14738998e-02f, 3.84447649e-02f, 7.18448823e-03f,
  8.46254751e-02f, 4.48727468e-03f, -1.14462944e-02f, -9.46393386e-02f, -8.33293945e-02f, 3.56205739e-02f, -8.96948203e-02f, -3.68171073e-02f, -5.17916270e-02f, -2.04526447e-02f,
  7.63777597e-03f, -8.88852850e-02f, -6.43726205e-03f, 3.14215459e-02f, -2.27266029e-02f, 2.96260393e-03f, -4.64844070e-02f, -2.32249647e-02f, 7.37392455e-02f, -1.46762319e-02f,
  -4.22100537e-02f, -6.81314096e-02f, -1.68038171e-03f, -8.83689299e-02f, -5.12883887e-02f, 2.60741822e-02f, 9.80314314e-02f, 1.68733280e-02f, 7.35520124e-02f, -4.49519008e-02f,
  -7.86908194e-02f, 7.10027814e-02f, -3.62023339e-02f, -1.11279320e-02f, -1.98431239e-02f, -1.26061160e-02f, 5.55852316e-02f, -1.25461891e-02f, -6.25910610e-02f, 4.70938422e-02f,
  -1.96928263e-01f, 1.24984197e-02f, 4.43709604e-02f, -5.78043312e-02f, -9.83066112e-02f, -1.10621443e-02f, -8.91920105e-02f, 7.84400254e-02f, -8.99106935e-02f, 7.33728567e-03f,
  5.06719127e-02f, -1.74707882e-02f, -7.05827251e-02f, 1.46461139e-02f, -4.86016683e-02f, -4.97857817e-02f, 9.12962575e-03f, 1.18517959e-02f, 8.62660483e-02f, 7.10345879e-02f,
  -3.17430384e-02f, -7.61489645e-02f, -5.98953851e-02f, -3.74639481e-02f, -6.76291436e-02f, -1.81085169e-02f, -3.54521722e-02f, 6.09541032e-03f, -9.47959423e-02f, -7.22770244e-02f,
  -6.42747059e-02f, -5.06785419e-03f, 1.28690064e-01f, -1.01406232e-01f, -1.07036009e-01f, -8.77119452e-02f, -1.77708358e-01f, -2.56790873e-03f, -4.90028560e-02f, -1.57878995e-01f,
  -6.90770000e-02f, -3.21143605e-02f, -3.99447195e-02f, 2.09585894e-02f, -3.63064222e-02f, -1.00992709e-01f, 7.38949850e-02f, 2.77498458e-02f, 6.43095598e-02f, -1.47023812e-01f,
  -1.66570798e-01f, -6.99552000e-02f, -2.86040064e-02f, -5.14864028e-02f, 2.31484268e-02f, -1.04540490e-01f, 4.50545624e-02f, -1.64785255e-02f, -3.82878073e-02f, -5.18747009e-02f,
  -2.78288424e-02f, 4.17175926e-02f, 1.12322308e-02f, 2.29525343e-02f, 1.61120556e-02f, 5.56746237e-02f, -1.82207637e-02f, 9.93541926e-02f, 5.70958965e-02f, -9.19438154e-02f,
  -6.66564032e-02f, -1.11853436e-01f, 7.96817020e-02f, -4.57395464e-02f, 3.05729061e-02f, -1.04701839e-01f, 3.29377735e-03f, 2.76844925e-03f, 8.80107582e-02f, 7.09372833e-02f,
  -1.03070602e-01f, 3.18214074e-02f, 8.98943692e-02f, 8.47288817e-02f, 2.22891141e-02f, 1.22255627e-02f, 6.74422160e-02f, -7.71675119e-03f, 4.49084789e-02f, -1.53461963e-01f,
  -4.26127650e-02f, 8.91382769e-02f, -1.49462214e-02f, -5.39933369e-02f, 5.08992113e-02f, -2.91624311e-02f, 7.69729400e-03f, -7.84259588e-02f, 1.03015313e-02f, -3.57580185e-02f,
  6.07651770e-02f, -2.34709531e-02f, -3.56623717e-02f, 9.07734968e-03f, 3.36105824e-02f, -3.91484462e-02f, 5.50063029e-02f, 2.93098073e-02f, 5.88584170e-02f, -6.74455911e-02f,
  1.65743809e-02f, -1.18818861e-02f, 6.32261578e-03f, -1.26273083e-02f, 4.48939130e-02f, 9.44969878e-02f, 1.95019394e-02f, -2.76987031e-02f, 7.42705017e-02f, -2.52559222e-02f,
  -6.02413490e-02f, 1.72475427e-01f, -1.57779664e-01f, -4.05576266e-03f, 3.49004082e-02f, 5.75660057e-02f, -1.71049386e-02f, -4.64227842e-03f, -2.79638153e-02f, -5.82085848e-02f,
  -5.46845561e-03f, 3.96556780e-02f, -4.91228998e-02f, -1.11682694e-02f, 1.93829145e-02f, 2.14352552e-02f, -7.75449127e-02f, -6.04070127e-02f, -4.84841093e-02f, -9.29372758e-02f,
  3.44295129e-02f, -5.85835502e-02f, -1.41178355e-01f, 2.31791083e-02f, -4.99050990e-02f, 2.32758727e-02f, -1.14066996e-01f, 2.33143624e-02f, -9.16476697e-02f, -2.33867064e-01f,
  -1.33028701e-01f, 4.36815433e-02f, -4.47921343e-02f, -8.91436934e-02f, -6.93839490e-02f, -3.52500826e-02f, -5.38991503e-02f, 6.24338165e-02f, 4.46377769e-02f, -9.59013999e-02f,
  -9.09868106e-02f, 2.76338272e-02f, -6.74996004e-02f, -4.98196781e-02f, 1.10679567e-01f, -1.08764870e-02f, -1.20909829e-02f, 5.44202328e-02f, 8.27665702e-02f, 1.00124918e-01f,
  3.74782942e-02f, -5.32775298e-02f, -4.74655889e-02f, 6.88856915e-02f, 3.38891521e-02f, -4.34603915e-02f, 3.31201814e-02f, 4.46034148e-02f, 6.45488650e-02f, 1.81441363e-02f,
  -1.62784845e-01f, -1.66522667e-01f, 9.49348584e-02f, -9.82008129e-02f, -1.14902548e-01f, 2.36977339e-02f, -9.90025401e-02f, -7.50691518e-02f, -8.99531320e-03f, -7.29581490e-02f,
  -1.05120435e-01f, 5.74148558e-02f, -1.01037487e-01f, 2.34189779e-02f, -5.60757853e-02f, -3.01693007e-02f, -8.60532746e-02f, -9.19270739e-02f, -7.03000501e-02f, 1.22361572e-03f,
  -7.67396092e-02f, -5.39666265e-02f, -1.56295717e-01f, -7.12468755e-03f, 1.53369494e-02f, -7.88401365e-02f, -4.45479527e-02f, -4.76996340e-02f, -6.80730715e-02f, -6.56417012e-02f,
  1.97568331e-02f, -2.64230315e-02f, -7.98615068e-02f, -6.13906272e-02f, 5.89604303e-02f, 5.45652136e-02f, 1.91538166e-02f, 1.18555231e-02f, 8.00793245e-02f, -4.80246954e-02f,
  4.94507216e-02f, -6.22114614e-02f, 3.16781132e-03f, 3.32847126e-02f, -1.83834303e-02f, -6.92897290e-02f, 1.02988400e-01f, 1.72262304e-02f, -3.79489474e-02f, -2.79242229e-02f,
  3.91136203e-03f, -2.05873512e-02f, 1.95020251e-02f, 3.02956365e-02f, -3.17151845e-02f, -3.06367781e-02f, -4.22061495e-02f, 4.42361124e-02f, 4.83646430e-02f, 6.94394186e-02f,
  8.08030218e-02f, 9.22777355e-02f, -1.20008178e-01f, 4.42124270e-02f, -9.32930782e-03f, -1.44445780e-03f, -8.00892115e-02f, -1.21126708e-04f, -4.58625145e-02f, -8.27558264e-02f,
  -8.53710249e-02f, 5.65933958e-02f, -1.09372032e-03f, 4.04053666e-02f, -7.26713687e-02f, -6.53239116e-02f, -7.01191798e-02f, -1.02274463e-01f, -8.87107700e-02f, 1.49970343e-02f,
  8.74792412e-02f, 1.78005546e-02f, -3.61466445e-02f, 2.03056615e-02f, -7.94465169e-02f, -7.53459558e-02f, -1.23674661e-01f, -8.14860463e-02f, -4.22284640e-02f, 1.90882105e-02f,
  8.12840536e-02f, -1.44703053e-02f, -3.30657400e-02f, -7.97355622e-02f, -5.90394922e-02f, -1.41036749e-01f, -7.15355426e-02f, 2.05146428e-02f, -4.88013178e-02f, 9.44169145e-03f,
  1.44679189e-01f, 1.62553176e-01f, 1.25897378e-01f, 9.76812690e-02f, 2.08177976e-02f, 1.11818407e-02f, 6.84149414e-02f, -4.05988581e-02f, -2.18415949e-02f, -1.19358756e-01f,
  -1.04281999e-01f, -3.90046537e-02f, 5.91061823e-02f, -7.14108124e-02f, 2.43529473e-02f, -6.61531389e-02f, -5.97346202e-02f, -3.05244997e-02f, -2.21961439e-02f, -8.49111453e-02f,
  1.11472175e-01f, -3.56853828e-02f, 7.02511892e-02f, 7.83026218e-02f, 7.65720680e-02f, -7.02863261e-02f, -3.53222676e-02f, -7.03927800e-02f, 1.98805351e-02f, -1.07931666e-01f,
  -2.21486129e-02f, 3.04675438e-02f, -5.42816184e-02f, -3.90326492e-02f, -8.91705081e-02f, 1.05331568e-02f, -4.43658531e-02f, -4.36717942e-02f, 5.52055836e-02f, -9.90786403e-02f,
  1.54495211e-02f, -4.38946337e-02f, 8.06359574e-02f, -7.24727884e-02f, 5.56409806e-02f, 2.44569425e-02f, 4.03103186e-03f, -1.18047632e-01f, 6.96084574e-02f, 7.01139942e-02f,
  2.45695077e-02f, -3.36995237e-02f, 3.83596160e-02f, 6.16458356e-02f, 7.73566514e-02f, 6.51438311e-02f, 1.48281911e-02f, 1.69188865e-02f, 8.25082790e-03f, -5.55443577e-02f,
  -6.96198046e-02f, -5.27781770e-02f, 2.12524123e-02f, 2.97720879e-02f, -4.87557054e-03f, -2.17488650e-02f, 6.43913448e-02f, -6.35786280e-02f, 3.01351883e-02f, -7.00404197e-02f,
  -8.13427195e-02f, 2.41760369e-02f, 1.71435997e-02f, -6.45694211e-02f, 5.91725782e-02f, 5.00146076e-02f, 5.78167289e-02f, -7.87626281e-02f, -9.44261476e-02f, -2.94681527e-02f,
  6.70480952e-02f, 1.19624987e-01f, 7.12742731e-02f, 8.77657086e-02f, 1.10121639e-02f, 1.01868184e-02f, -1.75680667e-02f, -9.67095271e-02f, -8.42166319e-02f, -4.57894988e-03f,
  -2.42652893e-02f, 7.00818980e-03f, 5.68871126e-02f, -1.11553567e-02f, 3.13088894e-02f, 1.53089864e-02f, -2.28994377e-02f, 2.21947394e-02f, 8.49883407e-02f, -2.36174464e-02f,
  -7.75120482e-02f, 1.71479601e-02f, 2.54771914e-02f, 6.36873543e-02f, 8.13468471e-02f, 9.56180096e-02f, -7.56821968e-03f, 3.70000675e-02f, 3.40891369e-02f, 1.05498731e-01f,
  -5.24701327e-02f, -1.05050430e-01f, 5.03325500e-02f, -4.05151397e-02f, 1.71157904e-02f, -3.59925255e-02f, 2.17820313e-02f, -3.75944073e-03f, 4.79560383e-02f, -1.20186791e-01f,
  -9.77681726e-02f, 2.14346703e-02f, 6.94768922e-03f, 2.04228964e-02f, 2.28276700e-02f, -5.41804470e-02f, -1.52201742e-01f, -4.26375680e-02f, -4.47882488e-02f, 4.36437614e-02f,
  -2.77792569e-02f, 4.51881401e-02f, 8.98978114e-03f, -1.06888950e-01f, 4.66979071e-02f, -8.39319453e-02f, -1.07607655e-01f, 2.08930876e-02f, 5.35596721e-02f, -1.05631851e-01f,
  -6.66386634e-02f, 9.55303684e-02f, 7.46444315e-02f, 1.09832454e-03f, 5.26221693e-02f, 2.87849251e-02f, -4.44881432e-02f, -4.29522917e-02f, -3.82120116e-03f, -3.46302018e-02f,
  -3.73575203e-02f, 7.25129247e-02f, 3.97461057e-02f, -9.84008610e-03f, 9.28586125e-02f, -5.72560728e-02f, 6.98415115e-02f, 6.39355779e-02f, -6.85939491e-02f, -4.36293818e-02f,
  1.63675174e-02f, -4.48537897e-03f, -1.80370528e-02f, 6.55225888e-02f, 2.62091383e-02f, 5.96202165e-02f, 7.57763162e-02f, -4.23878022e-02f, -1.15981326e-02f, -3.08873667e-03f,
  6.94191176e-03f, 5.32343723e-02f, -6.98804483e-02f, 7.02607706e-02f, 4.46766131e-02f, 5.17110825e-02f, -6.40289560e-02f, -8.14003199e-02f, 3.73404138e-02f, 4.08926383e-02f,
  5.79517893e-02f, 6.43049031e-02f, -3.96929421e-02f, 4.68420871e-02f, -1.04163334e-01f, -3.20309848e-02f, -1.36496741e-02f, -3.45390267e-03f, -1.08774059e-01f, 1.39139360e-03f,
  7.97439367e-02f, 1.02659002e-01f, 2.99289599e-02f, -2.58250087e-02f, -5.29377684e-02f, -3.06309443e-02f, -1.37399733e-02f, 2.96704359e-02f, 7.30137472e-05f, -6.17789701e-02f,
  -1.90624390e-02f, -6.23635994e-03f, -1.09355867e-01f, 4.14374634e-04f, -3.53629291e-02f, -4.21934202e-02f, 5.32658435e-02f, 4.63660583e-02f, -4.43342589e-02f, -6.59598485e-02f,
  8.16730335e-02f, 2.49153618e-02f, 5.71811050e-02f, 8.15982744e-02f, -9.09136832e-02f, -5.21597788e-02f, -7.62976781e-02f, -3.31165493e-02f, 2.32641343e-02f, -1.74329383e-03f,
  -8.26114044e-02f, -1.08672403e-01f, 3.30065042e-02f, -1.44436313e-02f, 3.39415781e-02f, 1.77514460e-02f, -1.32846296e-01f, -8.94294903e-02f, -1.21579707e-01f, -1.37153521e-01f,
  -1.59851074e-01f, 2.81715766e-02f, 4.57566790e-02f, -1.07453622e-01f, 2.43736599e-02f, -7.71211386e-02f, 5.94557263e-02f, -3.44156735e-02f, 2.90250760e-02f, 8.69862437e-02f,
  -5.64244092e-02f, -1.43419340e-01f, -3.47152241e-02f, -5.28302155e-02f, -2.28651497e-03f, 2.05162503e-02f, -8.57698843e-02f, -8.85439068e-02f, -1.54943109e-01f, -1.35980397e-01f,
  -8.12890306e-02f, -1.89286266e-02f, -1.96174294e-01f, 1.45543721e-02f, -3.27500328e-02f, -1.70097321e-01f, -1.25093409e-03f, -1.65597573e-01f, -1.26036674e-01f, -1.53424755e-01f,
  -3.22404429e-02f, -3.16158012e-02f, -7.65472800e-02f, -1.09327987e-01f, 3.56038404e-03f, 3.72823402e-02f, -9.40573737e-02f, -7.96350185e-03f, 8.41708556e-02f, 7.68689066e-02f,
  -5.82298562e-02f, -7.92149082e-03f, -7.56513923e-02f, -1.07067958e-01f, 3.79583724e-02f, 4.65875901e-02f, -8.63820240e-02f, 7.88457226e-03f, -6.95656762e-02f, -2.36396287e-02f,
  -4.49860208e-02f, -1.31414026e-01f, -3.76020260e-02f, -1.62753090e-02f, 2.15744097e-02f, -1.03445642e-01f, -8.80826935e-02f, -5.42100705e-02f, 5.22493757e-03f, -1.03223026e-01f,
  -2.94448193e-02f, 6.94253221e-02f, 1.01327924e-02f, -6.32033795e-02f, 2.98302490e-02f, -1.00351963e-02f, 1.39997271e-03f, 7.06164986e-02f, -3.35104875e-02f, 7.50378286e-03f,
  5.31146079e-02f, 9.98739526e-02f, -1.05147641e-02f, -4.20321152e-02f, 5.34598529e-02f, 2.01278161e-02f, -1.11670827e-03f, 3.09650600e-02f, -6.00594580e-02f, -7.18395039e-02f,
  -1.32999877e-02f, 3.03972047e-02f, -1.75592192e-02f, 7.46529847e-02f, 3.68739069e-02f, -5.44573553e-02f, -6.29873350e-02f, -6.14642464e-02f, 6.51165694e-02f, 6.70103952e-02f,
  -1.13431536e-01f, -5.81510775e-02f, -3.25092711e-02f, -1.19109429e-01f, -3.55254188e-02f, 6.40352368e-02f, 8.04194957e-02f, 3.15520726e-02f, -7.79853091e-02f, 3.24021988e-02f,
  2.09373236e-02f, -5.06070033e-02f, -6.56754449e-02f, -9.50820968e-02f, 1.37944408e-02f, -4.86185439e-02f, -5.46338782e-02f, 3.25874658e-03f, -7.02565685e-02f, -6.58667609e-02f,
  7.17673525e-02f, -1.02964349e-01f, -1.15768179e-01f, 3.70276757e-02f, 3.41471247e-02f, -2.48015877e-02f, -3.36944051e-02f, -1.32630125e-01f, -4.97530513e-02f, -5.96165508e-02f,
  2.48964250e-01f, -2.75291502e-03f, -6.75151795e-02f, 1.45862132e-01f, 1.03974432e-01f, -4.10723425e-02f, 3.89181003e-02f, -6.99714646e-02f, 1.60299212e-01f, 1.15628317e-01f,
  2.54605055e-01f, 2.36742064e-01f, 1.82134792e-01f, 9.21828225e-02f, -4.56712432e-02f, 3.55517380e-02f, -1.17143482e-01f, -2.48967484e-02f, 1.16101608e-01f, 4.29212674e-02f,
  1.22484602e-01f, -3.03122383e-02f, 1.41794076e-02f, 6.08703084e-02f, 2.52456684e-03f, 1.23579390e-01f, 2.45455522e-02f, -4.61494736e-02f, -1.06306691e-02f, -5.34263067e-02f,
  1.50647685e-01f, -2.81342585e-02f, -2.59458274e-02f, 9.03628021e-02f, 3.37251239e-02f, -1.29114464e-01f, 2.36405768e-02f, -6.26781657e-02f, -2.60696337e-02f, 2.28533130e-02f,
  3.54629308e-02f, -6.31851330e-03f, -1.32325552e-02f, -1.06916567e-02f, -5.74633963e-02f, -5.05827554e-02f, 2.34475657e-02f, -9.57369953e-02f, 2.94443779e-02f, 1.83378067e-02f,
  5.49667329e-02f, 1.02490470e-01f, 3.73846386e-03f, -1.21020421e-01f, -6.77356571e-02f, -1.54118275e-03f, -1.16094254e-01f, -1.09369755e-01f, 2.33473592e-02f, -9.67622623e-02f,
  1.29207119e-01f, 1.04218669e-01f, 6.98612183e-02f, 7.26126954e-02f, 8.26058611e-02f, 4.28733826e-02f, -7.49066696e-02f, 9.53845456e-02f, 1.11065842e-02f, -8.42685401e-02f,
  8.20156783e-02f, -4.13563885e-02f, 1.87660158e-02f, 9.76968706e-02f, 1.00580953e-01f, -6.84395134e-02f, -7.73403980e-03f, -1.58144943e-02f, 1.01720750e-01f, 1.13732209e-02f,
  1.14148714e-01f, 7.46951625e-02f, 3.04126237e-02f, -8.06763470e-02f, 1.01955071e-01f, -3.63991447e-02f, -5.53074963e-02f, -1.95671618e-02f, 9.56407115e-02f, 3.50588262e-02f,
  5.35598248e-02f, 1.09962635e-01f, 9.56191197e-02f, -3.54560055e-02f, 3.99617404e-02f, 3.25621814e-02f, 9.76039842e-02f, -1.01648919e-01f, 2.95430012e-02f, -6.08266108e-02f,
  1.89550221e-02f, -3.70564647e-02f, -8.69701654e-02f, -9.46785659e-02f, -6.99663237e-02f, -4.03132923e-02f, -2.08279341e-02f, -1.69569887e-02f, 5.56017347e-02f, -1.07746691e-01f,
  -7.15676844e-02f, 3.63113768e-02f, 6.00185730e-02f, -5.15222773e-02f, -4.47772518e-02f, 8.83199871e-02f, -2.00054031e-02f, 4.01236266e-02f, -5.03473133e-02f, -8.93893689e-02f,
  -1.32457674e-01f, -1.22744806e-01f, -8.12961161e-02f, -1.54050365e-01f, -4.56457399e-02f, -3.13714030e-04f, -5.33014573e-02f, 3.09161115e-02f, 5.16258762e-04f, -6.99685588e-02f,
  1.94692519e-02f, 4.18969691e-02f, -7.99457505e-02f, 8.55864137e-02f, 8.42197910e-02f, -5.60080409e-02f, -1.25733027e-02f, 1.27701904e-03f, 3.27551141e-02f, 8.76289830e-02f,
  6.12847842e-02f, 7.30070705e-03f, 1.31395794e-02f, -1.03894159e-01f, -1.15323491e-01f, -8.83153155e-02f, -7.25077614e-02f, -9.80595648e-02f, 4.21122677e-04f, -5.66354282e-02f,
  -1.23215303e-01f, -5.73110059e-02f, -2.02976167e-02f, -1.43515924e-02f, -8.86365771e-02f, 5.45453578e-02f, -3.38959321e-02f, -2.12133490e-02f, -7.41228685e-02f, -5.51954806e-02f,
  6.79084584e-02f, 4.10584174e-02f, -9.09310952e-02f, 8.41256082e-02f, -1.89894643e-02f, -2.55802734e-04f, 1.13828843e-02f, 5.86605258e-02f, -5.49813397e-02f, 6.96307868e-02f,
  -4.70879711e-02f, -7.16625080e-02f, -9.02713537e-02f, -3.58790196e-02f, 7.84407854e-02f, -4.64938805e-02f, -2.58248281e-02f, 6.75128475e-02f, 1.45326788e-02f, -1.40890434e-01f,
  5.48766218e-02f, 5.39508462e-02f, 5.67237400e-02f, 2.29288358e-02f, -2.80371290e-02f, 4.96155582e-02f, -1.01874799e-01f, 5.81158735e-02f, 5.74088190e-03f, -7.40625262e-02f,
  -1.47493770e-02f, -4.56085876e-02f, -3.51381972e-02f, -4.39368151e-02f, -4.25309911e-02f, -9.19996649e-02f, -7.86168203e-02f, -4.11171205e-02f, 4.16425243e-02f, 7.56005868e-02f,
  3.52458563e-03f, 5.74870361e-03f, 1.57473795e-02f, 4.68056202e-02f, 2.23741177e-02f, -9.50957388e-02f, 7.39611611e-02f, 7.58225024e-02f, -4.07107621e-02f, -6.01824857e-02f,
  -4.12203036e-02f, 2.60687806e-02f, -1.02353595e-01f, 5.95996119e-02f, -6.91819265e-02f, -5.74174337e-03f, 3.33494768e-02f, 8.67075399e-02f, -4.13574278e-02f, 4.89117093e-02f,
  4.20545749e-02f, -7.67968372e-02f, 3.10153738e-02f, 7.27122054e-02f, -6.60525411e-02f, 4.36608680e-02f, -8.64058640e-03f, 6.06095269e-02f, -5.71989305e-02f, -7.74459541e-02f,
  -2.42248513e-02f, 1.96825862e-02f, -4.27473038e-02f, -3.68418135e-02f, 5.79854995e-02f, -5.38083129e-02f, -1.08103231e-01f, -9.77203697e-02f, -6.72401190e-02f, -1.07286749e-02f,
  -3.37588079e-02f, 3.20633017e-02f, -9.30014253e-03f, -6.68400973e-02f, 4.21968400e-02f, 1.24910967e-02f, -8.65993276e-02f, -2.05933731e-02f, -8.64204466e-02f, 2.36510225e-02f,
  2.31272588e-03f, 6.77481443e-02f, 3.98177434e-07f, 5.55450004e-03f, 2.54617333e-02f, 8.25315714e-03f, -9.96715799e-02f, -1.26999253e-02f, -6.19394295e-02f, -1.25492245e-01f,
  -5.58312349e-02f, -6.18584491e-02f, 1.77661106e-02f, 5.39115258e-02f, -9.34973639e-03f, 5.34246154e-02f, 5.81134744e-02f, 3.61861624e-02f, 6.41247258e-02f, 6.54611662e-02f,
  4.20288034e-02f, -7.62662441e-02f, 5.11174882e-03f, -4.14729938e-02f, 1.37460912e-02f, 6.61374703e-02f, 3.17980647e-02f, -6.34292737e-02f, -8.35110713e-03f, -1.29465489e-02f,
  1.26848528e-02f, -6.95214868e-02f, 8.27626213e-02f, -4.30695713e-03f, -1.70683898e-02f, -3.30987386e-02f, 3.61890085e-02f, -9.41999331e-02f, -5.47569878e-02f, -4.48259600e-02f,
  -6.98596984e-02f, -7.25140944e-02f, 5.24455681e-02f, -6.46466091e-02f, -1.17801148e-02f, -6.04905225e-02f, -2.88535152e-02f, -4.87069413e-02f, 5.87611040e-03f, 7.87311718e-02f,
  2.94062793e-02f, 2.54653096e-02f, -9.96979922e-02f, -1.10624833e-02f, -5.71090132e-02f, 8.79329741e-02f, -2.04798009e-04f, 6.28693476e-02f, -3.10825761e-02f, 1.67987254e-02f,
  1.33424532e-02f, -6.17484525e-02f, 7.98422247e-02f, -5.98516352e-02f, 2.48676986e-02f, 1.84023175e-02f, -5.74589670e-02f, 1.45874463e-03f, 5.57168685e-02f, -9.26143453e-02f,
  6.93900064e-02f, -5.01689222e-03f, -6.22596703e-02f, -8.31514746e-02f, -4.49131280e-02f, -5.60772717e-02f, -2.93399673e-03f, 7.67318578e-03f, -6.67166933e-02f, -2.11421214e-02f,
  1.64390102e-01f, -4.75791059e-02f, 2.60077193e-02f, 7.58140683e-02f, -1.01153649e-01f, 1.33659579e-02f, 6.25170255e-03f, -4.40530516e-02f, -9.70079675e-02f, -8.86795968e-02f,
  5.26147112e-02f, -8.68895799e-02f, 8.28781351e-02f, 5.86894825e-02f, 9.00436938e-03f, 3.81528847e-02f, 3.20012532e-02f, -8.33274052e-02f, -1.98788475e-02f, -7.10837916e-02f,
  -5.95891513e-02f, -1.54031878e-02f, 8.22617710e-02f, 1.09099150e-01f, -6.26227856e-02f, -4.10310196e-04f, 9.15250704e-02f, 1.01059146e-01f, -2.27331673e-03f, 1.01145744e-01f,
  -6.09767549e-02f, -2.06879489e-02f, -1.11347288e-02f, -1.21090829e-01f, -6.04682192e-02f, 8.41428861e-02f, -3.88976820e-02f, -4.01814468e-02f, 1.44589934e-02f, -7.69794956e-02f,
  3.81519757e-02f, -1.13548182e-01f, -1.42309129e-01f, 1.97980143e-02f, 5.44149131e-02f, -9.23495069e-02f, -4.83390838e-02f, -1.55120403e-01f, 3.24863158e-02f, 1.78980138e-02f,
  -7.41685703e-02f, -2.90204794e-03f, -1.54866710e-01f, -8.69482532e-02f, -7.11842179e-02f, -1.32356942e-01f, -8.52320194e-02f, -1.25480056e-01f, -7.48352632e-02f, -6.58852085e-02f,
  1.30741652e-02f, 6.93386570e-02f, 2.05572564e-02f, -2.45138332e-02f, 1.96840074e-02f, 7.77806342e-02f, -4.28410545e-02f, -1.08673051e-02f, 9.75308642e-02f, 8.33515748e-02f,
  -5.59073221e-03f, 1.66197885e-02f, 1.79606192e-02f, 4.73992676e-02f, 9.92193595e-02f, -9.84364469e-03f, 6.28506318e-02f, -2.26741433e-02f, 2.44054198e-02f, 9.98367667e-02f,
  -2.21385527e-02f, 9.39821377e-02f, -5.95675036e-02f, 9.81608704e-02f, -3.81618403e-02f, -9.25369503e-04f, -2.29405076e-03f, 1.07684642e-01f, 5.13060205e-02f, -7.71003962e-02f,
  5.83034381e-02f, 5.43656908e-02f, -1.75036993e-02f, -1.91744196e-03f, -1.66478548e-02f, -1.22259902e-02f, 1.82919353e-02f, 7.15457425e-02f, 7.43829980e-02f, -7.27550238e-02f,
  5.78681938e-02f, -3.43710370e-02f, -1.45307984e-02f, -7.74410069e-02f, 4.63051610e-02f, -5.57855377e-03f, -3.90489101e-02f, 1.82189941e-02f, -6.01337999e-02f, 2.37041041e-02f,
  -5.33628324e-03f, 6.38495833e-02f, -4.56178226e-02f, 5.11943176e-02f, -1.98986921e-02f, 9.90248919e-02f, -6.59962669e-02f, 2.98462715e-02f, 1.09927217e-02f, 1.65250078e-02f,
  -3.76673192e-02f, 1.79184582e-02f, -1.24972828e-01f, -1.53690269e-02f, -8.69118646e-02f, 3.03074270e-02f, 2.15142276e-02f, 5.04236855e-02f, 1.05592925e-02f, 4.77068126e-02f,
  6.41282722e-02f, -5.77907972e-02f, 1.64091568e-02f, 1.01468585e-01f, -5.66046275e-02f, -3.63729745e-02f, -2.37652976e-02f, 3.47952321e-02f, -6.16118638e-03f, 9.10592824e-02f,
  5.17284945e-02f, 4.76727970e-02f, -4.71815616e-02f, -2.42170766e-02f, 9.40317735e-02f, -1.15789168e-01f, 4.35173586e-02f, 2.68583149e-02f, 2.90383976e-02f, -1.40051484e-01f,
  -2.07102984e-01f, -2.13610735e-02f, -7.42620742e-03f, -1.34138763e-01f, 2.01687813e-02f, -1.13444394e-02f, -7.32035413e-02f, 2.08735298e-02f, 4.08028439e-02f, -1.30372778e-01f,
  -6.65031672e-02f, -1.00860052e-01f, -1.26506895e-01f, -3.65318991e-02f, 5.06539121e-02f, -6.25894731e-03f, -1.66800097e-01f, -1.05375230e-01f, 1.40467063e-02f, -7.07640499e-02f,
  -9.35100392e-02f, -2.76417360e-02f, -1.01764658e-02f, -6.52337968e-02f, -4.65616509e-02f, -1.47869200e-01f, -1.11682966e-01f, 1.38252811e-03f, -1.14241950e-01f, -1.68532282e-01f,
  2.85094939e-02f, -5.68845123e-02f, -4.54942584e-02f, -6.73642680e-02f, -1.18500367e-02f, -6.89864531e-03f, 1.96208935e-02f, -3.99930961e-02f, 5.30764088e-02f, -2.70272568e-02f,
  2.16114912e-02f, -3.52634229e-02f, -7.09867328e-02f, 5.51394969e-02f, -6.21064613e-03f, -4.67269532e-02f, -1.00814886e-01f, -5.57595752e-02f, 2.77600512e-02f, 7.67852878e-03f,
  -3.31252217e-02f, -1.04717538e-01f, -1.29702598e-01f, 9.77003109e-03f, -1.98271461e-02f, 4.56357782e-04f, 5.14526060e-03f, -7.72207081e-02f, 4.90245819e-02f, -1.49675891e-01f,
  6.42578602e-02f, -5.37048876e-02f, -2.50952672e-02f, 1.95433628e-02f, -1.83766931e-02f, -3.00447997e-02f, -1.18158311e-02f, -8.32327234e-04f, 4.56519015e-02f, -2.46355329e-02f,
  8.45427159e-03f, -6.31255563e-03f, -4.62234206e-02f, 6.57628402e-02f, 6.20092861e-02f, -5.74756302e-02f, -5.38754426e-02f, -9.06234905e-02f, -7.91560709e-02f, -9.52567998e-03f,
  2.22877711e-02f, -6.21598437e-02f, -7.21672550e-02f, 2.73496937e-03f, 2.03673337e-02f, -4.84734811e-02f, 3.11506316e-02f, 2.30539078e-03f, -6.15466200e-02f, -2.15125810e-02f,
  -4.40629013e-02f, -2.01564897e-02f, -5.02772070e-02f, 4.04707063e-03f, -7.67081678e-02f, 6.54600114e-02f, 2.61706673e-02f, 8.05617198e-02f, -4.95358184e-02f, 6.85739517e-02f,
  -5.66366725e-02f, 6.38796762e-02f, -9.74588320e-02f, 5.48006818e-02f, 6.65846914e-02f, 6.40900061e-02f, 2.30654459e-02f, -5.17298877e-02f, -8.73737037e-02f, -3.29219997e-02f,
  -7.25836307e-02f, -1.26533225e-01f, -5.15509173e-02f, -3.11226789e-02f, -7.23595843e-02f, -1.03210241e-01f, -9.45300385e-02f, -7.02268779e-02f, -7.87769631e-02f, -1.21548653e-01f,
  2.73169354e-02f, -1.62893146e-01f, 1.33599562e-03f, -1.17478237e-01f, 1.46074854e-02f, -6.50534704e-02f, 1.22806188e-02f, -5.72065413e-02f, -5.32957874e-02f, -2.11452004e-02f,
  -1.19645678e-01f, 6.79771304e-02f, -5.17259687e-02f, 5.72734280e-04f, -6.88630417e-02f, -1.16688758e-01f, 4.07435372e-02f, 4.54948172e-02f, 2.47904286e-02f, -7.78826373e-03f,
  5.54121137e-02f, -6.06221817e-02f, -2.65577994e-02f, -3.80576961e-03f, -6.81956038e-02f, -9.95692834e-02f, -1.22950844e-01f, -1.45172909e-01f, -1.04033105e-01f, -3.01754698e-02f,
  -1.04965180e-01f, 3.21852006e-02f, 4.33613732e-03f, 1.28194718e-02f, -9.35327932e-02f, 6.56876042e-02f, 9.20424759e-02f, -9.88934636e-02f, 5.45786647e-03f, 2.96875518e-02f,
  -1.48040550e-02f, -2.93869339e-02f, 3.24499467e-03f, -8.36856812e-02f, -4.52320687e-02f, 9.54351947e-02f, -6.43345434e-03f, -3.77759337e-03f, -4.89986166e-02f, -1.27270669e-02f,
  1.46687916e-02f, 4.31190319e-02f, 8.40766057e-02f, 3.17756981e-02f, -3.53936590e-02f, 3.86712030e-02f, -4.23161611e-02f, 8.85793120e-02f, -2.47689728e-02f, -6.77216575e-02f,
  -8.51405188e-02f, 3.67111415e-02f, 4.63578738e-02f, -8.01450908e-02f, 1.30773345e-02f, 5.30922934e-02f, 3.15211341e-02f, -4.52638678e-02f, 5.11959381e-02f, -7.94979036e-02f,
  -7.63913766e-02f, 5.19504696e-02f, 2.83952523e-02f, -8.13043937e-02f, 3.09221856e-02f, 5.55430725e-02f, -1.88321453e-02f, -1.00907393e-01f, -8.93463269e-02f, 5.48083633e-02f,
  9.83734727e-02f, -3.38924639e-02f, -3.98031846e-02f, -6.87973276e-02f, -1.14300586e-02f, -4.80224229e-02f, 2.74831504e-02f, -2.07536574e-02f, -7.36640319e-02f, -1.26623944e-03f,
  -1.82562113e-01f, 5.61239198e-02f, 4.43189405e-02f, 8.44905749e-02f, 7.56003708e-02f, 5.16865514e-02f, 2.91753635e-02f, -8.80397260e-02f, 1.17986007e-02f, -2.86423154e-02f,
  5.72165810e-02f, -7.15814084e-02f, -7.65722319e-02f, 3.74111496e-02f, 1.06683243e-02f, 7.04168454e-02f, 3.88757102e-02f, 5.02487905e-02f, 8.52199271e-03f, -7.26772845e-02f,
  -4.67532203e-02f, 1.27572998e-01f, 8.07995498e-02f, 5.96718043e-02f, 9.45436284e-02f, 8.04793984e-02f, -5.93836838e-03f, 4.43671457e-02f, 1.45048887e-01f, 5.22155985e-02f,
  9.11994313e-04f, -4.28377092e-02f, 4.47067879e-02f, -1.15422048e-02f, 1.10938601e-01f, 9.49337184e-02f, 3.44672985e-02f, 1.36978310e-02f, -1.55839780e-02f, 8.82626176e-02f,
  -1.93674993e-02f, -1.21741608e-01f, -1.13875367e-01f, -2.56631803e-02f, 3.27272490e-02f, 7.17576593e-02f, 2.98746191e-02f, -1.11256868e-01f, 5.60852326e-02f, 5.99605963e-02f,
  -6.67131841e-02f, -1.18800782e-01f, 1.04511259e-02f, -1.02258086e-01f, -1.18084505e-01f, -1.08614132e-01f, -1.36499954e-02f, -4.20659408e-02f, -7.57339746e-02f, -8.70857835e-02f,
  -2.46954374e-02f, 7.48089701e-02f, -8.36731195e-02f, -1.28058314e-01f, -1.66541655e-02f, -4.67607602e-02f, 1.41073111e-02f, -7.83461332e-02f, -4.89217155e-02f, 7.84590393e-02f,
  -6.64876832e-04f, 2.55825501e-02f, -9.37237293e-02f, 1.05075287e-02f, -3.36256772e-02f, -6.28739223e-02f, 6.88862428e-02f, 7.80519843e-03f, 5.16810715e-02f, 3.75832580e-02f,
  -1.06287479e-01f, 4.82617356e-02f, -2.18353923e-02f, 4.05635126e-02f, 7.81946704e-02f, -2.89393496e-03f, -3.11869029e-02f, -8.24188069e-02f, 1.00162905e-02f, -7.31485784e-02f,
  2.04670578e-02f, -1.33136641e-02f, -4.73687984e-02f, -4.45039943e-02f, 6.81250542e-02f, -3.33584808e-02f, 2.68084090e-02f, 5.50623275e-02f, -6.30963817e-02f, 5.36929667e-02f,
  2.38641948e-02f, 3.55016887e-02f, -2.90933736e-02f, 1.16661554e-02f, -4.91841274e-05f, 5.71078658e-02f, 4.50136662e-02f, -7.71210939e-02f, -3.68663929e-02f, 6.64793998e-02f,
  -3.64452749e-02f, -6.72618952e-03f, -4.29679565e-02f, -1.40858758e-02f, -6.23163059e-02f, -3.78371552e-02f, 2.13907734e-02f, -1.57874525e-02f, 1.85709987e-02f, 3.73403654e-02f,
  -1.41702235e-01f, 9.96821448e-02f, -8.32970962e-02f, -1.10336691e-01f, 5.61085381e-02f, 2.90705040e-02f, 3.44650559e-02f, -6.98668584e-02f, -3.47094238e-02f, -7.23372027e-02f,
  -2.05177795e-02f, 3.94346491e-02f, -1.00573696e-01f, -1.05578005e-01f, 4.34017880e-03f, -1.21595515e-02f, -8.64443481e-02f, -1.67399235e-02f, -1.09893598e-01f, -9.64650139e-02f,
  -1.63811874e-02f, -1.26419112e-01f, 9.67115164e-03f, -1.24757044e-01f, -6.05792850e-02f, -1.41271293e-01f, -1.16568856e-01f, 3.56700495e-02f, -1.21677294e-02f, -5.74564002e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -6.66863169e-04f, -2.52375528e-02f, 7.11730644e-02f, -5.29884212e-02f, 3.53680886e-02f, 2.06028685e-01f, -2.39621121e-02f, -3.99063453e-02f, 3.13293599e-02f, 4.48264256e-02f,
  7.83347189e-02f, 2.11458117e-01f, 2.37216149e-02f, 1.97431426e-02f, 1.44723237e-01f, 7.75140077e-02f, 8.92756805e-02f, 2.65927054e-03f, 5.77442683e-02f, 3.12708355e-02f,
  -5.21950908e-02f, -1.06241518e-04f, 4.37639803e-02f, 4.28605638e-02f, 3.47937644e-02f, 2.57546529e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.19976921e-02f, 2.60445122e-02f, -1.86711386e-01f, 6.25327602e-02f, -4.73485552e-02f, -7.35159963e-02f, 3.45116593e-02f, -2.71767050e-01f, -1.88638210e-01f, 4.91374359e-03f,
  -1.81601644e-02f, 8.22567120e-02f, 7.89909810e-02f, -1.32301012e-02f, -2.02542037e-01f, -2.00671598e-01f, -4.48311232e-02f, 2.39969883e-02f, 1.26450043e-02f, -9.28271115e-02f,
  -2.14658633e-01f, -3.95199209e-02f, -1.77638549e-02f, -7.89995492e-02f, 2.83529405e-02f, -9.48342457e-02f, 5.21300212e-02f, -1.88924670e-01f, 1.69518277e-01f, -1.49762295e-02f,
  9.18364078e-02f, -2.49918237e-01f, 6.65906593e-02f, -1.89000353e-01f, -3.05714905e-01f, -2.49970853e-01f, -1.30860284e-01f, -1.44829765e-01f, -2.81992942e-01f, -4.52393666e-02f,
  -4.17774208e-02f, 2.98245773e-02f, -1.42591372e-01f, -4.78899926e-02f, 9.79620218e-02f, -7.59577826e-02f, 1.58637598e-01f, 1.50867859e-02f, -5.04897118e-01f, 1.76584423e-02f,
  -1.30840130e-02f, 1.42988637e-01f, 1.41949013e-01f, -1.39154002e-01f, -1.20815217e-01f, 1.55087471e-01f, 2.98451990e-01f, 2.31713027e-01f, 2.44440660e-01f, 9.51420367e-02f,
  2.00677350e-01f, 1.21464208e-02f, 7.18442164e-03f, 4.63903248e-02f, 8.05370230e-03f, -1.69292241e-01f, -3.24265689e-01f, 2.28292882e-01f, -6.94686407e-03f, 1.05088800e-01f,
  -8.64712149e-02f, 8.08629841e-02f, 1.05844580e-01f, 2.02282071e-01f, -1.30319580e-01f, -2.09512129e-01f, 1.34904593e-01f, -4.96175364e-02f, -3.39047402e-01f, 4.05981876e-02f,
  5.84644042e-02f, -6.73492178e-02f, -2.63954252e-01f, 2.85582636e-02f, 9.93912742e-02f, 1.73845619e-01f, -2.92377919e-01f, 2.42668524e-01f, 1.18878059e-01f, 3.06070030e-01f,
  1.07920386e-01f, -8.69462565e-02f, 2.15387836e-01f, -1.34176999e-01f, 1.06037542e-01f, -1.67560317e-02f, -8.38418305e-02f, 1.42388061e-01f, 1.52131915e-01f, -4.03814256e-01f,
  5.57786345e-01f, 3.70293483e-02f, -6.20735362e-02f, 2.35506818e-01f, 2.81376075e-02f, -2.07452811e-02f, 8.74996483e-02f, 1.36280581e-01f, -1.17420986e-01f, -1.27189890e-01f,
  8.56207088e-02f, -2.26142555e-02f, 6.40735805e-01f, -4.27177250e-02f, 1.42833874e-01f, 1.72616661e-01f, 3.81312966e-02f, 1.65108308e-01f, -1.22032858e-01f, 2.28357404e-01f,
  2.60495469e-02f, -4.11165506e-03f, 2.51492739e-01f, -1.33315608e-01f, 2.74121791e-01f, 2.66228884e-01f, 1.12379208e-01f, 7.14411438e-02f, -9.05254781e-02f, -1.47462755e-01f,
  -8.57604370e-02f, 5.60653210e-02f, 8.80458504e-02f, 7.26489723e-02f, 1.52745336e-01f, 2.29279473e-01f, 1.22332603e-01f, 3.53278667e-02f, 6.28850684e-02f, -1.58795804e-01f,
  3.88788432e-02f, 7.83352554e-02f, 1.06636040e-01f, 1.69348285e-01f, 1.23073399e-01f, 1.73923522e-02f, 1.16911650e-01f, 1.42664731e-01f, -3.23815525e-01f, -1.39131501e-01f,
  2.90915947e-02f, -1.41586646e-01f, 4.25794125e-02f, 2.20277354e-01f, 1.38893515e-01f, 1.52588889e-01f, -1.39546961e-01f, 1.39041826e-01f, -5.81711391e-03f, -9.56299249e-03f,
  -1.21433651e-02f, -1.76808596e-01f, 8.94717053e-02f, 8.16165507e-02f, -5.37165068e-02f, -7.08094053e-03f, -6.69248253e-02f, 8.19400884e-03f, 1.35476692e-02f, 6.09102994e-02f,
  4.24843021e-02f, -1.66564018e-01f, 6.97563812e-02f, -8.79159495e-02f, -2.48740271e-01f, -2.85768956e-02f, -2.65495390e-01f, -4.34491366e-01f, -2.54803896e-02f, 3.13867569e-01f,
  1.36139616e-01f, -4.51748036e-02f, -3.12982976e-01f, 3.32919270e-01f, 1.62346736e-01f, 9.70680341e-02f, -2.78234221e-02f, 2.32937504e-02f, -6.53328970e-02f, -2.05131546e-01f,
  1.61259204e-01f, -5.24907447e-02f, -3.09968144e-01f, -2.72636205e-01f, 1.59085974e-01f, -2.52551675e-01f, -1.68402735e-02f, -1.71146065e-01f, -4.81476486e-02f, -9.42945033e-02f,
  1.14032425e-01f, 4.29752111e-01f, 4.52920675e-01f, 5.41082136e-02f, -1.11196399e-01f, -1.32850096e-01f, -1.44234344e-01f, -1.99834824e-01f, 6.35045767e-02f, -7.82606378e-02f,
  -5.87410815e-02f, 1.43169418e-01f, 1.71593174e-01f, 4.35283780e-01f, 6.13433197e-02f, -1.10787928e-01f, -3.98393124e-01f, 3.37754577e-01f, 2.65220612e-01f, 1.90672025e-01f,
  -2.11202264e-01f, 7.22199008e-02f, -4.12193567e-01f, 2.32725307e-01f, -2.27483720e-01f, 4.70356643e-01f, 4.59923536e-01f, -2.18407780e-01f, 3.82959098e-01f, -1.37225017e-01f,
  1.89700216e-01f, -2.53360569e-02f, -1.77791148e-01f, 4.70301732e-02f, 9.97144915e-03f, 3.50451201e-01f, -2.12396652e-01f, 4.94010076e-02f, -4.93643843e-02f, 4.27185625e-01f,
  3.61210674e-01f, 8.68111104e-02f, -8.32586884e-02f, -2.62254272e-02f, 7.42123201e-02f, -2.16107875e-01f, 2.56404191e-01f, -4.40440066e-02f, -1.17261387e-01f, 4.57073778e-01f,
  -1.85633302e-02f, -1.28409490e-02f, -6.93739355e-02f, -1.14971831e-01f, 2.50747204e-01f, -8.49304199e-02f, -7.84690827e-02f, 7.26698786e-02f, 1.81834355e-01f, -5.24857938e-02f,
  1.66970566e-01f, 2.78258021e-03f, -1.04872391e-01f, -5.70633672e-02f, 2.26776123e-01f, 5.06230295e-02f, -7.83502311e-02f, 2.42664050e-02f, 2.92400457e-02f, 9.84844118e-02f,
  3.84393707e-02f, 2.53578294e-02f, 6.14855736e-02f, -1.15245596e-01f, 8.50752816e-02f, 2.18485650e-02f, 3.62377971e-01f, 1.67608753e-01f, -1.25772193e-01f, -7.88828135e-02f,
  8.49682093e-02f, -9.26921368e-02f, -5.18785045e-03f, -7.28121847e-02f, 1.54438034e-01f, 4.21435535e-02f, 1.90641906e-03f, -1.41733199e-01f, 1.39478028e-01f, 5.58884554e-02f,
  5.34889735e-02f, -1.09250881e-02f, 2.25122124e-02f, 1.12596393e-01f, 3.84739377e-02f, 2.09873959e-01f, 1.15842251e-02f, -1.26532331e-01f, 9.22842175e-02f, 3.83761302e-02f,
  1.79536045e-01f, -9.61316936e-03f, 6.20536134e-02f, -2.41624285e-02f, -1.36324987e-02f, 1.31212279e-01f, -3.10119819e-02f, 7.17728063e-02f, 1.59825981e-01f, 3.28840107e-01f,
  -4.26161766e-01f, -7.93609992e-02f, 6.00587465e-02f, 1.13525234e-01f, 3.44998986e-01f, -3.34919006e-01f, -3.55888680e-02f, -9.21459273e-02f, 2.22114295e-01f, 1.38514146e-01f,
  2.03598961e-01f, -1.65353104e-01f, 4.07808602e-01f, -8.46229270e-02f, 2.78733075e-01f, -9.45331305e-02f, 1.87101796e-01f, -2.45694280e-01f, 4.03878778e-01f, 4.50676709e-01f,
  -4.74791974e-02f, 1.11246057e-01f, 1.96008235e-01f, -1.06643952e-01f, -3.11363012e-01f, -1.48089647e-01f, -1.70761708e-03f, -1.25442058e-01f, -3.99035931e-01f, -1.10578783e-01f,
  3.52307060e-03f, 6.86029345e-02f, 6.32703155e-02f, 1.32381365e-01f, -1.77986518e-01f, -3.72259468e-01f, -1.59721211e-01f, 4.28438894e-02f, 2.22033232e-01f, 3.66144776e-01f,
  6.59168065e-02f, 6.55625835e-02f, 2.25053653e-01f, -1.58370793e-01f, 4.53594178e-01f, -2.69687533e-01f, 1.35281727e-01f, -3.88067998e-02f, -1.08970888e-02f, 5.97046837e-02f,
  7.61609897e-03f, 2.07596365e-02f, 9.45213810e-02f, -1.07480034e-01f, 1.87021133e-03f, -5.70810065e-02f, 4.41878401e-02f, -3.14058065e-01f, -1.11012109e-01f, 4.45124477e-01f,
  -6.94177151e-02f, -1.49586573e-01f, 2.93710351e-01f, 9.36766565e-02f, 4.07721065e-02f, 5.43230809e-02f, -5.87293971e-03f, -9.00338888e-02f, 3.27403694e-02f, -1.01013154e-01f,
  -7.57502690e-02f, -4.13993262e-02f, -9.47702378e-02f, -1.66576542e-02f, -2.15896130e-01f, 5.13397865e-02f, 2.06451029e-01f, 2.49881130e-02f, -2.53317922e-01f, 7.63739571e-02f,
  -2.49989238e-02f, 1.70292720e-01f, 3.64863593e-03f, 8.69485661e-02f, -1.15927778e-01f, -2.36651719e-01f, -1.47097148e-02f, -1.05938405e-01f, 2.30304241e-01f, 2.39981227e-02f,
  -1.79823577e-01f, 7.31280074e-02f, 5.00968657e-02f, -1.24505974e-01f, 2.23053433e-02f, -3.49790722e-01f, 4.72071208e-02f, 3.75244580e-03f, 1.66880582e-02f, -6.22053258e-03f,
  1.17509663e-01f, 1.41016245e-01f, 2.75895059e-01f, 1.34773524e-02f, -1.44229114e-01f, -1.37570724e-02f, -1.80324465e-01f, 9.36286673e-02f, -1.34496838e-01f, 8.87235776e-02f,
  -1.98544608e-03f, 2.63594631e-02f, 7.51255602e-02f, -2.14734092e-01f, 6.06890060e-02f, -8.72467924e-03f, 1.49970651e-01f, 1.85796227e-02f, -4.17487651e-01f, 1.10866860e-01f,
  -1.12754181e-01f, 5.10955267e-02f, 2.57263333e-01f, -1.70609802e-01f, 1.15332477e-01f, -3.54459763e-01f, -2.40828723e-01f, -1.48124397e-01f, -3.24921235e-02f, 4.80691224e-01f,
  -2.10206255e-01f, -7.32321888e-02f, -1.96918100e-01f, 2.16669098e-01f, -5.24868481e-02f, 2.94600651e-02f, -3.45347613e-01f, 2.53369510e-02f, 2.75476754e-01f, -1.32272067e-02f,
  1.09558471e-03f, 5.00367880e-01f, 5.34967035e-02f, 8.15789551e-02f, -2.52650023e-01f, -2.12774724e-01f, 3.37241709e-01f, -5.44437841e-02f, -1.70965359e-01f, -2.04912424e-01f,
  -5.43386815e-03f, 1.33126095e-01f, 1.23557769e-01f, 2.95907706e-01f, -1.95898548e-01f, 4.67617124e-01f, -1.06630526e-01f, -2.59126574e-01f, 1.48629531e-01f, 5.32427765e-02f,
  2.60018528e-01f, -1.43811136e-01f, 1.76617339e-01f, -1.46078333e-01f, 2.85479724e-01f, -8.02350640e-02f, 1.44852117e-01f, -9.84896794e-02f, -1.36612132e-01f, -2.47407407e-01f,
  7.01275766e-02f, -3.25644374e-01f, -9.53110456e-02f, 3.12876850e-01f, -3.88260335e-01f, -2.48331606e-01f, -2.16809008e-03f, -7.39163980e-02f, 4.60999906e-02f, -9.00269523e-02f,
  8.47875103e-02f, -1.94165617e-01f, -4.79924353e-03f, -3.22883204e-02f, 8.83015916e-02f, -1.10491462e-01f, 1.19694166e-01f, -8.43686536e-02f, -4.51747216e-02f, 3.24775815e-01f,
  1.08499490e-01f, 5.98362200e-02f, -4.17466052e-02f, 9.09843855e-03f, 2.47476131e-01f, -4.23743464e-02f, 1.61945015e-01f, -1.22247383e-01f, 2.29474917e-01f, 1.89198807e-01f,
  1.53638363e-01f, 2.02191249e-01f, 1.28426909e-01f, -4.65180129e-02f, 2.87526190e-01f, -1.42765746e-01f, 1.42119572e-01f, 9.54468623e-02f, 4.22529727e-02f, 1.20726913e-01f,
  -9.89370421e-02f, -3.03472340e-01f, 2.23528799e-02f, 1.51182279e-01f, -1.80925503e-01f, -2.28814967e-02f, -2.97206104e-01f, 3.05998456e-02f, 1.38496533e-01f, 2.38092113e-02f,
  -1.23803206e-01f, 2.74100099e-02f, -2.15952441e-01f, 2.05987260e-01f, -4.15517800e-02f, -3.60226221e-02f, -4.45086882e-02f, 2.46746019e-02f, -1.69280767e-01f, 1.29398346e-01f,
  -3.70631844e-01f, -1.35113597e-01f, 1.50852829e-01f, 1.65651411e-01f, -3.02873738e-02f, -1.76441520e-01f, -6.84762970e-02f, -1.78139836e-01f, -4.48169522e-02f, -5.39048575e-02f,
  3.11632127e-01f, 2.94306487e-01f, 1.47498157e-02f, -9.19117853e-02f, -4.80699763e-02f, 9.35414732e-02f, -5.14065549e-02f, -1.77478567e-02f, -6.46124706e-02f, -1.56084716e-01f,
  1.78211212e-01f, 1.07780993e-01f, -1.64186135e-01f, -2.32179374e-01f, 1.64370835e-01f, -1.70440763e-01f, 1.24829605e-01f, -2.15750098e-01f, -1.26511648e-01f, -1.62447065e-01f,
  1.20843679e-01f, 5.77634722e-02f, 3.91342521e-01f, 2.12051630e-01f, 4.11169603e-02f, 1.65654808e-01f, 2.64615715e-01f, -3.15985501e-01f, -6.52845204e-02f, -1.53864369e-01f,
  -2.28601396e-01f, 4.16013122e-01f, -9.05432552e-03f, -3.38756919e-01f, 1.00665137e-01f, -3.31890076e-01f, -1.13999262e-01f, 1.10973343e-01f, 2.85284109e-02f, 3.06785375e-01f,
  2.13897303e-01f, -3.16318780e-01f, 3.11074495e-01f, -1.26026437e-01f, -7.92417452e-02f, -3.11770350e-01f, 3.26117933e-01f, 6.28175884e-02f, -3.36975753e-01f, 1.23454966e-01f,
  1.22358099e-01f, 8.07233602e-02f, -2.88844943e-01f, -2.67876059e-01f, 1.27248198e-01f, -3.37654978e-01f, 1.23208009e-01f, -2.71178991e-01f, -1.90524027e-01f, -3.41724843e-01f,
  6.06618077e-02f, -3.39544192e-02f, -4.62781191e-01f, 3.21501821e-01f, 9.78200417e-03f, -4.99492139e-02f, 1.74327731e-01f, 3.94006595e-02f, 1.58359706e-02f, 2.64253393e-02f,
  9.32573974e-02f, -2.03595124e-02f, 1.18772879e-01f, 3.71519811e-02f, -2.97724247e-01f, -2.27514934e-02f, -1.19148582e-01f, -8.60043690e-02f, 2.50424713e-01f, -8.88651833e-02f,
  2.80043459e-03f, 8.30463469e-02f, 3.13707799e-01f, 5.57657145e-02f, -1.42918363e-01f, 9.23422053e-02f, 8.04854929e-02f, 1.72766998e-01f, -5.59303164e-02f, 5.47996126e-02f,
  -1.64446197e-02f, -1.55964680e-03f, -3.03606242e-01f, 2.49113530e-01f, 1.70193329e-01f, 5.25810905e-02f, -1.46950006e-01f, 1.12827972e-01f, 8.00894275e-02f, 1.03842154e-01f,
  -4.33152020e-02f, -1.74664916e-03f, -6.44461578e-03f, 4.42004092e-02f, 2.70564318e-01f, 3.44047286e-02f, 1.61245063e-01f, -2.06139982e-01f, 1.65633261e-02f, -2.36914959e-02f,
  -3.18691581e-02f, 2.87776709e-01f, 5.03851138e-02f, 7.30882213e-02f, -6.19573146e-03f, -3.64461057e-02f, 8.37074220e-02f, 2.50978470e-02f, -2.81003807e-02f, 1.41367093e-01f,
  -3.47410254e-02f, 1.53625086e-01f, 3.11972890e-02f, 1.84449747e-01f, 2.60830611e-01f, 2.87033916e-02f, -2.00717314e-03f, 7.68133905e-03f, 1.11105666e-02f, 1.76943615e-01f,
  -9.35819522e-02f, 2.40622148e-01f, -8.63576401e-03f, 5.03552007e-03f, 1.56929865e-01f, 4.22976650e-02f, 2.46393412e-01f, 2.80035287e-01f, 4.08148430e-02f, 2.26875514e-01f,
  -6.62533864e-02f, 4.80372936e-01f, 1.94347396e-01f, -3.99814904e-01f, 3.18982244e-01f, -2.72978395e-01f, 1.04629606e-01f, -3.31557006e-01f, 2.59073585e-01f, 2.09876418e-01f,
  -2.29399130e-01f, 3.19920868e-01f, -2.91429043e-01f, -1.17604151e-01f, -3.89823318e-01f, -8.73889327e-02f, -5.83920851e-02f, -1.68209463e-01f, -1.77464202e-01f, 3.37456971e-01f,
  -1.65576383e-01f, -2.98829347e-01f, -5.40606976e-01f, -5.79649568e-01f, 1.57428890e-01f, 2.33877217e-03f, -2.41206050e-01f, 4.31896225e-02f, -1.98986202e-01f, -1.56127904e-02f,
  -4.54481877e-02f, -1.57918528e-01f, -4.71072942e-02f, 3.26958358e-01f, -9.88853127e-02f, -2.77746208e-02f, 1.19121097e-01f, -1.64796442e-01f, 3.65994185e-01f, 4.47025478e-01f,
  -4.98474156e-03f, -2.43704751e-01f, -2.33990937e-01f, -1.79358723e-03f, -1.08220771e-01f, 6.74084350e-02f, -1.84116945e-01f, 3.07444155e-01f, -3.41840088e-01f, -2.61584342e-01f,
  4.10834670e-01f, -1.26063362e-01f, -9.81173962e-02f, -1.25291437e-01f, 1.34476051e-01f, -6.36437461e-02f, -7.96496049e-02f, 1.06644332e-01f, 6.11541346e-02f, 3.43614444e-02f,
  -4.42804955e-02f, 6.62955455e-03f, 7.62473885e-03f, -1.69350386e-01f, -7.86476135e-02f, 7.42806271e-02f, -2.15939358e-01f, 7.12212101e-02f, 4.32611816e-02f, -1.61163166e-01f,
  1.30334213e-01f, 1.37778088e-01f, -4.08745632e-02f, 1.29700929e-01f, -2.42665000e-02f, -1.59609318e-02f, -9.17900875e-02f, -1.40678093e-01f, -1.01158880e-01f, -4.08127941e-02f,
  -9.42872018e-02f, -5.77192716e-02f, -5.13860285e-01f, 8.29761922e-02f, -3.31210978e-02f, 1.47283986e-01f, -3.96910787e-01f, -6.70875087e-02f, -3.10193300e-02f, 6.78804740e-02f,
  1.32075250e-01f, 9.55545455e-02f, 1.26064137e-01f, 8.33954886e-02f, -3.37762505e-01f, 4.58829999e-02f, -2.26291344e-01f, 6.11054637e-02f, -3.17223608e-01f, -2.21317500e-01f,
  1.63807005e-01f, 1.25871850e-02f, -1.81932852e-01f, 1.97130531e-01f, 3.23967412e-02f, -9.49564129e-02f, 9.74874198e-02f, -3.63976769e-02f, -7.16355219e-02f, 4.41807248e-02f,
  1.36413686e-02f, 3.75224538e-02f, 4.91969213e-02f, 1.67864617e-02f, 8.75612870e-02f, 2.52445210e-02f, -2.48587266e-01f, -2.54533798e-01f, -6.48567677e-02f, 3.23344357e-02f,
  1.68255985e-01f, 4.95995255e-03f, -1.05752595e-01f, 7.56194443e-02f, 5.22061959e-02f, 1.90829188e-01f, 1.43768504e-01f, 1.36143222e-01f, 9.77499112e-02f, 1.71024144e-01f,
  -2.09473863e-01f, 3.55955213e-01f, 3.54770124e-01f, -5.04681826e-01f, -5.24696298e-02f, -1.98684350e-01f, 2.33510017e-01f, -5.56251287e-01f, 1.48449078e-01f, 1.12312660e-01f,
  -2.26038564e-02f, -5.64268120e-02f, 3.68066467e-02f, -1.78251892e-01f, 3.68049443e-01f, -3.24092120e-01f, -6.56285658e-02f, -4.05658692e-01f, 9.23458710e-02f, 4.28991497e-01f,
  -3.96769643e-01f, 5.50269987e-03f, 2.52982348e-01f, 2.70122349e-01f, 3.93829532e-02f, 1.78584680e-01f, 2.67555058e-01f, -9.84035805e-02f, 8.76212493e-02f, 6.72451481e-02f,
  4.28851023e-02f, 1.31997347e-01f, -1.84893042e-01f, -3.45910251e-01f, 1.70062929e-01f, 1.52582839e-01f, -1.83688566e-01f, -3.43368292e-01f, -2.57813215e-01f, 1.02299459e-01f,
  -2.77628638e-02f, 2.27978831e-04f, 1.39513493e-01f, 5.13416469e-01f, 1.74689204e-01f, 3.25180739e-02f, -1.27873486e-02f, -3.27566475e-01f, -3.83395068e-02f, -2.99251173e-02f,
  -7.58294240e-02f, 1.20069362e-01f, -1.44145146e-01f, -3.58158126e-02f, -4.68322523e-02f, -8.27798620e-02f, -8.58421177e-02f, 1.36523485e-01f, 4.83270697e-02f, 2.35650256e-01f,
  -6.98227137e-02f, 3.31643939e-01f, -5.05137146e-02f, 3.12829949e-02f, -5.09378500e-02f, -5.77732064e-02f, -7.34486654e-02f, 1.16471676e-02f, -1.37824386e-01f, -2.55756825e-01f,
  -7.42864683e-02f, -6.07494824e-02f, -6.15430064e-02f, -1.39885917e-01f, 3.63244452e-02f, -3.23294327e-02f, 7.39596039e-03f, -2.56685346e-01f, -1.04167096e-01f, 5.17088063e-02f,
  -8.64461586e-02f, -1.15410835e-01f, 6.34894297e-02f, 9.78392139e-02f, 1.33675992e-01f, 6.00322150e-02f, 8.79793391e-02f, 1.44151106e-01f, 2.68111769e-02f, -4.75866944e-02f,
  -7.57525787e-02f, 2.47190520e-02f, -1.32776694e-02f, -1.71957370e-02f, 1.70016974e-01f, 3.08216121e-02f, -2.30683926e-02f, -1.13276534e-01f, -3.53915468e-02f, -3.50126401e-02f,
  -1.02434374e-01f, -6.72141910e-02f, -8.71753246e-02f, 2.27382910e-02f, -2.19241813e-01f, -2.26187855e-01f, 4.07279320e-02f, -6.55763894e-02f, -1.36638090e-01f, -2.13371873e-01f,
  -5.36671877e-02f, -1.76896885e-01f, 3.70826088e-02f, 9.46938619e-02f, -2.38482237e-01f, 4.92193922e-02f, 2.61752773e-02f, 8.23824406e-02f, -2.17378557e-01f, -1.55266777e-01f,
  -1.28268734e-01f, -3.24182026e-02f, -2.81908810e-01f, -1.96521923e-01f, -2.29047298e-01f, -3.25354189e-01f, -1.71458349e-01f, -2.08003875e-02f, -2.74060637e-01f, 2.26030275e-01f,
  2.64656190e-02f, 3.93936366e-01f, 2.46826977e-01f, 1.30310252e-01f, 2.59148151e-01f, 1.25084296e-01f, -7.57764503e-02f, -1.40710890e-01f, 2.89916173e-02f, 1.64356217e-01f,
  1.71741784e-01f, 2.27267444e-01f, -8.28832984e-02f, 2.15321958e-01f, 2.58870095e-01f, -4.19125818e-02f, -1.97344169e-01f, 1.97939724e-01f, -1.04972497e-01f, -6.81832656e-02f,
  -2.11809978e-01f, 1.59688309e-01f, 8.14913958e-02f, -3.07316273e-01f, -7.07722083e-02f, 2.59301603e-01f, -1.49939701e-01f, -6.47761151e-02f, 5.88173233e-03f, 2.83446103e-01f,
  -2.75788367e-01f, 1.59350976e-01f, 2.89213032e-01f, 1.20552322e-02f, -7.38967732e-02f, -2.13590175e-01f, 2.46185437e-02f, 4.54024374e-02f, 2.12475657e-01f, 2.36823738e-01f,
  2.65618473e-01f, -4.07196820e-01f, 1.78433463e-01f, -3.06923985e-01f, -1.98186800e-01f, 2.61667520e-01f, -3.38548720e-01f, -2.81724244e-01f, -1.10673115e-01f, -2.62244809e-02f,
  2.25309312e-01f, -3.57651487e-02f, -6.35924861e-02f, -8.02655593e-02f, 2.46636271e-01f, 2.85931438e-01f, -1.06243148e-01f, 2.61178941e-01f, -1.28627732e-01f, -1.40878260e-01f,
  6.23708649e-04f, -6.98459446e-02f, -8.61603543e-02f, 1.28429592e-01f, -2.93242233e-03f, -1.96357314e-02f, -7.00730830e-03f, -9.15442035e-02f, 3.00054960e-02f, -1.01974225e-02f,
  -1.14918925e-01f, -3.41607593e-02f, -1.57501921e-01f, -3.58829349e-02f, 9.93940607e-02f, 1.76307797e-01f, 2.68873751e-01f, -2.72269212e-02f, -5.93861081e-02f, -2.75339670e-02f,
  5.00970371e-02f, -1.19346641e-01f, 9.22611952e-02f, -2.77391467e-02f, -5.42085953e-02f, 1.32013559e-01f, 6.57410994e-02f, -2.03022674e-01f, -2.27062449e-01f, 6.48715422e-02f,
  -6.32473174e-03f, 1.52815610e-01f, -1.51164964e-01f, 6.89658150e-02f, -5.66424392e-02f, 1.39128000e-01f, -4.35419381e-03f, -2.77133137e-02f, -8.32568109e-02f, -1.82423919e-01f,
  4.94639724e-02f, 1.86434388e-02f, 1.15111485e-01f, -8.60938057e-02f, 3.28397639e-02f, 9.54170451e-02f, -7.51989707e-03f, -1.79318897e-03f, -2.53458843e-02f, -1.56010883e-02f,
  6.03751764e-02f, 1.74944311e-01f, 1.15601219e-01f, 3.51910554e-02f, -2.49821749e-02f, -5.71160726e-02f, 1.17075026e-01f, -8.24442953e-02f, -5.10786427e-03f, 8.05079862e-02f,
  -1.66225880e-01f, 4.02768739e-02f, 1.85916752e-01f, -9.66743007e-02f, -4.42985035e-02f, 2.87490301e-02f, -8.80726278e-02f, -5.01218103e-02f, -2.44802177e-01f, 3.35293710e-01f,
  -9.36730281e-02f, 1.90776214e-02f, -3.73794436e-01f, -3.26494545e-01f, -3.63275021e-01f, -3.22394788e-01f, 1.44181415e-01f, -2.57204056e-01f, -3.36882114e-01f, 3.98081392e-01f,
  1.67501971e-01f, 2.65853286e-01f, 6.59182668e-02f, -4.68115121e-01f, -1.68751284e-01f, 4.76346493e-01f, -5.32679372e-02f, 3.57765295e-02f, 8.66656005e-02f, -1.94266930e-01f,
  -2.06914648e-01f, -2.36165926e-01f, -3.13923389e-01f, 2.22308055e-01f, -3.13312680e-01f, -1.30268618e-01f, 2.28079468e-01f, -1.37084842e-01f, -1.57614365e-01f, -4.67901260e-01f,
  4.24455404e-02f, -1.03729062e-01f, -1.28282443e-01f, -1.58958501e-04f, 1.69588864e-01f, -3.59269306e-02f, -2.36958876e-01f, 3.18690747e-01f, -8.13734382e-02f, 2.71986574e-01f,
  1.91344872e-01f, 1.85722098e-01f, -2.95180410e-01f, 3.75197828e-02f, 2.63861507e-01f, -1.65729791e-01f, 3.19479972e-01f, 5.49288020e-02f, 8.89521278e-03f, 7.44198561e-02f,
  -1.83767706e-01f, -1.38032278e-02f, -3.48139666e-02f, -1.23372246e-02f, 4.36012410e-02f, -1.50332093e-01f, -1.20233580e-01f, -1.44218504e-01f, 2.82909632e-01f, -1.67796448e-01f,
  -1.48926705e-01f, -1.34558916e-01f, -1.77817926e-01f, 2.18635029e-03f, -9.07773450e-02f, -5.86567745e-02f, -1.29275650e-01f, -6.13846853e-02f, -1.23644203e-01f, -1.82036251e-01f,
  1.98877543e-01f, 3.86152864e-02f, -6.19725063e-02f, 3.28042693e-02f, 8.32971185e-02f, 2.41340369e-01f, -4.63648438e-02f, -1.35375395e-01f, 1.08818606e-01f, -6.27668574e-02f,
  4.01320815e-01f, -6.63594753e-02f, 8.78082886e-02f, -1.78315118e-01f, -9.47801769e-02f, -1.20110624e-01f, -8.23432580e-03f, -4.86441590e-02f, 8.37327689e-02f, -1.33532220e-02f,
  2.11420387e-01f, -3.16722989e-01f, 3.16179127e-01f, 1.81201354e-01f, 8.58225450e-02f, -2.49830317e-02f, 3.06837950e-02f, -2.99211174e-01f, -4.60544117e-02f, 7.20750615e-02f,
  1.28640383e-01f, 3.23614925e-02f, 4.31787670e-02f, -7.23883137e-02f, -8.73287246e-02f, 1.40860667e-02f, 7.75478482e-02f, 5.82649037e-02f, 4.88971621e-02f, 1.35938004e-01f,
  1.16490126e-01f, -4.12869334e-01f, -7.89899901e-02f, -1.47302076e-01f, 1.68028753e-02f, -1.59041971e-01f, 2.66661700e-02f, -5.08945398e-02f, 6.02829382e-02f, 1.76234439e-01f,
  4.97580990e-02f, 6.85007945e-02f, -1.52211487e-01f, -5.35136685e-02f, -8.20929408e-02f, 2.21915662e-01f, 2.90754378e-01f, -3.82835627e-01f, 2.73863494e-01f, 2.04080358e-01f,
  2.14341179e-01f, 1.86623693e-01f, 3.88910323e-01f, 5.71880257e-03f, 2.66150773e-01f, 1.12485133e-01f, 4.29787219e-01f, -3.79790328e-02f, -4.19394761e-01f, -3.35340738e-01f,
  -2.56037146e-01f, 3.93271260e-02f, 4.93083119e-01f, -4.41247225e-02f, -4.26355839e-01f, -9.96843725e-02f, 8.67718980e-02f, 1.23922043e-01f, 4.67970073e-01f, 2.48327926e-01f,
  1.41661301e-01f, -2.38437667e-01f, 5.71056046e-02f, -6.63466975e-02f, 4.30196583e-01f, 3.16821754e-01f, -1.19192630e-01f, 2.47204065e-01f, -3.94408107e-01f, -1.82011366e-01f,
  -1.45336568e-01f, -2.30814386e-02f, -4.66622263e-01f, 1.66133717e-01f, 2.69287407e-01f, -1.67428399e-03f, 4.19433981e-01f, -7.86829963e-02f, 7.67289195e-03f, -2.03055903e-01f,
  -1.19986184e-01f, 1.01304859e-01f, -2.27143005e-01f, 3.87542754e-01f, -1.48595646e-01f, -2.18204539e-02f, -8.31717625e-02f, 1.31109916e-02f, -9.80925113e-02f, -1.14804417e-01f,
  2.48661041e-01f, -1.39970444e-02f, 3.45236510e-02f, -1.01115175e-01f, -1.51590139e-01f, 1.51069656e-01f, -8.86929259e-02f, 2.72252411e-02f, -1.85990795e-01f, -1.39316693e-01f,
  1.12505695e-02f, 2.92081796e-02f, -1.24325164e-01f, 3.36560309e-01f, -1.05738342e-02f, 1.93104278e-02f, -9.78783295e-02f, -1.54143780e-01f, 3.32654864e-02f, -7.08475187e-02f,
  2.79541034e-02f, -6.03444986e-02f, -1.43730074e-01f, -9.08834040e-02f, 1.36989564e-01f, 9.92744118e-02f, 1.04395777e-01f, 7.91457519e-02f, -2.23508757e-02f, 1.37818418e-02f,
  5.44241723e-03f, 4.96744215e-02f, 5.96338734e-02f, 1.80004895e-01f, -3.94851761e-03f, -5.33887520e-02f, -1.08503722e-01f, 3.08483839e-02f, -2.17376044e-03f, -8.11758917e-03f,
  1.07595518e-01f, -1.21283114e-01f, 8.32804367e-02f, 1.13406166e-01f, -2.39076428e-02f, 1.18821204e-01f, 4.12748940e-03f, -2.09349096e-01f, 2.71113999e-02f, 4.99068573e-02f,
  1.48795487e-03f, 1.58902388e-02f, -5.06006181e-04f, 2.22445671e-02f, -2.35057846e-02f, -4.88124904e-04f, -7.44211115e-03f, -1.47871092e-01f, 9.97326821e-02f, -1.64655894e-01f,
  9.99525338e-02f, -7.54646882e-02f, -9.63815376e-02f, 1.12061813e-01f, 1.63274720e-01f, 9.97643620e-02f, 1.95737645e-01f, -1.07931562e-01f, -6.13204874e-02f, 8.48688260e-02f,
  -5.45872636e-02f, -2.29533181e-01f, 1.18953690e-01f, -2.52467901e-01f, -2.29918867e-01f, 1.32519389e-02f, -1.52543128e-01f, 1.43285483e-01f, -3.81415427e-01f, 4.08797801e-01f,
  -1.70889720e-01f, 9.17711332e-02f, 1.64191082e-01f, 1.49224743e-01f, -4.49573249e-02f, 4.60834354e-01f, 2.54065365e-01f, 3.08347046e-01f, -2.28826582e-01f, 3.33928198e-01f,
  6.08960725e-02f, -1.79983124e-01f, 2.82141536e-01f, 2.40028992e-01f, -1.51461348e-01f, -5.83272688e-02f, -8.32261816e-02f, -2.16821909e-01f, 4.45025235e-01f, -8.76187161e-02f,
  2.34213859e-01f, -1.51074165e-02f, 4.61422563e-01f, -1.26553774e-02f, 1.86510440e-02f, -4.04957712e-01f, 6.38564378e-02f, -7.76128024e-02f, 1.97357595e-01f, 4.44318876e-02f,
  3.31851423e-01f, 5.52102737e-02f, -4.15465146e-01f, -3.43560845e-01f, -1.03550099e-01f, 6.63115606e-02f, -9.54962894e-02f, -4.59206253e-02f, 3.74740213e-01f, 4.67065871e-01f,
  -2.65273377e-02f, 1.84986338e-01f, -4.70299125e-02f, -8.95208791e-02f, -8.07478055e-02f, -7.13178003e-03f, -1.64669435e-02f, -1.82179302e-01f, 1.85548868e-02f, -2.05001980e-02f,
  -9.69347283e-02f, -2.27173612e-01f, -2.47669086e-01f, -1.02434188e-01f, 3.94440554e-02f, -1.75783172e-01f, -1.27892613e-01f, -1.00389440e-02f, 1.91453636e-01f, -8.47511888e-02f,
  -8.88221189e-02f, 5.47316065e-03f, -1.24892481e-01f, 2.01583683e-01f, -4.15529683e-02f, -4.80566127e-03f, -1.12717517e-01f, -1.71002865e-01f, -1.06275767e-01f, 8.06250125e-02f,
  -1.14050798e-01f, -3.08672190e-01f, 1.67524293e-01f, 4.82317917e-02f, -7.51761124e-02f, -3.44855972e-02f, -2.12328032e-01f, 3.61149348e-02f, -2.00085063e-02f, 2.86912695e-02f,
  5.15146703e-02f, -1.16231330e-02f, 1.50197610e-01f, 3.11078727e-02f, -8.25265944e-02f, -9.07093566e-03f, 5.08696400e-02f, -2.52998006e-02f, 1.21126652e-01f, 7.10296854e-02f,
  -1.96738198e-01f, 1.11432791e-01f, 1.41754568e-01f, 5.33805266e-02f, 6.60879388e-02f, 4.64635976e-02f, -7.92125762e-02f, 3.79107259e-02f, -7.43353143e-02f, 8.33305195e-02f,
  6.30200431e-02f, 2.06486173e-02f, 8.40933695e-02f, 1.33287549e-01f, 3.80829349e-02f, -1.48419619e-01f, 2.04622582e-01f, 5.66865727e-02f, -1.17101759e-01f, 9.86706018e-02f,
  8.16372856e-02f, 1.50210187e-01f, 9.15516913e-02f, 1.19919768e-02f, 1.51605368e-01f, -2.84984082e-01f, 1.41753198e-03f, -1.13733253e-02f, -1.58836006e-03f, -3.74853939e-01f,
  -1.69305112e-02f, 1.92173854e-01f, 5.05369544e-01f, 3.49922627e-02f, -3.88456196e-01f, -3.03642243e-01f, -5.68216145e-01f, -3.68423790e-01f, 9.35750008e-02f, 4.76883166e-02f,
  -5.36844805e-02f, -1.23774432e-01f, -2.25290477e-01f, 1.42321521e-02f, -1.39286146e-01f, -2.93983549e-01f, 2.33460695e-01f, -2.27949142e-01f, 9.60139707e-02f, 2.10874528e-01f,
  -1.82007238e-01f, -3.45903069e-01f, -1.12956027e-02f, -3.03523004e-01f, -1.80760980e-01f, 1.77328989e-01f, 1.16564281e-01f, 4.40791935e-01f, 2.64283717e-01f, 3.17747653e-01f,
  2.72170212e-02f, -2.90870488e-01f, -2.56679595e-01f, -2.03565076e-01f, -2.42272075e-02f, -1.28963128e-01f, -1.84425548e-01f, 9.56846103e-02f, -1.42046794e-01f, 2.48376071e-01f,
  8.53817463e-02f, -8.50891415e-03f, -2.90115625e-01f, -2.58221924e-02f, -6.10398203e-02f, -4.96726781e-02f, -3.60306710e-01f, 3.33921313e-01f, -3.67860347e-01f, -2.54026413e-01f,
  1.23216607e-01f, -4.19263467e-02f, -4.46018763e-02f, -1.26289546e-01f, 2.70428628e-01f, 1.07478328e-01f, -2.09765490e-02f, 4.24614921e-02f, 1.44837677e-01f, 2.35760182e-01f,
  -1.82824761e-01f, -2.76630610e-01f, -7.10034147e-02f, 8.07632059e-02f, 5.77331297e-02f, -1.91717565e-01f, -5.89451604e-02f, 6.27617761e-02f, 1.19613344e-02f, -1.91566870e-02f,
  -6.08763024e-02f, -8.03843141e-02f, 7.83816352e-02f, -5.78923635e-02f, -1.87207818e-01f, 1.88929215e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.67508030e-02f, -5.26314601e-03f, 1.57981515e-02f, -7.85325542e-02f, 7.76533782e-02f, -2.12039871e-04f, -1.21237673e-01f, -3.60830761e-02f, 4.35889140e-02f, -3.44344676e-02f,
  -3.34646888e-02f, 3.16557027e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    